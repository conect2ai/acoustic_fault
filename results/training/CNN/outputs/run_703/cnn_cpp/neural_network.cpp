#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.03472775f, -0.12048473f, 0.56680530f, -0.03046563f, -0.33936927f, -0.74882805f, -0.41654119f, -0.95710838f, 
    -0.77854598f, -0.40494540f, -0.32670406f, 0.12335741f, -0.37134758f, -0.39714220f, -0.04470132f, 0.33495551f, 
    -0.22233619f, 0.27144051f, -0.36859226f, -0.34447744f, 0.12949921f, 0.29195791f, 0.69581205f, 0.11621609f, 
    -0.14109021f, 0.73646826f, 0.16340715f, 0.45368728f, 1.17864192f, 0.07011379f, -0.82925230f, -0.94795001f, 
    0.03590327f, -0.21567264f, 0.40126663f, 0.59217322f, 0.08998445f, 0.11214458f, 0.16758679f, -0.37146300f, 
    -0.11170702f, 0.19096881f, 0.17022143f, -0.24689269f, -0.22977220f, -0.31455669f, -0.38086382f, -0.03026195f, 
    0.06275395f, 0.10612701f, 0.38627839f, 0.24903379f, 0.99279249f, 0.70524877f, 0.70513457f, 0.69563919f, 
    0.06149655f, 0.49303272f, 0.51294959f, 0.58982366f, -0.57002687f, 0.46716455f, -0.44560280f, 0.23377293f, 
    -0.31086078f, 0.15655816f, 0.24210398f, -0.40943879f, -0.20528248f, -0.09302723f, -0.02111291f, 0.04954002f, 
    0.02991691f, -0.17267300f, 0.20800920f, -0.65466702f, 1.52654231f, -0.59751058f, -0.14449742f, 0.64185536f, 
    -0.29935840f, -0.70728916f, 0.06599123f, 0.01789933f, 0.46121570f, -0.23259504f, -0.38688976f, -0.23078282f, 
    0.17572832f, -0.12778780f, -0.20500466f, 0.19498400f, -0.05023558f, 0.05071398f, -0.21138443f, 0.06888616f, 
    -0.05433589f, -0.08803722f, 0.13148506f, -0.35675901f, 0.76942354f, 0.00718065f, -0.23072217f, -0.58010858f, 
    -0.78672338f, 0.58344394f, 0.57499850f, -0.07611614f, -0.21665277f, 0.57558650f, 0.51609665f, -0.56084001f, 
    -0.63250160f, -0.15916526f, -0.08154449f, -0.00843181f, 0.12756608f, 0.16765183f, -0.08534499f, 0.27216515f, 
    0.08816011f, 0.15677352f, 0.28469726f, 0.28185666f, -0.49955404f, 1.14839351f, 0.52382314f, 0.32349920f, 
    0.11875724f, -1.26319945f, 0.31616420f, 0.31046125f, 0.15660515f, -0.52778614f, 0.45521498f, 0.22676864f, 
    0.57253087f, 0.43424129f, 0.18033198f, -0.35961950f, 0.16076225f, -0.02911670f, 0.27962071f, 0.25888437f, 
    0.04174428f, -0.11169309f, 0.36424705f, 0.13453247f, -0.37272644f, -0.30111399f, -0.70672858f, -1.41424286f, 
    0.17778715f, 0.46273649f, -0.21875271f, 0.10655414f, -0.06834846f, 0.59893531f, 0.03477273f, -0.63276130f, 
    0.47031057f, 0.16656995f, -0.29595944f, 0.23776767f, -0.27030456f, 0.23542407f, 0.29249305f, -0.29126203f, 
    -0.03314956f, -0.47109103f, 0.37416583f, 0.23191202f, -0.03075499f, 0.21895987f, -0.08512831f, 1.29032886f, 
    -0.39222834f, 1.05078220f, -0.00369143f, -0.50366610f, 0.58041525f, -1.42742443f, 0.24628563f, 0.30410030f, 
    0.55694824f, -0.18507968f, -0.22080350f, -0.22772573f, -0.01964313f, -0.31332609f, -0.53333783f, -0.08499862f, 
    -0.11447822f, -0.34175700f, -0.02215062f, 0.36115935f, 0.06577379f, 0.21022360f, 0.11603081f, 0.03012053f, 
    0.67284530f, -1.18944108f, -0.66348791f, 0.63394183f, 0.85381907f, 1.13405728f, -0.01950597f, -0.00001123f, 
    0.53599423f, 0.02843386f, -0.34736869f, 0.22844587f, -0.43537092f, 0.40091610f, 0.30362713f, 0.21236940f, 
    -0.18556601f, 0.02674354f, 0.20989874f, 0.15258653f, -0.25505221f, -0.15869540f, -0.23177020f, -0.11027677f, 
    -0.03862748f, 1.24096406f, 0.54080665f, -1.16694665f, 0.28012532f, -0.31122297f, -0.52998871f, 0.17904614f, 
    0.28637564f, 0.41249555f, 0.53560877f, 0.04587010f, -0.19285797f, 0.39152306f, -0.50955284f, 0.05169348f, 
    0.05626206f, 0.08910067f, -0.13357046f, 0.03669964f, 0.48860583f, -0.44020543f, 0.06282908f, -0.16946098f, 
    0.15909541f, -0.32061961f, -0.95555210f, 0.99888277f, 0.06602513f, -0.92083770f, -0.69828117f, 0.63621283f, 
    -0.88552123f, -0.43146521f, -0.82866734f, -0.47109050f, 0.40821204f, 0.07303470f, -0.20130335f, 0.37032452f, 
    0.00757190f, -0.30561084f, 0.22456729f, -0.45395359f, 0.13714240f, 0.11883319f, 0.07436368f, 0.24282314f, 
    0.33870250f, 0.15807919f, 0.39773819f, -0.12789474f, -1.37694144f, 0.06725711f, 0.82390696f, 0.14479811f, 
    0.70589501f, 1.53222942f, -0.01288211f, 0.21410820f, 0.43325207f, -0.51866430f, 0.03162138f, -0.11521676f, 
    0.01106151f, 0.06569979f, -0.46014890f, -0.10899505f, -0.29863769f, -0.06624321f, -0.16653921f, 0.12000009f, 
    -0.02100762f, 0.02530196f, -0.12295409f, -0.10157803f, -0.42637035f, -0.41730684f, -0.62761670f, -0.44555017f, 
    0.20119539f, -0.85624218f, -0.47105688f, -0.23333706f, 0.21846685f, -0.80943966f, 0.13220930f, 0.12874407f, 
    -0.03439578f, -0.05066864f, 0.10434618f, 0.44234008f, 0.57807249f, 0.37636396f, 0.38913965f, -0.09039779f, 
    0.13868326f, 0.15505207f, -0.27089998f, 0.35130998f, 0.72399777f, -0.55867213f, -0.14259464f, 0.37058431f, 
    -0.64882886f, -0.76707041f, 0.45024279f, -0.31948844f, 0.14883505f, -0.55691224f, -0.77906728f, -0.36101425f, 
    0.04655693f, -0.69660944f, 0.24683762f, -0.05961822f, -0.13604148f, 0.56762570f, 0.26691189f, 0.14674218f, 
    -0.24419275f, 0.45238194f, -0.08898926f, -0.28427163f, -0.07867352f, -0.34935421f, -0.87531972f, 1.26499736f, 
    0.97466666f, -0.96581781f, 0.59769100f, -0.42898947f, 0.07867726f, 0.02765796f, 0.07478002f, 0.12540446f, 
    0.02610696f, 0.23881321f, -0.48256540f, 0.27507153f, -0.12066680f, -0.09328493f, -0.06050633f, -0.00586370f, 
    -0.02768490f, 0.00804464f, 0.08521533f, 0.04918684f, 0.28820577f, 0.15483116f, 0.33139816f, 1.36505330f, 
    0.73012626f, 0.04088777f, 0.93859226f, 0.88690567f, 0.40851563f, 0.35378313f, 0.33251679f, 0.60950249f, 
    0.30204681f, -0.61774743f, -0.30167881f, -0.04600869f, -0.41315061f, 0.16384017f, -0.41700119f, -0.12115925f, 
    -0.02515906f, 0.13742663f, 0.18260837f, -0.06825943f, -0.22816472f, -0.05292677f, 0.04988055f, -0.15273340f, 
    0.91919172f, 1.02428198f, 0.55647629f, 0.97865176f, 0.47276434f, 0.89959288f, 0.10463040f, -0.72933394f, 
    0.04606389f, -0.69853455f, 0.26307839f, 0.39901370f, -0.14118589f, 0.17895147f, -0.10645042f, 0.24623543f, 
    -0.25810963f, -0.00714394f, -0.04612848f, -0.13950801f, 0.39221254f, -0.18581223f, 0.24025816f, 0.11112289f, 
    0.27335185f, -0.74582195f, -0.84144485f, -1.03414404f, -0.50888902f, -0.29794827f, 0.35968289f, 0.01648217f, 
    0.39949331f, 0.74138951f, 0.41352531f, -0.24151985f, -0.38261929f, 0.36550736f, -0.16837141f, -0.59467137f, 
    -0.06769567f, 0.26762927f, 0.13653608f, -0.04891882f, -0.00368745f, -0.38714612f, -0.43390748f, -0.42476085f, 
    -0.38924733f, 0.09459063f, -0.98234540f, -0.29690582f, -0.56344402f, -0.43623066f, -0.41352120f, 0.29113072f, 
    0.16243039f, 0.21862876f, 0.64237452f, 0.19606020f, -0.42045492f, -0.41040140f, 0.08868853f, 0.23078984f, 
    0.03345313f, -0.41342071f, -0.09011042f, 0.05461906f, -0.25916943f, -0.29288167f, 0.46262786f, 0.32316068f, 
    0.33615130f, 0.59555966f, -0.22370297f, -0.79827869f, 0.76769263f, 0.64700639f, -0.11456847f, 0.50950748f, 
    0.31490070f, 0.88453394f, 0.19595845f, -0.78918308f, 0.10172034f, -0.00250387f, 0.10764445f, 0.28327844f, 
    -0.47020319f, -0.08932937f, -0.18715730f, -0.31727701f, 0.22701660f, 0.19816367f, -0.65119839f, 0.12090214f, 
    0.07975683f, 0.22881052f, 0.33191028f, 0.53668755f, 1.01469445f, -0.01150251f, 0.21722382f, -0.13540332f, 
    1.25494635f, -0.12781180f, -0.46486208f, -0.54303974f, 0.26546377f, 0.48418373f, 0.11349819f, 0.44313091f, 
    -0.05993054f, -0.19112946f, -0.14843351f, -0.12225793f, -0.18752097f, -0.13461645f, 0.26038259f, 0.20747723f, 
    0.30757788f, -0.02762792f, 0.36552072f, -0.40197864f, 0.13224357f, 0.87484437f, 0.95086437f, 1.07269561f, 
    1.09616697f, 0.22928657f, 0.30016404f, 0.42846897f, -0.40402111f, -0.66618270f, 0.18940064f, 0.29434282f, 
    0.09997371f, -0.23629615f, 0.57559007f, -0.06589583f, 0.23222071f, 0.01789812f, 0.49971607f, 0.26072887f, 
    0.07497912f, -0.00291202f, -0.00486704f, -0.17737645f, -0.27500671f, -0.04509582f, 0.05307106f, -0.24170181f, 
    0.64585513f, 0.62848610f, 0.03040925f, 0.42299241f, 0.20839334f, -0.32462049f, 0.42831650f, 0.12261795f, 
    -0.18303135f, 0.41847733f, -0.32549581f, 0.34640619f, -0.50880110f, 0.49462411f, 0.32728440f, -0.50918943f, 
    -0.43834162f, -0.16681089f, -0.26272979f, -0.78226864f, 0.24375400f, -0.05097636f, -0.43242729f, 0.42016152f, 
    -0.28148016f, 0.15070683f, 1.17106724f, 0.22401515f, 0.84755558f, 0.58515513f, -0.74511683f, -0.16392034f, 
    -0.53183150f, -0.27007169f, -0.37045890f, -0.39763731f, -0.35952887f, -0.36110643f, -0.41071934f, 0.20703351f, 
    -0.04579521f, -0.38606459f, -0.11382512f, 0.04645739f, 0.21313263f, -0.12276961f, -0.05146749f, -0.15582395f, 
    -0.25949731f, -1.09109318f, -1.09757113f, -0.69954872f, -0.38416243f, -1.09054613f, 0.39999926f, 1.03622115f, 
    -0.22230667f, 0.13372111f, 0.22609594f, -0.16819148f, 0.50712335f, 0.05046117f, 0.34277123f, -0.30422437f, 
    -0.10737832f, -0.03858418f, -0.38489342f, -0.23561674f, 0.19015186f, 0.17539747f, -0.10394966f, 0.12870628f, 
    0.15216431f, 1.10826015f, 0.27958086f, -1.01806307f, -0.40081763f, -0.34083626f, 0.08392479f, -0.31549937f, 
    -0.77671319f, -0.10588789f, -0.42800474f, -0.60754818f, -0.37133849f, 0.21488602f, 0.26087654f, -0.17539546f, 
    -0.40361384f, 0.11781358f, -0.78158551f, -0.37799156f, -0.14972478f, 0.12414440f, -0.05936016f, 0.46448460f, 
    -0.15819813f, 0.02623927f, 0.04186593f, 1.10604775f, -0.88569689f, 0.15193789f, -0.71344143f, 1.02844656f, 
    -0.58793348f, -0.41928533f, -0.12751563f, 0.05857858f, -0.00121211f, -0.09268403f, 0.24281648f, 0.42178732f, 
    -0.25116524f, -0.11782663f, -0.08986648f, 0.16719091f, -0.02250174f, 0.10734051f, -0.11842630f, -0.14797787f, 
    -0.36895230f, -0.37145743f, -0.26826003f, 0.03028193f, 0.26135069f, 0.92226774f, 0.82177168f, 0.65608776f, 
    -1.16381299f, -0.53962910f, -0.64532328f, -0.72938657f, -0.06488264f, 0.29702020f, 0.17069620f, 0.21315990f, 
    0.26355013f, 0.15737621f, 0.04067531f, 0.31395012f, 0.41609806f, -0.15550177f, 0.46758348f, 0.63745093f, 
    0.13950582f, -0.14293312f, 0.33079743f, 0.34464356f, 0.73419923f, 0.62001646f, -0.87127274f, -0.71068138f, 
    -0.69693905f, 0.89201182f, 0.87866920f, 0.06990565f, 0.42822236f, 0.52356368f, -0.03163218f, 0.04122126f, 
    -0.21544214f, -0.03393831f, -0.14078824f, 0.08087847f, -0.04891961f, -0.02103264f, -0.09830537f, 0.20304640f, 
    0.22616495f, -0.30909976f, -0.26123071f, -0.30522987f, 0.32826462f, -1.04237318f, -1.30775583f, -0.40691161f, 
    0.46444243f, 0.38891712f, 0.22178292f, 0.76502955f, 0.74228716f, 0.16135632f, -0.09357103f, 0.03510762f, 
    0.15238056f, -0.15558894f, 0.35268646f, 0.17448466f, -0.05197383f, 0.14950414f, 0.52504373f, -0.27443540f, 
    -0.06781732f, -0.26928154f, -0.26736459f, -0.09140468f, -0.21148512f, -0.17466579f, -0.59743184f, -1.28180945f, 
    -0.31384128f, -0.01235968f, -0.09109752f, -0.08350873f, 0.72849172f, -0.76024181f, 0.50989813f, 0.76793909f, 
    -0.03822540f, 0.30447707f, -0.21113282f, -0.09377719f, -0.15069667f, -0.31166071f, 0.21671951f, 0.26560372f, 
    0.24251848f, -0.06158967f, 0.10601544f, 0.39919364f, -0.34541818f, 0.32085365f, 0.42768514f, -0.99150681f, 
    0.69034284f, -0.83046389f, -0.66870970f, -0.03285423f, 0.55438060f, 0.80648410f, -0.18203375f, 0.22172424f, 
    -0.06418364f, 0.18808860f, -0.51486737f, -0.05704326f, -0.19886059f, 0.29313302f, 0.41274709f, 0.20537077f, 
    -0.01044575f, 0.24111538f, -0.36391988f, -0.01810047f, 0.07806280f, 0.33002555f, 0.42778060f, 0.59326100f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12878112f, -0.00802501f, 0.22555366f, 0.00469882f, 0.28487593f, 0.11901643f, 0.31277278f, 0.14068843f, 
    0.29175287f, 0.12434975f, 0.43136999f, 0.07446720f, 0.48058006f, 0.17391680f, 0.22147243f, 0.19121370f, 
    0.30547976f, 0.04134403f, 0.00206856f, 0.18904650f, 0.06903648f, 0.21012875f, 0.31621778f, 0.23918128f, 
    0.35574898f, 0.13802658f, 0.11642514f, 0.20723279f, 0.29504007f, 0.38357976f, 0.38653976f, 0.17061822f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20985700f, -0.10190742f, -0.05087171f, 0.21110229f, 0.11915807f, -0.04159199f, -0.08553793f, -0.05856916f, 
    -0.06228738f, 0.00339873f, 0.03874290f, -0.01570586f, 0.21363878f, -0.14780907f, -0.10567345f, 0.37821579f, 
    -0.25424743f, -0.14995666f, 0.08059369f, 0.15828867f, -0.06552394f, 0.15524243f, 0.01687743f, 0.02579811f, 
    0.05942330f, -0.08234521f, -0.04020914f, 0.22749323f, -0.16028967f, -0.18538785f, -0.06657262f, 0.05764362f, 
    0.03870211f, 0.05936591f, 0.10868724f, -0.01658924f, 0.16205060f, 0.15497246f, 0.58021933f, 0.02897504f, 
    -0.05144196f, 0.05899180f, 0.11144262f, -0.21791168f, 0.21760869f, -0.04656930f, -0.15041785f, -0.15909697f, 
    0.06435268f, -0.06022311f, 0.14036570f, -0.25975570f, -0.10758083f, 0.08897844f, -0.11000405f, -0.22501834f, 
    -0.18057309f, 0.12792730f, 0.10369317f, -0.02738754f, -0.15152907f, 0.40454772f, 0.08226764f, -0.16650718f, 
    -0.02081602f, -0.04771887f, -0.22075006f, -0.06854387f, -0.06429583f, -0.02229624f, 0.01443447f, -0.04578088f, 
    -0.30460465f, -0.03643746f, -0.13326900f, 0.15904017f, -0.04220504f, 0.02709778f, -0.00035388f, -0.04995389f, 
    0.07711270f, 0.01912613f, -0.00386576f, -0.20579399f, 0.38429609f, -0.31236625f, -0.04320522f, 0.27949148f, 
    0.02948972f, -0.03133175f, 0.08555594f, -0.04486786f, -0.32353136f, 0.02596893f, -0.15713179f, 0.07766078f, 
    0.19845088f, -0.04768282f, -0.01665601f, 0.31946906f, 0.10856201f, -0.12404335f, -0.09931742f, -0.10074940f, 
    0.09758170f, -0.10264554f, 0.01645913f, -0.18257928f, -0.23450138f, -0.13407375f, 0.03856372f, 0.01094718f, 
    -0.16627294f, -0.04733747f, -0.10759164f, 0.14810753f, -0.03326881f, 0.07988562f, 0.24574028f, 0.07578210f, 
    -0.47832209f, 0.25874150f, -0.06740978f, -0.18706025f, 0.04671412f, 0.07641861f, 0.12154512f, -0.05454558f, 
    -0.03727687f, 0.03240985f, 0.06512659f, 0.08076432f, -0.20902582f, 0.25911635f, 0.13951226f, 0.28846183f, 
    -0.07308943f, 0.00575881f, 0.12570554f, -0.04761678f, -0.08346544f, 0.03276765f, 0.05151516f, 0.12884724f, 
    -0.40900549f, -0.07673193f, -0.04315399f, 0.14944823f, 0.06272476f, -0.06197378f, 0.01900567f, 0.06853130f, 
    0.12940808f, -0.15187407f, -0.00215929f, -0.13692544f, -0.52554375f, 0.23361947f, 0.02111643f, 0.01881983f, 
    -0.03929897f, 0.02342079f, 0.00927186f, -0.06169650f, -0.10389414f, 0.14579462f, 0.15591395f, -0.12276742f, 
    -0.44629452f, 0.05366270f, 0.11220143f, -0.29294649f, 0.05730924f, 0.05277038f, 0.02249581f, -0.12641986f, 
    0.10060854f, -0.08768463f, 0.01434529f, -0.08427413f, 0.21064654f, -0.01124934f, -0.16675018f, 0.28921199f, 
    -0.23385921f, 0.08300567f, 0.01868422f, 0.11735244f, 0.00331452f, 0.15205312f, -0.00224190f, 0.15334179f, 
    0.07349345f, 0.04418895f, -0.08792730f, -0.02484084f, -0.16108193f, -0.16654214f, 0.01355383f, 0.08420830f, 
    0.00078503f, -0.05320768f, -0.00855531f, -0.10725784f, 0.28470120f, 0.19834796f, -0.27308723f, -0.33948356f, 
    0.19101414f, -0.03577776f, 0.02494166f, 0.08055988f, -0.03207239f, -0.03447795f, -0.08357859f, -0.03185960f, 
    0.16343778f, 0.13529515f, -0.17582622f, -0.06080550f, 0.09154186f, 0.05162901f, -0.03320654f, 0.12620515f, 
    0.00130130f, 0.08897474f, -0.05552180f, -0.01105197f, -0.08409853f, 0.08927470f, 0.37630662f, -0.17071892f, 
    0.04390691f, -0.17905392f, 0.07465319f, -0.18192461f, -0.07808012f, -0.05229443f, -0.08409201f, 0.05730660f, 
    0.35657302f, -0.28692320f, 0.19112211f, -0.08287571f, -0.07437959f, 0.12713157f, -0.06539520f, 0.03402366f, 
    -0.01651321f, 0.00804653f, 0.10980329f, 0.02716152f, 0.11367806f, 0.23101734f, -0.18580599f, 0.06041418f, 
    -0.31890702f, -0.11221679f, 0.15543984f, 0.07922689f, 0.07394774f, 0.02778782f, -0.07922216f, -0.02267064f, 
    -0.01392302f, -0.13001472f, -0.19533780f, 0.15671159f, 0.06385102f, -0.09213143f, -0.04018907f, -0.00376530f, 
    0.09949534f, 0.04540277f, -0.07261515f, -0.33884737f, 0.03916208f, 0.10850748f, -0.03024550f, 0.34892133f, 
    -0.16553079f, -0.05275312f, -0.07571026f, -0.05989493f, -0.12629870f, -0.00174511f, 0.03672331f, -0.01547493f, 
    -0.77012432f, 0.04915735f, -0.26454750f, -0.19454543f, 0.03161900f, -0.07975114f, -0.07867699f, -0.02059150f, 
    -0.03884229f, -0.00140767f, 0.00621713f, 0.23135020f, -0.13768092f, -0.16212891f, 0.18422291f, -0.30958515f, 
    -0.05714196f, -0.10757098f, -0.07093929f, 0.02653632f, -0.19494978f, 0.00646598f, 0.00233234f, -0.10474417f, 
    0.18412295f, -0.04954509f, 0.06569164f, -0.31253898f, -0.03048662f, -0.07986014f, 0.05019699f, -0.11127207f, 
    0.16574651f, -0.07578482f, -0.09056372f, 0.13454492f, 0.18405847f, -0.00235814f, -0.18076736f, 0.03533495f, 
    -0.12189204f, -0.08007746f, -0.01836979f, -0.20111547f, 0.02420093f, -0.12938236f, -0.11587203f, -0.03552863f, 
    0.21103929f, 0.11191219f, -0.04872728f, -0.42068067f, 0.09584773f, -0.04590208f, 0.09596992f, -0.01036212f, 
    -0.03083197f, 0.16829833f, -0.08791609f, 0.13949855f, -0.40306213f, 0.31474638f, -0.01603913f, -0.16215517f, 
    0.14400110f, 0.11780951f, -0.08118127f, 0.09719703f, -0.08626879f, -0.08546221f, 0.05726386f, 0.03215223f, 
    -0.04892747f, -0.05727723f, 0.08576795f, -0.15705346f, -0.08645813f, -0.05494585f, -0.01034331f, 0.06605709f, 
    -0.10810538f, 0.14120147f, -0.19631258f, 0.06001707f, 0.58748823f, 0.13475551f, 0.15088846f, -0.37568140f, 
    0.06382778f, 0.10026079f, -0.01256870f, 0.07211280f, 0.02677486f, -0.07299147f, -0.06750990f, -0.03758065f, 
    -0.09079177f, 0.01801362f, -0.07035332f, -0.22649530f, -0.01419626f, -0.04437990f, 0.08068733f, 0.02100876f, 
    0.14339803f, -0.13582107f, 0.05274643f, -0.10175032f, -0.16715682f, 0.08028676f, 0.05763904f, 0.19922625f, 
    0.00554042f, -0.16860922f, 0.02898652f, -0.08203306f, 0.06957956f, 0.07867516f, 0.03160585f, -0.01997724f, 
    0.42567483f, 0.05873153f, 0.08123162f, 0.12515071f, -0.09284738f, 0.06618578f, 0.03002363f, 0.05064484f, 
    -0.00463465f, -0.10993206f, 0.02739195f, -0.13248779f, -0.01684508f, -0.22778292f, -0.27966425f, -0.35278341f, 
    -0.11015114f, -0.14948621f, 0.02727226f, 0.02516842f, 0.04012952f, -0.06126457f, -0.17195016f, 0.02469608f, 
    0.16385874f, -0.24118213f, -0.14861332f, -0.14803548f, 0.06248491f, -0.18809675f, 0.06605912f, 0.01494275f, 
    0.15495522f, -0.04812444f, -0.07162268f, 0.01927338f, 0.35907084f, -0.00696307f, 0.01715074f, 0.06310107f, 
    0.03831888f, -0.15566722f, 0.12478002f, -0.07217370f, 0.11882981f, -0.08384478f, 0.00635036f, 0.02074626f, 
    -0.05180643f, 0.13148354f, -0.18019274f, 0.34059069f, -0.17752983f, -0.06598497f, 0.11405507f, 0.03843505f, 
    -0.14211640f, -0.14996889f, -0.24583016f, 0.20664492f, -0.04866571f, 0.36689675f, 0.03887741f, -0.07396826f, 
    -0.12454782f, -0.11255842f, 0.10718425f, 0.07350425f, 0.28649616f, -0.06717083f, 0.25968298f, -0.17827560f, 
    0.54679018f, -0.44948581f, 0.05983351f, -0.09155476f, 0.05941116f, 0.15419231f, -0.22308159f, 0.02437222f, 
    -0.10501296f, 0.20890266f, -0.08582917f, -0.01365376f, 0.62658000f, -0.23692507f, 0.06925438f, -0.10095894f, 
    -0.01583127f, -0.14362490f, -0.00529461f, -0.06036460f, -0.05725473f, -0.04859519f, -0.21797174f, 0.10449041f, 
    -0.29143453f, -0.04790064f, -0.27299660f, -0.22146268f, -0.14084986f, -0.01330148f, 0.09864668f, -0.00475814f, 
    0.03548912f, 0.08757998f, -0.02580912f, -0.16418114f, 0.42082119f, -0.17547919f, -0.11357602f, 0.05584747f, 
    0.02043490f, 0.09128730f, -0.12181087f, 0.00156953f, 0.00658689f, 0.11811224f, 0.04721987f, -0.09180004f, 
    0.00792472f, -0.00868704f, 0.10238535f, -0.14410175f, -0.11974945f, 0.22290379f, -0.02384111f, 0.00226442f, 
    -0.04521849f, 0.16723245f, 0.04023510f, 0.09349699f, 0.03764231f, 0.02249861f, -0.08934934f, 0.28370446f, 
    0.13837455f, -0.01178629f, -0.03766435f, -0.07987054f, 0.10074899f, 0.11013207f, -0.23796566f, -0.20123327f, 
    -0.20657729f, 0.14262593f, -0.13089404f, -0.11000357f, -0.21304791f, -0.08543979f, 0.06877820f, 0.01674252f, 
    0.02718322f, 0.07467326f, -0.02785148f, -0.02256840f, 0.28007042f, 0.00027262f, 0.12863542f, 0.34287709f, 
    -0.03478550f, -0.06214332f, -0.04172491f, -0.02554449f, 0.06427395f, -0.10386196f, -0.01588478f, -0.01791149f, 
    0.12234250f, -0.12904933f, 0.33727622f, 0.26915634f, -0.22170401f, 0.04921726f, -0.01792760f, 0.06890676f, 
    0.00819779f, 0.17042799f, -0.14350837f, 0.13427079f, -0.06040287f, 0.04028228f, 0.08745036f, -0.12884350f, 
    0.04068142f, 0.00847145f, -0.12413502f, -0.00831349f, -0.00256187f, -0.00569039f, -0.03380239f, -0.08169740f, 
    -0.09316482f, 0.05879917f, -0.10716232f, -0.09905013f, 0.06728855f, -0.16105664f, -0.04512191f, -0.03425374f, 
    0.11720578f, -0.12843594f, -0.11916189f, -0.03805483f, -0.02196918f, 0.22871757f, -0.16310738f, -0.03976765f, 
    -0.22009061f, 0.10051242f, -0.03344407f, 0.11608601f, -0.03472056f, 0.00011364f, 0.09945335f, -0.11386116f, 
    0.12879398f, -0.12277316f, 0.20807756f, 0.24507278f, -0.06567237f, -0.09154005f, -0.00496277f, 0.12975831f, 
    -0.04291765f, 0.10589434f, -0.06046028f, -0.00032997f, 0.27333981f, -0.01122197f, 0.22619791f, 0.05660539f, 
    -0.11756447f, -0.08771517f, 0.03097587f, -0.06272967f, 0.06948417f, -0.05909962f, 0.06432115f, 0.01961736f, 
    0.09097201f, 0.07305462f, -0.07335337f, 0.16220446f, -0.04720626f, -0.08102464f, 0.04155082f, -0.28895646f, 
    0.07255355f, -0.34197679f, 0.10476641f, 0.15427400f, -0.05970494f, -0.38078868f, -0.08245116f, -0.01142229f, 
    0.12009877f, 0.17493844f, -0.00528826f, 0.03565426f, 0.03475131f, 0.03850625f, 0.09540084f, -0.11366865f, 
    0.27776197f, -0.30040324f, -0.00576327f, 0.02941369f, 0.01488658f, -0.00211519f, 0.02896126f, 0.06938405f, 
    0.02315763f, -0.22691385f, -0.02186649f, -0.09585318f, 0.17663120f, -0.45199659f, -0.05984141f, -0.51677853f, 
    0.02176374f, -0.21939042f, 0.21463445f, 0.13277166f, -0.38797036f, -0.10346124f, -0.05782400f, -0.07471148f, 
    -0.27985868f, -0.40673104f, 0.00908203f, -0.07951641f, 0.01556351f, -0.17229348f, -0.04850688f, -0.13988252f, 
    0.01078397f, 0.02427276f, 0.02291214f, -0.19166128f, -0.22439858f, -0.16295981f, 0.04135037f, 0.00181260f, 
    0.05583379f, 0.02854535f, -0.04027610f, 0.04701539f, -0.04821774f, 0.10601910f, 0.20555322f, 0.12581329f, 
    0.18117471f, -0.36682341f, 0.04162195f, -0.22013697f, 0.09862082f, -0.12214135f, -0.05417052f, -0.01613686f, 
    -0.10375722f, -0.05730082f, 0.05256998f, -0.08201236f, 0.25737900f, -0.00152530f, -0.25657120f, 0.19260898f, 
    0.10035978f, 0.00902447f, -0.17306517f, 0.10936706f, -0.09218042f, 0.07591740f, 0.10412293f, 0.03310858f, 
    0.21153143f, -0.15215075f, -0.25603557f, -0.10812563f, 0.01861708f, -0.03254263f, 0.11866428f, 0.19159345f, 
    0.14862096f, -0.09587429f, 0.12929294f, 0.03236719f, -0.33883283f, -0.16525780f, -0.19303028f, -0.45158976f, 
    -0.10321274f, 0.10075910f, -0.02676584f, -0.05359208f, 0.13541378f, -0.00641165f, -0.03457246f, 0.06222488f, 
    -0.07828742f, 0.02200997f, -0.37690514f, -0.47264123f, -0.03094677f, -0.08823615f, -0.12685905f, -0.08934487f, 
    -0.06597278f, -0.08722085f, 0.04871690f, 0.07504798f, 0.03904399f, 0.16904970f, -0.15302899f, 0.07641712f, 
    0.05490530f, 0.08426256f, -0.05326062f, -0.03959859f, -0.19180532f, 0.16928126f, -0.03538127f, -0.26400134f, 
    0.06062068f, -0.12097374f, -0.20258553f, 0.03786298f, -0.00203054f, 0.10454157f, -0.02615983f, -0.04212928f, 
    0.00184607f, 0.10638779f, 0.06506566f, -0.00529007f, 0.08946776f, -0.17291112f, -0.03129308f, -0.15574437f, 
    0.05621905f, 0.01833161f, 0.10623106f, -0.10083314f, -0.15331373f, 0.00107689f, 0.02855386f, -0.07655729f, 
    0.02380642f, -0.20870970f, 0.35341707f, -0.10821512f, -0.05364131f, -0.05485540f, 0.08129379f, -0.04004048f, 
    -0.03912526f, -0.07719202f, 0.01648345f, -0.02835170f, -0.38433525f, -0.08341912f, 0.21037786f, -0.27109370f, 
    -0.19480589f, -0.06579825f, 0.13078769f, 0.04053747f, -0.09712741f, -0.10126194f, -0.00969982f, -0.06375967f, 
    0.00543975f, -0.34725493f, 0.09401520f, -0.08176114f, -0.00445127f, 0.02748344f, -0.01189835f, 0.08195262f, 
    0.09079822f, -0.03426696f, 0.04205626f, -0.16551940f, -0.55219507f, 0.10553633f, 0.16741224f, -0.06892108f, 
    -0.03824563f, 0.10647739f, -0.10733853f, -0.03797784f, -0.07958484f, 0.04227339f, -0.04450136f, -0.12057225f, 
    -0.41741520f, -0.09779275f, 0.21959223f, -0.03789965f, -0.00871886f, 0.00468181f, -0.07490200f, 0.11966569f, 
    -0.04465074f, -0.10837097f, -0.10124590f, -0.09334158f, 0.08200726f, 0.08082645f, -0.11496324f, 0.12848239f, 
    -0.01879902f, -0.03988759f, 0.19625066f, 0.18453313f, -0.10388076f, 0.02400024f, 0.00605984f, -0.05572664f, 
    -0.12629262f, 0.28872949f, -0.16668969f, -0.62071395f, 0.12384068f, 0.07597248f, -0.01640086f, -0.04567656f, 
    -0.06963407f, -0.01138834f, 0.05632383f, -0.08276722f, 0.20241183f, -0.25816515f, 0.31230274f, -0.10505410f, 
    -0.06811545f, 0.04357738f, 0.01171029f, 0.04178879f, 0.23179004f, 0.08340823f, -0.00669821f, 0.11395452f, 
    0.09888985f, -0.33091220f, -0.41604629f, -0.17928328f, 0.09295594f, -0.19648790f, -0.10037138f, 0.04430528f, 
    -0.06876240f, -0.07553338f, -0.00948460f, 0.00537116f, -0.32405850f, 0.17468677f, -0.23968835f, -0.36094269f, 
    -0.16359985f, -0.04668213f, 0.07750548f, 0.08984113f, 0.08443996f, -0.17638628f, -0.05035980f, -0.11198257f, 
    0.53421569f, -0.05497454f, -0.33565089f, 0.14092128f, -0.01154953f, 0.15014319f, 0.09346988f, -0.07213826f, 
    -0.09393460f, -0.04796475f, 0.11656413f, -0.01542019f, 0.20164226f, 0.02574702f, -0.05120162f, -0.24012884f, 
    0.21269466f, -0.06535142f, 0.04196679f, -0.00980637f, -0.12959196f, 0.02081861f, 0.03505272f, 0.05611389f, 
    0.25789201f, -0.23275465f, -0.00723124f, -0.03659556f, 0.17439015f, 0.04373180f, -0.04105258f, -0.09304264f, 
    0.02985166f, 0.07849003f, 0.06481156f, -0.04823879f, 0.05887417f, 0.19412564f, 0.01139559f, 0.33655101f, 
    -0.08970896f, -0.10238864f, 0.06479608f, 0.11237975f, 0.03602200f, 0.07913908f, -0.04564040f, -0.12397903f, 
    0.33549941f, 0.15047756f, -0.10132483f, 0.25881866f, -0.20306243f, 0.10426915f, -0.14250594f, -0.03147683f, 
    -0.07597947f, -0.04769744f, -0.00627404f, 0.03540111f, 0.43481940f, -0.15383433f, -0.00599334f, 0.00269199f, 
    0.08533153f, -0.04212271f, -0.06079710f, -0.02248459f, -0.08644743f, 0.21639211f, -0.03822151f, 0.01967330f, 
    -0.35473970f, 0.30228290f, 0.03348945f, -0.24253666f, 0.05486935f, 0.15077001f, -0.01178670f, -0.01027151f, 
    -0.06641804f, 0.00677023f, 0.12176242f, -0.02176800f, 0.02849693f, -0.02782283f, -0.04463193f, -0.01906001f, 
    0.11110004f, 0.14869659f, 0.04803146f, -0.08961128f, -0.04911925f, -0.01346555f, -0.13628177f, -0.05378054f, 
    0.23650682f, -0.10731745f, -0.06818438f, 0.02428174f, -0.00872068f, 0.04517309f, -0.01819620f, -0.00281351f, 
    -0.13602509f, 0.04869356f, -0.13230823f, -0.17987864f, -0.33145440f, -0.33010253f, 0.03214962f, -0.10952269f, 
    0.07841846f, -0.00607411f, -0.10969844f, -0.05470403f, 0.12204727f, 0.05688069f, -0.12284198f, 0.04663628f, 
    0.66281277f, 0.14409366f, -0.18136179f, 0.48007721f, -0.23146315f, -0.22168767f, -0.03327494f, 0.01884021f, 
    0.06901126f, -0.03224120f, 0.01810033f, -0.04111955f, -0.46829864f, -0.04566003f, -0.21286704f, -0.38254237f, 
    0.20406798f, -0.16721885f, 0.16324143f, -0.13087577f, 0.01127067f, 0.23100071f, -0.00408167f, 0.05133712f, 
    0.07544003f, 0.26076525f, -0.02849092f, -0.46196297f, 0.09138161f, -0.06900438f, 0.05380434f, -0.07324596f, 
    -0.14991418f, 0.01472548f, -0.10247593f, 0.03803657f, 0.23024243f, 0.21094108f, -0.19351406f, 0.21425648f, 
    0.12114415f, 0.06905482f, 0.05479207f, -0.11841725f, -0.02254487f, -0.05819635f, -0.08067985f, -0.14865218f, 
    0.18223631f, 0.06915092f, 0.16530842f, 0.05688671f, -0.08537181f, -0.12567809f, 0.04490957f, 0.06111135f, 
    -0.07545741f, -0.01871420f, 0.09455708f, -0.07697044f, 0.31961256f, -0.06566200f, -0.05034156f, 0.09677325f, 
    -0.18040267f, -0.01179568f, 0.01198318f, 0.08973069f, -0.01503137f, -0.13421503f, -0.05090797f, 0.00482064f, 
    0.34027770f, -0.49135110f, 0.18271580f, -0.00932279f, -0.23846462f, -0.00327677f, 0.07954957f, 0.12650979f, 
    0.04071237f, 0.02837467f, -0.03585754f, 0.02935893f, 0.20750019f, 0.08140478f, -0.04339601f, 0.06425350f, 
    -0.07983591f, -0.24295704f, -0.15791596f, 0.06406903f, -0.03980200f, 0.04730646f, -0.08576819f, 0.03627926f, 
    -0.00850371f, 0.22297800f, 0.01737486f, 0.12891456f, 0.08976931f, 0.09313543f, -0.11011524f, -0.03948309f, 
    -0.01285477f, 0.11379961f, -0.09115276f, -0.00528267f, 0.18311124f, -0.37561917f, -0.20144472f, 0.39242834f, 
    -0.02320501f, 0.14244056f, 0.12317989f, 0.06902585f, 0.05438707f, -0.13126735f, 0.08219492f, -0.12691775f, 
    -0.76914454f, -0.36530593f, -0.52380580f, -0.12473446f, -0.15415789f, -0.12915453f, -0.01528166f, -0.14595929f, 
    -0.05557993f, 0.09843725f, -0.13152432f, 0.13122544f, 0.48003265f, 0.44293705f, -0.14817436f, 0.06728801f, 
    -0.04641080f, 0.03758390f, -0.09376773f, 0.09958299f, 0.03423141f, -0.25021717f, -0.00806929f, 0.18806492f, 
    -0.27413553f, -0.28023621f, -0.14039423f, 0.05423393f, -0.22267291f, 0.03998183f, -0.09569307f, -0.00022123f, 
    -0.07314276f, -0.10944138f, 0.11387525f, 0.05493106f, -0.21601643f, -0.30664524f, -0.14097072f, 0.20112199f, 
    -0.05538458f, 0.03668433f, -0.26655543f, 0.03134121f, -0.15682553f, 0.13310702f, -0.13993621f, -0.06939383f, 
    0.23348522f, -0.09558047f, 0.15353705f, 0.02720826f, -0.15498477f, 0.05899048f, 0.02655414f, -0.01330065f, 
    0.08564972f, 0.05046900f, 0.07572033f, -0.05591183f, 0.04606432f, -0.09735277f, -0.15227903f, 0.06557713f, 
    0.05549331f, 0.16060063f, 0.05136335f, 0.05205844f, 0.03299905f, 0.19388966f, -0.11016193f, 0.04741089f, 
    0.02770696f, 0.12449425f, -0.15834682f, 0.05115172f, -0.00218585f, 0.07751563f, 0.06327805f, -0.27000690f, 
    -0.01975786f, -0.01299139f, 0.22104725f, -0.04733645f, 0.19346656f, -0.28308290f, 0.03628490f, -0.18393749f, 
    -0.11723723f, 0.16645354f, -0.04716094f, 0.02562488f, 0.04019488f, -0.11897742f, -0.01885888f, 0.08421791f, 
    0.41510272f, 0.20488478f, 0.22494707f, -0.09407746f, 0.06193274f, 0.00082526f, 0.01865321f, 0.12921293f, 
    0.00923178f, -0.00666851f, -0.16394337f, -0.18658493f, -0.16763408f, -0.06130634f, -0.30135453f, 0.00350631f, 
    -0.03332012f, 0.00507576f, 0.11786416f, -0.08803245f, -0.03821880f, -0.05390181f, -0.00482307f, 0.02457042f, 
    -0.00773737f, 0.10392167f, 0.16696735f, 0.01834467f, -0.04639610f, -0.15368994f, -0.00187111f, -0.12197381f, 
    -0.01649182f, 0.03174520f, -0.08596240f, -0.01007705f, 0.04877191f, -0.07261320f, 0.13491304f, -0.04572955f, 
    -0.01578165f, 0.05684675f, 0.08562790f, 0.02448130f, 0.09468950f, 0.08729519f, 0.00640614f, 0.13895808f, 
    0.01575767f, 0.11124761f, 0.12454055f, -0.02683407f, 0.12721050f, 0.05635105f, 0.10322241f, -0.08878782f, 
    -0.01567833f, -0.06701459f, -0.09493390f, -0.08801570f, -0.55466878f, -0.54821038f, -0.21081178f, -0.17805286f, 
    -0.08177465f, -0.15307666f, -0.10561096f, -0.00729928f, 0.01852019f, -0.13410550f, -0.00916011f, 0.12455092f, 
    0.48359656f, -0.47432241f, -0.34557775f, 0.15454458f, 0.00256403f, -0.06217957f, 0.01080528f, -0.02247920f, 
    0.00236997f, -0.06812364f, -0.06047931f, -0.00191253f, -0.05218576f, -0.01390818f, -0.20106822f, -0.16414201f, 
    -0.25549972f, -0.16173932f, 0.09212582f, 0.08848713f, -0.17198636f, 0.12030274f, 0.07224055f, -0.03892206f, 
    0.13495702f, 0.32995099f, -0.04015907f, -0.12839559f, -0.20090009f, -0.18974499f, 0.05969595f, 0.03111566f, 
    -0.05998231f, -0.00051072f, 0.09228270f, 0.02693135f, -0.41059202f, 0.07630252f, 0.24129942f, -0.06845324f, 
    0.11336878f, -0.14381117f, -0.09407356f, 0.04341256f, 0.13132678f, 0.01775491f, -0.15010239f, 0.08479285f, 
    -0.14486501f, 0.12552199f, -0.04635839f, 0.20221782f, 0.07848203f, 0.07800099f, 0.01973323f, -0.10665684f, 
    -0.03298722f, -0.01658212f, -0.13179158f, 0.02736761f, -0.74724692f, -0.59909022f, 0.07205115f, 0.27451161f, 
    -0.04511644f, -0.01651645f, -0.04841309f, 0.03607601f, -0.00428157f, -0.22918278f, 0.05388776f, -0.02821591f, 
    -0.06675684f, -0.19365044f, -0.00193231f, -0.05660824f, -0.02116724f, -0.02041999f, -0.07108472f, -0.04873333f, 
    -0.07162221f, 0.24675763f, -0.04623093f, 0.08524106f, -0.09625907f, -0.36493561f, 0.03336702f, 0.41285762f, 
    -0.03835989f, 0.04241022f, 0.19809078f, 0.12000495f, -0.01124001f, 0.10060908f, 0.05019348f, -0.03364222f, 
    0.27600771f, -0.22213498f, -0.04394412f, -0.00382840f, -0.05324751f, -0.06314681f, -0.00627806f, -0.05518097f, 
    -0.11504222f, 0.06819031f, 0.03096987f, 0.08419082f, 0.32061380f, -0.08124299f, 0.26053473f, 0.00874052f, 
    0.01043808f, 0.06429599f, 0.08481491f, 0.08007437f, 0.05103372f, 0.07185438f, 0.10957576f, -0.06389167f, 
    0.48039562f, 0.37046349f, -0.37709135f, 0.24124418f, -0.01412530f, 0.11755289f, 0.17399566f, 0.12281182f, 
    0.20354261f, -0.06923784f, -0.03372923f, 0.05389643f, -0.47400892f, -0.07245515f, 0.09172294f, 0.36523995f, 
    0.16484128f, 0.06537356f, 0.09410890f, -0.18152986f, -0.11371134f, -0.06571437f, -0.11475752f, -0.16274026f, 
    -0.17615165f, -0.07577611f, 0.08173992f, 0.01018101f, -0.14828101f, 0.09268236f, 0.02110536f, -0.03568546f, 
    -0.13574238f, 0.04440401f, 0.00163714f, 0.03526629f, 0.03190257f, -0.00996106f, 0.12374044f, 0.03260899f, 
    -0.04529743f, -0.19935948f, 0.12620355f, -0.01608606f, -0.12032922f, -0.02716476f, 0.01080397f, -0.11645316f, 
    -0.08635590f, 0.13819066f, 0.00934431f, -0.09301165f, -0.19034144f, -0.11892240f, -0.01513480f, 0.01602282f, 
    0.00367037f, -0.09215782f, 0.02119630f, 0.03327917f, 0.04965539f, 0.35002798f, -0.05470065f, -0.12700425f, 
    -0.03180774f, 0.00012548f, 0.19185047f, 0.07684062f, 0.00919224f, -0.16959304f, -0.07992215f, 0.03496534f, 
    0.04157281f, -0.09718440f, 0.45796928f, 0.14822556f, -0.15044950f, 0.19025917f, -0.07223705f, -0.06578099f, 
    0.06306700f, 0.02392091f, -0.04618605f, 0.17021939f, -0.35206109f, -0.34761813f, 0.22619408f, 0.02535377f, 
    -0.15083195f, 0.12845407f, -0.09782165f, -0.14507005f, -0.02210914f, 0.15150629f, -0.11103387f, -0.07381138f, 
    0.01345319f, 0.05073816f, -0.21247678f, 0.03686528f, -0.01477075f, 0.10520202f, 0.03501758f, 0.09609087f, 
    0.09854720f, -0.03859652f, -0.03252625f, 0.13933372f, 0.30480865f, -0.15918265f, -0.22429192f, 0.13651615f, 
    -0.29960459f, 0.18133770f, 0.08066402f, -0.06232820f, 0.01802115f, 0.09675290f, -0.09109978f, 0.01914826f, 
    -0.36259711f, 0.05505307f, 0.29450375f, 0.02251638f, -0.03377698f, 0.04885367f, -0.05402143f, 0.09112994f, 
    0.08414999f, -0.04413539f, 0.03665034f, 0.07785386f, -0.20952059f, -0.29961228f, 0.03740257f, -0.16580385f, 
    0.03065686f, 0.15269420f, -0.05427907f, 0.06191658f, 0.02495891f, 0.03118135f, -0.02170648f, 0.04864629f, 
    -0.30294397f, 0.04050696f, -0.09958307f, -0.27478305f, 0.05571557f, 0.01212686f, -0.18501532f, -0.06170125f, 
    -0.06767883f, -0.01637546f, 0.11573315f, -0.00224518f, -0.46045679f, -0.21959729f, 0.13396224f, -0.18616445f, 
    0.09141300f, 0.03445841f, -0.10315571f, -0.01510355f, 0.16804053f, -0.04615865f, -0.06578778f, 0.22798988f, 
    -0.17186674f, 0.11052608f, -0.45260924f, 0.04981547f, -0.03329210f, -0.03922145f, 0.20636700f, -0.01637518f, 
    0.08236687f, -0.13627981f, -0.06513621f, 0.01886719f, 0.23610146f, -0.14640474f, -0.18037893f, 0.05777089f, 
    -0.02889886f, 0.02235161f, -0.03119519f, -0.13617496f, 0.12329375f, 0.02959055f, 0.03205171f, -0.16696650f, 
    0.21200442f, -0.30212778f, 0.10620189f, -0.22587627f, 0.14204721f, 0.03530324f, -0.01644959f, 0.06300206f, 
    0.02877614f, -0.09828876f, 0.04329547f, -0.09046196f, -0.72739720f, 0.41559520f, -0.09850154f, 0.00972747f, 
    -0.00182209f, -0.07049129f, -0.00991353f, -0.00254425f, 0.03611265f, 0.02470487f, -0.15479864f, 0.03489234f, 
    -0.00203748f, -0.10139670f, -0.09209213f, 0.04601072f, 0.04775208f, -0.17018740f, 0.05805385f, 0.18063171f, 
    0.10173198f, 0.09037928f, 0.08815232f, -0.05908408f, 0.32252043f, 0.01910649f, 0.18800001f, -0.16979437f, 
    0.12307292f, -0.00458159f, 0.09955905f, 0.05040126f, -0.13007428f, -0.06469740f, 0.09531492f, 0.18152198f, 
    0.34525532f, 0.35195717f, -0.17732191f, -0.07283019f, -0.24193577f, -0.22680497f, -0.01701903f, -0.07057231f, 
    -0.02178252f, -0.00584784f, -0.08355173f, 0.03575827f, 0.37763187f, -0.06197498f, 0.08356617f, 0.18703891f, 
    0.10784548f, -0.04063504f, 0.17112564f, 0.09543911f, -0.04390761f, 0.02375553f, 0.14385347f, 0.01052617f, 
    0.11778171f, 0.33454230f, 0.11816586f, -0.13101299f, -0.16617319f, 0.00099333f, -0.01621620f, 0.02268000f, 
    0.01753790f, -0.19767968f, 0.07516517f, -0.09304103f, -0.32969257f, -0.07617690f, 0.07490065f, 0.40397772f, 
    -0.02575837f, -0.22769687f, -0.00650009f, 0.00941892f, 0.04379374f, 0.08687394f, 0.17968465f, 0.13114573f, 
    0.18205398f, -0.19616131f, -0.15572098f, 0.02337608f, 0.04799297f, 0.20133457f, 0.12220202f, 0.12128405f, 
    -0.09647135f, -0.19940443f, -0.06634647f, -0.03307074f, -0.13293934f, 0.29815963f, -0.07325482f, -0.04755949f, 
    0.03947236f, -0.11255990f, 0.00528634f, 0.18150985f, -0.01115972f, -0.11876179f, -0.13069996f, 0.00143704f, 
    -0.01438174f, -0.32997540f, -0.20108329f, 0.10074043f, -0.06763741f, -0.09973256f, 0.06379799f, -0.00843138f, 
    0.07580176f, -0.22816014f, -0.10225978f, -0.02393394f, -0.45356184f, 0.07031493f, 0.00924479f, -0.06916776f, 
    0.01801552f, 0.12152296f, 0.03388277f, 0.10737712f, -0.00550243f, 0.04720878f, -0.12813990f, -0.07475499f, 
    -0.11213248f, 0.25362763f, -0.13644964f, -0.20402606f, -0.07803217f, 0.04291109f, 0.00193684f, 0.23395306f, 
    -0.22843836f, 0.19375871f, -0.02952622f, 0.04645468f, 0.32528993f, 0.24106188f, -0.12697862f, -0.24814397f, 
    0.01966875f, 0.05197870f, -0.08679826f, 0.05206471f, -0.07959047f, 0.02539080f, 0.00911910f, 0.19396260f, 
    -0.07119078f, 0.05090144f, -0.01340654f, -0.00260849f, 0.03706299f, 0.00694292f, 0.05009752f, 0.12714387f, 
    -0.05974539f, -0.11030397f, 0.04808464f, 0.05522407f, 0.18454567f, -0.00962191f, -0.09159669f, -0.00904612f, 
    -0.10109860f, 0.03229653f, -0.01988271f, 0.11979833f, 0.02078596f, 0.10046522f, -0.00472213f, 0.04835824f, 
    -0.12369629f, 0.02137184f, -0.17550740f, 0.18272391f, -0.00533688f, 0.08520583f, 0.22479613f, -0.03392928f, 
    -0.14104533f, -0.05235483f, 0.16291569f, -0.11562614f, -0.61586946f, -0.11449715f, 0.32256615f, 0.22946286f, 
    -0.15800060f, -0.07824809f, -0.08291531f, -0.14727759f, 0.17355914f, -0.07980879f, -0.25259268f, -0.10986315f, 
    -0.44091052f, -0.13710484f, 0.06516157f, 0.27924171f, 0.05690490f, 0.02585569f, 0.05581360f, 0.02868386f, 
    -0.00529367f, -0.01367427f, -0.10658282f, -0.00998402f, -0.61173701f, 0.07940492f, -0.10097331f, 0.03379489f, 
    -0.01934242f, 0.13108899f, 0.07177634f, 0.02651825f, 0.09555606f, -0.04991235f, -0.08047814f, 0.05230300f, 
    -0.38086590f, 0.27190050f, 0.14744131f, 0.20615613f, 0.09987909f, -0.04423121f, -0.22349343f, 0.11031344f, 
    -0.14393033f, 0.02198493f, 0.13273333f, -0.07472437f, -0.01651536f, -0.29326883f, -0.05941822f, -0.04273466f, 
    0.00806758f, -0.19095103f, 0.10837642f, 0.01324669f, 0.08643383f, 0.04731778f, 0.08704906f, -0.01539215f, 
    0.01695228f, 0.20940842f, -0.21930991f, 0.13230158f, -0.03383838f, -0.02111180f, -0.07312791f, 0.08904882f, 
    0.02089498f, -0.05615777f, -0.06206665f, -0.14962281f, 0.16088438f, 0.02089339f, -0.08998918f, -0.16669863f, 
    -0.07555542f, 0.18121102f, 0.03460083f, 0.03335200f, 0.07739567f, -0.42953569f, 0.06146625f, 0.13132222f, 
    -0.06123709f, 0.08667639f, 0.25840250f, 0.02106445f, 0.18727292f, -0.03258132f, 0.12821558f, -0.05052389f, 
    -0.01902833f, 0.00232562f, -0.18261728f, 0.02604314f, -0.14748599f, -0.17015964f, 0.14533523f, 0.25826064f, 
    0.00813353f, -0.09747144f, -0.06166926f, 0.01441875f, -0.11590132f, 0.08602709f, -0.00125941f, -0.06967641f, 
    0.13309954f, -0.06018555f, -0.26114362f, 0.09370880f, 0.26498520f, -0.07991782f, 0.00609066f, 0.12044544f, 
    0.02086198f, 0.15168156f, -0.09904594f, -0.04440294f, 0.24233305f, 0.21103208f, 0.04401335f, 0.05680446f, 
    0.00655543f, -0.19109297f, 0.06712202f, 0.15021507f, 0.06739403f, 0.02055511f, 0.16749765f, -0.05913729f, 
    -0.62662232f, -0.06928673f, -0.29450563f, -0.21255828f, 0.15869418f, -0.01641245f, 0.07110433f, 0.03687791f, 
    0.02529906f, 0.01089539f, -0.15693742f, 0.03561238f, 0.01715988f, -0.26778778f, -0.04310153f, 0.30484495f, 
    0.05713816f, -0.13004386f, -0.15252496f, 0.02004030f, 0.07054498f, -0.11432809f, 0.07307277f, -0.07867838f, 
    -0.66642606f, 0.27274925f, -0.07460160f, -0.27038151f, 0.07470897f, 0.05038432f, -0.20123698f, -0.08668255f, 
    0.08007582f, 0.12883578f, 0.09185724f, 0.10798962f, 0.19165334f, 0.05020639f, 0.12805705f, -0.19728732f, 
    -0.15169454f, -0.13465855f, -0.19747628f, -0.10855227f, -0.23546492f, -0.03368285f, -0.08374581f, -0.02982863f, 
    -0.44900060f, -0.35364774f, 0.29662010f, 0.40837252f, -0.00793291f, -0.03543604f, 0.08728406f, -0.01944917f, 
    -0.05091925f, 0.00921744f, 0.00555310f, 0.15907462f, -0.49567094f, 0.30727464f, -0.03092498f, -0.24353665f, 
    0.03909362f, 0.01133234f, -0.05275176f, 0.14071412f, -0.07533415f, -0.06863176f, -0.04559277f, -0.30004901f, 
    0.07017790f, -0.12221058f, -0.05806179f, 0.01349185f, 0.14664698f, 0.07602455f, 0.03050941f, 0.01494539f, 
    0.06956468f, 0.06030473f, 0.13138404f, 0.35568753f, -0.27373675f, -0.25807098f, -0.05842294f, -0.00982578f, 
    0.05542177f, -0.05509071f, -0.11194602f, -0.00689119f, 0.25071433f, 0.11260718f, 0.09915129f, -0.03370575f, 
    -0.05886378f, -0.10680855f, 0.06752798f, 0.30978787f, -0.16010942f, -0.02954388f, -0.03811571f, 0.10403787f, 
    -0.10825959f, 0.05624989f, 0.04776536f, 0.03119766f, 0.09268830f, 0.04148763f, 0.28763264f, -0.35246372f, 
    -0.07794803f, -0.04684129f, -0.10176055f, -0.20787820f, -0.01052177f, -0.01500283f, 0.02135675f, -0.18059069f, 
    -0.09152383f, -0.12891486f, 0.26104715f, 0.13305081f, 0.11689763f, 0.10109647f, -0.02299222f, -0.00497345f, 
    0.04677442f, -0.03919301f, -0.03367293f, 0.15405014f, -0.09987658f, -0.27365425f, -0.30631706f, -0.05668294f, 
    0.06958450f, 0.28179416f, -0.21296319f, -0.27596360f, -0.16119215f, -0.10155172f, -0.13321036f, -0.07021526f, 
    -0.47807911f, -0.23598759f, -0.06664160f, -0.02556095f, 0.04098607f, 0.14393023f, 0.22981097f, 0.10499696f, 
    0.16874975f, 0.11467928f, 0.11908535f, -0.21953152f, -0.24556543f, -0.07029813f, 0.19504133f, 0.27472726f, 
    -0.14644544f, 0.15317126f, 0.08867215f, -0.15059419f, 0.21588399f, 0.01149379f, 0.02668428f, -0.17632422f, 
    -0.00915699f, 0.03344879f, -0.01163212f, -0.28805196f, 0.04856021f, -0.05245750f, 0.04951780f, 0.15015548f, 
    0.14051925f, 0.09547636f, -0.13910137f, -0.05149424f, 0.06001101f, -0.00470855f, 0.11464962f, 0.07502127f, 
    0.10578328f, 0.08291277f, 0.03180404f, 0.03213896f, -0.08963379f, 0.08740515f, 0.17522281f, 0.23261870f, 
    -0.11164690f, 0.10537903f, 0.14542432f, 0.12142283f, 0.02091391f, -0.10132834f, 0.08267649f, -0.07733625f, 
    0.11277974f, 0.03310573f, -0.19910105f, -0.08921965f, -0.03244457f, 0.26727119f, 0.25013447f, -0.06464547f, 
    -0.11913932f, -0.12872612f, 0.10916150f, 0.11393130f, 0.10200991f, 0.06686806f, 0.00022501f, -0.05447267f, 
    -0.76642954f, -0.33523357f, -0.21142671f, -0.07738288f, 0.14410236f, 0.08649423f, 0.03283330f, 0.00367990f, 
    -0.00291656f, 0.12805195f, -0.12889704f, 0.09601664f, 0.16594285f, 0.12014128f, 0.04753522f, 0.17897712f, 
    -0.15336378f, 0.05895795f, 0.08040772f, -0.02119934f, 0.29500470f, -0.18359061f, -0.05664739f, -0.10099966f, 
    -0.14763723f, 0.12196709f, 0.02416828f, -0.09543631f, -0.06127037f, -0.00643854f, -0.13257073f, -0.02535648f, 
    -0.10611966f, -0.06618833f, -0.05860664f, -0.12741353f, 0.36552379f, 0.03400473f, -0.01600070f, 0.02548807f, 
    -0.14873092f, 0.00538488f, -0.01761441f, 0.13142994f, -0.18334018f, 0.14173774f, 0.11253107f, 0.28370574f, 
    0.30043846f, 0.12408313f, -0.19628209f, -0.15110929f, -0.24588121f, 0.11225881f, -0.28549597f, -0.22374183f, 
    0.02408068f, -0.05551434f, 0.04569107f, -0.00989579f, -0.45212710f, 0.27945745f, -0.01921611f, -0.20546228f, 
    0.10969603f, -0.05021631f, -0.04224774f, -0.34827942f, 0.08036146f, -0.00494708f, -0.05131697f, -0.05827870f, 
    -0.33767402f, -0.05742200f, -0.32271865f, 0.09086117f, 0.13812293f, 0.10423532f, -0.01135454f, -0.06637212f, 
    -0.01077122f, 0.02566992f, 0.03668248f, -0.14748017f, -0.33564723f, 0.18652593f, 0.10026077f, 0.07776935f, 
    0.10123175f, 0.10054903f, 0.15596382f, -0.09695413f, 0.14372069f, 0.03153652f, 0.09299732f, 0.01986248f, 
    -0.25832400f, -0.16118641f, -0.40356410f, -0.16226184f, 0.12714094f, -0.12789148f, 0.01441455f, 0.10386778f, 
    -0.25937748f, 0.24705291f, -0.05592748f, -0.03334726f, 0.21264268f, 0.22955759f, 0.10501561f, -0.27859393f, 
    -0.02490495f, 0.09200855f, -0.00128956f, -0.00039973f, 0.09084772f, 0.12579104f, -0.18559757f, -0.04252349f, 
    -0.14724059f, 0.14813100f, 0.22630045f, 0.01642974f, -0.17375644f, -0.11017206f, 0.04061262f, 0.08579151f, 
    -0.03446683f, -0.08043673f, 0.19152394f, 0.05009831f, -0.25773171f, 0.29778132f, 0.19422156f, -0.19577043f, 
    -0.04425865f, -0.06498080f, 0.12074903f, -0.12067636f, -0.20234777f, 0.18139637f, 0.11384422f, 0.01711953f, 
    -0.05222004f, 0.09890050f, -0.31019577f, 0.10495079f, -0.03527102f, 0.17868447f, -0.06640109f, 0.16494922f, 
    -0.19573663f, 0.00553818f, 0.09874714f, -0.09823547f, -0.36607984f, -0.07496860f, 0.15650390f, 0.27701241f, 
    0.00442315f, 0.21022755f, -0.13258801f, -0.09099712f, -0.06995246f, -0.07348651f, -0.10201424f, -0.12573698f, 
    0.27309906f, -0.07272284f, 0.07048537f, -0.19886081f, -0.02576317f, -0.16200751f, 0.15223840f, -0.21035931f, 
    -0.03469346f, 0.04117450f, 0.07715207f, -0.08077045f, -0.42065597f, 0.26723415f, 0.05714224f, 0.20656565f, 
    -0.01498035f, 0.11161486f, 0.09066328f, -0.05809648f, -0.13362187f, 0.07460222f, -0.02026083f, 0.02587306f, 
    -0.06210966f, -0.41547859f, 0.02012800f, -0.39303330f, -0.23950562f, -0.00722844f, 0.11410549f, 0.15419503f, 
    0.03216825f, -0.09189354f, -0.10096081f, -0.05516936f, -0.55029529f, 0.11571967f, 0.13287535f, 0.21895774f, 
    0.19441026f, 0.15282990f, 0.05887792f, 0.15850239f, 0.14865369f, -0.01212933f, 0.03553426f, -0.14775011f, 
    0.29327738f, 0.05271511f, -0.08746483f, 0.19239703f, -0.12018117f, -0.03208497f, 0.06321685f, 0.08480047f, 
    -0.18899322f, -0.19482917f, -0.01741708f, -0.09853315f, 0.44912496f, -0.80023658f, 0.10503362f, -0.05084929f, 
    -0.04603879f, 0.09900223f, -0.09530298f, -0.04878858f, 0.04776489f, 0.04234567f, 0.10483176f, 0.30157128f, 
    -0.07423342f, -0.07027403f, -0.26128641f, 0.02797816f, -0.00696457f, 0.09981707f, -0.08300741f, -0.03815579f, 
    0.06461770f, -0.01622897f, -0.24956673f, -0.35315266f, 0.05464171f, -0.06081105f, -0.21944575f, 0.02703990f, 
    -0.11222795f, -0.20407578f, 0.01791490f, 0.09119518f, 0.03094293f, -0.02591523f, -0.01995970f, 0.32015771f, 
    -0.02322984f, 0.00812365f, 0.06954450f, 0.07035789f, 0.02005784f, 0.05568875f, -0.05769693f, -0.11748741f, 
    0.04970789f, -0.02329457f, -0.07088402f, -0.06422149f, -0.48254800f, 0.31636444f, 0.16025893f, -0.27645466f, 
    -0.16251478f, -0.02307446f, 0.03681687f, 0.10030682f, -0.07739330f, 0.05814740f, -0.07280938f, 0.19005355f, 
    -0.18075828f, 0.05391422f, -0.01666956f, -0.12370299f, -0.02875775f, -0.05138884f, 0.10298654f, 0.17144960f, 
    0.00554276f, 0.07477562f, 0.01921793f, -0.02624088f, -0.33153719f, -0.20685302f, -0.15115581f, -0.31207129f, 
    -0.07193761f, -0.04765935f, 0.10352476f, 0.05309375f, 0.00914419f, 0.11143749f, 0.01939366f, 0.21344492f, 
    0.11992088f, 0.00200705f, 0.16138056f, -0.25733095f, -0.12774581f, -0.10560249f, -0.03432951f, -0.17909391f, 
    -0.15540926f, 0.08519019f, -0.11081825f, 0.25162914f, 0.06918469f, -0.20180653f, -0.16836403f, 0.06256512f, 
    0.10381447f, -0.09232360f, 0.10569157f, 0.04737201f, 0.00212409f, -0.01960516f, -0.17737873f, 0.22594948f, 
    -0.03865625f, 0.36086914f, 0.22501306f, -0.06529096f, -0.08043388f, -0.02794633f, -0.04315134f, -0.09665515f, 
    -0.01274029f, -0.03463957f, 0.06590732f, 0.11965001f, 0.12232520f, 0.25499091f, 0.12509713f, -0.25263998f, 
    -0.18142319f, -0.00186619f, 0.04018576f, -0.00176015f, 0.02856250f, 0.01624003f, -0.11182687f, -0.14665385f, 
    0.01502452f, 0.07590442f, -0.01376250f, 0.01778850f, -0.16189034f, 0.07536433f, 0.20308942f, 0.14701140f, 
    0.02445593f, 0.05491260f, 0.23687382f, 0.01192356f, 0.25471541f, -0.16952556f, 0.03063206f, -0.29257536f, 
    0.01242311f, 0.15626872f, -0.03668372f, -0.01309576f, 0.02613010f, -0.14036611f, 0.10877010f, 0.03603821f, 
    -0.39249721f, -0.18544315f, 0.06901633f, -0.22272779f, -0.01008377f, -0.05792676f, 0.08152429f, -0.27579936f, 
    0.00038873f, -0.13216357f, 0.14841840f, 0.02593654f, -0.08406958f, -0.07403523f, -0.16705367f, 0.17994896f, 
    0.20179801f, 0.01971522f, -0.09352275f, -0.16181147f, 0.00254951f, 0.04718397f, 0.08814590f, 0.20294577f, 
    0.39974618f, 0.16265257f, 0.13259999f, 0.45054123f, -0.01140782f, 0.10108329f, -0.05579306f, 0.02112680f, 
    0.07113331f, 0.12976317f, -0.12566005f, 0.19484103f, 0.13359092f, 0.18274474f, 0.17612678f, -0.39287663f, 
    0.13253367f, 0.01742166f, 0.05927029f, -0.00715043f, 0.09550116f, -0.22468999f, -0.05967009f, -0.22997673f, 
    -0.24458058f, -0.15827963f, -0.21838653f, 0.39807063f, 0.06886804f, -0.00067437f, 0.12684716f, 0.01815067f, 
    0.08685289f, 0.02089211f, 0.13991040f, -0.02687293f, 0.01209487f, -0.66458088f, -0.05777055f, -0.16443321f, 
    -0.00994969f, 0.07166253f, 0.07530889f, 0.30726251f, 0.06029352f, 0.01818563f, 0.03890545f, 0.02572065f, 
    0.16731164f, -0.02217179f, -0.00423249f, -0.07155349f, -0.15063904f, 0.02350875f, 0.02441655f, -0.26187298f, 
    -0.10881670f, 0.12762530f, 0.00627278f, 0.15352574f, -0.15590541f, -0.02454495f, -0.36253345f, 0.24655513f, 
    0.01874524f, -0.08346134f, -0.12677847f, -0.14323436f, -0.08175954f, 0.03127437f, -0.24664094f, -0.16156061f, 
    0.23655629f, -0.22445433f, 0.00974207f, 0.26876366f, -0.05331311f, -0.21042018f, -0.10274018f, -0.07522630f, 
    -0.01209077f, 0.01675952f, -0.00114576f, -0.03644199f, 0.22187868f, 0.26630935f, -0.25517261f, -0.32166177f, 
    -0.07716753f, -0.06770199f, -0.02181688f, -0.02609778f, -0.15795921f, -0.01164702f, 0.06146760f, -0.10743138f, 
    -0.14340509f, -0.10902479f, -0.04956875f, -0.17225653f, 0.02677742f, 0.04108527f, -0.08526068f, -0.08459657f, 
    -0.06203731f, 0.08239780f, -0.04706703f, -0.15222223f, -0.23594253f, 0.13406648f, 0.05821845f, -0.01140008f, 
    0.10742900f, -0.04550943f, -0.06057774f, -0.01030346f, -0.02219860f, -0.04537605f, -0.02812463f, 0.11222082f, 
    -0.30057216f, 0.29544973f, -0.09693345f, 0.07252437f, -0.09498499f, 0.00042242f, -0.14369743f, 0.00082270f, 
    0.10405950f, -0.00583949f, -0.06369259f, 0.04640030f, -0.26576746f, -0.14992496f, -0.16961907f, -0.10827872f, 
    0.00433290f, 0.01068451f, 0.03495325f, -0.02536246f, -0.03485471f, 0.03323920f, -0.13430418f, -0.03619729f, 
    0.21412838f, -0.16876054f, 0.20328982f, 0.14261672f, 0.00280476f, 0.00837061f, -0.11625543f, 0.00161406f, 
    0.00326315f, 0.03060076f, 0.05836509f, -0.10928248f, 0.05998957f, 0.09208944f, -0.25164619f, -0.24155085f, 
    -0.03043961f, -0.10163397f, -0.11696257f, -0.02611793f, -0.07705404f, 0.08241394f, -0.02497521f, 0.02702891f, 
    0.11985908f, 0.02152353f, 0.00919163f, -0.02858140f, -0.07512195f, 0.04442936f, 0.04260739f, -0.08413731f, 
    -0.08306714f, -0.06257790f, -0.20470609f, -0.15532570f, -0.13011779f, 0.19906585f, -0.02297373f, -0.32327133f, 
    0.04969305f, -0.01613841f, -0.02399358f, 0.12333635f, -0.05951445f, 0.08077903f, -0.06376263f, -0.24755794f, 
    0.29720798f, 0.10148939f, 0.16316964f, 0.40844288f, 0.13026038f, -0.16237365f, -0.04838894f, -0.02045629f, 
    -0.07153942f, -0.03520397f, -0.15667580f, -0.11774456f, -0.20654486f, 0.13986132f, 0.16693826f, -0.18039735f, 
    -0.13467215f, -0.03994047f, -0.00306369f, -0.02297949f, -0.05505193f, 0.08056812f, -0.19588785f, 0.04034144f, 
    0.18187839f, 0.03339605f, 0.14430726f, 0.06799680f, 0.14073770f, -0.05531288f, -0.02992738f, -0.06992419f, 
    -0.06962048f, -0.00104725f, -0.01519841f, -0.17279848f, 0.18745872f, 0.20762536f, 0.09761900f, 0.37411141f, 
    0.20668751f, 0.07995406f, 0.14099304f, -0.01419364f, -0.05781418f, -0.20337097f, -0.03267393f, -0.16553316f, 
    0.18543638f, -0.28106549f, 0.26882330f, -0.04590956f, 0.22725408f, 0.02104249f, -0.06058259f, 0.01840228f, 
    -0.12029994f, -0.10552736f, -0.16006529f, -0.04405121f, -0.14570461f, 0.12443683f, -0.00186592f, -0.13959400f, 
    0.06051421f, 0.11209588f, -0.02467049f, -0.06502276f, 0.00468466f, -0.08142220f, -0.12995499f, -0.16837430f, 
    -0.75525057f, 0.15523662f, -0.07724947f, -0.14874412f, 0.00431215f, -0.13363947f, -0.00138642f, -0.12748812f, 
    -0.10854094f, 0.00556767f, 0.03915968f, 0.03610360f, 0.22829254f, 0.25099486f, 0.14356099f, 0.26450425f, 
    0.16489369f, 0.11089425f, 0.18102503f, 0.00561100f, 0.01308865f, -0.03667963f, -0.01949362f, -0.05890699f, 
    -0.06628380f, 0.14062412f, 0.18559237f, 0.20441067f, 0.24479632f, 0.07328597f, 0.12073413f, -0.09264865f, 
    -0.11585988f, 0.00361254f, -0.04365797f, 0.00096505f, 0.17196736f, -0.30406708f, 0.02785888f, -0.06680298f, 
    0.00538444f, -0.09700046f, -0.08506288f, -0.02240217f, -0.02259578f, -0.04078964f, -0.05085447f, -0.04672684f, 
    -0.23145565f, -0.09300119f, -0.47737658f, -0.01568372f, 0.06062588f, 0.07303279f, 0.03454884f, -0.12280852f, 
    -0.11867218f, -0.09326121f, 0.14861545f, -0.09393482f, -0.04310014f, -0.25100136f, -0.10717087f, -0.13696568f, 
    -0.05747961f, 0.01407090f, 0.08172851f, -0.06110135f, -0.05969834f, 0.00441256f, -0.05364079f, -0.11785295f, 
    -0.19067915f, -0.09661032f, -0.05920440f, -0.24966969f, -0.20562398f, 0.03165452f, 0.01504093f, -0.01787154f, 
    0.00989576f, -0.06763110f, -0.07882357f, -0.01904345f, -0.27088431f, 0.12462240f, 0.09450148f, 0.02421191f, 
    -0.09776736f, -0.07226010f, -0.06178633f, -0.15594026f, -0.07047214f, 0.01788359f, 0.01085585f, -0.03100922f, 
    0.32910481f, 0.10660351f, 0.30764356f, 0.13687894f, -0.08437548f, 0.02229500f, -0.04260857f, -0.11846467f, 
    -0.00091309f, 0.08143308f, -0.04523141f, 0.03484237f, -0.06004580f, 0.08393435f, -0.23248202f, 0.26752111f, 
    -0.19634394f, 0.22776659f, 0.03113567f, -0.05709923f, -0.08484896f, 0.04854575f, -0.02295081f, 0.01103114f, 
    0.15936437f, 0.20957410f, -0.07318716f, 0.25693345f, -0.11378364f, -0.03815342f, 0.03775892f, 0.17066240f, 
    -0.11321083f, 0.08856556f, 0.04857204f, 0.01706120f, -0.04512794f, -0.31024137f, -0.12397628f, -0.16725124f, 
    -0.05418306f, -0.16635837f, -0.05384845f, 0.01401266f, 0.06761433f, 0.00172583f, -0.06555677f, -0.01542997f, 
    -0.15724719f, 0.18700139f, -0.04252584f, 0.00261134f, -0.00795154f, -0.07510839f, 0.04598454f, -0.04836161f, 
    0.09310301f, 0.03449925f, -0.07230668f, -0.02717467f, 0.10768750f, -0.07764673f, 0.19193438f, -0.19066125f, 
    0.03399697f, 0.12669596f, -0.12435566f, -0.07815517f, -0.07071444f, 0.04586973f, -0.02334865f, 0.01172352f, 
    -0.10411368f, 0.21462967f, 0.20951883f, 0.04500347f, 0.01135128f, 0.07111845f, 0.05221416f, -0.02623760f, 
    -0.08762696f, 0.01173892f, 0.05015812f, -0.10074237f, -0.38734013f, 0.17232633f, 0.12491362f, 0.22689389f, 
    0.17683329f, -0.03036835f, 0.04507700f, 0.06139612f, -0.06125478f, -0.04629597f, -0.01495882f, 0.08862746f, 
    -0.24168788f, -0.18560001f, -0.38565341f, -0.51127249f, -0.03424944f, -0.02155313f, 0.24053504f, -0.09107942f, 
    0.12210427f, -0.09812218f, -0.03559759f, 0.12518425f, 0.01410292f, -0.33291632f, 0.05429785f, 0.04439959f, 
    0.22483429f, -0.10531297f, -0.05229452f, -0.07618558f, 0.00081176f, -0.10725690f, 0.14320369f, 0.08524464f, 
    0.18395247f, 0.01205683f, 0.08172776f, 0.14294989f, 0.03531289f, -0.01888238f, -0.05602716f, -0.06576267f, 
    -0.06087406f, -0.07312316f, -0.07579771f, 0.10532534f, -0.34505236f, 0.02512608f, -0.13476454f, -0.00833154f, 
    0.13666189f, -0.04601543f, -0.25031045f, 0.08579387f, 0.02577555f, -0.06765885f, 0.25287017f, -0.26647803f, 
    0.15615258f, 0.22910035f, -0.10209391f, 0.04922218f, 0.08696228f, -0.03616701f, 0.07842840f, -0.09020372f, 
    0.02347777f, -0.14503697f, -0.14174446f, -0.02463511f, 0.32721937f, 0.18633385f, -0.37668237f, -0.02718326f, 
    0.02176106f, 0.07488422f, -0.04930241f, -0.11421873f, 0.06733757f, 0.08580341f, 0.21393798f, 0.14645396f, 
    -0.40181443f, -0.21798752f, 0.24655309f, -0.05568058f, -0.03555942f, -0.13023265f, -0.03617508f, 0.11778321f, 
    0.01170364f, 0.05844020f, -0.14778072f, 0.15761781f, -0.07854220f, 0.09616700f, -0.03293810f, -0.18886693f, 
    0.03554597f, 0.12851964f, -0.06595775f, -0.00335366f, 0.19448487f, 0.02346656f, -0.00394490f, -0.22691993f, 
    -0.11919586f, 0.14847034f, 0.21388939f, 0.05022903f, -0.11383216f, -0.11440931f, 0.14615388f, -0.00360722f, 
    -0.11563257f, 0.09122438f, 0.09708281f, 0.00667127f, -0.12160214f, 0.18381149f, -0.16340056f, 0.04714488f, 
    0.09771832f, -0.05580335f, -0.08810923f, -0.14206821f, 0.08059817f, 0.13560022f, -0.01846396f, 0.08754858f, 
    0.04308446f, 0.37385890f, -0.23383749f, -0.48356628f, 0.02298478f, -0.17228211f, -0.01588081f, 0.01848074f, 
    0.08598477f, -0.05835769f, -0.13946861f, 0.11399932f, 0.35041615f, -0.07601495f, 0.14276956f, -0.00023513f, 
    -0.16413845f, 0.01818662f, -0.08867461f, 0.14642073f, -0.07204369f, -0.05557018f, -0.14832401f, -0.21315101f, 
    -0.33801949f, -0.14940900f, -0.09378318f, -0.50661761f, -0.07980224f, 0.00979033f, -0.20752819f, -0.06426855f, 
    0.12676616f, -0.05145012f, 0.00516548f, 0.10093810f, -0.25197202f, -0.17447376f, 0.01037260f, -0.57151419f, 
    -0.11319309f, -0.27449891f, -0.00292206f, -0.01251625f, -0.02656148f, -0.02556216f, 0.03003644f, 0.01176354f, 
    0.12749265f, -0.01758734f, -0.02988815f, 0.10174941f, 0.15457000f, 0.04869450f, -0.10503802f, -0.02784360f, 
    0.03119878f, 0.03983092f, 0.14491448f, 0.05689187f, 0.27668267f, -0.07000862f, 0.06781168f, 0.20429841f, 
    0.11580057f, -0.04947324f, -0.04953459f, -0.10992584f, -0.10628127f, -0.01564236f, 0.08619642f, -0.09021476f, 
    0.19385530f, -0.09428387f, 0.09073199f, 0.24675123f, 0.08388022f, 0.05498334f, -0.01606893f, -0.03167988f, 
    0.16617043f, -0.03053521f, -0.00713654f, 0.00445968f, -0.37223050f, -0.08444419f, 0.27868173f, 0.05539199f, 
    -0.08356730f, 0.06735367f, -0.07591968f, -0.21823885f, 0.01041394f, -0.08669855f, 0.04795153f, -0.07740142f, 
    -0.21161014f, -0.15139860f, 0.25336257f, -0.04129913f, 0.02337891f, -0.06009455f, 0.15390551f, -0.01030470f, 
    -0.02765680f, -0.05005332f, 0.07427499f, -0.34593526f, 0.15711378f, 0.05014705f, -0.13335793f, 0.14542091f, 
    0.04626386f, 0.13082348f, -0.12486257f, -0.13163301f, -0.10458275f, -0.19583906f, 0.04458541f, -0.02381509f, 
    -0.23160729f, -0.19732533f, 0.01128823f, 0.00605546f, -0.01526066f, -0.03776747f, -0.01676591f, -0.08806842f, 
    0.09006292f, 0.08907607f, 0.03091297f, 0.00866987f, 0.15003188f, -0.07769482f, -0.19023314f, 0.24432917f, 
    0.16540262f, -0.04363812f, -0.04680414f, -0.04534837f, 0.06923784f, 0.04798204f, 0.16452287f, 0.09190874f, 
    0.14013872f, -0.35858339f, 0.13843830f, -0.06700949f, -0.04811934f, -0.09169705f, 0.01247140f, 0.00526117f, 
    -0.07151560f, -0.19499682f, -0.03969356f, 0.18990624f, 0.05209043f, -0.11588039f, 0.10657459f, 0.06523938f, 
    -0.00151280f, -0.16214783f, -0.03312747f, 0.05292897f, 0.18337271f, 0.01579186f, 0.00841041f, 0.00351420f, 
    -0.16215028f, 0.12735367f, 0.20728128f, -0.13668770f, 0.04030050f, 0.13037603f, -0.07970226f, 0.07850490f, 
    0.03301234f, 0.02142130f, -0.02690692f, 0.03265165f, -0.13316427f, -0.05227148f, -0.15194535f, -0.17379704f, 
    -0.11766146f, -0.06022520f, 0.03767238f, -0.04952575f, 0.16971599f, -0.01140471f, -0.11671934f, -0.43961957f, 
    0.00484803f, 0.05659926f, -0.18194309f, -0.25185952f, -0.07241057f, -0.18920726f, -0.36153191f, 0.09964477f, 
    0.07306322f, 0.02155199f, 0.16760720f, -0.06055670f, 0.06965954f, -0.22580068f, -0.18421915f, 0.05221759f, 
    0.07858955f, -0.02060340f, 0.02794501f, -0.02535570f, 0.17058140f, 0.19150732f, 0.11169165f, 0.00173241f, 
    0.14158292f, 0.39840376f, -0.21422516f, 0.07309972f, -0.16098376f, 0.10524275f, -0.29773208f, -0.05429974f, 
    -0.04013189f, -0.19279926f, 0.03400462f, 0.08486242f, -0.22378974f, -0.24622642f, 0.28247949f, -0.03174122f, 
    -0.17727666f, -0.12024453f, 0.08234917f, -0.11544995f, 0.04396945f, 0.02444996f, -0.11527357f, -0.09644064f, 
    -0.05165596f, -0.03300447f, 0.18655375f, 0.05175943f, -0.10535774f, 0.07405717f, -0.08959986f, 0.00813574f, 
    0.15893842f, -0.13158165f, -0.13193031f, 0.03908522f, -0.04575649f, 0.24877496f, -0.14281765f, 0.09396953f, 
    -0.12845498f, 0.01999073f, -0.06646435f, -0.05913943f, -0.03201934f, -0.05877939f, 0.06556841f, 0.12034449f, 
    -0.00256130f, -0.06000098f, -0.00477671f, -0.14853154f, -0.03364589f, 0.10200281f, -0.09362408f, -0.05801494f, 
    -0.11542770f, 0.01492365f, 0.02090016f, 0.00547876f, -0.38575426f, 0.18747783f, 0.14527637f, -0.17091212f, 
    -0.01104224f, -0.24205571f, 0.02612298f, 0.02649044f, 0.12834057f, 0.10565595f, 0.06372073f, -0.06191412f, 
    -0.06576453f, 0.22884341f, 0.15955439f, -0.24946626f, 0.12567620f, 0.04629714f, -0.04080208f, -0.17475320f, 
    0.04124185f, -0.09205285f, 0.16581437f, -0.05949526f, 0.09835462f, -0.57577318f, -0.10386839f, -0.15614752f, 
    -0.08915265f, -0.04481646f, -0.09516255f, 0.21543097f, -0.10763242f, -0.00021070f, 0.15519084f, 0.09553191f, 
    0.14417920f, 0.33397961f, 0.09508780f, 0.23407190f, -0.06787300f, 0.03365966f, -0.04609418f, -0.13598086f, 
    0.09110333f, -0.13925043f, 0.04616473f, 0.12367811f, 0.21657270f, 0.26400128f, -0.15261614f, 0.05035093f, 
    -0.06836116f, 0.10787148f, 0.29888135f, 0.07344769f, -0.00358628f, 0.10040522f, -0.01375652f, 0.01812912f, 
    0.57204556f, 0.10819201f, -0.12125304f, 0.21561645f, 0.00052436f, -0.02279052f, 0.09429839f, 0.02752464f, 
    0.03484955f, 0.01066409f, 0.20972900f, -0.03858943f, 0.75458312f, 0.10283178f, -0.01771457f, -0.20792705f, 
    -0.07702064f, 0.11084507f, 0.15661432f, -0.05155494f, -0.04101684f, 0.03678788f, 0.04509335f, 0.02893375f, 
    0.09181107f, 0.59915125f, -0.17582126f, 0.11457753f, 0.14866254f, -0.03393385f, 0.17570835f, 0.06421471f, 
    -0.12804167f, 0.01797469f, 0.10892883f, 0.12676737f, -0.31644151f, 0.10558067f, 0.11161537f, -0.08997803f, 
    -0.05960090f, -0.00129321f, 0.06407792f, -0.03167254f, 0.02057521f, -0.04395404f, 0.08113615f, 0.14727567f, 
    -0.16396843f, -0.13089840f, 0.00918172f, -0.13429631f, 0.06239551f, -0.13868377f, -0.06564218f, 0.08754666f, 
    0.07475049f, -0.02500929f, 0.06711978f, 0.11970754f, -0.21828645f, -0.02185008f, -0.00317256f, -0.09184319f, 
    0.02994821f, 0.04580395f, 0.06403162f, -0.18861446f, -0.05359746f, 0.03612349f, 0.02480265f, 0.07968666f, 
    0.07186796f, -0.10542458f, -0.03457833f, 0.11743605f, -0.11598042f, 0.01167763f, -0.00216734f, -0.17796573f, 
    -0.04814491f, -0.07329625f, -0.06887015f, -0.05687854f, 0.12256065f, 0.11776147f, -0.21800011f, -0.16487041f, 
    0.04108969f, 0.09705073f, -0.02136876f, -0.16317916f, -0.07526021f, -0.04425570f, 0.10494655f, 0.01868682f, 
    0.02516996f, -0.60004866f, 0.18872453f, -0.27081397f, 0.00823513f, -0.14378521f, 0.00492025f, -0.00973300f, 
    -0.13532394f, -0.00028867f, 0.10287582f, -0.05770595f, -0.39978686f, 0.17040838f, -0.25229785f, 0.03575479f, 
    0.04086008f, -0.01520794f, 0.05668233f, 0.02480211f, 0.07569025f, 0.06073303f, -0.06950814f, 0.00541081f, 
    -0.43941224f, 0.38526300f, -0.33371085f, -0.47782022f, 0.12468062f, -0.00746965f, 0.04371125f, -0.08216176f, 
    -0.11743733f, -0.04308156f, 0.09510416f, -0.09847865f, 0.09555069f, -0.33999985f, -0.01651509f, -0.00583929f, 
    0.10225121f, 0.01024111f, 0.08086691f, 0.10178524f, 0.11028498f, 0.03414839f, -0.00770086f, 0.02182442f, 
    -0.26855350f, -0.21159180f, 0.06712577f, 0.09048808f, 0.07270037f, -0.05780878f, -0.28040347f, -0.07897140f, 
    0.00827788f, 0.08358828f, 0.04926418f, 0.14692269f, 0.31426087f, -0.34296981f, -0.02476642f, -0.10025961f, 
    0.09966055f, 0.09307283f, -0.14059208f, -0.12447689f, -0.00707295f, 0.07351477f, -0.10777245f, 0.09503467f, 
    -0.23101526f, 0.27150109f, -0.05161582f, -0.25397262f, 0.03919513f, 0.01370561f, -0.01471558f, -0.26032522f, 
    -0.14181927f, -0.04052201f, 0.08400863f, -0.04299388f, -0.17676839f, 0.19739762f, -0.04695307f, -0.21665634f, 
    0.01400662f, -0.07221896f, -0.09966561f, 0.02278924f, 0.00074987f, 0.09322291f, -0.19745746f, -0.10228498f, 
    -0.05393736f, 0.08443668f, 0.19004798f, -0.13199669f, 0.26388699f, 0.10160628f, -0.15698516f, 0.04902495f, 
    0.17706889f, 0.01579808f, 0.16684620f, -0.02655638f, -0.33131841f, 0.18400574f, -0.26455271f, -0.01742321f, 
    0.04492616f, -0.10406329f, -0.09760260f, -0.02925171f, -0.03684299f, 0.01790834f, -0.10931466f, 0.01604813f, 
    -0.01546557f, -0.26456422f, -0.08606307f, 0.12247418f, -0.12275297f, 0.02424545f, -0.01745626f, 0.25921854f, 
    -0.07369188f, 0.24179396f, -0.13750911f, -0.13444170f, -0.59240556f, 0.39155617f, 0.10291522f, 0.25036961f, 
    0.05290339f, 0.15435192f, -0.28353336f, -0.07382694f, -0.11326170f, -0.16345416f, 0.12366392f, 0.17563103f, 
    -0.48566797f, -0.06807139f, 0.36834747f, -0.27648395f, -0.04811148f, 0.03716788f, 0.10834292f, -0.00275403f, 
    -0.01794863f, -0.09872099f, -0.10359748f, 0.04758108f, -0.16483134f, 0.06323842f, -0.02401851f, -0.58543968f, 
    0.07817392f, -0.08325408f, -0.06035678f, -0.08227251f, -0.14629863f, -0.12305499f, -0.07240754f, -0.25558773f, 
    -0.36125317f, 0.17670275f, 0.37141418f, -0.04332072f, 0.11027048f, 0.02276767f, 0.11089549f, 0.13544886f, 
    0.09264687f, 0.07239684f, 0.00889688f, 0.05226630f, 0.33953112f, -0.11930487f, -0.01264466f, 0.25948605f, 
    -0.08399651f, 0.03911345f, -0.00598708f, -0.03739191f, 0.16526711f, -0.09270596f, -0.00851236f, -0.04504144f, 
    -0.29756269f, -0.55519545f, -0.02773312f, -0.13024826f, 0.16146950f, 0.08047117f, 0.02791703f, -0.10351300f, 
    0.03979876f, 0.02398115f, -0.16042466f, 0.02812593f, 0.06925216f, -0.46096209f, 0.21918747f, 0.01173885f, 
    0.07522797f, 0.01160455f, -0.02617699f, 0.12246207f, -0.19798639f, -0.14468153f, 0.10285620f, -0.05231849f, 
    0.04328982f, 0.21010418f, 0.24399333f, -0.07435433f, 0.04515925f, 0.09289761f, 0.22327366f, 0.06062335f, 
    0.15474597f, -0.11056640f, 0.12099546f, 0.04734319f, -0.33000502f, -0.06023289f, 0.05784848f, -0.13637209f, 
    0.25214112f, -0.11195343f, 0.02501121f, -0.17189772f, -0.14221093f, -0.08419793f, -0.05059341f, 0.10647704f, 
    -0.31114057f, -0.14629856f, -0.06351814f, -0.32524201f, 0.01494684f, 0.08310531f, -0.06844820f, -0.05662230f, 
    -0.04533800f, -0.01927275f, -0.01716967f, 0.04331430f, -0.71888483f, 0.14074844f, -0.24277431f, 0.04182883f, 
    0.33446315f, 0.03234412f, -0.05021409f, 0.03634169f, 0.07200570f, 0.00454646f, 0.04694308f, -0.25756726f, 
    -0.04076705f, -0.14704430f, -0.00861873f, 0.03874941f, 0.06192925f, -0.10720114f, 0.14141749f, -0.10539432f, 
    0.13736586f, 0.07929821f, -0.01673842f, 0.02490747f, -0.70780098f, -0.47255543f, -0.13529862f, 0.05776427f, 
    0.06469653f, -0.12168132f, -0.00547558f, -0.08352661f, 0.03600150f, -0.04687213f, 0.21830478f, 0.09404653f, 
    0.15891500f, 0.19333716f, -0.00954892f, -0.02305126f, 0.01545404f, 0.00294169f, 0.05746763f, 0.05199168f, 
    0.05903235f, -0.07950054f, 0.10614601f, 0.14638558f, -0.75615424f, -0.31605160f, 0.13949470f, 0.24414544f, 
    0.07257256f, -0.06192444f, -0.00686941f, -0.12395166f, 0.00352879f, -0.00145226f, -0.16972478f, -0.02724224f, 
    0.01190848f, -0.10001922f, 0.12908368f, 0.18904889f, -0.03531634f, -0.10035402f, 0.00828904f, 0.11851339f, 
    0.05191543f, 0.05109804f, -0.10099469f, 0.02074713f, -0.60515994f, -0.63797724f, -0.03902487f, 0.14271455f, 
    0.14444107f, 0.15549231f, 0.07330129f, -0.12592070f, 0.05659701f, -0.09291757f, -0.06226303f, 0.09467369f, 
    -0.14160019f, 0.18844907f, -0.11162161f, 0.15102133f, 0.18249062f, 0.14314717f, 0.11396867f, -0.08160514f, 
    0.04511395f, 0.22979337f, 0.00865597f, 0.07588102f, 0.59975410f, 0.18143328f, -0.29980862f, 0.14611514f, 
    -0.23340914f, -0.12406925f, 0.02642374f, 0.04856249f, -0.03469079f, -0.00191886f, 0.04119934f, -0.20301536f, 
    0.19393185f, 0.06424533f, 0.16849630f, -0.01301617f, 0.11957445f, 0.25574797f, 0.03381942f, 0.11182613f, 
    -0.00065083f, 0.08005423f, 0.14486711f, 0.11329777f, 0.10473827f, -0.04780501f, -0.00907154f, 0.01706913f, 
    -0.04513779f, 0.00320566f, -0.07635948f, -0.08258052f, -0.11438734f, 0.01951884f, -0.06029525f, -0.22242713f, 
    -0.64403069f, 0.27850547f, -0.17380723f, -0.19266903f, 0.23346779f, 0.02593449f, -0.04782328f, 0.10806055f, 
    0.09612221f, 0.21784262f, 0.04582104f, 0.17689137f, -0.59095365f, -0.29395202f, -0.34109417f, -0.21395388f, 
    -0.03426552f, 0.06408911f, -0.02404701f, -0.06813593f, -0.05148441f, 0.00278947f, -0.09758241f, -0.03722198f, 
    -0.52270210f, -0.17844136f, -0.16826713f, -0.38909680f, 0.07812630f, 0.09886003f, 0.08356961f, 0.07084282f, 
    0.16962111f, 0.04476880f, 0.10353719f, -0.00342718f, 0.31486902f, 0.19551866f, 0.08368286f, -0.22972533f, 
    -0.18368687f, -0.06961043f, 0.01247127f, -0.04710896f, 0.01028137f, -0.14423817f, -0.18519036f, -0.01661630f, 
    0.23550060f, -0.04587546f, -0.03700449f, -0.00163396f, -0.28465027f, -0.07171879f, 0.07197169f, -0.08779111f, 
    0.20175092f, 0.20643455f, 0.06359479f, -0.17058562f, -0.18154404f, 0.13766791f, -0.33124530f, -0.06432503f, 
    0.04932284f, 0.07767221f, -0.07462767f, 0.01340809f, 0.21137616f, 0.11036824f, 0.14397877f, 0.00052613f, 
    -0.07591464f, -0.35148489f, 0.13036799f, -0.13027526f, 0.11391509f, -0.00017759f, 0.05826138f, -0.00614551f, 
    0.11715280f, 0.04299984f, 0.05194722f, 0.15625760f, -0.91486883f, -0.39746672f, -0.24724770f, -0.27366385f, 
    0.08839978f, -0.06581359f, -0.19398358f, -0.08883844f, -0.01164124f, -0.03032533f, 0.15546563f, -0.01964091f, 
    -0.16412397f, 0.03206903f, 0.04205181f, 0.10383147f, 0.00844834f, -0.11457140f, -0.01195904f, -0.02081862f, 
    -0.02036822f, -0.13020200f, 0.04600353f, 0.10787325f, -0.00866215f, 0.13980836f, -0.06913279f, -0.20614986f, 
    0.06935722f, -0.12052394f, -0.01022737f, 0.03064749f, -0.01042093f, -0.11187270f, -0.05553495f, -0.17075060f, 
    0.30137655f, 0.07755090f, 0.05255911f, -0.17956018f, -0.09890120f, 0.20037703f, 0.00024252f, -0.02872982f, 
    0.03145532f, -0.02696458f, 0.01613087f, -0.13813023f, -0.28790525f, -0.06374814f, 0.24423487f, -0.00491046f, 
    0.06619129f, -0.00455367f, -0.09763917f, 0.03690943f, 0.13500960f, -0.04610088f, -0.20040101f, -0.18601795f, 
    -0.23097347f, -0.36397699f, -0.26538384f, -0.00398426f, 0.16520101f, 0.00141488f, -0.02830029f, 0.05588075f, 
    -0.02970719f, 0.04019402f, 0.02188808f, -0.11752193f, 0.24177615f, 0.26932618f, -0.01220161f, -0.20532481f, 
    -0.01791682f, -0.05710196f, -0.03246067f, 0.21323469f, 0.04165036f, 0.18280636f, 0.19513725f, 0.25090536f, 
    -0.10321410f, -0.11894581f, -0.19586807f, -0.05522014f, -0.12666710f, -0.01888824f, -0.02948069f, 0.10089502f, 
    -0.02275497f, -0.10611631f, 0.02134312f, -0.02445054f, 0.40440452f, 0.05506839f, -0.05540093f, 0.12143990f, 
    -0.10142914f, -0.02902561f, 0.01657642f, -0.03625773f, -0.04807419f, 0.00193160f, -0.05133211f, 0.05107404f, 
    0.22064619f, 0.19425867f, -0.17012063f, 0.15180159f, 0.02301091f, -0.01859854f, -0.05213346f, -0.04859459f, 
    0.07724682f, 0.10992621f, 0.09465448f, 0.12643468f, 0.10483298f, -0.03245250f, 0.00641842f, -0.00059748f, 
    -0.14319785f, 0.04967657f, 0.03464148f, -0.06508402f, 0.15767215f, 0.22925223f, 0.02849754f, 0.09561155f, 
    0.35834968f, 0.00781673f, 0.09571230f, 0.21419619f, -0.03479309f, -0.10507961f, 0.07379792f, 0.05932257f, 
    -0.04114215f, -0.14797583f, -0.05080648f, -0.01941721f, 0.23967560f, 0.17421533f, -0.22716348f, -0.42978120f, 
    0.05790416f, -0.05928943f, -0.06392024f, 0.17132907f, -0.03907465f, 0.12705936f, 0.07538178f, 0.09733454f, 
    -0.15069103f, -0.16446732f, -0.23979011f, -0.42204449f, -0.05640770f, 0.06167261f, 0.00096828f, 0.15142065f, 
    0.03873625f, 0.05412601f, 0.03654572f, -0.16154364f, -0.10700763f, 0.12494678f, -0.11719258f, -0.00474943f, 
    0.07968143f, 0.07684396f, -0.00469775f, 0.14086570f, 0.20388006f, 0.05140080f, -0.09087906f, 0.20895113f, 
    0.13386290f, -0.24887340f, 0.11902858f, -0.13929847f, 0.06346533f, -0.04444176f, -0.09042732f, -0.02553367f, 
    -0.09666672f, 0.08703611f, 0.00045836f, -0.00025757f, 0.24337533f, -0.21875565f, 0.05429705f, -0.11869305f, 
    0.16384855f, -0.03482520f, -0.15996839f, -0.01363656f, 0.00529506f, 0.05694121f, -0.16521080f, -0.05574637f, 
    -0.09158717f, 0.18964231f, 0.07329842f, -0.32130909f, 0.09377627f, 0.19122714f, -0.13202229f, -0.05032017f, 
    -0.09543273f, -0.03008302f, 0.00450072f, -0.15512821f, 0.38004830f, 0.06819689f, -0.10062886f, -0.46163762f, 
    0.11530573f, -0.15776780f, -0.13528062f, 0.29845127f, -0.17507592f, 0.01578723f, 0.19418110f, 0.08024985f, 
    0.21067984f, -0.31713229f, 0.32547364f, 0.08800030f, -0.05657719f, 0.01031228f, 0.04028415f, -0.08165240f, 
    -0.08875026f, 0.01251279f, 0.00462575f, -0.06865588f, -0.39080688f, 0.40158468f, -0.00856368f, 0.16914430f, 
    0.19230792f, -0.03079684f, 0.06404243f, 0.01683937f, 0.07938666f, 0.03793475f, 0.08659374f, 0.00090651f, 
    -0.00120268f, -0.44140843f, -0.16159040f, 0.18751472f, -0.35161468f, 0.10361160f, -0.26311541f, -0.15910265f, 
    0.16173251f, 0.10850044f, 0.10980441f, 0.03712320f, -0.30034596f, -0.37864226f, 0.04778222f, -0.01496269f, 
    0.22961120f, 0.01931566f, 0.15882502f, -0.02829130f, 0.01784278f, -0.09968304f, 0.05278382f, 0.08621475f, 
    0.05769490f, 0.29371113f, 0.02230250f, 0.08133074f, -0.23260766f, -0.01998574f, 0.05105118f, -0.19216652f, 
    -0.14319642f, -0.15787390f, -0.09421958f, -0.12213973f, -0.05280499f, -0.30633068f, 0.09821131f, 0.00834108f, 
    -0.34176496f, 0.13082735f, -0.11233559f, -0.14098777f, -0.19558114f, -0.15032205f, -0.03705388f, -0.23482499f, 
    0.16725110f, -0.20163804f, 0.12357903f, 0.33776686f, 0.05585371f, 0.16454868f, 0.08768295f, 0.26498821f, 
    0.01279161f, -0.06014667f, 0.07938148f, 0.09226453f, -0.28430369f, -0.20038304f, -0.21680163f, -0.23570719f, 
    0.09470187f, 0.11470291f, 0.03631663f, 0.10065906f, 0.11472853f, -0.04765508f, 0.00793221f, -0.00498973f, 
    0.46304640f, -0.51555330f, -0.13542423f, 0.08706260f, -0.02738935f, -0.03108098f, -0.09173351f, -0.17903303f, 
    0.09111452f, 0.03259787f, -0.04902251f, -0.03796760f, 0.20348257f, -0.06914208f, -0.05180577f, 0.01572212f, 
    -0.03011769f, -0.06836258f, 0.12708251f, -0.11090106f, 0.16268200f, -0.07543345f, 0.02255270f, 0.02348142f, 
    -0.09791218f, 0.03372944f, -0.00158927f, 0.04236167f, -0.02935218f, -0.03773686f, -0.20650239f, -0.08355970f, 
    -0.05316267f, 0.01563810f, 0.10749185f, 0.08214597f, -0.15360045f, -0.18871407f, -0.09050650f, 0.07194308f, 
    -0.12362965f, -0.03877880f, 0.00172745f, 0.01050605f, -0.10028080f, 0.13125987f, 0.11935454f, -0.05094987f, 
    0.35937381f, 0.07060430f, -0.64976293f, 0.37732172f, 0.06745198f, 0.00736488f, 0.01315462f, -0.05796876f, 
    -0.06379641f, 0.01607045f, 0.06050437f, -0.03549372f, 0.56185657f, -0.20915174f, -0.15100832f, 0.04345132f, 
    -0.01468632f, -0.07466526f, 0.02888842f, -0.06151330f, -0.04139404f, -0.08933789f, 0.00036788f, -0.00977149f, 
    0.09311839f, -0.01616342f, 0.03649080f, -0.15937848f, -0.05181426f, 0.04891710f, -0.10173502f, 0.01534170f, 
    -0.15938289f, 0.06173988f, 0.01734401f, 0.06536714f, 0.05176891f, -0.30292043f, 0.10477068f, -0.24264854f, 
    0.06611903f, 0.05562546f, 0.15070453f, -0.21184182f, -0.02164504f, -0.01343758f, -0.01425476f, 0.03718827f, 
    -0.45629323f, 0.37542853f, -0.00329578f, 0.04668477f, 0.06147323f, -0.04648447f, -0.02135630f, -0.17906912f, 
    -0.00409692f, 0.07780278f, 0.08843759f, -0.17150794f, 0.26517227f, 0.22309172f, -0.18528765f, 0.07548308f, 
    0.08484929f, -0.08657333f, -0.04549962f, 0.03453961f, 0.03568396f, 0.04842718f, -0.00511555f, 0.16997080f, 
    0.07153714f, -0.25912514f, -0.09324946f, 0.10692319f, 0.10095204f, -0.00795408f, -0.10010861f, 0.06595425f, 
    0.08378760f, -0.10876039f, 0.15303369f, 0.14315502f, 0.09604097f, 0.02731711f, -0.23588237f, 0.14140067f, 
    -0.00415260f, -0.02213158f, -0.03012152f, 0.04259121f, 0.04052323f, -0.04919834f, -0.10491730f, -0.08985518f, 
    -0.17527056f, -0.21780038f, -0.04469532f, 0.03705864f, 0.11185996f, 0.03336623f, 0.19366525f, -0.02308301f, 
    0.07127605f, 0.01215423f, -0.06658843f, -0.02724073f, 0.01757084f, 0.18204632f, 0.11639067f, -0.23137845f, 
    -0.02458820f, -0.11460362f, -0.01561793f, -0.00074403f, -0.03363704f, 0.02027134f, 0.17735566f, 0.01999957f, 
    0.16199301f, 0.10891590f, -0.03903292f, -0.13246520f, -0.09179681f, -0.08072553f, 0.25690338f, 0.00151430f, 
    -0.04745333f, -0.19107223f, -0.11466303f, -0.09792499f, 0.04393276f, -0.26713318f, -0.03304014f, 0.23065238f, 
    -0.13652189f, 0.10123409f, 0.00368744f, -0.00740195f, -0.14961250f, 0.06373148f, 0.09320872f, -0.21279377f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14857139f, -0.00515588f, -0.01870237f, 0.01123299f, -0.00551139f, 0.03218822f, -0.00335112f, -0.05046415f, 
    0.00637115f, 0.04275179f, 0.14112915f, 0.06788224f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
