#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.13921718f, -0.22683837f, -0.39360946f, -0.83555228f, -0.90528637f, 0.61065346f, 0.48644352f, 0.08348996f, 
    0.02731971f, 0.07035751f, 0.22686698f, 0.12286134f, -0.18112203f, -0.40696988f, -0.73517287f, 0.03894839f, 
    -0.50410998f, -0.32288393f, 0.35128009f, -0.08025669f, 0.21977171f, 0.31304738f, 0.32623723f, 0.49702668f, 
    0.15345304f, -0.62721908f, -0.34059817f, -0.14104502f, -0.91784096f, -0.54339147f, -0.86376584f, -1.11413205f, 
    -0.65792388f, -0.50356656f, 0.17582904f, 0.23995887f, 0.27932364f, -0.18582202f, -0.16814283f, -0.59405136f, 
    -0.72918129f, -0.75648934f, -0.53062397f, -0.66186082f, -0.88041204f, 0.04814120f, -0.15067005f, -0.21394639f, 
    0.44393453f, 0.15417501f, -1.46034276f, -1.04739523f, -0.78012383f, -0.17752549f, -0.70467091f, 0.76681793f, 
    0.22308198f, 0.58780760f, 0.60481328f, 0.53089285f, 0.43721229f, 0.24865346f, 0.30160713f, 0.39564034f, 
    -0.18934684f, -0.27959788f, 0.03602232f, 0.03322338f, -0.06560819f, -0.14004600f, -0.10704731f, 0.16542029f, 
    0.26910019f, -0.02470604f, -0.21416867f, -0.56573695f, -0.34277877f, -0.50502831f, -1.48234749f, -1.31987584f, 
    -0.00200809f, 0.21998607f, 0.28644484f, 0.98344046f, -0.13394983f, -0.16538610f, -0.77259481f, 0.63712424f, 
    -0.87345719f, 0.23354411f, -0.19735232f, 0.20092051f, 0.20387112f, -0.30513543f, 0.26743999f, -0.07004648f, 
    0.47303703f, -0.32362279f, -0.06802205f, 0.71394873f, -1.31759572f, -0.15811643f, 0.09433164f, 0.81736946f, 
    0.05025221f, 0.21439256f, 0.62570339f, 0.27477321f, -0.12182949f, -0.52921170f, 0.04965770f, -0.05417549f, 
    -0.12386938f, 0.66817635f, 0.06315045f, -0.22012953f, -0.32697067f, -0.53838271f, -0.03676500f, 0.56514609f, 
    0.15369232f, -0.23465037f, 0.35819212f, 0.00294401f, 0.04128660f, -0.63037956f, -1.32571948f, -0.11907016f, 
    0.73591018f, 0.78535038f, -0.24931368f, -0.13669007f, 0.21428458f, 0.88809335f, 0.89607543f, 0.10248869f, 
    -0.14628051f, -0.48599768f, -0.06367374f, 0.45702952f, -0.00157963f, -0.04474443f, 0.04776277f, 0.10811168f, 
    -0.52499181f, 0.06263218f, 0.03703028f, -0.08407401f, -0.24303430f, 0.03986555f, 0.67091727f, 0.34633571f, 
    0.34653509f, 0.38669515f, -0.13854417f, 0.33055040f, 0.38528344f, 0.29058853f, 0.26758352f, 0.18999925f, 
    0.05965245f, 0.19165994f, -0.02861588f, -0.33612910f, 0.05230940f, -0.08982933f, 0.16209255f, -0.27587870f, 
    -0.26863271f, -0.49857026f, 0.11878473f, -0.15949538f, -0.01699067f, 0.01967740f, 0.05834704f, 1.22826231f, 
    1.53498745f, 0.76872742f, -0.32343450f, -0.89214599f, -0.50475353f, -0.20417748f, -0.05156042f, -0.15735869f, 
    -0.26797900f, 0.02457238f, -0.00383470f, 0.19702876f, -0.30149475f, -0.67601824f, -0.22350399f, 0.10634939f, 
    -0.05648034f, 0.18963058f, -0.09059583f, -0.01227745f, 0.29764628f, -0.31981918f, -0.26034746f, -0.20313321f, 
    -0.66540492f, -1.09810615f, -0.41263321f, 0.39244440f, 0.00457441f, -1.21641290f, -1.18916845f, -0.62653196f, 
    -0.62163883f, -1.08518147f, 0.67527241f, -0.51140553f, -0.28715220f, 0.85546112f, -0.63190484f, 0.18333666f, 
    0.01352451f, 0.29681703f, 0.25365815f, 0.26333240f, 0.11358096f, 0.17332046f, 0.02828037f, -0.13433778f, 
    0.31264830f, 1.93128109f, -0.76101357f, -0.96440744f, -0.38353789f, -0.33750296f, 0.51120096f, 0.50106841f, 
    0.51495063f, 0.12442181f, -0.68807667f, -0.31245822f, 0.58371520f, 0.01924150f, -0.16624156f, -0.23488045f, 
    -0.01699792f, -0.28027308f, -0.15972938f, -0.13317004f, -0.12857756f, -0.11936727f, -0.33243233f, -0.12022474f, 
    -0.17880546f, -0.31861633f, -1.47106731f, -0.79866791f, -0.44645515f, -0.09731980f, 0.32554191f, 0.49026313f, 
    0.25382775f, -0.56033313f, -0.60542399f, 0.32729289f, 0.04094312f, 0.00939884f, -0.45763120f, 0.10247454f, 
    -0.79506445f, -0.02906026f, -0.32978362f, -0.29589257f, -0.10653057f, -0.68251657f, -0.45284632f, -0.47500187f, 
    -0.84792042f, -0.41392273f, -0.43612173f, 0.14301494f, -0.51354158f, 0.02611372f, 0.35748899f, -0.17755044f, 
    1.32054412f, -0.88252586f, -0.76190162f, 0.13579839f, 0.63160181f, 0.06757552f, -0.06149553f, -0.02395743f, 
    -0.25259918f, -0.00125281f, -0.50148040f, -0.13126673f, 0.43646291f, -0.08302415f, 0.32762167f, -0.44568184f, 
    0.09306605f, 0.25180376f, 0.34696150f, -0.26352867f, 0.61551124f, 0.65078402f, 0.68032318f, 0.00663696f, 
    0.09291276f, -0.00107534f, -0.65616995f, -0.66355973f, -0.65398991f, 0.00564375f, -0.20871423f, -0.06975895f, 
    -0.04095008f, 0.49459997f, 0.13436499f, 0.45023176f, -0.26545331f, -0.04195626f, 0.23240191f, -0.36498010f, 
    -0.10057835f, 0.13704668f, 0.11774226f, 0.02576946f, 0.47657585f, 0.80014449f, -1.03248894f, -1.02315807f, 
    0.18000963f, 0.40013564f, 0.89957350f, 0.03505854f, 1.04067504f, -0.41498035f, -0.32217196f, -0.39522833f, 
    -0.07691076f, 0.15064500f, -0.36146063f, -0.01958951f, -0.11763673f, -0.07937428f, 0.17736579f, 0.10737532f, 
    -0.09476230f, 0.17714493f, -0.11249778f, -0.25063947f, -0.06725857f, 0.39042583f, -1.35057712f, -0.75992447f, 
    -1.02851510f, -0.89653367f, -0.80035436f, 0.37532863f, 0.21951625f, -0.18284072f, -0.06748375f, 0.36520019f, 
    -0.50882190f, -0.71954870f, -0.64957482f, 0.03890907f, 0.51720500f, 0.20883274f, 0.28687152f, -0.32156810f, 
    -0.13510081f, -0.05561530f, -0.18148643f, -0.31058797f, 0.06958361f, -0.09185910f, -0.23629853f, 1.32461202f, 
    0.26051939f, -0.96650952f, -0.80662447f, -1.31927657f, -0.12493829f, -0.02762483f, 0.06886996f, 0.22573489f, 
    0.40138313f, 0.21816140f, 0.51383531f, 0.24268037f, -0.01092349f, 0.37986094f, -0.07753272f, -0.24205099f, 
    0.27345484f, -0.00226502f, -0.40154913f, -0.02581960f, -0.15510039f, -0.19856814f, -0.13205814f, -0.18228665f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28755146f, -0.02580572f, 0.15807313f, 0.08622854f, 0.66557044f, 0.78732532f, -0.14885870f, 0.89944065f, 
    0.43639454f, 0.45580184f, -0.09300870f, 0.52839273f, 0.25351071f, 0.42269710f, -0.42442659f, 0.21988565f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12763697f, -0.06983984f, -0.45432267f, -0.20353074f, 0.14143705f, 0.02020416f, 0.04810610f, -0.06869509f, 
    0.06565077f, -0.24767998f, -0.16022238f, -0.04949894f, 0.35874909f, 0.27468556f, 0.10781964f, -0.29616958f, 
    0.25783947f, 0.17086421f, -0.09412249f, -0.03993478f, -0.22292031f, -0.23775753f, -0.10881721f, -0.17734621f, 
    0.31141713f, 0.16838969f, 0.11947946f, 0.08002390f, 0.23324730f, 0.13137420f, -0.02795237f, -0.03435279f, 
    -0.02552974f, 0.06217272f, -0.09768705f, -0.00339105f, 0.23727617f, -0.24873839f, 0.00345481f, -0.15757051f, 
    0.08823027f, 0.28568438f, -0.22930641f, -0.08437777f, 0.04364747f, -0.05737311f, 0.07647064f, -0.05167112f, 
    0.14056858f, -0.53972083f, -0.15099093f, -0.19024232f, 0.11983895f, -0.01521237f, -0.07310367f, 0.04858120f, 
    -0.21344012f, -0.47953480f, -0.33760449f, -0.17421983f, 0.12926210f, 0.20874272f, 0.29412210f, -0.34393194f, 
    -0.09508863f, -0.03292830f, 0.10623598f, -0.03842260f, 0.12660058f, -0.16069452f, -0.15385377f, -0.06867602f, 
    -0.54326725f, -0.59938675f, -0.30040485f, 0.03937561f, 0.14642574f, 0.11007317f, 0.11279957f, 0.00223485f, 
    -0.15785339f, 0.01410770f, -0.15538487f, -0.12734284f, -0.88972938f, -1.11941826f, -0.33934122f, 0.38754487f, 
    0.09103935f, 0.02589501f, -0.11449021f, -0.02454988f, -0.03829745f, -0.03690540f, -0.02819933f, 0.14195539f, 
    0.56914020f, 0.42223734f, -0.11759908f, -0.60632426f, -0.04402695f, 0.04557494f, -0.05022712f, 0.11755164f, 
    0.00181988f, -0.01959814f, -0.07009312f, -0.12573835f, -0.05576926f, -0.54394108f, -0.75954139f, 0.17894036f, 
    -0.02755315f, -0.26757488f, -0.05489309f, -0.08796842f, -0.01521156f, -0.11602877f, -0.33765349f, -0.00697235f, 
    0.61650985f, 0.30782619f, -0.12678397f, -0.06485394f, -0.10758328f, 0.06482403f, 0.05361030f, 0.10418697f, 
    0.04286468f, -0.13127649f, 0.19251572f, 0.13881573f, 0.26728261f, 0.04910839f, -0.13990085f, -0.12366650f, 
    -0.16640797f, -0.13063239f, -0.04454377f, -0.04469403f, -0.09227803f, -0.08035399f, -0.05099566f, -0.01192208f, 
    -0.02480464f, 0.02642121f, -0.19110735f, -0.06766714f, 0.02483722f, -0.26114255f, 0.04069930f, -0.16879417f, 
    -0.03442397f, -0.02563377f, 0.10072891f, 0.08938864f, 0.07513981f, -0.73624808f, -0.88191313f, -0.27443981f, 
    -0.13086298f, 0.10611460f, 0.17849316f, -0.03751598f, -0.16842978f, 0.04104254f, -0.13554241f, -0.08673084f, 
    0.48737434f, 0.17549410f, 0.00851885f, -0.19112860f, 0.25253785f, 0.48408321f, -0.02169237f, 0.27341306f, 
    -0.09177149f, 0.08233973f, 0.08682879f, -0.01335521f, 0.15246792f, -0.36483708f, -0.16153969f, 0.23229043f, 
    0.11062247f, 0.03795444f, 0.04472985f, -0.00927475f, -0.16870448f, 0.11206486f, -0.13096887f, 0.10184596f, 
    0.28918150f, 0.25813508f, -0.05674344f, -0.30863032f, 0.01495431f, 0.07359715f, 0.34082016f, 0.10268965f, 
    -0.17884903f, -0.02587072f, -0.32906112f, -0.02115101f, -0.06540038f, -0.25033304f, -0.12038109f, 0.24208197f, 
    0.00725029f, 0.27196255f, -0.19948797f, 0.30875966f, 0.16613984f, -0.10494543f, -0.04546794f, 0.10752111f, 
    -0.15331490f, -0.24980366f, -0.31514025f, -0.13279736f, -0.10820512f, 0.07440846f, 0.11617904f, 0.03884211f, 
    -0.17155308f, 0.06226419f, 0.03248875f, -0.03181599f, -0.12889865f, 0.41960382f, -0.30235949f, -0.28845936f, 
    -0.17863707f, 0.13641988f, -0.08145764f, -0.21141393f, -0.19060926f, 0.06840371f, -0.06855495f, -0.20317076f, 
    -0.22288004f, -0.49758810f, 0.17448890f, -0.03689487f, -0.06733382f, 0.00332732f, 0.24855864f, -0.02098361f, 
    0.16755207f, 0.21896167f, 0.26055300f, 0.18337432f, -0.40144712f, 0.35792273f, -0.08407918f, 0.22881204f, 
    -0.13733542f, 0.11069097f, -0.04915763f, 0.04753568f, -0.23814251f, -0.06020123f, -0.23484048f, 0.05211665f, 
    0.40108776f, 0.28795287f, 0.30732253f, 0.10705688f, -0.04166195f, 0.08444408f, 0.08958993f, -0.05696636f, 
    0.04167980f, 0.11939914f, -0.15942626f, 0.07506960f, 0.36890855f, 0.22086975f, 0.29705554f, -0.38244981f, 
    -0.03491191f, -0.06989933f, -0.07046089f, 0.11768351f, -0.11962633f, -0.03330855f, -0.03559804f, 0.11296857f, 
    -0.20671482f, 0.09101146f, 0.01124465f, -0.21790299f, -0.02818197f, -0.32269323f, 0.23501721f, -0.25513294f, 
    -0.04512451f, -0.08855624f, 0.11513185f, 0.07231753f, 1.12502503f, -0.21244656f, -0.22211245f, -0.01071275f, 
    -0.00760370f, -0.02633110f, -0.17168452f, -0.10446902f, -0.11461426f, -0.16551095f, -0.12219934f, -0.00540083f, 
    0.08666653f, -0.30071169f, -0.06787027f, 0.13497646f, -0.05127026f, 0.02839306f, 0.13387658f, -0.09760820f, 
    -0.06609450f, -0.35380423f, -0.39687943f, -0.19603962f, 0.13690251f, 0.55064040f, -0.21180534f, -0.27788043f, 
    -0.08059189f, -0.27337271f, 0.08013126f, 0.15384631f, -0.12136821f, -0.00845401f, 0.07011305f, -0.15490071f, 
    0.14835900f, -0.19861963f, -0.15612960f, 0.02895438f, -0.23326634f, -0.14856046f, -0.25403246f, -0.12345552f, 
    0.00386320f, -0.02515009f, 0.06604251f, 0.03416466f, 0.89540505f, 0.01628484f, -0.17447935f, 0.29904968f, 
    -0.12561423f, 0.01574148f, 0.07337499f, -0.12247220f, 0.36623082f, -0.06770365f, 0.04106211f, 0.09131211f, 
    0.44356683f, 0.15376514f, 0.66386521f, 0.09138293f, 0.19692376f, -0.28542677f, -0.30787131f, -0.41019851f, 
    0.01350234f, 0.07079975f, 0.03848032f, -0.34909835f, -0.00103029f, -0.33987281f, 0.02052464f, -0.41015542f, 
    0.05296536f, 0.00863789f, -0.19868405f, 0.17087100f, 0.26490366f, -0.11920147f, -0.10602701f, -0.01554967f, 
    -0.21294507f, 0.30866158f, 0.34424514f, 0.03351390f, 0.02313957f, -0.16251585f, -0.36144608f, 0.23242053f, 
    0.08247170f, -0.10913248f, -0.05712352f, 0.00472580f, 0.10812042f, -0.06003080f, -0.65307689f, -0.30644053f, 
    0.16456266f, 0.11091480f, -0.19193909f, -0.22173099f, -0.03385936f, 0.02199599f, -0.08891746f, 0.05521810f, 
    0.15527585f, 0.39222714f, 0.28062481f, 0.22310624f, -0.11724634f, -0.11895452f, 0.09004759f, -0.01138929f, 
    -0.11444505f, -0.21773414f, 0.20194475f, -0.01695158f, -0.49534929f, 0.60231608f, -0.05832574f, 0.52944434f, 
    -0.28258175f, 0.28173926f, 0.05450595f, -0.03641029f, -0.01428371f, -0.03085048f, -0.00972682f, -0.07612384f, 
    0.23030283f, -0.04711309f, -0.01793383f, 0.01535277f, 0.02373978f, -0.06191697f, 0.15827331f, 0.05934709f, 
    -0.28980964f, 0.23376994f, 0.10812160f, -0.32614273f, -0.37377721f, -0.05511877f, 0.01632576f, 0.19673707f, 
    0.01232027f, 0.10937609f, 0.05546508f, 0.16754161f, -0.05921463f, 0.02650426f, -0.09106477f, 0.10405529f, 
    -0.46894374f, -0.29584903f, 0.04232338f, -0.11791457f, -0.02920040f, -0.07182050f, -0.10316204f, -0.03133708f, 
    -0.02477983f, -0.18788582f, 0.03037900f, 0.19167225f, -0.54391760f, -0.10351314f, 0.81151390f, -0.78476131f, 
    0.04860518f, -0.07533890f, -0.09568533f, 0.16605578f, 0.14421241f, -0.23393877f, -0.00087697f, -0.02262611f, 
    -1.13318706f, -0.65816104f, -0.70654774f, -0.27790374f, 0.03849008f, 0.01081902f, -0.08758033f, 0.20303999f, 
    -0.00313091f, 0.03124292f, 0.01377824f, -0.07022908f, -0.47479174f, 0.59768951f, 0.15454616f, -0.03465075f, 
    -0.14429007f, 0.04481613f, 0.00794666f, -0.11163837f, 0.02201554f, 0.00436112f, 0.17723212f, 0.22487018f, 
    -0.13336796f, -0.43501171f, 0.43550542f, -0.12773867f, 0.02441499f, -0.10692155f, 0.00283136f, 0.04939688f, 
    -0.07689694f, 0.00652054f, 0.10934467f, 0.07165727f, -0.49987009f, 0.28064051f, -0.11958212f, -0.01375882f, 
    0.04332785f, -0.00234691f, -0.16848896f, -0.00476984f, 0.02458599f, 0.18230753f, 0.08255654f, -0.19367798f, 
    -0.55674255f, -0.07893813f, 0.19678137f, -0.00556480f, -0.01065660f, 0.18121941f, -0.14828759f, 0.13190340f, 
    0.05686484f, -0.07480717f, 0.01852069f, -0.08524660f, -0.34124628f, 0.32416549f, 0.30156097f, -0.17538357f, 
    -0.09721459f, -0.07051808f, -0.05043277f, 0.00151761f, 0.15065224f, 0.14556362f, 0.05793022f, -0.24183121f, 
    -0.06183280f, 0.04692108f, 1.03869998f, 0.50396436f, -0.24282633f, 0.01196886f, 0.12486421f, -0.03278266f, 
    0.05884118f, 0.08278050f, -0.11227900f, 0.04279714f, -0.18623894f, 0.34580931f, 0.12493836f, -0.03483933f, 
    -0.07536984f, 0.03626525f, -0.12475494f, -0.41285670f, 0.03907521f, 0.09104747f, -0.10274483f, 0.16895205f, 
    -0.10669667f, -0.10018559f, 0.20987451f, 0.35332933f, 0.02488639f, 0.22881514f, -0.12697570f, -0.26051375f, 
    0.19149929f, 0.03511034f, 0.35070544f, 0.21905898f, 0.06321771f, 0.00035682f, 0.07206116f, 0.37785560f, 
    -0.03617296f, -0.01941474f, 0.12518425f, -0.11881591f, -0.15458898f, 0.19995533f, -0.06680905f, -0.05054655f, 
    0.19128245f, -0.57657641f, 0.12853524f, 0.02489374f, 0.35947743f, 0.12681855f, -0.13211887f, 0.21067093f, 
    0.11416351f, -0.00581954f, -0.11641162f, 0.01362388f, 0.56369817f, -0.30521056f, 0.09467113f, 0.43034840f, 
    0.17281008f, -0.01297540f, -0.13388604f, 0.23776980f, 0.13991903f, 0.08388403f, -0.07365065f, 0.17307441f, 
    -0.13282336f, 0.83610988f, -0.20631625f, -0.34459001f, 0.08488192f, -0.05494697f, -0.10623732f, 0.06537306f, 
    -0.33728170f, -0.38292581f, 0.01271002f, -0.12292853f, -0.08550617f, 0.28203613f, -0.34921223f, -1.04325652f, 
    0.35669997f, -0.12418153f, -0.07577944f, 0.00433884f, -0.24167453f, 0.10185838f, -0.08788251f, -0.15936714f, 
    -0.59522390f, -0.50992405f, 0.02922057f, 0.04579872f, 0.04385750f, 0.00539708f, 0.01709927f, -0.14934650f, 
    -0.19626862f, 0.24000952f, -0.20321000f, -0.05416633f, -0.64907646f, -0.28026322f, 0.50312066f, -0.19124940f, 
    -0.32147801f, -0.28790733f, -0.16659392f, 0.16380563f, 0.19105907f, 0.13895226f, -0.04461615f, -0.03632633f, 
    -0.21664642f, -0.35457179f, -0.29807922f, 0.18505451f, 0.09579537f, 0.16023658f, -0.07030615f, 0.07323861f, 
    -0.03130361f, -0.12426680f, 0.10549400f, -0.17093863f, -0.40229368f, 0.25686482f, 0.00257006f, 0.36174244f, 
    -0.04934446f, 0.01534665f, 0.34326202f, -0.13224515f, -0.09165322f, -0.00136868f, 0.06457077f, 0.16238904f, 
    -0.18818520f, -0.03453153f, -0.16502723f, 0.12372827f, 0.10407923f, 0.07091926f, -0.00047843f, -0.01047387f, 
    -0.03944977f, 0.08108707f, 0.20321989f, -0.03357008f, -1.22924638f, -0.09862791f, -0.08162382f, -0.85572344f, 
    -0.04305293f, 0.15471675f, -0.20560861f, 0.02055407f, -0.10727694f, -0.03962225f, -0.24060412f, -0.04681451f, 
    -0.16437681f, -0.02033182f, 0.43758366f, 0.36996078f, 0.10001149f, 0.21407142f, -0.26402178f, -0.26127404f, 
    -0.07399632f, -0.38889015f, 0.06136619f, -0.12702975f, 0.24776450f, 1.57338250f, -0.27042228f, -0.10600835f, 
    0.65363109f, 0.06375094f, -0.07737290f, -0.16153003f, -0.24055450f, -0.21643336f, 0.05023431f, -0.18957126f, 
    0.12331139f, -0.30037871f, -0.12971005f, 0.34111762f, 0.09666630f, 0.00343414f, 0.09577996f, -0.19302906f, 
    -0.07587907f, 0.04043803f, 0.03144245f, 0.28066474f, -0.90739125f, -0.06008894f, -0.22069456f, 0.67119235f, 
    -0.23297663f, 0.01564866f, -0.08770730f, -0.02298564f, 0.08403992f, -0.14071544f, 0.12279804f, -0.15787247f, 
    0.06003211f, 0.13243023f, -0.02932125f, 0.23317470f, 0.26398343f, -0.12635607f, -0.38823244f, -0.04338488f, 
    -0.02763398f, -0.19801402f, -0.02021268f, -0.03146707f, 0.06527040f, 0.28232956f, 0.17258176f, 0.24478050f, 
    0.05754029f, -0.06180909f, 0.02715100f, -0.07803034f, -0.10323676f, -0.02833273f, -0.01249775f, 0.02052441f, 
    0.40365434f, 0.13589688f, 0.06549099f, 0.09185261f, -0.06143181f, -0.11331817f, 0.00188470f, -0.02324381f, 
    0.18396211f, -0.13260482f, -0.10391355f, 0.09284282f, -0.15333809f, 0.12130552f, 0.13118373f, -0.03846380f, 
    -0.10042021f, -0.31060442f, -0.02317469f, -0.15318437f, 0.08275085f, 0.07130618f, -0.01348209f, -0.01289615f, 
    0.30601132f, -0.77182084f, 0.00756552f, 0.03784156f, -0.25447398f, -0.14818461f, -0.04206603f, -0.12676533f, 
    -0.17635418f, -0.06786730f, -0.46493977f, 0.09214020f, -0.03126590f, -0.37964565f, -0.53431958f, -0.25390577f, 
    -0.10330301f, 0.03214094f, 0.03211491f, 0.05413957f, -0.08300597f, 0.10987195f, -0.35882857f, 0.06015693f, 
    0.17579004f, 0.15453812f, -0.00761822f, -0.13815928f, 0.12210839f, 0.03628294f, 0.09343932f, 0.06816461f, 
    0.17877011f, 0.02529416f, -0.03473549f, 0.07667788f, 0.49104470f, -0.20160381f, -0.82976115f, 0.39427957f, 
    0.11403324f, 0.04845759f, 0.20318606f, -0.00416785f, 0.15172631f, -0.06969387f, -0.01670932f, -0.07716024f, 
    0.04195615f, 0.08843544f, 0.53630662f, 0.31206447f, -0.16898352f, 0.09135693f, -0.16270868f, 0.03653200f, 
    0.06176240f, -0.03203626f, -0.07884166f, 0.00826502f, -0.19656432f, -0.27478898f, 0.02335720f, -0.39946574f, 
    -0.00444115f, -0.06881322f, -0.10961848f, -0.17142975f, 0.13189416f, -0.09985477f, 0.04448629f, 0.12636277f, 
    0.00391396f, 0.03572314f, 0.26790783f, 0.27170968f, -0.03002043f, -0.02845356f, -0.04789136f, 0.00040847f, 
    0.12811939f, 0.24836552f, 0.08390535f, 0.18430795f, 0.37218532f, -0.06850655f, -0.15393303f, -0.17398454f, 
    -0.02740085f, 0.08626645f, 0.16076131f, -0.21717165f, -0.20601836f, -0.27721414f, -0.25216773f, -0.14669734f, 
    -0.01088635f, 0.04724557f, 0.06795821f, 0.44038346f, 0.15228066f, 0.18391405f, 0.01205878f, 0.35783905f, 
    0.05975217f, 0.05923627f, -0.22437808f, -0.07499680f, -0.63017166f, -0.69047767f, 0.19852008f, -0.27226236f, 
    -0.13438198f, 0.26995164f, -0.20011534f, 0.11052456f, -0.19903167f, -0.10344651f, -0.45317650f, -0.28290561f, 
    -0.23840342f, -0.07381437f, -0.07655364f, 0.06889629f, -0.22152638f, 0.01897479f, 0.02112885f, -0.10098769f, 
    -0.00993189f, -0.01491582f, 0.03554387f, 0.21634623f, -0.16945656f, 0.11553008f, 0.06459427f, 0.01571478f, 
    0.13256630f, -0.06192734f, 0.09370298f, -0.22914262f, 0.07114238f, 0.02811216f, 0.06330013f, 0.02537843f, 
    -0.11255627f, -0.03908481f, -0.13557345f, -0.27340528f, -0.17277858f, 0.05233995f, 0.10787663f, -0.19078149f, 
    0.20865190f, 0.19234411f, 0.08066671f, 0.03246947f, 0.01134081f, 0.15582152f, 0.18673664f, -0.25867170f, 
    0.00322146f, 0.04192818f, -0.00659933f, 0.05095040f, 0.12079304f, -0.09704396f, -0.03165534f, -0.01773177f, 
    -0.71574152f, -0.33083478f, -0.42997864f, -0.22033711f, -0.00583820f, 0.07648798f, -0.22172819f, -0.03106486f, 
    0.02816160f, -0.05243743f, 0.12518694f, -0.21603157f, -0.06897651f, -0.24187626f, -0.29543141f, -0.06273269f, 
    0.24611859f, 0.07287798f, 0.05043982f, 0.12107614f, 0.05184349f, -0.15341249f, 0.19481839f, 0.24425900f, 
    -0.00938055f, 0.17426458f, -0.17725568f, 0.43622306f, 0.12982418f, -0.03762391f, -0.08180501f, 0.12782334f, 
    0.36807418f, 0.17374559f, -0.08540159f, -0.16379766f, -0.05661934f, -0.76375085f, 0.57136744f, 0.25497317f, 
    -0.03940088f, -0.14105941f, -0.10617775f, 0.06539794f, -0.00682402f, -0.17096871f, 0.15677390f, -0.02877413f, 
    -0.18133262f, -0.32477880f, -0.36704764f, 0.20217529f, 0.03190380f, -0.15841404f, -0.17394255f, -0.03523660f, 
    0.16808756f, -0.11186650f, 0.26025066f, 0.13105731f, 0.20939188f, -0.21378163f, -0.66290069f, 0.71685606f, 
    0.14349641f, 0.06833639f, 0.11461834f, -0.01604470f, 0.10618657f, -0.13285172f, -0.06118031f, -0.10962973f, 
    0.40356031f, 0.14045785f, 0.29643515f, 0.18107907f, 0.11718165f, 0.11046679f, 0.07185791f, -0.01972436f, 
    0.10204504f, 0.03867580f, -0.03140629f, 0.24651344f, 0.08513372f, 0.06034332f, -0.48824552f, -0.32065839f, 
    0.03680088f, 0.20743392f, -0.07553669f, -0.12549195f, 0.30649379f, -0.25138631f, 0.10264184f, -0.42296988f, 
    -0.16489385f, 0.40421763f, 0.30348343f, -0.37469539f, 0.01372687f, 0.04980413f, 0.08724762f, 0.03552391f, 
    0.06064744f, -0.30836526f, -0.33203879f, -0.04613144f, 0.12703089f, -0.79496801f, 0.25795749f, 0.21584594f, 
    -0.03381780f, 0.07830979f, -0.21984722f, -0.05207163f, 0.38923499f, 0.11683847f, 0.07322277f, 0.12528610f, 
    -0.35184312f, 0.17670701f, -0.23245050f, -0.33692437f, 0.00796552f, -0.13125446f, -0.02079054f, 0.04557307f, 
    0.07865888f, 0.01507004f, -0.06165338f, 0.07979096f, -0.50572628f, -0.06036399f, 0.19711010f, -0.18203774f, 
    -0.12431616f, 0.00295828f, 0.03326933f, -0.05204498f, -0.10449575f, -0.01826453f, 0.11760771f, 0.15358648f, 
    -0.27469134f, 0.33365065f, -0.05585032f, -0.28097692f, 0.05008248f, -0.19478256f, -0.21365571f, 0.06355183f, 
    0.00137228f, -0.18216851f, -0.16784362f, -0.22667959f, 0.39824721f, -0.02022261f, -0.28653881f, -0.07264315f, 
    -0.03771498f, -0.06398024f, 0.02499607f, 0.15510952f, -0.08776899f, -0.06012141f, 0.08292996f, -0.25689447f, 
    -0.18382092f, -0.12033369f, 0.22263120f, 0.45519015f, -0.24849121f, -0.49653733f, 0.03398099f, 0.04081976f, 
    -0.03372182f, 0.05998554f, -0.10969470f, -0.12091566f, -0.28832540f, -0.86697006f, -0.19653907f, -0.67560875f, 
    0.02720632f, -0.38606694f, 0.01032557f, -0.01056336f, -0.02525811f, 0.13960895f, -0.06841000f, -0.09162454f, 
    -0.86787361f, 0.57198077f, 0.64285862f, -0.06591440f, -0.16319641f, -0.05921458f, -0.26516306f, -0.15988018f, 
    -0.27416295f, 0.13879174f, -0.03614260f, 0.18286709f, -0.89193195f, 0.20477621f, 0.38506040f, 1.09532475f, 
    -0.01763671f, -0.41779292f, 0.24669607f, 0.08512208f, 0.02714470f, -0.00428239f, -0.09137476f, 0.04155896f, 
    -0.69540471f, 0.00737259f, 0.33965626f, 0.11053421f, -0.14361809f, 0.09299345f, -0.11976059f, -0.01568641f, 
    -0.23882991f, -0.14516990f, 0.25363019f, 0.10319390f, 0.10815857f, 0.07691408f, -0.09458826f, 0.14345232f, 
    -0.06179198f, -0.09548514f, -0.12542336f, 0.20381913f, 0.18977398f, 0.05117055f, 0.29762864f, 0.08630254f, 
    0.22835957f, 0.01042165f, 0.06922463f, -0.23865166f, 0.00765190f, 0.00608821f, 0.03411009f, -0.02635442f, 
    -0.05503199f, 0.02043957f, -0.19387813f, -0.19123891f, 0.24522392f, -0.35074240f, -0.22882080f, -0.71477956f, 
    -0.01631479f, 0.00057283f, 0.24904425f, -0.12002977f, -0.05226303f, 0.15237443f, -0.03384937f, 0.00580553f, 
    -1.14824820f, -1.58570564f, -0.43229944f, -0.33331984f, -0.03994649f, -0.04492801f, -0.10854433f, -0.55811584f, 
    0.07852564f, -0.10875411f, -0.12289407f, -0.03199468f, -0.46601516f, 0.48761952f, 0.11794097f, -0.35534060f, 
    0.08342200f, 0.24649560f, 0.17539358f, -0.14770448f, 0.01076487f, 0.12197551f, 0.24918230f, 0.14254056f, 
    -0.17332858f, -0.51733184f, 0.22177725f, -0.15424562f, -0.09370894f, -0.08622488f, 0.15720032f, 0.03615994f, 
    -0.04921136f, 0.19488770f, 0.14874431f, 0.03426645f, -0.19740842f, -0.13004671f, 0.14560446f, 0.40305522f, 
    0.19621044f, 0.13107525f, 0.07834212f, 0.17557196f, -0.07749758f, -0.10380842f, 0.00784628f, 0.00110899f, 
    0.12735726f, -0.30791751f, -0.30918306f, 0.04155958f, 0.09395950f, 0.35086259f, 0.21834528f, -0.17168331f, 
    -0.06835041f, -0.07915069f, -0.13031715f, -0.12674023f, -0.37277031f, 0.48746794f, 0.18083771f, -0.21264860f, 
    0.09621300f, -0.13310187f, 0.02503209f, 0.00348488f, 0.12078777f, 0.15070809f, -0.02539899f, 0.12667520f, 
    -0.76483512f, -0.49027491f, -0.85882628f, 0.08754923f, 0.01686367f, 0.07995246f, 0.15189369f, 0.05101784f, 
    0.04448610f, 0.04730918f, 0.13927193f, 0.06919081f, 0.81064600f, 0.34203520f, -0.37938750f, -0.10970367f, 
    -0.06161201f, -0.15844165f, 0.11182641f, 0.07264669f, 0.02041867f, -0.01516685f, -0.00340041f, 0.06332764f, 
    -0.33053711f, -0.22664724f, -0.36123469f, -0.52854806f, -0.33502972f, -0.09715225f, 0.08181466f, 0.15671247f, 
    0.13008255f, -0.04504915f, 0.02501150f, -0.00427960f, -0.77974659f, -0.72596955f, 0.26809186f, 1.13533330f, 
    -0.00260181f, 0.11148089f, -0.25295407f, 0.01287417f, -0.21103829f, -0.31581792f, 0.04239694f, -0.07678432f, 
    0.76956975f, -0.29201335f, -0.11727975f, -0.35478449f, 0.13583274f, -0.03173906f, -0.04038644f, 0.05244837f, 
    0.03973042f, -0.03208923f, 0.12825851f, 0.06558650f, -1.01743162f, -0.87339628f, -0.95461935f, -1.19288540f, 
    -0.22265315f, 0.35282224f, 0.20615323f, -0.01186710f, 0.11871168f, 0.00647016f, 0.02582394f, 0.10859060f, 
    0.27073011f, 0.30379787f, -0.31630859f, -0.31329364f, 0.11349053f, 0.02146171f, -0.03990738f, -0.00778423f, 
    -0.23847857f, 0.22631569f, 0.11208641f, 0.09565623f, 0.50608969f, -0.82182115f, 0.02734101f, -0.63534564f, 
    0.01149051f, 0.07891771f, -0.04080347f, -0.07600412f, 0.01534079f, 0.11469600f, -0.14266251f, -0.22785379f, 
    -0.03017950f, 0.03027314f, 0.02730604f, -0.16129084f, -0.06643959f, 0.00597353f, -0.06447554f, -0.04316335f, 
    0.02002635f, -0.15532981f, -0.26772228f, -0.38771078f, -0.19839077f, 0.23906900f, -0.14397176f, -0.21720095f, 
    0.12176961f, -0.00805327f, -0.09176475f, -0.17082858f, 0.04620251f, 0.08403267f, 0.11859100f, 0.08832368f, 
    -0.74194270f, -0.96940529f, 0.13671803f, 0.49495313f, 0.18789503f, 0.05915230f, 0.09405348f, 0.20130388f, 
    0.04874977f, 0.02617451f, -0.10148885f, -0.01890274f, -0.66165602f, 0.08861362f, -0.07588897f, 0.30727169f, 
    -0.00067268f, -0.19130448f, 0.22125874f, -0.01465981f, -0.00316592f, 0.29948533f, 0.07318790f, -0.06877933f, 
    0.10294319f, -0.69237339f, -0.01230425f, -0.25578988f, -0.05330788f, -0.07936976f, -0.09919817f, 0.25644609f, 
    0.19994169f, 0.18212152f, 0.16449197f, -0.03693336f, 0.19497915f, -0.07871291f, 0.62277627f, -0.72526956f, 
    -0.03784748f, 0.11060170f, -0.22112015f, 0.19539788f, -0.11735982f, -0.03376921f, 0.08128814f, -0.13389118f, 
    -0.25018346f, 0.15174796f, 0.15887131f, -0.16894077f, -0.18253917f, -0.13776506f, -0.06102234f, 0.06336878f, 
    0.07520233f, 0.02463733f, -0.00436559f, -0.01140703f, 0.00136409f, 0.02205190f, -0.05932261f, -0.30462858f, 
    0.05222873f, -0.02313226f, 0.29267469f, -0.05113075f, -0.00350328f, -0.03543636f, -0.14089753f, -0.10262324f, 
    0.80140918f, -0.56939727f, -0.66929448f, -0.78643346f, 0.02904013f, 0.11256830f, 0.06014442f, 0.35452616f, 
    0.14191480f, 0.04116935f, -0.09191113f, -0.09181643f, -0.05170185f, -0.08393902f, -0.26926380f, 0.03256214f, 
    0.01468758f, 0.01522569f, -0.04945568f, 0.00601435f, -0.09255558f, 0.08665253f, 0.10920136f, -0.13391849f, 
    -0.14925241f, -0.38929397f, -0.02809414f, 0.47662294f, -0.35070106f, 0.09765172f, 0.13616951f, -0.03242662f, 
    0.03062977f, 0.18006213f, 0.18816063f, 0.05543800f, 0.05706629f, -0.84315729f, -0.97609448f, -0.23931453f, 
    0.04558141f, -0.10012899f, 0.10620923f, 0.15913393f, 0.27724585f, 0.26511154f, 0.28541294f, -0.02238188f, 
    -0.32745981f, -0.55859077f, -0.59277582f, -0.08042046f, -0.02096972f, 0.20596746f, 0.17088395f, 0.05608704f, 
    0.11872341f, 0.02640948f, -0.13026704f, -0.16021174f, -0.25102547f, -0.63684976f, -0.64218533f, 0.58271426f, 
    0.25320688f, 0.00505371f, 0.25753552f, 0.05897588f, -0.15692706f, -0.04235363f, 0.00359618f, 0.09699401f, 
    0.35623628f, -0.27169850f, -0.22099917f, -0.55507421f, -0.29639724f, 0.11306910f, 0.14888664f, 0.11047501f, 
    0.26846102f, -0.01873483f, 0.25515392f, 0.19329293f, 0.27446431f, -0.06605266f, -0.46796879f, -0.69920427f, 
    -0.07020116f, 0.00477286f, 0.08805136f, 0.00009609f, 0.32089058f, 0.23350175f, -0.00174894f, 0.05665783f, 
    -0.72235268f, 0.02782264f, 0.04857946f, -0.14031661f, 0.03510111f, -0.03826154f, -0.12497880f, 0.02944429f, 
    0.02420190f, -0.11689010f, -0.05894638f, 0.08631433f, -0.77517688f, 0.44945872f, 0.00963078f, 0.38728708f, 
    0.02076229f, 0.01645418f, -0.35565105f, 0.05933153f, -0.48312566f, -0.11415239f, -0.14906171f, -0.03820221f, 
    0.49838263f, 0.01995759f, -0.52671051f, 0.03266633f, -0.09142129f, 0.14770783f, -0.01436557f, 0.11080963f, 
    0.00091924f, -0.06648824f, 0.14211810f, 0.11393224f, -0.27274689f, -0.28208837f, 0.34879208f, -0.03252014f, 
    -0.05381133f, 0.31267348f, -0.03497079f, -0.07596030f, -0.00939451f, 0.01149425f, -0.24816866f, 0.15626170f, 
    0.26719910f, -0.16656908f, -0.15682812f, -0.15552545f, -0.03613467f, -0.06866181f, 0.16143392f, -0.05243073f, 
    -0.19207552f, -0.49044254f, -0.21473023f, -0.73175460f, 0.11654070f, 0.18483567f, -0.06446750f, 0.29136664f, 
    0.12656280f, -0.16411161f, 0.16853400f, 0.16566606f, 0.17249820f, 0.01099684f, 0.20209928f, 0.36557472f, 
    -0.27355650f, -0.06839350f, 0.28716859f, -0.00539223f, 0.25097096f, -0.10359766f, -0.05346744f, -0.10975607f, 
    0.03940688f, 0.11176249f, 0.19403493f, 0.07063618f, 0.22796439f, -0.52938211f, -0.06958149f, -0.02508856f, 
    -0.15232019f, -0.09903954f, 0.31388047f, -0.23498382f, 0.24870124f, 0.07969774f, 0.16094059f, 0.08098765f, 
    0.02262614f, -0.90972912f, -0.82380259f, -0.12481383f, -0.06986164f, 0.40071732f, 0.22526453f, 0.00775448f, 
    -0.23775901f, -0.08848771f, -0.08617734f, -0.14366768f, -0.75093442f, -0.14403109f, 0.08396184f, 0.18203919f, 
    0.09336430f, -0.00039879f, -0.08791743f, 0.16813901f, -0.18278326f, -0.24919575f, -0.12855366f, 0.01024338f, 
    -0.10248113f, 0.08149017f, 0.37238693f, -0.79369789f, -0.10485985f, -0.06285770f, 0.07341538f, 0.08554523f, 
    0.00209378f, -0.00350235f, -0.16330342f, -0.12032689f, -0.41379359f, 0.26776439f, 0.35543749f, -0.07495668f, 
    -0.26143375f, -0.08031389f, 0.21030475f, 0.03606406f, 0.11611211f, 0.17764953f, 0.11661582f, -0.02835100f, 
    0.34820530f, 0.21288124f, 0.20688783f, 0.47358060f, 0.01831802f, -0.24939445f, -0.30299374f, -0.20350662f, 
    0.07899869f, -0.01020415f, -0.00562657f, 0.30387610f, 0.34761885f, -0.12212987f, -0.40975851f, -1.10888600f, 
    -0.16093312f, -0.25456563f, 0.09449968f, -0.21034378f, -0.05909447f, -0.12400237f, -0.06261201f, -0.05204242f, 
    -0.00927772f, 0.26773795f, 0.24073663f, 0.22591805f, 0.10416063f, 0.01381582f, -0.47165138f, 0.00193845f, 
    -0.10321339f, -0.42264861f, 0.04599724f, 0.17108642f, 0.24474730f, 0.19757299f, 0.65324378f, 0.70839113f, 
    0.12103423f, -0.22140104f, -0.08390848f, -0.29809636f, 0.12350882f, 0.16276816f, 0.17518179f, -0.05791362f, 
    -0.17107034f, -0.23025018f, -0.05474261f, -0.07429033f, 0.00195221f, 0.13458925f, -0.06609010f, -0.09420941f, 
    0.01029787f, -0.08296049f, 0.33806303f, -0.05006979f, -0.37117147f, -0.05176973f, -0.94830465f, -0.03610541f, 
    0.05241217f, 0.08051819f, 0.40964249f, -0.00247404f, 0.07464583f, 0.04960236f, -0.09979139f, 0.11407453f, 
    -0.51220578f, 0.06031739f, -0.39157620f, 0.12746914f, 0.04423665f, -0.28548729f, -0.05049930f, 0.05566667f, 
    0.01119482f, 0.01845236f, -0.03228682f, -0.03630054f, -0.04601285f, -0.15337268f, 0.61902708f, -0.68359697f, 
    0.18368784f, -0.34296790f, -0.09498037f, 0.04893724f, -0.05955626f, 0.13392806f, 0.04467641f, -0.03749654f, 
    -0.57018012f, -0.33835176f, 0.07562878f, 0.28599963f, 0.02953043f, 0.16735692f, -0.18707733f, -0.20720705f, 
    0.05085473f, 0.24286737f, 0.13317178f, 0.07489859f, 0.33352757f, -1.22814822f, 0.16942085f, -0.34807745f, 
    -0.02459010f, 0.08527957f, -0.37637228f, -0.20586278f, -0.06535172f, -0.09567799f, -0.13046911f, 0.04390470f, 
    0.22960602f, -0.30607530f, -0.39609352f, -0.24506576f, 0.30039513f, -0.13604967f, 0.34974584f, 0.10641136f, 
    0.04336826f, -0.09374420f, -0.20131224f, -0.03616474f, 0.11364530f, -0.56837022f, -0.03474182f, -0.14458089f, 
    0.27821916f, -0.17823869f, -0.09429765f, 0.23569033f, -0.27340645f, -0.08058973f, 0.02187411f, 0.08768518f, 
    -0.21581958f, -0.12762187f, -0.07068818f, 0.45920163f, -0.16511217f, 0.01140363f, 0.04308041f, -0.00794376f, 
    0.06892502f, -0.07911945f, 0.17416470f, 0.01772290f, -0.01604784f, 0.48466069f, 0.96404040f, -0.77862322f, 
    -0.02770938f, -0.27725545f, 0.07473511f, 0.10403213f, -0.12411512f, 0.07272200f, -0.02896141f, 0.05358188f, 
    0.26323017f, -0.47905591f, 0.14635731f, 0.01778441f, -0.17785566f, -0.06037402f, 0.06458668f, 0.09075782f, 
    0.03315381f, 0.04109997f, 0.01380012f, 0.16899742f, -0.37534016f, -0.33519334f, 0.19308713f, -0.32063586f, 
    -0.09505066f, -0.08620101f, 0.13764207f, -0.09690702f, -0.05971651f, 0.00601618f, 0.19745146f, 0.05353548f, 
    0.22621526f, 0.22079390f, -0.03105442f, -0.24459071f, 0.18880610f, -0.05715116f, -0.05084118f, 0.00308888f, 
    -0.37949806f, 0.11570488f, -0.12406988f, -0.22280641f, 0.11273310f, 0.16184834f, 0.79233122f, 0.13376808f, 
    -0.29847702f, 0.00255528f, 0.00297847f, 0.16178085f, 0.19821605f, 0.29473251f, 0.26847285f, 0.00489215f, 
    0.45349404f, 0.70622647f, 0.21634310f, -0.28830835f, -0.11217138f, 0.18203081f, 0.23234695f, 0.38780272f, 
    0.14835405f, 0.21387061f, 0.03168916f, 0.17688669f, -0.89496613f, 0.45849884f, -0.16291194f, -0.44333088f, 
    -0.15723836f, 0.05560967f, -0.00087037f, -0.09025622f, 0.14839600f, -0.23565988f, -0.02544355f, -0.27166331f, 
    -0.08444433f, -0.27597812f, -0.54497105f, -0.69013524f, 0.01964151f, -0.39918390f, -0.29484349f, -0.18037435f, 
    -0.32328564f, 0.03788725f, 0.32345977f, -0.21001425f, 0.10760979f, -0.06698558f, -0.02999338f, 0.15541483f, 
    -0.37095174f, -0.12133822f, 0.08991467f, -0.10451107f, -0.30151367f, -0.07750463f, -0.10832582f, -0.08750396f, 
    -0.79440343f, 0.56788212f, -0.54993802f, 0.10037220f, 0.20859066f, 0.14396267f, -0.06050825f, 0.12726846f, 
    -0.17541340f, 0.39155164f, -0.14635012f, 0.22783342f, -0.24951118f, 0.19205615f, 0.27916992f, 0.25484198f, 
    0.14874171f, -0.32062212f, -0.34820867f, 0.33781159f, -0.02040507f, -0.33553004f, -0.36716387f, -0.29425460f, 
    0.01930844f, 0.45142195f, -0.31369403f, -0.23052159f, 0.05748261f, 0.00682548f, -0.09511243f, 0.12098657f, 
    -0.12940411f, -0.30468836f, -0.58648580f, -0.55442226f, -0.69266254f, 0.39621565f, -0.89365947f, 0.60383379f, 
    0.24564999f, 0.19106066f, 0.33065546f, -0.11178583f, -0.12093068f, 0.17185593f, -0.04959045f, 0.26867783f, 
    -0.10714374f, -0.19823407f, -0.59602559f, -0.01332434f, -0.20547235f, 0.12310493f, 0.38598347f, -0.28401494f, 
    0.12550534f, 0.25598067f, -0.00467880f, -0.04753174f, -0.38294601f, 0.22316839f, 0.43324146f, 0.91017145f, 
    -0.06571581f, -0.14777610f, -0.26849648f, 0.04114272f, 0.25454423f, -0.06235317f, 0.16796885f, 0.14645053f, 
    -0.28300133f, -0.00927322f, -0.46801651f, -0.24333838f, 0.12916471f, -0.28441563f, -0.01199640f, 0.33487803f, 
    -0.18887699f, 0.22520611f, -0.14162351f, -0.57691145f, -0.39260009f, -0.07073455f, -0.26514634f, 0.21475245f, 
    -0.08481038f, 0.03817095f, -0.03319764f, -0.03702161f, -0.10688423f, -0.23074077f, -0.04350050f, -0.13690649f, 
    -0.34181464f, 0.18536788f, -0.23689362f, -0.23677757f, 0.23021239f, 0.10189222f, -0.12800324f, 0.06429233f, 
    -0.26590675f, -0.10581017f, 0.05524405f, -0.09447932f, -0.60828662f, -0.73013794f, -0.55679029f, -0.11449806f, 
    -0.03350756f, -0.49875468f, -0.05966709f, -0.14171213f, -0.01237332f, 0.20441110f, 0.14119723f, 0.11728992f, 
    -0.40285179f, -0.29158685f, -0.25672892f, 0.27623960f, -0.05802207f, -0.12900944f, -0.06831538f, -0.01265981f, 
    -0.05047249f, -0.01796219f, -0.22557558f, -0.24109827f, 0.20204343f, 0.08724069f, 0.54396266f, -0.70554560f, 
    -0.00434036f, 0.00044339f, -0.03173635f, -0.07186688f, -0.05708252f, 0.03977887f, -0.18356435f, -0.26346165f, 
    -0.41361481f, -0.00029282f, -0.26255298f, 0.24649216f, 0.26035932f, 0.11467884f, 0.03900456f, -0.09035260f, 
    -0.07768729f, -0.21601239f, -0.21318714f, 0.03500486f, -0.32236767f, -0.11526057f, -0.66763967f, 0.39513633f, 
    0.36992455f, -0.07168530f, 0.06327283f, -0.26978594f, 0.18338385f, 0.06827576f, 0.47584605f, 0.16552353f, 
    -0.05075200f, -0.01358589f, -0.24099994f, -0.07292134f, -0.19740976f, -0.00915691f, 0.15977645f, 0.07687301f, 
    -0.30555171f, -0.13062727f, 0.09649275f, 0.01815678f, 0.42869473f, -0.00794085f, 0.73967403f, -0.07019465f, 
    -0.08124392f, 0.01211686f, -0.09943719f, -0.03598890f, -0.27407527f, 0.08700711f, 0.08589293f, -0.11727905f, 
    0.12510975f, -0.63418406f, 0.41554278f, 0.30263209f, -0.01196400f, -0.06226206f, -0.11152592f, -0.06251717f, 
    0.09216462f, -0.19547631f, 0.04433076f, -0.19207335f, -0.00604967f, -0.21769606f, -0.00800513f, 0.70267612f, 
    -0.19712207f, 0.33618373f, -0.03263515f, 0.56618321f, -0.24753164f, 0.18432526f, 0.15576506f, 0.02891523f, 
    -0.41407165f, 0.01524479f, -0.58374321f, 0.10216860f, 0.16714089f, -0.05970450f, -0.13563673f, -0.20178245f, 
    0.08217308f, 0.16643408f, 0.43444622f, 0.04356844f, -0.39277020f, 0.28538701f, -0.00134851f, 0.79021764f, 
    -0.10843854f, -0.13082947f, 0.48949826f, -0.10767452f, -0.03515068f, 0.04945100f, -0.07980587f, -0.31450412f, 
    0.65913850f, 0.33297110f, 0.58377409f, -0.09974855f, 0.09633902f, 0.07508389f, 0.08567442f, -0.03662765f, 
    -0.22559217f, 0.06211878f, 0.09263811f, 0.03213469f, -0.89518619f, -0.08194016f, 0.00955395f, 0.34575114f, 
    -0.06105630f, -0.03240412f, -0.11587707f, 0.07437883f, -0.36047027f, 0.04928414f, -0.05623499f, 0.03644738f, 
    0.01054842f, 0.33294454f, 0.17298147f, -0.48328099f, -0.37700695f, -0.00395612f, 0.29051018f, 0.06380362f, 
    0.05878871f, 0.05813781f, 0.08790772f, 0.15895070f, -0.06613818f, -0.36144629f, 0.08229859f, 0.34795547f, 
    -0.14449498f, 0.05838753f, 0.08335565f, 0.15111652f, -0.12256813f, 0.06115751f, -0.15826736f, 0.18790169f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32639715f, 0.15215011f, 0.24469648f, -0.10600764f, -0.15370768f, 0.09574313f, 0.04147768f, -0.22248466f, 
    0.12935266f, -0.06270240f, 0.10290442f, 0.05693262f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
