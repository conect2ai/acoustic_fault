#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.62681043f, 0.88951170f, 0.58132374f, 0.35759667f, 0.82097852f, -0.26325321f, -0.27146971f, 0.15000486f, 
    0.24137618f, -0.37609729f, 0.04522204f, 0.50273705f, -0.89419341f, 0.13713548f, 0.31811118f, 0.49936619f, 
    -0.00604312f, 0.33565846f, 1.09229887f, 0.25735965f, -0.78887433f, -0.55458140f, -0.39313322f, 0.17580053f, 
    0.19661535f, -0.13821974f, 0.27078804f, 0.55287170f, -0.25275007f, -0.71468645f, -0.49535060f, 0.71787846f, 
    -0.18449800f, -0.07788715f, -0.11731786f, -0.18162556f, 0.04953269f, 0.87880260f, 0.37051642f, -0.19520876f, 
    -0.19008617f, 0.61141872f, -0.25809005f, 0.22528745f, -0.36249638f, -0.18853672f, -0.88115883f, 0.74820250f, 
    -0.55359817f, 0.07903755f, -0.13272423f, -0.01301322f, -0.33747783f, -0.01507048f, -0.71394157f, -0.84586579f, 
    -0.58021396f, -0.55437136f, 0.16293705f, 0.51311958f, -0.08872747f, -0.19191892f, 0.03844396f, -0.61875212f, 
    -0.01355012f, -0.45949391f, -0.62739486f, -0.11568497f, 0.12181818f, 0.33847803f, 0.45210052f, -0.31240192f, 
    0.55557334f, 1.02012575f, 0.76235098f, -0.99941033f, -0.26173732f, -0.56366581f, 0.38506749f, -0.01895515f, 
    -0.25089386f, 0.70553142f, 0.47680008f, 0.08385365f, 0.41884780f, 0.37004715f, 0.32321495f, -0.43863013f, 
    -0.13204096f, -0.23699589f, -0.33823586f, -0.70351905f, -0.57297188f, 0.72325152f, 0.70436823f, -0.56687969f, 
    0.00833918f, -0.31835297f, 0.01714674f, -0.63910496f, -0.56250358f, -0.65385777f, 0.20142914f, -0.46000722f, 
    -0.17335087f, 0.12464026f, 0.26462471f, 0.06525263f, -0.10657907f, -0.90617704f, -0.05897745f, -0.40688926f, 
    0.19633961f, -0.26893845f, 0.32727009f, 0.30863702f, 0.09077635f, -0.19289012f, -0.39029303f, -0.51815289f, 
    -0.13376738f, 0.89716792f, 0.77991366f, 0.11699750f, -0.16634557f, -0.24733278f, -0.07078143f, -0.66241211f, 
    -0.37632474f, -0.54137516f, -0.66635919f, -0.43185771f, -0.43521503f, 0.27687386f, -0.27223659f, 0.89662617f, 
    -0.75215894f, 0.81106550f, 0.38118309f, -0.32265130f, -0.05929843f, -0.34379011f, -0.19486406f, -0.25573933f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10822060f, 0.03007117f, -0.08944976f, 0.07801015f, 0.19397625f, 0.19180827f, 0.03138814f, 0.24701236f, 
    -0.00396279f, 0.12037901f, 0.15869360f, 0.15193611f, 0.27584186f, -0.12654376f, 0.03231020f, 0.18170011f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00962457f, -0.00284616f, -0.04552142f, 0.02024957f, -0.00914986f, -0.05267040f, -0.00389104f, -0.06418944f, 
    0.00104634f, 0.02765710f, -0.04832636f, 0.01562030f, -0.03938501f, -0.01361051f, 0.00503933f, 0.01723971f, 
    -0.00069501f, 0.02436692f, -0.01208563f, 0.05200045f, -0.00154067f, -0.00144466f, 0.03986846f, 0.00112007f, 
    -0.00104753f, -0.03374986f, -0.01975670f, 0.03739308f, -0.01724797f, -0.01556237f, -0.04560760f, 0.00656964f, 
    -0.01489957f, -0.03921233f, -0.04132522f, 0.01310255f, -0.05039589f, -0.03305197f, -0.02903383f, 0.02948183f, 
    -0.04157833f, 0.01973679f, -0.02424009f, 0.03063934f, -0.04406368f, -0.03917150f, -0.04972018f, -0.02137470f, 
    0.02521412f, -0.05026121f, -0.03476787f, 0.01560127f, -0.01531325f, -0.00528836f, -0.02851428f, 0.00652459f, 
    0.03062626f, -0.04402391f, 0.04962858f, -0.04663471f, 0.00464641f, -0.01229650f, -0.04724896f, -0.05110471f, 
    0.04528631f, -0.05379517f, -0.05618675f, 0.03482722f, 0.01842719f, 0.03938605f, -0.02499556f, 0.01010208f, 
    0.03373377f, -0.03613313f, 0.02326793f, -0.05317195f, -0.00357497f, -0.04335725f, 0.00333982f, 0.04437460f, 
    -0.04085537f, 0.01651675f, -0.01564401f, 0.00966149f, 0.02494672f, -0.03228376f, -0.00321779f, 0.00009393f, 
    -0.01361626f, -0.04908310f, 0.02608621f, 0.00871855f, 0.02605378f, -0.04402221f, -0.05853001f, -0.04133370f, 
    -0.05112357f, -0.04896047f, -0.00502144f, -0.03388365f, -0.05912875f, -0.06157374f, 0.04167898f, -0.03962983f, 
    0.05296643f, -0.00937048f, -0.00327181f, 0.00410040f, 0.04067710f, -0.04445397f, 0.01435498f, 0.00283341f, 
    0.04279175f, 0.02442851f, -0.00513625f, 0.00973315f, 0.01601816f, -0.03054321f, -0.01220750f, -0.04455158f, 
    0.02366422f, -0.02709458f, -0.02266698f, 0.00330542f, -0.03736420f, -0.00607075f, -0.01560687f, 0.02778694f, 
    -0.04334157f, -0.05222947f, -0.05305714f, 0.04221834f, 0.01350485f, 0.01599439f, -0.03149548f, 0.00036972f, 
    0.00063457f, -0.00031892f, -0.04367839f, -0.02082962f, -0.03651424f, 0.03908560f, -0.01138421f, 0.00793454f, 
    -0.02879373f, 0.02997906f, -0.05857666f, -0.03096981f, 0.02192281f, 0.02812330f, -0.02257474f, 0.01034022f, 
    0.00241551f, -0.02001362f, -0.02786949f, 0.02448234f, 0.04511769f, 0.02497589f, -0.02270429f, 0.04939411f, 
    0.04059122f, 0.00607209f, 0.00585065f, -0.04853507f, 0.04764568f, -0.03724066f, 0.03404389f, 0.02687020f, 
    0.04971253f, 0.03975125f, -0.03163039f, 0.01494992f, -0.05271560f, 0.05226091f, -0.00124511f, -0.00398225f, 
    -0.00141654f, -0.02790169f, 0.04954186f, 0.02708008f, 0.04877150f, -0.03296722f, -0.03192056f, -0.03516745f, 
    0.02022960f, 0.05228760f, -0.04167196f, 0.04007808f, -0.00024445f, 0.02478332f, 0.03603493f, -0.05047654f, 
    -0.05024583f, 0.00990170f, 0.03155932f, 0.01055269f, 0.02897716f, -0.03675875f, -0.04012833f, -0.00411946f, 
    -0.00187527f, -0.03320940f, -0.00813649f, -0.05980022f, 0.02647264f, -0.01552762f, -0.05741945f, -0.04321918f, 
    0.01251069f, -0.00554822f, 0.03596520f, -0.04433983f, -0.02711591f, 0.04589163f, -0.01891696f, 0.00487184f, 
    0.04130311f, 0.01764479f, 0.03701949f, 0.01687323f, -0.04529541f, 0.00968892f, -0.02030298f, -0.03545951f, 
    0.02311416f, 0.01229349f, 0.02176549f, -0.05110852f, 0.01419394f, 0.05149159f, -0.05053833f, -0.05218277f, 
    -0.02326040f, -0.00128507f, -0.02448795f, 0.03667973f, 0.02541284f, 0.03709335f, -0.04540630f, -0.04419776f, 
    0.01910944f, -0.01625944f, 0.00523801f, -0.04070052f, 0.02618974f, 0.04596339f, -0.02698597f, -0.06101739f, 
    0.04403053f, -0.04532408f, -0.05127800f, -0.00113652f, 0.00556327f, 0.04565127f, -0.00773914f, -0.02222765f, 
    -0.00299723f, 0.01017070f, 0.02780402f, -0.05545487f, -0.01630792f, 0.03332178f, 0.04399536f, -0.04250262f, 
    0.02797468f, -0.01007034f, 0.03684023f, -0.00555553f, 0.01510555f, 0.02469866f, -0.05960266f, -0.04094953f, 
    -0.05601126f, 0.03364410f, 0.01802285f, 0.04164034f, -0.04031037f, -0.03135826f, 0.01344656f, -0.00086532f, 
    -0.00644595f, 0.00233802f, 0.03334098f, -0.01886024f, -0.04604637f, 0.00691762f, 0.00395772f, -0.04653682f, 
    0.03179536f, -0.05397331f, -0.03652474f, -0.00216770f, -0.04996468f, -0.02347481f, 0.04074855f, -0.05163644f, 
    -0.03474237f, -0.02491724f, -0.02234252f, -0.00734544f, -0.03355188f, 0.00156179f, -0.04062802f, -0.01650000f, 
    0.03407430f, 0.04433993f, 0.04172214f, 0.02359403f, 0.00327617f, 0.00979870f, -0.00539594f, 0.01009468f, 
    0.03721148f, -0.00554960f, -0.05554058f, -0.04718005f, -0.04508709f, 0.00019714f, 0.01111735f, 0.04751492f, 
    -0.03471910f, -0.02172535f, -0.00117056f, 0.00644295f, -0.06205032f, -0.00814156f, -0.02171767f, -0.05560953f, 
    -0.01485885f, 0.04274205f, 0.01182202f, 0.03353113f, -0.04934097f, -0.00600939f, 0.03825872f, -0.05674868f, 
    0.00061696f, 0.01151137f, 0.04208263f, 0.01164173f, 0.02936953f, -0.02434173f, -0.02994277f, -0.02751673f, 
    0.03489558f, 0.01782856f, -0.04661267f, -0.01963413f, 0.02024233f, 0.04294160f, 0.00982971f, 0.00516382f, 
    0.02390669f, 0.04793592f, -0.06099596f, -0.03681900f, 0.02989405f, -0.00373025f, 0.03093399f, 0.02692373f, 
    -0.03838571f, 0.01158456f, 0.02563834f, -0.00306105f, -0.03712545f, 0.00822727f, -0.01536884f, -0.03356799f, 
    -0.03747434f, 0.00869427f, -0.02857758f, -0.02822089f, 0.00473936f, 0.00381057f, -0.03473512f, -0.01542643f, 
    -0.04735273f, -0.01119519f, 0.04819887f, 0.01489897f, -0.01081465f, 0.04440491f, -0.04496247f, -0.00632380f, 
    -0.03158823f, 0.04927136f, 0.02637004f, -0.01605241f, -0.02635802f, 0.01891713f, 0.00356224f, -0.01396581f, 
    0.03056414f, -0.02882468f, -0.01466220f, -0.05151907f, -0.05472288f, -0.00105578f, 0.01240795f, 0.03101892f, 
    0.03147693f, -0.01541855f, -0.03674491f, -0.02758644f, 0.03879264f, -0.03993227f, 0.04636539f, 0.05006392f, 
    0.00399079f, -0.01981519f, -0.02288184f, 0.03486399f, -0.03602267f, -0.06291692f, -0.04209118f, 0.03429346f, 
    -0.00806230f, -0.00456703f, 0.03937299f, -0.05962171f, -0.00334266f, -0.02826459f, 0.03497753f, -0.03565669f, 
    -0.01630855f, -0.01956814f, 0.03522230f, 0.05552187f, -0.03815897f, -0.01537129f, -0.05813882f, -0.05542669f, 
    -0.03792825f, -0.01196198f, -0.00154671f, -0.04395091f, -0.04063975f, 0.02927978f, 0.00047998f, 0.00737464f, 
    -0.00351204f, 0.05294564f, -0.05002946f, -0.04198468f, -0.04197247f, 0.00437271f, 0.05318411f, 0.02560997f, 
    0.05297893f, -0.01428970f, 0.01157854f, -0.03188061f, 0.02164325f, -0.02504389f, -0.03897331f, 0.01591809f, 
    0.00287845f, -0.04097180f, -0.00775910f, 0.02007693f, -0.05348765f, -0.04004119f, -0.03949497f, -0.06063494f, 
    -0.04399857f, 0.05219416f, -0.05932170f, -0.04059147f, -0.01956641f, 0.03286873f, 0.04506497f, -0.04496931f, 
    0.00406122f, 0.02146060f, -0.01082828f, 0.04417334f, 0.02189814f, 0.03960117f, -0.04563614f, 0.01525335f, 
    0.02491474f, 0.03050794f, -0.02687645f, -0.01441817f, -0.02693944f, 0.00693875f, -0.06089872f, -0.01738424f, 
    0.02676842f, 0.01112113f, 0.03233919f, -0.00200738f, -0.01621221f, -0.00944540f, 0.03833437f, -0.04585953f, 
    0.01268812f, 0.05159160f, 0.02356087f, -0.04233907f, -0.04255976f, 0.04966446f, -0.05586758f, -0.02336002f, 
    -0.00642505f, 0.04091687f, -0.03866553f, -0.04894388f, -0.05091521f, -0.03944490f, -0.01609446f, -0.03564610f, 
    0.03809153f, -0.05701114f, -0.01493359f, 0.01380878f, -0.06221439f, -0.01524682f, -0.03094218f, 0.00281906f, 
    0.00447056f, 0.02411124f, 0.00449922f, 0.01863625f, -0.00752884f, 0.04712633f, -0.04035677f, -0.04541406f, 
    -0.00298748f, 0.03378101f, 0.03630003f, -0.04694977f, -0.03684441f, 0.00284314f, -0.02979787f, -0.01381035f, 
    -0.04829124f, -0.02825982f, -0.04793640f, -0.04883593f, 0.04856537f, -0.04560797f, -0.00093231f, 0.00337295f, 
    0.01564263f, 0.03842721f, 0.00662035f, 0.02251862f, 0.00638582f, -0.02826518f, -0.02057465f, 0.02540961f, 
    -0.04439205f, -0.02045446f, 0.04617442f, 0.01296149f, -0.05208654f, -0.04016494f, -0.05633497f, -0.04911265f, 
    0.01266532f, -0.05923643f, 0.02294724f, -0.03808844f, 0.03459989f, -0.01612302f, 0.02713821f, -0.04255357f, 
    -0.04335265f, -0.05646518f, 0.01853167f, 0.04553898f, 0.04137883f, 0.03368841f, -0.01432230f, -0.00522675f, 
    -0.00868208f, 0.00612728f, 0.01602978f, 0.02357078f, -0.05790967f, 0.02077623f, -0.02517768f, -0.01294860f, 
    -0.06087141f, 0.03163312f, 0.01027438f, 0.00016235f, -0.01174239f, -0.05738584f, 0.02727515f, 0.02883354f, 
    -0.03423436f, 0.04230787f, -0.01644611f, 0.01025650f, -0.01909610f, -0.00243963f, 0.04460065f, 0.05294565f, 
    -0.00252919f, -0.01395823f, 0.02273339f, 0.02919463f, 0.03553306f, -0.00550897f, 0.00493317f, 0.00859635f, 
    0.05084445f, -0.04309998f, -0.05134604f, -0.04196748f, -0.00537286f, -0.05479857f, -0.02237937f, 0.03558290f, 
    -0.01753572f, 0.03584755f, 0.02043168f, 0.00996629f, -0.02520444f, 0.04352237f, 0.00023771f, 0.04220381f, 
    0.04116349f, -0.02822530f, 0.02970425f, 0.04459708f, 0.01556082f, -0.01158651f, -0.04165990f, 0.00321132f, 
    -0.05606217f, -0.04625702f, -0.03931678f, -0.05185391f, 0.04500046f, 0.04352150f, 0.00255595f, -0.02965843f, 
    0.11929251f, -0.10179508f, 0.17859708f, -0.07298128f, 0.15135612f, -0.04205511f, 0.05644059f, 0.08707745f, 
    -0.06425873f, 0.02059266f, 0.14040035f, -0.04440102f, 0.09000187f, 0.06504184f, 0.10439156f, -0.01312619f, 
    -0.00927510f, 0.06214424f, -0.05851984f, 0.02484689f, -0.27049983f, 0.17265779f, -0.09743773f, 0.12533619f, 
    0.04090317f, -0.00384776f, 0.11451574f, 0.06249670f, 0.10394532f, 0.18335508f, 0.06605617f, 0.08317611f, 
    0.10606693f, -0.07430813f, 0.03996759f, -0.01974059f, 0.09432851f, 0.13463840f, 0.09516832f, -0.01025521f, 
    -0.03946012f, -0.12448225f, 0.19861564f, 0.21770081f, 0.24623808f, 0.05407152f, 0.12328234f, -0.04587303f, 
    0.12015302f, 0.02032327f, 0.10141115f, 0.10507663f, 0.08110426f, 0.14280386f, 0.02659096f, -0.06035149f, 
    0.07775785f, -0.06659632f, 0.11379336f, 0.01565081f, -0.17282113f, -0.06452694f, -0.09083492f, 0.15199681f, 
    -0.03462358f, 0.06386496f, 0.02946928f, 0.10046358f, 0.02506613f, 0.07444640f, 0.03324102f, 0.10275018f, 
    0.08758563f, 0.03135592f, -0.06454280f, 0.08214232f, 0.04572302f, 0.03196736f, -0.03726048f, 0.07971973f, 
    -0.24222937f, 0.14037147f, 0.01266522f, -0.04782782f, 0.10049281f, 0.03104120f, 0.04058259f, -0.07544376f, 
    0.01267522f, -0.02690029f, 0.08403293f, 0.00596149f, 0.02841408f, 0.00246125f, 0.04213699f, 0.03775723f, 
    -0.01659925f, -0.08630566f, -0.01344996f, 0.02383100f, -0.06667409f, -0.00114325f, -0.03554815f, 0.13338795f, 
    -0.01505268f, -0.01653943f, -0.02707875f, 0.04169900f, 0.07785095f, 0.04798969f, 0.01096440f, 0.03573886f, 
    -0.06784119f, -0.04481065f, 0.00152090f, -0.05055132f, 0.00314968f, -0.03446215f, 0.12144462f, 0.09522986f, 
    -0.03975975f, 0.19605480f, -0.18784580f, -0.10815536f, -0.20049027f, -0.08547071f, -0.06018355f, 0.00412596f, 
    -0.05905350f, -0.03562482f, 0.01058457f, -0.02330423f, -0.01408434f, 0.07778615f, 0.09127139f, 0.07463416f, 
    -0.04841802f, -0.03464976f, 0.05296999f, 0.08019204f, -0.28957680f, 0.08008195f, -0.02979157f, -0.01414682f, 
    0.01086630f, -0.04710794f, 0.03460172f, 0.12208761f, -0.02276424f, 0.07671243f, -0.08428480f, -0.05335840f, 
    -0.02648767f, -0.15874808f, 0.04918174f, -0.02150796f, 0.07124922f, 0.01392760f, 0.07260526f, -0.05396447f, 
    0.40989521f, 0.33816090f, -0.05777330f, -0.26291716f, -0.07208271f, -0.00184162f, 0.00304848f, -0.07824565f, 
    0.05131332f, -0.01641681f, 0.00672433f, 0.06260383f, -0.02430708f, 0.02375560f, -0.03987971f, 0.06005892f, 
    -0.11523784f, 0.00175925f, -0.03466340f, 0.07670154f, -0.14219786f, -0.08364768f, -0.09176996f, -0.07664831f, 
    0.04910500f, 0.03380296f, -0.03142311f, 0.02430291f, 0.09130085f, -0.04545742f, 0.08761010f, 0.04802641f, 
    0.02155798f, -0.02130344f, 0.03428400f, 0.10276926f, 0.08698743f, -0.05783714f, -0.01812467f, 0.16327871f, 
    0.46582738f, -0.11866528f, -0.22065285f, 0.06937953f, -0.11598496f, -0.01837300f, -0.05993178f, 0.06493752f, 
    0.00517267f, -0.06271283f, 0.03114915f, -0.07030299f, 0.07054712f, 0.04451601f, 0.01882954f, -0.00443042f, 
    0.02211983f, 0.02834436f, -0.03075696f, -0.04915997f, 0.24970137f, -0.05825122f, -0.18926147f, -0.05442959f, 
    -0.00670731f, -0.04362701f, -0.14226075f, 0.10780580f, 0.01720439f, -0.09054874f, 0.04557780f, -0.01826530f, 
    0.00726464f, 0.01186358f, -0.00341263f, 0.08451980f, -0.02140600f, 0.14036617f, 0.04745280f, -0.05490649f, 
    -0.08362769f, -0.04468152f, -0.09200282f, 0.14388677f, 0.02118594f, 0.05649478f, -0.06335198f, 0.12237670f, 
    0.02163601f, 0.11105924f, 0.04296714f, 0.02415425f, -0.01192040f, -0.04244691f, 0.11325095f, 0.03125297f, 
    -0.02177074f, 0.01510639f, 0.07531197f, 0.10789791f, -0.18975019f, -0.00844879f, -0.11307932f, -0.20009810f, 
    -0.24375302f, 0.07621811f, 0.03152198f, -0.08305109f, 0.12418697f, 0.05947621f, -0.10830428f, 0.00748023f, 
    -0.00156383f, 0.02326080f, -0.00723832f, 0.02083117f, 0.06666639f, -0.06188211f, -0.08180067f, 0.07373681f, 
    -0.12983181f, -0.13565597f, -0.05303092f, -0.03401447f, 0.02643870f, -0.00817320f, -0.14755557f, 0.06784169f, 
    -0.02668501f, 0.07693020f, -0.01171099f, -0.12649642f, 0.05992090f, 0.05721021f, -0.01812194f, 0.20450318f, 
    0.00961193f, 0.02704607f, 0.08060335f, 0.03440800f, 0.27600092f, -0.28104287f, -0.00220220f, -0.08088765f, 
    -0.06824367f, 0.01195426f, -0.02543151f, 0.05431734f, 0.08051815f, 0.04058526f, -0.03423133f, -0.00478835f, 
    0.14865333f, 0.06538696f, 0.13392441f, 0.08280646f, 0.06869036f, 0.10628048f, 0.09454063f, 0.10834066f, 
    0.00127878f, -0.03940153f, -0.00062579f, -0.01750495f, -0.04023311f, 0.00051628f, 0.00278612f, 0.03522582f, 
    -0.06763260f, -0.03832994f, 0.04670969f, -0.04746327f, -0.06184971f, -0.06324412f, 0.00918763f, 0.00159966f, 
    0.01718933f, 0.02430520f, 0.02615776f, -0.03680550f, 0.01836052f, -0.06308921f, -0.04334290f, -0.01965152f, 
    0.02863156f, 0.01765869f, 0.03196701f, -0.05616930f, -0.04311452f, 0.01253253f, -0.02644457f, -0.06251328f, 
    -0.06213990f, 0.01631802f, 0.01835284f, 0.00596928f, -0.02372338f, -0.02411758f, -0.03464026f, -0.03970171f, 
    0.04165285f, -0.06274478f, -0.04856297f, -0.06129412f, -0.03098916f, -0.00856314f, -0.03387651f, -0.00139173f, 
    0.01457203f, -0.00685473f, -0.00056097f, 0.02111033f, -0.02985163f, 0.00557306f, 0.03025596f, -0.00659518f, 
    -0.01868489f, -0.04919475f, 0.03006767f, 0.03950627f, 0.01022942f, -0.00784138f, 0.04192824f, 0.03828942f, 
    0.02133297f, 0.01519955f, 0.02846895f, -0.00060101f, -0.05039959f, 0.00865548f, -0.03682622f, 0.04755158f, 
    0.02556803f, 0.00293264f, -0.00671591f, 0.01241591f, 0.04191801f, 0.00062213f, 0.03311893f, 0.01242983f, 
    -0.03361852f, 0.00288414f, -0.01835755f, 0.01430833f, 0.01122552f, -0.00561450f, -0.02036601f, 0.01632021f, 
    -0.01499793f, 0.01472689f, 0.01704620f, 0.02390043f, -0.03057184f, 0.01044384f, 0.02711909f, 0.02064878f, 
    0.00505122f, 0.02857908f, 0.01445840f, -0.05921786f, -0.02853958f, 0.01907124f, 0.01389476f, 0.03748100f, 
    -0.05705819f, -0.01870602f, 0.02450965f, -0.01814198f, 0.02129562f, -0.04975784f, -0.00992831f, -0.03235151f, 
    -0.00746086f, -0.03829723f, 0.03429084f, -0.01083125f, -0.02725417f, -0.04299809f, 0.01392150f, 0.00635892f, 
    -0.01494004f, -0.02920567f, -0.06276307f, 0.02638876f, 0.01111783f, 0.04741503f, -0.01367217f, 0.03249669f, 
    0.02588325f, 0.00822477f, -0.00980132f, 0.02349827f, 0.03679753f, -0.03755252f, 0.04272339f, 0.03845653f, 
    -0.05725734f, -0.03908123f, 0.01895543f, -0.01192184f, -0.01747895f, 0.02366659f, 0.04024636f, -0.05351700f, 
    -0.00449099f, 0.01212320f, -0.01332926f, -0.01236590f, 0.01219130f, -0.03643023f, 0.00257940f, 0.01674073f, 
    -0.05196024f, 0.02524363f, -0.03610158f, -0.05925231f, 0.03273701f, -0.02316221f, -0.03274332f, 0.03015810f, 
    0.00884792f, 0.00072119f, -0.00371772f, -0.00458323f, 0.03814447f, -0.06361911f, -0.01097604f, 0.02632366f, 
    0.01621599f, 0.00957613f, -0.01126415f, 0.03204907f, -0.05960010f, -0.04665758f, 0.00158752f, 0.02642475f, 
    -0.03597947f, -0.02722656f, -0.03451018f, 0.00515800f, -0.01806624f, 0.03048998f, -0.03957353f, 0.05083080f, 
    -0.01860218f, 0.02896737f, 0.03320492f, 0.02810218f, -0.02900128f, 0.02398466f, -0.02225728f, -0.06032196f, 
    -0.04939727f, 0.00562138f, -0.04855201f, -0.02619262f, -0.04750675f, -0.06143810f, -0.02746454f, 0.02560534f, 
    0.01744969f, -0.04210588f, -0.03898568f, 0.00363085f, -0.04210343f, 0.02322392f, -0.04967040f, 0.01883471f, 
    0.01601163f, -0.04987222f, 0.01181723f, 0.02074795f, 0.02279492f, 0.02776792f, 0.02952714f, 0.01636879f, 
    0.02038164f, -0.04548281f, 0.00688452f, 0.03330499f, -0.04180846f, 0.04286087f, 0.03269654f, -0.02718565f, 
    0.01715160f, 0.02634987f, 0.03461267f, -0.04428234f, -0.01643143f, 0.00285433f, 0.03728807f, -0.05509812f, 
    -0.05514434f, 0.02668003f, 0.01788583f, -0.05835807f, -0.05457960f, -0.04539500f, -0.05725442f, 0.00538736f, 
    -0.02446973f, 0.01337382f, -0.05951145f, 0.01949932f, 0.03393616f, -0.05859585f, -0.00888949f, 0.01804450f, 
    -0.03327863f, 0.00797486f, -0.05746296f, -0.00441974f, -0.03845362f, 0.01169356f, -0.01528172f, 0.01446011f, 
    0.04732035f, 0.00753043f, -0.00017396f, -0.01887588f, -0.01430554f, -0.05175490f, -0.01382167f, 0.04592601f, 
    0.02020083f, 0.00951564f, -0.00942139f, -0.05981668f, -0.03861419f, -0.04157003f, 0.01900772f, -0.04817661f, 
    -0.03289218f, 0.02529437f, -0.05869178f, -0.02149727f, -0.05151282f, -0.04944925f, -0.01446409f, 0.01703612f, 
    0.04483753f, 0.00154061f, 0.02031692f, 0.00487314f, 0.04450795f, -0.04552796f, -0.00076732f, 0.04558781f, 
    -0.02582089f, -0.06043708f, -0.04152070f, -0.01316868f, -0.03828815f, -0.01874033f, 0.04393090f, 0.03902925f, 
    0.04128333f, -0.03888788f, -0.05617348f, 0.00278022f, -0.01305649f, 0.04705793f, -0.01945889f, -0.03989165f, 
    0.01202098f, -0.02357511f, 0.03049156f, -0.03031971f, 0.01020388f, 0.00316918f, 0.02462175f, -0.00274645f, 
    0.04061076f, -0.03117113f, 0.02342728f, -0.03916083f, -0.05381453f, -0.05758521f, 0.00550719f, 0.01560273f, 
    0.27442977f, -0.16520916f, 0.29631913f, 0.07618327f, -0.24446195f, 0.06431694f, 0.04337082f, -0.06987630f, 
    0.09150355f, -0.10683142f, -0.07035626f, 0.00120239f, -0.11831781f, 0.10558877f, -0.05039093f, 0.02778421f, 
    0.04538620f, -0.05927710f, 0.03037550f, -0.01911968f, 0.11975900f, 0.02928509f, -0.06887326f, 0.14005281f, 
    -0.07152785f, -0.17897156f, -0.04597640f, -0.14407758f, -0.00897832f, 0.00288728f, -0.03288923f, 0.01203015f, 
    0.12242436f, 0.03239897f, -0.02562188f, -0.03913273f, 0.02398936f, -0.04064705f, 0.01050422f, 0.04441655f, 
    0.07010508f, 0.41903305f, 0.11692042f, 0.07010183f, 0.20406872f, 0.10966125f, 0.14429642f, -0.03293895f, 
    -0.01944078f, 0.09934295f, -0.01843223f, -0.07052218f, 0.02164227f, -0.09602272f, 0.10775003f, 0.07679825f, 
    0.12175675f, 0.07217383f, -0.04134141f, -0.00930014f, -0.39867210f, 0.25374058f, -0.02064899f, 0.09352487f, 
    0.01633329f, 0.01764801f, 0.02217250f, 0.08333290f, -0.06708764f, 0.00320019f, -0.08039580f, 0.11348794f, 
    -0.00838874f, 0.08269055f, -0.00031323f, -0.03560209f, -0.06523608f, -0.05648636f, 0.02896428f, -0.05762647f, 
    0.10296632f, -0.07514064f, 0.10275836f, 0.02869820f, 0.12318491f, -0.06852416f, 0.04736461f, -0.10318017f, 
    0.08728881f, -0.08672217f, 0.03154150f, -0.00136636f, 0.00368006f, 0.01080260f, 0.03142746f, 0.10340324f, 
    0.07084024f, -0.11153259f, 0.03138189f, -0.02229797f, 0.20215149f, 0.11803265f, -0.00677978f, 0.13323936f, 
    0.03713712f, 0.11282386f, -0.04316093f, 0.00262978f, 0.06336341f, 0.02254928f, -0.19185770f, 0.09936115f, 
    -0.01849861f, 0.08686223f, -0.03611851f, -0.04349422f, -0.02909445f, 0.00928150f, 0.09002618f, 0.08220503f, 
    -0.18333995f, 0.41915271f, -0.16800719f, 0.02889516f, -0.12496641f, 0.08679907f, 0.00924183f, 0.09875640f, 
    0.06341233f, -0.08168733f, 0.00901630f, 0.09910879f, 0.05989633f, -0.06545151f, -0.00652714f, 0.06721424f, 
    -0.02164561f, 0.08071459f, 0.07145157f, 0.06731214f, -0.05668638f, 0.03954297f, 0.11667073f, 0.16885783f, 
    0.01510867f, -0.02468991f, -0.05832895f, -0.06112320f, -0.07869870f, 0.04259759f, -0.03511600f, 0.03735419f, 
    0.03010625f, -0.05816387f, 0.09325436f, 0.06308629f, -0.01396563f, -0.12509975f, 0.07225116f, -0.09062368f, 
    0.42730820f, -0.06957877f, -0.04371198f, -0.05067354f, 0.17436340f, -0.06234964f, 0.01678051f, -0.22794074f, 
    -0.08173332f, -0.13599198f, -0.01856397f, -0.13149743f, 0.04320920f, -0.02620799f, 0.07889594f, 0.06093277f, 
    0.06638944f, 0.03123268f, 0.10339401f, 0.00345606f, -0.00606522f, -0.06175448f, -0.14182201f, -0.22343007f, 
    -0.01593172f, 0.11286591f, 0.10954008f, 0.11347536f, -0.04773087f, -0.04743521f, 0.08676260f, 0.11599424f, 
    0.06519408f, 0.05319304f, 0.07083349f, 0.15209624f, 0.09106594f, -0.02634946f, -0.19170889f, 0.06275157f, 
    0.02609322f, 0.15397607f, 0.04376931f, -0.02232947f, 0.15588719f, 0.07461637f, 0.11606216f, 0.03857473f, 
    -0.05401197f, -0.06107765f, -0.02352368f, -0.03474947f, 0.08853870f, -0.06376611f, -0.01824470f, 0.03338675f, 
    0.01936157f, 0.08182349f, -0.08860487f, 0.00964869f, 0.02319273f, -0.07442004f, -0.12620720f, 0.18748768f, 
    0.03124707f, -0.04231065f, 0.09088338f, 0.06808163f, 0.04771801f, 0.08135445f, 0.00763559f, 0.10454269f, 
    0.02800283f, -0.12696804f, 0.15230353f, 0.11304016f, -0.09011056f, 0.15318708f, 0.04178276f, -0.07195137f, 
    -0.16382772f, 0.04964613f, 0.00447764f, 0.05821193f, -0.00612687f, 0.09785397f, -0.07697355f, -0.03235589f, 
    -0.00684379f, -0.05677863f, 0.07996912f, 0.06071721f, -0.13022587f, -0.02115631f, 0.15356298f, -0.06097241f, 
    0.06942361f, -0.04945375f, 0.01419318f, 0.04566716f, -0.25262761f, 0.40370065f, -0.13316046f, -0.18063293f, 
    -0.35435158f, 0.13359621f, 0.12695342f, 0.14111476f, 0.06118185f, 0.05621685f, -0.07771149f, -0.01541990f, 
    -0.01457478f, -0.05859326f, -0.00503939f, -0.00710441f, 0.05778263f, -0.18722507f, 0.04667408f, -0.13774258f, 
    -0.08198602f, -0.11340489f, 0.07001396f, 0.23608072f, 0.05938175f, -0.03033132f, -0.12644714f, 0.01152754f, 
    -0.05924826f, 0.07643468f, 0.07062840f, 0.06358525f, -0.01457299f, 0.05185905f, 0.04425929f, 0.13456877f, 
    0.11361588f, 0.05668611f, 0.06684504f, -0.02948571f, 0.49143535f, -0.18538871f, -0.16029710f, 0.02536513f, 
    -0.10144940f, -0.06908761f, -0.07404629f, -0.03098193f, -0.04552066f, -0.05136836f, -0.09777216f, -0.00678297f, 
    0.04579545f, 0.12195160f, 0.03903538f, 0.10030144f, 0.05503122f, 0.03790253f, -0.20877434f, -0.08122356f, 
    0.03252898f, -0.04648226f, 0.04090067f, -0.05632058f, 0.04546615f, -0.00841074f, -0.02831571f, -0.03518461f, 
    -0.03191512f, 0.00603434f, -0.03216800f, 0.01103874f, -0.01085477f, -0.01972545f, 0.02060540f, -0.05249976f, 
    -0.05976671f, 0.04486562f, -0.02903395f, 0.04363149f, -0.03067696f, -0.01312585f, 0.01187528f, -0.06115458f, 
    -0.03533831f, 0.02785567f, -0.01254639f, 0.02127765f, 0.02121020f, -0.05894402f, -0.06227894f, 0.02924278f, 
    -0.06102632f, -0.02557487f, 0.01350380f, -0.03013725f, 0.00576423f, -0.02657945f, 0.04222414f, 0.03992430f, 
    -0.00504243f, 0.04513393f, -0.01301722f, -0.03141400f, 0.00980127f, -0.04797947f, -0.03531549f, -0.00435508f, 
    -0.04285775f, 0.01455870f, -0.04974102f, -0.06211925f, -0.01503671f, -0.04556384f, -0.05353803f, 0.02463522f, 
    -0.02191844f, 0.01860261f, -0.00355071f, 0.04526310f, -0.03756172f, 0.03323462f, -0.01503186f, 0.00649536f, 
    -0.03124920f, 0.03131093f, -0.03248854f, 0.02814827f, -0.03466966f, -0.04125836f, -0.06339858f, -0.01119551f, 
    -0.03670875f, 0.02597529f, 0.03107963f, -0.04068501f, -0.00513094f, -0.00855946f, -0.05706440f, -0.01907311f, 
    -0.03165155f, 0.02394616f, 0.00132042f, -0.02091006f, -0.05347140f, 0.01084325f, 0.04152998f, -0.02176250f, 
    -0.03963208f, 0.00398527f, 0.04269153f, 0.04549314f, 0.02583931f, -0.01313585f, 0.04403114f, -0.03738849f, 
    -0.03295453f, 0.01566163f, 0.02046226f, -0.02942788f, -0.06327247f, 0.03850834f, 0.00725943f, -0.03403796f, 
    -0.04225566f, 0.03801208f, -0.04728181f, 0.00081578f, -0.04541547f, 0.01130950f, -0.02132652f, 0.02870095f, 
    0.03807510f, -0.02763221f, -0.05243833f, -0.05682009f, 0.00070163f, -0.04813609f, 0.01918021f, 0.03399628f, 
    -0.02182819f, 0.01269377f, 0.01175253f, 0.03198534f, -0.01725469f, -0.03923157f, 0.00877643f, -0.02734954f, 
    -0.05441700f, -0.00170704f, -0.01248928f, 0.03966906f, -0.04033492f, -0.03231795f, -0.02271607f, 0.03332436f, 
    -0.00195960f, -0.03123902f, -0.03907593f, -0.05726849f, -0.06237713f, -0.03931536f, -0.03825544f, 0.02263172f, 
    0.04759350f, 0.03319287f, 0.02624471f, -0.03295232f, -0.02930514f, 0.01084106f, -0.04338855f, -0.05317191f, 
    0.00751380f, 0.01362577f, -0.01144749f, -0.04898575f, -0.00337534f, -0.00218487f, 0.03892899f, -0.05911078f, 
    -0.02076803f, 0.00418124f, 0.01302071f, -0.04039549f, 0.01548371f, 0.01427742f, 0.02292434f, 0.00339894f, 
    -0.05375077f, -0.03538226f, 0.03553911f, 0.00770711f, 0.03457342f, -0.04875479f, -0.01159732f, 0.04223536f, 
    -0.02932750f, -0.03977595f, 0.04202132f, -0.00375177f, 0.01365988f, -0.01351572f, -0.03187433f, 0.02621436f, 
    0.01315848f, 0.03342645f, -0.03128661f, -0.05645265f, 0.02381864f, -0.02458662f, -0.06005687f, 0.00061559f, 
    -0.01599682f, 0.02078411f, 0.00306811f, -0.05419778f, -0.01583587f, 0.00961223f, 0.00917801f, 0.04402467f, 
    -0.00583863f, 0.00347803f, -0.00641311f, 0.03428039f, -0.01975510f, 0.01843276f, 0.02691899f, -0.01952916f, 
    -0.02153328f, 0.02153756f, 0.01735256f, 0.00276197f, -0.01119443f, -0.02250106f, -0.05096852f, 0.04374056f, 
    -0.00074356f, 0.02097890f, 0.02807734f, 0.04436463f, -0.04859447f, -0.03551800f, -0.03276644f, -0.05491173f, 
    -0.03628476f, 0.02884017f, -0.00452104f, 0.03453571f, -0.03966348f, -0.05656597f, -0.04673410f, 0.03211417f, 
    0.01107451f, 0.02550634f, 0.00026207f, -0.01017129f, 0.04541690f, -0.04662301f, 0.03706602f, -0.03205213f, 
    -0.03492225f, 0.00314888f, 0.04276954f, -0.05439942f, 0.00951950f, -0.04642689f, -0.00329172f, 0.01313769f, 
    0.02877819f, 0.03996433f, 0.01871429f, -0.01347714f, 0.01220368f, -0.04259415f, -0.03630244f, 0.01015745f, 
    -0.02344627f, 0.01524990f, -0.04253354f, -0.04447704f, -0.01226152f, -0.06493430f, -0.04185678f, -0.04360216f, 
    0.04621514f, -0.05831413f, 0.03617242f, 0.03893410f, -0.01142771f, 0.02708191f, -0.05227942f, 0.02996612f, 
    -0.04707900f, 0.03616075f, 0.03726774f, 0.00994110f, 0.03417464f, 0.02320109f, 0.01280371f, -0.04050678f, 
    -0.01622492f, 0.02462269f, -0.03654210f, -0.05760057f, 0.00181783f, -0.03041289f, -0.04638968f, -0.05561785f, 
    0.01341035f, -0.00326775f, 0.00150033f, 0.00367526f, -0.02957121f, -0.00430003f, 0.02574117f, -0.01984958f, 
    -0.03787162f, 0.03606878f, -0.02014087f, -0.02516029f, -0.05170102f, -0.00853332f, 0.00721188f, 0.03824444f, 
    0.02940504f, 0.02196411f, -0.02958359f, 0.03939913f, -0.01737410f, -0.05442255f, -0.05288483f, -0.00832825f, 
    0.01212165f, 0.00054939f, -0.01664533f, 0.01763905f, -0.02189916f, 0.03055441f, -0.02981798f, 0.02234246f, 
    -0.00896535f, 0.02730769f, 0.03473437f, -0.02566398f, -0.03055233f, -0.02356374f, 0.00855653f, 0.04251913f, 
    0.01533537f, 0.05476043f, -0.03307093f, -0.04617514f, 0.00814823f, -0.01685352f, -0.05864129f, -0.00964286f, 
    -0.03884292f, -0.01033207f, -0.06196724f, -0.02523475f, 0.03478938f, 0.02959760f, 0.02998671f, 0.02572067f, 
    -0.01144788f, 0.02826185f, 0.00104630f, -0.00562492f, -0.03778483f, -0.04225342f, 0.03027097f, 0.01707853f, 
    0.05326052f, -0.05191452f, -0.03912259f, -0.05727618f, 0.02656261f, 0.01366025f, 0.00868056f, 0.03668234f, 
    0.02937531f, 0.01679813f, 0.05945918f, -0.00791384f, -0.04897867f, -0.02748013f, 0.01280972f, -0.00550309f, 
    0.00686763f, -0.03820542f, 0.03240599f, 0.02160166f, -0.01325401f, 0.00639345f, -0.04513309f, 0.03252241f, 
    0.04657019f, 0.00405942f, 0.04777367f, 0.04270713f, -0.00634021f, -0.05045548f, -0.03630555f, -0.03305298f, 
    0.02120542f, 0.01382769f, 0.02476146f, 0.02346336f, 0.04572460f, -0.04534703f, 0.02321355f, -0.03933225f, 
    -0.04941879f, 0.02161925f, -0.00071929f, -0.00377987f, 0.03044772f, 0.03105544f, -0.03944334f, -0.03208761f, 
    -0.01990503f, -0.03018254f, -0.05379706f, -0.01148571f, 0.00837143f, -0.02595683f, -0.05338308f, -0.01663019f, 
    0.00826356f, 0.03922797f, -0.00390112f, 0.02815384f, 0.01615472f, 0.04577944f, -0.00133925f, -0.02737425f, 
    -0.00932815f, 0.04020927f, 0.01778010f, -0.05099329f, 0.02298996f, 0.00328890f, 0.03865244f, -0.02979641f, 
    0.03179613f, 0.02536799f, 0.02168788f, -0.05845190f, 0.02648641f, -0.04460427f, 0.03505006f, 0.01614555f, 
    0.04778160f, -0.00816469f, -0.01264566f, -0.00987707f, 0.04578261f, 0.00481726f, 0.00029408f, 0.01206383f, 
    0.02450426f, -0.05981537f, -0.05915937f, -0.03796898f, -0.01797770f, 0.00640025f, -0.04741871f, -0.04631030f, 
    -0.01319486f, -0.05020583f, 0.02193340f, -0.02300004f, -0.03883773f, 0.04659116f, -0.05332755f, 0.00062585f, 
    -0.05889604f, -0.00372810f, -0.05335665f, -0.02939547f, -0.05083512f, -0.04207016f, -0.01808252f, 0.00974056f, 
    0.02458526f, -0.05748367f, 0.00751105f, 0.03924498f, 0.02346357f, 0.01902409f, 0.03372125f, -0.05986808f, 
    0.03750284f, -0.00547817f, 0.01817513f, -0.06016936f, -0.04601888f, -0.05008788f, -0.01683696f, -0.02783248f, 
    -0.02629724f, 0.04360849f, -0.01230010f, 0.02021440f, -0.03508624f, -0.00556421f, 0.04877198f, 0.00324574f, 
    -0.02852789f, -0.00219550f, -0.00473059f, 0.04167934f, 0.02784980f, -0.04256513f, -0.04544022f, -0.05368841f, 
    -0.02893448f, 0.01216600f, -0.01175483f, -0.04195952f, -0.00467663f, 0.02316687f, 0.01681856f, -0.00083188f, 
    0.01642712f, 0.04153253f, 0.03073885f, -0.05651012f, 0.02210527f, -0.05400447f, -0.00928264f, 0.02139838f, 
    -0.00973134f, 0.02364839f, 0.01571147f, -0.02389609f, -0.01235907f, -0.03980573f, -0.03962259f, 0.02884497f, 
    -0.02913423f, -0.05455291f, -0.00069274f, 0.02806038f, 0.01822265f, -0.06336945f, 0.01216873f, 0.04621605f, 
    0.04271197f, 0.00229928f, -0.00665164f, 0.01199368f, -0.00717471f, -0.01455389f, 0.03313332f, 0.00977416f, 
    0.02080632f, -0.06126055f, 0.03616083f, -0.00216612f, 0.00743265f, 0.01263080f, 0.03565655f, 0.03811880f, 
    -0.02305360f, -0.03149185f, -0.01889527f, 0.02386864f, -0.02653194f, -0.00242957f, -0.03159378f, -0.00581838f, 
    0.01006395f, -0.04267719f, 0.00207907f, 0.01918601f, 0.03596352f, 0.03165711f, -0.02474811f, -0.00853632f, 
    -0.05268516f, 0.01465830f, -0.05415570f, -0.06212143f, -0.01698575f, -0.05176668f, 0.01318481f, -0.06214359f, 
    0.01523886f, -0.00397976f, -0.05400602f, 0.00780675f, -0.01750301f, -0.02458729f, 0.02321354f, -0.05164413f, 
    0.02489582f, -0.04097020f, -0.04909116f, 0.01098062f, 0.03776400f, 0.00873044f, -0.04107290f, -0.03034772f, 
    0.00903549f, -0.04180183f, -0.00324826f, 0.01709939f, 0.04387808f, -0.01022523f, 0.03700649f, -0.00830927f, 
    0.01767581f, 0.04093899f, -0.05625189f, -0.04511984f, -0.05634986f, -0.01529494f, -0.01140664f, -0.04061240f, 
    0.03533690f, -0.05821565f, -0.04032880f, 0.04081923f, 0.04041442f, -0.02248436f, 0.04658414f, -0.03706427f, 
    0.03742817f, 0.00549323f, 0.02372725f, 0.00250059f, 0.04524506f, -0.04204893f, -0.01140364f, 0.02370518f, 
    0.04984003f, -0.00304761f, -0.00049267f, 0.02955192f, -0.06155230f, 0.04729911f, -0.03013510f, 0.01880751f, 
    0.03054980f, -0.00052595f, -0.05201714f, 0.02567637f, -0.04091016f, -0.01358323f, -0.02318058f, -0.00517650f, 
    0.03659988f, -0.00968043f, -0.02919499f, -0.02001162f, -0.04643444f, -0.05518905f, -0.04983798f, -0.01686799f, 
    0.38692835f, 0.08829293f, -0.02509845f, -0.14455746f, 0.02065924f, 0.04840321f, 0.03280125f, 0.07969730f, 
    0.01652488f, 0.01742306f, -0.03540463f, 0.09114408f, -0.07339662f, -0.03188908f, -0.00448211f, -0.00703792f, 
    -0.03906846f, -0.01335647f, -0.11508844f, -0.04946257f, 0.27807021f, 0.08532131f, -0.14579064f, 0.21950848f, 
    -0.04180576f, -0.05159542f, 0.12550345f, 0.11980852f, -0.00072261f, -0.08821101f, -0.02693668f, 0.05827694f, 
    -0.20577012f, 0.03055766f, 0.02055020f, -0.06935633f, -0.01412505f, -0.13420546f, 0.23358585f, -0.25149831f, 
    -0.04504455f, 0.09721465f, -0.09099775f, -0.07067574f, -0.27168396f, 0.08223067f, -0.01694854f, 0.25500897f, 
    -0.04637761f, 0.01536881f, -0.02709416f, 0.05152160f, 0.06277389f, -0.04209213f, -0.06063106f, -0.01030761f, 
    0.09133599f, 0.13080458f, 0.22086619f, 0.02786268f, 0.08341428f, 0.28597271f, 0.06853125f, -0.10928984f, 
    -0.03236259f, -0.06131230f, -0.07136057f, 0.10381295f, -0.00928531f, -0.20352235f, -0.04698578f, -0.11267592f, 
    0.09094241f, 0.11333919f, 0.00335422f, 0.03122327f, -0.07131769f, 0.00075614f, 0.01562152f, -0.07648062f, 
    -0.01961883f, 0.18234886f, -0.10292440f, 0.01844442f, 0.10473250f, 0.00940414f, 0.09116312f, 0.11155763f, 
    0.07845324f, 0.01246611f, 0.00767411f, 0.00809907f, 0.06444035f, -0.05992029f, -0.05591065f, 0.00944410f, 
    0.00630324f, -0.13213815f, 0.01819380f, 0.07307925f, 0.25458646f, -0.08490681f, -0.19725913f, 0.03460761f, 
    -0.12438483f, -0.08430732f, 0.10824536f, 0.04450374f, -0.01626237f, 0.00938394f, 0.04359006f, -0.00533237f, 
    -0.08139549f, -0.02911879f, 0.06035242f, 0.04220299f, 0.04424687f, -0.03869068f, 0.19353373f, 0.01203258f, 
    0.09629951f, -0.02523666f, -0.18673933f, 0.20381418f, 0.20938177f, -0.13305898f, -0.02695972f, -0.14427446f, 
    0.02821968f, -0.02918101f, 0.07143876f, -0.12221595f, 0.03664390f, 0.06936231f, 0.01913220f, 0.01802668f, 
    -0.01544958f, -0.12476948f, 0.16363825f, 0.00382839f, 0.05019865f, -0.08331217f, 0.08506929f, 0.03460494f, 
    -0.18644296f, -0.02460131f, 0.10529090f, -0.01344800f, -0.11566393f, -0.14960353f, -0.03651922f, -0.01280758f, 
    0.05675870f, -0.11394452f, -0.07325889f, 0.00920069f, -0.00285310f, 0.13364924f, 0.05800441f, -0.07312357f, 
    -0.04938847f, 0.34310913f, 0.12584510f, 0.11192449f, 0.16734520f, 0.09676065f, 0.11293678f, 0.03350386f, 
    -0.19087884f, -0.13010819f, -0.05462680f, 0.07511558f, -0.09753433f, -0.12484556f, -0.07877799f, 0.13771722f, 
    0.04307426f, -0.00891742f, 0.07974915f, 0.01514763f, -0.22130314f, 0.08147707f, -0.06903001f, -0.06161859f, 
    0.04114952f, 0.20667218f, -0.15467796f, 0.07655159f, 0.07688978f, 0.08806679f, -0.15471907f, 0.00396159f, 
    0.03182416f, -0.00865464f, -0.04565401f, -0.06805194f, 0.00818958f, -0.00388324f, -0.26379845f, -0.05204586f, 
    0.24819775f, -0.25119177f, 0.33989778f, -0.16466905f, 0.17045656f, -0.11065193f, -0.21980794f, -0.08180304f, 
    0.06790431f, 0.07875773f, 0.04638906f, -0.04796634f, -0.08946233f, 0.13891016f, 0.01016186f, 0.10224608f, 
    -0.17100979f, 0.17692986f, -0.03414452f, 0.09493864f, 0.06387247f, -0.25813428f, 0.10433695f, -0.25822499f, 
    -0.03735639f, 0.05265209f, -0.09718817f, -0.19414504f, 0.03531385f, 0.00616450f, -0.00475556f, -0.08365751f, 
    -0.10529771f, -0.01950352f, 0.10659248f, -0.06135235f, -0.08928379f, 0.11098979f, 0.08446801f, 0.21104936f, 
    0.28434345f, 0.06958570f, 0.07635804f, -0.08505721f, -0.14684260f, 0.04028336f, 0.05926605f, -0.06627262f, 
    -0.07399513f, 0.01766946f, 0.01947592f, -0.03691234f, 0.04417936f, -0.16621320f, -0.03467159f, 0.02095514f, 
    -0.05725008f, 0.10687392f, 0.05111122f, 0.00971832f, -0.10490164f, 0.13395445f, 0.12522291f, 0.20658022f, 
    0.21718480f, -0.01556174f, -0.08451708f, 0.12222206f, 0.00969431f, 0.03554729f, -0.17534477f, -0.15552038f, 
    0.15560055f, 0.07502904f, -0.07397631f, -0.00402966f, -0.04263409f, -0.13681513f, 0.04201168f, 0.00243407f, 
    0.03329464f, -0.25554433f, -0.10959671f, -0.11174885f, -0.33726507f, 0.08400820f, 0.09347799f, -0.08660365f, 
    -0.03284962f, -0.08471179f, 0.07583170f, 0.13259463f, -0.06325236f, -0.00050696f, 0.05842045f, 0.11012026f, 
    -0.03164988f, 0.19549137f, 0.15761265f, 0.01540005f, -0.38917047f, 0.13502271f, 0.01535466f, -0.14035563f, 
    0.09078679f, 0.16989456f, 0.10860197f, -0.06420985f, -0.04286025f, 0.00599097f, -0.07174518f, 0.03570842f, 
    -0.02599880f, 0.06421087f, 0.03779320f, -0.00417862f, 0.06341440f, 0.11269975f, -0.02526109f, 0.01696269f, 
    0.03314695f, 0.03222674f, -0.05714945f, 0.04230642f, -0.03534318f, -0.05318408f, 0.00515697f, -0.00927314f, 
    0.03947370f, -0.03433159f, 0.04224014f, -0.04316624f, -0.00257256f, 0.02330044f, -0.00166309f, -0.03441318f, 
    -0.03416243f, -0.04306989f, 0.02905408f, -0.03571357f, -0.00787531f, 0.03398351f, 0.03254120f, 0.04648269f, 
    -0.00218354f, -0.02844905f, -0.00986508f, 0.01055557f, 0.01311325f, 0.03220357f, 0.04759670f, 0.01070850f, 
    -0.00773582f, -0.04837143f, -0.01366797f, 0.03642758f, 0.02139340f, -0.01950866f, -0.02825118f, 0.00384447f, 
    -0.02963079f, -0.03756514f, -0.03468229f, 0.03010521f, -0.06449605f, 0.01884471f, -0.03144830f, 0.00913741f, 
    0.01343955f, -0.02413475f, -0.04391170f, -0.04660521f, -0.02686998f, 0.03336453f, -0.01344356f, -0.01055160f, 
    0.01743720f, 0.00770865f, -0.03052225f, -0.01929171f, 0.03290581f, 0.00500688f, 0.03377379f, -0.01019950f, 
    -0.05067558f, -0.00062978f, -0.02955199f, 0.02938906f, 0.01110535f, -0.00014597f, 0.01065103f, 0.01096023f, 
    0.01900153f, 0.04158485f, -0.03713197f, 0.00265024f, -0.04858931f, -0.03313016f, 0.03660339f, -0.03584223f, 
    -0.02021020f, -0.05578863f, -0.03017159f, 0.00057957f, 0.02145824f, -0.05411142f, -0.02049517f, 0.02119695f, 
    -0.01776066f, -0.04318657f, -0.00284125f, -0.04557109f, -0.04972761f, 0.01668651f, 0.02637962f, 0.02730045f, 
    -0.01874303f, -0.05098429f, 0.03710722f, 0.01340062f, 0.00001841f, 0.04718193f, 0.04264583f, -0.05260011f, 
    0.02070123f, 0.00774531f, 0.02579853f, -0.02778641f, 0.00682933f, -0.04675290f, -0.02400132f, 0.03167253f, 
    -0.01389579f, -0.02865482f, 0.01849691f, -0.01131876f, -0.01055234f, 0.00765910f, 0.03188306f, -0.03651033f, 
    0.00470004f, 0.00040381f, 0.04498284f, 0.04222842f, 0.01367103f, -0.04084972f, -0.05089568f, -0.03982763f, 
    -0.03569147f, -0.02664081f, -0.01304574f, -0.01116445f, 0.00932520f, 0.04504668f, -0.03435989f, -0.03435410f, 
    -0.05876697f, -0.00838504f, -0.03874152f, 0.02954166f, -0.03208726f, -0.01280137f, -0.00948840f, -0.05006263f, 
    -0.00223224f, -0.04366506f, 0.03485848f, 0.04330923f, 0.02277752f, -0.00846128f, 0.03718102f, -0.03869113f, 
    0.02349267f, 0.00475716f, -0.05827929f, -0.02149754f, -0.01113236f, -0.01460519f, -0.03974206f, 0.04761172f, 
    0.02932923f, -0.01814926f, 0.03036567f, 0.03405515f, 0.00351973f, -0.02118017f, 0.02120641f, -0.00647119f, 
    -0.05923486f, -0.01969456f, -0.03095163f, 0.02160002f, -0.04372721f, -0.02479495f, -0.05837796f, -0.00570577f, 
    0.05396839f, -0.05836344f, -0.00565644f, 0.02328984f, -0.02915831f, 0.01940823f, -0.00135455f, -0.01170678f, 
    0.04946927f, 0.00091918f, 0.01232256f, -0.04902817f, -0.00023590f, 0.00951852f, -0.05312789f, -0.06149038f, 
    -0.06013880f, -0.02690760f, -0.03059610f, 0.04157753f, 0.02512203f, -0.03058644f, -0.00698551f, 0.02675671f, 
    0.00045905f, 0.04274323f, -0.02268350f, 0.04162455f, 0.01888808f, 0.04829050f, -0.00957579f, 0.03925400f, 
    0.02235363f, -0.04486974f, 0.00458003f, -0.05601639f, -0.01056529f, 0.03785460f, -0.01408158f, -0.06102571f, 
    0.01749596f, -0.02368717f, -0.01118166f, 0.03127806f, -0.02910018f, 0.00019966f, 0.02156800f, 0.00195782f, 
    -0.03678631f, -0.03378249f, -0.03389075f, -0.05452123f, 0.01003709f, -0.03752235f, -0.02603639f, 0.03447092f, 
    -0.01552374f, 0.04189325f, -0.05718698f, 0.03242468f, 0.04939089f, -0.05693093f, 0.03522342f, -0.03778104f, 
    0.01858307f, 0.00590540f, 0.00690935f, -0.01779127f, 0.04406532f, -0.04625279f, -0.03611990f, 0.03981148f, 
    -0.05863185f, 0.04082205f, -0.03881504f, -0.05636689f, 0.03271066f, 0.02807361f, 0.03639477f, -0.03388269f, 
    -0.01709205f, -0.05365000f, -0.03201887f, 0.03846702f, 0.02276743f, -0.01051182f, -0.03512562f, -0.05702723f, 
    -0.03248373f, -0.01015061f, -0.01427867f, 0.03410810f, -0.00093937f, 0.03565249f, 0.04521069f, -0.05016169f, 
    -0.00409960f, 0.01960111f, 0.00181787f, 0.04852178f, -0.04352197f, -0.04021508f, -0.01555012f, 0.04147042f, 
    0.02426949f, -0.01677617f, -0.02349993f, 0.04746632f, -0.01463206f, 0.00719527f, 0.04621670f, -0.02645252f, 
    -0.00836802f, 0.03331041f, -0.01276597f, 0.03418774f, -0.03109802f, -0.04478417f, -0.03258087f, -0.04379354f, 
    0.01875779f, 0.02926029f, 0.03710386f, 0.01692623f, -0.00732459f, -0.05795576f, -0.01762681f, -0.00489930f, 
    -0.01196510f, -0.06015713f, 0.03374369f, -0.01151453f, 0.00790010f, -0.04906255f, 0.01697766f, -0.03715651f, 
    0.03586848f, -0.04761022f, -0.01294571f, 0.03687732f, -0.05773567f, 0.03946338f, 0.04047280f, -0.01062112f, 
    0.04851585f, -0.01119672f, -0.00358475f, -0.00578309f, -0.00318111f, 0.01566833f, 0.01793433f, -0.00785779f, 
    -0.00638667f, 0.00029327f, -0.03576535f, -0.05485178f, 0.02311407f, -0.04098853f, 0.02985972f, -0.03807346f, 
    0.03773521f, 0.01055698f, 0.01515703f, -0.02038820f, 0.03166704f, -0.05495914f, 0.00784442f, -0.06157404f, 
    -0.00051174f, -0.06334904f, -0.04997510f, -0.06230895f, 0.04282557f, -0.06266488f, 0.03979862f, -0.05875603f, 
    -0.01600938f, 0.00111417f, -0.00728480f, -0.04130452f, -0.05732790f, -0.04991036f, 0.02133092f, -0.01893780f, 
    -0.04754646f, 0.03397953f, -0.03063520f, -0.02951393f, 0.01092743f, 0.01059214f, 0.00206752f, -0.05671581f, 
    -0.05946937f, -0.01936186f, 0.01833716f, -0.05106978f, 0.00000498f, -0.05036140f, 0.03232735f, -0.02231616f, 
    0.04824521f, 0.04224259f, 0.04191279f, 0.00559070f, -0.01201303f, -0.00414703f, -0.05970440f, 0.00888691f, 
    -0.05878402f, 0.01110354f, 0.03311051f, -0.02587354f, -0.01974927f, -0.02509789f, -0.00754275f, 0.04100532f, 
    -0.01095198f, 0.04517240f, 0.04325824f, 0.02385357f, -0.00181612f, 0.03525645f, 0.04212977f, 0.04340336f, 
    -0.00506374f, 0.00968652f, 0.00688487f, -0.05995484f, 0.02044499f, 0.00222314f, -0.00881766f, 0.04164558f, 
    -0.03564458f, -0.05714763f, 0.03977400f, 0.03035040f, 0.00023707f, 0.00920335f, -0.02431864f, 0.02909575f, 
    0.04057466f, 0.04012026f, 0.00725625f, 0.04813642f, -0.00844128f, -0.00384524f, -0.06039978f, 0.01136181f, 
    0.04446838f, 0.00099369f, -0.05191088f, -0.02045596f, -0.00748153f, 0.02851216f, 0.00180634f, 0.01347178f, 
    0.01210168f, 0.03346903f, -0.00254287f, 0.03816328f, 0.02685854f, -0.04257052f, 0.03082562f, -0.02007690f, 
    -0.04753776f, 0.04169017f, 0.04199689f, -0.04463541f, -0.00752418f, -0.01426701f, -0.00135313f, -0.00465500f, 
    -0.00872733f, 0.03811027f, 0.01825484f, 0.02655743f, 0.02274246f, 0.04725756f, 0.00425333f, 0.03537498f, 
    -0.00828627f, -0.03357093f, -0.01797793f, 0.04066308f, 0.04154031f, 0.04814581f, 0.01770154f, -0.01358571f, 
    -0.01858342f, 0.04661625f, -0.02274600f, -0.05500476f, -0.02421910f, 0.01753019f, 0.02829501f, -0.05279363f, 
    0.03972369f, 0.02642145f, -0.01655914f, -0.00053133f, -0.05482705f, -0.01933531f, -0.01537292f, -0.00508838f, 
    -0.04191718f, 0.01541154f, 0.05122078f, -0.02552949f, 0.00520672f, 0.05503250f, 0.00358850f, -0.06073098f, 
    0.04086054f, -0.05208174f, 0.03932561f, 0.01385767f, 0.01861193f, -0.05796295f, -0.01596332f, 0.01101306f, 
    -0.05730243f, 0.01221299f, 0.00108930f, 0.00364293f, 0.03552754f, -0.04282072f, -0.01916519f, 0.01803731f, 
    0.00973309f, 0.00313994f, -0.01605068f, 0.00324255f, 0.00318233f, 0.02963052f, -0.04540938f, -0.02693231f, 
    0.03934625f, -0.01306376f, 0.02985617f, 0.02251456f, -0.01706439f, -0.03819603f, -0.01225881f, 0.04652483f, 
    0.04185385f, -0.03905978f, -0.03902698f, 0.04571719f, -0.02266778f, -0.02034439f, -0.01218347f, 0.03779078f, 
    -0.04972593f, 0.02008542f, -0.04996951f, 0.04684018f, -0.03656346f, -0.06086745f, -0.03491887f, -0.03361742f, 
    -0.04979006f, -0.04544678f, 0.01632695f, -0.00952915f, 0.01063724f, -0.01398804f, 0.01650221f, -0.00259156f, 
    -0.04958990f, 0.00155500f, 0.02497477f, -0.04780902f, -0.01605152f, 0.04224348f, 0.03006542f, 0.00560860f, 
    -0.02222164f, -0.04095197f, -0.01810798f, -0.03271946f, 0.02891870f, 0.01093168f, 0.02623700f, 0.00048742f, 
    -0.02099212f, 0.01400856f, 0.05168195f, -0.02212324f, 0.00400150f, -0.04519203f, -0.01885251f, 0.00669833f, 
    0.02640540f, -0.03373326f, -0.00445859f, 0.00812970f, -0.04220987f, -0.01618327f, -0.02751582f, -0.03407738f, 
    0.03019868f, 0.00821396f, -0.00851419f, 0.01650549f, 0.00438324f, -0.06203616f, -0.04623652f, 0.01730469f, 
    -0.03827244f, -0.01900131f, -0.01274695f, -0.05513137f, -0.04385008f, -0.02407227f, 0.01017414f, -0.03546557f, 
    0.04093777f, 0.02255170f, -0.01201703f, -0.04497963f, -0.00884838f, -0.04297988f, -0.04821438f, 0.00124804f, 
    0.01797919f, -0.00334140f, -0.02350893f, -0.01426941f, 0.03463749f, 0.03656212f, -0.00621237f, -0.03286529f, 
    0.04064428f, -0.03051134f, 0.04790403f, -0.04970937f, -0.04088653f, 0.02001630f, 0.03936904f, -0.06195984f, 
    0.02431507f, -0.01253986f, -0.00700789f, -0.04974408f, -0.00360166f, -0.06390519f, -0.01651204f, 0.01098270f, 
    0.01508299f, -0.04621749f, 0.00530813f, -0.04482412f, 0.04537731f, -0.05023711f, -0.06015339f, -0.04054706f, 
    -0.03253550f, 0.03640076f, -0.04263340f, -0.00229006f, 0.01558542f, -0.00611032f, -0.05347175f, 0.03610037f, 
    0.22424568f, -0.12734440f, -0.24378975f, 0.02069702f, -0.06142888f, 0.08058408f, -0.05926217f, -0.02645651f, 
    0.14759970f, -0.00235948f, -0.04205601f, 0.02611049f, -0.15807280f, 0.01500167f, 0.06478868f, 0.05720345f, 
    -0.01692689f, 0.06912440f, 0.00683318f, 0.00484091f, 0.19424626f, -0.05541554f, 0.23552822f, -0.09235487f, 
    0.00691311f, 0.07977663f, 0.03362554f, 0.09572855f, 0.01730596f, 0.07349652f, -0.01229838f, -0.01227396f, 
    -0.08573478f, -0.00201034f, -0.02697008f, 0.06748760f, 0.17084977f, 0.06367829f, 0.00244201f, 0.01250212f, 
    -0.23484282f, 0.01601893f, -0.08269949f, -0.04442796f, -0.05996063f, 0.12884814f, 0.18787946f, -0.07677601f, 
    -0.06294048f, 0.08431589f, 0.08866819f, -0.00828719f, 0.01046913f, 0.03970082f, -0.10094718f, 0.03436679f, 
    0.07442453f, 0.05525954f, 0.08831004f, 0.01933573f, -0.14365612f, 0.11228124f, -0.05012059f, 0.09108938f, 
    0.08935194f, 0.03307139f, 0.13055478f, 0.03887773f, 0.09311098f, -0.04628075f, -0.00397471f, -0.10290746f, 
    0.07167905f, 0.04929062f, -0.03980556f, 0.08950342f, -0.00583883f, 0.00666902f, -0.05964253f, 0.10966206f, 
    -0.20187581f, -0.08565623f, -0.00801019f, 0.06491920f, -0.17548847f, 0.06426234f, -0.06456769f, 0.04234767f, 
    -0.02623850f, 0.08532201f, -0.02038329f, 0.02413822f, 0.02518661f, 0.01506530f, -0.00573227f, 0.06205532f, 
    0.00346525f, -0.00839231f, 0.02302784f, 0.03070848f, 0.28576857f, -0.10396972f, 0.03870951f, -0.06786952f, 
    0.21928464f, 0.09047333f, -0.01028280f, 0.10265602f, 0.03152760f, -0.02354521f, -0.02425035f, -0.00082523f, 
    0.05295608f, -0.05129070f, 0.07938815f, 0.04979595f, 0.12675536f, 0.03703779f, 0.07224727f, 0.07450258f, 
    -0.04801124f, -0.30300698f, 0.22475775f, -0.28746337f, 0.25199381f, 0.00836217f, -0.00533933f, 0.08807985f, 
    -0.09544852f, 0.01527743f, -0.02675291f, -0.03515608f, 0.02768053f, 0.05420851f, 0.04845583f, 0.01730338f, 
    0.02069902f, 0.01635663f, -0.06194088f, 0.01139546f, -0.01450203f, -0.09684569f, 0.09107234f, 0.00726564f, 
    0.04306664f, 0.13696173f, 0.03590628f, 0.01269018f, -0.02987900f, -0.06538910f, 0.09117959f, 0.05930852f, 
    0.05201941f, 0.01646176f, 0.09739503f, -0.07176966f, 0.08370738f, -0.00946229f, 0.04603206f, 0.09354112f, 
    -0.34351757f, -0.01515906f, 0.33970097f, -0.04189029f, -0.17953137f, 0.12687516f, 0.01047919f, -0.02440096f, 
    -0.03375374f, 0.02646299f, 0.02956104f, 0.06743385f, -0.03014934f, 0.02161460f, -0.09683787f, 0.01751680f, 
    0.02923982f, 0.00630424f, 0.02728500f, -0.00753937f, -0.48500201f, 0.03642770f, -0.09671459f, 0.05862460f, 
    -0.01814939f, -0.08383431f, 0.07224409f, -0.05618362f, -0.04699695f, -0.02782368f, -0.05450434f, -0.17594405f, 
    -0.04365150f, -0.04508271f, 0.03002923f, -0.02045636f, -0.06555767f, -0.00818379f, -0.05868120f, 0.02671196f, 
    -0.04345592f, -0.02600765f, -0.02906209f, 0.00993754f, 0.12029695f, -0.11689743f, -0.04200831f, 0.01530384f, 
    -0.01377565f, 0.03162004f, 0.00792547f, 0.04805145f, 0.05325369f, 0.03089468f, 0.11634388f, -0.07119313f, 
    -0.06596845f, 0.02160878f, -0.00857817f, 0.06208717f, -0.07382520f, -0.02739696f, 0.09770527f, -0.01629737f, 
    0.05767420f, -0.07516106f, -0.07791527f, 0.02404549f, 0.00594606f, -0.05260371f, 0.01249012f, -0.01139036f, 
    -0.00136734f, 0.04358991f, 0.07625959f, -0.12784612f, -0.05439581f, 0.05655808f, -0.00113469f, 0.07960160f, 
    0.24538159f, 0.14085577f, 0.04974799f, -0.11634831f, 0.04123273f, 0.02515024f, 0.06840616f, 0.00499147f, 
    0.00539826f, 0.05818972f, 0.00222340f, -0.01581819f, 0.04174360f, -0.02511164f, -0.10304459f, -0.02173748f, 
    -0.01483198f, -0.00836623f, -0.00466619f, 0.04806005f, 0.15675941f, -0.39470109f, -0.04505613f, 0.05184922f, 
    0.06803421f, -0.06947309f, -0.15807346f, 0.01647194f, -0.03959182f, -0.07622001f, -0.11787504f, -0.02006801f, 
    0.05513589f, 0.03215303f, 0.03357629f, 0.00346049f, 0.05734517f, 0.03585950f, 0.04668626f, 0.08378629f, 
    0.14823724f, 0.26812088f, 0.00270149f, -0.14141354f, -0.05245928f, 0.07028534f, 0.05800462f, 0.08526465f, 
    -0.03467195f, -0.01290870f, 0.07662719f, -0.00726806f, -0.08597659f, -0.12351565f, -0.03324644f, 0.12199470f, 
    -0.03199910f, -0.01407721f, -0.00043267f, 0.11919868f, -0.21024674f, 0.03082582f, -0.01045855f, 0.08046909f, 
    0.23700772f, -0.03308985f, 0.04637833f, -0.06716628f, 0.03278474f, -0.07139029f, -0.11631268f, -0.02604086f, 
    0.06328613f, 0.04186167f, 0.08381732f, 0.01624766f, -0.02591333f, 0.11292680f, 0.01345683f, 0.04829990f, 
    -0.02194460f, -0.00399585f, 0.03978070f, 0.00749377f, 0.01909559f, 0.02762703f, 0.01294839f, -0.05029355f, 
    -0.01966598f, -0.02613883f, 0.03985238f, 0.03432787f, 0.03509081f, -0.04717889f, 0.03868885f, -0.04495272f, 
    0.03069136f, 0.04130973f, -0.02220153f, 0.01954531f, 0.02123599f, -0.02074549f, 0.00002142f, 0.01163071f, 
    -0.06155627f, 0.01868138f, -0.04216743f, -0.01780170f, 0.03239355f, 0.03955149f, 0.01579450f, -0.03346099f, 
    -0.00321752f, 0.02477939f, 0.02189180f, 0.00354824f, 0.02343738f, 0.04400888f, -0.01315350f, 0.04716261f, 
    0.01747765f, -0.04563173f, 0.03123379f, -0.00675632f, 0.01344859f, 0.04577729f, -0.01525042f, 0.02338494f, 
    -0.01324760f, 0.04076355f, -0.00528492f, -0.00353151f, 0.01814130f, -0.05016670f, -0.03465100f, 0.02131352f, 
    0.02871707f, -0.01926771f, -0.03621515f, -0.06370237f, -0.00992717f, -0.03849320f, -0.04727150f, -0.05811713f, 
    0.04036431f, -0.02752835f, -0.01401489f, -0.04576593f, -0.03723634f, -0.04649580f, -0.03056141f, 0.02852269f, 
    0.00109658f, -0.03207453f, -0.04325758f, 0.00176024f, 0.01335263f, -0.05354540f, -0.00714348f, 0.01985129f, 
    -0.01309152f, -0.06011869f, -0.02329107f, -0.01193145f, -0.04052504f, -0.03708654f, 0.03683854f, -0.02568647f, 
    0.02469295f, 0.00093779f, -0.04536137f, 0.00494110f, 0.02642445f, 0.04669745f, -0.06105104f, -0.00694665f, 
    -0.01961140f, -0.00002509f, 0.01263672f, 0.01852196f, -0.03219945f, -0.01120342f, -0.05774250f, 0.02438309f, 
    0.00025012f, -0.02874136f, 0.04025935f, 0.04348075f, -0.01789672f, 0.00508457f, -0.02910592f, 0.02088064f, 
    0.04349949f, -0.05713973f, -0.00328988f, 0.04871365f, -0.04779481f, 0.04210575f, -0.03159934f, -0.00452400f, 
    0.00659336f, -0.04508218f, 0.01829274f, 0.00708259f, 0.01766252f, 0.00229116f, -0.01444248f, -0.03116591f, 
    0.03889751f, 0.01357286f, -0.02539147f, 0.00996921f, 0.01608332f, -0.01830895f, -0.03178411f, -0.00663097f, 
    0.02148556f, -0.00063509f, -0.00449288f, 0.03707978f, -0.04930485f, -0.01530345f, 0.02144635f, 0.03277975f, 
    0.02608799f, -0.06075674f, -0.04835081f, 0.01328221f, 0.00763075f, -0.03636416f, -0.06092806f, 0.01729032f, 
    0.00361830f, -0.03135987f, 0.04464529f, -0.00439001f, -0.02164546f, -0.06076588f, -0.01313590f, -0.05853989f, 
    0.01316706f, -0.05852002f, -0.03510471f, -0.05397746f, -0.04886902f, 0.02568411f, -0.01747796f, -0.03796628f, 
    0.03021757f, -0.05031518f, -0.01738733f, -0.01109518f, 0.03040790f, 0.03085643f, -0.02555249f, 0.03061656f, 
    0.03760066f, -0.01996285f, 0.04298733f, -0.06268172f, -0.03857328f, 0.00821375f, -0.05147629f, -0.00792818f, 
    0.03263538f, -0.05644433f, -0.00481943f, 0.00672779f, -0.00698863f, -0.05683184f, 0.02334668f, 0.04732156f, 
    0.02072951f, 0.03559113f, -0.06219789f, 0.01494163f, -0.05772568f, -0.03964990f, 0.03113608f, -0.04145892f, 
    -0.00307163f, -0.05615009f, -0.02627221f, -0.02366301f, -0.05732307f, 0.01102464f, -0.02112864f, -0.01489615f, 
    -0.00012826f, -0.02099141f, 0.00337435f, -0.03063134f, 0.00816316f, -0.00474067f, -0.02452143f, 0.03066984f, 
    -0.02909822f, 0.03542164f, -0.02279494f, 0.02353551f, -0.05928541f, -0.00267672f, -0.03675848f, 0.00650050f, 
    -0.05778714f, -0.06213143f, -0.02523391f, -0.03825895f, 0.00924884f, -0.06347457f, 0.03182085f, 0.04884348f, 
    0.02578840f, 0.04103176f, -0.03037285f, -0.05611372f, 0.02123584f, -0.04867225f, -0.01625920f, -0.01921124f, 
    0.04752129f, 0.01706915f, -0.02461657f, -0.03288497f, 0.00470103f, 0.01492820f, -0.03608136f, -0.03926778f, 
    -0.03812896f, -0.03787389f, 0.03593775f, -0.06151800f, -0.01380816f, 0.00050421f, -0.02282730f, 0.00904407f, 
    0.01953056f, -0.04781872f, -0.03624223f, -0.03349292f, -0.03181025f, 0.02483439f, -0.04673665f, -0.04113255f, 
    0.02791722f, -0.02720945f, -0.00056529f, -0.01571856f, -0.03316487f, -0.02225669f, 0.00690300f, 0.00119383f, 
    0.02900576f, -0.01258386f, 0.02643210f, 0.02429835f, 0.04078104f, 0.03274278f, 0.02021881f, -0.04135022f, 
    0.01834444f, 0.03747706f, -0.03759878f, 0.02703713f, 0.01758472f, -0.05444813f, 0.03727476f, -0.02789791f, 
    -0.03287354f, -0.04478877f, -0.00277599f, -0.05802736f, -0.02451413f, -0.05013551f, -0.02357682f, -0.05012894f, 
    -0.01867265f, 0.02681586f, 0.00377292f, 0.01799487f, 0.00821889f, -0.01040531f, 0.02346536f, 0.04510074f, 
    0.00812210f, -0.01144501f, -0.02887475f, -0.05632133f, -0.00901320f, -0.00880764f, -0.01974421f, -0.05335769f, 
    0.00986720f, 0.00393002f, -0.03250362f, -0.06204111f, -0.00256521f, -0.03347644f, 0.01941263f, -0.04524039f, 
    -0.07696044f, 0.16493499f, 0.20024547f, 0.04983687f, 0.00776580f, 0.12960275f, 0.01077717f, 0.05836315f, 
    -0.01179056f, -0.02805599f, 0.00210313f, -0.05299161f, -0.00790731f, 0.08118984f, -0.03755093f, 0.05493282f, 
    0.01933253f, -0.05480764f, -0.01266086f, 0.00510381f, -0.08106685f, -0.17878121f, -0.07259100f, 0.04726876f, 
    0.09087971f, -0.01028171f, -0.13237378f, -0.11756646f, -0.10179384f, -0.03889040f, -0.00181645f, 0.11883521f, 
    0.00179621f, 0.07452431f, 0.08488995f, -0.05975920f, -0.10734834f, -0.17325297f, -0.01505877f, -0.00994464f, 
    0.20294921f, 0.25644290f, -0.00203876f, 0.04664447f, -0.21130905f, -0.10057137f, -0.10316812f, 0.01037922f, 
    -0.09018108f, -0.00697954f, -0.08920263f, -0.00878689f, 0.02752018f, -0.04129509f, 0.02470939f, 0.04710162f, 
    -0.01353368f, 0.00065906f, -0.05020846f, -0.05652541f, -0.18963073f, 0.20062463f, 0.09357151f, -0.06071898f, 
    -0.14150663f, 0.00257911f, 0.00421365f, -0.04392959f, -0.07271984f, 0.10073630f, 0.04656303f, -0.02441423f, 
    0.08845932f, 0.06751135f, -0.00015454f, -0.08687889f, -0.03940590f, 0.05742598f, -0.02343608f, -0.02923060f, 
    0.37741804f, -0.16765265f, 0.23403940f, 0.02659580f, 0.21352971f, -0.05266108f, 0.01037864f, 0.00924085f, 
    -0.01953942f, 0.01577369f, -0.04718248f, -0.01439558f, 0.08246063f, 0.03646726f, 0.02809126f, -0.00338661f, 
    -0.01428208f, -0.01896269f, -0.02500453f, -0.06506219f, -0.13899061f, -0.08530459f, -0.06744869f, -0.03334269f, 
    -0.12189974f, 0.00959074f, -0.00080183f, -0.08704767f, -0.02946524f, 0.03735622f, 0.00108065f, 0.02529957f, 
    0.06958836f, 0.12825565f, -0.05018572f, 0.02109872f, -0.00780186f, 0.02213063f, 0.04450437f, 0.12009647f, 
    -0.08351005f, 0.34352800f, -0.14152460f, 0.20318970f, 0.02880125f, 0.01639988f, 0.01389636f, -0.02090452f, 
    0.11723793f, -0.02481370f, 0.04935248f, 0.00902514f, 0.02057134f, 0.00029921f, 0.01137369f, 0.05035362f, 
    0.01428434f, 0.12292777f, 0.12047231f, -0.01017117f, 0.12603173f, 0.07137958f, -0.03916176f, 0.14808294f, 
    0.00198976f, -0.17879637f, -0.03408933f, -0.06927030f, 0.07774569f, -0.01325213f, 0.00513131f, 0.04858872f, 
    0.03607203f, 0.06667178f, -0.02638794f, -0.02027565f, -0.06819892f, 0.03765918f, -0.05172533f, -0.05127503f, 
    0.08405940f, -0.27645105f, 0.11796561f, 0.12901840f, 0.08943005f, -0.17277794f, 0.00618202f, -0.01361484f, 
    0.05353770f, -0.04304499f, 0.02661216f, -0.05996017f, 0.00994476f, -0.11023362f, 0.11220332f, -0.02618818f, 
    -0.03959589f, 0.03604532f, 0.10770097f, 0.08595810f, 0.42068756f, 0.15919083f, 0.08048631f, 0.10816979f, 
    0.04075956f, 0.09513196f, 0.06580383f, 0.10554191f, -0.01310673f, 0.02303643f, 0.09034262f, 0.23730667f, 
    0.00612755f, -0.02596999f, 0.04531812f, 0.05311001f, 0.07380013f, 0.02910869f, -0.05032515f, -0.05115470f, 
    -0.31427917f, 0.02106480f, 0.02991128f, 0.04253575f, 0.06011912f, 0.13042691f, 0.09021598f, -0.04576888f, 
    -0.04718909f, 0.02741173f, -0.02246887f, 0.03099205f, -0.02208455f, 0.02058131f, 0.05248317f, 0.05922268f, 
    0.00416190f, 0.08073101f, 0.03040656f, 0.05033775f, -0.04340512f, -0.01772477f, -0.01725080f, 0.06860121f, 
    0.04539249f, 0.08076356f, 0.12596986f, 0.00949244f, 0.04541932f, 0.03976228f, 0.10444287f, 0.01675485f, 
    0.04382466f, 0.00055796f, 0.04352966f, 0.14409153f, 0.04251010f, -0.03124631f, -0.05123945f, 0.05545684f, 
    -0.34638965f, -0.02155046f, -0.06265341f, 0.06801268f, 0.13602999f, 0.05385838f, -0.07494063f, 0.01975482f, 
    -0.06835666f, -0.08363871f, -0.04558671f, 0.14184734f, -0.03398316f, 0.07953238f, 0.05565432f, -0.06400434f, 
    0.10488625f, 0.01345018f, 0.02125015f, -0.11694226f, -0.29198250f, 0.28325984f, 0.00990527f, 0.02389113f, 
    0.11159107f, 0.07866663f, 0.15772821f, 0.02187802f, 0.01015506f, 0.12343916f, -0.00245118f, -0.04167851f, 
    -0.02888449f, 0.02292666f, 0.00088595f, 0.00153782f, 0.00911897f, 0.04518118f, 0.02970292f, -0.12382337f, 
    -0.21801034f, -0.08809605f, -0.02557366f, 0.17403695f, 0.02157590f, -0.02165779f, -0.07042373f, 0.02732007f, 
    0.02653706f, -0.02868786f, 0.00705914f, -0.02386506f, 0.07144259f, 0.09120419f, 0.08917087f, -0.02568581f, 
    0.06653549f, 0.01438715f, 0.07617451f, 0.01893181f, 0.38310292f, 0.11075674f, 0.07668930f, -0.06432998f, 
    -0.21742108f, 0.04971754f, -0.00114513f, 0.01347661f, -0.04243772f, -0.02785367f, 0.05134130f, 0.01107608f, 
    -0.02602803f, 0.01174031f, -0.13189633f, 0.02533501f, 0.05701441f, 0.05339409f, -0.12521510f, 0.03565667f, 
    -0.11199816f, -0.06987517f, 0.19019735f, 0.15727217f, -0.29978013f, -0.02259549f, 0.05391695f, -0.03587799f, 
    0.08279291f, -0.11919544f, -0.02087496f, 0.03198454f, -0.08083024f, 0.03427513f, 0.02349324f, -0.05035880f, 
    0.06074820f, 0.02332844f, 0.15167348f, 0.04605389f, 0.05801716f, -0.02842536f, 0.08584300f, -0.00031801f, 
    -0.16484773f, -0.08399928f, -0.07159649f, 0.03165239f, 0.02681104f, -0.08338004f, 0.15460116f, -0.03178380f, 
    0.05774750f, -0.01653303f, 0.11744243f, -0.00994355f, -0.04850448f, 0.03144639f, -0.08752287f, 0.07991609f, 
    0.22071226f, 0.04056229f, 0.05322105f, 0.17742868f, 0.16337873f, -0.06508930f, 0.05561140f, -0.10206663f, 
    -0.01803299f, 0.07592610f, -0.00402477f, -0.19856878f, 0.00890786f, -0.03846706f, 0.00664784f, 0.09005818f, 
    0.02590491f, 0.03837597f, -0.12025522f, 0.06830668f, -0.32351938f, -0.13433866f, 0.03468549f, 0.04615872f, 
    0.04460213f, 0.15551423f, 0.00510476f, 0.07854769f, -0.01621656f, 0.01869937f, 0.10859145f, 0.13144761f, 
    -0.02178225f, -0.02517447f, -0.00886657f, -0.08423930f, 0.02871920f, -0.00024455f, 0.06140471f, 0.04809359f, 
    0.07239748f, -0.03853390f, 0.16734336f, 0.11566789f, -0.05143637f, -0.04851247f, 0.03539761f, 0.02581719f, 
    0.06484181f, -0.02649742f, 0.07628411f, 0.04330170f, 0.00422365f, 0.10605120f, 0.07172002f, 0.06171261f, 
    -0.04308508f, 0.10552813f, 0.12646988f, -0.13207442f, 0.08971698f, 0.17998570f, 0.09802737f, 0.14928387f, 
    -0.01047707f, 0.10483573f, -0.01286626f, -0.04465974f, -0.07860881f, 0.06844199f, -0.04258770f, 0.06411409f, 
    0.09010015f, -0.00267733f, 0.03754321f, 0.02253004f, -0.04621242f, 0.08720091f, -0.02659351f, 0.00993606f, 
    -0.38774636f, 0.00185289f, -0.19343705f, -0.14439088f, -0.09055980f, 0.13404061f, 0.01546217f, 0.13959403f, 
    0.01296018f, 0.02214333f, -0.08371726f, -0.02721098f, -0.03817820f, -0.11956192f, -0.05305316f, 0.08041411f, 
    0.10934740f, 0.03164875f, 0.01747770f, -0.04166599f, -0.12778930f, 0.04964240f, -0.05730211f, 0.05965841f, 
    0.18274833f, 0.03706124f, 0.01500332f, -0.00036366f, 0.03609772f, 0.06763773f, 0.04890917f, 0.05802033f, 
    -0.01733166f, 0.22802527f, 0.16112247f, 0.07448114f, -0.04050024f, -0.04056825f, -0.01158724f, 0.10586984f, 
    0.12713206f, 0.03726741f, 0.05226238f, 0.30219638f, 0.17208616f, -0.05191725f, 0.11474554f, -0.00667101f, 
    0.04641397f, 0.03139445f, -0.04246385f, -0.10514347f, 0.12240902f, 0.06381808f, 0.19225876f, -0.05668198f, 
    -0.01523380f, 0.09899480f, 0.11909717f, -0.03847530f, 0.14478067f, 0.03866782f, 0.05984598f, 0.07235189f, 
    0.00867116f, -0.13408472f, 0.05725037f, -0.05576356f, -0.01180826f, -0.00222070f, 0.12486801f, 0.08682504f, 
    0.02704011f, 0.09161760f, 0.13910344f, 0.19774972f, -0.02465731f, 0.02088486f, 0.04711853f, 0.05801916f, 
    -0.43034062f, 0.09550945f, -0.36281091f, -0.15087698f, 0.06951382f, 0.09475391f, 0.12266711f, 0.01626848f, 
    -0.00284541f, -0.03033486f, -0.02355456f, 0.05812111f, 0.08714217f, -0.10120977f, 0.11548871f, 0.05207422f, 
    0.12087601f, -0.04739251f, 0.00635729f, 0.16272493f, -0.21628603f, -0.05134606f, -0.20233658f, 0.04261296f, 
    0.13606447f, 0.02258018f, 0.16027364f, 0.02290312f, 0.01042186f, 0.08229590f, 0.07428848f, 0.08624218f, 
    0.11738753f, 0.01653406f, 0.06021843f, 0.08132169f, 0.08455054f, 0.00452747f, -0.01923131f, -0.04336467f, 
    -0.33871651f, 0.05504990f, -0.07644621f, 0.12864251f, 0.00572357f, 0.14013673f, -0.08987287f, -0.07337128f, 
    -0.00693953f, -0.05627380f, -0.00722299f, -0.00774449f, 0.07094866f, 0.08821952f, 0.09322286f, -0.03014443f, 
    -0.02140382f, -0.04201542f, -0.03431807f, -0.01342979f, -0.29541606f, 0.01748378f, -0.26541549f, -0.21353294f, 
    -0.27638113f, 0.15492065f, 0.04136371f, 0.13682760f, -0.03307810f, -0.04669758f, 0.13411696f, 0.06785589f, 
    -0.04548224f, 0.02291430f, -0.01337274f, 0.03086074f, -0.04508022f, 0.05372655f, 0.08166263f, -0.12951173f, 
    -0.06973224f, 0.23534563f, 0.10555735f, 0.21843052f, 0.31213021f, 0.07963348f, -0.12072130f, 0.01118755f, 
    0.00667656f, 0.14415827f, -0.01938831f, 0.02970307f, 0.08338796f, 0.00960040f, 0.15597534f, -0.10538302f, 
    0.01901010f, 0.15282838f, 0.02076658f, -0.03577483f, 0.19616202f, -0.02669402f, 0.04180919f, 0.24270520f, 
    0.17097951f, -0.07692930f, -0.09841770f, -0.02848487f, 0.04199120f, -0.09734017f, 0.10343360f, 0.01404068f, 
    0.01654917f, 0.09761104f, 0.03091899f, -0.00141101f, -0.07288082f, 0.04242722f, 0.02721366f, -0.02088832f, 
    0.14979714f, 0.14992771f, 0.23326109f, -0.01642392f, 0.19664989f, -0.00657409f, -0.02608040f, 0.06930312f, 
    0.00948020f, -0.03611034f, -0.00217187f, 0.00136703f, -0.00404975f, -0.01008426f, -0.00390152f, -0.08862136f, 
    -0.00568184f, 0.03879735f, -0.01531296f, -0.04210356f, -0.17887285f, -0.12076732f, -0.01456660f, 0.15911444f, 
    0.03586156f, -0.04814604f, -0.13536195f, -0.07356901f, -0.04148324f, 0.05008021f, 0.04928058f, 0.00576466f, 
    0.03328040f, 0.00175150f, -0.04542878f, -0.08300765f, -0.12523374f, -0.14208245f, 0.14933069f, -0.03584072f, 
    0.29891714f, -0.03520312f, 0.00107087f, 0.00513414f, -0.14673163f, -0.12595910f, -0.05091959f, -0.03949581f, 
    0.11549328f, -0.02304505f, -0.01316779f, 0.04619107f, -0.01524491f, 0.04430326f, 0.04171143f, -0.08878855f, 
    -0.03693810f, 0.05041571f, 0.02446595f, -0.04822054f, -0.05171049f, 0.10854045f, 0.03135666f, -0.06696858f, 
    0.03946656f, -0.10068356f, -0.06291117f, -0.03896748f, -0.06620436f, 0.05936996f, -0.01636981f, -0.03695818f, 
    0.06821373f, 0.03808245f, 0.04041046f, 0.06777303f, -0.09349254f, -0.04744749f, -0.01761320f, -0.05836825f, 
    0.17661072f, -0.11527798f, 0.14521876f, 0.09645106f, 0.23745097f, -0.09829923f, -0.02355285f, 0.10628137f, 
    -0.04701198f, 0.01225478f, -0.00973738f, -0.01555731f, 0.11165784f, 0.04324014f, 0.00864995f, -0.06516040f, 
    0.01561069f, -0.04502751f, -0.02777293f, -0.05052908f, 0.08851951f, -0.09479080f, 0.02038017f, 0.01917149f, 
    -0.19012165f, 0.03904331f, 0.01337631f, 0.06920038f, 0.02173355f, -0.03343327f, 0.00443543f, -0.03939225f, 
    -0.07916969f, -0.01892612f, 0.00310276f, -0.06584140f, 0.07916290f, 0.06306245f, 0.03423025f, 0.10455392f, 
    0.14516959f, 0.18395394f, -0.14844033f, 0.14052749f, -0.02821660f, 0.00370146f, -0.04199052f, -0.00454348f, 
    0.09377924f, 0.03612254f, 0.04298905f, -0.03967886f, -0.04782209f, 0.01230480f, 0.01474804f, 0.06656864f, 
    -0.00895413f, 0.05118800f, 0.04008050f, -0.04537012f, -0.00763839f, -0.04207065f, -0.02592036f, 0.10221735f, 
    -0.00983514f, -0.12055456f, 0.05036471f, 0.02034887f, -0.04574790f, 0.07040906f, 0.04266768f, -0.00117519f, 
    0.01566654f, -0.11145972f, -0.01437722f, 0.02454248f, -0.01488764f, 0.00239853f, 0.07336347f, -0.06200078f, 
    -0.05007054f, -0.04290333f, 0.08371516f, -0.02226453f, 0.02338380f, -0.17471974f, -0.01370626f, 0.01415274f, 
    -0.07435738f, -0.06678808f, 0.01158688f, 0.06411270f, -0.03864293f, -0.09266523f, -0.04669346f, 0.02443007f, 
    0.00322169f, 0.03879872f, 0.06513990f, 0.03386199f, 0.19448997f, 0.10699636f, -0.02718855f, 0.16179870f, 
    0.15712275f, -0.00564659f, -0.04577081f, -0.06728034f, 0.02509516f, -0.03393263f, -0.03631842f, 0.10675099f, 
    0.00615968f, -0.03076969f, -0.10546080f, 0.04426499f, 0.10889586f, 0.00596280f, -0.10421313f, -0.05574109f, 
    -0.12063009f, -0.02145519f, -0.05799660f, 0.02027173f, -0.05155338f, 0.06819721f, -0.00356306f, 0.02331653f, 
    -0.04659992f, 0.06379034f, -0.07202990f, 0.02418456f, 0.00636155f, 0.04568665f, 0.00136199f, -0.00887141f, 
    0.00358648f, 0.09031067f, 0.05317391f, -0.09471935f, 0.06415462f, -0.03366802f, -0.11392736f, 0.08614068f, 
    0.06010936f, 0.05904016f, 0.13654584f, 0.07128371f, 0.07002298f, 0.03163426f, -0.00150489f, -0.03587485f, 
    0.04750655f, -0.08325430f, 0.05428948f, 0.08424759f, -0.02148016f, 0.05039079f, -0.07453295f, -0.03959264f, 
    -0.13560584f, -0.03765398f, -0.09201221f, 0.08228487f, -0.00392907f, 0.05608212f, 0.00595132f, 0.03053189f, 
    -0.02185438f, 0.01629280f, -0.05909399f, 0.06531167f, -0.12460476f, -0.06184569f, 0.00266341f, -0.11091492f, 
    0.00653037f, -0.03890793f, 0.11273283f, -0.00697448f, -0.21524143f, 0.02853072f, 0.08920044f, -0.07134943f, 
    -0.09407919f, 0.02383736f, 0.13579914f, 0.02306940f, 0.07074784f, 0.11464166f, 0.01894338f, 0.04400682f, 
    0.07758102f, 0.00901963f, 0.04250251f, 0.00308852f, 0.08256234f, 0.01693914f, -0.05160308f, -0.01062045f, 
    -0.08231635f, -0.16395539f, 0.12277657f, 0.09805263f, -0.05917546f, 0.01113675f, 0.12401708f, 0.07760692f, 
    0.00258023f, -0.04760989f, 0.02136083f, -0.05957354f, 0.04020758f, 0.01148878f, 0.03730891f, 0.09465258f, 
    0.09570602f, 0.10338432f, 0.02731485f, 0.01836973f, 0.50834149f, -0.03715868f, 0.04083499f, -0.09186588f, 
    -0.21098517f, 0.09173388f, 0.07136955f, 0.00604663f, 0.00342614f, -0.02393314f, -0.07118724f, 0.05081197f, 
    0.02530040f, 0.02083801f, -0.10830612f, 0.11518020f, 0.05093954f, 0.14265998f, -0.02870954f, 0.12922780f, 
    -0.01263136f, 0.03539830f, -0.05109541f, -0.00840133f, 0.00490303f, -0.05477674f, -0.00384887f, -0.04269001f, 
    -0.04409930f, -0.04127040f, -0.04956538f, -0.05156635f, 0.00715399f, 0.04029113f, -0.03822329f, -0.02971696f, 
    -0.03776583f, -0.01178354f, 0.01567767f, -0.04021816f, -0.01523360f, -0.00492267f, 0.04383837f, -0.04432189f, 
    -0.01894916f, -0.00220071f, 0.01844179f, 0.01238640f, 0.04483382f, 0.01777038f, -0.02222146f, -0.05906089f, 
    0.04095624f, 0.02457210f, -0.01442576f, -0.04950476f, 0.00915752f, 0.04040981f, 0.02035499f, -0.01993022f, 
    -0.03511992f, 0.02566944f, -0.01306100f, -0.05964405f, 0.00889310f, 0.04620342f, -0.04460818f, -0.05330296f, 
    -0.05438531f, -0.04772812f, -0.03594008f, 0.03052984f, -0.05822231f, -0.03539822f, -0.00636546f, -0.03522649f, 
    0.05077578f, 0.00562656f, -0.05738466f, -0.03234367f, -0.05474624f, 0.03609684f, -0.03581654f, 0.04604959f, 
    0.03562452f, 0.00005780f, -0.01576067f, 0.01293631f, 0.03518082f, 0.00057744f, -0.02296846f, 0.01132208f, 
    0.01821853f, -0.03083869f, -0.03760860f, 0.04702656f, 0.00709149f, -0.00407221f, 0.03338727f, 0.00731681f, 
    -0.00176584f, -0.00857134f, 0.03329369f, 0.03412092f, 0.02636951f, 0.00485734f, -0.02857991f, 0.02019022f, 
    0.03852636f, -0.02544441f, -0.01281372f, -0.05114699f, -0.02761057f, 0.01479006f, -0.00004558f, -0.01753281f, 
    -0.01464249f, 0.04055943f, -0.05938027f, 0.01042926f, -0.03736213f, 0.04045046f, -0.00227441f, 0.03150948f, 
    0.01889386f, -0.03927283f, 0.01130578f, -0.03276606f, -0.02251316f, -0.02840459f, -0.05204275f, -0.05880400f, 
    -0.03350931f, 0.04623824f, -0.03824116f, 0.04597666f, 0.00814940f, -0.00620530f, -0.01434664f, 0.03169772f, 
    -0.04657480f, 0.03245026f, 0.00440070f, -0.04765679f, -0.05763353f, -0.02792197f, 0.01335805f, -0.04714235f, 
    0.04649576f, 0.05060617f, -0.01512229f, -0.05523301f, 0.02563570f, 0.04793812f, -0.02038616f, -0.00093322f, 
    -0.04319244f, -0.01963853f, 0.00067423f, -0.02049405f, -0.05270546f, 0.01917106f, 0.00433379f, -0.03975121f, 
    -0.02520688f, -0.04758463f, 0.01773001f, -0.00406834f, -0.03911195f, 0.04827450f, -0.00281749f, -0.03860090f, 
    -0.00668756f, -0.01782909f, -0.01486226f, 0.01794107f, 0.03139076f, -0.05845835f, 0.00217592f, -0.00370694f, 
    -0.00932989f, 0.00297045f, 0.04132141f, 0.04740329f, 0.02635785f, 0.02341503f, 0.00535298f, -0.01214893f, 
    0.00296377f, -0.04551509f, -0.00153067f, 0.03463601f, 0.04957376f, -0.04652819f, -0.00845564f, 0.04603161f, 
    -0.00458229f, 0.02036525f, -0.05529415f, -0.00278957f, -0.05679049f, -0.00114223f, 0.01254364f, -0.05354486f, 
    0.04576900f, -0.03499929f, 0.00834379f, -0.02635910f, -0.02785208f, 0.02486528f, -0.06075022f, 0.04271566f, 
    0.00521080f, 0.02317261f, -0.01770806f, 0.04960068f, 0.00102234f, -0.00188016f, -0.06013483f, 0.01973822f, 
    -0.04001830f, -0.05832226f, 0.03022761f, -0.05405097f, -0.04629097f, -0.00232336f, -0.00929105f, 0.03210974f, 
    -0.02826171f, 0.01280883f, -0.05291341f, 0.04403456f, 0.04877492f, 0.02350767f, 0.00144729f, -0.05591931f, 
    0.00009482f, -0.02571928f, 0.04309240f, 0.00468290f, 0.00010800f, 0.01348097f, -0.04665956f, -0.05394470f, 
    0.04092398f, -0.02044409f, -0.03912024f, 0.03944446f, 0.03315517f, 0.04189295f, 0.02267630f, 0.02746831f, 
    -0.03441570f, -0.03593891f, -0.02993724f, -0.01528560f, 0.03211972f, -0.05723416f, 0.01086391f, -0.02726579f, 
    0.01972473f, 0.00765065f, -0.05566703f, 0.01882766f, 0.03968704f, -0.04665062f, -0.01791526f, -0.04090181f, 
    -0.02436570f, 0.03577181f, -0.03439654f, -0.03323221f, -0.03537516f, -0.00082390f, -0.00659548f, -0.02568358f, 
    0.03258942f, -0.01898261f, 0.02902118f, -0.00888855f, -0.02217730f, 0.02685642f, -0.01773411f, -0.02326165f, 
    -0.03900585f, 0.02900037f, 0.00682367f, -0.00492757f, -0.00976541f, -0.04267436f, 0.01919715f, -0.00173133f, 
    -0.01659324f, 0.02088444f, -0.00045384f, -0.04765445f, -0.00009842f, 0.03707322f, 0.04657514f, 0.03032469f, 
    -0.02217744f, -0.00703828f, 0.05354849f, 0.04684726f, 0.03342516f, 0.03973243f, -0.02792725f, 0.00439819f, 
    0.02519438f, -0.03391549f, 0.03475089f, -0.03463206f, 0.03904328f, -0.00849297f, -0.02775001f, 0.01315731f, 
    -0.00941439f, -0.03231655f, -0.00643983f, 0.00838020f, 0.05241580f, 0.01553049f, 0.04414896f, -0.00248808f, 
    -0.04661205f, -0.01175700f, 0.01122636f, -0.03427919f, 0.02791211f, 0.00655461f, 0.03234960f, -0.00624415f, 
    -0.02490884f, -0.03909919f, -0.03063487f, 0.02641737f, -0.05128805f, 0.03289643f, 0.02994205f, -0.02239385f, 
    0.51744443f, 0.02417488f, 0.03696441f, 0.17460024f, 0.30664328f, -0.03618943f, 0.04629882f, -0.00456142f, 
    -0.09529127f, 0.03203335f, 0.00912934f, -0.03314360f, -0.00998649f, -0.01485619f, 0.00642134f, 0.05143464f, 
    -0.07532531f, -0.05115021f, 0.00397030f, -0.00571666f, 0.10038964f, -0.07903131f, 0.16040891f, -0.11203171f, 
    -0.15894696f, 0.06374012f, 0.05775743f, -0.02840576f, -0.08075391f, -0.05121861f, 0.02102963f, -0.07950940f, 
    0.00537482f, -0.00863512f, -0.05347987f, -0.02146318f, -0.05541975f, 0.02326790f, 0.03907066f, -0.09598857f, 
    0.01157936f, 0.03258736f, -0.17415258f, -0.08186563f, -0.04647001f, 0.01055632f, 0.04383225f, -0.02571046f, 
    0.16170448f, 0.00855820f, 0.01154592f, 0.07592011f, 0.03072753f, 0.01411942f, -0.13727579f, -0.04230968f, 
    -0.06265856f, 0.00996928f, 0.03010019f, 0.00954701f, 0.21377513f, -0.03199241f, -0.19589704f, -0.06332853f, 
    -0.00114227f, 0.05062130f, -0.00128328f, 0.01080388f, 0.02778930f, 0.07693882f, -0.13832417f, 0.01522258f, 
    -0.01351419f, 0.24978445f, 0.00538739f, 0.19414493f, -0.02134977f, -0.07295172f, 0.01917038f, 0.11594619f, 
    0.04696953f, 0.12198620f, -0.04761644f, 0.13602734f, 0.15590201f, 0.07242936f, -0.03867921f, -0.06732348f, 
    -0.00070054f, 0.01214060f, 0.03203033f, 0.02807263f, -0.01720159f, 0.04925921f, -0.05905564f, 0.10539098f, 
    0.03714440f, -0.11738710f, -0.00401356f, -0.11011196f, 0.04370911f, -0.21199197f, 0.12590265f, -0.01563453f, 
    -0.11108194f, 0.04843967f, -0.05475561f, 0.07657387f, -0.04116198f, 0.02168056f, -0.01760818f, 0.07650100f, 
    0.03449228f, 0.04570713f, 0.01962505f, -0.00533012f, 0.02764267f, -0.04934428f, 0.00112929f, -0.07579037f, 
    0.17524524f, -0.04788936f, 0.29940721f, -0.15508328f, -0.00261935f, 0.03108068f, -0.00059221f, 0.01289732f, 
    -0.10476248f, 0.07843398f, 0.04170376f, -0.11723079f, -0.02574705f, 0.05638165f, 0.06333406f, 0.04408403f, 
    -0.05636202f, -0.01056957f, 0.00605251f, 0.09842188f, -0.27857172f, 0.01315832f, 0.08313558f, 0.01001441f, 
    -0.03137835f, -0.01788991f, 0.10703998f, 0.06141672f, -0.06266981f, 0.07883608f, 0.03893846f, -0.08503284f, 
    0.11989942f, -0.02678517f, -0.03839148f, -0.00325246f, 0.07564300f, -0.10460479f, 0.12088997f, 0.10720591f, 
    0.20583041f, 0.27092144f, -0.01085544f, -0.10391183f, -0.08024243f, 0.20862380f, 0.05169573f, -0.05316863f, 
    -0.02674459f, -0.18857616f, 0.02628101f, -0.02965593f, -0.05695684f, -0.08467055f, -0.13272263f, 0.02803909f, 
    0.10531972f, 0.02224352f, -0.00136663f, -0.09533092f, 0.11745670f, 0.30468673f, -0.05581906f, 0.27291417f, 
    0.25159562f, -0.09000736f, -0.03338221f, -0.11873908f, 0.00679780f, -0.04982350f, -0.12296817f, -0.02751089f, 
    -0.08276480f, 0.01015135f, -0.00470081f, -0.05179414f, -0.05642726f, -0.01622655f, -0.01117163f, -0.05767661f, 
    0.19260511f, -0.26109615f, -0.01743164f, -0.07257549f, 0.05093126f, -0.02559073f, 0.05923587f, -0.15499906f, 
    -0.02064967f, 0.08230668f, 0.06386352f, 0.06099706f, -0.04260325f, 0.07773098f, 0.13257909f, 0.05983993f, 
    0.03143472f, -0.07832577f, 0.04457466f, -0.00828501f, -0.10270726f, 0.00808245f, 0.16269489f, -0.01295763f, 
    0.00884527f, 0.04498407f, 0.01822786f, -0.00323563f, 0.00442707f, -0.11279046f, -0.04867242f, 0.00441962f, 
    0.02848745f, 0.07824287f, -0.02682897f, -0.10713016f, 0.04289901f, 0.02253317f, 0.01174565f, 0.06794808f, 
    0.28640789f, -0.21097831f, 0.08152131f, -0.06601658f, -0.00501931f, -0.09216360f, 0.14524610f, 0.11145983f, 
    -0.07801118f, 0.09219499f, -0.01047332f, -0.13628009f, 0.01850060f, -0.02776174f, -0.07087722f, -0.08259176f, 
    -0.09830827f, -0.02661682f, 0.02711182f, 0.00854278f, 0.18692914f, -0.36630565f, -0.00318006f, -0.01533017f, 
    -0.05372823f, -0.05347741f, -0.06172067f, -0.03168253f, -0.00057060f, 0.06047181f, 0.04769158f, -0.02230740f, 
    0.03430354f, 0.05602227f, 0.02334187f, 0.18390146f, -0.08361892f, -0.08296163f, -0.01384574f, 0.12712625f, 
    -0.13858074f, 0.05838904f, 0.14526376f, -0.43358847f, -0.00851399f, -0.06564441f, 0.10613734f, -0.00229409f, 
    -0.06587403f, -0.08733466f, -0.07805005f, -0.09632371f, -0.01635610f, 0.05403213f, -0.07619306f, 0.05956624f, 
    0.11066607f, 0.13849935f, -0.01170446f, 0.09074780f, 0.35948402f, -0.03973063f, 0.00767810f, -0.00679441f, 
    0.20850165f, -0.13475269f, 0.07304771f, -0.00012811f, 0.06615957f, 0.01227226f, 0.00508213f, -0.05086322f, 
    0.13836016f, -0.00902294f, -0.05616714f, 0.09424052f, 0.04484716f, 0.03174461f, 0.08069091f, 0.08217165f, 
    0.07813732f, -0.07851689f, 0.06251790f, -0.05430291f, 0.04707458f, 0.10777044f, -0.03680361f, -0.02577580f, 
    0.08976688f, -0.13254791f, 0.03507365f, -0.05695467f, -0.09922669f, 0.03599928f, -0.03748682f, -0.05441931f, 
    0.07177629f, -0.06237259f, -0.05315027f, -0.04531953f, 0.06680668f, -0.11637758f, 0.03713165f, 0.05693331f, 
    0.00199760f, 0.08240056f, -0.16223966f, -0.05157812f, -0.07115058f, 0.10670391f, 0.06907019f, 0.03129720f, 
    0.08318667f, 0.08296184f, 0.05564695f, 0.10943681f, -0.08069123f, -0.07040394f, 0.08061947f, -0.00285422f, 
    -0.00246441f, -0.02035975f, 0.11282613f, 0.07803699f, -0.11113968f, -0.12857129f, 0.01073562f, 0.01309986f, 
    -0.08255265f, -0.05791096f, -0.04023241f, -0.10728732f, 0.03968802f, 0.03820534f, 0.11434649f, 0.05231909f, 
    0.03053978f, -0.01909757f, -0.00123620f, -0.08246950f, -0.37165624f, 0.21266150f, 0.13494392f, 0.08536990f, 
    -0.04341481f, -0.07564819f, 0.03283298f, -0.03852011f, -0.09637333f, 0.10607716f, 0.01230674f, -0.07711197f, 
    0.13705592f, 0.09465015f, 0.03446661f, 0.01586322f, -0.06630792f, -0.00847246f, -0.01287094f, -0.06937987f, 
    0.24755418f, -0.30156291f, 0.21052136f, 0.19837105f, 0.08745593f, -0.10384986f, -0.01084658f, -0.00342396f, 
    -0.05250274f, 0.07837919f, -0.01188975f, 0.01783707f, 0.01819695f, 0.06045782f, 0.06220091f, 0.01559021f, 
    -0.05072048f, -0.01939398f, -0.02514542f, -0.00574034f, 0.23985612f, -0.12213786f, 0.05941692f, -0.02943924f, 
    -0.02446566f, -0.01359642f, 0.00153437f, 0.02158511f, 0.00972512f, 0.01289344f, -0.04562489f, 0.06417871f, 
    -0.00814195f, 0.07752451f, -0.01909124f, 0.04208769f, 0.09172194f, 0.09426442f, 0.06981388f, 0.15064192f, 
    -0.02513207f, 0.09287573f, -0.15449524f, 0.09674195f, 0.10552916f, 0.08954912f, 0.05587097f, 0.07717662f, 
    0.15360489f, -0.01134630f, -0.07683539f, -0.03044870f, -0.06733432f, -0.04245539f, -0.01529410f, 0.05286688f, 
    0.00912530f, 0.07608721f, 0.06246112f, -0.00194777f, 0.12008213f, -0.05510984f, 0.01421590f, 0.08683196f, 
    0.02210355f, -0.01940561f, -0.03706962f, 0.00119406f, 0.09133475f, 0.01384075f, 0.09470020f, -0.00936443f, 
    0.02048119f, -0.03448213f, 0.04058569f, -0.07111713f, -0.08173010f, -0.01355155f, 0.02543212f, -0.00388916f, 
    -0.29203600f, -0.25746757f, 0.37402725f, 0.00130097f, -0.04552095f, -0.07546794f, 0.05745707f, -0.08107225f, 
    -0.10225685f, 0.01814059f, -0.00746389f, -0.05047968f, 0.09773523f, -0.05600482f, 0.07118366f, -0.00345845f, 
    -0.04169479f, 0.07849997f, 0.07680590f, 0.02795005f, -0.05896256f, 0.16024905f, -0.07035517f, 0.09895046f, 
    0.03491049f, 0.05785485f, 0.15332392f, -0.02099190f, -0.06680641f, -0.06485870f, 0.03023148f, 0.05133892f, 
    -0.02023157f, 0.02201118f, 0.07688778f, 0.09949567f, 0.01547326f, 0.07054694f, -0.00941302f, 0.01034749f, 
    -0.40896150f, 0.19618921f, -0.10596764f, -0.00437028f, 0.06140840f, 0.12473691f, 0.00519284f, -0.02524222f, 
    -0.00934848f, 0.09650778f, 0.00129755f, 0.02175147f, -0.02370360f, 0.04539415f, 0.04064775f, 0.05575300f, 
    0.00858837f, 0.09504751f, 0.02617783f, 0.07767989f, -0.21804437f, -0.12626584f, -0.10883646f, 0.11445946f, 
    0.03328011f, 0.00864784f, 0.10066320f, 0.05139832f, -0.03712372f, -0.00630216f, 0.00168154f, 0.01677115f, 
    0.04862933f, -0.02146227f, 0.10703864f, 0.03127725f, -0.00652299f, 0.07829217f, 0.02744733f, 0.12360335f, 
    -0.23589624f, 0.04633281f, -0.01156443f, -0.01968675f, 0.02942401f, 0.09076250f, -0.01627396f, -0.01655010f, 
    -0.06555849f, 0.03879070f, 0.05863897f, 0.13863170f, -0.09383980f, 0.01345328f, -0.01833145f, -0.09789731f, 
    0.02807927f, -0.01921458f, 0.08780193f, -0.01334407f, -0.18033309f, 0.08908506f, -0.09841920f, 0.05498032f, 
    -0.01342756f, 0.02341285f, 0.14885418f, -0.00402259f, 0.02324693f, 0.05009859f, -0.10310586f, 0.04855429f, 
    -0.00905307f, 0.04717553f, -0.00164204f, 0.02533762f, 0.04256269f, -0.03880196f, 0.07325847f, -0.04141801f, 
    -0.03810406f, -0.02457944f, 0.04996591f, 0.21919288f, -0.04989959f, -0.07759540f, 0.00667936f, 0.00737760f, 
    0.03306000f, 0.08027707f, 0.03659519f, -0.00587585f, 0.02202476f, -0.00556755f, 0.11626926f, 0.02909674f, 
    0.07473996f, -0.01179150f, 0.00164260f, 0.09400957f, 0.27237615f, 0.08230513f, -0.00253398f, 0.02801635f, 
    -0.22921008f, 0.10319181f, 0.02578391f, -0.03570527f, 0.05195279f, -0.13891378f, -0.07934931f, 0.04744430f, 
    -0.01866673f, 0.03895744f, -0.10719422f, 0.07561035f, 0.06451415f, 0.09042125f, -0.06608517f, -0.03960437f, 
    -0.09235015f, 0.18809372f, 0.01935353f, -0.02213871f, 0.29401180f, -0.00162396f, 0.02712932f, -0.07329372f, 
    0.00686691f, 0.03834644f, 0.09816123f, -0.04705070f, 0.11369409f, -0.08449216f, 0.03412011f, 0.00381778f, 
    0.02863442f, 0.01731698f, 0.00702228f, -0.01044653f, -0.14197825f, -0.12400993f, 0.06157894f, -0.16113834f, 
    -0.01272649f, 0.08692465f, -0.03746691f, -0.10282743f, 0.03601230f, -0.07811088f, 0.01842758f, 0.11820915f, 
    0.06202098f, 0.02649953f, 0.02325946f, 0.06667366f, -0.19409031f, -0.00043133f, -0.00036298f, 0.13045233f, 
    -0.07128431f, -0.29834050f, -0.00541672f, 0.02632073f, -0.10389790f, -0.08933617f, -0.09254391f, -0.03991406f, 
    0.00224002f, -0.12236630f, 0.04942915f, 0.02317184f, -0.01600269f, 0.13437305f, 0.05406401f, -0.06740506f, 
    -0.05362778f, -0.06424015f, -0.11231907f, 0.02478440f, 0.08076347f, -0.10359811f, -0.26370600f, 0.00527618f, 
    -0.09850544f, -0.04614641f, 0.02191938f, -0.03154171f, -0.00500674f, 0.13919184f, -0.03387362f, 0.01385895f, 
    0.06125828f, 0.06444478f, -0.02281979f, -0.03418005f, 0.05073419f, -0.02804958f, 0.04012264f, 0.09781143f, 
    0.12665999f, 0.11142770f, 0.01853796f, 0.12582913f, 0.20034312f, 0.15732139f, -0.00364489f, -0.05317189f, 
    -0.10918758f, 0.06208107f, -0.06146354f, 0.01325432f, 0.04421894f, 0.03560797f, -0.04771345f, 0.07128452f, 
    0.05651555f, 0.08474310f, 0.03807570f, 0.00074392f, -0.28736487f, -0.14682172f, 0.02754710f, -0.12681746f, 
    -0.26661259f, 0.04690614f, -0.04406904f, -0.02665399f, -0.04244672f, 0.04527458f, 0.12500982f, 0.00203459f, 
    -0.04134227f, 0.02245770f, 0.06630262f, 0.11560155f, 0.02118310f, -0.08461360f, -0.04767567f, -0.04087540f, 
    -0.00041940f, -0.05115420f, 0.04332368f, 0.10882785f, -0.02089913f, -0.00021680f, 0.03823650f, -0.05395654f, 
    0.05612775f, 0.14798847f, -0.04491627f, 0.01887015f, -0.03532753f, 0.03374760f, 0.09780168f, 0.01613130f, 
    0.06385175f, 0.14101881f, -0.09551471f, -0.01415105f, -0.14401567f, 0.03466843f, -0.01204113f, 0.07845148f, 
    0.01483056f, 0.03643491f, 0.00216700f, -0.01482448f, 0.07670809f, 0.04098249f, 0.04598657f, 0.09670690f, 
    0.03934683f, 0.13594224f, -0.00201475f, 0.09079073f, 0.06354225f, -0.02739610f, 0.00678536f, 0.11420020f, 
    -0.14693716f, 0.03527350f, 0.17825773f, 0.05517010f, -0.04109411f, 0.06539643f, -0.02324551f, 0.00614093f, 
    0.01403561f, 0.03915652f, 0.07730320f, 0.03422795f, 0.10857808f, 0.03773733f, -0.00608369f, 0.06444544f, 
    0.03995772f, -0.01527237f, -0.04473832f, -0.00385815f, 0.30859116f, 0.23242386f, 0.08432344f, 0.10472880f, 
    0.24371970f, 0.01882976f, 0.02295247f, -0.07250499f, -0.02864779f, -0.04800024f, 0.06382561f, 0.07077856f, 
    -0.02065694f, -0.03029559f, 0.03360938f, -0.03174878f, 0.13960265f, 0.06285403f, 0.09990201f, -0.04337381f, 
    -0.03580155f, -0.06025307f, -0.11844490f, 0.08621093f, -0.25418913f, 0.02209515f, -0.08091057f, -0.04612998f, 
    0.01132144f, 0.08080192f, 0.02889571f, 0.10713495f, -0.08624461f, -0.03170259f, -0.00972875f, 0.06815789f, 
    0.09269016f, 0.00220343f, -0.00330619f, -0.09210604f, -0.07546153f, 0.01160603f, 0.09248871f, 0.04622296f, 
    -0.00617524f, 0.00854913f, -0.02676826f, 0.11741142f, 0.05407089f, -0.09410154f, 0.05101588f, -0.02381613f, 
    0.10536918f, 0.03405948f, -0.01449523f, 0.07725874f, 0.15233770f, -0.05638260f, 0.07244252f, 0.04511721f, 
    -0.09634798f, -0.17873083f, -0.03842171f, 0.03588466f, -0.11449782f, -0.01611673f, 0.05819995f, 0.04017666f, 
    0.07316851f, 0.00878385f, -0.06894779f, 0.08105933f, 0.00273330f, 0.00996193f, 0.09407265f, 0.10884507f, 
    -0.01478870f, 0.02740508f, -0.02707108f, 0.08674888f, 0.08068033f, -0.03640940f, -0.11994312f, 0.05405522f, 
    0.13528614f, -0.09677356f, 0.01268365f, -0.11302230f, 0.11189664f, 0.04143106f, 0.08838890f, -0.04752328f, 
    -0.06503499f, 0.03491959f, 0.09700957f, 0.05271998f, -0.05263817f, 0.05730707f, -0.01035067f, 0.07123515f, 
    -0.19383584f, -0.07524156f, 0.05386793f, -0.01182706f, -0.12561218f, -0.05223168f, 0.08395436f, 0.06294291f, 
    -0.01331308f, -0.02619212f, -0.02137072f, -0.06469269f, 0.08887308f, 0.14973652f, 0.10023634f, -0.03492941f, 
    0.07731625f, -0.10650255f, -0.09015620f, 0.02610812f, 0.19960286f, 0.07341508f, 0.20921062f, 0.01413291f, 
    -0.20633143f, -0.04458899f, 0.03434698f, -0.04148822f, -0.02631224f, 0.02945178f, 0.14692447f, 0.03633968f, 
    0.07780183f, -0.02705381f, 0.02207226f, 0.05565020f, 0.09973891f, -0.07280295f, -0.01024004f, 0.03156172f, 
    -0.23937088f, 0.10544182f, -0.01579406f, 0.22115849f, -0.32183576f, -0.08469494f, -0.02870785f, 0.10543707f, 
    0.05407664f, -0.00959099f, -0.04039781f, 0.06604286f, -0.04919291f, 0.04625705f, 0.00075901f, -0.10585906f, 
    0.01381945f, -0.05763506f, 0.02272918f, 0.03262828f, -0.16767570f, 0.01074194f, 0.04229829f, 0.10367572f, 
    0.14901175f, -0.08472340f, -0.01230270f, 0.09436970f, 0.07805310f, 0.03128121f, 0.03835493f, -0.10357221f, 
    -0.14502674f, -0.09629612f, 0.05850076f, -0.07255054f, 0.09279615f, 0.10440213f, -0.10329015f, -0.06386124f, 
    0.36613113f, 0.02051318f, -0.12531877f, 0.09534430f, 0.22594033f, 0.03700658f, 0.07178181f, -0.13017850f, 
    -0.05042783f, 0.03399831f, -0.02200773f, 0.04953333f, 0.07820629f, 0.00866962f, 0.01234374f, -0.00684426f, 
    0.03330048f, 0.01242288f, 0.01452337f, 0.03412211f, 0.05060496f, -0.16209474f, 0.17128703f, 0.04891313f, 
    0.26210225f, 0.16027869f, 0.01657504f, 0.03792412f, -0.00931444f, -0.07915406f, 0.01447012f, 0.10655541f, 
    -0.03294083f, -0.11762605f, -0.07868827f, 0.06673267f, 0.08847768f, -0.02054713f, 0.02743454f, 0.02846003f, 
    -0.21377113f, 0.14959890f, 0.05918096f, -0.04784140f, -0.11735196f, -0.04445333f, -0.03842470f, 0.16450565f, 
    0.09604440f, 0.03063108f, 0.14874797f, 0.03078617f, -0.06329121f, 0.07031935f, 0.07994542f, 0.01385685f, 
    -0.05040111f, -0.03371093f, 0.04466398f, -0.01850530f, 0.00527326f, 0.22687237f, 0.15686116f, 0.16715312f, 
    0.22900513f, 0.07525565f, 0.01309501f, 0.03194708f, 0.01380948f, 0.10154004f, -0.08119173f, 0.06669355f, 
    0.04562016f, -0.05702874f, 0.07812569f, -0.01221552f, 0.00871627f, 0.11342962f, 0.01477537f, -0.00100821f, 
    -0.40504423f, -0.09181272f, -0.04580827f, -0.27728978f, 0.09213323f, 0.12031440f, -0.02392557f, 0.06432464f, 
    -0.09644628f, -0.08078773f, -0.03149747f, 0.01071970f, 0.06823913f, 0.03011509f, -0.07846927f, 0.02644521f, 
    -0.02227234f, -0.04488832f, 0.06801586f, 0.01337981f, -0.05326681f, 0.24703321f, -0.06392920f, -0.07091721f, 
    0.15725636f, 0.13892758f, 0.00969343f, 0.05958745f, -0.07216819f, -0.01663711f, 0.01640888f, 0.05607050f, 
    -0.05520639f, 0.04051817f, 0.08343023f, -0.01501200f, -0.01495535f, 0.06467288f, -0.02552252f, 0.01593870f, 
    0.09030333f, 0.27663699f, -0.05576450f, 0.39850095f, 0.14291953f, -0.02382986f, -0.02373837f, 0.02721467f, 
    0.09909142f, 0.06081602f, -0.07965867f, 0.04038692f, -0.07542994f, 0.07061934f, -0.01077418f, 0.06770478f, 
    0.01262654f, -0.01450209f, 0.01048625f, 0.02972701f, -0.14242217f, -0.22206347f, 0.01587852f, -0.04255409f, 
    -0.20533009f, -0.14097634f, -0.11380672f, -0.05238553f, -0.03097897f, 0.18326040f, -0.00784587f, -0.09740648f, 
    0.09088579f, 0.04105385f, 0.03416084f, 0.00995614f, 0.02851305f, -0.10546464f, -0.05110486f, 0.03409765f, 
    0.02235235f, 0.07111982f, -0.28694642f, -0.18450475f, 0.12582789f, -0.04680186f, 0.09061033f, -0.03893999f, 
    0.00651846f, -0.12911518f, -0.05462016f, -0.03624451f, 0.12905581f, 0.04024804f, 0.02615719f, 0.02285152f, 
    0.10560212f, 0.03895755f, -0.03023975f, 0.07320938f, 0.17562088f, 0.10154507f, -0.15922424f, -0.30370882f, 
    0.18255532f, -0.04290574f, 0.07286242f, -0.05936135f, -0.00944824f, -0.04361465f, 0.06406271f, 0.04552759f, 
    -0.06013967f, -0.00947670f, 0.04700076f, -0.05725714f, 0.05854785f, -0.06148702f, 0.02803434f, 0.00543416f, 
    -0.12074158f, 0.33455670f, -0.05965189f, -0.00609476f, 0.03077186f, 0.04110095f, -0.05039944f, -0.03341307f, 
    -0.04197273f, -0.05539163f, -0.01067624f, -0.04062267f, 0.10493176f, -0.06153054f, 0.02584827f, 0.08239160f, 
    -0.02483073f, 0.03645652f, -0.07446782f, -0.05373347f, -0.34555385f, -0.19422422f, -0.04118707f, -0.20026377f, 
    -0.04818910f, 0.09100509f, -0.07690414f, 0.17134413f, -0.01740607f, -0.12967563f, 0.06015559f, 0.04927514f, 
    0.02423096f, 0.05037388f, -0.05452338f, -0.06327670f, -0.01369512f, -0.05704483f, 0.00187120f, -0.02927172f, 
    0.12308063f, 0.24032523f, -0.02871854f, 0.09922752f, 0.26045862f, 0.13895692f, -0.08768019f, 0.06123928f, 
    -0.00887218f, -0.00123132f, -0.03012337f, 0.09456045f, 0.04797399f, -0.06345930f, 0.07002994f, 0.04664782f, 
    -0.05092818f, 0.12245240f, 0.08407842f, 0.02370705f, -0.22989000f, 0.08397307f, 0.08115195f, 0.18868484f, 
    0.29724911f, -0.04535979f, -0.01326997f, 0.02878887f, -0.03206969f, -0.02313545f, 0.00497197f, 0.00792714f, 
    0.01681938f, -0.01125846f, 0.10372102f, -0.00956093f, -0.03527887f, 0.06823666f, 0.08685834f, 0.05398434f, 
    -0.19395162f, 0.00966142f, -0.05557790f, -0.17876084f, 0.15317437f, -0.04744450f, -0.01302893f, -0.17762183f, 
    -0.07918444f, 0.09281968f, 0.00811099f, 0.04188729f, 0.16572584f, -0.01947384f, 0.05950923f, -0.01783962f, 
    -0.04630313f, 0.17673707f, 0.08052830f, 0.03939446f, 0.01380775f, 0.05232691f, -0.16387299f, -0.24544586f, 
    0.01953954f, 0.00745493f, 0.12152901f, -0.11337432f, 0.13805348f, -0.00091395f, 0.01176142f, 0.03114502f, 
    0.20138967f, 0.15013210f, 0.03097719f, -0.03030234f, -0.02639211f, 0.19074608f, -0.09003811f, 0.08414056f, 
    -0.40994313f, -0.11958157f, 0.03993367f, 0.03272528f, 0.17150116f, -0.02083690f, 0.18375805f, -0.04683792f, 
    -0.01736818f, 0.03731642f, -0.04591898f, -0.11346401f, 0.11067703f, 0.07666738f, 0.01338703f, 0.07033235f, 
    -0.03247163f, -0.02774885f, 0.01160425f, -0.11295161f, -0.10723743f, 0.02914230f, -0.12663171f, 0.06611092f, 
    0.13687958f, -0.06400684f, 0.01980097f, 0.08462013f, -0.09887258f, 0.07293761f, -0.04440184f, 0.19922428f, 
    0.04321059f, -0.07227554f, -0.01040890f, -0.12442839f, 0.07219420f, 0.02369924f, 0.07795735f, -0.12543276f, 
    -0.18802132f, 0.24660864f, -0.00134895f, -0.12773329f, 0.22750913f, 0.11422385f, -0.06534911f, -0.22808759f, 
    -0.09268373f, -0.05807676f, 0.00728796f, -0.02003994f, 0.04207928f, 0.00755569f, -0.06332864f, -0.02241370f, 
    0.13185206f, 0.10327514f, 0.11223760f, 0.09741987f, -0.04385639f, -0.01984855f, -0.02994323f, 0.03922203f, 
    -0.21642859f, 0.08711049f, 0.07853684f, -0.08709229f, -0.01914649f, 0.07861499f, 0.06709639f, 0.02078395f, 
    -0.00247572f, -0.13146928f, 0.05234392f, 0.01300798f, 0.05992557f, -0.03054015f, -0.08083209f, 0.06924676f, 
    -0.01539076f, 0.10336065f, 0.05819012f, -0.01052084f, -0.11448135f, 0.06354873f, 0.04065364f, 0.00770689f, 
    0.04905929f, -0.00284079f, 0.04533495f, 0.00617363f, 0.00924371f, 0.04161550f, -0.09025112f, -0.00185531f, 
    -0.02054242f, 0.00148642f, -0.10986737f, 0.00445992f, -0.13437980f, 0.06752209f, -0.03217790f, -0.11467194f, 
    -0.06951371f, 0.09286518f, 0.05998501f, 0.05524119f, 0.02231663f, 0.08776166f, -0.06689606f, 0.07628617f, 
    -0.01924827f, 0.06293783f, 0.03755569f, -0.00522124f, 0.11423033f, -0.00943045f, -0.05459699f, -0.02172251f, 
    0.17079882f, 0.25201526f, 0.07560204f, -0.01129903f, 0.15395318f, -0.03464555f, -0.09452519f, -0.18159442f, 
    -0.07533424f, -0.01385545f, -0.02368100f, -0.00298932f, 0.02396335f, 0.11696991f, 0.10211744f, 0.12103414f, 
    0.01364581f, 0.03026615f, -0.07113689f, -0.03974811f, 0.15969914f, -0.02122924f, -0.13225415f, -0.22981551f, 
    0.11183541f, -0.14707242f, -0.03213577f, -0.12511677f, -0.09973598f, -0.09182357f, -0.03514465f, 0.11229634f, 
    0.06466335f, 0.00408435f, -0.00662988f, 0.00179609f, 0.18324651f, 0.02740426f, 0.16850162f, 0.03488658f, 
    0.42329341f, -0.04470234f, 0.11669410f, 0.02162596f, -0.33414134f, -0.12849675f, 0.02586702f, 0.13106468f, 
    0.06660869f, -0.00397771f, -0.02567722f, -0.03304743f, -0.06505889f, -0.07044706f, 0.02318675f, 0.04514230f, 
    0.08151385f, 0.02357871f, -0.01021845f, -0.06541391f, 0.07703701f, -0.13188341f, 0.12504399f, -0.05339926f, 
    -0.18980967f, 0.07714888f, -0.04366712f, 0.12921171f, 0.09254329f, 0.01111955f, 0.01953994f, 0.06044173f, 
    0.00051399f, -0.06524508f, -0.02154287f, 0.08574779f, 0.07021414f, 0.00607938f, 0.00789140f, 0.09037293f, 
    0.03933971f, -0.15135774f, 0.03999693f, -0.06831926f, -0.23983763f, -0.02813353f, 0.10745250f, 0.09374321f, 
    0.10083538f, 0.03872076f, 0.01749954f, 0.08954234f, -0.02510789f, -0.01389638f, -0.05943499f, 0.12313962f, 
    -0.00126072f, 0.02870705f, 0.05275133f, 0.19867700f, 0.02879473f, 0.37231082f, -0.05157987f, -0.07789154f, 
    0.08343934f, -0.11467699f, -0.01364591f, -0.08524940f, 0.01366166f, 0.06595092f, 0.00305609f, -0.08212034f, 
    -0.10809285f, 0.05628172f, -0.12653209f, 0.00227214f, 0.03787322f, 0.00606553f, 0.01922561f, 0.01171112f, 
    -0.00472307f, -0.31803444f, 0.02989053f, 0.03693192f, -0.02985058f, 0.15311131f, 0.09927136f, 0.04296219f, 
    -0.04661286f, 0.01507323f, -0.02214107f, -0.04166191f, 0.01770663f, -0.02815731f, 0.04119416f, 0.09383953f, 
    0.10150112f, -0.23715037f, -0.14042959f, -0.10122886f, -0.09373269f, -0.07016097f, 0.26969552f, 0.05591486f, 
    -0.21951856f, 0.00974174f, -0.12547787f, -0.06045570f, -0.07934725f, 0.04491859f, -0.06119632f, 0.12225494f, 
    0.14750686f, 0.00988698f, 0.08987666f, 0.00910692f, 0.02703802f, 0.07515235f, 0.03268851f, -0.09237906f, 
    0.00330915f, 0.00916152f, -0.01092380f, 0.02629042f, 0.02800049f, 0.04277617f, -0.01020500f, -0.03606351f, 
    0.00241691f, 0.02732824f, -0.00639764f, -0.04070800f, 0.03706689f, 0.02012494f, -0.05216799f, -0.03793351f, 
    -0.04150154f, -0.05031142f, 0.01285734f, 0.01742019f, -0.06467764f, -0.06662960f, -0.03058933f, 0.04788610f, 
    -0.02471151f, -0.00312423f, 0.00278050f, -0.04466145f, -0.03511535f, 0.00643420f, 0.03633511f, -0.05208814f, 
    -0.01079217f, 0.02442363f, -0.03241326f, 0.04079223f, -0.00577787f, 0.02759022f, 0.00851901f, 0.00160411f, 
    0.02952305f, 0.02818986f, -0.04240597f, -0.05332994f, -0.00864631f, -0.03649302f, -0.01475020f, 0.01145401f, 
    0.03549015f, -0.05605208f, -0.03518843f, 0.00984521f, 0.03324088f, -0.00114179f, -0.00430560f, 0.02933023f, 
    -0.03680072f, -0.02637642f, -0.01838322f, 0.02796537f, 0.03667268f, -0.05425866f, -0.04418747f, -0.01120783f, 
    -0.01261116f, 0.04463802f, -0.05922544f, -0.03869285f, -0.01465357f, -0.00602664f, 0.00021170f, -0.02078170f, 
    0.03000620f, -0.00628830f, -0.04588433f, 0.00864929f, 0.00379054f, -0.05062089f, -0.03556371f, -0.03773774f, 
    0.01342655f, -0.05700144f, 0.03633859f, -0.06641851f, -0.03106130f, -0.01057230f, -0.00621419f, 0.00797143f, 
    -0.01173304f, 0.02087733f, -0.05573244f, -0.02524368f, 0.00095931f, 0.00711791f, 0.00021847f, -0.01177571f, 
    -0.04093564f, -0.00328607f, 0.00774258f, 0.02547157f, -0.06093610f, -0.05125628f, 0.02847552f, 0.01915203f, 
    -0.01282047f, -0.04934230f, 0.00651501f, -0.00309463f, -0.02461546f, -0.02917023f, 0.01847716f, -0.05758589f, 
    0.02270625f, -0.00465956f, 0.00561847f, 0.00844357f, -0.03435265f, 0.00231640f, 0.04160396f, -0.05133332f, 
    0.03917820f, -0.01755845f, -0.01251327f, 0.00218361f, 0.01287473f, 0.02873942f, -0.03247636f, -0.05748983f, 
    -0.00040907f, 0.02750905f, -0.06159269f, -0.01132182f, 0.04591049f, -0.06598317f, -0.04480611f, 0.00010349f, 
    0.04365998f, 0.01617564f, 0.02322556f, 0.00642567f, 0.00543587f, 0.01167048f, 0.01513474f, 0.01241618f, 
    0.04748370f, -0.03319944f, 0.04384870f, 0.03238953f, -0.00088129f, -0.03974484f, -0.03064014f, -0.02967551f, 
    0.03349693f, -0.02419743f, -0.01636573f, -0.02753247f, 0.02987355f, 0.03792863f, 0.02432594f, -0.00872067f, 
    0.01424618f, 0.02805385f, -0.04613196f, 0.04659713f, 0.04715550f, 0.02411226f, -0.05325068f, -0.04408884f, 
    -0.01778011f, 0.03033255f, 0.03556819f, 0.01008197f, 0.00841209f, -0.00045429f, -0.03573089f, -0.02145828f, 
    -0.00327202f, 0.02189376f, 0.02736307f, -0.02917267f, -0.04969752f, -0.05557331f, -0.05757302f, 0.01683909f, 
    -0.00116342f, -0.00464332f, -0.05816663f, 0.03508195f, 0.02746749f, -0.04462169f, 0.01169544f, -0.00791020f, 
    0.03290189f, 0.04132375f, -0.02771110f, 0.02514913f, -0.01104572f, -0.00146409f, -0.04527919f, -0.04184644f, 
    0.04710051f, 0.01234596f, -0.04151909f, 0.04072865f, -0.02676325f, -0.05148591f, -0.05842075f, 0.00750516f, 
    -0.05616497f, -0.01294527f, 0.00614098f, -0.04152800f, -0.01403278f, -0.01910783f, -0.01645555f, 0.02561058f, 
    -0.00077495f, 0.03425139f, 0.00237769f, 0.00188487f, 0.05757011f, -0.04512596f, -0.01092064f, 0.05136736f, 
    0.04293140f, -0.05910579f, 0.02543704f, -0.05613818f, 0.02202426f, -0.05560456f, 0.03108484f, -0.01171931f, 
    -0.05879327f, 0.04225158f, -0.00426009f, -0.05075271f, 0.00145977f, 0.03443721f, -0.06636969f, -0.00300882f, 
    0.04830841f, 0.02692596f, 0.05466152f, -0.04875260f, -0.03085435f, -0.05673072f, 0.01393130f, 0.01908887f, 
    -0.00517270f, -0.04454486f, -0.06239378f, 0.03066876f, -0.02667469f, -0.01528949f, 0.03478301f, -0.00300927f, 
    0.04354273f, 0.00973925f, -0.01897573f, -0.03595600f, -0.05481274f, -0.03013658f, -0.02139712f, -0.03966591f, 
    0.01032231f, 0.00693513f, -0.04768904f, 0.00546615f, 0.00038788f, -0.00404464f, -0.00770391f, 0.01092144f, 
    0.00207733f, 0.00309573f, 0.02051641f, 0.03062380f, -0.05878190f, 0.03827958f, 0.03681620f, 0.04534854f, 
    0.00088368f, -0.03901657f, -0.00705379f, 0.05973211f, -0.01268039f, -0.01088911f, 0.04763249f, -0.04679181f, 
    -0.05439429f, 0.03861756f, 0.00802754f, -0.03307644f, -0.00070326f, -0.03963468f, -0.05511853f, 0.02586409f, 
    -0.01471299f, -0.01686612f, 0.02549129f, -0.03682314f, -0.01004415f, -0.02143583f, -0.00216873f, 0.00967618f, 
    -0.00595445f, -0.01742292f, 0.01335779f, -0.05080746f, 0.02398087f, 0.02048660f, 0.03389621f, -0.04486219f, 
    -0.01712997f, -0.01269436f, -0.02426156f, 0.00424247f, -0.03581912f, -0.02801929f, 0.01029959f, 0.04207382f, 
    0.35662752f, 0.23085703f, -0.11024331f, -0.00460430f, 0.09385645f, 0.02822578f, -0.07198527f, -0.05344675f, 
    0.01888294f, -0.06098145f, 0.01616905f, -0.00150796f, -0.00873398f, 0.05456602f, 0.00534874f, -0.00990541f, 
    0.03094560f, -0.13881519f, -0.04160064f, 0.00795653f, -0.29561362f, -0.10500067f, 0.03953737f, 0.03501970f, 
    0.10150297f, 0.02777954f, -0.05029921f, 0.01111561f, -0.13393946f, -0.02152707f, -0.07119008f, -0.01530111f, 
    -0.04539747f, 0.06164188f, -0.08070160f, -0.08095434f, 0.00016187f, -0.21927424f, 0.10139710f, -0.10727403f, 
    0.24686037f, 0.05969687f, -0.16813423f, -0.21480742f, -0.09387178f, -0.00260534f, 0.05338554f, -0.01679179f, 
    -0.02265204f, -0.00439840f, 0.13586856f, 0.17650166f, -0.00834243f, -0.09035785f, 0.01489120f, -0.01669802f, 
    0.01623538f, 0.06507009f, 0.02232753f, -0.07816724f, 0.17149048f, 0.26556677f, 0.18650833f, -0.03035469f, 
    0.04249672f, -0.12894401f, -0.06876549f, -0.05584160f, 0.02685638f, 0.09529976f, 0.01088434f, 0.05375464f, 
    0.01447231f, 0.16507553f, 0.01286678f, 0.16820666f, -0.02893118f, -0.09975040f, 0.07178174f, 0.09788688f, 
    0.12470908f, -0.24402927f, 0.01189472f, 0.02014541f, 0.13995685f, -0.08677296f, -0.13851492f, 0.02343792f, 
    -0.08396818f, -0.05196959f, -0.01843523f, -0.03355562f, 0.01794558f, 0.07734431f, -0.00335735f, 0.03639646f, 
    -0.01362236f, -0.09672524f, 0.00030071f, 0.01112661f, 0.00064146f, -0.10034954f, 0.16997097f, 0.02068716f, 
    0.21239072f, 0.01099038f, -0.09658238f, 0.09068017f, -0.02103110f, -0.06933555f, 0.02981101f, 0.02381892f, 
    -0.04021788f, -0.00015501f, -0.00998134f, -0.02371649f, 0.12063245f, 0.07824096f, 0.12791011f, -0.01942225f, 
    0.28127030f, -0.02540414f, 0.23884350f, 0.11900429f, 0.07857175f, 0.01737526f, -0.04607177f, -0.05396535f, 
    0.02450543f, 0.11212576f, -0.01497013f, 0.00155074f, 0.03635949f, -0.05498590f, 0.10033099f, 0.07553836f, 
    -0.03299657f, 0.09300056f, 0.08355200f, -0.00665277f, 0.03164130f, 0.08336978f, 0.01292315f, -0.00047965f, 
    -0.03791222f, -0.04924383f, 0.03468962f, 0.04586930f, -0.01403924f, -0.00567127f, -0.06523398f, 0.03860081f, 
    0.07150932f, -0.04337457f, -0.03266825f, -0.09788930f, 0.07782111f, 0.02299519f, 0.17851417f, -0.05039674f, 
    -0.19019668f, -0.24762279f, -0.16874708f, 0.03912127f, 0.26865959f, 0.07917460f, 0.06842848f, 0.02884383f, 
    -0.02829639f, -0.06301875f, 0.14322926f, 0.16966191f, 0.05848404f, -0.12733993f, -0.05901326f, -0.00334403f, 
    0.05255865f, 0.02307254f, 0.03254699f, 0.02733680f, -0.08852069f, -0.07181105f, -0.16592482f, -0.01932772f, 
    -0.17174552f, -0.01225766f, -0.02004053f, -0.05184256f, 0.07250410f, -0.08770859f, -0.00961671f, 0.03349703f, 
    0.10576846f, -0.02144172f, -0.10258650f, 0.07230359f, -0.06821229f, -0.07812095f, -0.07591466f, 0.09943522f, 
    -0.17266856f, 0.14201356f, 0.07533849f, 0.15101506f, 0.02900468f, 0.00255466f, -0.11973308f, 0.03705178f, 
    0.10338844f, -0.01625277f, -0.02215686f, 0.06218398f, 0.05378371f, 0.13152900f, 0.03625502f, -0.12771256f, 
    -0.05118458f, 0.06136009f, 0.09712182f, -0.06241805f, 0.04217860f, 0.21027920f, 0.03208485f, 0.11602031f, 
    0.06576396f, 0.03342388f, 0.02217417f, -0.05236006f, 0.02496431f, 0.04112449f, -0.09323042f, -0.08317527f, 
    -0.03103048f, 0.01837865f, 0.04608334f, 0.00930474f, -0.00485069f, -0.00292891f, -0.02017261f, -0.02201362f, 
    -0.02051058f, 0.03986873f, 0.09947122f, 0.01513371f, 0.12914017f, -0.02921097f, 0.05024500f, -0.01324515f, 
    -0.03264968f, -0.00918432f, -0.09725683f, -0.00398135f, -0.06121084f, -0.05253224f, 0.04469365f, -0.02012362f, 
    0.02072679f, 0.01661402f, 0.03487098f, -0.14828256f, 0.06605322f, -0.19049136f, 0.28400406f, 0.10875631f, 
    -0.09128614f, -0.02758413f, -0.01098970f, 0.08865415f, 0.05983882f, 0.09097978f, -0.07581144f, 0.05119302f, 
    0.10867514f, 0.08191304f, 0.04160012f, -0.00068244f, 0.03551302f, 0.01250833f, 0.07740102f, 0.00816737f, 
    0.15150270f, 0.04986104f, 0.23046184f, 0.13425353f, 0.03686262f, -0.04463952f, 0.08961592f, -0.05225477f, 
    -0.02370626f, -0.12178060f, 0.06833263f, 0.00620887f, -0.12156006f, -0.08162145f, -0.13388564f, 0.10000639f, 
    0.08953500f, 0.14644323f, 0.06405661f, 0.07215862f, 0.19537632f, -0.01188398f, -0.13612929f, 0.01693743f, 
    -0.09329434f, -0.04973014f, 0.08451868f, -0.09198252f, 0.02044795f, -0.06468355f, -0.05817651f, -0.08836048f, 
    -0.06092132f, 0.04904852f, -0.11399243f, -0.02212515f, 0.05866063f, 0.08203745f, 0.06619032f, 0.04949977f, 
    -0.22750753f, 0.12443213f, 0.01726324f, 0.03553500f, 0.03426218f, -0.01189627f, 0.04286614f, 0.01986748f, 
    -0.03914812f, 0.15860365f, 0.09294053f, -0.01532718f, 0.13567619f, -0.01320089f, 0.03403603f, 0.09293672f, 
    -0.09046756f, 0.04561176f, 0.04739321f, 0.02001244f, 0.08105484f, -0.03124815f, -0.12695161f, -0.05677578f, 
    -0.00367800f, 0.01580064f, 0.06667617f, -0.06719474f, 0.06664689f, -0.07626949f, 0.09843049f, 0.10026813f, 
    0.12299659f, 0.06740344f, 0.06785914f, -0.03875381f, -0.14410706f, 0.06563575f, -0.10394005f, 0.07929144f, 
    -0.12571476f, -0.00368381f, -0.02945251f, 0.08361850f, 0.00153912f, 0.03237149f, -0.09794739f, 0.01121228f, 
    0.10080937f, 0.02817359f, -0.02673948f, 0.05474174f, 0.00539216f, 0.08414884f, 0.03419269f, 0.07742327f, 
    -0.02447374f, -0.07331776f, 0.00799534f, 0.03075916f, -0.00582406f, -0.08276506f, -0.08921660f, -0.00001935f, 
    -0.00285867f, 0.06105391f, -0.01101541f, 0.00825998f, 0.02969379f, -0.01505676f, 0.12529209f, 0.06946521f, 
    -0.06287362f, -0.07020492f, -0.07923818f, -0.06787635f, -0.00876421f, 0.07499748f, 0.08563961f, -0.03928883f, 
    0.00489221f, 0.27879652f, 0.06195067f, -0.04273127f, 0.12891077f, 0.04813636f, 0.11631854f, -0.06336264f, 
    0.02642514f, 0.05869782f, -0.00820216f, -0.02618484f, -0.00651745f, -0.01769199f, 0.02097680f, -0.00207034f, 
    0.03707014f, 0.13185759f, 0.04100077f, -0.02007902f, -0.28021494f, 0.00841192f, -0.02112438f, -0.03944523f, 
    -0.18461362f, 0.01582098f, 0.06198599f, -0.00848081f, -0.02447737f, 0.04233278f, -0.00305539f, 0.01978533f, 
    -0.00513556f, -0.02628884f, 0.05020750f, -0.01419569f, -0.07179584f, 0.02246424f, -0.00522954f, -0.01325274f, 
    -0.24808294f, 0.08212110f, -0.06033613f, -0.00828826f, -0.00737746f, -0.00304001f, 0.02150626f, -0.02603333f, 
    0.03198772f, -0.06190002f, 0.09497780f, 0.03078184f, 0.06053182f, 0.11019755f, -0.04517766f, -0.02888401f, 
    0.06159465f, -0.01760518f, -0.02183008f, -0.01943296f, -0.04497969f, 0.07702223f, -0.09360731f, 0.01616048f, 
    0.05496833f, -0.02070538f, -0.02152458f, -0.01053943f, 0.01100797f, 0.03954028f, 0.05177915f, 0.00647385f, 
    -0.08355429f, 0.12520640f, 0.02474806f, 0.11576343f, -0.10401817f, 0.02459361f, -0.08714196f, -0.00620809f, 
    0.26628298f, 0.17143427f, -0.05047310f, 0.09051182f, 0.01615128f, -0.00770964f, -0.06500887f, 0.09206426f, 
    -0.02622164f, 0.03317534f, 0.07848816f, 0.01547274f, -0.00670421f, 0.09077603f, 0.11652774f, 0.00302937f, 
    -0.05990203f, -0.06490490f, -0.04836977f, 0.05370426f, 0.48179090f, 0.08998931f, 0.16023175f, 0.05429344f, 
    0.22838849f, -0.00258688f, 0.01398617f, 0.04269915f, 0.00355622f, 0.04539383f, -0.03888666f, 0.09421302f, 
    -0.05024241f, -0.02377035f, 0.07091303f, 0.02594398f, 0.07113971f, 0.09035966f, 0.07257672f, -0.11566639f, 
    0.14829984f, -0.09633467f, 0.02879851f, -0.04281090f, -0.15003146f, -0.07961448f, 0.06332614f, -0.03814626f, 
    -0.09342792f, -0.07252803f, 0.04455126f, -0.02769489f, -0.07364763f, 0.00481475f, 0.03467836f, 0.13857462f, 
    0.01036998f, -0.03667872f, -0.07023348f, 0.03250549f, -0.03475056f, -0.10042194f, 0.10298446f, -0.10359079f, 
    -0.04395152f, 0.05274250f, -0.01281737f, 0.02348248f, 0.02918012f, -0.06694335f, 0.11324124f, 0.08207470f, 
    0.05162553f, 0.08545741f, -0.02159913f, 0.01460136f, 0.12557259f, -0.02720966f, 0.04734612f, 0.00343748f, 
    -0.10410213f, -0.13222091f, 0.00831801f, -0.01419857f, -0.08353164f, 0.04567119f, 0.01922392f, 0.01962203f, 
    0.12393528f, -0.10973112f, 0.09274157f, 0.07880574f, 0.07221471f, 0.01918933f, 0.11411293f, 0.11215064f, 
    0.00150191f, -0.01676664f, -0.11469789f, 0.02198864f, -0.09171805f, 0.24169494f, -0.09083878f, 0.02660671f, 
    0.19583730f, 0.06391680f, 0.03213371f, -0.10202507f, -0.04173213f, -0.06287099f, 0.13654406f, -0.10614529f, 
    -0.05482217f, -0.05582388f, -0.00473248f, 0.00887506f, -0.05063730f, 0.06740661f, -0.05331378f, 0.01988306f, 
    -0.13600457f, -0.20571133f, -0.08343287f, -0.06051720f, -0.03662106f, -0.00366380f, -0.13583231f, -0.00084204f, 
    0.02902636f, 0.00185940f, 0.02103977f, 0.03318743f, 0.16442963f, 0.11653846f, 0.09630888f, -0.02696720f, 
    0.02879150f, -0.12004115f, -0.09574027f, -0.11518762f, -0.03229674f, 0.08375046f, 0.22529583f, 0.01585357f, 
    -0.00658890f, 0.00064093f, 0.03215043f, 0.03770413f, 0.00802799f, 0.08385436f, 0.11531740f, 0.04788450f, 
    0.11397290f, 0.01444042f, 0.07858330f, -0.03555250f, 0.03423873f, 0.01947682f, 0.01069502f, -0.03552015f, 
    -0.02797296f, -0.23563510f, 0.08641528f, 0.10973252f, -0.01726332f, -0.03229390f, 0.04650146f, 0.04810348f, 
    0.03291522f, 0.05316138f, -0.01000268f, 0.00708463f, 0.07484221f, -0.07186563f, 0.01305371f, 0.07204380f, 
    -0.00329268f, 0.10424244f, 0.03018258f, 0.08198702f, 0.31474492f, 0.06502447f, 0.03440556f, -0.10656358f, 
    -0.20479152f, 0.08980101f, 0.02760084f, 0.04860713f, 0.06148979f, -0.11687411f, 0.06175876f, -0.00650442f, 
    0.08844892f, 0.01742097f, 0.06248415f, 0.05414005f, -0.00814436f, 0.18178572f, -0.10740463f, 0.05765900f, 
    -0.18484053f, -0.07949332f, 0.14518414f, 0.12098191f, 0.06446520f, -0.06070961f, -0.05320072f, 0.00081681f, 
    0.02667277f, -0.01121171f, -0.00845513f, -0.13077052f, -0.01043343f, 0.09235639f, 0.07013861f, 0.03386144f, 
    -0.05307631f, -0.10207216f, -0.03401238f, 0.04562834f, 0.08278234f, -0.25181320f, -0.26887360f, -0.06526010f, 
    -0.02559157f, 0.08939428f, -0.02806645f, 0.07211419f, 0.03413113f, 0.00662229f, 0.06539316f, 0.02638872f, 
    -0.03342402f, 0.06255854f, 0.02087175f, -0.11330916f, -0.02336334f, 0.02937510f, -0.04813400f, -0.01365090f, 
    0.03728155f, 0.20681661f, -0.00454859f, 0.08712755f, -0.11433889f, 0.15500611f, 0.10016602f, -0.04453483f, 
    -0.01548809f, -0.03745246f, -0.07152008f, 0.09973932f, 0.01330722f, 0.03723493f, -0.03237265f, -0.05755091f, 
    -0.01920400f, 0.09362223f, 0.05097917f, -0.09663460f, -0.01607376f, -0.08162579f, -0.09802985f, 0.03405504f, 
    -0.19888741f, 0.07302582f, 0.11478274f, -0.12343524f, -0.03168934f, 0.04971839f, 0.00869433f, 0.03144583f, 
    -0.03034440f, -0.03264275f, 0.06078781f, 0.01387510f, -0.07585289f, -0.01470955f, -0.10507923f, -0.08170556f, 
    -0.09819969f, -0.12906165f, -0.05623627f, -0.08011141f, -0.06602615f, -0.01557878f, 0.05527220f, 0.02169540f, 
    -0.05317746f, -0.04042981f, -0.05544141f, -0.03327908f, -0.09964284f, -0.05206423f, 0.02667439f, -0.09017079f, 
    0.04947630f, 0.04904880f, -0.07739019f, -0.04621603f, -0.07022800f, -0.04805367f, 0.06386641f, 0.00424633f, 
    0.06403362f, 0.00954787f, 0.02719563f, -0.05821373f, 0.06640258f, -0.03788722f, 0.07993292f, -0.07385617f, 
    -0.05307127f, 0.17000748f, 0.04282406f, 0.00115763f, -0.05036481f, -0.01065978f, -0.08037185f, 0.11152220f, 
    0.15181035f, 0.21043526f, -0.00501626f, 0.07457253f, -0.08805068f, 0.09185904f, 0.01434555f, -0.02190049f, 
    0.05729667f, 0.01908360f, -0.04046033f, -0.03127356f, 0.07977626f, 0.14897971f, 0.08411082f, -0.02033483f, 
    0.03508255f, -0.02465563f, -0.06636633f, -0.05983563f, 0.26501369f, 0.23722215f, 0.14599404f, 0.03188679f, 
    0.27975914f, -0.03062676f, 0.07469242f, 0.00098715f, -0.01601837f, 0.01522274f, 0.02298702f, 0.05918538f, 
    0.00881934f, 0.04069149f, 0.04292301f, -0.02907968f, -0.00354991f, 0.14284480f, 0.11189962f, -0.00170163f, 
    0.01200187f, -0.11522114f, -0.11196926f, -0.17835192f, -0.01686060f, 0.00197400f, 0.07737666f, -0.08877172f, 
    -0.06619578f, 0.11145054f, 0.12436561f, 0.09092923f, -0.03433322f, -0.10373461f, 0.05190209f, 0.10402760f, 
    0.12579329f, -0.15483153f, -0.08862555f, 0.11463934f, -0.31348690f, -0.13298374f, 0.12795450f, -0.01046405f, 
    -0.09102814f, -0.04086494f, 0.01257131f, 0.05756957f, -0.07514231f, 0.04183069f, -0.01506126f, 0.09723545f, 
    -0.04062134f, 0.08661024f, -0.00890470f, 0.02271359f, 0.14792442f, -0.01757791f, 0.02885707f, 0.03768142f, 
    0.09276266f, -0.20764844f, 0.04480512f, -0.00008685f, -0.02479659f, -0.03684352f, -0.01375166f, 0.09782563f, 
    0.05152168f, -0.01854921f, 0.06058069f, -0.06023362f, 0.10009834f, 0.04599996f, 0.04434825f, 0.08281009f, 
    0.05332429f, 0.03685325f, -0.09219807f, 0.05858329f, 0.15397349f, 0.06510525f, -0.16874576f, 0.03115526f, 
    0.02531366f, 0.05494944f, 0.02589758f, -0.05821831f, -0.09885955f, -0.12236505f, 0.17677695f, 0.04626684f, 
    -0.09802399f, -0.06973405f, 0.08957640f, 0.11434282f, -0.10298790f, 0.02636598f, 0.07905288f, 0.10441937f, 
    -0.18521734f, 0.03686313f, -0.06564860f, -0.17959815f, 0.09058569f, -0.00055433f, -0.06919719f, -0.06200004f, 
    -0.05703848f, 0.10837664f, 0.03197856f, -0.09001764f, 0.07982477f, 0.10334738f, 0.08317518f, -0.07202281f, 
    0.02553237f, -0.06506153f, -0.15877269f, -0.03443275f, 0.01988859f, 0.07821244f, 0.09800512f, 0.03410520f, 
    0.09379222f, -0.09287483f, 0.07855800f, 0.01873551f, 0.02232922f, 0.03683806f, 0.09391662f, -0.00505715f, 
    0.13586786f, -0.05804601f, 0.08653918f, -0.01115181f, -0.03491003f, -0.07738941f, 0.03396472f, -0.06740487f, 
    -0.04240410f, 0.16016398f, -0.08590714f, -0.02695137f, -0.19970523f, 0.05981828f, 0.02068063f, 0.06929890f, 
    0.01234838f, -0.01498987f, -0.03735934f, 0.10357866f, -0.12342879f, 0.04755041f, 0.01104492f, 0.01256388f, 
    0.06316961f, -0.06008592f, -0.05453520f, -0.02658126f, -0.16734846f, -0.04151525f, -0.08765687f, 0.14626671f, 
    0.20339429f, -0.04201557f, -0.06685014f, 0.02134320f, -0.09373355f, 0.03467475f, -0.00191271f, -0.01946526f, 
    -0.15012437f, -0.02405187f, 0.01684981f, -0.11495946f, 0.01616095f, -0.16208853f, 0.07230159f, -0.14118122f, 
    0.18131420f, 0.15483941f, -0.06398064f, 0.06081038f, -0.12473943f, -0.02238400f, -0.01115713f, -0.02443069f, 
    -0.16754594f, 0.01572729f, -0.01206843f, 0.15032649f, 0.02854627f, -0.13542534f, 0.06358784f, -0.02058288f, 
    0.11075652f, 0.03206028f, -0.03640960f, 0.03063577f, -0.03171952f, 0.17445765f, 0.27833739f, 0.06469791f, 
    0.02453224f, 0.04913994f, 0.06854449f, 0.04229832f, -0.01723150f, -0.08419427f, 0.03207575f, -0.11674593f, 
    0.09624701f, -0.07058877f, 0.04080262f, 0.08197808f, 0.02035452f, -0.00622908f, -0.01181154f, -0.07006783f, 
    0.10273191f, -0.08549201f, 0.01002492f, -0.13347310f, -0.10805587f, -0.13183995f, -0.00689012f, 0.16104390f, 
    0.04577268f, 0.07941815f, 0.12541594f, -0.05577383f, 0.06686701f, 0.06618799f, 0.04330915f, -0.01118905f, 
    -0.04908372f, -0.02825411f, -0.04037351f, 0.12819871f, -0.02736712f, 0.06649739f, 0.04057927f, 0.02496633f, 
    0.24229872f, 0.05282434f, 0.02258590f, 0.04492176f, 0.04054517f, 0.05360510f, 0.02683936f, -0.12935938f, 
    -0.02031933f, 0.05454791f, -0.02051807f, -0.04585987f, 0.09547122f, 0.07550296f, 0.13992251f, 0.03129398f, 
    -0.13981986f, 0.06701386f, -0.07887927f, 0.07210512f, 0.17876559f, 0.01699043f, -0.06777164f, 0.01752787f, 
    0.03218247f, 0.00484172f, 0.07317904f, -0.09752423f, 0.06036454f, 0.09401346f, -0.05409458f, 0.00241363f, 
    0.00952454f, -0.05350306f, 0.14366493f, -0.03656204f, 0.13916886f, 0.15853165f, -0.05535338f, -0.00222486f, 
    0.04619011f, 0.00926505f, 0.02267032f, 0.03914981f, -0.05251500f, -0.00326885f, 0.00028756f, -0.05061233f, 
    0.04841806f, -0.08112381f, 0.01072547f, -0.04794305f, -0.04313661f, 0.13714615f, 0.09774876f, -0.11471573f, 
    -0.06718680f, -0.06011083f, 0.10731272f, 0.10289812f, 0.06195193f, -0.13995813f, 0.05657166f, 0.06474330f, 
    -0.03992215f, 0.02871789f, -0.01982832f, 0.10011110f, -0.04667643f, -0.03595684f, -0.01104588f, 0.05322981f, 
    -0.03395948f, -0.00886125f, 0.09935069f, 0.14484778f, -0.14894894f, -0.13395077f, -0.00302219f, -0.13093592f, 
    -0.22367352f, 0.12404786f, -0.03435396f, 0.01991588f, -0.03733242f, 0.12053929f, -0.08395628f, -0.03392950f, 
    0.00051047f, -0.02535705f, -0.01110911f, 0.02464639f, 0.00421768f, -0.11228811f, -0.13664022f, -0.01412253f, 
    -0.11137408f, 0.06938025f, 0.04479751f, 0.06419855f, 0.11248892f, 0.02802613f, -0.00934573f, 0.13631144f, 
    0.02881587f, -0.06462005f, -0.05836964f, -0.11309078f, 0.02815110f, 0.09868977f, 0.04416215f, 0.00585224f, 
    -0.05406863f, 0.07062465f, 0.02718106f, 0.01331944f, 0.23875161f, 0.04942530f, -0.06892277f, -0.03779748f, 
    0.12689339f, 0.09834062f, 0.03836800f, -0.03284615f, 0.00218571f, -0.02798742f, 0.00516654f, -0.08073847f, 
    -0.06510136f, -0.06586860f, 0.02946392f, 0.03966847f, -0.06773166f, 0.02411826f, 0.06518725f, 0.00649582f, 
    -0.14804769f, 0.27723888f, -0.05723769f, -0.02998435f, 0.07265817f, 0.09878568f, -0.00476325f, 0.01517843f, 
    -0.02344221f, -0.00927686f, 0.02878831f, -0.04729485f, -0.08157551f, -0.05594212f, -0.04520911f, -0.03637748f, 
    -0.05391366f, 0.08642494f, 0.08582150f, -0.13390809f, -0.27346390f, -0.05877290f, 0.04644633f, 0.04265915f, 
    0.01728177f, 0.09362202f, -0.00705391f, 0.06803123f, -0.00959813f, 0.11645130f, -0.01406491f, 0.02036792f, 
    0.15276851f, 0.11328007f, -0.10377187f, -0.08750344f, 0.10190327f, -0.04311108f, 0.01434652f, -0.13654707f, 
    0.15834488f, 0.04707863f, -0.04989650f, 0.15991819f, 0.07714713f, 0.10282174f, -0.02055470f, 0.07740457f, 
    0.02478695f, -0.03672110f, -0.01826943f, 0.11577357f, 0.00107418f, -0.05909699f, 0.06420406f, 0.07225771f, 
    -0.07092566f, 0.12790918f, 0.25651020f, 0.07190344f, -0.21530461f, 0.06790236f, 0.01028957f, -0.06258108f, 
    -0.00669365f, 0.12075792f, -0.02318352f, -0.00590618f, -0.01097102f, -0.07208257f, -0.05254281f, 0.05055603f, 
    -0.14589940f, 0.04665628f, 0.05314842f, 0.05873419f, 0.04041084f, 0.05695269f, 0.00756027f, 0.00092999f, 
    0.00458640f, -0.06150164f, 0.02186641f, -0.01309754f, 0.01189711f, -0.04664662f, -0.01219080f, -0.04066779f, 
    -0.01355271f, -0.01308147f, 0.02599603f, 0.00955970f, -0.00482418f, 0.02349639f, -0.04340420f, -0.01984311f, 
    0.04221947f, -0.04339597f, 0.01339090f, 0.00068779f, 0.03022016f, -0.02111007f, 0.02206003f, 0.03234063f, 
    0.02653758f, -0.04008445f, 0.03529609f, -0.03684264f, -0.04275834f, -0.02031768f, -0.01598619f, -0.03690459f, 
    -0.02192478f, 0.01667714f, 0.00667922f, 0.02193468f, 0.01589916f, 0.04073005f, 0.03536195f, 0.04612966f, 
    0.02998525f, -0.05940879f, -0.01353587f, -0.03765229f, -0.01411816f, -0.02995431f, 0.02110861f, -0.02023734f, 
    0.04750100f, -0.02605210f, -0.01187666f, -0.06171259f, 0.01248372f, 0.01950764f, 0.00871527f, -0.00553968f, 
    0.01452728f, -0.01984249f, 0.01535236f, 0.03610030f, -0.01345781f, 0.02552045f, -0.02307329f, -0.03485952f, 
    0.02698923f, 0.01977240f, -0.01639433f, 0.02257903f, 0.00657934f, -0.03349162f, -0.01149028f, -0.04032408f, 
    0.03375854f, 0.02987958f, 0.04449347f, -0.02534742f, 0.01210888f, 0.01156640f, 0.00317107f, -0.01714742f, 
    -0.01469744f, -0.03209068f, -0.01008542f, -0.01714264f, -0.01584351f, -0.00695891f, 0.03423353f, -0.01235519f, 
    -0.04984053f, -0.06420118f, -0.04150847f, -0.03778183f, 0.00890750f, 0.01517676f, 0.03139212f, -0.00990705f, 
    0.00034341f, 0.00305330f, -0.00278163f, -0.06256142f, -0.01218314f, 0.00246638f, -0.04610482f, -0.01528657f, 
    0.01477621f, 0.02442060f, 0.01615538f, 0.03131209f, -0.04342892f, -0.05444814f, -0.03473797f, -0.02950712f, 
    -0.06278489f, 0.00808098f, -0.01516805f, 0.03287789f, -0.04783737f, 0.04734655f, -0.03621482f, -0.00135094f, 
    -0.04974928f, 0.01753285f, -0.01062167f, -0.02639226f, -0.00916469f, -0.02732594f, -0.00590260f, -0.02096378f, 
    -0.00386717f, -0.03373885f, 0.00871065f, -0.00936310f, -0.00883632f, 0.02770647f, -0.03255106f, -0.04615998f, 
    0.01858666f, 0.03548931f, -0.00942618f, -0.01968109f, -0.01564812f, 0.04783342f, -0.00194471f, -0.05629361f, 
    0.03995463f, -0.04755159f, 0.04593919f, -0.01039343f, 0.03786373f, 0.02158681f, 0.00209518f, -0.04205949f, 
    -0.05725492f, 0.04119546f, 0.03562243f, -0.05879819f, -0.01475867f, 0.00190435f, -0.02403925f, 0.02014248f, 
    -0.02679433f, -0.01669327f, 0.03040975f, -0.02673245f, -0.02486161f, 0.03759082f, -0.03842171f, 0.02871899f, 
    -0.02984888f, 0.00706313f, -0.05387031f, 0.03350013f, -0.03822891f, 0.00124398f, 0.02536491f, 0.02575552f, 
    0.01676861f, -0.05953228f, -0.02417869f, -0.04505879f, 0.00673821f, 0.04510675f, -0.02384686f, -0.01321127f, 
    0.03831130f, -0.01749831f, -0.05235513f, 0.02817586f, -0.03332099f, 0.01046124f, -0.01199941f, -0.06136081f, 
    -0.00023258f, 0.04483303f, 0.04648648f, 0.01144452f, -0.03795776f, -0.05299640f, -0.01388829f, -0.01573444f, 
    0.04113709f, -0.03029079f, -0.03905074f, -0.05526160f, 0.02227152f, 0.00644338f, -0.04248383f, 0.01117274f, 
    -0.02551543f, -0.01558122f, 0.02404685f, -0.05025076f, 0.03433677f, -0.03817652f, 0.03797654f, 0.00316337f, 
    0.02613978f, -0.04468632f, -0.04348046f, -0.05789535f, -0.03825957f, 0.01455266f, 0.00311243f, -0.05698657f, 
    -0.01520002f, -0.02434514f, -0.06365348f, -0.00605404f, -0.00137653f, 0.04341734f, -0.05057454f, -0.03666849f, 
    -0.04218674f, 0.00693394f, 0.03721118f, 0.01572405f, -0.00232200f, -0.03212505f, -0.00256513f, -0.02498222f, 
    0.00397238f, -0.03372822f, -0.01426050f, -0.02310991f, -0.01601009f, -0.01325127f, 0.01188869f, 0.01945375f, 
    -0.05926624f, -0.00893480f, -0.05149932f, -0.02479202f, 0.03339464f, 0.00569881f, -0.00475513f, -0.02424679f, 
    -0.04068254f, -0.03241272f, -0.02434222f, -0.01619644f, -0.04093744f, -0.01786517f, -0.05814376f, -0.02978547f, 
    -0.05246073f, -0.04089382f, -0.05445371f, -0.03051302f, -0.01440438f, 0.01493605f, 0.00528375f, -0.04058362f, 
    0.04303637f, -0.03107844f, 0.02707785f, -0.03497401f, 0.00575948f, -0.03271774f, -0.04287436f, 0.00833237f, 
    0.00467301f, 0.03149343f, -0.04521786f, -0.05289074f, -0.01965206f, 0.02555179f, 0.02188842f, 0.02599513f, 
    -0.04784200f, 0.04286398f, -0.01001784f, -0.01198640f, -0.04534441f, -0.05709978f, -0.02846821f, -0.03670802f, 
    -0.00795182f, -0.01007956f, -0.05046816f, 0.00298780f, 0.04466992f, 0.01752532f, 0.00836898f, 0.02242564f, 
    0.04625676f, 0.03788891f, 0.00759202f, -0.00745673f, 0.02162168f, -0.00874911f, 0.00497327f, 0.04561484f, 
    0.03862219f, -0.03589400f, 0.04166008f, 0.04689399f, -0.03786910f, -0.01607092f, -0.02031106f, -0.04586650f, 
    -0.04088791f, -0.02003333f, 0.03632694f, -0.03423742f, 0.05791517f, 0.04756697f, 0.03081548f, 0.00776980f, 
    -0.00552898f, 0.04381959f, 0.01485717f, -0.01192200f, 0.00125611f, -0.03600603f, 0.01371540f, -0.02344337f, 
    0.02221500f, -0.00929922f, -0.02061886f, 0.00938556f, 0.03212386f, -0.02038720f, -0.05378083f, -0.05372712f, 
    -0.03333569f, -0.02283762f, -0.05897590f, 0.01701546f, 0.01680170f, 0.02975085f, -0.04290730f, -0.01439846f, 
    -0.04036726f, -0.02956315f, -0.05052751f, 0.00598676f, -0.03782948f, -0.00196265f, -0.02584500f, 0.00412165f, 
    0.04265926f, -0.01580656f, 0.02996410f, 0.00548354f, -0.05075137f, -0.01885035f, 0.02021991f, 0.03071916f, 
    0.00911347f, 0.00920836f, -0.03090501f, 0.03404111f, 0.02937920f, 0.04755005f, 0.00056946f, 0.01688249f, 
    0.03708077f, 0.04052473f, -0.05659931f, -0.00185803f, 0.02861902f, 0.04614360f, -0.02852813f, -0.05508524f, 
    0.01697021f, 0.00277716f, 0.04170382f, 0.00318266f, -0.00630212f, -0.02387270f, -0.01471194f, -0.01685034f, 
    -0.01495507f, 0.04448993f, 0.04044748f, -0.03811491f, -0.02748683f, -0.02053367f, 0.02256840f, -0.04571595f, 
    -0.02410043f, -0.04999376f, 0.03151807f, 0.01193157f, -0.01197653f, 0.00323400f, -0.01330819f, 0.04074019f, 
    -0.05100948f, 0.04841824f, -0.04824167f, -0.05844908f, 0.03621321f, 0.02120633f, -0.04124258f, 0.03940612f, 
    0.03450431f, 0.03851799f, -0.02355151f, -0.00843785f, 0.01516470f, 0.02574497f, -0.02460668f, 0.04176696f, 
    0.03471690f, -0.02795801f, 0.01127692f, -0.06403252f, -0.01936256f, -0.00216275f, 0.02558046f, -0.00638998f, 
    0.02106393f, -0.00833201f, -0.02314723f, -0.02019128f, 0.03869866f, 0.04474346f, -0.03931195f, 0.01567633f, 
    0.04263256f, -0.01992658f, -0.05778093f, -0.02349428f, -0.01506933f, 0.03094903f, 0.03840136f, -0.03875131f, 
    -0.00200725f, 0.00229265f, -0.03840166f, -0.00375409f, -0.02151763f, 0.04811305f, -0.01575837f, 0.02944043f, 
    0.03845561f, -0.05888937f, -0.03274760f, -0.02752190f, -0.00115353f, -0.03707680f, 0.03618078f, 0.03455181f, 
    -0.04751948f, -0.00649574f, 0.02899749f, 0.02324456f, 0.04317144f, 0.03758433f, -0.03103717f, -0.00355848f, 
    -0.01046421f, 0.01768537f, -0.04617747f, -0.05156635f, -0.04286773f, -0.03250337f, -0.05282896f, 0.00554400f, 
    0.01066499f, -0.04931603f, -0.02296726f, -0.06264089f, -0.03795653f, 0.02845168f, 0.03596888f, 0.02070489f, 
    0.04768666f, -0.03819664f, -0.03957129f, -0.04803315f, -0.03355666f, -0.03378280f, 0.03871102f, -0.04394801f, 
    0.00095858f, -0.00288134f, 0.03987979f, -0.00829378f, -0.05088297f, 0.01274998f, -0.01329748f, 0.01842456f, 
    0.04560142f, -0.04020235f, -0.00768676f, 0.03364508f, -0.06394155f, 0.01084070f, 0.01283296f, -0.04834791f, 
    -0.01600528f, -0.04614123f, -0.00575024f, 0.02963660f, 0.03560397f, -0.04880614f, 0.02533248f, 0.04429776f, 
    -0.02665072f, 0.01694934f, -0.06465537f, -0.03911230f, -0.05433337f, 0.00795983f, -0.03191597f, -0.00709054f, 
    0.04582815f, -0.03491309f, 0.01588843f, 0.00474232f, 0.01834725f, 0.05054669f, 0.02913773f, 0.04365415f, 
    -0.00534993f, -0.05092841f, 0.00017969f, -0.01402114f, -0.00093577f, 0.01997710f, 0.00103732f, 0.00823699f, 
    -0.00291753f, -0.04084428f, -0.04273618f, -0.04674728f, -0.03213312f, -0.01647385f, 0.04176646f, 0.02006480f, 
    -0.05233482f, 0.02661277f, -0.03123284f, -0.02822584f, 0.01963372f, 0.02597084f, 0.04379711f, -0.04299604f, 
    -0.03353354f, -0.00099537f, -0.02397781f, -0.06595342f, -0.00548477f, 0.03584395f, -0.02967620f, -0.01411994f, 
    0.01813871f, 0.02692905f, -0.00894814f, -0.01737031f, 0.01931919f, 0.01896659f, -0.00615409f, 0.00356931f, 
    -0.01066321f, 0.03483273f, 0.00882326f, -0.06477568f, -0.06111603f, -0.00038136f, -0.04244986f, 0.01421700f, 
    0.01797272f, 0.03492885f, -0.00995469f, -0.06169697f, -0.02160920f, -0.01336255f, 0.02405692f, -0.04348990f, 
    0.02859875f, -0.01077759f, 0.04602113f, 0.05485428f, 0.02583490f, 0.03462113f, 0.00563166f, -0.02360237f, 
    0.00905863f, 0.00544011f, -0.02310065f, -0.02331874f, -0.00648514f, 0.02363054f, 0.00469270f, 0.04031531f, 
    -0.04605329f, -0.00716143f, -0.02973290f, 0.01494706f, 0.01929836f, 0.03152492f, -0.03573729f, -0.03564553f, 
    0.01765700f, -0.04897958f, -0.03789889f, 0.03464734f, 0.03715219f, -0.06104257f, -0.04455796f, 0.02264019f, 
    -0.05235911f, -0.03944072f, 0.00489713f, 0.02507385f, -0.02770256f, -0.06199472f, -0.05660670f, -0.04338598f, 
    -0.05487929f, -0.00441508f, -0.01914181f, -0.05314070f, 0.02597423f, 0.01462735f, -0.04561902f, -0.03268424f, 
    -0.02919631f, -0.03910168f, 0.00898363f, 0.04824248f, 0.03358519f, -0.00688162f, -0.03686566f, -0.03396826f, 
    -0.04594951f, 0.03618044f, -0.01414728f, 0.01234648f, -0.01356904f, -0.04440853f, -0.04427017f, -0.02626638f, 
    -0.01784318f, -0.03800971f, -0.00155889f, -0.01173356f, 0.03711462f, 0.02158108f, 0.04906671f, -0.02757893f, 
    0.05397817f, -0.05082016f, -0.05480205f, -0.04616733f, -0.01337278f, -0.03703917f, -0.00360940f, -0.03008258f, 
    0.00494022f, -0.01227105f, -0.02922517f, -0.03238674f, -0.04242128f, -0.02370753f, 0.01091242f, 0.04447839f, 
    0.03930077f, 0.01482360f, 0.02702615f, 0.02451438f, 0.04785244f, -0.04219986f, -0.05319250f, -0.02067398f, 
    -0.00848900f, 0.04293647f, -0.02369459f, 0.04772336f, 0.00190331f, 0.03176156f, -0.01336465f, 0.04563653f, 
    0.01117066f, -0.04011057f, -0.00808773f, -0.05468754f, -0.05370373f, -0.02229525f, -0.00968010f, -0.03571467f, 
    0.05166803f, -0.05286581f, -0.04374764f, 0.00087001f, -0.05404084f, 0.02105735f, -0.05442263f, -0.05081972f, 
    -0.02988456f, -0.02116339f, -0.04369986f, -0.05414945f, -0.01297839f, -0.05139248f, 0.04042377f, -0.05453151f, 
    -0.02812707f, -0.02785836f, -0.01524924f, -0.04755913f, 0.01274046f, -0.03230700f, -0.04618010f, 0.00590931f, 
    -0.02530857f, -0.03395635f, -0.00015905f, 0.02626732f, 0.04854317f, 0.02312182f, -0.01765073f, 0.01526390f, 
    0.03142568f, 0.02750562f, -0.00044268f, -0.00998423f, 0.02622543f, 0.01132035f, 0.00673086f, 0.04106550f, 
    0.03876250f, 0.03162629f, 0.00707165f, -0.03277862f, -0.01263916f, -0.03198290f, -0.05444182f, 0.01957922f, 
    0.00914061f, 0.00903885f, -0.01985194f, -0.02904387f, -0.03062200f, 0.00359328f, -0.01970315f, 0.00947294f, 
    -0.03387931f, 0.05038814f, 0.00008810f, 0.05466452f, 0.00162158f, -0.05335051f, 0.01333869f, 0.05560350f, 
    0.04426736f, -0.02424542f, 0.00076780f, 0.01453237f, 0.03881452f, -0.01857588f, -0.03220157f, 0.05010518f, 
    0.02823464f, -0.03062337f, 0.04594484f, 0.02199340f, -0.05191613f, -0.04665478f, 0.01312748f, -0.00447450f, 
    0.02855123f, 0.05389189f, -0.00665634f, -0.02149414f, 0.04335955f, 0.01662265f, 0.01588617f, 0.00153065f, 
    0.00848292f, -0.04300965f, -0.01893081f, 0.05368353f, -0.01785989f, 0.04687752f, -0.00662898f, -0.05096773f, 
    0.01593280f, 0.00423830f, 0.05459278f, -0.00307946f, -0.01014157f, 0.01835751f, 0.02185343f, -0.00518460f, 
    0.05141819f, -0.03591988f, -0.03080594f, -0.00525838f, -0.03332876f, -0.02490006f, -0.03569609f, -0.00040339f, 
    -0.00977053f, -0.05028840f, 0.01113395f, -0.01755555f, 0.01953430f, -0.03310771f, -0.04381195f, -0.00190552f, 
    -0.04852540f, -0.05339408f, -0.01831785f, -0.03493755f, -0.03936233f, 0.02712236f, 0.02646076f, 0.03925005f, 
    -0.02267794f, -0.03681194f, -0.05518169f, -0.02806374f, -0.00368579f, 0.00134697f, 0.03446103f, -0.01770688f, 
    -0.03537976f, -0.00110598f, -0.00681801f, 0.02997762f, -0.04176631f, 0.05492030f, 0.00658151f, -0.04735579f, 
    -0.02913582f, -0.02913694f, -0.02915701f, -0.03648807f, 0.03390458f, -0.02002575f, -0.05301171f, 0.01343459f, 
    0.00208440f, -0.01357004f, 0.01330508f, -0.04393941f, 0.04511363f, 0.01399572f, -0.05408291f, 0.02330392f, 
    0.04901676f, -0.03493711f, 0.03594439f, -0.02301794f, -0.04955555f, 0.01072382f, 0.02104676f, -0.01450315f, 
    -0.03871334f, 0.04620995f, 0.01822839f, -0.01384144f, 0.02178716f, -0.04847933f, -0.05537641f, -0.04928980f, 
    -0.03125472f, 0.04311826f, -0.04725462f, -0.00319274f, 0.02521056f, 0.04044716f, 0.03243994f, 0.01617740f, 
    0.04528540f, 0.01942860f, -0.02987891f, -0.03155342f, -0.02976598f, -0.03691714f, -0.04606104f, -0.04384362f, 
    -0.02615154f, -0.01048911f, 0.04207975f, -0.05223483f, 0.01585480f, 0.04555208f, 0.03736527f, 0.05172732f, 
    -0.03205667f, 0.00783465f, -0.04812004f, -0.04719475f, 0.01154338f, 0.00431748f, 0.00249594f, -0.01981799f, 
    0.01931355f, 0.04777054f, -0.01927966f, 0.03219623f, 0.02634986f, -0.05544332f, -0.03147385f, -0.05124357f, 
    -0.03142701f, -0.00191298f, -0.04434228f, -0.01997043f, -0.01374351f, -0.05045846f, -0.00480636f, 0.01812084f, 
    -0.00328459f, 0.03218511f, -0.01170013f, -0.02305282f, -0.00984252f, -0.02832339f, -0.04046076f, -0.01050056f, 
    0.02148917f, 0.03166646f, -0.04910296f, 0.05427323f, -0.04356302f, -0.00786213f, 0.00536864f, 0.01625193f, 
    -0.00896364f, -0.01928589f, 0.02168731f, -0.05535196f, -0.00815389f, 0.02070813f, 0.00991123f, -0.03032321f, 
    0.00822376f, -0.01838728f, 0.00423200f, 0.05437382f, 0.04030247f, 0.01958146f, -0.05577140f, -0.00796032f, 
    -0.27980903f, 0.20255239f, -0.17342997f, 0.02294908f, -0.00868192f, 0.04365903f, -0.02332261f, -0.12664917f, 
    0.15558517f, -0.02487805f, -0.05294940f, 0.11171659f, 0.01164413f, -0.00028784f, -0.01866253f, 0.01536037f, 
    0.09724730f, -0.11246412f, 0.11879748f, -0.00790388f, -0.16586842f, 0.01412859f, 0.15206851f, -0.16399300f, 
    0.16622195f, 0.13176700f, -0.05224092f, 0.05436830f, 0.04524149f, -0.04462389f, -0.02864042f, -0.01803303f, 
    -0.03383955f, -0.00278009f, 0.04715729f, 0.13457927f, 0.11839241f, 0.04030429f, -0.12950695f, 0.07751139f, 
    0.09496597f, -0.02262307f, -0.06830386f, -0.03415305f, 0.01633613f, 0.04542806f, -0.05519690f, -0.01803495f, 
    -0.11730482f, -0.01928607f, 0.07006285f, 0.00767090f, -0.12438457f, 0.02527853f, 0.04060467f, -0.04192691f, 
    -0.02205374f, -0.00263902f, -0.11893632f, 0.06497326f, 0.07537998f, 0.02379465f, 0.01090836f, 0.01649486f, 
    -0.03617895f, 0.14136849f, 0.07530419f, -0.03655578f, 0.06101097f, 0.02146304f, -0.01798915f, 0.03959997f, 
    -0.03401858f, 0.01309122f, 0.08391818f, -0.06358284f, 0.07134832f, -0.12989689f, 0.04910174f, 0.12634067f, 
    -0.06019934f, -0.07916781f, -0.13388257f, -0.01814900f, -0.06773682f, 0.13922803f, 0.03423992f, -0.05437352f, 
    -0.06771911f, 0.03005113f, -0.04236230f, 0.11949644f, -0.10912339f, 0.09480029f, 0.04377751f, 0.00318667f, 
    -0.02549053f, 0.05289650f, 0.08981220f, 0.02373046f, -0.23587166f, 0.10454509f, 0.08019671f, -0.02547504f, 
    0.21727607f, -0.00154030f, -0.04168589f, -0.10896587f, -0.01530775f, 0.05932579f, -0.04893932f, 0.04543272f, 
    -0.01225279f, 0.00571690f, 0.10860901f, 0.11788239f, 0.04834606f, -0.04371627f, -0.08013659f, 0.02670522f, 
    -0.18444091f, -0.27956378f, 0.24927440f, -0.09171975f, 0.04774205f, 0.02925460f, -0.04801019f, 0.10741258f, 
    -0.10459459f, 0.05187274f, -0.13456702f, 0.01564693f, -0.03125002f, -0.03921383f, 0.07762089f, 0.01073523f, 
    0.10276308f, 0.10739894f, -0.13399431f, 0.00126365f, 0.02768230f, 0.16558191f, -0.02870468f, -0.09205781f, 
    0.06723185f, 0.08983296f, -0.05355706f, -0.00415189f, 0.01713034f, -0.04980687f, 0.03915378f, 0.02264234f, 
    -0.02322854f, 0.12712625f, 0.13497414f, -0.01857222f, 0.05337378f, 0.03268002f, -0.09160312f, 0.11980026f, 
    -0.31512469f, -0.21522282f, -0.05334616f, 0.18859601f, 0.10530330f, 0.12396732f, -0.00707328f, 0.00775039f, 
    0.09245415f, 0.14274696f, 0.10601930f, 0.03446535f, 0.14157689f, 0.10149812f, 0.05907789f, 0.07300099f, 
    0.06116325f, -0.08252451f, 0.00199439f, 0.02918552f, 0.06655942f, -0.04523924f, -0.04563645f, -0.05354291f, 
    -0.07490906f, -0.02610480f, 0.09701528f, -0.15877424f, -0.09238537f, 0.00750052f, 0.00565456f, -0.09508223f, 
    0.11536758f, 0.08783365f, 0.04738026f, 0.01330194f, -0.00572711f, -0.04017590f, 0.03364320f, 0.01258171f, 
    -0.21573168f, 0.24362066f, -0.18489094f, 0.07885225f, -0.04442250f, 0.02463388f, -0.02040913f, 0.06125675f, 
    -0.00451160f, 0.03878159f, 0.03250308f, -0.02990692f, -0.01153210f, 0.03607917f, 0.04707958f, -0.02670087f, 
    0.12997465f, -0.05493804f, 0.05559844f, -0.05368434f, 0.02111356f, 0.29891431f, 0.09832092f, -0.01613895f, 
    0.02513940f, -0.09936884f, 0.02262878f, -0.00377434f, 0.00416247f, 0.00962051f, 0.05734326f, -0.00308109f, 
    0.05825059f, 0.12912118f, 0.04550141f, -0.01832454f, 0.10776086f, -0.02515141f, 0.02059699f, 0.00416196f, 
    -0.17945996f, 0.15568276f, 0.03744993f, 0.02152018f, 0.03649695f, -0.04404180f, -0.04996626f, -0.09368125f, 
    0.05094423f, -0.05020427f, -0.02264582f, -0.02042323f, 0.05255169f, 0.12440697f, 0.03582053f, 0.07107556f, 
    -0.02987614f, 0.02551838f, -0.02505597f, 0.03381037f, 0.17177942f, -0.26791230f, -0.04402184f, 0.01024437f, 
    0.05445648f, -0.11236150f, -0.08032757f, 0.04753505f, -0.11631230f, -0.00372156f, 0.06915265f, 0.10404336f, 
    -0.05926167f, -0.03368046f, 0.01433976f, 0.07726891f, 0.07288247f, 0.11060203f, 0.05451882f, 0.02009281f, 
    0.10531827f, 0.33229563f, 0.09412354f, 0.10618448f, 0.09321281f, -0.08036990f, 0.00384035f, -0.11595457f, 
    -0.04852487f, 0.03332455f, 0.02951755f, -0.00335118f, -0.04301294f, -0.01260359f, 0.06637396f, -0.03889233f, 
    0.02056121f, 0.01494487f, 0.08251042f, 0.08935112f, -0.31003550f, 0.11211318f, 0.09493638f, 0.15317482f, 
    0.04251073f, 0.02717684f, 0.02071728f, -0.01991295f, -0.05428739f, -0.00885964f, 0.19659391f, -0.08258106f, 
    0.03616557f, 0.06542601f, -0.02271883f, -0.10304225f, -0.04451983f, -0.07993772f, 0.04553248f, 0.02418789f, 
    -0.15428965f, 0.28066847f, 0.05979089f, 0.00832882f, 0.11083864f, 0.01465484f, 0.19653055f, 0.14053367f, 
    -0.01496072f, 0.17550126f, -0.07556655f, 0.09451581f, 0.03629785f, 0.03056896f, 0.11082127f, 0.07247739f, 
    0.09725150f, 0.00816056f, 0.00905296f, -0.09022249f, 0.15558645f, -0.02151936f, -0.16870236f, 0.07464945f, 
    -0.02910141f, 0.08280816f, -0.04809374f, -0.01458552f, 0.07253122f, 0.01262115f, -0.02335063f, 0.06622781f, 
    -0.15520500f, -0.02396116f, -0.01915668f, -0.04578878f, -0.13380340f, -0.10932134f, 0.11331820f, -0.02416418f, 
    -0.12505810f, -0.09699134f, 0.06333949f, 0.09859088f, -0.20988958f, -0.13539083f, -0.20074773f, 0.07828344f, 
    -0.10883082f, -0.11929212f, -0.02228138f, -0.02784315f, -0.06067770f, 0.01210323f, 0.00038881f, 0.06089879f, 
    -0.00711779f, 0.09080372f, -0.03275029f, 0.05346838f, 0.04831560f, -0.15377688f, -0.03059124f, -0.10961563f, 
    -0.01162906f, 0.11429614f, -0.06780899f, -0.06343707f, 0.07971081f, -0.09986233f, 0.07416048f, -0.14389265f, 
    0.05492326f, 0.11999824f, -0.09768000f, -0.01432651f, -0.02837370f, 0.06456371f, 0.05202167f, -0.04070553f, 
    0.40501010f, 0.36221081f, 0.22756942f, 0.10645998f, 0.08726220f, 0.05687904f, 0.08926637f, 0.14738347f, 
    0.01526155f, 0.16369501f, -0.00725840f, 0.06700052f, 0.18808642f, 0.07183556f, 0.01251428f, -0.06763368f, 
    -0.00228125f, 0.06084239f, -0.01466800f, -0.08741124f, -0.15056713f, -0.12169308f, -0.15901124f, -0.12433005f, 
    -0.17880337f, 0.03958893f, 0.10495363f, -0.11864054f, -0.12452514f, 0.07192424f, 0.09025174f, 0.03202518f, 
    0.05442674f, 0.03817619f, 0.09246456f, 0.02088938f, 0.03255833f, 0.09962086f, 0.08645282f, 0.04355804f, 
    -0.25813171f, -0.06942952f, -0.31528449f, 0.09818283f, 0.09645199f, 0.17878658f, 0.10214733f, -0.11056313f, 
    0.15091012f, 0.09909736f, -0.04582951f, -0.14808638f, -0.04384675f, 0.01519033f, -0.02576096f, 0.06745307f, 
    0.08168879f, -0.05237550f, 0.11512215f, -0.10964344f, 0.04391328f, -0.13915342f, -0.16723169f, -0.06397803f, 
    -0.08524573f, 0.02326736f, 0.11400133f, -0.04120738f, -0.02219846f, -0.03738609f, 0.03871483f, 0.06119811f, 
    -0.02166968f, -0.01059100f, -0.07589255f, -0.02257238f, -0.03886765f, 0.17275515f, 0.06331591f, 0.12370072f, 
    -0.11569891f, 0.31067991f, 0.41661450f, 0.35414413f, 0.02625647f, -0.13066420f, -0.16975859f, 0.05207722f, 
    -0.17410716f, -0.06695336f, -0.07295748f, 0.07006353f, 0.02447197f, 0.05749181f, 0.10387520f, 0.01993981f, 
    0.03834262f, -0.11700986f, 0.01884291f, 0.08918209f, 0.27357051f, 0.34988749f, 0.31441334f, 0.22026995f, 
    0.15961358f, 0.14141975f, 0.01383874f, 0.02665903f, -0.02014142f, 0.08162219f, -0.01070795f, 0.07516582f, 
    0.04791537f, 0.13646999f, 0.08253112f, -0.03078043f, 0.02955735f, 0.00337733f, -0.00633995f, -0.14110298f, 
    -0.37771541f, -0.26649600f, -0.09905569f, -0.22429010f, 0.02534577f, 0.09941107f, 0.01613531f, -0.01259041f, 
    0.03260636f, 0.04235948f, 0.01039510f, -0.00672773f, -0.08917900f, 0.00037129f, 0.00318290f, 0.06657253f, 
    0.04351078f, 0.07205302f, -0.04518827f, 0.14877447f, -0.29344621f, -0.24073966f, -0.07741956f, -0.25946298f, 
    -0.02927957f, 0.18393216f, 0.10635981f, -0.01984780f, -0.07634243f, -0.01816003f, 0.11912721f, -0.05647387f, 
    -0.10271948f, -0.03740260f, -0.12163989f, -0.06205389f, 0.08569682f, -0.00911549f, 0.13702360f, 0.16721301f, 
    -0.17285703f, -0.15325049f, -0.04387361f, -0.05481870f, -0.07786458f, 0.12189078f, -0.00231593f, 0.02363239f, 
    0.01995287f, -0.04566024f, 0.04514473f, 0.01596100f, -0.06257182f, -0.00935971f, -0.05430296f, 0.08909499f, 
    -0.02543993f, 0.14249691f, 0.08071508f, -0.00874061f, -0.29089937f, -0.00824871f, -0.25452754f, 0.15671930f, 
    0.30909821f, 0.14074638f, 0.09725837f, 0.09218302f, 0.08201482f, 0.04408913f, 0.01275567f, -0.16969292f, 
    0.11209989f, 0.08433791f, 0.02757720f, 0.12581442f, -0.08587836f, -0.10103378f, 0.00386249f, -0.05146695f, 
    -0.23100318f, -0.14085759f, -0.15619743f, -0.05349144f, -0.00345506f, 0.02070298f, -0.01536644f, -0.04642139f, 
    0.00715570f, -0.08266346f, -0.05088788f, 0.02409338f, 0.09551406f, -0.03440161f, 0.01972284f, -0.14369833f, 
    -0.00673886f, 0.09077436f, 0.06469832f, 0.15853660f, -0.15231012f, 0.34339496f, 0.30510658f, -0.09516630f, 
    -0.06220610f, 0.13644722f, 0.11349627f, 0.09147941f, -0.09411396f, 0.03203753f, 0.09553090f, -0.01671476f, 
    0.00332578f, 0.02411345f, -0.01117870f, 0.06068369f, 0.05970379f, -0.02323775f, -0.04256985f, 0.09625487f, 
    -0.04965710f, -0.03571608f, -0.05251583f, -0.04104992f, -0.04264065f, 0.01862669f, -0.01399975f, 0.00728640f, 
    -0.05324496f, -0.05145527f, -0.04165690f, -0.04121067f, 0.03607637f, 0.02131187f, 0.02693363f, 0.00709672f, 
    0.01882229f, -0.01027729f, -0.06243565f, -0.04203184f, 0.04526368f, -0.00478512f, -0.03642257f, -0.05386081f, 
    -0.03757014f, 0.03723354f, 0.00026480f, -0.02086020f, 0.02285062f, -0.03569270f, -0.02579257f, 0.00686135f, 
    0.00020380f, 0.01107315f, -0.00248835f, 0.00200716f, -0.03452475f, -0.03505433f, 0.02484467f, 0.00060173f, 
    0.01448549f, -0.05401525f, 0.02164990f, 0.03360247f, -0.05212569f, -0.00495526f, 0.02824188f, -0.01981284f, 
    0.03866770f, 0.02546206f, -0.03383214f, -0.00649822f, -0.05482202f, -0.06152108f, 0.04271337f, 0.01815869f, 
    -0.02999363f, -0.02787685f, -0.01012714f, -0.00789990f, -0.05910221f, -0.00982779f, -0.03335867f, 0.03286844f, 
    0.04006611f, -0.04267710f, 0.00636472f, 0.01303100f, -0.01904586f, -0.04648367f, 0.00739539f, 0.03676395f, 
    -0.02174164f, -0.00736968f, -0.01568945f, 0.04011397f, 0.02419427f, -0.05919417f, 0.03891470f, 0.01085799f, 
    0.03263547f, -0.01484205f, -0.04161476f, -0.00698388f, -0.03249902f, -0.03887898f, -0.00909671f, 0.04567748f, 
    -0.03410180f, 0.04842434f, 0.01660324f, -0.02557277f, 0.00204869f, -0.04518600f, -0.00503711f, -0.04750238f, 
    -0.05320251f, 0.01187576f, -0.03254816f, 0.03480020f, 0.03579872f, -0.00724917f, 0.02465750f, -0.04732056f, 
    -0.01365431f, -0.00055766f, 0.02106119f, -0.01108387f, 0.03726106f, 0.01858026f, -0.00582744f, -0.00007860f, 
    0.00459247f, -0.03282532f, 0.01542006f, -0.01143568f, -0.04182801f, 0.04557252f, -0.02785915f, -0.02702969f, 
    -0.06242120f, 0.03541011f, -0.03316526f, 0.04454790f, -0.04413190f, 0.02564266f, -0.03067029f, -0.03071706f, 
    0.02327459f, -0.02199317f, -0.03815331f, -0.04583086f, -0.00114974f, 0.03861900f, -0.04522374f, -0.04214448f, 
    -0.02394977f, 0.02463460f, -0.03786990f, -0.04284864f, 0.04564492f, 0.03779806f, -0.03698442f, 0.00452989f, 
    0.02956215f, -0.01582387f, -0.00612437f, 0.00494488f, -0.03947673f, -0.01065640f, -0.05345772f, 0.03531874f, 
    -0.03316128f, -0.01516271f, -0.01451918f, 0.03889049f, 0.02311544f, 0.00622617f, -0.00372299f, 0.02085463f, 
    0.03505811f, 0.02365452f, 0.01453372f, -0.01292536f, -0.04750050f, 0.00713512f, -0.05613748f, 0.04457527f, 
    0.03927530f, -0.05119042f, -0.02708683f, -0.04239405f, 0.00509931f, 0.00514228f, -0.00215003f, -0.04419762f, 
    -0.04428710f, 0.04098384f, -0.05655609f, 0.01612460f, 0.03571379f, -0.02918759f, -0.00073518f, 0.03161255f, 
    0.04659908f, 0.01628151f, -0.00533860f, -0.01334400f, -0.03558865f, 0.04536240f, -0.03133982f, 0.04448313f, 
    0.01530039f, 0.03773867f, -0.04529272f, -0.00663088f, -0.02702613f, 0.03867434f, -0.04837608f, -0.04320908f, 
    0.01123803f, -0.02826375f, 0.03890243f, -0.01350544f, 0.00294400f, -0.05150657f, 0.02456529f, 0.03931811f, 
    0.04640355f, -0.03522715f, 0.04200174f, -0.04568702f, -0.01511489f, -0.02086076f, 0.00937916f, -0.04961005f, 
    0.04743531f, 0.01992836f, -0.02034745f, 0.03260761f, -0.05294798f, 0.01589687f, -0.03036976f, 0.04378260f, 
    0.02349422f, -0.03655689f, 0.02168858f, 0.03351944f, 0.04520301f, 0.05335081f, 0.02260392f, 0.02787841f, 
    0.02231551f, 0.00368073f, 0.04278229f, 0.02024042f, 0.02902589f, -0.04144636f, 0.01456762f, -0.04328930f, 
    0.01819900f, 0.00830496f, 0.01621222f, -0.03484545f, -0.01826327f, -0.00548961f, -0.04138327f, -0.01890321f, 
    -0.05634198f, -0.00721902f, 0.03178894f, -0.05318702f, -0.03419453f, -0.00919346f, -0.05331415f, 0.03198410f, 
    -0.03543751f, -0.04505704f, -0.02756651f, 0.01876850f, 0.04608873f, -0.01783499f, -0.02419470f, -0.02188711f, 
    0.02865219f, 0.04012475f, -0.00401305f, -0.01797972f, -0.05832275f, 0.03766312f, -0.00919264f, -0.01941164f, 
    -0.04541692f, 0.04843916f, -0.05609771f, -0.01317084f, 0.03128698f, 0.02763361f, 0.02631385f, -0.00227321f, 
    0.02711964f, 0.01288530f, -0.03005516f, -0.00700072f, -0.02076292f, -0.00729394f, 0.04028252f, -0.03789303f, 
    0.00333339f, 0.00355092f, -0.04852917f, 0.04143686f, 0.04546400f, 0.04840780f, -0.04834023f, 0.01093522f, 
    0.05155200f, -0.02666035f, -0.05087536f, -0.03443459f, -0.01592378f, 0.02915699f, -0.01817152f, 0.03764664f, 
    0.03634537f, 0.04383690f, -0.00184026f, 0.01398385f, -0.03910366f, 0.04208927f, 0.04000163f, -0.03237728f, 
    -0.05736597f, -0.05577113f, 0.05087914f, -0.04476016f, 0.00244919f, -0.01403750f, 0.01921297f, -0.04262324f, 
    0.12101417f, -0.02352498f, 0.11863513f, 0.29013640f, -0.09483168f, -0.07513665f, -0.05227090f, 0.04127077f, 
    0.00499974f, -0.01904747f, -0.07157795f, -0.01180062f, -0.09320525f, -0.01043805f, 0.00385813f, -0.10722699f, 
    -0.06663073f, 0.03634104f, 0.07251565f, -0.01039042f, 0.08577664f, -0.02005174f, 0.16320626f, 0.04367760f, 
    -0.08435562f, -0.08617776f, 0.02748710f, 0.08217850f, -0.02086626f, -0.12845509f, 0.05023886f, 0.00263453f, 
    -0.00073614f, -0.02198455f, 0.08983221f, -0.05071516f, 0.08978128f, 0.07877698f, -0.07462286f, -0.06712259f, 
    0.12661509f, -0.06863629f, 0.01785216f, 0.09886397f, 0.17998150f, 0.01201331f, 0.07900722f, -0.05929735f, 
    0.14530946f, 0.08316187f, 0.02241107f, 0.00522201f, 0.14143549f, -0.03069543f, -0.02298714f, 0.03913629f, 
    0.10034142f, -0.06500001f, 0.12461746f, 0.06205611f, -0.06340210f, -0.05656536f, -0.00150099f, -0.00724519f, 
    0.12158739f, 0.04358337f, 0.02674113f, 0.11943564f, -0.10779377f, -0.12375512f, 0.10908187f, 0.03190922f, 
    -0.01265787f, -0.01149585f, -0.03200696f, 0.06280742f, 0.06398965f, -0.05065796f, 0.04244335f, 0.10750845f, 
    -0.26266912f, 0.29421890f, -0.02511352f, 0.14529733f, 0.13495941f, 0.04464260f, 0.00109403f, 0.01579662f, 
    0.00456530f, 0.05733534f, 0.04439203f, 0.07419560f, -0.06213155f, 0.04832887f, 0.03342701f, -0.03639733f, 
    -0.04755148f, 0.00301459f, 0.13779929f, -0.02996300f, 0.11273568f, 0.13524292f, 0.08439600f, 0.09091689f, 
    -0.12398756f, 0.05321088f, 0.06917447f, -0.01037798f, 0.00509926f, 0.01969455f, -0.03210191f, 0.04983842f, 
    -0.03788803f, -0.18893301f, 0.14029719f, -0.01876956f, -0.05089066f, 0.03213765f, 0.06724325f, -0.02591003f, 
    -0.40016693f, -0.10834902f, -0.01181586f, -0.27934250f, -0.02339969f, -0.00566221f, -0.09271912f, 0.04395314f, 
    -0.11872163f, 0.00659590f, -0.07411090f, -0.06149421f, 0.02379563f, 0.04244626f, -0.00921729f, 0.00021990f, 
    -0.01455875f, -0.05109150f, 0.07392500f, 0.02348249f, -0.32105747f, 0.10528597f, 0.07146086f, -0.07627985f, 
    0.03129872f, 0.00511617f, -0.01287125f, 0.01196044f, -0.01093013f, 0.01803351f, 0.03075454f, 0.04519314f, 
    -0.06751765f, 0.12031473f, 0.07608995f, 0.04087845f, 0.03905625f, -0.01610463f, -0.01530058f, 0.07066728f, 
    0.10789090f, 0.44660053f, -0.01440767f, 0.24805090f, 0.08645691f, 0.09055618f, -0.00156640f, 0.03886800f, 
    0.09479319f, -0.01666550f, -0.04568846f, -0.01989199f, -0.02601444f, -0.03531901f, 0.09815604f, 0.08504537f, 
    -0.10053249f, 0.01823471f, 0.06087165f, -0.00025441f, 0.03516020f, -0.00557956f, 0.05987516f, 0.09392310f, 
    0.20148985f, -0.06784527f, -0.07446987f, -0.11921845f, -0.04219485f, 0.02271413f, -0.08301741f, -0.07442844f, 
    -0.03601800f, 0.00560737f, 0.14762999f, 0.04914795f, -0.02101396f, -0.03298052f, -0.05707769f, -0.03041059f, 
    0.23749362f, -0.16867970f, -0.10306815f, -0.16101314f, 0.07676382f, -0.14374183f, 0.07005982f, -0.05745099f, 
    0.00822007f, -0.16625467f, 0.00399962f, 0.07058275f, -0.00264727f, 0.03306246f, 0.06384543f, 0.05344034f, 
    -0.02094013f, -0.00778005f, -0.14218250f, 0.07134840f, -0.04413648f, -0.05810488f, -0.04208877f, -0.23994076f, 
    -0.04814975f, 0.00069956f, -0.01750223f, -0.06954799f, 0.04500820f, -0.01702783f, 0.04997794f, 0.07489593f, 
    -0.06635235f, 0.02467490f, 0.06758451f, -0.03719797f, -0.05421652f, 0.02828004f, -0.03202332f, -0.00672876f, 
    0.00252349f, 0.07650311f, 0.05122786f, 0.01537469f, -0.12490173f, 0.08860399f, -0.09648781f, 0.02022660f, 
    -0.02167292f, -0.03200094f, 0.10326023f, -0.10959479f, 0.04524388f, -0.04092446f, 0.03811026f, 0.03928673f, 
    -0.09944182f, -0.00839620f, -0.16417888f, 0.00646265f, -0.36208040f, -0.07678504f, -0.09311733f, -0.22249426f, 
    -0.04718937f, 0.08073947f, -0.09142449f, 0.15947862f, -0.03390099f, -0.11112408f, 0.00992387f, 0.04628294f, 
    -0.05722132f, 0.02100587f, 0.03928179f, -0.01192549f, -0.10253859f, -0.00561972f, 0.04513442f, 0.01452197f, 
    -0.02901788f, 0.02996460f, 0.06615759f, -0.09856859f, 0.06692737f, 0.05570458f, -0.14480877f, 0.04235564f, 
    -0.04049864f, 0.08278792f, -0.04435685f, 0.01290611f, 0.01711446f, -0.00391598f, 0.03142590f, -0.01065781f, 
    -0.00545673f, 0.17069167f, 0.02718801f, -0.00346315f, 0.04378813f, 0.04916861f, 0.08282381f, 0.11236162f, 
    0.23697750f, -0.03151987f, 0.00219300f, -0.02259385f, 0.05282304f, 0.00506748f, 0.01761917f, 0.05977336f, 
    -0.00234882f, 0.00169121f, 0.17637490f, 0.05481416f, -0.00082878f, 0.07236554f, 0.10535702f, 0.01133946f, 
    0.37088278f, -0.09448000f, 0.10209893f, -0.05367236f, 0.04941730f, -0.07416522f, 0.04531991f, 0.01542353f, 
    -0.13261114f, 0.07571160f, 0.00570145f, -0.03134690f, 0.07035295f, 0.09657736f, -0.05109012f, 0.04333991f, 
    -0.07434425f, -0.00527773f, -0.00220081f, -0.02473444f, 0.04148061f, 0.17908920f, -0.11453929f, -0.03537628f, 
    -0.06737027f, -0.03858133f, 0.27653849f, -0.05821521f, 0.07200578f, 0.02829672f, -0.07653798f, -0.01851514f, 
    -0.02145278f, -0.08158366f, -0.10360630f, 0.05540996f, -0.00117708f, -0.00732786f, 0.21004468f, -0.04284223f, 
    0.06800804f, 0.12620623f, 0.00868127f, -0.07160309f, 0.10377084f, 0.05785111f, -0.00648408f, 0.11471730f, 
    0.11941862f, 0.01317897f, 0.03366653f, 0.12363167f, -0.04247262f, 0.00765018f, -0.04221752f, -0.04915763f, 
    -0.03282719f, 0.01610016f, 0.09841953f, 0.09492273f, 0.43438074f, -0.19315264f, -0.12233023f, -0.08206970f, 
    -0.03565104f, 0.05632605f, -0.07303685f, 0.09464275f, 0.18815146f, 0.06848050f, -0.11266717f, 0.01591263f, 
    0.00131631f, 0.16584827f, 0.01348193f, 0.10227455f, 0.05505278f, 0.07921102f, 0.03346307f, 0.12712124f, 
    -0.01985094f, 0.14101560f, -0.11453965f, 0.00097663f, -0.13389285f, 0.14153379f, 0.06926116f, -0.00172298f, 
    0.02077144f, -0.08102583f, 0.01437250f, 0.06976790f, 0.06056426f, 0.03528825f, -0.04538693f, 0.07878248f, 
    0.02015513f, -0.10641276f, -0.05981171f, -0.04169898f, -0.15964082f, -0.00826499f, 0.03440943f, 0.05379059f, 
    0.07091260f, -0.07958192f, -0.02261251f, 0.00579694f, 0.07455516f, -0.10226870f, 0.05229870f, -0.04277111f, 
    -0.02874422f, 0.06067659f, -0.04253506f, -0.11724094f, -0.00660988f, -0.04001188f, 0.06335877f, -0.20535108f, 
    0.44994417f, -0.00151802f, 0.11251336f, 0.08545858f, -0.11391410f, -0.18839756f, -0.09106695f, -0.02102191f, 
    -0.07842863f, -0.01668623f, 0.00318134f, 0.01395689f, 0.02235110f, 0.00965833f, 0.06748617f, 0.01779739f, 
    -0.03918124f, -0.07531829f, -0.01366102f, 0.12178617f, -0.07106158f, -0.06208742f, 0.04383180f, 0.00330579f, 
    -0.11943620f, -0.01993532f, 0.07113992f, 0.00369861f, -0.00832526f, 0.08020017f, -0.07113968f, -0.03838747f, 
    0.05852259f, -0.14164332f, -0.03418240f, 0.06385960f, 0.14663503f, -0.05060342f, 0.07620779f, 0.04695132f, 
    0.55698258f, 0.24520826f, -0.23369633f, -0.22928910f, -0.09019613f, 0.11339260f, 0.04017705f, -0.00607102f, 
    -0.03319881f, -0.10110106f, 0.01639675f, 0.01220701f, 0.01906932f, -0.00793897f, -0.11815418f, 0.01008864f, 
    0.12345889f, -0.00574975f, -0.10233875f, -0.00580552f, -0.03252278f, 0.05985912f, 0.02653460f, 0.02678903f, 
    -0.07848907f, 0.06425309f, -0.08756299f, 0.00746862f, 0.05618342f, 0.02943810f, -0.07785843f, -0.01051105f, 
    0.02048035f, 0.03125328f, -0.04702394f, -0.08627819f, -0.07330724f, -0.03474375f, 0.01161312f, -0.02684966f, 
    0.43667212f, -0.32609630f, 0.05410370f, 0.08581784f, 0.07445435f, 0.09771939f, -0.04657447f, -0.07419141f, 
    0.04311407f, 0.04480988f, 0.02030397f, 0.04969794f, -0.05032166f, -0.01863297f, -0.01693577f, -0.02018723f, 
    -0.01994444f, -0.04724269f, -0.04803688f, -0.08866221f, 0.15616931f, 0.02734293f, -0.04187981f, 0.01307608f, 
    -0.01573652f, -0.01283796f, -0.07860314f, -0.03594514f, -0.01493370f, -0.01994717f, -0.08181127f, -0.08842228f, 
    -0.04243924f, 0.04182533f, -0.04821338f, -0.01034708f, -0.00977254f, 0.09358773f, 0.09571061f, -0.04890694f, 
    0.38455880f, -0.18632112f, -0.04547257f, 0.04059787f, 0.09057420f, -0.05524389f, 0.10759724f, 0.08061714f, 
    -0.00021198f, 0.08548613f, -0.00464595f, -0.06575777f, 0.01968290f, -0.03110558f, -0.03593346f, 0.03534155f, 
    0.05865673f, 0.06386956f, 0.08998682f, 0.07543440f, 0.27957222f, -0.11499941f, -0.01060883f, 0.04030436f, 
    -0.21678977f, 0.04527882f, -0.07878365f, -0.06497992f, 0.12503567f, 0.04280094f, 0.01153528f, -0.00446397f, 
    0.04099344f, -0.05032372f, 0.09091223f, 0.04455715f, -0.07376123f, -0.02969035f, -0.04669873f, 0.02574821f, 
    -0.05937518f, 0.06081226f, -0.02203782f, -0.29664546f, 0.05301991f, -0.13289823f, 0.05510530f, 0.01305051f, 
    -0.02690822f, -0.10378189f, -0.09717330f, -0.02685314f, -0.02677800f, 0.00501026f, -0.10392541f, 0.08505584f, 
    0.00885893f, 0.14594448f, 0.07159249f, -0.01878876f, 0.14925404f, -0.16627561f, -0.24409033f, -0.06299370f, 
    0.24233916f, -0.04335015f, 0.05999260f, 0.04759066f, 0.10502353f, 0.15332389f, 0.01390799f, -0.09437384f, 
    0.05346178f, -0.07539659f, -0.03595175f, 0.09508935f, 0.01011148f, -0.08194759f, 0.03713074f, 0.11370395f, 
    -0.04772101f, 0.02109677f, -0.01082709f, -0.00731800f, -0.00186059f, -0.05704019f, -0.03173603f, -0.05522229f, 
    0.02283289f, -0.04168418f, -0.05214795f, -0.01577654f, -0.03365792f, -0.02092766f, -0.00375842f, -0.02942111f, 
    -0.02017209f, 0.04237302f, 0.04151104f, -0.05209823f, 0.01459910f, -0.02101282f, -0.05409195f, -0.01456303f, 
    -0.00463989f, 0.03152382f, -0.04713393f, -0.05611565f, -0.02037198f, -0.04133651f, -0.05098868f, -0.03324982f, 
    -0.00807042f, -0.01717572f, -0.00427428f, -0.03279020f, 0.00756886f, -0.03428747f, -0.01375832f, -0.02128673f, 
    -0.05153137f, 0.01098567f, -0.03927890f, 0.04213648f, -0.00007272f, 0.03509338f, 0.03467999f, -0.05774073f, 
    0.00809646f, 0.02675886f, -0.05446943f, 0.03590586f, -0.01880326f, 0.01703328f, -0.03288334f, -0.05042871f, 
    0.00823663f, -0.05528051f, 0.03507387f, -0.05726462f, 0.03025969f, -0.04274924f, 0.03111885f, 0.04197614f, 
    -0.00453415f, 0.03864719f, 0.01730675f, 0.01377606f, -0.06113027f, -0.05200106f, -0.00652828f, -0.01972478f, 
    0.00397293f, 0.03174924f, -0.02081634f, -0.03856674f, -0.03467990f, -0.03315867f, -0.04441223f, -0.01408197f, 
    -0.03470273f, 0.01594742f, -0.01957808f, -0.00526428f, 0.04339038f, -0.05881079f, -0.03723783f, -0.03658571f, 
    0.02295731f, -0.02775903f, -0.04274574f, 0.04114353f, -0.04518332f, -0.03615654f, -0.03787308f, -0.01584742f, 
    -0.04575787f, 0.02288493f, 0.00457176f, 0.01974478f, 0.01691920f, -0.02117261f, 0.04122793f, 0.02397869f, 
    -0.02011077f, -0.05557691f, -0.04573543f, -0.05963113f, -0.03287054f, -0.00905085f, -0.01745629f, 0.02765917f, 
    0.00619692f, -0.05684168f, -0.05048208f, 0.00369355f, -0.03173268f, -0.04869513f, 0.01860985f, -0.00234375f, 
    0.03685576f, 0.00161776f, 0.03652822f, 0.03351641f, -0.03813683f, 0.00045087f, 0.00987404f, 0.03499026f, 
    0.00505780f, -0.02811109f, 0.04450804f, 0.03756631f, -0.05549239f, 0.03246314f, 0.02141223f, 0.04979869f, 
    -0.01911405f, -0.04905440f, -0.05922881f, 0.03340741f, -0.05479508f, 0.00807519f, 0.01419834f, -0.04023728f, 
    -0.00852933f, -0.03871479f, -0.03455058f, -0.05875460f, 0.04421567f, -0.01875937f, 0.04923633f, -0.05053258f, 
    -0.00161347f, -0.03065111f, -0.01550067f, 0.04233615f, 0.00759889f, 0.02667573f, -0.04297039f, 0.02372845f, 
    0.02159290f, 0.02957342f, -0.03836554f, 0.02679174f, -0.04952408f, 0.03581646f, 0.04977450f, 0.02714699f, 
    0.00714556f, 0.03895142f, 0.01441455f, -0.05314691f, -0.03085100f, 0.00921394f, -0.01365468f, -0.03285866f, 
    -0.04002637f, 0.03228266f, -0.05976925f, 0.01126173f, 0.01171017f, -0.00781736f, -0.03799247f, 0.04122940f, 
    -0.05622294f, -0.04889046f, -0.02553229f, 0.00647744f, -0.03864867f, -0.00236206f, 0.00073298f, 0.03127050f, 
    -0.04783266f, 0.03286027f, -0.00374527f, -0.04546180f, -0.00083094f, 0.00329562f, -0.05215778f, -0.03227128f, 
    -0.04522166f, -0.03057624f, -0.04830502f, 0.01962701f, -0.01822612f, 0.04963070f, 0.04381194f, -0.05747062f, 
    -0.05864163f, -0.01179551f, 0.01496970f, -0.01262299f, -0.02882729f, 0.04381008f, -0.05706568f, -0.04018359f, 
    -0.02445979f, 0.02764758f, 0.03670210f, -0.01026227f, 0.02206388f, -0.01529164f, 0.00537504f, -0.00001113f, 
    -0.00361637f, 0.02794042f, 0.01423326f, 0.00089297f, -0.00010427f, -0.03556961f, -0.02814217f, -0.01207081f, 
    -0.01912645f, 0.02059002f, -0.02266112f, -0.02527938f, 0.04256520f, -0.02521961f, 0.00754572f, 0.02755602f, 
    -0.04993360f, 0.04437512f, -0.05928130f, 0.03397486f, 0.02430456f, 0.01735019f, -0.00188010f, 0.01638033f, 
    0.01852839f, 0.03674343f, -0.03641667f, -0.05356219f, 0.01194057f, 0.00338222f, 0.02590090f, -0.02933302f, 
    0.04561582f, 0.00847642f, 0.04898640f, 0.00703847f, -0.02477520f, -0.01212018f, 0.00038806f, -0.04071632f, 
    0.04249217f, 0.00922874f, -0.02940355f, -0.02329903f, 0.03349399f, 0.03626546f, -0.05017507f, 0.05460805f, 
    -0.03980949f, 0.00089641f, -0.02786903f, -0.00500145f, -0.04090026f, -0.02002543f, 0.03658015f, 0.03234204f, 
    0.01643912f, -0.05838192f, -0.02868070f, -0.02310910f, -0.03554258f, -0.05583682f, 0.00588425f, -0.02277031f, 
    0.01916341f, 0.00624079f, 0.01278443f, -0.01429232f, -0.03299353f, 0.01283260f, -0.00690092f, -0.00197594f, 
    -0.04655820f, -0.00697278f, -0.00424422f, -0.01923417f, -0.01986342f, -0.02432569f, 0.03295723f, -0.01109713f, 
    0.01082251f, -0.04422939f, -0.03352323f, -0.05374476f, 0.03748042f, -0.03764741f, 0.00052692f, -0.01811600f, 
    -0.05762602f, -0.04725234f, 0.04675053f, 0.04002335f, -0.04838539f, -0.00814219f, 0.01982712f, -0.02877621f, 
    -0.01129484f, -0.17180587f, 0.10062122f, -0.07369055f, -0.05919123f, 0.03243834f, 0.00672059f, 0.03722551f, 
    -0.03821008f, 0.02696114f, -0.04280185f, -0.07462371f, 0.00341590f, 0.07870777f, -0.00965663f, 0.00773224f, 
    0.03877008f, -0.09743049f, -0.02537884f, -0.08539786f, 0.10804505f, -0.12188359f, -0.03808250f, 0.01988383f, 
    -0.10556077f, 0.02456579f, -0.06276065f, 0.04520178f, 0.05211988f, 0.12844059f, 0.02268142f, 0.01843132f, 
    -0.04265575f, -0.05896595f, -0.00816845f, 0.04287995f, -0.03074279f, 0.02894458f, 0.12034037f, -0.03738286f, 
    -0.04655536f, -0.06139342f, 0.07418950f, 0.15506391f, -0.11568809f, -0.07478777f, -0.05156855f, 0.00866957f, 
    -0.05504955f, -0.02624816f, -0.05456746f, 0.04677648f, 0.04900823f, 0.07548336f, 0.02030486f, 0.06002265f, 
    0.02353664f, 0.03879923f, 0.01215528f, 0.01434035f, 0.08397628f, -0.23734365f, -0.10566147f, 0.06413332f, 
    -0.12904766f, -0.01674409f, 0.05520907f, -0.01831438f, 0.09563264f, 0.02756591f, -0.07655885f, -0.05831364f, 
    0.03362024f, 0.17024162f, 0.01858140f, 0.17065589f, 0.08803096f, 0.06088781f, 0.00291335f, 0.07546932f, 
    0.21158454f, -0.01830307f, 0.05177581f, 0.03216986f, -0.31203490f, 0.06887250f, 0.06616377f, 0.04014243f, 
    0.06622811f, 0.00367223f, 0.00558823f, 0.11444879f, 0.06331680f, -0.04631080f, -0.02205432f, -0.00053285f, 
    -0.03732824f, -0.01680195f, -0.05486730f, -0.00644191f, 0.06461478f, -0.07182291f, -0.09047280f, -0.11659492f, 
    -0.00364805f, -0.01951892f, 0.05905112f, 0.00597509f, 0.00593997f, 0.01132508f, 0.10113114f, -0.03633220f, 
    0.01008834f, 0.09439886f, -0.00787661f, 0.10685068f, -0.05983936f, 0.03716713f, 0.08512540f, 0.07989611f, 
    0.08328876f, -0.00036614f, -0.32639763f, 0.12404275f, 0.15919523f, -0.03246523f, -0.01028244f, 0.06300833f, 
    0.02953841f, 0.06129132f, -0.04470582f, 0.03555189f, 0.02606006f, -0.01482582f, 0.08454705f, 0.07946324f, 
    0.07875168f, -0.08356599f, -0.00802509f, 0.03085063f, 0.16169095f, -0.16918395f, -0.08449271f, 0.04937696f, 
    0.14623398f, -0.05018312f, 0.05171729f, 0.01850449f, 0.13224353f, 0.03817446f, -0.02128889f, -0.03486689f, 
    0.03140322f, -0.11298283f, -0.02459975f, -0.03132178f, 0.00939172f, 0.01596667f, -0.04560437f, 0.06660308f, 
    0.02608642f, 0.01531696f, 0.38853639f, -0.17457345f, -0.44980136f, 0.02918501f, 0.00458457f, 0.04707614f, 
    -0.07009793f, 0.04824178f, -0.03008331f, -0.05087323f, 0.01256801f, 0.01575548f, -0.06753146f, -0.15627111f, 
    0.08134918f, -0.05737182f, 0.00127869f, 0.08646743f, -0.15924728f, 0.31205061f, 0.13824815f, 0.15246443f, 
    -0.02948794f, 0.22036503f, 0.02959765f, 0.09774315f, 0.13544741f, 0.08107374f, 0.00988295f, -0.09539002f, 
    0.03738911f, -0.00428506f, -0.00945761f, 0.01705186f, -0.07852396f, 0.01451855f, 0.00512124f, -0.07122120f, 
    -0.13696392f, -0.10156143f, -0.12878878f, -0.04443360f, 0.20571709f, 0.08058423f, 0.08688062f, -0.04881342f, 
    -0.08026998f, 0.17340133f, 0.00921434f, 0.00564730f, 0.01715564f, -0.06711132f, 0.05765292f, 0.00630884f, 
    0.08166113f, -0.08309821f, -0.05683069f, 0.04057939f, -0.03826172f, -0.03639002f, -0.04151754f, 0.15729646f, 
    0.10439017f, -0.02356963f, 0.03958602f, 0.03740629f, -0.03560842f, 0.02306785f, 0.04123544f, -0.01074766f, 
    -0.04678027f, -0.01208352f, -0.04667908f, 0.08042599f, 0.02918473f, -0.02139302f, 0.04763732f, 0.02999195f, 
    0.14147967f, -0.05818629f, -0.12753780f, 0.05721242f, 0.17582484f, -0.04106541f, 0.06569557f, 0.13164285f, 
    -0.01667130f, 0.14403822f, 0.06790340f, -0.04517698f, -0.04128707f, 0.06875236f, -0.03503941f, -0.01263314f, 
    0.03823659f, 0.03687442f, 0.08110607f, 0.01602205f, -0.03928997f, -0.13180645f, -0.16054195f, 0.02111783f, 
    -0.03839187f, 0.05479657f, 0.10634508f, 0.03038463f, 0.08417161f, 0.01334509f, 0.01904882f, -0.04959177f, 
    0.07484522f, -0.02208067f, 0.04661912f, 0.02533023f, -0.00163024f, -0.12105817f, -0.13256550f, 0.03788649f, 
    -0.25274912f, -0.00325760f, -0.20672709f, 0.00828617f, 0.08432169f, -0.11029865f, 0.02640927f, 0.14065820f, 
    0.07267676f, 0.04798356f, -0.05540955f, 0.02154825f, 0.08226832f, 0.02888195f, 0.02352539f, 0.04907606f, 
    -0.03646378f, 0.06259844f, 0.12355037f, 0.00507370f, 0.20324659f, 0.13361514f, 0.00058253f, -0.15567298f, 
    0.05981117f, 0.08562916f, 0.02669598f, 0.10120061f, 0.03803013f, 0.11925322f, 0.04528970f, -0.12771387f, 
    0.07898350f, 0.07846528f, 0.04144447f, 0.05934833f, 0.06332979f, 0.03562289f, 0.01654514f, 0.07007556f, 
    -0.12327447f, 0.30991012f, -0.00246643f, -0.18496145f, 0.23024291f, -0.05656907f, 0.14175315f, -0.04268675f, 
    -0.00693368f, 0.02925397f, 0.02007500f, 0.06564739f, 0.00359683f, -0.07999565f, 0.06398816f, 0.04154667f, 
    0.06077045f, -0.07221995f, 0.05015182f, 0.04998465f, -0.20156306f, 0.22570802f, -0.16318037f, 0.07716358f, 
    -0.04333242f, 0.13168041f, 0.04314788f, 0.03188034f, 0.09897935f, -0.10128792f, -0.10777120f, -0.01752854f, 
    -0.17804269f, 0.00614452f, -0.11767787f, -0.02817917f, -0.06878416f, 0.01116758f, 0.14547473f, 0.00278997f, 
    0.35934722f, -0.52576065f, -0.09369837f, -0.12782352f, -0.09694802f, -0.03918510f, -0.02734651f, 0.21495946f, 
    0.02849611f, -0.05310969f, -0.02424762f, 0.00330029f, -0.06301924f, 0.00662159f, 0.01771711f, -0.02179913f, 
    -0.04602727f, 0.04070878f, 0.00171116f, 0.01631501f, 0.42307088f, -0.06603608f, -0.03402423f, -0.11021338f, 
    -0.05517478f, -0.01379491f, -0.02258799f, 0.05250056f, -0.04838472f, 0.02381570f, 0.00326817f, -0.01328440f, 
    0.02386270f, -0.04798607f, 0.09557024f, 0.00479269f, 0.02661949f, -0.02007025f, 0.07992433f, 0.04473842f, 
    -0.08654398f, -0.03474957f, -0.18424034f, 0.08515479f, 0.28519830f, 0.07729086f, 0.10402694f, 0.13476847f, 
    -0.01435633f, 0.03243310f, -0.06074417f, -0.05959184f, -0.05701800f, 0.07142277f, -0.06331472f, -0.03064384f, 
    0.11265390f, 0.04400444f, -0.04818874f, 0.04214775f, -0.08725832f, -0.01433188f, 0.01645463f, 0.00207261f, 
    -0.16970766f, -0.02921158f, 0.04645380f, -0.02098701f, -0.06005251f, -0.00710564f, 0.10410972f, -0.03959396f, 
    -0.00264652f, 0.05808124f, 0.03359835f, -0.02085000f, 0.03380834f, -0.07987768f, 0.04464183f, -0.13801086f, 
    0.43784302f, -0.13185483f, -0.12838008f, 0.22431630f, -0.15185776f, -0.07644705f, -0.09420552f, 0.03262771f, 
    0.05209799f, 0.11282755f, -0.10977262f, 0.09042250f, 0.04482821f, 0.03089906f, -0.01112317f, -0.05525117f, 
    -0.00693790f, -0.01805912f, -0.07045070f, -0.07103951f, 0.15049496f, 0.05425049f, -0.17267968f, -0.08080980f, 
    -0.12721632f, 0.00584355f, 0.04627941f, 0.04644794f, 0.03136167f, 0.00746022f, -0.02539758f, 0.08807246f, 
    -0.00018376f, -0.01158027f, -0.05826057f, -0.00742412f, -0.00061582f, 0.00467419f, 0.09945688f, 0.00502499f, 
    -0.42703137f, 0.09267821f, -0.22455569f, 0.20874850f, 0.36842209f, 0.09838310f, 0.07204731f, 0.07387667f, 
    0.02194033f, 0.00361238f, -0.07688353f, -0.02213933f, 0.01680283f, -0.00102187f, -0.01366083f, -0.06194255f, 
    0.14789069f, -0.04606042f, -0.06257149f, 0.02613481f, -0.01302282f, -0.17478330f, 0.07122766f, 0.05419555f, 
    0.05651172f, -0.03116518f, -0.11165766f, -0.03402628f, 0.09983751f, -0.01343222f, -0.10576797f, -0.08556392f, 
    -0.03197315f, 0.01961747f, -0.07031379f, 0.06834327f, 0.08209032f, -0.03213296f, 0.06389773f, -0.01898761f, 
    0.07289714f, 0.05211770f, -0.10313427f, 0.04055827f, -0.19892338f, 0.08976299f, -0.21220437f, -0.05452808f, 
    0.13493745f, 0.07407496f, 0.15370160f, -0.03022223f, 0.02559695f, -0.03065196f, -0.00553471f, 0.02823110f, 
    -0.00028197f, 0.04700827f, 0.07739167f, 0.00068982f, 0.15947713f, 0.21581751f, -0.14637086f, -0.06871844f, 
    -0.10785223f, 0.11403552f, -0.13735932f, -0.03453677f, 0.09669662f, 0.03867459f, -0.01111482f, -0.07831273f, 
    0.02114546f, 0.04893023f, -0.01305460f, 0.02680030f, 0.02932479f, -0.07055864f, 0.02857299f, 0.05826233f, 
    0.20555048f, -0.00676924f, -0.06765610f, 0.08121722f, -0.17934217f, -0.13482207f, -0.01651824f, -0.14317514f, 
    0.02956730f, 0.08563757f, -0.02183834f, 0.08220086f, 0.08319155f, 0.03146785f, -0.02602138f, 0.02091387f, 
    0.06334606f, 0.09539049f, 0.00687028f, 0.06697623f, 0.32160488f, 0.00047046f, -0.01252385f, 0.03877494f, 
    0.01148068f, -0.06023441f, -0.11450712f, -0.04274965f, 0.04273756f, 0.04067935f, -0.03628511f, -0.00158599f, 
    0.06850339f, 0.04383700f, 0.04267408f, 0.02024845f, -0.00831693f, -0.02045613f, 0.02941655f, 0.08534763f, 
    0.10278588f, -0.13282715f, 0.06062794f, 0.05268732f, -0.29761705f, 0.06718828f, 0.06322245f, -0.00826158f, 
    0.05664736f, 0.04651515f, 0.00367655f, 0.09722659f, 0.05730561f, 0.07173135f, -0.08265901f, -0.07565903f, 
    -0.00613135f, 0.08026157f, -0.00633309f, 0.10970597f, -0.21117729f, 0.03691539f, 0.04212023f, -0.07675279f, 
    -0.03725236f, 0.08270594f, 0.21687475f, 0.03587022f, -0.05144835f, 0.05699875f, 0.08572127f, -0.00908883f, 
    -0.11900682f, -0.06268850f, -0.08074040f, -0.03811595f, 0.00612959f, -0.02283389f, 0.03140454f, 0.05746428f, 
    -0.03986116f, -0.05629706f, -0.02229987f, 0.01388309f, -0.05907128f, -0.05793681f, -0.02044329f, -0.04641674f, 
    -0.05502149f, 0.04184585f, -0.01630649f, -0.04300451f, -0.01647208f, -0.02975247f, -0.04130781f, -0.02102147f, 
    0.01791832f, 0.02624582f, -0.05955333f, 0.03940529f, -0.03801666f, -0.05959659f, 0.00665881f, -0.01067117f, 
    -0.03121290f, -0.00759307f, -0.00169363f, -0.04215055f, 0.03668586f, -0.00648152f, 0.04939264f, -0.05460643f, 
    -0.03821926f, 0.01706764f, -0.04610297f, -0.04840615f, 0.01081908f, 0.01523673f, 0.01060800f, 0.00519980f, 
    -0.05503029f, 0.01940097f, -0.00780274f, -0.03735010f, -0.02690426f, 0.01582782f, 0.02386932f, -0.04026211f, 
    0.00698535f, 0.03579070f, -0.04426508f, -0.03783946f, -0.06036933f, -0.03519542f, -0.02727833f, -0.00244823f, 
    -0.04727616f, -0.01826435f, -0.03232031f, -0.05284273f, 0.01365491f, -0.01677926f, -0.00036936f, 0.00998022f, 
    0.01216777f, -0.04499556f, -0.03250592f, 0.00959172f, 0.04653879f, 0.04670073f, -0.03601468f, -0.04271817f, 
    -0.03285703f, 0.02492175f, 0.03836437f, -0.02961055f, -0.02141999f, -0.00501171f, -0.00622601f, 0.02304402f, 
    0.02273638f, 0.01903200f, -0.05734029f, 0.00691190f, -0.03832626f, -0.03492041f, 0.00357544f, -0.01116409f, 
    -0.03719232f, 0.03035687f, 0.01252271f, 0.02016792f, 0.00775340f, 0.01558745f, -0.02000200f, 0.00342238f, 
    0.02946591f, -0.01826356f, -0.03328289f, 0.01402693f, -0.00819673f, -0.01808380f, 0.02033177f, 0.01975819f, 
    0.05115804f, -0.00341266f, 0.00241237f, 0.00616771f, 0.04586662f, -0.04725457f, -0.01681023f, 0.00078562f, 
    0.03167413f, -0.01953991f, 0.04287852f, -0.01306573f, -0.02377410f, -0.05871193f, 0.01947649f, -0.00032424f, 
    0.04647000f, 0.02305602f, -0.06270599f, -0.05841346f, 0.01745429f, -0.01204086f, -0.02999294f, -0.00109763f, 
    0.01036782f, -0.02934830f, -0.01900879f, -0.01891441f, -0.03414335f, -0.00506863f, -0.00740296f, -0.01790467f, 
    0.03717467f, -0.06728087f, -0.04359628f, 0.01152830f, 0.02257475f, -0.04914036f, 0.01951308f, 0.00391928f, 
    -0.02260226f, -0.05534707f, 0.03682501f, 0.01258619f, -0.04962953f, 0.01165645f, 0.02511666f, -0.00038825f, 
    -0.05235300f, 0.04206283f, 0.01256715f, -0.05739602f, -0.03522791f, 0.00803216f, 0.03092744f, -0.05422192f, 
    -0.01262796f, -0.01937700f, 0.01503838f, -0.00052882f, -0.02320425f, 0.03928817f, 0.02590378f, 0.00996239f, 
    0.02011919f, -0.06507456f, -0.00956087f, -0.01765705f, 0.00072627f, 0.01267318f, -0.01491774f, 0.01640398f, 
    0.01042965f, -0.05751317f, -0.00489865f, 0.03253717f, -0.04413490f, -0.06066369f, 0.02279945f, -0.02337584f, 
    0.03459381f, 0.00614860f, 0.04306916f, 0.04464660f, 0.04571515f, 0.04768775f, -0.01573415f, 0.00466754f, 
    -0.04210555f, 0.02956324f, -0.03230586f, 0.03998275f, 0.01262200f, -0.03691506f, 0.02550673f, 0.01388416f, 
    -0.00255360f, -0.02824928f, 0.00557257f, -0.04922819f, 0.01003850f, -0.01191951f, -0.03380652f, 0.00067402f, 
    -0.05855653f, 0.02895840f, -0.03706888f, 0.02521077f, -0.03489533f, -0.03471603f, 0.02051557f, 0.00295567f, 
    0.02878566f, -0.04410193f, -0.03737725f, -0.02606890f, 0.02114161f, -0.05654307f, 0.00871214f, 0.01149946f, 
    -0.00845716f, -0.04878327f, -0.01444910f, -0.04345206f, -0.03123249f, 0.04251250f, -0.04128707f, -0.04431336f, 
    0.04186143f, -0.01216677f, -0.00889871f, 0.04271445f, -0.03287189f, -0.05118392f, -0.00862184f, -0.01596196f, 
    -0.04140817f, -0.00669163f, 0.00602093f, 0.01528652f, -0.01344217f, 0.04143654f, 0.05106496f, -0.04958212f, 
    0.04762365f, 0.01288058f, -0.03956757f, -0.01763752f, 0.03937313f, 0.03180709f, -0.02936510f, 0.02735939f, 
    -0.00984200f, 0.00928469f, -0.01779615f, -0.00706658f, 0.01858912f, -0.05707055f, 0.04143657f, 0.01465057f, 
    0.03339013f, 0.01922419f, 0.00573347f, -0.03548316f, 0.03366589f, -0.00721112f, -0.03231469f, -0.04589792f, 
    0.03406901f, 0.00465241f, -0.00750074f, -0.04341794f, -0.00742232f, -0.04248534f, 0.04315552f, -0.02669069f, 
    -0.03176811f, 0.01801416f, 0.01372350f, -0.02003195f, 0.04017781f, 0.00167377f, -0.02951351f, -0.04088466f, 
    -0.02733673f, 0.00353341f, -0.06155839f, -0.01410080f, 0.03083291f, 0.02083702f, 0.02905739f, -0.01808387f, 
    0.04860840f, 0.00572734f, 0.05336307f, 0.02808745f, -0.04937806f, 0.04767358f, -0.03430672f, -0.04922862f, 
    -0.02487947f, 0.02718111f, 0.00831086f, 0.01156857f, -0.01092510f, 0.01852931f, -0.00920575f, 0.00944879f, 
    -0.05590723f, 0.01775740f, 0.03471109f, 0.02378423f, 0.00660076f, -0.00187760f, -0.00058459f, 0.04559303f, 
    0.12763071f, -0.18365692f, -0.08150022f, 0.03113496f, -0.05842967f, 0.12867811f, -0.06826142f, 0.01478812f, 
    0.03917956f, -0.07421494f, 0.01899944f, 0.04065372f, -0.07313573f, -0.02361939f, -0.01702081f, 0.01825115f, 
    0.08951601f, -0.01439418f, -0.11923924f, -0.00111475f, 0.34964940f, -0.14840472f, 0.14220282f, -0.08443986f, 
    -0.02787228f, 0.06862237f, -0.08097928f, 0.01139927f, -0.10518041f, 0.08137751f, -0.03323336f, 0.02892348f, 
    0.00354037f, 0.01939504f, -0.05526394f, 0.03164925f, 0.07971514f, -0.13513860f, 0.03756311f, -0.00148139f, 
    -0.22641361f, 0.23023792f, -0.09593360f, -0.06535031f, -0.12268820f, -0.03619410f, 0.10524841f, -0.04097812f, 
    -0.07115768f, -0.02999718f, 0.00274512f, 0.01469741f, -0.00276528f, -0.02921188f, 0.01032751f, 0.05264854f, 
    0.01188080f, 0.03131039f, 0.02001926f, 0.03575068f, 0.02443107f, 0.05301363f, 0.08372151f, -0.01003650f, 
    -0.04422852f, 0.03595485f, 0.12003829f, -0.06301351f, 0.03973167f, -0.03240458f, -0.00846746f, -0.12464570f, 
    0.06344857f, 0.06330191f, 0.01295468f, 0.04103747f, -0.03609366f, 0.01350035f, -0.11632587f, -0.06511977f, 
    0.21295810f, -0.11979654f, 0.10667487f, 0.02708336f, -0.22125736f, -0.02419767f, -0.05100068f, 0.06172663f, 
    -0.02970384f, 0.01422261f, -0.03836453f, -0.01141651f, 0.06241266f, -0.07707462f, -0.01312577f, 0.01558629f, 
    0.04444028f, -0.02980139f, -0.01494658f, -0.03632949f, 0.20732138f, -0.20396057f, -0.04774586f, -0.19025104f, 
    0.19179827f, -0.00333227f, -0.06685131f, 0.04734167f, 0.00808549f, 0.02372426f, 0.03164411f, -0.01696564f, 
    0.01321195f, 0.13552387f, -0.06093423f, 0.09195767f, 0.03374951f, 0.09952024f, -0.02452985f, -0.00437281f, 
    0.09700020f, -0.04279181f, 0.15037671f, -0.06085917f, 0.30851966f, 0.10213915f, 0.10521267f, 0.01544884f, 
    0.09588297f, 0.03376560f, -0.05559869f, -0.02020105f, -0.00745704f, -0.02483927f, 0.09631164f, 0.06498292f, 
    0.04609200f, 0.01628807f, 0.07339379f, 0.02776656f, 0.14441709f, -0.17420582f, 0.06908602f, 0.03702657f, 
    0.03465468f, 0.07982159f, 0.06033117f, -0.01848272f, 0.03450843f, -0.00992531f, 0.05646604f, 0.01273224f, 
    0.07128772f, 0.01234819f, -0.07885803f, -0.01099744f, -0.04984477f, -0.04785680f, 0.03542008f, 0.07329375f, 
    -0.18729705f, -0.32839662f, 0.40477571f, -0.11386447f, -0.26236904f, -0.01710509f, 0.02557340f, -0.08877531f, 
    -0.04145026f, -0.00060459f, -0.03077025f, 0.04010266f, 0.00718188f, -0.00794028f, -0.03575570f, -0.07766052f, 
    -0.02603068f, -0.02939903f, 0.08842584f, 0.05121738f, -0.22292237f, 0.23905677f, 0.01882192f, 0.15197615f, 
    -0.05415875f, 0.06846381f, 0.11486260f, 0.08864240f, -0.06061418f, -0.03438126f, 0.02113765f, -0.03974470f, 
    -0.01372537f, -0.01184988f, 0.00027184f, -0.01518898f, -0.02121166f, 0.08958960f, -0.10842967f, -0.00640120f, 
    -0.28332198f, 0.09313660f, 0.21057191f, 0.06444167f, 0.20604244f, 0.01772988f, 0.08503196f, -0.05057878f, 
    0.03016027f, 0.12347369f, -0.04979485f, 0.05130810f, -0.01863644f, 0.04479298f, 0.01248355f, -0.03050246f, 
    -0.00563637f, 0.00951546f, 0.07010285f, -0.01472727f, -0.24694663f, -0.07748851f, 0.12335377f, 0.11183525f, 
    0.11236436f, 0.04208693f, 0.13441798f, 0.03353114f, -0.11118776f, 0.00418729f, -0.01554729f, 0.10680941f, 
    -0.05466441f, 0.01700656f, -0.01233303f, -0.07844966f, -0.04654668f, 0.07065144f, 0.06200479f, 0.01224954f, 
    0.20139265f, 0.00149829f, 0.10769369f, -0.08796762f, 0.18083614f, 0.03329310f, 0.11189502f, 0.04044350f, 
    -0.01037407f, -0.00319612f, 0.02488725f, -0.03525663f, -0.02038447f, 0.00855322f, -0.03497357f, -0.14498295f, 
    0.00223129f, -0.03933481f, 0.03998870f, 0.00549962f, 0.15082340f, -0.08503989f, 0.07421923f, 0.20221831f, 
    0.17372805f, -0.00210192f, 0.07285140f, 0.02166765f, 0.02478765f, 0.08363229f, -0.09709388f, -0.04128516f, 
    0.11175901f, 0.09640690f, 0.00770262f, -0.07928154f, 0.01394929f, -0.07126015f, -0.01504427f, -0.05970065f, 
    0.09960543f, 0.20802693f, -0.05541370f, -0.11100974f, 0.00292720f, 0.02077808f, 0.15265177f, -0.01793806f, 
    0.04333574f, 0.01245250f, 0.02154115f, 0.01663466f, 0.00750899f, -0.03139881f, -0.02302683f, 0.02445382f, 
    0.02698992f, 0.07729533f, 0.02339998f, 0.02037835f, 0.01282547f, 0.13147023f, -0.02531152f, 0.04065405f, 
    0.11209921f, -0.02734004f, -0.00750608f, 0.01749096f, -0.04468995f, -0.01848353f, -0.06248904f, -0.03008753f, 
    -0.01179586f, 0.00094900f, -0.00696329f, -0.00396078f, -0.00649880f, 0.00959601f, -0.01547849f, -0.05869648f, 
    0.03184428f, -0.05937679f, -0.00164192f, 0.04139295f, -0.03752205f, 0.00440599f, 0.03471510f, 0.01954316f, 
    0.01641351f, 0.03349387f, -0.06115537f, 0.02635377f, 0.02060421f, -0.04554326f, 0.04717899f, -0.04739134f, 
    -0.05107431f, -0.06230421f, -0.06258072f, -0.04375109f, -0.01756968f, -0.05853077f, -0.02543182f, -0.02349073f, 
    -0.00971927f, 0.03904494f, 0.01693939f, -0.03099520f, -0.00215854f, -0.02256604f, -0.03955411f, 0.01773565f, 
    -0.06210137f, -0.02597505f, 0.04748452f, -0.00574767f, -0.03053267f, 0.01819691f, -0.02290833f, -0.03456802f, 
    -0.03967277f, 0.01075576f, -0.02437195f, -0.00962193f, -0.03172030f, -0.03358832f, 0.02646014f, 0.00778482f, 
    0.03629299f, 0.02595142f, -0.00519749f, -0.02942764f, -0.00993483f, -0.00989651f, 0.03128882f, -0.05455916f, 
    -0.04472790f, -0.02575133f, 0.03735788f, -0.04041303f, 0.02717576f, -0.03794594f, 0.01827884f, -0.03817489f, 
    -0.03036304f, -0.05927859f, -0.05275990f, 0.00403658f, -0.00081775f, 0.03247795f, -0.02873023f, 0.02822691f, 
    -0.03618801f, 0.03655677f, -0.00881122f, 0.02006342f, 0.03603736f, -0.04356069f, 0.02302433f, -0.05065940f, 
    -0.03633025f, -0.04703375f, -0.04966545f, -0.03481152f, -0.04524281f, -0.04040843f, 0.02577709f, 0.00031227f, 
    -0.05933316f, 0.00492529f, 0.03629827f, -0.01478082f, 0.02493424f, 0.04808049f, 0.01349227f, -0.00280417f, 
    0.03340627f, 0.01074314f, -0.02267460f, 0.03534602f, 0.01390786f, -0.04340114f, -0.05917015f, -0.06295594f, 
    0.00591561f, -0.05708415f, 0.03609883f, -0.03925632f, -0.01159922f, -0.03165329f, 0.04134406f, 0.00283638f, 
    -0.05829049f, 0.03002460f, -0.05416152f, 0.04148272f, -0.00882272f, -0.03105304f, -0.05870813f, 0.02502776f, 
    0.02592787f, 0.04589828f, -0.03926780f, 0.04654766f, -0.05100425f, -0.05190827f, 0.01042893f, 0.01399041f, 
    -0.04020328f, -0.02554895f, 0.01080732f, 0.04225112f, 0.02688258f, -0.05106449f, 0.00862651f, 0.02227744f, 
    0.02702489f, -0.02011501f, 0.02633001f, -0.04524201f, 0.00509108f, 0.01473058f, 0.02666085f, -0.04735675f, 
    -0.01569403f, -0.02469921f, 0.03656252f, -0.02079060f, -0.02270344f, -0.04955936f, -0.06070817f, -0.05977358f, 
    0.00922202f, -0.05020543f, -0.00542196f, -0.00794180f, 0.02665634f, -0.02629059f, -0.04793220f, 0.01724504f, 
    0.02100722f, -0.03845651f, 0.01301713f, -0.02353737f, 0.01136761f, -0.05548502f, -0.04900534f, 0.00812627f, 
    0.04504057f, 0.03733487f, 0.03530633f, -0.00658749f, 0.00153860f, 0.03247060f, 0.03419000f, -0.03811927f, 
    -0.05566906f, 0.03186452f, -0.06008827f, -0.01420899f, -0.03073802f, -0.00073189f, -0.04976830f, 0.00860551f, 
    -0.05099743f, 0.02969923f, -0.02267974f, 0.00936809f, 0.04310274f, -0.03123481f, -0.00902109f, -0.05176241f, 
    0.03597579f, 0.00082410f, -0.03019493f, -0.05864135f, 0.01625445f, -0.06176571f, 0.03898324f, 0.01261641f, 
    0.02286575f, 0.00333422f, 0.03354222f, -0.01892568f, -0.06048905f, 0.02010678f, 0.00516283f, 0.03145029f, 
    -0.00702907f, -0.02901689f, -0.04472320f, 0.01284322f, 0.00035318f, -0.03473631f, -0.06180361f, -0.03853226f, 
    0.03383578f, -0.01056525f, -0.04366499f, -0.03484336f, 0.02857108f, -0.00498674f, 0.00864843f, -0.04329865f, 
    -0.01622924f, -0.01682570f, -0.00463431f, -0.01500101f, -0.03526937f, 0.00272145f, 0.01824782f, -0.03902669f, 
    0.00629665f, -0.03855394f, -0.02777698f, -0.00432932f, 0.01526427f, -0.01151725f, 0.01699384f, 0.03456662f, 
    -0.00655284f, -0.00167543f, -0.01301030f, 0.02705819f, 0.04274287f, -0.04996181f, 0.02346218f, 0.04175526f, 
    -0.02512451f, -0.03012536f, 0.00321383f, -0.04524087f, 0.03950839f, -0.05041229f, -0.03926167f, 0.02530709f, 
    -0.04402636f, 0.01177804f, -0.04608211f, -0.01885901f, 0.00197082f, -0.00971861f, 0.00041607f, -0.00959558f, 
    0.04579422f, -0.02859311f, -0.00361992f, -0.00503806f, -0.00132492f, -0.03286167f, 0.00934007f, 0.00330869f, 
    -0.00142314f, -0.04282610f, 0.00040066f, 0.01036652f, -0.03482351f, 0.00960956f, 0.02634847f, 0.02530092f, 
    -0.02316152f, 0.04988387f, -0.04418304f, 0.04529075f, -0.03448762f, 0.04579023f, -0.05361139f, -0.02579630f, 
    0.04389090f, 0.00336739f, 0.02850697f, -0.02187495f, 0.01087596f, 0.00373300f, -0.00361804f, 0.04641931f, 
    0.02938887f, -0.03016981f, -0.03268738f, -0.06072298f, -0.06126861f, -0.02860662f, 0.02781079f, -0.02019174f, 
    -0.02708068f, 0.02086723f, 0.00608213f, -0.06060907f, 0.03164878f, -0.03044307f, 0.00985247f, 0.00663581f, 
    -0.00135746f, -0.03260437f, -0.00512945f, -0.00072447f, 0.01335001f, -0.02528939f, 0.01575250f, -0.01151192f, 
    0.19637808f, -0.15318018f, -0.15458973f, -0.03990986f, 0.06321308f, 0.08943985f, -0.08739133f, -0.02990701f, 
    -0.00251407f, -0.01935916f, 0.04641930f, 0.03739850f, -0.04714305f, 0.05942799f, 0.00027810f, 0.00146467f, 
    -0.05701949f, 0.02484599f, -0.10273673f, 0.00702991f, 0.15874244f, 0.09169184f, 0.11883119f, -0.12736632f, 
    0.04579711f, 0.06724931f, 0.09607837f, 0.09189460f, 0.04169761f, 0.20022109f, -0.03409859f, 0.01338967f, 
    0.05035193f, 0.01474785f, -0.06779642f, 0.09830676f, 0.18212825f, 0.09264660f, 0.10133915f, -0.00019224f, 
    -0.28134412f, -0.17041498f, -0.02164954f, -0.00318657f, -0.00536164f, 0.04102315f, 0.26172951f, -0.04112381f, 
    -0.01429659f, 0.00213383f, 0.11673533f, 0.02242751f, 0.04941216f, 0.01109438f, -0.01316277f, -0.01645512f, 
    0.09530538f, 0.07937816f, 0.11539259f, 0.03427001f, -0.14545211f, 0.12978446f, 0.04560484f, 0.15708919f, 
    -0.02546027f, 0.01241311f, 0.14162718f, -0.01601103f, -0.00487214f, -0.04031613f, -0.01752473f, -0.05069448f, 
    0.06385717f, 0.00243354f, 0.04867017f, 0.09938348f, 0.09065101f, 0.04555336f, -0.09898347f, -0.01114901f, 
    -0.33254001f, -0.07764206f, -0.07843256f, -0.03444585f, -0.05447033f, -0.01600015f, -0.06533441f, -0.01820542f, 
    -0.00277325f, -0.00774863f, -0.00120928f, 0.07646166f, 0.05375060f, 0.07232187f, 0.08219136f, 0.06849670f, 
    0.07022504f, -0.08074565f, -0.08662034f, 0.09597751f, 0.37411469f, -0.05432709f, -0.01206316f, 0.03981176f, 
    0.12292857f, -0.03561529f, 0.01401677f, 0.10322887f, 0.03989835f, -0.01145916f, 0.00413914f, 0.01338970f, 
    -0.04217438f, 0.00359329f, -0.01963904f, 0.18136345f, 0.09939174f, -0.01994633f, 0.08027369f, 0.12888326f, 
    0.13450629f, -0.13263620f, 0.17832236f, -0.16705002f, 0.04443778f, -0.02494818f, 0.00687170f, 0.05270671f, 
    0.05575828f, 0.02905874f, -0.02389758f, 0.04787591f, 0.05663172f, -0.02246748f, 0.03719736f, 0.04444760f, 
    -0.00658634f, -0.02676187f, 0.02026795f, 0.10343605f, 0.03016965f, -0.04060789f, 0.12371939f, 0.06685679f, 
    -0.02699420f, 0.11198112f, 0.00782934f, 0.13353713f, -0.02361896f, 0.00745122f, 0.05617499f, -0.00146026f, 
    0.07779983f, -0.07964858f, 0.00583115f, -0.07811446f, 0.15948109f, -0.06346240f, 0.11422683f, 0.09561222f, 
    -0.25502050f, -0.10159565f, 0.29332784f, -0.28278083f, -0.10650486f, 0.18751791f, 0.03223958f, -0.03720032f, 
    -0.04887939f, 0.06439285f, 0.02569403f, 0.10435890f, -0.04757937f, -0.02356667f, -0.07428432f, 0.07057989f, 
    -0.04591026f, -0.01354790f, -0.03599286f, -0.04362472f, -0.59247363f, -0.05343748f, -0.18571080f, -0.05013348f, 
    -0.11808266f, -0.09406123f, -0.00661592f, -0.07211174f, -0.04295029f, -0.15919024f, 0.05464411f, -0.08266048f, 
    0.01673177f, -0.00621148f, 0.03967945f, -0.04894660f, -0.05949096f, -0.02745743f, -0.01201893f, 0.08988633f, 
    0.20754567f, 0.08705045f, 0.11409851f, 0.12821555f, 0.04714371f, -0.13711002f, -0.00530282f, 0.00790490f, 
    0.02844945f, 0.13427691f, 0.01615699f, 0.08607957f, 0.04774248f, 0.04674628f, 0.02496775f, -0.07155747f, 
    -0.14335871f, 0.06797470f, 0.06996065f, -0.01861298f, 0.10112438f, 0.02327511f, 0.08050541f, 0.13277905f, 
    -0.04361421f, -0.05344594f, -0.14814880f, 0.06108984f, -0.00711436f, -0.04953161f, -0.03051909f, 0.04353655f, 
    -0.07191356f, -0.00081238f, 0.04554621f, -0.08255078f, -0.03163172f, 0.07904585f, 0.02382533f, 0.11407980f, 
    0.21322681f, 0.06125820f, 0.10058348f, -0.03600230f, 0.00659437f, -0.00228011f, 0.04371872f, 0.05650615f, 
    -0.05388276f, 0.07029194f, 0.07773198f, -0.04751606f, -0.03845017f, 0.01771227f, -0.09508461f, -0.00906307f, 
    0.02131942f, 0.03908834f, 0.11050492f, 0.16346949f, 0.24027720f, -0.22128688f, 0.00773218f, 0.02243544f, 
    0.00582454f, -0.03577020f, -0.06193583f, -0.01559107f, 0.02282288f, -0.00181491f, -0.10637139f, 0.01780834f, 
    0.08512999f, -0.00313135f, -0.01663140f, -0.13367213f, 0.01958889f, -0.05345495f, -0.02416298f, 0.12204611f, 
    0.22949311f, 0.16050619f, -0.01981495f, -0.03754445f, -0.05841262f, 0.02134397f, 0.06898215f, 0.01185757f, 
    -0.04427321f, 0.04191574f, 0.08445758f, 0.01198447f, -0.08137624f, -0.10771161f, -0.01246125f, 0.16061518f, 
    -0.05632699f, -0.07911616f, 0.04346252f, 0.07207462f, -0.16589023f, -0.10723239f, 0.00166858f, 0.10307348f, 
    0.01203534f, 0.07573199f, -0.04077649f, -0.00767064f, 0.01125156f, -0.03301116f, -0.09948456f, 0.00489684f, 
    0.05381762f, 0.09010176f, 0.05888743f, 0.04753349f, 0.04118520f, 0.02985240f, 0.00116040f, -0.03117845f, 
    0.00082194f, -0.02670585f, 0.04680678f, -0.02778572f, 0.01901686f, 0.03585736f, 0.00432803f, 0.00341957f, 
    -0.05414237f, 0.00921631f, -0.02861640f, -0.01044916f, 0.02435641f, 0.00553354f, 0.00202075f, -0.00243733f, 
    -0.00306162f, 0.04509239f, 0.02064316f, 0.01096247f, -0.03236968f, 0.03644843f, 0.04439479f, 0.04510029f, 
    0.02716393f, -0.03638105f, 0.01856659f, -0.03071998f, 0.00624579f, 0.04188625f, -0.03307344f, 0.03871574f, 
    -0.02145536f, 0.00036799f, 0.03151728f, -0.01242106f, 0.04408320f, -0.01495184f, -0.02848138f, -0.02881668f, 
    -0.04673757f, 0.01024793f, 0.02907213f, -0.05177420f, 0.00556921f, 0.01717039f, -0.02212317f, -0.06228711f, 
    -0.00193367f, -0.01730839f, -0.02488918f, 0.01433976f, 0.02045159f, -0.01029668f, -0.03572075f, -0.04635398f, 
    0.00987521f, -0.05700988f, 0.01098331f, 0.02301035f, -0.04577630f, 0.01984448f, 0.03314387f, 0.00808550f, 
    0.02421811f, 0.01795174f, -0.02928046f, -0.01555442f, -0.04027533f, -0.00873914f, -0.04152095f, -0.05763309f, 
    -0.06195185f, -0.01898805f, -0.00980304f, 0.03325952f, 0.04582840f, -0.04262232f, 0.02131313f, -0.01126701f, 
    0.03754636f, 0.01756588f, -0.01295353f, 0.02681012f, -0.04892435f, -0.02122273f, -0.00714858f, -0.06302415f, 
    -0.04704271f, -0.00300535f, -0.01826221f, -0.01469517f, 0.02246575f, -0.03724485f, -0.04606294f, -0.02992413f, 
    -0.05936784f, -0.03351552f, -0.04622659f, 0.02852786f, -0.02723859f, -0.05652701f, 0.00022692f, 0.04534825f, 
    -0.02413367f, -0.01186382f, -0.04662479f, 0.03594387f, 0.03953419f, -0.05432460f, -0.03550979f, 0.02867499f, 
    0.01666322f, 0.00811634f, -0.02572636f, -0.00861656f, 0.01109479f, -0.05973529f, 0.04836542f, 0.02103676f, 
    -0.00403229f, 0.04414370f, 0.03014907f, 0.02349431f, -0.01012982f, -0.03136927f, -0.03677266f, -0.01116976f, 
    0.00846816f, -0.05954174f, -0.03218344f, -0.02179780f, 0.00284975f, 0.01241443f, -0.05485353f, -0.00365977f, 
    0.02881122f, -0.04291073f, 0.01013960f, 0.02772132f, 0.03739173f, 0.04515979f, 0.03301736f, -0.03550932f, 
    0.04873860f, 0.02305108f, -0.03412977f, -0.04039579f, -0.03193861f, -0.04892168f, 0.02551732f, -0.05057007f, 
    0.01595102f, 0.02388767f, -0.04041794f, -0.04912639f, -0.01623232f, -0.00333045f, -0.03906594f, -0.00576769f, 
    -0.01605276f, 0.04708850f, -0.02182647f, 0.04057486f, -0.04501159f, 0.04281931f, -0.05254024f, -0.02531676f, 
    0.00379875f, 0.02360920f, -0.00791743f, -0.00772149f, 0.00083595f, -0.02246443f, 0.00565115f, -0.01530393f, 
    -0.00340565f, -0.06594088f, 0.03062515f, -0.00465784f, 0.03817793f, 0.02561339f, -0.03406819f, 0.04543919f, 
    0.01722336f, -0.01923115f, 0.04944314f, -0.00172680f, 0.02799284f, -0.01884731f, -0.03624749f, -0.06391480f, 
    -0.05771074f, -0.06120917f, -0.03230332f, 0.03309820f, -0.02699551f, 0.03879661f, -0.00276847f, -0.02110081f, 
    -0.01521267f, 0.01005653f, 0.01229941f, 0.04091731f, 0.03780746f, -0.03553148f, 0.01526457f, 0.01215188f, 
    0.04040887f, -0.00656097f, 0.04307258f, -0.01194656f, -0.04598869f, -0.02911733f, 0.03830276f, 0.03566901f, 
    0.04522210f, 0.02545166f, 0.02742420f, -0.03906101f, -0.00359208f, 0.00268191f, -0.06626352f, -0.03649842f, 
    0.02514756f, -0.00659013f, -0.04571524f, 0.01964008f, 0.02219428f, 0.03919161f, 0.02223299f, 0.04262177f, 
    -0.03781179f, -0.02671844f, -0.04899326f, -0.00860711f, 0.04119239f, -0.01444210f, -0.03683082f, -0.05256078f, 
    -0.04858109f, -0.04903206f, 0.01733051f, -0.05248575f, 0.00279316f, -0.04572183f, -0.00263027f, -0.04990310f, 
    0.02260382f, -0.01841764f, -0.01831040f, 0.04300153f, -0.04232762f, -0.05728117f, -0.01537296f, -0.02344385f, 
    0.00750001f, 0.02583845f, 0.03859803f, -0.03067332f, -0.02457403f, -0.05611257f, -0.00118438f, -0.04268449f, 
    -0.05750844f, -0.01082972f, 0.02447657f, -0.03808010f, 0.00341962f, 0.00805143f, 0.01378044f, 0.04043717f, 
    0.04040395f, 0.03672118f, 0.02906608f, -0.04087373f, 0.02661320f, -0.02401648f, 0.00578393f, 0.02866852f, 
    -0.00055847f, -0.02315313f, 0.01340688f, -0.04753886f, -0.05523863f, 0.03989542f, -0.01260909f, 0.01238117f, 
    -0.00286978f, -0.01358951f, 0.00967049f, 0.03341893f, 0.04165223f, -0.01405153f, -0.03461458f, 0.00631479f, 
    -0.00285476f, 0.03907297f, -0.05127766f, -0.06182362f, -0.03657284f, 0.00030764f, -0.03645466f, -0.00569721f, 
    -0.03563201f, 0.04458665f, 0.01202673f, -0.04494600f, 0.03485465f, -0.01424476f, 0.03006500f, 0.00946195f, 
    0.00508998f, -0.03765570f, -0.04598366f, 0.01756996f, -0.05317025f, -0.01189820f, -0.06410191f, 0.03127460f, 
    -0.37168694f, 0.07526932f, -0.03773079f, -0.12783171f, 0.04856848f, -0.15599799f, 0.09983308f, 0.01325013f, 
    -0.13024731f, 0.12510279f, 0.08664174f, 0.09702244f, 0.14420749f, -0.07681678f, 0.11734974f, -0.02687220f, 
    -0.01755986f, 0.04141583f, 0.04618122f, 0.01763468f, 0.06278087f, 0.21138713f, -0.11291847f, -0.03913645f, 
    -0.05638899f, 0.07565033f, 0.18728489f, -0.02972444f, 0.16103648f, -0.00840433f, -0.01705562f, 0.10043376f, 
    -0.01229353f, -0.01160663f, -0.01135040f, 0.10899390f, -0.05699760f, 0.09807596f, 0.06022488f, 0.09767341f, 
    0.08760367f, -0.27189678f, 0.14420469f, 0.06882279f, 0.10790604f, -0.05588369f, -0.10867185f, 0.22093755f, 
    0.04447313f, -0.04263462f, -0.09863000f, 0.10217357f, -0.03263249f, 0.05774342f, 0.04451982f, 0.05287217f, 
    -0.03085524f, 0.03513870f, -0.02331783f, 0.10518321f, 0.46749595f, -0.39538494f, -0.04421955f, 0.03457201f, 
    0.12982129f, 0.04718839f, 0.01010919f, -0.01006590f, 0.09065886f, 0.03181738f, 0.02933967f, 0.04029916f, 
    -0.03399820f, -0.05397437f, 0.10419352f, -0.03836731f, 0.14669938f, 0.11279989f, 0.08563635f, 0.08612311f, 
    0.01619262f, 0.25261414f, -0.15137957f, -0.07064509f, -0.07646166f, 0.06982162f, 0.08866210f, -0.04694130f, 
    0.02716612f, 0.03896988f, -0.06728169f, 0.08028612f, 0.01655657f, 0.07028535f, -0.03375524f, 0.01765219f, 
    0.06189228f, 0.12336657f, -0.00713984f, 0.00735787f, -0.12766114f, 0.16480437f, -0.03685801f, 0.05858094f, 
    -0.14170229f, -0.03609968f, 0.17718954f, 0.02284115f, 0.12782286f, 0.01436939f, 0.11608532f, 0.06122525f, 
    0.02913522f, -0.00468528f, 0.06106185f, 0.02330342f, -0.00041041f, -0.03890088f, -0.04273263f, -0.09001292f, 
    0.32412052f, 0.00908617f, -0.09582220f, 0.14637296f, -0.11172198f, -0.00988236f, 0.06998780f, -0.01070300f, 
    -0.01907674f, 0.04974616f, 0.04873791f, 0.09946878f, 0.03565312f, 0.07048924f, -0.06146623f, -0.12836094f, 
    -0.01661756f, 0.01896317f, -0.02975884f, -0.05860924f, 0.23044945f, -0.02865797f, -0.03892288f, 0.04602921f, 
    -0.02869130f, 0.05243459f, 0.03644080f, -0.01087655f, 0.10908222f, 0.06160446f, -0.01591889f, 0.06799304f, 
    0.03793303f, 0.08344006f, -0.05020382f, 0.10244469f, 0.04336945f, 0.13828501f, -0.03092815f, 0.11634398f, 
    0.09129637f, 0.31421143f, -0.08748943f, 0.06242163f, -0.05313188f, -0.00912722f, 0.02157996f, 0.05815555f, 
    -0.05429199f, 0.09735482f, -0.04767979f, 0.04159795f, -0.00966652f, 0.13658811f, -0.02293382f, 0.07532118f, 
    0.09910438f, -0.16071351f, -0.23761904f, 0.02697055f, 0.28103548f, -0.02494519f, 0.10865396f, -0.09295616f, 
    0.08571339f, 0.03433121f, -0.05873107f, 0.03614397f, -0.00888151f, 0.09791776f, 0.02925103f, -0.01097823f, 
    0.05087552f, 0.03553776f, -0.08070803f, -0.03536469f, 0.10250226f, 0.12757166f, 0.15432477f, -0.01336398f, 
    0.31245232f, 0.04877025f, -0.00795252f, 0.01652222f, -0.11671268f, 0.00627524f, -0.04945280f, 0.00485326f, 
    0.10887162f, 0.08357469f, 0.11162426f, -0.03316749f, 0.02916939f, -0.05449223f, -0.00198994f, 0.08150189f, 
    0.09469724f, -0.05499190f, 0.04145708f, 0.00678652f, 0.13395181f, 0.14123918f, 0.10322778f, -0.04753481f, 
    0.02536077f, 0.04269179f, -0.07034716f, 0.10711203f, 0.07852752f, 0.06568925f, 0.04011405f, -0.00213236f, 
    0.02903233f, 0.11153097f, -0.09175093f, 0.04180125f, 0.17156723f, 0.01587747f, 0.12130667f, -0.02332019f, 
    0.20751171f, -0.09918004f, -0.02400621f, 0.13505773f, -0.01495583f, 0.01904192f, 0.14627095f, 0.06533722f, 
    0.11323968f, 0.05318790f, 0.01432527f, -0.00553038f, 0.15563293f, 0.03872479f, 0.05706980f, 0.17658618f, 
    0.13350281f, 0.11618172f, 0.01135462f, 0.08320474f, 0.37179127f, 0.09297834f, -0.03218241f, 0.01151467f, 
    0.07460871f, -0.12182085f, -0.04901969f, -0.12597224f, 0.07118043f, 0.01796298f, 0.14158103f, 0.01486585f, 
    -0.03789529f, -0.03373923f, -0.00994275f, -0.02286400f, -0.04571327f, -0.00029296f, -0.06403784f, 0.07251360f, 
    0.13327746f, -0.09626057f, 0.02045488f, -0.00996130f, 0.08207570f, 0.11881799f, 0.07795259f, 0.02032449f, 
    0.02275028f, -0.00542829f, -0.04175724f, -0.01893227f, 0.11467738f, 0.02818963f, -0.03332164f, -0.05337775f, 
    -0.06198589f, -0.06475139f, -0.17639616f, -0.02694172f, -0.34574503f, -0.01005485f, 0.11081954f, -0.01518052f, 
    -0.00384702f, 0.00375590f, 0.06106371f, 0.06851798f, -0.03930728f, 0.18325868f, 0.11950219f, 0.03419910f, 
    0.12222085f, -0.05893610f, 0.08614538f, 0.01430829f, -0.04861662f, -0.06766178f, 0.05315866f, 0.08752481f, 
    0.06562500f, 0.13439836f, -0.21933854f, 0.20215870f, -0.11602846f, 0.01400366f, 0.04228001f, -0.06457742f, 
    0.07580951f, 0.10935213f, 0.02866204f, 0.04433678f, 0.01908447f, -0.05877473f, 0.01326953f, 0.14511219f, 
    0.01119407f, 0.00160390f, 0.09585971f, 0.07771691f, -0.01646937f, 0.01075352f, 0.05543489f, -0.14328416f, 
    0.13689250f, -0.01849661f, 0.05820388f, 0.14724773f, 0.01193476f, 0.01621416f, -0.11265101f, 0.10281112f, 
    0.01792600f, 0.01265397f, 0.15243174f, -0.00417548f, 0.05450846f, 0.01543498f, -0.12035669f, 0.01316218f, 
    -0.23071928f, 0.39713717f, -0.37334859f, -0.04427705f, 0.03033637f, 0.13503583f, 0.01177976f, -0.10677249f, 
    0.01472548f, 0.06616579f, 0.06672923f, 0.12195102f, -0.08100739f, -0.00533680f, 0.01568317f, 0.01461897f, 
    0.06582241f, 0.06058655f, 0.06304116f, 0.08259185f, -0.02247594f, 0.26927164f, -0.06314784f, 0.00007632f, 
    -0.11926629f, -0.01807320f, -0.02461336f, 0.00506885f, 0.06442139f, -0.09737481f, 0.02436559f, 0.11860319f, 
    -0.03612342f, -0.07494834f, -0.00452844f, -0.04090709f, 0.02535995f, -0.09773787f, 0.09309746f, 0.08494841f, 
    0.00326363f, 0.20185685f, -0.04999673f, -0.03670764f, -0.01591335f, 0.08904196f, 0.03887834f, -0.06630687f, 
    0.05503642f, 0.06379089f, 0.11921205f, -0.02451318f, -0.02274895f, -0.00299515f, 0.00993464f, -0.01404299f, 
    0.08031935f, 0.01780172f, 0.02577884f, 0.01294265f, -0.33424827f, -0.00572410f, 0.04832223f, -0.09800236f, 
    0.14671583f, 0.05195504f, -0.11722110f, -0.04280726f, -0.02294889f, 0.07358398f, -0.03999226f, -0.05495067f, 
    0.00283377f, -0.02423779f, 0.09804499f, -0.08423529f, 0.06222493f, -0.02292888f, -0.04748514f, 0.01091099f, 
    -0.45092085f, 0.10945739f, 0.27564809f, -0.14117774f, 0.10049551f, -0.07280243f, -0.09961042f, -0.03384999f, 
    -0.16572431f, -0.11624533f, 0.04010541f, -0.04474518f, 0.06387806f, 0.06613201f, -0.08246038f, -0.03328226f, 
    0.08639548f, -0.01298422f, 0.04375008f, 0.09523919f, -0.13742681f, 0.23093289f, 0.00889592f, -0.11427370f, 
    -0.07312553f, -0.05569791f, -0.02138304f, -0.01122421f, -0.05916444f, 0.01095929f, 0.01856342f, 0.02899222f, 
    -0.05252219f, 0.14401600f, 0.06427231f, 0.13828099f, -0.08107104f, -0.02702594f, -0.03194640f, 0.01760216f, 
    0.34886965f, 0.02232985f, -0.29522321f, -0.08662467f, 0.15713082f, 0.09260636f, -0.06154767f, -0.06354348f, 
    0.04763966f, -0.04803689f, 0.12789051f, 0.04477136f, -0.01808271f, 0.11116068f, 0.15346520f, 0.06826789f, 
    -0.04550063f, 0.03891349f, 0.07033673f, -0.01550058f, 0.30261335f, 0.03985587f, -0.05517175f, -0.07374151f, 
    0.00542352f, 0.04066420f, 0.06335747f, 0.06048753f, -0.05403170f, 0.08767465f, 0.02886739f, 0.09174675f, 
    0.05205396f, -0.05624861f, 0.12403442f, -0.22959031f, 0.07233708f, -0.07179584f, 0.04294385f, -0.12537198f, 
    0.25730762f, -0.09387087f, 0.24707791f, 0.04503606f, 0.03757338f, -0.13967288f, -0.02565912f, 0.01793471f, 
    -0.03678715f, -0.12584314f, -0.09726074f, -0.06107707f, -0.00685779f, 0.02247989f, -0.04000926f, 0.00176469f, 
    0.00658359f, -0.01739099f, -0.01060631f, 0.02055362f, 0.14654449f, 0.03964647f, 0.25365269f, -0.18005273f, 
    -0.04477641f, -0.06429613f, -0.08556769f, 0.00606631f, -0.00343122f, -0.04893969f, -0.00601937f, 0.01511601f, 
    -0.05054143f, -0.01902544f, -0.09228554f, 0.03809593f, 0.00407599f, -0.02282487f, 0.00796577f, -0.09241062f, 
    -0.06737147f, 0.22085977f, 0.09312147f, -0.14444895f, 0.07561178f, 0.02899699f, 0.02127741f, -0.03777086f, 
    -0.03388432f, -0.11083330f, -0.03445808f, 0.01405517f, 0.08927165f, 0.04800775f, 0.00947998f, 0.08747242f, 
    -0.03083135f, -0.01628107f, -0.04707767f, 0.07799391f, -0.19069628f, 0.15471914f, 0.10876149f, 0.12389611f, 
    0.21446633f, -0.02236419f, -0.17409517f, 0.02542496f, -0.05575023f, 0.10617985f, 0.03170042f, 0.01893439f, 
    -0.10184956f, -0.08126936f, 0.03962423f, 0.05367550f, -0.03059027f, -0.02916264f, -0.00888414f, 0.00510990f, 
    -0.12337904f, 0.01739377f, -0.12601784f, -0.19921041f, -0.09309167f, -0.06183450f, -0.09924971f, -0.08146931f, 
    -0.01347979f, -0.07009733f, 0.07298982f, 0.09253433f, -0.02754321f, 0.04599432f, 0.08126142f, 0.01063796f, 
    0.00217508f, -0.00113835f, 0.02496111f, -0.10286844f, -0.16427323f, 0.07799827f, 0.15255611f, -0.00001888f, 
    0.13117537f, -0.01369689f, -0.11825620f, -0.07606839f, -0.10339091f, 0.01397118f, 0.06943807f, 0.12128887f, 
    0.06987968f, 0.09295754f, 0.08868537f, -0.12588510f, 0.06436791f, -0.01536679f, -0.03281406f, -0.08910709f, 
    0.04549158f, -0.04704719f, 0.04395875f, -0.00944864f, -0.00629787f, -0.00687910f, -0.03280284f, -0.02843618f, 
    0.03984902f, 0.04372833f, -0.01971589f, -0.00188905f, 0.03072258f, -0.05218554f, -0.05027131f, -0.04846583f, 
    -0.04266891f, 0.03710859f, 0.04997987f, -0.03048963f, -0.02019667f, 0.04288846f, -0.03510296f, -0.02463599f, 
    -0.01681300f, 0.05102795f, -0.01116630f, -0.04103863f, 0.04791718f, -0.03414361f, -0.03409117f, 0.01656880f, 
    -0.04492251f, -0.00375345f, 0.02430184f, -0.03571047f, -0.03089653f, -0.04840176f, -0.05868572f, -0.01655625f, 
    -0.00111104f, 0.01935693f, -0.02249027f, -0.00710790f, 0.01936285f, 0.03413915f, 0.05057252f, 0.04330413f, 
    0.00410312f, -0.03738029f, -0.04959319f, -0.00129812f, -0.02542111f, 0.04457411f, -0.00492939f, 0.00317626f, 
    -0.00880077f, -0.04594634f, -0.04983817f, -0.04164723f, 0.01843404f, 0.04203057f, 0.01117222f, -0.01800128f, 
    0.04020002f, -0.06028256f, -0.01220585f, -0.01532714f, 0.01290434f, 0.02680901f, -0.00728096f, 0.02644703f, 
    -0.02440343f, -0.03323516f, 0.01894237f, 0.00022635f, 0.02092307f, -0.00580913f, -0.03225310f, -0.05832062f, 
    0.00210508f, -0.05674082f, 0.02077136f, -0.03822110f, 0.04160747f, 0.02829389f, -0.05449212f, 0.00269891f, 
    -0.02182090f, 0.00414935f, -0.04242399f, -0.01074171f, 0.00236845f, 0.03641907f, -0.00943591f, -0.00239229f, 
    -0.04895793f, -0.04220103f, -0.05479860f, -0.05548385f, 0.00110624f, -0.06238000f, -0.01372600f, -0.03358325f, 
    -0.04429569f, 0.00245026f, -0.00928188f, -0.00448011f, 0.01714411f, -0.01186324f, -0.04480284f, -0.03256804f, 
    -0.05179943f, -0.06353731f, -0.05020436f, -0.01017985f, 0.01518694f, 0.00323946f, -0.03357388f, -0.04349482f, 
    0.00981236f, -0.05646367f, -0.00880473f, 0.02769575f, 0.01121721f, -0.04897893f, 0.04331001f, 0.01542830f, 
    -0.02216169f, 0.04180042f, 0.03302628f, 0.04435072f, -0.02705574f, -0.03944760f, -0.00640157f, 0.01582236f, 
    -0.05950532f, 0.00414641f, 0.00105606f, -0.05678795f, -0.02569522f, 0.03632387f, 0.01467230f, 0.03384808f, 
    0.03644250f, 0.01546162f, 0.03682257f, 0.00078228f, -0.04843807f, 0.03337587f, -0.01033818f, 0.01877999f, 
    -0.02904152f, 0.00554692f, -0.04520222f, -0.01205736f, -0.03768811f, 0.00471974f, 0.03362222f, -0.04600337f, 
    0.04202540f, -0.03389411f, -0.01163913f, -0.01723093f, -0.03267441f, 0.00295907f, -0.05089276f, -0.01004662f, 
    0.03075817f, 0.01128486f, -0.04960804f, -0.06341051f, -0.03589221f, -0.02490284f, 0.02313229f, -0.06189100f, 
    0.01756373f, -0.02554320f, -0.05004133f, -0.00331190f, 0.04427798f, 0.02839370f, -0.02021482f, 0.02043051f, 
    -0.02060693f, 0.02085201f, -0.05051865f, 0.00136468f, 0.03975788f, -0.05852293f, 0.00159126f, 0.01515687f, 
    -0.01973114f, 0.03575583f, 0.02405732f, 0.04510430f, -0.05060381f, 0.03077445f, -0.03654159f, -0.02963406f, 
    -0.05008410f, -0.05038647f, 0.00848386f, 0.02248538f, 0.03282776f, -0.02354744f, -0.03566886f, -0.05296669f, 
    0.04915546f, 0.03503422f, -0.05119533f, -0.00540998f, 0.03603902f, -0.03561429f, 0.00125423f, -0.03203416f, 
    -0.04288882f, -0.05080693f, -0.05249506f, -0.03895755f, -0.04081941f, -0.00094479f, 0.00133267f, 0.03161824f, 
    0.00281605f, 0.00437207f, -0.02673067f, -0.05631503f, 0.00482614f, 0.00362416f, -0.02895148f, -0.00937733f, 
    -0.02349294f, -0.00263124f, 0.03474396f, -0.03854631f, 0.02995327f, -0.04008529f, -0.03018333f, -0.02325524f, 
    -0.03381805f, 0.01037659f, 0.00591001f, -0.03049780f, -0.00465494f, 0.00427040f, -0.04879618f, -0.05650087f, 
    -0.01705694f, 0.00656615f, -0.05472351f, -0.04014390f, 0.05307623f, -0.00610610f, 0.00004809f, 0.01109173f, 
    0.00384128f, 0.03530048f, -0.05723044f, -0.03761014f, -0.02483473f, -0.05169979f, 0.02229814f, 0.03513765f, 
    -0.02120341f, -0.00487025f, -0.03015721f, -0.05033555f, 0.03265517f, 0.01347278f, -0.02564581f, 0.03829660f, 
    -0.05181994f, -0.00921079f, -0.03757085f, -0.00079067f, -0.03414622f, -0.02915703f, 0.00259662f, 0.02611830f, 
    -0.01790348f, -0.00630804f, 0.02540307f, -0.04378587f, 0.03031262f, 0.02192845f, 0.04565611f, 0.00747667f, 
    0.00153721f, -0.06147119f, -0.00259635f, 0.03707357f, -0.04209220f, 0.03987155f, -0.06062217f, 0.03109309f, 
    -0.03850742f, 0.04257574f, -0.01511529f, -0.06579091f, 0.03814355f, 0.00211033f, -0.00240768f, 0.01149846f, 
    -0.01922316f, -0.05872076f, 0.03536441f, 0.02693649f, -0.00868861f, -0.03790468f, 0.01482027f, 0.02005733f, 
    -0.02074117f, -0.05961018f, -0.01474166f, 0.04162753f, 0.02728812f, 0.02306422f, 0.04058313f, 0.00452995f, 
    -0.29203960f, 0.24114569f, -0.28695008f, -0.03868213f, -0.04369519f, -0.04460941f, 0.03928750f, -0.00680311f, 
    0.07915916f, 0.11177594f, 0.04781231f, 0.12809311f, 0.12019990f, -0.09478267f, -0.03144686f, 0.10766774f, 
    0.02447699f, -0.02592353f, 0.03294664f, 0.01294720f, -0.14312394f, -0.06773637f, -0.09598596f, -0.13571838f, 
    0.16579880f, 0.12360236f, -0.01565972f, 0.01110565f, -0.03456644f, -0.05254381f, -0.11886414f, 0.05276122f, 
    -0.13306525f, -0.00993095f, -0.10465518f, 0.06579859f, -0.06828123f, -0.10152658f, 0.07609816f, 0.03713414f, 
    0.13773151f, 0.08993660f, -0.21181662f, -0.17509632f, -0.17161119f, -0.07365254f, -0.08374915f, -0.01149630f, 
    -0.09057741f, -0.05269054f, -0.02520018f, 0.12930886f, -0.09367218f, -0.02145660f, 0.02832513f, -0.06980053f, 
    0.02445391f, 0.03475312f, -0.03110915f, 0.00703620f, 0.35030970f, 0.02405944f, 0.05888397f, -0.06448784f, 
    0.07695605f, -0.02598578f, -0.02939329f, -0.11324096f, 0.06357284f, 0.03858811f, -0.00188453f, -0.12721945f, 
    -0.04675229f, -0.00406188f, 0.08872947f, -0.04137668f, 0.07320749f, -0.07398392f, 0.06769237f, 0.01823888f, 
    0.21209361f, 0.04202252f, -0.12466194f, -0.04648039f, -0.06352539f, 0.08420608f, 0.01201470f, 0.04429490f, 
    -0.02117301f, -0.02719936f, 0.02157630f, -0.05699585f, -0.02213648f, -0.00281225f, -0.03252931f, 0.05154181f, 
    0.07446766f, 0.10672733f, -0.11239596f, 0.02981540f, -0.23820591f, 0.11122159f, 0.02218307f, -0.14604449f, 
    0.30875993f, -0.02194157f, 0.05002518f, -0.03602542f, -0.00725813f, 0.04304852f, 0.03053070f, -0.14902112f, 
    0.00937012f, 0.08173740f, -0.00612634f, 0.01057817f, 0.03116763f, 0.01119990f, 0.01301035f, -0.04708559f, 
    0.11655068f, -0.08470552f, 0.14210084f, 0.16887538f, 0.14239927f, 0.10427582f, 0.04599584f, -0.05914544f, 
    0.07094439f, 0.01068355f, -0.01731157f, -0.02967333f, 0.10967360f, 0.04006917f, -0.02150174f, -0.02511205f, 
    0.06508892f, 0.03882523f, -0.04829187f, -0.10376578f, 0.31592992f, 0.09775726f, -0.09857716f, -0.08350235f, 
    0.00581185f, 0.09621241f, 0.06362986f, 0.05694442f, -0.01509824f, -0.00790948f, -0.00031947f, 0.01638180f, 
    -0.01398390f, 0.05548624f, -0.09462964f, 0.05126410f, 0.00813530f, 0.13453843f, 0.04964922f, -0.02200771f, 
    -0.21159081f, -0.23230304f, -0.02567296f, 0.15146910f, 0.16532360f, 0.03455844f, -0.04738170f, 0.02407783f, 
    -0.07505668f, -0.01158066f, 0.11595689f, 0.10185613f, 0.02729555f, 0.09217783f, -0.04829607f, 0.03312036f, 
    0.01555051f, -0.07522229f, -0.08834020f, 0.03933186f, 0.16047461f, -0.01299308f, 0.02832383f, -0.07043939f, 
    -0.20268232f, 0.00862650f, 0.01563287f, -0.00209896f, -0.04287607f, 0.14261566f, 0.00135659f, -0.09993458f, 
    0.02633433f, 0.09531279f, -0.00167952f, -0.14755987f, -0.01522551f, 0.02217834f, 0.06141736f, -0.10229505f, 
    -0.19402267f, 0.13881981f, 0.12936367f, 0.11776556f, -0.10363783f, 0.05944805f, -0.03533094f, 0.02717031f, 
    0.10270492f, 0.04849399f, -0.03621352f, -0.06719841f, -0.01927201f, 0.02321956f, -0.09444548f, 0.00687159f, 
    -0.00343913f, 0.03957301f, 0.12998214f, -0.08028308f, 0.12601337f, 0.27245614f, 0.14174089f, -0.05355529f, 
    0.01309688f, 0.09581778f, 0.06916961f, 0.04801341f, -0.03419912f, 0.03321828f, 0.02085700f, 0.01119440f, 
    -0.03053091f, 0.04335373f, -0.01416230f, 0.01851779f, 0.01979564f, -0.06238640f, 0.06645086f, 0.03006336f, 
    -0.01559590f, 0.17470708f, 0.00707577f, -0.09694613f, 0.05856199f, -0.00196336f, 0.13870610f, 0.03551834f, 
    0.08258475f, -0.00231531f, -0.07614276f, 0.01282818f, 0.09551588f, 0.04611589f, 0.02997263f, 0.08077363f, 
    0.04395033f, 0.03043033f, 0.03119406f, -0.08338857f, 0.25469649f, -0.09185903f, 0.07923201f, 0.28687051f, 
    0.20374252f, -0.10118757f, -0.04096549f, -0.00750748f, 0.02193627f, 0.15177004f, 0.04690533f, 0.02207521f, 
    0.04686934f, -0.01536083f, 0.02963583f, -0.04525867f, 0.07238256f, 0.01939151f, -0.01528053f, 0.00018089f, 
    0.17015556f, 0.12086495f, -0.02316654f, 0.06941145f, 0.03657016f, -0.00485291f, 0.18916129f, -0.02708341f, 
    0.08775804f, -0.11712608f, 0.06284174f, 0.10445347f, -0.02164057f, 0.00976283f, -0.03381873f, -0.09274194f, 
    0.00945554f, -0.05637536f, -0.01991696f, 0.08630989f, -0.43668628f, 0.19231749f, 0.02990827f, -0.02238821f, 
    0.09295358f, 0.02709855f, 0.05283589f, 0.07084001f, -0.06410974f, 0.03202968f, 0.09543192f, -0.01426822f, 
    -0.01100338f, -0.02535510f, -0.02372083f, -0.02760034f, 0.04377436f, -0.05804083f, -0.03852969f, 0.00983595f, 
    -0.05824941f, 0.03757644f, 0.01205157f, -0.04191237f, -0.03719081f, -0.04071500f, 0.00360373f, -0.02411300f, 
    -0.01904125f, 0.04072905f, 0.03467207f, -0.02180313f, 0.01756530f, -0.03517881f, -0.03996693f, 0.00945778f, 
    -0.00780837f, 0.04337831f, -0.04154954f, 0.00915340f, -0.02317293f, -0.01865221f, -0.04668738f, -0.04196272f, 
    -0.03751308f, 0.00510920f, 0.01877642f, 0.00325583f, -0.00416178f, -0.03968567f, 0.02976325f, -0.03225604f, 
    0.03917605f, 0.03037013f, -0.04248927f, -0.05785096f, 0.01037108f, 0.02034862f, -0.04656576f, 0.03376198f, 
    -0.03262581f, -0.00247370f, -0.00428719f, -0.03627271f, -0.02718072f, 0.03707483f, -0.00529644f, -0.03685626f, 
    -0.00237499f, 0.00175303f, -0.00927836f, -0.03059383f, 0.04902565f, -0.03659262f, 0.01316369f, -0.03318578f, 
    0.02823924f, -0.03708927f, -0.04579506f, -0.00107125f, 0.00208724f, -0.03473917f, 0.03728135f, -0.02363959f, 
    -0.01232132f, 0.02824189f, 0.01007147f, -0.00080226f, -0.06023544f, 0.01916358f, -0.00002228f, -0.00409106f, 
    -0.05205279f, 0.00973165f, -0.02419165f, 0.01404259f, 0.02127319f, 0.03363007f, -0.00039720f, 0.02669482f, 
    -0.06236752f, -0.02054341f, -0.02268310f, -0.03887717f, 0.02476085f, 0.02889188f, 0.03276788f, 0.01702243f, 
    -0.05075892f, -0.00221917f, -0.05531454f, -0.04428106f, -0.03316380f, 0.04500901f, 0.04816613f, -0.00421444f, 
    -0.05761590f, 0.01580775f, -0.04252730f, 0.01617257f, -0.03939391f, -0.02476856f, 0.00844146f, -0.03497047f, 
    0.00323138f, -0.01376741f, 0.02924502f, 0.01350821f, -0.02832156f, -0.02360562f, 0.05606982f, -0.05239301f, 
    0.00928269f, -0.01735256f, 0.00200776f, 0.01247186f, 0.02779478f, -0.05093274f, -0.05240102f, -0.00457746f, 
    -0.02944464f, -0.04165374f, 0.04162145f, -0.05290163f, 0.04425111f, -0.01484573f, -0.00540830f, -0.01912223f, 
    -0.00798994f, 0.02646235f, 0.01943354f, 0.00469241f, 0.03726907f, -0.00656749f, -0.04070073f, 0.03862053f, 
    -0.03803139f, -0.05678010f, 0.02311239f, -0.03560416f, 0.04479687f, 0.00237950f, 0.01774579f, -0.06385139f, 
    -0.03838658f, -0.02148731f, -0.02221619f, -0.02655545f, 0.00262132f, 0.00422499f, -0.04297566f, -0.00402227f, 
    -0.03230864f, -0.00407165f, 0.01982747f, 0.00659654f, -0.01142361f, -0.05597577f, -0.02527000f, -0.03304764f, 
    0.03686172f, 0.04129148f, 0.05566514f, -0.05970069f, 0.04423532f, -0.05407735f, 0.04504835f, 0.02589062f, 
    0.00110483f, -0.04036013f, -0.02179118f, 0.00310334f, -0.04547016f, 0.03870137f, -0.01547289f, 0.03316969f, 
    -0.03837552f, -0.02064634f, -0.01784520f, -0.01221755f, -0.04350052f, -0.03084500f, -0.00789287f, -0.04008037f, 
    -0.01411387f, 0.02156226f, 0.02442007f, 0.05225397f, -0.01124558f, 0.00519297f, 0.02149301f, -0.01913813f, 
    -0.04016762f, 0.03022867f, 0.05282841f, -0.03578242f, -0.01145965f, -0.04610790f, 0.00600309f, -0.00383881f, 
    0.04130939f, 0.03771361f, 0.02297260f, -0.02226526f, 0.03082482f, -0.00873604f, 0.04083512f, -0.01695650f, 
    0.01274713f, 0.03724436f, -0.02116825f, 0.04157909f, 0.00921050f, -0.03229031f, -0.03905335f, -0.01893594f, 
    -0.04072727f, -0.00499185f, 0.00975092f, -0.02656966f, 0.02058787f, -0.03455859f, -0.04260400f, -0.05779715f, 
    -0.02590421f, 0.01318999f, 0.04517283f, 0.00743741f, 0.04424724f, -0.06115039f, 0.04964234f, 0.04243072f, 
    0.00666924f, 0.02584857f, -0.02316428f, 0.04285048f, 0.00259581f, -0.02065918f, 0.01880130f, -0.05293480f, 
    -0.02001072f, -0.04209605f, 0.00296098f, 0.03363406f, 0.02619155f, -0.00707035f, -0.02924380f, -0.00951611f, 
    -0.02467141f, -0.05970852f, -0.03700485f, -0.06024450f, -0.02919704f, 0.01931357f, -0.01989761f, 0.01884904f, 
    -0.05620281f, -0.05828854f, 0.00807075f, -0.00317976f, -0.02126251f, 0.02627467f, 0.02653248f, -0.03334165f, 
    -0.04028655f, 0.03483573f, -0.01641799f, 0.01670794f, -0.05643294f, 0.02648238f, -0.00782172f, -0.01005578f, 
    -0.01775798f, 0.01544235f, 0.03663856f, 0.04301026f, 0.01733073f, 0.04582545f, 0.01941445f, 0.02771157f, 
    -0.03297781f, 0.00114740f, 0.02144587f, -0.00557800f, 0.02366336f, -0.02428634f, -0.04173751f, 0.00455868f, 
    -0.03097485f, -0.05634071f, -0.00100222f, 0.01844258f, -0.02952991f, -0.05328821f, -0.02996757f, -0.05850215f, 
    0.04602873f, 0.00863921f, 0.00334465f, -0.05578585f, -0.00168163f, -0.04009100f, 0.05448310f, -0.01273645f, 
    -0.02509687f, 0.02655604f, 0.00497718f, 0.02130603f, -0.00797211f, -0.00075772f, -0.05056440f, 0.02896534f, 
    -0.02649216f, 0.04069428f, -0.04165786f, -0.02014334f, -0.05117402f, -0.02336277f, 0.03356454f, 0.04478183f, 
    -0.02945045f, -0.03051341f, -0.05978233f, -0.01334820f, 0.04112303f, 0.02478748f, -0.00795712f, 0.01991912f, 
    -0.05400975f, 0.04264081f, -0.00910176f, -0.02294234f, -0.01718617f, 0.03197506f, 0.01409270f, 0.01694423f, 
    -0.01784123f, -0.03774268f, 0.06503657f, -0.05101359f, -0.05929117f, -0.05267967f, 0.00578961f, -0.03727632f, 
    -0.02039868f, 0.01321092f, 0.00577305f, 0.02900018f, 0.03423659f, -0.02404913f, -0.05420611f, -0.05333641f, 
    -0.00468719f, 0.04694847f, -0.01061440f, 0.02938261f, -0.00221817f, -0.04642495f, 0.01166612f, -0.05230904f, 
    0.02114761f, -0.03194866f, 0.01158706f, 0.02914561f, -0.04152787f, -0.03128281f, 0.04015398f, -0.06210776f, 
    0.03376956f, 0.02376666f, 0.04392473f, -0.02738362f, -0.03605278f, 0.03676353f, 0.03109937f, -0.03957143f, 
    0.04764917f, -0.04847700f, 0.01229124f, -0.04658109f, 0.04113032f, 0.01502343f, 0.03698543f, -0.03627632f, 
    -0.05471239f, -0.03993227f, 0.04934809f, -0.01471752f, 0.03379191f, -0.02327272f, -0.01918232f, 0.00341053f, 
    0.01809554f, -0.03006048f, -0.05738605f, -0.00230438f, -0.03100670f, 0.03872634f, 0.02008524f, 0.02511727f, 
    -0.05011958f, -0.00836395f, -0.03473430f, -0.03504164f, -0.01709961f, -0.04067107f, -0.05220662f, 0.03860235f, 
    -0.04824546f, 0.04334986f, -0.01603333f, -0.05098404f, 0.02069725f, 0.02482960f, -0.00704623f, 0.02176760f, 
    -0.01011545f, -0.06038379f, -0.06002056f, 0.00168712f, 0.01220136f, 0.00678719f, -0.01282952f, 0.03010731f, 
    0.01941663f, -0.00632491f, -0.00659645f, 0.01483061f, 0.00739329f, 0.02908658f, 0.04181592f, 0.04195827f, 
    0.00614605f, -0.05421256f, 0.00489688f, -0.03869708f, 0.00119769f, 0.01346231f, 0.00826656f, 0.02393130f, 
    0.01019513f, -0.02639942f, -0.04228227f, 0.01781286f, 0.03958609f, 0.01175116f, -0.03725503f, -0.02499084f, 
    -0.03878805f, -0.00178060f, -0.02276340f, -0.00746964f, -0.05286535f, 0.03521445f, -0.06509621f, -0.01324731f, 
    0.00094882f, -0.00517874f, -0.00979413f, -0.02434775f, -0.00577022f, 0.00580336f, -0.00128279f, -0.03719058f, 
    -0.01021557f, -0.04167763f, 0.02377379f, -0.03069685f, -0.02478876f, -0.05602409f, -0.03129572f, -0.05755004f, 
    0.04300182f, -0.03259654f, -0.06449685f, -0.00779524f, 0.03249286f, -0.03777356f, 0.01743633f, 0.00802084f, 
    -0.04622250f, 0.00311579f, -0.02834867f, 0.03790243f, 0.04002900f, 0.02141321f, 0.00004409f, 0.03649090f, 
    0.03462910f, 0.00045821f, 0.00748562f, 0.04066476f, 0.02032935f, 0.02285933f, -0.04272036f, -0.02454685f, 
    0.02886814f, -0.04518763f, 0.00109111f, 0.02433323f, -0.04302927f, 0.04127199f, 0.03596623f, -0.05831319f, 
    0.01836868f, -0.02552025f, -0.00704574f, 0.01385397f, 0.05231563f, -0.02312722f, -0.05590956f, 0.00974587f, 
    -0.00439495f, -0.02005174f, -0.05763189f, 0.02204125f, 0.01708283f, 0.04603282f, -0.01846912f, -0.03376741f, 
    -0.01117054f, -0.00434376f, -0.00886354f, 0.02025060f, 0.02265534f, 0.03478008f, -0.02692417f, -0.01490267f, 
    -0.02710329f, -0.04582047f, -0.01754735f, -0.05623820f, 0.02125178f, 0.00490087f, 0.01527616f, 0.00511575f, 
    0.01783539f, -0.05399111f, 0.05030941f, -0.03141479f, -0.01134112f, -0.05119887f, 0.03906096f, 0.00894906f, 
    0.00975982f, 0.04566857f, -0.01124541f, -0.01472094f, -0.04262057f, 0.04226092f, 0.02759653f, 0.04697390f, 
    -0.03579672f, 0.03840416f, -0.01673672f, 0.02726275f, -0.04831212f, -0.03794480f, 0.01853033f, 0.01868863f, 
    -0.01774482f, -0.00980783f, -0.03879945f, -0.00034320f, 0.01276784f, 0.01172150f, 0.00094611f, -0.03134029f, 
    -0.05721310f, 0.00165505f, -0.05165775f, -0.03037890f, -0.04429586f, -0.02162166f, 0.02274988f, -0.01789288f, 
    0.02503262f, 0.00444546f, -0.05895892f, 0.01362913f, 0.03376522f, -0.02026710f, 0.03011325f, 0.04224711f, 
    0.02873016f, 0.04081938f, -0.02206255f, -0.03058649f, -0.02931402f, 0.02802040f, -0.03485832f, 0.04080646f, 
    -0.05704307f, 0.04394250f, -0.05899303f, -0.03046969f, -0.03924165f, -0.05391067f, 0.04855609f, -0.06027456f, 
    -0.01890980f, 0.04500854f, -0.05009491f, -0.03497563f, 0.01665797f, -0.03355640f, -0.04683943f, 0.03347643f, 
    -0.01048544f, -0.01977484f, -0.01084171f, 0.02282781f, 0.00726036f, -0.04210873f, -0.01695000f, 0.03899676f, 
    0.00300277f, 0.03517626f, 0.03824629f, -0.00529347f, -0.01469358f, 0.01336010f, 0.02500610f, 0.01296314f, 
    -0.02892828f, -0.04358333f, -0.05853271f, -0.04879447f, -0.01555074f, -0.01467423f, 0.00514105f, -0.00770763f, 
    0.02604621f, 0.03858675f, -0.02998952f, 0.03921591f, -0.02783406f, -0.06228153f, 0.04716751f, 0.01512577f, 
    0.02953162f, 0.00035655f, 0.00610501f, -0.01832815f, 0.01210390f, 0.03812692f, 0.02845841f, -0.03595368f, 
    -0.01043742f, -0.04032066f, 0.01186274f, -0.02347189f, 0.01412579f, -0.02082163f, -0.03628423f, -0.01577592f, 
    -0.06452592f, -0.02000782f, 0.04605401f, -0.04650702f, -0.03981772f, 0.01442158f, -0.04180127f, 0.03586839f, 
    -0.02060353f, 0.02380978f, -0.04126940f, 0.02267570f, -0.00437244f, 0.00415992f, -0.02722011f, 0.01302714f, 
    -0.02079511f, -0.02688954f, 0.03720602f, -0.03713818f, -0.02746378f, 0.00052793f, -0.04036974f, -0.03076350f, 
    -0.02347410f, 0.03779773f, 0.01576863f, -0.01026924f, -0.00789737f, -0.04768888f, -0.01530796f, -0.06018491f, 
    -0.02167067f, -0.00941932f, -0.01756280f, 0.04471618f, 0.01974348f, -0.02295870f, -0.04691014f, -0.05542610f, 
    0.00449860f, 0.01865054f, 0.02701364f, -0.03112090f, -0.00621634f, 0.03032548f, 0.00217520f, -0.03122705f, 
    -0.01520830f, -0.01184698f, 0.01853952f, 0.01555290f, 0.00391398f, 0.00028860f, -0.02145340f, 0.00814776f, 
    0.02602222f, -0.00012498f, -0.00904726f, 0.03946858f, -0.02700843f, -0.01540169f, -0.01675637f, -0.04108670f, 
    0.00414159f, -0.01839284f, -0.02018328f, 0.04493577f, 0.01580323f, -0.01655238f, 0.00260252f, -0.02921805f, 
    0.00923666f, 0.01430233f, 0.02099289f, 0.03780567f, 0.04050763f, -0.02387034f, 0.03543953f, -0.02684684f, 
    -0.05377593f, 0.03518676f, 0.02130804f, -0.01131986f, 0.03993138f, -0.02428346f, -0.03525112f, 0.04468094f, 
    -0.02647699f, -0.04088833f, -0.00825199f, 0.04224386f, -0.02850491f, 0.01040914f, -0.02058445f, -0.04019066f, 
    -0.00011804f, 0.00818479f, -0.05737331f, 0.00971967f, -0.00031668f, 0.04248660f, 0.02544581f, 0.01325218f, 
    0.03688637f, 0.00478690f, -0.04866683f, -0.01419761f, 0.00818762f, -0.01449817f, -0.05086180f, -0.03712858f, 
    -0.05498868f, -0.02799509f, -0.03549440f, 0.00667690f, -0.03176040f, -0.04360341f, -0.01904677f, 0.05364366f, 
    -0.03938817f, 0.01879675f, 0.04247723f, -0.04442872f, -0.01502676f, -0.05780914f, -0.01628128f, -0.01863847f, 
    -0.01930114f, 0.01605507f, -0.06232566f, -0.05325857f, 0.03235129f, 0.00615490f, -0.05500514f, -0.01507792f, 
    -0.00183229f, -0.02709338f, -0.03715216f, 0.03808580f, 0.03859689f, 0.02643631f, -0.01605638f, 0.04687336f, 
    0.01643816f, 0.01048244f, 0.03852335f, -0.03214034f, 0.00200143f, 0.03593022f, -0.03588137f, -0.01952675f, 
    0.01827225f, -0.04487229f, -0.03244194f, 0.00146572f, 0.00102405f, -0.05049137f, -0.00853312f, -0.00093765f, 
    -0.03075981f, 0.02199037f, 0.03858493f, 0.03625405f, -0.05408900f, 0.00153417f, 0.02076293f, -0.00000321f, 
    -0.00128568f, -0.04382420f, 0.02450107f, -0.01732413f, 0.00754846f, 0.01388211f, 0.01808911f, -0.04715013f, 
    -0.02729635f, 0.02401010f, 0.02388728f, 0.01602394f, 0.03128260f, 0.04127077f, 0.02079075f, 0.00238685f, 
    0.03979672f, 0.05232514f, 0.01228740f, -0.02366924f, -0.01568046f, -0.00750054f, 0.04201071f, 0.04041437f, 
    0.03302628f, -0.04601658f, -0.02957078f, -0.02872062f, -0.05539809f, -0.05913538f, -0.05908053f, 0.00910084f, 
    0.03943966f, -0.04733549f, -0.01536904f, 0.01143963f, 0.03455916f, -0.00039241f, 0.04702603f, -0.03175204f, 
    0.00149209f, -0.03210042f, -0.00722477f, -0.03146446f, -0.02181203f, 0.01132478f, -0.06501608f, 0.03093953f, 
    0.03853818f, -0.06083661f, -0.01531573f, 0.00209603f, -0.04221239f, 0.03106932f, -0.01963626f, -0.03865533f, 
    0.02932682f, -0.03867675f, 0.00272036f, -0.03732945f, -0.00062283f, 0.03766123f, -0.02386381f, -0.04189285f, 
    0.02465271f, -0.02894667f, 0.04531384f, 0.00088706f, 0.00957156f, 0.01776706f, -0.02061454f, 0.04768252f, 
    -0.05683575f, -0.02135455f, 0.01671407f, -0.03952505f, -0.06700834f, -0.01070522f, 0.02913012f, 0.03167820f, 
    -0.03080334f, 0.04914264f, -0.02922655f, -0.01191990f, 0.02065602f, -0.01759049f, -0.05883374f, 0.00920808f, 
    -0.02482087f, 0.00187752f, -0.01701346f, 0.01336740f, 0.05493231f, 0.04675470f, -0.04679197f, 0.02149454f, 
    0.03595043f, 0.01598245f, -0.02674311f, -0.00871624f, 0.02074256f, -0.01111044f, -0.03349992f, -0.00283588f, 
    0.01827082f, -0.03057719f, 0.02181375f, -0.03231010f, 0.03412100f, -0.06458274f, 0.01064655f, -0.01524768f, 
    -0.03288517f, -0.02323375f, 0.02070009f, -0.06469431f, 0.02648232f, -0.05857062f, 0.01989747f, 0.03327997f, 
    0.03737856f, -0.04610217f, -0.02772478f, -0.04154386f, 0.01746785f, -0.04169561f, -0.03917717f, 0.01929007f, 
    0.04049383f, -0.01643091f, -0.05072298f, 0.00174200f, 0.02417478f, -0.00730423f, 0.02769857f, 0.00252688f, 
    -0.06211459f, -0.01925445f, -0.10134628f, 0.10418556f, -0.37460893f, -0.00660397f, -0.02683741f, -0.00485078f, 
    0.00259235f, -0.06705940f, -0.01840128f, 0.07046195f, -0.03217805f, 0.00329269f, -0.04267595f, 0.07236134f, 
    0.00154090f, 0.00584867f, -0.02753440f, 0.00527317f, -0.03042782f, 0.00097144f, -0.00058818f, -0.06034039f, 
    0.24553819f, -0.01182867f, 0.02633457f, 0.10390266f, -0.03385748f, 0.09832950f, -0.03461588f, 0.06692128f, 
    -0.03325017f, 0.00264220f, 0.01045544f, -0.07523727f, 0.05913642f, 0.03774714f, -0.00968793f, -0.07738566f, 
    -0.00864703f, 0.37645498f, -0.14068505f, 0.01058976f, 0.09385399f, 0.11373993f, 0.08718709f, -0.07182258f, 
    -0.13669129f, 0.06362408f, 0.00757583f, 0.08259197f, 0.06660382f, 0.01297911f, -0.05392522f, -0.04788363f, 
    0.14641717f, 0.09731879f, -0.04900674f, 0.09613783f, -0.05504113f, 0.07718626f, 0.15296400f, 0.03829246f, 
    0.00712245f, 0.13395450f, 0.07817318f, -0.00980814f, 0.06074623f, -0.14277366f, 0.06850012f, 0.04571463f, 
    0.02149511f, -0.04786089f, 0.05488392f, 0.04189053f, 0.02539223f, 0.01240363f, -0.01338145f, -0.05150347f, 
    0.01638300f, 0.00355569f, -0.02832630f, -0.17271240f, -0.36036602f, -0.07124612f, 0.06563551f, 0.00826853f, 
    0.01171030f, 0.03279667f, 0.04149546f, -0.08822379f, -0.05766769f, -0.06031859f, 0.00548488f, 0.02794652f, 
    -0.00278576f, 0.03473150f, 0.01507952f, 0.08992058f, -0.00435950f, 0.19262190f, -0.00264003f, -0.03094230f, 
    0.49848175f, -0.01540707f, 0.02950438f, -0.02072431f, -0.04072187f, 0.02643798f, -0.09305955f, -0.02545473f, 
    0.12456919f, -0.01447744f, 0.06082148f, 0.00290630f, -0.01345244f, 0.03428322f, 0.06886350f, 0.08934010f, 
    -0.11439371f, 0.07402359f, 0.07769286f, -0.04867255f, 0.14684081f, 0.10462407f, -0.02730720f, 0.02031481f, 
    -0.07769348f, -0.10140385f, 0.00808202f, -0.02962087f, 0.05474078f, 0.03608544f, -0.03776550f, -0.03084512f, 
    0.07663920f, -0.07719139f, 0.00328792f, 0.00001955f, 0.17857358f, 0.07416426f, 0.00372176f, -0.12592909f, 
    0.10604689f, 0.00872115f, 0.03259707f, 0.11299621f, -0.03377106f, -0.06660538f, -0.03856890f, -0.04188439f, 
    -0.00150838f, -0.04633274f, 0.06841394f, 0.04132104f, -0.09435967f, -0.01957200f, 0.02718153f, 0.01102369f, 
    0.10630780f, -0.12716962f, -0.05018968f, 0.04608170f, 0.00377905f, -0.05416694f, 0.05808970f, -0.01957064f, 
    -0.02823644f, 0.01112060f, 0.06440246f, 0.03145304f, -0.00703620f, 0.02784295f, 0.04148797f, 0.03654894f, 
    -0.04607218f, 0.06139074f, 0.07207004f, 0.02010459f, -0.23146912f, -0.07628185f, 0.00747151f, -0.07818823f, 
    -0.31725374f, 0.00867679f, -0.00614607f, 0.08784895f, -0.02054232f, 0.02698179f, 0.00981519f, -0.02439785f, 
    0.06119452f, 0.02769770f, 0.14688741f, -0.03281953f, -0.00601582f, 0.01797924f, -0.05140691f, -0.07100895f, 
    -0.06761203f, 0.11573613f, 0.13082710f, 0.01281124f, 0.18594033f, 0.01379055f, 0.11473775f, 0.10169169f, 
    0.05690359f, -0.10520145f, -0.08388979f, -0.01861380f, -0.00337101f, 0.02798479f, -0.04245486f, -0.04700888f, 
    0.02987326f, -0.00862086f, -0.05466840f, 0.03498041f, 0.04629332f, 0.04573316f, 0.06948601f, -0.01298649f, 
    0.09991432f, -0.00632475f, 0.04415760f, 0.02598157f, -0.00691076f, 0.00009424f, 0.05528478f, 0.04577818f, 
    0.01416079f, -0.01996506f, -0.05060286f, -0.00224314f, -0.02949939f, 0.07397160f, 0.03439212f, -0.04697135f, 
    -0.11752455f, 0.23640199f, -0.04302211f, -0.07442138f, 0.16569327f, 0.11006266f, 0.05465715f, -0.02110449f, 
    0.05823801f, 0.03564828f, -0.03851512f, -0.07881811f, 0.03921922f, -0.02327052f, -0.00719805f, -0.02701326f, 
    0.00613961f, -0.03797869f, -0.03112788f, -0.07610984f, -0.17579497f, -0.04054752f, 0.08435642f, 0.00600282f, 
    0.05509811f, 0.12217029f, 0.03296522f, 0.15932013f, -0.02863881f, 0.02677255f, -0.02950617f, 0.00717885f, 
    0.08911613f, 0.04474900f, -0.02875369f, -0.08644666f, 0.03396186f, -0.05703545f, 0.03026068f, -0.09816071f, 
    0.07775005f, 0.16603024f, -0.12108228f, 0.03784953f, 0.16246139f, 0.06931271f, -0.09181952f, -0.03183416f, 
    0.04107556f, -0.06138076f, 0.04913679f, 0.11760566f, -0.00897970f, 0.01699734f, 0.04129739f, 0.03625263f, 
    -0.04879994f, 0.07936613f, 0.15564357f, 0.03206790f, -0.25991297f, 0.01670972f, -0.01562474f, -0.01329382f, 
    0.27724266f, -0.02827133f, -0.09364317f, 0.06757592f, -0.04465401f, 0.00213045f, 0.05308077f, -0.04190247f, 
    -0.09040967f, 0.11203223f, 0.09241284f, 0.02728176f, 0.01144522f, 0.06102110f, -0.06129280f, -0.08460292f, 
    -0.04110108f, -0.35122365f, -0.19526602f, 0.06155784f, -0.22750708f, 0.03696956f, 0.04077536f, -0.14778711f, 
    0.00204296f, -0.00163035f, -0.01082249f, -0.02316093f, 0.07793830f, 0.01182283f, -0.00644810f, 0.11168735f, 
    0.02444587f, -0.00398281f, 0.11456953f, 0.07595517f, 0.40906295f, 0.09647989f, 0.11093988f, -0.21127117f, 
    -0.01762219f, 0.03142890f, 0.07767633f, 0.05789361f, 0.07203716f, 0.05692428f, -0.01658579f, 0.07072079f, 
    0.08764192f, -0.00211873f, -0.03932424f, 0.11990149f, 0.18146567f, 0.09878094f, 0.02531471f, 0.09665295f, 
    -0.36253190f, 0.32517198f, -0.01098955f, -0.14819004f, 0.03218326f, 0.06971826f, 0.05624899f, 0.02084754f, 
    -0.09545979f, -0.00153074f, 0.03324072f, -0.05341225f, -0.04535465f, 0.04559086f, 0.00224494f, 0.09505830f, 
    0.03419967f, 0.02069482f, 0.02924193f, 0.15315410f, 0.04143448f, -0.06090719f, -0.04888188f, 0.03432484f, 
    -0.05308142f, 0.05745254f, 0.11714853f, 0.04859307f, 0.14628235f, -0.03103604f, 0.03685298f, -0.03092046f, 
    -0.08068392f, -0.06273644f, 0.03766190f, -0.07382340f, 0.06410439f, 0.02347459f, -0.04494777f, 0.00721744f, 
    0.07360636f, 0.04854986f, -0.09030519f, -0.05221265f, -0.34843367f, 0.10853115f, 0.13727756f, -0.15350083f, 
    -0.02554856f, -0.00462544f, -0.01028494f, 0.04901457f, -0.01829856f, 0.00604684f, 0.03730204f, -0.02832204f, 
    0.11405883f, 0.18050586f, 0.07257588f, -0.02692473f, -0.04395569f, 0.07226814f, -0.10121087f, -0.05851772f, 
    0.30434933f, 0.00413733f, -0.01824785f, -0.01888980f, -0.01027370f, -0.03406979f, -0.10673223f, -0.05815737f, 
    0.09562439f, 0.11281243f, 0.02053420f, 0.01774774f, -0.04851650f, 0.00266830f, -0.07987192f, -0.00673061f, 
    0.00906503f, -0.07212555f, 0.21158810f, -0.09770100f, 0.10309974f, 0.09547716f, 0.08275479f, 0.10100513f, 
    -0.13679425f, -0.05722030f, 0.00087167f, 0.09730090f, -0.01963872f, -0.07558525f, -0.01420488f, -0.08608485f, 
    0.05251239f, -0.05230964f, -0.15616381f, 0.01648213f, 0.17373861f, -0.07419519f, 0.13195434f, -0.04013389f, 
    -0.03112810f, 0.10974925f, -0.01823639f, 0.04567647f, 0.06520396f, -0.02582712f, -0.03217433f, 0.01046743f, 
    -0.02078390f, 0.08857046f, 0.06121163f, 0.00756383f, 0.02336545f, -0.01425580f, -0.12043043f, 0.03314780f, 
    0.19477665f, -0.13569550f, -0.05472960f, -0.09678969f, -0.04473305f, 0.05046054f, 0.03167380f, -0.02508542f, 
    0.04181432f, -0.00764779f, -0.00640940f, -0.05002986f, 0.02523092f, 0.14943142f, 0.07657169f, -0.02428088f, 
    -0.01838593f, -0.02791908f, -0.04531344f, -0.03669227f, -0.04798682f, 0.00764756f, 0.00383615f, -0.11458209f, 
    -0.15995246f, 0.04570413f, 0.20078893f, 0.18567401f, -0.06106075f, -0.02619639f, 0.11921809f, -0.05045655f, 
    0.03319943f, 0.04499860f, 0.12930110f, -0.12260297f, -0.05284441f, 0.09376145f, 0.10764502f, -0.02650243f, 
    -0.00404417f, 0.04766156f, 0.24600425f, 0.06237669f, 0.16715235f, -0.00026414f, 0.16562811f, 0.05396025f, 
    0.03775427f, 0.04827636f, 0.00143067f, -0.07662367f, 0.02165725f, -0.05819671f, -0.12713251f, 0.02482087f, 
    0.07387584f, -0.12373283f, 0.01369695f, 0.00049295f, -0.05014344f, -0.02148831f, 0.23537768f, 0.01297481f, 
    -0.04244693f, -0.00793750f, 0.01376785f, -0.01801790f, -0.07501405f, 0.01602001f, 0.00484083f, 0.06086295f, 
    0.01790223f, 0.00387723f, -0.06261862f, -0.06273883f, 0.08727759f, 0.01949072f, 0.05022587f, -0.03073139f, 
    0.19748427f, 0.02930494f, 0.06325939f, -0.17250378f, 0.07923127f, 0.06146336f, 0.16068462f, 0.04816713f, 
    0.01124785f, 0.03196649f, 0.04162569f, -0.01236838f, 0.10496094f, 0.08878731f, -0.01771704f, 0.06309674f, 
    0.04416258f, 0.03354627f, 0.04554122f, 0.00335406f, 0.41268760f, 0.08364244f, -0.03954799f, 0.20987113f, 
    0.00244675f, -0.01425031f, -0.05399235f, -0.01641574f, -0.09960984f, -0.01485662f, 0.02643357f, 0.05678394f, 
    -0.11268220f, -0.11224699f, -0.02599550f, -0.03463851f, -0.03507274f, 0.08909591f, 0.11224870f, 0.07172054f, 
    0.06164725f, 0.15895639f, -0.21434434f, -0.17873381f, 0.13481316f, 0.05351420f, -0.08813852f, -0.07032047f, 
    -0.05031935f, 0.00024679f, 0.07412063f, 0.08082345f, -0.00139117f, 0.04584343f, 0.04973837f, -0.02984957f, 
    0.02930398f, -0.03762208f, -0.14066425f, -0.10666557f, -0.36853108f, 0.09091821f, -0.06020371f, -0.00952267f, 
    0.25523108f, -0.04326313f, -0.06058439f, -0.05873344f, 0.03880973f, 0.00992130f, 0.03521848f, -0.03390418f, 
    0.00940178f, 0.01451806f, 0.02900510f, -0.05244769f, -0.00337454f, -0.13331816f, -0.03777074f, -0.11981001f, 
    0.18755780f, 0.17429963f, -0.08305734f, -0.19407335f, 0.05577485f, -0.02796159f, 0.06417997f, -0.06107248f, 
    0.08180870f, 0.01451823f, 0.06583994f, 0.01768900f, 0.07707419f, 0.06421025f, 0.06794844f, 0.02778699f, 
    0.00006956f, -0.10513300f, -0.03696888f, 0.04614792f, -0.10324147f, 0.08999755f, -0.03527789f, 0.07237720f, 
    0.05652959f, 0.07110437f, 0.01385291f, 0.02250035f, 0.02162321f, 0.05740975f, -0.06321292f, 0.02208560f, 
    -0.11019494f, -0.02068510f, -0.10070891f, 0.14475688f, 0.05203401f, -0.15189403f, 0.18952319f, 0.02033202f, 
    0.11261726f, 0.02917547f, -0.01401634f, -0.21142296f, -0.16910172f, 0.02626427f, -0.05192605f, 0.15226042f, 
    -0.11000632f, -0.04043546f, 0.09607013f, 0.00984446f, -0.03373521f, -0.15242034f, 0.02549483f, -0.01103090f, 
    -0.04966446f, 0.17626578f, -0.01529284f, -0.01072404f, 0.16789173f, 0.21615264f, 0.10495888f, 0.04246821f, 
    0.02288471f, -0.06315118f, -0.03392504f, -0.06543216f, 0.04888522f, 0.20303267f, -0.00606101f, -0.08447647f, 
    0.04709606f, 0.10353612f, 0.09687074f, 0.05740923f, 0.01928119f, -0.00492789f, 0.10666564f, -0.04466289f, 
    0.16445057f, -0.30457139f, -0.11064153f, -0.06043294f, 0.03544205f, -0.02368520f, 0.10245484f, 0.06061820f, 
    -0.04381890f, -0.02110965f, -0.03239775f, 0.02194021f, 0.00378472f, 0.12052976f, 0.01924552f, 0.05822913f, 
    0.01651558f, -0.01577804f, -0.02361550f, 0.09495009f, -0.01579387f, 0.04811758f, 0.03173542f, 0.05626127f, 
    0.22340567f, -0.00386266f, 0.07721036f, 0.00428410f, 0.00016368f, 0.00124516f, 0.00697497f, -0.05201633f, 
    0.02849273f, 0.13302369f, -0.00981686f, 0.03773193f, 0.06767082f, 0.05236386f, 0.11613106f, 0.00312697f, 
    0.39402947f, -0.10427376f, 0.08339524f, 0.29637185f, 0.04583642f, -0.10181159f, -0.00051805f, -0.06023901f, 
    0.10827262f, 0.09247689f, 0.01283855f, 0.06667688f, 0.04868303f, -0.02566642f, 0.06593115f, 0.11640809f, 
    0.02717254f, 0.07357572f, 0.03743932f, -0.03501379f, 0.14117427f, -0.10051004f, 0.03722029f, 0.08826894f, 
    -0.02601353f, 0.03216165f, 0.00513166f, 0.03600333f, 0.05211317f, 0.05896326f, 0.00001485f, 0.05553259f, 
    0.07331387f, -0.06295469f, -0.07550163f, -0.08415837f, 0.06002587f, 0.07940488f, 0.07881241f, -0.01318753f, 
    -0.20720220f, -0.16863035f, -0.09250674f, -0.00245687f, 0.13521427f, 0.08781882f, 0.15700139f, 0.01596140f, 
    -0.12498944f, -0.02844739f, 0.02556236f, 0.02420254f, 0.04409565f, 0.03496986f, -0.12259952f, 0.03346649f, 
    0.07661799f, -0.03542442f, -0.02496883f, 0.07098104f, -0.19287090f, -0.10744993f, -0.15373439f, -0.08484719f, 
    -0.25616568f, 0.04945416f, 0.03619661f, 0.10173094f, -0.02296288f, -0.05056100f, 0.04832910f, -0.03366731f, 
    0.13713439f, 0.01569494f, -0.00657065f, -0.04959724f, -0.03807577f, 0.07830609f, -0.07305879f, 0.09651895f, 
    -0.04077229f, 0.02802084f, 0.06221745f, 0.18250208f, -0.00138068f, 0.13768727f, -0.08337846f, 0.13987839f, 
    0.12560573f, 0.18170771f, -0.01249435f, -0.05460056f, -0.01367202f, -0.02033141f, 0.01259571f, 0.02681697f, 
    -0.00419107f, 0.10265787f, 0.13547586f, -0.10676394f, 0.10372292f, 0.15875760f, 0.00909912f, 0.16961564f, 
    -0.01979098f, 0.04302459f, 0.04034274f, -0.00217814f, 0.02671824f, 0.12234700f, -0.08515171f, -0.09523922f, 
    0.10320928f, 0.06189842f, 0.03144216f, 0.07290274f, -0.01102308f, 0.07311981f, 0.03018345f, 0.00451254f, 
    0.11404839f, 0.10123406f, 0.02136518f, -0.01052586f, 0.01373819f, -0.05415218f, 0.10539892f, -0.11818535f, 
    0.00676951f, 0.11801710f, -0.01854273f, 0.08163819f, -0.01156506f, 0.04687164f, 0.03342787f, 0.01573514f, 
    0.08677632f, 0.05867251f, 0.17240970f, -0.01442549f, 0.20713866f, -0.09193069f, 0.04039814f, 0.17502713f, 
    -0.09624508f, -0.06574479f, -0.01602253f, -0.00296115f, 0.07863060f, 0.09362903f, -0.03769386f, 0.07594653f, 
    0.03574633f, -0.04088359f, -0.00969318f, 0.00782019f, 0.10260753f, -0.00288313f, 0.03575454f, 0.00810429f, 
    0.10477641f, 0.12067055f, 0.14183939f, 0.14746776f, -0.04954348f, -0.04849298f, 0.14971234f, -0.06367060f, 
    -0.05720295f, -0.11120645f, 0.06366802f, 0.03379861f, -0.05763551f, -0.00342261f, -0.02345647f, 0.05845755f, 
    0.10145915f, -0.01575843f, 0.02391950f, 0.04027453f, -0.12456775f, -0.03017628f, -0.13087425f, -0.08046988f, 
    -0.07076573f, 0.10040119f, 0.04982178f, 0.07008903f, 0.03439389f, 0.04326356f, 0.06887752f, -0.05851349f, 
    0.01776604f, 0.10576117f, -0.07087580f, -0.00853548f, 0.05197689f, -0.06341663f, -0.02563648f, -0.00473628f, 
    0.02380889f, -0.05426607f, -0.05694011f, 0.00028759f, -0.02745485f, -0.00760085f, 0.01491189f, 0.03655616f, 
    0.01466011f, -0.00140832f, -0.00699636f, -0.04446608f, 0.00126487f, 0.03418390f, 0.03895916f, 0.01417265f, 
    -0.02769789f, 0.00831836f, 0.04380183f, 0.02329169f, -0.00512679f, -0.02319884f, 0.03283139f, 0.03004851f, 
    0.05263862f, -0.04905511f, -0.00903885f, -0.04475994f, -0.00766866f, 0.01098696f, -0.04491512f, 0.01231542f, 
    0.00718729f, 0.01692953f, 0.04223986f, 0.00872388f, -0.03624723f, 0.00001635f, 0.01447513f, 0.02969282f, 
    -0.03763839f, 0.04269730f, -0.01321364f, -0.02609964f, -0.02171672f, -0.01293947f, 0.04121698f, -0.01363916f, 
    -0.03103739f, 0.02207190f, 0.02796114f, -0.05693221f, -0.02215371f, -0.05308502f, 0.02388464f, 0.00692385f, 
    -0.05692736f, -0.04641814f, 0.04723470f, -0.03699630f, 0.02775048f, 0.02055398f, -0.00830707f, 0.04507149f, 
    -0.00440150f, -0.04437410f, -0.02219753f, 0.02977346f, 0.01546823f, 0.04014480f, 0.00934464f, -0.04905054f, 
    -0.05279552f, -0.04747528f, 0.00109868f, 0.04741359f, -0.03327619f, 0.01988874f, 0.02091826f, -0.01263452f, 
    0.03880406f, 0.04992657f, 0.00368094f, 0.02300829f, 0.00245020f, -0.04181866f, 0.01845694f, 0.03275170f, 
    -0.02286880f, -0.03655474f, 0.00785508f, -0.01483571f, -0.03872787f, 0.01861263f, -0.02652167f, -0.00900480f, 
    -0.01299994f, -0.01909806f, -0.00220754f, -0.05317868f, 0.04867646f, 0.03657774f, 0.01103138f, 0.01685269f, 
    0.01186811f, -0.05310749f, -0.01745322f, 0.00849280f, -0.04428680f, -0.03676908f, -0.01084439f, 0.02840848f, 
    -0.05103318f, 0.01986979f, 0.00277901f, 0.02738084f, 0.01460259f, -0.01797057f, 0.00433535f, 0.02057963f, 
    -0.02256008f, 0.00883251f, -0.00931005f, -0.03848573f, -0.04065023f, -0.05644913f, 0.00455219f, 0.00725142f, 
    0.02083089f, 0.00025297f, 0.04281073f, 0.01965259f, -0.05676273f, 0.02589325f, -0.03124930f, 0.04453496f, 
    -0.03163401f, 0.04618688f, -0.01880974f, -0.04319258f, -0.00036687f, -0.03310408f, 0.03004135f, -0.00044564f, 
    -0.01738378f, 0.04448106f, 0.03559447f, -0.04508382f, 0.01956535f, 0.00667998f, 0.01742900f, -0.04779163f, 
    0.02442558f, 0.01856093f, 0.02290073f, -0.03186984f, 0.01623869f, -0.05463460f, -0.05917012f, -0.00620166f, 
    0.00799743f, -0.01369977f, 0.00624699f, 0.02618856f, 0.01847638f, -0.00589540f, -0.04259470f, -0.01718906f, 
    0.00520326f, -0.04210343f, 0.00328120f, 0.02861968f, -0.05704888f, -0.01061204f, -0.01531946f, -0.00813150f, 
    -0.00393785f, 0.04134974f, -0.02332898f, 0.04704868f, -0.02763076f, 0.00326706f, 0.01122981f, -0.00415004f, 
    0.00437963f, 0.01271232f, -0.05281141f, -0.05941394f, 0.04339236f, 0.02630317f, -0.05410070f, 0.02828292f, 
    -0.04912591f, 0.00945957f, -0.00390230f, -0.05670945f, 0.04719912f, -0.01783462f, 0.00041590f, -0.03839561f, 
    -0.00031904f, -0.01725379f, -0.00849703f, -0.01285251f, 0.05256524f, -0.00284129f, -0.06273498f, -0.05295806f, 
    -0.02967585f, -0.04873530f, 0.03298048f, -0.03140919f, 0.02530558f, -0.01504019f, -0.00677701f, 0.00025712f, 
    -0.01678586f, 0.01888940f, 0.00321821f, -0.03110661f, 0.03809553f, -0.00024735f, 0.00322268f, -0.03643029f, 
    -0.03269900f, -0.00695069f, 0.01180366f, -0.00822657f, -0.02980867f, -0.03456580f, -0.02686393f, -0.03058648f, 
    -0.01010210f, -0.01267010f, -0.05927799f, -0.02048606f, 0.03090706f, 0.03600804f, 0.04586011f, -0.02636644f, 
    -0.00776427f, -0.01216958f, -0.01980539f, 0.04630600f, -0.02671395f, 0.00948848f, -0.03224813f, -0.02056567f, 
    0.00776008f, -0.05500599f, -0.05270443f, -0.04013856f, 0.05312201f, 0.05035451f, -0.00314987f, 0.01846957f, 
    0.03963540f, -0.00784228f, -0.02112442f, 0.03094209f, -0.05739279f, 0.03163981f, -0.05444322f, -0.04439780f, 
    0.04455021f, -0.03340887f, -0.03164658f, 0.03017403f, 0.02398623f, -0.01905676f, 0.00608775f, 0.04315147f, 
    -0.04014245f, -0.05782758f, 0.01132471f, 0.02575262f, -0.00096341f, -0.00069952f, 0.04691017f, -0.04461568f, 
    0.01655252f, -0.05910736f, -0.04057255f, -0.00865544f, -0.01111419f, 0.03462046f, -0.03468219f, -0.02173273f, 
    0.01168861f, 0.03091729f, -0.01575037f, -0.05320812f, -0.05495092f, 0.01299472f, -0.00194798f, -0.04754011f, 
    0.03259780f, 0.02724439f, -0.02576003f, 0.03695993f, 0.01760965f, -0.05374678f, 0.01036631f, 0.04591471f, 
    0.04184785f, 0.02903472f, -0.02352556f, 0.00575856f, -0.05278618f, -0.00041531f, 0.04544706f, 0.01039318f, 
    -0.01277003f, -0.04847283f, 0.00896713f, -0.02038404f, -0.04589879f, -0.03031602f, 0.03811594f, -0.01641395f, 
    -0.05370503f, -0.03281607f, -0.01401796f, -0.02457116f, 0.01365535f, -0.03145467f, 0.02384304f, -0.04246242f, 
    -0.05318352f, -0.01235163f, 0.02458903f, -0.03418504f, 0.02453050f, -0.03461000f, -0.03725436f, -0.03134146f, 
    -0.02503434f, -0.01821581f, 0.03834137f, -0.04581459f, 0.02326600f, -0.05714256f, 0.03479901f, -0.02041151f, 
    0.02997542f, 0.02130136f, 0.03861800f, -0.03938487f, -0.00459680f, -0.04622199f, 0.03753768f, -0.04455088f, 
    -0.01565668f, -0.02652743f, 0.04022178f, -0.06302954f, 0.03102708f, -0.05878130f, -0.02134544f, -0.05083008f, 
    0.02434277f, -0.02830218f, -0.05826983f, -0.00858963f, 0.05435810f, -0.02707570f, -0.02722025f, -0.05967576f, 
    -0.00783265f, 0.04178386f, -0.04624432f, 0.02289842f, 0.01975870f, -0.03708398f, 0.01899492f, -0.00105558f, 
    -0.04102763f, -0.02965325f, -0.05263420f, 0.04037884f, 0.02493147f, 0.02488125f, -0.03838918f, 0.00278901f, 
    -0.01232620f, -0.01502996f, -0.01418902f, 0.02289151f, -0.04589355f, -0.00377891f, -0.05835647f, 0.02152614f, 
    -0.03609512f, 0.01294846f, -0.01172698f, -0.02666829f, 0.01529476f, 0.03248091f, -0.02528798f, -0.02935118f, 
    -0.05688160f, -0.01715202f, 0.01975029f, 0.04625814f, -0.00772759f, 0.01694315f, -0.06130626f, -0.03387396f, 
    -0.04899189f, 0.02679384f, -0.00472433f, -0.01469622f, -0.01449287f, 0.04506303f, -0.01535143f, -0.02784814f, 
    -0.02455021f, -0.01312458f, -0.04253964f, 0.00083839f, 0.00058499f, 0.01011692f, -0.02294998f, 0.04881775f, 
    0.02533439f, 0.01640508f, 0.00164898f, 0.02879506f, -0.05630410f, -0.00457964f, -0.00411592f, 0.03921307f, 
    0.03690950f, -0.05194247f, -0.04234703f, -0.03612550f, -0.04530896f, 0.03644205f, -0.02444202f, -0.02819821f, 
    0.05658619f, -0.02535159f, -0.04457717f, 0.00437452f, 0.01962763f, -0.03740958f, -0.03929878f, 0.02003435f, 
    -0.01436676f, -0.03796243f, -0.00471364f, -0.02198999f, 0.01469492f, -0.02059607f, 0.03152160f, -0.04300035f, 
    -0.06156709f, -0.03321446f, -0.00925758f, 0.03593970f, 0.03820897f, -0.01609743f, 0.00279526f, -0.00138959f, 
    -0.00803203f, -0.01486195f, 0.03664087f, -0.02934908f, 0.04090808f, -0.03152167f, 0.03831185f, -0.04646361f, 
    0.01569119f, -0.05256908f, -0.04213241f, 0.01492362f, -0.02142647f, -0.04531123f, 0.03524119f, 0.03329520f, 
    -0.03971224f, 0.03053859f, -0.00714583f, -0.02595276f, -0.00957964f, -0.03391878f, 0.03918011f, -0.05310087f, 
    -0.06171791f, 0.02589106f, -0.03508889f, 0.02123791f, 0.03565027f, 0.04921469f, -0.01923797f, -0.01444986f, 
    0.04097953f, 0.03481127f, -0.04811367f, 0.02979163f, 0.00495381f, -0.06034659f, 0.02750952f, 0.02259434f, 
    0.05099763f, -0.03287217f, 0.03697899f, 0.04668455f, 0.03907389f, 0.05598721f, 0.04168875f, -0.06174924f, 
    -0.03551267f, -0.04026050f, 0.00455190f, 0.00609115f, 0.03716970f, -0.04746782f, -0.03334614f, -0.05158008f, 
    0.01784115f, 0.05681231f, 0.01808680f, 0.00456127f, -0.01732654f, -0.01962434f, -0.03432177f, -0.02238980f, 
    0.03551845f, 0.05325079f, -0.00295688f, 0.02781047f, 0.00221382f, 0.04415717f, 0.01416501f, 0.04558063f, 
    0.02914072f, 0.05661026f, 0.01841183f, 0.04635001f, -0.01184206f, 0.01572140f, 0.01310248f, 0.02740224f, 
    0.02768191f, 0.00091165f, -0.03634707f, 0.00555022f, 0.00605690f, -0.00041758f, -0.06001323f, 0.04329787f, 
    -0.05024284f, -0.04959342f, 0.03865935f, -0.03692302f, -0.05584482f, -0.02067079f, 0.04092022f, 0.03840642f, 
    -0.04056310f, 0.03643491f, 0.04969577f, -0.00842254f, 0.00590593f, 0.03052246f, 0.02193823f, 0.04366791f, 
    0.00414415f, 0.03051452f, -0.00860323f, -0.02352444f, 0.00380891f, 0.04075628f, 0.01713242f, 0.00307112f, 
    -0.04681306f, -0.01664418f, 0.04616906f, -0.00754469f, -0.02172529f, 0.02987106f, -0.03424012f, -0.00519275f, 
    -0.03173076f, 0.00796950f, 0.00593517f, -0.03103803f, -0.06178043f, 0.04134782f, -0.01782446f, 0.01183832f, 
    0.03746337f, -0.01482028f, 0.02788530f, -0.01400287f, 0.02750248f, -0.01627125f, -0.01136613f, 0.00139974f, 
    -0.02043849f, -0.03145073f, 0.00928226f, 0.03788616f, -0.00830287f, 0.05756321f, -0.02504017f, -0.06333998f, 
    -0.04172303f, -0.05518762f, 0.02758167f, -0.05142207f, -0.05489532f, 0.00167556f, -0.02772463f, 0.00448503f, 
    0.00629546f, -0.03705802f, -0.03533941f, -0.01619319f, 0.03194511f, -0.01350770f, -0.02553649f, -0.02677413f, 
    -0.01395700f, 0.03321357f, -0.00373635f, 0.00439341f, 0.01683052f, 0.01524550f, 0.01528207f, -0.04424646f, 
    -0.00185857f, -0.04310993f, 0.01415127f, 0.05293834f, -0.03782644f, -0.03650848f, -0.03992481f, 0.03606503f, 
    0.33454275f, -0.04432465f, 0.07361770f, -0.21165729f, 0.22653975f, 0.13459773f, 0.17028789f, -0.01232647f, 
    0.08851219f, -0.01463772f, 0.02019943f, -0.00711430f, -0.14009617f, 0.06758153f, 0.05605540f, 0.02312740f, 
    0.05183284f, -0.05541404f, 0.01341437f, 0.02818524f, 0.01458762f, 0.16442908f, -0.06490021f, 0.15870005f, 
    -0.10553697f, 0.12326848f, 0.02860446f, -0.02724159f, 0.02364683f, 0.07066499f, 0.03052714f, 0.09341061f, 
    0.05680497f, -0.03122525f, 0.02357723f, 0.11552306f, -0.00062882f, -0.03715590f, 0.26644427f, 0.06428590f, 
    -0.08092715f, -0.26620850f, 0.17401643f, 0.13150290f, -0.22548774f, -0.00533892f, -0.01742515f, 0.18434280f, 
    -0.01341795f, 0.06273960f, 0.02400522f, -0.02461104f, 0.00620999f, 0.06606181f, 0.03247006f, 0.07121690f, 
    0.11817638f, -0.01624299f, 0.02117610f, -0.02636733f, -0.35571745f, 0.08248216f, -0.16694576f, 0.10546500f, 
    -0.07758316f, 0.01002199f, 0.04932163f, 0.03996799f, -0.00848240f, 0.05593412f, 0.04973928f, -0.05908888f, 
    0.20815365f, 0.20716876f, 0.01970199f, 0.04771525f, -0.00389006f, -0.01540948f, -0.02524480f, 0.04990038f, 
    0.07275008f, -0.18808955f, 0.09445852f, 0.13498835f, 0.18124847f, 0.00635858f, 0.09698647f, 0.10211333f, 
    0.03479156f, 0.04043438f, 0.04921851f, 0.10953004f, 0.17084736f, 0.08854526f, 0.08050267f, 0.04873044f, 
    -0.02890907f, -0.04502432f, -0.08373362f, 0.04515492f, 0.21590559f, -0.13601328f, -0.11769125f, 0.01379751f, 
    -0.17542204f, 0.00371198f, 0.01492670f, 0.02416869f, 0.02540950f, 0.07690989f, 0.05276192f, 0.13471180f, 
    -0.05090280f, 0.12332515f, -0.04679814f, 0.01525920f, 0.08522971f, 0.12348082f, 0.08679432f, 0.11641046f, 
    0.12860991f, -0.06872407f, -0.37388688f, 0.18066201f, -0.02759015f, -0.14684485f, -0.04700382f, 0.03567225f, 
    0.17225827f, 0.06018239f, -0.04436122f, 0.01153895f, 0.01276124f, -0.00495039f, 0.10445429f, 0.14578801f, 
    0.01028980f, 0.18713489f, 0.11039208f, 0.04951436f, -0.07874459f, -0.20174603f, 0.01343478f, 0.08429419f, 
    -0.06987150f, -0.12060267f, 0.04870837f, 0.04339179f, 0.09290802f, 0.07210838f, 0.08804617f, 0.06914782f, 
    0.04038367f, -0.12695163f, 0.08316348f, -0.01010026f, 0.12100644f, 0.06237859f, 0.08101060f, -0.02048780f, 
    -0.34679908f, 0.03549740f, 0.31721696f, -0.09057502f, -0.08583964f, -0.00525772f, 0.19037750f, -0.03322993f, 
    -0.09342175f, -0.03194552f, 0.03049596f, 0.07458320f, 0.12444491f, -0.07935278f, -0.03467105f, 0.01214467f, 
    0.05533200f, 0.06151911f, 0.01359821f, -0.01740265f, -0.37390035f, 0.12190807f, -0.12800325f, 0.14879814f, 
    0.08215173f, 0.14412458f, 0.06918554f, 0.05412653f, 0.10783854f, -0.06218677f, 0.04577344f, 0.00394284f, 
    0.08459619f, 0.03243524f, 0.05715290f, 0.10584014f, 0.04181265f, -0.00485740f, -0.01139484f, 0.12070420f, 
    -0.04368683f, -0.08934522f, -0.16167763f, 0.04083702f, 0.04697808f, 0.03862597f, -0.12478454f, 0.02060136f, 
    0.00690000f, 0.20918018f, 0.02983961f, 0.00279059f, -0.01881175f, 0.10306568f, 0.07995624f, 0.01264153f, 
    -0.08882366f, 0.11267404f, -0.03059314f, 0.09149007f, -0.08708914f, -0.15108308f, -0.19397119f, 0.05940630f, 
    -0.02222723f, 0.03978501f, -0.05464023f, -0.00020298f, 0.01233787f, 0.07905199f, 0.03000041f, -0.06079622f, 
    0.05720858f, 0.03701336f, 0.09263580f, 0.02822983f, -0.01925458f, 0.11217478f, 0.03821770f, 0.16526112f, 
    0.04871112f, 0.00874718f, -0.08477370f, -0.00674107f, -0.12207590f, -0.01807289f, -0.08895990f, -0.05926910f, 
    0.01144274f, 0.08939280f, 0.12730874f, 0.01679794f, -0.03428200f, 0.03700558f, 0.00489235f, -0.07132906f, 
    0.10924720f, 0.01566838f, 0.17444773f, 0.02498073f, -0.22991630f, -0.04200210f, -0.22313108f, 0.04598685f, 
    -0.00441470f, 0.02828390f, 0.06113453f, 0.06320217f, 0.13243064f, 0.08435735f, -0.13650219f, -0.02464802f, 
    0.06951720f, 0.11622228f, 0.10689588f, 0.03151202f, 0.12697701f, -0.03239971f, 0.00601395f, 0.04890279f, 
    -0.07085688f, -0.04434053f, -0.04856552f, 0.12918615f, -0.25088704f, -0.04527463f, -0.03141935f, 0.00989616f, 
    -0.00904645f, 0.01579737f, 0.13061301f, -0.05844727f, -0.01893318f, 0.05495466f, 0.01322029f, 0.06323162f, 
    0.08447594f, 0.02650595f, 0.05334591f, 0.14965051f, 0.17767823f, 0.01764372f, 0.01924920f, -0.09110566f, 
    -0.21869186f, 0.16133828f, 0.14772280f, 0.01683360f, 0.11498136f, -0.00797865f, -0.00662878f, -0.06731571f, 
    0.05031872f, 0.09910977f, -0.01677895f, 0.11090703f, 0.15213948f, 0.13581203f, -0.02809267f, 0.16517039f, 
    -0.04259322f, 0.01813002f, -0.02096334f, -0.02022060f, 0.04861243f, -0.02766439f, 0.00065445f, 0.01488769f, 
    0.04714692f, -0.03782158f, 0.04351528f, -0.00107575f, 0.04493511f, -0.00709155f, -0.00063955f, -0.01898045f, 
    -0.04336207f, -0.02928124f, 0.03196269f, 0.04342670f, -0.04269468f, -0.02951369f, -0.01168704f, -0.03863781f, 
    -0.05607320f, 0.02992151f, -0.03933141f, 0.01041287f, 0.02348531f, 0.03381611f, -0.05064743f, 0.02059378f, 
    0.00041097f, -0.04191320f, 0.01769180f, -0.05331346f, -0.02212483f, -0.02427247f, 0.03764395f, 0.00827485f, 
    -0.06688127f, -0.06206989f, 0.04119194f, -0.04908490f, 0.00547738f, -0.01987361f, -0.05058853f, 0.00147503f, 
    -0.05639151f, 0.02075580f, 0.04433058f, -0.01847148f, 0.04057503f, 0.00682517f, 0.00938278f, 0.00507376f, 
    -0.04309503f, 0.02820092f, -0.03684869f, -0.05866705f, -0.03123447f, -0.00895889f, 0.00685154f, -0.01681285f, 
    0.04049377f, -0.06095563f, -0.02998252f, 0.03336580f, -0.01865917f, 0.04395267f, -0.03807452f, 0.03008188f, 
    0.03329762f, 0.04610993f, -0.04092965f, 0.00585568f, 0.00288710f, -0.02790903f, 0.02765042f, -0.02860877f, 
    -0.04631476f, -0.05011225f, -0.04970391f, 0.02892561f, 0.03807621f, -0.02244700f, -0.04984717f, 0.00036758f, 
    0.02176552f, 0.04546952f, -0.03198410f, -0.02047583f, -0.00468339f, -0.01150141f, 0.00314360f, -0.00466547f, 
    -0.00345861f, -0.06354161f, 0.00853825f, 0.03266716f, 0.02063382f, -0.04933093f, 0.04034866f, -0.06121242f, 
    -0.02693850f, -0.01564903f, -0.04155636f, -0.03923106f, 0.02970405f, 0.00233302f, -0.06196206f, 0.01712560f, 
    0.03229170f, -0.04225178f, -0.00198724f, -0.01170157f, 0.04683227f, 0.01104137f, 0.02549023f, 0.03237645f, 
    0.03548063f, 0.00198843f, -0.00859513f, -0.01222795f, 0.01015600f, -0.03030079f, 0.00714942f, 0.03858952f, 
    -0.03016114f, 0.02185689f, -0.04206042f, -0.01014579f, -0.02770828f, -0.04615635f, 0.00267948f, -0.03784454f, 
    -0.03014044f, -0.03108813f, -0.04694092f, -0.00957016f, 0.03374496f, -0.00948494f, 0.03743400f, 0.03470223f, 
    -0.03148600f, -0.00560749f, 0.03323814f, 0.03244302f, 0.03571378f, -0.02115699f, 0.01409438f, 0.03700315f, 
    0.02505395f, -0.06126444f, -0.03158928f, -0.02735842f, 0.03900789f, 0.03016627f, -0.00655195f, -0.03822489f, 
    0.04265273f, -0.05206791f, -0.06626359f, -0.00462801f, -0.01628921f, 0.01345014f, -0.03276805f, -0.05390448f, 
    -0.02866602f, 0.04395936f, -0.03086625f, -0.01905745f, 0.04325916f, 0.02285594f, -0.00074926f, -0.04967699f, 
    0.00360026f, -0.03399961f, -0.03926339f, -0.05338446f, -0.03105629f, -0.00662116f, 0.01170238f, -0.01044819f, 
    0.04045775f, -0.03009279f, -0.03997964f, 0.03552240f, 0.03043573f, -0.02947520f, -0.04548109f, 0.03615965f, 
    -0.01754074f, -0.02860275f, 0.00593482f, -0.02546849f, 0.00332155f, 0.03987382f, 0.03027220f, -0.03958268f, 
    -0.00401296f, -0.02823175f, 0.04398488f, -0.05597972f, 0.03456347f, -0.03809238f, -0.04533280f, 0.03889782f, 
    -0.02231982f, -0.02989645f, 0.01487096f, 0.00935471f, 0.04353381f, 0.02777950f, -0.01945565f, -0.00459974f, 
    0.01082568f, 0.03001834f, -0.06093792f, -0.02162677f, 0.04732136f, -0.01276278f, -0.01307689f, 0.03969886f, 
    -0.02840128f, 0.04063850f, -0.03029139f, -0.02014712f, 0.02901320f, -0.01947413f, 0.00449460f, 0.01617619f, 
    0.01747936f, 0.02656686f, 0.01134841f, 0.01135700f, -0.04828928f, -0.02843300f, -0.04218321f, 0.02387087f, 
    0.00704089f, 0.03032504f, -0.05475524f, 0.02878424f, 0.01549685f, 0.01341409f, -0.01744437f, 0.01486475f, 
    0.04048707f, 0.00277409f, -0.02750560f, -0.01002922f, 0.01512729f, -0.00248150f, 0.02222695f, -0.02948223f, 
    -0.00934024f, 0.01324796f, 0.04395835f, 0.01109767f, 0.00475145f, 0.04165814f, -0.00469756f, 0.00953119f, 
    0.01169894f, -0.01736860f, 0.03404784f, 0.00544980f, -0.05487424f, 0.03785601f, 0.02783351f, 0.01428004f, 
    0.01539136f, -0.04219741f, 0.00923500f, 0.00008096f, -0.03125861f, 0.01559261f, -0.02951445f, -0.05579822f, 
    0.01897480f, 0.02806966f, -0.04694210f, 0.02431501f, -0.05384289f, -0.04832510f, -0.06074527f, -0.05070872f, 
    -0.03880254f, -0.05597536f, -0.04794392f, 0.02229925f, -0.00052541f, -0.04558526f, -0.00682280f, -0.01427168f, 
    -0.03864524f, 0.03796199f, 0.01569545f, -0.06134666f, -0.01171212f, -0.05364947f, 0.04381602f, -0.01680467f, 
    0.00333610f, -0.05511782f, -0.04425939f, -0.06379986f, -0.01465204f, 0.00536589f, 0.03737549f, 0.00103903f, 
    -0.03507582f, 0.01929585f, -0.00379017f, -0.00636954f, -0.04882637f, -0.01837257f, -0.03812042f, 0.04023658f, 
    -0.01623593f, 0.00232990f, -0.01322192f, 0.02849456f, -0.05498110f, 0.03952591f, 0.01516273f, -0.05579003f, 
    -0.05041548f, -0.04311586f, 0.03871584f, 0.01473002f, 0.00995531f, -0.01018557f, -0.05159404f, 0.02616476f, 
    -0.04229822f, -0.05299607f, -0.04274878f, 0.01024028f, -0.01126587f, 0.02925845f, 0.04607693f, -0.00514798f, 
    -0.03918391f, 0.02784536f, -0.04230532f, -0.04629666f, -0.04961381f, -0.04035379f, 0.01423024f, -0.03998409f, 
    0.05104274f, -0.05077213f, -0.01617464f, -0.02355818f, 0.03085377f, 0.03560308f, 0.00803688f, 0.02103790f, 
    -0.02917301f, -0.03159329f, -0.06029841f, 0.04538973f, -0.00033734f, 0.02732010f, 0.02036348f, -0.01315664f, 
    -0.03447338f, -0.05945585f, -0.04023124f, -0.06011829f, -0.00416688f, 0.04177342f, 0.02118703f, 0.03951045f, 
    0.04145867f, 0.00892566f, -0.03050244f, 0.01789158f, 0.00957703f, 0.04276465f, 0.01414181f, 0.01048060f, 
    0.01652600f, 0.04565329f, -0.04154716f, -0.04606465f, -0.04896026f, 0.01334781f, 0.01798124f, 0.00184118f, 
    -0.01422765f, -0.02168815f, 0.01242542f, 0.00266775f, -0.00806481f, 0.01252500f, 0.02371714f, 0.03164401f, 
    -0.05787546f, -0.00609504f, -0.00778392f, -0.02285386f, 0.01432003f, 0.02087647f, 0.04145922f, 0.03978397f, 
    0.02399585f, 0.04329738f, -0.05976909f, -0.00243479f, -0.05392781f, -0.04523116f, 0.03751311f, 0.01290081f, 
    0.03158308f, 0.00341884f, 0.02808917f, -0.01013330f, -0.03989138f, 0.01943176f, -0.01395387f, -0.04760334f, 
    -0.00109140f, -0.05866868f, 0.01610165f, 0.02926362f, 0.02749375f, -0.01567259f, 0.01218524f, -0.05540909f, 
    -0.05882212f, -0.04331297f, 0.00215887f, -0.03499267f, -0.05263673f, -0.01916583f, 0.00120505f, 0.03973401f, 
    -0.04677484f, -0.05240149f, -0.04388665f, -0.01302494f, -0.02915050f, -0.00412788f, 0.03504346f, 0.02586805f, 
    -0.05379878f, 0.05097811f, 0.03579004f, -0.03175010f, -0.00560335f, -0.02651580f, -0.02564519f, -0.03053884f, 
    0.03970745f, -0.04254300f, 0.03583728f, -0.02473329f, -0.00620000f, 0.02814031f, 0.01664507f, -0.03769960f, 
    -0.05377889f, 0.04028894f, -0.01665021f, 0.00128506f, 0.00809721f, -0.03718874f, 0.01964618f, 0.02508157f, 
    -0.02349769f, -0.01881668f, -0.01335408f, -0.04273534f, 0.03260190f, -0.00105991f, -0.04784947f, -0.03948084f, 
    -0.03521388f, -0.00172319f, -0.00573167f, -0.01139916f, 0.00577506f, -0.02646101f, -0.03617907f, 0.00445485f, 
    -0.05422412f, -0.03841918f, 0.02361643f, -0.01627408f, -0.02911024f, 0.04516741f, 0.01282036f, -0.00173529f, 
    -0.01652141f, -0.04355622f, -0.01777806f, 0.02584122f, -0.04411501f, -0.02369672f, 0.01406071f, 0.04458909f, 
    0.01335660f, 0.03500733f, 0.00346263f, -0.05850482f, -0.05574195f, -0.01447797f, 0.03312413f, -0.04244105f, 
    -0.03232071f, 0.00906062f, -0.02546273f, -0.04097485f, 0.03348219f, -0.03592296f, 0.03443133f, 0.04138838f, 
    -0.05107126f, 0.01930888f, 0.04949377f, 0.04725545f, -0.02068904f, 0.02937382f, 0.03691354f, 0.02858734f, 
    -0.02295464f, -0.02301935f, -0.00540632f, -0.03483806f, -0.03182444f, 0.04902075f, 0.01909044f, 0.01918067f, 
    -0.05540540f, -0.02776121f, -0.06011805f, 0.03944845f, -0.04003051f, 0.03941284f, -0.01374534f, -0.01591882f, 
    -0.02829778f, -0.00843791f, 0.01484649f, 0.04825149f, 0.00476757f, -0.01624439f, -0.04927172f, 0.01111790f, 
    0.01907927f, -0.05728477f, -0.03646856f, 0.03933863f, 0.02508037f, 0.03378481f, 0.04340680f, 0.02210479f, 
    -0.04712717f, -0.03128247f, 0.01139779f, 0.03343296f, -0.03722083f, 0.04816782f, -0.02783516f, -0.00257332f, 
    -0.02905519f, -0.04839097f, -0.01934353f, -0.05433790f, -0.02474876f, -0.04966530f, 0.02600130f, -0.05377100f, 
    -0.05879444f, -0.05293469f, -0.01216057f, -0.04421390f, -0.04544242f, 0.04533172f, 0.03352063f, 0.03956861f, 
    0.00391399f, 0.02264140f, -0.00398168f, -0.05245988f, -0.01955857f, 0.03869915f, 0.00356437f, 0.01181800f, 
    0.02035417f, 0.02140404f, -0.00580006f, -0.03713413f, -0.03298089f, 0.00110883f, -0.04425350f, 0.00816791f, 
    -0.05324745f, -0.05004166f, 0.00803509f, -0.04471134f, -0.04861975f, 0.01990170f, 0.01803126f, -0.06073099f, 
    0.04150113f, 0.02408228f, 0.02574714f, 0.04703219f, -0.03267465f, -0.03358924f, -0.02783787f, 0.04112136f, 
    0.01891238f, 0.00511632f, -0.03904345f, -0.02608074f, -0.05867644f, -0.04686731f, -0.02391726f, -0.00621919f, 
    -0.02203398f, -0.05503166f, -0.05641992f, 0.00815922f, -0.03436721f, 0.02615649f, 0.04474633f, -0.00622421f, 
    -0.02968679f, 0.02239808f, -0.02009288f, -0.03565094f, -0.01807071f, 0.04164091f, -0.02926846f, 0.04590388f, 
    -0.02610715f, -0.05629985f, 0.01164627f, -0.00727233f, 0.04555231f, -0.06003350f, -0.02061280f, -0.04861807f, 
    -0.05942529f, -0.06143974f, 0.01347832f, -0.02639887f, -0.03235403f, 0.02174535f, -0.00818766f, -0.03292731f, 
    -0.03969824f, -0.02088272f, -0.05552413f, -0.04215561f, -0.02748745f, -0.04520720f, 0.00242255f, 0.01046873f, 
    -0.02128622f, 0.02739180f, -0.02883815f, 0.04304587f, -0.00509380f, -0.03845724f, 0.02567629f, 0.01931902f, 
    -0.02925768f, 0.00659689f, -0.02269988f, 0.00085463f, 0.03698921f, 0.00493814f, 0.00251869f, -0.02709135f, 
    -0.03451434f, 0.02078060f, 0.04627271f, 0.00146144f, 0.01657542f, 0.01734505f, 0.01726714f, 0.00502522f, 
    -0.05226157f, 0.00475518f, 0.02376254f, -0.00923149f, 0.02934749f, -0.03465344f, -0.04598060f, -0.01369819f, 
    -0.01499664f, 0.02131119f, 0.03669406f, -0.00725365f, -0.04790935f, -0.06241966f, -0.06304484f, -0.00614488f, 
    -0.05646715f, 0.00518401f, 0.03999105f, -0.03764383f, 0.04613503f, -0.04656508f, 0.00779076f, 0.03518580f, 
    0.00971393f, -0.00331372f, 0.02530768f, 0.02524535f, -0.03016952f, -0.05068872f, 0.01652364f, 0.04366099f, 
    0.00763175f, 0.03029396f, -0.02504883f, 0.02924781f, 0.00770275f, 0.00849535f, 0.01202181f, -0.05894640f, 
    -0.03431104f, 0.01773359f, -0.05826833f, -0.00522570f, -0.05090312f, -0.04760244f, 0.04160636f, -0.04469870f, 
    -0.03764830f, 0.01411469f, 0.02805727f, -0.00601245f, -0.01570413f, -0.03472050f, -0.02007439f, 0.03937558f, 
    0.02304108f, -0.04448228f, 0.02694470f, 0.01242693f, -0.02665782f, 0.04665040f, 0.03227095f, 0.03201091f, 
    0.00459377f, 0.04351522f, 0.00956977f, -0.01477416f, 0.01761945f, -0.03932284f, -0.05985591f, 0.00332054f, 
    -0.04506449f, 0.03943958f, -0.00010275f, -0.00341000f, -0.02739061f, -0.05677243f, 0.02237591f, -0.02445210f, 
    -0.04682721f, -0.03310612f, 0.00247215f, -0.00067522f, -0.02758107f, -0.03986183f, 0.03870821f, 0.04276649f, 
    -0.04832356f, 0.04210847f, -0.05161487f, -0.04878858f, -0.00364810f, -0.05279750f, -0.03931064f, 0.02101151f, 
    -0.06259168f, 0.01586591f, -0.05935561f, -0.05839099f, 0.00800790f, -0.01098809f, 0.02368872f, -0.05486295f, 
    -0.00558601f, 0.00061217f, -0.01184900f, 0.02045352f, 0.04018906f, -0.02521112f, 0.00431249f, -0.04013120f, 
    -0.04656847f, 0.04345677f, -0.02392703f, 0.04348120f, -0.05735014f, -0.05757653f, -0.04149574f, 0.00225854f, 
    -0.05098533f, 0.00988228f, 0.00213493f, -0.03279555f, 0.00292925f, 0.03445343f, -0.04575016f, -0.06088087f, 
    -0.05389496f, 0.04001607f, -0.03479878f, 0.04227167f, 0.04785888f, 0.04504380f, -0.01232362f, -0.01041781f, 
    0.00348003f, 0.04355911f, 0.03249685f, -0.06190627f, -0.05478355f, 0.03676971f, -0.00422992f, 0.03006766f, 
    0.03282970f, -0.03758932f, -0.05401039f, 0.02323897f, -0.00324623f, -0.05750848f, 0.02119903f, -0.04160564f, 
    -0.03913027f, 0.01660638f, -0.02160063f, -0.01325815f, 0.01091994f, -0.04105529f, 0.02457356f, -0.05072318f, 
    -0.00884897f, -0.02551008f, -0.05585674f, 0.03109742f, 0.01234892f, 0.02048194f, -0.00239872f, 0.02184610f, 
    -0.02896223f, 0.01746331f, -0.03190067f, 0.02717604f, -0.04861198f, 0.03595791f, -0.00732077f, -0.04926271f, 
    0.04629136f, 0.02641055f, -0.02070970f, -0.00761614f, -0.03051163f, 0.03808833f, 0.01451332f, 0.00816444f, 
    -0.02725902f, -0.02787123f, 0.04673609f, -0.05170258f, -0.01028536f, 0.04168268f, 0.03639593f, -0.04780536f, 
    0.03988787f, 0.04725746f, -0.03877760f, -0.01816550f, -0.03071891f, -0.03435088f, -0.04180132f, -0.01236954f, 
    0.04743595f, 0.00309672f, 0.01326784f, 0.02433815f, 0.03122320f, -0.03626532f, -0.01432087f, -0.03454788f, 
    -0.00229132f, 0.01977676f, 0.03480837f, 0.03460478f, -0.05405420f, 0.02820014f, 0.02699164f, -0.05636022f, 
    -0.03702255f, 0.02886665f, -0.04985449f, 0.03674709f, -0.05071015f, -0.00822572f, -0.06048698f, 0.03836370f, 
    0.00729188f, -0.00919320f, 0.02145150f, -0.05802736f, -0.03415577f, 0.03048702f, -0.04600281f, -0.04058927f, 
    0.02751811f, -0.05092562f, 0.00091701f, -0.02085749f, 0.00735403f, -0.03440673f, -0.05051012f, 0.01359319f, 
    0.00250249f, 0.02609438f, -0.02815086f, -0.03854838f, -0.00060871f, 0.01476254f, 0.00425298f, -0.01150908f, 
    -0.03105421f, 0.00352622f, 0.02464466f, 0.02676618f, 0.01621667f, -0.04718065f, -0.01823331f, -0.03353301f, 
    0.03043802f, 0.02721127f, 0.04159117f, 0.02075801f, 0.01227669f, 0.00296447f, -0.00955731f, -0.04233082f, 
    -0.04269736f, -0.03151861f, 0.01911509f, -0.04089903f, -0.00345596f, 0.02882668f, -0.06098867f, -0.03880661f, 
    -0.03177368f, -0.04334266f, -0.04989729f, 0.05069857f, 0.00687643f, -0.05283404f, -0.04168552f, -0.01745799f, 
    -0.00868005f, -0.04812984f, 0.02226483f, -0.04363845f, 0.00682348f, -0.03303916f, -0.05150286f, -0.03568034f, 
    -0.02233281f, 0.00228157f, 0.01180308f, -0.04504493f, -0.00471642f, -0.04989377f, 0.03058681f, 0.04680403f, 
    0.00634346f, -0.05073788f, -0.05455496f, -0.05735153f, -0.03049479f, -0.07000804f, -0.04037445f, 0.02024836f, 
    0.02069812f, 0.03204906f, -0.00875146f, -0.05956917f, -0.04790629f, -0.05368552f, -0.07079586f, -0.01367853f, 
    -0.00305558f, -0.04187260f, 0.04295840f, -0.03178947f, 0.02604776f, 0.04193385f, 0.01210845f, 0.03778412f, 
    0.04078740f, 0.02198635f, -0.02899198f, -0.01055445f, 0.04067660f, -0.02389576f, -0.05247665f, -0.00453821f, 
    0.01003505f, -0.04648805f, 0.04953150f, 0.00426306f, 0.00641556f, -0.04382646f, -0.02813406f, 0.01437507f, 
    -0.05148688f, -0.01775388f, -0.00834361f, 0.01016341f, 0.03107897f, -0.04230492f, -0.05166811f, -0.03124393f, 
    0.01408508f, -0.03481228f, -0.02281934f, -0.02989353f, -0.03509738f, -0.02708127f, -0.02826264f, -0.02766042f, 
    0.00363495f, -0.06103457f, 0.01351584f, 0.03153180f, -0.01671484f, 0.03840286f, -0.01576116f, 0.05197023f, 
    -0.03049243f, -0.04315424f, 0.04690717f, -0.00464115f, -0.07541253f, -0.00247853f, -0.00089526f, -0.02842278f, 
    -0.01867830f, 0.01467182f, 0.01111335f, 0.02613443f, -0.02769701f, 0.01094175f, 0.01235311f, -0.00923959f, 
    0.01639161f, -0.06044104f, -0.06966614f, -0.01000815f, -0.03098787f, 0.01007422f, 0.03895069f, -0.07380939f, 
    -0.02341344f, -0.00994296f, -0.05763695f, 0.01642485f, -0.00605461f, -0.01139947f, -0.03048831f, 0.00105162f, 
    0.05539991f, 0.02828452f, 0.01326048f, -0.00345273f, -0.02801370f, 0.01915129f, -0.03603357f, 0.00884474f, 
    -0.04220149f, 0.01433629f, -0.01336411f, 0.02648210f, 0.02565701f, 0.00062136f, 0.00723289f, -0.04481953f, 
    -0.06452461f, 0.01673079f, 0.05606385f, 0.04464806f, 0.04529351f, 0.00875123f, 0.02352998f, -0.04010226f, 
    0.03186759f, -0.02177180f, 0.03950187f, 0.02635433f, 0.02796013f, -0.02764002f, 0.04069456f, -0.05633308f, 
    -0.00362292f, -0.03187698f, -0.02526722f, -0.03792518f, 0.02473856f, 0.04701001f, 0.03780504f, 0.04229749f, 
    -0.05811170f, -0.04790790f, -0.05548168f, -0.00775906f, -0.02585754f, -0.02416499f, -0.04353143f, -0.04988860f, 
    -0.02119713f, 0.02219243f, 0.03318994f, -0.06999893f, -0.05640346f, 0.02035542f, -0.05101926f, 0.02875735f, 
    0.01998601f, 0.04922884f, 0.00282598f, 0.02510943f, 0.02716519f, -0.06909315f, 0.00561826f, 0.04605488f, 
    -0.00384482f, 0.03840065f, -0.04072931f, 0.03289724f, -0.06134240f, 0.02816109f, -0.01394016f, -0.02293350f, 
    0.03180863f, 0.03878830f, -0.01315075f, 0.03614530f, -0.03811452f, 0.00693460f, 0.02049937f, -0.03174305f, 
    0.04110162f, -0.03392714f, 0.02766472f, -0.06038572f, -0.05051695f, 0.01817673f, -0.00570198f, 0.03230473f, 
    -0.01869996f, 0.00334766f, -0.05979672f, 0.03983993f, -0.04222608f, -0.03649887f, 0.04084515f, -0.03748540f, 
    -0.04159347f, -0.00171168f, -0.03878364f, -0.03075429f, 0.00632196f, -0.02533491f, 0.02903578f, -0.05142012f, 
    -0.06159287f, 0.01026213f, -0.02807557f, 0.01293939f, -0.02103325f, -0.02636808f, -0.03451061f, -0.00544995f, 
    -0.03382894f, 0.04083686f, 0.00949907f, -0.02689814f, 0.01256881f, -0.03300814f, -0.05596888f, 0.03417959f, 
    -0.02490344f, -0.03751700f, -0.05337058f, 0.04128632f, -0.04142773f, 0.04776291f, -0.01231085f, -0.04170434f, 
    0.04572289f, -0.02227519f, 0.02122815f, 0.01575996f, 0.04058331f, -0.05202988f, 0.01899879f, -0.01535572f, 
    -0.05679071f, -0.04873701f, -0.01843337f, -0.01704048f, -0.03857100f, -0.00125208f, 0.02012171f, 0.01215578f, 
    -0.06092191f, -0.02639808f, 0.03161769f, -0.03091549f, 0.03572709f, -0.02499139f, -0.02446573f, -0.05034901f, 
    -0.04452898f, -0.02328553f, 0.03137673f, -0.05902642f, -0.03125186f, -0.05186039f, -0.02872605f, -0.02382984f, 
    -0.03115854f, -0.04542768f, 0.04127924f, -0.06107246f, -0.05231167f, -0.00278914f, -0.02724072f, 0.01366503f, 
    -0.00909685f, -0.04755965f, 0.01443279f, -0.00657008f, 0.01299280f, -0.01175361f, -0.02131349f, -0.03311000f, 
    -0.01378943f, -0.02612755f, -0.01142748f, 0.01946992f, 0.02187610f, 0.01094439f, 0.03425507f, 0.03546876f, 
    -0.03385730f, -0.06213342f, 0.00610735f, -0.01236125f, -0.04949638f, 0.04682721f, -0.05353258f, -0.01156164f, 
    -0.00165970f, 0.03136627f, 0.03607579f, 0.04733991f, -0.01151482f, -0.05093010f, -0.05146072f, -0.01724312f, 
    0.29539719f, 0.06553055f, -0.21587461f, -0.09873480f, -0.01001838f, -0.00298466f, 0.04992118f, 0.04794244f, 
    -0.00667408f, -0.00728924f, 0.03593859f, 0.00699472f, -0.10296860f, -0.00422876f, 0.05161713f, 0.02772009f, 
    0.07225072f, -0.02740503f, -0.11183549f, -0.06746719f, -0.32804313f, 0.09649230f, -0.10895236f, 0.06213131f, 
    0.26646352f, -0.05803113f, 0.12211837f, 0.10956081f, -0.04891077f, 0.10226758f, -0.01835572f, 0.07464888f, 
    -0.20025098f, -0.07756761f, 0.07106871f, 0.03098892f, 0.12533358f, -0.02356738f, 0.17077430f, -0.11501057f, 
    0.08233672f, 0.06825012f, -0.22662039f, 0.06236180f, 0.00655120f, 0.11745045f, 0.02511428f, 0.01630520f, 
    -0.19130546f, 0.03869219f, 0.20507720f, 0.23379342f, 0.14826018f, -0.04697199f, 0.00473807f, -0.13443828f, 
    0.17908014f, 0.09083601f, 0.03043618f, 0.05983291f, -0.02665277f, 0.23911358f, 0.07926898f, 0.08206522f, 
    0.00880796f, -0.05403615f, -0.01711926f, 0.11011598f, 0.02339268f, -0.06936330f, -0.04559017f, 0.00369666f, 
    0.05163851f, 0.06213829f, 0.01776795f, 0.22394684f, 0.09578262f, -0.11580643f, 0.03428881f, 0.06492862f, 
    -0.15929063f, 0.11630747f, -0.06491546f, -0.11854723f, -0.05973034f, -0.06017701f, -0.02545402f, -0.03909904f, 
    0.08410476f, 0.01704680f, 0.16920646f, -0.05209854f, -0.03837247f, -0.04378573f, 0.06853577f, 0.04199214f, 
    -0.05157518f, -0.30993620f, 0.00270869f, 0.09012648f, -0.03993076f, 0.04165778f, 0.02361057f, 0.05780343f, 
    0.33187672f, -0.07523518f, 0.07339974f, -0.05002612f, 0.09021252f, 0.06955931f, -0.05954215f, 0.02419917f, 
    0.05855553f, -0.01171396f, 0.11225149f, 0.01102471f, 0.05716375f, -0.04691084f, 0.18858929f, 0.11685535f, 
    -0.01243322f, 0.06648900f, 0.07199545f, -0.05275227f, 0.08209910f, -0.11402895f, -0.05677399f, -0.07392270f, 
    -0.01595239f, 0.04629521f, -0.01022850f, -0.02222775f, 0.04657657f, 0.01227413f, 0.01363842f, 0.12039737f, 
    0.01866720f, -0.14032522f, 0.16122763f, 0.14885868f, -0.07649219f, 0.20624538f, -0.09460462f, -0.11054187f, 
    -0.02956854f, 0.08871382f, 0.09725818f, 0.10849419f, -0.09466779f, -0.07957889f, -0.04801466f, -0.01450315f, 
    -0.01603855f, -0.22681922f, 0.02231410f, 0.00499783f, 0.09148474f, 0.08322684f, 0.09095421f, 0.00555329f, 
    0.10745652f, 0.16301604f, 0.00299396f, -0.22813949f, 0.04151344f, 0.05234421f, 0.07085127f, -0.06006916f, 
    -0.02526413f, -0.00759433f, 0.07774107f, 0.14353052f, -0.06887060f, -0.02321288f, -0.14397666f, 0.16788760f, 
    0.00440163f, -0.09132409f, 0.07985421f, 0.08834677f, -0.32758531f, -0.15123491f, -0.25083387f, -0.09474996f, 
    -0.28215989f, 0.08453961f, -0.03187993f, -0.03377900f, -0.07220799f, 0.06702118f, -0.01833637f, -0.09440789f, 
    0.07055359f, 0.02992747f, 0.00598614f, -0.02743232f, 0.04583036f, -0.21050861f, -0.24180909f, 0.06847879f, 
    0.28544754f, -0.08574834f, 0.00693376f, 0.05263932f, 0.01229408f, -0.05633552f, -0.03649384f, 0.05346632f, 
    0.10665256f, -0.04912112f, -0.03490990f, -0.07188961f, -0.01537417f, 0.20271319f, 0.00579713f, -0.04568278f, 
    -0.16808121f, 0.07019969f, -0.06155851f, 0.06184593f, 0.37592620f, 0.11605462f, -0.18875796f, -0.14992870f, 
    0.07279265f, -0.01635610f, -0.14874084f, -0.02513879f, -0.00549641f, -0.00048924f, 0.03251932f, -0.01452020f, 
    -0.06132526f, -0.06567698f, 0.03007171f, -0.00872287f, -0.07289566f, 0.18241361f, 0.02899984f, 0.11011370f, 
    0.09732648f, 0.33654931f, -0.07344998f, -0.03138841f, 0.07663832f, 0.11240343f, 0.00186883f, -0.03011275f, 
    -0.02531058f, 0.02392217f, -0.08458202f, 0.01208364f, 0.04666021f, -0.10913231f, -0.00027460f, -0.03005359f, 
    -0.00410016f, 0.09774255f, 0.12252398f, 0.04450481f, -0.21784507f, -0.13850340f, 0.08753802f, -0.03392284f, 
    -0.06282361f, -0.00985076f, -0.00352062f, 0.06673093f, 0.06441887f, 0.19131911f, -0.20559344f, -0.08844414f, 
    0.20040816f, 0.03992658f, -0.07684506f, -0.02416353f, 0.11342727f, -0.20630267f, -0.11495974f, -0.01168033f, 
    0.11355244f, 0.07457864f, -0.11772654f, -0.04558754f, 0.02207106f, 0.02015498f, -0.02820046f, -0.04685317f, 
    -0.06240397f, -0.11602332f, 0.00645729f, 0.10635252f, -0.03567511f, -0.00626243f, -0.04889395f, 0.24938664f, 
    -0.08519504f, 0.06698637f, 0.22415172f, 0.11629524f, -0.12598763f, -0.03385241f, -0.02146599f, -0.08912648f, 
    0.06576626f, 0.09961750f, -0.00973855f, -0.02884052f, -0.08989442f, 0.06765959f, -0.01261177f, 0.00366277f, 
    0.03401211f, 0.14920236f, 0.05552110f, 0.11549989f, 0.05818415f, -0.00281310f, -0.07464472f, 0.03138736f, 
    -0.05316157f, -0.04358497f, 0.01480784f, 0.02918171f, -0.01059274f, -0.01938623f, -0.02537611f, -0.00099282f, 
    -0.04817149f, 0.03574224f, -0.03173877f, -0.01406087f, -0.02817248f, -0.00447550f, 0.03494368f, 0.01091085f, 
    0.00038634f, -0.02867806f, 0.02405020f, 0.02464430f, -0.03286914f, 0.03834634f, -0.03837216f, 0.03677101f, 
    0.03253303f, -0.04952788f, 0.01059406f, 0.01631035f, -0.05611708f, 0.02575584f, -0.01126358f, 0.04271474f, 
    0.01456640f, -0.00703592f, -0.00467169f, -0.02317992f, -0.00923516f, 0.01233671f, -0.04474439f, -0.05425341f, 
    -0.02044062f, -0.04137268f, 0.00626372f, 0.00056340f, 0.02595897f, -0.01476445f, 0.01447728f, -0.02993041f, 
    -0.04433907f, -0.00727716f, 0.02130145f, 0.04100641f, 0.02109580f, 0.03811606f, 0.01300220f, -0.04740939f, 
    -0.04116520f, 0.03847680f, -0.02238093f, 0.00198651f, 0.00978143f, -0.03523177f, 0.03431704f, 0.03241302f, 
    -0.05888526f, 0.01252367f, -0.05909051f, -0.02457454f, -0.06165823f, -0.00525230f, -0.01080690f, -0.00562129f, 
    -0.03513002f, -0.05983208f, 0.02694088f, -0.04755151f, -0.05193437f, -0.02906414f, -0.04983867f, 0.01840190f, 
    0.02033993f, 0.01953009f, -0.02626376f, -0.06144424f, -0.04329919f, 0.03940888f, -0.00852729f, -0.00385286f, 
    -0.00771395f, -0.01891098f, 0.02943982f, -0.00337649f, 0.00557088f, -0.01844705f, 0.04350478f, -0.01869552f, 
    0.03024496f, -0.01706290f, -0.03022171f, -0.00388173f, 0.00505653f, -0.03224334f, -0.01511540f, 0.04096018f, 
    0.03451363f, 0.03176998f, -0.05056072f, 0.04035983f, 0.00313494f, 0.05542135f, 0.00034250f, 0.00567100f, 
    0.00590358f, -0.03730875f, 0.01309601f, 0.04138730f, 0.02912728f, -0.06089536f, 0.04665159f, 0.03766601f, 
    -0.00164593f, 0.02234241f, 0.00478600f, -0.00291709f, -0.00807331f, -0.00234529f, -0.01307373f, -0.04507956f, 
    0.00293116f, 0.04825296f, -0.00349409f, -0.03331238f, -0.03936371f, 0.03456496f, 0.01093022f, -0.02292918f, 
    -0.01684910f, 0.02180425f, 0.01087919f, -0.05314857f, -0.05441657f, 0.04709443f, -0.04168316f, -0.00888893f, 
    0.03867579f, 0.04622911f, -0.04020731f, 0.02751239f, -0.04400602f, 0.00951282f, 0.03599419f, 0.04735830f, 
    -0.05803267f, -0.03150215f, 0.00883509f, -0.01466675f, 0.04522800f, 0.01830950f, 0.00567232f, -0.05278631f, 
    -0.05481910f, -0.04942942f, 0.00921746f, 0.03567383f, 0.01362417f, 0.04941542f, 0.00156652f, -0.02674228f, 
    0.00153267f, 0.00800506f, -0.02219104f, -0.05202291f, 0.02871151f, -0.00011853f, -0.03093268f, -0.03934764f, 
    0.00965153f, -0.01913526f, -0.00121104f, -0.06079107f, -0.02009812f, -0.05224220f, 0.01220764f, 0.03492883f, 
    0.00135874f, -0.00787960f, 0.03893676f, 0.01079362f, -0.00012343f, 0.03634998f, 0.02197721f, -0.01089679f, 
    0.01176691f, -0.01824973f, 0.02820157f, -0.05547864f, 0.00790744f, -0.02306060f, -0.03531040f, -0.05720562f, 
    0.00680877f, 0.01894342f, -0.04341067f, -0.05196502f, 0.00275835f, -0.04508997f, -0.02079582f, -0.05041611f, 
    0.00135026f, 0.00877275f, -0.06103528f, -0.01137663f, 0.02997865f, -0.02039269f, -0.05385360f, -0.05243278f, 
    0.02467316f, -0.04541953f, -0.05148000f, -0.03349503f, 0.01943882f, -0.04629340f, 0.02454272f, 0.00481803f, 
    -0.01616265f, 0.01930497f, 0.00111607f, -0.04978499f, 0.02581383f, 0.00797992f, 0.02432634f, 0.01940012f, 
    -0.03070037f, 0.01091089f, 0.03274788f, -0.05461416f, -0.05214428f, -0.04683039f, -0.03251837f, -0.04099252f, 
    -0.02012387f, -0.05922888f, -0.00850633f, -0.02277614f, -0.05113063f, -0.00098612f, 0.05222755f, -0.03669537f, 
    -0.05258440f, 0.01365673f, 0.04158961f, 0.01167795f, 0.01373508f, 0.04886283f, -0.05741297f, -0.01926911f, 
    0.00068677f, 0.01420514f, -0.00018557f, 0.04715787f, -0.00583995f, -0.02254557f, 0.00828384f, -0.02650996f, 
    0.00324616f, -0.00826808f, -0.05192754f, 0.04098347f, 0.01785841f, -0.06149839f, 0.05469681f, -0.01762284f, 
    -0.01246473f, -0.05007875f, -0.03868046f, -0.01537818f, 0.01355951f, -0.05320756f, 0.03049809f, 0.00721205f, 
    0.02854092f, -0.04157260f, -0.04345027f, -0.04705506f, -0.04162895f, -0.04541783f, -0.00514849f, -0.04248090f, 
    -0.03025368f, 0.00631801f, 0.03115309f, -0.04181933f, -0.05139147f, 0.00207762f, -0.02997592f, -0.03584078f, 
    0.01503280f, 0.01682402f, 0.00169814f, -0.02220625f, 0.02051211f, -0.03793643f, -0.00813801f, -0.03610185f, 
    -0.02553170f, 0.02071267f, 0.00810261f, -0.00678032f, -0.04781731f, -0.01659846f, 0.04942270f, -0.06073053f, 
    -0.02895075f, -0.00967647f, -0.05005780f, -0.05386465f, -0.00997205f, -0.01737351f, -0.00757801f, -0.00196702f, 
    -0.03867530f, 0.00404331f, 0.01269486f, 0.02399737f, -0.00180196f, -0.05008334f, -0.03808230f, -0.01001410f, 
    -0.05112840f, -0.03859548f, 0.03217524f, 0.03737805f, 0.03986957f, 0.02898444f, -0.00935220f, -0.03731890f, 
    -0.02082569f, -0.05619295f, -0.01326123f, -0.03205969f, -0.00567683f, -0.03651163f, 0.02581261f, -0.05289294f, 
    0.00713353f, 0.04277897f, 0.02745666f, 0.03205732f, 0.00111342f, -0.05585177f, -0.06084492f, 0.00333243f, 
    0.00070066f, -0.01954952f, -0.04008348f, -0.03919505f, 0.01290221f, -0.03031534f, -0.03633775f, 0.02261220f, 
    -0.01674804f, 0.02409086f, 0.04454138f, -0.00994727f, 0.02451797f, -0.00590409f, 0.02059780f, 0.03010371f, 
    0.03835285f, 0.00495552f, -0.04200944f, -0.04452614f, 0.00259142f, -0.03113144f, -0.03258671f, 0.04615219f, 
    0.04386658f, -0.03865405f, -0.05132978f, 0.03924087f, 0.03465526f, 0.03380394f, -0.00452023f, -0.05194180f, 
    -0.03228033f, -0.03127634f, -0.05065883f, -0.00224235f, -0.05053077f, 0.01906507f, -0.00499955f, 0.00146315f, 
    -0.02201395f, -0.02376734f, -0.00226125f, 0.02441506f, 0.04436718f, 0.03419597f, 0.01483671f, 0.02848965f, 
    0.02375570f, 0.04357817f, 0.02924526f, 0.04478673f, 0.02268355f, -0.04328470f, 0.00648478f, 0.02940809f, 
    -0.03434022f, -0.04728173f, -0.00788289f, -0.02355610f, -0.05931833f, -0.01746658f, -0.05542798f, -0.05951652f, 
    -0.03319098f, -0.05459099f, -0.02803992f, 0.02412119f, -0.05163704f, -0.04609945f, -0.02243595f, -0.01503629f, 
    -0.01313844f, -0.03168719f, 0.00882760f, 0.03373532f, -0.00557297f, -0.03199456f, -0.04846992f, -0.02628360f, 
    -0.00998240f, -0.00358613f, 0.03912486f, -0.00154234f, -0.00220487f, -0.04094056f, -0.00253160f, 0.03456783f, 
    0.03068981f, 0.04316643f, 0.04586416f, -0.03760636f, 0.02408167f, -0.03627468f, -0.04579700f, -0.00174341f, 
    0.03724614f, -0.06157884f, -0.05211845f, -0.00247675f, -0.03675817f, 0.00117702f, -0.01060851f, -0.05224011f, 
    -0.04232520f, -0.00841249f, -0.04581530f, 0.02650451f, 0.03808843f, -0.01921359f, 0.03863323f, 0.00477082f, 
    -0.02492832f, 0.04375041f, -0.01707388f, -0.02491188f, -0.03763811f, 0.03946375f, 0.03011797f, 0.01609632f, 
    -0.04711684f, -0.01100796f, 0.04479495f, -0.06156035f, -0.00027592f, 0.00758325f, 0.01463936f, 0.00417810f, 
    -0.02464955f, -0.00825006f, -0.01961830f, -0.03581356f, -0.01502381f, -0.06025074f, -0.05569126f, -0.00133307f, 
    -0.03825217f, -0.02940984f, 0.00923600f, -0.04529220f, -0.04080509f, -0.02531962f, -0.03530001f, -0.05807769f, 
    0.04171765f, -0.03615532f, -0.04546690f, 0.00070068f, 0.00280522f, 0.00174609f, 0.03548736f, 0.01267411f, 
    -0.05523113f, -0.05943621f, 0.03830684f, -0.01701867f, -0.03789075f, 0.03359847f, 0.04391587f, 0.02215948f, 
    -0.04416696f, -0.02889753f, 0.04123853f, 0.04440491f, -0.00253580f, -0.04028587f, 0.02263276f, -0.04060486f, 
    -0.05896427f, -0.03341527f, 0.00025875f, -0.01813393f, 0.05099262f, -0.00125308f, -0.04771579f, -0.05955248f, 
    -0.00701966f, 0.01611240f, -0.04457656f, -0.05580572f, -0.01264798f, -0.05369603f, 0.00105398f, 0.00395695f, 
    0.02054643f, 0.03373660f, 0.00502492f, 0.01636139f, 0.04195434f, -0.02003386f, -0.03673628f, 0.00250278f, 
    0.00491763f, -0.01990819f, 0.02238674f, 0.03246881f, 0.00482177f, 0.04359318f, -0.02472397f, -0.04710643f, 
    0.05051005f, -0.05772445f, -0.03967421f, 0.03668733f, 0.03403820f, 0.02954023f, -0.00978004f, -0.01962768f, 
    -0.04851619f, -0.04454975f, -0.01262429f, -0.02982676f, -0.03403417f, -0.04891019f, -0.02095088f, 0.04574842f, 
    0.04651843f, 0.00924396f, 0.04144397f, 0.04672023f, -0.05387824f, 0.04599429f, 0.01528267f, 0.03058975f, 
    0.03717719f, -0.04267823f, -0.00572157f, -0.04431371f, 0.04552405f, -0.01036682f, -0.05733608f, -0.02040324f, 
    0.03833115f, 0.04070099f, -0.05051748f, -0.02842726f, 0.00505405f, -0.00208173f, -0.03417713f, 0.02174239f, 
    -0.00872176f, 0.01661028f, -0.00760011f, -0.03069328f, 0.02363164f, -0.05608075f, 0.03835825f, 0.01444142f, 
    -0.04715993f, -0.04953012f, -0.01186459f, 0.03417739f, -0.00010093f, -0.00656403f, -0.01904550f, -0.02494245f, 
    0.04066303f, 0.02173270f, -0.03894186f, 0.04625204f, -0.00167706f, -0.05142463f, -0.01444248f, -0.01433511f, 
    -0.05009415f, 0.03639635f, 0.05137520f, 0.00518915f, -0.00805201f, -0.00052791f, -0.01409536f, 0.02115826f, 
    -0.02675292f, 0.00046506f, 0.04653708f, -0.03301594f, -0.03392989f, 0.03614243f, 0.01501892f, 0.03663142f, 
    -0.03626648f, -0.03814921f, 0.00683748f, -0.01204819f, -0.05878644f, -0.02067864f, 0.03301319f, 0.03905270f, 
    -0.51988411f, 0.23213136f, -0.01137431f, -0.05966895f, 0.04568354f, -0.08123303f, -0.05649544f, -0.05314519f, 
    0.04197161f, 0.04499420f, -0.00729162f, 0.04510611f, 0.06189249f, -0.10506626f, -0.02048299f, -0.03403746f, 
    -0.01829670f, 0.11303188f, 0.16552001f, 0.05349407f, -0.18816978f, 0.08229448f, -0.04045900f, -0.01833807f, 
    -0.13186619f, 0.05113185f, -0.07475235f, -0.08540995f, 0.07632918f, -0.20219481f, -0.01384996f, 0.00934138f, 
    0.10472463f, 0.01644891f, 0.04224023f, 0.09735479f, 0.03467652f, 0.10621572f, -0.14999136f, 0.18986647f, 
    0.26631051f, -0.25321248f, 0.08075097f, 0.09077111f, 0.20021500f, -0.09597629f, -0.00624424f, 0.02271480f, 
    0.02237479f, -0.02871932f, -0.07581525f, -0.10557527f, -0.04171025f, 0.00560569f, 0.07411102f, 0.02585189f, 
    -0.07233985f, -0.01641058f, -0.01267619f, 0.01396255f, 0.15624259f, -0.12784840f, 0.08223877f, -0.02285483f, 
    0.14726517f, -0.02049742f, -0.00988527f, 0.01206336f, -0.07123714f, 0.12052270f, 0.07264324f, 0.07289509f, 
    -0.00750621f, -0.12231773f, 0.03368864f, -0.14863765f, 0.05177841f, 0.04525321f, 0.09716132f, 0.03778521f, 
    -0.08399266f, 0.09474658f, -0.11229517f, 0.02327840f, 0.24142297f, -0.00955208f, 0.04703886f, -0.04704738f, 
    -0.05609976f, 0.00163842f, -0.01901951f, -0.00478261f, -0.04865487f, 0.14285687f, 0.01584378f, -0.02330495f, 
    0.10094531f, 0.17762636f, 0.11320314f, -0.00534255f, -0.15107125f, 0.20665708f, 0.07092899f, 0.16043021f, 
    -0.18723762f, 0.07254165f, 0.04401522f, -0.10369490f, -0.00009098f, 0.02664474f, -0.02224671f, 0.05969136f, 
    -0.02502965f, -0.06872161f, 0.04588470f, -0.00246809f, -0.03695352f, -0.03874445f, -0.05179630f, -0.05716474f, 
    0.01310210f, 0.02679147f, -0.03487108f, 0.00134540f, -0.16592820f, 0.06066928f, 0.12211911f, 0.08492583f, 
    0.02742975f, 0.10194423f, 0.01948423f, 0.05531010f, -0.10961253f, 0.01118900f, -0.13498259f, -0.07693895f, 
    0.06005386f, 0.06459712f, -0.01113894f, -0.00728608f, 0.03403253f, 0.08793422f, -0.06203897f, 0.00274904f, 
    0.10603321f, 0.04749487f, -0.00768403f, -0.03314224f, 0.03730870f, 0.06330017f, -0.01429935f, 0.04632548f, 
    -0.05196006f, 0.22705492f, 0.06831068f, 0.07611878f, -0.04667428f, 0.08274787f, -0.06942399f, 0.10166220f, 
    -0.12653543f, 0.13107263f, -0.11352068f, 0.30412856f, 0.33746481f, 0.01094689f, 0.01210380f, 0.05781612f, 
    -0.00333912f, 0.03700422f, -0.09428480f, -0.00867312f, 0.01277200f, 0.08229115f, 0.15287216f, 0.03186499f, 
    0.03583663f, -0.08254703f, -0.05294931f, -0.03381938f, 0.44106001f, -0.14977227f, 0.06995884f, -0.16299897f, 
    0.12860443f, -0.22650757f, -0.01784211f, -0.07357780f, -0.04162937f, -0.03204433f, 0.02175967f, 0.07164535f, 
    0.03633230f, 0.09711292f, 0.01199865f, 0.04323414f, 0.12123219f, 0.11311384f, 0.15959087f, 0.05323922f, 
    0.05314497f, 0.33422497f, -0.11797956f, -0.08654727f, -0.23175421f, -0.03047114f, -0.04685198f, 0.04240963f, 
    0.03482366f, -0.05979338f, 0.01913017f, -0.02187223f, 0.01267658f, -0.06209003f, 0.00100569f, 0.03338096f, 
    0.08271743f, -0.01016729f, 0.01900763f, -0.02325286f, 0.05084586f, 0.06323453f, 0.03637529f, -0.01598840f, 
    -0.09111357f, 0.09919853f, 0.01881987f, 0.02735993f, 0.09987541f, 0.13855535f, -0.01761694f, 0.04793858f, 
    0.05650726f, 0.09352015f, 0.00613644f, 0.06288737f, 0.10321701f, -0.09393911f, -0.03500522f, -0.06041806f, 
    -0.17468151f, -0.07350845f, 0.10351360f, 0.15340559f, -0.21860588f, -0.02955279f, -0.01717772f, -0.05897866f, 
    0.06601701f, -0.07941563f, -0.04138565f, 0.09952601f, 0.08068977f, 0.02877900f, 0.01296801f, 0.13870881f, 
    0.09266409f, 0.02364737f, -0.04436825f, 0.09709546f, 0.13783237f, 0.17122222f, -0.07369915f, -0.17989227f, 
    -0.08347547f, -0.09989440f, 0.05265962f, 0.00374954f, 0.00228480f, -0.05816267f, 0.17426327f, 0.01372589f, 
    -0.20603827f, 0.02734756f, 0.03176000f, 0.06948479f, 0.07427835f, 0.14000763f, 0.06151013f, -0.01780981f, 
    0.19107871f, -0.02857932f, 0.21496864f, 0.30979091f, 0.06073378f, 0.09481241f, 0.02700193f, 0.01520791f, 
    -0.00677068f, 0.09347661f, 0.01993558f, -0.08143646f, 0.04171594f, -0.04820514f, 0.04514750f, -0.12483097f, 
    0.01853349f, -0.08542043f, -0.16833930f, 0.01623582f, -0.17780341f, -0.07953203f, 0.16309902f, 0.20931540f, 
    -0.00858858f, -0.06597974f, -0.01142246f, -0.05413390f, -0.11422516f, 0.03491974f, 0.11112283f, 0.07334938f, 
    0.04382937f, -0.03620424f, 0.02697366f, -0.01503331f, -0.07237429f, -0.05410929f, -0.04548300f, -0.01779926f, 
    0.03775225f, -0.02958617f, -0.05463899f, -0.05236590f, -0.01648013f, 0.00314604f, -0.02315252f, 0.01647772f, 
    -0.04773924f, -0.04847448f, -0.02621944f, 0.01947913f, -0.05258375f, -0.00492837f, 0.02878660f, -0.00424460f, 
    -0.02046147f, -0.02556950f, -0.02563082f, 0.02653714f, 0.03946970f, 0.04563206f, -0.00277852f, 0.00045721f, 
    -0.01409364f, -0.03495068f, -0.03732136f, -0.03249635f, 0.01611836f, -0.02439601f, -0.04395074f, -0.04733549f, 
    0.01637877f, 0.00863110f, -0.01419019f, -0.00234170f, 0.01863576f, 0.03943137f, 0.01264964f, -0.02946966f, 
    0.04575174f, 0.04359328f, -0.02586647f, -0.03011964f, -0.00478624f, 0.03127501f, -0.02815801f, -0.02932111f, 
    0.00189285f, -0.03480418f, 0.00930524f, -0.05402377f, -0.00191406f, 0.00806653f, -0.02590493f, -0.04047610f, 
    -0.04764950f, 0.04611459f, 0.04956787f, 0.00039430f, -0.04813789f, -0.00095010f, 0.01992508f, -0.00377965f, 
    0.00924320f, 0.02403572f, 0.01449976f, 0.00191436f, -0.01571023f, -0.01016147f, 0.00202179f, -0.05962222f, 
    -0.01582968f, -0.05149968f, -0.01493356f, 0.02284814f, -0.00808893f, 0.02662316f, -0.03604324f, 0.03005127f, 
    -0.01633860f, 0.03019615f, 0.03319775f, 0.04997095f, 0.04700959f, 0.04999430f, -0.01523287f, -0.01990197f, 
    -0.02000499f, -0.01334145f, 0.03302803f, 0.04738735f, 0.01214497f, 0.03616152f, -0.05862970f, -0.00261493f, 
    0.02685919f, -0.05730751f, 0.03180464f, -0.05810387f, -0.04921787f, 0.01250279f, -0.03213420f, -0.04557749f, 
    0.03781212f, 0.04647252f, 0.00515208f, 0.03059844f, -0.01954238f, 0.03437120f, -0.04024922f, -0.04793373f, 
    -0.01484504f, 0.05304590f, -0.01392236f, 0.03792302f, -0.01050037f, -0.00346207f, 0.04870729f, -0.05258333f, 
    -0.03240681f, 0.00258438f, -0.00070443f, -0.02583257f, 0.03491251f, 0.02292848f, -0.01705991f, 0.03944470f, 
    -0.05163255f, 0.03803817f, 0.03403745f, -0.01093881f, 0.04611900f, 0.02718337f, 0.02966338f, 0.01158642f, 
    0.02486874f, -0.04268068f, 0.04533987f, 0.04217744f, 0.00766412f, -0.03172943f, -0.05962842f, -0.00614178f, 
    0.01129851f, -0.05181196f, 0.00069398f, 0.02469286f, -0.04333620f, 0.03186413f, -0.02099335f, 0.00278408f, 
    -0.03109391f, -0.01916435f, -0.03812436f, 0.01787211f, 0.04702039f, -0.02805379f, 0.02997015f, -0.02426864f, 
    -0.00033851f, 0.02611446f, -0.03193076f, -0.04683771f, -0.01491214f, 0.04172852f, 0.04714346f, -0.05167511f, 
    -0.02267416f, -0.01217705f, 0.00197426f, -0.00248209f, 0.05043478f, 0.03154457f, -0.02064851f, -0.01451910f, 
    -0.04871414f, 0.02648714f, -0.05598976f, 0.03793223f, 0.01716675f, -0.00101862f, 0.02610102f, -0.04140095f, 
    0.02481156f, -0.02916878f, 0.03527818f, -0.03442552f, -0.05268073f, 0.04899551f, -0.00118037f, 0.03819700f, 
    -0.04156062f, 0.02874175f, 0.04412530f, -0.04461046f, -0.04502068f, -0.02528286f, -0.01542930f, 0.04429383f, 
    -0.03995908f, -0.02355403f, -0.00868907f, 0.04190843f, -0.05619309f, -0.03236943f, 0.02516688f, -0.02944133f, 
    -0.03047354f, -0.05210230f, -0.03610061f, 0.03326739f, 0.02763227f, -0.03758620f, -0.02976351f, -0.05824886f, 
    -0.01882242f, 0.00785128f, 0.02758963f, -0.01165824f, -0.00110949f, -0.00883427f, 0.03279931f, -0.02545139f, 
    0.02573841f, -0.01318837f, 0.01243856f, 0.04290147f, 0.00406169f, 0.03111262f, 0.02101910f, -0.04573355f, 
    -0.05150424f, 0.01223828f, -0.04565184f, -0.00644780f, -0.02435974f, 0.00457423f, 0.02485421f, -0.05584013f, 
    0.01661721f, 0.01476082f, -0.02180796f, -0.03427649f, 0.04432171f, 0.01155038f, -0.02094883f, -0.00841314f, 
    -0.03665697f, -0.02742986f, 0.01637482f, -0.02084762f, 0.03050212f, -0.03716552f, 0.04755753f, -0.01420118f, 
    0.03472854f, -0.03693996f, 0.01617359f, -0.00537283f, -0.04936535f, -0.05122933f, -0.00712477f, 0.03076548f, 
    -0.04152442f, -0.02491104f, -0.05973934f, -0.02031501f, -0.00297743f, -0.05953364f, -0.02119079f, 0.03685220f, 
    -0.01388259f, -0.02185337f, 0.03695416f, -0.04977637f, -0.05554921f, 0.01837430f, -0.06042899f, 0.03780605f, 
    0.01689083f, -0.00223481f, -0.04444715f, -0.03226243f, 0.02314435f, -0.02593624f, -0.00336972f, 0.03958426f, 
    -0.05795995f, -0.04583710f, -0.03859655f, -0.02875096f, -0.04137532f, -0.05564288f, 0.03492762f, -0.02923661f, 
    -0.01298663f, 0.02534657f, -0.02618358f, -0.01704061f, -0.05586312f, 0.04875507f, -0.04966261f, -0.05266948f, 
    -0.05451482f, -0.03579554f, -0.03934774f, -0.01692531f, 0.01913688f, 0.02893437f, -0.03866393f, -0.04188758f, 
    -0.02107629f, -0.04143639f, -0.01745659f, 0.04814542f, -0.02817458f, 0.00812774f, 0.04429636f, -0.02834675f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03900616f, -0.00923331f, 0.07039209f, -0.04639508f, -0.01813783f, -0.03248669f, 0.00440604f, 0.03439946f, 
    0.01753832f, -0.06156091f, 0.04334495f, 0.04816684f, -0.00231013f, 0.01061954f, -0.04683844f, 0.04278940f, 
    -0.00590732f, 0.02818167f, 0.04207202f, 0.03735580f, -0.02267591f, -0.02169408f, -0.03109605f, 0.05864377f, 
    0.09659833f, 0.00649763f, -0.05193678f, -0.05834531f, 0.02233129f, 0.10388088f, 0.05330803f, 0.03607871f, 
    0.05095067f, 0.01227484f, 0.01831920f, 0.04069220f, -0.00032247f, 0.02235383f, -0.00975923f, -0.00122793f, 
    -0.01966538f, -0.01741131f, 0.11490569f, -0.03678399f, 0.01625754f, 0.04533767f, -0.03446515f, 0.02503059f, 
    -0.01179758f, 0.04950226f, -0.01041476f, -0.00721435f, -0.04129295f, -0.01123670f, 0.02577599f, -0.05768813f, 
    -0.05943013f, -0.04655845f, 0.01816504f, -0.01098375f, -0.05061704f, 0.02827209f, 0.06619319f, 0.01103667f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03978956f, 0.10351021f, 0.00523431f, -0.06433263f, 0.23962167f, 0.00726474f, -0.07437369f, -0.09283748f, 
    -0.05777252f, -0.03009927f, -0.07273868f, 0.03621510f, 0.23132513f, 0.20312668f, 0.06085975f, -0.10525429f, 
    -0.38590515f, 0.05520618f, 0.08964615f, 0.23158269f, 0.03861250f, -0.11390254f, -0.03307991f, 0.07486619f, 
    -0.06465563f, 0.23584419f, 0.12904167f, 0.08491603f, 0.00401458f, 0.28703988f, 0.08071753f, -0.10404156f, 
    0.17840719f, -0.37730277f, 0.10954551f, -0.00257711f, 0.16291447f, 0.11726102f, -0.30339843f, -0.10559303f, 
    -0.18503088f, -0.00077647f, -0.00511220f, 0.26962578f, -0.05522225f, -0.07173209f, 0.00978561f, -0.02171799f, 
    0.05459655f, -0.03168395f, -0.12193814f, -0.04113547f, -0.07998002f, 0.06842761f, 0.12759130f, 0.02865767f, 
    0.10491340f, 0.11496415f, -0.03290216f, -0.03998722f, -0.02884004f, -0.05613010f, 0.25174478f, 0.04048303f, 
    0.04154940f, -0.01125734f, 0.01637963f, -0.03067071f, 0.27394572f, 0.05392197f, -0.04641043f, -0.31068185f, 
    0.02371469f, -0.08950149f, -0.39032277f, 0.03198946f, 0.29922006f, 0.03558031f, 0.00228932f, -0.12352450f, 
    -0.13921793f, -0.00567641f, -0.01978241f, 0.11721487f, 0.06749178f, -0.08156344f, 0.22270119f, 0.06165032f, 
    -0.11553524f, 0.22595541f, 0.00510459f, -0.09629019f, 0.11356282f, 0.12353719f, -0.19273256f, -0.09855828f, 
    -0.14337490f, 0.18169209f, -0.00001380f, 0.02505755f, -0.25356448f, -0.05358685f, 0.04114963f, 0.02918745f, 
    -0.18422374f, 0.10245581f, 0.11504601f, 0.38580155f, -0.10488047f, 0.31601343f, 0.02288285f, -0.01335572f, 
    0.01717694f, 0.28594694f, 0.09569049f, -0.04536899f, -0.05026472f, 0.11699454f, -0.21821126f, -0.00125172f, 
    -0.10705005f, -0.04576439f, -0.03244479f, -0.03145268f, -0.06170872f, 0.10399094f, 0.01443884f, 0.01484154f, 
    -0.10810049f, 0.10792154f, 0.11838911f, -0.05088302f, 0.27883351f, -0.05136273f, -0.10680325f, -0.16385643f, 
    -0.00192291f, -0.09870440f, -0.12489253f, 0.05943438f, -0.02458530f, 0.14393903f, -0.13545057f, 0.05343736f, 
    -0.32535425f, -0.03705216f, -0.12511566f, -0.10691281f, 0.16490079f, -0.10897847f, 0.02218621f, -0.02510341f, 
    0.06543113f, -0.08444633f, 0.10338164f, -0.11211622f, 0.10299757f, 0.13929205f, -0.29396066f, -0.05666763f, 
    -0.08672188f, -0.07161388f, -0.09417349f, -0.17453858f, 0.05786325f, -0.07487777f, 0.06494617f, 0.07531728f, 
    0.05979066f, 0.03116130f, 0.07044795f, 0.27307567f, 0.01329347f, 0.09760260f, -0.04940833f, 0.11983103f, 
    0.10022597f, 0.26524058f, 0.45094702f, 0.12409997f, 0.11580917f, 0.05801880f, -0.06341235f, -0.02996352f, 
    -0.06226455f, 0.10687821f, 0.01646485f, 0.04814358f, -0.11255385f, -0.12464932f, 0.28469685f, 0.06778046f, 
    0.08273114f, 0.05562739f, 0.07855700f, -0.00037755f, 0.23166282f, -0.09247203f, -0.02656571f, 0.29290858f, 
    0.02061407f, -0.04913238f, 0.18223989f, 0.01038405f, 0.07746822f, -0.02026960f, -0.04041550f, 0.00826562f, 
    -0.09756397f, 0.14860071f, 0.01660850f, 0.09218045f, -0.20252144f, -0.01924522f, -0.14113602f, -0.02099687f, 
    0.03795461f, 0.15663435f, 0.03451646f, 0.09214000f, 0.08239329f, -0.23383515f, 0.08271927f, 0.11274519f, 
    0.16175054f, -0.08978819f, -0.01906154f, 0.30594182f, -0.26519817f, 0.03264914f, 0.25315252f, 0.00324427f, 
    0.12930058f, -0.02671920f, 0.05419397f, -0.21298181f, 0.01953460f, -0.28826842f, -0.04388505f, 0.08561539f, 
    -0.10723087f, 0.12118611f, -0.02803166f, 0.04300925f, -0.04778454f, -0.03102907f, 0.25599229f, 0.00534424f, 
    -0.11097701f, 0.03128989f, 0.06565375f, 0.11863408f, -0.01209405f, 0.12022078f, -0.25543278f, -0.09947231f, 
    0.11663049f, 0.12695222f, 0.10632955f, 0.08138867f, -0.07729736f, 0.00394348f, 0.02745504f, 0.04379730f, 
    0.04816455f, 0.05521667f, 0.06327731f, 0.11912908f, -0.14303294f, 0.13757525f, -0.08618946f, -0.03612197f, 
    0.44750056f, -0.06226617f, 0.15284407f, -0.10499848f, -0.10479912f, 0.10864168f, -0.01313813f, -0.04913937f, 
    0.24508223f, -0.10385729f, 0.02603777f, 0.08194735f, 0.01916668f, 0.13853133f, -0.01670353f, -0.01012015f, 
    0.27183601f, 0.54807293f, -0.06105974f, 0.07359152f, 0.09121779f, 0.06208495f, -0.12919624f, -0.01639053f, 
    0.02809735f, -0.01465587f, 0.07324840f, 0.05530862f, 0.08924394f, -0.07853310f, -0.01135065f, -0.00127265f, 
    0.10342892f, -0.14868607f, 0.16051823f, 0.03644109f, 0.01754826f, -0.09593340f, 0.06929747f, 0.10718285f, 
    -0.00702792f, -0.08466200f, -0.02434189f, 0.09828474f, 0.13088463f, -0.05041440f, -0.07453024f, 0.12287541f, 
    -0.02721411f, -0.07489048f, -0.13128689f, -0.04232276f, -0.02090639f, -0.11180170f, -0.09345044f, -0.07997714f, 
    0.10870492f, 0.05105153f, 0.00753940f, -0.08945697f, -0.07218004f, 0.04631517f, -0.05234854f, 0.03396257f, 
    0.10018952f, -0.01076777f, -0.08908705f, 0.05275521f, -0.03119235f, 0.02681017f, -0.08470242f, 0.10737304f, 
    0.07820480f, 0.02433891f, 0.04043254f, 0.07717852f, 0.11062984f, -0.02467237f, -0.01393148f, -0.00876640f, 
    0.02040410f, 0.11239158f, 0.08377796f, -0.11360613f, 0.09040912f, 0.05556344f, -0.02460709f, -0.12275180f, 
    -0.02849862f, 0.07857915f, -0.13506795f, -0.09689503f, 0.03874715f, 0.02770041f, 0.02973807f, -0.11356358f, 
    0.10685353f, 0.08993226f, -0.13501011f, -0.10637110f, -0.08117963f, 0.06742959f, 0.06776147f, 0.01187916f, 
    -0.11061475f, -0.10154609f, 0.04836051f, 0.05245005f, -0.11761430f, 0.05909759f, -0.11811049f, 0.06926468f, 
    -0.00778629f, 0.06364767f, 0.23430474f, 0.08106735f, 0.01330460f, -0.04361945f, -0.10042109f, -0.05250851f, 
    -0.02247916f, -0.09773345f, 0.07658977f, -0.00589121f, -0.03651175f, 0.24520712f, -0.00637000f, -0.00384435f, 
    -0.17004272f, 0.26371363f, 0.15774806f, 0.32289690f, 0.08454807f, -0.01114576f, -0.18792428f, -0.02084376f, 
    0.06701450f, -0.12032294f, 0.03947453f, 0.11628874f, -0.04307427f, 0.23681204f, -0.11199685f, -0.00524477f, 
    0.31909230f, -0.21192892f, 0.11437908f, 0.06515247f, 0.08139951f, 0.00447727f, -0.17550482f, 0.05062105f, 
    0.13159718f, 0.03362802f, -0.00489678f, -0.12035757f, 0.08400141f, -0.04201442f, -0.10764559f, 0.09580431f, 
    0.12411361f, -0.01822974f, -0.17257188f, -0.08856504f, 0.09216320f, 0.06235500f, 0.12568356f, -0.00761165f, 
    0.10519312f, -0.00107588f, 0.12354920f, -0.01133037f, 0.05441241f, -0.02203119f, 0.30897179f, -0.04146446f, 
    -0.05156349f, 0.06056638f, 0.02982963f, -0.02436433f, -0.02532000f, -0.03506241f, -0.03103509f, -0.04350955f, 
    0.01635825f, -0.01554370f, 0.07153063f, 0.09314572f, 0.09045941f, 0.11457790f, 0.07301535f, -0.01674909f, 
    0.10667308f, -0.10951694f, -0.09650952f, -0.04548879f, -0.02654516f, 0.05196422f, 0.02202692f, -0.11347238f, 
    0.02768311f, 0.02366718f, 0.08192392f, 0.04173697f, 0.07728820f, 0.09079278f, 0.10614978f, -0.11634705f, 
    -0.11212523f, -0.12815554f, -0.09344439f, -0.10234256f, -0.05694461f, -0.12019280f, -0.09710762f, 0.07307542f, 
    0.05323510f, 0.01699992f, -0.12643765f, -0.08699433f, -0.05997930f, -0.12809610f, 0.11630788f, 0.08766845f, 
    -0.09107709f, -0.13250120f, 0.09621966f, 0.02264424f, -0.09780155f, -0.02443927f, -0.08086044f, -0.09089655f, 
    -0.09711041f, 0.07218942f, -0.06348385f, -0.04447386f, -0.09069762f, -0.11649708f, -0.06291586f, 0.09952241f, 
    0.08065560f, -0.02757568f, 0.05058262f, -0.09335770f, 0.10613412f, -0.06152902f, 0.02237374f, 0.33414865f, 
    -0.06659896f, -0.03022619f, 0.07651001f, -0.10078607f, 0.23311536f, -0.01653091f, 0.09184925f, -0.10618290f, 
    0.09752291f, 0.05888197f, 0.18490858f, -0.19319467f, 0.13257289f, 0.04521703f, -0.25028837f, 0.31003550f, 
    0.20436165f, -0.08093512f, 0.04062581f, -0.10272418f, -0.03584747f, -0.10657357f, 0.44714925f, 0.10091095f, 
    0.18063258f, 0.00557742f, -0.01157348f, 0.07892960f, -0.24855262f, -0.11986659f, 0.14308485f, 0.11611539f, 
    -0.13713177f, 0.08932849f, -0.02921627f, 0.26932737f, -0.01741062f, -0.05870305f, -0.04702684f, -0.06471787f, 
    -0.03609279f, -0.05891724f, 0.14627942f, 0.00169410f, 0.07467267f, 0.11354506f, 0.21806808f, -0.07282423f, 
    0.04418581f, 0.00008794f, 0.00894336f, 0.12462563f, -0.10952939f, 0.08394468f, -0.21734610f, 0.12749425f, 
    -0.02476302f, 0.02230703f, -0.12872316f, -0.03022109f, -0.02682472f, -0.10032915f, 0.04219933f, 0.00569388f, 
    -0.07916243f, -0.00857372f, 0.06760570f, 0.00961530f, 0.07729480f, 0.18969055f, -0.16826794f, 0.04501572f, 
    -0.29942423f, 0.12787805f, -0.13914241f, 0.33046627f, -0.28436616f, -0.06809906f, 0.03970478f, 0.07839331f, 
    -0.11899631f, 0.25881055f, -0.09948434f, 0.03385966f, 0.00673386f, 0.05451047f, -0.03407866f, -0.10212112f, 
    -0.00477047f, -0.09865302f, -0.08714080f, -0.11030442f, 0.03990318f, 0.03068114f, 0.01768636f, 0.07321659f, 
    -0.12561370f, -0.02948474f, 0.06185572f, 0.09384324f, 0.01643549f, 0.24655735f, 0.02901010f, -0.03087237f, 
    -0.01970366f, 0.30872571f, 0.17125294f, 0.11483599f, 0.05771034f, -0.01191270f, -0.11858625f, -0.03550800f, 
    0.01879618f, 0.02997366f, -0.04979839f, 0.10051864f, 0.11597475f, 0.11658081f, 0.12300552f, 0.09112226f, 
    -0.05126180f, -0.09383205f, -0.20555282f, 0.13168594f, -0.06859206f, -0.02298985f, -0.07478110f, 0.25789726f, 
    -0.05044375f, -0.10529750f, 0.28489968f, 0.11919504f, 0.08765311f, 0.02756349f, 0.13583432f, 0.08614068f, 
    0.00783709f, 0.32378903f, -0.00195201f, -0.05077110f, -0.36454049f, 0.02863472f, 0.04767805f, -0.14681968f, 
    0.15156348f, 0.01997150f, -0.09934661f, -0.07550104f, 0.12031862f, -0.13905995f, 0.24175538f, 0.03916488f, 
    -0.01049872f, -0.11873376f, -0.01501801f, 0.31958491f, -0.16754608f, 0.05934469f, 0.46133891f, -0.08849916f, 
    0.23255347f, 0.01986111f, 0.04397437f, -0.19571009f, 0.11564253f, 0.03026605f, 0.03494583f, 0.01357113f, 
    -0.01279647f, 0.00292278f, 0.05420415f, 0.04427537f, -0.10415296f, -0.10815416f, 0.20335965f, -0.10644200f, 
    0.03375831f, -0.00401022f, -0.09062939f, -0.00278515f, 0.03151345f, 0.05573378f, -0.25763658f, -0.12206367f, 
    0.01813618f, 0.12459438f, 0.12706321f, 0.07982784f, -0.17642725f, -0.07680109f, -0.09794936f, 0.12988655f, 
    0.09806950f, 0.09959216f, 0.30543751f, 0.11103582f, -0.05708571f, 0.09825592f, -0.12589304f, -0.01947598f, 
    0.12911649f, -0.11312030f, -0.12628552f, 0.36595753f, -0.04759230f, 0.10321599f, 0.15666354f, 0.06394425f, 
    -0.09417027f, 0.11958987f, 0.09009596f, -0.11432126f, 0.08015539f, 0.19607115f, -0.14615785f, 0.01399616f, 
    0.20086080f, -0.03234901f, -0.01338027f, -0.21139783f, -0.15522535f, 0.04094737f, 0.03671046f, 0.10662489f, 
    0.27162129f, -0.04984052f, -0.14931677f, 0.43666309f, -0.11788970f, 0.15015976f, -0.06393800f, -0.02049856f, 
    -0.01917632f, 0.24069686f, -0.00031241f, -0.02417375f, 0.06354520f, 0.10495583f, -0.01952497f, 0.07657520f, 
    0.06570022f, 0.02216678f, -0.06225834f, 0.36787432f, -0.01274866f, 0.03503059f, -0.04117377f, 0.02451912f, 
    -0.03955241f, 0.09544084f, -0.03444618f, 0.10679404f, -0.30134088f, -0.09245668f, 0.00924547f, -0.09936789f, 
    0.09960640f, 0.03139273f, 0.10481515f, 0.08029283f, -0.13387240f, 0.10058228f, 0.09475685f, -0.10634926f, 
    0.06883311f, -0.14138550f, -0.10351463f, 0.31898853f, -0.12531368f, 0.02449226f, 0.21103315f, -0.22629279f, 
    -0.21957955f, 0.20817500f, -0.08950100f, -0.11571010f, -0.06791964f, 0.31774828f, -0.03943960f, 0.08727337f, 
    -0.01294270f, 0.12596083f, 0.01468964f, 0.01151211f, 0.28939024f, -0.04158309f, -0.16113433f, 0.05413500f, 
    0.14281337f, -0.00101287f, 0.08770832f, -0.20343688f, -0.07681201f, 0.31419858f, -0.09595152f, -0.03577591f, 
    0.02582211f, 0.13947409f, -0.16283263f, 0.25046441f, -0.05678117f, -0.04836309f, 0.04626002f, 0.01654877f, 
    -0.07197699f, 0.04933505f, 0.01151409f, 0.31599078f, 0.12049967f, -0.08729855f, 0.13601366f, 0.02258131f, 
    -0.07392998f, -0.07504852f, 0.07719470f, -0.11156265f, 0.03684730f, 0.11163180f, 0.04700661f, 0.01524878f, 
    0.02194855f, 0.05821132f, -0.03824333f, 0.08832580f, 0.02520647f, 0.04595464f, -0.14674301f, -0.11889631f, 
    -0.12654854f, -0.00998852f, -0.08419956f, -0.13401864f, -0.10404252f, 0.10075523f, 0.09096254f, -0.06253778f, 
    0.04535713f, -0.09195161f, -0.03987107f, 0.05973227f, -0.02652197f, 0.08128428f, 0.06620007f, -0.01273816f, 
    -0.13194005f, 0.00415607f, -0.02123323f, -0.03178168f, -0.12594283f, -0.01980952f, -0.13572286f, 0.07312009f, 
    -0.00683212f, 0.08675575f, -0.02432725f, -0.11596927f, -0.10068693f, -0.12903620f, 0.01711683f, 0.07311754f, 
    -0.08948389f, 0.04018287f, -0.02803973f, -0.13991705f, -0.04309319f, -0.06891645f, -0.07014865f, 0.10570689f, 
    0.08132151f, 0.11869410f, 0.00541270f, -0.15684003f, -0.04926872f, -0.12637626f, -0.04988348f, -0.08395397f, 
    -0.03952958f, -0.09681198f, -0.17862572f, 0.09220670f, -0.09651612f, 0.05044742f, -0.01220624f, 0.00246283f, 
    0.00498344f, -0.04152920f, 0.53378916f, -0.05399291f, -0.18519624f, 0.02842971f, -0.20953695f, 0.02764626f, 
    0.20101112f, 0.08974195f, 0.14301737f, -0.03165189f, -0.03162234f, 0.08543686f, -0.01483952f, -0.07340750f, 
    0.13325456f, -0.12397651f, 0.03213076f, -0.00810938f, 0.00308515f, 0.30308008f, 0.05606785f, 0.07080773f, 
    0.08109883f, -0.11839430f, 0.08256415f, -0.04647092f, -0.29013893f, 0.05075928f, 0.35830799f, -0.00895160f, 
    0.27590358f, 0.07359473f, 0.00904899f, 0.05114600f, -0.05925651f, 0.17854282f, 0.05936350f, 0.06996354f, 
    -0.02988869f, 0.21578528f, 0.33921027f, 0.13109390f, 0.10161211f, -0.03011864f, 0.09126331f, 0.07043537f, 
    -0.10439910f, -0.00410406f, -0.11755791f, -0.11173873f, 0.07351816f, 0.06455430f, -0.07729278f, -0.00015267f, 
    0.03112926f, -0.07639545f, -0.07558841f, 0.01552171f, 0.24771114f, 0.00914223f, -0.09092978f, 0.06275528f, 
    0.05142289f, -0.04287077f, -0.09366432f, -0.03031038f, -0.09827869f, 0.21342137f, -0.04173883f, -0.10910079f, 
    0.28202546f, -0.12050630f, 0.08311206f, 0.17886208f, 0.29124102f, 0.10917838f, -0.28370658f, 0.21781418f, 
    0.08147630f, -0.10940411f, -0.11171500f, -0.11317180f, -0.08841281f, -0.13511260f, -0.01340450f, -0.05822167f, 
    0.31434098f, 0.17652293f, -0.01626168f, -0.08196915f, -0.45383698f, 0.12033589f, 0.04500202f, 0.04607774f, 
    0.06244469f, -0.11524144f, 0.00566411f, 0.25839236f, -0.10530578f, -0.14723635f, 0.08819231f, -0.05435966f, 
    -0.04315220f, 0.04577813f, 0.26880434f, -0.08917528f, 0.02540341f, 0.07194930f, -0.08311936f, 0.07677208f, 
    -0.02176520f, -0.00933665f, 0.12655945f, -0.10633820f, -0.01686886f, 0.09152971f, 0.14190225f, -0.06967160f, 
    0.05191572f, 0.12582231f, -0.14464864f, -0.01394632f, 0.18711092f, -0.08530883f, -0.07841306f, -0.22151755f, 
    0.07680655f, 0.10931212f, 0.10596023f, -0.08688997f, 0.24805161f, 0.19825223f, 0.06422277f, -0.08415189f, 
    0.17672107f, 0.33116904f, 0.00992925f, -0.08013061f, -0.33940068f, 0.04686796f, -0.01630511f, -0.02436675f, 
    0.22399879f, -0.03867066f, 0.03809469f, 0.11649464f, -0.02080603f, 0.07885664f, 0.33955723f, -0.00374815f, 
    -0.08139034f, -0.09250508f, 0.02450453f, 0.27399966f, -0.16112354f, 0.08421838f, 0.42568532f, -0.10692259f, 
    0.00676188f, -0.08459251f, -0.06233130f, -0.10236780f, 0.05376616f, -0.04093013f, -0.07504391f, 0.07070116f, 
    -0.04993165f, -0.00274670f, 0.11156738f, -0.06063608f, -0.00104680f, -0.04142604f, 0.01710960f, 0.03204639f, 
    -0.03056367f, 0.02588086f, -0.04443233f, -0.26219726f, -0.06384711f, -0.04763940f, 0.02592707f, -0.05495208f, 
    -0.03977788f, -0.11229729f, 0.08246391f, 0.02330527f, -0.43438956f, -0.05961371f, 0.07626942f, -0.01158361f, 
    -0.12070531f, -0.09985013f, -0.24744640f, -0.03129256f, 0.03993139f, -0.06280039f, -0.04660499f, -0.12989087f, 
    -0.15350965f, 0.01666041f, 0.27745709f, -0.35511690f, 0.30865920f, -0.09874913f, -0.18769841f, 0.13834402f, 
    0.04507869f, -0.06444565f, -0.02885145f, -0.03638364f, -0.01839863f, 0.09086130f, 0.32130206f, 0.06452780f, 
    -0.30503866f, 0.20894092f, -0.05593999f, 0.21529004f, 0.41933465f, -0.01932728f, 0.01401353f, -0.11845947f, 
    0.05626237f, 0.06916392f, 0.18310468f, -0.15142778f, -0.07189268f, 0.16739611f, -0.12077592f, -0.06127864f, 
    -0.01992244f, -0.19379246f, 0.01662505f, 0.03770272f, 0.04414416f, -0.02555731f, 0.08344773f, 0.09131451f, 
    0.05013395f, -0.11841012f, 0.00400224f, -0.11078265f, -0.02160580f, 0.12030414f, 0.16863632f, -0.00995600f, 
    -0.00246514f, 0.07450466f, -0.10036215f, -0.00114663f, -0.34820527f, 0.03547460f, 0.11393560f, 0.01174001f, 
    -0.00535956f, -0.10010633f, 0.16893534f, -0.03687761f, -0.21586418f, -0.07621591f, -0.13496301f, -0.04508379f, 
    0.18102558f, -0.26323658f, 0.14967605f, -0.11248862f, 0.15240888f, -0.02371475f, 0.11091904f, 0.13657469f, 
    0.27215344f, -0.12960342f, 0.03987363f, 0.06236278f, 0.03015727f, 0.02864957f, -0.09383114f, -0.10724290f, 
    0.05103203f, 0.28449717f, -0.05399311f, -0.04733240f, 0.24227345f, 0.11495524f, 0.04293923f, 0.10579520f, 
    -0.01272769f, -0.03939572f, 0.23482195f, 0.04809401f, -0.06258287f, 0.12926908f, 0.07633907f, -0.06756628f, 
    -0.02073579f, -0.15459141f, 0.31139582f, 0.14417593f, 0.06375419f, -0.00328561f, 0.00787687f, -0.04918851f, 
    0.04770622f, 0.04216513f, 0.11921665f, -0.11117080f, -0.06661905f, -0.04940241f, 0.11317314f, 0.09918604f, 
    0.08556139f, -0.11121348f, -0.00292967f, 0.07414553f, -0.08540577f, -0.05578911f, 0.00768907f, -0.04586365f, 
    0.05970294f, 0.01578599f, -0.12442440f, 0.07937038f, -0.05210267f, -0.10748310f, 0.09522238f, -0.07213181f, 
    0.02454929f, -0.08690520f, -0.09424462f, 0.09181423f, 0.03279370f, -0.12792481f, -0.09536079f, -0.09762023f, 
    0.01203015f, 0.06171287f, -0.02841882f, -0.01625456f, -0.08902946f, -0.12709275f, 0.01347584f, 0.04754434f, 
    -0.01460189f, 0.06204476f, -0.11490701f, -0.10292862f, -0.04647697f, 0.07973312f, 0.02289851f, -0.06329145f, 
    -0.06722880f, -0.09712104f, 0.01127596f, -0.05533560f, -0.02627403f, 0.01718302f, 0.01219472f, -0.06491306f, 
    -0.01298614f, -0.13826890f, 0.09571008f, 0.04377557f, 0.09425507f, 0.01194560f, -0.06671735f, -0.02496924f, 
    0.09508799f, -0.06304972f, -0.06690413f, -0.01215047f, -0.09068264f, -0.00855750f, -0.05498227f, -0.11466013f, 
    0.12418463f, 0.10815344f, 0.10900225f, -0.08478363f, 0.06216888f, 0.03378252f, 0.09985643f, 0.03485882f, 
    -0.04651591f, 0.11423207f, 0.21231310f, 0.00258766f, 0.03094200f, 0.15123899f, -0.02183659f, -0.12890235f, 
    -0.16728535f, 0.04594174f, -0.11377060f, -0.09433465f, -0.35754001f, 0.07547227f, -0.08414381f, -0.11258668f, 
    0.09425529f, -0.02021954f, 0.07701280f, -0.08923922f, -0.08265255f, 0.16271110f, -0.08064953f, -0.03181670f, 
    -0.19517693f, 0.08435220f, 0.03738496f, 0.23586710f, -0.17482884f, 0.00821947f, 0.22895126f, -0.04628344f, 
    0.09153669f, 0.06509931f, 0.03128202f, -0.25939295f, -0.03658210f, -0.00082442f, -0.05408325f, 0.04318340f, 
    0.08032600f, 0.18009639f, 0.40309906f, 0.18244681f, 0.10266528f, -0.01094140f, 0.13428763f, -0.08178286f, 
    -0.02604251f, -0.05881449f, 0.02127286f, 0.09096404f, -0.09336643f, 0.10073036f, -0.08861957f, 0.07251583f, 
    0.06228241f, 0.08749206f, -0.14273004f, 0.04698288f, -0.08582760f, -0.03292900f, 0.08197626f, -0.19184239f, 
    -0.01731307f, -0.10777494f, 0.20493996f, 0.10056897f, -0.11819863f, 0.10118362f, -0.11373022f, -0.04031113f, 
    -0.13270615f, -0.02869667f, 0.10010409f, 0.29492325f, -0.11817364f, -0.00371680f, 0.27042392f, -0.07597974f, 
    -0.30735654f, 0.06924602f, -0.05322974f, 0.06059076f, 0.02254370f, 0.45223418f, -0.13523550f, 0.07202438f, 
    -0.17398083f, -0.32777530f, 0.10849822f, -0.22263801f, 0.29256397f, 0.06775455f, 0.04322331f, 0.05529742f, 
    0.13949104f, 0.09710927f, 0.07421384f, -0.18878414f, -0.03643579f, 0.21972296f, -0.01035438f, -0.05304484f, 
    -0.09169700f, -0.10158322f, -0.23174353f, 0.18995301f, -0.04150916f, 0.07372554f, 0.03083165f, -0.08324862f, 
    -0.06534473f, 0.04836877f, 0.00659678f, 0.02940529f, 0.07790204f, 0.00166297f, 0.27577546f, -0.02186589f, 
    -0.07329411f, -0.10822049f, 0.16683093f, 0.05982386f, 0.13498572f, -0.10953676f, 0.02670662f, 0.03057654f, 
    -0.02262508f, -0.03480453f, -0.17818731f, -0.11536453f, 0.14474072f, 0.10945974f, 0.14955015f, 0.10643697f, 
    0.15047611f, 0.05051568f, 0.28581846f, -0.10499047f, 0.42207101f, -0.01479801f, -0.08283725f, 0.30097932f, 
    0.04801388f, 0.09868206f, 0.00590183f, -0.10133111f, 0.05463430f, -0.08708876f, 0.30724230f, 0.08697668f, 
    0.13218842f, -0.20561871f, 0.06611195f, -0.06307082f, -0.14758040f, 0.00519510f, -0.14843941f, -0.07734606f, 
    -0.15431963f, 0.03078211f, 0.03683688f, 0.42917788f, 0.05111748f, -0.02557475f, 0.08107341f, 0.00000333f, 
    -0.08108490f, 0.09328111f, -0.22094704f, -0.11736554f, -0.02956264f, 0.09221141f, 0.10930105f, 0.09920353f, 
    -0.07061405f, 0.01282632f, -0.08427850f, 0.06100086f, -0.08897878f, 0.03129732f, -0.08887183f, 0.03383327f, 
    0.06240526f, 0.02930986f, 0.24446952f, -0.04444739f, 0.00175331f, 0.00589711f, -0.01558096f, 0.08910942f, 
    0.06485005f, -0.12066781f, 0.20165727f, -0.02686173f, -0.04079133f, -0.12527189f, -0.16370749f, -0.01412139f, 
    0.36904091f, -0.28087476f, 0.01124668f, 0.11832284f, 0.24413536f, 0.03501454f, -0.19307235f, 0.17009275f, 
    0.22171843f, -0.12261961f, 0.04096221f, 0.06173583f, -0.09720476f, -0.04991025f, 0.04115566f, 0.07029012f, 
    0.10735355f, 0.35330012f, -0.02258593f, 0.15001391f, -0.30577523f, -0.07258780f, 0.02227309f, -0.03251873f, 
    0.14363551f, -0.00662593f, 0.08551663f, 0.36814234f, 0.04391449f, -0.12245779f, -0.03956633f, -0.05607126f, 
    0.03755673f, 0.20149103f, 0.23134810f, -0.08309244f, -0.01316997f, -0.03381481f, -0.15977803f, -0.11313831f, 
    0.06079586f, -0.06214611f, -0.04154402f, 0.13039297f, 0.06272257f, 0.04309721f, -0.11796101f, -0.06900439f, 
    0.00046982f, -0.06236751f, -0.04854429f, 0.05174001f, 0.12344376f, -0.06802306f, -0.06312085f, -0.17370623f, 
    0.04390124f, -0.02657734f, 0.03598556f, 0.09217073f, -0.11038036f, 0.23754466f, -0.15897851f, -0.04702584f, 
    -0.21292165f, 0.02454425f, -0.01553652f, 0.43903372f, 0.02176023f, -0.06573603f, -0.19794235f, -0.08488167f, 
    0.15241945f, 0.06577364f, 0.11302236f, -0.06092374f, -0.12296112f, 0.13615964f, -0.08847206f, -0.02033060f, 
    0.16456206f, -0.20434377f, -0.00259487f, -0.04227242f, -0.15158340f, 0.03614350f, -0.16154149f, 0.10792792f, 
    0.16017890f, 0.11925554f, 0.22964007f, -0.29627004f, -0.02455262f, -0.13855419f, 0.04904325f, -0.03762126f, 
    -0.10267868f, 0.25033581f, 0.15713471f, 0.03706708f, -0.10197246f, -0.08084631f, 0.03124540f, 0.05432260f, 
    -0.11072347f, -0.07005478f, 0.03165830f, -0.14602150f, 0.06821909f, 0.12187514f, 0.48279485f, 0.01174875f, 
    -0.08814589f, 0.02429339f, 0.10267886f, -0.08671308f, 0.01371302f, 0.05297505f, 0.08667039f, -0.09865538f, 
    0.10703860f, -0.00552310f, -0.05583505f, -0.08645489f, 0.01706374f, 0.11581125f, 0.00510550f, -0.01109006f, 
    -0.11933381f, 0.05112839f, -0.01138702f, -0.11354378f, 0.02449028f, 0.13140094f, -0.03614199f, 0.10672511f, 
    -0.04584049f, -0.00103456f, -0.10550729f, 0.04209078f, -0.10395117f, -0.02161142f, -0.12985359f, -0.06559172f, 
    -0.12903342f, -0.05251854f, -0.11954619f, 0.06833455f, -0.09769177f, 0.09354853f, -0.07516621f, -0.06517188f, 
    0.02156482f, 0.06104394f, -0.02908816f, -0.01309096f, -0.06812185f, -0.03385819f, -0.10377257f, -0.03904236f, 
    0.04016463f, 0.01573755f, -0.01989751f, -0.04809384f, -0.10644553f, -0.06618100f, -0.12492070f, -0.02316982f, 
    -0.11978713f, -0.11888433f, 0.09051108f, -0.12994474f, 0.08710689f, -0.07439639f, -0.03489661f, 0.08373303f, 
    -0.08848114f, -0.05581548f, -0.04343295f, 0.06133894f, -0.34197447f, -0.00770221f, -0.04897974f, 0.16374239f, 
    0.05308666f, 0.08641014f, 0.17420831f, 0.06167901f, -0.13757530f, -0.11818490f, -0.17651410f, -0.07174423f, 
    -0.14178528f, -0.20023955f, 0.18169810f, 0.17027898f, -0.12069574f, 0.08447716f, 0.02368054f, -0.04598028f, 
    0.08563080f, 0.09477585f, -0.09572057f, -0.04378160f, -0.06623909f, 0.35440922f, 0.26735309f, -0.09401448f, 
    -0.03605813f, 0.00421954f, -0.06423028f, -0.02329392f, 0.27422825f, -0.11036655f, 0.09424601f, -0.09550466f, 
    -0.03421890f, -0.00318318f, 0.16929947f, 0.29846981f, -0.03837892f, 0.52885705f, -0.08564717f, 0.02187697f, 
    -0.12574364f, 0.25709540f, 0.28643194f, 0.08498924f, -0.02154101f, 0.04586771f, -0.06160756f, 0.01823137f, 
    -0.00183917f, -0.00453797f, 0.05661286f, 0.23747621f, -0.09747519f, 0.11674824f, -0.10441261f, 0.01171362f, 
    -0.05739376f, -0.09040217f, 0.11896577f, -0.02487738f, -0.03226763f, 0.00246306f, -0.00069202f, 0.02652807f, 
    0.02862545f, 0.05844092f, 0.01523456f, 0.02151842f, 0.05391157f, 0.06548055f, -0.08811523f, 0.07877541f, 
    -0.11073869f, -0.02490357f, -0.08137129f, -0.05180586f, -0.03215390f, -0.01781877f, 0.10116620f, -0.12809779f, 
    -0.12575397f, -0.11678824f, 0.05252049f, 0.01758517f, 0.10189873f, 0.01122035f, -0.03267895f, -0.05175070f, 
    0.01475677f, -0.03933512f, -0.09963082f, -0.05921805f, -0.08206241f, -0.04222220f, 0.05015546f, 0.02148741f, 
    0.08305848f, -0.08042687f, -0.04599487f, -0.10110573f, 0.02790336f, -0.10687491f, -0.02834174f, -0.04901762f, 
    0.01005962f, 0.09570035f, -0.11011498f, 0.00093971f, 0.07548182f, -0.08274721f, -0.07776856f, -0.00442839f, 
    0.10812314f, 0.05691409f, 0.00987351f, -0.00287896f, -0.05621184f, 0.07208170f, -0.08198349f, -0.05359113f, 
    0.06217988f, -0.10438813f, -0.08778250f, -0.11242923f, 0.02796992f, 0.11859163f, 0.06851541f, -0.03574887f, 
    0.08880178f, -0.05801782f, -0.10738289f, -0.07207374f, 0.10103630f, 0.03090801f, 0.07550891f, 0.06969674f, 
    -0.09721716f, -0.09770997f, -0.07773672f, 0.01430376f, 0.03168183f, 0.10097487f, -0.04746644f, -0.08865923f, 
    0.07730437f, -0.04505092f, 0.07930816f, 0.04456358f, 0.02245152f, -0.13519740f, 0.03665077f, -0.12955108f, 
    0.08459385f, -0.11157981f, -0.04545310f, 0.06720495f, -0.05420555f, -0.12236582f, 0.05102530f, -0.03336722f, 
    -0.06637686f, -0.08047992f, -0.08038340f, -0.02267403f, -0.01565924f, -0.06838728f, -0.04214237f, 0.08494757f, 
    -0.04677974f, 0.00716350f, -0.08093669f, -0.10096071f, 0.03520305f, 0.01134425f, -0.04462396f, 0.02797518f, 
    -0.07093522f, 0.10705785f, 0.00623533f, -0.10649635f, -0.08418560f, 0.03249729f, 0.00064362f, 0.10396123f, 
    -0.01381289f, -0.01739922f, 0.22331940f, -0.11027309f, 0.05918028f, -0.05647856f, -0.00096864f, 0.31311956f, 
    0.03588700f, -0.06929898f, 0.10599110f, 0.10744421f, 0.13920143f, 0.14066292f, 0.17485310f, 0.11249089f, 
    -0.17943744f, 0.28709364f, 0.01382211f, -0.02422298f, 0.03560448f, 0.07899449f, -0.13329060f, 0.09570673f, 
    -0.07945091f, 0.24307324f, -0.06921720f, 0.01030417f, 0.08579914f, -0.17881368f, 0.14799014f, -0.07646996f, 
    0.03379083f, -0.22044982f, -0.02050241f, 0.15423025f, -0.16171594f, 0.07646795f, 0.10255882f, 0.04454371f, 
    0.20527709f, 0.01018957f, -0.02491941f, -0.10121518f, 0.08078681f, -0.17788798f, 0.11531930f, -0.04613486f, 
    -0.03917609f, -0.02435842f, -0.15380964f, -0.01783389f, 0.01261386f, 0.08588972f, 0.17819305f, -0.08686312f, 
    -0.04514368f, -0.08330297f, 0.03452445f, 0.26757354f, -0.07865518f, -0.11432868f, -0.25133574f, 0.11991752f, 
    0.05125557f, 0.04385210f, 0.25244805f, 0.11476184f, 0.23181914f, -0.07719173f, -0.04496917f, -0.25733075f, 
    -0.02989335f, -0.07563318f, -0.17696005f, -0.00238467f, 0.16091950f, 0.24239874f, 0.17079459f, -0.08295325f, 
    0.04012530f, 0.28314769f, 0.26832733f, -0.20912516f, 0.24478929f, 0.05905868f, -0.27987266f, 0.10576166f, 
    0.19908364f, -0.33186531f, -0.04215170f, 0.09406473f, -0.02865718f, -0.05445956f, 0.20074633f, 0.01729452f, 
    -0.01757881f, -0.16222526f, -0.02594330f, -0.06331567f, -0.14405829f, -0.06394947f, -0.08828046f, 0.04623994f, 
    -0.10056770f, -0.07200173f, 0.01510383f, -0.17200355f, 0.11143617f, -0.16917132f, -0.05852116f, -0.00549466f, 
    -0.09387065f, -0.30469730f, -0.01991561f, -0.13773637f, 0.00384466f, -0.08839574f, 0.10939584f, 0.01207372f, 
    -0.07413898f, 0.06998376f, 0.04529566f, -0.17105161f, -0.00923376f, 0.04153905f, 0.26802236f, -0.04309995f, 
    -0.07742403f, 0.05340662f, -0.10790209f, -0.05591831f, 0.26973543f, -0.00775083f, -0.08709766f, 0.15219975f, 
    -0.08024461f, 0.09568436f, -0.27668566f, 0.12075841f, 0.29361913f, 0.12262087f, 0.31583014f, 0.05575917f, 
    0.02551962f, 0.05268551f, -0.03038204f, -0.07661019f, -0.15911318f, -0.07733303f, 0.27785483f, -0.14686790f, 
    0.05034634f, -0.02785859f, -0.10827199f, -0.00034914f, -0.02630325f, -0.17439364f, 0.16906826f, 0.12636273f, 
    -0.10930341f, 0.33077773f, -0.07839712f, -0.09599420f, 0.11301545f, -0.01543235f, 0.04391585f, -0.09506047f, 
    -0.22866869f, 0.03256608f, 0.13674170f, -0.29527330f, -0.00066500f, 0.12160613f, -0.02805919f, 0.03527416f, 
    -0.06218963f, -0.00412792f, -0.18051587f, 0.17854050f, -0.04107484f, -0.04846085f, 0.07265732f, -0.03182977f, 
    0.05711709f, 0.08292486f, 0.03413004f, -0.15273423f, 0.10914305f, 0.08115814f, 0.13658717f, -0.07545210f, 
    0.02778414f, 0.02756011f, 0.33634910f, 0.00399863f, 0.10441472f, 0.10056180f, -0.08073358f, -0.32538623f, 
    -0.03179235f, -0.08352543f, -0.03039756f, -0.05669720f, -0.17831957f, -0.18099596f, -0.15305234f, -0.06381687f, 
    -0.42986676f, 0.01257137f, 0.00977365f, 0.00854780f, 0.33460799f, 0.00863969f, -0.07834700f, 0.10990157f, 
    0.06675051f, -0.05305466f, 0.05862531f, -0.00264942f, 0.03992134f, 0.12498136f, -0.36917412f, -0.01956712f, 
    -0.27968663f, 0.01880584f, -0.01953593f, 0.01230150f, -0.01419189f, 0.05645730f, 0.06001299f, 0.05812877f, 
    0.33979490f, -0.07108127f, 0.13372271f, -0.06474432f, 0.00524519f, 0.05219176f, -0.08982551f, -0.04912611f, 
    -0.07444897f, 0.01555868f, 0.12530938f, -0.01940386f, 0.05486709f, -0.10898814f, 0.05578044f, 0.04352923f, 
    -0.05373377f, 0.06719154f, 0.09482414f, 0.08655887f, 0.01412715f, 0.02442281f, 0.23385090f, -0.09698950f, 
    0.08964833f, -0.00867913f, 0.36960110f, -0.05479778f, 0.02817457f, -0.11259692f, -0.09216400f, 0.24096520f, 
    -0.06861436f, 0.10761809f, 0.11330318f, -0.06615102f, -0.14553820f, -0.05650197f, 0.19516067f, -0.07375822f, 
    0.27770081f, 0.00031762f, -0.08613724f, 0.06220836f, -0.10290499f, 0.04862461f, 0.33688846f, -0.10313321f, 
    -0.15948725f, 0.05595120f, 0.00436640f, 0.05649909f, 0.00947827f, -0.21461430f, -0.21039391f, -0.09025481f, 
    0.03914898f, 0.45503169f, -0.00283172f, 0.12204356f, 0.18579504f, -0.04832075f, -0.10001784f, -0.07791437f, 
    0.33556813f, -0.00066014f, 0.12941951f, -0.26651067f, 0.06018560f, -0.23813175f, -0.01782120f, 0.08407277f, 
    0.11136829f, -0.05087626f, -0.26186523f, 0.19580853f, 0.02467517f, 0.09593795f, 0.20432548f, 0.06783668f, 
    0.07208781f, 0.11411875f, 0.05135363f, 0.43461892f, 0.09428950f, 0.07156096f, -0.08732678f, -0.09183037f, 
    0.05798292f, -0.10665070f, -0.20135286f, -0.09111340f, -0.11283256f, -0.08906189f, -0.08957984f, 0.27876809f, 
    0.01559959f, -0.12265802f, 0.09861318f, 0.12953323f, -0.17598180f, -0.03001975f, -0.26584980f, -0.00637064f, 
    0.03961793f, -0.15235898f, -0.07462436f, -0.10048671f, 0.10760102f, -0.02852012f, -0.01311747f, 0.07589250f, 
    0.16906324f, -0.14218795f, -0.10284301f, 0.01770278f, 0.02425238f, 0.24727966f, -0.16008134f, -0.01213082f, 
    -0.01702785f, 0.16532828f, -0.10902111f, -0.15852155f, 0.32566687f, 0.10570081f, -0.11090451f, 0.08329627f, 
    0.19052356f, -0.00230585f, 0.11442625f, 0.28857979f, 0.05752666f, 0.24392498f, -0.01074330f, -0.11535165f, 
    -0.04003416f, -0.11395495f, 0.36296621f, 0.16267802f, 0.06300313f, 0.11276985f, 0.08584237f, 0.03925453f, 
    0.06225891f, -0.02861018f, 0.10018861f, -0.20993473f, -0.08840069f, -0.00509097f, 0.25645322f, 0.05238056f, 
    0.08860780f, -0.08435683f, 0.22460289f, 0.03327616f, 0.20424925f, -0.07310181f, 0.06081052f, -0.16599762f, 
    0.01785984f, 0.12904130f, -0.09504440f, 0.12669025f, 0.18824863f, 0.08586199f, 0.21756934f, -0.00289454f, 
    0.13858353f, 0.22594063f, 0.24173354f, -0.25516060f, 0.07537732f, -0.02978077f, 0.26803273f, 0.15535875f, 
    0.06709042f, -0.24012516f, -0.05311320f, -0.05232521f, -0.09986028f, 0.15144372f, -0.14252219f, 0.11367274f, 
    0.12793420f, -0.15638933f, 0.10192058f, -0.18925919f, 0.08700429f, -0.06595120f, -0.09834924f, -0.07087776f, 
    0.12953824f, -0.02325281f, 0.03651505f, 0.03004754f, -0.09566697f, -0.26906273f, -0.06900028f, 0.12164319f, 
    0.08559568f, -0.25980508f, -0.22670960f, 0.08667304f, -0.08739205f, -0.10955800f, 0.03256576f, 0.03593037f, 
    0.02907747f, -0.08517832f, -0.02514431f, -0.13027382f, 0.00741597f, -0.09099296f, 0.27952299f, -0.03006477f, 
    0.10585169f, -0.07586386f, 0.06622048f, -0.11415362f, 0.08734636f, 0.06358848f, -0.08535256f, -0.11265957f, 
    0.11921559f, -0.10408621f, 0.22102420f, 0.06147121f, 0.01549351f, 0.08877036f, 0.17360167f, -0.04671743f, 
    0.25522834f, 0.05707622f, 0.01235997f, 0.18803488f, -0.32144666f, 0.04958231f, 0.31674823f, -0.26179013f, 
    -0.22931418f, 0.17411287f, 0.06660552f, -0.10339091f, 0.08206260f, 0.15194470f, -0.14610277f, -0.01058810f, 
    -0.15853181f, 0.23903334f, -0.12227642f, 0.18195203f, 0.00458783f, -0.10077164f, 0.17552599f, 0.04776287f, 
    0.15525343f, 0.07105400f, -0.16349114f, 0.01761131f, 0.08764698f, 0.16139358f, 0.11207215f, 0.01869862f, 
    0.08586484f, 0.16547127f, -0.16745819f, 0.21097136f, -0.07400431f, -0.12210166f, -0.10783163f, -0.07113679f, 
    0.12081958f, -0.11760998f, 0.03355198f, 0.24378139f, 0.01106714f, -0.06492342f, -0.27836141f, -0.11310627f, 
    0.04741402f, -0.04511908f, 0.09632256f, -0.05720065f, -0.05106879f, 0.03965012f, 0.04034394f, -0.23329392f, 
    0.08205754f, -0.00937965f, 0.05466191f, 0.10102902f, -0.12101369f, 0.23889543f, 0.03616617f, 0.02661751f, 
    -0.02299458f, 0.09141516f, 0.07608093f, 0.32515502f, -0.01113658f, -0.09699219f, -0.34733406f, 0.01219719f, 
    0.19382763f, 0.08748979f, -0.09211441f, -0.08260714f, -0.11069840f, 0.13906012f, 0.32406217f, 0.00314235f, 
    0.19751209f, -0.09686229f, 0.04506024f, 0.20828250f, -0.22626293f, -0.05297166f, 0.02621325f, -0.11779866f, 
    -0.07698019f, -0.08773579f, 0.10130854f, -0.11170179f, -0.06310733f, 0.00445839f, 0.02605436f, 0.00508741f, 
    0.04565846f, 0.03015014f, -0.07627229f, -0.21853210f, -0.11673266f, 0.11225541f, -0.06773326f, 0.08634026f, 
    -0.00887765f, -0.07294149f, 0.03943844f, -0.16798927f, -0.08124521f, -0.08140822f, 0.26776335f, -0.05387954f, 
    -0.11783741f, 0.03372303f, 0.03569183f, -0.02523446f, -0.14102992f, -0.03922263f, 0.03669727f, 0.17304440f, 
    -0.03366976f, -0.07373987f, -0.04496359f, 0.05131794f, 0.05658064f, 0.15138108f, -0.08968933f, 0.10403352f, 
    0.22899199f, -0.12910393f, -0.03462608f, 0.38571793f, -0.31965548f, -0.09898739f, 0.09043075f, 0.14206642f, 
    -0.00461300f, 0.02594658f, -0.11134418f, 0.02806405f, -0.02041966f, 0.12584640f, 0.24635829f, -0.09504201f, 
    0.30399689f, 0.06227699f, -0.11210117f, 0.07388693f, 0.12078112f, -0.11336273f, -0.00531944f, 0.09356933f, 
    -0.22918707f, 0.10512797f, 0.03086838f, 0.28396851f, 0.01479078f, 0.05094979f, -0.05328134f, -0.06530287f, 
    -0.04623970f, 0.07936943f, -0.16261081f, -0.09637462f, 0.05452167f, 0.05251067f, 0.04934600f, 0.09474839f, 
    0.09862453f, 0.00008731f, 0.00251295f, 0.13176087f, -0.05122041f, -0.12995368f, -0.21519753f, 0.04560690f, 
    0.08540012f, 0.08434321f, -0.03522289f, 0.05183704f, -0.11263331f, -0.12305005f, 0.02313519f, 0.03507343f, 
    -0.09054153f, 0.08282134f, 0.06961797f, 0.09404647f, -0.11802014f, -0.05532363f, 0.01500084f, -0.08811036f, 
    -0.01614631f, 0.07469061f, -0.13603167f, -0.08941308f, -0.08262224f, 0.00712470f, -0.03996359f, 0.08606665f, 
    0.07517792f, 0.03756055f, -0.12002450f, -0.00456550f, -0.00674407f, 0.00398539f, -0.11131934f, -0.01257072f, 
    -0.05815733f, 0.07052789f, 0.09652396f, 0.04982047f, 0.07571271f, 0.07367315f, -0.07050303f, 0.01974490f, 
    -0.04455115f, -0.01504866f, -0.07488348f, 0.02320073f, 0.11065483f, -0.04802802f, 0.12350205f, -0.07306978f, 
    0.02009079f, 0.04006549f, -0.10957731f, 0.06644178f, -0.08512156f, -0.08840679f, -0.07081892f, -0.12893900f, 
    0.08243731f, -0.07193072f, -0.12141328f, -0.13901794f, 0.00738418f, -0.09370475f, 0.03593300f, -0.02709652f, 
    0.03080010f, -0.10632168f, 0.12598339f, -0.04320185f, 0.14588681f, 0.06830832f, -0.10903487f, -0.02751711f, 
    0.11162911f, -0.01062356f, -0.06522302f, -0.11549395f, 0.13271402f, 0.05260031f, 0.25213927f, 0.02633780f, 
    0.04417729f, 0.13284656f, 0.16664395f, 0.27073652f, -0.13562986f, 0.10233671f, 0.13493842f, -0.11585583f, 
    0.02591132f, 0.06271347f, -0.11639431f, 0.07054870f, -0.06815988f, 0.09056198f, 0.12926695f, 0.09923626f, 
    0.38364139f, -0.21839692f, -0.02425157f, 0.02036627f, 0.21022636f, 0.12121102f, -0.30426857f, -0.11726893f, 
    -0.17169321f, 0.00951211f, -0.11269011f, -0.05488614f, 0.11975431f, -0.10355576f, -0.03368781f, -0.04029429f, 
    -0.02378000f, -0.17258371f, -0.29160857f, 0.00924390f, -0.08327205f, -0.06864446f, 0.11007341f, -0.07330852f, 
    -0.08703729f, -0.04000522f, 0.07231460f, 0.15014762f, -0.03799336f, 0.03847107f, 0.27145812f, -0.03769637f, 
    0.05130155f, -0.02112191f, -0.22735797f, 0.03121834f, -0.01345398f, 0.09849475f, -0.11118297f, -0.08220784f, 
    -0.08174174f, 0.00773637f, -0.01415615f, -0.11303278f, 0.28508970f, 0.04859961f, 0.16453023f, -0.08305515f, 
    0.15752709f, 0.27313218f, 0.14122550f, -0.27081311f, -0.15145151f, 0.08652722f, 0.20424125f, 0.07022697f, 
    -0.18051791f, -0.01253770f, 0.09266239f, 0.04997046f, 0.04554123f, 0.01279783f, 0.03186063f, 0.08994822f, 
    -0.32478338f, -0.15286320f, 0.10019937f, 0.13816278f, -0.17466582f, 0.06186095f, 0.17564780f, 0.00259249f, 
    0.10034132f, 0.12161282f, -0.14346723f, 0.07307397f, -0.01778511f, 0.23777910f, -0.09722828f, 0.12106393f, 
    -0.01992196f, 0.07515090f, 0.16899054f, 0.11659288f, -0.01411990f, -0.10511402f, 0.06367697f, -0.11812965f, 
    -0.08575231f, 0.00298718f, 0.00720475f, 0.01078076f, -0.10213318f, 0.11606530f, -0.19468401f, 0.02549484f, 
    -0.09056859f, 0.05089855f, 0.10762430f, 0.02214206f, -0.07978051f, -0.03723849f, 0.02165347f, -0.00997285f, 
    0.08865566f, -0.10969203f, 0.00679197f, -0.02732314f, -0.08021662f, 0.00986376f, -0.08950419f, -0.01295556f, 
    0.03378439f, 0.11198656f, -0.00641820f, 0.05309704f, -0.09249116f, -0.01764692f, 0.03620653f, 0.00298416f, 
    0.01909726f, -0.09496393f, 0.00879669f, -0.03172059f, 0.05903301f, 0.00557517f, -0.03859815f, 0.11365952f, 
    -0.13346516f, -0.06636682f, 0.10499047f, 0.12035533f, 0.09506802f, 0.11894526f, -0.06632451f, 0.06896618f, 
    -0.00944103f, 0.07668669f, -0.09740666f, -0.09182581f, -0.08892588f, 0.06490073f, 0.05967070f, -0.09934568f, 
    -0.06243746f, 0.08617014f, -0.12115926f, -0.01310124f, -0.00545983f, 0.01806955f, -0.03174154f, -0.12045175f, 
    0.12093608f, 0.11164558f, -0.10298233f, -0.03177227f, 0.06893010f, 0.11521333f, -0.05357080f, -0.07384191f, 
    0.04442492f, 0.06784449f, 0.19825016f, 0.00462452f, 0.15866654f, -0.02243518f, -0.08932012f, 0.04665286f, 
    -0.12242423f, 0.02648313f, -0.19699420f, -0.05879292f, 0.05360261f, 0.02822763f, -0.03301031f, 0.04003149f, 
    -0.32235530f, -0.15204652f, -0.08437756f, 0.29242513f, 0.27561507f, 0.07082006f, -0.28821695f, 0.27508292f, 
    0.03297226f, 0.15489794f, 0.06401107f, 0.03998782f, 0.09785600f, -0.12025745f, 0.04354519f, 0.07431852f, 
    0.11889742f, -0.12200153f, 0.09202860f, 0.13005698f, -0.03801677f, -0.02709002f, -0.34237513f, 0.02029691f, 
    -0.12667716f, 0.10393791f, 0.11926319f, 0.05627489f, 0.03637431f, 0.09406647f, -0.00596104f, -0.04332132f, 
    -0.11899373f, 0.19006428f, 0.00026444f, 0.02925650f, 0.06794922f, -0.01870139f, 0.03519003f, -0.04956907f, 
    0.04154174f, -0.06875324f, -0.10624970f, 0.19633076f, -0.04194692f, 0.02338144f, 0.24767821f, -0.00004443f, 
    0.04755414f, -0.00097318f, -0.03089360f, -0.03827129f, 0.39541638f, -0.02836688f, -0.09605211f, 0.51154166f, 
    0.04600976f, -0.12332624f, 0.02518448f, 0.07431509f, 0.13989568f, -0.00418642f, 0.34864166f, 0.11977956f, 
    0.21609369f, 0.17994344f, -0.02972456f, -0.21580453f, 0.38628846f, 0.07600459f, 0.08015706f, 0.04940878f, 
    -0.12761936f, 0.02587450f, 0.04898335f, -0.00120331f, 0.05721740f, -0.31085864f, -0.15159582f, 0.03984803f, 
    0.10758644f, -0.18011171f, 0.01203139f, -0.28522101f, 0.06599181f, -0.08919106f, 0.00229945f, 0.03551376f, 
    0.22775307f, -0.11496955f, -0.15858488f, 0.14344646f, 0.09791157f, -0.30316070f, 0.01307490f, -0.02554308f, 
    -0.06442596f, -0.15362164f, -0.22677049f, -0.01200176f, -0.04177186f, 0.08562105f, 0.05991777f, 0.09437813f, 
    0.05660824f, -0.05222845f, 0.00794308f, 0.04814163f, -0.08987936f, 0.07599369f, 0.08154505f, -0.02534235f, 
    -0.12450096f, -0.06887775f, 0.12268139f, -0.02262102f, 0.19868550f, 0.00238918f, -0.00313601f, -0.00569930f, 
    0.04278911f, 0.07060508f, 0.30643085f, -0.02077165f, -0.15127392f, 0.12212472f, -0.06731739f, 0.10223979f, 
    -0.02863460f, 0.20073824f, -0.22830625f, 0.05207707f, -0.24241264f, 0.04459773f, -0.10587601f, -0.09491335f, 
    -0.09529851f, 0.14869472f, 0.03136580f, 0.02381283f, 0.05630749f, -0.04246958f, -0.09453502f, 0.10461752f, 
    0.12057597f, 0.14492963f, -0.03111956f, 0.25909388f, -0.10144581f, -0.06233320f, 0.05600611f, 0.04186080f, 
    0.24878182f, 0.06822740f, 0.01195640f, -0.12301954f, -0.02911135f, -0.11864871f, 0.02583742f, -0.01067090f, 
    -0.00797066f, 0.28505203f, 0.23130088f, 0.08163813f, -0.03203640f, 0.05133960f, 0.19586694f, 0.01267875f, 
    0.04921734f, 0.04559289f, -0.02869399f, 0.17571595f, 0.03191730f, 0.02676289f, -0.26185912f, 0.02063341f, 
    -0.05575463f, -0.02308704f, -0.12329827f, -0.10659838f, -0.08954361f, -0.06590652f, -0.01507442f, -0.09620224f, 
    -0.07187937f, -0.06933218f, 0.11586431f, -0.11356698f, 0.11063454f, -0.09083131f, -0.02952741f, 0.11266465f, 
    -0.06069425f, 0.03974707f, 0.00915554f, -0.06637023f, -0.08515222f, -0.04478768f, 0.01233579f, -0.08151527f, 
    0.08906721f, -0.10007437f, 0.06558208f, 0.07708307f, -0.06697732f, -0.07732584f, -0.07528327f, 0.07117705f, 
    0.01628844f, -0.01726750f, 0.02051152f, -0.04532751f, 0.05746479f, 0.05286276f, 0.02677968f, 0.09255385f, 
    0.06271616f, -0.02623099f, -0.11854762f, -0.03883988f, 0.03716330f, 0.08997782f, 0.02539933f, 0.11892033f, 
    0.08871374f, 0.03392416f, -0.04617734f, -0.07992683f, -0.11245024f, -0.00180207f, -0.05699207f, 0.08611242f, 
    0.09973733f, 0.01428911f, 0.08285314f, -0.02488385f, 0.05886981f, -0.10423763f, 0.04587568f, 0.05316319f, 
    -0.00276289f, -0.01115858f, 0.06939760f, -0.12075547f, 0.29079202f, 0.00466926f, -0.09818989f, -0.19985349f, 
    0.02704548f, 0.12235602f, -0.12561242f, -0.02518131f, 0.03390131f, -0.11859681f, 0.07743718f, -0.05935724f, 
    -0.16010642f, 0.11048690f, 0.08500144f, -0.08785917f, -0.05057574f, -0.03021203f, 0.24098654f, -0.17006710f, 
    -0.14288838f, 0.05702357f, 0.08481808f, -0.05243690f, -0.01639087f, 0.03428283f, -0.21493496f, 0.08185264f, 
    -0.36176568f, 0.13450047f, -0.05812806f, 0.13127528f, -0.09436095f, 0.07970975f, 0.19022408f, -0.02133560f, 
    -0.02580781f, 0.08759262f, 0.02976483f, 0.16101684f, -0.02334409f, -0.01719280f, -0.02288966f, -0.11992803f, 
    -0.00285543f, 0.21089031f, 0.26551533f, 0.16917114f, -0.04157761f, 0.08808978f, -0.00233315f, -0.08676580f, 
    -0.00437576f, 0.02457452f, -0.05900193f, 0.08690993f, -0.10931972f, 0.04619792f, -0.18438129f, 0.05441963f, 
    -0.00702909f, -0.02529084f, -0.08453780f, -0.04589809f, -0.33110139f, 0.09670505f, 0.04239637f, 0.10458249f, 
    -0.04922302f, 0.04267104f, 0.27529672f, 0.11351772f, 0.01593112f, -0.12078252f, -0.23295726f, -0.06355167f, 
    -0.11629257f, 0.00355573f, 0.17740794f, -0.15893294f, 0.31078297f, -0.08197372f, -0.21672498f, 0.05986512f, 
    0.18109882f, -0.13133334f, -0.05562983f, 0.07209183f, 0.06478502f, 0.02600918f, 0.13711585f, -0.11987442f, 
    -0.02653528f, -0.08614856f, 0.12224905f, 0.19120456f, -0.06779861f, 0.07570220f, 0.27855518f, -0.12141252f, 
    0.30117145f, 0.07735745f, 0.18501543f, 0.22008318f, 0.09929301f, 0.01903658f, -0.00605182f, 0.05920608f, 
    0.11746885f, 0.12377314f, 0.20297901f, -0.04317157f, 0.08747849f, -0.07140875f, -0.03806926f, 0.09455540f, 
    0.03392276f, 0.05663223f, -0.06852237f, 0.04147011f, 0.02650328f, 0.02364013f, 0.00155621f, 0.09751736f, 
    -0.04310947f, 0.10418391f, 0.27144343f, -0.06517851f, 0.38024589f, -0.08415664f, -0.01259111f, -0.19073734f, 
    0.03558759f, 0.03798113f, -0.36793274f, 0.08867139f, 0.29368648f, 0.16434334f, 0.15042558f, 0.03408705f, 
    0.16775852f, 0.17427900f, 0.16561539f, -0.15259521f, 0.07605217f, 0.12152131f, 0.05181441f, 0.05773371f, 
    0.01992664f, -0.04055224f, 0.08461244f, 0.09595725f, 0.09951201f, -0.19287263f, 0.05439438f, -0.09504127f, 
    -0.04238180f, 0.25135916f, 0.06264508f, 0.14185254f, -0.03066953f, -0.04284077f, -0.15081982f, 0.01203270f, 
    -0.10853888f, -0.04862102f, -0.03989670f, -0.13611922f, 0.05721632f, -0.26087871f, 0.05876056f, -0.01056510f, 
    -0.01658830f, -0.11966906f, -0.15254775f, 0.10272377f, 0.11400487f, 0.04682960f, 0.19846527f, 0.11621273f, 
    0.07503417f, 0.10442021f, -0.13254009f, -0.05913636f, -0.10073836f, 0.03851150f, -0.00769324f, 0.01533828f, 
    -0.02581074f, 0.05933160f, 0.07005057f, 0.00206160f, -0.31525353f, 0.05640991f, -0.05584792f, -0.02421974f, 
    0.02215946f, 0.10369164f, 0.03436448f, -0.06898458f, -0.04046102f, -0.13833705f, -0.12132431f, 0.07133501f, 
    0.13154580f, -0.01219091f, 0.25989980f, -0.33932450f, 0.19960426f, 0.09234918f, -0.00449486f, 0.07135997f, 
    0.15389717f, -0.19942452f, -0.00251224f, 0.11131651f, 0.01254646f, 0.20758331f, 0.09763850f, 0.03466590f, 
    -0.31943676f, 0.08883058f, 0.07100737f, 0.18031006f, 0.32114294f, -0.03608666f, -0.10357582f, 0.02476340f, 
    0.03374730f, 0.01504490f, 0.11646092f, 0.04203044f, 0.07965073f, 0.11862019f, 0.07556955f, -0.12365788f, 
    -0.00772031f, -0.26704243f, -0.03223263f, 0.17582414f, -0.11343343f, 0.05550823f, 0.18305273f, 0.04269999f, 
    0.02735549f, -0.02191657f, -0.05738034f, -0.16352379f, -0.08704412f, -0.12800422f, 0.09002092f, 0.04292900f, 
    -0.05280018f, -0.10189344f, 0.11659978f, -0.02138411f, 0.12464465f, 0.08820120f, 0.10340643f, 0.36516821f, 
    -0.05064059f, -0.01842380f, 0.28054121f, 0.02454887f, -0.14871387f, -0.17132294f, 0.10701699f, 0.07761928f, 
    -0.00148145f, -0.03437553f, -0.04609988f, 0.08193612f, -0.16661204f, -0.00939866f, 0.30041239f, -0.09785839f, 
    -0.20448971f, 0.24843366f, -0.02162454f, 0.06427576f, -0.04223631f, 0.13500206f, -0.23625962f, 0.03188783f, 
    -0.10150266f, 0.26746863f, -0.04939954f, -0.03548567f, 0.04406646f, 0.01705159f, 0.08487282f, 0.09252150f, 
    0.18328014f, -0.09274796f, -0.06862815f, 0.06002017f, -0.07641593f, 0.00672117f, 0.01807459f, 0.06537957f, 
    -0.02423445f, 0.22675490f, 0.16466650f, 0.14657877f, 0.01776914f, -0.05634092f, 0.15571184f, -0.11535376f, 
    0.01737699f, 0.09850314f, -0.10504557f, 0.38667244f, 0.03007224f, -0.08953932f, -0.15152654f, 0.04291674f, 
    0.00649223f, 0.03836008f, 0.23241405f, 0.10298645f, 0.06185593f, -0.08818092f, -0.05055740f, 0.09002302f, 
    0.04391370f, -0.02938194f, -0.40649268f, 0.06118504f, 0.09728943f, 0.16508067f, 0.02894324f, -0.09315791f, 
    -0.17805040f, -0.15070093f, -0.09734140f, 0.15739419f, 0.21705513f, -0.07727290f, -0.20659018f, 0.29059267f, 
    0.17148176f, 0.01172731f, -0.11627843f, -0.07653023f, -0.10509817f, -0.22327784f, 0.16711336f, -0.06381721f, 
    -0.02031828f, 0.21574807f, -0.04472308f, 0.14784284f, 0.02833824f, -0.00319367f, -0.24365108f, -0.10996633f, 
    -0.14946610f, -0.04962286f, 0.24224392f, 0.03431410f, 0.10912673f, -0.05457399f, -0.02604208f, 0.11548716f, 
    -0.06424816f, -0.03561542f, 0.14786054f, 0.00486318f, 0.03668020f, 0.05419899f, -0.00016169f, 0.04880113f, 
    -0.02793841f, 0.05781867f, 0.00167503f, -0.07957190f, 0.06932364f, -0.06191367f, 0.16410460f, -0.11094428f, 
    -0.01277415f, 0.06794213f, 0.02772371f, 0.03356165f, 0.09548219f, -0.02091670f, 0.09866259f, 0.00977975f, 
    0.08249559f, -0.10655506f, -0.07122727f, 0.00776576f, 0.00107457f, -0.06713575f, -0.05403818f, 0.10655060f, 
    0.09383543f, 0.08195005f, -0.01792635f, 0.05070333f, -0.11928254f, 0.03164238f, -0.06097166f, -0.03898248f, 
    -0.06446616f, 0.11438566f, 0.01145527f, -0.12491179f, -0.01310091f, -0.03710020f, -0.12035744f, -0.09999181f, 
    0.00572464f, -0.03486833f, 0.07266222f, -0.02535474f, 0.08102760f, -0.02226551f, -0.04361920f, -0.00421558f, 
    0.07819413f, 0.10065508f, -0.11501430f, -0.09399749f, 0.03389275f, -0.12175675f, -0.01026861f, -0.11401837f, 
    -0.09898181f, 0.03265868f, -0.10109238f, -0.09509689f, 0.05860841f, 0.01464105f, -0.05253810f, 0.07340686f, 
    -0.03711177f, 0.01525402f, -0.04395229f, -0.05869129f, -0.12157895f, -0.08519816f, -0.06846571f, 0.07739048f, 
    0.11815833f, 0.05948321f, -0.07796109f, 0.10313945f, -0.28629223f, -0.02942090f, 0.13285072f, 0.05823229f, 
    0.04087814f, 0.03277427f, -0.32715657f, -0.07783363f, 0.24464269f, -0.00450912f, 0.23079209f, -0.04826506f, 
    -0.02124470f, 0.05381534f, 0.15707895f, 0.10068219f, -0.09269632f, -0.04911667f, -0.12879308f, 0.15353197f, 
    0.16355029f, 0.10123323f, -0.04018960f, -0.09544276f, -0.00315584f, 0.15024337f, 0.37435064f, 0.05258903f, 
    -0.01280538f, -0.12878563f, -0.01933463f, 0.15791608f, 0.25058255f, -0.09178081f, -0.15024313f, -0.11147372f, 
    -0.32468149f, 0.02210166f, 0.05164424f, -0.11446953f, 0.00089081f, 0.24847198f, -0.06766093f, 0.11519924f, 
    0.06207038f, 0.02327092f, -0.25570345f, 0.08565400f, -0.07801045f, -0.07209222f, 0.09848405f, -0.02029165f, 
    -0.05315923f, -0.12789837f, 0.06786118f, -0.18034947f, -0.08345043f, 0.05427407f, 0.18188603f, -0.07509634f, 
    -0.04248271f, 0.05182409f, -0.28566042f, -0.02323098f, 0.00389736f, 0.07418242f, 0.02594047f, 0.24240762f, 
    -0.03766258f, 0.05648668f, 0.26012215f, -0.06000077f, 0.20961440f, 0.04033958f, 0.01801526f, -0.03195779f, 
    0.00319776f, 0.37128732f, 0.01786184f, -0.04982842f, -0.23074950f, -0.00902934f, 0.03092102f, 0.01102665f, 
    0.01978415f, 0.15985799f, 0.04195501f, 0.01366604f, -0.00329278f, 0.03117045f, 0.20581576f, -0.03245524f, 
    -0.10152091f, -0.29863256f, -0.06109759f, 0.19120751f, -0.00471622f, 0.05261518f, 0.31071073f, -0.02395150f, 
    -0.08642048f, 0.00108744f, -0.06108701f, -0.15360621f, -0.00126230f, 0.02817502f, -0.06883492f, -0.06083908f, 
    -0.03639038f, -0.01893318f, 0.09987836f, 0.03923156f, -0.05074289f, -0.08822949f, 0.15501887f, 0.09029648f, 
    0.09307663f, -0.03894342f, -0.11232842f, -0.16839094f, -0.00432647f, -0.12322950f, 0.04438261f, -0.04083613f, 
    -0.09750347f, 0.11711502f, -0.12040737f, -0.11294152f, -0.08925220f, 0.11907224f, 0.04999699f, -0.00401566f, 
    -0.07900585f, -0.12057658f, -0.09363116f, 0.01164235f, -0.02489226f, -0.03134703f, 0.03272078f, -0.00092754f, 
    -0.07334801f, -0.02042251f, -0.14515528f, -0.00433452f, -0.05626069f, 0.01694408f, 0.06963047f, 0.03337139f, 
    -0.13008992f, -0.13626100f, -0.04124904f, -0.06010281f, -0.07880065f, 0.03378849f, -0.00663422f, -0.06638014f, 
    0.04492270f, -0.12478952f, 0.07717328f, -0.10657454f, 0.01010407f, -0.01332548f, -0.06497429f, -0.02482919f, 
    -0.12841628f, 0.05761266f, -0.11013471f, -0.13848303f, -0.00877289f, -0.01219851f, 0.12497382f, -0.03677525f, 
    -0.00057764f, -0.11062032f, 0.06179847f, 0.01381892f, -0.09306537f, 0.03316259f, -0.10379821f, -0.04329689f, 
    0.07051969f, -0.10712035f, -0.06468950f, -0.04395716f, -0.02631903f, 0.01657631f, 0.09919045f, -0.05637892f, 
    -0.05868249f, -0.12516029f, -0.01673406f, 0.04438395f, -0.21052636f, -0.05249450f, -0.10921510f, 0.12901281f, 
    -0.08198423f, -0.07575131f, -0.00179406f, 0.08045522f, 0.02208843f, -0.17847525f, 0.19751586f, -0.06223757f, 
    -0.05704705f, 0.19175079f, 0.23064478f, -0.15852632f, 0.36209416f, -0.02310161f, 0.25473318f, 0.03205848f, 
    -0.19495845f, 0.13569324f, 0.09749924f, -0.00077709f, 0.02259676f, -0.10462947f, 0.01871348f, 0.05566067f, 
    -0.21700460f, -0.17786464f, -0.11543728f, -0.09186608f, 0.47424015f, -0.10492885f, 0.06370816f, 0.06426436f, 
    0.24398553f, -0.03801420f, 0.18666753f, -0.14117037f, -0.02143916f, 0.30499530f, -0.10425514f, -0.00867557f, 
    0.05066801f, -0.14156878f, -0.19457352f, 0.16748555f, -0.01170728f, 0.03516767f, 0.11012349f, 0.09224509f, 
    -0.09316119f, 0.10767213f, -0.01882550f, 0.13143478f, 0.06771800f, -0.03051068f, 0.14459927f, -0.00595407f, 
    0.07706460f, 0.01794663f, -0.06881375f, 0.09137479f, 0.00577126f, 0.03186252f, 0.12742777f, -0.03932858f, 
    0.04755678f, -0.07129908f, -0.05122868f, 0.07575822f, -0.01498514f, 0.00962112f, 0.10392000f, 0.06324041f, 
    -0.08896048f, -0.05183463f, -0.12806508f, -0.03797241f, -0.11406684f, -0.07598517f, 0.01636008f, -0.06790044f, 
    -0.02553993f, -0.14850256f, 0.02518494f, -0.02359014f, -0.10611679f, -0.11477751f, -0.03725922f, 0.04889215f, 
    0.11085720f, -0.06563749f, 0.00764708f, -0.03910703f, -0.02506217f, 0.07776190f, -0.10541401f, 0.07095040f, 
    0.09114604f, 0.09500004f, -0.04787805f, -0.02294266f, 0.03478453f, 0.09116852f, -0.07512663f, 0.06282324f, 
    0.09544662f, 0.06169851f, 0.09097581f, 0.02130343f, 0.11585979f, -0.09028819f, -0.05916371f, 0.00046444f, 
    0.06349416f, 0.04559100f, -0.07020608f, 0.09451599f, 0.07334259f, 0.11335681f, 0.01154873f, 0.00970446f, 
    -0.03747390f, -0.06824753f, 0.03368329f, -0.05397055f, 0.39109358f, 0.08452006f, -0.12134285f, -0.07813303f, 
    0.00466020f, -0.09177005f, -0.03574267f, -0.10845728f, 0.18129906f, 0.17687614f, 0.17620189f, 0.09766418f, 
    0.20557387f, 0.22914673f, 0.11229073f, -0.13713646f, 0.18347217f, -0.01601258f, 0.09342731f, 0.11540310f, 
    0.12418867f, -0.22975314f, -0.00947738f, 0.02634620f, 0.10377377f, 0.06384234f, -0.17613830f, 0.10371808f, 
    0.02636605f, -0.15392712f, 0.12254199f, -0.16223180f, -0.27714655f, 0.01003158f, -0.03762257f, 0.05650723f, 
    0.11491819f, -0.08549297f, -0.10762015f, 0.09956046f, -0.07292400f, -0.31775966f, 0.07212220f, -0.06783152f, 
    -0.09516576f, -0.14703514f, -0.12772992f, 0.05736498f, -0.10727791f, 0.04183993f, 0.19222753f, -0.07486899f, 
    0.06094252f, -0.10053006f, 0.09488921f, -0.27289015f, 0.09239309f, 0.07330073f, -0.06832400f, -0.02282453f, 
    -0.04860196f, 0.07142957f, -0.28381935f, 0.10460787f, 0.09091103f, -0.07990026f, -0.05592142f, 0.04878723f, 
    -0.07695190f, 0.05595483f, -0.19359888f, -0.01304876f, 0.19962837f, 0.17496869f, -0.06644586f, 0.04188789f, 
    -0.40255809f, 0.13558853f, -0.05219682f, 0.08454812f, -0.13961647f, 0.07572949f, 0.05494109f, 0.09646667f, 
    0.03750654f, 0.18600903f, 0.11842167f, -0.02610736f, -0.05508000f, 0.27277899f, 0.16658959f, -0.10150348f, 
    -0.13171530f, -0.29396981f, 0.00838074f, -0.01470303f, 0.08554836f, -0.00500544f, 0.04841692f, 0.02579088f, 
    -0.06317781f, -0.10218532f, -0.03846710f, 0.19635470f, 0.05885788f, 0.35003272f, 0.01630114f, 0.00629750f, 
    -0.01239283f, 0.26529074f, 0.24833721f, 0.19652960f, -0.11741408f, -0.03161692f, -0.11073632f, -0.07508015f, 
    0.02262964f, -0.03146933f, 0.01357491f, -0.17697205f, 0.01749386f, 0.09408040f, 0.33395234f, -0.10501725f, 
    0.09910220f, 0.11269619f, -0.19826990f, 0.09895275f, 0.00499041f, 0.11807057f, 0.10437531f, 0.15069561f, 
    0.12682435f, -0.11752143f, -0.07146239f, 0.13097879f, 0.19103646f, 0.05275384f, 0.15675519f, -0.05908029f, 
    -0.16464750f, 0.07070944f, 0.13528308f, 0.14453913f, 0.12246111f, -0.03184218f, 0.12716231f, 0.13051313f, 
    -0.04138590f, 0.07922437f, -0.07287406f, -0.05301949f, 0.02454731f, 0.18353140f, 0.08676433f, -0.05336878f, 
    0.15921518f, -0.41921884f, -0.03405510f, -0.17808016f, 0.15101799f, -0.08845483f, -0.04773663f, 0.08957012f, 
    -0.18704703f, -0.04561714f, 0.01805444f, 0.48826230f, 0.07479637f, 0.03807629f, 0.01409252f, 0.08129917f, 
    -0.00678718f, 0.13054162f, -0.08308748f, -0.02871796f, 0.11326557f, 0.11401542f, -0.12855777f, -0.07006702f, 
    -0.02120030f, 0.07133373f, 0.07272304f, 0.02880448f, 0.09298438f, 0.00143617f, 0.34789392f, -0.07669395f, 
    -0.08020207f, 0.06870898f, 0.08888366f, -0.10182802f, 0.42498600f, -0.08995924f, 0.04110376f, 0.43525577f, 
    0.01195766f, -0.06942062f, -0.04112212f, 0.10412671f, 0.12500465f, -0.13952205f, 0.09611044f, 0.00936872f, 
    -0.00729395f, 0.21444899f, -0.12030286f, -0.29711145f, 0.24419905f, -0.09782426f, 0.08653158f, -0.16132095f, 
    -0.17444503f, 0.25867358f, -0.03903649f, 0.09085426f, 0.09795958f, -0.30496991f, 0.16492569f, -0.07511573f, 
    -0.15108934f, -0.00628109f, -0.11130387f, -0.10352770f, -0.05146953f, 0.02223281f, 0.18967913f, 0.11267252f, 
    0.17719188f, 0.07896822f, -0.07880733f, 0.03959145f, -0.06050245f, 0.03336596f, -0.12181735f, -0.11308775f, 
    -0.02589614f, 0.11309579f, -0.11784267f, 0.14360656f, 0.02997855f, 0.02009673f, 0.19527417f, 0.01054616f, 
    0.05554569f, -0.07290166f, -0.06634686f, 0.29488567f, 0.09459345f, -0.04955327f, -0.15176351f, -0.07767353f, 
    -0.00523517f, 0.03286538f, -0.07509063f, 0.10753430f, -0.28605342f, -0.01043476f, 0.01288940f, 0.28822955f, 
    0.11016792f, -0.04476643f, -0.10830563f, -0.07384950f, 0.02270189f, -0.09729354f, 0.17416358f, 0.03799024f, 
    0.48175976f, -0.21497215f, 0.05173677f, -0.05396789f, 0.25532541f, -0.08372240f, 0.24514529f, 0.09066214f, 
    0.04119341f, -0.16084802f, -0.08272630f, -0.01339649f, 0.08464259f, -0.15012319f, 0.30098575f, 0.11446205f, 
    0.15703584f, 0.19793199f, -0.11189120f, 0.11837374f, 0.37337437f, 0.06476745f, 0.10312437f, -0.09106074f, 
    -0.14353937f, 0.05907689f, 0.12941210f, -0.03686011f, 0.11435552f, 0.16435510f, 0.02024215f, -0.07797915f, 
    -0.11501301f, -0.20240624f, -0.11426482f, -0.01584752f, 0.05903794f, -0.06960519f, -0.08934805f, -0.10897136f, 
    0.09979045f, -0.03299363f, 0.12171461f, -0.10142409f, -0.11731622f, -0.09365240f, 0.17908937f, 0.02630654f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.11386344f, 0.07887258f, 0.03650167f, 0.09442044f, 0.10676963f, -0.07300014f, 0.11549856f, -0.02608474f, 
    0.02271318f, 0.06770280f, 0.11771343f, 0.02089190f, 0.15194935f, -0.00794633f, 0.17444900f, 0.11099242f, 
    0.09830917f, 0.09841687f, 0.08159362f, -0.10064682f, 0.03520913f, 0.16008805f, -0.02575527f, -0.04944320f, 
    0.16317418f, 0.10388818f, 0.15004517f, -0.00258803f, -0.06133159f, 0.09296094f, 0.03839521f, 0.00279535f, 
    -0.01191938f, -0.03587940f, -0.03314323f, 0.05524777f, -0.00684864f, 0.07154163f, 0.10325649f, -0.13534221f, 
    0.03642441f, 0.05018727f, -0.00329325f, 0.13353835f, -0.08085638f, -0.02690470f, -0.10908639f, 0.02634284f, 
    0.18314514f, -0.01632343f, 0.16167046f, -0.04464051f, -0.02637428f, 0.04524095f, 0.14207265f, 0.00620381f, 
    0.02576725f, -0.08345866f, -0.04024399f, -0.03447524f, -0.01017390f, -0.10976177f, 0.08254720f, -0.10596429f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.15720426f, 0.06314246f, -0.02756544f, -0.02526387f, -0.13721600f, 0.02620470f, 0.11092442f, 0.08991787f, 
    0.08480138f, -0.29039547f, -0.29685435f, -0.11303797f, -0.28664908f, -0.10101609f, -0.56409192f, 0.10448177f, 
    -0.12206978f, -0.12725280f, -0.23269707f, 0.02492922f, -0.36472902f, -0.10900778f, 0.21571085f, -0.10491204f, 
    0.05613014f, -0.06089181f, -0.65429211f, -0.11671428f, 0.00608377f, 0.10777240f, 0.19101925f, 0.11796147f, 
    -0.06302663f, 0.15821894f, -0.30673221f, 0.30607519f, -0.21294565f, -0.05622599f, -0.10668053f, -0.08584481f, 
    0.22156264f, -0.32932401f, 0.00012294f, 0.19163364f, 0.64568627f, -0.16351697f, 0.04050003f, -0.19270615f, 
    -0.24299887f, 0.21392442f, -0.22911088f, -0.17080240f, 0.16685809f, 0.07649714f, -0.08449250f, -0.16343191f, 
    0.11835007f, 0.08920564f, -0.09305395f, 0.28503838f, -0.23900451f, 0.18070221f, 0.30571273f, 0.02070895f, 
    -0.05558171f, 0.17047277f, -0.21530239f, -0.28129017f, 0.17369421f, -0.10531014f, -0.01286725f, 0.06573765f, 
    0.04043828f, -0.26606694f, -0.26141369f, -0.33976674f, 0.08380571f, -0.07647199f, -0.24671717f, 0.07876191f, 
    0.00882970f, 0.36475828f, 0.19283827f, -0.06851052f, -0.23841798f, 0.16468178f, 0.08945453f, -0.03424240f, 
    -0.04397772f, 0.02371774f, 0.04436516f, 0.03401046f, -0.09157809f, -0.24665278f, 0.19283591f, 0.17148839f, 
    -0.18986711f, 0.02680941f, -0.00383814f, 0.05055338f, 0.12290660f, 0.11524921f, 0.09217118f, 0.02731992f, 
    0.08076333f, -0.04683475f, -0.02660750f, -0.01163674f, -0.54153103f, -0.35024554f, 0.10424648f, 0.22518057f, 
    -0.05815861f, 0.12875292f, 0.25261685f, -0.23873177f, 0.13814904f, -0.11743250f, 0.26928180f, -0.15984829f, 
    -0.01590008f, 0.02156522f, 0.02680896f, -0.14606103f, -0.07844045f, -0.09408493f, -0.43353409f, 0.30785093f, 
    -0.33018002f, -0.58612925f, -0.07832237f, 0.09478052f, 0.09193350f, -0.11893185f, -0.38360453f, 0.02332595f, 
    0.19633627f, -0.12545311f, 0.14466080f, -0.22400911f, -0.12695757f, -0.12275939f, -0.04798771f, -0.03467532f, 
    -0.30887011f, 0.17367472f, 0.20280305f, -0.02651233f, -0.01122073f, -0.44031864f, -0.02185081f, 0.06719898f, 
    -0.31251329f, -0.05346216f, 0.16791071f, -0.12879483f, -0.03228779f, 0.06451848f, -0.53659004f, 0.21753524f, 
    -0.52956069f, 0.13194783f, 0.32916757f, -0.31750497f, -0.31386089f, -0.54843897f, -0.00165066f, -0.03261777f, 
    -0.31341890f, -0.21127389f, -0.00612659f, 0.02579748f, 0.27611428f, 0.00795153f, -0.06840454f, -0.15175104f, 
    0.07969712f, -0.14133136f, 0.03414627f, 0.10778978f, 0.16408662f, -0.06106958f, -0.05008249f, 0.08310784f, 
    0.00502924f, 0.21658348f, 0.10123170f, -0.45805642f, -0.04438798f, -0.18471929f, 0.32533243f, 0.32849777f, 
    0.15912548f, -0.20285797f, 0.05523203f, -0.15854929f, 0.13006318f, -0.01563483f, 0.19452198f, -0.08436769f, 
    -0.48619714f, 0.03867706f, -0.18704233f, 0.23421234f, 0.26838830f, 0.04139473f, -0.03436521f, -0.52576011f, 
    -0.34289438f, -0.52365321f, -0.04406399f, -0.02563557f, 0.02536818f, 0.31066701f, -0.32466695f, -0.38096082f, 
    0.17427474f, 0.08961762f, 0.01516933f, -0.03385183f, -0.02813671f, -0.14730658f, -0.43288052f, 0.13479380f, 
    -0.14245352f, 0.27796599f, 0.18924399f, 0.12337181f, 0.14461158f, -0.27323651f, 0.14664429f, -0.06600197f, 
    0.28477430f, -0.25804067f, 0.00804167f, -0.09233185f, 0.15680145f, 0.07290978f, 0.01923501f, -0.05914787f, 
    -0.52185720f, -0.08338341f, -0.19251259f, 0.16107494f, -0.23924273f, -0.06266543f, -0.25483084f, -0.12456570f, 
    0.00398644f, 0.03092829f, -0.01455676f, 0.09458520f, 0.05091127f, 0.05831263f, -0.03408312f, -0.16568652f, 
    0.18036956f, -0.02806950f, -0.23972124f, 0.01151458f, -0.34611884f, 0.03023556f, 0.00749069f, 0.12287118f, 
    0.05492837f, 0.09170878f, 0.16462873f, 0.06311588f, 0.05265582f, 0.00598023f, -0.09868967f, -0.46465760f, 
    0.09003020f, 0.13825774f, -0.41340923f, 0.04463264f, -0.05915144f, 0.17688185f, 0.08811905f, -0.42976815f, 
    -0.07732756f, -0.09783406f, 0.16691525f, 0.08754037f, 0.04309776f, 0.17062318f, -0.19781618f, 0.04655048f, 
    -0.60242182f, -0.15591285f, -0.38591120f, -0.15454727f, -0.01880747f, 0.01438860f, 0.15186322f, -0.05470841f, 
    0.13787991f, 0.22357781f, -0.03668338f, 0.08158310f, -0.07268617f, -0.06082100f, 0.08834186f, -0.12841518f, 
    -0.07513925f, -0.12897767f, -0.08942591f, -0.07711832f, -0.10480338f, -0.12299758f, 0.29251614f, 0.27611694f, 
    -0.01501047f, 0.16224973f, 0.01577074f, -0.13881403f, 0.23640443f, 0.24692531f, 0.13937065f, -0.07470150f, 
    0.19824380f, 0.12924747f, 0.16291778f, 0.04967869f, -0.07911751f, -0.05080640f, 0.19181269f, -0.03886504f, 
    0.02301381f, 0.08146646f, 0.03939600f, -0.21288455f, -0.21254267f, -0.10878155f, 0.00341646f, 0.26351246f, 
    0.21804743f, -0.11640061f, -0.11364011f, -0.09863493f, 0.09796832f, -0.09421950f, 0.00614309f, -0.06764734f, 
    0.33495882f, -0.11770789f, -0.19194490f, 0.05258717f, -0.03158486f, -0.00718524f, 0.06391750f, 0.04435946f, 
    0.01375610f, -0.34196672f, 0.08845305f, -0.04859787f, -0.41581836f, 0.25696242f, 0.07705222f, -0.13134132f, 
    0.02717819f, -0.20672072f, -0.12615447f, 0.18161251f, -0.24069916f, 0.02277813f, 0.04823852f, -0.21268354f, 
    -0.04523825f, 0.05067139f, -0.27092966f, -0.47354296f, 0.20805001f, -0.11609857f, 0.03012243f, 0.12893452f, 
    -0.08288964f, -0.56838804f, 0.11057738f, 0.14453602f, 0.24686848f, 0.06596138f, -0.39366448f, -0.27555496f, 
    -0.11656427f, -0.65111399f, -0.44136345f, 0.13907312f, 0.17595422f, -0.02477346f, 0.10074147f, 0.00664127f, 
    0.11954234f, -0.16352548f, 0.16559699f, 0.30099341f, 0.03543957f, -0.08266348f, 0.15227425f, 0.19825843f, 
    0.09323303f, -0.42887953f, -0.04159252f, -0.03785690f, -0.00374751f, 0.05430587f, 0.02060583f, 0.29855356f, 
    0.04819659f, -0.08189365f, 0.03202016f, -0.02603471f, -0.05230970f, 0.16953635f, -0.32100278f, -0.25255069f, 
    -0.22363564f, 0.23361450f, -0.20179245f, -0.21773821f, 0.11189927f, 0.19073580f, 0.25188479f, -0.05827707f, 
    0.10455575f, -0.27300629f, -0.10405724f, -0.01643935f, -0.16130096f, 0.12250211f, -0.00504157f, -0.54909182f, 
    0.07363731f, -0.14647184f, -0.38671583f, 0.03154249f, -0.06396087f, 0.06509079f, -0.16013557f, -0.01591901f, 
    -0.03136197f, -0.33802328f, 0.03230350f, -0.12287985f, -0.48997965f, -0.22430748f, -0.02115054f, -0.00116793f, 
    -0.32394782f, 0.28668919f, 0.16775268f, -0.23392344f, -0.25176811f, 0.04112162f, -0.47805870f, -0.04735330f, 
    -0.39769930f, 0.15081824f, 0.06177690f, 0.09527450f, 0.09066451f, -0.04606753f, 0.15703234f, 0.13568071f, 
    0.15790597f, -0.18333358f, -0.05719844f, 0.02609944f, 0.15394926f, 0.09716284f, -0.47538626f, -0.03204092f, 
    0.08383042f, -0.12268542f, 0.11221585f, -0.05238124f, -0.06938846f, -0.36761907f, -0.08551921f, 0.13768224f, 
    0.05643841f, 0.03571789f, -0.07146332f, -0.17015781f, 0.21882994f, -0.05235112f, -0.16073984f, -0.05073690f, 
    -0.28691292f, 0.30381152f, -0.03483922f, -0.37137452f, -0.19425328f, -0.00444208f, 0.11897838f, 0.22642782f, 
    -0.12422807f, -0.35117820f, -0.18190511f, 0.12341020f, -0.35202363f, -0.09127080f, -0.36530426f, 0.03022898f, 
    -0.05569000f, 0.01956563f, -0.08038627f, -0.22110279f, 0.17675100f, -0.01286298f, 0.14512981f, 0.13177361f, 
    -0.00346984f, 0.05874610f, 0.06159758f, -0.36171809f, 0.14593205f, 0.01267800f, -0.07414307f, 0.01589027f, 
    0.23436636f, -0.24685921f, -0.15252115f, 0.21399324f, -0.33813739f, 0.03749331f, 0.30789909f, 0.26347727f, 
    0.06066622f, -0.08163191f, 0.23606446f, -0.09558547f, -0.30829462f, -0.00401582f, 0.19355892f, 0.15003525f, 
    -0.30318847f, -0.02919237f, 0.10458770f, 0.07765849f, -0.08785534f, -0.27798745f, -0.00352398f, -0.33789161f, 
    -0.13773507f, -0.41015610f, 0.28089917f, 0.23368482f, -0.24222630f, -0.26666892f, 0.04686540f, 0.05775077f, 
    -0.04371173f, 0.35514522f, -0.12879966f, -0.40242016f, 0.18756989f, -0.37453216f, -0.01570061f, -0.02410253f, 
    0.24445646f, -0.27157795f, 0.13071430f, -0.06365526f, -0.23441938f, 0.06556784f, -0.16556241f, 0.10519881f, 
    0.02009125f, -0.02399365f, 0.00723748f, 0.27078727f, 0.06498764f, 0.31344554f, -0.06893630f, 0.11822554f, 
    -0.15221040f, -0.25402561f, -0.10914729f, 0.13083641f, 0.06527746f, -0.00789091f, -0.03924009f, 0.05517989f, 
    0.11110023f, -0.26889271f, 0.24826171f, -0.29960147f, -0.13190128f, -0.05362549f, 0.05555725f, -0.31908560f, 
    0.27063578f, 0.08139718f, -0.21782912f, -0.11117885f, 0.22842629f, -0.54124922f, -0.04703548f, -0.20604174f, 
    -0.22898813f, -0.03704634f, -0.28036916f, -0.02411512f, -0.05442868f, 0.17509183f, 0.17329437f, 0.11010844f, 
    0.20145611f, 0.15650126f, -0.26620293f, 0.13462524f, 0.05397575f, -0.15349770f, -0.14127266f, 0.00375873f, 
    -0.04309523f, 0.39876732f, 0.11695465f, -0.31526273f, 0.05434898f, 0.16178593f, -0.02157395f, 0.26425874f, 
    -0.04731099f, 0.22804239f, 0.19637217f, 0.00308781f, -0.17475331f, 0.10435238f, -0.14974292f, 0.20238434f, 
    0.04926016f, -0.05136184f, 0.02288672f, 0.25290254f, -0.24084085f, -0.61957955f, 0.25443912f, -0.28787035f, 
    -0.00213812f, -0.21412076f, 0.24406964f, -0.15822664f, -0.13477349f, -0.11067649f, 0.18816014f, 0.08214547f, 
    -0.18183759f, 0.00294767f, -0.22325762f, 0.09174006f, 0.02973463f, 0.04466691f, 0.17573537f, -0.15579672f, 
    -0.41926745f, 0.31386331f, 0.12193518f, -0.07530946f, 0.12811345f, 0.19446208f, -0.16306590f, -0.02203145f, 
    0.27714175f, 0.06782152f, 0.20963241f, -0.04778670f, -0.12532359f, 0.00980219f, -0.22822283f, -0.58485603f, 
    0.69435239f, -0.02815330f, 0.21480100f, -0.08968985f, -0.24612844f, 0.08420297f, -0.35215354f, 0.06050339f, 
    -0.25697902f, -0.38586289f, -0.09165276f, 0.22641441f, -0.28930914f, 0.01725283f, -0.11090146f, 0.05142868f, 
    0.34930724f, -0.60823447f, 0.20435253f, -0.02483879f, -0.01743347f, -0.11047815f, -0.27599809f, -0.24698848f, 
    0.06112467f, 0.24197005f, 0.11672097f, -0.25066599f, -0.00397781f, -0.14108232f, -0.16168536f, -0.35042748f, 
    0.05669827f, 0.43417689f, 0.18740900f, -0.05401903f, 0.04665370f, 0.09028187f, -0.15903564f, 0.08566124f, 
    0.11702856f, 0.01333653f, -0.39153707f, 0.22524767f, 0.00837887f, -0.05888060f, -0.17822447f, 0.09591745f, 
    -0.32494128f, -0.22083974f, -0.20401694f, -0.10437572f, 0.00487775f, -0.37506196f, 0.16750386f, 0.26709810f, 
    -0.10797913f, 0.10297206f, 0.15754575f, 0.02050968f, -0.08552549f, 0.00530405f, -0.43620133f, -0.08857926f, 
    -0.01659218f, 0.11834089f, -0.12742031f, -0.26573768f, 0.08181310f, -0.20580876f, 0.20314705f, 0.01998888f, 
    -0.05566022f, -0.04750780f, 0.10736915f, 0.29111373f, -0.20320231f, 0.07839752f, -0.00438005f, 0.28718939f, 
    -0.14900345f, 0.10148574f, -0.28937128f, 0.13551891f, 0.14184697f, 0.03633976f, -0.23246829f, -0.51816809f, 
    0.10807905f, -0.32851410f, 0.03595592f, -0.13876623f, 0.00850205f, -0.04898741f, 0.15347995f, -0.47374538f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14550111f, 0.00346628f, 0.09566918f, -0.01033863f, -0.12154227f, 0.02481930f, -0.02721459f, -0.20786659f, 
    0.02798429f, -0.07803153f, -0.03541147f, 0.05047208f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
