#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.70965761f, 0.56409252f, 0.30709568f, 0.24358605f, 0.03780947f, 0.06322744f, 0.17816330f, -0.05008793f, 
    0.25519019f, 0.71377015f, -0.36565292f, -0.07133426f, 0.04130379f, 0.76182002f, -0.85075742f, -0.17596838f, 
    -0.38350517f, -0.10398435f, -0.31287420f, -0.30456373f, -0.30492520f, -0.35990712f, -0.54589617f, -0.56953126f, 
    -0.17029022f, 0.66027308f, 0.28600338f, -0.64482212f, 0.17699993f, -0.07048513f, -0.17601743f, 0.67112470f, 
    -0.87102568f, -0.01668528f, 0.11078373f, -0.13602702f, -0.20725150f, -0.04724831f, -0.12989016f, 0.38575462f, 
    0.20705338f, -0.65576482f, 0.12524028f, 0.12576693f, -0.47475618f, -0.35287267f, 1.17427099f, -0.80080992f, 
    0.03002669f, 0.18402581f, 0.12287457f, -0.30571952f, 0.43428874f, 0.00814899f, -0.16271128f, -0.63991892f, 
    -0.62572175f, 0.43886554f, 0.66689610f, 0.46094704f, -0.05537431f, -0.25095445f, -0.33300218f, -0.27911538f, 
    -0.28696674f, -0.98499739f, -0.08530841f, 0.15339862f, 0.36630061f, 0.31519565f, 0.26039031f, 0.25174132f, 
    0.34267014f, 0.77969205f, 0.43310145f, -0.31954587f, -0.22650976f, -0.63418812f, -0.25784388f, 0.04871170f, 
    -0.27226952f, -0.75605136f, -0.28548554f, -0.39634410f, -0.20753539f, -0.26649311f, -0.28347766f, -0.01253597f, 
    -0.35383582f, -0.10119303f, 0.66055042f, -0.12091026f, 0.21193157f, 0.22704901f, 0.12541074f, 0.50262451f, 
    -0.13568059f, -0.16837940f, -0.30101711f, -0.34364322f, -0.39341363f, 0.13331103f, -0.14461127f, -0.54897618f, 
    -0.59453613f, -0.10795856f, -0.20796579f, -0.42542222f, 0.48943201f, 0.37434518f, 0.35382068f, 0.12491411f, 
    0.61651254f, 0.10275234f, 0.01717875f, 0.16327573f, -0.10886578f, 0.35317653f, -0.48424020f, 0.34926882f, 
    -0.51880109f, -0.13182709f, -0.19139548f, -0.07049889f, 0.10388873f, 0.70347744f, 0.01439959f, 0.45057106f, 
    0.45578641f, -0.34744981f, -0.35585856f, -0.53656024f, 0.37103653f, 0.16785139f, 0.42275086f, -0.16681573f, 
    0.29515982f, 0.10567681f, 0.33086354f, 0.41576669f, 0.30106655f, -0.19726089f, -0.25284213f, 0.88892549f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.39739978f, -0.04430535f, 0.06108382f, 0.22494382f, 0.50604182f, 0.27965271f, -0.10132366f, 0.47979897f, 
    0.31678593f, 0.22178176f, 0.44934878f, -0.06726265f, 0.15039259f, 0.06057880f, 0.22842893f, 0.14257790f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00665583f, 0.09716403f, 0.23642863f, 0.14707960f, 0.01320587f, 0.11924386f, -0.10624838f, -0.00429425f, 
    0.13907318f, -0.48708990f, -0.36847356f, -0.24986081f, -0.06924331f, -0.00493680f, 0.04959990f, 0.05626800f, 
    -0.16165364f, -0.09405492f, -0.36596444f, -0.22538744f, -0.28695562f, 0.09851102f, 0.00744174f, -0.18038978f, 
    0.12301258f, -0.03900689f, 0.09519799f, 0.05789918f, -0.18203725f, 0.08259963f, -0.02189938f, 0.10620875f, 
    -0.11671619f, 0.05860580f, 0.00775373f, 0.10293345f, 0.14128187f, 0.16836703f, 0.15783174f, 0.16130421f, 
    0.13256641f, 0.19391716f, -0.05144625f, 0.05801210f, 0.11679932f, 0.22107381f, -0.03121419f, -0.04804829f, 
    0.13956101f, -0.05363037f, -0.08580922f, 0.04679499f, 0.03816045f, 0.04274048f, -0.19404198f, -0.03475795f, 
    0.17129236f, 0.00854825f, 0.07434829f, -0.11375286f, 0.05324004f, -0.17444572f, -0.06688182f, -0.07948232f, 
    0.28635669f, 0.33859736f, 0.02729199f, 0.07451653f, 0.06930047f, 0.04638324f, 0.09018071f, 0.03936338f, 
    -0.17224863f, -0.40161404f, 0.17373990f, 0.18886654f, 0.09911783f, -0.04236953f, -0.03117283f, -0.08101361f, 
    0.08222933f, -0.33284825f, 0.03537214f, 0.18601809f, 0.13967501f, -0.09205184f, -0.08098768f, 0.02998517f, 
    -0.01965999f, 0.03930941f, -0.05992180f, -0.15448995f, -0.05683349f, -0.11286581f, 0.00593530f, 0.05783517f, 
    0.18345425f, -0.16023037f, -0.05419227f, -0.11600002f, -0.23380886f, -0.19337401f, -0.03381775f, -0.06685547f, 
    0.00935716f, 0.24411787f, -0.06985644f, -0.11075098f, -0.16151629f, -0.19400541f, 0.06416536f, 0.00516086f, 
    -0.00354569f, -0.10905430f, -0.01221362f, 0.10107885f, 0.06125744f, 0.20606448f, -0.15626653f, -0.43673080f, 
    0.04714848f, 0.20892487f, 0.00312440f, 0.04943981f, 0.09670580f, 0.07451727f, 0.13565831f, -0.17620187f, 
    -0.10868139f, 0.05907336f, 0.00341699f, 0.20443335f, 0.07471798f, 0.17684656f, 0.09075263f, -0.05330954f, 
    -0.00884970f, 0.13055821f, 0.03073660f, -0.08628710f, 0.22579591f, 0.20483659f, -0.03076620f, 0.19033816f, 
    0.01534346f, 0.03326597f, -0.00381951f, -0.06994738f, 0.02215426f, -0.01972430f, -0.06219730f, 0.02830296f, 
    0.01177653f, 0.01049561f, 0.05748753f, -0.07933560f, 0.04323026f, -0.01300982f, -0.06685079f, 0.03464029f, 
    -0.03024033f, 0.05300478f, 0.06273708f, 0.00823893f, -0.06010975f, -0.00245369f, 0.06290711f, -0.07086509f, 
    0.04603542f, -0.07140735f, 0.07176625f, -0.08777667f, -0.02644196f, -0.01205963f, 0.05171061f, -0.04407505f, 
    -0.01862741f, 0.07282694f, -0.06096915f, -0.05025798f, -0.06673300f, -0.02938561f, -0.08887064f, -0.04178466f, 
    0.02947482f, 0.04353297f, -0.06756238f, 0.07193998f, -0.03901318f, 0.05241619f, 0.01354839f, -0.00650531f, 
    0.00255740f, 0.04663553f, 0.04092905f, 0.02293929f, -0.07545557f, -0.04946840f, 0.01048365f, -0.04761575f, 
    -0.02517326f, 0.04597886f, 0.00391794f, 0.00644329f, -0.02623901f, 0.03741806f, -0.08209437f, 0.02081164f, 
    -0.02400634f, 0.01694042f, -0.04634067f, 0.00720841f, 0.05623995f, -0.07519428f, 0.06898643f, -0.03947895f, 
    -0.08191361f, -0.04983452f, 0.00734017f, 0.02774887f, -0.03464356f, -0.04839631f, -0.05939614f, -0.02203662f, 
    0.05208272f, 0.00460400f, -0.04345303f, 0.00537374f, -0.06754298f, -0.02698856f, 0.04146334f, 0.04214469f, 
    -0.06572833f, -0.08121289f, -0.08246666f, -0.06470081f, 0.02624138f, 0.05071415f, -0.03629138f, 0.06444831f, 
    -0.02337577f, -0.01478902f, -0.00180564f, -0.03733904f, -0.05560033f, -0.07332890f, 0.04283131f, -0.03923454f, 
    0.06353021f, -0.05594882f, -0.08261129f, 0.00628248f, -0.04501460f, 0.01196324f, -0.04550818f, 0.02328841f, 
    0.05573122f, 0.05680772f, -0.01348779f, -0.08023285f, 0.02737456f, -0.06021536f, 0.01783884f, 0.03624863f, 
    0.01362383f, -0.00396457f, -0.01366677f, -0.05487709f, 0.02268684f, -0.03504470f, -0.02677567f, 0.03303129f, 
    -0.07724346f, -0.07263695f, -0.07158870f, -0.08722413f, 0.01441026f, -0.01001691f, -0.06766244f, 0.01869245f, 
    -0.09781234f, 0.02445332f, -0.02486799f, -0.00561421f, 0.03704754f, 0.05944300f, -0.06007586f, -0.03344382f, 
    -0.02283022f, 0.04839372f, 0.04160913f, -0.04888546f, 0.06537796f, 0.06287175f, -0.03649846f, -0.07126302f, 
    -0.04999051f, -0.07875599f, -0.08192876f, -0.01168646f, -0.08707802f, 0.04359716f, -0.03060409f, -0.04991871f, 
    -0.01842034f, 0.04353052f, 0.07445800f, -0.03182817f, -0.00856280f, -0.05412360f, -0.07212350f, -0.08005331f, 
    -0.03509008f, 0.00103704f, -0.05565607f, -0.02150850f, 0.03119610f, 0.06170620f, -0.02652825f, -0.06040201f, 
    -0.03958917f, 0.00487440f, -0.07239155f, 0.04985128f, -0.09149734f, 0.05326721f, -0.01704269f, 0.02845759f, 
    -0.08824847f, 0.06754936f, 0.04687494f, -0.00691621f, 0.02148351f, -0.02966161f, 0.06877945f, -0.08495415f, 
    -0.02924231f, 0.07123994f, -0.07135615f, 0.00351263f, -0.05553584f, 0.00616043f, -0.02122044f, 0.00296250f, 
    0.00582755f, 0.04338482f, 0.05042785f, 0.00330027f, -0.07066921f, -0.03910843f, -0.03103271f, -0.04057048f, 
    0.02651598f, -0.05457054f, -0.02246686f, -0.00567529f, -0.06885035f, -0.05887610f, 0.00460884f, 0.01200258f, 
    0.05249155f, -0.08487528f, -0.03297504f, -0.06679329f, -0.02127900f, -0.08008001f, -0.02618268f, -0.05686362f, 
    0.03983315f, 0.03959785f, -0.07683443f, -0.05378851f, -0.03425570f, 0.04240118f, 0.02148823f, 0.01847902f, 
    -0.04680078f, -0.03681812f, -0.03324890f, -0.01846184f, 0.03972740f, -0.07273648f, -0.02173248f, 0.07068820f, 
    -0.04446989f, -0.05852549f, -0.00710725f, -0.04079190f, -0.01351086f, -0.08256214f, -0.01646372f, 0.07251086f, 
    -0.08846790f, -0.07486411f, 0.00737746f, 0.01283530f, -0.02842696f, -0.03254402f, 0.02023061f, -0.01702883f, 
    0.06327548f, -0.06663953f, -0.07902138f, 0.03382715f, 0.04403824f, 0.01869978f, 0.00662087f, -0.07998539f, 
    0.03884602f, 0.00476013f, 0.01160255f, -0.02367755f, 0.02623457f, 0.01749865f, -0.06733014f, -0.08557476f, 
    -0.06460326f, -0.00965499f, -0.05797679f, -0.07784571f, -0.03742902f, -0.01230666f, 0.07039714f, -0.02178001f, 
    0.06390695f, 0.03899800f, 0.02403339f, -0.08634986f, 0.05189404f, 0.07274275f, 0.04230957f, -0.01397131f, 
    -0.25910166f, -0.38400054f, 0.08022496f, -0.02417761f, 0.03399781f, -0.10636608f, 0.07979535f, -0.01184417f, 
    0.10856472f, -0.06413818f, 0.04167926f, -0.35830945f, 0.06939967f, -0.06641206f, -0.05854648f, -0.00809928f, 
    -0.12448402f, -0.03227644f, 0.21420465f, 0.34153527f, 0.42651558f, -0.02881992f, -0.00223701f, 0.02720188f, 
    0.19431138f, 0.06353027f, 0.07114466f, -0.23036467f, -0.02064622f, 0.26333871f, -0.04521129f, 0.06540399f, 
    -0.06541128f, 0.07935890f, 0.19676182f, -0.00708414f, 0.00454918f, -0.13094968f, 0.15956558f, -0.04635338f, 
    0.02008002f, -0.02677696f, 0.08052483f, 0.04743680f, -0.14312364f, -0.18721096f, 0.11576411f, -0.44954941f, 
    -0.09817965f, 0.18575110f, 0.10163943f, -0.14500712f, 0.19290310f, 0.13308385f, -0.08929016f, 0.25066468f, 
    0.14149682f, -0.12521416f, -0.09147137f, -0.07387388f, -0.12411141f, -0.16355087f, 0.06421652f, 0.05176797f, 
    0.29607934f, 0.08137387f, -0.26767755f, -0.12996620f, -0.01668426f, 0.03188904f, 0.11755369f, 0.19992281f, 
    0.08452564f, -0.58268738f, 0.11960899f, 0.04139786f, 0.08511080f, 0.00012267f, 0.11411548f, 0.03155700f, 
    -0.13726360f, 0.00191678f, 0.07272276f, 0.16098274f, 0.01867290f, 0.02479048f, -0.00612151f, 0.05710867f, 
    -0.09173506f, 0.02346228f, -0.27573994f, -0.07075044f, -0.17722221f, 0.05170562f, -0.00527589f, -0.15344876f, 
    -0.05830210f, -0.18575427f, -0.14270337f, 0.01324640f, 0.08143216f, 0.19283842f, 0.01931190f, 0.14932412f, 
    -0.02796166f, 0.11643340f, 0.01121872f, 0.00663123f, -0.44706187f, -0.11529588f, -0.22895356f, 0.04040269f, 
    -0.00709327f, -0.15539812f, 0.28992635f, -0.02220038f, -0.14232463f, -0.27829078f, 0.28686562f, -0.13797784f, 
    0.10094359f, 0.01852699f, -0.00779119f, 0.16796049f, 0.05473444f, 0.08205581f, 0.22948113f, -0.21775854f, 
    0.07465954f, 0.06602391f, 0.15129288f, -0.03195713f, -0.05092469f, 0.08544647f, 0.16298784f, 0.07024588f, 
    -0.08729476f, 0.17299572f, 0.00255519f, 0.02861809f, -0.11865737f, 0.22910057f, 0.10960381f, 0.07816418f, 
    -0.14742334f, -0.34081751f, 0.23658913f, 0.23583438f, 0.12912823f, -0.04298008f, 0.05667077f, -0.05032090f, 
    0.04153942f, 0.23117165f, -0.40382928f, -0.04269108f, -0.00438355f, -0.27949667f, -0.02308369f, -0.10294673f, 
    0.09464477f, 0.02534668f, 0.11271570f, 0.28819251f, 0.33862618f, -0.07249231f, 0.12242736f, -0.15561353f, 
    0.06553498f, -0.00939047f, 0.06505881f, -0.16217633f, 0.12848106f, 0.28857282f, -0.18405350f, -0.05825807f, 
    0.02101766f, 0.08865645f, -0.07764567f, 0.04586342f, -0.09052937f, 0.09481803f, -0.08870759f, 0.14395376f, 
    -0.03291531f, -0.15529950f, 0.20880109f, -0.00050591f, 0.00042988f, -0.24301139f, -0.55222678f, -0.68202096f, 
    -0.00279913f, 0.01772586f, 0.26321515f, 0.04882358f, 0.01739605f, -0.00562276f, 0.20165317f, -0.58435816f, 
    -0.27301750f, -0.16520430f, -0.07120236f, 0.01436183f, 0.20120330f, -0.05096843f, -0.01053456f, 0.13849948f, 
    -0.10400881f, -0.17798766f, -0.17420445f, 0.15055577f, 0.11269113f, 0.00251031f, 0.14707863f, 0.01837470f, 
    -0.02815975f, -0.29075006f, -0.18398103f, 0.14756751f, 0.02488592f, -0.05242285f, -0.10065982f, -0.03421836f, 
    0.02803130f, 0.15451357f, 0.27730367f, 0.22236614f, -0.12934597f, 0.05198223f, 0.21128145f, 0.09082394f, 
    -0.01617358f, -0.06125554f, 0.60647792f, -0.06503943f, -0.12719980f, -0.31805435f, -0.23623267f, -0.10332626f, 
    0.08655819f, -0.01251774f, -0.17264457f, 0.27643436f, 0.17733900f, -0.08058453f, -0.15752207f, -0.08552343f, 
    -0.07444137f, 0.08751170f, -0.06398465f, -0.05015227f, 0.33174235f, -0.42785126f, -0.39061257f, 0.03460986f, 
    0.02768194f, -0.09293076f, 0.01707199f, 0.10509039f, 0.08376551f, -0.11655709f, 0.10336766f, 0.25334200f, 
    -0.04950309f, 0.03551234f, -0.18924992f, 0.06588302f, -0.01199864f, 0.17840062f, -0.39071646f, -0.05073579f, 
    0.08587274f, -0.05290328f, -0.05524541f, -0.15804741f, -0.00839373f, 0.08216984f, 0.14387204f, 0.05511755f, 
    -0.20139945f, -0.12769011f, 0.06714641f, -0.13114430f, -0.08782662f, -0.03862172f, -0.00187922f, 0.08210088f, 
    -0.03428857f, -0.12550575f, -0.08081422f, 0.04505626f, 0.05275341f, -0.05109779f, 0.08212830f, 0.20382871f, 
    0.13599585f, -0.26563317f, 0.17764896f, 0.16352068f, -0.16242084f, 0.01141488f, -0.03181481f, 0.12565009f, 
    -0.06546418f, -0.25537542f, 0.15977184f, 0.07660709f, 0.04578376f, 0.16182533f, 0.12891807f, 0.06331793f, 
    0.09898083f, -0.22632118f, -0.14055477f, 0.30354297f, -0.15818076f, -0.07863657f, 0.02670737f, -0.01795546f, 
    -0.06200976f, 0.13915855f, 0.03589748f, 0.07402710f, -0.14257464f, -0.13883857f, -0.00273650f, -0.05209368f, 
    0.03842105f, 0.06046034f, 0.06160986f, 0.04527494f, 0.00719996f, 0.33238342f, 0.12971953f, -0.19458906f, 
    -0.29619434f, -0.09105469f, 0.09175471f, 0.12185106f, 0.06920307f, 0.15828025f, 0.27794749f, 0.01058920f, 
    0.03645554f, 0.21264599f, -0.04019094f, 0.10574738f, 0.02737299f, 0.01242524f, 0.03203504f, 0.11335584f, 
    -0.23962730f, 0.20678551f, 0.06849062f, -0.28598711f, -0.09765350f, 0.15183574f, 0.12414555f, 0.18179516f, 
    -0.16012560f, 0.05759320f, 0.32588196f, -0.13164814f, 0.01656333f, 0.10057154f, -0.21103998f, -0.22485903f, 
    -0.22516868f, 0.41502666f, -0.15376762f, 0.00611248f, -0.08966910f, -0.06049757f, -0.09031453f, 0.14342090f, 
    -0.00665117f, 0.00196707f, 0.01095725f, -0.03367291f, -0.12624091f, 0.07464235f, 0.00093802f, -0.03206990f, 
    -0.00372346f, -0.06378235f, -0.04562542f, 0.21187560f, 0.02155613f, -0.12790164f, 0.02753608f, -0.06524867f, 
    -0.16276835f, 0.07870374f, 0.12973151f, -0.26314455f, 0.06390066f, 0.02312628f, 0.11311188f, -0.08333740f, 
    -0.15880588f, -0.13088223f, 0.00093960f, -0.11942098f, -0.07425799f, -0.38730362f, 0.05204107f, -0.23810817f, 
    -0.19834465f, 0.09803799f, 0.05470289f, 0.14889279f, -0.03111167f, -0.09109768f, -0.16514468f, -0.01226369f, 
    0.13868530f, -0.04178363f, 0.05941093f, 0.26721418f, 0.07483858f, -0.00072652f, 0.12259415f, 0.14887306f, 
    -0.16602594f, -0.19597825f, 0.01351093f, 0.00509616f, -0.18489628f, 0.15037991f, 0.27895194f, -0.11536025f, 
    0.17730759f, 0.04164858f, 0.14285441f, 0.05168926f, 0.06297725f, 0.15106724f, 0.01907822f, 0.06938573f, 
    -0.14467929f, -0.05405745f, -0.09229407f, 0.08824029f, 0.24984363f, 0.10105154f, 0.02617485f, 0.05788741f, 
    0.02689095f, 0.08187725f, -0.27123207f, -0.02520580f, -0.22785638f, 0.13132505f, 0.14119326f, -0.12318120f, 
    -0.02211924f, -0.12196153f, -0.41302484f, -0.15357843f, -0.27122995f, -0.17365198f, -0.07831889f, 0.04133827f, 
    0.04987698f, 0.11841389f, 0.14283946f, 0.18716970f, -0.12933290f, -0.03856382f, -0.00591726f, -0.17901440f, 
    0.16681345f, -0.04049261f, 0.02079910f, 0.17363036f, 0.16281891f, 0.01552962f, -0.35468033f, 0.20760699f, 
    0.09745547f, 0.13810878f, -0.04883517f, -0.11725669f, 0.01623092f, -0.04818323f, -0.33974358f, -0.03501836f, 
    0.17228149f, -0.20140737f, 0.22220510f, -0.04383900f, 0.00747015f, -0.12865804f, 0.56212002f, -0.07025790f, 
    0.12330148f, 0.24952085f, -0.02500265f, 0.13364850f, 0.02489029f, -0.07972807f, -0.04895503f, -0.06124685f, 
    0.18017913f, 0.12540156f, -0.10548943f, -0.24298444f, 0.03411216f, -0.00394181f, 0.21412474f, 0.15636532f, 
    0.18004960f, -0.02634795f, -0.08251376f, 0.01196433f, -0.00563709f, -0.11489654f, -0.03013024f, -0.11675017f, 
    0.19123189f, 0.13955210f, -0.15029174f, 0.08857133f, 0.04898366f, -0.00893589f, -0.00518035f, 0.16242582f, 
    0.14171609f, -0.12788463f, -0.02225463f, 0.01008662f, 0.05337522f, -0.07759719f, -0.11453937f, -0.01441892f, 
    0.07894463f, -0.02148450f, 0.06112310f, 0.18487424f, 0.12918067f, 0.08663656f, 0.00360188f, -0.12087697f, 
    0.01679206f, 0.15031263f, 0.04485874f, 0.07358169f, -0.16593222f, 0.03940643f, 0.00498073f, 0.06659084f, 
    -0.12987907f, 0.07047822f, -0.06495528f, 0.10151220f, 0.03155658f, -0.23574270f, 0.29958013f, 0.05845580f, 
    -0.23483077f, 0.12224048f, 0.13350739f, -0.14558992f, -0.07210254f, 0.14464314f, -0.15592949f, -0.19335213f, 
    0.08266678f, 0.19144161f, -0.07873897f, 0.01306082f, 0.04639536f, 0.12195627f, -0.16958359f, -0.07559001f, 
    -0.03686548f, -0.01409236f, -0.02577193f, -0.00021165f, -0.03953724f, -0.08155844f, 0.01654525f, -0.02715763f, 
    0.05440344f, 0.06612185f, -0.00244819f, -0.06033922f, -0.07931267f, -0.05575166f, 0.02286974f, -0.00694800f, 
    0.06648452f, 0.06873426f, 0.05383054f, -0.05157534f, 0.01301262f, 0.02016805f, 0.03427687f, 0.02227674f, 
    0.02362466f, 0.01411600f, 0.00571373f, 0.04295344f, 0.04186751f, -0.07238082f, 0.06788351f, -0.07244639f, 
    -0.00501174f, -0.08617116f, -0.01938377f, -0.05303232f, 0.00314669f, 0.06424780f, -0.07596719f, -0.09067891f, 
    -0.01886563f, -0.08992379f, -0.00050414f, -0.04615773f, -0.03986765f, 0.01062950f, -0.05274945f, -0.08665795f, 
    -0.03741341f, 0.05145235f, -0.06760770f, 0.07081456f, -0.07694197f, 0.02459154f, -0.02857413f, -0.04620788f, 
    -0.03578476f, -0.01528547f, -0.01140278f, 0.00322274f, -0.02041206f, -0.09180370f, -0.06531206f, -0.05734459f, 
    -0.01092978f, -0.01208881f, -0.04772501f, -0.01158293f, -0.08821931f, -0.07785311f, -0.01926271f, -0.05354260f, 
    0.02386587f, 0.05125778f, 0.05685676f, 0.07618798f, -0.04084567f, -0.05939873f, -0.02424518f, 0.07016502f, 
    -0.08302426f, -0.03303308f, -0.07655083f, -0.06142235f, -0.03086174f, 0.03456935f, -0.00444701f, 0.05484717f, 
    0.05296660f, 0.01227020f, -0.04496079f, 0.00272702f, 0.08606970f, 0.00401661f, -0.06613398f, -0.06734238f, 
    0.01058390f, -0.03804589f, -0.05496565f, 0.03316978f, 0.04429031f, -0.00312333f, 0.03613379f, 0.07574848f, 
    0.05890530f, -0.03459479f, 0.07246338f, -0.04276663f, 0.00921012f, -0.02594961f, 0.07807668f, -0.08315223f, 
    -0.04010230f, 0.00045454f, -0.02355056f, -0.00845495f, 0.07457553f, 0.07223243f, -0.06617804f, -0.02910478f, 
    0.02138423f, -0.00948326f, -0.00907849f, 0.01810231f, -0.00124362f, -0.01136580f, 0.07324211f, 0.01716981f, 
    -0.06082959f, 0.02928063f, 0.02098566f, -0.05414059f, 0.01639219f, -0.06838553f, -0.04895873f, -0.04586841f, 
    -0.03186718f, -0.05428673f, 0.03382619f, -0.06549255f, -0.04177197f, 0.01318891f, 0.00781304f, -0.00478895f, 
    -0.48553008f, -0.10909460f, -0.05164837f, -0.05822197f, -0.03914845f, 0.06140470f, 0.05441752f, 0.14057015f, 
    -0.01574018f, 0.24537116f, -0.08303865f, 0.17539990f, 0.05425934f, 0.14591318f, 0.07947105f, 0.00953710f, 
    -0.23976696f, -0.01645067f, 0.12516592f, -0.11604485f, 0.01595267f, -0.02160052f, -0.06634530f, -0.08918439f, 
    0.03473317f, 0.03616579f, 0.16961324f, 0.24549463f, 0.28411308f, 0.16885127f, 0.01597170f, -0.01415981f, 
    0.03831846f, -0.19148128f, 0.20623548f, 0.04031304f, 0.19786833f, 0.44913191f, -0.02412674f, -0.02557140f, 
    0.04024148f, 0.02258478f, -0.05703446f, -0.04393303f, 0.04429696f, -0.08618459f, 0.04885665f, 0.30749997f, 
    -0.05438005f, 0.10283460f, 0.11958671f, -0.01447243f, 0.09354550f, -0.01580807f, 0.06051745f, 0.00986183f, 
    -0.20665859f, 0.06970616f, -0.03361778f, -0.15800725f, -0.07121611f, -0.31098634f, -0.27143449f, 0.06380804f, 
    0.19563881f, -0.19212481f, 0.02151950f, 0.03666972f, -0.04554880f, 0.19667600f, 0.02120185f, -0.07716091f, 
    -0.45377740f, 0.03423052f, 0.06320719f, 0.00762053f, -0.06432165f, 0.11008278f, 0.09090932f, 0.10698210f, 
    0.04321211f, 0.03955140f, -0.03727381f, 0.05126825f, -0.13690107f, 0.07240709f, 0.12566087f, -0.05246694f, 
    0.06159009f, -0.23913844f, -0.00706371f, 0.06448258f, 0.06109454f, -0.05321788f, -0.22148529f, -0.09439785f, 
    -0.03806666f, -0.06108106f, -0.10578007f, 0.09673817f, 0.05037508f, -0.14568070f, 0.06879068f, 0.14926618f, 
    0.26885962f, -0.09111257f, -0.07989924f, -0.11527094f, -0.53263777f, -0.09713493f, -0.14152315f, -0.17107005f, 
    0.05450831f, -0.12543114f, -0.18118718f, 0.08413348f, -0.08088784f, 0.13941574f, 0.22438942f, 0.32010576f, 
    -0.04762753f, 0.11861601f, 0.01742736f, 0.14182475f, 0.17242004f, 0.25885844f, -0.32698241f, 0.02827551f, 
    0.06045095f, -0.03720547f, 0.10385696f, 0.10013448f, 0.02545705f, 0.20132107f, 0.28579089f, -0.09396853f, 
    0.16601005f, 0.08578157f, -0.01157490f, 0.04947036f, 0.08432269f, 0.09449049f, 0.02060088f, 0.13373487f, 
    0.15564537f, -0.03748902f, -0.11686058f, -0.08934298f, -0.03280728f, -0.07609253f, -0.10263143f, 0.16909403f, 
    0.01202622f, 0.04154480f, 0.29087752f, 0.46320999f, -0.06763853f, 0.09392249f, -0.44862831f, -0.06144693f, 
    0.09011149f, -0.03424659f, -0.18670382f, -0.03417153f, 0.16310281f, 0.01993255f, -0.03168442f, 0.03599497f, 
    -0.06128542f, -0.05308767f, 0.00964896f, -0.30132535f, 0.07403842f, 0.43966478f, -0.00103094f, -0.12187432f, 
    0.06088719f, -0.00876117f, 0.09676985f, 0.22818264f, -0.23178121f, 0.12135611f, 0.14772619f, 0.18279748f, 
    0.16843878f, 0.01013152f, 0.14825915f, 0.04650096f, 0.22710586f, 0.64750820f, -0.28290939f, 0.03622409f, 
    -0.10457985f, 0.10795876f, 0.32001355f, 0.07524844f, -0.04936666f, 0.05505043f, -0.59065884f, -0.10110556f, 
    -0.11143195f, 0.18226163f, 0.15977466f, -0.07369859f, -0.07973248f, 0.13122115f, 0.14831375f, 0.06407314f, 
    -0.23036948f, 0.36066899f, -0.01640706f, 0.04336895f, -0.00783140f, 0.19407082f, -0.03195417f, 0.07700076f, 
    0.32947335f, -0.37664211f, 0.14678834f, -0.08268683f, -0.15636657f, 0.19832793f, 0.05874139f, -0.05564488f, 
    0.09997088f, -0.22814551f, 0.09002630f, 0.19927292f, -0.07967781f, -0.14727066f, 0.03762409f, -0.14778145f, 
    0.07560100f, 0.08235985f, -0.26758519f, -0.43338329f, -0.02213385f, -0.08825979f, 0.06902404f, 0.13338219f, 
    0.22423308f, 0.00283593f, 0.05558049f, -0.31389624f, 0.07763502f, 0.11249685f, -0.03146750f, -0.12086012f, 
    -0.18318257f, -0.04216659f, 0.16837175f, -0.12645286f, -0.18727401f, -0.29355338f, 0.31802765f, -0.06942162f, 
    -0.04092684f, -0.34296551f, -0.07873105f, 0.17592914f, 0.08699819f, -0.55134010f, -0.27518609f, 0.36710888f, 
    -0.02533881f, -0.19896476f, -0.07938743f, -0.08811809f, -0.09660166f, -0.10873748f, -0.17561129f, -0.17329444f, 
    -0.01407510f, -0.03338335f, 0.01870308f, 0.06039233f, 0.01152082f, 0.02339164f, -0.07849624f, 0.37668046f, 
    -0.11652558f, 0.04296424f, -0.19012146f, -0.19093467f, -0.11873595f, -0.07893044f, -0.00205275f, 0.05612301f, 
    0.08983392f, 0.17545943f, -0.33888710f, -0.02904791f, -0.12171444f, -0.02986312f, -0.11320150f, 0.02901824f, 
    -0.21082121f, 0.15646923f, 0.13791512f, 0.40340012f, 0.00543128f, 0.10529462f, 0.06411728f, 0.00146259f, 
    0.23589748f, 0.00174128f, 0.12255548f, 0.03417466f, 0.02073812f, 0.21893018f, -0.14192581f, 0.05157382f, 
    -0.00476092f, 0.03824686f, -0.19251230f, 0.50803947f, -0.08090284f, -0.08936572f, -0.16094813f, 0.11545266f, 
    -0.00504969f, 0.04545262f, 0.05047087f, 0.09419576f, 0.10978331f, -0.01455130f, 0.10222501f, 0.05219292f, 
    0.03692242f, -0.07064588f, 0.01603225f, -0.05289885f, -0.03811949f, -0.15494695f, 0.12330337f, -0.03921837f, 
    -0.00319916f, -0.11841390f, 0.04705391f, -0.08701539f, 0.00227616f, 0.22788355f, -0.04280946f, -0.44309998f, 
    0.22934751f, -0.02587626f, 0.03123216f, 0.07755480f, 0.02439784f, 0.11625490f, 0.14084932f, 0.02290566f, 
    -0.05609185f, 0.33935603f, -0.01024577f, 0.07582407f, -0.08619604f, -0.05121237f, 0.00309271f, -0.01570982f, 
    0.11353413f, 0.33881080f, 0.23800290f, -0.03013429f, -0.11036965f, 0.08781119f, 0.06079738f, -0.09223466f, 
    0.05715061f, 0.19342239f, -0.13526969f, 0.02095934f, 0.25826222f, 0.03147817f, 0.00754984f, 0.06359065f, 
    -0.10632300f, 0.03235233f, -0.13558979f, -0.07725316f, -0.21322361f, 0.03883913f, -0.17466760f, 0.11699530f, 
    0.13749287f, 0.14660716f, 0.11020294f, 0.30902898f, 0.03923965f, 0.37204197f, 0.14413199f, -0.00857259f, 
    0.01074141f, -0.06632540f, -0.18840444f, -0.02368147f, 0.01634368f, 0.17298019f, -0.13876075f, 0.19984291f, 
    -0.20275775f, 0.05063555f, -0.14161725f, -0.17361750f, 0.12118245f, -0.02955021f, 0.16847691f, 0.15255745f, 
    -0.01315761f, 0.03051744f, -0.14547087f, 0.11163738f, -0.01762236f, -0.08169145f, -0.19740458f, 0.19789341f, 
    -0.12379371f, 0.07832795f, -0.12123989f, -0.22122253f, -0.07914104f, 0.07217353f, -0.23850776f, 0.07903900f, 
    -0.23505665f, -0.39700508f, 0.30888781f, -0.10664362f, 0.11025231f, -0.06100966f, -0.01346322f, -0.22872573f, 
    0.02480489f, -0.10816959f, -0.08068918f, 0.17609769f, 0.04829843f, 0.03321750f, 0.03407369f, -0.01857325f, 
    0.01270411f, 0.12526931f, -0.35620618f, 0.55954093f, 0.05934283f, -0.01508308f, 0.03354358f, 0.02218665f, 
    0.09128364f, 0.02263119f, 0.00480013f, -0.15481405f, -0.03510113f, -0.06267713f, -0.11227305f, -0.07280014f, 
    0.03903438f, -0.08377310f, -0.09889311f, -0.13025728f, -0.26531750f, -0.27622563f, -0.06133996f, -0.08080964f, 
    0.11155279f, 0.10926013f, 0.07067614f, 0.02225420f, -0.23551299f, -0.27286041f, 0.05443712f, -0.22328696f, 
    0.25436017f, 0.07331491f, 0.08416817f, -0.09244300f, 0.08443582f, 0.15033014f, 0.54138744f, 0.03908018f, 
    0.01331632f, -0.02112895f, 0.20986949f, 0.18189184f, 0.15665117f, -0.15715626f, 0.35308462f, -0.22684263f, 
    -0.10633297f, 0.03396368f, -0.19227211f, -0.20794624f, -0.04678866f, 0.06174368f, 0.11356303f, 0.29051575f, 
    -0.12235970f, 0.01158463f, 0.05995358f, -0.05231493f, -0.15124100f, 0.02358818f, 0.08943398f, -0.11200605f, 
    -0.13984992f, 0.19567536f, -0.15691276f, 0.07368714f, 0.14098145f, -0.12858561f, 0.12701137f, 0.07283952f, 
    0.08404683f, 0.20102990f, -0.30021256f, -0.38346517f, 0.09797522f, 0.03080732f, -0.12069222f, 0.03345047f, 
    -0.19321309f, 0.09552438f, 0.09586085f, -0.06923069f, 0.23599586f, -0.10530829f, -0.05222786f, -0.15667969f, 
    0.00357364f, 0.03824981f, 0.13103727f, -0.17419963f, 0.07729456f, 0.00570381f, 0.08373278f, -0.14420946f, 
    0.05110705f, 0.01388893f, -0.10561410f, 0.26168436f, -0.00401125f, -0.12529866f, 0.20755658f, 0.04486986f, 
    0.11707338f, 0.01238796f, -0.00397369f, -0.07928073f, 0.03406223f, -0.40294755f, 0.21231222f, 0.42597720f, 
    -0.11013457f, 0.06627782f, 0.10892129f, -0.05393565f, -0.04512470f, -0.00999231f, -0.13610899f, 0.34347928f, 
    -0.15703632f, 0.06989487f, 0.16378938f, 0.11369765f, 0.01898395f, 0.00942567f, 0.03347354f, -0.10600732f, 
    0.17915782f, 0.18841372f, -0.09983649f, 0.05375887f, -0.19259651f, 0.06907348f, -0.04615857f, 0.00183934f, 
    0.29011568f, 0.01119476f, 0.17587054f, 0.03469937f, 0.01498250f, -0.07392275f, -0.01995753f, -0.12610036f, 
    -0.08469188f, -0.63572961f, -0.05340751f, 0.19488133f, 0.02069621f, 0.07721829f, -0.24788433f, -0.24093612f, 
    0.01105576f, 0.22239383f, -0.24629003f, -0.06006183f, -0.02243817f, 0.05143442f, 0.10512636f, -0.06823969f, 
    0.00608345f, 0.00592403f, 0.09030607f, -0.03412396f, 0.05624344f, 0.09050698f, 0.09729392f, 0.06318867f, 
    -0.11245377f, 0.20361753f, 0.03211878f, 0.02686313f, 0.04019142f, 0.07614886f, -0.01378058f, 0.06950994f, 
    -0.04288879f, 0.10451183f, 0.21450403f, 0.20207216f, 0.22031994f, -0.12758598f, -0.04436843f, 0.03132449f, 
    0.23733912f, -0.09795746f, 0.36811146f, 0.06103261f, -0.14577402f, -0.06072556f, -0.53242624f, -0.15227866f, 
    -0.00460544f, -0.22494531f, -0.23649496f, -0.17744073f, -0.02109506f, -0.10026085f, -0.02970826f, -0.39139545f, 
    0.04399278f, -0.25648981f, 0.00039909f, 0.23588568f, -0.08246122f, 0.03970500f, 0.07565472f, -0.03338963f, 
    0.06321641f, -0.00364577f, -0.16721050f, -0.08307046f, 0.04910628f, -0.07546853f, 0.03251160f, 0.02945822f, 
    0.08631986f, -0.05968698f, -0.38573775f, -0.36108431f, -0.05571656f, 0.04928919f, -0.02153870f, -0.04983832f, 
    -0.13920105f, 0.12386028f, 0.14851694f, 0.33071554f, 0.00918407f, 0.02416081f, -0.03051503f, -0.11910469f, 
    0.05808380f, -0.02510549f, 0.20254807f, -0.25785959f, -0.15586311f, -0.20889089f, -0.31246752f, 0.03387671f, 
    -0.25965363f, 0.10102203f, -0.01035339f, 0.06072599f, 0.21850108f, 0.14264962f, 0.17234138f, -0.09051488f, 
    -0.06749282f, -0.34222311f, 0.01074311f, -0.07620841f, 0.06854194f, 0.03941700f, -0.02124120f, -0.11263429f, 
    0.06339300f, 0.11798146f, 0.17287110f, 0.18390475f, 0.10602984f, 0.08263312f, 0.01692706f, -0.39089662f, 
    0.04367101f, -0.02351777f, 0.04303414f, 0.06722532f, 0.03404274f, -0.01050024f, 0.12627243f, -0.02522647f, 
    -0.03883989f, 0.18129431f, 0.02116564f, -0.20900489f, -0.05045617f, 0.09943022f, -0.24067548f, -0.03686574f, 
    0.46135876f, 0.22365086f, 0.18883538f, 0.02816668f, 0.01969271f, -0.02776050f, 0.07875761f, 0.08073633f, 
    0.13029449f, -0.25818956f, 0.05080717f, -0.40028480f, 0.03577702f, 0.07640000f, -0.11213166f, -0.23035727f, 
    -0.15332779f, -0.13134560f, -0.00481387f, 0.06414150f, -0.09921527f, -0.02033292f, -0.09343603f, -0.13288295f, 
    0.06622992f, -0.02848928f, 0.19168535f, -0.51595056f, -0.04674803f, -0.15761614f, -0.03853741f, 0.05612247f, 
    0.08217964f, -0.06000116f, -0.02376327f, -0.19805029f, -0.28808466f, 0.06171250f, 0.07663789f, 0.18877654f, 
    -0.06987575f, 0.11470997f, 0.13222678f, 0.09933070f, 0.24996601f, 0.10136624f, -0.18835455f, -0.32630855f, 
    0.10033122f, 0.04837137f, 0.01546774f, -0.00762502f, -0.12905158f, -0.06625461f, -0.12780628f, -0.54956979f, 
    -0.44360313f, -0.20191763f, 0.05446766f, 0.00170042f, -0.05366058f, -0.34557116f, -0.03795514f, -0.12323769f, 
    -0.49756369f, -0.11038336f, 0.07791910f, 0.14982717f, 0.07585172f, 0.14240888f, -0.01240140f, -0.06611169f, 
    0.45353395f, -0.02601155f, 0.13462356f, 0.16397075f, -0.11995520f, 0.04304070f, -0.00608635f, 0.09786788f, 
    -0.02783754f, 0.40656391f, -0.32471663f, -0.05857272f, -0.10163555f, -0.17501296f, 0.03534758f, -0.06996932f, 
    -0.03403407f, 0.06873290f, 0.14126253f, 0.02818225f, -0.02784800f, -0.05928985f, -0.03151625f, -0.14902002f, 
    -0.07751916f, -0.02291687f, 0.08869889f, 0.19202781f, 0.11476070f, 0.06378270f, -0.21766603f, -0.12624919f, 
    0.09641615f, 0.24207266f, -0.01370873f, 0.02935475f, 0.12644666f, 0.11913835f, -0.06595511f, -0.15245023f, 
    0.02161163f, -0.09483142f, -0.04699468f, 0.02893046f, -0.01521297f, -0.12376666f, 0.13557479f, 0.18675850f, 
    0.08206491f, -0.09545172f, -0.01655466f, 0.23296033f, 0.05472657f, 0.01448372f, 0.17193212f, 0.09352677f, 
    0.36549535f, -0.01984186f, -0.09120589f, -0.05642378f, 0.15316936f, 0.18015683f, 0.22624797f, 0.08919415f, 
    -0.04966830f, 0.29922396f, -0.05520162f, -0.04441897f, -0.22425795f, 0.03219733f, 0.18827030f, 0.16057871f, 
    -0.04683452f, -0.05342783f, -0.24342950f, 0.09155108f, 0.05264932f, 0.09922564f, 0.04396073f, 0.06914929f, 
    0.03713080f, -0.29826388f, 0.08413874f, 0.01454478f, -0.08896817f, -0.01359740f, -0.12563738f, 0.00414655f, 
    0.30261913f, -0.04351939f, 0.06807769f, 0.16096719f, 0.13433637f, -0.00933021f, -0.02543867f, 0.19640721f, 
    0.14310925f, -0.19276950f, -0.14361371f, 0.23062266f, -0.05225566f, -0.08277628f, -0.08661005f, -0.10106333f, 
    0.19828898f, 0.01756589f, 0.02616795f, -0.17690939f, 0.06164799f, 0.07517474f, -0.02154799f, -0.01297514f, 
    0.01350226f, 0.21518633f, 0.03536132f, 0.10191014f, 0.01596491f, -0.16882491f, 0.06237087f, -0.32323465f, 
    0.01606322f, -0.37648198f, 0.02091638f, 0.02742858f, -0.10277968f, 0.04276250f, 0.37313801f, 0.06810609f, 
    0.33540940f, 0.06001921f, 0.09750164f, -0.00707501f, -0.00011229f, 0.13752984f, 0.01234811f, -0.00187359f, 
    -0.20155814f, 0.00583773f, 0.04262058f, -0.09671223f, 0.23891276f, 0.27253026f, 0.18608382f, -0.08744384f, 
    -0.38649067f, -0.29792348f, 0.02045473f, 0.05903964f, 0.00783195f, -0.00273109f, 0.03925104f, 0.02352964f, 
    0.23774207f, 0.28257057f, 0.14187078f, 0.08645228f, 0.06192990f, 0.15454474f, 0.05458113f, -0.04562318f, 
    0.09235725f, -0.01103442f, 0.11526345f, 0.09431548f, -0.15722498f, 0.17877184f, 0.14473869f, -0.01881428f, 
    0.03636863f, -0.01509365f, 0.12018742f, 0.09900716f, 0.09364455f, -0.02417403f, -0.19111291f, 0.00299023f, 
    0.14117636f, -0.01758613f, -0.09415116f, -0.10186274f, -0.04968018f, -0.15902629f, 0.05300232f, 0.19602196f, 
    -0.04037696f, 0.23545407f, 0.00686251f, -0.06665567f, 0.02137046f, 0.09319872f, -0.04993675f, -0.21589504f, 
    0.26616973f, -0.05204388f, 0.04778365f, -0.27032375f, -0.30705523f, 0.03994209f, 0.13042673f, 0.20152998f, 
    0.05906587f, -0.10036618f, -0.36010981f, -0.07425407f, -0.19069895f, 0.09976399f, 0.04721531f, -0.12109697f, 
    -0.45822644f, -0.28576154f, 0.13534795f, 0.13415961f, 0.01399396f, -0.05276442f, 0.01939242f, 0.01730120f, 
    0.03183914f, -0.05532650f, -0.03343491f, 0.02453377f, 0.04081279f, 0.00258886f, -0.01586677f, -0.07287525f, 
    -0.07884318f, 0.00203856f, -0.08254585f, 0.01987990f, 0.07458783f, -0.08306868f, 0.02418589f, -0.08697507f, 
    0.04142656f, -0.08530727f, -0.08016124f, -0.02477748f, -0.07912454f, 0.06351219f, -0.07447106f, 0.05265279f, 
    -0.04754594f, 0.00788879f, 0.06886162f, -0.05546490f, 0.05987106f, 0.00731882f, -0.07694017f, -0.03947536f, 
    -0.08804332f, -0.08009779f, -0.05239339f, -0.06327602f, 0.03375614f, -0.00259523f, -0.06555050f, -0.08086687f, 
    -0.00529534f, 0.03325796f, -0.03833858f, -0.01133481f, -0.00500099f, 0.03345184f, -0.06192966f, 0.03571185f, 
    0.00436665f, -0.03131278f, 0.01469271f, -0.07154869f, 0.00661516f, 0.05400468f, 0.05675104f, 0.04407565f, 
    -0.03361394f, -0.02351730f, -0.07109572f, 0.04217441f, 0.02715047f, -0.01207376f, -0.02018319f, 0.00886632f, 
    0.03167673f, 0.03152453f, -0.05506626f, -0.01374194f, 0.07096200f, -0.00029690f, 0.05971602f, -0.02256251f, 
    0.04911633f, 0.03732381f, 0.07306401f, 0.02246848f, 0.00015508f, -0.03930695f, -0.06661101f, -0.01930634f, 
    0.05854053f, 0.06388153f, -0.06820843f, -0.00340155f, -0.08350992f, 0.01693712f, 0.01987500f, -0.09002887f, 
    0.06379262f, -0.03332035f, -0.00353450f, -0.06398471f, -0.04561072f, 0.00720665f, -0.01005012f, 0.06338885f, 
    -0.00495507f, -0.08520403f, -0.00248971f, 0.00298233f, -0.06327150f, -0.00628666f, 0.03968004f, -0.05662018f, 
    0.06030542f, 0.06687962f, -0.03829309f, 0.00642593f, -0.06241013f, 0.07132898f, -0.06550541f, -0.04321560f, 
    -0.03392546f, -0.08862038f, 0.01456326f, -0.08716628f, -0.07844612f, 0.07510745f, 0.01860504f, -0.03112988f, 
    -0.04243298f, -0.01170493f, 0.02999137f, -0.01820024f, 0.01855682f, 0.00328355f, -0.06781988f, -0.08364215f, 
    -0.09057727f, -0.00828832f, 0.04340725f, 0.02526917f, -0.02736398f, 0.02459551f, 0.06648129f, -0.03055747f, 
    0.07275365f, 0.00958205f, -0.06940310f, 0.02947169f, -0.04952974f, 0.03367275f, 0.05735372f, -0.08928823f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.30137083f, 0.03409059f, -0.04733228f, 0.05936924f, -0.03776707f, -0.04894718f, 0.12797911f, 0.04128624f, 
    0.01839137f, 0.20371768f, -0.09839258f, -0.07232610f, 0.14310683f, 0.03865818f, 0.03034830f, 0.03602675f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07832516f, 0.23376490f, 0.12721311f, -0.15294118f, -0.32494584f, 0.08602167f, -0.02077838f, -0.12760884f, 
    -0.04631465f, 0.35755691f, 0.28264540f, 0.24610563f, -0.38411751f, -0.42768908f, 0.03825440f, 0.05493335f, 
    0.32225025f, 0.13041383f, 0.22345839f, 0.28299484f, 0.21129107f, -0.12728302f, -0.18932638f, 0.15343173f, 
    0.22116564f, 0.33243600f, -0.37010816f, -0.12421589f, 0.44431248f, -0.36550391f, -0.23990005f, 0.04032201f, 
    -0.10470153f, -0.22861607f, -0.11348152f, -0.18793403f, 0.60929590f, -0.14752579f, -0.13864045f, -0.08040010f, 
    0.55582809f, 0.27275428f, 0.11950348f, -0.30475670f, 0.38204497f, 0.26556003f, 0.10413028f, -0.11706639f, 
    0.14679402f, -0.00757882f, -0.00053066f, -0.21249369f, -0.05495536f, -0.12592685f, -0.00663170f, 0.00802526f, 
    -0.17000771f, -0.13340399f, -0.13260758f, -0.13633719f, -0.13081530f, -0.01373678f, -0.14701745f, -0.16978627f, 
    -0.13289033f, -0.01356362f, -0.19910124f, -0.26874089f, 0.40225825f, 0.07372653f, 0.17920861f, 0.07732107f, 
    0.13968508f, -0.30792168f, 0.14014046f, 0.27346873f, -0.26915997f, 0.03135208f, 0.19573179f, -0.20014817f, 
    0.00213817f, -0.08476916f, -0.16245961f, -0.03525938f, 0.50578654f, 0.37295967f, -0.31911960f, -0.12151965f, 
    -0.08072275f, 0.10069158f, 0.16954362f, 0.38639879f, -0.17559905f, 0.08600266f, -0.22256710f, -0.18904872f, 
    0.05136946f, -0.17842403f, -0.06956038f, -0.00581846f, -0.03961828f, -0.10919375f, -0.16792499f, 0.12039950f, 
    -0.16641681f, 0.02705165f, -0.26354542f, 0.20158623f, -0.24821080f, -0.20893933f, -0.02482359f, -0.13445306f, 
    0.12432987f, -0.00339208f, -0.02528702f, -0.04174886f, -0.32990521f, 0.03145669f, 0.19066310f, -0.05987203f, 
    0.00183536f, 0.38602063f, 0.33215350f, 0.14010735f, -0.01535695f, -0.26053411f, -0.46516716f, 0.20062722f, 
    -0.43129492f, 0.23869665f, 0.08083252f, 0.10617254f, -0.19574836f, 0.20125592f, 0.15148012f, 0.18333338f, 
    -0.16174449f, 0.29890233f, 0.46025133f, 0.02660447f, -0.23000544f, 0.28252846f, 0.08412957f, -0.22354037f, 
    -0.07666524f, -0.17042665f, 0.19248085f, 0.38643014f, -0.03532392f, 0.03323317f, 0.01831434f, -0.13074088f, 
    0.24330455f, -0.14800040f, -0.13966437f, -0.36408389f, 0.27649933f, 0.53092259f, -0.16797268f, -0.13151453f, 
    0.27532220f, 0.08566904f, -0.13755411f, -0.31949890f, -0.07192253f, -0.28771263f, 0.18328658f, 0.16938627f, 
    0.27910486f, 0.20430899f, 0.27321661f, -0.32888216f, -0.22061709f, 0.10173008f, 0.09924220f, -0.03731861f, 
    -0.09204821f, -0.03897730f, -0.22100237f, -0.58931309f, -0.46021467f, -0.17935322f, 0.03915736f, 0.16104877f, 
    -0.53126061f, 0.08405171f, -0.29256874f, 0.35240117f, -0.04842500f, 0.27011147f, -0.27711588f, 0.23544794f, 
    -0.20291880f, 0.20387185f, -0.17719766f, 0.30136731f, 0.24208046f, 0.05863706f, -0.18873645f, -0.23647365f, 
    -0.20805070f, -0.01413384f, 0.27627558f, -0.07843731f, -0.76076597f, 0.21583106f, -0.32765818f, 0.23943993f, 
    -0.07101101f, -0.10802754f, 0.08985592f, 0.35129181f, 0.20590550f, 0.03737830f, -0.21848094f, 0.24179506f, 
    -0.23544322f, 0.35816029f, 0.00961364f, 0.41107780f, -0.22337012f, 0.22228345f, -0.02152190f, -0.05470532f, 
    0.20835802f, -0.21361041f, 0.12030005f, 0.18013106f, -0.13725665f, -0.08835641f, 0.32474488f, 0.10989231f, 
    -0.33891064f, 0.22918695f, 0.40470332f, -0.10437240f, -0.01974474f, -0.33158913f, -0.30569026f, -0.00027052f, 
    0.34471381f, 0.18496290f, -0.12396195f, 0.38970795f, 0.11549018f, -0.21410756f, -0.33352056f, 0.09400392f, 
    0.41222557f, -0.07226206f, -0.28618753f, -0.19631711f, 0.30408105f, 0.00599315f, 0.14017020f, 0.07351301f, 
    -0.23737185f, -0.19849333f, 0.18243116f, -0.09306831f, 0.19609712f, -0.08209359f, 0.24041863f, 0.14269248f, 
    -0.15717340f, -0.08323448f, 0.33538181f, 0.06713574f, -0.23154345f, 0.27348325f, 0.33602205f, -0.13971440f, 
    -0.21185908f, 0.23877707f, 0.19347374f, 0.14734745f, 0.46917310f, 0.34324589f, 0.18789935f, -0.09283617f, 
    -0.30592427f, -0.22806111f, 0.39336148f, 0.00226631f, -0.26198974f, -0.09241827f, 0.23125981f, 0.21918988f, 
    -0.18355322f, -0.19005030f, -0.11210004f, 0.24825959f, 0.31855279f, -0.00517812f, 0.20725344f, -0.11998609f, 
    0.00009087f, -0.29480332f, -0.02926107f, 0.01948446f, 0.39143926f, 0.16802244f, 0.05669484f, 0.12094377f, 
    0.11207358f, -0.14229980f, 0.11973029f, -0.00941639f, -0.19028993f, -0.13495061f, 0.33840531f, -0.16784477f, 
    -0.32441399f, 0.34713817f, 0.35778597f, 0.00557918f, -0.08529878f, -0.57843447f, -0.20257036f, 0.00005937f, 
    0.25601551f, 0.06418943f, 0.15880878f, -0.12464512f, -0.41767365f, 0.07221854f, 0.01213356f, 0.17885968f, 
    0.05386127f, 0.19886068f, 0.19545551f, -0.01128000f, 0.28616902f, -0.04354279f, -0.01269915f, -0.17374566f, 
    -0.21276286f, 0.01076457f, 0.19789228f, 0.17733184f, -0.27098128f, -0.17853646f, -0.11805896f, -0.11631370f, 
    0.04600093f, -0.13173129f, -0.01732683f, -0.19588637f, -0.00048519f, 0.15216945f, 0.17358704f, -0.08408219f, 
    0.21502441f, -0.13017119f, 0.17993575f, 0.21607813f, -0.21101511f, 0.30766430f, 0.20912966f, -0.23820089f, 
    0.06873317f, 0.54366940f, -0.17616060f, -0.24030662f, 0.05964502f, -0.49485976f, -0.22016858f, 0.19517007f, 
    -0.73492265f, -0.10812697f, -0.05893791f, 0.18083838f, 0.31264895f, -0.12994424f, -0.15663028f, -0.14814383f, 
    0.22087598f, -0.21690729f, 0.08884063f, -0.17998549f, -0.22260542f, -0.28086489f, -0.06187075f, -0.13189176f, 
    0.33666340f, -0.08646921f, -0.02761197f, 0.11576835f, -0.41614017f, 0.14462946f, -0.04128140f, -0.16571461f, 
    -0.16390981f, 0.25026789f, 0.19172965f, -0.07454158f, 0.11484365f, -0.30689168f, -0.13397379f, -0.10482173f, 
    0.13520366f, 0.01492437f, 0.20818591f, -0.15158503f, -0.45895040f, 0.12504971f, 0.28365844f, -0.16934572f, 
    0.32731590f, 0.03456568f, -0.14850363f, -0.16412558f, 0.04431150f, -0.24058419f, 0.04155674f, -0.19305867f, 
    0.30653104f, -0.14950234f, -0.14024028f, -0.28672054f, -0.05622068f, 0.06988442f, 0.04287655f, 0.02104023f, 
    0.43503025f, 0.02552607f, -0.04748411f, -0.10354955f, 0.37100390f, -0.37835184f, -0.08546829f, -0.21224625f, 
    -0.39664271f, 0.10233308f, 0.14049995f, 0.22136711f, 0.27647418f, 0.40980187f, -0.28076395f, 0.14456807f, 
    -0.08578113f, 0.34895244f, 0.26782247f, 0.53306341f, -0.00627714f, -0.13397412f, -0.11453322f, 0.15749945f, 
    0.20279874f, -0.04479209f, 0.18926901f, -0.11863399f, -0.21526587f, 0.21385546f, -0.25218084f, -0.13195391f, 
    0.39233798f, 0.44531485f, -0.01817472f, 0.08372267f, 0.18741491f, -0.58291769f, 0.07866237f, 0.00272772f, 
    -0.30315366f, 0.11824198f, 0.12997471f, 0.32509571f, 0.29234084f, 0.08575697f, -0.26416475f, 0.23601584f, 
    0.15023203f, -0.23118138f, 0.37052956f, 0.43007246f, 0.07013686f, -0.03618254f, 0.34664157f, -0.14357187f, 
    -0.05354917f, 0.25551891f, -0.06225988f, 0.05450556f, 0.34771109f, 0.18814044f, -0.01904503f, -0.01895295f, 
    0.21403134f, -0.17779186f, 0.13564894f, -0.50942296f, 0.14509569f, -0.65691185f, 0.25823697f, -0.12907684f, 
    0.08024412f, -0.04276219f, -0.06050527f, -0.02838683f, 0.21779498f, -0.20732304f, -0.03470579f, -0.06641194f, 
    -0.16042760f, 0.05006701f, -0.08606821f, -0.10997224f, -0.24604189f, -0.16119084f, -0.20248044f, 0.15658414f, 
    0.05183223f, -0.15566005f, -0.19898345f, 0.41869891f, -0.10478964f, -0.13388345f, 0.19285107f, 0.02905750f, 
    -0.06907503f, -0.56794178f, 0.13785876f, 0.17592070f, -0.08679287f, -0.07154129f, 0.07243879f, -0.06843150f, 
    0.24668194f, -0.15728931f, 0.08408693f, 0.32008639f, -0.23639162f, -0.19007041f, -0.08935785f, -0.13667792f, 
    0.38062140f, 0.47879153f, -0.22383550f, 0.10204223f, -0.04392178f, 0.21128413f, -0.32013214f, -0.24064009f, 
    -0.39870107f, -0.24660833f, -0.05293673f, 0.15303190f, -0.13241334f, 0.31363907f, 0.13991664f, 0.07492310f, 
    0.02117069f, 0.25035939f, 0.30721825f, -0.65448672f, -0.16526619f, -0.34021538f, 0.22068878f, 0.11511980f, 
    -0.10667020f, 0.01631681f, 0.09832425f, 0.22776839f, 0.51500154f, 0.29741290f, -0.10962478f, -0.13417931f, 
    -0.14257982f, 0.60744089f, -0.14276147f, 0.23648469f, 0.15191360f, -0.45756018f, 0.03012856f, 0.03988640f, 
    -0.03807820f, -0.07705904f, 0.01562512f, 0.07294197f, -0.05104198f, -0.36411640f, 0.25812429f, -0.01382423f, 
    -0.47145477f, -0.59988946f, -0.58252031f, -0.01684600f, 0.20623806f, 0.00801920f, -0.29153523f, 0.14493987f, 
    0.15491462f, 0.00320842f, -0.23707710f, -0.30010182f, -0.40350375f, 0.23250638f, 0.18882182f, -0.14268631f, 
    0.35356310f, 0.21549524f, 0.35020661f, -0.37715837f, -0.18550827f, 0.00869369f, -0.26373971f, -0.22209290f, 
    -0.06225859f, -0.15808685f, -0.14765421f, -0.09374885f, -0.00614728f, 0.04053478f, -0.06140171f, -0.23427182f, 
    0.29305142f, -0.59554130f, 0.27569011f, 0.18505757f, 0.48943990f, -0.04430641f, 0.17585458f, 0.17801400f, 
    -0.27971753f, 0.07771353f, -0.23275307f, 0.26878861f, 0.19678880f, -0.12401444f, 0.35198864f, 0.23605078f, 
    -0.25405711f, 0.47057375f, 0.31766599f, -0.04482906f, -0.09401552f, 0.18385328f, -0.21393815f, -0.24197823f, 
    -0.12260792f, -0.06867066f, -0.07892978f, -0.20247668f, -0.07385954f, -0.15696967f, -0.02752393f, 0.10655993f, 
    0.21185225f, 0.04120713f, -0.09300041f, -0.07407188f, -0.02266678f, -0.17177582f, 0.03113556f, 0.20069027f, 
    -0.21588680f, -0.18716833f, 0.10235089f, 0.02020919f, -0.21120125f, -0.21324891f, -0.03679061f, 0.20232385f, 
    -0.17342317f, -0.07132283f, -0.10577291f, 0.01213285f, -0.24975333f, -0.22473541f, 0.13650340f, -0.20216405f, 
    -0.02670107f, -0.08687863f, -0.15711245f, 0.16939019f, 0.16123569f, -0.49854553f, 0.07521518f, 0.02381682f, 
    -0.09869684f, -0.61375332f, -0.12979694f, 0.04199300f, -0.13456990f, 0.30851835f, -0.23369728f, 0.12967867f, 
    0.05165313f, -0.01639243f, -0.14952591f, 0.07698136f, -0.41180742f, -0.27381298f, 0.30757114f, 0.01596846f, 
    0.29234043f, 0.11915700f, 0.13509776f, -0.04426765f, -0.29374278f, 0.24608593f, -0.39441657f, 0.02948342f, 
    0.16278891f, -0.17146230f, 0.21936783f, -0.22764938f, 0.07476886f, 0.10734489f, -0.13241035f, 0.01319408f, 
    -0.02697676f, -0.46701902f, 0.41525108f, -0.27557850f, -0.27003667f, 0.06409170f, 0.21097349f, -0.14009792f, 
    -0.04930681f, -0.18567052f, -0.10212763f, -0.26481664f, 0.23512390f, 0.13538122f, 0.20444067f, 0.18269527f, 
    0.38409194f, 0.55006284f, -0.20767540f, -0.27766389f, 0.22255936f, 0.05929682f, -0.29638016f, -0.19762102f, 
    0.36742020f, -0.20278507f, 0.00125113f, 0.01308043f, 0.70506918f, -0.01175052f, -0.26875019f, 0.18135628f, 
    0.36877242f, -0.01294488f, -0.12311422f, -0.30773005f, 0.24406254f, 0.02745591f, -0.11012692f, 0.15166019f, 
    0.24822579f, -0.18558241f, -0.02505571f, 0.08562616f, -0.05755749f, 0.35804930f, -0.08447244f, -0.03692108f, 
    0.02624925f, -0.35281327f, 0.00192101f, -0.29277492f, -0.41398776f, -0.15505545f, 0.49757451f, 0.14125510f, 
    0.24322943f, 0.08395307f, -0.02103720f, 0.33824125f, -0.13039732f, 0.36863157f, -0.06062400f, -0.09633907f, 
    0.42679867f, 0.33027914f, -0.10121668f, -0.41891953f, -0.25520673f, -0.43617007f, 0.17997336f, -0.18702151f, 
    -0.00264151f, -0.21323188f, 0.22395223f, 0.04628227f, -0.09384146f, 0.21499287f, 0.12217043f, 0.19856493f, 
    0.36602184f, 0.58827353f, -0.21076564f, 0.17344816f, -0.37444377f, 0.15402107f, -0.12543587f, -0.07775877f, 
    0.05430181f, -0.14452443f, -0.21114977f, 0.09306244f, -0.44340459f, -0.04351952f, 0.06544619f, -0.12653683f, 
    -0.24180165f, -0.49525353f, 0.55308694f, -0.10223478f, 0.15142553f, -0.07470576f, 0.22253111f, 0.01947616f, 
    0.34872130f, 0.07553242f, -0.13732161f, -0.07482775f, 0.58251280f, 0.04087994f, 0.02132093f, -0.19276640f, 
    -0.21633321f, -0.21514429f, 0.18088244f, -0.39474148f, 0.20037644f, -0.11728778f, 0.41646218f, 0.14837214f, 
    0.23134948f, 0.03284416f, 0.05748777f, -0.53599095f, 0.47180715f, -0.17249848f, 0.10949191f, -0.01939638f, 
    -0.27234840f, -0.08546882f, 0.26191604f, 0.29784656f, 0.40616050f, 0.13412033f, -0.28111973f, 0.07551952f, 
    -0.19287427f, 0.00629704f, -0.05063355f, 0.17968823f, 0.12609886f, 0.08916768f, 0.12788028f, 0.21293066f, 
    0.27379924f, -0.39103529f, -0.17714573f, 0.03796803f, 0.52917707f, -0.11375967f, 0.13998978f, 0.08080532f, 
    0.06854487f, -0.14606687f, 0.09731489f, -0.14477268f, -0.24864072f, -0.08326849f, -0.27415401f, -0.07523277f, 
    -0.09031603f, 0.00382873f, 0.01327452f, 0.14549877f, -0.12331208f, -0.02227205f, -0.09492155f, 0.04252964f, 
    -0.32244816f, 0.20600930f, -0.13877574f, 0.43307877f, 0.24331531f, 0.30794376f, -0.19029041f, -0.17423663f, 
    0.22495514f, 0.37427408f, 0.01383978f, 0.29977149f, -0.32720938f, 0.33250904f, -0.23857541f, -0.02173406f, 
    -0.30741158f, 0.23429745f, -0.15239899f, 0.41907305f, 0.45035979f, -0.28344008f, 0.31835344f, -0.05057356f, 
    -0.36196452f, -0.08649682f, 0.03130394f, 0.39099574f, -0.20397067f, 0.12851971f, 0.15676150f, 0.17277800f, 
    0.21652313f, -0.17169107f, 0.00313892f, 0.23527096f, -0.34911647f, 0.33335504f, -0.11999617f, -0.18179394f, 
    -0.04996525f, 0.11589865f, 0.15027089f, 0.00713005f, -0.53462559f, -0.50992978f, 0.27344987f, 0.05838243f, 
    0.25474045f, -0.24722111f, -0.07974324f, 0.07286919f, 0.63642812f, 0.11411164f, -0.09213447f, -0.24940364f, 
    -0.03678178f, -0.32121187f, -0.34127697f, -0.07413355f, 0.03881266f, 0.14323682f, 0.26027653f, 0.19965240f, 
    0.02060459f, -0.20990971f, 0.21933237f, 0.52556008f, 0.10103682f, -0.16671586f, 0.08558191f, 0.10487271f, 
    -0.05576301f, 0.00497366f, 0.21835643f, -0.05296036f, -0.51374358f, 0.16866919f, 0.16671132f, 0.19465657f, 
    -0.20810726f, 0.10143813f, -0.10003707f, -0.15929745f, -0.26801997f, -0.13705572f, -0.00619552f, 0.21970987f, 
    0.21559788f, -0.07422437f, 0.13907437f, -0.18763052f, 0.15004984f, -0.10580128f, 0.34219658f, -0.22463858f, 
    0.05489568f, 0.05139588f, 0.18236573f, -0.14451487f, 0.00777889f, -0.23150405f, 0.26798260f, -0.00000145f, 
    -0.19259077f, 0.13310173f, 0.01552894f, -0.08305096f, -0.20299442f, 0.21508116f, 0.06095743f, -0.01570646f, 
    -0.43416312f, 0.17110929f, -0.10585052f, -0.17836325f, -0.44263572f, 0.21436407f, -0.14347228f, 0.09702852f, 
    0.53646165f, -0.07394177f, 0.39312065f, 0.09741357f, -0.10380128f, 0.32158169f, -0.15278527f, -0.22384445f, 
    0.21843202f, -0.04446762f, 0.18278688f, 0.41532844f, -0.00843021f, -0.12392900f, 0.03611276f, 0.20642230f, 
    0.11712202f, -0.29265240f, -0.28885150f, -0.28857881f, 0.40925527f, 0.20528889f, -0.02905062f, -0.18359992f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08577488f, 0.23941742f, -0.20397493f, -0.03396547f, -0.47781688f, 0.35559413f, -0.23622021f, -0.03451919f, 
    0.22401416f, 0.31411430f, 0.35374179f, 0.25405225f, 0.11540075f, 0.15385854f, 0.44355598f, 0.35597548f, 
    -0.30416191f, 0.11438638f, -0.22955225f, 0.34186807f, -0.12074776f, 0.13579984f, 0.40487760f, 0.00569244f, 
    0.42951769f, 0.01445449f, 0.36961147f, -0.20296760f, -0.13091722f, -0.09989975f, 0.07972213f, -0.17701021f, 
    -0.01825236f, -0.03869367f, 0.31949177f, 0.24617013f, 0.45152563f, 0.55497766f, -0.35412982f, -0.01150646f, 
    -0.22370410f, 0.16784009f, 0.56483787f, 0.27818775f, -0.36294016f, 0.34756204f, -0.16077037f, 0.18758965f, 
    0.46063024f, -0.29000801f, 0.53743118f, 0.29606706f, -0.12679379f, -0.40647995f, -0.10904251f, -0.27668101f, 
    -0.21690778f, 0.33741853f, -0.06598874f, 0.04434822f, -0.08372630f, 0.44071797f, 0.24141769f, -0.27080414f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00631442f, 0.09676293f, 0.16835704f, -0.00511326f, -0.11694037f, 0.03651221f, 0.04954058f, -0.01152714f, 
    -0.01913171f, -0.12279669f, 0.11764398f, 0.08279077f, -0.06818337f, 0.05330169f, -0.01327347f, 0.02406782f, 
    -0.07021918f, -0.01054541f, 0.06799523f, 0.19533940f, -0.04284015f, 0.11026490f, 0.01877123f, -0.11774062f, 
    0.19381988f, 0.00849265f, 0.18821968f, 0.05884354f, 0.21414202f, -0.03272824f, -0.14404969f, 0.07918997f, 
    -0.05278120f, -0.04990433f, -0.10620072f, 0.15283301f, 0.04816781f, -0.10116811f, 0.06195516f, -0.06104954f, 
    -0.00710215f, 0.03525539f, -0.07133608f, -0.10720214f, -0.11776371f, 0.09284874f, -0.13701628f, -0.17266183f, 
    -0.15357050f, -0.10854443f, 0.10004589f, -0.03994419f, 0.03416156f, 0.09376686f, -0.09029917f, -0.14227067f, 
    -0.13660005f, -0.09340890f, -0.09118819f, -0.21953326f, 0.08822056f, 0.06681162f, -0.02908012f, 0.00592051f, 
    -0.27896520f, 0.47829670f, 0.13053106f, 0.10511503f, -0.34000582f, 0.33383048f, 0.06675671f, 0.08847851f, 
    0.04072880f, 0.40824676f, -0.16378899f, -0.13925609f, 0.05312991f, 0.24140176f, -0.07346661f, 0.28754658f, 
    -0.16649657f, -0.07866704f, 0.03947461f, -0.45503798f, 0.09182464f, -0.01792995f, 0.06848052f, 0.02433353f, 
    0.03189165f, -0.27334693f, -0.15164213f, 0.18792315f, 0.00882960f, -0.05921534f, -0.03009809f, -0.03445163f, 
    -0.14186606f, 0.21953969f, -0.09593385f, 0.11754693f, 0.06044970f, 0.02562374f, -0.06759608f, -0.03652066f, 
    -0.00670692f, 0.12022655f, 0.06922874f, 0.08762988f, -0.77747518f, 0.09470535f, 0.24500987f, -0.10280975f, 
    0.06988044f, 0.13052000f, -0.18172263f, -0.30598503f, 0.02706016f, -0.20208938f, -0.12853020f, 0.35268420f, 
    -0.01685898f, -0.07220111f, 0.10908554f, 0.07041653f, -0.18904109f, -0.11131044f, 0.13670154f, 0.31848961f, 
    -0.15415716f, -0.05161305f, -0.08007379f, -0.09669365f, -0.10325573f, -0.08979037f, 0.04150150f, -0.14192006f, 
    0.08610904f, 0.08055463f, -0.02708221f, -0.56304914f, 0.50909173f, 0.35401899f, -0.13804220f, 0.28903776f, 
    0.02591360f, 0.14131057f, 0.02603276f, 0.10209841f, -0.01995346f, 0.09103254f, 0.11459465f, -0.01999319f, 
    -0.10331388f, -0.08280054f, -0.26998878f, 0.09752736f, -0.15109824f, 0.34105885f, 0.00773650f, -0.00132453f, 
    0.13365525f, -0.14075166f, 0.09506302f, 0.09413201f, -0.30157360f, -0.04800414f, -0.22538210f, 0.24826285f, 
    0.03321086f, 0.03515425f, -0.03218503f, -0.00946760f, -0.69767463f, -0.07097732f, -0.17486919f, 0.30054277f, 
    0.15845777f, -0.16802812f, 0.29221550f, 0.15771477f, -0.21048929f, -0.15485330f, -0.00124581f, 0.18596184f, 
    0.38496548f, 0.08805709f, -0.14686719f, 0.28576827f, -0.00749736f, -0.08072907f, 0.07275229f, 0.09264769f, 
    0.09642060f, -0.27409878f, 0.01536564f, -0.06336109f, 0.03356417f, -0.00621205f, -0.02073789f, -0.22789352f, 
    0.01054154f, -0.05539668f, 0.01834828f, -0.05597829f, -0.07773159f, -0.14025734f, -0.24502063f, 0.12828720f, 
    -0.08418048f, 0.35586262f, 0.13449955f, -0.30542505f, -0.09037445f, -0.18277119f, -0.13355865f, -0.38755372f, 
    0.09147207f, 0.06243563f, 0.04808648f, -0.02222254f, 0.03899791f, 0.22959487f, 0.38290757f, 0.01008798f, 
    0.03736419f, -0.03587214f, 0.24421205f, 0.04109398f, 0.29559308f, 0.01927705f, 0.05311546f, -0.13351668f, 
    -0.03057016f, 0.11232442f, 0.30830479f, -0.16564071f, 0.53220892f, -0.04238302f, 0.25982338f, 0.41843423f, 
    0.04632965f, -0.26585141f, 0.27483112f, 0.29737872f, 0.11549357f, -0.02416278f, -0.07817027f, -0.20171636f, 
    -0.02523909f, 0.14099187f, -0.03145500f, 0.09010644f, 0.12326598f, -0.02956596f, 0.01259381f, -0.04770477f, 
    0.12731978f, 0.08501153f, -0.18798266f, -0.00240320f, 0.03211538f, 0.35370991f, 0.00579310f, -0.13912971f, 
    0.12995276f, -0.39755949f, 0.03103469f, -0.13916370f, 0.25352085f, 0.39906088f, -0.05202586f, 0.02551747f, 
    0.19314589f, 0.33176187f, -0.07449020f, 0.14754449f, -0.22485928f, 0.08258711f, 0.14725086f, 0.38579705f, 
    -0.18537669f, -0.20022488f, -0.24552383f, 0.24159797f, 0.08457213f, 0.24543597f, 0.14470421f, -0.10918795f, 
    -0.07326312f, -0.06802398f, 0.25358042f, 0.17189874f, -0.40199590f, -0.13649574f, -0.23071751f, 0.10581466f, 
    -0.11895044f, 0.09590620f, 0.16643284f, -0.16125390f, -0.13971648f, -0.00083403f, 0.24134299f, 0.14380828f, 
    0.23192497f, -0.02251773f, 0.12759086f, 0.25965518f, 0.04117480f, -0.52936018f, -0.06314422f, 0.20770888f, 
    0.30138573f, 0.26567611f, 0.05134307f, 0.17796098f, 0.40590435f, 0.04911954f, -0.06956223f, -0.50994283f, 
    -0.05401629f, -0.10687877f, -0.03188055f, 0.09278511f, 0.05066252f, -0.02463920f, 0.09491521f, -0.01036200f, 
    -0.02416917f, -0.10582256f, -0.08205268f, 0.12486884f, 0.05018793f, -0.11756580f, -0.14840154f, 0.01157887f, 
    -0.12774169f, 0.07658659f, -0.01027243f, -0.14290433f, -0.04647471f, 0.06799801f, 0.05626407f, 0.00240463f, 
    -0.09022795f, 0.04709399f, -0.07165997f, -0.11520617f, -0.02457840f, -0.12071588f, -0.01252373f, -0.04544899f, 
    0.09265818f, 0.04920447f, 0.02537905f, -0.11981356f, -0.05887686f, -0.13351315f, -0.12000541f, -0.00964890f, 
    -0.08428675f, 0.05272320f, -0.11268239f, -0.11040033f, -0.04427757f, 0.05288647f, 0.06597650f, 0.05198634f, 
    0.04258247f, 0.00923312f, -0.13743934f, -0.09502760f, -0.09725071f, 0.10135273f, -0.05734439f, -0.05917442f, 
    -0.13218264f, 0.09333117f, 0.08730999f, -0.06815094f, -0.04622802f, -0.11998381f, 0.00401188f, 0.06681637f, 
    -0.04674348f, -0.17034680f, 0.01145040f, 0.10998638f, 0.05275967f, 0.03703507f, 0.10414523f, -0.08205044f, 
    -0.02590899f, 0.03091715f, 0.01880369f, -0.09869125f, 0.00908027f, -0.15260886f, -0.00463019f, 0.04673435f, 
    0.00893816f, -0.12433504f, -0.04486283f, 0.08419137f, 0.00168123f, -0.06698583f, -0.11515188f, 0.03951044f, 
    0.08410576f, 0.09629297f, -0.06937955f, -0.07614746f, -0.18991202f, 0.01642733f, 0.01461672f, 0.05032726f, 
    -0.05758432f, -0.06730656f, 0.03912804f, -0.16373834f, -0.01170443f, -0.15320218f, 0.04116548f, -0.16515900f, 
    -0.11946575f, -0.05180612f, 0.05937994f, 0.11825786f, 0.06381840f, -0.03988102f, -0.12558196f, 0.05436087f, 
    0.02860449f, -0.07621507f, 0.04425450f, -0.11117960f, -0.04801284f, 0.02995217f, -0.07043751f, 0.03908104f, 
    -0.09847573f, -0.16853519f, 0.01387075f, -0.14181361f, -0.07631406f, 0.01746801f, -0.03604490f, -0.01890987f, 
    0.01744462f, 0.24413824f, -0.15468457f, 0.01427323f, -0.45493346f, -0.13896187f, 0.10677481f, 0.27147156f, 
    -0.07524644f, 0.04378488f, 0.08593038f, 0.10803199f, 0.27846336f, -0.02361270f, 0.61400044f, 0.17755577f, 
    -0.29465449f, -0.03939774f, -0.11299971f, 0.72435087f, -0.03858449f, 0.24179812f, 0.19072121f, 0.02248207f, 
    0.31783855f, 0.15725495f, 0.24945711f, -0.16524449f, -0.01911788f, -0.01951262f, 0.08532722f, -0.10130033f, 
    0.21973962f, 0.22288848f, 0.15950565f, -0.03932338f, -0.40035883f, 0.14354850f, -0.01788175f, 0.04242391f, 
    -0.04869355f, -0.06522995f, 0.01436583f, 0.21293816f, -0.49788088f, 0.12819374f, -0.15286312f, 0.13516991f, 
    0.23423876f, -0.03581740f, 0.14176759f, -0.07033183f, 0.03860500f, 0.00531769f, 0.00095108f, -0.06287538f, 
    -0.04754176f, 0.17016713f, -0.10884675f, 0.14472397f, 0.07749355f, 0.09143870f, -0.13724723f, -0.03812034f, 
    0.03656466f, -0.26035473f, -0.22335750f, 0.02746409f, 0.04165174f, 0.29131952f, -0.07109211f, 0.12875807f, 
    0.12298035f, 0.02625505f, -0.19656038f, -0.36166036f, 0.22050680f, 0.34337693f, 0.06758910f, -0.24622379f, 
    0.08899466f, 0.02288932f, 0.13913172f, 0.38135657f, 0.00095825f, -0.06498547f, 0.01305601f, 0.29420838f, 
    0.02255984f, -0.19152410f, -0.16430971f, 0.30881757f, -0.08921428f, 0.28278905f, 0.16136779f, 0.07534647f, 
    0.03265346f, -0.10517523f, 0.26724532f, 0.14179900f, -0.18531257f, -0.07473387f, 0.04447862f, 0.16382472f, 
    -0.03214517f, -0.01674744f, -0.05809515f, 0.01995961f, -0.19798373f, -0.21752878f, -0.32633924f, -0.24409883f, 
    -0.24408032f, 0.03463521f, 0.10960344f, -0.46577677f, 0.00968678f, -0.16834894f, -0.01044684f, 0.21580577f, 
    0.36842719f, 0.03387303f, -0.03934108f, 0.08665049f, 0.06019720f, -0.15523514f, 0.19396883f, -0.22682048f, 
    -0.22519244f, -0.17717929f, 0.34288096f, -0.10288742f, -0.03373012f, -0.36012122f, -0.10361725f, 0.11671744f, 
    0.23617896f, 0.21403193f, 0.23224038f, -0.12309739f, -0.47712576f, 0.00295689f, 0.09164384f, 0.01208577f, 
    0.06609856f, -0.16536373f, -0.05491595f, -0.25490841f, 0.06268400f, 0.05236428f, 0.02706980f, 0.01608442f, 
    -0.09852585f, 0.09235823f, -0.07073440f, -0.36019647f, -0.15927087f, -0.25662890f, -0.15140194f, -0.05138932f, 
    -0.15632157f, 0.11875542f, -0.24007878f, -0.35550037f, -0.25001210f, 0.31292242f, -0.32167292f, 0.24886383f, 
    -0.06853181f, -0.01346368f, -0.18501140f, 0.35272795f, -0.28718784f, 0.28042334f, 0.52936238f, 0.02156919f, 
    0.02437874f, 0.30027217f, -0.17399532f, 0.03166258f, 0.03679607f, -0.28773215f, -0.12380187f, 0.37811953f, 
    -0.00914728f, -0.06253019f, -0.22745571f, 0.28965268f, -0.28759441f, 0.11915489f, 0.31356063f, 0.00556719f, 
    -0.18088737f, -0.16099745f, 0.25645030f, -0.06280123f, 0.20420836f, 0.00604451f, -0.06962386f, -0.06922219f, 
    0.20407967f, 0.23704581f, 0.09034844f, -0.22355531f, 0.10874584f, -0.00164289f, -0.02036349f, 0.00583491f, 
    0.44746089f, 0.20236622f, 0.19116487f, -0.42225909f, -0.04587024f, -0.22979610f, -0.35429022f, 0.12059870f, 
    -0.25808510f, -0.10869710f, -0.41104674f, 0.12574275f, -0.30756569f, 0.17810835f, -0.21967016f, -0.03414723f, 
    0.12972651f, -0.10660698f, -0.18377891f, -0.12657785f, -0.33530194f, -0.16419701f, 0.17880467f, 0.14636034f, 
    -0.01286592f, 0.02479208f, -0.70198655f, 0.03726439f, 0.47284991f, -0.10221919f, 0.27451226f, -0.15896301f, 
    -0.24129726f, -0.07104392f, 0.08576229f, 0.13323005f, -0.11034203f, 0.15247244f, -0.12811513f, 0.19964597f, 
    0.36397681f, -0.13147593f, 0.11934678f, 0.10362963f, -0.38812897f, 0.12509862f, 0.04074109f, 0.13718610f, 
    -0.03388678f, 0.12391347f, 0.02035227f, 0.11006743f, 0.04412600f, -0.12643805f, -0.05300663f, -0.01683643f, 
    -0.10601212f, -0.01960437f, -0.05224970f, -0.09786579f, -0.03662275f, -0.09147964f, 0.03777600f, -0.02435049f, 
    -0.01139157f, 0.08959737f, -0.06023870f, -0.09882064f, -0.00029902f, 0.08997448f, -0.12242953f, 0.06911860f, 
    -0.09710032f, -0.04827406f, 0.10313242f, 0.11833178f, -0.13079140f, -0.00256568f, -0.00362790f, -0.00869294f, 
    -0.12390605f, 0.01484399f, 0.07365750f, 0.09986494f, 0.02855287f, -0.08706889f, -0.00012000f, -0.08399914f, 
    0.01488397f, 0.00073920f, 0.03000246f, 0.07544309f, -0.10457025f, -0.10623685f, -0.01514684f, -0.03512483f, 
    -0.09083005f, -0.00610216f, 0.04676419f, 0.11554311f, -0.02455945f, -0.08950121f, -0.03578238f, -0.08378692f, 
    -0.04928312f, -0.04963119f, 0.11522117f, 0.05336278f, 0.02337312f, -0.03919896f, -0.06295912f, 0.02455181f, 
    -0.10240636f, -0.49336511f, 0.55370492f, 0.06817925f, -0.26810476f, -0.22455506f, -0.06397633f, -0.12826470f, 
    0.30647907f, 0.37956327f, 0.22182560f, -0.12888895f, 0.01133380f, 0.05981400f, -0.20637441f, 0.10170390f, 
    -0.03078233f, -0.13412833f, 0.08386716f, -0.50891352f, 0.08111095f, 0.08940389f, -0.39488125f, -0.01512420f, 
    -0.17665802f, 0.05004237f, 0.03828358f, -0.00183905f, -0.39384028f, -0.17615958f, 0.20860933f, -0.07101658f, 
    -0.32660732f, 0.26807272f, 0.46005502f, -0.84273338f, 0.29667583f, 0.27891323f, 0.01183635f, 0.31217185f, 
    -0.11292282f, -0.02923653f, -0.23415306f, 0.23517697f, 0.08898860f, 0.37177747f, -0.36351484f, -0.22577097f, 
    0.00696182f, 0.21162201f, -0.10564147f, -0.13379572f, -0.18213576f, -0.06050462f, 0.15184276f, 0.34912711f, 
    -0.25578102f, -0.34454370f, -0.13774689f, -0.01515193f, -0.04214823f, 0.14166898f, 0.47194180f, 0.10178592f, 
    -0.27073467f, 0.40345597f, 0.41967681f, 0.07989334f, 0.01724301f, -0.09234878f, -0.11677811f, -0.01134859f, 
    -0.04176099f, 0.11834520f, -0.10333682f, 0.22843233f, 0.11565644f, -0.08461797f, 0.11106159f, 0.33557260f, 
    -0.08650161f, -0.05393095f, 0.07289180f, -0.04660632f, -0.14388599f, 0.08258615f, -0.22386433f, 0.33760506f, 
    -0.20129405f, -0.08391755f, 0.11679354f, -0.13103242f, -0.06302973f, 0.12383539f, 0.18811868f, 0.06084630f, 
    0.08570467f, 0.10948396f, 0.01704516f, 0.06027118f, 0.89418882f, -0.19514965f, -0.05309086f, 0.13086532f, 
    0.08269343f, 0.00806345f, 0.17253812f, 0.05826298f, -0.82088959f, 0.16841875f, 0.40651393f, -0.05956409f, 
    0.03305104f, -0.12804079f, 0.01542042f, 0.18305297f, 0.11197773f, 0.16574582f, -0.04016707f, -0.06423120f, 
    0.19812916f, -0.17553753f, 0.12386280f, 0.10495987f, -0.01870668f, 0.01537275f, -0.27397960f, 0.20485204f, 
    -0.09754285f, 0.03082567f, 0.07137277f, 0.03006199f, -0.12081442f, 0.06124241f, 0.09832041f, -0.08414382f, 
    -0.13265778f, -0.04303038f, -0.01048943f, -0.14578059f, -0.00268887f, 0.02161196f, 0.01941405f, -0.12683788f, 
    -0.05911164f, -0.01107249f, -0.12247711f, 0.04402590f, 0.06637276f, -0.05883127f, 0.04602167f, -0.01087847f, 
    -0.04257625f, -0.08486190f, 0.01763185f, -0.13458167f, -0.01673695f, -0.09822565f, -0.05437529f, -0.00150537f, 
    -0.09556255f, -0.14684889f, -0.01476467f, -0.03056085f, 0.05576221f, -0.02233163f, -0.07032893f, 0.02953203f, 
    -0.10706452f, 0.09949355f, -0.07461783f, -0.07777753f, -0.03320141f, -0.08087753f, -0.06450425f, 0.01634465f, 
    0.08862680f, -0.01830792f, -0.09429935f, -0.13452536f, 0.07989533f, 0.03957742f, -0.09146294f, 0.00195783f, 
    -0.08596828f, 0.10575913f, -0.02649739f, -0.11529864f, -0.06467555f, -0.04119503f, -0.10518727f, 0.07759384f, 
    -0.10452142f, 0.04787818f, -0.05684010f, 0.04792888f, -0.02606949f, -0.08924745f, 0.03297275f, 0.00992787f, 
    -0.08137787f, -0.02031085f, 0.07683584f, 0.02650413f, 0.00473660f, -0.07506128f, -0.07933053f, 0.04970888f, 
    -0.12801847f, -0.12386264f, -0.10924224f, 0.04824585f, -0.03788201f, 0.07581605f, -0.01531441f, -0.11142574f, 
    -0.07755611f, -0.08812314f, -0.07556644f, -0.06530615f, 0.07067458f, 0.02606633f, -0.05259632f, 0.09585367f, 
    -0.02888957f, 0.01458515f, -0.10167399f, -0.04672250f, 0.00835009f, -0.05055366f, 0.06289483f, -0.09954111f, 
    0.11519744f, 0.08072585f, -0.05978251f, -0.11554602f, 0.04185516f, -0.10235676f, -0.10519218f, -0.04816049f, 
    -0.09181599f, 0.05186661f, 0.10989151f, -0.01631575f, -0.06101811f, -0.00945057f, -0.10197230f, 0.03923827f, 
    -0.06674216f, -0.01091863f, 0.02254905f, 0.09705921f, -0.05086075f, 0.08412419f, 0.10247983f, 0.02374129f, 
    0.04193667f, 0.11937588f, 0.25812024f, -0.03657039f, 0.22790423f, -0.04821490f, -0.03422636f, 0.04785390f, 
    -0.12106047f, -0.11542532f, 0.43528685f, 0.02821629f, -0.11123516f, -0.21682295f, 0.09923740f, 0.01310232f, 
    0.10236076f, 0.01529595f, -0.20399268f, -0.04837102f, -0.06610291f, 0.02435280f, -0.07803930f, 0.17239732f, 
    0.03562092f, -0.08445812f, 0.11224406f, -0.21024521f, 0.00601178f, -0.04928392f, 0.14471370f, -0.10031752f, 
    -0.07740087f, 0.07636265f, -0.01479079f, 0.04782972f, -0.15932834f, 0.17411071f, 0.11982516f, 0.00572890f, 
    -0.05305709f, 0.00758016f, 0.38816845f, 0.16813755f, 0.55359554f, 0.19663066f, 0.29201409f, 0.05753324f, 
    0.13277191f, -0.09270173f, 0.16883287f, 0.34108928f, -0.03534848f, -0.15414704f, 0.11289521f, -0.36040813f, 
    0.05104395f, -0.00584609f, 0.04036015f, 0.04538951f, 0.38058093f, 0.14256969f, -0.13361317f, -0.05247045f, 
    0.01745960f, 0.07767571f, -0.34658933f, 0.03926180f, -0.18854468f, -0.19536753f, 0.01471121f, 0.26804498f, 
    0.24711320f, 0.23648912f, 0.04194348f, 0.07859731f, 0.20916505f, -0.06315726f, 0.63643652f, 0.02907118f, 
    -0.06971449f, 0.10703944f, -0.11995803f, 0.67976362f, -0.01903724f, 0.07043567f, 0.39430586f, 0.06460623f, 
    0.35105422f, 0.16399774f, 0.08948413f, -0.22291809f, -0.01534410f, -0.16008267f, -0.09824230f, -0.10503094f, 
    0.17141186f, 0.05426906f, 0.08925039f, 0.07073599f, -0.51897532f, 0.29173824f, -0.13076030f, 0.22563332f, 
    -0.06786260f, 0.02422264f, 0.05081050f, 0.13729370f, -0.52461320f, 0.13681111f, -0.29865617f, 0.19799489f, 
    0.23039263f, 0.01555686f, 0.28730473f, 0.02704076f, 0.05871556f, -0.13555232f, -0.01314447f, -0.09870745f, 
    -0.00315006f, 0.28721002f, -0.16391379f, 0.27266133f, -0.26885515f, 0.14739347f, -0.24183173f, 0.12946625f, 
    0.10056610f, -0.46043471f, -0.45475844f, 0.09542626f, 0.04520584f, 0.05520299f, -0.04488395f, 0.00337387f, 
    0.22323726f, 0.08488166f, 0.04972290f, -0.15221825f, 0.04920561f, 0.10953376f, 0.24279059f, -0.11778378f, 
    0.22187331f, 0.20288403f, -0.10182684f, 0.26259586f, -0.10101468f, -0.04134610f, 0.03187098f, -0.18815318f, 
    0.05418263f, -0.10220427f, -0.02807384f, -0.09719437f, -0.18495107f, 0.17791903f, 0.27350447f, -0.05866061f, 
    0.13368949f, -0.22355148f, 0.30145845f, 0.04858094f, -0.56888127f, 0.03107005f, 0.04451647f, -0.04311188f, 
    -0.05956796f, 0.04994006f, 0.10974204f, 0.10431007f, 0.42994142f, -0.14791650f, -0.29278642f, 0.15579577f, 
    0.19814116f, -0.10374718f, 0.48648909f, 0.28452098f, 0.24595048f, -0.20818940f, -0.08402672f, -0.00287286f, 
    -0.05362124f, 0.27752560f, -0.09762569f, 0.23864548f, 0.20620315f, -0.01576037f, -0.20773572f, -0.10606330f, 
    -0.04393277f, -0.06882578f, 0.50364769f, 0.03055371f, 0.31287903f, 0.12655519f, 0.05264707f, -0.15309501f, 
    0.15238200f, -0.18522209f, 0.08743777f, -0.74016553f, -0.00161017f, -0.16832852f, -0.41154754f, 0.04848982f, 
    0.12740093f, 0.24687025f, -0.05710099f, -0.61866254f, 0.02297496f, -0.10676581f, -0.24996871f, -0.19212973f, 
    -0.16786487f, 0.02959605f, 0.26519805f, 0.17834689f, 0.18151559f, 0.38918144f, 0.25139457f, 0.03069390f, 
    -0.08363284f, -0.24056187f, 0.11673011f, -0.07517756f, -0.60144007f, 0.09679626f, 0.35296184f, -0.34924194f, 
    0.01085398f, 0.07803798f, -0.48464468f, -0.35709208f, 0.73858947f, 0.14875954f, 0.26737076f, 0.29645196f, 
    0.07383548f, -0.10814480f, 0.05413879f, 0.24043356f, 0.05215922f, 0.10166214f, -0.08877979f, 0.10109947f, 
    -0.35661092f, 0.13278773f, 0.09371465f, -0.03736340f, 0.13379996f, -0.30460092f, 0.64452362f, 0.11875376f, 
    -0.20938124f, -0.12207549f, -0.11397526f, 0.06420878f, 0.03733077f, 0.09836303f, -0.11555901f, 0.01554991f, 
    -0.15168108f, 0.05393661f, -0.07939779f, 0.03929923f, -0.13296470f, -0.00099872f, -0.01191950f, -0.09292419f, 
    -0.13274437f, -0.00369844f, -0.07935450f, -0.12126863f, -0.10866894f, -0.02838662f, 0.00011087f, 0.03498292f, 
    0.03493115f, -0.17787123f, -0.12062101f, 0.03708975f, -0.04908286f, 0.11101523f, -0.05355824f, -0.12308951f, 
    -0.04120374f, -0.10588088f, -0.04490192f, -0.13048060f, -0.03104876f, -0.16529244f, 0.04546203f, 0.05009422f, 
    -0.10423535f, -0.03694452f, -0.03605990f, 0.04593922f, 0.04031428f, -0.12188790f, -0.09023728f, -0.12095809f, 
    -0.20131242f, -0.08988427f, 0.03372575f, 0.03638140f, 0.04472497f, 0.08852103f, -0.07876261f, -0.04807170f, 
    -0.18614718f, -0.19372496f, -0.05343381f, -0.15183882f, -0.11286962f, -0.00424232f, 0.07079761f, -0.10907394f, 
    0.04063065f, -0.70386344f, -0.09281825f, -0.05127397f, -0.21289061f, -0.17163032f, 0.06361759f, 0.17337327f, 
    0.24163422f, 0.16859019f, 0.07413776f, 0.03718796f, 0.13505483f, 0.07953157f, 0.34307468f, -0.36763695f, 
    0.15933707f, -0.00486437f, -0.07712492f, 0.59974247f, 0.07542105f, 0.31066638f, 0.12492333f, -0.07075229f, 
    0.22074358f, 0.00501407f, 0.08120734f, -0.02883614f, -0.03981947f, 0.02601957f, 0.19845302f, -0.10216120f, 
    -0.01452808f, -0.08229642f, 0.35449973f, -0.06323072f, 0.36133009f, 0.14208849f, -0.12605885f, 0.37624738f, 
    0.07906546f, -0.04550955f, 0.64408827f, 0.16598830f, 0.05296526f, 0.09218074f, -0.43789819f, -0.20096578f, 
    -0.17190307f, 0.16222788f, 0.15609504f, -0.16808206f, 0.20814143f, -0.10559083f, 0.14543571f, 0.07549075f, 
    0.18307684f, -0.10180135f, -0.25060627f, 0.06537028f, 0.26463720f, 0.13693815f, 0.18878816f, -0.32795236f, 
    -0.16212897f, 0.00576019f, 0.01684914f, 0.05616528f, 0.02826362f, 0.48710611f, -0.00668696f, 0.04191501f, 
    0.20222698f, -0.08496615f, -0.09802304f, -0.45610821f, -0.32669371f, 0.25283438f, -0.09753164f, -0.09111189f, 
    0.03047281f, 0.01559293f, -0.15704292f, -0.05986463f, -0.07120674f, -0.24211700f, -0.06338958f, 0.08928456f, 
    0.03746015f, -0.20718220f, -0.11212898f, 0.23626693f, -0.23519039f, 0.13062271f, -0.02692589f, -0.07940963f, 
    -0.05121941f, 0.11702432f, -0.18947943f, -0.03820178f, -0.21248001f, 0.17763066f, -0.09821014f, -0.11506151f, 
    0.09537448f, 0.03395770f, -0.55345541f, 0.06798967f, 0.27476627f, 0.02498383f, 0.36051148f, -0.10245745f, 
    -0.06133495f, 0.14738376f, -0.00139124f, -0.11475312f, 0.10017540f, -0.29547146f, 0.04601678f, 0.32340789f, 
    0.07725860f, -0.00253113f, 0.14536314f, 0.04586868f, -0.09269170f, -0.09791304f, 0.41798320f, -0.15152922f, 
    0.36847943f, 0.29988512f, -0.22059612f, 0.00220843f, -0.42869791f, 0.26675713f, -0.08106299f, 0.00593997f, 
    0.07199457f, -0.19801538f, -0.05180508f, -0.25956389f, 0.19279720f, 0.28718957f, 0.09136824f, 0.09719705f, 
    -0.28284654f, 0.14670315f, -0.62184680f, 0.11783449f, -0.07820117f, -0.03064230f, 0.43997735f, -0.05075214f, 
    0.41552389f, -0.03870358f, 0.19368578f, 0.34564674f, 0.47805160f, -0.06993649f, 0.04375343f, -0.04878744f, 
    -0.40401125f, 0.05956247f, 0.16064565f, 0.26619408f, 0.03131213f, 0.03025000f, -0.52245015f, 0.05796328f, 
    -0.04176834f, -0.11161511f, -0.08700949f, -0.18510452f, -0.08124169f, 0.15992138f, -0.08124990f, 0.08831473f, 
    0.31797475f, 0.16384485f, -0.04731208f, 0.03089132f, -0.73547655f, -0.29578608f, -0.06423956f, 0.00517804f, 
    -0.28251359f, 0.28401104f, -0.28932706f, -0.04982557f, -0.24682845f, -0.35287905f, -0.19399743f, -0.44156462f, 
    0.14677089f, 0.01454609f, 0.08948509f, -0.00783062f, 0.14403343f, 0.34991458f, 0.09725760f, 0.13089316f, 
    0.14835843f, -0.28203529f, 0.05378282f, 0.05413058f, 0.32215330f, 0.29581597f, -0.13069007f, -0.33346960f, 
    0.01679780f, 0.20200276f, -0.11056954f, -0.17132869f, -0.03512425f, -0.15659937f, -0.02716301f, 0.20433635f, 
    -0.24934128f, -0.38362586f, -0.14628148f, 0.11287799f, 0.10535284f, 0.03437934f, 0.14220208f, -0.04315782f, 
    -0.83138824f, -0.13478766f, 0.08491971f, 0.21341985f, 0.05372059f, 0.16017401f, -0.45007694f, 0.23653986f, 
    -0.00590979f, -0.11826989f, -0.19484814f, -0.07321021f, 0.08804046f, 0.23762651f, 0.19485387f, -0.10421684f, 
    0.03051599f, 0.01298211f, -0.35012302f, 0.04763267f, -0.04583944f, -0.23787193f, 0.04231054f, 0.19588989f, 
    0.16388290f, 0.00136021f, -0.00002439f, -0.08800418f, -0.12111270f, -0.28694370f, 0.13087673f, -0.63520420f, 
    -0.00450193f, -0.01698341f, -0.25810158f, -0.03114980f, -0.10028227f, -0.10537516f, 0.04584485f, 0.22179650f, 
    0.12401512f, 0.09453859f, 0.04501228f, -0.27616733f, 0.29401067f, 0.15287827f, 0.41120651f, -0.07980150f, 
    -0.06321720f, 0.10726029f, 0.12709774f, 0.60497254f, 0.01846226f, 0.24372448f, 0.00040438f, 0.07765490f, 
    0.03659211f, -0.08990628f, -0.04004773f, 0.05753358f, -0.29599497f, 0.07782253f, 0.12515336f, -0.03769444f, 
    0.09884518f, 0.08792018f, 0.23575477f, 0.00486695f, -0.03367871f, 0.14990179f, -0.04647374f, 0.38598034f, 
    0.00379834f, 0.05586189f, -0.07868980f, 0.14053455f, -0.77068800f, 0.03046682f, -0.31736079f, -0.01754291f, 
    -0.18289748f, -0.08865369f, -0.02643271f, -0.05715215f, 0.11898930f, -0.00815296f, 0.01163357f, 0.09009330f, 
    0.24143532f, -0.13082726f, -0.11850546f, 0.13358745f, -0.03705828f, 0.05649616f, -0.30003813f, -0.00080015f, 
    0.22468361f, -0.43576178f, 0.25781780f, 0.06754149f, 0.20928298f, 0.11808651f, 0.01452081f, 0.03202287f, 
    0.29267308f, 0.08830222f, 0.13397995f, -0.07306727f, -0.04340506f, -0.01783349f, -0.30406785f, -0.28719679f, 
    0.20974338f, 0.02126094f, 0.01239247f, -0.14275345f, -0.18575633f, 0.11642969f, -0.05846276f, -0.07561858f, 
    -0.21698040f, 0.13837904f, -0.01061829f, 0.28119168f, 0.21088155f, 0.08904836f, 0.06085055f, -0.03292772f, 
    -0.44715670f, -0.02994923f, 0.23429008f, 0.10281109f, 0.05678082f, 0.09383833f, -0.21609432f, 0.15110213f, 
    0.06553012f, 0.08622977f, -0.01843303f, -0.00248469f, 0.73178655f, 0.35191363f, -0.19082896f, -0.19069740f, 
    -0.13507661f, 0.34768796f, -0.25041202f, -0.37033147f, -0.18800370f, -0.03940259f, -0.01477046f, 0.35395861f, 
    -0.04677271f, -0.11940648f, -0.41651693f, -0.06253903f, 0.01928175f, -0.00081067f, 0.47406682f, -0.25176001f, 
    0.16794778f, -0.01056602f, 0.11792771f, -0.06913015f, -0.38882348f, -0.14880882f, 0.04587367f, 0.26979211f, 
    0.03634180f, 0.21817814f, 0.23459749f, 0.32691517f, 0.03632374f, -0.21416065f, 0.29944572f, 0.23718461f, 
    -0.21197791f, -0.05413194f, -0.20634934f, 0.32002568f, 0.21348885f, 0.11903360f, 0.33378264f, -0.37937835f, 
    0.27362737f, 0.25922993f, 0.38160947f, -0.08674940f, 0.25628942f, -0.00813764f, 0.01019607f, 0.07466975f, 
    -0.17961204f, 0.20011613f, 0.23574170f, -0.07777266f, -0.41463083f, 0.29043007f, -0.00163241f, 0.08572433f, 
    -0.00954443f, 0.04894845f, -0.25939375f, 0.22843976f, 0.08694351f, 0.24234873f, -0.29258606f, 0.04061337f, 
    0.33890912f, 0.06733021f, 0.12652527f, 0.02506049f, 0.10972258f, -0.06072366f, 0.09116150f, -0.20380123f, 
    -0.36760327f, 0.33971688f, -0.38591486f, -0.00217115f, -0.04757517f, 0.04455661f, 0.10971760f, -0.06030275f, 
    0.15204296f, -0.26083058f, 0.10707999f, 0.03618626f, 0.11695497f, 0.39089611f, 0.10324393f, -0.01520951f, 
    0.31802717f, 0.01381091f, 0.14346847f, -0.29192108f, -0.02221279f, 0.30581990f, -0.21793920f, -0.18788193f, 
    0.12344927f, 0.13133503f, -0.21503618f, -0.13890426f, -0.01323375f, 0.08523287f, -0.05463632f, -0.34281272f, 
    -0.17300816f, -0.06856302f, -0.14897856f, 0.34706652f, -0.07021120f, 0.39902833f, 0.03658810f, 0.09069020f, 
    -0.18181145f, 0.16541201f, 0.01820212f, 0.15173085f, -0.05894085f, 0.22526170f, -0.20107614f, 0.11679491f, 
    -0.03969997f, 0.07911897f, -0.46258515f, -0.01474305f, 0.66898268f, 0.07298481f, 0.03451229f, 0.00845719f, 
    0.12851889f, 0.29222104f, -0.14999419f, -0.46180853f, -0.25324509f, -0.22976354f, -0.10215352f, 0.58168775f, 
    -0.06424402f, 0.04712266f, -0.24673627f, 0.06999773f, -0.15005717f, 0.05040129f, 0.44015706f, -0.27934656f, 
    -0.21603401f, 0.00129176f, 0.10205525f, -0.00145476f, -0.19318470f, -0.26706293f, 0.06575534f, 0.01842993f, 
    0.09734621f, 0.33356151f, 0.22939964f, 0.21957277f, -0.76535732f, -0.13100958f, 0.12313463f, 0.14240633f, 
    -0.02549565f, -0.26650620f, -0.23819920f, -0.29027143f, 0.06328225f, 0.15518960f, 0.10878129f, 0.11137674f, 
    0.12960869f, 0.27416980f, 0.11637089f, -0.30203962f, 0.02461731f, -0.40147150f, -0.25621915f, -0.03635252f, 
    -0.00803708f, 0.29893017f, 0.07103040f, -0.15085462f, 0.08171553f, 0.37666437f, -0.27448958f, 0.10073648f, 
    -0.02492079f, -0.07397106f, -0.23179714f, 0.45659241f, 0.14576040f, 0.28600773f, -0.11140294f, 0.14612356f, 
    0.15939052f, 0.23747826f, -0.20805332f, -0.35009697f, -0.28026158f, -0.19272201f, 0.04182643f, 0.15783744f, 
    -0.21747355f, 0.24122880f, -0.11920384f, 0.18930249f, -0.06398530f, -0.03856077f, 0.54916424f, 0.11173362f, 
    -0.03575772f, -0.05836081f, 0.07662582f, 0.03372252f, 0.04521115f, 0.09654931f, -0.08155596f, 0.03290471f, 
    0.02163802f, -0.07317507f, -0.04467515f, -0.10666709f, 0.11154070f, -0.04943330f, -0.13837054f, 0.00945374f, 
    0.07189903f, 0.01676780f, -0.03004228f, 0.06582350f, -0.13933353f, 0.11519101f, -0.05633131f, 0.11770533f, 
    0.04573630f, -0.04588666f, -0.01519968f, -0.06651220f, -0.03255120f, -0.02847157f, -0.13071473f, 0.09074497f, 
    0.02387157f, 0.03134406f, -0.10246319f, -0.12126176f, 0.08674169f, 0.05615446f, -0.06149741f, 0.07461029f, 
    -0.02990739f, -0.00171085f, 0.03467300f, -0.00300751f, -0.03489449f, -0.07013643f, 0.00804652f, 0.00331950f, 
    0.08772996f, 0.10812907f, 0.06189953f, -0.02687337f, -0.10045459f, 0.00652277f, -0.04971868f, -0.12537436f, 
    0.00467550f, -0.12095203f, -0.06122607f, 0.05153651f, -0.06160426f, -0.12551120f, -0.10080372f, -0.10720444f, 
    0.01419696f, -0.00192379f, 0.09028281f, -0.09347185f, 0.36513025f, 0.06950287f, -0.06194852f, -0.05984825f, 
    0.05242034f, -0.11310572f, -0.02678621f, -0.39470214f, 0.07196645f, 0.05671246f, -0.41269296f, 0.05959841f, 
    -0.04939453f, 0.34921512f, -0.07999502f, -0.11049062f, -0.32098725f, -0.00365502f, 0.12284475f, 0.05610505f, 
    -0.27974924f, -0.23951574f, -0.05907159f, 0.42916042f, 0.12347633f, 0.49308148f, 0.46708483f, 0.00348589f, 
    -0.01231305f, -0.27852878f, 0.40445331f, 0.24845427f, 0.07345246f, -0.03712095f, 0.04066928f, 0.01014528f, 
    0.07002886f, -0.07828981f, 0.05986679f, -0.24276942f, 0.23191720f, -0.02374094f, 0.06042062f, 0.16226727f, 
    0.06208777f, -0.11320063f, -0.03282410f, -0.08484900f, -0.51392299f, 0.22484556f, -0.04417397f, 0.18555501f, 
    0.05855014f, 0.21127096f, 0.06140795f, 0.16926996f, 0.38453725f, -0.49817041f, 0.19717282f, -0.36594951f, 
    -0.05024661f, 0.25682449f, 0.30670273f, -0.04516254f, 0.10698131f, 0.23150191f, 0.10471315f, 0.06090962f, 
    0.09798657f, 0.09084651f, -0.01756361f, -0.17901301f, 0.00407312f, 0.19154568f, -0.19217111f, 0.06011812f, 
    0.18296327f, 0.07714716f, 0.04380078f, -0.47112328f, 0.03998449f, -0.09149294f, -0.26483873f, 0.12399393f, 
    -0.16935596f, -0.10397059f, -0.04275692f, 0.23864059f, -0.00839155f, 0.08677400f, -0.11534043f, 0.02340052f, 
    -0.01786402f, 0.04064611f, -0.23950642f, 0.08402304f, -0.00368269f, -0.02299213f, 0.14565499f, 0.16798352f, 
    0.01481144f, 0.09284805f, -0.35063094f, 0.03136380f, 0.23904611f, 0.26236182f, 0.67255783f, -0.13220163f, 
    -0.08876307f, 0.23782285f, -0.17996359f, 0.00991453f, 0.03302244f, 0.07587053f, 0.09036104f, 0.45990661f, 
    0.13221766f, -0.04848321f, 0.05043974f, 0.04889380f, 0.00588604f, -0.08800288f, 0.33049205f, -0.09259833f, 
    0.01701238f, 0.03776128f, -0.03354240f, 0.04494786f, 0.03197330f, 0.38152108f, 0.06488828f, -0.12204612f, 
    0.14956643f, 0.16812798f, 0.04136081f, -0.27264851f, 0.27895823f, 0.05147854f, -0.01201108f, 0.21927361f, 
    -0.00078846f, 0.22259676f, 0.03141228f, -0.34303862f, -0.09155692f, -0.00980069f, -0.16728680f, -0.10127789f, 
    -0.14484161f, -0.02362264f, -0.14028864f, -0.02398349f, -0.12725385f, 0.13092528f, 0.00044104f, 0.07117577f, 
    0.18964007f, 0.07451559f, 0.14800252f, 0.02649108f, 0.13960697f, -0.05655579f, -0.04389126f, -0.00315646f, 
    -0.10886246f, 0.03605551f, -0.22329892f, 0.07341662f, -0.69078696f, 0.12088162f, 0.01589355f, 0.24702436f, 
    0.10314268f, 0.08870965f, 0.06174010f, 0.08727863f, -0.09127043f, 0.17212439f, -0.07280826f, 0.27868527f, 
    0.07609260f, 0.22537325f, 0.14343876f, 0.11631618f, -0.45288393f, 0.09227958f, 0.13624609f, 0.12923050f, 
    0.01074658f, 0.35329178f, -0.14573430f, -0.09803019f, -0.54682058f, -0.27535844f, 0.02422995f, 0.30613914f, 
    0.03102913f, 0.12267340f, 0.09454455f, 0.20779109f, -0.20866160f, -0.37320301f, 0.49946254f, 0.26926216f, 
    -0.41297013f, -0.13324220f, -0.02245564f, 0.43084139f, 0.23784956f, 0.05497438f, 0.38924822f, 0.23974761f, 
    0.34638411f, 0.01709533f, 0.21220119f, -0.12746359f, 0.16285442f, -0.14027478f, 0.02962025f, -0.09763138f, 
    0.01576195f, -0.00381537f, -0.03312280f, -0.11760510f, 0.10018423f, 0.10262819f, 0.03292444f, 0.07823236f, 
    -0.03311035f, -0.11562781f, -0.14634871f, 0.11891474f, 0.18496074f, 0.19331165f, 0.20116025f, -0.02428365f, 
    0.24084562f, -0.21684361f, 0.28562266f, 0.12773855f, -0.09982952f, -0.02383609f, -0.10430108f, -0.27408281f, 
    -0.42733812f, 0.02913405f, -0.50296062f, -0.04383206f, -0.15373543f, -0.20992136f, -0.00686361f, 0.15109274f, 
    0.28453648f, 0.00687847f, -0.35898158f, -0.11660336f, 0.28108668f, 0.66771442f, -0.03808935f, -0.06972390f, 
    0.11327782f, -0.19822842f, 0.17371903f, 0.41713405f, -0.14614740f, 0.35382363f, -0.08277072f, 0.11569969f, 
    -0.08152006f, 0.29332018f, -0.57875180f, 0.07904220f, -0.04419773f, -0.09945849f, 0.07120421f, -0.10461873f, 
    0.19369982f, -0.09411477f, 0.15532577f, -0.04153568f, 0.17445186f, 0.04710305f, 0.15711783f, 0.03133057f, 
    -0.22425921f, -0.01866224f, 0.23342758f, 0.29255897f, 0.07704853f, 0.13435346f, -0.23292337f, -0.16149387f, 
    0.02978587f, 0.00485183f, 0.42950591f, 0.12424824f, 0.57620090f, 0.01897500f, 0.12233384f, 0.28881821f, 
    0.32852793f, 0.17580849f, -0.09955543f, 0.08852945f, -0.55850464f, -0.79029733f, -0.05669525f, 0.26014572f, 
    0.01527486f, 0.31162992f, 0.04969672f, 0.12463707f, -0.04141193f, 0.11285850f, -0.21117313f, -0.45281953f, 
    -0.10580345f, 0.13122912f, 0.21735592f, 0.10439844f, -0.15835814f, -0.20007841f, -0.07310745f, -0.10020179f, 
    -0.07132373f, -0.00794106f, 0.05621045f, 0.34006879f, -0.36544827f, -0.21012339f, -0.02020838f, 0.28712642f, 
    -0.19695367f, 0.00335310f, 0.04728569f, -0.34030104f, 0.09247250f, -0.03830675f, 0.05185620f, -0.07802524f, 
    0.14271718f, 0.01077627f, 0.19599317f, -0.31150192f, 0.05768369f, 0.10345238f, 0.35857955f, -0.08758034f, 
    0.01567365f, -0.12992455f, 0.05411716f, -0.26226529f, 0.07432657f, 0.23865710f, 0.12305181f, -0.26712766f, 
    0.00606999f, 0.08582322f, 0.50249219f, -0.01250313f, 0.47027957f, -0.03552596f, 0.29503226f, 0.22696039f, 
    0.09481293f, -0.06354953f, 0.31498858f, 0.26708007f, 0.10179567f, 0.08675685f, 0.04498419f, -0.25689155f, 
    -0.21998222f, 0.06593850f, -0.04773936f, 0.00788866f, 0.34176797f, 0.11877830f, 0.25931329f, 0.02579898f, 
    -0.43505090f, 0.31347203f, 0.02414706f, 0.02913842f, -0.30331421f, -0.04845145f, -0.09472595f, 0.00617510f, 
    -0.17520165f, 0.41326499f, 0.09094310f, 0.02366309f, 0.06590603f, 0.19067760f, -0.09604247f, 0.58018470f, 
    -0.07150651f, -0.00879852f, 0.06327049f, -0.68796104f, -0.08056089f, -0.02809456f, -0.01208343f, -0.07961866f, 
    0.18458940f, -0.05095863f, -0.02106644f, 0.02220969f, 0.06259881f, 0.04959975f, -0.11238994f, -0.03022319f, 
    0.04804247f, 0.17498605f, -0.05533046f, -0.00650429f, 0.18959261f, -0.04477526f, 0.00493394f, -0.12603976f, 
    0.04349817f, 0.00467500f, 0.25994369f, 0.01565306f, -0.93344533f, 0.02608950f, 0.46245024f, 0.29994610f, 
    0.24524054f, -0.17088258f, 0.08177951f, 0.01450715f, -0.15078609f, -0.10317060f, 0.04491818f, 0.05762687f, 
    -0.07133210f, 0.07825557f, 0.23442629f, 0.01975652f, -0.40271741f, 0.00950015f, 0.18091817f, 0.31271350f, 
    0.23538074f, -0.18451236f, -0.15912831f, 0.10196082f, 0.16188926f, -0.11740261f, 0.01397069f, 0.06951720f, 
    0.24124208f, 0.10089634f, 0.09998590f, -0.25747651f, 0.55323052f, 0.10572592f, 0.19471201f, -0.31226003f, 
    0.26337278f, 0.20289396f, 0.04515907f, 0.76079375f, 0.06308216f, 0.10826938f, 0.09214102f, 0.15603848f, 
    0.08561991f, -0.08353251f, 0.05424420f, -0.12665106f, -0.15455191f, 0.15278107f, -0.04689795f, -0.06977321f, 
    0.09717979f, -0.08166179f, 0.22985999f, -0.00151984f, -0.10085781f, 0.00876816f, 0.11605375f, 0.28619486f, 
    -0.08616662f, -0.10649857f, -0.11574909f, 0.01217162f, -0.12888978f, 0.00383458f, -0.41912794f, -0.12014300f, 
    -0.09544935f, 0.04141564f, 0.18249610f, 0.02674224f, -0.02748283f, -0.00065612f, -0.10201503f, 0.06912810f, 
    0.34287116f, 0.04787913f, -0.05544057f, 0.03175145f, 0.24441320f, 0.02443464f, -0.36189494f, -0.01141663f, 
    -0.05270225f, 0.31479669f, 0.41504672f, 0.10898501f, -0.18474957f, 0.12480664f, -0.02258804f, 0.05706710f, 
    -0.10381337f, -0.08980592f, 0.01834899f, 0.64074302f, -0.48048273f, 0.04074389f, -0.16887258f, 0.17008992f, 
    -0.21333157f, -0.25575832f, -0.01212164f, -0.44002447f, 0.16163798f, -0.04090863f, 0.09018191f, -0.22024119f, 
    0.20413455f, 0.08003569f, 0.33732992f, 0.23680414f, 0.38864797f, 0.03025642f, -0.12090389f, 0.02022049f, 
    -0.21376887f, 0.12788169f, -0.25934047f, 0.21134071f, 0.54754597f, 0.10026693f, 0.02923185f, 0.01310251f, 
    -0.10237192f, 0.01692152f, 0.83177954f, 0.11309911f, -0.15563112f, 0.31472641f, 0.30049270f, -0.00971725f, 
    0.09333035f, 0.20763879f, -0.30723155f, -0.17052367f, 0.09304842f, -0.06514131f, -0.05107655f, 0.03448687f, 
    -0.18277441f, -0.05151105f, -0.04248894f, 0.00323211f, -0.16727099f, 0.11881761f, 0.57327867f, -0.19131978f, 
    0.12980942f, -0.02210730f, -0.08486577f, -0.12036592f, -0.10056920f, 0.21458343f, 0.10378546f, 0.02835610f, 
    0.16950111f, -0.12793647f, -0.17146198f, -0.38738540f, 0.36544231f, 0.46466321f, 0.09285040f, -0.16681634f, 
    -0.04142031f, 0.08362493f, 0.10637716f, -0.00928777f, -0.11204343f, 0.09619465f, -0.02990365f, 0.22831322f, 
    0.01218821f, -0.17076689f, -0.26002914f, 0.44075090f, -0.18200926f, 0.14047082f, 0.02111800f, 0.03028877f, 
    0.12247190f, 0.12081888f, 0.21898550f, 0.08784750f, -0.53294045f, -0.06040054f, -0.25817710f, 0.36060154f, 
    -0.09267931f, -0.03421792f, -0.49890479f, 0.04931666f, -0.19770564f, -0.05849569f, 0.00708198f, 0.04088252f, 
    -0.03092989f, 0.14761037f, -0.23585302f, -0.28545207f, -0.24329774f, -0.02202193f, -0.02745725f, 0.52173984f, 
    0.48665681f, 0.04443131f, -0.08990914f, 0.12538637f, 0.12389402f, -0.29663274f, 0.09574816f, 0.01440677f, 
    0.50401813f, 0.33452156f, -0.28610078f, -0.07925090f, -0.34617594f, -0.33942670f, -0.05764135f, 0.28199565f, 
    0.03493207f, -0.45604327f, 0.04401266f, 0.18761717f, -0.56231666f, -0.19458933f, 0.47970611f, -0.36711326f, 
    -0.06497505f, -0.22018458f, -0.46969584f, 0.75187731f, 0.20556702f, 0.01173337f, 0.28004366f, -0.03102945f, 
    0.26613730f, 0.25282058f, 0.42543271f, -0.05767882f, 0.38955358f, -0.43262780f, 0.00068860f, 0.07572977f, 
    -0.31242806f, 0.15227321f, 0.20259364f, 0.14957374f, 0.16208093f, 0.29516259f, -0.26633564f, -0.00269122f, 
    0.03355965f, 0.04669258f, -0.16141643f, 0.06698451f, 0.53663504f, 0.28359774f, -0.52641124f, -0.05352011f, 
    -0.05409484f, 0.00163771f, -0.10742350f, 0.00966010f, 0.09141035f, -0.39405704f, 0.08361965f, -0.29428014f, 
    -0.22666039f, 0.18203045f, -0.71628910f, -0.09505384f, -0.03097178f, 0.16360652f, -0.41583988f, -0.57221699f, 
    -0.02212152f, -0.41818553f, -0.04361053f, 0.08434735f, -0.09378506f, 0.47489226f, -0.01086980f, 0.21185438f, 
    0.32336473f, 0.21232201f, 0.01909147f, -0.30214491f, -0.38781458f, 0.43484238f, -0.06221768f, -0.21849591f, 
    0.03608357f, 0.18359984f, 0.00173202f, -0.03522461f, 0.19484375f, -0.08643615f, -0.29257908f, -0.42361206f, 
    0.23927709f, -0.00616352f, -0.05741251f, 0.38061196f, -0.09955417f, -0.00332866f, -0.41711625f, -0.02668139f, 
    -0.06689105f, 0.06188871f, -0.37708074f, -0.18332204f, 0.04264596f, 0.06822692f, 0.10087401f, 0.02736843f, 
    -0.12392026f, -0.04906091f, -0.04754601f, 0.13920717f, -0.09498180f, 0.06737706f, -0.33554241f, -0.32080972f, 
    -0.42823708f, 0.11572530f, 0.21018885f, -0.17822388f, -0.06595962f, -0.22207305f, -0.00498343f, 0.45041141f, 
    -0.10887349f, -0.25006214f, -0.14404626f, -0.05042325f, -0.26895937f, 0.15725686f, 0.37105396f, -0.17222759f, 
    -0.33580631f, 0.15204710f, 0.41394737f, 0.05435215f, 0.05080343f, 0.07765620f, 0.10000512f, 0.04758954f, 
    -0.06024638f, 0.06219171f, 0.24888782f, 0.07308567f, 0.01296739f, -0.06816417f, 0.11413021f, 0.02219969f, 
    0.19517994f, 0.16399436f, -0.01641396f, -0.38519549f, -0.12797888f, -0.18362254f, -0.09172820f, 0.28007156f, 
    -0.21426496f, -0.08667719f, -0.14924172f, -0.10598113f, -0.11713185f, 0.13650836f, -0.12673782f, -0.07256986f, 
    0.00712944f, -0.06555033f, -0.29245386f, -0.02858039f, 0.37234512f, 0.07092632f, -0.16367014f, 0.30528885f, 
    0.01032674f, 0.06309867f, -0.10666697f, -0.03262878f, 0.01792284f, 0.25311801f, 0.50875676f, -0.00927113f, 
    0.01034376f, -0.06586657f, 0.12518543f, 0.16127409f, 0.02581283f, -0.14517835f, 0.03130050f, -0.18568943f, 
    0.19102597f, 0.01500337f, 0.06291605f, -0.00391621f, -0.30888790f, -0.03437428f, -0.23723723f, 0.04323670f, 
    0.11570661f, -0.59405452f, 0.29020843f, 0.09394228f, -0.03339027f, -0.34320390f, 0.00173038f, 0.19395609f, 
    0.17701519f, -0.10986302f, 0.31985569f, -0.12152417f, 0.02948253f, -0.15920870f, 0.07625718f, 0.03980899f, 
    0.23720460f, 0.18450245f, 0.03137296f, -0.19729649f, -0.03233098f, -0.00010769f, -0.35542753f, -0.29937428f, 
    0.06119170f, 0.26009482f, 0.26478249f, -0.39481777f, -0.38707772f, -0.04487625f, -0.47666496f, -0.00862788f, 
    -0.00058282f, 0.19122331f, 0.08471639f, -0.81134784f, 0.65298235f, 0.30782232f, -0.06579896f, 0.20303570f, 
    -0.06639625f, 0.01404789f, 0.23668998f, 0.24237637f, -0.44863123f, 0.15931599f, -0.74830407f, 0.00477115f, 
    -0.07721143f, 0.21684144f, 0.08945082f, -0.09428871f, 0.02643824f, -0.03611738f, 0.00049028f, 0.14361934f, 
    0.02738360f, -0.15570158f, -0.21072127f, 0.11456171f, -0.03979529f, 0.14842373f, 0.27138382f, -0.05067625f, 
    0.05497685f, -0.03494290f, 0.09607452f, 0.10059090f, -0.08452939f, 0.05451270f, 0.03816469f, -0.00716889f, 
    -0.06628543f, -0.12277547f, -0.14676853f, -0.00408660f, 0.03618919f, -0.08498688f, -0.13471907f, 0.09176140f, 
    -0.12022066f, -0.06278355f, -0.10384387f, 0.00063088f, 0.04192353f, 0.09413388f, 0.04268684f, 0.06254823f, 
    -0.01289276f, -0.09463673f, -0.04838986f, 0.01560267f, -0.10234545f, 0.01737252f, -0.08351716f, -0.10229890f, 
    -0.01660279f, -0.17494683f, 0.08021911f, 0.05609613f, 0.07345743f, 0.01218955f, -0.06212213f, -0.06908735f, 
    0.01758491f, 0.11927406f, -0.01309969f, -0.04114131f, -0.12436655f, 0.09802566f, -0.08387175f, 0.09511248f, 
    -0.01556316f, 0.02401035f, -0.10331413f, -0.08829186f, -0.02041365f, 0.02011878f, 0.02797519f, 0.06955243f, 
    -0.09195546f, 0.06768438f, -0.11302059f, -0.06494948f, 0.09621732f, -0.09342569f, 0.03470666f, -0.05382390f, 
    -0.10704362f, 0.00043050f, 0.11844739f, 0.10757586f, -0.12237509f, -0.21294346f, -0.04959777f, -0.13599645f, 
    -0.00357800f, 0.22440909f, 0.11964835f, 0.36049795f, -0.31132346f, -0.22574070f, -0.01033999f, 0.16970889f, 
    -0.09608471f, 0.02908494f, -0.00833813f, -0.06116024f, 0.08782958f, 0.00552275f, -0.03064116f, -0.13102190f, 
    0.23099099f, -0.01464298f, 0.24650082f, -0.31381229f, 0.00325157f, 0.12249959f, 0.23890078f, -0.00793394f, 
    0.04328568f, -0.08036550f, 0.13397694f, -0.14214104f, 0.16944060f, 0.32427210f, 0.15737757f, -0.27460268f, 
    -0.04861133f, -0.01958771f, 0.62661296f, -0.07536814f, 0.47116858f, -0.02472585f, 0.16184534f, 0.36195898f, 
    0.12599838f, -0.17991139f, 0.31526276f, 0.26343915f, 0.18467593f, -0.03567133f, 0.08671788f, -0.31084916f, 
    -0.37516871f, -0.01178388f, -0.00850521f, 0.02625545f, 0.18432605f, -0.03992283f, 0.19887118f, 0.10382534f, 
    -0.00912358f, -0.32137135f, -0.30381072f, 0.11276425f, 0.05686769f, 0.14318737f, -0.00677673f, -0.00576922f, 
    0.18751553f, -0.09732587f, -0.05355617f, -0.64681196f, 0.37136447f, 0.43455547f, -0.06082598f, -0.27762291f, 
    0.01980656f, 0.05020141f, -0.07509437f, 0.31470567f, -0.13051064f, 0.04402151f, -0.11226635f, 0.19793707f, 
    -0.06060092f, -0.04607218f, -0.28335917f, 0.24764176f, -0.22070669f, 0.28041729f, 0.03243276f, -0.01300581f, 
    0.18610635f, 0.11633632f, 0.34611207f, -0.09822594f, -0.55755502f, -0.04727933f, -0.04242190f, 0.34136367f, 
    0.04511845f, 0.04933947f, -0.34675103f, -0.00141042f, -0.44662473f, -0.11976623f, -0.30219060f, -0.07241267f, 
    -0.11395763f, 0.17502607f, 0.03971293f, -0.32583854f, -0.01276980f, -0.18820144f, 0.08070293f, 0.42909306f, 
    0.43946314f, -0.03402077f, -0.34253937f, 0.15537427f, 0.20319487f, -0.03664213f, 0.20130554f, -0.22826387f, 
    -0.21395503f, 0.71316814f, 0.35203335f, -0.04241931f, -0.18094163f, 0.08534248f, -0.01389690f, -0.07623603f, 
    -0.03046307f, 0.21970649f, -0.00702805f, 0.52560449f, 0.09492565f, -0.03688802f, 0.01482267f, 0.28165135f, 
    -0.16902405f, 0.07822984f, 0.16458249f, 0.08471302f, 0.07176389f, -0.14876096f, 0.17614070f, 0.31801450f, 
    0.04316626f, -0.05914139f, 0.19618754f, -0.05518217f, 0.04524633f, -0.00341795f, 0.11535685f, 0.02515084f, 
    -0.15611370f, -0.05482181f, -0.11496323f, 0.19720478f, 0.66487348f, -0.06044761f, 0.05902886f, 0.09310739f, 
    0.06749390f, -0.06648380f, 0.47266999f, -0.16818964f, -0.56221384f, 0.27001241f, 0.48984143f, -0.08178467f, 
    -0.03186344f, -0.21025266f, 0.12641507f, 0.39744437f, 0.08996014f, 0.19866896f, 0.02637655f, -0.18537627f, 
    0.09923977f, -0.08922891f, 0.07280965f, -0.04692815f, -0.12246759f, -0.04310091f, -0.36719111f, 0.22107892f, 
    -0.26776451f, -0.11951029f, -0.21266340f, -0.01489030f, -0.08724444f, -0.12054478f, -0.09974952f, 0.21785666f, 
    0.22156759f, 0.19871978f, 0.30214494f, 0.07443076f, -0.00004939f, 0.30146152f, 0.48340836f, 0.10953068f, 
    0.16976634f, -0.02698029f, -0.03021681f, -0.05591873f, -0.00159692f, 0.08289577f, 0.15054637f, 0.11172476f, 
    0.06915162f, -0.04831465f, -0.09430710f, -0.14586636f, -0.25525847f, -0.15766867f, -0.15823257f, 0.06117418f, 
    0.07757670f, 0.25693378f, -0.13864754f, -0.14504500f, -0.75206834f, 0.26204345f, -0.35232139f, 0.11716450f, 
    0.04382458f, -0.03911822f, -0.20666464f, 0.35690472f, -0.36107546f, 0.00781928f, 0.12180657f, 0.04245586f, 
    0.16314784f, 0.06618805f, 0.02865496f, 0.04902187f, 0.09999138f, -0.49215513f, 0.06626435f, 0.10650653f, 
    0.10814004f, 0.05149456f, -0.07441430f, 0.20889562f, -0.19481091f, 0.16209856f, 0.13501053f, -0.13303903f, 
    0.38220784f, 0.17076989f, -0.45614064f, 0.09199059f, -0.29465708f, 0.24407628f, -0.10557173f, 0.19881992f, 
    0.06350230f, -0.34473637f, 0.01969349f, -0.17760849f, 0.14593978f, -0.00941525f, 0.06258153f, 0.02252540f, 
    -0.47260255f, -0.08446871f, -0.47929743f, 0.11269626f, 0.07263684f, 0.14035876f, 0.22645259f, -0.18416674f, 
    0.35156527f, 0.07576498f, 0.28394210f, 0.20777257f, 0.52872896f, 0.03196558f, 0.25119162f, -0.04306853f, 
    -0.24073033f, -0.04720164f, 0.31304002f, 0.34258071f, -0.08968613f, 0.23482180f, -0.30305707f, -0.26055196f, 
    -0.10124150f, 0.11324529f, -0.03632541f, -0.10179155f, 0.28633744f, 0.04868784f, -0.26932523f, 0.39365208f, 
    0.28326309f, 0.08415049f, 0.14369750f, 0.12947141f, -0.61966169f, -0.21593419f, 0.03816178f, 0.02041043f, 
    -0.38416708f, 0.33352637f, -0.33111438f, -0.10309736f, 0.04950434f, -0.22474192f, -0.04345356f, -0.39124954f, 
    -0.02367294f, -0.09327947f, -0.24264787f, 0.07588005f, -0.03292758f, -0.00514854f, 0.07372547f, 0.16517854f, 
    0.22789915f, 0.26180643f, -0.05738657f, -0.19499676f, 0.37034541f, 0.19210851f, 0.33127609f, -0.24203238f, 
    0.25179771f, 0.28382188f, 0.03648780f, 0.37821305f, 0.07700262f, -0.16809833f, 0.07617753f, 0.16472737f, 
    0.01399406f, -0.18041603f, -0.25497249f, 0.17800656f, -0.26176935f, 0.11783522f, 0.01179701f, 0.07896332f, 
    0.04888602f, 0.09452506f, 0.17773114f, 0.15829904f, -0.34753874f, 0.10279898f, 0.04644459f, 0.34770519f, 
    -0.10075890f, 0.06937647f, -0.29993466f, 0.07209200f, -0.68228906f, -0.06793272f, -0.20788030f, -0.10180365f, 
    -0.20560221f, -0.04676492f, 0.15112838f, -0.04559311f, 0.00205861f, -0.16036777f, -0.06344882f, 0.18026528f, 
    0.25992447f, -0.11485047f, 0.01888667f, 0.05482874f, -0.36054274f, 0.07932977f, -0.27203843f, 0.08820258f, 
    0.05363701f, 0.05420502f, -0.04608553f, -0.04269826f, -0.04491628f, 0.00432404f, 0.02552909f, 0.09619960f, 
    0.02647388f, 0.05584300f, -0.14281735f, -0.07454079f, -0.07104372f, -0.03669963f, -0.03256135f, 0.08026168f, 
    -0.00917374f, -0.09187162f, -0.06204786f, -0.11236048f, -0.11969937f, 0.01459172f, 0.05838400f, -0.07834376f, 
    -0.10957400f, -0.04429356f, 0.01537490f, 0.03080720f, -0.00084077f, -0.00869306f, -0.09933736f, 0.05316676f, 
    -0.07998044f, -0.01862003f, -0.05265787f, 0.03988509f, -0.06441659f, -0.00489400f, -0.01627255f, -0.12155944f, 
    0.03719817f, 0.02591285f, -0.03415778f, -0.06641489f, -0.07817404f, -0.00206320f, -0.04254322f, -0.00732143f, 
    -0.05396229f, 0.07014788f, -0.15881284f, -0.00980749f, -0.12172870f, -0.00875031f, 0.01939765f, -0.08145272f, 
    -0.04636672f, -0.04049531f, 0.07903294f, -0.04968075f, -0.00379148f, 0.09110333f, 0.09611847f, -0.07303734f, 
    0.27448317f, -0.33221579f, -0.11994690f, 0.06797120f, -0.01517886f, 0.42887989f, -0.02432482f, 0.17939018f, 
    0.03613626f, -0.28277460f, -0.14945705f, 0.15649809f, -0.41916111f, 0.17210934f, -0.08765388f, -0.15435252f, 
    -0.05578688f, 0.05275875f, -0.04925337f, 0.17851403f, 0.03243826f, -0.06284289f, -0.06631342f, -0.37185001f, 
    0.12382379f, -0.13337407f, 0.06146703f, 0.33864835f, 0.04559120f, 0.28618154f, -0.20166615f, 0.08032566f, 
    -0.03689894f, -0.02573116f, -0.11654518f, -0.02354034f, -0.32375190f, -0.02467129f, 0.13538083f, 0.00655098f, 
    -0.08876300f, -0.04206188f, -0.08965770f, -0.01638935f, -0.19706440f, -0.34441394f, -0.37353492f, 0.05470496f, 
    -0.15263864f, -0.19968568f, 0.28982416f, -0.31208104f, 0.17583738f, -0.26993316f, -0.00527442f, 0.05300030f, 
    -0.25173780f, -0.03681096f, 0.07924727f, -0.15223131f, -0.09389607f, 0.04864825f, 0.46149838f, -0.32736549f, 
    0.09985724f, -0.12162380f, 0.13175611f, 0.06384361f, -0.10015675f, 0.00554734f, -0.04450094f, 0.14441028f, 
    0.02761806f, 0.04750015f, 0.14184263f, 0.46393427f, 0.10760022f, 0.08147474f, -0.12820010f, 0.03751902f, 
    -0.02814671f, -0.04247364f, -0.11558463f, -0.06869580f, 0.07755051f, 0.03212291f, 0.04117608f, 0.08964035f, 
    -0.08093213f, 0.06495324f, -0.05560154f, 0.04151186f, 0.03943032f, 0.00491171f, 0.06957388f, -0.11247379f, 
    -0.20712073f, 0.24054065f, 0.09517696f, 0.06449822f, -0.00786237f, 0.13767929f, -0.25407276f, 0.06206116f, 
    -0.03182290f, 0.11029039f, -0.09878371f, 0.13717555f, -0.10581381f, 0.21649531f, -0.26685318f, -0.10134376f, 
    0.19108073f, 0.33834967f, -0.33521086f, -0.29342529f, -0.15651685f, -0.01060871f, 0.09388356f, 0.19705971f, 
    -0.18287319f, 0.06467514f, -0.11410731f, 0.08378492f, -0.02235084f, -0.03845464f, 0.27004069f, 0.01170095f, 
    0.20006484f, 0.23569956f, 0.08246586f, -0.12439825f, -0.12104017f, -0.01101975f, 0.01802401f, 0.17468999f, 
    0.02753097f, 0.03230847f, -0.06599542f, -0.42485592f, -0.08766024f, 0.06476516f, -0.14354692f, 0.36137497f, 
    -0.35528138f, -0.00879664f, -0.01613792f, -0.20001096f, 0.00497410f, -0.20997536f, 0.30451316f, -0.22486317f, 
    0.13856333f, 0.24446820f, 0.17852907f, 0.37863985f, 0.39687937f, 0.26259056f, -0.01214815f, 0.11172226f, 
    0.10639553f, 0.15319158f, -0.14965762f, 0.30128002f, 0.40873960f, 0.11481423f, 0.02172212f, -0.31098151f, 
    -0.00483730f, 0.03229076f, 0.08417203f, -0.14770967f, 0.60620981f, 0.10184316f, 0.08186495f, 0.16882215f, 
    0.17434177f, 0.17412528f, 0.05830475f, -0.09642508f, -0.93685544f, 0.43349186f, -0.03205206f, 0.22601768f, 
    -0.30300108f, 0.26572391f, 0.12520735f, 0.07807883f, -0.10893911f, -0.39057463f, 0.24944533f, 0.14127298f, 
    -0.08041274f, 0.34530589f, -0.25017956f, -0.01531515f, 0.02494132f, 0.11611085f, -0.08194418f, -0.15889461f, 
    -0.45237136f, -0.19642965f, -0.05264929f, -0.24919873f, -0.56553459f, 0.16064759f, -0.54502338f, 0.37007800f, 
    -0.46673024f, -0.25017291f, -0.03159476f, -0.51718092f, -0.06867810f, 0.01738008f, -0.01370467f, 0.34116179f, 
    -0.11285286f, 0.18658286f, 0.36749306f, 0.10804693f, 0.24377447f, 0.22170271f, 0.06513665f, -0.03211142f, 
    0.13289082f, 0.21114466f, -0.19596449f, 0.20682436f, 0.03829459f, -0.29731393f, 0.13193724f, -0.68690270f, 
    0.06525761f, 0.08413185f, 0.03687837f, -0.05254889f, -0.24466388f, 0.01926057f, 0.03707620f, 0.12214911f, 
    0.17535728f, 0.12530921f, -0.46504954f, -0.19383749f, -0.07205226f, 0.25988638f, 0.00079361f, 0.14829957f, 
    0.06714543f, 0.10037426f, 0.14188217f, -0.04125153f, 0.31816471f, -0.08971158f, 0.03882774f, 0.14649430f, 
    -0.05617428f, 0.53876877f, 0.28560990f, -0.05113886f, -0.33779705f, 0.25215062f, -0.00591666f, -0.25142276f, 
    -0.17278950f, 0.16021419f, 0.01292353f, -0.19936697f, 0.12116650f, 0.17576857f, -0.25684398f, 0.45071369f, 
    -0.35758188f, -0.03644025f, -0.31645447f, -0.56102413f, -0.10337295f, -0.11954336f, 0.24673349f, 0.07914514f, 
    0.04005154f, -0.19262476f, 0.06918345f, 0.16119194f, -0.00354266f, -0.09782156f, 0.05811182f, 0.06065460f, 
    -0.56964844f, 0.01524668f, 0.14055502f, 0.27492210f, -0.48258862f, 0.03568821f, -0.91526079f, -0.04700507f, 
    0.06102358f, -0.07411519f, -0.56796938f, -0.21664137f, -0.74660063f, 0.02711140f, 0.71269166f, 0.21473722f, 
    0.21566015f, 0.18514526f, -0.45806471f, 0.42695469f, 0.13803625f, -0.44273707f, 0.03260641f, 0.17802310f, 
    -0.17840202f, 0.03141529f, 0.46405333f, 0.08276528f, -0.12710394f, 0.20825295f, -0.87989861f, 0.10671027f, 
    -0.09025246f, -0.05322408f, -0.04412468f, 0.06944920f, 0.00567657f, -0.00569591f, -0.02983336f, -0.10984636f, 
    -0.04380504f, -0.07925287f, -0.09437452f, 0.07962772f, 0.08360446f, -0.04005997f, -0.01418401f, 0.02438914f, 
    0.04858324f, -0.06179731f, 0.03424846f, -0.02728723f, 0.03303799f, 0.05961107f, -0.06584954f, -0.01424355f, 
    -0.05754162f, -0.08326127f, 0.01063389f, -0.08923866f, -0.16094428f, 0.06631944f, 0.02544128f, -0.09086779f, 
    -0.05169382f, -0.18981710f, -0.15174806f, 0.04287555f, 0.00882380f, -0.07308561f, -0.13306037f, 0.05140015f, 
    -0.01933832f, -0.07995981f, 0.14447060f, -0.10381853f, -0.10707264f, -0.20059180f, -0.12144868f, -0.05585601f, 
    -0.04134876f, 0.06051384f, 0.06057777f, 0.01648259f, -0.00722606f, -0.06170281f, -0.09751655f, -0.04189786f, 
    0.00400409f, -0.08739780f, -0.09607038f, -0.17065412f, -0.11703153f, 0.08052696f, -0.03087126f, -0.04636931f, 
    0.06956141f, 0.30194426f, 0.02269026f, -0.08561519f, -0.15561378f, 0.11372411f, 0.02343667f, 0.13193613f, 
    0.09219523f, -0.14012808f, 0.13561161f, 0.20942573f, -0.12804475f, -0.06897644f, 0.19761983f, -0.11844886f, 
    0.12875238f, 0.20317455f, 0.06799313f, 0.57889867f, 0.01316833f, -0.08149310f, 0.02074272f, -0.00065114f, 
    0.34860617f, 0.10038253f, 0.22417913f, -0.07422730f, -0.05195390f, -0.08165924f, 0.08534315f, -0.11953436f, 
    0.10607445f, -0.08770014f, -0.14174357f, -0.02233758f, 0.27479941f, 0.19035940f, 0.12229288f, -0.02877619f, 
    -0.07420643f, 0.02014038f, 0.53726912f, 0.10810908f, -0.39573494f, 0.10542844f, 0.06556884f, 0.14822155f, 
    -0.10326212f, -0.08689974f, 0.21368501f, 0.39241123f, 0.17045434f, -0.14746128f, -0.07771120f, -0.33650717f, 
    0.04259650f, 0.11034014f, -0.14369316f, -0.06245617f, 0.12611169f, 0.13796489f, -0.23981671f, -0.15660493f, 
    -0.20617747f, 0.58775014f, 0.41403151f, -0.03325407f, -0.43467960f, 0.20514680f, 0.06888682f, -0.00635872f, 
    -0.11819991f, 0.06260566f, 0.10146461f, -0.18716559f, -0.47431245f, -0.08706156f, -0.15441278f, 0.45629349f, 
    -0.46816832f, -0.21103972f, -0.06005713f, -0.57723188f, 0.15582927f, -0.21899246f, 0.11154773f, -0.14889683f, 
    0.17359670f, 0.05043887f, 0.31906974f, 0.06619781f, 0.38857093f, -0.05194305f, 0.12028287f, 0.00244968f, 
    -0.42266238f, 0.14479321f, -0.05793101f, 0.16837965f, 0.33041710f, 0.18883918f, 0.03231417f, -0.31459767f, 
    -0.02733985f, 0.05422182f, -0.18409207f, -0.05760130f, -0.21983048f, 0.11615007f, 0.57681698f, 0.13473623f, 
    0.26543024f, 0.15504831f, -0.26182467f, 0.03178395f, -0.31829157f, -0.04212693f, -0.11230890f, -0.03049366f, 
    -0.65156400f, 0.00842079f, 0.07508905f, -0.07605236f, -0.05569368f, -0.25036740f, 0.14262536f, -0.05673167f, 
    -0.11086619f, 0.10219146f, -0.07883074f, -0.09450865f, 0.09618700f, -0.03992828f, 0.12020594f, 0.03195878f, 
    -0.13570996f, -0.05651082f, -0.07621557f, -0.07956569f, -0.04597889f, -0.00336637f, -0.01603466f, -0.05380853f, 
    0.02376355f, 0.06932493f, 0.06859080f, 0.03737346f, -0.07359686f, -0.07551308f, -0.09344731f, 0.11958258f, 
    -0.09743560f, -0.13107817f, 0.00255478f, -0.08270530f, 0.05942765f, -0.08171214f, -0.12743884f, 0.07598153f, 
    0.07761069f, 0.05927266f, -0.06085110f, -0.09442734f, -0.11953159f, 0.05294799f, 0.00500548f, -0.11670975f, 
    0.07054321f, -0.04414530f, -0.04437736f, -0.02921974f, 0.09853873f, -0.08643845f, -0.05213293f, -0.07266434f, 
    -0.00596883f, 0.08963799f, 0.04125906f, -0.10373110f, -0.09212756f, 0.04181723f, 0.01095359f, -0.10242343f, 
    -0.02900402f, -0.01361372f, -0.01620233f, -0.02998616f, 0.07716215f, 0.07540254f, 0.09509617f, -0.10079323f, 
    0.08140001f, -0.04444627f, 0.08714396f, -0.07230151f, 0.14537476f, -0.13823374f, -0.02232753f, -0.31021750f, 
    -0.16689420f, 0.04854451f, -0.12330103f, 0.27785441f, -0.14824551f, -0.07129150f, -0.45726994f, 0.14940909f, 
    0.04038076f, 0.01798410f, 0.20405231f, -0.10653445f, -0.03019034f, 0.12775052f, 0.06119745f, 0.01663738f, 
    -0.04329152f, -0.02999485f, 0.18873663f, -0.10110766f, 0.06547405f, 0.14492154f, 0.13477999f, -0.07511142f, 
    0.05756841f, -0.00326765f, 0.27817145f, 0.06305196f, 0.36291245f, -0.13848837f, 0.26866555f, -0.31126487f, 
    -0.11824271f, 0.05444461f, 0.08283242f, -0.19027825f, 0.25639826f, -0.10580190f, 0.03684453f, -0.06620366f, 
    0.13801371f, -0.15593326f, 0.08894094f, 0.11447276f, 0.19496684f, 0.33288556f, 0.06165085f, 0.03055015f, 
    -0.14511418f, -0.06207589f, 0.09294716f, -0.11599156f, 0.39854783f, -0.14051774f, 0.21866879f, 0.08984090f, 
    -0.25184923f, -0.35477957f, 0.23180126f, 0.03741615f, -0.08519711f, 0.63212943f, -0.00935146f, 0.01433667f, 
    0.00453115f, 0.25866917f, 0.05201361f, 0.19741940f, 0.18464938f, 0.35759845f, -0.07911117f, 0.05508549f, 
    -0.02854320f, -0.10802966f, -0.06669141f, -0.23351108f, 0.00156922f, 0.06878272f, -0.38804644f, 0.27432641f, 
    0.07246587f, -0.18028262f, 0.04385049f, 0.09662119f, -0.25351810f, 0.04698933f, -0.53213495f, -0.09073241f, 
    0.01548217f, 0.34479639f, 0.07359885f, -0.25742188f, 0.12733938f, 0.10030302f, 0.08583533f, 0.05597966f, 
    -0.11440185f, 0.05978306f, 0.32986829f, -0.01731575f, -1.05057657f, 0.05125750f, -0.03258311f, -0.36888814f, 
    -0.12378273f, -0.03783375f, -0.16435117f, -0.12603286f, 0.17742065f, -0.11454582f, -0.06339518f, 0.25460300f, 
    0.01398208f, -0.22484669f, 0.10889310f, -0.08268118f, 0.39525747f, 0.07273676f, 0.55756348f, -0.00556828f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13511764f, -0.00495578f, 0.28909183f, 0.44728202f, 0.27153984f, 0.03652652f, -0.02516160f, 0.21422458f, 
    -0.18940189f, -0.06967278f, -0.49695179f, -0.04851987f, 0.25134692f, 0.08823961f, 0.05170313f, -0.05070689f, 
    -0.00568108f, 0.18948185f, 0.19879413f, -0.01234496f, -0.07526004f, 0.39596775f, -0.04564588f, 0.26787663f, 
    -0.14443415f, 0.14063084f, -0.22695544f, 0.32926667f, -0.01957509f, 0.12716761f, -0.07891414f, 0.03428743f, 
    -0.08247872f, 0.26106542f, 0.21653266f, 0.45338598f, 0.31266984f, 0.24560598f, 0.19493617f, 0.16316234f, 
    -0.10181532f, 0.07823718f, 0.47298056f, -0.12623502f, 0.39235365f, -0.13602479f, 0.39179787f, 0.06225872f, 
    0.17118336f, 0.20497118f, 0.17108931f, 0.02339689f, -0.06118016f, -0.01395407f, 0.07618840f, 0.14873320f, 
    -0.01171085f, 0.04178479f, -0.03089540f, 0.52776134f, 0.27207732f, 0.07213862f, -0.06398696f, 0.43972644f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.03624917f, -0.04569671f, -0.03312609f, 0.07576226f, 0.13591966f, 0.07229845f, -0.02750512f, -0.59409708f, 
    0.07214153f, 0.00205395f, 0.21600133f, 0.04765264f, -0.39466235f, 0.10370196f, -0.01405545f, -0.00807247f, 
    0.29157117f, -0.64994621f, -0.02756916f, 0.29608032f, -0.15088810f, -0.41259697f, 0.11575315f, -0.49961364f, 
    0.34081176f, -0.24703695f, 0.28214359f, -0.62370539f, 0.11518784f, 0.15222953f, -0.05284016f, 0.24363831f, 
    0.22657998f, 0.02515210f, 0.00719794f, 0.13295126f, -0.00332390f, -0.14771222f, -0.04537317f, 0.16023113f, 
    0.04178306f, 0.05131959f, -0.46182278f, 0.24258088f, -0.24046828f, -0.08146144f, 0.01844342f, 0.04031415f, 
    0.06423905f, -0.43369848f, -0.16301051f, -0.17067093f, -0.07204115f, 0.17747228f, -0.16701783f, 0.09456685f, 
    -0.53461266f, -0.07392038f, -0.04429995f, -0.08306257f, -0.19735882f, -0.02897286f, 0.02245874f, -0.38420832f, 
    0.10270967f, 0.01887095f, -0.03276093f, 0.22081661f, 0.01782703f, 0.07704407f, -0.00483111f, -0.08032377f, 
    -0.43708014f, -0.34620273f, -0.18322439f, 0.02059424f, 0.28396773f, 0.18413709f, 0.00533768f, -0.02495410f, 
    0.00445273f, -0.18020943f, -0.19557543f, 0.18756811f, -0.11546545f, 0.10798033f, -0.03898821f, 0.02663244f, 
    -0.62537140f, -0.19719335f, -0.06367707f, -0.09539707f, -0.06684208f, -0.41053542f, 0.03305241f, 0.23186439f, 
    -0.02891769f, 0.13275982f, -0.16335107f, 0.05248992f, 0.22828130f, 0.14042839f, -0.18708757f, 0.15640904f, 
    -0.49076113f, -0.11676203f, 0.40576041f, -0.02745977f, 0.22370088f, 0.02168279f, 0.16505830f, -0.53246599f, 
    0.26371321f, -0.29594514f, 0.13333911f, -0.29159376f, -0.08352537f, -0.07866966f, -0.11692620f, -0.01947116f, 
    0.32170328f, 0.39091820f, -0.07809778f, 0.13928483f, 0.27028000f, 0.00394455f, 0.08724835f, 0.18621989f, 
    -0.07090549f, -0.35721830f, -0.34834471f, 0.00548808f, -0.16048156f, 0.05806971f, -0.15583393f, 0.09512813f, 
    -0.41114703f, -0.13687219f, 0.25223228f, 0.06649581f, 0.22132109f, -0.04426621f, -0.00097205f, -0.06846772f, 
    0.16751850f, 0.22072978f, 0.03087675f, -0.24920379f, 0.05577740f, -0.14105718f, -0.52582783f, 0.50431287f, 
    -0.27509588f, -0.24259561f, -0.54779041f, 0.15970680f, -0.27764487f, 0.11779272f, -0.01790033f, -0.90196788f, 
    -0.40684947f, 0.02675156f, 0.27039120f, 0.36184397f, 0.17847456f, -0.08511838f, 0.05126089f, -0.21753025f, 
    -0.99121928f, 0.49376804f, -0.35478738f, -0.08752710f, -0.34704846f, 0.08000081f, 0.17548724f, -0.58452755f, 
    0.09804287f, -0.11616477f, 0.45745540f, -0.19330657f, -0.00043815f, -0.47783712f, -0.12665206f, 0.13682088f, 
    -0.66830808f, -0.59059739f, -0.15499268f, 0.07278646f, -0.14449461f, 0.03284044f, 0.13002124f, 0.23608381f, 
    0.12135039f, -0.39508206f, 0.11118911f, 0.14214365f, 0.06709889f, 0.00801365f, 0.04282716f, -0.14191803f, 
    0.15568294f, -0.08196422f, -0.07261860f, -0.05680127f, 0.05599100f, -0.41234705f, 0.07823274f, 0.06141552f, 
    -0.17550090f, -0.09412502f, 0.18754214f, 0.15454836f, -0.18507817f, 0.26914787f, -0.07738893f, 0.10481097f, 
    -0.05172285f, 0.03147664f, 0.21143927f, -0.00031357f, 0.17770179f, -0.11237912f, -0.07934947f, 0.20034157f, 
    -0.11109141f, 0.05629858f, -0.15619577f, 0.09153120f, 0.06498979f, -0.13491353f, 0.02204586f, -0.17618549f, 
    0.00706517f, 0.22663838f, -0.16420709f, -0.25783104f, -0.41299814f, 0.12030438f, 0.18183735f, 0.20915909f, 
    -0.43287840f, -0.30065927f, 0.22569306f, 0.00334702f, -0.07675359f, -0.24157764f, 0.04027228f, 0.16747126f, 
    0.86274236f, -0.58926135f, -0.11013888f, -0.21590784f, -0.34265071f, 0.08538783f, 0.02264499f, -0.75605994f, 
    -0.04158761f, 0.08884611f, 0.25494993f, -0.03774051f, 0.17463391f, 0.00121547f, 0.04961196f, 0.05941859f, 
    0.17126472f, -0.39785239f, 0.03371361f, 0.09650093f, -0.49233356f, 0.21004657f, 0.08193512f, -0.10933292f, 
    -0.29173183f, 0.03791002f, -0.01788598f, -0.27027565f, 0.04366992f, -0.04967616f, -0.10229016f, 0.14869088f, 
    0.25826073f, 0.28625718f, 0.02452199f, -0.29346225f, 0.00595845f, -0.99302888f, 0.07777131f, 0.10489240f, 
    0.02616191f, 0.16782595f, -0.49578068f, 0.04993724f, -0.36121920f, 0.08370575f, 0.12594804f, -0.47734448f, 
    0.27288592f, -0.56338376f, -0.59969527f, 0.02100583f, -0.06033043f, -0.11743482f, -0.29237694f, 0.26764923f, 
    0.14562680f, -0.14433247f, 0.03813097f, 0.20334968f, -0.09186793f, -0.48608842f, 0.02215553f, 0.04251560f, 
    -0.34098154f, -0.02541243f, 0.01004464f, -0.05471635f, -0.55252510f, 0.08269893f, -0.09588199f, -0.25018618f, 
    -0.21682896f, 0.12238992f, 0.07303206f, 0.12048328f, 0.07811236f, -0.10203451f, 0.02117743f, -0.22121632f, 
    -0.13741952f, 0.22938089f, 0.22891901f, -0.07225068f, -0.10109831f, -0.04622002f, 0.04557963f, 0.06919453f, 
    -0.01477382f, -0.00651680f, -0.01321648f, -0.04819422f, -0.13281417f, -0.24936688f, 0.15478231f, 0.18828586f, 
    0.04621715f, -0.24427885f, -0.17181735f, -0.07048388f, 0.08979338f, 0.01070208f, -0.09865246f, -0.08906887f, 
    0.04157915f, 0.20117296f, -0.04641141f, 0.15441592f, -0.07305272f, 0.11185282f, -0.08520322f, 0.07888274f, 
    -0.17105481f, -0.94545603f, 0.27807438f, 0.21692918f, 0.05127887f, 0.09004206f, -0.00586253f, -0.21165581f, 
    0.06068137f, 0.00272196f, 0.10079480f, 0.03340833f, -0.12966408f, 0.25817639f, 0.01986280f, 0.02692143f, 
    -0.80158514f, 0.40990549f, -0.13001621f, 0.00650294f, 0.22530721f, -0.03760371f, -0.34799412f, -0.33032182f, 
    0.17982410f, -0.53382492f, -1.27485549f, -0.19379550f, -1.05454171f, 0.00894321f, -0.03161612f, 0.19724184f, 
    -0.15223312f, 0.19070056f, -0.40596741f, -0.04705653f, -0.48236501f, 0.09000847f, -0.01601058f, -0.09549154f, 
    0.18109055f, 0.29120761f, -0.04654980f, 0.40263376f, -0.09888831f, 0.26377252f, -0.79865956f, -0.21573630f, 
    -0.16952425f, 0.07599301f, -0.15083160f, 0.35150003f, -0.95793754f, -0.04852573f, 0.06585125f, -0.25017619f, 
    -0.22792611f, -0.61424804f, 0.45546964f, -0.95299220f, 0.04365275f, -1.14673543f, 0.11850825f, 0.23306951f, 
    -0.60472113f, 0.50975871f, -0.38282317f, 0.05649549f, -0.00991732f, 0.07687370f, 0.18778594f, -0.61798543f, 
    0.31467542f, 0.01394514f, -0.16995099f, 0.01144300f, -0.07050770f, -0.26669362f, -0.07270957f, -0.78640562f, 
    -0.34560350f, -0.64309448f, 0.00907470f, 0.32907593f, -0.17380001f, 0.01520467f, -0.06325256f, -0.30882531f, 
    -0.06858647f, 0.29393822f, -0.27287090f, -0.43370476f, -0.54951006f, -0.04210335f, -0.08042332f, -0.28449032f, 
    0.30889884f, 0.03111851f, 0.22633617f, -0.06176521f, 0.00943233f, -0.01202319f, 0.05005000f, 0.04821104f, 
    -0.40250060f, -0.23110096f, -0.30700976f, -0.32936922f, 0.08449543f, 0.05228775f, 0.38353905f, -0.31928527f, 
    0.42665550f, 0.09897470f, 0.29820079f, -0.68558592f, 0.30211800f, -0.28421026f, -0.07256877f, -0.72194153f, 
    0.29664201f, -0.00394939f, -0.22085851f, -0.85976970f, -0.47890714f, -0.11207385f, 0.13216281f, -0.14594543f, 
    0.74114084f, 0.29210520f, 0.23805085f, -0.16209251f, -0.15517351f, 0.08559095f, -0.40615514f, 0.44923198f, 
    -0.08770426f, -0.10993480f, -0.37204596f, 0.23633125f, 0.01282059f, 0.43585417f, -0.06155547f, -0.58293593f, 
    -0.31986624f, -0.02763103f, -0.04610197f, -0.18834302f, -0.36078039f, -0.04907888f, 0.21267164f, -0.08136850f, 
    0.04567927f, 0.20686857f, -0.13391319f, -0.13825487f, -1.09720314f, 0.04739698f, 0.09690783f, 0.22339758f, 
    -0.08181016f, 0.11513785f, -0.19237719f, -0.02306368f, -0.17138667f, 0.14925210f, -0.05173451f, -0.11517932f, 
    0.04587195f, 0.16399933f, 0.04297398f, -0.05577608f, -0.04474467f, -0.11353091f, -0.16864750f, -0.60104579f, 
    -0.65217566f, -0.02630107f, -0.34475774f, 0.09517145f, -0.41860127f, 0.23698089f, 0.08884582f, -0.52163965f, 
    0.03571006f, 0.00149579f, 0.28247342f, -0.54683566f, 0.34212849f, 0.42347643f, -0.39462209f, 0.15066563f, 
    -0.75996089f, -0.86179811f, -0.14980443f, 0.01162174f, -0.15547791f, -0.05399365f, 0.24460001f, -0.41662443f, 
    0.22817281f, 0.12611263f, -0.26872566f, -0.15537111f, -0.10965806f, 0.08207352f, -0.08008888f, 0.24661765f, 
    0.01422376f, -0.53162432f, -0.22199777f, -0.02225827f, 0.34987372f, -0.07985824f, -0.17347097f, 0.05382591f, 
    0.03609298f, 0.09220918f, 0.07726477f, 0.08213374f, 0.24441943f, -0.10765287f, 0.00052405f, 0.22508740f, 
    0.34604040f, -0.20926212f, -0.51371944f, -0.02565337f, -0.89620990f, -0.30774122f, -0.05799450f, -0.06280503f, 
    -0.02269894f, 0.15711434f, 0.34025228f, -0.90933353f, 0.08340212f, 0.22739035f, -0.12166461f, -0.19658704f, 
    -0.59358567f, 0.23162504f, -0.81088489f, 0.00401644f, -0.31701437f, -0.03892560f, -0.01475089f, -0.31499305f, 
    -0.26499516f, 0.01701354f, 0.14109851f, -0.00567755f, -0.05273348f, 0.03300427f, 0.21936733f, -0.36985856f, 
    0.14125168f, -0.08682181f, 0.05577864f, -0.30046251f, -0.21544310f, -0.06918538f, 0.08447432f, 0.35531834f, 
    -0.19649529f, 0.11437242f, 0.04072092f, 0.24916393f, 0.01118599f, 0.20513710f, -0.25201818f, -0.19068539f, 
    -0.29703954f, 0.07243838f, 0.06952889f, 0.20261964f, -0.33504367f, 0.08195089f, 0.04852835f, 0.15052138f, 
    -0.17948422f, 0.24631466f, -0.37585837f, -0.68632931f, -0.11178600f, 0.07721182f, 0.10060633f, 0.02053658f, 
    0.19611047f, -0.01725025f, -0.12286720f, 0.06897825f, -0.56751639f, -0.53174227f, 0.09779112f, 0.00738282f, 
    -0.26201111f, -0.15762272f, -0.98143876f, -0.53613865f, 0.01734756f, -0.25482106f, 0.25256521f, 0.33175060f, 
    0.09165474f, -0.52277941f, 0.40342677f, 0.08781803f, 0.17939714f, 0.13949785f, -0.10578012f, -0.15395562f, 
    0.14600898f, -0.07110684f, -0.05950052f, 0.08567666f, -0.29320097f, -0.04248638f, -0.52058035f, 0.39742097f, 
    0.05227558f, 0.02534873f, -0.08915188f, -0.38025722f, -0.54462570f, -0.02816737f, -0.63289106f, -0.00628285f, 
    -0.31169006f, -0.06945612f, 0.19736709f, -0.30670089f, 0.03626524f, 0.18329182f, 0.27548644f, 0.36878818f, 
    0.40226814f, -0.09171617f, -0.01682365f, -0.29003847f, 0.22524634f, 0.08275530f, -0.35219035f, -0.74727529f, 
    -0.00700891f, -0.02233431f, -0.15693381f, -0.19639632f, 0.00685817f, -0.04484341f, 0.08751652f, 0.09749799f, 
    -0.24248327f, 0.46508169f, -0.15134594f, -0.02484285f, 0.43132052f, 0.01598836f, 0.03576778f, 0.05644235f, 
    0.14896230f, 0.04965342f, -0.21336757f, -0.52790564f, 0.00655658f, 0.18406080f, -0.07932046f, -0.61501539f, 
    -0.53285968f, -0.01633139f, 0.24649683f, 0.19740061f, 0.06591967f, 0.48406419f, 0.04763163f, -0.18689394f, 
    -0.02642851f, 0.00625224f, -0.34573936f, -0.05749598f, -0.15083975f, -0.31558383f, -0.03709284f, 0.01795103f, 
    -0.35568956f, -0.31866229f, -0.07429448f, 0.08934467f, 0.41867164f, 0.09424771f, -0.23050381f, 0.04568557f, 
    -0.36741889f, 0.19964270f, -0.45140430f, -0.12177872f, -0.06450317f, -0.49617124f, 0.34274384f, -0.57507485f, 
    0.40968356f, -0.98510468f, -0.02894913f, -0.11457777f, -0.75714195f, 0.04586149f, -0.35210061f, 0.03356756f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.19991341f, 0.21428892f, 0.06337145f, -0.09587130f, 0.08140706f, -0.12063921f, 0.06135499f, -0.29165083f, 
    -0.01021077f, 0.31881836f, -0.28583539f, 0.00786004f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
