#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.75378537f, 0.65611768f, 0.60905123f, -0.24577640f, 0.24428786f, -1.04156446f, -0.57204682f, -0.24675694f, 
    0.00181213f, 0.24016602f, -0.10693711f, -0.32555825f, -0.13232964f, 0.05327997f, -0.01878135f, -0.10757513f, 
    0.27453652f, 0.14699408f, -0.03557646f, -0.02840418f, -0.33673081f, 0.13576867f, 0.01154110f, 0.08328072f, 
    -0.22701108f, 0.63950413f, 0.03325606f, 0.05423019f, -0.75565118f, -0.72680581f, -0.66836739f, -0.70562291f, 
    -0.05062309f, 0.45470026f, 0.52324730f, 0.05260641f, 0.55346972f, 0.32564536f, 0.44152823f, -0.11011130f, 
    -0.13237573f, 0.25121215f, -0.20138462f, -0.14800583f, -0.31477165f, 0.09506465f, -0.14892653f, -0.05660753f, 
    0.26342422f, -0.15583576f, 0.46433920f, -0.31751722f, -0.30705649f, -0.71229208f, -0.69731355f, 0.05644359f, 
    -0.19662741f, 0.45080587f, 0.28303596f, -0.00443401f, 0.34465808f, -0.05924170f, 0.25190830f, 0.03901385f, 
    0.17128915f, 0.14712854f, -0.15921558f, 0.23425171f, -0.04133643f, -0.19475602f, 0.00483016f, -0.24798968f, 
    -0.02095185f, -0.22746511f, -0.23716256f, -1.09104609f, -0.58057135f, -0.47718611f, 0.39474371f, 0.49005851f, 
    0.09788048f, -0.06108738f, -0.24668790f, 0.31876466f, 0.75047141f, 0.03960143f, 0.06181986f, 0.01343660f, 
    0.10125855f, -0.37557980f, -0.33219934f, -0.21391478f, 0.10776846f, 0.21391857f, -0.04969015f, 0.20268427f, 
    0.08202991f, 0.08421059f, 0.13360749f, -0.06704760f, 0.62308943f, 0.75337511f, -0.00255589f, -0.01195841f, 
    -0.47421834f, -0.25606689f, -0.56079495f, 0.13873260f, 0.36385569f, -0.76276439f, 0.16502964f, -0.09444466f, 
    -0.19501887f, -0.22183335f, 0.27831572f, 0.47604361f, 0.20357749f, -0.22256167f, -0.24718218f, -0.16689929f, 
    -0.19253854f, -0.13199304f, -0.24016158f, 0.22216114f, -0.12996222f, -0.16532481f, 0.34987533f, 0.03610931f, 
    -0.25686172f, -0.41694012f, 0.69806206f, 0.00957710f, -0.37620226f, -0.07374384f, 0.50849545f, 0.05356861f, 
    0.37356392f, -0.29801601f, -0.14475328f, 0.20422171f, -0.21371366f, -0.17703502f, 0.02446936f, -0.21146290f, 
    0.11953794f, -0.04970850f, -0.08143614f, 0.49597293f, 0.30772963f, -0.31939569f, -0.63857907f, 0.95043689f, 
    -0.52216852f, -0.42595375f, -0.71952021f, 0.10829964f, 0.32487920f, 0.51239568f, -0.21947004f, -0.34895998f, 
    0.13446203f, 0.24679983f, 0.01509774f, 0.64689797f, -0.38745540f, -0.12766331f, -0.01426420f, -0.30021337f, 
    -0.38555118f, -0.34452119f, 0.43769759f, 0.16034609f, -0.03621491f, 0.05009168f, 0.24896912f, -0.61896396f, 
    0.14828335f, 0.27479312f, 0.08864328f, 0.51517016f, -0.82117379f, -0.39525029f, 0.27595434f, 0.66974533f, 
    0.36987394f, -0.40290660f, -0.21275553f, 0.08254642f, 0.25284794f, 0.16509908f, -0.06259031f, -0.00705831f, 
    0.18805517f, -0.30747274f, -0.16386253f, -0.26024625f, -0.19755037f, 0.18886405f, 0.26107889f, -0.12729405f, 
    -0.36191952f, -0.37276343f, -0.53788412f, -0.50930905f, -0.42435837f, -0.76661003f, -0.60833663f, -0.67756444f, 
    -0.94958907f, -0.88818157f, 0.35830918f, -0.06668076f, 0.15949234f, 0.44170728f, 0.38257501f, 0.03742446f, 
    -0.04038768f, -0.12804590f, 0.25332105f, -0.01827873f, -0.34118888f, -0.17716748f, 0.30018809f, 0.09917523f, 
    0.23057026f, -0.46803826f, -1.09496677f, -0.59748232f, -0.86298758f, 0.02300945f, -0.16134103f, -0.81117159f, 
    -0.59634972f, -0.30694717f, -0.38471043f, -0.31727302f, -0.03619528f, 0.06775139f, -0.23413005f, -0.38924649f, 
    0.16939187f, 0.18388334f, -0.12469918f, 0.02143578f, 0.03595600f, -0.15549748f, 0.12410755f, 0.07282544f, 
    -0.18822171f, -0.32203114f, -0.95712107f, -0.21712498f, -0.36181301f, -0.64406699f, -0.40200475f, -0.02508643f, 
    0.15365487f, 0.40819725f, 0.57774568f, 0.56136841f, 0.21639431f, 0.19505718f, -0.04984546f, 0.06243328f, 
    0.01377369f, 0.19170427f, -0.19047399f, 0.21884090f, 0.01399356f, -0.23221798f, 0.01437659f, 0.14244618f, 
    0.29651913f, -0.20875339f, -0.22011706f, 0.27636489f, -0.46867633f, 0.53422195f, -0.05726520f, -0.55291295f, 
    -0.63224018f, -0.73237002f, -0.90222609f, -0.30834767f, -0.43474063f, 0.05377068f, -0.29126745f, -0.51357788f, 
    0.25703216f, 0.55679929f, 0.18146254f, -0.40731648f, -0.16132584f, -0.13572116f, 0.09280289f, -0.08531907f, 
    0.06310330f, -0.28345609f, -0.20232350f, -0.40308577f, 0.92255735f, 0.95330447f, 0.38565892f, -0.67645174f, 
    -0.64031208f, -0.30429325f, 0.21679629f, 0.05740265f, -0.42064318f, -0.66261613f, -0.28230837f, 0.32551917f, 
    0.15560435f, 0.22866389f, 0.13075931f, -0.01073336f, -0.07798172f, 0.26499921f, -0.16812186f, 0.01028022f, 
    -0.03788190f, -0.06299794f, -0.65987384f, -0.43044564f, -0.47758964f, -1.00785291f, -0.17569160f, 0.38424706f, 
    0.67109942f, 0.71917367f, 0.35471714f, -0.39213204f, -0.62752187f, -0.18001164f, 0.29751876f, -0.35489631f, 
    0.22700965f, -0.46229953f, -0.02172448f, 0.00587642f, -0.03979668f, 0.02249355f, 0.31569085f, 0.29624122f, 
    0.40610531f, -0.26124549f, -0.09020025f, -0.11739270f, -0.11683640f, -0.40058973f, 0.26305762f, 0.25758651f, 
    0.42736328f, 0.49439847f, 0.30967298f, -0.09274065f, 0.42951691f, 0.20765923f, 0.20249119f, 0.22544695f, 
    0.08059634f, 0.28679666f, 0.20112853f, 0.04546982f, -0.19626060f, 0.02278141f, -0.28846556f, 0.08920018f, 
    0.11551037f, -0.18086953f, -0.09455822f, -0.07730983f, 0.09127627f, 0.02647647f, 0.14140521f, -1.34152567f, 
    0.87704188f, 0.43659580f, -0.85412127f, 0.46704552f, 0.37297630f, -0.03692615f, -0.21190763f, -0.05418585f, 
    -0.02894805f, 0.19383328f, -0.13770059f, -0.13562559f, -0.49548379f, -0.25186163f, 0.14286986f, -0.23778771f, 
    -0.29341474f, -0.36653334f, -0.40905419f, -0.14757513f, -0.46729335f, -0.66786540f, -0.43928501f, -1.07908046f, 
    0.70310462f, -0.64661306f, -0.78843212f, 0.08921616f, 0.66130400f, 0.31235936f, 0.74289656f, -0.31600744f, 
    -0.60936433f, -0.82769632f, 0.22730449f, 0.30002245f, 0.03253177f, -0.03568477f, -0.22252429f, 0.14564474f, 
    -0.22483911f, 0.12324812f, 0.18671736f, 0.18436465f, -0.36568812f, -0.24745829f, -0.09197985f, 0.12488119f, 
    -0.13816778f, 0.54430079f, 0.35083389f, 0.25004131f, 0.53549260f, -0.91921014f, -0.09972307f, -0.27128020f, 
    -0.09459672f, 0.10907801f, -0.49472690f, -0.05197395f, -0.31732336f, -0.00531474f, 0.41078061f, -0.42723942f, 
    -0.19347830f, -0.05896847f, -0.08773451f, -0.07830842f, 0.31376871f, 0.27868930f, -0.15119326f, -0.06316125f, 
    -0.47908059f, 0.15501752f, 0.77344787f, -0.46269774f, -0.10306510f, 0.04077367f, -0.30076331f, 0.24148005f, 
    0.02015469f, -0.14233258f, -0.29474497f, 0.31222522f, -0.13745126f, -0.06048582f, -0.07588261f, -0.10952783f, 
    0.56218517f, -0.20208718f, -0.00042912f, 0.02382587f, 0.13036695f, -0.14753009f, 0.28738561f, 0.07755843f, 
    0.26955324f, -0.03111758f, -0.47373238f, 0.56136686f, -0.22256398f, 0.43346459f, -0.48472041f, -0.55368525f, 
    -0.38766482f, 0.23188809f, 0.28427190f, -0.00023674f, 0.13259402f, -0.18606704f, -0.20030658f, 0.02812157f, 
    0.12956855f, -0.34000340f, 0.03520159f, -0.44253108f, -0.18706886f, 0.43791166f, 0.19684392f, -0.01897159f, 
    -0.37856284f, -0.25829193f, 0.23759025f, 0.51149410f, -0.58823144f, -0.11697796f, 0.09363074f, 0.08235199f, 
    0.06209011f, 0.20848820f, 0.17129663f, 0.04825715f, 0.24543859f, 0.43485245f, 0.18143763f, -0.02171730f, 
    -0.40015560f, -0.23618670f, -0.23454535f, 0.14740087f, 0.18957993f, -0.11307483f, -0.19077021f, 0.16097200f, 
    0.06022533f, -0.08077910f, 0.34868160f, -0.01147548f, 0.25706223f, -0.31480098f, -0.94124341f, -0.83602798f, 
    -0.95656991f, -0.50519037f, 0.44561124f, 0.25236142f, 0.46392787f, 0.58431709f, 0.19082859f, 0.14839266f, 
    -0.25406194f, -0.10693661f, -0.27266422f, 0.14197224f, -0.22123027f, 0.08342668f, -0.21410562f, 0.12549266f, 
    -0.39097595f, -0.41674402f, -0.02996509f, -0.29851517f, -0.23416793f, -0.10190736f, -1.29056132f, -0.70788592f, 
    0.39044571f, 0.77483588f, 0.26579055f, 0.67433566f, 0.36258921f, -0.06432062f, 0.12383863f, 0.25358894f, 
    -0.05041053f, 0.07997582f, -0.43737552f, 0.44286793f, -0.47924215f, -0.23702455f, 0.05928719f, -0.15578827f, 
    -0.23681597f, 0.09388352f, 0.03436499f, -0.28386548f, 0.04235243f, 0.34481320f, -0.17530170f, 0.60963780f, 
    -0.10318458f, -0.75770712f, -0.81832427f, -1.02231586f, 0.48176175f, 0.46524838f, -0.12293749f, -0.06003175f, 
    0.35830098f, -0.33351621f, 0.39665604f, -0.28790873f, 0.04069975f, 0.20166929f, -0.19088228f, -0.12773953f, 
    0.00417346f, -0.14186198f, -0.55854911f, -0.11807873f, 0.03811656f, -0.18238746f, 0.30388907f, 0.56366175f, 
    -0.34783414f, -0.67388827f, -0.55841607f, -0.11314937f, -0.67169482f, -0.51740944f, -0.02959432f, -0.60132325f, 
    -0.92266452f, -0.90874338f, 0.38042927f, -0.23348674f, -0.08046239f, -0.28750944f, 0.53571868f, -0.41984883f, 
    -0.22097163f, -0.41382778f, -0.47503722f, -0.43462837f, -0.14693749f, -0.25738901f, 0.16035850f, -0.26287976f, 
    -0.58989120f, -1.14956784f, -0.64653808f, 0.80013710f, -1.28836036f, -0.96533716f, 0.17704740f, -0.08527926f, 
    -0.58408105f, -0.35362846f, 0.67986584f, -0.04566531f, 0.24505822f, 0.04597828f, -0.05917276f, -0.01498120f, 
    -0.22221071f, 0.08008807f, 0.00480349f, 0.12354007f, 0.17067195f, 0.04516647f, 0.23759151f, -0.12953193f, 
    -0.06140073f, -0.10774719f, 0.09308458f, 0.98182249f, 0.59148592f, -0.84717959f, -0.26518691f, 0.00515819f, 
    -0.07019264f, 0.20197169f, -0.20926803f, -0.11207003f, 0.02371657f, -0.15865056f, 0.88710731f, -0.58601058f, 
    -0.23203960f, 0.32277948f, -0.23764041f, -0.37325302f, 0.15205850f, -0.15293987f, -0.12229276f, 0.09243531f, 
    0.08856050f, 0.03507790f, 0.05394651f, 0.02252819f, 0.52887088f, 0.52304274f, -0.31693074f, 0.20310017f, 
    -0.53216797f, 0.32957360f, 0.21823557f, -0.05220079f, -0.22718114f, -0.04587663f, 0.36016554f, 0.13104306f, 
    -0.09742681f, -0.17507137f, 0.16852635f, -0.39779657f, -0.44112343f, 0.03301860f, 0.33692396f, -0.13644622f, 
    0.28855383f, 0.20473526f, -0.38246283f, 0.21309292f, -0.50055110f, 0.01786842f, -0.74581736f, -0.74828184f, 
    -0.70465612f, -0.19208850f, 0.01598546f, 0.10176332f, -0.24353409f, -0.08114309f, 0.06803518f, 0.18631397f, 
    -0.29082161f, -0.52886754f, -0.17202814f, 0.20569244f, 0.10286485f, 0.08110946f, -0.07049085f, -0.30011469f, 
    0.13423514f, 0.00503981f, 0.20894574f, 0.35681769f, 0.79472071f, -0.29575861f, 0.03891769f, 0.27276406f, 
    0.38355565f, -0.15418476f, -0.28128764f, -0.91620612f, -0.50519270f, 0.34914780f, 0.26156247f, -0.04320244f, 
    0.00511719f, -0.00749249f, 0.24586833f, -0.11563155f, -0.14354922f, 0.26209518f, 0.02874386f, -0.16668263f, 
    -0.15186152f, 0.12716223f, 0.09832343f, 0.15223251f, 0.46308911f, 0.08823945f, -0.29685056f, -0.26994956f, 
    -0.38239378f, -0.88079429f, 0.10586996f, 0.09348226f, 0.04628283f, 0.08160462f, 0.30264884f, 0.28136611f, 
    -0.26316094f, -0.46715403f, -0.18792529f, -0.13292208f, 0.25258058f, 0.37793076f, -0.25067371f, -0.61872935f, 
    -0.02017504f, 0.09545492f, -0.11399215f, -0.39205649f, -0.45716670f, -0.12998518f, -0.58362621f, -0.62826580f, 
    -1.08584356f, -0.32026386f, 0.53745198f, -0.04374840f, 0.44706273f, 0.58548439f, 0.29939824f, 0.02259110f, 
    -0.08159134f, -0.04096038f, -0.42085299f, 0.06835184f, 0.47167546f, -0.33802667f, 0.24515721f, 0.33295557f, 
    -0.38222176f, -0.31011200f, -0.10748817f, -0.14088802f, 0.19962147f, 0.36930865f, 0.26195884f, -0.15685938f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35631406f, 0.45221597f, 0.01922244f, 0.33735925f, 0.40770033f, 0.34856594f, 0.19079323f, 0.61268550f, 
    -0.17182778f, -0.45926282f, -0.15803406f, 0.27801818f, 0.08153813f, 0.16540314f, -0.11902922f, 0.04512581f, 
    0.30309683f, 0.23019995f, 0.32491255f, 0.27360722f, 0.10479628f, -0.04109719f, 0.42773500f, 0.47895840f, 
    0.07756189f, 0.17876554f, 0.46888557f, 0.45086029f, -0.23735566f, 0.33953613f, 0.16043904f, -0.05612441f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.70280540f, 0.59350896f, 0.30428931f, -0.04907134f, -0.00419123f, -0.02116284f, -0.00098977f, -0.02731073f, 
    -0.02762914f, -0.02948754f, -0.00383832f, 0.06251979f, 0.33636874f, -0.20895220f, -0.04043810f, -0.12535216f, 
    -0.07032162f, 0.02892535f, -0.12751831f, -0.06526086f, -0.14423844f, -0.18717693f, -0.04924400f, 0.04949878f, 
    0.10520673f, -0.08681813f, -0.06256768f, 0.05533810f, 0.14070831f, 0.05236843f, -0.03174901f, -0.01282912f, 
    -0.10438890f, 0.15017821f, 0.09242340f, 0.04569036f, 0.32035536f, 0.38235882f, 0.20968188f, -0.14545141f, 
    -0.03324393f, 0.03460503f, 0.08235956f, -0.07144786f, 0.08035122f, 0.08121809f, -0.08870544f, -0.24635397f, 
    -0.26198292f, -0.44540066f, 0.15614417f, 0.06807683f, -0.22461651f, 0.01805182f, -0.11575155f, -0.17282917f, 
    -0.02325019f, -0.00163968f, -0.06502838f, 0.00039205f, 0.18879700f, -0.32203332f, -0.13526414f, 0.19050844f, 
    -0.19132605f, -0.06257653f, 0.04651496f, 0.03433065f, -0.32016957f, -0.14814420f, -0.39909640f, -0.07797489f, 
    0.16053112f, -0.45044625f, -0.18490440f, 0.05651028f, 0.07176512f, 0.13552985f, -0.23932143f, -0.25646329f, 
    -0.20224328f, -0.06021658f, -0.06257284f, -0.06913839f, -0.81815112f, 0.02419123f, 0.24899548f, -0.13588014f, 
    0.01170333f, -0.00932407f, 0.01074795f, 0.07120719f, -0.03805212f, -0.15526953f, -0.16802984f, -0.17117393f, 
    0.52182800f, 0.21952775f, -0.16311467f, -0.33769751f, 0.10101512f, 0.03073226f, -0.11451734f, 0.17048459f, 
    -0.03740097f, -0.00271846f, 0.04949754f, -0.05232832f, 0.58508188f, 0.30231011f, 0.06508016f, -0.12875275f, 
    0.16428906f, 0.25194263f, 0.23570378f, 0.06880794f, -0.03298711f, -0.02138633f, 0.02829704f, 0.00617121f, 
    0.08964908f, -0.06588364f, 0.07526978f, 0.08411370f, 0.06975336f, 0.13207828f, 0.00599934f, 0.03574059f, 
    -0.03543654f, -0.01184418f, -0.08311932f, 0.20185760f, 0.32209930f, 0.14285788f, -0.10640503f, -0.26039061f, 
    -0.05070386f, 0.07323070f, -0.04494521f, 0.02517975f, -0.01650966f, -0.06005426f, 0.03593562f, -0.05879398f, 
    -0.02578590f, -0.27121177f, 0.01657888f, 0.22769175f, 0.00852498f, 0.05325438f, -0.19697742f, -0.05730047f, 
    0.11470985f, 0.01302999f, 0.08439095f, -0.07343385f, 0.29577056f, 0.33206615f, 0.01500304f, -0.21641511f, 
    0.08373789f, -0.21240109f, 0.03115249f, -0.18452251f, -0.08117327f, 0.02984040f, -0.00764334f, 0.03932182f, 
    0.00205741f, -0.00170194f, 0.01174361f, 0.06215199f, 0.09270452f, 0.10032690f, 0.07374503f, 0.04514544f, 
    -0.12919718f, -0.00369286f, 0.07107688f, 0.01542726f, -0.33384386f, 0.24574377f, -0.46727428f, 0.12502606f, 
    -0.11772368f, 0.05476673f, -0.03181413f, 0.09177891f, 0.01717428f, 0.10365950f, 0.24283548f, 0.23899773f, 
    0.25808617f, -0.23242955f, -0.51934785f, 0.18970734f, 0.08648337f, -0.31614086f, -0.11836891f, -0.05855415f, 
    -0.13832779f, -0.05269925f, 0.07153879f, 0.04678390f, -0.15487482f, -0.25918722f, 0.03452356f, -0.43912339f, 
    -0.00344768f, 0.05421137f, -0.25790861f, 0.04195171f, -0.03169886f, -0.01567518f, 0.01888225f, 0.03144494f, 
    -0.14930703f, -0.03548972f, -0.03228081f, 0.09267627f, -0.10925587f, -0.06815494f, 0.06240135f, 0.01849049f, 
    -0.07150015f, -0.02986371f, -0.08143171f, -0.05990396f, -0.29990414f, -0.29415354f, 0.07455350f, 0.24788164f, 
    0.07623313f, 0.04156379f, -0.01952814f, -0.05591639f, 0.00733752f, -0.04561831f, -0.06056176f, -0.06622457f, 
    -0.03337153f, 0.03572622f, 0.03603074f, 0.00178226f, -0.13395196f, -0.05340690f, 0.04320361f, 0.03038314f, 
    0.01338986f, 0.05851523f, -0.06700519f, -0.16521311f, 0.41151473f, -0.06226376f, -0.15207860f, -0.10018284f, 
    0.18110195f, 0.26626047f, -0.00221064f, -0.14790280f, -0.00620595f, 0.10595297f, 0.00205851f, 0.12011474f, 
    0.72085977f, -0.36254996f, -0.03995321f, -0.36137769f, -0.01699273f, -0.01148741f, 0.04171319f, 0.05653376f, 
    -0.05944384f, -0.05198703f, -0.21864839f, -0.26332158f, 0.06267563f, -0.18897921f, -0.30142078f, 0.10884468f, 
    0.08006701f, -0.00358859f, -0.30079362f, -0.44040188f, -0.15908802f, -0.15371071f, -0.02167376f, -0.13486460f, 
    0.37603995f, 0.17028324f, -0.08331339f, -0.22217233f, 0.19797413f, 0.00038129f, -0.08939955f, 0.06989274f, 
    -0.14384076f, -0.12709527f, -0.12417571f, -0.06734458f, 0.39150360f, 0.10616924f, -0.02008632f, -0.20869008f, 
    0.06546988f, 0.19092467f, 0.13518295f, -0.00248119f, 0.09656304f, -0.03905264f, 0.05670029f, 0.09067563f, 
    -0.43231305f, -0.93922567f, -0.66215789f, 0.25025561f, 0.01111593f, -0.05345946f, 0.03969875f, 0.03872839f, 
    -0.00972175f, -0.12715913f, -0.11027356f, 0.10367317f, -0.92303675f, -0.40615818f, -0.12341174f, 0.08500910f, 
    -0.00881675f, -0.01998365f, 0.00655017f, 0.08153228f, -0.09152114f, 0.01670485f, 0.09279592f, -0.05527880f, 
    0.31265259f, 0.22739801f, -0.07511467f, -0.06423260f, 0.20547822f, 0.15024792f, -0.07685067f, 0.07464977f, 
    -0.00070738f, -0.03783556f, 0.02630888f, -0.00722062f, 0.09392487f, 0.16850308f, 0.15668984f, -0.25974858f, 
    -0.09611493f, 0.04750757f, -0.09731512f, 0.15560798f, 0.02710271f, -0.15766771f, -0.01484407f, 0.04304306f, 
    -0.02554392f, 0.12596333f, -0.06579309f, -0.07339672f, -0.01826624f, 0.17517187f, -0.13327579f, -0.26323861f, 
    -0.00761556f, -0.10829573f, 0.12130837f, 0.02793388f, 0.31938270f, -0.14139657f, -0.30671123f, -0.13324289f, 
    0.19725996f, -0.01398881f, 0.02889948f, -0.03214526f, -0.01117582f, 0.11321840f, -0.12001329f, -0.06507776f, 
    0.39631790f, -0.00645900f, 0.24584775f, -0.01359670f, 0.02675057f, -0.08419389f, -0.14239126f, 0.02741820f, 
    0.02227337f, 0.04603074f, -0.01375323f, 0.00145185f, -0.38559243f, -0.70436531f, 0.10179523f, -0.22560747f, 
    0.05935745f, 0.11699986f, -0.01652509f, 0.00808144f, 0.26114771f, 0.05235498f, -0.12223161f, 0.09300252f, 
    -0.03481557f, -0.23188141f, -0.03723647f, -0.24252176f, -0.01857152f, 0.09963123f, -0.02034350f, -0.00836958f, 
    0.09210997f, -0.01562121f, 0.05335961f, 0.07431759f, -0.17595994f, 0.19676267f, -0.23984000f, 0.00703905f, 
    -0.14045621f, 0.07769568f, 0.11442627f, 0.04114607f, -0.12664600f, -0.04651913f, -0.18470067f, 0.02100741f, 
    0.01502398f, -0.15237281f, 0.30727366f, 0.15214270f, 0.14484531f, -0.08536489f, 0.21020773f, -0.23252991f, 
    -0.04242338f, 0.08371429f, -0.07713130f, 0.04346070f, 0.17594862f, 0.18878387f, 0.12439772f, -0.25059077f, 
    -0.10110886f, -0.04216380f, 0.06743649f, 0.14984442f, 0.07971576f, -0.13476828f, -0.09868361f, -0.28462481f, 
    -0.54562545f, -0.66139573f, 0.00136939f, -0.17354949f, -0.15371816f, 0.03017505f, 0.08823857f, 0.10408757f, 
    0.03728916f, -0.20491363f, 0.07134987f, 0.14763689f, -0.47273952f, 0.19619516f, 0.18751697f, 0.05446192f, 
    0.07157297f, -0.07144388f, 0.02569038f, 0.02030276f, 0.23088071f, 0.17406416f, -0.00906682f, 0.07402921f, 
    -0.13717325f, -0.08811624f, 0.32333297f, 0.06982963f, 0.00279203f, -0.01503204f, 0.19129682f, -0.11840326f, 
    -0.04021041f, 0.01903444f, 0.06362104f, 0.01506062f, 0.11335715f, 0.30820653f, -0.01259175f, 0.43206015f, 
    -0.05064735f, -0.01074846f, -0.14780857f, -0.30659944f, -0.04937837f, 0.02885571f, 0.02982930f, -0.02574313f, 
    -0.21135126f, -0.03942367f, -0.03926624f, -0.12357950f, -0.05499526f, 0.05036652f, -0.09999762f, 0.06914034f, 
    -0.13259737f, -0.00779008f, 0.06438088f, -0.05428124f, -0.20296584f, -0.22312923f, -0.12306838f, -0.33981586f, 
    0.08051258f, -0.16258147f, -0.15412040f, 0.28566074f, 0.04577208f, 0.08068102f, 0.14323626f, -0.05262027f, 
    0.26287284f, -0.16926527f, -0.06371237f, -0.18607467f, 0.19099534f, 0.04268473f, -0.25209704f, 0.15430342f, 
    -0.00936047f, -0.01943157f, -0.25863147f, 0.07287395f, -0.03990149f, 0.09553571f, -0.06653632f, -0.01187551f, 
    -0.08678248f, 0.07244603f, -0.07872170f, 0.31035882f, 0.24923822f, -0.01085850f, 0.03797055f, -0.00227227f, 
    0.19114134f, 0.17426597f, 0.20617433f, 0.18330064f, -0.01204829f, -0.00327794f, -0.04670874f, -0.10705694f, 
    -0.04053783f, 0.05913883f, 0.04571629f, -0.03435572f, 0.10817444f, -0.07611106f, 0.11220618f, 0.03596945f, 
    0.05654668f, -0.03873749f, -0.13699357f, 0.12951651f, -0.62380463f, -0.15616123f, -0.38746274f, -0.24500047f, 
    0.23661384f, -0.02382303f, -0.28456584f, 0.03121241f, -0.19997767f, 0.22692496f, 0.14076951f, 0.00769946f, 
    0.12753598f, 0.16298202f, 0.06485862f, 0.18134381f, 0.26209417f, 0.23778620f, -0.07494182f, -0.44686073f, 
    0.05425119f, -0.22337061f, -0.20731084f, -0.05551318f, 0.05563846f, -0.09143581f, 0.03095624f, -0.09863433f, 
    0.33710319f, 0.06391066f, -0.04106318f, 0.08954868f, -0.00151325f, -0.03362935f, -0.06168333f, -0.02246124f, 
    -0.13260405f, 0.01907646f, 0.08870888f, -0.09500386f, 0.43077400f, 0.08836617f, 0.11019371f, -0.14353332f, 
    -0.19772099f, 0.08016655f, 0.08466512f, -0.06828327f, 0.09562400f, -0.10301645f, 0.10169949f, -0.07133791f, 
    -0.05426254f, 0.11726777f, 0.08679102f, 0.00708937f, -0.01627817f, -0.01467084f, 0.02475185f, -0.04128164f, 
    -0.04967686f, -0.13449806f, -0.14813429f, 0.24165344f, 0.12976898f, 0.28413939f, -0.12922782f, 0.05168789f, 
    0.02715186f, 0.13210565f, -0.09206273f, -0.36203128f, 0.10465049f, 0.05229674f, -0.17622411f, -0.16084684f, 
    0.31559500f, -0.03556810f, 0.12251874f, 0.04028575f, -0.08303005f, -0.00722065f, 0.03478906f, -0.00305985f, 
    0.16175871f, -0.05070684f, -0.08881194f, -0.06198250f, 0.45957744f, -0.30512390f, -0.04056130f, -0.33148798f, 
    0.15531892f, 0.16270693f, 0.10199817f, 0.06871116f, 0.04087409f, 0.16557387f, -0.10260837f, -0.05092739f, 
    -0.14206783f, -0.15649749f, 0.36645406f, -0.31231788f, 0.08467051f, 0.02951120f, -0.01880653f, 0.21761759f, 
    0.05585716f, -0.03428578f, 0.02611506f, 0.05535745f, 0.03387524f, 0.03828987f, 0.12643585f, 0.10084356f, 
    -0.07755206f, 0.17440997f, -0.45946780f, 0.18634312f, -0.14721738f, -0.01622000f, 0.10426863f, 0.06561595f, 
    0.52608931f, -0.14843531f, 0.38694167f, -0.02390012f, -0.05697270f, -0.01373964f, 0.11282557f, -0.06236563f, 
    -0.09746164f, -0.02722838f, 0.09918923f, -0.02042813f, 0.71925598f, 0.03242234f, 0.31476587f, 0.00646603f, 
    -0.07175910f, -0.12045627f, 0.00185045f, -0.00433941f, 0.00035229f, 0.03127685f, -0.03813196f, -0.00824361f, 
    0.22564951f, 0.36195660f, 0.28186673f, -0.14672706f, 0.01637424f, 0.20003748f, 0.07338511f, -0.17967564f, 
    -0.04029155f, 0.04056381f, -0.13666770f, -0.02611652f, -0.33095899f, 0.04029569f, -0.04888271f, -0.03738224f, 
    0.15085906f, -0.32051799f, 0.06876266f, 0.15308660f, -0.15951566f, -0.10475518f, 0.10650952f, 0.09335771f, 
    0.13788876f, 0.06182441f, 0.04323068f, 0.12721597f, 0.11617297f, 0.08287282f, -0.21470505f, -0.17324015f, 
    -0.32727870f, -0.00635902f, -0.21099283f, -0.30006576f, 0.09313679f, -0.21056361f, 0.40468132f, -0.06331168f, 
    -0.09205206f, 0.01243575f, 0.07531338f, -0.02530818f, -0.02563211f, -0.31624854f, 0.11466803f, -0.19364531f, 
    -0.76151860f, -0.38376546f, 0.64707053f, 0.05627993f, -0.00725676f, 0.07395212f, -0.05109662f, 0.02081979f, 
    -0.00407276f, -0.05905083f, 0.01671710f, -0.00620417f, -0.18798847f, 0.47889456f, -0.14200224f, 0.17205615f, 
    -0.11523581f, 0.07535397f, -0.09159533f, -0.34377855f, 0.04449885f, 0.06161299f, -0.16532890f, 0.21565722f, 
    -0.11196748f, 0.35746256f, 0.08461925f, 0.09509139f, -0.06966574f, 0.02736733f, 0.10261986f, -0.15906985f, 
    0.10735460f, 0.11381299f, 0.14408407f, 0.08684500f, 0.05566291f, -0.21887456f, -0.14249754f, 0.22302260f, 
    0.23392530f, -0.00616133f, 0.08776153f, 0.15604746f, 0.19541357f, -0.11721663f, 0.10789608f, -0.10903364f, 
    -0.47575402f, -0.10460762f, 0.12336745f, 0.02361286f, 0.01052749f, 0.06232843f, 0.05566828f, -0.30257708f, 
    -0.02887480f, 0.06136455f, -0.20637582f, 0.17609820f, 0.16399738f, -0.17493895f, 0.26008612f, -0.11552156f, 
    0.23284064f, -0.08784308f, 0.00555583f, 0.03515056f, 0.11687119f, 0.13664581f, 0.03164075f, -0.13627018f, 
    0.15362063f, -0.27109903f, -0.07885300f, -0.11147185f, 0.00937229f, 0.00018448f, -0.00324739f, -0.10017713f, 
    0.10110220f, -0.48773015f, -0.07965882f, 0.07105002f, 0.01281521f, -0.02221527f, -0.15488414f, 0.14075993f, 
    -0.03431825f, 0.00741694f, 0.08919088f, 0.05149981f, -0.09577134f, 0.00268632f, 0.03239447f, -0.07419129f, 
    -0.87482792f, -0.82440311f, -0.26467979f, -0.31920707f, -0.06959194f, -0.03644149f, -0.01131490f, -0.33872437f, 
    -0.07019334f, 0.05253382f, 0.03697784f, -0.04284884f, -0.97594655f, -0.37876385f, -0.26312143f, 0.04146909f, 
    -0.10667998f, -0.33192530f, -0.05294618f, -0.07440341f, 0.02659152f, 0.00952174f, -0.04655572f, -0.00854888f, 
    0.10305202f, 0.33666044f, 0.07961624f, 0.15823826f, -0.01780250f, 0.00298745f, 0.07277118f, -0.11101556f, 
    -0.16626792f, -0.05129119f, 0.04007722f, 0.11266952f, -0.48694310f, -0.04189581f, 0.22817932f, -0.07493088f, 
    0.15034254f, -0.01989113f, -0.24138714f, -0.13985778f, 0.04858969f, 0.05971687f, -0.07028165f, 0.00436759f, 
    -0.08356386f, -0.07757596f, 0.12865068f, -0.46273687f, -0.02135197f, -0.17575170f, -0.34839794f, -0.11929445f, 
    0.05528110f, 0.05506176f, -0.05439115f, -0.10984854f, -0.00759307f, 0.13012120f, -0.21660639f, -0.10689176f, 
    0.17790292f, 0.10916141f, -0.10032872f, 0.15815142f, 0.02015711f, 0.08757972f, 0.03820524f, -0.00704793f, 
    -0.24522886f, -0.04423291f, -0.02783128f, 0.04768264f, -0.05775579f, -0.01751584f, 0.05031128f, 0.08801219f, 
    -0.04944630f, -0.09442801f, 0.05250615f, -0.12219016f, 0.24622157f, -0.12460305f, 0.05553882f, 0.06884423f, 
    -0.01927419f, -0.12939571f, -0.00087195f, -0.01122556f, 0.07188373f, 0.18513751f, 0.19504383f, 0.24170670f, 
    -0.11654579f, 0.00007795f, 0.07124782f, -0.19486606f, -0.32369736f, -0.19470499f, 0.01644788f, 0.21417083f, 
    0.08015023f, -0.03695721f, 0.03894308f, -0.20986721f, -0.63725948f, 0.37060559f, 0.02587555f, -0.41410440f, 
    0.01327445f, 0.00634773f, -0.22341464f, 0.08246937f, 0.04456046f, 0.00585749f, -0.01154477f, -0.01438835f, 
    -0.17407341f, -0.06348546f, 0.05602581f, 0.09526755f, 0.05611296f, 0.05553840f, 0.03925993f, -0.06557632f, 
    0.00942404f, -0.00486125f, 0.02605988f, 0.02208054f, -0.02520051f, 0.31883782f, -0.08997937f, -0.08762445f, 
    -0.17641063f, 0.07517644f, -0.03941222f, 0.08232753f, -0.09811728f, -0.06606828f, 0.10637634f, -0.17801282f, 
    0.04190807f, 0.00103506f, -0.02500055f, 0.02707309f, 0.09828242f, -0.01816487f, -0.06054310f, 0.07353858f, 
    0.12573440f, 0.03603846f, -0.29242426f, -0.08809405f, -0.34218144f, 0.80336618f, 0.41307804f, 0.32910961f, 
    -0.09409209f, -0.03940926f, 0.09300164f, 0.11197297f, -0.06228048f, 0.00027868f, -0.05014039f, -0.12957534f, 
    -0.09938064f, -0.12768783f, 0.02458867f, 0.04934537f, 0.01308326f, -0.01713941f, 0.06653219f, 0.08656882f, 
    -0.10039505f, -0.07045183f, -0.00108632f, 0.01058745f, 0.08038426f, 0.47115901f, 0.54910600f, -0.12582508f, 
    0.05833719f, 0.10745775f, -0.16089502f, 0.00612227f, 0.00160535f, 0.01673606f, -0.15970989f, 0.12539479f, 
    -0.51204801f, -0.12303601f, 0.38281426f, -0.11765118f, -0.04362261f, -0.04506180f, 0.05435260f, -0.10828875f, 
    -0.05132350f, 0.01875010f, -0.04546649f, 0.01020638f, 0.90760547f, -0.02650223f, 0.18193522f, 0.72952014f, 
    -0.12995185f, 0.09213658f, -0.25949392f, 0.29428798f, 0.08008050f, 0.08373606f, -0.01416022f, -0.00765390f, 
    0.24296123f, -0.27314872f, 0.31240380f, -0.26493901f, 0.01225595f, 0.03678301f, -0.01019458f, 0.08841716f, 
    0.03936415f, 0.01896958f, 0.19948214f, -0.04173466f, 0.29118052f, -0.15347736f, -0.20011434f, -0.14371702f, 
    -0.02336672f, 0.10471455f, 0.05875408f, 0.02825344f, 0.02877126f, 0.04028428f, -0.05366302f, 0.10822614f, 
    -0.28553253f, -0.00931698f, 0.15943323f, -0.35725102f, -0.17771955f, 0.06458900f, 0.08725087f, -0.21417926f, 
    -0.10339505f, -0.10138030f, -0.06651679f, 0.03589462f, -0.06403103f, -0.14652541f, 0.10107865f, -0.02523443f, 
    -0.11954178f, 0.01227176f, -0.19434993f, 0.19021012f, 0.06684596f, 0.01723024f, 0.02841512f, 0.01195186f, 
    0.06321713f, 0.15416969f, 0.18346490f, 0.38146830f, -0.01187055f, -0.00772692f, 0.15322693f, 0.09492318f, 
    0.16649011f, 0.07763667f, -0.04202566f, 0.20046709f, 0.00227671f, -0.42983201f, 0.46433043f, 0.11632671f, 
    -0.10998526f, 0.07680711f, 0.07052872f, -0.04250978f, 0.12505983f, -0.27071288f, 0.11409145f, -0.10972348f, 
    -0.10066511f, -0.54994661f, 0.37092233f, -0.12513651f, -0.43504035f, -0.09579220f, -0.23124687f, 0.07700570f, 
    -0.05637292f, 0.00298932f, 0.09827867f, -0.02258075f, -0.14462227f, -0.11700669f, -0.03182207f, 0.07119106f, 
    -0.00352576f, -0.19809099f, 0.06955270f, 0.05241932f, 0.03735109f, 0.04601322f, -0.07646608f, 0.07410711f, 
    -0.25956863f, -0.12914942f, -0.03298753f, 0.20123836f, -0.00683184f, 0.23358220f, -0.08530102f, 0.06919989f, 
    -0.10837525f, 0.04029260f, 0.06670298f, 0.02501731f, 0.05506455f, -0.03875861f, -0.00431637f, -0.60253799f, 
    0.29919001f, 0.21311235f, -0.05742532f, -0.08492132f, -0.15662605f, -0.13268697f, -0.14799923f, -0.11550485f, 
    -0.09357640f, -0.64932722f, 0.37804824f, -0.16182065f, -0.18462688f, -0.16584362f, -0.13034099f, 0.09778736f, 
    -0.07385013f, 0.11206478f, -0.00856918f, -0.01287531f, -0.24442661f, -0.28544420f, -0.25878781f, -0.09606124f, 
    0.23925535f, 0.09110053f, 0.16002963f, -0.22030985f, -0.10668096f, -0.05329985f, -0.12763457f, -0.00008393f, 
    0.08388055f, -0.10035548f, 0.01501603f, 0.44212618f, 0.11799410f, -0.23791938f, -0.00596328f, 0.05990987f, 
    -0.08904865f, 0.22770891f, -0.07242868f, 0.02904562f, 0.62420976f, 0.00433322f, -0.22591831f, -0.67925894f, 
    -0.13106318f, -0.18263970f, -0.04384203f, -0.03792682f, 0.12957947f, -0.09989013f, -0.07770249f, -0.09049319f, 
    0.02963930f, -0.36467111f, -0.11771708f, 0.23078577f, 0.08351596f, 0.23148118f, 0.09644359f, -0.08742423f, 
    0.16226822f, -0.20334418f, -0.03156276f, -0.21369690f, -0.20852040f, -0.15279254f, -0.26533410f, 0.16192922f, 
    -0.00294338f, -0.04996134f, 0.02822314f, 0.06999663f, 0.03276668f, 0.08968211f, -0.08204790f, -0.01846426f, 
    0.96750319f, 0.01152941f, 0.05081887f, 0.39003736f, 0.14823908f, 0.27990121f, 0.14353986f, -0.08833787f, 
    -0.09179897f, -0.05491201f, 0.07197646f, -0.05741717f, -0.03268525f, -0.30465052f, 0.15709984f, 0.24433881f, 
    -0.06125056f, 0.15995416f, -0.01855347f, 0.14067014f, 0.06516995f, -0.09893017f, 0.12346305f, -0.09843236f, 
    -0.09336931f, 0.00233450f, 0.52367300f, 0.10232987f, -0.18282597f, -0.07384939f, 0.03588583f, 0.04726786f, 
    0.13258100f, 0.05965930f, 0.02942171f, 0.11874777f, -0.14235407f, 0.75937766f, -0.14249073f, 0.08043654f, 
    -0.15834507f, 0.12610818f, -0.03949793f, 0.02992792f, 0.11127020f, 0.05685762f, 0.01733365f, 0.16202343f, 
    -0.42288971f, -0.30138153f, -0.05120522f, -0.18739773f, 0.03190742f, -0.34356740f, -0.10571509f, -0.00857422f, 
    -0.00324977f, 0.08152051f, -0.07789866f, -0.07027674f, 0.51494169f, -0.12446993f, 0.04455191f, -0.10501425f, 
    -0.03467839f, -0.03311573f, 0.02569123f, -0.08121731f, 0.00864339f, 0.13884526f, -0.04073286f, 0.06105924f, 
    -0.15146351f, 0.61319387f, 0.03441916f, 0.59629905f, 0.26823860f, -0.24981494f, 0.15050714f, -0.29459074f, 
    0.03320955f, 0.05269351f, 0.15984853f, 0.06190220f, -0.19599786f, -0.39318886f, 0.20613287f, 0.07006953f, 
    0.17874770f, 0.01258149f, 0.03869211f, -0.10618574f, 0.03935673f, 0.06557603f, 0.00475357f, -0.11065799f, 
    -0.99547350f, -0.27684587f, -0.19166049f, -0.05777338f, -0.05875049f, 0.05041317f, -0.18943977f, -0.32082245f, 
    -0.01893762f, -0.01921227f, -0.08068140f, 0.12546417f, -0.65984315f, 0.00009341f, -0.16386601f, 0.10178329f, 
    -0.05880281f, -0.14908069f, 0.03157345f, -0.15239882f, 0.03362515f, -0.03201910f, 0.20417708f, -0.26004088f, 
    0.30052033f, 0.00880480f, 0.04708442f, -0.16679296f, 0.33807251f, 0.11293724f, 0.03401750f, 0.01312615f, 
    -0.19430624f, 0.13596287f, -0.08539229f, -0.01317566f, -0.04457434f, -0.09471446f, -0.01155020f, 0.34029949f, 
    0.22265920f, 0.06498638f, -0.02421062f, 0.02919219f, -0.04745999f, 0.10122113f, -0.02232247f, 0.02897915f, 
    -0.75335902f, 0.87712133f, -0.18324538f, -0.63379025f, 0.43022451f, 0.27092722f, 0.04681415f, -0.03046077f, 
    -0.54894757f, 0.00659184f, -0.09713045f, -0.06188760f, -0.22889598f, -0.09835640f, 0.05261962f, 0.43703094f, 
    0.20958254f, -0.16601034f, 0.03596251f, 0.03870133f, 0.02678298f, -0.01235706f, 0.14278238f, 0.00577013f, 
    -0.08406965f, -0.18607776f, -0.03750892f, 0.15018399f, -0.04768142f, 0.01688608f, 0.19085035f, 0.09343654f, 
    -0.07955296f, -0.06007311f, 0.01085725f, -0.04762345f, 0.07523609f, -0.17873032f, -0.00671250f, 0.29263866f, 
    0.13404809f, -0.16816342f, -0.16512924f, -0.02636296f, -0.04877400f, 0.16842918f, -0.12021255f, 0.19762793f, 
    0.17474000f, 0.40406194f, 0.23334503f, -0.09818078f, -0.37774366f, 0.03661322f, -0.58911622f, -0.04850503f, 
    -0.00169581f, 0.23111188f, 0.12289789f, 0.03484102f, 0.19845740f, -0.04163994f, 0.29838604f, -0.31921721f, 
    0.01842203f, 0.00419992f, -0.43350559f, -0.05020479f, -0.11176622f, -0.25882244f, 0.16612472f, -0.06882849f, 
    0.16544840f, -0.18558484f, 0.01126709f, 0.31558263f, 0.03381279f, -0.08639301f, -0.12951618f, -0.13207279f, 
    0.03589220f, 0.12465308f, 0.04258714f, -0.01808210f, 0.17725293f, -0.02859955f, 0.08928566f, 0.00573981f, 
    -0.00521123f, -0.22286443f, -0.13384008f, -0.21486321f, -0.15859263f, 0.14534198f, -0.18788017f, 0.06475438f, 
    0.20498298f, -0.15354584f, -0.03259531f, 0.12744562f, -0.01431608f, 0.03372740f, 0.08834372f, -0.10924841f, 
    -0.07920673f, 0.04492141f, 0.03905271f, 0.03753498f, -0.25969192f, 0.48775399f, 0.08176470f, -0.21223406f, 
    0.18409391f, 0.24180561f, -0.17505063f, 0.03182121f, -0.33162776f, -0.00036442f, -0.08142656f, 0.13050842f, 
    0.22762021f, 0.01804422f, -0.32233739f, 0.26005861f, -0.09552042f, 0.04403679f, 0.15626888f, 0.01347488f, 
    0.10410068f, -0.03136151f, 0.05876250f, -0.00415853f, -0.16061248f, 0.14815228f, -0.04556395f, 0.13072842f, 
    0.02590101f, 0.05198086f, -0.15984008f, -0.22990838f, -0.07277881f, 0.09516378f, 0.09589348f, -0.20444283f, 
    -0.03401254f, 0.09595318f, 0.20696327f, 0.06332486f, 0.01971172f, -0.07396300f, 0.00721202f, -0.19871227f, 
    0.07307395f, -0.08195795f, -0.17837442f, 0.01922220f, 0.03299312f, -0.02185883f, -0.38721901f, 0.04945976f, 
    -0.22034663f, -0.01371811f, -0.14263555f, -0.10005125f, 0.02660361f, -0.08590765f, -0.17866601f, 0.02697194f, 
    -0.12782799f, 0.56817406f, -0.28200936f, -0.07148624f, -0.03678181f, 0.07260351f, -0.09186069f, 0.18742387f, 
    -0.03031881f, -0.03351784f, -0.05510722f, -0.09473500f, 0.15353169f, 0.23854762f, -0.35919103f, 0.04894558f, 
    0.20090035f, 0.01856487f, -0.01953736f, -0.02240594f, -0.11382837f, -0.49912634f, -0.01898992f, 0.20487793f, 
    0.26613292f, 0.08513956f, 0.17479469f, -0.00300818f, 0.05934504f, -0.04890342f, -0.13216880f, -0.07853975f, 
    -0.14111115f, -0.19108196f, 0.07360514f, -0.26238167f, -0.91510326f, -0.08248329f, -0.06935982f, -0.01529371f, 
    -0.02048441f, 0.02223862f, -0.02618049f, 0.04066168f, -0.19994414f, -0.22577694f, 0.01943015f, 0.08772770f, 
    0.12975733f, 0.36614329f, 0.26177052f, 0.31386504f, -0.24626926f, -0.08726999f, 0.06363226f, 0.29704037f, 
    -0.05145394f, 0.03274635f, -0.06593362f, -0.00272077f, -0.13945080f, -0.05609362f, 0.17495994f, 0.01646675f, 
    -0.16883382f, -0.00260385f, -0.13579305f, -0.01202422f, 0.07836677f, -0.01701524f, 0.06621273f, 0.02891608f, 
    0.05635303f, 0.08475845f, 0.03426500f, 0.02338395f, -0.02408360f, 0.01718954f, 0.05152873f, 0.01512408f, 
    0.22421679f, -0.12407667f, 0.01411858f, -0.00735310f, 0.05820649f, 0.30839354f, 0.01570258f, 0.06894583f, 
    -0.05690671f, 0.12744185f, 0.12709783f, -0.10084984f, -0.11457403f, -0.00526257f, -0.07711156f, 0.00877537f, 
    0.08582685f, 0.34114814f, -0.22418432f, 0.23427849f, 0.13295078f, -0.07108190f, 0.14316866f, -0.16914988f, 
    0.06601041f, 0.01497075f, 0.03989472f, -0.02978993f, 0.12607907f, -0.36515570f, 0.33461389f, 0.44018245f, 
    -0.05774303f, -0.18484950f, -0.13898067f, -0.27278018f, -0.16243793f, 0.01588466f, -0.03726080f, 0.14309826f, 
    0.02867466f, -0.00406892f, -0.06558508f, -0.04972976f, 0.16017407f, 0.04025762f, 0.08063639f, 0.04000644f, 
    0.11941383f, -0.00271379f, -0.00544211f, 0.08190250f, 0.24506333f, -0.24010074f, -0.28945765f, 0.21164371f, 
    0.00883625f, -0.13900416f, -0.00155268f, -0.12033422f, 0.07968006f, 0.08371232f, 0.22987472f, 0.43714687f, 
    0.04773115f, -0.07299604f, 0.19231135f, -0.06284387f, -0.01574246f, -0.04697875f, -0.19966608f, 0.08417365f, 
    -0.21263088f, -0.00518568f, 0.01046956f, 0.02233941f, -0.01809251f, -0.13426320f, -0.13460648f, 0.33786353f, 
    -0.12518987f, 0.13051991f, -0.08538782f, 0.18827160f, 0.03819122f, -0.01985195f, -0.05287816f, 0.01892049f, 
    0.03124659f, 0.00065097f, -0.04785263f, 0.00438069f, 0.09694970f, 0.00348882f, 0.09743644f, -0.02962777f, 
    0.05063980f, -0.07328066f, -0.08344621f, -0.00979949f, -0.23906504f, -0.13342178f, -0.22804978f, -0.46719334f, 
    0.00938389f, -0.01537159f, -0.16617343f, 0.16461554f, -0.13885264f, 0.02935334f, -0.16978203f, -0.00933733f, 
    0.18936050f, 0.09643760f, -0.02017914f, -0.03371309f, 0.00520837f, 0.02645979f, 0.10124011f, 0.03799364f, 
    0.03464994f, -0.01902111f, -0.05647288f, -0.19525790f, -0.28066251f, -0.02540342f, 0.14100577f, 0.07075398f, 
    -0.19099618f, -0.00424113f, -0.11683167f, 0.04987549f, 0.05471786f, -0.02548753f, 0.03956867f, 0.10947680f, 
    0.26359209f, -0.78468853f, -0.20403804f, 0.02093095f, -0.06115080f, 0.00965257f, 0.01139552f, 0.00128049f, 
    -0.09205934f, 0.12653813f, -0.09800892f, 0.08561337f, -0.00617736f, 0.20095354f, -0.06017170f, 0.19722380f, 
    -0.11256070f, -0.28967926f, -0.11675277f, 0.01375863f, -0.23498107f, -0.02531554f, 0.07320265f, -0.07321928f, 
    0.00275432f, 0.21041147f, 0.16561477f, 0.10169560f, -0.02254665f, -0.12542678f, -0.00156799f, 0.13807468f, 
    0.07356309f, 0.06368862f, 0.06156226f, 0.21069427f, -0.06040647f, 0.30274943f, 0.10584955f, 0.18124771f, 
    -0.18581362f, -0.23228683f, -0.03522531f, -0.21772100f, 0.02745995f, 0.05926611f, 0.07533406f, 0.01123237f, 
    0.11274112f, 0.11555477f, -0.40034997f, -0.20357147f, 0.02023272f, 0.06639540f, 0.01600027f, -0.05483562f, 
    0.11563300f, -0.12929562f, -0.16569632f, -0.19322060f, -0.12445616f, -0.13617685f, -0.13034242f, 0.07417079f, 
    0.00625691f, -0.05000104f, 0.05523852f, -0.06898848f, 0.16359188f, -0.08527819f, 0.02355643f, 0.03467738f, 
    0.06126318f, 0.04396008f, 0.07325767f, 0.14350413f, -0.14405864f, -0.06580277f, 0.13641034f, -0.04157735f, 
    0.07242464f, 0.03137898f, 0.04089044f, -0.03312098f, -0.07372643f, -0.03597749f, -0.07502409f, 0.17173287f, 
    -0.09522466f, 0.06938194f, -0.09945549f, 0.21652085f, 0.00503083f, -0.00565272f, -0.10966078f, -0.05360765f, 
    -0.21398327f, -0.03483557f, -0.27502307f, -0.08756995f, -0.17739660f, -0.03369836f, -0.01863390f, 0.04288727f, 
    0.01613325f, 0.06605455f, -0.17355724f, 0.13294314f, 0.44860938f, -0.58572531f, 0.20973521f, 0.00577591f, 
    -0.18841347f, -0.03520916f, 0.09031030f, -0.06275523f, 0.09161415f, -0.02171334f, 0.03593867f, -0.13125715f, 
    -0.19300786f, 0.02282501f, -0.12911429f, 0.21535604f, 0.22771554f, 0.13518314f, -0.02521219f, 0.11068396f, 
    0.06052796f, 0.01106152f, 0.04522046f, 0.02053335f, 0.29441899f, 0.07700235f, -0.11524858f, -0.05051230f, 
    0.00548624f, -0.07930845f, -0.02878651f, 0.25750431f, -0.06489898f, 0.07063559f, -0.02552543f, -0.12643683f, 
    0.14019679f, -0.03821486f, -0.23134175f, -0.09525038f, 0.04883915f, -0.09216285f, -0.04807294f, 0.14741784f, 
    0.05862689f, -0.25027117f, -0.01946394f, -0.31995437f, -0.33806792f, -0.49817112f, 0.44739583f, 0.02599237f, 
    -0.18880914f, -0.02735840f, -0.05779654f, 0.01374985f, 0.15516585f, 0.00962275f, 0.26613528f, 0.02237350f, 
    0.34929270f, 0.02611534f, -0.38790998f, 0.00598549f, 0.10680326f, 0.07887862f, -0.15748967f, 0.12442778f, 
    0.09358999f, 0.07731796f, 0.23831630f, 0.13305846f, -0.47225627f, -0.23009574f, -0.05401151f, 0.21573974f, 
    -0.05980431f, 0.10778920f, -0.18400870f, -0.08967022f, 0.34192517f, 0.33774352f, 0.19807072f, 0.06392785f, 
    0.13544582f, 0.32239959f, -0.53359449f, -0.12317654f, 0.07300214f, 0.08561479f, -0.17148711f, -0.11350728f, 
    0.01385076f, 0.19130573f, -0.08123995f, -0.02954133f, -0.10045321f, -0.28866738f, 0.12651283f, 0.42185029f, 
    0.04503281f, 0.02693739f, -0.00303028f, -0.01801767f, -0.04987771f, 0.16658689f, -0.12048320f, 0.03517823f, 
    0.04933296f, 0.21869722f, -0.02908252f, -0.12525807f, 0.32826564f, 0.14267872f, 0.05878285f, -0.29568014f, 
    0.06343216f, 0.00317527f, 0.01438513f, 0.07372825f, 0.09700053f, 0.06169271f, 0.24006312f, -0.27748087f, 
    0.33299130f, 0.13735987f, 0.19154692f, 0.04538888f, 0.00880261f, -0.00357446f, 0.07589020f, 0.07538081f, 
    -0.43190992f, -0.43934020f, -0.23715307f, -0.03210159f, -0.04102480f, -0.11107643f, 0.04085093f, -0.05026977f, 
    -0.03204922f, 0.03317568f, 0.04830216f, -0.14447458f, 0.14231843f, 0.24109654f, 0.15421934f, 0.21120109f, 
    0.02550944f, -0.18898791f, -0.10814125f, 0.02518686f, -0.10249877f, -0.02280305f, 0.00524366f, 0.05778297f, 
    -0.06744405f, 0.06511617f, -0.40194932f, 0.16830480f, -0.11892488f, 0.11641534f, 0.10347679f, -0.05654680f, 
    -0.18717656f, -0.05234941f, 0.19006662f, -0.42703891f, -0.14600831f, -0.29748738f, 0.44392014f, -0.06276552f, 
    -0.11654286f, -0.17709120f, 0.06997418f, -0.04516307f, 0.03560273f, -0.04171439f, -0.03856971f, -0.10101597f, 
    -0.20692655f, -0.30051163f, -0.04372567f, 0.08533072f, 0.01145630f, -0.15170290f, -0.11375535f, 0.00445855f, 
    0.02380869f, -0.06065503f, -0.00764600f, 0.23374517f, -0.70588154f, 0.37390921f, 0.18562572f, -0.18313207f, 
    -0.00421057f, 0.13574651f, 0.03785707f, 0.03945728f, 0.28827614f, -0.54148984f, -0.57133400f, -0.54238272f, 
    0.01374519f, 0.19300313f, -0.16504605f, -0.45895648f, 0.15703052f, 0.03362679f, 0.07154365f, -0.15273942f, 
    -0.10305498f, -0.21497650f, -0.18238392f, -0.02147951f, 0.46485919f, -0.23706967f, -0.46460068f, 0.60764080f, 
    0.00058585f, 0.16240633f, 0.29524523f, 0.11411995f, -0.02327996f, 0.12387717f, -0.05939026f, 0.02070873f, 
    -0.20366842f, -0.13489471f, 0.02741199f, -0.02921968f, 0.02218331f, 0.00219162f, 0.04166897f, 0.18377258f, 
    0.09489244f, 0.21716130f, 0.09327639f, -0.21492977f, 0.27274081f, -0.10623658f, -0.18959543f, 0.28483033f, 
    0.22310555f, -0.14863017f, -0.12971750f, -0.11878327f, 0.14650045f, 0.20018119f, -0.22218047f, 0.35365817f, 
    -0.19021609f, -0.10655019f, -0.12518230f, 0.11916967f, -0.03959199f, 0.04062581f, -0.12875891f, -0.11437120f, 
    0.04694383f, -0.05869810f, 0.07667113f, 0.07218610f, -0.01978236f, -0.33566716f, -0.28675863f, -0.47456774f, 
    -0.08968822f, -0.06164424f, 0.05993124f, 0.06325446f, 0.02467979f, -0.37668034f, 0.00363718f, -0.06074785f, 
    -0.52077633f, -0.28097025f, 0.18338387f, 0.45667040f, -0.02258787f, -0.02083603f, 0.01875508f, 0.04790584f, 
    0.09671598f, -0.05461570f, 0.04675897f, -0.06661536f, -0.13711278f, 0.00522874f, 0.00000782f, -0.37033817f, 
    -0.01336238f, 0.16432181f, -0.11749616f, 0.14728430f, 0.35166526f, -0.20329058f, -0.07179363f, 0.06957152f, 
    0.19678384f, 0.21869230f, -0.05089338f, 0.13231099f, -0.01126880f, 0.06340152f, -0.05682398f, -0.22592326f, 
    0.04682544f, 0.01707802f, 0.00481246f, -0.12467082f, -0.24077792f, -0.07767645f, 0.11716031f, -0.35645834f, 
    0.20461060f, -0.13079822f, 0.10536343f, 0.04716562f, 0.06831958f, 0.05636334f, 0.02351939f, -0.17261995f, 
    -0.52731293f, 0.26024252f, -0.55957657f, 0.14363325f, 0.27282032f, -0.02915140f, 0.02697716f, -0.10396350f, 
    0.10324555f, -0.02471319f, 0.07620622f, 0.07156591f, -0.69444311f, -0.08392777f, -0.25931525f, 0.40598127f, 
    0.12262099f, -0.14361745f, 0.08841757f, 0.03425742f, 0.08424335f, 0.05348999f, 0.06634329f, 0.11564652f, 
    -0.16587238f, 0.03343796f, -0.09542118f, 0.10030769f, 0.08196473f, 0.11861682f, 0.06345065f, 0.26927182f, 
    0.06659313f, -0.00887027f, 0.15025039f, 0.17509955f, 0.12199553f, -0.02686940f, 0.11399028f, -0.13091330f, 
    -0.22806180f, 0.33218738f, 0.06063227f, -0.08788653f, 0.20169015f, 0.10542325f, 0.05719198f, -0.01251173f, 
    -0.22580661f, -0.05408182f, 0.03793218f, -0.20270507f, -0.03530485f, -0.09698669f, 0.08629702f, 0.26066607f, 
    0.02581723f, -0.12252141f, -0.04542875f, 0.08941782f, -0.34376240f, -0.06849249f, -0.57645249f, -0.00117392f, 
    0.04299439f, -0.19152273f, 0.00198592f, -0.17311272f, 0.14489444f, 0.18017983f, -0.22747162f, -0.05875861f, 
    -0.05610961f, -0.48153219f, -0.68974423f, -0.28549603f, -0.09783659f, 0.17474568f, 0.16373751f, 0.01370944f, 
    -0.08007862f, -0.01878441f, -0.05849811f, 0.05613349f, 0.75406319f, 0.34106642f, -0.40000176f, -0.04301035f, 
    -0.01514340f, -0.18199769f, -0.00417830f, 0.10882692f, -0.04014645f, 0.03777562f, -0.03445661f, -0.08940957f, 
    0.28107601f, 0.43757674f, -0.11388443f, 0.09103604f, -0.07646064f, 0.15103748f, -0.01724168f, -0.02483341f, 
    0.10993636f, 0.08153312f, -0.03458681f, 0.12927659f, -0.27172220f, -0.08733336f, 0.29675844f, 0.24191640f, 
    -0.06957028f, -0.04483761f, -0.05428354f, 0.00609248f, -0.08361802f, 0.18585873f, 0.03100288f, 0.05972014f, 
    0.31075975f, -0.03431357f, 0.06855866f, -0.47466224f, -0.04664318f, 0.08924476f, 0.29286644f, -0.03031937f, 
    0.03432693f, 0.05418036f, 0.14179561f, -0.16887985f, 0.14874826f, -0.04748408f, 0.02191449f, 0.38193160f, 
    0.09374008f, 0.00752541f, -0.11257801f, 0.12978147f, -0.06228703f, -0.17872927f, 0.12637395f, 0.03263865f, 
    0.03579359f, 0.32462883f, 0.55736452f, -0.46907726f, -0.01005894f, -0.17628215f, 0.07730313f, 0.02353437f, 
    0.09391887f, 0.07765235f, -0.05309786f, 0.02910466f, 0.10454319f, -0.00008887f, -0.23986068f, 0.02326750f, 
    -0.19150726f, 0.05127172f, -0.06201880f, 0.20314385f, -0.22987497f, 0.01750226f, 0.07102083f, 0.03029472f, 
    -0.82776666f, -0.81525815f, -0.57150054f, -0.09834480f, -0.26786757f, -0.33960772f, -0.42002070f, -0.26888326f, 
    -0.02251566f, -0.03032464f, -0.01144116f, 0.01075212f, -0.71583784f, -0.72087443f, -0.67353755f, -0.34004337f, 
    -0.17789073f, 0.04851339f, -0.15736520f, -0.07214944f, 0.04549494f, 0.08455328f, 0.04658648f, 0.04804840f, 
    -0.03251634f, 0.13937172f, 0.16313937f, 0.18232897f, -0.06816318f, 0.02592399f, -0.20632043f, 0.12579115f, 
    0.03820753f, 0.10238768f, -0.00754932f, 0.03969923f, -0.64898735f, -0.91526145f, -0.55519319f, 0.14990532f, 
    -0.12400378f, 0.17282555f, 0.03317699f, -0.40720901f, 0.03630756f, -0.11315696f, 0.11305674f, 0.08579063f, 
    0.38278592f, -0.08301222f, -0.05655950f, -0.25509307f, -0.03757960f, 0.00713694f, 0.23091890f, -0.07048933f, 
    0.01265559f, -0.02517378f, -0.03199797f, 0.13197254f, -0.25624603f, -0.25608304f, -0.14506635f, 0.51079369f, 
    0.10404168f, 0.20919356f, 0.14800726f, 0.16564564f, -0.03639992f, -0.03645038f, 0.09247371f, 0.14477214f, 
    -0.03672302f, -0.00613906f, -0.04987320f, -0.05982787f, 0.09040018f, -0.01556108f, 0.00206515f, 0.06392775f, 
    -0.08095808f, -0.10610627f, -0.24537212f, -0.09516490f, -0.00342534f, -0.01049651f, 0.13766856f, -0.11139485f, 
    0.00680570f, 0.04170983f, 0.06192885f, 0.07200318f, 0.30353576f, 0.17439897f, 0.22576943f, 0.04773869f, 
    -0.56278747f, -0.03778636f, 0.26602724f, 0.25034612f, 0.06453805f, -0.08890441f, 0.07578553f, -0.27365765f, 
    0.03745154f, 0.00443636f, -0.00296859f, 0.01013364f, 0.04192737f, 0.02315385f, -0.05360560f, -0.33181801f, 
    0.01610780f, 0.07721324f, 0.25573021f, -0.31341445f, -0.02772635f, 0.04426411f, 0.09932958f, 0.05457292f, 
    0.20203972f, 0.06376720f, -0.08270476f, 0.09786756f, 0.01957057f, 0.09686677f, 0.12940116f, 0.01373747f, 
    0.01880250f, -0.00107377f, -0.07656921f, 0.04484686f, 0.19925994f, 0.13144757f, -0.21487296f, 0.03895406f, 
    0.07070669f, -0.09998615f, 0.15594573f, -0.01311558f, -0.12322053f, -0.14426304f, -0.09133449f, 0.14063431f, 
    -0.03442055f, -0.03609349f, 0.05356437f, 0.16767330f, 0.06664588f, -0.09272055f, -0.00922261f, 0.02113166f, 
    -0.11311159f, -0.04120640f, -0.00859642f, -0.24582806f, -0.64264977f, 0.42929107f, 0.20294014f, 0.29626322f, 
    -0.10780559f, 0.00978051f, -0.00753357f, 0.14842680f, 0.02862209f, 0.01303797f, 0.09605369f, 0.05155979f, 
    -0.12732470f, -0.13034785f, 0.23463224f, 0.19350457f, -0.08169583f, -0.07357837f, -0.07663128f, 0.05271226f, 
    0.18134694f, 0.12075420f, 0.09198028f, 0.18298942f, 0.30085519f, 0.42925420f, 0.13348553f, 0.48068318f, 
    0.12045209f, -0.30754212f, 0.31069207f, 0.04013156f, 0.01506787f, 0.15520945f, 0.07414117f, -0.07010829f, 
    -0.94044089f, -0.80806673f, -0.26940757f, -0.25150400f, -0.16286144f, 0.02861688f, -0.24967696f, -0.39047477f, 
    -0.12393937f, -0.14957659f, 0.19587749f, 0.03997178f, -0.83495879f, -0.78967017f, 0.40961799f, 0.27077726f, 
    -0.01057775f, 0.08665384f, 0.08368974f, -0.14647964f, -0.00190939f, 0.06164181f, 0.00398872f, 0.07680887f, 
    0.35064122f, -0.15193108f, -0.36802006f, -0.11399952f, 0.10188859f, 0.10836797f, 0.08818541f, -0.00349550f, 
    -0.05367395f, 0.08570325f, -0.17029409f, -0.09124405f, -0.05320552f, -0.01322875f, -0.07781027f, -0.08470842f, 
    0.13333750f, -0.02799516f, 0.07511862f, -0.02756991f, -0.08486579f, 0.03682856f, 0.16047961f, -0.13976698f, 
    -0.77066523f, -0.87026060f, -0.33074999f, -0.30811700f, -0.39274609f, -0.53885174f, -0.20937087f, -0.06702988f, 
    0.00008250f, -0.04081405f, -0.06494260f, -0.19633684f, -0.17170243f, -0.18161079f, -0.48930970f, 0.05384910f, 
    -0.23148559f, -0.03784344f, -0.03621457f, 0.08499140f, 0.01524046f, 0.01943831f, -0.12390532f, -0.13931996f, 
    0.05880885f, 0.10038526f, -0.16040035f, 0.10825548f, -0.10903373f, 0.10832031f, -0.01552159f, 0.19219652f, 
    0.10087466f, 0.01098575f, 0.19759396f, -0.00110964f, -0.33337274f, -0.04192080f, 0.26007533f, -0.49830970f, 
    0.04818178f, -0.02175460f, -0.13921395f, 0.00895361f, -0.09391961f, 0.17560615f, 0.14513008f, 0.19229686f, 
    -0.24912342f, -0.16270167f, -0.02925275f, -0.05610481f, 0.00122910f, 0.03661291f, -0.08226005f, -0.14850870f, 
    0.13031836f, -0.01382021f, 0.07620189f, 0.01962479f, -0.65169853f, -0.54417205f, -0.24349615f, 0.19569275f, 
    -0.07308131f, 0.03060528f, -0.04612118f, 0.04071043f, -0.17102714f, -0.07951448f, 0.08221472f, -0.01707275f, 
    0.04167627f, -0.14324394f, -0.16858397f, -0.09337921f, 0.01616637f, 0.05279273f, 0.07037541f, 0.07575180f, 
    -0.04391627f, 0.12584080f, -0.11653703f, 0.05896452f, 0.61670274f, -0.04308925f, -0.02772505f, -0.41083041f, 
    0.06667239f, -0.05508266f, -0.20057352f, 0.03794174f, -0.09306450f, -0.00911725f, 0.05586123f, -0.21104331f, 
    -0.21370530f, 0.39398786f, -0.13313742f, 0.00789155f, -0.16683871f, -0.05462732f, -0.00840630f, 0.05184215f, 
    0.02161893f, -0.03118727f, -0.05292135f, 0.05204833f, 0.19702515f, 0.03368298f, 0.21171083f, -0.08205067f, 
    -0.13117358f, -0.04835678f, 0.01547952f, 0.07545108f, -0.14928310f, -0.09956877f, -0.04724701f, -0.20108107f, 
    0.16461273f, 0.48906979f, -0.21230505f, 0.38727063f, 0.05820264f, -0.17128709f, 0.17405723f, 0.08850873f, 
    -0.26948062f, 0.06957425f, 0.14813222f, 0.18561542f, 0.19601114f, -0.09507808f, -0.12942071f, -0.20723087f, 
    -0.00213020f, 0.02373262f, -0.00818384f, -0.07216521f, -0.10381840f, -0.04161306f, -0.05076322f, -0.18670495f, 
    -0.52601624f, -0.34607315f, 0.01763439f, 0.40528461f, 0.09749341f, -0.00001065f, 0.01524456f, 0.08105204f, 
    0.05317238f, -0.01623272f, -0.04158724f, -0.00654489f, -0.62960470f, -0.43014047f, -0.24436979f, -0.18436085f, 
    -0.04224639f, 0.11331104f, 0.09416374f, 0.27930346f, 0.07359458f, 0.01941695f, -0.04494237f, -0.09161541f, 
    0.42859393f, -0.09806156f, -0.11952032f, -0.08029548f, 0.07305840f, -0.03277552f, -0.09711223f, -0.11527745f, 
    -0.01339751f, -0.11269871f, 0.02771238f, 0.04160296f, -0.83564776f, -0.35062680f, 0.12016289f, 0.45440194f, 
    0.00958877f, 0.10381017f, 0.24419311f, 0.00437732f, -0.01850323f, -0.03683679f, -0.12827073f, -0.09245530f, 
    -0.20140082f, 0.34301877f, -0.23826946f, 0.15381044f, -0.09308862f, 0.00167883f, 0.14996354f, 0.15160710f, 
    0.03953894f, 0.05877118f, 0.23083347f, 0.06467036f, 0.24004082f, -0.13541324f, -0.02212981f, -0.32650155f, 
    0.08248562f, -0.19654256f, -0.03669644f, -0.09628847f, -0.17212877f, 0.12766866f, 0.12897904f, 0.00115158f, 
    0.08086921f, 0.05820645f, -0.03257034f, -0.18514121f, 0.03344534f, -0.02752335f, 0.04802476f, 0.00128427f, 
    0.04940048f, 0.01591222f, 0.00402121f, -0.03735015f, 0.29168391f, -0.01527173f, 0.05420494f, -0.04999581f, 
    -0.00607954f, -0.06622748f, 0.09973907f, -0.01364443f, 0.07610679f, 0.00955754f, 0.18139392f, 0.03208145f, 
    -0.10998741f, 0.12018811f, 0.23173584f, -0.05872908f, -0.02608947f, 0.06988685f, 0.25261542f, 0.22637852f, 
    -0.07756421f, 0.07040291f, 0.11582891f, 0.03289866f, 0.20363452f, 0.15895092f, -0.12036283f, -0.11749680f, 
    -0.09871088f, -0.08918436f, -0.05973589f, -0.04011042f, 0.01605169f, 0.17709465f, 0.06358431f, 0.08298033f, 
    -0.01888482f, -0.02700421f, 0.13291644f, -0.14061937f, -0.03025694f, 0.03457965f, -0.06433071f, -0.01949272f, 
    0.09592693f, -0.00086534f, -0.02271622f, -0.07495595f, -0.18869717f, 0.05464334f, -0.32582900f, 0.28212944f, 
    -0.11064739f, 0.20130642f, 0.09057962f, -0.08636934f, -0.12329385f, 0.18326753f, 0.02708258f, -0.06233433f, 
    0.14284796f, 0.01068229f, -0.06049911f, -0.16731021f, -0.00380871f, 0.11729121f, -0.01424207f, 0.02080540f, 
    0.04018785f, 0.02284519f, -0.01793974f, -0.08846171f, -0.04580652f, -0.91910011f, -0.45626125f, -0.25516915f, 
    -0.17692536f, -0.26837024f, -0.00042957f, -0.01212741f, 0.12088708f, -0.00544732f, 0.03857634f, -0.07407999f, 
    0.31758177f, 0.20265196f, -0.14054868f, -0.53304958f, 0.00087804f, 0.09693464f, 0.03463493f, 0.00635877f, 
    0.02440741f, 0.16414714f, -0.14758036f, -0.21035416f, -0.35212684f, -0.46974969f, -0.16753840f, -0.30130830f, 
    -0.28659403f, 0.07583170f, 0.16175623f, -0.07781629f, -0.03357714f, 0.08527504f, 0.06491967f, -0.04553589f, 
    -0.52361798f, 0.00297120f, 0.21781376f, 0.46378651f, 0.18721774f, 0.02974807f, 0.24268863f, 0.16891488f, 
    0.03085657f, -0.06335585f, -0.06375501f, -0.07488391f, -0.06920291f, -0.60806018f, -0.37525564f, -0.33278805f, 
    0.07871311f, 0.22317728f, -0.07491912f, 0.12107217f, 0.18722449f, -0.00189349f, 0.00847665f, 0.03210963f, 
    -0.42357484f, 0.27801436f, -0.33380458f, 0.17844577f, -0.06746329f, 0.07403698f, -0.06202695f, -0.01387055f, 
    0.03424866f, -0.05953898f, -0.00883972f, -0.08105781f, -0.09366947f, 0.10183269f, -0.21469602f, 0.09154478f, 
    0.01729152f, -0.03613286f, 0.01536814f, -0.08614922f, 0.05298128f, 0.06299242f, -0.01457292f, -0.03912110f, 
    -0.88510257f, -0.70012534f, -0.66862321f, 0.23616180f, 0.07439592f, -0.13699462f, -0.06915259f, 0.03773826f, 
    0.07635532f, 0.03622080f, 0.01433759f, 0.01585547f, 0.08535220f, -0.13748385f, 0.25013408f, 0.18392229f, 
    -0.21235229f, -0.08730584f, -0.34564650f, -0.07067388f, 0.03467510f, -0.00875722f, -0.02165087f, -0.01084793f, 
    -0.12764411f, -0.51366395f, -0.34082305f, 0.10651196f, -0.08461995f, -0.26589236f, 0.02382499f, -0.14678112f, 
    0.16249579f, -0.07791048f, -0.10515047f, 0.04220194f, 0.39407092f, 0.21898194f, -0.20363958f, -0.15667047f, 
    -0.07842664f, 0.15074562f, 0.15939313f, 0.08796929f, -0.08243154f, 0.34438601f, 0.04929637f, 0.07554394f, 
    -0.40427694f, 0.37165171f, 0.12269051f, 0.04929288f, 0.06024345f, -0.12981349f, -0.16206209f, -0.12983839f, 
    -0.08840703f, 0.00797930f, 0.05468808f, -0.02363726f, 0.18930508f, 0.01865512f, -0.09774699f, 0.12528016f, 
    0.19163242f, 0.02712688f, -0.00102465f, 0.14796168f, -0.16776922f, -0.11737775f, 0.16463588f, 0.05230717f, 
    -0.22859466f, -0.22861832f, -0.04508581f, -0.08373918f, 0.08391346f, 0.00702277f, 0.04460358f, 0.12671778f, 
    -0.29057211f, -0.11222012f, -0.23696099f, -0.30126655f, 0.07223917f, -0.09724449f, -0.30049488f, -0.17631462f, 
    0.00301162f, -0.14380236f, 0.16285953f, -0.08558929f, 0.18279736f, 0.07314739f, 0.13794661f, 0.17469122f, 
    -0.66588360f, 0.01130771f, 0.31400594f, 0.15760824f, 0.18872671f, -0.15557842f, -0.12432849f, 0.04760108f, 
    0.02362661f, -0.14438184f, 0.13190584f, -0.01349842f, -0.14364652f, -0.16594055f, 0.12027295f, 0.11630549f, 
    -0.04299144f, 0.01429741f, 0.05306702f, 0.05106404f, 0.04558558f, 0.04392340f, 0.17657669f, 0.10247029f, 
    -0.55234480f, -0.08739687f, -0.21785410f, -0.00568926f, 0.05583510f, 0.22058406f, 0.16118170f, 0.14535113f, 
    -0.14980835f, 0.11844609f, 0.01705384f, 0.11840281f, 0.64816397f, 0.22256958f, -0.16357696f, -0.31823981f, 
    0.18089971f, 0.05124459f, 0.01048308f, 0.00570758f, 0.19668415f, 0.11655120f, 0.36154377f, 0.23050171f, 
    -0.21931164f, -0.39520591f, 0.01685558f, -0.12573051f, -0.08745740f, -0.14893785f, 0.00666741f, 0.04409762f, 
    0.08864188f, 0.00608912f, 0.04141061f, 0.04853768f, 0.37487653f, -0.49076003f, -0.45840767f, -0.13112053f, 
    -0.16719374f, -0.36229962f, 0.10601128f, -0.29704672f, 0.00788352f, -0.03246286f, -0.06218840f, 0.06328031f, 
    -0.29965469f, -0.31070632f, -0.17993040f, -0.11821932f, 0.00851049f, 0.13944653f, 0.08336814f, 0.05305289f, 
    0.16635114f, 0.14060397f, -0.11798643f, -0.19026370f, 0.27786094f, -0.03303236f, 0.32066262f, 0.06393078f, 
    0.19127417f, 0.08012906f, 0.04025004f, -0.17589024f, -0.01177194f, 0.04156291f, 0.05033876f, -0.09290642f, 
    -0.54525417f, -0.13602439f, 0.13687329f, 0.16271944f, 0.01818679f, 0.02882600f, -0.47904408f, 0.10394828f, 
    -0.47428152f, -0.13745049f, -0.08854839f, -0.04908241f, 0.26110375f, 0.23149908f, -0.20929387f, -0.42101073f, 
    0.11161477f, -0.01961371f, -0.06240603f, -0.26474959f, -0.16973206f, 0.01152432f, -0.13121326f, -0.03829151f, 
    0.03354503f, 0.10654376f, -0.09676509f, -0.10522830f, -0.09146338f, -0.03253081f, -0.03210908f, 0.02585139f, 
    -0.00079359f, -0.03745287f, -0.01013323f, 0.04556787f, 0.10862704f, 0.10832255f, 0.10481574f, -0.08721872f, 
    0.03545002f, -0.03002170f, 0.10774093f, 0.00975707f, -0.37978646f, 0.15984462f, -0.27734253f, -0.71819574f, 
    -0.05772743f, -0.10750062f, 0.00078262f, 0.01922204f, -0.14309239f, -0.02413291f, -0.19593963f, -0.11075673f, 
    -0.05431318f, -0.15391171f, 0.07580171f, 0.05529916f, -0.50073802f, 0.38435826f, 0.19900835f, 0.29389039f, 
    0.02151046f, 0.09235922f, -0.29837406f, -0.17735733f, -0.20572720f, -0.08478748f, -0.05637836f, -0.14457911f, 
    -0.20928875f, 0.00305236f, 0.17800859f, -0.02195918f, -0.06218749f, 0.02476425f, -0.00502649f, -0.05824795f, 
    -0.09234243f, 0.09210438f, 0.07132913f, 0.17705002f, 0.15424444f, 0.13560893f, 0.33526704f, 0.04365857f, 
    -0.08193684f, -0.00879872f, -0.14105704f, -0.05083881f, 0.13143724f, -0.08179370f, 0.32011306f, 0.01295260f, 
    0.00563752f, -0.01074413f, -0.02864920f, -0.01328701f, -0.08570656f, -0.04363282f, -0.04485134f, -0.03504611f, 
    0.08293027f, 0.10123925f, 0.19301672f, 0.10812286f, -0.25165108f, -0.66609353f, -0.31233835f, 0.23094060f, 
    0.09787330f, 0.11265536f, 0.07840716f, 0.17436290f, -0.20879413f, 0.13963015f, -0.15966144f, -0.13224660f, 
    0.07505188f, -0.17027995f, -0.33841473f, -0.43916178f, -0.10971200f, -0.06033040f, -0.06601577f, 0.07657710f, 
    0.35617211f, 0.13367055f, 0.20150279f, -0.04274010f, -0.65637779f, -0.52783078f, 0.13022441f, 0.61503881f, 
    0.12031338f, 0.15439743f, 0.13780439f, 0.13049173f, 0.14362878f, 0.20990422f, 0.11848088f, 0.20848009f, 
    -0.14115320f, -0.52461600f, -0.74403065f, -0.61479390f, -0.04952759f, -0.08987423f, 0.11630841f, -0.04684843f, 
    0.18056859f, -0.06996766f, 0.12756659f, 0.02001654f, -0.24585360f, -0.38778365f, -0.61414301f, 0.45617706f, 
    0.29166225f, 0.22177745f, 0.23823613f, 0.18528222f, -0.13753304f, -0.06619076f, -0.05080479f, -0.11612650f, 
    -0.23082407f, 0.04542822f, -0.08222879f, 0.20134293f, 0.01132622f, 0.05085452f, 0.06703065f, 0.06834795f, 
    -0.09303453f, 0.05545999f, -0.01105136f, 0.10364337f, 0.03113468f, 0.13635783f, 0.02446054f, -0.21650741f, 
    -0.09269527f, 0.08562630f, 0.04775860f, -0.00319798f, -0.11388908f, -0.06226067f, 0.04298938f, 0.15914437f, 
    -0.42123100f, -0.65508717f, -0.42452359f, 0.25634876f, 0.32029110f, 0.13197681f, -0.11697198f, -0.14008272f, 
    -0.00601080f, -0.05417999f, 0.05483149f, 0.05818576f, 0.34629190f, 0.07764222f, 0.04830777f, -0.02947104f, 
    0.15898280f, -0.30557957f, -0.20925613f, -0.17741895f, 0.08880146f, 0.22861527f, 0.19992942f, 0.16377586f, 
    0.36014050f, -0.24446905f, 0.28427529f, 0.12079539f, 0.11831196f, 0.10165638f, 0.17166945f, 0.09387740f, 
    -0.02262301f, 0.00144576f, -0.00356634f, -0.58665043f, -0.20701359f, -0.02002386f, -0.08734271f, -0.36595595f, 
    -0.12938826f, 0.06454160f, -0.04658942f, 0.08066067f, 0.17907700f, 0.07503897f, -0.12131324f, -0.02259627f, 
    0.06010571f, -0.15559714f, -0.95530421f, 0.10485811f, 0.16567354f, 0.08040965f, 0.15950777f, 0.06689798f, 
    0.00211062f, -0.07820671f, 0.02723857f, 0.00181567f, 0.07022641f, 0.42692468f, 0.40189877f, -0.38869002f, 
    -0.22100806f, -0.16719604f, 0.04237860f, -0.09941170f, 0.04216405f, 0.04164841f, 0.15030298f, 0.11552757f, 
    0.02425019f, 0.20150986f, 0.30198932f, -0.25731191f, -0.14844967f, -0.23660888f, -0.03083877f, -0.14803500f, 
    -0.12698138f, 0.15856653f, 0.16741014f, 0.05602786f, 0.00786584f, -0.33616260f, 0.55063540f, 0.44614878f, 
    0.11685188f, -0.01323583f, -0.28838322f, -0.11185013f, 0.08144578f, -0.18821326f, -0.15706593f, 0.19632430f, 
    -0.21955177f, 0.06826849f, -0.94900268f, 0.19620016f, 0.09634448f, -0.11950023f, 0.16092402f, 0.13519001f, 
    0.04596218f, -0.23183374f, -0.05790259f, -0.07966404f, -0.00669642f, -0.07776581f, -0.00783669f, -0.35938230f, 
    -0.20195661f, 0.06164134f, 0.09680571f, -0.25469542f, -0.07102861f, -0.04647503f, -0.02759860f, 0.08779634f, 
    -0.21677892f, 0.48897019f, -0.14407513f, -0.19155344f, -0.01860848f, -0.08049040f, -0.23747334f, -0.13985635f, 
    0.38743427f, 0.08282477f, 0.13157181f, -0.16158293f, -0.13178055f, 0.28304109f, -0.12803520f, 0.31850094f, 
    0.08836419f, -0.03794276f, -0.10879054f, -0.19117549f, 0.16057017f, -0.13515382f, -0.02928974f, 0.01788687f, 
    -0.21577880f, -0.08670112f, 0.21640530f, -0.24222155f, -0.12522173f, -0.10232718f, 0.08964559f, 0.30286300f, 
    -0.08493348f, 0.00418761f, -0.02145335f, -0.01799870f, -0.59584153f, -0.17065269f, 0.34741941f, 0.12564777f, 
    -0.38955042f, -0.23748711f, 0.00026591f, 0.11832882f, 0.09166586f, 0.09821077f, 0.13161537f, -0.00487634f, 
    0.04730575f, 0.13910362f, 0.30633971f, 0.10101561f, -0.01506705f, -0.16447526f, -0.07197738f, -0.29082489f, 
    0.15709092f, -0.01155721f, 0.01053553f, 0.14181289f, 0.45633712f, 0.05766283f, -0.33916432f, -0.24819262f, 
    -0.09907266f, 0.06980415f, 0.09153043f, 0.11682186f, 0.12892231f, 0.04585422f, 0.03478556f, 0.00833353f, 
    -0.23523782f, 0.51682174f, -0.20309381f, -0.17020006f, 0.03797393f, -0.07854551f, 0.33870539f, 0.09252328f, 
    0.20974201f, -0.03311662f, -0.13319969f, 0.27477491f, -0.03571881f, -0.57357842f, 0.11788625f, -0.11386823f, 
    -0.09588036f, 0.05561936f, -0.10940868f, -0.09579447f, 0.04188023f, 0.01159478f, 0.04324652f, -0.00554885f, 
    -0.05966973f, -0.17077108f, -0.01581651f, 0.07544242f, 0.09735258f, 0.15378107f, -0.00167474f, 0.08861327f, 
    0.12702355f, 0.03141534f, 0.06085651f, -0.08213256f, -0.31029907f, -0.09706672f, 0.16088472f, 0.14472842f, 
    -0.00150316f, 0.20441978f, -0.00565992f, -0.07653006f, 0.11389537f, 0.14960556f, 0.19608773f, 0.06047443f, 
    0.22320698f, -0.35478270f, 0.23654988f, -0.52362317f, 0.19414219f, 0.00372134f, -0.17588456f, 0.22944793f, 
    0.23536380f, -0.00559353f, -0.04519765f, -0.05927859f, -0.15847622f, -0.14633091f, -0.48029932f, 0.20066725f, 
    0.07641705f, -0.03723820f, 0.11566402f, 0.10660513f, 0.01449714f, -0.02580307f, -0.12362162f, 0.08818226f, 
    0.33088318f, -0.25847146f, 0.05460434f, -0.20909868f, 0.15165649f, 0.02435055f, -0.05848379f, -0.23441793f, 
    0.04336535f, -0.18989219f, -0.06035733f, 0.06489827f, -0.46131212f, 0.04728688f, -0.20022242f, -0.30488491f, 
    0.24534895f, -0.02887977f, 0.05243917f, -0.13225724f, -0.17630900f, 0.02074069f, 0.06814045f, -0.08549882f, 
    0.08751466f, 0.04441679f, 0.18291223f, 0.18773842f, 0.00648215f, 0.15919518f, -0.04779695f, -0.01065732f, 
    0.19002077f, -0.10192876f, 0.03592914f, -0.17131202f, 0.45314345f, -0.28629535f, 0.39721039f, -0.09017725f, 
    0.06055032f, -0.17544258f, -0.05550920f, -0.07345239f, 0.02982347f, -0.08439386f, 0.11699589f, 0.09205539f, 
    -0.04616751f, 0.10336062f, 0.03763868f, 0.46063477f, -0.04530817f, -0.02434885f, -0.23039977f, -0.06906556f, 
    -0.28489971f, -0.04478039f, 0.16689008f, -0.04361770f, 0.25765198f, 0.02776529f, 0.20968831f, -0.98164427f, 
    -0.31737518f, -0.28339288f, -0.07857385f, 0.05379310f, -0.32293066f, 0.02875321f, 0.04467956f, 0.05020616f, 
    -0.08769876f, -0.00575646f, 0.09696122f, -0.28606007f, -0.01876646f, -0.05067073f, 0.02956442f, 0.18064214f, 
    0.12160143f, 0.09593467f, 0.06679004f, 0.00528211f, -0.53990722f, 0.12294072f, -0.17959596f, -0.70001650f, 
    -0.43235496f, -0.01733673f, -0.16769969f, -0.14786714f, 0.09568506f, 0.06020182f, 0.01884768f, 0.04942807f, 
    -0.58169186f, 0.30627051f, -0.45392922f, 0.03327461f, -0.17977992f, -0.18479738f, 0.12569638f, 0.10199073f, 
    0.09970356f, -0.00081538f, -0.24867642f, -0.19090337f, -0.47391906f, 0.04736361f, -0.18374370f, 0.09268084f, 
    0.06486390f, 0.05870112f, -0.03119659f, 0.00641289f, 0.10028304f, -0.07468836f, 0.01952828f, 0.05817029f, 
    -0.45276207f, 0.19349313f, 0.12497308f, -0.53536320f, 0.13526398f, -0.21770935f, 0.10076295f, 0.00152432f, 
    0.02209223f, 0.04241101f, 0.03554333f, 0.00897522f, 0.02285431f, -0.01810597f, -0.34719452f, 0.19861235f, 
    0.03576543f, 0.07248922f, 0.27785456f, -0.04478490f, 0.06373508f, -0.09745166f, -0.12652425f, 0.03913973f, 
    -0.05542743f, -0.02087777f, 0.19321154f, 0.01564862f, 0.04465567f, -0.05907030f, 0.06651735f, -0.22540571f, 
    -0.03952449f, 0.09262774f, 0.26931489f, 0.09638656f, -0.01552021f, 0.41824546f, -0.27958745f, 0.65208715f, 
    -0.04192778f, -0.06958085f, -0.40277615f, 0.19300258f, 0.05719863f, -0.07957339f, 0.00644965f, -0.17118689f, 
    -0.08303169f, -0.01108338f, -0.67408884f, 0.18152912f, -0.20964357f, -0.10829824f, 0.11834170f, 0.07994558f, 
    -0.20124422f, 0.27795658f, -0.10655669f, 0.01987641f, -0.55446303f, 0.20088796f, 0.09825996f, -0.11131269f, 
    0.09401827f, 0.19459884f, -0.04439395f, 0.04746750f, -0.07001746f, -0.13552271f, -0.04030031f, -0.12780312f, 
    -0.16853651f, -0.18770137f, -0.19598204f, 0.40553614f, -0.02918053f, -0.37866098f, -0.18395796f, 0.16960660f, 
    -0.03797229f, -0.47206548f, -0.18297580f, -0.07261614f, -0.64663857f, 0.33997953f, 0.01972244f, -0.27608502f, 
    0.01510700f, -0.11190634f, -0.05891440f, -0.17382234f, -0.00435426f, 0.10088032f, -0.01662059f, 0.01545190f, 
    -0.08938581f, 0.06733754f, -0.28669259f, -0.08383081f, -0.14783821f, 0.11107040f, 0.09707155f, -0.05342790f, 
    -0.24125302f, 0.14276165f, -0.04857862f, -0.01185216f, 0.22188376f, 0.32259905f, 0.20112853f, 0.32115310f, 
    0.15837270f, 0.17390406f, 0.12856591f, -0.02153502f, -0.19972618f, 0.15971737f, 0.11004908f, 0.14349030f, 
    0.50182706f, 0.18396340f, 0.30101189f, -0.11520354f, -0.16233219f, 0.17488629f, 0.34492519f, 0.28862202f, 
    0.13233595f, 0.10754672f, 0.08902686f, 0.00288427f, -0.36805823f, 0.14222266f, 0.00273739f, 0.01297349f, 
    -0.27089176f, 0.14188077f, 0.08351102f, 0.10596099f, -0.04118149f, -0.20369506f, -0.08677736f, 0.05209072f, 
    -0.21550241f, -0.03184032f, -0.18430188f, 0.19946057f, -0.01519957f, -0.16292706f, -0.02572916f, -0.05014613f, 
    0.04539681f, 0.12230188f, 0.13188387f, -0.02450204f, -0.30555379f, -0.20508642f, -0.71140593f, 0.12288728f, 
    -0.10292381f, -0.15719165f, -0.20405042f, 0.17236686f, -0.08405129f, 0.21316147f, -0.03034462f, -0.06147776f, 
    0.25265476f, -0.04569088f, -0.01973020f, -0.15288195f, -0.02231893f, -0.36249679f, -0.03650157f, 0.05659701f, 
    -0.02524574f, -0.06095762f, -0.19513890f, -0.02666017f, -0.11917973f, 0.11738388f, -0.06730840f, 0.08927382f, 
    -0.10335081f, -0.29544628f, 0.12931940f, 0.02673343f, 0.01952012f, 0.01287289f, -0.09598132f, 0.11133422f, 
    0.02633990f, -0.50453293f, 0.14679450f, 0.05783635f, -0.08400404f, -0.26863530f, 0.17199279f, -0.03202057f, 
    -0.45837960f, -0.31268632f, -0.25910404f, -0.25398761f, -0.51463008f, 0.01015464f, -0.15963227f, 0.04622819f, 
    -0.06193630f, 0.11696098f, 0.11367132f, -0.04748376f, -0.02096968f, -0.13455735f, 0.00583402f, -0.24702224f, 
    -0.34787992f, -0.57103336f, -0.19281593f, -0.73701674f, -0.19475245f, -0.10277945f, -0.15174270f, -0.03330700f, 
    0.14624766f, -0.05785750f, -0.01455547f, -0.02023672f, 0.74945873f, -0.09462035f, -0.06124147f, -0.17922939f, 
    0.04033202f, 0.06626824f, 0.16092107f, 0.04747221f, -0.07071704f, -0.33765820f, -0.45067981f, -0.24865387f, 
    -0.05476082f, -0.01431288f, 0.32629013f, 0.10100655f, -0.03644485f, 0.13924764f, -0.50737351f, 0.03801097f, 
    0.02555221f, -0.31819847f, -0.00703120f, -0.09469219f, -0.16642383f, 0.33105198f, -0.22000128f, -0.03314724f, 
    -0.23622254f, 0.27826446f, 0.19508548f, -0.09771947f, 0.14297496f, 0.13039948f, -0.07434519f, -0.02852706f, 
    -0.31366661f, 0.54497230f, 0.07265732f, 0.01668298f, 0.04978966f, -0.06077908f, -0.12724032f, 0.20160347f, 
    -0.32784975f, 0.31641826f, 0.15217997f, -0.02132273f, -0.11626677f, -0.22298959f, 0.20205210f, 0.05570415f, 
    -0.16299424f, -0.16761924f, -0.11087231f, 0.21573569f, 0.29288191f, 0.09114132f, 0.12824950f, 0.09391093f, 
    -0.09179506f, -0.01846904f, 0.08366110f, -0.16731517f, -0.11782739f, -0.09908302f, 0.00542755f, 0.00521964f, 
    -0.06602654f, -0.00984341f, 0.15672375f, 0.01639541f, -0.14118336f, -0.00945645f, -0.01581540f, -0.00174491f, 
    0.04315878f, -0.17389874f, 0.02129057f, -0.03565612f, -0.04997505f, 0.28135464f, 0.00867973f, -0.48732969f, 
    -0.33694065f, 0.64700514f, 0.32789430f, -0.14383210f, 0.25877175f, 0.09895903f, -0.22317676f, 0.07008348f, 
    0.07762393f, -0.06504270f, 0.24936560f, -0.06766942f, 0.15111309f, 0.23663618f, 0.18309197f, 0.08917003f, 
    -0.11179178f, -0.04023307f, 0.11126204f, -0.10641728f, 0.11094703f, 0.08228568f, 0.04320454f, 0.03572855f, 
    -0.24736184f, 0.22131188f, -0.33618292f, 0.42089063f, -0.04940638f, 0.19197869f, -0.17117442f, 0.00977442f, 
    0.11435357f, 0.17184614f, -0.01307289f, -0.17815083f, 0.12030388f, -0.13251157f, -0.01300158f, -0.25174740f, 
    0.05313614f, -0.10580778f, 0.44880185f, 0.00103358f, -0.27149773f, 0.12510177f, 0.12877235f, -0.01745145f, 
    0.39967942f, -0.48271939f, 0.48586306f, 0.27725321f, -0.21305734f, -0.08986177f, 0.20242228f, -0.01039748f, 
    0.01013969f, -0.20263878f, 0.07455455f, 0.31699780f, 0.03492543f, -0.30422077f, 0.31343982f, -0.10051519f, 
    -0.07371217f, -0.08121461f, 0.30930570f, 0.25696537f, 0.00169822f, -0.03251782f, -0.02951758f, -0.01548657f, 
    0.11534516f, -0.45457560f, 0.15912457f, -0.04596697f, -0.40227702f, -0.06184319f, 0.22919233f, 0.23521130f, 
    0.15161408f, -0.12061492f, 0.16272472f, 0.18429914f, -0.16701952f, 0.10070221f, -0.25041410f, -0.09070759f, 
    0.01115311f, 0.16303159f, 0.11819240f, -0.33894730f, -0.00552696f, 0.18703225f, 0.02525772f, 0.21312542f, 
    -0.03069227f, 0.15001902f, -0.16196814f, -0.30395317f, -0.08867847f, 0.02929893f, -0.19728208f, -0.06576570f, 
    -0.02682467f, -0.01662983f, -0.28438938f, -0.47418252f, -0.22829440f, 0.71213019f, -0.11947858f, -0.04401871f, 
    0.13738029f, 0.11870580f, -0.05522100f, 0.14372253f, -0.14300032f, 0.31337845f, -0.21865495f, 0.25314084f, 
    0.74801207f, 0.07634236f, 0.49248531f, -0.05527696f, -0.03217375f, 0.07458434f, -0.12169029f, -0.01904218f, 
    -0.15968043f, -0.00038936f, 0.00636173f, -0.26779360f, 0.14007662f, -0.38744983f, 0.48621124f, 0.13288383f, 
    0.16853762f, 0.11909141f, 0.28845569f, -0.24342297f, 0.06241182f, 0.00498125f, 0.03161739f, 0.07806876f, 
    -0.30452052f, -0.32906884f, 0.16960268f, 0.05264113f, -0.21488233f, -0.07587975f, 0.13341969f, -0.01103235f, 
    -0.08981073f, -0.02648383f, -0.08440008f, 0.03141097f, -0.27503636f, 0.04265055f, -0.60880178f, 0.34230992f, 
    0.33140159f, 0.00563402f, -0.01056945f, 0.07563504f, 0.06230561f, 0.06393044f, 0.02106806f, -0.13179930f, 
    0.60821778f, -0.11315630f, 0.24780136f, 0.03510714f, -0.13116626f, 0.02267788f, -0.24397045f, 0.09256011f, 
    -0.08683037f, 0.00191164f, -0.12887245f, 0.05808214f, -0.38637456f, 0.21994142f, -0.22759074f, 0.08545619f, 
    0.03295784f, 0.08764282f, 0.02942877f, 0.00746245f, -0.18868557f, 0.22007026f, -0.08763542f, 0.00710836f, 
    -0.17864910f, -0.23808174f, 0.43594253f, -0.09443301f, -0.07021905f, -0.07898412f, -0.00011489f, 0.05261035f, 
    -0.01268444f, 0.07063465f, -0.07792118f, -0.08786144f, 0.20956050f, -0.45577776f, 0.02303054f, -0.18790822f, 
    0.10084579f, 0.04086368f, 0.05939404f, 0.12835784f, -0.07337786f, 0.24020152f, 0.14982189f, -0.01290330f, 
    -0.07414577f, -0.24091116f, -0.08930213f, 0.00943991f, -0.14655712f, -0.20507064f, -0.36356211f, -0.17347956f, 
    0.06223236f, -0.11251431f, -0.10954192f, -0.07962780f, -0.03703746f, -0.17060567f, 0.18299191f, -0.17316903f, 
    0.05787410f, -0.07438242f, 0.07597011f, -0.09922326f, 0.00606928f, 0.08314423f, 0.03335181f, 0.01981941f, 
    -0.05077539f, -0.15769121f, -0.13416915f, -0.08926813f, -0.04003650f, 0.09655663f, 0.05154292f, -0.10374082f, 
    -0.04330534f, 0.04326958f, -0.02462562f, -0.19200265f, -0.02971177f, -0.17459266f, 0.15919475f, 0.15525053f, 
    -0.17897326f, -0.32083642f, 0.01714930f, 0.00908210f, 0.13186477f, 0.08653491f, 0.04123984f, 0.11834820f, 
    0.26897582f, -0.08195878f, 0.26681525f, -0.25574395f, -0.13822496f, 0.19168127f, -0.12940638f, -0.08049472f, 
    0.10412705f, 0.12103966f, 0.19336522f, 0.11495121f, -0.39763388f, 0.09817138f, -0.26036400f, 0.11886869f, 
    0.03402946f, -0.05561448f, 0.13913043f, -0.10932782f, 0.02443004f, -0.03316965f, -0.07037040f, 0.09186135f, 
    0.22313879f, 0.17713408f, -0.04392192f, 0.01591775f, -0.00486492f, -0.01721981f, 0.07803302f, 0.07550257f, 
    -0.09091901f, 0.02845348f, -0.09262144f, -0.22600837f, -0.18860948f, -0.04620232f, -0.10192730f, -0.05065961f, 
    0.04188832f, 0.11572590f, 0.07147103f, 0.09127248f, -0.06388485f, 0.14303362f, 0.25448778f, 0.00686004f, 
    -0.47133631f, 0.22779107f, -0.06476581f, 0.20194180f, -0.19708206f, 0.29400608f, 0.01801961f, 0.07235959f, 
    -0.09592947f, 0.16482288f, -0.05053715f, -0.07207709f, 0.17608581f, -0.28867787f, 0.85129845f, 0.22546105f, 
    0.04004037f, -0.13555507f, 0.12270813f, 0.13464418f, 0.16097763f, 0.00942741f, 0.03293650f, 0.00334695f, 
    -0.13716412f, 0.30812067f, -0.25146139f, 0.10268363f, 0.09291352f, -0.08073588f, 0.24230134f, 0.04003110f, 
    0.08103595f, -0.06916793f, -0.06547241f, -0.03832464f, 0.08172261f, -0.23524252f, 0.35364649f, 0.00716131f, 
    0.17587245f, 0.00762123f, 0.25544277f, 0.17117013f, -0.31080842f, -0.02905603f, -0.18900867f, -0.04503857f, 
    -0.34104827f, -0.05307435f, -0.14016545f, 0.05578212f, 0.01976070f, -0.02454696f, 0.04576167f, 0.02208746f, 
    -0.17001598f, -0.01944919f, -0.02032059f, -0.10704336f, 0.03860850f, 0.09089330f, 0.01448688f, -0.59958726f, 
    -0.00586179f, -0.08413566f, -0.06976838f, 0.15413089f, -0.10911477f, 0.03171437f, 0.20292665f, 0.09442589f, 
    -0.72407389f, -0.39527676f, -0.39386511f, 0.15129079f, 0.27841708f, -0.11270539f, 0.16974050f, -0.18638539f, 
    -0.01660318f, -0.02345983f, 0.17868097f, 0.25239372f, -0.76802683f, 0.34395254f, -0.29536620f, 0.11988094f, 
    -0.06465015f, -0.06267585f, 0.03957786f, 0.10002978f, -0.19768219f, -0.14370508f, -0.22546463f, 0.13511011f, 
    -0.59779447f, -0.43996093f, -0.28154948f, 0.30304429f, -0.45601541f, -0.19389643f, -0.09169526f, -0.21122165f, 
    0.11512294f, 0.06924526f, 0.03070326f, 0.06302638f, -0.13427091f, 0.20985396f, -0.57401079f, -0.34125957f, 
    0.04402965f, -0.22698103f, 0.43764165f, -0.24682368f, 0.14257178f, 0.01683902f, -0.12963487f, -0.01192022f, 
    0.02066759f, -0.16059850f, 0.99615443f, -0.58503956f, 0.03062862f, 0.04693674f, -0.21700108f, -0.01082951f, 
    -0.14924255f, 0.20464554f, 0.17034066f, 0.05450968f, 0.32507065f, 0.19892594f, 0.18493599f, -0.13724583f, 
    -0.09942316f, 0.21776667f, -0.11561638f, -0.01141849f, -0.02794682f, 0.02997130f, 0.02914777f, -0.05275562f, 
    -0.09873291f, 0.03989861f, -0.06857166f, -0.36399922f, -0.06641530f, -0.12726298f, -0.33157659f, 0.07333393f, 
    -0.02001625f, 0.03852440f, -0.16521347f, -0.18055323f, 0.23618226f, -0.10458917f, 0.23731223f, 0.15848486f, 
    0.27975732f, -0.06042155f, 0.01594935f, -0.12420127f, -0.07598055f, 0.01623463f, -0.16059211f, -0.17229882f, 
    0.06049888f, 0.12004118f, 0.15994796f, -0.41367149f, 0.04146061f, -0.04614248f, 0.19579631f, 0.16798463f, 
    0.08940657f, 0.08225401f, 0.32237235f, 0.14648131f, -0.46868232f, -0.13924229f, -0.15834656f, 0.58465850f, 
    0.09904490f, -0.07712824f, 0.02108224f, 0.24032104f, -0.25880200f, -0.23286867f, -0.03898086f, 0.11586298f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22490612f, 0.11580899f, 0.07753965f, -0.09637441f, -0.09502060f, 0.06481493f, 0.02242354f, -0.11505881f, 
    0.14562963f, 0.06336168f, -0.01362850f, -0.06108754f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
