#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.81375533f, -0.76846421f, -0.64342576f, 0.00937185f, -0.13399777f, 0.11967438f, 0.57010823f, 0.35421365f, 
    0.53890699f, 0.92718166f, 0.20886251f, 0.49243861f, 0.05981762f, -0.60847163f, 0.02890946f, 0.33161366f, 
    -0.10589008f, -0.33844528f, -0.66080320f, -0.54811215f, -0.33942121f, 0.34764314f, -0.73525608f, -0.79193127f, 
    -0.12044221f, 0.24552445f, 0.19004162f, 0.63950080f, 0.36591023f, 0.72436875f, -0.18255620f, -0.10513803f, 
    -0.38383114f, 0.17839652f, 0.06351662f, 0.24263839f, -1.03216469f, -0.81511647f, 1.03342533f, -0.18841563f, 
    -0.42151931f, -0.26261011f, -0.06467944f, -0.17006943f, -0.37765670f, -0.15852207f, 0.86839706f, 0.09044964f, 
    0.73252219f, 0.73573887f, 0.87161511f, -0.08827674f, 0.09224541f, 0.20398872f, -0.36784661f, -0.03116276f, 
    0.61399764f, -0.34122714f, 0.21467230f, 0.36204880f, 0.28630364f, 0.20706387f, -0.80360073f, -0.06205229f, 
    -0.41139174f, -0.01410333f, -0.38316062f, -0.58590770f, -0.69869637f, -0.29928681f, -0.09615386f, -0.39432523f, 
    0.05453638f, -0.31952363f, -0.08675696f, -0.72783309f, 1.30870783f, -0.96769041f, -0.15733619f, 0.20184919f, 
    -0.00490240f, 1.30705655f, -1.11224210f, -0.07819167f, 0.05193782f, 0.26423964f, -0.41383377f, -0.14298818f, 
    0.00813661f, -0.17412511f, -1.06132519f, -0.57903600f, -0.54620928f, 0.21403836f, 0.63253015f, -0.47883868f, 
    -0.30765331f, -0.06014187f, -0.44416440f, 0.11674135f, -0.81749535f, -0.66572672f, 0.39007527f, 0.26870927f, 
    0.63558465f, -0.13990428f, -0.18056153f, -0.68638635f, 0.52657467f, -0.34052905f, 0.85011095f, 0.17120829f, 
    0.16246191f, 0.50597250f, 0.33521473f, -0.22659086f, 0.00174215f, 0.54160279f, -1.06498039f, 0.82770884f, 
    -0.79740912f, -0.20876826f, -0.17354521f, -0.20171498f, 0.38804153f, 0.35364416f, -0.03547762f, 0.04616758f, 
    0.12317037f, 0.13900653f, -0.83855832f, -0.63596129f, 0.36569482f, 0.15501940f, 0.19103053f, 0.35011691f, 
    0.33027184f, 0.50298119f, -0.38221520f, 0.24242787f, -0.68943548f, 0.24434175f, 0.29322234f, 0.68317944f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27119443f, 0.35458267f, -0.40301821f, -0.27141073f, -0.42784941f, 0.01704079f, 0.58339715f, 0.51747578f, 
    -0.00325503f, 0.22709811f, -0.20222189f, 0.22593240f, 0.38024771f, 0.26472127f, 0.58903384f, 0.43454242f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02052841f, 0.18666703f, 0.09933729f, 0.19366485f, 0.20995110f, 0.04874198f, -0.17700449f, 0.06984016f, 
    -0.23195128f, 0.04530444f, 0.21257035f, -0.06864282f, 0.01790698f, -0.14174682f, -0.05884798f, 0.16241212f, 
    0.02332394f, -0.01925787f, 0.12473410f, -0.12995386f, 0.11529002f, 0.24238674f, 0.06311383f, 0.17951351f, 
    -0.06343192f, 0.00916029f, -0.06103131f, 0.07763978f, 0.05526299f, -0.17617682f, -0.06435241f, -0.23079441f, 
    -0.07229917f, 0.17501526f, 0.00419613f, 0.11414772f, 0.21565868f, 0.31473771f, 0.37270576f, 0.34403586f, 
    0.01996138f, 0.16308655f, 0.17589265f, -0.20765415f, -0.04101175f, -0.29223010f, 0.07320974f, -0.12802178f, 
    0.05326784f, -0.00179401f, 0.22097602f, -0.15889339f, -0.11735328f, -0.19145395f, 0.05934969f, -0.03176158f, 
    -0.23434421f, -0.20637831f, 0.14410058f, -0.01106882f, -0.02269567f, -0.13970757f, 0.13633299f, -0.02570628f, 
    0.07978521f, 0.26628730f, 0.15052131f, 0.09091920f, -0.02418065f, -0.12037135f, 0.00610397f, -0.00971952f, 
    -0.03204789f, -0.15191557f, -0.08156901f, -0.02492314f, 0.15896770f, 0.15759063f, 0.09041360f, -0.05578150f, 
    0.07034801f, -0.07804251f, 0.34374207f, 0.02274642f, -0.08812511f, 0.01974398f, 0.23553720f, 0.21402410f, 
    0.23955773f, 0.11469373f, 0.00060142f, -0.62071550f, 0.08152920f, 0.16763835f, -0.12354575f, -0.01517626f, 
    0.00669083f, 0.07010759f, 0.04211229f, -0.32996109f, 0.00787349f, 0.06660932f, 0.01376604f, 0.23747727f, 
    0.18851912f, 0.14124316f, 0.35106593f, 0.19223815f, 0.43894246f, -0.08879757f, -0.15033109f, 0.00811650f, 
    0.03551800f, -0.01663205f, 0.21633221f, -0.05158054f, 0.09530602f, 0.07642259f, 0.27993807f, -0.22941132f, 
    0.01112254f, 0.14828970f, -0.35348159f, 0.06986998f, -0.05871820f, -0.14780481f, 0.24525310f, 0.06633855f, 
    -0.04313689f, 0.03593423f, -0.04162963f, -0.15384498f, 0.06976736f, -0.05692178f, -0.16703390f, 0.18649514f, 
    0.09398390f, -0.07414295f, 0.03573773f, -0.01629068f, 0.15862957f, -0.17607740f, -0.23171602f, -0.16645746f, 
    0.13068612f, -0.22663619f, -0.42100954f, 0.09536380f, 0.21782994f, 0.21258871f, 0.06777214f, -0.05847499f, 
    -0.18770131f, 0.39087692f, -0.09482217f, -0.08245341f, 0.15991017f, 0.11579263f, 0.05511834f, 0.05310181f, 
    -0.16375795f, 0.10883126f, 0.07477935f, -0.25172141f, 0.57860345f, -0.09141894f, 0.01760978f, -0.26338691f, 
    -0.06309791f, -0.15860945f, 0.19581455f, 0.20995562f, -0.41691265f, -0.26756355f, 0.14873645f, 0.07355595f, 
    0.09630422f, -0.05367781f, -0.02153409f, 0.16991496f, 0.29990229f, -0.28769198f, -0.02188250f, -0.02621891f, 
    -0.22387859f, -0.02474066f, -0.06401692f, 0.27438712f, 0.12600997f, 0.14674802f, 0.30046538f, -0.10662761f, 
    -0.32864743f, -0.07481837f, -0.01001200f, 0.13612774f, 0.03943361f, 0.12905203f, 0.10563900f, 0.06924848f, 
    0.03983184f, 0.00808409f, 0.10574177f, -0.17280334f, 0.01530601f, -0.02784316f, 0.01272141f, -0.42524517f, 
    -0.99023604f, -0.29404438f, -0.06888199f, 0.06211291f, -0.09505265f, 0.09041199f, -0.12963732f, 0.17000669f, 
    -0.85762393f, -0.51656300f, 0.43817809f, 0.03149743f, 0.04357919f, -0.10825847f, 0.17505918f, 0.15361033f, 
    -0.06347464f, 0.10555711f, -0.15997626f, 0.23330608f, 0.01338283f, 0.05554883f, 0.12991425f, 0.12308823f, 
    0.00168147f, -0.00864702f, 1.18415487f, -0.18779461f, -0.58213747f, 0.03743465f, -0.05586861f, 0.09822787f, 
    -0.09169845f, 0.01931401f, -0.06756992f, -0.25039127f, -0.36956438f, -0.60491472f, 0.23704678f, 0.11127479f, 
    0.16104558f, 0.22041491f, 0.16029406f, 0.09860477f, 0.28221259f, 0.02057874f, 0.16074900f, 0.05517997f, 
    -0.08126710f, -0.04992617f, -0.03276357f, 0.09293779f, 0.10387575f, -0.06588035f, -0.44255331f, -0.04740286f, 
    0.00717420f, -0.00687826f, 0.04245510f, 0.09834394f, 0.11591171f, -0.17421566f, -0.75930846f, -0.92991227f, 
    0.14020650f, 0.03629924f, -0.00373734f, -0.18969570f, -0.06016315f, -0.03419792f, -0.00957834f, -0.08476614f, 
    0.02856985f, 0.25265551f, -0.02618086f, 0.04176377f, 0.04456699f, -0.02992267f, 0.02295359f, 0.22530463f, 
    -0.19640458f, -0.08069938f, -0.32517594f, 0.22392370f, 0.00823012f, 0.10229357f, 0.19820525f, -0.04221169f, 
    0.09395958f, 0.29703236f, 0.15900758f, 0.22894584f, -0.04136043f, 0.14127882f, 0.08091514f, 0.16619806f, 
    0.14045765f, -0.01330809f, 0.21572219f, 0.26044828f, 0.38079268f, -0.20087977f, -0.00514501f, -0.22819249f, 
    0.03548582f, 0.14339648f, 0.03926484f, 0.47756729f, 0.21852492f, -0.08720627f, -0.15029758f, 0.03007215f, 
    -0.14400640f, 0.20615327f, 0.02076987f, 0.18706755f, -0.38606289f, -0.16281259f, 0.26502386f, 0.06835025f, 
    0.27399048f, 0.22045751f, -0.10775816f, -0.06285606f, -0.01279708f, -0.13622834f, 0.14178659f, -0.09572441f, 
    -0.03571073f, -0.19243257f, -0.15023404f, -0.02651418f, -0.15167286f, -0.06281062f, 0.04849521f, 0.15173507f, 
    0.32942083f, 0.02853061f, -0.07885650f, -0.10612163f, -0.23644143f, 0.19926226f, 0.12286568f, 0.36419728f, 
    -0.01799915f, 0.07743048f, 0.07526733f, 0.02887356f, -0.07296101f, 0.07189695f, 0.13664277f, -0.10178950f, 
    -0.14566842f, -0.40730941f, 0.04874488f, 0.15666802f, 0.02310983f, -0.08791480f, 0.03729817f, -0.06808301f, 
    -0.13074002f, 0.15657347f, -0.26141271f, -0.22851859f, -0.06787433f, 0.10390845f, 0.22265643f, -0.12932114f, 
    -0.15100557f, -0.06068862f, -0.16983186f, -0.02848320f, -0.15414633f, -0.02443350f, -0.19230707f, -0.32067969f, 
    0.01974658f, -0.08157632f, 0.14531714f, -0.53677654f, -0.34455463f, -0.37792537f, -0.13015127f, 0.07035069f, 
    -0.17133363f, -0.13212438f, -0.24468751f, -0.00952964f, 0.31751111f, 0.39294308f, 0.25740761f, -0.23057972f, 
    0.11870040f, -0.09549880f, -0.07946334f, 0.02486364f, -0.08177458f, 0.09254705f, 0.29677632f, -0.38350409f, 
    0.08119208f, 0.09451485f, 0.08943674f, 0.07826474f, 0.09677505f, 0.10537892f, -0.29703847f, -0.14724022f, 
    0.01844912f, -0.05151973f, 0.19162062f, 0.03958312f, -0.00453510f, 0.18462473f, -0.14758892f, 0.25609303f, 
    0.30305117f, 0.28939962f, 0.24994807f, 0.09168188f, 0.01227575f, -0.04278993f, 0.11262652f, 0.21159224f, 
    0.11906074f, -0.18677865f, 0.44718891f, -0.20140323f, 0.09048415f, -0.09650956f, -0.17168860f, -0.06193304f, 
    -0.00974485f, -0.12651528f, 0.08610842f, 0.07375636f, -0.04076677f, -0.05566091f, -0.17811047f, -0.00347200f, 
    -0.08708592f, -0.12074511f, -0.33736488f, -0.02061197f, -0.10112721f, 0.27712303f, 0.05106403f, 0.09349822f, 
    -0.04180725f, -0.25920525f, -0.01936817f, -0.00434798f, 0.36432979f, 0.07944215f, 0.19013289f, -0.01476523f, 
    -0.17416073f, -0.05638700f, 0.01424266f, 0.16192450f, -0.12612727f, 0.45674601f, -0.12212607f, 0.00654999f, 
    -0.02914041f, 0.19201119f, -0.12895785f, -0.06241329f, 0.09792275f, 0.00134649f, -0.08726889f, -0.08105928f, 
    0.20492736f, -0.15509081f, 0.03016526f, 0.09671475f, 0.16090825f, -0.01973517f, -0.19524723f, 0.19870938f, 
    0.00669862f, -0.06939978f, 0.32415521f, 0.20027375f, -0.11631054f, 0.09750932f, -0.21299331f, -0.07768454f, 
    0.02161782f, -0.20210949f, 0.14050263f, -0.08510492f, -0.10288730f, 0.01857214f, -0.11549021f, 0.12238680f, 
    0.27144098f, -0.03547269f, -0.02372265f, -0.08158179f, 0.01511942f, 0.00453631f, -0.07399136f, 0.33331728f, 
    0.00155884f, 0.05532888f, 0.12237621f, 0.87294209f, 0.02763367f, -0.06961051f, 0.04448016f, 0.14789642f, 
    -0.01333529f, -0.03082139f, -0.17129004f, -0.26156554f, -0.24331336f, -0.02562526f, 0.09012384f, 0.01497162f, 
    0.13885991f, 0.06902248f, 0.14829706f, 0.12080023f, -0.55820227f, 0.05864055f, -0.01787545f, -0.03918153f, 
    0.08894709f, 0.00611085f, -0.02441190f, 0.07539343f, -0.07813690f, 0.20401664f, 0.29612759f, -0.03034507f, 
    -0.07166316f, -0.07440551f, 0.08552616f, -0.03832886f, -0.11138464f, -0.29015845f, 0.30776933f, 0.26978180f, 
    0.27930176f, -0.01649013f, 0.22422378f, 0.14887518f, -0.17576002f, -0.06104030f, -0.17736214f, -0.18801409f, 
    -0.07551610f, 0.07868878f, 0.04183919f, -0.02688285f, -0.02323674f, -0.08626642f, -0.03248889f, 0.05950531f, 
    0.23114219f, -0.17648530f, 0.07129070f, 0.19322383f, 0.12279188f, 0.14191008f, 0.04949972f, 0.04519714f, 
    0.19889519f, 0.14547621f, -0.07519972f, -0.02809602f, 0.10768577f, -0.08912397f, 0.14223604f, 0.10144600f, 
    0.16380583f, -0.70085269f, -0.29954907f, -0.12964064f, 0.05314435f, 0.08317900f, 0.20291026f, 0.07234517f, 
    -0.02151200f, 0.12417918f, 0.49654019f, 0.34631765f, 0.10220005f, -0.00673262f, -0.01529541f, 0.32447964f, 
    -0.17312297f, -0.06237713f, 0.00719444f, -0.30489326f, -0.16729578f, 0.22075291f, 0.07188401f, 0.03159784f, 
    0.10209633f, 0.13664052f, 0.18799289f, 0.15353814f, 0.66086966f, 0.17991216f, -0.08633377f, -0.01642099f, 
    -0.04860292f, -0.29618171f, 0.01706640f, 0.09453151f, -0.18971604f, 0.04794192f, 0.09881554f, 0.20170593f, 
    0.00762955f, -0.13254434f, -0.18424828f, -0.10796373f, 0.00728560f, -0.02540664f, 0.00206625f, -0.40035608f, 
    0.11960158f, 0.13856785f, -0.02337863f, -0.00527261f, 0.00692929f, -0.27711773f, 0.15465863f, 0.00878651f, 
    0.06183562f, -0.08595882f, -0.02005287f, 0.04640052f, -0.08385531f, -0.03629740f, -0.05467630f, 0.06952032f, 
    -0.24418065f, 0.04346599f, -0.00913341f, -0.01693442f, -0.24254070f, -0.02759510f, -0.11444062f, 0.18771642f, 
    -0.23654617f, -0.06558137f, -0.12890024f, -0.10816567f, 0.11022311f, -0.12231325f, -0.01084685f, 0.01731120f, 
    0.20461901f, -0.06245255f, 0.64755350f, 0.06957826f, -0.26331171f, -0.01204263f, 0.09921562f, 0.26576513f, 
    0.05843045f, 0.00511457f, 0.07396017f, 0.63628370f, -0.01439797f, 0.06033827f, -0.12722242f, 0.00635919f, 
    0.03599001f, 0.10365941f, -0.21817200f, -0.17488970f, -0.13163765f, -0.19394739f, -0.09487848f, 0.07591294f, 
    0.17176378f, -0.05019268f, 0.00042135f, 0.03050587f, 0.06022910f, -0.12279618f, 0.11683285f, -0.00847344f, 
    -0.04475699f, -0.02856484f, 0.15425681f, 0.18838453f, 0.09338690f, -0.05585188f, 0.10246213f, 0.19750935f, 
    -0.02032644f, -0.14881423f, -0.14439715f, 0.02715954f, 0.02638187f, 0.03171663f, 0.13517827f, -0.12648106f, 
    0.02912342f, 0.13210669f, -0.12711462f, -0.03007268f, 0.12864330f, 0.12937377f, 0.22843443f, 0.06777862f, 
    -0.48722628f, 0.07525674f, -0.32640710f, 0.03055107f, -0.01288906f, 0.19223298f, 0.07588101f, -0.09348411f, 
    -0.03064444f, 0.14427614f, 0.23468237f, 0.20395432f, -0.13419230f, 0.00199807f, -0.20770301f, -0.02443857f, 
    0.18027516f, -0.07401977f, 0.07463163f, -0.57033902f, -0.09826498f, 0.15487054f, -0.28249049f, -0.29292411f, 
    -0.05910518f, 0.11064917f, 0.13072896f, 0.16551390f, -0.30828035f, -0.36333960f, -0.18852930f, -0.32679749f, 
    -0.17602155f, -0.20842773f, -0.16695501f, -0.26901603f, 0.36273500f, -0.11768027f, -0.57086486f, -0.26680017f, 
    0.01262948f, -0.30678964f, -0.05023018f, 0.06344949f, -0.02345983f, -0.02392333f, -0.38218409f, -0.50704759f, 
    -0.00804480f, -0.05511732f, 0.21148095f, -0.00234845f, -0.16382129f, 0.09731382f, 0.32867676f, 0.35494834f, 
    0.12675580f, 0.04789585f, 0.09969907f, 0.13048965f, 0.19218095f, 0.19720480f, 0.20176935f, -0.02196344f, 
    -0.10070262f, -0.17497016f, -0.01710523f, 0.05473998f, -0.03150083f, 0.15420716f, -0.14057206f, 0.00486824f, 
    -0.29839790f, -0.97834325f, 0.68669051f, 0.09086154f, 0.13980074f, -0.00091861f, 0.03412843f, -0.01514176f, 
    0.04693393f, -0.09654102f, -0.06503223f, -0.04897687f, -0.21827082f, 0.18260695f, 0.32826236f, 0.10061508f, 
    0.00196805f, -0.02269446f, -0.29411912f, -0.44113910f, 0.56967348f, 0.09656388f, -0.09404322f, -0.09442158f, 
    -0.20078199f, -0.03492586f, 0.00684405f, -0.36542255f, 0.21063790f, 0.16782725f, 0.16099703f, 0.01064457f, 
    0.21701841f, -0.07003982f, 0.17819647f, 0.33837578f, 0.41828769f, 0.26349625f, 0.30953857f, 0.04491124f, 
    0.06082877f, 0.01099176f, 0.18097520f, -0.00589985f, 0.09816747f, 0.39968294f, -0.94196641f, -0.37364721f, 
    -0.08804672f, 0.06512730f, 0.11868767f, 0.15601254f, -0.06054824f, -0.05456335f, -0.39708930f, -0.13867597f, 
    0.24454871f, 0.03688808f, -0.11349447f, -0.17952998f, 0.20066459f, 0.13378200f, 0.02920356f, 0.14963333f, 
    -0.03920758f, 0.10897052f, 0.14106835f, -0.02420392f, -0.16901341f, 0.13007161f, 0.05747666f, 0.15783606f, 
    0.00709120f, 0.06264010f, 0.01031771f, 0.07657844f, -0.05323295f, -0.02392502f, 0.02216434f, 0.01755690f, 
    -0.06939055f, 0.03459588f, 0.04682709f, -0.00103970f, -0.05820735f, 0.07036361f, 0.05308955f, -0.05824843f, 
    -0.05766375f, 0.01659892f, 0.01792411f, 0.04935762f, 0.02260226f, -0.06035922f, 0.02788837f, -0.01674614f, 
    0.06257976f, 0.01093689f, 0.00850516f, 0.05470494f, 0.02424446f, -0.07075707f, -0.00988161f, -0.05278604f, 
    0.01938837f, -0.08408415f, -0.03449913f, -0.05075806f, -0.04335302f, -0.03291541f, 0.00008617f, 0.00614623f, 
    -0.04606537f, -0.03642331f, -0.01493636f, 0.03119929f, 0.02854423f, -0.06396950f, -0.01816264f, -0.00735263f, 
    -0.01336910f, 0.00075028f, 0.02926979f, 0.06539861f, -0.02592242f, 0.03531595f, -0.06779177f, -0.03104366f, 
    -0.06557465f, -0.08145560f, -0.08832874f, -0.02751920f, -0.07537863f, -0.07734837f, -0.01403159f, -0.04760097f, 
    -0.08389879f, -0.07490643f, 0.04318976f, 0.02676764f, -0.04136093f, -0.00311560f, 0.02934010f, 0.02503864f, 
    -0.05775331f, -0.07734323f, 0.03893200f, -0.07680014f, -0.01671429f, -0.00913486f, -0.06780796f, -0.04939019f, 
    -0.06195984f, -0.07813809f, -0.01335848f, 0.04557210f, 0.07296535f, 0.01344263f, 0.02066702f, -0.04732262f, 
    0.06927997f, 0.05760794f, -0.03714627f, -0.07001453f, 0.04280996f, 0.03548416f, 0.07202655f, -0.04418042f, 
    0.00590731f, -0.07228555f, -0.07619637f, -0.04403411f, 0.04406663f, -0.01138021f, -0.02853691f, -0.04786876f, 
    0.00789535f, -0.04350605f, -0.04576382f, -0.07993659f, -0.05306047f, 0.01682983f, 0.07603186f, 0.06172071f, 
    0.07232865f, -0.06365412f, -0.08873912f, -0.00625526f, -0.06167703f, 0.04135806f, -0.03047554f, -0.09070535f, 
    0.04707661f, -0.04765431f, -0.06886237f, -0.08649410f, 0.03995685f, -0.03778740f, -0.07298738f, 0.00843679f, 
    0.06336591f, -0.00288169f, -0.06830708f, 0.05900498f, 0.07000161f, -0.04915466f, 0.02891218f, -0.00209673f, 
    -0.09041597f, -0.06391915f, 0.04300014f, -0.05006833f, -0.07232862f, 0.00881133f, -0.01518434f, 0.05171313f, 
    0.16484338f, 0.20552702f, 0.24337593f, -0.03024584f, -0.10058897f, -0.10412306f, 0.29297361f, 0.18668649f, 
    -0.01635732f, -0.26060086f, -0.15114214f, 0.16101855f, 0.25243297f, 0.21869811f, 0.16202581f, 0.02336055f, 
    0.04950787f, -0.03294519f, -0.19042662f, 0.15941972f, 0.09003020f, 0.05613682f, 0.04401578f, 0.06342503f, 
    0.14014679f, -0.11762363f, -0.03151919f, -0.19994989f, -0.06427251f, 0.11277312f, 0.21579032f, 0.24410665f, 
    0.03091563f, 0.18125370f, 0.09986166f, -0.02313989f, -0.32880700f, 0.42166588f, 0.18975364f, 0.13234417f, 
    -0.00768794f, 0.15380183f, 0.00266621f, -0.06892849f, -0.49687862f, 0.00864862f, -0.15508914f, -0.16351229f, 
    0.27318189f, 0.32064143f, -0.03327442f, -0.04746414f, -0.28327650f, 0.07616446f, -0.09995420f, -0.04955817f, 
    0.27202556f, 0.12160066f, 0.14545152f, 0.22005162f, -0.46165469f, -0.03159728f, -0.07983197f, -0.30288801f, 
    0.18023159f, -0.11002553f, 0.11188842f, 0.07778356f, 0.09492477f, -0.08076746f, -0.28448525f, -0.32160804f, 
    0.31837881f, 0.13650519f, 0.37492764f, 0.16379206f, 0.23779735f, 0.01945063f, -0.06964252f, 0.11476815f, 
    -0.10721055f, -0.09411672f, 0.32737988f, 0.02945885f, 0.06972818f, 0.13321705f, 0.17363469f, 0.01223289f, 
    -0.34249243f, -0.06797330f, -0.13972497f, 0.17691569f, 0.04326209f, 0.03437070f, -0.07126468f, -0.07478146f, 
    -0.10429067f, 0.09803508f, 0.12039486f, 0.00990054f, 0.11596491f, -0.16956146f, -0.01882198f, 0.05761425f, 
    -0.08634373f, -0.39338714f, -0.20376952f, -0.31269228f, -0.10827103f, -0.15627554f, 0.05843842f, 0.00593180f, 
    0.22684772f, 0.01028216f, -0.15494323f, -0.04895811f, -0.04182933f, 0.11634219f, 0.18184268f, 0.43957779f, 
    0.16922741f, 0.15059648f, 0.02353355f, 0.13639751f, -0.08152045f, 0.03892064f, -0.12277468f, 0.15492021f, 
    -0.01925075f, -0.02136007f, 0.14803539f, 0.15390815f, 0.15215723f, 0.14686233f, -0.25829798f, 0.00472844f, 
    -0.06314944f, -0.08737306f, 0.12663342f, -0.04335906f, -0.04147541f, 0.10773897f, 0.26373443f, 0.41761386f, 
    -0.03242958f, 0.03263285f, -0.00854232f, 0.01838884f, 0.02068102f, 0.01929327f, -0.05981076f, -0.03529221f, 
    0.05238934f, 0.06806365f, 0.05697029f, -0.01952092f, -0.01914748f, -0.09660606f, -0.03766829f, 0.03158835f, 
    0.01909637f, -0.06294373f, 0.00086719f, 0.06534316f, -0.07470757f, 0.01815601f, -0.03661547f, 0.04100700f, 
    -0.01782160f, 0.02859165f, -0.02967802f, 0.02186167f, -0.04586140f, -0.01665169f, 0.05808881f, 0.03370373f, 
    -0.04717258f, 0.05677232f, -0.04467999f, -0.02696764f, 0.04519615f, -0.02874530f, 0.02854171f, -0.06298602f, 
    0.00382192f, -0.02735441f, -0.01846256f, -0.00853550f, 0.04420008f, -0.00763996f, -0.07997736f, 0.02721155f, 
    -0.08493908f, -0.08201030f, -0.07214987f, -0.07675735f, -0.00556127f, -0.07512689f, -0.08431610f, -0.02011554f, 
    -0.02226867f, 0.03545780f, 0.02512669f, -0.00958965f, 0.00713913f, 0.06864142f, -0.07543229f, -0.01609770f, 
    -0.01661244f, 0.02762553f, -0.02212574f, -0.08090740f, 0.06692930f, 0.03393754f, -0.08189857f, -0.06757323f, 
    -0.06652874f, -0.08607309f, 0.05473696f, -0.03365371f, -0.05391275f, -0.07403030f, -0.07357377f, 0.04723602f, 
    -0.06469452f, -0.08230338f, 0.06911631f, 0.05965143f, -0.00676647f, -0.07229771f, 0.03917213f, 0.04058731f, 
    -0.08453318f, 0.04946314f, -0.09345334f, -0.05412439f, -0.07947034f, 0.06115365f, -0.02552102f, 0.07369080f, 
    -0.04071911f, -0.00046029f, -0.04400507f, 0.03833710f, -0.04000590f, -0.06701313f, -0.06055468f, -0.04501316f, 
    0.05927671f, 0.04129926f, -0.07278005f, 0.04688013f, -0.07042807f, -0.07901657f, -0.01414136f, 0.01766425f, 
    0.06435218f, -0.06418598f, 0.06204958f, 0.02980510f, -0.00854871f, 0.03869615f, -0.03734389f, -0.05338541f, 
    -0.06549659f, -0.05892473f, -0.05625888f, 0.00580178f, -0.09512655f, -0.07110382f, -0.02287119f, -0.07149524f, 
    0.04744653f, -0.09550343f, -0.06530752f, 0.03266825f, 0.04004304f, -0.02929955f, -0.03216145f, 0.00417036f, 
    0.07132917f, 0.05944240f, 0.05408053f, 0.00442276f, -0.03823134f, 0.05240960f, -0.06787214f, 0.05037302f, 
    -0.05155080f, 0.01583052f, -0.05677588f, 0.02271816f, 0.05105104f, 0.05780511f, -0.02679334f, -0.03466815f, 
    -0.09835672f, -0.09700433f, -0.06826847f, 0.04067273f, -0.03949273f, 0.04643731f, 0.00184478f, -0.02972764f, 
    -0.00208267f, -0.07797047f, -0.04880345f, -0.01610794f, 0.03962523f, 0.04723675f, 0.05867062f, 0.05676110f, 
    -0.09257273f, -0.04452916f, 0.04117968f, 0.01004121f, -0.00941893f, 0.04316792f, -0.04307772f, 0.03621269f, 
    -0.07552549f, -0.06840175f, -0.01678557f, 0.06615869f, -0.04384905f, -0.00609618f, 0.05109661f, 0.02667883f, 
    0.02397661f, 0.04532648f, -0.00056041f, -0.02416938f, -0.05704678f, -0.06471796f, 0.00464100f, 0.06342836f, 
    0.05238478f, -0.06163770f, 0.03160096f, 0.04496673f, 0.06143687f, -0.05848123f, -0.01624270f, 0.02638690f, 
    -0.05239067f, -0.02843922f, -0.06079858f, -0.08592728f, -0.00956045f, -0.08964387f, -0.04327912f, -0.08164565f, 
    0.02267284f, -0.06109046f, 0.04098109f, -0.05396317f, -0.03489839f, -0.01885493f, -0.05950752f, -0.04094881f, 
    -0.07741014f, -0.03035130f, 0.04030802f, 0.06366311f, -0.02001297f, -0.06100089f, -0.02059419f, -0.08341476f, 
    0.00766479f, 0.04385142f, -0.07299303f, -0.05364972f, 0.01441785f, -0.08147116f, -0.07691739f, 0.03675799f, 
    -0.08682616f, 0.06026692f, 0.07174606f, -0.06284093f, -0.00639346f, -0.00841506f, -0.10050610f, 0.01274419f, 
    -0.07838348f, 0.06107108f, -0.03968187f, -0.09359039f, -0.00275475f, 0.03047340f, -0.05525526f, 0.01559905f, 
    -0.03757096f, -0.04313280f, 0.00359008f, -0.06260667f, 0.03903091f, -0.03780663f, -0.09844504f, 0.02057182f, 
    -0.05986374f, 0.04902316f, -0.05499008f, -0.10067783f, -0.08441209f, 0.03426069f, -0.02933915f, 0.07732420f, 
    -0.01137152f, -0.08854859f, -0.08704870f, -0.01824597f, -0.05564873f, 0.05455746f, -0.08325002f, -0.00118805f, 
    0.02506302f, -0.08240817f, 0.02764274f, 0.01749173f, -0.05300221f, 0.01587589f, -0.04197241f, -0.08335908f, 
    0.02390987f, 0.06365182f, 0.00977719f, -0.08867594f, -0.03170060f, -0.07588490f, -0.05215240f, -0.01670895f, 
    -0.02513643f, -0.27687627f, -0.10030502f, 0.04949104f, -0.02719441f, 0.04600425f, 0.07927128f, -0.09286765f, 
    0.33887589f, 0.26485103f, -0.63823014f, -0.68018299f, -0.10939636f, 0.26208705f, -0.12323644f, -0.04295064f, 
    0.03273449f, 0.27621979f, 0.23920618f, 0.14630923f, 0.60096717f, -0.32402194f, -0.13652684f, 0.08801720f, 
    0.05230900f, 0.04693637f, 0.07521199f, 0.04386401f, -0.64738196f, 0.52752030f, 0.08747916f, 0.09226708f, 
    0.11587336f, 0.13255106f, -0.04101543f, 0.17320485f, -0.14789572f, -0.26881656f, 0.16267912f, -0.27252042f, 
    -0.20618115f, 0.24006040f, 0.14676869f, 0.09159099f, -0.09977511f, 0.41180241f, -0.16747601f, -0.82679290f, 
    -0.27353752f, -0.06851605f, -0.02505100f, 0.16224404f, 0.12966783f, 0.08649441f, -0.42654556f, -0.37033239f, 
    0.31974193f, -0.10905152f, -0.13552037f, -0.13849671f, 0.38921168f, -0.10848664f, 0.00308916f, 0.37681523f, 
    0.15583493f, 0.56133264f, -0.01546324f, 0.10607260f, 0.06162366f, 0.08987325f, -0.12981372f, -0.18102136f, 
    -0.83093989f, -0.65738451f, 0.46934387f, 0.00701361f, -0.01768974f, 0.01607384f, 0.13707741f, 0.17819947f, 
    0.06214401f, 0.54446685f, -0.00364531f, -0.09253614f, 0.03384992f, 0.33052817f, -0.10859712f, 0.17109554f, 
    -0.15656227f, 0.00763092f, -0.23073509f, -0.24400297f, 0.05330489f, -0.09517336f, -0.10962177f, 0.10318588f, 
    0.13737974f, -0.03212987f, 0.01204776f, -0.04346114f, -0.31511864f, -0.34258369f, -0.12556683f, 0.19859034f, 
    0.02315358f, 0.15610561f, 0.02517359f, -0.15680774f, -0.10069067f, -0.30467737f, -0.16584998f, -0.01333869f, 
    0.01406287f, 0.09857693f, -0.14013886f, -0.21314910f, 0.00625827f, 0.20116733f, 0.01107122f, 0.18478307f, 
    -0.07252228f, 0.10094485f, -0.06722860f, 0.10440023f, -0.07174726f, 0.12469055f, 0.17071931f, 0.22156242f, 
    0.25889573f, -0.06658657f, 0.13520147f, -0.22070517f, -0.11570038f, 0.01673344f, 0.14367856f, -0.17581201f, 
    -0.37174982f, -0.39195600f, -0.00641833f, -0.13494353f, -0.24770521f, 0.06600516f, -0.03816504f, 0.05542915f, 
    0.01953876f, 0.01630792f, 0.07895527f, 0.05537745f, -0.08927843f, -0.01847361f, -0.09156630f, 0.03071627f, 
    0.02049803f, -0.06758730f, 0.05812018f, 0.03603540f, 0.01743242f, -0.04937863f, 0.05137909f, 0.06589999f, 
    0.03470676f, -0.05692345f, 0.05815937f, -0.06599971f, 0.06503587f, -0.09226192f, 0.05901458f, -0.08484579f, 
    -0.04267733f, -0.01845441f, -0.02759971f, 0.00406517f, -0.02237090f, -0.02787866f, 0.01753811f, -0.07566459f, 
    -0.01965896f, -0.07387649f, -0.03384530f, -0.08199888f, -0.02255532f, 0.01410430f, 0.02473910f, -0.03919670f, 
    -0.04751904f, 0.00023587f, 0.07498003f, 0.02948575f, 0.01413259f, -0.00527658f, 0.01015846f, 0.02567754f, 
    -0.01428074f, 0.01284332f, -0.05632147f, 0.01156595f, -0.08748320f, -0.07009976f, -0.02133983f, -0.08810849f, 
    -0.02537359f, -0.01055167f, 0.05117382f, -0.03777938f, -0.02278666f, -0.07194424f, 0.02996703f, -0.06200375f, 
    0.05969647f, 0.03582172f, 0.01727874f, 0.04284778f, 0.01072973f, 0.04463130f, -0.00221110f, -0.03629073f, 
    0.03247656f, -0.00222947f, -0.00212178f, -0.01409234f, -0.05378615f, -0.07856990f, -0.08694196f, -0.00102002f, 
    0.00217010f, -0.05819889f, -0.00742942f, -0.04680675f, 0.01708141f, -0.06424152f, -0.00442502f, 0.00700742f, 
    -0.02366359f, 0.04689400f, -0.03294782f, -0.00347645f, -0.03029617f, 0.04650646f, -0.07548910f, -0.04705858f, 
    -0.07054237f, 0.02606708f, -0.08551905f, -0.07657491f, -0.07135602f, -0.02294740f, 0.03635440f, -0.08637150f, 
    -0.02041542f, 0.05634986f, 0.06856065f, 0.01504844f, 0.06001712f, -0.07409570f, -0.00164069f, -0.06411885f, 
    -0.06032684f, -0.08179078f, -0.00144841f, 0.01895442f, -0.02405331f, -0.05527943f, -0.05702246f, -0.04711583f, 
    0.05829046f, -0.00784486f, -0.04645761f, -0.00929793f, -0.09298313f, 0.02540412f, 0.00952831f, -0.08301189f, 
    -0.03897680f, -0.02349027f, -0.09688778f, -0.01212187f, 0.06015098f, 0.00029565f, -0.03859948f, 0.06625252f, 
    -0.04296919f, 0.06196465f, -0.00974384f, -0.08081128f, -0.05844771f, 0.05692418f, -0.08057254f, -0.08246459f, 
    0.13688560f, 0.23159966f, 0.19236407f, 0.18079542f, 0.10232557f, -0.11484475f, 0.11142083f, -0.34522137f, 
    -0.27945819f, 0.11067456f, 0.06932606f, -0.20697862f, 0.04076603f, -0.17307420f, 0.12782383f, -0.10344706f, 
    0.17593031f, -0.04899828f, 0.12719822f, -0.33683807f, -0.00974685f, 0.20469107f, -0.11181560f, -0.00729368f, 
    0.06313791f, -0.07407030f, -0.07308968f, 0.15238056f, 0.18200493f, -0.17843391f, -0.09592623f, 0.09524552f, 
    -0.01567434f, 0.14303762f, 0.17474973f, -0.05618317f, 0.36767179f, 0.29522625f, -0.18535589f, -0.19778959f, 
    -0.00101380f, -0.29342195f, 0.01381513f, 0.29494724f, -0.06922433f, 0.10468396f, -0.26305282f, 0.03203239f, 
    0.23060979f, 0.24118781f, 0.08689024f, 0.04402992f, -0.16094416f, -0.08533051f, -0.00167555f, 0.20756793f, 
    -0.35861120f, -0.12559353f, 0.01775290f, 0.09052330f, 0.18970305f, -0.09722271f, 0.28588143f, 0.05962113f, 
    0.08398128f, 0.23823424f, 0.06388973f, 0.22627901f, -0.01464877f, 0.08624151f, -0.03379838f, 0.26215124f, 
    -0.08902389f, 0.43238330f, 0.10619900f, 0.20676653f, -0.29035610f, 0.01724893f, 0.01818212f, 0.06124749f, 
    0.08187693f, -0.29923898f, 0.18597919f, 0.04443304f, -0.00888931f, -0.33181220f, -0.04371159f, -0.09260653f, 
    0.10097161f, 0.22375934f, -0.21605268f, 0.23596556f, -0.27921697f, -0.01633000f, -0.04257100f, -0.06035675f, 
    0.10399477f, 0.00843867f, 0.11943496f, -0.13498548f, 0.07447114f, -0.37074298f, -0.10305275f, -0.05233273f, 
    -0.04954714f, 0.04933563f, 0.11678910f, 0.52239162f, -0.13215964f, -0.27518824f, -0.15124080f, 0.14463684f, 
    0.02409410f, 0.03648945f, 0.00251458f, -0.00626073f, 0.11562725f, -0.37666884f, 0.24424665f, 0.09799661f, 
    0.15801427f, 0.03422430f, 0.13558123f, -0.05967504f, 0.09799295f, -0.14499792f, 0.10330852f, -0.04451588f, 
    0.04741526f, 0.30948579f, 0.27086365f, 0.04351939f, -0.01762979f, -0.14602356f, -0.14529847f, 0.04558437f, 
    0.20049720f, 0.04931748f, -0.02563759f, 0.16542386f, -0.06749282f, 0.14786324f, -0.29631883f, -0.51294732f, 
    -0.05829009f, 0.07840959f, 0.01814579f, 0.01062217f, 0.05999920f, -0.06724194f, 0.02392632f, 0.02759465f, 
    0.20618804f, -0.24135041f, -0.04243846f, 0.08387412f, 0.10787398f, 0.17239864f, -0.00215873f, -0.04234638f, 
    0.21092734f, 0.18932755f, -0.21704702f, -0.39393893f, -0.12858507f, 0.01607732f, -0.03010562f, -0.03882783f, 
    0.14660373f, 0.15827824f, -0.10686877f, -0.45765114f, -0.22415985f, -0.37919241f, -0.27664781f, -0.21188940f, 
    -0.01614937f, -0.18165500f, -0.17192553f, -0.01677963f, -0.13483326f, -0.08365990f, 0.02440197f, -0.08468162f, 
    0.03776937f, -0.11859743f, -0.21347275f, 0.04541169f, 0.07407369f, -0.27159870f, -0.18378448f, -0.17325668f, 
    -0.22693798f, -0.32813531f, -0.53642672f, 0.02929459f, 0.07466511f, 0.07936359f, 0.26678142f, -0.05648094f, 
    0.13249540f, 0.23576969f, 0.15569925f, 0.10097243f, 0.07922367f, -0.12042655f, 0.07390901f, -0.20508179f, 
    -0.10495955f, 0.24827497f, 0.16432837f, 0.14348593f, 0.07673444f, 0.16965929f, 0.06818993f, 0.02272940f, 
    0.15707727f, -0.15583843f, 0.43274364f, 0.16657168f, 0.02380982f, -0.09458999f, 0.19298492f, 0.18042628f, 
    0.22248574f, 0.60402191f, 0.26033610f, 0.16451719f, 0.02482819f, 0.13005410f, -0.16718721f, -0.08945460f, 
    -0.01840356f, 0.17009254f, -0.44933334f, 0.01551395f, 0.09559236f, -0.03521459f, -0.21549241f, 0.08531696f, 
    -0.00399390f, 0.04044941f, -0.09729383f, 0.18146379f, -0.24413551f, 0.06168809f, -0.07529075f, -0.06192666f, 
    0.05145390f, -0.03913848f, -0.10853061f, -0.14275400f, 0.03545425f, 0.03979436f, 0.00729181f, -0.18262742f, 
    -0.09224000f, -0.00809145f, -0.00279995f, -0.11906151f, 0.20653126f, 0.51159149f, -0.06940186f, -0.38772097f, 
    0.02739825f, -0.11090095f, 0.20078874f, 0.08970108f, 0.05147171f, 0.18690197f, -0.08113474f, -0.03022871f, 
    0.04438832f, 0.10914382f, -0.05253932f, 0.27029392f, 0.14931026f, 0.11758863f, 0.05940486f, -0.24062893f, 
    -0.31263536f, 0.19897616f, 0.05825423f, -0.14727329f, -0.04254669f, 0.13498490f, 0.32544574f, 0.41881174f, 
    0.12721641f, -0.49807644f, -0.43289506f, -0.21495715f, -0.05525760f, -0.12446090f, 0.13258329f, 0.11856087f, 
    0.05292017f, -0.27615404f, 0.28200546f, -0.01821149f, 0.28188428f, -0.12624674f, 0.16922572f, 0.22979228f, 
    0.30903661f, 0.07848359f, 0.28247586f, 0.21584499f, -0.02677765f, -0.11279467f, 0.07434835f, -0.20372444f, 
    0.03380118f, 0.05942174f, -0.08483139f, -0.26988533f, 0.05557028f, 0.06214419f, -0.01997832f, -0.14965107f, 
    -0.09200551f, 0.01781844f, 0.16003588f, 0.08567685f, 0.05230509f, 0.09336941f, -0.69500440f, 0.10967650f, 
    0.07071041f, 0.17162175f, 0.05864891f, -0.07487951f, 0.05346679f, 0.05862366f, 0.10410979f, 0.11880870f, 
    -0.10747725f, -0.16927832f, -0.20040520f, -0.11378404f, 0.12568246f, -0.07229156f, -0.07037610f, 0.08085820f, 
    0.15530264f, -0.10216138f, 0.17071162f, -0.02876410f, -0.03397204f, -0.14037393f, 0.05831949f, 0.06207105f, 
    0.06527901f, -0.25513315f, 0.04257232f, -0.04884522f, 0.06894004f, 0.04422218f, 0.02992311f, 0.10049436f, 
    0.09655903f, 0.25684223f, 0.17272322f, -0.16323704f, 0.13368231f, -0.01574449f, 0.11072392f, 0.02688049f, 
    0.03268840f, 0.40298465f, -0.02405238f, -0.40455726f, -0.02357027f, 0.03399863f, 0.11316650f, -0.02047943f, 
    -0.28368449f, 0.02365525f, 0.18907233f, 0.21406344f, 0.08010910f, -0.17276391f, 0.00465173f, -0.24204232f, 
    -0.00809174f, -0.18800145f, 0.01424738f, -0.17823343f, -0.06099620f, -0.22851574f, -0.03871065f, 0.10399420f, 
    -0.14508191f, -0.02387215f, -0.26379514f, -0.22091810f, 0.19226615f, 0.19287029f, 0.22828504f, -0.06790097f, 
    0.02938086f, -0.01206401f, -0.08764102f, -0.10332841f, 0.08988341f, 0.66442919f, -0.02866764f, -0.44218284f, 
    0.07105508f, 0.21385725f, -0.27390796f, 0.04291583f, -0.00178095f, 0.16985652f, -0.01547981f, -0.00319987f, 
    -0.03849619f, -0.03159137f, -0.19145407f, 0.10670624f, 0.01416631f, 0.11605589f, 0.12798129f, -0.27613768f, 
    -0.01145084f, -0.08773889f, -0.04410421f, -0.09735412f, 0.07412832f, 0.09751153f, 0.13934255f, 0.07948259f, 
    0.34985021f, 0.51752186f, -0.04261624f, -0.17865986f, 0.06931386f, -0.10278405f, 0.13896185f, 0.05137984f, 
    0.02984236f, -0.12024121f, -0.12025094f, -0.17543396f, -0.00867533f, 0.23214222f, 0.03711992f, 0.22639158f, 
    0.31916127f, 0.10390905f, -0.80672967f, -0.05275165f, -0.17361970f, -0.35477260f, -0.22325937f, -0.52270854f, 
    0.05232895f, 0.09683295f, -0.05655446f, -0.09965511f, -0.36433768f, -0.17622316f, -0.03492085f, -0.07699561f, 
    0.11999741f, 0.11482459f, 0.02548383f, -0.16666733f, -0.03463402f, 0.00720328f, 0.07695770f, -0.13016404f, 
    -0.06199180f, -0.02662220f, -0.14602007f, -0.05953354f, -0.00816999f, 0.03454034f, 0.13300668f, 0.06941262f, 
    -0.07439848f, -0.02299532f, 0.20621115f, 0.16676208f, -0.11573584f, -0.05795177f, -0.02312676f, -0.05921288f, 
    0.19658566f, 0.08064700f, 0.08224093f, -0.07312557f, 0.03240261f, 0.19820169f, 0.32128039f, -0.11301438f, 
    0.04942323f, -0.31703135f, 0.12483720f, 0.20737441f, -0.05245474f, 0.02142783f, -0.03529092f, -0.09099955f, 
    -0.70148224f, -0.73345625f, -0.40589592f, -0.12129302f, 0.11356964f, -0.13162498f, 0.04111923f, -0.00073180f, 
    0.05864336f, 0.09207097f, 0.12029974f, -0.54808551f, 0.13924478f, 0.02062233f, 0.11515317f, 0.00275233f, 
    -0.21160816f, 0.02174663f, -0.20845237f, 0.56143254f, 0.32719597f, -0.35413191f, 0.07809838f, -0.07541746f, 
    -0.00000946f, -0.09574454f, -0.02635808f, 0.14259908f, 0.20285504f, 0.36673456f, -0.30559629f, -0.14995888f, 
    -0.02378783f, -0.01428481f, 0.08362761f, 0.21810257f, 0.15994793f, 0.10145177f, 0.06694523f, 0.00446182f, 
    -0.04166204f, 0.08054304f, 0.03016822f, 0.01872755f, 0.08186428f, 0.50383812f, -0.35831136f, -0.66705257f, 
    -0.00632117f, 0.11234017f, -0.13906173f, 0.07115830f, -0.02184300f, -0.09322828f, 0.14559267f, 0.04421170f, 
    -0.18179664f, -0.03590605f, 0.19650194f, -0.19695856f, 0.36029306f, -0.07521996f, 0.05336204f, -0.02207179f, 
    -0.32578078f, -0.18930984f, -0.01214192f, 0.02593939f, 0.20667881f, 0.17381756f, 0.11528700f, -0.07382862f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10109643f, -0.06012323f, 0.20685706f, 0.02059093f, -0.19017048f, 0.27875015f, -0.03506255f, 0.00853124f, 
    -0.00926814f, 0.05074102f, 0.17011727f, 0.05077237f, -0.13439983f, 0.24459329f, -0.04212859f, 0.41288105f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12535928f, -0.21415249f, 0.36252201f, -0.10881700f, -0.44725582f, -0.14422013f, -0.25281712f, 0.27723312f, 
    0.11235695f, 0.06656294f, 0.28457856f, 0.23837958f, 0.01926588f, 0.18995383f, -0.23616418f, 0.36654869f, 
    -0.09249201f, 0.03121166f, -0.07362545f, -0.33855194f, -0.22730158f, 0.74697506f, 0.22073825f, -0.08512062f, 
    0.08626696f, -0.14883558f, 0.39786586f, -0.15213086f, -0.27295294f, 0.45506266f, 0.15778188f, 0.47475985f, 
    -0.30801535f, -0.17555836f, 0.02766191f, 0.06359566f, -0.16682844f, 0.24103737f, 0.17438172f, 0.33673352f, 
    0.21861328f, 0.10325640f, -0.22080952f, -0.10020852f, -0.15636578f, 0.43570161f, 0.38999400f, 0.23913555f, 
    0.37912118f, -0.53300935f, -0.81583381f, -0.04094673f, -0.40100598f, 0.37441605f, 0.04955408f, -0.24987616f, 
    -0.14890356f, -0.07692634f, 0.35304359f, -0.05121714f, 0.41474614f, 0.18341406f, -0.43265149f, 0.59606963f, 
    0.48888949f, -0.59653741f, 0.03935258f, 0.28993896f, -0.28966701f, -0.09205610f, -0.06088868f, -0.35371628f, 
    0.12276634f, 0.17816755f, 0.14363712f, -0.17241937f, 0.16660200f, 0.20522174f, -0.72795224f, 0.49280304f, 
    0.23401435f, -0.65380388f, -0.43092352f, 0.26497436f, -0.30318397f, 0.90104914f, 0.09174165f, -0.17097199f, 
    0.21698457f, -0.03601153f, 0.41376182f, 0.04997682f, 0.59730351f, -0.11132821f, -0.47338793f, -0.04630245f, 
    0.34596184f, 0.29630041f, 0.23635611f, -0.57080775f, 0.14472257f, -0.20820160f, -0.10414821f, 0.08332717f, 
    -0.17391060f, -0.11027259f, 0.68835700f, -0.10868680f, -0.20615108f, 0.03260265f, -0.03507449f, -0.01356092f, 
    0.43786120f, 0.23217899f, 0.26556888f, -0.13160667f, 0.20677812f, 0.12100477f, 0.07134064f, -0.14208364f, 
    0.18939249f, -0.10764770f, 0.05460261f, -0.19895311f, -0.05855597f, -0.28384721f, 0.17760721f, -0.22567579f, 
    0.47163627f, -0.06213960f, -0.27568275f, -0.00751196f, -0.02462162f, 0.21027271f, -0.01161317f, -0.04112247f, 
    -0.05118356f, -0.01492440f, -0.70019037f, -0.03174753f, 0.20065817f, 0.25808355f, -0.45512825f, 0.37617898f, 
    0.14334862f, -0.16208482f, -0.11704818f, -0.12696461f, -0.14754339f, 0.11650603f, 0.16872373f, -0.04890243f, 
    -0.13728389f, 0.17303526f, 0.06249225f, -0.05492529f, -0.04601755f, -0.20734093f, -0.09124810f, -0.13882571f, 
    0.10991852f, -0.45450413f, 0.10104443f, -0.09153464f, 0.31906670f, -0.02820989f, -0.14864996f, 0.09620698f, 
    -0.09948908f, -0.18303689f, -0.23476309f, -0.24200562f, -0.33869264f, -0.26972654f, -0.45261374f, 0.51858938f, 
    0.19389758f, 0.26614335f, -0.29531142f, 0.31457895f, -0.22154871f, 0.42721575f, -0.05300161f, -0.18375622f, 
    -0.12870027f, -0.15266547f, 0.53977054f, 0.22557470f, 0.17978558f, -0.10076043f, -0.61556578f, -0.11837542f, 
    -0.04704142f, 0.01174235f, -0.08977710f, -0.04519209f, -0.21676469f, 0.47365755f, -0.15041941f, 0.10026398f, 
    -0.17382057f, -0.22036205f, -0.17171033f, 0.10429956f, 0.23121557f, 0.14293303f, -0.21306075f, 0.48618594f, 
    0.00234644f, -0.56592566f, -0.80487972f, -0.12060972f, 0.13852675f, 0.09480772f, 0.02664062f, 0.40990645f, 
    -0.13715462f, -0.06563261f, 0.26962706f, 0.22208378f, -0.13058995f, 0.42378667f, 0.57200718f, 0.10984138f, 
    -0.04896538f, -0.30822605f, 0.12699382f, -0.18863122f, -0.05023501f, 0.06713653f, -0.00286086f, 0.32407227f, 
    0.06898157f, -0.08134060f, 0.43199897f, -0.10026856f, -0.39983979f, 0.46883705f, 0.64390439f, -0.21078965f, 
    0.51000804f, 0.23978476f, 0.02802850f, -0.29930007f, 0.26246542f, -0.09791890f, 0.09224689f, -0.19394739f, 
    0.09561927f, -0.17035387f, 0.60655928f, -0.01650123f, 0.03067236f, -0.15665963f, -0.03213567f, 0.13372812f, 
    0.10193092f, -0.20236319f, 0.16840336f, -0.07551992f, -0.18056962f, -0.16859347f, -0.10430056f, -0.24220538f, 
    0.17718953f, 0.13044441f, -0.15666261f, 0.12977651f, -0.13263002f, -0.19040415f, 0.03400403f, -0.03261113f, 
    -0.05996861f, -0.88728237f, -0.16207327f, 0.61461258f, 0.38489464f, -0.21529812f, -0.03043565f, 0.11119200f, 
    0.23944943f, -0.21276391f, 0.59984326f, 0.22957961f, 0.09026908f, 0.14664632f, -0.39475405f, -0.10561763f, 
    0.18914673f, 0.27916893f, 0.30600351f, 0.39170122f, 0.17938487f, 0.04081900f, 0.15270455f, -0.31040162f, 
    -0.03918441f, 0.13361213f, 0.50857323f, -0.01007648f, -0.17359120f, -0.15132616f, -0.14339437f, -0.15878668f, 
    -0.17103121f, 0.05119078f, -0.07884278f, 0.02102298f, -0.25653812f, -0.07559952f, -0.13790867f, -0.03797742f, 
    -0.00264096f, -0.23499560f, -0.23330691f, -0.08492935f, -0.15232864f, -0.06420341f, 0.02393832f, -0.07502840f, 
    -0.07972508f, -0.23017149f, 0.20567913f, -0.20949742f, -0.24363557f, -0.06529827f, 0.14705855f, -0.14210114f, 
    -0.02448258f, -0.21763173f, 0.03762018f, 0.06665796f, 0.09837369f, -0.00086879f, -0.26721486f, -0.17779079f, 
    0.05437885f, 0.03610715f, -0.01199190f, -0.06738055f, 0.08609259f, -0.24655001f, -0.23056018f, -0.14888401f, 
    0.16392267f, -0.16254935f, -0.24832937f, -0.14687768f, -0.12547579f, 0.00631344f, 0.04672943f, -0.21365279f, 
    -0.08083393f, -0.42519405f, -0.19160083f, 0.05649700f, 0.25007448f, -0.59782612f, -0.23465392f, 0.44791496f, 
    0.18249363f, 0.21303058f, 0.73368961f, -0.00093025f, 0.04223034f, 0.19352446f, -0.34638757f, -0.37460160f, 
    -0.47386289f, -0.17801167f, 0.00153654f, 0.14781094f, 0.08771756f, 0.36789116f, -0.07360122f, 0.34410262f, 
    -0.21749370f, -0.23820056f, -0.49847746f, 0.14863203f, 0.29867268f, 0.14165778f, 0.09528676f, -0.25357878f, 
    -0.19247599f, 0.01017296f, 0.03490182f, -0.36714169f, 0.19784927f, 0.43646172f, 0.23101152f, 0.30310771f, 
    -0.09628489f, 0.15611641f, 0.57747298f, 0.02889166f, 0.07289466f, -0.14970692f, 0.70887494f, -0.17721602f, 
    0.31942722f, -0.54976034f, -0.32479116f, -0.57318187f, -0.20850222f, 0.58411592f, 0.20809942f, 0.35162786f, 
    -0.00897116f, 0.24165942f, -0.22100054f, 0.15851277f, -0.19224675f, 0.57464129f, -0.36946121f, 0.47724605f, 
    -0.08625444f, -0.46409342f, 0.45993811f, 0.16779758f, -0.07656361f, 0.29445913f, -0.06010669f, -0.02059446f, 
    -0.19955698f, 0.14668554f, 0.34851384f, -0.06429392f, -0.08964911f, -0.02656241f, -0.09026881f, -0.03231015f, 
    0.24373600f, 0.15538836f, 0.06930982f, 0.24282813f, -0.17536111f, 0.27860573f, -0.06925470f, 0.03675618f, 
    0.19262801f, -0.19691202f, -0.23568304f, -0.17864001f, 0.02349098f, 0.21473308f, -0.18376248f, -0.14387782f, 
    0.25064790f, 0.36798891f, 0.44396415f, 0.07869345f, -0.22991830f, -0.24830984f, 0.20775461f, 0.11497864f, 
    -0.15319481f, 0.14203468f, -0.08180730f, -0.03134701f, -0.26307228f, -0.27986658f, 0.32910159f, -0.22245373f, 
    -0.24893573f, 0.07614829f, 0.17881018f, -0.13819820f, -0.20128226f, -0.09714487f, 0.20588553f, 0.32649407f, 
    -0.10063267f, -0.14923470f, 0.22506990f, -0.06736156f, 0.04210453f, 0.11745504f, 0.30437493f, 0.03785222f, 
    0.26275730f, -0.22106530f, -0.27968502f, -0.02091143f, 0.57335716f, -0.47573528f, 0.15517434f, -0.10727677f, 
    0.23674883f, -0.19814357f, 0.61308223f, 0.07174953f, 0.28947100f, -0.24191198f, 0.04502474f, 0.00929807f, 
    0.23382580f, -0.05032177f, -0.35821977f, 0.02059775f, 0.00203060f, -0.38977796f, -0.23487318f, 0.11764505f, 
    -0.19393414f, 0.19976550f, 0.51195991f, -0.03892869f, 0.29026297f, 0.30985916f, 0.15800230f, 0.13496110f, 
    0.10569491f, 0.07363572f, -0.16635419f, -0.03863894f, 0.05473603f, 0.03379349f, 0.15976560f, -0.21159710f, 
    0.17241067f, 0.09354839f, -0.01556780f, -0.06106715f, -0.13117336f, -0.17115794f, 0.14031661f, -0.13777274f, 
    0.47421974f, 0.03411628f, -0.07619517f, -0.08243628f, 0.33336291f, -0.00400662f, -0.23687716f, -0.00345827f, 
    0.11650072f, -0.13584396f, -0.31720230f, 0.10756497f, 0.14409412f, 0.06266729f, -0.51266593f, -0.30753431f, 
    -0.11049911f, 0.15560347f, -0.30719608f, -0.20196570f, 0.06731487f, 0.17338043f, 0.08572012f, -0.08092491f, 
    0.11917760f, -0.03261419f, -0.22038075f, -0.14132831f, 0.07532597f, 0.11892235f, 0.32093263f, 0.35942936f, 
    -0.18660432f, -0.33916777f, 0.33548537f, 0.29298633f, -0.20514013f, -0.13626899f, -0.18236145f, 0.00115983f, 
    -0.16608869f, 0.23323968f, 0.14490734f, 0.02039902f, 0.02268239f, 0.37160876f, -0.09480663f, 0.20736054f, 
    -0.34315801f, 0.05148553f, -0.11414863f, 0.38114890f, -0.18744673f, 0.50095427f, 0.03395447f, -0.05716338f, 
    0.01229371f, -0.14451686f, -0.37389839f, 0.13047025f, 0.23217039f, 0.29875010f, 0.23456837f, -0.19466580f, 
    -0.06286586f, 0.12920539f, -0.21255608f, 0.04398194f, 0.25733370f, -0.19495131f, 0.15273046f, -0.17872642f, 
    0.16587903f, 0.04344046f, -0.16627172f, 0.19390954f, 0.09873668f, -0.09610365f, 0.15161517f, -0.05025812f, 
    -0.08869551f, -0.29360121f, -0.03044892f, 0.04353653f, -0.02881888f, 0.12065446f, 0.17866592f, 0.13104627f, 
    -0.07180354f, -0.06393629f, -0.10127830f, 0.09734473f, -0.27197665f, -0.10742337f, -0.13818061f, -0.30960757f, 
    0.17907193f, -0.12462857f, -0.10221226f, 0.42962131f, -0.14224789f, 0.23120984f, 0.15405801f, 0.16082518f, 
    0.17556030f, 0.12262706f, 0.07671282f, 0.05087946f, 0.28040755f, -0.35682642f, -0.67936933f, -0.16569856f, 
    0.33089575f, 0.09314322f, 0.33162141f, -0.05686039f, 0.32778898f, 0.06234932f, -0.23358925f, -0.11223330f, 
    -0.22516604f, 0.14070170f, 0.21311705f, 0.11091065f, 0.09535447f, -0.30763364f, -0.39851418f, -0.37471384f, 
    -0.04499134f, 0.47833553f, 0.08392828f, -0.05132182f, -0.13089557f, 0.33885172f, 0.03792739f, 0.21600316f, 
    -0.05314278f, -0.11360608f, 0.34068459f, 0.19077587f, -0.31453133f, 0.07993682f, 0.01757011f, -0.50898618f, 
    -0.30905208f, -0.39130071f, -0.17041898f, 0.41509682f, 0.07115445f, -0.11464913f, 0.14184247f, 0.20111376f, 
    0.01294501f, -0.14684980f, 0.52709240f, 0.03753464f, -0.16175760f, -0.05324166f, -0.03571620f, 0.02757305f, 
    0.05762339f, 0.18955937f, -0.17290515f, -0.05237991f, -0.01114702f, 0.01913607f, 0.16240823f, -0.07269537f, 
    0.18870434f, -0.23090976f, -0.14180276f, 0.09350234f, -0.20471549f, -0.04788998f, -0.02594149f, -0.15035948f, 
    -0.29417369f, -0.06979489f, 0.27242318f, 0.32687753f, -0.02383563f, 0.42984474f, -0.12811871f, 0.40880582f, 
    0.22297843f, -0.15245675f, 0.46446541f, 0.08975011f, -0.27347815f, 0.06383733f, -0.17813292f, -0.66658342f, 
    -0.17155172f, 0.07582930f, -0.01221606f, 0.26784727f, 0.05960993f, -0.04553761f, 0.03078553f, 0.13169244f, 
    0.07610007f, -0.23412041f, -0.07776396f, -0.08384297f, -0.27229264f, 0.46787259f, -0.42326772f, 0.33318025f, 
    -0.03047399f, -0.12554635f, 0.44240630f, -0.31539193f, -0.32000902f, 0.34338170f, 0.12203736f, 0.31413922f, 
    -0.04980589f, 0.06347466f, -0.41150475f, 0.19619577f, 0.22158247f, -0.13887005f, 0.25382113f, -0.16157192f, 
    -0.01846006f, 0.19542447f, 0.30990329f, 0.00475961f, -0.50822359f, 0.23470683f, -0.10019722f, 0.24152310f, 
    0.26476091f, 0.01893301f, 0.50492001f, -0.04606552f, -0.17935935f, 0.22288196f, -0.22182941f, 0.37702981f, 
    -0.23227690f, 0.31420326f, -0.05703283f, -0.04734716f, 0.12004003f, 0.44789335f, 0.07473683f, 0.04011239f, 
    -0.01328148f, 0.10981689f, -0.15046428f, -0.07166876f, -0.19785978f, -0.13578548f, 0.45237893f, 0.48541936f, 
    -0.15214513f, -0.09147029f, -0.31235898f, 0.07525615f, 0.08936188f, -0.17857651f, 0.02639180f, 0.27424845f, 
    -0.14349097f, -0.21167415f, 0.09402098f, 0.04400879f, -0.15248044f, -0.01622860f, -0.20045614f, 0.09386449f, 
    0.12507987f, -0.21827410f, 0.21387795f, -0.34139177f, 0.40519708f, 0.63900369f, 0.14837420f, -0.07785482f, 
    -0.04553743f, 0.00708994f, 0.24165042f, 0.20316857f, 0.01540486f, -0.13849445f, 0.39207050f, -0.27435607f, 
    0.14679268f, 0.16701320f, -0.10810689f, 0.09345262f, -0.23762690f, 0.69872725f, -0.11859940f, -0.27948093f, 
    -0.10765490f, 0.13814463f, -0.26975957f, -0.11574920f, 0.24388665f, 0.29532933f, -0.32871509f, -0.03965279f, 
    0.29083699f, 0.36865091f, -0.15087514f, 0.10729095f, 0.58093625f, -0.35294369f, -0.18476221f, -0.07137946f, 
    0.17899713f, 0.06467319f, -0.22412446f, -0.07815707f, -0.13238961f, -0.54265207f, 0.34486946f, -0.20180029f, 
    -0.42597732f, -0.29537228f, -0.10777775f, 0.33455217f, -0.07619023f, 0.20828038f, -0.13123365f, 0.39839238f, 
    -0.12271072f, -0.11841872f, 0.12798765f, -0.09027371f, 0.42122567f, 0.14043216f, 0.22178955f, -0.39337060f, 
    0.41634259f, 0.27796736f, -0.23644982f, -0.03874278f, 0.18509406f, 0.12004813f, -0.03290057f, -0.00094731f, 
    0.16380352f, 0.13866252f, -0.07276256f, 0.06812825f, 0.29387915f, -0.35820466f, -0.31299180f, 0.02853528f, 
    -0.20180005f, 0.03771663f, 0.17415570f, -0.29499796f, -0.07874735f, 0.00639492f, -0.07777888f, -0.24407150f, 
    0.05237116f, -0.16923097f, -0.10255195f, -0.05497447f, 0.02292285f, -0.16490187f, 0.05934331f, -0.26268896f, 
    0.22477432f, 0.32495433f, -0.19550960f, 0.51147068f, 0.04286781f, -0.04093811f, 0.03157434f, 0.03334426f, 
    -0.03258389f, -0.23324129f, -0.03857356f, 0.08747032f, -0.17233023f, 0.04655473f, -0.76033872f, -0.28296337f, 
    0.29871327f, 0.09445496f, 0.13711439f, -0.04999067f, -0.42500392f, -0.30753857f, 0.08478297f, 0.06976631f, 
    0.16205972f, -0.05323261f, 0.32584587f, -0.14546332f, -0.15964223f, 0.14096153f, -0.12606375f, 0.42224741f, 
    -0.21330015f, -0.28507313f, 0.38521284f, 0.23029423f, 0.32463345f, 0.20330568f, -0.00056707f, 0.27205107f, 
    -0.08509373f, -0.21670820f, 0.30288181f, -0.22833513f, -0.11964852f, -0.10011178f, -0.06496968f, -0.33189967f, 
    0.30387762f, -0.12181678f, -0.13273722f, -0.36626628f, 0.20537554f, -0.40391025f, 0.20202851f, 0.04403602f, 
    0.09510629f, -0.12093446f, 0.47002894f, 0.05766901f, 0.36283779f, -0.09134723f, -0.06571964f, 0.34736618f, 
    -0.04853866f, -0.83093864f, -0.48270229f, -0.23260860f, 0.39335650f, 0.21274985f, 0.08547211f, 0.44377875f, 
    -0.07564206f, 0.06950521f, 0.06410769f, 0.17101876f, 0.21009895f, 0.29165378f, 0.41464645f, -0.28077227f, 
    0.18851417f, -0.34951687f, 0.14582668f, -0.14929968f, 0.06719036f, -0.03642324f, 0.18557920f, 0.24108902f, 
    -0.08499697f, -0.20440702f, -0.29677758f, -0.22624150f, -0.21284425f, 0.29004741f, -0.35868695f, 0.20856979f, 
    0.00609879f, 0.18892373f, -0.05373933f, 0.11451705f, -0.15263614f, -0.16895673f, -0.16684702f, -0.07806282f, 
    -0.15745187f, -0.01056191f, -0.22005308f, 0.20263994f, -0.00337994f, -0.09358044f, 0.09970163f, -0.22461896f, 
    0.14701284f, -0.05118524f, -0.18197939f, 0.01124668f, -0.16079153f, -0.25737250f, -0.17648250f, -0.28181073f, 
    -0.08384877f, 0.16263336f, 0.06813053f, -0.15630910f, 0.03769065f, -0.19501115f, -0.15874739f, -0.09210852f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12577981f, 0.08608375f, 0.29629442f, 0.50915366f, 0.52473736f, 0.34606338f, -0.20285659f, 0.17542823f, 
    0.33376878f, -0.16200326f, 0.01859033f, 0.05791071f, -0.01586965f, 0.09158735f, 0.06966174f, -0.09730820f, 
    -0.13282213f, 0.47060540f, 0.19846444f, -0.26898798f, -0.12561928f, 0.13582021f, -0.21563692f, -0.13560262f, 
    0.12521695f, 0.67577863f, 0.09720951f, 0.49895972f, -0.18584953f, 0.08708259f, -0.16382451f, 0.03509187f, 
    0.09267273f, -0.12110361f, 0.39940685f, 0.50199723f, 0.21925798f, 0.22223775f, -0.28432748f, 0.12867376f, 
    0.16224802f, -0.11195909f, -0.03507202f, -0.24137846f, 0.20527993f, 0.27324405f, 0.25401294f, 0.10620204f, 
    0.03675725f, 0.13952261f, -0.28367075f, 0.32735994f, -0.43020299f, -0.09365356f, -0.11269275f, -0.06742612f, 
    0.08909706f, 0.52250570f, 0.12225714f, -0.27702779f, 0.43631962f, 0.69046086f, -0.16135120f, -0.05473500f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.42596492f, -0.20048212f, -0.36695442f, -0.84507209f, -0.56426865f, -0.43469557f, 0.12692282f, 0.35765487f, 
    -0.18033072f, 0.01591388f, -0.37062177f, -0.26061165f, 0.04166025f, 0.15694739f, 0.13134846f, 0.23133643f, 
    0.00249603f, 0.13952295f, 0.21097858f, -0.10219811f, 0.00660616f, 0.01988363f, -0.00710540f, -0.21517199f, 
    0.22461215f, -0.99241483f, -0.09618901f, -0.29278865f, -0.05694666f, -0.13179770f, 0.38331720f, 0.03178072f, 
    -0.05676137f, 0.03102825f, 0.09652500f, -0.46569103f, -0.45174092f, 0.12659204f, 0.01059443f, -0.33636779f, 
    0.19986121f, -0.19280043f, 0.04893720f, 0.01497488f, -0.29348814f, -0.41156977f, 0.04383250f, -0.36535507f, 
    -0.11824311f, -0.18929683f, 0.46163213f, -0.39074481f, 0.56625670f, -0.14723706f, 0.13245511f, 0.02902132f, 
    -0.25724730f, -0.36513042f, 0.10831925f, 0.21705863f, 0.07100540f, -0.42559496f, -0.15201451f, -0.10894930f, 
    0.10285962f, -0.02186818f, 0.07503836f, -0.94196701f, -0.21535276f, -1.73781729f, 0.20688102f, 0.12628621f, 
    -0.02664953f, 0.07943492f, -0.07833558f, -1.13852870f, -0.16346233f, 0.18010588f, 0.27807805f, 0.01130006f, 
    -0.03407742f, 0.06702989f, -0.01036607f, -0.07143682f, 0.01726474f, 0.06494536f, 0.35633019f, -0.31225196f, 
    0.09464444f, 0.11153542f, 0.15569860f, 0.07427575f, 0.09705069f, 0.06224074f, 0.02716477f, -0.00988083f, 
    0.05350973f, -0.03194898f, 0.11175909f, 0.09040780f, -0.18961093f, -0.01906818f, -0.07902809f, -0.38186079f, 
    0.02883579f, 0.26440224f, 0.12853563f, -0.05798180f, 0.19845302f, 0.11959413f, -0.02063611f, 0.20360073f, 
    0.02364389f, 0.13032672f, -0.13036042f, -0.00156982f, -0.68615979f, -0.20373024f, -0.26716372f, -0.09321195f, 
    -0.36903554f, 0.23636265f, 0.01389399f, 0.05841115f, -0.02516218f, 0.25087994f, 0.19008295f, -0.14605452f, 
    -0.08804376f, 0.10637683f, 0.15947953f, 0.73050439f, 0.03228280f, 0.49552411f, -0.02883326f, -0.13886176f, 
    0.12622917f, -0.04341644f, -1.06819153f, -0.24128142f, 0.19418308f, 0.42752752f, -0.28604579f, -0.00904743f, 
    -0.02206178f, -0.07403949f, -0.39925495f, 0.01446532f, -0.01339799f, -0.09949014f, -1.37646127f, 0.06378810f, 
    0.00572305f, 0.32951882f, -0.42475513f, -0.14937715f, 0.31130046f, -0.01275954f, -0.42847329f, 0.06727810f, 
    0.10482098f, -0.01497277f, 0.34517258f, -0.11315139f, 0.08820585f, -0.02219301f, -0.07616732f, -0.25569701f, 
    -0.20492962f, 0.05001028f, -0.45939308f, -0.04718482f, -0.81878114f, 0.04756593f, 0.00422888f, -0.11379009f, 
    0.13239299f, -0.16945857f, -0.13903539f, 0.08885500f, 0.17026332f, 0.01511381f, 0.08196840f, -0.10259806f, 
    -0.72309738f, -0.06244227f, -0.37579730f, -0.01458581f, 0.29686287f, -0.15057753f, -0.06418751f, -0.02940252f, 
    -0.41916361f, -0.54916465f, -0.11616687f, 0.09539277f, 0.05990265f, 0.33798069f, 0.03541043f, 0.12215529f, 
    0.38932705f, 0.03932471f, 0.30305865f, -0.28051600f, -0.23564401f, 0.14249131f, -0.00028552f, 0.03217205f, 
    0.00917961f, -0.03613083f, -0.42644873f, 0.01757056f, 0.09003007f, -0.04895235f, 0.09426284f, -0.00720565f, 
    -0.05371628f, 0.16914292f, -0.53333038f, 0.00770213f, -0.32884845f, -0.28464517f, 0.16395453f, 0.10595491f, 
    0.05209497f, 0.36052436f, -0.08273858f, -0.42270938f, 0.20690343f, -0.08490725f, -0.02793498f, 0.16064163f, 
    0.08988636f, -0.60271949f, -0.37307823f, -0.06354913f, -0.32090646f, -0.28874195f, -0.37502608f, -0.78322685f, 
    0.47006348f, 0.05449685f, -0.00188571f, 0.24081630f, 0.14745174f, 0.08551148f, 0.28139317f, -0.02001002f, 
    0.28301552f, -0.38590375f, -0.07569872f, 0.05346026f, 0.25683150f, 0.26439485f, -0.19319676f, -0.07970111f, 
    0.05495869f, -1.19458067f, -0.33486602f, 0.13406423f, 0.31615570f, 0.14916080f, 0.09935065f, 0.03155580f, 
    -0.40414178f, 0.07538600f, 0.58997893f, 0.29199749f, -0.35406399f, -0.17948426f, -0.06960960f, 0.16167000f, 
    0.09476985f, 0.13088605f, 0.12951812f, -0.08219606f, -0.05195536f, -0.10575918f, 0.10672729f, 0.00824639f, 
    0.13398737f, -0.94539672f, 0.24257842f, -0.13562438f, -0.06430772f, 0.12288229f, 0.10906725f, 0.20829488f, 
    0.08129895f, -0.06674233f, -0.04116074f, 0.00469211f, -0.35326949f, -0.03378866f, -0.11126988f, 0.18309903f, 
    0.14794727f, -0.00467649f, 0.12021630f, 0.03279307f, -0.09426817f, -0.16680761f, -0.19847269f, -0.03177179f, 
    0.17362097f, -0.25235045f, -0.00588822f, -0.55026090f, -0.42872199f, 0.21383794f, 0.09194287f, -0.08533107f, 
    -0.02558877f, 0.15531053f, -0.01291877f, 0.23337205f, -0.04206441f, -0.14163589f, -0.25894403f, -0.10345744f, 
    0.19190057f, 0.38930467f, 0.03584440f, -0.03161146f, -0.19324712f, -0.37674025f, 0.09639933f, -0.00344237f, 
    -0.11267161f, -0.06758998f, -0.21060571f, -0.27483815f, -0.05569593f, 0.18740737f, 0.18314722f, -0.06135419f, 
    -0.12169126f, 0.08277278f, -0.24209946f, -0.02684057f, -0.04747315f, -0.00408014f, 0.07313518f, 0.07362396f, 
    0.08702666f, -0.10380425f, 0.12473608f, -0.13302253f, 0.23012370f, 0.12539822f, -0.03710146f, 0.15722655f, 
    0.01456820f, -0.00819572f, -0.09422832f, 0.08226953f, -0.20987251f, -0.17776820f, -0.04926103f, -0.02486090f, 
    -0.10962719f, -0.08548880f, 0.30106959f, 0.06997399f, 0.10677566f, -0.08188969f, 0.40282211f, 0.16492519f, 
    -0.56207347f, 0.08456443f, -0.08335122f, -0.30229780f, -0.27240756f, 0.05498634f, -0.25289923f, -0.06325310f, 
    -0.10007121f, 0.14003970f, -0.02156259f, 0.17086677f, 0.03666784f, 0.02269113f, -0.10419620f, -0.09252231f, 
    0.02971029f, 0.38938120f, 0.03124504f, 0.70119601f, 0.33086446f, 0.13755307f, -0.24640244f, 0.00271524f, 
    0.21481110f, 0.07911751f, -1.46160960f, 0.24081531f, 0.32439265f, -0.95380080f, -1.04909968f, -0.08470407f, 
    -0.06233677f, -1.31692863f, -0.07105640f, 0.07337047f, 0.00019566f, -0.12255699f, -0.26627734f, -0.18374904f, 
    -0.35863444f, 0.33531323f, -0.28266630f, 0.18963884f, -0.45047379f, -0.11577995f, -0.62548226f, -0.19413577f, 
    -0.10122270f, -0.03832377f, 0.22562556f, 0.04080020f, 0.12599599f, -0.01995648f, 0.00902469f, -0.00502307f, 
    -0.15183032f, -1.19163871f, -0.45469844f, -0.05026631f, -0.42482367f, 0.07121449f, -0.09383497f, 0.23996516f, 
    0.35432845f, -0.25695384f, -0.37955433f, 0.24284466f, 0.06280170f, -0.37207189f, 0.30089614f, 0.08572203f, 
    0.00445373f, 0.10933343f, -0.52536750f, -0.37442258f, -1.41129863f, -0.03330227f, -0.04023597f, -0.04973956f, 
    -0.21566787f, 0.14217392f, -0.17912842f, -0.50302035f, -0.45616674f, 0.37877262f, 0.23485869f, 0.15144533f, 
    -0.17505254f, -0.06731724f, -0.30671415f, 0.61779368f, -0.17807530f, -0.38853163f, -0.76157737f, 0.20571668f, 
    -0.03267154f, -0.50105250f, 0.13587983f, 0.11403774f, 0.02187591f, -0.07248539f, -0.28325176f, -0.24515317f, 
    0.09889478f, -0.38681933f, -0.81147301f, 0.13332388f, -0.10317615f, -0.21719387f, -0.46747938f, -0.37640598f, 
    -0.08740702f, 0.15452477f, -0.11019019f, -0.31403914f, -0.09773365f, 0.03941682f, -0.02458263f, 0.01476383f, 
    0.09872102f, 0.39525336f, -0.17371102f, -0.03757504f, 0.16661114f, 0.12639396f, -0.18814069f, 0.13578266f, 
    -0.09414141f, -0.27304205f, 0.07529450f, 0.18990979f, 0.12830129f, -0.25443551f, 0.14413372f, 0.00602238f, 
    0.54414171f, -0.08295816f, 0.00159789f, -0.60523605f, -1.05523992f, -0.39646661f, -0.05848031f, -0.06151096f, 
    0.17528524f, 0.00700431f, 0.22355732f, -0.83262080f, -1.12928188f, -0.87517864f, -0.27083027f, -0.11167577f, 
    -0.02003997f, 0.10759817f, -0.17377985f, -0.54263550f, 0.03920488f, 0.36350608f, 0.53885633f, -0.38743490f, 
    -0.04859555f, -0.62475854f, -0.38033745f, -0.02634840f, 0.10429551f, 0.08330049f, -1.12076247f, 0.26883811f, 
    0.23635049f, 0.34238574f, -0.05433545f, 0.10106385f, -0.23233399f, 0.27406907f, -0.54869676f, -0.25604576f, 
    0.01902600f, -0.12367527f, -0.07226361f, -0.02220207f, 0.17112492f, -0.14266698f, 0.01597481f, -0.23168468f, 
    -0.22914627f, 0.14768325f, -0.51269978f, 0.09887932f, 0.29828212f, 0.03429157f, 0.40145534f, 0.04211762f, 
    0.17536359f, -0.35403883f, 0.45810553f, -0.14089376f, -0.57892811f, 0.17082705f, -0.26340941f, -0.05715492f, 
    -0.18988439f, -0.06584929f, -0.01820892f, -0.22571516f, 0.37179297f, 0.13246819f, -0.04543119f, 0.05658155f, 
    0.21982034f, -0.37252983f, -0.09296900f, 0.51378369f, 0.61312848f, 0.03956123f, -0.08901843f, 0.00229685f, 
    0.25478265f, 0.11316875f, 0.92766732f, 0.00775172f, 0.00303409f, -0.20297536f, -0.21913047f, 0.14979757f, 
    0.12273343f, 0.23363653f, 0.16029541f, -0.12244606f, 0.03431540f, -0.03320184f, -0.35962537f, -0.68918806f, 
    -1.24823880f, 0.04234407f, 0.10185735f, 0.13752151f, -0.12305322f, -0.28333411f, 0.07615206f, 0.02087591f, 
    0.02571562f, 0.17674740f, -0.06295209f, 0.10021693f, -0.17467844f, 0.07077369f, 0.03663277f, 0.01279912f, 
    0.08152945f, -0.36581129f, -0.20581698f, -0.10211943f, -0.48907274f, 0.20978546f, -0.59466994f, -0.00712257f, 
    -0.09686397f, -0.15124515f, -0.83872640f, 0.03708887f, -0.50387788f, -0.54785442f, 0.02019691f, -0.00777955f, 
    0.40812203f, 0.31997609f, -0.33553457f, 0.05246007f, -0.33662137f, 0.22372490f, -0.35642996f, -0.11816785f, 
    -0.30346802f, -0.29637823f, 0.28278571f, -0.87750769f, -0.40439507f, -0.08747132f, -0.48701438f, -0.80166483f, 
    -0.13911355f, 0.11353780f, -0.36383739f, 0.01845587f, -0.15432623f, 0.15690233f, 0.11560357f, -1.09588003f, 
    -0.06948511f, 0.52278060f, -0.19541441f, -0.03073066f, 0.07863331f, 0.06025072f, -0.12405448f, 0.41405433f, 
    -0.06539970f, -0.28358072f, -0.12468883f, 0.06375160f, -1.00240111f, 0.09223616f, -0.37267271f, 0.16750078f, 
    0.04329840f, -0.08959784f, 0.27104899f, 0.17810315f, 0.40177050f, 0.01803300f, -0.04720006f, 0.11076563f, 
    -0.53758752f, -0.04357165f, 0.55627656f, 0.10983172f, 0.40912154f, 0.25329319f, -0.34451073f, -0.12605372f, 
    -0.29868159f, -0.01829287f, -0.83178556f, -0.11559770f, -0.09415239f, 0.53592080f, -0.46251014f, -0.03775175f, 
    0.42668924f, -0.55837709f, 0.33022523f, -1.15942502f, 0.18971829f, 0.00470329f, -0.01900451f, 0.05321928f, 
    -0.01200154f, -0.05356581f, -0.03252609f, -0.29822376f, 0.11206567f, 0.52767724f, -0.65034866f, -0.08066715f, 
    -0.01456499f, 0.11418094f, 0.51066846f, 0.22079822f, 0.07075504f, -0.81636369f, -0.65036488f, -0.65585625f, 
    -0.12281963f, -0.19037689f, -0.05349062f, 0.03607142f, -0.01749157f, -0.12912223f, -0.53342938f, 0.41577715f, 
    -0.09893297f, 0.18693124f, 0.51005417f, -0.00211114f, -0.16889630f, -0.14207442f, -0.40492374f, -0.71772254f, 
    0.03634815f, 0.08558930f, -0.58763003f, 0.12184102f, 0.07956335f, -0.06449448f, -0.07003091f, 0.25541240f, 
    0.20545022f, -0.00232136f, -0.09358778f, 0.01761556f, 0.45950931f, -0.06145493f, 0.35313267f, -0.06088447f, 
    -0.15002562f, -0.01686074f, 0.47679123f, 0.07437432f, -0.31635135f, 0.12846708f, -0.04551293f, 0.09491615f, 
    -0.16816939f, -0.46827269f, 0.47106814f, -0.35510868f, -0.09781207f, 0.00906938f, -0.11768997f, -0.12695907f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.25905690f, 0.25520864f, 0.00510107f, 0.15524110f, -0.26346010f, -0.22189452f, 0.05368122f, -0.12080928f, 
    -0.19730899f, 0.27467802f, 0.13674083f, -0.15513606f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
