#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.62017453f, -1.17171860f, -1.73376870f, 0.68372357f, 0.89099222f, 0.10168525f, 0.40321988f, 0.49359944f, 
    -0.29371181f, 0.64482886f, -0.64790928f, -1.07532883f, 0.49974868f, -0.63980156f, -0.66249526f, -0.51755071f, 
    -0.45228016f, -0.17213497f, 0.07511234f, 0.17877448f, 1.20739806f, -0.31420392f, 0.10969518f, 0.77954787f, 
    0.11335079f, -0.57213426f, 0.95540196f, -0.55533940f, -0.72734797f, -0.43515831f, -0.97494167f, -1.20655632f, 
    -0.98712558f, 0.03594799f, -0.83062887f, -0.58087331f, -0.77255708f, 1.11633706f, -0.56729233f, 0.52244091f, 
    0.68829155f, -0.02807596f, 0.74060518f, -0.54732400f, -0.34313482f, -1.19487751f, -0.70506829f, 0.26859891f, 
    0.85463762f, -0.39856842f, 0.00874101f, 0.67618692f, 0.29476234f, 0.94871873f, -0.06583707f, -0.01321935f, 
    -0.62633049f, -0.16054273f, -0.22521000f, -0.55425799f, -0.44615078f, -0.40127793f, 1.37413347f, 0.21398741f, 
    0.71388453f, 0.94695365f, 0.74620843f, -0.80271930f, -0.86736470f, 0.02711879f, -0.27108896f, -0.30648428f, 
    -1.63100231f, 1.01387930f, -1.36553240f, 0.22297202f, -0.06904653f, -0.48126924f, -0.39429742f, -0.34196362f, 
    -0.08945268f, 0.57356501f, 0.07051169f, -0.75430310f, 0.42979398f, 0.01363810f, 1.17936182f, 0.19312853f, 
    -0.70267677f, -0.99637860f, -0.71435976f, 0.15548852f, 0.48344040f, 1.00210869f, 0.82638955f, 1.24702322f, 
    0.01341772f, 0.30535787f, 0.49802837f, 0.94249785f, 0.47272488f, 0.63125163f, -0.85183781f, 0.05785064f, 
    -0.16656093f, 0.52087164f, 0.89181626f, 0.90719903f, -1.10284841f, 0.12765276f, 0.41971508f, -0.91358733f, 
    -0.81568748f, -1.29382098f, 0.41223067f, 0.86289769f, 0.69279021f, -1.26282585f, -1.15694928f, -0.05019819f, 
    0.40843597f, 0.55738980f, 0.86573416f, -0.05605269f, -0.48364273f, -0.59167010f, 0.55109328f, 1.42292523f, 
    -0.17472023f, 0.19503368f, 1.02122545f, 0.14906588f, 0.01183883f, 0.65855998f, 0.34230563f, -0.02962112f, 
    0.21649098f, -0.20285422f, 0.74590462f, 0.80866122f, -0.51789898f, -0.36769167f, 0.59924448f, -0.06388240f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.52610970f, 0.20340320f, 0.59597468f, -0.40418091f, 0.51532882f, 0.04110152f, -0.23921403f, 0.80377328f, 
    0.10537419f, 0.28128442f, -0.12156588f, 0.75398910f, 0.46686748f, -0.03309186f, 1.10811257f, 0.83324331f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.91515201f, 0.04384701f, 0.23885065f, 0.08832704f, 0.12162603f, 0.00512770f, 0.06689110f, 0.01109342f, 
    0.08388712f, -0.62745839f, -0.41631696f, -0.73030418f, -0.07449941f, 0.32217479f, -0.14381365f, 0.11344266f, 
    0.06263575f, 0.35189584f, 0.32639691f, -0.24652907f, -0.03288876f, 0.14098231f, -0.12268165f, -0.09788895f, 
    -0.03878445f, -0.04544465f, 0.16660900f, 0.40389553f, 0.23019060f, 0.13431369f, -0.24210922f, 0.00835009f, 
    -0.26720214f, 0.01438929f, -0.15252963f, 0.14344183f, 0.03703885f, 0.30585933f, 0.20703308f, -0.14490686f, 
    0.08773969f, -0.06636751f, 0.13712715f, 0.18826757f, 0.02719186f, -0.22141388f, -0.08811696f, -0.03037772f, 
    0.00874415f, -0.23036630f, 0.05615371f, 0.08147180f, 0.10410903f, -0.03638799f, -0.35219800f, -0.39604694f, 
    -0.62261808f, 0.49267235f, -0.04363698f, 0.17832001f, -0.08874617f, -0.06057194f, -0.19295318f, 0.01788095f, 
    -0.05590038f, -0.20758715f, 0.01950057f, 0.03388683f, -0.06370134f, -0.03853982f, 0.05063482f, 0.14445858f, 
    -0.76296490f, -1.12625098f, -1.44113493f, 0.11778578f, 0.17299233f, 0.07315055f, 0.31724560f, 0.08083778f, 
    0.07656145f, -0.14323084f, 0.50654089f, -0.13375369f, 0.23299131f, 0.01195511f, -0.13575427f, -0.03421791f, 
    0.16904312f, 0.15939851f, 0.22897311f, -0.13006388f, -0.26277047f, -0.18719199f, -0.27638653f, -0.14302026f, 
    0.04602921f, 0.01538235f, 0.10321634f, 0.33182648f, -0.07247427f, -0.30333191f, 0.09904248f, -0.14808476f, 
    -0.05939502f, 0.03729400f, 0.01594323f, 0.05711644f, -0.84374797f, 0.19420834f, 0.43688518f, -0.09222326f, 
    -0.06113194f, 0.04880459f, 0.03872497f, 0.06961286f, -0.06576469f, 0.09394518f, -0.46217823f, -0.78897566f, 
    -0.07836743f, -0.30641064f, 0.37043813f, -0.09193892f, -0.11160409f, -0.03440062f, 0.14469019f, 0.20845607f, 
    0.03994711f, -0.09130131f, -0.06955531f, 0.01343517f, -0.08207419f, 0.06806321f, 0.17403254f, -0.00710729f, 
    0.33868095f, 0.26952827f, 0.42587766f, 0.43168744f, 0.12426770f, 0.06457309f, 0.19317730f, 0.03464858f, 
    -0.05080717f, -0.05711689f, 0.46852171f, -0.01981423f, 0.15346423f, 0.18859495f, 0.15595904f, 0.00696016f, 
    0.13725516f, 0.31858736f, 0.27630934f, -0.12661707f, 0.10974880f, 0.11820315f, -0.12251183f, 0.01812822f, 
    0.14026099f, 0.09357983f, 0.05908227f, -0.21307433f, -0.60454267f, 0.25914419f, 0.38896358f, 0.01855539f, 
    0.32276881f, 0.20383221f, 0.15928796f, 0.05002800f, 0.29341656f, 0.05205654f, 0.14632663f, -0.18236050f, 
    -0.08533221f, -0.04717964f, 0.04850495f, -0.16663697f, -0.18272223f, -0.51937753f, -0.95364368f, 0.19859281f, 
    0.20933531f, 0.06416578f, -0.32699028f, -0.09273072f, -0.07468954f, -0.17429899f, -0.43509316f, -0.05754097f, 
    -0.04225824f, -0.02721756f, 0.42883953f, -0.25574663f, 0.24906565f, -0.01546521f, -0.23431371f, -0.33654341f, 
    -0.42284009f, 0.61264640f, -0.01775734f, -0.05133220f, -0.06702361f, -0.14082283f, -0.51264429f, 0.02384360f, 
    -0.04171412f, 0.38764226f, -0.15334444f, 0.03697490f, 0.08151353f, 0.06986311f, 0.01871258f, -0.10228792f, 
    0.30756056f, 0.10425994f, -0.10612783f, 0.20860977f, -0.04880593f, -0.32150406f, -0.13526997f, -0.02824784f, 
    -0.01745082f, 0.45754653f, 0.29948154f, 0.08131830f, 0.22074276f, 0.40008554f, -0.00307278f, 0.21351478f, 
    0.26522070f, -0.04988590f, -0.21089686f, -0.08304898f, 0.07388727f, -0.02431387f, -0.18962413f, -0.07189129f, 
    0.08725923f, 0.12156036f, -0.08607946f, 0.09846582f, -0.38013077f, -0.32681385f, -0.08731664f, -0.02701463f, 
    -0.15592262f, -0.05103444f, -0.26131168f, -0.19192165f, 0.25313228f, 0.23659106f, -0.07398710f, -0.13638529f, 
    -0.18906692f, -0.16379273f, -0.23320653f, -0.01421977f, -0.14015549f, 0.39261866f, 0.08579478f, 0.57598907f, 
    -0.00188901f, 0.23867878f, 0.12120322f, 0.32573482f, 0.36066994f, 0.14011775f, -0.04198061f, -0.28599459f, 
    -0.10931333f, 0.12829469f, -0.14700705f, 0.21239865f, 0.10758647f, -0.15212189f, -0.21705115f, 0.22983125f, 
    -0.16870616f, -0.28144792f, 0.08176085f, 0.00610943f, -0.03143300f, -0.04475802f, -0.18704547f, -0.05838468f, 
    0.11017716f, -0.01566009f, -0.50585610f, -0.23680443f, -0.13602740f, -0.15697598f, 0.02848356f, -0.11953948f, 
    0.09884600f, 0.47710681f, 0.43298951f, -0.37927812f, -0.00600140f, 0.14238416f, -0.03384829f, -0.36950561f, 
    -0.16531512f, 0.02563647f, 0.05443815f, 0.22813298f, 0.28151250f, -0.02513743f, 0.15261638f, -0.07354001f, 
    0.11465706f, 0.22195883f, 0.00021873f, 0.35509235f, 0.31864712f, -0.62206239f, 0.08567791f, 0.18387391f, 
    0.13537653f, 0.07833759f, 0.06597371f, 0.00949476f, 0.16871004f, 0.04894564f, 0.19316776f, 0.18381660f, 
    0.27565724f, 0.01127706f, -0.10858072f, -0.38177666f, -0.11152960f, 0.02111805f, 0.18858801f, -0.01674887f, 
    0.18325651f, -0.15132385f, 0.28370541f, 0.11361177f, 0.12496973f, -0.07993165f, 0.34429386f, -0.19472894f, 
    -0.33420596f, -0.37213051f, 0.08420055f, -0.15087216f, 0.42018935f, 0.10975088f, 0.31529856f, -0.24060349f, 
    -0.25585172f, 0.17112556f, 0.09470399f, 0.20629080f, 0.18698712f, -0.14567062f, 0.20314477f, -0.03394836f, 
    0.15598904f, 0.59077144f, 0.27153221f, -0.19956635f, -0.06968452f, -0.14732108f, -0.13484798f, -0.30318141f, 
    -0.29420343f, 0.07284971f, -0.01364459f, -0.02878305f, 0.00414672f, 0.18650034f, 0.03892364f, -0.53837866f, 
    -0.23427424f, -0.50186658f, 0.11122146f, -0.02917446f, 0.13456611f, -0.13591707f, 0.10085309f, -0.05363330f, 
    -0.07703592f, -0.19040979f, 0.09111448f, -0.02428378f, 0.12951222f, 0.25647777f, 0.01317864f, 0.01473927f, 
    0.19492745f, 0.18912554f, 0.11118293f, 0.33390152f, 0.20201235f, 0.01947011f, 0.09489004f, 0.15605545f, 
    -0.07000112f, 0.32600251f, 0.18214154f, 0.10391005f, 0.25828028f, -0.62901556f, -0.66389120f, -0.28852618f, 
    -0.20795961f, -0.02491619f, -0.42571551f, -0.12273859f, -0.00208836f, -0.02233280f, 0.23916079f, 0.09657441f, 
    0.38250124f, 0.05345154f, -0.12848154f, 0.05875426f, -0.09190327f, -0.22412181f, 0.06189239f, 0.21789108f, 
    -0.14948238f, 0.18888719f, -0.24886930f, 0.14666344f, 0.07770273f, 0.03826706f, -0.13431485f, 0.16685446f, 
    -0.35863549f, -0.58431041f, -0.59168172f, -0.20198597f, 0.24215542f, 0.09263095f, -0.06381659f, 0.03882033f, 
    -0.00540325f, -0.23555274f, -0.38512805f, -0.42728832f, -0.14652644f, -0.06837382f, 0.26130050f, 0.05121019f, 
    -0.00180428f, -0.06848919f, 0.22040020f, 0.39852571f, 0.40934581f, -0.01323234f, -0.04760261f, -0.04071851f, 
    -0.07340579f, 0.13534521f, 0.08934215f, 0.52199644f, -0.03815490f, -0.08394007f, -0.78460324f, -0.37992793f, 
    -0.18656042f, 0.13658549f, 0.15010692f, 0.14609298f, -0.19636139f, -0.32560286f, -0.50847268f, 0.05495174f, 
    0.12557802f, 0.00864528f, -0.09258670f, 0.07919294f, 0.27920884f, -0.30971295f, -0.96549135f, 0.00453521f, 
    -0.21634211f, 0.02621161f, -0.01425554f, -0.00035442f, 0.03127004f, -0.12144443f, -0.34174266f, 0.44245765f, 
    0.72570473f, 0.15574335f, -0.26406088f, -0.18078372f, 0.47728631f, -0.19433518f, 0.03881080f, 0.80174053f, 
    0.81557709f, 0.61128008f, -0.11838472f, -0.10884739f, -0.00596339f, 0.00675893f, 0.10262942f, 0.14068136f, 
    -0.46179828f, -0.29934287f, -0.57263523f, -0.15394188f, -0.09362081f, 0.21644706f, 0.10747522f, 0.11514127f, 
    -0.20545676f, -0.32813054f, -0.22031118f, 0.43476027f, -0.14989108f, -0.05086710f, -0.01269242f, -0.32428524f, 
    0.14562978f, 0.35313991f, -0.26886535f, -0.17210209f, -0.12381023f, -0.11686394f, -0.09090012f, -0.16089413f, 
    -0.14571655f, -0.11764535f, 0.02872243f, 0.42991412f, 0.33400801f, 0.23316906f, -0.02172399f, 0.11458424f, 
    0.09986547f, 0.03101121f, 0.29411316f, -0.06148001f, -0.20013338f, -0.57371265f, 0.18357192f, 0.24985158f, 
    -0.29982969f, -0.10369822f, 0.36983201f, 0.10062324f, 0.07737292f, -0.51065278f, -0.20156971f, -0.06766246f, 
    0.14203425f, 0.01035995f, -0.25253862f, -0.10358498f, -0.10053402f, -0.08800898f, 0.38881010f, 0.25199902f, 
    0.15276603f, -0.03500798f, -0.09397191f, -0.14565048f, -0.00752398f, -0.10189437f, -0.05760783f, -0.15758993f, 
    -0.01903122f, 0.02505019f, 0.06522604f, 0.02724549f, -0.38140425f, 0.17670490f, -0.15189540f, 0.10281184f, 
    0.12744300f, -0.18972133f, -0.02917031f, -0.19652693f, -0.08362134f, -0.11528344f, 0.02704427f, -0.17974974f, 
    0.11776467f, 0.17007580f, 0.12774135f, -0.28917697f, -0.00274204f, -0.00428160f, -0.08108190f, 0.01065848f, 
    -0.19979818f, -0.12643798f, 0.11515569f, 0.04630690f, 0.18760665f, -0.08348859f, 0.04573113f, -0.21193318f, 
    -0.04654759f, -0.04384847f, 0.06446128f, 0.62905645f, 0.33866632f, -0.05462999f, -0.06632072f, -0.09658158f, 
    0.09194306f, 0.10654778f, 0.10494239f, 0.06257072f, -0.07828341f, 0.05025679f, 0.37655830f, 0.26101696f, 
    -0.34269032f, 0.08795831f, -0.17586133f, -0.21418586f, -0.24589305f, 0.29693100f, 0.12013031f, -0.00289056f, 
    0.19130929f, 0.12919867f, -0.31305337f, 0.20847465f, 0.26947939f, 0.25104180f, 0.18558574f, -0.12729159f, 
    0.46441868f, -0.36954218f, 0.22598216f, -0.17080988f, 0.21439429f, -0.02898921f, 0.29876468f, -0.48707369f, 
    -0.10090905f, 0.14875622f, 0.06713361f, -0.27366513f, -0.01771041f, -0.28037035f, -0.09055880f, -0.24995057f, 
    0.56261772f, -0.06679699f, -0.15671238f, -0.00512817f, -0.06972186f, 0.28056523f, -0.01933990f, 0.09722453f, 
    -0.02463421f, -0.16610111f, -0.22186016f, 0.26372665f, 0.24093734f, 0.01455366f, -0.17493759f, -0.06688354f, 
    -0.41837570f, -0.21330503f, 0.16376609f, 0.13259956f, 0.24367194f, 0.00265597f, -0.00539969f, -0.11217803f, 
    -0.08255931f, 0.07838430f, 0.06599475f, -0.15995316f, 0.08024281f, 0.20842898f, -0.17145739f, 0.02409877f, 
    0.01518190f, 0.14901145f, 0.31526738f, 0.10628504f, 0.86066526f, 0.03425534f, 0.20862743f, -0.42191955f, 
    0.06705267f, 0.06054366f, 0.17098650f, 0.23923504f, 0.36994138f, -0.01044873f, -0.08985000f, -0.14079463f, 
    0.15375553f, 0.28589126f, -0.37263504f, -0.35850549f, -0.11312326f, -0.12950182f, 0.02029628f, 0.06975682f, 
    0.09711955f, -0.01393766f, -0.21489744f, -0.14094430f, 0.05454148f, 0.15861413f, -0.00319575f, -0.05206647f, 
    -0.07251181f, 0.01533080f, -0.09985404f, -0.05123400f, -0.03735688f, -0.11014298f, -0.21916372f, 0.08312228f, 
    -0.56348610f, 0.71405125f, 0.57438171f, 0.01046273f, 0.29870564f, -0.11919436f, 0.09436343f, 0.05487525f, 
    0.32160172f, -0.14664994f, 0.02953645f, -0.53172982f, -0.12250175f, -0.00506957f, -0.07713917f, -0.06207086f, 
    0.04748729f, 0.08390026f, 0.03483380f, -0.01170802f, -0.19899227f, -0.15783051f, -0.31912866f, 0.11437657f, 
    0.22996795f, 0.04086810f, 0.08954911f, -0.74741304f, 0.35028309f, -0.42832723f, -0.00436481f, 0.03288824f, 
    -0.14555292f, 0.20582220f, 0.27557993f, 0.03206942f, 0.18766603f, 0.16971087f, -0.03220956f, 0.30828086f, 
    -0.25793719f, -0.15957084f, 0.30132633f, -0.24397677f, 0.14707907f, -0.68498111f, 0.18289171f, 0.07214507f, 
    -0.28607190f, 0.17883724f, -0.14152604f, 0.09461748f, -0.00191679f, 0.00042941f, -0.07946297f, -0.51395571f, 
    -0.40197414f, 0.16662881f, -0.05091543f, -0.12784716f, 0.23757796f, -0.05720441f, 0.11518178f, -0.24869661f, 
    -0.46214867f, 0.14173692f, 0.32025695f, 0.37081638f, -0.06670993f, 0.30736801f, 0.18669668f, 0.15689668f, 
    -0.54011911f, 0.02712320f, -0.31260508f, 0.20345914f, -0.21876238f, -0.18869707f, -0.02859528f, -0.27062222f, 
    -0.02868665f, 0.23902172f, -0.01738283f, -0.16162395f, 0.12677239f, -0.28542623f, -0.08698862f, 0.23328307f, 
    -0.25955892f, -0.09918322f, -0.18084097f, 0.08334178f, -0.06068397f, 0.01906716f, 0.00454381f, -0.05854537f, 
    -0.02251972f, 0.00329736f, 0.02713884f, 0.39891252f, -0.31234175f, -0.33432227f, 0.18141666f, 0.08705327f, 
    0.08869062f, 0.30975449f, 0.32638597f, 0.34417298f, -0.17339689f, -0.25481662f, -0.45951882f, 0.04509699f, 
    0.06744793f, 0.03374220f, 0.23095481f, 0.15894692f, 0.16416803f, -0.41317004f, -0.30400854f, 0.42955780f, 
    -0.04351886f, 0.05265011f, -0.25292823f, -0.15099663f, -0.05751481f, 0.03262815f, 0.17523269f, -0.17334789f, 
    0.18361180f, 0.06864109f, -0.16901122f, 0.16863011f, -0.18642527f, 0.03950917f, -0.03205629f, 0.07423952f, 
    -0.03855132f, 0.41646379f, 0.32134190f, 0.14983140f, 0.14654373f, 0.30568260f, 0.29594204f, 0.03153015f, 
    0.16166967f, 0.17990421f, 0.10370193f, -0.09857646f, 0.25502917f, -0.11443349f, 0.13577941f, -0.19656588f, 
    -0.05444023f, 0.04634757f, 0.34676123f, 0.49145713f, -0.02650109f, 0.14576171f, -0.06512375f, 0.21457827f, 
    -0.09330726f, -0.08295449f, -0.05420853f, 0.11291838f, 0.33784953f, 0.15893514f, 0.32617602f, 0.19009215f, 
    0.33257100f, 0.19776297f, 0.18255240f, -0.02415526f, -0.39120230f, -0.52508783f, 0.16868415f, -0.01944391f, 
    0.01960144f, 0.08225162f, -0.13123693f, -0.01597782f, -0.13514365f, 0.29830778f, 0.14725833f, 0.39743766f, 
    -0.07098781f, 0.09037549f, -0.46101698f, 0.33693704f, 0.47302726f, 0.22128220f, 0.15560669f, 0.16112106f, 
    -0.12725902f, -0.09779157f, 0.13838920f, -0.13203651f, 0.09494825f, 0.00682274f, -0.04846432f, 0.52983785f, 
    -0.02229092f, 0.23885913f, 0.35131979f, 0.15206835f, 0.28706783f, 0.32904527f, 0.32693052f, -0.38951200f, 
    0.09385505f, 0.04462754f, 0.28890494f, 0.16942950f, 0.24866731f, -0.01732244f, 0.04953291f, 0.26834324f, 
    -0.05691426f, 0.56882149f, 0.77082545f, -0.24941412f, 0.18636498f, -0.03435363f, -0.13868345f, 0.00897313f, 
    -0.01611552f, -0.11001411f, -0.04956411f, 0.04211423f, 0.15697943f, -0.04438796f, 0.17458184f, -0.65285623f, 
    0.06837139f, 0.33535799f, -0.22545846f, -0.04951794f, -0.28428680f, 0.15810427f, 0.11137226f, -0.14026231f, 
    -0.14259453f, 0.24109244f, 0.18175305f, -0.07412570f, 0.20214899f, 0.09071772f, -0.20234248f, 0.37369001f, 
    -0.04593514f, 0.11857224f, 0.29687303f, 0.32672420f, 0.03404760f, -0.13217171f, 0.01840487f, 0.08919683f, 
    -0.12513953f, 0.01040431f, 0.49137139f, 0.27956507f, 0.12128849f, 0.19667791f, 0.04962784f, -0.13895316f, 
    0.05165238f, 0.12292020f, 0.13114247f, -0.36636683f, -0.15930781f, -0.35284635f, -0.01042249f, -0.07010981f, 
    -0.04337300f, -0.00256214f, 0.16546269f, 0.17196696f, -0.16596699f, 0.39013529f, 0.18972734f, -0.06425729f, 
    0.05781833f, -0.06841584f, 0.31135809f, 0.31774646f, 0.08183368f, -0.02928614f, 0.17275904f, 0.36313629f, 
    0.47627309f, 0.01217621f, -0.63479292f, 0.13434072f, -0.05575563f, 0.10450175f, 0.06213494f, -0.02732065f, 
    0.00947397f, 0.23471382f, -0.09256749f, 0.30536142f, -0.06215230f, 0.02649668f, 0.26026648f, -0.07480127f, 
    -0.02173873f, 0.09976847f, 0.19950271f, -0.08979174f, 0.52217400f, 0.12621203f, 0.11834767f, -0.09795650f, 
    0.00210694f, -0.00306227f, -0.08606333f, 0.55491149f, 0.43053204f, 0.42164770f, -0.09828746f, 0.18785688f, 
    0.04655005f, 0.13378106f, -0.03048883f, 0.12287470f, -0.34237707f, -0.38256386f, -0.47835502f, 0.00265074f, 
    -0.06670857f, -0.19673115f, 0.06896763f, -0.03063287f, -0.06626342f, -0.15281223f, 0.40601629f, -0.19485347f, 
    -0.10221704f, -0.03809263f, 0.15805596f, 0.16132376f, 0.13316813f, 0.09820227f, 0.32635278f, 0.29264796f, 
    0.40265650f, 0.16547453f, -0.25473368f, -0.18943617f, 0.21739216f, 0.02573795f, -0.06153455f, -0.32632178f, 
    0.29509720f, -0.36855447f, 0.09228316f, -0.44916719f, -0.36990005f, 0.02031581f, -0.01271903f, -0.01070663f, 
    -0.00130979f, 0.49181369f, -0.30001023f, -0.05684080f, -0.13195549f, 0.11309757f, 0.06344593f, 0.12296664f, 
    0.07360868f, -0.01528991f, -0.95088911f, 0.05661751f, -0.21235090f, -0.01925709f, -0.07052862f, 0.03344311f, 
    -0.18237033f, -0.13776544f, 0.30852446f, -0.19079189f, -0.02932917f, -0.05208388f, -0.13110356f, -0.13312630f, 
    0.10682445f, 0.00444262f, -0.01132253f, 0.19124843f, -0.18201999f, -0.25428897f, -0.04287667f, 0.26262292f, 
    -0.10274675f, 0.19079457f, 0.26538041f, 0.30387911f, 0.18058555f, 0.26506940f, 0.44368145f, -0.26199120f, 
    0.10337104f, -0.16977143f, -0.08386731f, -0.01020728f, 0.03408254f, 0.76881361f, -0.47560486f, 0.09830619f, 
    -0.07054804f, 0.05144585f, 0.19827949f, 0.04302966f, 0.16370986f, -0.10276261f, 0.18507239f, 0.22708373f, 
    -0.26976371f, 0.12197712f, -0.09819133f, 0.05854141f, 0.06609146f, 0.04182680f, 0.04448283f, -0.41819039f, 
    -0.35523236f, -0.61314380f, 0.09443633f, -0.16533016f, -0.13218673f, 0.09134821f, 0.05727383f, -0.03423980f, 
    0.09276189f, 0.26427895f, -0.00817068f, 0.09469934f, -0.16451015f, 0.02471645f, 0.10503998f, -0.00569845f, 
    -0.00092795f, 0.03216040f, 0.47148874f, 0.04071075f, 0.12656951f, -0.12485304f, -0.04878165f, 0.00333863f, 
    -0.25798911f, -0.28581342f, -0.04659064f, -0.36489046f, -0.02730819f, -0.14125620f, -0.07771082f, -0.13596320f, 
    -0.09039354f, -0.21855690f, -0.08486793f, 0.12227349f, 0.28069240f, 0.17229089f, 0.12503533f, 0.12402865f, 
    0.17526042f, 0.14191927f, -0.20728858f, 0.01216238f, 0.12491810f, 0.15530409f, -0.03953123f, 0.12479305f, 
    -0.10178316f, 0.04771864f, -0.12582210f, -0.03582288f, 0.01548987f, 0.24351144f, -0.04427823f, 0.09263362f, 
    0.23134296f, -0.05354337f, -0.14663765f, 0.25619581f, 0.03962247f, 0.18295318f, 0.26798186f, 0.71954548f, 
    0.24007207f, -0.07546586f, 0.30375224f, -0.01851078f, 0.11395098f, -0.15353222f, 0.30352774f, -0.19211537f, 
    -1.31445336f, -0.13642034f, 0.02110367f, -0.01218885f, -0.20874506f, 0.03024039f, -0.02195349f, -0.33331156f, 
    -0.27279145f, 0.06623761f, 0.03514148f, -0.31535703f, -0.20168413f, 0.06442258f, -0.04855176f, -0.03171476f, 
    -0.06164838f, -0.19908467f, 0.29180226f, -0.55451822f, 0.32482699f, 0.06321708f, 0.01708169f, -0.10454105f, 
    0.01923789f, -0.00083398f, 0.33788255f, -0.25807196f, -0.16704756f, 0.09207802f, 0.14362071f, -0.06011605f, 
    -0.09574743f, -0.18863450f, 0.20761578f, 0.05156111f, -0.18489742f, 0.01915626f, 0.19906886f, 0.03681324f, 
    -0.03125077f, 0.04726765f, 0.05242680f, 0.06216633f, 0.17397074f, 0.52393496f, 0.54191899f, 0.16898586f, 
    0.03036647f, -0.00727635f, 0.00797182f, 0.03545287f, 0.03296426f, -0.30164066f, 0.10656277f, 0.19346446f, 
    0.08625773f, 0.18988232f, 0.15417731f, 0.02201072f, 0.02196544f, -0.09927724f, 0.10183542f, -0.19258881f, 
    -0.40371412f, -0.03209370f, 0.07762451f, 0.10426891f, -0.09047749f, 0.15614299f, 0.09152631f, -0.34824425f, 
    -0.17666405f, 0.35606098f, -0.23199841f, 0.09806935f, -0.16296028f, 0.09276138f, -0.00371646f, 0.18271858f, 
    -0.34712580f, 0.03672612f, 0.08744969f, -0.07262667f, 0.04317428f, 0.05771760f, 0.05308945f, -0.05065554f, 
    0.00305115f, -0.47425359f, -0.19171013f, 0.28490129f, -0.00857726f, 0.07278904f, 0.18682246f, -0.09432080f, 
    0.33521613f, 0.14920329f, 0.21932878f, 0.16178538f, -0.03709267f, 0.01913825f, 0.03668367f, -0.10242756f, 
    -0.13300596f, -0.02298103f, 0.02437319f, 0.10992080f, 0.32211107f, -0.54478312f, 0.08130669f, 0.05847208f, 
    -0.17287013f, -0.03204881f, -0.11343075f, 0.36235633f, 0.18583839f, -0.15542740f, 0.05594941f, -0.47931707f, 
    -0.03637869f, 0.16406159f, -0.03002776f, 0.06189409f, 0.28683656f, -0.13665238f, 0.23480430f, 0.08450846f, 
    -0.11457448f, -0.08926772f, 0.12691800f, 0.07061867f, 0.06773595f, -0.05476566f, 0.41672444f, 0.49820316f, 
    -0.07350975f, 0.31840876f, 0.19421823f, 0.01867306f, -0.14976349f, -0.24311581f, -0.53247064f, 0.15270810f, 
    0.08663937f, 0.06063377f, 0.13164265f, 0.00280088f, 0.10824286f, 0.10778721f, 0.24956138f, 0.24383825f, 
    -0.42691901f, -0.32756615f, -0.48123166f, 0.27383587f, 0.02518296f, -0.36395791f, -0.20847167f, -0.16864452f, 
    0.11885561f, -0.04082828f, -0.01381292f, 0.21775152f, -0.26475269f, 0.07759877f, 0.02960745f, -0.14282322f, 
    0.37811780f, 0.37229094f, -0.10602183f, 0.13707076f, -0.40540656f, -0.11565936f, 0.22279637f, 0.05422165f, 
    0.04116940f, -0.10798145f, 0.06107510f, 0.36903200f, 0.06792825f, 0.04451020f, 0.08379593f, -0.03755797f, 
    0.17874540f, 0.01625148f, -0.11417690f, -0.02335178f, -0.88127393f, -0.25815156f, -0.31272876f, -0.27688694f, 
    0.08181652f, -0.02211482f, 0.02518769f, -0.07605049f, -0.18718626f, 0.16454889f, 0.45097122f, -0.05140541f, 
    -0.01385526f, -0.18278030f, 0.25455442f, 0.13382997f, -0.30589813f, 0.16340794f, 0.28919372f, 0.12355989f, 
    0.17682423f, -0.09088370f, -0.02518504f, -0.01456597f, 0.05642520f, 0.06683245f, -0.10191920f, 0.06910477f, 
    -0.06043887f, 0.17421010f, -0.03850290f, -0.05450032f, 0.18154953f, 0.03411920f, -0.15304762f, -0.07814031f, 
    -0.35901219f, -0.05415064f, 0.21518210f, 0.09663253f, 0.04279608f, 0.19027463f, 0.14663443f, -0.00097535f, 
    0.07308333f, 0.40066755f, 0.34142882f, 0.23382594f, 0.16959034f, -0.10229003f, -0.06421937f, 0.18065932f, 
    0.06683679f, 0.16472852f, -0.50537527f, -0.37458953f, -0.66455179f, 0.15223746f, 0.15406771f, -0.10633294f, 
    -0.03394889f, 0.30502951f, -0.01542750f, -0.03769368f, -0.04974685f, 0.28124914f, 0.08571641f, -0.01158721f, 
    0.08605479f, 0.25922698f, 0.08642553f, 0.09987377f, -0.00200443f, 0.31589535f, -0.78942358f, -0.00082869f, 
    0.00304755f, -0.08043972f, 0.25861120f, -0.05144570f, -0.08408846f, -0.46535370f, -0.13722998f, -0.48809984f, 
    0.26348895f, -0.21561120f, 0.13707043f, 0.21236733f, 0.14397097f, 0.15124121f, 0.11929247f, -0.08452334f, 
    0.19669320f, -0.20009226f, 0.17549564f, -0.30782375f, 0.03092195f, -0.31461278f, 0.16957113f, -0.39506426f, 
    -0.34788463f, 0.53104860f, 0.00275901f, 0.19445406f, 0.31196433f, 0.15876646f, 0.09815525f, 0.06739250f, 
    -0.33456948f, -0.09403098f, -0.16854167f, 0.27676296f, -0.32957616f, 0.24028637f, 0.17854911f, 0.03726680f, 
    -0.25609609f, -0.01021788f, -0.35906726f, -0.41287202f, 0.04966033f, -0.04392644f, 0.25917771f, 0.14178203f, 
    -0.12687965f, -0.09047552f, -0.92657834f, -0.98807883f, -1.03745937f, -0.14390360f, -0.10681054f, -0.21884164f, 
    0.05619255f, 0.09380937f, 0.32118064f, 0.21986468f, -0.44616035f, -0.18838613f, -0.27838036f, -0.12305458f, 
    -0.05672005f, -0.11145947f, 0.11214852f, 0.10706638f, 0.22664617f, 0.13669206f, 0.64695650f, -0.35713652f, 
    -0.15764654f, -0.04598538f, -0.10918087f, 0.01288272f, 0.05532957f, -0.89758408f, 0.21180426f, -0.51248610f, 
    -0.10807788f, -0.09706737f, -0.04622484f, 0.18351263f, -0.22842631f, -0.07088903f, 0.01995899f, -1.23219287f, 
    -0.88696468f, 0.15098925f, 0.23648565f, 0.11789082f, 0.11273906f, 0.31415468f, 0.22229600f, -0.47559026f, 
    -0.38380569f, -0.01930830f, 0.17829901f, 0.15642494f, -0.27935401f, 0.08341617f, 0.24972241f, 0.25017104f, 
    0.46508640f, -0.25991818f, -0.22812536f, -0.08816715f, 0.26582918f, 0.25191757f, -0.05743672f, -0.17085032f, 
    0.07366303f, 0.04599522f, -0.14215471f, -0.10154469f, 0.06632576f, -0.18200757f, 0.03740026f, -0.13348326f, 
    0.25722110f, 0.31205058f, -0.05046447f, -0.23135260f, -0.07525513f, 0.13287657f, 0.22369619f, -0.00790734f, 
    0.24208128f, -0.05787635f, -0.08236051f, 0.23608628f, -0.16315192f, -0.14911072f, -0.06828425f, -0.18375260f, 
    -0.19258396f, -0.02601427f, 0.11474901f, -0.11937532f, -0.12814863f, -0.17449528f, -0.33483940f, 0.09631160f, 
    0.05586125f, 0.15512611f, -0.05136462f, -0.20293574f, 0.13916354f, 0.29439732f, -0.28840366f, -0.27839127f, 
    0.05481493f, 0.20534573f, 0.05817848f, 0.27785683f, -0.16587307f, -0.07673609f, -0.03315809f, -0.20193219f, 
    -0.48701251f, 0.18644340f, -0.05744530f, 0.00831953f, 0.13754292f, -0.01228895f, -0.06197455f, -0.11496978f, 
    0.57300782f, 0.40443066f, 0.02100119f, 0.01523706f, -0.03777358f, -0.00656141f, 0.01130487f, -0.15014508f, 
    0.64030027f, -0.12400842f, -0.33799991f, 0.18071339f, -0.06971748f, -0.10696700f, -0.12953782f, 0.12848823f, 
    0.28292298f, -0.54389393f, -0.48488000f, -0.05790001f, 0.06941620f, 0.03036657f, 0.05572408f, 0.02148845f, 
    0.16419448f, -0.08166517f, -0.13670617f, -0.05383879f, 0.04766706f, -0.09905387f, 0.23926555f, 0.28801528f, 
    0.09851406f, -0.30165344f, -0.12105746f, -0.26212192f, 0.27091941f, 0.08129257f, -0.07162070f, -0.09161576f, 
    -0.07998942f, -0.05473046f, 0.09107000f, 0.04898804f, 0.17508607f, -0.05582509f, -0.10689969f, 0.35554650f, 
    -0.07364511f, 0.10565374f, -0.10625335f, 0.01980417f, -0.15635318f, 0.68813068f, -0.02553333f, -0.53164315f, 
    -0.25317955f, 0.12678589f, 0.23292507f, 0.07263242f, 0.25884920f, 0.19240871f, -0.23592542f, -0.08645843f, 
    0.00436014f, 0.03072998f, -0.00480836f, 0.09695278f, 0.07594512f, -0.02483503f, 0.03814734f, -0.01144664f, 
    -0.07653596f, -0.24387705f, 0.13594919f, 0.14496732f, 0.01912523f, -0.15908615f, 0.03128923f, 0.10215060f, 
    0.27703750f, -0.10509094f, 0.61386639f, -0.04712973f, 0.04378475f, 0.19946104f, -0.05559920f, -0.07636143f, 
    0.35291964f, 0.11867040f, 0.06358107f, 0.03396098f, -0.12719361f, 0.08314342f, 0.17526218f, 0.16296111f, 
    -0.07096510f, -0.06383958f, -0.44753850f, -0.44162521f, -0.24345809f, -0.03072538f, -0.04537170f, -0.00028720f, 
    0.12161171f, -0.05570760f, 0.19493510f, -0.41860354f, -0.06893199f, 0.15037896f, 0.11993436f, -0.10036330f, 
    -0.12531619f, 0.11362936f, 0.18178305f, 0.05887902f, 0.20365664f, -0.33562014f, -0.13789204f, 0.02024893f, 
    0.12214540f, 0.10834163f, 0.01236716f, 0.00345928f, -0.01173335f, -0.06915370f, -0.57096022f, 0.23678403f, 
    -0.02844876f, -0.03864839f, -0.08975511f, -0.17873734f, 0.13146517f, 0.18966705f, -0.49740231f, -0.04126319f, 
    0.25032890f, -0.23154809f, 0.27508950f, -0.13240680f, 0.35549027f, -0.09186289f, -0.01712907f, -0.15664843f, 
    -0.18041930f, -0.53756690f, 0.21161680f, 0.09460977f, 0.26742014f, 0.04087300f, -0.03881112f, 0.14076003f, 
    0.24808136f, -0.32140607f, 0.02174945f, -0.02476381f, 0.08721793f, 0.28565037f, 0.31195965f, 0.04460775f, 
    -0.25053313f, -0.03174751f, -0.04055832f, 0.03742513f, -0.10071506f, -0.28862506f, -0.04075536f, -0.04990904f, 
    -0.12741584f, -0.20881395f, -0.26710185f, -0.32957751f, -0.04190857f, 0.02727752f, -0.01674368f, -0.18979092f, 
    0.01710687f, 0.03494598f, 0.07385668f, -0.32423505f, -0.12964480f, -0.22349885f, 0.05071786f, -0.05878445f, 
    0.02322141f, -0.07449143f, 0.16008927f, 0.17591566f, -0.08807392f, 0.27335998f, 0.50254571f, 0.04524275f, 
    0.05778836f, -0.24008794f, 0.19144030f, -0.03242131f, 0.25719482f, -0.14482471f, 0.10948718f, 0.29571265f, 
    0.03478838f, -0.40073875f, -0.35070327f, 0.09906127f, -0.11229662f, -0.07099717f, -0.64058626f, -0.18553394f, 
    0.01123230f, -0.00456937f, 0.03840622f, 0.09903365f, 0.40987614f, 0.07216313f, 0.07940392f, -0.01314658f, 
    -0.15720673f, 0.53572875f, 0.09086104f, 0.31774235f, 0.11056402f, 0.24414092f, -0.06273346f, 0.08365846f, 
    0.06280521f, -0.19384491f, 0.03048839f, 0.14640608f, -0.21622969f, -0.39073053f, -0.06913098f, 0.20691261f, 
    0.04744362f, 0.14572981f, -0.67270827f, -0.36153743f, -0.36769402f, -0.16921362f, 0.15960380f, 0.15433256f, 
    -0.03796615f, -0.20070313f, -0.53633368f, -0.03203448f, -0.09222805f, 0.12191387f, 0.17526548f, -0.06330555f, 
    -0.03140571f, -0.00464734f, 0.00036451f, -0.17773193f, 0.01890912f, 0.57871705f, -0.23781854f, -0.48219129f, 
    -0.10900481f, 0.17396541f, 0.07791503f, 0.29543066f, 0.08834079f, 0.04267834f, 0.32931334f, -0.32380250f, 
    0.18097764f, 0.04392862f, -0.10935710f, 0.11607186f, -0.16276103f, -0.10035775f, -0.42077214f, 0.00871983f, 
    -0.22778212f, 0.03231633f, -0.15732548f, 0.16108719f, 0.07320032f, 0.06194967f, -0.10318127f, 0.18116198f, 
    -0.40658736f, -0.33945745f, 0.08058332f, -0.41719589f, -0.15136482f, 0.03554030f, -0.09997463f, 0.32857376f, 
    -0.70255417f, -0.27266741f, 0.10492221f, 0.23687249f, 0.06414317f, 0.18913208f, -0.12502967f, 0.22743624f, 
    -0.26572537f, -0.42912769f, -0.79224092f, -0.01438976f, 0.19201814f, 0.10455433f, 0.21261805f, -0.10415240f, 
    0.00881755f, 0.55499536f, -0.17927273f, 0.02691576f, -0.02398059f, -0.15723735f, 0.02557621f, -0.03747139f, 
    0.19515190f, 0.24253529f, 0.27801540f, 0.27635166f, 0.26180327f, -0.22674282f, -0.04187181f, -0.21811464f, 
    0.01987609f, 0.01990106f, 0.03675062f, 0.00137279f, 0.14427924f, -0.00024225f, 0.33758143f, 0.05218339f, 
    0.41535944f, 0.31142947f, -0.14672554f, -0.18222111f, 0.30549303f, 0.62429637f, -0.02093985f, -0.21666372f, 
    -0.10625361f, 0.10487872f, -0.00724559f, -0.06704721f, -0.03079442f, 0.05896559f, 0.66050619f, 0.52773923f, 
    -0.08298907f, -0.26008183f, -0.64704728f, 0.07687502f, -0.17922294f, 0.24856675f, 0.00261070f, 0.04261411f, 
    -0.04321515f, -0.01041743f, 0.04496291f, 0.22280614f, 0.24684480f, 0.02687646f, 0.07172897f, 0.24702691f, 
    -0.15066157f, 0.19885457f, -0.32455510f, 0.06401132f, -0.20174387f, -0.09459458f, 0.07019046f, -0.05924771f, 
    0.39593229f, -0.12466835f, 0.05023700f, 0.24499774f, -0.26484644f, -0.04798023f, 0.18576877f, 0.09093161f, 
    0.06930740f, 0.06323666f, 0.36293203f, -0.16351601f, 0.03707109f, -0.12612092f, -0.19966209f, -0.18617578f, 
    0.19746567f, 0.06778596f, -0.08199674f, 0.07513528f, 0.05493161f, 0.03435133f, -0.04283093f, -0.25087795f, 
    -0.07068506f, 0.15741454f, 0.09554788f, 0.24844627f, 0.30417216f, 0.34417942f, -0.14821167f, -0.22886568f, 
    -0.17285849f, 0.04872606f, 0.06140665f, 0.31865793f, -0.11693704f, -0.01353968f, 0.33228052f, -0.43161464f, 
    0.00027527f, -0.28834075f, -0.04856518f, 0.04943675f, 0.03155446f, 0.83373725f, 0.21789996f, 0.16838181f, 
    0.02233092f, 0.30638409f, -0.06749377f, 0.18462542f, 0.20692185f, 0.02072424f, -0.68797755f, 0.48627418f, 
    -0.01322090f, -0.20326339f, -0.07411236f, -0.02500807f, -0.05092099f, -0.04500862f, 0.01258823f, -0.17992257f, 
    -0.48764291f, 0.03165086f, -0.15930070f, 0.02759215f, -0.07028773f, 0.09631552f, -0.14051449f, 0.06514335f, 
    -0.07701220f, -0.04747316f, -0.25624245f, -0.03744240f, 0.13529110f, -0.27236843f, 0.01266545f, -0.23229747f, 
    -0.29704958f, -0.05294720f, 0.00603306f, 0.30340767f, 0.31030974f, -0.26657888f, -0.07888592f, 0.03700682f, 
    0.15488258f, 0.24675867f, 0.22923453f, 0.24690126f, 0.21346773f, -0.52303088f, -0.19981319f, -0.39139026f, 
    0.07565943f, -0.01669551f, -0.05363399f, -0.20719533f, -0.01260057f, -0.01896999f, 0.11328495f, 0.00821847f, 
    0.19640793f, -0.11334212f, 0.02015220f, -0.04030846f, 0.14518090f, -0.13965292f, 0.21195619f, 0.07329118f, 
    0.18941577f, -0.05060856f, -0.11059184f, -0.13411497f, -0.23944023f, -0.21302925f, 0.24540026f, 0.03202835f, 
    -0.23742007f, 0.16279082f, -0.06276669f, 0.24118891f, 0.13140585f, 0.18674959f, 0.15257706f, 0.24889721f, 
    0.15645738f, -0.01094366f, -0.04864953f, -0.18484929f, 0.05682101f, -0.01179794f, 0.12615120f, -0.01046620f, 
    0.01783268f, 0.11077031f, -0.53632855f, -0.17288810f, -0.38675272f, -0.04128406f, 0.11830597f, -0.01452933f, 
    -0.40124172f, -0.11145774f, 0.26692703f, 0.04541343f, -0.02996582f, -0.13798802f, 0.22659804f, 0.20813109f, 
    0.38550457f, -0.02449913f, 0.45615286f, 0.35612768f, -0.08583516f, 0.33330774f, -0.02935013f, 0.00504224f, 
    0.22837602f, 0.05960019f, 0.23659526f, -0.01352086f, -0.14515747f, 0.10450517f, 0.14865117f, 0.10769035f, 
    -0.13686103f, -0.18931402f, -0.23685271f, 0.03668871f, 0.32642323f, 0.60161519f, 0.12174159f, 0.09806305f, 
    0.24197753f, -0.02472978f, 0.03912111f, -0.04700590f, 0.19993344f, 0.02125107f, -0.24989761f, -0.04736933f, 
    0.05987863f, -0.04166667f, -0.12734675f, -0.41619357f, 0.38806218f, 0.16984309f, -0.25154614f, 0.20483153f, 
    0.39856279f, 0.07101192f, 0.06336778f, 0.28775302f, -0.40376550f, -0.59441364f, -0.32412526f, 0.31227371f, 
    -0.05514377f, 0.10681459f, 0.14999154f, -0.16775624f, -0.12567344f, -0.41341338f, -0.36514533f, 0.73829764f, 
    -0.13025925f, -0.04293546f, -0.04209573f, 0.15579247f, 0.14217983f, 0.16218846f, 0.10628379f, -0.07210363f, 
    0.22711013f, -0.22519878f, 0.17280862f, -0.19236259f, 0.02647253f, 0.07995952f, 0.15237734f, 0.01154347f, 
    0.23829754f, -0.48568651f, -0.08513200f, -0.40107083f, 0.16339208f, 0.05795222f, -0.09808834f, 0.18920749f, 
    0.26481441f, 0.34335074f, 0.04224614f, 0.10206859f, 0.20449683f, 0.04483917f, 0.22037244f, 0.24203305f, 
    -0.07165169f, -0.38534290f, -0.10711204f, 0.17921001f, 0.04256950f, 0.12134647f, 0.01799604f, 0.01501481f, 
    -0.05297358f, 0.00717129f, -0.38150343f, -0.35225901f, -0.11691747f, -0.30252501f, -0.13961959f, 0.34038070f, 
    -0.12359439f, -0.16202307f, -0.10116104f, -0.25469598f, -0.27402130f, -0.69217360f, -0.20226189f, -0.00311770f, 
    0.02360677f, -0.03665759f, 0.17808402f, 0.12260769f, -0.00751732f, 0.21574602f, 0.18470129f, -0.05048524f, 
    0.09248827f, -0.04260593f, 0.10178303f, 0.21103612f, -0.11646481f, 0.06970975f, -0.09646055f, -0.04330045f, 
    -0.03484017f, 0.05383614f, 0.08290995f, 0.22328751f, -0.07983804f, 0.10930121f, 0.16169907f, 0.09811313f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.53001255f, 0.13676983f, 0.23536448f, 0.27935091f, -0.30461687f, 0.62909174f, 0.01559036f, -0.20589788f, 
    -0.27104986f, -0.13545729f, 0.27263534f, -0.06581288f, 0.45846596f, 0.04253954f, 0.01218347f, 0.11955460f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.38758850f, -0.10818294f, 0.22149226f, -0.31301707f, 0.46230328f, -0.55876398f, -0.26428726f, 0.93443805f, 
    0.10369836f, -0.29369897f, -0.33177230f, 0.33827597f, -0.88977510f, -0.02503480f, 0.38504949f, -0.17529668f, 
    -0.10519259f, 0.34568819f, 0.45975378f, 0.40804324f, -0.10787912f, 0.04570388f, -0.15111633f, -0.02617040f, 
    -0.03576672f, 0.03675310f, 0.37209985f, -0.53358984f, 0.38650647f, -0.06747425f, 0.03829760f, -0.62352479f, 
    -0.56894153f, 0.40093285f, 0.02798833f, -0.62583262f, -0.38793704f, 0.27033690f, 0.11738922f, -1.35178280f, 
    -0.54709172f, -0.09972093f, -0.14629807f, -0.23870504f, 0.13077639f, -0.56900412f, 0.16260588f, 0.52598810f, 
    -0.99778467f, 0.57415980f, -0.18986410f, -0.25663602f, 0.46377674f, -0.79184532f, -0.07822925f, -0.38590282f, 
    -0.40163139f, -0.53422737f, 0.30208004f, 0.93046731f, -0.20039766f, 0.52866620f, -0.21339561f, 0.14825720f, 
    -0.27847967f, -0.30656713f, -0.09081957f, 0.13416414f, 0.07356410f, -0.30577230f, -0.49636874f, -0.07742551f, 
    0.66253996f, -0.03974445f, 0.53000337f, -0.05325669f, 0.04757803f, 0.51976961f, 0.52854592f, 0.31396425f, 
    -0.19052754f, -0.41326275f, 0.18375927f, 0.15439261f, 0.02116539f, 0.09617495f, 0.04669310f, 0.00583320f, 
    0.28341603f, -0.34587690f, 0.67971033f, -0.30316922f, -0.31198272f, -0.18301216f, -0.16920426f, 0.04045752f, 
    0.50287610f, -0.14648689f, -0.30833659f, -0.86657602f, -0.32271817f, 0.68174273f, -0.21241702f, -0.37100783f, 
    -1.34443331f, 0.52368474f, -0.87834072f, 0.00792571f, -0.52006489f, -0.08788004f, -0.39747190f, 0.42097563f, 
    0.63931131f, 0.49684241f, -0.21707286f, 0.04367330f, 0.05674474f, -0.38220602f, -0.18751085f, -0.45016363f, 
    0.52956474f, 0.43802384f, -0.15958691f, -0.13869292f, -0.27756515f, 0.08063275f, 0.21222690f, -0.16106454f, 
    0.42269728f, -0.88839579f, 0.18171239f, 0.34962684f, 0.45623350f, 0.30617079f, -0.14898266f, -0.03532910f, 
    0.33060947f, -0.20534869f, -0.60697615f, 0.36469772f, 0.31896433f, -0.46888766f, -0.73187453f, -0.62619740f, 
    -0.03449647f, 0.24584427f, -0.17114811f, -0.32039899f, -0.65217292f, 0.06329590f, -0.34229979f, 0.20119014f, 
    -0.74891239f, -0.03819882f, -0.84466803f, -0.17748740f, 0.55939263f, 0.98790509f, -0.02630052f, 0.48343077f, 
    -0.53028262f, -0.91796947f, 0.15188189f, -0.56762093f, 0.36602429f, -0.26523641f, 0.42279211f, -0.67616498f, 
    0.05237835f, -0.57894439f, -1.05974412f, -1.04942131f, 0.77356893f, -0.34295955f, 0.25987044f, -0.47581503f, 
    -0.90323251f, -0.31226248f, -0.31825066f, 0.88468462f, -0.44205159f, -0.26698580f, 0.32355973f, 0.14747390f, 
    -0.44222659f, 0.49880016f, -0.40697962f, 0.00236764f, -0.46289960f, -0.17982155f, -0.86270082f, 0.09564003f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.73494619f, 0.02767284f, 0.53503394f, 0.40620184f, -0.20062126f, -0.17268261f, 0.14623162f, -0.66396099f, 
    0.02977622f, 0.39869261f, 0.13119414f, 0.20212422f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
