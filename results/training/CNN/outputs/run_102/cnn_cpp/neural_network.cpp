#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.02529990f, -0.13543768f, -0.46884596f, -0.43332317f, -0.41779423f, -0.15962666f, 0.65528530f, 0.52730721f, 
    -0.36396569f, 0.10637443f, -0.01648618f, 0.02992139f, 0.07201358f, -0.12024555f, 0.25200826f, -0.38074487f, 
    -0.18662371f, -0.03265104f, 0.00190189f, -0.14811958f, 0.18038656f, 0.30050781f, -0.08057547f, 0.02581293f, 
    -0.19170511f, -0.82376051f, 0.45965105f, 0.32455572f, -0.47221336f, -0.53207636f, 0.52526653f, 0.12348494f, 
    -0.67185313f, -0.35683236f, -0.21063420f, -0.12321787f, 0.09943791f, -0.08554202f, 0.19434819f, 0.10440505f, 
    -0.19923575f, 0.04499464f, -0.10814553f, -0.06892908f, -0.17880629f, 0.11655617f, -0.03369845f, -0.06363202f, 
    -0.15585189f, 0.03407747f, -0.58390903f, 0.00467402f, -0.73139656f, -0.55326998f, 0.06407945f, -0.18690956f, 
    0.41599604f, 0.55439824f, 0.27475867f, 0.42195207f, -0.02819192f, 0.03240996f, 0.04340299f, -0.27801192f, 
    0.05582359f, 0.06743368f, 0.05964202f, 0.23310278f, 0.06250351f, -0.38587233f, -0.03217030f, 0.18267666f, 
    -0.21248916f, -0.04112067f, 0.20004676f, -0.19628121f, -0.32304811f, -0.05227264f, 0.34831801f, -0.13869995f, 
    -0.58953804f, 0.41707239f, -0.12071151f, -0.51424533f, -0.22090842f, -0.20759262f, 0.35291016f, 0.06111544f, 
    0.18269724f, -0.16394772f, -0.12654209f, -0.04729027f, 0.16996896f, -0.16309200f, -0.20706291f, 0.14965296f, 
    0.04040536f, 0.17837745f, 0.00610294f, -0.34394383f, -0.56095344f, -0.48830584f, -0.47042012f, -0.32012504f, 
    -0.22564249f, 0.58556324f, 0.51699656f, 0.00513812f, 0.12061793f, 0.41547841f, -0.34835860f, -0.19879180f, 
    0.09366249f, 0.26268703f, 0.17735183f, -0.05097639f, 0.06467245f, 0.20014553f, -0.15815245f, -0.14608058f, 
    0.22146198f, -0.05262676f, -0.35833812f, 0.12684134f, -0.08074076f, -0.27644959f, -0.57375503f, -0.07417791f, 
    0.44451883f, 0.35433862f, -0.71740574f, 0.43855256f, -0.07396054f, -0.51743287f, 0.22058234f, 0.05325831f, 
    0.05581690f, 0.29200360f, 0.02694491f, 0.21662675f, -0.19383416f, 0.39795902f, 0.23646177f, 0.13453385f, 
    0.15076040f, 0.14147644f, -0.12162018f, -0.03366920f, -0.07582710f, 0.04478673f, -0.44625503f, -0.68306631f, 
    -0.06819269f, 0.48118687f, -0.25519940f, 0.45654139f, -0.07346075f, -0.07362790f, -0.27196044f, -0.05576659f, 
    0.03005294f, 0.01615965f, -0.16756755f, 0.15744375f, 0.16593280f, -0.19902265f, 0.29159880f, 0.26871628f, 
    -0.02691429f, -0.02587728f, -0.04412797f, -0.24976665f, 0.02010916f, 0.02990789f, 0.13962448f, -0.10457829f, 
    -0.37275958f, -0.50808287f, -0.41238657f, -0.13542473f, 0.02441646f, -0.19520712f, -0.13654065f, 0.02102784f, 
    0.21956442f, -0.13358843f, -0.10887796f, -0.44641981f, -0.13575390f, -0.23079129f, 0.20045942f, 0.00488392f, 
    0.10166861f, 0.05394959f, -0.08361284f, 0.25784817f, -0.11795333f, 0.25495970f, 0.44953510f, -0.08991092f, 
    0.86611301f, 0.15628798f, 0.39480132f, 0.42660028f, 0.63792837f, 0.11874764f, -0.22983041f, -0.44712430f, 
    -0.20078011f, -0.33529830f, 0.14355618f, 0.15349336f, 0.00584357f, 0.24140815f, -0.29567999f, 0.03917843f, 
    -0.14587922f, -0.31100494f, 0.03008376f, -0.00461145f, -0.01265109f, 0.05983241f, 0.28432637f, -0.07958222f, 
    -0.21327464f, 0.21780057f, -0.37670204f, 0.47289890f, 0.25588980f, -0.02162663f, -0.29417711f, -0.63616568f, 
    -0.23586956f, 0.08930906f, 0.03381903f, 0.19623838f, 0.00366202f, -0.14938015f, -0.43027589f, 0.18896115f, 
    0.04833753f, -0.05108152f, -0.49146974f, -0.35610434f, -0.30146256f, -0.09477729f, -0.08729303f, 0.25382724f, 
    0.09155220f, 0.26920640f, 0.79840225f, -0.02916851f, 0.24554619f, 0.03568064f, 0.39917782f, -0.15577765f, 
    0.13251112f, 0.09321816f, -0.17075035f, -0.22681150f, -0.07472674f, -0.01268308f, 0.00563397f, -0.25517339f, 
    -0.15662168f, -0.14308113f, 0.03060726f, 0.11713521f, 0.15218568f, -0.01490569f, -0.15720642f, -0.05657484f, 
    -0.29175079f, -0.34428528f, -0.08131494f, -0.13587114f, -0.63886887f, 0.19379026f, 0.32805908f, 0.51493108f, 
    -0.63698578f, 0.50649661f, -0.07848713f, -0.49399439f, 0.39122364f, 0.28079292f, 0.10706868f, -0.04653652f, 
    -0.19164909f, 0.01730259f, -0.27754238f, -0.37357867f, -0.27001715f, -0.21650346f, -0.10636367f, -0.09256665f, 
    0.12468760f, 0.20790982f, -0.06134490f, -0.05059965f, -0.72629380f, 0.50878739f, -0.23462795f, 0.11640360f, 
    0.43598369f, -0.23687191f, 0.37125573f, 0.29984072f, -0.20214884f, 0.39911026f, 0.09102140f, -0.37463218f, 
    0.35091770f, -0.36707944f, 0.20795210f, -0.09229305f, -0.31105366f, -0.25785899f, -0.21492268f, -0.33517826f, 
    -0.03489233f, 0.13091424f, -0.14807361f, 0.08491874f, -0.02351423f, -0.36998039f, -0.23091500f, -0.25614065f, 
    -0.36847767f, 0.02838293f, -0.08818347f, 0.40514740f, -0.10091975f, 0.25847435f, 0.20605418f, -0.19529840f, 
    -0.19515303f, 0.17419235f, -0.31952739f, -0.03522655f, -0.30156735f, 0.37622705f, 0.15846077f, -0.15947537f, 
    -0.11330652f, -0.23660474f, -0.30937812f, -0.40995365f, -0.17065342f, -0.17232227f, 0.59666800f, 0.47555870f, 
    -0.03074153f, 0.23531422f, 0.27533039f, 0.12838534f, 0.13186751f, -0.41426137f, 0.51306355f, 0.22323772f, 
    0.44765833f, 0.14269072f, 0.01413006f, -0.13845743f, -0.25898346f, -0.22005601f, -0.30425251f, 0.07093534f, 
    -0.08741266f, -0.08160195f, -0.03137523f, 0.09705327f, 0.29118273f, 0.03575057f, 0.11754580f, -0.47349787f, 
    -0.46391010f, 0.22640002f, 0.66135210f, -0.03135383f, 0.13251884f, -0.19211936f, -0.38541684f, -0.24756834f, 
    -0.24841312f, 0.25880694f, 0.07928012f, 0.10578914f, 0.08198673f, -0.11633750f, 0.02066671f, -0.21415345f, 
    -0.40626141f, 0.03668438f, 0.19326983f, -0.13413462f, 0.22560246f, 0.12278929f, 0.25209832f, 0.25898448f, 
    0.01853745f, 0.23661207f, -0.33785149f, -0.26506561f, -0.41499677f, 0.10239632f, 0.47688729f, -0.29575327f, 
    0.35848367f, 0.47166863f, -0.21894045f, 0.18761376f, 0.12013391f, 0.07644150f, 0.14007220f, -0.02719570f, 
    -0.30355498f, 0.09369326f, 0.16294289f, 0.22886439f, 0.06430016f, -0.21468435f, 0.11381632f, -0.18490972f, 
    0.20010455f, -0.06610072f, -0.30960810f, -0.47307238f, -0.40837312f, 0.19428679f, -0.20049596f, -0.68930417f, 
    -0.09539181f, 0.29473227f, -0.19434394f, -0.48361892f, -0.37938443f, 0.30086809f, -0.28319791f, -0.42160508f, 
    -0.11971436f, 0.05455848f, 0.09828408f, 0.17847431f, -0.30812556f, -0.23254462f, 0.17569354f, 0.10118388f, 
    -0.10057504f, -0.05845845f, -0.62192285f, -0.32992247f, -0.47065353f, -0.33387831f, -0.41455579f, 0.10978667f, 
    0.56763947f, 0.34496814f, 0.42270678f, 0.21155104f, 0.14672618f, -0.29493067f, 0.06330810f, -0.06190826f, 
    0.11198833f, 0.22192393f, -0.23777647f, -0.04621672f, 0.03685204f, -0.14826086f, -0.07993723f, -0.22388500f, 
    0.21326360f, -0.03317079f, 0.24620615f, 0.47947729f, 0.43930691f, 0.59952492f, 0.66014034f, 0.31447393f, 
    0.08444332f, 0.07791006f, -0.35571477f, -0.55061996f, -0.21573463f, 0.19480895f, 0.16686352f, -0.04942029f, 
    0.16423146f, 0.11264349f, -0.01083978f, -0.01481226f, 0.12931836f, -0.13567263f, 0.03992094f, 0.02403907f, 
    0.15008754f, 0.08306006f, 0.18681425f, 0.19645090f, -0.31188270f, 0.64831424f, 0.01157658f, 0.08251151f, 
    0.18449192f, -0.68817192f, 0.20364121f, 0.23318884f, -0.15798488f, -0.54395235f, -0.26196265f, -0.32146928f, 
    0.09863542f, -0.00593121f, 0.27581587f, -0.16614774f, 0.20418558f, 0.19096693f, 0.29775128f, 0.34053496f, 
    -0.22672881f, -0.30128133f, -0.18224393f, -0.26937565f, -0.14352864f, -0.19259171f, 0.17973790f, 0.60847563f, 
    0.52338254f, 0.39226785f, 0.23954225f, 0.50632066f, 0.30993509f, 0.26691434f, 0.33154070f, -0.32437292f, 
    0.07067268f, 0.07203159f, 0.08258314f, -0.15673767f, -0.27059570f, 0.01052957f, 0.01077691f, -0.19402592f, 
    -0.19151606f, 0.02077406f, -0.05047331f, 0.08669759f, 0.20292726f, -0.01218426f, -0.51375794f, -0.39253509f, 
    -0.43160015f, 0.03820951f, -0.02541296f, 0.18002863f, 0.67831302f, 0.27066419f, 0.28105032f, 0.22810453f, 
    -0.12714499f, -0.21419849f, -0.03953417f, -0.29093575f, -0.34114063f, -0.08293909f, -0.00743346f, 0.23102859f, 
    0.25532243f, -0.41094100f, -0.04391449f, 0.16042617f, -0.15722677f, 0.01206405f, 0.17767216f, -0.60473877f, 
    -0.00680243f, -0.36929345f, 0.46788761f, 0.19834150f, -0.07455812f, -0.09039851f, -0.14816689f, 0.30200374f, 
    -0.01982736f, 0.35961702f, -0.11041658f, -0.12912644f, 0.25481182f, -0.07420201f, 0.13895908f, 0.24345930f, 
    0.41785136f, -0.33225948f, -0.18172634f, -0.32308275f, -0.11404497f, -0.10617846f, 0.21276949f, -0.17402011f, 
    -0.21927899f, 0.58067006f, 0.73101395f, 0.38877448f, -0.43188784f, -0.27617154f, 0.22387457f, -0.33124274f, 
    -0.54397017f, -0.01868205f, 0.20273641f, 0.37082529f, 0.36238927f, -0.04135579f, 0.06130244f, -0.01199821f, 
    -0.36066681f, 0.18410264f, 0.27169633f, 0.04811947f, -0.05792911f, 0.05841591f, -0.11378869f, 0.01887813f, 
    0.20305640f, -0.22001727f, 0.16931167f, -0.43500009f, -0.59987259f, -0.42646974f, 0.62926805f, -0.15838458f, 
    -0.52821034f, 0.00843491f, -0.00135528f, -0.33534041f, 0.05763004f, 0.23429389f, -0.05924675f, -0.16765866f, 
    0.20062654f, 0.26663736f, 0.18597463f, -0.02877457f, 0.06586175f, -0.01371413f, -0.21297154f, -0.07427194f, 
    0.09694920f, 0.22360092f, 0.69589508f, 0.07753823f, 0.33809006f, 0.65137064f, 0.47260538f, -0.31668448f, 
    -0.29488152f, -0.00569068f, 0.10160632f, -0.06205737f, 0.08679289f, -0.22361003f, -0.21794495f, -0.13506961f, 
    0.09791338f, 0.02967252f, -0.08575780f, 0.00500980f, -0.21549918f, 0.12629493f, 0.20171642f, -0.14642341f, 
    0.11502996f, 0.09676527f, 0.31158549f, 0.48463821f, 0.64701754f, 0.21300626f, -0.23981875f, -0.45621517f, 
    -0.34314704f, 0.54940587f, 0.05172218f, -0.46473491f, 0.48464614f, 0.14164820f, 0.10579345f, -0.21783039f, 
    0.10697460f, -0.02773432f, -0.11527546f, -0.20873247f, 0.28394955f, 0.09978640f, -0.14417602f, 0.01427734f, 
    -0.06151680f, -0.00386596f, -0.00726986f, 0.17200442f, -0.48078865f, -0.45802161f, -0.14439841f, 0.47402066f, 
    0.09021037f, 0.19407016f, 0.24693526f, 0.02943393f, -0.03174992f, -0.41518483f, -0.08788306f, 0.20956109f, 
    -0.05075264f, -0.09649602f, -0.33603153f, -0.37396321f, 0.16352254f, -0.28857568f, 0.34410030f, -0.27932778f, 
    -0.20571989f, -0.21053021f, -0.17108017f, 0.08447807f, -0.10380118f, 0.88967603f, 0.12888093f, -0.48963746f, 
    -0.34776101f, -0.32646185f, -0.25609174f, 0.00536310f, 0.23382351f, 0.03585858f, -0.07423393f, -0.21041073f, 
    0.08417447f, 0.47741205f, -0.07876401f, -0.34922490f, 0.09459645f, -0.21993420f, 0.11104610f, 0.18586136f, 
    0.26342541f, 0.34180504f, -0.04276672f, 0.01071359f, -0.25715229f, 0.09770738f, -0.20898765f, -0.15798089f, 
    -0.12224915f, -0.59462196f, -0.03370699f, -0.32367393f, 0.07217111f, -0.36235586f, -0.67015529f, -0.44265187f, 
    -0.30674252f, 0.20147014f, -0.04551271f, 0.03997621f, -0.59384060f, -0.06695045f, -0.20516166f, 0.06952159f, 
    0.12458289f, 0.22540101f, 0.17921734f, -0.20805559f, -0.32099935f, -0.03570483f, 0.15801385f, 0.23589920f, 
    -0.19266500f, -0.45270208f, -0.01012197f, 0.11285829f, -0.39653572f, -0.69254786f, -0.26634574f, -0.07819825f, 
    -0.31943816f, -0.42764828f, -0.22085716f, 0.01889744f, 0.30078754f, -0.33569062f, -0.20940247f, 0.24832922f, 
    0.13383590f, 0.11212379f, 0.24913740f, -0.21402554f, -0.08031783f, -0.27237421f, 0.02289132f, 0.08027381f, 
    0.50096244f, 0.26655784f, -0.14281540f, -0.25309879f, 0.38792571f, -0.34009090f, -0.86145359f, -0.09967952f, 
    -0.29564673f, 0.33060518f, 0.09385920f, 0.35472235f, 0.05827947f, 0.00905958f, -0.05720665f, -0.12044711f, 
    -0.14215013f, -0.38199481f, 0.16056481f, 0.13366565f, 0.29789087f, 0.11883230f, 0.15948333f, 0.08712517f, 
    -0.22499858f, -0.66783875f, -0.63426238f, -0.20239164f, 0.24885534f, 0.41136345f, 0.40584105f, 0.77512157f, 
    0.20336422f, -0.28929034f, -0.11342618f, 0.09606138f, 0.14655507f, -0.22263603f, 0.38453692f, 0.43903482f, 
    0.18284714f, -0.11057769f, -0.16253293f, -0.15054983f, 0.15754491f, 0.05736522f, 0.14821447f, 0.13776131f, 
    -0.17195289f, -0.02963826f, 0.05867153f, -0.56557190f, -0.33557701f, -0.34621352f, 0.43675184f, 0.38659075f, 
    0.56857991f, -0.51369256f, 0.12771940f, 0.15122713f, 0.06884612f, -0.20339875f, -0.03525252f, -0.12997730f, 
    0.16385733f, 0.18054496f, 0.28939351f, 0.00184660f, 0.31929776f, 0.05059132f, 0.16084197f, -0.16243793f, 
    0.32981431f, 0.34731600f, -0.11392070f, 0.19859371f, 0.66352260f, 0.68320101f, -0.11453149f, 0.32714325f, 
    -0.24675022f, -0.08384898f, -0.36891004f, 0.12587295f, -0.18518296f, 0.14561801f, -0.24184497f, -0.04033040f, 
    -0.08908015f, 0.51736438f, 0.28378439f, 0.00158399f, 0.09522466f, -0.12531373f, -0.23916301f, 0.31075895f, 
    0.20155607f, -0.06235239f, 0.13053879f, -0.04301233f, -0.23246197f, 0.39404824f, 0.32239407f, 0.69059986f, 
    -0.22040732f, 0.25108352f, -0.38997540f, 0.33864865f, -0.23432945f, 0.35030076f, -0.42930853f, -0.23652056f, 
    0.12978894f, 0.25124437f, -0.07457723f, -0.04419067f, 0.29351115f, 0.02873961f, -0.06623439f, -0.19986469f, 
    0.04999492f, -0.05870331f, -0.31810814f, -0.00228215f, -0.26715687f, 0.65651137f, -0.47123948f, -0.51477826f, 
    -0.25804478f, 0.48419425f, 0.43717873f, 0.24008405f, 0.21032581f, 0.57474738f, 0.18603483f, -0.09636676f, 
    -0.14790972f, -0.16789477f, -0.16492595f, -0.46423632f, -0.10302483f, -0.03208904f, -0.10510717f, -0.17518626f, 
    -0.00306798f, -0.00209728f, -0.06607676f, -0.05916605f, 0.05532843f, -0.04669694f, 0.85756028f, -0.27583849f, 
    -0.52233094f, 0.80028623f, -0.19035015f, -0.24043265f, 0.29122332f, -0.02500194f, 0.33570167f, 0.26392546f, 
    -0.30678645f, 0.00922484f, 0.05504012f, 0.17611182f, -0.08433677f, 0.00088353f, 0.18569270f, -0.09210636f, 
    -0.25531930f, 0.11058569f, 0.00922178f, -0.09016389f, 0.00403706f, 0.10109847f, 0.04635312f, -0.34844851f, 
    0.31212699f, -0.38255811f, -0.54598475f, 0.42467749f, 0.08721014f, -0.63907689f, -0.17649516f, -0.21041296f, 
    0.23473281f, -0.08873089f, 0.23118246f, 0.15106064f, 0.00335234f, 0.20617245f, 0.15093735f, 0.00714610f, 
    -0.30189312f, -0.16134375f, 0.01354010f, 0.03327094f, 0.17633730f, 0.27912465f, 0.00332809f, 0.06916258f, 
    0.21294171f, -0.28801465f, 0.52039176f, 0.48023105f, -0.29336756f, -0.06397151f, -0.42151549f, 0.67323846f, 
    0.39400190f, -0.36597660f, 0.08895092f, -0.24118495f, -0.28290957f, 0.11358839f, 0.07917428f, 0.08075731f, 
    0.10228529f, 0.10819201f, -0.12360730f, 0.00004111f, -0.13289201f, -0.05079059f, -0.05745629f, 0.02734278f, 
    -0.32673901f, -0.74265206f, 0.66584951f, 0.58032870f, 0.36278889f, 0.13515525f, 0.25347602f, 0.47200796f, 
    -0.05000642f, 0.07060737f, -0.03536781f, 0.20902054f, -0.13179420f, 0.19596903f, -0.15498205f, 0.03584396f, 
    -0.13574813f, -0.03046313f, 0.04243349f, -0.12375937f, -0.13478352f, -0.19506218f, -0.09643963f, -0.00335047f, 
    0.00893808f, -0.16306603f, 0.45505184f, -0.08231620f, 0.43746117f, 0.23406638f, 0.06000920f, 0.48550522f, 
    0.34063455f, 0.25798905f, 0.05449308f, 0.25204116f, -0.04112609f, -0.09866482f, -0.04588550f, 0.20436028f, 
    0.16948879f, 0.11959057f, -0.00982452f, 0.02531894f, 0.03079139f, 0.06273853f, 0.29615000f, 0.02454885f, 
    -0.25378197f, -0.24632838f, 0.32895043f, -0.29312968f, -0.15558906f, -0.24000862f, -0.27924293f, -0.37815386f, 
    0.07292560f, 0.32430053f, 0.50833374f, -0.20961393f, 0.28343794f, 0.31215736f, 0.14731514f, -0.05431160f, 
    -0.29176807f, 0.06040996f, -0.16259982f, 0.20570903f, 0.01569428f, 0.19048025f, 0.18095872f, -0.02729402f, 
    0.04376120f, 0.08787213f, -0.02019249f, -0.34260398f, -0.49027011f, 0.01637296f, 0.28793636f, 0.26727366f, 
    0.33539450f, -0.71777183f, -0.03212407f, 0.40270224f, -0.22432506f, -0.42540279f, 0.31876504f, 0.11881917f, 
    -0.05524525f, 0.20481728f, 0.24960159f, 0.07113165f, 0.25687772f, -0.11434257f, 0.15134306f, -0.17961422f, 
    0.01047694f, -0.01702736f, -0.14532043f, -0.43319839f, -0.08174741f, 0.19386820f, 0.21307021f, 0.11851973f, 
    0.15329894f, 0.68217540f, -0.25547513f, -0.54047406f, -0.46673316f, -0.66481251f, 0.02887371f, 0.29113427f, 
    0.29052585f, 0.13453172f, -0.03203519f, 0.01290517f, 0.37704951f, 0.16214341f, -0.09308381f, 0.13845290f, 
    0.04515990f, 0.17660533f, -0.01287020f, -0.12327698f, -0.01697034f, 0.20748134f, -0.17098023f, -0.47791353f, 
    -0.30954167f, 0.43844840f, 0.26964182f, -0.58399034f, 0.51716870f, 0.36348116f, -0.28172877f, 0.05617103f, 
    0.37839830f, -0.11719513f, 0.07313011f, -0.20856202f, 0.19596031f, -0.38551059f, 0.14204068f, 0.27678308f, 
    -0.11094922f, 0.03429095f, 0.00550522f, -0.21332529f, -0.04932227f, -0.03886040f, -0.01934168f, 0.55514085f, 
    0.53986889f, -0.59801531f, -0.68983442f, 0.04319023f, -0.10637825f, 0.40960255f, 0.51997167f, 0.23788638f, 
    0.05160967f, 0.04274981f, -0.27684513f, -0.31438628f, -0.28993893f, 0.21626739f, 0.17567037f, 0.00297176f, 
    -0.26215836f, 0.00583610f, 0.11328297f, -0.17544766f, 0.01292343f, -0.28408736f, -0.38875234f, -0.31216463f, 
    -0.71497482f, 0.65812892f, -0.43072590f, -0.17434789f, -0.26226419f, 0.52726960f, -0.05594237f, -0.52127647f, 
    0.34768310f, -0.34415221f, -0.19744702f, 0.04612355f, -0.18007191f, -0.00158735f, 0.01723808f, -0.05728250f, 
    -0.16248755f, -0.20796736f, -0.26935458f, -0.17554191f, -0.12605545f, -0.05689914f, 0.24429451f, 0.01086021f, 
    0.19138774f, 0.62578237f, 0.00051456f, 0.38842595f, 0.01322841f, 0.17071053f, 0.42345333f, 0.32873359f, 
    0.37627569f, 0.30106121f, 0.22650689f, -0.50491381f, 0.18166400f, -0.19292827f, 0.11172292f, 0.16838430f, 
    0.12417400f, -0.01022360f, 0.01046279f, 0.04622436f, 0.27764258f, -0.15397635f, 0.07265884f, -0.07331420f, 
    0.07667024f, 0.08381236f, 0.44476500f, -0.03921186f, 0.36106890f, 0.76116031f, 0.64082229f, 0.38929430f, 
    -0.10104448f, -0.36289498f, 0.02903626f, -0.03920439f, -0.10310834f, 0.30673808f, -0.18946399f, 0.04918098f, 
    -0.10892256f, 0.04548003f, 0.23314868f, 0.13935974f, 0.32414308f, 0.17157540f, 0.24917386f, 0.36397567f, 
    -0.30549052f, -0.36585572f, -0.17316392f, 0.69284612f, 0.47301507f, -0.56183648f, -0.18202075f, -0.60067654f, 
    0.24719092f, 0.20342949f, -0.10996848f, -0.15617689f, 0.27886912f, 0.21318670f, 0.10497411f, -0.09226755f, 
    0.03410413f, 0.21504639f, 0.06677449f, -0.30006492f, 0.05245812f, -0.12405918f, 0.01876380f, 0.27236888f, 
    0.11299358f, -0.23373841f, 0.18432967f, 0.22260118f, -0.46267948f, -0.53180671f, -0.10611688f, -0.43282625f, 
    -0.27702817f, -0.01098921f, -0.50353968f, 0.03095177f, -0.28301150f, 0.25354964f, 0.26886794f, -0.11533904f, 
    0.16049199f, 0.04557053f, 0.03794666f, 0.03352994f, 0.34408712f, 0.07861582f, -0.02664368f, 0.14890030f, 
    -0.09889820f, -0.19535992f, -0.03104918f, 0.01055531f, 0.22483768f, -0.29307866f, -0.68195915f, -0.66916168f, 
    0.03865729f, -0.25890765f, -0.30330303f, 0.31953013f, 0.15694165f, 0.29127023f, 0.27626297f, -0.13598330f, 
    0.14863974f, 0.22412181f, 0.18951631f, 0.18861055f, -0.19542179f, -0.20838337f, -0.01367460f, 0.09859163f, 
    -0.12463349f, 0.24438180f, 0.02628320f, -0.10871299f, 0.22666252f, -0.04878289f, 0.04844889f, 0.00711965f, 
    -0.32890329f, -0.37374645f, 0.30337098f, 0.21267892f, 0.23475429f, -0.33420020f, -0.14924638f, -0.38287726f, 
    0.29534039f, 0.35718656f, -0.23472838f, 0.18453030f, -0.11253417f, 0.09158847f, -0.16003382f, 0.29036137f, 
    0.08312712f, 0.26802260f, -0.20031205f, 0.23781809f, -0.24549013f, 0.32169545f, 0.48828766f, -0.59538811f, 
    -0.08657088f, -0.35640538f, -0.02048274f, 0.37264821f, -0.34157145f, 0.56900424f, 0.57175666f, -0.49854568f, 
    0.01046269f, -0.00106025f, -0.00336823f, 0.06515642f, 0.06103671f, 0.13475242f, -0.00631079f, 0.07932322f, 
    -0.34871712f, 0.19793226f, 0.31544358f, 0.21780828f, -0.11416202f, -0.01535311f, 0.45289743f, -0.30101067f, 
    -0.59093410f, 0.00299326f, 0.30216876f, -0.29831800f, 0.00627244f, 0.12415305f, -0.30146855f, 0.08888436f, 
    0.49559829f, -0.45556140f, 0.28591964f, -0.25219861f, -0.35216466f, 0.08987223f, -0.21263093f, 0.32515517f, 
    0.22752751f, 0.08439615f, 0.04605179f, 0.14203362f, -0.01819384f, 0.07737081f, 0.07548222f, -0.08103908f, 
    -0.06336201f, 0.75936669f, -0.13740140f, -0.29998419f, -0.32372048f, -0.35245007f, -0.21663238f, 0.46866450f, 
    -0.11623565f, 0.18815459f, 0.18596365f, 0.10022003f, 0.50865734f, -0.19985530f, -0.05456181f, 0.18499908f, 
    0.09985354f, -0.28194866f, -0.25597405f, 0.16166876f, 0.01393915f, -0.30881938f, 0.04998642f, 0.03558798f, 
    0.07173301f, -0.24871753f, 0.59966850f, 0.17413837f, 0.10381541f, -0.53828603f, 0.40656185f, 0.28632405f, 
    0.21715304f, -0.07236949f, 0.23198454f, 0.18717459f, -0.18542051f, 0.25362113f, -0.09321861f, -0.12421015f, 
    0.22628653f, -0.22882254f, 0.00081477f, 0.11415005f, 0.09217621f, -0.32018042f, -0.18618973f, 0.00993730f, 
    -0.13740923f, -0.27114335f, -0.17907716f, -0.56922549f, -0.77067417f, 0.24742225f, -0.23801190f, -0.16214368f, 
    -0.00968839f, -0.06884673f, 0.37112260f, -0.20578031f, 0.36282811f, -0.02182733f, -0.10009220f, 0.09020586f, 
    -0.04060102f, -0.17195773f, -0.00348266f, 0.28185931f, -0.23440006f, 0.09471180f, -0.28632340f, 0.01037973f, 
    -0.12964921f, 0.24234688f, 0.10150483f, 0.15644565f, 0.61430001f, 0.27633563f, 0.15391669f, 0.59427243f, 
    0.50135285f, 0.22838528f, 0.23566009f, 0.04786515f, -0.01127032f, -0.23976971f, 0.03518202f, 0.01989204f, 
    -0.00174964f, -0.05283446f, 0.06966051f, -0.05419505f, 0.09911320f, 0.42833057f, 0.07448111f, 0.01295826f, 
    -0.23448156f, 0.01950116f, 0.08379862f, 0.07205939f, -0.02493722f, -0.39953172f, 0.47578976f, 0.65780294f, 
    -0.57045323f, -0.18030807f, -0.28360614f, 0.39448890f, -0.25748354f, -0.58870178f, -0.40583581f, 0.12441579f, 
    0.38748822f, -0.13243341f, 0.40224138f, 0.02485752f, -0.13584854f, -0.22126476f, -0.25025088f, -0.28074294f, 
    0.11472639f, -0.13763170f, 0.25323394f, 0.28054151f, 0.13637359f, -0.04906412f, -0.07092140f, -0.12321567f, 
    -0.33281729f, 0.13011591f, -0.30369669f, 0.10858619f, -0.67118371f, -0.07495790f, -0.11516376f, -0.47462949f, 
    -0.47842628f, 0.23147632f, 0.09709012f, -0.21795556f, -0.17203470f, 0.14389728f, -0.21155451f, -0.20910852f, 
    0.13246292f, -0.10370255f, 0.04776914f, 0.01160206f, -0.17311879f, -0.19553055f, -0.17116474f, 0.47664624f, 
    0.23800972f, 0.35666353f, 0.57711637f, 0.09856192f, 0.39468375f, 0.36782366f, -0.38044158f, -0.31495893f, 
    -0.15456279f, -0.00252658f, 0.26329076f, -0.02026289f, -0.04238786f, 0.20783344f, -0.14266293f, 0.23641697f, 
    -0.21747240f, 0.17472470f, 0.16249882f, 0.18572840f, -0.10365847f, 0.14973433f, 0.09794042f, 0.20037337f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00390350f, 0.08268458f, 0.26235890f, -0.04062835f, -0.00724109f, 0.13926595f, 0.14556181f, 0.21737744f, 
    -0.08116630f, 0.23491353f, -0.06825350f, 0.08472256f, -0.01037448f, 0.17972688f, 0.19640335f, 0.21468598f, 
    0.19465083f, 0.12520355f, 0.14682983f, -0.06594443f, 0.04441034f, 0.18797934f, 0.13784531f, 0.11862896f, 
    0.00920788f, 0.15998881f, -0.03897211f, 0.16789588f, 0.13346322f, -0.01528208f, 0.04042716f, 0.08640673f, 
    0.15924978f, 0.00966815f, 0.02893510f, -0.03273675f, -0.04674840f, -0.03674331f, 0.18142448f, 0.11892987f, 
    -0.08981604f, 0.23131250f, 0.20297496f, 0.19214866f, 0.20587452f, -0.03378960f, 0.17807557f, 0.20731115f, 
    -0.06132289f, 0.16359751f, -0.03837225f, -0.01820380f, -0.02260783f, 0.03803698f, 0.07750926f, 0.06411666f, 
    0.14826682f, 0.16347758f, 0.19295649f, 0.01111042f, 0.21312860f, 0.22042249f, 0.19460109f, 0.07610898f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04602272f, 0.12068833f, -0.07635523f, -0.12591867f, 0.12756449f, -0.10099595f, 0.04697691f, 0.12446252f, 
    0.05344436f, -0.03608548f, 0.00003766f, -0.10058759f, -0.35767129f, -0.01137770f, 0.11354423f, 0.26276022f, 
    0.00139801f, 0.01291447f, -0.03131904f, 0.03023442f, -0.00322904f, -0.02292942f, 0.09445615f, -0.11623216f, 
    0.03856099f, -0.09369595f, -0.05229695f, -0.17948075f, 0.18487224f, 0.17921598f, -0.03967934f, 0.04431774f, 
    0.13447537f, -0.04585377f, 0.01287533f, 0.03260013f, 0.10049048f, -0.07300511f, -0.12397233f, 0.08250153f, 
    -0.04170708f, -0.06209287f, -0.10214710f, 0.18661582f, 0.05592017f, -0.19993107f, 0.09361589f, -0.00833073f, 
    -0.03590961f, 0.02314748f, -0.12712207f, -0.08282840f, 0.14463124f, 0.11388688f, -0.05794210f, -0.07232429f, 
    0.08842584f, 0.00041972f, -0.02219319f, -0.03928266f, 0.06354390f, -0.01052413f, -0.10798350f, -0.09254187f, 
    0.02917537f, 0.05750129f, -0.02228977f, 0.06351664f, 0.03804216f, 0.05883316f, 0.18560120f, -0.01967008f, 
    -0.11428738f, 0.17020726f, 0.03426782f, 0.09577948f, 0.12133694f, 0.10192040f, 0.09491793f, -0.09581911f, 
    0.06588062f, 0.01645933f, 0.09815636f, -0.05637929f, 0.00459536f, 0.00132801f, 0.06546368f, -0.11047255f, 
    0.08968372f, 0.14504345f, 0.03330454f, 0.00431183f, 0.07934037f, -0.05690902f, -0.01841285f, -0.09570434f, 
    0.06129679f, 0.09671497f, 0.12327990f, 0.13721819f, -0.08038779f, -0.03634849f, 0.11571009f, -0.08074454f, 
    -0.08387350f, -0.04681210f, -0.00603644f, 0.12349442f, -0.11854796f, 0.04503491f, 0.05734200f, 0.04745944f, 
    -0.02695736f, 0.09664475f, 0.04053087f, 0.00213190f, 0.03124253f, -0.08197967f, -0.10020578f, -0.06995866f, 
    0.21373056f, -0.05884455f, 0.14894448f, 0.26613027f, -0.05442792f, -0.11228696f, -0.00943891f, 0.00049578f, 
    -0.02170322f, -0.03755768f, 0.00788732f, 0.06746443f, 0.14733946f, -0.05579713f, 0.01412511f, -0.22823340f, 
    -0.12197746f, 0.05799304f, 0.07561585f, 0.00079972f, -0.00440969f, -0.06121071f, -0.07643418f, -0.09244283f, 
    -0.09667921f, -0.07739037f, 0.05343647f, -0.03070375f, 0.01383120f, 0.08402547f, 0.11583906f, -0.08295716f, 
    -0.06900287f, -0.12877157f, -0.03179553f, -0.03411448f, 0.07994622f, -0.04039808f, -0.10744105f, -0.09477441f, 
    0.15679654f, 0.10163585f, -0.11532618f, -0.16848446f, -0.05841305f, -0.06229009f, -0.04968866f, -0.03765929f, 
    0.00004696f, 0.06757797f, 0.10769218f, 0.11309355f, -0.05137980f, -0.09938346f, 0.04563876f, 0.06295437f, 
    -0.03559161f, -0.13488080f, -0.08280006f, -0.05970024f, -0.03799380f, -0.13445826f, -0.06262871f, 0.01053256f, 
    -0.11083876f, 0.09471825f, 0.08958373f, -0.06114563f, -0.04424831f, 0.13794652f, -0.03113410f, 0.08849380f, 
    0.05370840f, -0.12395417f, -0.06485316f, -0.15032311f, -0.07764829f, -0.07006241f, 0.11950056f, 0.02656050f, 
    0.00841670f, 0.07863197f, 0.10221197f, 0.09970680f, 0.03948120f, -0.08122502f, 0.09661569f, -0.11658269f, 
    0.14958610f, 0.06268958f, 0.03230943f, 0.04485552f, -0.06158547f, -0.12594061f, 0.06254303f, -0.09526225f, 
    -0.06484824f, -0.04113175f, -0.17342810f, -0.13454640f, 0.18490016f, 0.11659502f, 0.06881709f, -0.05560647f, 
    0.04965747f, 0.05865875f, -0.04964586f, 0.06512915f, 0.22023414f, 0.06149253f, 0.15763675f, 0.13916145f, 
    -0.05952136f, 0.04472911f, 0.07650565f, -0.00461716f, -0.12519339f, 0.07323135f, 0.03182264f, 0.10048816f, 
    0.17206396f, -0.07638741f, 0.00206331f, -0.03459025f, -0.02023580f, 0.05534285f, -0.06522419f, -0.00396840f, 
    -0.01925170f, 0.11598106f, 0.10895300f, -0.02510846f, 0.03469166f, 0.10437213f, 0.23232135f, 0.10907769f, 
    -0.02462275f, 0.06439163f, 0.01126971f, -0.02039195f, -0.07871921f, 0.00854254f, -0.00570580f, -0.05351329f, 
    0.16994971f, 0.03570203f, -0.04718061f, -0.10941041f, 0.12448499f, 0.05104512f, -0.05699035f, 0.02464529f, 
    0.05403251f, -0.10576399f, -0.00437349f, -0.01327315f, -0.20379318f, -0.09184311f, -0.00888644f, -0.04048857f, 
    0.06892526f, 0.05674732f, 0.01895542f, -0.03953834f, -0.04248029f, 0.00279258f, 0.05152217f, 0.04164159f, 
    0.23779403f, 0.02963349f, -0.00314767f, 0.05329015f, -0.13093525f, -0.03785625f, 0.02074186f, -0.06372067f, 
    -0.02833344f, -0.07017886f, 0.21263747f, 0.06698541f, -0.19788912f, 0.07060393f, 0.07280695f, -0.12390258f, 
    0.07551312f, 0.03299519f, 0.00733428f, -0.02977562f, 0.15417776f, -0.07779213f, 0.08202788f, -0.03941343f, 
    0.00834700f, 0.05865481f, -0.02826866f, 0.04780395f, -0.10932369f, 0.02463202f, 0.01334675f, 0.00999541f, 
    -0.02907153f, -0.07510113f, 0.05248046f, 0.12183133f, 0.31694582f, 0.14223026f, -0.11826853f, -0.03082351f, 
    -0.05836605f, -0.07569854f, 0.05649528f, 0.11169057f, -0.05443114f, 0.04949338f, -0.00295037f, 0.04959448f, 
    -0.08372458f, 0.00913617f, -0.13748717f, 0.06797329f, 0.08626904f, 0.18892513f, -0.01690753f, -0.14907105f, 
    -0.10624565f, -0.05790921f, 0.06859627f, -0.02919501f, 0.12455984f, -0.06920949f, 0.13931134f, -0.01463061f, 
    0.10619360f, -0.09416115f, 0.04231425f, 0.11881037f, 0.05955012f, -0.06702303f, 0.00509847f, -0.06559593f, 
    0.16519174f, -0.16191828f, -0.08970007f, 0.16509072f, 0.04730092f, -0.00935491f, 0.11014651f, 0.01866771f, 
    -0.03954479f, 0.12673448f, 0.11198549f, -0.07140578f, 0.01102443f, -0.17619273f, -0.03160205f, -0.16457570f, 
    -0.00508379f, 0.02324918f, -0.00657825f, -0.07520676f, -0.03077621f, 0.05725711f, 0.11359659f, 0.12260161f, 
    -0.02898017f, 0.11444085f, 0.26092273f, -0.11219229f, -0.05769159f, -0.15704791f, 0.00995243f, 0.06454971f, 
    -0.07996343f, 0.00599556f, 0.00326761f, 0.06784387f, -0.12054916f, -0.11713142f, -0.04043687f, -0.08725808f, 
    0.06887961f, 0.11871015f, 0.01100906f, -0.00118067f, -0.05374954f, 0.04371541f, -0.06344953f, 0.03676252f, 
    -0.07281248f, 0.05333165f, 0.00122574f, -0.25341445f, 0.02287887f, 0.11163257f, -0.03781623f, 0.01420096f, 
    0.20626369f, 0.02836337f, -0.04913192f, 0.01590859f, -0.01241419f, 0.04334208f, 0.11602953f, 0.20017208f, 
    -0.01332427f, -0.10020462f, 0.04638475f, 0.06330834f, 0.04687985f, -0.04259044f, -0.00904366f, 0.06344431f, 
    0.14513020f, 0.12779303f, 0.25596726f, -0.02980965f, 0.02811576f, -0.07519012f, -0.03958198f, -0.06043132f, 
    -0.01971791f, -0.02091170f, 0.05162343f, -0.13282183f, 0.22911765f, -0.04396444f, 0.07243937f, -0.12618853f, 
    0.01583232f, -0.00839105f, -0.18423173f, -0.07722446f, 0.04669297f, 0.05145342f, -0.12876396f, 0.03350746f, 
    0.21125801f, -0.05915774f, -0.02359052f, -0.13770625f, -0.05455556f, 0.04354012f, -0.07199854f, -0.00734952f, 
    0.01730550f, -0.03436702f, 0.04369693f, 0.05912040f, -0.29965776f, -0.06273574f, 0.28475121f, -0.07152358f, 
    -0.00621107f, 0.07237639f, 0.08661038f, -0.00772211f, 0.00832182f, 0.06786618f, 0.06346700f, 0.06912153f, 
    -0.00104565f, 0.21635319f, -0.04259650f, 0.14011706f, 0.06760918f, -0.10018253f, -0.07241365f, -0.07657280f, 
    0.01521006f, 0.02196214f, 0.13827677f, 0.02524296f, -0.02404574f, -0.08056484f, 0.22909258f, 0.12902775f, 
    -0.05875512f, 0.00533402f, 0.02499615f, -0.04864024f, 0.03494390f, -0.04633125f, 0.02228449f, -0.05861323f, 
    0.30969495f, 0.14645647f, 0.07799908f, 0.10866402f, 0.02768447f, 0.04627965f, -0.04599891f, 0.02343383f, 
    0.10594280f, 0.02443280f, 0.00265418f, 0.08994149f, -0.04005325f, -0.02737563f, -0.18601659f, -0.02392154f, 
    0.07824203f, -0.07955579f, 0.02114233f, 0.05798389f, 0.01227516f, -0.05001959f, -0.00759114f, 0.03709831f, 
    0.32545495f, -0.08090838f, -0.02096518f, -0.15676659f, 0.11275882f, -0.01816444f, -0.06399748f, -0.02529718f, 
    -0.01258497f, 0.03512358f, 0.02125595f, 0.08775499f, 0.01591838f, 0.13614690f, 0.08384069f, -0.20443001f, 
    -0.07168800f, 0.04336930f, -0.02456538f, -0.02117115f, -0.06889502f, 0.04429643f, 0.04201986f, 0.17621695f, 
    0.08727378f, 0.10734855f, 0.04314112f, -0.11779365f, 0.01321861f, 0.03770443f, -0.09858283f, 0.04643100f, 
    0.04526616f, 0.00202739f, 0.11088895f, -0.05625660f, 0.29739624f, 0.12459674f, 0.08017191f, -0.03989636f, 
    -0.01258936f, -0.03127589f, -0.16857401f, -0.10307156f, 0.00860418f, 0.06885649f, -0.16608690f, 0.02965950f, 
    -0.34284982f, -0.15278603f, 0.08704770f, 0.08539119f, -0.01160025f, -0.02275468f, -0.00413274f, 0.04800387f, 
    -0.04988110f, 0.15090041f, -0.08211968f, 0.02095044f, 0.30377358f, 0.06205124f, 0.23380297f, 0.04227909f, 
    -0.06685844f, 0.02079288f, 0.05621576f, -0.10565636f, -0.06247604f, 0.04808246f, -0.06117909f, 0.06550646f, 
    0.02062298f, 0.04148402f, 0.22950917f, -0.10966578f, -0.01149815f, 0.00039629f, -0.06407601f, 0.03018196f, 
    -0.03254720f, 0.06187881f, 0.11407008f, 0.03305347f, 0.26019648f, 0.21220075f, -0.03846018f, -0.07470705f, 
    -0.04145524f, 0.06178411f, 0.00541213f, 0.10427518f, -0.06860373f, -0.01854108f, 0.01685539f, 0.03426614f, 
    -0.18346515f, -0.02983456f, 0.00623047f, 0.10019471f, 0.08721146f, 0.06540608f, 0.06317379f, -0.02127794f, 
    0.04980677f, -0.02292911f, 0.06563171f, 0.08181913f, -0.25050479f, -0.17542708f, -0.04376319f, -0.07791673f, 
    0.05251959f, 0.01986061f, 0.18243127f, 0.00997600f, 0.04761136f, 0.09555763f, -0.03162780f, 0.03159578f, 
    0.01469359f, -0.03275579f, -0.04474549f, -0.06903048f, -0.05210549f, 0.06870365f, -0.00626115f, -0.05631352f, 
    -0.01174687f, 0.04613138f, 0.02153329f, 0.03241107f, -0.00850502f, -0.02211885f, 0.07093083f, -0.14338461f, 
    0.05823739f, 0.00116608f, 0.10452659f, -0.02813713f, -0.06735110f, 0.09581658f, -0.00555024f, 0.01149527f, 
    -0.17311196f, -0.15047348f, 0.03645978f, 0.06298927f, 0.08681557f, 0.10948756f, 0.12022205f, -0.01618852f, 
    -0.02411973f, 0.07198837f, -0.08421031f, 0.04731190f, 0.17283021f, -0.16684182f, -0.05247091f, 0.00713977f, 
    0.02466360f, -0.07372047f, 0.01955575f, -0.07948561f, -0.14668366f, -0.01321128f, -0.19961452f, 0.08402558f, 
    0.29534465f, 0.20681477f, 0.08541138f, 0.07786433f, 0.00011012f, -0.11819652f, -0.08487738f, 0.04721004f, 
    0.01161532f, -0.02701502f, -0.07871512f, -0.02683113f, -0.12681919f, -0.07288364f, -0.05748784f, 0.16505231f, 
    0.03243182f, 0.01592249f, 0.21179031f, -0.03851707f, -0.06357633f, -0.01224091f, 0.00264617f, 0.10162923f, 
    0.02206098f, 0.23504065f, 0.14160980f, 0.16558275f, 0.00226469f, -0.02111232f, 0.04108337f, -0.05089168f, 
    0.09325061f, 0.05460332f, 0.03477998f, 0.10051315f, -0.08079500f, -0.03373173f, -0.01449371f, 0.11594884f, 
    -0.00336786f, 0.00286962f, 0.06044893f, 0.05255827f, -0.09531949f, 0.05313740f, -0.04712809f, 0.01318964f, 
    -0.10630580f, 0.03420676f, 0.04077373f, 0.02477602f, 0.02343647f, -0.02881375f, 0.00137011f, -0.06732303f, 
    -0.07629503f, 0.06034634f, 0.04696820f, -0.00649980f, 0.00444016f, 0.01773751f, 0.17477098f, 0.03351232f, 
    -0.07590552f, 0.11607561f, 0.07995636f, -0.02207518f, -0.05723142f, 0.02779093f, -0.01065040f, 0.04370508f, 
    0.01571442f, -0.04178855f, 0.02314180f, -0.04299860f, 0.01444096f, 0.03124496f, 0.01155295f, -0.03456206f, 
    -0.01961151f, -0.00421965f, 0.00030208f, -0.01714224f, 0.01359707f, -0.01537833f, -0.02518810f, -0.03334687f, 
    -0.01896477f, 0.00217447f, 0.01930227f, 0.01599104f, 0.02434727f, -0.03596473f, 0.02857851f, -0.02124931f, 
    0.00139743f, -0.00489232f, -0.02395836f, 0.00004412f, -0.02312932f, -0.00087315f, -0.03704565f, -0.03366422f, 
    0.00206349f, -0.02382529f, -0.03092015f, -0.02104481f, 0.00093300f, -0.02672806f, -0.02738293f, 0.01345839f, 
    0.02633996f, 0.02414085f, -0.02800451f, -0.02498242f, 0.01934608f, 0.02397416f, 0.02443104f, 0.01649282f, 
    -0.02013549f, 0.00551935f, -0.03249945f, -0.03364775f, -0.01261823f, -0.01206458f, -0.01081996f, -0.02000633f, 
    0.02123667f, -0.01075844f, -0.01771560f, -0.00366525f, -0.00289443f, -0.02164392f, 0.01077115f, 0.02263437f, 
    -0.01635291f, 0.00388649f, -0.02523455f, 0.02485354f, -0.01814323f, 0.01431076f, -0.03222344f, -0.00087301f, 
    -0.00685664f, -0.00023304f, -0.01889185f, 0.02572934f, 0.03596640f, 0.00076313f, -0.01439863f, -0.03189918f, 
    0.00586079f, -0.02310970f, 0.00243280f, -0.00181608f, -0.03545691f, -0.00568745f, -0.03387628f, -0.03047286f, 
    -0.02238016f, -0.03414080f, -0.02429837f, -0.03832247f, -0.01815825f, -0.00323799f, -0.01709752f, 0.01447907f, 
    -0.02752715f, -0.00971256f, -0.02858325f, -0.00279809f, -0.03931270f, -0.01753234f, -0.00347079f, -0.02316955f, 
    0.00950356f, -0.00533422f, -0.00045151f, 0.00337556f, -0.02604565f, 0.00785425f, -0.02604963f, 0.01742841f, 
    -0.04254260f, -0.01333785f, -0.01998801f, -0.03986337f, 0.01405275f, -0.02681562f, -0.00855036f, -0.00306452f, 
    -0.01040796f, -0.03765323f, 0.02597425f, 0.00068919f, 0.01977631f, -0.03843972f, -0.01375557f, -0.01567816f, 
    0.02030949f, 0.01617330f, 0.02170101f, 0.02576846f, -0.02014655f, -0.02809878f, -0.03242347f, -0.00564256f, 
    0.00707023f, -0.03781244f, -0.03017696f, -0.00747134f, -0.00247531f, 0.00512363f, -0.02218996f, -0.03214126f, 
    0.00497047f, -0.01572931f, -0.01067916f, -0.00435711f, 0.02095157f, 0.01161086f, 0.01785362f, -0.01872543f, 
    0.01865289f, -0.04018289f, 0.01685543f, -0.00481780f, 0.01881147f, -0.01944101f, -0.02261291f, 0.01505962f, 
    -0.01196675f, -0.01386377f, -0.00750774f, 0.01223096f, -0.02338203f, -0.03739487f, -0.03921610f, 0.00388735f, 
    -0.04270594f, 0.01555553f, -0.02932874f, 0.02188513f, 0.02690357f, 0.01850860f, -0.02488501f, -0.02421308f, 
    -0.03648015f, -0.00401998f, 0.03706603f, -0.02036242f, -0.02572373f, -0.00409932f, 0.01930779f, 0.02875324f, 
    0.01498249f, -0.03682693f, -0.03819513f, -0.02423571f, -0.01662660f, -0.00653605f, -0.02197948f, -0.02882689f, 
    -0.02188530f, -0.01298828f, 0.01230117f, 0.02650733f, -0.00160229f, 0.00749559f, -0.03027703f, 0.01678842f, 
    -0.01128107f, 0.01985164f, -0.03534786f, 0.03049213f, -0.03845639f, -0.02145122f, -0.00636098f, 0.01839495f, 
    -0.02938725f, -0.03746473f, -0.01848890f, -0.01710859f, 0.02350198f, -0.02211869f, 0.02861675f, -0.02429461f, 
    -0.03398041f, -0.01292050f, 0.01212764f, -0.01628460f, 0.02968942f, -0.03882185f, 0.02433812f, 0.02840010f, 
    -0.01288405f, -0.01769942f, -0.01901253f, -0.01134301f, -0.00606092f, -0.00451165f, -0.03253675f, 0.00221416f, 
    -0.00019867f, 0.02488343f, 0.01636502f, 0.00365712f, 0.01089180f, -0.04316295f, -0.01697500f, -0.04163041f, 
    -0.00933692f, -0.03696389f, -0.03627224f, 0.02277266f, -0.01397107f, -0.01424442f, 0.01815634f, 0.00417991f, 
    -0.02211479f, -0.02930789f, -0.01733577f, -0.01122848f, -0.01567845f, -0.02536505f, 0.02939104f, -0.02642186f, 
    -0.00650655f, -0.01122917f, 0.02192663f, -0.02484728f, -0.00088614f, 0.01488294f, -0.01007317f, 0.00456415f, 
    -0.02330210f, 0.01829359f, -0.03351519f, -0.02146367f, 0.00265256f, 0.01766494f, -0.00080613f, -0.02872917f, 
    0.01786504f, 0.01275518f, 0.00049846f, 0.02941568f, 0.01695281f, -0.01860693f, 0.02493553f, -0.03849610f, 
    0.01401708f, 0.01950848f, -0.00021153f, -0.01343478f, -0.04226923f, 0.00562826f, -0.01586516f, -0.00763914f, 
    -0.01765388f, 0.01926860f, 0.01779039f, 0.02771390f, 0.00060454f, 0.02569394f, -0.03482611f, -0.01472825f, 
    0.00135505f, -0.02788576f, -0.00450165f, 0.02572510f, 0.00546200f, 0.02441463f, 0.00394337f, -0.02287574f, 
    0.00322295f, 0.01296314f, 0.00841859f, 0.02489704f, 0.02903045f, -0.03692133f, -0.02545077f, -0.03352341f, 
    -0.04370085f, -0.00979180f, -0.03089975f, 0.02354803f, 0.01855825f, -0.03126028f, 0.02849358f, 0.00532398f, 
    0.01594937f, -0.01401706f, 0.00880231f, 0.03303225f, 0.00822641f, -0.01203046f, -0.04022146f, -0.01092347f, 
    0.00443593f, 0.02355476f, 0.01050669f, -0.01728742f, -0.00850112f, -0.02206108f, -0.01784404f, 0.02729044f, 
    0.02125574f, 0.00144881f, -0.02720226f, 0.01537303f, 0.00755931f, 0.02449861f, 0.00671609f, -0.04293440f, 
    -0.02809602f, -0.03228915f, 0.02098442f, 0.01073057f, 0.02391457f, 0.00888064f, 0.01203656f, 0.02235939f, 
    0.01240437f, 0.01978675f, 0.01202046f, 0.00005769f, -0.00062523f, 0.02055616f, -0.01778143f, 0.03596048f, 
    -0.03306104f, -0.00744653f, -0.02311788f, 0.02461110f, -0.03734082f, 0.00716148f, 0.01275370f, 0.00911416f, 
    -0.01305099f, -0.00236568f, -0.00772713f, -0.01414870f, 0.02650063f, -0.01929237f, -0.02185570f, -0.02787955f, 
    -0.00697943f, -0.00374460f, 0.00443176f, -0.00055844f, 0.02167077f, 0.01281475f, 0.01476632f, -0.01664971f, 
    -0.01872221f, 0.02381571f, 0.00691853f, 0.01190691f, 0.00677233f, -0.03379032f, -0.03163364f, -0.00274405f, 
    -0.01361644f, 0.00493455f, -0.03481656f, 0.00111757f, -0.01252077f, 0.02502907f, -0.02731914f, -0.03687591f, 
    -0.03137206f, 0.01721632f, -0.02434468f, 0.01088116f, -0.03759117f, 0.03387478f, -0.01656369f, -0.03144547f, 
    -0.00113469f, -0.03020636f, 0.02171742f, 0.00285218f, -0.00851892f, 0.01424828f, -0.01703095f, 0.03216394f, 
    0.01542453f, -0.03668219f, 0.01171443f, -0.02386863f, -0.03324260f, 0.00748129f, -0.01307199f, -0.00929954f, 
    -0.01701673f, -0.03304874f, 0.00034763f, -0.04103573f, -0.01277404f, -0.01379084f, 0.02087420f, 0.02442332f, 
    0.01745082f, 0.02792577f, -0.00674577f, -0.02468754f, -0.00230243f, -0.00805733f, -0.02795501f, -0.03641503f, 
    -0.03943962f, -0.03419985f, -0.00424581f, -0.01284722f, -0.01682085f, -0.00076879f, -0.01370811f, 0.00831159f, 
    0.00657254f, 0.02075268f, -0.03017804f, -0.03994615f, 0.01799347f, 0.02193592f, 0.01654337f, 0.02641790f, 
    -0.02460441f, -0.02287117f, 0.00660625f, 0.00981902f, -0.01960862f, -0.03594340f, 0.01458518f, -0.02871689f, 
    -0.00751220f, 0.01868581f, 0.02193641f, 0.01317828f, -0.00319681f, 0.01264814f, 0.00875324f, 0.00974619f, 
    -0.02805699f, -0.01747314f, 0.00236965f, 0.01535263f, -0.01040329f, 0.01278090f, -0.03437235f, 0.00370344f, 
    -0.03440729f, -0.01322610f, 0.02372674f, -0.02708193f, -0.03612562f, -0.04001180f, 0.01038541f, 0.01862994f, 
    -0.03027489f, -0.02790077f, 0.00482718f, 0.00792659f, -0.00948876f, 0.01015601f, -0.00867625f, -0.00094780f, 
    0.01795081f, 0.01843581f, -0.01893306f, -0.03004042f, -0.01901617f, -0.00804438f, 0.01324039f, -0.03105706f, 
    -0.02031046f, 0.00938980f, -0.01459854f, 0.01572258f, 0.02093207f, -0.00104131f, 0.00260279f, -0.00376718f, 
    -0.02793282f, -0.00454827f, 0.01227346f, -0.03093760f, -0.02780530f, -0.01925254f, -0.02298626f, -0.03745582f, 
    0.02748164f, 0.01880986f, -0.00098498f, -0.01369361f, -0.01082856f, -0.01800757f, -0.03373435f, 0.00453744f, 
    -0.03641143f, -0.03477410f, -0.00429117f, -0.04428639f, 0.00539367f, 0.01901247f, -0.02099971f, -0.01793339f, 
    -0.01573876f, -0.03007442f, -0.00366626f, 0.02892151f, -0.02113097f, 0.01734139f, 0.02301837f, 0.02935494f, 
    0.01322058f, 0.00718240f, 0.01234265f, -0.03415543f, 0.03445682f, -0.01449090f, -0.03897971f, 0.00590882f, 
    0.02557452f, 0.00307990f, 0.01270736f, 0.01023620f, 0.01941813f, 0.00293955f, -0.02364281f, 0.02225229f, 
    -0.01755560f, 0.02495252f, -0.02636597f, -0.01610843f, 0.00878905f, 0.00912630f, -0.00658185f, 0.02140625f, 
    0.02617651f, 0.02890828f, 0.00520728f, -0.03213757f, 0.00854117f, 0.02010806f, -0.03129806f, -0.01625462f, 
    -0.01732781f, -0.03365924f, 0.01239491f, -0.04094217f, 0.04125810f, -0.01233175f, -0.01228868f, 0.01772550f, 
    -0.04197970f, -0.00544799f, 0.00517720f, 0.01709083f, 0.01265038f, -0.00881868f, -0.00595651f, 0.02914972f, 
    0.01082041f, -0.03458928f, 0.02227098f, -0.03715827f, 0.01833705f, 0.01140912f, 0.01459766f, 0.02668477f, 
    0.00302139f, -0.01374637f, 0.02543230f, 0.01952796f, 0.02339195f, 0.01543561f, 0.01155775f, -0.02812450f, 
    0.00545103f, 0.02131656f, 0.00343975f, -0.03525416f, -0.01545710f, 0.01933121f, -0.04128261f, 0.01337761f, 
    0.01644495f, -0.04098478f, 0.01051208f, -0.03204519f, -0.03021592f, -0.01107266f, -0.00647243f, -0.02380062f, 
    -0.00223417f, 0.00749127f, 0.01448098f, -0.00087545f, 0.01980458f, -0.01929234f, -0.02761342f, 0.01254455f, 
    -0.01440750f, -0.02924594f, 0.02504709f, -0.01521856f, -0.04009148f, -0.04081626f, 0.00823255f, 0.00894116f, 
    0.01686702f, -0.01391958f, -0.03916480f, -0.02803494f, -0.03647903f, -0.01337804f, 0.02268484f, 0.02149431f, 
    -0.03966442f, 0.01055041f, -0.03572628f, 0.00648718f, 0.01543303f, -0.01778368f, 0.02899322f, -0.02542795f, 
    -0.03917073f, 0.02869928f, 0.01771114f, -0.02367467f, -0.01764934f, 0.01736329f, 0.01340803f, -0.00518173f, 
    -0.02558833f, 0.01573217f, -0.00464483f, 0.02695205f, 0.00542856f, -0.04180573f, 0.02795403f, -0.03680043f, 
    0.00383349f, 0.01649339f, -0.03346515f, 0.02765204f, -0.04159037f, 0.01059600f, 0.01137220f, 0.02349968f, 
    0.02435328f, -0.01789645f, 0.00409359f, -0.00648687f, 0.00310360f, 0.01054868f, 0.01277579f, -0.04043332f, 
    -0.00228264f, -0.02144902f, 0.00854335f, -0.01607831f, -0.00652863f, -0.01447286f, -0.02672629f, 0.02794168f, 
    -0.01718310f, 0.00232929f, -0.00491521f, -0.00193535f, -0.03205815f, 0.00217826f, 0.01412744f, -0.03373977f, 
    0.01064035f, -0.03401122f, 0.01747887f, -0.00480890f, -0.03346515f, -0.02522611f, -0.03122483f, 0.01601438f, 
    -0.02183698f, 0.02397144f, 0.00950422f, -0.02243822f, 0.01237825f, 0.00767523f, -0.03664392f, 0.02714979f, 
    0.01737176f, 0.01589912f, 0.01798135f, 0.02568324f, -0.03079470f, -0.04071464f, -0.04155629f, -0.02130239f, 
    0.00085338f, 0.01883364f, 0.00058921f, -0.03249288f, 0.02262778f, -0.02867525f, -0.03977428f, -0.01655118f, 
    0.00879994f, 0.01328332f, -0.00076895f, -0.01593002f, 0.02390117f, 0.00936649f, 0.02451294f, -0.00325240f, 
    -0.02134818f, 0.02539239f, -0.01355572f, 0.01582902f, 0.01157648f, -0.01789858f, 0.00529913f, 0.00104477f, 
    -0.01851644f, -0.02646715f, 0.00105863f, 0.02514967f, 0.00042192f, 0.01523793f, -0.03953743f, -0.01601473f, 
    -0.02962987f, -0.01273537f, -0.01567335f, -0.01954234f, -0.04078775f, 0.02026324f, -0.03075930f, 0.01803420f, 
    0.02550763f, -0.00799525f, -0.01130090f, 0.03171360f, -0.01101344f, 0.02459255f, -0.01325556f, 0.03505117f, 
    -0.02346022f, 0.01508568f, -0.01824136f, -0.04132684f, 0.03073577f, 0.03217373f, -0.01018785f, -0.00068701f, 
    0.01209695f, 0.02231931f, 0.00864126f, 0.03046020f, 0.01387311f, -0.00736131f, 0.00904448f, 0.02709665f, 
    -0.01860300f, -0.00808026f, -0.00667198f, 0.01760457f, -0.00979833f, 0.01013616f, -0.02253193f, -0.01845984f, 
    0.02658246f, -0.00410338f, -0.02581935f, -0.01466956f, -0.03333803f, -0.01179441f, 0.01116145f, 0.01816966f, 
    -0.02612726f, -0.02393477f, 0.01237641f, 0.00654523f, -0.03804498f, -0.03545805f, -0.01989042f, 0.01950190f, 
    0.00775883f, 0.01274752f, -0.01619640f, 0.01965125f, -0.03234195f, -0.03376671f, 0.01007728f, 0.02583932f, 
    0.02156044f, -0.01227808f, 0.01417203f, -0.01801502f, 0.01501973f, -0.03207533f, -0.02837180f, -0.03052976f, 
    -0.03537860f, 0.00365346f, 0.02072895f, -0.01378283f, -0.00684106f, -0.00023826f, 0.00160015f, -0.03192100f, 
    0.01612375f, -0.01581606f, -0.01002507f, 0.01701463f, 0.01676369f, 0.03508195f, -0.01353300f, -0.03129340f, 
    -0.03626950f, 0.00145361f, 0.02618030f, -0.03551802f, -0.03496780f, 0.01844066f, 0.01782961f, -0.01631791f, 
    0.00815085f, 0.03059414f, -0.01026134f, 0.02985190f, 0.01972156f, 0.01524192f, 0.02040440f, 0.00410822f, 
    0.01104610f, -0.03759417f, -0.02499230f, -0.00684878f, 0.01690205f, -0.02485205f, 0.01073872f, 0.01601471f, 
    0.00906289f, 0.02195268f, 0.01500428f, -0.01791845f, -0.00091237f, 0.03031401f, 0.00567009f, 0.00103254f, 
    -0.02569441f, -0.04054763f, 0.02073298f, -0.04116656f, 0.00965735f, -0.02682723f, 0.00248507f, -0.03132019f, 
    -0.02102672f, 0.01142004f, -0.00318902f, 0.02971711f, 0.00091401f, 0.02174066f, -0.01077053f, 0.03146654f, 
    0.00192454f, -0.00136702f, -0.00358634f, 0.00340676f, -0.00683134f, -0.03073410f, -0.03302051f, 0.02289788f, 
    0.01169622f, -0.00775521f, -0.02614649f, -0.03308358f, -0.03639125f, 0.00173649f, -0.01032472f, 0.00559830f, 
    0.01609176f, 0.00073496f, -0.03522932f, 0.02726790f, -0.00372576f, 0.00296608f, 0.01371480f, 0.02851872f, 
    -0.01994860f, 0.00412977f, -0.03787328f, -0.02278261f, -0.03291940f, -0.01273299f, -0.02850840f, -0.00286176f, 
    -0.01964272f, 0.02595897f, 0.02540221f, 0.00835310f, -0.01006074f, 0.00890899f, -0.02224275f, -0.00689331f, 
    -0.03127589f, -0.03452502f, -0.01352957f, 0.00194246f, 0.00605592f, -0.02517732f, 0.01914385f, 0.03099120f, 
    -0.02031044f, 0.01514289f, 0.01789929f, -0.00951690f, -0.03347171f, 0.00062050f, 0.02561217f, -0.02970705f, 
    0.02108217f, -0.00620727f, -0.03586657f, 0.01812851f, -0.02421315f, 0.00628022f, 0.02358191f, -0.03884725f, 
    -0.01894087f, -0.01604032f, 0.00678768f, -0.02855895f, -0.00975016f, -0.02664476f, -0.03559671f, -0.03089898f, 
    -0.00764062f, -0.02415892f, -0.00593855f, 0.01636724f, 0.02843396f, -0.01529385f, 0.01739093f, -0.01034836f, 
    -0.00544439f, 0.02634068f, -0.03220036f, 0.01600850f, 0.02853796f, 0.03060122f, 0.01820359f, 0.00354911f, 
    0.01294996f, -0.00073781f, -0.01225771f, 0.00566576f, 0.01397645f, 0.02681675f, 0.01130700f, 0.01704122f, 
    -0.03540415f, 0.02384309f, 0.01319052f, -0.00442567f, 0.01433522f, -0.00161816f, 0.01430114f, -0.02309754f, 
    -0.02664077f, 0.00504791f, -0.00948903f, -0.03354938f, -0.02094252f, 0.00223418f, -0.00364666f, 0.01796683f, 
    -0.02578102f, 0.00852523f, 0.03207070f, -0.01119438f, -0.02873790f, 0.02886841f, -0.01738894f, -0.01993613f, 
    -0.01021781f, -0.01585022f, -0.00795448f, 0.00056036f, -0.04291460f, -0.04201864f, -0.02670447f, 0.02813986f, 
    0.00982687f, 0.01001585f, 0.00223385f, -0.03637097f, -0.00178552f, 0.01085605f, -0.03418386f, 0.01566104f, 
    -0.02263124f, 0.00936047f, 0.03427088f, -0.00433432f, -0.02443253f, -0.00187571f, -0.00285742f, 0.00159789f, 
    0.01827662f, 0.00734032f, -0.02187172f, 0.02831755f, 0.02498821f, -0.01484435f, -0.03335965f, -0.03691454f, 
    0.02108563f, -0.02303967f, -0.03972929f, 0.00499491f, 0.01431869f, 0.00539479f, 0.02115429f, -0.00898148f, 
    -0.00122751f, -0.00174385f, 0.02706993f, -0.03480262f, -0.02561353f, 0.01330600f, 0.02145813f, -0.02984793f, 
    -0.02014744f, 0.01717214f, -0.02343813f, 0.01666142f, -0.01366041f, 0.02735458f, -0.01544124f, 0.00533009f, 
    0.02414531f, -0.01985741f, -0.00322245f, -0.02904969f, 0.03079636f, 0.00339215f, 0.02646559f, 0.00038642f, 
    -0.00243083f, 0.02405988f, 0.01162520f, -0.01862528f, 0.02448626f, -0.04291966f, 0.01809490f, -0.02958830f, 
    -0.02283087f, 0.01872617f, -0.04241225f, 0.01290596f, -0.01105360f, -0.01850159f, 0.02427158f, 0.01339696f, 
    -0.03441618f, 0.03023000f, -0.00287683f, 0.01841642f, -0.01144002f, 0.00364398f, 0.01723448f, -0.03630819f, 
    -0.00796807f, 0.01049465f, 0.01498418f, -0.01107361f, 0.01124557f, -0.00957462f, -0.03619879f, -0.00116832f, 
    -0.03338854f, 0.02034984f, 0.00025103f, 0.02182207f, -0.02108886f, -0.01562766f, -0.00488140f, 0.02127118f, 
    0.00593793f, -0.01895153f, -0.03269916f, 0.03187865f, -0.02242474f, 0.00404167f, -0.02621801f, 0.01191697f, 
    -0.01953133f, -0.00476270f, -0.02745578f, -0.03404985f, 0.01104401f, -0.01819943f, 0.02166111f, -0.03339384f, 
    -0.00345665f, -0.01842766f, -0.02966080f, -0.02945166f, -0.00696144f, -0.02423751f, -0.01582474f, -0.01280844f, 
    -0.03826559f, 0.02308503f, -0.00157121f, 0.00046144f, -0.03009424f, 0.02005813f, 0.02122212f, -0.03780035f, 
    0.01321401f, -0.01972876f, -0.02845586f, -0.00847833f, 0.01842703f, 0.01429720f, -0.02317190f, -0.00167771f, 
    0.01844129f, -0.01991617f, -0.00764506f, -0.01351940f, -0.04433623f, -0.02530842f, -0.02952350f, 0.03021191f, 
    0.00565008f, 0.02251516f, 0.01771736f, 0.01247967f, -0.02902596f, 0.02584845f, 0.01822103f, -0.01763249f, 
    -0.01843751f, 0.00775992f, 0.02092724f, -0.02023559f, -0.02515710f, -0.02913263f, -0.03591015f, 0.01519997f, 
    0.00535053f, 0.00766407f, -0.00479237f, 0.02068189f, 0.00892275f, 0.00704669f, 0.03343853f, 0.01943654f, 
    -0.04157796f, -0.02091349f, 0.01263209f, -0.00717358f, 0.02254987f, -0.00737372f, 0.00126630f, -0.00053336f, 
    0.00415746f, 0.02581107f, 0.02993711f, 0.02806165f, 0.02503880f, -0.00221315f, 0.02558045f, 0.03101571f, 
    0.01158545f, -0.02441737f, 0.01182522f, 0.02669887f, -0.03866381f, 0.02851081f, -0.02438438f, -0.00863601f, 
    0.00711796f, 0.02191757f, -0.02904414f, 0.00124222f, -0.01130358f, 0.00821716f, 0.00593879f, -0.01195129f, 
    -0.02040437f, 0.01912684f, 0.00876069f, -0.00569807f, 0.00318257f, -0.02443703f, -0.02526887f, -0.04089591f, 
    -0.00071910f, 0.00472243f, -0.02067019f, 0.02136851f, -0.02580645f, -0.02297177f, 0.01773184f, -0.00804805f, 
    -0.03595994f, -0.00753513f, -0.02004724f, 0.01245604f, 0.00538602f, 0.02057682f, -0.00054927f, -0.02106550f, 
    -0.01831135f, -0.03724170f, -0.00362483f, 0.01558895f, 0.02161860f, 0.02631383f, 0.00965097f, -0.01462471f, 
    -0.00278731f, 0.01612245f, -0.02810958f, 0.02170979f, 0.00649069f, -0.03518452f, -0.02537572f, -0.02019247f, 
    0.01411227f, 0.02501373f, 0.02076174f, -0.03369094f, -0.01513640f, -0.00906502f, -0.01208917f, -0.01861680f, 
    0.02328768f, 0.00131533f, -0.02621089f, -0.00921942f, -0.03060041f, -0.02208794f, -0.02545294f, -0.02579507f, 
    -0.01965852f, -0.00339632f, -0.01769548f, -0.00796439f, -0.03001889f, -0.04122836f, -0.01309184f, 0.03102761f, 
    -0.00042100f, -0.02051732f, 0.02310910f, 0.02249191f, -0.01255184f, -0.01384376f, 0.01075650f, -0.01522742f, 
    -0.03789436f, -0.03513172f, 0.00845957f, -0.00304066f, 0.01994318f, -0.03039455f, 0.01387311f, 0.02785437f, 
    0.02957646f, 0.01550367f, -0.02407189f, -0.00824503f, -0.03216316f, -0.00693678f, -0.02407093f, -0.02831421f, 
    0.00542104f, -0.00139000f, -0.03343686f, -0.00377711f, 0.00091543f, 0.01655361f, -0.01831459f, -0.03021461f, 
    -0.01280508f, 0.01107822f, -0.00324901f, -0.01109319f, -0.01191766f, 0.02994405f, -0.03160646f, -0.04152815f, 
    -0.03357535f, -0.00034975f, -0.02289132f, 0.00186271f, 0.02223955f, 0.03120829f, -0.03039793f, -0.03691987f, 
    -0.00039684f, -0.00163474f, 0.00914577f, 0.01819950f, -0.00243340f, 0.02758296f, -0.04052438f, -0.01587315f, 
    -0.00797297f, -0.02293626f, 0.00166319f, 0.01959128f, -0.00318873f, -0.00885054f, -0.01294927f, 0.02327141f, 
    0.01338008f, 0.00926368f, -0.04199449f, -0.00558454f, 0.02303861f, 0.02110498f, -0.01626494f, -0.00796041f, 
    -0.03001947f, -0.01884381f, -0.03651583f, 0.00152962f, 0.02129274f, -0.01662158f, -0.01913591f, 0.00127902f, 
    -0.01941672f, -0.02639891f, -0.03009260f, -0.00524692f, 0.01496148f, 0.01090130f, -0.02013343f, 0.01981219f, 
    -0.00995575f, -0.00046704f, -0.04376249f, -0.00375237f, -0.04123638f, -0.00292653f, 0.02513864f, 0.01367975f, 
    0.02472679f, 0.02617829f, -0.01699524f, 0.00374744f, -0.02232394f, -0.03055413f, -0.04178516f, 0.02200338f, 
    -0.02278399f, -0.02783604f, 0.00868200f, 0.00996989f, -0.02760141f, -0.02921026f, -0.03547632f, -0.00855250f, 
    -0.00975483f, -0.02902746f, 0.02265512f, -0.01780660f, -0.02384840f, -0.01671810f, -0.00940584f, 0.02222841f, 
    -0.02817599f, 0.02195594f, -0.02168607f, 0.00904392f, -0.03781142f, 0.01818617f, 0.00422936f, 0.00367146f, 
    0.00956782f, 0.03045752f, 0.01987665f, 0.00460496f, 0.00492566f, 0.01993327f, -0.02456295f, -0.01064683f, 
    0.02595020f, -0.03792724f, 0.01788086f, -0.00043728f, 0.02112065f, -0.01708398f, 0.02196052f, 0.01478862f, 
    0.00512249f, 0.01262743f, -0.01655789f, 0.00994562f, -0.01468997f, 0.01998583f, -0.00989151f, -0.00548054f, 
    -0.01413281f, -0.04169598f, 0.00920507f, 0.00758013f, -0.03631989f, 0.02546002f, 0.02433312f, -0.02013530f, 
    -0.01790533f, 0.01714906f, -0.01057766f, -0.02596139f, 0.01073713f, -0.03098590f, -0.01064544f, 0.02866111f, 
    0.02059813f, 0.02280807f, -0.00180467f, 0.02994903f, -0.02376416f, 0.02158364f, 0.02985454f, 0.01109378f, 
    -0.01273975f, 0.00787725f, -0.03068618f, 0.02079699f, -0.01329565f, 0.03042220f, -0.00950958f, -0.03525937f, 
    0.01153573f, -0.03282231f, 0.00934764f, -0.02873097f, 0.02743844f, -0.02876138f, -0.01933885f, -0.02403850f, 
    -0.01950976f, 0.01819904f, -0.01761886f, -0.00525183f, 0.00458002f, -0.01374408f, 0.01913523f, -0.02994967f, 
    -0.03235094f, -0.00672267f, -0.00063264f, 0.01009219f, -0.00249587f, -0.01189345f, 0.00008135f, 0.01598544f, 
    0.02201365f, 0.01444506f, -0.02923351f, -0.03119682f, 0.00764448f, 0.01933214f, -0.01770589f, -0.03952219f, 
    -0.02506583f, -0.01662626f, -0.02053510f, -0.00742342f, 0.01722261f, -0.00898811f, -0.01001888f, 0.01159249f, 
    0.02416947f, 0.01041936f, -0.03550518f, -0.03251931f, 0.03223991f, 0.00336763f, 0.02089476f, -0.03779880f, 
    -0.02865887f, -0.02955176f, -0.01947300f, -0.00343155f, -0.01511441f, 0.01967434f, -0.02248157f, 0.01294783f, 
    -0.00578030f, 0.01489237f, -0.00273016f, -0.02133233f, -0.02579510f, 0.01122237f, 0.00215121f, -0.04554550f, 
    0.29796791f, 0.05256654f, -0.05105443f, 0.06128026f, 0.05773539f, 0.03340501f, 0.08011172f, 0.01542580f, 
    -0.01054054f, -0.00584940f, 0.00332418f, 0.08858277f, 0.13959618f, -0.03235282f, -0.22694226f, 0.11114288f, 
    -0.05813997f, -0.06825346f, 0.01192728f, 0.04630096f, -0.02227957f, -0.04023098f, 0.01616440f, -0.05949078f, 
    0.10824305f, 0.03338299f, 0.03730755f, 0.02506154f, -0.01987760f, -0.01285905f, 0.02754760f, 0.01797434f, 
    -0.10913548f, 0.04256738f, -0.01597427f, -0.01718617f, 0.24426363f, 0.17796071f, -0.07085921f, -0.14281034f, 
    0.00970079f, 0.04099324f, 0.25303504f, -0.01749173f, 0.10937296f, -0.06521872f, 0.08590411f, -0.13860440f, 
    0.37627304f, 0.02765407f, 0.04155877f, -0.07002264f, -0.05493930f, -0.03408613f, 0.08424354f, 0.01725584f, 
    -0.12026166f, 0.05980332f, 0.02268220f, 0.13117877f, 0.47448680f, 0.09867141f, -0.02075172f, 0.06394213f, 
    -0.01034949f, 0.03541742f, 0.05817728f, 0.05243651f, -0.04065304f, 0.01903329f, 0.00290696f, 0.04660060f, 
    0.23072344f, -0.08385400f, 0.11620187f, -0.01559601f, -0.06792768f, 0.09763967f, -0.03187851f, 0.10502446f, 
    -0.01976246f, -0.00564376f, -0.04047605f, -0.11834791f, -0.04236419f, 0.05188310f, -0.06118865f, -0.05392018f, 
    -0.03070723f, 0.04356906f, -0.13834184f, -0.13075657f, 0.00222451f, 0.05599333f, -0.00431899f, 0.10670973f, 
    -0.04890374f, 0.06797487f, -0.12730107f, -0.25264296f, -0.01655232f, -0.03475253f, -0.04630107f, 0.03981645f, 
    -0.00662201f, 0.07943802f, 0.07375585f, -0.14356096f, 0.02253679f, 0.04917558f, -0.09209099f, -0.17668873f, 
    0.09952472f, 0.03013043f, -0.10495875f, -0.00421599f, -0.00623016f, 0.05542658f, 0.17383234f, -0.06657051f, 
    -0.28159720f, -0.01537659f, -0.03632519f, -0.10052811f, 0.04583979f, -0.00343190f, 0.04773009f, 0.04910679f, 
    -0.14519085f, 0.03485574f, 0.06068067f, 0.03549973f, 0.54602247f, 0.06205790f, -0.02204885f, 0.14654759f, 
    0.06165967f, 0.12680189f, -0.11907694f, -0.00923372f, 0.00764286f, 0.00841886f, 0.05673347f, -0.02430521f, 
    0.17835508f, -0.00166949f, -0.01809233f, -0.00402836f, -0.01549010f, 0.00354142f, 0.03109712f, 0.02823004f, 
    0.00121856f, 0.05941162f, 0.05598667f, 0.07781836f, 0.15787891f, -0.02101397f, -0.04132630f, -0.11159120f, 
    -0.03545268f, -0.01696348f, 0.13925989f, 0.06585067f, -0.02706637f, 0.06910234f, 0.03714757f, 0.06274674f, 
    -0.08008321f, -0.02394463f, -0.02346045f, 0.07175138f, -0.02943010f, 0.05720395f, 0.00090138f, 0.02457545f, 
    0.05398816f, 0.14361094f, 0.12693165f, 0.10458227f, 0.30379280f, 0.12581261f, -0.22087561f, -0.03610623f, 
    0.02652768f, 0.02601817f, -0.00210910f, -0.08926905f, 0.06479426f, 0.01261291f, 0.02584767f, -0.15541796f, 
    0.08279075f, 0.07672058f, -0.06157233f, 0.01165439f, -0.04565390f, 0.08311704f, -0.02247554f, 0.10654432f, 
    0.04016877f, -0.03529836f, -0.02732611f, -0.10042012f, -0.06690404f, 0.13536945f, 0.04654431f, -0.12414451f, 
    0.06741023f, 0.00149976f, 0.01537791f, 0.03221392f, 0.05651381f, 0.07525155f, -0.01010251f, -0.03790097f, 
    0.27889675f, 0.03583034f, 0.06036798f, -0.00898693f, -0.12855910f, 0.03230423f, -0.03152286f, 0.10272418f, 
    0.02249625f, 0.04618247f, 0.05473036f, 0.03253798f, -0.10258761f, -0.04494858f, -0.16300778f, -0.13905239f, 
    0.00518566f, -0.02193006f, -0.03744315f, 0.01568096f, 0.10837125f, -0.01568842f, -0.06238523f, -0.03095785f, 
    -0.09050830f, 0.00700994f, 0.00739978f, -0.00344919f, 0.01562479f, -0.11760189f, 0.01530509f, 0.07138360f, 
    0.00494551f, 0.03554659f, -0.05655364f, -0.08691263f, 0.10551915f, -0.14330396f, -0.00978056f, -0.07486262f, 
    -0.07174653f, -0.05046487f, -0.08617733f, -0.00666862f, -0.03475145f, 0.02346823f, 0.09044834f, 0.15632744f, 
    0.22889364f, -0.09411813f, 0.09946202f, 0.06085030f, 0.00974158f, -0.00855161f, 0.04571436f, 0.05304359f, 
    0.00083544f, 0.05659587f, -0.00628426f, 0.11757340f, 0.07499562f, -0.03337333f, -0.10742816f, -0.03423080f, 
    -0.06330895f, -0.02334891f, -0.15779869f, 0.04526407f, -0.11609971f, -0.03003459f, -0.00294483f, 0.05729013f, 
    -0.00167472f, 0.01388174f, 0.06062568f, 0.07336477f, -0.02486896f, -0.02652424f, 0.00575902f, -0.05009413f, 
    0.04805939f, 0.01474599f, -0.11227611f, -0.08579072f, 0.01427804f, 0.05583577f, -0.12321170f, 0.04424871f, 
    -0.03625730f, 0.06161726f, 0.01158135f, 0.02422506f, -0.03834394f, -0.01440546f, -0.03530110f, 0.02392616f, 
    -0.16493896f, 0.15726808f, -0.02593910f, -0.19285686f, -0.02461542f, 0.02533630f, -0.01162383f, 0.07740510f, 
    -0.02180750f, 0.02441953f, 0.01680701f, 0.02136861f, -0.09062906f, 0.10949380f, -0.00228829f, 0.16385570f, 
    -0.05784016f, 0.01388760f, 0.04455144f, 0.02277428f, -0.01124287f, -0.01685201f, -0.02275594f, -0.02188789f, 
    0.35923660f, -0.05871602f, 0.15268858f, 0.18225563f, -0.08206005f, -0.03587069f, 0.01724564f, 0.08076840f, 
    0.15371276f, -0.01041073f, -0.12678479f, 0.01109377f, -0.36421224f, 0.01330039f, -0.09634720f, 0.00601937f, 
    -0.01813207f, 0.11442979f, -0.00963307f, -0.01040241f, 0.02336824f, -0.04030964f, 0.07234394f, 0.18059994f, 
    0.06400520f, 0.06108859f, -0.21766128f, -0.24237068f, -0.10869713f, 0.04957984f, -0.00684967f, -0.06435526f, 
    -0.02924790f, -0.11162137f, -0.02573471f, 0.06149140f, 0.00660015f, 0.01628662f, -0.06574678f, -0.15936039f, 
    0.07535586f, 0.05898242f, 0.03298032f, 0.05560117f, 0.03707138f, 0.00239297f, 0.00874346f, -0.06961139f, 
    -0.01209007f, 0.08002096f, 0.03052493f, -0.12743887f, 0.18863425f, 0.14726457f, 0.06383017f, 0.04647021f, 
    0.00224817f, 0.01245201f, 0.14210673f, -0.00328407f, 0.51426232f, -0.14892653f, 0.10118227f, 0.21922186f, 
    -0.11111016f, -0.03490749f, -0.08818112f, 0.03277315f, 0.07836229f, 0.12864906f, -0.11109556f, -0.01426789f, 
    0.23576431f, -0.04913434f, 0.00278596f, 0.02851744f, -0.08403394f, 0.10869150f, -0.04367955f, 0.07502272f, 
    -0.18828659f, 0.02581260f, 0.06808288f, -0.07422508f, 0.04103603f, 0.00041660f, 0.02409062f, -0.11339517f, 
    -0.00869428f, 0.03835306f, 0.01983922f, 0.04786829f, -0.06364238f, 0.00892671f, -0.01067898f, 0.00260041f, 
    -0.09821419f, 0.08169835f, -0.01363251f, 0.02777273f, -0.02656467f, -0.03688525f, 0.01182243f, -0.07809065f, 
    -0.02192339f, -0.06512655f, 0.03147541f, 0.07527533f, -0.08574887f, 0.01620073f, 0.06432147f, 0.05191517f, 
    -0.01000434f, -0.00668513f, 0.02552793f, 0.12391932f, 0.03181585f, -0.08674430f, 0.02278421f, 0.07130575f, 
    -0.32399079f, -0.21381389f, 0.10298879f, 0.00846161f, -0.02537041f, 0.04415826f, -0.00519205f, 0.13582969f, 
    0.10613753f, 0.00998574f, 0.02328471f, 0.00975109f, 0.07604513f, 0.07307507f, -0.14912185f, -0.24573487f, 
    0.12583572f, 0.02533748f, -0.08048051f, 0.05154914f, -0.02067114f, -0.02800032f, 0.05203742f, 0.03487703f, 
    -0.18529317f, 0.10323689f, 0.11337613f, -0.01219789f, 0.03000713f, -0.00298028f, 0.05191391f, 0.01238646f, 
    -0.01397518f, -0.00938179f, -0.05861324f, 0.01471279f, 0.25446740f, -0.12021016f, -0.09019686f, -0.04312089f, 
    -0.05442495f, -0.10718493f, -0.10064539f, -0.06213065f, 0.02448794f, -0.13152665f, 0.04968813f, 0.05080585f, 
    -0.13395938f, -0.06346685f, -0.00861433f, 0.03107783f, -0.06981334f, 0.02084851f, 0.06359491f, 0.05427142f, 
    -0.03846283f, 0.03020276f, 0.02511247f, 0.00654679f, 0.08279758f, -0.08887810f, 0.00409092f, -0.11754569f, 
    -0.06237655f, -0.01508866f, 0.10670574f, 0.05479567f, -0.07318001f, 0.00030687f, 0.00451684f, -0.03533414f, 
    0.08663277f, 0.28528634f, 0.08417348f, -0.04092297f, -0.05502778f, 0.03231814f, 0.08481530f, 0.11710640f, 
    -0.01409322f, 0.00136999f, -0.02521504f, -0.00196081f, 0.28555730f, 0.12542239f, -0.20983711f, -0.13608715f, 
    0.08741968f, 0.10643731f, 0.06914740f, 0.02401281f, -0.00302663f, -0.00202264f, 0.03076950f, -0.10803846f, 
    0.36437863f, -0.02757461f, 0.13716751f, 0.15031788f, 0.05136842f, 0.03163131f, 0.02453545f, 0.04089567f, 
    0.01396792f, 0.10452089f, 0.05288976f, 0.03994871f, -0.38171974f, 0.06042052f, -0.12126201f, 0.02951234f, 
    0.06333493f, -0.04388793f, 0.18915053f, 0.13531281f, 0.01687934f, -0.11784330f, 0.06776094f, -0.06133998f, 
    0.06751791f, -0.02045782f, -0.02207566f, 0.19742660f, 0.06348017f, -0.03931281f, 0.00300273f, -0.03152453f, 
    -0.05550218f, 0.06883068f, 0.00354809f, 0.09388054f, -0.18839459f, -0.04863565f, -0.05528410f, 0.05265643f, 
    -0.09024870f, -0.00696255f, -0.02929875f, 0.10246700f, -0.04750276f, -0.05859901f, -0.01966321f, -0.02186569f, 
    -0.09173217f, -0.13215144f, 0.00293452f, -0.16281487f, -0.18034460f, -0.04262726f, 0.01668196f, -0.04567780f, 
    -0.05882616f, -0.14162742f, 0.05699801f, -0.04104701f, -0.17649949f, -0.07773291f, 0.03333365f, 0.14677951f, 
    -0.00833299f, 0.02789043f, 0.04838736f, 0.13387139f, 0.10014368f, 0.01209690f, -0.00407787f, 0.06321306f, 
    -0.15652238f, 0.06810931f, 0.01756085f, -0.22593465f, -0.03693070f, -0.05723533f, 0.01790948f, -0.09099282f, 
    -0.12674934f, -0.07022607f, -0.10181051f, -0.16646978f, 0.29729474f, -0.02638175f, 0.13447735f, -0.07354698f, 
    -0.07342061f, 0.00622251f, 0.09647501f, -0.12237525f, 0.04566054f, 0.11484596f, 0.01546054f, 0.06601298f, 
    0.06432653f, -0.13234474f, -0.09718083f, 0.11870138f, -0.06674261f, 0.07465722f, -0.08075140f, -0.02550664f, 
    0.07930364f, 0.09556668f, 0.03995056f, 0.03445677f, 0.17789438f, -0.03713383f, -0.01954462f, 0.02692840f, 
    0.03715755f, 0.07075084f, -0.05592179f, 0.03331694f, 0.04548208f, -0.02505585f, 0.03371871f, 0.11191454f, 
    -0.04383963f, -0.07163189f, -0.07435305f, -0.01870583f, -0.02062080f, 0.12622434f, -0.03699467f, 0.03782880f, 
    -0.09619628f, 0.05118451f, -0.01252670f, -0.05289070f, -0.12208180f, 0.00302479f, 0.01641735f, -0.02838771f, 
    -0.02178472f, 0.05002441f, 0.00949192f, 0.11925030f, 0.20044810f, -0.08614864f, 0.06473313f, -0.04433001f, 
    -0.27110818f, 0.12869971f, -0.01001632f, 0.08895174f, -0.08913523f, 0.09085374f, 0.01886297f, -0.03395113f, 
    -0.02722051f, 0.01638902f, 0.01952487f, 0.01609111f, 0.14035654f, 0.00805594f, 0.13943766f, -0.01895739f, 
    -0.03885882f, -0.03709627f, -0.00345015f, -0.00213724f, 0.01705881f, -0.05924216f, 0.06672482f, 0.06256822f, 
    -0.19830768f, -0.16333127f, -0.01630513f, -0.07124511f, -0.02248541f, -0.02681183f, 0.00117094f, 0.01022863f, 
    -0.00667089f, 0.02283974f, -0.06536848f, -0.03272330f, 0.16983192f, 0.00293872f, -0.22713836f, -0.03598185f, 
    0.10085814f, 0.07271110f, 0.00725827f, -0.01206066f, 0.12890315f, -0.02298788f, -0.03353443f, -0.03786714f, 
    -0.03868883f, -0.05171023f, 0.00860381f, -0.04244350f, 0.04916900f, -0.09258151f, 0.06284876f, -0.06231593f, 
    0.07094087f, -0.05777999f, -0.07528398f, 0.04194080f, -0.09196953f, -0.28050116f, -0.10739089f, -0.01690832f, 
    -0.06439930f, 0.01980107f, -0.06027055f, -0.07623857f, 0.02899238f, 0.04331398f, -0.01438034f, 0.05156730f, 
    0.02486501f, 0.01529642f, 0.02209043f, 0.02693249f, 0.01441153f, 0.01609266f, 0.00900986f, -0.02296222f, 
    0.00438972f, -0.04052109f, 0.01113997f, -0.03646775f, -0.02633699f, -0.02311322f, 0.02278033f, -0.01380592f, 
    0.00010706f, -0.03718751f, 0.01276007f, 0.00000274f, 0.01574441f, -0.01844271f, -0.01066560f, 0.02786631f, 
    0.00811815f, -0.00117196f, -0.01889159f, -0.03794898f, -0.00246299f, 0.00029984f, 0.01806782f, -0.02379345f, 
    0.00340312f, 0.01371928f, 0.00075712f, 0.01565310f, 0.01922169f, 0.02902173f, -0.02700149f, -0.01699375f, 
    -0.02041129f, -0.00391419f, 0.01541204f, -0.01990608f, 0.02417469f, 0.00679627f, -0.00805897f, 0.01186696f, 
    0.02173946f, -0.02773427f, -0.00906868f, -0.01042614f, -0.02126633f, -0.00690569f, -0.02371700f, 0.02711943f, 
    -0.01959251f, 0.02296555f, -0.00167182f, 0.02677240f, -0.01443089f, -0.02220486f, 0.02110991f, -0.01647681f, 
    -0.02475451f, -0.03232385f, 0.00320334f, -0.00839720f, -0.01969577f, 0.00951010f, -0.01537545f, -0.02351152f, 
    -0.03889139f, -0.00490041f, 0.02656384f, 0.02474804f, -0.02198238f, 0.03274685f, -0.01222068f, 0.01856230f, 
    0.00508318f, -0.01213263f, -0.03205756f, 0.01207087f, -0.03517686f, -0.00286465f, -0.00408212f, 0.00766854f, 
    0.02629051f, -0.02338964f, 0.02143724f, -0.00769000f, -0.00679045f, 0.00649914f, -0.03419734f, -0.01962619f, 
    -0.00773902f, 0.01419789f, -0.03408306f, 0.00011541f, 0.00290328f, -0.02588880f, 0.01066892f, 0.00323837f, 
    -0.00432122f, -0.02089510f, -0.01568998f, -0.02524085f, -0.00598203f, 0.00437089f, 0.02216176f, -0.03459677f, 
    -0.02128103f, -0.02058117f, -0.02784838f, 0.02595434f, 0.00472688f, 0.00790300f, 0.02602516f, 0.02599754f, 
    -0.03068437f, 0.02381615f, -0.01499381f, 0.01561220f, -0.01335782f, 0.02266902f, -0.00442600f, -0.03188069f, 
    -0.00537257f, -0.03928778f, 0.00746662f, -0.00452313f, 0.02827704f, 0.00001984f, 0.00911590f, 0.01282339f, 
    0.02114627f, 0.01552082f, 0.01727966f, -0.00648615f, -0.00310096f, -0.02163506f, -0.01537333f, -0.02016986f, 
    -0.02387275f, 0.00636798f, -0.03377908f, 0.02952882f, 0.01445982f, 0.02163518f, 0.02330594f, 0.02308995f, 
    -0.02334005f, -0.02082474f, -0.02058275f, 0.02412052f, -0.03790863f, -0.03404816f, -0.01815887f, 0.01862381f, 
    -0.00175565f, 0.02381930f, 0.02418519f, -0.03650979f, -0.03198617f, 0.02506598f, 0.01598850f, -0.01322455f, 
    -0.00242689f, 0.00843733f, -0.02371911f, 0.00952688f, -0.03055874f, 0.00038334f, -0.00249211f, -0.01802377f, 
    -0.03373770f, -0.03844158f, 0.01001378f, -0.02999143f, -0.03433235f, -0.03368554f, 0.00321625f, -0.01916504f, 
    -0.02638435f, 0.02501982f, 0.01624370f, -0.01761693f, -0.02175071f, -0.01563991f, -0.00723613f, 0.02838889f, 
    -0.03529738f, 0.00437271f, 0.02927822f, 0.00112110f, -0.00944157f, 0.02384311f, -0.03950578f, 0.01607659f, 
    0.00843914f, -0.03846177f, 0.00021543f, 0.01399965f, -0.00527540f, 0.01615735f, -0.03165295f, 0.01117844f, 
    0.02314204f, -0.02013495f, 0.00996720f, -0.01519041f, 0.00835766f, -0.00778540f, -0.02162003f, -0.02319043f, 
    0.02122139f, 0.00363014f, 0.01270921f, -0.01710393f, 0.01092729f, 0.01594206f, 0.01592787f, -0.01844192f, 
    0.00704430f, 0.02229346f, -0.02100023f, -0.03059803f, 0.01036260f, -0.01197140f, -0.03494667f, 0.00123520f, 
    0.00296683f, -0.01096743f, -0.02243220f, 0.00594617f, -0.02147789f, -0.04055778f, 0.01093554f, 0.01251522f, 
    0.00568868f, 0.00207374f, 0.01141301f, -0.01164976f, -0.04122478f, -0.01833818f, 0.00888472f, -0.02050608f, 
    -0.00256359f, 0.03002140f, -0.01994685f, 0.02758615f, -0.02784680f, 0.00765241f, 0.01565973f, 0.02263819f, 
    0.02636882f, -0.00021893f, 0.01827619f, -0.03260929f, 0.01728312f, -0.02076083f, -0.01653639f, 0.00709607f, 
    0.02676877f, 0.01806345f, -0.01256933f, -0.01944291f, -0.01919537f, 0.00456615f, 0.01698589f, 0.02550332f, 
    -0.02090957f, -0.01405363f, -0.01451085f, 0.02308509f, 0.00555241f, -0.01849846f, 0.01288282f, 0.01699124f, 
    0.01857738f, -0.02552480f, 0.02315078f, -0.02046048f, -0.02625702f, -0.00308077f, 0.00979396f, 0.01657644f, 
    -0.00546680f, 0.00027413f, -0.03843842f, 0.01029512f, -0.02857216f, 0.01221533f, -0.01468160f, -0.00776235f, 
    0.01078410f, -0.03578520f, 0.00912155f, 0.02264338f, 0.00899583f, 0.00357244f, 0.01687239f, -0.03773334f, 
    0.01955002f, 0.02386564f, 0.01760221f, -0.03428331f, -0.01378543f, -0.00948748f, -0.01624458f, -0.04009590f, 
    -0.00422451f, -0.02764069f, 0.01173084f, -0.00051348f, 0.02953481f, 0.01729637f, 0.02062596f, 0.02161438f, 
    -0.03594851f, -0.02956600f, -0.02428227f, -0.01694614f, 0.03010912f, -0.01162324f, 0.00995042f, 0.01827895f, 
    0.02741367f, 0.01866164f, -0.02440314f, 0.02759650f, -0.00778582f, -0.03754636f, 0.00837410f, -0.02861418f, 
    -0.02276549f, -0.03135673f, 0.00099511f, -0.02134353f, -0.01556727f, 0.02494049f, 0.01216738f, 0.01363715f, 
    -0.00686693f, -0.02237789f, 0.02418877f, 0.02783837f, -0.02714077f, -0.03049576f, -0.03109237f, -0.03891613f, 
    0.01338526f, -0.02329457f, -0.00476646f, -0.00069525f, 0.01446535f, 0.00449588f, -0.00047976f, -0.03190319f, 
    -0.01851273f, 0.01204356f, -0.01499399f, -0.00870908f, 0.01948143f, 0.01835061f, 0.02993836f, -0.00696516f, 
    0.02270812f, -0.02292457f, -0.00750820f, -0.01111335f, 0.00172605f, 0.01308776f, -0.01118193f, 0.01328791f, 
    0.02437705f, 0.01116624f, -0.00408379f, -0.01648591f, -0.01202947f, -0.04011202f, 0.03313649f, 0.00749391f, 
    -0.02642355f, -0.03152544f, -0.02196192f, -0.03779222f, -0.03117581f, 0.00462277f, -0.01632091f, -0.00067871f, 
    0.00535573f, 0.00418656f, 0.01516270f, -0.01954862f, -0.01304857f, -0.03967262f, -0.02644261f, -0.02766838f, 
    -0.03853137f, -0.00852645f, -0.01783920f, -0.01048861f, 0.00699583f, -0.02253560f, -0.03778647f, 0.00418407f, 
    0.01382138f, -0.00453187f, -0.01496354f, 0.00793076f, 0.01096082f, 0.01666483f, -0.00083965f, 0.02818161f, 
    0.01287175f, -0.03200145f, -0.00194162f, 0.02533776f, 0.02910318f, -0.02430749f, 0.01106716f, -0.00700457f, 
    0.00000913f, -0.00327088f, -0.00281410f, -0.00477367f, -0.00171380f, 0.01059180f, -0.01670832f, 0.01704175f, 
    -0.01212809f, -0.02430742f, -0.02464625f, -0.03944960f, -0.00621358f, -0.03548442f, -0.00109309f, -0.00856330f, 
    0.00746929f, -0.00431154f, -0.00304750f, -0.01592544f, 0.00197440f, 0.02260414f, -0.03386635f, -0.03148655f, 
    0.01364205f, -0.00852284f, 0.00273004f, -0.01494849f, -0.02225181f, 0.00846134f, 0.00009536f, -0.02554059f, 
    0.03041575f, 0.01133185f, -0.02745169f, 0.00425343f, 0.00225958f, 0.00351209f, 0.00721542f, 0.01346697f, 
    -0.01496984f, -0.01156325f, 0.02866820f, -0.03266966f, -0.02683065f, 0.02893711f, -0.01430229f, 0.00461301f, 
    -0.01658839f, -0.04047660f, 0.00935744f, 0.01868880f, -0.00089549f, -0.02215078f, 0.01741402f, 0.01000623f, 
    -0.03844513f, -0.01001742f, -0.02512368f, 0.01944026f, 0.00392320f, -0.01434591f, -0.03203594f, 0.00508288f, 
    -0.01287053f, 0.01923378f, 0.02147621f, 0.02948222f, -0.03595075f, -0.00409051f, -0.00354855f, 0.02634174f, 
    0.01100265f, 0.01884801f, -0.00645348f, -0.03909226f, -0.01805059f, -0.02800195f, -0.00199631f, -0.02061560f, 
    -0.03871250f, -0.01898317f, 0.01972668f, -0.02058455f, 0.00164383f, 0.00543666f, 0.00518161f, 0.02207878f, 
    0.01341412f, -0.03969543f, -0.02774368f, -0.02720595f, -0.00156051f, -0.00842616f, 0.02827029f, 0.02418433f, 
    -0.03804281f, -0.02812021f, -0.01823707f, -0.00565117f, -0.01961356f, 0.00671234f, 0.00071043f, 0.00235770f, 
    -0.00044100f, 0.01338617f, 0.00244686f, 0.00742646f, 0.00698630f, -0.00805822f, -0.00845896f, -0.01571293f, 
    0.00884547f, -0.01917478f, -0.02592247f, -0.00342958f, 0.01697855f, 0.01572804f, -0.02172013f, 0.02000384f, 
    -0.00777536f, -0.02116909f, -0.00553515f, 0.03007024f, -0.03018447f, 0.02525239f, -0.00561302f, 0.03912340f, 
    0.02535550f, -0.03533885f, -0.02224195f, -0.01564095f, 0.01859967f, -0.03083965f, -0.03976881f, -0.00690595f, 
    -0.02148428f, 0.00014158f, 0.01587741f, 0.02301811f, -0.02381900f, -0.03203901f, 0.02618605f, -0.03343897f, 
    -0.00643726f, 0.00359287f, -0.02624819f, -0.04070790f, 0.02804943f, 0.02586740f, 0.02522556f, -0.03337305f, 
    0.00315480f, -0.02313727f, 0.01556033f, 0.02872904f, 0.03398730f, 0.02305168f, 0.00476866f, -0.01388829f, 
    -0.00888866f, 0.00261609f, -0.00532083f, 0.00363079f, -0.02813538f, -0.03922600f, 0.01027861f, 0.02449870f, 
    0.01634587f, -0.01116445f, -0.00010968f, -0.00890540f, 0.02460997f, -0.01947854f, -0.01877576f, 0.01313755f, 
    0.01188736f, 0.02158486f, 0.01901050f, -0.01898373f, -0.02900844f, -0.01359851f, -0.00693910f, -0.02197992f, 
    0.01590590f, 0.01492190f, 0.01287055f, 0.02245962f, -0.03120943f, 0.02863404f, -0.00889725f, -0.02030128f, 
    -0.02641256f, 0.01703114f, -0.03918749f, -0.01332091f, -0.00670082f, 0.01707111f, -0.01670695f, 0.01265453f, 
    0.01617500f, 0.00322381f, 0.01248731f, -0.01250204f, 0.02086539f, -0.01627953f, -0.01393891f, -0.04356346f, 
    0.01088735f, 0.03055109f, -0.03943879f, -0.01013547f, -0.02239455f, -0.01881070f, 0.01999377f, -0.01181374f, 
    -0.00843878f, -0.00010336f, -0.03776404f, 0.00263052f, 0.02713087f, -0.03831322f, -0.01843860f, 0.02448330f, 
    0.01989399f, 0.01486500f, 0.02881468f, -0.02133089f, -0.02241002f, 0.03936769f, 0.02111268f, -0.02716860f, 
    -0.03252340f, -0.01139451f, 0.01404593f, 0.01212584f, -0.02302481f, -0.00268074f, 0.00447170f, 0.02662593f, 
    -0.00913267f, -0.00953426f, 0.00291153f, -0.03628708f, -0.02176404f, -0.02476920f, 0.02217237f, -0.01787906f, 
    0.02144860f, -0.03068659f, -0.01707924f, 0.00734738f, 0.02400553f, 0.01590200f, 0.02392687f, -0.03435344f, 
    0.02633740f, -0.00099548f, 0.01731409f, 0.00166007f, -0.01342830f, -0.01508790f, 0.01407936f, 0.01747147f, 
    0.02124013f, -0.00931204f, 0.02400871f, -0.02062042f, -0.01191220f, -0.02407110f, -0.00435033f, -0.01807310f, 
    0.01308670f, 0.02321302f, -0.02604670f, -0.00442765f, 0.00541213f, 0.01606183f, -0.04341823f, -0.02772544f, 
    0.00616966f, -0.02457413f, 0.02475246f, -0.03605684f, 0.01705540f, 0.03083164f, -0.04016338f, -0.01043928f, 
    0.00430336f, 0.02903063f, 0.02510928f, -0.01554475f, -0.03398428f, -0.02677276f, -0.00668596f, 0.00066907f, 
    -0.00326416f, -0.02240858f, 0.02657631f, -0.02184705f, 0.01458242f, 0.01145217f, 0.01255143f, -0.02847579f, 
    -0.00313027f, -0.00964366f, -0.01335640f, -0.00840749f, -0.03283499f, -0.03757310f, -0.01622305f, 0.00481934f, 
    -0.03271826f, -0.01507519f, 0.00793957f, 0.02179247f, -0.01678332f, -0.03663205f, 0.01777526f, -0.03302821f, 
    0.01334811f, -0.00579495f, -0.01648239f, 0.02852409f, -0.02769847f, -0.00198387f, 0.02823786f, -0.02463734f, 
    -0.03156372f, 0.00239756f, -0.01958305f, -0.00832367f, -0.02764598f, 0.02051666f, -0.03335853f, -0.03692711f, 
    -0.02854718f, -0.03154341f, -0.00783231f, 0.00948656f, -0.03812372f, -0.00932135f, 0.02776150f, -0.00499380f, 
    -0.03040611f, -0.01091527f, 0.02469852f, -0.02981048f, 0.03331111f, 0.00167110f, -0.01012835f, 0.01401248f, 
    -0.01486950f, 0.02594796f, 0.02894144f, -0.01571258f, 0.00241416f, -0.02077965f, -0.03494854f, 0.02568492f, 
    0.00718701f, 0.00088740f, -0.03944120f, -0.02206339f, -0.03814789f, -0.00819208f, 0.01198317f, -0.03989933f, 
    0.00692430f, 0.01426009f, -0.03184664f, -0.01984157f, -0.03101174f, 0.02709246f, -0.01732087f, 0.00322550f, 
    0.02969087f, -0.02919362f, -0.00236935f, -0.02432189f, 0.00920114f, 0.01687438f, 0.01509872f, 0.02965184f, 
    -0.02805044f, -0.03807190f, -0.03219515f, -0.01038737f, -0.01940441f, 0.00150574f, -0.00285792f, -0.01257878f, 
    -0.01487247f, -0.00551739f, -0.01789810f, -0.01421003f, -0.01295225f, -0.03817194f, 0.02774795f, -0.02957820f, 
    -0.01623950f, 0.01540286f, 0.01770366f, -0.02250749f, -0.01378042f, 0.01339498f, 0.02674558f, 0.02972566f, 
    0.01191382f, 0.00123786f, -0.02869760f, 0.00777818f, -0.00439170f, 0.01313595f, -0.00359690f, 0.00862674f, 
    -0.01442299f, -0.03453385f, -0.02882375f, -0.01048663f, -0.00844895f, -0.02168356f, -0.03284374f, -0.02106347f, 
    -0.01114708f, 0.01185438f, 0.02577783f, 0.00515188f, 0.00164269f, 0.00278326f, -0.01048828f, 0.02129842f, 
    0.02738364f, 0.02569455f, 0.02591369f, -0.00774460f, -0.00686055f, 0.01389544f, 0.00942822f, -0.03212987f, 
    0.02595766f, 0.00734390f, -0.02507426f, -0.04181517f, -0.01529955f, -0.00283025f, -0.02473537f, 0.00620555f, 
    -0.00920385f, -0.00667519f, 0.00181414f, -0.00221654f, -0.00104295f, -0.00209929f, 0.03654996f, -0.00203531f, 
    0.02499137f, -0.03686190f, -0.03382803f, -0.04032610f, -0.03588356f, 0.00044005f, -0.01884297f, -0.02417844f, 
    -0.02945979f, 0.01054165f, 0.00308832f, -0.03509356f, -0.00875078f, -0.03961611f, 0.02709177f, 0.01620609f, 
    -0.01589953f, -0.02250287f, 0.03900220f, -0.03457429f, 0.01045262f, 0.04287693f, -0.00809298f, -0.03311237f, 
    0.01570595f, -0.01474294f, -0.02814088f, -0.00953531f, -0.02903225f, 0.00603743f, -0.03014897f, 0.01822118f, 
    0.00500206f, 0.01183294f, -0.01730605f, -0.02625705f, 0.00293952f, -0.03390845f, 0.01534168f, 0.01449668f, 
    0.01096300f, -0.00371743f, -0.01782933f, -0.02785984f, 0.01096209f, 0.02736943f, 0.01305697f, 0.01870773f, 
    -0.03663938f, -0.03315841f, 0.01056191f, 0.00094645f, 0.01782433f, 0.00056227f, -0.02278837f, -0.02283482f, 
    0.04173890f, -0.00217796f, -0.00236545f, -0.02445159f, -0.00512143f, -0.01298791f, 0.01582847f, -0.00808059f, 
    0.01057490f, -0.01025863f, -0.03523881f, -0.02424811f, -0.02582283f, -0.01994851f, 0.01817725f, 0.01554349f, 
    0.01383327f, 0.00779244f, 0.01581835f, 0.00563905f, -0.01135282f, -0.03200636f, 0.02527614f, 0.02184234f, 
    -0.02791642f, 0.01899331f, -0.01750453f, 0.02778474f, -0.00130833f, 0.01866905f, -0.03615520f, 0.03061715f, 
    -0.03883045f, 0.01401622f, 0.00903472f, -0.02530436f, 0.01296552f, -0.02818548f, -0.02586870f, 0.01097490f, 
    -0.01557883f, -0.03405282f, 0.01833647f, -0.00278549f, 0.01475395f, 0.01596617f, -0.02183968f, -0.00204510f, 
    0.01936722f, -0.03156896f, -0.02489361f, 0.00776027f, -0.01247584f, -0.02374999f, 0.01877819f, -0.01245309f, 
    0.02625910f, 0.02115348f, -0.03157796f, 0.00753191f, -0.00440809f, 0.02223386f, -0.00120861f, -0.02694787f, 
    -0.03095578f, -0.01932402f, -0.02314600f, -0.00424682f, -0.02713242f, -0.02875504f, -0.01398250f, 0.02423017f, 
    -0.01184164f, -0.03434211f, -0.01210565f, -0.02421107f, 0.00587071f, 0.02570930f, 0.01225824f, 0.01508362f, 
    0.02390846f, -0.00633825f, 0.01731324f, 0.01653780f, 0.04098629f, -0.01193632f, -0.00793531f, 0.01383718f, 
    0.03113664f, -0.03354261f, -0.01731564f, 0.00577217f, -0.00450261f, 0.03655184f, 0.02142946f, 0.01874772f, 
    0.01631152f, 0.03162767f, 0.00828412f, -0.01332920f, -0.01367133f, -0.00676958f, -0.02266170f, 0.00748390f, 
    0.00857653f, 0.01273538f, 0.02919786f, -0.02901941f, -0.02813731f, -0.01152625f, 0.02042009f, -0.00911409f, 
    -0.00109239f, 0.02985925f, 0.00460677f, 0.00597796f, -0.02655644f, -0.01234291f, 0.00139537f, -0.02053504f, 
    0.03987563f, -0.02078682f, 0.00747693f, 0.00148088f, -0.02022933f, 0.02495011f, -0.02404417f, -0.00538439f, 
    0.00672521f, 0.02357388f, -0.01105303f, 0.00350595f, 0.00335254f, -0.01769730f, 0.01231963f, 0.02678034f, 
    -0.02779185f, 0.02717632f, -0.03672127f, 0.02029845f, 0.01990265f, -0.03679787f, -0.00823744f, 0.02284743f, 
    0.00907180f, -0.01994628f, 0.00685380f, -0.03351583f, -0.02715885f, 0.02725501f, -0.01152588f, -0.01364918f, 
    -0.03681087f, 0.01206203f, -0.03380222f, 0.01560111f, -0.00566347f, -0.00047621f, -0.02997538f, -0.02543451f, 
    -0.00296800f, 0.01031908f, 0.01235992f, -0.01219860f, 0.01817168f, -0.02786167f, 0.02776268f, -0.02179349f, 
    0.00832997f, -0.01202931f, -0.01422731f, -0.01092060f, 0.02999798f, -0.01888699f, -0.03674689f, -0.03018492f, 
    -0.01609260f, -0.02773517f, -0.00269047f, 0.01407180f, 0.01349030f, -0.01193831f, 0.00522315f, 0.01653528f, 
    0.01995587f, 0.03269481f, 0.01077135f, -0.00350132f, 0.01669539f, -0.03029107f, 0.01948643f, 0.01522510f, 
    -0.01772212f, -0.01149953f, -0.00941753f, -0.01371421f, 0.01351140f, 0.00317499f, 0.02277631f, -0.01065728f, 
    0.01894134f, 0.01056362f, 0.02625912f, -0.02957156f, 0.01991714f, -0.00075653f, 0.01153863f, -0.01558632f, 
    -0.03314773f, -0.02605765f, -0.01349148f, -0.00328385f, -0.02525480f, -0.02064018f, -0.03428625f, -0.03631451f, 
    -0.03111887f, 0.03085159f, -0.01163389f, -0.02176018f, 0.00714509f, 0.00425285f, -0.00471555f, 0.00984671f, 
    0.01455508f, 0.01197565f, -0.01843993f, -0.00045179f, -0.02591520f, -0.02603574f, -0.00986228f, 0.00158883f, 
    -0.00779691f, 0.02665861f, 0.02266541f, 0.01385507f, 0.01248954f, -0.00839899f, 0.02020833f, 0.00089103f, 
    0.01415896f, -0.03083294f, 0.03990205f, -0.00862634f, -0.01343094f, -0.01651744f, 0.01007864f, -0.02888387f, 
    0.02868244f, -0.01397961f, -0.00108647f, -0.02333901f, 0.01671113f, -0.00512999f, -0.01164143f, 0.00036273f, 
    -0.03571211f, -0.01090992f, -0.01174758f, 0.00426382f, 0.02949383f, 0.01725774f, -0.01904530f, 0.00692226f, 
    0.00792295f, -0.03822517f, 0.03482905f, -0.01326269f, -0.01597556f, 0.01759624f, 0.00294330f, -0.03776917f, 
    -0.03711894f, 0.03062918f, -0.03017800f, 0.00289614f, -0.03002285f, 0.02119673f, 0.00106647f, 0.01537863f, 
    -0.01290697f, 0.01705360f, 0.00768321f, -0.01969722f, -0.01426227f, 0.01979037f, 0.00538577f, 0.00971811f, 
    0.03226795f, 0.01852381f, 0.00756300f, 0.01204943f, 0.01794355f, -0.02953499f, 0.01287846f, 0.00786169f, 
    -0.01524098f, 0.01937144f, 0.02582920f, 0.01405083f, 0.03022117f, 0.01701106f, 0.00968476f, 0.01964017f, 
    0.01442517f, 0.03967210f, 0.00087496f, -0.00570927f, -0.02894377f, -0.03467723f, -0.02330753f, 0.01848568f, 
    -0.00543270f, 0.01902504f, -0.00839278f, 0.01371747f, 0.03395218f, -0.03183440f, 0.02840386f, -0.02658778f, 
    -0.03115292f, -0.02033266f, -0.01345403f, 0.01237711f, 0.00189398f, 0.02698131f, -0.03876712f, -0.03688698f, 
    -0.03614353f, -0.01640869f, -0.01895702f, -0.02220090f, 0.00031962f, 0.01338277f, -0.04015571f, -0.03492444f, 
    -0.00947909f, -0.00721518f, -0.00031234f, -0.01561709f, -0.01995161f, -0.00184725f, 0.01006398f, -0.00336873f, 
    0.00137989f, -0.00950608f, -0.03501573f, 0.00209591f, -0.00796759f, -0.01087978f, 0.01934191f, -0.03463272f, 
    0.00899541f, -0.01390988f, 0.00312903f, 0.00022481f, -0.03400652f, 0.00691431f, 0.01606887f, -0.01811020f, 
    -0.00296167f, -0.03074682f, -0.01607445f, -0.02256719f, -0.01799205f, 0.00906706f, 0.00717423f, 0.00001496f, 
    0.00201376f, 0.01866793f, -0.00219554f, -0.02437630f, -0.01051252f, -0.01194997f, 0.01893069f, -0.03964798f, 
    -0.00605945f, -0.01615584f, 0.00896493f, -0.01106428f, 0.00958689f, -0.02018883f, 0.00973807f, -0.00121038f, 
    0.00168902f, 0.00295375f, -0.03107744f, -0.00523840f, 0.00964851f, -0.02419129f, -0.02450112f, -0.04127723f, 
    0.00775729f, -0.00061892f, -0.03473501f, -0.03752924f, 0.00885818f, 0.00803452f, -0.01575990f, 0.01721551f, 
    -0.01314282f, 0.02763449f, -0.00961929f, 0.02391150f, 0.02792562f, 0.01648964f, 0.01964923f, 0.00733816f, 
    0.01138613f, 0.00615425f, -0.02325301f, 0.02745247f, 0.02340398f, -0.00189892f, -0.02484316f, -0.02771317f, 
    0.00195425f, -0.02348975f, -0.04021368f, -0.00175998f, -0.00261260f, 0.00930319f, -0.02387437f, 0.00811677f, 
    -0.01726723f, -0.03160520f, 0.02350362f, -0.00552145f, -0.03282005f, -0.01418267f, 0.03304822f, 0.01282664f, 
    -0.02364197f, 0.01672010f, -0.00471548f, -0.02152215f, 0.04060470f, -0.02102925f, 0.00983808f, -0.00909206f, 
    -0.00124400f, -0.01793629f, 0.01962367f, 0.03719649f, -0.02638217f, 0.01361414f, -0.02189677f, -0.03434879f, 
    0.04348204f, -0.02412226f, -0.03109457f, -0.03984352f, 0.00738679f, -0.01636066f, -0.00979974f, 0.01982956f, 
    -0.03335628f, 0.01383967f, -0.03681770f, 0.02696084f, -0.03850157f, -0.01370702f, -0.02608653f, -0.01386506f, 
    0.01390661f, -0.00848912f, -0.01636049f, -0.02502881f, 0.01060902f, -0.02047808f, -0.02291005f, -0.03078319f, 
    -0.01304710f, -0.03552387f, 0.02008279f, -0.00116455f, -0.02744360f, -0.01198409f, -0.00248667f, -0.00280287f, 
    -0.03354479f, -0.01538484f, 0.01255675f, -0.00713322f, -0.00728438f, 0.02329827f, 0.04327316f, -0.01636587f, 
    0.00184929f, -0.00353249f, 0.01392676f, -0.01246306f, 0.04175686f, -0.02797507f, -0.01719823f, 0.01082434f, 
    0.00130008f, -0.02018376f, 0.02306117f, 0.01557116f, -0.01971147f, -0.02284381f, 0.02830492f, -0.01838885f, 
    -0.02866980f, -0.00822346f, 0.00916635f, 0.00407799f, -0.03249179f, -0.03731964f, -0.00911197f, 0.02950265f, 
    0.00498476f, 0.00276128f, -0.01992975f, -0.00528933f, 0.03114467f, 0.01988270f, -0.02653933f, 0.02642565f, 
    -0.01709805f, 0.02291420f, 0.00746868f, -0.00030123f, -0.01948658f, 0.01458062f, -0.01719200f, 0.01308709f, 
    0.01389103f, 0.01410140f, -0.03026779f, -0.03959795f, -0.01681811f, 0.01595053f, -0.01626159f, -0.01138885f, 
    -0.01134881f, -0.03772413f, -0.03097424f, 0.02276850f, 0.02081087f, -0.03025638f, 0.00601964f, -0.03381112f, 
    -0.00063849f, -0.00552356f, -0.01350814f, -0.00795222f, -0.02308728f, -0.01643588f, -0.01548700f, 0.02136843f, 
    0.01783910f, -0.02234562f, 0.01896674f, 0.02185054f, 0.01387476f, -0.03515093f, 0.01505696f, -0.01312001f, 
    -0.01086789f, -0.00766205f, 0.03098059f, 0.00319796f, 0.01819630f, 0.01740271f, -0.01855181f, -0.00485139f, 
    0.02192250f, -0.01803564f, -0.02861867f, -0.01194413f, -0.00379516f, 0.03052601f, -0.01016483f, -0.03932320f, 
    -0.03449089f, -0.01802235f, -0.02416571f, -0.02968387f, -0.02355245f, 0.02342374f, 0.02306966f, 0.01926228f, 
    0.01566369f, 0.01971966f, 0.01701305f, 0.00810241f, 0.01837717f, 0.00308184f, 0.01487390f, -0.01740005f, 
    0.00829011f, 0.02858540f, 0.02463507f, 0.00719903f, -0.00058927f, -0.02132438f, -0.00914801f, -0.01927123f, 
    -0.40567255f, -0.04731860f, -0.09961209f, 0.08401751f, 0.07401101f, 0.09725790f, -0.09274555f, 0.04271025f, 
    0.10173815f, 0.00068362f, 0.06447211f, 0.06175565f, 0.03821497f, -0.20199229f, 0.12641242f, 0.27103749f, 
    0.00321654f, 0.10902568f, -0.04950636f, -0.03343704f, 0.00511583f, 0.02377071f, 0.05013981f, 0.14654399f, 
    -0.30210254f, -0.12889825f, -0.02881708f, -0.00683448f, 0.04490928f, 0.08394080f, 0.09253115f, -0.02527328f, 
    0.00067638f, 0.07670721f, 0.02774847f, 0.03681907f, -0.15944837f, 0.08039239f, 0.08256753f, 0.07251103f, 
    0.25022975f, 0.03172904f, 0.02556583f, 0.06181244f, -0.05092577f, 0.12050320f, 0.11457856f, -0.00696979f, 
    -0.15479201f, -0.30165911f, -0.09717996f, -0.21089375f, -0.00120012f, 0.23700863f, -0.03637980f, -0.20353720f, 
    0.06629859f, -0.04457518f, 0.12659438f, 0.10818519f, -0.25853699f, 0.12174678f, 0.01575596f, -0.00410751f, 
    0.10222223f, -0.02751481f, 0.12791291f, 0.10568140f, -0.00110176f, -0.04716983f, -0.00223256f, 0.01310640f, 
    -0.00493116f, 0.05661834f, 0.06514222f, -0.14641935f, 0.01892641f, -0.01168726f, 0.12455900f, 0.03362336f, 
    0.12228839f, 0.02064666f, 0.04824410f, -0.02499213f, 0.11103121f, 0.07238729f, -0.20082758f, -0.04765704f, 
    0.04095219f, -0.00340164f, -0.06910760f, 0.06683819f, -0.09964068f, 0.04922841f, 0.01901952f, 0.04818607f, 
    0.19681473f, 0.08049783f, -0.07267298f, -0.11233792f, -0.06667951f, 0.02724310f, 0.06731982f, 0.00285154f, 
    0.08539857f, -0.09480698f, 0.10484679f, 0.19977805f, 0.12721123f, 0.03499641f, -0.01819273f, -0.00875084f, 
    0.08394064f, -0.04996080f, 0.16832252f, 0.08983334f, 0.03454253f, 0.06480355f, -0.00627803f, 0.13467249f, 
    0.03667564f, 0.10718770f, 0.02924194f, 0.07010908f, -0.10806455f, 0.02471462f, 0.10554267f, -0.02596655f, 
    0.02509615f, 0.05611176f, 0.10648967f, 0.16177619f, 0.04631663f, 0.15355176f, -0.11186252f, -0.13543174f, 
    0.11197267f, -0.02464679f, 0.08342022f, 0.06993750f, 0.00276596f, 0.00280213f, 0.19251251f, 0.05145734f, 
    -0.33779424f, -0.17023657f, 0.05183589f, 0.01137140f, -0.03157217f, -0.01106623f, 0.10098570f, 0.06690564f, 
    0.03345851f, -0.05607699f, 0.06353003f, 0.07040808f, -0.00861758f, 0.02351458f, 0.01028330f, 0.04235988f, 
    -0.04344133f, 0.05122010f, 0.07817665f, 0.00815139f, 0.03149398f, 0.11934531f, 0.11399195f, 0.08801761f, 
    -0.17541368f, 0.18691798f, 0.01282029f, -0.15430082f, 0.12543413f, 0.04258833f, 0.00718407f, -0.03819719f, 
    0.10806421f, -0.01477679f, 0.02425641f, 0.06115986f, 0.12444379f, 0.03870308f, 0.11558028f, 0.07503808f, 
    0.11018154f, 0.00432593f, 0.03424647f, 0.04149310f, 0.09984756f, 0.00041498f, 0.07014279f, 0.04049170f, 
    -0.01762625f, 0.00445902f, 0.03364954f, 0.17262188f, -0.02302826f, 0.04918730f, -0.07241639f, -0.03276182f, 
    0.01256065f, -0.01217864f, -0.02949768f, -0.04301010f, 0.29868156f, 0.14999180f, -0.14265998f, 0.12964466f, 
    0.04011042f, 0.01322062f, 0.03862299f, -0.00369122f, 0.04653289f, 0.04601943f, 0.03105266f, 0.07874848f, 
    -0.20482999f, -0.12907180f, -0.11495438f, 0.03355081f, 0.11574208f, 0.04009818f, 0.07024428f, -0.03888587f, 
    0.03546047f, 0.10011139f, 0.05456208f, 0.02751157f, 0.29795146f, 0.02405890f, 0.03666501f, -0.20870285f, 
    0.01213477f, 0.00076625f, 0.00010685f, 0.01890234f, 0.05649104f, 0.00833022f, 0.06866580f, 0.05027047f, 
    0.11844424f, 0.09983644f, 0.12033077f, 0.14747772f, -0.16085663f, -0.07230986f, 0.12321716f, 0.01561244f, 
    0.03366447f, 0.04973791f, 0.08383881f, 0.02037288f, -0.09990278f, -0.06837669f, 0.16068429f, -0.13994542f, 
    0.18434161f, 0.05364264f, -0.02645871f, 0.04430236f, 0.05217268f, 0.02472748f, -0.01232919f, 0.02602465f, 
    -0.19913466f, -0.11609853f, -0.08605713f, -0.20030139f, 0.05190799f, 0.07426643f, 0.04025541f, 0.01826206f, 
    -0.00549704f, 0.10105895f, 0.04184366f, 0.06303963f, 0.03523715f, 0.07660218f, 0.17897239f, -0.14828096f, 
    -0.04697640f, -0.04815038f, 0.07868780f, -0.02948186f, 0.09165680f, 0.17409675f, 0.02745824f, 0.01363977f, 
    0.37778145f, -0.05474275f, 0.18660568f, 0.11122462f, 0.08871423f, -0.10473590f, 0.04398490f, 0.07763903f, 
    0.03193725f, 0.00042511f, -0.05512390f, 0.13633193f, 0.24752571f, -0.05241872f, -0.09905164f, 0.22450803f, 
    -0.08230303f, 0.04677677f, -0.01235541f, -0.03503536f, 0.04446338f, 0.01731323f, -0.04078060f, 0.01452239f, 
    0.15959336f, 0.18404484f, 0.11887281f, -0.39348844f, 0.05996532f, 0.03001692f, 0.03859514f, 0.03105362f, 
    0.10858154f, -0.06675243f, 0.01277226f, 0.01773444f, 0.22065337f, 0.05820448f, 0.05800302f, 0.14408305f, 
    0.05690601f, -0.03052188f, 0.08465943f, 0.07383296f, 0.07098304f, 0.12457707f, -0.04423564f, 0.02501697f, 
    0.06704460f, 0.20284727f, 0.16635382f, -0.07440605f, 0.01319057f, 0.05095720f, 0.06652219f, 0.04306198f, 
    0.21216643f, 0.13036790f, 0.13935381f, 0.10350756f, -0.03104603f, 0.16703428f, 0.01245270f, 0.27683756f, 
    0.04462906f, 0.12263346f, -0.06544911f, -0.00441531f, 0.09934440f, -0.02272684f, -0.00064170f, -0.00817803f, 
    0.15663119f, -0.16092898f, -0.07645796f, 0.31598899f, 0.05589582f, 0.04881656f, 0.08610354f, 0.04614487f, 
    0.08481703f, -0.06473895f, 0.04616458f, 0.04904854f, 0.07622591f, 0.18277393f, -0.06877080f, 0.17838141f, 
    0.03960513f, -0.07632433f, 0.06062040f, 0.00058279f, 0.12628876f, 0.05338864f, 0.00442520f, 0.03958081f, 
    0.14356451f, 0.10659231f, -0.14498383f, 0.22252998f, 0.03314732f, -0.03320706f, -0.12852688f, 0.07898211f, 
    0.04785487f, 0.00709784f, -0.00963273f, 0.00853051f, -0.21897128f, 0.01703068f, 0.02192909f, -0.02956216f, 
    0.18665753f, 0.01658101f, 0.08292555f, 0.03044587f, 0.05002873f, -0.00936210f, 0.15675013f, 0.05730648f, 
    0.10804775f, -0.04936785f, -0.02598126f, 0.07559714f, 0.04867225f, 0.03225579f, 0.06447475f, 0.10278996f, 
    0.00135577f, 0.04991154f, -0.02343656f, -0.02861469f, 0.33027428f, 0.13808547f, 0.09730770f, 0.23176804f, 
    -0.02583081f, 0.09544268f, -0.03135026f, 0.07165986f, -0.00304841f, 0.02615143f, 0.10287390f, -0.05717743f, 
    0.14769742f, 0.10899506f, 0.22006400f, -0.32374024f, 0.07729499f, 0.13785562f, 0.03705547f, 0.13573788f, 
    0.01026779f, 0.04452700f, 0.10600897f, 0.06995784f, -0.13776080f, -0.08457116f, 0.01065562f, -0.18803690f, 
    0.02484656f, -0.00477935f, 0.16305190f, -0.06202388f, 0.00869955f, 0.00836797f, 0.13481323f, -0.04688939f, 
    -0.16752140f, 0.26961687f, 0.20087671f, -0.18116175f, 0.10176101f, 0.08050900f, 0.05257518f, -0.02018262f, 
    0.02812690f, -0.00960770f, 0.02182277f, 0.05118490f, -0.01758841f, -0.05925201f, 0.02384811f, 0.20222715f, 
    -0.01423139f, 0.15612152f, 0.02290448f, 0.03408421f, -0.03598591f, 0.01010772f, -0.02748457f, 0.04710450f, 
    0.02083261f, -0.05828806f, 0.05211014f, -0.18163525f, 0.22090057f, 0.05010244f, 0.02194134f, 0.01066395f, 
    -0.02625478f, -0.04841368f, 0.09836254f, 0.02801601f, 0.18199623f, -0.03816881f, 0.03537193f, 0.00519896f, 
    0.04572250f, -0.07615954f, 0.07724308f, 0.07896961f, 0.04326378f, 0.11354519f, -0.03978350f, 0.09798649f, 
    -0.08448832f, -0.02810364f, 0.06864323f, -0.04165732f, 0.00770980f, 0.04621533f, -0.04925121f, 0.05604962f, 
    0.00805845f, -0.02715731f, 0.00430148f, 0.12038940f, -0.21742605f, -0.10922722f, -0.07359525f, 0.06923221f, 
    0.10141574f, 0.05998261f, 0.04585978f, -0.02056988f, 0.04114679f, 0.10323144f, -0.02344102f, -0.01614168f, 
    0.08252975f, 0.00380174f, 0.08074498f, -0.02776890f, 0.04436034f, 0.02088902f, 0.07938012f, 0.13462915f, 
    0.09079856f, 0.00448038f, 0.10782742f, 0.05728914f, -0.00039440f, 0.08983057f, -0.06054720f, 0.05330778f, 
    0.08421005f, 0.02474631f, 0.04670668f, 0.02795601f, -0.01179141f, -0.02008022f, 0.02905362f, 0.01282446f, 
    -0.33309668f, 0.16584931f, 0.12712739f, -0.10874876f, 0.06347706f, -0.02159958f, 0.16930050f, 0.09878450f, 
    0.06076835f, 0.00595446f, -0.08621258f, -0.00812479f, -0.26682931f, 0.03858088f, -0.03862921f, 0.26093236f, 
    0.17309219f, 0.17684078f, 0.03388673f, -0.08869139f, 0.12108393f, 0.04623624f, 0.06673145f, 0.24058123f, 
    0.08632855f, -0.01915943f, 0.23851633f, 0.28339079f, 0.02838021f, 0.08108224f, -0.00609979f, 0.05711689f, 
    -0.08530796f, -0.00627318f, -0.06405455f, 0.12575832f, -0.34402072f, -0.06424477f, 0.08444734f, -0.06039342f, 
    0.03111365f, 0.01013160f, 0.10161383f, 0.09853695f, -0.00985732f, -0.00095860f, -0.04639994f, 0.02103059f, 
    0.13299210f, 0.16676469f, 0.00888645f, -0.21531856f, 0.06241775f, 0.06205064f, 0.08370939f, 0.08059582f, 
    0.01019682f, -0.01156902f, -0.03604262f, 0.04860029f, -0.01057638f, 0.20641433f, 0.03721935f, 0.19098553f, 
    0.18664055f, 0.13834640f, -0.02776110f, 0.02917657f, 0.16016482f, 0.13065118f, 0.13901144f, -0.03803314f, 
    -0.06680781f, -0.10378893f, -0.21705513f, 0.09083144f, -0.08280347f, 0.10780882f, 0.07452930f, 0.00579512f, 
    0.08564135f, 0.03425221f, -0.04146645f, 0.03002400f, -0.26229978f, 0.07205208f, 0.00965392f, -0.14559777f, 
    0.05261471f, 0.08170497f, 0.09330011f, -0.00017418f, 0.10963986f, 0.07182470f, 0.09766223f, -0.03286090f, 
    0.05928030f, -0.04005566f, 0.07989702f, 0.24772733f, 0.04210409f, -0.01429129f, 0.12968701f, 0.01619333f, 
    0.02707743f, -0.02379998f, -0.06007978f, -0.05309188f, -0.24142008f, -0.01012966f, 0.01863609f, -0.00130977f, 
    0.14744586f, 0.04794506f, 0.06661428f, 0.13442923f, 0.04328217f, -0.01514226f, -0.05507329f, 0.01758064f, 
    0.07785273f, -0.03069820f, 0.01190642f, 0.16638945f, 0.03433534f, -0.00601982f, 0.08807952f, -0.05094580f, 
    0.02046085f, -0.04805062f, 0.05470864f, 0.11726552f, -0.06035689f, 0.01532839f, 0.00095610f, 0.15092525f, 
    0.16610050f, 0.04853503f, -0.02501316f, -0.03584199f, 0.09723174f, 0.05372815f, -0.00111823f, 0.04008634f, 
    -0.12154173f, 0.02830233f, 0.04623794f, 0.22326188f, -0.03022964f, 0.05179446f, 0.08975957f, 0.01331736f, 
    0.10672794f, 0.13256799f, 0.03317800f, 0.00436235f, -0.15240186f, 0.11812812f, -0.16960983f, 0.00465840f, 
    -0.00356595f, 0.14134815f, 0.05132880f, -0.00458754f, -0.01315140f, 0.07046179f, 0.10432870f, 0.03652851f, 
    0.03139209f, 0.10060902f, 0.12902249f, -0.16935304f, 0.09891725f, 0.06666303f, 0.03227739f, 0.02454576f, 
    0.09154744f, 0.05035659f, 0.01924083f, -0.00841000f, 0.18010573f, -0.16959195f, 0.06170274f, 0.28148782f, 
    -0.05604818f, 0.11421072f, -0.05534320f, 0.12327518f, -0.01840894f, 0.02483075f, 0.08649707f, 0.07558425f, 
    0.16638888f, 0.19058393f, 0.11158279f, 0.12883349f, 0.11474120f, 0.08504013f, 0.06363636f, 0.11242129f, 
    0.03411221f, 0.01585454f, 0.13501772f, 0.00906023f, 0.22507346f, 0.06695662f, 0.07135431f, -0.05779674f, 
    0.03273391f, 0.05868207f, 0.06838708f, 0.05391529f, 0.01497675f, -0.03980195f, 0.07128587f, -0.02202590f, 
    0.08329695f, 0.12938426f, -0.05477133f, -0.04832450f, 0.00869192f, 0.02815578f, 0.04290700f, 0.13129899f, 
    -0.03943140f, 0.01518778f, 0.07157766f, -0.06643027f, -0.19616020f, -0.14637177f, -0.04518661f, -0.18576518f, 
    0.01141361f, 0.00957487f, 0.00640978f, 0.02938505f, 0.02122429f, -0.00942091f, 0.00441314f, 0.00470808f, 
    -0.02284823f, -0.22542022f, 0.01228788f, 0.16618332f, -0.01826748f, 0.07923800f, -0.02769021f, 0.15131640f, 
    0.10138611f, -0.00373316f, 0.11606317f, 0.03660830f, 0.06426971f, -0.12824731f, -0.20399576f, -0.09413767f, 
    -0.10753180f, -0.05138744f, 0.13095185f, 0.11190839f, 0.02347555f, -0.12760325f, 0.07854446f, 0.05953651f, 
    -0.11835787f, -0.08030377f, 0.04367445f, 0.01489391f, 0.03114700f, -0.03096260f, -0.09355666f, 0.04696489f, 
    -0.01016332f, 0.07873216f, -0.00257808f, -0.00449636f, 0.20749848f, 0.01250464f, -0.11959846f, -0.01354582f, 
    0.03220488f, 0.03211216f, -0.00864877f, 0.08619253f, 0.06700884f, 0.10939550f, 0.11723244f, -0.07760580f, 
    -0.10675309f, -0.05727123f, 0.10195519f, -0.10195017f, 0.03766135f, 0.06324166f, 0.08068614f, -0.01480241f, 
    0.03493294f, 0.03279300f, 0.00025564f, 0.04091366f, -0.16218804f, -0.03705805f, 0.05063899f, 0.02827013f, 
    -0.03017395f, 0.02139038f, 0.01393607f, -0.02035935f, 0.12513903f, 0.01320169f, 0.04562948f, 0.13112146f, 
    -0.24301273f, 0.23505437f, 0.10596120f, 0.03218820f, 0.04035852f, 0.02516853f, 0.17548540f, -0.06275385f, 
    -0.08287648f, 0.14357048f, 0.00712406f, 0.08473289f, -0.20218480f, 0.07724272f, 0.18164235f, -0.15737922f, 
    -0.03602020f, 0.08707900f, 0.02427821f, 0.04550596f, 0.06653804f, 0.02304646f, -0.04704695f, -0.04884788f, 
    0.00096019f, -0.03828985f, 0.00962293f, 0.14015821f, 0.15481122f, 0.00260060f, 0.03712147f, -0.00657944f, 
    -0.04477161f, 0.01500439f, -0.01287022f, -0.01196119f, 0.20387846f, 0.00491732f, 0.02799700f, -0.12513559f, 
    0.00740700f, 0.07377612f, 0.12642068f, 0.00432932f, 0.02243692f, -0.02631602f, -0.01384735f, -0.01321541f, 
    0.25007048f, -0.11655041f, 0.04153735f, 0.04674824f, 0.02161145f, 0.11438206f, 0.11828161f, -0.07151911f, 
    -0.02380826f, -0.03598939f, -0.00210139f, 0.04181545f, 0.01595714f, -0.13571952f, 0.02845362f, -0.04213819f, 
    0.06990714f, 0.00223002f, -0.01779268f, -0.03578309f, -0.01660361f, 0.02171049f, 0.04815492f, -0.03757944f, 
    0.01781036f, 0.06768899f, 0.18821536f, 0.09306430f, 0.07162240f, -0.02962519f, 0.08209951f, 0.00644626f, 
    -0.05793748f, 0.00048480f, -0.02007493f, 0.03825286f, -0.01461846f, 0.02113541f, -0.08982891f, -0.13157444f, 
    -0.05078440f, 0.12434493f, 0.06188188f, -0.03138455f, 0.02564271f, 0.01262797f, -0.03730331f, 0.02665366f, 
    -0.10546161f, 0.00617067f, 0.02937806f, 0.12766726f, -0.01927601f, -0.01230639f, 0.04387734f, 0.04153170f, 
    -0.01250898f, 0.07445226f, 0.02313048f, -0.03315341f, -0.24253169f, -0.19730259f, 0.00956688f, -0.13005069f, 
    0.02875605f, 0.06586885f, -0.00437257f, 0.13783742f, -0.03123659f, -0.05569933f, -0.02992880f, -0.00572460f, 
    -0.18257368f, -0.22165768f, -0.00268965f, 0.14514343f, 0.01709515f, 0.03277590f, -0.03988488f, 0.02175185f, 
    0.01502507f, 0.00460112f, 0.00619713f, 0.07722562f, -0.11833976f, 0.14020893f, 0.13177048f, 0.02500285f, 
    0.14023367f, 0.16778982f, -0.01206652f, -0.01030109f, 0.01595497f, 0.04377574f, 0.08413510f, 0.03510303f, 
    0.18843488f, -0.13791554f, -0.03917386f, -0.03717584f, 0.10544755f, -0.00361922f, -0.01272365f, -0.03577714f, 
    -0.00947122f, 0.15458679f, 0.01009434f, -0.04092498f, 0.29057309f, 0.11529055f, 0.13650224f, 0.17311625f, 
    0.03690306f, 0.06460765f, 0.01106295f, 0.02808201f, -0.00408519f, 0.04791109f, 0.04100991f, -0.01327438f, 
    0.04682915f, -0.26605487f, 0.02166628f, 0.12172028f, -0.01059182f, 0.01105846f, -0.05445770f, 0.00099659f, 
    0.07910457f, -0.03162383f, 0.02922514f, 0.01498997f, -0.06188293f, -0.16636941f, 0.00291095f, 0.00151452f, 
    -0.07966038f, 0.01802878f, -0.03459435f, -0.00918203f, -0.01946153f, 0.00115321f, 0.05222282f, 0.07195849f, 
    0.09849288f, -0.04852296f, 0.04015328f, -0.17359079f, -0.03835006f, 0.02417792f, 0.01443151f, 0.00120631f, 
    -0.01925585f, 0.01929076f, 0.11142040f, 0.00286094f, -0.30163950f, 0.08787841f, 0.04579385f, -0.08807375f, 
    0.02534008f, 0.02767091f, 0.00953490f, 0.01421306f, 0.16171141f, -0.02690362f, 0.07456949f, 0.01617170f, 
    -0.23209150f, 0.12625571f, 0.13844517f, 0.06040701f, 0.03291397f, 0.02784131f, 0.02354377f, 0.04523253f, 
    -0.00266457f, 0.04806092f, 0.04919866f, 0.06968305f, 0.22641420f, 0.03114673f, -0.02945945f, 0.13765970f, 
    0.00263318f, -0.08444274f, 0.09226342f, 0.02244469f, 0.04643433f, 0.05806213f, 0.04578950f, 0.04038988f, 
    0.07127758f, -0.17634118f, 0.00508553f, 0.05779485f, -0.00515415f, 0.12364021f, -0.04616693f, -0.00458478f, 
    -0.00011304f, -0.02627946f, -0.00168561f, 0.01343754f, -0.02626928f, -0.11004972f, -0.00258622f, 0.02402900f, 
    0.05117582f, -0.01989170f, 0.07294250f, 0.07643519f, 0.07182870f, -0.04667146f, 0.07874848f, -0.08907874f, 
    0.09790694f, -0.16303310f, -0.12880911f, -0.13826358f, 0.09520287f, -0.07611149f, 0.00538736f, -0.03194504f, 
    -0.03617892f, 0.15036136f, 0.17689647f, -0.02651707f, -0.20393749f, -0.16813439f, -0.13414443f, -0.22876088f, 
    0.00019543f, 0.10944726f, 0.08993885f, -0.02292510f, 0.01038825f, 0.04612152f, 0.06329688f, -0.05130833f, 
    -0.13287441f, -0.02086535f, 0.07591202f, -0.14375316f, -0.02762242f, -0.02958184f, 0.10010679f, 0.02432327f, 
    0.10458984f, 0.06799510f, 0.02567535f, 0.10716853f, 0.14557050f, -0.18137300f, -0.21695559f, -0.03116567f, 
    -0.01344336f, -0.08272047f, 0.06620347f, 0.01297930f, -0.02742017f, 0.06282773f, -0.04297493f, 0.00140521f, 
    -0.18226455f, -0.06390876f, -0.08995363f, -0.06988914f, -0.00002165f, -0.04421641f, -0.03873806f, 0.00069929f, 
    0.13495784f, -0.03919979f, -0.01580547f, 0.04109070f, -0.16219819f, -0.04614193f, 0.17551509f, 0.15269640f, 
    0.19147365f, 0.05897780f, -0.04092430f, 0.03716931f, 0.06439480f, 0.03570996f, 0.06940816f, 0.06706870f, 
    0.03328269f, -0.00151007f, 0.17545539f, -0.14443433f, 0.05046732f, -0.06564578f, -0.08292818f, -0.04863898f, 
    -0.00151087f, 0.10641959f, 0.07618289f, -0.04188603f, 0.01354690f, -0.10703214f, 0.08664708f, 0.14420652f, 
    -0.02874042f, -0.03554039f, -0.12688696f, 0.07507399f, 0.12323342f, -0.02567741f, -0.03619939f, 0.15314016f, 
    -0.00635380f, 0.10521787f, 0.03408020f, -0.07363694f, 0.02890623f, 0.10765487f, 0.00123615f, 0.09371412f, 
    0.05863929f, -0.00245209f, 0.05471478f, 0.04569170f, -0.22228901f, -0.05996125f, -0.03215623f, -0.12848978f, 
    -0.00231394f, 0.05099415f, 0.07053570f, 0.06603298f, 0.05675290f, -0.01384138f, 0.00574361f, 0.09610201f, 
    -0.07572468f, 0.21368711f, -0.00416178f, -0.07257891f, 0.05389335f, -0.07463031f, -0.08809085f, 0.05203104f, 
    -0.04002117f, 0.08430541f, 0.01701652f, 0.06743175f, 0.15974988f, 0.10473214f, 0.06807557f, 0.04775119f, 
    0.00354460f, 0.07160213f, -0.07245516f, 0.01735939f, 0.03208910f, -0.01577535f, 0.08106355f, -0.08425881f, 
    0.27552104f, 0.20562071f, 0.08178106f, 0.09656309f, 0.04262041f, 0.01027082f, -0.01559545f, -0.00823579f, 
    0.02191817f, -0.00103911f, 0.05255309f, -0.01612159f, -0.00053309f, -0.02804700f, -0.03501857f, 0.10701240f, 
    -0.05389677f, -0.06601360f, -0.00852544f, 0.07679540f, -0.00431587f, 0.02654892f, 0.08434875f, 0.01505752f, 
    0.28226009f, -0.05018512f, -0.00579178f, -0.06498204f, 0.06490449f, -0.03206998f, -0.04760072f, -0.00472248f, 
    0.00027081f, 0.08113459f, 0.06321382f, 0.02725857f, -0.13482577f, 0.21574092f, -0.04281651f, -0.20383936f, 
    -0.02262326f, -0.00735103f, -0.01950338f, -0.04627567f, 0.06418191f, -0.01727656f, 0.03200806f, 0.00580564f, 
    0.33193237f, -0.03868157f, 0.00603956f, 0.02153194f, 0.02065511f, 0.03298339f, -0.02225119f, 0.12870426f, 
    0.04150395f, 0.07296512f, 0.11542783f, -0.02727503f, 0.23076116f, 0.08486337f, -0.11251813f, 0.24856506f, 
    0.06818993f, -0.10517798f, -0.08045768f, 0.08442859f, 0.11257875f, 0.04687838f, 0.03705291f, -0.00558945f, 
    -0.43082196f, -0.18011430f, 0.06268053f, -0.01932286f, 0.01266789f, 0.00671721f, -0.02836839f, 0.11758266f, 
    0.05997480f, 0.12191681f, -0.05558884f, 0.03897070f, 0.10677954f, 0.22548261f, 0.21957409f, 0.13568097f, 
    0.01338729f, 0.04972195f, -0.01168189f, -0.06189336f, 0.07633621f, -0.03911389f, -0.01799796f, 0.05763333f, 
    -0.04534468f, 0.19847369f, 0.18169305f, -0.03731967f, 0.09127253f, -0.06545545f, -0.06403648f, 0.09314787f, 
    0.02981314f, -0.00732044f, 0.01785391f, -0.07570730f, 0.20031510f, 0.18681625f, -0.01566992f, 0.00193660f, 
    0.08430678f, 0.03455101f, 0.04560152f, 0.03116910f, -0.00673312f, -0.06043960f, 0.01323748f, 0.04325773f, 
    -0.13368590f, -0.05972042f, 0.10672811f, -0.01397599f, -0.02566491f, 0.00485025f, 0.05587702f, -0.03240693f, 
    -0.03226723f, 0.00544895f, 0.10618713f, 0.13733546f, -0.14676167f, -0.12007177f, 0.09069213f, 0.04881454f, 
    -0.03536682f, 0.11208236f, 0.05340036f, 0.06740781f, 0.01439918f, 0.06059759f, -0.02024485f, 0.00137937f, 
    0.04391782f, 0.00145966f, -0.10201672f, -0.08378400f, 0.06608560f, 0.05579182f, -0.08216812f, -0.07888575f, 
    0.03768114f, 0.06018006f, 0.07994055f, 0.03203771f, 0.31663337f, -0.10219046f, -0.07646008f, -0.02365444f, 
    -0.06694082f, -0.02522298f, 0.03691752f, -0.07656548f, -0.03563532f, 0.05535387f, 0.10675941f, 0.04811336f, 
    0.00971882f, -0.14592807f, -0.03670204f, -0.08695291f, -0.02547931f, -0.03091712f, 0.01372167f, 0.05980906f, 
    0.01751295f, 0.05508037f, -0.06930061f, 0.05842107f, 0.11936273f, 0.07435680f, -0.05175911f, 0.00949503f, 
    0.01849630f, 0.03590735f, 0.04989770f, -0.10357630f, -0.01305578f, -0.03779043f, -0.08151952f, 0.16808508f, 
    0.12758271f, 0.21458682f, 0.06457391f, 0.15091111f, 0.05647102f, -0.05987779f, -0.00420654f, 0.06121325f, 
    0.01963362f, -0.00229620f, -0.00615475f, 0.00701799f, 0.04152577f, -0.24610692f, 0.02389656f, -0.00041296f, 
    -0.04932213f, -0.07167562f, 0.15781172f, -0.02997325f, -0.04067153f, -0.03006981f, 0.05501644f, 0.16808787f, 
    0.00259539f, 0.22816698f, 0.05292427f, 0.07613037f, 0.12377986f, -0.02881632f, 0.00332762f, -0.00696279f, 
    0.05900751f, 0.15245129f, 0.02706336f, 0.14811794f, 0.02637547f, -0.13453777f, -0.19019681f, -0.14162359f, 
    0.00288918f, -0.03148083f, 0.07139281f, -0.08729678f, -0.03161228f, 0.09025290f, 0.02263586f, 0.03902281f, 
    -0.24141103f, -0.03166674f, 0.04963757f, -0.10508475f, 0.02727377f, -0.04987182f, 0.02295969f, 0.03031688f, 
    0.06010252f, 0.02214477f, 0.04655371f, 0.02139665f, -0.01103312f, 0.20537628f, 0.14986016f, 0.00633437f, 
    0.15278971f, 0.15269363f, 0.02020115f, -0.05286350f, 0.00640559f, 0.02157988f, 0.03235318f, -0.02865375f, 
    0.02837725f, -0.00495189f, -0.01182542f, 0.01505851f, 0.00077234f, 0.00279429f, 0.02271948f, -0.00630913f, 
    -0.01336823f, 0.02395346f, -0.00744127f, -0.01991411f, -0.03501086f, 0.02364232f, -0.03620204f, 0.01786057f, 
    0.00098177f, -0.01039058f, 0.01947639f, -0.00851316f, -0.03424546f, 0.01640114f, -0.00701563f, -0.03415366f, 
    0.02298802f, -0.00771153f, -0.02312179f, -0.02580754f, 0.00071304f, -0.00638090f, -0.02628716f, -0.03890876f, 
    0.02670900f, 0.02232579f, -0.04084109f, -0.01325234f, -0.03319633f, 0.00629764f, -0.01825272f, -0.02444632f, 
    0.01580429f, -0.02498716f, -0.01662376f, -0.02612721f, 0.02547368f, 0.02256878f, -0.03079301f, -0.03165899f, 
    -0.02600630f, 0.01743960f, 0.02483503f, 0.00837275f, 0.00685366f, -0.04135732f, 0.00952351f, 0.01400469f, 
    -0.02493995f, -0.02079334f, -0.03482787f, -0.00412414f, -0.02303749f, 0.00797660f, 0.01315733f, -0.00796472f, 
    0.00273107f, 0.01854064f, 0.00948494f, 0.00106303f, 0.02214397f, 0.00362874f, -0.00850104f, 0.01818287f, 
    0.01458658f, -0.02658825f, -0.01950477f, 0.00607238f, -0.02302811f, 0.02449627f, 0.00735765f, -0.03051386f, 
    0.02831984f, 0.00798751f, -0.03491799f, 0.02688516f, -0.03889951f, -0.02129615f, 0.01323590f, -0.00709952f, 
    -0.00660350f, 0.00786810f, -0.01134562f, -0.02301500f, 0.02360136f, -0.00306600f, -0.00381201f, -0.02646687f, 
    0.02960582f, 0.00235860f, 0.02320947f, 0.02063250f, -0.03097297f, 0.00715247f, -0.03325703f, 0.01775418f, 
    -0.00535350f, -0.01367310f, -0.02052302f, -0.01891764f, 0.00750034f, 0.00181874f, -0.04030188f, -0.00162216f, 
    -0.00589918f, 0.01417723f, -0.02771000f, 0.02836671f, 0.00810777f, -0.02075595f, -0.01352637f, -0.02774189f, 
    0.00464176f, -0.00268639f, 0.00806292f, -0.01664098f, 0.02857277f, 0.00507453f, -0.01010508f, -0.01784035f, 
    -0.02853557f, -0.02100476f, -0.01768911f, 0.02637359f, 0.02033255f, -0.03321749f, -0.02390522f, -0.00949919f, 
    -0.01575106f, 0.01252654f, -0.01310772f, -0.01378306f, 0.01778726f, -0.03482776f, 0.02769466f, -0.01632831f, 
    -0.02998809f, -0.03813716f, -0.02229341f, -0.00177015f, 0.02563222f, 0.00874952f, 0.02937940f, 0.00652122f, 
    -0.01809289f, -0.02072204f, 0.02556375f, 0.00478897f, -0.02485299f, 0.00811214f, -0.01731856f, 0.00962273f, 
    -0.02147918f, -0.00953163f, 0.00819509f, -0.03869963f, -0.02448583f, 0.00179864f, -0.00012979f, -0.02264646f, 
    -0.00417419f, 0.01213168f, 0.00721186f, -0.03630554f, -0.01509701f, -0.01106986f, 0.01912048f, -0.02402954f, 
    -0.02590408f, -0.03038819f, -0.00121829f, 0.01738880f, -0.02877619f, 0.02328340f, -0.01087385f, 0.02475563f, 
    -0.01852967f, -0.03901615f, -0.00474293f, -0.02040564f, -0.00680778f, -0.00277664f, 0.00569722f, -0.01176615f, 
    0.00278460f, 0.00258139f, -0.01962574f, 0.01137379f, -0.03017382f, 0.02033564f, 0.01251948f, -0.02875650f, 
    0.02392635f, -0.03759815f, -0.02606405f, 0.02371140f, 0.03552845f, 0.00535886f, 0.02346953f, -0.03089182f, 
    0.02433968f, 0.00689898f, 0.02873788f, 0.02636430f, -0.01603571f, 0.01860748f, -0.03206517f, -0.01737050f, 
    -0.03713110f, -0.02944198f, -0.02822497f, 0.00990959f, -0.01481451f, -0.04061574f, 0.02407537f, -0.01002884f, 
    -0.04078294f, -0.04022698f, -0.02080100f, -0.00612436f, -0.03224165f, -0.01743063f, 0.00386577f, -0.03806832f, 
    -0.02966481f, 0.02528146f, 0.01664807f, 0.02258378f, -0.02223864f, 0.01361998f, 0.00768192f, -0.00350295f, 
    0.01469413f, -0.03894373f, -0.01838451f, 0.00539433f, -0.01185164f, 0.01985903f, 0.02066671f, -0.03964440f, 
    0.02865892f, 0.02674346f, 0.01406940f, 0.01089159f, -0.00270602f, -0.00578412f, 0.01180604f, -0.03978465f, 
    -0.02046774f, -0.04061867f, -0.02529090f, -0.00035400f, -0.01483095f, -0.01895245f, -0.01832566f, 0.00503517f, 
    0.00438772f, 0.01754002f, -0.03697803f, 0.00012402f, -0.01926043f, -0.03782694f, -0.03671997f, 0.02460678f, 
    0.02386745f, -0.03195587f, -0.01396144f, -0.00259787f, 0.00334306f, -0.00427538f, -0.02662585f, 0.02266277f, 
    -0.03297404f, 0.01455263f, -0.03831970f, 0.00823615f, -0.02119457f, -0.03004708f, 0.02823220f, -0.00138410f, 
    0.01404352f, -0.03532000f, 0.01524787f, -0.03015462f, -0.02832376f, -0.03948708f, -0.00574491f, 0.02208016f, 
    0.00053011f, 0.02759497f, 0.01977212f, -0.01117530f, 0.00318835f, -0.01117316f, 0.02915532f, 0.01020096f, 
    -0.00254738f, 0.01736540f, -0.02826660f, 0.02452684f, -0.03974431f, 0.01766010f, -0.03072936f, -0.01668072f, 
    -0.04006282f, 0.02294637f, -0.02074898f, -0.00048256f, -0.02956392f, 0.00823146f, -0.00862449f, 0.00413049f, 
    -0.03133110f, 0.00006237f, -0.01049358f, -0.03083485f, -0.02507015f, -0.02612475f, 0.01206371f, -0.01741079f, 
    -0.01587294f, -0.02188018f, 0.01842074f, -0.03210074f, -0.01386159f, 0.00258742f, -0.02331638f, -0.02635901f, 
    -0.00251954f, 0.02623627f, -0.00324621f, 0.02910844f, -0.03293788f, 0.00271398f, -0.01050903f, -0.03613494f, 
    0.00990484f, 0.01085256f, 0.02559919f, 0.00388608f, -0.02019972f, -0.01810690f, 0.01144034f, -0.00698961f, 
    -0.00692311f, -0.00863224f, 0.00541101f, -0.01120248f, -0.02281743f, 0.02173137f, -0.00755818f, -0.02751429f, 
    -0.03194578f, 0.01498135f, 0.00642537f, -0.02456449f, -0.01442905f, -0.00545081f, -0.00770718f, 0.02822000f, 
    0.01715262f, -0.02354536f, -0.00023647f, 0.00081406f, -0.00349967f, 0.01160579f, -0.00324968f, 0.00303635f, 
    -0.03063025f, 0.02288718f, -0.00504244f, -0.02492351f, -0.02329529f, -0.03278099f, -0.00024389f, -0.02578136f, 
    0.02491934f, -0.03886438f, 0.01003306f, -0.04260410f, -0.00157724f, -0.04120300f, -0.01928040f, -0.02204195f, 
    0.01007633f, -0.02308016f, -0.03812886f, -0.03165849f, -0.02283756f, -0.00190477f, 0.00621120f, -0.00299832f, 
    0.00863360f, -0.04074358f, 0.02411588f, -0.04116506f, 0.00712756f, 0.02627554f, -0.01725941f, -0.00537171f, 
    0.02837988f, 0.01330782f, -0.02660033f, -0.03255821f, -0.00210495f, -0.01139521f, 0.02616562f, 0.02448025f, 
    -0.03244198f, -0.00150170f, -0.01157647f, -0.00737788f, -0.01520496f, -0.03433710f, -0.00332744f, -0.04207369f, 
    -0.01912317f, -0.04212935f, -0.00470145f, 0.02726659f, -0.00962410f, -0.01381216f, 0.01723416f, -0.03003486f, 
    -0.03769067f, 0.00286684f, 0.00296660f, -0.00031268f, -0.02431485f, -0.03040541f, -0.01441472f, -0.00694561f, 
    -0.02915595f, 0.02710597f, 0.01534984f, -0.00218162f, 0.00650428f, -0.01332830f, -0.01751225f, 0.00756379f, 
    0.01959275f, 0.02744090f, 0.02501244f, -0.02068074f, -0.00007211f, -0.00962759f, -0.01592137f, -0.01061208f, 
    0.00107392f, -0.03377283f, -0.00071059f, 0.01721733f, 0.02350636f, 0.02764972f, 0.01399818f, 0.00264087f, 
    0.00284201f, -0.01156206f, -0.02609015f, -0.01498761f, 0.02787687f, -0.03746297f, 0.02215004f, 0.02415174f, 
    0.01121693f, 0.02066356f, -0.01456646f, -0.00403058f, -0.04099101f, -0.00343973f, 0.00918028f, 0.01808919f, 
    -0.01824545f, 0.00802918f, 0.01839538f, -0.02527293f, 0.01519790f, 0.01809253f, -0.03685731f, -0.01733268f, 
    -0.01727675f, 0.02601529f, -0.02582678f, -0.03529169f, -0.04047872f, 0.01602670f, 0.00654449f, -0.02725871f, 
    0.00887615f, -0.03630059f, -0.00214149f, -0.03673332f, 0.00040223f, -0.00849197f, -0.00219543f, -0.01765703f, 
    0.02136203f, 0.02302978f, -0.03731026f, 0.01120187f, 0.01570018f, 0.00061347f, 0.01568737f, -0.03833536f, 
    -0.03698138f, 0.01324312f, 0.02334359f, 0.02034370f, 0.02260533f, 0.01084218f, 0.02628299f, -0.00434199f, 
    -0.03092985f, 0.00066198f, 0.02637197f, -0.03275234f, 0.01276100f, -0.02838410f, 0.00461904f, -0.02018129f, 
    -0.02692821f, 0.02747451f, 0.02130456f, -0.01572170f, -0.04059336f, -0.02072493f, 0.02642604f, -0.00866500f, 
    -0.03814172f, 0.01438014f, 0.02791777f, -0.03586863f, -0.03450041f, -0.03051058f, 0.02687305f, -0.02171308f, 
    0.02195786f, 0.02645799f, -0.03418887f, 0.00899290f, 0.00793821f, -0.02070587f, -0.03369940f, -0.00473996f, 
    0.02898316f, -0.01642608f, -0.00007150f, -0.01117650f, 0.02171652f, 0.02861267f, 0.01997145f, -0.02741733f, 
    -0.00474035f, 0.00629041f, 0.00952598f, -0.01910039f, -0.00484593f, -0.02376104f, 0.00126565f, -0.03888598f, 
    -0.00743041f, 0.00507836f, 0.00629701f, -0.00968841f, -0.04110815f, -0.02281173f, 0.00151912f, -0.03057777f, 
    0.01684889f, -0.02680379f, -0.03547619f, 0.02189074f, 0.01555482f, -0.01326277f, -0.01258655f, -0.01734128f, 
    -0.02337215f, -0.02116367f, 0.00564004f, -0.00335677f, 0.00819083f, -0.02159587f, -0.03912143f, -0.03423367f, 
    0.00849098f, -0.04256884f, 0.02541903f, 0.02291051f, 0.02300132f, -0.01756338f, 0.01773965f, -0.01575199f, 
    0.02416538f, -0.04222303f, 0.02155844f, -0.01860249f, 0.00659967f, -0.02463676f, 0.02291814f, -0.00207839f, 
    -0.00140013f, -0.03372411f, 0.00016581f, -0.03713869f, 0.01146216f, -0.01143919f, -0.03828038f, -0.01567356f, 
    -0.02581170f, -0.02783187f, -0.00279914f, 0.01412412f, -0.03700678f, -0.03916119f, -0.00083831f, -0.04166664f, 
    0.01836307f, -0.00010226f, -0.01023937f, -0.01939516f, -0.01589691f, -0.02114569f, 0.02517401f, -0.01249645f, 
    0.01841580f, -0.02453399f, -0.03364681f, 0.02179192f, -0.01965303f, 0.02654172f, -0.01985344f, -0.03300498f, 
    -0.01105047f, -0.02587005f, 0.01702831f, 0.02768113f, 0.02533623f, 0.02447938f, 0.00346469f, 0.01416524f, 
    -0.02392056f, 0.00583611f, -0.03590325f, -0.01699583f, 0.00851398f, -0.00419919f, -0.03097484f, -0.00697141f, 
    -0.03008189f, -0.03718506f, 0.02392971f, -0.03176774f, 0.00034568f, 0.02936585f, 0.02310480f, -0.03773634f, 
    -0.03598583f, -0.01165779f, 0.01733963f, -0.03611102f, 0.02133793f, -0.03347763f, -0.03744278f, 0.00634266f, 
    -0.02920658f, -0.03670583f, -0.03639040f, -0.02816741f, -0.01407856f, -0.04096734f, 0.01929822f, 0.01410555f, 
    -0.03776868f, -0.02726957f, -0.02701820f, 0.01337944f, -0.01850637f, 0.01350270f, 0.00901029f, 0.01988102f, 
    -0.00911907f, -0.03299723f, 0.02823561f, -0.01800373f, -0.03791652f, -0.02672952f, 0.02495070f, -0.03796412f, 
    -0.04065184f, -0.02684060f, -0.02651738f, -0.04038779f, -0.00633527f, -0.02178173f, -0.02167379f, -0.01576138f, 
    0.02266251f, 0.00145402f, -0.00140966f, 0.02439929f, -0.00389555f, -0.02150089f, -0.00698763f, -0.03975112f, 
    -0.01737667f, 0.02091651f, 0.01417133f, 0.02325998f, -0.01414214f, 0.02160639f, 0.01031046f, -0.02638037f, 
    -0.01441231f, 0.01545036f, -0.00810464f, -0.02071099f, -0.03422604f, -0.01200466f, -0.02324261f, -0.00946313f, 
    -0.00236588f, 0.02580757f, 0.01523122f, -0.03922483f, -0.00495768f, -0.02208839f, 0.01784068f, -0.02428495f, 
    -0.02282573f, -0.02934731f, -0.03548218f, -0.02742763f, 0.02391012f, 0.02473729f, -0.01799228f, -0.00232015f, 
    -0.00290793f, -0.00212108f, -0.00830160f, 0.01351511f, -0.02085653f, 0.02354398f, -0.02275022f, -0.01489855f, 
    -0.01796888f, 0.00094681f, -0.03110694f, 0.01218314f, -0.01107173f, -0.01181850f, -0.01524218f, 0.01212741f, 
    -0.00529735f, 0.00665462f, -0.01616386f, -0.03940986f, 0.02240116f, 0.02626209f, 0.00762794f, -0.01264364f, 
    -0.08393070f, -0.06163205f, 0.12526116f, 0.10839985f, 0.04078007f, 0.03861598f, -0.05667990f, -0.05487898f, 
    0.01975769f, 0.05984693f, 0.02526532f, -0.03585864f, -0.33246464f, -0.12131667f, 0.03389335f, 0.26541495f, 
    0.05783033f, 0.05392887f, -0.05855273f, -0.14845152f, 0.00223765f, -0.01363577f, -0.01578445f, 0.06474493f, 
    0.12552586f, -0.25274900f, -0.01870773f, -0.08127619f, -0.02169991f, -0.01965362f, 0.04909614f, 0.11881907f, 
    0.03666555f, 0.00354612f, 0.10885839f, -0.04440700f, -0.09438267f, 0.14141397f, 0.07051510f, 0.11777540f, 
    -0.03321620f, 0.00509759f, 0.00119081f, 0.09263900f, -0.03975974f, -0.00639193f, -0.03519946f, 0.01261952f, 
    0.01568764f, -0.14220303f, -0.23888969f, 0.03894499f, 0.19638382f, -0.00250511f, -0.02682680f, -0.13368537f, 
    0.02940313f, -0.08238384f, 0.03605446f, 0.15934318f, -0.17974408f, 0.10062104f, -0.13113959f, -0.07325561f, 
    0.11634618f, -0.00496995f, -0.08848237f, 0.03090870f, -0.06015512f, -0.03964495f, 0.06514630f, -0.04556428f, 
    0.27604753f, 0.19533657f, -0.10442743f, 0.18998195f, 0.17093800f, -0.02668655f, 0.08319164f, -0.02534087f, 
    -0.02481699f, 0.05583167f, 0.02781188f, 0.03420111f, 0.09608972f, -0.04254683f, 0.02116113f, 0.13679662f, 
    0.14018613f, -0.03190057f, -0.07632935f, -0.06274418f, 0.06445595f, 0.06520206f, 0.10420265f, -0.01855338f, 
    0.06150958f, 0.06457531f, -0.15336114f, -0.32860413f, -0.00221765f, -0.01509234f, 0.02349000f, -0.01764274f, 
    -0.00615239f, -0.02537099f, 0.03532105f, 0.10980175f, 0.18528925f, 0.22599638f, -0.03358584f, -0.05799662f, 
    0.00686156f, 0.00589256f, 0.08149963f, 0.02253487f, -0.00597728f, -0.00762029f, -0.01389391f, 0.07282050f, 
    -0.10295877f, -0.14161316f, -0.12188552f, -0.03082051f, -0.01659351f, -0.00783400f, 0.09978632f, -0.01582014f, 
    -0.06486568f, 0.03097735f, -0.03524650f, 0.03726681f, -0.13818677f, 0.02199216f, -0.12555243f, -0.22207412f, 
    0.04493367f, 0.05106208f, 0.03198746f, 0.10748922f, -0.02153728f, -0.03231387f, 0.06492452f, -0.00481161f, 
    0.01108241f, -0.31599697f, -0.10688299f, -0.06777167f, 0.09435015f, 0.01647535f, 0.10456075f, 0.15873973f, 
    0.01340056f, 0.00537901f, -0.06635085f, 0.04344262f, 0.06341277f, -0.07451868f, 0.03334904f, 0.13053139f, 
    0.04686017f, 0.01771109f, 0.15020162f, 0.03539161f, -0.03561828f, 0.06977393f, 0.10135375f, -0.04806743f, 
    -0.09626146f, 0.06745169f, 0.11328708f, -0.14576696f, -0.00614333f, -0.04289344f, 0.03607709f, 0.04840488f, 
    0.08289801f, -0.08126641f, -0.01952646f, -0.05487572f, 0.18188587f, 0.34541693f, -0.03435165f, 0.19092675f, 
    0.04623196f, 0.07160383f, 0.02816935f, 0.11306268f, 0.05610413f, 0.04162380f, -0.06562638f, 0.04955782f, 
    -0.10920207f, -0.07163263f, 0.11122554f, 0.02045091f, 0.07793267f, -0.05789721f, -0.01464361f, 0.04809149f, 
    0.03110339f, -0.04045450f, -0.14266227f, 0.02791178f, 0.32726431f, 0.13731299f, -0.05538521f, 0.23544770f, 
    0.01740172f, -0.00470813f, 0.02052660f, 0.05145717f, 0.07549498f, 0.02459682f, -0.05932467f, 0.04270737f, 
    -0.01260912f, -0.10570120f, -0.05874054f, 0.08730108f, 0.18491517f, -0.04015134f, -0.01716491f, 0.02448115f, 
    0.09377405f, 0.06714777f, -0.02021550f, -0.01641040f, 0.04280215f, 0.05056546f, -0.04767303f, -0.36206999f, 
    -0.03204869f, -0.01241020f, -0.02158636f, 0.04769078f, 0.00223031f, 0.01789956f, 0.09178929f, 0.07286889f, 
    0.18564478f, -0.05709038f, -0.11027930f, 0.08708030f, -0.03860514f, -0.05675168f, 0.07691478f, 0.00945792f, 
    0.09688210f, -0.04268941f, 0.04660838f, -0.06637448f, -0.15179734f, 0.03563738f, 0.00228241f, -0.14710936f, 
    0.11926804f, 0.09082907f, -0.02873885f, 0.00422633f, -0.00635467f, 0.05270051f, 0.07358429f, 0.04289329f, 
    -0.15869445f, -0.08455154f, -0.07415374f, -0.04067053f, 0.12040401f, 0.03117441f, -0.01601031f, 0.06206340f, 
    -0.01311695f, 0.11535513f, 0.02200052f, 0.02709973f, 0.08279121f, 0.12132234f, -0.12481782f, -0.04444966f, 
    0.02967421f, 0.03320265f, 0.04009277f, 0.08790895f, -0.01021274f, -0.01376127f, 0.04097140f, 0.01002916f, 
    -0.01566583f, 0.01122572f, 0.13700478f, -0.04791974f, -0.01552892f, 0.05395780f, -0.04253128f, 0.03650679f, 
    0.06664556f, 0.08774573f, -0.03082863f, 0.08706141f, -0.06658699f, -0.09048529f, 0.06627592f, 0.13048907f, 
    -0.03787730f, 0.03345155f, -0.00470545f, -0.03823753f, -0.01720605f, 0.00197693f, -0.06253947f, -0.09736280f, 
    0.00519502f, 0.09547963f, -0.00687882f, -0.39624578f, -0.05089951f, -0.05597417f, 0.02832993f, 0.00958314f, 
    0.07499725f, -0.03506344f, 0.01804808f, 0.07262698f, 0.15215902f, -0.14915937f, 0.18237786f, 0.08667082f, 
    -0.02219538f, -0.05566795f, 0.15839991f, 0.07103503f, 0.08809603f, 0.02867960f, -0.05760771f, -0.02372057f, 
    0.04068048f, 0.25671571f, 0.01028987f, 0.11759924f, 0.10156584f, -0.01618592f, -0.00189271f, 0.14757951f, 
    -0.04290775f, 0.08940943f, 0.13496485f, 0.05858951f, -0.00305464f, 0.10466953f, 0.20560864f, 0.21400194f, 
    0.05889723f, 0.11742277f, -0.02390251f, -0.05795730f, -0.08166582f, -0.12584382f, -0.07698744f, -0.03313445f, 
    0.26203164f, -0.07718524f, 0.00911781f, 0.22351450f, 0.02326670f, 0.05153748f, 0.04867294f, -0.00490250f, 
    0.01360185f, 0.09372590f, -0.01394742f, 0.02258569f, 0.19163439f, 0.11373018f, -0.02289970f, 0.23293853f, 
    -0.00830562f, -0.01295233f, -0.03057115f, -0.02252475f, -0.00029794f, 0.09044496f, -0.06684203f, 0.08321617f, 
    0.13567378f, -0.10395768f, 0.07054247f, 0.32338244f, 0.03753398f, -0.00823153f, -0.05914976f, -0.02482212f, 
    -0.06276167f, 0.02018749f, 0.03863291f, 0.06632394f, 0.13825637f, 0.07493518f, -0.12549980f, -0.03233048f, 
    0.14306778f, -0.09077250f, -0.03062185f, 0.05196979f, -0.01944740f, -0.01158883f, -0.01927944f, 0.05899161f, 
    0.12786737f, -0.06834862f, -0.11123066f, 0.06187392f, 0.27256489f, -0.05360797f, -0.03348923f, -0.02659187f, 
    -0.01981073f, 0.04663986f, -0.02646727f, -0.03756625f, 0.12547538f, -0.09677271f, 0.11632353f, 0.01505578f, 
    -0.03860777f, 0.07121691f, -0.07610137f, 0.02572148f, -0.04644413f, 0.05186098f, 0.09538524f, 0.00200701f, 
    0.00395439f, 0.03884735f, -0.10746891f, -0.16600643f, 0.02543527f, 0.07934729f, 0.00784897f, -0.02613328f, 
    -0.03818351f, 0.08581161f, -0.03556354f, 0.05540365f, -0.12223452f, -0.13118625f, -0.07776553f, -0.03911409f, 
    0.13811815f, -0.04188618f, -0.08030776f, 0.08437043f, 0.01060158f, -0.01727670f, -0.00767904f, 0.00621234f, 
    -0.32890418f, 0.11942216f, -0.09732547f, -0.13550028f, 0.21749602f, 0.03063830f, 0.01512038f, -0.03305014f, 
    0.02466430f, 0.00165434f, 0.07627647f, 0.12333335f, 0.16225170f, -0.19044852f, -0.04719874f, 0.13379309f, 
    -0.16194122f, 0.17771579f, 0.00194443f, 0.00793783f, -0.06527337f, -0.06407783f, -0.04513662f, 0.12640578f, 
    0.23125279f, 0.14288573f, -0.03619905f, -0.11968295f, 0.03666715f, 0.00451075f, 0.02850164f, -0.01639349f, 
    0.10841310f, -0.00675790f, -0.00770548f, -0.01487784f, -0.07230714f, 0.00181244f, -0.09602467f, -0.06321205f, 
    0.02169215f, 0.16180083f, -0.04327682f, 0.00644100f, -0.03624016f, 0.11366226f, 0.02730800f, 0.01550302f, 
    -0.03780752f, -0.05460535f, -0.02571796f, -0.11171500f, 0.11813744f, 0.04871533f, 0.12092359f, 0.02547033f, 
    -0.01568090f, 0.04302007f, -0.05641194f, 0.10066243f, -0.11775420f, -0.02092594f, -0.02368551f, 0.09909102f, 
    0.06801598f, -0.04573010f, -0.10795737f, 0.00801203f, -0.05547350f, 0.04739129f, 0.01596117f, -0.04363509f, 
    0.05777186f, 0.08005463f, -0.09985555f, -0.09367059f, -0.00053069f, -0.03029750f, -0.07068519f, 0.12327646f, 
    0.10737537f, 0.04657847f, 0.07633589f, -0.00602168f, -0.03380182f, 0.02684614f, -0.04628628f, -0.15149398f, 
    -0.00338538f, -0.04967112f, -0.05262770f, 0.08293107f, 0.03280246f, 0.10295974f, 0.02469992f, -0.00599767f, 
    -0.15608321f, 0.05389703f, -0.14281729f, 0.03056660f, 0.11099941f, 0.00268745f, -0.02173350f, 0.07217555f, 
    0.01594778f, -0.03512509f, 0.00578382f, -0.06923222f, 0.18483567f, -0.06084501f, 0.10626572f, 0.10937884f, 
    0.06611066f, 0.04667650f, -0.01094348f, 0.07499406f, 0.04080918f, -0.01769452f, 0.08405900f, 0.14140208f, 
    -0.39698976f, -0.05622813f, 0.21975063f, 0.20745677f, 0.01552615f, -0.04280844f, 0.10185834f, 0.07196876f, 
    -0.11323618f, -0.00935735f, 0.11745886f, 0.05715622f, -0.14930992f, -0.04583134f, -0.00579155f, -0.04848182f, 
    0.03580168f, 0.13747734f, 0.08678398f, 0.07711519f, 0.11956452f, 0.04317620f, 0.02344459f, 0.04585861f, 
    -0.15328448f, 0.22649570f, -0.06436837f, -0.33370551f, 0.10433403f, 0.06771012f, -0.02268006f, 0.04833632f, 
    -0.02348639f, 0.04749051f, 0.01207183f, 0.13610773f, -0.17491488f, -0.01606146f, 0.25620124f, 0.13119702f, 
    0.00319531f, 0.02878322f, 0.07656112f, -0.08602183f, 0.04380479f, 0.01343025f, 0.05964947f, 0.04452490f, 
    0.11132250f, -0.02608052f, -0.05811404f, 0.15847269f, -0.08561355f, 0.07108378f, 0.03035218f, 0.00892776f, 
    -0.05003889f, -0.00868203f, 0.00066156f, 0.03381285f, -0.13827939f, -0.08624174f, -0.04299087f, -0.01997144f, 
    -0.01687212f, 0.06985379f, 0.05360394f, -0.05941662f, 0.10068091f, 0.07618876f, -0.07890331f, 0.03811103f, 
    0.16229217f, 0.09602032f, 0.14091308f, 0.18229412f, 0.12813316f, -0.02566421f, 0.05509439f, 0.03137478f, 
    0.05333464f, 0.11553399f, -0.03226595f, -0.16372140f, 0.16042772f, -0.15009730f, -0.18886600f, -0.10916025f, 
    0.14980493f, 0.09499974f, -0.16668017f, 0.12564752f, -0.11731457f, -0.01795839f, -0.00938062f, 0.01495150f, 
    0.17692931f, 0.03987858f, -0.00803873f, 0.04930761f, 0.01192977f, 0.07859830f, 0.04661068f, 0.00688791f, 
    0.01807196f, -0.11401648f, -0.02213509f, 0.00831716f, -0.10637949f, -0.10595836f, 0.13015664f, 0.09814776f, 
    -0.00231727f, -0.06045293f, 0.00072697f, -0.02390778f, 0.02612062f, 0.02604929f, -0.15293883f, 0.08284166f, 
    -0.05679040f, 0.04322892f, 0.08941425f, 0.14876588f, 0.01253108f, -0.05538013f, 0.05832387f, 0.02305941f, 
    0.17884737f, 0.03991537f, 0.00581551f, -0.04318261f, 0.14921162f, 0.14288384f, -0.25297648f, 0.05444156f, 
    0.00920711f, 0.02370669f, 0.09353561f, 0.07687775f, -0.06540075f, 0.15240061f, 0.02203188f, -0.08993512f, 
    -0.13067250f, 0.01564459f, -0.09502999f, -0.18577148f, -0.01745827f, 0.00090451f, 0.09787186f, -0.00669111f, 
    0.02791773f, 0.05579091f, -0.01105312f, -0.08865175f, -0.05884533f, -0.21493977f, 0.06772787f, 0.20261952f, 
    0.01410935f, 0.00956940f, -0.07671179f, 0.02804121f, -0.05961615f, 0.00548297f, 0.00491166f, 0.02514631f, 
    0.07727214f, 0.17489251f, 0.14631329f, 0.16968429f, -0.08868527f, 0.08701871f, 0.07605126f, -0.00569322f, 
    0.05504301f, 0.05539408f, 0.03901805f, 0.03805795f, -0.15908615f, 0.16599508f, -0.02570156f, -0.12467897f, 
    0.04249110f, 0.08382900f, 0.08285461f, 0.07277130f, 0.04493916f, -0.01243385f, 0.02307146f, 0.07006737f, 
    -0.01194346f, -0.00403817f, -0.02765727f, -0.01574791f, -0.01834237f, -0.01436337f, 0.01773172f, 0.00494025f, 
    0.01157147f, -0.03691538f, -0.01891739f, 0.00912283f, -0.01555425f, 0.02424424f, 0.02867911f, -0.01825700f, 
    0.00789784f, -0.03195762f, 0.02688203f, 0.00409006f, -0.01264422f, 0.01583848f, 0.02323120f, -0.01487452f, 
    0.00024808f, -0.00096043f, 0.00318287f, 0.02823429f, -0.01553245f, -0.03512842f, -0.00489666f, -0.02023188f, 
    0.02120013f, 0.01834106f, 0.03145630f, 0.00847979f, -0.03608825f, -0.00929626f, -0.03673519f, -0.01069353f, 
    -0.03228029f, 0.03367275f, -0.02482303f, -0.02629316f, -0.03677340f, 0.02991011f, -0.00993128f, 0.00419164f, 
    0.02069298f, 0.01438849f, -0.00448094f, 0.02966287f, 0.01011131f, -0.00240951f, -0.00767803f, 0.01318513f, 
    -0.01426865f, -0.01603369f, -0.02382884f, -0.00991852f, 0.02916280f, -0.03018551f, -0.01540663f, 0.02009781f, 
    0.01100664f, -0.02431243f, -0.02676095f, -0.02564734f, -0.02707649f, 0.03232743f, -0.01597777f, -0.00642598f, 
    0.01835990f, 0.00488286f, 0.00241548f, -0.00449299f, 0.00504386f, 0.00413233f, 0.02633446f, -0.01205244f, 
    -0.00471807f, 0.01106069f, 0.01870252f, -0.02263647f, 0.03127540f, -0.01551816f, 0.02471272f, 0.01526299f, 
    0.01710897f, -0.02694144f, -0.03615874f, -0.02127016f, 0.00373842f, 0.02703537f, -0.00622229f, 0.02151585f, 
    0.01583728f, -0.02745480f, -0.02093405f, -0.03849000f, 0.01679614f, -0.00540267f, -0.02943999f, -0.02705870f, 
    0.03246237f, -0.03675035f, 0.03152035f, 0.02186072f, -0.01358197f, -0.02804870f, 0.01964818f, 0.02170735f, 
    -0.00798976f, 0.01770941f, -0.02972457f, 0.02290062f, -0.00903939f, -0.02046792f, -0.01027039f, 0.03005599f, 
    -0.01672812f, 0.00894134f, 0.00760458f, -0.00124742f, -0.04229160f, 0.01302909f, -0.03343763f, -0.01799617f, 
    0.02701853f, 0.01067562f, -0.01239667f, -0.03837996f, -0.02413572f, -0.01898535f, 0.01755129f, -0.02733576f, 
    0.00449010f, -0.02718641f, 0.01589794f, 0.00782024f, -0.01630881f, -0.02015633f, 0.01047643f, -0.02000446f, 
    -0.01949224f, 0.00485960f, -0.00789015f, -0.01406390f, 0.00572833f, -0.01959399f, 0.02660022f, 0.01797341f, 
    -0.02997891f, -0.01505861f, -0.03586728f, -0.01904955f, -0.00435153f, -0.03190121f, -0.00900198f, 0.00535533f, 
    -0.01385662f, 0.00059973f, -0.03597958f, -0.01174850f, -0.04154751f, 0.00572077f, -0.01478180f, 0.01200782f, 
    0.02534674f, -0.00501782f, -0.00449856f, -0.03419073f, -0.01455656f, -0.00748366f, -0.03282520f, 0.02433375f, 
    -0.00079315f, 0.00556348f, -0.03409151f, 0.00961814f, -0.02811567f, -0.03376780f, 0.02578662f, -0.04050668f, 
    -0.01468083f, 0.02365701f, 0.02648605f, 0.02894393f, -0.02546210f, -0.00449483f, 0.00822566f, -0.01310788f, 
    0.02031350f, -0.03477969f, -0.01709417f, -0.00128914f, -0.03338261f, 0.01074074f, -0.03297796f, -0.00379118f, 
    0.02387126f, 0.03028578f, 0.03202279f, 0.03261753f, -0.00801187f, -0.03864912f, -0.01170537f, 0.01700090f, 
    -0.03731625f, -0.03311317f, -0.00725432f, -0.02006157f, 0.01144489f, 0.00207829f, 0.02886015f, 0.02772057f, 
    -0.03383231f, -0.01728034f, -0.03785773f, -0.01277393f, 0.00134988f, -0.03374935f, 0.01229228f, 0.02388587f, 
    0.00824381f, 0.00352769f, 0.02752271f, -0.01529720f, -0.00375388f, -0.00198622f, -0.00884679f, -0.03713828f, 
    -0.02699753f, -0.01077289f, -0.00575498f, -0.02086960f, -0.02234393f, 0.02237336f, 0.01199812f, 0.02730588f, 
    0.01872868f, 0.02311650f, -0.02282121f, 0.01556571f, -0.00788279f, -0.00224569f, -0.02417697f, -0.03972718f, 
    -0.03469741f, -0.01709496f, -0.02341266f, -0.02410827f, 0.02270032f, -0.02619459f, 0.02383206f, -0.03419403f, 
    0.03131092f, -0.00480646f, 0.00076554f, -0.00211570f, 0.00470114f, 0.02611343f, 0.02165322f, 0.02135363f, 
    0.00406162f, -0.03217076f, -0.02453614f, 0.01574458f, -0.02104794f, 0.01275333f, 0.02424715f, -0.00939086f, 
    0.02602261f, -0.01525129f, -0.03664935f, -0.00317695f, -0.01751422f, 0.01759256f, -0.02672372f, 0.02224753f, 
    0.00259326f, -0.00129387f, 0.02268109f, -0.00869829f, -0.03366021f, -0.00440143f, -0.01202360f, 0.00504966f, 
    0.00425682f, -0.02170324f, -0.02763626f, -0.00170371f, 0.00778569f, -0.01610306f, -0.00946401f, 0.02349743f, 
    0.01843975f, 0.01556383f, 0.00041183f, 0.00804113f, 0.03060884f, -0.01177882f, -0.00985516f, -0.03024501f, 
    0.02657245f, 0.03872465f, 0.02779461f, 0.00243119f, 0.01215177f, 0.00925402f, 0.02832995f, -0.02274832f, 
    0.03171637f, -0.02749944f, -0.00681425f, 0.01935682f, -0.03308735f, -0.00913695f, 0.00131576f, -0.01337312f, 
    0.02067957f, -0.01250410f, -0.02660793f, 0.00607520f, -0.02805799f, 0.00651227f, 0.01841193f, -0.02580921f, 
    -0.01631284f, 0.03090388f, 0.01879468f, -0.02657150f, -0.01464026f, 0.02725662f, 0.00079144f, 0.02380684f, 
    0.00135214f, 0.00328922f, 0.01249553f, -0.01370641f, -0.00450693f, 0.02811684f, -0.03767598f, -0.03838154f, 
    -0.01420026f, 0.01819543f, 0.03385391f, 0.00098530f, -0.02167611f, 0.01860965f, 0.02469763f, 0.00047855f, 
    -0.02489298f, -0.00302965f, -0.01754709f, 0.00634796f, -0.01352388f, -0.03711255f, -0.00200496f, 0.02037499f, 
    -0.00235025f, -0.00148553f, -0.03956726f, -0.01525849f, 0.01328340f, -0.00780558f, 0.02742773f, -0.02497986f, 
    0.01236229f, -0.02138714f, 0.00165958f, 0.00753917f, 0.00472313f, 0.01009591f, -0.01319325f, 0.01703941f, 
    -0.03365780f, 0.02055289f, -0.01918437f, -0.00091333f, -0.00244309f, -0.03333087f, -0.00583867f, -0.01665499f, 
    -0.03105722f, 0.02095660f, -0.00955863f, -0.02617300f, -0.01114380f, 0.03238765f, -0.02386940f, 0.02507229f, 
    -0.00973004f, -0.01501917f, -0.02073745f, -0.00209715f, 0.02786096f, 0.00463011f, -0.00521686f, -0.02207697f, 
    -0.02423041f, 0.01554477f, -0.02231320f, -0.01296518f, 0.01149323f, -0.02209191f, 0.01023086f, -0.01174676f, 
    0.02607343f, -0.01266574f, -0.01433201f, 0.02205996f, -0.00429940f, 0.01711261f, 0.00315680f, -0.02887191f, 
    -0.03651504f, -0.02598741f, -0.02233510f, -0.03275071f, -0.02742324f, 0.01440506f, -0.03768189f, 0.02829464f, 
    -0.00723113f, -0.03067862f, -0.00353477f, -0.02571620f, -0.02275898f, 0.02788565f, -0.01022117f, -0.01188546f, 
    0.00854731f, 0.02296278f, -0.02580924f, -0.00460024f, -0.00740587f, 0.02984105f, -0.02448096f, -0.02296093f, 
    -0.01180206f, -0.00050251f, 0.00922679f, 0.01144085f, 0.02586116f, 0.00632259f, -0.03690038f, 0.00700871f, 
    -0.02100503f, 0.01433498f, -0.03981983f, 0.01805791f, 0.01242939f, -0.02073755f, 0.01524467f, 0.00820034f, 
    0.02695139f, 0.00207034f, 0.00741641f, -0.03296965f, 0.00055770f, -0.01407008f, 0.00240960f, 0.01887374f, 
    -0.03357732f, -0.03048084f, -0.01490185f, -0.02607355f, -0.03316006f, -0.04031654f, -0.00407377f, 0.01588478f, 
    0.02521881f, -0.01000923f, 0.00986777f, 0.01315594f, -0.03407481f, -0.00432191f, 0.02335181f, 0.02432455f, 
    0.02296468f, -0.00732396f, 0.02669379f, -0.03359698f, 0.01304585f, 0.03186189f, -0.02229508f, -0.00269994f, 
    0.01549791f, 0.02866692f, 0.00766852f, -0.00702262f, 0.00896138f, -0.01608139f, 0.01474973f, -0.01082139f, 
    0.00340887f, -0.00306500f, -0.02477837f, 0.02405105f, -0.02572787f, -0.01656077f, -0.01497242f, 0.01983233f, 
    0.00456630f, 0.02552656f, -0.03210612f, -0.01738184f, 0.00234286f, -0.01937375f, -0.02901928f, 0.01316957f, 
    -0.00336075f, -0.01523735f, 0.03448522f, 0.03118446f, 0.01710480f, 0.00130888f, -0.00770954f, -0.03999616f, 
    0.02084093f, -0.03200499f, -0.03108363f, -0.02808081f, -0.03222368f, -0.00712037f, 0.03095994f, 0.02739113f, 
    -0.02093240f, 0.01189139f, 0.02106800f, -0.03453165f, -0.01246635f, -0.00056742f, -0.01637741f, -0.00538423f, 
    0.03064664f, -0.02753024f, 0.02597649f, -0.01220716f, 0.01227009f, -0.00687583f, 0.02456419f, -0.03309860f, 
    0.01894320f, -0.00954642f, 0.01287889f, -0.00322840f, 0.00970942f, -0.03537067f, -0.03465447f, -0.02754572f, 
    -0.03802359f, -0.03639928f, -0.02178427f, -0.03135518f, 0.01312771f, 0.01879221f, 0.01892201f, 0.02651146f, 
    0.00178890f, 0.01956750f, -0.02846803f, -0.01088005f, -0.02866747f, 0.00714929f, -0.03814056f, 0.03256124f, 
    0.01612817f, -0.01860205f, -0.02318606f, -0.02603503f, 0.00932172f, 0.01327722f, 0.01703460f, -0.01847623f, 
    -0.01349649f, -0.03997788f, -0.02856422f, -0.01077187f, -0.02489720f, 0.01075627f, -0.01142257f, 0.01326476f, 
    0.03546929f, -0.03264932f, -0.03949293f, 0.01613098f, 0.00507982f, -0.01345390f, -0.00081273f, 0.02609261f, 
    0.02677253f, -0.03170300f, -0.01519681f, -0.00529084f, -0.01840601f, -0.01216345f, -0.02652511f, -0.03717578f, 
    -0.00296998f, -0.01353167f, 0.02158958f, -0.01618153f, -0.03031677f, -0.02546820f, -0.04108141f, -0.01213578f, 
    -0.00011906f, 0.01201599f, 0.00609700f, 0.01129190f, 0.01247584f, -0.03516596f, -0.00296079f, -0.00663188f, 
    -0.02037228f, -0.00384425f, 0.02443158f, -0.02831457f, -0.02315158f, 0.03469817f, 0.00107441f, -0.02696039f, 
    0.00978272f, -0.00602111f, -0.01802773f, -0.02089166f, -0.01491953f, -0.03107747f, -0.02521300f, -0.02425504f, 
    -0.00548012f, 0.01273481f, -0.01755718f, 0.02029059f, 0.02570685f, -0.00452210f, -0.01800852f, -0.00928595f, 
    -0.01197510f, -0.03346880f, -0.02824683f, -0.01041605f, -0.02074900f, 0.00853955f, 0.00119813f, 0.02839317f, 
    -0.00090806f, -0.03330256f, -0.02561581f, 0.02579275f, 0.01719326f, -0.03322527f, 0.03333093f, 0.00482209f, 
    0.01257303f, 0.01608160f, 0.00664082f, 0.01512535f, -0.03027386f, 0.02061613f, 0.02874892f, 0.02901760f, 
    0.02759113f, 0.00143232f, -0.03198287f, -0.00957853f, 0.02476718f, 0.00790285f, -0.02677860f, -0.01834157f, 
    -0.02101312f, -0.00193389f, -0.01187169f, -0.03911799f, 0.01750809f, -0.02859204f, -0.01861375f, 0.01298972f, 
    0.01864998f, 0.00259881f, -0.02897275f, -0.00667513f, -0.04055124f, 0.01660205f, -0.01863403f, 0.01958763f, 
    -0.01115903f, 0.00263251f, -0.03298238f, 0.01795376f, -0.03213460f, -0.03811453f, -0.01717298f, 0.01354123f, 
    0.02129798f, -0.02039733f, -0.03245699f, 0.00511053f, 0.01131046f, 0.01388339f, -0.01358864f, -0.02494669f, 
    0.00538984f, -0.02005434f, 0.02039502f, 0.01644059f, 0.02884023f, -0.00439278f, -0.01858184f, 0.00252550f, 
    -0.00070779f, -0.02738924f, 0.02686752f, 0.02845027f, 0.01213641f, -0.02767676f, -0.04106696f, 0.01264553f, 
    -0.02254257f, -0.03500753f, -0.03804746f, -0.02975501f, 0.03348880f, -0.00163059f, 0.03241842f, 0.01757711f, 
    0.02549599f, 0.00632364f, 0.00399966f, 0.02361514f, -0.02479765f, -0.03972812f, -0.01034641f, 0.02999769f, 
    -0.03302978f, 0.00756642f, -0.01400141f, 0.02209022f, -0.02095993f, 0.01578481f, 0.02853259f, -0.00195763f, 
    0.01761333f, 0.00919473f, 0.00178436f, -0.01081201f, -0.03573129f, -0.01304847f, 0.01153591f, 0.01527611f, 
    0.03016127f, -0.02925178f, -0.02891880f, 0.01483268f, 0.00548961f, -0.03110276f, -0.01567656f, 0.02190851f, 
    -0.03381892f, -0.00435210f, -0.00276650f, 0.00717177f, 0.01994915f, 0.01858703f, -0.02746056f, -0.01137222f, 
    0.02116353f, 0.05869316f, 0.11175216f, 0.17381032f, -0.11157365f, -0.02640529f, 0.09406125f, 0.04269367f, 
    -0.04944218f, 0.05521360f, 0.06162616f, -0.00840665f, 0.08849814f, -0.12057891f, -0.08442628f, -0.07188711f, 
    0.14707756f, 0.03035605f, -0.04562341f, -0.05552365f, 0.06739408f, -0.03508585f, -0.02295969f, 0.00960784f, 
    0.02619165f, 0.00989532f, 0.11029770f, 0.34015346f, -0.05016520f, -0.04601030f, 0.08152150f, 0.02937158f, 
    -0.04842100f, -0.00773645f, 0.03742420f, 0.01748941f, 0.09553553f, 0.04151810f, 0.07809801f, -0.05250952f, 
    0.06349239f, 0.04391789f, 0.10533419f, -0.02385815f, -0.06318516f, 0.10185040f, -0.05466524f, -0.02109372f, 
    -0.13971306f, 0.07051861f, 0.12887385f, 0.24579333f, -0.01093222f, 0.02127034f, 0.02983755f, -0.01783360f, 
    -0.02472138f, -0.15088910f, 0.02337420f, -0.01326275f, -0.04345677f, 0.09815396f, -0.00258027f, -0.08961596f, 
    0.04152623f, -0.03814087f, -0.01185895f, -0.05817479f, -0.09808587f, -0.00996200f, -0.04363684f, -0.04921103f, 
    0.06833915f, -0.11883396f, 0.17736945f, -0.12146527f, -0.04401427f, -0.05364940f, -0.06416387f, -0.03015420f, 
    -0.08957373f, 0.02606704f, -0.03617131f, -0.04189677f, 0.03837186f, 0.05265043f, 0.04619785f, 0.26507255f, 
    0.09994026f, -0.02027178f, 0.07295370f, 0.01938216f, 0.00087917f, -0.08529847f, 0.01918581f, 0.02411633f, 
    -0.10147610f, -0.04197028f, -0.10739129f, 0.12994543f, 0.17698990f, 0.04151984f, 0.02056790f, -0.03592540f, 
    0.02141523f, -0.05069410f, 0.00847197f, 0.04604131f, 0.17651929f, 0.07778590f, -0.12078538f, -0.05541981f, 
    0.00765680f, 0.03487907f, -0.03672593f, 0.02710314f, 0.03150796f, 0.03549718f, -0.03513217f, 0.17649974f, 
    -0.27152678f, 0.02320262f, -0.04033430f, 0.03794302f, 0.10027637f, -0.05973184f, 0.08293735f, -0.08066622f, 
    -0.00629978f, 0.05546051f, -0.00016893f, -0.06265976f, -0.12628607f, 0.00577694f, -0.15826525f, -0.15418430f, 
    0.14883605f, -0.04230185f, 0.06656249f, -0.06124055f, -0.04734145f, 0.01038066f, 0.09071130f, 0.00766186f, 
    0.06998789f, -0.16627945f, -0.13720071f, 0.07694698f, -0.02696574f, 0.00808317f, -0.04653374f, 0.03505240f, 
    0.07825392f, 0.01748921f, 0.04519795f, -0.05528332f, -0.03679516f, -0.04467538f, 0.12375511f, 0.12363741f, 
    -0.03061698f, -0.04150245f, 0.14117457f, 0.05082014f, 0.02649385f, 0.13851468f, 0.05217041f, -0.02487008f, 
    0.04632997f, 0.03883716f, -0.02381069f, -0.20257953f, 0.08039723f, 0.05882692f, 0.01583199f, -0.10194085f, 
    0.11313795f, -0.03000440f, 0.02297004f, -0.04658433f, 0.16435023f, 0.08249809f, 0.09634382f, -0.01977414f, 
    0.03371130f, 0.01192123f, -0.00375262f, 0.04047368f, 0.02388278f, -0.03925565f, -0.07352336f, 0.11715288f, 
    -0.03514901f, 0.13754383f, 0.06028028f, 0.12742957f, -0.00884984f, 0.05426043f, -0.06984323f, 0.03478492f, 
    -0.03033844f, -0.05807701f, -0.04688742f, -0.09333558f, 0.15638725f, 0.19929381f, -0.18318392f, 0.37647137f, 
    0.01361093f, 0.03074702f, -0.06245628f, -0.04197058f, 0.12238535f, 0.13154440f, 0.04552460f, 0.05100765f, 
    -0.15070213f, 0.02880892f, 0.17801157f, 0.33029422f, 0.06088485f, -0.01344775f, 0.02629796f, 0.02176762f, 
    -0.03125558f, -0.00969987f, -0.01918737f, -0.08219422f, -0.01289202f, -0.08073101f, -0.01455165f, -0.03869612f, 
    0.09883225f, 0.01452757f, -0.03035296f, -0.02043124f, 0.09379236f, -0.02420057f, -0.02815423f, 0.04958802f, 
    0.04498884f, -0.03369630f, -0.04896121f, 0.19494106f, -0.03090767f, -0.02972712f, 0.04104067f, -0.03648238f, 
    -0.00545227f, -0.02657127f, -0.03619355f, 0.01194799f, 0.02900287f, 0.00028569f, -0.11801347f, -0.22552359f, 
    0.15135862f, 0.00801536f, -0.05907749f, -0.00927234f, 0.05850866f, 0.02400410f, -0.09211624f, -0.06443254f, 
    -0.10285909f, 0.05794377f, 0.13807352f, 0.14967024f, -0.09563027f, 0.01898253f, -0.00366624f, 0.00454697f, 
    -0.05035359f, 0.01943559f, -0.00400510f, -0.07083279f, 0.04208698f, -0.06028911f, 0.05069200f, -0.00563485f, 
    -0.03935051f, -0.03539656f, 0.02225368f, -0.07840817f, 0.02570576f, 0.03552118f, 0.06829366f, 0.01272420f, 
    0.18954188f, -0.03966830f, -0.07864962f, -0.09079138f, 0.04722239f, -0.02417126f, -0.04616898f, 0.01560615f, 
    -0.07745336f, 0.02171981f, 0.02480705f, 0.02201724f, -0.00646264f, -0.02775474f, 0.00348391f, 0.20136535f, 
    -0.00866653f, -0.03146875f, -0.08479685f, -0.01886135f, -0.03210248f, -0.06040306f, -0.04936689f, -0.00567189f, 
    -0.00036299f, -0.01266186f, -0.11792607f, -0.05685776f, 0.17096505f, 0.01319440f, -0.06643450f, -0.02233882f, 
    0.07812794f, -0.03473028f, -0.03998343f, -0.04469185f, 0.07832365f, -0.16675882f, 0.04769891f, -0.03229734f, 
    0.03140259f, 0.00646273f, 0.19076842f, -0.04629732f, 0.04305020f, 0.02686157f, 0.01748303f, -0.01727528f, 
    -0.02168310f, -0.01269946f, 0.19740134f, -0.12034539f, 0.04161466f, -0.03419002f, 0.00701910f, 0.03691677f, 
    0.03182048f, 0.03936503f, 0.03488990f, 0.01348588f, -0.10055255f, 0.32500160f, -0.05932182f, 0.15091145f, 
    -0.06776914f, 0.06870447f, -0.03011122f, -0.02328230f, 0.04153258f, 0.10423537f, -0.14512317f, -0.09214047f, 
    0.01543490f, -0.06851589f, 0.06487649f, 0.12770715f, 0.06512211f, -0.07530576f, 0.00641015f, 0.03375521f, 
    0.06484186f, 0.03488678f, -0.00877594f, -0.01072134f, -0.07139246f, 0.13361609f, -0.09161975f, 0.32133415f, 
    0.04785557f, 0.02126359f, -0.05578040f, 0.03814695f, 0.00346841f, 0.07754149f, -0.00968875f, -0.02280358f, 
    -0.04430545f, 0.01287978f, -0.26477137f, 0.21783520f, -0.02626868f, -0.03670374f, -0.09849058f, -0.02962999f, 
    0.03185300f, 0.05217996f, -0.02839232f, -0.01686872f, -0.07309148f, -0.00983916f, 0.03694063f, -0.13644327f, 
    0.10809734f, -0.07626665f, 0.08599230f, 0.05957446f, 0.03267236f, -0.02592485f, 0.07064636f, 0.06252801f, 
    -0.08037587f, -0.03691823f, 0.06650889f, 0.29844648f, 0.00774952f, -0.08522759f, 0.16431747f, 0.02751639f, 
    -0.14816450f, -0.06292410f, 0.03045884f, -0.08553652f, 0.15622479f, -0.16145268f, -0.06125025f, 0.14419913f, 
    -0.00154359f, 0.15212557f, -0.04140261f, -0.03038991f, 0.02621220f, -0.03567328f, 0.09991407f, -0.00487353f, 
    -0.02106858f, -0.04160675f, -0.12612727f, -0.27577874f, -0.01064695f, 0.09305393f, -0.02032202f, 0.06666535f, 
    -0.01351163f, 0.06338657f, -0.09043770f, 0.13398238f, -0.15397984f, 0.03649257f, -0.12685724f, 0.04768850f, 
    -0.03868419f, -0.01751082f, 0.08962559f, 0.05478636f, -0.01714559f, -0.03160799f, -0.01522466f, -0.03549981f, 
    -0.26058429f, 0.27620745f, -0.01752543f, -0.09768791f, 0.12319074f, -0.03843616f, 0.10719733f, 0.08887129f, 
    0.02265364f, -0.00399531f, -0.07502501f, -0.00411197f, 0.14972152f, -0.07413802f, -0.14258663f, 0.31935066f, 
    0.06714208f, 0.13062003f, -0.11447110f, -0.04227941f, 0.02099802f, -0.02144519f, -0.15538718f, 0.12770119f, 
    0.07381404f, 0.05380674f, -0.03943380f, -0.28148577f, -0.06946961f, 0.10425396f, -0.05271442f, 0.09446615f, 
    -0.01866934f, -0.02363792f, 0.03701370f, -0.06511788f, -0.14187811f, 0.06354619f, -0.06051083f, 0.01658401f, 
    0.10711159f, 0.10494404f, -0.08062951f, 0.03885525f, -0.01222179f, 0.09032337f, 0.01312975f, -0.00040647f, 
    -0.14914685f, 0.01070711f, -0.04203432f, -0.14390904f, 0.06103894f, 0.08559579f, 0.01175033f, -0.03078310f, 
    -0.03496447f, -0.11242828f, -0.12491098f, 0.12190728f, 0.00929745f, 0.11511469f, 0.16562916f, 0.11657932f, 
    -0.02369364f, 0.01687778f, -0.01685002f, 0.04582335f, -0.04971210f, 0.01893128f, -0.01244355f, -0.02762054f, 
    0.00873253f, -0.10007583f, -0.05105500f, 0.02677729f, 0.03767945f, -0.04409949f, -0.04397361f, 0.08616807f, 
    0.02821473f, -0.04989837f, 0.04465722f, 0.05461096f, -0.14933877f, -0.11782833f, -0.16275156f, 0.19161955f, 
    0.11498877f, -0.07600483f, 0.01510036f, -0.00514167f, -0.01800913f, 0.00150353f, -0.03033168f, -0.05159384f, 
    -0.05379548f, -0.01220569f, -0.02666442f, -0.11170195f, 0.03618026f, 0.00819493f, 0.07744472f, -0.06329925f, 
    -0.08411355f, 0.02138379f, -0.01671807f, -0.04536729f, 0.03101918f, 0.09899192f, -0.03331164f, 0.15452261f, 
    0.06312437f, 0.06289996f, -0.00281007f, -0.07028154f, 0.00629944f, 0.05236934f, 0.05435982f, 0.08775567f, 
    -0.01250598f, 0.06013412f, -0.00009015f, 0.09998595f, 0.08086447f, 0.11965151f, -0.03608980f, 0.05129831f, 
    -0.01778718f, 0.00493321f, 0.04188723f, 0.05265053f, -0.30668381f, 0.10063519f, -0.08493103f, -0.13647090f, 
    -0.02088943f, 0.06766319f, 0.13271455f, 0.04895219f, 0.01513180f, -0.03107017f, 0.05265030f, 0.03822973f, 
    -0.19648983f, 0.11718000f, -0.14888404f, 0.06536897f, 0.11946021f, 0.01280088f, -0.00861357f, 0.04376290f, 
    0.10571168f, 0.03592905f, -0.02029754f, 0.07846799f, -0.22665329f, -0.02758873f, 0.13530865f, -0.03779823f, 
    0.11271662f, -0.02694487f, 0.09588144f, -0.09703188f, 0.06710203f, 0.00378323f, 0.10098537f, -0.00097211f, 
    0.04857564f, 0.02175803f, 0.08192219f, 0.19809587f, -0.03149699f, -0.02246949f, -0.05108216f, -0.08435094f, 
    -0.01195026f, -0.04383373f, 0.00917575f, 0.01828364f, 0.00879147f, 0.15949436f, 0.13483302f, 0.05600326f, 
    0.04903067f, 0.02382497f, -0.11018407f, 0.07058623f, 0.03657721f, 0.02486904f, 0.02129575f, -0.05153006f, 
    0.05404792f, 0.03952386f, 0.16734652f, 0.16330148f, 0.06047339f, -0.09342679f, -0.00627185f, -0.11418483f, 
    -0.07124747f, -0.03614819f, 0.01835319f, 0.01200351f, 0.01749335f, -0.04693613f, 0.00690981f, -0.03431422f, 
    0.07402931f, -0.03641383f, 0.03052936f, -0.00353880f, -0.03279001f, -0.09059490f, -0.00422537f, -0.00551296f, 
    0.10156977f, 0.07368845f, -0.06608316f, 0.10931072f, -0.00905611f, -0.05033874f, -0.02532073f, -0.04299038f, 
    0.03825707f, -0.04636627f, -0.02933331f, 0.02455731f, -0.20558959f, 0.23106579f, 0.07397547f, -0.03917256f, 
    -0.00999406f, -0.02988291f, 0.07672834f, 0.01032948f, 0.17880993f, -0.00346523f, 0.01919850f, 0.03375154f, 
    -0.09628165f, -0.09836149f, -0.04151578f, -0.01077959f, 0.02429853f, 0.04942115f, 0.13148230f, -0.09162368f, 
    0.11550947f, 0.06497794f, 0.10894030f, -0.03353571f, 0.06319324f, 0.04142031f, -0.00472060f, -0.07450665f, 
    -0.02485960f, 0.13504125f, 0.04726971f, -0.07909440f, 0.02191804f, 0.07708129f, 0.19641513f, -0.06830618f, 
    -0.07695238f, -0.00216751f, 0.01085599f, -0.06956647f, 0.06823932f, 0.00438556f, 0.01717141f, -0.05436591f, 
    -0.06904241f, -0.10261862f, 0.03174924f, -0.04141276f, 0.26677397f, -0.04670101f, 0.04224249f, 0.04499330f, 
    -0.05544036f, -0.12753102f, -0.09686058f, 0.00289323f, 0.02516345f, 0.04599020f, -0.00586055f, -0.00209516f, 
    0.08361015f, 0.07234183f, 0.09727284f, 0.01636656f, 0.08453344f, 0.13900396f, 0.04077006f, 0.08524568f, 
    0.07382783f, 0.10317291f, -0.04342550f, -0.03749344f, 0.01682219f, 0.12607533f, -0.05393897f, -0.08121400f, 
    0.11374296f, 0.03789800f, 0.04847896f, 0.01592529f, 0.03945917f, -0.01343876f, -0.00366663f, -0.07247803f, 
    -0.20367491f, -0.04717264f, 0.07062229f, 0.00670992f, 0.04890387f, 0.07734735f, -0.05226902f, -0.01951590f, 
    -0.00267254f, 0.04309140f, 0.02937223f, 0.16030493f, 0.39910275f, 0.15876912f, 0.20584334f, -0.18963841f, 
    0.07522766f, 0.07219279f, 0.08106508f, 0.07072317f, -0.00273592f, 0.04086864f, -0.03276174f, 0.20976506f, 
    -0.06155314f, 0.03119075f, 0.04363899f, -0.00461252f, -0.00677795f, -0.08705086f, 0.13900283f, 0.08456003f, 
    -0.07704975f, 0.04854422f, -0.04589361f, 0.05525451f, -0.09536807f, 0.01509050f, 0.20110287f, 0.08750729f, 
    0.12991303f, 0.05677669f, 0.03111899f, -0.09585135f, 0.01348235f, 0.22407103f, -0.00520866f, 0.13301690f, 
    -0.02683612f, -0.07436815f, 0.11273843f, -0.03077955f, -0.02767320f, 0.04437225f, 0.03839557f, 0.13027246f, 
    0.06311419f, 0.03877944f, 0.05006593f, 0.08388363f, -0.12036976f, -0.05408793f, 0.15276505f, 0.10124170f, 
    0.06702811f, -0.06147056f, 0.09190810f, -0.07489963f, 0.02315189f, -0.08099695f, -0.14369731f, -0.00986064f, 
    -0.03791019f, -0.06047749f, -0.11283907f, -0.10920716f, 0.04731460f, -0.04847484f, -0.00828842f, 0.09639426f, 
    0.04183122f, -0.03679681f, -0.01392651f, 0.03485396f, -0.02416396f, -0.00684999f, -0.03247070f, 0.00477943f, 
    -0.03718488f, -0.03632598f, 0.00052880f, 0.17971966f, -0.13513918f, 0.06777250f, 0.07315052f, 0.08150738f, 
    0.16726552f, 0.16042259f, 0.03839963f, -0.00957776f, 0.04633819f, 0.09713507f, -0.09497856f, 0.13493761f, 
    0.06925604f, -0.04246707f, 0.03371288f, 0.00945033f, 0.13779397f, -0.09438431f, -0.07207485f, 0.12042948f, 
    0.03434687f, -0.08512622f, 0.02234160f, -0.07295477f, 0.06468894f, 0.09478141f, 0.18229331f, 0.07598431f, 
    0.20250992f, 0.21681634f, 0.01999373f, -0.11824891f, -0.07941243f, 0.10265260f, 0.06504018f, 0.11719660f, 
    0.13280177f, 0.10602661f, 0.00946662f, 0.13520613f, -0.24317397f, 0.09056988f, 0.14552499f, 0.17999974f, 
    0.06977677f, 0.00293197f, -0.05716717f, -0.01575075f, 0.01650922f, 0.17259958f, 0.10215361f, 0.17113237f, 
    0.11605000f, 0.08831768f, 0.10502044f, -0.08337170f, 0.02754728f, -0.08589521f, -0.00036401f, 0.07875886f, 
    0.05678586f, 0.13302730f, 0.09120512f, 0.08082519f, -0.07374126f, 0.03152004f, 0.11215065f, 0.12625445f, 
    -0.00956813f, 0.05854507f, 0.08753940f, 0.19241369f, 0.04639345f, 0.17723072f, 0.04581644f, 0.24177809f, 
    0.00609835f, 0.21659532f, 0.04878591f, -0.03851485f, -0.00783440f, 0.07155042f, -0.01249336f, -0.03006142f, 
    0.02589539f, 0.09452803f, 0.09093083f, 0.15504977f, -0.07773229f, -0.01298001f, 0.07967960f, 0.12459169f, 
    0.10962782f, -0.05140186f, -0.11938617f, 0.08713830f, 0.09615715f, -0.00228328f, 0.09990361f, 0.00370936f, 
    0.06135863f, 0.05576522f, 0.10788773f, 0.00536381f, 0.02848648f, 0.10164098f, 0.03074317f, -0.03400620f, 
    0.05652628f, 0.00982547f, 0.02619200f, -0.01111441f, -0.11713450f, -0.04483188f, 0.00642724f, 0.10825297f, 
    -0.03113578f, -0.00103956f, 0.05644242f, -0.00462749f, 0.07210615f, 0.09825826f, 0.01673795f, 0.06725474f, 
    0.06725232f, 0.02542349f, 0.05160998f, -0.00321584f, -0.01872323f, 0.01440030f, -0.01387834f, 0.08105543f, 
    0.05919245f, -0.01578734f, 0.10925950f, 0.00801644f, 0.05144899f, 0.10627416f, -0.00810633f, 0.00821702f, 
    0.07781452f, -0.04964411f, 0.00378999f, 0.05321125f, 0.06378441f, -0.04394352f, 0.00148340f, -0.01439315f, 
    0.10323029f, 0.09072501f, 0.11084582f, 0.04113920f, -0.09961654f, 0.01922368f, 0.19100468f, 0.06868969f, 
    0.11415672f, -0.03133904f, 0.04816348f, 0.01140077f, -0.04089012f, -0.01169334f, 0.01531545f, -0.01779740f, 
    -0.01576043f, 0.02387511f, 0.03944524f, -0.03780651f, 0.06086240f, 0.04311159f, -0.00982903f, 0.14304452f, 
    -0.05210856f, 0.07187792f, 0.02869262f, 0.03351399f, 0.04117092f, 0.05376076f, 0.18153198f, 0.06224027f, 
    -0.02631471f, 0.13881040f, -0.01748684f, 0.11413941f, 0.10830388f, 0.10364030f, 0.13942793f, 0.14579926f, 
    -0.01567483f, 0.09037008f, 0.09716717f, 0.09045972f, 0.14354162f, 0.05288509f, -0.04524561f, -0.06789695f, 
    -0.13701472f, 0.13671851f, 0.15099423f, 0.06211238f, 0.16782174f, 0.07630998f, 0.06916384f, 0.08821765f, 
    0.06334452f, 0.08026433f, -0.16745882f, 0.06287052f, 0.14808141f, -0.07061337f, 0.10671609f, 0.11824340f, 
    0.03693410f, -0.00211107f, 0.04693573f, 0.06760151f, -0.03363232f, 0.11762468f, -0.06309267f, 0.11249282f, 
    0.10946310f, 0.08619935f, 0.17388941f, 0.07096901f, 0.06335890f, -0.06207106f, -0.01834583f, -0.03340750f, 
    0.05146855f, 0.03782143f, 0.01378253f, -0.13003771f, -0.24481526f, -0.03757525f, 0.23478183f, 0.07076078f, 
    0.08905800f, 0.04940747f, 0.04240201f, -0.00664944f, 0.03262046f, 0.00392413f, 0.01425587f, 0.01048680f, 
    -0.09011437f, 0.08136337f, -0.00494491f, -0.00828572f, 0.05235517f, -0.01660531f, 0.10328536f, 0.10807622f, 
    0.14031552f, 0.16957995f, 0.09309064f, 0.13234051f, 0.03040122f, 0.05402238f, 0.00682661f, 0.07879024f, 
    0.02643203f, 0.13365722f, 0.10860208f, 0.01638285f, -0.02852249f, 0.02651862f, -0.00265047f, 0.09824695f, 
    -0.16738342f, 0.07872060f, 0.11125958f, -0.03063902f, 0.07321374f, 0.01652911f, 0.07715926f, 0.04100782f, 
    0.10018209f, -0.06655692f, -0.05135548f, 0.17849527f, 0.03760271f, 0.19269447f, 0.19087954f, 0.18196285f, 
    0.07085727f, -0.01781070f, 0.07003966f, 0.05907913f, 0.10679083f, 0.00434654f, -0.03408305f, 0.06055574f, 
    0.05908693f, 0.00011126f, 0.02829972f, 0.10479522f, -0.01266410f, 0.09954328f, 0.02726760f, -0.00802790f, 
    0.03555108f, -0.05367804f, 0.06506123f, 0.00918780f, -0.18980320f, 0.12957673f, 0.05839476f, 0.06090899f, 
    0.07896758f, 0.03283808f, -0.01814237f, 0.04175248f, 0.07016572f, -0.01645054f, 0.17288084f, -0.00153717f, 
    -0.19366808f, 0.01561183f, 0.03707069f, 0.04202059f, 0.09486692f, 0.05096899f, -0.02943843f, 0.07172019f, 
    -0.12777014f, 0.04356650f, 0.05270763f, 0.03131522f, 0.10441919f, 0.06975112f, 0.06613164f, -0.08624145f, 
    0.06814111f, 0.07862793f, 0.04795432f, -0.03433916f, -0.04857351f, 0.11323790f, 0.00387157f, -0.14008093f, 
    0.04484900f, 0.05842935f, 0.03949023f, 0.11031532f, 0.02521155f, 0.12822644f, 0.14044437f, 0.11231046f, 
    0.08517918f, 0.11199314f, -0.00765824f, 0.20535135f, -0.07623940f, 0.31187057f, -0.02572450f, 0.08295340f, 
    0.11651964f, 0.05584882f, 0.15224405f, 0.09324473f, -0.01785264f, 0.09061848f, 0.19317545f, 0.00097167f, 
    -0.03051154f, 0.15698302f, 0.08093882f, 0.20349616f, -0.00187936f, 0.04891139f, 0.06807475f, -0.05761107f, 
    -0.04424761f, 0.11023393f, 0.06187883f, 0.00634306f, 0.05504100f, 0.00717414f, -0.05776243f, 0.02764561f, 
    0.03772502f, -0.08825291f, -0.04461525f, 0.08357647f, -0.03282372f, -0.00369681f, 0.04309089f, -0.08397027f, 
    0.18341558f, -0.14945109f, 0.11140610f, 0.11410238f, -0.05484260f, 0.17425394f, 0.15418555f, 0.07370958f, 
    0.06192095f, -0.01115120f, -0.00500903f, 0.06338722f, 0.27835083f, 0.10235482f, 0.04794050f, -0.02685901f, 
    -0.05012941f, -0.02428906f, 0.15971689f, 0.12289414f, 0.05816346f, 0.15624459f, 0.02172735f, 0.12939122f, 
    -0.11424949f, 0.01118348f, 0.00909885f, -0.02043743f, 0.04995426f, 0.07735251f, 0.05845924f, 0.00786726f, 
    -0.01869316f, 0.02995212f, 0.03032973f, -0.01896046f, -0.08807793f, -0.05815929f, 0.12649742f, 0.00211592f, 
    0.11641880f, 0.13966979f, 0.02450916f, 0.07871806f, -0.01242575f, 0.04248794f, -0.00422641f, 0.05736916f, 
    -0.05410434f, 0.01073175f, 0.04559587f, 0.17214009f, -0.00708458f, 0.07330096f, 0.13405088f, -0.00831710f, 
    0.09280474f, 0.03770828f, 0.03849302f, -0.09677178f, -0.01767588f, 0.11244624f, 0.20437852f, 0.14890926f, 
    0.01418458f, 0.05843905f, 0.01866614f, 0.02485485f, 0.12194817f, -0.01987094f, 0.01841848f, -0.08993880f, 
    -0.21371941f, 0.06887049f, 0.04813427f, 0.07667943f, 0.02343060f, 0.01304103f, 0.13370132f, -0.01430480f, 
    0.09717667f, -0.00593655f, -0.11121710f, 0.06840375f, -0.18045484f, 0.00932854f, 0.05877766f, -0.02722033f, 
    0.00892858f, 0.11640492f, 0.11144680f, 0.19071560f, 0.09471396f, 0.03903649f, 0.16892760f, 0.12670675f, 
    0.44047308f, 0.11623889f, 0.09124687f, 0.03570191f, -0.04664750f, 0.06753898f, -0.01528798f, 0.02815909f, 
    0.04928693f, -0.12839985f, 0.14218748f, 0.09626742f, -0.03888693f, 0.02274796f, -0.16212767f, -0.00323062f, 
    0.11614165f, -0.04943079f, -0.04623356f, 0.09616311f, 0.04090459f, 0.04162822f, 0.11677081f, -0.03024742f, 
    0.15465750f, 0.13515404f, -0.11581135f, 0.12593885f, -0.01408150f, 0.08410599f, 0.12894285f, -0.03405856f, 
    0.00195829f, -0.02072429f, -0.02986272f, -0.03744923f, -0.12501337f, 0.07907181f, 0.14595625f, 0.08738870f, 
    -0.00321489f, 0.06421578f, 0.04047102f, -0.01979356f, 0.08330470f, 0.07785991f, 0.05727345f, -0.03564254f, 
    0.00703515f, -0.13752902f, -0.17476059f, -0.15559469f, 0.12305439f, 0.04849023f, -0.06616358f, 0.13013946f, 
    0.03217542f, 0.04427842f, -0.07847498f, -0.07710471f, -0.02537191f, 0.14378138f, -0.08061476f, -0.00313711f, 
    0.01094242f, -0.00609355f, -0.00793414f, -0.00109136f, 0.00796211f, -0.07254388f, 0.06047493f, -0.04765018f, 
    -0.16756697f, 0.14267929f, 0.09568908f, 0.01401004f, 0.12431639f, -0.07311036f, 0.10307854f, 0.08918148f, 
    0.03088161f, -0.06692706f, -0.00882670f, -0.03851693f, -0.11565562f, -0.02373674f, 0.01568612f, 0.10157051f, 
    0.03930372f, 0.07746486f, -0.06020869f, 0.04280493f, 0.07187759f, 0.00208824f, 0.01440090f, -0.05256778f, 
    0.16053993f, 0.04112576f, -0.00787836f, 0.09606562f, 0.00131246f, -0.06209573f, -0.01030046f, 0.06769907f, 
    0.09887426f, -0.07030416f, 0.13889755f, -0.00172763f, -0.11336387f, 0.12564805f, 0.06678714f, 0.02686895f, 
    0.00949333f, 0.06564400f, 0.02758639f, 0.10894574f, 0.08850233f, 0.06599411f, 0.17930199f, -0.10879964f, 
    -0.02098391f, -0.02559290f, 0.02871276f, -0.08406070f, -0.01843776f, 0.13520899f, 0.05956318f, 0.09907372f, 
    0.00901755f, 0.10129587f, 0.08736289f, 0.13278385f, 0.13522604f, 0.06599768f, 0.03640983f, -0.15204588f, 
    0.17219357f, 0.00595842f, -0.14937407f, 0.04785896f, -0.00237459f, 0.07043198f, -0.06268682f, -0.01310566f, 
    0.21108206f, 0.06483915f, -0.02120391f, -0.07408056f, -0.02504259f, 0.04383116f, 0.06295949f, 0.08173937f, 
    0.06974169f, -0.02846960f, 0.04007955f, -0.06568674f, 0.03769541f, -0.00320373f, 0.15060861f, -0.04764608f, 
    0.15844987f, 0.11356375f, -0.06180633f, 0.04994164f, 0.00491652f, -0.07670275f, 0.12188727f, 0.13270384f, 
    -0.01996583f, -0.02430620f, -0.02712619f, 0.10610927f, 0.00043290f, 0.12780337f, 0.00320601f, 0.10500346f, 
    0.10130868f, 0.05040707f, 0.03745425f, 0.07681578f, 0.05263370f, 0.13505602f, -0.09285954f, 0.04571088f, 
    0.11097468f, -0.05925538f, -0.01565929f, 0.05814619f, -0.00775983f, -0.06865483f, 0.02171172f, 0.04125640f, 
    0.02685185f, -0.00245245f, 0.02136547f, -0.02674952f, -0.01548415f, 0.00589885f, -0.00838998f, 0.00648954f, 
    0.00838499f, 0.00178893f, 0.01027393f, -0.01642992f, 0.02674853f, -0.00284905f, 0.01130633f, 0.00180619f, 
    0.02226367f, -0.01787766f, 0.03848222f, 0.00273298f, 0.02722185f, 0.00095684f, -0.00965839f, -0.02450635f, 
    -0.01423074f, 0.01656293f, 0.00030109f, 0.00807264f, 0.02892905f, -0.02241536f, -0.02037763f, -0.03605922f, 
    0.02268240f, -0.00327090f, -0.00223634f, 0.01981292f, 0.01132389f, 0.00462022f, -0.02459581f, 0.02515745f, 
    -0.02037291f, 0.02263958f, -0.02659141f, 0.00396901f, -0.02265634f, -0.01846307f, -0.02497913f, -0.02115012f, 
    -0.00891351f, 0.02021534f, -0.02310877f, -0.01769606f, 0.00494262f, -0.01144276f, -0.03919867f, 0.01447174f, 
    -0.03650883f, -0.00735424f, -0.01219797f, 0.03679982f, 0.01265560f, -0.03533714f, -0.01067043f, 0.00896057f, 
    -0.02736908f, 0.01228862f, 0.01180348f, -0.00318377f, -0.02111584f, 0.00214738f, -0.00365875f, -0.01715911f, 
    -0.00320739f, 0.00855642f, -0.00283381f, -0.01498883f, -0.02839757f, 0.02251160f, -0.02249125f, -0.01920081f, 
    -0.02186326f, 0.00997894f, -0.00487041f, 0.00968909f, -0.00568099f, 0.02017879f, 0.01101945f, -0.02095579f, 
    0.02265152f, -0.00694574f, -0.02950004f, -0.00080605f, 0.00383693f, 0.03593371f, -0.02256614f, -0.03209705f, 
    0.02883257f, -0.03037860f, -0.04096060f, 0.02472256f, -0.02036013f, -0.03000549f, -0.03843611f, -0.03310362f, 
    -0.00093108f, -0.01502694f, 0.00085877f, 0.01034556f, 0.00022632f, -0.02601147f, -0.01866091f, 0.01360301f, 
    -0.00031651f, -0.02277459f, -0.03845774f, -0.01254147f, -0.03955714f, -0.01226236f, -0.00603967f, 0.01593166f, 
    0.03031904f, 0.00062648f, 0.02654835f, 0.00060842f, -0.03538127f, -0.01426114f, 0.03072903f, -0.03939582f, 
    0.01250614f, 0.00121452f, 0.01931200f, 0.02073571f, -0.00142211f, 0.00044744f, -0.00151871f, 0.02262909f, 
    0.02568448f, 0.02177202f, -0.03032137f, 0.02743598f, -0.02800027f, 0.01256649f, 0.00162293f, -0.00452161f, 
    0.02677553f, -0.02695820f, 0.01033134f, -0.04001803f, -0.03941322f, -0.01144754f, -0.02047116f, -0.01843307f, 
    0.00052761f, 0.00353353f, 0.01652424f, 0.01017318f, -0.02386744f, -0.01760087f, -0.00857074f, -0.01244556f, 
    0.02491844f, 0.01876633f, 0.01071825f, 0.02853218f, -0.00970461f, -0.03245672f, 0.03631733f, 0.00508931f, 
    -0.04312444f, -0.03408985f, -0.02699518f, 0.00023769f, 0.01935628f, 0.00979553f, 0.01317778f, 0.00125977f, 
    -0.01665964f, -0.01129233f, 0.00391728f, 0.02656922f, 0.02155104f, 0.00650078f, -0.02881481f, -0.02988913f, 
    0.01636313f, 0.02908211f, -0.02919221f, -0.01524254f, 0.01530022f, -0.03088127f, -0.03112567f, -0.01471153f, 
    -0.01339296f, -0.02394681f, 0.03058128f, -0.00732986f, -0.00705331f, 0.01201362f, 0.01818055f, -0.00551297f, 
    -0.03261887f, -0.03168415f, 0.00828936f, 0.01251893f, -0.00143855f, 0.01738922f, 0.02686415f, 0.01158457f, 
    -0.02717089f, 0.00265936f, 0.01559153f, -0.01070279f, -0.02469875f, -0.00965042f, -0.02340624f, 0.01672724f, 
    -0.03090318f, -0.00730765f, 0.00685989f, 0.00939405f, -0.02422472f, 0.03563818f, -0.01703081f, -0.01993185f, 
    -0.01758957f, 0.01420927f, 0.00339713f, -0.02754886f, -0.04238169f, -0.00597041f, 0.02940279f, -0.02354107f, 
    0.01967502f, -0.01235597f, 0.02244738f, -0.00226024f, -0.00350697f, 0.03058039f, -0.00876343f, -0.02091778f, 
    -0.00492733f, 0.01576255f, 0.00474003f, 0.02881027f, -0.03080686f, 0.02345678f, 0.02285845f, 0.00840012f, 
    -0.02340918f, -0.00795380f, -0.03937795f, 0.00227377f, -0.01610348f, 0.01495285f, 0.01451680f, 0.01210706f, 
    -0.01388614f, 0.01461258f, -0.03044406f, -0.00614050f, 0.01501812f, 0.00268969f, -0.02135931f, 0.00607280f, 
    -0.00125028f, -0.00942294f, 0.02072415f, -0.02348866f, -0.02233149f, 0.01617792f, -0.02695185f, 0.02744896f, 
    0.00925042f, -0.00603805f, 0.01673502f, -0.02569071f, -0.03486731f, 0.02237285f, 0.00727891f, -0.00387767f, 
    0.03307149f, 0.01081132f, -0.01171925f, 0.00902108f, 0.01921723f, 0.00494332f, 0.00389709f, -0.02238335f, 
    0.02510154f, 0.02020702f, -0.00126196f, 0.01160245f, -0.01349458f, -0.01674649f, -0.00729473f, -0.02454193f, 
    -0.01167823f, -0.03666305f, -0.01043011f, 0.00230782f, -0.03754143f, 0.01938227f, 0.01145210f, 0.01025639f, 
    0.02554684f, -0.00192045f, -0.03970161f, 0.03112934f, 0.03087836f, -0.03264130f, 0.00077452f, 0.00823667f, 
    0.00709057f, 0.00173902f, -0.04087796f, 0.00045647f, 0.01759807f, -0.02237582f, -0.01074377f, -0.00266586f, 
    0.00337557f, -0.01860889f, 0.00435728f, 0.02421354f, 0.01352427f, -0.00826420f, -0.01373416f, 0.01624425f, 
    0.01902320f, 0.00497577f, 0.01473216f, 0.00590776f, 0.01727094f, -0.03944388f, -0.00758873f, 0.00542284f, 
    -0.00327995f, 0.02518760f, 0.03799031f, 0.01370317f, -0.03463979f, 0.01694061f, -0.01315181f, 0.00715110f, 
    0.00493234f, 0.02628001f, 0.02512272f, 0.00108693f, 0.00239790f, -0.00098134f, 0.02120330f, -0.04035317f, 
    -0.00576586f, -0.00553018f, -0.02855269f, 0.02547695f, -0.03453118f, -0.01734747f, 0.01453703f, -0.04156031f, 
    0.02609706f, -0.01257622f, 0.02053899f, 0.02905142f, 0.00905166f, 0.03439810f, 0.00361724f, 0.03484039f, 
    -0.02657005f, -0.03492334f, 0.02589495f, -0.03782627f, -0.00372578f, -0.01067751f, -0.01867901f, 0.02167710f, 
    -0.02394683f, -0.02065697f, 0.01139386f, -0.01995745f, -0.01018944f, 0.02850155f, -0.01628558f, -0.03324680f, 
    -0.03887290f, -0.02305573f, 0.02303693f, -0.01669490f, -0.01097838f, 0.00684967f, -0.00337653f, -0.03569315f, 
    -0.03457391f, -0.00404829f, -0.01547635f, 0.01618198f, -0.00719741f, -0.04080073f, 0.01130400f, 0.00323179f, 
    -0.01264761f, -0.02211619f, 0.02927217f, 0.01776803f, 0.02671614f, 0.01602948f, 0.00029047f, -0.03450780f, 
    0.01298919f, -0.01723329f, -0.02163185f, -0.01116675f, 0.01671622f, -0.00009258f, -0.04123788f, -0.03589322f, 
    0.01426379f, -0.03011728f, -0.04208091f, -0.00241969f, -0.01394481f, 0.02815787f, 0.00768137f, -0.02691934f, 
    0.00717093f, 0.01846236f, -0.03837106f, 0.00984286f, 0.01735601f, 0.02304239f, 0.00097619f, -0.00354083f, 
    0.02478597f, 0.01760991f, -0.02035665f, -0.03958626f, -0.00038968f, -0.00061318f, -0.03651470f, -0.03823859f, 
    -0.03301897f, 0.03402302f, -0.01327673f, -0.00819192f, 0.02775220f, 0.02025113f, 0.02278928f, -0.04305722f, 
    0.01085058f, 0.01314302f, 0.00152831f, -0.03926468f, -0.02989823f, 0.00631517f, -0.02472012f, -0.01408108f, 
    -0.00751639f, 0.00146095f, 0.01488762f, 0.01769802f, -0.03911303f, -0.02944859f, -0.04095765f, -0.01655087f, 
    -0.01159190f, 0.00040545f, -0.03265838f, 0.00150868f, -0.02412438f, -0.01859421f, -0.03605620f, -0.03694304f, 
    0.01698863f, -0.01167047f, 0.01706851f, 0.00841290f, 0.02713369f, 0.02476153f, 0.02375126f, -0.03170979f, 
    0.02745236f, 0.02182766f, 0.00656846f, 0.01428798f, 0.02111675f, -0.00307696f, -0.02488707f, -0.03952378f, 
    -0.01321987f, -0.03728926f, -0.01924840f, -0.03244162f, -0.01044216f, -0.02800212f, -0.01696815f, -0.02962582f, 
    0.01277352f, -0.00507628f, -0.03678472f, 0.01344866f, 0.00945212f, -0.03709910f, -0.00189753f, -0.02138003f, 
    -0.01263971f, -0.02618750f, -0.00592750f, -0.02203285f, -0.01001772f, -0.02364161f, 0.00847655f, -0.03278921f, 
    -0.02178498f, -0.00037533f, 0.02825066f, 0.00020357f, -0.03019398f, -0.01759297f, 0.01978856f, 0.02229295f, 
    0.03062082f, -0.01349477f, -0.00970323f, 0.02527359f, 0.03031433f, 0.01717248f, 0.01324453f, 0.00353415f, 
    -0.02934611f, 0.00965022f, -0.03121797f, 0.01561928f, -0.01041368f, -0.03130776f, 0.00508520f, -0.02477419f, 
    -0.04003458f, 0.01386597f, -0.03731905f, -0.02975958f, -0.03342701f, -0.02057677f, -0.01352986f, 0.01245536f, 
    -0.03904876f, -0.02167335f, 0.00616303f, -0.03566854f, -0.00386263f, 0.01338249f, 0.02272400f, 0.01973588f, 
    -0.02817773f, -0.02259495f, -0.04015326f, 0.01137095f, -0.02888742f, -0.02505810f, 0.01633765f, 0.00608166f, 
    0.01132274f, -0.01108395f, 0.01990051f, 0.02964275f, -0.02744169f, -0.02751013f, -0.02929024f, -0.03191845f, 
    -0.03871258f, -0.01591977f, -0.03619316f, 0.02096200f, -0.03282733f, -0.00495702f, 0.01218086f, 0.00701417f, 
    -0.02083777f, 0.00606907f, -0.02761595f, -0.02338492f, 0.01373831f, 0.01123806f, -0.01419692f, -0.00728808f, 
    -0.01317702f, 0.01439276f, -0.01717778f, 0.02266953f, 0.01494269f, -0.00227109f, 0.02105433f, 0.00247121f, 
    -0.02594533f, -0.01284641f, -0.04097939f, -0.02223278f, -0.03867127f, -0.01366427f, -0.02652534f, 0.02312144f, 
    -0.02127041f, -0.01286770f, 0.01187135f, -0.04146883f, 0.01720241f, -0.01737087f, 0.00217507f, -0.03131950f, 
    -0.00852508f, 0.02691023f, -0.01224903f, -0.00532862f, -0.04165467f, -0.00657975f, 0.01323518f, -0.02300523f, 
    -0.02687710f, 0.00033563f, -0.00145227f, -0.01292096f, -0.03093584f, -0.00822538f, 0.00872336f, 0.01891114f, 
    -0.02374024f, 0.00897699f, 0.03145238f, -0.01451985f, -0.00982032f, -0.00473054f, 0.01984354f, -0.00448602f, 
    -0.02300170f, -0.02778521f, -0.00828210f, 0.02696820f, 0.00746823f, -0.01982224f, 0.00824925f, 0.02681322f, 
    -0.00871239f, -0.00123094f, -0.01193797f, 0.00986741f, -0.01228756f, 0.01558512f, 0.02288822f, -0.00461691f, 
    -0.00402722f, 0.00101529f, -0.03387839f, 0.03264625f, 0.02535996f, -0.02166752f, -0.03645553f, 0.02358459f, 
    0.01514246f, -0.04113535f, -0.02524244f, 0.02613587f, 0.01390405f, -0.03334124f, -0.00869756f, -0.01577828f, 
    -0.01781110f, -0.03477405f, -0.03061114f, 0.02393509f, -0.00994719f, -0.03355082f, 0.00996082f, 0.00448404f, 
    0.02011156f, 0.00940864f, -0.03378053f, 0.00475852f, -0.01436432f, -0.01625029f, -0.03383165f, 0.01678651f, 
    0.01719508f, 0.02147475f, -0.01107018f, 0.00930438f, -0.03283286f, -0.02417785f, 0.02268379f, 0.02163920f, 
    0.00197264f, 0.01203460f, -0.02827506f, 0.01600333f, 0.00748676f, -0.00186813f, 0.03638920f, -0.00592222f, 
    -0.01649173f, 0.00824192f, 0.02865512f, -0.04215556f, -0.01953274f, -0.02864703f, -0.00304738f, -0.03188729f, 
    -0.01469396f, -0.02885821f, 0.02337891f, -0.03988488f, -0.01668985f, -0.03381047f, -0.01533147f, -0.02708626f, 
    0.02710131f, -0.02750498f, 0.00334298f, -0.00666876f, 0.02720219f, -0.02836781f, 0.02930782f, -0.01421461f, 
    -0.01833013f, 0.01629460f, 0.02628249f, -0.03747081f, -0.02187089f, -0.00907552f, -0.00338485f, -0.00848744f, 
    -0.03463159f, -0.00994307f, -0.01618055f, 0.02296597f, -0.00579493f, -0.01105120f, -0.01514351f, 0.03137404f, 
    0.00247022f, 0.01780528f, -0.01035450f, 0.00504502f, -0.02445285f, 0.02490843f, -0.00209095f, -0.00857772f, 
    0.01079479f, -0.02687825f, -0.00811302f, 0.00454706f, -0.01359557f, -0.03423100f, -0.00429033f, 0.03095098f, 
    -0.00155075f, 0.00601496f, -0.01933994f, 0.02188855f, 0.01940510f, 0.02562654f, 0.02188438f, 0.00497990f, 
    -0.00681494f, 0.00188988f, -0.01209324f, 0.01281354f, -0.02501994f, 0.01372202f, 0.00539438f, 0.01524882f, 
    -0.02946142f, -0.01233473f, 0.07796845f, -0.05965465f, 0.15336128f, -0.03837085f, 0.05144487f, -0.01535669f, 
    -0.02556041f, 0.01110501f, 0.01013706f, -0.00637898f, -0.25141817f, 0.13058111f, 0.15291122f, -0.06984442f, 
    -0.00009379f, -0.04104508f, -0.01288608f, 0.02761530f, -0.00853907f, 0.01959652f, 0.04818977f, 0.05484937f, 
    0.17338379f, -0.12109856f, -0.12215336f, -0.16358054f, 0.08741434f, -0.04820513f, -0.02921968f, 0.12834087f, 
    0.00620342f, -0.00194331f, -0.01535453f, 0.02032881f, 0.05380523f, 0.07864244f, -0.07554199f, 0.13309918f, 
    -0.09812771f, -0.03410596f, -0.00553782f, 0.03902116f, 0.13131820f, -0.08626574f, -0.02113647f, -0.01638148f, 
    0.22656342f, 0.07525795f, -0.08787381f, -0.00192936f, 0.11708412f, -0.13118495f, 0.03580149f, 0.07906417f, 
    0.02115823f, 0.02693919f, -0.05926164f, 0.05993914f, 0.31273067f, -0.08671851f, -0.04866402f, 0.11954370f, 
    0.00519031f, 0.03027437f, -0.04362901f, 0.05073684f, 0.00438865f, -0.00913699f, 0.03406095f, 0.02958012f, 
    0.10753832f, 0.09870637f, -0.18908648f, 0.19071145f, 0.12034316f, 0.09470458f, -0.03771840f, 0.11359358f, 
    0.05552267f, -0.02544147f, -0.00240144f, -0.03450771f, -0.03784667f, -0.14766237f, 0.08092014f, -0.04910225f, 
    -0.00733089f, 0.04923557f, -0.03698841f, -0.01775869f, 0.04401289f, 0.06556357f, 0.00464468f, 0.01662102f, 
    0.05780891f, 0.18487483f, 0.05310222f, -0.18011424f, -0.07858942f, -0.08304202f, -0.00183424f, 0.04965114f, 
    0.00649485f, 0.06761947f, -0.05568522f, -0.00832638f, 0.03025805f, -0.06139369f, -0.01775774f, 0.04917013f, 
    -0.02544412f, 0.06850247f, -0.07817940f, -0.08039965f, 0.05128077f, -0.02781291f, 0.13117547f, -0.08989823f, 
    0.10065192f, 0.04565668f, -0.03917521f, -0.10468899f, 0.02944079f, -0.01812868f, 0.02621474f, 0.06530765f, 
    -0.06060245f, 0.02348231f, -0.10986288f, 0.04565731f, 0.14728406f, -0.04894717f, 0.08571198f, 0.05271468f, 
    -0.05089122f, 0.08600057f, -0.09073554f, 0.03336009f, 0.03888589f, 0.04128288f, -0.03386105f, 0.02687903f, 
    0.29825163f, -0.00055768f, -0.05495154f, -0.13845085f, 0.01324021f, 0.06312924f, 0.12385717f, 0.03521662f, 
    -0.03243997f, 0.01553338f, 0.02409812f, -0.00039998f, 0.10308682f, -0.01064154f, -0.07102118f, -0.02096476f, 
    0.04605253f, 0.01492738f, 0.04873942f, 0.13832797f, 0.01994118f, -0.05743907f, -0.07339654f, -0.01004223f, 
    0.12035574f, 0.03525538f, 0.11608454f, 0.05124027f, -0.09414248f, -0.06563982f, 0.06406163f, 0.07465155f, 
    -0.02133588f, -0.01445050f, -0.01360037f, 0.03076716f, 0.02625305f, 0.08312640f, -0.22501561f, 0.16671920f, 
    -0.05037791f, 0.07104911f, -0.05487137f, 0.00347041f, -0.01366499f, 0.07015004f, 0.02683237f, -0.02385094f, 
    0.07003804f, -0.12434188f, 0.08534696f, -0.24672884f, 0.00046576f, -0.03837807f, 0.14099680f, 0.04020559f, 
    0.02142976f, 0.04257951f, -0.00949789f, 0.06529430f, -0.27285483f, -0.19560759f, 0.17148662f, -0.14195322f, 
    0.06833664f, 0.00081959f, 0.02631058f, 0.03488658f, -0.01186899f, 0.00178783f, -0.03140930f, -0.08663990f, 
    0.24191327f, 0.03963769f, -0.14463867f, -0.04796024f, -0.01347634f, -0.04420634f, -0.07712200f, 0.09964851f, 
    0.07006623f, 0.06847983f, -0.03811635f, 0.00314310f, -0.07793885f, 0.23875372f, 0.01370095f, -0.12259955f, 
    -0.04184716f, -0.00345535f, -0.01729536f, 0.06574681f, -0.05216328f, 0.04864011f, 0.01195327f, 0.03135020f, 
    0.17350900f, 0.07387207f, -0.16252474f, -0.10807134f, -0.03899987f, 0.02921935f, 0.05383296f, 0.09952459f, 
    0.01519524f, 0.03664658f, 0.06981267f, -0.01878212f, -0.01605469f, 0.08093967f, -0.04779346f, 0.01771970f, 
    -0.06288873f, 0.11240701f, 0.06296632f, -0.03722568f, -0.08857584f, 0.03353694f, 0.06840342f, 0.06104862f, 
    0.20758517f, 0.01463633f, -0.07602920f, 0.02401635f, 0.15268397f, 0.02254177f, -0.01003256f, 0.00557770f, 
    -0.02510950f, 0.04623861f, -0.05921355f, 0.09077828f, 0.08508071f, 0.01688379f, -0.19632488f, 0.19321379f, 
    0.00891793f, 0.09450828f, -0.00400724f, 0.06873260f, -0.03975791f, -0.08239019f, -0.02925334f, 0.01009542f, 
    -0.26414230f, 0.23966654f, 0.10577053f, -0.04396472f, -0.13869865f, 0.14750430f, 0.05690169f, -0.04791726f, 
    -0.00347553f, 0.04696638f, -0.00690751f, -0.02141109f, -0.19422092f, -0.05247748f, 0.18523581f, -0.16900176f, 
    0.05874721f, 0.03461307f, -0.02033221f, -0.01326398f, 0.05734491f, 0.03429075f, 0.02250051f, 0.01877570f, 
    -0.04083669f, 0.08556619f, -0.07267629f, 0.07450444f, -0.06582048f, -0.03556474f, 0.02388194f, 0.07913309f, 
    -0.08882290f, 0.07782461f, 0.04900568f, 0.09661882f, -0.04818655f, 0.08296692f, 0.16839163f, -0.07310142f, 
    -0.06115989f, 0.03468385f, 0.02425133f, -0.01360771f, -0.07115985f, -0.05639122f, 0.05000727f, 0.01200444f, 
    -0.01847509f, -0.01066099f, -0.25336081f, 0.22863701f, 0.03167186f, 0.03836550f, -0.03343988f, 0.00623698f, 
    -0.08526617f, 0.03363693f, 0.03213961f, 0.02766445f, -0.03861312f, -0.09941117f, 0.20964582f, -0.17094511f, 
    0.04243036f, 0.01850023f, 0.10738925f, 0.03477143f, -0.09075294f, -0.06816854f, 0.01314710f, 0.08178791f, 
    -0.03735718f, 0.06715509f, 0.02900937f, -0.12411628f, -0.00873898f, 0.00000692f, 0.01324169f, -0.00927814f, 
    -0.01707897f, 0.11006436f, -0.00886663f, 0.01373176f, -0.01980789f, -0.07685763f, 0.14207327f, -0.11268666f, 
    -0.01271721f, -0.04973670f, 0.03555473f, -0.01125816f, -0.05554957f, -0.00510191f, 0.05645970f, 0.02726889f, 
    0.09562261f, 0.00161443f, 0.38668972f, -0.02765091f, 0.00269753f, 0.02952779f, 0.14884344f, -0.06291020f, 
    -0.10108880f, -0.05601696f, 0.09455954f, 0.05035776f, 0.22699419f, 0.02391956f, -0.04098902f, 0.04257805f, 
    -0.00865211f, 0.01089850f, -0.14808218f, -0.00869731f, 0.03873493f, -0.02341113f, -0.06699056f, -0.04825863f, 
    -0.01496313f, -0.06058086f, 0.04850109f, -0.16906446f, 0.13726123f, 0.09338727f, -0.07580828f, 0.02048671f, 
    0.07740332f, 0.02597499f, -0.01099270f, 0.01009888f, -0.02761792f, -0.02254829f, 0.08694088f, -0.17324492f, 
    -0.02085395f, 0.02055455f, 0.01595717f, -0.06752092f, -0.01462709f, 0.02770220f, -0.05286023f, 0.01737640f, 
    -0.10138442f, 0.17305702f, -0.09777847f, 0.14588556f, -0.02669325f, 0.03537600f, 0.05466982f, -0.08559355f, 
    0.01953532f, 0.03312637f, -0.06615598f, -0.02706821f, 0.07009231f, 0.14318085f, 0.06930195f, 0.01590178f, 
    0.14966595f, -0.00976748f, -0.11032201f, 0.13883255f, -0.01041939f, -0.03102913f, -0.00652252f, 0.05047745f, 
    0.04079368f, -0.22994268f, -0.12818722f, 0.12748073f, 0.01474963f, -0.02516150f, -0.01659755f, 0.00227118f, 
    0.02693334f, 0.00753903f, 0.08096370f, 0.06912082f, -0.04653475f, -0.07302675f, 0.08926990f, -0.28685439f, 
    -0.06242608f, -0.05383975f, 0.00241700f, 0.02324989f, -0.00212831f, -0.04636187f, 0.13229792f, 0.04098695f, 
    -0.01214514f, 0.16850248f, -0.04344381f, 0.26184449f, -0.06354020f, 0.01923642f, 0.03633444f, -0.05146935f, 
    0.15388332f, 0.08110578f, -0.04405229f, 0.05903677f, 0.10305462f, 0.02233908f, 0.01186661f, -0.07569174f, 
    -0.10752853f, 0.05773574f, 0.04404686f, 0.01026943f, -0.00988023f, -0.06538862f, 0.07625274f, 0.00061106f, 
    0.05979605f, 0.02637219f, 0.04501941f, 0.00442803f, 0.05440220f, 0.01639367f, 0.09479698f, 0.03523718f, 
    -0.00996003f, 0.08424406f, 0.03771810f, -0.04901898f, 0.04656772f, -0.08299335f, -0.06365110f, -0.07585087f, 
    0.01868869f, -0.01274672f, -0.03535274f, 0.05137267f, -0.01780985f, -0.06546903f, 0.02802026f, -0.01497780f, 
    0.10670318f, 0.26322767f, -0.11265387f, -0.03554194f, -0.00767857f, 0.06427741f, 0.00713923f, -0.03778689f, 
    -0.01153001f, 0.06540471f, 0.03916792f, -0.09523737f, 0.21299189f, 0.13090840f, 0.27067751f, -0.12401842f, 
    -0.05193007f, 0.06235210f, 0.01358820f, 0.03223230f, 0.10228366f, 0.04294908f, 0.05080323f, 0.01622644f, 
    0.17877276f, 0.04386641f, -0.06701945f, 0.17472933f, -0.01603864f, 0.06592543f, -0.15459931f, 0.00073108f, 
    0.06775171f, 0.01531069f, 0.09401810f, 0.03396034f, 0.18339171f, -0.02032204f, 0.12533423f, -0.24592757f, 
    0.00031484f, -0.06949237f, 0.03500170f, 0.17549771f, -0.03379133f, -0.01223031f, 0.06193331f, -0.05952395f, 
    -0.14848506f, -0.10803433f, 0.15480280f, 0.01633244f, -0.05824166f, -0.08491595f, 0.04414192f, -0.07405402f, 
    -0.01926873f, 0.02485244f, 0.03513466f, 0.03470934f, 0.21842192f, -0.02284494f, 0.01380303f, 0.05128691f, 
    0.04067696f, 0.01508040f, 0.02551896f, 0.01015552f, -0.01123649f, 0.01696312f, 0.06058973f, 0.04972260f, 
    -0.03607688f, 0.04649044f, 0.02235171f, -0.07114651f, -0.02108371f, 0.04683902f, -0.00878090f, -0.07077652f, 
    -0.02312593f, -0.02865861f, 0.07773759f, 0.00267540f, 0.07672717f, -0.08157480f, 0.21616310f, -0.08454159f, 
    -0.06412666f, -0.03309305f, 0.14632973f, 0.01676969f, -0.02347760f, 0.01781622f, -0.03686818f, 0.07983481f, 
    -0.00418393f, -0.11352934f, -0.01074249f, -0.13393043f, 0.07955249f, -0.06180200f, -0.01511222f, 0.00792638f, 
    -0.05427702f, -0.01747451f, 0.00783073f, -0.03171622f, 0.04518827f, -0.15173151f, -0.18161915f, 0.03383610f, 
    -0.03438403f, -0.02446843f, 0.09224814f, -0.01874353f, -0.00584899f, -0.03513662f, -0.11400092f, 0.07013191f, 
    -0.00174552f, -0.00757671f, 0.03073982f, -0.05793796f, -0.00087857f, 0.02727306f, -0.00582321f, 0.05260794f, 
    0.05336953f, 0.11084323f, -0.02483973f, -0.01530354f, 0.23053628f, 0.01491525f, -0.16466108f, -0.03611149f, 
    -0.04539992f, 0.12172996f, -0.19124362f, 0.07818952f, -0.07278276f, 0.05691546f, 0.05103142f, 0.00548439f, 
    0.07549725f, -0.14822762f, -0.01430103f, -0.02031160f, -0.01679299f, 0.05798976f, 0.09522617f, 0.05585252f, 
    0.01707966f, -0.04342583f, 0.03061033f, -0.07650501f, 0.05973202f, -0.14611824f, 0.13389914f, -0.06517104f, 
    -0.04390826f, -0.10902973f, 0.08817099f, 0.06254303f, -0.06415708f, -0.01781093f, 0.01984773f, -0.06284148f, 
    0.11702933f, 0.08965006f, 0.11928385f, -0.15284003f, 0.00266824f, -0.05496434f, 0.00210337f, 0.09083358f, 
    -0.05511445f, -0.06711995f, 0.00341264f, -0.00363814f, 0.14998084f, 0.01960141f, -0.07559727f, 0.08530953f, 
    0.01552872f, -0.14565454f, -0.04364898f, 0.07213981f, 0.01940834f, 0.05332565f, -0.14516544f, -0.02471051f, 
    -0.01010265f, 0.05371233f, -0.10356396f, -0.04149300f, -0.05452143f, -0.03720962f, 0.04882960f, 0.03978523f, 
    0.00758224f, 0.02896377f, -0.01224705f, 0.01229566f, -0.28149492f, 0.09816500f, -0.03858713f, -0.06232337f, 
    0.08238757f, 0.05490636f, -0.01728325f, 0.02722934f, 0.01355487f, -0.05340571f, -0.04835351f, -0.00475016f, 
    -0.21654983f, -0.09211526f, 0.03014665f, 0.00534948f, -0.07561819f, -0.00983568f, -0.01437895f, -0.10826316f, 
    0.03420595f, 0.09638686f, -0.01112117f, 0.04197268f, -0.16992891f, 0.04756813f, -0.04388809f, -0.00055788f, 
    -0.05020981f, 0.06935618f, -0.03624398f, -0.00515341f, -0.04189922f, -0.02222888f, 0.01133701f, 0.11832934f, 
    -0.37940562f, 0.09888970f, -0.08123218f, -0.15893690f, 0.11066110f, -0.07404209f, 0.08104907f, 0.11472240f, 
    0.04683910f, -0.02862443f, 0.06293289f, -0.05620749f, -0.16196012f, -0.11476628f, 0.14220677f, -0.18499625f, 
    -0.04380306f, 0.10177097f, 0.00513257f, 0.02623202f, 0.06794742f, 0.06039873f, 0.09962573f, -0.03466836f, 
    -0.09946054f, 0.06359815f, -0.08198616f, 0.04738509f, 0.12389680f, 0.12451805f, 0.04147290f, 0.00305157f, 
    0.03049061f, -0.06718076f, 0.02199412f, 0.01292752f, -0.01215446f, 0.01202950f, -0.18241608f, 0.03859308f, 
    0.08836775f, 0.03498229f, -0.09845240f, -0.03146757f, 0.02667340f, -0.05952517f, 0.07340075f, -0.03233833f, 
    -0.07562005f, -0.05985088f, 0.03068434f, -0.07853404f, 0.03137339f, 0.15441510f, -0.04502522f, 0.06246844f, 
    0.06555331f, -0.04574804f, 0.05507106f, -0.15088424f, 0.02204180f, 0.05914205f, -0.12338574f, 0.09686176f, 
    0.07246255f, 0.05736669f, 0.06572415f, 0.01318942f, -0.00393226f, -0.05393764f, 0.01774442f, 0.12216852f, 
    -0.31574240f, -0.02272062f, 0.08086494f, -0.07034315f, 0.03007944f, 0.07463275f, 0.03372509f, 0.01729524f, 
    0.10163219f, -0.07018583f, 0.09323216f, -0.00479329f, 0.04320107f, -0.04682832f, 0.00209458f, -0.03043908f, 
    0.09264377f, 0.02871124f, 0.07645530f, 0.10434474f, -0.00251067f, -0.00860281f, -0.04641215f, -0.08791336f, 
    0.26417512f, 0.03940548f, 0.18451168f, 0.29414487f, -0.03418012f, -0.10112907f, 0.02595751f, -0.02685433f, 
    0.07549613f, 0.02541198f, 0.01935144f, 0.09306764f, -0.11655450f, -0.09161422f, 0.03317398f, 0.20159839f, 
    0.10189179f, 0.07518890f, 0.05503406f, 0.08426736f, 0.14145043f, -0.00986934f, -0.06108712f, 0.03481361f, 
    0.14334238f, 0.21341889f, 0.11076413f, 0.06873146f, 0.00468298f, -0.03102794f, -0.07960495f, -0.00721471f, 
    0.11426890f, 0.03345845f, 0.06057101f, 0.06805347f, 0.11029360f, 0.11007263f, -0.09361771f, -0.00197616f, 
    0.02916949f, -0.08528701f, 0.03116428f, -0.03719597f, 0.03962503f, -0.02892144f, 0.06026769f, 0.03375688f, 
    -0.15123774f, 0.05156453f, 0.04159302f, 0.08821053f, -0.07969847f, 0.07222494f, 0.09247250f, -0.16434744f, 
    0.04539232f, -0.02399711f, 0.03820856f, -0.03376444f, 0.00841974f, 0.01361824f, -0.10170209f, -0.02736535f, 
    0.10357881f, 0.06847442f, -0.05343751f, -0.08948832f, 0.00367077f, -0.06023737f, -0.03730696f, -0.04422494f, 
    0.28249043f, -0.07250796f, 0.01593229f, 0.02608045f, 0.09425963f, -0.08890335f, 0.11274776f, 0.00101580f, 
    0.09938623f, -0.04989559f, -0.03877930f, -0.03557035f, -0.06434651f, -0.24698523f, 0.07048281f, -0.02794616f, 
    -0.05771432f, 0.11366827f, 0.05051657f, 0.02327083f, 0.01996745f, -0.03548985f, 0.10625035f, 0.05753974f, 
    0.22586019f, -0.03308802f, -0.07356382f, -0.01585655f, -0.03112148f, 0.02695542f, 0.01876342f, -0.04288457f, 
    -0.00720594f, 0.06808737f, 0.08055298f, 0.01582988f, -0.11148774f, -0.14025649f, 0.00026708f, -0.04755383f, 
    0.14571790f, 0.06181395f, -0.07233065f, 0.01542432f, -0.08472200f, -0.04110339f, 0.06486774f, -0.07797133f, 
    -0.07765295f, 0.05868265f, -0.07739742f, -0.01240995f, 0.07620575f, 0.02554594f, 0.06815363f, -0.00430798f, 
    -0.05186640f, -0.03929452f, -0.02887554f, 0.04203903f, 0.40464607f, 0.11687139f, 0.15594594f, 0.19582722f, 
    0.02201696f, 0.00300540f, 0.06059353f, -0.06555127f, -0.02056719f, 0.08728130f, 0.01142632f, 0.11858709f, 
    -0.02271866f, 0.12513548f, -0.01273939f, 0.06221841f, -0.05329686f, -0.00827403f, -0.04489299f, -0.03920873f, 
    -0.03344151f, 0.14296797f, 0.13829075f, 0.08974081f, 0.07144426f, 0.02585650f, 0.11169366f, 0.12672745f, 
    -0.03656161f, -0.00003076f, 0.03562539f, 0.00079379f, 0.00391440f, 0.01920530f, -0.00066111f, -0.02844858f, 
    0.04463272f, 0.17977265f, -0.06963147f, 0.00404019f, 0.02915507f, 0.05615003f, -0.03694249f, 0.02496837f, 
    0.02937497f, -0.06649291f, -0.01402260f, -0.03140711f, -0.09652426f, -0.09680512f, 0.02863389f, 0.01768292f, 
    0.03065375f, 0.00647047f, 0.03467809f, -0.08286203f, 0.07610898f, 0.11915608f, -0.05823798f, 0.04081113f, 
    0.28311735f, 0.13908415f, -0.02699662f, -0.02004159f, -0.03349233f, 0.00455677f, 0.05422415f, 0.02022475f, 
    -0.05234103f, 0.02686697f, 0.17781265f, 0.05416892f, 0.03412860f, -0.01906600f, 0.04734121f, -0.10988031f, 
    0.03409004f, -0.01216907f, 0.06778456f, -0.02210617f, 0.12332794f, 0.03931103f, 0.08966626f, 0.01579726f, 
    0.20037308f, 0.07324453f, 0.00445010f, 0.23183985f, 0.06704095f, 0.06818764f, 0.01255468f, 0.04971114f, 
    0.08414430f, 0.01126740f, 0.02726728f, 0.02536346f, 0.20160060f, 0.27088788f, -0.06054204f, -0.11823025f, 
    -0.07067605f, -0.00772100f, 0.01859511f, 0.04907965f, -0.05213964f, 0.04022150f, 0.09205966f, 0.04331772f, 
    -0.24572612f, -0.02704982f, -0.11920001f, -0.16158354f, 0.02284458f, 0.12494961f, -0.01085275f, -0.17972431f, 
    0.01951237f, 0.00155680f, 0.02685725f, -0.03304376f, -0.06836525f, 0.22188048f, 0.09164513f, -0.06056412f, 
    -0.03027798f, -0.11962947f, 0.09419991f, 0.09451278f, 0.10391538f, 0.06526598f, 0.06135787f, -0.07262427f, 
    -0.16161458f, -0.08418362f, -0.10037474f, 0.16465065f, 0.08986653f, -0.02053045f, 0.05374259f, 0.08061084f, 
    0.03063258f, 0.07165141f, 0.11173009f, -0.05364978f, -0.12286603f, -0.10089765f, -0.09808794f, 0.05893844f, 
    0.08774658f, -0.06486323f, 0.03989431f, -0.05469910f, 0.03818790f, -0.01159396f, 0.10935608f, 0.07826295f, 
    -0.01563391f, 0.13405521f, 0.14872102f, -0.07800429f, -0.04481793f, -0.16303393f, 0.07934743f, 0.08113815f, 
    0.07520889f, -0.06280797f, -0.01151903f, -0.00589204f, -0.41342458f, 0.00956083f, 0.10630468f, -0.16452064f, 
    0.14424531f, 0.15905802f, -0.01691923f, 0.06988367f, 0.05526839f, -0.04055779f, 0.16543318f, 0.10537474f, 
    -0.06245403f, -0.04145000f, 0.25419950f, -0.05599447f, -0.02777106f, -0.02043482f, 0.13093768f, 0.03349682f, 
    0.11664425f, -0.02908760f, -0.05470532f, 0.07558282f, 0.30400279f, 0.22392993f, 0.02824565f, 0.20466390f, 
    -0.07134834f, 0.00477038f, 0.01818189f, -0.03276521f, 0.12963630f, -0.00574756f, -0.06042950f, 0.01462315f, 
    0.10131011f, 0.11790935f, 0.17478229f, -0.13317120f, 0.02297308f, 0.08849856f, -0.06968482f, 0.06996728f, 
    -0.00792015f, 0.05089609f, 0.02257419f, -0.09432326f, 0.09238821f, 0.07005204f, 0.03237846f, -0.07080563f, 
    0.09930383f, -0.08677746f, 0.05872657f, -0.05774472f, 0.04517306f, 0.00015724f, -0.07304002f, 0.05351537f, 
    0.24353263f, 0.08525245f, -0.00475434f, 0.09041014f, -0.04992909f, 0.00925365f, 0.02845013f, 0.06183921f, 
    -0.00574423f, 0.06432506f, -0.01970335f, 0.01859406f, -0.28050470f, -0.14745370f, 0.19262277f, 0.07959141f, 
    0.08098325f, 0.01287282f, 0.11902180f, 0.03882917f, 0.04330761f, 0.07486491f, -0.02223533f, 0.03982410f, 
    -0.21190155f, 0.05327778f, -0.09278174f, 0.10436918f, 0.08391482f, 0.04944325f, -0.18206728f, 0.00155318f, 
    0.00075951f, 0.00653896f, 0.10804198f, 0.01152625f, 0.01170710f, -0.03927218f, 0.21923149f, 0.14910978f, 
    -0.01089765f, -0.00733551f, 0.02464459f, -0.07469823f, 0.02847926f, 0.08745839f, -0.05222142f, -0.00755333f, 
    0.14546409f, 0.10548587f, 0.09204367f, 0.04220250f, 0.01698030f, 0.05962295f, -0.07331548f, 0.05786062f, 
    0.07213935f, -0.04279170f, -0.02681798f, 0.08784920f, -0.16498478f, 0.02093176f, -0.02523013f, -0.03821992f, 
    0.03891164f, 0.00039364f, 0.09346835f, 0.02943750f, -0.01486831f, -0.02419940f, -0.01570676f, 0.00469813f, 
    0.14606833f, -0.04694578f, -0.12523273f, 0.04327084f, 0.10639951f, 0.06244154f, -0.07867689f, 0.07236536f, 
    -0.01826446f, 0.02797101f, 0.05683702f, 0.14701644f, 0.09331432f, 0.01526532f, 0.18588223f, 0.08570969f, 
    0.05300120f, -0.00454802f, 0.07446443f, -0.01746606f, -0.13130787f, -0.07099122f, 0.06830922f, 0.13370557f, 
    -0.10216984f, 0.20804308f, -0.04626127f, -0.06583021f, 0.01361380f, 0.02969699f, -0.01665591f, 0.00928321f, 
    0.01339988f, -0.04326500f, 0.00956355f, 0.04149747f, 0.09494051f, 0.07116807f, -0.00569434f, -0.08190432f, 
    -0.05166101f, 0.01754364f, -0.02989564f, -0.18195948f, 0.01097601f, 0.05581072f, -0.09955660f, 0.06647462f, 
    0.02051117f, -0.21617551f, 0.00584459f, -0.07613034f, -0.00175462f, 0.04361967f, -0.05447973f, -0.02666591f, 
    -0.02316168f, 0.06239831f, -0.11643619f, 0.09559482f, 0.20066099f, 0.12484676f, 0.12584229f, -0.05867712f, 
    0.03072650f, -0.05103111f, 0.02295308f, -0.03235152f, -0.12904978f, 0.00240387f, 0.00580276f, 0.08664735f, 
    0.21983902f, -0.16501778f, 0.19848613f, 0.14536294f, 0.08696757f, -0.05316055f, -0.00143825f, 0.07489906f, 
    0.09503133f, 0.11333746f, -0.00607862f, 0.08881821f, 0.27639052f, 0.07385094f, -0.09932352f, -0.19512169f, 
    0.05018691f, -0.00843304f, 0.06825868f, 0.01490347f, 0.00259192f, 0.01339231f, 0.03234117f, -0.00372964f, 
    -0.18829124f, -0.17754480f, -0.00791650f, 0.07942489f, 0.04097264f, 0.02744368f, 0.04356749f, 0.00361012f, 
    0.06410476f, -0.04044895f, 0.03100031f, 0.01280108f, -0.25409171f, 0.02809312f, -0.13904841f, 0.06169812f, 
    0.14969058f, 0.03695401f, 0.04324834f, 0.20539072f, -0.01843550f, 0.02020494f, 0.02803118f, -0.05358800f, 
    -0.06696285f, -0.09624466f, 0.11426081f, -0.05533497f, -0.05281997f, -0.00147882f, 0.14801933f, -0.02623096f, 
    -0.05185332f, -0.09845908f, 0.06392176f, 0.07295649f, -0.29185653f, 0.18926463f, 0.04993999f, -0.00369027f, 
    0.04364488f, 0.00318759f, 0.06408533f, 0.03507530f, -0.00847304f, 0.06467689f, 0.00986458f, 0.01018627f, 
    -0.00039858f, -0.18358468f, 0.02458916f, 0.15535957f, 0.00290397f, 0.06675161f, 0.01747065f, -0.04788767f, 
    -0.00691306f, 0.02835360f, -0.07506917f, 0.01537287f, 0.00226052f, -0.03693806f, 0.03432998f, -0.10193785f, 
    0.02384785f, -0.07375773f, 0.08674466f, -0.02793900f, -0.09922376f, 0.04239497f, 0.00120959f, 0.02352134f, 
    0.30566221f, 0.03780389f, 0.01424987f, -0.08014307f, 0.02863082f, -0.06826017f, 0.03319753f, -0.02042031f, 
    -0.01804744f, 0.01857159f, 0.05763048f, 0.05389829f, -0.34915736f, -0.03754082f, -0.13497114f, 0.05855166f, 
    -0.00181461f, 0.12241897f, 0.04091233f, -0.02126643f, 0.00875486f, -0.05608269f, -0.04188873f, 0.03977375f, 
    0.26961789f, 0.16819043f, 0.13737410f, 0.09843855f, 0.06738222f, 0.02222139f, -0.00212855f, -0.04274192f, 
    0.05154864f, 0.07249238f, 0.08814522f, 0.17563824f, -0.09121210f, 0.03243635f, 0.03506199f, -0.00548116f, 
    -0.08208948f, 0.05324086f, 0.05731142f, 0.05653813f, -0.00711000f, 0.03812090f, 0.04243872f, -0.01506131f, 
    -0.17670679f, -0.02502362f, -0.04716014f, -0.16656150f, 0.12965082f, 0.03213132f, -0.04441255f, -0.03850416f, 
    0.04180537f, -0.02310606f, 0.04368579f, -0.01913404f, 0.35006163f, 0.01448063f, 0.25112671f, 0.05444726f, 
    0.03218624f, 0.03457945f, 0.01520423f, 0.00400611f, -0.03461073f, 0.00553058f, -0.00988095f, 0.00449023f, 
    0.24161316f, 0.16015099f, 0.17572196f, 0.07332166f, 0.05543815f, 0.05516362f, -0.00011535f, -0.03092037f, 
    -0.04039221f, 0.11754593f, -0.00323625f, 0.10038665f, 0.27136776f, 0.22677995f, 0.08356766f, -0.09128109f, 
    0.14692388f, -0.04531775f, 0.07021814f, 0.05751014f, -0.02500786f, -0.03457757f, -0.02645698f, 0.10006782f, 
    0.25901821f, -0.02845480f, 0.11588965f, 0.10868677f, -0.00178717f, -0.11342663f, -0.01990720f, 0.12964420f, 
    -0.09201375f, 0.04913007f, -0.00668255f, 0.00384291f, 0.19969858f, 0.04687184f, 0.03852776f, 0.03406909f, 
    -0.20424671f, 0.06375772f, 0.08478618f, 0.00238838f, 0.05950515f, 0.08959478f, -0.06088326f, 0.04203564f, 
    0.13944092f, 0.25577977f, 0.19954889f, 0.19010091f, 0.09902335f, -0.11741991f, 0.07508914f, 0.08389467f, 
    -0.01000054f, -0.00175957f, -0.08081459f, 0.14727408f, 0.28990862f, -0.16826025f, 0.09882222f, -0.03452867f, 
    -0.00924641f, 0.01525811f, -0.04024914f, -0.04030583f, -0.06228990f, -0.03901867f, -0.15775801f, -0.05872908f, 
    0.15623154f, -0.03606258f, -0.03681652f, 0.09901340f, 0.03127339f, -0.04998275f, -0.03879302f, 0.03778236f, 
    -0.07373989f, 0.04607651f, -0.02631339f, -0.05536147f, -0.10738369f, 0.02280959f, 0.17919704f, 0.02725637f, 
    -0.08155421f, -0.01663754f, 0.00743801f, 0.00829825f, -0.06544638f, -0.03257496f, 0.05371101f, 0.11828218f, 
    -0.11541335f, 0.18346144f, -0.18507621f, -0.15043291f, 0.09398432f, 0.13380186f, -0.03650877f, 0.01981493f, 
    -0.00931842f, 0.02323570f, 0.02892108f, -0.09077323f, 0.08326943f, -0.06176989f, -0.16262381f, -0.09222334f, 
    -0.09263419f, -0.03199493f, -0.12501612f, -0.11022323f, -0.01312746f, -0.00652168f, 0.16402234f, -0.05643409f, 
    0.03454957f, 0.07892973f, -0.20315960f, -0.02657024f, -0.00986032f, -0.00170768f, 0.13784151f, 0.07150130f, 
    -0.10032060f, 0.06322407f, -0.06214875f, 0.00678145f, 0.00258384f, -0.12801558f, 0.10614110f, 0.11457968f, 
    0.02718542f, 0.03978764f, -0.16794913f, -0.08374099f, 0.01346118f, 0.12418853f, 0.06527361f, 0.06224600f, 
    0.46207720f, -0.14527102f, 0.05861261f, -0.05352278f, 0.00481894f, 0.00081293f, -0.05650201f, 0.08817016f, 
    -0.00985073f, 0.08687709f, 0.09517361f, 0.03863674f, 0.03858719f, 0.03578416f, 0.11792884f, 0.02256712f, 
    -0.02907343f, -0.02152495f, 0.16629361f, 0.19123876f, 0.04017346f, 0.12203009f, -0.01987302f, 0.15042767f, 
    -0.05661049f, 0.25467321f, 0.07155960f, -0.04324891f, -0.03556481f, 0.05921963f, 0.00209321f, -0.00459306f, 
    -0.13932015f, 0.06857962f, 0.04199608f, 0.04782251f, 0.01423994f, 0.06147309f, -0.12015534f, 0.15902103f, 
    -0.03433016f, -0.02371529f, -0.12432510f, -0.02963936f, -0.02279323f, 0.04839082f, -0.01271779f, -0.05221204f, 
    0.00707713f, 0.10967015f, 0.16012132f, -0.17425556f, 0.05561965f, 0.01778509f, 0.12907344f, 0.09410708f, 
    0.09113985f, -0.01253230f, -0.03992292f, -0.02944127f, -0.12268911f, 0.16206217f, 0.11103015f, 0.15515745f, 
    -0.04607354f, 0.01147261f, 0.01655961f, 0.04899492f, 0.08252147f, 0.07272343f, -0.02510404f, 0.04364672f, 
    0.25622207f, 0.17985751f, 0.14866464f, 0.06017659f, -0.03519578f, -0.02343606f, -0.04059509f, 0.15904383f, 
    0.03118541f, -0.01502169f, 0.06992940f, -0.06087638f, -0.28518221f, 0.12734309f, -0.27175471f, -0.15085854f, 
    0.10815039f, 0.02582825f, 0.00249088f, 0.02965043f, 0.01479705f, -0.06370648f, -0.06139961f, -0.01564204f, 
    0.19231798f, -0.19664642f, -0.04046475f, 0.01018040f, -0.09651636f, 0.04122619f, 0.14287835f, 0.03944033f, 
    0.07586143f, -0.08726656f, -0.01792032f, -0.06970954f, 0.09412542f, -0.03628324f, -0.07621556f, 0.04355041f, 
    -0.01825493f, 0.04763627f, 0.02356512f, -0.12694661f, 0.05213551f, -0.00914256f, 0.04176832f, 0.11449116f, 
    0.19989236f, 0.00764083f, 0.22051030f, 0.15519637f, 0.02336974f, -0.01654902f, 0.09124788f, 0.02902315f, 
    -0.08855861f, 0.08790708f, 0.00943188f, 0.12230890f, -0.10332634f, -0.04270878f, 0.02544184f, 0.23417780f, 
    -0.03899505f, 0.08419701f, -0.02004546f, 0.01518304f, -0.00640758f, -0.06125213f, 0.03570957f, -0.09731100f, 
    -0.08152466f, 0.06675538f, -0.02584812f, -0.01380115f, 0.03350165f, 0.14030299f, 0.03556131f, -0.00958948f, 
    0.01360308f, 0.09124488f, -0.18501209f, -0.00530606f, -0.02391832f, 0.16581865f, 0.19018881f, -0.00298443f, 
    0.07894783f, -0.04397740f, -0.01321916f, 0.13669683f, -0.07128496f, 0.03154380f, -0.05438423f, 0.07920594f, 
    -0.15767424f, 0.02321701f, -0.16850628f, -0.00961964f, 0.05494193f, -0.10320599f, -0.01516904f, -0.08887289f, 
    -0.13685897f, 0.00452721f, 0.05915552f, -0.06462157f, -0.04804820f, -0.11285694f, 0.16324344f, -0.00605215f, 
    -0.00472929f, 0.03060169f, 0.11652263f, -0.09445768f, -0.08851164f, -0.07721902f, 0.05907850f, -0.01308174f, 
    0.04998401f, -0.13740863f, -0.00690135f, 0.20183490f, -0.01321159f, -0.05970039f, 0.01542833f, 0.10863950f, 
    -0.05777431f, 0.02852369f, 0.03975316f, 0.04833670f, -0.02085580f, 0.07711836f, 0.00476399f, -0.06769782f, 
    0.06433727f, 0.15280759f, 0.09563193f, -0.02390739f, -0.11373892f, 0.00905691f, -0.09723312f, 0.09889638f, 
    -0.11224811f, 0.03685284f, 0.12238050f, -0.19121768f, 0.02581583f, -0.05028671f, 0.05716456f, -0.04788825f, 
    -0.04589184f, -0.02272603f, -0.13303955f, 0.06499474f, -0.09621637f, 0.07947236f, 0.17270789f, -0.02626988f, 
    0.00548838f, -0.01729251f, -0.00729745f, 0.05372757f, -0.01804265f, 0.00228332f, -0.05251009f, 0.02710049f, 
    -0.10230085f, -0.04989392f, -0.00893572f, -0.00079950f, -0.04511839f, 0.12224857f, 0.04299813f, -0.08921126f, 
    -0.13318846f, -0.07403255f, 0.06371595f, 0.01125890f, 0.41828579f, 0.00263703f, 0.08826786f, 0.17274643f, 
    -0.04650795f, -0.06263186f, -0.10577432f, 0.02759943f, 0.03959215f, -0.00516101f, -0.06231494f, -0.05117566f, 
    -0.09259854f, 0.11127314f, 0.12213107f, -0.08527624f, 0.06035916f, 0.11189435f, -0.07210103f, -0.04240348f, 
    -0.17681515f, -0.05671505f, -0.01574576f, -0.02501113f, -0.10960709f, -0.20550767f, 0.06319070f, -0.31285378f, 
    0.14126430f, 0.07070014f, -0.03192694f, -0.06903665f, -0.15063649f, 0.03172841f, 0.05844121f, -0.07388832f, 
    -0.02811235f, 0.06358571f, -0.20915972f, 0.19822887f, -0.01124697f, -0.04225890f, 0.05435403f, -0.01061973f, 
    0.00784251f, 0.04755610f, -0.03612601f, 0.21053444f, 0.13246362f, 0.44577020f, 0.03715076f, 0.26092610f, 
    0.09148459f, 0.12963666f, -0.07283684f, 0.08850507f, -0.03975621f, 0.06894422f, 0.13250022f, 0.00400166f, 
    -0.19335407f, 0.06527682f, -0.03589009f, 0.10061084f, 0.02539050f, 0.02325148f, 0.08941761f, 0.02372889f, 
    -0.03343383f, 0.04085239f, 0.02531355f, -0.01037763f, 0.05349507f, 0.03111830f, -0.01749213f, -0.06385890f, 
    0.01365459f, -0.07921156f, -0.15731055f, 0.03045006f, 0.00525137f, -0.11587802f, 0.04067075f, -0.05694301f, 
    0.42339483f, 0.12374674f, 0.09755300f, 0.16896553f, -0.15914291f, 0.04674743f, 0.11929675f, 0.09721715f, 
    0.11894679f, 0.03494061f, -0.04948918f, 0.00278975f, 0.21448036f, 0.06143456f, -0.06121258f, -0.05359388f, 
    -0.00442245f, 0.07094235f, 0.00377824f, 0.06689735f, 0.02225529f, -0.01478950f, 0.07153713f, 0.03918216f, 
    0.08919967f, 0.11275568f, -0.04401683f, -0.06476910f, 0.09826758f, 0.06955380f, 0.19283140f, -0.09387812f, 
    -0.06416926f, -0.02173978f, -0.03884481f, -0.09256479f, 0.20935066f, 0.06740560f, 0.13414989f, -0.00539865f, 
    -0.00184547f, 0.07254674f, 0.00230133f, 0.08004361f, -0.09046692f, -0.08618284f, 0.04808675f, -0.04257649f, 
    0.13330966f, -0.02209967f, -0.00630670f, 0.04751516f, -0.07912710f, 0.06872302f, 0.09269090f, -0.06519458f, 
    0.05624513f, 0.02661924f, 0.04067163f, -0.08001431f, -0.03018895f, 0.09560477f, -0.05476309f, -0.16401416f, 
    -0.03960933f, -0.07975116f, -0.06482351f, -0.05436078f, 0.12593077f, 0.03127747f, 0.00870376f, -0.14980265f, 
    0.26419112f, -0.09708241f, 0.01009757f, 0.14424989f, -0.06013876f, 0.02889320f, 0.00761400f, -0.07975896f, 
    -0.02021820f, 0.04116938f, 0.03426969f, 0.06039423f, 0.01825087f, 0.12531489f, -0.00482111f, -0.09671845f, 
    0.04710693f, -0.01835256f, 0.10953093f, 0.22437058f, -0.00352087f, 0.01650820f, 0.12510912f, -0.13171278f, 
    0.11404248f, 0.18432228f, 0.11550229f, 0.11249688f, -0.01650980f, -0.08074833f, 0.02410046f, -0.01625918f, 
    0.04188075f, -0.05412632f, 0.11008263f, 0.00637363f, 0.22491105f, 0.06078812f, -0.19802377f, 0.03861344f, 
    0.05364216f, -0.04995622f, -0.04814183f, 0.02753348f, 0.10501692f, 0.03496715f, 0.04332075f, -0.01873821f, 
    -0.18231454f, 0.17910154f, -0.09248168f, 0.05470891f, -0.06965566f, 0.07455936f, 0.04936844f, -0.18249749f, 
    -0.05930739f, -0.02148927f, -0.02731291f, -0.08870281f, -0.26911953f, 0.12538785f, 0.30921188f, 0.01381877f, 
    -0.03043954f, -0.08186100f, 0.14593594f, -0.02850259f, 0.00680813f, 0.01172653f, 0.10474417f, -0.01425657f, 
    0.05708045f, -0.00060332f, 0.04857903f, -0.08668885f, 0.16375843f, -0.05943830f, -0.10361646f, -0.00535270f, 
    -0.10418490f, -0.02379789f, -0.10925616f, -0.14631535f, 0.25139964f, 0.02228322f, 0.14978455f, -0.00183501f, 
    -0.07802473f, -0.03618947f, -0.04677778f, -0.07608342f, -0.02149551f, -0.05261182f, -0.05165613f, 0.07309156f, 
    -0.14059152f, 0.17202319f, 0.00876701f, 0.02200506f, 0.05256300f, -0.00805171f, -0.04794729f, -0.03858465f, 
    0.03245948f, 0.00073774f, -0.04009272f, -0.12206078f, 0.44552606f, -0.23602891f, -0.04507392f, 0.04876002f, 
    -0.03943314f, 0.12621981f, -0.09568726f, 0.03279341f, 0.02013449f, -0.05852136f, 0.09487702f, -0.09805738f, 
    -0.00902880f, 0.02929797f, -0.03799771f, 0.04445777f, -0.02845846f, -0.00189785f, -0.03918118f, 0.02551676f, 
    0.01572446f, -0.08620447f, 0.14581273f, -0.08655944f, 0.07013416f, 0.14494084f, 0.03333314f, 0.05059626f, 
    -0.08409433f, 0.04113166f, 0.02719829f, 0.14169744f, 0.11970877f, -0.03287294f, 0.10403416f, -0.09167073f, 
    0.03500964f, 0.19813165f, -0.02613576f, -0.11281298f, 0.03522329f, 0.10447284f, 0.01786484f, 0.12183776f, 
    -0.00440896f, 0.06559596f, 0.03159102f, -0.04623453f, 0.34429026f, -0.04874589f, 0.12909839f, 0.01260958f, 
    0.08800399f, -0.07673542f, -0.07995721f, -0.04458519f, -0.02033074f, 0.02891022f, -0.01883224f, -0.02880275f, 
    -0.03643919f, 0.08597721f, -0.21148174f, -0.03130795f, -0.00603937f, 0.00028175f, 0.03329001f, -0.03067177f, 
    0.03095200f, -0.05685274f, -0.06813196f, -0.12157577f, 0.15007605f, -0.02318223f, 0.00525051f, -0.10207083f, 
    0.10214117f, -0.00492076f, -0.04395889f, 0.01751704f, 0.04872031f, -0.08375559f, 0.02707573f, 0.05764724f, 
    -0.08145360f, 0.00731831f, 0.01925435f, 0.10205016f, -0.11121529f, 0.03359769f, 0.07707872f, -0.02614636f, 
    0.07314848f, 0.08847810f, -0.08161828f, 0.10303923f, -0.16686210f, 0.15736096f, -0.25376320f, 0.00772437f, 
    0.02089836f, -0.02848125f, 0.02184220f, 0.00005882f, -0.00139996f, -0.04106849f, -0.02918185f, 0.08395036f, 
    -0.00567016f, -0.01543907f, -0.00721326f, -0.03013212f, -0.02289677f, -0.03124289f, 0.02874273f, -0.03760580f, 
    0.03000579f, -0.03814388f, -0.03183739f, 0.05211723f, 0.31874090f, 0.16646710f, 0.05921207f, 0.24762744f, 
    0.06556692f, -0.01816948f, 0.04760076f, 0.07021061f, -0.04033920f, 0.10939629f, -0.01669670f, -0.03001325f, 
    -0.02613495f, 0.17585345f, 0.05235423f, -0.05110812f, 0.05160033f, 0.02965753f, 0.06844822f, -0.16554520f, 
    0.02524336f, 0.04596870f, -0.01850498f, 0.02349417f, 0.07546151f, -0.05600234f, 0.17679912f, 0.06581909f, 
    0.19617058f, 0.01229176f, -0.10296918f, -0.02063881f, 0.00422532f, 0.10150325f, -0.00603986f, -0.02846414f, 
    -0.03635761f, 0.11743496f, -0.00666622f, -0.04637031f, -0.05199701f, 0.16333979f, 0.02981268f, -0.04874562f, 
    0.01496096f, 0.01638975f, 0.09544938f, -0.06925577f, -0.08587188f, -0.08603223f, 0.18124415f, -0.11250480f, 
    -0.07292544f, -0.02273284f, 0.10605902f, 0.03237467f, 0.02622769f, -0.01602083f, -0.03934789f, 0.02724717f, 
    -0.03449983f, 0.14254053f, 0.02970447f, -0.07505388f, -0.07188083f, -0.06838860f, -0.02100191f, -0.02581626f, 
    0.10994353f, 0.01407023f, 0.07394434f, -0.02015679f, 0.09652513f, 0.08094004f, -0.02652668f, -0.03461671f, 
    0.01166447f, 0.04349707f, 0.04389971f, 0.04704351f, -0.08494867f, -0.00451507f, -0.06577551f, -0.11268098f, 
    0.07501055f, -0.20974872f, 0.04375591f, 0.22665378f, -0.04948571f, 0.09892809f, -0.05920771f, 0.03738800f, 
    -0.00370943f, -0.12363350f, 0.06208220f, 0.10086188f, 0.07960004f, -0.00325871f, -0.09793606f, 0.13740653f, 
    0.01149934f, -0.01882080f, 0.04545201f, -0.01491551f, -0.08219634f, -0.03733283f, 0.01458373f, 0.01241943f, 
    0.15196116f, 0.01223421f, 0.24510588f, 0.10731307f, -0.03965785f, 0.09023570f, 0.02349191f, -0.02322925f, 
    0.07906053f, -0.06314597f, 0.05211915f, 0.05425261f, -0.01022217f, -0.04954435f, 0.06360056f, -0.01322524f, 
    0.00595142f, 0.03954770f, 0.01292712f, -0.02284127f, -0.01988897f, -0.00451793f, 0.01077040f, 0.02292711f, 
    -0.30538893f, 0.15181606f, 0.11604454f, 0.05094292f, 0.07120646f, -0.04246033f, -0.02884964f, -0.07337847f, 
    -0.00994087f, -0.03530306f, 0.01574015f, 0.02531409f, 0.01839973f, 0.14758660f, 0.03749008f, -0.00063199f, 
    0.00778946f, 0.03705956f, -0.07302617f, -0.07541006f, 0.03287046f, 0.03087325f, 0.00482566f, 0.10484575f, 
    -0.17403543f, 0.01072984f, -0.09503759f, -0.02968414f, -0.00599145f, -0.00176245f, -0.06211080f, -0.01386577f, 
    -0.03396344f, -0.05951348f, -0.04868890f, 0.03659658f, -0.01913687f, -0.16616601f, 0.12423114f, 0.05590603f, 
    0.00118604f, -0.03346401f, 0.01708186f, -0.06677017f, -0.04687709f, -0.02309274f, 0.04639259f, -0.04001689f, 
    0.08131669f, -0.02050505f, -0.02275498f, -0.07345437f, 0.01898400f, 0.02614646f, -0.00938247f, -0.06443957f, 
    0.02095957f, -0.03126513f, 0.03472109f, 0.09260081f, 0.30634180f, 0.11101279f, 0.02011478f, 0.06896409f, 
    -0.04257919f, 0.04141802f, 0.05880750f, -0.05567592f, -0.03215471f, 0.01370825f, 0.07486526f, -0.00264446f, 
    0.05623666f, 0.15109965f, -0.03583655f, -0.01749391f, -0.01851914f, 0.04897563f, 0.10971972f, -0.06589058f, 
    0.02799957f, 0.04643473f, 0.06014072f, 0.03434306f, 0.07357752f, -0.19067842f, 0.09958664f, 0.16829313f, 
    -0.04397301f, -0.06276936f, 0.11744931f, 0.01939074f, -0.07737543f, -0.01317752f, -0.00394862f, 0.00052463f, 
    -0.09438211f, 0.14864966f, 0.21772259f, 0.03988826f, -0.00720391f, 0.05650983f, 0.07032470f, 0.00833691f, 
    -0.00966808f, -0.08999464f, 0.02680921f, 0.04570316f, -0.18781531f, 0.02947693f, 0.07940798f, -0.01251862f, 
    -0.04098586f, -0.04773281f, 0.06522360f, 0.01508593f, -0.01354090f, -0.07722207f, -0.10114247f, -0.02525268f, 
    -0.03157035f, 0.15111484f, 0.06446450f, -0.20483249f, -0.02426369f, 0.02405478f, 0.05780638f, -0.07696763f, 
    0.03503075f, 0.05417607f, 0.05694880f, -0.01396185f, -0.04517779f, 0.04587274f, 0.15007961f, -0.11506000f, 
    0.10696907f, -0.00936720f, 0.06073924f, -0.04375065f, 0.08814914f, 0.03693207f, 0.03797337f, -0.04390372f, 
    0.06361295f, -0.07126894f, 0.01982157f, 0.23928025f, 0.12551555f, -0.10760510f, 0.09049079f, 0.06063591f, 
    0.00253364f, -0.05744582f, -0.07843854f, 0.01058546f, 0.24497451f, 0.00586559f, -0.05467132f, 0.16206612f, 
    -0.01867864f, -0.06351573f, -0.01650616f, 0.04651135f, -0.01133933f, 0.08343392f, -0.00862650f, 0.00160275f, 
    0.18866813f, -0.02031158f, 0.02633298f, 0.06633627f, -0.01273574f, 0.09813766f, 0.07861946f, -0.05843624f, 
    -0.00257741f, -0.08176458f, 0.02852069f, -0.04577532f, -0.11499824f, 0.07380669f, -0.00735713f, -0.07710724f, 
    0.07017979f, 0.03927054f, -0.02056864f, 0.02239818f, -0.02788801f, 0.01108234f, -0.03618457f, 0.02182276f, 
    0.03029658f, 0.05240636f, 0.09073202f, -0.07283499f, 0.03333977f, 0.03617447f, 0.05352278f, -0.03155816f, 
    0.01087447f, 0.09861155f, 0.03973593f, -0.04884543f, 0.22172107f, -0.00065072f, -0.03698625f, 0.05573837f, 
    -0.04277968f, -0.06776441f, -0.04212386f, 0.01326538f, -0.00949065f, 0.12836754f, -0.04126981f, -0.03691509f, 
    -0.02682758f, -0.00684997f, 0.10088410f, 0.24637377f, 0.05618134f, -0.01020335f, 0.02680048f, 0.06976454f, 
    0.13109003f, -0.06889781f, -0.06543561f, 0.01452291f, 0.13413098f, 0.00963736f, 0.08071087f, 0.09937773f, 
    0.01227276f, -0.02144682f, -0.04395543f, -0.05166643f, 0.01914095f, -0.05707566f, -0.00323344f, -0.00330127f, 
    0.05297293f, 0.03527262f, -0.14363633f, 0.04452780f, -0.02722914f, -0.01167642f, -0.08935270f, 0.06838993f, 
    -0.01641948f, -0.06715075f, 0.01795761f, -0.03923001f, -0.15316124f, 0.12502483f, 0.16550331f, -0.11346400f, 
    -0.03221765f, 0.08742013f, 0.04022757f, -0.01619558f, -0.02890110f, -0.04961411f, 0.10816446f, 0.01127676f, 
    -0.06169988f, 0.11883909f, 0.13271573f, -0.13122796f, -0.10238706f, 0.02806626f, 0.00011100f, 0.02648121f, 
    -0.02899763f, 0.05025218f, 0.04695190f, 0.06137814f, -0.02764861f, 0.09688184f, -0.10879102f, 0.15813418f, 
    -0.00309268f, -0.02035330f, 0.06743493f, 0.01240932f, -0.03366535f, -0.03763419f, -0.02219634f, -0.03988163f, 
    0.19258896f, 0.04411512f, 0.07974158f, 0.09510202f, 0.02682852f, 0.07344247f, 0.16684839f, 0.02592679f, 
    0.05838342f, 0.00325714f, 0.06136011f, -0.03243840f, 0.17893185f, -0.04497308f, 0.00866911f, -0.22033042f, 
    -0.09690637f, 0.06914774f, 0.08910794f, -0.16383834f, -0.06430341f, 0.06168886f, 0.03143479f, -0.08945209f, 
    0.41803524f, 0.07929112f, 0.04812567f, -0.07996909f, -0.15958466f, 0.05102635f, 0.03177278f, -0.07587501f, 
    -0.06698254f, -0.01510099f, -0.01906915f, -0.10281428f, 0.00238129f, 0.07308054f, 0.18080154f, 0.24330872f, 
    0.01620483f, -0.02161340f, -0.03019537f, 0.00354481f, -0.03989148f, 0.10425869f, 0.03531900f, -0.06709274f, 
    0.07621044f, 0.00838032f, 0.03006821f, -0.00554165f, 0.04847449f, 0.03345083f, 0.03459350f, -0.02294510f, 
    -0.04898821f, -0.08510000f, 0.05210375f, -0.02447235f, -0.03669119f, -0.04085584f, 0.11300272f, 0.14226940f, 
    0.09288906f, -0.08900668f, 0.13343249f, 0.00199131f, -0.03492902f, 0.06642065f, -0.08930261f, -0.01558236f, 
    -0.08805168f, 0.03749455f, 0.07229494f, -0.01965552f, -0.12714574f, -0.02608832f, -0.04128251f, 0.02274307f, 
    0.02939734f, -0.03681034f, 0.06732614f, 0.02703614f, 0.03911113f, 0.02187457f, 0.05762780f, 0.02010997f, 
    0.04581056f, 0.01318797f, -0.00190146f, -0.03633312f, 0.06129704f, 0.05655932f, -0.04886882f, -0.00646181f, 
    0.02064518f, -0.19051130f, 0.09812222f, 0.08754416f, 0.05418351f, 0.03632458f, 0.07278070f, -0.07868166f, 
    -0.03601469f, -0.06006458f, -0.09641288f, 0.02428851f, -0.12261300f, -0.15145981f, 0.10570766f, 0.19985996f, 
    -0.03253549f, 0.03601063f, 0.01156994f, 0.00013554f, -0.08086095f, -0.03471744f, -0.01826161f, 0.05264054f, 
    -0.07721157f, 0.00222271f, 0.12359151f, -0.19537993f, -0.07221797f, 0.01577138f, 0.10970880f, -0.06823606f, 
    -0.00101351f, 0.00580670f, -0.07506840f, 0.03593597f, -0.19746214f, -0.01336717f, 0.00034121f, 0.02873397f, 
    0.03159452f, 0.05721345f, 0.01008704f, -0.18067917f, 0.01179752f, -0.01795285f, -0.01004736f, 0.04840161f, 
    0.33837122f, 0.13555820f, -0.05857310f, 0.03124329f, -0.02627270f, 0.00393819f, 0.02645856f, 0.05170709f, 
    -0.01213754f, 0.02104681f, -0.00143272f, -0.00129405f, -0.04080749f, -0.02303816f, 0.03415240f, -0.08514193f, 
    -0.07965147f, -0.03432451f, -0.03284775f, 0.01061244f, -0.10509462f, 0.02115245f, -0.04958510f, -0.04037475f, 
    0.13246040f, -0.04168541f, 0.05671714f, 0.05617182f, 0.06214520f, 0.11363295f, 0.06066476f, -0.05129020f, 
    -0.02357910f, -0.01661939f, -0.07089811f, 0.02410507f, -0.03669498f, -0.04322364f, -0.16199526f, 0.00596129f, 
    -0.08497364f, 0.05282933f, -0.10670131f, 0.04852495f, -0.03299683f, 0.06317382f, 0.01524225f, -0.10096951f, 
    0.10613414f, 0.04045012f, -0.06601933f, 0.19720690f, 0.07684337f, 0.01374796f, -0.01576242f, 0.07391063f, 
    0.12209793f, 0.05942142f, -0.02068815f, 0.00141052f, 0.09202000f, 0.11753207f, 0.01941221f, -0.06936429f, 
    0.02487846f, -0.05337330f, 0.03732811f, -0.01996329f, -0.03946429f, -0.01965455f, 0.11151572f, -0.01112629f, 
    -0.14066935f, 0.00456834f, 0.09301297f, 0.04762971f, -0.03825411f, -0.06701450f, 0.10725687f, 0.02653946f, 
    -0.00871828f, -0.01763434f, -0.00972816f, -0.05495184f, -0.25902212f, 0.11078900f, 0.22065465f, 0.02464408f, 
    0.07323647f, -0.02873894f, 0.08939725f, -0.02519842f, 0.06416386f, 0.06184331f, -0.04925368f, -0.01777051f, 
    -0.08006388f, 0.21820433f, 0.05518688f, 0.16889444f, 0.05712847f, 0.05550456f, -0.04162508f, -0.05001145f, 
    0.05275715f, 0.02589648f, 0.08576869f, 0.03372942f, 0.08809575f, -0.07966056f, -0.04968563f, 0.02063726f, 
    0.02952574f, 0.02301433f, 0.00323679f, -0.00813929f, -0.04389836f, 0.08727030f, -0.04732776f, -0.00725056f, 
    0.08635085f, -0.19698478f, 0.01280783f, 0.02199614f, -0.05549764f, 0.03738509f, 0.02305670f, -0.08666742f, 
    -0.04472421f, -0.03950747f, 0.01800833f, 0.04101838f, -0.06140170f, 0.08309422f, -0.00410333f, 0.06804920f, 
    0.12216748f, 0.08102845f, 0.00674842f, 0.03257973f, -0.01631220f, -0.01684796f, 0.04720021f, -0.04173863f, 
    0.00009278f, -0.01554046f, 0.24108562f, 0.06760464f, -0.08395112f, 0.11826348f, 0.03129599f, -0.01713140f, 
    -0.01556805f, -0.03789265f, 0.06665816f, 0.00076953f, 0.16251643f, 0.06606768f, 0.18987368f, 0.24842566f, 
    -0.06033043f, 0.05060444f, -0.00390637f, 0.06966113f, -0.03256591f, 0.00471015f, 0.01605074f, -0.07093222f, 
    0.27941579f, 0.04113097f, 0.02877165f, 0.11354582f, 0.02317749f, 0.03970201f, -0.00590267f, 0.05989189f, 
    -0.09148355f, -0.04954714f, 0.06190946f, 0.00411703f, 0.00161742f, -0.04640430f, 0.16532686f, 0.04589684f, 
    -0.12210168f, -0.03943247f, 0.04806864f, 0.04097909f, -0.01015994f, -0.05283792f, -0.02881813f, -0.06872415f, 
    0.00796912f, -0.03627159f, -0.02841185f, 0.02564608f, -0.00291021f, -0.00338102f, -0.03426956f, -0.01578437f, 
    -0.02123599f, -0.03562876f, -0.00891815f, -0.01177692f, -0.02121954f, -0.00390680f, -0.00199929f, -0.04002136f, 
    -0.02407015f, -0.02450964f, 0.01362714f, -0.01437843f, -0.02672754f, 0.02327860f, -0.03438056f, -0.02364236f, 
    -0.02286702f, -0.01253237f, 0.00455874f, 0.00565541f, -0.00411491f, -0.02151353f, -0.04113296f, -0.00943296f, 
    -0.04050861f, -0.00845288f, 0.01139019f, 0.02784651f, -0.01560644f, -0.01814664f, -0.03053656f, -0.00067186f, 
    -0.00220129f, -0.03326176f, -0.01781830f, 0.02090072f, 0.01972430f, -0.00336043f, 0.02741561f, -0.00769530f, 
    -0.01665767f, 0.00650211f, 0.01190810f, 0.00178451f, -0.02367344f, 0.02692953f, -0.01414952f, -0.01001681f, 
    -0.03920766f, -0.03530007f, 0.02989457f, -0.02477615f, 0.02473689f, -0.03341846f, -0.01283936f, -0.02197734f, 
    -0.00085409f, -0.00572629f, -0.03567971f, 0.02118052f, 0.00499494f, 0.02446263f, -0.00736758f, -0.00043402f, 
    -0.04056702f, -0.03658294f, 0.02412696f, -0.01475702f, -0.02969460f, 0.02695617f, -0.00733148f, -0.04204993f, 
    -0.02131346f, -0.03750625f, -0.03376997f, -0.01329753f, 0.02641981f, -0.02964896f, -0.03433448f, 0.00185157f, 
    0.01834909f, -0.04023626f, -0.03000842f, -0.01274044f, -0.02940424f, 0.01833957f, 0.00308245f, -0.01717800f, 
    0.01724080f, -0.03085489f, -0.00885880f, -0.03623531f, -0.03643226f, 0.02721992f, -0.02494672f, 0.00534591f, 
    0.02268988f, -0.01414652f, 0.02211789f, 0.02820446f, 0.01173980f, -0.01288721f, 0.01434093f, -0.01386779f, 
    -0.01101539f, -0.03233756f, 0.01534567f, -0.03352217f, -0.03549734f, -0.00089183f, 0.02410237f, -0.01715786f, 
    0.01422664f, -0.02850396f, -0.02003737f, -0.00790528f, 0.02772571f, 0.00514473f, 0.02522587f, 0.01766192f, 
    0.01817575f, 0.00807602f, -0.01492300f, -0.04042163f, -0.02895462f, -0.03058255f, -0.02088474f, 0.02053716f, 
    0.00514708f, 0.00308121f, -0.00629760f, 0.02472918f, -0.01112357f, -0.03908449f, 0.00887661f, -0.03340096f, 
    -0.01386182f, 0.02908321f, 0.03001165f, -0.03943849f, 0.02777747f, -0.00113760f, -0.00981056f, -0.03694311f, 
    -0.03101099f, -0.00668067f, 0.02594119f, -0.02880001f, -0.01659073f, -0.00153792f, -0.02438098f, 0.01564541f, 
    0.01344867f, -0.02380119f, -0.03650305f, 0.02136791f, 0.00904668f, -0.04075886f, -0.02066090f, -0.01724375f, 
    0.01376138f, -0.03264340f, 0.02776366f, -0.01437324f, 0.02924177f, -0.02484482f, 0.01588067f, -0.00257614f, 
    0.00038205f, 0.01326259f, -0.01557208f, -0.03317950f, 0.01507225f, 0.00810539f, -0.01498036f, -0.00174156f, 
    0.02811788f, -0.00663621f, -0.01451391f, -0.04069545f, 0.00622178f, -0.03964300f, -0.00082410f, -0.03713435f, 
    0.02420481f, 0.00382697f, 0.00678843f, 0.02807184f, -0.02575620f, -0.01135478f, 0.01660397f, -0.01003752f, 
    0.02045954f, -0.03460840f, -0.04178429f, 0.00719590f, -0.00715770f, -0.03177838f, -0.02029719f, -0.00504862f, 
    -0.02839916f, 0.01188543f, -0.03367053f, 0.00860651f, -0.02102832f, 0.00994883f, 0.02788620f, -0.03549422f, 
    0.02414658f, 0.01426492f, -0.03897576f, -0.02641433f, -0.01071588f, -0.01752347f, -0.03931015f, -0.00951409f, 
    -0.02314796f, 0.02022695f, -0.01874361f, 0.01479351f, 0.00696718f, 0.00353989f, 0.00932950f, 0.00936922f, 
    -0.02351816f, -0.00435770f, 0.00250312f, 0.00509661f, -0.02256094f, -0.03776899f, -0.02654533f, 0.02724387f, 
    -0.00794464f, -0.03517305f, -0.02386291f, 0.01038287f, -0.02696596f, -0.02904369f, 0.01883549f, 0.00342243f, 
    0.02118991f, -0.01010017f, -0.03784760f, 0.01459972f, 0.01472921f, 0.01863690f, -0.03671501f, 0.02590435f, 
    -0.03505145f, -0.00534956f, -0.01762138f, 0.01196741f, -0.02898056f, -0.02341547f, 0.00162767f, 0.01229237f, 
    0.02587404f, 0.00208291f, 0.02958502f, -0.04195815f, 0.02090083f, -0.04154711f, -0.00331997f, -0.01386451f, 
    0.00677127f, -0.01901151f, -0.01796083f, 0.01744963f, -0.02670500f, -0.00364535f, 0.00176794f, -0.01729272f, 
    -0.02562230f, 0.00092652f, 0.02936579f, -0.01965177f, -0.00630321f, 0.02427072f, 0.00789016f, -0.03077767f, 
    0.01335515f, 0.00058508f, 0.02484561f, -0.01503396f, -0.02517994f, -0.02664757f, 0.02007897f, 0.00202019f, 
    0.01791813f, 0.00436343f, 0.02934525f, 0.01896474f, -0.01193363f, 0.00949199f, 0.02930322f, -0.03528812f, 
    -0.01769553f, 0.00430093f, -0.03520776f, -0.03975210f, -0.00178636f, 0.01175671f, -0.01105753f, 0.02357323f, 
    -0.00623767f, -0.01112544f, -0.02829120f, -0.01975420f, -0.03406854f, 0.01073325f, -0.00194196f, 0.00666791f, 
    -0.02103596f, 0.01960585f, -0.01923958f, -0.02138208f, -0.03358857f, -0.02377628f, -0.00627541f, 0.02441089f, 
    0.02372755f, 0.01531808f, -0.00367508f, -0.02606448f, 0.00585651f, -0.03363869f, 0.01066284f, -0.03738695f, 
    0.00050852f, -0.03373737f, 0.00886549f, -0.02364930f, -0.00978982f, -0.03829297f, 0.01837133f, 0.02518032f, 
    -0.00074509f, -0.01491684f, -0.00261427f, -0.01770821f, -0.01283612f, -0.01955212f, -0.00347111f, 0.00623076f, 
    -0.03649822f, 0.02071675f, 0.00571722f, -0.03022275f, -0.00079995f, 0.02958211f, -0.02958498f, 0.00369423f, 
    -0.01776103f, -0.00874935f, -0.00912986f, -0.00590183f, -0.01468844f, -0.03613746f, -0.00190523f, -0.04051993f, 
    -0.03803124f, -0.01191759f, -0.04193881f, -0.02136223f, -0.01441591f, -0.03441956f, -0.01032332f, -0.01211543f, 
    0.01859230f, -0.00967927f, -0.02435358f, -0.01792721f, 0.00103709f, 0.00957671f, 0.00125480f, -0.03223509f, 
    0.02745857f, -0.04126913f, 0.00459496f, 0.01045815f, 0.02902053f, -0.03943297f, 0.02376786f, -0.02004495f, 
    -0.01796898f, 0.01904493f, 0.02169235f, 0.02150163f, 0.02099944f, 0.00802048f, 0.02734716f, 0.02818421f, 
    0.02812027f, 0.01285129f, 0.02120789f, 0.02199072f, 0.02017261f, 0.00892888f, -0.01047300f, -0.00288951f, 
    -0.02148824f, -0.01532038f, -0.03941813f, -0.02025441f, -0.00045779f, -0.02650762f, -0.03487145f, -0.03148059f, 
    0.02530933f, 0.01678872f, -0.00741587f, -0.03352383f, -0.00637964f, -0.02267204f, 0.01398522f, -0.01705330f, 
    -0.02404018f, 0.00995129f, 0.02618881f, -0.02566414f, 0.01751840f, -0.01074070f, 0.00357997f, 0.01863596f, 
    -0.01484198f, -0.02621181f, 0.00902728f, -0.03958988f, -0.00036721f, -0.03281771f, -0.01308439f, -0.01861035f, 
    0.01789367f, -0.00387510f, -0.02615745f, -0.02312756f, 0.00633756f, -0.03244408f, -0.03335985f, -0.02531438f, 
    -0.03352198f, -0.02206434f, -0.02017483f, 0.02001112f, 0.02157008f, 0.01849345f, 0.00169860f, 0.02279680f, 
    -0.01223823f, -0.01553965f, 0.01660741f, -0.01053199f, -0.01982232f, 0.02659924f, 0.00438916f, -0.03064526f, 
    -0.01075708f, 0.01769509f, -0.03237380f, 0.02339788f, 0.00163389f, 0.00138556f, 0.01400510f, -0.01878585f, 
    0.00543859f, 0.01374957f, -0.00529346f, 0.00527494f, -0.01215463f, -0.03942315f, 0.00397621f, -0.01955007f, 
    -0.01156389f, -0.01830207f, -0.01188273f, -0.01762315f, 0.02980337f, 0.01927866f, -0.00708126f, 0.02836858f, 
    0.01107251f, 0.01356601f, 0.02281230f, -0.02869140f, -0.00017894f, 0.02295275f, 0.01757945f, -0.03863441f, 
    -0.01202151f, -0.01603285f, 0.00261785f, 0.00441037f, -0.00974068f, 0.00087160f, -0.04000249f, 0.01957887f, 
    -0.02423912f, 0.01530263f, 0.01222283f, -0.02848884f, -0.03410056f, -0.00941604f, 0.01969057f, 0.01738788f, 
    0.02141054f, 0.02036793f, 0.02405691f, 0.01246516f, -0.01956714f, -0.03602411f, -0.02488099f, 0.00749303f, 
    -0.00930255f, -0.02149935f, 0.01430084f, -0.02921662f, -0.02756263f, 0.00383332f, -0.00451338f, 0.01255661f, 
    0.01192561f, 0.02264999f, -0.03051518f, 0.02079459f, 0.01901713f, 0.00573676f, 0.01619260f, -0.04160567f, 
    -0.01413536f, -0.02060100f, 0.00181478f, -0.03098420f, -0.03128963f, 0.00313074f, -0.02146970f, 0.01780673f, 
    -0.00383047f, 0.00965310f, -0.03221853f, -0.01181210f, 0.02245696f, 0.02816100f, 0.00066358f, 0.01902528f, 
    0.00244152f, 0.02692070f, 0.02475784f, -0.03568522f, -0.02369188f, -0.02054384f, -0.02767516f, -0.03660385f, 
    -0.01425693f, 0.00838318f, 0.02049712f, 0.01603389f, -0.02373838f, -0.01107816f, -0.02430056f, -0.00760231f, 
    -0.00258935f, -0.01165278f, -0.02055084f, -0.02294713f, -0.00658832f, -0.01344784f, -0.03881919f, -0.00441063f, 
    0.00322032f, -0.01254576f, -0.03434587f, -0.01390138f, -0.01744489f, -0.00111121f, -0.00926157f, -0.00089920f, 
    -0.01675480f, -0.02491238f, -0.03557603f, -0.03541990f, -0.01285620f, -0.04058932f, 0.00855429f, -0.01998972f, 
    -0.02975293f, 0.01195228f, 0.02159170f, -0.04022335f, -0.03238243f, -0.03000854f, 0.00660857f, 0.02471448f, 
    -0.04032904f, -0.00320570f, 0.00121069f, 0.00030697f, -0.00104237f, 0.00338632f, -0.02022417f, -0.02647028f, 
    -0.00129699f, 0.00036164f, -0.00068362f, -0.00340121f, 0.00513124f, -0.00612211f, -0.03684264f, -0.02669001f, 
    -0.01643520f, 0.02940003f, -0.04186138f, -0.00632576f, -0.04192846f, -0.02628525f, -0.03398321f, 0.00271070f, 
    0.01894098f, -0.02441950f, 0.02219941f, 0.01462128f, -0.01171795f, -0.02646629f, 0.01518581f, 0.01012393f, 
    0.00239208f, 0.02385802f, 0.02289503f, 0.01602300f, -0.01129388f, -0.03638873f, -0.01543682f, 0.02561364f, 
    0.02592005f, -0.00349071f, -0.00731509f, -0.03115634f, -0.03168843f, 0.01260894f, 0.01078799f, 0.02021345f, 
    -0.00338571f, 0.00815330f, -0.00867821f, 0.01080434f, 0.00568458f, -0.02136913f, 0.00528522f, 0.02960119f, 
    0.02554704f, -0.00808371f, -0.01553860f, 0.02068548f, 0.00954519f, -0.01691794f, -0.02543780f, -0.03969683f, 
    0.00510949f, 0.01317806f, 0.01863670f, -0.04141092f, -0.03619549f, -0.02042198f, 0.01084426f, -0.02309212f, 
    -0.01933405f, -0.02812182f, -0.02460143f, 0.00196703f, -0.00168660f, -0.04082616f, 0.02816547f, -0.02598903f, 
    -0.01076914f, 0.02035012f, 0.00900123f, 0.00730622f, -0.01359077f, 0.02037355f, -0.03195254f, -0.03460224f, 
    -0.03052124f, -0.00158739f, -0.01563284f, -0.04094767f, -0.00688798f, 0.00124556f, 0.00339622f, -0.04038122f, 
    -0.02337769f, 0.00866921f, -0.02448886f, -0.01894888f, 0.01296223f, -0.01862027f, -0.00851933f, -0.01101153f, 
    -0.02132802f, 0.00079961f, 0.01665097f, -0.00905424f, 0.00473544f, 0.02363154f, -0.04113187f, 0.02533469f, 
    0.02585701f, -0.01533908f, -0.01035005f, -0.02875101f, -0.00708192f, 0.01134165f, -0.01591162f, -0.00870117f, 
    -0.01419862f, 0.00240931f, 0.01682336f, -0.03520058f, 0.02622635f, -0.00125625f, -0.04080692f, -0.01269082f, 
    -0.01929665f, -0.03129850f, 0.00970224f, -0.03452930f, 0.02327535f, 0.01708901f, 0.00797294f, -0.02278976f, 
    0.02764165f, -0.00770779f, -0.01736118f, 0.02635017f, -0.02421922f, -0.03496066f, 0.01163642f, 0.00534740f, 
    -0.01808189f, -0.02412239f, 0.01415353f, 0.01762367f, -0.02555672f, -0.01908368f, -0.02694791f, -0.00215239f, 
    -0.03920010f, 0.01598759f, -0.03331877f, -0.01478024f, -0.01078092f, 0.02688883f, -0.00728687f, -0.02225480f, 
    0.01388043f, 0.01670342f, 0.01168205f, -0.01911167f, -0.02928544f, -0.00800603f, -0.01767441f, -0.04082663f, 
    -0.02811190f, -0.03313075f, -0.03748415f, -0.04157986f, -0.02152807f, 0.01120165f, -0.00617354f, -0.00073615f, 
    0.03479346f, 0.00200445f, -0.01439908f, 0.00722194f, 0.02355989f, -0.02308339f, 0.00006153f, 0.00481211f, 
    0.02343000f, -0.03326480f, -0.04043395f, -0.03946176f, -0.01020328f, 0.00924487f, 0.02222733f, -0.02496282f, 
    0.01408529f, 0.00002700f, -0.02778368f, -0.03321962f, 0.01799132f, -0.03966377f, 0.01983185f, 0.01762134f, 
    -0.01466298f, 0.02231866f, -0.03260493f, -0.02847658f, -0.00131238f, -0.00805332f, 0.03525256f, -0.01097296f, 
    0.02248960f, 0.01910780f, -0.00735775f, 0.01054902f, -0.03710350f, 0.00368204f, 0.00747297f, -0.01575255f, 
    0.01137120f, 0.00709803f, 0.02612952f, -0.02903823f, -0.00172213f, 0.02147220f, -0.02671476f, -0.00145952f, 
    -0.01282122f, -0.01824548f, -0.03462779f, 0.00047520f, -0.00509096f, 0.01358151f, 0.02253094f, -0.01121849f, 
    0.00561985f, -0.00841532f, 0.02628295f, 0.02510934f, -0.02837688f, 0.01444386f, 0.02789469f, -0.03173030f, 
    -0.01851326f, 0.02431678f, -0.01289636f, -0.01367984f, 0.02352082f, -0.01407961f, 0.01033469f, -0.03716147f, 
    0.02405226f, -0.02969317f, 0.02259279f, 0.02970520f, 0.00768733f, -0.00027271f, -0.00493344f, 0.01521178f, 
    -0.02588082f, 0.02521253f, 0.02004373f, 0.02138989f, 0.00279992f, -0.01805586f, -0.00877669f, -0.03252757f, 
    -0.00421787f, -0.03367065f, -0.02541350f, 0.01671127f, 0.00027587f, -0.00119815f, -0.00030513f, -0.02302331f, 
    -0.00173652f, -0.01094003f, -0.02672497f, -0.00130304f, 0.01388097f, -0.01777460f, 0.01111551f, 0.01773062f, 
    0.00500693f, 0.01084493f, 0.01465007f, -0.03662730f, -0.02987951f, -0.00423759f, -0.02814816f, 0.00432156f, 
    -0.02891463f, -0.00287978f, -0.00530516f, -0.01009658f, 0.00258307f, -0.01655272f, -0.03945977f, 0.01503304f, 
    -0.02079359f, 0.02414769f, -0.00136386f, 0.02841036f, 0.01998147f, -0.01512576f, 0.00701131f, 0.02131502f, 
    0.00641457f, -0.02794216f, 0.01741850f, 0.00323240f, -0.02740538f, 0.01280351f, -0.00011857f, -0.00956156f, 
    -0.00826317f, -0.01039150f, -0.03460805f, -0.03918065f, -0.03142499f, -0.02055220f, 0.01646383f, -0.02411638f, 
    0.01488791f, 0.02682238f, -0.02178820f, 0.01156535f, 0.01185487f, 0.00957059f, 0.00454347f, -0.01915650f, 
    -0.02094745f, -0.03058182f, -0.01025844f, -0.02270303f, 0.01392302f, -0.03697947f, 0.01860330f, -0.02050874f, 
    -0.00835546f, -0.03245923f, 0.01031560f, -0.00176317f, 0.01832596f, 0.00098824f, -0.01124259f, -0.02807130f, 
    -0.03899470f, 0.01948568f, -0.02340133f, -0.02083056f, -0.03080738f, 0.00747026f, -0.01847385f, -0.02290464f, 
    -0.03702483f, 0.01830317f, -0.00694738f, 0.02307669f, 0.02650730f, 0.02534795f, 0.00391833f, 0.02944236f, 
    -0.01746058f, 0.00879316f, 0.01198414f, 0.00749828f, 0.02538631f, 0.02211160f, 0.00332176f, 0.01161276f, 
    -0.02573725f, -0.02177609f, 0.00044676f, -0.03404216f, 0.00044572f, -0.01138176f, -0.01429232f, 0.02748607f, 
    -0.02911584f, -0.00099852f, -0.03206582f, 0.02318993f, -0.04011751f, -0.02263867f, 0.01259571f, 0.00204620f, 
    0.01443085f, 0.01698986f, -0.02301848f, 0.00685109f, -0.01909991f, 0.02798205f, -0.03482928f, 0.02647436f, 
    0.02745769f, -0.00723194f, -0.04124822f, -0.02978045f, -0.04087207f, -0.02624628f, -0.04135960f, -0.02925307f, 
    0.00446416f, 0.01761556f, 0.00456176f, -0.02207663f, 0.00691363f, 0.01657822f, 0.01748927f, -0.01389180f, 
    -0.00848412f, 0.00942756f, 0.00297305f, -0.03413215f, 0.01463011f, 0.01351743f, -0.03905700f, -0.02287000f, 
    -0.02999355f, 0.01660122f, -0.00004623f, -0.03896271f, 0.00420125f, -0.01322411f, 0.01670875f, -0.03048567f, 
    -0.00635769f, -0.01918471f, 0.01053813f, -0.01411011f, -0.02827439f, 0.01796985f, -0.02962894f, 0.02918888f, 
    -0.03281216f, -0.03899041f, -0.00117104f, 0.00970746f, -0.01621472f, -0.00929573f, -0.03329273f, 0.01897935f, 
    -0.02545771f, -0.00215458f, 0.01953071f, -0.02902321f, -0.03189678f, 0.02000915f, -0.03915484f, -0.02474018f, 
    0.00266731f, -0.01068394f, -0.03675391f, -0.02154220f, -0.02698089f, 0.00658152f, -0.02092718f, -0.03800248f, 
    0.00956821f, -0.03587428f, 0.02515559f, 0.02266646f, -0.01993947f, -0.00933324f, -0.02489736f, -0.03408172f, 
    0.02640923f, 0.00408743f, -0.02451102f, -0.03697397f, 0.00874122f, 0.02364989f, 0.00701973f, -0.04188408f, 
    0.01312464f, 0.02190402f, 0.00848195f, 0.00772259f, -0.01120325f, -0.02490999f, -0.03356989f, 0.01330500f, 
    -0.02944325f, -0.04187079f, -0.00915439f, -0.03445978f, -0.00603817f, 0.01530535f, -0.03803647f, -0.01311570f, 
    0.01994125f, 0.02007576f, 0.02362577f, -0.03549723f, -0.02696799f, 0.01018716f, 0.02272069f, -0.03842913f, 
    0.02890677f, -0.03614558f, 0.02565555f, -0.02707813f, 0.02783152f, -0.03584731f, 0.00404666f, -0.02763933f, 
    0.02772275f, -0.02819642f, 0.01858886f, -0.03016594f, -0.03290043f, -0.00866214f, 0.02870865f, 0.00708557f, 
    -0.02131522f, -0.01054838f, 0.00625990f, 0.01006871f, -0.04098758f, 0.02656099f, -0.02435979f, -0.00135170f, 
    0.01724956f, 0.02533595f, 0.00289932f, 0.01906959f, -0.00548429f, 0.00053438f, 0.02049238f, 0.02458344f, 
    -0.03419837f, -0.03902015f, -0.03165203f, 0.01817551f, -0.03010190f, -0.03462939f, -0.00149272f, -0.02040124f, 
    -0.02108934f, -0.02716732f, -0.01956720f, -0.02509362f, -0.00832835f, 0.02639178f, 0.01359614f, 0.01685766f, 
    0.01503243f, 0.01728232f, -0.03276776f, -0.02240035f, -0.01149710f, -0.01262519f, 0.00577914f, 0.02063698f, 
    -0.00480917f, 0.00598258f, 0.00140405f, 0.02206951f, 0.00327864f, -0.01089258f, 0.01510265f, -0.01605937f, 
    0.02764129f, -0.00472885f, -0.01924039f, 0.00537793f, -0.00977912f, 0.01328925f, 0.01967929f, 0.02685926f, 
    -0.03131872f, -0.01308878f, 0.01027274f, -0.02791427f, 0.01665794f, 0.01883297f, 0.02201516f, -0.03253762f, 
    -0.03436721f, 0.01373889f, -0.03103537f, 0.01269966f, 0.00112427f, -0.01894470f, 0.02677784f, 0.01138153f, 
    -0.02319529f, -0.01460263f, 0.01653057f, -0.00368376f, 0.02259462f, -0.00271173f, -0.04114923f, 0.00950224f, 
    -0.02331421f, 0.00432801f, 0.01685055f, 0.00179905f, 0.00239434f, -0.01470420f, -0.02787045f, -0.00916204f, 
    -0.03375167f, -0.00372925f, 0.02488834f, 0.00620303f, -0.03229340f, 0.00383131f, 0.02761358f, 0.00294826f, 
    -0.04015294f, -0.01584409f, 0.01394311f, -0.02432296f, -0.04141211f, -0.02832018f, -0.01900699f, -0.02231499f, 
    -0.00323921f, 0.02404737f, -0.04141866f, -0.01515083f, -0.01120804f, -0.02422624f, -0.03578414f, -0.03426739f, 
    0.00761313f, -0.00931542f, -0.03652507f, -0.02950770f, -0.04166988f, -0.02009754f, -0.03356965f, -0.02711276f, 
    -0.02368298f, 0.00653978f, 0.02811372f, -0.03024824f, 0.00397941f, -0.02412593f, -0.01879805f, -0.02727426f, 
    -0.00593080f, -0.00040443f, -0.01488781f, 0.02802494f, -0.02656597f, 0.01911133f, 0.02168413f, -0.02966605f, 
    -0.03149600f, -0.02005762f, -0.03559471f, -0.00656325f, 0.00499590f, -0.00547058f, 0.00229733f, 0.01745483f, 
    0.00117457f, 0.01192619f, -0.01859606f, 0.01963282f, -0.00828640f, 0.02357003f, 0.00398747f, 0.02730249f, 
    -0.04202029f, -0.03983201f, 0.00787858f, -0.01787595f, 0.00880059f, 0.02024843f, -0.00807267f, 0.01442441f, 
    0.01279804f, -0.02301506f, -0.00521556f, 0.02446429f, 0.00562661f, -0.00894318f, -0.01067985f, 0.01734615f, 
    0.02632944f, 0.00077353f, 0.00043192f, -0.01515262f, -0.00172571f, -0.03977640f, 0.00016631f, -0.01131186f, 
    -0.00328257f, -0.02696262f, 0.00531036f, 0.01090682f, -0.00322619f, 0.02881270f, -0.03929683f, 0.00091959f, 
    -0.02811434f, -0.02041230f, -0.02014872f, -0.03632249f, 0.00877302f, -0.02439934f, -0.00519986f, 0.01686996f, 
    -0.01000793f, -0.02125076f, -0.02336543f, -0.03131975f, -0.00159236f, -0.01188866f, -0.01425226f, 0.00102076f, 
    -0.02367798f, -0.03012969f, 0.01340962f, 0.01380027f, -0.02706203f, 0.01668048f, 0.02351715f, 0.03961286f, 
    -0.03491817f, -0.00483188f, -0.00416707f, 0.02551409f, -0.02027753f, 0.01385338f, 0.02084508f, -0.04113166f, 
    -0.03904114f, -0.03667093f, -0.02806784f, 0.00865211f, -0.01205015f, 0.02955958f, -0.01734445f, -0.00368114f, 
    -0.01563898f, 0.00766826f, -0.01409540f, 0.01896247f, 0.00188333f, 0.01565812f, -0.01189393f, -0.01254806f, 
    -0.01393393f, -0.01972082f, 0.02774744f, -0.00754400f, 0.00141256f, -0.00122900f, -0.01740127f, 0.01660086f, 
    0.02998935f, 0.02034220f, 0.00242794f, -0.01160639f, -0.01480064f, 0.00528358f, 0.02893547f, 0.01954032f, 
    -0.02079515f, 0.01786400f, -0.00570136f, -0.04035735f, 0.00813900f, 0.01182407f, -0.00436537f, -0.02565914f, 
    -0.04123512f, 0.01943729f, -0.02282008f, 0.02563400f, 0.01088599f, -0.00140136f, -0.00980518f, -0.03691565f, 
    -0.03288204f, 0.01986742f, 0.02620582f, 0.01298516f, -0.01719654f, -0.02279257f, 0.02196765f, 0.01803823f, 
    -0.00217452f, -0.00292597f, -0.02380271f, -0.00453595f, -0.01132215f, -0.03800777f, -0.01289067f, 0.00405818f, 
    -0.01257959f, 0.00724437f, -0.04092881f, 0.02306975f, -0.01686116f, -0.01333142f, -0.00019959f, 0.01531122f, 
    -0.02712567f, 0.01339352f, -0.02968326f, -0.03316450f, -0.01931214f, 0.01409104f, -0.01897696f, -0.02423265f, 
    0.01962951f, 0.02608225f, -0.00189329f, 0.00287003f, -0.03173752f, -0.00795421f, -0.00442999f, -0.01938938f, 
    -0.01188395f, 0.00801736f, -0.00211436f, 0.00396991f, -0.02704343f, 0.02902076f, -0.02544347f, -0.03366086f, 
    -0.03074597f, 0.01782562f, 0.02552312f, 0.02479341f, 0.02062858f, -0.03894862f, -0.02412007f, -0.00377675f, 
    -0.01786486f, 0.02068157f, 0.00374539f, -0.00204099f, -0.00584603f, -0.02462672f, 0.00609005f, 0.00564838f, 
    -0.02782128f, -0.00892032f, -0.03741052f, 0.01772427f, 0.02457090f, -0.03176761f, 0.02501164f, -0.02259433f, 
    0.00340922f, 0.02925606f, -0.02712390f, 0.02723198f, 0.00226206f, -0.02123088f, -0.02311120f, -0.00808378f, 
    -0.03364307f, -0.03357084f, -0.02506419f, -0.03725627f, 0.01939678f, 0.00916950f, 0.00327606f, -0.03533508f, 
    0.01535914f, 0.01997478f, -0.01678124f, 0.00404606f, -0.01732955f, -0.01508592f, -0.02840576f, -0.03994949f, 
    -0.03182807f, -0.00739417f, -0.02942855f, 0.01864809f, -0.04188574f, -0.00494996f, -0.03683364f, -0.02830561f, 
    -0.01792801f, -0.04196852f, 0.01190331f, -0.03998406f, 0.02628731f, 0.01843692f, 0.00522134f, 0.01499186f, 
    -0.01771992f, -0.01607239f, -0.04068559f, 0.02552866f, -0.02316448f, 0.00406253f, -0.01499791f, 0.00454933f, 
    -0.03727623f, -0.03051948f, -0.01000250f, -0.03839750f, -0.02051484f, -0.03207326f, 0.01279456f, 0.02386015f, 
    0.01734681f, 0.01113115f, -0.02225235f, 0.01354720f, 0.00367025f, -0.00965180f, 0.02193478f, -0.02755802f, 
    0.01964183f, -0.02827226f, -0.00291477f, -0.03813884f, 0.00508470f, 0.01353991f, 0.01900844f, -0.03957836f, 
    0.00813658f, 0.00211719f, 0.01852809f, -0.03737030f, -0.00495011f, 0.00872089f, -0.00055243f, -0.03889288f, 
    0.02337170f, -0.01129569f, 0.02498155f, -0.00365658f, -0.01984704f, 0.02421716f, -0.00532951f, 0.02779902f, 
    0.21424589f, 0.11379002f, -0.09877999f, 0.03523253f, 0.00651053f, 0.00864536f, 0.07264983f, 0.13142619f, 
    0.05790504f, -0.02000820f, -0.00071878f, 0.02713626f, -0.07589039f, -0.15597856f, -0.17414184f, 0.10366838f, 
    -0.05044591f, 0.05442305f, -0.04553719f, 0.06339169f, 0.05542252f, -0.03351639f, 0.12306695f, -0.03549615f, 
    0.02024960f, 0.15359774f, 0.04867323f, 0.14389385f, -0.09377572f, 0.04885459f, -0.02261434f, -0.02622789f, 
    0.00230384f, 0.11155240f, 0.04445977f, -0.02086575f, 0.13482003f, 0.16028741f, -0.16063733f, -0.10686480f, 
    -0.05662656f, 0.00071323f, 0.13182665f, 0.13293821f, 0.06667721f, -0.13104297f, 0.06849969f, -0.07221016f, 
    0.20703430f, 0.06214939f, 0.06159723f, -0.08735288f, -0.09486820f, 0.05967809f, -0.02407717f, -0.05074560f, 
    -0.05304053f, 0.03033539f, 0.07355642f, 0.02125309f, 0.33450699f, 0.17687351f, -0.10311183f, 0.05996115f, 
    0.02578033f, 0.07771625f, 0.07906232f, 0.04267449f, -0.01506396f, 0.06091134f, 0.05128349f, 0.03789006f, 
    0.11939103f, -0.05785957f, 0.23123646f, 0.04396826f, -0.11094140f, -0.01841503f, 0.03121755f, 0.03277429f, 
    0.06013303f, 0.03770510f, 0.01269871f, 0.00273994f, 0.00401737f, 0.09449311f, -0.00392043f, -0.03104736f, 
    -0.06753056f, 0.01999738f, 0.01435857f, -0.13136804f, 0.13030404f, 0.01975677f, 0.02643544f, 0.05182185f, 
    -0.01242003f, -0.03302296f, -0.15376134f, -0.03627243f, 0.06357708f, 0.07902431f, 0.09749995f, -0.03904506f, 
    0.03087881f, 0.06891428f, 0.07367204f, -0.07164581f, -0.05241180f, 0.02023571f, 0.07423445f, -0.10430971f, 
    0.15089090f, 0.06299791f, 0.02141744f, 0.13274477f, 0.09613382f, 0.02801584f, 0.01281136f, 0.06449176f, 
    -0.30509874f, -0.02542475f, -0.11235086f, 0.06285270f, 0.11477999f, 0.03303361f, -0.00517933f, -0.03820981f, 
    -0.06953279f, 0.02054440f, 0.09933493f, 0.03307067f, 0.45717368f, 0.08514337f, -0.17421997f, 0.15182631f, 
    0.08155143f, 0.04986716f, 0.02812184f, 0.08736988f, 0.06022990f, -0.00277473f, 0.04642600f, -0.10760745f, 
    -0.01225846f, -0.03648217f, 0.06345318f, 0.14075783f, -0.02727215f, 0.04875976f, -0.04062132f, 0.06345950f, 
    0.02522748f, 0.05341780f, 0.01472658f, -0.04254786f, 0.11070507f, 0.00471027f, -0.04049731f, -0.02120002f, 
    -0.01952887f, -0.00853560f, 0.03453286f, -0.03784483f, 0.03412452f, 0.02985489f, -0.00552467f, -0.06386317f, 
    0.12871358f, -0.09011926f, -0.03656524f, 0.08143646f, 0.17248672f, 0.09894358f, 0.07321005f, 0.04058668f, 
    0.08638391f, 0.07209165f, 0.16861932f, 0.01998247f, 0.28517282f, 0.08551235f, 0.01602530f, -0.06549900f, 
    0.02395990f, -0.02006438f, 0.12198117f, -0.00305106f, 0.03182489f, 0.07955126f, 0.01910488f, 0.05045167f, 
    0.10738011f, 0.15457194f, -0.08914632f, 0.08922455f, -0.02468832f, 0.07318512f, 0.01911625f, 0.06729552f, 
    0.01582826f, 0.00900049f, 0.09579285f, 0.03438358f, -0.04061367f, 0.11870642f, -0.02214672f, -0.07128985f, 
    0.05648529f, 0.01614355f, -0.04368323f, -0.01379416f, 0.12903415f, -0.03473391f, 0.10204326f, 0.03437373f, 
    0.09857571f, 0.04564665f, 0.04195016f, 0.02486105f, -0.06200685f, 0.03516582f, -0.03127380f, -0.03798492f, 
    0.00482885f, 0.02374882f, -0.02798692f, -0.01070345f, 0.22047961f, -0.11181604f, -0.21549907f, -0.02497109f, 
    0.13615628f, 0.10474831f, -0.01155462f, -0.03462913f, 0.08709841f, 0.03453239f, -0.04360429f, 0.00254225f, 
    -0.17573750f, -0.03569528f, -0.03918086f, 0.07408729f, 0.03694289f, -0.03830982f, -0.11779919f, 0.06839199f, 
    0.01918326f, 0.11544073f, 0.02523858f, -0.02811122f, 0.19162761f, -0.10297380f, -0.03678399f, -0.04026758f, 
    0.07281777f, 0.01263684f, -0.05080851f, 0.01662201f, 0.05495826f, 0.07637578f, 0.00436503f, 0.05372747f, 
    0.22705552f, -0.04898556f, -0.01326639f, 0.07384909f, -0.05284255f, -0.06984267f, 0.00506980f, 0.04225194f, 
    0.02649838f, -0.02236801f, 0.01759928f, -0.02750098f, 0.05003167f, -0.01786923f, 0.08282933f, 0.01070181f, 
    -0.03597613f, -0.10307629f, -0.02149834f, 0.01709354f, -0.04047260f, 0.10352327f, 0.06748755f, 0.09760236f, 
    0.39057079f, -0.05318395f, -0.05306309f, 0.07919845f, 0.05374374f, -0.02867133f, -0.00081242f, -0.02679082f, 
    -0.02734671f, 0.01201243f, 0.11536638f, 0.03668441f, 0.06978443f, 0.13062192f, -0.14354260f, -0.03629640f, 
    -0.11427544f, 0.06211006f, -0.03121766f, -0.00516985f, 0.08870829f, -0.04285466f, 0.07849776f, 0.00861514f, 
    -0.23609364f, -0.00641291f, -0.13442411f, -0.19317001f, 0.17758825f, 0.06320272f, 0.02482567f, 0.09134822f, 
    0.04772441f, 0.02148349f, 0.02146347f, 0.04787755f, 0.31313118f, 0.16819030f, -0.20582244f, 0.15299159f, 
    0.10293306f, 0.08601864f, 0.03392855f, 0.05850193f, 0.02644212f, 0.07613883f, 0.04940903f, 0.13160430f, 
    0.17326772f, 0.01526230f, 0.14793913f, 0.11693513f, -0.10406300f, -0.01138787f, 0.00325506f, -0.02437913f, 
    0.10677676f, -0.07418395f, -0.04060184f, -0.01135284f, -0.28341356f, 0.18752965f, -0.09245408f, -0.02375667f, 
    0.08286855f, 0.08598775f, -0.02256510f, 0.02742634f, 0.08762632f, 0.03981832f, 0.05230602f, 0.17239211f, 
    0.13127497f, 0.05033237f, -0.19841859f, -0.10740913f, -0.13408154f, 0.00832303f, -0.01293965f, -0.04343377f, 
    0.00582153f, -0.00496385f, 0.08064761f, 0.01093497f, -0.08197650f, -0.05169054f, -0.12654157f, -0.15551496f, 
    0.14184631f, 0.06069435f, 0.05243909f, -0.00843388f, 0.05745314f, 0.03022721f, -0.00179524f, -0.04694923f, 
    0.05806119f, 0.20363341f, -0.05235534f, -0.09620643f, 0.10200498f, 0.05159155f, 0.06819359f, 0.16424304f, 
    0.15076548f, 0.04002216f, 0.06546175f, 0.05621231f, 0.30861366f, -0.04927914f, 0.12400866f, 0.12354822f, 
    -0.01545966f, -0.01220116f, 0.05002798f, 0.03799868f, 0.06658375f, 0.11995535f, -0.05521661f, 0.04482801f, 
    0.36279958f, 0.00990703f, 0.01024982f, 0.15190315f, -0.12798513f, 0.02125578f, 0.10076655f, -0.02678069f, 
    -0.00713808f, -0.02810325f, 0.04147970f, -0.00811996f, 0.10214710f, 0.00284431f, -0.03126922f, 0.01315316f, 
    0.06203250f, 0.11057944f, -0.02821629f, 0.12998168f, 0.03859164f, -0.04431172f, 0.08155796f, 0.12209893f, 
    -0.08711725f, -0.03622216f, 0.04897958f, -0.06160450f, 0.03113100f, -0.05747868f, -0.08827472f, 0.03022182f, 
    0.02630557f, -0.05825945f, 0.00290548f, 0.05501328f, -0.06201981f, -0.06151952f, 0.06776372f, 0.01054141f, 
    0.01159158f, -0.02364405f, 0.09369874f, 0.09215845f, 0.10702369f, -0.02518385f, 0.00616586f, 0.00703798f, 
    -0.28685465f, -0.11941610f, 0.13065572f, -0.03098586f, 0.09224630f, -0.02834477f, 0.11608826f, 0.13379294f, 
    0.13998573f, -0.01229390f, 0.03609094f, 0.07016387f, 0.02685729f, 0.08854688f, -0.02450468f, -0.05802581f, 
    0.07644965f, 0.13953950f, 0.03873304f, -0.04620139f, 0.06932045f, 0.03582711f, 0.01959161f, 0.09783781f, 
    -0.18295215f, 0.00882117f, -0.00395102f, 0.00059976f, 0.12568843f, 0.02928513f, -0.06588727f, 0.05270067f, 
    -0.06823123f, 0.09676339f, 0.03800930f, 0.00823095f, 0.20274132f, -0.13050653f, -0.03761218f, 0.06829765f, 
    0.06284411f, -0.01340868f, -0.12106214f, -0.00591648f, 0.06763925f, -0.01026547f, 0.08758599f, 0.04953580f, 
    0.13151874f, -0.05221954f, 0.00301243f, 0.08594947f, 0.07353530f, 0.07953662f, 0.06104206f, 0.03663891f, 
    0.04078866f, 0.02471944f, 0.08206306f, 0.11687220f, 0.10481503f, 0.09367578f, -0.00738834f, -0.08928309f, 
    -0.11242741f, -0.04783441f, 0.12191682f, 0.05981908f, 0.01005441f, -0.01432597f, 0.04658651f, 0.05405875f, 
    0.11823489f, 0.13663051f, 0.08856075f, -0.08090863f, 0.03454369f, -0.00501551f, 0.02236098f, 0.17507072f, 
    0.03295375f, 0.07215536f, 0.07251980f, 0.12947153f, 0.29487178f, 0.08336455f, -0.27486590f, -0.04903223f, 
    0.11309271f, 0.04789925f, 0.07815591f, 0.02690966f, -0.05980471f, -0.00324340f, 0.01704276f, -0.00270708f, 
    0.20132855f, 0.05617456f, 0.08819892f, 0.09930256f, 0.05304964f, -0.01824918f, 0.08633745f, 0.09529530f, 
    0.01413880f, 0.11889544f, 0.09455742f, -0.00597437f, -0.17749503f, 0.16061413f, -0.13262515f, 0.11393412f, 
    0.12610760f, 0.06417903f, 0.08137324f, -0.01438065f, -0.00062003f, 0.03529280f, -0.05165842f, 0.04301592f, 
    -0.11671404f, -0.10576669f, 0.06068828f, 0.18340833f, 0.10225268f, 0.08020435f, -0.04181147f, -0.04519878f, 
    0.01148024f, 0.10396377f, -0.07116624f, 0.12407716f, -0.02566897f, 0.04059991f, 0.00065615f, 0.03556959f, 
    0.00270395f, 0.12034611f, 0.09591275f, 0.04162486f, -0.01212906f, -0.01757918f, -0.02930141f, 0.01868306f, 
    -0.02755177f, -0.15989545f, 0.07878169f, 0.05489664f, 0.01470877f, -0.08931666f, -0.03419407f, 0.07124883f, 
    0.06491629f, 0.01848579f, 0.13641088f, 0.06706426f, 0.07924175f, 0.15439434f, -0.03772051f, 0.10795400f, 
    0.12834318f, 0.03793164f, 0.02824137f, 0.07869610f, 0.10937871f, 0.04996162f, 0.06557880f, 0.10765486f, 
    -0.08144111f, 0.10973399f, 0.14444770f, -0.18616988f, -0.18498369f, -0.01820016f, 0.03835066f, -0.11642259f, 
    0.04207383f, -0.09337483f, -0.02025712f, 0.02203706f, 0.08658674f, 0.00313862f, 0.18554275f, 0.01872613f, 
    -0.06882773f, 0.02124076f, 0.03320333f, -0.02022356f, 0.09333383f, 0.13216795f, 0.02877097f, 0.07421648f, 
    0.23803289f, -0.02742637f, -0.04299808f, 0.13090990f, -0.11658279f, 0.10845475f, -0.11101967f, -0.06671403f, 
    0.09097505f, 0.01516050f, 0.09925978f, 0.11208219f, 0.10848431f, 0.09871645f, 0.12328198f, 0.04732586f, 
    0.02075396f, -0.02560113f, 0.10914730f, 0.02673504f, 0.11356357f, 0.01320291f, 0.03936584f, 0.17142713f, 
    -0.11338110f, -0.19583449f, 0.11993577f, 0.01346837f, -0.02225157f, 0.09148204f, 0.01724412f, 0.07925788f, 
    -0.03775958f, 0.16601029f, -0.04114053f, 0.05621612f, 0.07427558f, 0.12705070f, -0.06846025f, 0.03644609f, 
    0.11840337f, 0.07004403f, 0.01365098f, 0.01981046f, 0.10836486f, -0.02506364f, 0.02461758f, 0.11367505f, 
    -0.05468198f, 0.22102955f, -0.08407442f, 0.17601803f, 0.03886182f, 0.13155925f, 0.08958759f, -0.03938526f, 
    0.09613243f, 0.03881057f, 0.10651616f, -0.02959295f, -0.13299678f, 0.04186480f, 0.08602457f, -0.01421434f, 
    -0.13106351f, 0.04071788f, 0.08723301f, -0.05116700f, 0.06409455f, -0.08665802f, 0.11103887f, 0.12783410f, 
    -0.11481012f, -0.05786086f, 0.01693523f, 0.06037160f, 0.18244357f, 0.04657852f, -0.02767206f, 0.00474541f, 
    0.04540949f, 0.05990776f, 0.09130546f, 0.02873427f, 0.26277259f, 0.02072977f, -0.19293228f, 0.02148889f, 
    0.00467295f, -0.00442811f, 0.03283844f, 0.03317196f, 0.15049794f, 0.09169976f, -0.00152758f, 0.01651592f, 
    0.02522825f, 0.01178627f, -0.02011150f, -0.07898208f, 0.09502210f, -0.05010065f, 0.06575821f, -0.01764495f, 
    0.07015198f, 0.00973213f, 0.02280456f, 0.02103518f, 0.20872194f, -0.24904403f, -0.04844104f, 0.01339075f, 
    0.06319610f, 0.08165501f, 0.02417601f, -0.02606962f, 0.08584138f, 0.08914313f, -0.00009464f, 0.00777786f, 
    0.38899535f, 0.17527203f, 0.01310250f, 0.09787893f, -0.07908066f, -0.06797343f, 0.12339703f, 0.09007798f, 
    0.01681153f, -0.02216815f, 0.01688416f, -0.07385057f, -0.14847276f, -0.10670259f, -0.18546307f, 0.21503925f, 
    0.03293123f, -0.01372521f, 0.04777524f, 0.02328466f, 0.06838024f, -0.05444122f, 0.03751316f, -0.16923092f, 
    0.15255594f, 0.15082121f, 0.07928073f, 0.16760509f, -0.01255664f, 0.09000184f, -0.07360641f, -0.01021027f, 
    0.06046209f, -0.00358087f, 0.14751136f, -0.08567701f, 0.07664526f, -0.02682893f, -0.10445081f, -0.10574624f, 
    -0.11149114f, -0.01132187f, 0.00716007f, 0.13223928f, -0.03015401f, -0.16974604f, -0.00834301f, -0.13250591f, 
    0.08906944f, 0.11762945f, 0.06356370f, 0.15350986f, 0.05769207f, -0.00836843f, -0.00528552f, -0.04447960f, 
    -0.09499636f, -0.00669189f, 0.02838242f, -0.09067155f, 0.12350425f, 0.11204855f, -0.09410545f, 0.00106192f, 
    -0.02609825f, 0.10219202f, -0.05159811f, 0.04081310f, -0.00046167f, 0.04763928f, 0.10141391f, -0.04249327f, 
    0.11042502f, 0.04490034f, 0.21447498f, 0.17978314f, -0.05256476f, -0.00052840f, -0.05501493f, -0.01960204f, 
    -0.12710446f, 0.06538586f, 0.01672432f, -0.03815800f, 0.13242297f, 0.10837205f, 0.21341741f, 0.18488187f, 
    0.06748503f, 0.03579987f, 0.06817847f, -0.13959651f, 0.13577567f, -0.03364452f, 0.00870612f, -0.00907293f, 
    -0.09764630f, -0.18904778f, -0.07602569f, 0.17741016f, 0.11120749f, -0.01377074f, 0.10311299f, -0.07761203f, 
    -0.02458483f, 0.09516485f, 0.04371483f, -0.04201631f, -0.10363672f, 0.10931852f, 0.06756820f, -0.08961755f, 
    -0.02063176f, 0.04047046f, -0.06709385f, 0.10551123f, -0.03989675f, -0.04709249f, -0.07491458f, 0.03860754f, 
    -0.25109473f, -0.12717800f, -0.01504233f, 0.15534535f, 0.14508709f, -0.10731905f, -0.05453879f, -0.10674766f, 
    -0.00837246f, 0.00646305f, 0.04310810f, -0.07381398f, 0.18868503f, -0.05189099f, -0.15154089f, -0.04487630f, 
    0.04215771f, 0.06222585f, 0.09343689f, 0.04832353f, -0.00226988f, -0.07051045f, -0.04402140f, -0.09357455f, 
    -0.04382054f, -0.02716576f, -0.04525995f, 0.13567168f, 0.02382196f, 0.12502778f, -0.01242593f, 0.01152692f, 
    0.02640165f, 0.04346089f, 0.03572321f, -0.08983880f, 0.11723128f, 0.04203698f, 0.01943980f, -0.03397382f, 
    0.05866478f, -0.05124900f, 0.00303965f, -0.12231030f, 0.00022433f, -0.07081596f, 0.02906753f, -0.09589117f, 
    0.14839257f, -0.20297509f, 0.01398274f, 0.08596516f, 0.09790444f, 0.00707525f, 0.05779518f, 0.02540180f, 
    0.00924512f, 0.03426518f, 0.06890670f, -0.08891894f, 0.09182698f, 0.08582404f, 0.07123315f, -0.10069698f, 
    -0.01634457f, 0.06798019f, 0.10493650f, -0.01796525f, -0.08758681f, 0.04592649f, -0.06807268f, 0.06679231f, 
    0.01529080f, 0.13543732f, -0.09464394f, 0.04967009f, 0.07002151f, -0.04149372f, -0.02497290f, 0.11396179f, 
    -0.02561265f, 0.02474757f, -0.01062313f, 0.00068622f, 0.17763250f, 0.17260309f, 0.00479714f, 0.06736735f, 
    0.01140120f, -0.00103712f, -0.00906440f, -0.01134073f, 0.05074792f, -0.09163379f, 0.07867514f, 0.03974279f, 
    0.03994873f, 0.06450676f, 0.13943978f, 0.08487790f, 0.01470117f, 0.04647529f, -0.02551492f, 0.03976380f, 
    -0.03311157f, -0.01753349f, -0.03929106f, -0.01391713f, 0.13296583f, -0.17929333f, 0.00025427f, 0.10798310f, 
    -0.01909793f, 0.00719464f, 0.01425241f, -0.03403275f, 0.05303127f, 0.07187797f, 0.01725229f, 0.04431923f, 
    -0.17992380f, -0.15248258f, -0.09806323f, -0.03135863f, 0.19520842f, 0.13221490f, -0.14817265f, 0.02394296f, 
    -0.01482354f, -0.03537448f, -0.06586929f, 0.01880115f, 0.08388522f, 0.06352086f, -0.07446623f, -0.09013916f, 
    0.03260884f, 0.04014201f, -0.05664469f, 0.04412652f, 0.01137095f, 0.04037856f, 0.00242418f, -0.05924516f, 
    0.03434321f, 0.02868989f, 0.07406097f, 0.06914758f, -0.06461836f, -0.06357294f, -0.09512099f, 0.02612049f, 
    0.03729995f, -0.06695544f, 0.04000457f, -0.14875560f, -0.02471428f, -0.07987984f, -0.10298366f, -0.09337062f, 
    0.01966041f, -0.06213839f, -0.06213014f, -0.00213281f, -0.05944501f, 0.02179536f, 0.08794221f, 0.02904483f, 
    0.19969180f, -0.16452897f, -0.14951937f, -0.07148024f, -0.06040821f, -0.01514678f, -0.04868554f, -0.05574330f, 
    -0.04182776f, -0.06009817f, 0.20096095f, -0.01158857f, -0.01463198f, 0.12832679f, -0.00629670f, 0.01535644f, 
    0.00280857f, 0.02371347f, 0.02598104f, 0.04273363f, 0.03067372f, -0.10045666f, 0.03750896f, -0.12427747f, 
    -0.06671920f, -0.05236748f, -0.15490623f, 0.04857093f, 0.00312289f, -0.01371250f, 0.04930787f, 0.03900903f, 
    0.00773837f, -0.00740360f, -0.00867052f, 0.09670518f, 0.30747393f, 0.02340710f, -0.19661456f, -0.07635575f, 
    -0.00800436f, -0.04138849f, 0.04274570f, 0.03027443f, 0.00053339f, -0.04529869f, 0.03277545f, 0.08494320f, 
    0.08119330f, -0.02549030f, 0.12105294f, -0.00531962f, 0.02254078f, 0.01155869f, -0.08556846f, -0.08153725f, 
    -0.14515448f, -0.09593052f, -0.10533538f, -0.05402185f, 0.00828729f, 0.15876321f, -0.02247893f, 0.01352898f, 
    0.05157095f, -0.11213800f, -0.08210437f, -0.02385792f, 0.00825282f, 0.07584704f, -0.05370149f, -0.01542434f, 
    0.07013146f, 0.05220007f, 0.00993274f, 0.08223003f, -0.06898377f, -0.05599789f, -0.03216331f, -0.02599613f, 
    -0.08271263f, 0.04444049f, 0.07930701f, -0.14256415f, 0.00337855f, -0.14601852f, -0.14796783f, 0.02300616f, 
    0.05170217f, 0.09640746f, -0.03863626f, 0.03033385f, -0.03981275f, 0.03115925f, 0.05056589f, -0.03379674f, 
    -0.06290243f, 0.05157824f, -0.10473496f, -0.04560626f, 0.02310558f, -0.04737754f, 0.04911028f, 0.03484358f, 
    0.04667267f, 0.12870218f, -0.00067700f, 0.00532270f, 0.26703674f, -0.08461147f, 0.02843771f, -0.02568293f, 
    -0.09988236f, -0.02719118f, 0.04327570f, 0.07271281f, -0.09349640f, 0.11536784f, -0.12914990f, 0.02922947f, 
    0.31340098f, -0.02335046f, 0.06457635f, 0.13923512f, -0.06675828f, -0.10586174f, 0.09087346f, -0.09411451f, 
    -0.00968928f, -0.02912309f, -0.02280704f, -0.06197707f, 0.10328732f, -0.09097803f, -0.11750689f, 0.06939751f, 
    -0.06035886f, -0.01030821f, -0.01579407f, 0.03292744f, 0.12502058f, -0.06665937f, -0.01537267f, 0.21259478f, 
    0.01288283f, -0.11829169f, -0.08760346f, -0.07492953f, -0.06228606f, -0.04286059f, -0.12299150f, -0.06621655f, 
    0.00694886f, -0.09736172f, 0.05994277f, -0.05514560f, 0.10294924f, -0.27829829f, -0.00406881f, 0.03355247f, 
    0.00856606f, -0.02955742f, -0.03082179f, -0.04316353f, 0.05647391f, 0.04993752f, -0.09001881f, 0.01029922f, 
    0.06971814f, -0.02066877f, -0.08811951f, -0.12606741f, 0.05962959f, -0.01054448f, 0.00869747f, 0.10525160f, 
    0.05409236f, -0.00784518f, -0.06858613f, -0.05375361f, 0.06327687f, 0.05356351f, 0.01894179f, 0.15579571f, 
    0.00330028f, 0.05627213f, 0.06017840f, -0.05158223f, 0.06794716f, 0.05102302f, -0.05135754f, 0.05466773f, 
    -0.08551802f, 0.19018419f, -0.11426246f, -0.10725039f, 0.04356955f, -0.02371332f, -0.12543572f, 0.05130592f, 
    -0.06184943f, 0.05366448f, 0.02572117f, -0.02952588f, -0.18253483f, -0.09192198f, -0.02000411f, 0.07205664f, 
    0.06843407f, 0.14112976f, -0.15318669f, -0.02765037f, 0.00077561f, -0.04251643f, 0.09537584f, -0.06102400f, 
    0.18256058f, 0.00069560f, -0.01660244f, -0.02280274f, 0.01799976f, -0.07910965f, 0.05549674f, -0.01142125f, 
    0.02463103f, 0.05208252f, -0.07672668f, 0.01900610f, 0.21273312f, 0.14646074f, 0.10419563f, 0.09844291f, 
    -0.11435720f, -0.01435876f, 0.06340871f, 0.03878354f, 0.00749952f, 0.06293248f, 0.01640554f, -0.01269278f, 
    0.01427253f, -0.00609489f, 0.02223167f, -0.07505942f, -0.00922929f, -0.00225646f, -0.07855650f, -0.02815043f, 
    -0.06470142f, -0.03218247f, -0.05400328f, 0.07544532f, -0.01058659f, -0.19808820f, -0.25360090f, -0.00012315f, 
    0.04906900f, -0.07266723f, -0.00477986f, 0.02057076f, -0.07300999f, 0.07166185f, -0.08318399f, -0.05230800f, 
    0.27000064f, -0.10063703f, 0.04362632f, -0.02750579f, 0.00007954f, 0.02931365f, -0.01206912f, 0.04721642f, 
    -0.05299421f, 0.03438939f, 0.13198815f, -0.11058959f, 0.20632102f, 0.09092743f, -0.04342644f, 0.08212054f, 
    0.00188027f, -0.00457931f, -0.04141128f, -0.10410403f, -0.05176786f, 0.05263510f, -0.07300718f, -0.08121196f, 
    -0.30780226f, -0.04786815f, -0.08910818f, 0.01925191f, 0.10735032f, -0.02710044f, 0.01807333f, -0.04487967f, 
    0.06809823f, 0.11331682f, 0.00682940f, 0.01980068f, 0.05675234f, 0.05627861f, 0.08067425f, -0.01960324f, 
    -0.08544677f, 0.10425132f, 0.10380562f, -0.08228077f, 0.00843607f, -0.00262803f, -0.02963972f, 0.00108613f, 
    -0.08930359f, -0.15063551f, 0.05187522f, 0.04282304f, 0.05252071f, -0.02987695f, -0.07403674f, 0.05572146f, 
    0.02712249f, 0.01471128f, 0.07863927f, 0.01048345f, 0.13953976f, -0.05108090f, -0.11072999f, -0.06762430f, 
    0.04644432f, -0.07826582f, -0.02039834f, -0.01090500f, -0.03668747f, -0.02548841f, -0.06104603f, 0.13220952f, 
    0.13566558f, 0.26622435f, 0.22963494f, 0.19140218f, -0.07170995f, 0.01640846f, 0.06205576f, -0.07583357f, 
    -0.03646620f, -0.05470109f, 0.07428353f, 0.00484359f, 0.19417329f, 0.04109034f, 0.18109779f, 0.08130533f, 
    0.05860222f, -0.00410222f, -0.03386402f, 0.04754588f, 0.02218113f, 0.02057440f, -0.02289793f, 0.04585510f, 
    0.13917537f, -0.08691269f, 0.02270259f, 0.10093305f, -0.01557016f, 0.01589769f, -0.14160864f, -0.07075058f, 
    -0.07042570f, 0.04622602f, 0.06287962f, 0.07470610f, 0.14613493f, 0.12830187f, 0.10556836f, -0.01330266f, 
    -0.01464575f, -0.02935285f, 0.13458183f, -0.01417252f, 0.00669769f, 0.02552770f, -0.00411260f, 0.05802510f, 
    -0.14908056f, 0.10578331f, 0.06771275f, -0.00125938f, 0.00712277f, 0.11430785f, -0.00927913f, 0.05542436f, 
    -0.04716494f, 0.05557904f, -0.08934753f, 0.03790152f, 0.15867303f, 0.03069634f, 0.02518505f, -0.03420692f, 
    0.01503521f, 0.00462009f, 0.06783696f, -0.07150517f, -0.04009290f, -0.02563406f, -0.09240423f, 0.13781656f, 
    0.00015575f, 0.04284511f, -0.07145017f, 0.09767844f, 0.10586391f, -0.04346263f, 0.01698512f, -0.11754820f, 
    0.02682784f, -0.07093970f, 0.08482435f, -0.07358018f, -0.08253000f, 0.05074732f, 0.12058381f, 0.18094365f, 
    -0.08251655f, 0.04766419f, 0.14372347f, 0.03499907f, -0.00835062f, -0.07179534f, 0.10293884f, 0.08398530f, 
    -0.11123014f, -0.05943564f, 0.09224848f, 0.12063049f, 0.09621299f, 0.03436685f, -0.02917259f, -0.06338228f, 
    -0.05795136f, 0.02654655f, -0.00128858f, 0.00669367f, 0.18195346f, 0.04817122f, -0.12262530f, 0.06129079f, 
    -0.10127810f, -0.09564575f, 0.06732429f, -0.05248543f, 0.06271116f, 0.08292437f, -0.08053292f, -0.09968752f, 
    0.12028909f, 0.04200371f, 0.02621006f, -0.03192826f, 0.06160668f, -0.06235646f, 0.04958648f, -0.02628627f, 
    0.00148205f, 0.03367702f, 0.03570430f, 0.03489080f, 0.05928957f, -0.12165273f, 0.01331763f, 0.02696347f, 
    -0.01221681f, 0.06734839f, 0.07104168f, -0.04875110f, 0.04247664f, 0.06299825f, -0.04882102f, -0.03355657f, 
    -0.03606714f, -0.02252113f, 0.02731603f, 0.01936700f, -0.01841417f, -0.00135731f, -0.00951687f, -0.03662826f, 
    0.00216123f, 0.00910289f, -0.02928671f, 0.01400871f, -0.03462671f, 0.01845851f, 0.00841369f, 0.02706477f, 
    -0.03386666f, 0.02660497f, -0.00021317f, 0.00430818f, -0.03678719f, -0.00701619f, -0.02617361f, 0.02242134f, 
    0.02397132f, 0.00173505f, 0.00401156f, -0.03211578f, 0.03102905f, 0.01309772f, 0.02651003f, 0.02228324f, 
    -0.01505869f, -0.01374929f, -0.01717516f, -0.00937364f, 0.02926578f, -0.00547480f, -0.02490011f, -0.02928103f, 
    -0.00243947f, -0.03252776f, -0.00251669f, -0.01536930f, -0.02549654f, -0.03242592f, 0.00037658f, 0.00512315f, 
    -0.02914150f, 0.00129232f, 0.00306051f, -0.03495890f, -0.01198416f, -0.02070778f, -0.00118211f, -0.03914567f, 
    -0.01269625f, -0.02086182f, -0.03893602f, 0.00448224f, 0.00787934f, -0.01462735f, -0.03514506f, 0.00717027f, 
    -0.02882229f, -0.04006347f, -0.00842023f, -0.01526249f, 0.01805957f, 0.01853648f, -0.02642051f, 0.00383182f, 
    0.01268392f, 0.01210164f, 0.02149384f, -0.01189488f, 0.02508242f, -0.01510615f, -0.04263552f, 0.01307062f, 
    0.03133634f, 0.01713317f, 0.01145552f, -0.00854503f, -0.01398294f, 0.02559051f, -0.00336802f, 0.01222592f, 
    -0.01832540f, -0.02485019f, -0.02325643f, -0.02247225f, -0.02686839f, 0.00698641f, -0.00646990f, 0.01569859f, 
    0.01689710f, -0.02891180f, 0.04078303f, -0.00561397f, -0.03729030f, -0.02627187f, -0.03320707f, -0.02320813f, 
    0.03474361f, 0.01382019f, -0.00411373f, -0.00431688f, -0.02239774f, -0.00253015f, -0.02899213f, -0.03650729f, 
    0.01888989f, -0.04587194f, 0.01334693f, -0.03269289f, -0.03359211f, -0.03971991f, -0.01186321f, 0.02922557f, 
    -0.00630899f, -0.01008054f, 0.03137780f, -0.02132735f, -0.00794616f, 0.01109486f, -0.00983116f, 0.00173461f, 
    0.02337808f, 0.00529088f, 0.02141163f, -0.01568341f, -0.02005421f, -0.02873741f, 0.01676792f, -0.03596980f, 
    -0.01166812f, -0.03911493f, -0.03156255f, -0.00222023f, 0.02138880f, 0.00384290f, 0.01355325f, 0.00781977f, 
    -0.01267091f, 0.00601770f, -0.02155491f, -0.02756382f, 0.00285759f, 0.02590733f, 0.01747437f, 0.03048176f, 
    0.02918366f, -0.00965706f, 0.01046278f, -0.02350994f, -0.02960314f, -0.03862439f, 0.02769393f, 0.00072385f, 
    0.02652477f, -0.03292327f, -0.02060045f, -0.01599617f, 0.01364271f, -0.01225013f, 0.02740668f, 0.00525668f, 
    -0.02407437f, 0.01141516f, 0.03227932f, -0.03686512f, -0.03820924f, 0.00313661f, -0.04440081f, 0.01171386f, 
    -0.00777906f, 0.01754214f, -0.00398939f, -0.02165939f, 0.01820470f, -0.03364183f, 0.01539362f, 0.02428671f, 
    -0.00950814f, -0.00796667f, -0.03373392f, -0.03366994f, 0.01209928f, 0.00669533f, -0.02281500f, -0.02473849f, 
    0.00928797f, 0.00264352f, 0.00456152f, -0.03734316f, -0.01765742f, 0.00342760f, -0.01444660f, -0.03341089f, 
    -0.00044803f, -0.00510110f, 0.00777270f, -0.02450259f, -0.01629830f, 0.02447275f, 0.01218828f, 0.02458696f, 
    0.02817845f, 0.00024561f, -0.00194739f, 0.01534072f, -0.00706145f, -0.02767488f, -0.02710962f, -0.02294747f, 
    -0.02120083f, -0.01451569f, 0.01932308f, -0.03396782f, -0.01687078f, 0.00892305f, 0.02697910f, 0.02519318f, 
    0.02047005f, -0.03224877f, -0.03076007f, -0.00125604f, -0.03920012f, -0.01361432f, -0.01114123f, 0.00470397f, 
    -0.02321522f, 0.02658236f, -0.03400118f, -0.01776255f, -0.03851364f, 0.02966129f, -0.01111979f, -0.01833924f, 
    -0.00656320f, 0.00608256f, 0.02085729f, 0.00412028f, -0.02463312f, -0.02602341f, 0.00556708f, 0.00944717f, 
    -0.02239672f, 0.00463259f, -0.00726638f, 0.03006301f, -0.00051458f, -0.01682661f, -0.02907505f, -0.02045467f, 
    -0.02372500f, 0.00813240f, 0.00597656f, 0.01876618f, 0.00782605f, -0.02290200f, -0.01709211f, 0.01941769f, 
    0.00353964f, 0.02882001f, -0.00702909f, -0.02704449f, 0.01481448f, -0.02276995f, -0.02105507f, -0.01196440f, 
    0.02834932f, -0.01666678f, 0.01352883f, -0.03349717f, -0.00357830f, 0.02458932f, -0.03893220f, 0.01693902f, 
    -0.01947200f, -0.00026171f, 0.03460174f, -0.01680559f, -0.02465877f, 0.02205995f, -0.00629413f, 0.02966804f, 
    -0.01997654f, 0.02687473f, 0.02199067f, -0.01922063f, 0.00850675f, -0.02377234f, 0.00926489f, -0.01395320f, 
    -0.02113481f, -0.00218154f, -0.03406597f, 0.03143314f, -0.01937551f, -0.00097792f, -0.01461327f, 0.01842382f, 
    -0.01516583f, -0.00286516f, -0.01357254f, -0.01856303f, -0.04144666f, -0.03537646f, 0.00299752f, 0.01465289f, 
    -0.03351714f, 0.01363669f, 0.00798488f, -0.01975228f, 0.01582171f, -0.03769162f, 0.00059461f, -0.00472738f, 
    -0.00872730f, 0.00770711f, -0.01302895f, -0.03930207f, 0.00311632f, 0.00095401f, 0.01631753f, -0.02098111f, 
    0.02953509f, 0.01330584f, 0.01713138f, -0.01757264f, -0.01555617f, -0.01086801f, -0.01400783f, -0.00507174f, 
    -0.02659030f, -0.01202982f, -0.01301565f, -0.02920090f, -0.03388681f, 0.00083605f, 0.02105971f, -0.02746858f, 
    0.02847740f, -0.01039057f, -0.02402384f, 0.02131402f, 0.02355241f, 0.00837364f, 0.01430747f, -0.01575256f, 
    -0.01609945f, -0.03859304f, -0.00291016f, -0.03009268f, -0.03925207f, -0.02532206f, 0.01226031f, -0.00610911f, 
    0.02890667f, 0.00669326f, -0.03329051f, 0.02724970f, 0.03887669f, 0.00705021f, -0.01330206f, 0.02752354f, 
    0.02332769f, -0.01160676f, 0.01326959f, -0.02471768f, 0.00341904f, 0.03164755f, -0.00104681f, -0.03177110f, 
    0.02402454f, -0.03581422f, -0.00843150f, 0.02694543f, -0.02821741f, -0.03507671f, -0.02290330f, -0.02939835f, 
    0.01133994f, -0.00096880f, 0.02874095f, -0.00516727f, -0.01761540f, 0.01886711f, -0.03094209f, 0.02279636f, 
    0.02121534f, -0.02510316f, -0.02909035f, -0.01254168f, -0.04027817f, 0.02934141f, -0.02014204f, -0.03768728f, 
    -0.00375021f, -0.01351775f, 0.00138750f, -0.00466456f, 0.02281608f, 0.01481259f, -0.03199442f, -0.01537217f, 
    -0.01426019f, 0.00667872f, -0.00374955f, 0.00882959f, 0.03603867f, 0.02304388f, -0.01248302f, -0.00501570f, 
    -0.01163316f, -0.00063340f, -0.00049240f, 0.02669479f, 0.01769725f, -0.00638721f, -0.02324897f, 0.01260479f, 
    -0.03888174f, 0.01351685f, -0.02031117f, -0.03652287f, 0.02803578f, 0.00574473f, 0.01520656f, -0.00515867f, 
    0.03397899f, 0.01830523f, -0.03215289f, 0.02215905f, 0.03152625f, 0.00786629f, 0.01393023f, 0.00286389f, 
    0.02231058f, 0.03146978f, 0.01710667f, -0.03224023f, -0.02940048f, 0.01919569f, 0.01904986f, -0.02717831f, 
    -0.01290659f, -0.02384633f, 0.02078493f, 0.02382937f, -0.03348035f, 0.03278951f, 0.02309289f, 0.01718199f, 
    -0.00580078f, -0.01887969f, -0.03689797f, 0.00655480f, -0.01290166f, -0.03750690f, -0.00273542f, -0.03682536f, 
    0.00847860f, 0.02723421f, -0.03182092f, 0.01662971f, 0.03545051f, -0.00628618f, 0.00808675f, -0.00993258f, 
    -0.01980572f, 0.01548125f, -0.02037471f, -0.00571829f, 0.00035342f, -0.01955094f, -0.00111795f, 0.00247360f, 
    0.00706109f, 0.02046072f, -0.02101483f, 0.01548431f, 0.02688686f, -0.01043776f, -0.00755951f, -0.02692176f, 
    0.02281694f, -0.01708437f, 0.02698087f, -0.03282217f, -0.01357635f, -0.01237469f, -0.02443264f, 0.01934870f, 
    0.02244562f, -0.00286405f, -0.00379662f, 0.00874402f, 0.01742940f, 0.00610149f, 0.01388022f, -0.03255567f, 
    -0.03347103f, -0.00899718f, -0.01481120f, 0.00039404f, -0.01642642f, 0.01012065f, 0.00888918f, 0.01578348f, 
    -0.00365119f, -0.01276132f, -0.03089561f, 0.02064187f, -0.01701155f, -0.01679642f, -0.03040141f, -0.01141734f, 
    0.01867347f, 0.02941761f, -0.01450100f, 0.00763764f, 0.01376079f, -0.03254308f, -0.03040024f, -0.03298806f, 
    -0.00415489f, 0.02168927f, -0.01204915f, -0.02075597f, 0.00314363f, -0.00029363f, -0.01124397f, -0.03542231f, 
    -0.01263865f, -0.00295417f, -0.01249757f, 0.01647797f, -0.02497280f, 0.02836576f, 0.03667854f, -0.00756433f, 
    0.00488388f, 0.01854471f, -0.02356496f, -0.01893144f, -0.01699508f, -0.01016070f, -0.03562819f, 0.02578984f, 
    0.00276095f, 0.01425153f, 0.01463074f, 0.02445696f, 0.02307303f, 0.01337200f, -0.03734871f, 0.00214669f, 
    -0.01120640f, -0.00003841f, -0.00679020f, -0.00688709f, -0.00742837f, 0.02124272f, -0.01566214f, 0.01970198f, 
    0.00387865f, -0.01492291f, 0.03274738f, -0.01912788f, -0.01577689f, -0.02987364f, 0.00292633f, 0.02756369f, 
    0.02620975f, 0.02813578f, 0.02086904f, -0.02204681f, -0.02535090f, -0.01081878f, -0.03858398f, -0.00462408f, 
    -0.00518101f, -0.03660535f, -0.02466463f, -0.00173550f, -0.03276872f, -0.03294196f, -0.04052270f, 0.01528257f, 
    0.02218886f, -0.00502539f, 0.00917373f, 0.00989034f, -0.03095645f, 0.01311526f, 0.02007961f, 0.00947692f, 
    0.01906743f, -0.03200483f, -0.02989810f, 0.00995773f, -0.01124671f, -0.02404737f, 0.00145503f, 0.00210516f, 
    0.02682568f, 0.03206619f, -0.00192546f, 0.02387150f, -0.00449235f, -0.02441780f, 0.01449670f, -0.01980850f, 
    -0.02117811f, 0.00122160f, -0.00231445f, 0.01818014f, -0.00726215f, 0.01753366f, 0.03014757f, 0.00449650f, 
    -0.02192949f, 0.01476981f, -0.03036015f, 0.00147618f, -0.03002343f, 0.02894951f, 0.00119822f, -0.03832085f, 
    0.00096698f, 0.02994703f, -0.03263657f, -0.01196573f, 0.02204224f, 0.02563445f, 0.01418000f, -0.01994876f, 
    0.00919811f, -0.00156034f, 0.01441290f, 0.02488133f, 0.01655026f, 0.01866337f, -0.01933790f, -0.03500248f, 
    0.02179303f, -0.03346305f, 0.03431468f, 0.01182372f, 0.02690663f, -0.01602007f, 0.00675698f, -0.00506393f, 
    -0.03682411f, 0.01307841f, -0.01114398f, -0.01161493f, -0.00088819f, -0.02738179f, -0.00546351f, -0.00572773f, 
    0.01987790f, 0.02728733f, -0.01295895f, -0.03391702f, -0.01415654f, 0.02995380f, -0.02333174f, -0.01376705f, 
    0.02363397f, 0.02980809f, -0.02526713f, 0.03230910f, -0.02437849f, -0.03080595f, -0.02781056f, -0.00444471f, 
    -0.03135986f, -0.01957869f, -0.01551739f, 0.01125495f, -0.03815577f, 0.02940644f, -0.00737305f, 0.02574933f, 
    -0.00024361f, 0.01614846f, -0.01602020f, -0.02190746f, -0.03069559f, -0.03742731f, -0.01673886f, -0.00274218f, 
    -0.03028065f, 0.00101071f, -0.00794410f, 0.01383085f, -0.04004226f, -0.02428190f, 0.01310889f, -0.02413381f, 
    -0.00036785f, 0.02421204f, 0.01654226f, -0.03152447f, 0.00523293f, -0.03527733f, 0.00719619f, 0.01829807f, 
    -0.01054155f, 0.01030828f, -0.01939678f, -0.02415294f, -0.03518024f, 0.02367760f, -0.00140121f, 0.01887977f, 
    0.00756678f, 0.02227948f, -0.01915705f, -0.02963755f, -0.02395212f, -0.03694487f, -0.00783690f, -0.02385207f, 
    -0.01780094f, -0.02439675f, 0.02156197f, -0.00752833f, 0.00092304f, -0.02019585f, 0.03137239f, -0.01355270f, 
    -0.02027669f, -0.01575086f, 0.01710269f, -0.02443158f, -0.01132559f, 0.00682885f, 0.01004228f, 0.01191712f, 
    0.00361833f, -0.01901498f, -0.02539109f, 0.01010349f, 0.01813817f, -0.02545160f, -0.03228065f, -0.00098863f, 
    0.01740106f, 0.00585396f, 0.00555201f, -0.00557034f, -0.03486980f, -0.00853263f, -0.01155423f, 0.02047857f, 
    0.03146401f, -0.02478650f, 0.01192043f, -0.00979387f, -0.02814926f, -0.02188084f, -0.03405453f, -0.02839350f, 
    -0.00964062f, -0.02769587f, 0.04091257f, -0.02555732f, 0.00116069f, -0.00804296f, -0.01070476f, -0.01821168f, 
    -0.02752424f, -0.01338698f, -0.03633517f, 0.01147520f, -0.02289588f, -0.03122722f, 0.02369804f, -0.01280787f, 
    0.00441340f, 0.00845292f, -0.00007725f, 0.01710165f, -0.03003876f, -0.03315113f, 0.02642648f, -0.01751388f, 
    0.00596560f, -0.01441336f, -0.00791483f, 0.03369259f, -0.00829932f, 0.02102430f, -0.00778264f, -0.01076737f, 
    0.02560328f, 0.01072554f, -0.01580082f, -0.02977967f, 0.02918833f, 0.01017344f, 0.02602665f, -0.04097088f, 
    0.00671022f, -0.04072653f, -0.02423688f, -0.00800573f, 0.02178702f, 0.02246922f, 0.01702114f, 0.02816435f, 
    0.02369647f, 0.01746729f, -0.02745020f, -0.02748107f, -0.02223594f, -0.04020967f, 0.01265857f, 0.01001932f, 
    0.02018025f, -0.01209945f, -0.03768448f, -0.03613162f, -0.00729086f, -0.00489966f, -0.00316543f, -0.03921746f, 
    -0.03800259f, 0.04149982f, -0.01542037f, 0.02717539f, 0.01702869f, -0.02619660f, 0.00963562f, -0.00461656f, 
    0.02016886f, -0.02535719f, -0.00125868f, -0.02359002f, 0.02799601f, 0.02136764f, 0.00239488f, -0.03329542f, 
    -0.01640971f, -0.01523165f, 0.00860245f, -0.00329556f, -0.00518387f, -0.02950030f, 0.02849103f, -0.01022031f, 
    -0.01690563f, -0.00179535f, 0.02594369f, 0.02979936f, -0.01216112f, 0.01159707f, 0.02674693f, -0.02721567f, 
    0.00046533f, 0.01873218f, 0.02957619f, -0.00133556f, 0.01579092f, -0.00777789f, -0.03768436f, 0.02429876f, 
    -0.01102298f, -0.00244123f, 0.01068466f, -0.01695239f, 0.01009102f, -0.00134353f, -0.02083484f, 0.00723522f, 
    0.00769528f, -0.03281320f, -0.01422004f, -0.03234061f, 0.01081169f, 0.00723467f, 0.01172685f, 0.02312843f, 
    -0.03524197f, -0.02895753f, 0.01812709f, -0.01962983f, -0.03238846f, -0.00130080f, -0.00189372f, -0.01318198f, 
    -0.02767656f, 0.00979088f, -0.00139062f, -0.02504605f, 0.00082450f, -0.01957583f, 0.02062259f, 0.00113507f, 
    0.00155792f, -0.01668414f, -0.03600794f, -0.02709308f, 0.01402219f, 0.00095861f, -0.02642181f, -0.03537958f, 
    0.01391737f, 0.03226221f, 0.00864025f, 0.02910703f, 0.00080703f, -0.02221558f, 0.00665891f, -0.02451250f, 
    0.01288795f, -0.01176760f, 0.01168886f, -0.03521714f, 0.01343744f, -0.02030814f, -0.00476943f, 0.01312851f, 
    -0.03056767f, -0.02258279f, 0.02679793f, 0.00509361f, -0.02805752f, 0.01756764f, -0.00476539f, -0.01447792f, 
    -0.00375314f, 0.03826116f, -0.02781948f, -0.01598640f, 0.02935173f, 0.00981801f, -0.01571688f, -0.01249229f, 
    -0.01604381f, 0.00047335f, -0.01446817f, -0.02138091f, -0.04014232f, -0.02620680f, -0.02427671f, -0.04084593f, 
    -0.00853381f, 0.01223604f, 0.01488568f, -0.02732605f, 0.00155814f, 0.02120537f, 0.00754081f, -0.03658916f, 
    0.01235767f, -0.00867508f, 0.01995601f, -0.01921566f, -0.00984862f, 0.04039726f, -0.02430966f, 0.01595627f, 
    -0.03528456f, 0.01936957f, -0.01747417f, -0.01940502f, 0.00822565f, -0.01266635f, -0.02345308f, -0.04116707f, 
    -0.03658572f, -0.02951724f, 0.02247185f, 0.02991526f, 0.04189716f, -0.00985995f, -0.02535729f, -0.04088998f, 
    -0.01227375f, 0.00204300f, 0.01467880f, 0.00350275f, 0.01397114f, -0.02450700f, 0.01373895f, 0.00747872f, 
    0.02742834f, -0.03347316f, 0.00030645f, -0.00107053f, -0.01503830f, 0.01229204f, -0.03190038f, -0.04125198f, 
    0.01180528f, 0.01369995f, -0.01874883f, -0.02952497f, 0.01658653f, -0.03245595f, -0.02630994f, 0.02022715f, 
    -0.01764191f, 0.01757818f, 0.00938773f, 0.02600714f, 0.00832899f, 0.03555206f, -0.00709901f, 0.00968674f, 
    0.00463705f, -0.02851734f, 0.02542107f, -0.04111370f, 0.01906452f, -0.01855740f, 0.00541414f, -0.02578205f, 
    0.01012525f, -0.03506741f, -0.02074134f, 0.01982654f, -0.00531722f, -0.04019385f, 0.02411375f, 0.00427171f, 
    0.02794215f, -0.01793701f, -0.03207862f, 0.03191676f, -0.00569837f, 0.01312508f, -0.02521464f, 0.00198378f, 
    -0.03900433f, -0.03971890f, -0.01615751f, -0.01502116f, -0.03059905f, -0.00277749f, 0.02618459f, 0.01938749f, 
    -0.02596864f, -0.02673272f, -0.03297035f, -0.03045403f, 0.00493385f, -0.00019044f, 0.00495355f, 0.00937007f, 
    -0.02740218f, -0.02711904f, -0.03045668f, 0.01874809f, 0.02255962f, -0.00169447f, -0.01970886f, -0.01385983f, 
    -0.02726050f, -0.02261467f, -0.01439584f, -0.02687241f, 0.01097248f, -0.00693623f, -0.02158034f, -0.03660422f, 
    -0.01982581f, -0.02746432f, -0.01883357f, -0.03489100f, 0.00298091f, -0.00802625f, 0.01460263f, 0.02283786f, 
    0.02960918f, -0.01440616f, 0.02923440f, 0.01954239f, 0.02993813f, 0.02940292f, -0.01680112f, -0.01205802f, 
    0.01226187f, -0.03074931f, 0.03482301f, 0.02740888f, 0.01207634f, -0.01152953f, 0.02183700f, 0.02765267f, 
    -0.04094192f, -0.02192270f, -0.02796383f, 0.01036835f, 0.02072445f, 0.01386195f, -0.03090645f, 0.03865556f, 
    -0.02363976f, 0.00650613f, 0.02484409f, -0.03043052f, -0.02436265f, -0.01479927f, -0.03846646f, -0.03427300f, 
    -0.03232809f, 0.02234999f, -0.02751416f, 0.00639801f, -0.03798541f, -0.01052435f, -0.00708796f, -0.02244544f, 
    -0.01388436f, -0.02721967f, -0.02693845f, -0.02929730f, 0.02461051f, -0.01835225f, -0.01984129f, -0.01556673f, 
    0.02482006f, 0.00746772f, 0.02570477f, -0.01112716f, -0.03152330f, -0.03352073f, -0.01449738f, -0.03301818f, 
    -0.01802824f, -0.02953639f, -0.03250151f, 0.02558904f, -0.02412511f, -0.03155083f, 0.01186702f, 0.01038126f, 
    -0.03543122f, 0.02330194f, 0.02962623f, -0.02386420f, -0.01103509f, 0.02006417f, 0.01166857f, 0.01496316f, 
    0.00738000f, -0.01922293f, -0.00401595f, -0.03463901f, 0.00893790f, 0.03726270f, 0.02544068f, -0.02329120f, 
    -0.01774179f, 0.01980245f, 0.00670555f, 0.00139181f, 0.02487331f, 0.00813041f, 0.01113591f, 0.01671301f, 
    0.02662000f, 0.02866979f, 0.02519692f, 0.02302270f, -0.03712410f, -0.02419031f, -0.01848012f, -0.02881197f, 
    0.01041361f, -0.00955609f, -0.00315533f, 0.00735190f, 0.01206909f, 0.02395470f, 0.00520329f, -0.03590297f, 
    -0.00645233f, -0.01248987f, -0.01910617f, 0.03752194f, 0.02202844f, -0.03665757f, 0.01805090f, 0.02525835f, 
    0.00481210f, 0.00466238f, 0.02102820f, 0.01913061f, 0.00317500f, -0.02867142f, -0.01702309f, 0.03397456f, 
    -0.02750149f, 0.02162805f, 0.02615860f, 0.02044849f, 0.01620172f, 0.02722915f, -0.01165601f, -0.03808736f, 
    -0.02910516f, -0.00637787f, 0.02051200f, -0.01243007f, -0.02813385f, 0.02218881f, -0.00122515f, -0.01362528f, 
    -0.03738497f, 0.02035024f, -0.03814333f, -0.00199180f, -0.00545121f, -0.00076530f, -0.03616048f, 0.01637804f, 
    0.02556975f, 0.00796299f, -0.00431206f, 0.00289665f, -0.00843104f, 0.02918900f, 0.01570501f, -0.00866751f, 
    -0.01062205f, -0.02873697f, -0.04047296f, -0.03132774f, -0.04060994f, 0.03956550f, -0.01613378f, -0.03183855f, 
    0.00308819f, 0.02595023f, 0.02606718f, -0.01636368f, -0.00380275f, -0.01449437f, 0.00908821f, -0.00841543f, 
    -0.01265705f, -0.01991034f, -0.00500548f, 0.01853819f, 0.00536087f, 0.01290554f, 0.03852302f, -0.00812550f, 
    0.01408893f, -0.01075025f, 0.00164029f, 0.01017135f, -0.00068278f, 0.02143347f, 0.02179045f, -0.03961310f, 
    0.02798062f, 0.02361183f, -0.00699652f, 0.01655527f, 0.01127593f, -0.03842417f, -0.00573213f, -0.02505644f, 
    0.03830156f, -0.00624597f, 0.00339716f, 0.02075932f, 0.04195547f, -0.03075707f, 0.01054518f, 0.03380414f, 
    -0.02679319f, -0.02789467f, -0.00916645f, -0.00814394f, 0.02521723f, 0.00416481f, -0.02225014f, -0.00977394f, 
    -0.00026082f, 0.01648552f, -0.03966204f, 0.01346957f, -0.00638958f, -0.01638567f, 0.01213644f, 0.02321259f, 
    -0.00300153f, 0.02847694f, 0.01795537f, -0.02900582f, -0.00614597f, -0.02103344f, -0.03215671f, -0.02365225f, 
    0.00370899f, -0.02595103f, 0.02533580f, 0.01906843f, 0.03203205f, -0.03464106f, -0.02704017f, -0.03140493f, 
    0.00624088f, 0.00927695f, -0.04007970f, -0.01803822f, 0.00248238f, 0.00925434f, 0.00619680f, 0.01674122f, 
    -0.03718377f, -0.01161700f, 0.02722535f, -0.01696294f, 0.00636598f, 0.02418106f, -0.01742819f, 0.00900249f, 
    0.02654635f, 0.03049786f, -0.02781874f, -0.01355552f, 0.02260004f, -0.02871662f, -0.02250147f, -0.00209144f, 
    0.02559918f, 0.00611908f, 0.01000784f, -0.02821578f, 0.00223008f, 0.00884250f, -0.00326652f, -0.00438707f, 
    -0.00418399f, -0.02002191f, -0.04139095f, -0.01161614f, -0.01731195f, 0.00745402f, 0.00252040f, -0.04137855f, 
    0.02183015f, 0.02108584f, -0.01141648f, -0.02148294f, 0.03220265f, -0.02543247f, 0.01888167f, -0.01912485f, 
    -0.02648115f, 0.01732106f, -0.01499210f, -0.00578802f, 0.00922298f, -0.00903130f, 0.02404657f, -0.02925623f, 
    -0.02677932f, -0.02208318f, 0.00007857f, 0.02094064f, 0.01634254f, 0.00160034f, 0.00564345f, 0.02484226f, 
    -0.01767788f, -0.03775807f, -0.03739759f, -0.01242549f, -0.01675030f, -0.04107955f, 0.02391721f, 0.01209358f, 
    0.03521281f, -0.03443206f, 0.02444880f, 0.01334789f, 0.01372013f, -0.01218360f, -0.02066295f, -0.00873298f, 
    -0.01063456f, -0.02568925f, -0.00020014f, -0.00833083f, 0.02152737f, -0.03922718f, 0.02274062f, 0.00669630f, 
    -0.03310600f, 0.02655640f, -0.00774281f, -0.01712712f, 0.02018740f, -0.02038936f, -0.01413811f, -0.03778855f, 
    0.01106394f, -0.03856456f, -0.01408988f, -0.01738293f, -0.02339522f, 0.01851388f, -0.04081852f, -0.00542471f, 
    -0.01057911f, -0.00220802f, -0.02500405f, -0.02168091f, -0.00072053f, 0.03066922f, 0.01028995f, -0.03149017f, 
    -0.00171270f, 0.00169487f, -0.00171202f, -0.03389004f, -0.01257584f, -0.02110661f, -0.01991048f, 0.01876743f, 
    -0.03622437f, -0.03361586f, -0.00586851f, -0.00816467f, -0.01829713f, -0.03712128f, -0.01610473f, -0.01092338f, 
    0.02182236f, -0.01743685f, 0.00541181f, -0.02130437f, 0.00710981f, -0.03350778f, 0.01297971f, -0.01640480f, 
    -0.04170878f, 0.00986004f, 0.01910861f, 0.00873326f, 0.02952102f, -0.00108081f, -0.02513330f, -0.00225551f, 
    -0.03938415f, -0.03109807f, -0.02479425f, 0.02189557f, -0.03027827f, -0.01332584f, 0.02398035f, -0.02669953f, 
    -0.00515565f, -0.00181226f, 0.00134399f, -0.01707212f, 0.01518771f, 0.01989980f, -0.00657831f, 0.02626027f, 
    0.01125003f, -0.00036993f, 0.02711990f, -0.02782215f, -0.02611952f, 0.00401802f, -0.03677852f, 0.02396068f, 
    0.02093443f, -0.04138196f, -0.02762750f, -0.02991746f, 0.01817204f, 0.01193064f, -0.00766617f, -0.03348720f, 
    0.01081980f, -0.01434665f, 0.00656413f, -0.00203389f, 0.01334631f, -0.03015504f, 0.03007288f, -0.00085955f, 
    -0.00116152f, -0.01053626f, -0.02644282f, -0.03824848f, -0.01553027f, 0.00728028f, -0.03193477f, -0.02369346f, 
    -0.01868170f, -0.04126410f, 0.02001408f, 0.01186695f, 0.00597293f, 0.01877810f, -0.03392088f, -0.03495935f, 
    0.01240740f, -0.00408957f, 0.00816568f, 0.00874949f, 0.01240076f, -0.03902522f, -0.03654308f, -0.04118769f, 
    -0.02743230f, 0.02429738f, -0.00460393f, -0.01092251f, -0.03743656f, -0.00419005f, 0.00225674f, -0.02688674f, 
    0.01372573f, -0.00286683f, -0.00289364f, 0.03098864f, 0.00435176f, 0.00167483f, -0.01110151f, -0.01890201f, 
    -0.14892578f, 0.06446464f, 0.07139388f, 0.02303806f, 0.00196272f, 0.04408053f, -0.08754322f, -0.07318641f, 
    -0.01391811f, -0.03318737f, 0.02316579f, 0.02707769f, 0.34494057f, 0.03701422f, 0.02815344f, -0.24777532f, 
    0.03137138f, 0.04635736f, 0.09791144f, -0.00292465f, 0.00025138f, 0.09335174f, -0.11050837f, 0.14280881f, 
    -0.21681854f, -0.09717011f, 0.06127764f, 0.14516078f, 0.04558021f, -0.04405162f, 0.11007633f, 0.04910360f, 
    0.03989297f, -0.09456297f, 0.07887670f, 0.03254621f, -0.02811320f, -0.17897998f, 0.10547213f, -0.10819285f, 
    0.04358372f, 0.05634872f, -0.06570660f, -0.07021665f, -0.11419685f, 0.08600667f, -0.02710164f, 0.08143225f, 
    -0.20111412f, -0.11140142f, 0.11108804f, 0.12160253f, -0.02713813f, -0.00274490f, -0.02979140f, 0.03301562f, 
    -0.00954652f, 0.04301393f, 0.01646356f, 0.07226080f, -0.10431721f, -0.08479367f, 0.11833182f, 0.01039019f, 
    0.00202643f, -0.02300927f, 0.02889119f, 0.04162079f, 0.08372092f, 0.04223488f, -0.07783861f, -0.03080536f, 
    -0.11563995f, 0.02226751f, 0.02582580f, -0.29065758f, -0.03279014f, -0.01598601f, 0.07680102f, 0.10795844f, 
    -0.03731155f, -0.04997543f, -0.07524831f, 0.09259807f, -0.08777103f, 0.03145080f, -0.04033447f, 0.10670663f, 
    -0.07158891f, -0.07085679f, -0.05432365f, 0.09387896f, -0.16675474f, -0.01892156f, 0.04755783f, 0.06296409f, 
    -0.10369206f, 0.19114058f, 0.29326966f, 0.07376465f, -0.03011346f, 0.03637837f, 0.01275097f, 0.07040495f, 
    -0.02580768f, 0.03723885f, -0.01406044f, 0.09917177f, -0.18665135f, 0.04696398f, 0.16289805f, -0.04765227f, 
    -0.07016167f, -0.03402878f, 0.05380431f, -0.02170580f, -0.01605898f, 0.06763906f, 0.05823433f, -0.06833267f, 
    0.36425847f, 0.06460629f, 0.02852618f, 0.00661218f, -0.01321137f, 0.06707247f, 0.04110737f, 0.08055392f, 
    0.09697654f, 0.08199137f, -0.00764335f, 0.08124475f, -0.04819862f, 0.06616132f, 0.10172802f, -0.07442153f, 
    -0.09150473f, 0.02268959f, 0.08874326f, -0.02767125f, -0.08963905f, 0.02996000f, 0.03110756f, 0.17299926f, 
    0.00528534f, -0.04973163f, 0.05178319f, -0.01502787f, -0.00268906f, 0.02430512f, 0.09123677f, -0.03052969f, 
    -0.04099241f, 0.01135131f, 0.03690434f, 0.19326515f, -0.14415480f, -0.00100023f, 0.03953639f, 0.08240576f, 
    -0.02922330f, 0.00320328f, 0.01010492f, 0.08644219f, 0.01336048f, 0.05507359f, 0.14718987f, 0.07517746f, 
    -0.18333048f, 0.23233208f, 0.19411516f, 0.08804122f, -0.03125401f, -0.03606996f, 0.01237076f, 0.00546696f, 
    -0.15719435f, 0.02867457f, -0.00826867f, 0.08267199f, -0.14118969f, -0.11434997f, 0.11431404f, -0.16460393f, 
    0.03975936f, -0.01278901f, -0.13033836f, -0.00955081f, 0.07286856f, -0.07090953f, 0.03851061f, -0.10782990f, 
    -0.12450691f, -0.10314846f, 0.14065628f, 0.21517125f, 0.04919723f, -0.01551367f, 0.00468964f, -0.03562032f, 
    0.04013224f, -0.06419192f, -0.02893180f, -0.04620910f, -0.05410661f, -0.06263848f, -0.09000887f, -0.09514492f, 
    -0.10380646f, 0.04437160f, 0.06664474f, -0.01919237f, -0.16525598f, 0.03411704f, -0.04129792f, 0.12266695f, 
    -0.25308284f, -0.18492761f, 0.02714850f, 0.18706071f, 0.02300707f, 0.01737029f, -0.03067284f, 0.05587710f, 
    -0.01336964f, -0.02268092f, 0.07396659f, 0.06775892f, -0.09011166f, 0.19851962f, 0.29102707f, 0.10032950f, 
    0.01284662f, 0.00850562f, -0.00390164f, 0.02479807f, 0.04355755f, 0.02573761f, 0.05334695f, -0.08339974f, 
    0.24793111f, 0.05141876f, 0.13683854f, -0.05825347f, 0.03140389f, 0.02833104f, 0.16317281f, -0.05501449f, 
    0.01609531f, -0.02950587f, -0.08076117f, 0.01127648f, 0.21940324f, 0.09202850f, 0.09875668f, 0.25161153f, 
    -0.05952882f, 0.08203270f, 0.07155307f, 0.04189392f, 0.02330466f, 0.04973667f, 0.09268346f, 0.02111926f, 
    -0.20557584f, -0.26185322f, 0.05324185f, 0.06379081f, -0.00287040f, 0.05519408f, 0.08162057f, -0.05367618f, 
    -0.01342514f, 0.06073740f, 0.04393602f, 0.07581318f, 0.04954961f, -0.03373852f, 0.07815598f, -0.05040892f, 
    -0.03692821f, 0.17363125f, 0.01982837f, 0.07292235f, 0.07750829f, 0.04330444f, -0.00933404f, -0.07795490f, 
    0.02413151f, -0.24736208f, 0.10813981f, -0.15705711f, 0.07595463f, 0.00865352f, 0.04430848f, 0.02825075f, 
    0.13911863f, 0.01771748f, -0.11413679f, -0.04222289f, -0.00717457f, 0.03396989f, 0.05535214f, 0.16818666f, 
    -0.04330889f, -0.03418033f, 0.10907683f, 0.05221452f, 0.02310652f, 0.11137009f, -0.00127311f, 0.01438661f, 
    0.15803541f, 0.28937590f, 0.39721072f, 0.12580730f, 0.06005274f, 0.03324776f, 0.04574192f, -0.01602304f, 
    0.07517246f, 0.03008790f, 0.05828428f, 0.02080772f, -0.11906962f, -0.00221961f, 0.12247685f, 0.08653039f, 
    0.08803814f, -0.06612895f, 0.00765082f, -0.07177132f, 0.03372232f, 0.04606831f, -0.03889627f, -0.02794296f, 
    0.07572751f, -0.14562041f, -0.00296564f, -0.16496275f, 0.02421670f, 0.06572301f, -0.02517482f, 0.05957954f, 
    0.04003652f, 0.08367025f, 0.08886383f, 0.03596592f, 0.29012603f, 0.01172315f, -0.11431395f, 0.15189098f, 
    -0.01797584f, 0.00861869f, 0.12711185f, -0.07339473f, -0.05055089f, -0.05287309f, 0.04143093f, -0.13590024f, 
    0.00516250f, -0.08076769f, 0.10781141f, 0.08080577f, 0.17592615f, -0.03613612f, -0.02514274f, 0.05160647f, 
    0.03913750f, 0.00498272f, -0.02085321f, 0.01576381f, -0.06735972f, 0.07785608f, -0.08927283f, 0.02666466f, 
    -0.06636510f, -0.02937064f, 0.02318018f, -0.02095628f, -0.00132190f, 0.01150250f, -0.01064874f, -0.05642456f, 
    -0.12893736f, -0.10010301f, -0.04881872f, -0.07983710f, -0.06072258f, -0.00288023f, -0.00413725f, -0.06354304f, 
    0.05123371f, 0.02519001f, -0.02832206f, 0.00503310f, -0.14514896f, -0.09640560f, -0.21279483f, -0.02917577f, 
    0.03875917f, -0.02506192f, -0.02047352f, 0.03231464f, -0.04049205f, -0.06123044f, 0.12100250f, 0.01910458f, 
    -0.26689202f, -0.02693441f, 0.00143903f, -0.09762944f, 0.01153242f, -0.03230858f, -0.07922500f, 0.02605737f, 
    0.07131673f, -0.04646378f, -0.09192279f, 0.00872420f, -0.10386319f, 0.08549660f, 0.14077617f, 0.20070714f, 
    0.11020333f, -0.02261905f, 0.05320459f, -0.09627774f, 0.03030090f, 0.07381117f, 0.05559254f, -0.03707569f, 
    0.16819495f, 0.04907957f, 0.19241524f, -0.05856428f, -0.01737713f, 0.07407742f, 0.05997766f, 0.06594858f, 
    0.04138464f, 0.23320122f, 0.11188430f, -0.00708694f, -0.01276788f, -0.14320579f, 0.07152563f, 0.06591263f, 
    0.02833957f, -0.03321913f, 0.01085134f, -0.05584452f, 0.01736878f, -0.06561673f, 0.15390779f, 0.12776297f, 
    0.25655884f, 0.30485836f, 0.10065615f, -0.05751847f, -0.04156555f, 0.15858468f, -0.02876988f, -0.07259184f, 
    -0.13295202f, 0.10123112f, 0.07862022f, -0.04776436f, -0.07254143f, -0.02520667f, -0.05084686f, 0.06555008f, 
    -0.05425808f, -0.13298368f, 0.02450209f, 0.09240627f, -0.00388828f, -0.05266611f, 0.02922400f, -0.03903454f, 
    -0.05002007f, -0.08901981f, 0.06736734f, -0.23434559f, -0.00534023f, 0.03648065f, 0.06162121f, 0.07611626f, 
    0.02450109f, -0.09431874f, -0.05149142f, 0.09719775f, 0.28278023f, 0.19471130f, 0.06216086f, -0.09359853f, 
    -0.10618301f, -0.01465966f, 0.12357698f, 0.05599502f, 0.06678261f, 0.09242700f, -0.00758105f, 0.03609554f, 
    0.03070767f, 0.12362993f, 0.06578311f, 0.12184837f, -0.05830012f, -0.12861842f, -0.00520123f, 0.00466335f, 
    -0.02538359f, -0.04878165f, 0.03395805f, -0.14317319f, -0.06898282f, 0.00291019f, 0.03494585f, 0.19724928f, 
    -0.00013918f, 0.06263553f, -0.00495974f, -0.03783302f, 0.01057987f, 0.06777942f, 0.04869243f, -0.00707916f, 
    0.20305605f, -0.18085659f, 0.05163325f, 0.06848037f, 0.05657071f, 0.00412236f, 0.05960824f, -0.04487114f, 
    0.03774179f, 0.00685022f, -0.03402671f, -0.06844646f, -0.22199559f, 0.06449930f, 0.12655690f, 0.07178756f, 
    -0.08526637f, -0.02575045f, -0.08438156f, -0.04482281f, 0.14391299f, -0.09721836f, -0.07037324f, -0.08253641f, 
    0.17588323f, -0.10215296f, 0.04558077f, -0.07544879f, -0.05368600f, 0.01837452f, 0.05544777f, 0.06371500f, 
    -0.00109570f, -0.04564677f, -0.02811218f, 0.04429242f, -0.05793447f, -0.13720554f, -0.06522928f, 0.27469388f, 
    0.04008908f, -0.10665461f, -0.00338488f, 0.14197171f, 0.18275686f, 0.03250104f, 0.16983005f, 0.03876537f, 
    0.03116301f, 0.08488311f, -0.05881270f, -0.07409957f, -0.03042117f, -0.07244795f, -0.02924797f, 0.11589081f, 
    0.11190445f, -0.00598903f, 0.00659299f, 0.00520081f, -0.11617956f, 0.03886473f, 0.14742774f, 0.14356823f, 
    0.04833954f, -0.12541470f, -0.11677351f, 0.04398445f, 0.10242064f, 0.05879590f, -0.09625752f, -0.01880826f, 
    0.23360816f, 0.27134934f, 0.01688935f, 0.02093427f, 0.00130701f, 0.09504020f, 0.06914653f, 0.08547838f, 
    0.05200586f, -0.04747211f, -0.19226649f, -0.12741710f, 0.07479109f, 0.15384714f, -0.12326283f, 0.07805988f, 
    -0.00052178f, 0.03773600f, -0.03183631f, 0.00643100f, -0.02142070f, -0.05521920f, 0.03097777f, -0.14244832f, 
    0.12596086f, 0.03158947f, 0.07400071f, 0.21749640f, 0.04828069f, 0.08144777f, 0.05928878f, 0.19071093f, 
    -0.02211946f, 0.10562860f, 0.00300258f, -0.01776692f, -0.04951648f, 0.09885085f, 0.06840044f, 0.05467473f, 
    0.05767599f, 0.10068967f, -0.02080495f, 0.03729032f, -0.10256019f, -0.05907562f, -0.02541834f, -0.11628642f, 
    -0.15126890f, 0.01243827f, -0.07514956f, -0.08956526f, 0.20541975f, -0.06998560f, 0.01580197f, 0.02185605f, 
    -0.04892833f, -0.10706787f, -0.04116841f, -0.11641781f, 0.00933356f, -0.11923471f, -0.03100431f, 0.10800193f, 
    -0.09509493f, 0.09326682f, 0.01459959f, -0.11372083f, 0.02765843f, -0.05625350f, 0.06062933f, -0.09880968f, 
    0.11594327f, 0.25335971f, -0.14352868f, -0.14634246f, -0.01345672f, -0.06206865f, -0.01661929f, -0.03248938f, 
    0.02655521f, -0.08274525f, 0.04718322f, 0.02508618f, 0.04799039f, 0.14094746f, 0.03150382f, 0.01727503f, 
    0.10420933f, 0.08171557f, -0.03440870f, -0.11691643f, -0.08396402f, 0.08201538f, 0.03647695f, 0.01847214f, 
    0.00422848f, -0.12407339f, -0.00733468f, 0.02267825f, 0.06217842f, -0.08319912f, -0.00103459f, 0.13836843f, 
    -0.04289262f, 0.11774590f, -0.06504063f, 0.09159294f, 0.05887600f, -0.13353525f, 0.00279119f, -0.01262005f, 
    0.17186457f, -0.06892904f, -0.09933313f, 0.01020670f, -0.10637634f, 0.03635538f, -0.02009301f, 0.04678653f, 
    0.21156344f, 0.23517781f, 0.12386321f, 0.00705702f, 0.08310213f, 0.02467563f, -0.01016549f, 0.03800264f, 
    0.04014359f, 0.04598821f, -0.09571251f, 0.04646216f, 0.11376771f, -0.13683997f, -0.05067792f, -0.15028541f, 
    0.01187918f, -0.01336283f, 0.07974067f, -0.12011619f, -0.07239531f, -0.04143346f, 0.03846917f, 0.01265869f, 
    -0.12133845f, 0.08703170f, 0.03927806f, -0.06779353f, 0.04314774f, 0.04741764f, -0.04363667f, 0.06263021f, 
    0.07662816f, -0.01021580f, 0.07702251f, -0.02761926f, 0.12704328f, 0.29937518f, 0.22411689f, -0.00582319f, 
    0.05889793f, -0.05187700f, -0.04152314f, 0.04919251f, -0.04023859f, -0.04805469f, 0.04829415f, -0.09773595f, 
    0.00848830f, -0.01261178f, 0.01804581f, 0.02482538f, 0.00593539f, 0.00766698f, -0.00210685f, -0.00262115f, 
    -0.03469927f, 0.00587655f, -0.01369977f, -0.03604622f, 0.00847615f, 0.00468637f, 0.01669351f, -0.03414155f, 
    -0.00596411f, -0.03932927f, -0.00658557f, -0.04189505f, -0.01190686f, 0.00237520f, -0.01625336f, -0.02780611f, 
    -0.00396110f, 0.02891427f, -0.00409692f, 0.01425322f, -0.00811527f, 0.01815268f, 0.01409233f, 0.02677177f, 
    -0.01181662f, 0.00650380f, 0.00280876f, -0.03003168f, -0.03063733f, 0.01956845f, 0.00340931f, -0.03565065f, 
    0.02991108f, -0.00123648f, -0.00383320f, -0.03282732f, 0.02693374f, -0.01074158f, 0.00234909f, -0.02859361f, 
    0.02396557f, -0.03221591f, -0.00479183f, 0.01399563f, 0.01333062f, 0.01602793f, 0.02500172f, 0.00307951f, 
    0.02864736f, 0.00582544f, -0.00308735f, -0.01388129f, 0.02124009f, -0.03800829f, -0.02394594f, 0.02208870f, 
    -0.02067214f, -0.01602917f, -0.00685864f, -0.00810765f, -0.02571961f, -0.02758961f, -0.02171398f, 0.01544613f, 
    -0.00605267f, -0.03496037f, -0.01941139f, 0.00515250f, 0.02930772f, -0.01177484f, -0.03826056f, -0.00884206f, 
    0.00680349f, 0.01169657f, 0.02118180f, -0.01501941f, -0.02185661f, 0.01686853f, -0.02646717f, 0.02851498f, 
    0.01607747f, -0.03076942f, -0.02623457f, 0.02499251f, 0.02620681f, -0.03869374f, -0.02922076f, 0.00654662f, 
    0.01032864f, 0.00423663f, -0.00806388f, -0.03532051f, -0.01118807f, 0.02309787f, -0.03381722f, -0.01623341f, 
    -0.01606077f, -0.00523882f, -0.00978151f, -0.01266598f, -0.03162352f, -0.00319926f, -0.01018844f, 0.02964157f, 
    -0.03860413f, -0.01185775f, -0.01858588f, -0.01905920f, -0.02720254f, -0.01883854f, 0.01961063f, -0.03652271f, 
    0.02101669f, -0.02421492f, -0.00539156f, -0.02623094f, 0.00186286f, -0.03759856f, -0.02414338f, 0.01506685f, 
    0.00027739f, -0.02645351f, -0.03271792f, 0.01084615f, -0.03943095f, 0.01562505f, 0.02364999f, -0.02267454f, 
    0.01139152f, -0.00798083f, 0.00068406f, -0.01881424f, -0.00166653f, 0.02639967f, -0.02409776f, 0.01259161f, 
    0.02096633f, -0.02201245f, 0.01346454f, 0.00336265f, 0.00075132f, -0.01971017f, -0.03193734f, -0.02392712f, 
    0.02898750f, 0.00006533f, -0.01345229f, -0.02985786f, -0.04101582f, 0.00763254f, 0.01054442f, -0.03418611f, 
    0.02810243f, 0.00214095f, -0.00081764f, -0.00809595f, 0.02398186f, 0.01533935f, -0.02589546f, -0.01760463f, 
    -0.01588738f, -0.03642224f, 0.01354321f, 0.01174043f, -0.04031451f, -0.01691888f, 0.02735629f, -0.03066998f, 
    0.01852329f, -0.01446360f, 0.00876829f, 0.01041814f, 0.02588384f, 0.02205705f, -0.03776722f, -0.03765867f, 
    0.00257535f, 0.01720223f, 0.02929296f, 0.02789054f, -0.02923459f, -0.03910848f, 0.01757343f, -0.00902419f, 
    0.02217051f, -0.01459737f, 0.00559044f, -0.04166622f, -0.03629284f, 0.01654323f, -0.01469859f, -0.01575943f, 
    -0.01807278f, -0.04047164f, -0.02854234f, -0.02149325f, -0.03736124f, 0.02353109f, -0.03968031f, 0.02249027f, 
    0.01287507f, -0.02124820f, -0.01968000f, 0.01850528f, -0.03122896f, -0.01720083f, -0.01954104f, -0.00792200f, 
    -0.03376416f, -0.01758274f, -0.01972002f, -0.01710651f, -0.01323288f, -0.03471391f, -0.02994345f, -0.02198537f, 
    0.01138971f, 0.00980505f, 0.01973594f, -0.00135397f, -0.02514919f, -0.02678026f, -0.00625032f, 0.02879400f, 
    -0.00174906f, 0.01634877f, -0.02474689f, 0.02670701f, 0.00230671f, 0.02781568f, 0.00066339f, -0.01208716f, 
    -0.01418729f, 0.01348978f, 0.02310056f, 0.02210389f, -0.00548655f, 0.00919163f, -0.03222668f, -0.02393105f, 
    0.00305423f, -0.03255524f, -0.00989844f, -0.02315710f, -0.02657461f, -0.00494566f, -0.00720027f, 0.00864402f, 
    -0.02903282f, 0.00608779f, -0.01840637f, 0.00972893f, 0.02371850f, -0.01442102f, 0.00931276f, -0.02595314f, 
    0.00466492f, 0.00114644f, 0.00775025f, -0.00439982f, 0.00181682f, -0.02392953f, -0.00617192f, -0.03056570f, 
    -0.03158360f, -0.03391239f, 0.02554852f, -0.02868905f, -0.00604311f, 0.00897564f, -0.03829602f, -0.01235296f, 
    -0.02809146f, 0.00758384f, -0.00056120f, -0.01190808f, -0.02727279f, -0.00252458f, -0.02945067f, 0.01013521f, 
    -0.02215889f, -0.02713297f, -0.02552903f, -0.02892479f, -0.03782238f, 0.00939455f, -0.04103096f, -0.02824776f, 
    -0.03902788f, -0.00726776f, -0.01146609f, -0.01326184f, -0.03948050f, 0.02110933f, -0.01614530f, 0.01998471f, 
    -0.02488003f, -0.02520778f, -0.00525401f, -0.00762727f, -0.00201422f, 0.02984849f, 0.02420046f, 0.02756191f, 
    0.00225654f, -0.00398137f, -0.02973164f, -0.01023647f, -0.01314309f, -0.00898469f, -0.03489959f, -0.03585803f, 
    -0.02422039f, 0.01117125f, -0.02084656f, 0.00288485f, -0.02286556f, -0.01371474f, 0.02267413f, 0.01362806f, 
    0.01927321f, 0.00879555f, 0.00904727f, 0.00172867f, -0.01409792f, -0.01621651f, 0.01645184f, -0.03335036f, 
    -0.03164909f, -0.01631582f, -0.03169492f, -0.01747845f, -0.00075076f, -0.03336876f, -0.02278662f, -0.03898525f, 
    0.02410333f, -0.03770063f, 0.01833418f, -0.01388302f, -0.03639726f, -0.02184631f, 0.02986294f, -0.00090865f, 
    -0.01138083f, 0.02522377f, 0.00468150f, 0.01495340f, 0.01548715f, 0.01108172f, -0.00898251f, -0.03007564f, 
    -0.01602695f, -0.03517318f, -0.03657708f, -0.02373999f, 0.01324205f, 0.01179563f, 0.01638562f, -0.03510198f, 
    -0.00810591f, -0.03336765f, -0.01974804f, 0.00751046f, -0.01769687f, -0.00635183f, 0.01105978f, -0.02643376f, 
    -0.02587817f, -0.02289104f, 0.00032401f, -0.02503520f, -0.03605384f, 0.00608036f, 0.00629460f, 0.00989775f, 
    0.01741019f, -0.00068978f, -0.03480439f, -0.00800605f, -0.03110636f, 0.01953654f, -0.03663225f, -0.04059575f, 
    -0.03740080f, -0.02779251f, -0.02081705f, 0.01410424f, -0.01561827f, -0.02897432f, 0.00044640f, -0.01601163f, 
    0.00571763f, -0.02579041f, -0.01670604f, -0.03711803f, -0.03046668f, -0.00894762f, -0.01155848f, 0.02088909f, 
    -0.03673790f, -0.03043997f, -0.02742682f, 0.02263472f, -0.01688366f, -0.00897223f, 0.01959893f, 0.00762120f, 
    0.01296155f, 0.02166782f, 0.00492008f, -0.01889860f, -0.02302472f, 0.00756541f, -0.02930891f, -0.03399049f, 
    -0.02254065f, 0.00931324f, 0.00075130f, 0.00966274f, 0.02339424f, -0.01154500f, 0.00924932f, -0.02520105f, 
    -0.01432233f, -0.00996520f, -0.01849777f, 0.00010416f, -0.03716424f, -0.00110112f, 0.01068494f, 0.01857604f, 
    -0.01990661f, 0.02567684f, 0.00294772f, -0.00759494f, 0.01250495f, 0.01481748f, -0.00382708f, 0.01609747f, 
    -0.00443929f, -0.03297819f, -0.01928182f, 0.02158461f, 0.00587506f, -0.00213090f, 0.01960794f, 0.02618692f, 
    0.01397268f, -0.02937051f, -0.00414632f, -0.03592573f, 0.01801960f, 0.01807660f, 0.02013268f, 0.01551248f, 
    0.00987846f, 0.00677930f, 0.02643199f, 0.01290732f, 0.02946877f, 0.02489699f, 0.02620056f, -0.01955273f, 
    0.02183791f, 0.01414142f, -0.01966431f, 0.01512299f, -0.01016354f, -0.01886485f, -0.00160691f, -0.01892087f, 
    -0.00650174f, -0.03386323f, -0.00241470f, 0.00156552f, 0.02685556f, 0.02502737f, -0.03383489f, -0.02871805f, 
    0.00743308f, -0.04092907f, 0.01431851f, -0.02267725f, -0.01001047f, -0.02205846f, -0.02782207f, -0.00254142f, 
    0.01660361f, 0.00348801f, 0.01402928f, 0.01661124f, -0.00210459f, 0.00083701f, -0.02345087f, -0.04040274f, 
    -0.00411341f, -0.03473146f, -0.03713822f, -0.00303168f, -0.01783931f, 0.01875336f, -0.03156158f, -0.04204768f, 
    0.02044778f, -0.03939262f, -0.02321738f, 0.01360044f, -0.00703989f, 0.00883253f, 0.00952178f, -0.02925280f, 
    0.02163584f, -0.01490548f, -0.02928453f, 0.00268692f, -0.02280176f, 0.00195984f, -0.01325505f, -0.03606207f, 
    -0.01024225f, 0.00235566f, -0.02540022f, 0.01438678f, 0.02065074f, 0.00525901f, -0.03237113f, -0.00319848f, 
    0.02563816f, -0.04117788f, -0.00791499f, -0.00642576f, 0.00041422f, -0.02539559f, -0.03754267f, 0.00954265f, 
    -0.01765855f, 0.02694035f, -0.03729242f, -0.03149005f, 0.00494336f, 0.00235596f, -0.00459336f, 0.00892747f, 
    -0.01443380f, -0.01178243f, -0.03657443f, -0.02967535f, -0.00276030f, -0.04014265f, -0.03256600f, -0.03578343f, 
    0.01536045f, 0.01629782f, -0.02908354f, 0.01111962f, -0.02421319f, -0.01963867f, 0.00492864f, 0.01788447f, 
    0.00366340f, 0.00464467f, 0.01314929f, 0.01339416f, -0.03299181f, 0.00684561f, -0.00932645f, 0.02832578f, 
    -0.03456340f, -0.00770988f, 0.00830602f, 0.00902514f, -0.00541886f, 0.00412241f, -0.01838276f, 0.02197982f, 
    0.01459709f, -0.00165310f, 0.02547923f, -0.00446151f, -0.00383607f, -0.02046210f, 0.01074737f, 0.00973775f, 
    0.01252948f, 0.02333260f, -0.03761593f, 0.02780416f, 0.02644484f, -0.02180643f, -0.01090657f, 0.01110443f, 
    0.02910806f, 0.02728237f, -0.00607541f, -0.03705367f, -0.01357878f, 0.01255833f, -0.01285623f, 0.01887289f, 
    0.00478160f, -0.03427209f, -0.00688850f, -0.00471332f, -0.03271130f, -0.01682998f, 0.02845347f, 0.01017447f, 
    -0.01023267f, 0.01230646f, 0.00452607f, -0.02295002f, -0.01490216f, 0.01093652f, -0.02322101f, -0.03390035f, 
    -0.00738150f, 0.00979600f, 0.01763638f, 0.02884908f, -0.04125661f, 0.02399937f, -0.00747275f, -0.01168327f, 
    -0.02383665f, -0.00901782f, -0.01099904f, -0.00129563f, -0.03762760f, -0.00104304f, 0.02086476f, 0.00266348f, 
    -0.01834567f, -0.01792902f, 0.00326106f, 0.00843677f, 0.00685191f, 0.01076587f, 0.01520973f, 0.01998643f, 
    0.00459770f, -0.01238201f, -0.01270968f, -0.00598790f, -0.00550072f, 0.00834729f, 0.00657553f, -0.02543421f, 
    0.01880847f, 0.00440648f, -0.00929188f, -0.03087232f, 0.02655680f, -0.03996383f, -0.03760992f, -0.00618581f, 
    -0.02656457f, 0.02325768f, 0.01508121f, -0.02423966f, 0.02529284f, 0.00683336f, 0.01579007f, 0.00161460f, 
    -0.01049478f, -0.02933264f, -0.03989392f, -0.01261857f, 0.00420147f, -0.00067236f, 0.02035327f, -0.02658247f, 
    0.00999189f, 0.02835666f, -0.01142351f, -0.02498323f, 0.01906673f, 0.00452560f, -0.00949163f, 0.02206530f, 
    -0.01661727f, 0.00681253f, -0.02831270f, -0.03557668f, -0.01724048f, -0.00923468f, -0.00606575f, -0.03563971f, 
    -0.01298804f, -0.01291129f, -0.03641885f, 0.02895565f, -0.01643215f, -0.03703543f, -0.00749030f, 0.01091626f, 
    -0.03726926f, 0.00836802f, -0.02030285f, 0.02204766f, 0.01987851f, 0.01758619f, -0.01175298f, 0.01221613f, 
    -0.00872563f, 0.00278930f, -0.00222428f, -0.01454155f, -0.00322505f, 0.02507810f, -0.02508020f, 0.00467058f, 
    -0.03391553f, -0.01212592f, 0.01068849f, -0.00675226f, -0.01448927f, -0.02060178f, -0.03343349f, 0.01427223f, 
    0.01344248f, -0.03772754f, -0.01425436f, 0.00836544f, -0.03477199f, 0.01768607f, -0.01517666f, -0.03184635f, 
    0.01030773f, -0.02243933f, -0.00923510f, -0.03128500f, -0.00785360f, 0.01430916f, -0.01284667f, 0.02900673f, 
    -0.02213052f, -0.03466616f, -0.02526524f, -0.00725814f, -0.01104459f, -0.03803584f, 0.01237215f, -0.00410447f, 
    0.01219849f, 0.00081461f, -0.02572584f, -0.03271829f, -0.00252407f, -0.00472163f, -0.02239904f, 0.00216153f, 
    -0.02516210f, -0.01184882f, 0.02323513f, 0.01154895f, 0.02117640f, -0.02405430f, -0.03692682f, -0.00800729f, 
    0.30695364f, -0.01859130f, 0.06033524f, 0.00710935f, -0.01074930f, -0.00290823f, 0.02727176f, 0.09693277f, 
    0.09440435f, 0.11605699f, -0.07347007f, -0.06242182f, -0.34913951f, 0.04838329f, 0.01471831f, 0.19205832f, 
    0.11713041f, -0.08852125f, 0.02305258f, 0.06358090f, -0.01766747f, -0.02292381f, 0.06441015f, -0.12402004f, 
    0.21477593f, -0.10497851f, 0.10089323f, -0.16379343f, 0.13000759f, 0.12851103f, -0.08908558f, 0.05257252f, 
    0.13464867f, 0.05865129f, 0.12087438f, 0.00574120f, 0.00499032f, -0.16578105f, 0.04845672f, 0.09168378f, 
    -0.09917516f, -0.09636106f, -0.01969599f, 0.17712764f, 0.05133028f, -0.08701190f, -0.03343813f, 0.10485246f, 
    -0.15480821f, 0.07721303f, -0.13497925f, 0.07014746f, 0.17255731f, -0.02102847f, 0.00134510f, -0.00422845f, 
    0.08901761f, 0.03562536f, 0.03236588f, -0.06178897f, -0.16346145f, -0.05159448f, 0.01543653f, -0.15101793f, 
    -0.03923769f, 0.01224856f, -0.12622012f, 0.02659276f, 0.07478765f, 0.10187237f, 0.17377979f, 0.01695924f, 
    0.00945782f, 0.20331147f, -0.02887544f, 0.21763651f, 0.13036539f, -0.00350006f, 0.03629669f, -0.18410563f, 
    -0.03253650f, 0.12926628f, 0.12299679f, 0.05314234f, -0.05671750f, 0.03368392f, 0.11641561f, 0.06508404f, 
    0.14338705f, 0.14951862f, 0.18059459f, 0.00030821f, 0.16238001f, -0.05586758f, 0.00684304f, -0.06696256f, 
    -0.23978317f, -0.02012169f, 0.09428153f, 0.12826447f, 0.05405962f, -0.03551144f, 0.13033400f, -0.08645701f, 
    -0.06940992f, -0.00801414f, -0.04646301f, 0.08271328f, 0.03424223f, 0.08798350f, 0.08352920f, 0.11124522f, 
    -0.04217451f, 0.07238346f, -0.01488785f, -0.02988636f, -0.01285633f, -0.11754309f, -0.09670036f, 0.02523594f, 
    0.05518740f, -0.19565906f, 0.10036726f, 0.17629917f, -0.01781387f, -0.07063268f, -0.02529093f, -0.08210272f, 
    -0.05494922f, -0.07267643f, -0.04075468f, -0.02482132f, -0.26887786f, -0.13432363f, 0.08558419f, -0.21386947f, 
    -0.08974636f, 0.01731919f, 0.07167860f, 0.03244878f, -0.03575813f, -0.06993397f, -0.16093156f, -0.08038085f, 
    0.13506529f, 0.00894044f, -0.01266343f, 0.00483106f, 0.07121592f, 0.04819148f, -0.04350580f, 0.04684811f, 
    -0.02384263f, -0.01602371f, -0.01636073f, -0.08785807f, 0.01869885f, -0.01043277f, 0.04833408f, 0.00515028f, 
    0.16220002f, 0.00555399f, -0.12032610f, -0.14697774f, 0.00398292f, -0.04951159f, -0.01805787f, -0.09616419f, 
    -0.09510010f, 0.01565401f, 0.07497482f, 0.02070963f, -0.09215159f, -0.01320101f, -0.01545192f, 0.01280157f, 
    -0.02144440f, -0.10805596f, -0.10998001f, -0.09163057f, -0.08679561f, 0.17251620f, -0.00453775f, -0.01399386f, 
    -0.04566523f, 0.07934792f, 0.14803694f, 0.06976301f, -0.10625715f, 0.10857853f, -0.08527927f, 0.17626970f, 
    -0.18106081f, -0.00272999f, -0.02434549f, -0.16752316f, 0.00565845f, -0.07700966f, 0.12515403f, 0.10061038f, 
    0.03678339f, 0.09507604f, 0.10292100f, 0.11716793f, 0.17890364f, 0.01136159f, 0.13093463f, 0.03716836f, 
    0.01254130f, 0.05113523f, 0.06533144f, 0.12832850f, 0.00143773f, -0.04400152f, 0.02487734f, -0.05200973f, 
    -0.02044660f, -0.05768149f, 0.06889369f, -0.06102245f, 0.12820223f, 0.11000647f, 0.10993075f, -0.04254782f, 
    0.08192132f, 0.01215214f, 0.00323629f, 0.06634613f, -0.30541578f, -0.00686823f, 0.09718062f, 0.08089771f, 
    -0.09242875f, 0.00349668f, 0.08528499f, 0.01909195f, -0.03693578f, 0.05279832f, 0.11379470f, 0.12516752f, 
    0.14922704f, -0.22388630f, -0.02392519f, 0.02247465f, 0.08514702f, 0.11313972f, -0.08410251f, 0.00289285f, 
    0.00813336f, 0.06342138f, 0.05161385f, 0.05464989f, -0.03646764f, 0.17935485f, 0.08292750f, 0.04652347f, 
    0.02780638f, 0.04404311f, 0.01081988f, 0.01564241f, 0.05215694f, -0.04553930f, 0.04833336f, -0.09486716f, 
    0.05037929f, 0.06609265f, 0.01486781f, -0.08362791f, 0.10113132f, 0.03726704f, -0.07586287f, 0.03870029f, 
    0.06094949f, -0.05227134f, 0.09869728f, -0.12934251f, -0.17948139f, -0.01131472f, -0.02620888f, -0.03446182f, 
    0.13028283f, -0.01974690f, 0.12643611f, 0.00561486f, -0.02516071f, -0.07608517f, 0.09995616f, -0.00623439f, 
    -0.20565909f, -0.05574585f, -0.05083599f, -0.03609499f, -0.06470754f, 0.07629767f, -0.06192711f, 0.01736756f, 
    0.01019412f, -0.09344397f, 0.21163067f, 0.05726972f, -0.27014476f, 0.10421086f, 0.10221463f, -0.11726382f, 
    0.16947204f, 0.08901910f, 0.02835179f, 0.02578908f, 0.02963163f, -0.00820387f, 0.11210406f, -0.05073510f, 
    -0.06179112f, -0.16254985f, -0.04570845f, 0.19449109f, -0.14561641f, -0.02033165f, 0.06286990f, -0.01777396f, 
    -0.07801832f, 0.02096720f, 0.00515798f, 0.12852928f, 0.04237340f, -0.16601785f, -0.03936904f, -0.03193471f, 
    -0.05038161f, 0.01298971f, -0.02913545f, 0.01809826f, 0.06829264f, -0.02318625f, -0.01542690f, 0.03294368f, 
    -0.11854742f, 0.06044573f, -0.02728709f, 0.07268053f, 0.13979909f, 0.01174574f, -0.04846047f, -0.01927157f, 
    -0.20066594f, -0.12884405f, 0.07252917f, -0.05029035f, 0.24814852f, -0.27176869f, 0.13618608f, -0.05486226f, 
    0.03687268f, -0.08050845f, -0.01368609f, 0.09242036f, 0.01733362f, 0.06851412f, 0.01303681f, -0.00295977f, 
    0.21972016f, 0.02230782f, 0.13020794f, 0.04374222f, 0.04525439f, 0.03493788f, 0.12877643f, 0.04965926f, 
    -0.06174519f, 0.12097865f, 0.06436374f, -0.06731374f, 0.11209096f, -0.13697004f, 0.05614755f, -0.02752434f, 
    -0.06884230f, 0.11070159f, -0.01626614f, 0.03182046f, -0.07818245f, 0.08025404f, 0.05796852f, 0.16336100f, 
    -0.06878114f, -0.07653714f, 0.07059839f, 0.13015361f, -0.06146264f, 0.02578736f, 0.01296520f, -0.02712972f, 
    -0.01257961f, 0.08738109f, -0.07959027f, 0.05698589f, -0.02140432f, -0.04033185f, -0.13712700f, -0.07407234f, 
    0.01114519f, 0.01610008f, 0.09060048f, 0.03584827f, -0.07889532f, 0.04970090f, -0.13478586f, 0.05044337f, 
    -0.15294552f, 0.13028377f, -0.19813678f, -0.03315737f, 0.12722158f, -0.00229557f, 0.01411279f, -0.07178394f, 
    0.21837641f, 0.07125492f, -0.00417704f, 0.04300367f, -0.31121078f, -0.09569735f, 0.08521295f, -0.00664590f, 
    0.00524380f, -0.04790426f, -0.02509245f, 0.10015533f, 0.08111764f, 0.05452427f, 0.02647260f, 0.18007639f, 
    0.03296541f, -0.05620964f, -0.00870576f, 0.07312401f, 0.01359619f, -0.11591958f, -0.02806145f, -0.03493225f, 
    -0.03656096f, -0.09325713f, -0.00932922f, -0.14844465f, 0.13440044f, -0.04479874f, 0.00134683f, 0.02451232f, 
    -0.05527818f, 0.13002291f, -0.22798002f, -0.12775397f, 0.11902583f, 0.04429083f, -0.14597327f, -0.04992968f, 
    0.10983030f, 0.06217140f, -0.16693382f, 0.01232448f, -0.00641816f, -0.01493625f, -0.07210523f, -0.04738820f, 
    -0.00064642f, -0.10044164f, 0.05536246f, 0.08710399f, -0.02877535f, 0.06600002f, 0.11448675f, 0.07512362f, 
    -0.06109950f, 0.09783666f, 0.10315741f, -0.06525982f, 0.07595787f, 0.07566804f, 0.05856318f, 0.11015672f, 
    0.33067435f, 0.13752398f, -0.02824649f, 0.21080571f, -0.01573044f, -0.17893218f, 0.02899043f, -0.03143630f, 
    -0.00739760f, 0.09442379f, 0.07924827f, 0.04562590f, -0.40572000f, 0.07108618f, 0.10199452f, 0.06809483f, 
    0.08737891f, 0.15166599f, -0.00890445f, 0.03919357f, 0.01020372f, -0.09132192f, 0.07282410f, -0.12376402f, 
    0.19527912f, 0.11794017f, 0.04743006f, 0.08797540f, 0.08326294f, -0.03020597f, -0.00278703f, -0.04110399f, 
    0.11595697f, 0.04692329f, -0.00247225f, 0.10780855f, 0.11614718f, 0.09819663f, -0.08242775f, 0.05058616f, 
    0.10153880f, -0.08941847f, -0.03728757f, -0.03232114f, 0.11397129f, -0.00818496f, 0.07052775f, 0.15918477f, 
    0.01051572f, -0.12917222f, 0.01190870f, -0.08796112f, 0.05728451f, -0.08663010f, -0.06994800f, -0.09221569f, 
    0.02487220f, 0.07924187f, 0.02143962f, 0.07538538f, -0.24111927f, -0.08204886f, 0.01330265f, -0.12620050f, 
    -0.05296034f, -0.05163620f, -0.09773782f, -0.00478204f, -0.00320717f, 0.13128862f, 0.01876739f, 0.14944921f, 
    -0.03842219f, -0.10644931f, -0.04369694f, -0.08641570f, 0.01077147f, 0.00186667f, -0.08327891f, 0.00351806f, 
    0.00633022f, 0.01021761f, 0.09633327f, -0.02773366f, 0.52596694f, -0.01135692f, 0.16770539f, -0.04501970f, 
    -0.03728759f, -0.06073016f, -0.21133183f, -0.10006323f, -0.11362378f, 0.04258177f, -0.16902074f, -0.08232851f, 
    -0.38934946f, 0.06706762f, 0.04075134f, -0.01862872f, -0.00973433f, 0.04798421f, 0.13278306f, 0.07057610f, 
    0.08052652f, 0.08727021f, 0.08196530f, -0.07570992f, 0.32148325f, 0.05241487f, 0.12153360f, 0.06206223f, 
    -0.03516465f, 0.10430413f, 0.02901877f, -0.09554925f, 0.10795680f, 0.07114331f, 0.03944975f, 0.04664153f, 
    -0.28839979f, 0.20088011f, -0.01068470f, 0.00353021f, 0.09561361f, -0.05614444f, -0.04496821f, 0.05233360f, 
    -0.00450565f, 0.14340787f, 0.17014192f, 0.03106356f, -0.13014416f, 0.01193422f, 0.00950355f, -0.03620736f, 
    -0.10976975f, -0.02850599f, -0.05564953f, -0.00936704f, -0.09438074f, -0.07024723f, -0.04709049f, 0.08525934f, 
    0.13855685f, 0.10881598f, 0.09520063f, 0.15693772f, 0.13597502f, 0.01444654f, 0.07768202f, 0.02062961f, 
    0.04776954f, 0.00153164f, 0.11897871f, 0.17629746f, -0.04317733f, -0.17773834f, 0.04663131f, -0.04931045f, 
    0.02410045f, 0.01188810f, 0.02865350f, 0.06511884f, 0.01496621f, 0.00164435f, -0.00385015f, 0.03268507f, 
    0.07622442f, 0.15067531f, -0.02760471f, -0.06981046f, 0.08246903f, 0.11239897f, -0.04684572f, -0.00488900f, 
    0.04258417f, 0.09912524f, 0.03817894f, 0.09420910f, 0.20001726f, -0.12035804f, 0.02916612f, -0.12928800f, 
    -0.01777093f, -0.01882582f, 0.11096752f, -0.06905650f, -0.09020271f, 0.13994011f, 0.01987843f, 0.08200137f, 
    -0.01862195f, 0.02578830f, 0.03580626f, -0.06140758f, 0.14046556f, -0.01193189f, 0.09241153f, 0.05052802f, 
    0.06929173f, 0.11767208f, 0.00046531f, 0.00790429f, 0.09897833f, -0.14489284f, -0.07039943f, 0.11166582f, 
    -0.04954179f, -0.05751691f, 0.00108697f, -0.07541821f, -0.06570247f, -0.06194602f, -0.13363038f, 0.16073808f, 
    0.15461420f, 0.09218653f, 0.02239983f, 0.02372285f, 0.01801773f, -0.11574527f, -0.11606472f, 0.01568883f, 
    0.02646346f, -0.10082233f, -0.03026072f, -0.02734383f, 0.07092083f, -0.04268903f, 0.11570550f, 0.09241519f, 
    0.06402819f, -0.00431209f, 0.22242355f, 0.06438871f, -0.04224544f, 0.00088544f, 0.02860801f, 0.10937571f, 
    -0.13182607f, 0.08150809f, 0.04593980f, 0.23459467f, -0.12238704f, -0.04315151f, 0.01526568f, -0.04695560f, 
    0.06890021f, 0.01288136f, 0.08576753f, 0.04469807f, -0.20332490f, -0.02280216f, 0.10356969f, 0.05376839f, 
    0.04265819f, -0.10145771f, 0.07099043f, 0.03216109f, -0.02908574f, 0.12954710f, -0.11330995f, 0.04822194f, 
    0.08155645f, -0.03146455f, 0.04997971f, 0.13789445f, -0.03253343f, 0.00094546f, 0.07656247f, -0.01206201f, 
    -0.11959784f, 0.05901210f, 0.00223668f, 0.08144567f, -0.33439344f, 0.19642822f, 0.02454391f, 0.06648459f, 
    0.01545630f, 0.05776521f, 0.08532638f, -0.02153665f, 0.00271003f, 0.07092997f, -0.01302245f, 0.05027154f, 
    0.09454300f, -0.17982189f, -0.01780686f, -0.05835495f, 0.04254404f, 0.05870550f, -0.00966170f, -0.14728211f, 
    0.04515191f, -0.06997540f, -0.00715541f, 0.01833850f, 0.18559770f, 0.23564552f, -0.00480650f, -0.00087183f, 
    -0.11683466f, 0.07322767f, 0.09345295f, -0.02422350f, 0.00603423f, 0.18700504f, 0.01132157f, 0.03840967f, 
    0.12775172f, 0.25616574f, -0.08723859f, -0.24545968f, 0.06439182f, -0.00994009f, 0.08328535f, -0.01951022f, 
    0.05034176f, 0.07698289f, -0.05223021f, -0.04546176f, -0.22593088f, 0.09959746f, 0.13109332f, 0.08164525f, 
    0.13838698f, 0.03398069f, -0.08009569f, -0.12129021f, 0.00750953f, 0.09425137f, -0.03167397f, 0.01751656f, 
    0.20761923f, 0.05409012f, -0.13292667f, -0.07895299f, -0.02874389f, -0.01785146f, 0.10822270f, 0.08714221f, 
    0.06018869f, 0.13546959f, 0.02277635f, 0.00994907f, -0.15459569f, -0.00095790f, 0.11761250f, 0.19617224f, 
    -0.02537145f, 0.06670208f, 0.00917464f, 0.00583419f, 0.00648330f, 0.01444994f, 0.01079816f, 0.08259431f, 
    -0.02542162f, 0.09608329f, -0.21093130f, 0.15350294f, 0.00328003f, 0.08752728f, -0.07338461f, 0.14805162f, 
    0.06571127f, -0.06606141f, 0.00901428f, 0.13567778f, 0.15353486f, -0.06054515f, -0.04068153f, -0.07818879f, 
    -0.02975078f, 0.01635579f, -0.00721987f, 0.05782050f, -0.03790146f, 0.10364622f, -0.05844971f, -0.06676519f, 
    0.25143641f, -0.22036013f, 0.15113814f, 0.11592061f, -0.06775360f, -0.05757567f, -0.05777341f, 0.13687965f, 
    0.03064013f, 0.04536000f, 0.03708863f, -0.11031989f, 0.02411195f, -0.06549945f, 0.05398788f, 0.18508253f, 
    0.04337050f, -0.03551001f, -0.01712273f, 0.09147672f, -0.07676689f, 0.03079524f, 0.07751162f, -0.01410783f, 
    0.13970132f, 0.04741922f, 0.12066659f, -0.13234486f, -0.00933750f, 0.14916009f, -0.07317323f, 0.13147250f, 
    0.10893412f, 0.00277782f, -0.00468258f, 0.05784502f, -0.10987411f, 0.07544595f, 0.17434283f, 0.27863866f, 
    -0.02881863f, -0.00944691f, -0.01721398f, 0.10516550f, -0.02449727f, 0.00406754f, 0.01155339f, 0.06392851f, 
    -0.12206437f, 0.40857893f, 0.05055550f, -0.04026019f, 0.04907891f, 0.06742091f, -0.00395131f, 0.08084198f, 
    0.04172934f, 0.05765830f, -0.04783477f, 0.07275629f, 0.04535438f, 0.11676186f, -0.02597776f, -0.00994706f, 
    0.05137566f, -0.01474575f, -0.00510752f, 0.04594964f, 0.03450450f, -0.05309605f, -0.04435453f, 0.03749461f, 
    0.14349934f, -0.22328359f, -0.02416463f, 0.15858810f, -0.06463560f, 0.05040321f, -0.07758518f, 0.02116266f, 
    0.00686135f, 0.12445632f, -0.03340426f, 0.03081227f, -0.15032431f, 0.03733301f, 0.06806500f, 0.08335596f, 
    0.06245757f, -0.04024773f, -0.01471015f, 0.03784245f, 0.04203077f, -0.04652654f, 0.10520162f, -0.04759122f, 
    0.11564677f, -0.04801422f, 0.03789142f, -0.05023506f, 0.09334145f, -0.00970804f, 0.02193526f, -0.03487841f, 
    0.04261891f, 0.02904565f, -0.02428918f, 0.10065114f, 0.00199144f, -0.10929213f, 0.07599388f, -0.11693145f, 
    -0.05560127f, -0.11817304f, 0.08683717f, -0.04676654f, -0.04643846f, 0.02404797f, 0.05859510f, 0.04542762f, 
    0.23811819f, 0.12902479f, -0.05632701f, -0.18247172f, -0.09906641f, -0.00316909f, 0.01215344f, 0.03432455f, 
    0.03680308f, 0.05361161f, 0.07591674f, 0.02466617f, 0.09245395f, -0.06603108f, 0.15681897f, 0.21600440f, 
    -0.13381082f, -0.08606517f, 0.02021549f, 0.02515666f, -0.01842239f, 0.01968647f, -0.01333758f, -0.01479039f, 
    -0.21641560f, 0.26583010f, 0.06312545f, -0.10137226f, 0.15800768f, 0.07895318f, 0.02658217f, 0.04962236f, 
    0.03000692f, -0.07205639f, 0.00238431f, 0.11825760f, -0.14944996f, 0.05300830f, -0.09799520f, 0.08116578f, 
    -0.06035253f, -0.00232033f, 0.05180225f, 0.08199041f, -0.00961927f, 0.02425474f, 0.01393020f, 0.06154711f, 
    -0.03295192f, 0.17314802f, -0.09833838f, -0.03711746f, 0.04181869f, 0.02464717f, 0.09557045f, 0.01387850f, 
    0.06730366f, 0.06057071f, -0.01373393f, 0.03232378f, 0.18326361f, 0.22214100f, -0.06853778f, 0.06227635f, 
    0.14378360f, -0.00049841f, 0.04119055f, 0.12839572f, 0.07646276f, -0.02404257f, -0.06505870f, 0.02584006f, 
    -0.42529753f, 0.13155603f, 0.02789047f, 0.14108500f, -0.03535228f, 0.08444511f, 0.01298237f, 0.06135128f, 
    0.15112831f, -0.01961250f, -0.03493210f, 0.01984578f, 0.20799188f, -0.10201452f, 0.00532749f, -0.04025351f, 
    0.03771614f, 0.06465859f, 0.12171637f, 0.02200389f, -0.05838237f, 0.09128626f, -0.00999167f, 0.01815953f, 
    0.30175072f, -0.06747135f, 0.09173587f, 0.27144724f, -0.04983314f, -0.03460675f, 0.05446861f, 0.01669409f, 
    0.00123722f, 0.06012097f, 0.02009517f, -0.00321847f, -0.33439428f, 0.11385817f, 0.07269664f, -0.06965280f, 
    -0.03015354f, 0.09723200f, -0.10114668f, 0.03553073f, 0.03511730f, -0.05046733f, -0.00258222f, 0.05383340f, 
    0.05123131f, 0.11802073f, -0.07259364f, 0.03543596f, -0.01838246f, -0.02382197f, 0.00738922f, 0.06796415f, 
    -0.03880882f, 0.04452124f, -0.01635873f, 0.00199516f, 0.17103064f, -0.19763349f, 0.04090787f, -0.16271052f, 
    -0.05227415f, -0.06751049f, 0.03128161f, -0.02409767f, -0.06883207f, 0.04756211f, 0.04120790f, 0.08810920f, 
    -0.14230058f, 0.26278171f, 0.15541154f, -0.04583760f, -0.09934001f, 0.06210866f, -0.02908556f, 0.05194077f, 
    0.00557504f, -0.03775015f, -0.03832869f, 0.08583812f, 0.20271337f, -0.02922490f, 0.15931498f, 0.01337251f, 
    0.04814960f, 0.01620614f, -0.00024444f, 0.04555636f, 0.01824012f, -0.09182354f, -0.00209268f, -0.01199690f, 
    0.15840343f, -0.03295418f, 0.08021448f, 0.01668584f, 0.12476274f, 0.08821849f, 0.03565243f, 0.07234323f, 
    -0.01034124f, 0.03833731f, 0.06024469f, -0.02786099f, -0.06059070f, 0.23824844f, 0.03000846f, 0.05460137f, 
    -0.06158816f, 0.08834948f, -0.02003867f, 0.02718345f, -0.07255886f, 0.02786096f, 0.08684243f, 0.02497408f, 
    0.23039255f, 0.04218658f, -0.03625578f, -0.03265764f, 0.02843305f, -0.02277078f, -0.05814030f, 0.05788160f, 
    0.05174606f, 0.06887624f, -0.01458842f, 0.04455473f, 0.04226117f, 0.13194795f, -0.14091246f, -0.06140646f, 
    -0.12988523f, -0.08702111f, 0.05494397f, -0.02424406f, 0.06572115f, 0.00184435f, -0.11401742f, 0.03382147f, 
    -0.00984804f, 0.01895535f, -0.09794593f, 0.35550496f, -0.05394305f, 0.06525970f, 0.12646185f, 0.00981414f, 
    0.05723751f, -0.04282682f, -0.00467190f, -0.01039854f, 0.14169353f, -0.12678675f, 0.09948300f, -0.02239752f, 
    0.06995193f, 0.07221501f, 0.08650751f, 0.02276798f, -0.00623587f, 0.06981689f, 0.01856099f, -0.02028523f, 
    0.37853989f, -0.25047705f, -0.03743498f, 0.23777729f, -0.04333443f, 0.02076044f, -0.00695086f, -0.04816399f, 
    -0.04881964f, 0.03142037f, 0.04921810f, 0.03405449f, 0.21322629f, 0.11301844f, 0.03891398f, -0.12247942f, 
    0.02184549f, -0.12019955f, 0.03899721f, 0.06035708f, 0.01421554f, 0.08171285f, 0.08551005f, -0.06536804f, 
    -0.18289775f, -0.09885643f, 0.01105519f, 0.17966592f, -0.01474892f, 0.00726763f, 0.09731766f, -0.01802019f, 
    0.04432520f, 0.03899016f, -0.07657451f, 0.08325703f, -0.07082348f, 0.07454006f, -0.00030308f, -0.03236977f, 
    0.00918291f, -0.06761117f, 0.08952672f, 0.03951834f, -0.01178588f, 0.04040636f, 0.01389874f, 0.02790746f, 
    -0.09421977f, -0.14944287f, 0.00710505f, 0.05573155f, -0.06074648f, -0.03804681f, 0.00404373f, 0.06850415f, 
    0.05085740f, 0.11711384f, 0.17084977f, -0.01215999f, 0.02095649f, 0.00201818f, 0.05508633f, -0.02557983f, 
    0.01962134f, 0.11435814f, 0.03638581f, -0.05149961f, 0.11254112f, 0.05125212f, -0.02847021f, 0.04418477f, 
    -0.34477958f, 0.18837567f, 0.05300526f, 0.16570856f, 0.02193698f, 0.06435958f, 0.06295413f, -0.05426954f, 
    -0.02778640f, -0.05139118f, -0.12189876f, -0.05054067f, 0.18817197f, -0.18562315f, 0.22514334f, 0.25687608f, 
    0.01207270f, 0.03809540f, 0.04128310f, 0.01717220f, 0.10332714f, 0.02971442f, -0.02395781f, -0.01584538f, 
    -0.15551943f, 0.08291577f, 0.01902314f, 0.11625102f, -0.00501515f, 0.08030600f, -0.01054992f, 0.02303210f, 
    -0.04223088f, 0.00000884f, -0.02085555f, 0.07835360f, -0.05671391f, -0.17649034f, 0.10594825f, -0.20393094f, 
    -0.09387807f, 0.01001713f, 0.10475718f, 0.08552791f, -0.04614699f, -0.05634177f, 0.02066346f, -0.00331755f, 
    0.34914169f, 0.06959107f, -0.15234728f, -0.23155110f, -0.04891693f, 0.02199768f, 0.09146950f, -0.03270835f, 
    0.04745932f, 0.03006917f, 0.10805463f, -0.02258061f, 0.03793911f, -0.12563592f, -0.06562655f, -0.00765180f, 
    0.06138575f, -0.05769005f, -0.07813225f, 0.03966461f, 0.03118967f, 0.08048447f, 0.10853332f, -0.06523554f, 
    0.24901704f, -0.27019295f, 0.00844184f, 0.16376081f, -0.04594412f, 0.08104941f, 0.05721294f, -0.05377095f, 
    -0.00076523f, 0.00162930f, -0.00573963f, -0.02597995f, 0.15450455f, -0.33470705f, -0.10953091f, -0.03928886f, 
    -0.09095607f, -0.03094316f, -0.08022066f, 0.02962657f, -0.07025407f, 0.04584516f, -0.11069731f, 0.03307753f, 
    0.16587451f, 0.06531832f, -0.08718520f, -0.10057317f, 0.04763832f, 0.03741819f, 0.05870228f, 0.15400735f, 
    0.03822163f, 0.09497618f, -0.02659409f, -0.00240363f, 0.21138570f, 0.07688220f, -0.18927018f, 0.02980291f, 
    0.06126823f, -0.03742266f, 0.05128294f, 0.00759988f, -0.04081262f, -0.08517826f, 0.01853166f, 0.06836583f, 
    0.07327431f, -0.06683935f, -0.00953064f, -0.04725524f, 0.02597027f, -0.02233421f, 0.05814761f, 0.15409307f, 
    -0.00417342f, 0.07446396f, -0.04344662f, 0.02813579f, -0.25446045f, 0.28643185f, 0.04774449f, 0.11285836f, 
    0.04361163f, 0.03753748f, -0.05185596f, 0.02026043f, 0.12028785f, 0.04957436f, -0.02288001f, 0.02415845f, 
    0.04417470f, 0.23428002f, 0.10378344f, -0.09603820f, 0.07229303f, 0.09758902f, -0.01469030f, 0.03855479f, 
    0.11711328f, 0.01223997f, 0.06955111f, -0.02675845f, 0.06151835f, -0.16000979f, 0.09390090f, -0.02030817f, 
    0.07127134f, 0.06584613f, 0.05212383f, 0.06618579f, -0.08036354f, 0.11928008f, 0.08733294f, -0.08295468f, 
    -0.00916536f, -0.22969957f, 0.11226419f, -0.18396999f, -0.04750440f, 0.03586441f, -0.03213959f, 0.05987492f, 
    -0.05125030f, -0.08572992f, 0.03618704f, 0.09266103f, 0.01123464f, 0.19932537f, -0.01157018f, 0.04323115f, 
    0.01925455f, -0.06818534f, -0.17533661f, 0.17767580f, 0.07860451f, 0.00461870f, -0.07022276f, -0.06743641f, 
    0.15366116f, -0.20233305f, -0.00009846f, 0.03926804f, -0.06974330f, 0.04120715f, -0.00596811f, 0.01736190f, 
    -0.02743660f, -0.02579646f, 0.02256077f, 0.02737955f, -0.22781970f, 0.27344596f, 0.09898260f, 0.02070231f, 
    0.05978422f, 0.10985776f, 0.03808929f, 0.01724552f, 0.06097534f, 0.01852110f, 0.01910962f, 0.02972051f, 
    0.15493004f, -0.04911702f, -0.09942946f, 0.05586560f, -0.05167598f, 0.00291885f, -0.01325184f, -0.01829673f, 
    0.00097264f, -0.06288479f, 0.03780961f, 0.07915141f, 0.03925005f, -0.13839714f, 0.01020771f, 0.10136439f, 
    -0.09414993f, -0.12988254f, -0.02323075f, 0.03708239f, 0.01110933f, 0.02250648f, 0.03003679f, 0.03460147f, 
    0.00723269f, -0.02578382f, -0.01054159f, -0.00737769f, -0.02245753f, 0.02616322f, -0.03784586f, 0.03850534f, 
    0.00252224f, -0.00395175f, 0.01500786f, -0.02473003f, -0.02502227f, 0.02393382f, 0.00273375f, -0.01052074f, 
    -0.02192859f, 0.02096686f, -0.00982726f, 0.00400757f, 0.01171842f, -0.00769493f, 0.00653963f, 0.02354799f, 
    -0.03247249f, -0.02239977f, 0.02054748f, -0.02169396f, 0.01148636f, 0.00506504f, -0.00595911f, 0.00458615f, 
    -0.02544616f, -0.01663180f, 0.02750398f, -0.00998090f, -0.04363953f, -0.01793533f, -0.01643531f, -0.03573637f, 
    -0.01946650f, 0.01022425f, 0.02279921f, 0.01479344f, -0.00414939f, 0.01932648f, -0.03689351f, 0.00269364f, 
    -0.01408698f, 0.02260575f, 0.00845271f, 0.00420918f, -0.01964536f, 0.00632976f, -0.02430667f, 0.00763563f, 
    -0.00049032f, -0.00107350f, -0.00966721f, -0.02315825f, 0.02159420f, 0.02108327f, 0.00401229f, 0.00797003f, 
    0.02082605f, -0.00929204f, 0.00228688f, -0.02444546f, -0.01110356f, 0.02840667f, -0.02756600f, -0.03403037f, 
    -0.00767378f, 0.02388825f, -0.00708037f, -0.00916846f, -0.01812432f, 0.02788399f, -0.01690241f, -0.01385061f, 
    0.01376033f, -0.04176242f, 0.02529779f, -0.03771998f, -0.02559447f, 0.03454352f, -0.01334451f, 0.02473097f, 
    -0.01465624f, -0.00204048f, 0.02567946f, -0.03528245f, -0.02244508f, 0.00497667f, 0.02831833f, -0.04173556f, 
    0.00376991f, -0.00872927f, 0.01207038f, 0.01230238f, 0.02755652f, 0.01074085f, -0.03565817f, -0.02471011f, 
    -0.03613693f, 0.02656397f, -0.02396381f, -0.02032434f, -0.00055808f, -0.03553336f, 0.00150976f, 0.02189279f, 
    0.03594314f, -0.00602282f, -0.02583450f, 0.01947152f, 0.02008065f, 0.02645816f, 0.02647427f, -0.01708784f, 
    0.00311736f, -0.03001301f, 0.02188425f, -0.00994425f, -0.00890710f, -0.00783377f, -0.01413576f, 0.00581076f, 
    -0.03940535f, -0.00587968f, 0.01361406f, -0.00177934f, 0.01182717f, -0.03780179f, -0.02171656f, 0.01515340f, 
    -0.03915708f, 0.02110848f, -0.03668109f, -0.00077637f, -0.04132614f, -0.01415978f, 0.01829434f, -0.01216743f, 
    -0.00410680f, -0.00653000f, -0.01530067f, 0.02260577f, 0.01398338f, -0.03143813f, -0.04104095f, 0.01160834f, 
    0.02478325f, 0.01375774f, 0.01831756f, 0.00303241f, -0.02082248f, -0.02858620f, -0.01971457f, 0.01186586f, 
    -0.03502044f, 0.00246333f, 0.00759882f, 0.00800163f, -0.00184979f, 0.01613127f, -0.03069877f, -0.01555366f, 
    -0.01063417f, 0.00199420f, 0.02641434f, 0.01361874f, 0.01230628f, -0.00008116f, 0.00755290f, 0.01739542f, 
    -0.01176510f, 0.02423205f, -0.03048926f, -0.04127314f, -0.02967213f, 0.01890220f, -0.00108405f, 0.01730498f, 
    -0.01592396f, 0.02629885f, 0.03887813f, -0.03196380f, -0.03887778f, -0.01800404f, -0.03868532f, 0.01078408f, 
    -0.02350006f, 0.00679589f, 0.00215875f, -0.00907350f, -0.03052923f, 0.03254944f, -0.01306625f, -0.00257535f, 
    0.02177398f, 0.01087885f, -0.03628133f, 0.01693006f, -0.03693775f, 0.02210527f, 0.01178610f, -0.02061024f, 
    -0.03831478f, -0.00182663f, -0.03928247f, -0.01385858f, -0.01023807f, -0.00264268f, -0.03236764f, 0.00524999f, 
    -0.03725988f, 0.00673440f, -0.02358274f, 0.01663473f, -0.02332738f, 0.01471050f, -0.02225705f, -0.04279072f, 
    0.00111964f, 0.01799876f, 0.01369664f, 0.01203502f, -0.02127309f, -0.00795079f, -0.02440554f, -0.01125898f, 
    0.00681657f, -0.02148870f, -0.03613984f, 0.01648762f, -0.01454966f, 0.00912128f, 0.01664092f, -0.03882098f, 
    -0.02000003f, -0.00386468f, 0.00907372f, -0.01722301f, 0.01798674f, 0.01546650f, -0.02461947f, -0.01449121f, 
    -0.01372427f, 0.00868864f, 0.02677802f, 0.01476431f, -0.02760042f, -0.03555081f, -0.04145866f, -0.01236669f, 
    -0.01350643f, 0.01450960f, -0.03962782f, 0.01898984f, -0.04078752f, 0.03333330f, 0.02080125f, -0.03938376f, 
    0.01326898f, -0.03684856f, 0.00991906f, -0.01798843f, -0.03532261f, 0.01847378f, 0.01767397f, -0.00121263f, 
    0.02335439f, -0.00647057f, -0.02969349f, -0.02573330f, 0.00309176f, -0.00544679f, -0.03024662f, -0.03905622f, 
    -0.00220436f, -0.03294095f, 0.01276663f, 0.02356963f, -0.02844329f, -0.03222008f, -0.02153572f, 0.02084860f, 
    -0.02983527f, 0.00139647f, -0.00134021f, 0.00985652f, 0.02476576f, -0.03424508f, 0.00613607f, -0.00270056f, 
    -0.01081373f, 0.00760918f, 0.00256339f, -0.01982169f, 0.00359189f, -0.03209060f, -0.01585087f, -0.02411562f, 
    -0.01232339f, 0.02389194f, -0.04327904f, 0.02842850f, -0.02363293f, -0.04096267f, 0.03259104f, 0.02534187f, 
    -0.03666872f, 0.00304129f, -0.00707068f, 0.00410525f, 0.00205683f, -0.01914951f, 0.00209633f, -0.00219952f, 
    0.01268237f, 0.00018552f, -0.04458924f, -0.00015705f, 0.03254530f, -0.02585171f, 0.02057076f, 0.00900009f, 
    0.01044485f, -0.00599739f, 0.00181120f, 0.02542610f, 0.01945252f, -0.00991753f, -0.00699657f, -0.00641876f, 
    -0.01097652f, -0.01222780f, 0.01988930f, -0.01055923f, -0.00314616f, -0.01715283f, 0.01318510f, -0.03263013f, 
    0.00980191f, -0.00228722f, 0.01395384f, 0.02729879f, 0.03350150f, -0.01856672f, 0.00690068f, 0.02004514f, 
    -0.04255375f, 0.03208101f, -0.00678635f, 0.01097309f, 0.00263791f, -0.03350025f, -0.01972588f, 0.01998855f, 
    -0.02876026f, -0.04210000f, -0.02169915f, -0.03981888f, -0.02554373f, -0.01295372f, -0.03225166f, 0.00568102f, 
    -0.03017890f, -0.02034073f, 0.01817225f, -0.01796976f, -0.00739210f, -0.03420424f, 0.00028038f, 0.00396618f, 
    -0.04239719f, 0.02471000f, 0.00667866f, -0.03742521f, 0.00451324f, -0.00050815f, 0.01839169f, 0.01575409f, 
    -0.00382820f, 0.01553460f, -0.00247257f, -0.02991419f, -0.01619697f, 0.00390581f, -0.02692721f, -0.02072546f, 
    -0.02848169f, -0.04052412f, 0.01422471f, -0.03232351f, -0.02963757f, -0.01657473f, 0.00809722f, -0.02843634f, 
    0.01334957f, 0.02849732f, 0.00561004f, -0.03356441f, -0.00238866f, 0.01946506f, 0.01165242f, -0.00372381f, 
    0.03805803f, -0.02636575f, 0.03298969f, -0.00286959f, -0.04215438f, 0.02771797f, -0.02053837f, 0.01394864f, 
    -0.00550955f, -0.02167444f, -0.02401451f, 0.02243821f, 0.00290785f, 0.03170673f, 0.02435943f, -0.00313078f, 
    -0.00353984f, 0.00739736f, 0.00752851f, -0.00670862f, -0.00586902f, 0.02799641f, 0.01030264f, -0.01690839f, 
    -0.01234883f, -0.00148043f, -0.00891034f, -0.03102697f, 0.02484243f, 0.00349794f, 0.00022899f, -0.03564183f, 
    -0.03230361f, -0.02977154f, 0.00911562f, -0.00573636f, -0.01444631f, 0.00272420f, -0.02520740f, 0.00557397f, 
    0.02143682f, 0.00970153f, 0.02314483f, 0.01235359f, 0.02741969f, -0.03604084f, 0.01377560f, 0.02663991f, 
    0.00326986f, -0.02704547f, -0.03311574f, -0.00068118f, -0.02682698f, -0.02191193f, -0.02426331f, -0.02299925f, 
    0.00924296f, 0.00812543f, -0.02598317f, 0.01051958f, 0.02284056f, -0.02265849f, -0.01129374f, -0.02388252f, 
    0.01071193f, 0.00071423f, -0.03748929f, -0.00252919f, 0.00527625f, -0.02037356f, -0.02353522f, 0.02380147f, 
    -0.00919251f, -0.00190308f, -0.03903440f, -0.02788441f, -0.02450507f, 0.01875967f, 0.02131385f, -0.01785052f, 
    -0.02825329f, -0.01334251f, 0.01649523f, 0.01624762f, -0.03108042f, 0.01148994f, 0.01530760f, -0.02186255f, 
    0.02182159f, -0.02458517f, -0.02762567f, -0.02760438f, 0.01220453f, -0.04453680f, 0.00489413f, -0.01493587f, 
    0.02571600f, 0.00916777f, 0.01825191f, 0.03036231f, -0.01596493f, -0.02473117f, 0.00325086f, 0.01154535f, 
    -0.03076128f, 0.02977481f, -0.00217380f, 0.02341340f, 0.01998025f, 0.01848789f, -0.03100111f, -0.01385854f, 
    -0.03522518f, -0.03209528f, -0.01806739f, -0.02519763f, 0.01447718f, -0.03646095f, 0.02090258f, 0.02853379f, 
    -0.01278839f, 0.00996587f, -0.01996321f, 0.01912405f, 0.01690950f, -0.04361186f, -0.03096425f, 0.01261074f, 
    -0.01872621f, -0.00149754f, 0.02777421f, -0.00232286f, 0.00925093f, -0.02374820f, -0.03428344f, 0.02439442f, 
    -0.02753108f, -0.03242059f, -0.02020729f, 0.00774215f, 0.01609651f, -0.03075076f, -0.00845697f, -0.02039333f, 
    -0.00813902f, -0.01813900f, 0.02541958f, -0.02841615f, -0.02699541f, 0.01087453f, -0.01368202f, 0.01168052f, 
    0.02463020f, -0.02112508f, 0.02093583f, -0.01508862f, -0.00618320f, 0.00522549f, 0.00421102f, 0.02289635f, 
    0.00007343f, 0.00004298f, -0.02301929f, -0.00043295f, 0.01958436f, -0.00830896f, 0.01372635f, -0.01575974f, 
    0.00980756f, 0.00317659f, -0.01422295f, -0.00054763f, -0.00084398f, -0.03633722f, -0.00061126f, -0.04231132f, 
    0.01925751f, -0.01941436f, 0.00727298f, 0.01358941f, -0.00932102f, 0.02827450f, -0.01550393f, -0.00431612f, 
    -0.00575422f, -0.02377150f, -0.02069760f, 0.01800957f, 0.01147651f, -0.02177376f, -0.00581435f, -0.00731096f, 
    -0.04238379f, 0.01759704f, 0.02616411f, -0.00438176f, 0.01098036f, 0.01503120f, 0.02379954f, -0.01358836f, 
    0.01599555f, -0.03569940f, -0.03876057f, -0.00726482f, -0.01146689f, -0.03342278f, -0.01210197f, 0.00348531f, 
    0.03013125f, -0.01463052f, -0.02581476f, -0.03480672f, -0.01580898f, 0.00912908f, -0.01095557f, -0.01935677f, 
    0.00174562f, -0.00112973f, 0.01971543f, 0.00545916f, 0.02984556f, -0.00295593f, -0.01689786f, -0.03376314f, 
    -0.03425468f, -0.02029944f, -0.01502475f, 0.00536271f, 0.00778641f, 0.01778085f, 0.00343816f, -0.01391054f, 
    -0.00648989f, -0.00395539f, 0.00857096f, -0.00480709f, -0.01294663f, -0.03729150f, 0.02223682f, -0.02380979f, 
    -0.02518900f, -0.00326171f, 0.00784174f, -0.01175341f, -0.01971134f, -0.02890514f, -0.00593476f, 0.00300693f, 
    -0.02123859f, -0.03748670f, -0.01321186f, 0.01352956f, 0.00878354f, 0.01057423f, 0.02203448f, -0.00730590f, 
    -0.03052638f, -0.03367866f, -0.00769590f, -0.01437028f, -0.00483568f, -0.00093090f, 0.00126307f, -0.01673649f, 
    -0.01783715f, -0.01714250f, -0.01823016f, 0.01108241f, 0.02309294f, 0.01985782f, -0.00288223f, -0.03196565f, 
    -0.03493823f, -0.03761335f, -0.03762722f, -0.02359409f, -0.03005808f, -0.01313443f, 0.02246877f, -0.01118157f, 
    -0.00073468f, -0.00575260f, 0.01806341f, 0.02405324f, -0.03072269f, -0.00106485f, 0.00100038f, -0.00619955f, 
    0.02882024f, -0.03861641f, 0.01060903f, -0.02039365f, -0.01752319f, -0.03509687f, 0.01791454f, 0.01741046f, 
    -0.02499661f, 0.00575669f, 0.02710617f, -0.01178185f, -0.02524716f, 0.00261000f, -0.01133431f, -0.01146877f, 
    -0.03913575f, 0.00617816f, 0.00977652f, -0.02558883f, -0.01721026f, -0.00025586f, -0.01712427f, 0.02365046f, 
    0.02822611f, -0.03788394f, 0.02478601f, -0.03828435f, 0.01413149f, 0.00739723f, -0.00096011f, 0.00268894f, 
    0.00849721f, 0.00154578f, -0.03700692f, 0.01504590f, 0.01264695f, 0.01435125f, 0.00175932f, -0.01414730f, 
    0.01287921f, 0.00150532f, -0.01168756f, -0.01008301f, 0.02614936f, 0.00072961f, -0.00553989f, 0.01483193f, 
    -0.03202780f, -0.02295030f, -0.03272266f, -0.01040070f, 0.02349391f, -0.00460259f, -0.00578845f, 0.02526257f, 
    -0.02913050f, -0.00292356f, 0.00882611f, -0.02226763f, -0.02997833f, -0.02199204f, 0.01545044f, 0.02920303f, 
    0.01951314f, -0.00531772f, -0.03551364f, 0.01391549f, -0.02557187f, -0.01217587f, 0.00175476f, -0.01501122f, 
    0.25717634f, -0.06949492f, 0.06011425f, 0.06395795f, 0.01966922f, -0.01213155f, 0.09598105f, -0.07178816f, 
    0.04021033f, -0.01559023f, 0.02880331f, -0.04381410f, -0.15466893f, 0.02648054f, -0.12587999f, -0.26601204f, 
    -0.04413052f, 0.00864732f, 0.10894839f, 0.02866928f, 0.02183689f, 0.12393701f, 0.00656118f, -0.06672590f, 
    0.20443894f, 0.06109598f, -0.07675301f, 0.00016973f, 0.01696093f, 0.03292582f, 0.06053080f, 0.11208801f, 
    0.10886208f, -0.00022408f, 0.07516918f, -0.01911883f, -0.15065709f, 0.07808553f, -0.07729650f, -0.01376180f, 
    -0.06614161f, 0.10742307f, -0.01820467f, -0.06709003f, 0.05555749f, -0.05350931f, -0.01445905f, 0.10515041f, 
    0.13777661f, 0.06698529f, -0.03812126f, 0.14188449f, 0.00530505f, -0.20149525f, 0.09119010f, 0.21040818f, 
    0.02614164f, 0.10079481f, -0.01704591f, -0.09566965f, 0.06477725f, -0.00645172f, 0.02872210f, 0.21671803f, 
    -0.02871243f, 0.11875961f, -0.07212681f, 0.01663027f, 0.07714733f, 0.06009676f, 0.11663803f, 0.06367981f, 
    0.00004186f, -0.01684107f, -0.19561134f, 0.16798650f, 0.02221773f, 0.10603692f, -0.04718645f, 0.12132827f, 
    0.01230811f, -0.01267488f, 0.03724965f, 0.20610738f, 0.04152687f, -0.15615453f, 0.08640217f, 0.10663602f, 
    -0.01628569f, 0.01666103f, 0.10788447f, 0.02105959f, 0.19098212f, 0.05218394f, 0.02125857f, 0.04595967f, 
    0.02308889f, -0.02491516f, 0.31577206f, 0.13098444f, 0.09214874f, -0.05415172f, 0.01540867f, 0.00796189f, 
    0.04298669f, 0.17998029f, -0.02533819f, -0.10299659f, -0.09857984f, 0.04062509f, 0.23256710f, 0.11157252f, 
    0.03411439f, 0.06934287f, -0.07095997f, 0.10182198f, -0.00672694f, 0.02664224f, -0.04175033f, 0.00570410f, 
    0.06352242f, -0.05092850f, 0.09413526f, -0.06817950f, 0.20836124f, 0.10612807f, -0.10638697f, 0.06234818f, 
    0.06827869f, -0.00693516f, -0.02710287f, -0.02379121f, -0.02092137f, 0.03840217f, 0.13930535f, 0.14653301f, 
    -0.01874997f, 0.03216328f, 0.06025181f, 0.09513571f, 0.03141730f, 0.04831414f, -0.11803322f, 0.04570258f, 
    0.23281512f, 0.33668995f, -0.07990175f, -0.01622482f, 0.06992850f, 0.13547410f, 0.01518834f, 0.07316191f, 
    0.06630094f, 0.05530062f, -0.02456594f, 0.04681969f, 0.06108526f, 0.04852707f, -0.01743463f, 0.01042838f, 
    0.07271542f, 0.05672086f, -0.01009204f, 0.11993742f, 0.04775127f, -0.09982008f, -0.02988599f, -0.08685160f, 
    0.28090641f, -0.31979856f, 0.03963625f, 0.16470301f, -0.03292747f, 0.05970668f, 0.01435864f, 0.08918581f, 
    0.02196421f, 0.08809187f, 0.00063951f, -0.00959843f, -0.07753525f, 0.12189548f, 0.00217721f, -0.01493698f, 
    -0.00477542f, 0.08905371f, 0.07487998f, 0.07243978f, 0.06989399f, 0.01353842f, 0.03416612f, 0.04675188f, 
    0.05907246f, -0.07700104f, 0.08030444f, -0.00269908f, 0.04268821f, -0.03839889f, 0.11255256f, 0.05633897f, 
    0.04546859f, 0.06643260f, 0.01996610f, 0.11860783f, -0.25865629f, -0.23993045f, 0.04411522f, -0.12966019f, 
    -0.00468099f, -0.01024711f, 0.04994101f, 0.11269191f, -0.02585007f, 0.00247918f, 0.09120743f, 0.05834027f, 
    0.14459974f, -0.01935910f, 0.00527854f, 0.04834779f, -0.04152992f, 0.01816838f, -0.00989313f, 0.09761893f, 
    0.00937247f, -0.00589908f, 0.02794911f, 0.02273857f, -0.21833040f, 0.10800041f, 0.32258379f, 0.29149041f, 
    -0.01818471f, 0.01770497f, 0.02436116f, 0.01560166f, 0.04364249f, 0.03786897f, 0.04356414f, 0.02034350f, 
    -0.10548518f, 0.13287969f, -0.12080067f, -0.13128343f, 0.23451827f, 0.10638711f, -0.06021924f, 0.01404414f, 
    -0.00357999f, -0.01043199f, -0.05256581f, 0.18105327f, 0.12584844f, 0.16715991f, -0.10041614f, 0.16476865f, 
    -0.09756112f, 0.04967981f, 0.02420800f, 0.12542541f, 0.00071799f, 0.00922901f, 0.10733057f, -0.04964607f, 
    0.09868694f, 0.07157595f, -0.09298205f, 0.22084972f, 0.04920025f, 0.01695987f, -0.02619311f, 0.03405846f, 
    0.11201429f, 0.01834003f, 0.02552039f, -0.03399207f, 0.20266333f, 0.06899107f, -0.19513160f, 0.12302105f, 
    0.09460947f, 0.02705196f, -0.00912746f, 0.14071220f, 0.00818428f, -0.08688667f, -0.00262815f, 0.11318877f, 
    -0.52058268f, 0.14261375f, -0.03486139f, -0.10571534f, -0.14133701f, 0.17936529f, -0.04803498f, 0.01062729f, 
    0.05896322f, -0.04762292f, 0.13737684f, -0.04507593f, -0.22219299f, -0.07144751f, 0.06925172f, -0.09980810f, 
    0.09387115f, 0.07144669f, 0.11534574f, 0.01185791f, 0.00942020f, 0.06302620f, 0.07523641f, 0.02401527f, 
    0.07574255f, -0.02274216f, 0.16186580f, 0.48571935f, -0.03171444f, 0.04695883f, 0.03536306f, 0.10221680f, 
    0.04229703f, 0.17293312f, -0.03760467f, 0.08174796f, -0.24553768f, 0.06833373f, 0.00409646f, -0.09722412f, 
    -0.00736265f, 0.15458822f, -0.03647863f, -0.00146715f, 0.04947032f, -0.04068847f, 0.09680377f, -0.00188566f, 
    0.06490866f, 0.03004216f, -0.18568560f, 0.10107858f, -0.00334812f, -0.00616541f, -0.05107296f, 0.08515907f, 
    -0.07873215f, -0.00017170f, -0.06247301f, 0.01902960f, 0.04407196f, -0.22813950f, 0.10899001f, -0.19867274f, 
    -0.09201520f, -0.07064907f, 0.12657438f, 0.01057929f, -0.00968450f, 0.03761675f, 0.10469562f, 0.06988414f, 
    0.00866456f, 0.25213927f, 0.06145122f, -0.18571210f, -0.01785666f, 0.07714000f, -0.03578146f, 0.04119537f, 
    -0.01535236f, 0.10345595f, 0.10218178f, 0.02422394f, -0.01272714f, -0.11277703f, 0.07521133f, -0.09143281f, 
    0.00981260f, 0.10187618f, 0.04850787f, 0.09021422f, 0.01152758f, 0.02457747f, 0.10322244f, 0.05389435f, 
    0.03811257f, -0.08948743f, 0.17192402f, -0.08557989f, 0.08585382f, 0.09734698f, 0.18323390f, -0.00648121f, 
    0.05845744f, 0.11826517f, 0.01101358f, 0.07721950f, 0.11712076f, 0.08111307f, -0.13605377f, 0.00001023f, 
    -0.07398661f, -0.01418926f, 0.00547467f, 0.02494060f, -0.06157359f, 0.03056168f, -0.08249848f, 0.02753364f, 
    0.09526398f, -0.11582036f, -0.04580058f, 0.02000624f, 0.05086569f, -0.04533485f, -0.00818669f, 0.02368866f, 
    0.12660274f, 0.01468178f, -0.01613315f, 0.02845683f, -0.17423920f, 0.03914859f, -0.04541933f, -0.08880391f, 
    -0.02809730f, -0.07641917f, 0.06118520f, 0.02163576f, 0.15514988f, -0.01015061f, -0.08617912f, 0.13615073f, 
    -0.06770397f, -0.01012837f, -0.14927024f, 0.22492929f, 0.00435903f, 0.02979191f, -0.02517719f, -0.01850906f, 
    0.01282269f, -0.03415767f, 0.00420796f, -0.07544611f, 0.00179647f, -0.21274230f, 0.05268218f, 0.13828853f, 
    0.08906206f, 0.00367680f, -0.07872390f, 0.10134780f, 0.09452870f, -0.06912433f, -0.10917207f, 0.09274095f, 
    0.29329908f, -0.29086965f, -0.12982081f, 0.27634582f, 0.00359127f, -0.05564956f, -0.06603830f, 0.07435719f, 
    0.02213617f, -0.01919694f, 0.08359959f, 0.09282516f, 0.13496713f, 0.07638949f, -0.04008359f, -0.15749104f, 
    0.05321323f, -0.05608171f, 0.14051442f, 0.02518737f, 0.12755692f, 0.07662220f, 0.05318024f, 0.05417432f, 
    -0.32853091f, 0.03161265f, -0.07802821f, 0.13522473f, -0.02869128f, -0.05575769f, 0.03862447f, 0.00518016f, 
    0.06261664f, 0.10875753f, -0.08340451f, 0.05143588f, -0.23683175f, 0.21521084f, -0.04910789f, -0.03926503f, 
    -0.01701280f, 0.10332359f, 0.01339895f, 0.01036077f, -0.00121699f, -0.05550297f, 0.04652397f, -0.02923013f, 
    -0.02444570f, -0.04853322f, 0.00191293f, 0.08653104f, -0.01244471f, -0.03224504f, -0.01618280f, 0.00907752f, 
    0.07926575f, 0.12376945f, 0.10267583f, -0.00803756f, 0.09247147f, 0.06181667f, 0.10651748f, 0.05089859f, 
    -0.05594173f, 0.07354327f, 0.02843353f, 0.03246565f, 0.12019468f, 0.01300178f, 0.05879255f, 0.04865102f, 
    -0.20609796f, 0.20643143f, -0.03476373f, 0.08781203f, 0.06764293f, 0.07377927f, -0.01956899f, -0.04356388f, 
    -0.07333856f, 0.07062225f, -0.03191908f, -0.00276597f, 0.14100295f, -0.08098718f, 0.21801308f, 0.08521982f, 
    0.05627557f, 0.01834032f, 0.02990452f, 0.01726085f, 0.09620743f, 0.06649014f, -0.00529853f, 0.03052028f, 
    0.17525750f, -0.07412683f, -0.11544126f, 0.22126095f, 0.05779204f, 0.09887335f, -0.10666727f, 0.10985324f, 
    -0.03654569f, 0.02908397f, 0.09950403f, 0.06079054f, 0.31036478f, -0.18042275f, 0.13989323f, -0.14546293f, 
    -0.13961783f, -0.13654771f, 0.05646664f, 0.05352750f, -0.02075787f, 0.02253246f, -0.07965912f, -0.05276425f, 
    -0.05424161f, -0.04869316f, -0.15455778f, -0.27388054f, 0.03739581f, 0.02667266f, 0.05180486f, -0.04061886f, 
    0.11932587f, 0.08503430f, 0.10953354f, -0.07854193f, 0.20562166f, 0.02982719f, 0.03085892f, 0.05369585f, 
    0.05090077f, 0.00393183f, 0.01183482f, -0.05541367f, 0.11593488f, 0.01729831f, 0.16985627f, 0.03095472f, 
    0.08384590f, -0.21019121f, 0.09476957f, 0.18794046f, 0.00607030f, -0.02398350f, -0.03326657f, 0.06302472f, 
    0.03306848f, 0.02221207f, 0.04732225f, 0.00898793f, 0.10300419f, -0.33274204f, -0.04063986f, -0.10187265f, 
    -0.07518347f, -0.08730230f, 0.03397421f, 0.02730893f, -0.04883964f, -0.10169475f, -0.17162332f, 0.11439911f, 
    0.13782728f, 0.06608284f, 0.09224934f, -0.01675918f, 0.02005834f, -0.06668820f, 0.08961003f, 0.20040397f, 
    -0.01355232f, 0.09145625f, 0.09614552f, 0.10521567f, 0.23950584f, -0.05736056f, -0.08460896f, 0.23722006f, 
    0.05139712f, -0.01349763f, -0.02798225f, 0.14925064f, -0.04482131f, -0.06975275f, -0.00815469f, 0.07577374f, 
    0.14910862f, -0.05350098f, -0.07619347f, -0.15836857f, 0.03066545f, 0.06767174f, -0.08612588f, 0.08317648f, 
    0.02068393f, 0.06249896f, 0.06846019f, 0.15404692f, 0.09864655f, 0.19247866f, -0.17247975f, 0.11395760f, 
    -0.11517181f, -0.01869127f, 0.00880798f, -0.07260810f, 0.05397163f, 0.06567086f, 0.11412854f, 0.08683144f, 
    0.12744084f, 0.09886493f, 0.03621182f, -0.21291396f, 0.07505666f, 0.01118604f, 0.05287757f, 0.15296340f, 
    0.11751575f, 0.12843639f, -0.02569519f, -0.01067190f, 0.02502947f, -0.05237797f, 0.14073791f, -0.13774852f, 
    -0.00880041f, 0.03233774f, 0.10078258f, 0.04288310f, -0.01963031f, 0.03982255f, 0.00954719f, 0.03243427f, 
    0.04132687f, -0.10752904f, 0.08380303f, -0.17782521f, 0.08764732f, -0.05228475f, -0.02826270f, 0.06928711f, 
    0.02463122f, -0.09502100f, 0.03595734f, 0.06657936f, 0.11326674f, 0.07497836f, 0.03066775f, 0.00863807f, 
    -0.05282527f, -0.12107697f, -0.04497811f, 0.17053027f, 0.15339094f, 0.01955268f, -0.05731822f, 0.09007027f, 
    0.13691783f, -0.13950115f, 0.02590999f, 0.18840455f, -0.03586476f, -0.06979053f, -0.06403584f, 0.03774050f, 
    -0.00461776f, 0.03311827f, -0.01373390f, 0.05817872f, -0.36172435f, 0.22185318f, -0.05774618f, -0.26385128f, 
    0.05373811f, -0.01505521f, 0.16628657f, -0.03773905f, 0.09368224f, 0.10613474f, -0.01603020f, 0.03471524f, 
    -0.09875801f, -0.05747041f, 0.00335531f, -0.08268040f, 0.01867483f, 0.01482479f, 0.04339494f, -0.05017148f, 
    0.07864154f, -0.00186155f, 0.02828228f, 0.07081025f, -0.12081424f, 0.05406246f, 0.02534643f, 0.10622058f, 
    -0.01697360f, 0.02157757f, -0.04097922f, 0.00063895f, 0.01078965f, 0.07155372f, 0.01517277f, 0.04890437f, 
    0.01505595f, 0.00852359f, 0.02054732f, 0.02044125f, 0.00208530f, -0.00043723f, 0.02681952f, 0.02353794f, 
    -0.00095342f, -0.03007352f, 0.02238287f, 0.00965046f, 0.01450885f, -0.03984762f, -0.00369617f, 0.03301473f, 
    -0.03932342f, -0.04109143f, -0.00710764f, 0.00827609f, 0.02669215f, -0.04083103f, 0.00759472f, 0.02814186f, 
    0.00528595f, -0.02187921f, 0.00777023f, -0.01217337f, -0.00590919f, 0.02880733f, 0.03074653f, -0.00263758f, 
    -0.01305779f, -0.02477032f, -0.03686943f, -0.00130106f, -0.00320019f, 0.01346702f, -0.01225790f, 0.03672659f, 
    -0.01051122f, -0.01961334f, 0.01885412f, 0.01536834f, 0.00639779f, 0.01245365f, -0.03268329f, 0.00328204f, 
    -0.02020693f, -0.03635447f, -0.02235823f, 0.04172670f, -0.03434976f, -0.03060825f, -0.01091699f, -0.01580309f, 
    -0.03985700f, -0.01985232f, 0.01405901f, 0.02727953f, -0.00741362f, 0.02835656f, -0.00914694f, -0.03576040f, 
    0.02322477f, -0.01517181f, 0.01109718f, -0.02514609f, -0.02299721f, -0.01767743f, 0.01706226f, -0.02007957f, 
    0.02689312f, -0.00183947f, -0.01117346f, 0.01041078f, 0.02069363f, 0.02026888f, 0.03099362f, -0.00901587f, 
    0.00511648f, 0.00052948f, 0.02201804f, -0.02643924f, -0.03721707f, -0.00787766f, 0.01608984f, -0.00509662f, 
    0.00349962f, 0.02983508f, 0.01206501f, -0.03918419f, -0.04122617f, -0.02383281f, 0.01758561f, 0.02271964f, 
    0.02983818f, -0.00702617f, -0.02596205f, 0.02046987f, 0.00133145f, -0.01469953f, -0.03337388f, -0.02296838f, 
    0.00385844f, 0.00853700f, 0.00711155f, -0.02959094f, -0.03796323f, -0.00726946f, 0.02563144f, 0.02533818f, 
    -0.01090927f, -0.02385490f, 0.00057297f, 0.02435562f, 0.00529362f, -0.01240576f, -0.03011507f, -0.01949865f, 
    -0.01510928f, -0.03449902f, -0.02115154f, 0.00366597f, 0.01169872f, 0.01731705f, -0.04121400f, -0.03520167f, 
    0.02541866f, -0.00487135f, -0.01567845f, -0.03111795f, -0.00230917f, -0.03364771f, -0.01797114f, 0.02758765f, 
    -0.00280074f, -0.00387824f, 0.03049301f, 0.02953214f, 0.01898810f, -0.02146321f, -0.00307677f, 0.02727783f, 
    0.01378552f, -0.03661007f, -0.01392487f, 0.00172692f, -0.00291736f, -0.01294055f, -0.01507096f, 0.00589432f, 
    -0.01345112f, 0.00751964f, -0.04484471f, -0.03741531f, 0.03057960f, 0.02058674f, 0.01646470f, 0.02656561f, 
    -0.03356276f, -0.03423777f, 0.02305511f, 0.01061179f, -0.00152632f, -0.01106655f, 0.01304233f, -0.03191790f, 
    0.00503018f, -0.04167664f, 0.01229868f, -0.03040541f, -0.03360572f, -0.03747717f, -0.00063256f, -0.02959665f, 
    -0.00654270f, -0.03968147f, -0.02233074f, 0.01064797f, -0.02308040f, 0.02805480f, -0.03274871f, -0.00977409f, 
    0.01703241f, -0.03899948f, 0.00568312f, -0.00783170f, -0.02510295f, -0.00373607f, -0.01082372f, 0.01348327f, 
    0.02589026f, 0.02084157f, 0.03519651f, -0.01963103f, -0.01102854f, 0.01872687f, -0.01261966f, 0.02630796f, 
    -0.00413625f, -0.02904931f, -0.01726224f, 0.00026306f, -0.01089478f, -0.01852709f, 0.01605890f, -0.02273662f, 
    -0.03747538f, -0.04110840f, -0.02405653f, 0.02909960f, 0.01581314f, -0.03379249f, -0.02730257f, 0.00376817f, 
    -0.02872682f, -0.03191123f, 0.03907342f, 0.02993534f, 0.02664094f, -0.01993866f, -0.02727017f, 0.02282787f, 
    -0.03096840f, 0.01514651f, -0.00355781f, -0.01880569f, -0.03162037f, 0.01689457f, -0.03036195f, -0.02476335f, 
    0.00676323f, -0.00625936f, -0.02859418f, -0.01440141f, 0.02708544f, 0.00389155f, -0.03383323f, -0.04094558f, 
    0.02525072f, -0.02790417f, 0.00541832f, 0.00112788f, -0.03857851f, -0.04043779f, 0.01261417f, 0.01977149f, 
    -0.03774882f, 0.02168319f, 0.02346879f, -0.01300187f, -0.00791088f, 0.01879588f, 0.00582411f, -0.01731171f, 
    -0.01410232f, 0.02675577f, 0.00219848f, -0.03141008f, -0.04170055f, 0.01714265f, -0.00730091f, -0.00854824f, 
    -0.00849306f, 0.00837695f, -0.00923527f, 0.01109692f, -0.00731700f, -0.01168708f, -0.00447966f, 0.00383180f, 
    -0.03404579f, -0.03289214f, 0.01244850f, -0.03182939f, -0.02901738f, 0.02670938f, 0.01388724f, -0.04064281f, 
    0.02753844f, -0.00903006f, -0.03037043f, -0.01634160f, 0.00692771f, -0.03764635f, -0.00160609f, 0.01313974f, 
    0.00394629f, -0.03598551f, -0.00220156f, -0.01613981f, 0.00163201f, -0.01733225f, 0.01897150f, -0.01881373f, 
    -0.00537895f, -0.02596420f, -0.00218295f, 0.02199716f, 0.02170125f, -0.00307207f, -0.00411816f, -0.03644286f, 
    0.01655582f, 0.00293777f, 0.00680119f, -0.02989489f, -0.02664382f, 0.02574775f, 0.02477009f, -0.02166314f, 
    0.00869705f, -0.02138273f, -0.04159754f, -0.02526725f, 0.00840810f, 0.03275114f, 0.02660804f, 0.01243588f, 
    -0.04009863f, 0.02761195f, 0.01990071f, 0.01207703f, -0.01602493f, 0.02620419f, 0.03094675f, -0.00611933f, 
    -0.00785694f, -0.02610396f, -0.00819835f, 0.02032549f, -0.03097920f, 0.00430508f, 0.02755364f, 0.00248458f, 
    -0.03559637f, 0.00181331f, -0.01927973f, -0.01360359f, 0.01578815f, -0.01530684f, 0.02788446f, -0.01616103f, 
    0.01747368f, -0.00289649f, 0.01766270f, 0.00350199f, 0.03076972f, 0.02863746f, -0.00494099f, -0.02054135f, 
    -0.01649350f, -0.01229654f, 0.02647568f, -0.02526815f, 0.01852369f, 0.00193522f, 0.01849621f, -0.01810366f, 
    0.01011886f, -0.00414219f, -0.02745973f, -0.01612826f, 0.02955527f, -0.01823404f, -0.01341028f, -0.01215688f, 
    -0.00939726f, 0.02807788f, -0.03066154f, 0.02286136f, 0.02009236f, -0.00286823f, -0.03555875f, -0.00612168f, 
    0.02296932f, 0.01845762f, 0.00729383f, -0.01263885f, 0.00598725f, -0.00163241f, -0.01894141f, 0.02592208f, 
    -0.00231050f, -0.01076678f, -0.00281618f, -0.01722369f, -0.01977279f, 0.00581686f, -0.00309541f, 0.00211094f, 
    -0.02746563f, 0.02174319f, -0.02153847f, -0.02363973f, 0.00478851f, -0.02033124f, -0.00558034f, -0.00175346f, 
    -0.01363526f, 0.02214500f, -0.03502284f, -0.01301432f, 0.01089072f, 0.01813058f, -0.00130909f, 0.03467031f, 
    -0.00197832f, 0.02050263f, 0.02243350f, -0.01224393f, -0.03828441f, -0.02387790f, -0.01809465f, -0.00012443f, 
    -0.03243465f, 0.00945307f, -0.00907098f, 0.00520459f, 0.01450005f, -0.02009253f, 0.02125713f, -0.00792729f, 
    -0.02320519f, 0.01138314f, 0.01439954f, 0.02205898f, 0.01361392f, 0.00526199f, -0.01385067f, 0.01580088f, 
    -0.01180183f, -0.02783532f, 0.02829073f, -0.02892338f, 0.02072912f, -0.03283946f, 0.01899451f, 0.02797926f, 
    -0.02937132f, -0.03052077f, 0.02433377f, 0.02917320f, -0.02528184f, -0.01937014f, 0.00633584f, -0.00434516f, 
    0.01571421f, -0.02599186f, -0.01179445f, -0.00137099f, -0.00821466f, 0.01343169f, -0.03463551f, 0.01579333f, 
    0.00035418f, 0.02174271f, 0.02711043f, -0.02727098f, -0.03096681f, 0.01199181f, 0.01254030f, 0.02511712f, 
    0.02763463f, 0.03119930f, 0.00480584f, 0.02815187f, -0.01751104f, 0.00671703f, 0.01256600f, -0.03042711f, 
    0.03125556f, 0.00724671f, 0.02005721f, 0.03348757f, -0.01339285f, -0.02050320f, 0.03030032f, 0.02710449f, 
    0.01515572f, -0.02308837f, -0.02665332f, -0.01929426f, 0.00471223f, 0.02218951f, -0.01698966f, 0.01615564f, 
    -0.01746064f, 0.00984097f, -0.00183561f, 0.02259837f, -0.01453962f, 0.01112822f, -0.01284295f, 0.02285507f, 
    -0.03471987f, 0.02247622f, 0.02045765f, -0.02992788f, -0.03464041f, 0.01953145f, -0.01443071f, 0.01938858f, 
    0.01409072f, -0.02124039f, -0.03382999f, 0.01028493f, -0.03107517f, 0.03175115f, -0.01085358f, -0.01365844f, 
    0.03001541f, -0.00932720f, 0.02482434f, 0.00313890f, -0.01564406f, -0.00727456f, 0.02889453f, 0.02541008f, 
    -0.01796436f, -0.01940979f, -0.01936801f, -0.03536502f, -0.01032879f, -0.00930188f, -0.00998287f, -0.03294734f, 
    -0.01398405f, 0.02531330f, 0.02596163f, -0.01628440f, -0.00706614f, -0.03225845f, -0.03085398f, 0.01807248f, 
    -0.00239950f, 0.01108343f, 0.00177516f, -0.02780174f, -0.01085952f, -0.00455798f, -0.02952561f, 0.00427219f, 
    -0.03491632f, 0.00795817f, 0.01048221f, 0.03131093f, 0.04084812f, -0.02463417f, 0.00930218f, 0.02295242f, 
    -0.02954851f, -0.01017352f, 0.02542425f, -0.00448789f, -0.03114068f, -0.02482116f, -0.01153631f, 0.01749394f, 
    0.00815023f, -0.00307678f, 0.01722681f, 0.02268667f, 0.00624837f, 0.00104018f, -0.03702137f, -0.00372700f, 
    -0.00652453f, 0.01484444f, -0.00641274f, 0.00300090f, 0.00519894f, -0.02151663f, -0.02865836f, 0.02644801f, 
    -0.03806894f, -0.02745905f, -0.00998870f, 0.01830640f, 0.02486305f, 0.00703369f, -0.01019851f, 0.01431485f, 
    -0.02024545f, -0.00917352f, 0.02137020f, -0.01164829f, -0.02203714f, -0.02276907f, 0.00095203f, 0.01537153f, 
    0.01247572f, 0.02287777f, -0.00829943f, 0.01434731f, -0.02308563f, -0.02109694f, 0.00187055f, 0.01090234f, 
    0.01207189f, 0.02872098f, -0.01050402f, 0.00054930f, -0.01426743f, -0.02895004f, -0.02017351f, 0.00521711f, 
    -0.01868810f, 0.01398025f, 0.00126617f, -0.02415891f, 0.00604625f, -0.00903536f, 0.01120220f, 0.02655311f, 
    -0.02995858f, -0.03822206f, 0.00177577f, 0.01495110f, -0.03882357f, 0.02823734f, -0.02245343f, 0.02481122f, 
    -0.03838218f, -0.02828789f, 0.00607552f, -0.02254413f, 0.00622036f, 0.01074855f, -0.02673742f, -0.02163373f, 
    0.01593852f, -0.03378932f, 0.02699590f, -0.01011072f, -0.00477270f, 0.02965016f, 0.03787277f, 0.00505416f, 
    -0.01581664f, 0.00668149f, 0.02564155f, 0.00554053f, -0.02257150f, 0.04342999f, 0.02580180f, -0.03162390f, 
    -0.00423510f, -0.03754014f, 0.00665876f, -0.01414374f, -0.00257326f, 0.04079273f, 0.00300634f, 0.02623220f, 
    -0.00432398f, -0.00274744f, -0.03280174f, -0.00088035f, 0.02415441f, -0.02609995f, -0.00484638f, -0.01276427f, 
    -0.01532435f, -0.01158914f, 0.00821307f, -0.02157554f, 0.02897405f, -0.00844327f, 0.01355871f, -0.04245579f, 
    0.00370904f, -0.01381728f, 0.02324921f, -0.01513295f, 0.02309450f, -0.02195036f, -0.02443158f, -0.03694556f, 
    0.02391633f, 0.01012083f, -0.00902931f, -0.02469831f, -0.03694832f, 0.01072633f, 0.03545149f, -0.01737886f, 
    0.02870954f, 0.00512915f, -0.01317641f, -0.01324044f, -0.02349985f, 0.01106651f, 0.02227510f, -0.03831697f, 
    -0.00756149f, 0.02579040f, -0.00735152f, 0.02700623f, -0.00025713f, -0.02103564f, -0.01706314f, 0.02279796f, 
    0.03294856f, -0.03219096f, -0.02853600f, -0.00831908f, -0.00231411f, -0.01438950f, -0.02031333f, -0.03675786f, 
    -0.02764099f, 0.00878044f, -0.01383907f, -0.03863357f, 0.02072107f, -0.00166066f, -0.01616859f, 0.02144945f, 
    -0.02276824f, 0.02952646f, -0.04148434f, -0.00198183f, 0.00069532f, -0.00184961f, -0.00587654f, 0.00850954f, 
    -0.00374539f, 0.01982518f, -0.02526808f, -0.01096692f, -0.02379249f, 0.01216199f, -0.03681381f, -0.01444838f, 
    0.02640159f, -0.00385084f, -0.01829803f, 0.02948875f, -0.00435570f, 0.00748691f, -0.02764829f, -0.03665731f, 
    -0.00691368f, 0.00449036f, -0.00603003f, 0.02128278f, 0.03037075f, -0.00194533f, 0.01814609f, -0.01889178f, 
    0.00215498f, 0.02909700f, 0.01445066f, 0.01168825f, 0.02444499f, 0.02477467f, 0.00322582f, 0.02489469f, 
    0.01716794f, -0.01916762f, 0.01393534f, -0.04009970f, 0.01487489f, 0.00895291f, -0.02629244f, 0.01804115f, 
    0.07261898f, -0.11418117f, 0.06994941f, 0.05464656f, -0.12149850f, 0.10413274f, -0.02274439f, -0.01088082f, 
    0.05066833f, 0.14340931f, -0.02397222f, 0.02916525f, 0.08320563f, 0.04897501f, 0.01526883f, 0.04351002f, 
    0.13589032f, -0.01469993f, -0.02597877f, -0.07147140f, -0.03571029f, 0.01423489f, -0.06537234f, -0.03167457f, 
    0.02718684f, 0.05149004f, 0.06847833f, -0.00730793f, 0.00003274f, 0.00026962f, 0.07685038f, -0.03997644f, 
    0.00113932f, 0.05662319f, -0.04473517f, 0.01068558f, -0.06942222f, 0.02819198f, 0.25687537f, 0.06632694f, 
    0.08764084f, -0.04943769f, 0.01517799f, -0.02634719f, -0.04414050f, 0.19600131f, -0.09899213f, 0.05534651f, 
    -0.14327922f, 0.07188306f, -0.01891100f, 0.07374997f, 0.02137202f, 0.01821250f, 0.06584605f, 0.05918074f, 
    0.01307752f, -0.02835652f, 0.00886282f, -0.05222027f, -0.33916700f, 0.01462310f, 0.11220071f, -0.05035491f, 
    -0.08786084f, -0.07698946f, -0.00129376f, -0.01690484f, 0.01707984f, 0.05111193f, 0.02652844f, 0.01187572f, 
    0.09041465f, 0.03930375f, -0.01127393f, 0.04920914f, 0.02696895f, -0.08958895f, -0.00386289f, -0.10346050f, 
    -0.02764651f, 0.06989449f, -0.01806257f, 0.07920953f, -0.02049523f, 0.01205006f, -0.02149252f, 0.11257652f, 
    0.09530162f, 0.02006063f, 0.13940324f, 0.03427278f, 0.02584524f, 0.02889204f, -0.01755275f, -0.01101069f, 
    -0.10776048f, -0.07006118f, 0.02011569f, 0.06186787f, 0.04742517f, 0.06127987f, -0.07797579f, 0.05160450f, 
    0.01825603f, -0.10665901f, -0.03186036f, -0.01498852f, 0.18409432f, 0.03157428f, -0.01938483f, 0.14162084f, 
    0.04026165f, -0.01791185f, 0.00414274f, -0.02662330f, -0.03722647f, -0.01517557f, 0.00624089f, 0.14408897f, 
    -0.08878701f, -0.04900890f, 0.07154801f, -0.07212377f, -0.07753986f, -0.00441950f, 0.02061793f, -0.02967120f, 
    0.04523967f, -0.02338243f, -0.02177965f, -0.04711645f, -0.45300186f, 0.00651499f, -0.00229810f, -0.02240088f, 
    0.01251084f, -0.03718244f, -0.01457357f, -0.03518000f, -0.00366480f, 0.04617000f, -0.04940814f, 0.01446423f, 
    -0.02276204f, 0.02494766f, -0.05378366f, 0.03215419f, 0.05968894f, -0.08852784f, -0.08423122f, 0.14409678f, 
    0.04569854f, 0.03345392f, -0.06912241f, -0.02002927f, -0.08748198f, 0.02490785f, 0.05603702f, 0.03760540f, 
    0.01146995f, 0.01066834f, 0.01577816f, -0.01085342f, 0.03208407f, 0.06832979f, -0.00447948f, 0.03172733f, 
    -0.21675612f, -0.05782893f, -0.07194208f, -0.10578021f, -0.03387992f, 0.12522647f, -0.09201501f, -0.07543100f, 
    0.09114526f, -0.04498127f, -0.05426879f, 0.00389013f, -0.06205929f, 0.17957990f, 0.16917495f, 0.11059080f, 
    0.03245682f, -0.07099766f, 0.01832311f, 0.08755964f, 0.03605561f, 0.01238663f, -0.02164903f, 0.13420063f, 
    -0.16700716f, 0.04154411f, -0.05314875f, -0.02575761f, 0.09464027f, 0.05466713f, -0.02248791f, -0.02314054f, 
    0.05433557f, -0.03585932f, 0.02771041f, 0.08204088f, 0.20332754f, 0.11374419f, -0.03561415f, 0.21430993f, 
    -0.07146475f, 0.05136849f, -0.00961440f, 0.00129264f, 0.09067371f, 0.03109699f, 0.04993080f, 0.01860106f, 
    0.03796215f, 0.04818172f, 0.11661553f, 0.00498418f, 0.08712938f, 0.07431918f, 0.08053927f, 0.02100844f, 
    0.01893328f, 0.01013279f, 0.01032372f, -0.00313695f, -0.28696045f, -0.09395093f, 0.00465413f, -0.00109562f, 
    -0.04574987f, 0.00156775f, -0.03525953f, -0.01961550f, 0.03079575f, 0.01383235f, 0.01356506f, 0.05290481f, 
    -0.01674386f, -0.02285148f, 0.08315532f, 0.14581560f, -0.01118708f, -0.00196675f, 0.04256543f, -0.02046686f, 
    0.10369627f, -0.03851827f, 0.05736288f, 0.04397369f, -0.18297666f, 0.06064909f, -0.10940549f, -0.17414890f, 
    0.08764314f, -0.02899614f, -0.01564490f, 0.04960795f, 0.09667585f, -0.00295788f, 0.00477236f, -0.00632573f, 
    -0.05928154f, 0.15601046f, 0.10294176f, -0.06129071f, -0.01289867f, 0.03840584f, 0.11270799f, 0.02282189f, 
    -0.02457598f, 0.04849891f, 0.04830442f, -0.05956574f, 0.00270076f, 0.13197112f, 0.09475604f, -0.00361702f, 
    0.10988826f, -0.03909933f, 0.20128447f, 0.02756765f, 0.06938346f, -0.01530663f, 0.05235668f, -0.01339371f, 
    -0.28537393f, -0.02091010f, 0.00241236f, 0.02622783f, 0.07270973f, 0.01021628f, -0.03798870f, 0.07660118f, 
    0.06452074f, 0.00115362f, -0.01762841f, 0.08164838f, 0.04839519f, 0.01599301f, 0.01828050f, 0.09823190f, 
    0.05955360f, 0.04442981f, 0.01503956f, 0.01097262f, -0.08206093f, 0.01331533f, -0.03654438f, 0.02334235f, 
    0.03324476f, -0.14780630f, -0.00202620f, 0.06966289f, -0.04552002f, -0.03244986f, -0.04311637f, -0.11629333f, 
    0.03314475f, 0.03339312f, -0.02870981f, -0.01886512f, -0.26160955f, -0.27902576f, 0.04129322f, 0.03142715f, 
    0.04410365f, 0.08219852f, -0.05586704f, -0.06672029f, 0.09157163f, 0.06769589f, 0.03894372f, -0.00984723f, 
    -0.08884427f, 0.15060133f, 0.02778063f, -0.03370677f, 0.10284264f, -0.05943023f, 0.05804250f, 0.07072120f, 
    -0.00260118f, -0.01871895f, 0.04459992f, 0.00168019f, 0.04402823f, -0.11069053f, 0.03678555f, 0.10943561f, 
    -0.14467055f, 0.07965086f, -0.09698655f, -0.02671011f, 0.02182807f, 0.08280469f, -0.04152370f, -0.00487618f, 
    0.09898275f, 0.09704123f, 0.12150607f, 0.04371441f, 0.01961886f, 0.09341026f, 0.00680578f, 0.04359359f, 
    0.05457057f, -0.00695738f, -0.01154922f, 0.02978341f, 0.12982701f, 0.13052517f, 0.13937639f, 0.24084342f, 
    -0.06632156f, 0.00149290f, -0.05743951f, 0.06184538f, 0.04066942f, 0.06990445f, -0.03539713f, 0.05189382f, 
    0.03102096f, -0.09171449f, -0.16099638f, 0.24436717f, -0.04332067f, 0.10703818f, -0.13423319f, -0.07551978f, 
    0.04728776f, 0.08097264f, -0.03691195f, 0.04348503f, -0.13997737f, 0.13199510f, 0.03033379f, -0.01900875f, 
    -0.00749781f, -0.05416709f, 0.08283539f, 0.02418528f, -0.00461782f, -0.00790692f, -0.00538761f, 0.03963861f, 
    -0.15500139f, 0.15106218f, -0.13294940f, 0.14055006f, 0.04588270f, -0.03497010f, 0.09505563f, 0.04052851f, 
    -0.01709645f, 0.07502935f, 0.12466152f, -0.02330182f, -0.16753750f, -0.05262778f, 0.03234296f, -0.06062886f, 
    -0.04549851f, 0.01603127f, -0.01828604f, 0.04301958f, -0.00837108f, 0.08019694f, 0.05345389f, 0.00472614f, 
    -0.08222920f, -0.09396572f, -0.13015689f, 0.05393359f, 0.08314858f, 0.04955199f, 0.00241184f, 0.01408869f, 
    -0.04609425f, -0.07751418f, -0.06762028f, 0.04883430f, -0.06724591f, 0.11046056f, -0.13939701f, 0.00241631f, 
    -0.07492061f, 0.10051654f, 0.00460612f, -0.07222033f, 0.00799613f, 0.01421298f, 0.03659736f, -0.14973880f, 
    -0.09878860f, 0.09728652f, -0.04466423f, 0.12178344f, -0.00953066f, -0.08568064f, 0.01665225f, -0.05092053f, 
    -0.01259043f, -0.02899421f, 0.04758062f, 0.05997427f, 0.20474333f, 0.05246513f, -0.01068261f, 0.22280289f, 
    0.02489379f, 0.06169155f, -0.00158087f, -0.03341988f, -0.00004774f, 0.02085852f, 0.00872160f, 0.04352338f, 
    0.28904933f, -0.12285549f, 0.05871050f, 0.06381205f, -0.02142354f, 0.01111211f, 0.06198794f, -0.04021825f, 
    -0.03636250f, 0.03586694f, 0.05517435f, -0.03478830f, -0.35955864f, 0.07323021f, -0.05088378f, -0.01970877f, 
    0.10169958f, 0.05049603f, -0.00116951f, 0.05805202f, -0.00362096f, -0.01192026f, -0.03597602f, 0.00838496f, 
    -0.18828201f, -0.02738589f, -0.03655424f, -0.11348563f, 0.04730634f, 0.04159456f, -0.01694607f, -0.01618168f, 
    -0.00320471f, 0.05134964f, -0.04015446f, 0.12921874f, 0.00344045f, 0.07681818f, 0.06944307f, 0.02398329f, 
    0.08537580f, 0.06026717f, -0.05174418f, -0.02532321f, 0.10583517f, -0.00571470f, -0.02098674f, 0.07636864f, 
    -0.22096829f, -0.06149723f, 0.00614206f, 0.05686198f, -0.02726701f, -0.04703176f, 0.02377256f, -0.03015277f, 
    0.07387364f, 0.02191180f, 0.04606535f, -0.03820185f, -0.16330424f, -0.04723186f, 0.03397412f, 0.09560551f, 
    0.02966590f, -0.07701038f, -0.01883834f, 0.07685649f, 0.07924857f, 0.07687285f, 0.05841773f, 0.07105471f, 
    -0.27755260f, -0.02696341f, -0.04738898f, -0.04230071f, -0.00061653f, -0.04068996f, 0.08449990f, -0.08612002f, 
    0.00225853f, -0.00507622f, -0.00234358f, 0.03103624f, 0.06471295f, -0.03517719f, 0.13007730f, -0.05511973f, 
    -0.05245776f, 0.11894704f, -0.06398208f, -0.10584068f, -0.08732589f, 0.02543871f, -0.03881020f, 0.02091661f, 
    0.24375834f, 0.23038675f, -0.00499696f, 0.01608070f, 0.05006559f, 0.09029309f, 0.10151040f, 0.02281659f, 
    0.01831353f, -0.07087012f, 0.10351687f, -0.09773592f, -0.14060247f, -0.05788218f, -0.09938212f, -0.10807650f, 
    0.00307309f, 0.09232555f, 0.00837289f, -0.00911957f, 0.08810007f, 0.05539851f, 0.13336109f, 0.02636988f, 
    -0.17222694f, 0.17508338f, -0.13305256f, 0.07697557f, 0.08336928f, -0.04041171f, 0.01745054f, 0.03450908f, 
    0.04288119f, 0.08553387f, 0.09686619f, 0.08493653f, -0.33395040f, -0.11176442f, 0.02563086f, 0.01988202f, 
    -0.05762932f, 0.03748354f, -0.00102335f, -0.08479450f, 0.00361613f, 0.02916499f, -0.02571702f, 0.03307577f, 
    0.14139317f, 0.07960338f, -0.01615194f, 0.01042331f, 0.06696322f, -0.02581388f, -0.04364980f, 0.04405432f, 
    0.04874565f, 0.06268640f, 0.02824516f, 0.05120802f, 0.06345815f, 0.03846864f, -0.00129623f, -0.04775969f, 
    -0.01693000f, -0.03980422f, -0.10086899f, 0.03809830f, 0.01040605f, -0.03797734f, 0.04166136f, -0.05865543f, 
    0.03648046f, 0.20364654f, 0.08037291f, 0.06521926f, 0.00635011f, -0.07160348f, 0.09078328f, 0.09598840f, 
    0.05671838f, 0.05050793f, -0.02422343f, 0.11856308f, -0.04764659f, -0.07464676f, 0.03868119f, -0.00932634f, 
    0.06317189f, -0.07693118f, 0.06844512f, 0.00065938f, -0.01053489f, 0.05108126f, -0.03297743f, 0.01845481f, 
    0.07551879f, 0.17520742f, 0.04321196f, -0.05153707f, 0.04574616f, -0.07848813f, 0.05017893f, -0.00570449f, 
    0.11782814f, 0.06790452f, 0.04910476f, 0.02001206f, -0.18248081f, 0.00913741f, -0.04008096f, 0.08288322f, 
    -0.03688655f, 0.02496822f, -0.03226031f, 0.00971818f, 0.14183098f, -0.02963450f, 0.03247453f, -0.00524082f, 
    -0.11884382f, -0.17859788f, -0.04171624f, -0.04044745f, -0.02148247f, 0.08370631f, -0.00024274f, -0.00373843f, 
    0.04294759f, -0.05289425f, 0.01891778f, 0.01394624f, 0.11721519f, 0.06710680f, 0.09798633f, -0.09651898f, 
    0.06159152f, 0.11022540f, 0.02314774f, 0.07368619f, 0.02192498f, 0.06113081f, 0.07313585f, -0.06350516f, 
    -0.11983741f, -0.05401563f, -0.05498724f, 0.04540371f, -0.10882667f, 0.01822929f, 0.04630097f, -0.01345346f, 
    -0.03002388f, -0.05213046f, 0.10663813f, -0.02881493f, -0.02344255f, 0.04618875f, 0.20286302f, 0.07295921f, 
    0.06865627f, -0.09335492f, -0.06202330f, -0.00093515f, 0.00628570f, 0.04620139f, -0.02713391f, 0.11732079f, 
    0.25607491f, 0.02714835f, 0.02633076f, 0.14878562f, -0.00586267f, 0.05022518f, 0.03747581f, 0.10017798f, 
    -0.07493062f, 0.05167721f, 0.02923868f, -0.00277366f, -0.18103212f, 0.15602048f, -0.14491406f, -0.02328088f, 
    0.00666407f, -0.05668077f, 0.04519276f, 0.04612903f, 0.06499373f, 0.01157437f, 0.04962071f, 0.06164540f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01156820f, -0.01728393f, -0.02332233f, 0.05131967f, 0.00028800f, -0.02193104f, 0.07566147f, 0.01429375f, 
    0.02869676f, 0.09012261f, -0.03204915f, 0.02575459f, -0.00514990f, -0.03921630f, -0.00727288f, 0.00340335f, 
    -0.00019886f, -0.08154074f, -0.02641680f, -0.00758941f, 0.05266186f, 0.00158809f, -0.02785231f, -0.01510164f, 
    -0.06470150f, -0.01276056f, -0.00396427f, -0.00474955f, -0.00160024f, 0.08050426f, 0.01545281f, 0.00289675f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06674093f, -0.13951559f, -0.15768611f, 0.11521891f, 0.03784896f, -0.01035966f, 0.07790861f, 0.19195272f, 
    0.01961852f, 0.07075214f, 0.05552120f, -0.38915467f, 0.02077560f, -0.00664691f, -0.03854765f, -0.16163339f, 
    -0.34318551f, -0.29060429f, 0.02486359f, -0.06313042f, 0.24771789f, -0.00392414f, -0.10200204f, -0.14266518f, 
    0.07249351f, 0.06510793f, 0.21856941f, 0.15231451f, -0.06940084f, 0.32015812f, -0.16938590f, 0.04877475f, 
    -0.16500133f, 0.09715801f, 0.11790671f, 0.25471589f, 0.06626641f, 0.02792436f, 0.02401816f, 0.17148615f, 
    0.17709303f, 0.17447525f, 0.15159270f, 0.22361991f, -0.07633244f, 0.05277199f, 0.09794600f, -0.34732190f, 
    0.36536694f, -0.10777183f, -0.12229241f, 0.08689196f, 0.16839714f, 0.09300922f, -0.17618138f, 0.08687121f, 
    -0.26291424f, -0.12864943f, 0.44685760f, -0.28749701f, 0.05981578f, 0.02873650f, 0.03265898f, 0.30682969f, 
    0.09035534f, -0.16684607f, 0.12019329f, -0.22361478f, -0.02137258f, 0.16210142f, -0.21097589f, -0.10234089f, 
    -0.12385990f, 0.02804677f, -0.16705039f, 0.03458575f, 0.04271395f, -0.03775662f, 0.22666381f, 0.09318948f, 
    0.23945986f, -0.03622779f, 0.09914174f, 0.02538790f, 0.01277969f, 0.31995881f, 0.10274546f, 0.11136867f, 
    0.00090008f, 0.04350277f, 0.36880437f, -0.08793478f, 0.09600910f, 0.08728448f, -0.14680384f, 0.07957899f, 
    0.09026354f, -0.12334727f, 0.06370312f, 0.44411948f, -0.11915526f, -0.04841360f, 0.05442323f, 0.10736015f, 
    0.12214418f, 0.20230369f, -0.00190834f, -0.00441866f, 0.01109403f, 0.07427930f, 0.22506191f, -0.00769034f, 
    0.26971337f, -0.24673006f, -0.13020666f, -0.14071533f, 0.29824391f, 0.21669155f, 0.18121952f, 0.14336133f, 
    -0.17953345f, -0.15304461f, -0.15187271f, -0.19242500f, -0.18330085f, -0.16817617f, -0.05619899f, -0.24132738f, 
    0.07857951f, -0.01885379f, -0.08884157f, 0.16603205f, 0.09054435f, 0.00284531f, 0.01025691f, -0.11488991f, 
    0.14538613f, 0.12928917f, -0.07909260f, -0.00366364f, -0.10161666f, -0.08995176f, -0.00450761f, -0.06161801f, 
    -0.09701043f, -0.12308964f, -0.10775998f, -0.08958900f, -0.06784275f, 0.07320523f, -0.16001895f, -0.06027935f, 
    0.02464765f, -0.15661594f, 0.01428007f, 0.04728343f, 0.03704295f, -0.15189779f, -0.08407403f, -0.00118424f, 
    0.10402740f, -0.05655618f, -0.01274664f, 0.10451753f, 0.15769708f, 0.00287469f, -0.13005297f, -0.16543721f, 
    0.05309542f, -0.09766577f, -0.07101333f, 0.11849425f, -0.07221825f, -0.04117241f, 0.08645573f, -0.10597558f, 
    0.14360096f, -0.00690027f, 0.11564627f, 0.01611354f, -0.04285401f, 0.04784510f, -0.08773566f, -0.12102259f, 
    0.14095530f, -0.10778399f, -0.05338670f, -0.16948552f, 0.16901301f, -0.13393505f, -0.17183016f, -0.07807329f, 
    -0.29242012f, -0.07151494f, -0.10313770f, 0.27543610f, -0.16698463f, -0.05751921f, -0.02682695f, -0.05836148f, 
    -0.06575321f, 0.18685004f, 0.13638842f, 0.42351863f, -0.07957348f, -0.15206511f, -0.27631104f, -0.12072947f, 
    0.04299213f, 0.03762573f, 0.05110166f, -0.00437189f, 0.09713928f, 0.36038432f, 0.17653482f, -0.14121313f, 
    -0.14354546f, -0.01903586f, -0.00966393f, 0.08159024f, 0.07645158f, 0.17212325f, -0.13860422f, 0.30556902f, 
    0.00026324f, -0.10925429f, 0.08136754f, -0.18236165f, 0.15698014f, -0.09316062f, -0.22750868f, 0.32083046f, 
    -0.11062745f, -0.38124123f, -0.09966674f, 0.02397490f, -0.11164594f, -0.07542788f, -0.04304773f, 0.22325173f, 
    0.13548583f, 0.05035018f, -0.04536196f, 0.12349120f, 0.18367039f, 0.51608407f, -0.10704345f, -0.12195247f, 
    0.11981116f, -0.18112123f, 0.19444621f, -0.08449844f, 0.08184732f, 0.09554038f, 0.01859456f, -0.19342588f, 
    0.18823405f, 0.13046314f, 0.01962597f, 0.04713177f, 0.16023573f, 0.00890037f, 0.13968442f, 0.25853112f, 
    -0.06739497f, 0.20447950f, 0.15349334f, 0.25467053f, -0.14955691f, -0.18066409f, -0.08579730f, 0.07653880f, 
    -0.14463462f, -0.24305269f, -0.12853388f, 0.05648182f, 0.29662880f, 0.42532772f, 0.05575915f, 0.06858981f, 
    -0.30552390f, -0.10391501f, 0.04651808f, -0.18772550f, 0.10175211f, 0.06154950f, 0.14190921f, -0.26372924f, 
    -0.29140952f, -0.17975855f, -0.07161729f, -0.21195100f, 0.04407264f, -0.09836135f, 0.02632985f, -0.22082858f, 
    0.10731034f, 0.33215827f, -0.10151718f, 0.41958073f, 0.15104862f, 0.12993154f, -0.24586193f, -0.27931845f, 
    0.25215179f, -0.01813820f, 0.14153808f, -0.10545305f, -0.05292423f, 0.26481789f, -0.10073638f, 0.04629792f, 
    0.21313189f, -0.11994035f, -0.16091031f, 0.07148035f, 0.00394224f, 0.01816298f, 0.08877236f, 0.17136161f, 
    -0.12871721f, 0.16146287f, -0.13188128f, 0.07904321f, -0.07454730f, 0.08164559f, 0.02814998f, -0.04961053f, 
    0.13146171f, -0.06127273f, -0.15563717f, 0.11572732f, -0.02738635f, -0.09907894f, 0.07710675f, -0.12412141f, 
    -0.01666044f, -0.13947766f, -0.11072822f, 0.03731429f, -0.10792533f, -0.13074087f, 0.12743127f, 0.03881864f, 
    0.13418515f, 0.03974629f, -0.10858581f, -0.12960128f, 0.06428992f, -0.12346862f, 0.04978112f, -0.12984672f, 
    -0.17840454f, -0.01722703f, -0.11720634f, 0.05951809f, 0.02835375f, -0.07786164f, 0.00827044f, 0.04748996f, 
    -0.02404058f, -0.06164121f, -0.07240264f, 0.12082301f, 0.02594864f, -0.03494851f, 0.03588388f, -0.03704119f, 
    -0.19088039f, 0.01857184f, -0.01603402f, 0.18025486f, -0.18350130f, 0.00456543f, 0.16594213f, -0.01748427f, 
    0.13735811f, -0.06144136f, -0.15412925f, -0.03172472f, -0.15427664f, -0.08737141f, 0.04405656f, 0.06863642f, 
    -0.25934282f, 0.06732973f, 0.12223676f, 0.31416476f, 0.05039812f, 0.05966185f, 0.30127552f, -0.00193576f, 
    0.08324520f, -0.17818405f, -0.01222013f, 0.32427603f, 0.20639192f, -0.11810658f, -0.38580272f, 0.10472875f, 
    -0.12708649f, 0.01882350f, 0.12506776f, 0.07403376f, 0.24771746f, 0.11645305f, 0.02065232f, 0.12585250f, 
    0.12166012f, -0.09244791f, -0.34933800f, -0.09854843f, 0.02003221f, -0.13545395f, 0.16533530f, -0.13159452f, 
    -0.11322855f, 0.06796449f, 0.13086657f, -0.13604359f, 0.13152988f, -0.05004958f, 0.00257156f, -0.17268094f, 
    -0.04162270f, -0.13521205f, -0.00421254f, 0.02060357f, -0.07685751f, -0.02937705f, -0.09681883f, 0.13142394f, 
    -0.05200357f, -0.10107800f, 0.09395611f, -0.03976486f, 0.03269216f, -0.02354412f, -0.15999910f, 0.07036264f, 
    0.03923061f, 0.07028978f, -0.06391090f, 0.07169917f, 0.02817173f, 0.01776139f, 0.00271880f, -0.06070732f, 
    0.13935940f, -0.10093776f, 0.10587497f, 0.24436696f, -0.02463361f, -0.00113429f, 0.18317679f, -0.12932318f, 
    -0.01455977f, 0.14090377f, 0.17585941f, -0.12681115f, -0.17430216f, -0.05960546f, 0.17960130f, 0.27715492f, 
    -0.40825066f, 0.09448441f, -0.01509591f, -0.11083675f, 0.26295808f, 0.20832010f, -0.12893943f, 0.05422998f, 
    -0.26413330f, -0.07035545f, -0.22390698f, 0.22248720f, 0.01041324f, 0.12720133f, -0.05994280f, -0.24325287f, 
    0.47087607f, -0.05269561f, 0.15191624f, -0.56946701f, 0.08048160f, 0.08920386f, 0.24815713f, 0.29096720f, 
    0.16547742f, 0.22251822f, -0.03580090f, 0.03429564f, -0.12450968f, 0.08743279f, -0.19967110f, 0.15985709f, 
    -0.34711590f, 0.27425987f, -0.09297400f, 0.13914348f, -0.14363004f, 0.26523405f, -0.08122001f, -0.06233323f, 
    0.35863119f, -0.06896851f, 0.46836096f, -0.13587829f, -0.08797616f, -0.07021515f, -0.13370724f, 0.07888512f, 
    0.14180696f, 0.16655754f, -0.14876798f, -0.25550923f, -0.09874166f, 0.00393751f, 0.20159155f, 0.31839502f, 
    -0.11653545f, -0.04300369f, -0.08429806f, 0.29072595f, 0.07525124f, -0.11218365f, -0.09325331f, 0.24443565f, 
    0.07341388f, -0.26944333f, 0.09294246f, -0.11222724f, 0.10127559f, -0.08547740f, -0.05256269f, 0.03018296f, 
    0.45092261f, 0.07640981f, -0.07098886f, -0.30025432f, 0.10353206f, 0.02507743f, -0.13323645f, -0.20815228f, 
    0.01369964f, 0.03799458f, -0.17822441f, 0.08351207f, 0.04317154f, -0.12205297f, -0.08806206f, -0.16499774f, 
    0.04903378f, 0.14072698f, 0.08984052f, 0.05389621f, -0.16984868f, 0.09803858f, -0.12846817f, -0.10930068f, 
    0.00224976f, -0.15971366f, 0.14845146f, -0.17122851f, 0.00998377f, 0.10927641f, -0.11889268f, -0.01130794f, 
    -0.04099103f, -0.13899231f, 0.06775567f, 0.03256763f, -0.03414766f, -0.07482447f, 0.12310845f, -0.00241172f, 
    0.04510424f, -0.14379668f, 0.01051563f, 0.10647825f, -0.12115464f, 0.12918040f, 0.00066639f, -0.17124258f, 
    0.16138276f, -0.17114154f, -0.06125154f, 0.02930626f, -0.13570727f, 0.00879951f, -0.10626686f, -0.01425565f, 
    -0.13761380f, -0.00863359f, 0.01628060f, -0.12194896f, -0.10675900f, 0.08564846f, -0.11951883f, 0.05655733f, 
    -0.11042809f, 0.14072150f, 0.07703061f, -0.06449147f, 0.12893374f, 0.12276736f, 0.08151133f, 0.12686846f, 
    -0.08945767f, -0.04229242f, 0.02339496f, 0.37658152f, -0.15760164f, 0.09449490f, -0.17995118f, 0.20279072f, 
    0.01649000f, -0.32717863f, -0.05088827f, -0.27656195f, 0.25755769f, -0.12457487f, 0.22068565f, -0.02116040f, 
    0.38296804f, -0.06425280f, 0.00496009f, -0.11726667f, 0.19208573f, -0.21790302f, -0.04858759f, 0.07808702f, 
    0.17411119f, -0.10088693f, -0.28351703f, 0.29833165f, -0.15480272f, 0.37308425f, -0.10741129f, -0.25741723f, 
    -0.09369005f, -0.16469435f, -0.00422407f, -0.06276897f, -0.04774714f, -0.06498273f, 0.02768787f, 0.11257741f, 
    0.05852317f, 0.05959959f, -0.01090854f, -0.16249232f, 0.09398201f, 0.06808029f, -0.16449258f, -0.06426620f, 
    -0.00916377f, -0.02112026f, -0.18230525f, -0.03115310f, -0.17116933f, 0.02991884f, -0.11237972f, 0.00296967f, 
    0.08645421f, -0.09241904f, -0.01418532f, -0.05380144f, -0.15510312f, -0.06397922f, 0.08913180f, -0.07071686f, 
    0.11941455f, -0.16074775f, 0.08036897f, -0.03489169f, -0.06781835f, 0.00686308f, -0.20470165f, -0.20205563f, 
    -0.09516919f, -0.04163269f, 0.08746867f, -0.20181361f, -0.09323493f, -0.15928262f, -0.12673503f, 0.08732749f, 
    -0.02110247f, 0.01656748f, 0.03900186f, -0.09322453f, -0.01044635f, -0.06984198f, 0.16930465f, -0.14262158f, 
    0.03934280f, -0.04740073f, -0.07036912f, 0.11952722f, -0.06007886f, 0.01935679f, 0.06952041f, -0.10572935f, 
    0.19520430f, 0.06930540f, -0.09894764f, 0.23445022f, -0.06469510f, 0.02639786f, -0.06670527f, -0.21526213f, 
    0.06119712f, -0.08705220f, 0.09509163f, 0.04353438f, 0.06805211f, 0.08039854f, -0.11957783f, -0.20550317f, 
    0.17512606f, 0.01155134f, 0.10666519f, -0.14691433f, 0.27932104f, 0.33484423f, -0.10760615f, -0.08651207f, 
    -0.47154066f, -0.09690675f, 0.36993599f, 0.12360607f, 0.11599469f, -0.00276753f, 0.09300375f, 0.31967193f, 
    0.15163663f, -0.00593259f, 0.12377348f, -0.23665194f, -0.08234684f, -0.09990393f, 0.26270294f, -0.11491137f, 
    -0.16594154f, -0.10961729f, 0.16483967f, -0.03126280f, 0.17640918f, -0.02926859f, -0.26405215f, 0.26747361f, 
    0.02302903f, 0.24901249f, 0.06160201f, 0.03269484f, 0.16116853f, -0.24003299f, -0.11153090f, 0.07222003f, 
    -0.15436260f, 0.07081248f, -0.09628004f, 0.01165067f, 0.05181137f, -0.28480574f, -0.07656109f, 0.11843070f, 
    0.27928856f, -0.01217826f, -0.06387304f, -0.12233155f, 0.07157267f, -0.06688403f, -0.20302549f, 0.07662658f, 
    -0.06725553f, -0.20680629f, 0.02299247f, -0.42609352f, -0.11153744f, 0.03335190f, 0.13390332f, 0.20416361f, 
    0.08091407f, -0.04502396f, -0.05120066f, -0.04605670f, 0.01579803f, 0.28498229f, -0.16301537f, 0.15779892f, 
    -0.01628116f, -0.12666367f, 0.27146903f, 0.28622428f, 0.04971139f, 0.34228393f, 0.15319958f, -0.26107064f, 
    -0.26323122f, -0.06222295f, 0.16751613f, -0.48014143f, 0.00108934f, -0.10232352f, 0.25571012f, -0.13953890f, 
    0.09481375f, 0.37092814f, -0.01257783f, 0.05406909f, 0.32420644f, 0.10955943f, 0.19126549f, 0.09716390f, 
    0.01843247f, -0.15047634f, 0.06488486f, 0.04195579f, -0.10999652f, -0.40929896f, -0.11339592f, -0.15942414f, 
    -0.05751416f, -0.04415650f, 0.02383999f, 0.33587468f, -0.12514898f, 0.20748293f, 0.05210774f, 0.36591807f, 
    0.37502152f, 0.07548313f, 0.02465536f, 0.20323612f, -0.05949967f, -0.09185581f, -0.01519351f, 0.21797645f, 
    -0.07854322f, 0.36854535f, 0.13901830f, -0.14283508f, 0.15209714f, -0.12487508f, 0.56207269f, 0.09696193f, 
    0.38011840f, -0.30021396f, -0.15091427f, -0.15186508f, -0.12756680f, -0.30916268f, -0.16202810f, 0.14341816f, 
    0.04544944f, -0.00956647f, 0.07581292f, -0.18030775f, -0.11290540f, -0.07796882f, -0.09249840f, -0.24330050f, 
    -0.01175872f, -0.12604421f, -0.05897186f, 0.05748363f, -0.16611034f, 0.11324654f, 0.19801822f, -0.23895216f, 
    0.13669932f, 0.03882049f, 0.00805374f, -0.08898802f, 0.24317770f, 0.10793681f, 0.03890872f, -0.09104194f, 
    0.05411411f, 0.50946844f, 0.08575701f, -0.16992633f, -0.14464535f, 0.03760229f, 0.06599986f, -0.05248418f, 
    0.05721379f, -0.03843356f, 0.03788635f, 0.39859647f, 0.02628296f, 0.19477563f, -0.11311131f, -0.06775685f, 
    -0.13306178f, -0.04960406f, -0.13472889f, 0.32207751f, -0.08253637f, 0.06534135f, 0.21542670f, 0.03723682f, 
    -0.14198521f, 0.19287334f, 0.06005797f, -0.19231947f, -0.02728508f, 0.16757382f, -0.09907453f, -0.28098252f, 
    0.26799181f, 0.10211109f, 0.13068528f, -0.11609692f, 0.11054503f, -0.03588264f, -0.13385250f, -0.13938063f, 
    0.26756534f, 0.07274919f, -0.14774883f, -0.05805946f, -0.12168682f, -0.29123637f, 0.05366802f, -0.10424457f, 
    0.10195476f, 0.02373995f, -0.08587244f, 0.16437413f, 0.01247642f, -0.16630709f, -0.12880424f, -0.18494226f, 
    -0.16097818f, 0.07518017f, 0.12342352f, 0.12256827f, -0.01045777f, -0.00294750f, 0.04788764f, 0.02451826f, 
    -0.09959242f, 0.04972372f, -0.12743460f, -0.06654211f, -0.08579223f, -0.13145414f, 0.12247906f, 0.05384074f, 
    0.16191278f, 0.10247108f, -0.11895654f, -0.03674312f, 0.01921798f, -0.13773459f, -0.03150680f, 0.03976589f, 
    -0.17259006f, -0.07951332f, 0.12024762f, -0.10350931f, 0.10987675f, 0.14803356f, -0.14020486f, -0.12663378f, 
    0.11680831f, -0.15474035f, 0.10679981f, -0.01241250f, -0.08205265f, 0.13119011f, 0.11265253f, -0.07824846f, 
    0.14418511f, -0.01086086f, 0.12026445f, 0.04813487f, -0.17758514f, 0.06967831f, 0.15880622f, -0.07073728f, 
    -0.02448397f, -0.11352550f, 0.11829218f, 0.01784178f, -0.11940987f, 0.14119618f, 0.04427901f, -0.05788375f, 
    0.05310168f, 0.10415983f, -0.04240077f, 0.07958446f, -0.01807933f, -0.05952259f, -0.14804447f, 0.02771961f, 
    0.01614655f, 0.11070133f, -0.14713249f, -0.06411940f, 0.10910391f, 0.11545464f, 0.08034662f, -0.13582706f, 
    0.04362592f, -0.16320428f, 0.03870893f, -0.00283655f, -0.15204868f, 0.02896480f, -0.08032838f, 0.09949744f, 
    0.01305948f, 0.14584549f, -0.00497059f, -0.07741822f, -0.15443048f, -0.09391088f, 0.13601296f, -0.01435645f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.11884225f, 0.13012861f, -0.04496244f, 0.04021769f, 0.07820172f, -0.14575832f, -0.11283802f, 0.07911822f, 
    0.22080928f, -0.01120506f, -0.01984029f, 0.04049952f, 0.16748017f, -0.05745296f, 0.03429812f, 0.01051984f, 
    -0.11758465f, -0.08919454f, 0.12443584f, 0.05310940f, 0.02618630f, -0.01633522f, 0.01053380f, 0.15066952f, 
    -0.06192005f, 0.22455648f, -0.13316974f, 0.00472546f, -0.12961629f, 0.06357506f, -0.01004742f, -0.05823080f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.11106315f, -0.54255635f, 0.12145134f, -0.06508438f, 0.06287401f, -0.06258173f, -0.42928880f, -0.31110680f, 
    -0.55239809f, -0.37097472f, 0.05920795f, 0.03707638f, -0.39620584f, -0.02790564f, 0.11328655f, -0.31655073f, 
    -0.11505786f, 0.11777150f, -0.02899908f, 0.16023660f, 0.12417167f, -0.01870418f, -0.08675051f, 0.25201231f, 
    0.23126610f, 0.21045032f, 0.15955766f, 0.15477408f, -0.40977591f, -0.11700377f, 0.05923631f, -0.03494690f, 
    0.24079481f, -0.29416800f, 0.12126182f, 0.01355111f, 0.13679449f, 0.17463173f, -0.19787960f, 0.13910948f, 
    0.15140867f, -0.12431902f, -0.10183425f, -0.01588014f, -0.64795607f, 0.04104272f, 0.11939885f, 0.21243115f, 
    -0.09440979f, 0.01660869f, 0.10159475f, 0.00570989f, 0.02355735f, -0.07584836f, -0.07067084f, -0.46548608f, 
    0.49484912f, -0.12198464f, 0.11872686f, 0.00598471f, -0.11010825f, 0.04062243f, -0.13216189f, -0.07272794f, 
    -0.21267565f, -0.02352441f, 0.08734656f, 0.30163026f, 0.11394255f, 0.16341287f, 0.03707247f, 0.08759247f, 
    0.17746843f, -0.13681844f, 0.06460819f, 0.11859760f, 0.03684564f, 0.07077677f, 0.12102353f, -0.51281667f, 
    0.17543474f, 0.05864976f, -0.13442039f, 0.28191176f, -0.08283778f, -0.07544300f, -0.25494140f, -0.40637255f, 
    0.01148750f, -0.25586185f, 0.22965826f, -0.15086818f, -0.15678257f, -0.02702029f, -0.11385747f, -0.06771155f, 
    -0.09388784f, -0.02244121f, -0.14894567f, -0.42726433f, -0.10975838f, 0.02363484f, 0.04706336f, -0.11537880f, 
    -0.40419817f, 0.13689864f, -0.17105831f, 0.08807701f, -0.03629241f, -0.14373636f, -0.16833600f, -0.30665743f, 
    -0.28474405f, 0.11081816f, -0.02449378f, 0.05818408f, 0.06216884f, 0.11008582f, 0.15397918f, 0.17126153f, 
    -0.21040729f, 0.20654970f, -0.54427576f, 0.17482978f, -0.06378880f, 0.02707674f, -0.11233918f, -0.06963456f, 
    -0.00358300f, -0.21162920f, -0.12570056f, -0.48645183f, -0.03654493f, 0.11624376f, 0.03852012f, 0.04454421f, 
    -0.34674236f, 0.22398470f, -0.09549177f, -0.03859901f, 0.04976657f, -0.02018659f, -0.30534008f, 0.19008607f, 
    0.20396674f, -0.12995818f, -0.04059501f, -0.02564051f, -0.11088905f, 0.11341587f, -0.54050106f, -0.10104097f, 
    -0.14815888f, 0.31449604f, -0.02900442f, -0.00882671f, -0.23781510f, -0.15721117f, -0.08856732f, 0.10836363f, 
    -0.07057662f, -0.10805434f, -0.02149642f, -0.12218474f, 0.04887267f, 0.06587496f, -0.32131431f, -0.20028438f, 
    0.26536572f, -0.50973380f, 0.01169600f, 0.01917223f, -0.18206061f, -0.01282616f, 0.23978774f, 0.49728867f, 
    0.09489106f, -0.12633975f, 0.02001176f, -0.32727158f, -0.05717427f, -0.00013692f, -0.11914495f, 0.36141503f, 
    -0.12456542f, -0.02948106f, 0.09708244f, -0.04048569f, -0.40572676f, 0.16107625f, 0.04493636f, -0.07304250f, 
    0.08019894f, -0.33761752f, -0.78534126f, 0.22206083f, 0.02574604f, 0.06190386f, -0.41370872f, -0.52542472f, 
    -0.12589793f, -0.31126717f, 0.09103295f, 0.05815632f, 0.23164828f, -0.05954500f, 0.08685439f, 0.05938834f, 
    0.15557341f, 0.07265434f, 0.14777511f, 0.15110344f, 0.08390655f, -0.00707476f, -0.51002032f, 0.18667158f, 
    -0.37463036f, -0.14214349f, 0.07548218f, 0.01616866f, 0.54950476f, -0.11827419f, -0.04955031f, 0.01463945f, 
    -0.55048102f, 0.12417801f, 0.22101665f, 0.19490322f, -0.01005441f, 0.08545405f, 0.24321099f, 0.07767767f, 
    -0.02393095f, 0.25576425f, 0.08437921f, -0.11455214f, -0.14650320f, 0.06417650f, -0.52542001f, 0.27483407f, 
    -0.23010832f, 0.06992430f, 0.12825698f, -0.41616464f, -0.11420931f, -0.17214483f, 0.24979813f, 0.08932523f, 
    -0.01295021f, -0.23449451f, -0.16000137f, 0.08681659f, 0.37569946f, -0.04859592f, -0.05811219f, -0.00834424f, 
    0.06577612f, -0.12572214f, 0.07797223f, 0.08834306f, -0.13069683f, 0.00617135f, 0.09705284f, 0.37625849f, 
    0.25101152f, -0.30475599f, 0.09854772f, -0.06949060f, 0.28589576f, 0.12010880f, -0.15008150f, 0.16740327f, 
    0.21671982f, -0.15234219f, 0.15231831f, 0.01659510f, 0.00438473f, -0.10647938f, 0.03760660f, 0.22753295f, 
    0.16682175f, -0.46001112f, -0.41111010f, -0.39413589f, -0.23064207f, -0.14644372f, -0.04270063f, -0.07974263f, 
    -0.12714353f, 0.36024582f, -0.01043799f, 0.40441400f, -0.10028803f, -0.06726049f, -0.29457006f, -0.47773388f, 
    0.16430902f, 0.01099408f, -0.10993411f, 0.01881390f, -0.26696894f, -0.01317450f, -0.45207930f, -0.12017182f, 
    0.17587732f, 0.09288268f, -0.11831585f, -0.09828406f, -0.10503451f, -0.17543921f, -0.11609494f, -0.06177826f, 
    -0.42115885f, 0.13799541f, 0.42692271f, -0.22602500f, 0.21716592f, 0.10112444f, 0.16662590f, -0.14025925f, 
    0.24365531f, 0.34715086f, -0.03558450f, 0.16002610f, 0.04509407f, 0.15550989f, 0.31271407f, -0.22989622f, 
    0.25580576f, -0.02382752f, -0.09110300f, 0.16187878f, -0.12347326f, 0.04851742f, 0.20569451f, -0.17377183f, 
    -0.33882469f, 0.07258186f, 0.07289154f, -0.13386108f, -0.01991701f, -0.13617676f, 0.27592650f, -0.38838351f, 
    -0.00019390f, -0.00377916f, -0.15393282f, -0.23610397f, -0.13572264f, 0.00592837f, -0.12592436f, 0.05121675f, 
    -0.15917766f, -0.37497929f, -0.34493706f, 0.27755994f, 0.05652454f, 0.10643222f, 0.10824335f, -0.25229049f, 
    0.36825612f, 0.14199722f, 0.01485211f, -0.15878506f, 0.37779295f, -0.14088282f, 0.43034407f, -0.06997936f, 
    -0.02960599f, 0.03690057f, 0.10266813f, -0.29614133f, -0.02020050f, 0.00425467f, -0.14872698f, 0.20322151f, 
    -0.28586099f, 0.00773481f, -0.37628460f, -0.09315933f, 0.02554931f, 0.13113748f, -0.09626655f, -0.03357588f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.10992909f, -0.07963108f, 0.02509392f, 0.25163952f, 0.20458311f, 0.17442243f, 0.00963743f, -0.00502532f, 
    -0.17029464f, -0.10376345f, 0.17432338f, 0.06071715f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
