#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.55241430f, -0.02862981f, 0.02745021f, -0.70738828f, -1.05604565f, 0.34904873f, 0.16885246f, -0.55815375f, 
    -0.05371038f, 0.19033508f, -0.53449160f, -0.39601198f, -0.60144246f, -0.77954024f, -0.30280331f, -0.32285315f, 
    0.65190965f, 0.06529606f, -0.23405057f, 0.75581026f, -0.43170968f, -0.51408160f, -0.11942276f, 0.73151946f, 
    -0.14893007f, -0.25334531f, 0.48460612f, -0.10665988f, -0.09557537f, 0.00808653f, -0.49916300f, 0.17233501f, 
    -0.78679925f, -0.23595807f, 1.02066171f, -0.70400465f, -0.22120890f, -0.29041132f, -0.58313227f, -0.28881767f, 
    -0.00338200f, -0.62357396f, 0.63437086f, 0.54247743f, 0.44381019f, -0.51149297f, 0.41056445f, -0.02595521f, 
    -0.11321523f, -0.27704483f, -0.80065584f, 0.79588979f, 0.16452597f, 0.35159373f, 0.00002522f, 0.18623693f, 
    0.75341141f, -0.07693386f, 0.01589105f, -0.48070794f, -0.42660612f, -0.35275307f, 0.60957158f, 0.40257192f, 
    -0.21953471f, -0.24038862f, 0.58639330f, 0.64654416f, -0.70387137f, 0.05821502f, 0.49010441f, -0.50966197f, 
    -0.76743275f, 0.39023226f, 0.19718806f, -0.31581393f, 0.49351531f, -0.53358680f, -0.48117903f, -0.38736454f, 
    -0.41241395f, 0.40720198f, 0.13921264f, 0.57865983f, 0.36553001f, -0.75971508f, 0.12826039f, 0.07193617f, 
    0.20532613f, 0.34469104f, 0.22440112f, 1.31517506f, -1.17060530f, -0.12278505f, -0.14926265f, -0.22260843f, 
    -0.00769313f, 0.21824366f, 0.20382839f, -0.36025885f, -0.07630915f, 0.62678438f, 0.64023048f, -0.50898558f, 
    -0.11467759f, 0.00062065f, -0.04587733f, 0.16114759f, -0.76327360f, -0.31296405f, -0.47168651f, 0.43781397f, 
    0.38811144f, 1.02731681f, -0.10314592f, 0.42772579f, 0.12653297f, 0.07810039f, 0.43305957f, 0.41592699f, 
    0.47628543f, -0.43954068f, -0.28997937f, 0.30551472f, -0.46600723f, -0.21373688f, -0.02728690f, -0.28938970f, 
    -0.82635146f, 0.47898498f, -0.43552777f, -0.01546548f, 0.20985612f, 0.21026839f, 0.43583068f, 0.23072496f, 
    0.32944223f, -0.14443120f, 0.25215402f, 0.41298619f, 0.26865840f, -0.39775345f, 0.44169879f, -0.56491274f, 
    0.69679999f, -0.06645294f, 0.44956830f, -0.51909113f, 0.29337648f, 0.38038120f, 0.12789235f, 0.28882644f, 
    0.39495647f, -0.14906473f, 0.41185969f, 0.18036103f, 0.49223563f, 0.67943048f, 0.49376807f, 0.27826676f, 
    0.25133938f, -0.31691176f, -0.37738207f, -0.90112948f, -0.98504734f, 0.35234416f, 0.73458618f, -0.04182406f, 
    -0.17183229f, 0.41707548f, -0.48845667f, 1.11075664f, -1.00916493f, -0.64361417f, 0.22531939f, -0.23121382f, 
    0.11721873f, -0.06297742f, -0.07723573f, -0.36673874f, 0.26062813f, 0.47013143f, 0.16152714f, 0.17170249f, 
    0.46630695f, -0.01876305f, 0.29064056f, -0.27110234f, 0.38785470f, -0.39459494f, -0.66414279f, -0.29906392f, 
    0.51435107f, 0.72617882f, -0.18426809f, -0.28709725f, -0.37289429f, -0.28947544f, 0.10586870f, 0.59817469f, 
    -0.31303880f, 0.04808169f, -0.10522363f, 0.19690232f, 0.30484548f, -0.58624446f, 0.90063488f, 0.89901459f, 
    0.00392357f, 0.10458785f, 0.62457699f, -0.34141678f, -0.54032063f, -0.55307126f, 0.14714392f, 0.01576640f, 
    -0.45200136f, 0.50660676f, -0.53740436f, -0.35235888f, 0.77128762f, -0.05982065f, 0.14976451f, 0.29712197f, 
    0.01857605f, -1.18441617f, 1.05849528f, -0.78880221f, 0.78202975f, -0.24680533f, -0.54727733f, -0.28472504f, 
    -0.16166149f, 0.13591245f, -0.26362279f, 0.30000219f, 0.39494851f, 0.35688064f, 0.61319166f, 0.01242001f, 
    -0.41434345f, -0.20061107f, 0.33939153f, -0.53093350f, -0.69208443f, -0.08478457f, -0.03953778f, 0.19303757f, 
    -0.48031849f, -0.07143410f, -0.40084472f, -0.11219370f, -0.63101560f, -0.49444458f, 0.17375803f, 0.65813345f, 
    -0.27274215f, 0.63075083f, -0.18118720f, -0.18208022f, 0.10565276f, -0.34026116f, 0.02446719f, 0.33884671f, 
    0.40802342f, -0.08248346f, 0.55694020f, -0.04914745f, -0.62222117f, -0.32473549f, -0.19057849f, 0.46152127f, 
    -0.07957596f, -0.64894414f, -0.30452237f, 0.12590472f, 0.42393467f, 0.53153747f, 0.41298091f, -0.87160492f, 
    -0.17982574f, 0.72285378f, 0.77330852f, -0.99163753f, -0.97349513f, -0.19361813f, 0.46159896f, 0.23538786f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.44107661f, -0.21988468f, 0.09303142f, 0.29993701f, -0.31701151f, 0.18455915f, -0.11103828f, 0.16793235f, 
    0.16854635f, -0.16851702f, 0.00128908f, 0.08747572f, -0.06144664f, 0.34183082f, 0.52877015f, 0.23505208f, 
    0.39831278f, 0.10020031f, 0.16749345f, 0.14737506f, -0.23365399f, 0.07964049f, -0.20996778f, -0.08583295f, 
    0.31081283f, 0.12023769f, -0.05014877f, -0.30752501f, 0.09476419f, 0.22210371f, -0.01969230f, 0.27281499f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.10867972f, -0.20325433f, -0.22635289f, 0.12245001f, 0.02305578f, 0.21022221f, 0.00183402f, 0.00676397f, 
    -0.10662460f, -0.16639595f, -0.15464181f, -0.06051309f, -0.01373600f, 0.05095880f, 0.02962218f, 0.06404234f, 
    0.08529434f, -0.12996741f, 0.20439355f, -0.08886267f, 0.13936622f, -0.00652865f, 0.32425249f, -0.04663140f, 
    -0.02202032f, 0.08091287f, 0.25622913f, 0.06415319f, 0.11873319f, 0.16690193f, 0.13264336f, 0.05518891f, 
    0.27675074f, 0.10990191f, 0.22372864f, 0.13819888f, -0.02242257f, 0.04394954f, 0.15419796f, -0.34287652f, 
    -0.18941461f, 0.02261654f, 0.13204198f, 0.13939203f, 0.06694981f, 0.07934286f, 0.15272199f, 0.32127842f, 
    0.08596192f, -0.00481574f, 0.11246015f, 0.20236684f, 0.18634696f, -0.00324738f, 0.12578230f, -0.33554649f, 
    -0.23419268f, -0.11918146f, 0.01267667f, -0.04295153f, -0.14648874f, 0.09173515f, -0.14530078f, -0.14056005f, 
    0.06196191f, -0.17240189f, 0.36350551f, 0.07853788f, 0.19071208f, 0.02793719f, 0.16379867f, 0.25317362f, 
    0.04765917f, -0.11705978f, 0.30648562f, 0.06395835f, 0.07870436f, 0.21828088f, 0.07077505f, -0.00295305f, 
    0.09645188f, -0.05458030f, -0.41140252f, -0.08634702f, -0.01514023f, -0.04200931f, -0.04113808f, 0.23364711f, 
    0.09369799f, -0.14609702f, -0.28662944f, -0.16708003f, 0.00910138f, 0.05633243f, -0.03792384f, 0.09277850f, 
    0.19004951f, 0.15872744f, 0.03531300f, -0.01779404f, -0.06109402f, -0.16679324f, 0.10184161f, 0.11037986f, 
    0.14999714f, 0.05868099f, 0.08031337f, -0.20503029f, 0.07336885f, -0.18385132f, -0.18127854f, 0.18799764f, 
    -0.11424281f, 0.11377872f, -0.00265149f, -0.06282018f, -0.08819282f, -0.05802731f, -0.03686404f, 0.04082356f, 
    -0.01496313f, 0.09782740f, 0.22734587f, 0.08417839f, 0.00010957f, -0.09274779f, 0.09476542f, 0.22063881f, 
    0.08931809f, 0.02709216f, 0.02737135f, 0.09136849f, 0.19488114f, 0.03923351f, 0.13357159f, -0.00344817f, 
    -0.05466253f, 0.03760136f, -0.00883708f, 0.01579076f, 0.05458798f, 0.13209446f, -0.21982548f, 0.05916939f, 
    -0.03023186f, -0.08628999f, -0.08149336f, 0.19754964f, 0.10119239f, -0.01617084f, 0.10714776f, 0.10880052f, 
    0.33982322f, -0.05696077f, -0.12577023f, -0.14920041f, 0.20140426f, 0.05577689f, 0.04723630f, 0.04670515f, 
    0.05409023f, 0.07169516f, -0.02208883f, 0.04502347f, -0.12627394f, -0.00846428f, -0.15468118f, 0.22902705f, 
    -0.20854795f, -0.15238826f, 0.02018879f, -0.07877129f, 0.20801599f, 0.02680857f, -0.06586359f, 0.05777220f, 
    0.04621878f, -0.00702137f, 0.06008148f, 0.21437432f, -0.10128567f, -0.25113633f, -0.06896385f, -0.00253806f, 
    0.03705486f, -0.01334699f, 0.02289431f, -0.01081506f, 0.05136873f, -0.08931912f, 0.02944988f, -0.04093327f, 
    0.00471553f, -0.18111518f, 0.01448613f, -0.10538059f, -0.26656193f, -0.11298123f, -0.06413749f, -0.11710023f, 
    -0.13245237f, 0.05941485f, 0.20328441f, -0.14723730f, 0.07462670f, 0.00415231f, 0.05130906f, -0.16113943f, 
    -0.19636405f, -0.22999649f, 0.00973267f, -0.16299298f, 0.07984560f, 0.01730741f, -0.11936817f, 0.11190125f, 
    0.03515653f, -0.06943109f, 0.08185313f, -0.06240461f, -0.07851792f, 0.21616477f, 0.17735292f, 0.11770123f, 
    0.34159118f, 0.12476081f, 0.10407842f, 0.33176631f, -0.02495431f, 0.12515803f, -0.22986609f, 0.08077604f, 
    -0.23612210f, 0.11988520f, -0.10228793f, -0.09743655f, -0.16318479f, -0.09427284f, -0.01381567f, 0.00670212f, 
    0.10818273f, 0.01692093f, -0.06180996f, -0.09594482f, -0.13532250f, -0.16106752f, -0.04142230f, -0.12852855f, 
    -0.28155604f, -0.01494808f, -0.09351936f, 0.05406164f, 0.10741804f, -0.10451443f, -0.10128190f, 0.23028003f, 
    0.00969484f, 0.02699115f, 0.10526209f, 0.02482255f, -0.13397536f, 0.02751430f, 0.03976686f, 0.13437462f, 
    -0.02345933f, 0.07078166f, 0.04946831f, -0.05346251f, -0.13800490f, -0.27991095f, -0.07831299f, -0.10210023f, 
    0.05872439f, -0.14627729f, -0.06129181f, -0.02172549f, 0.17150036f, 0.09095886f, 0.07092670f, 0.14381237f, 
    -0.02267660f, 0.16459051f, 0.06237910f, 0.08320102f, 0.12138762f, 0.10193302f, 0.01345567f, -0.09748073f, 
    -0.09285951f, -0.12734765f, 0.15823586f, -0.03680995f, 0.04514507f, 0.02376239f, 0.19763559f, -0.08601923f, 
    -0.13640168f, 0.12855436f, 0.02237802f, 0.16706382f, 0.01100335f, 0.05256962f, 0.13669869f, 0.04370305f, 
    -0.07188507f, 0.02956162f, -0.02879324f, 0.08470606f, 0.07757724f, -0.01300612f, 0.06568582f, 0.03421825f, 
    0.04675822f, 0.14081545f, -0.05581725f, 0.14050663f, 0.04841880f, 0.00566511f, 0.01300792f, -0.05529710f, 
    0.12114521f, 0.04669380f, 0.06050669f, 0.04285251f, 0.34713194f, 0.16595659f, 0.37431517f, 0.18330158f, 
    0.04144636f, 0.01757712f, 0.16885278f, 0.06330026f, 0.07475652f, 0.27256060f, 0.20666528f, 0.34434918f, 
    -0.08310043f, 0.00337426f, 0.05370675f, 0.05562139f, 0.05570169f, 0.23318312f, -0.32751057f, -0.02837197f, 
    -0.16655362f, -0.19856445f, 0.26600966f, -0.04713641f, 0.02205441f, 0.09400732f, 0.00413019f, 0.01959515f, 
    -0.16327800f, 0.17109703f, 0.18423341f, 0.03104988f, -0.08035363f, 0.03920884f, 0.02940763f, 0.07837889f, 
    -0.07165586f, -0.00299220f, 0.07694392f, 0.12082290f, 0.05379876f, -0.02077586f, -0.05841996f, -0.19127846f, 
    -0.14432263f, -0.29919544f, -0.24436711f, -0.31598541f, -0.08269145f, 0.00552642f, 0.02427571f, 0.07686197f, 
    0.17391162f, 0.21542777f, -0.41882938f, -0.48270482f, 0.27876627f, 0.10868014f, 0.05068044f, 0.23691550f, 
    0.01463689f, 0.23907067f, 0.10406583f, -0.10914673f, -0.09699592f, -0.00160026f, -0.11758652f, -0.01549813f, 
    -0.02450584f, 0.17016099f, 0.18002917f, 0.19950077f, -0.04345123f, 0.07456395f, 0.08128733f, 0.05509316f, 
    -0.09423491f, 0.08839968f, 0.06349954f, 0.03993956f, 0.03057871f, -0.40456855f, -0.23911148f, 0.07777154f, 
    0.01791560f, 0.02021153f, -0.02818567f, -0.09891637f, 0.05518591f, -0.00727703f, 0.13584764f, 0.11510801f, 
    0.19705278f, 0.04925720f, 0.06612960f, 0.05877270f, 0.08156928f, 0.05441894f, -0.04073208f, -0.18013424f, 
    0.04810692f, 0.07509365f, 0.18273196f, 0.00738061f, -0.13164225f, 0.04615289f, -0.05686167f, 0.03301141f, 
    -0.17138688f, -0.19051811f, -0.15708114f, -0.08312169f, -0.07212816f, 0.00409177f, -0.07826643f, 0.11548511f, 
    0.30275124f, -0.15794836f, -0.04976760f, -0.10802963f, 0.17545368f, -0.00229064f, -0.03430631f, -0.16541815f, 
    -0.22559470f, -0.07115165f, 0.09095427f, 0.00841618f, 0.16153085f, -0.08216949f, -0.11499819f, -0.13468537f, 
    -0.15570550f, -0.06162910f, 0.06384552f, -0.03714406f, 0.03604666f, 0.02747695f, -0.03672506f, 0.05441193f, 
    0.05520981f, -0.11389149f, 0.25304189f, -0.22184870f, -0.20795541f, -0.20836151f, -0.10044494f, 0.06954384f, 
    0.00227738f, -0.07472154f, 0.17941308f, -0.10049038f, 0.26556659f, 0.12688600f, 0.20681959f, 0.07763089f, 
    0.02388565f, -0.14391448f, -0.07756583f, -0.22731234f, 0.01455710f, -0.05515132f, -0.13737242f, -0.10827799f, 
    -0.06850661f, 0.05734672f, 0.01067088f, -0.06463187f, 0.18454929f, 0.18024467f, 0.03716933f, -0.36093283f, 
    -0.65227222f, -0.02271009f, -0.03066469f, 0.03111535f, 0.19222921f, 0.01529714f, 0.00471242f, 0.02717356f, 
    -0.11982232f, -0.09982318f, 0.11500613f, 0.06031826f, -0.07933901f, 0.17661947f, -0.02442772f, 0.00833797f, 
    0.13921237f, 0.34333786f, 0.13514997f, 0.31173623f, 0.04534044f, 0.06056131f, -0.00131705f, -0.07596202f, 
    0.02569708f, -0.00642517f, -0.04088579f, -0.01030745f, -0.08928139f, 0.12632011f, 0.08389775f, -0.03388974f, 
    0.15573962f, -0.08197576f, 0.02339975f, -0.01730967f, -0.08205728f, -0.02289020f, -0.19092704f, 0.04281330f, 
    -0.15073997f, -0.06962262f, 0.01466319f, -0.23075013f, -0.05390431f, 0.19677749f, 0.20688146f, -0.03065155f, 
    -0.04133171f, -0.14291950f, 0.14675495f, -0.00110622f, -0.03142121f, -0.20521419f, 0.16283299f, 0.28331780f, 
    0.01473011f, 0.06545746f, -0.19609949f, 0.09168347f, 0.00584708f, -0.15278494f, 0.09595737f, -0.01192314f, 
    0.09619088f, 0.13189276f, 0.02266675f, 0.09938329f, 0.11042272f, -0.04184867f, 0.17948963f, 0.15032427f, 
    0.22143866f, 0.38479799f, -0.28843352f, -0.01085329f, -0.07756775f, -0.08182665f, 0.14601871f, 0.01982569f, 
    -0.95470220f, -0.42427278f, -0.61867929f, -0.18217781f, -0.12554476f, -0.18646722f, -0.17709343f, -0.04066334f, 
    0.06703603f, -0.65666944f, -0.43909556f, -0.76714277f, -0.05492655f, -0.07420406f, -0.17314225f, -0.02792827f, 
    -0.10273393f, -0.06444930f, 0.20485823f, -0.15822753f, -0.21958253f, 0.06668359f, -0.06883144f, 0.05874288f, 
    0.12973304f, 0.15491866f, 0.13977718f, -0.05025624f, -0.53335130f, -0.02483412f, 0.07568385f, -0.10480281f, 
    -0.07483626f, -0.10938996f, -0.02767371f, 0.12659644f, -0.26649421f, -0.03332329f, -0.14654975f, -0.15932302f, 
    0.18012023f, 0.02535177f, 0.04855455f, -0.09990391f, -0.15604691f, -0.16907199f, -0.21727900f, 0.21593779f, 
    0.00902493f, 0.05043451f, -0.01364529f, -0.04009259f, 0.00311303f, -0.21812704f, -0.03690906f, -0.17110434f, 
    -0.24491966f, 0.00057631f, 0.14572571f, 0.02196537f, -0.02674360f, 0.05495029f, 0.06748973f, -0.17680007f, 
    0.07165989f, 0.04970701f, 0.10275116f, 0.12391374f, 0.05207013f, 0.03360437f, 0.11581299f, 0.11195602f, 
    0.02397244f, -0.09870147f, -0.07710361f, -0.08326048f, 0.03771710f, 0.06391738f, -0.10855360f, -0.00684314f, 
    0.26222038f, 0.14692582f, 0.04433059f, 0.03630870f, -0.00753864f, -0.03508909f, 0.00584446f, -0.03220494f, 
    -0.05446922f, 0.00248864f, 0.61413062f, -0.13937521f, -0.42073169f, 0.31453913f, -0.00551354f, 0.19568013f, 
    0.16380467f, -0.16892360f, -0.02417508f, 0.14363950f, 0.11398473f, 0.18634087f, -0.11391316f, 0.12879516f, 
    0.09029905f, 0.05902556f, 0.11921865f, -0.01814920f, -0.06701645f, 0.13398415f, -0.00503288f, -0.12544453f, 
    -0.10797056f, -0.11910964f, -0.00251394f, 0.00707438f, 0.02989675f, 0.02541059f, -0.03256645f, -0.10614185f, 
    0.22076218f, 0.06906229f, 0.12337995f, 0.09142563f, 0.03596133f, 0.29365808f, -0.26024896f, 0.47150362f, 
    0.39827535f, 0.02107277f, 0.12777689f, 0.02818323f, -0.00827902f, 0.08259497f, 0.12094928f, 0.01773022f, 
    0.05036880f, 0.02949774f, -0.05429603f, -0.05550156f, 0.04448221f, 0.10036853f, -0.02786581f, 0.11609439f, 
    0.29322684f, -0.03790361f, -0.11517238f, -0.10295823f, -0.05646314f, 0.11132333f, 0.12093945f, -0.03140555f, 
    0.03377802f, 0.05674413f, 0.00429303f, -0.12180232f, -0.07489510f, -0.19461901f, -0.09359150f, 0.11944978f, 
    -0.00342078f, 0.05916429f, -0.52933180f, 0.27153724f, 0.49675456f, 0.04609669f, -0.04373961f, -0.11385446f, 
    0.00285943f, 0.02022345f, 0.11553156f, -0.29527652f, 0.36807239f, -0.10857379f, 0.05587837f, 0.09151758f, 
    -0.04905211f, -0.03744591f, 0.04267872f, 0.12895849f, 0.07762203f, 0.04252868f, -0.06502733f, 0.03017784f, 
    -0.11544861f, -0.09454999f, 0.01781139f, 0.13660027f, 0.08144300f, -0.28158057f, -0.15335235f, -0.03181120f, 
    -0.02757802f, 0.10314296f, -0.10313024f, 0.07777090f, 0.05264661f, 0.10987479f, 0.17165326f, 0.02038134f, 
    0.00089099f, -0.07744215f, -0.02601772f, 0.04112704f, -0.16765207f, -0.00981147f, 0.11371844f, -0.06451860f, 
    0.01312275f, 0.01360998f, 0.00435541f, 0.00496390f, 0.03873788f, 0.10010694f, 0.04435021f, -0.02590942f, 
    0.21614704f, 0.08039508f, 0.10599531f, -0.02897835f, 0.01524756f, 0.27332139f, 0.10132056f, -0.02820178f, 
    0.00903715f, 0.08485493f, -0.42462084f, -0.09392962f, 0.17472711f, -0.03054400f, 0.01164420f, 0.03268254f, 
    -0.01258968f, 0.02607093f, 0.04304159f, 0.05471318f, -0.11818718f, -0.05472449f, -0.00718951f, 0.03188784f, 
    0.24216288f, 0.12298036f, -0.08239651f, -0.28089771f, 0.34631151f, 0.02017027f, -0.10761732f, 0.00330815f, 
    -0.26178148f, -0.22939917f, -0.12498984f, 0.01352454f, 0.03493296f, 0.14165404f, -0.10185835f, -0.11481862f, 
    -0.00042653f, -0.07147147f, 0.00505095f, 0.04659814f, -0.01917671f, 0.00330421f, 0.11489458f, 0.01728170f, 
    0.03778791f, -0.02645578f, -0.02704746f, 0.17530809f, 0.03984030f, 0.28298867f, 0.40244803f, -0.29446882f, 
    -0.09887521f, -0.05723498f, -0.01434619f, 0.24525422f, -0.00392137f, -0.01105503f, -0.26629046f, -0.46511540f, 
    -0.60166055f, 0.10380370f, -0.10537833f, 0.09629672f, -0.06811670f, 0.07246461f, 0.27917400f, -0.01018674f, 
    -0.14991483f, 0.05570719f, 0.06356300f, 0.06742106f, 0.19051547f, -0.32495406f, 0.03749076f, -0.00979432f, 
    -0.25719935f, -0.12012105f, 0.33386606f, 0.41095665f, -0.02861425f, 0.14054614f, -0.05468363f, 0.16880360f, 
    -0.07386207f, -0.29748785f, 0.06427646f, 0.00783097f, -0.30881351f, -0.15699568f, 0.25275603f, -0.12869647f, 
    0.15647522f, 0.20057775f, -0.06055586f, -0.05489782f, -0.04917110f, 0.30404738f, -0.09292144f, 0.11041963f, 
    0.13171865f, -0.07878338f, -0.09903298f, 0.15296346f, 0.01552129f, 0.00067509f, 0.11172421f, -0.17063618f, 
    -0.18721345f, 0.03470642f, -0.17813031f, -0.25421000f, -0.13446590f, 0.17844227f, 0.11145502f, 0.26712662f, 
    0.02882499f, -0.20922618f, 0.04742054f, -0.24108486f, -0.07063316f, -0.07091367f, -0.23050548f, -0.36806026f, 
    -0.16101864f, -0.17903043f, 0.08606571f, 0.03922667f, -0.17671259f, -0.00397499f, -0.10794853f, -0.25153330f, 
    -0.06542280f, -0.22408569f, 0.13898727f, 0.11790011f, -0.01187733f, 0.16128409f, -0.06669732f, 0.28122711f, 
    0.02100937f, 0.11032321f, 0.11271711f, 0.03289978f, 0.04488910f, 0.26048142f, 0.25649783f, -0.02402612f, 
    -0.25556126f, -0.66479397f, -0.61149621f, -0.53000003f, -0.25649846f, 0.03090751f, 0.00826977f, -0.00685678f, 
    -0.10144778f, -0.11510900f, -0.18204708f, -0.16398326f, -0.84106129f, 0.01195045f, -0.03986981f, -0.04452685f, 
    0.01235073f, -0.06885675f, -0.12841095f, -0.24089259f, 0.07307944f, -0.21299967f, -0.35459325f, -0.08727785f, 
    0.11773964f, 0.17469285f, 0.13237451f, 0.12287325f, -0.24116836f, -0.06209855f, 0.24313627f, 0.02490410f, 
    0.05646106f, 0.01794541f, 0.09832192f, 0.05403089f, 0.30394357f, -0.26658508f, 0.25805241f, -0.12509364f, 
    0.03621016f, 0.02443619f, 0.11062361f, 0.15359701f, 0.01913888f, -0.04496836f, -0.04459667f, 0.38489479f, 
    0.21534505f, 0.03767766f, 0.13895819f, 0.10140975f, 0.14894085f, -0.04295985f, 0.05275793f, -0.05035931f, 
    -0.22110932f, -0.06329068f, 0.01452932f, 0.04040714f, -0.25552556f, 0.07562865f, -0.00982528f, 0.11139254f, 
    -0.11959783f, -0.42899671f, -0.31532842f, -0.05734918f, -0.04288051f, -0.12270905f, 0.07315083f, -0.04842105f, 
    0.04237359f, -0.12817164f, -0.35144830f, -0.00264935f, 0.02565251f, -0.13177647f, -0.19305496f, 0.11947933f, 
    -0.00523310f, 0.10604761f, -0.18943354f, 0.02615030f, 0.27893665f, 0.03573447f, 0.22724928f, -0.01912115f, 
    0.15503995f, -0.04340549f, 0.16950110f, 0.35813981f, 0.36357528f, 0.26076531f, -0.05165804f, 0.25686374f, 
    -0.11424649f, 0.20934017f, 0.03034842f, -0.00250451f, -0.36808535f, -0.35832638f, -0.09127804f, 0.08238253f, 
    0.13158326f, 0.12327316f, 0.10810057f, 0.05457601f, 0.02533661f, 0.00556111f, 0.24173200f, 0.18477388f, 
    0.19594769f, -0.03014643f, 0.08840878f, 0.17900391f, 0.06812961f, 0.09759527f, -0.17234696f, -0.18648179f, 
    -0.50592059f, 0.00411183f, 0.28824356f, 0.08888531f, 0.10031915f, -0.08550898f, -0.12619771f, -0.60900581f, 
    -0.25420499f, -0.29892725f, -0.08183489f, -0.13106373f, 0.00212744f, 0.10407581f, -0.26094753f, -0.00395869f, 
    -0.04926338f, 0.00882279f, -0.13383085f, -0.31191230f, 0.00776574f, 0.19264510f, -0.22511709f, 0.13937768f, 
    -0.00631288f, 0.07535497f, 0.23482066f, 0.15664345f, 0.14983754f, 0.07773895f, 0.08672410f, 0.01486536f, 
    0.22570553f, 0.14795925f, -0.16663137f, -0.38924608f, -0.06651389f, 0.07333772f, -0.06097930f, -0.15350303f, 
    0.11136450f, 0.21507257f, 0.09372125f, -0.32496095f, 0.11551253f, 0.23640351f, 0.00613267f, 0.00911718f, 
    0.14340007f, 0.25595140f, -0.09685112f, -0.12803169f, -0.24333453f, 0.03833364f, -0.02834858f, -0.06451020f, 
    -0.01503642f, -0.12032073f, 0.10423721f, 0.31278303f, -0.00312373f, -0.16090976f, 0.00797241f, -0.11183690f, 
    0.02480259f, -0.03333332f, -0.31530601f, 0.13270187f, 0.17759357f, -0.00342725f, 0.09773024f, -0.20736423f, 
    -0.10284653f, -0.11406619f, 0.00013410f, -0.05358851f, -0.33755243f, -0.28574097f, -0.06647440f, 0.14569633f, 
    0.08804242f, 0.47727200f, -0.10786606f, 0.04745403f, 0.08720118f, -0.04886363f, 0.03258039f, 0.15131822f, 
    -0.00226767f, 0.04527710f, 0.00461543f, 0.01516964f, 0.04652761f, -0.01421277f, -0.04942589f, 0.04370330f, 
    0.02062156f, -0.03434167f, -0.01268245f, -0.00150856f, -0.02642231f, 0.04496894f, 0.00630512f, -0.02417045f, 
    -0.04499145f, 0.03988559f, 0.01132877f, 0.01584397f, 0.00952101f, -0.02034191f, 0.03098816f, -0.05997261f, 
    0.01978036f, 0.01060702f, 0.02600644f, -0.03076952f, 0.03457079f, -0.04398408f, -0.04030563f, -0.05827642f, 
    -0.02255955f, -0.06023797f, -0.02278136f, 0.01240471f, 0.02519684f, -0.01284195f, 0.02820868f, -0.04489460f, 
    -0.04503572f, 0.02262641f, 0.02453406f, 0.06208323f, -0.03877151f, 0.01298695f, 0.00419778f, 0.04715804f, 
    0.00801029f, -0.00097194f, -0.04076452f, -0.01582275f, 0.02483828f, 0.02340639f, -0.04582733f, -0.04127470f, 
    -0.05575389f, -0.05601579f, -0.05494394f, -0.05146386f, -0.02810235f, 0.02776442f, 0.05106553f, -0.04808548f, 
    -0.00556784f, 0.00935543f, -0.05588206f, -0.04341469f, 0.03140766f, -0.01793951f, 0.03833934f, 0.02019172f, 
    -0.01803485f, 0.02159653f, 0.00469027f, -0.04038628f, 0.05030188f, 0.02358503f, -0.03610600f, 0.05022537f, 
    -0.05586615f, 0.01392337f, -0.03896092f, -0.05815097f, 0.02801883f, 0.01381152f, -0.00899211f, -0.00280330f, 
    -0.01814996f, -0.04274947f, -0.02328086f, -0.00340846f, 0.03638406f, -0.03902319f, -0.05173087f, -0.03445148f, 
    -0.05220304f, -0.01647671f, 0.04975088f, -0.03490403f, -0.05729784f, -0.04317545f, -0.06150242f, 0.03664684f, 
    -0.03280689f, 0.00596348f, -0.02698306f, -0.02943754f, 0.00716025f, 0.04393885f, -0.01131129f, -0.03327191f, 
    0.02917888f, -0.02412439f, 0.04387012f, -0.02557009f, 0.00990006f, 0.02057972f, -0.05329527f, 0.00519347f, 
    -0.03707927f, -0.01708144f, -0.02024066f, 0.02430050f, -0.02229916f, -0.04278206f, 0.02133406f, 0.03222134f, 
    -0.02358291f, -0.01077766f, -0.04652154f, 0.04730320f, -0.02043829f, 0.03099833f, -0.03738766f, 0.06207146f, 
    0.03521969f, -0.01227490f, -0.03155918f, -0.04613058f, 0.03030181f, -0.05346351f, -0.02102279f, 0.01498649f, 
    -0.03253145f, 0.04041910f, 0.04838843f, 0.04873638f, 0.01338623f, 0.02609705f, 0.03100091f, -0.05975685f, 
    -0.04976855f, 0.04923922f, -0.00450928f, -0.04940020f, 0.04889590f, -0.00989187f, 0.02978552f, -0.06168498f, 
    -0.04397944f, 0.00748053f, 0.03840822f, 0.01094536f, 0.04699338f, 0.05238639f, -0.02114660f, -0.01984235f, 
    0.02572977f, 0.01721441f, 0.02273774f, -0.02255327f, -0.04311961f, 0.00746236f, -0.02127313f, -0.05013499f, 
    0.01699773f, 0.04104481f, -0.01279502f, 0.01373848f, -0.02545877f, -0.05457148f, -0.01514046f, -0.05915671f, 
    -0.01386286f, 0.01513145f, -0.06119149f, 0.03561001f, 0.03386062f, 0.04963794f, -0.04613259f, -0.04101999f, 
    0.05621081f, 0.00440547f, 0.02720788f, -0.02297380f, -0.01506721f, -0.04563257f, -0.04043022f, -0.06066592f, 
    -0.03465030f, -0.05159196f, 0.02183347f, -0.04340346f, -0.02906722f, -0.00103839f, 0.02295325f, 0.00391744f, 
    0.00705456f, 0.00846929f, -0.02566341f, -0.05059210f, -0.06174980f, -0.05871662f, -0.04459688f, -0.01380504f, 
    -0.02179198f, -0.02703373f, 0.04352091f, 0.01227246f, 0.04834912f, -0.03571780f, -0.04614969f, 0.03101456f, 
    -0.03949230f, -0.04982708f, 0.00479691f, -0.06258151f, -0.01653145f, 0.02928436f, -0.03785072f, -0.04889813f, 
    0.01617097f, -0.04720348f, -0.04848512f, -0.04102491f, 0.03303143f, 0.03879300f, -0.05124212f, 0.03189911f, 
    -0.04335422f, -0.04270390f, -0.04091141f, -0.01365879f, 0.02723141f, 0.00235018f, -0.04840000f, 0.01079848f, 
    0.02650231f, -0.03912841f, 0.02128772f, -0.00074250f, -0.02911051f, 0.03875031f, 0.05617389f, 0.02603854f, 
    -0.02854614f, 0.04983179f, -0.01824383f, -0.01015428f, 0.00231238f, -0.05308961f, -0.04827026f, -0.02872695f, 
    -0.01039720f, 0.03057896f, 0.04527811f, -0.05195887f, 0.03238166f, -0.03103866f, -0.01460251f, -0.02882402f, 
    0.00921400f, -0.00186274f, -0.00546186f, 0.02554896f, -0.00755477f, -0.03023975f, -0.04859246f, 0.03502423f, 
    -0.04335972f, -0.06342698f, -0.01097874f, 0.01430633f, -0.00522271f, -0.00051530f, -0.02621027f, 0.02742011f, 
    -0.00618487f, 0.00918570f, -0.00804034f, -0.00079945f, -0.04126491f, -0.02373866f, -0.06234618f, 0.03585954f, 
    -0.00181547f, 0.03179071f, 0.00467007f, 0.03264889f, -0.01981352f, -0.04541263f, -0.04829663f, 0.02227330f, 
    0.00977936f, -0.05058059f, -0.01047294f, 0.00700242f, -0.00003392f, -0.03767920f, 0.02738138f, -0.03503767f, 
    -0.06085012f, -0.05401981f, 0.01586422f, 0.04932640f, -0.04296355f, -0.04132565f, 0.03106663f, 0.01634769f, 
    0.03624566f, -0.02127258f, -0.03307560f, -0.01938381f, 0.05664890f, -0.04595145f, 0.03704634f, -0.03486808f, 
    0.03380569f, -0.02513071f, 0.06032545f, -0.03755123f, 0.04696343f, 0.03611318f, -0.03805355f, -0.02634746f, 
    -0.05141184f, -0.05205798f, -0.05437300f, -0.05216509f, -0.00355553f, -0.05826887f, -0.04930692f, -0.01213410f, 
    0.02563115f, -0.02613569f, 0.04557118f, -0.00490331f, -0.01288923f, -0.05184636f, -0.03523794f, -0.01510311f, 
    0.04885557f, -0.04172512f, -0.05693718f, 0.04222388f, -0.05724352f, -0.02112449f, 0.02467759f, 0.02832249f, 
    -0.05859349f, 0.00338559f, 0.01825472f, 0.01818480f, -0.02597142f, -0.05253582f, -0.06081646f, 0.02416896f, 
    0.03933964f, -0.02041473f, 0.04382209f, -0.01716536f, -0.01180070f, 0.01060216f, 0.02488593f, 0.05081039f, 
    0.04331277f, -0.04126482f, 0.02063604f, -0.00094118f, -0.06287974f, 0.04538424f, 0.02503428f, -0.00736406f, 
    0.05380185f, 0.02650170f, -0.05216292f, 0.00091561f, 0.01798137f, -0.04134366f, -0.04130702f, -0.04459268f, 
    -0.00648536f, -0.00276648f, 0.04166093f, -0.04172505f, 0.03529628f, 0.03483752f, -0.01646729f, -0.04220653f, 
    0.02122712f, -0.05613989f, -0.01634836f, -0.01126646f, -0.04332467f, -0.02833787f, 0.00677220f, 0.05006899f, 
    0.00462450f, -0.06484808f, -0.00259736f, 0.00475844f, 0.05167632f, 0.01488773f, -0.02613484f, 0.00338995f, 
    0.00406226f, -0.03499395f, -0.06255310f, 0.01168405f, 0.05341382f, -0.04112149f, -0.06147120f, -0.00809811f, 
    0.02377940f, -0.05534082f, 0.04291998f, -0.03522279f, 0.02662125f, 0.04791172f, 0.02688222f, -0.01216851f, 
    0.04326601f, -0.00743831f, 0.02683697f, -0.02745136f, -0.01637375f, -0.01619560f, -0.05792870f, 0.03133445f, 
    -0.00246451f, -0.00467153f, -0.03870559f, -0.05750854f, 0.01989372f, 0.04634536f, 0.00775567f, -0.05566899f, 
    -0.01760758f, -0.00358065f, 0.03604781f, -0.05305921f, -0.01319340f, 0.04694849f, -0.04614560f, 0.00394765f, 
    0.04648654f, -0.04274926f, 0.04905992f, 0.04755981f, -0.04767394f, 0.03648887f, -0.04184745f, 0.04084877f, 
    -0.02205810f, 0.04043344f, -0.01056178f, 0.04231985f, 0.02643955f, 0.02171949f, 0.04208118f, 0.00237935f, 
    0.00307415f, 0.03665796f, 0.03708287f, -0.02032485f, -0.02664708f, -0.00840511f, 0.01365209f, -0.06649406f, 
    -0.05477360f, -0.06458143f, -0.04459212f, -0.05369211f, 0.00361375f, -0.01842752f, -0.00140641f, 0.01142277f, 
    0.02111249f, 0.01401619f, -0.03630100f, -0.06171428f, 0.02914938f, 0.02164728f, 0.01985348f, -0.05175652f, 
    0.03024115f, 0.01140646f, 0.03692432f, 0.04185588f, -0.06078539f, 0.02044037f, -0.03733671f, -0.05173977f, 
    -0.05941525f, -0.05981435f, -0.02840400f, -0.02452977f, 0.00732796f, -0.00088168f, -0.01326994f, -0.06448366f, 
    -0.02237872f, 0.03684550f, -0.00217589f, 0.03311534f, -0.04983418f, -0.00929827f, -0.06810591f, -0.03300748f, 
    -0.00872228f, -0.01960750f, -0.01158847f, 0.03709655f, -0.00827787f, -0.00621803f, 0.01233819f, -0.03388293f, 
    0.05170961f, 0.01997610f, 0.01986239f, -0.05268963f, 0.01626236f, 0.04183731f, 0.01026908f, 0.03224999f, 
    0.00967489f, 0.03552876f, 0.00760890f, -0.01211888f, 0.02494698f, 0.03579100f, -0.02121777f, -0.05257387f, 
    0.02644325f, 0.00725245f, -0.03529175f, -0.00427177f, 0.00062057f, -0.02206354f, 0.03621316f, -0.04486293f, 
    -0.03891511f, -0.04354177f, 0.03179213f, 0.01988047f, 0.01755159f, -0.03784764f, 0.03263865f, 0.00687234f, 
    -0.06451967f, -0.04409674f, -0.05729749f, -0.01705858f, -0.03967180f, -0.03926315f, 0.00323893f, 0.01429511f, 
    -0.06240498f, 0.01180992f, 0.02099996f, 0.04889738f, -0.00205402f, 0.00946965f, 0.00343549f, 0.00196353f, 
    0.26445013f, 0.69313931f, 0.61023176f, -0.42902237f, -0.11599018f, -0.34112835f, 0.20588802f, -0.02734415f, 
    -0.02527197f, 0.28171146f, 0.42718568f, 0.03585212f, -0.33164093f, -0.06120438f, -0.12707727f, -0.08224266f, 
    -0.01723880f, 0.04104941f, 0.18749022f, -0.42119241f, -0.29735425f, -0.20793343f, 0.03720553f, -0.08164676f, 
    -0.01728120f, 0.16901420f, 0.00061294f, -0.50556403f, 0.12534650f, 0.12532410f, -0.07391383f, -0.01129689f, 
    0.01534578f, 0.02999781f, 0.23073152f, -0.14748673f, -0.09203622f, 0.61964011f, -0.15356988f, 0.25444639f, 
    0.00124313f, -0.15941812f, -0.01530911f, -0.13437180f, -0.07469713f, -0.02579338f, 0.31607777f, 0.02658570f, 
    0.02296504f, -0.05181624f, -0.09985680f, 0.00157644f, -0.08796275f, -0.03287344f, -0.38157666f, -0.01248594f, 
    -0.00228328f, 0.00674671f, -0.06805027f, -0.07694943f, -0.20544264f, 0.01991194f, -0.09289044f, -0.32363531f, 
    0.29341051f, -0.24719808f, 0.27123213f, -0.17846408f, 0.06401933f, 0.21104118f, 0.06200802f, 0.05146708f, 
    -0.26050532f, -0.01248817f, 0.04023410f, -0.00533744f, -0.12214057f, 0.13162862f, 0.02342113f, 0.05089891f, 
    0.08679834f, 0.00843337f, -0.04420965f, 0.13572542f, -0.13512245f, 0.02096106f, -0.05697654f, -0.03925899f, 
    -0.18830000f, -0.00837513f, 0.83804637f, -0.37637702f, -0.95933175f, 0.07601918f, 0.16492158f, -0.04464214f, 
    0.01792975f, -0.12480005f, -0.16341454f, -0.28599307f, 0.11101417f, -0.11422447f, -0.06791632f, 0.03323426f, 
    -0.13641067f, 0.26867330f, -0.16054820f, 0.01795027f, 0.22361039f, -0.01680634f, 0.01055095f, -0.31202552f, 
    -0.33432108f, -0.09673489f, -0.04929832f, -0.00057670f, 0.09546706f, -0.17676428f, 0.06898887f, 0.13234517f, 
    0.05434731f, -0.02348012f, -0.11350717f, -0.07098421f, 0.07220467f, 0.08974121f, 0.17605932f, 0.54326028f, 
    -0.38177317f, 0.17661801f, -0.16328061f, -0.02462117f, 0.03084563f, 0.14155510f, 0.13711222f, 0.08815354f, 
    0.09201108f, -0.08383357f, -0.20512831f, 0.09092255f, 0.03663795f, 0.09697671f, 0.09319385f, 0.25818411f, 
    -0.03129336f, -0.07331068f, -0.10060298f, 0.00868477f, 0.09677183f, -0.05228902f, 0.19395804f, -0.03379476f, 
    -0.12760383f, 0.12708744f, 0.04407535f, 0.03497558f, -0.14639719f, -0.25795010f, -0.16370560f, 0.11148799f, 
    0.10608913f, -0.00437850f, -0.14162420f, 0.45361128f, 0.09293512f, 0.09210233f, -0.18779704f, 0.15914065f, 
    0.04962072f, 0.07884280f, -0.00113443f, -0.36964813f, -0.03876761f, -0.73204863f, -0.12832163f, 0.13898471f, 
    0.20283724f, 0.11305784f, -0.00477154f, 0.03279077f, 0.06568092f, 0.13118479f, -0.14788309f, -0.22736795f, 
    -0.09736233f, -0.07869579f, 0.19687907f, 0.08436013f, 0.12148304f, -0.18933617f, 0.10030949f, 0.12901802f, 
    -0.04348926f, -0.17765091f, 0.10635529f, -0.05806673f, 0.00145710f, 0.02329360f, 0.21232906f, -0.05971598f, 
    -0.25657618f, -0.26989645f, 0.06113577f, -0.17715268f, 0.14192207f, 0.13949086f, -0.00943874f, -0.29362738f, 
    0.02592677f, 0.00842816f, -0.12338664f, 0.06097266f, -0.09097470f, -0.17788036f, -0.21201000f, 0.06493364f, 
    0.06858924f, 0.05555852f, -0.16842104f, 0.12357870f, -0.05206670f, -0.02741736f, 0.08160428f, 0.09106532f, 
    0.11960370f, -0.63914597f, -0.32554698f, -0.44627604f, 0.17000315f, -0.04856713f, 0.00381909f, 0.06097769f, 
    0.08777773f, -0.08516798f, 0.04904639f, 0.05160309f, 0.06837086f, -0.18777725f, -0.26428333f, -0.00907149f, 
    -0.00926721f, 0.05478774f, 0.18084946f, -0.00952339f, -0.14727035f, -0.35371867f, -0.10915043f, -0.09845884f, 
    0.06958729f, 0.06668699f, 0.03551702f, -0.11949252f, 0.29406202f, -0.03144260f, 0.06697237f, 0.07559384f, 
    -0.07111552f, -0.01490667f, -0.06184907f, -0.09549782f, 0.06167550f, 0.09723423f, 0.02741474f, 0.02704292f, 
    0.01534794f, 0.08635308f, 0.07942928f, -0.05108757f, 0.26572481f, 0.21154200f, 0.13750073f, -0.02625873f, 
    -0.04199188f, 0.03837229f, -0.02715615f, 0.15839864f, -0.04447817f, -0.07067318f, -0.07221064f, -0.61915243f, 
    0.22625875f, 0.18784258f, 0.18659370f, -0.09445481f, -0.05689846f, 0.06960616f, -0.04324322f, 0.13040540f, 
    -0.04075410f, 0.01141541f, -0.05155368f, 0.02601900f, -0.00079778f, 0.03840298f, 0.05429690f, -0.00385445f, 
    0.00514147f, -0.00136325f, -0.05131377f, -0.02758002f, -0.06124181f, -0.04521444f, 0.05099338f, -0.04700455f, 
    0.02628383f, -0.01643618f, -0.05395455f, -0.05608132f, 0.00432082f, -0.03547829f, -0.03316936f, -0.01923341f, 
    -0.00197638f, 0.04288200f, -0.05958885f, -0.06462194f, -0.00131116f, -0.02467986f, -0.00625813f, -0.03502997f, 
    0.02883639f, -0.01812758f, 0.00998302f, -0.03955216f, -0.03545616f, 0.02534219f, 0.00778643f, -0.00557726f, 
    -0.01335311f, -0.05256629f, -0.00148656f, 0.04450826f, 0.01594503f, 0.03249757f, -0.05848044f, -0.03171055f, 
    0.00074758f, -0.01088182f, -0.00196135f, -0.05065849f, -0.03418157f, -0.02027919f, -0.05107049f, -0.05203008f, 
    -0.00410767f, 0.03520242f, 0.01366705f, 0.04904296f, 0.00117882f, -0.01568277f, -0.02083209f, 0.00393836f, 
    -0.03724980f, -0.00817537f, -0.05304299f, -0.01341745f, 0.01532482f, 0.03480698f, 0.01886361f, 0.01013649f, 
    -0.04456183f, -0.02994128f, -0.00787530f, 0.01844856f, 0.03616489f, 0.01689880f, -0.05561151f, -0.03831543f, 
    -0.04546827f, 0.01952708f, 0.00811858f, 0.02503926f, -0.05763197f, -0.03049650f, 0.02270469f, 0.02735225f, 
    0.02857590f, -0.00512692f, 0.02567580f, 0.03312182f, 0.05112275f, -0.05932651f, 0.02139290f, -0.03423139f, 
    -0.01333503f, 0.00938910f, -0.06587883f, 0.05545862f, -0.04073478f, -0.05452254f, 0.05121775f, 0.00005389f, 
    -0.03882523f, 0.00858453f, 0.02418805f, -0.02370098f, 0.02711816f, 0.03970767f, 0.04474612f, -0.05672235f, 
    -0.05313466f, -0.02962004f, 0.01426431f, 0.04019156f, -0.02010943f, -0.02331642f, -0.03477774f, 0.03632411f, 
    -0.02764871f, -0.05375584f, -0.02129230f, 0.03363645f, 0.03618942f, 0.01938368f, 0.03321390f, -0.07157692f, 
    -0.01813900f, 0.02736203f, 0.01847487f, -0.06343592f, -0.05201423f, -0.05908478f, 0.03608697f, -0.05225456f, 
    0.03666176f, 0.02885429f, -0.04936664f, -0.02886293f, -0.05591504f, -0.00714483f, -0.04268464f, -0.02488957f, 
    -0.01211264f, 0.04438185f, -0.03158638f, -0.05116178f, -0.05744334f, 0.00822206f, -0.00018207f, -0.02011923f, 
    0.01775708f, -0.00614970f, -0.02369269f, -0.05102096f, -0.04864259f, 0.00183720f, 0.01795763f, 0.00344019f, 
    0.00622001f, -0.06313686f, 0.01330972f, -0.02493287f, 0.04197768f, -0.05215406f, -0.00280043f, -0.05284149f, 
    -0.02823307f, -0.00590543f, -0.05455585f, 0.00944550f, -0.06459466f, 0.02081175f, -0.05751571f, -0.05116534f, 
    -0.00637500f, 0.00230871f, -0.06004409f, -0.00145228f, -0.03639372f, -0.00686562f, 0.03978025f, 0.00054824f, 
    0.00718280f, -0.02134489f, -0.06046189f, -0.07843427f, -0.06285949f, 0.04254952f, -0.07214835f, 0.01227709f, 
    -0.06409834f, -0.04215385f, -0.00693194f, -0.03957841f, 0.03850327f, 0.03111061f, -0.04702879f, -0.00184149f, 
    -0.05102371f, -0.02737543f, 0.02291068f, 0.02761296f, -0.05140903f, -0.04961628f, 0.04681252f, 0.00028451f, 
    -0.02196190f, 0.00736527f, -0.04008010f, -0.02631483f, -0.03710455f, -0.04316838f, -0.06663226f, 0.02939249f, 
    -0.00206077f, -0.02155007f, -0.03723639f, 0.02272894f, -0.05518195f, 0.01901206f, -0.01779876f, -0.06924820f, 
    -0.05591857f, 0.04344731f, -0.04289040f, -0.06723455f, 0.04127881f, -0.00766677f, 0.01685415f, 0.02009842f, 
    0.04012150f, 0.04658325f, -0.02051097f, -0.02515609f, -0.00500962f, 0.04586536f, 0.05462062f, 0.04917034f, 
    -0.03197083f, 0.04036943f, -0.04558176f, 0.03240091f, 0.04407170f, -0.00502064f, 0.01278706f, 0.00938956f, 
    -0.03093802f, -0.06839074f, -0.04039832f, 0.02665403f, -0.04577822f, -0.01025214f, 0.00277956f, 0.03364417f, 
    -0.03086921f, 0.00269944f, -0.02119404f, 0.03369996f, 0.02944749f, 0.02535321f, 0.02039429f, 0.03394224f, 
    -0.03006688f, -0.01246559f, -0.00556294f, -0.03564123f, 0.00138430f, -0.01076986f, 0.00154782f, 0.01664442f, 
    -0.02636219f, 0.02770183f, -0.03256203f, -0.04535888f, 0.01027025f, -0.03649846f, -0.01264209f, -0.00429596f, 
    -0.01232292f, 0.04152296f, 0.03026705f, -0.00761511f, 0.03541100f, 0.03185455f, -0.05998095f, 0.03823725f, 
    0.15162665f, 0.06411639f, 0.18374516f, 0.09423141f, 0.10546178f, 0.19888905f, -0.11430214f, -0.13860160f, 
    -0.00026005f, -0.06430974f, -0.03097326f, 0.51396257f, -0.05821525f, 0.02872267f, -0.10855278f, -0.08334200f, 
    -0.01726866f, -0.00995869f, -0.02798398f, 0.11413514f, -0.07421268f, 0.12310522f, 0.08154818f, -0.23426737f, 
    0.20713246f, 0.09516156f, 0.09515125f, -0.01973226f, 0.07839151f, 0.04936154f, -0.12496571f, 0.10353159f, 
    -0.01724918f, -0.03648023f, -0.04386441f, 0.18284005f, -0.15199631f, -0.27930373f, -0.12187038f, -0.11344193f, 
    0.02367073f, -0.38104215f, -0.02395151f, 0.02513997f, -0.25139034f, -0.23666671f, -0.07899792f, -0.12951279f, 
    0.09732603f, -0.00859652f, -0.02320243f, -0.18899131f, -0.11878454f, -0.11234984f, 0.18654561f, 0.07524069f, 
    -0.01985970f, 0.01908676f, -0.09121885f, 0.00577313f, 0.11193406f, -0.13245592f, -0.11199785f, -0.07538907f, 
    0.19446352f, 0.15495250f, 0.13193589f, 0.18491076f, 0.19797717f, -0.06287884f, 0.05692254f, -0.01732841f, 
    0.13416862f, 0.18149762f, 0.15987298f, -0.14835168f, -0.08520999f, 0.16890892f, 0.13059245f, 0.16528408f, 
    0.13240308f, 0.21736968f, 0.08219823f, 0.06810813f, -0.08283541f, 0.14495839f, 0.03165797f, -0.02970635f, 
    0.03751960f, -0.19607684f, -0.07329381f, 0.19121131f, 0.30591750f, 0.32605562f, 0.15254968f, -0.15205316f, 
    0.06332772f, -0.00487928f, -0.15036355f, 0.03408346f, 0.14567572f, -0.03152434f, 0.06050393f, 0.08957592f, 
    0.02512962f, -0.00700677f, 0.08055320f, -0.26665476f, 0.16084020f, -0.01844384f, -0.00876858f, -0.01203459f, 
    0.07089628f, -0.04570165f, -0.21883558f, -0.06667391f, -0.10371791f, 0.15269019f, 0.24021044f, 0.21698281f, 
    0.01505632f, 0.10262445f, -0.03278947f, -0.03630154f, 0.11595140f, -0.03352276f, 0.01836656f, -0.17574242f, 
    0.03669402f, -0.17808984f, -0.18225232f, -0.11302618f, -0.08126748f, -0.00410278f, -0.05745091f, -0.21385594f, 
    0.07316329f, 0.15492336f, 0.05698717f, 0.07257762f, -0.02544309f, 0.09505892f, 0.25578314f, -0.08099419f, 
    0.05764780f, 0.08300335f, 0.00714564f, 0.06776262f, 0.03142995f, 0.00631316f, -0.04188210f, -0.03318865f, 
    -0.29238072f, -0.01939877f, 0.10417083f, 0.05526195f, 0.05901464f, 0.11170759f, -0.04410939f, 0.02276158f, 
    -0.03126068f, 0.01106670f, 0.27204475f, -0.17014915f, -0.00670720f, -0.11374102f, -0.01492042f, 0.24922942f, 
    0.09119251f, 0.14162779f, 0.17781961f, -0.20075184f, 0.09769745f, 0.32228872f, 0.07776292f, 0.03566958f, 
    0.36388645f, -0.04211374f, 0.22308123f, 0.18030891f, 0.01623413f, 0.07981672f, 0.12901446f, 0.12340469f, 
    0.07902525f, 0.01617833f, 0.02627502f, 0.04344299f, -0.02329594f, -0.14808172f, -0.00200538f, 0.00121324f, 
    -0.07082321f, 0.06041079f, 0.22219205f, 0.04058835f, 0.11843963f, 0.16947646f, -0.13865913f, 0.09933729f, 
    0.13700789f, 0.05504885f, -0.01428849f, -0.00345184f, 0.06507413f, 0.04461982f, 0.11109968f, 0.03375029f, 
    0.15873562f, 0.35463607f, -0.04873040f, -0.21417692f, 0.08932900f, -0.01672119f, 0.08289705f, 0.08319566f, 
    0.06594329f, 0.04506915f, 0.13227983f, -0.12058962f, 0.00725202f, -0.07331052f, -0.04431108f, 0.03482360f, 
    -0.06849866f, 0.23968591f, -0.02273447f, 0.10528763f, 0.05845138f, -0.11652797f, 0.16899239f, 0.00707218f, 
    0.06336705f, 0.10803069f, -0.01077607f, 0.04757530f, -0.03348661f, 0.09719896f, -0.00667623f, 0.02488108f, 
    -0.03766767f, 0.12396814f, -0.05655122f, 0.12531129f, 0.19333823f, 0.18845698f, -0.16289294f, -0.15252164f, 
    0.15163375f, 0.03090880f, -0.05358077f, 0.13017875f, 0.19972104f, 0.12338161f, 0.01185199f, -0.03922456f, 
    0.04037558f, 0.02692638f, 0.01462393f, 0.00152777f, -0.03751449f, -0.11700130f, -0.06123003f, -0.01239859f, 
    0.02023901f, 0.21248914f, 0.01063906f, 0.16419771f, 0.07003897f, -0.02563716f, -0.11408056f, -0.06807982f, 
    -0.17230684f, 0.00938747f, 0.03487771f, -0.07400125f, -0.18308872f, -0.30758196f, -0.16628990f, -0.14691457f, 
    0.14489134f, -0.36409533f, 0.08041184f, 0.05884159f, 0.07574454f, 0.12651147f, 0.11860044f, -0.01744513f, 
    -0.02819506f, 0.03556078f, 0.03070881f, -0.06064573f, 0.04134512f, 0.00954850f, -0.03714280f, 0.03549719f, 
    0.00872391f, 0.03916247f, 0.00427723f, 0.02043664f, 0.04324393f, 0.02943911f, -0.02565469f, -0.02707295f, 
    -0.05936238f, 0.01575777f, -0.05271028f, -0.05348473f, -0.00659759f, -0.00836579f, -0.01656797f, 0.00521652f, 
    0.00746651f, -0.00707023f, -0.00175300f, -0.00575155f, -0.02376536f, 0.02248655f, 0.01386646f, -0.03823524f, 
    -0.04855245f, -0.01169514f, -0.03449525f, -0.03712432f, 0.01330684f, 0.00737686f, 0.03577925f, 0.03275521f, 
    0.03692704f, 0.02311203f, -0.03772939f, 0.01736249f, 0.00493845f, -0.02296664f, 0.04695096f, -0.00178786f, 
    -0.01487429f, 0.03925391f, 0.03443037f, -0.04869125f, 0.02055268f, -0.01448317f, -0.06385950f, 0.01712270f, 
    0.00838316f, -0.03707904f, -0.05125070f, 0.02820233f, 0.00009176f, -0.04802681f, -0.04988874f, -0.04289059f, 
    -0.05074805f, -0.02576860f, -0.04664369f, 0.03675829f, 0.03634484f, -0.04350900f, -0.02556879f, 0.00890178f, 
    0.01970274f, -0.04631405f, -0.00423034f, -0.00008173f, 0.04302495f, -0.04129410f, 0.03942806f, -0.06711054f, 
    -0.03897788f, 0.02531557f, 0.03771137f, 0.01432490f, -0.01437330f, -0.00215259f, 0.03575857f, -0.03706122f, 
    -0.05961091f, 0.03713475f, 0.02511441f, -0.05225933f, -0.04252991f, -0.05009074f, 0.02814087f, -0.02533464f, 
    0.00504725f, -0.01505936f, -0.05263351f, 0.00911571f, -0.02333314f, -0.04541405f, -0.00566929f, 0.01415754f, 
    0.01036390f, 0.00348599f, -0.04434565f, 0.00291482f, 0.00722769f, -0.02179387f, -0.06754420f, -0.00161798f, 
    0.01429265f, -0.03147347f, -0.04122888f, -0.01982355f, -0.03300644f, -0.06726411f, -0.00696939f, -0.06637042f, 
    -0.00837588f, 0.04087810f, -0.00345708f, 0.02001746f, -0.06609586f, -0.01543298f, -0.03157117f, 0.01241960f, 
    -0.02537040f, -0.01176353f, -0.02451005f, 0.02851337f, -0.03528599f, -0.01946876f, -0.00371227f, -0.04664849f, 
    0.04659093f, -0.06698991f, -0.00860207f, -0.03911361f, 0.01674820f, 0.01062449f, -0.01590229f, -0.05216810f, 
    -0.00097743f, -0.06475866f, -0.06605313f, -0.02236302f, 0.03446440f, -0.02742378f, 0.04375675f, 0.01389965f, 
    -0.03552962f, 0.03828567f, -0.01791466f, -0.01500733f, 0.01971588f, 0.02933991f, 0.02470449f, -0.02726415f, 
    -0.06236549f, 0.00172952f, -0.00842626f, 0.01620375f, -0.03880700f, 0.01879974f, -0.05860412f, 0.02335799f, 
    -0.06053548f, -0.01245236f, -0.01582123f, 0.00284782f, -0.01863431f, -0.01978300f, -0.02095543f, -0.00249950f, 
    0.01545232f, -0.04397674f, -0.00711783f, -0.00299579f, 0.02021721f, 0.03682718f, 0.03511344f, -0.03055151f, 
    -0.05057541f, 0.02929611f, -0.04082423f, -0.00098628f, -0.05088526f, -0.04294046f, -0.04597500f, -0.02562008f, 
    -0.01915161f, -0.04364472f, -0.05329860f, 0.00616826f, -0.06767499f, -0.03976252f, 0.01078723f, -0.03332616f, 
    -0.02624117f, -0.01053738f, -0.06873021f, 0.04392631f, 0.01954032f, -0.04380305f, 0.03263354f, -0.03890223f, 
    0.02118800f, -0.03374864f, 0.02070568f, 0.00960150f, 0.00445461f, -0.02018141f, 0.00933644f, 0.01955393f, 
    0.04291737f, -0.05089844f, 0.00266140f, -0.04144606f, -0.00940144f, 0.04019879f, -0.01512247f, 0.01241627f, 
    -0.01902302f, -0.01281972f, -0.02754313f, 0.00816329f, -0.01367501f, 0.04585336f, -0.02610354f, 0.01819483f, 
    -0.06300047f, -0.05985607f, -0.01632220f, -0.03851797f, -0.06831570f, -0.01088163f, 0.01009768f, 0.03144072f, 
    0.01725592f, -0.00485213f, 0.02628424f, 0.04524564f, -0.01092353f, 0.03713989f, -0.00941981f, -0.00629118f, 
    -0.00265038f, -0.02386131f, -0.04366760f, -0.00453540f, 0.01493617f, -0.06996733f, 0.00035960f, -0.05840670f, 
    0.04709997f, 0.03471559f, -0.01145080f, 0.02599815f, -0.04083294f, 0.03389581f, -0.03869645f, -0.06015516f, 
    0.02197645f, -0.01823884f, 0.01752770f, -0.03472559f, 0.04057875f, -0.01740482f, -0.06338269f, 0.00034540f, 
    -0.04940543f, -0.01680721f, 0.00662506f, 0.00280371f, -0.01226759f, -0.05835127f, -0.05967651f, -0.00638958f, 
    -0.05777780f, -0.02460315f, 0.03410058f, -0.02797448f, 0.03980415f, 0.00494017f, -0.02858920f, 0.00831330f, 
    -0.32435384f, -0.02241677f, -0.00424639f, -0.17093603f, -0.12464633f, -0.06598271f, 0.08287675f, 0.16468270f, 
    0.03544977f, 0.15486974f, 0.25602171f, 0.24664542f, -0.10713329f, -0.10440325f, -0.00755189f, 0.16013901f, 
    0.02937852f, 0.01302614f, -0.45866910f, 0.24226351f, 0.35039359f, 0.30844679f, 0.22065635f, -0.31244346f, 
    -0.02733761f, 0.05304371f, -0.16369523f, -0.16732208f, 0.36061388f, -0.34187090f, -0.18499041f, -0.17567319f, 
    -0.06206981f, -0.03772796f, -0.34431013f, -0.27867183f, 0.37227136f, 0.23631248f, 0.04570292f, 0.00383523f, 
    -0.11462600f, -0.01689711f, 0.13071628f, 0.03707951f, 0.12670375f, 0.36225113f, 0.22336568f, -0.14969999f, 
    0.13782983f, 0.03142566f, 0.12962860f, 0.06880189f, 0.10013659f, 0.18697377f, 0.23323992f, 0.07081038f, 
    0.22522271f, 0.16525555f, 0.08026071f, 0.02705211f, 0.16730006f, -0.44010982f, 0.13587649f, 0.35013112f, 
    0.02784593f, -0.17281547f, -0.35077155f, -0.04797376f, 0.10096607f, -0.07110754f, 0.00949459f, -0.01676695f, 
    -0.39266437f, -0.06236332f, -0.33464938f, -0.11291177f, 0.11992060f, -0.12093018f, 0.02086251f, -0.11711226f, 
    -0.05422113f, 0.12137898f, 0.15223783f, 0.01039701f, 0.07789493f, -0.01610555f, 0.14013939f, 0.08835310f, 
    -0.13490866f, 0.03572036f, -0.10400972f, 0.49354115f, -0.23842531f, 0.01874015f, 0.18020901f, -0.15114944f, 
    -0.15761580f, -0.01764171f, 0.08044805f, 0.26819476f, 0.08771557f, -0.04675497f, -0.00211245f, 0.05995585f, 
    0.36137807f, -0.06398261f, -0.13991195f, -0.04554941f, 0.15921751f, -0.04756012f, 0.03706384f, -0.30609959f, 
    -0.15306370f, -0.34548894f, 0.03993939f, -0.03070986f, -0.17020342f, 0.20970401f, 0.03312923f, 0.15373033f, 
    0.11456523f, 0.05976073f, 0.13526817f, 0.04728111f, -0.16147290f, -0.07944127f, -0.04430268f, -0.22686714f, 
    -0.06052190f, 0.22187696f, 0.09179907f, 0.10833609f, 0.14598036f, 0.04833629f, 0.06887637f, 0.24827287f, 
    0.20357749f, 0.15168953f, 0.01612135f, -0.08687621f, -0.06584549f, -0.14712429f, -0.00502005f, -0.06616576f, 
    0.00192190f, 0.10984086f, 0.28686976f, 0.01711186f, 0.18507643f, -0.02494737f, 0.09687898f, 0.13369669f, 
    0.00227143f, 0.20871732f, 0.09104195f, 0.25096825f, -0.33440831f, -0.16984899f, -0.08068433f, -0.00857125f, 
    -0.02522341f, -0.16129872f, 0.04908431f, -0.32249483f, -0.49682969f, -0.15644467f, -0.33456302f, -0.10103537f, 
    -0.02372318f, -0.14777587f, -0.08525701f, 0.29557091f, -0.42519814f, -0.11864106f, 0.09431829f, -0.29674774f, 
    0.18364885f, 0.01671057f, -0.02173525f, -0.07438561f, 0.16769376f, 0.06024886f, 0.16300549f, 0.06887264f, 
    0.05987602f, -0.05885324f, 0.06341609f, -0.00854645f, -0.06390061f, -0.07315728f, 0.03638154f, -0.38733882f, 
    -0.02894561f, -0.11468220f, 0.01307247f, -0.17803617f, -0.11702909f, -0.21280107f, -0.02632450f, 0.11516894f, 
    0.16748469f, 0.12926640f, 0.16023324f, -0.23546149f, 0.02605646f, -0.08339500f, 0.00817747f, 0.33739978f, 
    0.12192322f, 0.11924801f, 0.12909669f, -0.05598796f, -0.02477985f, 0.09592380f, -0.05298917f, 0.14099768f, 
    0.00306970f, -0.02209858f, 0.01860901f, 0.03813559f, 0.12943456f, -0.07598881f, 0.04844963f, -0.00859792f, 
    -0.01832715f, -0.17586353f, -0.47269163f, -0.50900936f, -0.10227282f, 0.18988627f, -0.13879631f, -0.05003092f, 
    -0.13775131f, -0.03113579f, 0.26323211f, 0.10600295f, 0.23484690f, -0.10428108f, -0.02778800f, -0.07565341f, 
    -0.06242687f, -0.00421751f, -0.07723140f, 0.11324313f, -0.05307775f, -0.40283898f, -0.11185122f, -0.13454045f, 
    -0.02043281f, 0.00356056f, 0.00958809f, -0.08650443f, 0.04369392f, 0.15681046f, 0.08818579f, -0.10706528f, 
    -0.12176736f, 0.18587618f, -0.10133819f, -0.01284808f, -0.21210857f, 0.09519335f, 0.13187504f, 0.26803216f, 
    0.04701568f, 0.03483151f, 0.02154887f, 0.02797759f, 0.07962797f, 0.02976736f, -0.09929764f, 0.17875829f, 
    0.14050482f, 0.13029225f, 0.00978185f, -0.04727930f, 0.14610197f, 0.00078899f, -0.02803352f, 0.28858310f, 
    0.19222042f, -0.37190527f, -0.13164999f, -0.06178717f, 0.12961216f, -0.04261410f, -0.13417263f, 0.21570764f, 
    0.55149746f, 0.03071844f, 0.08571876f, 0.09188984f, -0.11107982f, -0.10406835f, -0.08939075f, 0.05520554f, 
    -0.13659948f, 0.07068390f, -0.06835129f, -0.03054084f, 0.11917610f, -0.07236547f, 0.13189542f, -0.01582020f, 
    0.15994497f, -0.01884791f, 0.19841236f, -0.08673821f, 0.07711367f, 0.03935262f, -0.07793793f, 0.06632436f, 
    0.19726521f, -0.16009358f, 0.09626140f, 0.05211629f, 0.09902856f, 0.21883273f, 0.03251993f, -0.16405371f, 
    0.22481361f, 0.03367741f, 0.13261503f, 0.24267438f, 0.16140898f, 0.18499798f, 0.01266257f, -0.12511317f, 
    -0.04120127f, 0.14436466f, 0.19138229f, 0.18318436f, 0.21745890f, 0.30276346f, 0.13599631f, 0.12980421f, 
    0.00121233f, 0.12391355f, 0.02464715f, 0.14602025f, 0.17283623f, 0.11483093f, 0.06730960f, -0.28635034f, 
    0.16733411f, -0.00408149f, -0.04606043f, 0.02263279f, 0.16323583f, 0.02028513f, -0.05164165f, -0.15513115f, 
    0.03787950f, 0.24428496f, -0.00305127f, -0.01516547f, -0.01872822f, 0.02124440f, 0.09038101f, 0.40448236f, 
    0.34619531f, 0.05976524f, -0.12294225f, 0.00428827f, 0.04541161f, 0.20417750f, -0.14403518f, -0.02618703f, 
    -0.33387256f, -0.27330145f, -0.14994952f, -0.28311446f, -0.22102907f, 0.15760137f, -0.11174785f, 0.05210716f, 
    0.00514820f, -0.11891305f, -0.48010942f, 0.36425641f, -0.19582738f, -0.12115288f, -0.25854737f, 0.58290923f, 
    0.03382419f, -0.03176062f, 0.01007983f, -0.17886639f, 0.13292897f, -0.26488361f, -0.07938541f, 0.09585292f, 
    -0.08652365f, 0.09283224f, 0.05206858f, -0.00538257f, 0.04244609f, -0.28554940f, -0.18945275f, 0.27932397f, 
    0.07599748f, -0.01743654f, -0.04350022f, -0.06997854f, 0.15462708f, -0.30062032f, -0.21016306f, 0.14453031f, 
    -0.07146577f, -0.02106142f, -0.06114195f, -0.02120944f, -0.07272755f, -0.14954229f, -0.05196192f, -0.02505652f, 
    -0.28462875f, 0.05676885f, -0.24765599f, -0.01445431f, 0.12472710f, 0.25681648f, 0.07465877f, -0.20626229f, 
    0.10490623f, 0.16906439f, -0.00802366f, 0.19828951f, -0.00922739f, 0.01687535f, -0.25599536f, -0.05852531f, 
    -0.16779572f, -0.01729948f, -0.20549911f, 0.09845651f, -0.08244584f, -0.12017531f, 0.15348673f, 0.08107718f, 
    0.02653853f, -0.16639988f, 0.08110058f, 0.13454631f, 0.12176895f, -0.04113051f, -0.00312787f, -0.22347094f, 
    -0.37303704f, -0.05532095f, 0.18786508f, -0.05949099f, -0.19032472f, 0.07411456f, -0.18285926f, -0.05839039f, 
    -0.11161327f, 0.06697985f, 0.20577058f, 0.14117250f, 0.06009777f, 0.02251551f, 0.16531549f, -0.04344367f, 
    0.06140238f, 0.16597767f, 0.01633587f, -0.03253835f, -0.30993110f, 0.06299917f, -0.07827509f, -0.01398097f, 
    -0.15176882f, 0.02664275f, -0.08915186f, 0.01329596f, 0.02596025f, 0.25867125f, 0.14737538f, -0.20557246f, 
    0.03606128f, -0.00766735f, 0.05304026f, -0.11064017f, 0.01266931f, -0.02858287f, -0.08735988f, 0.10054448f, 
    -0.07904163f, -0.06407794f, -0.26898259f, -0.05910795f, 0.06231650f, 0.03862602f, 0.15431431f, -0.43822277f, 
    -0.37347454f, -0.09543329f, -0.14435749f, -0.07869368f, 0.09836503f, 0.10526706f, -0.23453130f, -0.52574307f, 
    -0.06388918f, -0.09344411f, -0.17228658f, -0.05041425f, -0.19411694f, 0.01592991f, 0.02548071f, 0.09103040f, 
    0.20030542f, 0.25352234f, -0.05557034f, -0.18283336f, 0.07745786f, 0.01442363f, 0.02605883f, -0.10255400f, 
    0.00317285f, -0.01896519f, -0.19581711f, 0.04671311f, -0.09460541f, 0.12977923f, -0.05389629f, -0.05278249f, 
    -0.11628655f, -0.05080630f, -0.08826605f, 0.22335556f, 0.22206971f, -0.26245266f, 0.00035938f, 0.00756978f, 
    -0.03165040f, 0.04233062f, -0.04517132f, 0.02955739f, 0.19053642f, 0.13486026f, -0.15094972f, 0.21733217f, 
    0.17020717f, -0.05179652f, 0.03259462f, -0.04771393f, -0.09453115f, -0.05687799f, -0.08430985f, -0.06870873f, 
    0.01880402f, 0.32454154f, 0.14031897f, -0.03831157f, -0.27296469f, -0.18540540f, 0.03219229f, -0.06056256f, 
    -0.16926563f, -0.14132844f, -0.05619263f, 0.07439258f, 0.10647133f, 0.17428282f, 0.04425228f, 0.10615426f, 
    0.28964940f, -0.03154558f, 0.02084265f, -0.07915200f, -0.15537181f, 0.09792537f, -0.02806522f, 0.09912729f, 
    0.05314685f, -0.61670101f, 0.04584171f, 0.01666926f, -0.12125263f, -0.05485709f, 0.06911323f, -0.09232948f, 
    -0.10961501f, 0.30193144f, -0.72676510f, -0.38364339f, -0.18121211f, 0.02422323f, -0.13027146f, -0.12067682f, 
    -0.13262938f, -0.00126951f, 0.20338430f, 0.04335390f, -0.13867767f, 0.29074708f, 0.19336769f, 0.25625062f, 
    0.16617803f, -0.05632677f, 0.13462646f, -0.14670922f, 0.01782485f, 0.09973168f, 0.08067648f, 0.09290802f, 
    -0.09856722f, -0.01566495f, 0.35632190f, -0.00990163f, -0.39768183f, -0.12968467f, -0.06893547f, -0.01743875f, 
    0.09383349f, -0.05213827f, -0.12374145f, -0.21346314f, -0.18329510f, -0.36786190f, -0.32024118f, 0.07259099f, 
    0.18551220f, 0.12164725f, -0.10023936f, 0.01632113f, 0.18706329f, -0.16167352f, 0.25263348f, 0.07607640f, 
    0.14745800f, 0.07177673f, -0.06947820f, -0.04384329f, 0.01376238f, 0.03790909f, 0.05796319f, 0.00021636f, 
    0.14589094f, 0.22145019f, 0.19128524f, 0.14419162f, 0.00151118f, 0.03476953f, 0.20173159f, -0.15031804f, 
    -0.10880638f, -0.02858008f, 0.14392497f, -0.03321767f, 0.06077409f, 0.10530681f, 0.18556955f, -0.07701883f, 
    0.07891485f, 0.19333340f, 0.09144201f, -0.01015742f, -0.17913494f, -0.07919789f, -0.19653007f, 0.12963246f, 
    0.03684558f, -0.12639764f, -0.14454040f, -0.26331303f, -0.22034195f, 0.17186114f, 0.11636916f, 0.22425610f, 
    0.02781937f, 0.00072206f, 0.06039619f, 0.20492257f, 0.07917585f, -0.16127038f, 0.08655132f, -0.02063898f, 
    0.07114881f, 0.21920498f, 0.01735168f, 0.07910766f, 0.04702875f, -0.34883949f, -0.28460288f, -0.16031621f, 
    0.02329321f, 0.04211481f, -0.06046605f, -0.13689627f, -0.10364782f, 0.15503408f, 0.33168516f, 0.10943748f, 
    -0.09436672f, -0.01064283f, 0.08116553f, 0.13032663f, 0.17646459f, 0.15258454f, -0.50554919f, -0.43540952f, 
    0.02414024f, 0.17369299f, 0.06330328f, 0.14264295f, 0.08577086f, -0.10897494f, -0.00040705f, -0.06319185f, 
    0.26301894f, 0.14671247f, -0.12452149f, -0.04776659f, 0.03169720f, -0.04168192f, 0.03825366f, 0.12870044f, 
    0.27180490f, 0.21867104f, 0.09928309f, -0.11415745f, 0.04253779f, 0.01654014f, 0.18584494f, -0.00713343f, 
    -0.09510964f, 0.16224572f, 0.24934275f, 0.04307227f, -0.13756004f, -0.04285495f, 0.00090315f, 0.05261235f, 
    -0.15052022f, -0.05332420f, 0.04672014f, -0.67903388f, -0.60883331f, -0.42786330f, 0.04713462f, 0.21854475f, 
    -0.06362410f, -0.03187261f, -0.14439730f, 0.39855778f, -0.41340846f, -0.21628293f, -0.11481804f, 0.39143634f, 
    0.20270918f, 0.10195828f, 0.05561612f, 0.17728581f, 0.23295473f, 0.19059910f, 0.00084568f, -0.19289200f, 
    -0.08291539f, -0.01391030f, 0.04483120f, 0.08917249f, -0.15286827f, -0.16199403f, -0.36994469f, -0.65531170f, 
    -0.13499089f, 0.04324926f, 0.10732935f, 0.02345694f, -0.04196719f, 0.00058444f, 0.05793718f, 0.12704302f, 
    -0.07832418f, 0.06368499f, 0.09727260f, 0.13039744f, -0.00955771f, 0.02624932f, -0.22519922f, 0.15481752f, 
    0.06940595f, 0.19104591f, -0.11925331f, -0.16993898f, -0.05329426f, 0.12859590f, 0.01095036f, 0.14966877f, 
    -0.08799812f, -0.15846822f, -0.04830956f, -0.07766490f, 0.20612210f, -0.06393548f, 0.02467257f, -0.01845150f, 
    -0.14861140f, -0.16908649f, -0.28247955f, -0.60138261f, 0.13931446f, 0.12642699f, 0.19134712f, 0.15941484f, 
    0.06546706f, -0.12551999f, 0.09550130f, 0.09544948f, 0.12010375f, -0.10003248f, -0.03948814f, -0.10597008f, 
    -0.03705716f, -0.08795352f, 0.04885988f, 0.30253264f, -0.46837938f, -1.31164885f, -0.21959127f, -0.05839978f, 
    0.20420843f, -0.00772901f, -0.09306989f, -0.08244967f, 0.09323417f, -0.15687941f, -0.32569292f, -0.03775347f, 
    0.01627358f, 0.01265420f, 0.03779139f, -0.08807931f, 0.01842817f, -0.07716015f, 0.06266053f, 0.07198267f, 
    0.01066115f, -0.12028582f, -0.00448121f, 0.10250854f, 0.16259569f, 0.26247978f, -0.04934234f, -0.26100183f, 
    -0.10602744f, 0.06530014f, 0.13352545f, -0.08539382f, 0.02754601f, -0.16040072f, -0.00942024f, -0.13248996f, 
    0.06642038f, -0.07615214f, 0.08929507f, -0.09364267f, 0.05631988f, 0.04874343f, 0.19454111f, 0.02389073f, 
    -0.06508793f, 0.23944587f, 0.25370798f, 0.01041145f, 0.12655877f, 0.15165654f, -0.05435667f, -0.02139859f, 
    -0.05665601f, 0.01783330f, -0.01622561f, 0.25787327f, 0.06192544f, 0.18567337f, -0.08069532f, -0.05503865f, 
    -0.02065613f, 0.02329370f, 0.51456559f, -0.16265939f, 0.05144206f, 0.01366184f, 0.00959182f, -0.33210188f, 
    -0.05703210f, 0.14684074f, -0.08070582f, 0.20210458f, 0.22089197f, 0.28691080f, 0.20562096f, 0.36583397f, 
    0.10539031f, 0.05556270f, -0.16182178f, -0.06818498f, -0.09060413f, -0.01269341f, 0.16537252f, -0.19510217f, 
    -0.18248302f, -0.14568086f, -0.00220827f, -0.02073157f, 0.24954845f, -0.02809192f, 0.00187233f, 0.14826114f, 
    0.22802451f, 0.04046498f, -0.14026517f, -0.06010317f, -0.02447260f, -0.01760697f, 0.02186214f, -0.21383637f, 
    0.07392197f, 0.03875502f, 0.03200978f, -0.02238186f, -0.07577378f, -0.00442022f, -0.10416219f, 0.16017689f, 
    0.09942638f, -0.12766121f, 0.02333946f, 0.06359301f, -0.11525819f, 0.02553032f, 0.08044256f, 0.08933039f, 
    0.02118132f, -0.01696589f, 0.27040792f, 0.11445674f, -0.04252716f, 0.14716363f, -0.04326789f, 0.15579356f, 
    -0.23820984f, -0.07474639f, -0.03816444f, -0.08586147f, -0.03137548f, 0.02530049f, -0.14551938f, 0.21760838f, 
    -0.00470442f, -0.23942211f, 0.21763511f, 0.44209030f, 0.28385445f, 0.20204902f, -0.10828647f, -0.00911555f, 
    0.20787835f, 0.42503697f, 0.01747345f, -0.22901006f, 0.03176341f, -0.12824646f, 0.01266273f, -0.13904762f, 
    -0.20095000f, 0.07410727f, 0.12127368f, -0.13279520f, 0.21417406f, 0.02360868f, 0.00242307f, 0.02694743f, 
    0.03485733f, 0.06782939f, 0.00561872f, -0.06031784f, 0.14640559f, -0.12349211f, -0.19562405f, -0.10543329f, 
    0.05568054f, 0.02517524f, -0.09747277f, -0.01637598f, -0.19490090f, -0.21341828f, -0.04173763f, 0.16907783f, 
    0.10607096f, -0.01373796f, -0.26799780f, -0.23694038f, 0.04801527f, -0.10936727f, 0.17973323f, 0.19926076f, 
    -0.14516583f, -0.15773284f, -0.10898647f, -0.07665213f, 0.17787173f, 0.03765351f, 0.13415346f, -0.30110928f, 
    0.15122539f, -0.17419337f, -0.04168114f, -0.00727771f, 0.05813923f, -0.06956526f, 0.16564064f, 0.13610238f, 
    0.26530489f, 0.06901083f, 0.01663182f, -0.07416864f, 0.10838228f, 0.04058294f, 0.08993153f, 0.04930864f, 
    0.11516505f, -0.02936709f, 0.15786232f, 0.49413547f, 0.06726022f, -0.15230089f, -0.10318093f, 0.18397032f, 
    -0.03719989f, -0.05799875f, -0.08342300f, -0.10160132f, 0.26714504f, 0.08730396f, -0.07478110f, -0.11775590f, 
    -0.03105327f, -0.05205825f, 0.25893751f, -0.08346394f, 0.08080029f, 0.02322480f, 0.03514464f, 0.01385310f, 
    -0.04676155f, 0.04913659f, -0.01728957f, 0.17826916f, -0.14852378f, -0.01108655f, 0.17574243f, 0.07355236f, 
    -0.15551223f, -0.06998280f, 0.22192524f, -0.14355099f, 0.11907975f, -0.12234264f, 0.08797800f, 0.11465939f, 
    -0.06539387f, 0.00004140f, 0.02308492f, -0.12626994f, -0.14523526f, 0.20665216f, -0.08728989f, 0.09613173f, 
    -0.03603924f, -0.01413745f, 0.00679264f, -0.08627838f, -0.20889939f, 0.03794945f, -0.03992772f, -0.12183648f, 
    0.16360325f, 0.13363795f, 0.11485393f, -0.07868443f, 0.00559209f, -0.01894486f, 0.22074533f, 0.13370898f, 
    0.23156197f, 0.22108030f, 0.36000729f, 0.52396870f, 0.11841870f, -0.05208340f, -0.12927052f, 0.10361245f, 
    0.00935801f, 0.14109468f, -0.02932864f, -0.14438321f, -0.11663526f, -0.07007655f, -0.18206730f, 0.08905497f, 
    0.06261937f, 0.23417525f, -0.15881853f, -0.21788190f, 0.29961759f, 0.26056376f, -0.07263983f, -0.17001784f, 
    -0.01868548f, 0.17189507f, 0.12997359f, -0.06188143f, 0.12626415f, 0.16188335f, -0.12681171f, 0.22949764f, 
    -0.04310060f, 0.05019595f, -0.12349563f, -0.08589868f, 0.03320115f, -0.02877026f, -0.06697989f, -0.12108120f, 
    -0.05532727f, -0.02243928f, 0.05632970f, -0.33373910f, 0.04834274f, -0.37556165f, -0.02304914f, 0.01009752f, 
    -0.13104399f, 0.07320783f, -0.04013926f, -0.28661093f, 0.05947146f, 0.21605183f, 0.12328139f, -0.01160668f, 
    0.08721741f, 0.04723036f, 0.09632576f, 0.06958621f, -0.13767201f, 0.20074068f, -0.00297272f, -0.08847428f, 
    0.04856837f, 0.00557154f, -0.02246881f, -0.01679572f, -0.03768796f, 0.02893601f, -0.05904122f, -0.04203111f, 
    -0.00927557f, -0.01204589f, -0.04100722f, 0.02332037f, 0.03179046f, -0.02345117f, -0.02831658f, -0.04814181f, 
    -0.05016096f, -0.02074108f, 0.03404951f, -0.05009375f, -0.06047587f, -0.05693971f, 0.01267646f, -0.03057808f, 
    -0.02743476f, -0.04795954f, -0.04575789f, 0.01723092f, -0.01575431f, -0.02569291f, -0.04538579f, 0.04377672f, 
    0.02363926f, -0.05860071f, -0.02710377f, 0.00447962f, 0.05227560f, -0.00303318f, 0.02855954f, 0.00366585f, 
    -0.04160064f, 0.04877124f, -0.01813556f, -0.06119358f, 0.00642212f, -0.00014118f, 0.04750220f, 0.03991216f, 
    0.04247006f, 0.03506770f, 0.03666138f, -0.00343711f, -0.02893269f, -0.06351630f, -0.00091881f, -0.04988611f, 
    -0.04525581f, -0.02351554f, -0.06468870f, -0.05314384f, 0.01988047f, 0.03788156f, -0.02099597f, -0.02264043f, 
    0.02340183f, 0.04191102f, 0.02514209f, 0.02913133f, 0.04254146f, 0.03071856f, -0.05902401f, -0.02258051f, 
    0.04606367f, -0.05357564f, -0.01966294f, -0.03803594f, 0.04409140f, 0.01029174f, -0.03826244f, -0.02593539f, 
    0.03468189f, -0.04654073f, -0.03487393f, -0.05685195f, -0.00318142f, -0.03017646f, 0.03681985f, -0.01932382f, 
    0.03015886f, 0.00697894f, 0.04968809f, -0.05673010f, -0.05836152f, -0.04502802f, 0.04307973f, -0.03298366f, 
    0.04745146f, 0.01437194f, -0.03900348f, 0.00350182f, 0.03684202f, 0.00758821f, -0.03672864f, -0.06849196f, 
    -0.04620920f, 0.00746681f, 0.04538578f, 0.03713354f, 0.04029105f, 0.00078110f, 0.03072523f, -0.01727344f, 
    0.04500381f, -0.02571161f, -0.04492210f, 0.02624603f, -0.02553275f, -0.03795518f, -0.05638709f, 0.03571851f, 
    0.00216641f, 0.04582044f, 0.01638369f, -0.00858948f, -0.04563766f, -0.05429048f, 0.02987098f, -0.04775628f, 
    -0.00339452f, -0.04604486f, -0.00806268f, -0.00467729f, -0.04903169f, -0.01080572f, 0.04491227f, -0.02317791f, 
    -0.03455681f, 0.03068346f, 0.03764670f, -0.04509877f, -0.01823094f, 0.00189189f, -0.00833552f, -0.00449475f, 
    -0.04954918f, -0.05026426f, -0.03737544f, -0.01520585f, 0.03004546f, -0.01686134f, -0.04469185f, 0.03055775f, 
    -0.02336523f, 0.01085160f, 0.02304736f, -0.04449593f, 0.00550366f, -0.00664556f, -0.01158157f, -0.03779706f, 
    -0.01847492f, 0.02651196f, -0.06035469f, -0.03889452f, -0.03721736f, -0.00009491f, -0.02212320f, 0.02204304f, 
    -0.04190295f, -0.00147257f, 0.00569081f, 0.02880047f, 0.02589068f, 0.04766992f, -0.02159782f, -0.03548274f, 
    -0.04120224f, -0.03282829f, -0.01794172f, 0.00519485f, 0.04365271f, -0.01342837f, 0.04471713f, 0.03088186f, 
    -0.01092584f, -0.05155238f, 0.02218823f, 0.04310513f, 0.00613649f, 0.00019905f, -0.06448738f, -0.03213017f, 
    0.00576473f, 0.01200751f, -0.04147742f, 0.00314999f, 0.04550908f, 0.01701878f, 0.02790662f, 0.01208569f, 
    0.00472699f, 0.01383546f, 0.03298099f, -0.04022368f, 0.05109929f, 0.00018803f, 0.02111683f, 0.02961038f, 
    0.02002985f, -0.00996979f, -0.05490260f, 0.02345522f, -0.01811121f, 0.04336730f, 0.00891527f, -0.04436249f, 
    0.04749453f, -0.06378716f, 0.00590312f, -0.02375704f, -0.05518855f, -0.03619012f, 0.03937869f, -0.02412792f, 
    -0.03162002f, -0.04053672f, -0.00132890f, -0.03730027f, -0.03908833f, -0.02502809f, -0.01376917f, -0.03489628f, 
    -0.00400658f, -0.01983974f, -0.02725533f, 0.01781547f, -0.05393653f, -0.00253430f, 0.04301877f, -0.05925761f, 
    0.00789889f, 0.03666266f, 0.03143972f, 0.02804743f, 0.00381381f, 0.02229627f, -0.01565209f, 0.02894470f, 
    -0.01385694f, 0.00569502f, 0.00594357f, -0.03154495f, 0.00492235f, -0.01637700f, 0.03031898f, 0.03598094f, 
    -0.06179187f, 0.03301902f, -0.01100278f, -0.06300778f, -0.04339346f, -0.00184860f, 0.04127221f, 0.04763637f, 
    -0.03727614f, -0.00291537f, -0.04135928f, 0.03501489f, -0.02801983f, 0.02686505f, -0.04478544f, -0.00552656f, 
    -0.06060601f, 0.00032308f, 0.02512744f, -0.01540800f, 0.01833601f, -0.01109775f, -0.02092582f, -0.05367896f, 
    0.03433371f, -0.04670377f, 0.04044822f, -0.06361671f, -0.03592635f, 0.02838365f, 0.01397242f, 0.05176092f, 
    0.02608398f, -0.01919688f, 0.04851355f, -0.04085205f, -0.04858141f, -0.02695525f, -0.02033429f, -0.03213864f, 
    -0.03183814f, -0.05181245f, 0.03334160f, 0.02337528f, -0.05040452f, -0.04873187f, -0.02470373f, -0.04745245f, 
    -0.00203346f, -0.00308852f, -0.00307863f, -0.03553412f, -0.01997970f, -0.05613523f, -0.06562431f, -0.01285079f, 
    -0.04029251f, 0.01980377f, -0.04432270f, 0.02482998f, -0.05982668f, -0.00697138f, -0.04236109f, 0.03441834f, 
    0.02745803f, 0.00619138f, -0.05601939f, -0.06221133f, -0.01184956f, 0.03096809f, -0.05315651f, 0.00174286f, 
    -0.04753273f, 0.03664232f, 0.03819843f, -0.01846338f, 0.03901241f, 0.00300275f, 0.03186990f, 0.03660199f, 
    0.01257608f, -0.03400807f, -0.06265000f, 0.02997658f, -0.05403237f, 0.01752669f, -0.03265411f, -0.04827248f, 
    -0.02785926f, -0.00223326f, 0.00823380f, -0.03546108f, -0.05098864f, -0.03599890f, -0.06220110f, -0.05950495f, 
    -0.00709003f, 0.03636483f, -0.06452531f, -0.00848321f, -0.03415824f, -0.04424288f, -0.04674793f, 0.01192540f, 
    -0.05513433f, -0.03586869f, 0.01735765f, -0.06138551f, -0.04682909f, -0.04240638f, 0.03717251f, -0.06384385f, 
    0.04627344f, -0.02676870f, 0.03090381f, -0.00488358f, 0.01473967f, -0.02991327f, 0.00734800f, -0.00483963f, 
    0.03730488f, -0.05401114f, -0.05400597f, 0.03636049f, -0.01757040f, 0.00424276f, -0.00940335f, -0.03542252f, 
    0.01703019f, 0.01625766f, -0.00411949f, -0.03704697f, 0.05265848f, -0.04939757f, 0.00742699f, -0.04115777f, 
    -0.00044069f, -0.05380100f, -0.03941660f, -0.03203885f, -0.00646803f, -0.03348428f, 0.04433127f, -0.05446433f, 
    -0.01207789f, 0.04352619f, -0.05007308f, 0.01448615f, 0.02160110f, -0.04100673f, -0.04305451f, 0.03803144f, 
    -0.04016982f, -0.05772536f, -0.06439365f, -0.04396921f, -0.00937814f, 0.03400491f, 0.00066472f, -0.02244691f, 
    0.02899802f, -0.04287282f, -0.03639627f, -0.02908900f, 0.01480029f, 0.01233811f, 0.04370382f, 0.01087281f, 
    0.03806742f, 0.01391194f, -0.00612730f, -0.00744928f, 0.02726065f, 0.00223181f, 0.03667308f, -0.00357940f, 
    -0.00272465f, -0.01981009f, -0.01080814f, -0.06089718f, 0.03943041f, -0.04442893f, -0.04330139f, 0.02370109f, 
    0.02184916f, -0.04187410f, -0.03884499f, -0.04926157f, 0.03190286f, 0.04954835f, -0.03424507f, -0.05246942f, 
    -0.03343190f, 0.02719602f, -0.00359910f, -0.01817508f, 0.03759212f, -0.02453658f, -0.02087208f, -0.05769916f, 
    -0.01175840f, -0.00492392f, -0.03051440f, 0.03106536f, -0.05745086f, 0.00254517f, 0.02846850f, -0.02775209f, 
    -0.01515479f, 0.00120563f, 0.00950747f, -0.05525024f, 0.03459411f, 0.03703875f, -0.03464594f, 0.01214057f, 
    0.01245459f, 0.03271416f, 0.00015410f, -0.05616619f, -0.04035657f, -0.06602667f, -0.05072517f, -0.03114579f, 
    -0.02759746f, 0.02909350f, 0.01078893f, 0.04997355f, -0.01298708f, -0.06440137f, -0.01123997f, -0.01080193f, 
    0.05757265f, 0.01643294f, 0.04056793f, -0.04831601f, -0.03963679f, 0.03777844f, 0.02751114f, -0.01912019f, 
    -0.02703626f, -0.04534435f, -0.04098593f, -0.01570658f, -0.04263162f, -0.03373838f, -0.01484207f, -0.04351586f, 
    -0.01082164f, 0.01564615f, -0.01840776f, -0.00915088f, -0.05618382f, -0.00643989f, -0.04522211f, -0.01747437f, 
    0.03246523f, -0.04726891f, 0.03505977f, 0.00557835f, 0.03041245f, 0.00803209f, 0.03834530f, -0.02845948f, 
    -0.00282964f, 0.03058844f, -0.03463469f, -0.03356697f, -0.03574288f, -0.05393845f, -0.04692245f, -0.04456896f, 
    0.05130906f, 0.01142820f, -0.05437283f, -0.06044009f, -0.01314210f, -0.02117927f, 0.05029834f, 0.04592967f, 
    -0.05011911f, -0.01917271f, 0.01785508f, -0.04545809f, 0.03987825f, 0.03650372f, -0.05850028f, 0.04306978f, 
    -0.03854676f, -0.01046311f, -0.03876429f, -0.00302038f, -0.05701943f, -0.01019397f, -0.01290677f, -0.00985067f, 
    -0.00052327f, -0.01404290f, -0.03355569f, 0.02501334f, 0.03108984f, 0.04000804f, 0.01540608f, -0.03113910f, 
    0.01153064f, 0.02532068f, 0.01316763f, 0.03759916f, 0.05788665f, 0.00490520f, -0.05056899f, -0.00276982f, 
    -0.00890867f, -0.00366235f, -0.02939659f, -0.04488251f, 0.02337850f, 0.00835316f, 0.01903955f, 0.03383908f, 
    -0.66030294f, 0.27043205f, 0.28798893f, -0.37942079f, -0.36259684f, -0.15152167f, 0.10845872f, 0.27542534f, 
    0.11144132f, 0.16319181f, 0.16307373f, 0.31811121f, -0.20515178f, -0.06657282f, -0.28294748f, 0.02527961f, 
    -0.05697703f, 0.04071403f, -0.29139540f, 0.30400953f, -0.77166373f, 0.08647326f, -0.42118999f, 0.31468555f, 
    0.13604081f, -0.05050834f, 0.09262037f, -0.04483852f, -0.20689321f, 0.39108610f, 0.10144685f, 0.00050326f, 
    -0.16394523f, 0.05989238f, -0.01800523f, 0.07523771f, -0.40293407f, 0.06145042f, 0.11563273f, 0.07583173f, 
    0.08967030f, -0.20133178f, 0.01785485f, 0.05266967f, -0.20632057f, -0.22696020f, -0.04305231f, 0.14545244f, 
    0.03889044f, -0.02482051f, -0.13968356f, -0.03617566f, 0.00748606f, -0.11051071f, -0.05245650f, 0.28527886f, 
    -0.17739993f, -0.04370481f, -0.07457350f, 0.06329270f, 0.18967052f, -0.11055050f, 0.08628409f, 0.13858528f, 
    -0.45847839f, 0.16004576f, 0.10274209f, 0.03550727f, -0.00303294f, 0.06570774f, 0.06817692f, 0.04094866f, 
    -0.35776505f, -0.09367684f, 0.38491821f, 0.17567995f, 0.11840473f, -0.11599057f, -0.01281593f, 0.09058787f, 
    0.01975723f, 0.27549249f, 0.32294604f, -0.05204831f, 0.08134964f, -0.02852921f, -0.21642989f, 0.06779676f, 
    -0.07799441f, -0.05566938f, 0.11462599f, -0.19002381f, -0.47293755f, -0.06804567f, -0.01906147f, 0.50907463f, 
    0.12441273f, -0.12851375f, 0.00953224f, -0.50967211f, -0.12212946f, 0.20948671f, 0.02659941f, 0.16141334f, 
    -0.08495860f, -0.10036331f, 0.09048001f, -0.12257339f, -0.52371794f, -0.08383787f, -0.66691113f, -0.11455742f, 
    -0.19115508f, -0.15051478f, -0.03319702f, 0.02104318f, 0.03294142f, 0.08054733f, 0.03565966f, -0.00031256f, 
    0.08465172f, 0.06601097f, -0.10754671f, 0.00636912f, 0.33295858f, 0.06767812f, -0.26207072f, -0.07963873f, 
    0.00936764f, -0.01116945f, 0.13115500f, -0.09601421f, -0.04039850f, 0.03473051f, -0.04952877f, -0.08084443f, 
    -0.20293421f, 0.18635926f, 0.11629879f, -0.13297424f, -0.16886671f, 0.10476062f, 0.07141531f, 0.29962903f, 
    0.49879631f, 0.22089648f, 0.03053208f, 0.13007602f, -0.02455166f, 0.09868409f, 0.04833276f, 0.18251970f, 
    0.02679610f, -0.15108153f, -0.08878491f, -0.05251693f, -0.01891453f, -0.14841464f, -0.26492512f, -0.03821070f, 
    0.22490692f, 0.10974064f, 0.17345487f, -0.19639543f, 0.04308348f, -0.02020571f, 0.06911483f, -0.00649569f, 
    0.02101157f, 0.08731032f, 0.15840851f, 0.28590247f, -0.21987028f, -0.25748914f, 0.04226961f, 0.07141671f, 
    0.15185256f, -0.06418496f, -0.04560706f, 0.06859104f, 0.12995228f, 0.47977784f, 0.10002957f, -0.06294939f, 
    -0.23258045f, -0.28145778f, 0.06686740f, 0.01965646f, 0.01795884f, 0.08643059f, -0.09770338f, 0.11336887f, 
    -0.04108152f, 0.33002949f, -0.17748986f, -0.03374492f, 0.08176295f, 0.20086761f, -0.07349312f, 0.55777323f, 
    -0.13030270f, -0.05669115f, -0.19715972f, 0.05895364f, -0.08103149f, -0.25892559f, 0.02667405f, 0.38343149f, 
    -0.01453228f, 0.42604882f, 0.05499317f, -0.21189399f, -0.05755367f, 0.10578527f, 0.08302419f, 0.11635806f, 
    -0.27905673f, -0.53052896f, 0.21550749f, 0.11892582f, 0.07586973f, 0.22647659f, 0.03943851f, 0.09770954f, 
    -0.00855993f, -0.43840539f, 0.25999948f, -0.09479938f, -0.07539019f, 0.07489840f, 0.30921981f, 0.10456086f, 
    0.04475340f, -0.01741652f, -0.35170865f, -0.03344351f, -0.05306679f, -0.17751098f, -0.07780869f, -0.32952356f, 
    -0.09805761f, -0.18698549f, 0.01582929f, -0.14649461f, -0.05577505f, 0.12723793f, -0.03136479f, 0.11396322f, 
    -0.15794826f, 0.13102518f, 0.17355382f, 0.01540899f, -0.53551441f, -0.00840263f, -0.16934802f, 0.00416737f, 
    0.00567656f, 0.00716411f, -0.07689003f, -0.20667827f, -0.05457833f, -0.36123699f, 0.07379635f, 0.21115088f, 
    0.03457013f, -0.05572610f, -0.15636744f, 0.02075231f, 0.02812007f, 0.06025391f, -0.09515746f, 0.09695891f, 
    -0.27591971f, 0.16275370f, 0.05850723f, 0.15547457f, 0.07917688f, 0.13554934f, -0.02536397f, -0.47201571f, 
    -0.17050569f, 0.56309646f, -0.09990568f, -0.08245499f, -0.27226532f, -0.08837596f, 0.11917248f, 0.16943131f, 
    0.21613455f, 0.21192156f, -0.37091357f, 0.03782130f, 0.11563211f, 0.09780966f, 0.12787794f, 0.00024290f, 
    -0.06727277f, 0.24075313f, -0.09226170f, -0.37634388f, 0.11914136f, 0.22009344f, 0.06738409f, 0.10306398f, 
    0.00321527f, 0.07732046f, 0.07392883f, 0.14931449f, 0.27239674f, 0.04379143f, 0.18561581f, -0.07045452f, 
    -0.24314538f, -0.12406074f, 0.24773559f, 0.07828693f, 0.08887883f, -0.08467363f, 0.00881275f, 0.13663141f, 
    0.11147166f, 0.17577969f, 0.07967173f, -0.02977645f, -0.15086259f, -0.11966550f, -0.00084599f, -0.39087254f, 
    -0.05206624f, 0.00862921f, 0.14375925f, -0.00759808f, 0.08366182f, 0.04576435f, 0.07893913f, 0.14754204f, 
    0.00320984f, 0.08154195f, -0.03769568f, 0.00468923f, 0.16789059f, 0.05788618f, -0.09899453f, -0.31604469f, 
    -0.21924877f, 0.04626166f, 0.05582912f, 0.03858856f, 0.10420875f, -0.03967135f, -0.03554863f, 0.04892318f, 
    0.09813359f, -0.18189885f, 0.13924569f, 0.08069898f, 0.03564601f, -0.02470363f, 0.03970644f, 0.03087940f, 
    0.00674077f, -0.05487393f, 0.11943933f, 0.02617152f, -0.10509793f, 0.00746711f, -0.02672139f, -0.09039310f, 
    -0.21409701f, -0.18602921f, -0.07951521f, -0.16382147f, 0.05822030f, 0.00335533f, -0.20025563f, -0.06587117f, 
    -0.01075824f, 0.09803515f, -0.19954866f, 0.41712436f, 0.02123645f, -0.09430869f, 0.17657635f, 0.04026642f, 
    -0.05895854f, 0.03078259f, 0.18942609f, -0.18244764f, -0.05082469f, -0.16645890f, 0.08798487f, -0.12751170f, 
    0.05732764f, -0.05636939f, 0.00953567f, -0.10727160f, -0.09069853f, 0.19098672f, 0.09765507f, 0.27461720f, 
    0.11345802f, 0.03560934f, 0.05315179f, -0.11571433f, 0.00757472f, -0.23289281f, -0.26038697f, -0.07515404f, 
    0.14015871f, 0.08176521f, 0.01083582f, -0.14330694f, -0.10214268f, -0.15586914f, -0.04520461f, 0.32446492f, 
    0.08373047f, 0.02721520f, 0.07976402f, 0.07461639f, 0.16258739f, -0.01709699f, 0.01592881f, 0.08820817f, 
    -0.15431954f, 0.00375407f, 0.08549102f, 0.14884703f, -0.01531037f, -0.09547558f, -0.07557299f, -0.04355579f, 
    -0.08966671f, -0.15455599f, -0.04703869f, -0.02540568f, 0.04376214f, -0.03314370f, -0.05219951f, 0.00760575f, 
    0.16093118f, -0.10028188f, -0.21933529f, -0.11053614f, 0.28166220f, 0.11076978f, 0.12853977f, -0.14840202f, 
    0.02393723f, -0.06584755f, -0.24558197f, 0.29885420f, 0.01584833f, 0.10466436f, 0.16399166f, -0.02624463f, 
    -0.08268359f, -0.09056961f, -0.30501798f, 0.05115132f, 0.26541930f, 0.11392146f, 0.03428115f, 0.10182441f, 
    -0.02745478f, -0.11334071f, 0.06335839f, -0.00818771f, -0.05056318f, -0.15407479f, -0.04273611f, 0.07241267f, 
    -0.02979421f, -0.08382857f, -0.12939142f, 0.11035984f, -0.05100993f, -0.05136307f, -0.03270820f, 0.09231274f, 
    0.09318360f, -0.01016196f, 0.01179533f, -0.25336462f, -0.15045041f, -0.37076315f, -0.11783068f, 0.06157598f, 
    0.05634086f, -0.00065705f, 0.10626925f, -0.18723041f, -0.17045638f, 0.21428673f, 0.09090868f, -0.14262359f, 
    0.01243870f, -0.16507198f, 0.19856565f, -0.03116233f, 0.10561050f, -0.01525970f, -0.18074253f, 0.04775140f, 
    0.08729108f, 0.15832011f, 0.28677446f, 0.04015820f, -0.04060683f, 0.00460174f, -0.08885317f, 0.06561102f, 
    0.21611339f, -0.09687319f, 0.25060293f, 0.54423386f, 0.09677840f, 0.26058358f, -0.08697273f, -0.08001712f, 
    -0.05879150f, -0.08959369f, -0.02173216f, -0.17086637f, -0.22156438f, -0.00827563f, -0.04750886f, 0.05905667f, 
    -0.07547022f, 0.00224381f, -0.02940108f, -0.10849858f, 0.18383986f, 0.00412365f, 0.11417682f, -0.06629051f, 
    -0.19918692f, -0.06436410f, 0.03910629f, -0.18100257f, -0.07439623f, 0.14910530f, 0.18078491f, 0.34214988f, 
    0.04702909f, 0.07813390f, -0.03181501f, -0.07714055f, -0.05350013f, 0.03341905f, 0.10045434f, 0.10617120f, 
    0.03533792f, 0.02295589f, -0.05476397f, -0.24063511f, -0.09709614f, -0.44040853f, -0.05252642f, 0.02354233f, 
    -0.09604547f, -0.11489771f, 0.06512659f, -0.17950454f, -0.04543243f, 0.10355945f, 0.08636700f, 0.24414164f, 
    -0.21042854f, 0.10158810f, 0.08214922f, 0.07873054f, 0.10041182f, 0.17971058f, -0.04776959f, -0.08098151f, 
    -0.40641847f, 0.13938087f, 0.22532953f, -0.15311684f, -0.02425911f, -0.18287806f, -0.02518809f, -0.04901028f, 
    0.02545224f, -0.03061515f, 0.19639666f, -0.12540451f, -0.09516228f, 0.00446412f, -0.11019478f, -0.07661839f, 
    -0.01834594f, 0.11562823f, -0.68084931f, -0.51754552f, 0.37380919f, -0.14008681f, -0.15793718f, 0.10610056f, 
    0.04744672f, 0.04184631f, 0.07518408f, -0.02048893f, -0.07605205f, -0.08134729f, -0.17369767f, 0.00180690f, 
    -0.25934273f, 0.03713765f, 0.09262184f, -0.04408073f, 0.09625043f, 0.22551951f, -0.22360688f, 0.04385070f, 
    -0.00540333f, 0.02205732f, 0.00844482f, 0.15128841f, -0.04913047f, -0.09952984f, 0.25238654f, 0.28293529f, 
    -0.09292656f, -0.02897691f, -0.28473979f, -0.14353994f, 0.13443607f, 0.03631318f, 0.09126128f, 0.12346781f, 
    -0.34438351f, 0.03185779f, -0.18762060f, -0.09130252f, 0.25895655f, 0.18048683f, 0.00193249f, 0.31903642f, 
    -0.32690749f, -0.08319706f, 0.03672943f, -0.23969635f, -0.03177099f, 0.09394465f, 0.02726342f, -0.13630866f, 
    -0.14578031f, -0.16797394f, 0.09259666f, -0.03284615f, -0.03816349f, -0.12451868f, 0.18932012f, 0.13673335f, 
    -0.12492939f, -0.46260217f, -0.01877275f, 0.23820649f, 0.08555979f, 0.26024684f, 0.05185952f, 0.00065372f, 
    0.02402256f, -0.10718290f, -0.48018375f, -0.91999429f, -1.04017735f, -0.08563969f, -0.23004235f, 0.03785531f, 
    -0.22680570f, 0.06628391f, 0.11223257f, -0.85659105f, -0.05074748f, -0.14678615f, 0.21149009f, 0.06922428f, 
    0.02774789f, -0.04604140f, -0.01849449f, 0.00652609f, -0.39720023f, -0.23374155f, -0.22334594f, -0.15378480f, 
    0.17411284f, 0.11135121f, -0.07472660f, 0.04944568f, 0.07365843f, -0.44277930f, 0.02541697f, -0.26698449f, 
    -0.11570179f, -0.04815150f, -0.19654079f, -0.07610848f, 0.19735970f, -0.01301766f, 0.02566775f, 0.12909794f, 
    -0.25794637f, 0.10362959f, 0.05506635f, 0.28317192f, -0.09631780f, 0.01853324f, 0.05122497f, 0.55830109f, 
    -0.28631601f, 0.07659451f, -0.01284007f, -0.05074709f, -0.07095327f, -0.11309224f, 0.11607681f, -0.03370593f, 
    0.41035038f, 0.25755125f, -0.15072548f, -0.10502071f, 0.26563969f, 0.03470006f, 0.12386408f, 0.15981545f, 
    -0.05405507f, -0.07351124f, -0.17189427f, -0.29088899f, -0.30417243f, -0.10167836f, -0.04323538f, 0.03659930f, 
    -0.06019378f, 0.25163648f, 0.44769028f, 0.15023357f, 0.12385948f, 0.00101348f, -0.07571466f, 0.10538334f, 
    0.11965155f, -0.05174276f, -0.09475194f, 0.66700768f, 0.07684765f, -0.02078132f, -0.03069387f, -0.07701531f, 
    0.20141613f, 0.04592866f, 0.17098042f, -0.19802617f, 0.04671473f, -0.44115931f, -0.18017803f, -0.05307473f, 
    0.02730426f, -0.00756245f, -0.04318931f, -0.01456734f, 0.09904769f, 0.54045188f, 0.09044159f, 0.34880251f, 
    0.02048137f, -0.02799093f, 0.01377215f, 0.24876802f, -0.00108997f, 0.14331940f, 0.37224221f, 0.26193494f, 
    0.27492455f, 0.05295024f, -0.18179014f, -0.03336115f, 0.02434287f, 0.05461640f, -0.02262791f, 0.40825582f, 
    -0.34976792f, -0.75482547f, -0.26478040f, -0.17589101f, -0.18234724f, 0.03650629f, -0.04629365f, 0.12012980f, 
    -0.46751577f, -1.01845026f, -0.33821979f, 0.00685927f, 0.07050836f, 0.10720162f, 0.14362408f, 0.05908801f, 
    0.00936182f, -0.60772723f, 0.42513409f, -0.15583508f, -0.12578604f, -0.01960146f, 0.05549305f, 0.14021656f, 
    0.02169998f, 0.12774658f, -0.33572811f, -0.44861722f, -0.44410765f, 0.00878781f, 0.02686634f, -0.07267614f, 
    0.07465219f, -0.05632208f, 0.13102335f, 0.72665870f, 0.10733650f, 0.36263657f, 0.12545826f, 0.00443874f, 
    0.17440484f, 0.07088653f, -0.00082902f, 0.01772873f, 0.08915651f, -0.06402783f, 0.30473146f, -0.22067533f, 
    0.03886210f, 0.07818893f, 0.05597715f, -0.09867482f, -0.02859729f, -0.15306070f, -0.12952504f, 0.40284732f, 
    -0.06018652f, 0.07350241f, -0.04481943f, -0.05406921f, -0.13713112f, -0.17499349f, 0.23499307f, -0.16376948f, 
    0.08131784f, -0.06024901f, 0.19743004f, -0.17182189f, 0.01885938f, 0.16956656f, -0.03824284f, -0.10464907f, 
    0.20361713f, 0.04173773f, 0.04151663f, -0.12814406f, 0.00842797f, -0.01494570f, -0.12247659f, 0.03949405f, 
    0.08392581f, 0.47481793f, 0.70109630f, -0.07021300f, -0.02999294f, -0.09686875f, 0.12892742f, 0.02580539f, 
    -0.00882696f, 0.26898071f, 0.16056810f, -0.05732199f, 0.04455930f, 0.11078276f, 0.03480771f, 0.08169462f, 
    -0.01252338f, 0.16246025f, -0.25128406f, -0.22109187f, 0.34071052f, -0.10950535f, 0.13695779f, 0.04101084f, 
    -0.02506628f, -0.11069389f, -0.06669638f, -0.12288778f, 0.27648994f, 0.26747340f, -0.00916264f, 0.07744113f, 
    0.07253862f, -0.03459255f, 0.25651625f, -0.00158814f, 0.28534290f, 0.35864452f, -0.08527058f, 0.03942663f, 
    -0.01556635f, 0.04101660f, 0.06695628f, 0.07687649f, -0.08676902f, 0.06705272f, 0.34020132f, 0.22738309f, 
    -0.03279898f, -0.09776717f, 0.05067662f, -0.03741908f, 0.13230954f, 0.07508039f, -0.05077321f, -0.03205086f, 
    -0.01274763f, 0.08055530f, -0.00324677f, 0.13294765f, 0.26615354f, 0.07466572f, 0.26419026f, -0.09210705f, 
    0.27299491f, -0.08880462f, 0.38200727f, 0.00126173f, -0.28319404f, -0.02983945f, 0.03398754f, -0.13478251f, 
    -0.25300571f, -0.20239054f, -0.02421844f, -0.14284648f, -0.05390719f, 0.09769505f, -0.03864766f, -0.05520801f, 
    -0.18411458f, -0.07337303f, 0.15437409f, 0.03152674f, -0.12774813f, -0.08693583f, 0.04613078f, -0.00317758f, 
    0.00907624f, 0.06375435f, -0.42217711f, 0.08446985f, -0.73826438f, -0.00789840f, 0.22393329f, 0.19193825f, 
    -0.13298808f, 0.12343164f, -0.11527454f, 0.00262801f, -0.00028778f, -0.09460547f, 0.00534835f, -0.09077735f, 
    0.14519784f, 0.27435118f, 0.01974386f, -0.03105207f, 0.19201304f, -0.56412417f, -0.30270475f, 0.16591990f, 
    0.16045789f, 0.04003212f, 0.02845813f, -0.03358926f, 0.10868478f, -0.13837607f, 0.00508758f, -0.23272389f, 
    -0.02802394f, 0.02164654f, 0.12410305f, -0.04648419f, -0.04089398f, -0.04999003f, -0.01789291f, 0.18127206f, 
    -0.49991432f, 0.09871894f, -0.01757247f, 0.01891880f, 0.12191484f, 0.09222578f, -0.02598183f, -0.08108804f, 
    0.12787454f, 0.08628432f, -0.07467599f, -0.10191984f, -0.16372237f, -0.08826198f, 0.10718663f, -0.11443285f, 
    -0.21348293f, -0.01119994f, 0.15060955f, 0.01131610f, 0.04133585f, -0.08201607f, -0.00749223f, 0.11322302f, 
    -0.00681456f, 0.19106267f, 0.14109433f, -0.08654554f, -0.28953126f, -0.35627696f, -0.41682401f, -0.00045764f, 
    0.03762809f, -0.07230901f, 0.11922368f, -0.39331672f, -0.76834798f, 0.02875229f, 0.04861455f, 0.15399732f, 
    -0.02333504f, -0.13145712f, 0.04446029f, -0.03796238f, -0.23684375f, -0.48431021f, -0.09499091f, 0.18171416f, 
    0.03255085f, 0.11082841f, 0.00492732f, -0.06847038f, 0.16323206f, 0.08804227f, -0.08505547f, -0.15890859f, 
    -0.22151791f, 0.01143844f, -0.05257835f, -0.02604145f, 0.01762078f, -0.01722028f, -0.26940447f, -0.60453552f, 
    0.00057825f, -0.06250620f, -0.00411484f, -0.03145086f, -0.14952029f, -0.06705251f, 0.06460337f, 0.11966576f, 
    0.04679246f, 0.16775396f, -0.16112150f, 0.15663426f, -0.06109610f, 0.16804685f, -0.02789347f, -0.19699678f, 
    0.09261160f, -0.10192168f, 0.00736573f, -0.02655668f, 0.07973152f, 0.27629438f, -0.11286926f, 0.15306188f, 
    0.05428389f, -0.14303693f, 0.12602520f, -0.27240491f, -0.01821363f, 0.03001392f, 0.16454646f, 0.09691786f, 
    0.14080930f, -0.15245087f, 0.29131937f, -0.57495940f, -0.09389870f, 0.09709652f, 0.20107390f, -0.00764362f, 
    0.14977548f, 0.05708833f, 0.11631071f, -0.04041160f, 0.13781391f, 0.03185480f, -0.20834531f, -0.08946774f, 
    0.01286910f, 0.05365137f, 0.05299521f, 0.60170031f, 0.02421412f, -0.26385438f, 0.03362077f, 0.05296894f, 
    0.14254309f, -0.01575231f, -0.03234966f, 0.13380840f, 0.23696548f, -0.34604961f, -0.13589750f, 0.06898797f, 
    -0.19038388f, -0.10818864f, 0.12724565f, -0.03003608f, -0.07617858f, -0.00072513f, 0.05685207f, 0.13581772f, 
    0.00677951f, -0.08894878f, -0.09623333f, 0.07112239f, -0.12465194f, -0.30188546f, -0.11036137f, 0.04408753f, 
    0.28416625f, 0.04526076f, 0.07439530f, 0.01536600f, -0.03048299f, 0.20108934f, -0.00799248f, -0.12227790f, 
    0.55366206f, -0.15587209f, -0.02233945f, -0.02835319f, 0.06560642f, 0.15941182f, -0.06858642f, 0.14565141f, 
    0.20405243f, 0.32271251f, 0.39102027f, -0.03095883f, 0.04804536f, -0.06759298f, 0.21771276f, 0.03201960f, 
    -0.06850494f, 0.23582928f, 0.38466620f, 0.27825421f, 0.07562801f, 0.04130682f, 0.14882319f, 0.04554101f, 
    -0.17430608f, -0.15703399f, -0.13964602f, -0.00017358f, -0.04575587f, -0.00243980f, 0.09812701f, 0.05147896f, 
    -0.00890907f, -0.04180899f, -0.00315234f, -0.00390704f, 0.01672620f, 0.27430665f, -0.03815473f, 0.11072700f, 
    0.04926354f, -0.16853398f, 0.10764329f, -0.26907668f, 0.30063689f, 0.20742331f, 0.08381291f, -0.10112923f, 
    -0.20953602f, 0.02119066f, 0.08897598f, 0.11830542f, 0.20557186f, 0.18198980f, 0.03497399f, 0.16912040f, 
    -0.09515849f, -0.00458931f, -0.10060655f, -0.00961058f, 0.14769341f, 0.06498794f, 0.04446723f, -0.32000828f, 
    0.25731128f, 0.17178866f, 0.14848682f, 0.06375531f, -0.27967393f, 0.17707662f, -0.30432126f, -0.42575496f, 
    -0.09265840f, -0.22125348f, 0.11420729f, -0.02052160f, -0.09562039f, -0.02988835f, 0.05156127f, -0.08832798f, 
    -0.29239255f, -0.22120535f, 0.05555959f, 0.02653088f, -0.08598621f, -0.12102097f, 0.19165877f, -0.16851649f, 
    -0.29561058f, 0.13915169f, 0.19989651f, 0.27943352f, -0.05539924f, -0.09996679f, 0.02802528f, 0.04392418f, 
    -0.13140976f, -0.05888981f, 0.46966207f, -0.36359763f, -0.62027884f, 0.16382696f, 0.24756394f, 0.07800745f, 
    0.01058766f, 0.35146916f, 0.10323061f, -0.31723267f, -0.55985451f, 0.00766362f, 0.03983552f, -0.01206137f, 
    -0.17639650f, 0.10258042f, 0.31481445f, -0.07572053f, -0.06384215f, 0.05786758f, -0.07604967f, -0.13769241f, 
    -0.14602250f, 0.17437296f, 0.06060232f, -0.13349800f, 0.08039747f, 0.32864001f, -0.55678391f, -0.16420688f, 
    0.13628016f, -0.08831190f, -0.16489218f, -0.12249701f, -0.25910899f, -0.29006776f, 0.22717640f, 0.11216778f, 
    0.05931941f, -0.16099100f, -0.14297186f, -0.04827505f, 0.20106849f, 0.02166531f, 0.05928919f, -0.29257005f, 
    -0.24715309f, -0.50536466f, -0.00659255f, -0.07593618f, -0.08946383f, -0.12207704f, -0.14584358f, -0.00765841f, 
    -0.22913304f, 0.07577457f, -0.17317471f, -0.11392041f, -0.19176510f, -0.10618645f, 0.08581739f, -0.03471281f, 
    0.13795869f, 0.03299316f, -0.14919966f, -0.07191754f, -0.15357041f, -0.03655588f, -0.01994909f, 0.10418677f, 
    0.02935419f, 0.15272151f, 0.09456190f, 0.01186626f, 0.07425343f, 0.11780700f, -0.15578827f, -0.06822320f, 
    0.08694399f, -0.07322105f, 0.02615727f, 0.20774680f, -0.17126247f, -0.12903325f, 0.12032989f, 0.06704607f, 
    0.16378242f, -0.03869266f, -0.06100932f, -0.21015990f, 0.12627810f, 0.09423359f, 0.10937201f, 0.08934774f, 
    -0.02258043f, -0.09367773f, 0.13311796f, 0.04224024f, 0.18457033f, -0.08725149f, -0.04501688f, 0.03713004f, 
    0.01237684f, -0.02091735f, -0.04006303f, -0.01382986f, -0.05480748f, -0.00531413f, 0.34823084f, -0.01014509f, 
    0.11452217f, -0.13498217f, 0.13887264f, 0.01958200f, 0.18491596f, -0.23852439f, 0.06483660f, 0.11070380f, 
    -0.47489497f, -0.05296737f, -0.01323117f, 0.08971271f, -0.03833871f, -0.04206616f, 0.21077719f, -0.16331777f, 
    -0.25544935f, 0.06116132f, -0.02674388f, -0.04260285f, -0.07298125f, -0.13694534f, 0.03347538f, 0.09171769f, 
    0.13724373f, -0.13167928f, 0.13811196f, 0.10633592f, -0.35344726f, -0.09784124f, -0.08925311f, 0.15581723f, 
    -0.03598883f, 0.07645551f, -0.00278005f, -0.23252732f, 0.07343756f, -0.06746175f, 0.31573874f, -0.02747862f, 
    0.11361749f, -0.05167090f, 0.01157259f, 0.15783854f, 0.08731434f, 0.09902470f, 0.01115311f, -0.01818720f, 
    0.03539827f, 0.07045882f, -0.06362354f, -0.07857428f, -0.39320809f, -0.05331976f, 0.17883234f, -0.24781294f, 
    -0.03262277f, 0.03083471f, -0.11832280f, -0.03324292f, -0.11419787f, -0.53935021f, -0.31381005f, -0.00289163f, 
    0.02198801f, -0.22692451f, 0.02061957f, -0.15735245f, -0.06735864f, -0.06604757f, 0.17794760f, -0.06054810f, 
    0.11037300f, -0.09203201f, 0.07706609f, 0.06538818f, 0.05077358f, 0.08649718f, 0.03776818f, 0.18125838f, 
    0.17709732f, 0.12363669f, -0.02406340f, 0.15152341f, -0.03067973f, -0.04318519f, 0.06545322f, -0.02184714f, 
    0.00711226f, 0.05264387f, -0.00303204f, 0.02092811f, -0.01369846f, -0.03943875f, 0.05086504f, 0.03242148f, 
    0.00209487f, -0.04471548f, -0.04600788f, 0.04816540f, -0.01373279f, 0.02477630f, -0.00871904f, -0.02099742f, 
    -0.04657194f, -0.03733974f, -0.01639633f, -0.01757548f, -0.03921167f, -0.02802475f, 0.01758223f, -0.06374387f, 
    -0.01288274f, -0.04101549f, 0.03349840f, -0.04956484f, 0.01466085f, -0.00779065f, -0.00183091f, -0.03372607f, 
    -0.02385100f, 0.04669051f, 0.02621079f, -0.01959008f, 0.02921056f, -0.04925636f, -0.05052313f, -0.05705272f, 
    0.03983369f, 0.02120461f, -0.00586432f, 0.01590981f, 0.01697596f, -0.02160530f, 0.03021435f, -0.05486308f, 
    0.00598255f, -0.04270192f, -0.01985034f, 0.04901546f, -0.02998356f, -0.01884575f, -0.03377045f, -0.02087343f, 
    0.04274797f, -0.03158268f, 0.01665984f, -0.00792385f, 0.03653525f, -0.04445114f, 0.00944489f, -0.05889307f, 
    0.01180339f, -0.05263582f, -0.04229099f, 0.02663464f, -0.00040582f, 0.00672977f, 0.03722132f, -0.00475763f, 
    0.02761112f, -0.04260386f, -0.00880723f, 0.01099592f, 0.00777418f, -0.03719831f, 0.05229485f, -0.06265644f, 
    0.04322937f, 0.04463181f, -0.04308989f, 0.01304235f, -0.00920256f, 0.03654333f, -0.05107159f, 0.04426030f, 
    0.01288867f, -0.01020105f, 0.05484149f, -0.02038409f, -0.05214372f, -0.02913140f, 0.03101043f, -0.00775651f, 
    -0.05501127f, 0.05306982f, -0.03884777f, 0.03674302f, 0.00718286f, 0.03889578f, 0.01300084f, -0.06130318f, 
    0.01063056f, 0.04982541f, 0.02939033f, -0.01295646f, 0.05233718f, -0.06361367f, -0.03574482f, 0.04858715f, 
    -0.03617498f, -0.05761484f, -0.04823854f, -0.01556721f, 0.03520520f, -0.06109836f, 0.02604274f, 0.00736621f, 
    -0.04176537f, -0.01310195f, -0.01462839f, -0.00833083f, 0.02370907f, -0.01032572f, 0.03170177f, -0.06288925f, 
    0.02404243f, 0.04663795f, -0.02936179f, -0.04343668f, -0.00487709f, -0.00266631f, -0.02406490f, -0.05786512f, 
    -0.01822708f, 0.01076076f, 0.04120245f, -0.04930160f, -0.06392399f, -0.02753454f, -0.04268751f, -0.01707488f, 
    0.01147126f, -0.03385297f, 0.00952868f, 0.02108153f, 0.01322165f, 0.04214203f, 0.03212699f, 0.00225830f, 
    -0.06333405f, 0.01585563f, 0.00003324f, -0.00256408f, -0.05221585f, 0.00528012f, -0.05810939f, 0.02930998f, 
    -0.02221096f, -0.03723304f, 0.02798536f, 0.00270378f, -0.02288430f, 0.00119634f, 0.01548085f, -0.03241484f, 
    -0.04277200f, 0.03413226f, -0.00776708f, 0.02288822f, -0.06288549f, 0.03665401f, 0.00078887f, -0.05172426f, 
    -0.00067728f, 0.00607809f, 0.02510139f, 0.02353165f, 0.02694562f, 0.00655976f, -0.04402297f, -0.00248663f, 
    -0.04486013f, -0.05709060f, -0.03969343f, 0.03548134f, 0.03994340f, 0.01449484f, 0.04061662f, 0.02993097f, 
    -0.05085317f, 0.01977161f, -0.05940079f, 0.04149633f, -0.02572613f, -0.00340239f, -0.01129519f, -0.01643494f, 
    0.02520816f, -0.02719528f, -0.05058634f, 0.04193692f, 0.02127041f, -0.03804658f, 0.02513950f, -0.03284846f, 
    -0.03723384f, 0.00235363f, -0.06168585f, 0.04736136f, -0.04778207f, 0.01404166f, 0.06082596f, -0.00776250f, 
    -0.04248558f, 0.01914097f, 0.00401726f, -0.03629488f, 0.01426920f, -0.00135009f, -0.01053835f, -0.01165318f, 
    -0.00986538f, 0.03645425f, -0.02829863f, -0.02715272f, -0.04023222f, 0.04809473f, 0.01060518f, 0.03294206f, 
    0.00461854f, -0.03275291f, -0.02785229f, -0.05204635f, -0.05554599f, 0.00350927f, -0.03631702f, -0.02473251f, 
    0.01418326f, 0.00220186f, 0.04234017f, -0.02815427f, 0.02236752f, 0.01388852f, 0.00194858f, -0.01300168f, 
    0.02418512f, -0.04744785f, 0.00653447f, 0.02772746f, -0.03218200f, -0.05099136f, -0.03719080f, -0.05845936f, 
    0.02792304f, 0.00247569f, -0.05471743f, -0.03621558f, -0.03279512f, 0.02425390f, -0.03176666f, 0.03490533f, 
    -0.04844517f, 0.01824536f, -0.05255040f, -0.05422246f, -0.00047243f, -0.04117825f, -0.03941382f, -0.01660722f, 
    -0.01944969f, 0.05223606f, -0.00988643f, -0.02771618f, 0.02472601f, -0.04935829f, 0.03843009f, 0.03634420f, 
    -0.05615253f, -0.04526836f, 0.04140680f, 0.04625127f, 0.05284252f, -0.01593129f, -0.06215299f, -0.03339778f, 
    0.03749804f, 0.00384161f, -0.00124285f, -0.04890854f, -0.05609792f, -0.03819960f, 0.04877782f, 0.02190667f, 
    0.04729858f, -0.04195818f, 0.04058145f, 0.00436615f, 0.01035038f, -0.03242956f, -0.03333674f, -0.03297317f, 
    -0.04963326f, -0.04886781f, 0.01860647f, 0.03825537f, 0.00510728f, -0.00226348f, -0.01697642f, -0.02414810f, 
    -0.04769527f, 0.02620788f, -0.03923948f, 0.03329520f, 0.01375802f, 0.02004707f, -0.02727531f, 0.04296770f, 
    0.03820007f, 0.01817670f, 0.03616219f, -0.02015810f, 0.05720444f, -0.03363482f, -0.06097277f, -0.04802183f, 
    0.02364483f, 0.02520005f, 0.02060663f, 0.03634552f, -0.00284424f, -0.05726461f, -0.04890537f, 0.04370791f, 
    0.03870796f, 0.00410831f, -0.03481629f, 0.00556163f, -0.04376145f, -0.00516870f, -0.02844080f, -0.01027675f, 
    0.03538138f, 0.02018081f, -0.04808881f, 0.04942621f, -0.06029055f, -0.04873508f, -0.04836372f, 0.01927464f, 
    0.02235647f, -0.06003532f, -0.00300952f, -0.05880523f, 0.00480450f, 0.01776664f, 0.04656485f, 0.02619120f, 
    0.03715796f, 0.03659976f, -0.05702692f, 0.03190649f, -0.02499206f, -0.04297859f, 0.00881714f, -0.06215720f, 
    -0.00722488f, -0.02142647f, -0.01835961f, -0.05247547f, -0.02637544f, 0.03896500f, -0.06677119f, -0.01937347f, 
    0.04247063f, 0.00419595f, -0.01443865f, 0.02866687f, 0.04095235f, -0.04493963f, -0.04941594f, 0.00145368f, 
    -0.03928591f, -0.06111183f, 0.00188505f, 0.00495467f, -0.03884185f, -0.02768181f, -0.01570099f, -0.05626782f, 
    0.03549944f, 0.04892157f, 0.01077593f, 0.02961389f, 0.01279878f, -0.03904393f, -0.02012714f, -0.01033148f, 
    0.02266180f, -0.04188090f, -0.03637202f, -0.01929629f, 0.04538972f, 0.00266028f, -0.04545724f, -0.06567358f, 
    0.01750457f, -0.00625109f, -0.00236740f, 0.00659406f, -0.05239367f, -0.01397349f, 0.00514351f, 0.03806670f, 
    -0.06378867f, 0.03004951f, -0.04580483f, -0.05016988f, 0.00675342f, 0.01794716f, 0.03956087f, -0.06060845f, 
    0.02183540f, -0.01927560f, 0.00425228f, -0.05858183f, 0.04677052f, -0.04966934f, 0.03696052f, 0.03832885f, 
    0.04466106f, 0.01640857f, 0.00489929f, 0.02038999f, 0.04560580f, -0.06414571f, 0.04101168f, -0.05123240f, 
    -0.05925157f, 0.04237427f, -0.06526374f, -0.04690414f, -0.02447682f, 0.01424336f, -0.04863955f, 0.04164736f, 
    -0.00150322f, -0.04175286f, 0.00046419f, 0.00234336f, -0.05260325f, 0.00749370f, -0.05216930f, 0.03087963f, 
    -0.04033035f, -0.05471386f, 0.01824883f, -0.06293073f, 0.01985970f, -0.00126276f, 0.01161816f, -0.02527821f, 
    -0.00473413f, -0.04174126f, -0.00234188f, -0.00251630f, 0.03971654f, 0.01897481f, -0.06657799f, -0.01470068f, 
    0.02698717f, -0.00663982f, 0.00988246f, -0.04263832f, -0.05827368f, 0.02680239f, 0.02356891f, -0.00766142f, 
    -0.06426115f, -0.00830047f, 0.00887955f, 0.00342433f, -0.06394807f, -0.03685612f, 0.05104276f, 0.04122399f, 
    -0.00135153f, 0.04544776f, -0.01571999f, -0.02586742f, -0.03986238f, -0.00368201f, -0.05002739f, -0.06229813f, 
    -0.01752837f, -0.00264577f, -0.00773621f, -0.05585667f, -0.05381326f, -0.04711264f, -0.03249000f, -0.01957256f, 
    0.04069950f, 0.00288994f, -0.06243628f, -0.02219019f, 0.01651213f, 0.01407441f, 0.01270871f, 0.01388306f, 
    0.00974306f, 0.01462524f, -0.04397135f, -0.02599340f, -0.03549205f, 0.00451035f, -0.01374772f, -0.05478845f, 
    0.01640870f, -0.01167447f, 0.03400033f, 0.02504976f, 0.02374453f, -0.04648332f, 0.02609792f, 0.00161467f, 
    0.01140453f, -0.00976479f, -0.04238286f, -0.00299713f, 0.00079753f, 0.01420397f, 0.00446428f, -0.02608630f, 
    0.02352380f, 0.03121322f, 0.01809853f, -0.00803086f, 0.04035337f, -0.00928136f, -0.01209197f, 0.00525371f, 
    -0.03044689f, -0.01951956f, -0.03564067f, -0.04895593f, 0.03132246f, -0.02463507f, -0.03417883f, -0.05106760f, 
    -0.01414775f, -0.01615649f, 0.00358607f, 0.00687326f, -0.03345182f, 0.04347585f, 0.03211889f, -0.03467902f, 
    0.02432064f, 0.04903231f, 0.00506006f, -0.03377016f, -0.04271675f, 0.03145824f, 0.02778067f, -0.06433515f, 
    -0.03523963f, -0.02078192f, -0.00199977f, -0.05085958f, 0.03007606f, 0.03328741f, 0.03768640f, 0.02589138f, 
    0.01800603f, 0.05522186f, 0.02508056f, -0.00197620f, 0.03276309f, 0.03517816f, 0.02880552f, -0.04347056f, 
    -0.04796014f, -0.01429645f, -0.03514617f, -0.04466733f, -0.06539338f, -0.03314172f, 0.04122354f, -0.00895932f, 
    -0.04093992f, 0.01003812f, -0.00706440f, 0.02696414f, 0.03324006f, -0.04394300f, 0.04458411f, 0.01204525f, 
    -0.04859802f, 0.02227114f, 0.03355445f, -0.01668769f, 0.01664276f, -0.01799312f, -0.04307831f, -0.03126293f, 
    -0.04601417f, -0.02806490f, -0.04471935f, -0.00818591f, 0.01728053f, -0.02084915f, -0.00540172f, -0.03176860f, 
    -0.05106724f, 0.02414743f, -0.05171198f, -0.03637553f, -0.01789529f, -0.06359641f, -0.00781703f, 0.04265216f, 
    0.03804564f, 0.02411590f, -0.02210779f, 0.02462183f, 0.04546138f, 0.04346024f, 0.05200776f, -0.02338935f, 
    -0.05630349f, -0.06160330f, 0.00172234f, 0.02078992f, 0.01708159f, 0.03990433f, 0.04571610f, -0.02882010f, 
    0.01454749f, -0.05378500f, -0.06572113f, -0.00540755f, -0.03984751f, 0.02421186f, -0.02851343f, -0.05439861f, 
    0.04768201f, 0.02912837f, 0.01749863f, 0.01878023f, -0.01833166f, -0.03148956f, -0.00161750f, 0.01117693f, 
    -0.04406877f, -0.02940632f, -0.06324791f, -0.05085124f, -0.01879533f, 0.02456766f, 0.02029676f, -0.03128892f, 
    -0.01441195f, -0.01035273f, -0.03204842f, -0.06423524f, 0.03909367f, 0.03641609f, -0.01889689f, -0.05144519f, 
    -0.03308456f, -0.01181888f, 0.00131364f, -0.03869575f, 0.00508281f, 0.00128451f, 0.03182410f, -0.00116862f, 
    0.04513297f, -0.02046099f, -0.05357523f, 0.00437701f, 0.03778470f, 0.00023021f, 0.04297208f, -0.06324016f, 
    -0.03791090f, -0.02645902f, -0.04187962f, 0.03458181f, -0.03510758f, 0.00770728f, -0.02072025f, -0.06333912f, 
    0.01804886f, -0.02406876f, 0.01802671f, -0.06673167f, -0.02616978f, 0.03964794f, 0.02172515f, 0.00553920f, 
    -0.06915983f, -0.06305520f, -0.02980657f, 0.04711739f, -0.04793800f, -0.02918131f, -0.02995684f, 0.04417479f, 
    -0.05878096f, -0.03134025f, 0.03236565f, -0.02144944f, 0.00407797f, 0.02978855f, 0.04658819f, 0.02570115f, 
    -0.01343662f, 0.02295142f, -0.03123475f, -0.03729627f, 0.04901571f, 0.00345774f, -0.02843455f, 0.00151769f, 
    -0.06667347f, -0.00533844f, 0.02214839f, 0.04699602f, -0.06552289f, 0.02679775f, -0.05529122f, -0.04568129f, 
    -0.00481370f, -0.00520632f, -0.01580185f, -0.01450179f, -0.06367732f, 0.04397907f, 0.04059980f, 0.04436360f, 
    0.01657873f, -0.02360038f, 0.01365089f, -0.04360630f, 0.01205097f, -0.01746255f, 0.04427968f, 0.02458507f, 
    0.00652673f, -0.00251773f, 0.02801739f, 0.02100023f, -0.04094601f, -0.01401511f, 0.00594189f, 0.04624519f, 
    -0.00067344f, 0.01746782f, 0.02493130f, 0.02811972f, 0.01199369f, 0.00015759f, -0.00315723f, -0.06267419f, 
    0.03122359f, 0.04320041f, 0.01761622f, -0.03065420f, 0.02431017f, -0.01182249f, -0.04334792f, -0.01203861f, 
    -0.00540884f, -0.03051800f, -0.05848387f, -0.06483525f, 0.01164611f, 0.01730001f, -0.04698299f, -0.04868892f, 
    0.03336301f, -0.02694514f, 0.03693943f, -0.05607933f, -0.04230818f, -0.02956404f, -0.03403164f, 0.02051757f, 
    0.00574849f, 0.04513867f, 0.00863279f, 0.01653603f, -0.00447460f, -0.06390195f, -0.06981721f, -0.00897594f, 
    -0.00463454f, -0.02636641f, -0.01460278f, -0.06611804f, -0.05294306f, 0.02867448f, -0.01362615f, -0.04793967f, 
    0.01232248f, 0.01842599f, 0.03880921f, -0.01697120f, 0.02632983f, -0.06045673f, 0.03063296f, -0.06052519f, 
    -0.05213844f, 0.02842289f, 0.04793935f, 0.00957182f, -0.01869316f, -0.02432314f, 0.00083742f, 0.00548346f, 
    -0.04787594f, 0.01386188f, 0.03447958f, 0.04363511f, -0.00465077f, 0.02039064f, -0.00343218f, -0.02965383f, 
    0.02415047f, -0.04559132f, -0.06428054f, 0.03187705f, -0.01362379f, -0.06222456f, -0.06586570f, 0.04773840f, 
    -0.00300796f, 0.04650671f, 0.02595127f, -0.00253881f, -0.01546494f, 0.01347402f, 0.00743000f, -0.04863002f, 
    0.00669112f, -0.03241559f, -0.05951874f, 0.03646359f, -0.02930162f, -0.01537668f, 0.02856324f, -0.04980886f, 
    0.04495119f, -0.02017819f, 0.00458235f, -0.01745676f, 0.03865017f, -0.06489865f, -0.01034583f, -0.03577816f, 
    -0.27284282f, -0.13238224f, -0.28385326f, 0.14311388f, 0.18075836f, -0.06947359f, -0.07146367f, 0.01500321f, 
    0.08626787f, -0.23433235f, 0.11781497f, 0.01413539f, 0.11716167f, 0.15780005f, 0.01369616f, 0.03744190f, 
    -0.10532653f, -0.14379437f, -0.20326875f, -0.01466446f, -0.15415782f, 0.17677738f, 0.29902098f, 0.03495300f, 
    0.27983701f, 0.06405263f, 0.07359166f, -0.08516774f, -0.12251343f, -0.17687100f, -0.00226621f, -0.00923038f, 
    -0.05149409f, -0.06240936f, -0.30333969f, -0.02115741f, 0.07509977f, -0.16682625f, -0.30477351f, -0.08372597f, 
    0.15893486f, 0.21301462f, 0.16475001f, -0.08175644f, -0.19180481f, 0.05843338f, -0.04118434f, -0.16569975f, 
    -0.08206013f, 0.09954965f, 0.09663863f, -0.09612024f, -0.18141034f, -0.21167865f, 0.37718731f, 0.06790879f, 
    0.01725250f, 0.20869604f, -0.01889799f, -0.07678145f, -0.00370756f, 0.09943442f, 0.07519706f, 0.17189427f, 
    -0.19890529f, 0.07054273f, 0.25434569f, 0.08847111f, 0.20157407f, 0.00000573f, 0.04491361f, 0.03609630f, 
    -0.07982253f, -0.04571037f, -0.07543212f, 0.19449210f, 0.12034786f, -0.02074338f, -0.06765997f, -0.05205223f, 
    0.11794616f, 0.15813628f, 0.11978811f, 0.10603493f, -0.11261178f, 0.01247646f, -0.13632099f, -0.12689389f, 
    -0.09363281f, 0.08122572f, 0.11294017f, -0.13574958f, -0.23382775f, 0.22004737f, -0.21589561f, -0.08375659f, 
    0.14083140f, -0.28470355f, -0.08416314f, 0.24623764f, 0.23781893f, -0.01301026f, 0.17687315f, 0.09016447f, 
    0.03383574f, -0.12423300f, 0.03404810f, 0.09106418f, -0.05302993f, -0.02990034f, -0.06365488f, 0.12195332f, 
    -0.01680691f, 0.18560323f, 0.09006582f, -0.02564266f, -0.01218009f, 0.19398449f, 0.28389424f, 0.15147297f, 
    0.14097819f, 0.06835239f, -0.06447785f, -0.17268533f, 0.18226333f, -0.10780196f, 0.03772520f, -0.13225017f, 
    0.07798255f, 0.00782511f, 0.05567610f, 0.20165505f, -0.04468429f, -0.00105995f, -0.00440579f, 0.04126304f, 
    -0.06528972f, -0.02667477f, 0.21545106f, 0.09098177f, 0.09271390f, 0.11413160f, 0.05195346f, 0.01774120f, 
    0.09070703f, 0.04136401f, 0.04572824f, -0.01225458f, -0.09231029f, 0.00119838f, -0.12167560f, -0.10920851f, 
    -0.05024882f, 0.00617818f, -0.06736591f, -0.02428186f, 0.14173141f, 0.04830702f, 0.10896669f, 0.05999051f, 
    0.00248475f, -0.09741620f, 0.04619984f, -0.11208635f, 0.09469260f, -0.02129126f, -0.02300925f, 0.08126125f, 
    0.20312771f, 0.02781513f, -0.01354321f, -0.05936483f, 0.33086610f, 0.10933702f, 0.03223416f, 0.27851424f, 
    -0.09234993f, -0.01100841f, 0.22435389f, -0.05381786f, 0.04839351f, -0.04980781f, 0.00219936f, 0.10521474f, 
    -0.05453235f, 0.05602648f, -0.12453368f, 0.05362455f, -0.02993491f, -0.10657324f, -0.03311105f, 0.07107846f, 
    0.01701043f, 0.00488127f, 0.13378038f, 0.13514803f, 0.13002582f, 0.00655329f, 0.06090834f, -0.13183786f, 
    -0.12264156f, 0.13149942f, -0.10429697f, 0.08083025f, 0.00715675f, 0.04426855f, -0.14441141f, 0.37025544f, 
    0.26259547f, -0.16594067f, 0.09063507f, 0.02341253f, -0.22046153f, -0.11047106f, 0.19521360f, -0.01726643f, 
    0.09795450f, -0.14849229f, -0.13829258f, 0.11250098f, 0.07834262f, 0.00537318f, 0.06177725f, -0.14707264f, 
    -0.16624966f, -0.07693048f, -0.11078371f, -0.06619810f, 0.12604150f, 0.08379035f, -0.05550541f, -0.06685428f, 
    0.04204929f, -0.03783904f, 0.13450265f, -0.06659281f, -0.04383491f, 0.10067602f, 0.02859928f, 0.18218994f, 
    0.00790604f, 0.12934546f, 0.00680426f, -0.03375426f, -0.01753111f, 0.06640948f, -0.00599997f, -0.00233754f, 
    0.01976918f, 0.10767824f, -0.03953571f, -0.08964008f, -0.04727487f, 0.18213791f, -0.03624919f, 0.17976744f, 
    -0.06000778f, 0.21546870f, 0.11874010f, 0.11306202f, 0.13071886f, -0.06211006f, 0.16901603f, 0.01019375f, 
    0.00003805f, 0.07237751f, 0.04605464f, 0.08357304f, 0.38471016f, 0.07362647f, -0.02616156f, -0.04331801f, 
    -0.09319573f, -0.03902430f, 0.06669281f, 0.13026363f, -0.12521189f, -0.36219978f, -0.29524562f, 0.11786336f, 
    -0.09450793f, -0.01090705f, -0.00786322f, 0.03041575f, 0.04643520f, 0.04406553f, 0.17582141f, 0.00880458f, 
    0.35485077f, 0.25934586f, 0.34432486f, 0.21440113f, -0.01406371f, -0.09635334f, -0.23124932f, -0.13073944f, 
    0.00401635f, 0.17514609f, 0.36587998f, 0.18400304f, 0.30642152f, 0.11239229f, -0.05911004f, -0.00562142f, 
    -0.07517609f, -0.27933708f, -0.49909931f, 0.21349220f, -0.30062318f, -0.07806439f, -0.12276956f, 0.11916686f, 
    0.19279063f, 0.12443297f, 0.02819899f, -0.13835704f, 0.05669888f, 0.20443042f, 0.00106107f, 0.05230704f, 
    0.18743575f, -0.03876605f, 0.04948999f, 0.03331222f, 0.35829160f, 0.17585264f, 0.09629779f, 0.24830106f, 
    0.05098787f, -0.01964074f, 0.03761004f, -0.10181887f, -0.25340605f, 0.33209479f, 0.01376648f, 0.07917449f, 
    0.03024774f, 0.00416051f, -0.13947128f, -0.03236335f, 0.17293669f, -0.30496481f, -0.14448804f, -0.22023833f, 
    0.11991050f, 0.03908070f, -0.00114336f, -0.06371133f, 0.12402606f, 0.01314328f, -0.28096262f, 0.01057027f, 
    -0.14493288f, 0.02405622f, -0.14810115f, 0.02398038f, -0.05057098f, -0.13353494f, 0.00005857f, 0.25057149f, 
    0.23972967f, -0.00408959f, 0.19426718f, -0.15475737f, -0.03874900f, -0.20494436f, 0.13263887f, 0.01915176f, 
    -0.04008953f, -0.03597258f, -0.10972565f, -0.13080265f, -0.12353133f, 0.07203607f, -0.07866848f, 0.12948003f, 
    0.10383248f, -0.07645936f, -0.09950035f, 0.51037323f, -0.42931995f, -0.09443916f, 0.04273384f, -0.17152253f, 
    0.16798958f, 0.07079523f, -0.36705357f, 0.16363527f, 0.05202980f, -0.14725600f, -0.04352946f, 0.10756737f, 
    -0.01495442f, 0.14746813f, 0.05652809f, -0.01708378f, -0.11905388f, -0.43487307f, 0.17310198f, 0.14986858f, 
    0.11423551f, 0.29193214f, -0.05759378f, 0.07717246f, 0.01126168f, -0.18324263f, 0.07420380f, 0.12292735f, 
    -0.10960729f, 0.04392410f, 0.01791376f, 0.04127106f, -0.05160628f, -0.16138498f, 0.11380478f, 0.02719140f, 
    0.08609666f, 0.14065842f, -0.09476752f, 0.00868774f, -0.09910847f, 0.04481990f, -0.10472739f, 0.00063668f, 
    0.03446833f, -0.21257813f, 0.09175677f, -0.07219160f, 0.06161474f, 0.01732416f, -0.03572658f, 0.06348999f, 
    -0.35559538f, -0.22010453f, -0.36346477f, 0.01600316f, -0.12962057f, 0.04945506f, 0.02253705f, -0.08771574f, 
    -0.36219847f, 0.23782422f, 0.15608218f, -0.17199072f, -0.01528986f, -0.11454210f, -0.01973830f, -0.20231238f, 
    -0.33862692f, 0.10720365f, 0.05649721f, -0.16126682f, 0.18402575f, 0.10365745f, 0.14103703f, 0.04621775f, 
    0.06319879f, 0.07313573f, 0.14197236f, -0.09657593f, 0.26041570f, -0.02682601f, -0.02463963f, 0.09285975f, 
    0.14641561f, 0.02119358f, -0.00801144f, 0.00670153f, 0.02557554f, 0.02599744f, -0.13295802f, 0.16351208f, 
    0.16599235f, 0.07747010f, -0.12644482f, -0.07641520f, -0.01965719f, 0.19199505f, -0.06436089f, 0.05188441f, 
    0.02726924f, 0.03752011f, -0.09202208f, 0.10310358f, -0.01860367f, 0.12451802f, -0.05884864f, 0.06922146f, 
    -0.04337198f, 0.23610726f, 0.21415433f, 0.04643513f, 0.00533272f, 0.11015170f, -0.02003879f, -0.47378534f, 
    -0.02418473f, -0.30335179f, 0.01978654f, 0.09433545f, -0.07512930f, 0.04154341f, 0.02588146f, -0.02316722f, 
    -0.20582253f, 0.08797483f, -0.18433478f, -0.04335700f, -0.01481040f, -0.01444963f, -0.13606945f, -0.15899020f, 
    -0.19171539f, 0.12140500f, 0.15808798f, -0.04529883f, -0.16911788f, -0.19117972f, -0.06075547f, 0.07483819f, 
    0.11293408f, -0.00397120f, 0.15903072f, -0.01777584f, -0.34237432f, 0.23860405f, 0.16148847f, 0.02866128f, 
    0.13574608f, 0.05091042f, -0.05716018f, 0.40933162f, 0.04585670f, 0.09905605f, 0.12339175f, -0.12303782f, 
    0.17885299f, -0.16252694f, -0.12585603f, 0.05277830f, 0.11172932f, -0.24576356f, 0.00758721f, 0.03495577f, 
    0.03680888f, 0.18192083f, -0.04858758f, 0.14599077f, 0.03669357f, 0.26366746f, -0.04713155f, -0.22871353f, 
    0.02729463f, 0.07214192f, 0.03124526f, 0.07669381f, 0.11581435f, 0.05816995f, 0.06980895f, 0.11976887f, 
    -0.03010481f, 0.07293285f, -0.05385539f, -0.16327740f, -0.12125104f, -0.11231127f, -0.53367722f, 0.28547722f, 
    0.02304421f, 0.02412240f, 0.00987059f, 0.08684888f, -0.05568639f, 0.08751681f, -0.05840712f, 0.01684925f, 
    -0.07888033f, -0.01224459f, -0.00710054f, -0.11892316f, 0.06393954f, -0.11768828f, -0.02239408f, 0.02183601f, 
    0.10257665f, -0.08139928f, -0.05053229f, 0.27066666f, -0.00946593f, -0.03402842f, -0.03410640f, 0.03329519f, 
    -0.01474962f, -0.10998434f, -0.17323664f, 0.09272891f, 0.04025413f, -0.28942189f, 0.15031788f, -0.05266993f, 
    -0.07543638f, 0.07785780f, 0.09153622f, -0.17934605f, -0.21628772f, 0.08851790f, 0.08426494f, 0.03383543f, 
    0.02539342f, -0.02681491f, 0.11384809f, 0.04727637f, -0.15564209f, -0.17144416f, -0.04695079f, 0.33126459f, 
    0.21366535f, -0.26496676f, 0.32397467f, -0.33346930f, -0.29273319f, -0.02906068f, -0.08202671f, -0.08252975f, 
    0.22945079f, 0.07054476f, -0.09838158f, 0.07736333f, -0.35643065f, -0.19665265f, -0.30780485f, 0.01459774f, 
    -0.10980659f, 0.13760887f, -0.08047967f, -0.08161475f, 0.04672614f, -0.03058131f, 0.04714782f, -0.24711806f, 
    -0.07983090f, 0.22333957f, -0.13338615f, -0.02927358f, 0.18750277f, -0.03682351f, -0.14172654f, -0.01596579f, 
    0.17583062f, 0.12844415f, -0.14617154f, -0.00844764f, 0.26900360f, 0.16671200f, -0.02046245f, 0.17594829f, 
    0.11227442f, 0.02568280f, -0.14546302f, -0.13778023f, 0.06483755f, 0.10584752f, -0.04054940f, 0.08386882f, 
    0.05144259f, -0.08631961f, -0.07500935f, 0.14433728f, 0.16793276f, -0.11724989f, -0.07477908f, -0.25850022f, 
    0.02617713f, -0.00539354f, -0.11125119f, 0.01384383f, 0.04053801f, -0.05907321f, -0.01416523f, 0.12006763f, 
    0.01990935f, 0.02032118f, 0.03355808f, -0.04860119f, -0.11134695f, 0.42493924f, 0.46402872f, -0.03306372f, 
    -0.10661338f, -0.08523404f, -0.00293645f, 0.16378358f, -0.22518237f, -0.05976590f, 0.06927175f, 0.07430007f, 
    -0.04813246f, 0.10269684f, 0.05993857f, 0.14361547f, 0.06215700f, 0.05061297f, 0.06602324f, 0.00755541f, 
    0.15419494f, 0.01538034f, -0.09979745f, 0.00793308f, 0.20390037f, -0.00503038f, 0.04192922f, 0.11108318f, 
    0.02415820f, 0.08681390f, 0.02182319f, -0.01104905f, 0.13191545f, 0.04921058f, 0.01005828f, -0.08722502f, 
    -0.07728764f, 0.02928170f, -0.03969191f, 0.03021048f, 0.04776154f, -0.02747400f, 0.02712548f, -0.05959341f, 
    -0.27676639f, 0.00025656f, -0.04945595f, 0.16921511f, -0.02437950f, -0.02283657f, 0.07870751f, -0.04788435f, 
    -0.17047234f, -0.15059529f, -0.10631572f, 0.00215727f, 0.33108518f, -0.05724538f, -0.02462461f, -0.04364840f, 
    0.23183198f, 0.06990482f, 0.19266604f, -0.13828750f, 0.11285579f, 0.16895323f, -0.04583687f, 0.00630342f, 
    0.18857133f, -0.05123943f, 0.16895939f, 0.24246396f, -0.05183710f, -0.08072495f, 0.09144455f, 0.08868796f, 
    0.07213972f, 0.13575147f, 0.07057358f, 0.06707077f, -0.10938879f, -0.05064287f, -0.02804426f, 0.18855762f, 
    0.18487173f, 0.14710465f, -0.22104499f, 0.01491711f, 0.05832240f, 0.14661428f, -0.07612744f, -0.16727071f, 
    0.10720372f, 0.02948371f, 0.14980759f, 0.11483359f, 0.18449289f, -0.05429747f, -0.02362785f, -0.43024984f, 
    -0.03775818f, 0.08891337f, 0.05953525f, -0.00346116f, -0.10302436f, 0.12559088f, 0.15810759f, 0.17192018f, 
    0.08565938f, 0.11154158f, 0.23956509f, 0.04563442f, -0.02985622f, 0.03860723f, -0.25261137f, -0.01320107f, 
    0.13620703f, 0.12870255f, -0.24930848f, 0.01696276f, -0.10156047f, -0.09418847f, 0.06421001f, 0.13452461f, 
    0.00523145f, 0.26931044f, -0.00022373f, -0.01040689f, 0.01024505f, 0.14672425f, 0.09172992f, 0.05685271f, 
    -0.08137641f, 0.03543288f, -0.14919730f, 0.09882220f, 0.03327586f, -0.05096642f, 0.06423626f, 0.01192188f, 
    -0.19771630f, -0.03663119f, -0.03043051f, 0.04813637f, -0.04339876f, 0.20112430f, 0.18140778f, -0.09873420f, 
    -0.01525644f, -0.05342453f, -0.00115647f, 0.14350428f, -0.04376034f, -0.00248082f, 0.01827711f, -0.06403928f, 
    0.09677413f, 0.08106863f, 0.00378645f, 0.18151015f, -0.07266235f, -0.11375158f, -0.08491833f, 0.00058235f, 
    -0.01574321f, 0.03464384f, 0.01676827f, -0.25021312f, -0.34851554f, -0.59901571f, -0.59877288f, -0.12312482f, 
    -0.06242055f, -0.07237894f, 0.09539662f, -0.07882804f, -0.12213252f, 0.02768644f, 0.00254077f, 0.07494133f, 
    -0.04876340f, -0.00609916f, 0.37011531f, -0.16964602f, -0.13608091f, -0.28260773f, 0.17655756f, 0.13436486f, 
    0.06680238f, -0.08175223f, 0.26361302f, 0.48010290f, -0.14472710f, -0.15870711f, -0.04861462f, -0.13502447f, 
    -0.07833431f, 0.01860696f, -0.36165267f, -0.29074216f, -0.17441963f, -0.10438141f, -0.08297333f, 0.03823232f, 
    -0.01306987f, -0.08206753f, -0.03825364f, -0.13629124f, -0.08826968f, 0.44674248f, 0.04678243f, 0.06040655f, 
    0.00627642f, 0.06060803f, -0.04874520f, 0.28962246f, -0.05829348f, 0.10182629f, 0.03860494f, 0.01981826f, 
    -0.09949068f, -0.02777156f, -0.04426221f, -0.26473862f, -0.13469870f, -0.20010360f, 0.02386067f, -0.06753603f, 
    0.08276720f, -0.03136817f, 0.02532086f, 0.16656958f, -0.03688769f, -0.06595708f, -0.48863363f, -0.58165753f, 
    -0.04842624f, -0.06667145f, -0.23384009f, -0.00121210f, -0.08612853f, -0.34176829f, 0.14245519f, -0.13450432f, 
    -0.11859860f, 0.11433422f, 0.06300077f, 0.02414221f, -0.19329044f, -0.07074441f, 0.05059181f, 0.13694467f, 
    -0.17113267f, -0.00243936f, 0.25133577f, 0.14240876f, -0.00354983f, 0.19636787f, 0.00744064f, 0.07709794f, 
    -0.01844868f, -0.02971394f, -0.08900646f, -0.13908301f, 0.08473396f, -0.01805585f, 0.12036895f, 0.00884733f, 
    -0.03401185f, -0.22460431f, 0.48899600f, -0.41842955f, -0.91008765f, 0.24778360f, 0.15843196f, 0.27735382f, 
    -0.12750244f, -0.13308457f, -0.12785050f, -0.29808435f, -0.35878855f, -0.08420804f, -0.14991221f, 0.01333736f, 
    -0.01903892f, -0.00799309f, 0.02330329f, -0.13813010f, 0.29280758f, 0.21530874f, 0.00321236f, -0.15393838f, 
    -0.00756083f, -0.19390790f, -0.04576486f, 0.00583596f, -0.00611304f, 0.18026026f, -0.34615195f, 0.00195330f, 
    0.09346067f, -0.01070110f, -0.01847674f, -0.00364762f, 0.00699297f, 0.03479777f, 0.27658731f, 0.19945194f, 
    0.06497993f, 0.05545005f, -0.02864881f, -0.06504666f, 0.10016172f, 0.06764643f, 0.08500499f, 0.20619005f, 
    -0.15526308f, 0.13004242f, -0.00328663f, -0.01775764f, -0.03132943f, 0.02609880f, 0.04747126f, 0.17734899f, 
    -0.34430990f, -0.05574622f, -0.08581605f, -0.09433200f, 0.07980828f, 0.03624284f, -0.07755618f, 0.16380975f, 
    -0.20494606f, 0.36081409f, -0.05999834f, 0.15812114f, -0.08414736f, -0.07051136f, 0.05351796f, -0.03515334f, 
    0.20818992f, -0.05632229f, -0.06533932f, 0.03135740f, 0.26010823f, 0.10624738f, -0.03392831f, -0.15084869f, 
    -0.09443817f, 0.18894212f, 0.25013593f, -0.20528232f, -0.16015196f, -0.04460457f, 0.10665927f, -0.03165316f, 
    0.21923438f, -0.06915459f, -0.00246681f, 0.04137168f, 0.13006245f, -0.07571390f, 0.04503454f, 0.02944590f, 
    0.08774230f, 0.00301313f, 0.17115298f, -0.17494693f, 0.07054760f, -0.26030400f, -0.05042878f, 0.17456739f, 
    0.10402814f, 0.03446035f, -0.06703583f, 0.10806030f, 0.03467358f, 0.07698014f, 0.15704998f, -0.23524456f, 
    0.03922563f, 0.16508390f, -0.11113487f, -0.01743711f, -0.00627218f, -0.46552807f, 0.05192373f, -0.27271494f, 
    -0.38810602f, -0.27380618f, -0.17284842f, -0.16627400f, 0.13644572f, 0.04289297f, 0.06882160f, 0.00339275f, 
    0.09144282f, -0.04524068f, 0.21578224f, 0.06582821f, -0.03249187f, 0.16076040f, -0.02320137f, 0.01752000f, 
    0.00511026f, -0.25123054f, -0.25449559f, -0.00647792f, 0.08602083f, -0.03923520f, 0.06722512f, 0.09836567f, 
    0.02672829f, 0.21202917f, 0.04943024f, -0.03149012f, 0.10889903f, -0.25085667f, -0.07413267f, 0.02587156f, 
    0.24691933f, -0.09892768f, 0.13998540f, -0.26078957f, -0.14972290f, 0.04541463f, -0.01747857f, -0.09128162f, 
    -0.07931601f, 0.07747552f, 0.01599155f, 0.17031062f, -0.13391052f, 0.01798455f, 0.21879424f, -0.17802371f, 
    0.02535947f, -0.14926983f, -0.05377192f, -0.06385106f, 0.01830175f, -0.08902080f, -0.17052464f, 0.00788676f, 
    -0.11051928f, 0.10327747f, -0.09071305f, 0.09337436f, -0.01738755f, 0.12574409f, -0.09544814f, 0.05159590f, 
    -0.05977474f, 0.04715187f, 0.16348226f, 0.01012869f, 0.03654435f, -0.04046443f, -0.13061382f, -0.20697616f, 
    -0.08986134f, 0.03317042f, -0.04577451f, 0.12441517f, -0.06652870f, 0.17553577f, 0.02792468f, 0.13795125f, 
    -0.17635258f, -0.41119665f, 0.08870611f, -0.02684850f, -0.13242249f, -0.15291244f, -0.00727184f, -0.04097141f, 
    -0.06466762f, -0.14897358f, -0.52731287f, 0.03806488f, -0.00068488f, 0.00149614f, -0.26076421f, 0.02090174f, 
    -0.14946193f, 0.05561014f, 0.44296131f, -0.28981501f, -0.42361963f, 0.17522117f, 0.12234860f, 0.13682665f, 
    0.01573641f, 0.23859727f, -0.07257196f, -0.20842147f, -0.25964779f, 0.21432465f, 0.13758807f, 0.15008745f, 
    -0.43859512f, 0.09494839f, -0.04279363f, 0.24319893f, -0.37967038f, -0.24397376f, -0.13277738f, 0.00305904f, 
    0.29419816f, -0.13339403f, -0.05395505f, -0.07334060f, 0.00320693f, -0.33883315f, -0.14672342f, 0.15083945f, 
    0.00143888f, -0.03322717f, -0.03068478f, 0.01443029f, -0.02909347f, 0.13129695f, 0.02617450f, -0.00753508f, 
    -0.10619443f, 0.08136351f, -0.00334399f, -0.02716221f, 0.15745096f, 0.21887206f, -0.01208259f, -0.24889708f, 
    0.16125736f, 0.00136495f, -0.13796289f, 0.08035152f, 0.09803692f, -0.03566627f, 0.01406380f, 0.02133447f, 
    0.12329143f, -0.04496249f, 0.07527752f, -0.07191450f, -0.03094766f, -0.17774414f, 0.01792250f, 0.06156972f, 
    0.30871332f, 0.22074312f, 0.12902346f, -0.00375120f, 0.12104771f, -0.04605031f, -0.01217121f, 0.07081484f, 
    0.05620332f, -0.07458137f, 0.49185407f, -0.48309800f, -0.64213765f, 0.04836550f, 0.12108995f, 0.11759057f, 
    0.24067633f, -0.13836075f, -0.39391080f, -0.05065870f, -0.01712195f, 0.01903243f, -0.06738974f, -0.19044724f, 
    -0.01240633f, 0.26199308f, 0.09037252f, -0.18570900f, 0.08578379f, 0.08337238f, 0.04976176f, 0.04292464f, 
    0.19119625f, -0.03801129f, -0.04970024f, -0.13141365f, 0.08701237f, 0.02814769f, -0.00558793f, -0.08555632f, 
    0.08934844f, 0.04609358f, 0.06065547f, -0.13936596f, 0.08474569f, 0.00066385f, -0.14064133f, 0.06909637f, 
    0.41362107f, 0.10769001f, 0.01650750f, -0.06713017f, -0.04075782f, 0.00513828f, 0.03081178f, 0.02323522f, 
    0.06213959f, -0.05466466f, -0.18697774f, -0.14450869f, -0.05964435f, 0.07876031f, 0.06039162f, 0.13862996f, 
    0.24247560f, -0.00831243f, -0.14929484f, -0.04933088f, 0.07826382f, 0.02515480f, -0.06198189f, 0.02436368f, 
    0.05081469f, 0.07918702f, 0.09902751f, -0.07498349f, -0.30293679f, -0.07732072f, -0.15919647f, 0.04290543f, 
    0.00277903f, 0.04287567f, -0.08057843f, 0.18880962f, 0.41390324f, 0.14206557f, 0.23182854f, -0.04214143f, 
    0.02073530f, -0.14458038f, 0.04624039f, -0.33957118f, 0.07951504f, 0.02116547f, 0.04130880f, 0.02302999f, 
    0.12776202f, -0.19122481f, 0.05742753f, 0.18382180f, 0.19711842f, 0.16945764f, -0.02949840f, -0.04618499f, 
    -0.17876944f, -0.00930210f, -0.04764553f, 0.21360265f, 0.02353845f, -0.01055577f, -0.01661975f, -0.07678325f, 
    0.10549546f, 0.13199872f, 0.05763543f, 0.02699964f, -0.10380823f, 0.20145521f, 0.16846102f, 0.18015981f, 
    -0.11729601f, -0.20872991f, 0.02613661f, -0.05436300f, -0.12334657f, 0.18930757f, 0.01967524f, -0.11874312f, 
    0.07646473f, -0.02935020f, -0.01072237f, -0.01755113f, 0.09231889f, -0.07282248f, -0.08347528f, -0.10543999f, 
    0.25550243f, -0.00908968f, -0.00116140f, -0.20091246f, 0.05340420f, 0.04097574f, 0.01237701f, -0.06753592f, 
    -0.06256819f, 0.16450532f, -0.06130939f, 0.09202084f, -0.00299693f, -0.08791299f, 0.13632587f, -0.07299289f, 
    0.00111541f, 0.01824425f, 0.17819294f, 0.05890695f, -0.18189140f, -0.14594205f, -0.05993973f, 0.00340898f, 
    0.05793918f, -0.00313895f, -0.00167596f, 0.14173891f, 0.15533423f, 0.13371745f, -0.04777344f, -0.09160607f, 
    -0.09485245f, -0.14623179f, -0.12380332f, 0.04823209f, 0.09829359f, 0.00328076f, -0.16139279f, 0.10371140f, 
    0.10279046f, 0.05818959f, -0.04816839f, -0.02218989f, 0.17497787f, 0.14374146f, 0.06146096f, -0.07510114f, 
    -0.01445494f, -0.08774056f, -0.09377723f, 0.00484471f, 0.26197222f, 0.18441606f, 0.32405782f, -0.18607055f, 
    -0.24918242f, -0.04223684f, 0.08423350f, -0.01797848f, 0.09345892f, 0.00239520f, 0.13199198f, -0.47229198f, 
    -0.38105768f, 0.36314607f, 0.09402606f, -0.03294324f, -0.24457377f, 0.24006762f, 0.11186287f, 0.00762027f, 
    0.12977171f, 0.15681250f, 0.07186793f, -0.03437144f, 0.06427532f, 0.01087607f, 0.12491087f, 0.03415592f, 
    -0.00018469f, 0.02506527f, -0.01138435f, -0.26222003f, 0.10128970f, -0.04086622f, 0.01073122f, 0.06455584f, 
    0.08533727f, 0.15205027f, 0.30989277f, 0.14925767f, 0.08690341f, 0.09037266f, 0.11073014f, 0.12271211f, 
    -0.10014046f, -0.02658466f, -0.26977736f, -0.05157193f, -0.19229893f, -0.08838554f, 0.09659008f, 0.20080912f, 
    -0.13468438f, 0.05188054f, 0.18565431f, -0.08201682f, 0.00325552f, 0.27530462f, -0.23936397f, -0.13982297f, 
    -0.01398354f, -0.07092544f, 0.01897741f, 0.01258918f, -0.08218918f, -0.24332266f, 0.01958572f, -0.03430618f, 
    0.02150782f, 0.11776064f, 0.02100282f, 0.11200848f, 0.10597315f, 0.03301439f, 0.09284983f, 0.00773412f, 
    0.22417267f, -0.00135285f, -0.01851010f, -0.03534937f, -0.03264917f, 0.30618757f, 0.05714658f, 0.13369913f, 
    0.12636389f, 0.07026768f, -0.02824758f, -0.07576730f, 0.17063279f, -0.15492199f, 0.19907427f, -0.21884076f, 
    0.02373771f, -0.06025568f, 0.09289970f, 0.09508726f, 0.04469351f, -0.00306636f, -0.24779022f, -0.18047023f, 
    -0.22037935f, 0.00169404f, 0.12455375f, 0.16233931f, -0.04521982f, -0.05464972f, -0.13787049f, 0.04763735f, 
    -0.05611246f, 0.11699522f, 0.41997871f, 0.37205169f, -0.08089758f, 0.05429702f, 0.24843016f, 0.31021643f, 
    0.01330039f, 0.33233929f, -0.00528782f, -0.14787807f, 0.11528613f, 0.23300700f, 0.11941545f, 0.19119252f, 
    -0.00100015f, -0.02033562f, 0.00089485f, 0.01504732f, 0.09087176f, -0.17630827f, -0.09216236f, 0.04645273f, 
    0.02622398f, -0.12891483f, 0.08151316f, -0.03689701f, -0.09684732f, -0.04791855f, -0.07621476f, 0.14321564f, 
    0.08729127f, 0.00741742f, 0.13866454f, -0.15013377f, 0.08203833f, 0.09834304f, 0.01943192f, 0.09415282f, 
    -0.09851669f, -0.13157615f, 0.06701363f, -0.04812770f, 0.13684531f, 0.07320344f, -0.05488913f, -0.00483141f, 
    0.05573184f, -0.02803625f, 0.26262730f, 0.07129303f, 0.05835967f, -0.21673465f, -0.08903851f, -0.17918767f, 
    0.23781998f, 0.07034159f, 0.11776131f, -0.05906732f, 0.12848164f, 0.10849326f, 0.03435916f, 0.03722374f, 
    0.14425671f, 0.07178766f, 0.06949845f, 0.13104405f, 0.19294868f, 0.01016145f, 0.07541143f, -0.17965479f, 
    0.04696002f, 0.00243733f, 0.09314343f, -0.22203112f, -0.29947609f, -0.13253976f, -0.14517175f, -0.15596473f, 
    -0.05906891f, -0.00948768f, -0.06984709f, 0.02564758f, -0.24330434f, -0.02063632f, -0.03236631f, 0.05333581f, 
    -0.11117926f, -0.20813994f, -0.15751933f, -0.06095079f, 0.07652198f, 0.20891581f, -0.01875927f, -0.11520488f, 
    -0.24680687f, 0.00957591f, -0.13967523f, -0.01660866f, -0.01393625f, 0.06528872f, -0.26980075f, -0.23380309f, 
    -0.09247345f, -0.09991037f, -0.12471109f, -0.03659901f, -0.21089913f, -0.15497714f, 0.19925945f, 0.29168567f, 
    0.08937199f, -0.05073018f, 0.04437412f, 0.13845219f, -0.06977267f, -0.00835306f, -0.08593746f, 0.11399679f, 
    0.00281406f, 0.43871263f, 0.02092675f, 0.08324571f, 0.04702087f, -0.02789227f, -0.10272250f, 0.13321222f, 
    0.18305208f, 0.10030283f, 0.12785836f, -0.04024690f, 0.07618824f, 0.09472359f, 0.17491911f, 0.11354204f, 
    0.03973153f, -0.16117990f, 0.25092438f, -0.00533859f, 0.11247406f, -0.06442950f, 0.01771987f, 0.23416932f, 
    0.15879397f, -0.02332854f, -0.03719540f, 0.22482623f, 0.12986845f, 0.20728430f, 0.07702342f, -0.12982035f, 
    0.05252185f, 0.07610790f, -0.08472922f, -0.16687790f, -0.19615339f, -0.32671392f, -0.05277263f, 0.01961310f, 
    -0.07722572f, 0.04186124f, -0.09044884f, 0.04743239f, -0.03731189f, 0.01495185f, -0.17192909f, 0.02967742f, 
    -0.07701509f, -0.02570498f, 0.05488695f, -0.13297199f, 0.06123503f, -0.03762666f, 0.13474073f, -0.02242843f, 
    0.09911370f, -0.04661519f, -0.01089065f, -0.33968273f, -0.30732998f, -0.12901443f, 0.19458197f, 0.06684463f, 
    -0.00824938f, 0.03148839f, 0.29635164f, -0.03037985f, 0.10490448f, 0.11561377f, 0.23795997f, -0.42497489f, 
    -0.05048854f, 0.01730439f, 0.04928599f, 0.03913870f, 0.00233189f, 0.10441489f, -0.03879148f, -0.08229743f, 
    -0.29263613f, -0.00778136f, 0.18211503f, -0.17003322f, 0.00046751f, -0.26643080f, 0.03175044f, 0.09881832f, 
    -0.02500818f, -0.01573540f, 0.16790733f, 0.17583764f, 0.10003111f, -0.03959122f, -0.18539880f, 0.04945073f, 
    0.02885520f, -0.01024871f, -0.42259392f, -0.35537130f, 0.29984549f, -0.05081537f, 0.18096471f, 0.15312003f, 
    -0.01360278f, -0.08784512f, 0.08328819f, -0.25977233f, 0.08359143f, 0.39590344f, 0.20005244f, 0.00252917f, 
    -0.07399058f, -0.05938116f, -0.12956975f, 0.12099300f, 0.15347897f, 0.06843731f, -0.10083077f, -0.05599475f, 
    0.06255227f, -0.15407725f, 0.08597784f, -0.01057754f, 0.03806659f, -0.12651572f, 0.22270730f, -0.10934652f, 
    -0.01796915f, 0.00667668f, 0.08828586f, 0.08201573f, 0.08479278f, 0.17475888f, 0.21535480f, -0.08583395f, 
    0.13234010f, -0.21075998f, -0.01272743f, -0.08266201f, -0.05483610f, -0.01382705f, 0.13590755f, 0.01434909f, 
    -0.21893562f, 0.14897557f, 0.07287737f, 0.02398425f, -0.27757087f, -0.05681144f, -0.13760732f, 0.07525120f, 
    -0.20620765f, -0.15340447f, 0.16209742f, -0.00112095f, 0.10446312f, 0.05742954f, 0.17485236f, 0.04507578f, 
    -0.16277806f, -0.12401419f, -0.13704181f, -0.02699485f, -0.05627813f, -0.31383631f, -0.07081418f, -0.03606887f, 
    0.19584836f, 0.01134566f, 0.28479868f, -0.62547368f, -0.61430281f, -0.02771503f, 0.14226864f, 0.52098250f, 
    -0.12605490f, 0.09257407f, 0.21502282f, 0.22994240f, -0.36916661f, -0.08266743f, 0.02454847f, -0.06038880f, 
    0.01094274f, -0.06066711f, 0.00441282f, -0.11426727f, 0.02882309f, -0.26594013f, 0.16644114f, -0.04732631f, 
    0.18302184f, -0.03348007f, -0.08019613f, -0.01504873f, -0.10635871f, 0.36543974f, -0.19643798f, -0.19854526f, 
    0.07647002f, -0.04439610f, -0.08340292f, 0.00368075f, 0.11399135f, -0.16056561f, 0.31453776f, -0.16576068f, 
    -0.06762143f, 0.05939731f, 0.29351377f, -0.00131266f, 0.05897567f, 0.07108778f, 0.16017997f, 0.05548824f, 
    -0.16137883f, 0.18779843f, 0.03376230f, 0.03011834f, -0.10948285f, 0.01515664f, -0.11014248f, 0.03762484f, 
    -0.28162694f, -0.14557126f, -0.05854652f, -0.23568380f, -0.01636104f, 0.00916429f, -0.11296599f, 0.13039725f, 
    0.09406310f, 0.28274161f, -0.14205706f, 0.05976384f, -0.12628661f, -0.18608458f, 0.00831319f, -0.06325349f, 
    -0.00434953f, 0.08140033f, -0.05362033f, -0.11427382f, 0.03171503f, 0.09768158f, 0.02826881f, -0.12676193f, 
    0.07907099f, -0.08654705f, -0.00079748f, 0.18344721f, 0.06336762f, -0.18393587f, 0.03867532f, -0.03905023f, 
    0.04673257f, 0.12044127f, 0.01150201f, -0.26622367f, 0.16282341f, -0.26622027f, 0.21445048f, -0.14083003f, 
    -0.16462657f, -0.20558085f, 0.01364382f, -0.12621878f, 0.02988039f, -0.09123867f, -0.10074708f, 0.10728455f, 
    0.10958180f, -0.09410439f, -0.13829355f, 0.07320550f, 0.10492343f, -0.08339351f, 0.13173477f, -0.36426398f, 
    0.11867961f, 0.07434133f, 0.18335409f, 0.20951805f, -0.06053384f, -0.21682362f, 0.07340254f, 0.33422232f, 
    -0.17792462f, -0.11919956f, -0.12782954f, -0.11894524f, -0.07492045f, -0.03234949f, 0.23182608f, 0.07504164f, 
    -0.13297106f, -0.48860642f, 0.32561728f, -0.19866984f, 0.07221539f, 0.22213800f, 0.04224263f, 0.15882085f, 
    0.02187872f, 0.22017585f, -0.13933675f, 0.21027066f, -0.15672387f, 0.03063387f, 0.20802301f, 0.02016740f, 
    0.05436856f, 0.14234704f, 0.34755936f, -0.12222026f, 0.10146253f, -0.06009184f, -0.14691676f, 0.02770040f, 
    0.08665977f, -0.13989533f, -0.09879494f, -0.02477178f, -0.06596661f, -0.01208925f, -0.05153089f, -0.10635163f, 
    -0.15020949f, 0.04382958f, 0.04440609f, 0.07472394f, -0.07330677f, -0.35227683f, 0.35463214f, -0.00542583f, 
    0.02959177f, -0.04736677f, 0.00415173f, 0.07535376f, -0.17767294f, -0.33223119f, -0.17184870f, 0.21808259f, 
    -0.00536384f, -0.05392713f, -0.08223781f, -0.00438384f, -0.00119470f, 0.02541621f, -0.24513713f, -0.08534969f, 
    0.05765387f, -0.17641194f, 0.17883256f, 0.03435444f, 0.10125424f, -0.01456129f, 0.17988551f, 0.04586383f, 
    0.11659101f, -0.07669430f, 0.07565882f, 0.00453572f, 0.05689253f, -0.07290132f, -0.05515100f, 0.03728327f, 
    -0.66322380f, -0.26692829f, -0.24557358f, -0.02475652f, 0.03121776f, 0.07945102f, 0.06937581f, 0.10100751f, 
    0.12115262f, -0.29221079f, -0.39133173f, -0.46569014f, 0.10902315f, 0.15772955f, -0.23898602f, 0.15311141f, 
    0.03993533f, 0.09807879f, 0.24342127f, -0.31386435f, 0.30671501f, -0.07878775f, 0.35316980f, 0.22589734f, 
    0.25681415f, 0.02638415f, 0.33771357f, -0.05559506f, -0.19684547f, 0.05633149f, 0.24496041f, 0.14009033f, 
    0.08785574f, 0.16215368f, 0.03369654f, 0.17968859f, -0.22979543f, -0.08392067f, -0.44917834f, -0.48235217f, 
    -0.16976339f, -0.13899916f, 0.03959818f, 0.10622600f, -0.00502599f, -0.28906119f, -0.07868117f, -0.17428586f, 
    0.01373336f, -0.22653514f, -0.12919064f, 0.12915158f, 0.25474811f, 0.12312710f, -0.04656192f, -0.24947938f, 
    0.10199772f, 0.00700370f, 0.06199544f, -0.14032781f, 0.10790731f, 0.14890839f, 0.11018878f, -0.10123261f, 
    0.01074503f, 0.09051233f, 0.19391365f, 0.28804773f, 0.05849598f, 0.10921421f, 0.15641549f, 0.17970011f, 
    -0.21713090f, 0.02523650f, 0.22608626f, -0.03518459f, -0.00578229f, 0.01132588f, -0.27155611f, 0.03457153f, 
    -0.12454640f, -0.07096121f, -0.19177048f, 0.13489392f, 0.00639611f, 0.06998520f, -0.12998754f, -0.02109583f, 
    0.05813826f, -0.01335357f, 0.38125169f, -0.37146389f, -0.32343650f, 0.11356657f, -0.10452602f, 0.02672769f, 
    -0.01199886f, 0.10938695f, 0.16054894f, 0.02908859f, -0.13503575f, 0.06978036f, 0.23173997f, 0.08068710f, 
    -0.05576686f, 0.14909674f, 0.05397296f, -0.00249578f, -0.44719970f, 0.06152034f, 0.26193655f, 0.08568133f, 
    0.06501996f, 0.03242478f, -0.08159336f, -0.00774325f, 0.11692564f, 0.01400077f, -0.10405979f, -0.04060628f, 
    0.06203280f, 0.23136441f, -0.10621250f, 0.33678326f, 0.23074649f, -0.00488933f, -0.17533080f, 0.15617533f, 
    0.22784352f, -0.02496755f, 0.01448451f, -0.04047807f, 0.16170590f, 0.13047846f, 0.21366884f, 0.06504788f, 
    -0.05754125f, -0.08923137f, 0.15508233f, -0.08338214f, -0.07406487f, 0.01762439f, 0.02057541f, -0.14082426f, 
    0.29411414f, 0.09223697f, -0.06931517f, -0.02593715f, 0.07237753f, 0.24347541f, -0.10259391f, 0.06145791f, 
    0.30768386f, -0.11304425f, -0.03135417f, -0.17587371f, 0.14783248f, 0.02511637f, -0.04115441f, -0.00348531f, 
    0.10268667f, 0.09077322f, -0.36557326f, -0.02270583f, 0.33349130f, -0.06375647f, 0.12004237f, -0.05053649f, 
    0.00418313f, -0.10934234f, -0.05151323f, 0.15866052f, 0.07045759f, 0.12966017f, 0.12928784f, -0.01098497f, 
    0.05187342f, -0.09934167f, 0.04397570f, 0.08161776f, 0.03003851f, -0.11604173f, 0.10876036f, -0.07684258f, 
    -0.22316113f, 0.00826088f, -0.19559313f, 0.06158595f, 0.03818609f, -0.36199608f, -0.15276882f, 0.20990644f, 
    -0.05971533f, -0.05606383f, 0.00730972f, -0.16962211f, -0.19647174f, -0.16454694f, 0.12463102f, -0.28391665f, 
    0.37722364f, -0.12535407f, 0.04690726f, 0.02898863f, -0.11879905f, -0.14708854f, 0.16178361f, -0.13174406f, 
    -0.05667534f, -0.19703244f, 0.00259034f, 0.14731908f, -0.24396409f, 0.31175590f, -0.01274319f, 0.19050586f, 
    0.01111369f, 0.09917762f, 0.01833229f, -0.02371741f, 0.06808900f, 0.05688694f, 0.14664105f, 0.27149963f, 
    0.15867773f, 0.07788110f, 0.22293253f, 0.21916862f, 0.02993894f, -0.09547275f, 0.02196064f, 0.14248815f, 
    -0.13805328f, -0.01534131f, -0.09017605f, 0.01458410f, -0.08486032f, -0.04208942f, 0.04149465f, -0.13435602f, 
    -0.04900161f, -0.01786290f, -0.02598155f, -0.42365375f, -0.50165164f, 0.23457600f, -0.07638323f, 0.04819753f, 
    -0.11310002f, -0.13851131f, -0.17636119f, 0.04806837f, -0.06949810f, -0.12037949f, -0.05856870f, 0.14439142f, 
    -0.06287754f, 0.12673140f, 0.02757328f, -0.04416843f, -0.01844931f, 0.00056035f, 0.02931086f, -0.13300808f, 
    0.00555044f, -0.07911353f, -0.03297804f, -0.07896278f, -0.09861434f, -0.38048300f, -0.01125738f, -0.20822042f, 
    -0.17189489f, -0.02573213f, -0.01406841f, -0.05807231f, 0.07528062f, 0.21243744f, 0.06328925f, -0.20698152f, 
    -0.14880559f, -0.17505047f, 0.15236752f, 0.15729079f, -0.06905688f, 0.19436440f, 0.03148856f, 0.12624560f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.26495364f, 0.01888942f, 0.13519512f, 0.17474477f, -0.01282143f, -0.05544318f, 0.15561818f, -0.04353584f, 
    0.03139235f, 0.02859083f, 0.16114399f, -0.03403011f, 0.29020745f, -0.03779682f, 0.01514002f, -0.03837781f, 
    0.14355442f, 0.09297274f, -0.02644352f, -0.03241273f, -0.05448093f, -0.03892191f, -0.03846160f, -0.02950381f, 
    0.10913511f, -0.12616962f, -0.03226093f, 0.16900231f, 0.01915281f, 0.03210806f, 0.16647317f, 0.31471074f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24991363f, 0.04359470f, 0.15304384f, -0.06201059f, 0.16786635f, -0.07984867f, 0.15168594f, 0.02115419f, 
    0.26392171f, -0.04798831f, -0.02671848f, -0.05069072f, -0.13511586f, 0.09451070f, -0.06648789f, -0.13030456f, 
    0.19509058f, -0.06646631f, -0.33827400f, 0.01561863f, 0.60615456f, -0.14030734f, -0.08509693f, 0.10047790f, 
    0.04915149f, 0.33868530f, 0.14654785f, 0.12506060f, 0.29998171f, -0.16201274f, -0.14398493f, -0.14614825f, 
    0.32673585f, 0.30994773f, -0.47595116f, 0.15048534f, -0.04109096f, -0.00924918f, -0.01285371f, 0.00373897f, 
    -0.02995288f, -0.02741315f, 0.05015912f, 0.18250558f, 0.41128832f, 0.34857932f, 0.12734812f, -0.03915792f, 
    0.69789141f, -0.04776494f, -0.37329325f, -0.24831623f, 0.16992247f, -0.03991180f, -0.01472278f, 0.09779651f, 
    -0.29434949f, -0.27587426f, -0.32669610f, -0.25710022f, -0.11598984f, -0.00467473f, -0.46153730f, -0.09399474f, 
    0.11892579f, -0.14969428f, 0.39566320f, 0.16182016f, -0.12469395f, 0.15218069f, 0.19846885f, 0.16569184f, 
    0.24458405f, 0.16867989f, -0.29315075f, 0.04940988f, -0.10822436f, 0.01727608f, 0.11168816f, 0.03243100f, 
    -0.22389767f, -0.04525062f, -0.59497041f, -0.97309107f, -0.11997924f, 0.03150760f, 0.01473633f, 0.15217471f, 
    0.40406114f, 0.20721853f, 0.47951403f, 0.09000529f, 0.00455178f, -0.63984632f, -0.07833140f, -0.15344302f, 
    0.20201021f, -0.03200916f, 0.07408750f, 0.12893881f, 0.09738897f, -0.08283162f, 0.10372759f, 0.08873413f, 
    -0.28072262f, 0.03490541f, -0.25526536f, -0.18165345f, -0.01698013f, 0.01398635f, -0.02942627f, 0.05640076f, 
    0.16312142f, 0.16999744f, 0.44479656f, 0.06680324f, 0.48877198f, -0.05222854f, 0.06066637f, -0.12413932f, 
    -0.17185424f, -0.34199682f, -0.28017578f, 0.60229939f, -0.08941094f, 0.25147018f, 0.47122160f, 0.46234477f, 
    -0.05236267f, -0.14336638f, 0.24559586f, 0.03453880f, -0.09857563f, -0.04307021f, 0.10579722f, 0.12026392f, 
    0.39176890f, 0.14000085f, -0.23238243f, -0.05658314f, -0.13071854f, 0.20871417f, 0.13964902f, -0.05108804f, 
    0.29059032f, -0.14906691f, -0.82322335f, -0.02865659f, 0.17609504f, 0.05789330f, -0.02961372f, -0.03240253f, 
    -0.06896519f, 0.27934429f, 0.27075732f, -0.13069110f, 0.56392819f, -0.06307238f, -0.28708833f, -0.07337393f, 
    0.18972841f, 0.21544287f, 0.09987223f, 0.20932317f, 0.04642956f, -0.14171855f, -0.23272115f, -0.07197671f, 
    0.28335121f, -0.11617577f, -0.02487494f, -0.25359839f, -0.05515284f, -0.08865122f, 0.07783426f, 0.08818962f, 
    0.33253023f, -0.12447311f, -0.26514775f, -0.70703948f, -0.11610628f, 0.01720585f, -0.08391882f, -0.12951733f, 
    0.23004422f, -0.26458889f, 0.25596699f, 0.35597241f, -0.00547545f, 0.06572518f, 0.21010359f, 0.02287829f, 
    0.00250079f, 0.19371235f, -0.22498544f, 0.54436970f, 0.07385971f, 0.05929192f, 0.57308787f, 0.16554663f, 
    0.15222332f, 0.04308730f, 0.27740681f, -0.17560336f, -0.16314451f, -0.13352384f, 0.08450861f, -0.01693517f, 
    0.24056095f, -0.28686816f, 0.98881739f, -0.00670716f, 0.00243135f, 0.12752534f, -0.09345818f, 0.01874995f, 
    0.32136220f, 0.32881173f, -0.12402842f, -0.07642011f, -0.36794633f, -0.02229693f, 0.16525963f, -0.11425059f, 
    0.20088983f, 0.16374315f, -0.43890887f, 0.14169607f, 0.14010157f, -0.02530779f, 0.20715709f, -0.11491562f, 
    -0.07583230f, -0.09092365f, -0.02615317f, 0.58665264f, 0.25296712f, 0.23100384f, -0.08561964f, 0.12273519f, 
    -0.45194608f, 0.26905054f, -0.33919290f, 0.52184772f, 0.20115432f, 0.06006458f, 0.09454198f, -0.07964335f, 
    -0.22035217f, 0.28275278f, -0.23921761f, 0.27143061f, -0.16891856f, -0.05267983f, 0.39656162f, -0.20985796f, 
    0.21932173f, 0.46369979f, -0.17185903f, 0.65066564f, -0.06218259f, -0.15905564f, -0.67761832f, 0.01387942f, 
    -0.30745327f, -0.08002397f, -0.04224723f, 0.03968558f, -0.38953388f, 0.08667563f, -0.13960901f, 0.15606804f, 
    -0.21799831f, 0.22640207f, 0.40513939f, -0.20489107f, 0.06400238f, 0.12608801f, -0.12218247f, 0.01776592f, 
    -0.08036473f, 0.10049869f, -0.07631765f, 0.13521312f, -0.06944644f, -0.39136234f, 0.58572179f, 0.25211120f, 
    -0.14814964f, -0.33904812f, 0.07087340f, 0.17505412f, 0.05716044f, 0.00469099f, 0.66699159f, -0.17181595f, 
    0.09506018f, -0.06724031f, -0.12503302f, -0.23749202f, -0.31757954f, 0.16568960f, -0.00329692f, -0.13798213f, 
    -0.14697690f, 0.09264016f, -0.59592044f, 0.46748066f, 0.37488824f, -0.03736935f, 0.02684744f, 0.11543314f, 
    -0.10908344f, 0.37303373f, -0.12168381f, 0.82781285f, 0.34786898f, 0.11442490f, -0.03604267f, 0.15984677f, 
    -0.01162245f, 0.14826465f, -0.02911933f, 0.20538774f, -0.02183107f, 0.12723882f, 0.10574418f, 0.12584808f, 
    -0.15174264f, -0.09602489f, -0.01442982f, 0.15435897f, 0.68703717f, -0.07817519f, 0.00619281f, -0.08679088f, 
    0.45560232f, -0.09226083f, 0.95229858f, 0.45962200f, 0.34652975f, 0.08198887f, 0.06713024f, -0.02449864f, 
    0.06621858f, -0.03754828f, -0.27354038f, -0.15530196f, 0.03925762f, 0.13689518f, -0.02233515f, -0.12555143f, 
    -0.14134827f, 0.18021059f, 0.42222893f, 0.02762202f, 0.07078037f, -0.02515758f, -0.29653779f, -0.02168499f, 
    -0.07016597f, 0.10773693f, -0.02021097f, -0.26554033f, 0.44406536f, -0.23124181f, 0.07164825f, 0.14930426f, 
    0.12952411f, -0.00770256f, 0.91880697f, -0.03536329f, 0.33806556f, -0.01187219f, -0.06933836f, 0.05820052f, 
    -0.07991543f, 0.08508933f, 0.03415945f, 0.56389099f, 0.11700782f, 0.19096737f, 0.44704515f, 0.05228990f, 
    -0.07300401f, -0.01420723f, -0.01172673f, -0.02349366f, 0.09894583f, 0.10267384f, 0.15145935f, 0.04054305f, 
    -0.12759957f, -0.14067653f, 0.12208454f, -0.13135451f, 0.09608433f, -0.15472500f, -0.16263422f, -0.07983970f, 
    -0.07491786f, -0.02465944f, 0.16260476f, -0.03007462f, -0.07630800f, -0.12001091f, 0.13993452f, -0.12562707f, 
    -0.04921076f, -0.05033441f, -0.13892274f, -0.00486778f, 0.03738505f, -0.19762000f, 0.13385326f, 0.06286503f, 
    -0.17337616f, 0.01314577f, -0.08342782f, -0.13954179f, 0.00777443f, -0.06266984f, -0.04012886f, 0.03796727f, 
    0.10839402f, 0.15667798f, 0.05547565f, -0.05614586f, -0.14159453f, -0.10472967f, 0.12953557f, -0.09889619f, 
    -0.16243950f, -0.06563804f, -0.04065771f, 0.01282296f, -0.07738939f, -0.02275928f, -0.09503435f, -0.14644310f, 
    0.06049388f, -0.05781367f, -0.15478237f, 0.01534246f, 0.06408098f, -0.01362128f, 0.12539767f, -0.05398652f, 
    -0.10571966f, 0.01399314f, 0.04476771f, 0.12052935f, 0.04229546f, 0.04213296f, 0.16855958f, -0.02162306f, 
    -0.06683803f, -0.12876002f, 0.15734465f, 0.13459462f, -0.16907103f, -0.07877839f, -0.01888183f, -0.10145117f, 
    -0.03538791f, -0.00144919f, -0.02554702f, -0.17108205f, -0.17103013f, -0.13916659f, 0.07532818f, -0.11559277f, 
    -0.06094829f, -0.02352631f, -0.09720784f, -0.02674792f, -0.15860087f, -0.15434416f, -0.12791038f, -0.12643085f, 
    0.18064892f, -0.11784016f, -0.03409541f, 0.24381410f, 0.11250810f, 0.15688491f, 0.58291554f, -0.05398897f, 
    0.11528646f, 0.15181880f, 0.33790401f, 0.11399277f, -0.55399233f, 0.02063687f, 0.11645548f, 0.13248417f, 
    -0.49350852f, -0.07922776f, -0.86260629f, -0.32656583f, 0.09689812f, -0.06954987f, 0.06229974f, -0.04906496f, 
    0.17541774f, 0.44446313f, 0.33344510f, 0.57897216f, 0.02358450f, -0.34363291f, -0.18455161f, -0.20193781f, 
    0.27472994f, 0.08824914f, -0.26910770f, 0.11694606f, 0.05592509f, -0.11894380f, -0.68099582f, -0.11380057f, 
    -0.02469106f, 0.14326601f, -0.17636013f, -0.17240414f, -0.30856538f, 0.42867219f, 0.06788492f, -0.10329179f, 
    0.48281431f, 0.30095083f, -0.65434742f, -0.18957074f, -0.03686700f, -0.10461825f, 0.09204598f, -0.12567215f, 
    -0.27106702f, -0.20275718f, -0.01181679f, -0.11355802f, 0.37518370f, -0.10478846f, 0.26120725f, 0.46024624f, 
    -0.00841749f, -0.11547040f, 0.49724114f, 0.21716781f, -0.04219631f, 0.14711343f, -0.15532734f, -0.07426240f, 
    0.03490591f, 0.04497781f, -0.22796617f, -0.36413246f, -0.40243638f, -0.03173761f, -0.04800941f, -0.11096784f, 
    0.46423998f, 0.15528893f, 0.26494506f, -0.15331911f, -0.06266937f, 0.15099306f, -0.15548511f, -0.02701258f, 
    0.11351285f, -0.15097594f, -0.01947532f, 0.06122473f, 0.37023833f, -0.08849303f, 0.12960802f, 0.49491292f, 
    -0.09845299f, 0.13220534f, 0.04554837f, -0.28555608f, 0.16614817f, 0.09882532f, 0.03736843f, 0.02880392f, 
    -0.05108594f, 0.05859142f, -0.60132784f, 0.45086879f, 0.52889502f, 0.08277974f, 0.04981860f, 0.07338247f, 
    0.14565194f, -0.19927877f, 0.79451424f, 0.35651243f, 0.17325427f, 0.08709709f, 0.11210971f, 0.10969120f, 
    -0.00179378f, 0.18681857f, -0.04620332f, -0.37531620f, 0.23041897f, 0.15173800f, -0.14746530f, -0.02391872f, 
    0.05458209f, -0.00676231f, 0.08359575f, 0.54328871f, -0.11785091f, -0.14527819f, 0.61451250f, 0.01025128f, 
    -0.01173688f, -0.13323379f, 0.40219373f, 0.34503880f, 0.31538880f, -0.15801188f, -0.02740740f, 0.08554786f, 
    -0.38416460f, -0.07655328f, 0.77216464f, 0.53503007f, 0.13836546f, 0.06800944f, 0.10816734f, -0.15247117f, 
    0.23471975f, 0.45732588f, 0.09151394f, -0.48122868f, 0.10525924f, -0.19686122f, -0.42451864f, -0.03602061f, 
    -0.15489849f, -0.09033208f, 0.02907694f, -0.12444554f, -0.04142934f, 0.03974788f, -0.14940561f, -0.08615256f, 
    -0.05147897f, -0.05886869f, 0.02654321f, 0.13828224f, 0.07334444f, 0.05212918f, -0.15160364f, 0.02609497f, 
    -0.09545609f, -0.12125365f, -0.02985469f, -0.13299455f, 0.00099473f, -0.10338605f, 0.15460937f, 0.09861599f, 
    -0.06123341f, -0.16180792f, -0.04466961f, -0.01299503f, -0.01780672f, -0.21527791f, -0.06756841f, 0.05786015f, 
    -0.10928767f, 0.07885140f, -0.10592403f, 0.10684839f, -0.10198364f, 0.09548831f, -0.06550169f, -0.04386044f, 
    0.02217127f, -0.11515094f, 0.07126606f, -0.20364426f, -0.15036006f, -0.17806794f, -0.15177514f, 0.02484808f, 
    -0.10066494f, -0.12214693f, 0.02367831f, 0.05419203f, 0.10541429f, -0.04579120f, 0.07938556f, -0.02405898f, 
    -0.01158300f, -0.09568676f, -0.08426768f, -0.15121458f, 0.00025219f, -0.10650779f, -0.17432359f, -0.12942925f, 
    -0.23477913f, -0.19898553f, 0.13152991f, -0.36359546f, -0.17449507f, 0.09376605f, -0.09365351f, -0.14534020f, 
    0.00866542f, 0.15837482f, 0.19352211f, -0.14103405f, 0.12792560f, -0.01092502f, -0.17348255f, -0.15947516f, 
    0.10793496f, -0.12270451f, -0.17163816f, -0.26055825f, -0.13755497f, 0.05752455f, 0.16545948f, -0.09718402f, 
    -0.18161350f, -0.29341060f, 0.08734442f, 0.03668457f, -0.08538352f, 0.04017210f, -0.35972297f, -0.15638719f, 
    -0.12582111f, -0.06383562f, 0.01603968f, -0.22879136f, -0.08889044f, -0.15331841f, 0.59746110f, -0.04537567f, 
    0.15190375f, -0.16539718f, -0.23294263f, 0.03404710f, 0.11189640f, 0.17896387f, 0.05456655f, 0.06948731f, 
    -0.06959435f, 0.10127619f, -0.12468772f, 0.15421776f, 0.37067235f, -0.12591791f, -0.09532987f, -0.16581538f, 
    -0.12979114f, -0.32457536f, 0.00319580f, 0.76264310f, -0.12304957f, 0.32443583f, 0.46239820f, -0.19618559f, 
    0.28224418f, -0.21576437f, 0.31312481f, 0.02902029f, 0.03969613f, 0.02981452f, 0.41570309f, -0.09607808f, 
    0.14564718f, 0.11250229f, -0.54093122f, 0.12879287f, 0.28172711f, 0.09086420f, -0.16370803f, -0.13409193f, 
    -0.13784717f, 0.15376449f, 0.20930666f, -0.29463980f, -0.58391082f, -0.11980197f, -0.06709418f, -0.06809896f, 
    0.22833461f, 0.02324387f, 0.06352717f, -0.28416988f, 0.20487301f, -0.33521074f, -0.56724632f, 0.24455075f, 
    -0.01632882f, -0.12933573f, -0.15374267f, 0.14646690f, 0.03967965f, -0.16703451f, -0.14129843f, 0.04855188f, 
    -0.00954881f, 0.13639918f, 0.22625940f, -0.29742867f, 0.13992319f, 0.15765475f, 0.02085902f, -0.00363696f, 
    0.55169249f, 0.04868314f, -0.33503515f, -0.14216788f, -0.33962718f, -0.13008855f, -0.02879520f, 0.11940224f, 
    0.16910130f, -0.22041416f, -0.00795557f, -0.46121439f, -0.27076223f, 0.13047034f, -0.19655876f, 0.05055028f, 
    -0.14096451f, -0.13738677f, 0.02183061f, -0.05212869f, -0.04783798f, 0.01676071f, -0.19375978f, 0.00378133f, 
    -0.08616021f, 0.09058820f, 0.02597985f, -0.19138356f, -0.19265793f, 0.01071016f, -0.12660298f, -0.15862271f, 
    -0.05250037f, 0.00638522f, 0.12429730f, -0.06863094f, 0.07365573f, -0.16490711f, -0.17977284f, -0.02419112f, 
    0.18460956f, -0.20322487f, 0.04568375f, 0.10257909f, 0.20204177f, 0.21185352f, 0.03972605f, -0.14200212f, 
    0.30749434f, -0.18603115f, 0.21026501f, 0.01049544f, 0.11377662f, 0.04326926f, 0.17840920f, -0.13187976f, 
    0.20334551f, -0.06173728f, -0.33651900f, 0.18826605f, 0.43574765f, 0.11477707f, -0.05279690f, 0.05070013f, 
    0.34535196f, 0.10499053f, -0.11829287f, -0.02450556f, -0.39734998f, 0.03552113f, -0.14089796f, 0.00594055f, 
    -0.20391248f, -0.14325537f, -0.23879276f, 0.15798000f, 0.26680484f, 0.08809224f, -0.24312237f, 0.20005049f, 
    0.17381787f, 0.00513390f, -0.33919236f, -0.06766821f, -0.10556201f, -0.16626264f, 0.23568749f, -0.14839625f, 
    0.06301540f, 0.08960430f, 0.16178040f, 0.08060881f, -0.02860964f, 0.13266817f, -0.12486054f, 0.08128871f, 
    0.49765366f, -0.24758875f, -0.55049586f, -0.13247795f, 0.08632353f, 0.12108187f, -0.17443097f, -0.11010586f, 
    0.02566531f, -0.19728638f, -0.05089032f, -0.06646176f, -0.06836919f, 0.19416288f, -0.31637412f, -0.19989635f, 
    -0.11277246f, 0.46353373f, -0.28607997f, 0.14626005f, 0.07615777f, 0.10310393f, -0.14659837f, 0.09126629f, 
    -0.01083616f, -0.15843827f, 0.38470706f, 0.31477597f, -0.73754466f, 0.18735884f, -0.14652497f, -0.02703431f, 
    -0.36561710f, 0.12912959f, -0.16208243f, -0.18810202f, 0.29239091f, 0.10699323f, -0.05128283f, 0.15532166f, 
    -0.09624246f, 0.30305386f, 0.01116715f, 0.43612295f, -0.46253055f, -0.02763109f, 0.52754962f, -0.51898479f, 
    0.14221466f, 0.36464238f, -0.01675898f, 0.14637862f, 0.15591626f, 0.03199684f, -0.58620161f, -0.16252850f, 
    -0.23474531f, -0.04789118f, 0.12213618f, 0.39161435f, 0.38221598f, 0.17948268f, 0.03523520f, 0.04187165f, 
    -0.05585900f, 0.27443701f, 0.57267928f, 0.17819312f, -0.59854108f, -0.16896461f, -0.11572177f, 0.08122540f, 
    -0.15134194f, 0.09179373f, -0.13093984f, -0.88471723f, 0.31158784f, -0.08740010f, -0.01867071f, 0.04176933f, 
    0.05170698f, -0.06077351f, 0.19842015f, 0.09370313f, 0.08367186f, -0.02710581f, -0.07953815f, 0.02647199f, 
    -0.10045314f, -0.12382834f, -0.09954353f, -0.03722939f, 0.10186993f, 0.01203627f, -0.07447915f, 0.04303054f, 
    0.03398550f, -0.23618703f, -0.07567634f, -0.13989876f, -0.04183473f, 0.09788252f, 0.12303940f, -0.15814066f, 
    -0.03653271f, -0.08070464f, -0.22516479f, -0.08109982f, -0.03332805f, -0.02382105f, 0.07377463f, -0.02769476f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05274984f, 0.13515572f, 0.21574154f, 0.07512330f, -0.01061413f, 0.35994315f, 0.27026734f, 0.19899894f, 
    0.11911778f, 0.03347625f, 0.11074387f, -0.13802625f, -0.05495063f, -0.16113190f, -0.15129623f, 0.27041173f, 
    0.04535847f, 0.02565776f, -0.11652672f, -0.05198658f, -0.22164129f, -0.01864129f, 0.19881934f, 0.02751352f, 
    0.21332419f, 0.18198463f, -0.11853843f, 0.30434877f, -0.19068523f, 0.01353675f, -0.01778502f, -0.23120494f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01325353f, -0.87314290f, -0.57974303f, -0.07323132f, -0.34813273f, -0.52967352f, 0.26361933f, 0.23531973f, 
    0.03970377f, -0.07776830f, 0.20248544f, 0.18846551f, -0.08933786f, 0.13162434f, 0.03939248f, 0.06187917f, 
    -0.63067222f, -0.11693030f, 0.40155387f, 0.26495042f, -0.02255375f, -0.03228843f, -0.41297013f, 0.00717710f, 
    -0.21165095f, 0.17394260f, -0.22447737f, -0.47538862f, 0.05009415f, 0.13768743f, 0.11353981f, -0.17548388f, 
    -0.67837250f, 0.11950170f, -0.82020849f, 0.13300638f, -0.44665185f, 0.19828330f, 0.22532763f, -0.14743784f, 
    0.31248406f, -0.54499358f, 0.32817304f, 0.38854855f, -0.13311648f, -0.08854299f, 0.12256246f, -0.36884922f, 
    -0.18974367f, -0.01718276f, 0.09679123f, 0.15087639f, -0.03132901f, -0.19418490f, 0.31722733f, -0.14721726f, 
    -0.07225861f, 0.13332216f, 0.13517594f, 0.08917800f, -0.09717299f, -0.22347303f, 0.20492072f, -0.06900442f, 
    -0.05896366f, -0.64689916f, 0.56765634f, 0.00826363f, 0.03663464f, 0.23505962f, -0.13070665f, -0.40425181f, 
    0.36595851f, -0.07444112f, -0.66294348f, -0.11452693f, -0.15322910f, -0.11363867f, 0.04748895f, 0.29732564f, 
    0.13893336f, 0.30574256f, -0.62555313f, 0.09852138f, 0.03163301f, 0.00225963f, -0.07727735f, -0.42535049f, 
    0.20871091f, -0.07143580f, 0.00216850f, -0.20146511f, -0.32068396f, -0.76601291f, 0.16849108f, 0.01846394f, 
    -0.12025938f, 0.18070450f, 0.40092495f, -0.80689818f, 0.03656616f, -0.01086507f, -0.04659833f, 0.21172541f, 
    0.22250941f, -0.30833554f, -0.35918808f, -0.88150239f, -0.07244507f, -0.03670744f, -0.07776439f, 0.45312214f, 
    -0.01014119f, -0.86983746f, -0.16770108f, 0.25543812f, -0.17422590f, 0.07058216f, -0.05066106f, -0.56613296f, 
    -0.01634321f, -0.16661465f, 0.05734732f, -0.10497710f, 0.39079455f, 0.17881647f, 0.27893776f, 0.08843685f, 
    0.39436990f, -0.08573081f, 0.21821831f, 0.02021636f, 0.05726719f, 0.09784726f, 0.01162595f, -0.00638982f, 
    0.10436130f, 0.11860680f, -0.01738467f, 0.17676958f, -0.18498224f, 0.09063365f, -0.13355532f, 0.30172285f, 
    -0.25432867f, -0.32575995f, -0.19120435f, 0.05865471f, -0.03563331f, -0.01059680f, 0.00335714f, 0.08792317f, 
    -0.62835157f, 0.14639083f, -0.03067371f, -0.31811059f, 0.22802781f, 0.30678853f, -0.42823383f, -0.11287594f, 
    -0.21091899f, 0.28498763f, -0.67612922f, 0.19048902f, -0.09474014f, -0.24365813f, 0.10366692f, 0.15676680f, 
    0.16587982f, 0.42885464f, 0.13062598f, -0.25209948f, 0.01951733f, -0.12833402f, 0.13157518f, 0.05687183f, 
    0.20119776f, -0.00626068f, -0.16152622f, 0.09899067f, 0.15385149f, -0.08675595f, -0.13754229f, -0.09093533f, 
    -0.10421684f, 0.05460241f, -0.03381144f, 0.08537159f, 0.02949665f, -0.23168445f, -0.08179898f, 0.07901112f, 
    0.09046691f, -0.54429728f, 0.37331691f, 0.10142490f, 0.31416211f, 0.04213311f, -0.57747668f, -1.04352117f, 
    -1.29739761f, 0.42081681f, -0.48806927f, 0.18775919f, 0.06718386f, -0.10055918f, 0.00550425f, 0.00219131f, 
    -0.13409822f, 0.34286061f, 0.30682668f, -0.14654773f, -0.06148981f, 0.05315652f, -0.23549612f, 0.12080664f, 
    0.46737832f, -0.21721309f, -0.21286476f, 0.36602041f, -0.44137090f, -0.78749645f, -0.56872225f, 0.14936495f, 
    0.19686486f, -0.11643447f, -0.75504154f, -0.20877641f, 0.24357925f, -0.41647905f, -0.24335298f, 0.18837526f, 
    -0.63082409f, 0.10770362f, 0.35071611f, 0.19679825f, -0.06094155f, 0.14520554f, 0.04642273f, -0.27929258f, 
    -0.54402614f, -0.25097242f, 0.57111329f, 0.35427830f, 0.03158179f, -0.00946441f, -0.10990754f, 0.07483573f, 
    -0.00330239f, -0.28873825f, 0.10763443f, 0.17271517f, -0.23960122f, -0.41014460f, 0.22879849f, 0.03862019f, 
    -0.50364542f, 0.48335138f, -0.42366621f, 0.21339035f, -0.16385783f, -0.18574739f, -1.13246393f, 0.24280685f, 
    -0.13981234f, -0.41702741f, 0.03732539f, -0.23696235f, 0.16374756f, -0.17089432f, -0.10501529f, -0.37709570f, 
    0.29727620f, -0.12369017f, 0.47754174f, -0.15904190f, 0.14071503f, 0.13401359f, -0.12165621f, 0.05983357f, 
    0.20980965f, 0.05825118f, -0.09144216f, 0.17209999f, -0.12447024f, -1.02380395f, 0.52377152f, 0.06133974f, 
    -0.07649519f, 0.08828338f, 0.24571601f, -0.05892673f, 0.06148241f, 0.30567509f, 0.43105385f, -0.06495762f, 
    -0.51499081f, 0.15740527f, -0.26268685f, -0.40981027f, -0.18498717f, 0.15223697f, 0.14410105f, 0.57177675f, 
    -0.49073130f, -0.25130665f, -0.26274359f, 0.12929654f, 0.03112175f, -0.01566695f, -0.33303228f, 0.33249536f, 
    0.29554054f, -0.15267080f, 0.03671482f, 0.13308989f, 0.27518034f, -0.71358484f, -0.89189166f, 0.15611763f, 
    -0.39135307f, -0.02310607f, -0.45184892f, 0.23356985f, -0.27168098f, 0.17262900f, -0.56128716f, 0.35998803f, 
    0.28868765f, 0.08418813f, -0.45744756f, 0.26725945f, 0.11374390f, 0.08901933f, -0.04142112f, -0.11038669f, 
    0.37952974f, -0.16971977f, -0.47499999f, -1.19222701f, 0.02218456f, 0.00298891f, -0.07367941f, 0.48796010f, 
    -0.42626578f, -0.50038010f, -0.09989857f, 0.11995448f, -0.33823234f, 0.32769525f, -0.11683153f, -0.07637639f, 
    0.32029286f, 0.38705793f, -0.23254088f, -0.22932938f, 0.43359494f, 0.46207249f, -0.05876453f, -0.66532201f, 
    -0.27623406f, -0.58544433f, -0.04007741f, 0.09606934f, -0.12450892f, 0.12531160f, 0.00900938f, -0.38328779f, 
    0.42765629f, 0.24245751f, 0.22871412f, -0.59949344f, -0.12275391f, 0.16050117f, -0.17679952f, -0.08899689f, 
    -0.07118754f, 0.21744221f, -0.13836037f, 0.04056958f, 0.25270370f, -0.18777864f, -0.07856616f, 0.13299650f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.30276471f, 0.08235065f, -0.07515153f, -0.09078883f, -0.02570619f, -0.12563866f, -0.03545826f, -0.39287865f, 
    -0.01825586f, 0.17460231f, 0.06419956f, 0.16574283f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
