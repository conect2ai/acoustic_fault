#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.58372879f, -0.61980450f, 0.65501899f, 0.85705715f, 0.72421455f, -0.10779480f, 0.52869517f, 0.37310797f, 
    0.08461138f, 0.39570713f, 0.04913338f, 0.04012901f, -0.23425691f, 0.10893222f, -0.13347225f, -0.36226812f, 
    -0.38864815f, -0.18753642f, 0.08586483f, -0.24870287f, 0.06309596f, -0.25141469f, -0.27317569f, -0.20477906f, 
    -0.02318921f, -1.03076792f, 1.31369245f, 0.17696793f, -0.64117235f, 0.44885823f, 0.23250394f, -0.28847045f, 
    -0.24451168f, 0.03507025f, -0.53408879f, -0.04053564f, 0.12745029f, 0.04119060f, 0.19335864f, -0.22170092f, 
    -0.00912626f, -0.11236628f, -0.20248331f, -0.12745158f, 0.14297299f, -0.15577203f, -0.11884041f, -0.03963293f, 
    -0.02178783f, -0.03798423f, 0.91681319f, 0.04109826f, -0.83219308f, -0.68967986f, -0.64766276f, 0.44433895f, 
    0.60138422f, 0.29527754f, 0.31953222f, 0.46318573f, -0.07431529f, 0.03871321f, -0.23561455f, -0.08657687f, 
    -0.06097347f, -0.09320729f, -0.04565449f, 0.07102181f, 0.05475812f, -0.07379647f, -0.07453138f, 0.14839178f, 
    -0.01263539f, 0.15963061f, -0.27812180f, 0.22340593f, -0.03209748f, 0.38935807f, 0.28115469f, -0.57939446f, 
    -0.54333097f, -0.20168483f, -0.35348502f, -0.50436628f, -0.06940407f, 0.26360837f, -0.04139443f, 0.40692747f, 
    -0.23566331f, -0.51009077f, -0.42633137f, -0.47723022f, 0.11641809f, 0.15236086f, -0.54581237f, -0.05891467f, 
    0.10169666f, 0.35742188f, -0.11151078f, -0.01743058f, 0.18168220f, 0.91966319f, 0.79516023f, 0.27351508f, 
    0.55638599f, -0.70445532f, 0.24819311f, -0.06504907f, -0.67181951f, -0.44178152f, -0.19500963f, -0.16625187f, 
    0.25206757f, 0.42470255f, 0.25789207f, -0.07064076f, -0.00241033f, -0.00653774f, -0.08734769f, 0.02878133f, 
    -0.14024617f, -0.07057665f, -0.11359216f, 0.07810909f, 0.11866089f, 0.96494269f, -0.46664447f, 0.05091825f, 
    -0.72843957f, -0.07381905f, 1.02001715f, -0.18071792f, 0.13974065f, -0.09435377f, -0.12576944f, 0.45011613f, 
    0.21848573f, -0.17497374f, 0.09538759f, 0.03171501f, -0.09122645f, -0.26969784f, -0.17746828f, -0.03354592f, 
    -0.04493963f, 0.27838781f, 0.21699230f, 0.06503376f, 0.13852848f, 0.06705441f, 0.76606691f, -0.22142325f, 
    -0.36425015f, -0.20939203f, -0.30750912f, -0.48489964f, -0.29656222f, -0.04751615f, 0.11135098f, -0.67329133f, 
    -0.64141619f, -0.31141466f, 0.27503359f, -0.14564045f, -0.22894406f, -0.24117069f, -0.35515264f, -0.50217694f, 
    -0.08816421f, -0.15782596f, 0.17371596f, 0.15741898f, 0.19054830f, -0.26009056f, -0.07854287f, 0.20856449f, 
    -0.54143453f, -0.69620401f, 0.73487300f, 0.48508433f, -0.59937769f, 0.23729852f, 0.67318666f, 0.49706432f, 
    -0.13386309f, -0.20451948f, -0.43253231f, -0.32436976f, -0.12220910f, -0.17707811f, 0.10090476f, -0.05764549f, 
    -0.10420432f, -0.29162908f, -0.06877417f, 0.02775206f, 0.05973788f, 0.11245592f, 0.35027313f, -0.03081184f, 
    -0.39615873f, -0.77087259f, -0.80979496f, -0.62077963f, -0.47664973f, -0.26636553f, 0.31223911f, 0.16831876f, 
    0.41056713f, 0.28826290f, -0.34969276f, -0.17919402f, -0.01341040f, -0.01476339f, -0.34878471f, 0.21596502f, 
    0.00139887f, 0.13495576f, 0.10483570f, -0.07868107f, 0.12499148f, 0.15515167f, -0.11015513f, -0.13017353f, 
    0.28268462f, -0.97226858f, -0.05953430f, -0.29234299f, 0.03655399f, 0.32852769f, -0.43745908f, 0.36370441f, 
    0.28872851f, -0.37678280f, -0.66544729f, 0.09198579f, 0.20687339f, 0.18726783f, 0.35452956f, 0.14164776f, 
    0.06133576f, -0.23770715f, -0.30846673f, -0.09390819f, -0.26818538f, 0.07688815f, 0.10464907f, 0.09571319f, 
    0.28796861f, 0.16059850f, -0.39410019f, -1.09458280f, -0.71629560f, 0.20269534f, -0.00055406f, -0.58803570f, 
    0.69521511f, 0.29022807f, -0.64597219f, 0.37030223f, 0.55840164f, 0.13610022f, -0.00031954f, -0.12018408f, 
    0.21329387f, 0.04498701f, 0.40975153f, 0.17792119f, 0.06066278f, -0.12212147f, 0.17141186f, -0.10182841f, 
    -0.09174066f, 0.13688447f, -0.03617765f, -0.72271234f, -0.30228326f, 0.51996946f, 0.26897401f, 0.61087757f, 
    -1.04047835f, -0.00492697f, -0.34070164f, -0.28147331f, 0.14863110f, 0.48271504f, 0.30745128f, 0.06240905f, 
    -0.03031940f, 0.12226652f, -0.00165504f, 0.03274699f, 0.19814686f, 0.10441265f, 0.25426605f, -0.03264289f, 
    -0.19189434f, 0.21559708f, -0.34390357f, -0.05292342f, 0.93899941f, 0.58238620f, 0.38684189f, 0.23025875f, 
    0.13077928f, 0.20052359f, 0.36992261f, 0.27325681f, 0.08327014f, 0.31111333f, -0.44810864f, 0.16932073f, 
    -0.25348705f, -0.23986389f, 0.20851351f, -0.13788944f, -0.12331031f, -0.05334351f, -0.13961279f, 0.13635039f, 
    -0.02223309f, 0.11550999f, 0.18218127f, 0.23430948f, 0.17068326f, 0.26354408f, 0.47953072f, 0.73822975f, 
    0.77589470f, -0.75514287f, -0.59986842f, -0.12481628f, 0.25009573f, -0.31290412f, 0.13263279f, 0.31115541f, 
    0.31036413f, -0.53518641f, 0.17740785f, 0.23977745f, 0.16804916f, 0.12570301f, 0.24986356f, -0.02944689f, 
    0.16403341f, 0.20862897f, 0.21950446f, -0.05696538f, -0.12634523f, -0.21472491f, -0.20183718f, -0.47518200f, 
    -0.01588648f, -0.51669765f, -0.30217925f, -0.19694099f, -0.69892740f, -0.56511742f, -0.68399072f, -0.36978093f, 
    -0.15505308f, 0.59853715f, 0.00798795f, -0.04833616f, -0.25794667f, 0.16455020f, 0.21131459f, 0.34615463f, 
    0.04134278f, -0.42185816f, 0.06864043f, 0.12263356f, -0.07797835f, -0.18850878f, 0.11125555f, 0.99777329f, 
    0.28969812f, 0.62221491f, 0.94826323f, 0.74812990f, 0.59905559f, 0.14509945f, -0.33158678f, 0.30043501f, 
    -0.29706332f, -0.20269459f, 0.17333062f, -0.00216636f, 0.34363377f, -0.22072311f, 0.23262860f, 0.28388709f, 
    0.15574352f, 0.20983054f, -0.04064821f, 0.11978075f, 0.17479509f, 0.11061669f, 0.06625751f, 0.08309906f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03333270f, -0.09848700f, 0.17831303f, 0.13807710f, -0.03340626f, 0.15714690f, 0.06467763f, -0.02503077f, 
    0.01315178f, 0.10057873f, 0.10747718f, 0.27746198f, 0.25502807f, 0.01330604f, 0.05844742f, 0.08136790f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00819764f, 0.00032717f, -0.00895923f, -0.01308948f, -0.01413100f, -0.05231145f, -0.00112801f, 0.05292327f, 
    0.01467283f, -0.00165888f, 0.06510061f, 0.00403315f, -0.04726984f, -0.06294149f, 0.03009308f, 0.04874716f, 
    0.05959909f, 0.00607694f, -0.05656860f, -0.07200166f, -0.00768808f, 0.05427238f, -0.05930188f, -0.03339991f, 
    -0.06383178f, 0.00245094f, 0.05251458f, 0.02153697f, -0.06040053f, -0.01543740f, -0.04816454f, -0.02818107f, 
    -0.00033738f, 0.01649077f, 0.06334033f, 0.05285911f, 0.00804459f, -0.04761685f, 0.01420363f, -0.04740922f, 
    -0.00705395f, -0.00454928f, -0.05900732f, -0.01672281f, -0.05897211f, 0.00326631f, -0.07164773f, -0.02270485f, 
    0.03131802f, 0.00006960f, 0.00276678f, 0.04988798f, -0.05544066f, -0.01342517f, -0.02702697f, -0.00745443f, 
    -0.04952068f, -0.04426061f, -0.06953468f, -0.04246836f, -0.01557883f, -0.07473668f, 0.02208590f, -0.05243714f, 
    -0.00622294f, -0.06406257f, -0.06233472f, 0.00938147f, 0.04816713f, -0.06411786f, -0.01510620f, -0.06384243f, 
    0.04072353f, 0.04154488f, 0.01023002f, 0.05482672f, -0.05582303f, 0.00275084f, -0.06652699f, -0.03853652f, 
    -0.02410878f, -0.06047834f, -0.00254130f, 0.04319158f, 0.00206117f, 0.03780958f, -0.07387772f, -0.02790643f, 
    -0.00531361f, 0.03336558f, 0.03372873f, -0.02447850f, -0.06092542f, -0.02696908f, -0.04624970f, -0.03475608f, 
    0.04794621f, 0.04664089f, -0.05502998f, -0.04211968f, -0.02192170f, -0.06052976f, -0.03653028f, 0.01338374f, 
    0.04875879f, 0.04444347f, -0.05466413f, -0.06952935f, 0.03580385f, 0.02315643f, -0.03053201f, 0.04688473f, 
    -0.00443370f, 0.05066459f, -0.06736908f, 0.06107477f, -0.00796061f, -0.07164495f, 0.03342368f, -0.01242330f, 
    -0.06866706f, -0.06971409f, -0.01871148f, -0.05854820f, 0.00607532f, -0.05119988f, 0.05615792f, 0.01849022f, 
    0.04451117f, 0.04521837f, -0.06173261f, 0.02130681f, -0.03697361f, 0.01400990f, -0.06692196f, 0.01486389f, 
    -0.05282226f, -0.01844352f, -0.04731119f, 0.05212762f, 0.05946880f, 0.02307353f, -0.04926760f, -0.01731526f, 
    -0.01991861f, -0.06385437f, -0.04306795f, 0.05378760f, -0.03655944f, -0.07584389f, 0.05207195f, 0.06055860f, 
    -0.01441665f, -0.03652278f, -0.06475484f, -0.02607086f, 0.01871300f, -0.04906517f, -0.05580307f, -0.07558729f, 
    -0.04863469f, 0.04150207f, -0.00004595f, 0.01843108f, -0.01582853f, 0.02914258f, -0.06690567f, -0.01011981f, 
    0.05052547f, -0.05667650f, -0.06922937f, -0.05055656f, -0.02438080f, 0.00091907f, -0.07067336f, -0.04481276f, 
    -0.01322248f, -0.04820574f, 0.01769184f, -0.06231365f, 0.06029476f, -0.04507449f, 0.05407236f, 0.00461704f, 
    0.06264611f, -0.04669463f, -0.06654546f, -0.04258578f, 0.04699752f, 0.03551440f, 0.00721267f, -0.06730346f, 
    -0.25235012f, 0.09521807f, 0.02892367f, 0.00917195f, -0.04269805f, 0.08408847f, -0.02328895f, 0.01521044f, 
    -0.01179981f, -0.01218797f, -0.01684230f, -0.14971343f, 0.19971992f, 0.27414095f, -0.07884107f, -0.10936549f, 
    0.15150191f, -0.04701778f, -0.06377371f, -0.09806891f, 0.01894252f, 0.20867142f, -0.09595155f, -0.12865517f, 
    0.33763450f, -0.03598461f, 0.01383783f, 0.03437565f, -0.08538648f, 0.00369133f, 0.13024507f, 0.00326484f, 
    0.03424910f, 0.01067038f, 0.00477625f, -0.07680676f, -0.10113448f, -0.01493044f, 0.15162311f, -0.00551334f, 
    -0.09653172f, 0.14583947f, 0.02663234f, -0.08862485f, -0.03522409f, -0.20050456f, 0.01289410f, 0.00066642f, 
    -0.37652266f, 0.13637151f, 0.18666199f, 0.09796330f, 0.14530042f, -0.00278041f, -0.10226279f, -0.09813951f, 
    -0.10962394f, -0.06083161f, 0.02064822f, -0.01038400f, -0.42250201f, 0.06722058f, -0.10792653f, -0.18554163f, 
    -0.07010328f, 0.01784749f, 0.02994981f, 0.10129944f, 0.09537481f, 0.11532383f, -0.11193161f, -0.08862931f, 
    0.10214348f, -0.20748791f, 0.21957585f, -0.03733156f, -0.05587074f, 0.11801611f, 0.11160383f, -0.03522671f, 
    -0.06964993f, -0.07537532f, -0.16120219f, -0.15849069f, 0.34009808f, -0.55434066f, -0.12120698f, -0.00107087f, 
    -0.03381979f, -0.00753676f, 0.02697678f, 0.11699726f, 0.01317153f, 0.07756551f, 0.00811943f, 0.04996854f, 
    0.25177938f, 0.09937409f, 0.33523712f, 0.35081255f, -0.08931589f, 0.03788874f, -0.04327791f, 0.10382789f, 
    0.04583650f, -0.08740267f, 0.02025471f, -0.05546905f, 0.36961427f, 0.03857535f, 0.08701386f, -0.00589144f, 
    0.01574117f, 0.13477312f, 0.04737344f, 0.02589489f, 0.14561230f, 0.00229533f, -0.12801142f, 0.04673374f, 
    0.54080051f, -0.10292611f, 0.17065804f, 0.07942322f, -0.20121002f, 0.02034574f, 0.01458852f, 0.05527008f, 
    -0.08228514f, -0.04029517f, 0.06018697f, 0.09356892f, 0.19466157f, 0.04409828f, 0.11636127f, 0.08876111f, 
    0.02504015f, 0.06145569f, -0.01585640f, 0.03246990f, -0.17301196f, 0.03543855f, 0.00631711f, 0.26962999f, 
    -0.14199999f, -0.04036735f, 0.15836385f, -0.00517058f, 0.02692163f, 0.08499544f, 0.10630463f, -0.09999902f, 
    0.18646249f, 0.11216634f, 0.00268477f, 0.07157766f, -0.58522534f, -0.17110488f, -0.17739820f, -0.00447093f, 
    0.04002993f, -0.00043614f, 0.03785157f, 0.04961386f, -0.07312766f, 0.14000660f, 0.06381163f, 0.05834508f, 
    0.29455209f, 0.15916798f, 0.25831050f, 0.18323611f, 0.15646848f, 0.06652171f, -0.16108656f, 0.14886694f, 
    -0.00515376f, 0.00079800f, 0.09656757f, 0.04309250f, -0.14957698f, -0.19824725f, 0.07430761f, -0.08086596f, 
    -0.08971497f, 0.00612189f, 0.06004364f, 0.01856028f, -0.03172368f, -0.01905917f, 0.11331229f, 0.10435864f, 
    0.06390773f, -0.16346247f, -0.08221802f, -0.27497917f, -0.08063242f, -0.08358598f, -0.14168933f, 0.02690841f, 
    -0.03723875f, 0.04378559f, -0.10399740f, 0.19815961f, 0.10139844f, 0.00774109f, 0.19066754f, 0.36513796f, 
    0.14192751f, -0.04420370f, 0.09730588f, 0.21881345f, -0.02893417f, -0.01464023f, 0.01737816f, 0.12275229f, 
    -0.11562958f, -0.04612825f, -0.19367896f, 0.01993718f, -0.12732883f, 0.10701232f, 0.08741478f, 0.07397980f, 
    -0.03080394f, 0.02998856f, 0.03957830f, -0.03999956f, 0.21714872f, 0.22884944f, 0.14309040f, 0.19310336f, 
    0.05631138f, 0.07833268f, -0.04369151f, -0.16631503f, -0.08929159f, 0.07780021f, -0.13429520f, -0.04293308f, 
    -0.12287422f, -0.03522550f, -0.02864230f, -0.03097185f, 0.10704628f, -0.14863396f, 0.08083367f, 0.05152675f, 
    0.09673876f, 0.04131623f, 0.12013599f, -0.08990505f, -0.13133071f, -0.09539206f, -0.00927502f, 0.24514461f, 
    -0.04699712f, -0.00224050f, 0.15231721f, 0.08782044f, 0.00540375f, -0.06405186f, 0.08799352f, 0.01435339f, 
    0.04247212f, 0.31717774f, 0.14616004f, 0.10396331f, 0.11643633f, 0.19858281f, -0.00204509f, 0.03366431f, 
    0.11539129f, 0.20212267f, 0.17904110f, 0.25977376f, -0.03192724f, 0.13571122f, 0.17011943f, 0.03903027f, 
    0.26452088f, 0.05655711f, 0.07664269f, -0.07866614f, -0.04838691f, 0.09246922f, 0.14558789f, -0.13905351f, 
    0.06214159f, 0.14781310f, -0.29589292f, -0.26579317f, -0.28581142f, -0.02183310f, 0.06906267f, -0.28250498f, 
    -0.05639777f, 0.00186407f, 0.01017333f, -0.02606857f, 0.08518497f, 0.05919598f, 0.25448859f, 0.15702371f, 
    -0.06624147f, -0.12362640f, -0.04441759f, 0.03528047f, 0.05281461f, 0.06293453f, 0.19164973f, 0.04770300f, 
    -0.09583592f, 0.23844600f, 0.21651903f, -0.16194171f, 0.02760977f, 0.08363316f, 0.04236832f, 0.11425834f, 
    -0.04043255f, -0.01467626f, -0.03852323f, -0.08024485f, 0.13134387f, 0.30339584f, -0.03990388f, 0.00462358f, 
    0.10449309f, 0.06349476f, 0.06464968f, 0.20479265f, -0.00236809f, -0.02606950f, 0.04385033f, 0.00176928f, 
    -0.37171179f, -0.16844991f, -0.23707251f, -0.17595880f, -0.03637011f, -0.10228740f, 0.01787682f, 0.10045623f, 
    0.06314175f, 0.02190259f, 0.06792059f, -0.06758334f, 0.04202276f, 0.18082923f, 0.13515256f, 0.05948697f, 
    0.21998723f, 0.10281713f, -0.07496025f, 0.03436047f, -0.07455178f, 0.02617678f, 0.10211883f, -0.07817087f, 
    -0.11436193f, -0.03057421f, -0.16911432f, 0.02766133f, -0.10526057f, -0.20789182f, 0.00544025f, -0.15740430f, 
    -0.09909312f, 0.01184143f, -0.05458078f, -0.08639706f, -0.24030676f, -0.21356085f, -0.16014189f, -0.22706692f, 
    0.08248620f, 0.04790043f, -0.03000920f, -0.01513354f, -0.00413376f, 0.06809190f, -0.04176396f, 0.03230260f, 
    -0.50259304f, 0.14924139f, -0.00014764f, -0.04025207f, 0.26207209f, -0.02819384f, -0.13072971f, -0.06333349f, 
    -0.11343122f, -0.09858102f, 0.05498720f, -0.25939879f, -0.07960141f, -0.21215357f, -0.09175950f, 0.15383796f, 
    -0.16094546f, 0.06977236f, -0.03660085f, -0.06120548f, 0.02060500f, 0.06447859f, 0.14295092f, -0.04303193f, 
    0.12757280f, 0.18283583f, -0.01297015f, 0.00827457f, 0.03047668f, -0.05402399f, -0.02552300f, 0.02734859f, 
    -0.07679234f, -0.12901300f, -0.04872728f, 0.07036912f, -0.09729323f, 0.11748393f, 0.27498347f, -0.06210463f, 
    -0.04767776f, -0.13731520f, 0.07146092f, 0.05011615f, 0.26800698f, -0.21241400f, 0.11790276f, -0.11497539f, 
    0.25197485f, -0.20296960f, -0.13874085f, 0.28968349f, 0.10322693f, 0.16621262f, -0.12337336f, 0.06322619f, 
    -0.09408409f, 0.04174836f, 0.24199902f, 0.19626920f, -0.08304280f, 0.21451645f, 0.33239648f, 0.02093181f, 
    -0.05076020f, -0.06567997f, -0.10911752f, 0.04771356f, 0.28268969f, 0.00039363f, 0.03629996f, 0.05376133f, 
    -0.26340804f, 0.19868028f, 0.13556936f, 0.10707477f, 0.07617916f, -0.05686747f, 0.00313818f, 0.06191774f, 
    0.17804115f, 0.06843916f, -0.13162845f, -0.18742211f, -0.15060668f, 0.18154854f, -0.21779540f, -0.12938015f, 
    -0.25439522f, -0.01140382f, 0.03814802f, 0.06944778f, 0.09693621f, 0.06203942f, -0.14786501f, -0.04272000f, 
    -0.20136420f, -0.14364086f, -0.02768092f, 0.15284736f, 0.13714921f, 0.11885189f, -0.00109487f, 0.02474223f, 
    0.06117998f, -0.07305324f, -0.23578128f, 0.02637887f, 0.02922475f, -0.01637714f, -0.14875285f, -0.16255155f, 
    0.05409094f, 0.14580742f, 0.07931861f, 0.04290840f, -0.02060571f, 0.01828254f, 0.08640270f, 0.13105763f, 
    -0.19833958f, -0.12078161f, -0.02453452f, -0.02592798f, 0.21886025f, -0.01668234f, -0.00172736f, -0.07232700f, 
    0.00636274f, -0.05821997f, -0.00028123f, 0.04003604f, 0.12237602f, 0.00287144f, 0.01945576f, -0.25443822f, 
    0.01376303f, 0.01700431f, 0.07970705f, 0.02400809f, 0.00825313f, -0.07296760f, 0.04418236f, 0.15734896f, 
    0.25916386f, -0.02501823f, 0.04787472f, -0.08273076f, 0.22135727f, 0.09635276f, 0.14537250f, 0.03664191f, 
    0.11100282f, 0.03811242f, -0.01038672f, 0.08103784f, 0.10178124f, -0.00996241f, -0.09044984f, -0.11622722f, 
    -0.02987839f, -0.17341334f, -0.11564827f, 0.01253338f, 0.00636175f, 0.15387172f, 0.03938089f, 0.14876145f, 
    -0.19278774f, 0.07029501f, -0.24087866f, -0.21636052f, 0.01753744f, -0.06744567f, -0.05320211f, 0.02015298f, 
    0.04133506f, -0.01719303f, 0.06279397f, 0.13979517f, 0.07601689f, -0.08923601f, 0.21967550f, 0.23924308f, 
    0.33527854f, -0.01708374f, -0.06457962f, -0.08719984f, 0.04168383f, -0.06402355f, 0.07708650f, 0.11643471f, 
    0.37308013f, -0.26943669f, 0.26687735f, 0.28432336f, -0.02727214f, 0.03059503f, -0.06907900f, 0.10263290f, 
    0.21216528f, 0.04693648f, 0.02032540f, -0.07263310f, 0.14097963f, -0.17343199f, 0.03223308f, -0.23204982f, 
    -0.00620235f, 0.09558853f, 0.06981313f, -0.06325383f, 0.10886326f, 0.20592080f, 0.03315027f, 0.23619066f, 
    -0.16328198f, -0.21623346f, 0.00796839f, -0.18965897f, 0.04106160f, 0.10313317f, 0.04992576f, 0.05371753f, 
    0.17292283f, -0.00931901f, -0.03274164f, -0.00713136f, -0.16831484f, 0.07816894f, 0.03061756f, 0.08232902f, 
    -0.07205494f, 0.13999008f, 0.02033288f, 0.19177601f, 0.01422173f, -0.01894519f, -0.09449713f, 0.17362680f, 
    0.00334706f, 0.34158552f, 0.11490490f, -0.20122473f, -0.17679028f, -0.07974843f, 0.07108515f, -0.04691973f, 
    0.08361896f, -0.04538222f, -0.06859359f, -0.02173392f, 0.18934442f, 0.12042317f, -0.10205355f, -0.07749011f, 
    0.11679084f, 0.22109780f, 0.11973696f, 0.13880856f, 0.03096179f, 0.03128245f, 0.06717727f, 0.04551367f, 
    -0.14325276f, -0.30254659f, 0.06049415f, -0.12199780f, 0.06452042f, -0.03449100f, 0.05222352f, 0.02927579f, 
    0.05966331f, -0.02144183f, -0.05279558f, 0.01866440f, -0.05922133f, -0.04908093f, 0.13748825f, 0.18292604f, 
    -0.03018506f, -0.10543725f, 0.08148769f, -0.09038960f, -0.02302051f, 0.05495067f, -0.03173877f, 0.11137263f, 
    -0.36723414f, -0.48763579f, -0.22934668f, -0.35372978f, 0.07988750f, 0.02111981f, -0.03389518f, 0.05513943f, 
    0.02490307f, -0.02536423f, 0.02460290f, -0.00359077f, -0.12221518f, 0.20849243f, -0.23024067f, 0.03933190f, 
    0.14206266f, 0.15359479f, 0.05381204f, 0.01118413f, 0.06644513f, -0.03859360f, -0.10365838f, -0.12298636f, 
    -0.32838708f, -0.22509114f, -0.17262717f, -0.00951058f, 0.02493067f, -0.00864655f, 0.07287555f, 0.17761236f, 
    0.02891081f, 0.01515851f, 0.03299833f, 0.12423705f, -0.03292864f, 0.12256721f, 0.26240960f, 0.17016374f, 
    0.06466580f, -0.04431226f, 0.13066491f, -0.02998627f, 0.11416141f, 0.19519752f, 0.00132838f, 0.04444380f, 
    -0.25925690f, 0.10795926f, 0.20061231f, 0.13591012f, -0.12656160f, 0.07017764f, -0.03575512f, -0.02278206f, 
    0.01101391f, 0.08861133f, 0.02007559f, 0.09413584f, -0.36175755f, 0.17031659f, 0.05758718f, 0.30892348f, 
    0.01956920f, -0.23153265f, -0.06702427f, 0.00013201f, 0.08141607f, 0.03738340f, 0.02158157f, 0.07468142f, 
    0.13270982f, 0.03826549f, -0.12063492f, -0.12119752f, 0.17997649f, 0.11020332f, 0.00274519f, 0.06110924f, 
    -0.07527319f, 0.00214488f, 0.00967447f, 0.04814302f, 0.06952498f, 0.15710016f, 0.12118442f, -0.08346552f, 
    -0.16803314f, -0.04409916f, -0.05600911f, 0.05777837f, 0.09260666f, 0.03079637f, 0.09538148f, 0.02784640f, 
    0.22608331f, -0.03419714f, 0.17058124f, 0.11563700f, -0.06036643f, 0.01287654f, 0.12498222f, -0.02377019f, 
    0.02171480f, 0.07461822f, 0.13500850f, 0.00995821f, 0.38183045f, 0.19883195f, -0.08588799f, -0.32068181f, 
    0.11141624f, 0.09054063f, 0.02600663f, -0.09236167f, -0.00984736f, 0.04302175f, -0.01198201f, 0.00746957f, 
    0.02147893f, -0.30838451f, 0.16942587f, 0.01874072f, -0.02616021f, 0.02831868f, 0.09592114f, 0.02659977f, 
    0.03406039f, 0.13575989f, 0.00099953f, 0.11303748f, -0.23171759f, -0.13884474f, -0.09066620f, -0.12004473f, 
    -0.04057764f, 0.11902934f, 0.07205985f, 0.05213801f, 0.05146128f, -0.00239020f, 0.15242170f, 0.15958445f, 
    -0.11035831f, 0.23719627f, 0.12628990f, -0.03053411f, 0.07514179f, 0.13452820f, 0.08375861f, -0.03090444f, 
    0.12239530f, -0.04239726f, -0.14532968f, -0.02914616f, -0.06159004f, 0.07724559f, -0.10403062f, -0.16912694f, 
    0.06277210f, 0.13077979f, 0.05547946f, -0.00148104f, -0.16316682f, -0.02219985f, -0.13372719f, -0.07535966f, 
    0.05607013f, -0.24819250f, -0.10787165f, -0.18979459f, -0.17884603f, -0.05438618f, 0.04964538f, -0.06188627f, 
    -0.15341203f, -0.01596070f, 0.07959749f, 0.01377958f, 0.23021227f, -0.34125265f, 0.00910064f, 0.04977738f, 
    -0.09760055f, 0.02583494f, 0.00724926f, -0.00711131f, 0.05253268f, -0.03333148f, 0.10789964f, 0.19400768f, 
    -0.05396082f, -0.23908852f, 0.14484958f, 0.09975116f, -0.07422992f, -0.06089486f, -0.08476221f, 0.14205028f, 
    0.00914110f, 0.02879343f, 0.24049693f, -0.02938481f, 0.01997133f, 0.14780346f, -0.10122455f, -0.00505533f, 
    -0.03260524f, -0.02168547f, 0.02586632f, 0.00406258f, -0.01955204f, -0.17599191f, -0.14792742f, -0.14845546f, 
    0.43583438f, -0.22136471f, -0.14477234f, 0.08568081f, -0.09106488f, -0.01917903f, 0.14746258f, 0.05432571f, 
    0.06156451f, -0.05319163f, 0.11586302f, -0.01920373f, -0.06147968f, 0.00550855f, 0.29534638f, 0.26431373f, 
    -0.02745461f, 0.11182646f, -0.07408357f, -0.07074682f, -0.05224035f, 0.00590590f, -0.02924123f, -0.06846304f, 
    -0.07146523f, 0.25822234f, 0.17565720f, 0.10645149f, -0.04776823f, -0.02313492f, -0.02053855f, -0.09832665f, 
    0.00721967f, -0.01123610f, 0.06763823f, 0.02339554f, -0.23605534f, -0.18777351f, 0.11223338f, -0.10116893f, 
    -0.09747636f, 0.05041809f, 0.12214236f, 0.02253843f, 0.00408396f, -0.05530738f, -0.10380077f, -0.07847096f, 
    0.19649896f, -0.04824256f, 0.09565993f, 0.11161313f, 0.20194577f, 0.12205575f, -0.02925806f, 0.15715760f, 
    0.05493945f, -0.08314333f, 0.05509983f, 0.08074158f, 0.19922520f, 0.14013797f, 0.08940339f, -0.07132050f, 
    -0.13400103f, -0.05197540f, 0.05647516f, 0.06158638f, 0.03252346f, 0.03075379f, 0.05049685f, -0.11090408f, 
    0.03132244f, -0.25838560f, 0.15640646f, 0.08822618f, -0.05142488f, 0.05340645f, 0.00965819f, -0.00667235f, 
    0.09411412f, 0.08020789f, 0.04715856f, 0.02871822f, 0.26562795f, -0.15598345f, -0.34010115f, -0.33323485f, 
    0.12022437f, 0.01264757f, -0.21663746f, -0.01264931f, 0.11840346f, 0.07171866f, -0.02531086f, -0.00789655f, 
    0.03621887f, -0.06034068f, 0.15069690f, 0.06655261f, -0.09805659f, 0.14963256f, 0.17267437f, 0.13471943f, 
    0.14617068f, 0.16736308f, -0.04762170f, 0.08747452f, -0.00216773f, 0.06835555f, -0.25135213f, -0.03087976f, 
    0.09633487f, 0.14112253f, -0.01286000f, 0.13127881f, 0.10806537f, 0.16861372f, 0.21920316f, 0.11870296f, 
    -0.28383362f, -0.07881217f, -0.06996755f, -0.23308489f, 0.09610374f, 0.12821665f, -0.01164097f, 0.02118591f, 
    0.15162760f, -0.04074286f, -0.18046795f, 0.06677710f, 0.38776991f, 0.24467123f, -0.02795948f, 0.15437058f, 
    0.09128339f, 0.17814146f, -0.01281645f, 0.14921498f, -0.08572365f, 0.05113074f, -0.05039514f, 0.08946134f, 
    -0.29994646f, -0.25514138f, 0.06470283f, -0.24506825f, 0.08671553f, -0.05936423f, 0.07159884f, 0.15450984f, 
    0.07223873f, 0.08104946f, -0.01378724f, 0.16011848f, -0.13986033f, -0.39904693f, 0.11117791f, 0.34176734f, 
    -0.05328917f, -0.11325659f, -0.00389818f, 0.14051297f, -0.11183959f, 0.07649893f, 0.04913517f, 0.07983676f, 
    -0.09886090f, -0.11945207f, -0.03410665f, -0.30585843f, -0.13339122f, -0.15630044f, -0.07108496f, 0.08692191f, 
    0.05205011f, 0.13236399f, 0.08921108f, 0.09701069f, 0.03219952f, 0.21052083f, -0.05957161f, 0.02867825f, 
    0.00441822f, 0.08983369f, 0.04174582f, -0.12904397f, 0.04459960f, -0.07951923f, -0.01846044f, -0.07934951f, 
    0.46881849f, -0.07207856f, -0.19296274f, 0.19273445f, -0.05605911f, -0.00071228f, 0.15717359f, -0.04551747f, 
    -0.07142986f, -0.01792856f, 0.12909348f, 0.06856171f, -0.11052011f, 0.24824008f, 0.26401588f, 0.22395210f, 
    0.15265197f, -0.00147193f, 0.02014801f, 0.01431422f, 0.01022921f, 0.02769410f, 0.05604140f, -0.16867511f, 
    -0.31991997f, 0.02949831f, -0.09225794f, 0.12326584f, 0.04425845f, 0.12084855f, 0.05105200f, -0.05560571f, 
    0.07015452f, -0.09630753f, 0.02035230f, 0.17193672f, -0.27584377f, -0.21416527f, 0.13495214f, 0.15856695f, 
    0.15045874f, -0.09013059f, 0.12390471f, -0.02362492f, 0.08629536f, -0.04373627f, -0.12292580f, 0.08720483f, 
    0.09617100f, 0.20162788f, -0.23421021f, -0.13899288f, 0.11420054f, 0.17763458f, 0.17252837f, 0.06786510f, 
    0.13234751f, -0.02544200f, -0.01768063f, -0.00131748f, -0.15477256f, -0.11756519f, -0.03655740f, -0.10242679f, 
    -0.05924113f, 0.02557694f, -0.12676966f, -0.03760007f, 0.06816357f, -0.02202268f, 0.07741582f, -0.12707500f, 
    -0.09514240f, 0.12641409f, -0.44554949f, 0.18812826f, 0.11208169f, 0.03064090f, -0.07681192f, -0.04860164f, 
    0.17547160f, 0.09772410f, 0.07359129f, 0.00881242f, -0.30316496f, -0.07412155f, 0.12488754f, -0.28882855f, 
    -0.01352127f, 0.08043955f, -0.10815111f, 0.03171911f, 0.01751703f, -0.02427008f, 0.12504090f, 0.14112990f, 
    0.15765704f, 0.28023392f, 0.10102410f, -0.43506560f, -0.08587857f, -0.06294800f, 0.08087239f, 0.05465452f, 
    -0.02258302f, -0.03502757f, 0.02327619f, 0.09674290f, -0.15208235f, 0.04603035f, -0.06247663f, -0.01522976f, 
    -0.03257832f, 0.07921891f, 0.02398493f, 0.04852576f, 0.09192596f, 0.12667073f, 0.03736201f, 0.10371398f, 
    0.15104930f, 0.06445985f, -0.29804659f, 0.02411198f, 0.00378649f, 0.05352973f, -0.01527804f, 0.00369773f, 
    -0.09774747f, -0.01307585f, 0.06013907f, 0.15434602f, 0.35207057f, 0.18746960f, 0.23180738f, -0.27130365f, 
    -0.03432858f, 0.01176265f, 0.06841173f, -0.09505922f, -0.00594780f, -0.07807948f, 0.13499627f, 0.12772559f, 
    -0.22667360f, -0.14859845f, -0.04865523f, 0.05231396f, -0.12262944f, 0.13876787f, 0.08120716f, -0.11008918f, 
    0.04566448f, 0.14639883f, 0.00473790f, 0.13231194f, -0.04551185f, 0.46376440f, -0.42437273f, 0.47414318f, 
    -0.04573988f, -0.14219773f, 0.03032868f, 0.11343845f, -0.01618406f, -0.02413018f, 0.25220346f, -0.09448677f, 
    0.01606190f, -0.04324862f, -0.06701219f, -0.27250966f, -0.15253596f, -0.01160023f, 0.07254539f, 0.23773296f, 
    0.02962374f, -0.00548730f, -0.14970897f, 0.08547529f, -0.00910602f, -0.07329357f, -0.18952207f, 0.05842585f, 
    -0.06250456f, -0.16079704f, 0.00856036f, 0.12297146f, 0.08556922f, 0.12116952f, -0.09241185f, -0.07524350f, 
    0.25200343f, -0.25572789f, -0.03578258f, 0.13289177f, -0.02389117f, -0.08516735f, -0.13813157f, 0.00144483f, 
    -0.08385114f, 0.05152470f, 0.12518227f, 0.01074357f, -0.17277862f, -0.43885586f, -0.24853228f, 0.26083252f, 
    0.13482319f, 0.03115265f, -0.01231421f, -0.07986623f, 0.04586600f, -0.00620528f, 0.03488965f, -0.05734045f, 
    0.40870705f, 0.10621674f, -0.10785592f, -0.07078005f, 0.17007871f, 0.08902821f, 0.06678326f, -0.11581670f, 
    0.09913849f, -0.09132723f, -0.04968610f, 0.13299486f, 0.07563786f, 0.30755091f, -0.16972315f, 0.20466803f, 
    -0.11617278f, 0.00632653f, -0.01861304f, -0.20721416f, 0.09772830f, -0.18354394f, 0.14893878f, 0.06038772f, 
    -0.77037388f, -0.26497346f, 0.05859781f, -0.04446098f, -0.11474144f, 0.05173182f, 0.08739357f, 0.06564542f, 
    -0.12014076f, 0.21374661f, -0.12684497f, 0.05475947f, 0.19091487f, 0.17435075f, -0.19443887f, 0.27365154f, 
    0.17402567f, 0.03373327f, -0.05052273f, -0.09907030f, -0.11871045f, -0.07257270f, -0.06790262f, 0.17590004f, 
    0.00925745f, 0.12960896f, -0.06160387f, 0.03006843f, 0.14447547f, -0.04970091f, 0.00131859f, 0.11180585f, 
    0.01081550f, 0.10384007f, 0.05040699f, -0.00976014f, -0.06246432f, 0.14172079f, 0.27615714f, 0.03384819f, 
    -0.20032632f, 0.03058380f, 0.28777128f, -0.06663157f, 0.04005932f, -0.05795095f, -0.01416269f, 0.16716157f, 
    0.13879119f, -0.35053286f, -0.09249921f, -0.37057820f, 0.12424250f, 0.09492675f, -0.03150574f, -0.06048853f, 
    -0.08322650f, -0.07769550f, -0.00255954f, 0.01582527f, -0.11818323f, 0.13314687f, 0.28247562f, 0.21325171f, 
    0.00087556f, 0.00121082f, -0.05145688f, 0.00476231f, 0.17203520f, -0.10827160f, -0.07270282f, 0.03966551f, 
    0.12277642f, 0.36166978f, 0.05057147f, 0.23035353f, -0.13286537f, 0.00906669f, 0.08076335f, 0.06736524f, 
    0.04051804f, -0.02573273f, 0.12873471f, 0.01624404f, -0.08435376f, -0.36079675f, 0.18045847f, -0.21536773f, 
    0.15593523f, -0.01048544f, -0.02009972f, -0.02577242f, 0.07172465f, -0.07240752f, 0.16237196f, 0.01422547f, 
    0.13057874f, 0.03723337f, 0.01622574f, 0.00660090f, 0.15796848f, 0.09423912f, 0.14669779f, 0.03097510f, 
    0.01752540f, 0.10042050f, 0.06206853f, -0.04689346f, -0.13182628f, 0.49890399f, 0.00097737f, 0.05229389f, 
    0.03761549f, 0.10271016f, 0.00187237f, -0.08501901f, 0.19405484f, -0.02965210f, -0.06574200f, -0.09056108f, 
    -0.12362006f, -0.30803004f, -0.21165821f, -0.23216987f, 0.04136970f, 0.04286426f, 0.26613018f, 0.00368790f, 
    0.09825452f, -0.10292567f, -0.03053897f, 0.02285781f, -0.40699336f, 0.32877466f, -0.07116412f, -0.07868666f, 
    0.11148667f, -0.03811183f, -0.00611389f, 0.22654560f, 0.01024425f, 0.11882836f, 0.01317583f, 0.04709868f, 
    -0.70886427f, 0.03303682f, -0.07425406f, -0.04483735f, 0.16965339f, -0.10118571f, -0.02052345f, 0.26506826f, 
    0.11860687f, -0.06614961f, -0.12890059f, 0.06547463f, -0.00148655f, 0.08664082f, -0.21438527f, 0.06294290f, 
    0.09431161f, 0.00584704f, 0.07900228f, 0.03471901f, -0.01973598f, 0.05615374f, 0.02180439f, 0.14202456f, 
    0.27149126f, -0.15816808f, 0.00495903f, -0.02699176f, 0.03054653f, -0.03689725f, 0.00889319f, 0.11756287f, 
    -0.05024627f, 0.05461608f, 0.06987178f, -0.00486171f, 0.03215831f, 0.14698553f, -0.05398335f, 0.12526654f, 
    -0.16315539f, -0.03720661f, -0.18484263f, 0.04521183f, 0.03309257f, 0.15459445f, 0.03390233f, 0.15142475f, 
    -0.40164620f, -0.03252061f, 0.05056927f, -0.04429290f, -0.08884931f, -0.10172854f, 0.00707366f, 0.02396530f, 
    -0.03142670f, 0.16839044f, 0.07643496f, 0.08585268f, 0.48744404f, -0.16543390f, -0.04871874f, 0.23884127f, 
    0.11574261f, 0.01745627f, 0.03479460f, 0.00696274f, 0.15322913f, 0.05881578f, -0.04129358f, 0.23867166f, 
    -0.15245363f, 0.25188074f, 0.16122253f, 0.10733350f, 0.19146103f, 0.00176021f, 0.10056769f, 0.05847745f, 
    -0.11724810f, -0.11745008f, 0.16842502f, -0.07460874f, 0.29108697f, 0.18528837f, -0.16410165f, -0.02215296f, 
    0.04240736f, 0.17968006f, 0.02163191f, -0.04393377f, -0.07099395f, 0.03931081f, 0.05499468f, -0.15348719f, 
    0.19688623f, -0.05150421f, 0.07974471f, 0.01799570f, -0.10240784f, -0.05192511f, 0.09848534f, 0.00156237f, 
    -0.05083125f, -0.07639756f, 0.00545623f, -0.01473804f, -0.42766416f, -0.31788206f, -0.07029653f, -0.09526603f, 
    -0.06721664f, -0.01789439f, -0.02009068f, -0.04394345f, 0.01312346f, -0.04285032f, 0.19417185f, -0.05977681f, 
    -0.05203235f, 0.12895152f, 0.04313342f, 0.45556960f, 0.20594469f, 0.13292746f, -0.08770955f, -0.25254101f, 
    -0.01083117f, 0.10109302f, 0.02945566f, 0.07926401f, -0.38650408f, 0.27077594f, 0.06127296f, -0.19374457f, 
    -0.00686228f, -0.06923869f, 0.06689156f, 0.02347229f, 0.15148084f, -0.15379982f, -0.08962720f, -0.01767528f, 
    -0.24457242f, -0.14523888f, -0.29898062f, -0.14601496f, 0.07380160f, -0.01131899f, 0.14256015f, 0.11594281f, 
    0.04008799f, 0.14842901f, 0.06034248f, 0.05496234f, 0.00667601f, -0.31766886f, -0.20645580f, -0.07499340f, 
    0.08206116f, 0.06048652f, -0.04282315f, -0.05323330f, 0.00427678f, 0.01272895f, -0.10330888f, -0.01550749f, 
    -0.02562770f, -0.08716194f, 0.14300564f, 0.44650245f, -0.09053881f, -0.15247728f, -0.13695888f, 0.18450108f, 
    0.01222169f, 0.05108903f, -0.00635612f, 0.03488217f, 0.05539471f, 0.11572833f, -0.15812714f, -0.19977213f, 
    0.06846134f, 0.02027099f, 0.09489754f, -0.04887264f, 0.09630339f, -0.15744752f, -0.04667179f, 0.00630413f, 
    0.45620388f, -0.22847135f, -0.05771139f, -0.11414041f, -0.17552665f, -0.09628053f, 0.12280194f, -0.02811346f, 
    -0.09470437f, -0.03546592f, 0.06232553f, 0.05069227f, 0.14075431f, -0.23575956f, 0.02314514f, 0.14784473f, 
    0.00203144f, 0.09163159f, -0.10583265f, 0.01994750f, -0.05703937f, 0.02504550f, 0.04843860f, -0.04988716f, 
    0.27377817f, 0.26521778f, 0.20582250f, 0.00125494f, 0.02667402f, 0.03914183f, 0.03638282f, -0.04197988f, 
    0.14510538f, -0.02701885f, -0.06265008f, -0.02904266f, -0.17824039f, -0.33682808f, -0.07831329f, -0.20432223f, 
    -0.01557553f, 0.18106973f, 0.08819401f, 0.05728769f, -0.08948735f, -0.03333669f, 0.00652893f, -0.04783974f, 
    -0.28789970f, -0.23007269f, -0.15130518f, -0.12241546f, 0.21381806f, -0.13387236f, -0.19676808f, 0.24101192f, 
    0.21823180f, -0.04913551f, 0.18825898f, 0.17632689f, 0.26363137f, -0.00769002f, 0.35002020f, 0.19511624f, 
    0.01599212f, 0.00013770f, 0.10162116f, -0.05284921f, -0.06698090f, -0.00375424f, 0.01517776f, 0.00031565f, 
    -0.00734848f, -0.01405284f, -0.11509928f, -0.05477418f, 0.03411801f, 0.01127618f, 0.01902997f, -0.05044070f, 
    -0.01895612f, 0.02258618f, -0.02272481f, -0.05619422f, -0.09030277f, -0.01355530f, -0.05013049f, 0.02333649f, 
    -0.01024067f, -0.10029083f, 0.02540782f, -0.04460758f, -0.07205179f, -0.06668582f, 0.02489587f, 0.03015826f, 
    0.04179068f, -0.08157978f, -0.08916215f, -0.05802103f, 0.04478361f, -0.03554589f, 0.04976681f, 0.03954485f, 
    0.00784318f, -0.01086871f, 0.02732732f, -0.06480631f, -0.09613749f, -0.05482310f, -0.04877748f, -0.06423134f, 
    -0.00559062f, -0.01768313f, -0.10483392f, -0.00882423f, -0.09578898f, -0.07812978f, -0.02205339f, -0.00278737f, 
    -0.07264826f, -0.03208035f, 0.01207127f, -0.02969654f, 0.03805564f, 0.03747489f, 0.00157380f, 0.00132915f, 
    0.01802084f, -0.07778477f, 0.02265407f, 0.00188769f, -0.01940021f, 0.00119086f, 0.00626214f, -0.01653054f, 
    -0.00284871f, 0.01709137f, -0.04662368f, -0.02373721f, 0.00881123f, -0.09490252f, -0.01794032f, -0.05007967f, 
    -0.07489608f, 0.01111825f, -0.04690864f, -0.02241963f, -0.04044151f, -0.07599743f, -0.06871049f, -0.09324439f, 
    -0.02191159f, 0.00673598f, -0.10871049f, -0.02736899f, 0.02588007f, -0.03658178f, -0.03863505f, -0.02612650f, 
    0.01835456f, -0.03738840f, -0.09697269f, -0.02486923f, -0.07607615f, -0.03572273f, -0.05140622f, -0.04835885f, 
    -0.01399270f, -0.07968767f, -0.08215216f, 0.00177821f, 0.00621537f, -0.09390696f, -0.09492029f, 0.00284891f, 
    -0.04343531f, 0.03479984f, -0.08049797f, -0.00225329f, 0.00332354f, -0.03184938f, -0.01148895f, 0.01906360f, 
    -0.05596696f, -0.06721131f, -0.01757790f, 0.01329919f, 0.00708120f, -0.09464445f, -0.05365870f, -0.01094532f, 
    0.01066284f, -0.02866328f, -0.02080126f, -0.03809948f, -0.04103168f, -0.07413284f, -0.00553926f, 0.03897708f, 
    0.01986552f, -0.00877525f, 0.02851742f, 0.01396496f, -0.04342349f, 0.07934815f, 0.01240243f, -0.02747271f, 
    -0.07001446f, 0.03323438f, -0.05497214f, -0.07456262f, -0.04528340f, -0.06699994f, 0.00236658f, -0.03693403f, 
    -0.02951311f, -0.02917960f, -0.00137986f, 0.01938494f, -0.01054016f, -0.07606860f, 0.02199125f, -0.07390679f, 
    0.00356910f, -0.08140851f, 0.01134405f, -0.02957943f, -0.10028452f, 0.03645852f, 0.05767766f, -0.00901320f, 
    0.05619077f, 0.02775544f, -0.07761807f, -0.07129370f, -0.05039578f, -0.07460622f, 0.03447923f, -0.00788583f, 
    0.04979175f, 0.02970867f, 0.04833680f, -0.05424251f, -0.00019604f, -0.10312641f, -0.10294057f, -0.00167344f, 
    -0.04233158f, -0.05112282f, -0.06620823f, -0.01544906f, 0.00366354f, 0.02203315f, -0.03646913f, -0.00496133f, 
    0.05363033f, 0.01403769f, -0.01503518f, -0.04356890f, 0.01428054f, -0.05980797f, -0.07912274f, 0.04005388f, 
    -0.05513411f, 0.03902861f, 0.02232913f, -0.03809413f, 0.04582124f, -0.02539840f, -0.04270801f, -0.04142248f, 
    -0.02412109f, -0.05674552f, 0.05235415f, -0.03524037f, -0.02251706f, -0.02722751f, 0.01885568f, 0.01622053f, 
    -0.02629914f, 0.03596130f, -0.03954109f, -0.06765673f, -0.05990074f, -0.06335302f, 0.00437594f, 0.05190913f, 
    0.04740765f, -0.02202977f, -0.00338473f, 0.05081772f, 0.04571813f, 0.00651764f, 0.05097195f, -0.07468478f, 
    0.02292232f, 0.03605686f, -0.06448072f, 0.00543861f, -0.01740764f, -0.06818238f, -0.01853164f, -0.01339885f, 
    -0.02921782f, -0.02096567f, -0.06911641f, -0.06229098f, -0.06798128f, 0.03509498f, -0.07101423f, 0.02863483f, 
    0.06462228f, 0.04761963f, -0.01094061f, -0.05996168f, -0.02391705f, -0.05540164f, -0.07026464f, 0.05696471f, 
    -0.05141739f, -0.02086836f, 0.05937442f, -0.05245851f, 0.01243541f, -0.01866903f, 0.02833598f, -0.01531503f, 
    0.04506330f, -0.07376205f, -0.06510251f, 0.03502418f, 0.02434803f, 0.00223181f, 0.01691520f, -0.00390979f, 
    -0.01071368f, 0.03748136f, 0.00660720f, -0.06559067f, -0.05510810f, 0.04288801f, -0.06937549f, -0.00184956f, 
    -0.02959213f, 0.05611403f, 0.03918141f, 0.01497390f, -0.03722269f, -0.07280394f, -0.01941467f, -0.02350944f, 
    0.01857716f, 0.05885335f, 0.05201146f, -0.01282394f, 0.05992227f, -0.00609809f, -0.05616852f, -0.02030703f, 
    -0.07820228f, -0.04519812f, -0.01055436f, -0.01357728f, 0.02676201f, -0.04442469f, -0.01941775f, -0.02355176f, 
    -0.06277467f, -0.01763405f, 0.02362337f, 0.01226031f, 0.00101116f, 0.04961329f, 0.00758460f, -0.04348430f, 
    0.01133547f, -0.03343342f, -0.05133131f, -0.06180032f, 0.00469661f, -0.05805103f, 0.01626278f, -0.01501651f, 
    -0.01780163f, -0.00545599f, -0.03097934f, 0.00987125f, -0.01904254f, -0.00473773f, -0.07171784f, -0.00369533f, 
    0.03114385f, -0.02691722f, 0.04114782f, 0.01855989f, -0.01977983f, 0.01287165f, -0.02623155f, -0.00973226f, 
    -0.02077245f, 0.06104615f, 0.02971141f, -0.02665680f, -0.01247997f, 0.01548992f, -0.04768585f, -0.06347064f, 
    -0.04029217f, -0.07207715f, -0.04968427f, -0.07524443f, -0.04132938f, -0.03134075f, 0.06351217f, -0.00231815f, 
    -0.02288721f, -0.07756358f, -0.05265807f, -0.01835206f, 0.03830085f, -0.04607148f, -0.03338579f, 0.00097086f, 
    0.01201883f, 0.03520987f, -0.05275927f, 0.00965751f, 0.01111735f, 0.02307479f, -0.01474000f, 0.00503517f, 
    0.05627071f, 0.03951696f, -0.03326926f, -0.05426452f, 0.05741160f, 0.03675875f, 0.01910509f, -0.02770070f, 
    0.02966525f, -0.01173875f, -0.04790405f, 0.02875877f, 0.01643123f, 0.03255362f, -0.02743549f, -0.00662679f, 
    -0.03180673f, -0.01340348f, 0.05201517f, 0.01882727f, -0.03926415f, 0.05428290f, -0.07367880f, -0.01392862f, 
    -0.40050220f, 0.15345146f, -0.04650735f, -0.09651785f, 0.02408613f, 0.06960444f, 0.10862034f, -0.06748482f, 
    0.02620159f, -0.01377531f, 0.01793028f, 0.03744334f, 0.26046318f, 0.33557734f, 0.11288477f, -0.10051445f, 
    -0.06538622f, 0.06815170f, 0.29597643f, 0.14763486f, -0.10178906f, -0.07003327f, 0.07958066f, -0.07718663f, 
    0.01088425f, -0.17387950f, 0.15217006f, -0.00759927f, 0.05650528f, -0.02735197f, -0.04873148f, 0.06704956f, 
    -0.12728225f, 0.15329683f, 0.10015789f, 0.14321683f, -0.10917751f, -0.06404802f, -0.02254044f, -0.04312634f, 
    -0.16642018f, 0.00113917f, -0.06987178f, -0.09678551f, 0.03734907f, -0.05218277f, -0.07382864f, 0.08725119f, 
    0.03466869f, -0.05651705f, 0.00072204f, 0.09315845f, -0.08426675f, -0.04285890f, 0.15394422f, -0.05556380f, 
    -0.10084108f, 0.06535511f, -0.04603620f, -0.09040026f, -0.09474762f, -0.12357794f, 0.01008125f, -0.24464490f, 
    0.00799378f, 0.04832890f, -0.02168639f, -0.15595458f, -0.10141471f, -0.05251326f, 0.09841394f, -0.14268942f, 
    0.64775503f, 0.16309692f, 0.07307230f, 0.14366820f, -0.15057261f, -0.08606745f, -0.05641964f, -0.05402273f, 
    -0.13003911f, 0.09216856f, 0.06145360f, -0.03894105f, 0.28710410f, 0.36896402f, -0.08084740f, 0.08031510f, 
    0.02507075f, 0.12469918f, -0.10400232f, -0.08692257f, 0.06014229f, -0.10721421f, 0.09829493f, 0.07316390f, 
    0.17668758f, -0.03735213f, 0.08032095f, 0.31784862f, 0.12173000f, -0.14883605f, 0.09713545f, 0.28669971f, 
    -0.11119137f, 0.13361259f, 0.00809865f, 0.07432517f, 0.14945818f, -0.06190981f, 0.04304594f, 0.03529513f, 
    0.01054373f, -0.07824388f, -0.05683338f, 0.16372702f, -0.07051609f, -0.02332140f, -0.11215428f, -0.01770506f, 
    -0.03188931f, -0.10607367f, 0.10467298f, -0.06024393f, -0.02478488f, 0.01202365f, -0.14524502f, -0.04789067f, 
    0.05887679f, 0.04582207f, -0.01175950f, -0.10770491f, -0.40203303f, -0.21888925f, 0.22390553f, 0.15310456f, 
    0.02140572f, -0.02207058f, -0.11812463f, 0.00241613f, 0.03475699f, -0.10925493f, -0.01585828f, 0.01700201f, 
    0.09531771f, 0.01706524f, 0.03970552f, 0.01530175f, -0.08010625f, -0.11666691f, 0.02216143f, -0.00683680f, 
    0.01143450f, 0.12553580f, 0.07981605f, -0.09352448f, 0.12231982f, -0.18840699f, 0.03640484f, -0.06040712f, 
    -0.16276439f, 0.17672855f, 0.02184501f, 0.00452214f, -0.04468885f, -0.14594504f, 0.10431501f, -0.09365661f, 
    0.21063964f, 0.12681977f, 0.37002537f, 0.32332438f, 0.18365712f, 0.29231325f, -0.02963134f, 0.00820211f, 
    -0.12372212f, 0.08300055f, -0.05696857f, 0.00794238f, 0.14830603f, 0.31247297f, -0.21802351f, 0.03542473f, 
    -0.02251555f, 0.02705945f, 0.05102784f, 0.09383513f, -0.00106477f, -0.02502643f, -0.18975995f, -0.04199033f, 
    -0.01690176f, -0.06733493f, -0.06121064f, -0.06192622f, -0.01032902f, -0.02094363f, -0.06938024f, 0.05403780f, 
    -0.05381962f, -0.06605635f, -0.05286306f, -0.03607749f, 0.00528572f, 0.03827081f, -0.06664318f, 0.04384226f, 
    0.03609772f, 0.03852316f, 0.02917435f, -0.06238338f, -0.06769796f, -0.03026180f, -0.07774877f, -0.06173746f, 
    -0.05484944f, 0.02122956f, -0.03333672f, 0.03435490f, -0.06978638f, -0.06937022f, 0.05552826f, 0.00523671f, 
    -0.03913397f, 0.02574143f, -0.03495530f, -0.05184776f, -0.01860968f, -0.01696310f, -0.04070398f, -0.03229125f, 
    0.04984256f, 0.01485737f, -0.06448218f, -0.02703187f, -0.02956868f, -0.02459005f, -0.05629278f, 0.01843788f, 
    -0.03898672f, 0.03066170f, -0.05595374f, 0.00508756f, 0.01703962f, -0.06121791f, -0.01353429f, 0.00535813f, 
    -0.00056368f, 0.04358472f, -0.02654897f, -0.03607855f, 0.04142474f, -0.07341196f, 0.00430527f, -0.08028051f, 
    -0.07871053f, -0.06136237f, 0.00617448f, -0.02792108f, -0.07940866f, 0.01822801f, 0.00060461f, -0.05815959f, 
    -0.07953685f, 0.03201237f, -0.04036013f, 0.05240362f, -0.02335944f, -0.00951866f, 0.04961732f, 0.03385794f, 
    0.03730107f, 0.01521477f, -0.03095204f, -0.00340278f, 0.00297936f, -0.06845745f, -0.03835877f, -0.02656155f, 
    -0.07840274f, -0.00578993f, -0.04014370f, 0.06014338f, -0.04910680f, 0.00512762f, 0.04731727f, -0.05761954f, 
    -0.00152301f, -0.07585953f, -0.03949338f, 0.04962770f, 0.06057701f, -0.05635601f, 0.00307138f, 0.04947761f, 
    -0.05049011f, 0.00097865f, 0.03597518f, 0.05186354f, 0.00968811f, -0.06155446f, 0.06303050f, 0.03600299f, 
    -0.05206493f, -0.06668730f, -0.07316086f, -0.01052089f, -0.02678248f, -0.01940152f, -0.03508226f, -0.01653929f, 
    -0.03805969f, -0.05465477f, 0.03131894f, -0.07014062f, 0.03019753f, 0.04683572f, 0.00278962f, -0.08034577f, 
    0.06274668f, -0.01153541f, -0.01749936f, 0.01780481f, -0.07823594f, -0.07146710f, -0.05977019f, -0.06859895f, 
    -0.01386271f, 0.00217078f, 0.05987376f, -0.01387751f, 0.03145711f, -0.07830442f, -0.07040886f, 0.06154406f, 
    -0.03818190f, 0.06066579f, -0.05939185f, 0.00183177f, 0.03479254f, 0.03051578f, 0.02493152f, -0.07101110f, 
    0.02807616f, -0.03452389f, 0.02736460f, -0.05910761f, -0.07432155f, 0.02868941f, -0.03967439f, 0.00948248f, 
    0.02382972f, -0.06607337f, -0.00375446f, -0.07093365f, 0.05409268f, -0.04372590f, -0.07588024f, 0.01407806f, 
    0.03953615f, -0.02296023f, 0.03084359f, 0.04414686f, 0.04267029f, -0.01302417f, 0.01739532f, 0.03668453f, 
    -0.03522139f, 0.04774565f, 0.05438321f, -0.00243849f, -0.04523058f, -0.00097906f, -0.05127894f, -0.03302659f, 
    0.01566549f, -0.05129253f, 0.06337619f, -0.00297986f, 0.01910518f, -0.05164188f, 0.02787144f, -0.07605786f, 
    0.56848532f, -0.18439543f, 0.26842818f, 0.20791729f, -0.16567761f, -0.00694712f, 0.06794541f, -0.00999492f, 
    0.11213050f, -0.04417863f, 0.12787096f, 0.08944267f, 0.11735903f, -0.16695987f, 0.08499426f, -0.15026625f, 
    0.06186025f, 0.13562240f, -0.00354034f, -0.00207067f, 0.08954451f, 0.11620466f, -0.10411894f, 0.02641884f, 
    0.20906664f, 0.04248388f, 0.00097757f, -0.06779517f, -0.01366967f, 0.07918600f, -0.03055019f, 0.19379185f, 
    0.04946228f, -0.04401870f, -0.01181860f, 0.08586386f, 0.09109379f, -0.04855948f, -0.33435139f, -0.12109154f, 
    -0.00392404f, -0.02368347f, 0.01106787f, 0.10401110f, -0.01987855f, 0.11412238f, 0.02302395f, 0.09435274f, 
    0.32709217f, 0.07015832f, -0.08396466f, -0.14896354f, 0.11825808f, -0.00769423f, 0.03911842f, -0.05379724f, 
    0.12362901f, -0.07423781f, -0.09337064f, 0.04868659f, 0.49792123f, 0.38829896f, -0.33442405f, 0.22879812f, 
    -0.15692370f, 0.15901183f, 0.05322125f, 0.20129927f, -0.03882045f, 0.03564935f, 0.01557479f, 0.12224663f, 
    -0.19312106f, -0.28358880f, -0.18930782f, -0.13357697f, 0.02171143f, -0.11677622f, -0.02713175f, 0.00318551f, 
    0.02848020f, -0.05747341f, 0.00486825f, 0.10992881f, -0.14660567f, -0.14687534f, 0.31311193f, -0.01372297f, 
    -0.12507401f, 0.04351253f, 0.13643102f, -0.09858506f, 0.01280631f, 0.07466077f, -0.02060802f, 0.02635529f, 
    -0.19612634f, -0.22555842f, -0.04962915f, -0.43746772f, 0.01139521f, 0.18025905f, -0.08284711f, -0.09902859f, 
    -0.02607967f, 0.10685674f, -0.01610394f, 0.06095280f, -0.04593835f, 0.08521303f, -0.01086543f, 0.00159664f, 
    -0.01344553f, 0.10234280f, 0.05016828f, -0.11047693f, -0.07958453f, 0.01397915f, -0.04977328f, -0.06303309f, 
    0.36783236f, -0.18622731f, -0.00271595f, 0.01480459f, -0.14042890f, 0.10260733f, 0.10706319f, 0.02928462f, 
    0.04645450f, 0.02860770f, 0.08463134f, 0.06735723f, 0.20115860f, -0.16687515f, 0.17598543f, 0.13672282f, 
    0.09189837f, 0.09102277f, 0.14834391f, -0.10868121f, 0.06879330f, 0.07685629f, 0.01137934f, -0.09279355f, 
    -0.03529471f, 0.15146266f, 0.03904931f, 0.17159203f, -0.03966261f, -0.04058077f, 0.00977821f, -0.10962588f, 
    -0.10083485f, -0.03677925f, -0.01188933f, 0.00565186f, 0.11867815f, 0.11138522f, -0.10423534f, 0.17422436f, 
    0.04242922f, -0.12159656f, 0.14158541f, 0.08422020f, -0.02365170f, -0.10368212f, -0.03705671f, 0.03324943f, 
    -0.08303846f, -0.01310838f, -0.26938441f, -0.02354779f, -0.00289035f, -0.00661208f, 0.09654639f, 0.03796693f, 
    0.08474437f, 0.04432742f, -0.01731870f, 0.00807357f, 0.20716459f, -0.01143718f, 0.12806073f, 0.09929562f, 
    -0.16254979f, -0.04041534f, -0.01364501f, -0.10998225f, 0.06257455f, -0.06223222f, 0.05201756f, -0.06586875f, 
    -0.25749180f, 0.10292620f, -0.24223855f, 0.11384569f, 0.16968080f, -0.03733803f, 0.16149302f, -0.15892610f, 
    0.00792580f, 0.11534386f, 0.07860025f, -0.02033149f, 0.27885595f, 0.21741366f, -0.19894081f, -0.22800517f, 
    0.00721850f, 0.01260155f, -0.03933918f, 0.18443012f, -0.01915406f, -0.09067702f, 0.06615179f, 0.00717999f, 
    -0.36909795f, 0.45766842f, 0.21356928f, 0.23572287f, -0.10307813f, 0.28913543f, 0.11671588f, 0.06536193f, 
    0.05790295f, -0.01151715f, 0.06823812f, 0.07295623f, 0.08575466f, -0.07646947f, 0.16269428f, -0.13705048f, 
    0.02348813f, -0.00479389f, -0.00340393f, -0.09291012f, -0.05049798f, 0.12127334f, 0.00022647f, 0.11441058f, 
    -0.27187699f, -0.31721675f, 0.06993236f, 0.02472691f, -0.11732805f, -0.04797252f, -0.00524467f, 0.03693864f, 
    -0.06899889f, -0.02206691f, 0.10782198f, 0.01051106f, 0.00352842f, 0.38843346f, 0.11269873f, -0.04403992f, 
    -0.01526650f, -0.00212020f, -0.05797670f, -0.19001745f, 0.12368894f, -0.01940859f, 0.11631761f, 0.00922867f, 
    0.32564524f, 0.12095128f, 0.15397218f, 0.09002879f, -0.10454838f, 0.09827776f, -0.07892375f, -0.00315231f, 
    0.09266485f, 0.10649028f, 0.05202650f, 0.11371914f, 0.19751014f, 0.15086862f, -0.14098293f, 0.23714234f, 
    -0.00119532f, 0.00588580f, -0.02096866f, 0.00629567f, -0.17814216f, -0.16625848f, 0.16700637f, 0.06865855f, 
    -0.06359047f, 0.27907741f, 0.23843381f, 0.25154367f, 0.11221251f, -0.04176503f, 0.02621182f, 0.11874485f, 
    -0.18769671f, 0.06741443f, -0.02262018f, -0.00610337f, -0.03397228f, -0.29352641f, 0.00587756f, -0.00402704f, 
    0.08294116f, -0.19954771f, 0.01928423f, -0.05317513f, 0.05655805f, -0.00659119f, 0.06907295f, 0.13837650f, 
    -0.59039247f, 0.03741194f, 0.07349056f, 0.05342302f, 0.09254301f, -0.04478120f, -0.03658057f, -0.05159295f, 
    0.02131548f, 0.20322806f, -0.02749525f, -0.07594121f, -0.41879719f, -0.20220882f, 0.17738633f, 0.05569087f, 
    0.02765636f, -0.06349327f, 0.00913014f, -0.00043873f, 0.09753374f, 0.05666468f, -0.03894892f, -0.04345681f, 
    -0.10509481f, -0.06123215f, -0.11481224f, 0.03264885f, 0.01565519f, -0.09427216f, -0.06955074f, -0.05168658f, 
    -0.10864382f, 0.10339396f, -0.01294701f, 0.04350056f, 0.01580486f, -0.32853469f, 0.20525168f, 0.02524067f, 
    0.06468461f, 0.06064849f, 0.01249499f, -0.18209417f, 0.09629273f, -0.03710730f, 0.05857517f, -0.00225719f, 
    0.23070104f, -0.11643356f, 0.34027654f, 0.08725701f, -0.00943632f, 0.18043852f, -0.03517892f, 0.00412848f, 
    0.03178992f, 0.04407326f, -0.03950831f, 0.09677044f, -0.11321001f, 0.37361091f, -0.33796334f, 0.11717509f, 
    0.11157196f, -0.01436108f, 0.08122268f, 0.14534210f, -0.02785721f, -0.05739295f, -0.09066878f, 0.00505476f, 
    0.02919403f, 0.08722388f, 0.05509856f, -0.02493887f, 0.11809204f, -0.08956128f, -0.04472630f, -0.31087354f, 
    0.01806725f, -0.08971779f, 0.00959148f, 0.10885803f, 0.49157178f, 0.07302721f, 0.21734528f, 0.16554053f, 
    -0.00000748f, -0.05798141f, -0.05088251f, 0.13729374f, -0.08508882f, -0.10532100f, -0.08912233f, 0.05691160f, 
    -0.12083224f, 0.39904842f, -0.19946523f, 0.10070933f, -0.08127232f, 0.12987883f, 0.08786348f, 0.17436861f, 
    0.04298736f, -0.09369487f, 0.08141382f, -0.08752429f, 0.01291162f, 0.31423625f, 0.13308695f, 0.16027522f, 
    -0.02835210f, 0.04206530f, -0.09255859f, -0.07011265f, -0.01402375f, 0.12769844f, 0.03172177f, 0.05750077f, 
    -0.13705479f, -0.01478849f, 0.16729245f, -0.12702332f, -0.00479831f, -0.06769840f, 0.02465075f, -0.09377184f, 
    -0.07015134f, -0.00500144f, 0.00107113f, 0.03873953f, -0.06240679f, 0.34408519f, -0.08258411f, 0.18903537f, 
    0.00220108f, -0.10556570f, 0.12229049f, -0.05445305f, 0.19381189f, 0.09039740f, 0.02462089f, -0.04165169f, 
    0.20266499f, 0.07773195f, 0.02743895f, 0.24644347f, -0.02876078f, 0.27811015f, 0.04751515f, -0.01137449f, 
    0.13793804f, 0.20905085f, 0.21129678f, 0.23349509f, 0.28329355f, 0.17967166f, -0.07522895f, 0.04670498f, 
    0.06981326f, -0.02081898f, 0.00203995f, -0.12434915f, -0.13152581f, -0.03549412f, 0.24489048f, -0.05788747f, 
    0.08550922f, 0.10623291f, -0.16502243f, 0.01174219f, -0.20649403f, 0.26020858f, 0.23413275f, 0.08186425f, 
    -0.10187945f, 0.05165589f, 0.07757577f, -0.04238366f, 0.42426208f, -0.17014663f, 0.02991441f, 0.11375514f, 
    0.05585016f, -0.02207299f, -0.14352363f, -0.03179075f, 0.00995451f, 0.15966024f, -0.04346700f, 0.00087043f, 
    -0.08701348f, -0.07059877f, 0.28587168f, -0.13387722f, -0.04166770f, 0.04403674f, -0.02020803f, 0.21289477f, 
    -0.16209318f, 0.00646517f, -0.05073296f, -0.13218209f, 0.26374108f, -0.01298247f, 0.14939129f, 0.00473791f, 
    0.09779289f, 0.13001153f, -0.04759736f, -0.10056108f, -0.02334524f, 0.06585802f, 0.02415387f, -0.10516200f, 
    -0.30373523f, -0.16321434f, -0.10627083f, -0.26644698f, -0.02715827f, -0.18653326f, -0.19340071f, -0.12462717f, 
    -0.02581229f, -0.06972107f, 0.08118763f, 0.18431194f, -0.12657630f, 0.25085291f, -0.06709687f, 0.17943427f, 
    0.05188838f, 0.19600239f, -0.09771537f, -0.10748802f, 0.02820174f, 0.00544066f, -0.07992792f, -0.01447669f, 
    0.00087725f, 0.05064697f, 0.05881987f, -0.03033913f, -0.12207571f, 0.08534510f, -0.08469728f, -0.15484454f, 
    -0.07474371f, 0.12442476f, -0.14935659f, 0.09884395f, -0.30200428f, 0.21468024f, -0.09298644f, -0.16836485f, 
    0.24391954f, -0.03652331f, -0.13790178f, -0.17508800f, -0.00056415f, -0.05970639f, -0.16525204f, 0.08124113f, 
    0.05568540f, -0.04739582f, 0.12306309f, 0.21716605f, -0.00320592f, 0.05037685f, 0.03051858f, -0.04591206f, 
    0.11823685f, 0.03453045f, 0.16876306f, 0.10688813f, 0.43113580f, 0.32668972f, 0.10311909f, -0.25747603f, 
    -0.07472637f, -0.01878843f, 0.04200870f, 0.06095762f, 0.08659587f, -0.13773629f, 0.05561776f, 0.13477322f, 
    -0.22730292f, -0.20236938f, 0.04708239f, 0.02034755f, 0.13370761f, 0.26518336f, -0.07910956f, -0.08080155f, 
    0.13424690f, 0.07030417f, 0.13652964f, 0.10969150f, -0.18174826f, -0.13248433f, 0.12225010f, -0.01869200f, 
    0.01380537f, -0.03930914f, 0.08206115f, 0.01878773f, 0.00063772f, 0.08300918f, 0.03113518f, 0.15704708f, 
    -0.25534713f, 0.22457020f, 0.26535541f, -0.07129845f, -0.06188329f, -0.02864136f, 0.09067419f, 0.01043310f, 
    0.06419494f, -0.15227363f, -0.01905993f, -0.04777475f, 0.08488058f, -0.02794220f, 0.07029110f, -0.21732056f, 
    0.04907688f, 0.25959185f, 0.02755523f, -0.16223970f, -0.11691649f, -0.00975373f, 0.11975269f, -0.06985369f, 
    0.37687612f, -0.26255575f, -0.06444534f, 0.03640483f, -0.08033998f, 0.04523678f, -0.00816629f, -0.08103318f, 
    0.03864526f, 0.04879883f, 0.16250362f, 0.07182433f, 0.07136784f, 0.28743818f, 0.11032194f, 0.19971573f, 
    0.08013291f, -0.00382992f, -0.02058662f, -0.10072599f, -0.03504071f, -0.08436821f, 0.00970562f, 0.10917072f, 
    -0.28376839f, -0.33209890f, -0.07308681f, -0.14909530f, -0.00405861f, -0.06363524f, 0.03631808f, 0.12011607f, 
    -0.07580821f, 0.09511923f, 0.09419572f, 0.00935579f, -0.18160750f, 0.05767352f, -0.02820192f, -0.01806188f, 
    0.08684134f, -0.13820198f, 0.12952891f, 0.02554031f, -0.05593905f, 0.01454876f, 0.02552710f, 0.06763713f, 
    -0.67019278f, -0.09505879f, -0.23313649f, 0.01364516f, -0.02709495f, -0.11256596f, -0.05311466f, 0.14171113f, 
    0.10606122f, 0.18014139f, -0.03655295f, -0.05382084f, -0.47764057f, -0.11237837f, 0.28839847f, 0.24538872f, 
    0.03622320f, -0.15522118f, 0.00300789f, -0.13094069f, 0.06796797f, 0.09697979f, -0.08051687f, -0.03272215f, 
    -0.17343940f, 0.05861354f, 0.17565869f, 0.16214719f, -0.02348345f, -0.13222350f, -0.09188313f, -0.02531620f, 
    -0.04452575f, -0.00472401f, 0.01608810f, 0.07017846f, -0.33558735f, -0.17511715f, 0.15823850f, 0.21698970f, 
    -0.06529206f, 0.10410108f, -0.05631008f, -0.02431056f, 0.13616543f, 0.06278931f, 0.04560864f, -0.04251589f, 
    0.14316772f, -0.03453390f, 0.24422133f, 0.08954731f, 0.03155351f, 0.14545643f, 0.04880069f, 0.14545858f, 
    0.05434806f, 0.05319647f, -0.00669209f, 0.17455028f, 0.25749874f, 0.35685530f, -0.14260177f, 0.13293126f, 
    -0.08917556f, 0.00042132f, -0.02356029f, 0.07841472f, 0.03439515f, -0.01181539f, -0.04510025f, -0.05418268f, 
    -0.02397148f, -0.08670863f, -0.05221698f, -0.04571792f, -0.00044975f, -0.04761527f, 0.02474901f, -0.06488010f, 
    0.03337645f, -0.06158969f, -0.00045769f, -0.06798211f, -0.07147643f, -0.02612971f, -0.03516975f, -0.05847719f, 
    -0.04116396f, -0.05281403f, -0.06575609f, -0.00488940f, -0.06531125f, 0.05888925f, 0.04939049f, -0.04507367f, 
    -0.04809559f, -0.03910755f, -0.05829128f, -0.02540556f, 0.03710415f, 0.06559289f, -0.00973934f, 0.03881687f, 
    -0.01862686f, 0.02689193f, 0.05400478f, -0.01992151f, -0.03476785f, 0.01948101f, -0.02080539f, -0.02080230f, 
    -0.07361284f, -0.03455004f, 0.04627494f, -0.02221351f, 0.04424886f, -0.03661278f, 0.03333388f, -0.01384086f, 
    -0.07076098f, 0.02239021f, 0.05376443f, 0.04651703f, 0.04456022f, 0.03972983f, 0.02419450f, -0.02718083f, 
    -0.02016892f, -0.02450772f, 0.01446970f, -0.07511061f, 0.04797610f, -0.02463316f, -0.08053032f, -0.02908483f, 
    0.01328348f, -0.03026522f, 0.01718009f, -0.02400235f, -0.01515220f, 0.00331185f, -0.05662581f, -0.05146028f, 
    0.03536899f, 0.05312762f, -0.03895124f, 0.05714590f, -0.04748175f, -0.04630125f, 0.02713427f, 0.06453930f, 
    0.02385641f, -0.00577723f, 0.01081919f, 0.04713774f, -0.01715454f, 0.01300400f, 0.02420525f, -0.00675650f, 
    -0.04102543f, 0.01223959f, -0.06638815f, -0.05220442f, -0.01562107f, -0.06991484f, 0.04020702f, 0.04406929f, 
    0.00572548f, 0.03524547f, -0.02471682f, -0.01977690f, -0.02889265f, 0.03882460f, 0.05182032f, -0.07984971f, 
    -0.06345998f, -0.04298002f, -0.00966867f, -0.06981035f, 0.04044832f, 0.02853721f, 0.05804527f, -0.03475004f, 
    -0.00212289f, -0.06420218f, 0.05622969f, 0.01058514f, 0.00881582f, -0.05082674f, 0.00280832f, 0.00962581f, 
    -0.08545614f, -0.04557436f, -0.07878333f, 0.05707455f, 0.01357768f, -0.02820557f, -0.05857179f, -0.08113169f, 
    0.00014388f, -0.03313905f, 0.03329366f, -0.00484835f, -0.02080328f, -0.01070660f, 0.03608612f, -0.02086108f, 
    0.02088553f, 0.03537375f, -0.00537852f, 0.00865490f, -0.02031682f, -0.06170488f, 0.02451764f, -0.05835076f, 
    -0.06378929f, -0.02967945f, -0.01440731f, -0.03805954f, -0.02324671f, 0.03599484f, -0.06608003f, 0.05233585f, 
    -0.03103494f, -0.06390399f, -0.05777609f, -0.01159568f, -0.05717836f, -0.00479668f, -0.00294912f, -0.08428293f, 
    -0.06727149f, 0.02743057f, 0.04930643f, 0.04264526f, -0.03311577f, -0.02650300f, 0.05174595f, 0.05156917f, 
    -0.06724579f, -0.03886450f, -0.02333593f, 0.06635346f, 0.05934601f, -0.04913447f, -0.02841491f, -0.06570582f, 
    -0.00565903f, 0.01627400f, -0.01950077f, 0.03801731f, 0.03639040f, -0.06976067f, 0.01370436f, -0.05848225f, 
    -0.00598547f, -0.02421859f, 0.01170889f, -0.06310941f, -0.00119688f, -0.05925336f, -0.02100025f, -0.03659149f, 
    -0.03835902f, -0.02503198f, 0.05519143f, -0.00552373f, -0.02344348f, 0.02720626f, 0.05988150f, 0.04925694f, 
    -0.05799120f, -0.06427095f, -0.02801973f, 0.03829964f, 0.04007872f, -0.04867176f, 0.03212529f, 0.05460875f, 
    -0.01031864f, 0.01443027f, 0.04403018f, 0.01814947f, -0.04789479f, -0.04233685f, -0.03140404f, -0.01047771f, 
    -0.05090361f, -0.06253529f, -0.04400544f, -0.02833934f, -0.07641525f, -0.06282397f, 0.04604438f, -0.04112612f, 
    0.02475316f, 0.04123754f, -0.00567348f, 0.04127195f, -0.00208139f, 0.00178581f, -0.04008259f, -0.05437665f, 
    -0.03649734f, -0.07189046f, 0.01498346f, -0.03778201f, 0.02825891f, -0.02009144f, -0.05719288f, 0.05132998f, 
    0.03036070f, -0.02068836f, 0.00832439f, 0.00132283f, -0.05744130f, 0.05553139f, -0.06135084f, 0.04005592f, 
    -0.01515536f, -0.04108391f, 0.03511012f, -0.05202642f, -0.07911915f, -0.04410499f, 0.01120381f, 0.02225871f, 
    -0.06354395f, 0.04566270f, -0.05418565f, 0.02080659f, -0.01957746f, 0.05765116f, -0.04292883f, -0.04167212f, 
    0.00412503f, 0.04550213f, 0.05329872f, -0.06390546f, 0.03710287f, -0.06813832f, 0.02406522f, -0.03399848f, 
    -0.05151843f, 0.00745801f, -0.02716140f, 0.03300061f, 0.06150976f, -0.03116951f, -0.04320884f, -0.00246645f, 
    0.01106936f, -0.04976213f, 0.04530868f, 0.01072028f, -0.03068993f, -0.02744639f, 0.03291021f, -0.05569858f, 
    -0.05080196f, 0.07942516f, -0.00824544f, 0.03897623f, 0.03104081f, 0.03779905f, 0.04778655f, 0.03549995f, 
    0.00373059f, 0.05043184f, -0.02762917f, 0.00414980f, 0.00872274f, -0.01688741f, -0.03223595f, 0.01940622f, 
    -0.06568668f, 0.02501780f, -0.04472871f, 0.04972071f, 0.05193623f, -0.01712649f, -0.05703180f, -0.04910523f, 
    -0.05910684f, -0.07999063f, 0.01436753f, 0.07115281f, -0.00396264f, -0.05958397f, 0.02960223f, 0.05302078f, 
    0.02041161f, -0.01256201f, 0.02378463f, -0.03005873f, -0.03060873f, -0.00450965f, 0.06131817f, 0.02310392f, 
    -0.04241627f, 0.00637880f, 0.00478823f, -0.03336753f, -0.01256056f, 0.02626740f, 0.01881293f, -0.03680430f, 
    0.03001690f, 0.01837371f, -0.03548855f, -0.01703445f, -0.03551428f, -0.04614647f, -0.03060178f, 0.04396374f, 
    -0.01305813f, -0.07524695f, -0.03872651f, -0.05439602f, 0.04318723f, -0.06909247f, 0.03430605f, 0.03728791f, 
    0.04387756f, 0.03459219f, -0.06298165f, 0.03639962f, 0.00872655f, -0.00926284f, -0.06775381f, 0.01668556f, 
    -0.00324689f, -0.01129541f, -0.03747804f, 0.03139463f, 0.04211972f, 0.01127760f, -0.01585769f, 0.01547791f, 
    -0.06261291f, -0.03518692f, 0.05409330f, 0.03340333f, 0.01190804f, -0.00241126f, -0.02483291f, -0.07041904f, 
    -0.05283540f, 0.00305976f, -0.07922781f, -0.03228148f, -0.06005684f, -0.05319519f, -0.04598961f, -0.05366775f, 
    -0.25265741f, -0.03316730f, 0.00526583f, -0.46353343f, 0.02562107f, -0.02693389f, -0.09584208f, 0.10956230f, 
    -0.04013953f, 0.05690791f, -0.02381460f, 0.00862048f, 0.21786381f, -0.04239353f, -0.03528503f, 0.54668432f, 
    0.13601553f, -0.01954896f, -0.00527233f, 0.05706672f, 0.00747102f, 0.12358198f, 0.08109466f, 0.01547309f, 
    0.08596332f, -0.18129818f, -0.11767878f, 0.14842092f, -0.06328740f, -0.16270088f, 0.04123449f, 0.11024246f, 
    -0.07458571f, 0.04755352f, -0.08564971f, -0.01906599f, -0.01876123f, 0.02486856f, 0.13359649f, 0.27450824f, 
    0.04265293f, 0.07814088f, -0.03438243f, 0.01931905f, 0.16406739f, -0.03462092f, 0.01723253f, 0.03381569f, 
    0.05633107f, -0.14408277f, 0.08165261f, 0.16025184f, 0.23742360f, 0.04898501f, 0.06166079f, -0.01007375f, 
    0.00748828f, 0.20344867f, 0.01032907f, 0.26801351f, -0.35428357f, -0.06678684f, -0.03795088f, 0.23138142f, 
    0.06294163f, -0.18340373f, 0.02925567f, 0.32337707f, -0.03329390f, -0.02174551f, -0.12140939f, -0.03409007f, 
    -0.22117004f, 0.46903285f, 0.07907698f, 0.07278707f, 0.07364755f, 0.05438713f, -0.05489983f, 0.07828204f, 
    0.10147846f, 0.11068393f, -0.00179932f, 0.16671294f, -0.01604890f, -0.33000228f, 0.07353231f, -0.19013184f, 
    0.04525040f, -0.11172601f, 0.01408313f, 0.05884162f, -0.03897262f, -0.04174172f, 0.01138945f, -0.03361063f, 
    0.15196577f, 0.14087661f, -0.12675662f, 0.34729129f, -0.32476935f, 0.07755166f, -0.02818449f, -0.15796892f, 
    0.10734218f, 0.05879109f, 0.05218059f, -0.04710183f, 0.19715981f, 0.05555531f, 0.22597541f, 0.03974017f, 
    0.06269886f, -0.09628166f, 0.17989321f, -0.03185999f, -0.10612369f, -0.04637773f, 0.00570165f, 0.02393073f, 
    0.41207528f, 0.06687106f, 0.07425448f, -0.22162580f, -0.02386426f, 0.07773291f, 0.14825140f, -0.03453148f, 
    -0.06229806f, -0.14873461f, -0.00519680f, -0.21846206f, 0.19484389f, 0.40295249f, 0.00927861f, -0.06052260f, 
    -0.05411745f, 0.22391407f, 0.01458073f, 0.10864878f, -0.02468535f, 0.01324515f, 0.08077889f, -0.01795596f, 
    -0.18587124f, -0.05020757f, -0.09282964f, -0.14556335f, 0.03884255f, -0.01984335f, 0.15281440f, 0.04575089f, 
    0.16308714f, -0.01997904f, 0.12859905f, -0.07622613f, 0.03374580f, 0.04721782f, 0.09038869f, -0.26087573f, 
    0.16409697f, 0.07003214f, 0.02290384f, 0.16292883f, -0.02843874f, -0.01969449f, -0.01501558f, -0.02863995f, 
    0.12643935f, 0.19692539f, -0.22019254f, 0.05310026f, 0.16288477f, -0.16689308f, -0.18847018f, -0.06912279f, 
    0.09864771f, -0.00734493f, -0.01348404f, -0.03884673f, -0.20984443f, -0.18580776f, 0.20201223f, -0.24666902f, 
    0.04597484f, 0.05171974f, 0.09515148f, -0.04518979f, 0.04579310f, 0.01170455f, 0.08911535f, 0.03406787f, 
    -0.07329483f, -0.01693833f, -0.04671510f, -0.01664812f, 0.02347028f, 0.03203984f, -0.02808446f, 0.02344230f, 
    -0.03782372f, -0.06069884f, -0.02754753f, -0.05031034f, -0.06192765f, -0.01756361f, -0.04951820f, 0.07252222f, 
    0.07073368f, -0.05814856f, -0.00527809f, 0.01877750f, -0.02975597f, 0.03976915f, -0.04548997f, 0.03148263f, 
    -0.03626931f, 0.04188131f, -0.02639731f, -0.05210984f, -0.06921545f, -0.03288170f, -0.08852939f, -0.04163340f, 
    -0.03213152f, 0.00767836f, 0.03482264f, -0.05561328f, 0.02212902f, 0.02202335f, -0.07406420f, -0.04467895f, 
    -0.06067373f, 0.03685303f, 0.04733079f, -0.00468881f, -0.06585667f, -0.05579745f, 0.03030059f, -0.05152275f, 
    -0.08029549f, -0.07501781f, -0.08044713f, -0.03110148f, -0.04119808f, 0.06861502f, 0.01157734f, 0.07333778f, 
    -0.01825922f, 0.03835205f, -0.07169319f, -0.05346708f, -0.05614768f, -0.00408435f, 0.02822448f, 0.03692660f, 
    -0.10102079f, -0.01480702f, -0.08638827f, -0.03962612f, -0.04033982f, 0.06527150f, -0.00238901f, 0.04219102f, 
    -0.05129195f, 0.06073917f, -0.07235568f, -0.10061299f, 0.00001961f, 0.01608763f, -0.06369447f, -0.04752816f, 
    -0.02622367f, -0.05964828f, -0.07475623f, -0.07394841f, -0.12859541f, 0.07165940f, -0.00341471f, 0.02634259f, 
    0.00117428f, -0.00074972f, 0.01036075f, 0.04642724f, 0.00920386f, 0.03166504f, -0.00169286f, 0.04257639f, 
    0.03096419f, 0.00112469f, -0.04650418f, 0.04283993f, -0.02410996f, -0.00243559f, -0.07472622f, 0.01018643f, 
    0.02132397f, 0.05409905f, -0.02795433f, -0.07265583f, -0.00269477f, -0.01401954f, -0.01347994f, -0.05731698f, 
    -0.06655270f, -0.07812158f, -0.04755087f, 0.01967020f, 0.04391915f, 0.01499625f, 0.05675328f, 0.04735712f, 
    0.05022262f, -0.04093432f, -0.06178161f, 0.03900411f, 0.02409095f, 0.06110113f, 0.02829670f, -0.03261501f, 
    -0.02382973f, -0.01105397f, 0.02644849f, 0.00592242f, -0.11565539f, 0.03615660f, -0.06945523f, -0.02806044f, 
    -0.02102959f, -0.01415509f, -0.05834659f, 0.01295139f, 0.04668422f, -0.08356672f, -0.00597573f, -0.02936357f, 
    -0.10225980f, -0.08439315f, -0.02885799f, 0.01900836f, 0.04152892f, 0.04117161f, -0.03615840f, 0.05970895f, 
    -0.08200166f, 0.08857336f, 0.02449588f, -0.05018554f, -0.06883655f, -0.10105137f, -0.01486671f, 0.04039515f, 
    -0.02150771f, -0.02605798f, -0.02335585f, 0.05323418f, -0.06317320f, -0.07136288f, -0.06339227f, -0.00264364f, 
    -0.01851680f, 0.02856417f, 0.01981014f, -0.08991830f, 0.04145656f, -0.07792581f, 0.00066002f, 0.00143159f, 
    0.00374012f, -0.08078310f, 0.01626195f, 0.03102797f, -0.10033990f, -0.04425228f, 0.03664994f, -0.02941631f, 
    0.00944689f, -0.03793465f, 0.02842436f, 0.06357489f, -0.08810579f, -0.04647882f, 0.01498832f, -0.01377235f, 
    0.40971455f, -0.07911330f, 0.03404520f, 0.14214700f, -0.09788772f, 0.09053658f, 0.02649823f, 0.08219557f, 
    0.16427311f, 0.20379287f, 0.14750572f, 0.17384940f, 0.15852751f, 0.15863849f, -0.02125647f, -0.33372918f, 
    0.00470871f, 0.00465248f, 0.14369647f, -0.13801229f, -0.01140470f, -0.04362137f, -0.08578120f, 0.06226483f, 
    -0.12246429f, -0.26588148f, 0.05760458f, -0.14395270f, -0.00221707f, 0.15448220f, 0.17740922f, -0.01917266f, 
    -0.09120189f, -0.04123240f, 0.19713564f, 0.05649881f, 0.01235998f, 0.04627069f, -0.13163292f, -0.09337022f, 
    0.05213162f, 0.18022873f, -0.00928586f, 0.09358502f, -0.10013394f, 0.27535123f, -0.11678153f, 0.18404295f, 
    -0.02972673f, 0.49647054f, -0.05809845f, -0.20113032f, -0.00055145f, -0.02557904f, 0.07459172f, -0.08810883f, 
    0.10014673f, -0.13313748f, -0.22094204f, -0.10689583f, 0.07087356f, -0.27775863f, -0.01636948f, -0.22593935f, 
    0.24215515f, 0.06667734f, 0.11681894f, -0.11023402f, -0.22512875f, -0.02120892f, 0.06684363f, -0.01816153f, 
    -0.17865928f, -0.12554830f, -0.16066664f, -0.22911663f, 0.05442209f, -0.04567409f, 0.13783064f, -0.01612282f, 
    -0.06139509f, 0.17430918f, 0.04440812f, 0.21299142f, -0.03230986f, 0.06304125f, -0.08518227f, 0.39983824f, 
    0.14216474f, 0.04898020f, 0.04796726f, 0.05557174f, 0.11309303f, 0.05939032f, 0.10780826f, 0.08769602f, 
    -0.06891321f, -0.14614642f, -0.05037054f, -0.31664807f, -0.08551318f, -0.24029602f, 0.08914550f, 0.08632876f, 
    0.00310766f, 0.08005084f, 0.30899593f, 0.02638178f, -0.04604559f, 0.31995684f, -0.17174263f, -0.03076887f, 
    -0.00875012f, -0.04701728f, -0.08019241f, -0.08129779f, 0.09444888f, -0.06058356f, -0.03661198f, -0.16221270f, 
    0.30101311f, -0.05852043f, -0.00522904f, 0.26483300f, 0.00601472f, -0.01426263f, 0.11647970f, 0.21961369f, 
    -0.07745616f, 0.02818849f, 0.02241037f, -0.07029654f, 0.11868870f, 0.03817572f, -0.03790886f, 0.36980486f, 
    0.13920347f, 0.06509864f, 0.04891667f, 0.10339468f, -0.01476732f, 0.07422230f, -0.03069934f, -0.14052781f, 
    -0.11384404f, 0.15920560f, 0.12156012f, 0.00856749f, -0.07201510f, -0.15342237f, -0.09283614f, 0.04226581f, 
    -0.00892208f, -0.05831502f, 0.09257600f, 0.13219926f, -0.35460281f, 0.04641065f, 0.18295689f, 0.23975831f, 
    -0.11935741f, 0.22819169f, -0.00810914f, -0.03177320f, -0.04628085f, -0.11883205f, -0.07573765f, -0.06757116f, 
    -0.13681491f, -0.06904817f, 0.04500762f, -0.17731994f, -0.04113825f, 0.02528215f, 0.19337827f, 0.06653699f, 
    -0.09612913f, 0.06082859f, -0.14384197f, -0.02238549f, 0.23313816f, 0.01955785f, -0.12657596f, -0.04714210f, 
    -0.09433645f, -0.00660827f, 0.04112760f, 0.09333234f, 0.04069827f, 0.12533970f, -0.00966622f, -0.17302456f, 
    0.27406207f, 0.01576048f, 0.21391271f, -0.29984209f, -0.10073445f, -0.14331819f, -0.09318578f, -0.00222583f, 
    -0.03151114f, -0.15920906f, -0.01221667f, 0.02361796f, -0.33564281f, -0.34144557f, 0.09147929f, 0.43846050f, 
    -0.06688899f, -0.01547335f, -0.14594460f, -0.04390924f, -0.09830999f, 0.10173419f, 0.10985347f, 0.06475387f, 
    -0.11266720f, 0.14165030f, -0.09115128f, 0.07101712f, -0.02534251f, -0.13009419f, -0.10967930f, -0.01889648f, 
    0.15902707f, 0.00443473f, -0.04250719f, -0.14128102f, 0.08079194f, 0.04250502f, 0.03335173f, 0.11651103f, 
    0.05020026f, -0.18369989f, 0.06428313f, -0.03174976f, 0.02336708f, -0.16033669f, -0.05968537f, 0.06431118f, 
    0.28524581f, -0.17945576f, -0.03142657f, 0.03386125f, -0.03932407f, 0.02637891f, -0.08769351f, 0.05368409f, 
    0.05573711f, 0.03567122f, 0.05784483f, 0.09091061f, 0.13851787f, 0.07474314f, -0.03487808f, 0.31280348f, 
    -0.03146258f, -0.03053093f, 0.03640243f, 0.16004397f, 0.08234987f, 0.12011932f, 0.00143245f, 0.01864512f, 
    -0.22300619f, 0.18050647f, 0.00793505f, 0.16830738f, 0.12007989f, 0.07054006f, 0.05235657f, -0.10185574f, 
    0.05345508f, -0.15735066f, -0.05691134f, -0.10969324f, -0.06879305f, -0.32630202f, 0.02500996f, -0.20289312f, 
    0.13176148f, -0.00513054f, 0.02685632f, 0.10469876f, -0.06209459f, 0.02574988f, -0.05131677f, 0.03121317f, 
    0.10663048f, -0.02602843f, -0.13451463f, 0.03285309f, 0.12727287f, 0.23227875f, -0.11680582f, -0.12317759f, 
    -0.09374528f, -0.05169888f, 0.07480789f, -0.01560116f, 0.21307373f, -0.25679678f, 0.05840173f, 0.27851877f, 
    0.04809541f, 0.06614419f, 0.06158674f, 0.04799829f, 0.00146869f, 0.03393170f, 0.06399595f, -0.07090746f, 
    -0.00692622f, 0.07652775f, -0.07342482f, -0.10050830f, 0.05959156f, 0.10237656f, 0.04120353f, -0.07546289f, 
    0.06512410f, 0.01900795f, 0.18570027f, -0.04930507f, 0.32251036f, 0.17370604f, -0.03883598f, -0.27956921f, 
    -0.04301378f, 0.01512178f, 0.13200378f, 0.03626730f, 0.07706658f, -0.06185241f, 0.13859445f, 0.05960762f, 
    -0.01523593f, 0.13861635f, 0.04051064f, 0.03291143f, 0.04881959f, 0.17543280f, -0.02550906f, -0.12891968f, 
    0.13191919f, -0.01203597f, -0.12339591f, 0.07056198f, 0.40697882f, 0.19485214f, 0.13574295f, -0.01435271f, 
    0.15418404f, -0.18237822f, -0.01577228f, 0.00990844f, -0.02366569f, 0.10214835f, 0.00031855f, -0.12186178f, 
    0.19182731f, 0.05395466f, -0.15651488f, 0.01531541f, 0.07557458f, -0.13312145f, 0.03530052f, 0.03316652f, 
    0.02768160f, -0.10160126f, 0.16922502f, 0.01846350f, -0.27441275f, 0.19616224f, 0.16556437f, -0.55811328f, 
    0.09041709f, -0.02744572f, 0.02100008f, -0.11078384f, -0.10903227f, 0.01666273f, 0.12471358f, 0.09005100f, 
    0.75756294f, -0.01387421f, 0.10849728f, -0.06354215f, 0.01490920f, -0.15220658f, 0.00249943f, 0.10200402f, 
    0.04574997f, -0.00240481f, 0.02556008f, 0.03545220f, -0.55881757f, -0.23055618f, 0.25432542f, 0.15617146f, 
    -0.07857786f, -0.14895785f, -0.03639894f, -0.12454588f, 0.01471780f, -0.07944728f, -0.01724868f, 0.14165157f, 
    -0.13401139f, 0.15170158f, -0.13163799f, -0.05732980f, 0.18803142f, 0.07551605f, -0.00652766f, -0.06560244f, 
    -0.01330335f, -0.05607442f, 0.02156222f, -0.13286704f, 0.16268277f, 0.11602318f, -0.04090590f, 0.00773752f, 
    0.05938397f, -0.16459258f, 0.04514784f, -0.01119747f, -0.10748323f, 0.02530152f, -0.00648611f, 0.13606283f, 
    0.37279162f, 0.32261831f, 0.08309817f, 0.12984248f, -0.02860550f, -0.11584388f, 0.01441775f, 0.08488102f, 
    0.08340828f, 0.06769226f, -0.00848558f, -0.03549462f, 0.16912331f, -0.05974595f, -0.13469377f, 0.10318673f, 
    0.11545448f, -0.01164578f, 0.00924573f, -0.06254128f, 0.09825133f, -0.06127070f, 0.13103913f, 0.01936142f, 
    -0.23096840f, 0.14313564f, -0.27056047f, 0.05729243f, 0.06012256f, 0.03292036f, -0.02164648f, -0.02847217f, 
    0.16686691f, -0.09806057f, 0.13496013f, 0.13388737f, -0.36109912f, 0.13580407f, 0.04502705f, -0.20945570f, 
    0.19171898f, 0.07296943f, 0.15896985f, 0.07255602f, 0.04407568f, 0.05712724f, -0.01628556f, -0.01201524f, 
    -0.11249527f, 0.02281709f, -0.14034265f, -0.11235186f, 0.15685961f, 0.20166729f, 0.07442851f, -0.04755954f, 
    -0.00699749f, -0.03555195f, 0.03088784f, 0.04183691f, -0.24161331f, -0.04891329f, -0.05930383f, 0.08682017f, 
    0.01342789f, -0.07530131f, 0.04710645f, 0.03777970f, -0.00616911f, 0.06620358f, 0.17822038f, -0.04153665f, 
    -0.37820989f, 0.21989045f, -0.12286637f, 0.09412915f, 0.23893237f, -0.02468037f, 0.10808342f, 0.10462180f, 
    -0.00213435f, -0.05406494f, 0.13584150f, 0.01902026f, 0.32189816f, 0.04504038f, -0.29054603f, -0.14512606f, 
    0.01539007f, -0.05815980f, 0.13816926f, 0.15334311f, 0.12942265f, 0.11789107f, 0.01528387f, 0.07053842f, 
    0.31867510f, 0.14591990f, 0.03985668f, 0.12039522f, 0.02458689f, 0.06512167f, -0.06718830f, 0.15028407f, 
    -0.08044971f, -0.06154858f, -0.13683641f, 0.03433361f, 0.55808628f, 0.25003424f, 0.06034162f, 0.07338689f, 
    0.03021255f, -0.03307284f, -0.10894540f, 0.02459801f, 0.06657065f, 0.02616132f, -0.07477649f, -0.00738751f, 
    -0.26985648f, -0.18802562f, -0.08858949f, -0.13232394f, -0.08223885f, -0.19169785f, 0.14398366f, 0.07183703f, 
    -0.13590714f, -0.09341656f, 0.03001437f, -0.02959986f, 0.28052837f, 0.08798461f, 0.15703979f, -0.16185147f, 
    0.05026233f, 0.03645334f, 0.04845648f, 0.03781366f, 0.00362529f, 0.08708869f, 0.00987680f, 0.01362587f, 
    -0.52919900f, 0.19543040f, 0.06162674f, -0.26711857f, 0.18052162f, -0.06280239f, -0.16894025f, -0.05386374f, 
    -0.08938434f, -0.04259698f, -0.05367651f, -0.11838575f, 0.08434782f, -0.15899956f, -0.10091548f, 0.35211375f, 
    -0.12708074f, 0.01939455f, -0.01334941f, 0.24988854f, -0.09033576f, -0.01055107f, 0.06184762f, 0.02804643f, 
    -0.05673574f, -0.00993464f, -0.05819716f, 0.19866416f, -0.09158879f, 0.02765246f, 0.01934320f, -0.01772373f, 
    -0.00504543f, -0.00719604f, -0.04532563f, -0.02068135f, -0.01551742f, 0.15021640f, 0.42461964f, 0.16490577f, 
    -0.00779186f, -0.00456411f, -0.00814591f, -0.06317893f, 0.15363167f, -0.07480141f, 0.07580377f, -0.08525160f, 
    -0.24615021f, -0.31333929f, 0.04598690f, 0.08960601f, -0.00610720f, 0.07794362f, -0.11486461f, 0.02000679f, 
    -0.11745214f, 0.17955281f, 0.20390865f, 0.13529728f, -0.15026917f, -0.04939131f, 0.20748286f, 0.24504490f, 
    0.09177180f, -0.15551624f, -0.04412380f, 0.14826605f, 0.16731873f, -0.01579297f, 0.05229782f, 0.06395572f, 
    -0.04866462f, 0.30058175f, 0.31763157f, 0.16046678f, 0.10994398f, 0.11822595f, -0.06876090f, 0.08390737f, 
    0.29179776f, 0.05742885f, 0.01707425f, -0.08666022f, -0.04924647f, 0.11064816f, -0.18005618f, 0.07557010f, 
    0.09914227f, -0.13358825f, 0.06934185f, 0.04281300f, 0.02699174f, -0.10059544f, -0.02298304f, -0.07920452f, 
    0.06947730f, -0.06167688f, -0.21125333f, 0.22310793f, -0.15873110f, 0.03602981f, -0.02684525f, -0.08117664f, 
    -0.04526158f, -0.06045532f, -0.06754020f, 0.02091533f, 0.16677372f, -0.11243330f, -0.01294313f, 0.03056695f, 
    0.04650040f, -0.12083257f, 0.09510051f, 0.21218705f, 0.04811256f, 0.04350483f, 0.10139256f, 0.21373805f, 
    -0.39312720f, 0.08840083f, -0.12687241f, -0.08896862f, 0.12478880f, 0.05849527f, -0.05372765f, -0.09437604f, 
    -0.06886589f, 0.01863227f, -0.05968478f, 0.00273144f, 0.00408760f, 0.37728265f, 0.01178962f, -0.18361753f, 
    -0.00085824f, 0.13390501f, 0.01915238f, 0.17278807f, -0.02304789f, -0.02678809f, 0.12672535f, 0.17725180f, 
    -0.14578810f, -0.15045954f, 0.01463276f, -0.07548317f, 0.12403728f, 0.14100125f, 0.10911568f, 0.02234348f, 
    0.22044739f, 0.00097068f, 0.04541408f, 0.04313445f, -0.21952103f, 0.08584304f, 0.15365003f, -0.08064887f, 
    0.06143755f, -0.09981339f, -0.09869873f, 0.03639065f, -0.01892368f, 0.17425668f, 0.02380230f, 0.04436867f, 
    0.24556287f, 0.18307421f, -0.13241462f, -0.06914584f, 0.08665871f, -0.02523451f, -0.14843759f, -0.09536153f, 
    -0.05916476f, -0.00287859f, 0.13186452f, 0.02073186f, -0.37748262f, 0.09313799f, -0.02565000f, -0.31956959f, 
    0.24161169f, -0.05956480f, 0.13088700f, -0.02687730f, 0.02517330f, -0.02426158f, 0.00535810f, 0.21815735f, 
    0.14020574f, -0.03707049f, 0.00682112f, 0.10470708f, -0.02529440f, 0.10410989f, -0.03534120f, -0.06159831f, 
    0.03796494f, 0.07448193f, -0.03043949f, -0.09371167f, -0.05556918f, -0.04354469f, 0.04406828f, 0.05880044f, 
    0.02379142f, 0.14483522f, -0.07221808f, -0.14120847f, 0.07559384f, 0.12429610f, 0.03723865f, -0.02147780f, 
    0.40326259f, -0.36946926f, 0.10889478f, -0.27481914f, 0.09499132f, -0.13671090f, -0.04160890f, 0.01895597f, 
    -0.01924008f, -0.00511516f, 0.01741120f, 0.00680376f, 0.18576439f, 0.03855614f, -0.20291469f, 0.13806109f, 
    0.09699519f, 0.06691904f, 0.05026400f, 0.09631179f, 0.07260276f, -0.06387166f, 0.09548651f, -0.12717429f, 
    0.21566358f, 0.08530059f, -0.21508771f, 0.10752009f, -0.01491657f, 0.03552336f, 0.07446189f, 0.00530575f, 
    0.07671437f, -0.01078359f, -0.01568659f, 0.10798829f, 0.28905988f, -0.31531715f, 0.08844032f, -0.07829202f, 
    -0.03238117f, 0.10558072f, -0.03079996f, 0.00994021f, 0.02475378f, 0.03789320f, 0.01044589f, 0.06164823f, 
    -0.00040658f, -0.10288426f, 0.20090719f, -0.17916256f, -0.00765119f, -0.14379708f, 0.10462419f, 0.02903220f, 
    -0.06564026f, -0.04034092f, 0.02493420f, -0.00943756f, -0.14784379f, 0.11073552f, 0.17019176f, 0.00832804f, 
    0.00692182f, 0.00490159f, -0.11147795f, 0.03321104f, 0.14516756f, 0.04645249f, -0.10658010f, 0.03528566f, 
    0.17042926f, -0.03395224f, -0.00758264f, -0.32197297f, 0.05379009f, 0.03869965f, -0.03777500f, -0.04418427f, 
    0.07184198f, 0.09669743f, -0.03428654f, -0.03011451f, -0.27015185f, 0.33180219f, 0.08176162f, -0.09123396f, 
    -0.00873643f, 0.20054685f, -0.18206531f, -0.04735107f, 0.00437408f, 0.05056088f, -0.01878550f, 0.05622562f, 
    0.30154604f, -0.03126911f, -0.02585894f, 0.22735888f, -0.01633777f, 0.04079282f, -0.03300932f, -0.06756833f, 
    -0.05388794f, -0.10886033f, 0.07036714f, 0.21820536f, -0.06019104f, -0.07197856f, -0.15821913f, 0.11771106f, 
    0.00740723f, -0.03922093f, -0.04776318f, 0.09526493f, -0.05875569f, 0.04373510f, 0.09615354f, -0.06938149f, 
    0.46089390f, -0.04376064f, -0.09943151f, 0.03706464f, 0.00250213f, 0.03192203f, 0.05316672f, 0.05774744f, 
    -0.04120031f, -0.00268488f, -0.06290980f, -0.04371840f, 0.26790863f, 0.02375928f, -0.28430358f, 0.18123339f, 
    -0.04008682f, -0.11489119f, 0.07206929f, -0.06613906f, 0.00041238f, -0.12461060f, -0.00797888f, 0.21163461f, 
    -0.24073209f, 0.10309344f, -0.12504527f, 0.08062879f, 0.04110295f, 0.06196839f, 0.14233512f, -0.01300299f, 
    0.15749919f, 0.07679488f, 0.12214006f, -0.06682275f, 0.33000877f, -0.46776417f, 0.07754146f, 0.48279488f, 
    -0.02354540f, 0.01108572f, -0.05954998f, -0.10707985f, 0.07606091f, -0.05368586f, -0.00465071f, 0.10656355f, 
    -0.06147293f, -0.02335952f, 0.09809837f, -0.01538187f, -0.02146486f, 0.03093343f, -0.09273345f, 0.11542992f, 
    -0.02703342f, -0.03614934f, -0.05125062f, -0.12248799f, -0.11287639f, -0.03336501f, -0.22965471f, -0.00988386f, 
    -0.01254829f, 0.00095732f, -0.05406518f, -0.13782990f, -0.00877477f, 0.08667587f, 0.01514690f, -0.01571941f, 
    0.16367249f, -0.43528855f, 0.12688680f, -0.09928593f, 0.14381382f, -0.21604180f, 0.14905308f, -0.04102844f, 
    0.09814095f, -0.00180854f, 0.05626210f, -0.00111829f, -0.07286090f, 0.05020018f, 0.01219058f, -0.03391868f, 
    0.06682283f, 0.07005735f, 0.12289845f, 0.20960057f, 0.19679508f, -0.05230956f, 0.25717869f, 0.01349047f, 
    -0.08736873f, 0.30953673f, -0.05560456f, 0.17661479f, 0.00896528f, 0.15036865f, -0.04426667f, -0.04590346f, 
    0.03307890f, 0.08895169f, -0.09860338f, 0.11372164f, -0.13539353f, -0.47299713f, 0.18707453f, -0.22735099f, 
    0.18536663f, 0.03338664f, 0.06946062f, 0.05586077f, -0.00359062f, -0.03892612f, -0.17557377f, -0.01229061f, 
    -0.40715879f, -0.15792000f, -0.03328871f, -0.20122904f, -0.09949917f, -0.06458808f, 0.03906317f, 0.08357725f, 
    0.02645174f, 0.06333437f, -0.06930339f, -0.08540794f, -0.10136152f, -0.55447066f, -0.12921607f, 0.03312604f, 
    0.11011339f, -0.14545935f, 0.02500149f, 0.18202212f, 0.17005174f, 0.08889341f, -0.08259293f, 0.16096477f, 
    0.10276494f, -0.17273711f, 0.07767735f, 0.09612510f, -0.05049951f, -0.19279675f, 0.03871279f, 0.01366029f, 
    0.10340813f, 0.02050586f, 0.09094623f, -0.08131886f, 0.11398566f, 0.30463216f, -0.15392399f, -0.06599602f, 
    0.05461256f, 0.18246169f, 0.02335338f, 0.03576811f, 0.04103387f, -0.06961271f, 0.03063762f, -0.06468453f, 
    0.55625397f, -0.00284387f, -0.16871497f, 0.21123870f, 0.01936264f, 0.02042830f, 0.17038873f, 0.09060223f, 
    -0.02664847f, -0.16365643f, 0.14362316f, 0.09638866f, 0.02164739f, 0.30045238f, -0.10440867f, -0.01774040f, 
    0.06084393f, 0.03384940f, -0.10356808f, 0.22605588f, -0.00863322f, -0.07847547f, 0.14721230f, 0.09551087f, 
    0.10493612f, 0.10626722f, 0.05116541f, -0.01451673f, 0.04858504f, 0.18291862f, 0.17810832f, -0.08041156f, 
    0.19652860f, 0.00109682f, 0.03375748f, -0.01581912f, -0.21265662f, 0.00714544f, 0.16221486f, -0.05881947f, 
    -0.00008035f, -0.15482447f, -0.04693488f, -0.04631751f, -0.11409357f, 0.02034274f, -0.06747931f, 0.15709567f, 
    0.11383159f, 0.22085772f, -0.21422479f, -0.06556469f, 0.09818054f, 0.05053449f, -0.01465805f, 0.06671747f, 
    0.10770543f, -0.04741137f, 0.17987341f, -0.02174235f, 0.06073714f, -0.32419214f, 0.27255389f, -0.09727195f, 
    -0.13659343f, -0.02976117f, -0.05576633f, -0.05674746f, 0.10414568f, 0.09096039f, 0.08572084f, -0.01738800f, 
    -0.03143496f, 0.02306663f, 0.05836776f, 0.00747014f, -0.03690346f, -0.06441859f, -0.03884421f, -0.03063263f, 
    -0.04751349f, -0.06315540f, -0.00984397f, 0.05403868f, 0.02564186f, -0.06373980f, 0.03726988f, 0.00892624f, 
    -0.03905138f, -0.02063135f, 0.02610507f, 0.00921659f, 0.00268645f, -0.07067082f, -0.06594330f, -0.01720923f, 
    -0.06114084f, 0.02056673f, -0.07332116f, -0.05929626f, 0.02967024f, -0.07023777f, -0.00079134f, -0.05531275f, 
    -0.06700714f, 0.00720708f, -0.06354153f, -0.07832833f, 0.00762584f, -0.00044084f, 0.01700987f, 0.06004904f, 
    -0.03239689f, 0.00336773f, -0.07565442f, -0.04928924f, -0.02627668f, -0.05777518f, 0.00280224f, -0.04449624f, 
    0.01916952f, -0.00124720f, -0.06681781f, 0.05577810f, -0.03814814f, -0.01645827f, -0.08066159f, 0.01072426f, 
    0.02431232f, -0.04933656f, 0.04591054f, -0.02786057f, 0.00651919f, 0.03672250f, 0.03068084f, 0.05871952f, 
    0.05182293f, 0.02832329f, 0.03569466f, 0.02804189f, -0.04426813f, 0.03844161f, 0.04713989f, -0.06112926f, 
    0.02941920f, -0.00178639f, 0.05111801f, 0.03946804f, -0.01210109f, -0.06430623f, -0.03256337f, -0.06962718f, 
    0.01648815f, -0.01669502f, 0.02398599f, 0.04728711f, -0.08277126f, 0.02272801f, -0.05408762f, -0.05477478f, 
    0.03093644f, 0.03655893f, 0.02885832f, -0.00408304f, 0.00826076f, 0.03940052f, -0.07150558f, 0.01373297f, 
    0.00719810f, 0.02742856f, 0.04457943f, -0.04070396f, 0.01221732f, 0.01491742f, -0.01503139f, 0.00247200f, 
    0.04421887f, 0.00336052f, -0.05039884f, -0.06418896f, -0.03522471f, -0.06652248f, 0.03874741f, 0.05215719f, 
    -0.03488531f, 0.01654014f, -0.08099436f, -0.04139120f, -0.07456893f, 0.00431688f, -0.01321380f, 0.02812511f, 
    -0.04717479f, 0.03857983f, -0.07907455f, 0.03014356f, -0.04323888f, -0.05920567f, -0.04709683f, 0.04875336f, 
    0.04423606f, -0.06111611f, 0.00214455f, 0.04365340f, -0.01163355f, 0.05793863f, 0.04976746f, 0.04689702f, 
    -0.03744489f, -0.03455844f, -0.05388981f, -0.05259361f, -0.08037750f, 0.02266018f, -0.02659286f, 0.02515119f, 
    0.04416930f, -0.02423855f, -0.03583074f, -0.03456951f, -0.02328995f, -0.02828271f, -0.05583397f, -0.04480244f, 
    -0.01998070f, 0.04448309f, -0.02557275f, 0.00425362f, -0.06134589f, -0.07105853f, -0.07219665f, -0.05599260f, 
    -0.06342662f, -0.08318605f, -0.05398521f, -0.03889461f, -0.02293187f, -0.00020972f, 0.01794071f, 0.03079363f, 
    0.01582973f, -0.07988074f, -0.00301756f, 0.05296937f, 0.04206014f, -0.03081437f, -0.05348323f, 0.03678901f, 
    0.01024528f, 0.03500112f, -0.00394611f, 0.05066586f, 0.00887307f, 0.06079566f, -0.02037822f, 0.04001052f, 
    0.05266349f, -0.05034782f, -0.02488472f, -0.04751315f, 0.05008631f, 0.05110574f, 0.04618274f, -0.06684703f, 
    -0.04989976f, 0.01811054f, -0.13535009f, -0.09873573f, 0.01356689f, -0.03750712f, 0.13082278f, -0.00475528f, 
    0.05248666f, 0.11753358f, 0.08225495f, 0.24576402f, 0.23031192f, 0.32549629f, 0.18938693f, 0.20141257f, 
    -0.14082837f, -0.08556934f, 0.19991930f, 0.21680205f, -0.06293447f, -0.23173255f, -0.02451941f, 0.14171584f, 
    -0.24540497f, -0.05759571f, -0.02725212f, 0.05303508f, 0.18331797f, 0.18391357f, -0.08542656f, 0.03917610f, 
    -0.08407973f, 0.14159481f, 0.05865640f, 0.04011592f, 0.04452399f, -0.11163258f, 0.09526338f, 0.03696941f, 
    -0.02960386f, -0.05917733f, -0.04361623f, -0.14466019f, -0.05075923f, 0.09810860f, -0.10565808f, 0.05845337f, 
    -0.12312849f, 0.03821090f, 0.23855571f, 0.12534656f, -0.05494559f, -0.07701396f, 0.13031852f, -0.01285210f, 
    -0.05931599f, 0.10016104f, -0.01006073f, -0.00050377f, -0.00628088f, -0.12760206f, -0.01455015f, -0.05059951f, 
    0.08792847f, 0.10402341f, -0.04679220f, -0.14246725f, -0.14080586f, 0.07041746f, 0.09242032f, -0.12416258f, 
    0.46791825f, 0.36626664f, 0.05218197f, 0.13498442f, -0.06565139f, 0.05915637f, -0.13172637f, -0.04044651f, 
    0.04232338f, 0.13938044f, 0.27141690f, 0.27567509f, 0.11711825f, 0.48527604f, 0.02085206f, -0.07692514f, 
    0.25442114f, 0.08387434f, -0.05025693f, -0.20834480f, -0.01292101f, -0.13453005f, 0.15690340f, -0.01643415f, 
    -0.04744121f, 0.20601626f, -0.01776376f, 0.06675143f, 0.01399982f, -0.08321795f, 0.05277471f, 0.07829149f, 
    -0.17620569f, 0.16009158f, 0.08866645f, -0.01121893f, -0.35534996f, 0.05655047f, 0.24389340f, -0.02494402f, 
    0.04646191f, -0.22128150f, 0.04719482f, 0.00440422f, -0.19479784f, 0.00054978f, 0.14565352f, 0.05062184f, 
    -0.57510597f, 0.21443605f, -0.02912151f, -0.06892197f, 0.10258961f, -0.09540869f, -0.09821384f, 0.05290149f, 
    0.03095040f, 0.03825103f, -0.10299148f, -0.28385627f, -0.49281344f, -0.01911025f, 0.02404050f, 0.23359254f, 
    0.02110320f, 0.00501934f, -0.01332887f, 0.04460160f, 0.08299759f, 0.00177687f, -0.08729597f, -0.08427651f, 
    -0.14135781f, -0.07940893f, -0.04607887f, 0.04860151f, -0.10195225f, -0.20774217f, -0.26500985f, 0.06520484f, 
    -0.06764235f, -0.06227925f, 0.03494551f, -0.12298435f, 0.45484141f, -0.20290199f, 0.28053427f, -0.10116906f, 
    -0.07177798f, 0.28641251f, -0.01302500f, -0.09563594f, 0.14096797f, -0.08851611f, -0.00147707f, -0.14498483f, 
    0.15461439f, -0.06730323f, 0.39670992f, 0.29454136f, -0.09509822f, 0.16373123f, -0.01146137f, 0.01565286f, 
    -0.09255344f, 0.00860396f, -0.03714202f, 0.05103648f, 0.17564973f, 0.33749047f, -0.19962862f, -0.03792774f, 
    0.03302451f, 0.07793470f, 0.05483626f, 0.08921375f, 0.01714010f, 0.02499166f, -0.06736452f, -0.09539807f, 
    0.05438909f, 0.07354132f, 0.38229054f, 0.04193443f, 0.05598147f, -0.09800591f, 0.01644180f, 0.08084641f, 
    -0.07846192f, -0.09246901f, 0.10748817f, -0.12765169f, 0.40060556f, 0.25688648f, 0.23882195f, 0.02231809f, 
    -0.01986146f, -0.01100654f, 0.06021910f, 0.01990184f, 0.01690441f, 0.12110170f, -0.02203714f, 0.10474490f, 
    0.02676162f, -0.03494558f, -0.21493280f, 0.06209712f, -0.07595629f, 0.06947847f, -0.20581558f, 0.05230324f, 
    0.10436578f, 0.03249692f, -0.02929845f, 0.00798215f, -0.28401229f, -0.24545622f, 0.19479181f, 0.07321008f, 
    -0.15580747f, -0.06863931f, -0.00632336f, -0.10983305f, -0.09176181f, -0.25870696f, 0.04586368f, -0.06281267f, 
    0.07765929f, -0.14770460f, 0.45328882f, 0.22968523f, 0.01104142f, 0.00381154f, 0.12213232f, -0.03653097f, 
    -0.05451322f, -0.00334409f, 0.03755156f, -0.04753860f, -0.14051700f, 0.34252319f, -0.17630623f, -0.03086281f, 
    -0.21376777f, 0.12058391f, -0.08868079f, 0.04282760f, 0.14682323f, -0.03686299f, -0.00561572f, -0.20589386f, 
    0.40798268f, -0.13044517f, -0.00681679f, 0.14623226f, 0.00498494f, -0.02506433f, -0.07499773f, -0.00140243f, 
    -0.08698274f, -0.00483582f, 0.08957723f, -0.10470125f, 0.27772754f, -0.12329962f, 0.10001311f, -0.29096028f, 
    -0.11060444f, -0.01295878f, 0.07291983f, -0.20884149f, 0.04672143f, -0.01676374f, -0.10469154f, 0.03198984f, 
    -0.11041576f, -0.24694209f, 0.06071828f, 0.23592377f, 0.04347511f, 0.22860478f, -0.09442884f, 0.05790092f, 
    -0.00237124f, -0.08174802f, 0.11717343f, 0.03244251f, -0.02340113f, -0.08413279f, 0.08956287f, -0.03598770f, 
    0.05782630f, 0.03676241f, 0.21527281f, -0.03066061f, -0.11270963f, -0.06235054f, -0.16229245f, 0.14229228f, 
    -0.23682232f, -0.18171282f, -0.03301745f, -0.29528859f, -0.11269286f, -0.09451453f, -0.02345398f, 0.05338253f, 
    0.14268264f, 0.01784818f, -0.07751001f, -0.05055282f, -0.07240296f, -0.16148606f, 0.25381160f, -0.05380755f, 
    -0.02891193f, 0.01633904f, 0.04294028f, -0.16741569f, 0.08663231f, -0.00378021f, -0.02152133f, 0.13180706f, 
    -0.16724530f, 0.09875166f, 0.09213731f, 0.08976401f, -0.11574383f, -0.00389662f, -0.05955983f, -0.01408330f, 
    -0.01493769f, 0.07752596f, 0.05778257f, -0.05030216f, -0.13728507f, -0.09471359f, -0.10694251f, -0.15784974f, 
    -0.10599378f, 0.10264497f, 0.10486295f, 0.20432593f, 0.12754877f, 0.23337442f, 0.00848488f, -0.13882284f, 
    0.16505505f, -0.10372595f, 0.21591440f, 0.24243206f, 0.16595201f, -0.00267037f, -0.19267437f, 0.25046465f, 
    0.09229170f, 0.01490474f, 0.09997520f, 0.18409581f, 0.21994659f, 0.17063449f, 0.33597299f, 0.10893613f, 
    -0.00957601f, 0.03678802f, 0.11506204f, -0.03548345f, 0.03129598f, 0.01810182f, 0.08924653f, 0.07145076f, 
    0.06136989f, 0.06893013f, -0.03344185f, 0.01417809f, 0.01249370f, 0.02527662f, 0.11350518f, 0.06661548f, 
    0.02245905f, 0.15791687f, 0.09476162f, 0.02066722f, -0.17430635f, 0.06640532f, -0.15482734f, -0.13568708f, 
    0.08650659f, 0.08822881f, 0.01261403f, -0.14916320f, 0.02229020f, 0.00211659f, -0.05587136f, -0.03130965f, 
    0.06770054f, -0.16288520f, 0.07394945f, -0.00997358f, 0.16748500f, -0.08373560f, 0.15635096f, -0.13784696f, 
    0.02344602f, 0.03636721f, 0.03162682f, 0.00127919f, -0.05748370f, -0.10211965f, -0.06609646f, -0.23466311f, 
    0.13276513f, 0.03313550f, 0.08270774f, 0.08647341f, 0.06700771f, 0.05115075f, 0.14302810f, 0.11830204f, 
    0.06539423f, 0.30685645f, -0.02283015f, 0.22632141f, 0.06157402f, 0.07331125f, -0.07892559f, -0.10351328f, 
    0.01608619f, 0.06951815f, -0.03131941f, 0.03046920f, -0.13767071f, -0.33255675f, 0.03176346f, -0.32664016f, 
    0.20690848f, -0.04443781f, -0.07637289f, -0.09662259f, -0.06616858f, -0.02833362f, -0.14253946f, -0.08324416f, 
    -0.15557960f, 0.00658724f, -0.11965510f, -0.14296791f, -0.11856452f, -0.14349569f, 0.13551801f, 0.10514133f, 
    -0.18330298f, 0.07822303f, -0.05171382f, -0.05385516f, -0.08841764f, -0.30091590f, -0.03581627f, 0.06001300f, 
    0.01748396f, 0.05649571f, -0.08551627f, 0.19586690f, 0.10472669f, 0.08304288f, -0.00477180f, 0.11200158f, 
    0.02739032f, 0.07222015f, 0.19082916f, 0.26130491f, 0.09656424f, -0.12275692f, -0.00962284f, 0.13255113f, 
    0.10218900f, 0.08585560f, 0.21126732f, -0.03156729f, -0.14299934f, 0.03383170f, -0.05097239f, -0.11303036f, 
    0.04931020f, 0.15092742f, -0.08558297f, 0.00253574f, 0.04112887f, -0.07510867f, -0.00296629f, -0.08763462f, 
    0.42386195f, 0.06019370f, -0.14478174f, 0.17340447f, 0.02791153f, -0.05846129f, 0.13794255f, 0.05428289f, 
    0.03073025f, -0.04869200f, 0.19657663f, -0.02814222f, 0.04359605f, -0.00187180f, -0.15718538f, 0.15033495f, 
    -0.10271823f, 0.06162876f, -0.13033709f, 0.09863562f, 0.01389951f, 0.03156105f, 0.02361648f, 0.09074363f, 
    0.32112643f, 0.23238592f, 0.17866845f, 0.10798849f, 0.09427333f, -0.02257206f, 0.04325109f, -0.01369052f, 
    0.09176706f, -0.00826916f, -0.04597138f, 0.00312631f, 0.00762284f, -0.19043735f, 0.14735332f, -0.19197851f, 
    -0.00573393f, -0.03941168f, 0.00296049f, -0.11259888f, -0.07195757f, -0.00676115f, -0.09307798f, 0.03555868f, 
    0.05465685f, -0.06097587f, 0.10924884f, -0.07168649f, 0.11552789f, 0.09896629f, 0.07058040f, 0.07521804f, 
    0.10035168f, -0.07311709f, 0.18328945f, -0.09570769f, 0.35016841f, -0.00667793f, 0.18551385f, -0.01195501f, 
    -0.17117620f, -0.04645697f, 0.01012486f, 0.13125242f, 0.06499516f, 0.09154726f, 0.06843662f, -0.10591174f, 
    0.00697774f, -0.15926957f, -0.33001509f, 0.05182697f, -0.10186782f, 0.10204350f, 0.05416156f, -0.14426337f, 
    -0.02024960f, 0.08515994f, 0.02461622f, -0.00674670f, -0.29918027f, 0.01208618f, -0.07455735f, 0.02018244f, 
    0.05601746f, -0.12196480f, -0.19642793f, 0.05590010f, 0.05643869f, -0.18868977f, 0.04444975f, -0.11153029f, 
    0.18761221f, 0.10875443f, 0.19155534f, -0.08252151f, 0.14691955f, -0.16216119f, 0.06807347f, -0.07713162f, 
    -0.12865147f, 0.12236939f, 0.03225994f, -0.01449719f, 0.45580241f, 0.12962408f, -0.11162224f, 0.03562523f, 
    0.08654848f, 0.08813474f, 0.04014275f, -0.03546610f, 0.00543201f, 0.19476110f, -0.02102350f, -0.01992177f, 
    -0.01203356f, 0.07806895f, -0.21581021f, -0.12205975f, -0.05924299f, -0.04523036f, -0.12575217f, 0.03179600f, 
    0.14364606f, -0.00227202f, 0.03158141f, -0.13507064f, 0.37693197f, -0.35839793f, 0.07774595f, -0.03115490f, 
    0.16933393f, 0.02051521f, -0.05999446f, -0.15692675f, -0.06597099f, 0.00364164f, 0.02197216f, 0.13784063f, 
    0.19244505f, 0.05001745f, 0.28478578f, -0.02600977f, -0.10795279f, -0.15411848f, -0.00397009f, -0.07753135f, 
    -0.06767630f, 0.03279301f, -0.04927703f, 0.05252179f, -0.09436893f, 0.14536396f, 0.09852078f, 0.02380233f, 
    0.00421901f, 0.10102542f, -0.05779738f, 0.21859989f, 0.03638098f, 0.10486847f, 0.08703659f, 0.03642711f, 
    0.27442980f, 0.41809094f, 0.26064518f, -0.03392097f, 0.17477813f, -0.05911698f, 0.00034821f, 0.01329688f, 
    0.05370265f, 0.12617011f, -0.08173394f, -0.10310529f, -0.05934779f, 0.00404589f, 0.11532916f, 0.11021688f, 
    -0.03696318f, 0.09000664f, -0.21289606f, 0.05897211f, 0.08650646f, -0.07158844f, 0.06445200f, 0.01995573f, 
    0.16097039f, 0.11948218f, 0.01725231f, 0.29466453f, -0.00622441f, -0.00432048f, -0.09486353f, -0.14135721f, 
    -0.05020875f, 0.00479407f, 0.07138350f, -0.01774197f, -0.20679332f, -0.16463663f, -0.10425876f, -0.00380954f, 
    0.08365811f, -0.05207185f, -0.12737980f, 0.12210813f, -0.06122882f, -0.00947430f, 0.07538600f, -0.15910576f, 
    0.31274620f, -0.06717935f, -0.17138970f, 0.01026328f, 0.08523288f, -0.13654980f, 0.00467194f, 0.06844165f, 
    -0.00532220f, -0.11895836f, 0.01433301f, 0.02792786f, 0.37284771f, -0.08974696f, 0.02564896f, 0.18927014f, 
    0.04710113f, -0.13412774f, -0.01881808f, -0.25777307f, -0.03419754f, -0.22577895f, 0.04846682f, 0.09596924f, 
    0.03297217f, 0.08639351f, 0.12682837f, 0.24919173f, -0.15002517f, 0.08620322f, 0.19764690f, -0.09410899f, 
    0.03449816f, 0.05855668f, -0.20603144f, -0.21864143f, 0.01001226f, -0.14904910f, -0.33164164f, 0.15475085f, 
    -0.08943439f, -0.05975772f, -0.14218076f, -0.03334385f, -0.04449870f, -0.14675725f, -0.02414604f, -0.02926449f, 
    -0.10637347f, 0.22945412f, -0.14782164f, 0.42285445f, 0.15906225f, -0.00734386f, 0.04830426f, -0.16099100f, 
    0.02970628f, 0.10101447f, -0.03858368f, -0.03255646f, -0.06712753f, 0.14461669f, -0.07537320f, -0.48997346f, 
    0.08056953f, 0.03151311f, -0.02646467f, -0.04769355f, 0.05849960f, -0.04857660f, 0.04787971f, -0.09176407f, 
    0.16632642f, 0.36670056f, 0.21810855f, 0.02484169f, -0.11138477f, 0.08526426f, 0.18856172f, 0.00175086f, 
    -0.04064984f, -0.14115027f, 0.04865434f, -0.01893721f, -0.07587592f, 0.03190409f, -0.10347909f, -0.22547558f, 
    0.04140137f, 0.12891412f, 0.01721713f, -0.04236315f, -0.03038377f, 0.06055487f, 0.21035451f, -0.00848191f, 
    -0.23692033f, 0.01936753f, -0.20164225f, 0.18564248f, 0.07716390f, 0.08204755f, -0.05216175f, -0.03151202f, 
    -0.01274139f, 0.01924864f, -0.11707843f, -0.04755100f, -0.00267518f, 0.03058065f, 0.22758739f, -0.16123000f, 
    0.07760800f, 0.04772678f, -0.10021398f, -0.17167154f, 0.02276470f, -0.00933472f, 0.14561999f, 0.01923039f, 
    -0.28386411f, -0.20556101f, 0.00896320f, -0.20147550f, 0.00975790f, 0.09882424f, 0.08173702f, 0.16116229f, 
    -0.04241105f, 0.09499206f, -0.05892164f, 0.03908056f, 0.04211561f, 0.27408653f, -0.10293034f, 0.37387565f, 
    -0.05540160f, 0.06028533f, -0.16542616f, 0.12073757f, -0.00958376f, -0.04768704f, 0.13686211f, 0.09904887f, 
    0.08238470f, 0.24593218f, 0.15002431f, -0.10726576f, 0.00058094f, -0.16144040f, 0.03006244f, 0.18744092f, 
    0.11768918f, 0.02825244f, -0.05634362f, -0.00424477f, 0.01251232f, -0.03556675f, -0.10149597f, -0.18387675f, 
    0.00769301f, 0.02191972f, -0.11034919f, -0.07202712f, 0.17496315f, 0.07392693f, -0.13709810f, 0.02028796f, 
    0.27943730f, -0.00414409f, 0.10927074f, 0.08190899f, -0.13336690f, -0.07540631f, -0.08355170f, -0.03003569f, 
    -0.02747705f, -0.03037074f, -0.00402314f, 0.03289878f, -0.04343359f, -0.07078546f, -0.26814115f, 0.14834592f, 
    0.05352359f, -0.00543787f, 0.00137315f, -0.08080981f, -0.00200387f, -0.00172682f, -0.02498427f, -0.11736730f, 
    0.33138916f, 0.06262365f, 0.06896676f, 0.18200311f, 0.13278826f, -0.06221955f, 0.00116168f, -0.11352747f, 
    -0.09490487f, -0.02945665f, -0.00061842f, -0.01899054f, -0.25650376f, -0.05693665f, -0.13118459f, -0.01200933f, 
    -0.01417705f, 0.06917777f, 0.17154415f, -0.15352741f, -0.02080424f, -0.10436419f, 0.00942359f, 0.10207248f, 
    -0.54932058f, -0.34692374f, 0.01787840f, -0.39708883f, -0.13211395f, 0.12895741f, 0.04353467f, 0.14476164f, 
    0.01458277f, -0.00777338f, -0.04353357f, 0.02949680f, 0.07071184f, 0.05373817f, 0.03167480f, 0.68334883f, 
    0.19794142f, 0.00472778f, 0.00865574f, 0.01191740f, -0.07915113f, -0.02491166f, -0.05536099f, 0.08393236f, 
    0.02629643f, 0.03638404f, 0.04468153f, 0.02616104f, 0.05564969f, -0.00696267f, -0.01519875f, 0.04425591f, 
    0.05791700f, 0.05927034f, 0.02396984f, -0.01773011f, -0.05447501f, 0.04014610f, 0.02436794f, -0.06322890f, 
    0.04961013f, 0.02402419f, 0.00707862f, 0.04052228f, -0.03842421f, 0.03924883f, -0.02692198f, -0.00022323f, 
    0.04260098f, 0.04634112f, -0.06436647f, -0.05195201f, -0.05073113f, -0.00570107f, -0.00571199f, 0.03386710f, 
    0.03210992f, 0.02089491f, -0.00887280f, -0.01853401f, -0.00472432f, 0.01864427f, -0.01775871f, -0.02498113f, 
    0.04141753f, -0.03156655f, -0.07135650f, 0.04285049f, -0.08659451f, 0.03759570f, -0.08261018f, 0.02200393f, 
    -0.05039065f, -0.05920666f, -0.01840941f, -0.06564981f, -0.01542173f, -0.00984528f, 0.00144205f, -0.07660809f, 
    -0.07389012f, 0.02910879f, -0.04687764f, -0.00876695f, -0.08149395f, -0.01222913f, -0.02191365f, -0.00595045f, 
    -0.01267922f, -0.01039770f, -0.03918950f, 0.05928697f, -0.01361857f, -0.06243720f, -0.01526749f, -0.00674939f, 
    -0.01217482f, -0.06940870f, -0.04384834f, 0.05902954f, 0.05617982f, 0.05300957f, -0.02260773f, 0.01979399f, 
    0.03163143f, -0.07698064f, -0.01156604f, -0.03930623f, 0.00438447f, -0.02136597f, 0.03607271f, -0.03928914f, 
    0.00967923f, -0.06590878f, 0.02353741f, 0.03836036f, 0.01517337f, 0.02577579f, 0.02862957f, 0.05859774f, 
    -0.00417424f, -0.07102557f, 0.04614024f, 0.04116575f, -0.06697108f, -0.07988554f, -0.05931839f, 0.03662857f, 
    0.00939758f, -0.07828143f, -0.00580889f, -0.02855591f, -0.04824578f, 0.03179928f, -0.03570180f, -0.06429232f, 
    -0.02845068f, 0.00860231f, 0.03852071f, -0.04500291f, 0.03431776f, 0.00984467f, 0.02355851f, -0.07310724f, 
    -0.00175660f, -0.01407691f, -0.04760699f, -0.01335217f, 0.00360272f, 0.05277840f, -0.03136524f, 0.00907477f, 
    -0.01439727f, -0.08531645f, 0.03251352f, 0.01575580f, -0.02064902f, -0.05413019f, 0.02044881f, -0.02800336f, 
    0.02782858f, 0.00247177f, 0.06364045f, 0.05939535f, -0.04055158f, -0.07861343f, 0.03294181f, 0.00710697f, 
    -0.06431015f, -0.06159305f, -0.08200125f, -0.05785021f, -0.07619420f, 0.03315752f, -0.05075917f, 0.04676469f, 
    0.00196008f, -0.02002894f, 0.00634197f, 0.05828880f, -0.02305866f, 0.03534518f, 0.03763387f, -0.03341356f, 
    -0.06608875f, -0.07992009f, 0.02537630f, -0.04869082f, -0.04325307f, 0.02031252f, -0.03236670f, -0.03732457f, 
    -0.01980920f, -0.02303571f, -0.01730395f, -0.07557309f, 0.04221740f, 0.03089057f, -0.07358463f, 0.03803812f, 
    -0.05871585f, -0.01293142f, -0.07329627f, -0.04342216f, -0.07054481f, 0.02935625f, -0.08964817f, 0.00695822f, 
    -0.01078340f, -0.01016930f, 0.04959805f, -0.00876436f, -0.01258552f, -0.00691195f, -0.04502441f, -0.00253318f, 
    -0.28010091f, 0.06852445f, 0.01551514f, 0.12761630f, 0.08125330f, 0.08341757f, -0.17007850f, -0.02421934f, 
    -0.15134880f, -0.16078427f, -0.09449132f, -0.29873314f, 0.18140492f, 0.08920718f, 0.11633161f, 0.15565063f, 
    0.02014476f, -0.01995927f, -0.12236440f, 0.00132173f, 0.06793343f, 0.10267921f, 0.08310763f, -0.04303217f, 
    0.20513025f, 0.08155534f, -0.16488573f, -0.10892773f, -0.08837253f, 0.06116349f, -0.17057058f, 0.05369732f, 
    0.02625175f, 0.01581965f, -0.13232037f, -0.04770375f, 0.09693160f, 0.11170608f, 0.27493683f, 0.28641394f, 
    -0.03557689f, -0.09915799f, 0.00529928f, 0.07031184f, 0.06507583f, -0.25683764f, 0.00277852f, -0.19298369f, 
    -0.13701205f, -0.29607293f, 0.10808861f, 0.31599224f, -0.02629846f, 0.02545143f, 0.01766926f, -0.04036943f, 
    -0.08024155f, 0.05398995f, 0.15842174f, -0.02377504f, -0.04008243f, 0.02406799f, 0.23050468f, -0.04930122f, 
    -0.10987865f, -0.09768945f, -0.04672732f, 0.17232753f, 0.14154708f, 0.05731268f, 0.01629274f, 0.11291535f, 
    0.40282199f, -0.13053043f, 0.47622830f, 0.14362966f, 0.09712109f, 0.12273491f, 0.01241685f, 0.12193082f, 
    0.11835440f, -0.14129241f, -0.13901642f, -0.25117543f, 0.07436830f, 0.07384644f, 0.04503858f, -0.24904551f, 
    -0.10103878f, 0.00698298f, 0.05975905f, -0.03604210f, 0.07486593f, -0.02085346f, -0.19436432f, -0.00712806f, 
    0.14654413f, 0.10665961f, 0.12909967f, 0.07528692f, 0.11672975f, 0.12800731f, -0.04193987f, -0.04999426f, 
    0.03203165f, -0.21532458f, -0.20837618f, -0.05113810f, -0.06148959f, 0.00121440f, 0.29389265f, 0.01558473f, 
    0.04543381f, 0.12060327f, 0.02223332f, 0.10572559f, 0.13768837f, 0.20459785f, 0.06709726f, 0.28253832f, 
    -0.42179972f, 0.13431183f, 0.10826300f, -0.12585291f, 0.15422441f, -0.04679354f, -0.04998281f, 0.03280659f, 
    0.06732444f, -0.04775236f, -0.10511202f, 0.24826036f, -0.08880001f, 0.08940034f, 0.06153520f, -0.23545086f, 
    0.04600477f, -0.02043865f, -0.01638297f, 0.01585763f, -0.11544617f, -0.04577382f, 0.12322976f, 0.15454890f, 
    0.10620958f, -0.28189662f, 0.00885977f, -0.15855196f, 0.05949936f, 0.07889777f, 0.08064997f, 0.04207292f, 
    0.01077443f, 0.16109222f, -0.08953299f, -0.03542560f, -0.11010579f, -0.07892284f, -0.18279390f, 0.12170049f, 
    0.12332307f, -0.10384797f, -0.09804603f, -0.03130978f, 0.01037814f, 0.20397252f, 0.13134375f, 0.18435976f, 
    0.02323925f, 0.19165954f, 0.11034646f, 0.20117676f, -0.01986788f, 0.03769414f, -0.22788864f, 0.09186815f, 
    0.02893919f, -0.05640778f, 0.19645607f, 0.11972879f, -0.09685672f, -0.26409966f, 0.17716143f, 0.42360556f, 
    0.13797903f, -0.07747186f, -0.05925727f, -0.11563908f, 0.06285323f, 0.00185788f, 0.12052776f, 0.28063142f, 
    0.06331010f, 0.05084655f, -0.07482830f, 0.04116057f, 0.04394194f, 0.02683823f, 0.00569935f, 0.01629340f, 
    0.00368261f, 0.05402590f, -0.00963195f, -0.06360565f, -0.02171674f, 0.06158663f, 0.02406381f, -0.03955667f, 
    -0.06373351f, -0.00965352f, 0.00261004f, -0.04247478f, 0.04549065f, -0.06063723f, 0.01779881f, -0.07602969f, 
    -0.05004687f, 0.02883108f, -0.04549114f, 0.04026207f, -0.02630165f, 0.01714238f, 0.05675432f, 0.04263152f, 
    -0.03569797f, 0.03837649f, -0.04809556f, -0.03750742f, -0.01853164f, 0.02055468f, 0.01644450f, -0.01265559f, 
    -0.06917850f, -0.01290265f, -0.01078752f, -0.01491449f, -0.03081920f, -0.02091146f, -0.03623402f, -0.06082259f, 
    -0.03161711f, 0.06508783f, -0.06150672f, 0.01408986f, -0.05651148f, -0.06429540f, -0.00671642f, 0.00779372f, 
    0.00184884f, 0.04990534f, 0.05007519f, 0.00217225f, -0.03343505f, 0.02428676f, 0.03357107f, -0.00000578f, 
    -0.03806802f, -0.07097252f, 0.04084691f, 0.02467122f, 0.06648993f, -0.06478949f, -0.01751383f, -0.01775199f, 
    -0.04087404f, -0.02258742f, 0.02325851f, -0.03792295f, -0.03526100f, 0.05458352f, 0.03760175f, -0.03184494f, 
    0.02532344f, 0.03740351f, 0.03903930f, 0.02942454f, -0.04255835f, 0.04506794f, 0.03600844f, -0.06863919f, 
    0.03285655f, -0.06465339f, -0.03862472f, -0.03018413f, -0.05375698f, -0.04198566f, -0.07524031f, -0.07050408f, 
    -0.01533985f, -0.05848479f, 0.05983134f, 0.04657881f, -0.01740347f, 0.01405164f, -0.03204994f, -0.02255354f, 
    -0.03761156f, 0.03863603f, 0.00997437f, -0.04513185f, -0.04145755f, -0.00059313f, 0.02247947f, -0.04431219f, 
    0.02494297f, -0.02792887f, -0.04815693f, 0.01378614f, 0.01032093f, -0.00385852f, 0.00773705f, -0.02818735f, 
    0.02886403f, -0.01897276f, 0.00239288f, 0.04327727f, -0.01594274f, -0.02673446f, 0.06085301f, -0.02385474f, 
    -0.05828058f, -0.05078273f, -0.03631285f, 0.04937484f, -0.02029081f, -0.01328107f, -0.06079337f, -0.01891094f, 
    0.04277796f, -0.07690962f, -0.02766467f, 0.02054631f, -0.06473424f, 0.02765541f, -0.01668409f, -0.07133175f, 
    0.04035751f, 0.02031555f, -0.03754828f, 0.00275992f, -0.03142409f, -0.05828644f, -0.04135403f, -0.04119539f, 
    -0.02249375f, -0.00022840f, 0.03763748f, 0.03345681f, -0.01000175f, 0.00969388f, 0.01217914f, -0.02673126f, 
    -0.05844993f, -0.02939194f, 0.05959186f, 0.02994771f, 0.00737662f, 0.00000561f, -0.02613472f, 0.03408776f, 
    0.00772856f, 0.00057003f, -0.05315711f, -0.05036197f, -0.03160193f, -0.01791208f, 0.03870020f, -0.02111805f, 
    -0.07042615f, 0.03461882f, -0.01240377f, -0.02952427f, 0.03763471f, -0.04349476f, 0.06491801f, -0.07597363f, 
    -0.06986651f, 0.01468377f, -0.04237302f, -0.02789967f, -0.04733714f, -0.00440234f, -0.04988379f, 0.04662345f, 
    0.01778626f, 0.03679486f, 0.00940523f, 0.05109523f, -0.06989890f, 0.00049330f, 0.00387425f, 0.05664058f, 
    -0.06851500f, 0.02273989f, 0.00806207f, -0.01389944f, 0.03058828f, 0.03996901f, 0.05802510f, -0.01427499f, 
    -0.03623512f, 0.02410043f, 0.06220645f, -0.07561812f, -0.00093451f, -0.03102834f, -0.05657230f, -0.06610564f, 
    -0.00646567f, -0.04217366f, -0.04300378f, 0.01456590f, -0.05520387f, -0.00440239f, 0.05273217f, 0.01203341f, 
    0.05697628f, -0.01951102f, 0.04173566f, 0.02611217f, -0.05500457f, -0.07173485f, 0.04089592f, -0.07254092f, 
    0.03080212f, -0.05245610f, -0.05203216f, -0.05447606f, 0.03710976f, -0.07517136f, -0.00777354f, -0.07465112f, 
    0.00450350f, 0.06534097f, -0.01124818f, -0.03493183f, 0.03582269f, 0.04851794f, 0.05783839f, 0.00771571f, 
    0.00477617f, 0.00909961f, 0.05434350f, -0.05118974f, -0.02489446f, 0.06035702f, 0.05732558f, 0.05947340f, 
    0.04631404f, -0.02232372f, -0.06560088f, 0.05613833f, -0.00847039f, -0.04766246f, 0.03221113f, 0.02459964f, 
    0.04750526f, 0.01718895f, -0.00782095f, -0.05402779f, 0.00014662f, -0.06125822f, -0.03592433f, -0.05674852f, 
    -0.05949437f, -0.05457679f, -0.04414423f, 0.02533727f, 0.03855950f, -0.01821773f, 0.00121972f, -0.07363429f, 
    -0.05668005f, 0.03740070f, 0.02517239f, -0.04261491f, -0.03207023f, 0.01025270f, 0.00919751f, -0.02053299f, 
    -0.02041680f, 0.02133436f, -0.02637276f, -0.06131317f, -0.02821159f, -0.07494867f, 0.05483160f, -0.04526969f, 
    0.04387022f, 0.02761173f, -0.07128271f, -0.03298576f, -0.01053180f, 0.06233168f, 0.02499635f, -0.06727792f, 
    0.02250062f, 0.01981429f, -0.01213805f, -0.04272144f, -0.05759461f, 0.03079280f, 0.02163324f, 0.01927671f, 
    -0.05141410f, -0.03631296f, 0.01122362f, 0.03042143f, 0.04171385f, -0.06176716f, 0.03374753f, -0.00081018f, 
    -0.00636849f, -0.04857060f, 0.00955237f, -0.04929044f, -0.00235401f, 0.06265811f, -0.05878128f, 0.01438054f, 
    -0.06513833f, -0.03783423f, 0.05652690f, -0.03833066f, -0.04358248f, 0.00493814f, -0.07465118f, -0.05460092f, 
    0.01003852f, 0.05165252f, -0.01508068f, -0.07744348f, 0.03315323f, -0.00294344f, -0.05830662f, -0.00101360f, 
    0.01712603f, 0.02984853f, 0.02719253f, 0.03704153f, 0.03448861f, -0.01799940f, -0.05921872f, -0.06633123f, 
    -0.07215128f, -0.04479487f, -0.03917208f, 0.02197262f, -0.02484533f, -0.01451297f, 0.04407848f, -0.04190461f, 
    0.03210200f, 0.03356070f, 0.01860751f, -0.03842179f, -0.04251469f, -0.04617552f, -0.04182299f, 0.04866665f, 
    -0.01907263f, 0.01381022f, 0.05184474f, -0.01439827f, -0.05661584f, -0.05653355f, -0.02364549f, 0.02284625f, 
    -0.01190534f, -0.06784886f, -0.05322058f, -0.04756155f, 0.03074379f, -0.02724391f, 0.01316532f, -0.01353243f, 
    0.02014825f, 0.05951602f, -0.08643878f, -0.30608338f, 0.01091137f, -0.10977085f, 0.07464867f, 0.07778352f, 
    0.04578952f, 0.11301742f, 0.07507105f, 0.17993559f, -0.34791958f, -0.25724408f, -0.01378998f, 0.27089360f, 
    -0.27469474f, 0.01052151f, 0.08861128f, 0.09418809f, -0.06305686f, -0.23386401f, 0.00036508f, 0.19821358f, 
    -0.32678726f, -0.03363411f, 0.12056430f, 0.07583273f, 0.21769270f, -0.03437850f, 0.04613268f, -0.06169147f, 
    0.01290880f, 0.06168966f, 0.04562318f, 0.02772984f, 0.07272586f, 0.02153487f, -0.09955902f, -0.03466760f, 
    0.12803839f, -0.00688594f, 0.05082711f, -0.05225276f, 0.02142603f, 0.20297422f, -0.05708681f, 0.16182885f, 
    0.54447770f, 0.01567538f, -0.16770236f, -0.12771878f, -0.02905813f, 0.02520802f, -0.06348141f, 0.09232391f, 
    0.06097196f, 0.09686061f, -0.04887794f, -0.04095133f, 0.26480243f, -0.19601719f, 0.01359964f, 0.06083226f, 
    0.14427651f, -0.04226764f, 0.01721947f, 0.08604214f, -0.14088473f, -0.05899530f, 0.04876703f, -0.05448940f, 
    -0.06953130f, 0.36806077f, -0.20816097f, 0.15376058f, -0.01497316f, -0.01671985f, 0.00496237f, -0.04111444f, 
    -0.04978034f, 0.03254549f, 0.06987358f, 0.17146769f, -0.24475795f, 0.22680078f, -0.08091094f, -0.07842697f, 
    0.15653874f, -0.00801864f, -0.05200750f, 0.09902356f, -0.05993835f, 0.02888406f, 0.12590759f, 0.09402320f, 
    0.03224834f, 0.02108897f, -0.20314991f, 0.17766140f, 0.20250377f, 0.01958105f, 0.01443296f, -0.05548474f, 
    -0.14670703f, 0.14833543f, 0.09871643f, 0.05859403f, 0.06391373f, -0.23811781f, -0.20196450f, 0.11733241f, 
    -0.02736263f, -0.11728542f, 0.00943906f, 0.16433753f, -0.17044997f, -0.03869790f, 0.13134092f, -0.09004857f, 
    0.00195665f, 0.12492839f, -0.07299316f, 0.06474763f, 0.14136723f, 0.00044536f, -0.00206422f, 0.02565446f, 
    0.05564273f, 0.03861015f, 0.20442802f, -0.24427694f, -0.05217338f, 0.01110165f, -0.16139847f, -0.00886303f, 
    -0.00511561f, 0.08263320f, -0.03887071f, 0.06040624f, 0.07623785f, -0.03668109f, 0.07630087f, -0.10821730f, 
    0.05822025f, 0.07571057f, -0.07610837f, 0.03748490f, 0.11572015f, 0.03173693f, 0.01859348f, 0.11359102f, 
    -0.04229164f, -0.18617110f, 0.07279973f, -0.00467828f, 0.61803800f, 0.18560353f, 0.33303213f, -0.09757536f, 
    0.03577312f, 0.07696683f, -0.05312691f, -0.07606405f, 0.00269891f, -0.08732488f, -0.14502580f, -0.06239939f, 
    0.08370131f, 0.02342855f, -0.08811992f, 0.05153529f, -0.00543476f, -0.02373118f, 0.22959472f, -0.14494173f, 
    -0.01011127f, 0.11199404f, -0.04905568f, -0.02923531f, 0.13684636f, 0.39710477f, -0.02942102f, -0.39282593f, 
    0.10930604f, 0.14506286f, -0.06415536f, 0.08874711f, -0.04493019f, -0.06082033f, -0.13368405f, -0.19084570f, 
    0.13139683f, 0.16565937f, 0.02921918f, 0.03812965f, -0.02868790f, 0.02502025f, 0.07321461f, 0.10472243f, 
    -0.01330251f, 0.01146862f, -0.04768562f, -0.04403315f, -0.43095592f, -0.02361001f, 0.29426941f, 0.12704538f, 
    -0.12154923f, 0.04537710f, 0.11035433f, -0.19264205f, -0.07058853f, -0.08011456f, 0.03365073f, 0.07122696f, 
    0.34406567f, -0.17429115f, -0.04619522f, -0.31188685f, 0.13218215f, -0.17061752f, -0.10558391f, 0.03188447f, 
    -0.00991313f, -0.00841579f, -0.01479438f, -0.00265842f, -0.10439683f, -0.09532726f, -0.06018771f, 0.09738573f, 
    -0.01192619f, 0.01956353f, -0.02804375f, -0.05550197f, 0.02007993f, -0.11335441f, -0.00094971f, -0.06019334f, 
    0.59402412f, 0.16630073f, 0.08758638f, 0.35694677f, -0.08095909f, -0.01201234f, 0.05534581f, -0.10201738f, 
    -0.11271045f, -0.08150822f, -0.02111506f, -0.05080793f, 0.06089884f, -0.31571808f, -0.05137760f, -0.32260343f, 
    -0.07792100f, -0.02982781f, -0.03780454f, 0.05089609f, -0.09847277f, -0.06261724f, 0.00581964f, -0.21403256f, 
    0.33081537f, 0.02656731f, -0.04332522f, 0.13879345f, 0.03759332f, 0.06903931f, 0.09706195f, -0.09313198f, 
    -0.15996101f, -0.14724340f, -0.06916914f, -0.11711831f, 0.02474821f, 0.19311470f, -0.06301497f, -0.29487020f, 
    0.00131257f, 0.15191312f, -0.08520127f, -0.12323178f, 0.15867560f, 0.07971366f, -0.01746026f, 0.09037540f, 
    0.18879694f, -0.03562330f, 0.12228682f, 0.13571739f, 0.34880164f, 0.19500935f, 0.06142399f, 0.01426808f, 
    0.05094815f, -0.00443506f, -0.06214650f, 0.04701441f, -0.05814777f, -0.09586141f, -0.07889830f, -0.10896675f, 
    0.07251787f, 0.07245337f, -0.06668793f, 0.20211576f, -0.02620778f, 0.06197287f, -0.09135904f, -0.06090318f, 
    0.10556836f, -0.09914234f, 0.12773620f, -0.05659643f, 0.00635336f, 0.02899024f, -0.12545940f, 0.03040340f, 
    0.11071619f, -0.07258508f, 0.05699678f, 0.07576096f, 0.26492554f, -0.34310713f, -0.18616118f, -0.16557139f, 
    -0.05291662f, -0.02435118f, -0.11849461f, -0.01050551f, 0.09297013f, -0.04949957f, -0.01516795f, 0.07564404f, 
    0.56378734f, 0.16330455f, 0.17535579f, 0.00825363f, -0.08457564f, 0.05682086f, 0.08348540f, -0.02980806f, 
    -0.12198150f, 0.05454164f, -0.11264509f, -0.09826151f, 0.47030473f, 0.14289694f, -0.26147908f, -0.03296820f, 
    -0.19821069f, -0.07389866f, -0.02252507f, -0.06051862f, -0.08341651f, 0.02394353f, -0.02993031f, 0.02162994f, 
    -0.08080044f, -0.00542431f, 0.12611102f, 0.36423308f, 0.14066939f, -0.08428182f, 0.03402055f, 0.11618498f, 
    0.08282795f, 0.08688043f, 0.07240257f, -0.00265725f, 0.40408587f, 0.08694538f, 0.15807840f, 0.22001477f, 
    -0.08077051f, 0.06012946f, -0.02653299f, -0.04054061f, -0.09901679f, -0.01717153f, -0.15321976f, 0.10941937f, 
    -0.08721410f, -0.01687376f, -0.04974318f, 0.07099707f, 0.05160446f, 0.04199225f, 0.02485567f, 0.01559338f, 
    -0.01349912f, -0.00132677f, 0.19022687f, -0.05562611f, 0.43277749f, 0.45639405f, -0.00660602f, -0.00249873f, 
    0.01727446f, 0.01081907f, -0.00137183f, -0.02640653f, 0.11552620f, -0.00039153f, 0.04430225f, 0.00803073f, 
    0.07242814f, -0.47023308f, 0.05985014f, -0.03060920f, 0.14713617f, 0.02760087f, 0.06682894f, -0.11628900f, 
    0.00527344f, 0.18577582f, 0.08516111f, 0.05243469f, -0.18689720f, -0.15195480f, 0.14201017f, 0.01679252f, 
    -0.01479915f, 0.05759685f, 0.07311750f, -0.03518665f, -0.03286152f, -0.06958614f, 0.13876958f, 0.11956664f, 
    -0.28120357f, 0.17866053f, 0.22993657f, 0.36622891f, 0.04716362f, 0.09848445f, 0.11487765f, -0.02915316f, 
    0.00802925f, -0.06285981f, -0.05416068f, 0.05177922f, -0.35304055f, -0.27714595f, 0.00165219f, -0.30786857f, 
    0.16781557f, 0.11568014f, 0.01888653f, -0.16564433f, 0.04532648f, -0.05976271f, 0.07214417f, -0.14550117f, 
    0.27120665f, -0.06580718f, 0.01271624f, -0.05327971f, -0.08681482f, 0.00843662f, -0.02112713f, 0.07562490f, 
    -0.07731657f, 0.17551236f, 0.12005972f, 0.05541899f, 0.06999607f, -0.10160529f, 0.08296245f, -0.00283884f, 
    0.13689704f, -0.00536886f, -0.11236595f, -0.07644570f, 0.11594944f, 0.02403928f, 0.01735966f, 0.13805088f, 
    -0.23113966f, 0.00176212f, 0.00456657f, 0.17245431f, -0.14657612f, -0.25453925f, 0.06009081f, 0.00798861f, 
    0.00235293f, 0.07334237f, 0.13374627f, -0.12746115f, -0.36921382f, 0.40917525f, 0.22747701f, -0.23931275f, 
    0.02677936f, -0.08163761f, 0.03839467f, -0.06481486f, -0.00568062f, -0.10372250f, 0.06977209f, 0.10593919f, 
    -0.32650104f, 0.17602272f, -0.14066070f, 0.12698635f, 0.06096091f, -0.18759060f, 0.12772800f, 0.07194799f, 
    0.05492360f, -0.08173002f, -0.01323177f, -0.10091594f, -0.40699294f, 0.10336664f, -0.00017718f, 0.22435120f, 
    0.01114456f, 0.01173689f, -0.14903265f, 0.07823674f, -0.05102253f, 0.16096269f, -0.08450654f, 0.06796865f, 
    0.14760388f, -0.01952678f, 0.04519763f, 0.07398347f, 0.03728063f, 0.04318280f, -0.13695557f, 0.00081935f, 
    -0.00761040f, 0.05940840f, 0.00292807f, -0.11292677f, -0.15048762f, -0.42071426f, -0.02772978f, -0.04627192f, 
    -0.00979741f, 0.17124271f, 0.00025738f, 0.00173558f, 0.11470038f, 0.02609236f, -0.06626679f, 0.03525135f, 
    0.06380610f, 0.04677986f, 0.20902245f, 0.13148180f, -0.06997095f, 0.02676545f, -0.15666035f, 0.06201600f, 
    0.16204682f, -0.07319734f, 0.14892296f, 0.06485554f, 0.44877341f, -0.17787959f, 0.23495162f, 0.35571811f, 
    -0.16999160f, 0.06233113f, -0.01309623f, 0.14192331f, 0.07359209f, 0.04195622f, 0.08396306f, -0.07284832f, 
    0.01968248f, -0.00656086f, -0.03410019f, -0.03183765f, 0.05386195f, 0.05644784f, 0.04173785f, -0.00765033f, 
    -0.02697906f, -0.01817793f, 0.01601839f, 0.01227633f, 0.03665864f, -0.00521331f, 0.02871223f, -0.08275966f, 
    -0.06504214f, 0.03200818f, 0.00026856f, 0.01293201f, 0.00591051f, 0.03809647f, -0.00899657f, 0.01855760f, 
    0.00532203f, 0.00162746f, 0.04929567f, -0.02576198f, -0.01199475f, -0.04607984f, -0.06776299f, -0.04803745f, 
    -0.01105421f, 0.02674388f, -0.03116774f, -0.01887296f, 0.04680577f, -0.07134881f, -0.07832292f, 0.01134063f, 
    0.02443291f, 0.04678987f, -0.01646107f, -0.04415493f, -0.07468098f, 0.00799152f, -0.06568903f, -0.03238427f, 
    -0.01312469f, 0.02214804f, 0.02421208f, -0.05057894f, 0.04442019f, 0.00635830f, 0.00492397f, -0.05395632f, 
    -0.02140459f, 0.03401676f, -0.03269522f, -0.04576943f, -0.04899332f, 0.05712251f, -0.01998080f, -0.02739172f, 
    -0.07716830f, 0.00904356f, -0.03647847f, 0.01029556f, 0.05694131f, 0.03989693f, -0.05820389f, -0.00933208f, 
    0.00359372f, -0.03594198f, 0.04304934f, 0.01629331f, 0.02461588f, 0.00892138f, 0.02838123f, 0.05053599f, 
    0.00214101f, 0.01448751f, 0.01614765f, 0.00457613f, 0.01902234f, 0.02700511f, -0.05934955f, -0.03729538f, 
    -0.07917908f, -0.04558486f, -0.07359029f, 0.03021063f, 0.03966085f, -0.02995236f, 0.02050110f, -0.00835825f, 
    0.03349957f, 0.00502139f, 0.01644610f, -0.05442336f, -0.03804850f, -0.04083415f, 0.04654261f, 0.05469013f, 
    0.03364556f, 0.05405760f, 0.04806630f, -0.07079399f, -0.00694787f, 0.05864119f, 0.04131690f, -0.04424520f, 
    -0.02946175f, 0.01110148f, -0.06115511f, 0.04531038f, 0.03120799f, 0.01892220f, -0.07742256f, -0.06531501f, 
    -0.07082721f, 0.03042622f, 0.04569477f, 0.04475218f, 0.00166979f, -0.06782109f, -0.05813359f, -0.05684460f, 
    0.04623369f, 0.01024952f, 0.01540732f, -0.04789778f, -0.06398103f, -0.04825552f, -0.00096554f, -0.01826542f, 
    0.02800870f, -0.01014465f, -0.03780943f, 0.01662070f, -0.06769196f, -0.06827484f, -0.05848635f, -0.05230003f, 
    -0.06231451f, -0.00766778f, 0.00332968f, -0.06304469f, 0.05215912f, -0.05342555f, -0.07174856f, -0.08012409f, 
    0.02612690f, -0.01805221f, -0.07062034f, 0.05649109f, -0.07373682f, -0.04849934f, 0.01466528f, -0.01621314f, 
    0.02881428f, 0.01438490f, -0.06375252f, -0.00601609f, -0.01536892f, -0.07903349f, -0.02504218f, -0.01326097f, 
    0.03558468f, 0.05387889f, -0.07102157f, 0.06077136f, -0.01907139f, -0.07944528f, 0.02983396f, 0.05374902f, 
    0.05928583f, -0.01983150f, -0.05129652f, 0.05184361f, -0.06860272f, 0.03658463f, 0.02351379f, 0.05952627f, 
    0.01537869f, -0.03121242f, -0.07872843f, 0.00723177f, -0.05274738f, -0.01911865f, -0.04007300f, 0.02440069f, 
    0.10955835f, -0.01986917f, -0.23370636f, 0.01004372f, 0.06858896f, -0.01379287f, -0.07164180f, -0.07942480f, 
    -0.00246745f, 0.02027970f, -0.09670392f, -0.15083075f, -0.02356583f, 0.17695478f, 0.00839498f, 0.22065796f, 
    0.15832414f, -0.07106116f, -0.07901838f, 0.07693977f, 0.13022223f, 0.02755147f, 0.01749424f, -0.16466889f, 
    0.03481379f, 0.31429377f, -0.13521625f, 0.03800229f, -0.11702278f, -0.01544042f, 0.06701763f, 0.02746737f, 
    -0.06521904f, 0.00446174f, -0.04920173f, -0.11951039f, 0.44467777f, 0.07141113f, -0.06232816f, 0.04913944f, 
    0.04294221f, -0.02674318f, -0.00041695f, 0.00057533f, -0.06225542f, 0.05297774f, 0.01916786f, -0.12324802f, 
    -0.22599123f, -0.25655830f, -0.11852212f, 0.11971822f, 0.13524733f, -0.01119284f, -0.00703451f, 0.03709120f, 
    0.03463023f, 0.04835626f, 0.13115747f, -0.04694411f, -0.09760471f, 0.10057330f, 0.07055730f, 0.18125087f, 
    -0.16260946f, 0.00117546f, -0.03250370f, -0.02985777f, 0.17717603f, 0.02315020f, 0.10112957f, 0.07326309f, 
    0.04290051f, 0.16263698f, 0.28055570f, -0.00310081f, 0.01147839f, 0.11817902f, -0.08782031f, 0.16327661f, 
    0.07467315f, 0.03756820f, -0.04892232f, -0.02715141f, 0.12983054f, 0.07103207f, 0.09733190f, 0.00101200f, 
    -0.02074895f, 0.03013527f, 0.10620788f, 0.05502200f, -0.05210673f, 0.04866742f, -0.01840952f, -0.06864277f, 
    0.14659235f, 0.38877326f, 0.22648029f, 0.02080862f, -0.11376385f, -0.00745528f, 0.00662289f, -0.17054890f, 
    0.08829191f, -0.10917519f, -0.09078488f, -0.06859568f, -0.13846412f, 0.04315298f, 0.31786790f, -0.05446685f, 
    0.00609183f, 0.05807417f, -0.12962452f, -0.16512042f, 0.11921461f, 0.00226027f, 0.02439219f, 0.16409542f, 
    0.17751160f, 0.11843336f, 0.31839013f, -0.05185246f, 0.00234952f, 0.10058835f, 0.01877921f, -0.03367227f, 
    0.00650058f, 0.02516875f, -0.04843156f, 0.18889317f, 0.20784171f, 0.05304110f, -0.16676575f, -0.08353217f, 
    -0.02289452f, -0.03471255f, 0.04086414f, 0.02198618f, -0.11108547f, 0.02614865f, -0.04461856f, 0.05935988f, 
    0.07936162f, -0.22602895f, -0.17869708f, -0.22291748f, 0.10285712f, 0.00516616f, -0.03249960f, 0.03363971f, 
    0.02586303f, 0.11169042f, -0.00044028f, -0.00016408f, 0.16854595f, 0.01709110f, -0.27124056f, -0.01253073f, 
    0.11543052f, -0.00291500f, 0.00730250f, 0.00734157f, 0.06229337f, -0.02785207f, 0.00582327f, 0.06450824f, 
    -0.26639342f, -0.06007952f, -0.01668325f, -0.00812588f, -0.15224330f, -0.16591258f, -0.03177665f, -0.05967743f, 
    0.12255763f, -0.17699423f, -0.08642868f, 0.00019896f, -0.08254986f, -0.42099571f, -0.02944168f, 0.43385935f, 
    0.05006006f, 0.03730338f, 0.03352165f, -0.08021879f, 0.02910370f, 0.07278641f, 0.08726785f, 0.18420182f, 
    0.13727263f, -0.01509059f, 0.19086042f, 0.07711050f, 0.14389127f, -0.01531591f, -0.19132410f, 0.03679474f, 
    0.03858949f, -0.07416669f, -0.04791047f, -0.12608266f, -0.31896868f, -0.25088680f, 0.05160524f, 0.13170789f, 
    -0.10366618f, -0.14393984f, -0.24071795f, 0.05176686f, 0.13646796f, 0.15879528f, 0.08105440f, 0.11761529f, 
    -0.05124607f, -0.07326776f, -0.13288265f, -0.17002797f, 0.18590580f, 0.02397753f, -0.09496770f, -0.08208799f, 
    0.18244432f, 0.00078246f, -0.07388388f, -0.12149426f, -0.08536310f, 0.08306084f, 0.28587583f, 0.12985964f, 
    -0.02154246f, -0.20185058f, 0.10406110f, 0.14785133f, 0.05069904f, -0.21296471f, -0.06027737f, 0.05333254f, 
    0.00123404f, 0.00812240f, 0.10467420f, 0.08475792f, -0.03645559f, 0.01759314f, -0.06727964f, 0.12184735f, 
    -0.00017200f, 0.06249947f, 0.11592560f, -0.01081209f, 0.15869498f, 0.07039277f, 0.14901149f, 0.11241854f, 
    0.08016209f, 0.01033334f, 0.08998786f, 0.12376691f, 0.20922647f, 0.16667253f, -0.04109017f, 0.03738337f, 
    -0.18642369f, -0.23290761f, 0.26248810f, -0.02401881f, 0.08845107f, 0.04234274f, -0.00104834f, 0.03939294f, 
    0.11770716f, -0.20257458f, 0.03954476f, -0.16658379f, -0.22024870f, -0.13911746f, 0.08522917f, -0.09610471f, 
    0.03354517f, -0.05489997f, 0.10032989f, -0.03731770f, 0.00155738f, 0.03523345f, -0.21662186f, 0.04303633f, 
    -0.30034405f, -0.31424692f, -0.16986316f, -0.13983665f, 0.03726796f, 0.10226160f, -0.08988331f, -0.19385196f, 
    0.01011844f, -0.11745238f, -0.03361367f, -0.05177179f, -0.14687766f, -0.04271403f, -0.15159087f, 0.08686503f, 
    -0.02049628f, 0.07281701f, 0.13257369f, 0.12113574f, -0.04105259f, 0.09601552f, 0.14134687f, 0.10187811f, 
    -0.64580309f, 0.16755551f, -0.26648825f, -0.11814610f, 0.19966646f, 0.05002157f, 0.07684057f, 0.15303989f, 
    0.05725478f, -0.01412814f, 0.09417912f, 0.09408169f, -0.02908332f, 0.27810663f, 0.00198372f, -0.22520214f, 
    0.03166974f, -0.03849734f, 0.10318898f, 0.08327188f, 0.06360143f, 0.16334254f, 0.19713810f, 0.17549679f, 
    -0.02976475f, -0.10722485f, 0.17066076f, 0.11431288f, 0.07202095f, 0.28449175f, 0.08340409f, -0.03332034f, 
    0.17554817f, 0.14124466f, -0.04156767f, 0.15421543f, -0.03435785f, 0.13797051f, 0.14087874f, 0.16040380f, 
    0.09744410f, -0.16116071f, -0.06222193f, -0.05274701f, 0.00445248f, 0.26097333f, 0.01618238f, 0.05751419f, 
    0.21432197f, 0.13547042f, -0.11675902f, 0.01223998f, 0.05797752f, -0.16026559f, -0.10225739f, 0.13727732f, 
    0.07873322f, 0.00333442f, 0.36542562f, 0.06197256f, -0.11306639f, 0.04347917f, 0.15868227f, -0.18386708f, 
    -0.02463862f, -0.07600881f, 0.06133744f, 0.02213921f, 0.17312546f, 0.02116553f, 0.12631966f, 0.19649714f, 
    -0.41860738f, 0.12787442f, -0.19526698f, -0.14197539f, 0.28063336f, -0.01199407f, -0.02286706f, -0.02459371f, 
    -0.13406168f, -0.07546519f, 0.18366331f, -0.01810799f, 0.29285458f, -0.10146151f, -0.23277006f, 0.23559162f, 
    -0.05090963f, 0.03418457f, -0.20784959f, 0.21732716f, -0.09199276f, 0.01348840f, 0.19632831f, -0.03356951f, 
    -0.10912602f, 0.30448079f, 0.14130028f, 0.27966309f, -0.02050642f, 0.01111047f, -0.00665759f, 0.14016177f, 
    0.03042303f, -0.00005136f, -0.04950412f, 0.07634826f, -0.04319061f, -0.16449063f, -0.02107899f, -0.11449645f, 
    0.13746628f, -0.19875315f, 0.00048355f, 0.01459084f, 0.04486676f, 0.06659801f, 0.13386844f, 0.05971089f, 
    0.20268747f, -0.63425899f, -0.03961241f, 0.21741690f, 0.11109564f, 0.12944375f, -0.15407948f, 0.03941414f, 
    -0.01221235f, 0.13461463f, 0.08385855f, 0.24255583f, 0.06141391f, 0.53873640f, 0.21145144f, 0.11162429f, 
    -0.11218806f, 0.00194572f, -0.09121148f, 0.02412159f, 0.23029982f, -0.10057127f, 0.07369795f, 0.04383581f, 
    0.10601422f, 0.45389932f, -0.10641119f, 0.00194053f, -0.06568093f, 0.08272760f, -0.15285344f, 0.10147831f, 
    0.15500624f, 0.11946563f, 0.08580168f, 0.08601042f, -0.07899975f, 0.15621166f, -0.08613902f, -0.17471321f, 
    0.02379910f, -0.02602966f, 0.09196034f, 0.14215486f, -0.13303024f, -0.05054964f, 0.00641470f, 0.08839904f, 
    -0.16345234f, 0.37119114f, 0.08639508f, 0.37696955f, -0.01457900f, 0.16895671f, -0.02831776f, 0.07922411f, 
    -0.10079202f, 0.04674738f, -0.19320424f, 0.00529833f, -0.25758708f, -0.32855567f, 0.15215829f, 0.01498969f, 
    -0.06172548f, -0.14140484f, -0.00656598f, -0.02965312f, -0.10799307f, -0.01630559f, 0.13039467f, 0.21635392f, 
    -0.18683581f, 0.12012488f, 0.08228867f, -0.00375900f, 0.06848773f, -0.13151194f, -0.03384566f, -0.22058004f, 
    -0.01784397f, 0.05873153f, -0.07631189f, -0.06202698f, -0.28658089f, -0.13349244f, 0.04548119f, -0.05175603f, 
    -0.07694114f, 0.06225473f, 0.01851827f, 0.06122451f, 0.06964100f, -0.00698196f, -0.03980954f, -0.08145860f, 
    0.28910747f, 0.02482171f, -0.20152517f, -0.12789716f, 0.20274830f, 0.01712354f, 0.03348892f, -0.08617511f, 
    -0.06377287f, -0.08998697f, 0.00399136f, 0.03797492f, 0.54363406f, -0.38984719f, 0.01188361f, -0.42349672f, 
    0.19225894f, 0.07304689f, 0.03673986f, -0.06078670f, 0.06340577f, 0.03544087f, -0.05720934f, -0.06116998f, 
    -0.11780832f, -0.07273783f, 0.07430971f, -0.06458684f, 0.00266701f, 0.05108481f, -0.04130351f, -0.09045788f, 
    0.19814211f, 0.03169224f, 0.02093290f, 0.05169145f, 0.08768301f, 0.12019967f, -0.01618776f, 0.07014199f, 
    0.26613456f, 0.10892958f, -0.07042894f, -0.11393960f, -0.07111042f, -0.09925466f, 0.03275453f, -0.04178033f, 
    0.40615946f, 0.05584818f, 0.19532791f, 0.46199155f, -0.03264257f, 0.00147872f, -0.06575295f, 0.05094828f, 
    0.09700891f, -0.10170886f, -0.06751313f, -0.11623447f, -0.60672307f, -0.18935628f, 0.09486984f, -0.23733504f, 
    -0.07536934f, 0.00687264f, 0.00341909f, -0.10071816f, 0.07516959f, 0.17417325f, 0.07496604f, 0.00213174f, 
    0.43252957f, 0.18945985f, -0.08596444f, -0.24043721f, 0.04126073f, -0.13774578f, -0.08774996f, -0.02229385f, 
    0.12422977f, 0.06415945f, -0.02808834f, -0.01655924f, 0.03936189f, 0.03151432f, -0.20807604f, -0.07859731f, 
    0.02984779f, -0.00915838f, 0.09812928f, 0.08697558f, 0.03891591f, -0.09104734f, 0.00689480f, 0.00489818f, 
    0.48909032f, 0.03785206f, -0.27001369f, -0.22964194f, -0.11396549f, 0.10552353f, 0.01956279f, 0.04942095f, 
    0.01338735f, -0.01436284f, 0.09875743f, -0.00681714f, 0.45302197f, 0.14111893f, 0.02820877f, -0.10166114f, 
    -0.12320095f, 0.00954406f, -0.01154558f, 0.03040836f, 0.00577574f, 0.16467656f, -0.09523630f, 0.09218158f, 
    -0.12227444f, -0.52492678f, -0.11537871f, 0.03214965f, 0.00673614f, 0.04279670f, 0.06762439f, -0.04104842f, 
    -0.03875411f, -0.24354941f, -0.11591554f, -0.23122540f, -0.09324778f, 0.08299471f, 0.10146363f, 0.14997610f, 
    -0.13604020f, 0.10937721f, -0.11051755f, 0.01636995f, 0.07132012f, 0.19818345f, -0.01647419f, -0.04592721f, 
    0.14741565f, -0.16945349f, -0.00723266f, -0.42753756f, 0.24853948f, 0.12115438f, -0.00629245f, 0.13569327f, 
    0.17343353f, -0.06748582f, -0.05624212f, 0.09329917f, 0.09939192f, -0.11654235f, -0.14820492f, 0.12173755f, 
    -0.00847303f, 0.21420226f, -0.01854058f, 0.10400826f, 0.13094972f, 0.15676764f, -0.16711113f, -0.09519850f, 
    0.11278562f, -0.00429488f, -0.03757726f, 0.03312115f, 0.07194821f, 0.07751054f, -0.08515223f, 0.02183680f, 
    -0.07466315f, -0.03716737f, 0.07948539f, 0.24654256f, 0.18703566f, -0.24235377f, -0.12247436f, -0.18386059f, 
    0.04010801f, -0.16074213f, -0.00284816f, 0.00033657f, 0.13831186f, 0.04266562f, 0.06456953f, 0.11370261f, 
    0.29917133f, 0.18995941f, 0.22889090f, 0.17685573f, 0.08933092f, 0.23508817f, 0.15342772f, -0.03871678f, 
    0.04199649f, 0.10004495f, -0.15516287f, 0.15178563f, 0.12501068f, 0.33865422f, -0.14377216f, 0.32623750f, 
    0.03201351f, -0.17089792f, 0.04185445f, -0.00182397f, -0.04668999f, 0.12348904f, 0.07698062f, 0.11046370f, 
    -0.19491915f, -0.08703847f, -0.06099074f, 0.00476024f, 0.00565462f, -0.04451109f, 0.08047488f, 0.06868716f, 
    -0.02012718f, 0.06585915f, 0.06989334f, -0.08921883f, -0.09511504f, 0.15149648f, -0.00124090f, 0.16944185f, 
    -0.02008952f, 0.03537509f, 0.05249184f, -0.03953598f, 0.04686991f, 0.02661010f, 0.02428842f, 0.07906836f, 
    -0.33541870f, 0.15421540f, -0.04138991f, 0.11293962f, 0.07961453f, 0.12373468f, -0.09171346f, 0.00314814f, 
    -0.03145318f, 0.03404196f, -0.11015844f, -0.13587926f, -0.13476734f, -0.10987438f, -0.00742972f, -0.34734187f, 
    -0.05651467f, 0.06374358f, 0.13769273f, -0.10543073f, 0.08718911f, 0.12969755f, 0.12937959f, -0.09045262f, 
    0.08515609f, -0.28911549f, 0.19973567f, -0.23579542f, -0.00028888f, -0.03043489f, 0.06256451f, -0.04048176f, 
    0.00961023f, 0.00278814f, -0.01425585f, 0.04045570f, -0.23496538f, 0.23209909f, 0.24403067f, 0.11948054f, 
    -0.06079811f, 0.15278928f, -0.02592779f, 0.20538245f, 0.24144787f, -0.09910441f, 0.08832357f, 0.01692696f, 
    -0.03063339f, 0.17126967f, -0.08921190f, -0.19718285f, -0.09476012f, 0.19703507f, 0.05287640f, 0.03709064f, 
    -0.15475017f, 0.04041313f, -0.01229594f, -0.02994681f, 0.07979201f, -0.21251684f, 0.56005859f, -0.28207594f, 
    0.10911522f, 0.05413937f, -0.03135788f, 0.06427579f, -0.06902298f, 0.03067259f, -0.02759970f, 0.02367837f, 
    -0.01591077f, -0.30308110f, 0.20412883f, 0.09332838f, 0.07272220f, 0.11174785f, 0.17759831f, 0.02328793f, 
    0.04058532f, 0.00698575f, -0.15686044f, -0.19106823f, 0.03987091f, 0.11915294f, -0.26927170f, 0.39650285f, 
    -0.13543218f, 0.03723831f, -0.13953125f, 0.12674993f, 0.18059006f, 0.11257499f, 0.04384030f, 0.15977097f, 
    0.05621525f, -0.44330433f, 0.06332440f, -0.07771577f, 0.05588108f, -0.11166430f, 0.05531249f, 0.20920685f, 
    0.11411285f, -0.03842600f, -0.16626374f, 0.10319620f, 0.16489086f, 0.01624418f, -0.27942577f, 0.11728349f, 
    0.02983489f, 0.04216036f, -0.00491816f, 0.25687405f, 0.03530775f, 0.18432212f, -0.15019622f, -0.07515873f, 
    -0.03249148f, -0.20949158f, -0.28293893f, 0.18455583f, 0.01232621f, 0.00403700f, -0.10778734f, 0.09082901f, 
    0.02666246f, -0.04822599f, 0.13955715f, 0.18159471f, -0.08064517f, -0.01554247f, -0.02859903f, -0.01460285f, 
    0.03270699f, -0.11384321f, -0.05477639f, 0.06316281f, 0.07938971f, -0.02798625f, 0.20285074f, 0.09298124f, 
    0.08929035f, 0.09103264f, 0.07994050f, 0.03557208f, 0.07164086f, 0.18107486f, 0.17592296f, -0.03206731f, 
    0.06765290f, 0.08554520f, 0.03841246f, 0.19690962f, -0.48144525f, 0.24709398f, 0.01529500f, 0.28696033f, 
    -0.12914528f, -0.08917798f, -0.14097396f, -0.13430175f, 0.02082242f, 0.04112683f, 0.02853682f, 0.12893513f, 
    0.02393972f, 0.22194731f, 0.01519297f, 0.08910701f, 0.10877845f, 0.21591875f, -0.04142430f, 0.08281941f, 
    0.04454730f, 0.09908395f, 0.16507891f, 0.01133288f, -0.17682955f, 0.06034752f, -0.16138253f, 0.03548269f, 
    0.03051183f, -0.03040682f, 0.03127786f, 0.07212443f, -0.02941164f, -0.11142588f, -0.00852743f, 0.06289154f, 
    -0.01076950f, 0.04334428f, -0.02706447f, 0.03173530f, 0.00161376f, 0.05752549f, -0.01813253f, 0.02655866f, 
    -0.05506499f, -0.03478725f, 0.04489141f, -0.04548835f, 0.03128504f, 0.01234156f, 0.00527716f, -0.03307164f, 
    0.05669740f, -0.07984728f, 0.01126719f, 0.05842849f, 0.03248536f, 0.02102900f, -0.05582290f, -0.06179643f, 
    -0.02292392f, -0.01953597f, 0.05073614f, -0.06303351f, -0.03364399f, -0.07005625f, -0.05569643f, 0.04010732f, 
    -0.03210987f, 0.03398719f, 0.01197817f, 0.03409946f, 0.01599761f, -0.01149385f, 0.03238218f, 0.05009011f, 
    0.01823298f, -0.01865756f, 0.03539592f, -0.07112499f, 0.02834987f, 0.01318334f, 0.03467090f, 0.01248438f, 
    -0.06541747f, -0.07098613f, -0.06970929f, 0.02199626f, -0.06429315f, 0.02472165f, 0.04984523f, 0.02088603f, 
    -0.06604588f, -0.02611421f, -0.03775142f, -0.03624460f, -0.07481354f, -0.01110305f, -0.02541872f, -0.00115531f, 
    0.03824570f, -0.00491521f, -0.02566773f, -0.00830446f, 0.00222669f, 0.04668223f, 0.05710826f, -0.00921009f, 
    0.05752145f, -0.00561463f, -0.04263609f, -0.03952403f, -0.01206755f, -0.07988418f, 0.03289112f, 0.05728853f, 
    -0.03857007f, 0.01980023f, 0.01701429f, 0.00240753f, -0.02348890f, -0.03277536f, -0.00668317f, -0.03798420f, 
    -0.06567522f, -0.07110147f, 0.03379834f, -0.00428022f, 0.05325538f, -0.01429289f, 0.01047735f, -0.00103487f, 
    0.00372296f, -0.05054305f, -0.01051914f, 0.02241010f, 0.00671277f, 0.00028828f, 0.05472673f, -0.06265405f, 
    -0.00772206f, -0.00544911f, -0.00764388f, -0.07607916f, -0.02174016f, 0.03035546f, -0.07192225f, -0.02812558f, 
    -0.07551853f, -0.02419542f, -0.00571066f, 0.01428598f, -0.06478938f, 0.01178582f, 0.02865491f, -0.05799306f, 
    0.02949806f, -0.01075908f, -0.08153428f, -0.03583356f, 0.06229360f, 0.00820361f, 0.01978122f, 0.03790953f, 
    0.03377372f, 0.05707517f, 0.04214186f, 0.04530537f, -0.00743433f, -0.06381722f, -0.00629455f, 0.02239512f, 
    0.05022287f, -0.04616439f, -0.05329622f, -0.07923886f, 0.06151652f, 0.02882116f, 0.00318922f, -0.01330394f, 
    -0.01190946f, 0.04632637f, -0.02837513f, -0.03149283f, -0.07485442f, -0.05697231f, -0.07153217f, -0.03593153f, 
    -0.07715613f, 0.01877872f, -0.07971114f, -0.01014023f, 0.02694071f, -0.02155841f, -0.06017213f, 0.00475362f, 
    -0.04500319f, -0.02893422f, -0.01483064f, -0.04843399f, 0.01851557f, -0.01048966f, -0.07980569f, 0.03676050f, 
    0.00971099f, 0.01724643f, -0.01074826f, -0.03091290f, -0.02013063f, -0.00645509f, -0.04917864f, 0.03965456f, 
    -0.06924680f, 0.00692489f, -0.00559568f, -0.00321207f, 0.00004860f, -0.07533133f, -0.00724661f, 0.03667483f, 
    0.00714963f, -0.02435581f, -0.05928976f, 0.00677139f, 0.01923321f, 0.04068887f, -0.06932717f, -0.00206147f, 
    0.04776444f, -0.02728199f, 0.01577546f, -0.06449789f, 0.05025955f, 0.00901103f, -0.07050562f, -0.02274336f, 
    0.06062022f, -0.07716963f, 0.06166334f, -0.02079706f, -0.02115282f, -0.04537248f, -0.04773454f, -0.02842750f, 
    -0.05069090f, -0.01214299f, 0.05744763f, -0.08512338f, -0.08090217f, -0.02728826f, 0.04093906f, -0.02750466f, 
    0.04055568f, 0.00143959f, 0.06575192f, -0.00719004f, 0.01156975f, 0.02473870f, 0.06106627f, 0.00995755f, 
    -0.02452668f, -0.00886979f, -0.03964771f, -0.05862744f, -0.06437664f, -0.01470148f, -0.05969552f, -0.05696164f, 
    -0.02310381f, -0.01714244f, 0.00578447f, -0.02154675f, 0.05531415f, 0.00372803f, -0.07594965f, -0.02212886f, 
    -0.00114841f, -0.04794511f, 0.04464408f, -0.08518224f, -0.04060386f, 0.03712140f, 0.01277748f, -0.05313053f, 
    -0.01330229f, 0.01179373f, 0.01687459f, 0.05522772f, -0.07190120f, 0.00675063f, -0.02272769f, -0.03329591f, 
    -0.02037147f, 0.04126521f, -0.04184819f, 0.04595547f, 0.01674452f, -0.03599504f, 0.04251091f, -0.02964256f, 
    0.01505148f, 0.03900227f, -0.03559001f, 0.04806861f, 0.01932436f, 0.00109369f, -0.02655582f, -0.04498429f, 
    -0.08335304f, 0.01357152f, 0.05033027f, -0.02167536f, -0.03021367f, -0.06312063f, -0.05939264f, -0.00249317f, 
    0.04416848f, 0.02970566f, -0.05551592f, 0.02987357f, -0.06234060f, 0.06357486f, -0.06132343f, 0.03494503f, 
    -0.04350485f, 0.05740712f, -0.06814396f, 0.05777619f, 0.03434613f, -0.07031754f, -0.04397357f, 0.04727899f, 
    0.00228997f, 0.01779182f, -0.06429429f, 0.06060967f, -0.06928980f, -0.01984857f, 0.04227102f, -0.02178473f, 
    0.04208433f, -0.02052411f, 0.01875874f, 0.01023206f, -0.06816877f, 0.02299523f, 0.00643234f, -0.05659344f, 
    -0.00156979f, -0.01670990f, -0.06067690f, 0.03593070f, 0.02070320f, 0.05405635f, -0.04628896f, -0.02519064f, 
    -0.03302443f, -0.03809157f, 0.03853906f, -0.06728893f, 0.01200038f, -0.00495662f, 0.03334016f, -0.07556234f, 
    -0.05458572f, -0.05736547f, 0.02879174f, 0.04389721f, -0.01317944f, 0.03360480f, -0.05719093f, -0.01558267f, 
    -0.00574617f, -0.06049364f, -0.05037183f, -0.02767355f, 0.00202932f, -0.02234298f, -0.02346475f, -0.08068944f, 
    -0.05608195f, 0.01953021f, -0.04126338f, -0.00129528f, -0.00360842f, -0.02532867f, -0.03543087f, 0.04649488f, 
    0.03559735f, 0.05880849f, 0.05902366f, -0.04751151f, -0.02113574f, -0.05263583f, -0.06656600f, -0.04971995f, 
    -0.00566885f, 0.02001072f, 0.00088463f, 0.00375780f, -0.02794541f, 0.03514442f, 0.04079458f, 0.05942592f, 
    0.00156384f, 0.04250772f, -0.03286494f, 0.04524213f, -0.07692722f, -0.05034427f, 0.05044089f, 0.01391268f, 
    0.02234003f, 0.05009529f, 0.03712477f, -0.03894726f, 0.01559025f, -0.06039834f, -0.04343846f, 0.01849950f, 
    -0.01539361f, 0.23649088f, -0.00089552f, -0.14619558f, -0.01870790f, -0.01036623f, -0.03703270f, -0.06411085f, 
    -0.11210639f, 0.02727242f, -0.15360351f, 0.00757116f, -0.22106950f, -0.04774227f, 0.13451509f, -0.08071240f, 
    0.05041375f, -0.08450086f, 0.16183178f, 0.07454267f, -0.13757980f, -0.04772660f, 0.02281991f, -0.03158869f, 
    -0.25740820f, 0.32929265f, -0.03903154f, 0.09459064f, -0.08111613f, -0.05275695f, 0.04200688f, 0.11870495f, 
    0.01172563f, -0.04100881f, 0.01661713f, -0.03558436f, -0.04339930f, 0.16013376f, 0.23604339f, 0.10257170f, 
    -0.09242465f, -0.03758113f, 0.01215113f, -0.00168308f, 0.04473775f, 0.03801439f, 0.08377018f, 0.08863903f, 
    -0.07686974f, -0.19867311f, 0.12923896f, -0.20380218f, -0.08052955f, -0.02469205f, -0.06583905f, -0.05444489f, 
    -0.06560545f, 0.06828846f, 0.04663885f, 0.06431699f, -0.18414082f, 0.24617699f, 0.00163060f, 0.04163783f, 
    -0.08001167f, -0.07850984f, 0.08122744f, 0.05723469f, 0.08192328f, 0.06428204f, 0.00094507f, 0.00306118f, 
    -0.03593417f, -0.03214502f, 0.09562866f, 0.21904679f, 0.11009335f, 0.24596764f, 0.01609411f, -0.07185852f, 
    -0.04713626f, -0.00875172f, -0.07829875f, 0.13016380f, 0.23005970f, -0.03786778f, -0.35717663f, 0.09011798f, 
    -0.10042363f, 0.11762706f, 0.03570795f, 0.12660456f, 0.09628658f, -0.05977059f, 0.14430876f, 0.09562400f, 
    0.04267849f, -0.04152924f, 0.07412445f, 0.20940308f, 0.13325849f, 0.20479365f, 0.17087571f, 0.09400165f, 
    0.02996898f, -0.03317253f, -0.02716770f, 0.02347833f, 0.53526765f, -0.54986906f, -0.19163626f, 0.28607872f, 
    0.06133525f, -0.03277493f, -0.02288305f, 0.07522517f, 0.13617791f, 0.08971577f, -0.12267818f, -0.07533270f, 
    -0.04153279f, -0.11043669f, 0.18930489f, -0.09557346f, 0.05613998f, 0.20191832f, -0.20612541f, 0.30870432f, 
    0.06843043f, 0.14585504f, 0.02846947f, -0.08137376f, 0.34655309f, -0.25065717f, 0.07932805f, -0.16813044f, 
    -0.05765897f, 0.03171087f, -0.05609179f, 0.00040612f, 0.12901969f, 0.00064400f, 0.00271882f, 0.09591485f, 
    -0.35994211f, 0.05441942f, 0.02969187f, -0.11624435f, -0.05481855f, 0.05921091f, -0.02505491f, -0.05260112f, 
    0.03775433f, 0.09377018f, 0.10418206f, 0.20170678f, -0.32527509f, 0.29318738f, 0.07438719f, 0.13651694f, 
    -0.03056886f, 0.08763427f, -0.04328643f, -0.20448309f, -0.05197168f, 0.13782489f, 0.02006749f, -0.02409008f, 
    0.15820605f, -0.07643223f, 0.20209531f, -0.06281641f, 0.04808761f, 0.00028800f, -0.08301377f, -0.10669224f, 
    -0.04447727f, 0.05443060f, 0.04530132f, -0.05264103f, -0.51193446f, 0.47270516f, -0.01510953f, -0.47999844f, 
    0.17062271f, -0.01570344f, 0.09791765f, 0.06399444f, -0.08886389f, 0.01061891f, 0.09020202f, -0.00165724f, 
    -0.14791153f, -0.03139686f, -0.00172539f, -0.01771316f, -0.05316312f, 0.11265446f, 0.14131980f, -0.14082170f, 
    0.07810396f, 0.11589529f, 0.06772847f, 0.26065192f, 0.47722816f, -0.03246875f, -0.20407806f, -0.13999501f, 
    0.08397090f, 0.18993828f, 0.00750614f, 0.16351061f, -0.12814285f, -0.02434906f, -0.07489309f, -0.06325854f, 
    -0.15761617f, 0.26956633f, 0.20466641f, 0.23270012f, -0.17861860f, 0.04928310f, 0.09672522f, 0.23573616f, 
    -0.07358149f, -0.03149641f, 0.06520934f, 0.15498175f, 0.05328228f, -0.04368512f, -0.19757165f, -0.15546097f, 
    0.09999932f, 0.10848380f, -0.12272746f, 0.12181602f, 0.09508140f, 0.21895677f, 0.05594140f, 0.09943445f, 
    -0.00719952f, -0.27139083f, -0.17692307f, -0.24286225f, 0.16271703f, 0.05858089f, 0.06699006f, -0.09216764f, 
    0.07783528f, -0.04159141f, -0.17346102f, 0.13872699f, 0.23470522f, 0.28936133f, -0.04367553f, 0.25213647f, 
    0.03192624f, 0.09985696f, 0.02657581f, 0.09759602f, -0.13466665f, 0.01618268f, 0.03811510f, 0.04013986f, 
    -0.18658800f, 0.15936585f, -0.13816226f, -0.00251290f, -0.06604448f, -0.01484078f, 0.02802972f, 0.06635755f, 
    0.01042655f, 0.17073396f, 0.08245604f, 0.31070846f, 0.10059534f, 0.00429322f, -0.04803846f, 0.26884091f, 
    -0.13086997f, 0.01538432f, 0.03131531f, 0.07074484f, -0.04727235f, 0.02398455f, 0.17456269f, 0.05754033f, 
    0.11733773f, -0.05935505f, -0.06926392f, 0.01678563f, -0.13697486f, 0.04451291f, -0.02030653f, 0.07716253f, 
    -0.16106868f, 0.08879296f, -0.00529084f, 0.16303991f, 0.36910090f, -0.03726024f, -0.06761244f, 0.14989325f, 
    0.04656294f, -0.04759534f, -0.01309772f, -0.06503111f, -0.02440434f, -0.04481732f, -0.07127595f, -0.05074131f, 
    0.65059608f, -0.25438136f, 0.09274801f, 0.10468252f, -0.19463463f, 0.04710996f, 0.00081162f, -0.15879519f, 
    -0.10754838f, 0.13070084f, -0.02505607f, -0.08728516f, -0.00019885f, -0.02433005f, 0.25495937f, 0.18737155f, 
    0.06884336f, 0.17891832f, 0.02080129f, -0.08347656f, 0.07611485f, -0.04670362f, -0.01180126f, -0.24302131f, 
    -0.15215282f, 0.08746028f, -0.16528136f, 0.00859639f, 0.00927509f, -0.04197017f, -0.01124192f, -0.14510889f, 
    -0.03498299f, -0.06005462f, 0.13830228f, 0.08455313f, 0.02039187f, 0.02995633f, 0.11903974f, 0.03284317f, 
    0.09306329f, 0.20285904f, 0.11592376f, 0.11213789f, -0.01480616f, -0.15612304f, 0.02714005f, -0.02914312f, 
    0.06901937f, 0.07600166f, -0.17435192f, -0.06381402f, 0.13402101f, 0.16076110f, 0.05755183f, -0.14539942f, 
    0.05888009f, 0.01792517f, -0.32894611f, -0.02996552f, -0.19111982f, 0.16056517f, -0.13434877f, -0.12994939f, 
    0.14854597f, 0.04217605f, -0.01846387f, -0.09231034f, -0.09711024f, -0.11744321f, -0.12458874f, -0.09980091f, 
    0.20343187f, -0.05677452f, 0.11058688f, -0.11597822f, -0.11117920f, 0.02426482f, 0.03647937f, 0.06625561f, 
    0.04979542f, 0.06037064f, 0.03720297f, 0.21154064f, 0.03821909f, -0.09599618f, 0.32335186f, 0.47481146f, 
    -0.20161875f, -0.01971770f, 0.28467742f, 0.03862752f, -0.10021754f, -0.11118015f, -0.05388616f, 0.10682140f, 
    0.07202148f, -0.09947241f, -0.31361440f, -0.04514521f, -0.03909617f, -0.02266486f, -0.11789852f, 0.04896533f, 
    -0.18078972f, -0.03421232f, -0.03026018f, -0.06194901f, -0.01026137f, 0.15930808f, 0.25215450f, 0.28313836f, 
    -0.02979623f, -0.01942384f, -0.03694762f, -0.05311569f, -0.01648910f, 0.04513592f, -0.19109443f, -0.14742018f, 
    0.24679136f, 0.05935352f, 0.12311010f, 0.15852651f, 0.11573008f, -0.06086090f, 0.25454831f, 0.03754894f, 
    0.00636081f, 0.03740091f, 0.03053608f, -0.09139998f, -0.04763492f, -0.08233635f, -0.13562414f, 0.18617555f, 
    -0.01749029f, -0.16219233f, 0.01647605f, 0.17274284f, 0.01743969f, -0.14258373f, 0.03099718f, 0.01076242f, 
    -0.03169656f, 0.27292937f, -0.26035887f, 0.20344862f, 0.08228779f, 0.14479709f, 0.05886471f, -0.05251017f, 
    0.10245643f, 0.10343159f, 0.11059564f, 0.14930442f, -0.17334518f, 0.43069121f, 0.16459885f, -0.19699872f, 
    0.08341748f, 0.13720499f, 0.17080830f, -0.15028208f, 0.00409221f, -0.08434112f, -0.02123147f, -0.17326403f, 
    -0.01358832f, -0.17413236f, -0.45552060f, -0.18718913f, -0.14602800f, 0.15408835f, 0.13833576f, -0.23450895f, 
    0.00552877f, -0.04386248f, -0.01354879f, 0.08416191f, -0.07612171f, 0.15758950f, 0.12204953f, 0.10130239f, 
    0.00590785f, -0.13750498f, 0.10165950f, 0.09442287f, -0.01141254f, 0.14245775f, 0.15942283f, -0.07482952f, 
    -0.12306161f, 0.05937768f, 0.10620060f, -0.14899558f, 0.10572220f, -0.03737075f, -0.05596019f, 0.06883080f, 
    -0.01090701f, -0.03724948f, -0.12900554f, -0.01959410f, 0.37865028f, 0.12955782f, -0.10830740f, 0.08724099f, 
    0.04564701f, 0.02624333f, 0.13760296f, -0.02148690f, -0.02118476f, -0.00126689f, -0.07792411f, 0.06035663f, 
    -0.00667964f, -0.09343062f, -0.04306576f, -0.15898958f, -0.09599487f, -0.01627767f, -0.02514561f, 0.11378974f, 
    -0.00787492f, -0.05816059f, 0.07429848f, -0.14384456f, 0.26235414f, 0.35385409f, -0.08186670f, -0.12020928f, 
    -0.01364034f, 0.14545722f, -0.15932624f, 0.24161947f, -0.01903386f, 0.08929657f, 0.08505794f, -0.14287211f, 
    -0.26922041f, -0.10528301f, -0.20590284f, 0.01353778f, -0.05676754f, -0.21249001f, -0.07588226f, 0.02576568f, 
    0.02031790f, 0.01983200f, 0.00636404f, 0.19140953f, 0.04830664f, -0.01538261f, 0.09210221f, -0.00079374f, 
    0.20733681f, 0.02996597f, 0.08208793f, -0.07054643f, -0.07104273f, 0.07686115f, -0.05104651f, 0.07617003f, 
    -0.01933008f, -0.04507492f, 0.03210119f, -0.00285340f, -0.05840509f, -0.00995612f, 0.01451524f, -0.05216084f, 
    0.03784428f, 0.03951311f, -0.06102434f, -0.07576494f, 0.02872336f, 0.04229852f, -0.05909184f, -0.05271594f, 
    0.05512463f, -0.06669091f, -0.06387831f, -0.07190811f, -0.04749550f, -0.07405750f, 0.05872767f, 0.05066656f, 
    -0.07119969f, 0.04619330f, 0.03715036f, -0.04632949f, -0.02106864f, -0.03739193f, -0.03382031f, 0.02656728f, 
    -0.02712428f, -0.02181258f, -0.04322307f, -0.04700235f, -0.04232175f, 0.02176824f, -0.00897344f, 0.04409645f, 
    -0.00989413f, -0.04490534f, -0.00014170f, 0.05357547f, -0.01510056f, 0.02166332f, -0.03055425f, 0.00300907f, 
    -0.04296927f, 0.03459823f, 0.02776255f, -0.07124826f, -0.01537689f, -0.03997267f, 0.04181852f, 0.02857347f, 
    0.03381249f, -0.00136442f, -0.01830818f, 0.00546287f, 0.03378443f, 0.02155098f, 0.04150089f, -0.01596989f, 
    0.04981435f, -0.03989986f, -0.03610820f, -0.00541151f, -0.07712066f, -0.08148972f, -0.00003594f, -0.01823735f, 
    0.06142304f, 0.05273802f, 0.01719326f, -0.01156598f, -0.01343835f, -0.03528406f, 0.01480532f, 0.04765388f, 
    0.02340562f, 0.04158494f, -0.05510949f, -0.02239209f, 0.02200701f, -0.04649821f, 0.01947767f, 0.05239014f, 
    -0.06610490f, 0.01181441f, 0.05619560f, -0.04252152f, -0.02276462f, 0.05494944f, -0.00975550f, -0.00546805f, 
    -0.00487843f, 0.01940068f, -0.06944102f, -0.03735976f, 0.00670430f, 0.03473033f, 0.02473515f, -0.02062710f, 
    0.00433225f, 0.01259073f, -0.02065927f, -0.07713541f, -0.00764476f, -0.06903314f, -0.03834689f, -0.01937073f, 
    0.01170972f, -0.04850565f, 0.00243908f, 0.03440291f, -0.06318549f, 0.06252925f, 0.02447141f, 0.03345311f, 
    0.04727605f, -0.04422854f, -0.05961364f, 0.04359764f, -0.04836388f, -0.07899698f, 0.03889680f, 0.03346965f, 
    0.02250723f, 0.05044494f, -0.07677362f, -0.06859722f, -0.01669972f, 0.04000722f, -0.02634499f, -0.07738744f, 
    -0.08290783f, -0.01635936f, -0.06963493f, -0.03315000f, -0.07338727f, -0.06545361f, -0.00639366f, 0.05556833f, 
    0.03228224f, 0.01577737f, 0.02787094f, 0.05398527f, -0.08252856f, 0.00454647f, 0.03681144f, 0.01244471f, 
    -0.05592057f, 0.05259845f, -0.03338183f, -0.03229375f, 0.00959898f, -0.05314020f, 0.05147332f, 0.02674066f, 
    -0.04641954f, -0.00607885f, -0.01865307f, -0.03293307f, 0.05496924f, 0.02552708f, -0.06833889f, -0.02869047f, 
    0.02675607f, -0.04753916f, -0.01160017f, -0.06218237f, -0.02233463f, -0.07236291f, 0.04627971f, -0.07357200f, 
    -0.01964857f, 0.02695611f, 0.04805476f, -0.07831191f, -0.00310791f, 0.01947027f, 0.03575140f, 0.03765608f, 
    -0.00586948f, -0.04160964f, 0.02312928f, -0.03216093f, 0.02663969f, -0.06826167f, 0.02057132f, -0.07871122f, 
    0.43094519f, -0.21421766f, -0.00417376f, -0.15554862f, -0.02409200f, -0.04229438f, -0.00498001f, -0.00158856f, 
    0.06934784f, -0.04537145f, 0.03389512f, 0.18157758f, 0.08048799f, 0.11494698f, 0.20805946f, 0.35254079f, 
    0.02960180f, -0.12891406f, -0.04735008f, 0.22998258f, 0.03441488f, -0.17019717f, -0.00556635f, 0.18063352f, 
    -0.26514283f, -0.03527781f, -0.24787669f, 0.05338153f, 0.03963125f, 0.14050607f, -0.00274412f, -0.05930017f, 
    0.09468701f, 0.15436010f, 0.01064846f, 0.00535881f, 0.31669828f, 0.02526708f, 0.11603381f, 0.17029177f, 
    0.02128374f, 0.00220901f, 0.11501563f, -0.19017655f, -0.14647849f, 0.05303960f, -0.04100081f, 0.14184134f, 
    -0.17765316f, 0.14264685f, 0.31100711f, -0.11710444f, -0.02994389f, -0.09976460f, 0.07635894f, 0.06936879f, 
    0.14888085f, 0.04626467f, -0.02023143f, -0.13578317f, -0.06994740f, -0.19627567f, -0.12978941f, 0.24979118f, 
    0.11599766f, 0.10052291f, 0.07003625f, -0.00197080f, -0.07676153f, 0.02340999f, 0.11440451f, 0.10061359f, 
    0.11433294f, 0.22720157f, 0.05039382f, 0.11516972f, 0.03461619f, 0.15283662f, -0.10573648f, 0.01476122f, 
    0.16440907f, 0.04504499f, 0.25535366f, 0.20939557f, -0.09507641f, 0.08431121f, 0.32785282f, -0.09294437f, 
    0.38849148f, -0.04548154f, 0.06603420f, -0.11691746f, -0.08751679f, 0.01598457f, 0.00917173f, -0.05409750f, 
    -0.03532886f, 0.13390736f, -0.29560858f, -0.27516073f, -0.25830382f, -0.12810786f, 0.02297766f, -0.35095680f, 
    -0.11052537f, 0.01468127f, 0.21103191f, -0.13817097f, -0.18719743f, 0.21125989f, 0.37101173f, 0.13472298f, 
    -0.07839605f, -0.17790262f, 0.05989027f, -0.10530344f, -0.07186582f, 0.01166700f, 0.24325246f, 0.00188734f, 
    -0.40285948f, 0.37172908f, 0.07319895f, -0.10397629f, 0.10787027f, -0.02993872f, 0.15879433f, 0.10833963f, 
    0.09408612f, 0.08268893f, -0.05905597f, -0.09416551f, -0.15899745f, 0.38754651f, -0.05245174f, 0.13141806f, 
    0.03144739f, 0.03528000f, 0.08971022f, 0.09051038f, 0.07590881f, 0.22794065f, -0.01168371f, -0.01739382f, 
    -0.34459290f, -0.17199634f, -0.12325729f, -0.05122681f, 0.02227486f, -0.04046950f, -0.05816568f, 0.04459798f, 
    0.06114199f, -0.04152222f, 0.01842537f, -0.06278922f, 0.29052028f, 0.07947448f, 0.11943460f, 0.11297905f, 
    0.22106403f, 0.15466771f, -0.03504757f, -0.05965271f, 0.11046716f, -0.02423905f, -0.01996378f, 0.02080208f, 
    -0.00467600f, -0.14847185f, -0.06296655f, 0.07778259f, -0.18106133f, -0.16588661f, 0.08043654f, -0.08689784f, 
    -0.00022167f, -0.06282979f, -0.05514565f, 0.05802986f, 0.01276719f, -0.04013455f, -0.04017041f, -0.18672416f, 
    -0.05989230f, 0.03848379f, -0.00910370f, 0.03724010f, -0.01422650f, -0.00641767f, 0.03249752f, 0.01206648f, 
    -0.05939864f, -0.05163036f, -0.04000679f, 0.06898120f, 0.05815122f, -0.02824768f, -0.04113813f, -0.04982145f, 
    0.01885282f, -0.05216416f, -0.00636423f, 0.01698406f, -0.04566301f, -0.02950059f, -0.02352194f, -0.03035452f, 
    0.00996608f, 0.04940031f, -0.04311223f, -0.05801466f, -0.00043694f, 0.06312812f, -0.02775259f, 0.06409629f, 
    0.05599811f, -0.06622456f, -0.07372190f, 0.01325193f, 0.05978214f, 0.04138530f, -0.05988561f, -0.06254932f, 
    0.01740095f, -0.04335517f, 0.04553907f, -0.03078935f, 0.03534312f, -0.07238119f, 0.04506270f, 0.04646944f, 
    -0.04960584f, -0.01217125f, -0.00133796f, -0.00351004f, -0.06447242f, -0.01071472f, -0.06427536f, 0.06298386f, 
    -0.00541116f, 0.01506610f, -0.07470608f, 0.00155023f, -0.05430526f, 0.05707012f, 0.02153433f, -0.03915909f, 
    0.04905669f, -0.02780943f, 0.06134001f, 0.05048790f, 0.01731612f, -0.06482589f, 0.06551003f, -0.04971628f, 
    -0.04381621f, 0.06429809f, 0.01649093f, -0.02504482f, -0.05064243f, -0.04679118f, -0.04343076f, -0.01181384f, 
    0.03153358f, 0.06544388f, 0.04497336f, 0.02635444f, -0.03508866f, -0.03524007f, 0.06120981f, -0.05314353f, 
    -0.07252304f, 0.00443093f, -0.02704179f, -0.04718201f, -0.00750903f, -0.00114040f, -0.03028252f, -0.06220146f, 
    0.02012729f, -0.04410835f, 0.02680175f, -0.02339517f, 0.00537386f, 0.02651734f, 0.04971433f, 0.04635428f, 
    -0.03419583f, 0.03901352f, 0.02579907f, 0.02361433f, -0.04556414f, 0.03427264f, -0.04560639f, 0.04923651f, 
    -0.03787751f, -0.00675495f, -0.02150107f, -0.04705370f, 0.05996748f, 0.05794091f, -0.00883802f, 0.05183011f, 
    -0.01250361f, -0.03157648f, -0.00242878f, -0.06714027f, 0.02334769f, 0.01276690f, -0.04426203f, -0.03471533f, 
    -0.02378186f, -0.01487837f, -0.02853813f, -0.04234809f, -0.07306806f, 0.00056570f, -0.01180512f, -0.05263286f, 
    0.01601903f, -0.04482889f, -0.07283052f, -0.04781520f, -0.03744926f, -0.04953919f, -0.02041932f, 0.01042293f, 
    -0.00098153f, -0.01284691f, -0.06489326f, -0.03143712f, -0.07059620f, -0.05877484f, -0.07689271f, 0.00028653f, 
    0.01940411f, -0.00934336f, -0.03744384f, -0.04359050f, -0.00841511f, -0.02321511f, 0.06007258f, 0.04354401f, 
    -0.02120313f, 0.00081823f, -0.07081734f, -0.00227101f, -0.05746733f, -0.05375563f, -0.05497600f, -0.03170035f, 
    -0.07147015f, 0.01655219f, 0.06436726f, 0.02135257f, -0.03896968f, 0.05045609f, -0.01732396f, 0.04008823f, 
    -0.05449061f, -0.05592561f, -0.07155804f, -0.05832167f, -0.02578997f, -0.00060163f, -0.04697983f, -0.07445944f, 
    0.00218832f, -0.01342415f, -0.02131397f, 0.04254775f, -0.07404984f, 0.00701254f, -0.00255779f, -0.02578175f, 
    0.04117705f, 0.02797112f, -0.02582640f, -0.06170551f, -0.07727077f, -0.06539379f, 0.04441193f, 0.02736031f, 
    0.01551390f, 0.15418194f, 0.21590251f, 0.12178673f, 0.08227576f, -0.05400700f, -0.14415671f, -0.01264091f, 
    0.00377298f, -0.08442814f, -0.01535947f, -0.33109400f, -0.29942793f, -0.03086702f, 0.09214618f, 0.15151528f, 
    0.03043982f, 0.03500313f, -0.15024929f, -0.19784988f, 0.17487447f, 0.12127144f, 0.13921984f, 0.09574323f, 
    0.34756070f, -0.19246139f, -0.19339958f, -0.22176845f, 0.14288931f, -0.12766750f, -0.02039185f, -0.16530541f, 
    0.11060011f, -0.00698789f, -0.13455221f, -0.03861047f, -0.10006616f, -0.05219202f, 0.15768777f, 0.01698931f, 
    0.01100569f, -0.16740257f, 0.18688849f, 0.16700232f, 0.13366427f, -0.37383860f, 0.01183599f, -0.06360708f, 
    0.18723853f, 0.09900723f, 0.06319284f, 0.24738954f, -0.00731788f, 0.14046746f, -0.06117290f, 0.03804356f, 
    -0.03519367f, -0.01539942f, 0.17039190f, 0.11089878f, 0.01028872f, -0.09960251f, 0.13020106f, -0.16599692f, 
    0.03984607f, -0.04769331f, -0.14494710f, 0.06119550f, 0.10103852f, 0.03969501f, -0.07333528f, -0.04347477f, 
    0.01061894f, -0.17335983f, 0.10576345f, -0.02023115f, 0.10764014f, 0.00822420f, 0.06822643f, 0.02944968f, 
    0.10481424f, -0.08577602f, -0.07831085f, -0.31069714f, -0.08747143f, -0.19872648f, 0.07472016f, -0.30377916f, 
    -0.13565010f, -0.05640212f, -0.00356534f, -0.01544483f, 0.18398887f, 0.04224897f, -0.27260736f, -0.01998306f, 
    -0.15411587f, -0.22404556f, 0.06625656f, 0.02170383f, 0.21610287f, 0.19568956f, -0.04742883f, 0.01725284f, 
    0.10932516f, -0.19756691f, -0.13172001f, -0.07306194f, -0.29100832f, 0.00172861f, -0.00817792f, -0.20528366f, 
    0.09575340f, 0.15580611f, 0.08517030f, 0.10334974f, 0.00654983f, 0.03651280f, 0.05269537f, 0.16371468f, 
    -0.29788154f, 0.08359827f, -0.20991851f, 0.03399732f, 0.22780550f, -0.07802134f, 0.12224015f, 0.06435749f, 
    0.04299565f, -0.08553416f, 0.05564060f, 0.13542120f, -0.06460164f, -0.02491027f, -0.10668714f, -0.20990302f, 
    -0.04120217f, -0.13000448f, -0.07575246f, -0.04448100f, -0.03365413f, 0.09187832f, 0.19288646f, 0.18965405f, 
    0.39313471f, 0.12073503f, 0.14622444f, 0.01740329f, 0.12619919f, 0.11004032f, 0.11540598f, 0.03266688f, 
    0.02044216f, 0.16937473f, -0.03352990f, -0.04536030f, 0.14097364f, -0.01216408f, -0.16936189f, -0.05646507f, 
    -0.00765227f, -0.28320956f, -0.02480099f, 0.05077344f, -0.01036126f, 0.18309478f, -0.05125525f, 0.20174009f, 
    -0.06177572f, 0.06932323f, 0.03793161f, 0.03991572f, 0.06633890f, -0.12119033f, -0.11624926f, 0.19517273f, 
    0.09120801f, -0.10027082f, 0.30712217f, 0.17415178f, 0.20305541f, -0.20106763f, 0.31077853f, 0.15428045f, 
    -0.08863837f, -0.08865394f, -0.07878723f, -0.01709406f, 0.15196805f, -0.03956018f, 0.21052261f, 0.24744137f, 
    -0.03938475f, -0.02157256f, 0.06172778f, 0.04614255f, 0.05056901f, 0.02482461f, 0.02457568f, -0.07809927f, 
    0.03557783f, 0.01173961f, -0.03515918f, 0.06291986f, -0.07832570f, -0.08659341f, -0.04918733f, -0.05850741f, 
    0.03952192f, -0.04215197f, -0.01774444f, 0.02447092f, 0.03567126f, -0.07052512f, -0.01406265f, -0.00176985f, 
    -0.00946768f, -0.01164448f, 0.00075735f, -0.05437373f, -0.02680229f, -0.00062668f, -0.01000430f, 0.03441496f, 
    -0.03759136f, 0.04664229f, 0.03862323f, 0.01591537f, 0.04598375f, 0.03652688f, -0.05950461f, -0.06802474f, 
    0.05501472f, -0.06735752f, -0.01753605f, -0.00212924f, -0.04341633f, -0.03375569f, -0.07065138f, 0.03549806f, 
    -0.03931125f, 0.03553759f, 0.04733811f, 0.05050302f, -0.01796234f, -0.06109725f, -0.04719526f, -0.07583561f, 
    -0.01013104f, -0.05457946f, -0.06546264f, -0.00410863f, -0.07274856f, -0.04316466f, -0.03588112f, -0.03856002f, 
    0.01562913f, -0.03981506f, -0.04337675f, 0.03552504f, -0.08157514f, 0.06362785f, 0.05115001f, 0.05823572f, 
    0.00115500f, -0.01025036f, 0.01980313f, -0.04972461f, 0.04976068f, 0.05663446f, 0.04420309f, 0.00518951f, 
    -0.06509913f, -0.00317779f, -0.05600933f, 0.05379676f, 0.03043408f, -0.06596033f, -0.06346413f, -0.02189011f, 
    0.00523641f, 0.03337999f, -0.07609301f, 0.04241203f, 0.05919274f, 0.02450108f, 0.03095056f, -0.07167865f, 
    -0.00766408f, 0.01676794f, -0.00934360f, -0.03472331f, -0.01592382f, 0.04872456f, -0.05072895f, -0.04704030f, 
    -0.03150019f, 0.00426889f, -0.02787637f, -0.07669775f, 0.01064502f, -0.07638573f, 0.01236247f, -0.01417456f, 
    -0.02633659f, -0.07777748f, -0.04871669f, 0.01511994f, 0.06358577f, -0.02908969f, 0.01133377f, 0.03996378f, 
    0.04488051f, 0.05159827f, -0.06526616f, -0.07671309f, -0.05214213f, 0.01221038f, -0.05256767f, -0.00106181f, 
    0.06832634f, -0.02466776f, -0.00659221f, 0.06281793f, -0.04593750f, -0.02205907f, -0.04173319f, 0.00595504f, 
    -0.03626132f, -0.02875379f, 0.02587010f, -0.08054224f, -0.05517384f, -0.07459558f, -0.02831839f, 0.05795054f, 
    -0.08037063f, -0.07296272f, -0.05501747f, -0.02431941f, 0.04599803f, -0.02638109f, -0.01750300f, -0.07697128f, 
    0.01032204f, 0.04689742f, -0.00082611f, 0.03812991f, 0.02988680f, -0.03449089f, 0.05701363f, 0.00733283f, 
    -0.07164292f, 0.01437206f, -0.00354798f, -0.05786234f, -0.07335680f, -0.00861724f, -0.07628115f, 0.02957210f, 
    -0.01221930f, 0.00420235f, 0.01557083f, 0.03446244f, 0.05699008f, 0.05540802f, -0.06423954f, 0.02777001f, 
    -0.05037689f, 0.00832035f, 0.03662271f, 0.00750278f, 0.00279233f, 0.02639697f, 0.02227036f, 0.05474627f, 
    0.00466096f, 0.05320515f, -0.04377752f, -0.03142040f, -0.02040532f, -0.07449781f, 0.00408563f, 0.03742437f, 
    0.05099226f, -0.09385300f, -0.22008829f, -0.01491030f, -0.02576873f, -0.00692788f, 0.01317725f, 0.03902336f, 
    -0.00112938f, 0.14127208f, -0.10030373f, 0.06886683f, -0.11078876f, 0.03153972f, -0.11620560f, -0.12463477f, 
    0.13015375f, 0.01623707f, -0.05312748f, -0.14397535f, 0.05231741f, 0.06395324f, -0.07560857f, -0.03569611f, 
    0.13163500f, -0.14942332f, -0.02543991f, -0.18024629f, 0.02993793f, -0.04918340f, 0.22388299f, -0.00880698f, 
    -0.12642552f, -0.03608478f, 0.03243965f, -0.01048933f, 0.25764897f, 0.31511566f, -0.02518876f, -0.01882490f, 
    0.19806688f, 0.21631958f, -0.06499702f, 0.12394346f, 0.06374729f, 0.06394748f, -0.01461813f, 0.03793830f, 
    -0.12431888f, 0.45940983f, -0.25728026f, 0.10900591f, 0.09104963f, 0.00165729f, -0.01591059f, 0.04420217f, 
    0.10511957f, 0.00059305f, 0.05738599f, -0.03525961f, -0.14476101f, -0.32227877f, 0.14607832f, -0.10324419f, 
    0.18934402f, -0.07389086f, 0.02968938f, -0.16365531f, 0.00153366f, -0.01698877f, -0.06115856f, 0.16635886f, 
    -0.26533690f, 0.01247335f, 0.07953592f, -0.17435856f, -0.00471314f, 0.04463974f, 0.19571717f, 0.00483634f, 
    0.08216242f, 0.22531305f, -0.04124488f, -0.00129173f, -0.08774467f, -0.03796860f, -0.05627564f, 0.26181382f, 
    0.05981611f, -0.05006008f, 0.08648587f, 0.17047705f, -0.00227478f, 0.14886293f, -0.00059484f, 0.03275799f, 
    0.09618124f, 0.16806713f, 0.11945825f, -0.16260654f, -0.16328216f, -0.17931966f, 0.12828706f, -0.13521756f, 
    0.20557539f, 0.04964498f, 0.02696620f, 0.05777300f, 0.03149334f, 0.39091522f, 0.00628258f, -0.09710013f, 
    -0.03276951f, 0.11641788f, -0.14846535f, -0.10025415f, 0.06725036f, -0.03202993f, 0.11213122f, 0.06269055f, 
    0.36613479f, 0.09405457f, 0.04632033f, 0.13428120f, 0.06744467f, 0.03522329f, 0.08926762f, 0.07643353f, 
    -0.09373748f, 0.00093617f, -0.07359005f, 0.06518012f, 0.25437987f, 0.27715024f, -0.17067227f, 0.17918508f, 
    0.06275347f, 0.13298412f, 0.09580407f, 0.09201346f, -0.15302971f, 0.07435356f, 0.08101907f, 0.05235976f, 
    0.13203673f, -0.08665679f, -0.09903755f, -0.21252280f, 0.06776759f, -0.03115677f, 0.03722782f, -0.03151992f, 
    0.02751330f, 0.05963052f, 0.00863062f, 0.07083836f, -0.19460508f, 0.02333629f, -0.06530637f, 0.10737333f, 
    0.03364190f, 0.02329592f, 0.04310445f, 0.01379066f, -0.10141432f, -0.03944596f, -0.07427480f, 0.23564732f, 
    -0.36959162f, -0.03223082f, -0.24180129f, -0.19774519f, -0.13583982f, -0.02474661f, 0.06533358f, -0.06794477f, 
    -0.06383435f, 0.07543753f, -0.02623448f, -0.09382433f, 0.07684574f, -0.47751927f, -0.10959752f, 0.26479495f, 
    0.02497550f, -0.06577987f, -0.06104500f, -0.06335240f, 0.12112575f, 0.02414073f, -0.10972473f, 0.03526161f, 
    0.00256313f, 0.04572675f, -0.06217282f, -0.07671695f, 0.00191541f, -0.07317433f, -0.05471189f, 0.00159893f, 
    0.05475177f, -0.04615811f, -0.00182136f, 0.00005467f, 0.04392880f, -0.02968852f, 0.03975859f, 0.01047794f, 
    -0.04997578f, -0.05229430f, 0.04138170f, 0.04480103f, 0.06479026f, -0.00449076f, 0.02728574f, -0.08112090f, 
    -0.02781963f, 0.05283681f, -0.05229576f, -0.03626143f, 0.04944475f, -0.04958764f, -0.03450964f, 0.02448849f, 
    -0.00958393f, 0.00829321f, 0.02607209f, 0.05490264f, -0.04707178f, -0.00169566f, -0.04121279f, -0.00756987f, 
    -0.01927880f, 0.03284342f, -0.01928986f, 0.02818776f, -0.02002018f, -0.01639385f, -0.04615022f, -0.04363495f, 
    -0.01782951f, 0.07305720f, -0.06819034f, 0.01762900f, -0.00923758f, 0.04179661f, -0.04189071f, 0.00999932f, 
    0.02758555f, -0.07105319f, -0.01445878f, -0.05666696f, 0.02158902f, -0.07034291f, -0.01359384f, 0.02045968f, 
    -0.02472006f, 0.01173365f, -0.06116189f, -0.02433018f, 0.01222245f, -0.08114012f, -0.04462118f, 0.02081014f, 
    0.00093961f, -0.01950838f, -0.05051386f, 0.01995593f, -0.08122016f, -0.05907895f, 0.04420747f, -0.04898008f, 
    -0.01559131f, 0.06461010f, -0.03572259f, -0.01381735f, 0.02439856f, -0.02058576f, 0.02026809f, -0.01765383f, 
    0.03371135f, 0.01711463f, -0.00131096f, -0.03817694f, -0.02405983f, -0.01967336f, -0.06989513f, 0.02649142f, 
    -0.05822242f, 0.04966658f, -0.00253900f, -0.06230833f, 0.00874010f, -0.04415135f, -0.02882755f, -0.00541113f, 
    0.06066316f, 0.00527499f, -0.06750830f, 0.03474395f, -0.04492044f, -0.03714651f, 0.01122419f, -0.05108159f, 
    -0.04901515f, 0.02414545f, 0.03703045f, -0.02988818f, -0.06639685f, -0.06898366f, 0.01729685f, 0.04661698f, 
    0.06699033f, 0.00551763f, -0.00345437f, 0.05451747f, 0.00600556f, 0.05777841f, 0.00858301f, 0.03861666f, 
    0.00236134f, -0.01038850f, -0.04375034f, -0.06144951f, 0.02088067f, -0.06377336f, -0.07233869f, 0.05712613f, 
    0.03228173f, -0.00276755f, -0.07179136f, 0.01223559f, 0.04219834f, -0.00696027f, 0.04546789f, -0.04516529f, 
    -0.00219129f, -0.05349902f, 0.06132059f, -0.00025628f, 0.04910367f, 0.02624449f, -0.01124272f, -0.04035767f, 
    -0.06730095f, 0.01496171f, -0.04405557f, 0.04233710f, -0.01411955f, -0.04336302f, 0.01748782f, -0.05480110f, 
    -0.00063250f, 0.01579413f, 0.00354330f, -0.02334747f, -0.05386854f, -0.00850718f, 0.03048768f, 0.00796152f, 
    -0.02384661f, -0.00451100f, -0.05881938f, 0.04216494f, -0.00908356f, -0.01272317f, 0.05482899f, 0.02899755f, 
    -0.01869842f, -0.05279860f, -0.06071351f, 0.01176316f, 0.01147354f, -0.00534589f, -0.08772053f, -0.05523551f, 
    -0.02627045f, 0.03433714f, 0.00458158f, 0.03942866f, 0.04299186f, 0.02506282f, 0.05245932f, 0.04606408f, 
    -0.00785751f, -0.00181352f, -0.07407527f, 0.00818955f, -0.06786430f, 0.04162925f, -0.07067689f, 0.03247272f, 
    -0.00047648f, 0.03332267f, 0.03704612f, 0.03139535f, -0.08725131f, -0.03773805f, -0.06510773f, 0.02017806f, 
    -0.07209083f, 0.02873627f, 0.03982358f, -0.09195670f, -0.05359099f, -0.01338408f, -0.02140783f, 0.03463114f, 
    -0.00887893f, -0.02755992f, 0.02151823f, 0.04437549f, 0.00682281f, -0.07591514f, -0.03819700f, -0.09628734f, 
    0.03822487f, -0.05875230f, 0.07601772f, -0.07266159f, -0.01140322f, 0.01330494f, 0.00061925f, -0.02134599f, 
    0.00973087f, 0.01464897f, -0.08285283f, -0.02461853f, -0.02630885f, -0.02695993f, -0.06079915f, 0.03654364f, 
    0.00995394f, -0.01924556f, -0.02129168f, -0.06316709f, -0.07201163f, -0.04216688f, -0.01257127f, -0.03272760f, 
    0.00044166f, -0.04157135f, 0.00820559f, -0.04069344f, -0.05069388f, 0.02755663f, 0.03662982f, -0.00070850f, 
    -0.06569114f, 0.04269922f, -0.03345752f, -0.02192428f, -0.07604618f, 0.01247660f, -0.06984514f, -0.02709413f, 
    0.05665823f, 0.01097885f, 0.00353500f, 0.08179709f, 0.02212225f, -0.01437866f, 0.00186850f, -0.06209852f, 
    -0.02965085f, 0.00020332f, 0.02196717f, -0.05517552f, -0.04922776f, -0.02927502f, -0.06569193f, 0.02431403f, 
    -0.01246171f, -0.02190882f, 0.00747842f, -0.01279357f, -0.03555037f, -0.03096071f, -0.00966066f, 0.05479972f, 
    0.07592793f, 0.04055263f, -0.06268878f, 0.05447918f, -0.06817058f, -0.07819264f, -0.01529828f, -0.07605226f, 
    -0.04138174f, 0.03462324f, 0.02334675f, -0.07836418f, 0.02991453f, -0.02080666f, 0.06827641f, -0.05400173f, 
    0.01167542f, 0.02955348f, 0.02731112f, -0.00893678f, -0.00523693f, -0.06766248f, -0.04029264f, 0.06509943f, 
    0.02047433f, 0.02483614f, -0.03205777f, -0.02500884f, 0.00338325f, 0.06149390f, -0.03384363f, -0.01225333f, 
    -0.04770705f, 0.00134728f, 0.04828776f, -0.04955157f, -0.04421864f, 0.02810872f, 0.05978715f, -0.08735457f, 
    0.06461325f, -0.02194868f, -0.03521416f, -0.03578909f, 0.02136610f, -0.04655766f, 0.07755863f, 0.03539905f, 
    -0.04087912f, -0.07216612f, -0.07363881f, -0.05250935f, -0.03537701f, -0.01994530f, 0.04089809f, -0.02430714f, 
    -0.03845667f, -0.07559813f, -0.00302143f, -0.01137294f, 0.06609842f, 0.04921775f, 0.05013284f, -0.03380767f, 
    0.03470205f, 0.03131369f, 0.03569121f, 0.03694943f, -0.07022009f, -0.05516560f, -0.09142791f, -0.05913281f, 
    0.00801974f, 0.07104780f, -0.03631420f, 0.03192921f, -0.05476638f, -0.01714963f, -0.05441842f, 0.00489092f, 
    0.01546808f, 0.00291129f, -0.06974319f, -0.06153274f, 0.01946588f, 0.01084895f, -0.03554540f, -0.01471776f, 
    -0.04240277f, 0.01145763f, 0.00118004f, 0.02872483f, -0.07489472f, 0.02678724f, -0.00749928f, 0.01514222f, 
    0.47322825f, 0.14624646f, 0.08439155f, 0.21708041f, 0.05546258f, -0.20956059f, -0.02430597f, 0.12867191f, 
    -0.08328931f, -0.02734337f, 0.08493158f, 0.09563779f, -0.18616715f, 0.18706486f, 0.06503200f, -0.03079171f, 
    0.13978431f, -0.08856065f, -0.01712435f, -0.07360331f, -0.08327696f, -0.02672751f, -0.05465712f, -0.11274678f, 
    0.09112130f, 0.47237968f, -0.17265132f, -0.05114951f, -0.06985330f, 0.08935761f, 0.07038372f, -0.06151371f, 
    0.01996301f, -0.07369075f, 0.12078793f, -0.13183406f, -0.23491040f, -0.06700512f, -0.00467816f, -0.26058847f, 
    -0.08424057f, -0.12808882f, 0.10061940f, -0.10254180f, -0.23632015f, 0.04719764f, -0.04349968f, 0.10509926f, 
    -0.00740965f, 0.22959854f, 0.11942036f, 0.17718123f, 0.09377738f, -0.14551531f, -0.08295904f, -0.03778090f, 
    0.01969257f, 0.05660733f, 0.01928576f, -0.07348898f, -0.22356918f, 0.18175136f, -0.18853532f, -0.12834463f, 
    -0.00389256f, -0.05619378f, 0.04700614f, -0.22068477f, 0.10630471f, -0.00175523f, -0.04295310f, 0.00945275f, 
    -0.17015715f, -0.05148138f, -0.45431030f, -0.25582340f, 0.05866287f, 0.21866022f, 0.04639408f, 0.03968194f, 
    0.00117707f, 0.05401784f, 0.12305975f, 0.02164080f, 0.09138559f, -0.06251653f, 0.02669029f, 0.01752468f, 
    0.04729562f, 0.09113612f, 0.08155461f, 0.10356215f, 0.05821208f, 0.08745557f, -0.05868709f, -0.06579551f, 
    0.01719289f, 0.26746601f, 0.12500778f, 0.09140936f, 0.04036352f, 0.00453367f, 0.08199265f, 0.00224993f, 
    0.03305202f, -0.13555299f, 0.24212554f, 0.02134370f, -0.03666204f, -0.10842653f, 0.03636679f, -0.07135636f, 
    -0.08400964f, -0.01232198f, 0.04692992f, -0.10390186f, 0.03594405f, -0.14919057f, 0.07635953f, -0.04370351f, 
    0.15076993f, 0.16805871f, 0.25244072f, -0.05772775f, -0.02283752f, 0.08090582f, 0.17658930f, 0.20761728f, 
    -0.02428793f, -0.03502035f, 0.02934299f, -0.00801382f, 0.37067059f, -0.00417696f, -0.02790705f, 0.08441237f, 
    -0.10807137f, 0.02646451f, 0.08052520f, -0.07992746f, -0.07765020f, 0.10447297f, -0.12879106f, 0.18383820f, 
    0.15309530f, 0.06460217f, 0.12109038f, 0.17138849f, -0.00545114f, -0.05499627f, -0.09598311f, -0.01997460f, 
    -0.00073601f, 0.08957443f, -0.03296808f, 0.03885836f, -0.10826673f, -0.17178461f, 0.04410025f, -0.09289199f, 
    -0.02457935f, 0.12383159f, -0.08163881f, 0.02418176f, 0.03884599f, 0.13600156f, 0.00614973f, -0.00444415f, 
    -0.23785211f, -0.33769771f, 0.07270335f, -0.37138525f, -0.11020479f, -0.17828760f, 0.03872768f, 0.14642288f, 
    -0.12415195f, -0.13027516f, 0.12987034f, 0.11269967f, 0.21584551f, 0.01679064f, 0.12944114f, 0.01661074f, 
    0.05588121f, -0.09084481f, 0.07054230f, 0.17450947f, -0.09217077f, 0.11325725f, 0.16263193f, -0.08677924f, 
    0.02090729f, 0.05363068f, -0.02985826f, -0.02007766f, 0.05980115f, -0.04769327f, 0.03527307f, -0.04035492f, 
    -0.07378852f, -0.01115653f, -0.00184347f, -0.06684860f, -0.00054335f, -0.01632977f, 0.05246720f, 0.04502878f, 
    0.02288137f, -0.03079871f, 0.02245698f, 0.02291376f, 0.04699220f, 0.03194126f, -0.04513066f, -0.05211015f, 
    -0.02915614f, -0.04588517f, 0.06075368f, 0.02825092f, -0.00641540f, 0.02094640f, -0.06391918f, -0.03334814f, 
    0.02260153f, -0.06143982f, 0.05039285f, -0.02391401f, -0.05748672f, 0.04994581f, -0.02128168f, -0.01262337f, 
    0.06195163f, 0.01621111f, -0.01303633f, 0.03173208f, -0.07266836f, -0.01413304f, -0.07753631f, -0.03781964f, 
    -0.05665095f, -0.03703937f, 0.03278201f, -0.01657879f, 0.01700614f, 0.06049109f, -0.07680830f, -0.07400684f, 
    -0.02135957f, 0.05883774f, 0.05283972f, 0.06110213f, -0.01367272f, -0.01388006f, 0.04871386f, -0.07040343f, 
    0.05939035f, -0.05167374f, -0.07031859f, 0.04177844f, -0.05443892f, -0.06793014f, 0.00277003f, -0.05316987f, 
    0.00989405f, 0.00767721f, -0.03234120f, -0.04222313f, 0.00887257f, -0.03431689f, -0.03972540f, -0.03226404f, 
    0.05978948f, 0.00609148f, -0.02662122f, -0.04966124f, 0.05154273f, -0.05409310f, 0.06672516f, -0.00510229f, 
    -0.02696812f, -0.06776519f, -0.00812799f, -0.02777059f, -0.05562051f, -0.01795409f, 0.02100898f, -0.03390189f, 
    0.06048102f, -0.01223526f, -0.01415218f, -0.07406974f, -0.03022531f, 0.03073605f, 0.00087489f, -0.07200501f, 
    -0.02732375f, 0.01861382f, 0.03215979f, -0.02531537f, 0.02099813f, -0.03382420f, -0.02804499f, 0.04003164f, 
    0.05693331f, 0.01370951f, 0.02914367f, 0.02078220f, -0.04795565f, 0.02028099f, 0.05150087f, -0.04265321f, 
    -0.05460600f, -0.00019074f, -0.05804537f, -0.07719794f, 0.04189226f, 0.01099396f, -0.07032306f, -0.03423420f, 
    0.03343650f, 0.00304511f, 0.01659461f, 0.01036701f, -0.00380564f, 0.00644416f, 0.03532117f, -0.07872207f, 
    -0.06739413f, 0.00523966f, -0.01179709f, -0.01435323f, -0.00237538f, -0.00266689f, -0.01783708f, 0.04296131f, 
    -0.02477681f, -0.05503961f, 0.01964765f, -0.05861275f, -0.02279476f, -0.00925590f, -0.04870263f, -0.04923877f, 
    0.01881928f, 0.03924261f, -0.00926225f, -0.05616294f, 0.05429644f, 0.03113122f, 0.02045479f, -0.00872656f, 
    -0.05450771f, -0.03895297f, -0.03557965f, -0.06693290f, 0.05750301f, 0.01950384f, -0.01753447f, -0.03798763f, 
    -0.01614987f, 0.04046320f, -0.00021606f, 0.02464762f, 0.05537511f, 0.05461158f, -0.04318152f, -0.01757080f, 
    0.00047667f, -0.06058922f, -0.06925784f, 0.05179269f, 0.06035645f, -0.06754515f, 0.05293492f, 0.01250935f, 
    -0.06312390f, 0.05209616f, -0.03440491f, -0.04270654f, -0.04287360f, -0.01471015f, 0.02339878f, -0.02991136f, 
    -0.15387028f, -0.03696896f, -0.16669548f, -0.33974788f, 0.15043887f, 0.01136373f, 0.10361645f, -0.02673284f, 
    -0.04690310f, 0.11862662f, 0.10469402f, 0.31446716f, 0.03056610f, -0.15673983f, -0.21503757f, 0.09767702f, 
    0.06257521f, -0.05312097f, -0.10510606f, 0.27592033f, -0.02028489f, -0.02776748f, -0.00428035f, -0.00605389f, 
    -0.35841078f, 0.36335772f, 0.21980636f, 0.44111642f, -0.07991420f, 0.06971045f, 0.12496670f, 0.15142633f, 
    -0.02527687f, 0.13257124f, 0.10671499f, 0.01704088f, 0.04047732f, 0.08982507f, -0.07641990f, -0.14569440f, 
    0.18384518f, -0.02961307f, -0.05214761f, -0.00168603f, 0.02054758f, 0.23185614f, 0.02607570f, 0.13215776f, 
    -0.03215198f, -0.14454028f, -0.15157771f, -0.21966808f, 0.03815085f, -0.00927813f, -0.09514811f, -0.01090186f, 
    0.13480428f, 0.17540409f, 0.00022192f, 0.04174570f, -0.15897068f, 0.16866545f, -0.06823851f, 0.30695847f, 
    0.16825393f, -0.00864580f, 0.12468806f, 0.04546237f, -0.03381029f, 0.00225025f, 0.02684101f, -0.03272362f, 
    -0.33656624f, 0.44785744f, -0.06518792f, -0.00901896f, -0.06402387f, 0.02380926f, -0.11717223f, -0.03472355f, 
    0.19060196f, 0.15390211f, 0.07874798f, 0.22137336f, 0.03801153f, -0.14422792f, -0.15265718f, 0.04288368f, 
    0.18874687f, -0.02119157f, 0.07015250f, 0.22379841f, -0.02940696f, -0.06206448f, 0.13055281f, 0.03370770f, 
    0.09040860f, 0.34124848f, -0.00654415f, 0.27237576f, -0.07741370f, -0.01101180f, -0.03749957f, 0.01127379f, 
    -0.10054971f, 0.05319398f, 0.15515800f, 0.02062227f, 0.30616254f, -0.13646764f, 0.05149765f, 0.21362297f, 
    -0.06735432f, -0.04021228f, 0.00825747f, -0.02365117f, -0.03660587f, -0.03613255f, 0.13136193f, -0.01082775f, 
    0.31763303f, 0.04881571f, -0.01165038f, -0.02536881f, -0.02137929f, 0.04840077f, 0.09700128f, -0.05783712f, 
    -0.10241321f, 0.05314343f, 0.17420143f, -0.22867106f, 0.04734395f, 0.25276351f, 0.01028948f, -0.00023116f, 
    0.02291841f, 0.13669974f, -0.00060753f, 0.14477465f, 0.07629426f, 0.07189590f, 0.06333309f, -0.08810101f, 
    -0.27927977f, -0.00889584f, -0.08592942f, -0.08427212f, 0.13664274f, 0.00344777f, -0.06377264f, -0.04370615f, 
    0.08863945f, -0.06436794f, 0.17006072f, 0.01216372f, 0.19388039f, -0.11355795f, 0.40709656f, -0.13615958f, 
    0.23908690f, 0.08225850f, 0.06525000f, -0.08691218f, -0.09157332f, -0.15175396f, -0.01753480f, -0.14111897f, 
    0.21671608f, 0.08813494f, -0.15417407f, -0.20674643f, 0.03543528f, 0.11526105f, 0.10377250f, -0.11852265f, 
    -0.12885556f, 0.01827445f, -0.17358680f, -0.01233955f, -0.32419512f, 0.19013982f, -0.19346492f, -0.51314515f, 
    0.16465399f, 0.04648583f, 0.02173413f, 0.12270061f, -0.08118872f, -0.06280483f, 0.04489973f, -0.05910015f, 
    0.16054560f, 0.12373050f, 0.18755512f, 0.06126959f, 0.15393957f, -0.04765641f, 0.06025587f, -0.03409094f, 
    0.01856352f, -0.03166775f, 0.09341096f, 0.14419235f, 0.28691366f, -0.26719794f, -0.24400693f, -0.03277634f, 
    0.02933191f, 0.11019910f, -0.04751235f, 0.06876640f, -0.15997255f, -0.04988716f, 0.02150104f, -0.02868837f, 
    -0.39323819f, 0.47873777f, 0.00381941f, 0.31959268f, -0.03762456f, 0.02793379f, 0.16540359f, 0.12547775f, 
    -0.01078140f, -0.05404781f, 0.02940282f, 0.15525955f, -0.04592725f, -0.06742533f, 0.03565395f, -0.17561720f, 
    0.04327096f, -0.01699968f, 0.16866657f, 0.07328361f, 0.06691994f, 0.11321697f, 0.04107182f, -0.00311135f, 
    0.27174985f, -0.14016183f, 0.07104655f, 0.01155847f, 0.21199588f, 0.04520378f, -0.13080645f, -0.12472983f, 
    -0.01013654f, -0.03050955f, -0.17234273f, 0.11929080f, -0.12171663f, 0.62726492f, -0.17773367f, 0.19455868f, 
    0.00851567f, 0.07456427f, 0.05112262f, 0.15450779f, 0.17701946f, 0.04384564f, 0.07823601f, -0.04264314f, 
    -0.51331347f, 0.14387126f, -0.28531885f, 0.05850439f, 0.04196370f, -0.01066141f, 0.06059102f, 0.08718763f, 
    0.14053603f, -0.05646709f, -0.04537459f, 0.08176274f, -0.12100639f, -0.30721980f, -0.18594217f, -0.11398733f, 
    -0.05799130f, -0.01205502f, 0.13177817f, 0.08991107f, 0.01278092f, 0.01448002f, -0.06940798f, 0.19421624f, 
    -0.43842968f, -0.20594391f, -0.16451630f, 0.18550023f, 0.06361334f, 0.13676587f, -0.05095620f, 0.19630504f, 
    -0.01205490f, -0.03545610f, 0.06082076f, 0.10293947f, 0.18048532f, -0.41470698f, -0.25855041f, -0.01664203f, 
    0.03204719f, 0.06822183f, 0.04194611f, -0.11891130f, -0.10531162f, -0.05201419f, -0.10456505f, -0.02370353f, 
    0.18175332f, -0.24535201f, 0.00158778f, -0.01075199f, 0.10021111f, -0.00222587f, 0.01915490f, 0.09665248f, 
    -0.06352280f, 0.06387500f, 0.04270403f, 0.01842703f, 0.27167854f, -0.13690132f, 0.26495171f, 0.00714532f, 
    0.07607358f, 0.12829220f, 0.12823975f, -0.10526527f, 0.00608712f, 0.08599734f, 0.00327613f, -0.08151078f, 
    -0.13820583f, 0.22461900f, -0.00648847f, 0.15484302f, 0.06265344f, 0.03383083f, -0.11078122f, -0.15145086f, 
    -0.06886870f, -0.00662854f, 0.01440712f, 0.05365947f, -0.00324398f, -0.03992654f, 0.15783300f, -0.11791562f, 
    0.09697277f, 0.10346294f, -0.02867773f, 0.13129765f, 0.08807088f, -0.02294577f, -0.11997002f, -0.15720093f, 
    -0.01928247f, -0.04954329f, -0.23306395f, -0.41647479f, 0.04588072f, 0.06546994f, -0.01393198f, -0.01994935f, 
    -0.00695487f, -0.07974563f, -0.17146863f, 0.02131756f, 0.05310034f, 0.36685520f, 0.14827900f, -0.09168129f, 
    0.21852972f, 0.06309478f, -0.09617338f, -0.04634800f, 0.02182240f, -0.01248599f, -0.10836020f, -0.06375331f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03741318f, 0.00220878f, 0.12286178f, 0.07889473f, 0.12825671f, -0.02299610f, 0.17924434f, -0.09452488f, 
    -0.05419255f, 0.05278308f, -0.07961956f, 0.00058631f, -0.09413333f, -0.08072431f, -0.04706383f, -0.06283788f, 
    0.03244412f, -0.04797711f, -0.01004897f, -0.00531079f, 0.11853100f, -0.08277710f, 0.00808763f, 0.06312269f, 
    0.09042526f, 0.20689335f, -0.01400952f, 0.18745546f, -0.02574347f, -0.00751491f, -0.04821013f, 0.10772935f, 
    0.05825493f, -0.03698915f, -0.01322296f, 0.02168012f, -0.06403606f, -0.05533096f, 0.01881225f, -0.08542997f, 
    -0.01467254f, -0.04581696f, -0.02264850f, 0.16662315f, -0.01793175f, -0.06838155f, 0.14225101f, 0.05796235f, 
    -0.07758178f, 0.09904890f, 0.03054792f, 0.02296462f, -0.03199704f, 0.08340711f, -0.04932743f, 0.01802686f, 
    -0.01095923f, -0.03190817f, 0.02698554f, 0.04025638f, -0.12396893f, 0.02704988f, 0.19672170f, -0.00058184f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01231073f, -0.38672081f, 0.04873786f, -0.13933331f, 0.09739002f, -0.24343757f, -0.32338464f, 0.49395940f, 
    0.39496517f, -0.56117356f, 0.05635225f, 0.01933775f, 0.10405082f, 0.08159815f, -0.00334713f, 0.01706202f, 
    0.10101042f, 0.20233040f, -0.09652074f, 0.02588743f, -0.63439482f, -0.04344455f, 0.23854250f, -0.39351147f, 
    0.22836408f, -0.42463773f, 0.20189793f, -0.27498990f, 0.11300223f, 0.19159661f, -0.19389291f, -0.09154274f, 
    0.24966201f, 0.21782653f, 0.09728073f, -0.04476269f, -0.01246865f, -0.07571024f, 0.02799975f, 0.27878001f, 
    -0.03093283f, -0.05485893f, 0.04235411f, -0.05054364f, -0.51810801f, 0.27921772f, 0.16047476f, -0.11476588f, 
    0.01110286f, -0.07742919f, -0.33481544f, 0.13451058f, 0.07238737f, 0.06857978f, -0.02560715f, -0.07945374f, 
    0.09552586f, 0.15342723f, -0.03174560f, -0.05509397f, 0.06173555f, -0.02960836f, -0.47463956f, -0.57816988f, 
    0.03812601f, 0.16974512f, -0.41397697f, -0.00201828f, 0.14668739f, 0.27010831f, 0.13653944f, 0.00339143f, 
    -0.00366374f, 0.19716717f, -0.07711022f, 0.05607185f, 0.05439457f, -0.12761240f, 0.16997419f, -0.37460649f, 
    -0.80804932f, 0.01842617f, 0.05666042f, 0.00887626f, -0.12075283f, -0.10465961f, 0.05154605f, -0.01992986f, 
    -0.02606137f, -0.42959905f, 0.31975010f, 0.34824046f, -0.06591044f, -0.15552315f, 0.06324391f, 0.26082355f, 
    0.14941454f, 0.01586938f, -0.00977262f, -0.07369572f, -0.10262864f, 0.06013679f, -0.08695479f, 0.28912848f, 
    0.10335429f, -0.05341140f, -0.19934765f, 0.03528117f, -0.32252955f, 0.28412214f, 0.22714987f, -0.03810949f, 
    0.01991647f, -0.33873090f, -0.15915291f, -0.27579215f, -0.11569634f, -0.28930902f, 0.04728579f, 0.30269384f, 
    -0.12316255f, -0.00400371f, -0.01092484f, 0.09037872f, -0.09562673f, -0.09913594f, -0.33229411f, -0.09918439f, 
    -0.11116713f, 0.28505012f, -0.12614621f, 0.07989804f, -0.15955983f, 0.14541574f, 0.01132148f, 0.20415582f, 
    -0.18766895f, 0.38040075f, -0.03390067f, -0.04940867f, -0.00448272f, 0.10861918f, 0.02979998f, -0.32876092f, 
    0.08201765f, -0.43262482f, 0.00624406f, 0.07319571f, 0.15447047f, -0.08426102f, 0.19416854f, -0.20638797f, 
    -0.13468751f, -0.26419273f, -0.03971223f, 0.18114106f, 0.06750251f, -0.29534408f, -0.13705774f, 0.22361918f, 
    -0.16549797f, 0.33419138f, 0.09475331f, -0.44647455f, -0.08942261f, 0.03432456f, -0.09695774f, 0.06231196f, 
    -0.29933971f, 0.06093713f, 0.03762957f, -0.59103554f, -0.08633859f, -0.08090137f, -0.06021808f, -0.08395596f, 
    0.08716267f, 0.03801386f, 0.32978100f, 0.04785759f, -0.05296779f, -0.55357265f, -0.11854651f, -0.30448383f, 
    -0.05477813f, 0.33025753f, 0.10450899f, -0.02526848f, 0.27107504f, -0.11083239f, 0.12622103f, 0.21609417f, 
    -0.01340818f, 0.10723659f, 0.25649256f, -0.21486889f, 0.03279225f, 0.08878669f, 0.26020253f, -0.35614726f, 
    -0.02741581f, -0.14255024f, -0.12541559f, -0.10536425f, 0.12209211f, 0.06011446f, 0.03668274f, 0.07798030f, 
    0.26656821f, 0.26360500f, 0.10025480f, 0.03359880f, 0.19417860f, -0.09497157f, -0.00412696f, -0.58455122f, 
    -0.78835928f, 0.07789087f, 0.17182754f, -0.07756422f, 0.09074509f, 0.19845207f, 0.17744219f, -0.50362968f, 
    -0.04148272f, -0.10135453f, -0.08672887f, 0.23390934f, -0.03485193f, -0.00772748f, -0.48074111f, -0.54770780f, 
    0.35445791f, -0.03989923f, 0.16264811f, -0.24200201f, 0.01418286f, -0.77989781f, -0.06720731f, -0.03022039f, 
    -0.04172678f, -0.37574363f, 0.30600932f, 0.12977104f, -0.04501720f, 0.17155337f, -0.08136791f, -0.54439175f, 
    0.11135365f, 0.04753836f, -0.02314542f, -0.04210195f, -0.75522822f, -0.05691865f, -0.07698077f, -0.35783693f, 
    -0.10374137f, 0.15400353f, -0.16076463f, -0.06686334f, 0.02504739f, 0.23748025f, -0.13474475f, -0.19678028f, 
    0.01505977f, 0.29290318f, -0.06503819f, 0.00805161f, 0.26259574f, -0.05428590f, -0.34494606f, 0.38271400f, 
    -0.01199153f, 0.36013138f, 0.08908365f, 0.11686983f, -0.06975488f, 0.07697982f, 0.01615597f, -0.27387762f, 
    -0.10661155f, 0.04948728f, -0.37210703f, -0.00897713f, 0.05907310f, 0.30522212f, 0.26915452f, 0.18073201f, 
    -0.17209861f, 0.14469986f, 0.04970560f, -0.05882958f, 0.09942016f, 0.12764549f, -0.02851088f, -0.07375377f, 
    0.44269747f, -0.04216542f, -0.25361344f, 0.00526866f, 0.13216810f, -0.36972070f, 0.03622952f, 0.00840538f, 
    -0.05405550f, 0.05374634f, -0.18453966f, -0.22812559f, -0.02032164f, 0.01345284f, 0.07708977f, 0.00697395f, 
    -0.09638028f, -0.29515219f, 0.07979901f, 0.02420651f, 0.14729553f, -0.05778677f, 0.05033852f, 0.01321669f, 
    0.10349929f, -0.08313432f, -0.02448496f, 0.31254923f, 0.06413655f, -0.24377447f, -0.40983874f, -0.18911864f, 
    0.27336726f, 0.07077466f, 0.06283824f, -0.08696288f, -0.02886666f, -0.05779906f, -0.07814233f, -0.31742680f, 
    -0.06526452f, -0.05645125f, 0.08890932f, -0.05737668f, 0.10363211f, -0.07678080f, -0.38270757f, 0.18397720f, 
    0.11625315f, 0.24704567f, -0.05623545f, 0.00092391f, -0.04250791f, 0.00744123f, 0.27332622f, -0.18180725f, 
    -0.39659849f, -0.51044363f, -0.09702491f, 0.28166911f, 0.05811521f, -0.11094734f, -0.03198894f, 0.23156556f, 
    -0.10829841f, -0.04977512f, -0.11554363f, 0.27800599f, 0.03283642f, 0.11487949f, 0.13059910f, 0.04660549f, 
    -0.05590647f, 0.12760124f, -0.46701634f, 0.32347524f, -0.01803050f, -0.03885081f, -0.02896149f, 0.39988929f, 
    0.08403281f, -0.26984078f, -0.03672791f, -0.11799085f, -0.09557230f, -0.04871410f, -0.30215502f, -0.02245083f, 
    0.03441402f, -0.20364104f, 0.13039045f, -0.34622592f, 0.25883907f, 0.21222699f, 0.21169630f, -1.08936501f, 
    -0.12343409f, -0.23172300f, 0.07912790f, -0.07397708f, -0.23318042f, -0.04895872f, 0.34847301f, -0.29382929f, 
    0.04127799f, 0.11786507f, -0.06658737f, -0.01548625f, 0.06370061f, -0.02761358f, 0.25561550f, 0.21061443f, 
    0.28100219f, -0.25549534f, -0.28558481f, -0.01828873f, 0.03297951f, 0.07460074f, 0.15273033f, -0.05296285f, 
    -0.36200273f, -0.86963218f, 0.10123766f, -0.53623545f, -0.08194389f, 0.02622378f, 0.09352861f, -0.16384542f, 
    -0.15397502f, 0.05086674f, -0.28502607f, 0.12087538f, -0.40026957f, -0.00259335f, -0.33108163f, 0.05348654f, 
    -0.05825523f, 0.06934662f, 0.03017055f, 0.24951114f, 0.09597710f, 0.29867178f, 0.10136966f, -0.17155297f, 
    0.04040234f, -0.20962250f, -0.12034887f, -0.09098573f, 0.23832913f, -0.07144215f, 0.10170727f, 0.24991027f, 
    -0.07790087f, 0.25569803f, 0.15123661f, -0.43758246f, -0.50891775f, -0.09149532f, -0.35438719f, -0.05307294f, 
    -0.80531585f, 0.02363643f, -0.03823794f, 0.00594391f, 0.20203592f, -0.11297196f, -0.10078241f, 0.14150324f, 
    0.33002928f, -0.26076603f, -0.09817695f, 0.05175415f, 0.16731255f, 0.05401926f, -0.51101065f, 0.16683619f, 
    -0.14906533f, -0.12649180f, -0.12355292f, -0.34810764f, -0.02509807f, 0.16544874f, 0.18820766f, -0.16732535f, 
    0.19615808f, 0.02125902f, -0.08288098f, 0.19276457f, 0.00417771f, 0.09090153f, -0.08812141f, 0.23299979f, 
    -0.20526899f, -0.03848728f, 0.29889679f, -0.34762362f, 0.12306272f, 0.13405550f, -0.52850890f, 0.11213648f, 
    0.10816129f, 0.37112808f, 0.02417987f, -0.04479722f, -0.10676462f, 0.07515524f, 0.00337611f, -0.18256414f, 
    0.02909031f, -0.34424227f, -0.01561591f, 0.05880291f, 0.20610464f, 0.06756913f, 0.09170131f, -0.24315658f, 
    0.08466527f, -0.09563673f, -0.30710939f, 0.32585549f, -0.03854559f, -0.24393590f, 0.12274951f, -0.10401664f, 
    -0.34911630f, 0.06259955f, -0.08382802f, 0.01534209f, -0.46311519f, -0.07230020f, 0.23513436f, 0.26666152f, 
    -0.27754128f, -0.16489877f, -0.02556174f, 0.08973601f, -0.26838538f, 0.01541835f, -0.42766863f, 0.01592312f, 
    0.16258408f, -0.29387799f, 0.16027787f, -0.20401964f, -0.07604539f, -0.20049834f, 0.06152410f, -0.06476656f, 
    0.08417894f, 0.31008691f, -0.07800705f, 0.27625716f, 0.07802159f, -0.07297713f, -0.43835312f, -0.22748469f, 
    -0.06930003f, -0.06078894f, 0.45171195f, 0.15740675f, 0.48162675f, 0.22211316f, -0.41440150f, -0.02445823f, 
    0.00458270f, -0.25812951f, -0.17759021f, -0.55391777f, -0.06735580f, -0.08104436f, 0.07577898f, 0.33248341f, 
    -0.04734888f, -0.01325192f, -0.11586247f, -0.05655869f, 0.26733851f, -0.10381521f, -0.15664075f, 0.34509552f, 
    -0.08138008f, -0.34174702f, -0.08900759f, 0.03215668f, 0.08722597f, -0.06645435f, 0.23781216f, 0.58361298f, 
    -0.37344238f, -0.41383174f, -0.09266347f, 0.07754105f, 0.11741427f, -0.01156415f, 0.10486597f, 0.32273230f, 
    0.13841447f, 0.08223746f, -0.01196723f, -0.07957694f, -0.11355464f, 0.02917972f, -0.11403883f, 0.20831981f, 
    -0.02294810f, 0.11876629f, -0.32872438f, -0.18880975f, -0.03021818f, 0.08540916f, -0.14766976f, -0.22661920f, 
    0.08416196f, -0.01285145f, 0.00044779f, -0.35263321f, 0.03524739f, 0.01450665f, 0.30573174f, -0.19970822f, 
    -0.71268845f, 0.04429587f, -0.38057429f, 0.03069949f, 0.25235307f, 0.16032362f, 0.20367943f, 0.09552560f, 
    0.02205588f, 0.33767661f, 0.44959512f, -0.19681320f, 0.02666784f, -0.12532824f, 0.11569682f, -0.59392089f, 
    0.00738210f, -0.46255755f, 0.07644794f, 0.03614420f, -0.43416855f, 0.09036710f, 0.34934160f, 0.30212864f, 
    0.04891849f, 0.39493799f, 0.24029236f, -0.10078175f, 0.06413437f, -0.18826833f, 0.26006672f, -0.43640009f, 
    -0.39376548f, -0.32418352f, 0.13450590f, -0.13000816f, -0.31445181f, -0.11059904f, -0.36780855f, -0.13443558f, 
    0.15821278f, -0.26674554f, -0.00665113f, -0.03679780f, 0.20964663f, 0.10258928f, 0.02055351f, 0.17688209f, 
    -0.18162660f, 0.40335205f, -0.20626141f, 0.38522246f, 0.01043255f, -0.30418751f, -0.50175399f, -0.04825053f, 
    0.06548839f, 0.07262325f, 0.11241673f, 0.15704194f, 0.06764250f, -0.08769315f, -0.34908140f, -0.75086987f, 
    -0.28214851f, 0.07259685f, 0.12733044f, 0.31820661f, -0.57570326f, 0.02391282f, 0.37257180f, 0.11697719f, 
    -0.05720122f, 0.41224408f, -0.13085009f, -0.43518505f, 0.02610154f, 0.08814352f, 0.11508607f, -0.03151561f, 
    -0.11810533f, 0.37117344f, 0.06658150f, 0.11848253f, -0.12355396f, 0.09321033f, 0.23951268f, -0.57772440f, 
    -0.00284804f, -0.41745532f, 0.19858013f, 0.07890683f, -0.28924361f, -0.31311950f, -0.09099344f, -0.45522410f, 
    0.05987125f, -0.25099400f, 0.04164931f, 0.00997668f, -0.05098864f, -0.00946906f, -0.19012746f, -0.15274510f, 
    -0.42509404f, -0.27233806f, 0.01150629f, -0.03096900f, 0.28551400f, 0.08209484f, -0.09273268f, 0.14428766f, 
    0.28136003f, 0.08147096f, 0.23526871f, 0.22298189f, -0.09985841f, 0.22355911f, -0.45732412f, 0.24755648f, 
    0.26602975f, -0.15933676f, 0.03962284f, -0.14412118f, 0.10767824f, 0.07052676f, 0.42719126f, 0.04181196f, 
    0.16379544f, 0.00759903f, 0.09844589f, -0.02164421f, 0.35152116f, -0.37602144f, -0.37156382f, -0.00091448f, 
    0.03352140f, -0.71408278f, -0.08684228f, 0.16156243f, -0.02492405f, 0.26524869f, -0.07172063f, 0.00825534f, 
    -0.03017725f, 0.20992276f, -0.05901673f, 0.02334241f, -0.17079516f, 0.03733001f, 0.30000693f, -0.29835182f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18120854f, 0.01012053f, -0.08138965f, -0.06677648f, 0.02716884f, 0.02014033f, -0.09281686f, -0.00877392f, 
    -0.13210198f, 0.09267092f, 0.20358911f, 0.00747947f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
