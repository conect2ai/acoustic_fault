#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.90659589f, -0.43138519f, 0.24562302f, 0.17938678f, -0.32897374f, -0.33732158f, 0.60261565f, 0.48772994f, 
    0.54400164f, 0.09188419f, 0.08124670f, -0.07038785f, 0.06359814f, 0.49758434f, 0.34283870f, -0.39456636f, 
    0.92398775f, -0.42040604f, -1.07021320f, -0.39467847f, 0.18337193f, 0.00620160f, -0.31922883f, -0.60583884f, 
    -0.28373772f, 0.65024722f, -0.17799973f, 0.06338169f, 0.25579572f, 0.27519834f, -0.84897858f, -0.55613172f, 
    -0.00338701f, -0.02302575f, 0.21946108f, 0.50286323f, 0.90022010f, 0.38124633f, 0.03233562f, -0.34419370f, 
    -0.15370354f, -0.19455834f, 0.72400904f, -0.32700107f, -0.01422141f, -1.04629946f, 0.11352366f, 0.08235472f, 
    -0.45442122f, 0.07479805f, -0.76686203f, 0.65663141f, 0.55680239f, 0.25535986f, 0.66162497f, -0.80960894f, 
    -0.61267537f, -0.62890303f, -0.33554116f, -0.36873665f, -0.04961719f, -0.14935239f, -0.47937882f, 0.53262782f, 
    -0.31474978f, 0.05219900f, 0.53304708f, 0.70493245f, 0.33863172f, 0.42725092f, 0.41729647f, 0.21154396f, 
    -0.18803835f, 0.15370196f, 0.29949951f, -0.35578680f, 0.08479395f, 0.26945776f, 0.49516392f, -0.98165441f, 
    0.43862620f, -0.87890315f, -0.31975165f, -0.48095739f, 0.49479574f, -0.21408801f, -0.34913635f, -0.57234704f, 
    -0.58360761f, -0.49808249f, -0.05346902f, 0.34799314f, 0.16756901f, 0.55241275f, 0.95695883f, -0.48767471f, 
    0.19118442f, 0.00669356f, -0.33257163f, -0.53128463f, 0.07629686f, -0.29741499f, 0.43777820f, 0.29479536f, 
    0.95119792f, -0.54201972f, -0.51276553f, -0.22781333f, -0.30267936f, -1.14266539f, -0.53632021f, 0.72798741f, 
    0.73509228f, 0.22322771f, -0.13885432f, -0.24543530f, -0.24837767f, -0.10974295f, -0.24661762f, -0.22212835f, 
    -0.69787812f, -0.15862121f, -0.99380058f, -0.19145462f, -0.47638965f, 0.71309572f, 0.61459172f, 0.29002789f, 
    0.45853996f, -1.00938129f, -0.10945954f, 0.43295705f, -0.21889815f, 0.41614363f, -0.06458333f, -0.06766377f, 
    -0.81058151f, -0.83094281f, 0.19915268f, -0.01361157f, 0.58887136f, 0.07572713f, 0.17701811f, 0.42992604f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07884767f, 0.25652248f, -0.51186538f, 0.35477698f, 0.34104389f, 0.49699393f, 0.26822326f, -0.20100138f, 
    0.19940405f, -0.00118072f, -0.20218727f, -0.13150272f, 0.22762322f, -0.12947032f, 0.17524588f, 0.51271778f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.06152420f, -0.07050590f, 0.05996626f, -0.04361600f, 0.00464071f, -0.01381127f, 0.00672330f, 0.00715371f, 
    -0.09068172f, -0.02909329f, 0.03916598f, 0.05280991f, 0.05986834f, 0.00606724f, -0.09221732f, -0.00367430f, 
    0.06172071f, -0.08831059f, 0.05815665f, -0.03936859f, 0.06770305f, -0.06524526f, -0.03888406f, -0.04883227f, 
    -0.07931367f, 0.05408537f, 0.04866227f, 0.00467655f, -0.02461019f, -0.01915343f, -0.08637949f, -0.03948057f, 
    -0.01142214f, -0.08305950f, -0.01437756f, 0.03478107f, -0.08275573f, 0.01750198f, -0.04943936f, -0.03086938f, 
    -0.09430605f, -0.01078564f, -0.04682283f, 0.06684072f, 0.01564217f, -0.08295766f, 0.00487104f, 0.02178070f, 
    -0.02588204f, 0.03758638f, 0.03777611f, 0.00730375f, 0.04133644f, 0.06772472f, 0.02783390f, -0.01432863f, 
    0.06356930f, -0.00734895f, -0.00492966f, 0.01353871f, 0.04952776f, 0.03056218f, -0.08159927f, -0.01089471f, 
    0.05531102f, -0.04387127f, -0.03597967f, -0.01382342f, -0.00032648f, 0.00777440f, 0.04838791f, 0.01769551f, 
    -0.00714737f, 0.05529524f, -0.06574285f, 0.01356307f, -0.05471636f, 0.02763695f, -0.03885403f, 0.00390134f, 
    -0.04128504f, -0.05244259f, -0.05014260f, -0.08494122f, -0.09053623f, -0.03859687f, 0.02176499f, -0.08846726f, 
    -0.04355613f, 0.06861855f, -0.05852111f, 0.02793667f, -0.06813414f, 0.07781449f, -0.08364266f, -0.00449467f, 
    -0.02282361f, 0.01227731f, -0.05404852f, 0.01228776f, 0.00688233f, 0.00715267f, -0.01130374f, -0.05040118f, 
    -0.02633132f, -0.07105838f, 0.00590589f, 0.02248467f, 0.04341384f, -0.01131607f, -0.05183864f, 0.01062666f, 
    -0.02674592f, -0.06290488f, -0.09051141f, -0.05840941f, 0.03264854f, 0.00193276f, 0.06579705f, -0.04337119f, 
    0.03209645f, 0.01337993f, -0.03435582f, -0.06182742f, -0.06240820f, -0.07059845f, -0.08886651f, 0.05054004f, 
    -0.02962907f, 0.00676670f, -0.06254616f, 0.06514949f, 0.02959037f, 0.01997514f, -0.03701751f, 0.01957647f, 
    0.04214018f, -0.00813067f, -0.05873282f, -0.01960607f, 0.05594107f, -0.09095221f, 0.02170099f, 0.05025384f, 
    0.28614241f, -0.02954452f, -0.16025391f, 0.05858598f, -0.00147184f, 0.12622871f, 0.11205816f, -0.02708481f, 
    0.04715086f, -0.08633319f, 0.20167997f, 0.25406921f, 0.05708840f, -0.10893764f, -0.04335444f, -0.11506113f, 
    -0.04372367f, 0.07983621f, 0.04154410f, -0.01928735f, 0.10120962f, 0.32862705f, -0.11278528f, -0.27505633f, 
    -0.14381494f, -0.20735127f, -0.06749950f, -0.04550266f, 0.11421467f, -0.15487882f, 0.04948815f, -0.05172495f, 
    0.06161788f, 0.04443761f, -0.07190927f, 0.17053324f, 0.58307034f, 0.09693538f, 0.06281521f, 0.02024662f, 
    -0.06785683f, -0.14104433f, 0.00019679f, 0.23670225f, 0.04131418f, -0.61452806f, -0.12254028f, 0.29521596f, 
    -0.00108425f, 0.15864925f, 0.05216224f, 0.20510571f, 0.12712781f, 0.01614117f, -0.17515549f, -0.52732253f, 
    -0.70832717f, -0.09002624f, 0.19315697f, 0.35260105f, 0.24275587f, 0.06977744f, 0.08520990f, -0.20535211f, 
    -0.00551288f, -0.08996998f, -0.24051546f, 0.04382938f, 0.10626318f, 0.13192850f, -0.02931990f, -0.05021784f, 
    0.03772414f, 0.05122948f, 0.17626204f, 0.01051387f, 0.01303816f, 0.02814224f, 0.14553340f, 0.41059923f, 
    0.02234743f, 0.14857452f, -0.38273731f, -0.64223939f, -0.11634334f, -0.04559667f, 0.12119965f, 0.06516884f, 
    0.10853814f, 0.06535511f, -0.02520400f, 0.10617835f, 0.21309094f, -0.04706634f, -0.17855449f, -0.03198290f, 
    -0.07661653f, -0.20366450f, 0.30030173f, -0.59329182f, 0.13445018f, -0.35421011f, -0.03127184f, -0.21953046f, 
    -0.17939660f, 0.00887292f, -0.19337635f, 0.11113177f, -0.26963428f, -0.44318819f, -0.08809940f, 0.04701202f, 
    0.02447838f, -0.04486745f, -0.02141584f, -0.11276486f, 0.05926098f, -0.52901453f, -0.43179172f, -0.05778294f, 
    -0.04705030f, 0.08087993f, -0.17832591f, 0.05563067f, -0.00384883f, 0.05313846f, 0.68758905f, 0.09201125f, 
    0.01975652f, -0.10613839f, -0.02435850f, 0.01844604f, 0.11722768f, 0.10823317f, 0.05527700f, -0.63192916f, 
    0.15808825f, -0.33905247f, -0.00730588f, 0.24846487f, 0.19026621f, 0.13850462f, -0.07120734f, -0.13898833f, 
    0.01419100f, -0.01287898f, -0.11322184f, 0.01120307f, -0.07028347f, -0.16185793f, -0.06392807f, -0.36562228f, 
    -0.31294867f, -0.20600499f, 0.05826578f, -0.06245482f, -0.07530630f, 0.13317615f, 0.16676435f, 0.00180908f, 
    -0.06510232f, 0.21186453f, 0.50032818f, 0.08425279f, -0.07204990f, 0.25859275f, -0.20748886f, 0.13756217f, 
    0.07247379f, -0.14431395f, -0.05075829f, -0.11059018f, 0.15396759f, 0.05460761f, 0.16076589f, -0.06476924f, 
    -0.01113681f, 0.01336437f, -0.10551265f, -0.29367459f, 0.18419659f, 0.53747314f, 0.00085959f, 0.14770252f, 
    -0.11624411f, -0.03848215f, 0.23965871f, 0.11759574f, -0.11909465f, -0.16189082f, -0.32368109f, -0.14311790f, 
    0.16904765f, 0.06520677f, 0.20098485f, 0.02985848f, -0.06129998f, -0.17654827f, 0.03966955f, 0.15768030f, 
    0.35341385f, 0.11162844f, 0.16409341f, 0.04417140f, -0.06147926f, 0.10419645f, 0.16244306f, 0.00280327f, 
    0.00885295f, 0.12362693f, 0.00133464f, -0.03665442f, 0.20759901f, -0.18839778f, -0.21492627f, -0.14466399f, 
    0.09182096f, -0.19114147f, 0.02088046f, 0.28434730f, 0.24032250f, -0.17850049f, 0.04594263f, -0.13149662f, 
    0.06169769f, -0.01319178f, -0.02601387f, 0.09586732f, -0.13080253f, -0.18081865f, 0.03319459f, -0.14226250f, 
    0.07314500f, 0.20292760f, 0.25439480f, 0.43550977f, -0.21805282f, 0.11761043f, 0.02760100f, 0.07475292f, 
    -0.01587026f, 0.03135635f, -0.15321508f, 0.02596398f, -0.55070019f, -0.54960841f, -0.07088018f, 0.04740120f, 
    0.10306273f, 0.06380644f, 0.26905653f, 0.00175704f, -0.22872682f, -0.13197434f, -0.05988684f, 0.05115568f, 
    0.10095350f, 0.16707829f, 0.11378777f, 0.18225618f, 0.17758556f, 0.16158865f, 0.15730253f, 0.08320955f, 
    0.18228027f, 0.05687040f, -0.11800439f, -0.06306501f, -0.12799655f, -0.07427846f, 0.27977985f, 0.43574309f, 
    -0.08697021f, -0.16380572f, 0.01739614f, 0.03621798f, -0.09285619f, -0.03979822f, -0.01286762f, -0.02795272f, 
    -0.07672026f, 0.28430188f, 0.14141479f, 0.12971959f, -0.02508825f, -0.01808481f, 0.06948413f, -0.09186652f, 
    0.00860063f, -0.18240201f, -0.00871441f, -0.12064206f, -0.06058615f, 0.02959703f, 0.04458208f, 0.05338985f, 
    0.05644708f, -0.10672693f, -0.38878462f, 0.10103100f, -0.10172901f, 0.08225999f, -0.11369655f, -0.27014655f, 
    0.00453994f, 0.23835032f, -0.37412143f, 0.00911712f, -0.26224017f, -0.01236157f, -0.04522660f, -0.10267468f, 
    -0.01480829f, 0.15249117f, -0.11108473f, 0.26112440f, 0.05384830f, 0.09700143f, -0.05482526f, -0.00125904f, 
    0.07193810f, -0.05621213f, 0.14786558f, 0.11036827f, -0.05968830f, -0.18714783f, 0.01796431f, 0.02448680f, 
    0.01038851f, -0.03322028f, 0.06718925f, 0.01861412f, 0.27133605f, 0.28451455f, 0.16694768f, 0.12012672f, 
    0.07913730f, 0.11899684f, 0.12154110f, 0.11059125f, 0.00779019f, 0.11350171f, 0.20608610f, 0.08913871f, 
    0.12088363f, 0.05549274f, 0.00237599f, 0.07769672f, -0.02315455f, -0.17440522f, 0.15289333f, 0.17904200f, 
    -0.39089814f, -0.14702170f, -0.03617308f, 0.00999783f, -0.18805303f, 0.02708102f, 0.26311290f, 0.19547208f, 
    0.09380522f, 0.48806340f, 0.07637989f, 0.01995520f, -0.00574098f, -0.30326110f, 0.18483233f, 0.12960760f, 
    0.14074695f, -0.08901069f, 0.02530440f, -0.60320753f, 0.09922139f, 0.01935991f, 0.21491276f, 0.13831234f, 
    -0.27095953f, 0.06084623f, 0.04692880f, -0.14884497f, -0.12175087f, -0.01976012f, 0.06096826f, -0.32764158f, 
    0.07024790f, 0.07247045f, -0.09061195f, -0.20153323f, -0.22901537f, -0.47915697f, 0.02694057f, -0.28784043f, 
    -0.17140551f, -0.14901903f, 0.03101292f, -0.28046292f, -0.10754387f, -0.25186986f, -0.68478036f, 0.14895824f, 
    -0.01399568f, -0.08995394f, -0.02128408f, -0.09449615f, -0.08681437f, 0.27815023f, 0.16221349f, 0.26648229f, 
    -0.12306345f, -0.01637969f, 0.13341288f, 0.09715308f, 0.05909422f, 0.29816070f, -0.23729679f, -0.35561815f, 
    0.45782587f, -0.31510654f, -0.09844626f, -0.12233813f, -0.02839390f, 0.13484380f, -0.03568149f, -0.28605011f, 
    -0.25017145f, -0.04615512f, 0.05944426f, 0.00191099f, 0.00697524f, 0.10945748f, 0.07390658f, 0.02131627f, 
    -0.03997857f, -0.04454327f, -0.07734220f, 0.02292258f, 0.03402023f, 0.06955103f, -0.01731566f, 0.05491489f, 
    0.02489795f, 0.01275549f, 0.00002432f, 0.00007051f, 0.02394266f, 0.07593576f, -0.04485092f, -0.09067984f, 
    -0.04170698f, -0.06162156f, 0.04539920f, -0.07775004f, -0.05670999f, -0.07863182f, 0.00788954f, 0.01518140f, 
    -0.01329600f, -0.02005768f, 0.05634240f, 0.03044164f, -0.03956715f, -0.04680697f, -0.00300790f, -0.00192954f, 
    0.00547612f, -0.03375980f, 0.01982201f, -0.02788337f, -0.07515750f, -0.01903377f, 0.04713626f, -0.03235555f, 
    -0.07269917f, 0.05752624f, -0.02109969f, -0.02854589f, -0.03041684f, -0.04830549f, 0.02751022f, -0.00255795f, 
    0.07696087f, -0.00488319f, 0.05757942f, 0.03864037f, -0.01051390f, -0.01851868f, 0.06370269f, -0.00664281f, 
    -0.05695264f, -0.04611331f, -0.00808910f, -0.00046123f, -0.05386373f, -0.04806685f, -0.05882099f, -0.05205887f, 
    -0.05793018f, 0.06604110f, 0.02440743f, -0.05842005f, 0.02657703f, 0.02926097f, -0.01171207f, -0.06059420f, 
    0.04153538f, 0.03287197f, 0.08171135f, -0.08021929f, 0.01497054f, -0.06185710f, -0.00658031f, 0.04306854f, 
    -0.02131467f, -0.07704729f, 0.05861100f, 0.07343667f, -0.04250487f, 0.02794628f, -0.03024473f, 0.06853931f, 
    0.00935492f, -0.08197989f, -0.05683800f, 0.03930373f, 0.06035973f, 0.06379259f, -0.02820723f, -0.06870482f, 
    0.00755766f, 0.03832525f, -0.03228063f, -0.06083864f, 0.03935755f, 0.01026019f, -0.05519925f, 0.04259372f, 
    0.01865313f, 0.07387571f, -0.05896284f, -0.07959734f, 0.06020548f, -0.07717957f, -0.08027380f, -0.05235697f, 
    -0.08673422f, -0.01937137f, -0.05115737f, 0.04796403f, -0.08622324f, -0.00460312f, -0.00018162f, -0.03418478f, 
    -0.05627641f, 0.04453175f, -0.04397025f, -0.01350826f, -0.07340869f, 0.03543209f, 0.05893959f, -0.03181186f, 
    0.01610789f, 0.01061140f, 0.07007656f, -0.07370469f, 0.00725255f, 0.04086669f, -0.03016680f, 0.00515931f, 
    -0.07515476f, 0.02341015f, -0.08367682f, -0.05863237f, -0.00222782f, 0.07684768f, -0.04210382f, -0.03191542f, 
    0.42083129f, 0.03759694f, 0.14524917f, 0.07953836f, 0.11985310f, 0.24730077f, 0.13895117f, -0.25308692f, 
    -0.23642120f, 0.10167979f, 0.09197331f, 0.06579714f, 0.08366345f, 0.03203831f, -0.21646579f, 0.06771184f, 
    0.15360425f, 0.21259294f, -0.84014946f, 0.12044072f, -0.42235321f, -0.32134858f, -0.34136787f, -0.22776528f, 
    0.06947964f, 0.13876545f, 0.25768664f, 0.21678363f, 0.24988881f, -0.37207410f, 0.10458918f, -0.16789840f, 
    0.18426825f, 0.01819433f, -0.09327358f, -0.20930678f, 0.22697513f, -0.14561841f, -0.43691039f, 0.02602412f, 
    0.00229051f, 0.04282852f, 0.05626188f, 0.14871649f, -0.03724832f, -0.29449531f, 0.26271260f, 0.08393780f, 
    -0.04099419f, -0.08717279f, -0.20745875f, -0.06761973f, 0.08855960f, -0.07917918f, -0.05493098f, -0.44497734f, 
    -0.00633611f, 0.18505310f, -0.29657441f, -0.16890717f, 0.02379871f, 0.12200198f, -0.06914950f, 0.03270485f, 
    -0.10842146f, -0.03865315f, 0.19438456f, 0.00578725f, -0.01390539f, 0.17394392f, 0.12554462f, -0.12475925f, 
    -0.19014914f, 0.14778595f, 0.00060115f, 0.16401176f, 0.06379558f, -0.05619677f, -0.04014566f, 0.02139353f, 
    -0.06342403f, 0.24569143f, 0.01216874f, -0.22081371f, -0.18316254f, 0.08323173f, -0.13444547f, 0.09023146f, 
    0.12238986f, 0.14389135f, -0.12280912f, -0.39551106f, 0.34481868f, -0.31353757f, 0.10987663f, -0.02791191f, 
    0.20358503f, 0.03463094f, 0.15566193f, 0.40703666f, 0.47850847f, -0.00113246f, -0.10293996f, -0.16037759f, 
    0.02695668f, -0.11652936f, 0.18953069f, 0.28358540f, 0.15341872f, 0.26685798f, 0.27070564f, -0.10203355f, 
    -0.12973824f, -0.33326298f, -0.04556283f, 0.20015654f, 0.02215584f, -0.17352352f, -0.18644263f, -0.45011845f, 
    0.03454513f, -0.00931215f, -0.42261654f, -0.05050312f, -0.06350277f, 0.11923885f, -0.22475955f, -0.33248082f, 
    -0.43401679f, 0.14176080f, 0.17998619f, 0.07227207f, 0.18678653f, 0.04794985f, -0.12423187f, -0.01268513f, 
    0.37349784f, 0.15982142f, 0.02336841f, -0.18028399f, -0.15309222f, 0.03591482f, -0.01364648f, 0.03575104f, 
    -0.05603447f, -0.00100453f, -0.46640238f, 0.05780537f, -0.07982418f, 0.04661082f, -0.06400882f, -0.06336557f, 
    0.17842673f, -0.00884994f, 0.45813090f, 0.28395024f, -0.04901457f, 0.11978681f, -0.05663633f, 0.07147197f, 
    0.12686503f, 0.09100169f, -0.40707853f, 0.07905844f, 0.40043810f, -0.16385922f, 0.21940663f, -0.35551098f, 
    0.00363270f, -0.00026217f, 0.21456584f, -0.61747259f, -0.43586323f, 0.26067579f, -0.02530645f, 0.03998705f, 
    -0.02135248f, -0.07041779f, 0.14955568f, 0.00809648f, 0.08318160f, 0.27320325f, -0.35261181f, 0.29121137f, 
    0.03704804f, -0.08466570f, 0.04187209f, -0.17370641f, 0.11664523f, -0.12420981f, 0.07998575f, 0.07138523f, 
    0.32187566f, 0.05893398f, 0.05159844f, 0.14482330f, 0.06504420f, -0.10579788f, 0.19599658f, 0.00233206f, 
    -0.02233794f, 0.08953123f, 0.12286511f, -0.24666497f, 0.17323935f, 0.00107097f, 0.12727396f, 0.28426751f, 
    0.22418573f, -0.02239043f, -0.55400276f, -0.28346637f, -0.31851637f, 0.23184422f, 0.08268435f, 0.08944803f, 
    -0.21811973f, 0.10899249f, -0.04491773f, 0.04445127f, 0.11607080f, -0.03836225f, 0.04405356f, -0.12100907f, 
    0.02494770f, -0.40557718f, -0.09296373f, -0.03248801f, 0.01426076f, -0.13057914f, 0.09543422f, 0.21396184f, 
    0.11689951f, -0.18585573f, 0.07959461f, 0.35523564f, 0.21394236f, -0.21757764f, -0.33927476f, -0.10579471f, 
    -0.00959293f, 0.00944586f, -0.10449338f, -0.43193528f, -0.46650264f, 0.07881341f, -0.34133452f, -0.05504895f, 
    -0.22419764f, -0.04532741f, 0.01983642f, -0.02311439f, -0.48846611f, -0.08258782f, 0.15055004f, 0.07886126f, 
    0.21406981f, 0.09403591f, 0.06877572f, 0.02039618f, -0.05739813f, -0.19890496f, 0.14760165f, 0.07424044f, 
    -0.13296627f, 0.06719686f, -0.26567906f, -0.01872841f, -0.11772793f, -0.06288137f, -0.43095052f, -0.36705965f, 
    -0.22292414f, 0.14628012f, -0.07935004f, -0.15250015f, 0.00704633f, 0.13279487f, -0.07330998f, 0.32061958f, 
    0.13137256f, -0.05398084f, 0.12353586f, 0.09644368f, 0.04773184f, -0.02138951f, 0.12359437f, 0.16799152f, 
    0.08772846f, -0.04051250f, -0.11305545f, -0.03265256f, 0.08306119f, -0.01075887f, 0.16760942f, -0.05431655f, 
    0.08650896f, -0.23902656f, 0.09813096f, 0.11717309f, -0.02023487f, -0.04374993f, -0.24613342f, 0.23094451f, 
    -0.17210375f, -0.10811964f, 0.88221508f, 0.15010442f, 0.03917200f, -0.05104348f, -0.00866637f, -0.13127753f, 
    0.04806797f, -0.09174218f, -0.04518556f, -0.24169399f, 0.11542677f, -0.13942014f, -0.09151244f, 0.00533981f, 
    0.04614650f, 0.02244455f, -0.02707133f, 0.25311017f, -0.37932050f, 0.26805151f, -0.10464842f, 0.06710696f, 
    -0.03562441f, 0.17423567f, -0.11187075f, 0.32176617f, 0.13546489f, 0.48563609f, -0.08289610f, -0.24432313f, 
    0.01096327f, 0.06507409f, 0.18279894f, -0.07363249f, -0.11385809f, 0.18616486f, 0.13191171f, -0.00340620f, 
    -0.36593229f, -0.07007728f, -0.02272111f, -0.06971703f, -0.00647474f, -0.01985085f, 0.09284175f, 0.13629662f, 
    0.05721635f, 0.14023401f, -0.08151393f, -0.17487079f, -0.18977064f, 0.16322647f, -0.03315116f, 0.07870266f, 
    -0.02640763f, 0.19028082f, -0.15287969f, -0.06358999f, 0.07135466f, -0.34089407f, 0.11342347f, 0.30463216f, 
    -0.11741021f, 0.59067255f, -0.00434509f, -0.24960026f, 0.02597781f, -0.03948403f, -0.14937088f, -0.02624333f, 
    -0.04312606f, -0.02402616f, -0.04170952f, 0.02930065f, 0.31812149f, -0.10933661f, 0.09503884f, -0.04213441f, 
    -0.13317783f, -0.13202427f, -0.11780030f, 0.03688129f, 0.13108586f, 0.26906565f, 0.15063520f, 0.12984923f, 
    -0.11873176f, 0.01138016f, -0.13354662f, -0.26263589f, 0.13987322f, -0.34349865f, -0.07317712f, -0.29972869f, 
    0.13816251f, -0.11218308f, 0.00694679f, -0.08712365f, -0.02198126f, 0.22477753f, 0.20574631f, -0.24955402f, 
    0.00135430f, 0.09739868f, -0.10773534f, -0.02718892f, -0.02031138f, 0.07432332f, -0.25817439f, 0.37738761f, 
    -0.20430894f, -0.04159577f, -0.16987258f, -0.20128140f, 0.11267453f, 0.09139991f, 0.05234476f, 0.18113045f, 
    -0.25322646f, -0.19044812f, -0.03832892f, 0.08509497f, -0.01864881f, 0.15675011f, 0.02650551f, 0.10648441f, 
    -0.17749937f, -0.16842629f, 0.29041249f, -0.08566669f, 0.21586135f, 0.22027120f, 0.02297449f, 0.05868260f, 
    0.01282575f, 0.06553984f, 0.31253159f, -0.08475202f, 0.08181795f, -0.13838018f, -0.21897183f, 0.10524319f, 
    0.11606751f, 0.02900383f, 0.45732450f, 0.25085720f, 0.28800520f, -0.12616488f, 0.21971513f, -0.17962368f, 
    0.12305173f, 0.16055529f, 0.08485521f, -0.65752959f, 0.28854373f, -0.25698307f, 0.10551123f, -0.01975033f, 
    -0.01515821f, -0.07951985f, -0.23661469f, -0.09216984f, 0.06108849f, 0.06454587f, 0.32520640f, 0.00034654f, 
    -0.09203845f, -0.00270268f, -0.02280105f, 0.00854207f, -0.10462207f, 0.24266951f, 0.07918160f, 0.12849310f, 
    0.06535161f, -0.01854326f, -0.02207825f, 0.07351259f, -0.03339754f, 0.08105585f, -0.10542573f, -0.22923477f, 
    0.06824045f, -0.11834183f, -0.04304056f, 0.13759094f, 0.07803765f, -0.04646310f, -0.10337108f, 0.23148683f, 
    -0.21385634f, -0.04808466f, 0.16784820f, -0.15179855f, 0.14461330f, 0.00876723f, -0.19262771f, -0.05046461f, 
    -0.69646966f, 0.28166968f, 0.58961922f, 0.15643628f, -0.13467622f, -0.34757802f, -0.18549243f, -0.22427221f, 
    0.04369870f, -0.07674607f, -0.36208674f, 0.00832961f, 0.01734222f, -0.01167193f, -0.13472807f, 0.03408941f, 
    -0.11648007f, 0.06449260f, 0.09780005f, 0.46352160f, 0.12388211f, -0.28759786f, -0.02360875f, -0.09472154f, 
    0.01448755f, 0.03652318f, 0.15789217f, -0.25559130f, 0.54731423f, -0.18115534f, 0.02670348f, 0.02466298f, 
    0.00314386f, -0.05613015f, -0.00909810f, 0.16450624f, 0.29704738f, -0.40029100f, -0.09130745f, -0.10450500f, 
    0.02533382f, -0.08421711f, 0.03891218f, 0.05751589f, 0.04575445f, -0.11433114f, 0.56692499f, 0.40160671f, 
    -0.14006765f, 0.03446986f, -0.16647889f, 0.10783608f, 0.09156211f, -0.03858371f, -0.14942589f, 0.10566529f, 
    -0.15557377f, -0.02292078f, -0.11798392f, -0.13977571f, 0.15016139f, 0.14229135f, 0.00384520f, 0.13761108f, 
    -0.06419445f, -0.18037744f, 0.04544555f, -0.11281379f, -0.03416830f, 0.03227825f, -0.00649155f, -0.04113269f, 
    0.09774449f, 0.27851388f, -0.28579503f, -0.16947894f, 0.20242298f, -0.10729508f, -0.01234611f, 0.04620135f, 
    0.22592236f, 0.06213693f, -0.45181197f, 0.10216436f, 0.34118441f, 0.02431154f, -0.10493163f, 0.03679352f, 
    0.12783110f, -0.01600420f, 0.16063647f, 0.20809576f, 0.44051382f, -0.17592375f, 0.02016972f, 0.03496296f, 
    0.18869470f, 0.18322016f, 0.08047508f, 0.06309793f, -0.00866638f, -0.09461667f, -0.14799406f, -0.00483070f, 
    -0.08474648f, 0.01757787f, -0.09307089f, 0.10851377f, -0.00100224f, -0.35347834f, -0.42037749f, 0.03962876f, 
    0.13260065f, 0.01538042f, -0.20841956f, -0.10242835f, 0.08046342f, 0.11526615f, 0.32735154f, 0.36348286f, 
    -0.04670906f, -0.19435379f, -0.09570936f, -0.11113084f, -0.12464241f, -0.06153542f, 0.20612144f, 0.21847075f, 
    0.16141728f, -0.05433001f, 0.06767999f, -0.15006280f, 0.07378452f, -0.07985464f, -0.19317013f, -0.20787053f, 
    -0.14630900f, -0.77508873f, -0.27757603f, -0.10151875f, 0.10061492f, 0.08793227f, 0.18289275f, 0.03665658f, 
    -0.83449399f, 0.28549701f, 0.31267869f, 0.00095670f, -0.00699817f, 0.09564258f, -0.14983195f, -0.01920940f, 
    -0.18887058f, 0.14777683f, 0.22868370f, 0.37536165f, 0.13055396f, 0.16617647f, 0.08684024f, 0.10620625f, 
    -0.06590471f, -0.13811335f, -0.17091490f, 0.16077234f, -0.55693293f, -0.38379127f, -0.25307149f, -0.11502599f, 
    0.12796997f, -0.03693785f, 0.02205211f, -0.32122907f, 0.19217134f, 0.15589595f, -0.21210831f, -0.17822766f, 
    0.01004962f, 0.21744055f, 0.12420887f, 0.01027374f, 0.52401912f, -0.47135764f, -0.19252346f, 0.12218975f, 
    -0.04485760f, 0.14724159f, 0.17388134f, -0.00701996f, -0.01657099f, 0.28125098f, 0.38815919f, 0.38580987f, 
    -0.06723775f, -0.03721385f, -0.09579934f, 0.01857475f, -0.01442362f, 0.04421683f, -0.04057396f, -0.89307404f, 
    -0.32448193f, -0.04341643f, -0.09742092f, -0.08751222f, 0.05671601f, -0.00845153f, -0.01999027f, 0.20389795f, 
    0.01112155f, -0.27567211f, -0.01637797f, -0.00971693f, -0.04687871f, -0.11415517f, -0.01415451f, 0.08250223f, 
    -0.04720029f, -0.06489880f, -0.00941864f, 0.04368114f, -0.07521568f, -0.02788786f, -0.00253743f, -0.04874112f, 
    -0.08324479f, -0.01610579f, 0.04140048f, -0.08775035f, -0.03848307f, 0.06703933f, 0.02080376f, -0.04059644f, 
    0.02996079f, -0.01213336f, -0.01835569f, -0.05248262f, -0.07437664f, -0.08629917f, -0.01965385f, -0.08319699f, 
    0.04840576f, -0.07167730f, -0.06783839f, 0.07938606f, -0.05016259f, 0.00395931f, -0.09455059f, -0.07085071f, 
    0.03098872f, -0.06988626f, 0.00399912f, -0.03463512f, -0.00964432f, 0.00079548f, 0.01013981f, 0.03458443f, 
    0.01865664f, -0.02621551f, 0.03445597f, 0.01361153f, 0.06798861f, 0.01426242f, 0.03397413f, -0.04919090f, 
    0.05738074f, 0.07021144f, -0.01825839f, -0.00712193f, 0.07367043f, -0.02343504f, -0.05804840f, -0.05781449f, 
    -0.04533437f, -0.06607372f, -0.02226311f, -0.00558300f, 0.07420629f, -0.06705973f, -0.07551461f, -0.00245441f, 
    -0.09874333f, -0.08166220f, -0.03634321f, -0.00831571f, -0.08004718f, -0.00423576f, -0.05013645f, 0.01082712f, 
    0.01674863f, 0.02272390f, -0.03454931f, 0.00638836f, -0.09448149f, -0.00813743f, 0.04990515f, -0.04662150f, 
    0.01609547f, -0.02162071f, 0.00858111f, -0.04067142f, -0.00497863f, -0.05061423f, -0.06136946f, -0.02008314f, 
    0.03522146f, -0.05282305f, -0.03813097f, -0.00371925f, 0.05776654f, 0.03359431f, -0.03947746f, -0.06816256f, 
    -0.04247518f, -0.09562479f, -0.06781588f, -0.01872745f, -0.03242978f, 0.00427517f, -0.04552162f, -0.05493511f, 
    0.06653348f, -0.06892034f, -0.00282321f, 0.04355564f, -0.02521953f, 0.05138298f, 0.01061473f, 0.04747605f, 
    -0.06219137f, -0.01047137f, -0.06836062f, -0.08028296f, -0.02393291f, 0.02697725f, -0.00219137f, -0.00064356f, 
    0.03876293f, -0.01036238f, -0.04631264f, -0.03584145f, 0.03180689f, -0.06254436f, 0.00888986f, 0.03671663f, 
    0.05207930f, -0.09601697f, -0.00594033f, -0.05736423f, 0.04578007f, -0.08588969f, -0.08800069f, -0.02380683f, 
    0.06205101f, -0.05190812f, 0.06102222f, 0.04586837f, -0.05003894f, 0.02822165f, -0.06064730f, 0.03450834f, 
    0.11750091f, -0.17829859f, -0.26932776f, 0.16106540f, 0.01121702f, 0.29809213f, 0.01464768f, -0.04937720f, 
    0.10284606f, -0.14757223f, 0.26783115f, -0.00641791f, -0.40647051f, 0.14752342f, -0.08447687f, 0.08608674f, 
    0.10939541f, 0.03718659f, -0.15811175f, -0.02127824f, 0.65824854f, -0.22326253f, 0.09786128f, -0.26795393f, 
    -0.13771546f, 0.00379856f, 0.14834800f, -0.07375106f, -0.05493972f, -0.18316601f, 0.09657818f, 0.04312718f, 
    0.03989758f, -0.14209849f, -0.07932968f, -0.15076649f, -0.29203469f, 0.14941312f, 0.28412563f, -0.22397695f, 
    0.16754283f, 0.07911183f, -0.05138391f, -0.15395519f, 0.16156133f, 0.44985881f, 0.00073141f, 0.12371014f, 
    0.26074380f, -0.07543022f, -0.07452136f, 0.19303879f, 0.01767755f, 0.11695559f, 0.08944552f, 0.13424627f, 
    -0.03557719f, 0.05417839f, -0.23738296f, 0.05145293f, 0.05978184f, 0.01193429f, 0.07131192f, -0.21619524f, 
    -0.01215970f, -0.09378728f, -0.15710174f, -0.13515146f, 0.05878528f, 0.08559314f, 0.02093206f, 0.19512601f, 
    0.42948094f, 0.00199633f, 0.19174153f, -0.06680905f, -0.03797168f, -0.16737992f, 0.05460430f, 0.29486153f, 
    0.26478833f, -0.09957725f, -0.07558890f, 0.41604966f, 0.13072644f, -0.03238858f, -0.13682757f, 0.18581229f, 
    0.03670840f, 0.12838323f, -0.15779378f, -0.03915583f, -0.06613825f, -0.33287635f, -0.16083871f, -0.18644209f, 
    -0.04503277f, 0.08347569f, 0.04740794f, -0.23104632f, 0.10762542f, -0.15350085f, -0.19525616f, -0.05960631f, 
    -0.11312535f, -0.17128508f, -0.16532925f, 0.11216079f, -0.33147198f, 0.59859747f, 0.57568568f, -0.01789483f, 
    -0.00340934f, -0.03647885f, 0.01029494f, -0.20467424f, 0.01012184f, -0.08064017f, 0.17559671f, 0.31480032f, 
    0.01432333f, -0.13685727f, -0.25304237f, 0.01139410f, 0.03265679f, 0.02674057f, -0.59477848f, -0.23666312f, 
    -0.30800027f, -0.12976743f, 0.11227778f, -0.11066601f, -0.02158118f, 0.03090485f, 0.01842985f, -0.18046844f, 
    0.44070560f, 0.27652627f, 0.19345787f, 0.06172848f, 0.06350134f, 0.11701582f, 0.17492336f, 0.15327969f, 
    0.02249291f, -0.17461689f, 0.24019974f, -0.03196573f, 0.16248915f, -0.10528459f, 0.04879024f, 0.18159714f, 
    -0.23281622f, -0.01725741f, -0.07132415f, 0.18692625f, -0.15560880f, 0.12004655f, -0.02003432f, 0.10039657f, 
    0.16520385f, 0.18313746f, -0.01554336f, 0.28746283f, -0.04186378f, -0.25247288f, 0.34578499f, -0.47079122f, 
    0.02319041f, -0.00009744f, 0.11446304f, 0.15413836f, 0.03064152f, -0.31946626f, 0.20624809f, -0.01196558f, 
    -0.14628318f, 0.07463706f, 0.14884123f, -0.05704533f, 0.32923508f, 0.14937568f, 0.01424034f, -0.08538949f, 
    0.05988067f, -0.07895178f, 0.01719447f, 0.07911088f, -0.03512664f, -0.45002666f, -0.14983259f, 0.07386671f, 
    0.03451673f, 0.14161976f, -0.20560239f, -0.25910771f, 0.07468305f, -0.09559792f, 0.01212131f, 0.00510668f, 
    0.20682511f, -0.05145995f, -0.08381734f, 0.08422814f, -0.22780421f, 0.02581073f, 0.07025052f, -0.06549219f, 
    -0.02644183f, -0.22290197f, -0.11773387f, 0.00962643f, 0.20276241f, -0.08742732f, 0.08998650f, -0.14272057f, 
    -0.20090809f, 0.23391257f, 0.58348864f, -0.13325447f, 0.09472524f, -0.11237700f, 0.10858686f, 0.18630382f, 
    0.22296706f, -0.18787500f, -0.03081082f, -0.01498061f, 0.09902631f, 0.19196966f, -0.05685326f, 0.02882012f, 
    0.20132402f, 0.28200853f, -0.32451317f, -0.03974179f, 0.25655112f, 0.00593860f, 0.04168962f, -0.16719203f, 
    0.01596165f, 0.05152675f, 0.02595482f, -0.03366790f, 0.18603389f, -0.35373479f, 0.10391744f, -0.27314210f, 
    -0.15003322f, -0.25362438f, -0.30138838f, -0.02637285f, -0.25376621f, -0.14182988f, 0.09866590f, 0.14603519f, 
    0.11722565f, -0.05685984f, -0.12663248f, -0.22333486f, 0.43153962f, 0.21981579f, -0.02051789f, 0.01763582f, 
    -0.10921362f, -0.29471096f, 0.03575428f, 0.05618606f, -0.07641216f, 0.21552023f, 0.58068967f, -0.03564614f, 
    0.24273448f, 0.05554556f, 0.11547727f, -0.08110016f, -0.17016660f, -0.01754343f, 0.08529121f, -0.00611135f, 
    0.35311875f, 0.04288174f, -0.07983173f, -0.04902146f, 0.04584263f, -0.23007745f, 0.16096437f, -0.25999889f, 
    -0.12355198f, -0.05364979f, -0.19938874f, 0.10228021f, -0.01660523f, 0.22572672f, 0.10972001f, 0.03394119f, 
    0.13654564f, 0.05219976f, -0.02998823f, 0.05920924f, -0.10233381f, 0.09830282f, -0.07868664f, 0.07962321f, 
    0.08641769f, 0.50586164f, -0.17854716f, -0.35227466f, -0.21223104f, -0.02957951f, -0.01691818f, 0.00325198f, 
    0.14445062f, -0.43286636f, 0.09536533f, 0.33502033f, 0.23203574f, 0.11236652f, 0.05091197f, 0.02783870f, 
    0.05737672f, 0.11118231f, -0.04474725f, 0.02776041f, -0.32002583f, 0.04994696f, -0.30452740f, 0.30190623f, 
    -0.01938820f, 0.13322432f, 0.08706030f, -0.04367286f, 0.09574634f, 0.44000465f, -0.13205844f, 0.34515798f, 
    0.17201108f, -0.11286563f, 0.09438180f, -0.05418112f, 0.05229945f, 0.12759098f, 0.00486953f, 0.04704954f, 
    0.63389152f, -0.03461222f, -0.01926420f, 0.09428468f, 0.01837833f, -0.11472903f, -0.19297951f, 0.17415954f, 
    -0.18214440f, -0.16753128f, -0.02307836f, -0.28932339f, -0.26689449f, 0.09317117f, 0.17218600f, 0.08114883f, 
    -0.06627219f, 0.16699116f, -0.56555480f, 0.52281785f, 0.06309601f, 0.11396172f, 0.10031840f, 0.39758712f, 
    -0.10378702f, 0.07280079f, -0.01346142f, 0.15738328f, 0.01548892f, -0.19677933f, 0.22905347f, 0.31982988f, 
    0.24318095f, -0.00372857f, 0.00667142f, -0.13164859f, 0.00194321f, -0.18514307f, 0.18035997f, -0.27603421f, 
    0.08133189f, 0.07462023f, -0.01208514f, 0.06195020f, -0.05003156f, -0.12556908f, -0.00115933f, -0.12208699f, 
    -0.05037512f, -0.22524272f, -0.06257314f, -0.21343590f, 0.01077973f, 0.22958069f, -0.01805390f, -0.25283492f, 
    -0.05371984f, 0.06932618f, -0.01186102f, -0.02025631f, 0.00497202f, -0.13718635f, 0.00165391f, 0.40934134f, 
    -0.08357228f, 0.12247619f, -0.04349471f, 0.13501115f, 0.12362287f, -0.27692509f, -0.40788293f, 0.08237386f, 
    -0.15103169f, 0.16206858f, -0.15832593f, -0.30661216f, -0.05559174f, 0.12788761f, 0.10627398f, -0.30454403f, 
    -0.09259120f, 0.33655176f, 0.01932925f, 0.03752375f, -0.08194724f, 0.10647314f, 0.15449126f, 0.04181805f, 
    -0.05478321f, -0.06205608f, 0.06402951f, 0.07806969f, 0.02274924f, 0.02421784f, 0.03811771f, 0.25574270f, 
    0.39541864f, 0.23163152f, -0.07050573f, 0.14324439f, 0.01818159f, 0.31003720f, -0.17701317f, -0.15220058f, 
    -0.16582610f, 0.05572738f, -0.51251405f, -0.16928951f, 0.37446970f, -0.00315385f, 0.15143748f, -0.01310240f, 
    0.06906517f, -0.07707013f, -0.07487291f, 0.13842939f, -0.13020547f, 0.09933781f, 0.33244848f, 0.31327790f, 
    0.42843750f, 0.19827259f, 0.12313515f, 0.22288738f, -0.07943509f, -0.13728423f, 0.28054574f, 0.16029231f, 
    0.11960614f, 0.26019138f, -0.16710767f, 0.00777389f, 0.07711366f, -0.09079644f, 0.34906784f, 0.15330242f, 
    -0.14232138f, 0.03950955f, -0.02592549f, 0.11832134f, 0.21478477f, 0.15075977f, -0.01315360f, -0.04582713f, 
    0.06361458f, 0.04366988f, -0.04970208f, 0.06884084f, -0.04542634f, 0.15454881f, -0.09423516f, 0.00994303f, 
    -0.05225073f, -0.07954802f, 0.11516576f, 0.05516450f, -0.00880704f, 0.11094517f, -0.19148695f, 0.08287623f, 
    0.38375291f, 0.01342955f, 0.28412807f, -0.13187186f, 0.11601047f, 0.26286972f, 0.03979604f, 0.04868698f, 
    -0.02173412f, -0.16972311f, 0.07328718f, 0.12586847f, 0.01675736f, -0.07654637f, -0.37213463f, -0.16566283f, 
    -0.21328875f, -0.15959227f, 0.05914989f, 0.20178743f, -0.06230415f, 0.21913818f, 0.13525425f, -0.01439437f, 
    -0.24445826f, 0.03925719f, -0.27110407f, -0.11521539f, 0.12940706f, -0.01137741f, 0.01986838f, -0.01377578f, 
    -0.12477166f, -0.07958735f, -0.22344616f, -0.50794452f, 0.04987836f, -0.27486488f, -0.07185586f, -0.05797993f, 
    -0.05368963f, -0.25798967f, -0.12570006f, -0.16870260f, -0.14080249f, 0.33269930f, -0.00362456f, -0.25079662f, 
    -0.15756087f, 0.12839395f, 0.07379773f, 0.15036191f, 0.06859462f, 0.15296945f, 0.19751704f, -0.13004988f, 
    0.34304389f, 0.20037818f, 0.19565082f, 0.08919317f, -0.19550447f, 0.04911255f, 0.15185533f, -0.02245831f, 
    -0.07409622f, 0.06026198f, -0.06121895f, -0.21527435f, -0.07514349f, 0.18181854f, 0.10656898f, 0.15042509f, 
    0.02973437f, -0.05953214f, -0.21769956f, -0.34474742f, -0.16219589f, -0.24616256f, 0.32655054f, 0.06058137f, 
    0.13469715f, 0.00562220f, 0.03455345f, 0.04674896f, 0.01362757f, 0.25798351f, 0.12786427f, 0.13659552f, 
    0.04448380f, 0.14977442f, -0.03526235f, -0.44220614f, -0.13953757f, -0.05006839f, -0.08042333f, -0.18924898f, 
    0.00818932f, -0.21299668f, 0.10274534f, 0.34616131f, -0.51734436f, -0.14914033f, -0.00935700f, 0.20175442f, 
    -0.14586441f, 0.21199648f, 0.24711797f, 0.20172612f, 0.02123453f, -0.09970687f, 0.04838183f, 0.04265501f, 
    0.05907822f, 0.01265006f, 0.24552220f, 0.16937740f, 0.11108839f, -0.43565351f, 0.12040492f, 0.11343876f, 
    0.03569371f, 0.04915464f, -0.09033232f, 0.03442252f, 0.06722712f, 0.00941069f, -0.12699725f, -0.26168838f, 
    -0.09365682f, 0.13022473f, 0.21100470f, -0.06035966f, -0.00272254f, 0.05963550f, 0.05400945f, -0.16967031f, 
    0.06202795f, -0.11282274f, 0.08903043f, 0.03989871f, -0.19719858f, -0.00986165f, 0.13204797f, 0.08581495f, 
    0.10078990f, -0.14890884f, 0.36576089f, 0.06329483f, 0.05857117f, -0.03334051f, 0.21950164f, 0.17099191f, 
    0.12091110f, 0.06214932f, -0.09031771f, 0.15051906f, -0.11563805f, -0.06665229f, -0.14982258f, 0.08915985f, 
    -0.04425655f, 0.09707924f, -0.32024020f, -0.20785609f, -0.05504071f, 0.07210577f, -0.05302317f, -0.05836055f, 
    0.05953079f, 0.01341438f, 0.09242744f, -0.30595452f, -0.11422536f, -0.26547408f, -0.15183076f, -0.05996609f, 
    0.02557111f, -0.05149974f, 0.03775478f, -0.18584144f, -0.07582828f, 0.40378791f, 0.29677683f, -0.03818440f, 
    -0.01134078f, -0.01062022f, -0.08865204f, 0.09345207f, -0.03128106f, -0.41292548f, -0.61568439f, -0.14081068f, 
    0.04030042f, -0.01377038f, -0.09597224f, 0.03030059f, 0.05180640f, 0.09695461f, 0.06674144f, -0.32053739f, 
    -0.15381427f, -0.05709980f, 0.07635742f, 0.22055058f, -0.05535973f, -0.08921938f, -0.00086712f, 0.00370174f, 
    0.37841398f, 0.46200091f, 0.08016459f, 0.02801874f, 0.08645050f, 0.09200200f, 0.12137509f, -0.06284828f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.06534678f, 0.29443452f, 0.07072701f, 0.12195645f, 0.01889574f, 0.04292735f, 0.31222031f, -0.03811919f, 
    -0.12886669f, -0.12979054f, -0.02938682f, 0.05584019f, 0.24768043f, 0.06429936f, 0.16133989f, 0.31462374f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01816043f, -0.04053614f, -0.05943659f, -0.10183051f, 0.08080509f, -0.02804938f, 0.01353708f, -0.21026123f, 
    -0.02692631f, -0.06010130f, -0.19696119f, 0.11625966f, -0.14589500f, 0.02936095f, -0.16259903f, -0.04389077f, 
    0.11479124f, -0.52461398f, 0.48866749f, 0.28175789f, 0.18724164f, 0.27976847f, -0.33024266f, -0.92777854f, 
    0.29812187f, -0.19769791f, 0.04879100f, 0.00737396f, 0.51196867f, 0.37336951f, -0.07595542f, 0.05395405f, 
    -0.11739802f, -0.12399714f, -0.25213033f, 0.21717092f, -0.04971313f, -0.06180829f, 0.21520559f, -0.13325067f, 
    0.21235244f, -0.06050971f, 0.02954814f, -0.22974986f, -0.16147181f, -0.00929832f, -0.20539248f, 0.13276526f, 
    0.09630710f, -0.30890965f, 0.22941479f, 0.00290782f, 0.12982216f, 0.48338163f, -0.93678415f, -0.04274423f, 
    -0.17102177f, 0.34791151f, 0.14393756f, -0.11820646f, 0.00537804f, 0.40846324f, -0.12978740f, -0.24218056f, 
    0.10774782f, 0.23831253f, -0.34246138f, 0.39712876f, -0.21633834f, -0.20965885f, -0.25923118f, 0.38619864f, 
    0.42535657f, 0.42104957f, -0.13014874f, -0.13549140f, -0.15949678f, 0.14786942f, 0.19797058f, 0.16229679f, 
    0.10222717f, 0.15518284f, -0.25596055f, 0.35471869f, 0.16357930f, -0.19482544f, 0.19422732f, -0.50507075f, 
    0.41599748f, -0.11100733f, -0.01201413f, 0.36499694f, 0.34279376f, 0.14652450f, 0.21136726f, -0.28427520f, 
    -0.05740747f, 0.30918247f, -0.25208941f, 0.67063046f, -0.06181702f, -0.61737245f, -0.18756554f, -0.20168667f, 
    0.24277949f, 0.39076203f, 0.14427605f, -0.12703036f, 0.49274859f, 0.08771769f, 0.36479390f, -0.07009841f, 
    0.07824877f, -0.30780089f, 0.35629475f, -0.20669769f, 0.11688933f, 0.51303524f, 0.18425053f, -0.18406254f, 
    -0.29217079f, -0.38340214f, 0.23896605f, 0.38903081f, -0.24691534f, 0.20429228f, -0.17844315f, 0.28216386f, 
    -0.22400518f, 0.46125966f, -0.11187943f, 0.16186108f, -0.09645149f, -0.15032052f, -0.44566467f, 0.00962546f, 
    -0.48689461f, 0.05458998f, 0.12298466f, 0.40429690f, -0.20061973f, -0.17863289f, 0.22403954f, 0.13473721f, 
    0.06633145f, -0.18101846f, 0.45676813f, 0.05261094f, 0.09778458f, 0.08492585f, -0.20477532f, 0.41636646f, 
    -0.67931652f, 0.25860444f, 0.03407934f, 0.03846880f, -0.30657491f, 0.39167744f, -0.16399796f, 0.01994495f, 
    0.04032167f, -0.29278639f, 0.31843105f, 0.46789172f, 0.08774748f, -0.04314299f, 0.32968456f, -0.29584551f, 
    0.25715262f, 0.43833908f, -0.17732835f, -0.03260731f, -0.17474768f, 0.21241841f, 0.07983989f, -0.48664209f, 
    -0.14483020f, 0.51104671f, 0.24698412f, -0.08910429f, 0.18827814f, 0.17723304f, 0.21956716f, -0.40351695f, 
    -0.40359616f, 0.06669163f, -0.24296506f, 0.47111884f, 0.25399375f, -0.27382085f, -0.01840716f, -0.21095651f, 
    0.21696448f, -0.09116711f, 0.59627682f, -0.31502947f, -0.19368148f, -0.22170469f, 0.13592467f, 0.03732712f, 
    -0.30992267f, -0.38928565f, -0.16528496f, -0.07053693f, 0.14538531f, -0.01971642f, 0.04656953f, 0.53240651f, 
    -0.24260797f, -0.67898792f, -0.08265083f, -0.11244227f, -0.19320326f, 0.46790466f, -0.00299168f, -0.05727104f, 
    -0.53214532f, 0.59039819f, -0.23382732f, 0.16014174f, -0.18248390f, 0.24224783f, 0.04843214f, -0.01204409f, 
    -0.10647115f, 0.39146474f, 0.27574891f, 0.63845581f, -0.12254313f, 0.26565206f, 0.03956365f, -0.26753986f, 
    -0.15965940f, -0.55897826f, -0.16165544f, -0.25049099f, 0.29968923f, -0.16266297f, -0.13241145f, 0.28995556f, 
    0.10035402f, -0.03164729f, -0.14672786f, -0.01220363f, 0.22227392f, -0.29088220f, 0.12669562f, 0.16234864f, 
    0.30676389f, 0.37596601f, -0.13118085f, 0.08968668f, -0.09468271f, -0.09847866f, 0.39792171f, -0.10160602f, 
    0.11340892f, -0.36939612f, 0.07256851f, 0.13759461f, -0.01626709f, -0.13745171f, -0.14247040f, -0.05570453f, 
    -0.29798469f, -0.00602827f, -0.10218362f, -0.09427019f, -0.38035303f, 0.56410295f, 0.23530710f, 0.01133480f, 
    0.24360952f, 0.15295981f, 0.46381640f, -0.23476306f, 0.14342450f, 0.20528331f, 0.01314121f, 0.15990222f, 
    -0.01863312f, 0.51173490f, 0.15979941f, 0.16299097f, 0.40756753f, -0.21019545f, -0.11245650f, -0.39574778f, 
    0.05591828f, 0.37098306f, 0.11959886f, 0.49305978f, 0.07950699f, -0.14623469f, 0.21990065f, 0.12718354f, 
    0.24825129f, -0.70018411f, -0.10516991f, -0.34174702f, 0.09306072f, -0.01221595f, 0.01933573f, 0.05079255f, 
    0.19494258f, 0.37251997f, -0.25091401f, 0.56648040f, -0.08726233f, -0.33578259f, 0.04715664f, 0.00823148f, 
    -0.64405268f, 0.29507312f, 0.12974606f, -0.20745362f, 0.00368041f, 0.09118927f, 0.07762648f, 0.33608484f, 
    -0.03585161f, 0.10583446f, 0.15359236f, 0.24917862f, -0.09902818f, -0.67158413f, -0.57956624f, -0.12310150f, 
    0.70898420f, 0.07753590f, 0.12010392f, 0.37677947f, 0.42693111f, 0.32286105f, -0.91967165f, -0.08524146f, 
    0.09566159f, -0.23843111f, 0.14724998f, 0.08226158f, 0.19291602f, 0.16974436f, 0.50402302f, 0.70515633f, 
    -0.02302230f, 0.28605601f, -0.09337961f, 0.35985136f, -0.15437569f, 0.29339460f, -0.23886250f, -0.28930253f, 
    0.19086692f, 0.15130326f, 0.41684443f, -0.82293773f, 0.22818331f, 0.30395898f, 0.32969886f, 0.14178485f, 
    0.00316760f, -0.14513357f, -0.11786451f, 0.17181011f, -0.10516985f, -0.06482860f, -0.03441827f, -0.25258973f, 
    0.18355620f, -0.59227216f, 0.21304016f, 0.33633050f, 0.12565877f, 0.10278112f, -0.12593381f, -0.30464166f, 
    0.13354297f, 0.19222149f, 0.10440856f, -0.03921834f, -0.38261342f, 0.36728254f, 0.09848475f, 0.14853074f, 
    -0.11042010f, -0.47559473f, 0.07080358f, 0.14433214f, 0.05108431f, 0.05567124f, 0.18623492f, -0.34329829f, 
    0.76980323f, -0.31081840f, -0.23637463f, 0.35931858f, 0.16870508f, 0.02563860f, -0.33301839f, 0.15133137f, 
    -0.05248263f, -0.05790775f, 0.18660076f, 0.04413589f, 0.20334697f, -0.01009983f, 0.00029824f, -0.13514590f, 
    -0.13801256f, 0.12629095f, 0.22738847f, -0.23534687f, -0.18873769f, -0.10907415f, -0.10797700f, -0.00796246f, 
    -0.08682224f, -0.69361556f, -0.19977929f, -0.00473079f, -0.21597631f, 0.31884670f, -0.69202751f, 0.39387020f, 
    0.26858568f, 0.56286353f, -0.01357437f, 0.10963186f, -0.63844478f, 0.32611150f, 0.29104310f, -0.20427796f, 
    -0.00980332f, 0.61971945f, 0.26069620f, 0.00018695f, -0.11842790f, -0.29886144f, -0.26440558f, -0.52157474f, 
    0.06580993f, 0.05578536f, -0.09788372f, 0.32289714f, 0.61685401f, -0.18763508f, -0.00392194f, -0.52566415f, 
    0.08018348f, -0.10578948f, -0.31757665f, 0.64167094f, -0.19791937f, -0.90869552f, -0.01073298f, 0.23177099f, 
    -0.90528637f, 0.04594212f, 0.21577892f, 0.08648074f, -0.43117279f, 0.50249654f, 0.20389988f, 0.52999645f, 
    0.23594126f, 0.02142661f, 0.24406956f, 0.14769407f, -0.06677157f, -0.65333480f, -0.92716610f, 0.30713257f, 
    -0.32015225f, -0.28491315f, 0.15486111f, 0.01642241f, -0.23160426f, 0.43049163f, 0.23078266f, 0.24260832f, 
    -0.22522874f, 0.42854622f, -0.48249626f, 0.01038959f, 0.12886260f, -0.18245289f, -0.10874499f, 0.13597839f, 
    -0.19008298f, -0.14188103f, 0.12845489f, 0.20197427f, -0.14112885f, 0.17751262f, 0.09140582f, 0.24364969f, 
    0.03717776f, -0.27214414f, -0.19072956f, 0.24376862f, -0.22969234f, 0.01057995f, 0.30924809f, 0.15063249f, 
    0.43386039f, 0.08357340f, -0.08414669f, 0.08141618f, -0.22836278f, 0.16184066f, 0.16319683f, 0.00065186f, 
    0.05370712f, 0.00499241f, -0.16489692f, -0.18848860f, 0.12179965f, -0.21077409f, -0.01925231f, -0.06094474f, 
    0.01840793f, 0.01879346f, 0.18919122f, -0.22498509f, 0.04247089f, -0.12110549f, -0.05656521f, -0.04354341f, 
    0.12826328f, -0.12321994f, 0.23296556f, 0.19994357f, 0.22984190f, -0.54691732f, -0.91580224f, -0.02610206f, 
    -0.64491564f, -0.31221899f, 0.09947028f, 0.11073723f, 0.33662865f, 0.42688534f, 0.27958119f, -0.03752592f, 
    0.23762816f, -0.16714455f, 0.07320420f, -0.72021735f, 0.06643316f, 0.40616655f, -0.11827971f, -0.07375592f, 
    0.08767298f, 0.36623278f, -0.20565423f, -0.36913913f, -0.22161151f, -0.42650601f, 0.03230695f, 0.20353349f, 
    -0.05314484f, -0.28052071f, -0.03671781f, 0.15168458f, -0.18673548f, 0.36582375f, -0.50994498f, 0.09997093f, 
    0.21934119f, 0.48438534f, -0.16140716f, -0.10301409f, -0.17335550f, 0.48325104f, 0.17495802f, -0.19905922f, 
    0.07825136f, 0.37188485f, -0.22609012f, 0.01780715f, 0.05711871f, -0.25826544f, 0.21843466f, -0.22432847f, 
    -0.05940144f, 0.22442533f, -0.19185787f, 0.24439202f, 0.13422889f, -0.24061649f, 0.29217443f, -0.10100937f, 
    0.13781570f, -0.65378791f, 0.19249429f, 0.33909714f, -0.09290487f, 0.05041099f, -0.29684001f, -0.78452331f, 
    -0.33010092f, -0.06371038f, -0.13219722f, 0.39129823f, -0.03509027f, 0.50005800f, -0.21928208f, 0.02786938f, 
    0.23324466f, 0.24578732f, 0.23284809f, 0.19895180f, 0.20657262f, -0.26099464f, 0.40924186f, -0.08266184f, 
    -0.27995938f, -0.12957658f, 0.17376053f, 0.29115704f, -0.17611989f, -0.15409641f, -0.09683672f, -0.20564258f, 
    0.00220557f, 0.03871896f, -0.16084652f, 0.28514716f, 0.23371270f, -0.54940099f, -0.35780451f, 0.30114013f, 
    0.56372988f, -0.00336520f, 0.10819995f, 0.28866392f, 0.06130439f, 0.21176681f, 0.29757726f, -0.12596506f, 
    0.12929896f, -0.17729846f, 0.17875101f, -0.18133049f, -0.20644957f, 0.20991045f, -0.13435905f, -0.01512139f, 
    -0.05023156f, -0.14036156f, -0.05056977f, -0.23538959f, 0.09216332f, -0.04462317f, -0.21515620f, -0.20383489f, 
    -0.18431230f, -0.95625830f, 0.10249615f, -0.12518252f, -0.24841635f, 0.31005558f, 0.10813787f, -0.06472957f, 
    -0.65069771f, 0.47759208f, -0.02023003f, 0.12866333f, -0.21807380f, 0.24796183f, -0.08646705f, 0.14488891f, 
    0.08310702f, 0.32861039f, -0.37795958f, 0.08900238f, 0.17821097f, -0.97204465f, -0.06407288f, 0.25077781f, 
    -0.18085031f, -0.34291685f, 0.16035232f, 0.28196234f, -0.35930645f, 0.50556970f, 0.33606243f, 0.20320141f, 
    0.07285284f, 0.31817862f, 0.07765810f, 0.13270608f, 0.07148234f, 0.02294679f, 0.16281888f, -0.15349764f, 
    0.31527829f, 0.53642517f, -0.13582170f, -0.25043136f, -0.00172096f, -0.18409808f, 0.19416024f, -0.32069966f, 
    0.19297701f, 0.26030904f, -0.09187997f, -0.30894390f, -0.20209512f, 0.08550403f, 0.43673527f, -0.19416863f, 
    -0.05393148f, 0.60618329f, 0.17705289f, -0.05286890f, 0.03463762f, 0.08743130f, 0.03998476f, -0.05329124f, 
    0.10410574f, 0.09686364f, -0.19897254f, -0.48990640f, 0.04155511f, 0.02750519f, -0.31157291f, -0.64856726f, 
    0.04414661f, 0.01154339f, 0.18507078f, 0.06094412f, 0.64546889f, 0.01629611f, 0.15154389f, 0.30881417f, 
    0.09786402f, 0.18003428f, 0.02783191f, 0.49962506f, 0.09150579f, 0.17687367f, -0.34881404f, -0.59561694f, 
    -0.46257049f, -0.06798166f, 0.10790633f, 0.02440510f, 0.58806658f, 0.27981463f, 0.16657045f, 0.26184654f, 
    0.19832830f, 0.28827560f, 0.54610091f, -0.11779822f, -0.18091734f, -0.05946579f, 0.13914676f, 0.40934658f, 
    -0.74154955f, -0.26680663f, -0.09785931f, 0.20677994f, 0.13119432f, -0.09736244f, -0.16269073f, 0.20432352f, 
    -0.02594561f, -0.23415887f, 0.19937633f, -0.62424165f, 0.21630724f, 0.11835355f, -0.03780580f, -0.32134151f, 
    -0.76416916f, -0.21418428f, -0.21186557f, 0.56588161f, -0.01175843f, -0.04971797f, -0.31730422f, 0.52526587f, 
    0.00097822f, 0.28343642f, 0.05235281f, 0.65217793f, 0.02424199f, 0.13618700f, -0.47429365f, -0.36200029f, 
    -0.06182838f, 0.09000742f, 0.11678989f, -0.15138119f, 0.37236100f, -0.02287686f, 0.16888395f, 0.29060274f, 
    -0.17553042f, -0.18346058f, 0.48722392f, 0.36292857f, 0.20907965f, 0.03680210f, -0.83534461f, 0.69645959f, 
    0.46674299f, 0.19581819f, -0.23680009f, 0.05702688f, -0.13947657f, 0.29493102f, -0.77430522f, -0.53580004f, 
    0.17171645f, 0.13493498f, -0.01709906f, -0.48011568f, 0.18499120f, -0.12609574f, 0.18668677f, -0.47565299f, 
    0.18655670f, -0.23903574f, 0.19440228f, 0.46150193f, 0.28032628f, 0.22760452f, -0.10327107f, -0.11940933f, 
    0.16957358f, 0.14033426f, -0.12854809f, -0.17164168f, -0.14731368f, -0.01296267f, -0.25526652f, 0.15003122f, 
    0.13228962f, -0.05628197f, -0.24636924f, -0.18721850f, 0.05655426f, -0.25331447f, -0.16298966f, 0.04617362f, 
    -0.09572548f, 0.17636889f, 0.51951152f, 0.02866085f, 0.11383358f, 0.31271827f, 0.37308803f, 0.03735073f, 
    -0.16208860f, -0.17229396f, 0.08845948f, 0.15841711f, -0.30659714f, 0.32864898f, -0.32751364f, -0.53057075f, 
    0.17991197f, -0.19584033f, -0.07211082f, 0.31762618f, 0.11283864f, -0.04980881f, -0.07656435f, 0.28685713f, 
    0.30244145f, 0.45238665f, -0.10699801f, -0.12076192f, -0.34139520f, -0.20679113f, 0.34311500f, 0.14018825f, 
    0.18677005f, 0.04881081f, 0.45793453f, 0.43807486f, 0.00370302f, 0.32603756f, -0.80572462f, 0.52592880f, 
    0.32723930f, 0.37366584f, -0.00992503f, 0.27152273f, -0.20818822f, -0.03070406f, -0.72698724f, -0.46555015f, 
    -0.01439138f, 0.22017144f, -0.39464083f, -0.05106296f, 0.05110705f, -0.04681615f, -0.31441998f, 0.12172955f, 
    0.09206219f, 0.35970929f, 0.09809066f, -0.07076157f, -0.13532755f, -0.11640148f, 0.25254235f, 0.25493160f, 
    -0.10002669f, 0.19555412f, 0.13756655f, 0.18882433f, 0.12424562f, 0.02963727f, 0.22466891f, -0.48022497f, 
    -0.47047621f, -0.36922336f, 0.00708883f, 0.35909429f, 0.07462402f, 0.26330227f, 0.25968483f, 0.01194512f, 
    -0.20845950f, 0.34775132f, -0.02752586f, -0.00997483f, -0.03066391f, 0.24384689f, 0.06680822f, -0.05009691f, 
    -0.15510680f, 0.25261337f, 0.22299112f, 0.00375091f, 0.01863162f, -0.45103985f, 0.19741578f, 0.18360779f, 
    0.06024614f, 0.20857173f, -0.06373309f, 0.06401113f, 0.22212368f, -0.40828249f, 0.41474789f, -0.12267578f, 
    0.59984869f, 0.57642639f, 0.22584520f, 0.18779349f, 0.11663035f, -0.12114984f, 0.15016115f, -0.27257371f, 
    0.08064771f, -0.12409201f, -0.09015544f, 0.30866560f, 0.23939219f, 0.02148391f, 0.03304543f, 0.25140867f, 
    0.17387626f, 0.17888366f, -0.12523028f, -0.06967050f, 0.39132392f, -0.21816453f, -0.18786848f, -0.07645512f, 
    0.14199366f, 0.11678122f, 0.01031424f, -0.58776581f, 0.11076499f, 0.12523480f, 0.03623153f, 0.17309307f, 
    0.60069823f, -0.57227451f, -0.17178443f, 0.53303879f, -0.11967728f, 0.30186570f, -0.22933277f, -0.15945747f, 
    0.07806415f, 0.22567742f, 0.34670234f, -0.58857721f, 0.02896515f, -0.26311743f, -0.01724323f, -0.23112816f, 
    0.30300713f, -0.38053814f, 0.16508923f, -0.03484258f, 0.37758461f, 0.05509214f, 0.20051904f, 0.43611139f, 
    0.17629772f, -0.05428970f, -0.19610879f, 0.21838766f, 0.14793639f, 0.36801037f, 0.14412965f, 0.03705752f, 
    -0.05836164f, -0.43991762f, -0.22083510f, 0.11430089f, -0.24982533f, 0.00100240f, 0.28401029f, -0.28740567f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21848550f, 0.05582819f, -0.14523765f, 0.12550701f, -0.01954687f, 0.05532243f, -0.07989223f, -0.00177652f, 
    0.43387392f, -0.10731493f, -0.13203168f, 0.07862310f, 0.48757744f, 0.29297310f, 0.26729560f, 0.06889114f, 
    0.46070156f, -0.15826789f, 0.55079627f, 0.13645831f, -0.19791241f, -0.04854224f, 0.02045840f, 0.14167114f, 
    0.41036999f, -0.20065323f, -0.18892205f, 0.09186333f, 0.05118078f, 0.55344480f, 0.14074516f, -0.01801191f, 
    0.11090173f, 0.28452122f, 0.32398173f, 0.10814880f, 0.06579685f, 0.09301533f, -0.33001232f, -0.07780188f, 
    0.04910390f, 0.39236239f, 0.18483151f, 0.42936805f, 0.38821626f, -0.07941777f, 0.44039857f, 0.22750200f, 
    0.72847551f, -0.13590495f, -0.00036939f, 0.47029969f, -0.11182380f, -0.23301922f, 0.22302650f, -0.23197222f, 
    0.28975415f, 0.08778362f, 0.04561472f, -0.07812824f, -0.19187331f, 0.35269189f, 0.60205561f, -0.44264254f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06087953f, -0.97252512f, 0.09184097f, 0.05309870f, 0.27925768f, -0.58776981f, -0.04574813f, -0.36568555f, 
    -0.11839631f, 0.20445628f, 0.06488673f, -0.56286180f, 0.18376604f, 0.12272028f, -0.16225567f, 0.17312756f, 
    -0.08115955f, 0.21306200f, 0.00217983f, -0.00062357f, 0.17655118f, 0.17861824f, -0.00216090f, -0.06437748f, 
    -0.31608471f, 0.07193764f, 0.17444484f, -0.54096138f, -0.13348737f, -0.29920617f, -0.70966482f, 0.11267523f, 
    -0.07238922f, -0.80398428f, -0.05567065f, 0.27714813f, -0.28110558f, -0.21794194f, -0.41365921f, 0.12370118f, 
    -0.10480402f, 0.15075576f, -0.60953891f, 0.20102601f, 0.13174675f, -0.06660068f, -0.80476201f, -0.04669196f, 
    -0.01821188f, -0.27490360f, 0.36996403f, -0.79735267f, -0.02469964f, -0.19077143f, 0.24763836f, 0.35666275f, 
    0.01973461f, -0.52720332f, 0.12290291f, 0.09954654f, 0.33289436f, -0.32487094f, 0.08565107f, -0.02942508f, 
    0.00647144f, -0.61226219f, 0.09162223f, 0.19688779f, 0.17477439f, 0.03436526f, 0.22886151f, -0.29237854f, 
    0.31263903f, -0.04288780f, 0.02872520f, -0.06506687f, -0.19743837f, 0.28184700f, 0.39704713f, 0.14111717f, 
    0.17741306f, -0.07343156f, 0.30447990f, 0.24606772f, -0.94112396f, -0.01334442f, -0.20150457f, -0.08889657f, 
    -0.75374669f, -0.00869337f, 0.34973016f, 0.46465078f, 0.23881140f, 0.05711693f, 0.20854482f, -0.10491253f, 
    -0.00843104f, 0.07651361f, -0.00505734f, 0.01743469f, 0.16056117f, -0.04779461f, 0.53105795f, 0.06713961f, 
    -0.15064853f, 0.13668811f, 0.32069179f, 0.18767622f, 0.10513008f, -0.19735152f, -0.12673953f, -0.05318604f, 
    -0.17743978f, -0.09048890f, -1.01820135f, -0.02395772f, -0.07069340f, -0.01361064f, 0.05630243f, -1.08046556f, 
    0.21387300f, -0.13556765f, 0.16533989f, 0.13257632f, 0.29689580f, -0.23785001f, -0.11249031f, -0.14503749f, 
    -0.08612052f, -0.03530749f, 0.11912528f, -1.17985034f, -0.46827018f, -0.22354643f, -1.21863484f, 0.24628456f, 
    -0.14419231f, 0.26950139f, -0.07782849f, -0.08811556f, 0.22522601f, -0.14439699f, -0.35330957f, -0.03281484f, 
    0.17039533f, -0.15829907f, -0.06059583f, -0.22719674f, -0.02766258f, 0.07458580f, 0.16281305f, -0.03713558f, 
    0.29506946f, 0.00659033f, -1.65413833f, -1.17928028f, 0.42995510f, 0.35468808f, -0.00437303f, 0.14134420f, 
    0.07977851f, 0.17378435f, 0.20801409f, -1.29838383f, -0.16464457f, 0.34318805f, -0.29914069f, -0.37783170f, 
    -0.10703719f, 0.35093611f, 0.29103643f, 0.34577450f, 0.04604704f, -0.28984398f, -0.15487345f, 0.11044145f, 
    0.77913469f, -0.45944348f, -0.78787202f, 0.13426964f, -0.06648031f, 0.01809642f, -0.09243744f, -0.24133132f, 
    -0.23881406f, 0.01728575f, -0.21761072f, -0.10882978f, -0.16110285f, 0.26378310f, 0.08464821f, 0.17964576f, 
    -0.03461348f, 0.24408686f, -0.03072808f, 0.23644170f, 0.01315289f, -0.19140434f, -0.24476042f, 0.18876228f, 
    0.06149471f, 0.16513802f, -0.00139943f, -0.46447301f, 0.12634298f, -0.11750243f, -0.61786437f, -0.32161060f, 
    0.10831098f, -0.10655669f, -1.19004238f, -0.38650861f, 0.59917361f, 0.04903042f, -0.24516414f, 0.01934952f, 
    0.17197621f, -0.07757290f, 0.20943953f, -0.21665950f, 0.04838630f, 0.44910324f, -0.15040568f, 0.09804700f, 
    0.02622435f, 0.27456796f, -0.91595578f, 0.05963587f, -0.92348731f, 0.18314776f, -0.96905661f, 0.16562486f, 
    -0.23273528f, -0.02929083f, 0.02188573f, -0.75151813f, -0.77507657f, -0.67907959f, -0.14171329f, 0.08422129f, 
    -0.77046520f, -0.12753108f, 0.48634580f, -0.23274013f, -0.09394618f, 0.22551213f, -0.04111566f, 0.37643668f, 
    -0.22180654f, -0.08950227f, 0.22126745f, -0.39571610f, -0.06815354f, 0.13906518f, -0.04229354f, 0.69312185f, 
    -0.11846152f, 0.00426446f, 0.02154611f, -0.00208080f, -0.24669471f, 0.20326678f, -0.21801987f, 0.16728951f, 
    0.10466432f, -0.06287629f, 0.21343632f, 0.27187291f, -0.61876649f, 0.29344556f, -0.04334293f, 0.04509599f, 
    -0.06022784f, 0.23772006f, -0.04486684f, -0.37125880f, 0.01698690f, 0.24927934f, 0.05219731f, 0.01809167f, 
    0.17184895f, -0.02580605f, 0.02125653f, 0.07296963f, -0.17861992f, -0.82883865f, -0.15746762f, 0.11876894f, 
    -0.08505613f, -0.43113017f, -0.42629597f, -0.02000611f, 0.16176644f, 0.19661607f, 0.40334579f, -0.13912131f, 
    -0.36189070f, 0.06108365f, -0.51063132f, -0.01470170f, 0.00180392f, 0.03524585f, -0.10854545f, 0.04952880f, 
    -0.33952439f, -0.19322459f, 0.07108336f, 0.02649380f, 0.05299115f, 0.26881036f, -0.04974239f, 0.11588497f, 
    -0.37297317f, 0.12293299f, 0.17838117f, 0.13331592f, 0.02291391f, -0.03474996f, -0.44861454f, -0.02316858f, 
    0.00079224f, 0.13554893f, -0.08012297f, -0.21132374f, 0.11418853f, 0.21273047f, 0.33707690f, -0.24314976f, 
    -0.16604653f, 0.03925503f, 0.22214450f, -0.08657672f, 0.11395582f, 0.14952067f, -0.10970297f, 0.13575467f, 
    0.00526864f, 0.07009418f, -0.15857039f, 0.28423512f, -0.41778734f, -0.02485856f, -0.16936517f, 0.20803119f, 
    -0.15789601f, -0.07758150f, -0.10845111f, -0.15442845f, 0.33599004f, -0.13661109f, -0.23074076f, 0.03905918f, 
    -0.11058956f, 0.04315668f, -0.02719160f, -0.06037569f, 0.00609462f, 0.11946390f, -0.31905851f, -0.01173830f, 
    -0.02899153f, 0.17301804f, -0.04565339f, 0.35881731f, 0.09356520f, -0.22227921f, 0.16579516f, -0.07900594f, 
    -0.77317345f, 0.27050009f, -0.49680465f, -0.24919032f, 0.05915119f, 0.00395389f, 0.09403452f, -0.29779792f, 
    -0.08747733f, 0.11162448f, -0.02380799f, 0.02539736f, -0.55441320f, -0.68005073f, -0.06798588f, -0.12605874f, 
    -0.02452895f, 0.23387979f, 0.11219700f, -1.34955871f, -0.31900197f, -0.19436496f, -0.97623485f, 0.40300551f, 
    -0.00219454f, -0.38605088f, -0.43457666f, 0.17723578f, 0.28767624f, -1.54603839f, 0.31932655f, -0.39886597f, 
    -1.67994785f, 0.08408936f, -0.31184170f, 0.30581412f, -0.68908656f, -0.09479962f, 0.06935796f, -0.41663828f, 
    0.38400519f, 0.03142706f, -0.92998952f, -0.01658741f, -0.67920089f, -0.62901425f, 0.02164045f, -0.27221873f, 
    0.05597015f, -0.27644590f, 0.25515077f, -1.48560226f, -0.01517825f, -0.77023250f, -0.18415083f, -1.05082440f, 
    -0.06696562f, -1.23744774f, -0.62137240f, -0.24794742f, -0.19115381f, 0.16311926f, 0.26276684f, 0.33180231f, 
    0.84268457f, 0.24795596f, -0.39474472f, 0.13036281f, -0.02834507f, 0.04446997f, -0.13981734f, -0.19499594f, 
    -0.11117570f, 0.12877283f, 0.16463220f, -0.51969916f, 0.12104540f, 0.05575020f, 0.15111251f, -0.05793780f, 
    0.00862058f, -0.44601139f, 0.09239785f, -0.43680522f, -0.00911175f, 0.25680685f, 0.01018743f, -0.33452716f, 
    -0.26833364f, -0.35264751f, 0.02584544f, 0.16081072f, -0.05800201f, -1.31809473f, -0.46568155f, 0.02016381f, 
    -0.64204025f, 0.17838651f, -0.13758951f, -0.46556917f, 0.71294653f, 0.22633536f, 0.23695941f, -1.23863423f, 
    0.22277814f, -0.08733998f, -0.91896194f, 0.06428768f, -1.22385657f, -0.34624591f, 0.15423132f, -0.13748257f, 
    0.03583847f, -0.38049600f, -0.47808388f, 0.28617299f, 0.04534147f, 0.02053371f, 0.24739605f, 0.46973559f, 
    -0.03969699f, -0.89070594f, 0.19695729f, -0.03195611f, -0.09545887f, -0.19979130f, -0.34210998f, 0.12820114f, 
    -0.18109110f, -0.18674304f, 0.35771775f, 0.28538990f, 0.02843152f, 0.38563606f, -0.23154011f, -0.12729777f, 
    -0.08376121f, -0.04855309f, -0.23562275f, 0.30545211f, -0.28797609f, 0.43010613f, 0.15212160f, -0.01606399f, 
    -0.03863947f, -0.71686494f, 0.03966263f, -0.52584779f, 0.20226608f, -0.13315997f, 0.13633275f, -0.17231393f, 
    0.54353440f, -0.01241130f, -0.75648636f, 0.07233917f, 0.13665950f, -0.90556914f, -0.14073083f, -0.03445352f, 
    0.10205545f, -0.25167474f, -0.20726991f, 0.32344902f, -0.31299192f, 0.03110124f, 0.04481132f, -0.33472335f, 
    -0.96321982f, 0.01630358f, -0.16047426f, -0.21993454f, 0.61700106f, 0.63944149f, 0.25402796f, -0.16235302f, 
    0.03703000f, 0.49156439f, 0.29189569f, -0.52308810f, 0.09948120f, -1.04603469f, -0.71879345f, -0.00967291f, 
    -0.09992194f, -1.15484154f, 0.42574424f, -0.24022791f, 0.10840879f, -0.08168951f, 0.18371826f, 0.26463544f, 
    -0.35505086f, 0.20680122f, 0.05913451f, -0.15237720f, -0.06636692f, -0.57114780f, 0.10267823f, -0.09738904f, 
    0.21473783f, 0.15011874f, -0.04602068f, -0.36714694f, -0.25152779f, -0.23385035f, 0.11019204f, -0.05757946f, 
    0.09380351f, 0.47321030f, 0.09522209f, 0.30064076f, -0.36819157f, -0.23873781f, -0.65179414f, 0.29792488f, 
    -0.58326542f, 0.12093899f, -0.03114612f, 0.02475717f, 0.18344706f, 0.33644319f, -0.07457012f, -0.37867233f, 
    0.04157754f, 0.16663189f, 0.08971334f, -0.39784527f, 0.15896565f, 0.10815500f, 0.21566674f, 0.01046540f, 
    -0.12539828f, 0.07570010f, -0.94815826f, -0.08011310f, -0.83432287f, -0.29487878f, -0.14612901f, -0.24372034f, 
    -0.02267229f, -0.01136228f, -0.79926878f, 0.11273777f, -0.28866488f, 0.23353608f, -0.27933976f, -0.82244092f, 
    -0.07204829f, 0.27453691f, -0.84490228f, 0.04021829f, 0.27777055f, -0.20943666f, 0.10610060f, 0.11797529f, 
    0.14187279f, -0.10084427f, -0.76055759f, 0.21011709f, -0.10664999f, 0.15760654f, -0.23336411f, -0.75861371f, 
    -0.22334534f, 0.11138724f, -0.10954400f, -0.21836814f, -0.19758880f, 0.11163267f, 0.14973448f, -0.09107846f, 
    -0.03924261f, 0.10281323f, 0.06712408f, -0.63091308f, 0.27209690f, 0.51718229f, 0.13412626f, -0.07297044f, 
    -0.20237739f, -0.94579518f, 0.40718335f, -0.65753961f, -0.23888566f, -0.69958866f, -0.63361377f, 0.32658544f, 
    0.18248974f, -0.56237561f, -0.87708890f, -0.30426085f, -0.33228135f, -0.01105779f, -0.32972667f, 0.07518408f, 
    0.67737603f, 0.09062424f, 0.01882084f, -0.42852086f, -0.06406283f, -0.17502433f, 0.06251353f, 0.44970128f, 
    -0.08977874f, -0.31088772f, -0.76442546f, 0.05005373f, 0.13185927f, -0.37747318f, -0.45574024f, 0.42055058f, 
    0.01745526f, -0.93195647f, 0.24617119f, -0.32279563f, -0.09817568f, 0.11262661f, -0.07532642f, -0.78175610f, 
    -1.08665633f, 0.00398283f, -0.43296003f, 0.25821131f, -0.04034042f, -0.43695438f, 0.22421183f, -0.48153421f, 
    0.10442822f, 0.05264545f, -0.57247150f, 0.23107347f, 0.07576694f, 0.36880094f, 0.14297453f, -0.14444861f, 
    0.05765402f, 0.47617316f, -0.02077316f, -0.03277649f, -0.20391627f, 0.27961349f, 0.48318008f, -0.48277783f, 
    0.02419022f, -0.28706312f, -0.55626351f, 0.16169272f, -0.07679322f, -0.16812213f, 0.06184719f, -0.32594028f, 
    -0.23281235f, 0.00927383f, 0.04420251f, -0.18528047f, -0.44783422f, -1.08263648f, -0.25432149f, -0.18427293f, 
    -0.05842486f, -0.01324432f, -0.20008774f, 0.53676695f, -0.58817804f, 0.23865587f, -0.06047638f, -0.62191910f, 
    -0.13483056f, 0.48040301f, -0.09023054f, -0.06917711f, -0.01035017f, 0.41825891f, -0.51566362f, 0.19340770f, 
    -0.06390424f, -0.44039232f, 0.01324235f, -0.11628081f, -0.18130167f, 0.39271250f, 0.30126044f, -0.04153836f, 
    -0.25263405f, 0.19479634f, -0.83421552f, 0.21031801f, -0.18125200f, -0.55322367f, -0.56575626f, -0.23541437f, 
    -0.08800680f, -0.07920072f, -0.13551220f, -0.03989285f, -0.19732401f, 0.02737146f, 0.24397331f, -0.34259498f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26621386f, 0.28803807f, 0.03570947f, -0.07341792f, -0.26856136f, -0.10328685f, 0.07416502f, -0.15845186f, 
    -0.21969488f, 0.17074443f, 0.17530164f, 0.05720265f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
