#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.39283407f, -0.56671304f, 0.26996183f, -0.73825657f, -0.19560811f, 0.32043859f, 0.14826429f, -0.05863602f, 
    0.27547547f, -0.74689770f, -0.29570648f, -0.75103903f, 0.10072897f, -0.34881574f, -0.18730845f, -0.15695895f, 
    -0.13383028f, -0.14518848f, 0.28490394f, 0.43573323f, -0.31529194f, -0.43587232f, -0.54237467f, -0.09073101f, 
    0.09281037f, 0.45333472f, 0.02067080f, 0.48791850f, 0.65294009f, 0.52936739f, -0.30377951f, -0.07624497f, 
    -0.29257903f, 0.33709803f, 0.18376009f, -0.10215494f, 0.29114860f, -0.07218576f, -0.25047439f, -0.46311900f, 
    0.39141265f, 0.56448948f, 0.27595159f, 0.21651886f, 0.34256372f, -0.24315780f, -0.27870920f, 0.13853227f, 
    0.59733647f, -0.23708624f, -0.38736826f, -0.04358364f, -0.08652703f, -0.25913659f, -0.48527518f, -0.24298604f, 
    -0.04485746f, 0.53460139f, 1.03385890f, -0.10560231f, 0.08825641f, 0.05273497f, -0.21017125f, 0.17465171f, 
    -0.71267021f, -0.67542607f, -0.28880921f, -0.39614445f, -0.33477443f, -0.39079672f, -0.07208899f, 0.18136472f, 
    -0.73857653f, -0.61312258f, -0.54744065f, 0.01354886f, 0.21037191f, 0.55361503f, 0.11972146f, 0.05055455f, 
    0.17660818f, -0.23170544f, -0.10047287f, -0.04775054f, -0.97736931f, -0.05612647f, -0.53599983f, 0.20102191f, 
    0.07243531f, -0.17710614f, -0.06160839f, -0.19887371f, 0.79169005f, 0.76689416f, -0.04454542f, 0.11332884f, 
    0.23260006f, 0.09863564f, 0.22480628f, 0.79452163f, 0.40385509f, -0.47718558f, -0.13087106f, 0.35658690f, 
    -0.01595869f, -0.03401056f, -0.34316009f, -0.25249103f, -0.03362864f, 0.51895934f, -0.27134678f, 0.04363059f, 
    -0.30745152f, 0.09654593f, 0.41655001f, -0.33395013f, 0.40391096f, 0.54375201f, 0.11953905f, 0.53011167f, 
    -0.69417793f, 0.35987270f, -0.23667184f, -0.28814086f, 0.06582833f, -0.04681956f, -0.31747603f, 0.72024214f, 
    -0.42231408f, 0.34266388f, -0.24066404f, -0.25547251f, -0.10617791f, -0.00454518f, -0.16869454f, 0.58124906f, 
    0.23532677f, 0.69811273f, 0.54329085f, 0.15665536f, 0.00254227f, 0.00471534f, -0.05027130f, 0.05162513f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05005592f, -0.12098026f, -0.18614045f, 0.05443872f, 0.12891248f, 0.06279875f, -0.10654087f, 0.32070333f, 
    0.04881591f, 0.25033125f, -0.23483047f, 0.20682785f, 0.04980366f, -0.07514210f, -0.20253593f, 0.06500699f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00676666f, 0.03938650f, -0.31483018f, 0.04990394f, -0.16459855f, 0.19327074f, -0.02811676f, 0.06247338f, 
    0.07103567f, -0.16923910f, 0.14044307f, -0.05599832f, -0.14595836f, 0.09817476f, 0.08768710f, 0.14116788f, 
    0.08868451f, -0.01431286f, -0.08357915f, -0.03785179f, -0.06182150f, 0.10917144f, -0.03150016f, 0.09390534f, 
    0.05136590f, -0.11947587f, 0.01774093f, -0.03328685f, 0.18203194f, -0.22786807f, -0.08367390f, 0.23912367f, 
    0.07970827f, -0.02738412f, -0.01005514f, 0.03316837f, 0.29434347f, 0.15322490f, 0.01113630f, -0.05887441f, 
    0.00775901f, -0.05144064f, 0.08842460f, -0.15136866f, 0.17217730f, -0.14474471f, -0.14643373f, 0.06132591f, 
    -0.00772884f, 0.11308327f, 0.00171118f, -0.08932388f, -0.01143557f, -0.08067384f, 0.10801013f, -0.12493640f, 
    0.13862199f, -0.25456923f, 0.04335069f, 0.01603883f, 0.14238206f, 0.19829586f, -0.09044033f, -0.35751745f, 
    -0.30551827f, 0.03052716f, 0.10832032f, 0.17863332f, 0.00319070f, -0.16946650f, -0.03853577f, -0.16135782f, 
    0.43620598f, 0.29974431f, -0.00304045f, -0.03746750f, -0.04513242f, -0.16492607f, -0.01670166f, 0.02393423f, 
    0.08908913f, 0.24072790f, -0.12430930f, -0.20695604f, 0.06593733f, -0.09413362f, 0.20209999f, -0.05395732f, 
    -0.00022657f, -0.08326056f, -0.12375975f, 0.14052173f, 0.05139565f, -0.01738815f, 0.07956590f, -0.16668840f, 
    -0.07298436f, 0.07057314f, 0.11131994f, 0.23227257f, -0.29437834f, -0.06606597f, 0.15950483f, -0.00994245f, 
    0.13847072f, -0.01621829f, -0.00676533f, -0.06508572f, 0.00271157f, -0.08047965f, -0.48172539f, 0.04648035f, 
    0.12412701f, 0.06699201f, 0.10500819f, 0.04288531f, -0.17467901f, 0.15375181f, 0.06834880f, -0.18585989f, 
    -0.07555028f, 0.06759383f, 0.02110214f, -0.15330563f, 0.11157069f, -0.08318801f, -0.10490037f, -0.35118049f, 
    -0.20887376f, -0.08374693f, 0.08896080f, -0.11737479f, 0.02937583f, 0.04176124f, 0.01498335f, -0.16271622f, 
    -0.16798079f, -0.01383494f, -0.08591810f, -0.04281465f, -0.00790120f, -0.07800433f, 0.01415844f, 0.21176845f, 
    0.06533793f, -0.07086731f, 0.14790402f, -0.03435152f, -0.19286820f, -0.23956135f, 0.11026276f, 0.06963053f, 
    0.03731649f, -0.21952097f, -0.34148604f, -0.00280760f, -0.02873367f, -0.02782780f, 0.08371522f, -0.07461066f, 
    0.11094163f, 0.13719058f, 0.02786487f, -0.33238584f, -0.14345625f, -0.07964729f, 0.13444586f, -0.16510248f, 
    0.12203584f, 0.17181543f, -0.05031802f, -0.35114819f, -0.03808299f, 0.31574750f, 0.15288548f, 0.10638969f, 
    -0.20773974f, 0.03894947f, 0.03137630f, 0.00348575f, -0.23637150f, -0.14461993f, -0.12045770f, 0.14705026f, 
    0.06693517f, 0.06248078f, -0.13837308f, -0.09985461f, 0.00905778f, 0.10793041f, -0.11553325f, -0.10410602f, 
    -0.10505245f, 0.09682584f, 0.13341701f, 0.07334562f, -0.04821510f, 0.07192998f, -0.07852992f, -0.06695515f, 
    -0.16849074f, -0.04682358f, -0.17044455f, 0.14630988f, 0.05412117f, 0.13256173f, 0.14550918f, 0.18140996f, 
    -0.04764102f, 0.41917390f, -0.04729504f, -0.10050362f, -0.04232724f, 0.21688315f, -0.07588302f, 0.04851059f, 
    0.24637745f, -0.13583186f, 0.18568735f, 0.09089908f, -0.11176866f, 0.12161040f, -0.06045022f, 0.06997168f, 
    0.10139197f, -0.08216949f, 0.20952593f, 0.11824851f, 0.22420539f, 0.22331233f, -0.05966301f, -0.03672836f, 
    -0.12919112f, 0.13648687f, 0.11809088f, -0.12993279f, -0.06707464f, -0.05123821f, -0.06215698f, -0.05685589f, 
    -0.04581853f, 0.08302211f, -0.11725032f, -0.12585811f, 0.05894143f, -0.00324722f, -0.09564001f, -0.01748076f, 
    0.00281007f, -0.05038446f, -0.04144524f, -0.07621651f, 0.24471894f, 0.21564153f, -0.24793357f, 0.09493829f, 
    -0.02260738f, -0.01177279f, -0.08550186f, 0.10741697f, -0.10954462f, -0.48953575f, 0.54828137f, 0.00374246f, 
    0.21497019f, -0.02730704f, -0.07565930f, 0.19685219f, 0.05812525f, -0.04963219f, 0.33011898f, -0.04425112f, 
    -0.16084446f, -0.04938693f, 0.06137335f, 0.09222101f, -0.13120481f, 0.11950070f, 0.08754854f, -0.42626360f, 
    -0.15202342f, -0.12072770f, -0.05633194f, -0.04404980f, 0.15298298f, 0.05620256f, -0.05778229f, 0.04506518f, 
    -0.02741417f, 0.08066657f, -0.05818032f, -0.01299154f, -0.02016660f, -0.05392255f, -0.03739684f, -0.07569557f, 
    0.04643869f, -0.03788360f, -0.02931669f, -0.07728561f, 0.04812716f, 0.00080990f, -0.03723357f, 0.03858020f, 
    -0.04585477f, -0.02409052f, -0.07922255f, 0.04507139f, -0.06001838f, -0.06893149f, 0.03925499f, -0.07760043f, 
    -0.09605026f, 0.04338049f, 0.03343479f, -0.05902224f, -0.10029699f, -0.05393527f, -0.00090512f, 0.01469928f, 
    -0.09826623f, -0.04738830f, 0.08610588f, 0.04815802f, -0.06047626f, -0.03204127f, 0.04579481f, -0.04013655f, 
    0.02392030f, -0.10036014f, 0.03459090f, -0.07374463f, 0.00239429f, -0.09736177f, -0.03718001f, -0.06689448f, 
    -0.01766734f, -0.05458232f, 0.06299360f, -0.01897655f, -0.02369356f, -0.10361394f, 0.04254889f, -0.08425339f, 
    0.00149764f, 0.03418463f, 0.01256959f, -0.03312054f, 0.02404535f, 0.02252854f, -0.02147301f, -0.01457759f, 
    -0.03984401f, -0.00395498f, -0.08976641f, -0.03644992f, -0.05209320f, -0.05817686f, 0.03922923f, 0.00772643f, 
    -0.06999170f, -0.03519979f, 0.03367900f, -0.00037827f, -0.04324407f, -0.00916877f, -0.09415592f, 0.03448843f, 
    -0.05363073f, -0.08171736f, -0.09119860f, -0.03891965f, 0.05390933f, -0.09348741f, 0.04990897f, -0.05403292f, 
    0.04317768f, -0.00570219f, -0.00026453f, -0.00406414f, -0.07305034f, -0.07811876f, -0.00287609f, -0.07365249f, 
    -0.06656923f, -0.04354708f, 0.01529027f, 0.03302984f, -0.01707307f, 0.00270171f, 0.03865783f, 0.00925867f, 
    -0.01806052f, -0.03147893f, 0.08726197f, 0.01378482f, -0.01816804f, -0.05365977f, -0.03065801f, -0.09162225f, 
    -0.09920087f, -0.09086012f, -0.00594125f, -0.09043816f, 0.04598768f, -0.06009063f, -0.03716946f, -0.05872499f, 
    -0.05342213f, -0.05944020f, -0.09091636f, 0.01693835f, 0.03077995f, -0.08207904f, -0.04821336f, -0.02384691f, 
    0.00301789f, -0.10505960f, 0.04690079f, 0.03512532f, 0.00938652f, -0.00666764f, -0.03575050f, -0.03797530f, 
    -0.05487219f, -0.09159438f, 0.02235437f, -0.10063715f, 0.05676717f, 0.02374095f, 0.01609248f, -0.05081537f, 
    -0.09550314f, 0.08013934f, -0.00287942f, -0.20510212f, -0.18554406f, -0.09311120f, -0.10877399f, 0.07782056f, 
    0.12421557f, 0.13934346f, 0.18399853f, 0.19911197f, -0.14981346f, 0.00172767f, 0.07006284f, 0.12073702f, 
    0.04234969f, 0.01176212f, 0.20433830f, -0.26211670f, -0.04189407f, -0.21607801f, -0.11767850f, 0.10488010f, 
    -0.07997514f, -0.06846119f, -0.08707586f, -0.08847046f, -0.15484183f, 0.07016993f, 0.05556505f, -0.04364539f, 
    0.12641272f, -0.05899799f, 0.11886854f, 0.07642521f, -0.15602824f, 0.01379208f, -0.11824248f, -0.02049930f, 
    -0.19317575f, -0.11266557f, 0.20290339f, 0.07667468f, 0.16364388f, 0.14564760f, -0.03560727f, 0.13197626f, 
    0.01748372f, 0.07582148f, 0.12323777f, -0.05199889f, -0.05231702f, 0.05289880f, 0.39521226f, 0.20012003f, 
    -0.06130730f, 0.13243347f, -0.00336563f, 0.04002367f, 0.13694720f, 0.00085668f, -0.05289643f, 0.19053069f, 
    0.17218840f, -0.10286789f, 0.10451765f, -0.00983457f, 0.01500348f, 0.09783980f, 0.02969331f, -0.16738611f, 
    0.23475978f, 0.34490484f, 0.10599631f, 0.21771890f, -0.05244891f, -0.11253570f, -0.05895235f, 0.17059940f, 
    -0.04528789f, 0.08221896f, -0.05068696f, 0.03779109f, 0.02074531f, -0.11304384f, 0.05357107f, -0.08834821f, 
    -0.11089480f, 0.00699898f, -0.34982568f, 0.08189927f, 0.08005911f, 0.13951376f, -0.26968047f, 0.21445473f, 
    0.04843981f, -0.00911814f, -0.00984218f, -0.07441429f, -0.15341605f, -0.20060438f, -0.04627566f, 0.08898302f, 
    -0.08322794f, -0.03375565f, 0.04885366f, -0.13931981f, 0.07723095f, 0.02481814f, -0.23738688f, -0.02823571f, 
    -0.05174047f, 0.02229293f, -0.07252540f, -0.03582209f, 0.10773385f, -0.42151430f, -0.13818038f, 0.10607475f, 
    0.19287407f, 0.16055365f, 0.07701645f, -0.10269334f, -0.12674221f, 0.10099329f, 0.20746894f, -0.30779630f, 
    -0.09048290f, -0.08169339f, -0.12462738f, -0.06768977f, -0.07613663f, 0.01342203f, -0.13110083f, -0.39038888f, 
    -0.05221308f, -0.15710580f, 0.10085062f, 0.15091996f, -0.03779003f, 0.04924323f, 0.13420261f, -0.02721590f, 
    -0.35077158f, -0.06809364f, -0.13485652f, 0.07956237f, 0.01761695f, -0.21443185f, -0.03144051f, -0.13618967f, 
    0.05187688f, 0.04390309f, 0.14961116f, -0.18989231f, -0.01177293f, 0.08671032f, 0.06806088f, 0.13969919f, 
    0.10681831f, -0.09345220f, 0.20526282f, -0.10846872f, 0.27167764f, -0.01314885f, -0.20283265f, -0.10362920f, 
    -0.05265285f, -0.02998117f, 0.05015782f, 0.33195242f, 0.29798546f, 0.00287567f, 0.14390722f, 0.00072385f, 
    -0.02719255f, 0.07656204f, -0.05294892f, 0.25098032f, 0.11172041f, 0.06351295f, -0.18249233f, -0.13432758f, 
    -0.03656282f, -0.11118130f, 0.03401279f, 0.01065207f, 0.14730470f, -0.08822994f, -0.29623169f, -0.01776332f, 
    0.01968635f, 0.15628380f, -0.05641446f, 0.14853543f, 0.08702324f, 0.14670430f, -0.07348111f, -0.13144194f, 
    -0.33752975f, -0.09707130f, 0.06250568f, -0.07864386f, -0.16683872f, 0.04611273f, -0.12901680f, -0.34353366f, 
    -0.11769588f, 0.03566765f, 0.03658523f, 0.15987819f, -0.18154888f, -0.07633944f, 0.00684754f, 0.07070342f, 
    0.08295343f, -0.17887613f, -0.56004077f, 0.05730849f, 0.01044235f, 0.04745154f, 0.07581072f, -0.04718895f, 
    -0.00320263f, -0.00058714f, -0.04178711f, -0.27737242f, 0.03653778f, 0.11408865f, 0.25305808f, 0.24162000f, 
    -0.00376375f, 0.02546174f, -0.51110375f, -0.30813557f, 0.27328470f, 0.08441564f, 0.15431260f, -0.07088304f, 
    0.01042598f, -0.16476305f, -0.17407431f, 0.05557992f, 0.00385580f, 0.00561487f, -0.21792766f, -0.06974419f, 
    -0.07283325f, 0.15736762f, -0.10179920f, 0.09346978f, -0.22457412f, -0.07351063f, 0.07664363f, 0.09690499f, 
    -0.00815735f, 0.07336859f, 0.00305682f, 0.03875560f, 0.06374678f, 0.15044110f, 0.02445152f, -0.11881404f, 
    -0.14997958f, 0.19114295f, 0.17774871f, -0.02756260f, 0.04478912f, -0.03069065f, -0.13643152f, -0.05213491f, 
    -0.13847648f, -0.10463421f, -0.03419686f, -0.01174236f, 0.07194526f, 0.06500211f, -0.05714132f, 0.16196556f, 
    0.07241680f, 0.27458790f, -0.14023164f, 0.05166107f, 0.05567712f, 0.12686634f, 0.12427985f, -0.10165513f, 
    0.50294459f, -0.14663838f, -0.03998316f, -0.26541126f, 0.09441634f, -0.05210503f, 0.01076214f, 0.05782312f, 
    0.10638934f, -0.32753262f, -0.07029091f, -0.14288709f, 0.06553069f, -0.04702036f, 0.04976289f, -0.14352030f, 
    -0.11735167f, -0.02418718f, -0.01319656f, 0.27236685f, 0.05364142f, 0.12966178f, -0.04907094f, 0.08323354f, 
    -0.14484964f, 0.05454853f, -0.05064767f, 0.12815501f, 0.28119421f, 0.14636396f, 0.02953825f, 0.12928332f, 
    -0.01927620f, 0.07799945f, 0.04751348f, -0.12436059f, 0.27995595f, 0.20669995f, -0.06661139f, -0.03244387f, 
    -0.06373347f, 0.13494645f, 0.06840640f, -0.02601656f, -0.14785221f, -0.14742023f, -0.20461142f, 0.08643205f, 
    -0.13087426f, 0.09533476f, -0.20063511f, -0.08871385f, -0.02029865f, -0.07283540f, 0.49775496f, -0.31079581f, 
    -0.04110629f, -0.10373656f, -0.19956926f, -0.18235528f, -0.09285355f, -0.06832019f, 0.14775698f, 0.09353956f, 
    -0.07453562f, 0.06390015f, -0.02116633f, 0.16733846f, -0.07187035f, 0.18379728f, 0.04443263f, 0.07091630f, 
    0.25178942f, 0.10930923f, -0.06723209f, -0.35103488f, 0.14301956f, 0.02085876f, -0.03902432f, -0.09817049f, 
    -0.07115003f, 0.38312316f, 0.12019915f, -0.03886651f, 0.19783187f, 0.02988092f, -0.06759837f, -0.20561661f, 
    0.01436615f, 0.09670558f, 0.09147245f, -0.18288828f, -0.04312691f, -0.29976723f, 0.06574214f, 0.14042205f, 
    -0.12064291f, -0.07965656f, -0.14608647f, 0.16804668f, 0.02253602f, -0.10313695f, -0.03050081f, 0.06919403f, 
    0.00203899f, 0.04333343f, 0.08052233f, 0.15727404f, 0.03450178f, -0.03868976f, -0.18578327f, 0.09534243f, 
    0.07744244f, 0.17565012f, -0.00068017f, -0.04344951f, -0.07924367f, -0.23057646f, 0.40123633f, -0.04902328f, 
    0.01963939f, 0.10974837f, 0.08090158f, -0.01061401f, -0.02446339f, -0.03432738f, -0.01413799f, -0.21695815f, 
    0.03585607f, -0.14577359f, 0.01487081f, 0.09772831f, -0.19125511f, 0.00129996f, 0.16623963f, -0.40437394f, 
    -0.17264237f, 0.04738458f, 0.14580461f, 0.08548531f, 0.12562300f, 0.07172159f, -0.05944264f, 0.04565861f, 
    -0.26881537f, 0.07775375f, -0.00491878f, -0.10342772f, 0.10361496f, -0.19827177f, 0.10775106f, 0.07963409f, 
    0.11005421f, 0.04678891f, 0.10535982f, 0.05321115f, -0.14829712f, 0.02664631f, 0.04252657f, 0.03891798f, 
    -0.15080877f, 0.08131880f, 0.11142058f, 0.09829625f, -0.02924086f, 0.09723890f, 0.03383262f, -0.01966567f, 
    0.11719348f, 0.07077735f, -0.08806046f, 0.34940389f, 0.00374521f, 0.09626241f, 0.04269866f, -0.06416026f, 
    -0.13881283f, 0.02098052f, 0.18931146f, -0.01519757f, -0.24972756f, -0.07508586f, -0.09000450f, 0.04450412f, 
    0.00167180f, -0.00112011f, 0.12058399f, -0.01057189f, -0.23118803f, 0.02581500f, -0.20745170f, -0.02544278f, 
    -0.14526732f, -0.04154673f, -0.06090256f, -0.09184146f, 0.01364898f, -0.01735744f, -0.19548380f, 0.14868827f, 
    0.13562703f, 0.18897599f, -0.08543201f, 0.05484797f, -0.22277145f, 0.10321416f, 0.23287427f, 0.45453379f, 
    0.27736750f, -0.10887706f, -0.08955883f, -0.21446492f, -0.20880292f, 0.16001217f, 0.25547656f, 0.12796055f, 
    0.03987342f, -0.07154749f, 0.03086632f, 0.12014485f, 0.16902350f, -0.08391641f, 0.00484149f, -0.11514959f, 
    0.07751981f, -0.19744171f, 0.13013841f, -0.06569394f, -0.08656842f, -0.04768340f, -0.09778898f, -0.00105149f, 
    0.15010799f, -0.08299717f, 0.03613451f, -0.31994689f, -0.04150356f, 0.07485446f, 0.06111262f, 0.12319016f, 
    -0.06904764f, 0.04541390f, -0.27664703f, 0.06878317f, 0.25240868f, -0.18982859f, 0.09556121f, 0.28311458f, 
    0.12797432f, 0.06768696f, -0.09860440f, 0.12650867f, -0.08344343f, 0.01810556f, 0.06613556f, 0.07616378f, 
    0.06007695f, -0.04653940f, -0.06030220f, 0.05713566f, -0.13604085f, 0.22219808f, 0.02780672f, -0.19214493f, 
    -0.24426763f, -0.01574122f, -0.07157602f, 0.01352625f, -0.10799941f, 0.08642487f, 0.41566473f, -0.02593625f, 
    0.19416408f, -0.17393182f, -0.05437338f, -0.16244072f, -0.02652884f, -0.04298605f, 0.07578935f, -0.17799743f, 
    0.20118843f, -0.21181044f, 0.09014364f, 0.19797802f, 0.09513634f, -0.00206133f, 0.23329560f, -0.05475614f, 
    -0.10773177f, -0.04145247f, -0.03928034f, 0.02152834f, 0.06508466f, 0.03518711f, -0.05798766f, -0.03223887f, 
    -0.05092397f, -0.00292181f, -0.01622284f, -0.08693037f, 0.04662151f, -0.04096782f, 0.02203612f, -0.05068269f, 
    -0.04683558f, 0.02896163f, -0.03314425f, -0.01500228f, 0.01483373f, -0.07535545f, -0.04083568f, 0.04931190f, 
    -0.03999808f, -0.07366633f, -0.08383727f, -0.10285410f, -0.02358857f, -0.01771147f, 0.03902563f, -0.00962917f, 
    -0.01826860f, -0.05071835f, 0.04048902f, 0.04377207f, -0.00403510f, -0.06321104f, -0.03878913f, -0.01856094f, 
    0.01825446f, -0.09865446f, -0.03355291f, -0.03940807f, -0.01289451f, -0.09219772f, 0.04306749f, 0.02446649f, 
    -0.05951810f, -0.04933611f, -0.01443801f, -0.01186472f, -0.04511342f, -0.07604110f, -0.02360387f, 0.02694948f, 
    0.06208219f, 0.05926145f, 0.03255638f, -0.01574531f, -0.11238068f, 0.01279794f, -0.04353083f, 0.01075446f, 
    0.07907763f, -0.03888826f, 0.06645986f, -0.01000235f, -0.04664845f, -0.04024474f, -0.03375785f, -0.01482528f, 
    0.01165200f, 0.02076292f, -0.03207118f, -0.02721022f, -0.05671832f, 0.05017975f, 0.00727177f, -0.02264416f, 
    0.05769652f, -0.10640448f, -0.05525151f, 0.01093243f, -0.00140899f, -0.07768643f, 0.05540780f, -0.01106460f, 
    -0.02342190f, 0.00549134f, -0.06360416f, 0.03077426f, -0.09024165f, -0.11248843f, -0.09241751f, 0.05550506f, 
    -0.12473673f, 0.04237054f, -0.06037840f, 0.03632397f, -0.03043101f, -0.10965195f, -0.04409342f, 0.02600695f, 
    0.00092292f, -0.11567087f, -0.06126786f, -0.06269093f, -0.05501867f, 0.00450823f, -0.01573946f, 0.03621720f, 
    0.03547108f, 0.08746067f, -0.10569354f, 0.05893026f, -0.07087862f, -0.02966225f, -0.07158091f, -0.11751493f, 
    0.00037299f, 0.03198155f, -0.09477889f, -0.11380064f, -0.11578426f, -0.08178642f, -0.06120480f, -0.07033256f, 
    -0.05455730f, -0.08842011f, -0.05731403f, -0.02243167f, -0.03784560f, 0.05602503f, -0.02735359f, -0.02011588f, 
    0.04684129f, -0.04635585f, 0.02637105f, 0.06006352f, 0.03019173f, 0.03341145f, 0.01322142f, 0.01699782f, 
    -0.15870641f, -0.27936170f, -0.17967632f, 0.12426821f, 0.10816427f, 0.09620479f, 0.03558129f, -0.09412909f, 
    -0.05419636f, -0.30939049f, 0.01543963f, 0.37022856f, 0.07769639f, 0.18174158f, -0.00746227f, -0.02178452f, 
    -0.03171144f, 0.07857353f, 0.22851774f, -0.20343474f, -0.09299092f, -0.15342896f, 0.00717978f, -0.11089141f, 
    -0.03994272f, 0.13103646f, 0.08054260f, 0.01659046f, 0.25376254f, 0.08846627f, 0.11596206f, 0.07466489f, 
    -0.00042702f, -0.07656909f, 0.00505846f, -0.15881777f, 0.03325379f, 0.23448004f, 0.11055011f, -0.17388976f, 
    -0.01670558f, 0.12240151f, 0.19575687f, -0.04903445f, -0.06059184f, 0.13012333f, -0.20639148f, -0.34224239f, 
    -0.12503390f, 0.14720543f, 0.06053747f, -0.01741078f, 0.15462211f, -0.12958750f, -0.58251411f, -0.25661966f, 
    -0.07827055f, 0.08930928f, -0.00968080f, -0.15189907f, 0.01128801f, -0.05586730f, -0.05026081f, -0.02684943f, 
    -0.09584899f, -0.14562283f, -0.05363510f, -0.23315313f, -0.04169611f, 0.05338761f, 0.03256766f, 0.12646279f, 
    -0.45248786f, -0.37186652f, 0.05714913f, 0.07782431f, 0.12599288f, 0.04586592f, -0.06561366f, -0.06745058f, 
    0.07651708f, -0.08772942f, 0.19873413f, -0.12474119f, 0.10954753f, -0.06832363f, -0.04503614f, 0.06637457f, 
    0.17930648f, 0.02330903f, -0.22318064f, -0.32882482f, -0.21690705f, -0.13380824f, 0.03205807f, 0.03789845f, 
    -0.05640696f, -0.06242297f, 0.22166537f, 0.41554305f, -0.00624690f, 0.09459450f, -0.01950167f, -0.13502736f, 
    -0.04695810f, 0.08329526f, -0.04131981f, 0.11836503f, -0.23426844f, -0.04284048f, -0.03933642f, 0.06976359f, 
    0.14758441f, 0.04973782f, 0.11349345f, -0.14158590f, 0.10137791f, -0.11481678f, 0.22560482f, -0.08220693f, 
    0.09439170f, -0.03716324f, 0.15898344f, 0.05281245f, 0.10628515f, 0.13621640f, -0.31217682f, 0.12091409f, 
    0.19193910f, 0.03470121f, -0.12477121f, 0.08238818f, -0.05784556f, -0.13141106f, -0.01025001f, 0.25020048f, 
    0.03398960f, -0.02579349f, 0.17281458f, 0.04541290f, -0.09636653f, -0.01463096f, 0.02422860f, -0.08526918f, 
    0.00131836f, -0.10376297f, 0.06541002f, 0.17220089f, -0.17468357f, -0.05888421f, 0.10084778f, -0.04818640f, 
    0.10682341f, -0.19415973f, -0.56919599f, 0.33899015f, 0.23639140f, 0.00420945f, 0.08702067f, -0.03827227f, 
    0.04718504f, -0.04759958f, -0.14445083f, 0.17016560f, -0.35542172f, 0.06221936f, 0.12426528f, -0.10838779f, 
    0.01111162f, 0.01723637f, -0.24252906f, 0.22522882f, -0.00417419f, -0.16582297f, 0.10115179f, -0.01304195f, 
    -0.01859476f, 0.14228725f, 0.07049342f, 0.09820308f, -0.03860204f, 0.02260254f, -0.08236216f, -0.05257224f, 
    -0.07546822f, 0.08939631f, -0.03545807f, -0.03882614f, 0.07905100f, 0.09289591f, -0.25991702f, 0.13117026f, 
    -0.25824788f, -0.15153596f, 0.06271267f, 0.03687451f, 0.04277885f, 0.13087164f, 0.00526945f, -0.04977287f, 
    0.05036699f, -0.01055858f, -0.32111642f, 0.11004873f, -0.01861874f, 0.01877732f, 0.09896006f, -0.14771359f, 
    0.40626872f, 0.00935409f, 0.04659611f, -0.00614075f, -0.08000559f, -0.01635243f, 0.00666490f, -0.00625502f, 
    0.04021074f, -0.15664549f, 0.34045911f, -0.10897928f, 0.12535828f, -0.04492644f, -0.17015117f, 0.00203710f, 
    0.03605496f, -0.33565959f, 0.06483377f, -0.26571763f, 0.11276030f, 0.07177619f, 0.08140682f, 0.12387564f, 
    0.11224435f, 0.04635229f, 0.29303509f, 0.09311739f, 0.06058765f, -0.04943029f, -0.04423938f, -0.03652940f, 
    -0.21807010f, -0.13723701f, -0.02160934f, 0.11932685f, -0.08702579f, -0.05784428f, 0.04282582f, 0.09389007f, 
    -0.02520029f, -0.02502462f, 0.00120522f, -0.07602160f, 0.03763052f, 0.36997354f, -0.09824468f, -0.09042075f, 
    -0.00024270f, 0.05496296f, 0.02246561f, 0.09197173f, -0.03873534f, -0.11907673f, -0.07592855f, -0.22611418f, 
    0.19776514f, 0.07254624f, 0.06393325f, -0.02539272f, -0.00779316f, 0.06146415f, -0.59642303f, 0.08412482f, 
    -0.59439659f, -0.04852007f, -0.03090445f, 0.02921788f, -0.08273637f, 0.08159685f, 0.05281276f, -0.05326735f, 
    0.08754735f, -0.10619196f, 0.07145062f, 0.11611803f, -0.17870875f, 0.13081516f, 0.01214170f, 0.02213625f, 
    -0.06754173f, -0.08565639f, -0.02476797f, 0.01927118f, -0.03475254f, -0.02592934f, -0.00816904f, 0.06799880f, 
    -0.08044812f, -0.02186352f, 0.00796705f, -0.04961392f, 0.03292825f, -0.08624235f, -0.02434616f, 0.04055310f, 
    0.00347558f, -0.01554241f, -0.03262599f, 0.06746866f, 0.03946117f, -0.02218975f, 0.04358938f, 0.00113526f, 
    0.03156447f, 0.00157062f, -0.00560240f, -0.06442667f, -0.03637288f, -0.01962616f, -0.03497633f, 0.03164387f, 
    -0.04148375f, -0.04886993f, -0.07047664f, 0.05264506f, 0.03152160f, -0.03215626f, 0.02200561f, -0.00701787f, 
    0.00769982f, 0.06038039f, 0.05097184f, 0.01935053f, -0.06136969f, -0.03285455f, -0.04835414f, -0.01824461f, 
    0.01778666f, -0.05892603f, -0.03133619f, 0.00645253f, 0.05082572f, 0.06228773f, 0.05237216f, -0.06519421f, 
    0.03079092f, 0.00955574f, 0.00181369f, -0.02841931f, -0.08209095f, -0.01524516f, -0.07078142f, -0.03156823f, 
    -0.01207464f, -0.06687278f, -0.09037708f, 0.04429818f, 0.06810188f, 0.02161450f, -0.06464835f, -0.07271542f, 
    0.02627500f, -0.03595210f, 0.00781613f, 0.05728076f, 0.01685172f, -0.02561578f, -0.03839459f, -0.05576333f, 
    -0.01148065f, -0.07608058f, 0.04669352f, 0.03284975f, -0.08505899f, 0.04343655f, -0.04534303f, 0.02988307f, 
    0.04977067f, 0.00759838f, 0.03997186f, 0.00491695f, -0.03397975f, 0.02208659f, 0.01885479f, -0.00473903f, 
    0.05750952f, 0.00784202f, -0.08429671f, -0.06615403f, -0.09312989f, -0.05673445f, -0.08361568f, -0.02618075f, 
    0.01077999f, 0.04408970f, -0.07774524f, 0.04527837f, 0.02125642f, 0.05974561f, -0.02406323f, -0.06293465f, 
    0.03807024f, 0.01278367f, -0.04407861f, 0.03574401f, 0.06168653f, 0.03741067f, -0.08418874f, 0.06840343f, 
    0.04610360f, -0.06630807f, -0.06427913f, 0.01334224f, -0.08339273f, -0.06823034f, -0.08443006f, -0.01429750f, 
    -0.09017501f, -0.00323415f, -0.04258188f, 0.02910994f, 0.06070881f, 0.06735958f, -0.08068871f, -0.02240576f, 
    0.00107696f, -0.04961089f, -0.00637666f, 0.07547230f, -0.02344016f, -0.01271024f, 0.02602365f, -0.05469056f, 
    -0.02159267f, -0.06008505f, -0.21955344f, 0.07368083f, -0.02009899f, -0.11904602f, 0.02741343f, 0.20546114f, 
    0.08163858f, 0.33233535f, 0.32023653f, 0.17223278f, 0.22648960f, 0.03710161f, 0.14344500f, 0.20065691f, 
    0.13755208f, -0.12843443f, -0.01965849f, -0.12720412f, 0.02794518f, -0.20069784f, -0.06297483f, 0.23447917f, 
    -0.23153169f, 0.22072786f, -0.25363147f, -0.24024253f, -0.14698058f, -0.10040486f, -0.11425208f, -0.13516498f, 
    -0.12397214f, 0.03800092f, 0.12320310f, 0.12798873f, -0.14792648f, 0.14472173f, -0.07621348f, 0.01526021f, 
    -0.16905709f, -0.10496625f, -0.11571807f, 0.05841793f, -0.03359993f, 0.06610506f, 0.19548756f, 0.00866679f, 
    -0.04095208f, 0.04714141f, 0.00856343f, -0.11301025f, 0.01805031f, 0.13909832f, 0.41700888f, 0.46827266f, 
    0.07527383f, 0.09733804f, 0.13809867f, 0.11521138f, 0.05069047f, -0.03040775f, -0.01705017f, 0.21664886f, 
    0.18302910f, 0.20936882f, 0.00131628f, -0.00000527f, 0.09814820f, -0.20883195f, -0.07760599f, 0.04768889f, 
    0.15359415f, 0.21269235f, 0.26661491f, 0.26143354f, -0.03650483f, 0.05758943f, 0.07068417f, -0.13960277f, 
    0.12207650f, -0.21401498f, -0.59879345f, -0.14174771f, 0.08959492f, -0.08461951f, -0.03513581f, 0.05179657f, 
    0.05579386f, -0.13741775f, -0.30910209f, 0.02996862f, -0.17061852f, 0.10902140f, -0.05693337f, -0.17769459f, 
    -0.09326407f, 0.05511777f, -0.09696464f, -0.10639767f, 0.22015892f, 0.06144746f, 0.03633725f, -0.15778920f, 
    -0.05606529f, 0.01425114f, 0.12553178f, 0.15470245f, -0.17216291f, 0.08195322f, 0.06727206f, 0.01274114f, 
    0.05251946f, 0.11730839f, 0.12813421f, -0.14569798f, 0.02525940f, 0.04003111f, -0.00367383f, 0.10957294f, 
    -0.32055998f, -0.08972123f, -0.01478603f, -0.11895179f, -0.16160248f, -0.00361011f, 0.05597205f, 0.01553951f, 
    0.04146602f, 0.07998409f, 0.26134428f, -0.03609974f, 0.15545931f, 0.04329046f, -0.08264252f, 0.05787911f, 
    0.20376894f, -0.11893353f, -0.10952786f, 0.00758549f, -0.02009971f, 0.32072642f, 0.03130423f, 0.23310241f, 
    -0.06695447f, 0.01849449f, -0.02455094f, 0.04431900f, 0.06910664f, -0.07014567f, -0.05901172f, 0.01682124f, 
    0.07304311f, 0.04598973f, -0.01336647f, -0.03217169f, -0.03664934f, 0.03052019f, -0.03338819f, -0.01150720f, 
    0.01648148f, -0.06083941f, 0.06045526f, -0.00055198f, -0.07298947f, -0.01007069f, -0.04788629f, -0.00539078f, 
    -0.02603233f, 0.09208041f, 0.06990719f, 0.00958112f, -0.00783481f, 0.06113514f, -0.03589867f, -0.07219138f, 
    0.03845818f, -0.04923385f, -0.07079476f, -0.04974014f, -0.00524294f, 0.02017765f, -0.02103982f, 0.00370079f, 
    0.02778727f, -0.02144089f, -0.06249807f, -0.02093617f, 0.00510069f, -0.07284690f, -0.00163979f, 0.03540184f, 
    0.05409110f, 0.03375578f, 0.05790996f, 0.00982956f, 0.01094423f, -0.10097621f, 0.04555955f, 0.01162049f, 
    -0.03186907f, -0.01561977f, 0.05544954f, -0.00471553f, 0.04346751f, -0.00203090f, 0.04077831f, 0.04720607f, 
    0.00611398f, 0.04493530f, -0.05270671f, 0.00219024f, 0.03065838f, -0.04522096f, -0.02913956f, 0.04186445f, 
    0.05164436f, -0.01121141f, -0.09108324f, -0.08610922f, 0.00171119f, -0.05546744f, 0.00021654f, -0.04366293f, 
    -0.08652738f, 0.00039542f, 0.00095234f, 0.04849229f, -0.01850719f, -0.08802041f, 0.04006055f, -0.02062903f, 
    -0.01399957f, 0.01100184f, -0.07107486f, -0.05794553f, -0.05610998f, -0.07831872f, 0.02391041f, 0.04641935f, 
    -0.07229550f, -0.11421709f, -0.02782898f, 0.00484110f, 0.03875906f, 0.00013348f, -0.02757972f, -0.06414866f, 
    0.04368845f, -0.00324415f, -0.07316228f, 0.01827697f, -0.04346284f, 0.03446267f, 0.03077229f, 0.00734506f, 
    -0.08182574f, 0.05634073f, -0.08192503f, 0.04958564f, 0.00852410f, -0.03118982f, -0.09208019f, 0.02790982f, 
    0.02464920f, -0.00320549f, 0.00530636f, -0.06097243f, -0.04841835f, 0.03315762f, -0.01389397f, 0.03032278f, 
    -0.07795308f, 0.05894090f, -0.02393960f, 0.05075159f, -0.07762980f, 0.03982012f, -0.07971825f, 0.07409570f, 
    -0.03446176f, -0.08618883f, -0.05661446f, -0.02308732f, -0.06384388f, -0.07800114f, 0.02221496f, -0.04750231f, 
    -0.07561580f, -0.04601531f, -0.06191645f, 0.05455495f, 0.07135014f, -0.00061085f, -0.03567263f, -0.12697986f, 
    -0.07179248f, -0.19029185f, 0.19520000f, -0.05825451f, 0.07509374f, -0.07089405f, -0.15345168f, -0.01265250f, 
    0.00624338f, 0.06829154f, -0.15613499f, -0.05077091f, 0.23301215f, -0.18308531f, -0.05372605f, -0.05240715f, 
    -0.10864587f, 0.11059180f, 0.03013678f, 0.38254842f, 0.26938450f, 0.27583724f, -0.16561931f, -0.17503329f, 
    0.07430054f, 0.04374940f, 0.07371918f, -0.06414344f, 0.12558217f, -0.28342077f, -0.01227948f, 0.09687055f, 
    0.04890750f, -0.06303298f, -0.02348543f, -0.08484074f, -0.05173585f, 0.11440960f, 0.08645944f, -0.14144929f, 
    0.17937088f, 0.01599829f, -0.12693432f, 0.12106732f, -0.03971266f, 0.14351046f, 0.03890423f, -0.26507166f, 
    -0.21538080f, 0.04899428f, 0.34793642f, -0.05553844f, 0.05437974f, 0.02964794f, 0.09174859f, -0.18412328f, 
    0.05050797f, -0.11041391f, 0.03041370f, 0.14747478f, 0.15026243f, -0.08073415f, -0.06093811f, 0.01376939f, 
    0.10714372f, 0.08774208f, -0.47234204f, 0.10291106f, 0.03851567f, 0.11005481f, -0.04991831f, 0.02913244f, 
    -0.04038940f, -0.06410875f, -0.10350827f, -0.11359175f, -0.00518516f, 0.10064589f, -0.03350613f, -0.04516784f, 
    0.05315699f, -0.09193628f, -0.03144864f, -0.09650218f, -0.05910942f, -0.05673821f, 0.07770181f, 0.19958769f, 
    -0.02869830f, 0.00405402f, -0.19215061f, -0.04797822f, 0.07658224f, 0.30960381f, -0.05903922f, -0.15168631f, 
    -0.20318888f, -0.01718113f, 0.11811729f, 0.10040634f, -0.12128292f, -0.12462534f, 0.02750805f, -0.32872608f, 
    -0.11292756f, 0.16588154f, 0.00617050f, -0.07772830f, 0.11699703f, -0.00162578f, 0.18763646f, 0.09092849f, 
    0.04179085f, 0.14594077f, 0.00323294f, -0.30155993f, -0.06940425f, 0.11787452f, -0.22720593f, -0.14325215f, 
    0.08101957f, 0.00114494f, 0.07838999f, -0.03352732f, -0.03493918f, 0.00809643f, -0.10344531f, 0.03684362f, 
    0.40485540f, 0.37631407f, -0.07321477f, -0.03120897f, -0.12097563f, 0.00406388f, 0.12941980f, 0.04245802f, 
    0.01855758f, -0.08525325f, 0.05285603f, -0.03255356f, -0.09258422f, -0.07550752f, 0.01083413f, 0.01066107f, 
    -0.04735399f, -0.07152010f, 0.01634649f, -0.07055239f, -0.10036992f, -0.04608319f, -0.00213981f, -0.06191451f, 
    -0.04211222f, -0.09594660f, -0.05013493f, -0.07871258f, 0.00343166f, 0.01677379f, 0.02059937f, 0.01071313f, 
    0.08245224f, -0.02099331f, -0.03154707f, -0.00327505f, -0.00953766f, 0.00425091f, -0.03159078f, -0.03467803f, 
    0.05706170f, -0.00812747f, 0.02223231f, 0.01371932f, -0.00858688f, 0.01117804f, -0.07986683f, -0.03249191f, 
    -0.01512070f, 0.02701387f, -0.02853343f, -0.03777513f, -0.03361033f, 0.01429472f, -0.06529314f, 0.00730971f, 
    0.00732133f, -0.09673228f, -0.01303054f, 0.04405138f, 0.05516439f, 0.03249985f, 0.05412557f, -0.08200743f, 
    -0.02416513f, 0.06149660f, -0.00336912f, 0.03096357f, -0.03612608f, 0.03639286f, 0.00230437f, 0.06390979f, 
    -0.06536525f, -0.07236736f, -0.10363201f, -0.02389885f, 0.00470064f, -0.04890616f, 0.01745655f, 0.03196246f, 
    -0.08335058f, -0.10565858f, 0.01137919f, -0.05250095f, 0.01519357f, -0.00506699f, -0.04929380f, 0.01204283f, 
    0.03446530f, 0.04349766f, 0.04354392f, -0.08284386f, -0.08243044f, -0.07272715f, 0.00531553f, 0.05094815f, 
    -0.00725488f, 0.03400949f, 0.01814301f, -0.07528307f, 0.01306692f, 0.02197839f, -0.05766950f, -0.01932245f, 
    -0.01203800f, 0.02669011f, -0.00989269f, -0.03397228f, -0.07681043f, -0.03206996f, -0.03872391f, 0.04810116f, 
    -0.07470065f, -0.03401706f, -0.04703082f, -0.00816890f, -0.08183639f, -0.04729515f, -0.07591486f, -0.05159374f, 
    -0.02544558f, 0.05527250f, -0.05774212f, -0.01186803f, -0.05292092f, 0.01933703f, -0.07641833f, -0.04156642f, 
    -0.05283182f, -0.06098703f, 0.04590971f, -0.05032257f, 0.03836169f, 0.01507616f, 0.06294481f, -0.06602113f, 
    0.03805141f, -0.01353584f, 0.06919713f, 0.06600543f, 0.05660896f, -0.01689776f, -0.06025891f, -0.06618633f, 
    -0.02774979f, -0.08760197f, 0.02837742f, -0.00585113f, -0.00200257f, 0.02130949f, -0.00476469f, 0.08811137f, 
    0.10665818f, 0.24619101f, 0.08722065f, -0.00207279f, 0.19868629f, -0.07716641f, -0.00672517f, 0.13205770f, 
    -0.06685419f, -0.39735028f, 0.36815700f, 0.04138824f, 0.18628351f, 0.01268512f, -0.02405478f, -0.02193241f, 
    -0.22953954f, -0.00558231f, 0.02930653f, -0.15105331f, -0.20665371f, 0.25714174f, 0.03774906f, 0.23307317f, 
    -0.01512962f, 0.17035888f, 0.07499288f, -0.01800371f, 0.22856610f, -0.11413574f, -0.02021645f, -0.05434648f, 
    0.01051953f, 0.03110340f, -0.15869240f, 0.12525550f, 0.26538688f, -0.14502397f, 0.14853071f, -0.14995150f, 
    -0.01312812f, -0.18154450f, 0.07366420f, 0.15516266f, 0.24337953f, -0.15896250f, 0.16552760f, -0.11926760f, 
    0.04602639f, 0.08795249f, -0.08562222f, 0.09679536f, -0.00900588f, -0.03503200f, 0.01453949f, -0.39614952f, 
    -0.20829390f, -0.07012665f, -0.11300854f, -0.12829916f, 0.04008697f, -0.00766599f, -0.04340032f, -0.19619249f, 
    -0.27406204f, -0.20885028f, 0.07871006f, 0.06650726f, 0.21170233f, -0.06052476f, -0.18225947f, -0.09731273f, 
    -0.01426288f, 0.31850398f, 0.02306321f, 0.01777200f, -0.03925353f, -0.04564527f, 0.01405664f, -0.15356791f, 
    -0.15506561f, 0.04523646f, -0.09512090f, -0.00617316f, -0.02322360f, 0.26414034f, 0.15982220f, -0.12326514f, 
    -0.02157001f, -0.19137047f, 0.03799448f, 0.14006066f, 0.04418029f, -0.09688435f, 0.15419658f, -0.06743153f, 
    0.04437173f, 0.01167545f, 0.09488895f, 0.09948058f, 0.14997983f, -0.13794993f, 0.09948701f, -0.15710491f, 
    0.13999584f, 0.19382606f, 0.00676767f, 0.10574690f, 0.23794556f, -0.03253428f, 0.12731242f, 0.08927306f, 
    0.03793008f, 0.05953127f, 0.07165521f, -0.07791373f, 0.08512995f, -0.21601500f, -0.13484091f, -0.09901868f, 
    0.24043709f, -0.04535733f, -0.02179199f, -0.00347042f, -0.01052705f, -0.12671579f, -0.39740691f, -0.11635721f, 
    -0.10360056f, 0.04658499f, 0.02542706f, 0.07962144f, -0.20396383f, -0.05857615f, -0.04554718f, -0.03289879f, 
    0.05996547f, 0.14171460f, 0.06460934f, -0.11333514f, -0.17239386f, 0.01148549f, 0.04507795f, 0.08227984f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03109028f, 0.16462365f, 0.02069725f, -0.02345856f, 0.20065689f, 0.08797469f, -0.09562623f, -0.00348226f, 
    0.20116399f, 0.17603731f, 0.04461181f, 0.13667029f, -0.08667481f, 0.10082484f, -0.00635993f, 0.26698437f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08099286f, 0.16466694f, 0.13563497f, -0.53257638f, 0.27998692f, 0.15620251f, -0.09089597f, 0.11331424f, 
    0.10394694f, 0.41540936f, -0.00640308f, -0.02563437f, -0.23574494f, -0.01855670f, -0.03569110f, 0.44623953f, 
    -0.36547834f, -0.38157305f, 0.15324476f, 0.44482112f, 0.02238172f, -0.13265447f, 0.25320324f, -0.22093940f, 
    0.14123237f, -0.42096126f, -0.10781223f, -0.02014633f, -0.23772734f, 0.29521379f, 0.21630250f, 0.08845903f, 
    -0.38900366f, 0.27280569f, -0.01997748f, 0.20635594f, -0.26837033f, 0.10829610f, 0.42127204f, -0.14651951f, 
    -0.02007947f, -0.46834752f, -0.01400911f, -0.06076160f, 0.01295307f, 0.05449189f, -0.00365163f, -0.04263373f, 
    0.18695591f, -0.17671901f, 0.01275299f, -0.60943747f, -0.01580346f, 0.39313489f, 0.22923307f, 0.04929793f, 
    -0.25923434f, -0.04126444f, -0.09507912f, 0.23146363f, -0.22133550f, -0.06397799f, -0.15480506f, -0.00985856f, 
    -0.03886473f, -0.10393369f, 0.20045671f, 0.07493383f, 0.07485354f, -0.24267915f, -0.04277155f, 0.05346319f, 
    0.07105765f, -0.21865863f, 0.18471524f, -0.10511908f, 0.21020821f, -0.14223874f, 0.01084939f, -0.18927032f, 
    0.51652378f, 0.13994986f, 0.21002144f, 0.11578374f, 0.09301072f, 0.12356657f, 0.06550663f, -0.23871225f, 
    -0.34583524f, -0.29081455f, -0.17569859f, 0.26972809f, -0.03997217f, -0.22289224f, -0.12408086f, 0.01348900f, 
    0.28410882f, -0.30510694f, 0.07783094f, 0.26880184f, -0.27498546f, 0.37577456f, -0.28558111f, -0.25916764f, 
    -0.05295782f, -0.13046722f, -0.23924699f, -0.15847717f, -0.26059461f, 0.19405121f, -0.14717714f, 0.35404825f, 
    0.39166924f, -0.28685230f, 0.10422862f, -0.02649086f, -0.62814587f, 0.34875038f, -0.09416186f, -0.11219825f, 
    0.28597012f, 0.37371871f, -0.15547596f, 0.02332671f, 0.19339783f, -0.25751653f, 0.22614704f, 0.45579153f, 
    0.16814394f, 0.18025799f, 0.16033727f, -0.38126779f, -0.02177247f, 0.48163569f, 0.35579401f, -0.09237784f, 
    -0.18113481f, -0.16898501f, 0.05301680f, 0.16703665f, -0.23468846f, 0.07056485f, -0.06624529f, -0.38193727f, 
    0.10370175f, -0.10497109f, -0.21095629f, 0.02127438f, 0.06833605f, -0.25977504f, -0.15719610f, 0.08698133f, 
    0.23927504f, -0.22176588f, -0.12333688f, 0.45685571f, 0.05915438f, 0.23339090f, -0.21076515f, 0.39449307f, 
    -0.06393889f, 0.24001269f, 0.19721906f, 0.02689362f, -0.88770628f, 0.36302435f, 0.09991572f, 0.05110036f, 
    0.10588893f, 0.37216249f, -0.06524509f, 0.23184368f, 0.12182382f, -0.32333177f, -0.00660048f, -0.14826412f, 
    0.02164767f, -0.33519599f, -0.06965713f, 0.22526279f, 0.08412208f, -0.27477029f, -0.09297183f, 0.07326811f, 
    0.00018052f, 0.24074972f, 0.19501887f, 0.39320958f, -0.18837366f, 0.01252866f, -0.15432280f, 0.33577320f, 
    0.30996117f, -0.06566367f, 0.15223876f, -0.45852244f, 0.24857567f, 0.07068788f, 0.40980539f, -0.00920641f, 
    0.32666555f, 0.01795866f, -0.03117260f, -0.23895864f, 0.19583727f, -0.11044653f, -0.11664748f, 0.16641134f, 
    -0.09999614f, -0.00355193f, 0.04094378f, -0.29958439f, 0.51191252f, -0.14965905f, -0.02417257f, 0.00157198f, 
    0.45624009f, -0.06910720f, -0.12706392f, 0.39654750f, -0.06633592f, 0.08853503f, 0.03805094f, -0.31893563f, 
    -0.25133848f, 0.30617920f, 0.08393122f, 0.21534455f, 0.16884205f, 0.18024991f, -0.05161619f, 0.05770370f, 
    0.02581801f, -0.21994402f, -0.21096438f, -0.19844554f, 0.23642807f, 0.19859056f, 0.03028064f, 0.11861409f, 
    0.22560138f, -0.23726687f, -0.22652748f, -0.17132139f, -0.23910433f, -0.20301995f, 0.07453254f, -0.13377222f, 
    0.07397875f, -0.23749283f, -0.16627011f, -0.20139915f, -0.14514855f, -0.18684983f, -0.06018278f, -0.11676779f, 
    -0.51468027f, 0.12804794f, 0.07272234f, 0.04398821f, -0.37011275f, -0.04741886f, 0.26897860f, -0.11284219f, 
    0.25904304f, 0.32545471f, 0.23031406f, -0.27080232f, 0.21721862f, 0.42546231f, 0.21854250f, 0.42002964f, 
    0.09401003f, -0.39105207f, 0.19518992f, -0.38045454f, -0.01609406f, 0.15487823f, 0.32767126f, -0.21930400f, 
    0.15606588f, 0.64179391f, 0.05175916f, 0.08751003f, 0.17400806f, -0.13785817f, -0.18667825f, 0.13411154f, 
    -0.25962397f, 0.20433125f, 0.18359838f, -0.23924030f, 0.48441625f, 0.06498531f, 0.19602026f, -0.05523878f, 
    0.22069499f, -0.35159418f, -0.23155694f, 0.17656760f, -0.19210821f, 0.31244472f, 0.20521289f, -0.35831830f, 
    -0.02601181f, 0.09993858f, 0.01453191f, 0.02300688f, 0.00782457f, 0.47785753f, -0.01530890f, 0.11341207f, 
    -0.02373243f, -0.07590654f, 0.21591268f, -0.14157969f, 0.10425720f, 0.32193223f, 0.12756802f, -0.40533969f, 
    0.37497237f, 0.21887326f, 0.08669835f, -0.14884286f, 0.36644450f, 0.42761058f, 0.00928372f, 0.16608885f, 
    0.28231499f, -0.32499385f, -0.06245528f, -0.30258715f, 0.15291329f, -0.18008344f, -0.23718703f, 0.20888971f, 
    0.39331818f, -0.27463800f, -0.03578246f, 0.05358967f, 0.37317070f, 0.00729255f, -0.28693879f, -0.15133908f, 
    -0.36241037f, 0.24702685f, 0.20150596f, 0.29502547f, 0.05927886f, -0.22794764f, -0.04896340f, 0.40321377f, 
    0.39035580f, 0.36100680f, -0.19419724f, 0.13801794f, -0.03493900f, -0.10675125f, -0.27803707f, 0.08362151f, 
    -0.69109988f, 0.46615380f, -0.22623917f, 0.17197241f, -0.11761203f, 0.40219051f, 0.04793015f, -0.10591606f, 
    -0.29168344f, 0.12534389f, 0.14114772f, -0.24699624f, 0.15497662f, 0.10498490f, -0.13653736f, 0.02797680f, 
    0.49833432f, 0.35207596f, 0.13290949f, 0.10363723f, 0.14255701f, 0.08384615f, 0.22996841f, 0.11994797f, 
    0.19493160f, 0.15394963f, -0.14046434f, -0.12193624f, -0.22461487f, 0.45843658f, 0.09233896f, -0.17279504f, 
    -0.22636499f, -0.14511164f, -0.18244019f, 0.12495946f, 0.22006992f, -0.54546815f, 0.24264255f, 0.19174708f, 
    -0.18494491f, 0.39667797f, 0.13093039f, 0.25416875f, -0.12140884f, 0.07852583f, 0.39863479f, -0.01246172f, 
    -0.28577486f, 0.38924944f, -0.01806329f, -0.08742519f, 0.12952073f, -0.53708792f, 0.12679857f, -0.18612300f, 
    0.12221847f, -0.25520310f, -0.20566395f, -0.12890828f, 0.09835206f, -0.08879828f, -0.25423735f, -0.11170568f, 
    0.13148551f, 0.03398963f, 0.19759345f, -0.14838421f, -0.21819919f, -0.01743205f, 0.04712004f, 0.02244226f, 
    0.19244333f, -0.29056403f, 0.03791227f, 0.10291101f, 0.22665048f, -0.21940196f, -0.23585440f, -0.01496024f, 
    -0.04582989f, 0.52008009f, 0.10640674f, 0.22505982f, 0.01306950f, 0.17717661f, -0.05915511f, -0.26646796f, 
    -0.12262277f, -0.11658914f, 0.10650601f, -0.19951437f, 0.43479234f, -0.10860378f, -0.05641070f, -0.04289015f, 
    -0.37924275f, 0.29353315f, 0.10163370f, 0.15002836f, 0.00935340f, 0.32918581f, 0.24198598f, 0.44245267f, 
    -0.04591220f, 0.53177893f, -0.06998188f, 0.01262681f, -0.49796873f, -0.10344905f, -0.13595964f, 0.09140746f, 
    0.50297683f, 0.02627236f, 0.03025497f, 0.17435615f, -0.14541303f, -0.17793939f, -0.12919497f, -0.39820412f, 
    0.07925704f, 0.13088444f, -0.06962782f, -0.23375860f, -0.14662629f, -0.16566360f, -0.17495090f, 0.00250787f, 
    -0.12803626f, -0.07619584f, 0.13749257f, -0.00704485f, 0.14011505f, -0.21146929f, 0.02370378f, 0.07441118f, 
    -0.20526946f, -0.21624510f, -0.02467448f, 0.16710024f, -0.17564990f, -0.09235195f, -0.00876610f, 0.18118659f, 
    -0.27164781f, -0.17756218f, -0.18180162f, -0.09450658f, -0.06992760f, -0.08307617f, -0.23576625f, -0.12494069f, 
    -0.19208804f, 0.18313727f, 0.02860608f, -0.04344527f, -0.18502395f, 0.01733250f, 0.08090673f, 0.07453088f, 
    0.50310063f, 0.67752701f, -0.09518875f, -0.11952876f, -0.11725629f, -0.08686156f, -0.26383099f, 0.15293209f, 
    0.06890326f, 0.25905135f, 0.23444821f, 0.29049206f, 0.03383842f, -0.20974632f, 0.03695575f, 0.11928722f, 
    0.10995881f, 0.81365544f, 0.06460618f, -0.02288651f, -0.15852287f, -0.48829040f, -0.01622757f, -0.07068384f, 
    -0.00798500f, 0.25432095f, -0.19012326f, -0.30533123f, 0.14845055f, -0.20342423f, 0.06362890f, -0.09695779f, 
    -0.03434115f, -0.13417092f, -0.05704835f, 0.34731853f, -0.16950396f, 0.32690981f, -0.18285844f, -0.07568255f, 
    -0.28540611f, -0.17443749f, 0.14699787f, 0.45034942f, -0.29960483f, -0.07200429f, 0.02831922f, -0.10367164f, 
    0.38878787f, -0.35860986f, 0.05881916f, 0.42220035f, -0.13496099f, -0.17116077f, -0.02982253f, -0.22796470f, 
    0.47789478f, 0.29104662f, -0.02858925f, 0.01379600f, 0.51547152f, 0.48341432f, -0.44806269f, 0.23139891f, 
    -0.17782292f, -0.15256406f, 0.09997495f, -0.05998491f, 0.00588906f, 0.15005314f, -0.24199785f, -0.34215006f, 
    -0.35681349f, 0.53276634f, 0.05706581f, 0.02773061f, 0.02907184f, -0.12495938f, 0.06426676f, 0.08055218f, 
    -0.13116920f, 0.00972904f, -0.04376718f, 0.20597988f, 0.16210596f, -0.66765445f, -0.09081838f, -0.22755544f, 
    -0.47169721f, -0.00131163f, -0.15635109f, -0.32911709f, -0.00677741f, 0.25696966f, 0.28447458f, 0.22666429f, 
    0.38154230f, 0.19551525f, 0.10769024f, -0.13369322f, -0.00967679f, 0.07678657f, -0.16755013f, 0.40428650f, 
    0.29129344f, -0.48551294f, 0.16314438f, -0.04218628f, 0.04715639f, 0.07196158f, 0.17116210f, 0.00609704f, 
    0.00820987f, 0.16456084f, 0.05140712f, 0.01457931f, -0.04291254f, -0.49364269f, 0.21350938f, 0.11330125f, 
    -0.06179652f, -0.07524423f, -0.18411854f, -0.35189828f, -0.18519861f, 0.47520506f, 0.27569380f, 0.02224408f, 
    0.53365213f, 0.12330478f, -0.04954491f, 0.04391528f, 0.21578810f, 0.09590735f, -0.07795568f, -0.34938303f, 
    -0.18467709f, 0.23637810f, 0.10789290f, 0.27904442f, 0.01353914f, 0.10810889f, -0.27608612f, -0.17276467f, 
    0.58014113f, -0.39709440f, 0.09859614f, 0.23878266f, -0.20092724f, 0.12854508f, 0.18443222f, 0.00959819f, 
    -0.22242050f, -0.13248700f, 0.04649517f, -0.12310302f, -0.08079884f, -0.21600533f, -0.03495614f, -0.08967075f, 
    0.00786238f, 0.07407240f, 0.14868224f, -0.08605768f, 0.00294715f, 0.07247820f, 0.05844301f, 0.14175211f, 
    0.28641018f, -0.24669486f, 0.16976230f, -0.61345237f, 0.23035699f, 0.26105464f, 0.32514927f, 0.06993195f, 
    -0.16378477f, -0.02149488f, 0.20802048f, 0.09494284f, -0.01801916f, 0.06850646f, -0.14746748f, -0.03617705f, 
    0.64420855f, 0.03256871f, 0.09682927f, -0.17808270f, 0.43753240f, 0.41807318f, -0.28682816f, 0.03286711f, 
    0.06774200f, -0.06157417f, -0.09190409f, -0.26926234f, -0.00350660f, -0.02764787f, 0.24777640f, 0.35040265f, 
    0.01870275f, 0.06268876f, 0.10040320f, -0.22086732f, 0.25774872f, -0.10669558f, -0.30342725f, 0.14771917f, 
    0.18339033f, 0.32392192f, 0.07875811f, 0.25426775f, -0.21474768f, 0.29694808f, 0.14152919f, 0.26777530f, 
    0.03720603f, 0.24484710f, 0.24229714f, -0.25562081f, 0.26580289f, -0.16934736f, -0.38465539f, 0.11878052f, 
    0.01515183f, 0.53627497f, 0.13027340f, 0.24333653f, 0.04418580f, 0.32780665f, -0.09089584f, 0.48590434f, 
    -0.05370715f, 0.04263454f, -0.18391705f, -0.19389643f, -0.23024987f, -0.19239712f, 0.13130161f, 0.15613899f, 
    0.07983633f, 0.10051137f, -0.18885806f, -0.11334779f, 0.02847615f, -0.25324190f, 0.23499262f, -0.02314160f, 
    -0.28296810f, -0.22298872f, -0.17772119f, 0.04946469f, -0.01803261f, 0.34292442f, 0.31383747f, 0.06706610f, 
    -0.27742794f, 0.15799299f, -0.02753395f, 0.22256944f, -0.16795854f, -0.33812198f, 0.09177066f, -0.17708136f, 
    -0.36858767f, 0.15594046f, 0.03326085f, 0.06855858f, 0.23706859f, 0.24369562f, 0.09205047f, 0.05854125f, 
    -0.35947049f, -0.19299752f, 0.22723868f, -0.49721098f, -0.00790857f, 0.15360177f, 0.05389221f, 0.36436224f, 
    0.10508621f, -0.20326486f, 0.22939217f, -0.12400866f, 0.06199580f, 0.03128067f, -0.05485052f, -0.06565300f, 
    0.04262346f, 0.13267973f, -0.17452660f, -0.17033255f, -0.24636260f, -0.14618969f, 0.19801274f, -0.20210403f, 
    0.23616815f, 0.44607067f, -0.08369303f, 0.38060892f, -0.93979394f, 0.29804546f, -0.24829933f, 0.18304794f, 
    0.43926150f, -0.04351760f, 0.08961242f, -0.21238281f, 0.20501103f, -0.18324827f, -0.08155824f, 0.11273547f, 
    -0.32884312f, 0.27509221f, 0.12856084f, -0.36773229f, 0.47574100f, 0.03037502f, 0.11505800f, 0.19163981f, 
    0.38254517f, -0.30159536f, 0.14186186f, -0.03344271f, -0.15931283f, 0.19466279f, 0.04167527f, -0.43550915f, 
    0.48422429f, -0.28389564f, 0.20994902f, 0.37497339f, -0.29398352f, -0.12803270f, 0.27521369f, 0.14819182f, 
    -0.04053908f, 0.06198663f, 0.10792734f, 0.03565954f, -0.22758129f, -0.40165266f, 0.01354597f, 0.58561432f, 
    -0.18651199f, 0.34382802f, -0.06356016f, -0.13651201f, -0.15231626f, 0.43834350f, 0.24440172f, 0.10431256f, 
    -0.10544775f, -0.39557859f, 0.04856903f, 0.09774692f, -0.24341784f, -0.12076402f, -0.07822738f, 0.04627537f, 
    -0.15338506f, -0.17036685f, -0.16296315f, 0.21312933f, 0.79215503f, 0.19638537f, -0.04771860f, 0.14682144f, 
    -0.14100561f, -0.31324404f, 0.15375429f, 0.16848110f, -0.09419937f, -0.34350476f, 0.23666263f, 0.01231888f, 
    0.12363340f, -0.14179547f, 0.07750499f, 0.39212021f, 0.09863178f, 0.01327307f, -0.10347591f, -0.00462244f, 
    -0.16466209f, 0.46650934f, -0.15661223f, 0.14697145f, -0.17630632f, -0.31120408f, -0.08372094f, 0.29339433f, 
    -0.19266051f, -0.23980013f, -0.22608632f, 0.02323779f, -0.12938747f, 0.05906892f, -0.18323061f, 0.17853320f, 
    -0.12227228f, 0.17911232f, 0.24628088f, -0.05819768f, 0.13257942f, -0.13619199f, -0.03271484f, -0.18248558f, 
    0.34366074f, -0.18691723f, 0.12025311f, 0.36905876f, 0.03760744f, 0.04766917f, 0.31731591f, 0.09846530f, 
    -0.35188839f, -0.35898075f, -0.05238910f, 0.14331298f, 0.15733589f, 0.03198048f, 0.22570305f, -0.29592451f, 
    -0.30663761f, 0.09857968f, 0.21604370f, 0.38905677f, 0.08454880f, -0.01628747f, 0.30622083f, 0.07209720f, 
    -0.15349774f, -0.15543185f, 0.18030663f, 0.31166938f, 0.15732440f, -0.28924838f, -0.00058112f, -0.30361795f, 
    -0.06698669f, 0.18716685f, 0.14256731f, 0.03581467f, -0.05975096f, 0.42362568f, -0.24229960f, 0.05644815f, 
    0.33081990f, 0.13391124f, 0.09523217f, -0.15662923f, -0.09112769f, 0.10119077f, -0.06024049f, 0.20714393f, 
    0.53741604f, -0.10719442f, 0.23673312f, 0.30190572f, 0.65888959f, 0.09798502f, -0.00033508f, -0.10181367f, 
    -0.27297181f, -0.33516330f, 0.08832639f, 0.12286001f, 0.11562864f, -0.35502130f, -0.04245776f, 0.18407840f, 
    0.04524632f, 0.15644062f, -0.06973030f, 0.15810931f, -0.51217812f, 0.32829714f, 0.23846790f, 0.02565598f, 
    0.22040960f, 0.61235976f, 0.08528604f, -0.29527700f, 0.16529481f, -0.14085960f, -0.10929690f, 0.18305671f, 
    -0.16206849f, 0.28683397f, 0.16462635f, 0.26785910f, 0.21111378f, 0.18010353f, 0.46269119f, 0.16815653f, 
    0.33383247f, -0.10908788f, -0.16253828f, 0.05576706f, -0.12431370f, -0.43264201f, -0.21981657f, -0.40735337f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04457361f, -0.21737942f, 0.22706161f, 0.19084764f, -0.17321178f, 0.14124133f, 0.00062480f, 0.41864073f, 
    0.02818950f, -0.15014908f, -0.05029952f, -0.27343115f, 0.21663633f, 0.59991372f, 0.27323690f, 0.22072983f, 
    0.37704897f, 0.03015433f, 0.26628724f, -0.25779501f, 0.23327428f, 0.53355390f, 0.12075826f, 0.60206407f, 
    0.41820154f, 0.37749070f, -0.12558012f, 0.27483797f, -0.08651048f, 0.40209502f, -0.20190015f, -0.06647497f, 
    -0.03135212f, -0.30564162f, -0.05502731f, -0.42097887f, -0.05109949f, 0.22624570f, -0.01419646f, -0.06714959f, 
    -0.22930162f, 0.36509430f, -0.23044786f, 0.21590540f, -0.05770666f, 0.32070109f, 0.18223916f, -0.24424402f, 
    0.11361130f, 0.26090446f, -0.20801488f, 0.06923175f, 0.40320832f, -0.17915462f, 0.39653555f, 0.31910351f, 
    -0.09558697f, -0.15968817f, 0.12853020f, 0.03995008f, 0.10229280f, 0.44213769f, 0.07580604f, -0.04216910f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.24357964f, -0.03733977f, 0.04774428f, -0.15793978f, -0.10782118f, -0.04978670f, 0.06092765f, 0.22233482f, 
    0.15293100f, -0.34755379f, 0.11658195f, -0.31058937f, 0.36835447f, -0.01012417f, 0.24351971f, -0.10739149f, 
    0.31481734f, -0.19406998f, 0.14581449f, 0.31099942f, 0.40092108f, 0.04341498f, -0.00117078f, 0.27973384f, 
    0.19391441f, 0.10636654f, -0.01272001f, -0.11676379f, -0.27819258f, -0.20550023f, 0.04098572f, 0.04275456f, 
    0.10632671f, -0.34209263f, -0.21489747f, -0.37292859f, 0.18993267f, -0.19296931f, 0.23147969f, 0.17033796f, 
    0.18095364f, 0.14450997f, 0.02981041f, -0.20631026f, -0.10717896f, -0.06246548f, -0.10565457f, -0.09164537f, 
    -0.15920626f, 0.03171832f, 0.02261546f, 0.20451654f, 0.43069938f, -0.19048260f, 0.14334755f, 0.05033287f, 
    0.11522042f, -0.06975102f, -0.05309181f, 0.04686309f, 0.51328188f, -0.02960374f, 0.31970760f, 0.07206950f, 
    -0.99705321f, 0.00583153f, 0.10505050f, -0.18975349f, 0.09503230f, 0.08371784f, 0.41181940f, -0.12073261f, 
    0.05284636f, 0.03674378f, -0.05830627f, 0.10590301f, -0.56629336f, -0.00648491f, 0.11884228f, 0.07375179f, 
    -0.24827754f, -0.35128406f, 0.18111505f, 0.27503040f, 0.03716455f, -0.03957028f, 0.15162392f, -0.26383948f, 
    -0.06632429f, 0.18463324f, -0.12293988f, 0.23020734f, -0.00698449f, 0.29503688f, 0.08520721f, -0.06706848f, 
    -0.49576178f, 0.54704690f, 0.02164560f, 0.24666536f, 0.27854890f, 0.51640421f, -0.68739122f, -0.49575266f, 
    -0.03743260f, 0.18927127f, 0.01474370f, -0.47493497f, 0.01340525f, -0.12350113f, -0.21199948f, 0.01048012f, 
    -0.08976803f, -0.48515648f, 0.06273150f, 0.44357041f, 0.09294865f, -0.02560721f, 0.04541342f, 0.00048954f, 
    0.03314846f, -0.10629342f, 0.23736559f, 0.31499204f, -0.07824661f, 0.25009844f, -0.13582967f, 0.28992695f, 
    0.26948187f, -0.02042577f, 0.08472385f, 0.32530326f, -0.11837521f, 0.05992283f, -0.33480284f, 0.17709419f, 
    0.12989038f, 0.12233128f, -0.04712306f, 0.18539971f, 0.35332149f, 0.36284697f, -0.05220909f, 0.00395234f, 
    0.02640390f, 0.32670927f, 0.18665203f, -0.29199967f, -0.04138395f, 0.05939026f, -0.09523541f, 0.24391048f, 
    -0.09463554f, -0.19977912f, -0.04773731f, 0.29460305f, 0.13157070f, -0.14599311f, 0.08156703f, -0.09007238f, 
    0.04214947f, -0.28567457f, 0.06933110f, 0.19998170f, -0.14428182f, -0.65089017f, 0.18638873f, 0.15895049f, 
    0.11662030f, -0.07261143f, -0.02563449f, 0.45889375f, -0.45134106f, 0.21976565f, -0.01163834f, -0.08033360f, 
    0.23712219f, -0.17720678f, 0.04447427f, -0.47278827f, 0.16080184f, -0.11397868f, 0.09267213f, 0.04457678f, 
    -0.02664302f, 0.06456579f, 0.05587801f, -0.00383612f, 0.09413987f, -0.08521760f, -0.00475974f, 0.03626839f, 
    0.18339302f, 0.05075380f, 0.10385867f, 0.46974397f, -0.01324704f, 0.00368214f, -0.63445997f, 0.02268719f, 
    0.29829493f, -0.31854188f, 0.28355399f, -0.18792690f, 0.17754103f, -0.01018169f, -0.15512446f, -0.01075502f, 
    0.00042382f, 0.36264929f, 0.14136791f, 0.06404938f, 0.13036440f, -0.18047698f, 0.12090817f, 0.24289252f, 
    0.18030904f, 0.08732685f, 0.08335426f, -0.22443880f, 0.08436078f, 0.20159748f, 0.04564840f, -0.11246026f, 
    0.16757573f, -0.18982327f, 0.04095798f, -0.02132760f, -0.17807721f, -0.37302974f, 0.31473905f, -0.12898260f, 
    0.51574999f, -0.16716008f, 0.00675570f, 0.48703229f, -0.17479531f, 0.02760330f, -0.13006918f, 0.05191352f, 
    0.20252326f, 0.08381891f, 0.06055525f, 0.16964842f, 0.18050614f, -0.13485348f, 0.11568399f, -0.26408985f, 
    -0.32368341f, 0.06545520f, -0.19631349f, -0.14711076f, 0.25135079f, -0.16862071f, 0.31332678f, 0.16607104f, 
    0.05309116f, -0.03141217f, 0.00541453f, 0.04595396f, 0.03843649f, -0.08610586f, 0.07321037f, -0.14881578f, 
    0.00866322f, -0.07879426f, -0.04815949f, 0.02568133f, 0.01401075f, -0.08137262f, 0.10007169f, -0.08509414f, 
    -0.05010341f, 0.07115403f, -0.06435625f, -0.04113249f, 0.04838100f, -0.16581795f, -0.10000452f, -0.00353940f, 
    -0.03224611f, -0.00219618f, -0.01381186f, -0.00729194f, -0.06554362f, -0.01543570f, -0.09932818f, 0.08260319f, 
    0.02698311f, -0.01683607f, -0.16931453f, 0.06269503f, -0.05701436f, 0.06307715f, -0.02438805f, 0.12473977f, 
    -0.02102118f, -0.06006753f, 0.04432371f, -0.04347337f, -0.02598141f, 0.00214099f, 0.00248357f, -0.07429400f, 
    0.01833656f, -0.07225804f, -0.04022886f, -0.11914748f, -0.11544705f, 0.05695192f, -0.03090215f, -0.03321515f, 
    -0.03889815f, 0.09295952f, 0.04640868f, -0.05871120f, -0.15286486f, -0.12024601f, 0.03841729f, -0.07837502f, 
    0.01712855f, -0.11618037f, -0.12025779f, -0.12540238f, -0.02128436f, -0.01724564f, -0.04461355f, 0.04446631f, 
    -0.15888284f, -0.08103351f, -0.08253102f, -0.14282511f, 0.01022858f, -0.07531361f, 0.04221909f, 0.01492740f, 
    -0.07176322f, -0.09788023f, -0.00643412f, 0.04352678f, 0.05079589f, -0.10257421f, -0.06345652f, -0.03229179f, 
    0.00793322f, -0.05667423f, 0.10599964f, 0.08885664f, 0.01134100f, -0.01713051f, 0.01232426f, 0.11785513f, 
    -0.04605421f, 0.04083031f, 0.04213251f, 0.02941205f, 0.08323927f, -0.00138466f, -0.09564813f, 0.09010682f, 
    -0.01220392f, -0.09388026f, -0.03870614f, -0.07000285f, 0.01261882f, -0.09545282f, 0.02526917f, 0.05222683f, 
    -0.15596658f, -0.00372022f, 0.09974852f, 0.09865496f, -0.04215406f, 0.05132109f, -0.00855380f, -0.06518285f, 
    0.00607927f, -0.10554655f, -0.12810160f, -0.05241438f, -0.10642733f, 0.03352372f, -0.04963005f, -0.13020925f, 
    -0.02446287f, -0.05406351f, -0.01240095f, 0.03536303f, 0.05948915f, -0.04278905f, 0.71145898f, 0.45381120f, 
    0.03600642f, -0.32011616f, 0.23272362f, -0.16503614f, 0.20751269f, -0.17749739f, 0.08756521f, -0.04643792f, 
    0.22233492f, 0.01117571f, -0.22502638f, 0.23627870f, 0.22346637f, 0.07744791f, -0.25130677f, 0.08411112f, 
    0.19366534f, 0.08978222f, 0.01700956f, -0.22640403f, -0.14627282f, 0.13667338f, -0.03562534f, 0.03818579f, 
    0.45979106f, -0.14886670f, -0.50052381f, -0.31745550f, -0.17977440f, 0.05378444f, 0.17091143f, 0.25533628f, 
    0.25047138f, 0.11585767f, -0.12225260f, -0.16341783f, 0.24512738f, -0.10455981f, 0.04241594f, 0.06934476f, 
    0.13067262f, -0.59411120f, -0.12351803f, 0.44869366f, -0.10182399f, 0.12096102f, 0.06700316f, 0.04716569f, 
    0.11199623f, -0.04579051f, -0.19993110f, -0.19618662f, 0.23231095f, 0.07186610f, 0.28609368f, -0.00188516f, 
    0.10870825f, -0.12974022f, -0.06385380f, 0.02026906f, -0.09687638f, -0.03266249f, 0.03361342f, -0.01242695f, 
    -0.11525861f, -0.12419735f, -0.01723959f, -0.04379304f, 0.02556848f, -0.04314949f, -0.05410329f, -0.02807757f, 
    -0.02772430f, -0.13142467f, 0.08831832f, 0.02810553f, -0.05565335f, -0.06244311f, 0.01619364f, 0.07925049f, 
    0.10875604f, -0.01896873f, 0.07675992f, 0.10439238f, -0.12037414f, -0.07474558f, 0.12227230f, -0.07900962f, 
    -0.08873665f, -0.06172892f, -0.06070974f, 0.11133036f, -0.06201044f, 0.05937840f, 0.05762646f, -0.02857296f, 
    -0.00419857f, -0.05132231f, 0.12347217f, -0.03490003f, -0.01905672f, -0.04001866f, -0.03007794f, -0.08099948f, 
    0.03100414f, 0.01325543f, 0.02145948f, 0.01490481f, 0.03172519f, 0.02914814f, -0.12792297f, 0.08375737f, 
    -0.01556522f, -0.06131208f, -0.06807785f, 0.01805468f, -0.08226252f, -0.06884931f, 0.02371416f, -0.01754699f, 
    0.17626850f, -0.17899142f, 0.15948941f, 0.20960090f, -0.05190538f, 0.23704937f, -0.18008614f, -0.01404928f, 
    0.26702186f, -0.04157658f, 0.03120899f, 0.02375771f, -0.12668206f, 0.30578047f, 0.17136781f, 0.12237448f, 
    -0.15196373f, -0.17095655f, 0.29951951f, 0.07119386f, 0.25577581f, 0.21958417f, 0.00213772f, -0.02492599f, 
    0.17148757f, 0.21955295f, -0.04624952f, -0.12367561f, 0.12198406f, -0.15590805f, -0.03769691f, -0.10685842f, 
    -0.30363598f, 0.08701599f, 0.13787600f, -0.38574532f, 0.84656030f, 0.14912628f, -0.14805166f, -0.16119592f, 
    -0.09952130f, 0.19534104f, -0.05108576f, 0.22184755f, 0.51588523f, 0.05763689f, -0.08251830f, -0.06919651f, 
    0.23715532f, -0.08234324f, -0.05923308f, -0.33848891f, 0.23074356f, -0.11796773f, 0.20931721f, 0.48127118f, 
    -0.08806839f, 0.00058252f, 0.12125316f, 0.28813493f, -0.05270448f, 0.48068446f, -0.19960028f, 0.30241492f, 
    0.11045960f, 0.01407405f, 0.24071960f, 0.06512997f, -0.03377970f, -0.01042399f, 0.21313909f, 0.26691696f, 
    0.04656069f, 0.06141409f, 0.00944512f, -0.19877420f, 0.30482334f, 0.21756519f, 0.16554216f, -0.08493048f, 
    0.19402120f, -0.20454904f, 0.06050092f, 0.00889882f, 0.20462304f, 0.04742500f, -0.21320464f, 0.12310012f, 
    0.29609159f, 0.01606132f, -0.00988093f, -0.41709101f, -0.04558045f, -0.00355613f, 0.10666859f, -0.09050553f, 
    -0.23642822f, -0.61946118f, 0.06786704f, -0.10698983f, 0.03914275f, -0.17794800f, 0.26537105f, 0.17147508f, 
    -0.02935524f, 0.06573606f, -0.02285183f, 0.09177350f, 0.53931379f, 0.13618706f, -0.00625139f, -0.02201122f, 
    -0.14465238f, 0.15564772f, -0.07483211f, 0.07921205f, 0.19911753f, 0.08756582f, 0.31813580f, -0.10536364f, 
    -0.21740147f, -0.03706931f, -0.13092154f, -0.12613975f, 0.21588987f, 0.04592382f, -0.03109743f, 0.01933052f, 
    -0.03562061f, 0.30775106f, 0.00969790f, 0.08495216f, 0.10896583f, 0.11594588f, 0.27421397f, -0.26635382f, 
    0.16092677f, 0.24081418f, -0.22889262f, 0.21059941f, 0.07333029f, -0.40923682f, 0.24696423f, -0.06527990f, 
    0.24644135f, -0.09618110f, 0.07143346f, 0.20239814f, -0.10455154f, 0.06519910f, 0.36958686f, -0.32890564f, 
    -0.29317671f, -0.77892435f, 0.08100957f, -0.04406865f, 0.37530667f, -0.64181209f, 0.02603871f, -0.09002571f, 
    -0.95291507f, -0.95674425f, 0.14004532f, -0.82670718f, 0.24017335f, -0.40566394f, 0.23651651f, -0.43092573f, 
    -0.08678731f, -0.12758757f, 0.00770958f, 0.27810669f, 0.24133807f, 0.00851724f, 0.28466257f, 0.03729382f, 
    -0.21530636f, 0.63587821f, 0.08449043f, 0.15716136f, -0.40741190f, 0.02807953f, 0.16842845f, 0.04069660f, 
    0.00594926f, -0.10061869f, 0.14009458f, -0.25393930f, 0.17605512f, 0.04489564f, -0.20639203f, -0.73854774f, 
    -0.09072983f, 0.07158896f, -0.00648409f, -0.04065410f, -0.12279561f, -0.01773944f, 0.05871773f, -0.10193179f, 
    0.06655083f, 0.03255066f, -0.14015131f, 0.06586516f, -0.08649920f, 0.07824381f, 0.01737290f, 0.10349289f, 
    -0.04753528f, -0.00376775f, -0.14289229f, 0.08235648f, -0.14903218f, -0.12043227f, -0.07963940f, 0.04377860f, 
    -0.02764547f, -0.12737246f, 0.08417477f, -0.16070507f, -0.02459883f, -0.04398121f, -0.11638363f, -0.05121116f, 
    -0.14647748f, 0.05505560f, 0.09825285f, 0.03745730f, 0.07977251f, -0.10454085f, 0.08869786f, 0.05771860f, 
    0.02464763f, -0.15492816f, -0.11500169f, -0.06252701f, -0.02193673f, -0.11049406f, 0.03624643f, 0.02284731f, 
    0.03117880f, 0.02539355f, -0.05786923f, -0.08591271f, 0.04397614f, -0.10922009f, 0.03763015f, -0.09304919f, 
    -0.07133862f, -0.03512391f, -0.08730146f, 0.07362434f, -0.11593444f, 0.00268559f, -0.07982431f, -0.11605616f, 
    0.00536178f, -0.04662237f, 0.09119774f, 0.15734519f, -0.11577433f, 0.05909370f, 0.29360723f, -0.63634628f, 
    0.04095059f, 0.19503947f, -0.37782058f, -0.20841622f, 0.12854698f, 0.15391825f, 0.15115523f, 0.05622724f, 
    -0.10337442f, -0.25854012f, 0.18682273f, 0.10905093f, 0.17607050f, -0.21991903f, -0.02351853f, 0.00034248f, 
    0.03042699f, -0.00153578f, -0.02188698f, -0.29663068f, -0.09614496f, -0.05019921f, -0.07866980f, 0.01816509f, 
    -0.15087265f, -0.49196795f, 0.13848393f, 0.23021755f, 0.29259476f, -0.12732138f, 0.10099392f, -0.18474308f, 
    0.07085340f, 0.14867078f, 0.04051939f, 0.19266841f, 0.05187814f, -0.05706997f, -0.13457319f, 0.02952942f, 
    -0.26818988f, 0.58381718f, -0.04744472f, -0.41889587f, 0.31015185f, -0.87037814f, 0.25449172f, -0.05717162f, 
    -0.70994079f, -0.06559519f, -0.09035770f, -0.16616938f, 0.17090853f, 0.04971626f, -0.53107071f, 0.03694178f, 
    0.07416088f, -0.04271242f, -0.13856995f, 0.07916551f, 0.11382709f, 0.03677149f, 0.08378272f, -0.13990967f, 
    0.01743513f, 0.00135008f, 0.00656206f, 0.00115173f, 0.05631496f, -0.07738817f, -0.08709510f, -0.03343599f, 
    0.05594180f, 0.07609984f, 0.00377639f, -0.08439428f, -0.06676344f, -0.08427003f, -0.13309373f, -0.07041777f, 
    -0.03251002f, 0.01775852f, -0.00451572f, -0.02308125f, -0.03211208f, -0.00238555f, 0.12055369f, 0.09370588f, 
    -0.02911188f, -0.16469496f, -0.05468193f, -0.02111246f, -0.14873749f, -0.09785399f, -0.03803156f, 0.06958534f, 
    -0.06768964f, 0.02999081f, 0.10536595f, -0.06603973f, -0.11276022f, 0.04153498f, -0.07963671f, 0.01743308f, 
    0.02091864f, -0.07659565f, -0.05008063f, -0.08412731f, 0.06322493f, -0.10032500f, 0.02464950f, 0.01438986f, 
    0.07705388f, -0.11333241f, 0.01581497f, -0.07417556f, 0.02868818f, -0.06448826f, -0.10698666f, -0.02587083f, 
    0.09574869f, 0.16949165f, 0.10597074f, -0.17876215f, 0.06346080f, 0.02783736f, -0.11596438f, -0.31924149f, 
    0.03103657f, 0.18821883f, 0.05952581f, 0.13732703f, 0.01653126f, -0.10700910f, 0.16304880f, -0.04480663f, 
    0.40292996f, 0.05218694f, 0.09147129f, 0.17276736f, -0.62751800f, -0.07170398f, 0.43395698f, 0.04602731f, 
    -0.19761370f, -0.28977680f, -0.07480849f, 0.17906873f, 0.37832478f, 0.21917574f, -0.07005273f, -0.08126537f, 
    0.10085955f, 0.07260357f, 0.32062462f, -0.60364956f, -0.08016953f, -0.04518991f, 0.10936646f, -0.04271586f, 
    -0.12498938f, -0.00691545f, -0.06861136f, -0.23255818f, -0.87821382f, 0.29953501f, 0.32028428f, -0.03696437f, 
    0.02906662f, -0.36102343f, 0.10172504f, 0.32167625f, 0.22451317f, -0.34692207f, 0.02636131f, -0.07244272f, 
    -0.09321721f, 0.04992612f, -0.04829386f, -0.12360194f, 0.00210486f, -0.54418081f, 0.10390518f, -0.61311740f, 
    -0.14111896f, -0.11118207f, -0.12374064f, 0.07837939f, 0.10421193f, -0.07818986f, -0.10500844f, -0.07441451f, 
    -0.15514772f, 0.04675728f, 0.07938452f, -0.08472773f, -0.02605547f, 0.05958784f, 0.04332635f, -0.02802271f, 
    -0.11823265f, -0.07134388f, -0.14867088f, -0.05282222f, -0.07071585f, 0.00897920f, -0.04647574f, 0.02156669f, 
    0.05700305f, -0.04620240f, 0.07592343f, -0.10714638f, -0.07767666f, 0.05597952f, 0.07375267f, -0.10951622f, 
    -0.12595294f, 0.05057170f, -0.03888480f, -0.02654639f, -0.07856199f, 0.04919080f, 0.04695498f, 0.02211159f, 
    -0.15751782f, -0.06982789f, -0.03855476f, -0.04717762f, 0.02656935f, -0.11265534f, 0.06434587f, 0.03677620f, 
    -0.05655291f, 0.03092980f, 0.05691034f, -0.11112207f, 0.01386029f, -0.10226487f, 0.06675389f, 0.00734250f, 
    -0.09960462f, -0.10454489f, -0.05253750f, 0.01907877f, 0.07647359f, 0.01358342f, 0.06319068f, -0.11845494f, 
    0.05842824f, 0.01271627f, 0.07392386f, 0.05924235f, 0.11130919f, -0.07460531f, -0.05360930f, -0.00497529f, 
    0.06071996f, 0.05711479f, -0.13233395f, -0.09965807f, 0.00082059f, -0.05869757f, 0.05886749f, -0.04189028f, 
    -0.11883099f, 0.05554564f, -0.12887907f, -0.03028413f, -0.03887447f, -0.11617604f, 0.01044413f, 0.06457956f, 
    -0.15280809f, -0.07502936f, -0.06417839f, -0.02646510f, 0.06178619f, -0.01348104f, 0.06260021f, 0.10224025f, 
    -0.11350620f, 0.09087983f, -0.04743450f, 0.03416086f, -0.11057463f, 0.00937686f, -0.00968656f, 0.05552408f, 
    -0.06995280f, -0.00136119f, -0.10193641f, -0.00738076f, 0.04477109f, -0.12877479f, -0.02439477f, -0.01029079f, 
    0.01144354f, -0.05667654f, 0.01249371f, -0.08783844f, 0.02118715f, -0.03183110f, -0.09050954f, -0.03789995f, 
    0.03951845f, -0.06852214f, 0.04710261f, 0.09269391f, 0.02817569f, -0.10508347f, 0.06926347f, -0.00355093f, 
    0.03222863f, -0.05671035f, 0.10133114f, 0.02664611f, -0.10236715f, -0.13875246f, -0.09098414f, 0.08187936f, 
    -0.12607256f, -0.14555973f, 0.09640951f, -0.02747653f, 0.03879185f, -0.11972141f, 0.07615238f, -0.10012916f, 
    0.09664528f, 0.04137577f, -0.08526049f, 0.09473609f, -0.00088846f, -0.01009769f, 0.09389316f, -0.03085256f, 
    0.12026127f, -0.10170413f, 0.08841674f, -0.03668721f, 0.03134155f, -0.04598260f, -0.04179242f, 0.05943795f, 
    -0.06557954f, -0.06977733f, -0.08784903f, 0.04602172f, -0.12058799f, -0.07832232f, -0.07770573f, 0.06721316f, 
    -0.06856286f, -0.00923241f, -0.00998493f, 0.04060758f, 0.00753486f, -0.07928751f, 0.05288230f, 0.00232930f, 
    -0.03865318f, 0.02539290f, -0.00858802f, -0.13772599f, 0.08126990f, -0.00316157f, -0.05856026f, -0.08665219f, 
    -0.11280463f, 0.06430192f, 0.09790222f, 0.04749075f, -0.07176481f, 0.00980090f, 0.00103320f, -0.08349255f, 
    -0.30242324f, -0.19183519f, 0.06795390f, -0.34943628f, 0.00194806f, 0.10507742f, 0.46827191f, -0.00056123f, 
    -0.16240519f, 0.26303700f, 0.19145180f, 0.09514036f, -0.36706737f, -0.14510970f, 0.16493215f, 0.00286193f, 
    -0.15642679f, -0.60039979f, 0.05942387f, 0.02226031f, 0.23957543f, -0.06488985f, -0.04775690f, -0.14079618f, 
    0.04663512f, -0.01067219f, 0.06599981f, -0.01087993f, -0.24043973f, 0.43531495f, -0.03428876f, 0.12230043f, 
    0.06073248f, 0.44253984f, -0.02865409f, 0.53022867f, 0.21736534f, 0.66952664f, -0.31296369f, -0.30127698f, 
    -0.12007085f, 0.05985087f, -0.08434089f, -0.59302872f, 0.44313329f, -0.00209171f, -0.01025387f, 0.00306846f, 
    -0.09101462f, -0.04982467f, 0.10365900f, 0.51443094f, -0.22974676f, 0.18679623f, 0.10489514f, 0.15620661f, 
    0.19079627f, -0.06125590f, 0.09430879f, 0.24681586f, 0.14969012f, 0.04348025f, 0.12035038f, 0.19804107f, 
    -0.04642016f, 0.00171921f, 0.03119259f, -0.08999164f, -0.02181873f, -0.07436431f, 0.13497421f, -0.13307780f, 
    0.02213404f, -0.08034720f, -0.07708021f, 0.01239905f, -0.03738572f, -0.10039562f, 0.00356797f, -0.10759968f, 
    -0.14101949f, -0.08724238f, -0.14677906f, 0.00144827f, -0.00834028f, -0.02696543f, 0.04338298f, -0.06193241f, 
    0.08042552f, -0.12523681f, -0.11278749f, -0.04735508f, 0.06707142f, -0.07913709f, -0.10029493f, -0.05069628f, 
    -0.15565908f, 0.00666674f, 0.06443508f, 0.08250013f, 0.03897597f, -0.09573735f, 0.04391266f, 0.10118249f, 
    -0.13334686f, 0.07606541f, 0.09657690f, -0.11759299f, 0.07181707f, -0.11744844f, 0.06201459f, -0.06757846f, 
    -0.03012010f, -0.07143877f, -0.04860443f, -0.13545661f, 0.02690949f, 0.05337987f, -0.14911108f, -0.12064555f, 
    -0.00594232f, -0.11496593f, -0.14625622f, -0.06879793f, -0.08565427f, -0.07017130f, -0.13188034f, 0.00918854f, 
    -0.12531084f, -0.14717175f, 0.09999764f, 0.14039186f, -0.02722220f, 0.16171224f, -0.28419310f, -0.18928522f, 
    0.29006451f, -0.23539424f, -0.05477562f, -0.08892010f, -0.54293191f, 0.07167146f, 0.13594474f, -0.11981338f, 
    -0.05680626f, -0.04327979f, -0.00427368f, 0.34786856f, -0.22982916f, 0.02122772f, 0.40027460f, 0.03246205f, 
    -0.00357068f, 0.26867992f, 0.02394192f, 0.19467850f, -0.12921022f, 0.03108979f, 0.10277274f, 0.09070099f, 
    -0.08385017f, 0.22608960f, 0.12086038f, -0.29634666f, 0.21886685f, 0.42685270f, -0.14650665f, -0.26925236f, 
    0.16471437f, 0.03510239f, 0.07422972f, 0.15598229f, -0.33942544f, 0.03855012f, -0.02014872f, -0.01666412f, 
    0.27211589f, -0.17987163f, -0.09109831f, 0.11925051f, 0.01248237f, -0.03862301f, 0.16098234f, 0.21533376f, 
    0.09179129f, 0.12373216f, 0.29844257f, 0.32069972f, 0.01251678f, 0.11353701f, -0.00055956f, 0.14346053f, 
    -0.02549303f, -0.20805319f, 0.06569086f, 0.02214393f, 0.08601424f, 0.07270940f, -0.23625712f, -0.00409853f, 
    0.05535541f, 0.07713251f, -0.08873796f, -0.22043355f, -0.07352594f, 0.40364614f, 0.28926930f, 0.07352525f, 
    0.11178818f, -0.26859286f, 0.35674304f, 0.08725131f, 0.18009530f, 0.06668412f, 0.02011437f, 0.28631338f, 
    0.09187118f, 0.04618036f, -0.09794574f, 0.00406548f, -0.18932490f, -0.15450197f, 0.04204941f, 0.06502450f, 
    -0.18167345f, -0.07274587f, 0.16221966f, -0.31637532f, 0.29863334f, -0.34552121f, -0.03216746f, -0.11573717f, 
    0.12430710f, 0.13722970f, -0.00016831f, -0.09153570f, 0.12196645f, 0.22350506f, -0.05207032f, -0.11123840f, 
    0.08891463f, -0.07763336f, -0.08634992f, -0.04626362f, 0.30273497f, -0.29727706f, 0.19788419f, 0.02390209f, 
    -0.22786203f, 0.02757603f, 0.09972019f, 0.20309798f, 0.17500024f, 0.07390704f, 0.08137663f, 0.15883803f, 
    0.18471509f, -0.31414208f, -0.31558549f, 0.14672302f, 0.09461114f, 0.17049626f, -0.08776803f, -0.01614950f, 
    -0.01334383f, 0.20323746f, 0.01403983f, 0.07978436f, -0.08502848f, 0.23415436f, -0.27733013f, -0.02853505f, 
    -0.12241367f, 0.36319968f, -0.00810745f, -0.45384708f, -0.14701729f, 0.42066160f, 0.34586266f, 0.09462524f, 
    -0.03817998f, -0.04528491f, -0.08455236f, 0.43940791f, 0.07463694f, 0.20586912f, -0.01761696f, 0.16765505f, 
    0.11413897f, 0.28310776f, 0.04541936f, 0.01534532f, 0.04598696f, 0.00720598f, -0.28212255f, -0.21975128f, 
    -0.22977783f, 0.00104856f, -0.07043996f, 0.08616994f, 0.10728803f, 0.23385142f, 0.12303746f, 0.06263684f, 
    0.13221237f, -0.11685737f, 0.12263899f, -0.34369871f, -0.09105187f, 0.15572467f, -0.15077145f, 0.19671053f, 
    0.34943238f, -0.05141012f, -0.00004201f, 0.24048211f, -0.08343733f, 0.34156275f, -0.07690331f, -0.11413308f, 
    0.11115634f, -0.10868762f, -0.19556803f, 0.36086136f, -0.10741597f, 0.17986552f, -0.03200034f, 0.16368118f, 
    0.33884156f, 0.13666511f, 0.09560072f, -0.11479015f, 0.08262838f, 0.46054330f, 0.01179299f, 0.04820572f, 
    -0.17075810f, 0.20652652f, 0.15172315f, -0.16706294f, 0.22507335f, 0.25255027f, -0.03568128f, 0.29233333f, 
    0.11988690f, -0.41848075f, -0.08090825f, 0.10074257f, -0.04338073f, 0.17455985f, 0.06526957f, -0.02462122f, 
    -0.36074761f, -0.59937304f, 0.29130694f, 0.61884022f, 0.07735046f, -0.40287718f, 0.04828783f, -0.05841104f, 
    0.07677244f, 0.16903976f, 0.08400428f, 0.47329646f, 0.45380685f, 0.20575576f, 0.09629734f, 0.03450440f, 
    -0.05531885f, -0.50028431f, -0.06419252f, -0.09962448f, 0.19642408f, -0.21121599f, 0.18926661f, 0.09721298f, 
    -0.11497585f, -0.00893617f, 0.05792990f, 0.03983061f, -0.00774944f, 0.14216390f, -0.25813970f, 0.10554182f, 
    -0.11463069f, -0.04938176f, 0.18853754f, 0.02321554f, -0.06939648f, 0.26560578f, -0.49251655f, -0.05708938f, 
    0.00522069f, -0.10973631f, -0.01744591f, 0.06423835f, -0.19319074f, 0.09740460f, 0.01140640f, -0.01163487f, 
    -0.07730835f, 0.01408545f, -0.03510889f, -0.18624179f, -0.24865811f, 0.17881078f, 0.01521329f, -0.01206114f, 
    -0.02200712f, 0.42041016f, 0.09254422f, 0.26130861f, -0.03889422f, 0.32125881f, 0.07323298f, 0.06711820f, 
    -0.12403622f, 0.35478607f, -0.05733556f, -0.31335914f, -0.04537342f, 0.78964084f, -0.20434797f, 0.00702571f, 
    0.02324577f, -0.03821447f, 0.11146235f, -0.03303220f, -0.49864051f, -0.13886958f, -0.18389256f, 0.11486603f, 
    0.31027824f, -0.35589558f, -0.03755161f, -0.35582060f, -0.05862638f, 0.16532651f, 0.19198993f, 0.31735921f, 
    0.25148731f, 0.07521710f, 0.18590805f, 0.40470630f, -0.30120873f, 0.39718989f, 0.09994427f, 0.22629309f, 
    0.23575500f, -0.29545125f, -0.21298599f, 0.17777862f, 0.06961507f, 0.06378800f, 0.05225055f, 0.12331536f, 
    -0.03828910f, -0.01982092f, 0.41931790f, 0.09378772f, -0.23941714f, -0.20979108f, -0.18922873f, -0.08071731f, 
    -0.24628459f, -0.02723133f, -0.12218777f, 0.03530107f, -0.05985626f, 0.15077451f, 0.53042990f, -0.09242621f, 
    0.29771528f, 0.26276669f, 0.06534947f, 0.24284488f, 0.05069890f, 0.72050047f, -0.04163612f, -0.03919905f, 
    0.30578774f, 0.49283290f, -0.04829457f, -0.02134517f, 0.63424212f, 0.65000457f, -0.05355141f, -0.12340655f, 
    -0.12166099f, -0.09815943f, 0.05793384f, -0.09025189f, 0.27588058f, 0.02456728f, 0.15444528f, -0.12019077f, 
    -0.04530844f, -0.32777447f, 0.01004146f, 0.80059779f, -0.31334537f, -0.04980675f, 0.01502300f, -0.01428312f, 
    0.27958968f, 0.09372500f, -0.06814354f, -0.02077234f, 0.11212490f, -0.11857775f, 0.07268005f, -0.22253382f, 
    0.07886008f, -0.00401981f, 0.07708849f, -0.04211460f, -0.09932765f, 0.05486020f, 0.36720520f, 0.23805162f, 
    -0.24143721f, -0.12303255f, 0.32223737f, -0.12732187f, 0.19909254f, -0.14071938f, 0.03958433f, 0.12486902f, 
    0.25877061f, -0.00719584f, -0.15147631f, 0.22023086f, 0.15263176f, 0.11175009f, 0.20573333f, 0.12443358f, 
    0.24411066f, 0.06271343f, 0.03841999f, 0.00376892f, -0.00636458f, 0.06146657f, -0.02048300f, 0.08446916f, 
    0.44343597f, -0.07683903f, -0.10090279f, -0.13185669f, -0.00884977f, -0.01282446f, 0.11791632f, 0.11178736f, 
    0.05239782f, 0.08129819f, -0.07049440f, -0.25517842f, 0.23988141f, 0.18376876f, 0.21360092f, 0.03520336f, 
    -0.09022623f, -0.02201275f, 0.05149755f, 0.61308599f, -0.27431497f, 0.20459360f, 0.12881991f, -0.19670349f, 
    0.11238765f, 0.09742226f, -0.20422113f, -0.26181495f, 0.26137212f, -0.03821726f, 0.32866871f, -0.27934965f, 
    -0.11275607f, 0.03003325f, -0.10359546f, -0.06465104f, 0.02434285f, -0.01660329f, 0.14025877f, -0.06018094f, 
    -0.09151566f, -0.12801810f, 0.00903297f, 0.07095152f, 0.09431648f, -0.10078643f, 0.05328961f, 0.02766106f, 
    0.09663410f, 0.02750809f, -0.03942684f, -0.06448308f, -0.00042115f, -0.08032177f, -0.04996615f, 0.04116654f, 
    -0.07190483f, -0.09208728f, 0.05894869f, 0.01119712f, -0.08251225f, 0.06833541f, 0.09392245f, -0.08273774f, 
    -0.10023614f, 0.00641365f, -0.10758954f, -0.09344063f, 0.01755011f, -0.01844748f, 0.04109468f, 0.03060954f, 
    0.01369473f, -0.14030744f, -0.07634409f, -0.08028563f, -0.05015215f, 0.08239007f, -0.00680835f, 0.00115664f, 
    -0.08087508f, -0.11051410f, 0.12009841f, 0.09566725f, -0.04887832f, -0.00772546f, -0.11092870f, 0.02258735f, 
    -0.12327098f, 0.08338830f, -0.07549430f, -0.07267581f, -0.09482905f, 0.08774637f, 0.03089828f, 0.06251787f, 
    -0.14507265f, -0.11996060f, 0.05687887f, -0.39919418f, -0.09879604f, 0.06094386f, 0.20970277f, -0.01066664f, 
    -0.32098198f, -0.30078417f, -0.15214968f, -0.13238820f, 0.09448745f, -0.18327075f, 0.26792157f, -0.01363102f, 
    0.21753754f, -0.39635244f, -0.19488801f, 0.24796188f, 0.23694196f, -0.00325862f, -0.01811330f, 0.07046420f, 
    -0.03241140f, 0.09904610f, 0.12235080f, -0.18297887f, -0.06429550f, -0.13336405f, -0.07133207f, 0.00619880f, 
    0.16692303f, 0.01487280f, -0.29980245f, 0.01157220f, 0.39422315f, 0.12892300f, 0.09041470f, 0.19001810f, 
    -0.05441506f, 0.11317332f, -0.07168809f, -0.48538470f, 0.52481657f, -0.01439757f, -0.10871074f, 0.02733433f, 
    -0.21062103f, 0.19265847f, -0.06892677f, 0.42803082f, 0.14329894f, 0.10487349f, 0.01261188f, 0.22981361f, 
    -0.00602757f, -0.03665629f, -0.13971032f, -0.13778751f, 0.28509733f, 0.11620268f, 0.28695196f, 0.03242062f, 
    0.31665337f, -0.21005784f, 0.03447811f, 0.27619576f, -0.09832400f, 0.10975761f, 0.02868818f, 0.23177713f, 
    0.05199682f, 0.26945844f, -0.03303844f, 0.19994158f, 0.05159201f, 0.45261559f, 0.03213076f, -0.10778666f, 
    -0.03645647f, 0.09493402f, 0.11717401f, -0.16412143f, 0.07221907f, 0.14596748f, -0.10121666f, 0.11669021f, 
    0.04316841f, -0.22204402f, -0.06626182f, -0.00951016f, 0.17977573f, 0.01343560f, -0.04259144f, -0.13576537f, 
    -0.24293192f, -0.27349332f, 0.17410867f, 0.47292179f, 0.09481761f, -0.42082238f, 0.06666337f, -0.03490802f, 
    -0.07488516f, 0.19095817f, -0.08519184f, 0.18319896f, 0.35032517f, 0.13356979f, 0.33957607f, 0.03609543f, 
    -0.10043946f, -0.11642411f, 0.09570441f, 0.07603083f, 0.24489768f, -0.09391646f, 0.17702994f, 0.11707558f, 
    -0.12288146f, -0.03608298f, -0.15799834f, -0.03026336f, 0.15375283f, -0.12970875f, -0.11638407f, -0.00304423f, 
    0.06570836f, -0.23581357f, 0.20221221f, -0.18317813f, -0.01072569f, 0.08934678f, -0.11542684f, 0.18527003f, 
    -0.20853892f, 0.25018096f, 0.07258233f, 0.14515115f, 0.04239412f, 0.22613177f, 0.08341048f, 0.07968141f, 
    0.38874614f, 0.10673557f, 0.14115329f, -0.20706709f, -0.06856533f, -0.13504517f, -0.22492917f, 0.19657627f, 
    -0.34636930f, 0.07870936f, -0.06595130f, 0.15571035f, 0.03713523f, 0.47407043f, -0.08724210f, -0.15279242f, 
    0.50674862f, 0.20141470f, 0.16214475f, 0.50656158f, -0.33596796f, -0.14310066f, 0.31164768f, -0.15222323f, 
    -0.09942390f, 0.06956794f, 0.08592080f, -0.13558950f, -0.03714316f, 0.23852134f, 0.30778164f, -0.16774805f, 
    -0.01659543f, 0.89500672f, -0.07154459f, 0.15650436f, 0.23699133f, 0.03963082f, 0.15492573f, -0.13901472f, 
    0.08498807f, -0.11223406f, -0.09412883f, 0.04024475f, -0.03801330f, -0.17132087f, 0.11340787f, -0.00772866f, 
    0.08997902f, 0.07584795f, -0.06796951f, -0.04579302f, 0.00219001f, -0.06815685f, 0.00226080f, 0.04970600f, 
    -0.14150469f, -0.02569943f, 0.02398823f, 0.06788159f, -0.02000380f, -0.09178773f, 0.00615363f, -0.06824854f, 
    -0.02300782f, -0.11631249f, -0.10997913f, 0.03599355f, -0.11613417f, -0.12040905f, 0.06593497f, -0.07518441f, 
    -0.00435877f, 0.08222283f, 0.04180062f, -0.08035485f, 0.06085496f, 0.06488241f, -0.09397985f, -0.08666897f, 
    0.00487344f, 0.04540199f, 0.10028660f, 0.02229112f, 0.09712622f, -0.07458733f, -0.10392249f, 0.03929264f, 
    -0.03555078f, -0.00429058f, 0.09334274f, -0.09996730f, 0.10747168f, -0.02257113f, -0.13262472f, 0.12489261f, 
    -0.03146529f, -0.09876973f, 0.10430156f, 0.05986526f, 0.08674176f, 0.01233930f, -0.05696731f, -0.12953928f, 
    0.03250566f, -0.04098263f, -0.14182612f, -0.08338843f, -0.03704026f, 0.02558303f, -0.13939787f, 0.05302928f, 
    0.42689532f, 0.10332944f, -0.16594072f, 0.21589144f, -0.07097550f, -0.10257164f, -0.00181193f, 0.34463137f, 
    -0.06771826f, 0.03712755f, 0.09987417f, 0.28109983f, 0.23361363f, 0.07026379f, -0.23624605f, -0.04894787f, 
    0.06141268f, 0.57510978f, -0.05903140f, -0.63502955f, -0.03335221f, 0.29499671f, -0.06984829f, 0.16376735f, 
    0.14354086f, -0.10592899f, 0.09103325f, 0.20677033f, 0.13372344f, 0.11213903f, 0.10709828f, 0.13068251f, 
    0.39514777f, -0.06188449f, 0.05397724f, -0.05754863f, -0.90805966f, -0.10570040f, 0.10395443f, -0.03349355f, 
    -0.09764760f, -0.19087310f, 0.03132803f, 0.24362043f, -0.07734817f, 0.04639567f, 0.09859630f, 0.01020021f, 
    0.08425067f, 0.36321172f, 0.05383839f, -0.47299007f, -0.13738026f, 0.16174547f, -0.12568417f, -0.02754993f, 
    0.25322565f, 0.01790400f, -0.06275207f, -0.02943775f, -0.10048541f, 0.17454156f, 0.03818813f, -0.02622958f, 
    -0.10928212f, -0.02223223f, 0.13801144f, 0.25006121f, 0.00098722f, 0.04886147f, 0.20652620f, -0.20543854f, 
    0.19649889f, -0.37781125f, 0.17376423f, -0.17521098f, 0.19539911f, -0.31228644f, -0.25772446f, 0.01760486f, 
    -0.25510794f, 0.26831505f, -0.02978332f, -0.31217399f, -0.07321410f, -0.04951360f, -0.39627847f, -0.34010589f, 
    0.37763619f, 0.45850039f, -0.09703615f, -0.80462074f, -0.21987963f, -0.28189090f, -0.00246069f, 0.04927646f, 
    -0.00735004f, 0.31062809f, -0.23545377f, 0.29621568f, -0.33185065f, 0.82358146f, -0.03956905f, 0.30220386f, 
    0.01915985f, -0.22486623f, 0.10910045f, 0.28884226f, -0.47017241f, -0.43187350f, -0.69486153f, 0.03348286f, 
    0.38780141f, -0.14016293f, -0.07004839f, -0.56645328f, 0.04042189f, 0.15688275f, 0.22297607f, 0.28165427f, 
    0.13875102f, 0.09277603f, 0.20798025f, 0.23184447f, -0.56131893f, 0.48092976f, 0.20279990f, 0.38166809f, 
    0.04772484f, 0.05121592f, 0.06407622f, -0.22158806f, -0.01332921f, -0.24238496f, -0.30819452f, 0.11845165f, 
    -0.05126016f, 0.06042803f, -0.20139553f, -0.07119068f, 0.45322061f, 0.34307870f, 0.14667775f, 0.09437367f, 
    0.15335099f, -0.00465077f, 0.33591664f, 0.30284262f, 0.33645752f, -0.22814654f, -0.75093865f, 0.18188341f, 
    -0.21244290f, -0.33668873f, 0.04805400f, -0.09865528f, 0.12705752f, -0.29861104f, 0.07690071f, -0.13738327f, 
    0.04013630f, -0.16808927f, -0.11319260f, 0.71298629f, -0.31572655f, -0.02793444f, 0.29220229f, -0.32139629f, 
    0.30344209f, 0.15297769f, -0.09177756f, -0.18230067f, 0.08203766f, 0.07397405f, 0.02753995f, -0.14154318f, 
    -0.11918693f, 0.08630006f, -0.05341727f, -0.27849749f, 0.52342039f, -0.36200759f, -0.05332601f, 0.16497554f, 
    -0.18798846f, 0.08405863f, -0.14589770f, 0.02073001f, 0.19406325f, -0.11469691f, 0.03992695f, 0.34339699f, 
    -0.02559358f, 0.04626821f, -0.08314959f, -0.02702093f, 0.01307569f, -0.14698392f, -0.07062588f, -0.01222665f, 
    -0.00785051f, -0.13258377f, -0.01852922f, -0.03284490f, -0.08532184f, -0.13239875f, 0.06326213f, -0.06918821f, 
    -0.06040353f, 0.10088357f, -0.08953670f, 0.01123630f, -0.01482234f, 0.04751269f, 0.08817084f, -0.01602727f, 
    -0.03850525f, -0.04131910f, -0.08553427f, -0.00042883f, -0.00772713f, 0.06147794f, -0.05019352f, -0.02496406f, 
    -0.10568139f, -0.04203606f, -0.09741041f, -0.10840092f, 0.09820415f, -0.03240491f, -0.09694191f, -0.10262101f, 
    -0.03821085f, -0.00914563f, -0.09939733f, 0.09656297f, -0.09706635f, -0.13047697f, 0.05101759f, 0.06115329f, 
    -0.03817996f, -0.05177814f, -0.07164124f, 0.04178631f, -0.03571843f, -0.00091484f, 0.00983372f, -0.02935684f, 
    -0.11310572f, -0.02520056f, -0.12399839f, -0.10371374f, -0.10078178f, -0.02050511f, -0.12518081f, -0.10353053f, 
    0.06299257f, -0.65338153f, 0.14545192f, -0.05695439f, 0.08896188f, 0.11449524f, -0.06236302f, -0.05679423f, 
    -0.11214273f, 0.24921347f, 0.01044513f, 0.13711187f, -0.14183657f, 0.27611458f, 0.03046818f, 0.06757566f, 
    -0.02717619f, -0.11963625f, 0.10053734f, -0.26253685f, 0.07872924f, 0.13721786f, 0.17955580f, 0.11053646f, 
    -0.02277903f, 0.10045044f, -0.10435864f, 0.06417201f, -0.05147625f, 0.73779094f, -0.06404984f, -0.11504550f, 
    0.08957860f, 0.46534511f, 0.14414008f, -0.03741268f, 0.14934708f, 0.65767157f, -0.12867986f, -0.42093498f, 
    -0.24702036f, 0.06396124f, 0.03805802f, -0.04639588f, -0.03436223f, 0.02779137f, 0.23872194f, 0.01033354f, 
    -0.13379164f, 0.63152236f, 0.06044003f, 0.14227618f, -0.01272375f, 0.15648331f, 0.16440439f, 0.04932220f, 
    -0.07952157f, 0.02865686f, -0.01189520f, 0.25365376f, -0.20377542f, -0.02657955f, -0.18811271f, 0.21399473f, 
    0.03752048f, 0.18310128f, 0.10050373f, 0.20449547f, 0.04225011f, -0.06077001f, -0.56310266f, -0.02621337f, 
    0.33158413f, -0.18563335f, 0.33013803f, -0.40645140f, 0.21333814f, -0.10286116f, 0.09154882f, -0.02214673f, 
    0.07199200f, 0.16412681f, 0.17065485f, 0.27816537f, 0.21589665f, -0.42328608f, -0.27208197f, -0.01606059f, 
    0.13253154f, 0.41500953f, -0.09397236f, -0.40538526f, -0.17891990f, 0.38085756f, -0.00345249f, -0.14829448f, 
    0.15167721f, 0.21689175f, 0.08175798f, -0.28050864f, 0.04274810f, -0.18565442f, 0.23078325f, 0.13172963f, 
    0.20671533f, -0.06122309f, -0.00259499f, 0.23598441f, 0.02016207f, -0.12340153f, -0.19929330f, 0.07535116f, 
    0.14736339f, 0.19383430f, 0.07266144f, 0.27331772f, 0.16461892f, -0.01853827f, 0.22914602f, -0.25150925f, 
    -0.25025994f, -0.09521320f, -0.09478001f, 0.14261048f, -0.01323146f, -0.28831863f, 0.34514365f, 0.24637337f, 
    0.07696775f, 0.00014705f, 0.30994368f, 0.15548606f, -0.05493461f, 0.16695800f, -0.15763456f, -0.08231388f, 
    0.37130913f, -0.10233866f, 0.14609040f, -0.21409443f, -0.01983388f, 0.31060162f, 0.17108941f, -0.03449193f, 
    0.07679708f, -0.15718949f, 0.21297328f, 0.26909831f, 0.14105095f, -0.08421285f, -0.10791598f, 0.12824096f, 
    0.13423119f, 0.22942217f, -0.11111127f, -0.08573040f, -0.09991948f, 0.09784444f, 0.04877226f, -0.05841811f, 
    -0.09124160f, -0.30545771f, 0.05586623f, -0.38671830f, 0.31455353f, -0.32875487f, -0.05672505f, -0.10405954f, 
    0.22939362f, 0.21291965f, -0.12031437f, 0.09612118f, -0.06242797f, -0.13683264f, -0.23010163f, 0.03886279f, 
    0.14750996f, 0.28655148f, 0.01952146f, -0.07805604f, 0.25072449f, 0.03477184f, 0.24114335f, 0.24149565f, 
    -0.00361282f, -0.07509457f, 0.14969893f, 0.21731889f, 0.13303414f, -0.09475171f, 0.03340563f, 0.32307097f, 
    0.11015780f, -0.07444066f, -0.08125602f, -0.03278041f, -0.06781454f, 0.12230583f, 0.00338601f, -0.11287938f, 
    -0.01049502f, -0.04700531f, 0.07017845f, -0.08053355f, 0.01075570f, -0.07530387f, -0.03280021f, 0.11061911f, 
    -0.10654916f, 0.09520766f, -0.04511678f, -0.08916266f, -0.11630028f, -0.08683874f, 0.04624316f, -0.10101929f, 
    -0.02493811f, -0.03584862f, 0.05922125f, -0.03128368f, 0.01923051f, -0.11896965f, -0.06929973f, -0.03117223f, 
    -0.02408782f, -0.09876105f, -0.04390500f, 0.07944618f, -0.04687037f, -0.00269596f, -0.03736992f, -0.07168701f, 
    -0.02395226f, -0.12466697f, -0.01567365f, -0.09354165f, 0.06106958f, -0.09149081f, 0.07280093f, 0.04270804f, 
    -0.05626336f, -0.04276402f, -0.09320250f, -0.03272422f, 0.01844983f, -0.04882444f, 0.05867097f, -0.09794211f, 
    -0.11165151f, 0.07801720f, 0.06270382f, 0.07925309f, -0.01286322f, -0.12383279f, 0.07649301f, -0.02950753f, 
    0.21004063f, -0.22643480f, 0.08606379f, 0.05138588f, 0.10252379f, -0.20384224f, -0.64885354f, 0.21902132f, 
    -0.11069339f, 0.08333427f, 0.47161773f, 0.29143104f, -0.21575283f, 0.10277711f, -0.37186581f, -0.02760090f, 
    0.11858920f, 0.16388595f, -0.11080629f, -0.11179919f, -0.38694707f, 0.01669300f, -0.01962600f, 0.24491426f, 
    -0.22457848f, 0.16309543f, -0.01137169f, 0.20533165f, 0.06540914f, 0.52800632f, -0.11796409f, 0.05070674f, 
    0.60256881f, 0.54538214f, 0.02643437f, 0.38671082f, -0.69673622f, -0.28481069f, 0.02726575f, -0.08083788f, 
    0.23268235f, 0.12344200f, -0.11407282f, -0.13606514f, -0.85974407f, 0.17555362f, 0.12555578f, 0.03199993f, 
    0.01686885f, -0.01366996f, 0.03968595f, 0.50215393f, -0.21475242f, 0.00122192f, 0.02685791f, -0.52858973f, 
    0.25046095f, 0.11318456f, -0.32970002f, 0.05331874f, 0.13720542f, -0.57558757f, 0.38766399f, 0.09224331f, 
    -0.04166293f, 0.28995126f, 0.33770284f, 0.16483243f, -0.03701961f, -0.05608870f, -0.34248024f, -0.09201893f, 
    0.28948838f, -0.08034527f, -0.06912912f, -0.04491731f, 0.15674043f, 0.37325984f, 0.00150203f, -0.09479372f, 
    0.20566015f, 0.28891218f, 0.32463473f, -0.13382475f, -0.16128129f, -0.11812151f, -0.20879807f, 0.15343681f, 
    -0.23888001f, 0.09962893f, -0.05854095f, 0.02522179f, -0.01387122f, 0.19886214f, -0.04288058f, 0.05247913f, 
    -0.01337982f, -0.20290440f, 0.05230189f, 0.20623817f, -0.31385720f, -0.60086268f, 0.01833827f, 0.22331689f, 
    0.27627811f, 0.07114326f, -0.02601722f, 0.35027006f, -0.40932140f, 0.02258428f, -0.16516298f, 0.07748368f, 
    0.25601649f, 0.51482153f, -0.09648569f, -0.03786083f, 0.52519268f, -0.05157334f, 0.22328514f, 0.06439340f, 
    -0.21793476f, -0.09301823f, 0.12255999f, 0.30917379f, -0.05652027f, -0.23428686f, -0.04304120f, 0.19821903f, 
    -0.01967641f, -0.00537345f, -0.06561386f, -0.04767590f, 0.02296425f, -0.12298185f, -0.04679138f, 0.10490122f, 
    0.08104266f, -0.10622157f, -0.03254972f, 0.05694729f, 0.12175445f, 0.00442902f, 0.05410931f, 0.05150867f, 
    -0.08808926f, -0.04943152f, 0.08714850f, 0.04096963f, -0.09223302f, -0.11253437f, 0.06369381f, -0.06737435f, 
    0.05865806f, -0.03376939f, 0.00474994f, -0.06026625f, 0.09201808f, -0.11002526f, 0.10145999f, -0.01672189f, 
    0.00673148f, 0.11546151f, -0.03958154f, 0.08767320f, -0.00427411f, -0.06014292f, -0.09984002f, 0.09035937f, 
    0.04736459f, -0.05683525f, 0.05787009f, -0.10125315f, -0.07622292f, 0.02691525f, 0.07374888f, 0.05188827f, 
    0.06559979f, 0.01773643f, -0.10101141f, 0.03859960f, -0.03051177f, -0.06069679f, -0.08431256f, 0.08079748f, 
    0.00873046f, 0.09017581f, -0.05486293f, 0.01999853f, -0.04739318f, -0.02571095f, -0.06207286f, -0.09540740f, 
    -0.41914469f, -0.00698350f, -0.15586667f, -0.04427823f, -0.08639945f, 0.06150219f, 0.26131934f, -0.01418437f, 
    0.00927154f, 0.31928101f, 0.40205517f, 0.15735489f, -0.35302231f, 0.16618070f, -0.22062169f, 0.01619433f, 
    -0.29358965f, 0.00164531f, -0.02432401f, 0.13856444f, -0.24126250f, -0.28233141f, 0.08539620f, -0.14679381f, 
    -0.13012330f, -0.09098514f, -0.01577288f, 0.19401671f, -0.23079129f, 0.50099891f, 0.10231856f, 0.20502901f, 
    -0.06748173f, 0.12914354f, 0.00793767f, 0.92138821f, -0.26612332f, 0.02896558f, -0.33606654f, -0.35967329f, 
    0.25913242f, 0.16306947f, -0.09454814f, -0.34531102f, -0.54458153f, -0.08675228f, -0.35190028f, -0.08850884f, 
    0.16556321f, 0.00664517f, 0.06853072f, 0.39645404f, -0.00446471f, 0.09202702f, -0.06385083f, 0.03617645f, 
    0.00657186f, 0.06852984f, 0.11692761f, 0.12178939f, -0.10957159f, -0.24981241f, -0.19943263f, 0.15071349f, 
    -0.42864981f, 0.05015975f, 0.03498074f, -0.14247192f, 0.01560454f, 0.28578016f, 0.52431041f, 0.26209128f, 
    -0.08813048f, 0.36536577f, 0.13687681f, 0.38015106f, -0.19945526f, -0.29108903f, -0.10079442f, 0.06684375f, 
    0.02226712f, -0.19600946f, -0.21057102f, -0.05773094f, -0.12949339f, 0.18545242f, -0.07305422f, -0.16641019f, 
    0.28027102f, 0.09127230f, -0.11499818f, 0.10068092f, 0.00507427f, -0.03648325f, 0.01810874f, -0.00267996f, 
    -0.27877516f, 0.21872158f, -0.08364211f, 0.33763605f, -0.07940147f, 0.54682565f, -0.20870619f, -0.10763888f, 
    -0.39777103f, 0.09424655f, 0.09671203f, -0.48914972f, 0.15609233f, -0.05878393f, -0.03737716f, 0.08909789f, 
    0.03180989f, 0.44792542f, -0.00309378f, 0.21380447f, -0.74510056f, 0.27295461f, 0.05638567f, -0.02392271f, 
    0.16791236f, -0.11252451f, 0.17297702f, 0.02824167f, -0.21612151f, 0.17724040f, 0.07769024f, -0.16234156f, 
    -0.06748205f, 0.26891914f, 0.16473751f, -0.00279154f, 0.03453855f, 0.01722236f, -0.19545592f, 0.09271041f, 
    0.13093656f, -0.39104220f, 0.20454273f, -0.24128243f, 0.11011347f, -0.00985933f, 0.01847979f, 0.10228623f, 
    0.28895018f, 0.26070663f, -0.00138880f, 0.52196455f, 0.07975856f, -0.29260886f, -0.23989935f, 0.17549987f, 
    -0.04439589f, 0.38796318f, 0.04201721f, -0.15659243f, -0.17369311f, 0.17768210f, -0.00040123f, 0.02392037f, 
    0.43307617f, 0.04289699f, -0.21608141f, -0.14853255f, -0.05699682f, -0.32093737f, 0.33548135f, 0.51003408f, 
    0.57300138f, 0.07527090f, 0.09948940f, 0.07379855f, -0.31293073f, -0.19166440f, -0.32365522f, 0.03067852f, 
    0.22952242f, -0.12468595f, -0.04745997f, 0.41114947f, 0.11467432f, -0.03001049f, 0.05157176f, -0.19280347f, 
    0.00789854f, 0.10231291f, 0.02003829f, 0.12979440f, 0.20290814f, -0.35375258f, 0.35135889f, 0.13752571f, 
    0.08647170f, -0.22252582f, -0.14415808f, 0.29882231f, 0.00724424f, 0.20323047f, 0.38932216f, 0.36886629f, 
    0.07963703f, 0.00600342f, 0.13344525f, 0.00728881f, 0.17822249f, 0.14926215f, -0.15800436f, 0.01514885f, 
    -0.14456055f, 0.13446428f, -0.12904863f, -0.15764874f, 0.11567735f, 0.46538582f, -0.14764163f, 0.26157436f, 
    0.45071530f, -0.21464893f, -0.06176318f, 0.07519015f, 0.10605758f, 0.08833103f, 0.03784877f, -0.12422247f, 
    -0.15416451f, -0.36978137f, 0.08995665f, -0.14889456f, 0.14508051f, 0.01447772f, -0.01855619f, 0.51137024f, 
    0.09643923f, -0.06833734f, -0.10144040f, 0.22600788f, 0.32926610f, 0.20306498f, 0.24522477f, 0.01061444f, 
    0.23017702f, -0.43732715f, -0.05375980f, -0.04899300f, -0.19513454f, 0.19852436f, 0.12752353f, 0.12711941f, 
    0.14732176f, 0.03441913f, 0.08787747f, -0.19540228f, -0.02510099f, 0.31501850f, 0.00703163f, -0.03878203f, 
    0.12902774f, -0.08320732f, -0.10996473f, 0.04701583f, -0.04952970f, -0.10149359f, 0.10694931f, -0.03972614f, 
    -0.06416414f, 0.01680212f, -0.05020814f, -0.00192753f, 0.11967144f, -0.11285011f, 0.00047335f, -0.02553935f, 
    -0.02598758f, -0.07311998f, -0.01966303f, -0.09713496f, -0.04909570f, -0.07396170f, 0.07095937f, 0.00164625f, 
    -0.07009236f, 0.07712723f, 0.01896961f, -0.01205348f, -0.05082753f, -0.00086451f, -0.11542444f, -0.09610923f, 
    -0.08137167f, 0.05466092f, 0.04705986f, 0.06092137f, -0.15565902f, 0.02786450f, 0.02253938f, 0.09900254f, 
    -0.04453035f, -0.01323856f, 0.01513717f, 0.08739315f, 0.02289978f, -0.10249190f, -0.03776010f, -0.02757725f, 
    -0.01661971f, -0.05329308f, 0.09242690f, -0.08985860f, -0.03226305f, -0.15551357f, -0.03819850f, 0.02525763f, 
    -0.13769659f, -0.12059331f, -0.00527829f, -0.09953075f, -0.00631783f, -0.10819851f, -0.06376704f, 0.03199047f, 
    -0.02836988f, 0.05310497f, -0.08617792f, 0.01985984f, 0.05947635f, -0.04337589f, 0.06709681f, 0.03743307f, 
    -0.01433635f, -0.00871960f, 0.03541445f, -0.08036792f, -0.11994398f, -0.00940670f, 0.02789796f, -0.09129098f, 
    0.02673123f, 0.02819087f, -0.12825976f, 0.03924962f, -0.02918044f, -0.09498325f, -0.02379004f, -0.07367399f, 
    0.08561298f, 0.05407294f, -0.00663978f, -0.04300239f, -0.12667988f, 0.07496241f, -0.07459788f, 0.01924220f, 
    0.02494124f, -0.02453883f, 0.02482510f, 0.08057464f, -0.11164692f, -0.12086274f, 0.00165201f, -0.07562725f, 
    0.01292561f, 0.08432853f, 0.02995095f, 0.10304288f, 0.04353078f, -0.00566465f, -0.06573512f, 0.12368013f, 
    0.04727132f, 0.09684304f, 0.05138846f, -0.01264887f, -0.10801502f, -0.09547316f, -0.01243661f, 0.09307068f, 
    -0.12913702f, 0.00446557f, -0.02870141f, -0.08253784f, 0.02746306f, 0.00569110f, -0.02656921f, -0.16309834f, 
    -0.13454582f, 0.05678885f, 0.06539512f, -0.05730523f, -0.04468514f, 0.02383156f, 0.02450407f, -0.12284758f, 
    -0.11508137f, -0.08313820f, -0.01690981f, -0.07731614f, -0.10597533f, -0.05383314f, -0.03708952f, 0.00383401f, 
    -0.00508609f, -0.10166635f, -0.13638820f, -0.12460809f, -0.08150707f, -0.08675654f, -0.02157130f, 0.04705355f, 
    -0.10569187f, -0.03337597f, 0.10894106f, -0.07649305f, 0.07879963f, -0.05558730f, -0.01619272f, -0.06014280f, 
    0.06587279f, 0.01798316f, -0.07488249f, 0.05334532f, -0.10428688f, -0.08124298f, 0.07927641f, -0.07033502f, 
    0.02024015f, -0.06511309f, -0.08733097f, -0.00865655f, 0.05605380f, -0.11747532f, -0.09033467f, 0.05000195f, 
    0.03718367f, -0.10893962f, -0.04387279f, -0.04012860f, -0.05603927f, -0.04906343f, -0.03572427f, -0.07071847f, 
    0.02123655f, 0.05406110f, -0.08404320f, -0.04675030f, -0.01025722f, 0.04470861f, -0.13634910f, -0.14379008f, 
    -0.04737160f, 0.12688835f, 0.04920388f, -0.37215200f, 0.11055905f, 0.12009075f, 0.24402750f, 0.06835533f, 
    -0.28757012f, -0.00478619f, -0.44216409f, -0.10937972f, 0.20306154f, 0.00287778f, 0.27066067f, 0.05001019f, 
    0.03624240f, -0.38763189f, 0.04269024f, -0.04039357f, 0.53275090f, 0.23441586f, -0.12485813f, 0.17926048f, 
    0.10906383f, -0.09285258f, 0.10272700f, 0.04322765f, 0.07843294f, -0.43958765f, 0.05361496f, 0.14402188f, 
    -0.25134039f, -0.33259973f, -0.11019920f, -0.02905949f, 0.16539355f, -0.14532992f, -0.04472365f, 0.06064197f, 
    -0.35237816f, 0.22199613f, -0.11819569f, -0.32166073f, 0.50355780f, 0.15336348f, -0.02264786f, -0.02719014f, 
    -0.26955399f, 0.09104702f, 0.04855433f, -0.03159163f, 0.19498262f, 0.22368605f, 0.01082264f, 0.19868180f, 
    0.18582329f, 0.10163681f, 0.03980663f, -0.04754839f, 0.24509741f, 0.35443875f, 0.09462611f, 0.00571952f, 
    -0.06795820f, 0.00315128f, 0.04861050f, 0.18730974f, 0.00306043f, 0.17998157f, 0.55580086f, 0.31147870f, 
    0.22036296f, -0.48523602f, 0.27714249f, -0.40456378f, 0.11507073f, -0.21765369f, 0.08623817f, -0.09773000f, 
    -0.10917144f, -0.05122572f, -0.10515109f, 0.41266808f, 0.35228604f, -0.18268822f, -0.49402323f, -0.10185989f, 
    0.39169624f, 0.48607007f, 0.07092559f, -0.35972649f, -0.44572860f, 0.03104484f, -0.10251695f, 0.09237403f, 
    0.06371185f, 0.23183954f, -0.45358658f, -0.48496154f, 0.62728089f, 0.56735897f, -0.07406376f, 0.52107489f, 
    0.25799999f, -0.01654609f, -0.09150845f, 0.08655384f, 0.50313926f, -0.27350208f, -0.37636364f, 0.05025508f, 
    0.09426600f, -0.52201903f, 0.00644240f, 0.62658012f, -0.04518074f, 0.15321468f, 0.23960616f, 0.09770340f, 
    0.11157794f, -0.06982969f, 0.02815787f, 0.10573306f, 0.12634839f, 0.11505022f, 0.33672628f, 0.26556537f, 
    0.19163293f, 0.21963701f, -0.20559667f, -0.04923868f, 0.02310200f, -0.05782880f, 0.08653491f, 0.14244291f, 
    -0.39406797f, 0.17970273f, -0.06561643f, 0.27896637f, 0.35143140f, 0.20332207f, -0.14493588f, -0.06052762f, 
    0.07986408f, 0.23225318f, -0.01177277f, -0.45056605f, 0.13625351f, 0.24951576f, 0.04918451f, -0.03741792f, 
    -0.09444149f, -0.17925075f, 0.05396921f, 0.23983182f, 0.18267551f, -0.29858488f, -0.03777863f, 0.06613541f, 
    0.24567853f, 0.43124384f, -0.01632986f, 0.50101924f, -0.11471882f, 0.10055432f, 0.13446167f, 0.04154488f, 
    -0.15850028f, -0.08116057f, -0.08288213f, 0.04573338f, 0.17412710f, 0.14170173f, 0.26864356f, -0.01151374f, 
    -0.28953543f, -0.24789071f, -0.02301288f, -0.63087142f, -0.05965887f, 0.25079486f, -0.39557150f, -0.22793823f, 
    0.17090964f, -0.01938966f, -0.09234991f, -0.29546610f, -0.01779233f, 0.12654018f, 0.12038606f, -0.07465138f, 
    0.27745271f, -0.25903475f, -0.15014106f, 0.34443861f, 0.06525040f, -0.00809117f, 0.01572093f, 0.36290818f, 
    0.06226913f, -0.24126187f, 0.09530332f, -0.10189901f, 0.31330025f, 0.11339764f, -0.11079904f, -0.00711367f, 
    -0.01193092f, 0.27557492f, -0.12416839f, -0.10443184f, 0.32044691f, 0.33122072f, -0.12702563f, 0.30163893f, 
    0.19265471f, 0.13076699f, -0.05132724f, 0.21028505f, 0.14258654f, 0.01967096f, 0.09199366f, 0.12372746f, 
    0.37941554f, 0.04005706f, 0.02639269f, -0.09342118f, 0.04772646f, -0.46361604f, 0.22689295f, -0.14479305f, 
    0.08848206f, -0.00036779f, 0.11768854f, 0.28780627f, 0.26402920f, 0.21490163f, 0.34096342f, -0.01696065f, 
    0.08273006f, -0.36285883f, -0.09654260f, -0.12463314f, -0.05134225f, 0.00258589f, -0.00251373f, -0.17750101f, 
    0.05036630f, -0.04290961f, -0.27857229f, -0.22124666f, 0.29410431f, 0.04206407f, 0.09152387f, 0.02275796f, 
    0.08932476f, -0.05112040f, 0.25064874f, 0.01481921f, -0.06315325f, 0.19372106f, 0.14025989f, -0.00637332f, 
    0.17142281f, -0.11092605f, 0.11184905f, -0.10582382f, -0.38684088f, -0.04432789f, 0.22660969f, 0.05344097f, 
    0.04950856f, -0.24766004f, -0.10488863f, 0.26431262f, -0.04345698f, 0.22236109f, 0.53331745f, -0.00875308f, 
    0.29557002f, 0.64464265f, -0.10122882f, -0.02222777f, 0.05564530f, 0.05986391f, -0.08436951f, -0.09807663f, 
    -0.02899963f, 0.35334879f, -0.20689341f, -0.79391110f, 0.61678606f, 0.36885622f, -0.21024688f, -0.01768780f, 
    -0.10581861f, -0.04267714f, -0.02124487f, 0.09147874f, 0.16016136f, 0.00774106f, -0.00096250f, -0.02588905f, 
    0.23746626f, -0.07703854f, -0.11064897f, 0.21276994f, -0.20076373f, 0.08616958f, 0.04155248f, 0.19178458f, 
    0.19819096f, -0.12324810f, 0.15175287f, 0.13328056f, 0.12988366f, 0.13246855f, 0.25390911f, 0.15765290f, 
    -0.20756340f, -0.26855475f, 0.21839212f, -0.04470272f, -0.08282949f, 0.14380309f, -0.07193384f, -0.07986698f, 
    0.09071290f, 0.11573809f, 0.15976393f, 0.13983464f, -0.05596133f, 0.01794035f, 0.07206872f, 0.09308460f, 
    -0.02098814f, -0.09648072f, 0.17939341f, -0.42042017f, -0.07658336f, 0.00201790f, -0.04563028f, -0.15032221f, 
    0.04275535f, 0.25905472f, 0.10555743f, 0.04485426f, -0.14578499f, 0.76603931f, 0.01183279f, -0.06004807f, 
    -0.09365232f, 0.29722297f, 0.02600579f, -0.09075237f, -0.05163903f, 0.69364268f, -0.21855402f, -0.06516759f, 
    -0.07889958f, 0.18594956f, -0.02694811f, -0.17913283f, -0.20877899f, 0.02464340f, -0.08674972f, 0.09562617f, 
    0.22321597f, -0.25314820f, 0.04301719f, 0.28145236f, -0.05452162f, 0.31624636f, 0.20631610f, 0.05706284f, 
    -0.03402327f, -0.10095085f, 0.07887135f, 0.21579160f, -0.16467765f, 0.08774994f, 0.04656855f, 0.21599692f, 
    0.10918468f, -0.17157631f, -0.12361941f, 0.07001760f, 0.11149314f, 0.08202532f, 0.06157744f, 0.00046562f, 
    0.04546290f, -0.01411713f, -0.21216735f, 0.03035662f, 0.21150781f, -0.05864200f, -0.00301040f, 0.07924908f, 
    0.00927526f, 0.06802320f, -0.11902427f, -0.00586304f, -0.02097810f, 0.08862571f, 0.22917083f, -0.05705078f, 
    -0.02107720f, 0.17310697f, 0.06508962f, 0.07352106f, 0.16070445f, -0.10437117f, 0.09868586f, -0.08670612f, 
    -0.05014471f, 0.16247734f, -0.01770206f, -0.23093666f, 0.27354860f, -0.21185628f, -0.04417865f, -0.02908576f, 
    0.06468234f, -0.28031647f, 0.00496383f, 0.31248948f, 0.24210124f, 0.14342201f, -0.00286962f, -0.06206964f, 
    -0.27796021f, 0.26222157f, 0.04041108f, -0.35647973f, -0.13134019f, -0.01302628f, -0.17164607f, -0.04550486f, 
    -0.03736390f, 0.10411239f, -0.09439488f, -0.23593438f, -0.05015264f, 0.06037606f, 0.00884922f, -0.16372238f, 
    0.02514042f, 0.09828641f, -0.02410946f, 0.01370479f, -0.04430977f, -0.08640813f, 0.10366921f, -0.00635927f, 
    0.10170423f, 0.01696181f, -0.02348070f, -0.11100563f, -0.07593712f, -0.14997867f, -0.02209608f, -0.04098521f, 
    0.08818451f, 0.02512110f, -0.10246293f, -0.02610570f, -0.01961099f, -0.13967694f, 0.03199654f, -0.02954748f, 
    0.04586538f, -0.05260607f, -0.06768015f, -0.06792549f, 0.03908926f, -0.08024789f, 0.05386631f, -0.06917207f, 
    -0.05392555f, -0.01357316f, 0.04045639f, -0.00599535f, -0.00552510f, -0.06572846f, -0.05660406f, 0.06165689f, 
    -0.06778669f, -0.12180544f, 0.00942110f, 0.05080644f, 0.00997140f, -0.02455504f, -0.05617701f, 0.02942531f, 
    0.08941142f, 0.04210839f, -0.12148647f, -0.12506434f, -0.05900350f, 0.01788072f, -0.03647982f, -0.14718121f, 
    -0.08145183f, -0.06846979f, 0.05275787f, -0.13497984f, 0.07235339f, -0.14650324f, -0.08554213f, -0.03773759f, 
    0.09159648f, -0.37137318f, 0.24724300f, -0.13722217f, -0.02234571f, -0.03199771f, -0.49932066f, -0.13688251f, 
    0.20030659f, -0.37634477f, 0.22454898f, -0.37683886f, -0.19765855f, -0.02648169f, 0.23619248f, -0.03778039f, 
    0.21763888f, -0.32524794f, 0.09480006f, 0.25384411f, 0.18523370f, -0.39374849f, 0.32919103f, 0.16394265f, 
    -0.07444485f, 0.33699298f, 0.06481975f, -0.11563216f, -0.08196395f, 0.25259438f, -0.05285218f, 0.08565354f, 
    0.36559191f, 0.06641494f, 0.03229108f, -0.15066372f, -0.15831047f, -0.11737155f, 0.11347406f, -0.58684826f, 
    0.16473134f, -0.04438818f, 0.10659681f, -0.13210849f, -0.28974846f, -0.00890753f, -0.01881254f, 0.02423383f, 
    -0.17848489f, 0.38851157f, 0.01617494f, 0.33317074f, 0.40138331f, -0.19134721f, 0.20134765f, -0.31478688f, 
    -0.04900204f, 0.01600240f, -0.19891116f, -0.12762783f, 0.24031129f, -0.26618683f, 0.17090264f, 0.09155437f, 
    0.11755183f, -0.03198214f, -0.02156497f, 0.40113720f, 0.06696939f, 0.08465070f, -0.12867391f, 0.24756168f, 
    0.20123836f, 0.23648752f, 0.01993141f, 0.25007415f, 0.36715928f, 0.62463254f, -0.14812732f, -0.04295684f, 
    -0.16232446f, 0.54266351f, 0.31624356f, -0.43378094f, -0.08966240f, 0.09495455f, -0.25785768f, 0.43106833f, 
    0.13778573f, -0.15826613f, -0.06687022f, 0.23333436f, -0.04329777f, -0.31835952f, 0.01627158f, 0.05940453f, 
    -0.24448018f, -0.55723637f, 0.25842533f, 0.48087195f, -0.25836509f, -0.33205310f, 0.17098160f, 0.33391258f, 
    0.03659726f, 0.14370245f, -0.08512864f, 0.50681007f, -0.24771504f, 0.30568263f, 0.10381751f, -0.07068139f, 
    0.16098946f, -0.63576204f, 0.04977085f, -0.59021312f, 0.33330366f, 0.10894780f, 0.11641721f, 0.37492308f, 
    0.03486878f, 0.05614474f, 0.19415256f, 0.02522372f, -0.04671612f, 0.23517255f, -0.19138278f, 0.07346459f, 
    0.03315620f, -0.20538934f, -0.18637134f, -0.09134449f, -0.07506220f, -0.14464766f, 0.05005638f, -0.03708423f, 
    0.02074155f, -0.02887921f, 0.05024647f, -0.13642518f, -0.14111535f, -0.04030328f, 0.02798566f, -0.05109048f, 
    -0.14030385f, 0.07051024f, -0.06775533f, -0.05708165f, -0.17460452f, -0.10504767f, -0.00296493f, -0.14544114f, 
    -0.04379453f, -0.00859188f, 0.11144485f, 0.07687130f, -0.12920430f, 0.04579173f, -0.01762396f, -0.01078258f, 
    0.03040222f, -0.10768809f, -0.02892792f, -0.03685131f, -0.04824607f, -0.10709267f, -0.03878639f, -0.06305428f, 
    -0.07533566f, -0.01540128f, 0.01395838f, -0.06633175f, -0.11952017f, 0.02762001f, -0.14555702f, 0.00943977f, 
    0.05433460f, -0.07358330f, -0.03364179f, -0.10503025f, -0.07877555f, 0.04289052f, -0.14222407f, -0.00376245f, 
    0.02449748f, 0.02569523f, 0.03134944f, -0.00129929f, -0.02886119f, -0.07230639f, 0.05577206f, -0.08290716f, 
    0.01749051f, -0.10304144f, -0.06007972f, -0.10923602f, 0.05398753f, -0.09549148f, -0.01435044f, 0.01578145f, 
    -0.07134537f, -0.05128625f, 0.05480157f, -0.08328279f, -0.03350829f, -0.06886516f, 0.06553892f, -0.04485747f, 
    -0.12052441f, 0.07557829f, 0.06464949f, -0.12348717f, -0.08160105f, -0.07081241f, -0.09089220f, -0.05213701f, 
    -0.09092453f, -0.04414551f, -0.07292438f, 0.09493588f, 0.09678998f, 0.03083092f, 0.06421787f, -0.06647228f, 
    0.04788415f, 0.05406485f, -0.08002408f, -0.00404289f, -0.07030897f, -0.04761951f, -0.12199481f, -0.02325827f, 
    -0.01477660f, 0.07818228f, -0.05491921f, -0.06315295f, 0.03711827f, 0.03737863f, 0.00703350f, 0.09074952f, 
    -0.03793462f, -0.08716425f, 0.00265649f, -0.01615670f, 0.07488593f, -0.10474628f, 0.12604359f, 0.07813151f, 
    -0.03754315f, 0.04786028f, 0.05768982f, -0.06390955f, -0.10138971f, 0.08246145f, 0.08235484f, 0.02240987f, 
    0.21566701f, 0.07739493f, -0.40168104f, 0.08190361f, 0.00917612f, 0.00250913f, 0.13737859f, 0.21906850f, 
    -0.03816060f, -0.03389803f, 0.05201121f, 0.27773368f, 0.05148019f, 0.11163834f, -0.08496806f, 0.11823381f, 
    -0.10465971f, 0.22892246f, 0.00989953f, 0.26210162f, 0.15813962f, 0.27158582f, -0.00111939f, 0.11066625f, 
    0.06232331f, -0.59721661f, 0.03666653f, 0.53531021f, 0.17405869f, -0.15166447f, -0.05190565f, 0.06693740f, 
    0.31631422f, -0.17454156f, -0.11624331f, 0.89048845f, 0.28283799f, -0.84048760f, 0.05746636f, 0.18236230f, 
    0.20459203f, -0.05809597f, 0.02559311f, 0.07563098f, 0.70711648f, 0.28142229f, 0.29311574f, 0.05877623f, 
    -0.12597127f, -0.62161952f, -0.10719390f, -0.12069788f, 0.05933795f, -0.11603108f, -0.08792041f, 0.04158030f, 
    0.05281610f, 0.07964596f, -0.21419260f, -0.31353804f, 0.22952412f, 0.08812635f, 0.08166250f, -0.21199556f, 
    0.01607569f, 0.39333436f, -0.03778392f, -0.13621637f, 0.07338791f, -0.02734103f, 0.29178020f, 0.38730580f, 
    -0.27412304f, -0.04845716f, 0.01230970f, 0.26840660f, 0.03606884f, -0.19066672f, 0.03906009f, 0.07403001f, 
    0.37236896f, 0.35576713f, -0.29828855f, -0.09660547f, -0.04180633f, 0.19020715f, -0.26900765f, 0.06117890f, 
    -0.02636373f, 0.11085481f, 0.03302513f, 0.10560437f, 0.21516888f, -0.59458190f, -0.09398018f, -0.04967793f, 
    0.40067637f, 0.26783669f, -0.49276400f, -0.78404152f, -0.34123024f, -0.09989341f, 0.08353901f, 0.38178939f, 
    -0.14756525f, -0.01299351f, -0.01270333f, -0.33715662f, -0.08576946f, -0.07906121f, 0.09889968f, 0.14190969f, 
    0.10895108f, 0.35794601f, -0.01938252f, -0.21895778f, -0.43222776f, 0.48203540f, -0.15327401f, 0.19668688f, 
    0.45628390f, 0.08510387f, 0.15011664f, -0.01523391f, 0.02023741f, 0.15110505f, 0.38767043f, -0.11172483f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.29787245f, -0.15548459f, 0.10750434f, -0.01257593f, -0.13777757f, -0.03054776f, 0.35322759f, -0.02105059f, 
    0.19847494f, 0.32342720f, -0.16558187f, 0.01513418f, -0.19521613f, -0.15261252f, 0.01548771f, -0.02882325f, 
    0.02008934f, -0.13324319f, -0.09366401f, -0.03035443f, 0.17711465f, 0.52354908f, 0.10532789f, 0.18551619f, 
    0.28417549f, -0.10663200f, 0.01918135f, -0.03144332f, 0.24150419f, 0.06106623f, 0.14969629f, 0.00541696f, 
    0.28811607f, -0.27170011f, 0.16211212f, -0.14684342f, 0.35015360f, -0.15127988f, 0.12028093f, 0.11656223f, 
    0.00616428f, 0.01359010f, -0.04495167f, -0.40526545f, 0.07935336f, 0.04731412f, 0.38587898f, -0.11661245f, 
    0.02534338f, -0.08712709f, 0.40046826f, -0.08321496f, 0.04234429f, 0.30594680f, 0.24377486f, 0.06786090f, 
    -0.05750624f, -0.12306549f, 0.08280554f, 0.19589593f, -0.13250415f, -0.12809460f, -0.07790117f, 0.00454270f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.23251341f, -0.06912060f, 0.00849781f, -0.07953849f, 0.06814302f, -0.00105410f, -0.55254161f, 0.08443175f, 
    0.19030175f, -0.23126772f, -0.15707046f, 0.02010978f, -0.24239279f, -0.08916537f, 0.02385357f, -0.09623830f, 
    -0.00703248f, 0.06320707f, -0.34083936f, -0.02887818f, 0.40077838f, 0.17456488f, 0.29953849f, 0.08864833f, 
    0.40870294f, 0.05575097f, -0.19292308f, 0.00315285f, -0.23489800f, -0.04539711f, -0.07410181f, -0.08825610f, 
    0.14211391f, -0.76127458f, -0.92576593f, 0.08609021f, 0.16188595f, -0.43630099f, 0.11252053f, 0.11343874f, 
    0.15129369f, 0.05114120f, 0.09807754f, -0.58969676f, -0.63282377f, -0.30704841f, 0.17053401f, -0.14960276f, 
    -0.09600271f, 0.10605057f, -0.43483543f, -0.46687880f, -0.32769597f, -0.06620142f, 0.28453550f, 0.12096011f, 
    -0.28679395f, 0.00748997f, 0.01122812f, 0.04838379f, -0.03518971f, 0.05035656f, -0.05461719f, -0.28249925f, 
    -0.09658445f, -0.20147024f, 0.01951869f, 0.02198629f, 0.09755845f, -0.03527542f, -0.52428234f, -0.05426027f, 
    0.18458951f, 0.07565283f, -0.14017303f, -0.07485720f, -0.36576599f, -0.08153234f, -0.57665771f, -0.05248219f, 
    -0.06152566f, -0.10197470f, 0.29413173f, 0.01679552f, -0.07274697f, -0.00468546f, 0.20199203f, 0.16543250f, 
    -0.17551334f, 0.10318695f, -0.05321304f, -0.00240312f, 0.10657506f, 0.12617329f, -0.03668261f, 0.07658872f, 
    -0.01141189f, -0.22308952f, -0.49209002f, 0.09027442f, 0.04274010f, -0.07443712f, -0.14461561f, 0.10732518f, 
    -0.23829307f, -0.30073860f, 0.04570137f, 0.38856924f, 0.17771961f, -0.45048159f, 0.22020496f, -0.12073992f, 
    0.00411952f, 0.11708600f, 0.29552442f, -0.60002810f, 0.18953858f, 0.31641859f, 0.04422441f, -0.15666747f, 
    0.31581265f, -0.02322215f, 0.24316339f, 0.04633817f, -0.02739788f, -0.09383324f, 0.24503766f, -0.44667011f, 
    0.12797514f, -0.88180780f, -0.06981192f, 0.22579335f, 0.02203202f, -0.04141549f, 0.26210245f, 0.08218467f, 
    -0.06963605f, 0.08928178f, 0.34147283f, -0.12985465f, -0.81545717f, 0.04370818f, 0.54939783f, -0.08506308f, 
    -0.11130267f, 0.05778646f, -0.79104793f, -0.16428310f, -0.03181068f, -0.15020190f, -0.38985074f, 0.13222629f, 
    -0.61758465f, 0.23283125f, 0.18448317f, -0.00273666f, 0.01019520f, -0.02327221f, -0.64267844f, 0.06177725f, 
    -0.33490732f, 0.21111660f, -0.24408451f, 0.06238059f, -0.71153760f, 0.19385791f, -0.03078065f, -0.06552145f, 
    -0.26510847f, -0.40354794f, -0.03749443f, -0.38151288f, -0.85961401f, 0.17308456f, 0.27151605f, -0.10522711f, 
    -0.04083486f, 0.12354138f, -0.18546179f, 0.58640242f, -0.07008944f, 0.13689475f, 0.08662469f, -0.50671184f, 
    -0.14234671f, 0.15032129f, -0.08022664f, 0.01942616f, 0.01413728f, -0.03092464f, 0.20743169f, -0.37211123f, 
    0.08381051f, 0.13410801f, -0.51915705f, -0.04889613f, -0.09317017f, -0.09850653f, 0.04232291f, -0.05879996f, 
    0.01751429f, -0.20300677f, 0.38450512f, 0.08532479f, -0.20834759f, -0.05795651f, 0.11460175f, 0.10433872f, 
    0.04310222f, -0.09092309f, 0.15135871f, -0.00981652f, 0.18268339f, -0.00816344f, -0.43599653f, -0.53347933f, 
    0.14927095f, 0.05741352f, -0.00036032f, -0.09923416f, 0.31785026f, -0.57821918f, -0.09962641f, 0.05452450f, 
    -1.00885451f, 0.19811815f, 0.06915007f, 0.04155073f, -0.02168463f, 0.19135574f, 0.02950108f, 0.06315988f, 
    -0.11719862f, -0.11486540f, -0.03869149f, -0.12000570f, 0.06364130f, 0.17338386f, -0.53672642f, -0.08217146f, 
    -0.09103197f, 0.06234679f, 0.29150155f, 0.29437938f, -0.10613346f, -0.91194868f, 0.26615092f, 0.07738204f, 
    -0.17768751f, 0.06621471f, 0.34996253f, -0.86829460f, 0.02818714f, 0.04521372f, 0.17317860f, 0.20441148f, 
    -0.09218633f, -0.10503925f, 0.07108311f, 0.17835061f, -0.02481100f, 0.09306376f, -0.06714081f, -0.07481983f, 
    -0.04717350f, 0.12879081f, 0.36447620f, 0.00993533f, -0.14480716f, -0.07734133f, -0.07595176f, -0.04902714f, 
    0.08795441f, -0.09333935f, 0.02318552f, -0.17976259f, -0.04696798f, -0.08169092f, -0.09091341f, 0.10996394f, 
    -0.07792757f, 0.21480931f, -0.02166563f, -0.03718205f, -0.16759709f, 0.07690111f, 0.15494080f, -0.08827349f, 
    -0.10618895f, -1.10170305f, -0.09119433f, -0.04762961f, 0.12405531f, 0.24744253f, 0.07247333f, 0.01846789f, 
    0.24162962f, 0.22696911f, 0.07156643f, 0.30273920f, -0.15631577f, 0.12225345f, 0.04344871f, -0.08160844f, 
    0.07579787f, -0.11927612f, -0.25778347f, -0.06348330f, -0.30486953f, -0.01033882f, -0.20683217f, 0.12685077f, 
    0.24450934f, 0.02457116f, 0.16946164f, -0.01205165f, -0.08040501f, 0.04567430f, -0.48648688f, 0.17608635f, 
    0.05297561f, 0.44718039f, 0.09953032f, -0.19073962f, 0.02486296f, -0.00520196f, 0.25620914f, 0.03198075f, 
    0.02592884f, 0.09273834f, -0.81310296f, -0.05502830f, -0.28579238f, -0.09258016f, 0.05016061f, 0.10169781f, 
    -0.12926295f, 0.08839658f, -0.05370774f, -0.12958381f, -0.09575922f, 0.12309034f, 0.01074353f, 0.26094285f, 
    -0.16236843f, -0.69975662f, -0.23290204f, 0.01022214f, -0.01892716f, 0.18545461f, 0.01597483f, 0.02554416f, 
    0.24692753f, 0.31459352f, 0.38561597f, -0.03160792f, 0.01460994f, -0.63817382f, -0.07683509f, 0.10100977f, 
    -0.52438700f, 0.03615092f, -0.00253692f, -0.08254921f, 0.00525629f, -0.72469103f, 0.12401272f, -0.01100714f, 
    0.04372206f, -0.06151786f, 0.22633110f, -0.02840065f, 0.00020428f, -0.07221954f, -0.45916972f, -0.04170843f, 
    -0.08081651f, -0.07114214f, -0.35513279f, 0.26478806f, 0.00583466f, -0.07943045f, 0.08718982f, 0.01843009f, 
    0.10842852f, -0.45152625f, 0.19462892f, 0.02625140f, -0.07174346f, 0.02225634f, -0.16002302f, 0.04548202f, 
    0.11558007f, 0.11775806f, -0.49032700f, 0.08943053f, 0.65366602f, 0.00890571f, -0.29801422f, -0.13132767f, 
    0.11334838f, -0.03814121f, -0.45254019f, -0.09445065f, -0.06315222f, 0.16078874f, -0.29967228f, 0.04816410f, 
    -0.33058432f, -0.41046703f, -0.11636704f, 0.08882760f, 0.09392215f, 0.22364360f, 0.21208845f, 0.06413883f, 
    -0.42111477f, -0.97699803f, 0.16040255f, 0.06191418f, -0.09084551f, -0.03946569f, 0.13062958f, 0.00791374f, 
    0.31539920f, 0.16131571f, -0.06906978f, -0.76033968f, 0.49563628f, 0.05751961f, -0.14410092f, -0.09829596f, 
    -0.07036684f, -0.02542018f, 0.07435971f, -0.05776830f, -0.05772080f, -0.02660052f, -0.21889658f, -0.25030127f, 
    -0.39951152f, -0.01517967f, 0.03175926f, 0.18982990f, -0.10738676f, 0.06965211f, -0.12369900f, 0.33481210f, 
    -1.06693459f, 0.21267481f, -0.26766682f, -0.58498085f, -0.10758560f, 0.03830938f, -0.61738497f, 0.05149964f, 
    -0.00924623f, -0.89398652f, 0.21331784f, -0.02753336f, 0.14594506f, -0.08166268f, 0.22325572f, -0.12812535f, 
    -0.07232054f, -0.11294284f, 0.27256730f, -0.09437568f, 0.11536091f, -0.33320028f, 0.02025667f, -0.17237823f, 
    0.14830971f, 0.07157835f, -0.41057780f, -0.01554284f, -0.40004843f, -0.19756740f, -0.01382893f, -0.04330064f, 
    0.29039717f, 0.35210642f, 0.43024769f, 0.01177250f, 0.09270156f, 0.05202445f, -0.11862977f, 0.03544749f, 
    0.14478314f, -0.12286043f, -0.13140777f, 0.37179154f, 0.20094889f, -0.35936838f, -0.34906346f, -0.08092199f, 
    -0.05605349f, 0.09374866f, -0.23142251f, 0.07876755f, 0.19084637f, 0.32400438f, -0.15331392f, 0.16338350f, 
    -0.01039685f, 0.07582830f, -0.87743551f, -0.28294116f, -0.11022592f, -0.06601276f, 0.47845915f, -0.17998993f, 
    -0.28147933f, 0.22376184f, 0.01714664f, -0.31502330f, -0.06016580f, -0.12023302f, 0.11998256f, -0.03390602f, 
    -0.63842469f, -0.23633443f, 0.14133322f, -0.11344868f, 0.00779046f, 0.01126899f, 0.14322913f, -0.11488484f, 
    -0.06898352f, -0.12235212f, 0.02996156f, -0.19344850f, -0.43976262f, -0.82164145f, 0.33969408f, -0.47504893f, 
    -0.16940403f, 0.26483309f, 0.16294333f, -0.01517498f, 0.12923142f, -0.09753887f, 0.26832920f, -0.08295904f, 
    0.23887655f, -0.69786340f, -0.07965903f, 0.05875156f, 0.01366027f, -0.38416550f, -0.98062176f, -0.06110182f, 
    0.48616308f, -0.62768227f, -0.07674535f, -0.24061327f, 0.07865565f, 0.05183234f, 0.08050410f, -0.09784421f, 
    -0.06200646f, 0.03333699f, 0.12284867f, -0.22343205f, 0.34007898f, 0.10259978f, -0.18682499f, -0.30034822f, 
    0.02216457f, 0.03507808f, -0.27787998f, -0.09011682f, -0.07821181f, -0.02196384f, 0.20082690f, 0.41494709f, 
    0.02327874f, -0.01477820f, 0.07184896f, 0.21809125f, 0.08109952f, 0.05361794f, 0.06189856f, 0.04219037f, 
    -0.36113650f, -0.01077891f, -0.57290244f, 0.03946543f, 0.05599786f, -0.03579833f, 0.19565785f, -0.05318451f, 
    -0.07514207f, 0.01677533f, 0.02396761f, -0.16354130f, -0.12780069f, -0.02706565f, -0.02913231f, 0.03947417f, 
    -0.07883130f, -0.06007750f, 0.17903242f, -0.06558530f, 0.04163754f, 0.00343957f, 0.24618106f, 0.02067367f, 
    0.20944975f, -0.17623641f, 0.30033562f, 0.07070878f, -0.16992544f, -0.03399244f, -0.15333226f, 0.10254304f, 
    0.46586230f, 0.13161062f, 0.02181820f, 0.41409209f, 0.19113277f, 0.11754920f, -0.09718862f, -0.06612029f, 
    0.12637766f, 0.06321426f, -0.30916029f, -0.36207181f, -0.01898208f, 0.10944080f, -0.32564017f, -0.03628771f, 
    0.09650653f, -0.10871301f, 0.34609723f, -0.03345890f, -0.05143008f, 0.06205792f, -0.11575942f, -0.52067548f, 
    0.07115072f, -0.01908760f, -0.67138153f, -0.52206111f, 0.06255653f, -0.06967992f, 0.32549554f, 0.06092117f, 
    -0.06745362f, 0.09167371f, 0.00704787f, -0.01227427f, 0.09163481f, -0.08996342f, -0.94964886f, 0.01178109f, 
    -0.08181874f, 0.09062883f, 0.25514054f, -0.12292444f, -0.02881784f, 0.10482339f, -0.18345697f, -0.23732789f, 
    0.11771564f, 0.21873747f, 0.31503552f, 0.12038080f, 0.28570607f, -0.11036161f, 0.13036321f, 0.02025263f, 
    -0.30331510f, -0.06803495f, -0.28502762f, -0.06945162f, 0.13632686f, -0.18465738f, -0.05862029f, 0.00254929f, 
    -0.08649071f, -0.41437936f, 0.10971855f, -0.40098792f, 0.29797092f, -0.14441477f, 0.14801788f, -0.07053365f, 
    0.02975005f, 0.04155500f, 0.39973137f, 0.20470251f, -0.39911112f, -0.14555015f, 0.20891735f, 0.17175402f, 
    -0.02807803f, 0.01436317f, -0.29013401f, -0.43661046f, 0.06583957f, 0.02895761f, -0.32760757f, 0.16498360f, 
    0.03502808f, -0.35134044f, 0.07954749f, -0.01861998f, 0.05819170f, -0.07884195f, -0.12408610f, 0.09975448f, 
    0.09036140f, -0.03691639f, 0.27393296f, -0.01379512f, -0.49133557f, 0.05996442f, 0.20467947f, 0.03100725f, 
    -0.11652214f, 0.09274249f, -0.39715970f, -0.01707723f, 0.03272989f, -0.02551726f, -0.11082643f, -0.12513979f, 
    0.22520918f, -0.19438033f, -0.18577325f, -0.05379374f, -0.56791776f, -0.26519147f, -0.20433506f, -0.05335869f, 
    -0.00101316f, 0.37261346f, 0.07547162f, -0.07714905f, -0.20927308f, 0.19620401f, 0.10813505f, 0.01926902f, 
    -0.31025630f, 0.14954779f, -0.00686151f, -0.29088846f, -0.04381885f, 0.14813520f, 0.09322306f, -0.04312837f, 
    -0.02247568f, 0.03944581f, 0.14890330f, 0.25422201f, 0.03181256f, 0.00123602f, 0.12291857f, -0.02314650f, 
    -0.11738372f, 0.05890359f, -0.07559007f, 0.12181327f, -0.02413329f, 0.08971625f, -0.71048993f, 0.36104405f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.28218004f, 0.04401879f, -0.26109800f, -0.02124039f, -0.10804458f, 0.04711480f, -0.08215230f, -0.53970486f, 
    -0.10614710f, -0.14559333f, 0.23095621f, 0.00306947f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
