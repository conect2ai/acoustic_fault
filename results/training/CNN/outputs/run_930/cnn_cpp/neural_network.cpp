#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.20857313f, -0.05748121f, -0.31419975f, -0.40156260f, 0.41403666f, -0.24915741f, -0.20399594f, 0.41538349f, 
    -0.15639935f, 0.19072306f, -0.40469337f, -0.09151995f, -0.11334439f, -0.08574884f, -0.12011053f, 0.56152600f, 
    -0.16473150f, 0.20296068f, 0.22593835f, 0.04914518f, 0.26424262f, 0.09974265f, -0.27554744f, -0.27853918f, 
    0.06818141f, -0.33664894f, 0.13996252f, 0.37617588f, 0.19188404f, 0.30660203f, -0.53748578f, 0.56109565f, 
    -0.30329233f, -0.47951362f, -0.29137141f, 0.42475384f, 0.32413793f, -0.16540439f, -0.03829823f, -0.12820980f, 
    -0.00019071f, -0.39432764f, -0.12979814f, -0.12861139f, -0.06995709f, -0.21681304f, -0.03372269f, 0.12730631f, 
    0.35597497f, -0.10857315f, 0.79995006f, 0.25358620f, -0.64520353f, -0.51527846f, -0.35977185f, 0.23097007f, 
    0.56714821f, 0.39076313f, 0.30368483f, 0.43676412f, 0.18111743f, 0.15665804f, -0.17497455f, -0.25850663f, 
    0.13103919f, -0.18612647f, -0.37293723f, -0.00083859f, 0.11291150f, -0.30083913f, -0.18669970f, 0.13903923f, 
    -0.14823042f, 0.15312234f, -0.16571106f, 0.54482710f, -0.01114033f, 0.36872193f, 0.72393411f, 0.40384015f, 
    0.15004030f, 0.16612853f, 0.28973678f, -0.10749862f, 0.43747860f, -0.34110621f, -0.23906803f, -0.06912684f, 
    -0.23186561f, 0.16435361f, -0.26020738f, -0.11064219f, 0.04416684f, 0.06662934f, -0.05377984f, 0.40817478f, 
    -0.15915363f, -0.16216612f, -0.12642175f, 0.09164668f, 0.03861508f, -0.67462903f, -0.03005347f, 0.06576060f, 
    -0.19638617f, -0.40403965f, -0.17252766f, 0.34571791f, -0.42443550f, -0.41811407f, 0.03982495f, -0.13886353f, 
    0.21493429f, -0.30970263f, 0.19260593f, 0.05105221f, 0.25221875f, 0.00858674f, -0.02303876f, 0.37211728f, 
    -0.08474549f, 0.03839787f, -0.04489145f, 0.28817764f, -0.17385401f, -0.15220490f, -0.53480750f, -0.23847793f, 
    1.04094279f, 0.19653611f, 0.26650220f, 0.65742993f, -0.36723736f, 0.56804699f, 0.13994274f, 0.00544414f, 
    -0.14750296f, -0.21101907f, 0.01786123f, -0.12733419f, -0.19762070f, -0.25508633f, -0.29202649f, 0.01100249f, 
    -0.09792370f, -0.05645558f, 0.21965414f, -0.15815924f, -0.00258379f, -0.28164229f, -0.20193069f, -0.65674806f, 
    -0.38974145f, 0.06652518f, -0.10573713f, -0.55655694f, -0.00264530f, 0.30695865f, -0.69109374f, -0.01586233f, 
    -0.31551442f, 0.00817889f, -0.37299648f, 0.10234461f, -0.08217532f, -0.21917656f, -0.29482624f, -0.22541693f, 
    -0.15375248f, -0.40891683f, -0.02580506f, 0.11835559f, 0.04948792f, 0.25972301f, 0.13719705f, 0.92143160f, 
    0.52156675f, -0.01659226f, 0.14192690f, 0.30437258f, 0.47227332f, 0.50473487f, 0.19335166f, 0.29975602f, 
    0.14725094f, 0.09487619f, -0.13412614f, -0.12701793f, -0.25855809f, -0.33256409f, 0.24690467f, 0.12136643f, 
    -0.15142421f, -0.15481327f, -0.05632250f, -0.22980408f, -0.12528248f, -0.22984812f, -0.37191474f, -0.25539234f, 
    -0.52883941f, -0.72067279f, -0.24913806f, -0.21661977f, -0.01188951f, 0.46846735f, 0.36029008f, 0.30601770f, 
    0.51736403f, 0.31632781f, 0.23439832f, -0.25007674f, -0.06797049f, -0.15732343f, -0.12438511f, 0.19713190f, 
    0.00361025f, -0.15999652f, 0.00031024f, -0.14074560f, -0.21931437f, -0.33975333f, 0.14912356f, -0.04146504f, 
    -0.04401017f, -0.57966715f, -0.70382529f, -0.80047071f, -0.24606714f, 0.18579499f, 0.03122422f, 0.64447814f, 
    0.54516923f, 0.08462305f, 0.15808383f, -0.05150928f, -0.18662781f, -0.21065351f, -0.38402119f, 0.11603743f, 
    0.14232039f, 0.25135547f, 0.25354788f, -0.01626526f, 0.09538926f, -0.08673436f, 0.08107254f, -0.14942788f, 
    0.13630961f, 0.25140110f, -0.43503681f, 0.49189726f, -0.09240999f, -0.71603537f, -0.42227453f, 0.31942210f, 
    -0.14819734f, -0.53725755f, -0.26878333f, 0.03002009f, -0.09502400f, 0.38162243f, -0.17632821f, 0.05335913f, 
    0.33018354f, 0.11787694f, 0.16300915f, -0.19039716f, -0.11497359f, 0.26738822f, -0.12202702f, -0.06977527f, 
    0.16822502f, 0.05745969f, 0.37144279f, 0.40927824f, -0.38295040f, 0.54537797f, 0.75602937f, 0.23781000f, 
    0.15339562f, -0.54579616f, -0.27496400f, -0.35760581f, -0.32885480f, 0.14281124f, 0.28681102f, 0.21569473f, 
    0.05633207f, 0.08100672f, -0.21515577f, 0.39509434f, 0.02048720f, -0.07570976f, 0.02535614f, -0.06014851f, 
    -0.08472693f, -0.00114585f, -0.34157652f, -0.08032861f, 0.46017328f, 0.54401875f, 0.53288758f, 0.74435312f, 
    0.55754328f, 0.19049749f, -0.08890995f, -0.47167325f, -0.12205739f, 0.08526443f, -0.01414972f, 0.13160032f, 
    -0.03251847f, 0.16516751f, 0.06988571f, 0.23215997f, 0.05678394f, 0.29485425f, 0.04925495f, 0.04744549f, 
    0.12817667f, 0.11963011f, 0.14378496f, -0.11385003f, 0.11184848f, -0.38876355f, 0.57985628f, -0.17360567f, 
    0.37989867f, 0.58293414f, 0.14895195f, -0.25582266f, -0.80695868f, 0.12084504f, -0.29546884f, 0.05131739f, 
    -0.03678415f, -0.15200073f, 0.35160157f, 0.17758289f, 0.16643612f, 0.22930163f, 0.16199386f, -0.34659708f, 
    0.12070017f, -0.09205128f, -0.01547856f, 0.13162753f, 0.23398949f, 0.01238508f, -0.47787207f, -0.52996284f, 
    0.09191644f, 0.70015472f, 0.09906842f, -0.08898266f, 0.05072002f, 0.55278891f, 0.00309388f, -0.23163508f, 
    0.03634058f, -0.01441014f, 0.20215869f, 0.10807031f, -0.30820367f, 0.02183829f, 0.26251054f, 0.01553365f, 
    -0.01749449f, 0.13604075f, -0.36374748f, -0.14928219f, 0.08825429f, 0.14254023f, 0.32535848f, 0.35469162f, 
    -0.17583083f, 0.21884672f, 0.52909625f, 1.01863086f, -0.43166313f, 0.21136197f, -0.06243883f, -0.08883670f, 
    0.05849723f, 0.23205929f, -0.17161062f, 0.16214241f, 0.00802677f, 0.32633683f, -0.08248936f, -0.25684562f, 
    0.53007096f, 0.29159600f, -0.02266909f, 0.00710508f, -0.12796186f, -0.06524973f, 0.00090323f, -0.13293591f, 
    -0.82544702f, 0.01727183f, -0.31705830f, -0.00498021f, 0.28524223f, -0.08192191f, 0.99557877f, 0.18254071f, 
    -0.56225687f, 0.35388362f, -0.03894507f, -0.01637663f, 0.28948310f, -0.37545773f, 0.30230674f, -0.07332901f, 
    -0.13475475f, 0.00831019f, 0.15090287f, -0.09348469f, 0.20544767f, 0.02464294f, -0.02405494f, 0.00243600f, 
    0.02784357f, 0.11151560f, 0.92931867f, -0.28631511f, -0.37085205f, 0.19676222f, 0.03732091f, -0.48211208f, 
    0.03134789f, -0.09614033f, -0.58494401f, 0.23110230f, -0.38684955f, 0.23086809f, 0.12760797f, 0.14893149f, 
    0.29333523f, -0.19110765f, 0.01210610f, 0.23090188f, 0.12221155f, 0.06176675f, -0.30448174f, -0.29523662f, 
    -0.27243760f, 0.01644968f, 0.12484258f, 0.30721477f, -0.43199119f, -0.69769818f, 0.02948457f, -0.26115486f, 
    0.23916003f, -0.10758660f, -0.50535071f, 0.06834278f, 0.18450175f, -0.13138779f, -0.19236998f, 0.11533047f, 
    -0.06653560f, 0.32475749f, 0.18882936f, 0.24656591f, 0.21944430f, -0.23497252f, 0.15732047f, 0.14731239f, 
    0.04312650f, -0.07006454f, 0.29816684f, 0.53599066f, 0.43946064f, 0.19068319f, -0.04054759f, -0.00838104f, 
    -0.26265809f, -0.86661977f, -0.66819727f, -0.64485735f, -0.21039477f, -0.22934720f, 0.36572203f, 0.26456693f, 
    -0.23653010f, -0.21489014f, -0.21590635f, -0.24883994f, 0.19769408f, -0.14538917f, 0.17263426f, 0.17478551f, 
    0.21104370f, 0.01431701f, 0.18788792f, -0.16172887f, 0.90451431f, 0.29471585f, 0.57121074f, 0.04345941f, 
    0.71603906f, 0.30286792f, -0.35912582f, 0.16032815f, 0.09950288f, -0.03729602f, 0.32108769f, 0.33142138f, 
    -0.45213476f, 0.16475871f, 0.08795200f, -0.18493289f, -0.13974454f, -0.21501462f, 0.15290564f, -0.32922959f, 
    0.22846720f, 0.35079780f, -0.05836571f, -0.08971731f, 0.32013869f, 0.62004834f, -0.04754674f, -0.02988527f, 
    0.27145442f, 0.40084004f, 0.63057220f, -0.49244976f, -0.60469729f, -0.14896348f, -0.28455886f, -0.25691587f, 
    -0.39180610f, -0.45052975f, 0.05570179f, -0.20436910f, 0.02702099f, -0.19964761f, -0.34936032f, 0.13359477f, 
    -0.15828359f, -0.21572569f, -0.06939276f, 0.01500758f, -0.03175785f, -0.05561424f, -0.64374077f, -0.69557238f, 
    -0.25655609f, 0.21348242f, -0.51249576f, 0.13739495f, 0.59190720f, 0.42818594f, 0.26632759f, 0.31213230f, 
    0.29112068f, -0.04958742f, 0.00637306f, 0.45847395f, 0.18268894f, -0.06406061f, 0.03982056f, -0.00201539f, 
    -0.29084119f, -0.06900809f, 0.08770433f, 0.13302013f, -0.05081107f, 0.14709876f, 0.01578929f, 0.81894886f, 
    0.54185426f, 0.63457817f, -0.27141297f, -0.57738501f, -0.35713202f, -0.55021763f, -0.17690186f, -0.23094249f, 
    0.37919798f, 0.25752494f, -0.16247603f, 0.22462910f, 0.19660901f, 0.06735249f, 0.05229938f, 0.05323701f, 
    0.13323383f, 0.16853569f, 0.06677842f, 0.05019830f, 0.12876959f, 0.08532763f, 0.32315394f, 0.03593724f, 
    -0.13908885f, 0.19135806f, -0.03133022f, 0.31605530f, -0.51250231f, 0.18134141f, -0.31232432f, -0.28238147f, 
    -0.45997572f, -0.13824102f, -0.01377149f, -0.16960077f, -0.05208191f, 0.51906174f, -0.33225909f, -0.25081983f, 
    0.37443995f, -0.36007744f, -0.03360414f, 0.04020741f, -0.13238911f, 0.12012159f, -0.07060249f, 0.10441159f, 
    -0.37071478f, 0.15787880f, -0.18301129f, -0.35945597f, -0.36988080f, -0.14743640f, -0.62026072f, -0.20419119f, 
    -0.00382291f, 0.33803317f, 0.28822923f, -0.44908336f, -0.13918690f, -0.03868035f, -0.32559434f, -0.24779624f, 
    -0.28791815f, -0.37013692f, -0.15988459f, -0.37194306f, -0.16497523f, 0.11152824f, -0.09062011f, -0.03724650f, 
    0.01793484f, -0.11718275f, 0.35643524f, 0.39152503f, -0.63759184f, -0.14336580f, -0.49383342f, 0.26346478f, 
    -0.39059052f, 0.01856854f, 0.31711069f, -0.19482239f, -0.29791972f, -0.20121372f, -0.09140480f, 0.23908436f, 
    -0.14895770f, -0.24361421f, 0.28754708f, -0.35380593f, -0.15386114f, -0.08185704f, -0.09372411f, 0.03538931f, 
    -0.08823510f, 0.15396133f, 0.16846350f, 0.05407854f, -0.35049805f, -0.52227741f, -0.07567354f, -0.00133617f, 
    0.15604953f, 0.12619281f, 0.13074756f, 0.26130000f, -0.53887206f, 0.14444518f, -0.22323377f, 0.27480304f, 
    -0.02347027f, 0.02302842f, 0.29887396f, -0.41943130f, -0.63205904f, -0.16348656f, -0.05375689f, -0.00337605f, 
    0.14700305f, 0.34191868f, -0.13052359f, -0.04769088f, 0.03123960f, 0.04626800f, -0.43987831f, -0.50923145f, 
    -0.30678207f, -0.15748613f, -0.44750920f, -0.19923940f, -0.38913178f, -0.12814103f, 0.24269708f, 0.30252439f, 
    0.17943835f, -0.05692200f, -0.14207216f, -0.20404319f, 0.18521841f, 0.08350951f, 0.03571381f, -0.34281576f, 
    0.00924745f, -0.22376984f, 0.51977104f, 0.09544912f, -0.22953379f, -0.27578756f, 0.02822902f, 0.23527035f, 
    0.18287827f, 0.64645123f, -0.74795520f, 0.20478092f, -0.48754841f, -0.02336458f, 0.16016209f, -0.03039870f, 
    0.04853547f, 0.34336042f, 0.05889842f, 0.07293870f, 0.20416707f, 0.40799266f, -0.11482063f, 0.39177820f, 
    0.25949004f, -0.39837226f, -0.10290831f, -0.14308065f, -0.09929024f, 0.02168387f, -0.12116144f, -0.47348571f, 
    -0.28431028f, -0.12005464f, -0.28693160f, -0.19776788f, -0.75658035f, -0.25721529f, 0.32113090f, 0.30051690f, 
    -0.57092243f, 0.01782208f, 0.22097494f, -0.04662139f, -0.45617366f, 0.17701857f, 0.21172233f, 0.29644236f, 
    -0.15256099f, 0.08159044f, -0.05649995f, 0.18358871f, -0.20842662f, 0.14062645f, 0.10747295f, -0.06882191f, 
    -0.45594871f, -0.41874251f, -0.34796166f, -0.13287953f, 0.41019672f, 0.50905269f, -0.42228651f, -0.29524317f, 
    -0.12080913f, 0.07749058f, 0.14198381f, 0.32354954f, 0.35262415f, -0.41961673f, -0.17774938f, 0.05649953f, 
    -0.03174324f, -0.17898561f, 0.02679901f, 0.01783213f, -0.12384406f, -0.07390959f, -0.34466833f, 0.05582283f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29281577f, 0.15213339f, 0.26647538f, 0.04846386f, 0.01829206f, 0.17217618f, 0.14112006f, 0.09533966f, 
    0.17307499f, 0.17269941f, 0.21056116f, 0.12753622f, 0.04556238f, 0.12208285f, 0.34144926f, -0.08791601f, 
    0.07202818f, 0.09764234f, 0.04787003f, 0.03151170f, 0.12998952f, 0.08927224f, -0.14140680f, 0.02580347f, 
    0.07763033f, 0.24932243f, -0.02605838f, -0.10172611f, 0.21347916f, 0.20204389f, 0.20811339f, 0.02294118f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02058433f, -0.15260132f, 0.08392946f, -0.14406729f, 0.08130632f, 0.02451559f, 0.05669082f, 0.08724035f, 
    0.11779275f, -0.04293610f, 0.00626764f, 0.02317085f, -0.11891381f, -0.04819182f, 0.13555419f, 0.06867347f, 
    0.05153781f, -0.08348940f, 0.07031543f, -0.09116796f, 0.07070856f, -0.03801315f, -0.01117381f, 0.02872495f, 
    0.01609837f, -0.15838684f, -0.18640748f, -0.30683717f, -0.01089311f, -0.04351602f, 0.01187059f, -0.09569613f, 
    -0.01956294f, 0.00241958f, -0.02806835f, 0.05447368f, 0.55228114f, 0.20703460f, 0.21957438f, 0.38996026f, 
    -0.05189073f, -0.02549074f, -0.12576155f, 0.06989074f, 0.07115753f, 0.09859604f, -0.08185962f, 0.05622701f, 
    -0.27376848f, -0.26730353f, -0.19530787f, 0.10481921f, 0.02274382f, 0.06861082f, -0.04693070f, -0.02227558f, 
    0.06532884f, 0.08054732f, -0.04223218f, 0.05446913f, 0.04979622f, 0.24935301f, -0.00797435f, 0.25192657f, 
    0.00437656f, 0.06016536f, -0.04878403f, 0.06731471f, 0.02458857f, 0.01954974f, 0.02967436f, -0.03867549f, 
    -0.46855357f, -0.08610803f, -0.08000010f, -0.10125351f, 0.15903293f, -0.01132291f, -0.06546909f, 0.05143250f, 
    -0.08239170f, -0.02476683f, -0.00361495f, -0.05885453f, 0.34534049f, 0.12782921f, 0.16955891f, 0.14150296f, 
    -0.05925279f, 0.07425903f, -0.04957663f, 0.07967251f, 0.01837476f, 0.10348669f, -0.06300871f, 0.05664197f, 
    -0.05722652f, 0.05347665f, 0.03866466f, -0.01692945f, 0.10154074f, 0.03632677f, -0.06569274f, -0.05927356f, 
    0.02037313f, -0.05714576f, -0.01347513f, 0.00557041f, -0.31643727f, 0.31723911f, -0.02312006f, -0.18291704f, 
    0.07716025f, 0.10946354f, -0.04019412f, 0.04113531f, 0.08756744f, 0.06595898f, 0.02242589f, 0.00154605f, 
    -0.18569405f, 0.09403889f, -0.06479578f, -0.05521791f, 0.08099539f, 0.02829014f, 0.04834330f, -0.03121543f, 
    -0.09937079f, 0.02906745f, 0.08455856f, 0.09801705f, 0.00901365f, 0.06535316f, 0.24695265f, 0.16721673f, 
    -0.05004031f, -0.00963277f, 0.00090081f, -0.09353744f, -0.03837091f, -0.04218657f, 0.06412519f, 0.07476608f, 
    0.21276671f, 0.12430733f, 0.27629927f, 0.31025979f, -0.06569497f, -0.10634559f, 0.07713640f, 0.01565028f, 
    0.06229139f, 0.12201707f, 0.00906971f, 0.16167414f, 0.01749578f, 0.12227927f, 0.38266894f, 0.06248710f, 
    -0.02568319f, -0.05643097f, -0.02298770f, -0.04065744f, 0.14008005f, 0.05282566f, -0.01027113f, 0.05721037f, 
    -0.32157233f, 0.03914343f, -0.23441617f, 0.11058317f, 0.18128954f, 0.17621367f, -0.06705614f, 0.00029064f, 
    0.03146207f, 0.02696546f, -0.06662818f, 0.10151546f, 0.45426187f, 0.05529546f, 0.01603720f, 0.10080720f, 
    -0.13824840f, -0.01603003f, -0.01485578f, 0.11894975f, 0.08989940f, 0.00324814f, 0.05501281f, -0.04354884f, 
    -0.22921453f, 0.22521524f, 0.02594223f, -0.14100380f, 0.06967262f, -0.03484618f, 0.01950542f, 0.02651888f, 
    0.02370940f, -0.07057386f, 0.03414163f, 0.02071154f, -0.01485059f, 0.21447873f, 0.09744772f, -0.08088161f, 
    -0.04345229f, -0.08755654f, -0.13746531f, -0.05428038f, 0.02952594f, 0.13330659f, 0.06975425f, 0.09957992f, 
    -0.27043337f, -0.00501532f, 0.06108866f, -0.12855144f, -0.01012221f, 0.10584456f, 0.03956610f, 0.09861889f, 
    0.08131852f, -0.07830807f, -0.02747165f, -0.00993995f, -0.18559246f, -0.12357870f, 0.32573232f, 0.14376980f, 
    -0.27245855f, -0.03908124f, 0.01021011f, -0.09725842f, -0.05585929f, -0.13704151f, 0.07409766f, 0.11775292f, 
    0.22351098f, -0.00113816f, 0.33690241f, 0.09703664f, -0.09084560f, -0.17782675f, -0.12346943f, 0.05087274f, 
    0.03363643f, -0.01901595f, -0.04315583f, -0.00727917f, 0.10186364f, 0.13544963f, 0.24346827f, 0.11973259f, 
    0.01220094f, -0.04179427f, 0.05428115f, 0.13237761f, 0.07619704f, 0.03620080f, 0.06087240f, 0.10074050f, 
    -0.56290388f, -0.06397189f, -0.10637133f, -0.01038321f, 0.13010886f, 0.14007947f, 0.06795011f, 0.17435521f, 
    -0.05599975f, -0.10878480f, 0.04590876f, 0.06453908f, -0.12405279f, -0.06797390f, 0.12829624f, -0.08353726f, 
    -0.05072512f, -0.09850442f, -0.02692711f, 0.04675912f, 0.06678890f, -0.04566063f, -0.05671865f, -0.01464765f, 
    -0.16149022f, -0.06483454f, -0.08160473f, -0.15477034f, 0.00982005f, -0.03364408f, -0.00762793f, -0.03858201f, 
    -0.19102180f, -0.02574616f, 0.04741531f, 0.04386294f, -0.21182559f, -0.30124500f, -0.05886279f, 0.05956500f, 
    0.17502813f, 0.01523337f, 0.13526343f, -0.06899317f, -0.10704810f, 0.00378441f, -0.05870085f, -0.03599115f, 
    0.12944211f, -0.16465184f, -0.10756955f, -0.09025542f, 0.01252413f, 0.06947243f, 0.02861857f, -0.06167141f, 
    0.00261085f, -0.08344107f, -0.01183229f, -0.00667853f, -0.15286076f, 0.03230156f, -0.19492956f, -0.35879156f, 
    -0.03083544f, 0.10892297f, 0.01433079f, 0.03964473f, -0.10984308f, 0.04097482f, -0.12293838f, -0.05023487f, 
    -0.11983315f, -0.01378517f, -0.01945948f, -0.13923311f, 0.04991020f, -0.08859679f, 0.11670130f, 0.03732089f, 
    0.03348719f, -0.05983531f, -0.06750521f, 0.09479663f, 0.10713682f, 0.03054321f, -0.03614756f, -0.07355673f, 
    0.02506076f, 0.02042584f, -0.00693560f, 0.11262224f, 0.07123999f, 0.10988585f, 0.09262389f, 0.01841972f, 
    -0.11975051f, -0.23099875f, -0.02059775f, 0.06569490f, 0.02228739f, 0.11106504f, -0.01058050f, -0.06064988f, 
    0.17567195f, 0.01100692f, 0.13306299f, 0.14632674f, -0.44930756f, -0.02482067f, -0.07987968f, -0.08284062f, 
    0.04919327f, -0.00975783f, 0.15172333f, -0.00670844f, 0.12415349f, -0.00874265f, 0.03493840f, 0.05145609f, 
    0.10735928f, -0.02872952f, -0.06589130f, 0.23074600f, -0.03230150f, -0.00794294f, 0.10638141f, -0.05835639f, 
    -0.01254029f, -0.01502825f, 0.10200229f, 0.08686450f, 0.18740965f, -0.17167433f, -0.10155042f, -0.02621436f, 
    0.03681516f, 0.02453841f, -0.10909235f, 0.10095570f, 0.00381881f, 0.09415437f, 0.07510471f, 0.01843468f, 
    -0.42070872f, 0.14000717f, 0.10733519f, 0.08726227f, 0.02318060f, 0.04752239f, 0.07271239f, 0.04943405f, 
    0.07383683f, 0.12018526f, 0.06687729f, -0.01831509f, -0.21757044f, 0.02741349f, -0.21554875f, -0.20764652f, 
    0.11122270f, -0.04840091f, 0.03461765f, -0.01881347f, -0.14635530f, -0.14368755f, -0.05122303f, 0.18589911f, 
    0.14916579f, 0.19818191f, -0.07962676f, -0.01609444f, -0.02731420f, 0.06237079f, -0.14756073f, 0.05720466f, 
    0.02979049f, -0.16537689f, -0.04678528f, -0.00960100f, -0.31277049f, 0.11782937f, 0.03081873f, -0.11199661f, 
    -0.02152121f, -0.04203354f, 0.00237554f, 0.11489971f, -0.08220841f, -0.00848111f, -0.05267152f, 0.12773284f, 
    0.01717796f, 0.03348013f, -0.21469560f, 0.10077782f, -0.04347738f, 0.08801302f, 0.00929670f, -0.04485498f, 
    -0.08080474f, 0.09853032f, 0.15036176f, 0.00361203f, -0.32138392f, 0.05160331f, -0.01212509f, -0.17819354f, 
    0.05086078f, -0.00184713f, 0.10349074f, 0.04200155f, 0.05797239f, 0.00556326f, 0.04797709f, 0.07844406f, 
    0.13974114f, -0.00642017f, -0.11579570f, -0.04166974f, 0.12451624f, 0.01643182f, 0.07481777f, 0.23029308f, 
    0.02788082f, -0.00534673f, 0.08888581f, -0.04238539f, -0.04032741f, -0.04801743f, -0.03429428f, 0.11433800f, 
    0.04378650f, 0.00544001f, 0.06590718f, 0.16444096f, -0.06920952f, -0.02683824f, 0.08016748f, 0.05600559f, 
    0.27223730f, -0.26898846f, 0.15623637f, 0.09956366f, -0.03502460f, 0.11004891f, 0.03557657f, 0.05216132f, 
    0.04934498f, -0.11233822f, 0.02932901f, 0.07600369f, 0.08972714f, 0.04212528f, -0.21741746f, -0.18541963f, 
    0.11616230f, -0.08812644f, 0.01371639f, 0.01086286f, -0.03810737f, 0.02227141f, -0.13696679f, 0.16403602f, 
    -0.10096239f, 0.24444118f, -0.10317158f, -0.29682827f, -0.01075636f, -0.00530798f, -0.08954807f, 0.05818537f, 
    -0.07064473f, 0.04916471f, -0.06514944f, -0.01651067f, -0.09177977f, 0.11228513f, 0.10067807f, -0.01586916f, 
    0.00136662f, 0.00912648f, 0.05004553f, 0.10235455f, -0.02377497f, -0.03864741f, -0.00655761f, 0.04589774f, 
    0.14925967f, 0.24915835f, -0.18640529f, 0.08384928f, 0.18777899f, -0.04302656f, -0.06732046f, 0.09431511f, 
    0.14484006f, 0.06523588f, -0.01744409f, 0.00139758f, -0.06277955f, 0.04914526f, -0.25617903f, 0.08232579f, 
    0.07538132f, 0.00386573f, 0.00500112f, -0.03233339f, 0.04353455f, 0.01242287f, -0.04164386f, 0.02995026f, 
    0.22538325f, -0.17392062f, 0.08871379f, -0.02256458f, 0.06499968f, -0.00512321f, 0.08826911f, 0.12143915f, 
    0.00502850f, 0.14439285f, -0.01166764f, 0.01291827f, 0.11805122f, -0.19182426f, 0.24706066f, 0.07712470f, 
    -0.18921599f, 0.05892865f, 0.06548628f, 0.12466826f, 0.10632317f, -0.05712441f, 0.04831607f, -0.08055597f, 
    0.11737283f, -0.15226631f, 0.17250496f, 0.22020909f, 0.14235641f, -0.16023529f, -0.01185385f, 0.08242574f, 
    0.00629835f, 0.06575862f, -0.08972185f, -0.09705444f, -0.03602315f, 0.33561289f, 0.11988664f, -0.04619598f, 
    0.01469329f, 0.01889364f, -0.11762143f, -0.13800381f, -0.02803965f, -0.02874901f, -0.12689686f, 0.07197118f, 
    0.22251970f, 0.16829263f, -0.12676819f, -0.30477211f, 0.22700188f, 0.04185111f, -0.01395153f, -0.09475567f, 
    -0.01927940f, 0.04116758f, 0.10927815f, -0.02335628f, 0.09352481f, 0.15161160f, -0.06316414f, -0.16988057f, 
    0.01509903f, -0.19071798f, -0.19331333f, -0.10525257f, -0.03556894f, -0.09003710f, -0.00534638f, -0.00086059f, 
    0.02302494f, 0.20238553f, -0.07887148f, 0.02272895f, 0.08253543f, 0.06924525f, -0.04173344f, -0.04978056f, 
    0.11488038f, 0.05914402f, -0.01634818f, 0.03779791f, 0.12280799f, 0.09665897f, 0.21062110f, -0.07832491f, 
    -0.04862868f, 0.12526089f, -0.07597663f, 0.00312474f, -0.00606667f, 0.05117939f, 0.00701095f, 0.02457564f, 
    0.03344456f, 0.02820126f, 0.01238587f, 0.03110721f, 0.01998003f, 0.15369175f, -0.15740524f, -0.06389307f, 
    0.11621578f, 0.07852240f, 0.03793752f, -0.03675844f, 0.12496955f, 0.04269663f, -0.10874016f, 0.05038017f, 
    -0.04505322f, 0.00031270f, -0.08009402f, -0.03427065f, 0.07008990f, 0.11174063f, 0.23622219f, 0.06167972f, 
    -0.10578160f, 0.16503507f, 0.23282896f, 0.01172739f, 0.05420632f, -0.11355650f, -0.04042282f, -0.02131514f, 
    -0.01960998f, 0.10211972f, 0.08353907f, 0.13896403f, -0.16545105f, 0.04174107f, -0.05529431f, 0.12684329f, 
    0.06085754f, -0.07031644f, -0.00696030f, 0.10775548f, 0.04250815f, 0.03033750f, 0.13226731f, 0.05738428f, 
    -0.21682338f, -0.19264211f, 0.03348432f, 0.02368401f, -0.01792002f, 0.01134748f, 0.03946669f, -0.09161401f, 
    -0.04193342f, 0.13228258f, -0.05572541f, -0.11046276f, 0.05879223f, -0.18712614f, 0.00619088f, 0.00674741f, 
    -0.01500278f, -0.02640017f, -0.08157276f, 0.17805424f, 0.08388168f, 0.06032193f, 0.02862457f, 0.04606277f, 
    0.32346198f, -0.06220560f, -0.06523307f, -0.00151365f, 0.04878438f, -0.05912558f, 0.06870332f, -0.03921638f, 
    -0.01929189f, 0.21894327f, -0.15089504f, 0.01480287f, -0.08709367f, 0.13914715f, -0.01569471f, 0.01504189f, 
    0.16282544f, 0.02156418f, -0.10209683f, -0.00661432f, 0.12203366f, 0.09552120f, -0.20516048f, 0.09537838f, 
    0.20227592f, -0.07588077f, 0.14976871f, -0.19476230f, 0.16544601f, 0.03494674f, 0.08148076f, 0.17201132f, 
    0.03215793f, 0.09277539f, 0.06814110f, -0.00995519f, -0.33257967f, 0.21568224f, 0.11862341f, 0.00193664f, 
    0.05858281f, 0.03759306f, -0.05937107f, -0.03855068f, 0.08794504f, -0.06566668f, -0.06153056f, -0.02903667f, 
    0.24888946f, -0.39118385f, -0.01038267f, -0.23635408f, -0.11613769f, -0.01894894f, 0.01571270f, 0.10789668f, 
    0.15319557f, -0.07865493f, -0.00314176f, 0.14144465f, -0.03652255f, -0.16191016f, 0.09355959f, 0.22778466f, 
    -0.20680062f, -0.01644976f, -0.03194093f, -0.07609703f, 0.04907399f, 0.05410234f, 0.01673922f, 0.08019054f, 
    0.26074618f, 0.07140606f, -0.04831358f, 0.32007384f, 0.14369157f, 0.20459315f, -0.03998035f, -0.08424551f, 
    0.03268931f, 0.01984945f, 0.03726024f, 0.15487561f, 0.12215950f, -0.01868165f, -0.16951120f, 0.34379163f, 
    0.21291181f, 0.00547401f, -0.01390656f, 0.06459945f, -0.01098180f, 0.01621776f, -0.04119370f, 0.05745863f, 
    0.22465464f, 0.04635930f, 0.07234477f, 0.33556959f, -0.11236270f, 0.10150246f, -0.09472027f, 0.11198414f, 
    0.06866518f, 0.02769203f, -0.10022534f, -0.00377756f, -0.05594419f, -0.20414774f, -0.09232934f, -0.05032426f, 
    -0.07284915f, 0.02913658f, -0.16161825f, -0.05993162f, -0.00078481f, -0.03604154f, 0.00905605f, -0.11447573f, 
    0.31781816f, 0.12072311f, -0.07588699f, -0.16437130f, 0.20525825f, -0.03883297f, -0.02733267f, 0.09054150f, 
    0.03896964f, 0.08121308f, -0.08417874f, -0.06974030f, 0.33830568f, 0.01628825f, -0.21180086f, -0.21923460f, 
    0.17979701f, 0.07462876f, 0.03884339f, 0.07365382f, 0.11047693f, 0.07941055f, 0.00562703f, 0.11710164f, 
    -0.19929820f, 0.07600945f, 0.07149491f, -0.19092368f, 0.06027521f, 0.08369812f, 0.03212010f, 0.06370509f, 
    0.06315998f, 0.04868850f, -0.02569511f, -0.01566723f, 0.06992006f, 0.18331228f, -0.01362784f, 0.18221606f, 
    0.01778436f, -0.00958392f, 0.04649121f, -0.06262086f, -0.01248081f, 0.10171337f, 0.08710372f, -0.07575995f, 
    -0.37129471f, -0.15605436f, -0.02768774f, -0.00762496f, -0.14891572f, -0.16261466f, -0.02810314f, -0.10900930f, 
    0.12849939f, -0.00114824f, 0.05191562f, -0.07811328f, 0.09445892f, 0.03795904f, -0.16474715f, -0.17086402f, 
    0.08405852f, -0.03076869f, 0.04173709f, 0.06181405f, 0.06042997f, 0.04247968f, 0.07695170f, -0.06584775f, 
    -0.12017846f, 0.11619043f, -0.17957944f, 0.29661894f, 0.07435503f, 0.04535424f, -0.04442924f, 0.10012565f, 
    -0.03721794f, -0.04698832f, 0.03440997f, 0.04468323f, 0.00183680f, -0.01541292f, 0.02896218f, -0.01942304f, 
    -0.08373005f, -0.02899325f, -0.05240737f, 0.06996121f, -0.07904222f, 0.10351001f, -0.04753024f, -0.04159433f, 
    0.35487366f, 0.14870472f, -0.12119459f, -0.14672023f, 0.09404884f, 0.01468567f, -0.03960199f, 0.05999615f, 
    0.05214802f, -0.00464819f, -0.05831644f, 0.15934215f, 0.13837181f, -0.06265426f, 0.12609899f, -0.37469774f, 
    -0.20154268f, -0.03782111f, -0.04989195f, 0.05721700f, 0.07055775f, 0.11493415f, -0.04953782f, -0.00760525f, 
    -0.05143199f, 0.07908469f, 0.09451637f, -0.19514348f, -0.01996799f, 0.15278509f, -0.03477349f, -0.01588552f, 
    0.07348821f, 0.07718313f, 0.07662470f, 0.01760389f, 0.32379240f, -0.12695041f, 0.40989861f, 0.00745668f, 
    -0.17991070f, 0.08481140f, 0.09307705f, -0.01569944f, 0.10274578f, 0.12375115f, 0.02456841f, 0.02389633f, 
    -0.27210760f, -0.20998134f, 0.12302497f, -0.14204022f, -0.09842524f, -0.08348840f, 0.01867731f, -0.03850416f, 
    -0.09996779f, 0.05038229f, 0.06325150f, 0.04792275f, 0.15040469f, -0.03200766f, 0.19303015f, -0.09766041f, 
    0.10165628f, 0.02601965f, 0.00432838f, 0.04279522f, -0.07392448f, -0.00536094f, -0.10459343f, -0.04218894f, 
    0.36169609f, 0.05093060f, -0.22845769f, -0.01888039f, 0.05439620f, -0.03540238f, -0.04184394f, 0.02241691f, 
    -0.07960342f, -0.00204012f, 0.04054319f, 0.16095276f, -0.40701073f, -0.17155942f, 0.19684629f, 0.22859345f, 
    -0.01505649f, -0.00387578f, 0.06721248f, -0.04572691f, 0.01622936f, 0.05236618f, 0.01099644f, 0.16037686f, 
    -0.24516222f, 0.10908747f, 0.09034001f, 0.17883848f, 0.14253591f, -0.08426388f, 0.11586498f, 0.10618547f, 
    -0.02720189f, -0.02638889f, -0.01205105f, 0.05435782f, 0.09919222f, -0.20242876f, 0.05786400f, -0.11540863f, 
    0.02118387f, 0.06889800f, 0.10026363f, 0.12904729f, -0.12864061f, -0.19556083f, -0.14509006f, 0.02101904f, 
    -0.25317305f, -0.38861224f, 0.17244424f, -0.14104320f, -0.07610860f, 0.00628159f, -0.05245268f, 0.15705487f, 
    0.12592460f, 0.07059705f, -0.00767854f, -0.06647657f, 0.14572839f, -0.17372762f, 0.06393658f, 0.03604693f, 
    -0.10259549f, 0.11596825f, 0.07333434f, -0.04046725f, -0.14330572f, 0.03971360f, -0.20457061f, -0.06195356f, 
    0.29818246f, 0.12358487f, 0.13824743f, -0.03258319f, 0.01052256f, -0.03985096f, -0.01474996f, 0.12702987f, 
    0.01623656f, 0.07573000f, 0.11531437f, -0.09968800f, 0.06601680f, 0.11162052f, -0.04572161f, -0.09328936f, 
    0.05573420f, 0.08138952f, -0.01501910f, 0.03974659f, 0.01690919f, 0.12953497f, 0.02845947f, 0.03321232f, 
    0.08727822f, 0.05895521f, 0.12620749f, -0.05355413f, -0.03407019f, 0.10616441f, 0.12824918f, 0.05743722f, 
    -0.15855801f, -0.13833523f, 0.05404576f, -0.04646993f, 0.12827200f, 0.12138111f, -0.08792017f, -0.00684247f, 
    -0.02716856f, -0.05046709f, 0.12065265f, 0.22964372f, -0.07951311f, 0.06562142f, 0.03856007f, -0.01217850f, 
    0.05004936f, -0.02897284f, -0.01210179f, -0.06846827f, 0.01622749f, -0.01079645f, 0.08559066f, -0.08209626f, 
    -0.02245107f, -0.09872106f, -0.05639216f, 0.02570013f, -0.07804045f, 0.30926591f, 0.23391211f, 0.09526906f, 
    0.09417735f, 0.14450654f, 0.06209479f, 0.05886337f, 0.05812448f, 0.03120695f, 0.12062275f, -0.20006599f, 
    -0.04302825f, -0.22858433f, 0.04206427f, 0.03077672f, 0.07063098f, 0.14271501f, 0.01872939f, 0.02263467f, 
    -0.07372405f, 0.06055233f, 0.12195932f, 0.07996490f, -0.05367501f, -0.15861990f, 0.10009525f, -0.11880232f, 
    -0.02851738f, 0.00472816f, -0.03135689f, 0.01880776f, -0.00914086f, -0.07042822f, -0.02023310f, 0.08848536f, 
    0.16663627f, 0.01649239f, 0.06614772f, 0.00499380f, 0.06328826f, 0.01678843f, 0.01617120f, 0.00878282f, 
    0.01423184f, -0.11108467f, 0.03442270f, -0.15706116f, 0.46064037f, -0.10196450f, -0.00287975f, 0.11041030f, 
    0.06177689f, 0.12694432f, 0.16456044f, -0.07958278f, 0.06419985f, -0.09969812f, 0.12759212f, 0.01676153f, 
    0.18459167f, -0.02578927f, 0.06794138f, 0.15390055f, 0.02748237f, -0.15562254f, 0.03595581f, -0.08566920f, 
    0.11212220f, 0.17309946f, 0.09556056f, 0.12901735f, -0.36596021f, -0.33368820f, -0.00125647f, -0.06411703f, 
    -0.21517487f, 0.02829203f, 0.07693623f, 0.19559959f, 0.12540512f, -0.03933369f, 0.11618610f, -0.01856015f, 
    0.10320940f, 0.05160015f, -0.07296331f, -0.18158905f, -0.09982877f, -0.01834780f, -0.04619574f, 0.18900731f, 
    -0.00892299f, 0.22712141f, 0.09500025f, 0.02516496f, 0.03906406f, -0.09155463f, -0.08933527f, -0.13270117f, 
    -0.14725649f, -0.13733271f, 0.07550334f, -0.05303290f, -0.14753470f, 0.05040494f, 0.13593629f, 0.03085208f, 
    0.45547941f, 0.03374991f, -0.07262149f, 0.05071004f, -0.03954067f, 0.04126794f, -0.03419815f, 0.13723902f, 
    0.14968027f, -0.00141248f, 0.01191379f, -0.14537050f, 0.28323328f, -0.12737438f, 0.03082388f, 0.17409158f, 
    0.02613771f, 0.13067123f, 0.11203081f, -0.06809811f, 0.14013392f, 0.06753436f, -0.08944834f, -0.06315563f, 
    0.12208878f, -0.09411315f, -0.07554010f, -0.00974375f, -0.06397992f, 0.01030935f, -0.00750980f, 0.01960031f, 
    0.05819816f, -0.19703805f, -0.16999015f, -0.08289515f, 0.53747422f, 0.20639493f, -0.06515501f, -0.00855774f, 
    0.12701899f, -0.08114934f, 0.06203287f, 0.01238607f, -0.03456039f, -0.02232342f, -0.01859841f, -0.08602443f, 
    0.09762654f, -0.03141620f, 0.04706623f, -0.02177508f, -0.16847238f, -0.16104245f, -0.09579995f, 0.09766912f, 
    -0.05685388f, -0.08023277f, -0.00870621f, -0.08426911f, -0.05671008f, 0.06320184f, 0.23883507f, 0.06193436f, 
    -0.09921118f, 0.31091091f, 0.05731746f, 0.11889600f, -0.03819041f, 0.05000318f, -0.10981864f, 0.06938439f, 
    -0.26378369f, 0.02506888f, 0.18491930f, 0.07727717f, 0.02497603f, -0.00117857f, 0.03116680f, 0.12391611f, 
    -0.00869447f, -0.13434771f, -0.11713739f, 0.09068377f, 0.19753960f, 0.35074237f, -0.03539203f, 0.01024948f, 
    -0.05639923f, -0.01477249f, 0.06078093f, 0.05779702f, 0.03617013f, -0.02869222f, -0.00656808f, -0.10081593f, 
    -0.08434591f, 0.02164405f, -0.01282353f, -0.07370824f, 0.05983112f, -0.10847495f, 0.08717193f, -0.14971267f, 
    -0.06017325f, 0.09734259f, -0.19697356f, -0.01763035f, 0.35479617f, 0.01132159f, -0.02351461f, 0.03515894f, 
    0.28814363f, 0.10890906f, -0.08262705f, 0.13097872f, 0.07370894f, 0.04195961f, -0.09490477f, 0.11462607f, 
    -0.12344720f, -0.23507901f, -0.12886931f, -0.08761829f, -0.12916134f, 0.05248800f, 0.02473607f, -0.06158782f, 
    0.04820006f, 0.09793343f, 0.04567873f, 0.04995924f, 0.12998921f, -0.37431404f, 0.00086393f, 0.18456507f, 
    0.03340427f, -0.04738472f, -0.03391722f, 0.05290398f, 0.11209898f, -0.18325438f, -0.03454950f, 0.08496228f, 
    0.47078753f, -0.01704887f, -0.02506119f, -0.28835657f, -0.15898117f, 0.01872588f, -0.00304648f, -0.11962721f, 
    0.01422510f, 0.00586622f, -0.00169971f, -0.03039054f, -0.19170706f, -0.11417133f, -0.16272324f, 0.23957630f, 
    0.04466735f, 0.15625447f, 0.01707230f, 0.03098433f, 0.03984873f, 0.02415063f, -0.08442035f, 0.03023145f, 
    0.39573517f, 0.06472474f, -0.00017618f, 0.03857936f, -0.01578683f, 0.13635972f, 0.00086327f, 0.03375116f, 
    -0.01834283f, 0.00163304f, 0.02017800f, 0.12690327f, -0.05289195f, 0.06196089f, -0.02190789f, 0.04820950f, 
    -0.07284796f, -0.08419257f, -0.00179502f, -0.06391940f, 0.03109031f, 0.11783591f, 0.19311482f, 0.08281595f, 
    -0.01555722f, -0.19847874f, -0.17150758f, 0.20134041f, -0.12308708f, -0.01711966f, 0.04692850f, 0.04195612f, 
    0.08904234f, 0.15691721f, 0.17388059f, -0.00233475f, 0.36026728f, -0.04428790f, 0.00070426f, 0.00812128f, 
    -0.14078954f, -0.10961547f, -0.03169332f, -0.14685604f, 0.06671750f, -0.09239308f, 0.15539657f, 0.11349174f, 
    0.05465001f, -0.14896630f, -0.15763940f, -0.01828946f, 0.02660073f, 0.00893673f, -0.12596160f, 0.08578384f, 
    -0.03377010f, 0.15271442f, -0.17459349f, -0.04602287f, -0.15225834f, 0.18124467f, 0.10090262f, 0.25331590f, 
    -0.03125473f, 0.04886542f, 0.08642663f, 0.01526701f, 0.02820554f, -0.06972546f, -0.16323686f, -0.10436483f, 
    0.05326352f, 0.12188369f, -0.03914900f, 0.01957255f, -0.07074016f, -0.11919249f, 0.09858147f, -0.03410919f, 
    0.06632345f, 0.10826162f, -0.05674358f, 0.04442909f, 0.22623058f, -0.04376831f, -0.06741857f, -0.01241557f, 
    -0.20035677f, -0.06937963f, 0.12835163f, 0.00467339f, 0.01370485f, 0.03498573f, -0.15343261f, 0.12064427f, 
    -0.00911520f, 0.22071743f, 0.16994944f, 0.00491653f, -0.00831705f, 0.07244753f, -0.11479150f, -0.02317366f, 
    -0.09696000f, 0.08858385f, 0.04084034f, -0.00487946f, -0.01549467f, -0.05119176f, 0.05319861f, 0.08991875f, 
    -0.07089586f, -0.06621815f, -0.01616433f, 0.10442930f, 0.00584822f, 0.01420138f, -0.06131089f, 0.06585085f, 
    -0.00393024f, 0.12945507f, -0.20816162f, 0.07010503f, 0.03516484f, -0.01924130f, -0.09172384f, 0.04545822f, 
    -0.04596321f, 0.05729327f, -0.14245237f, 0.02585886f, -0.02200397f, -0.14725697f, 0.00155290f, -0.13318469f, 
    0.01283666f, 0.01138079f, 0.04242067f, -0.04472188f, 0.00454857f, -0.00899149f, 0.04241964f, -0.11459111f, 
    -0.16334918f, 0.06926160f, 0.24999057f, 0.07042457f, -0.01386179f, -0.12857483f, 0.21154210f, 0.03262299f, 
    0.00580182f, 0.00728374f, -0.03890981f, -0.00491242f, 0.01174789f, 0.04781068f, 0.16643532f, -0.08115505f, 
    -0.07048924f, -0.11848730f, 0.02677377f, -0.08920335f, 0.12163402f, -0.00115732f, 0.01490248f, -0.05979972f, 
    0.11044054f, 0.07311480f, 0.19125149f, -0.01051005f, 0.15149690f, -0.02103299f, 0.11991759f, -0.02260795f, 
    0.05504901f, -0.05094607f, -0.12961775f, 0.08739020f, -0.25603998f, 0.11876610f, -0.11494415f, 0.08396798f, 
    -0.04353294f, 0.01874396f, -0.03429861f, -0.16624151f, -0.09297302f, 0.06211385f, 0.03573414f, -0.07174144f, 
    -0.17145930f, -0.12742557f, 0.07231689f, -0.09267288f, -0.09204815f, 0.07875333f, 0.14088683f, -0.09139573f, 
    0.02949444f, -0.02658719f, 0.11187760f, 0.06489089f, -0.02836193f, 0.01523688f, 0.10241398f, -0.02748589f, 
    -0.10237455f, 0.01126386f, 0.04853790f, -0.13089083f, 0.02175875f, 0.14927097f, -0.10387196f, -0.07299604f, 
    0.35077903f, 0.11789420f, -0.12958108f, 0.27662089f, 0.01943491f, -0.02813098f, 0.00513037f, -0.06262472f, 
    0.12911800f, 0.02266745f, -0.12465338f, -0.05758917f, 0.20481260f, -0.20868012f, -0.13333899f, -0.01404076f, 
    -0.00058988f, -0.02381008f, 0.09296619f, -0.03918508f, 0.04417941f, 0.07078611f, 0.03265633f, -0.01166975f, 
    -0.06705722f, -0.01939207f, -0.10470460f, 0.00291325f, 0.12503435f, 0.01478046f, 0.05119498f, 0.04968739f, 
    -0.10133889f, -0.12101209f, 0.07041501f, 0.05349458f, -0.10467269f, -0.09133297f, 0.05583136f, 0.03828834f, 
    0.11116461f, -0.08675683f, 0.01186687f, 0.13738862f, -0.00547742f, 0.02163636f, 0.12406873f, 0.04779162f, 
    0.04586895f, 0.01082303f, 0.30550885f, -0.13669725f, -0.02280706f, -0.06675504f, 0.16363692f, -0.12798764f, 
    0.05363523f, 0.06650990f, 0.06400880f, 0.01044992f, -0.28572863f, 0.17544626f, 0.16314916f, -0.08926620f, 
    -0.06376427f, 0.07841477f, 0.10765355f, -0.11729242f, 0.04562059f, -0.07617141f, 0.10517283f, -0.04407126f, 
    -0.20997806f, 0.03989667f, -0.01704419f, 0.04362401f, -0.08561174f, 0.15143873f, 0.06253174f, 0.04877566f, 
    -0.06925894f, -0.02442096f, -0.06358620f, -0.11022922f, 0.08252338f, 0.20562489f, 0.03071175f, 0.20659791f, 
    0.10698876f, 0.02949582f, -0.12348273f, 0.16417781f, -0.00649639f, -0.06142658f, 0.06241045f, -0.01346425f, 
    0.10869793f, 0.13562267f, 0.03805118f, 0.08209740f, 0.07797167f, -0.01104152f, -0.00652062f, -0.13370723f, 
    -0.07801779f, 0.01638468f, -0.00677527f, 0.09317183f, 0.26844731f, 0.02577596f, -0.30910373f, 0.27150634f, 
    0.19074242f, 0.02222544f, 0.00546725f, 0.16671789f, -0.01839095f, 0.00455450f, -0.02564822f, -0.04469695f, 
    -0.06435210f, -0.15194912f, -0.19121741f, 0.09367135f, -0.03073818f, 0.12194730f, 0.05075553f, -0.02601609f, 
    -0.11880989f, -0.00488647f, -0.05507588f, 0.03565947f, -0.00635026f, -0.07801830f, -0.09104738f, 0.28202349f, 
    -0.12017810f, 0.04472747f, 0.09752356f, -0.03357874f, 0.01355002f, -0.00652394f, 0.04814356f, 0.00899568f, 
    0.06641429f, -0.08089005f, 0.19365795f, -0.07457419f, -0.02617493f, -0.02511325f, 0.10499597f, -0.17188518f, 
    0.01832073f, 0.09438559f, 0.02717040f, -0.06848064f, 0.28547049f, 0.03285639f, -0.34048042f, 0.04112734f, 
    0.11042006f, 0.00339750f, -0.07780060f, 0.04982894f, 0.07865389f, 0.03235386f, -0.00701595f, 0.09630071f, 
    0.32576564f, -0.05947899f, 0.07103675f, 0.22642794f, -0.09558211f, -0.19540499f, -0.00575392f, 0.05973465f, 
    0.15016113f, -0.11363024f, -0.11803839f, -0.01045565f, 0.05095815f, 0.13886774f, 0.04117379f, 0.02260792f, 
    0.03729450f, 0.04767315f, -0.22569482f, -0.07950462f, 0.01332277f, -0.12050960f, 0.07414752f, 0.04874193f, 
    0.30022943f, 0.25580895f, -0.07269011f, 0.09260783f, -0.02365101f, 0.11750320f, 0.10888386f, 0.10818601f, 
    0.08985417f, 0.08817738f, -0.08920251f, -0.05359344f, 0.28058952f, -0.02286591f, 0.08527564f, 0.04702317f, 
    0.08234889f, -0.01924847f, 0.04095364f, 0.00561635f, 0.07312980f, -0.11857660f, 0.03938419f, 0.12304907f, 
    0.09439492f, 0.12039948f, -0.05565572f, 0.08739997f, -0.11514609f, 0.00512689f, -0.17248312f, -0.04544423f, 
    0.07723907f, -0.01861295f, -0.01050741f, 0.13724063f, -0.25824964f, 0.01566516f, 0.08270999f, 0.10008906f, 
    0.08032329f, -0.04412866f, 0.04360537f, -0.01815266f, -0.08912990f, -0.05380829f, -0.04379348f, -0.03049085f, 
    0.21146828f, 0.21864206f, -0.09835626f, -0.13808373f, -0.08507565f, 0.01816893f, 0.04238945f, 0.02579073f, 
    -0.01325439f, -0.05140528f, 0.05877995f, -0.07562438f, 0.16970731f, 0.04708809f, -0.04798597f, 0.03773674f, 
    -0.09915651f, -0.00165678f, 0.05654410f, -0.09969492f, -0.11317361f, -0.14542879f, 0.00868534f, 0.08562018f, 
    0.03043170f, 0.21336736f, 0.01774816f, -0.04414138f, 0.08080198f, 0.07021685f, -0.02999803f, 0.13511726f, 
    0.03367648f, 0.08206324f, 0.01626533f, -0.08188165f, 0.21742067f, 0.05701080f, -0.19693708f, -0.11083554f, 
    0.01463359f, 0.03737845f, -0.10822115f, -0.03421794f, 0.03385181f, -0.04643326f, 0.04512355f, -0.01093913f, 
    0.33320367f, -0.02031779f, 0.16397399f, -0.09954056f, 0.11117792f, -0.14011338f, 0.15940334f, 0.20956872f, 
    0.02776117f, -0.08512852f, -0.02430190f, 0.02191783f, -0.11401394f, 0.09070472f, -0.22699010f, 0.05647824f, 
    -0.02796908f, 0.05348120f, 0.08285645f, 0.00241213f, 0.02382720f, -0.04156305f, 0.05593766f, -0.02831478f, 
    -0.21233994f, 0.13973436f, 0.01047808f, 0.21344788f, 0.02475525f, -0.05545102f, -0.01743087f, -0.08160125f, 
    -0.03062975f, 0.06796459f, 0.04952358f, 0.02108012f, 0.06955558f, -0.22236352f, -0.10420784f, 0.05452964f, 
    0.12824838f, -0.07919244f, -0.01340284f, -0.00425164f, -0.04021804f, 0.16628960f, 0.00539132f, 0.03724376f, 
    -0.08613503f, 0.09565239f, -0.18175858f, 0.24978271f, -0.21950646f, 0.04795693f, -0.06624113f, 0.14496724f, 
    0.06536023f, -0.03376152f, -0.00569944f, -0.04367777f, 0.16720547f, 0.02627114f, 0.05281626f, -0.02152663f, 
    0.23862652f, -0.02273902f, -0.07450365f, -0.08000417f, 0.03027982f, 0.07005107f, 0.05684079f, -0.00397496f, 
    0.17526500f, -0.00324318f, -0.14603037f, -0.16658826f, 0.10378972f, -0.03510729f, 0.06721291f, 0.06093780f, 
    -0.04376939f, -0.00022383f, -0.10371442f, -0.00044244f, 0.39224705f, 0.05162892f, -0.07225011f, -0.00236319f, 
    0.01647095f, 0.08664679f, -0.06474416f, 0.07700256f, 0.03006021f, -0.04790942f, -0.03909199f, -0.00028957f, 
    -0.47842082f, 0.00386447f, 0.12944908f, -0.13998826f, -0.08788814f, 0.01304402f, 0.02538362f, -0.04469326f, 
    0.10959162f, 0.08665825f, 0.04223295f, 0.03996707f, -0.04460673f, 0.16986760f, -0.13107601f, -0.03935177f, 
    0.16358475f, -0.15499076f, -0.05578304f, 0.15357894f, -0.06393093f, 0.01465279f, 0.20106861f, 0.01025327f, 
    0.20578820f, -0.04475254f, -0.12503360f, -0.13372561f, 0.01723601f, -0.04079362f, 0.03641715f, -0.05581480f, 
    -0.03725793f, -0.04863991f, 0.01760045f, -0.03411300f, -0.19754881f, -0.23561393f, -0.27803025f, -0.02998343f, 
    -0.04775392f, 0.04094908f, 0.01689228f, 0.03432626f, -0.03681953f, -0.08500325f, 0.09436774f, 0.13304290f, 
    -0.16388169f, 0.17310554f, -0.01689813f, 0.12442175f, 0.08736427f, 0.06188468f, -0.01470991f, 0.12883824f, 
    -0.01314727f, 0.04008267f, 0.15457909f, -0.00814790f, -0.13701101f, -0.05348104f, -0.20176020f, 0.09079909f, 
    0.12666115f, -0.06838514f, -0.17928410f, -0.06984422f, 0.04248609f, 0.04689768f, 0.04992609f, -0.00839903f, 
    0.49806875f, -0.06607011f, -0.17240396f, -0.04260450f, 0.05456178f, 0.15035829f, 0.02219959f, -0.02794704f, 
    0.00502269f, 0.07597029f, 0.06933113f, -0.12762773f, -0.07679515f, -0.33751887f, 0.11169482f, -0.08475912f, 
    0.03300747f, 0.04427504f, 0.05774954f, 0.06739649f, 0.00072993f, 0.01100921f, -0.13162045f, 0.02341253f, 
    0.30737013f, 0.03575775f, -0.03083849f, -0.03802213f, -0.06790079f, 0.10278644f, -0.02728820f, -0.00748787f, 
    -0.02692952f, 0.03972336f, 0.15305656f, 0.02901773f, 0.12276651f, 0.14806280f, -0.07513988f, -0.15413027f, 
    -0.03964926f, -0.00243802f, 0.06431647f, -0.05831045f, 0.09749946f, 0.17026772f, 0.06087927f, 0.01117111f, 
    0.19059713f, 0.05456692f, 0.07158833f, 0.08401067f, 0.10037554f, 0.11449879f, 0.01444083f, 0.08707267f, 
    -0.00742417f, -0.03428442f, 0.06306204f, -0.01442469f, -0.05240219f, -0.11751459f, -0.09121384f, -0.17408580f, 
    0.04569612f, 0.04776261f, 0.05747836f, 0.03069714f, -0.14092574f, 0.09597223f, -0.04941545f, -0.02719556f, 
    0.13754213f, 0.17781284f, -0.26232755f, 0.06962050f, 0.00422872f, 0.00952993f, -0.04909826f, 0.01842644f, 
    -0.02419016f, 0.08052016f, -0.01250423f, -0.04567442f, 0.36344039f, 0.29520041f, 0.20971516f, 0.01409556f, 
    0.04947807f, -0.11555288f, 0.12906168f, 0.06171564f, -0.08416132f, -0.11668715f, 0.05536522f, 0.13101368f, 
    -0.20957200f, 0.01076531f, 0.06693780f, 0.02894740f, 0.09061120f, -0.09228933f, 0.03641862f, -0.02699536f, 
    0.14773291f, 0.00626592f, -0.08144726f, -0.02329761f, -0.01645268f, 0.12475134f, 0.00834539f, -0.15094972f, 
    -0.08852725f, 0.02995783f, 0.06419141f, 0.10340963f, 0.03496218f, -0.05530156f, -0.12990111f, -0.02346640f, 
    -0.11157330f, -0.09211881f, 0.17478970f, -0.30642489f, -0.00137083f, -0.09980157f, -0.06747261f, 0.07997670f, 
    0.09945679f, -0.04496954f, 0.02550301f, 0.03434622f, -0.08241727f, -0.17175128f, 0.19441964f, 0.13713929f, 
    0.10402540f, -0.01321328f, -0.04373017f, 0.12388058f, -0.14648001f, 0.04312531f, -0.08553638f, -0.07993916f, 
    0.11131958f, -0.01282671f, 0.19645269f, -0.04020339f, -0.06037196f, 0.01917543f, -0.07447287f, 0.04119156f, 
    0.03769155f, -0.00885339f, 0.27167863f, -0.06645366f, 0.20950590f, -0.02936695f, -0.16444324f, -0.12029715f, 
    0.05484325f, -0.06367406f, -0.09433240f, -0.02038357f, 0.00452537f, -0.01947904f, -0.02795248f, 0.04293948f, 
    -0.06913762f, 0.04477207f, -0.01102518f, -0.21743861f, -0.06283589f, 0.01381300f, 0.03201595f, -0.00344310f, 
    -0.08861314f, -0.05481929f, 0.04636731f, -0.15317041f, 0.23974851f, -0.06387740f, -0.10094607f, -0.00863533f, 
    0.07201847f, -0.03037163f, 0.03399331f, 0.09003795f, -0.06124476f, -0.13206963f, 0.00920244f, -0.14483227f, 
    -0.04409152f, 0.11380153f, -0.06439512f, 0.24793819f, -0.04413986f, 0.00795160f, 0.01101273f, 0.11407854f, 
    -0.07829950f, 0.00438522f, 0.09054218f, -0.05958844f, 0.16406298f, -0.01740520f, -0.15517084f, -0.11327577f, 
    -0.02560004f, 0.02908508f, 0.00273479f, 0.05250071f, -0.05938821f, -0.00133805f, 0.05035537f, 0.22100148f, 
    -0.10668039f, 0.23752147f, 0.06067337f, 0.22783770f, -0.06707826f, 0.04042582f, 0.01714689f, 0.16781579f, 
    0.11086041f, 0.00695069f, -0.09150604f, -0.02998684f, -0.14873484f, 0.07624828f, -0.01707975f, -0.19579110f, 
    0.03333084f, -0.00208796f, 0.03484515f, -0.00931055f, -0.04539680f, -0.01343599f, 0.10050836f, -0.06605861f, 
    -0.27414733f, 0.10432815f, 0.03051760f, -0.07592759f, 0.06484945f, 0.01660088f, 0.06961542f, -0.00060539f, 
    0.03132351f, -0.06650534f, 0.03566680f, 0.08478248f, 0.12419119f, -0.13290355f, 0.04121931f, -0.22315569f, 
    -0.03832010f, -0.12806056f, -0.18510003f, 0.02789669f, -0.03372146f, 0.09881197f, 0.01046703f, 0.12819369f, 
    0.13437130f, 0.05126715f, -0.11724662f, -0.07557796f, 0.01382685f, 0.13345885f, 0.16123766f, 0.08028124f, 
    0.09921360f, -0.08307503f, -0.08091132f, 0.04532058f, -0.39390433f, 0.29296538f, -0.04736498f, 0.06237423f, 
    0.17017139f, -0.09763237f, -0.06806502f, -0.18116874f, -0.09180713f, -0.13145384f, 0.10253450f, 0.09799466f, 
    -0.11697683f, -0.16856970f, 0.01042672f, 0.01155837f, -0.12315373f, -0.09305755f, 0.01235952f, 0.02289815f, 
    -0.00321221f, -0.07043696f, 0.06941677f, 0.21407612f, 0.12570545f, -0.28389037f, 0.00908595f, 0.05691596f, 
    -0.02169767f, 0.00037914f, -0.09066970f, -0.01645098f, -0.01035536f, 0.01058099f, -0.07741969f, -0.05809229f, 
    0.01537856f, -0.09611425f, -0.03681312f, 0.25847673f, -0.09370848f, 0.01984805f, 0.00687303f, -0.04063549f, 
    0.10689551f, 0.00486147f, 0.03350753f, 0.06460608f, -0.04073479f, 0.23401992f, -0.04671269f, -0.26411340f, 
    0.06784694f, -0.16705593f, -0.04460143f, 0.08510748f, 0.10975610f, -0.03369398f, 0.11400525f, -0.02870017f, 
    -0.15175880f, 0.39381865f, -0.02965396f, -0.32684368f, 0.14910203f, 0.05505046f, 0.00076434f, 0.01281511f, 
    -0.06089080f, -0.06425189f, 0.08751666f, -0.04400384f, -0.37973738f, -0.04255774f, -0.11595422f, 0.04728035f, 
    0.04377823f, 0.11882144f, -0.03710651f, 0.26179880f, -0.05465585f, 0.04347317f, 0.16639240f, 0.04668675f, 
    0.16612516f, 0.04514232f, 0.18232363f, -0.14924094f, 0.15043356f, -0.05667594f, 0.06357671f, 0.11772928f, 
    0.08810722f, 0.15957762f, 0.11101759f, 0.05699844f, -0.13267526f, 0.15232815f, -0.05610076f, -0.06684286f, 
    0.07466563f, -0.13653207f, 0.01938513f, -0.00327265f, -0.02742500f, 0.03356480f, 0.10280316f, 0.08105607f, 
    0.31427971f, -0.25270504f, -0.20424160f, 0.19156547f, -0.02512570f, 0.18128613f, 0.01278476f, -0.01771918f, 
    -0.10591614f, 0.09736020f, 0.00984487f, -0.13106613f, -0.04984159f, -0.37891051f, 0.01591435f, 0.25021619f, 
    0.16438943f, 0.02328372f, -0.07776392f, 0.05489849f, 0.05274309f, -0.10859004f, -0.01128694f, 0.00859783f, 
    0.27340427f, -0.09496436f, -0.03929257f, 0.26113284f, 0.02676021f, 0.01221235f, -0.06842802f, 0.07689989f, 
    -0.01699116f, 0.05983497f, 0.14335677f, -0.04960168f, -0.06101212f, 0.08235524f, -0.16848265f, -0.05729813f, 
    0.14123724f, 0.07337798f, 0.06209725f, -0.04256014f, 0.09578639f, 0.08875980f, 0.11231409f, -0.02318092f, 
    -0.14877531f, 0.34613132f, 0.02168083f, 0.05151023f, 0.17369547f, -0.00458729f, 0.03168735f, 0.05343172f, 
    -0.02858916f, -0.01131132f, -0.07351178f, 0.11648159f, -0.25979871f, 0.21830185f, -0.13617952f, -0.18717475f, 
    -0.10103564f, 0.07211958f, 0.07691803f, 0.00121965f, -0.02596014f, 0.18070252f, -0.07657554f, 0.04340716f, 
    0.02503941f, -0.01629086f, 0.00955601f, 0.01421916f, -0.06621829f, -0.08045240f, 0.11682122f, -0.16672201f, 
    -0.07075861f, 0.15105443f, 0.01605783f, 0.01233048f, 0.05396951f, 0.13314240f, 0.04439338f, 0.14134261f, 
    0.21120414f, -0.07171129f, -0.01447404f, -0.07087854f, 0.05276170f, 0.00258736f, -0.00086921f, 0.01085888f, 
    -0.06046634f, -0.13544376f, 0.01073785f, 0.17656766f, 0.00512633f, -0.04735291f, 0.07356051f, -0.01860951f, 
    0.11812533f, -0.02960345f, -0.06287336f, 0.02259559f, 0.01641654f, 0.14183064f, -0.09871648f, -0.06150912f, 
    -0.01593880f, 0.03078844f, -0.00954986f, 0.14119717f, 0.07835300f, -0.14835604f, -0.04334913f, -0.07321731f, 
    -0.18678400f, 0.29796433f, 0.27686664f, 0.13219081f, -0.10336068f, 0.14911166f, 0.01745200f, 0.01575347f, 
    0.12683302f, -0.03056878f, -0.07511441f, 0.07010870f, 0.03836709f, -0.06758821f, 0.20166954f, 0.05309042f, 
    0.08126251f, 0.04245576f, 0.09033493f, 0.00144002f, -0.09659271f, -0.02397231f, 0.00274778f, 0.09112824f, 
    0.21058418f, 0.06423189f, -0.05339982f, 0.04152510f, 0.00132194f, 0.08428005f, -0.13721767f, -0.05161998f, 
    0.03002701f, -0.02231486f, 0.19569215f, 0.06133441f, -0.00689944f, 0.10273078f, -0.02115044f, -0.10107911f, 
    0.17088938f, -0.04415312f, -0.03892998f, 0.02970812f, 0.04289889f, 0.14794309f, 0.04306875f, 0.08835748f, 
    -0.02208368f, 0.18065362f, -0.13966848f, -0.05956651f, 0.03111005f, 0.02055175f, -0.01619512f, -0.01469796f, 
    -0.03604309f, -0.00428104f, 0.01323657f, -0.13492078f, 0.21231318f, 0.01515779f, -0.06159294f, 0.02432077f, 
    0.05904132f, -0.04975835f, -0.09549541f, -0.07540559f, 0.00691289f, -0.17847928f, 0.17415586f, 0.02724075f, 
    -0.05322402f, -0.00167915f, -0.03967102f, -0.05701977f, 0.03599741f, 0.00456514f, 0.02203833f, -0.04624791f, 
    -0.05375225f, 0.00075507f, 0.04455684f, -0.04019725f, 0.01358092f, -0.00689452f, 0.03607138f, 0.01371816f, 
    -0.04197057f, -0.01971676f, 0.00581728f, 0.04164307f, -0.03096578f, -0.04074085f, 0.01293044f, -0.02926965f, 
    0.02480757f, -0.03838409f, 0.00589678f, 0.03467968f, -0.02446632f, 0.01787227f, -0.00850159f, -0.04352629f, 
    0.02233201f, 0.02311658f, 0.00966627f, -0.04666469f, -0.00109824f, 0.02441498f, 0.02328742f, -0.01902412f, 
    -0.01934609f, 0.03672986f, 0.01026306f, -0.05694145f, 0.01875733f, -0.00509190f, -0.03238067f, -0.03127973f, 
    -0.00830415f, -0.03557882f, 0.02251855f, -0.01718475f, 0.02400629f, -0.00899505f, -0.04644389f, 0.01494387f, 
    0.00343533f, 0.00533317f, -0.04855376f, 0.03428636f, 0.02218829f, -0.04388557f, -0.05349119f, 0.01719971f, 
    0.01275777f, -0.05639470f, -0.03338437f, 0.04094637f, 0.00665701f, -0.03434086f, 0.03499670f, 0.03252744f, 
    -0.03575572f, -0.00578217f, -0.04377959f, 0.00369582f, -0.03424855f, 0.03782009f, -0.04761570f, 0.04172184f, 
    0.01001272f, -0.04997499f, 0.01966344f, 0.01230454f, -0.02169769f, 0.03584510f, -0.00766662f, -0.01330821f, 
    -0.00694874f, 0.04433207f, -0.02966843f, 0.03661189f, -0.05596340f, 0.03443038f, -0.04277209f, -0.00030737f, 
    0.03000266f, -0.03000287f, 0.02118128f, 0.03312660f, -0.00010802f, -0.03570558f, 0.00433233f, 0.03579255f, 
    0.01640557f, -0.02632188f, 0.02361835f, -0.04953437f, -0.00409740f, 0.01224589f, -0.03069179f, 0.02609905f, 
    0.01104765f, -0.04275573f, -0.05132413f, -0.04223154f, -0.04347377f, -0.00873301f, 0.03978330f, -0.05369988f, 
    0.01106617f, -0.00876818f, 0.03225344f, -0.02928478f, -0.02632998f, -0.04502669f, -0.05488338f, -0.01219482f, 
    0.00980785f, 0.02410033f, -0.00491241f, -0.02311315f, 0.01774200f, -0.00519032f, 0.00083164f, 0.00619995f, 
    -0.04447755f, -0.02122356f, -0.03372640f, 0.00198451f, 0.03696670f, -0.04052244f, -0.00900522f, -0.00820766f, 
    0.01784074f, -0.04118223f, -0.03158288f, -0.04700270f, -0.03766518f, 0.00059258f, -0.03755736f, 0.00473845f, 
    0.01471107f, -0.02475367f, 0.02128311f, -0.01639496f, 0.02825073f, -0.00337819f, -0.02595351f, -0.01581054f, 
    0.03328918f, -0.03571961f, -0.05044758f, -0.04014088f, -0.00284645f, -0.04582592f, -0.01397929f, 0.00351125f, 
    -0.00646410f, -0.04839686f, 0.03913993f, -0.02404993f, 0.00532023f, 0.02140191f, -0.00216419f, -0.03248753f, 
    -0.05445099f, -0.04066135f, -0.04605082f, -0.01237639f, -0.01140669f, -0.01711550f, -0.02817936f, 0.03126166f, 
    -0.04280011f, 0.00876667f, 0.02252923f, 0.00870030f, 0.01462570f, 0.04028013f, 0.03436315f, 0.02281181f, 
    -0.03977102f, 0.01296225f, -0.05230082f, -0.00768765f, 0.03678929f, -0.03884558f, -0.02958375f, 0.02024765f, 
    0.04154143f, -0.00343127f, 0.03612429f, -0.03337415f, -0.02962276f, -0.03351442f, 0.02995798f, 0.00373699f, 
    -0.03338920f, 0.03922057f, 0.01296071f, -0.04556026f, 0.03892769f, 0.01060504f, 0.01632011f, -0.04447756f, 
    -0.03426409f, 0.04314274f, 0.04073125f, -0.01171800f, -0.04075519f, 0.01106404f, 0.00670201f, -0.04349010f, 
    0.02535123f, -0.03173045f, -0.03067927f, -0.00182100f, 0.03120388f, -0.03027640f, -0.03080359f, 0.00785758f, 
    -0.04718668f, 0.03711564f, -0.00473372f, -0.04599978f, 0.00532993f, -0.04916807f, -0.05200808f, 0.00302854f, 
    0.01189215f, -0.01757844f, 0.03585923f, 0.00957811f, 0.00650328f, -0.03358560f, 0.03100284f, 0.00207729f, 
    -0.00363732f, 0.00190318f, 0.03632600f, -0.03854719f, -0.04548759f, -0.01231148f, -0.00039977f, 0.02906493f, 
    0.02049748f, -0.03443030f, 0.00012426f, -0.01042361f, -0.04065618f, -0.05091529f, -0.05538122f, 0.00300631f, 
    -0.02406576f, -0.00604328f, -0.02630067f, 0.00662777f, 0.01497004f, 0.00605633f, 0.01005939f, 0.04465196f, 
    -0.04077684f, -0.05162491f, -0.03975093f, 0.03212865f, 0.00458920f, 0.02260222f, -0.05421416f, 0.01894884f, 
    -0.01702062f, -0.02319617f, 0.02074688f, -0.05471941f, -0.04416876f, 0.02977967f, 0.01554608f, -0.02925872f, 
    -0.04027534f, -0.03740269f, 0.02637197f, 0.04136596f, 0.00382582f, 0.04368202f, -0.05001427f, -0.05375364f, 
    -0.03675588f, 0.04236222f, -0.04873662f, -0.04464375f, 0.00797757f, 0.04462059f, -0.00089466f, -0.04405412f, 
    0.03568506f, -0.01932569f, -0.02865185f, -0.04973629f, -0.04119854f, 0.04249529f, -0.01365708f, -0.05453135f, 
    0.01848234f, -0.01838867f, -0.00250603f, -0.01164728f, -0.05372545f, -0.04550972f, -0.01350702f, 0.02889899f, 
    -0.03532550f, 0.02057919f, 0.01000591f, 0.03443506f, 0.00162995f, -0.00774037f, -0.02809170f, -0.03336627f, 
    0.01680214f, 0.03285686f, 0.02702475f, -0.03607972f, -0.04277546f, -0.05044419f, 0.02929071f, -0.01856892f, 
    0.02513322f, 0.02635759f, -0.01777288f, -0.01090975f, 0.01440966f, -0.02302548f, 0.03387734f, 0.02050544f, 
    -0.04595860f, -0.04011722f, -0.02381134f, -0.01601472f, -0.03636460f, -0.00145623f, 0.01883839f, 0.04382942f, 
    0.04324459f, 0.04421372f, -0.01157552f, 0.00886106f, -0.02837685f, -0.00851536f, -0.00008798f, 0.00005962f, 
    -0.05378219f, -0.02145778f, -0.00620303f, -0.03455355f, 0.00568468f, 0.03066857f, 0.00747619f, -0.02015374f, 
    0.04051349f, -0.01573811f, -0.01960019f, -0.01189672f, -0.00731218f, 0.04462027f, -0.01200468f, -0.02304658f, 
    0.02010990f, -0.01330852f, -0.05395088f, -0.03865351f, -0.04426970f, -0.00334105f, -0.05402390f, -0.02197601f, 
    -0.01134272f, 0.00391235f, 0.00624323f, -0.03615552f, 0.01551457f, -0.05381272f, 0.08307745f, -0.14447923f, 
    0.02746880f, 0.05169823f, -0.09199978f, 0.01481371f, 0.25713354f, -0.16603194f, 0.07792486f, 0.02514998f, 
    0.02838442f, -0.00850712f, -0.05957567f, 0.01987372f, -0.05976247f, -0.01486453f, 0.03691265f, -0.00434836f, 
    0.12002496f, -0.02285730f, 0.16874100f, -0.10519838f, 0.04458901f, -0.10074209f, -0.00545869f, -0.04698861f, 
    -0.10280931f, -0.04454004f, 0.09276402f, -0.01631910f, -0.01573879f, 0.02915956f, 0.00495224f, -0.08657984f, 
    0.08843246f, 0.02579999f, -0.02539060f, 0.06273583f, -0.01977576f, -0.09238297f, -0.15176414f, 0.10703896f, 
    0.02390550f, -0.00575844f, -0.10837436f, 0.10674047f, -0.23145323f, -0.10953804f, -0.11328524f, 0.10072546f, 
    -0.09016220f, 0.00918242f, -0.10208877f, -0.08209518f, -0.30767787f, 0.07429592f, 0.02989043f, -0.17451753f, 
    -0.04295676f, 0.11957205f, 0.05463731f, -0.05554635f, -0.04932873f, 0.14435376f, 0.10385084f, -0.02963423f, 
    -0.19317982f, 0.14313023f, -0.21487522f, -0.10103930f, -0.12932001f, -0.06203575f, 0.05267724f, 0.05450720f, 
    -0.11488148f, 0.12515280f, 0.26682150f, -0.03743018f, 0.19367015f, 0.05661669f, 0.10930374f, -0.01456989f, 
    0.15982291f, -0.07566155f, 0.06127337f, 0.05949361f, 0.01733200f, 0.11653678f, 0.00415065f, 0.02315297f, 
    0.04559728f, -0.08598229f, -0.23368661f, -0.02444321f, 0.12780139f, 0.00100410f, 0.05116554f, 0.00937508f, 
    0.01247943f, 0.02383782f, 0.05219065f, -0.04502850f, -0.16050115f, 0.17319319f, -0.13119714f, -0.00634419f, 
    0.11195295f, 0.04177881f, -0.01071681f, 0.11269772f, 0.01112778f, -0.05679351f, -0.04183285f, -0.06845208f, 
    -0.26824784f, -0.06010327f, 0.16508348f, -0.02170788f, -0.03643613f, -0.12429251f, -0.03467156f, 0.05677436f, 
    -0.04056956f, 0.00655381f, 0.11438403f, 0.00913107f, -0.00427912f, 0.05298018f, 0.11386029f, 0.01086267f, 
    0.08596101f, 0.13229851f, -0.01041941f, 0.06338943f, -0.11289799f, -0.05722440f, 0.04177319f, 0.03176992f, 
    0.30480018f, 0.11774009f, 0.12950297f, 0.00144390f, 0.09349561f, 0.09373898f, -0.02700011f, -0.05413203f, 
    -0.04584652f, 0.07642196f, -0.05603142f, 0.03866266f, 0.10250156f, 0.06007025f, 0.23951165f, 0.11918004f, 
    -0.09487080f, 0.06704868f, 0.04483645f, -0.03115374f, -0.10705506f, 0.01550174f, -0.10555999f, 0.10776667f, 
    -0.09143861f, 0.09567255f, -0.14097624f, 0.00341023f, 0.08785386f, 0.00062927f, -0.02801119f, 0.04759326f, 
    0.05350743f, 0.01054391f, -0.03802470f, 0.01590330f, 0.24699935f, 0.15363026f, 0.06740456f, -0.17995699f, 
    0.12200516f, 0.09290833f, 0.02514431f, -0.14877497f, 0.10939950f, -0.07072457f, -0.05788858f, 0.04817007f, 
    -0.18500304f, -0.01550946f, 0.06045937f, -0.12015607f, 0.12687959f, -0.04118785f, 0.01319967f, 0.03397444f, 
    -0.01972049f, 0.08038824f, 0.08548661f, -0.09390648f, -0.00729642f, -0.04001709f, 0.11155047f, 0.22406749f, 
    -0.01868049f, 0.05163261f, 0.18998960f, -0.17098391f, 0.08435515f, 0.01828031f, -0.08941856f, 0.00243168f, 
    0.04992381f, -0.23558016f, 0.00083940f, -0.01434167f, -0.07344821f, -0.01978106f, 0.09063964f, 0.06671871f, 
    -0.05983961f, -0.01309279f, -0.09468272f, -0.04134950f, -0.07490353f, 0.12742935f, 0.05425096f, 0.09342995f, 
    -0.01495286f, -0.04592877f, 0.05865060f, 0.01408966f, -0.12214934f, 0.01106119f, -0.03518560f, 0.08356014f, 
    0.39635327f, 0.12608287f, 0.15137261f, 0.08058275f, 0.05011532f, -0.00409614f, 0.04347350f, 0.00720641f, 
    -0.06187675f, -0.12934501f, -0.01737995f, -0.08801012f, -0.07522280f, -0.06716121f, -0.13385893f, 0.00865931f, 
    0.02771101f, 0.01072787f, 0.00335486f, -0.06570719f, 0.02100240f, 0.07785126f, 0.17721938f, 0.03035404f, 
    -0.30255955f, 0.10629866f, -0.24439561f, 0.00347357f, 0.07996672f, -0.03677387f, 0.00728631f, 0.13904342f, 
    0.17990582f, -0.00040205f, -0.02725147f, -0.04475427f, 0.44105068f, 0.14921355f, 0.07150681f, -0.07289150f, 
    -0.04928101f, 0.08579984f, 0.09750698f, 0.10606997f, -0.05049815f, -0.10983204f, 0.05277943f, -0.07764272f, 
    -0.03102246f, 0.08465430f, 0.02882915f, -0.18582967f, 0.12012950f, 0.14797683f, -0.10140925f, 0.02128167f, 
    -0.00298927f, 0.06096500f, 0.05286606f, 0.08817424f, 0.00952192f, -0.07132833f, 0.03405580f, 0.10593519f, 
    0.06034047f, 0.08748984f, 0.10349181f, -0.06927509f, 0.06422283f, 0.09644369f, 0.18962169f, 0.10088436f, 
    0.20935309f, 0.16796619f, -0.17722510f, -0.02867707f, 0.20462766f, -0.02681496f, 0.05213745f, -0.02288090f, 
    -0.13187508f, 0.02352337f, -0.02042356f, -0.00564095f, -0.11454074f, 0.06799655f, -0.12189259f, 0.08568594f, 
    0.15066855f, 0.04619251f, -0.11732473f, 0.15644994f, 0.12665065f, -0.02173822f, 0.03500470f, 0.01086525f, 
    -0.25144392f, -0.20668457f, 0.08409065f, 0.10772029f, -0.05434841f, -0.09056322f, -0.07368702f, 0.09066275f, 
    -0.00406501f, -0.05141186f, 0.00095821f, -0.04800602f, 0.26085967f, -0.04235707f, 0.04368970f, -0.04838395f, 
    -0.01438268f, 0.01582365f, 0.00959271f, -0.05753357f, -0.06368092f, -0.05678988f, 0.05434343f, 0.02369152f, 
    0.07969734f, -0.14362967f, -0.00690804f, 0.09633223f, 0.03866367f, 0.00579901f, -0.07698508f, -0.07009669f, 
    0.01903640f, 0.13797621f, -0.01870251f, -0.00477813f, -0.18374749f, -0.21049777f, 0.08024379f, 0.07549855f, 
    0.10733289f, 0.06951438f, -0.05950826f, 0.03332017f, 0.18785831f, 0.09314719f, -0.11190182f, -0.08201726f, 
    0.22812264f, -0.05586325f, 0.08378464f, 0.35958651f, -0.17092432f, -0.05039234f, -0.00940032f, -0.08568878f, 
    -0.01955279f, 0.14747283f, 0.05357012f, -0.05443498f, -0.42232245f, 0.09084051f, 0.16430190f, 0.01657137f, 
    -0.13431117f, 0.01532289f, 0.10135692f, 0.02082088f, -0.12227438f, 0.10714535f, -0.15474375f, 0.00470973f, 
    -0.26661035f, -0.14902525f, 0.01857408f, 0.10296080f, -0.12116743f, 0.10222943f, 0.03361696f, -0.06067392f, 
    0.02459726f, 0.01257685f, -0.02938426f, -0.07132460f, -0.16720013f, 0.00578521f, -0.17184232f, -0.22901243f, 
    0.04009708f, -0.01530108f, 0.02633456f, 0.02946579f, 0.08055973f, -0.01701028f, 0.19372447f, -0.02101283f, 
    0.20207052f, 0.03220033f, 0.01611907f, 0.00655296f, -0.09498916f, -0.12758657f, -0.06907877f, -0.06103002f, 
    -0.05061118f, 0.06470256f, 0.00602894f, 0.26545295f, -0.15330468f, 0.27174836f, -0.06475203f, -0.28651899f, 
    0.00476443f, 0.05025731f, 0.07559257f, 0.09177551f, 0.02285671f, -0.09889931f, 0.01805024f, 0.10830068f, 
    0.18460937f, 0.01187568f, 0.17589393f, 0.01573617f, 0.17373507f, -0.04385340f, -0.01532273f, 0.02378252f, 
    -0.05934479f, -0.05613694f, 0.02844260f, 0.10599317f, 0.00214018f, -0.09854946f, -0.10434456f, -0.03048998f, 
    0.02756174f, -0.12067568f, 0.03692671f, -0.07103296f, -0.02605903f, -0.04031750f, -0.06892086f, 0.03928236f, 
    0.04353252f, 0.05783504f, -0.01383033f, 0.20094520f, 0.04390730f, -0.02200709f, 0.07103536f, 0.04142013f, 
    0.08112017f, -0.12325642f, 0.09683263f, -0.01915917f, 0.05624269f, 0.00359551f, 0.04382129f, 0.29828298f, 
    -0.01631542f, -0.10931482f, 0.14411052f, -0.00239463f, -0.13979372f, -0.02206140f, 0.06132729f, -0.02272067f, 
    0.18052644f, -0.08506604f, -0.01410630f, 0.42751062f, 0.03143103f, -0.03374050f, -0.01672187f, -0.06215065f, 
    0.14037314f, 0.00841010f, -0.01805776f, -0.00407147f, -0.14350450f, 0.11792657f, 0.03561388f, 0.11231080f, 
    0.13630080f, -0.00021954f, -0.04180756f, -0.02040462f, 0.02628778f, -0.12092080f, 0.03452790f, 0.06055295f, 
    -0.22091828f, -0.07862583f, 0.02559495f, 0.00083554f, 0.12044105f, 0.06572986f, 0.01299180f, 0.07124957f, 
    -0.03415620f, -0.00278143f, 0.26806486f, 0.11408265f, 0.13121772f, 0.12116596f, 0.23533046f, 0.02219115f, 
    0.02142345f, 0.03909604f, -0.07570002f, -0.04539412f, -0.03800865f, 0.03721069f, 0.13204148f, -0.02728236f, 
    0.03615751f, 0.11355771f, -0.12005092f, -0.19385688f, -0.01333361f, -0.04211105f, 0.05276056f, 0.07581145f, 
    -0.09366862f, -0.01345254f, 0.04416785f, 0.05212956f, -0.32060310f, -0.12545703f, -0.11178611f, -0.03379042f, 
    0.22031392f, -0.05084469f, 0.11520672f, 0.02298998f, 0.02280017f, 0.09576341f, -0.00355195f, -0.12262084f, 
    -0.33843705f, 0.02067957f, -0.09427002f, 0.01578348f, -0.01483014f, 0.00488395f, 0.07346975f, -0.03478369f, 
    -0.04964029f, 0.10089923f, 0.06917148f, -0.04126169f, 0.07312340f, 0.05214929f, -0.13403101f, 0.12446330f, 
    0.16869001f, -0.02412025f, -0.02359622f, -0.03620423f, -0.10588941f, 0.05512917f, 0.11771767f, -0.11655468f, 
    0.03088984f, -0.14888552f, 0.14284597f, 0.30233848f, -0.00478569f, -0.01888156f, 0.04513245f, 0.04269706f, 
    0.07563086f, 0.07903703f, 0.05819052f, -0.00216781f, -0.07385358f, -0.15271091f, 0.12875775f, 0.15937027f, 
    -0.09506141f, -0.00536259f, -0.13434683f, -0.02364247f, 0.04562765f, -0.07899491f, -0.03407368f, -0.02954951f, 
    -0.40509444f, -0.33991581f, -0.19370992f, -0.10712735f, 0.09244046f, 0.01626623f, -0.00723402f, -0.07410277f, 
    0.19246204f, 0.05061994f, -0.14946231f, -0.01722424f, 0.00577099f, 0.19295783f, -0.02483227f, 0.24169978f, 
    -0.00653967f, -0.00624853f, 0.03573070f, 0.08607649f, 0.16027850f, 0.03045532f, 0.09110289f, 0.05261049f, 
    -0.13986483f, 0.10882718f, -0.03245917f, 0.12348101f, 0.09340676f, 0.04977746f, 0.06854704f, 0.15886810f, 
    -0.00066998f, -0.00684765f, -0.03909482f, -0.04380251f, -0.03355177f, -0.37541217f, -0.05120832f, -0.07384502f, 
    -0.10142535f, 0.11895602f, 0.03911377f, -0.11857987f, 0.21535218f, 0.18934141f, -0.02970559f, 0.05574657f, 
    0.09837835f, -0.17561799f, 0.07868133f, 0.04139427f, -0.14709742f, 0.14278588f, 0.06318031f, -0.01972065f, 
    0.00105784f, -0.02233849f, -0.02476680f, 0.11454396f, 0.12982880f, -0.20284621f, 0.11944710f, 0.21926042f, 
    0.06102109f, 0.12019605f, -0.01149016f, -0.09793352f, -0.05486606f, 0.07180105f, 0.07826251f, -0.07676902f, 
    0.00211415f, -0.06510434f, -0.04565113f, 0.23552299f, -0.05806514f, 0.10631657f, 0.09813873f, 0.03523802f, 
    -0.07998113f, 0.04157382f, 0.01517701f, 0.00211733f, 0.11996456f, -0.04015746f, -0.18655111f, 0.05467425f, 
    -0.04107562f, -0.09270201f, 0.00050941f, 0.14375196f, 0.03652282f, 0.05415245f, 0.00845527f, 0.07551537f, 
    0.13246253f, 0.13693288f, 0.01284296f, 0.10072143f, 0.05828695f, -0.02462862f, 0.02518125f, -0.02124990f, 
    0.02326188f, 0.06602382f, -0.06353397f, 0.11743817f, -0.16442715f, 0.07339730f, -0.01798120f, 0.15415870f, 
    0.04275161f, -0.10613064f, 0.03237088f, 0.07736035f, 0.10663149f, 0.00734583f, -0.02522719f, 0.10358603f, 
    0.28252673f, 0.05467211f, -0.02306456f, 0.24301557f, 0.02378298f, 0.03476733f, -0.10116082f, 0.06053755f, 
    0.03842266f, 0.08431026f, 0.03675131f, 0.03304069f, -0.09513781f, 0.07184242f, 0.14128235f, 0.18965632f, 
    0.13781559f, -0.00201128f, 0.01499249f, 0.06035705f, 0.06840327f, -0.02065517f, 0.12945943f, -0.01404092f, 
    0.00339482f, -0.00529105f, -0.02989988f, -0.04081737f, 0.02330751f, 0.01108449f, -0.02369081f, -0.02856206f, 
    -0.02955507f, 0.03913408f, -0.05409837f, 0.02081552f, 0.01361423f, -0.04806384f, -0.01222228f, -0.02429940f, 
    0.01530435f, -0.01179972f, -0.04965351f, -0.01367224f, -0.03688604f, -0.00932516f, 0.04136241f, 0.01535501f, 
    -0.05035397f, 0.03125053f, -0.00211141f, -0.00379896f, -0.02756189f, -0.01060582f, 0.04044914f, -0.02309671f, 
    -0.05370064f, 0.01438342f, -0.01574429f, -0.05262304f, 0.01124827f, 0.03658734f, -0.00682593f, -0.00915305f, 
    0.01483780f, 0.04109221f, 0.04060264f, -0.00443979f, -0.05133892f, -0.04063131f, 0.01662173f, -0.05252529f, 
    -0.01820841f, 0.02568887f, -0.00375392f, 0.02587084f, -0.05159537f, 0.02587789f, -0.03321819f, -0.05480019f, 
    -0.05154375f, -0.03474967f, 0.03282739f, 0.01354893f, 0.00093937f, -0.01594343f, -0.03820648f, -0.00608823f, 
    -0.03694488f, 0.02535041f, 0.02158283f, 0.02884980f, 0.03071418f, 0.00548295f, -0.02187534f, 0.01462796f, 
    -0.04656142f, -0.01923956f, 0.01759159f, -0.02721013f, 0.03646153f, -0.00101509f, 0.02807949f, -0.00133504f, 
    -0.03780588f, 0.01708456f, 0.01560043f, -0.03933618f, 0.01962485f, -0.01139179f, 0.01172299f, -0.04640181f, 
    -0.03821637f, -0.01032006f, 0.01289350f, -0.05611520f, 0.00128936f, -0.03083926f, -0.03368730f, 0.00061280f, 
    0.04292923f, -0.05383078f, -0.00499146f, -0.01238382f, 0.03323151f, -0.04264050f, 0.00156441f, -0.02064648f, 
    -0.04931102f, -0.00456487f, 0.02290733f, -0.01430905f, 0.04240374f, -0.03604729f, -0.01827072f, -0.03086132f, 
    0.02153070f, 0.01238901f, 0.00861522f, -0.00901785f, -0.03200879f, 0.03510009f, -0.02740231f, 0.04005950f, 
    -0.02676900f, -0.02844564f, 0.03492923f, -0.01892636f, 0.03644047f, 0.01917429f, 0.02306650f, 0.02480324f, 
    0.04185836f, -0.01875352f, 0.03537950f, -0.04372855f, 0.04212000f, -0.02780106f, -0.01860920f, 0.00921061f, 
    -0.05128656f, -0.03850759f, 0.00883785f, 0.00058786f, -0.04129796f, 0.00006323f, -0.02831731f, 0.03090403f, 
    0.02231522f, -0.03817204f, -0.03401499f, -0.02486895f, 0.02176106f, 0.04576609f, 0.02057719f, 0.03439920f, 
    -0.04683875f, -0.04176198f, -0.01590520f, -0.00215499f, 0.01128416f, -0.00290580f, -0.03297605f, -0.04019077f, 
    0.04024750f, -0.05018298f, -0.02422832f, -0.00345415f, 0.01203551f, 0.01845664f, -0.00431612f, -0.00897915f, 
    0.00093047f, 0.00643738f, -0.01849979f, 0.01606083f, 0.02944659f, -0.02577338f, 0.03548283f, -0.00768560f, 
    0.00541278f, -0.00560246f, 0.01147138f, -0.04815111f, -0.00722787f, -0.05228041f, -0.05047521f, -0.03339906f, 
    0.00116016f, 0.01063804f, -0.00691690f, -0.03564638f, -0.01644194f, 0.01927116f, 0.02750213f, -0.05245671f, 
    0.02685966f, 0.02674139f, 0.04545118f, -0.02754343f, -0.00040215f, -0.03075748f, 0.02059120f, -0.02133037f, 
    -0.01345935f, 0.03666300f, -0.03388796f, -0.00136812f, 0.01072196f, 0.01150173f, -0.00020798f, -0.01056899f, 
    0.00072210f, -0.05309307f, 0.02653526f, 0.02814917f, 0.00351381f, -0.03351046f, 0.04218297f, -0.05041354f, 
    -0.04162194f, 0.02478640f, -0.03960454f, -0.04432421f, 0.02727943f, -0.04467862f, -0.00768902f, 0.00464416f, 
    0.01539572f, 0.04236673f, -0.04318723f, -0.05100531f, -0.03173751f, -0.01808115f, 0.04038545f, 0.00922824f, 
    -0.05402755f, 0.03946010f, -0.03019091f, -0.00410091f, -0.04922129f, 0.03416878f, 0.01125712f, 0.04454608f, 
    -0.05059186f, -0.01119832f, -0.00379882f, -0.01661361f, 0.02525937f, -0.02957574f, -0.01446726f, -0.02249521f, 
    -0.03863540f, -0.01962095f, -0.03763171f, -0.01625112f, 0.04546423f, 0.03382046f, -0.01695003f, -0.01975881f, 
    -0.02581257f, -0.00222869f, 0.04806599f, -0.04429840f, -0.02003327f, -0.01719679f, -0.02722655f, -0.05087811f, 
    -0.01878186f, 0.01209386f, -0.02590452f, 0.01017321f, -0.02715639f, 0.04124366f, -0.02913073f, -0.04306825f, 
    -0.04461940f, -0.04731052f, -0.01008102f, 0.00492142f, -0.01739842f, -0.01558903f, 0.03331111f, 0.03469767f, 
    -0.03817140f, -0.02631805f, -0.02051035f, -0.00390237f, -0.02818396f, -0.00129803f, -0.01058070f, -0.01414046f, 
    0.00805403f, -0.03556953f, -0.04674375f, -0.02859495f, -0.01612758f, -0.05141654f, -0.00145468f, -0.03228059f, 
    -0.00230903f, -0.03386315f, -0.01967506f, -0.02550975f, 0.01141712f, 0.00902908f, -0.01579253f, 0.01066272f, 
    0.02642147f, -0.05609883f, -0.02826779f, -0.02360829f, -0.02957188f, -0.05491960f, -0.03551090f, -0.05103190f, 
    0.02099017f, -0.01906206f, -0.02860939f, 0.00330692f, -0.05102083f, 0.00231287f, -0.00968422f, -0.01183876f, 
    0.01246456f, -0.00888484f, 0.03794089f, -0.00998765f, 0.00496690f, 0.03905287f, 0.00855849f, 0.03283252f, 
    0.03054816f, 0.01654670f, -0.01295440f, -0.00807765f, -0.04913542f, 0.02861601f, 0.02197661f, 0.04082811f, 
    -0.04783741f, -0.02423181f, -0.04304215f, 0.04157377f, -0.00892384f, 0.02959477f, -0.01882744f, -0.01933148f, 
    -0.00322714f, -0.04509106f, -0.03474027f, -0.00598266f, -0.03968591f, -0.00578342f, -0.03423758f, 0.02430016f, 
    -0.03382499f, -0.00613205f, 0.02634772f, 0.01789353f, 0.03677784f, 0.01280676f, -0.03056397f, 0.03627316f, 
    0.01558331f, -0.02104835f, -0.02548301f, -0.02385241f, -0.02877381f, -0.02323781f, -0.02985179f, 0.00152825f, 
    0.02585347f, 0.03487181f, -0.01113735f, -0.03347867f, 0.00383581f, -0.01737555f, 0.01922242f, -0.02860890f, 
    -0.00581692f, -0.02604882f, 0.02965464f, 0.04394744f, 0.03460107f, -0.01806025f, -0.00236950f, 0.01884656f, 
    0.13488442f, -0.08219804f, 0.08713180f, 0.22123852f, -0.09114423f, -0.01402985f, 0.17728414f, -0.16147377f, 
    -0.02897100f, 0.09601757f, 0.09929253f, -0.03458383f, -0.11165394f, -0.17389731f, 0.05742457f, -0.01056113f, 
    0.07351923f, -0.11860773f, -0.09176424f, 0.18684191f, 0.04954333f, 0.07432973f, 0.05202047f, 0.03471027f, 
    -0.38169393f, 0.22427663f, -0.15978003f, 0.09222382f, 0.02782727f, 0.10411714f, -0.04431615f, -0.08840066f, 
    0.04042081f, 0.10790654f, 0.01362784f, -0.01522734f, 0.00637311f, 0.01839380f, -0.02005875f, -0.33725739f, 
    0.10317858f, -0.10352340f, -0.06764901f, -0.12973104f, -0.14171945f, -0.13211638f, -0.01930944f, 0.03935226f, 
    -0.07816184f, 0.07580625f, 0.07887109f, 0.05360692f, -0.04860961f, -0.13609570f, -0.00832860f, 0.13397473f, 
    -0.03453985f, -0.06371262f, -0.00026391f, -0.04073982f, -0.26547953f, 0.26067126f, 0.18391968f, -0.13210960f, 
    0.03674741f, -0.02970879f, 0.07772262f, 0.00635339f, -0.09187066f, -0.05928562f, 0.07082007f, 0.02857322f, 
    -0.24643582f, 0.18158281f, 0.08748328f, -0.02453964f, 0.07985806f, -0.01361667f, 0.14405644f, -0.01638546f, 
    -0.09807802f, -0.00094218f, 0.22533895f, 0.07452367f, -0.33546501f, 0.21107024f, -0.09720002f, 0.01802682f, 
    0.10528358f, 0.10484029f, 0.07756465f, 0.09460372f, 0.07994184f, 0.11811221f, 0.11802853f, 0.15179162f, 
    -0.12483230f, -0.18858744f, -0.23093840f, -0.06964582f, 0.07960208f, 0.09106357f, 0.13752915f, 0.07511629f, 
    0.05769676f, -0.01458914f, 0.14397532f, 0.02577989f, -0.31733885f, 0.01189638f, -0.07416921f, -0.05563889f, 
    0.04008004f, 0.05135146f, 0.16095209f, -0.00029640f, -0.13032402f, -0.09483926f, -0.07066479f, 0.01443360f, 
    0.29240078f, -0.06158561f, 0.09349881f, 0.25424242f, -0.00855971f, -0.03179344f, -0.07340464f, 0.04056689f, 
    0.09365875f, -0.14748397f, -0.06410328f, 0.02079778f, 0.16683559f, 0.00795788f, -0.10663962f, -0.25783068f, 
    0.01928704f, -0.05972805f, 0.05385900f, 0.04299152f, -0.07368390f, -0.04391294f, -0.09522376f, 0.04438028f, 
    -0.05012126f, 0.29314676f, -0.02734045f, -0.13955189f, 0.15245521f, 0.02783587f, -0.04445857f, 0.03813522f, 
    -0.07149160f, -0.03231720f, -0.03064734f, -0.03314096f, -0.09901309f, 0.15368907f, 0.33615461f, 0.04180172f, 
    -0.05776232f, -0.03701755f, 0.03708143f, 0.05131534f, -0.06493406f, -0.00132017f, -0.03604383f, -0.07507548f, 
    0.01406103f, 0.07209446f, -0.00902526f, -0.08725664f, 0.18891726f, -0.15104125f, 0.08623108f, 0.05422480f, 
    0.09128094f, 0.09048784f, 0.03660046f, -0.09441509f, -0.01870401f, 0.08691108f, -0.09026749f, -0.12986447f, 
    -0.03099881f, 0.02968528f, 0.10650916f, -0.14902273f, 0.13467900f, -0.06836387f, -0.00483094f, -0.12792549f, 
    -0.28261736f, -0.20825329f, 0.01700415f, -0.03563991f, -0.04011029f, 0.02612417f, 0.14383782f, -0.03569707f, 
    0.07229286f, -0.09222686f, -0.07700251f, -0.02914830f, 0.14714633f, -0.00545134f, 0.18684635f, 0.28615728f, 
    -0.10806241f, -0.00544347f, -0.05182417f, 0.07949021f, 0.06623074f, -0.05953036f, 0.07166630f, -0.03216529f, 
    -0.04280408f, -0.16753425f, 0.04842706f, 0.26161808f, -0.00879445f, -0.08916190f, 0.09658930f, -0.03731426f, 
    0.04544381f, -0.07783569f, -0.16571102f, -0.11600208f, 0.05574759f, 0.14827010f, 0.00834153f, 0.24283108f, 
    -0.02287239f, 0.09193028f, -0.06163908f, 0.02959428f, -0.04020610f, -0.06988049f, -0.14062655f, 0.09454472f, 
    0.22702484f, 0.07767706f, -0.16345309f, -0.14258562f, 0.05821696f, -0.05459021f, -0.06041687f, -0.17259434f, 
    -0.06462543f, -0.14276911f, -0.12231619f, -0.10152010f, 0.08506329f, 0.24361783f, -0.13597806f, 0.14269635f, 
    -0.08098870f, -0.01738581f, -0.05616805f, 0.03582228f, 0.07187225f, -0.06415402f, 0.11365140f, 0.05011439f, 
    -0.23155539f, -0.00033956f, -0.12407059f, -0.06273379f, 0.15655458f, 0.04364780f, 0.01794847f, -0.06381437f, 
    0.09933902f, 0.01402140f, -0.01635232f, -0.07517826f, 0.43245733f, -0.03362119f, 0.00366185f, -0.06728765f, 
    -0.01374331f, 0.00879995f, -0.09714719f, -0.04610887f, 0.03989392f, -0.08370031f, -0.08477758f, -0.16744937f, 
    0.28581730f, -0.10788415f, 0.20759310f, -0.01152222f, -0.01856639f, 0.09689589f, -0.03322051f, 0.03994013f, 
    0.09541316f, 0.05979823f, -0.01216234f, 0.10513895f, 0.01644821f, -0.08258864f, 0.00446901f, 0.16708884f, 
    0.06037961f, 0.09906250f, -0.05129448f, -0.03075916f, -0.04786361f, 0.10331985f, 0.32897893f, 0.13847885f, 
    0.35456097f, 0.31980678f, 0.12959735f, 0.16696325f, 0.05110568f, 0.08848445f, -0.02260291f, 0.04261559f, 
    -0.01937480f, 0.06298593f, 0.00749482f, 0.14648248f, -0.02487605f, 0.11711334f, -0.13669525f, 0.19681987f, 
    0.24195039f, 0.05548849f, -0.10032620f, 0.11167291f, 0.06500962f, -0.00488113f, 0.20737481f, 0.11021143f, 
    -0.05501447f, -0.03899460f, -0.09600226f, 0.18134548f, -0.06152971f, 0.01716133f, -0.03208342f, 0.04731749f, 
    0.08200026f, 0.10019741f, -0.08169391f, 0.17619383f, -0.11566844f, -0.08157556f, 0.16475908f, -0.06929339f, 
    -0.08214204f, -0.08784869f, -0.12556766f, 0.05959749f, 0.03909862f, 0.03573837f, 0.06597738f, -0.12103047f, 
    0.45783830f, -0.05531343f, -0.01686809f, 0.06272132f, 0.06486981f, -0.00818677f, -0.07381395f, -0.00210026f, 
    0.02314335f, 0.21383300f, -0.04233523f, 0.04251294f, -0.21225888f, 0.03838172f, 0.02465883f, 0.14109986f, 
    0.08594045f, 0.14108649f, 0.03299892f, 0.07676530f, 0.20330200f, 0.13001104f, -0.11302299f, 0.16392954f, 
    -0.07409758f, -0.02053494f, -0.16793466f, 0.11788260f, -0.01264407f, -0.04917233f, 0.14798023f, 0.01968365f, 
    -0.02205056f, -0.08553279f, -0.02656691f, -0.02613787f, 0.13016792f, 0.27554569f, -0.02271796f, -0.06058390f, 
    0.15846525f, 0.14815347f, 0.10408221f, 0.07415669f, 0.01716532f, 0.02935667f, 0.09593581f, -0.03985747f, 
    -0.09371331f, 0.06198215f, 0.15722485f, 0.22005345f, 0.12387772f, 0.12784491f, 0.17814550f, 0.11652110f, 
    -0.00784600f, 0.03535476f, 0.10559909f, -0.03626204f, -0.01471777f, 0.07973137f, 0.09175150f, -0.20949663f, 
    0.14590502f, -0.00614171f, -0.04835228f, 0.02828783f, 0.00794269f, -0.03628409f, 0.09595811f, 0.07141820f, 
    -0.21578439f, 0.04673271f, -0.01626272f, -0.22314714f, -0.00782346f, -0.02450764f, 0.02374167f, 0.01172773f, 
    0.06623989f, -0.07801636f, 0.12884602f, 0.06939439f, 0.45567775f, -0.23762439f, -0.08217033f, -0.10757013f, 
    0.08875100f, 0.04564711f, -0.02433587f, 0.13768798f, 0.06956324f, 0.09744941f, 0.07820623f, 0.17425013f, 
    0.11700364f, 0.07755233f, -0.23535423f, -0.07708443f, -0.02518781f, -0.07958744f, 0.03927739f, 0.02929434f, 
    0.04158818f, 0.05083666f, 0.14047991f, 0.13089673f, -0.27502215f, -0.12844025f, -0.03041987f, -0.06964339f, 
    0.13473816f, -0.08845058f, 0.05903779f, 0.12767680f, 0.10675080f, -0.01474913f, 0.24297787f, 0.19074735f, 
    -0.03778129f, -0.13953581f, -0.15985991f, -0.01514467f, -0.16544780f, -0.12581606f, -0.01930172f, 0.24841811f, 
    -0.02224518f, 0.01640845f, 0.02613676f, 0.13943702f, -0.05146924f, -0.39413413f, -0.11510605f, 0.23307025f, 
    -0.12624618f, -0.23286952f, -0.04239440f, 0.02940632f, -0.08152248f, -0.09159476f, -0.01491321f, -0.10211727f, 
    0.05706953f, -0.12006161f, -0.11095737f, -0.00924913f, -0.04444019f, 0.04520179f, -0.07708671f, 0.06369343f, 
    0.01119036f, -0.01518076f, 0.03244092f, 0.01499606f, -0.06858034f, 0.04808179f, 0.13748240f, -0.04914205f, 
    0.11695886f, 0.01691177f, -0.08325246f, 0.00079438f, 0.33596009f, -0.07561136f, -0.01219636f, 0.06702768f, 
    0.27497858f, 0.14656048f, 0.18273053f, -0.01973118f, 0.02503685f, 0.11938182f, -0.00026743f, 0.01496197f, 
    0.02125259f, 0.01050037f, -0.00641809f, -0.05640962f, 0.43337041f, 0.07762035f, -0.15145758f, 0.19063455f, 
    -0.03579389f, 0.17619044f, 0.00253879f, 0.01284000f, -0.08583094f, -0.06794645f, 0.06394577f, -0.06625657f, 
    0.12076353f, -0.02839418f, 0.04680736f, -0.03628232f, 0.02189545f, -0.10008054f, -0.08836271f, 0.14498849f, 
    0.00093085f, 0.01652270f, 0.01373187f, 0.00724849f, 0.07508083f, 0.09355488f, 0.12108172f, -0.01192219f, 
    0.14771678f, 0.01270501f, -0.03046445f, 0.11815485f, 0.04271080f, 0.13879514f, 0.02785408f, 0.23550844f, 
    -0.03586714f, -0.24654828f, -0.16898781f, 0.18786310f, 0.06102493f, 0.02672164f, 0.07963161f, 0.07155082f, 
    -0.03537565f, -0.05731316f, 0.04754746f, 0.04296711f, 0.21830153f, -0.26228184f, -0.18628879f, 0.21021217f, 
    0.09638643f, 0.12825367f, 0.12286238f, -0.09392883f, 0.10722090f, -0.02412380f, -0.03301736f, -0.05973504f, 
    0.29363519f, -0.09986011f, -0.22010535f, 0.10736796f, -0.02896205f, -0.14897881f, -0.03397575f, 0.06957382f, 
    -0.01182381f, -0.01483977f, -0.04484072f, -0.07104143f, -0.11995762f, 0.16934238f, 0.12924437f, 0.00951479f, 
    0.24168085f, 0.07075687f, 0.00809802f, -0.04491793f, 0.18538718f, 0.03849690f, 0.14319460f, 0.07636711f, 
    -0.02340202f, 0.17623302f, 0.05833191f, -0.03569371f, 0.17908713f, 0.09082827f, 0.04656428f, 0.02610377f, 
    0.26482174f, 0.09684408f, 0.18187700f, -0.00001000f, -0.11607351f, -0.20864891f, -0.00242074f, -0.21696982f, 
    0.05916220f, 0.05399616f, 0.01175533f, 0.00961901f, 0.15442559f, 0.01295297f, 0.07627161f, 0.07754268f, 
    0.17763083f, -0.19117913f, -0.16718994f, -0.20555393f, -0.09059793f, -0.06477172f, 0.03820917f, -0.00867354f, 
    0.00293659f, -0.01209682f, -0.01458753f, -0.10827494f, -0.07239892f, 0.03710428f, 0.08243076f, 0.18496203f, 
    0.11053841f, 0.16023235f, 0.11985639f, -0.09329554f, 0.07260159f, 0.00189476f, -0.08281892f, -0.07201230f, 
    0.24471624f, -0.00415838f, -0.00257803f, -0.07581238f, -0.02628871f, 0.23564267f, 0.07403629f, 0.00295966f, 
    0.15170078f, 0.16218777f, 0.02669746f, 0.17145063f, -0.17234012f, -0.02857606f, 0.06638475f, 0.04456709f, 
    -0.09407860f, -0.00144195f, 0.03919336f, 0.13859504f, 0.08553869f, 0.09525931f, 0.12799969f, 0.07451879f, 
    -0.25265566f, -0.01552200f, 0.14746906f, 0.13591316f, -0.11357459f, -0.04711873f, 0.01296267f, -0.11239244f, 
    0.00476546f, 0.05720904f, 0.21652456f, 0.06164352f, 0.02678216f, -0.08700518f, 0.00715959f, 0.06424621f, 
    0.13328904f, -0.08147188f, 0.00337525f, 0.08480375f, 0.06267379f, -0.00465877f, 0.14182006f, 0.13783154f, 
    0.04590553f, -0.15767220f, -0.13456473f, -0.05183672f, 0.15014359f, 0.18767653f, -0.05040339f, 0.05867429f, 
    -0.09193164f, 0.02270723f, 0.08309267f, 0.02223072f, 0.06881909f, 0.35307887f, 0.03393553f, 0.17088668f, 
    -0.01332063f, 0.04136487f, 0.03441794f, -0.12414952f, 0.02554511f, -0.02872087f, 0.00064849f, -0.00357413f, 
    -0.25529864f, -0.04928225f, -0.06891784f, 0.13089578f, -0.02242394f, -0.08214848f, 0.00813580f, 0.01917265f, 
    0.02283176f, 0.13889943f, -0.10883331f, 0.05007081f, 0.05662975f, -0.20089158f, -0.03722476f, -0.06457569f, 
    0.03622736f, -0.08253799f, -0.03954969f, -0.05407246f, 0.08909149f, -0.00118040f, 0.10362357f, 0.04346396f, 
    -0.05639161f, -0.05853468f, -0.02653102f, -0.02167860f, -0.02782143f, -0.03318468f, 0.01486850f, 0.02957768f, 
    0.02404928f, -0.05282918f, -0.01368419f, -0.02057710f, -0.04457725f, -0.03729581f, 0.03475694f, -0.02407310f, 
    0.00281673f, 0.02749563f, -0.00712755f, -0.03085122f, -0.03022029f, 0.03984242f, 0.01746594f, 0.00034312f, 
    0.00090013f, 0.04001271f, -0.02482011f, -0.04672056f, 0.01610740f, -0.01373375f, -0.05141294f, -0.02877360f, 
    -0.05397857f, -0.04618504f, -0.04491017f, -0.05254836f, 0.02933978f, -0.01592558f, 0.02179032f, 0.01332629f, 
    -0.02905959f, 0.03453875f, 0.02323373f, -0.03431040f, 0.00639433f, -0.05296925f, 0.03571977f, 0.04070611f, 
    -0.02275814f, -0.02911233f, -0.04079207f, 0.03074707f, 0.00986650f, -0.04986399f, -0.03096294f, 0.03207784f, 
    -0.02502603f, 0.02942589f, -0.03020536f, 0.02268394f, -0.01364695f, -0.00353710f, -0.00656920f, -0.01192548f, 
    0.04273622f, -0.04861461f, -0.00431181f, -0.00028862f, -0.01613870f, -0.02948983f, 0.02963171f, -0.02792767f, 
    -0.01404380f, -0.03559679f, -0.01281148f, -0.01275543f, 0.01683676f, 0.01077406f, -0.05262983f, -0.00940901f, 
    -0.04697821f, -0.03797237f, 0.02449475f, -0.02987728f, 0.00774220f, 0.01399165f, -0.05263022f, -0.04258033f, 
    0.01696716f, -0.00353811f, -0.05527960f, -0.03883068f, -0.03336021f, -0.04378136f, -0.02824986f, 0.01082086f, 
    -0.00878321f, -0.02653451f, -0.04691979f, 0.02395861f, -0.02935619f, -0.04887578f, -0.00232114f, -0.03375647f, 
    0.01103085f, -0.03145611f, -0.04674809f, -0.03609635f, -0.02116195f, 0.00928787f, -0.03753216f, -0.00759616f, 
    -0.01519591f, -0.02839729f, -0.01732428f, -0.00156512f, 0.00607437f, 0.02497803f, 0.02344736f, -0.05110724f, 
    0.01204387f, 0.00539366f, 0.00078197f, 0.00307767f, -0.03130805f, 0.00866043f, -0.05398215f, -0.02549190f, 
    0.03925066f, -0.05271965f, -0.04278351f, 0.03800641f, -0.04177651f, 0.03575190f, -0.04393450f, -0.05533456f, 
    -0.01429702f, 0.01577466f, 0.02098805f, -0.04014719f, -0.00061919f, -0.00108409f, -0.04935046f, 0.00732662f, 
    -0.01248407f, 0.01179973f, -0.02358545f, -0.00239404f, 0.02477459f, -0.02103779f, 0.02468103f, -0.00917384f, 
    0.03853624f, -0.02490518f, -0.00212525f, 0.03819488f, 0.00944779f, -0.05095642f, -0.01054829f, 0.00655792f, 
    -0.04834355f, -0.01978576f, 0.00219429f, 0.03068688f, -0.02483955f, -0.01232765f, 0.03538229f, 0.03816827f, 
    0.01391810f, 0.03815009f, 0.03833894f, -0.04368752f, 0.03032795f, -0.03566521f, -0.04489825f, -0.04710288f, 
    -0.00107011f, -0.04208817f, -0.00157690f, -0.04832178f, -0.00663349f, -0.02261427f, 0.04304539f, 0.03542631f, 
    -0.03506956f, -0.01625926f, -0.00203947f, -0.04126332f, 0.03869931f, -0.04087330f, 0.00361989f, 0.02289477f, 
    -0.01642789f, -0.04244782f, -0.01391271f, 0.00158857f, 0.01336989f, -0.03992228f, -0.03506624f, -0.02825250f, 
    0.04174906f, -0.04603240f, 0.03969629f, -0.01123457f, 0.01680968f, 0.01658508f, -0.04833138f, 0.03593590f, 
    -0.04829941f, 0.01005804f, -0.04211268f, -0.01233809f, 0.02584546f, -0.05376691f, -0.04792431f, -0.03567515f, 
    -0.00597332f, -0.00684631f, 0.02242847f, 0.03570807f, -0.03585581f, -0.03929331f, 0.02173480f, 0.02282773f, 
    0.01248019f, -0.00353521f, -0.02126852f, 0.02426752f, 0.03219161f, 0.00723867f, -0.01191823f, -0.04638835f, 
    -0.02094232f, -0.00379025f, 0.03448013f, 0.00626054f, -0.00814098f, 0.04120719f, -0.05287948f, 0.00591002f, 
    -0.03632163f, -0.02467412f, 0.02097690f, -0.00702326f, -0.03871187f, -0.03819042f, -0.04983492f, 0.03525340f, 
    -0.02878281f, -0.00668677f, 0.02576160f, -0.03394775f, 0.00165786f, -0.04790405f, -0.00899023f, 0.02968825f, 
    -0.03432741f, -0.04279456f, 0.03253183f, 0.02763638f, -0.00894123f, -0.03806293f, -0.00098916f, -0.02804638f, 
    -0.05400565f, -0.02413734f, 0.03068305f, 0.04062818f, 0.00044189f, 0.02549513f, 0.01559493f, -0.03871096f, 
    0.02796790f, 0.02849753f, -0.00372606f, 0.02674211f, 0.03862097f, -0.03637016f, 0.03380344f, -0.02028112f, 
    0.02899322f, 0.00344668f, 0.03301997f, 0.03106283f, 0.00871978f, 0.01034500f, -0.04224956f, -0.04375187f, 
    0.02388681f, 0.03216165f, -0.03274179f, 0.04049953f, 0.03681627f, 0.00925961f, -0.00763680f, -0.02462754f, 
    -0.03693977f, -0.04516828f, -0.02149463f, -0.00929488f, 0.00476521f, 0.04031011f, -0.04925262f, -0.02715790f, 
    -0.04616290f, -0.01595359f, 0.03139959f, -0.01817257f, -0.04661708f, 0.00210569f, 0.03616032f, 0.03362590f, 
    -0.04968612f, -0.02973033f, 0.01651753f, -0.05465490f, -0.05443783f, 0.02779572f, -0.03274740f, 0.02019056f, 
    -0.05779208f, 0.02533255f, 0.02658425f, 0.02015785f, -0.03172402f, 0.03813047f, -0.02575764f, -0.03503438f, 
    0.01686801f, 0.00530174f, 0.01143731f, 0.04006403f, 0.03944979f, 0.03246964f, -0.04390156f, 0.00509589f, 
    -0.05188612f, -0.05100807f, 0.01136091f, 0.03993429f, -0.00115014f, -0.04975779f, -0.04352364f, 0.00762671f, 
    0.04047494f, -0.02131962f, 0.01838590f, -0.00617100f, -0.02368676f, 0.01025578f, 0.02858542f, 0.03559771f, 
    -0.05076000f, 0.02280834f, 0.03637375f, -0.03895174f, 0.03773651f, -0.03602740f, -0.00983016f, -0.05228807f, 
    -0.02691704f, 0.01313121f, 0.02381159f, 0.01878698f, 0.03626328f, -0.00140786f, 0.02365724f, -0.00498636f, 
    -0.04852241f, 0.02874916f, 0.03875144f, -0.04476407f, -0.01530273f, 0.01101895f, -0.00695505f, 0.03232030f, 
    0.04221421f, -0.04357667f, 0.01419005f, 0.04241381f, -0.05386078f, -0.03957578f, -0.05699214f, -0.01674078f, 
    0.03244077f, 0.28415820f, 0.01684926f, 0.18884404f, -0.03698345f, -0.04538827f, -0.10586700f, 0.07486389f, 
    0.08773331f, 0.04922922f, -0.09025156f, 0.01162586f, 0.11786032f, 0.12851639f, -0.17808831f, 0.05757595f, 
    -0.05626849f, 0.04183648f, -0.07681172f, -0.05029064f, 0.05301059f, 0.06352020f, 0.05525739f, -0.09643544f, 
    -0.04034113f, 0.10309236f, -0.13402255f, -0.00056417f, -0.11054166f, -0.04786025f, 0.16586992f, 0.06337012f, 
    0.12640381f, 0.07512699f, 0.09444535f, -0.03822654f, -0.09536026f, -0.04697747f, -0.15508178f, -0.02853490f, 
    0.01934416f, -0.16013724f, -0.02573246f, -0.18288645f, 0.01750303f, 0.06150101f, 0.11957128f, 0.02091153f, 
    0.27354598f, 0.09596927f, 0.12857838f, 0.09128296f, 0.06282299f, 0.06388638f, -0.04665362f, -0.05578922f, 
    0.00922638f, 0.03997171f, 0.06777340f, 0.03378703f, -0.00709110f, -0.10302067f, -0.05082726f, -0.07737578f, 
    0.09499326f, -0.14660518f, 0.03213254f, 0.05439086f, 0.00002877f, -0.05835520f, -0.11004402f, -0.00627327f, 
    0.28019059f, -0.09902824f, 0.03375434f, 0.21770640f, 0.10980032f, 0.12140531f, -0.15827845f, -0.06632620f, 
    0.10148105f, 0.11279099f, -0.05636434f, 0.06707069f, 0.11427162f, -0.12993571f, -0.10623959f, -0.16846916f, 
    -0.02314769f, -0.07753443f, -0.05439344f, -0.13009109f, 0.00226849f, -0.00100780f, -0.01339641f, -0.01941085f, 
    0.20750128f, 0.28047022f, 0.28643855f, 0.04757119f, 0.06752447f, 0.13127579f, 0.08391487f, 0.07339898f, 
    0.00899774f, 0.01148226f, -0.01109074f, -0.01007090f, 0.26763481f, 0.21270707f, 0.28288099f, 0.04670054f, 
    -0.01167669f, 0.02463944f, 0.16118385f, 0.10652891f, -0.07062711f, 0.01269017f, 0.00466018f, 0.01616351f, 
    0.17128757f, 0.07184397f, -0.06690940f, 0.00891350f, 0.11512609f, 0.08512656f, 0.04224914f, -0.04151463f, 
    0.09882152f, 0.10350875f, -0.01162616f, 0.01437167f, 0.01992115f, 0.07762478f, -0.12067208f, 0.17052743f, 
    0.01568546f, -0.08108585f, -0.00520654f, 0.04985464f, 0.02919065f, 0.14117043f, -0.14401595f, -0.04479304f, 
    -0.04775741f, -0.21541598f, -0.16990948f, 0.03194970f, -0.10876777f, -0.10417401f, -0.11345705f, -0.12567870f, 
    -0.03005623f, -0.04745601f, 0.11221795f, 0.05642528f, -0.12509310f, -0.04207550f, -0.06302253f, 0.00495601f, 
    0.12606308f, -0.10723485f, -0.11958540f, -0.08631506f, 0.01768209f, 0.01831271f, 0.05083092f, -0.03135595f, 
    0.08520795f, 0.16793579f, -0.03435401f, -0.00991827f, -0.03250821f, 0.07632187f, -0.04158663f, 0.01216874f, 
    -0.00173291f, 0.09383745f, 0.07115780f, -0.00332267f, 0.03542608f, -0.06304786f, -0.26872587f, 0.32285389f, 
    0.08429121f, -0.11837651f, -0.08591925f, -0.06280850f, -0.08538871f, -0.07538388f, 0.03355189f, -0.12577838f, 
    0.45347527f, 0.20139982f, 0.10046098f, 0.02500570f, -0.10258728f, 0.02336803f, 0.05674904f, 0.08939233f, 
    0.00477277f, 0.05881185f, -0.00444191f, 0.12846720f, -0.15621413f, 0.17158921f, -0.08880664f, -0.05814719f, 
    0.03865942f, -0.04347911f, -0.09066371f, 0.04524641f, -0.02270964f, -0.06147011f, -0.04126262f, -0.04437999f, 
    -0.04815726f, 0.24376541f, 0.09536415f, 0.11903366f, 0.19855176f, -0.00385282f, -0.00961374f, -0.08352506f, 
    0.01809520f, 0.05204656f, 0.03158082f, 0.02299801f, 0.06447532f, 0.20089316f, 0.06238250f, -0.09604668f, 
    -0.06037680f, 0.00864451f, -0.03504894f, -0.16853186f, 0.15778393f, 0.09996825f, -0.07655441f, -0.04324073f, 
    -0.12462710f, -0.25313565f, -0.19066791f, -0.17315675f, 0.13500619f, 0.04781562f, -0.02776496f, -0.15810344f, 
    0.07230205f, 0.09573022f, 0.02265573f, 0.01569119f, 0.12994507f, -0.04386622f, 0.19391546f, 0.08061715f, 
    0.09053075f, -0.11878997f, -0.03610051f, -0.15728045f, -0.01465778f, -0.05558956f, 0.02314024f, -0.07159617f, 
    0.37014574f, 0.24427241f, 0.20511334f, 0.03306346f, -0.08009542f, 0.03689775f, 0.00832866f, 0.13035366f, 
    -0.15277997f, -0.01310131f, 0.02128568f, 0.02893759f, -0.14683831f, 0.04883445f, 0.05219849f, -0.01969164f, 
    0.00226164f, -0.08338089f, -0.06640312f, -0.10645206f, 0.01144340f, 0.11387841f, -0.03499907f, 0.11139388f, 
    -0.10941098f, -0.04176543f, -0.09320280f, 0.05835360f, -0.05527303f, -0.10992821f, -0.05618514f, -0.06928190f, 
    0.08226728f, -0.00943635f, -0.00661970f, -0.07092331f, 0.19588260f, 0.17664453f, -0.06638862f, 0.10827594f, 
    0.10095596f, 0.10768072f, 0.01353960f, -0.04093444f, 0.09495070f, -0.01461530f, 0.05357137f, 0.00695049f, 
    -0.01602183f, -0.04161957f, 0.01887537f, 0.06249933f, -0.01133683f, -0.02413543f, -0.07930940f, 0.00465838f, 
    0.08079804f, 0.08704944f, -0.00213966f, 0.12199406f, 0.03006285f, 0.01965027f, 0.07278407f, -0.08753280f, 
    -0.07472927f, 0.01450911f, 0.06032739f, -0.00447750f, -0.07085474f, -0.04887304f, -0.04297318f, -0.08337372f, 
    -0.06955724f, 0.22467372f, 0.12924248f, -0.07098940f, 0.09187204f, -0.01060534f, 0.04441514f, -0.21862529f, 
    -0.09694888f, 0.15002012f, 0.08366240f, -0.14871600f, 0.07842119f, -0.10186067f, -0.18097241f, 0.02116620f, 
    -0.07239377f, -0.06195911f, -0.12088925f, 0.08919511f, -0.02364814f, 0.05999557f, -0.08256918f, 0.04359942f, 
    0.17624702f, 0.04174590f, 0.09355529f, 0.11663572f, 0.16497673f, 0.07190153f, 0.06205284f, 0.07256673f, 
    0.11538641f, 0.04893971f, 0.05129811f, 0.03064128f, 0.17504667f, 0.20489289f, 0.11705947f, -0.04144542f, 
    0.05493740f, -0.07752983f, 0.03916642f, 0.04954477f, -0.00914666f, -0.04285239f, -0.07843176f, -0.01283464f, 
    -0.01128794f, 0.14224657f, -0.04244442f, 0.27937722f, -0.10427940f, -0.04463736f, -0.09003421f, 0.09830164f, 
    0.05718744f, 0.19050157f, 0.05683593f, -0.13216178f, -0.04922538f, 0.06818147f, -0.22170648f, -0.00527385f, 
    -0.00775907f, -0.05409557f, 0.05409881f, -0.06748137f, 0.01480719f, 0.04559163f, -0.12933700f, 0.12818022f, 
    0.05072869f, 0.20555812f, -0.09471175f, 0.13383102f, 0.00140857f, 0.13274023f, 0.01344258f, 0.01214652f, 
    0.07252652f, -0.03671562f, -0.06026877f, 0.05405778f, 0.06568884f, -0.01866649f, -0.10374653f, 0.12773976f, 
    0.14444479f, -0.02080867f, 0.01521126f, -0.06336001f, 0.13138825f, 0.01337628f, 0.18733136f, -0.08474271f, 
    -0.11447940f, -0.03315357f, 0.13901828f, -0.23915532f, -0.03134308f, -0.20432019f, 0.09471489f, -0.06118013f, 
    0.02322368f, 0.07793850f, -0.00807578f, 0.14235698f, 0.06440116f, -0.01931750f, 0.00777328f, -0.06491165f, 
    0.09001353f, -0.15411995f, -0.01222025f, 0.17184342f, -0.04587194f, 0.02124005f, -0.07106310f, 0.05262556f, 
    -0.01670688f, -0.10339510f, 0.13399298f, 0.00939446f, 0.16481768f, -0.06812042f, 0.01835982f, 0.10427688f, 
    0.12914488f, -0.11287995f, -0.04864211f, 0.11269760f, 0.31400323f, 0.00561397f, -0.08122005f, 0.01918402f, 
    0.23013858f, -0.05899040f, -0.05722154f, -0.14461502f, -0.00598953f, 0.04122985f, -0.00763150f, 0.04070942f, 
    -0.04077385f, 0.09243991f, 0.21703896f, 0.29893696f, -0.06914691f, -0.05926380f, -0.00686815f, -0.07252837f, 
    0.01016342f, -0.12026728f, -0.05428427f, 0.00750114f, 0.14936210f, 0.03934958f, 0.25770992f, 0.26326132f, 
    -0.14743991f, -0.03288854f, 0.05437668f, -0.02203725f, 0.08091718f, -0.06972836f, -0.07264227f, -0.04679413f, 
    0.06942709f, 0.01127402f, -0.19204824f, -0.00079562f, 0.07291821f, -0.07169575f, -0.01830787f, -0.07268506f, 
    0.09829298f, 0.17123081f, 0.07776806f, 0.04480571f, -0.16330449f, 0.10001928f, 0.05026272f, 0.12755197f, 
    0.08327796f, -0.09411380f, -0.11722069f, -0.01640177f, 0.09890336f, -0.03976381f, -0.01542476f, 0.04339560f, 
    0.03035369f, -0.04540305f, 0.00994903f, 0.27059165f, 0.17810412f, 0.05082430f, 0.00277109f, -0.01279657f, 
    0.01633084f, -0.05850562f, 0.21551348f, 0.06611597f, -0.23236321f, -0.12625727f, 0.04461223f, 0.09782398f, 
    0.02899652f, 0.07432901f, -0.13708307f, -0.00750478f, 0.05942931f, 0.07284591f, 0.22290377f, 0.00920096f, 
    0.04587435f, 0.04575424f, 0.05168363f, -0.11577457f, 0.04847284f, 0.01211096f, -0.04930128f, -0.06983057f, 
    -0.07913918f, 0.08419991f, 0.11507265f, 0.07840627f, -0.13085277f, -0.16162524f, -0.13781457f, 0.30213413f, 
    0.16016455f, -0.14594597f, -0.01103150f, -0.06736992f, -0.04895636f, -0.00674922f, 0.08069839f, -0.08100902f, 
    0.12388141f, 0.12400567f, -0.08968523f, 0.10359614f, -0.05555844f, 0.10188479f, 0.02008441f, -0.05578256f, 
    -0.06263323f, -0.01892867f, 0.05434879f, -0.03624225f, -0.21254599f, 0.02410034f, -0.32046685f, 0.17748049f, 
    0.23584017f, 0.03511154f, -0.16073087f, 0.02478666f, -0.01913150f, 0.07853601f, 0.09133495f, 0.07091662f, 
    0.21547042f, 0.07566280f, -0.06582259f, 0.16663228f, 0.09161288f, 0.04814195f, -0.04430048f, -0.00837250f, 
    0.08368143f, 0.02382014f, 0.25599694f, 0.01042029f, -0.25879905f, -0.10752815f, -0.06521568f, 0.04330852f, 
    -0.02919751f, -0.00197434f, 0.04386301f, -0.04092881f, 0.17397635f, 0.05721045f, 0.08079503f, -0.09251402f, 
    -0.19232839f, -0.06796812f, -0.11422148f, 0.20804822f, 0.20243229f, 0.11792637f, -0.03528005f, -0.10871076f, 
    0.18142192f, -0.05133965f, -0.08313915f, 0.04369930f, -0.24092843f, 0.14201622f, 0.12837195f, 0.14384489f, 
    0.02178971f, 0.08549438f, 0.09321115f, 0.01678239f, 0.09963518f, 0.13555515f, 0.06794411f, -0.04542356f, 
    0.03321539f, -0.05509239f, 0.19070882f, 0.16932176f, 0.01868895f, -0.08942933f, -0.00228915f, 0.13170040f, 
    -0.09816348f, 0.01988917f, 0.06435858f, -0.08128753f, 0.13068548f, -0.12177408f, -0.08981458f, -0.19572666f, 
    0.09587287f, -0.05477145f, 0.05539633f, -0.13348596f, 0.15411282f, 0.09438315f, 0.01247210f, 0.09842117f, 
    -0.06527707f, -0.21254218f, -0.11821205f, 0.00760413f, -0.09919040f, -0.04492732f, 0.03051683f, 0.00555863f, 
    0.08154366f, -0.03442596f, -0.01135327f, -0.04538134f, 0.02387515f, 0.06092176f, -0.04427818f, 0.17133446f, 
    0.09696981f, 0.09994669f, 0.06236429f, 0.09481672f, -0.06760906f, 0.01550710f, -0.05752704f, -0.03627624f, 
    -0.05007327f, 0.04608920f, 0.00498216f, 0.02018680f, -0.08475444f, 0.07691225f, 0.07687118f, 0.03895983f, 
    0.03908494f, -0.00783160f, 0.04330345f, 0.13847037f, -0.09933692f, 0.00777608f, 0.01387560f, -0.03887108f, 
    0.01825923f, 0.02143504f, 0.14966400f, 0.16650018f, -0.13138959f, -0.01278634f, -0.03943243f, -0.05967909f, 
    0.13640089f, 0.35682896f, 0.06154254f, -0.17348289f, 0.07800903f, -0.05291776f, -0.01444625f, -0.10452642f, 
    0.09579441f, 0.03174980f, 0.20645450f, 0.19018699f, -0.06241008f, 0.11134214f, -0.11711039f, 0.13536447f, 
    0.10297732f, -0.13257265f, -0.05016535f, -0.03512459f, 0.07963032f, 0.04826589f, -0.08831541f, 0.11734992f, 
    -0.11068998f, 0.01007075f, 0.02476675f, 0.14941384f, 0.04349172f, 0.05259545f, -0.14981599f, 0.18081273f, 
    0.18482110f, -0.01292339f, 0.05621023f, -0.01041261f, 0.12444814f, 0.11449587f, 0.12433316f, -0.08904938f, 
    0.03343732f, -0.09103108f, 0.08966871f, 0.03837112f, 0.08127447f, -0.03806452f, 0.25671527f, -0.03865974f, 
    -0.02412577f, -0.00526604f, -0.05058685f, 0.04295132f, 0.02630732f, 0.02755308f, -0.01741722f, -0.05643038f, 
    0.00580902f, 0.01615201f, 0.03070481f, 0.01226132f, -0.03305113f, -0.04729079f, -0.04846059f, -0.01544024f, 
    -0.04060673f, 0.01959834f, 0.03731629f, -0.04474479f, 0.03990498f, 0.01779574f, -0.03591413f, 0.01486033f, 
    0.04309509f, 0.04296530f, -0.03718579f, -0.03565825f, -0.01822109f, 0.01799561f, 0.02130804f, -0.00014535f, 
    -0.01112311f, -0.05125347f, 0.01653262f, -0.01887111f, 0.02183562f, 0.03037748f, 0.00392957f, -0.03926803f, 
    -0.02071554f, 0.03477768f, -0.03468759f, -0.02107134f, 0.02259087f, -0.00232751f, 0.03820554f, 0.01963405f, 
    -0.01852532f, -0.01712665f, -0.05574953f, 0.03442446f, 0.00773092f, -0.03698658f, -0.04755607f, 0.02883269f, 
    -0.04737447f, 0.02339867f, 0.00693528f, -0.01203998f, -0.05666684f, 0.00384044f, -0.04055649f, -0.00372824f, 
    -0.03086416f, 0.01740512f, -0.00203513f, 0.00213946f, 0.01253666f, 0.03243116f, 0.04210497f, 0.00973157f, 
    0.00338469f, -0.00545402f, 0.00298270f, -0.01246207f, 0.03963448f, 0.03205710f, 0.02158118f, -0.02140473f, 
    -0.02972410f, -0.02563488f, -0.04612069f, 0.03212478f, 0.01872419f, 0.01047053f, -0.01468593f, -0.02731666f, 
    -0.03015311f, -0.00286244f, -0.04571958f, -0.05272533f, 0.01351911f, -0.02096554f, 0.03579317f, 0.00226241f, 
    -0.03868633f, 0.02658300f, -0.01528858f, 0.01443394f, -0.03819870f, 0.02121695f, -0.00199418f, -0.01883905f, 
    0.03317455f, -0.04363055f, -0.04375605f, 0.04234570f, -0.00651109f, -0.05465629f, -0.04428897f, -0.02476476f, 
    -0.05735625f, 0.03844596f, -0.01912971f, 0.01947773f, -0.03750927f, -0.03913260f, 0.01860585f, -0.05769490f, 
    0.02484881f, -0.01717830f, -0.05496167f, 0.00723481f, 0.04234268f, -0.02295949f, -0.00069084f, -0.01935994f, 
    0.02135548f, 0.03042102f, -0.02905570f, -0.04227211f, -0.05585796f, 0.03072387f, 0.03390699f, 0.01187684f, 
    -0.05668225f, -0.05749954f, 0.02120565f, 0.00901661f, -0.04197495f, -0.04188603f, 0.00674647f, -0.04637372f, 
    0.02885275f, 0.02866699f, 0.00282301f, -0.04477011f, 0.02367442f, -0.01443627f, -0.01623128f, -0.03555561f, 
    -0.03279850f, -0.05036134f, 0.04284163f, 0.00725653f, 0.01174290f, -0.02466518f, -0.01425316f, -0.00682971f, 
    -0.02352881f, 0.02552683f, 0.00283807f, -0.04453946f, 0.03127674f, 0.01010858f, -0.05240442f, 0.03794115f, 
    -0.04264993f, -0.05633968f, 0.03626827f, 0.02716255f, -0.04086079f, 0.03652723f, -0.05795170f, -0.00986165f, 
    0.02034446f, 0.01990156f, 0.01966260f, 0.01647560f, -0.03445466f, -0.03703701f, -0.05244982f, 0.04009282f, 
    -0.03584333f, 0.03176802f, -0.05471418f, 0.00391762f, -0.03873868f, 0.03383120f, -0.04141042f, -0.05015866f, 
    0.02181005f, -0.01186725f, -0.02756952f, 0.00297513f, -0.03963817f, -0.03924173f, 0.03868721f, 0.00627555f, 
    0.04219453f, -0.05415376f, 0.02220585f, -0.02896457f, 0.00347102f, -0.01699633f, 0.02846721f, -0.00307799f, 
    0.02981323f, 0.01081858f, -0.03353063f, -0.04222172f, -0.01457709f, -0.01517951f, -0.05213909f, -0.04677482f, 
    -0.04525611f, -0.03251521f, 0.03757990f, -0.02147890f, -0.03912010f, -0.00210740f, -0.02802285f, 0.03239719f, 
    -0.03206782f, -0.04169985f, -0.01010990f, 0.02402018f, -0.00032883f, 0.01447318f, 0.03982667f, -0.05110541f, 
    0.03281610f, -0.03561756f, -0.01978369f, -0.01037875f, -0.03663601f, -0.02920636f, 0.00269203f, 0.01454366f, 
    -0.04130542f, 0.04109422f, 0.00210734f, 0.01116619f, -0.00642885f, 0.02319892f, 0.01404352f, -0.00359522f, 
    0.00345326f, 0.01794077f, 0.01128233f, -0.04875810f, -0.03706829f, 0.00298258f, 0.01183300f, -0.02307598f, 
    -0.04534815f, -0.00289012f, 0.01794842f, 0.03879370f, -0.04719608f, -0.02666344f, -0.02255096f, -0.02435116f, 
    -0.03302744f, -0.00087033f, -0.00733996f, -0.03833951f, 0.03673584f, -0.04161340f, 0.03560168f, -0.03686801f, 
    0.02579305f, -0.01166057f, 0.04314518f, -0.05718395f, 0.01360019f, -0.03182891f, 0.03098560f, -0.04544661f, 
    0.02495075f, -0.02811272f, 0.04474679f, -0.01690974f, -0.03146291f, -0.05569737f, 0.02992538f, -0.02510163f, 
    0.02130493f, 0.02439684f, -0.01622550f, -0.02364255f, 0.04332216f, 0.04035693f, -0.03446816f, 0.00094862f, 
    0.01794274f, -0.02589793f, -0.02870488f, -0.00820661f, 0.00524158f, 0.03806002f, 0.03846651f, 0.03624292f, 
    -0.02064129f, 0.02963943f, -0.04433871f, -0.03868386f, 0.03772674f, -0.03303255f, 0.04015977f, 0.01178834f, 
    -0.02721825f, 0.03807303f, -0.01372666f, -0.04571734f, 0.01259891f, 0.02623930f, 0.01086336f, -0.03747787f, 
    -0.02668369f, -0.01884193f, -0.02749930f, -0.00371627f, -0.01900627f, -0.00682036f, -0.05184548f, 0.00772720f, 
    0.03485572f, -0.04172408f, -0.03303471f, 0.02625068f, 0.03771580f, -0.02668470f, -0.02290754f, 0.02255814f, 
    0.02411455f, -0.02088284f, 0.00449357f, 0.00736649f, -0.01600220f, -0.01749939f, -0.01197800f, -0.00912250f, 
    0.01001368f, -0.03666356f, 0.01726924f, -0.01602964f, -0.05334707f, -0.02509727f, -0.01985805f, 0.04315272f, 
    -0.02974813f, 0.01002587f, 0.02040598f, -0.00006912f, 0.00556114f, -0.02685463f, -0.02060409f, 0.01887534f, 
    0.00653557f, 0.02834599f, -0.02631180f, -0.01840141f, -0.05525979f, -0.05471010f, -0.04439946f, -0.05520795f, 
    0.03590813f, -0.02317274f, 0.04491005f, 0.00256054f, 0.04207984f, -0.00547589f, 0.00201862f, -0.05346194f, 
    -0.03916089f, -0.04364454f, 0.00833465f, 0.02642871f, -0.01597975f, -0.01127941f, -0.00692098f, -0.03757964f, 
    -0.00134227f, -0.03483689f, -0.05652635f, -0.00725704f, 0.00237811f, -0.00513298f, 0.01699120f, 0.00453126f, 
    -0.00640714f, -0.03505356f, -0.02151779f, 0.01764832f, 0.00095436f, 0.04130024f, 0.03734024f, -0.04304377f, 
    -0.00563861f, 0.01926803f, 0.00293503f, -0.02703165f, 0.00543046f, -0.05171061f, 0.03409508f, -0.04998050f, 
    -0.03127934f, 0.03103318f, -0.01204796f, -0.03697786f, 0.01316924f, 0.04372202f, -0.01791917f, -0.03713008f, 
    -0.00854011f, 0.02166159f, -0.03176448f, 0.01022153f, -0.01809648f, -0.00129813f, -0.03955529f, -0.03994661f, 
    0.02007780f, 0.01550492f, 0.00057493f, -0.01634095f, 0.03154272f, 0.00871246f, 0.02601112f, -0.04068107f, 
    0.00250946f, 0.03982375f, 0.02103947f, -0.01479273f, 0.03816816f, -0.00633208f, 0.04906189f, -0.03041690f, 
    -0.04103160f, -0.01806049f, -0.00439538f, -0.01352540f, 0.01860511f, -0.04943755f, -0.05397753f, -0.04714395f, 
    -0.02130652f, -0.03559732f, 0.03865523f, -0.03367615f, 0.00879706f, 0.02081036f, 0.03608220f, 0.02038258f, 
    0.00349428f, 0.01152994f, 0.04390775f, 0.00131426f, -0.04638032f, -0.00300693f, 0.04017770f, -0.03783166f, 
    -0.02005851f, -0.03405809f, 0.00767922f, 0.01053109f, -0.04853388f, -0.02615574f, -0.04012434f, -0.01925346f, 
    0.00054154f, -0.04961983f, -0.02472336f, 0.00322298f, 0.00459469f, -0.00863140f, -0.04519840f, 0.03075883f, 
    0.00920797f, 0.00504086f, 0.02002712f, -0.02117938f, 0.02155804f, 0.04518931f, -0.00046601f, -0.00393657f, 
    -0.01432288f, 0.00791681f, -0.01095081f, -0.02029556f, -0.02042615f, -0.00601922f, -0.00857170f, 0.00332334f, 
    -0.00651412f, -0.02105185f, -0.00013368f, 0.04279942f, 0.03694020f, 0.02935554f, -0.04464776f, -0.03954171f, 
    0.02833508f, 0.02507254f, 0.03239200f, -0.03908696f, 0.03201140f, -0.02239408f, 0.01836284f, 0.03484474f, 
    -0.02572177f, -0.03715770f, -0.02022194f, -0.00703297f, -0.01396571f, 0.01084456f, 0.01180086f, 0.02076807f, 
    0.04012797f, 0.02917198f, -0.00356471f, -0.04327264f, 0.00237061f, -0.03235213f, -0.03034100f, -0.01256226f, 
    -0.03226520f, 0.00177793f, -0.01052144f, -0.00171233f, 0.02729594f, -0.03519614f, 0.03982796f, 0.04325432f, 
    0.02264931f, 0.04085745f, -0.03231851f, -0.00785801f, -0.01372147f, 0.02230803f, -0.00388302f, 0.04287346f, 
    -0.01467992f, -0.03374086f, -0.00758039f, -0.04452588f, -0.02073799f, 0.03562959f, -0.05075502f, -0.05147960f, 
    0.02430750f, 0.04418090f, -0.01788071f, -0.04475922f, 0.03745162f, 0.02072192f, 0.04370847f, -0.04445342f, 
    0.00649934f, -0.01116817f, -0.03567620f, 0.04252497f, 0.03715182f, -0.04707536f, 0.03747972f, -0.04238613f, 
    -0.01903102f, -0.00983089f, -0.01108353f, -0.00466534f, 0.00727889f, -0.03496154f, 0.01486808f, -0.01720925f, 
    0.02355526f, 0.01127883f, 0.01150432f, 0.01531839f, 0.00285244f, -0.00497016f, -0.03063787f, -0.01722381f, 
    0.02778525f, -0.05239794f, -0.00333377f, -0.05566788f, 0.01974540f, -0.04067956f, -0.03494445f, 0.04225459f, 
    0.02643249f, -0.02446767f, 0.01916015f, -0.03709839f, -0.01166536f, -0.04473166f, 0.01646223f, 0.01371468f, 
    0.00337889f, -0.03695350f, -0.05348941f, 0.01071661f, -0.01908750f, 0.01044675f, 0.00977397f, -0.02802643f, 
    0.03658187f, -0.01763571f, 0.03858406f, 0.01331914f, 0.00093698f, 0.01081171f, -0.02615557f, 0.00272737f, 
    -0.04138431f, 0.00918867f, -0.03519696f, -0.02118244f, -0.02005131f, 0.00275313f, 0.00602725f, -0.02692671f, 
    -0.02277991f, -0.02629012f, -0.03328238f, -0.03007827f, -0.04868731f, 0.02609461f, -0.00984944f, -0.00847712f, 
    -0.00046085f, 0.03891605f, 0.00307451f, 0.00978167f, -0.04743113f, -0.03669608f, -0.05598186f, 0.03918077f, 
    -0.01683591f, -0.04512623f, -0.04014936f, -0.00041472f, 0.00929944f, -0.03119795f, 0.01604286f, -0.03477976f, 
    -0.04302425f, 0.01159031f, 0.00134282f, 0.03334390f, -0.01629199f, 0.02807683f, 0.00501861f, 0.01211447f, 
    -0.04095050f, -0.04470970f, 0.00023847f, -0.01228567f, 0.01136679f, -0.02436063f, -0.01424148f, 0.03514263f, 
    -0.04361017f, -0.03671893f, 0.03787595f, 0.00046022f, 0.00185736f, 0.02257399f, -0.05373022f, -0.05447106f, 
    0.02669902f, -0.04019268f, 0.00514515f, 0.00524777f, 0.03699479f, -0.00395855f, -0.03325467f, -0.04369120f, 
    -0.04478341f, -0.04132254f, -0.03053251f, -0.02757573f, -0.03834128f, -0.04848393f, 0.01404266f, -0.03174795f, 
    -0.03940531f, -0.05142997f, -0.02373616f, 0.01539141f, 0.01547693f, -0.02137897f, -0.03485901f, -0.02057145f, 
    -0.00499229f, -0.03496543f, 0.02402101f, -0.02070233f, 0.04187493f, 0.02715031f, -0.02817542f, -0.05290288f, 
    -0.03780724f, 0.03956740f, -0.00122634f, -0.02990785f, -0.02866075f, -0.01127659f, -0.04768730f, 0.02957241f, 
    0.03414132f, 0.02414172f, 0.03035431f, 0.03074448f, 0.02215615f, 0.04237314f, -0.03229020f, 0.00869358f, 
    0.00845471f, 0.02419666f, -0.05066871f, 0.00830557f, 0.00182089f, -0.00739227f, 0.02124254f, 0.00322025f, 
    0.00239728f, 0.01042895f, -0.01092723f, -0.03079170f, -0.00896416f, -0.00131773f, -0.02492508f, -0.03824829f, 
    -0.00264406f, 0.04302052f, 0.01495780f, 0.02653092f, -0.02284846f, -0.00748992f, -0.03373915f, -0.02656280f, 
    -0.02518167f, -0.04351481f, -0.02866422f, -0.02419846f, -0.04046248f, -0.05111781f, -0.00307404f, -0.04213635f, 
    0.00300744f, -0.03420047f, -0.02048571f, -0.04158681f, -0.04986067f, -0.04143417f, 0.00218970f, -0.04167641f, 
    -0.00638334f, -0.02174099f, -0.05267607f, -0.01276325f, 0.04085738f, 0.03351888f, 0.04139439f, 0.00733514f, 
    0.03377622f, -0.04535189f, 0.00548274f, -0.03293788f, 0.02870972f, -0.01282070f, -0.02388063f, 0.00049132f, 
    0.01054637f, 0.03820942f, -0.00129053f, -0.03445046f, -0.04990920f, 0.00370690f, 0.03335639f, -0.02756985f, 
    -0.00692846f, -0.03656130f, 0.02543511f, 0.01500507f, -0.03186489f, 0.04095729f, 0.02143889f, 0.03207436f, 
    0.01986644f, -0.02168566f, 0.01780544f, -0.04059051f, -0.04545873f, -0.01265351f, -0.00200583f, 0.04851186f, 
    0.02058196f, -0.03517247f, 0.01095950f, 0.00801513f, -0.01067081f, -0.03890273f, -0.00227153f, 0.04666540f, 
    0.03612582f, 0.02029890f, -0.02967786f, -0.00750281f, 0.03189598f, 0.01851423f, -0.04828096f, 0.00184493f, 
    -0.00710606f, -0.00216677f, -0.00961020f, -0.04785475f, -0.03552426f, 0.02775596f, -0.01535555f, -0.01289445f, 
    0.04708320f, -0.04152028f, -0.00146454f, -0.02819987f, -0.01735904f, 0.01453816f, -0.02808854f, 0.03538813f, 
    -0.02195967f, 0.02109893f, 0.02793985f, -0.03036406f, -0.02520127f, 0.01189159f, 0.03837611f, 0.03278603f, 
    0.01014350f, 0.05066279f, -0.04522077f, -0.00500878f, -0.03462200f, 0.00590466f, 0.01813849f, -0.00879755f, 
    -0.04977248f, 0.00151903f, -0.00083231f, 0.00735646f, 0.00862586f, 0.02697259f, 0.01872423f, -0.00099291f, 
    0.04433436f, -0.02206514f, -0.04889297f, 0.04013780f, 0.00454006f, -0.02760654f, 0.02416516f, 0.00798288f, 
    0.01855717f, 0.01525724f, 0.02311314f, -0.03228946f, 0.00102508f, -0.04447750f, -0.01941513f, 0.04062082f, 
    0.01684225f, -0.00796242f, -0.01501985f, -0.02417480f, -0.03662907f, -0.04292905f, -0.00793995f, -0.02006642f, 
    -0.01781079f, 0.00319774f, -0.02032777f, 0.01115342f, -0.02667613f, 0.03294283f, -0.03195275f, -0.01481415f, 
    0.00576463f, -0.02165126f, -0.04398481f, -0.00007490f, 0.00531677f, 0.03253112f, -0.00929218f, -0.03439614f, 
    0.01730939f, 0.03263619f, 0.02410526f, -0.03988013f, 0.00776481f, 0.02380579f, -0.00509559f, -0.02096957f, 
    0.03287737f, -0.03400504f, -0.01438924f, -0.02107741f, 0.00298984f, -0.04924683f, -0.03473474f, 0.03320716f, 
    0.02670888f, 0.04950885f, -0.00436426f, 0.02711227f, 0.01304448f, 0.04594777f, 0.04352801f, -0.01854977f, 
    -0.02984854f, -0.03426579f, -0.01183922f, -0.02256896f, -0.01044483f, -0.01338239f, 0.00043099f, -0.04130548f, 
    0.04429679f, -0.04772905f, -0.04504468f, -0.03107757f, -0.02306287f, 0.00783768f, -0.03609002f, -0.02374500f, 
    -0.00261549f, 0.03610715f, -0.03510495f, -0.02003076f, -0.01918251f, -0.00623587f, -0.04793599f, -0.02102730f, 
    0.03287598f, -0.04342447f, -0.01490524f, 0.02969808f, -0.02822851f, -0.01965844f, 0.02079547f, 0.04565040f, 
    0.04365528f, 0.01215002f, 0.02482621f, -0.03209210f, -0.00844403f, 0.00130398f, 0.00209697f, -0.04361220f, 
    -0.02352419f, -0.02565021f, -0.00251061f, 0.01293140f, 0.00858666f, 0.03042497f, -0.00767946f, -0.00857255f, 
    0.03633760f, -0.04791576f, 0.01572480f, 0.02372804f, 0.01642584f, -0.01334309f, -0.02294333f, 0.02664245f, 
    0.02239914f, 0.03317291f, -0.00396769f, -0.02068103f, -0.00584064f, 0.01884101f, -0.04026191f, 0.02570208f, 
    0.04383053f, 0.03578935f, -0.04380428f, -0.01053458f, -0.03246436f, 0.03604783f, -0.02571998f, 0.03008853f, 
    -0.00589961f, 0.00535739f, -0.03433623f, -0.00980839f, -0.03042806f, -0.02172627f, -0.04765698f, 0.00285801f, 
    -0.02659130f, -0.03019745f, -0.04454170f, -0.01395034f, -0.00820477f, -0.04265672f, -0.01743037f, 0.03606555f, 
    -0.03200591f, 0.02951499f, -0.01411143f, 0.02355659f, -0.04316559f, -0.02958408f, 0.00452205f, 0.05064765f, 
    -0.02396547f, -0.00031970f, 0.04454523f, -0.01694713f, -0.00531597f, -0.01465179f, -0.03252365f, 0.03839929f, 
    -0.04504600f, -0.02798420f, -0.03642986f, 0.04599945f, 0.00286282f, -0.02084018f, -0.04164504f, -0.00652567f, 
    -0.03869595f, 0.00995190f, -0.01645702f, -0.02398682f, -0.04017767f, -0.00664504f, -0.01174422f, 0.04395960f, 
    0.02707822f, 0.04379641f, 0.03869599f, 0.02248829f, 0.02245176f, 0.04475471f, -0.01275637f, -0.00855656f, 
    -0.03465887f, -0.03963286f, -0.05020844f, -0.01332255f, -0.01566200f, 0.01751540f, 0.03509402f, -0.02395424f, 
    0.00215102f, -0.00216052f, -0.00619628f, -0.01449910f, -0.03544263f, 0.00968474f, -0.00487303f, -0.04216195f, 
    -0.02995059f, 0.02688803f, 0.03204995f, 0.02534660f, 0.00597777f, 0.03102610f, 0.03967181f, -0.01155694f, 
    -0.04389691f, 0.03945699f, -0.04052141f, 0.04831228f, 0.03851356f, -0.01317021f, 0.02476785f, -0.03440141f, 
    -0.03921501f, -0.02821690f, 0.00037703f, 0.04034731f, -0.00920020f, -0.01672353f, 0.00428932f, 0.03402984f, 
    0.04763565f, 0.03728566f, -0.03995501f, -0.03756866f, -0.01835031f, 0.02843776f, -0.02891893f, 0.00656384f, 
    -0.02768787f, 0.00899418f, 0.00418870f, -0.04806310f, 0.03957811f, -0.04649426f, 0.01366637f, -0.04907715f, 
    -0.04460336f, 0.01463461f, -0.03172648f, -0.00448944f, -0.04449169f, 0.02317323f, -0.03396403f, 0.00569258f, 
    -0.03913698f, -0.04858316f, -0.01901603f, 0.02887981f, -0.02871152f, 0.04283134f, 0.04634399f, -0.02283167f, 
    -0.02944553f, -0.04695596f, 0.03656050f, -0.02302965f, -0.00723969f, 0.01390105f, -0.02459117f, 0.04269790f, 
    -0.03233578f, -0.02601072f, -0.00064999f, 0.00761137f, -0.00400386f, 0.02915470f, -0.03910509f, -0.04417783f, 
    -0.00117713f, -0.04861069f, 0.02262132f, 0.00185907f, 0.01303049f, -0.00586339f, 0.02799333f, -0.00702205f, 
    0.02533755f, -0.01360299f, 0.04200659f, 0.04476661f, -0.01407514f, -0.01107995f, 0.03686748f, 0.00673826f, 
    0.03480031f, -0.21744138f, -0.04348890f, 0.23684736f, -0.06714235f, -0.00746900f, 0.10705204f, -0.10046025f, 
    -0.11669046f, -0.08581116f, 0.01372675f, 0.07945661f, -0.10346843f, -0.11188876f, 0.10312454f, 0.02361786f, 
    -0.02596193f, 0.05544720f, -0.05164553f, 0.08263717f, 0.01598838f, 0.12241346f, 0.12543726f, -0.09244161f, 
    -0.13065620f, 0.18767755f, 0.17421350f, 0.16203053f, -0.00270388f, 0.10054977f, -0.04367114f, 0.14822413f, 
    -0.04387690f, 0.02659056f, 0.07064009f, 0.07430344f, -0.18245332f, 0.08445268f, -0.05314876f, 0.00979506f, 
    -0.00095829f, -0.00443166f, 0.15627927f, -0.14605604f, -0.12390482f, -0.03814542f, 0.07019135f, 0.08933481f, 
    0.45359519f, 0.23580065f, 0.07731140f, -0.16272728f, 0.01849973f, 0.18491516f, -0.00603805f, -0.00957610f, 
    0.01639453f, -0.04307682f, 0.02210341f, -0.01341882f, -0.10310983f, 0.02558753f, 0.07604710f, 0.07760055f, 
    0.04824990f, 0.20667227f, -0.02537884f, -0.10647923f, 0.00216919f, -0.09050108f, 0.00260351f, 0.06979548f, 
    0.18193485f, -0.13802695f, 0.22413540f, -0.08753294f, -0.04799374f, -0.02347697f, 0.00572680f, -0.11829090f, 
    0.07118537f, 0.14106955f, 0.07369420f, 0.17329986f, -0.06601429f, 0.06670143f, 0.01522052f, 0.01780718f, 
    -0.11670215f, 0.02033233f, 0.11671600f, 0.23293903f, 0.05079057f, 0.05916550f, 0.12208539f, -0.00352086f, 
    0.14729162f, -0.00178354f, 0.03428089f, 0.05904826f, 0.07325020f, -0.08530112f, -0.10759081f, 0.20901217f, 
    0.05955662f, 0.13845627f, 0.17369683f, 0.03055232f, 0.01477356f, -0.23644240f, 0.04025039f, 0.15837330f, 
    -0.02580853f, -0.10084409f, 0.05418889f, 0.06524011f, -0.03893306f, -0.09875293f, 0.17226540f, 0.00345846f, 
    0.34008890f, 0.10957472f, -0.00662564f, -0.06289825f, 0.04526633f, 0.06437469f, 0.05212532f, 0.20408836f, 
    -0.00284220f, -0.17589843f, -0.02916003f, -0.14267275f, -0.02664495f, 0.18563809f, -0.06498804f, -0.13822252f, 
    -0.04028156f, -0.01509162f, 0.03366412f, 0.03098294f, 0.03504212f, -0.02838572f, -0.12092096f, -0.09910553f, 
    -0.15799990f, 0.08671857f, 0.05158487f, 0.05017566f, -0.08134159f, 0.04471141f, -0.01136211f, -0.05269941f, 
    -0.02771805f, -0.03694455f, -0.12956147f, -0.20401897f, -0.05349575f, 0.23646325f, -0.06838160f, -0.08176182f, 
    0.07544205f, 0.05714087f, -0.04900447f, -0.09023627f, -0.02741693f, -0.06019477f, 0.00358193f, -0.16743025f, 
    0.35229641f, -0.14164765f, 0.02388714f, 0.07731787f, -0.05048579f, -0.04854890f, -0.06590322f, -0.01481468f, 
    -0.10825261f, -0.04588503f, -0.04445017f, -0.06358553f, -0.05689731f, -0.06767733f, 0.13930640f, -0.00424372f, 
    0.00961287f, 0.07189494f, 0.12850004f, 0.03594774f, 0.10976722f, 0.06588706f, -0.08356373f, -0.06723454f, 
    0.31754264f, -0.06319675f, 0.16214013f, -0.05037690f, 0.03317690f, -0.02440790f, -0.05172341f, -0.00323843f, 
    -0.04161604f, 0.05162114f, -0.13943805f, 0.00452875f, 0.02529165f, 0.18225206f, 0.06003369f, -0.06884837f, 
    -0.15216155f, 0.04128868f, 0.10380932f, 0.08243183f, 0.05856263f, -0.08282739f, 0.11370262f, -0.12543610f, 
    -0.23938783f, 0.06346285f, 0.14568849f, 0.00180593f, 0.07858356f, -0.14850582f, -0.06429790f, 0.00546662f, 
    -0.14043027f, -0.07320439f, -0.01646051f, -0.07173348f, -0.19111183f, -0.10906849f, -0.04351987f, -0.15800659f, 
    0.05177230f, 0.12291817f, -0.12066992f, 0.07843504f, -0.01785855f, -0.04577925f, -0.04562433f, -0.00916581f, 
    -0.12533274f, 0.26204300f, -0.09298898f, -0.07968467f, 0.08260171f, 0.00770138f, 0.10369363f, -0.12487352f, 
    -0.03556706f, 0.00971803f, 0.07033246f, -0.07177251f, -0.13393755f, 0.25890833f, -0.05519987f, -0.04999780f, 
    0.01590388f, -0.02163903f, -0.19885531f, 0.06085142f, -0.08289764f, -0.05670810f, 0.06771452f, 0.11279419f, 
    0.32526281f, 0.11572479f, 0.19625589f, -0.00233141f, -0.04106067f, 0.06319011f, -0.13554992f, -0.08232187f, 
    0.04787889f, 0.09291980f, -0.04744273f, 0.04933503f, -0.19883013f, -0.16989706f, -0.00646331f, -0.07009246f, 
    -0.02074135f, 0.26464963f, -0.09204360f, -0.01974463f, -0.14305159f, 0.02475884f, -0.08632341f, -0.11541086f, 
    0.08065870f, 0.06644939f, -0.07231691f, -0.00237421f, 0.01499427f, 0.07626081f, -0.08711479f, -0.01929750f, 
    0.05701968f, 0.08734298f, 0.16336036f, 0.02561489f, 0.10401151f, 0.10590629f, 0.03538101f, -0.05128070f, 
    -0.06562643f, -0.13960062f, -0.00179673f, 0.08585496f, 0.02185665f, 0.12032823f, 0.14132331f, 0.16161983f, 
    -0.08936758f, 0.14047013f, 0.09885482f, 0.17324297f, -0.02509643f, -0.12731844f, 0.04663257f, 0.15313488f, 
    -0.02640537f, 0.01341598f, 0.16002643f, 0.11681002f, 0.01540693f, 0.10718153f, -0.11811540f, 0.19798301f, 
    -0.08780035f, -0.10229094f, -0.04627004f, -0.01337953f, 0.01965905f, 0.04284034f, 0.15846030f, -0.01342217f, 
    -0.04907420f, 0.01203810f, 0.03769274f, 0.08436568f, 0.11587204f, 0.01060260f, 0.02816597f, 0.10711706f, 
    -0.04883973f, 0.05651908f, -0.08842818f, -0.06807957f, -0.03878548f, -0.17057402f, 0.07419179f, 0.17231625f, 
    0.01986117f, 0.03091731f, 0.00756121f, 0.06079309f, 0.13863985f, -0.04245218f, -0.12533394f, -0.09679904f, 
    0.00513042f, -0.05412739f, 0.20490724f, -0.04061779f, 0.01122633f, -0.18625617f, 0.06971691f, 0.13461617f, 
    -0.05467364f, 0.14182343f, -0.17034866f, 0.08882724f, -0.10827459f, 0.18268983f, 0.12129364f, -0.03150530f, 
    0.11105635f, -0.02857644f, -0.05279498f, 0.10326120f, 0.00673277f, 0.25509229f, -0.22523765f, 0.05161659f, 
    -0.04048033f, 0.00556581f, 0.03955447f, 0.02452998f, 0.03795759f, 0.00715876f, -0.00911032f, 0.01710013f, 
    0.00349077f, -0.01737689f, -0.02909029f, -0.05022230f, 0.02266074f, -0.04998778f, -0.03154340f, 0.03557155f, 
    0.01928592f, -0.04951251f, 0.02981165f, -0.01343286f, 0.00199524f, -0.03199224f, -0.01243630f, -0.00575022f, 
    -0.01531047f, -0.03371028f, 0.00226116f, 0.02858382f, -0.03346163f, -0.01262138f, -0.03242584f, -0.03044378f, 
    -0.03339945f, 0.00035123f, 0.01757861f, -0.05259684f, 0.04921779f, -0.02123754f, -0.00836625f, -0.02932145f, 
    -0.03591222f, 0.02341216f, -0.03407195f, -0.01855997f, -0.02729139f, -0.01527721f, 0.00693932f, 0.01386906f, 
    -0.02632350f, 0.04404875f, -0.03445537f, 0.03535872f, -0.05368215f, -0.00848132f, 0.04174181f, -0.03356228f, 
    0.00778177f, -0.05220966f, 0.00471646f, 0.02500603f, -0.01296430f, 0.01627566f, 0.01145125f, 0.02405079f, 
    0.05309294f, -0.04851559f, 0.02838699f, -0.05400117f, -0.01472643f, 0.03775181f, -0.02926134f, -0.00478764f, 
    0.05165842f, 0.04220572f, 0.00224502f, -0.03656515f, 0.01906811f, 0.03111451f, -0.00597969f, -0.00654568f, 
    0.02977746f, 0.03651981f, -0.01920449f, 0.01673144f, -0.03140989f, 0.02916719f, -0.01981175f, 0.01121500f, 
    -0.02184965f, -0.02090379f, -0.01939769f, 0.01935669f, 0.04721915f, 0.04733951f, 0.02596458f, -0.03065676f, 
    -0.00827198f, -0.02994864f, 0.02035178f, -0.03520133f, -0.00215650f, -0.00590650f, -0.02415762f, 0.03641215f, 
    -0.04946353f, -0.03943712f, -0.03097996f, -0.01023695f, 0.03367282f, -0.02641284f, -0.05352917f, 0.01340156f, 
    0.02547441f, -0.02904155f, 0.03504584f, 0.04246825f, 0.01343244f, -0.04891941f, 0.01628209f, 0.00083924f, 
    0.02313203f, -0.04675946f, -0.00619541f, -0.03454562f, -0.03945607f, 0.01654251f, 0.03573053f, 0.03653283f, 
    -0.01114515f, 0.01660900f, 0.02835591f, 0.02779032f, -0.02423911f, -0.03106567f, 0.01219272f, -0.03272744f, 
    -0.05144009f, -0.00681075f, 0.00731735f, -0.00127066f, 0.00238871f, -0.02962805f, -0.02154131f, 0.03689545f, 
    -0.00492683f, 0.03338921f, 0.01281546f, -0.01510512f, 0.00146407f, 0.01381293f, -0.04835812f, 0.00329108f, 
    -0.01040927f, 0.01551772f, 0.02893468f, -0.03408531f, -0.02037858f, -0.03410313f, 0.04131680f, -0.01605227f, 
    -0.00553413f, 0.02728399f, -0.04562955f, -0.03089340f, -0.01163949f, 0.03244031f, 0.03901673f, -0.04938772f, 
    0.03508799f, 0.00036885f, -0.03545211f, 0.04212841f, 0.00324281f, 0.03080267f, 0.00092581f, -0.00992580f, 
    -0.00752132f, -0.01625018f, -0.02999302f, -0.01288696f, -0.01329884f, -0.02363461f, -0.02565254f, -0.05630799f, 
    0.02318064f, -0.05041926f, -0.00069403f, 0.02640324f, -0.03444491f, -0.03560649f, -0.05142325f, 0.01789541f, 
    0.02758631f, -0.02656894f, -0.04901488f, 0.02512700f, 0.02593601f, -0.05017955f, -0.02157659f, -0.02034112f, 
    -0.04349949f, -0.00707677f, -0.04536405f, -0.01135626f, -0.01102650f, -0.05373748f, 0.02108189f, -0.01883419f, 
    0.02936172f, -0.01850344f, 0.00185240f, 0.03480519f, 0.02715887f, 0.01278282f, 0.03295400f, 0.01339986f, 
    0.00896482f, 0.00574812f, 0.02038475f, 0.02699443f, -0.00289175f, -0.00798770f, 0.01586579f, 0.00430871f, 
    -0.01401280f, -0.04383082f, -0.03200269f, -0.01485279f, 0.02161186f, 0.01358167f, -0.04633116f, -0.00449518f, 
    0.02114171f, 0.00946216f, 0.00979887f, 0.00772072f, 0.00439002f, 0.01510114f, -0.02938505f, -0.04173484f, 
    0.04383085f, -0.01895140f, 0.03347057f, -0.01198158f, 0.00467166f, 0.04046159f, -0.03033160f, -0.03295732f, 
    -0.01807647f, -0.00949190f, -0.00576403f, -0.00907865f, -0.00130516f, -0.03690402f, -0.04153896f, -0.03965367f, 
    -0.05183248f, 0.03669383f, -0.00258585f, -0.04521941f, -0.01166228f, -0.02543254f, -0.05698900f, -0.01983684f, 
    0.01916108f, 0.00697124f, 0.03838195f, 0.02789944f, 0.03913553f, -0.00129656f, 0.03328130f, -0.04224933f, 
    -0.05039602f, -0.04338554f, 0.04010371f, 0.02380296f, -0.02122778f, -0.01292196f, -0.00592465f, -0.04766738f, 
    -0.03259345f, 0.02781702f, -0.04878599f, 0.03347452f, -0.04465219f, 0.01476087f, -0.03429427f, -0.02408011f, 
    0.05139269f, -0.00051436f, 0.00289493f, 0.00574052f, 0.02698743f, -0.03921159f, -0.03572154f, -0.04781914f, 
    0.00436869f, 0.02017910f, -0.03069070f, -0.00390296f, 0.01504388f, 0.01338712f, -0.03896532f, 0.01747487f, 
    0.00954541f, -0.00400308f, 0.00762771f, 0.02398436f, -0.04278919f, 0.01854766f, -0.00834331f, 0.03824383f, 
    0.02179876f, -0.00418193f, 0.03376263f, 0.01082845f, -0.00708694f, -0.04187090f, -0.00691856f, 0.03374858f, 
    0.02637676f, 0.01456461f, -0.02480945f, -0.03758249f, 0.00579383f, 0.00052597f, 0.02645725f, -0.05250569f, 
    -0.04278121f, 0.00028075f, 0.01236967f, -0.04084489f, -0.00666340f, -0.00241664f, -0.02638829f, -0.03918890f, 
    -0.00844529f, -0.02163171f, 0.02508772f, 0.01602560f, -0.04124180f, -0.00574265f, 0.03496050f, -0.05361246f, 
    0.01095284f, -0.05547732f, -0.00910438f, -0.03936947f, 0.02829027f, -0.00339859f, -0.05353056f, -0.01900975f, 
    -0.00609650f, -0.02514402f, -0.05105197f, 0.00227405f, -0.01861926f, -0.01003742f, 0.01131288f, -0.00999820f, 
    0.00632149f, -0.03084892f, -0.00453684f, 0.00103560f, 0.01972694f, -0.03482236f, -0.00305915f, -0.00422505f, 
    0.00109511f, -0.02934952f, -0.02604396f, 0.01110723f, 0.03773122f, 0.03579047f, -0.03153692f, 0.03523809f, 
    -0.00339469f, 0.03507074f, -0.05677595f, -0.04354275f, -0.01465795f, 0.03336700f, -0.00168978f, -0.04961957f, 
    0.11158158f, 0.04387639f, -0.05145644f, 0.09601659f, -0.06200658f, -0.03819702f, 0.05256449f, -0.11727536f, 
    0.02746320f, 0.06297040f, 0.00364086f, -0.01909819f, -0.31197014f, -0.02925491f, 0.12185581f, 0.08341188f, 
    -0.04357520f, -0.08342148f, -0.04637731f, 0.02407575f, 0.02529815f, 0.03988894f, 0.01297208f, -0.08478023f, 
    0.05153043f, -0.20770507f, 0.07608439f, -0.06690975f, -0.07914650f, -0.04540508f, -0.03199894f, -0.11584619f, 
    -0.02963020f, 0.08905707f, 0.02067932f, 0.01933080f, -0.04636699f, -0.12316394f, -0.22351176f, 0.19771618f, 
    -0.12182835f, 0.04690978f, 0.10232618f, -0.04141745f, 0.05693297f, 0.06563493f, 0.01679707f, 0.05421730f, 
    0.16583759f, 0.05651688f, -0.00289638f, 0.17791787f, -0.14342883f, -0.04588831f, -0.03123090f, 0.04773325f, 
    -0.01771130f, 0.02308783f, -0.04897650f, 0.06581449f, -0.33642513f, 0.26721257f, -0.11961290f, 0.11912298f, 
    0.03155190f, 0.13055483f, 0.22181539f, 0.02124071f, 0.02336149f, -0.07956601f, -0.01892770f, 0.05153555f, 
    -0.15126219f, 0.06000976f, 0.17478845f, 0.25526407f, 0.15078685f, -0.06125502f, -0.10947271f, -0.01273572f, 
    -0.06983179f, 0.06348216f, 0.09562162f, 0.07722267f, 0.31368133f, -0.15032698f, 0.03061874f, -0.08387373f, 
    -0.11877554f, 0.02259932f, 0.00049357f, 0.02729492f, 0.05801997f, 0.21345294f, -0.05620038f, -0.10279363f, 
    0.15931694f, 0.25518104f, 0.04777234f, 0.13115513f, 0.19172180f, 0.03595119f, -0.01603857f, 0.10398482f, 
    0.09774549f, 0.07776781f, 0.07104014f, -0.17166594f, 0.02268394f, 0.36897221f, 0.01785809f, 0.18680473f, 
    0.07710281f, 0.02806445f, 0.17107089f, -0.00146015f, -0.04205081f, 0.07258791f, 0.19066419f, -0.00299824f, 
    0.07139946f, -0.01122390f, 0.10835068f, -0.03077021f, 0.12575470f, 0.06910750f, 0.08659869f, 0.00941307f, 
    0.04485322f, 0.10031478f, 0.08070005f, 0.05313223f, -0.16012955f, -0.08678241f, -0.06863160f, 0.18843074f, 
    0.11003943f, 0.05335043f, 0.10150898f, -0.05991948f, -0.14418221f, 0.11244616f, -0.07104148f, 0.01622627f, 
    0.13039105f, -0.35202822f, -0.07199568f, 0.27807829f, -0.06177234f, -0.02703216f, 0.04671735f, 0.05902456f, 
    -0.03347458f, 0.02624859f, -0.00143182f, 0.06972343f, 0.03006841f, -0.05902798f, 0.09839985f, -0.03064611f, 
    0.07449242f, -0.06361137f, 0.03419263f, -0.07082437f, 0.03848070f, -0.04946414f, -0.00455124f, -0.00878881f, 
    -0.09504142f, 0.29344568f, -0.16625316f, 0.10311442f, 0.06512458f, 0.08087690f, -0.08418872f, -0.02817735f, 
    -0.08805801f, -0.03548653f, -0.00977462f, 0.04746900f, -0.13784325f, -0.12385699f, -0.17679398f, 0.24390529f, 
    0.11231623f, 0.02185937f, 0.08731923f, -0.09238048f, 0.04012403f, -0.00728291f, 0.02407829f, -0.12342013f, 
    -0.10953783f, 0.27361554f, 0.24997461f, -0.14598322f, 0.04229236f, -0.11777425f, -0.08376260f, 0.02006555f, 
    0.01534800f, 0.04063073f, 0.02729508f, -0.02700023f, 0.04805992f, 0.21497434f, 0.04474922f, -0.03114678f, 
    -0.05337721f, 0.10010042f, 0.05219902f, 0.06797054f, -0.07332934f, 0.08224647f, 0.05059259f, 0.03324918f, 
    0.02539398f, -0.04819211f, 0.13243090f, -0.07856178f, 0.05983625f, -0.01817206f, 0.03525985f, 0.07999234f, 
    -0.02076098f, -0.03191689f, 0.05326557f, -0.00941200f, 0.13214265f, -0.13972391f, 0.02101554f, 0.04460713f, 
    -0.09706295f, -0.05487442f, 0.04376708f, 0.07419327f, 0.00408406f, -0.00726752f, -0.08429763f, 0.00291649f, 
    0.15957107f, -0.37504381f, -0.08002442f, -0.03515229f, -0.02407471f, -0.04772939f, 0.02586946f, -0.10675580f, 
    0.04936774f, 0.01006166f, -0.06429257f, -0.13147900f, 0.28193089f, -0.04392896f, 0.18260799f, 0.35307425f, 
    0.11494559f, -0.08865591f, -0.03738233f, 0.05300499f, -0.06549410f, -0.02936431f, 0.00937313f, 0.06638226f, 
    -0.07862967f, 0.35569328f, -0.03274975f, 0.14926697f, 0.10048812f, 0.09138482f, -0.16410370f, 0.19413263f, 
    0.07272551f, -0.03990654f, -0.05016694f, 0.03098295f, 0.37037405f, -0.21796092f, -0.08731057f, -0.20179532f, 
    -0.11097019f, 0.02032373f, -0.00274616f, 0.08770120f, 0.10466669f, 0.09311689f, 0.07875706f, 0.11411233f, 
    0.06719264f, -0.06078125f, 0.02699335f, -0.02292557f, 0.03516721f, 0.03334631f, -0.03068926f, -0.02646042f, 
    -0.04534539f, -0.03348088f, 0.09188855f, -0.05477620f, 0.17634781f, 0.04344073f, 0.02704084f, 0.04480258f, 
    0.04110446f, -0.01636191f, 0.03657391f, -0.06480266f, 0.05128613f, 0.05808786f, 0.09159853f, -0.00132717f, 
    0.22881089f, -0.22868159f, -0.09340383f, -0.15197302f, 0.05672171f, -0.03930458f, 0.07187560f, 0.14864247f, 
    -0.03840338f, 0.08423992f, 0.04609093f, -0.02027894f, 0.10079919f, 0.05906312f, -0.12864015f, 0.03494161f, 
    -0.02693889f, -0.01300918f, -0.06101698f, 0.04703963f, 0.02346647f, 0.13621430f, -0.01501085f, -0.08563844f, 
    -0.03150834f, 0.05967521f, 0.10994917f, 0.00588036f, 0.06435501f, -0.08133972f, 0.13947922f, 0.03558040f, 
    -0.02518681f, 0.13431795f, -0.09157006f, 0.01554489f, -0.08163856f, -0.22054800f, -0.05636991f, 0.12145861f, 
    -0.00584687f, 0.03987850f, -0.03180261f, 0.20934421f, 0.06381751f, 0.04636222f, -0.06141442f, 0.09100197f, 
    0.42130175f, -0.03843679f, 0.05160244f, 0.05779535f, 0.03499329f, 0.02819814f, 0.02335067f, 0.08690680f, 
    0.05007634f, 0.07063777f, 0.01481556f, -0.00386440f, -0.05791094f, 0.01323406f, 0.07561486f, 0.15979786f, 
    0.07088322f, 0.02903023f, 0.00532112f, 0.12579222f, 0.05501267f, 0.06575301f, -0.06177195f, 0.00884837f, 
    0.10557172f, -0.05883645f, 0.20213328f, -0.19010329f, 0.07887695f, 0.13377321f, -0.04232560f, 0.07824740f, 
    -0.02858141f, 0.15082110f, 0.06678035f, -0.00130132f, -0.00238616f, -0.08728976f, 0.08481746f, -0.07235140f, 
    -0.07601298f, -0.03561093f, 0.15160058f, -0.03044511f, -0.01545956f, -0.08125261f, -0.19232725f, 0.08866455f, 
    0.22241390f, -0.21630625f, -0.04497952f, -0.10699718f, -0.15466826f, -0.05893452f, -0.12065581f, -0.04729634f, 
    -0.02669789f, -0.12989718f, -0.01458841f, -0.04166777f, 0.13242735f, 0.06980333f, 0.17847154f, -0.09537762f, 
    -0.10877813f, 0.00744543f, -0.06159659f, 0.14009687f, 0.06473826f, 0.02258797f, -0.03418577f, -0.11394554f, 
    -0.06792185f, -0.15281999f, -0.08975200f, 0.23731720f, -0.03074363f, -0.01067416f, 0.09239540f, 0.04194091f, 
    -0.11478769f, 0.09058213f, -0.11786724f, 0.14659186f, -0.01692079f, 0.12865864f, 0.08931199f, -0.20837188f, 
    -0.07903856f, -0.05724913f, -0.04042843f, -0.07537010f, 0.02370889f, 0.06572456f, 0.02387349f, 0.02302967f, 
    0.06645320f, 0.19858040f, -0.04399375f, -0.05983609f, -0.02389790f, 0.13749644f, 0.13396527f, 0.20620476f, 
    -0.00561121f, -0.02302172f, -0.04762943f, -0.18747990f, 0.19205463f, 0.20424426f, 0.14326327f, 0.07140893f, 
    0.08344924f, -0.01700826f, -0.09241107f, -0.12504910f, -0.09959898f, -0.07583746f, -0.06414265f, 0.01941063f, 
    -0.09923380f, -0.04707859f, -0.20194146f, -0.11517477f, 0.02995282f, -0.02007182f, 0.02300680f, -0.28601238f, 
    0.07313345f, -0.07885129f, -0.08728504f, 0.07673831f, 0.01895579f, 0.07421010f, -0.20255223f, -0.12419268f, 
    0.08071987f, 0.14616355f, -0.08143065f, -0.05563707f, 0.14040881f, 0.16804431f, -0.03532488f, 0.02147590f, 
    -0.47451341f, 0.01187751f, 0.10517791f, 0.17744604f, 0.07749497f, -0.10674351f, 0.05961504f, -0.07894971f, 
    -0.01685917f, 0.00893034f, -0.05142691f, -0.00226548f, 0.02728754f, -0.00507292f, 0.17942676f, -0.05113366f, 
    -0.01727972f, 0.02016147f, 0.05432044f, 0.03876042f, -0.17243987f, -0.10595471f, 0.22181562f, 0.04552543f, 
    -0.05269339f, 0.06073657f, 0.09381008f, -0.05167617f, 0.09572891f, 0.09120055f, 0.09599508f, 0.07466111f, 
    0.03219706f, 0.06920139f, 0.11160358f, 0.15312737f, 0.04124218f, -0.04273971f, 0.08313743f, -0.00843936f, 
    0.02717819f, -0.04836898f, 0.05583189f, 0.01080360f, -0.01134241f, 0.06027809f, 0.06272522f, 0.15345104f, 
    -0.11463741f, -0.12239569f, 0.03313069f, -0.08816501f, 0.07355351f, -0.00258234f, 0.10174087f, -0.04174449f, 
    0.08129050f, 0.02976101f, 0.04451257f, 0.11709515f, 0.05856624f, 0.05309954f, 0.12265206f, -0.46244994f, 
    0.00415535f, 0.00217419f, 0.03017694f, 0.03366829f, -0.02516160f, -0.12138452f, -0.00888680f, 0.06409802f, 
    -0.29778501f, -0.05446438f, -0.18613569f, -0.06616065f, 0.04208002f, 0.06828622f, -0.03309324f, -0.03136969f, 
    0.03920034f, 0.09881965f, 0.03006802f, -0.12007116f, 0.00165760f, -0.13384683f, 0.02925654f, 0.12438022f, 
    0.08240775f, 0.02390991f, 0.06047166f, -0.09489676f, 0.01136844f, 0.08337323f, -0.06002598f, 0.09378018f, 
    0.04081167f, -0.17499483f, -0.01314143f, -0.02667266f, -0.15509050f, 0.22502621f, 0.04720555f, 0.02223458f, 
    -0.00017887f, 0.06905352f, 0.00037606f, 0.11009231f, 0.07732619f, -0.09382677f, 0.00964535f, 0.19102861f, 
    -0.08298334f, -0.04379252f, 0.04892636f, 0.06099235f, -0.18767957f, -0.02594893f, 0.07823694f, -0.05999133f, 
    -0.20850547f, 0.03680643f, 0.14154612f, 0.22052202f, -0.09837488f, -0.04356564f, -0.04292603f, 0.10578793f, 
    -0.08766723f, -0.10109481f, -0.21444859f, 0.03031435f, -0.08422053f, 0.00521651f, -0.09646556f, 0.03524348f, 
    -0.01353426f, 0.11783464f, 0.24806733f, -0.03592653f, 0.07098052f, 0.07655068f, 0.00380411f, -0.00327768f, 
    -0.39932203f, -0.09722073f, -0.23345001f, -0.02269861f, 0.12934963f, -0.09212332f, 0.12892911f, 0.04347549f, 
    0.03109864f, 0.06961071f, 0.11021251f, 0.00092130f, 0.12264738f, 0.05614135f, -0.06433768f, 0.05463841f, 
    -0.00933955f, -0.08907466f, 0.12417851f, 0.14769897f, 0.07246569f, -0.06265192f, 0.03014821f, -0.01504345f, 
    -0.08041061f, 0.09251989f, 0.08494516f, 0.10013675f, 0.04936096f, -0.09892138f, 0.08874981f, 0.08791479f, 
    -0.05345184f, -0.02365247f, -0.10270381f, -0.01276867f, 0.08490621f, -0.16387594f, 0.17975247f, 0.11915250f, 
    0.16260514f, 0.08726519f, 0.05401138f, -0.03580495f, -0.07961768f, -0.16782172f, -0.12344927f, -0.18377978f, 
    0.11523764f, 0.05174474f, -0.09923185f, 0.12864099f, 0.06104049f, 0.14380953f, 0.06184516f, -0.02429929f, 
    0.04215362f, -0.02321171f, -0.31367961f, -0.10008807f, 0.07848164f, -0.09378894f, -0.05166107f, 0.00439632f, 
    0.12995987f, 0.10564866f, 0.05013466f, 0.04053387f, 0.05625445f, 0.08224708f, -0.13045989f, 0.05135916f, 
    0.15626830f, -0.03635074f, 0.13951109f, 0.18492782f, 0.04578722f, 0.03314667f, -0.01436533f, 0.09153118f, 
    0.11511536f, -0.07542583f, 0.01436105f, 0.10358282f, 0.08859266f, 0.12463247f, 0.08895249f, -0.25160500f, 
    0.10043939f, 0.09563757f, 0.09950597f, -0.05491740f, 0.00061431f, -0.03972808f, 0.11578691f, 0.04521839f, 
    -0.02416626f, 0.09480492f, -0.03714516f, 0.02450258f, 0.00360862f, 0.15781100f, -0.05447879f, -0.01060863f, 
    -0.10691863f, -0.10538059f, 0.17875487f, -0.09195001f, -0.04981211f, 0.01464316f, -0.06334493f, 0.18874343f, 
    0.04070100f, 0.13590531f, 0.06445898f, 0.06300522f, -0.03852539f, -0.05069403f, 0.25424659f, -0.09771134f, 
    -0.03012916f, -0.03926165f, -0.00704163f, -0.00671347f, 0.02969623f, 0.02826623f, -0.00715415f, 0.00662957f, 
    -0.04291985f, 0.00449756f, 0.00742916f, -0.00685710f, -0.00957651f, 0.03628252f, 0.01112352f, 0.03438834f, 
    -0.02202018f, -0.04225089f, -0.05760043f, 0.03713418f, -0.03594954f, 0.04034841f, 0.03027144f, -0.03194001f, 
    0.02691976f, -0.00727287f, 0.02343126f, 0.01623142f, 0.00988136f, 0.00792135f, 0.01601789f, -0.04425125f, 
    0.04089061f, -0.01007089f, -0.03484190f, 0.03455429f, 0.00615457f, -0.02143217f, -0.04232373f, 0.02122156f, 
    -0.01142380f, 0.00751861f, 0.00493439f, -0.00199349f, 0.03397831f, -0.01199774f, -0.03235453f, 0.00915381f, 
    -0.04667060f, 0.02093197f, -0.03637337f, -0.04810912f, -0.02498803f, -0.02374233f, -0.05405284f, 0.02191800f, 
    -0.05083628f, 0.01752822f, -0.00722353f, -0.01218705f, 0.01345507f, 0.00798253f, -0.00564447f, -0.02556048f, 
    0.04530988f, -0.04841058f, -0.04769597f, 0.03950796f, -0.01423330f, -0.05155271f, -0.00397869f, -0.05003319f, 
    0.00566547f, 0.00856650f, -0.02987725f, -0.04991785f, -0.02827803f, 0.01073810f, 0.00348158f, -0.01337768f, 
    -0.03667239f, 0.02346688f, 0.00716480f, 0.01673158f, -0.01375570f, 0.03499633f, -0.03854894f, -0.04494071f, 
    0.01687528f, 0.03815341f, 0.00474581f, -0.02443844f, 0.00301791f, 0.01363758f, -0.02678006f, 0.00706012f, 
    0.03597622f, -0.00406177f, -0.04045394f, -0.04307789f, -0.05721880f, -0.04038747f, -0.02238981f, -0.01314557f, 
    0.00725176f, -0.02580709f, -0.02935799f, -0.04999652f, -0.00489619f, 0.00545055f, -0.04897629f, 0.03095916f, 
    -0.04780794f, -0.03485855f, 0.01530263f, 0.01353607f, 0.00279962f, -0.02678639f, 0.02408801f, -0.04070439f, 
    0.03341263f, -0.03590357f, -0.03419039f, 0.01537810f, -0.04679072f, 0.00085050f, 0.00407483f, -0.01802029f, 
    0.01270550f, -0.03570465f, -0.05294060f, -0.00298808f, -0.05299162f, -0.04820953f, 0.02395528f, 0.03639884f, 
    0.03458130f, 0.03335118f, -0.04904287f, -0.04819149f, -0.00688875f, -0.02334482f, -0.01102090f, -0.03748388f, 
    0.01357710f, -0.03211907f, -0.04532769f, 0.03366871f, 0.02159046f, -0.01537152f, 0.03863640f, 0.00955374f, 
    0.03943893f, 0.03282338f, -0.01138300f, 0.04050114f, -0.04257013f, 0.00938802f, -0.02759388f, -0.01469869f, 
    -0.04034133f, 0.01786849f, -0.01082698f, -0.05621075f, 0.03001688f, -0.04212536f, 0.02260815f, -0.00825168f, 
    -0.06047889f, -0.01587374f, -0.04302610f, -0.02630869f, 0.01935803f, -0.01145771f, -0.03797497f, -0.03254919f, 
    -0.00192503f, 0.01409241f, -0.00848976f, 0.02387553f, 0.01401931f, 0.03451037f, -0.02889533f, -0.03712636f, 
    -0.02886867f, -0.00991119f, -0.03455243f, 0.03522279f, -0.00376782f, 0.00663228f, 0.01811622f, -0.01367114f, 
    0.02334094f, 0.02534601f, -0.04104315f, -0.00769300f, 0.03661000f, 0.00312873f, -0.00276426f, 0.02183561f, 
    -0.04819981f, -0.01311033f, -0.02108106f, 0.03989321f, -0.00498949f, -0.04570261f, -0.00027257f, -0.00848163f, 
    0.01224409f, -0.05373261f, -0.04220105f, 0.01647520f, 0.00109295f, -0.05353450f, -0.00199544f, -0.01228663f, 
    -0.01888558f, 0.01958944f, 0.02630826f, -0.03578349f, -0.00869501f, -0.04922321f, 0.03336118f, -0.05020459f, 
    0.03921917f, -0.05197637f, -0.01730676f, -0.02298249f, -0.00389030f, -0.03334816f, -0.00771133f, -0.03985038f, 
    -0.03535290f, 0.01032963f, -0.02676216f, -0.05212570f, -0.03258510f, 0.00082132f, -0.00532670f, -0.02997051f, 
    -0.00134763f, -0.01239520f, -0.02840143f, -0.00500661f, 0.02065551f, -0.02167518f, -0.03842152f, -0.01753341f, 
    -0.00210222f, 0.02182524f, 0.03415571f, -0.03352557f, 0.01240483f, 0.00674880f, -0.01151510f, -0.04085341f, 
    -0.03910901f, 0.01132788f, -0.03645537f, -0.00070990f, 0.04095894f, -0.04444775f, 0.01901688f, -0.01004723f, 
    0.01663965f, -0.02651970f, -0.05865329f, 0.00126852f, -0.03892444f, 0.01123697f, -0.03322757f, 0.00508991f, 
    0.03023790f, -0.03617578f, 0.03030944f, -0.03415634f, 0.03181552f, -0.01633673f, -0.00039038f, 0.01644292f, 
    -0.02484399f, -0.04037568f, 0.02932702f, 0.04177486f, -0.01144437f, -0.05178441f, 0.03123215f, 0.00297059f, 
    -0.03521512f, 0.01571698f, -0.00794262f, 0.04135745f, -0.04636145f, 0.01434740f, 0.02256445f, 0.01112656f, 
    0.00583825f, -0.02206267f, -0.03084191f, 0.02485947f, 0.00289307f, -0.02284600f, -0.01590960f, -0.04361795f, 
    -0.04698498f, 0.02103466f, 0.01069301f, -0.02743632f, 0.03111750f, 0.03290526f, 0.02285828f, -0.00257443f, 
    0.02734047f, 0.04350024f, -0.03167688f, -0.05489299f, -0.03412083f, -0.00289808f, 0.01168940f, -0.03864523f, 
    -0.03011027f, -0.05592237f, -0.02553151f, 0.00698787f, -0.04536787f, -0.03259731f, -0.02046140f, -0.01800236f, 
    -0.00978037f, 0.03091544f, 0.00407558f, -0.04210230f, 0.03795959f, -0.01213082f, -0.01515008f, -0.00434784f, 
    -0.01174027f, 0.01038775f, -0.01181678f, -0.01968051f, 0.03931642f, 0.00617007f, -0.01535039f, -0.05586426f, 
    0.02220525f, -0.02350010f, 0.02008540f, -0.03556104f, 0.02177891f, 0.03401558f, -0.01178932f, -0.04616214f, 
    -0.03289805f, -0.02450009f, -0.04612033f, -0.04139358f, 0.03144874f, 0.01118493f, -0.02696223f, -0.03111248f, 
    0.02033287f, 0.03617328f, -0.05568504f, 0.03193535f, -0.03885824f, -0.02003500f, -0.01390449f, -0.00131514f, 
    0.01215366f, -0.00232178f, -0.02472754f, -0.04722049f, -0.01883083f, -0.04649574f, -0.01453878f, 0.03062971f, 
    0.01016181f, 0.03189285f, 0.00478680f, -0.00058371f, -0.04817336f, -0.00209569f, 0.00804008f, -0.02031346f, 
    0.12148993f, -0.22047769f, -0.00282184f, -0.11961272f, -0.08319646f, 0.02227555f, 0.21603724f, -0.01484456f, 
    0.01674711f, 0.02665974f, 0.15757532f, 0.07768787f, -0.17703964f, -0.02641823f, 0.19145511f, 0.04590128f, 
    0.16076998f, -0.03475897f, 0.06992983f, 0.08616237f, 0.03215130f, 0.03592099f, 0.04609898f, 0.14073645f, 
    -0.23260224f, -0.02881906f, -0.12404691f, -0.05961583f, 0.09793137f, 0.17646702f, -0.00520256f, -0.11339197f, 
    0.05922418f, 0.12968968f, 0.09334251f, 0.06495457f, 0.06717809f, 0.00602973f, 0.13022372f, -0.02900274f, 
    0.00075321f, 0.00585380f, -0.00348257f, 0.01740973f, -0.07751036f, 0.01810155f, -0.02898442f, 0.13128081f, 
    -0.02217873f, 0.06665464f, -0.13965195f, 0.05971551f, 0.17002840f, 0.09782322f, -0.00611251f, 0.07022850f, 
    0.00961578f, -0.14751761f, -0.04202924f, -0.01627629f, -0.04865243f, 0.31762737f, -0.03090517f, 0.22244930f, 
    -0.01150963f, 0.08281157f, 0.07469811f, 0.05419149f, 0.02818755f, -0.05567883f, 0.04825731f, 0.12157366f, 
    -0.12145019f, 0.06714010f, -0.00394035f, -0.10717813f, -0.03077849f, -0.02035525f, 0.07965644f, 0.04321799f, 
    -0.09688578f, 0.07499065f, 0.07284728f, 0.03061499f, -0.31558171f, 0.05049852f, -0.02503130f, -0.01264979f, 
    -0.06257094f, 0.15641978f, 0.08380204f, 0.17253964f, 0.08715423f, 0.02848636f, 0.10694640f, 0.04078393f, 
    0.00308549f, -0.07567753f, -0.18071990f, -0.10531830f, -0.02374327f, 0.02278640f, 0.04682428f, 0.04809650f, 
    -0.01149299f, 0.09569856f, 0.13347542f, 0.07090241f, -0.26012942f, -0.07324375f, -0.17095011f, -0.14132577f, 
    0.07724990f, -0.02362158f, 0.10759322f, 0.00291531f, 0.02901742f, 0.01603257f, 0.00826914f, 0.18261993f, 
    0.27137694f, -0.11722814f, 0.16570485f, 0.02957453f, 0.01602799f, 0.06421627f, 0.03375829f, 0.11297565f, 
    0.05966131f, -0.13829377f, -0.06062158f, 0.05648192f, 0.31673211f, 0.00197224f, -0.03576028f, -0.12907371f, 
    0.06464126f, 0.09520004f, 0.09348187f, -0.00428911f, 0.08714186f, -0.06084105f, -0.03214396f, 0.12260148f, 
    -0.12968463f, 0.24828471f, 0.03217155f, -0.16439368f, 0.01141245f, -0.01874584f, -0.02451870f, 0.12918168f, 
    0.11486331f, 0.08316515f, -0.10178067f, 0.03555841f, 0.18200442f, 0.29211670f, 0.17867878f, 0.02591171f, 
    -0.00312138f, 0.02931907f, 0.05132987f, 0.07064746f, 0.03236041f, 0.09089430f, -0.03797038f, 0.06586576f, 
    -0.02279595f, -0.00828909f, -0.09804506f, 0.04712818f, 0.21311714f, -0.13278402f, 0.12932011f, 0.14099793f, 
    0.12796408f, -0.02976451f, -0.04532799f, 0.02813039f, 0.12434117f, 0.10472293f, 0.02912129f, -0.06860408f, 
    -0.15177605f, 0.07028974f, 0.14678442f, 0.14125481f, 0.14166455f, 0.02910182f, 0.01975170f, 0.08500061f, 
    -0.26202109f, -0.05351844f, -0.01646975f, -0.07583828f, 0.00337074f, -0.04744889f, 0.08300207f, 0.06832813f, 
    0.06021751f, -0.04616710f, -0.13412428f, 0.15707874f, 0.34309652f, 0.10154889f, 0.28707224f, -0.10863710f, 
    -0.12196945f, -0.00764934f, -0.00253503f, 0.04823860f, 0.06704000f, 0.06073123f, 0.19277585f, 0.02755131f, 
    -0.11856059f, -0.10604328f, 0.14999729f, -0.09653585f, -0.03217034f, -0.09947783f, 0.01480924f, 0.11297189f, 
    0.10112184f, -0.01384408f, -0.24511200f, -0.06227761f, 0.12170465f, 0.03768050f, 0.28266576f, 0.07387001f, 
    -0.05344785f, 0.14913762f, -0.05281846f, 0.05605890f, -0.04874711f, -0.13085721f, 0.00529591f, 0.09776607f, 
    0.11525038f, 0.10270917f, 0.03684091f, -0.26314524f, -0.10232824f, 0.00798511f, -0.00269942f, 0.06581248f, 
    0.01362637f, 0.11570530f, -0.00202918f, -0.01773895f, 0.13318379f, 0.16231789f, -0.02770920f, 0.02317507f, 
    0.00632012f, -0.08105426f, 0.01552002f, 0.15193637f, 0.08937953f, -0.11368582f, 0.07440346f, 0.14834306f, 
    -0.00054772f, -0.06613082f, -0.19412260f, -0.16375026f, 0.06972343f, 0.05142178f, 0.05859259f, 0.01943341f, 
    0.02161279f, 0.02677869f, 0.03186599f, 0.05369906f, -0.19803335f, -0.05028890f, 0.13721956f, 0.03313213f, 
    0.07235087f, 0.10732813f, -0.04484945f, 0.05379057f, 0.07437127f, -0.03142109f, -0.08126651f, -0.13222368f, 
    0.23289363f, 0.01835377f, 0.11232675f, -0.09594180f, 0.07579942f, 0.11452816f, 0.05384185f, 0.12703927f, 
    -0.09883290f, 0.12715045f, 0.10602094f, 0.14266893f, -0.13098772f, -0.17654440f, 0.08903655f, -0.02725337f, 
    -0.01895481f, -0.02650776f, -0.02298583f, -0.03213438f, -0.07614658f, 0.12071648f, 0.21593194f, 0.12952851f, 
    0.03378894f, 0.05477811f, 0.10655326f, 0.08222307f, -0.03180720f, 0.14185092f, 0.00157201f, 0.05106823f, 
    0.10092140f, 0.04541597f, -0.01818345f, 0.04144279f, 0.10668582f, 0.12974556f, -0.09245850f, -0.01607441f, 
    0.00969929f, 0.02965920f, -0.07969373f, -0.00490723f, 0.07821947f, 0.09445299f, 0.05739551f, 0.14481880f, 
    -0.04859111f, -0.11444413f, -0.07918822f, 0.05081928f, 0.07222905f, 0.11815089f, 0.02802999f, 0.03143853f, 
    0.01060284f, 0.06829868f, -0.17973474f, 0.13180745f, -0.09615056f, 0.03842800f, 0.05529787f, 0.06465599f, 
    -0.01307773f, 0.02301699f, 0.05391128f, 0.12012066f, 0.11206671f, 0.14273290f, 0.09956451f, -0.05004639f, 
    0.14208773f, -0.09052946f, -0.01212695f, 0.08107252f, -0.02590716f, 0.00190129f, 0.11490653f, -0.05935907f, 
    -0.01380025f, 0.14552894f, 0.02883510f, 0.12694263f, -0.15589993f, 0.07655945f, -0.08995765f, -0.03883920f, 
    -0.06518254f, 0.04164661f, 0.03640575f, 0.00087233f, 0.15047100f, 0.10988966f, -0.09527154f, 0.18539600f, 
    -0.04240218f, 0.03161153f, -0.01554421f, -0.03315647f, 0.02907950f, 0.00961741f, -0.04414295f, -0.04509676f, 
    0.01285305f, 0.03909334f, -0.00091054f, -0.04522968f, -0.02808390f, -0.05789700f, -0.01453545f, -0.04947864f, 
    0.01415271f, 0.04535886f, -0.03053930f, 0.04331473f, 0.01455852f, -0.02866663f, -0.02790933f, -0.04981796f, 
    -0.04351148f, 0.01780912f, 0.01259031f, -0.03829168f, 0.04227438f, -0.05142576f, 0.04495320f, -0.04113146f, 
    -0.03810938f, 0.00699602f, -0.02109640f, 0.00800053f, -0.02530109f, -0.04837791f, -0.00594673f, 0.04156314f, 
    0.01018836f, 0.01772898f, -0.04435848f, 0.01290083f, -0.00347739f, -0.00371141f, 0.02347137f, 0.03474720f, 
    -0.02694912f, -0.01117491f, -0.04768895f, -0.02850410f, 0.01688711f, 0.00807486f, 0.00241856f, 0.01886014f, 
    0.01914141f, -0.03304537f, -0.00378633f, 0.02854699f, 0.04121907f, 0.04237836f, -0.01075703f, -0.03180616f, 
    -0.02564519f, 0.01716844f, -0.02678311f, 0.01161395f, -0.04266530f, 0.02594339f, -0.01632805f, 0.02464358f, 
    -0.02337691f, 0.02819822f, -0.02886508f, 0.02038000f, -0.03313231f, -0.04029497f, -0.00991882f, -0.01902694f, 
    0.04375104f, 0.01053169f, 0.02478105f, -0.05320263f, 0.00789853f, 0.01011003f, 0.02378590f, -0.03878239f, 
    -0.00025095f, -0.00742288f, -0.03242722f, -0.05507913f, -0.02330813f, -0.03323043f, -0.01776458f, -0.02347780f, 
    -0.01026049f, -0.05005254f, -0.05439426f, 0.00945806f, -0.04828734f, 0.01035070f, -0.00298090f, -0.01275760f, 
    0.01717421f, -0.01069430f, 0.04521171f, -0.05024642f, -0.03233785f, 0.02953464f, -0.01152876f, 0.02546361f, 
    0.03774036f, 0.00460338f, 0.01274149f, -0.02760562f, -0.02476846f, 0.00896384f, 0.00643318f, -0.02165593f, 
    0.03483253f, 0.00549212f, -0.03405578f, 0.00199091f, 0.02306879f, 0.03475121f, -0.01978190f, -0.00912239f, 
    -0.03268439f, -0.03592879f, -0.02249276f, -0.01212468f, -0.01995247f, 0.03967462f, 0.02044767f, -0.01661290f, 
    -0.03280886f, 0.00540125f, 0.02326606f, 0.00730534f, -0.00318866f, 0.03406715f, -0.01855111f, -0.04422892f, 
    0.02013664f, -0.01789618f, -0.02810830f, -0.03702532f, -0.02120109f, -0.01929027f, -0.03798198f, -0.00480552f, 
    -0.04381974f, -0.00788959f, 0.04524911f, 0.00072803f, -0.04534646f, 0.00053289f, 0.03757530f, -0.00597231f, 
    -0.02659824f, 0.04373814f, -0.01830507f, 0.03191540f, 0.04269424f, -0.04959997f, -0.03820809f, -0.00934011f, 
    0.00999337f, -0.00879201f, 0.03305128f, 0.02963628f, -0.01516549f, 0.01504995f, 0.00922337f, 0.01050284f, 
    0.03514482f, 0.00501386f, 0.03973722f, -0.02581613f, -0.05114678f, -0.02266172f, -0.00851022f, -0.03318185f, 
    -0.01471900f, 0.03442302f, 0.00391025f, 0.03479100f, 0.03141669f, -0.00931697f, 0.00133753f, 0.03644070f, 
    0.04276329f, 0.04270244f, -0.02682179f, 0.02179180f, -0.03755749f, 0.01729976f, -0.02135750f, -0.02182482f, 
    0.03651831f, -0.00744125f, -0.00542341f, -0.00277905f, 0.02427764f, 0.04455228f, 0.03048220f, 0.01535397f, 
    -0.03329103f, -0.03878558f, 0.00910681f, 0.02105062f, -0.05220632f, -0.03974801f, -0.02830807f, -0.04898364f, 
    -0.05779285f, 0.03281141f, -0.01724132f, -0.02121052f, 0.00354948f, 0.03122610f, -0.03253604f, 0.02630957f, 
    -0.05167827f, 0.01737304f, 0.04233512f, 0.01685575f, 0.03324264f, 0.03388823f, 0.01348342f, -0.00398742f, 
    0.03959309f, 0.01515706f, -0.02491068f, -0.00956957f, -0.00807271f, 0.03383532f, -0.04066109f, -0.02912246f, 
    -0.04581214f, 0.01733194f, -0.03190240f, 0.04199720f, -0.04002604f, -0.04406532f, -0.02259138f, 0.01605450f, 
    -0.02147689f, -0.03637280f, -0.05452981f, 0.01972776f, -0.01144529f, 0.02961181f, -0.01333404f, 0.01625447f, 
    -0.05620934f, 0.00813297f, -0.02172966f, -0.02757822f, -0.03530527f, -0.00981509f, -0.00212320f, 0.04202176f, 
    0.04735311f, -0.02898553f, -0.04161901f, -0.05365857f, 0.02262457f, 0.00111517f, 0.00042420f, 0.01166434f, 
    0.00347717f, -0.02307936f, -0.03556884f, 0.01165014f, -0.02764579f, -0.02187936f, 0.04171586f, -0.02982323f, 
    -0.04483605f, 0.01352823f, 0.00170091f, -0.01448019f, -0.03917171f, 0.02353504f, -0.01966288f, 0.01326936f, 
    0.04043967f, 0.03491369f, -0.02940856f, -0.02233369f, 0.01310423f, 0.03607496f, 0.00115014f, -0.03173756f, 
    0.00521026f, -0.02798345f, 0.02344085f, 0.02449537f, 0.03779801f, 0.04689637f, -0.00985469f, -0.00058240f, 
    0.01108665f, -0.04844601f, 0.02607444f, -0.00867282f, 0.00958881f, 0.01083685f, -0.03114591f, 0.02121067f, 
    -0.02742429f, -0.04707364f, 0.00744223f, -0.05364744f, -0.01282064f, -0.00581177f, 0.00167139f, -0.01342359f, 
    -0.00227258f, -0.04715832f, -0.00907866f, -0.05157140f, 0.00352117f, 0.02555430f, 0.04250162f, -0.04758895f, 
    -0.05488898f, -0.04494719f, 0.00072934f, 0.01388160f, -0.02672546f, 0.01857872f, -0.04834486f, -0.03464570f, 
    0.03740211f, 0.04632258f, -0.02410649f, 0.00276605f, -0.04742447f, -0.05581131f, 0.04746106f, -0.01664473f, 
    0.04486435f, -0.03299478f, -0.01595122f, -0.05806912f, -0.01437704f, 0.03854832f, -0.01390410f, -0.00982803f, 
    -0.03715728f, 0.03961567f, 0.03874219f, 0.02522482f, -0.01163553f, -0.04049512f, -0.05327354f, 0.00527586f, 
    -0.03350113f, -0.02753294f, -0.02692951f, -0.00872739f, 0.04065428f, 0.00978930f, 0.01140253f, 0.02940712f, 
    -0.05371569f, 0.02738795f, -0.05560312f, 0.03755483f, 0.02020876f, -0.04861102f, 0.03673130f, 0.02745892f, 
    -0.04927573f, -0.02181659f, 0.02982653f, -0.02645851f, -0.01631305f, -0.05191183f, -0.04987074f, -0.04488711f, 
    -0.01590355f, -0.02598922f, -0.01915585f, 0.03453033f, 0.00496680f, -0.02278814f, -0.04959584f, 0.00899057f, 
    -0.03045536f, -0.02760350f, -0.00917378f, 0.00700334f, -0.02336354f, -0.02358211f, -0.00481272f, 0.01758036f, 
    -0.05242312f, -0.00519738f, -0.03337472f, 0.00085364f, 0.03097261f, 0.00249607f, 0.00711204f, 0.01952849f, 
    -0.02276135f, -0.04895489f, 0.02620857f, 0.01584399f, -0.00225022f, -0.02525671f, 0.02498933f, -0.02072531f, 
    0.02118100f, -0.01784923f, -0.02250986f, 0.00783790f, 0.02648118f, -0.00688468f, -0.03988532f, -0.05741365f, 
    -0.04960646f, -0.01271414f, 0.00740309f, -0.01499087f, 0.03898094f, 0.04189598f, -0.01579995f, -0.03746839f, 
    -0.02410863f, -0.00637896f, 0.02612821f, -0.02634562f, 0.00493766f, 0.00642418f, 0.02063878f, -0.00544668f, 
    -0.01525152f, 0.03468626f, 0.03892877f, -0.05518157f, -0.03114325f, -0.03287204f, -0.02806551f, 0.01539588f, 
    -0.03205084f, -0.00105819f, 0.01042575f, -0.01060425f, -0.00201260f, -0.00168977f, 0.01473435f, -0.04780184f, 
    -0.00228536f, -0.02614188f, 0.01796632f, 0.04091206f, 0.01245514f, 0.01369307f, 0.01047290f, 0.02716130f, 
    -0.02250288f, -0.03461508f, -0.03045946f, 0.00602674f, 0.01382232f, -0.01992328f, 0.03984098f, -0.04842437f, 
    -0.05233971f, 0.00977569f, 0.00045887f, -0.04744411f, -0.04236338f, -0.04726726f, -0.00245577f, -0.01126304f, 
    -0.02680576f, 0.03700857f, -0.00807329f, -0.00303862f, 0.00370589f, 0.02926357f, -0.04932719f, 0.00167229f, 
    0.00908100f, 0.01777904f, 0.03823628f, 0.02331610f, 0.02812711f, 0.02016443f, 0.01350904f, -0.03685785f, 
    -0.04428675f, -0.01171589f, -0.00889176f, -0.02390798f, -0.04387154f, 0.00571122f, 0.04143400f, -0.05205144f, 
    -0.03381422f, 0.02449689f, -0.01881204f, -0.02137058f, -0.03382196f, 0.03690234f, -0.01001767f, 0.00793185f, 
    0.02130151f, 0.00558219f, -0.03310316f, 0.01088024f, 0.03473632f, 0.01217924f, -0.02455769f, -0.01796545f, 
    0.02198273f, 0.03279303f, -0.03981502f, -0.02315118f, -0.03361147f, -0.00345794f, -0.04677230f, -0.03549844f, 
    0.00198477f, -0.00701472f, 0.00682859f, -0.02213831f, -0.02021729f, 0.03708231f, -0.01528434f, -0.03176723f, 
    -0.04086544f, -0.05792960f, -0.05580189f, 0.03382549f, -0.04195124f, 0.03634310f, -0.05854282f, 0.02250653f, 
    0.04078526f, 0.03872184f, -0.02956039f, 0.01686918f, -0.03514338f, -0.05190947f, -0.02305790f, -0.01699225f, 
    -0.01661818f, -0.03322064f, 0.00675605f, 0.03901202f, 0.03354600f, 0.00005781f, 0.01655729f, 0.02542672f, 
    0.03412405f, -0.04146411f, -0.02947934f, -0.04237798f, -0.00747815f, -0.01147568f, 0.01130559f, 0.03470325f, 
    -0.02870520f, -0.01774731f, 0.03876613f, -0.03551722f, 0.00327581f, -0.03915080f, 0.02721723f, -0.03250544f, 
    -0.05156136f, -0.00921945f, -0.03726665f, -0.03943878f, 0.00069549f, 0.02551311f, -0.00569813f, -0.01458280f, 
    0.04091892f, -0.05555166f, -0.05345825f, -0.03461773f, 0.03929128f, -0.01213515f, -0.03697992f, -0.05524962f, 
    0.02945983f, -0.00043995f, 0.00586545f, -0.05893358f, 0.01645859f, -0.03534967f, 0.01017694f, -0.01232672f, 
    0.03400317f, -0.04479102f, -0.01802837f, 0.02453108f, -0.02336623f, -0.03052248f, -0.00289712f, 0.01736858f, 
    -0.01567550f, -0.02792717f, 0.01535598f, -0.03167095f, 0.01658516f, 0.04306785f, 0.03882367f, 0.03451309f, 
    0.01210914f, -0.03340058f, -0.02318577f, -0.02459303f, 0.01270938f, 0.02260881f, -0.02298199f, 0.03124618f, 
    0.03444883f, -0.02077819f, 0.00741898f, -0.02511219f, 0.03845040f, -0.01918880f, 0.04001058f, -0.01849657f, 
    -0.00568719f, 0.02040456f, 0.00982357f, 0.04143995f, -0.00508636f, -0.02171055f, 0.01783933f, 0.01548250f, 
    -0.05182946f, 0.01476741f, -0.04530024f, -0.02770895f, 0.01520704f, -0.05432442f, -0.00092986f, -0.01605666f, 
    -0.00395681f, 0.03960889f, -0.03737493f, 0.03459347f, -0.03422801f, -0.04516684f, -0.01755090f, 0.03214063f, 
    -0.00155855f, 0.02428850f, -0.02699433f, 0.03294587f, 0.03532518f, -0.04370065f, -0.02676260f, -0.03535349f, 
    -0.04267436f, 0.03741042f, -0.05737087f, -0.01703565f, -0.03204316f, 0.01346468f, -0.02399434f, -0.02758633f, 
    -0.01847838f, -0.05413733f, -0.04680204f, 0.01104398f, -0.00371333f, -0.04673046f, -0.05013869f, 0.00999183f, 
    0.03445365f, -0.02374204f, 0.01972658f, 0.00595966f, 0.03664153f, -0.02388230f, -0.03824611f, -0.04994782f, 
    -0.00597559f, -0.02241104f, 0.01156696f, -0.01728300f, -0.01536214f, 0.01532709f, 0.00046553f, -0.02655393f, 
    -0.05407361f, 0.02844151f, -0.03144743f, -0.03182385f, -0.03928649f, -0.00689945f, -0.00468739f, -0.04464735f, 
    -0.01118807f, -0.02076889f, -0.03811659f, 0.00882502f, 0.02527440f, 0.03143359f, -0.05358013f, 0.01447206f, 
    -0.00242230f, -0.00596207f, -0.01260331f, 0.01428532f, 0.01302303f, -0.02738180f, -0.05226836f, 0.04116072f, 
    -0.03581319f, -0.05130023f, -0.04175247f, -0.04574870f, 0.01328338f, -0.00360916f, 0.00475293f, 0.03800837f, 
    0.00580050f, 0.03982734f, 0.03467575f, -0.02698382f, -0.05736992f, 0.01049272f, -0.03491641f, 0.00516128f, 
    0.03423746f, 0.03806077f, -0.05480857f, -0.03437613f, 0.00512845f, -0.04880557f, 0.03895446f, 0.01270877f, 
    -0.00981294f, 0.02234060f, 0.00048941f, -0.05879575f, -0.02995510f, 0.02492815f, -0.03519955f, -0.04018571f, 
    -0.03769526f, 0.00494527f, -0.02178423f, -0.04684097f, -0.03225796f, 0.00267224f, -0.01879287f, -0.03420218f, 
    -0.00919317f, 0.01607307f, -0.01810500f, -0.00499784f, -0.04475982f, -0.02665347f, -0.03812372f, -0.03967297f, 
    -0.07560910f, 0.02769382f, -0.04567850f, -0.24386719f, 0.20144373f, 0.04707756f, -0.03268437f, 0.14182641f, 
    0.11852311f, 0.05405676f, 0.01724758f, 0.05320515f, 0.32597065f, 0.16418505f, -0.08364490f, -0.03386056f, 
    0.14051090f, 0.12372662f, 0.02177706f, -0.01581709f, 0.07260787f, -0.04141036f, 0.05493881f, 0.05491989f, 
    0.30344296f, 0.12120950f, 0.07205041f, 0.03284588f, 0.08381101f, 0.01302689f, 0.09030887f, 0.17430469f, 
    0.03106149f, -0.08185737f, 0.06713559f, 0.03378731f, 0.18800963f, 0.17481874f, 0.24267548f, 0.27470461f, 
    0.01762018f, 0.05455139f, 0.04852825f, 0.01771156f, 0.06031150f, 0.16489245f, -0.01193476f, 0.05949672f, 
    -0.03245962f, -0.02836438f, -0.14203419f, -0.02528567f, 0.02944426f, 0.10829329f, 0.03240482f, 0.01027432f, 
    0.15020381f, 0.11274804f, 0.06910162f, 0.01301012f, 0.37661016f, -0.21115294f, 0.05755104f, 0.15965155f, 
    0.10159299f, 0.02095901f, -0.04982021f, 0.05740662f, 0.05519989f, 0.17828067f, 0.12510031f, 0.02537096f, 
    0.00725982f, -0.09120555f, -0.15350580f, 0.00662695f, -0.16466789f, 0.05146978f, -0.05086071f, 0.03559728f, 
    0.12003631f, 0.10065914f, 0.06702326f, -0.01316979f, 0.29171360f, 0.03684889f, 0.14643814f, 0.15668738f, 
    0.14428037f, 0.08708770f, -0.07927325f, 0.04579790f, 0.02239318f, 0.06132000f, 0.09348424f, 0.05040799f, 
    0.14715268f, 0.06735221f, 0.08684070f, 0.00549459f, 0.05029454f, 0.07094838f, 0.01073848f, -0.02605340f, 
    -0.04454471f, 0.07386796f, -0.12786157f, 0.06533796f, 0.14304210f, 0.04638138f, -0.00080211f, -0.04115449f, 
    0.07497261f, 0.11305752f, -0.14190145f, 0.07854795f, 0.18189393f, -0.03872240f, 0.03038203f, 0.02632164f, 
    -0.30466756f, 0.03512121f, -0.05214512f, -0.26581272f, 0.02450480f, -0.02211500f, 0.00515849f, 0.06015954f, 
    -0.01590738f, 0.09347969f, 0.15791279f, 0.06001241f, -0.03440910f, 0.14269277f, 0.16841269f, 0.08360078f, 
    0.08092536f, 0.03964276f, -0.04385004f, 0.11467709f, 0.06873064f, 0.03876936f, 0.11523024f, 0.00704497f, 
    0.22684176f, 0.03912969f, 0.20904088f, 0.18210408f, 0.01224547f, 0.01967289f, -0.01053785f, -0.06510049f, 
    0.09599628f, 0.08680901f, -0.02593814f, -0.04424601f, 0.11213452f, -0.12019996f, -0.20678404f, 0.08766582f, 
    0.02244927f, 0.08768778f, 0.03004606f, 0.00423853f, 0.02902707f, 0.03675549f, 0.09963860f, 0.09804412f, 
    0.03388139f, -0.06407743f, 0.03076255f, 0.15605067f, -0.07743027f, 0.04578547f, -0.03972606f, 0.05082537f, 
    0.08570247f, 0.00345191f, 0.08492188f, 0.01150663f, 0.31919494f, 0.07399483f, 0.10795778f, 0.05391725f, 
    -0.00475195f, -0.05230406f, -0.08504963f, 0.16985185f, 0.01882940f, 0.04038173f, 0.08433136f, 0.15948662f, 
    0.36735049f, 0.00994261f, -0.04085584f, 0.07951407f, 0.12412008f, 0.02063179f, -0.05662606f, 0.02604200f, 
    0.03983800f, 0.00283354f, 0.08243350f, 0.10599389f, -0.07175405f, -0.09909169f, -0.09240250f, -0.05678599f, 
    0.08214254f, 0.09319904f, 0.04007712f, -0.08666220f, 0.10988031f, 0.08152474f, -0.07942919f, 0.14969257f, 
    0.00208015f, 0.10884936f, -0.16481352f, -0.10501031f, -0.06121773f, 0.09147120f, -0.05382078f, 0.02465047f, 
    0.09039990f, -0.04530089f, 0.12416041f, 0.00038420f, -0.09558418f, 0.03319037f, 0.00115498f, -0.21888231f, 
    0.02817243f, -0.02580375f, 0.15116102f, 0.00956462f, 0.05311497f, 0.07725721f, 0.15496047f, 0.08510028f, 
    0.17391296f, 0.27184880f, 0.34026554f, 0.22938707f, 0.11631497f, -0.00731628f, 0.04662881f, 0.11889714f, 
    0.03082013f, -0.02426722f, 0.13446967f, 0.06800780f, -0.05734900f, -0.15646629f, 0.05880664f, -0.19930519f, 
    0.09298583f, 0.11367775f, 0.03788787f, 0.02444692f, -0.06924104f, 0.16576810f, 0.05013976f, -0.04365012f, 
    0.17021778f, -0.08858638f, 0.06834911f, 0.01763529f, -0.05873428f, -0.07716214f, 0.03432839f, 0.04484422f, 
    0.03081390f, -0.03823484f, 0.07509005f, 0.01460962f, -0.12734975f, 0.15994613f, 0.10696699f, 0.14598766f, 
    0.17134885f, 0.01221295f, 0.13683641f, 0.04695154f, -0.04096660f, -0.06796916f, 0.11042950f, 0.00111612f, 
    -0.14719197f, 0.06592232f, -0.04216503f, -0.07589092f, 0.14146039f, 0.03072804f, 0.08512547f, 0.07745989f, 
    0.01041266f, 0.08591443f, 0.11630777f, 0.05255351f, -0.15330657f, 0.03802574f, -0.04990780f, -0.11560956f, 
    0.02713053f, -0.00732127f, 0.15387228f, 0.19821863f, -0.04073858f, -0.00726597f, -0.04715328f, -0.02977691f, 
    -0.10601383f, -0.08386687f, -0.01810959f, -0.14705299f, 0.04992368f, -0.06168018f, -0.01905200f, -0.05103492f, 
    0.08410394f, -0.00540531f, 0.01249545f, 0.08587522f, -0.13285199f, -0.01703354f, 0.08487651f, -0.03617148f, 
    0.02287825f, 0.06696536f, 0.02625593f, -0.02106075f, 0.04393065f, -0.01897415f, -0.02440465f, -0.02243924f, 
    -0.04046176f, -0.00804044f, 0.02657540f, -0.11481903f, 0.04985524f, 0.10619356f, -0.02292292f, 0.08823720f, 
    0.07272548f, -0.00652930f, 0.15520354f, 0.01698449f, 0.26306924f, 0.17690529f, 0.02364405f, -0.05068503f, 
    0.02498325f, 0.06294600f, 0.01437097f, -0.07941407f, 0.00872756f, 0.05198473f, 0.06561297f, 0.02599666f, 
    -0.36275950f, -0.14475824f, 0.02593979f, -0.02704250f, 0.04715855f, 0.03889282f, 0.00635687f, 0.04294605f, 
    0.03258520f, -0.05625720f, 0.08650791f, 0.06624310f, 0.06871308f, -0.00052391f, -0.06953587f, -0.07881470f, 
    -0.00426833f, -0.08525187f, 0.03265012f, 0.00257939f, 0.03668262f, 0.03668977f, 0.18072963f, -0.03643188f, 
    -0.09858551f, 0.24183756f, 0.02833036f, -0.11057944f, 0.07425043f, 0.01284292f, -0.01596090f, 0.01120303f, 
    0.04462144f, -0.03398655f, 0.06759629f, -0.06405864f, 0.03778906f, 0.16232756f, -0.07599525f, 0.11800466f, 
    0.07831523f, -0.02607308f, 0.08564767f, 0.05798827f, -0.03546962f, 0.03107841f, -0.01619594f, 0.05231585f, 
    0.08529530f, -0.17321871f, -0.15416771f, -0.17293650f, 0.11030047f, -0.00992021f, 0.06780898f, -0.09487014f, 
    -0.02444348f, 0.00702795f, -0.01357350f, 0.02566915f, 0.26498416f, -0.03352036f, 0.13006540f, -0.19154742f, 
    -0.03000718f, 0.01376364f, -0.10430342f, 0.17625079f, 0.10841391f, -0.01320417f, -0.05477702f, -0.06765819f, 
    -0.55299091f, -0.07280456f, 0.07869899f, 0.12498060f, 0.02304518f, -0.11480232f, 0.12924704f, 0.01882824f, 
    0.04458776f, -0.02344977f, 0.02792973f, -0.05934961f, 0.30517700f, -0.09489886f, 0.10071079f, -0.01197255f, 
    -0.08290165f, -0.12431677f, 0.03049009f, 0.10300561f, 0.08328311f, 0.07619426f, 0.00698249f, -0.00266854f, 
    -0.18271083f, 0.24392578f, -0.08389156f, 0.04670949f, 0.09067135f, -0.06200773f, 0.06227531f, 0.04749237f, 
    0.05183915f, -0.16421445f, -0.00779595f, -0.07969397f, -0.13575089f, -0.12695067f, -0.02817212f, -0.07171035f, 
    0.01902385f, 0.04635923f, -0.02181688f, -0.17129387f, -0.00205136f, -0.03056005f, -0.01581148f, 0.02997144f, 
    -0.23301804f, -0.15683119f, 0.00009956f, -0.17743312f, -0.08901016f, 0.06995717f, 0.11088242f, -0.04227205f, 
    -0.01509794f, -0.07666120f, -0.12630461f, 0.04436937f, -0.11807392f, 0.08181493f, 0.04326000f, -0.11683778f, 
    0.01306905f, -0.01123811f, -0.06335220f, -0.11858276f, 0.09577755f, 0.09487044f, -0.11969142f, -0.09312520f, 
    -0.00728228f, -0.06299064f, -0.09906228f, 0.18727092f, -0.03823584f, 0.00181876f, 0.05618245f, -0.12614925f, 
    0.05120533f, 0.15066437f, 0.01363439f, 0.10252050f, 0.08719777f, -0.32158834f, 0.13143808f, 0.07139140f, 
    -0.02265348f, -0.02533663f, 0.08226352f, 0.04093472f, 0.05064046f, 0.03904114f, 0.12848672f, 0.12880987f, 
    0.36357221f, 0.02168282f, -0.04185511f, 0.05852195f, 0.01937397f, -0.07241005f, 0.08039451f, 0.05951536f, 
    0.11340035f, 0.03833552f, 0.11086006f, 0.16199721f, 0.22633648f, -0.04959239f, 0.17915285f, 0.21050821f, 
    -0.08705532f, -0.17293175f, 0.02285563f, 0.18927570f, 0.05533507f, 0.11247938f, 0.03296271f, 0.09918833f, 
    -0.30873653f, 0.16650498f, 0.08582041f, -0.17453858f, -0.03855739f, 0.03047980f, 0.01655797f, 0.00441537f, 
    0.11256095f, -0.01148338f, 0.04219053f, 0.05397917f, 0.03187681f, 0.16509464f, -0.00962112f, 0.00262696f, 
    -0.03220524f, -0.03548692f, -0.05808026f, 0.06642218f, -0.03205094f, -0.02490355f, 0.04343719f, 0.16837251f, 
    -0.44097942f, 0.06606027f, -0.17623806f, 0.14611812f, -0.05864834f, 0.04191674f, 0.12216725f, 0.06974351f, 
    0.05432866f, -0.07356724f, 0.06213099f, 0.01152983f, 0.06636607f, -0.04285661f, -0.04121653f, 0.26501119f, 
    0.08597285f, 0.03154518f, -0.12405739f, -0.06720519f, -0.04409821f, 0.01367693f, 0.06016360f, 0.13301124f, 
    0.32425570f, 0.03784453f, -0.15635039f, 0.01523122f, -0.02249706f, 0.05654576f, 0.13212684f, -0.05667906f, 
    0.10895446f, 0.01487901f, 0.01400220f, 0.06348778f, 0.37428701f, 0.09094908f, -0.00210962f, 0.25722724f, 
    0.08530053f, -0.08798846f, 0.04147322f, 0.06898062f, 0.07771469f, -0.03791825f, 0.02621511f, 0.12959304f, 
    0.15442471f, -0.19602326f, -0.01288661f, 0.11772430f, -0.07142194f, -0.01336848f, -0.05809408f, 0.13868216f, 
    0.11704177f, 0.04663489f, -0.06706820f, 0.08564469f, 0.21912451f, -0.30162963f, 0.02854351f, 0.02187089f, 
    -0.12892464f, -0.02264597f, 0.24266942f, -0.01775079f, 0.07670666f, -0.00779731f, 0.08344420f, 0.01257396f, 
    -0.34106323f, -0.14203821f, -0.12944239f, -0.08252797f, 0.04027142f, 0.01539746f, 0.06992877f, 0.01389217f, 
    -0.03438743f, -0.04275562f, 0.11310565f, -0.04861953f, 0.33443868f, 0.21739258f, -0.09243694f, 0.08115085f, 
    0.00607371f, -0.15523791f, -0.04245656f, 0.05689801f, 0.07661687f, 0.04726221f, 0.08846609f, 0.04958344f, 
    0.21296303f, -0.05121802f, 0.05795615f, 0.01308464f, -0.08981633f, -0.03171974f, 0.05085214f, 0.02486173f, 
    -0.03978946f, -0.05435794f, -0.00997450f, -0.01941823f, -0.18931495f, 0.00380835f, 0.01377332f, -0.00498913f, 
    0.13027751f, 0.02370081f, -0.05423389f, -0.11199955f, 0.03455491f, -0.02791400f, -0.04621099f, -0.01692685f, 
    0.31269941f, -0.05280460f, -0.08219656f, -0.03474273f, -0.11634291f, 0.14078236f, 0.03235697f, -0.12745030f, 
    -0.00822100f, 0.01409712f, -0.07111228f, -0.09551279f, 0.16456906f, -0.08152910f, 0.09580201f, -0.14652944f, 
    0.17208146f, -0.00595753f, 0.01103809f, 0.00172079f, 0.03687909f, -0.03098281f, -0.01497805f, 0.16001831f, 
    0.12994368f, -0.03335489f, -0.21249160f, -0.05200946f, 0.00959742f, 0.04568895f, -0.03886745f, -0.12245135f, 
    0.01863084f, 0.06011556f, -0.03646585f, 0.03835849f, -0.07511215f, 0.19471778f, -0.03999187f, 0.06651912f, 
    0.07387586f, -0.09726939f, 0.09308376f, -0.04886609f, -0.03308338f, 0.03475938f, 0.08283868f, 0.11796633f, 
    0.10924853f, 0.15789039f, -0.20509410f, 0.00625202f, -0.02728395f, 0.11835501f, 0.03017270f, 0.01479086f, 
    0.11100781f, -0.03407219f, 0.17450365f, -0.04910658f, 0.18777570f, -0.15869941f, -0.17315347f, -0.00860381f, 
    -0.20441869f, 0.06499783f, 0.10558818f, -0.14746277f, 0.03799425f, -0.20330642f, 0.13038392f, 0.11493817f, 
    0.01701946f, -0.00354137f, 0.03925491f, -0.03234059f, 0.03697426f, 0.02786833f, -0.04761637f, 0.01051250f, 
    0.04276360f, 0.02025050f, 0.04063989f, -0.03757665f, -0.04191531f, 0.02999858f, -0.02852498f, -0.02805004f, 
    -0.04655470f, -0.02878738f, 0.03877909f, 0.02609584f, 0.02225191f, 0.04383488f, -0.03505355f, 0.04085469f, 
    0.03028915f, -0.00476219f, 0.04755201f, -0.03547786f, -0.00527113f, 0.01548625f, -0.02822835f, 0.01611952f, 
    0.02436979f, -0.02105672f, 0.00651665f, 0.00676786f, -0.05490505f, 0.01496059f, -0.01348032f, -0.01105763f, 
    0.04279421f, 0.01818051f, 0.04207134f, 0.04492300f, 0.02511063f, -0.02081982f, 0.01208211f, -0.02890435f, 
    0.00720154f, -0.05091610f, 0.02076530f, 0.04012476f, -0.00217860f, -0.02011951f, -0.00623635f, 0.01650975f, 
    0.00849370f, 0.04096083f, 0.03236657f, -0.04576281f, 0.01101557f, -0.04500693f, -0.03638411f, 0.00663008f, 
    -0.03505431f, -0.05022456f, -0.02025637f, -0.03251484f, -0.01602571f, -0.05356915f, -0.03151873f, -0.01218510f, 
    0.03601931f, 0.04153533f, 0.03683997f, -0.03346092f, -0.00264457f, -0.01815282f, -0.01233461f, 0.00271190f, 
    -0.02400027f, 0.03562814f, -0.03981702f, -0.04942849f, 0.00907293f, -0.00436398f, -0.04484065f, -0.03091620f, 
    -0.05421186f, 0.00720331f, -0.04722309f, 0.00673172f, -0.05201017f, 0.03237737f, -0.00994674f, -0.01789222f, 
    -0.02132591f, 0.01323676f, -0.02629831f, -0.02528159f, 0.00226214f, -0.02591176f, -0.05174970f, 0.01430408f, 
    -0.02327774f, -0.04281913f, 0.01580767f, -0.01793353f, -0.03565418f, 0.00208670f, 0.02095804f, 0.03514943f, 
    0.02401855f, -0.01471968f, -0.02084876f, 0.00433305f, -0.04079110f, 0.01515112f, -0.04025564f, 0.03178884f, 
    0.00928844f, 0.03415882f, -0.04580501f, -0.01897551f, -0.01419198f, 0.02460984f, -0.04408934f, -0.01183247f, 
    0.01208421f, 0.02655209f, -0.00860254f, -0.01142617f, 0.01560423f, -0.04002861f, -0.04761821f, 0.01242972f, 
    -0.01481129f, 0.00313978f, 0.03954262f, -0.01979658f, 0.02187223f, -0.05390727f, 0.02322582f, -0.01096158f, 
    -0.00510493f, -0.01256496f, -0.02707706f, 0.03724370f, -0.04000199f, -0.05162158f, -0.00406774f, -0.04149450f, 
    -0.04833982f, 0.04494577f, 0.04873484f, -0.00098213f, -0.04321590f, 0.04049205f, 0.00397579f, 0.00343559f, 
    -0.01159091f, 0.02613168f, 0.01420323f, 0.03649021f, -0.01530654f, -0.01310448f, -0.05500813f, -0.04218233f, 
    -0.03927438f, 0.00254004f, -0.03406945f, -0.01204040f, -0.00017870f, -0.00954764f, -0.02211630f, -0.04378546f, 
    0.04025237f, -0.05492160f, -0.03318853f, -0.02486679f, 0.04029009f, -0.02365838f, 0.03660559f, 0.00743424f, 
    -0.04572338f, 0.04452898f, -0.01064068f, -0.04922546f, -0.05092035f, -0.04972101f, -0.02373240f, 0.01871761f, 
    0.00628230f, -0.02722180f, -0.03477623f, -0.04806082f, -0.02595823f, 0.01247560f, 0.01942699f, -0.05620928f, 
    -0.02169198f, 0.02576628f, -0.01303107f, -0.01616360f, 0.01129533f, -0.02623724f, 0.00104965f, 0.00390606f, 
    0.01373639f, 0.00028667f, 0.02094379f, -0.04261703f, -0.01649239f, 0.00331633f, -0.00830410f, -0.03492142f, 
    0.03638224f, 0.03741178f, 0.04134021f, 0.00437032f, -0.01785908f, 0.02675415f, 0.00056213f, 0.00856603f, 
    -0.00314946f, -0.03098069f, 0.00275497f, -0.05215282f, -0.01545261f, 0.00224030f, 0.00643426f, -0.04889088f, 
    0.00660995f, -0.04492993f, -0.04052060f, -0.02884180f, 0.02077064f, -0.00851842f, -0.03291264f, 0.00398182f, 
    -0.03351134f, 0.02702019f, -0.00080589f, -0.01069130f, -0.05534231f, 0.01951534f, -0.03048393f, -0.01784898f, 
    -0.00271390f, 0.02407234f, 0.01568278f, 0.01874959f, -0.00388925f, 0.03682958f, 0.02325514f, -0.02753837f, 
    -0.01140945f, -0.02385223f, -0.00644900f, -0.01210628f, -0.02709097f, 0.00614621f, -0.03263335f, 0.03461232f, 
    -0.00999023f, -0.05121015f, -0.04900910f, -0.01821239f, 0.04094659f, 0.02525919f, -0.01556235f, -0.05399489f, 
    -0.01411668f, -0.03800493f, 0.00803215f, -0.01251941f, -0.04333792f, -0.01884372f, 0.03165850f, -0.00684368f, 
    -0.03194474f, 0.03341132f, -0.03222885f, 0.03726500f, -0.02466110f, 0.03129832f, 0.04479467f, -0.01594930f, 
    -0.01990859f, 0.02965709f, -0.02563318f, 0.02108681f, 0.03259739f, -0.00354343f, 0.01745883f, -0.01432210f, 
    -0.04218568f, 0.00778403f, -0.02259289f, 0.03481523f, 0.02581707f, -0.02802632f, 0.00051191f, 0.03807574f, 
    0.01005645f, 0.02512236f, -0.03109818f, -0.02848408f, -0.02779800f, -0.04948828f, -0.01315438f, 0.01859153f, 
    -0.00814797f, 0.00127825f, -0.03071162f, 0.00806906f, -0.02959297f, 0.01040703f, 0.03797879f, -0.01592160f, 
    -0.01863118f, 0.03517096f, -0.04356920f, -0.04601627f, -0.05125351f, -0.00501516f, -0.00765329f, 0.01002681f, 
    0.03500661f, -0.02611299f, -0.05574491f, 0.04005070f, -0.04399671f, -0.05271434f, -0.03890070f, 0.02253704f, 
    -0.03049838f, -0.00537867f, -0.01274029f, 0.03069470f, -0.03390147f, -0.00243737f, -0.02562045f, -0.03269730f, 
    -0.01285748f, -0.04810793f, 0.02715840f, 0.00647274f, -0.02283821f, -0.01252841f, -0.05287078f, 0.00410410f, 
    -0.01588723f, -0.03759043f, 0.01554526f, -0.04855314f, 0.02123718f, -0.01712284f, -0.00442486f, 0.03157774f, 
    0.01616706f, -0.00386328f, -0.05343527f, 0.02643435f, -0.02960759f, -0.05228706f, 0.01468146f, -0.02262433f, 
    -0.04342093f, 0.03562649f, -0.03691156f, -0.03693625f, -0.00885740f, 0.04367258f, -0.02003084f, -0.04381324f, 
    0.01853605f, 0.03673844f, -0.05457013f, 0.02010658f, 0.02522042f, -0.04939684f, 0.03376624f, -0.00278623f, 
    -0.02916491f, 0.03055208f, -0.04152845f, -0.01362440f, -0.04098358f, 0.04038641f, -0.02292855f, 0.02007904f, 
    0.02807812f, -0.01637698f, 0.00309988f, 0.03843817f, 0.02054650f, 0.03495057f, -0.01703053f, 0.03817512f, 
    -0.00752665f, -0.05090663f, 0.00910381f, 0.00579009f, -0.01190754f, 0.03427672f, 0.03195633f, -0.01735738f, 
    0.01372971f, -0.01160162f, -0.04128819f, -0.03339989f, -0.02824128f, -0.05462626f, 0.02572967f, 0.01484645f, 
    0.00091710f, -0.04372873f, -0.03037953f, 0.01125299f, -0.03869901f, -0.01733151f, -0.01190028f, 0.02093893f, 
    0.00326363f, -0.04994364f, -0.05398116f, 0.03637993f, 0.03437920f, -0.00945917f, 0.00315774f, -0.01753466f, 
    0.03222683f, -0.01820935f, 0.01574744f, 0.03784461f, -0.01796241f, -0.05692187f, -0.03994364f, 0.03829587f, 
    -0.01850717f, -0.03612922f, 0.02743251f, -0.00565262f, 0.01211524f, 0.00092887f, 0.03371232f, -0.01395613f, 
    -0.04437447f, -0.01841179f, 0.03996703f, -0.00370061f, -0.02843454f, 0.02800571f, 0.04284400f, -0.00204017f, 
    0.01382981f, 0.01040415f, -0.03053479f, -0.04651308f, -0.00651040f, -0.01356029f, -0.05075474f, -0.02567255f, 
    -0.05173443f, 0.00718577f, -0.00440954f, -0.02863034f, 0.02125183f, 0.03019768f, 0.01295370f, -0.00677084f, 
    0.00240847f, 0.01933840f, -0.02567859f, -0.01822617f, 0.01996016f, -0.03876032f, -0.00808327f, -0.04750119f, 
    -0.02375808f, -0.03282489f, -0.00476121f, 0.01444908f, -0.04100255f, -0.04051529f, -0.01152484f, -0.03718602f, 
    0.01133207f, -0.01624334f, -0.05531573f, -0.05521635f, -0.02666063f, 0.03455742f, -0.05555518f, -0.05069998f, 
    0.02314567f, 0.00302484f, 0.01081869f, -0.00064639f, -0.02956855f, 0.00741566f, -0.04120327f, 0.03910956f, 
    -0.01556425f, -0.05400545f, 0.02251350f, -0.02465611f, -0.03122959f, -0.04073338f, 0.02302867f, -0.02450263f, 
    0.01869590f, -0.03680786f, -0.01562573f, 0.01924029f, 0.01321897f, 0.01785423f, 0.04439612f, 0.03942563f, 
    -0.01007106f, 0.04613332f, 0.03281116f, 0.02053172f, -0.05083794f, -0.01657216f, -0.00521456f, -0.01412348f, 
    0.03108885f, -0.05646778f, 0.02858484f, -0.02549928f, 0.03341101f, 0.01071343f, 0.00946622f, -0.05634308f, 
    0.03883793f, 0.02923905f, -0.00568866f, -0.02504607f, -0.02371180f, 0.03337155f, 0.01832073f, -0.05526163f, 
    0.01545520f, -0.04928955f, 0.03122838f, -0.03958647f, -0.02663940f, 0.00672464f, -0.02486297f, 0.00635586f, 
    -0.03489681f, 0.03938184f, 0.03735022f, -0.04398250f, -0.03877354f, -0.04349583f, 0.02803086f, -0.05724424f, 
    -0.01013225f, 0.02627432f, 0.03068302f, -0.03352176f, -0.02767334f, 0.04387417f, -0.05894103f, 0.02157946f, 
    -0.05175734f, 0.00669316f, -0.02390145f, 0.04360978f, -0.04540607f, -0.03272662f, -0.00442545f, -0.05596859f, 
    0.03301222f, -0.03099035f, 0.04300974f, -0.05171409f, 0.03490993f, -0.01821142f, 0.03878101f, 0.01904278f, 
    -0.00417912f, -0.03148755f, 0.00475907f, 0.04099273f, 0.02628374f, 0.04030748f, 0.02361022f, -0.04177665f, 
    0.02001649f, -0.00810312f, -0.02197691f, 0.03002675f, -0.04165716f, -0.03024874f, -0.05336653f, -0.04439257f, 
    -0.03670044f, -0.04965655f, 0.01108248f, -0.03279196f, -0.01263325f, -0.01995805f, -0.03694402f, 0.00355686f, 
    -0.04301612f, 0.01979184f, 0.01473127f, -0.02139788f, -0.04341165f, 0.03563584f, 0.01317840f, 0.01881378f, 
    -0.04491673f, 0.04331036f, -0.05841086f, -0.04106428f, -0.03261647f, -0.00960337f, 0.02908150f, -0.01599188f, 
    -0.02550810f, 0.01315391f, 0.00898709f, -0.04922834f, 0.02232009f, 0.04393548f, 0.00903139f, 0.01459986f, 
    -0.03225148f, 0.02388487f, -0.02455963f, -0.01833409f, 0.02452126f, 0.01725624f, 0.01214306f, 0.03340873f, 
    -0.05319232f, 0.03627136f, -0.00128651f, -0.05038132f, 0.02243978f, -0.04981538f, -0.03327756f, -0.02450322f, 
    -0.00518137f, -0.01787761f, -0.03267368f, 0.01506703f, 0.04346984f, 0.00486713f, -0.01953092f, 0.00647717f, 
    0.01026188f, -0.00110919f, -0.01767074f, -0.01651465f, -0.02014229f, 0.02491674f, -0.00319760f, 0.02869868f, 
    -0.04692461f, -0.02933531f, 0.00447751f, 0.01600036f, 0.03500246f, 0.00420584f, -0.04822876f, 0.04078164f, 
    -0.03731768f, -0.05530876f, -0.03230011f, -0.03717539f, -0.02219764f, -0.03497905f, -0.02232033f, -0.03091318f, 
    0.00305436f, 0.04387692f, 0.01582655f, -0.03302067f, -0.04204630f, -0.00988739f, -0.04008636f, 0.02714063f, 
    -0.02901332f, -0.02222187f, -0.03927201f, 0.01798899f, 0.03683992f, -0.00293312f, 0.00724075f, 0.02303263f, 
    -0.02261666f, 0.03902766f, 0.00690595f, 0.01543656f, 0.00587121f, -0.00912827f, -0.02434776f, -0.00586312f, 
    0.01482165f, 0.04228085f, 0.03347405f, -0.05499107f, 0.00438366f, 0.04149529f, 0.00488533f, -0.01355918f, 
    -0.03869004f, 0.03727937f, 0.02117395f, -0.00210545f, 0.02548621f, 0.04131432f, 0.04669996f, 0.01097298f, 
    -0.01152328f, -0.01349077f, -0.01233752f, 0.01821740f, -0.04494080f, -0.05407654f, 0.00672650f, 0.02242127f, 
    -0.02059066f, -0.02041470f, -0.05360856f, 0.03463639f, 0.01395873f, 0.02933123f, 0.03881752f, -0.02687644f, 
    0.01604866f, -0.03864396f, 0.02016968f, 0.00433724f, -0.02006445f, -0.00087281f, 0.00717133f, 0.01274941f, 
    -0.02427370f, -0.01472133f, 0.03836912f, -0.02337429f, -0.01108238f, -0.04216187f, -0.02917492f, -0.00489211f, 
    0.01602804f, -0.04442351f, -0.04018858f, -0.01905964f, -0.04164462f, 0.03940814f, -0.01831916f, -0.05722971f, 
    -0.01699946f, 0.04265634f, 0.01057203f, 0.03013290f, 0.03101041f, 0.04499212f, -0.01972456f, -0.00684458f, 
    -0.01884806f, -0.02946126f, 0.00206624f, -0.04993101f, -0.01023944f, -0.00798587f, -0.04403758f, -0.00041750f, 
    0.03640001f, -0.03918438f, 0.00910801f, -0.00309767f, -0.02673097f, -0.01290704f, -0.05461296f, -0.01701251f, 
    0.04352129f, 0.02440035f, -0.03755902f, -0.00716867f, 0.03283515f, -0.02799327f, 0.02769348f, 0.03399340f, 
    -0.01674138f, -0.00002917f, -0.05010287f, -0.01894001f, -0.05161902f, -0.04314179f, 0.02518749f, 0.03794484f, 
    -0.04956667f, 0.03891803f, -0.01909341f, 0.03304640f, 0.04048594f, -0.03777617f, -0.05334056f, 0.01725069f, 
    0.01573836f, 0.03470938f, -0.00320686f, 0.03013507f, -0.02795262f, 0.04097423f, 0.03678278f, 0.01437759f, 
    -0.03848258f, 0.01217497f, -0.01478256f, -0.04624753f, 0.01534566f, -0.02466954f, -0.00828211f, -0.00903318f, 
    0.03165317f, -0.03692077f, 0.03911993f, -0.04346690f, -0.04023273f, 0.00604113f, -0.01978188f, 0.01039923f, 
    -0.04835947f, 0.04391806f, 0.01525216f, -0.04326629f, -0.03875658f, -0.02132114f, -0.01392909f, -0.02018773f, 
    0.01705561f, 0.03876526f, 0.03088410f, 0.01902634f, 0.01109384f, 0.00066744f, -0.02318865f, -0.01697554f, 
    0.04156758f, 0.00105311f, 0.03744697f, -0.01286311f, 0.00054663f, -0.00877601f, -0.05220519f, -0.01652080f, 
    0.02329102f, -0.01146887f, -0.01807069f, -0.01636695f, -0.04332361f, 0.02605058f, 0.04091642f, 0.02827624f, 
    0.01079891f, 0.03275974f, -0.01605733f, -0.01526919f, -0.02629999f, 0.00729215f, 0.02044600f, -0.02494226f, 
    0.04315841f, -0.00891036f, -0.00112385f, -0.02527931f, -0.01864320f, 0.04202571f, 0.01410511f, 0.00982184f, 
    -0.01778411f, 0.02679672f, -0.02575831f, 0.03963633f, 0.03749814f, -0.03342907f, -0.00680774f, -0.01037608f, 
    -0.03824108f, -0.03375607f, -0.01688715f, -0.01649027f, 0.01593039f, -0.01563781f, -0.01489314f, -0.05391999f, 
    0.02527092f, 0.04413963f, -0.01087150f, -0.00872365f, 0.03865596f, 0.03593241f, -0.01715649f, 0.00222118f, 
    -0.05266763f, 0.01663438f, 0.01891083f, 0.02869586f, 0.01680277f, 0.00156864f, -0.04435131f, -0.04777058f, 
    -0.05443199f, -0.02221199f, -0.04154078f, -0.02673729f, -0.04957254f, -0.00619444f, -0.02340622f, -0.02189115f, 
    -0.02960235f, -0.02852310f, -0.02172588f, 0.02593530f, -0.00085687f, -0.01497539f, -0.03598675f, -0.00576270f, 
    -0.00745529f, -0.00973838f, -0.01358543f, 0.02274534f, 0.00994661f, 0.00186133f, -0.04048970f, 0.02651427f, 
    -0.01194738f, -0.05648880f, 0.03326304f, -0.02548110f, -0.04064738f, 0.03067921f, 0.03913885f, -0.00277974f, 
    0.02086300f, 0.04746759f, -0.00595973f, 0.03113868f, 0.03790784f, -0.03607053f, -0.04611555f, 0.04348806f, 
    0.03761812f, -0.01884891f, 0.03625234f, 0.02332815f, -0.00765900f, -0.05520823f, -0.00654501f, -0.00247128f, 
    -0.03548469f, -0.01845757f, 0.01127601f, -0.04204926f, 0.02001494f, 0.00032679f, -0.03538581f, -0.03789349f, 
    -0.05229871f, 0.01583170f, -0.03546847f, -0.01186447f, 0.03927765f, -0.00753924f, -0.00408235f, -0.03775764f, 
    -0.02921765f, -0.05344990f, 0.00251272f, -0.02325925f, 0.03556800f, -0.04702039f, -0.03178702f, 0.01378335f, 
    -0.02109423f, -0.00792452f, 0.01553262f, 0.00274905f, 0.02974210f, 0.02781133f, 0.04467737f, -0.01872730f, 
    -0.05149851f, -0.03409744f, -0.05642643f, 0.03515822f, 0.00728931f, 0.00357421f, -0.00655822f, -0.04618512f, 
    -0.01155308f, -0.04143845f, -0.03478992f, -0.02489477f, -0.04954505f, -0.04738905f, 0.00666354f, -0.02967227f, 
    0.01541808f, -0.03665744f, -0.00265896f, 0.01465310f, -0.03549303f, 0.01124932f, 0.02494121f, 0.03718719f, 
    -0.03024166f, 0.04109287f, 0.04360687f, 0.02625691f, 0.03897037f, -0.04754098f, 0.03966758f, 0.03413141f, 
    -0.05431427f, -0.03602445f, -0.04618510f, -0.00282157f, -0.02342947f, 0.00207910f, -0.00186755f, -0.02883577f, 
    -0.02506378f, -0.04994888f, 0.01022677f, -0.04376922f, -0.02648286f, -0.00563186f, 0.01981224f, 0.03064524f, 
    -0.00057833f, -0.01660807f, 0.00673392f, 0.04388581f, 0.00076252f, 0.00246008f, 0.01903074f, 0.02571902f, 
    0.04299070f, 0.00832138f, 0.02504168f, -0.04218148f, 0.01950395f, -0.01463248f, -0.03880758f, 0.00749295f, 
    -0.01086414f, 0.00714320f, -0.05187692f, 0.03714409f, 0.01432296f, 0.02464412f, -0.02131133f, 0.00014601f, 
    0.02634701f, -0.04611155f, -0.03164490f, -0.04052564f, -0.04538394f, -0.04488405f, -0.02410352f, -0.02632034f, 
    0.01155605f, 0.01590456f, -0.04245492f, -0.04699359f, 0.00208750f, -0.02881992f, -0.03832615f, -0.05396963f, 
    -0.02494310f, -0.05169472f, -0.03758659f, -0.05361825f, -0.05366823f, -0.01042766f, 0.00790126f, -0.03437697f, 
    -0.03010738f, 0.02386884f, 0.00510523f, -0.00732604f, -0.04652331f, 0.02771575f, -0.04184238f, -0.03936139f, 
    -0.05468827f, -0.01740097f, 0.02348240f, -0.00552208f, -0.03289174f, 0.01046599f, -0.02664187f, -0.01842290f, 
    0.02939768f, -0.03168411f, -0.00929151f, 0.03326139f, -0.01911605f, -0.02704296f, -0.02934903f, -0.02108555f, 
    -0.02869050f, 0.02584250f, -0.01938132f, 0.03126328f, -0.04941773f, 0.00219782f, -0.04009018f, -0.00171194f, 
    -0.05602875f, 0.00101812f, 0.01279713f, 0.00499726f, -0.01545678f, 0.01913196f, -0.04716469f, -0.00377212f, 
    0.00614921f, 0.00230615f, -0.04229674f, 0.04251543f, -0.04287406f, -0.03672383f, -0.00111618f, -0.03089734f, 
    -0.04371683f, 0.03339200f, -0.00085482f, 0.04301098f, -0.05581939f, 0.02015759f, 0.02727190f, 0.01576747f, 
    -0.01463316f, 0.00686939f, -0.02055317f, -0.01460973f, -0.05408806f, -0.04740560f, -0.04371285f, 0.00870750f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02598863f, 0.07010692f, 0.04177653f, 0.02118887f, 0.02147144f, 0.05534099f, 0.11492585f, 0.00220967f, 
    0.02114494f, 0.08343323f, 0.04100312f, 0.02205564f, 0.09375955f, -0.01055115f, 0.04786010f, 0.07566047f, 
    -0.03171419f, -0.02055752f, -0.00783355f, -0.04432256f, -0.01821977f, -0.01474871f, 0.04871011f, -0.03894648f, 
    0.01048312f, 0.01268716f, -0.01502645f, 0.09915210f, 0.08485004f, 0.02142917f, -0.04913446f, -0.03386413f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15835735f, 0.29320285f, -0.08442883f, 0.07238106f, -0.05970957f, -0.03547180f, -0.23290640f, 0.10790934f, 
    0.30271038f, -0.04756408f, 0.07636079f, 0.23804465f, -0.14338677f, 0.01349793f, 0.09475853f, -0.00220029f, 
    -0.12632447f, -0.01698526f, -0.11020716f, 0.08647447f, -0.02240145f, 0.49230379f, 0.02702413f, -0.10542397f, 
    -0.06730358f, 0.08811098f, 0.00242032f, -0.08380776f, 0.03019904f, 0.01080133f, -0.09667448f, -0.11170177f, 
    0.15431556f, -0.04707634f, 0.10573932f, -0.09744889f, -0.13092935f, -0.04019659f, -0.01174026f, -0.16936566f, 
    -0.14734609f, -0.00287463f, 0.02440971f, -0.00067424f, -0.03245708f, -0.14589594f, -0.00495057f, 0.04987858f, 
    -0.12373798f, -0.16151899f, 0.03719982f, 0.02810468f, 0.15180565f, -0.06436932f, 0.06113301f, -0.07380463f, 
    -0.00346108f, 0.10708300f, 0.00345088f, -0.16103499f, -0.09617732f, -0.01716780f, -0.08592718f, -0.16137023f, 
    -0.57648730f, 0.13661459f, 0.30878314f, 0.27865803f, -0.05596283f, -0.04316598f, 0.10716464f, -0.12670667f, 
    -0.29281855f, 0.31695604f, -0.05726756f, -0.20846631f, 0.37040585f, -0.00959087f, -0.13763085f, -0.04953952f, 
    -0.00717186f, 0.16743122f, 0.00254150f, 0.24988848f, -0.11838316f, 0.09894401f, -0.05863585f, 0.07519407f, 
    0.25730824f, 0.08720026f, -0.04227641f, -0.11188535f, -0.17015141f, 0.00838155f, 0.06017581f, -0.00253166f, 
    0.46253553f, -0.24163255f, 0.37836722f, 0.20769346f, 0.16497305f, -0.32529533f, -0.13457796f, 0.05185346f, 
    -0.34911919f, -0.13804664f, 0.00109669f, -0.31281972f, -0.24439594f, 0.12666175f, 0.32477012f, 0.13790271f, 
    -0.10480695f, 0.06893449f, 0.05571029f, 0.07655432f, -0.14847916f, -0.04198274f, 0.19101372f, 0.12420564f, 
    0.17042406f, -0.04574905f, -0.00370646f, 0.27506593f, 0.24501477f, -0.16958699f, -0.01501111f, 0.15790124f, 
    0.43627125f, 0.27394721f, 0.07981021f, -0.39150667f, -0.24095410f, 0.06353813f, -0.31863260f, 0.16194260f, 
    0.22027254f, 0.18733528f, -0.01293773f, 0.02262283f, -0.22812133f, -0.02272225f, 0.04501464f, -0.07834651f, 
    -0.03737606f, -0.00293369f, -0.09824532f, 0.02892060f, -0.16025886f, 0.41318649f, 0.24782424f, -0.07906873f, 
    0.14421366f, 0.17657831f, 0.02007288f, 0.07489043f, -0.23495726f, -0.06894689f, 0.07386768f, 0.10116149f, 
    -0.22979403f, 0.20984536f, 0.13317369f, 0.43140790f, 0.33903471f, -0.14971659f, 0.30278203f, -0.06399476f, 
    -0.27122551f, -0.03441056f, 0.11089274f, 0.21283300f, 0.10711403f, 0.11713018f, -0.10462171f, -0.08014012f, 
    -0.07090341f, 0.03467751f, -0.11139362f, 0.52692562f, 0.06401370f, -0.32561201f, -0.18257450f, 0.12811419f, 
    0.24091892f, -0.01336136f, -0.07340895f, -0.01269220f, -0.30898997f, -0.15839405f, -0.08767458f, 0.12627551f, 
    0.32172951f, -0.17671748f, -0.09924813f, -0.05501779f, 0.34513772f, 0.05713753f, 0.18857440f, 0.09840219f, 
    0.05783940f, 0.09709931f, -0.02700620f, 0.21987167f, -0.08962967f, -0.04211736f, -0.38541633f, 0.22773172f, 
    -0.13403535f, -0.07465745f, -0.16526347f, -0.37814060f, 0.17116101f, 0.19989581f, 0.29173115f, 0.14283632f, 
    0.06082452f, 0.09524867f, -0.04258028f, 0.07444219f, 0.59824103f, -0.04700771f, -0.11362310f, -0.04818472f, 
    0.50127226f, -0.09886149f, 0.33667785f, -0.40195256f, -0.17882831f, 0.23021962f, -0.09212235f, -0.17438878f, 
    0.09931489f, 0.17560975f, 0.10530822f, -0.06949279f, -0.09474844f, 0.00186047f, -0.19777264f, -0.00607006f, 
    -0.01637959f, -0.05633053f, -0.01157837f, -0.17895561f, 0.11806407f, 0.31232303f, 0.42518869f, -0.11763303f, 
    0.18833764f, -0.14004633f, -0.05286834f, 0.01645981f, -0.08981628f, 0.02539386f, -0.07511954f, -0.06875584f, 
    -0.20731224f, 0.27332860f, 0.24495780f, -0.18821599f, -0.08281411f, 0.58133918f, 0.18862709f, -0.05376666f, 
    0.23668450f, -0.19128910f, -0.04571152f, -0.01436027f, 0.27612597f, 0.09697510f, -0.00156749f, 0.00380313f, 
    -0.02380560f, -0.15560673f, -0.04003093f, -0.15858391f, 0.07759865f, -0.28850025f, 0.11585008f, 0.10592414f, 
    0.06514287f, 0.13595936f, -0.01215896f, 0.26150745f, 0.22465405f, 0.17229417f, 0.12938955f, -0.14332564f, 
    -0.08383317f, 0.40970847f, -0.22174273f, 0.00936004f, -0.11195013f, 0.10188838f, 0.51594907f, -0.08249080f, 
    0.29360884f, -0.00708228f, -0.03772714f, 0.42468837f, 0.42524371f, 0.02154010f, -0.40179992f, -0.20154831f, 
    0.02623849f, -0.05486809f, 0.10754546f, 0.09511604f, 0.10804228f, -0.37303981f, 0.34839910f, -0.08788638f, 
    0.30259848f, -0.18561274f, 0.06639396f, 0.09776271f, 0.22881830f, -0.03297203f, -0.14656986f, -0.08236858f, 
    -0.46721479f, -0.03760311f, -0.13739438f, 0.20704155f, 0.38244873f, 0.16817008f, 0.19389917f, -0.12026361f, 
    -0.20214495f, 0.30651307f, 0.01004890f, -0.09144645f, -0.02803505f, -0.04847003f, 0.34007519f, 0.36600810f, 
    -0.14293995f, 0.14827438f, 0.00737157f, -0.02764589f, 0.13139217f, 0.06622464f, -0.29654890f, -0.03971060f, 
    -0.00248843f, -0.13006990f, 0.04932377f, -0.12213715f, 0.23163927f, -0.10096661f, 0.12809508f, -0.04727051f, 
    0.16929305f, 0.20469144f, 0.40080440f, 0.16543888f, -0.21202143f, 0.54193097f, -0.10295330f, 0.12374341f, 
    -0.21348059f, -0.47403508f, -0.05454917f, -0.22492836f, 0.03456232f, -0.09803842f, 0.13538928f, -0.20497471f, 
    -0.10636098f, 0.04982423f, -0.12814680f, 0.09947851f, -0.15773648f, 0.20534344f, -0.27655414f, 0.06495689f, 
    0.20358330f, -0.05340194f, -0.16752492f, 0.08035509f, 0.02160126f, 0.10889123f, 0.04897127f, 0.07580922f, 
    -0.17598362f, 0.20664769f, -0.12671524f, -0.00495118f, 0.15504923f, -0.08774777f, 0.04605028f, -0.07132190f, 
    -0.28777316f, 0.28396267f, 0.05293777f, 0.18074583f, 0.17689130f, -0.07294083f, 0.23268685f, 0.32735267f, 
    -0.12565328f, -0.17178078f, 0.14318556f, -0.06135472f, -0.06064736f, 0.23850855f, -0.36912650f, 0.13380611f, 
    -0.03418360f, 0.06940814f, 0.11086513f, -0.08697139f, 0.21237566f, -0.05091088f, 0.11373033f, 0.08588787f, 
    0.09535348f, 0.15872416f, 0.26848090f, 0.33073428f, 0.21989432f, 0.18993321f, 0.03992517f, 0.01357289f, 
    0.24564712f, -0.13949348f, 0.13157482f, 0.03643146f, -0.07430371f, -0.16033614f, 0.02491190f, -0.33889762f, 
    -0.07763034f, 0.03142237f, 0.08598235f, -0.48868409f, 0.01171725f, 0.16647342f, 0.38301083f, -0.03477173f, 
    0.25680116f, -0.08266386f, 0.05619707f, -0.09677426f, 0.56256002f, 0.07114805f, 0.12737401f, -0.10255071f, 
    0.21080655f, -0.11202376f, 0.03335623f, -0.42075551f, -0.16145371f, 0.04885855f, 0.57111865f, -0.02022557f, 
    -0.26738515f, 0.30741605f, 0.13238141f, -0.11831905f, 0.19898777f, 0.03014747f, 0.06564949f, 0.38608876f, 
    -0.12790863f, 0.08039090f, 0.06455972f, 0.03659124f, 0.13256699f, -0.14358136f, 0.14631028f, -0.17558584f, 
    0.05463360f, -0.07145665f, 0.14005382f, 0.02118240f, -0.28047094f, -0.03116717f, -0.04518078f, -0.06828563f, 
    0.08461769f, -0.02458963f, 0.14660171f, 0.43839473f, -0.37596950f, 0.01989431f, -0.32940340f, 0.15527324f, 
    -0.19459116f, 0.30597252f, 0.07783031f, -0.40295771f, 0.37179050f, 0.09732017f, 0.08429444f, -0.01684540f, 
    -0.13553172f, 0.12207220f, -0.02724336f, -0.06417272f, 0.14507158f, 0.23651664f, -0.40234065f, 0.08136676f, 
    -0.03676261f, 0.11184765f, -0.16117461f, 0.00597028f, 0.17748617f, 0.08073136f, 0.13902818f, 0.11339675f, 
    0.31299767f, -0.00188421f, 0.35339674f, 0.26449049f, -0.11942329f, -0.41882822f, -0.32936192f, 0.12767965f, 
    -0.07996059f, 0.25550461f, -0.06745788f, 0.19053091f, -0.12313154f, 0.14191520f, 0.25786990f, 0.15360354f, 
    0.06409180f, -0.02925348f, -0.17377572f, -0.12789239f, -0.06507555f, -0.03569198f, -0.10793324f, -0.06682176f, 
    0.20347227f, -0.14361203f, -0.06251886f, -0.16280746f, -0.08222432f, 0.10237844f, -0.06365827f, 0.08342430f, 
    -0.23801245f, 0.01704042f, -0.39260694f, 0.22726963f, 0.21540165f, 0.11096763f, -0.06211021f, 0.13102357f, 
    0.32496852f, -0.13607118f, 0.03033895f, 0.30356723f, 0.26590577f, 0.15389644f, -0.08428286f, -0.00393778f, 
    -0.01470489f, -0.09133448f, 0.10407797f, -0.15545748f, -0.01887597f, 0.19203280f, 0.08199364f, -0.15210631f, 
    -0.10334388f, 0.11926115f, -0.07276721f, -0.07226261f, 0.22852637f, 0.10572739f, 0.08859147f, -0.07296271f, 
    -0.42489135f, 0.42178655f, 0.28028080f, -0.16775881f, 0.11373774f, 0.32476091f, 0.34990132f, -0.05227412f, 
    -0.14420471f, 0.42923635f, -0.10324980f, 0.31292841f, -0.23510945f, 0.13677543f, 0.28686982f, -0.00358541f, 
    0.03422556f, 0.07108187f, 0.10460563f, 0.09533092f, -0.06517042f, 0.15628117f, 0.03802207f, 0.04983611f, 
    -0.14034900f, 0.03991990f, 0.04958561f, -0.21180627f, -0.17260174f, -0.15488155f, -0.05862609f, 0.02714876f, 
    0.37000370f, 0.19390649f, -0.09478180f, -0.01962021f, -0.07596141f, -0.42742422f, -0.04007183f, 0.08929379f, 
    -0.04540559f, 0.24018729f, -0.12976426f, 0.37515014f, 0.00503142f, -0.01703235f, -0.09807564f, -0.09179512f, 
    0.13932408f, -0.15275691f, 0.16576928f, 0.29954985f, -0.16890286f, 0.20538907f, -0.42801550f, 0.10874575f, 
    0.32577401f, 0.05780426f, -0.13536118f, -0.12438039f, -0.05200699f, 0.01434854f, 0.08833809f, -0.07512376f, 
    0.17241271f, 0.40190360f, -0.38480520f, -0.11310973f, -0.12717566f, -0.09697785f, -0.09808934f, 0.12053054f, 
    0.50438327f, -0.02708707f, 0.08955980f, 0.62397230f, 0.19521926f, 0.05169765f, 0.13657460f, 0.06139491f, 
    0.17062584f, -0.15300716f, -0.04164823f, 0.06226745f, 0.08261636f, -0.08696642f, -0.39583826f, -0.06624641f, 
    0.23227732f, -0.09815098f, -0.14109564f, -0.01191546f, 0.00078650f, -0.02934438f, -0.04150896f, 0.15665115f, 
    0.02209625f, -0.10419778f, -0.00632935f, 0.24309005f, 0.27161196f, -0.22353268f, -0.26317415f, 0.15445386f, 
    0.13314776f, 0.50150013f, -0.10698987f, 0.28630283f, -0.17389895f, 0.01125417f, 0.10024542f, 0.02665927f, 
    -0.06952534f, 0.10009424f, 0.07489157f, 0.05837934f, 0.10096684f, 0.29805100f, 0.28997809f, -0.18128301f, 
    0.00186475f, 0.05316514f, 0.14553168f, -0.34609672f, 0.14530960f, -0.12254287f, 0.13255253f, 0.12075983f, 
    -0.01504435f, -0.01398090f, 0.34469575f, -0.07637860f, -0.24778119f, 0.58460897f, 0.20537630f, 0.16899218f, 
    0.21250370f, -0.14567706f, 0.03870615f, -0.31038573f, -0.01139738f, 0.11493255f, 0.32007188f, 0.15240592f, 
    -0.00650671f, 0.00817520f, 0.08290821f, 0.00382995f, -0.02437406f, 0.07163227f, -0.31129748f, -0.01410495f, 
    -0.16889451f, -0.11470319f, -0.13843371f, 0.25328273f, -0.20517519f, 0.00730949f, -0.06950748f, -0.11950728f, 
    0.22291431f, -0.12176905f, -0.15782781f, -0.23300633f, -0.16071807f, 0.18381482f, 0.02579924f, -0.05262806f, 
    0.30105653f, 0.06528977f, -0.09372091f, -0.40765601f, -0.01926759f, -0.17246298f, 0.00617919f, 0.35820949f, 
    -0.01364408f, -0.07574113f, 0.00287203f, 0.39652270f, 0.02078516f, 0.13375548f, -0.06163922f, -0.06788584f, 
    -0.23026811f, 0.16462147f, -0.03934899f, 0.26741976f, -0.29571158f, -0.01095708f, 0.04001617f, -0.05561693f, 
    0.08278981f, -0.10042466f, -0.09890579f, 0.06906557f, 0.00732468f, 0.14616196f, -0.13106894f, 0.02067807f, 
    0.02013124f, -0.02265514f, 0.10207233f, -0.03012357f, -0.11081826f, 0.11166470f, -0.12972215f, -0.00090349f, 
    -0.11217678f, -0.00266050f, 0.13163505f, -0.09344452f, 0.14624159f, -0.12596783f, -0.14322662f, -0.05008445f, 
    -0.15813245f, 0.01981144f, 0.15965095f, 0.07829425f, -0.08625555f, -0.06178387f, -0.08059558f, 0.02496035f, 
    0.05248940f, -0.28683877f, -0.12846285f, -0.08831260f, 0.34085968f, 0.19379157f, 0.37676638f, 0.07408673f, 
    -0.05792975f, 0.01007583f, 0.05335777f, -0.10355385f, 0.30245391f, -0.03407537f, -0.02457333f, 0.22280623f, 
    0.00449882f, 0.16930269f, 0.02653005f, -0.38520560f, -0.16017774f, -0.12964755f, 0.31162849f, 0.02454725f, 
    -0.05604529f, 0.13227190f, 0.11470380f, 0.16310690f, 0.50236768f, -0.15805772f, 0.06572672f, -0.11923958f, 
    0.03646063f, 0.07850467f, -0.09649302f, -0.10991613f, -0.11706268f, -0.07170448f, -0.04283107f, -0.14160013f, 
    -0.16152160f, -0.17246082f, 0.12455525f, 0.14581917f, -0.15068798f, 0.10349070f, -0.18810070f, 0.12591277f, 
    0.07684523f, -0.14786594f, 0.14473921f, 0.14607365f, 0.02956970f, -0.13320772f, -0.14466532f, -0.03357715f, 
    -0.09966596f, 0.03187263f, -0.10763822f, 0.07924724f, -0.02587252f, 0.12993878f, -0.03300899f, -0.08641783f, 
    0.28599828f, -0.37100840f, 0.25981826f, 0.44823211f, -0.12250151f, -0.18399037f, -0.29529786f, 0.09803933f, 
    0.28897759f, 0.11885332f, 0.12427106f, -0.28236946f, 0.26053670f, 0.09450191f, -0.24392076f, -0.10043781f, 
    -0.03326280f, -0.11988318f, -0.04404124f, 0.10217464f, -0.09036797f, -0.03123136f, 0.26890448f, 0.13669713f, 
    0.11315504f, 0.08310594f, -0.09338611f, 0.28821865f, 0.09183603f, 0.14992869f, -0.14467616f, -0.04017137f, 
    -0.35757047f, 0.28716004f, 0.09289591f, 0.37277165f, 0.14680266f, -0.10828051f, -0.17760186f, 0.10478295f, 
    0.05718505f, -0.12136543f, -0.03503205f, 0.25623289f, 0.08266060f, -0.13846532f, 0.21403635f, -0.11930981f, 
    0.00967203f, 0.04543216f, -0.16210586f, 0.41248941f, -0.05144027f, 0.31434122f, -0.51655340f, 0.01294717f, 
    0.19249377f, 0.07477470f, 0.08024632f, 0.04323841f, -0.34546459f, 0.04103947f, 0.16348641f, 0.12138826f, 
    0.54974699f, -0.22062445f, 0.17619918f, -0.16360854f, 0.02127690f, 0.32372686f, -0.19538032f, -0.05094595f, 
    -0.17018551f, -0.41632795f, 0.06936809f, -0.16391754f, 0.02606215f, -0.11805733f, 0.27272347f, 0.08870430f, 
    0.14901590f, 0.12272226f, 0.13082987f, -0.14578716f, 0.00184813f, 0.03932234f, -0.05717435f, 0.01671966f, 
    -0.02812929f, -0.02425798f, -0.16591327f, 0.28203496f, 0.25149986f, 0.07641818f, 0.13677838f, 0.12410384f, 
    0.03301162f, -0.11942581f, 0.01030101f, -0.16577017f, 0.10466169f, -0.04820078f, -0.04384575f, 0.14495417f, 
    -0.00989330f, -0.02022695f, -0.01112453f, -0.00722473f, -0.09176492f, -0.10995788f, -0.08948149f, 0.06204380f, 
    -0.03794348f, -0.04077065f, 0.12156683f, -0.02646436f, 0.16238841f, -0.17192705f, 0.05079456f, -0.08283373f, 
    0.01005006f, -0.06144344f, -0.15788510f, -0.13881035f, 0.13413312f, 0.13091947f, -0.14548731f, 0.12390286f, 
    -0.16324416f, 0.10519132f, -0.01348080f, 0.21760032f, -0.37651125f, -0.14701974f, 0.01741408f, 0.15038292f, 
    -0.13915816f, -0.06445712f, 0.06231700f, -0.60398179f, 0.13006510f, 0.14088543f, 0.33352393f, 0.09038240f, 
    -0.07878535f, -0.13643207f, 0.05096161f, -0.02224857f, 0.08765703f, -0.14077017f, -0.24493401f, 0.15962227f, 
    -0.05609021f, -0.08199016f, -0.07642318f, 0.33042318f, -0.17243968f, 0.15278691f, 0.15204458f, 0.11009766f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.22535589f, -0.06968263f, -0.05812527f, 0.18016107f, -0.08933046f, 0.01639597f, -0.08474490f, 0.18305586f, 
    0.00544377f, 0.24341595f, 0.16211639f, 0.17170835f, 0.01120354f, 0.07494452f, 0.19061428f, 0.06898009f, 
    0.11974876f, 0.01445613f, -0.05656738f, -0.14398459f, 0.03663482f, -0.15211836f, -0.06751038f, 0.09582338f, 
    -0.17877354f, -0.02188137f, -0.11651723f, 0.13365708f, -0.18071441f, 0.11422217f, -0.02392356f, -0.09167252f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.28387803f, 0.01313199f, -0.39048150f, 0.26249850f, 0.41603601f, -0.24794488f, -0.02537262f, 0.14603035f, 
    -0.09454957f, -0.29133445f, -0.55758345f, 0.45717239f, -0.19124039f, 0.21685706f, -0.82480508f, -0.00865223f, 
    0.22899725f, -0.35493755f, -0.42005301f, 0.10093033f, 0.11195844f, -0.50538772f, -0.05739028f, -0.17812473f, 
    -0.02802117f, -0.37644523f, 0.06849987f, 0.03629227f, 0.15908122f, 0.27845013f, -0.09958445f, -0.27534702f, 
    -0.11105069f, 0.13958982f, -0.18357441f, 0.07781241f, 0.03606131f, -0.22043903f, 0.10979372f, 0.32465160f, 
    0.07948235f, -0.17310894f, -0.12373398f, 0.23921616f, -0.40587232f, 0.04057644f, -0.14123461f, 0.18229145f, 
    -0.27960953f, -0.33099872f, 0.08310545f, -0.63430750f, -0.40258148f, 0.09921785f, 0.26332879f, 0.22210719f, 
    -0.07173513f, 0.08043749f, 0.09196074f, 0.21849376f, -0.38545433f, 0.27311683f, 0.17608768f, -0.35038537f, 
    -0.02329119f, 0.12606449f, 0.04464739f, -0.16392127f, -0.04763926f, -0.19211216f, -0.59416634f, -0.27444625f, 
    0.07371423f, -0.03495361f, -0.16165298f, 0.00234757f, -0.12030894f, -0.52756506f, -0.18050565f, 0.34605893f, 
    -0.29935083f, -0.02515898f, -0.30210376f, -0.46304247f, 0.17316674f, -0.24349239f, 0.26953346f, 0.40687144f, 
    0.13100207f, -0.12131298f, -0.08699167f, 0.10809502f, 0.23095500f, -0.01791725f, 0.12872094f, 0.56196392f, 
    0.01578655f, -0.13264810f, 0.29879633f, 0.06410412f, -0.34316829f, 0.20140986f, 0.02910578f, -0.29110932f, 
    -0.39549863f, -0.33758223f, 0.14997950f, -0.11932981f, 0.13553713f, 0.02381498f, -0.65683478f, 0.36866495f, 
    0.20051718f, 0.08401221f, -0.18140210f, 0.02369414f, -0.32148623f, 0.27812663f, -0.39340606f, -0.40444148f, 
    0.00671127f, -0.14788228f, -0.01163514f, 0.26330039f, 0.32468548f, -0.28024489f, 0.04646230f, -0.51589441f, 
    0.15300916f, -0.11059763f, -0.00551345f, -0.03889748f, 0.22519901f, -0.18502669f, 0.15218572f, 0.13412063f, 
    -0.23979203f, 0.07016652f, -0.29982641f, -0.33945534f, 0.10669187f, -0.16362666f, 0.25316891f, 0.20612201f, 
    0.34106672f, -0.20837584f, -0.14465964f, 0.47899839f, 0.26174304f, 0.25550044f, -0.52007359f, 0.14776450f, 
    0.06299659f, -0.17634790f, -0.11312786f, -0.01334809f, -0.06335089f, -0.12455034f, -0.01803881f, 0.04147474f, 
    0.05236955f, 0.07924191f, -0.45519054f, -0.07728029f, 0.28214666f, -0.54507655f, 0.35932758f, 0.30403879f, 
    0.10749620f, 0.16554418f, -0.26134244f, -0.34754461f, -0.30765539f, 0.27812567f, 0.02270336f, -0.67966568f, 
    0.09915993f, 0.12792735f, -0.28972492f, -0.30952567f, 0.16881414f, 0.34175155f, -0.36008671f, -0.15352446f, 
    -0.01093917f, 0.17546560f, 0.06920990f, 0.13559102f, -0.48175910f, 0.01895791f, 0.15565649f, -0.76021177f, 
    -0.34682006f, 0.15357703f, -0.01724861f, 0.10751794f, -0.63956666f, 0.51600611f, 0.07936580f, -0.38977927f, 
    0.08831381f, 0.37706387f, -0.25623810f, 0.05516655f, -0.29965192f, 0.16811347f, -0.32043621f, -0.33896971f, 
    -0.21151769f, 0.02238717f, -0.69175947f, 0.15580526f, 0.18375944f, -0.62521756f, -0.54893440f, -0.65313405f, 
    0.13960984f, 0.17086661f, 0.03639615f, 0.21656899f, -0.04587081f, 0.02590817f, -0.03454967f, -0.08902989f, 
    0.27555737f, -0.00651255f, -0.17562000f, -0.03470967f, 0.18143782f, 0.19413896f, -0.12583511f, -0.22398880f, 
    -0.51079178f, -0.35640192f, 0.24630199f, -0.49026674f, 0.15223871f, -0.02637366f, 0.27239373f, -0.56869572f, 
    0.02920214f, -0.25390869f, 0.40568498f, 0.25102979f, -0.02792315f, 0.32037139f, -0.18386909f, 0.28788036f, 
    0.07727425f, -0.27155310f, 0.14237379f, -0.59507936f, 0.22238143f, -0.12642768f, -0.13486633f, 0.14637607f, 
    -0.45597982f, 0.15980250f, -0.54249370f, 0.33597931f, -0.41275948f, -0.19025791f, 0.28434190f, -0.07927366f, 
    0.01540030f, -0.32886344f, 0.28180268f, -0.18475756f, 0.25730446f, -0.54093593f, 0.38376805f, -0.46610141f, 
    -0.16686507f, -0.14657786f, -0.21666773f, -0.07440978f, -0.16618903f, -0.20561196f, 0.03995184f, 0.17874968f, 
    -0.17648678f, 0.34338796f, 0.04111572f, -0.20575748f, -0.40546799f, 0.34779897f, -0.01183165f, 0.13371800f, 
    -0.04261817f, -0.14858359f, 0.08542994f, -0.43562156f, 0.06272583f, 0.29187474f, -0.15931913f, 0.05646583f, 
    0.20313592f, 0.26446712f, -0.27740106f, 0.15131554f, -0.08137472f, -0.22129892f, 0.14551423f, -0.47464377f, 
    -0.33794889f, -0.15825129f, 0.36918128f, -0.00103153f, 0.21671991f, -0.35514566f, 0.12872836f, 0.03997110f, 
    0.00025230f, -0.24064207f, -0.08541358f, -0.27385482f, 0.19558552f, -0.12913835f, -0.01939090f, -0.61840773f, 
    -0.30570662f, -0.03729937f, 0.26240489f, 0.10907800f, -0.33694130f, 0.01906764f, -0.06388282f, 0.00084019f, 
    0.11142789f, -0.05739571f, 0.14049558f, 0.09942677f, 0.14712255f, 0.13778906f, 0.16466197f, 0.26836520f, 
    0.22288515f, -0.59349716f, 0.40001312f, -0.23126291f, -0.63834393f, -0.17511176f, -0.02843747f, -0.43192574f, 
    0.02857537f, 0.02191061f, 0.09323761f, -0.16666606f, -0.16528846f, -0.07817876f, 0.08346578f, 0.37137645f, 
    0.18447542f, -0.10873143f, -0.21122633f, -0.40979698f, -0.50632429f, -0.26140964f, 0.27925050f, -0.51794726f, 
    0.08957005f, 0.16104290f, 0.30203202f, -0.01084323f, 0.30344498f, 0.16997495f, -0.73703015f, 0.17408076f, 
    -0.61260462f, 0.56015760f, -0.05258264f, -0.18455283f, 0.20264447f, -0.03069457f, -0.12177870f, -0.27944919f, 
    -0.18283698f, 0.14993753f, -0.19755280f, -0.33543169f, 0.10434605f, -0.03970806f, 0.01171984f, -0.38724351f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03680749f, 0.13556720f, -0.03324653f, -0.07000583f, 0.04557245f, -0.07794517f, 0.05140460f, -0.09017427f, 
    0.08402180f, 0.02204708f, -0.01206008f, -0.15915921f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
