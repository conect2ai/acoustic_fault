#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.00886786f, 0.48370466f, -0.18693884f, 0.06527636f, 0.54924804f, 0.23094100f, 0.26029390f, -0.29693744f, 
    -0.36525312f, 0.31053296f, -0.22261223f, 0.27987957f, -0.49134263f, -0.34575909f, 0.27800333f, 0.43431443f, 
    0.15196984f, -0.12134378f, 0.03693972f, -0.21792893f, 0.11787286f, -0.09894836f, -0.06240162f, 0.00080396f, 
    -0.12927620f, -0.10359520f, 0.05265320f, -0.16766113f, 0.04141744f, 0.15378799f, 0.15169261f, -0.03363503f, 
    -0.12909269f, 0.15942390f, -0.30255157f, 0.06253364f, 0.09532696f, 0.02767067f, 0.09732182f, -0.06476334f, 
    0.02221233f, -0.03399513f, -0.09949630f, -0.15373670f, 0.02719310f, -0.16443259f, 0.13056958f, 0.11950810f, 
    0.14302361f, 0.24632719f, -0.15321255f, 0.07508197f, 0.09823816f, 0.45632616f, 0.01372874f, 0.09493116f, 
    -0.40407625f, -0.26369125f, 0.05737700f, 0.13055229f, -0.38632622f, -0.19569984f, -0.16293812f, 0.03949605f, 
    0.25553879f, 0.05698486f, 0.02197968f, -0.08417608f, 0.13579009f, -0.17502216f, -0.34852406f, -0.15134794f, 
    -0.32664412f, -0.36114076f, -0.53261632f, 0.28502449f, -0.14166580f, -0.45549968f, -0.43066815f, 0.10936470f, 
    0.07790592f, 0.38495091f, 0.30384654f, -0.24010958f, 0.22580579f, -0.29930237f, -0.14226371f, 0.22661147f, 
    -0.21808019f, -0.13116451f, -0.30064505f, -0.15479738f, -0.08216736f, 0.12131667f, -0.05849200f, 0.08158116f, 
    0.04041405f, 0.20560063f, 0.24047944f, 0.30924931f, -0.50676239f, 0.31103370f, -0.17958690f, -0.57309258f, 
    0.07924215f, -0.59862530f, -0.54282761f, 0.25633025f, -0.16446058f, 0.26504502f, 0.35889065f, 0.30620477f, 
    0.39245439f, 0.10301591f, -0.33640364f, 0.19230260f, -0.38456357f, -0.12165907f, -0.47070706f, -0.57212031f, 
    0.40889448f, 0.04751413f, -0.08316380f, 0.41306794f, -0.00261018f, 0.46920106f, 0.20509535f, 0.18580377f, 
    -0.14113852f, -0.69473815f, -0.29522470f, -0.14623746f, 0.04924584f, 0.25387520f, 0.25226745f, 0.27703238f, 
    -0.19220601f, -0.46956071f, 0.19303432f, 0.24102698f, 0.26407677f, -0.16201878f, 0.00318795f, -0.06888504f, 
    -0.03037221f, -0.12267046f, -0.09875061f, 0.27249613f, 0.03236743f, 0.06873378f, -0.62261629f, -0.29738769f, 
    -0.25873488f, -0.29962415f, -0.27921125f, 0.00776847f, -0.01038489f, -0.37566268f, 0.13825041f, 0.26037723f, 
    -0.20446713f, -0.22865558f, -0.24458820f, -0.41618192f, -0.32625329f, 0.07773189f, 0.16964026f, -0.10151642f, 
    0.00622204f, 0.01749861f, -0.09155511f, -0.20189886f, -0.14824766f, -0.06801178f, 0.00813390f, 0.52722251f, 
    0.35733324f, 0.26299557f, -0.46069452f, -0.41519389f, -0.23201005f, -0.03965915f, -0.23816255f, -0.39114130f, 
    -0.22991347f, -0.13357919f, 0.26100159f, 0.27070776f, 0.08889714f, 0.37582314f, -0.22081678f, 0.00584596f, 
    0.34381157f, -0.12265146f, 0.09030423f, 0.09357642f, -0.33017650f, -0.16441548f, -0.09616878f, -0.12381196f, 
    0.00733772f, -0.24991928f, 0.12077083f, 0.79901797f, -0.65284932f, -0.69869560f, -0.42680842f, -0.15605709f, 
    -0.07439765f, 0.05050769f, 0.59491086f, -0.04200957f, 0.02410309f, 0.33474365f, -0.12579621f, -0.14983180f, 
    0.07493136f, 0.27229479f, -0.08695728f, -0.47105643f, -0.01399669f, -0.04614792f, -0.13346803f, -0.08409047f, 
    0.36259973f, -0.62101823f, 0.23075385f, -0.18750361f, -0.76490229f, -0.34501961f, -0.02749556f, -0.03836929f, 
    0.34572092f, 0.38087061f, 0.04697561f, -0.31657916f, -0.18533291f, -0.38028586f, -0.53298551f, 0.28996682f, 
    0.20023085f, 0.14857852f, 0.04566278f, -0.01824405f, 0.18024522f, -0.05270928f, 0.04400758f, -0.03517769f, 
    -0.11320450f, -0.37842178f, -0.09453310f, 0.83521098f, 0.88055426f, -0.60190910f, -0.56638044f, -0.54148799f, 
    -0.23902959f, 0.12661129f, 0.15063971f, 0.15130636f, -0.15358043f, 0.13424954f, 0.21688604f, 0.35500658f, 
    -0.29105946f, 0.06327726f, 0.09654174f, -0.17179917f, -0.28474385f, -0.03370279f, 0.26788187f, -0.07637039f, 
    -0.09502321f, -0.18794021f, -0.04362478f, -0.69529885f, 0.21139430f, 0.34056181f, -0.13253684f, 0.11336047f, 
    0.09775028f, 0.42423949f, 0.21923971f, -0.23111603f, -0.36525834f, -0.20488398f, 0.05731912f, -0.11961073f, 
    -0.15002036f, 0.06470130f, -0.08330089f, -0.01752170f, -0.29255006f, -0.02637555f, 0.19486579f, -0.03400780f, 
    0.25996417f, 0.14676043f, -0.23206705f, 0.10644894f, 0.12098764f, 0.50900984f, 0.15579015f, -0.43763694f, 
    -0.21074574f, -0.02044526f, 0.30652380f, 0.07681756f, -0.19401377f, -0.51987344f, -0.36543989f, 0.08606961f, 
    0.10265511f, -0.12199720f, 0.00634499f, 0.20412724f, -0.14135070f, 0.08835770f, -0.27164555f, -0.26649922f, 
    -0.34061161f, -0.14766100f, -0.30629715f, -0.17429845f, -0.09468716f, -0.81291956f, 0.99464703f, 0.03988646f, 
    -0.48263595f, 0.29468745f, -0.56776899f, -0.29583654f, 0.05538625f, 0.50365573f, 0.32119900f, -0.17945459f, 
    -0.28875774f, -0.02396135f, -0.11653589f, 0.12375598f, 0.03642593f, 0.20278683f, 0.13406783f, 0.05353079f, 
    -0.06513663f, -0.19768104f, 0.04302405f, -0.16230705f, -0.05162361f, -0.15924378f, 0.53692096f, 0.24316983f, 
    0.01220984f, -0.32741526f, -0.26149952f, 0.04086008f, 0.24306943f, -0.32926777f, -0.40342921f, -0.08911399f, 
    0.07421529f, -0.22094665f, 0.17410415f, -0.28042552f, 0.20341791f, -0.27612534f, 0.17965685f, 0.03704564f, 
    -0.21143484f, -0.07059267f, -0.32813483f, -0.24364811f, -0.11385015f, -0.30221376f, -0.57185894f, 0.72789192f, 
    0.34265867f, 0.12830567f, 0.64804167f, -0.60177022f, -0.18048607f, -0.11383044f, -0.20087916f, -0.44946122f, 
    -0.38408649f, 0.11296317f, 0.07522175f, 0.14638834f, -0.17041916f, -0.16890357f, -0.00928765f, 0.05264901f, 
    -0.10334483f, 0.09989521f, 0.01457546f, -0.02607048f, 0.10212350f, 0.13915804f, 0.06575719f, -0.07601292f, 
    -0.45703030f, -0.53492826f, -0.23005971f, -0.26828212f, -0.19743657f, 0.11336394f, -0.14134738f, -0.43603137f, 
    -0.41171157f, 0.03678305f, -0.10283738f, -0.27005553f, -0.12309457f, -0.16271147f, -0.16414455f, -0.04384454f, 
    -0.19365059f, -0.25589928f, -0.17978033f, -0.18073647f, -0.04453861f, -0.09990727f, -0.22815990f, -0.30316609f, 
    -0.29782093f, -0.01300192f, -0.10541160f, -0.13164940f, 0.37944996f, 0.24202073f, 0.20942393f, -0.26329893f, 
    -0.20332664f, -0.16174775f, -0.08691846f, 0.14163241f, -0.16741870f, 0.02970141f, 0.23083702f, 0.06139629f, 
    0.11984756f, 0.05181793f, -0.07339671f, -0.07782870f, -0.12879804f, -0.24468631f, 0.10729281f, 0.04903456f, 
    0.05940917f, 0.01516728f, 0.21859056f, 0.08609854f, 0.03276168f, 0.29706216f, -0.49249691f, -0.11547453f, 
    0.40709379f, -0.32061401f, 0.13586581f, -0.01186713f, 0.02119917f, 0.13595200f, -0.20146245f, -0.34975207f, 
    0.35002077f, -0.15954487f, -0.23521787f, -0.11840985f, 0.29027852f, 0.17514932f, -0.14192730f, 0.17748237f, 
    0.13096462f, -0.30855760f, 0.20698978f, -0.54086703f, -0.35434288f, -0.09896956f, 0.27944911f, 0.44192046f, 
    0.27460927f, -0.42384088f, -0.33751038f, 0.13420336f, 0.14760067f, -0.05164772f, 0.35520780f, -0.26613164f, 
    0.43080336f, -0.20582496f, -0.06721935f, 0.11708311f, 0.24354038f, -0.34027576f, -0.18819176f, 0.00311252f, 
    0.37535465f, 0.10222728f, -0.08421241f, 0.07705846f, 0.66251892f, -0.51509517f, -0.40432525f, -0.05690986f, 
    0.47140282f, 0.39819112f, 0.05701214f, -0.16227509f, -0.38068941f, 0.12930441f, -0.12554272f, 0.36864549f, 
    -0.28570199f, -0.19929871f, 0.21304844f, 0.11360329f, -0.25856179f, 0.02009769f, 0.04153214f, 0.05754651f, 
    -0.15919273f, 0.05198129f, -0.04995441f, -0.13275371f, -0.03703048f, -0.62621212f, -0.35312161f, -0.22063537f, 
    0.20607981f, 0.01913676f, 0.27461359f, 0.16395421f, 0.38113013f, -0.09406663f, 0.23091908f, 0.02989311f, 
    0.07395253f, 0.24568981f, 0.01927521f, -0.18582088f, -0.26511639f, -0.10671775f, 0.01366477f, -0.22877371f, 
    -0.04999465f, 0.19035700f, 0.06354988f, 0.21880835f, -0.05014361f, 0.20955180f, 0.58226621f, -0.03038211f, 
    0.13567714f, -0.07778439f, -0.47942141f, -0.28774115f, -0.28979310f, 0.10704553f, 0.32731491f, -0.15283738f, 
    -0.39878884f, -0.37650996f, -0.22241817f, 0.02373207f, 0.27391770f, 0.25395334f, 0.12603745f, 0.16029692f, 
    0.04090840f, -0.20701252f, -0.28448051f, -0.26549438f, -0.17462540f, 0.09315130f, -0.32061365f, 0.11897548f, 
    -0.01897548f, 0.15969865f, 0.23673540f, -0.01286446f, 0.32286587f, 0.16797465f, -0.04501295f, 0.19278218f, 
    -0.23887947f, -0.00013251f, 0.47937608f, 0.14876355f, -0.26563653f, -0.25505739f, -0.23609048f, 0.00244748f, 
    -0.02192399f, 0.19950014f, -0.16374570f, -0.07625796f, 0.04125929f, -0.02420596f, 0.02992638f, 0.07366630f, 
    0.61709911f, 0.32317179f, -0.25748643f, -0.14237802f, 0.14161186f, -0.10867999f, 0.00038559f, 0.09438831f, 
    -0.12889387f, -0.26531339f, 0.09692942f, 0.02658038f, 0.17619058f, -0.21120612f, -0.20431536f, 0.02230849f, 
    -0.18397911f, 0.28843281f, -0.22334681f, -0.16006482f, -0.26201653f, -0.06511199f, 0.11983396f, -0.00528047f, 
    -0.23474133f, 0.19107045f, 0.24715285f, 0.24086134f, 0.19340041f, -0.01539017f, 0.25525773f, 0.21074589f, 
    0.29325327f, -0.02725232f, 0.05967512f, 0.14381209f, 0.11647571f, -0.06859660f, 0.01929585f, -0.06872379f, 
    0.10373153f, -0.12124432f, 0.08276930f, -0.16521223f, -0.09762101f, 0.08739575f, 0.09032633f, -0.06125539f, 
    -0.00067308f, -0.07847094f, -0.81497651f, -0.64261001f, -0.18586105f, 0.22296675f, 0.78881490f, -0.06026225f, 
    -0.40012696f, -0.29086202f, -0.28241792f, 0.42111582f, -0.24232179f, 0.23600163f, 0.22641701f, -0.11880953f, 
    -0.36480749f, 0.37432495f, 0.09720648f, -0.13720065f, -0.06201057f, -0.11533172f, 0.26660368f, -0.14218688f, 
    -0.34044886f, -0.14840674f, -0.14673802f, 0.20123649f, 0.26179418f, -0.33043829f, 0.32253832f, -0.34091446f, 
    -0.48499823f, -0.46300927f, 0.30709356f, 0.54716760f, -0.04506410f, 0.17829841f, 0.08532888f, 0.00341971f, 
    -0.04477932f, -0.05390317f, -0.08016642f, -0.12382279f, 0.16950305f, -0.11822191f, 0.05619363f, 0.14193934f, 
    0.16807361f, -0.21273486f, 0.20725970f, -0.01486113f, 0.83637732f, 0.48777711f, -0.48884007f, -0.24198790f, 
    -0.89301056f, 0.02194451f, 0.17551833f, -0.28822345f, 0.13600039f, 0.30594873f, 0.08496575f, 0.31335187f, 
    -0.06981318f, -0.06606123f, -0.07890434f, 0.07882677f, -0.16120858f, 0.19203743f, 0.09863915f, -0.46001366f, 
    -0.05246858f, -0.08505428f, -0.06099021f, -0.10657175f, -0.03351722f, 0.01855282f, -0.09130795f, -0.18149596f, 
    -0.00060057f, 0.62084711f, 0.32147914f, 0.29487896f, -0.19434498f, -0.50744665f, -0.53456450f, -0.02190081f, 
    0.30148858f, -0.09341309f, -0.15929866f, -0.11627138f, -0.07605880f, -0.27288121f, 0.17513384f, 0.06292082f, 
    0.02690296f, 0.32408753f, -0.01144121f, 0.00180773f, -0.16393259f, -0.30136195f, -0.07069418f, 0.07984420f, 
    0.34619281f, 0.01003219f, -0.15651971f, -0.48493844f, 0.00790441f, 0.36981276f, -0.11072260f, -0.10039311f, 
    -0.28100413f, -0.02508344f, -0.00754147f, 0.09118792f, 0.15900330f, -0.18037964f, 0.11143482f, -0.05819292f, 
    0.21934965f, -0.30779496f, 0.06432297f, -0.25714079f, 0.08549578f, 0.37006453f, -0.13605720f, -0.41342667f, 
    0.07806987f, 0.15450455f, 0.36121693f, 0.25751096f, 0.21010710f, 0.15907349f, 0.10195208f, 0.12565957f, 
    0.12752481f, 0.15825427f, 0.10835297f, -0.15490793f, -0.16884017f, 0.03119517f, -0.11893072f, 0.08591484f, 
    -0.13377517f, -0.21110664f, -0.03518034f, -0.13649750f, -0.26871783f, 0.20589687f, 0.08283135f, 0.09717014f, 
    0.12381808f, -0.37491533f, 0.08744600f, 0.18979329f, 0.12630363f, 0.59957486f, -0.64759570f, -0.36425343f, 
    0.03638446f, 0.45217603f, -0.09278892f, -0.03879594f, -0.03053578f, 0.20241977f, -0.07228030f, 0.20388432f, 
    0.02942401f, 0.04309272f, -0.08749287f, -0.20288254f, -0.10813469f, 0.19371855f, -0.17608911f, -0.02582863f, 
    -0.05382425f, 0.36911118f, -0.23822474f, -0.16723152f, 0.25070944f, 0.18282549f, -0.32109225f, -0.12864968f, 
    -0.07456785f, 0.01262766f, -0.00240467f, 0.11270966f, -0.19962786f, 0.17178412f, 0.03415020f, -0.01880379f, 
    0.16778202f, 0.13903376f, -0.04643142f, -0.03880946f, -0.34892449f, -0.11330399f, 0.01672236f, 0.15148297f, 
    0.16073039f, -0.07008182f, 0.40841129f, 0.12881000f, -0.03090807f, -0.44037220f, -0.15016203f, 0.12786762f, 
    -0.40237954f, -0.26560152f, 0.26021901f, 0.15217076f, 0.00265296f, 0.22950056f, -0.14683397f, -0.04681329f, 
    0.12852170f, 0.20725490f, 0.33876374f, 0.12466928f, -0.34804657f, -0.28134087f, -0.15234806f, -0.12899943f, 
    -0.15689994f, 0.02596030f, 0.31544501f, -0.25508568f, -0.55511492f, -0.22238681f, -0.09849294f, -0.13192803f, 
    -0.24802269f, -0.18700568f, -0.07798295f, -0.37571093f, -0.64671487f, 0.07009713f, 0.43273219f, -0.08206054f, 
    0.54051369f, -0.09665708f, -0.26449105f, -0.35836747f, -0.11969200f, 0.13182144f, -0.24791789f, -0.36745998f, 
    -0.15227374f, -0.11929926f, 0.22642873f, -0.28761810f, -0.05995765f, -0.54607552f, -0.24749425f, -0.32221159f, 
    -0.29873934f, -0.12398824f, -0.25179842f, -0.47369331f, -0.47806296f, -0.27957198f, -0.12000453f, -0.10925597f, 
    -0.14626206f, 0.25757772f, -0.12978756f, -0.23595750f, -0.12849315f, -0.26566190f, -0.38038746f, -0.29047525f, 
    -0.39306897f, -0.20771104f, 0.27782109f, -0.07063244f, -0.09472282f, 0.58839995f, -0.62277633f, -0.44712242f, 
    -0.56710815f, -0.76212388f, 0.50179535f, 0.30748785f, 0.46996549f, 0.01510093f, 0.08668183f, 0.05302195f, 
    0.06069855f, 0.22030443f, -0.22946134f, 0.21773656f, 0.14276476f, -0.14243159f, 0.11082499f, -0.34666181f, 
    0.12348396f, 0.11531500f, -0.18655214f, -0.11849497f, -0.02771582f, 0.09747645f, 0.18679921f, 0.20457630f, 
    -0.01675261f, 0.46621430f, 0.33138895f, -0.37551138f, -0.40613291f, -0.39752245f, -0.16532473f, -0.04260849f, 
    0.15864541f, 0.25072691f, -0.18357588f, 0.07791166f, 0.27724352f, -0.11838825f, -0.07369857f, 0.06055203f, 
    -0.26936188f, 0.22237682f, -0.22314484f, 0.09077771f, -0.03965613f, 0.12822473f, -0.09269460f, 0.11707035f, 
    0.30223083f, -0.50320876f, -0.50306976f, -0.30584916f, -0.08754917f, -0.21692035f, -0.00159097f, 0.08292440f, 
    -0.30325177f, -0.17312548f, -0.08165302f, 0.18346748f, -0.19717047f, -0.18982480f, 0.00127711f, -0.49743944f, 
    -0.02334224f, -0.19813006f, -0.09839189f, -0.05090919f, 0.28372854f, 0.10076558f, -0.11107434f, 0.33522397f, 
    -0.16387847f, -0.96138781f, -0.57004935f, 0.18953195f, -0.34574452f, 0.47388968f, 0.21549743f, 0.20221750f, 
    0.15338455f, 0.48467040f, 0.29227015f, -0.23771931f, -0.23159184f, -0.12708779f, 0.13131075f, -0.14582096f, 
    0.06053701f, 0.22290833f, 0.29992375f, 0.05343012f, 0.13865681f, -0.30932426f, 0.25790146f, -0.16545172f, 
    -0.28971922f, 0.22309777f, -0.16778308f, 0.34629327f, 0.32729825f, -0.28036436f, -0.37336352f, -0.61760378f, 
    0.16490142f, 0.36463574f, -0.33992881f, 0.35153005f, 0.00640557f, -0.01847093f, 0.23560432f, -0.04155668f, 
    -0.03339631f, 0.55736935f, -0.37744614f, -0.29787758f, -0.11684019f, -0.14566489f, -0.04550586f, 0.30013654f, 
    0.06397080f, -0.25144073f, 0.43676230f, 0.59359896f, -0.27892613f, -0.36727548f, -0.57378203f, 0.22787535f, 
    0.15396421f, -0.22274062f, 0.27608392f, -0.25205138f, -0.24488375f, 0.02210086f, -0.18137208f, 0.06122722f, 
    0.20782216f, -0.09605192f, 0.01808730f, 0.02913829f, -0.01825774f, 0.02473327f, -0.11123946f, 0.24416173f, 
    -0.05696572f, -0.03149799f, -0.13942064f, 0.52304971f, 0.05111012f, 0.41577280f, 0.06071188f, -0.49406981f, 
    0.02234355f, -0.16602123f, -0.00683909f, 0.19734259f, -0.32648095f, 0.07913452f, -0.29091039f, -0.23852551f, 
    -0.13167910f, -0.14201322f, 0.47890699f, 0.24173342f, -0.00161314f, -0.23969969f, 0.05926758f, -0.11209679f, 
    0.10960143f, -0.20610514f, -0.07121062f, -0.15256168f, 0.56420618f, 0.21141431f, -0.25755924f, -0.05398632f, 
    -0.44812274f, 0.26641941f, -0.03192203f, 0.04552542f, -0.23270811f, 0.11988974f, -0.11885501f, -0.05608725f, 
    -0.11200151f, -0.22268853f, -0.13838592f, 0.31537098f, 0.33147618f, -0.02347355f, -0.27783039f, -0.41409495f, 
    -0.32155949f, 0.29438606f, 0.28072619f, -0.08762829f, 0.30205980f, -0.86133480f, -0.33375603f, -0.38038424f, 
    0.53030545f, 0.55418444f, 0.30224177f, -0.45596477f, -0.25782537f, 0.37933680f, 0.38938844f, 0.34805426f, 
    0.16199280f, -0.19443089f, 0.21637923f, -0.00135844f, -0.02055096f, -0.13094316f, -0.03211728f, -0.08153036f, 
    -0.32353094f, -0.15745205f, 0.03036881f, -0.11986889f, 0.27902770f, -0.23826976f, 0.53475618f, -0.18575773f, 
    -0.53113616f, -0.50791901f, 0.05341239f, 0.26412666f, 0.06618356f, -0.31983984f, 0.16354838f, -0.01704463f, 
    0.04981442f, 0.01047521f, 0.26844478f, 0.08008215f, -0.24852295f, -0.39721891f, -0.14682621f, 0.01259871f, 
    0.23360427f, -0.29362985f, 0.34875697f, -0.27469203f, -0.19116420f, 0.33639839f, 0.28864747f, -0.34010193f, 
    -0.25362742f, 0.40581194f, 0.78426915f, -0.65299290f, 0.32938391f, 0.07787997f, -0.30344999f, -0.00470248f, 
    -0.18978603f, 0.04987774f, -0.22184776f, 0.11019610f, 0.11033132f, -0.17558047f, -0.02099879f, 0.30495706f, 
    0.14233255f, -0.36771157f, 0.10770109f, -0.24036802f, -0.19857304f, 0.35606390f, 0.18645097f, -0.26442689f, 
    0.27339619f, -0.08303894f, 0.03497335f, -0.10951603f, -0.00546262f, -0.01877937f, -0.14298329f, 0.18642062f, 
    0.31252891f, 0.21193124f, -0.08450678f, 0.07532115f, 0.03927660f, 0.14421137f, 0.04941426f, -0.20494041f, 
    0.08487745f, -0.14530943f, -0.08742981f, -0.15021889f, 0.03922235f, 0.18175882f, -0.05324771f, -0.19499949f, 
    0.12317182f, -1.15163374f, 0.45536357f, 0.28117302f, -0.94446772f, -0.63845283f, 0.33751670f, 0.01845310f, 
    0.12170517f, 0.33337346f, 0.25504559f, -0.19383150f, -0.10981591f, -0.11836582f, -0.34910107f, -0.17870672f, 
    0.22281598f, 0.02974755f, 0.01508845f, 0.19592190f, 0.13082601f, -0.01065084f, 0.04349336f, -0.08776618f, 
    -0.15771264f, -0.15624900f, -0.04465719f, 0.24656998f, 0.09450845f, -0.28858945f, 0.15642138f, -0.08450893f, 
    0.04259396f, -0.16604072f, 0.13256401f, 0.05196293f, 0.28006247f, -0.08743434f, 0.19547094f, -0.31840366f, 
    0.17749985f, 0.12434903f, 0.06344780f, 0.19317716f, 0.04124242f, 0.05653287f, 0.21657959f, -0.02801721f, 
    -0.24323621f, 0.04509814f, 0.03196844f, -0.48681676f, -0.26099783f, -0.41028780f, -0.16885799f, 0.01856442f, 
    -0.34914070f, -0.31369039f, -0.49509203f, -0.28402036f, -0.22699866f, 0.26587081f, 0.31650665f, 0.06020997f, 
    0.03618507f, -0.11346553f, 0.09365127f, -0.15456627f, 0.02096529f, -0.08133431f, 0.13006382f, 0.20580864f, 
    0.32083240f, 0.01933638f, 0.24480581f, 0.19807784f, 0.56506401f, 0.04764948f, 0.14170784f, -0.28278816f, 
    -0.31134430f, 0.50877255f, 0.40255001f, -0.26300094f, -0.53137326f, -0.14099753f, 0.02396755f, -0.01964619f, 
    -0.14421555f, -0.12131727f, -0.00128516f, 0.26902038f, -0.16261350f, 0.25333044f, -0.06141913f, -0.15214415f, 
    -0.06146837f, 0.27185857f, 0.07064173f, -0.20146617f, -0.01106604f, -0.54493743f, -0.51319969f, -0.36451608f, 
    0.12309042f, 0.18378186f, -0.23089138f, -0.26991996f, -0.22814791f, -0.13436882f, -0.52428234f, -0.08828717f, 
    0.29887426f, -0.23152657f, 0.14658764f, -0.22846268f, -0.12039254f, 0.12329033f, 0.22214383f, 0.13711508f, 
    0.04767592f, -0.13447088f, 0.02290426f, 0.18601757f, -0.07432618f, -0.18052928f, 0.63073009f, -0.13355431f, 
    -0.44357270f, -0.55851412f, -0.80031568f, 0.19142617f, 0.22152238f, 0.26593420f, -0.14086060f, 0.07405096f, 
    0.09567941f, 0.55425560f, 0.27305493f, -0.20849165f, -0.11975344f, -0.33290836f, 0.20847680f, 0.23453532f, 
    -0.23229444f, 0.07635874f, -0.17600311f, 0.04437627f, -0.28328803f, 0.15623707f, 0.08078289f, 0.07081081f, 
    0.15168364f, 0.10392491f, -0.13852739f, -0.29029036f, 0.28619656f, -0.11199854f, 0.14255972f, -0.13334680f, 
    0.09283413f, 0.03561554f, 0.01535239f, -0.13998125f, -0.14752942f, 0.27189827f, 0.17035718f, -0.28605005f, 
    -0.15390122f, 0.18329859f, 0.09795374f, 0.14460708f, -0.01165097f, -0.07063755f, 0.00739448f, 0.01110117f, 
    -0.12583645f, 0.08270889f, -0.32668477f, 0.08169297f, 0.44580817f, -0.48172879f, -0.49197772f, 0.76657349f, 
    -0.28172413f, -0.41755450f, 0.09102487f, -0.20311148f, 0.30174768f, 0.16468665f, -0.10601387f, 0.31791148f, 
    0.03355128f, -0.07329270f, -0.20520476f, -0.13117148f, -0.19302514f, -0.16628657f, 0.15622322f, -0.04136935f, 
    0.18540365f, 0.07312324f, -0.08711139f, 0.03831459f, 0.15843001f, -0.31119159f, 0.53078490f, 0.16398124f, 
    -0.41318682f, -0.27403226f, -0.58336836f, 0.32388178f, -0.10683982f, -0.28794014f, 0.10612196f, -0.27316061f, 
    -0.14457113f, -0.08961023f, 0.06255383f, -0.20220552f, -0.08873292f, 0.09180067f, -0.02372285f, -0.18690112f, 
    -0.06008824f, 0.16946898f, -0.29190046f, 0.14657755f, 0.14189278f, -0.65328664f, -0.36520439f, -0.25910246f, 
    0.14384708f, 0.28452370f, 0.18338983f, -0.06384704f, 0.23582336f, 0.13321880f, 0.34892440f, -0.53515673f, 
    -0.09384572f, -0.14090143f, -0.29716402f, -0.30219668f, -0.12639087f, 0.35540053f, 0.05805918f, 0.30803376f, 
    -0.06246161f, -0.28669372f, 0.64106530f, -0.85207707f, -0.58068866f, -0.10236633f, 0.09695469f, 0.17773330f, 
    0.41569525f, 0.18572916f, -0.11379433f, 0.17343526f, 0.51634926f, -0.16634957f, 0.14754622f, 0.07944921f, 
    0.15761299f, -0.02467109f, -0.03599631f, -0.16751878f, -0.19576189f, 0.20974748f, -0.12103163f, 0.06766560f, 
    -0.03902809f, 0.07527366f, -0.06602243f, 0.23956394f, -0.79058540f, -0.46669784f, -0.73367792f, -0.20095336f, 
    -0.44944701f, 0.44451857f, 0.12985620f, 0.08829641f, -0.05911202f, 0.49992809f, 0.39187840f, 0.27080491f, 
    0.34047759f, -0.13698739f, 0.03674279f, -0.00794295f, -0.21649459f, -0.10380728f, -0.15631263f, -0.15231168f, 
    -0.15960443f, 0.03103423f, -0.02481291f, 0.04657856f, -0.21768063f, -0.55376440f, -0.35294870f, -0.15442899f, 
    0.05340943f, 0.39417955f, 0.09485415f, -0.24265003f, 0.18369178f, 0.33263886f, -0.10364311f, 0.11627955f, 
    0.22942527f, -0.02259485f, -0.17709345f, -0.18653259f, 0.04725463f, 0.17410183f, -0.00757210f, -0.17310016f, 
    -0.20639382f, -0.02701838f, -0.14767250f, 0.25654739f, -0.06914416f, -0.20736217f, -0.17225112f, -0.21219639f, 
    0.45790207f, 0.27380276f, -0.00633784f, -0.41024700f, -0.78092986f, -0.17789675f, 0.56747711f, 0.29322970f, 
    0.50482184f, -0.10452967f, -0.03412886f, 0.31765750f, -0.22891666f, -0.23905654f, 0.12007076f, 0.13183835f, 
    -0.26815784f, -0.15024367f, 0.02464050f, 0.07559778f, 0.01340335f, -0.22139707f, 0.16203715f, -0.46790206f, 
    -0.48490787f, -0.33494338f, -0.02595231f, -0.46551418f, 0.13076946f, -0.11335560f, 0.05443121f, 0.27309510f, 
    -0.11551232f, -0.23738194f, -0.37917250f, -0.22566313f, 0.57444555f, 0.24505450f, -0.00027150f, -0.06229211f, 
    -0.36858428f, -0.36639807f, -0.50265634f, -0.21079950f, 0.02477430f, 0.24918401f, 0.14198421f, 0.19518575f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28102440f, 0.05030895f, 0.04185451f, -0.35084635f, -0.01618188f, -0.03160302f, -0.33139604f, -0.04590973f, 
    -0.01812491f, -0.24370174f, 0.04938335f, -0.06284536f, -0.08038966f, 0.03732699f, -0.00899065f, 0.13421308f, 
    -0.05951744f, -0.15582617f, 0.00716290f, -0.06780332f, 0.02000532f, 0.02927409f, -0.17345935f, -0.23749904f, 
    -0.13761918f, -0.40066314f, 0.02310907f, 0.09032091f, 0.20057069f, -0.09225540f, 0.07095881f, -0.21238586f, 
    0.06488848f, 0.01273887f, 0.15660343f, -0.10697754f, -0.18735766f, 0.21603169f, -0.26219305f, -0.14329560f, 
    -0.17877553f, -0.11720099f, 0.10899604f, 0.12889561f, 0.14865382f, -0.22326729f, 0.22043048f, 0.05756086f, 
    -0.18535213f, -0.21863815f, -0.17513649f, -0.01319811f, 0.15057327f, -0.35360211f, 0.14634210f, 0.15939932f, 
    -0.05341551f, -0.07609058f, -0.06616701f, 0.01573619f, 0.14966446f, -0.18980229f, 0.07971472f, -0.05232272f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.35120392f, -0.32456741f, 0.03411093f, 0.23759365f, 0.12744936f, -0.00290381f, 0.00672792f, -0.08746585f, 
    0.01512192f, -0.00190120f, -0.04875208f, 0.02123316f, 0.01752961f, 0.04997455f, 0.04632576f, -0.00077302f, 
    -0.01963711f, 0.05223094f, 0.02293678f, 0.01387548f, -0.13586843f, 0.05290801f, 0.00547494f, -0.05513884f, 
    -0.03617883f, 0.06364848f, -0.09333286f, -0.08635668f, 0.00343785f, 0.00108980f, -0.09801922f, -0.06494121f, 
    0.07154122f, 0.19850801f, 0.09336475f, 0.14450969f, 0.07507326f, 0.04453132f, 0.05202266f, 0.00894984f, 
    -0.02276380f, 0.01191973f, 0.05457777f, 0.00579601f, -0.05477367f, -0.10102435f, 0.01127722f, -0.31562492f, 
    -0.14822125f, -0.39081725f, -0.23447789f, 0.13808687f, 0.09595016f, 0.08593636f, 0.05298344f, 0.15399450f, 
    0.01252402f, 0.00933797f, 0.00573246f, 0.07591545f, 0.00863430f, 0.11794901f, 0.26694569f, 0.13635364f, 
    0.03775700f, 0.19020958f, 0.13917787f, -0.03452668f, -0.05784030f, 0.08874170f, 0.01003120f, 0.00621405f, 
    0.15003456f, 0.15045716f, -0.01450093f, 0.09330688f, 0.05703702f, 0.12432989f, 0.05784211f, 0.03052772f, 
    -0.02382923f, -0.05532503f, -0.16466747f, -0.05040127f, -0.09558555f, -0.10697608f, 0.03947128f, -0.05359957f, 
    0.19939370f, 0.14355753f, -0.04787162f, 0.06120575f, 0.20699660f, 0.11910001f, -0.04171817f, 0.17123733f, 
    -0.70213354f, -0.17715727f, -0.05857719f, -0.22955242f, 0.03534499f, -0.09539382f, -0.01299252f, -0.00967438f, 
    -0.07942395f, -0.20178287f, -0.00149684f, 0.00589683f, -0.12198982f, 0.15817365f, 0.09350143f, 0.16087776f, 
    0.19651526f, 0.09889176f, -0.02344193f, -0.16340603f, -0.08181067f, -0.03996117f, -0.12500262f, -0.14115535f, 
    0.29764748f, -0.37070045f, 0.33013785f, -0.19993517f, 0.01893494f, 0.18998504f, -0.10498753f, 0.10268322f, 
    0.16947258f, -0.11540551f, 0.23540278f, 0.05092053f, 0.14939636f, -0.13062948f, -0.06134633f, -0.08047023f, 
    -0.06342749f, 0.01132846f, 0.08337520f, -0.13479061f, -0.05964305f, 0.13760829f, 0.04908700f, -0.05919632f, 
    0.21409243f, -0.08570097f, 0.13597360f, -0.02048078f, -0.03445037f, -0.06785819f, -0.01181602f, -0.06560804f, 
    -0.02601370f, 0.14933631f, 0.01860670f, 0.04464668f, 0.28694904f, -0.25330386f, 0.17334758f, -0.12184419f, 
    0.01629970f, 0.26550421f, -0.17391251f, 0.22307356f, 0.07743628f, 0.06884581f, -0.10521416f, 0.07460315f, 
    -0.12833785f, -0.08090384f, 0.07046331f, -0.06913800f, 0.01951918f, -0.06686482f, -0.10092468f, -0.04997861f, 
    0.01431339f, 0.06939425f, 0.18638203f, 0.15762985f, -0.13906956f, 0.40148395f, 0.36304575f, -0.24360260f, 
    -0.22613451f, -0.26648280f, -0.12097929f, -0.15030377f, -0.08464018f, 0.01788544f, 0.05130341f, 0.01738289f, 
    -0.03683006f, -0.05793206f, 0.07433740f, 0.19866221f, -0.03197364f, -0.05512068f, 0.01041270f, 0.08135518f, 
    -0.10271026f, -0.10067412f, 0.10524356f, 0.07235967f, -0.05676737f, 0.04935267f, 0.05371180f, 0.01737711f, 
    0.01443346f, -0.04585320f, 0.00813820f, 0.05549640f, -0.02394828f, 0.14409645f, 0.00139732f, -0.09227107f, 
    0.14734933f, 0.31139696f, -0.06207446f, 0.01902559f, -0.05947346f, 0.05382524f, 0.00044810f, -0.00263986f, 
    0.00653326f, 0.12513307f, 0.07601313f, -0.26199830f, -0.07662833f, -0.11636623f, 0.05418989f, 0.07434683f, 
    -0.01012668f, 0.05687528f, -0.05343979f, 0.24820994f, -0.12002189f, -0.10845982f, 0.01815243f, 0.00410483f, 
    0.09271377f, -0.04288706f, -0.13388397f, 0.22840363f, 0.00203085f, -0.00275357f, -0.00168388f, 0.05998379f, 
    -0.04989507f, 0.19774985f, 0.02332662f, 0.16275932f, 0.06050843f, -0.00018279f, -0.11256798f, -0.04110926f, 
    -0.09565066f, 0.00049016f, 0.10596156f, 0.03072242f, -0.05544980f, -0.10967248f, -0.04975081f, 0.06760824f, 
    -0.02611727f, 0.04242366f, 0.20510952f, 0.09152229f, 0.03430165f, 0.10806111f, 0.15172984f, -0.18174188f, 
    0.01546506f, 0.02563012f, -0.06920163f, 0.01385106f, 0.19770543f, 0.34478128f, 0.12080102f, -0.01099086f, 
    -0.06771638f, -0.06478366f, -0.01077665f, 0.04597848f, -0.05528069f, 0.09385378f, 0.05313718f, -0.02907183f, 
    0.06860188f, 0.11957514f, 0.42961088f, -0.09672946f, -0.00796557f, -0.16028781f, -0.03669037f, -0.03790278f, 
    0.04129810f, 0.13314919f, -0.03831221f, 0.17427714f, 0.14316578f, 0.13901155f, 0.11306778f, 0.00154848f, 
    -0.07013258f, -0.04704212f, -0.03204953f, 0.01124564f, 0.05027003f, -0.00539243f, -0.00815454f, 0.00939891f, 
    0.13114288f, -0.20929943f, -0.28867722f, 0.29851815f, -0.10849410f, 0.01106083f, 0.18903595f, 0.01255693f, 
    -0.03224247f, -0.11875778f, -0.12746690f, 0.02177597f, -0.25444430f, 0.01931181f, 0.25038621f, 0.02377857f, 
    0.09121862f, 0.04717670f, -0.13120343f, 0.04616163f, -0.02369954f, 0.02108711f, 0.01163832f, 0.11656833f, 
    -0.14172743f, -0.02114625f, 0.14057569f, -0.02999936f, 0.05850790f, 0.05950802f, -0.06823316f, 0.14604238f, 
    0.02090278f, -0.02923555f, 0.22760455f, 0.07483462f, 0.19481702f, 0.18230431f, -0.16799156f, 0.11824540f, 
    0.05652958f, -0.10338480f, 0.04944900f, -0.06239310f, 0.03227483f, 0.00949955f, -0.01317174f, 0.02370741f, 
    0.19591811f, 0.20460540f, -0.03053197f, 0.10463643f, -0.16074109f, -0.05485971f, 0.28215045f, -0.22300085f, 
    0.02090664f, -0.01677263f, -0.01421935f, -0.07902182f, 0.25191960f, 0.15764891f, 0.08762862f, -0.10549890f, 
    -0.02190769f, -0.00517107f, 0.01482423f, -0.04835672f, 0.07123200f, 0.15271571f, -0.00104050f, 0.01380990f, 
    -0.01506589f, 0.25849557f, -0.03062732f, 0.04521473f, 0.18706571f, -0.02355271f, -0.08492046f, 0.07098567f, 
    -0.02618616f, 0.10579593f, 0.13403431f, 0.17439020f, 0.05913674f, 0.31563583f, 0.05993830f, -0.01454430f, 
    -0.07298133f, -0.16157839f, 0.09618364f, 0.01284389f, -0.04650770f, 0.01151241f, -0.02739625f, -0.01222239f, 
    0.03352536f, -0.12532219f, 0.20879170f, -0.12056126f, 0.18736960f, 0.17647175f, 0.13507137f, -0.03352197f, 
    -0.02002170f, 0.14540023f, -0.21488635f, 0.10015491f, -0.08971132f, -0.26234657f, 0.02938995f, 0.03759723f, 
    -0.09165184f, 0.03093438f, 0.08533826f, 0.17632842f, -0.04553664f, -0.15848933f, -0.09553422f, 0.03957301f, 
    -0.00487508f, -0.15048625f, 0.20634842f, 0.10987334f, 0.01649736f, 0.07313817f, -0.01827727f, 0.01271195f, 
    -0.06352842f, -0.11499593f, -0.05606343f, -0.00702767f, 0.13961375f, -0.00019736f, 0.01675289f, 0.00948987f, 
    -0.14887065f, 0.04687306f, 0.14315233f, -0.05094106f, -0.00342468f, -0.04885948f, -0.05782320f, 0.03145036f, 
    -0.12886971f, 0.08992396f, 0.09719785f, 0.22442988f, -0.07165355f, -0.10689025f, -0.13396712f, 0.08613247f, 
    -0.00977184f, 0.05287463f, 0.01359884f, -0.00150062f, -0.12257902f, 0.05505991f, 0.08099701f, 0.25040314f, 
    0.02674331f, 0.09537982f, -0.05426261f, -0.03120755f, -0.02169037f, -0.07060870f, -0.14366607f, -0.09999913f, 
    0.08092616f, -0.00756075f, -0.07805140f, -0.02752518f, -0.10575834f, -0.00640486f, 0.07477199f, 0.03204240f, 
    -0.11156929f, -0.10463177f, -0.00860488f, 0.02709998f, -0.32112014f, -0.06840473f, 0.39990258f, 0.16244414f, 
    -0.15390931f, 0.00352014f, 0.05273374f, 0.03965869f, 0.05026044f, 0.06404895f, -0.14593644f, 0.13252237f, 
    -0.02966860f, 0.09738611f, 0.17856002f, 0.04452179f, -0.04621568f, -0.02337592f, 0.08327101f, 0.16380708f, 
    -0.10943718f, 0.10420366f, -0.02830021f, 0.04000181f, 0.12537791f, 0.06363506f, 0.44712746f, 0.05450906f, 
    -0.00796463f, -0.10762248f, -0.08049967f, 0.02989861f, 0.10398398f, 0.03116191f, -0.11368791f, 0.14437251f, 
    -0.01207590f, -0.05627669f, 0.36640805f, -0.04706322f, -0.05799690f, -0.04714381f, 0.04416868f, 0.04791506f, 
    -0.06311766f, 0.08977824f, -0.11172365f, 0.16639562f, 0.11930036f, -0.10401691f, -0.17748600f, -0.09772032f, 
    -0.00489236f, 0.00648548f, 0.02902753f, 0.04712457f, -0.08885629f, -0.01705314f, 0.06351404f, 0.00592655f, 
    -0.01775377f, -0.14608066f, -0.04193461f, 0.27792722f, -0.03247265f, 0.11537305f, -0.03403473f, 0.12321815f, 
    0.09021570f, -0.04850029f, 0.08254058f, -0.07874177f, 0.03044575f, 0.27025515f, 0.20036986f, -0.22832860f, 
    -0.04591135f, -0.15724628f, 0.30331209f, 0.03595996f, -0.01506265f, 0.23505053f, -0.09618887f, -0.09326793f, 
    0.08435719f, 0.12925200f, 0.06187534f, -0.05637734f, -0.02838195f, 0.07634541f, -0.06352285f, 0.04969364f, 
    0.05839746f, -0.01724532f, -0.21786119f, -0.03891741f, 0.21990633f, 0.28458092f, 0.05302658f, 0.30541989f, 
    0.11946335f, 0.04570397f, -0.07486640f, 0.06375278f, 0.00058585f, -0.13503860f, -0.07507144f, -0.04108384f, 
    0.05787622f, 0.01452900f, 0.08485185f, 0.01921560f, -0.00719036f, -0.02987038f, -0.05242005f, 0.05056993f, 
    -0.11361527f, -0.07293791f, -0.07637704f, 0.00186903f, -0.11174559f, -0.17708211f, -0.19761570f, 0.03463714f, 
    0.03889187f, -0.07548858f, -0.09373669f, -0.02334411f, -0.06681412f, -0.03529445f, -0.07365299f, -0.05758181f, 
    0.13827419f, 0.05190646f, 0.18242945f, -0.00622157f, -0.02589499f, -0.05605972f, -0.00268975f, 0.03640554f, 
    -0.02012544f, 0.00889314f, 0.17477268f, -0.04312292f, -0.02515680f, -0.14110810f, 0.01985721f, 0.02846195f, 
    -0.25332341f, 0.06156339f, -0.04367349f, -0.03906509f, -0.03745737f, -0.07517231f, -0.09262563f, -0.07626673f, 
    0.04952433f, -0.20526791f, -0.10322359f, -0.04825706f, -0.06350738f, -0.03538455f, 0.09243003f, 0.06615622f, 
    0.00508041f, 0.11260377f, -0.06937846f, -0.01005187f, 0.08842748f, 0.09015930f, 0.04087691f, 0.06150138f, 
    0.04291718f, 0.05543348f, 0.05065889f, 0.00801477f, -0.00597046f, 0.13855527f, 0.07516510f, -0.01422199f, 
    -0.00759831f, 0.03427503f, -0.18176408f, 0.01980964f, -0.05251817f, 0.10184088f, 0.22799729f, -0.04655208f, 
    -0.04680378f, 0.16577794f, 0.01218419f, -0.04035829f, -0.02811452f, 0.00182561f, 0.05239040f, -0.18644491f, 
    0.07262634f, -0.30847588f, 0.03517292f, 0.04624541f, 0.03673695f, -0.00782837f, -0.03352037f, -0.01962771f, 
    0.04350768f, 0.11546145f, -0.10577959f, 0.02744023f, -0.01773204f, 0.07019697f, 0.01231491f, -0.09675623f, 
    0.04678685f, 0.22569805f, -0.25083652f, -0.11448190f, 0.28160694f, 0.04335986f, -0.12846665f, 0.01933833f, 
    -0.04706494f, -0.02523695f, 0.06352723f, 0.03196438f, -0.12626426f, -0.08622279f, -0.02496409f, -0.05623870f, 
    0.11896429f, -0.16648333f, -0.21136196f, 0.00472934f, -0.10324109f, -0.09126732f, 0.09004605f, 0.04018988f, 
    0.00888431f, 0.05605101f, 0.09217877f, 0.00303546f, -0.07706410f, -0.16813672f, -0.04560807f, -0.06137916f, 
    -0.06922036f, 0.05886118f, 0.05689458f, 0.04702473f, -0.09900992f, 0.06412897f, 0.04996521f, -0.03294788f, 
    -0.18352380f, 0.02805335f, 0.13187897f, -0.09327470f, 0.15791300f, 0.00751146f, -0.16731951f, 0.20990811f, 
    0.02835145f, -0.04998746f, 0.02595654f, 0.02129270f, -0.05006747f, -0.14626174f, 0.32479429f, 0.00786466f, 
    0.06881977f, -0.05048457f, 0.18647358f, -0.00745712f, -0.05350327f, -0.01961928f, 0.09995882f, 0.01533433f, 
    0.05844055f, -0.10276472f, -0.04869478f, 0.15350989f, 0.07403106f, 0.22418670f, -0.03541938f, 0.12447917f, 
    0.19617863f, 0.01489715f, 0.30333343f, 0.10974287f, -0.04020412f, 0.02244000f, -0.00285094f, 0.02872157f, 
    0.02375636f, -0.04570896f, -0.03060063f, -0.04680881f, -0.09954692f, -0.14238767f, -0.09583020f, -0.13284649f, 
    0.13545790f, 0.10952647f, -0.01044562f, 0.18703347f, -0.08160464f, 0.07201820f, 0.06606071f, 0.08326272f, 
    0.02935902f, 0.01926468f, 0.22152779f, 0.18881957f, -0.00969980f, 0.02467769f, 0.02360655f, -0.01786371f, 
    0.00116782f, -0.13800968f, 0.00379534f, -0.07572658f, -0.02398008f, -0.09476643f, -0.15482572f, -0.16493846f, 
    -0.48652560f, 0.00160294f, 0.00389236f, -0.23569408f, 0.01564986f, -0.04660163f, -0.03473832f, 0.13449679f, 
    0.00740423f, -0.02435984f, -0.04093470f, -0.01741081f, 0.30365419f, -0.01500096f, 0.01685975f, 0.07804362f, 
    -0.17839751f, 0.06629010f, 0.00896696f, -0.05341424f, -0.01763589f, -0.03295886f, 0.04702388f, -0.28116032f, 
    0.02462932f, -0.25790763f, -0.13302186f, -0.01013631f, -0.04358927f, -0.06222964f, -0.05889345f, 0.14056179f, 
    -0.00067821f, 0.05612071f, 0.04603291f, 0.08182260f, 0.09321574f, -0.05622103f, -0.08948451f, -0.02981413f, 
    -0.00806761f, 0.19310494f, 0.20508103f, 0.07599270f, 0.00891335f, 0.01904536f, -0.09443054f, 0.14751288f, 
    -0.24316312f, -0.23391175f, -0.08437468f, -0.24011192f, -0.00491675f, 0.22817717f, 0.13502024f, -0.13774852f, 
    0.00008634f, 0.02025739f, -0.20435263f, -0.02836774f, -0.13065098f, -0.16232778f, -0.21327403f, -0.04941627f, 
    0.00119861f, -0.08979058f, -0.09399992f, -0.03256112f, 0.00513412f, -0.03932289f, 0.06265744f, -0.02809380f, 
    0.27093858f, 0.10141560f, -0.05517614f, -0.07744978f, -0.05983015f, 0.11513327f, 0.20997880f, -0.02169593f, 
    0.11493675f, -0.01075274f, 0.15461171f, -0.00484809f, -0.18213122f, -0.03667062f, 0.15572275f, 0.13768554f, 
    0.05042342f, 0.02625442f, -0.07501232f, -0.06577060f, 0.12486342f, -0.05286568f, 0.06979397f, -0.07285744f, 
    0.24687454f, 0.09729473f, 0.28352302f, -0.01333882f, -0.00362805f, -0.03106375f, 0.18607354f, 0.05710605f, 
    0.07809035f, 0.08911480f, 0.00562714f, 0.16395320f, -0.20603293f, -0.10303079f, -0.14336988f, 0.01592776f, 
    -0.19692010f, 0.04982687f, 0.10695877f, 0.02266414f, 0.00279572f, 0.13190529f, 0.10549838f, 0.08020946f, 
    0.19432820f, -0.02319946f, 0.18775563f, -0.01247433f, -0.00808580f, 0.07467432f, 0.14209871f, 0.13488388f, 
    0.10399238f, 0.08695535f, 0.10190646f, 0.26997495f, 0.72937977f, -0.02672889f, 0.00117316f, 0.01408747f, 
    -0.02698027f, 0.18164924f, 0.29897118f, -0.07868101f, -0.02513816f, -0.11705004f, -0.07870322f, -0.03949167f, 
    -0.20283431f, -0.32019454f, -0.21762098f, 0.09959330f, 0.02137838f, 0.11109638f, 0.01541276f, 0.09433099f, 
    -0.01479844f, 0.09134681f, 0.10341324f, 0.17361470f, -0.01813043f, -0.07992545f, 0.03730795f, 0.10952959f, 
    0.05293355f, 0.07904094f, -0.04367777f, 0.02056035f, -0.09586857f, 0.00438802f, -0.04471128f, -0.10415612f, 
    0.23900419f, 0.08939133f, 0.03578842f, 0.02472720f, -0.04946838f, 0.00429745f, -0.02135703f, -0.06710229f, 
    0.01984449f, -0.09706020f, 0.02305299f, -0.02885981f, -0.08773184f, -0.08151584f, -0.01451694f, 0.03425368f, 
    -0.05694681f, 0.10043938f, -0.16620445f, 0.02524984f, -0.11692932f, -0.12336840f, -0.00413779f, -0.18830737f, 
    0.03953137f, 0.10481954f, 0.06164128f, 0.05155253f, 0.05081467f, -0.02654285f, 0.11264396f, 0.12710389f, 
    0.18130606f, 0.15395632f, 0.11101840f, 0.07765159f, 0.04633183f, 0.12662800f, 0.13052541f, 0.04344399f, 
    -0.07027175f, -0.15491743f, -0.13223334f, -0.04271730f, -0.10123501f, -0.06531252f, -0.06764924f, 0.01929903f, 
    0.19702017f, 0.04111215f, -0.11906687f, 0.02344644f, -0.15469031f, 0.04886027f, 0.25662073f, 0.09890662f, 
    0.12221057f, 0.08723436f, 0.03267349f, 0.21604791f, 0.12859426f, 0.12765060f, 0.30272990f, 0.13102260f, 
    0.04473846f, 0.00782705f, -0.06648067f, -0.08408657f, 0.02928836f, -0.11651994f, -0.02457498f, 0.01559771f, 
    0.41720656f, 0.12624595f, 0.16604076f, 0.08787227f, -0.01529129f, 0.00290473f, 0.02520593f, 0.04565824f, 
    0.04486107f, 0.06224586f, 0.05254340f, 0.07348822f, 0.20797297f, 0.10831943f, 0.07293600f, 0.11361358f, 
    0.01122385f, -0.03667090f, -0.05439616f, -0.04046668f, 0.08540832f, -0.03521373f, -0.04859432f, 0.00971396f, 
    -0.07748208f, -0.25453344f, -0.19070148f, 0.06408652f, 0.10944066f, -0.05129799f, 0.06800192f, 0.11472732f, 
    -0.10173035f, 0.10460584f, 0.04080849f, 0.11734648f, 0.10463507f, 0.07500824f, -0.07893120f, -0.00308176f, 
    -0.02116583f, 0.00530573f, 0.14654928f, -0.03401570f, -0.09246865f, -0.05477344f, -0.07442585f, -0.12108341f, 
    0.41074672f, -0.10232403f, 0.00814161f, -0.07095393f, -0.03182021f, -0.00989144f, 0.15296076f, 0.10341636f, 
    0.21914059f, 0.16292618f, 0.11898360f, -0.03191672f, -0.06913351f, -0.04637464f, 0.26255918f, 0.31042334f, 
    0.24702722f, 0.18518619f, 0.01812202f, 0.02189470f, 0.03860437f, -0.00429548f, 0.03135123f, 0.04126381f, 
    0.14211243f, -0.08453383f, -0.12768979f, -0.11448843f, 0.00234571f, 0.02385034f, 0.12338573f, -0.13423340f, 
    -0.05043874f, -0.03876939f, -0.08878954f, -0.11939388f, 0.17039515f, 0.16959758f, 0.25087160f, 0.15350085f, 
    0.01103107f, -0.02014855f, -0.10663208f, -0.05477170f, -0.03158224f, -0.04262494f, 0.00525445f, -0.05432377f, 
    0.07239600f, -0.01438753f, 0.05927617f, 0.06451828f, -0.01509950f, 0.05864587f, 0.00277976f, -0.00208533f, 
    0.11304835f, 0.20533922f, 0.10579014f, -0.14623886f, 0.18062268f, 0.06202121f, -0.04156123f, 0.00414361f, 
    0.03240891f, -0.01968744f, -0.00907743f, 0.03808578f, -0.09594570f, -0.05957831f, -0.05993371f, -0.07712361f, 
    0.18935955f, -0.00445204f, -0.02275347f, -0.14084540f, -0.05433696f, 0.06409924f, 0.07160486f, 0.04149318f, 
    0.11470761f, 0.07807308f, 0.00214352f, -0.19749022f, -0.36562479f, -0.31427622f, 0.00512241f, -0.03184952f, 
    0.06049278f, -0.00941005f, -0.05825371f, 0.10589271f, -0.09014634f, 0.02857177f, 0.01537453f, 0.11058700f, 
    -0.12732270f, -0.29772899f, -0.22920474f, 0.01023086f, -0.00271707f, 0.08097891f, -0.05094818f, 0.03092154f, 
    0.00922594f, 0.02195122f, 0.08663862f, 0.05755920f, 0.19727236f, -0.03316203f, -0.22514586f, -0.12279806f, 
    -0.08457731f, -0.10483064f, -0.00616774f, 0.04000603f, 0.16051967f, 0.03238132f, 0.05140130f, 0.05615963f, 
    -0.02875066f, -0.13768633f, -0.10812333f, 0.09210465f, 0.16210186f, 0.19673736f, 0.08180247f, 0.01459508f, 
    -0.04540740f, -0.12284045f, -0.04239786f, -0.06827843f, -0.22257684f, -0.17460467f, -0.16064927f, -0.18256292f, 
    -0.10563873f, -0.13819356f, 0.14966121f, 0.19487767f, -0.02367803f, 0.05969995f, -0.00976854f, 0.00244380f, 
    0.05294349f, 0.01071797f, -0.10785434f, 0.00016594f, -0.10709450f, 0.02747577f, -0.12476901f, -0.19843380f, 
    -0.05219542f, 0.00129829f, 0.10392892f, 0.00919651f, 0.09397621f, 0.02851487f, 0.07261728f, 0.04041731f, 
    0.11460942f, 0.07876939f, 0.10013447f, 0.10424682f, -0.07469813f, -0.12389922f, 0.03115967f, -0.09813613f, 
    0.14926866f, 0.06564674f, 0.01170279f, -0.05698757f, -0.07788926f, -0.03895729f, 0.09160432f, 0.13231017f, 
    0.05067996f, -0.01245960f, 0.01365148f, -0.05423707f, 0.34613493f, 0.09162050f, 0.11375160f, 0.06374288f, 
    -0.07338501f, 0.06574998f, 0.08041424f, -0.01771279f, 0.12502082f, 0.06255077f, 0.12345253f, 0.09270606f, 
    0.35793394f, 0.11594543f, 0.04784096f, -0.20499891f, -0.05675168f, -0.00708435f, 0.00875371f, 0.00633709f, 
    -0.00711075f, -0.00908351f, -0.08273348f, -0.13226283f, 0.04127834f, 0.03545519f, 0.11182848f, 0.06775780f, 
    -0.06005620f, -0.04324568f, -0.08532734f, -0.00447878f, 0.15107910f, -0.05983335f, 0.10725702f, -0.12159967f, 
    0.06319205f, 0.11886376f, 0.00954797f, 0.03763754f, -0.11388802f, -0.12953815f, 0.11500463f, 0.17365776f, 
    0.21803747f, 0.23665306f, -0.13711286f, -0.10210990f, 0.10503676f, -0.09902323f, 0.03574950f, -0.07091951f, 
    -0.02988221f, 0.24758542f, -0.11657308f, 0.04251106f, 0.06531144f, -0.07554621f, 0.02875192f, 0.01717221f, 
    0.22428088f, 0.10608941f, 0.03260022f, 0.02864167f, -0.08900457f, -0.05770700f, 0.00525235f, -0.03479816f, 
    -0.03101373f, 0.03937572f, 0.07252879f, -0.04402234f, -0.39780501f, -0.41295472f, -0.01690836f, -0.18809015f, 
    0.09004303f, 0.04622425f, 0.11886089f, -0.01067911f, 0.04046732f, 0.02494991f, 0.03754619f, 0.18823321f, 
    -0.00943683f, 0.00415519f, -0.01834978f, 0.00950337f, -0.02696505f, 0.07956152f, -0.01775190f, -0.03814292f, 
    -0.13524847f, -0.13510630f, -0.09390642f, -0.02172878f, -0.33329782f, -0.13123685f, -0.09293409f, -0.08093792f, 
    0.00270380f, -0.18999739f, -0.13912743f, -0.16872849f, -0.08488879f, -0.05924220f, -0.08378348f, -0.09005544f, 
    0.32013896f, 0.08807354f, 0.14230305f, 0.08470877f, 0.03645452f, 0.04432479f, 0.14651123f, -0.01432260f, 
    0.09549488f, -0.03079761f, 0.03227950f, 0.06892465f, -0.04239589f, -0.20562273f, -0.12413511f, -0.00079347f, 
    -0.10913593f, -0.07305264f, -0.15487581f, -0.07799749f, -0.09937803f, 0.01250723f, -0.06967889f, -0.05905676f, 
    0.07275615f, -0.07049023f, 0.02391643f, -0.20964290f, -0.07348507f, -0.11827154f, 0.11389422f, 0.00910777f, 
    0.13459805f, 0.18278638f, -0.17834100f, -0.07976384f, 0.18537676f, 0.07877254f, -0.05432207f, 0.02801434f, 
    -0.07413882f, -0.05229874f, 0.00966993f, -0.09076793f, -0.00453454f, -0.12151878f, -0.04685583f, -0.14778621f, 
    -0.17024481f, 0.05881275f, -0.09146543f, -0.17243326f, -0.01928868f, -0.10123911f, 0.04393042f, 0.21393342f, 
    -0.09191119f, 0.07102583f, 0.06170346f, -0.03110503f, 0.11405872f, -0.23234273f, 0.15694214f, 0.21735795f, 
    0.14690518f, 0.11480330f, 0.10141762f, -0.01117163f, 0.05815138f, 0.00798338f, -0.02826000f, 0.11288294f, 
    -0.34745952f, -0.27756876f, 0.22554047f, -0.13675214f, -0.00003701f, -0.03901555f, 0.03572403f, 0.07643066f, 
    0.10004855f, 0.09304331f, 0.03018432f, 0.02926801f, 0.09576715f, 0.10342918f, 0.12327284f, 0.00199451f, 
    -0.06338657f, -0.10334822f, -0.05423314f, -0.07060755f, -0.01937949f, -0.03106662f, -0.05073704f, -0.00185037f, 
    -0.15652609f, 0.00307109f, 0.18006405f, -0.21714382f, -0.16284516f, -0.15884706f, -0.11115064f, 0.04727337f, 
    0.05683608f, 0.06017997f, 0.13281961f, 0.11567516f, 0.05036458f, 0.10124832f, 0.14662176f, -0.10697709f, 
    0.00142746f, -0.00489030f, -0.06403825f, -0.00837632f, -0.04324499f, -0.07848018f, 0.03492470f, -0.07374720f, 
    -0.18921635f, -0.11448152f, -0.01060325f, 0.10525776f, -0.05825716f, 0.21159850f, -0.03154312f, 0.01344363f, 
    0.00755492f, 0.00464121f, -0.14401975f, -0.02900277f, -0.13127388f, -0.18170509f, -0.30926803f, -0.24801116f, 
    -0.00276210f, -0.13149400f, 0.00722515f, 0.06449153f, 0.05576050f, 0.01782281f, 0.13027015f, 0.07100771f, 
    -0.06949902f, -0.02938872f, 0.38189796f, -0.07415321f, 0.03260063f, -0.00437521f, 0.00725699f, 0.22346860f, 
    0.07882802f, -0.00203856f, 0.14860339f, -0.01583568f, -0.06179223f, 0.10556889f, 0.04700388f, -0.04630566f, 
    -0.08768344f, 0.01211172f, 0.19249704f, 0.03650131f, 0.11526060f, 0.07816958f, -0.02906790f, 0.13973781f, 
    0.05237403f, -0.21540987f, -0.09378818f, -0.00779582f, -0.00264841f, 0.08471566f, 0.08901578f, 0.03611459f, 
    0.08635162f, -0.12436847f, -0.06361209f, -0.20016406f, -0.22710849f, -0.12707941f, 0.05080367f, -0.17700301f, 
    -0.20373754f, -0.22737929f, -0.12439670f, -0.07104167f, -0.01375781f, 0.26269016f, 0.02454007f, 0.22668664f, 
    -0.05474024f, 0.01076770f, -0.00311250f, -0.00967169f, -0.01615894f, -0.07091994f, 0.01193726f, -0.08837700f, 
    0.01535094f, -0.08700056f, -0.07704197f, -0.04950531f, 0.07443003f, 0.10060658f, -0.26031792f, -0.06184156f, 
    -0.13772492f, -0.07236324f, 0.01064165f, -0.07725105f, 0.05562032f, 0.11752361f, 0.04888358f, 0.10703672f, 
    -0.29886270f, -0.14358650f, 0.05055491f, 0.01149300f, -0.08983524f, -0.11447521f, -0.03143121f, 0.07649837f, 
    0.01082232f, -0.09516066f, 0.03682694f, -0.03889762f, -0.17401029f, -0.05119689f, -0.10070326f, -0.04261320f, 
    -0.03072661f, 0.00280969f, 0.04081349f, 0.01397913f, -0.21564543f, -0.09673379f, 0.06056456f, -0.13119861f, 
    0.14880298f, -0.19809793f, -0.26732969f, 0.26828745f, 0.12683275f, 0.31155905f, 0.13922185f, -0.08939441f, 
    0.07930413f, 0.00893531f, -0.06840290f, 0.10793398f, -0.13671887f, -0.07732662f, -0.08210006f, 0.05445117f, 
    0.00660931f, -0.04693414f, 0.10308126f, 0.11707460f, -0.01382146f, -0.02142894f, 0.02013781f, -0.06559510f, 
    -0.06457425f, 0.40023956f, -0.38087308f, 0.26027280f, -0.03655478f, -0.03068452f, 0.12892538f, -0.03199526f, 
    -0.05628364f, -0.00572501f, -0.28668401f, 0.12943281f, 0.07339954f, 0.12522873f, 0.03605871f, 0.11690547f, 
    -0.09152928f, -0.13817163f, 0.08803965f, 0.06307132f, 0.09796313f, 0.07200094f, -0.07063387f, 0.08125016f, 
    -0.04246487f, 0.12736638f, -0.14855082f, -0.10109598f, 0.04848519f, 0.08655672f, 0.08810510f, 0.05631984f, 
    0.05440078f, -0.01796333f, 0.09826898f, 0.04611590f, -0.02120570f, 0.10120355f, -0.32006201f, 0.23156397f, 
    -0.09542079f, -0.03512901f, 0.15790784f, 0.02338272f, 0.09405328f, 0.03698678f, 0.14418644f, -0.06413981f, 
    0.03512979f, 0.02715084f, -0.05521013f, -0.07736490f, 0.06620785f, 0.19593623f, 0.06611621f, 0.18013632f, 
    0.03606777f, -0.07772519f, -0.01066193f, -0.25158954f, 0.00410412f, -0.30939406f, -0.22599451f, -0.10216016f, 
    0.10925636f, 0.23652489f, 0.05209014f, 0.06252429f, 0.03380564f, -0.00721033f, -0.15248144f, -0.06767128f, 
    -0.08533726f, -0.04401565f, 0.14124618f, -0.10604208f, -0.01982421f, -0.02581884f, 0.03760346f, 0.03429911f, 
    0.08841066f, -0.00591186f, -0.04033257f, -0.06716135f, -0.13840248f, -0.16271359f, -0.13650377f, -0.12540242f, 
    0.00694373f, 0.09190664f, 0.07285569f, -0.10203167f, -0.17298606f, -0.18508767f, 0.03293035f, 0.06531835f, 
    0.12556195f, -0.06562741f, -0.01583625f, 0.10885900f, 0.07827482f, -0.11804049f, 0.06494625f, -0.05379266f, 
    0.02070676f, 0.03908273f, -0.09675916f, 0.28700718f, -0.04752577f, -0.06457050f, 0.16003728f, 0.08433703f, 
    -0.02112605f, 0.03098794f, -0.03822103f, -0.07973050f, 0.05961385f, 0.01221546f, 0.19039692f, 0.02679603f, 
    -0.09937094f, 0.11756270f, 0.26997539f, -0.21683837f, 0.15399581f, -0.08333737f, 0.04793404f, 0.22877090f, 
    0.02391344f, -0.09364374f, -0.01796289f, -0.06579083f, 0.03598968f, 0.08428893f, 0.19958708f, 0.09153150f, 
    -0.02055170f, -0.10020555f, -0.18824546f, 0.02014413f, 0.09804291f, 0.17412065f, 0.14118057f, 0.02839329f, 
    0.06544195f, 0.03848639f, -0.32099348f, -0.03812959f, -0.01315152f, 0.10852835f, -0.11740603f, 0.02498361f, 
    -0.08737105f, -0.01198704f, 0.06603415f, -0.19690427f, -0.20012785f, -0.06277841f, 0.01730775f, -0.07293145f, 
    -0.10525684f, 0.04604170f, -0.12368645f, -0.06754774f, 0.19092767f, -0.07611610f, 0.06175842f, -0.02103910f, 
    0.00218152f, -0.04477006f, -0.24860242f, -0.15218012f, -0.05153668f, 0.00003019f, 0.10804182f, 0.07568178f, 
    0.00524830f, -0.17065458f, 0.16800715f, -0.21308018f, -0.20007133f, -0.21993379f, -0.16676195f, -0.09288607f, 
    -0.08276073f, -0.17188267f, -0.10203475f, -0.05465152f, 0.07695913f, -0.00015683f, -0.11192735f, -0.00106566f, 
    -0.13861240f, -0.15436359f, 0.24102558f, -0.00800595f, 0.03239179f, 0.14100869f, -0.05279397f, 0.20774083f, 
    0.08638688f, 0.02255017f, 0.15087402f, -0.01325220f, 0.14296728f, 0.16295590f, -0.32404119f, 0.02210395f, 
    -0.04451912f, 0.11951090f, 0.23327425f, 0.02302589f, 0.02238742f, -0.02455023f, 0.03983395f, 0.01043812f, 
    0.44319990f, 0.24491315f, 0.00457676f, -0.04755915f, 0.02652979f, -0.08160926f, 0.19380821f, 0.01104171f, 
    0.11761111f, 0.10281462f, -0.09252249f, 0.02084683f, -0.22915411f, -0.00973526f, 0.16080253f, -0.07382978f, 
    0.13003498f, -0.01266090f, 0.15525886f, 0.15642089f, 0.00339453f, -0.01729877f, -0.06045569f, -0.04861406f, 
    0.03556029f, 0.07378130f, -0.06178553f, 0.07723901f, 0.04711237f, 0.24633825f, 0.00319964f, 0.14495714f, 
    0.05470604f, 0.06239571f, 0.07313901f, 0.04465649f, -0.03284521f, -0.04878025f, -0.01806630f, -0.00890538f, 
    -0.10252210f, -0.04274808f, -0.07301247f, -0.06218628f, 0.08541066f, -0.13167115f, 0.05088769f, -0.01678070f, 
    -0.06608517f, -0.13986300f, 0.07753789f, 0.16484015f, -0.12385044f, 0.09789843f, -0.07852344f, 0.01612986f, 
    0.11262716f, -0.12801024f, -0.04691526f, -0.12719229f, -0.14846180f, -0.27181962f, -0.15478411f, 0.07441042f, 
    0.14520936f, 0.15206185f, -0.02918885f, 0.05449937f, 0.07720346f, -0.08484744f, 0.08524096f, 0.03326638f, 
    -0.08299502f, 0.08243220f, -0.12142517f, 0.09195884f, -0.00525142f, 0.05216438f, -0.02864778f, 0.15542670f, 
    0.16476265f, 0.02340774f, 0.12043323f, 0.13432457f, -0.14493473f, 0.20005201f, 0.11901416f, 0.09205766f, 
    0.06709409f, 0.03615105f, -0.05955238f, -0.12238976f, 0.02983236f, 0.10047959f, 0.00914409f, -0.00752128f, 
    -0.16028365f, 0.04328096f, 0.03096009f, -0.05510958f, 0.05678568f, 0.01541593f, 0.13667913f, -0.07768081f, 
    0.04475339f, 0.08018517f, -0.06804131f, 0.00173016f, -0.04217293f, 0.29125771f, 0.06592057f, 0.01574185f, 
    -0.02969710f, -0.08365463f, 0.01282476f, 0.12629195f, 0.04019200f, 0.04951574f, 0.03827256f, 0.03132784f, 
    -0.34344399f, -0.44280744f, -0.28008044f, -0.26160660f, 0.11121120f, 0.10525977f, 0.20027556f, -0.09419594f, 
    -0.09813936f, -0.13360129f, 0.02438560f, -0.11914570f, 0.05336975f, 0.04287179f, -0.01364659f, -0.08455604f, 
    0.09704751f, 0.08454258f, 0.18233910f, -0.01055317f, 0.03951016f, 0.07389201f, 0.09912392f, 0.14032876f, 
    -0.24701898f, -0.08076300f, 0.20993152f, -0.03172670f, -0.09776656f, -0.03091796f, -0.15861355f, 0.04972451f, 
    -0.04362354f, 0.06889638f, -0.02420377f, -0.16113563f, -0.08269343f, 0.12793940f, -0.40437660f, 0.09200615f, 
    0.05698557f, 0.09989785f, 0.07685214f, -0.13950360f, -0.07315914f, -0.11729913f, 0.05357461f, -0.01450957f, 
    0.25843340f, 0.17081402f, -0.05056877f, -0.09774172f, 0.07715496f, -0.05426788f, 0.15958942f, -0.00466747f, 
    0.15773332f, 0.02705633f, 0.03532819f, -0.01817602f, 0.01645246f, 0.06693064f, -0.33537290f, -0.11768274f, 
    -0.01748801f, 0.09004999f, 0.06759723f, -0.11472655f, -0.02393045f, -0.10052634f, 0.08509377f, -0.04312875f, 
    0.19209063f, 0.06314757f, -0.00809837f, -0.11442807f, -0.04346664f, -0.00384683f, 0.10245778f, 0.00430992f, 
    0.16363019f, -0.08765014f, 0.00267114f, 0.01541277f, -0.11954202f, -0.19982758f, 0.05495993f, -0.02847133f, 
    -0.02272035f, 0.01608307f, 0.03439363f, -0.01453301f, 0.05218745f, -0.00028975f, 0.07716883f, -0.06292731f, 
    0.02428494f, 0.22137159f, 0.38550228f, -0.14854150f, -0.05794451f, -0.07811566f, 0.06928794f, 0.14383236f, 
    0.05981849f, 0.14896347f, 0.03536648f, -0.04018700f, 0.02666162f, -0.10491925f, -0.00575765f, 0.15386501f, 
    -0.03671480f, 0.30642048f, -0.04559982f, 0.18976408f, 0.07676610f, -0.04910455f, 0.08193798f, -0.02658325f, 
    -0.08350325f, 0.06746983f, -0.01989450f, 0.01828696f, -0.07695510f, -0.25688416f, -0.03910932f, -0.02051134f, 
    0.18788493f, 0.02946910f, 0.20851684f, 0.14340538f, -0.20024416f, -0.26338735f, -0.05167761f, 0.01145520f, 
    0.02463864f, -0.00599310f, 0.13619049f, 0.02651327f, -0.07307612f, 0.02731773f, -0.16785121f, -0.00710494f, 
    -0.21468402f, -0.17511417f, -0.16207850f, -0.21378572f, 0.09535225f, -0.02427881f, -0.05185662f, 0.01152663f, 
    0.02805412f, 0.02699080f, 0.10981248f, 0.08423146f, -0.26490390f, -0.17233165f, 0.05576435f, -0.05140181f, 
    0.05138244f, 0.13060790f, 0.16827188f, 0.11649858f, 0.03122782f, -0.07460660f, -0.03113367f, 0.02686278f, 
    0.00383450f, -0.00826340f, 0.08969219f, -0.06882335f, 0.03662996f, -0.17545375f, 0.11517394f, 0.03415174f, 
    0.04206786f, -0.03108557f, -0.10609964f, 0.06008788f, -0.24691410f, 0.00922315f, 0.01608400f, 0.04040358f, 
    0.05444916f, -0.00247681f, 0.05717843f, 0.01429931f, 0.02079474f, 0.04718138f, 0.03024675f, -0.04617401f, 
    -0.09662645f, 0.25890380f, 0.19493477f, -0.05871196f, -0.03937232f, -0.03969605f, 0.05106065f, -0.06888158f, 
    -0.04505816f, -0.08398725f, 0.10169987f, 0.09686221f, -0.00228103f, -0.04671901f, 0.02348628f, 0.05488800f, 
    -0.04882965f, -0.09643259f, -0.04570596f, -0.00715300f, 0.20812955f, 0.05341887f, -0.01470502f, 0.17977051f, 
    -0.20944202f, -0.01037425f, -0.06845970f, 0.08031245f, 0.13040578f, 0.09998503f, -0.03288522f, 0.02156089f, 
    0.07234712f, -0.13669917f, -0.02876854f, 0.14802437f, 0.13697657f, 0.30007014f, 0.12903821f, 0.05818395f, 
    -0.03929780f, 0.08826684f, -0.00133331f, -0.08624308f, 0.01420555f, -0.00617226f, -0.00586116f, -0.03656454f, 
    -0.11296287f, -0.00536692f, 0.14772411f, 0.12310898f, 0.00699687f, 0.03791638f, 0.09551539f, 0.05411954f, 
    0.04577844f, -0.03124998f, 0.10790145f, 0.27689126f, -0.14082825f, -0.21403913f, 0.24689674f, 0.02496591f, 
    -0.15840958f, -0.05234876f, -0.17715290f, 0.01284483f, 0.20172594f, 0.11346255f, 0.15473397f, 0.08170605f, 
    -0.03643983f, 0.07310642f, 0.21060823f, 0.00443917f, -0.04383208f, 0.03164703f, -0.05451178f, 0.13133484f, 
    0.12284020f, 0.06025138f, -0.00760231f, -0.09500798f, 0.08894839f, 0.05974808f, 0.07528447f, 0.05533693f, 
    -0.02657683f, -0.11080447f, -0.07996143f, 0.00302374f, 0.15279730f, 0.02929147f, -0.00158855f, -0.08040193f, 
    0.07008922f, -0.22022460f, -0.41622609f, 0.18206722f, -0.09395253f, 0.17245503f, 0.16266556f, 0.01392164f, 
    -0.01465018f, 0.01926057f, 0.01245330f, 0.01739204f, -0.05506163f, 0.14886042f, -0.17026691f, 0.03629195f, 
    -0.07508057f, 0.02576548f, -0.09644324f, 0.10038985f, 0.12068445f, 0.06750703f, -0.10000241f, 0.01403664f, 
    0.11410508f, -0.15524291f, 0.00922877f, 0.33439821f, 0.08556123f, -0.07683060f, -0.05303963f, 0.03981015f, 
    0.02636492f, 0.14293620f, 0.12052563f, 0.08287600f, -0.06675728f, -0.11825192f, -0.07199088f, 0.04364502f, 
    0.04258815f, 0.00079056f, -0.05112537f, 0.02642263f, -0.17021760f, -0.12816377f, -0.19346507f, -0.14593174f, 
    -0.10634980f, -0.01048618f, -0.01641867f, 0.09958263f, -0.03599362f, -0.00129288f, -0.03665217f, -0.04598626f, 
    0.00814275f, 0.11806253f, 0.16304307f, 0.22208382f, -0.02533400f, -0.08278903f, -0.06793163f, 0.05114108f, 
    -0.01729922f, -0.01657451f, 0.04298486f, 0.01954713f, -0.00726909f, -0.26872176f, -0.26049203f, -0.32548359f, 
    0.09498426f, 0.04534318f, 0.01394555f, 0.15785745f, 0.10054664f, 0.14284708f, -0.04313948f, 0.07796099f, 
    -0.01893135f, -0.07120159f, -0.00953322f, 0.06913021f, -0.00243109f, -0.02483122f, -0.04999062f, 0.02704861f, 
    0.01259727f, 0.02167450f, -0.01588539f, 0.01875586f, -0.05491332f, 0.01087826f, -0.04958070f, -0.07015090f, 
    0.13367753f, 0.22892189f, 0.03786495f, 0.17972127f, 0.12974365f, 0.11402649f, 0.03229592f, 0.05146718f, 
    -0.08628816f, -0.01233080f, -0.03387718f, 0.10256925f, 0.20992501f, -0.12229619f, -0.09739958f, -0.09724898f, 
    0.06443720f, -0.02199909f, -0.05358560f, -0.09872713f, 0.18719824f, 0.12044616f, 0.01908633f, 0.05955758f, 
    -0.28213573f, -0.01100179f, 0.18253656f, -0.47574395f, 0.04781252f, 0.06213267f, -0.01191157f, -0.12351262f, 
    0.06955665f, -0.08116448f, -0.07863350f, 0.00859450f, -0.22666201f, 0.23537216f, 0.11338037f, 0.21516243f, 
    0.11206941f, 0.13304418f, -0.05646937f, -0.08126708f, -0.06807484f, 0.01887169f, 0.02027542f, 0.03243944f, 
    0.32077834f, -0.29469368f, -0.02374585f, 0.12532328f, -0.07180829f, -0.01538491f, -0.19729206f, 0.01294577f, 
    0.03390894f, -0.10875282f, 0.02346797f, -0.07100068f, -0.00025881f, -0.13178223f, -0.10139845f, 0.11534886f, 
    0.11827478f, -0.02055220f, 0.11718149f, -0.07302609f, -0.03816143f, 0.00849731f, 0.07460375f, -0.07449932f, 
    0.12387577f, -0.01383503f, 0.06607041f, 0.02739239f, -0.01875683f, -0.03306623f, 0.01465880f, -0.08354393f, 
    0.01134159f, 0.15246524f, 0.11267996f, 0.11507840f, -0.42295527f, 0.01311065f, 0.17125672f, 0.17803060f, 
    0.01407822f, 0.12130015f, -0.11544445f, 0.08736207f, 0.14847742f, 0.15988828f, -0.07249043f, 0.07634640f, 
    0.08910997f, -0.02867040f, 0.04350335f, 0.01917275f, 0.03781991f, -0.08297369f, -0.03378092f, -0.09904053f, 
    0.03693274f, 0.14657594f, 0.18131456f, 0.25353631f, -0.04537055f, -0.07157350f, 0.03781430f, -0.25578591f, 
    0.04003549f, -0.18503156f, 0.00240010f, -0.06693158f, -0.10091755f, -0.02812202f, -0.02118274f, 0.00081193f, 
    0.15994295f, 0.06486264f, 0.16424184f, 0.14480594f, 0.07170964f, 0.10902362f, 0.05237788f, -0.00063249f, 
    -0.06720916f, -0.05592565f, 0.05600494f, 0.06899619f, -0.20507516f, -0.04078371f, -0.00946887f, 0.10704158f, 
    0.02422448f, -0.13484709f, -0.11382487f, -0.01425277f, 0.01625730f, -0.00760033f, -0.14303575f, -0.06087229f, 
    -0.05206720f, 0.03550858f, -0.08499405f, -0.07366871f, 0.05668627f, 0.03712916f, -0.01071332f, 0.05226735f, 
    -0.03974422f, -0.10355201f, -0.08227989f, -0.11881136f, -0.07818152f, -0.10076000f, -0.04163179f, -0.00332976f, 
    0.03020389f, 0.03728183f, -0.03295380f, 0.06073773f, -0.01990753f, -0.13898127f, -0.13123441f, -0.12139019f, 
    0.21020037f, -0.12363746f, -0.03921254f, 0.02758864f, -0.03245426f, 0.01051903f, -0.04326729f, -0.02269307f, 
    0.02899217f, 0.13520625f, -0.02130276f, 0.11624297f, -0.02508403f, -0.01825386f, 0.00176547f, -0.06572694f, 
    -0.09640954f, -0.02830845f, 0.15067492f, -0.04438834f, -0.00510305f, -0.08515713f, -0.14742820f, -0.00509282f, 
    -0.07269869f, 0.19430985f, 0.19895846f, -0.09774698f, 0.04140803f, 0.22239074f, 0.17278667f, -0.05614309f, 
    0.10468670f, 0.06057359f, 0.05828529f, 0.08915916f, -0.00502455f, 0.05538532f, -0.06128031f, -0.18544021f, 
    0.00966921f, -0.11501930f, -0.06205599f, -0.07662540f, -0.13675508f, -0.06176285f, -0.02472266f, -0.02406023f, 
    -0.03266561f, -0.08651273f, 0.01938291f, -0.17381182f, -0.08188298f, -0.11133013f, -0.08610094f, -0.19144334f, 
    -0.03428492f, -0.01052630f, -0.11703694f, 0.09304105f, -0.00957059f, -0.08435854f, -0.08922879f, 0.01140401f, 
    0.01422768f, -0.02362663f, -0.11852776f, -0.02427286f, 0.01285683f, -0.06526756f, -0.05086360f, 0.05480009f, 
    0.28629184f, -0.02947721f, -0.05338627f, 0.25992522f, -0.01055917f, 0.01546814f, 0.14620294f, 0.08586284f, 
    -0.03007117f, -0.02535848f, -0.02307768f, 0.03619945f, -0.22092451f, -0.10423429f, 0.02243121f, -0.07270265f, 
    -0.14288425f, 0.00826572f, -0.10225496f, -0.04917102f, -0.01239760f, -0.03191027f, 0.00132171f, -0.02752942f, 
    0.21628042f, -0.04902315f, -0.11280462f, -0.19496456f, 0.02186890f, -0.00852330f, -0.06594234f, 0.02632915f, 
    0.08217355f, -0.01453532f, 0.13395460f, 0.05603162f, 0.15296654f, -0.14893864f, -0.14868170f, 0.15814060f, 
    0.21198420f, -0.20995259f, 0.12792674f, 0.04459099f, -0.05939401f, 0.00853778f, 0.01985935f, 0.06327403f, 
    0.02795746f, -0.18550208f, 0.00292048f, 0.03814283f, 0.01414852f, 0.00418899f, 0.04794147f, -0.11848249f, 
    -0.08205608f, -0.07925347f, -0.08799874f, -0.11692019f, 0.02709029f, -0.08703501f, -0.09263813f, -0.03248281f, 
    0.01267127f, -0.10200702f, -0.04510610f, 0.00019163f, -0.00185870f, -0.03385983f, 0.02286809f, 0.05847684f, 
    -0.06096478f, 0.06840067f, -0.16499290f, -0.05654640f, 0.05443121f, -0.07232413f, -0.10217717f, 0.01645052f, 
    0.07020712f, 0.04504456f, 0.22825745f, 0.16620785f, -0.14535530f, 0.06143127f, 0.14321901f, 0.00792296f, 
    -0.12298630f, -0.04789039f, 0.00904265f, -0.10159650f, -0.00990095f, -0.05178098f, -0.07247841f, 0.02634063f, 
    0.10688598f, 0.01806819f, -0.02445223f, -0.09080026f, 0.08074559f, 0.05216784f, 0.04157821f, -0.01807475f, 
    0.02990435f, 0.10172950f, 0.03800824f, 0.13100010f, 0.21193813f, 0.01085075f, 0.08624966f, -0.04836986f, 
    0.03062655f, -0.00952103f, 0.05575757f, -0.04516381f, 0.00595871f, 0.00670836f, -0.04132306f, 0.10912447f, 
    0.20617981f, 0.12568212f, 0.12647097f, 0.04342585f, 0.10356183f, 0.07450805f, -0.05296651f, -0.00284308f, 
    -0.00051386f, -0.08564761f, 0.03656464f, 0.03800533f, 0.42370638f, 0.28507462f, 0.10079636f, 0.12378718f, 
    -0.00166798f, 0.04880578f, 0.03164695f, -0.09271067f, 0.15736808f, -0.04130432f, -0.02159811f, 0.21643260f, 
    -0.39703941f, -0.09671690f, 0.03211897f, 0.10779803f, 0.03737518f, -0.04746991f, -0.20914184f, -0.09013168f, 
    -0.01998191f, -0.09310219f, -0.10777576f, 0.06173736f, -0.05944880f, 0.15116662f, 0.04339073f, 0.10211902f, 
    0.11136676f, 0.10513045f, -0.01837083f, 0.05044143f, -0.08955202f, -0.17041960f, -0.06716187f, -0.01034103f, 
    0.08627997f, 0.06379639f, 0.05283969f, 0.06441752f, -0.09132892f, -0.01759142f, -0.04340903f, -0.00757279f, 
    0.18604104f, 0.07461556f, -0.04109004f, 0.13086265f, -0.25456673f, -0.00025442f, 0.18379541f, -0.21341659f, 
    -0.22738327f, -0.05874839f, -0.07807206f, -0.08074618f, -0.03564239f, 0.05595436f, -0.08909026f, 0.03131638f, 
    0.07593725f, -0.00562125f, 0.09662233f, -0.07415891f, -0.03188438f, -0.02442816f, -0.02874473f, 0.03226908f, 
    0.03893533f, 0.01410944f, -0.01622291f, 0.05068218f, -0.01240528f, -0.06503377f, -0.01938009f, -0.25399208f, 
    0.03913061f, 0.03138196f, -0.04143299f, 0.02540698f, 0.02820433f, 0.09101680f, -0.02420437f, 0.07378700f, 
    0.18148558f, -0.04609655f, 0.06082154f, -0.19864146f, 0.02880998f, 0.08789888f, -0.04351564f, -0.00797479f, 
    -0.05257396f, 0.01023980f, 0.02322800f, 0.09060131f, -0.16229421f, 0.06152267f, -0.12212404f, 0.04190209f, 
    -0.07854220f, -0.08229081f, -0.02132888f, 0.06436466f, 0.02178279f, 0.05184714f, 0.02464071f, 0.09181459f, 
    0.06126066f, 0.09491506f, -0.20162348f, 0.07413863f, 0.02815839f, 0.02107755f, -0.08271509f, 0.06009856f, 
    0.06702430f, -0.12015957f, -0.06922084f, -0.09071209f, 0.13560931f, -0.08146252f, -0.00112430f, -0.42574027f, 
    -0.02693837f, -0.07124407f, 0.10628015f, -0.00406521f, 0.09434780f, 0.01811074f, -0.03896363f, 0.03574914f, 
    -0.03510580f, 0.06596771f, -0.14765145f, 0.02498332f, -0.11938839f, 0.03457015f, -0.05328977f, 0.02016483f, 
    -0.09318265f, -0.05286819f, -0.03253594f, 0.07244820f, 0.01839668f, 0.44529384f, 0.06377976f, 0.36284450f, 
    0.06702998f, 0.07802878f, -0.06847145f, 0.07996115f, -0.00548353f, -0.03179255f, 0.05236866f, 0.02761418f, 
    -0.03440865f, -0.04066846f, -0.05207692f, 0.04428599f, 0.04364923f, -0.05919529f, -0.07936319f, 0.03080530f, 
    -0.04080255f, -0.01608815f, -0.07913850f, -0.07845905f, 0.11850053f, 0.14500320f, 0.01237967f, 0.04917420f, 
    0.14865083f, 0.05734727f, 0.02994560f, 0.01707904f, 0.01165989f, -0.02968688f, -0.05431741f, -0.02136409f, 
    0.22388935f, -0.14308019f, -0.11891625f, -0.14558403f, 0.08095191f, 0.03123560f, -0.04607392f, 0.07236812f, 
    0.01378424f, 0.03910106f, 0.13027126f, -0.04139582f, 0.20216687f, 0.02697129f, 0.12870716f, 0.01509174f, 
    -0.02147841f, 0.09891165f, 0.11477797f, -0.01572182f, 0.03421460f, -0.06561453f, -0.08689439f, -0.00178107f, 
    0.43904290f, 0.12010392f, -0.15179004f, -0.10427812f, 0.07263810f, 0.04919840f, -0.06324602f, 0.00060995f, 
    0.13014778f, 0.05270241f, -0.04568008f, -0.02627931f, 0.11645240f, -0.04258126f, -0.13874353f, -0.06816603f, 
    -0.03005427f, -0.08569789f, -0.00314859f, 0.01807027f, -0.03885857f, -0.04099266f, -0.00250077f, -0.07552429f, 
    -0.06011531f, 0.13033685f, -0.04537455f, -0.04582651f, 0.06933701f, 0.00153521f, 0.23148771f, -0.09503586f, 
    -0.01522735f, 0.04907444f, 0.05490895f, 0.04165664f, 0.09927728f, -0.13968930f, -0.14385599f, -0.20029832f, 
    0.18357882f, -0.13625817f, 0.06660158f, 0.14929786f, -0.04274144f, -0.08065092f, 0.02943639f, 0.11183468f, 
    0.04967820f, 0.26407567f, 0.04035239f, 0.09171565f, 0.00331356f, 0.12452784f, 0.00505194f, -0.10055076f, 
    0.02839122f, -0.08581901f, -0.23970129f, -0.02207423f, 0.07117752f, -0.03970044f, 0.20517726f, 0.10729233f, 
    -0.06604925f, -0.05621200f, 0.05140563f, 0.07156171f, -0.00421484f, -0.01716006f, -0.05685102f, -0.02669208f, 
    0.22751278f, 0.26681942f, 0.19162707f, 0.21198405f, 0.00856823f, 0.00201302f, 0.13339080f, 0.05605906f, 
    0.03309749f, 0.06668231f, 0.09918822f, 0.20517749f, -0.06635661f, -0.07962161f, -0.03542060f, 0.01583449f, 
    -0.12465256f, 0.02669624f, 0.08654330f, 0.08941690f, -0.03184348f, 0.12484227f, 0.17626496f, 0.13212977f, 
    -0.30317569f, 0.12207227f, 0.11694249f, -0.09706614f, -0.03689322f, 0.03642125f, -0.18352677f, 0.08881638f, 
    0.02499465f, -0.12816413f, 0.00140243f, 0.01673370f, 0.10674726f, -0.06058301f, 0.26534185f, 0.10565934f, 
    0.18701437f, 0.06035183f, 0.18823504f, -0.01970708f, -0.01754660f, -0.06822477f, 0.09187616f, 0.05694478f, 
    0.17318127f, -0.19730164f, -0.29311475f, 0.01929581f, 0.01666008f, 0.10326606f, 0.07451332f, -0.07949148f, 
    0.12170927f, -0.00675533f, 0.06356712f, 0.06110152f, -0.01723161f, -0.06307661f, 0.00416811f, -0.00560201f, 
    0.05016816f, 0.02230612f, -0.09163197f, 0.02172169f, -0.14662074f, -0.16553311f, -0.05045098f, -0.13418008f, 
    0.08007042f, 0.00416448f, -0.10570704f, 0.07735368f, 0.02347718f, 0.00040691f, 0.02027100f, 0.04153595f, 
    0.23072851f, 0.18101460f, 0.18885200f, 0.31568897f, 0.01004766f, -0.11612201f, -0.09459251f, -0.03080285f, 
    0.11139431f, -0.02634913f, -0.03619349f, 0.04251737f, -0.16350843f, -0.03779924f, -0.00630822f, -0.09919299f, 
    0.02807931f, -0.01864622f, -0.07173162f, 0.04232863f, -0.00114056f, -0.21263765f, 0.02545201f, 0.10568002f, 
    0.07336336f, 0.17945485f, 0.03384027f, -0.05366166f, 0.08296175f, 0.00190028f, 0.02332394f, 0.10137895f, 
    -0.00868988f, -0.05800306f, -0.02916813f, -0.03481871f, 0.06377302f, -0.00173006f, 0.22794195f, -0.18869953f, 
    -0.08170380f, -0.19513868f, -0.08631119f, 0.02445981f, -0.02336081f, 0.00914392f, 0.06166622f, 0.05538529f, 
    -0.02166931f, 0.04156027f, 0.00231106f, 0.01230154f, 0.14966615f, 0.10881820f, -0.02840555f, 0.10105924f, 
    0.01007949f, 0.05142970f, 0.20236467f, 0.12025325f, 0.09106872f, -0.02191145f, -0.15812625f, 0.12819673f, 
    0.19565149f, -0.04084702f, 0.03944873f, 0.23047832f, -0.08798774f, -0.28568298f, 0.11319380f, 0.04074414f, 
    -0.00113264f, 0.08331214f, -0.04615598f, -0.07428671f, 0.16880439f, -0.26917580f, -0.11582097f, 0.02940534f, 
    0.05504309f, 0.01293484f, 0.01395854f, -0.03260412f, 0.03783061f, -0.09104005f, 0.03830491f, 0.08634097f, 
    0.03743098f, 0.09167416f, -0.12400728f, -0.17536323f, 0.00384273f, 0.08859321f, 0.08756639f, -0.10182922f, 
    0.04267446f, 0.16350833f, 0.16745368f, -0.03637519f, -0.20204023f, 0.00962727f, 0.09058996f, -0.04249046f, 
    0.07800230f, 0.07880783f, -0.21422616f, -0.08071630f, -0.08633067f, -0.05205172f, 0.10262989f, -0.03589144f, 
    0.07715099f, 0.14150037f, 0.11481857f, -0.05454674f, -0.00571070f, -0.06073682f, -0.04129240f, -0.03041205f, 
    0.03194092f, 0.17027199f, 0.13430278f, 0.09053766f, 0.74969387f, -0.22787341f, -0.21573143f, -0.20049946f, 
    0.02924458f, 0.05145448f, -0.02890689f, 0.02709612f, 0.06714125f, -0.02882964f, 0.15487774f, 0.03261680f, 
    0.00847599f, -0.05512507f, 0.01137013f, 0.04448764f, -0.02074594f, -0.02661419f, 0.06123919f, 0.00724870f, 
    0.13205981f, 0.10499507f, 0.11899190f, 0.24239144f, 0.23890676f, 0.14197023f, 0.14614697f, 0.27443379f, 
    0.01726178f, 0.09055163f, 0.20728415f, -0.08682666f, -0.08882726f, -0.05697487f, -0.12733878f, -0.02120405f, 
    -0.19152206f, -0.10187927f, -0.05637460f, 0.05868473f, -0.05832290f, 0.04658701f, 0.04291265f, -0.00431958f, 
    0.05147040f, 0.07878429f, 0.11168594f, 0.14986433f, 0.10754723f, -0.05889199f, -0.01477390f, 0.05609072f, 
    0.01641106f, 0.01399598f, -0.05059807f, 0.18351097f, 0.02193056f, 0.00376343f, -0.05468637f, -0.11806124f, 
    0.02273605f, -0.09760907f, -0.17503716f, 0.04335693f, -0.07545669f, -0.04290505f, -0.04774963f, -0.06811523f, 
    -0.08672377f, -0.00347836f, 0.04611494f, 0.02547242f, 0.00896404f, -0.19426365f, -0.10173854f, -0.03371752f, 
    -0.05127182f, 0.01578427f, -0.12680075f, 0.10558881f, -0.12377379f, -0.01168944f, -0.06894054f, -0.12506194f, 
    -0.08367449f, -0.14170527f, 0.03983482f, 0.01253981f, 0.06255445f, 0.05580286f, -0.01438370f, 0.01206852f, 
    0.03331533f, 0.02510253f, 0.30055642f, 0.26176447f, -0.10577202f, 0.06927207f, -0.01868168f, -0.02175515f, 
    -0.00009767f, 0.00479997f, -0.01997598f, -0.05422019f, -0.09229969f, 0.04084967f, -0.08307374f, 0.04158189f, 
    0.07855726f, -0.17267868f, -0.06376965f, 0.07639380f, -0.08797266f, -0.02750501f, 0.17469002f, 0.10850181f, 
    -0.05395580f, -0.01974082f, 0.10482720f, 0.16462101f, -0.05609423f, -0.08868443f, 0.05630790f, -0.12255540f, 
    0.04027112f, -0.01985225f, -0.02241872f, -0.02709734f, -0.13447465f, 0.14442326f, -0.11270095f, 0.13983570f, 
    0.04252920f, -0.00941126f, 0.19472469f, -0.14317797f, -0.06373359f, -0.04435413f, -0.04424174f, -0.01431787f, 
    0.04151807f, 0.13497493f, 0.04391970f, 0.03337944f, -0.06570206f, -0.00831350f, -0.04782346f, -0.10387381f, 
    -0.04512119f, -0.01795469f, 0.03156013f, -0.02394959f, 0.04244500f, 0.10285240f, 0.05177925f, -0.02682252f, 
    -0.15144081f, -0.17275383f, -0.13819271f, -0.00917080f, -0.05598544f, 0.03632159f, 0.04184103f, -0.08741545f, 
    0.04964355f, 0.11618373f, -0.02735120f, 0.01284776f, 0.09919026f, -0.09117050f, -0.01297131f, -0.11904034f, 
    0.07064076f, -0.08614329f, 0.09040494f, -0.00576301f, -0.05353996f, -0.02319214f, -0.09426014f, -0.07768153f, 
    -0.14373836f, 0.08273860f, -0.00498027f, 0.15540396f, -0.02943971f, -0.07429165f, -0.06420308f, 0.12699540f, 
    0.01522606f, 0.27333024f, 0.14966418f, -0.02110165f, -0.12308474f, -0.05208954f, 0.22328489f, 0.24231760f, 
    0.17515738f, 0.19610521f, -0.08960821f, -0.21951033f, -0.02408219f, 0.01295876f, -0.05335383f, 0.08614875f, 
    0.08174352f, 0.18267629f, -0.18093595f, -0.06193655f, 0.03185539f, 0.00259982f, 0.02278551f, -0.02144067f, 
    -0.04530641f, -0.14501205f, -0.05249253f, -0.09199743f, -0.04525220f, 0.08662265f, -0.01394142f, -0.13783795f, 
    0.00970516f, -0.01023154f, -0.04478975f, -0.01669504f, -0.10369729f, 0.08912922f, 0.10512711f, 0.00469358f, 
    0.19747238f, -0.19483767f, -0.00426582f, -0.09007955f, 0.04041823f, 0.10349868f, -0.02698394f, -0.03550646f, 
    0.04367087f, 0.13165177f, -0.02867155f, -0.09757917f, 0.25950557f, 0.04628314f, -0.10120891f, -0.05220550f, 
    0.07134080f, -0.03082558f, -0.00068367f, 0.07576795f, 0.02278882f, -0.02255244f, -0.05376948f, -0.18510698f, 
    0.14507969f, -0.07932413f, 0.03379550f, 0.06228532f, -0.00446995f, -0.04394311f, 0.08475331f, 0.06232384f, 
    0.06346475f, 0.07024422f, -0.05626324f, -0.26530713f, -0.17689440f, -0.14718087f, 0.04495372f, 0.11394262f, 
    -0.00457320f, 0.04076146f, 0.00735887f, 0.20598695f, -0.05080053f, -0.00766306f, 0.03922947f, 0.04442853f, 
    -0.14226276f, -0.09228402f, 0.00553741f, 0.14854926f, -0.07325573f, 0.02738513f, -0.01562506f, 0.05832307f, 
    -0.03572750f, -0.00134065f, 0.04053339f, 0.07928286f, -0.01739556f, 0.12293144f, 0.23398304f, 0.10186268f, 
    -0.05952606f, -0.03626322f, 0.08537586f, 0.03327350f, -0.04463918f, 0.07190455f, 0.04066265f, 0.04690853f, 
    0.33394817f, -0.10256954f, -0.11624929f, 0.15803471f, 0.07259618f, 0.16395076f, 0.23806448f, 0.09142986f, 
    0.02271048f, -0.09809571f, -0.03686522f, -0.02544633f, -0.10255627f, -0.15118125f, 0.04808051f, 0.05798788f, 
    -0.03426661f, -0.14749904f, -0.06134621f, 0.14098518f, -0.05825180f, 0.03660829f, -0.04444859f, -0.10315320f, 
    -0.15296756f, 0.09962638f, 0.10518858f, 0.03419410f, 0.04869641f, 0.05108107f, 0.02621708f, -0.06147662f, 
    0.04771552f, -0.11973131f, 0.19052552f, 0.13606435f, 0.33630213f, 0.03274224f, 0.00837621f, 0.15287291f, 
    0.09510127f, 0.06868625f, -0.00427849f, 0.05785729f, 0.02475122f, -0.07767933f, 0.21582325f, -0.13642651f, 
    -0.00861014f, -0.02728978f, 0.01331963f, 0.01783781f, 0.03673158f, -0.07601896f, -0.06476589f, 0.08914831f, 
    0.00370205f, -0.04621848f, 0.13211599f, 0.03186815f, 0.03514967f, 0.04614239f, 0.16571964f, 0.16050045f, 
    -0.04005279f, -0.00402067f, 0.10774378f, 0.03777398f, 0.07327213f, 0.00766753f, 0.06107261f, -0.09127782f, 
    -0.14280777f, -0.06994075f, 0.19124398f, -0.01011303f, -0.04839094f, -0.07779510f, -0.06535595f, 0.02273367f, 
    -0.11271828f, 0.14544407f, 0.03883620f, -0.27271655f, -0.00137114f, -0.15441827f, 0.03688902f, 0.00362556f, 
    0.02847887f, 0.00869010f, -0.08532345f, 0.00798650f, 0.19707696f, 0.15047042f, 0.07954024f, 0.04563910f, 
    0.10399508f, -0.02142730f, 0.25613499f, 0.16625762f, 0.06871995f, -0.13106228f, 0.05373514f, -0.02903341f, 
    -0.20124590f, 0.20143431f, -0.08066482f, -0.02374872f, -0.21501181f, 0.14566341f, 0.05888340f, 0.17395954f, 
    -0.01991584f, -0.19328079f, 0.07683139f, 0.01756193f, 0.02206147f, 0.09901211f, -0.07042288f, 0.00580126f, 
    0.06094865f, 0.00439947f, -0.06451525f, -0.03924971f, 0.01537024f, -0.00585028f, -0.04030751f, -0.02653978f, 
    0.08090031f, 0.03806585f, 0.00335954f, -0.00243938f, 0.17578140f, -0.29729965f, -0.08044600f, 0.11294823f, 
    0.16415842f, -0.04042362f, 0.11140247f, -0.04228142f, 0.04323512f, -0.02759187f, 0.08746371f, 0.24247059f, 
    0.08811379f, -0.01892463f, -0.01956048f, -0.02948533f, -0.01376265f, 0.01654021f, 0.12529051f, -0.04258391f, 
    -0.07845208f, -0.02714302f, -0.20299444f, -0.10448480f, -0.06914555f, -0.11425050f, -0.05376277f, 0.07856890f, 
    -0.08391211f, -0.17129506f, -0.12394899f, -0.07839210f, -0.06343456f, -0.04310078f, -0.02068463f, -0.13776012f, 
    -0.10298059f, 0.09170122f, 0.14015329f, 0.20287479f, 0.03167174f, 0.02487945f, -0.09083588f, -0.04486433f, 
    -0.00877253f, 0.05024521f, -0.01569031f, -0.08053516f, -0.18082662f, -0.09447785f, -0.04624193f, 0.09007698f, 
    -0.10591916f, 0.05070993f, -0.06103889f, 0.04717735f, -0.06410410f, -0.07598456f, -0.06993037f, -0.02802064f, 
    -0.06264509f, 0.16193797f, 0.17198838f, 0.15167482f, 0.08551381f, -0.13340165f, 0.07009152f, 0.01114842f, 
    0.00132172f, 0.12091699f, -0.15625072f, -0.03607230f, -0.00535598f, -0.05602280f, -0.06653994f, -0.03179326f, 
    0.08881603f, -0.04962387f, -0.03978949f, -0.05126474f, -0.02841252f, -0.08377326f, 0.01734889f, -0.04485963f, 
    0.05156925f, 0.04339389f, -0.08327560f, 0.00339696f, 0.02928500f, -0.06674472f, -0.06507880f, 0.24519816f, 
    0.05984991f, -0.02023632f, 0.02617586f, -0.10940059f, -0.13731052f, -0.10376295f, 0.27480733f, 0.26059946f, 
    0.10039639f, 0.02331112f, -0.00704176f, -0.05044707f, -0.05488130f, -0.00532399f, 0.00524162f, -0.09403363f, 
    -0.06092864f, 0.17268004f, -0.05831907f, 0.09300749f, -0.03260667f, -0.22292936f, 0.05805130f, -0.06709812f, 
    -0.10637616f, 0.11150248f, -0.11133121f, -0.16325352f, -0.08183010f, 0.11199486f, -0.13292399f, -0.01578413f, 
    -0.00339030f, -0.06469941f, -0.04153141f, -0.04636325f, 0.04073195f, 0.00299806f, -0.01834775f, 0.03955904f, 
    -0.00068036f, 0.03098659f, 0.09652532f, 0.08601856f, 0.00533791f, -0.06455863f, -0.02727754f, -0.07679179f, 
    0.11705472f, 0.06920146f, 0.05586587f, 0.06914365f, -0.14947124f, -0.06235342f, 0.00132792f, 0.03148277f, 
    -0.00263280f, 0.00661119f, -0.08622418f, -0.00047356f, 0.14883538f, 0.15019996f, -0.03920310f, -0.08266425f, 
    0.19050163f, -0.19404051f, -0.03491657f, 0.14522418f, -0.05261828f, 0.04947517f, -0.01962365f, -0.09587844f, 
    -0.00547673f, -0.01289232f, 0.01339195f, -0.07327627f, -0.03016337f, -0.08630253f, -0.02281399f, 0.14104824f, 
    -0.04953624f, -0.09545230f, -0.05719435f, 0.06246201f, -0.07401519f, 0.03712578f, 0.05234068f, 0.07788631f, 
    -0.03596165f, -0.03201279f, -0.04262257f, -0.02995385f, 0.00792172f, 0.02198912f, 0.01765090f, 0.02834873f, 
    -0.01949694f, 0.00392631f, 0.01313489f, -0.03732152f, -0.03023529f, -0.00368516f, 0.00244461f, -0.03435507f, 
    0.02530148f, 0.02667205f, -0.00228156f, -0.00784164f, -0.03555201f, -0.04147431f, -0.00664472f, -0.03916404f, 
    -0.00109769f, -0.03157491f, -0.02276994f, -0.01163911f, 0.02809213f, -0.02180045f, -0.01408664f, 0.01694047f, 
    -0.02372452f, 0.02531627f, -0.03387816f, 0.00657511f, 0.01186430f, -0.02575600f, -0.03817942f, 0.01774032f, 
    0.01716568f, -0.03467298f, -0.02640344f, -0.03102590f, 0.01624660f, 0.01255245f, 0.02564270f, -0.03246534f, 
    -0.02063610f, -0.02187947f, -0.00880895f, -0.02067895f, 0.02052286f, -0.00152238f, 0.00214732f, -0.02807753f, 
    -0.00796975f, -0.02127717f, -0.04095889f, -0.03228218f, -0.02399047f, -0.01493723f, -0.02088209f, -0.01056254f, 
    -0.01122586f, -0.03083303f, 0.00768803f, 0.02623911f, -0.04007371f, -0.04020779f, -0.03034655f, -0.01481883f, 
    -0.00159295f, 0.00777059f, 0.01035986f, -0.01398052f, -0.01080329f, -0.01408407f, 0.01996181f, -0.00032138f, 
    0.02320892f, 0.00427994f, 0.00388612f, 0.02816706f, 0.00859905f, 0.01129008f, 0.01349414f, 0.02519008f, 
    0.01664334f, -0.01241642f, 0.02621076f, 0.00398269f, 0.02429487f, -0.01681915f, 0.02145171f, -0.02336210f, 
    -0.01572179f, -0.01585350f, -0.03297244f, -0.03422757f, -0.02023416f, -0.00625675f, 0.00200543f, 0.00536719f, 
    -0.03761267f, 0.00798486f, 0.00967835f, 0.02320788f, -0.02526705f, -0.03689985f, 0.02685201f, 0.00156827f, 
    0.00025037f, -0.01336455f, -0.02993551f, 0.01063249f, 0.01541261f, 0.00158016f, 0.02200683f, 0.01024065f, 
    0.02703440f, -0.01742770f, 0.01779164f, -0.03737017f, 0.02023225f, -0.04056207f, 0.01936075f, 0.00017438f, 
    0.00450454f, 0.00055093f, -0.00026024f, 0.02295834f, -0.02978004f, 0.02968259f, -0.00644917f, -0.01971745f, 
    -0.02929603f, -0.04328565f, -0.00945040f, -0.01977269f, -0.02505276f, -0.02772653f, 0.01684383f, 0.01078352f, 
    0.01514798f, -0.00468864f, 0.00790117f, 0.02194375f, -0.01093931f, -0.02333039f, 0.02061567f, -0.02158430f, 
    0.00698758f, 0.00433563f, 0.02167756f, -0.01504864f, -0.00585263f, 0.02337537f, 0.02392603f, 0.02869504f, 
    0.00349502f, 0.01676157f, 0.00195340f, 0.00579806f, 0.02290865f, -0.00568681f, 0.01767591f, -0.01300926f, 
    0.01205061f, -0.01725278f, 0.00130253f, -0.03972482f, -0.01779456f, 0.00296930f, -0.02434251f, -0.02518892f, 
    -0.00303652f, -0.03480706f, -0.00851224f, -0.02418508f, -0.00966036f, -0.02406842f, 0.01629607f, 0.02967834f, 
    0.01972156f, -0.03049719f, -0.02538696f, -0.01737785f, -0.01654149f, -0.01682944f, 0.01302373f, -0.01213623f, 
    0.00468547f, -0.03046801f, -0.02675853f, -0.02341360f, 0.00738806f, -0.01885417f, 0.01721149f, -0.02923687f, 
    0.02364262f, 0.01454694f, 0.02034598f, -0.04244718f, 0.01925368f, 0.01207667f, 0.02364132f, 0.00286128f, 
    0.01289848f, 0.02620852f, 0.01476995f, 0.00296390f, -0.01771439f, -0.00095999f, -0.04144959f, 0.02292914f, 
    -0.03511991f, -0.01189577f, 0.02286416f, 0.02086724f, -0.04225227f, 0.00294388f, -0.03714947f, 0.00489236f, 
    -0.01712481f, 0.00822958f, -0.00824074f, -0.02399673f, 0.00550464f, -0.02775067f, -0.00204835f, -0.01074331f, 
    0.00215369f, -0.02966038f, 0.02322143f, 0.02157558f, 0.02198991f, -0.02419239f, -0.01689917f, 0.02593705f, 
    -0.01107715f, -0.01430096f, -0.02422361f, -0.02117787f, -0.00899625f, -0.01476674f, -0.00358229f, -0.01473681f, 
    0.02795572f, -0.04414427f, 0.01056456f, -0.03150237f, -0.01204374f, -0.00227919f, -0.03134353f, -0.02513941f, 
    -0.02288694f, -0.00492336f, -0.00598088f, -0.02777401f, -0.03556731f, -0.00531282f, 0.00943651f, -0.01864101f, 
    -0.01615051f, -0.04027802f, 0.02311166f, 0.02307550f, 0.00469290f, 0.01197830f, -0.02214656f, 0.01329381f, 
    0.00994217f, -0.02696226f, 0.01985565f, -0.03786269f, 0.00748102f, -0.02115159f, -0.03338306f, 0.02484732f, 
    -0.02243144f, -0.04111630f, 0.00878812f, 0.01872927f, -0.02880596f, -0.02551915f, -0.03669482f, -0.02577728f, 
    -0.03771919f, -0.03806392f, 0.00870494f, -0.00624216f, -0.01614843f, -0.00721637f, 0.00530008f, -0.03541242f, 
    0.01037522f, -0.02483928f, -0.02116170f, -0.04030637f, 0.02730827f, -0.02804028f, 0.01140908f, 0.01009602f, 
    -0.01517775f, -0.01556345f, -0.02254916f, -0.01548637f, -0.02718010f, -0.03674614f, -0.02493067f, -0.01124324f, 
    -0.02573909f, 0.00123253f, -0.02013535f, 0.00668029f, 0.02861579f, -0.04279294f, 0.00331748f, -0.00654629f, 
    -0.00174968f, -0.02097326f, 0.02245379f, -0.01270881f, -0.03937161f, -0.02363736f, -0.00508436f, 0.00176971f, 
    0.01413455f, -0.01895792f, -0.03689672f, 0.00099111f, -0.03815800f, 0.02450290f, -0.04277317f, -0.03793631f, 
    0.01491596f, -0.01927461f, 0.02588940f, 0.02251903f, -0.00974121f, 0.02255403f, -0.04333024f, -0.01053419f, 
    -0.02846771f, 0.01005726f, -0.01051575f, -0.00464760f, -0.01858364f, -0.00141500f, -0.02499538f, 0.01265153f, 
    0.00960894f, -0.00124527f, -0.03722296f, 0.00595875f, -0.01870514f, -0.02639982f, -0.03487116f, -0.03163256f, 
    0.02355055f, 0.01984487f, -0.01522685f, 0.00409725f, 0.00443060f, 0.00227610f, 0.02803994f, 0.01416671f, 
    -0.02242206f, -0.02066080f, -0.00569936f, -0.02547240f, -0.03680252f, -0.01271796f, -0.01397200f, -0.01133418f, 
    -0.04085318f, 0.02133524f, -0.04137199f, -0.01396289f, 0.02710634f, -0.04077344f, 0.00429131f, -0.01272496f, 
    -0.00572687f, -0.02783790f, 0.00986150f, 0.02446486f, -0.00974940f, 0.01212442f, -0.00620086f, -0.01773850f, 
    -0.03505820f, 0.03391372f, -0.00279952f, -0.02654140f, -0.04208467f, -0.01753163f, -0.01836327f, -0.03019154f, 
    0.01856032f, 0.02725134f, -0.02621876f, 0.02621580f, -0.03204107f, 0.02340826f, -0.04086342f, -0.03493851f, 
    -0.02383305f, 0.01663613f, -0.04240407f, 0.02284188f, -0.02901831f, -0.01013482f, 0.01791884f, -0.00343319f, 
    -0.03652056f, -0.00749659f, -0.01147064f, -0.03472346f, -0.01424037f, -0.00742049f, 0.00603516f, -0.00688741f, 
    -0.01285838f, 0.00652360f, -0.03754091f, -0.01103348f, 0.00785179f, -0.02092572f, -0.00961961f, -0.02757095f, 
    -0.02370273f, 0.03987712f, -0.04148383f, -0.01207636f, 0.01765434f, 0.01251114f, -0.03740403f, -0.02654904f, 
    -0.03486768f, 0.02746431f, -0.03950574f, 0.01548066f, -0.02562192f, -0.01991859f, 0.00874331f, 0.02789750f, 
    -0.00949923f, 0.02390900f, -0.02190682f, 0.00200109f, 0.00424830f, 0.01298836f, -0.03885678f, 0.02239767f, 
    -0.00497662f, 0.01431797f, -0.03539094f, -0.01132863f, -0.02390883f, -0.01202647f, -0.00493987f, -0.00013710f, 
    0.02075101f, 0.00176707f, -0.04051450f, 0.01856433f, -0.00717162f, 0.00777372f, 0.00895315f, 0.01694345f, 
    -0.04376183f, 0.02152028f, -0.02681701f, -0.00830706f, -0.03808732f, -0.00228403f, 0.00231974f, 0.00728255f, 
    -0.00885788f, 0.02453726f, -0.01508700f, -0.00140229f, -0.01147962f, 0.01605252f, 0.01166091f, 0.02461617f, 
    0.02383384f, 0.02496716f, -0.00350480f, 0.01145392f, -0.01660431f, -0.00600705f, -0.01548794f, -0.01820813f, 
    -0.02113297f, -0.02655684f, 0.02778040f, 0.01466432f, -0.00868820f, -0.00011592f, -0.02123419f, -0.03052851f, 
    -0.01012974f, -0.01718958f, 0.01563826f, -0.02852353f, -0.02182765f, -0.02386901f, -0.01959633f, -0.01010211f, 
    -0.03409796f, 0.01518343f, -0.02913056f, -0.01112924f, -0.03948458f, 0.01205197f, 0.02392357f, -0.04180926f, 
    0.01358453f, 0.02534628f, 0.01042234f, 0.00624562f, -0.03560901f, 0.01471617f, -0.04090932f, -0.01195767f, 
    -0.03033504f, -0.03954752f, -0.00443983f, -0.01549726f, 0.00141792f, -0.03100317f, -0.01597349f, -0.02535847f, 
    0.01503197f, 0.00013988f, -0.03882227f, -0.04107095f, 0.01702120f, 0.02504765f, -0.03100923f, -0.02066261f, 
    0.00336051f, -0.01235642f, -0.00834764f, -0.01236877f, -0.00558181f, 0.00295313f, 0.02434347f, -0.00502902f, 
    0.00648746f, -0.01355588f, -0.00732857f, 0.01597730f, -0.01844906f, -0.02086578f, -0.00541549f, -0.03438740f, 
    0.00782407f, -0.03635183f, 0.02570849f, -0.00505127f, 0.00982328f, 0.01807683f, 0.02880962f, 0.02606158f, 
    0.00357571f, -0.01465036f, 0.00443507f, 0.02481773f, -0.02776577f, -0.03663706f, 0.01992141f, -0.00814593f, 
    -0.03003236f, 0.01496619f, -0.00281438f, -0.01026194f, 0.01074134f, 0.00443704f, -0.00396226f, -0.00294390f, 
    0.00887541f, 0.00525587f, 0.03117600f, -0.01353778f, 0.01702648f, -0.01541618f, 0.03966294f, -0.01470462f, 
    -0.02300930f, 0.01340495f, 0.01299847f, 0.01547967f, -0.01810628f, 0.00044788f, 0.02387427f, -0.01055352f, 
    0.02005999f, -0.03651107f, -0.02072087f, -0.02938657f, 0.01381447f, -0.02244738f, -0.02826634f, -0.00645295f, 
    -0.00349263f, -0.00180383f, 0.01564857f, 0.00395757f, 0.00835039f, -0.03268123f, 0.00303702f, -0.03800037f, 
    0.02882021f, 0.02019074f, -0.01379776f, 0.03112277f, -0.03156086f, -0.01759139f, -0.04200244f, 0.02156701f, 
    0.00094152f, -0.03502723f, -0.01081900f, 0.02761263f, 0.00888839f, -0.00880649f, -0.03524058f, -0.02617759f, 
    0.02061386f, 0.01540002f, 0.00057030f, -0.02709673f, 0.02656241f, 0.01428604f, -0.02781331f, 0.01573623f, 
    0.01702460f, 0.01410880f, 0.02783181f, 0.00372146f, -0.02798987f, -0.02036032f, -0.04010818f, 0.01743155f, 
    0.00348445f, -0.03506700f, -0.00392361f, -0.02379313f, 0.01523291f, -0.01010248f, -0.02917984f, -0.02022009f, 
    0.02018088f, -0.00732439f, 0.01836948f, -0.04064240f, -0.03590670f, -0.01842377f, 0.01467309f, 0.02028866f, 
    0.00646808f, 0.00880501f, -0.01378068f, 0.02659438f, -0.01738122f, -0.03715932f, 0.01719802f, 0.00981112f, 
    -0.02666015f, -0.02129659f, -0.03440494f, 0.00596689f, 0.01826531f, -0.03264128f, -0.04209071f, -0.03292760f, 
    -0.01513905f, 0.00494827f, -0.04045516f, -0.02021359f, 0.00715837f, 0.01120617f, -0.01361297f, 0.02512625f, 
    0.01886041f, -0.01811550f, 0.00200798f, -0.00608438f, 0.01487652f, -0.01777405f, -0.01697629f, 0.02465818f, 
    -0.03782380f, -0.00844727f, 0.01698135f, -0.04097146f, 0.02859888f, 0.02957186f, 0.00290109f, 0.00018312f, 
    0.00249461f, -0.01228204f, -0.00229600f, -0.02346332f, -0.01619848f, -0.00413578f, 0.01276243f, 0.00185601f, 
    0.00576188f, -0.00281190f, -0.00534598f, 0.01466180f, -0.00394868f, -0.00930934f, -0.02355791f, -0.03718711f, 
    0.00495036f, -0.00249247f, -0.02827927f, -0.00784408f, -0.01362036f, -0.00952144f, 0.01946517f, -0.00789378f, 
    -0.03271483f, -0.03960525f, 0.01431923f, -0.02789690f, 0.00886229f, 0.01684747f, 0.02602680f, -0.04184989f, 
    0.01818648f, -0.01702082f, -0.00820711f, -0.02763332f, -0.00734400f, 0.00416746f, 0.00488408f, -0.02297427f, 
    -0.01952974f, 0.00149268f, -0.02559512f, 0.01251237f, -0.02245348f, -0.00648658f, -0.02764704f, 0.01953698f, 
    -0.02243856f, -0.00603199f, 0.02757935f, 0.02670078f, -0.00377853f, -0.03070560f, -0.00603649f, -0.02826211f, 
    0.01788204f, -0.00122238f, 0.00051470f, -0.00807022f, -0.00094120f, -0.01313046f, -0.00347582f, -0.04030075f, 
    -0.18185072f, -0.10368055f, 0.08516944f, 0.29089379f, 0.03801614f, 0.19854119f, 0.06422152f, 0.07596288f, 
    0.16859935f, 0.03152301f, 0.29297552f, 0.02835158f, -0.03833338f, -0.04772633f, 0.07523644f, 0.00917692f, 
    0.10684814f, -0.06647501f, 0.04213746f, 0.07664222f, -0.08380481f, -0.03385925f, -0.02679879f, -0.08232184f, 
    -0.01175316f, 0.07411383f, -0.11400203f, 0.06882905f, 0.04940043f, 0.04667827f, 0.07476518f, 0.06696746f, 
    0.13404158f, 0.22082022f, 0.20428577f, 0.17925255f, -0.00100254f, 0.03328910f, 0.14028952f, -0.18474928f, 
    -0.07489671f, -0.03361638f, -0.01950292f, 0.03867242f, -0.07612772f, 0.02787039f, 0.00298770f, -0.16424954f, 
    -0.22922157f, 0.06615463f, 0.06898893f, -0.22590226f, 0.03974500f, 0.02835693f, -0.05440469f, 0.17393416f, 
    0.08899996f, 0.16510753f, -0.12246819f, -0.08956977f, 0.18998511f, -0.03084229f, -0.01922206f, 0.15988886f, 
    -0.12408759f, -0.03610631f, 0.12767482f, -0.03211400f, 0.10762320f, 0.04971421f, -0.06505458f, 0.04453862f, 
    -0.09391981f, 0.06492388f, -0.00121791f, 0.01189340f, -0.01726522f, 0.00256163f, 0.11984116f, -0.03257665f, 
    -0.02260138f, 0.03619228f, 0.04755897f, -0.04241998f, 0.17197238f, 0.00351204f, -0.01328990f, -0.24487753f, 
    -0.03483246f, -0.05588757f, -0.02957054f, -0.18842976f, 0.00572900f, 0.07164283f, 0.01417630f, 0.06283848f, 
    -0.19197115f, 0.06430165f, -0.16366899f, -0.04389768f, 0.14854845f, 0.04300089f, 0.16657418f, -0.06198987f, 
    0.05716519f, 0.03772631f, 0.03158068f, -0.03180958f, -0.31309646f, -0.04251798f, 0.09055155f, -0.10173545f, 
    -0.04451506f, 0.01646577f, 0.01290193f, -0.01181329f, 0.04672945f, 0.06470422f, 0.08388437f, -0.02652638f, 
    0.07052992f, -0.14696395f, 0.28569704f, -0.37849244f, 0.04359678f, -0.03899761f, 0.21221316f, 0.02531448f, 
    -0.01312322f, -0.02391997f, -0.06200265f, 0.15904208f, -0.12745148f, -0.10369664f, 0.13620670f, -0.09535379f, 
    0.06000717f, 0.15237170f, -0.16400850f, 0.02746320f, 0.11353011f, -0.05824712f, 0.10601596f, 0.08178765f, 
    -0.01451260f, -0.00581523f, 0.07154905f, -0.34519520f, 0.01415435f, 0.02242466f, 0.03221296f, 0.08129289f, 
    0.00685049f, 0.09437765f, 0.10863073f, 0.16198318f, -0.25134525f, 0.03495483f, 0.01294250f, 0.15588008f, 
    0.00511928f, -0.03095896f, 0.15860711f, 0.17704616f, 0.17273901f, 0.09965678f, 0.13175327f, -0.00037436f, 
    0.03438301f, 0.01257898f, 0.01913605f, -0.08629722f, 0.02836859f, -0.05595881f, 0.04165312f, -0.02968970f, 
    0.12823647f, 0.21546340f, 0.17024601f, 0.20729251f, 0.31907511f, -0.04450927f, -0.01444198f, -0.27144915f, 
    -0.13823581f, 0.04910743f, 0.17172723f, -0.00570364f, -0.00643288f, -0.04795396f, 0.01442476f, 0.00981519f, 
    -0.03345275f, -0.10023963f, -0.12313785f, -0.04890388f, -0.00964542f, 0.09579273f, 0.00536735f, -0.09607876f, 
    -0.07017814f, -0.00681077f, -0.08776354f, 0.03809512f, -0.04879889f, -0.02585397f, -0.07003617f, 0.09973225f, 
    0.05372397f, -0.03576101f, 0.03396536f, 0.05102772f, -0.06376570f, 0.02540209f, 0.06534419f, -0.02383337f, 
    0.12849784f, 0.09679179f, -0.00305071f, 0.09252950f, -0.07822613f, -0.03221330f, 0.10965868f, -0.04662015f, 
    0.03301175f, -0.05819640f, 0.03814349f, 0.07211577f, -0.24414842f, -0.01823799f, -0.12330977f, 0.28569061f, 
    0.11616461f, 0.16499650f, 0.05974848f, 0.03469498f, -0.02637763f, -0.13253345f, 0.05255349f, -0.07445507f, 
    -0.06792660f, 0.05118656f, 0.02274348f, -0.01157174f, 0.05599209f, 0.02001159f, 0.04606912f, 0.08043775f, 
    -0.00556730f, 0.03505750f, 0.07860853f, 0.10467128f, -0.35927624f, -0.00763548f, 0.19878313f, 0.29864118f, 
    0.08016505f, 0.02558908f, -0.05523023f, 0.06722741f, -0.02084157f, -0.07155756f, -0.08088244f, -0.08751417f, 
    0.07361350f, 0.10561271f, -0.17738388f, 0.03475371f, 0.03328022f, -0.02061084f, 0.27322385f, 0.18845357f, 
    0.05732011f, 0.08971407f, 0.08781026f, 0.09690317f, -0.07998843f, -0.15096782f, -0.05641943f, 0.08188586f, 
    0.01826407f, 0.03162627f, -0.06868380f, 0.00941059f, 0.01224874f, -0.00182336f, 0.05580980f, -0.00603108f, 
    0.27901688f, 0.03662708f, 0.03289026f, -0.10620829f, 0.04042594f, 0.01871272f, -0.01072517f, 0.07721511f, 
    -0.09405268f, 0.08661509f, -0.04885889f, 0.01738483f, 0.02906607f, -0.10308952f, -0.10448130f, 0.02000218f, 
    0.00632570f, 0.02710110f, 0.02795424f, 0.03599645f, -0.08809173f, -0.04677017f, -0.02356165f, -0.03442078f, 
    -0.24467362f, -0.13029438f, -0.18500470f, 0.21094429f, 0.05651086f, -0.01879616f, 0.00047955f, 0.02402664f, 
    0.00208242f, 0.02706493f, 0.07740901f, -0.03343600f, 0.07012060f, 0.12129955f, -0.07278541f, 0.12169833f, 
    -0.06640474f, 0.01116896f, 0.13532878f, 0.04903016f, -0.05770413f, 0.01762993f, -0.05172572f, -0.03055079f, 
    0.31627497f, 0.06816814f, 0.05445031f, -0.03492016f, 0.06941080f, -0.03347766f, 0.09620674f, -0.00745958f, 
    -0.07697389f, 0.19011155f, 0.11397249f, 0.04265898f, -0.11031707f, -0.06012895f, 0.04231999f, 0.07715090f, 
    0.20320630f, 0.01902317f, 0.07860546f, -0.14775394f, 0.00917610f, -0.03779795f, 0.03384007f, 0.03721326f, 
    0.11964618f, 0.00763288f, -0.02723839f, -0.12228397f, 0.00301334f, 0.10005850f, 0.11894286f, 0.00155694f, 
    -0.09261821f, 0.04045651f, -0.08204651f, 0.07885149f, -0.26926693f, -0.15543868f, -0.02994316f, 0.18756860f, 
    0.02395608f, 0.02224417f, -0.05569020f, 0.01274703f, -0.03236766f, 0.07201532f, 0.00451166f, -0.04525590f, 
    -0.03441979f, 0.08957392f, -0.22137223f, 0.35956624f, 0.04571006f, -0.02677536f, 0.11500239f, 0.10577708f, 
    -0.03532795f, 0.03310261f, 0.15990175f, -0.25188625f, 0.08523630f, -0.04170020f, -0.09217435f, -0.00383078f, 
    -0.00117198f, -0.01343429f, 0.09610266f, 0.14599140f, -0.08573516f, -0.03245181f, -0.01084799f, -0.01731438f, 
    0.22580124f, 0.10799788f, -0.02732886f, -0.07813444f, 0.04190142f, -0.00025092f, 0.23900878f, 0.01362947f, 
    0.00610711f, -0.05385624f, 0.20816039f, -0.16919582f, -0.03092451f, -0.21791291f, -0.03525969f, -0.13581654f, 
    -0.13637283f, -0.11333977f, -0.15998079f, -0.02600674f, -0.14341436f, -0.10579857f, -0.05697264f, 0.04878063f, 
    -0.06368186f, -0.07699573f, -0.19019362f, -0.16148612f, -0.05960803f, -0.11880182f, -0.08057477f, -0.14359218f, 
    -0.14032209f, -0.05745964f, -0.06973787f, -0.05699595f, 0.11326826f, 0.33853498f, 0.31978878f, -0.02842140f, 
    -0.00938099f, -0.09440237f, -0.04778714f, -0.12978370f, 0.10897798f, 0.16005342f, 0.05027373f, 0.05120851f, 
    0.11555795f, 0.09840232f, -0.11027133f, -0.00550182f, -0.00419287f, 0.00186453f, -0.03636860f, 0.03795877f, 
    -0.03698919f, -0.03050428f, 0.02677146f, 0.02462537f, -0.09251586f, -0.16175768f, 0.04753693f, -0.29066676f, 
    0.00979263f, -0.11557233f, -0.05041011f, 0.02177181f, 0.02531587f, 0.01734551f, -0.09084813f, -0.05302466f, 
    -0.23336734f, 0.12014404f, 0.10129515f, 0.25380492f, -0.04182316f, 0.05159885f, 0.09199281f, -0.05111136f, 
    -0.02026182f, 0.20348388f, 0.13770007f, 0.15960403f, 0.02497433f, 0.05183488f, -0.18679558f, 0.07277548f, 
    0.05630292f, 0.16736354f, -0.04060867f, -0.02570989f, -0.09665003f, -0.01261861f, -0.01001149f, 0.03725220f, 
    0.23747404f, -0.14098807f, 0.12510344f, -0.03701746f, 0.05590783f, -0.15642267f, -0.03131843f, -0.00866941f, 
    0.04382962f, 0.06299026f, 0.09370678f, -0.10855977f, 0.13025002f, -0.00581629f, -0.11863712f, -0.06329117f, 
    -0.05034925f, 0.07322471f, 0.02724231f, 0.03485893f, 0.03238965f, -0.00505545f, -0.06385880f, 0.01908021f, 
    0.19227797f, 0.05150665f, 0.02414699f, -0.27417058f, -0.17206034f, -0.00656084f, 0.07820804f, 0.03906265f, 
    -0.00181469f, -0.01174561f, 0.04562840f, -0.14178012f, -0.28117645f, 0.04543260f, 0.04264444f, 0.46130154f, 
    -0.02928102f, 0.03946673f, -0.07621615f, 0.03263095f, 0.14788353f, -0.00159836f, 0.19372831f, 0.11245865f, 
    0.18600354f, 0.14959352f, 0.07383538f, -0.01322197f, -0.01316517f, -0.03077861f, -0.03527898f, 0.10440301f, 
    0.00980274f, 0.25429529f, -0.06246442f, -0.08428649f, -0.12905629f, -0.26160112f, 0.01151801f, 0.13573429f, 
    -0.00639122f, 0.13465104f, 0.07884705f, -0.03177375f, -0.05242426f, 0.07527639f, 0.05954797f, 0.10116252f, 
    0.02514039f, 0.01650347f, 0.00119937f, 0.06972707f, -0.02605694f, -0.01017030f, 0.00032684f, 0.06276605f, 
    0.03188326f, 0.09204222f, 0.05401585f, -0.02435104f, -0.29546514f, 0.05779861f, -0.04878340f, -0.20322096f, 
    0.02593993f, 0.11486959f, 0.10130766f, -0.05935614f, 0.05014419f, 0.10050713f, 0.01864338f, 0.04491925f, 
    -0.03919829f, -0.05519154f, 0.00520010f, -0.00475005f, -0.15716922f, 0.03525979f, 0.07491262f, 0.00354841f, 
    0.02091761f, -0.03572552f, -0.04750200f, -0.02391861f, -0.06320647f, 0.03435658f, 0.09625411f, 0.02395440f, 
    -0.08780526f, -0.23983742f, -0.15089668f, -0.04363929f, 0.01494429f, -0.03861757f, -0.06646051f, -0.02008056f, 
    0.14063185f, -0.06668135f, 0.00189173f, -0.14373651f, -0.06194470f, 0.15065499f, 0.01612486f, -0.04413128f, 
    0.07159134f, 0.02432042f, 0.06135519f, 0.00219038f, -0.05631917f, -0.10099518f, -0.08189991f, -0.15668778f, 
    -0.08746064f, -0.14751011f, -0.11038183f, -0.11429784f, -0.01615950f, 0.02288764f, -0.06718475f, -0.01932299f, 
    0.21420075f, 0.24454986f, 0.21779574f, -0.11122946f, -0.01771432f, -0.07808071f, -0.10553782f, 0.08643165f, 
    -0.03743837f, 0.16804834f, -0.04538132f, -0.11126871f, 0.12826702f, 0.02197446f, -0.08597456f, -0.00684149f, 
    -0.03674889f, 0.07950264f, 0.07627552f, -0.00295130f, 0.06092841f, 0.09892461f, -0.00784416f, 0.07507639f, 
    0.00799531f, -0.15743782f, 0.21884798f, -0.19626033f, 0.08119734f, 0.02879749f, -0.08675646f, 0.21985196f, 
    -0.12155916f, 0.01240258f, 0.09496886f, 0.00952499f, -0.10861467f, -0.20028378f, 0.13530996f, -0.06319627f, 
    -0.07478251f, 0.15772344f, -0.13888906f, -0.18681864f, 0.06512974f, 0.02648228f, -0.01647151f, 0.08807584f, 
    -0.11352295f, 0.16253430f, 0.31249145f, -0.17242360f, -0.00870850f, -0.03635974f, 0.04798378f, 0.23287170f, 
    0.10611095f, -0.10160972f, -0.10651013f, -0.16520841f, -0.44300187f, 0.12997049f, 0.19444351f, 0.33070174f, 
    0.07630438f, -0.04141284f, 0.02700271f, -0.00210148f, 0.02384243f, 0.02411015f, -0.06530253f, 0.07135813f, 
    -0.25304082f, 0.28269249f, 0.34363085f, 0.09296305f, -0.06241172f, -0.06152488f, -0.00195650f, -0.01963076f, 
    -0.04319354f, 0.07020974f, 0.06855261f, 0.13491756f, -0.15115525f, 0.05215737f, 0.04072280f, 0.23123367f, 
    0.03868655f, 0.05906021f, -0.02465149f, 0.01071411f, -0.10596838f, 0.03484574f, 0.22595561f, 0.01037440f, 
    -0.14707239f, 0.08754165f, -0.01633877f, 0.18023334f, -0.10876928f, 0.08123916f, 0.11428877f, 0.10671113f, 
    -0.03068284f, -0.01397884f, -0.01578868f, -0.05867545f, 0.03128566f, 0.14509885f, 0.22349152f, 0.05528950f, 
    -0.07555331f, -0.19679619f, -0.06772322f, -0.09150425f, -0.22172341f, -0.05882593f, 0.00906251f, 0.03758775f, 
    0.00123877f, 0.00667300f, 0.01592395f, -0.01879915f, 0.01784738f, 0.02650732f, 0.00186939f, -0.03013010f, 
    -0.01273554f, -0.02234405f, -0.00689628f, 0.01640245f, -0.01651390f, -0.02196037f, 0.02908789f, -0.02117947f, 
    0.01852990f, 0.03248030f, -0.02257911f, -0.04193341f, -0.02398703f, -0.00485139f, -0.02914224f, -0.01564430f, 
    0.00149393f, -0.01146798f, 0.01070474f, -0.03857630f, -0.03805900f, -0.00111933f, 0.00474330f, -0.00392847f, 
    -0.01024113f, 0.01680871f, 0.02442157f, -0.00968191f, 0.02438514f, -0.02964554f, -0.03091873f, 0.01901541f, 
    -0.03185770f, 0.01831386f, -0.04151517f, -0.01120349f, -0.04056534f, 0.01462247f, 0.00627541f, 0.02055906f, 
    0.02222339f, 0.01895671f, 0.01570324f, -0.02404140f, -0.04002935f, -0.00514407f, 0.00626651f, 0.00982303f, 
    0.02043989f, 0.02696611f, -0.00891836f, -0.03026472f, 0.00416727f, 0.02968683f, 0.01056899f, -0.03246465f, 
    0.02429091f, -0.03569677f, 0.01795768f, -0.02728624f, -0.00508245f, 0.00657137f, -0.00001854f, 0.00669599f, 
    -0.02532904f, -0.00769206f, -0.01172524f, -0.02448566f, -0.00202094f, -0.00815770f, -0.03584227f, -0.01303955f, 
    -0.01019108f, 0.02718363f, -0.01254294f, -0.01712599f, -0.01190267f, -0.00406514f, 0.00609802f, -0.01119819f, 
    0.02877417f, -0.02146033f, -0.03013860f, -0.03550920f, 0.01355656f, -0.01646430f, 0.01399750f, -0.03897447f, 
    -0.04174544f, 0.01720888f, -0.02398944f, -0.03314231f, 0.00146798f, -0.03562743f, -0.00735093f, -0.04039882f, 
    0.02062436f, 0.00783917f, -0.02414089f, -0.03448073f, -0.01714852f, -0.02684874f, 0.03000179f, -0.01909649f, 
    -0.00755402f, -0.02411824f, 0.02677001f, -0.02699975f, -0.01472993f, -0.02387791f, -0.00386589f, -0.03272507f, 
    0.01687390f, 0.02320977f, -0.00441202f, -0.01506173f, -0.00777413f, 0.00329630f, -0.00040598f, 0.00799231f, 
    -0.04130656f, 0.00692458f, -0.00613742f, 0.00502403f, 0.00922285f, -0.02336594f, -0.02767725f, 0.00879241f, 
    0.00617500f, 0.00399022f, -0.01807876f, 0.02408455f, -0.01170933f, -0.03603250f, -0.01970236f, -0.00756366f, 
    0.02337199f, 0.02486186f, 0.02119140f, 0.01782029f, 0.00270062f, -0.01806029f, -0.02442407f, -0.03436178f, 
    0.00787419f, 0.00105833f, -0.01068324f, 0.00296715f, 0.01414438f, 0.01677696f, -0.01230667f, -0.01278892f, 
    -0.02990218f, -0.02273597f, 0.02770840f, -0.01705547f, 0.00555364f, 0.02889529f, 0.03844568f, 0.01077810f, 
    0.01890834f, 0.01600911f, 0.01387419f, -0.03249788f, 0.01753902f, 0.00294119f, -0.03757535f, -0.00163523f, 
    -0.01264265f, 0.02889025f, 0.01135809f, -0.03118036f, -0.00463802f, -0.03919953f, 0.02203346f, -0.03692725f, 
    0.02083923f, 0.01124131f, 0.03923617f, -0.01859648f, -0.02064576f, -0.02189164f, -0.02516731f, 0.00495406f, 
    -0.01952161f, -0.04177211f, 0.00670444f, 0.02236223f, -0.03514997f, 0.01539838f, -0.01406370f, 0.00238681f, 
    -0.00718024f, -0.03270630f, -0.02366059f, -0.01502956f, 0.00690437f, 0.01298004f, -0.00005644f, 0.00219937f, 
    0.01113004f, 0.01521516f, 0.02198199f, 0.02128337f, 0.02236856f, -0.01223048f, -0.03900577f, -0.02773771f, 
    0.02128332f, -0.04099815f, 0.02484023f, 0.01809072f, 0.00482085f, 0.01663850f, -0.02753959f, 0.00147108f, 
    -0.03312581f, -0.01089083f, 0.02251784f, -0.00907777f, 0.01121772f, 0.00130970f, 0.00960760f, -0.02441590f, 
    -0.03417064f, -0.02061116f, 0.01093735f, 0.02141432f, 0.00008953f, -0.00836346f, -0.03671713f, 0.02533961f, 
    0.01203873f, -0.00208371f, 0.00807854f, -0.02420969f, 0.02896085f, -0.02642973f, -0.00718630f, 0.01324550f, 
    0.00865896f, -0.02732430f, -0.04099913f, -0.02524857f, -0.01054533f, -0.01287374f, -0.00654875f, -0.00335320f, 
    0.01589417f, 0.02339001f, -0.04029702f, 0.00195045f, 0.00858397f, -0.00324018f, -0.04002252f, -0.02991319f, 
    0.02394611f, 0.01119480f, -0.01622492f, 0.00378151f, 0.00056876f, -0.03392638f, -0.03097126f, 0.01423114f, 
    0.01878284f, -0.00625564f, 0.00468476f, -0.01568923f, -0.01039711f, -0.02831931f, -0.02588737f, 0.02828627f, 
    0.02709693f, -0.02124022f, 0.00861379f, -0.01923800f, -0.03853507f, -0.01159684f, -0.02514685f, -0.01747916f, 
    0.02616847f, 0.00511020f, -0.02479692f, -0.02081452f, 0.01714912f, 0.01971138f, 0.00001427f, 0.01219658f, 
    0.01856825f, 0.00374312f, 0.03396306f, 0.00170707f, 0.01818271f, -0.03074296f, -0.01845431f, 0.02689129f, 
    -0.01006369f, -0.00170372f, 0.01113500f, 0.02316128f, -0.04148527f, 0.03616599f, -0.02136961f, 0.03972106f, 
    -0.00203553f, -0.02567013f, 0.00266150f, 0.00465472f, -0.03782498f, -0.02252414f, 0.00185271f, -0.00810976f, 
    0.02969633f, -0.00482873f, 0.01970051f, 0.02771706f, -0.02300735f, 0.02717914f, -0.03563081f, 0.02136409f, 
    0.01919452f, -0.00253875f, 0.00758516f, 0.00588524f, 0.02758334f, -0.03263407f, -0.04190841f, 0.03465133f, 
    0.00475996f, -0.03001686f, -0.02665452f, -0.02394450f, -0.02954708f, 0.00601941f, -0.00792188f, -0.02812799f, 
    -0.00549578f, -0.04103399f, 0.00530095f, 0.00449037f, 0.00661401f, -0.02104927f, -0.01854157f, 0.01732759f, 
    -0.00727952f, 0.02387120f, -0.01824838f, 0.00548015f, -0.02571342f, -0.02298009f, -0.01589928f, 0.00345061f, 
    0.01551580f, -0.01119085f, -0.02844821f, 0.01148975f, 0.01879235f, -0.03376231f, -0.01584909f, -0.01128774f, 
    -0.01459721f, -0.02051308f, 0.00561965f, 0.01595075f, -0.04043835f, 0.02027385f, -0.00963768f, 0.00729539f, 
    0.00498987f, -0.00629742f, -0.01240641f, -0.01729819f, -0.03893143f, -0.01943268f, -0.01437280f, -0.02977233f, 
    -0.03908877f, 0.01347964f, 0.01186247f, -0.03246856f, 0.01854117f, -0.00861974f, -0.03964491f, 0.01743348f, 
    0.03430335f, -0.02342770f, -0.01023161f, 0.02251335f, 0.00692499f, -0.02630055f, 0.00827520f, -0.02520376f, 
    -0.02468390f, 0.02220217f, 0.01954333f, -0.02240624f, -0.02744948f, 0.02227171f, -0.01113205f, 0.02822035f, 
    -0.02752081f, 0.00615400f, -0.01445356f, -0.01835664f, -0.00071439f, 0.00310966f, 0.00020893f, 0.01467260f, 
    0.01110505f, 0.02239960f, -0.00562301f, 0.00990393f, -0.00972069f, 0.00448692f, -0.03361027f, -0.03930241f, 
    -0.04078623f, -0.01234747f, -0.00271017f, 0.00742857f, -0.02844714f, 0.00229048f, -0.02072894f, 0.00617852f, 
    -0.00876016f, 0.00516330f, 0.02696861f, 0.00978225f, -0.01327944f, -0.02845436f, 0.00077864f, 0.01259538f, 
    -0.01386535f, 0.02534998f, -0.02507486f, 0.01426734f, -0.00404238f, 0.01689191f, 0.02070556f, -0.01494896f, 
    0.01407279f, -0.02735189f, -0.02824228f, -0.01448224f, 0.00878162f, -0.02125350f, -0.01111871f, 0.00903857f, 
    0.02241849f, -0.00529656f, 0.00490979f, -0.01604197f, -0.01116167f, -0.01887204f, 0.01688787f, -0.01373320f, 
    0.01494720f, 0.00160328f, -0.00323237f, -0.03995829f, 0.01783574f, 0.01121507f, 0.01707478f, -0.03634411f, 
    -0.01713215f, -0.01097503f, 0.02453984f, 0.02995555f, 0.00108042f, -0.01927845f, -0.00285585f, -0.03188555f, 
    0.00329576f, 0.02193471f, -0.01160632f, -0.03293058f, -0.03452358f, -0.03257779f, -0.01835391f, -0.00156208f, 
    0.01679616f, 0.00714573f, -0.02923772f, -0.02139613f, -0.03363123f, 0.01909258f, 0.01955712f, 0.01110699f, 
    -0.00435841f, 0.01246590f, 0.00878643f, 0.01062278f, -0.03127436f, -0.04073143f, 0.00443468f, -0.01153236f, 
    -0.01356247f, 0.00280699f, -0.00681572f, 0.02622142f, -0.03356177f, -0.00286598f, -0.00997081f, 0.02084231f, 
    -0.02545987f, 0.01746523f, -0.00298988f, -0.00549696f, -0.02039116f, -0.03376517f, 0.00515844f, -0.02456918f, 
    -0.02203326f, 0.02315740f, -0.03631409f, -0.03963061f, 0.02315101f, 0.01362014f, 0.02317283f, 0.00351402f, 
    -0.01774074f, -0.04090923f, 0.00656962f, -0.03289694f, -0.03248814f, 0.02791516f, 0.02438768f, -0.02094272f, 
    -0.01729497f, -0.02994949f, 0.01772816f, -0.01251389f, 0.01686219f, -0.02237839f, -0.00799249f, -0.03204643f, 
    -0.03115054f, 0.00483652f, 0.03426930f, -0.02126935f, 0.01912825f, 0.02430338f, -0.03600077f, 0.00473641f, 
    0.00664517f, -0.04177010f, -0.00255759f, 0.00379229f, 0.01679595f, 0.00312612f, -0.03278374f, -0.01651087f, 
    -0.01689333f, -0.03742633f, 0.01705919f, -0.01115356f, -0.03926850f, 0.02239994f, 0.00231136f, -0.03584823f, 
    -0.03176330f, -0.01899265f, -0.00613589f, 0.01916717f, -0.02916959f, 0.01843527f, 0.01638910f, -0.04015757f, 
    0.01406782f, -0.02594212f, 0.01094983f, -0.02252369f, 0.00389875f, 0.02405695f, -0.03370414f, 0.02011333f, 
    -0.04142860f, -0.04047031f, -0.03076369f, 0.02373344f, 0.01215576f, -0.00671607f, -0.03784046f, 0.00536762f, 
    -0.02659120f, -0.00518007f, -0.04175650f, 0.00795782f, 0.01958910f, 0.00949674f, -0.02677234f, -0.04114120f, 
    0.00764127f, -0.02834858f, -0.02183557f, -0.02054230f, 0.00630676f, -0.00252654f, 0.02021031f, -0.03589263f, 
    0.01184534f, 0.01379229f, 0.02993901f, 0.00917538f, -0.00059136f, 0.00174927f, 0.00526170f, -0.00904255f, 
    0.01707559f, -0.02780783f, -0.00931740f, -0.00398285f, -0.03048643f, -0.03556113f, -0.03345449f, -0.01675869f, 
    -0.00963956f, -0.03800928f, -0.01491161f, -0.02137520f, -0.02066316f, -0.02125563f, 0.02196533f, 0.00689753f, 
    -0.00059334f, 0.01224766f, 0.00045191f, 0.02637547f, 0.00272046f, -0.00607610f, -0.00334098f, -0.01568580f, 
    -0.04084583f, 0.03152441f, 0.02647465f, -0.00833051f, -0.00965380f, 0.02606567f, -0.02741672f, 0.01536369f, 
    0.02648918f, -0.00111154f, 0.00765201f, -0.02559441f, -0.00683033f, -0.01131960f, 0.01898695f, 0.02252859f, 
    0.00948353f, -0.01773654f, 0.02654769f, -0.02167037f, 0.00723655f, -0.01250457f, 0.01079634f, 0.00777503f, 
    -0.01826405f, 0.00158352f, 0.01638077f, -0.01577806f, -0.03129955f, -0.00763911f, 0.01673945f, 0.00090499f, 
    -0.00654299f, -0.02217052f, -0.02130810f, 0.02289509f, 0.00447659f, 0.01736578f, -0.00758315f, -0.00422575f, 
    0.02390747f, -0.03811596f, -0.00693741f, 0.01891381f, -0.01276098f, 0.00610125f, -0.02615010f, -0.03458880f, 
    0.00227397f, 0.02557377f, 0.00156528f, 0.02399326f, -0.00170315f, -0.02038819f, 0.02822750f, 0.00999612f, 
    0.01219157f, -0.02328003f, 0.01277093f, -0.03003425f, 0.04071267f, -0.03922709f, 0.02357953f, -0.02967967f, 
    -0.02460158f, -0.03945836f, -0.01653041f, -0.03157387f, -0.00975407f, 0.02737797f, -0.00222706f, -0.02591038f, 
    0.01221851f, 0.01410966f, -0.01699614f, 0.00341117f, 0.01905502f, -0.01526351f, -0.02409335f, -0.04077156f, 
    -0.01732735f, 0.02327599f, -0.01270926f, -0.00513695f, 0.00040536f, 0.01646681f, -0.00847999f, -0.00501602f, 
    -0.01057624f, 0.00541502f, 0.01301365f, 0.02765504f, -0.02370560f, -0.04039197f, 0.00925038f, 0.00560931f, 
    -0.03299365f, -0.03114567f, -0.03382312f, 0.00680657f, -0.00430852f, 0.02444440f, -0.01855352f, -0.02140019f, 
    0.01815682f, -0.02725253f, 0.01794363f, -0.00953421f, 0.00790744f, -0.02158215f, -0.02111836f, -0.01661631f, 
    -0.01292860f, 0.00402692f, -0.03693697f, -0.00020504f, -0.02065677f, -0.01913297f, -0.00877353f, -0.01335393f, 
    0.00164838f, 0.02795675f, -0.00508109f, 0.00691958f, -0.02261339f, -0.01225314f, 0.01150769f, -0.03120184f, 
    0.03306662f, -0.02084935f, -0.02521684f, -0.00620655f, -0.04427991f, -0.03032906f, -0.01451582f, 0.00209261f, 
    -0.00579176f, -0.03103200f, -0.02500810f, 0.01308642f, 0.00850210f, -0.04430797f, -0.00696801f, -0.02799632f, 
    -0.03557494f, 0.02617889f, -0.01609403f, -0.02236411f, -0.00063046f, 0.01609481f, 0.01522987f, 0.02109720f, 
    0.02534194f, -0.02009662f, 0.00389228f, -0.00292662f, 0.01235347f, 0.01746109f, -0.03554874f, -0.02496756f, 
    0.02844238f, -0.01598341f, 0.01515929f, 0.00555821f, -0.03643280f, 0.01310464f, -0.02199578f, 0.01807833f, 
    -0.02369776f, 0.02321842f, 0.01907278f, -0.00035113f, 0.02112476f, -0.00806985f, -0.02568932f, 0.00762714f, 
    -0.02282952f, 0.01507085f, -0.00139515f, -0.01636983f, -0.02412148f, -0.00734460f, 0.01511306f, -0.02922980f, 
    -0.02953222f, -0.03577620f, 0.00129984f, -0.02467272f, -0.01553037f, -0.01499951f, 0.01500561f, -0.00829850f, 
    0.02063543f, 0.00795943f, -0.02361790f, -0.04103160f, -0.00983772f, 0.01375329f, 0.03424299f, -0.00286487f, 
    0.00458048f, -0.00023513f, -0.00126230f, -0.01438971f, 0.02433054f, 0.03372060f, -0.00528701f, 0.00347215f, 
    0.02112312f, -0.02020629f, 0.02866008f, -0.01075435f, -0.04078262f, -0.03927003f, -0.02989500f, -0.03441318f, 
    -0.02622589f, -0.01738173f, -0.02422151f, 0.01919399f, -0.02331535f, 0.01135228f, -0.01787120f, -0.03292375f, 
    -0.02322569f, 0.00974238f, -0.00964032f, -0.03172128f, 0.02349230f, -0.04076123f, -0.00093102f, 0.00464165f, 
    -0.00249113f, -0.01221839f, -0.01861952f, -0.00436028f, -0.01607627f, 0.02670131f, 0.03314234f, 0.00990515f, 
    -0.01646062f, -0.00971817f, -0.02259576f, 0.01228146f, 0.02332549f, 0.02500783f, 0.01364102f, 0.01325465f, 
    -0.00865341f, -0.02515754f, 0.00377175f, -0.00833985f, 0.01357834f, 0.02593960f, -0.03932429f, 0.01289901f, 
    -0.01651257f, -0.02082810f, -0.02761732f, -0.02643063f, -0.00153571f, -0.00889905f, -0.00808339f, 0.01335538f, 
    -0.03742449f, 0.02006173f, 0.02321814f, -0.03416665f, 0.02048389f, -0.02830917f, -0.00105949f, 0.01690795f, 
    0.02356722f, -0.03066860f, 0.00352886f, 0.02471122f, -0.03409937f, -0.03211517f, -0.04387202f, 0.02811820f, 
    0.00525225f, 0.02085331f, -0.01047713f, -0.03258143f, 0.00691689f, -0.04316208f, 0.01046551f, -0.02263376f, 
    0.02599748f, 0.01757542f, 0.02859024f, -0.03054122f, 0.00089592f, -0.02024845f, 0.00304482f, 0.02678380f, 
    0.02944634f, 0.01637478f, -0.04065259f, -0.03447095f, 0.01775071f, 0.00059572f, -0.04136549f, -0.01478640f, 
    0.00632472f, 0.01978087f, -0.02239060f, -0.01417484f, 0.00489556f, -0.04046398f, -0.04085212f, -0.04025328f, 
    -0.02243053f, -0.02368556f, -0.03259632f, -0.02398707f, -0.03268838f, -0.00280514f, -0.00221726f, 0.00542430f, 
    0.02309558f, -0.03177868f, -0.01766224f, 0.01532123f, 0.00827413f, -0.00749111f, -0.02273955f, 0.00524457f, 
    -0.01826232f, 0.01821004f, -0.01938168f, -0.00696284f, 0.01908232f, -0.00061538f, 0.02531250f, 0.02216602f, 
    -0.02133479f, -0.03722950f, 0.02216806f, 0.01620151f, 0.00670689f, 0.01807564f, -0.03538698f, 0.00976740f, 
    0.02238870f, -0.00455659f, 0.00856001f, -0.03845259f, -0.03227030f, -0.03734057f, 0.01998709f, 0.02204164f, 
    -0.03764271f, -0.00338479f, 0.00076038f, -0.03011882f, -0.04247126f, 0.01390764f, 0.00051581f, 0.01662241f, 
    0.01694627f, -0.01496957f, 0.02302320f, 0.01042232f, 0.00440012f, 0.00664590f, -0.02910358f, -0.00306276f, 
    0.04256072f, -0.02157039f, 0.01894404f, 0.01996651f, 0.01439335f, 0.00065355f, -0.00673161f, -0.02041044f, 
    0.01162727f, 0.01491240f, 0.01357511f, -0.00028093f, -0.01998780f, 0.00281597f, 0.01236040f, -0.01938273f, 
    0.00532464f, 0.00962111f, 0.02686168f, 0.00206401f, 0.02663068f, 0.00929658f, -0.00592729f, 0.00150052f, 
    -0.03768625f, 0.02267822f, -0.01488899f, -0.01147564f, 0.00453987f, -0.04006064f, -0.00318010f, 0.02705489f, 
    -0.01887046f, 0.01746572f, 0.02204208f, -0.01331871f, 0.01334423f, 0.02705936f, -0.00916406f, -0.00993961f, 
    0.00677893f, -0.03430727f, -0.00768427f, -0.03657298f, 0.02260859f, -0.01546565f, -0.00195006f, -0.02395522f, 
    -0.02135548f, 0.01386503f, -0.02219244f, -0.03573482f, 0.02190698f, -0.01848255f, -0.02960261f, 0.02172033f, 
    0.02089071f, -0.02467242f, -0.02556423f, 0.00098836f, -0.02942817f, -0.01489124f, -0.02660765f, -0.00311753f, 
    -0.01784815f, 0.00978371f, -0.00031269f, -0.02797486f, -0.00413216f, -0.02617375f, 0.02519849f, -0.00343075f, 
    0.01201825f, 0.00690208f, -0.00222398f, -0.03106302f, 0.00775849f, -0.02699799f, -0.02708153f, -0.02437301f, 
    -0.01758765f, 0.02924119f, 0.01811787f, -0.02473996f, -0.02614910f, 0.01081450f, 0.01508298f, -0.03201630f, 
    0.00193342f, -0.03804335f, 0.00641389f, -0.01795369f, 0.01256169f, -0.02554558f, 0.01656423f, 0.01353061f, 
    -0.01150745f, -0.00611677f, 0.00152185f, 0.01671534f, 0.01858956f, -0.00146142f, 0.01722060f, -0.03145216f, 
    0.01386063f, -0.01805590f, -0.01737678f, -0.00692571f, -0.00976002f, -0.02861642f, 0.02463269f, 0.01738072f, 
    -0.03468312f, 0.03244258f, 0.00953911f, -0.03469405f, 0.00161901f, -0.02095597f, 0.00103902f, 0.02010636f, 
    0.02248914f, 0.02579906f, 0.01693601f, 0.01060495f, -0.00098279f, -0.00191447f, 0.02696256f, 0.02599199f, 
    0.01103241f, -0.00859291f, -0.00905244f, 0.02481509f, -0.03954140f, 0.02507761f, -0.01950993f, -0.04032513f, 
    0.02246591f, -0.01702121f, 0.01555757f, 0.00707606f, 0.00056411f, -0.02261950f, 0.01233929f, -0.03025050f, 
    -0.04079008f, 0.02056425f, -0.03159698f, 0.01831364f, 0.00160690f, 0.00799554f, -0.01072857f, 0.00798167f, 
    -0.01079630f, 0.00966968f, 0.01413017f, -0.00257550f, -0.02102477f, 0.01317918f, -0.02741427f, -0.02550361f, 
    0.01877384f, 0.02856303f, 0.02300008f, -0.02112338f, 0.02209028f, -0.01167309f, -0.01737095f, 0.00355321f, 
    0.00246011f, -0.04156071f, 0.01073742f, -0.03652493f, 0.01731074f, -0.00005747f, 0.02336492f, 0.01002752f, 
    0.02250218f, -0.02633444f, 0.00998575f, -0.00355440f, 0.00493507f, 0.00850631f, -0.00549326f, 0.00755019f, 
    0.02100689f, -0.02986771f, -0.00143008f, -0.01471367f, 0.02959120f, 0.01053229f, 0.01476951f, 0.02724299f, 
    0.00437464f, -0.03599793f, 0.02256641f, 0.02202106f, 0.03357434f, 0.00868377f, 0.02198862f, -0.01005755f, 
    -0.02804906f, -0.01275737f, 0.01760081f, 0.02120163f, -0.00420395f, -0.00506201f, -0.00954698f, -0.01467704f, 
    -0.03335540f, 0.01108979f, 0.00494286f, -0.02658149f, -0.01964315f, -0.00250561f, 0.03018843f, -0.03237856f, 
    -0.03124353f, -0.03703742f, 0.00242800f, -0.00662093f, -0.02604209f, -0.00286809f, 0.01092409f, 0.00995964f, 
    -0.02588645f, -0.03798717f, -0.03170537f, 0.00031148f, 0.02125967f, -0.02376048f, 0.03369194f, 0.02900042f, 
    0.01644199f, -0.01069169f, -0.02193018f, 0.03304021f, -0.02862832f, -0.02244814f, 0.02203360f, -0.01706253f, 
    0.02199168f, 0.02391201f, -0.03400583f, -0.00154903f, 0.00334996f, -0.02767335f, 0.00650577f, 0.01966055f, 
    0.01666217f, 0.00917227f, 0.01021058f, 0.02060653f, 0.02880396f, 0.00592695f, 0.01888177f, 0.01564199f, 
    -0.00714653f, -0.00743528f, -0.04319054f, 0.00736749f, -0.02065576f, 0.00002322f, -0.03320100f, 0.02513812f, 
    -0.03581076f, -0.00422400f, 0.02051587f, 0.02281231f, -0.02711060f, 0.00701549f, -0.04029199f, -0.00485348f, 
    -0.02999877f, -0.00841683f, -0.01368962f, 0.00374276f, -0.03439991f, -0.03866822f, 0.01774446f, -0.00385991f, 
    0.02335003f, -0.03873757f, 0.01015583f, -0.01402845f, -0.03218439f, -0.04036400f, 0.01785391f, -0.03721638f, 
    0.01612465f, 0.02227937f, -0.02818002f, -0.00882336f, 0.01131345f, -0.02927891f, -0.04104373f, -0.03208669f, 
    -0.00299291f, -0.01952738f, -0.01029586f, 0.00341170f, 0.01532739f, -0.00331160f, 0.02530082f, -0.04134394f, 
    0.01881464f, -0.03955327f, -0.00350766f, 0.01440010f, 0.01145616f, -0.01377623f, -0.02756294f, 0.03461957f, 
    0.00499761f, 0.01944007f, -0.02975135f, 0.00582508f, -0.02073762f, 0.02855179f, 0.02536553f, -0.01244684f, 
    0.00658614f, -0.00543625f, 0.01721047f, 0.02201455f, 0.01559411f, -0.00361322f, 0.01691569f, 0.00462159f, 
    -0.02086678f, -0.01147017f, 0.00407494f, -0.00800530f, -0.02106279f, -0.03022587f, 0.00712543f, -0.00107825f, 
    0.01349638f, -0.01913289f, 0.02373411f, -0.02409507f, -0.00473169f, -0.03490449f, -0.02249520f, -0.02654754f, 
    0.00546289f, 0.01619194f, -0.03572959f, 0.02518274f, -0.02245363f, 0.01360140f, 0.00888703f, 0.04240914f, 
    0.00789644f, -0.02544668f, -0.04083000f, 0.02705687f, -0.00549035f, -0.02417062f, 0.00784025f, 0.02597293f, 
    -0.01591451f, -0.02280730f, -0.03355048f, -0.03485781f, -0.01818500f, 0.02476384f, -0.01117201f, -0.03960828f, 
    0.02463370f, 0.02186423f, -0.00782525f, 0.01785937f, 0.00759545f, -0.02492183f, -0.01384641f, 0.01117541f, 
    -0.02604825f, -0.03530818f, -0.01867948f, 0.01753088f, -0.02522400f, -0.00244951f, -0.03299580f, -0.04089937f, 
    -0.04160957f, -0.02797432f, -0.01716285f, -0.02022989f, -0.00810244f, 0.02902688f, 0.02043403f, -0.04121529f, 
    -0.02748215f, 0.02696974f, 0.01673923f, -0.00302613f, -0.02864536f, -0.02185933f, 0.02670422f, 0.03054396f, 
    -0.02763724f, -0.03737656f, -0.02672998f, -0.01763164f, 0.01263250f, 0.01206985f, -0.03014925f, 0.01502049f, 
    0.00563003f, -0.00901357f, -0.00423547f, -0.03276043f, -0.00899519f, -0.01155698f, -0.03301907f, 0.02279324f, 
    0.00143941f, -0.02474070f, -0.01266406f, -0.00097439f, -0.02967528f, 0.01674844f, -0.04367471f, 0.02597171f, 
    0.02223133f, -0.01215613f, -0.00768555f, 0.02348626f, -0.03844297f, -0.02643341f, -0.03767659f, -0.00301906f, 
    0.00131153f, -0.00982734f, -0.00901769f, -0.01971924f, 0.02524231f, 0.01939297f, -0.03107101f, 0.00573011f, 
    -0.00820175f, 0.02030390f, -0.00473425f, -0.00750522f, 0.01425557f, 0.02366817f, -0.00297358f, -0.01244889f, 
    0.01078319f, -0.01783554f, 0.02489521f, -0.00492426f, -0.00926056f, 0.01809344f, -0.01270968f, 0.00320220f, 
    -0.01815237f, -0.03620704f, -0.03208979f, -0.02407187f, -0.02763825f, -0.02812943f, -0.00031259f, 0.01597531f, 
    -0.02538049f, -0.03043891f, -0.03659462f, 0.02526958f, -0.04067488f, -0.03638135f, -0.03685486f, 0.00849526f, 
    -0.00875778f, 0.01322883f, 0.01905515f, -0.00450282f, 0.02768291f, 0.03384136f, -0.03238199f, -0.01416710f, 
    0.01091722f, 0.00201143f, 0.00292788f, 0.00432967f, -0.01934975f, 0.00088352f, 0.00255103f, 0.00925884f, 
    0.02618256f, -0.02705726f, -0.02373539f, -0.01425695f, -0.00309663f, -0.02431425f, -0.03063290f, -0.02353736f, 
    0.02081276f, 0.01441544f, 0.00615554f, 0.00565230f, -0.02176209f, 0.02485361f, -0.02401886f, -0.02978743f, 
    0.01091655f, 0.01225983f, -0.01025669f, -0.02868476f, -0.01662700f, 0.02283082f, 0.01867088f, -0.01992587f, 
    -0.01322719f, 0.02739256f, -0.04222399f, -0.03448152f, -0.00083337f, 0.00566568f, -0.01961989f, 0.02286476f, 
    0.03048851f, 0.01346489f, 0.02286729f, -0.01176641f, 0.03266981f, 0.02662673f, 0.00111697f, -0.03369999f, 
    -0.11323754f, 0.03173310f, 0.23071252f, 0.03425394f, 0.08352575f, -0.10788453f, 0.05561223f, 0.29835910f, 
    -0.02067011f, 0.02207982f, 0.17491549f, -0.06723211f, -0.03397984f, 0.08766019f, 0.07481167f, -0.05617105f, 
    -0.04379537f, 0.05276041f, 0.04474348f, -0.08671353f, 0.12937459f, -0.01541424f, -0.01090089f, 0.09407491f, 
    0.10118710f, -0.21828133f, 0.04628804f, -0.01227658f, -0.00974585f, -0.03109940f, 0.05454759f, -0.04919275f, 
    0.07230000f, -0.14909448f, -0.17653541f, -0.10886607f, -0.09013069f, -0.13360545f, -0.05519918f, 0.04878304f, 
    -0.10789063f, 0.08355344f, -0.04201919f, 0.01386690f, 0.12174787f, -0.01326874f, -0.12463621f, 0.10692347f, 
    0.00310481f, -0.10662414f, 0.02285340f, 0.03005832f, -0.05810122f, -0.03660844f, 0.04049802f, -0.05590494f, 
    -0.16348445f, -0.16233221f, 0.14431795f, -0.02309137f, 0.06929527f, 0.00782537f, 0.00680397f, 0.03568607f, 
    0.12675202f, -0.02253870f, -0.03661012f, 0.07652361f, 0.00457974f, -0.18844751f, -0.04128124f, 0.13237369f, 
    -0.19588622f, -0.10055058f, -0.01893553f, -0.00550062f, -0.02478597f, -0.00714383f, 0.02449076f, 0.06244837f, 
    -0.08405446f, -0.11647314f, 0.04809295f, 0.03313759f, 0.00322984f, 0.06788106f, -0.11967992f, 0.03681651f, 
    -0.05560775f, -0.10479627f, 0.02278163f, 0.05646652f, -0.10968072f, -0.19575912f, 0.03314057f, -0.13305797f, 
    0.25850913f, -0.19008166f, 0.01803855f, 0.16484463f, 0.15259153f, 0.00120256f, 0.19714051f, -0.07519450f, 
    0.00315969f, 0.04527763f, -0.03845831f, 0.05493998f, -0.44010597f, 0.04551641f, -0.09599077f, -0.06961708f, 
    -0.00781702f, 0.02798992f, 0.01510300f, 0.12509649f, 0.02504636f, -0.01641668f, -0.01619223f, -0.04107282f, 
    -0.04630021f, -0.12456093f, -0.40160924f, 0.45365277f, 0.10599314f, 0.17616646f, 0.11494854f, 0.16404361f, 
    -0.22111392f, 0.10553519f, -0.04026847f, 0.05736214f, -0.15271911f, 0.06604239f, -0.08804777f, 0.08601239f, 
    0.03749670f, -0.20144838f, 0.17708147f, -0.05136175f, -0.00921968f, 0.05645243f, -0.10579920f, 0.03834411f, 
    -0.11886436f, 0.15829028f, -0.15132108f, 0.13780357f, 0.02200208f, 0.03785120f, 0.05666804f, -0.03320832f, 
    0.20719734f, 0.08138302f, -0.00881674f, -0.04398250f, -0.20396776f, -0.06071245f, -0.11444385f, 0.18418683f, 
    0.05463404f, 0.04051767f, 0.02290501f, 0.27653694f, 0.10933360f, -0.10503302f, 0.02316337f, -0.01263502f, 
    0.03869944f, 0.04636613f, -0.03918534f, -0.00877994f, 0.01440454f, 0.10052839f, 0.07353408f, 0.04034278f, 
    -0.00989594f, -0.14135881f, 0.06291560f, -0.23559962f, 0.20463690f, 0.07690168f, 0.05024124f, 0.04685361f, 
    0.10321167f, 0.01324297f, 0.03565401f, 0.02172353f, 0.05408895f, 0.03337137f, 0.01051086f, -0.08396788f, 
    -0.03600603f, 0.04486392f, 0.11454958f, -0.10701112f, -0.01980132f, 0.00178649f, 0.10292589f, 0.03514351f, 
    -0.00890474f, -0.06422229f, 0.00427866f, -0.00357137f, -0.03240341f, -0.08780833f, 0.16352335f, -0.10435223f, 
    0.06869645f, 0.00926770f, 0.16566613f, -0.06915061f, 0.09647179f, -0.10586706f, -0.00876875f, 0.08766456f, 
    0.08660686f, 0.00340049f, 0.15600152f, 0.18430008f, 0.21028125f, -0.04644639f, 0.07906260f, -0.05030904f, 
    0.06773911f, 0.02203679f, -0.13214661f, 0.29848549f, 0.00714374f, -0.12807223f, 0.11749969f, -0.01402426f, 
    -0.02480848f, -0.03320011f, 0.04803692f, -0.13279714f, 0.06029117f, 0.16201705f, 0.13519220f, 0.05406997f, 
    0.00756567f, -0.07095729f, 0.38733244f, -0.04499966f, 0.06439392f, -0.01308734f, 0.15655072f, 0.01916051f, 
    0.06410386f, -0.10051975f, 0.00365692f, -0.15880288f, 0.19158383f, -0.03231028f, -0.06508344f, -0.01361029f, 
    -0.06221079f, -0.06824753f, -0.02225558f, -0.03022179f, 0.18712080f, 0.06921603f, 0.04050687f, -0.00217259f, 
    0.06505954f, 0.10676900f, -0.03531644f, 0.08945348f, 0.12558271f, 0.28874451f, -0.28166106f, -0.00998150f, 
    -0.01896517f, -0.23936632f, -0.17902906f, 0.07331469f, 0.10934392f, 0.23819628f, 0.19163062f, -0.01881028f, 
    0.07565973f, -0.04224646f, 0.02330361f, -0.07284724f, 0.08733638f, -0.04912239f, 0.06012764f, -0.01667874f, 
    0.09714235f, 0.23364924f, -0.20963289f, -0.09354126f, -0.04682779f, 0.09862414f, 0.02400141f, 0.03843638f, 
    -0.01680654f, -0.19426921f, 0.16524974f, -0.03710419f, 0.14050797f, 0.11689807f, 0.04547621f, -0.02984002f, 
    -0.02637062f, -0.02238810f, -0.05605338f, -0.01800572f, 0.03131895f, -0.06184663f, 0.00025073f, 0.05390013f, 
    0.09479497f, -0.21644071f, 0.35328224f, -0.05558577f, -0.02042304f, 0.10774744f, 0.02977486f, 0.04019103f, 
    -0.06476385f, 0.04552688f, 0.04186504f, 0.00288218f, 0.30739731f, -0.08976944f, -0.01074500f, 0.09902943f, 
    0.06276309f, -0.03631227f, 0.09395623f, -0.09331608f, -0.05346898f, 0.10440812f, 0.12226338f, 0.09305240f, 
    0.36951932f, -0.05387586f, -0.09706220f, 0.02763834f, 0.14304791f, -0.02593176f, 0.31727928f, 0.01234503f, 
    0.04160221f, -0.02156414f, -0.11324232f, -0.08856273f, -0.05404963f, -0.03763577f, -0.02744019f, -0.01921979f, 
    0.03273672f, -0.12989037f, 0.14040241f, -0.00119480f, 0.04940574f, 0.03280818f, -0.05429967f, -0.02026333f, 
    0.10661215f, 0.01782155f, 0.00034967f, 0.13961753f, 0.14972632f, 0.23897403f, -0.17703706f, 0.15427066f, 
    -0.00976721f, 0.07912941f, 0.08630650f, -0.07787582f, 0.23128046f, 0.19530039f, 0.02756155f, -0.07865110f, 
    -0.01519580f, -0.03468000f, -0.01733064f, 0.03130144f, 0.07760405f, -0.16373831f, -0.01393741f, -0.00589082f, 
    0.41511098f, -0.28204510f, 0.26322025f, 0.04857916f, 0.01124466f, -0.00136413f, 0.01276079f, -0.07591158f, 
    0.06460813f, -0.06924971f, -0.06383539f, 0.11627034f, 0.15019412f, 0.05833817f, 0.20981219f, -0.04531776f, 
    0.02112575f, 0.18568537f, -0.16638811f, -0.02746140f, 0.07575651f, -0.08292078f, 0.02994410f, 0.02519299f, 
    -0.05019688f, 0.08578411f, -0.09905854f, 0.20503540f, 0.18188348f, 0.07324998f, -0.07341662f, 0.17056133f, 
    0.10674682f, -0.20651872f, 0.23217261f, 0.11582129f, 0.07559744f, 0.20514598f, 0.13437720f, 0.02956714f, 
    0.09461327f, 0.01418462f, -0.02305406f, -0.19986345f, 0.10218855f, 0.23407249f, -0.02465701f, 0.05576785f, 
    0.06044183f, 0.12787519f, 0.07079962f, -0.06344639f, 0.12376733f, -0.00955002f, 0.05657853f, -0.07728025f, 
    0.07632238f, 0.07227845f, 0.00862309f, 0.07802180f, -0.05030215f, -0.06542539f, -0.30486628f, -0.08705477f, 
    0.00398994f, 0.08563248f, 0.01978231f, 0.22865348f, -0.01482076f, -0.02057381f, 0.02155266f, 0.01856596f, 
    -0.10555990f, -0.03854950f, 0.09362321f, 0.10497323f, 0.03753452f, -0.01537414f, 0.22810215f, -0.14807148f, 
    0.05162523f, -0.01879094f, 0.05571897f, -0.06910193f, -0.12143406f, 0.08635826f, -0.04040094f, 0.01504538f, 
    0.15513790f, 0.04705951f, 0.20585483f, 0.02417324f, 0.05736003f, -0.00467166f, 0.02454085f, 0.13204737f, 
    -0.04707402f, -0.22521941f, -0.12186950f, -0.15506747f, -0.07713238f, -0.04492127f, -0.06474474f, 0.09497353f, 
    0.00136256f, 0.05331300f, -0.07410016f, -0.03898984f, -0.08353677f, 0.27493820f, 0.03238891f, 0.02868356f, 
    0.27046052f, -0.02481952f, -0.04877413f, 0.00535003f, 0.04632854f, -0.03703012f, 0.19641185f, 0.04657023f, 
    0.10239651f, 0.07651656f, 0.01278371f, -0.02455769f, 0.13896932f, 0.06435414f, 0.11983687f, 0.06903781f, 
    0.18285617f, -0.15622684f, 0.01977473f, -0.01482586f, 0.23926094f, 0.28106135f, -0.01347511f, 0.09123537f, 
    0.08146960f, 0.11206276f, 0.03444459f, -0.18718146f, -0.05407823f, -0.11765602f, 0.23911129f, -0.01981897f, 
    0.07385336f, 0.26675239f, 0.01344779f, 0.06169241f, 0.15945576f, 0.11048665f, -0.05684339f, 0.00295378f, 
    0.17017838f, -0.15239578f, 0.09615739f, 0.03169345f, 0.10318142f, -0.22631586f, 0.05365874f, -0.23637962f, 
    -0.05249147f, -0.06433646f, 0.03423136f, -0.05363414f, 0.13025880f, 0.02334934f, 0.02253095f, -0.05690129f, 
    -0.00984815f, -0.11885655f, 0.23910138f, -0.16586070f, -0.10990005f, 0.04932456f, 0.06083835f, 0.13313146f, 
    0.11298245f, -0.03093012f, 0.02086509f, 0.08846886f, 0.02718995f, -0.18919836f, -0.04695851f, 0.01544486f, 
    0.00427681f, 0.09321192f, -0.08111742f, 0.13429201f, -0.00336288f, 0.01234087f, 0.22924715f, 0.04457952f, 
    0.14091995f, 0.04252971f, 0.00482209f, 0.00941703f, 0.08136416f, -0.03164760f, -0.01972467f, -0.07207393f, 
    0.05491338f, -0.04591873f, 0.10025566f, 0.04800267f, -0.65037650f, -0.21409674f, -0.14164509f, -0.16306311f, 
    -0.00251506f, -0.10600348f, 0.07156997f, 0.15363769f, -0.08952628f, -0.08358941f, -0.06668401f, -0.09226653f, 
    0.02005978f, -0.05919988f, -0.04877423f, -0.01266852f, 0.21626069f, -0.08445897f, 0.01962213f, 0.14495410f, 
    0.02282765f, 0.00561200f, 0.13550653f, 0.06639021f, -0.14837365f, -0.09832051f, 0.04548889f, -0.03856783f, 
    0.03927553f, 0.11627579f, 0.12855709f, 0.00987311f, 0.02033511f, 0.00980930f, 0.02843451f, 0.04588894f, 
    -0.02338129f, 0.14391205f, 0.04541500f, -0.00942194f, 0.09646568f, -0.02273135f, 0.06579319f, 0.00480763f, 
    -0.04695957f, 0.02529803f, -0.00255505f, 0.09606647f, 0.02866993f, 0.08980777f, 0.18771066f, 0.05414012f, 
    0.02275985f, 0.09117032f, 0.01440329f, -0.18695949f, 0.06211952f, 0.00809080f, -0.00870112f, 0.02720778f, 
    -0.01712187f, -0.00204311f, -0.22146255f, -0.05303891f, -0.00042904f, 0.17809589f, 0.08811585f, -0.02891683f, 
    -0.00032775f, -0.15742658f, 0.15402141f, -0.03485220f, 0.02736414f, 0.00058129f, 0.14239021f, 0.05434434f, 
    0.07754711f, 0.05561630f, 0.06577959f, 0.00407274f, 0.12544508f, -0.00385976f, -0.03085548f, 0.05409403f, 
    -0.11334323f, 0.25704512f, 0.14442976f, 0.03478216f, 0.06231204f, 0.05134493f, -0.08729617f, 0.12359639f, 
    0.05370648f, -0.16207938f, -0.03981318f, 0.19408715f, 0.14391264f, 0.16446625f, 0.03738206f, 0.03519449f, 
    -0.06238128f, -0.06815021f, 0.12060814f, -0.05118263f, 0.00253140f, -0.00624081f, 0.06909309f, 0.05123337f, 
    -0.28995323f, -0.15873139f, -0.04361454f, 0.09862210f, -0.07767471f, 0.10452072f, 0.22988266f, -0.19987217f, 
    0.08480481f, -0.20087768f, 0.01429799f, 0.26231149f, 0.19530749f, -0.30203313f, -0.02748546f, -0.19303624f, 
    -0.09928789f, -0.06558050f, -0.00487342f, 0.01654259f, 0.39056018f, 0.12752472f, 0.10486536f, -0.02750042f, 
    -0.05562907f, -0.05274233f, -0.15690021f, -0.24329168f, -0.02357424f, 0.07226039f, 0.02545918f, 0.13169366f, 
    0.13978761f, -0.01601885f, -0.03615183f, -0.06503928f, 0.07270972f, -0.04897342f, -0.06959732f, -0.14330335f, 
    -0.01161965f, -0.08770430f, -0.02740009f, -0.00353795f, 0.18056253f, -0.04790575f, 0.13005304f, -0.09425039f, 
    0.25289431f, -0.18581764f, -0.08712378f, 0.32275409f, 0.09568559f, -0.16907580f, 0.21625093f, -0.06464662f, 
    -0.05399750f, 0.08989687f, 0.09465633f, 0.06904899f, -0.10219758f, -0.09913947f, -0.13836424f, -0.07074463f, 
    0.07539422f, 0.01753237f, -0.01290669f, 0.06802740f, 0.29403153f, 0.03270253f, -0.12689567f, 0.21366213f, 
    0.14066583f, 0.10887303f, -0.05453259f, 0.00706602f, -0.12799473f, -0.13851152f, -0.10434204f, -0.01384389f, 
    -0.09527190f, -0.04192626f, -0.05519327f, 0.03098842f, 0.02358288f, 0.04805591f, -0.02857077f, 0.05818561f, 
    0.03510598f, -0.09569418f, -0.02738348f, 0.00640785f, -0.06277177f, 0.01385007f, 0.01233873f, -0.01522583f, 
    -0.16059487f, 0.05262015f, 0.06436400f, -0.05587913f, -0.05188225f, 0.03874676f, 0.02375993f, 0.03249316f, 
    -0.28119841f, -0.13015491f, 0.00969526f, -0.08129798f, 0.13130860f, 0.16891876f, 0.04886471f, 0.22215645f, 
    0.08790348f, -0.00537347f, -0.00770239f, 0.00297675f, 0.04639212f, 0.05180067f, -0.03695636f, 0.00899939f, 
    -0.02169706f, 0.11752160f, 0.21298134f, 0.31664687f, 0.01534768f, 0.22493562f, 0.11622149f, 0.17157914f, 
    -0.00316821f, -0.07241279f, -0.04443595f, -0.07066280f, -0.00918269f, 0.00768816f, 0.05207919f, 0.09133465f, 
    -0.04511911f, 0.04773525f, -0.06410891f, -0.02247728f, -0.01149907f, 0.04264479f, -0.10857374f, -0.19570079f, 
    0.41813552f, 0.18382820f, 0.08527211f, 0.14267936f, 0.16191053f, 0.11281780f, 0.01981204f, 0.05317616f, 
    -0.02019046f, -0.02511595f, -0.06299411f, 0.04927788f, -0.01646274f, -0.06209789f, 0.03842130f, 0.15121461f, 
    0.23116697f, 0.22567539f, -0.07146380f, 0.10303156f, 0.21366926f, 0.18085478f, 0.07692681f, 0.12900321f, 
    0.13066380f, 0.13795397f, 0.28080329f, -0.27262223f, -0.12876704f, 0.23204727f, -0.00070872f, 0.13370501f, 
    -0.12034560f, 0.00842469f, -0.08077816f, 0.01360152f, 0.46612480f, 0.20033850f, 0.10736093f, 0.15646452f, 
    0.15883084f, 0.09742711f, 0.02065603f, 0.00500898f, -0.07679266f, 0.00133073f, -0.04449547f, 0.02020196f, 
    -0.01854194f, -0.17305163f, 0.16188562f, 0.14954568f, -0.07652505f, -0.03470993f, -0.40625489f, -0.03546767f, 
    0.25263518f, -0.12091579f, -0.05162969f, -0.15085378f, 0.10311688f, -0.06554094f, 0.12751366f, 0.30646822f, 
    0.01457333f, -0.15761577f, 0.09558374f, -0.05335674f, -0.03684824f, -0.02421158f, 0.06902940f, 0.12775175f, 
    0.05287284f, -0.20852052f, 0.15138836f, 0.11823642f, 0.03946511f, -0.01415355f, 0.03503821f, -0.09476157f, 
    -0.07069776f, -0.05007908f, -0.16362706f, -0.03504292f, -0.13554390f, 0.04777636f, 0.25778043f, 0.07770262f, 
    -0.04114275f, -0.18498023f, -0.13319248f, -0.05802605f, 0.05007971f, -0.01724605f, -0.16521926f, -0.01726514f, 
    -0.00852218f, -0.04091201f, -0.04011780f, -0.05311927f, 0.02380910f, 0.05928195f, -0.14898476f, 0.05240676f, 
    -0.20115264f, -0.13276434f, -0.13973530f, -0.07995641f, 0.12827009f, -0.05866819f, -0.11625643f, 0.15915240f, 
    -0.02180068f, 0.02947761f, -0.23862806f, -0.16950805f, -0.03451864f, 0.00541528f, 0.05962645f, 0.02084830f, 
    0.18011978f, 0.16451769f, 0.01880004f, 0.18644959f, -0.07669201f, 0.08689655f, 0.02922857f, 0.15757640f, 
    -0.01139641f, 0.00071221f, 0.05288795f, 0.00978171f, -0.03776437f, 0.06375758f, -0.01554535f, 0.05902001f, 
    0.03419577f, 0.00042872f, 0.05202710f, 0.01963743f, -0.00225744f, 0.07803103f, 0.04127032f, 0.03387563f, 
    -0.01868567f, 0.02027623f, 0.13643093f, 0.03504480f, -0.07468434f, 0.06092916f, -0.00116030f, -0.03314441f, 
    -0.00799317f, 0.03168580f, 0.07320955f, -0.00939427f, 0.02008475f, 0.11832634f, 0.05426508f, -0.08210118f, 
    0.01033525f, 0.05275246f, -0.00133945f, 0.09536923f, -0.01440978f, -0.07294026f, 0.00503331f, -0.01885273f, 
    0.19091514f, 0.14196743f, -0.36780000f, -0.04563735f, -0.03044249f, 0.00094018f, 0.00818157f, 0.00994735f, 
    -0.11082036f, 0.15891939f, 0.00793220f, -0.06273774f, 0.00081625f, 0.03642257f, 0.04970292f, -0.06861635f, 
    -0.03886547f, 0.03015044f, 0.06847466f, 0.02405105f, -0.08647352f, 0.01723968f, 0.00464734f, 0.04699172f, 
    -0.03358595f, -0.11323092f, 0.25996971f, -0.03220748f, -0.03304989f, -0.05124802f, -0.00138508f, -0.02777307f, 
    0.05044705f, 0.03365228f, 0.01303302f, -0.15900828f, 0.14013347f, 0.02428628f, -0.00166707f, -0.00765795f, 
    0.03541201f, 0.01611884f, 0.00129559f, 0.01968877f, -0.01926910f, 0.13665052f, 0.03524234f, 0.14871731f, 
    -0.04743381f, 0.00712219f, 0.09036226f, 0.19928928f, 0.05256979f, -0.04760481f, 0.00581925f, -0.05325020f, 
    0.05931673f, 0.24472398f, -0.02785889f, 0.16499439f, 0.06358890f, 0.02475878f, 0.01351637f, 0.07007609f, 
    0.04446457f, -0.02114644f, -0.01436753f, -0.01050762f, 0.06165789f, 0.02464703f, -0.04132481f, -0.06323497f, 
    0.02610356f, 0.26684120f, -0.11223501f, 0.07125476f, 0.06089427f, -0.01122039f, 0.14097391f, 0.10201792f, 
    -0.08730906f, -0.08144611f, -0.05181653f, 0.03280457f, -0.10586862f, 0.05213826f, 0.08061954f, -0.06304064f, 
    -0.12785067f, 0.08777145f, -0.09233642f, 0.09897727f, 0.03135249f, -0.04278402f, -0.00911355f, -0.01795276f, 
    0.01150622f, -0.22373436f, -0.08293440f, 0.06513645f, -0.01381746f, 0.05440862f, -0.18777736f, 0.09156077f, 
    0.17203930f, -0.01948590f, 0.07943239f, 0.01159997f, 0.20762713f, 0.02344747f, 0.07290158f, 0.27853763f, 
    -0.10264911f, -0.04392807f, 0.01165388f, 0.22484538f, -0.02960819f, 0.00893956f, 0.03719396f, -0.00061750f, 
    -0.04443141f, 0.06096997f, 0.09254621f, 0.01074407f, -0.01451012f, -0.05591474f, 0.06444836f, -0.05732717f, 
    0.02495693f, -0.03102180f, 0.03799514f, 0.08261395f, 0.03439097f, 0.01179725f, 0.08618371f, 0.02301176f, 
    -0.04669832f, 0.05202614f, 0.05761174f, -0.00024964f, 0.11688409f, 0.08081897f, 0.02432744f, 0.06163985f, 
    -0.24757586f, 0.15780075f, 0.05644639f, -0.19507767f, -0.04904800f, 0.05136742f, 0.01784523f, 0.00348337f, 
    0.04018658f, 0.08882305f, 0.11889298f, 0.02899305f, -0.13127059f, 0.08094090f, 0.05421292f, -0.08306774f, 
    -0.01535726f, -0.09261965f, 0.03516793f, -0.00477482f, -0.03372183f, 0.12448551f, 0.05072362f, 0.08342716f, 
    0.06305528f, -0.14746219f, 0.02770980f, -0.14156760f, 0.00208721f, 0.13163884f, -0.11309962f, 0.06521119f, 
    0.07237992f, 0.02005762f, -0.13699076f, 0.03876607f, 0.15105414f, 0.11887228f, 0.05286552f, 0.12384659f, 
    0.03094903f, 0.13061714f, 0.21514715f, 0.10712692f, 0.17629012f, -0.05554377f, 0.02171112f, 0.05099970f, 
    0.22793010f, 0.16571052f, 0.13485502f, 0.24458428f, 0.25302124f, 0.18353745f, 0.09848085f, 0.21028867f, 
    0.03547809f, -0.03684967f, 0.02625979f, -0.01612064f, 0.21832363f, -0.28032380f, -0.20502065f, 0.07067537f, 
    0.11766290f, 0.04729416f, -0.03991790f, -0.21902238f, 0.00692098f, -0.08130519f, -0.09152319f, -0.21067147f, 
    -0.09120269f, 0.00072885f, 0.06870905f, -0.01017456f, -0.05471238f, -0.03898714f, -0.04826527f, 0.06109690f, 
    -0.04038403f, 0.03080173f, 0.06383947f, 0.02585746f, 0.28056180f, 0.19027826f, 0.09204382f, 0.43222171f, 
    0.07673484f, 0.15936060f, -0.10454807f, -0.29589340f, -0.04349528f, -0.02267207f, 0.00667294f, -0.10036768f, 
    0.06209823f, 0.09807383f, -0.15394308f, 0.04823740f, 0.01491683f, 0.06499296f, 0.01625570f, -0.13000116f, 
    -0.22745553f, -0.23270428f, -0.09456891f, -0.10245484f, -0.13211940f, -0.01286942f, 0.33788463f, -0.34017104f, 
    -0.19099174f, -0.05571771f, 0.18455990f, 0.00996484f, -0.02664247f, 0.03347420f, -0.17316951f, -0.05782992f, 
    -0.01950707f, 0.00345729f, -0.05926609f, 0.14295578f, 0.04614678f, 0.06177054f, -0.08176290f, -0.12329124f, 
    -0.02625989f, 0.08543954f, -0.00423706f, 0.08016060f, 0.06252935f, 0.03072305f, 0.13832442f, -0.09038364f, 
    0.00707932f, -0.01380740f, -0.15803581f, -0.13142793f, 0.08261636f, 0.19094020f, 0.01408666f, 0.00845011f, 
    0.46721712f, 0.11734772f, -0.09775628f, 0.05406356f, 0.06536056f, 0.01186770f, -0.04209463f, -0.00514636f, 
    -0.03401648f, 0.10536386f, -0.02613592f, 0.05326467f, -0.07419425f, 0.07718734f, 0.02856622f, -0.14592861f, 
    0.00387515f, 0.07137834f, 0.06773004f, 0.10709236f, -0.14384778f, -0.01306204f, -0.07650121f, -0.05340702f, 
    0.07193039f, 0.12624517f, -0.27866685f, 0.30811706f, -0.00904150f, 0.02757765f, -0.10938309f, -0.05860408f, 
    0.09766146f, -0.11911054f, -0.01439515f, -0.07379323f, 0.09251682f, 0.12623484f, 0.03866139f, -0.26044646f, 
    -0.19739322f, 0.16560268f, -0.09823947f, -0.08882696f, 0.09511612f, 0.05216778f, -0.17701633f, -0.20330146f, 
    -0.01298067f, -0.06649734f, -0.00457369f, -0.01031771f, -0.01369809f, 0.03151120f, 0.00564665f, 0.07968786f, 
    0.00433189f, 0.01689675f, -0.07197855f, -0.05034142f, 0.51190186f, 0.23423405f, 0.24743664f, 0.20389141f, 
    -0.00073456f, 0.10030125f, -0.01786781f, 0.05447433f, -0.05706106f, -0.01351988f, -0.11552995f, 0.00968128f, 
    0.05358357f, 0.06168857f, -0.00155925f, 0.02899998f, -0.05002107f, -0.01470412f, -0.11020532f, -0.08251054f, 
    -0.08363675f, -0.08847031f, -0.04490505f, -0.01289750f, 0.26864401f, 0.39811563f, 0.23456404f, 0.30988556f, 
    0.12776014f, 0.16656105f, 0.02924407f, 0.10504426f, -0.03967401f, 0.02256903f, -0.01559576f, 0.05598610f, 
    0.32484949f, -0.00475003f, -0.25809789f, 0.13316831f, -0.00855733f, 0.06176963f, -0.03050700f, -0.13524540f, 
    0.01843043f, 0.08074381f, -0.03258896f, -0.04966535f, 0.27143794f, 0.20050348f, 0.19808881f, 0.22630438f, 
    0.06871345f, 0.12445352f, 0.07402138f, 0.13073805f, -0.04103391f, -0.01098488f, -0.00151949f, 0.03018410f, 
    0.23143639f, -0.34517431f, -0.16833994f, 0.11217390f, 0.09757618f, 0.08780215f, -0.01510132f, -0.13495421f, 
    -0.01264352f, 0.11012693f, -0.15135269f, 0.04640706f, -0.03493832f, 0.02475584f, 0.00570218f, 0.06722735f, 
    -0.00893147f, -0.02241768f, 0.01971529f, -0.03855976f, -0.05058509f, -0.04787176f, 0.02779401f, -0.11368761f, 
    -0.06799886f, 0.07741965f, -0.08120683f, 0.12534203f, 0.07830121f, 0.00288665f, 0.26740593f, -0.00342342f, 
    0.00475102f, 0.15011509f, -0.03107047f, -0.01186088f, 0.21649268f, -0.05646670f, -0.04302923f, 0.03587765f, 
    0.01642374f, -0.23794194f, 0.07901970f, 0.10496058f, -0.01358844f, -0.02142850f, 0.00049896f, -0.05923462f, 
    0.27035448f, -0.10978536f, 0.06758212f, 0.24721469f, 0.09253397f, 0.09666175f, -0.09682679f, -0.15660235f, 
    0.05965110f, 0.25569186f, -0.07287433f, 0.00066326f, -0.01513794f, 0.10397479f, -0.05680177f, -0.04550179f, 
    -0.01598362f, 0.03555085f, 0.09576546f, 0.09275958f, -0.16310838f, -0.03139860f, -0.06107763f, -0.04244619f, 
    0.04164020f, -0.05199992f, -0.27665409f, -0.00036737f, 0.10760542f, 0.14049186f, 0.10240792f, 0.11952513f, 
    -0.02621273f, 0.05057824f, -0.06987053f, -0.21410167f, 0.01906223f, -0.00020883f, -0.04179455f, -0.12227699f, 
    -0.01809754f, 0.03773761f, 0.07589271f, 0.13497376f, -0.10625733f, 0.01619594f, -0.03059736f, -0.17765602f, 
    -0.16025706f, 0.06983107f, 0.25442037f, -0.39567626f, -0.23128054f, 0.05242103f, 0.01947542f, 0.14830358f, 
    0.00836474f, -0.05072504f, 0.00601562f, 0.01195912f, 0.13067089f, 0.09524551f, 0.04546685f, 0.03135749f, 
    0.16074096f, 0.11131631f, -0.00089027f, 0.01136117f, 0.09267382f, -0.03630664f, 0.03013454f, -0.26834181f, 
    0.02035544f, 0.01375730f, 0.00166791f, -0.01205957f, 0.00452565f, -0.03477347f, -0.00269062f, 0.01133677f, 
    0.01250859f, -0.00725883f, 0.01438790f, 0.00996215f, 0.01565322f, 0.01415225f, 0.00919582f, -0.04030788f, 
    -0.00937536f, -0.03304145f, -0.00873597f, 0.02792353f, 0.01834623f, 0.02137726f, 0.00823818f, 0.02202312f, 
    -0.04426230f, 0.01785130f, -0.03272060f, -0.03439304f, -0.01125172f, -0.02112054f, -0.02409595f, -0.02221982f, 
    -0.01847502f, -0.03308567f, -0.03901559f, -0.01360897f, -0.02115884f, 0.01843026f, 0.02710288f, -0.01782739f, 
    0.00340953f, -0.04297221f, -0.01640728f, 0.00975735f, 0.01826818f, -0.01905938f, -0.00613608f, -0.00831650f, 
    -0.01624781f, 0.01845416f, -0.02061393f, 0.00103106f, 0.01513703f, 0.00070127f, -0.02912979f, 0.00564369f, 
    -0.03230191f, -0.00744012f, -0.03109878f, -0.01438498f, 0.01496391f, -0.00015623f, -0.03063098f, -0.01909330f, 
    -0.00526013f, -0.01556729f, 0.01144199f, -0.02653394f, -0.00643635f, 0.00226309f, 0.00672303f, -0.04077151f, 
    -0.02488861f, -0.00235586f, 0.00741333f, 0.02096609f, -0.00926182f, -0.01644392f, -0.03254203f, 0.00607707f, 
    -0.00052278f, 0.02027827f, -0.03648096f, -0.04220079f, 0.00926868f, 0.02267651f, -0.01530092f, -0.01984175f, 
    0.00617730f, -0.03212900f, 0.00186469f, -0.03409907f, 0.00807771f, -0.02301937f, 0.00190256f, 0.01382725f, 
    0.02072153f, 0.01095067f, -0.01906450f, -0.02872974f, 0.02939394f, -0.01246313f, -0.01040130f, -0.01152758f, 
    -0.00720850f, -0.04441651f, -0.01904173f, 0.00514813f, -0.03747183f, 0.00332761f, 0.01545808f, 0.00068674f, 
    -0.03959959f, -0.04184137f, 0.02303238f, 0.02267972f, -0.00588901f, -0.00570172f, -0.01936092f, 0.00866884f, 
    -0.00379503f, 0.02842480f, -0.01335431f, 0.00412839f, -0.02096577f, 0.00533583f, -0.00249482f, -0.03285056f, 
    0.00015766f, -0.02102793f, 0.02651321f, 0.03222556f, 0.01580322f, -0.00670674f, 0.02203573f, -0.01455283f, 
    -0.04277658f, 0.01605795f, 0.02137917f, -0.03946925f, -0.00571457f, 0.01385990f, -0.03656874f, -0.02229153f, 
    0.02171499f, 0.01334039f, 0.01579492f, 0.00453913f, 0.01632674f, -0.03567786f, -0.03142294f, -0.01041788f, 
    -0.00738998f, -0.01062603f, -0.01252363f, 0.01995878f, 0.01313263f, -0.01816702f, -0.03883048f, 0.00967576f, 
    0.01050216f, -0.03849543f, 0.02604937f, -0.01262073f, -0.01890977f, 0.01356541f, -0.00698513f, -0.00978167f, 
    -0.02542598f, -0.00140932f, 0.01141433f, -0.03879621f, -0.01974828f, -0.00866763f, 0.01075802f, -0.04170924f, 
    -0.02562390f, -0.02268208f, -0.03429804f, -0.01080844f, -0.01152961f, -0.03014138f, -0.01733555f, -0.03444662f, 
    0.01045599f, -0.04025436f, 0.02115482f, 0.00289575f, -0.02012636f, -0.04247237f, 0.01877055f, -0.03639428f, 
    -0.00257424f, -0.01215662f, 0.00610599f, -0.01519534f, 0.00402694f, -0.01947224f, 0.01366580f, 0.02213453f, 
    -0.03627507f, -0.02187834f, -0.00775102f, 0.00691296f, 0.02047425f, 0.02476934f, -0.03699276f, -0.00069608f, 
    0.00739777f, -0.02880137f, -0.02975742f, 0.00645088f, -0.00300037f, 0.00083567f, -0.03146403f, -0.03654665f, 
    0.02869690f, 0.01774136f, 0.02873154f, 0.01995706f, -0.02516853f, -0.00990578f, -0.04124299f, -0.00141545f, 
    -0.01890581f, -0.01278898f, -0.01288919f, -0.00371718f, -0.00691401f, -0.02408675f, -0.00310521f, -0.00481434f, 
    0.02393857f, -0.02146074f, -0.03745745f, 0.00525786f, -0.03002287f, -0.01023347f, 0.02691223f, -0.02033313f, 
    0.01667588f, -0.04229867f, -0.03203318f, 0.01075340f, -0.03105198f, -0.02371114f, -0.00928961f, -0.01598094f, 
    -0.03886869f, 0.01983337f, -0.04159471f, -0.00197417f, 0.02162306f, 0.01601917f, -0.00155127f, 0.00463343f, 
    0.02270221f, -0.01771741f, 0.01783954f, -0.00849287f, 0.01535112f, -0.00910867f, -0.00194667f, 0.00536566f, 
    -0.01939555f, 0.00936998f, 0.00862501f, 0.02218256f, -0.03892301f, -0.03852999f, -0.01499552f, 0.00311780f, 
    -0.01288195f, 0.00867646f, -0.02327313f, -0.03987195f, 0.02176229f, 0.02050849f, 0.02466597f, -0.03205191f, 
    -0.00856120f, -0.01468974f, -0.01316738f, -0.02910308f, -0.03540092f, -0.01083131f, 0.01404813f, -0.00909674f, 
    -0.02083940f, -0.00886292f, 0.02724075f, 0.00005245f, -0.03288849f, -0.03844218f, -0.02655929f, 0.00437298f, 
    0.00487850f, -0.02550708f, -0.03258378f, 0.00822672f, 0.02631387f, -0.02558010f, 0.01417058f, -0.02021635f, 
    -0.00724257f, -0.03901388f, -0.01952254f, -0.02480247f, -0.01364434f, -0.03246155f, 0.00790260f, -0.01546929f, 
    -0.01245090f, 0.01463812f, -0.03508131f, -0.03803933f, -0.00164911f, 0.00877146f, 0.02259752f, -0.03117365f, 
    0.02008303f, -0.01435093f, 0.00176239f, -0.03710763f, -0.02267155f, 0.01601114f, -0.01072239f, 0.01187021f, 
    -0.01551443f, -0.01355386f, -0.04143874f, -0.03054146f, 0.01199433f, -0.03129843f, 0.00131507f, -0.02910491f, 
    -0.04441981f, 0.01594831f, 0.01900548f, 0.00087797f, 0.01586645f, -0.03465763f, 0.02448662f, -0.00991636f, 
    -0.01060498f, -0.04272684f, -0.00932605f, -0.01748794f, 0.01057123f, 0.00015428f, -0.01285733f, 0.01617809f, 
    -0.00305552f, -0.00496844f, -0.00181088f, 0.01857330f, -0.03099016f, -0.01690745f, 0.00715074f, 0.02321238f, 
    -0.02555322f, 0.00298102f, 0.00394915f, -0.03550380f, -0.02026897f, 0.01842643f, -0.04276770f, 0.01764335f, 
    -0.01710464f, -0.00617015f, 0.00573057f, 0.01509221f, -0.00591191f, 0.02406732f, -0.00980724f, 0.01853250f, 
    0.00919903f, 0.02297162f, 0.02008012f, -0.03359215f, -0.01157070f, 0.00918162f, 0.02118355f, -0.00001299f, 
    -0.01560177f, -0.00926993f, 0.01025775f, 0.02518102f, 0.00017271f, 0.01109817f, -0.02663612f, 0.01138186f, 
    -0.00921558f, 0.02211973f, -0.02076157f, -0.02470622f, 0.01233725f, -0.04458859f, 0.02046039f, 0.01976642f, 
    0.02505496f, -0.02982467f, -0.01572248f, 0.02529913f, -0.00603553f, -0.01454388f, -0.01545449f, 0.01482109f, 
    -0.00042005f, -0.00888614f, -0.00833587f, -0.02833201f, 0.01242844f, 0.01968754f, 0.02704077f, 0.02718207f, 
    -0.03233815f, -0.01413444f, -0.01014313f, -0.04120304f, -0.00429251f, 0.02645852f, 0.00253683f, -0.01066358f, 
    -0.00764689f, -0.01682654f, -0.03234449f, -0.03930322f, -0.01447308f, 0.00990962f, -0.00212586f, -0.01420904f, 
    -0.00163903f, -0.01542300f, 0.01153147f, -0.01117067f, -0.01263706f, 0.00626004f, 0.00555283f, 0.00826499f, 
    -0.02649587f, -0.00484613f, 0.01518898f, 0.01758666f, -0.00540631f, -0.00465037f, -0.04396741f, 0.00721669f, 
    0.01228653f, 0.00205400f, -0.00064400f, -0.03069785f, 0.01609257f, -0.01136980f, -0.02402844f, -0.03032547f, 
    -0.03953063f, 0.01065076f, 0.01712985f, -0.01516458f, 0.02148298f, -0.03279779f, -0.01657492f, 0.00594310f, 
    -0.02060276f, 0.00304670f, -0.03407284f, -0.04299457f, -0.02399633f, -0.01876155f, 0.00615945f, -0.01649630f, 
    0.02276464f, -0.02241050f, -0.04027327f, -0.02415069f, 0.02407378f, 0.00581034f, 0.01140130f, 0.00437194f, 
    -0.04103799f, -0.01280059f, -0.03870866f, 0.02415497f, -0.00670404f, -0.00752418f, 0.00663423f, -0.00522027f, 
    -0.00935626f, 0.01808520f, 0.00188436f, -0.00414774f, 0.01795931f, -0.03387491f, -0.00638337f, -0.04061526f, 
    0.02307426f, -0.01396430f, -0.02974827f, -0.01070813f, 0.00973918f, -0.04282767f, 0.00771811f, 0.00068363f, 
    0.01981074f, -0.02648559f, 0.01303935f, 0.02270726f, -0.00113857f, 0.02057927f, 0.02195867f, -0.01982683f, 
    0.01428940f, -0.02849028f, 0.00883300f, -0.02512158f, -0.03125023f, -0.03014581f, -0.01071711f, 0.01467857f, 
    -0.02499695f, -0.03461805f, -0.02851450f, -0.00404736f, -0.03841127f, -0.04331799f, 0.01384889f, -0.02903254f, 
    -0.02203190f, -0.02665568f, 0.02454822f, -0.01505842f, -0.04193391f, -0.02345440f, -0.03083584f, -0.02115636f, 
    0.00919293f, -0.00519408f, 0.00695737f, -0.00172353f, -0.00778775f, -0.02267138f, -0.00113449f, -0.01568862f, 
    -0.01922221f, -0.03387270f, -0.00179582f, -0.01587067f, -0.01759548f, -0.02113636f, -0.02370060f, -0.03684077f, 
    -0.04412024f, -0.00913108f, -0.01859496f, -0.03764096f, 0.00943146f, 0.02532820f, -0.02583599f, -0.01015538f, 
    0.01735702f, -0.02457726f, 0.01917644f, -0.04126735f, -0.01694760f, -0.00878445f, -0.00296547f, 0.01766252f, 
    0.00175893f, -0.01985562f, 0.00939136f, -0.01951966f, 0.02550405f, -0.00364139f, -0.01089002f, -0.00072306f, 
    -0.01845581f, 0.02271788f, -0.01683711f, -0.01630059f, -0.00346860f, -0.01056265f, 0.01365694f, -0.01146596f, 
    -0.03858168f, 0.01089636f, -0.00918687f, -0.03445960f, -0.00444000f, -0.03797433f, -0.02181795f, -0.00898101f, 
    -0.01596758f, 0.01044783f, 0.01549296f, -0.02353754f, 0.01893822f, -0.02123346f, 0.01161339f, 0.02494931f, 
    0.02620826f, -0.04321832f, -0.00452717f, -0.02537791f, 0.01011119f, -0.00209231f, -0.02104671f, 0.01429600f, 
    0.00278663f, -0.02619429f, 0.00487242f, 0.01726966f, -0.01914170f, -0.02340648f, 0.01299279f, -0.00850660f, 
    -0.02180923f, -0.02998951f, -0.03147442f, 0.00207399f, 0.00371142f, -0.03462756f, -0.03076216f, -0.04328757f, 
    -0.01243909f, 0.02536287f, -0.01215905f, -0.03194689f, -0.02981604f, -0.04353514f, -0.03280945f, -0.04370018f, 
    -0.02804634f, -0.01774781f, -0.03963895f, 0.02035102f, -0.00547326f, 0.00106389f, -0.02524986f, -0.01481462f, 
    0.01585382f, 0.01881501f, 0.02143145f, -0.00712993f, 0.01452010f, 0.02274110f, 0.00766427f, 0.02287025f, 
    -0.03126811f, 0.01607548f, 0.02348812f, 0.00199533f, -0.02301148f, -0.03346967f, 0.02746332f, 0.00720356f, 
    0.00573167f, -0.02313215f, -0.01341062f, 0.02068584f, -0.02022386f, -0.03141426f, -0.00034235f, 0.00389456f, 
    0.01249150f, 0.01150948f, -0.00188206f, 0.00899116f, 0.01551965f, -0.00837323f, -0.02916953f, -0.01985603f, 
    0.01049535f, 0.02656474f, 0.01248061f, -0.01277474f, 0.00475549f, -0.03337417f, -0.01808993f, -0.01352635f, 
    -0.00392835f, -0.02842251f, -0.01321329f, 0.01294828f, -0.01591904f, 0.02112395f, 0.00241729f, -0.02243671f, 
    0.01901452f, -0.02958292f, -0.01178200f, -0.02706059f, 0.00848712f, 0.00437682f, -0.00398703f, 0.00272402f, 
    -0.03695662f, -0.03277287f, -0.02335591f, 0.00472304f, -0.03849604f, 0.02058322f, 0.00944093f, 0.02024956f, 
    0.02087943f, 0.01907241f, -0.02707475f, -0.03522608f, -0.00573650f, -0.02846965f, 0.00038752f, 0.01258800f, 
    0.00154373f, -0.01856647f, 0.02226641f, -0.01576931f, -0.03041934f, -0.03035117f, -0.04169492f, -0.00200633f, 
    -0.03706927f, -0.02006994f, 0.01822454f, -0.00005961f, -0.02082339f, -0.02250992f, -0.01341315f, 0.01848749f, 
    0.00077007f, 0.01590654f, 0.00677037f, 0.01719152f, 0.00708715f, -0.01998433f, 0.01520343f, 0.01968414f, 
    -0.03480052f, -0.04052356f, 0.00782834f, -0.02216234f, -0.04235663f, 0.01404348f, -0.01088510f, 0.00411820f, 
    -0.01208604f, 0.01941233f, 0.01340333f, -0.03904551f, -0.00309666f, 0.01609829f, -0.03932571f, -0.02671031f, 
    -0.04277952f, 0.00153511f, -0.01182463f, 0.00150780f, -0.00703335f, 0.02647937f, -0.02665033f, 0.00527718f, 
    -0.04443220f, -0.02598073f, -0.00300850f, -0.00468273f, -0.03045943f, 0.02595142f, -0.01097614f, 0.02751658f, 
    -0.26764682f, -0.05267447f, -0.29557690f, 0.20824820f, -0.01348228f, 0.03377615f, 0.03538908f, 0.01735412f, 
    -0.02238741f, -0.06390529f, -0.05070711f, 0.21171008f, 0.02829039f, -0.02977942f, -0.03231894f, -0.03802054f, 
    0.14960697f, 0.11134626f, -0.10218122f, 0.02002366f, -0.05572889f, -0.13008399f, -0.11679737f, -0.12895349f, 
    0.04599610f, 0.09578815f, -0.08710078f, 0.02910587f, -0.01590150f, -0.03499152f, -0.00849569f, 0.01384574f, 
    0.13751228f, 0.24488240f, 0.06315901f, 0.21062171f, 0.05062833f, -0.00986249f, -0.10911126f, -0.16179225f, 
    0.16172074f, 0.08265609f, -0.17328227f, -0.01737811f, -0.16147099f, -0.20087236f, -0.12504770f, -0.20901559f, 
    0.13886365f, 0.18656577f, 0.14039375f, 0.03066897f, -0.00746624f, -0.00525165f, -0.03622177f, -0.00610904f, 
    -0.00094071f, 0.09545179f, 0.02880835f, -0.03800721f, -0.25362688f, -0.02099329f, -0.01784453f, -0.07186863f, 
    0.06407007f, 0.03619169f, 0.03089502f, -0.02010685f, -0.01601909f, 0.00554624f, -0.05256620f, 0.08187465f, 
    -0.26613492f, -0.08460816f, 0.10895416f, 0.09759381f, -0.00064001f, -0.04297195f, 0.04065874f, -0.10699987f, 
    0.01843394f, 0.06079717f, 0.07641561f, 0.18780099f, -0.08501451f, 0.24655110f, 0.14417644f, 0.05186981f, 
    0.05328514f, 0.02902624f, -0.05670133f, -0.15381283f, 0.06301018f, 0.18024340f, 0.03158657f, -0.05357920f, 
    0.08743329f, 0.25070831f, 0.22133528f, 0.52527988f, 0.08171974f, -0.10861286f, -0.18166807f, 0.12091041f, 
    -0.13139154f, 0.07792971f, 0.09907629f, -0.10869528f, 0.12052824f, -0.01412039f, 0.18069722f, 0.02334776f, 
    -0.01243440f, -0.17824231f, 0.00077662f, -0.04513194f, 0.03143610f, 0.06424161f, -0.01101833f, 0.21153630f, 
    0.01638567f, 0.11698579f, 0.23108764f, -0.25479326f, 0.12752810f, 0.00409137f, 0.12430516f, -0.32112637f, 
    0.10009053f, 0.02167268f, 0.01245481f, 0.02412769f, 0.07231368f, -0.05765530f, 0.02502730f, -0.14681908f, 
    0.15466417f, 0.15232167f, -0.12649988f, -0.00752343f, 0.00010707f, -0.18220630f, -0.13439873f, 0.01070327f, 
    0.15152891f, 0.17771836f, -0.06427789f, -0.11237837f, 0.03194132f, -0.01076583f, -0.01142599f, -0.04034156f, 
    0.02929343f, 0.13143493f, 0.17202057f, 0.11355277f, 0.36138493f, -0.09070238f, -0.13728279f, -0.04140664f, 
    0.05279038f, -0.06068485f, -0.01707666f, 0.05742753f, 0.00207756f, -0.03370476f, -0.01185285f, 0.00091269f, 
    -0.03930688f, 0.15914600f, 0.01395915f, 0.00833589f, -0.00868097f, -0.07648642f, 0.04281294f, -0.06587645f, 
    0.19302216f, 0.18647520f, 0.13649040f, 0.14490782f, 0.03650283f, 0.25387692f, 0.19159631f, 0.08829466f, 
    0.18282016f, 0.04451824f, 0.09546215f, 0.18893470f, 0.04223264f, -0.07672338f, -0.02758796f, -0.12111969f, 
    -0.10522494f, 0.05432330f, 0.00891878f, 0.16297340f, 0.06990357f, 0.04913050f, -0.01116116f, -0.04169801f, 
    0.10999525f, 0.07334535f, 0.12222383f, 0.27328902f, 0.07033207f, 0.08795550f, -0.00851933f, 0.08419190f, 
    0.06718695f, -0.08951560f, -0.10861855f, 0.09377505f, 0.02026996f, -0.01223444f, -0.04816857f, -0.00370827f, 
    -0.06364623f, 0.11484189f, -0.20244300f, 0.00680276f, -0.07059531f, -0.00003084f, -0.05844618f, -0.04933649f, 
    0.01794016f, -0.07386632f, -0.11848703f, -0.08452822f, 0.02146534f, 0.00928064f, -0.07833255f, 0.07064029f, 
    0.04496575f, 0.10219944f, 0.11984949f, -0.06408729f, -0.04778006f, -0.02009183f, -0.10500498f, -0.13827266f, 
    -0.17673159f, 0.03011305f, -0.14735289f, 0.03088838f, -0.05813040f, 0.10341142f, -0.12581542f, 0.04843135f, 
    0.04402671f, 0.11442596f, -0.02146268f, 0.16854239f, -0.06439413f, 0.02400820f, 0.03351093f, 0.23811607f, 
    -0.00885599f, 0.05083724f, -0.02277088f, -0.03951083f, -0.02061420f, -0.06307354f, -0.08106192f, -0.11095895f, 
    0.18888833f, 0.07237437f, -0.23213582f, -0.02601852f, -0.06868484f, -0.13755783f, 0.01672195f, 0.11070710f, 
    -0.06314486f, 0.05761090f, -0.00866758f, 0.05460259f, -0.00234107f, -0.07896698f, -0.13739768f, 0.01143523f, 
    -0.00080277f, 0.00522414f, -0.02635159f, 0.07320572f, -0.13163577f, -0.01802486f, -0.00387992f, 0.02156043f, 
    0.33505133f, -0.03750087f, 0.11327928f, 0.03080589f, -0.00582781f, 0.07685737f, -0.04821212f, -0.04810506f, 
    0.03517457f, -0.01232423f, 0.12193647f, -0.01919984f, -0.10872846f, -0.11890428f, -0.10668977f, -0.02493099f, 
    0.02049055f, 0.08512347f, -0.00510182f, -0.00690018f, 0.03519003f, 0.14426526f, 0.16552556f, 0.11885168f, 
    -0.29970226f, 0.01065739f, 0.15108950f, 0.07321902f, -0.07160124f, 0.00324375f, -0.08906761f, -0.04592718f, 
    -0.01030529f, -0.05171229f, 0.06810074f, -0.00234991f, -0.11751043f, 0.02757147f, 0.19929156f, -0.01634947f, 
    0.12925768f, 0.02065735f, 0.03754471f, 0.11990642f, -0.00631725f, -0.02314882f, -0.06994305f, -0.07919738f, 
    -0.31052467f, 0.21940632f, 0.01791132f, -0.06052577f, -0.02124540f, 0.04343433f, -0.00005943f, -0.07395168f, 
    -0.00021322f, 0.01690132f, 0.11685558f, 0.15716173f, 0.06077716f, 0.14391088f, 0.08900187f, -0.11256836f, 
    0.06016722f, 0.10412338f, -0.08270991f, 0.08861837f, 0.04430399f, -0.04423612f, -0.02720935f, 0.01030514f, 
    -0.06642636f, -0.05270483f, 0.00463029f, 0.05662865f, 0.07439106f, -0.02683628f, -0.00828490f, 0.01634868f, 
    -0.09612519f, -0.08288050f, -0.05753478f, -0.06429690f, -0.26668158f, -0.09846649f, -0.13395476f, 0.00658855f, 
    0.06010843f, 0.00266168f, -0.00955512f, -0.01311831f, -0.12997301f, 0.04486375f, -0.06562142f, 0.04557736f, 
    -0.15195322f, 0.13705006f, -0.22555052f, 0.24667794f, 0.02148063f, -0.06402095f, 0.05405105f, 0.02225721f, 
    -0.05103096f, 0.00482648f, -0.09837384f, -0.04209064f, 0.21722320f, -0.01287445f, 0.15446316f, 0.17163149f, 
    -0.09224469f, -0.07488028f, 0.02762493f, 0.08481915f, -0.06539737f, -0.07953738f, 0.07306489f, -0.05242566f, 
    -0.08016624f, 0.13885540f, -0.01874532f, 0.16516434f, -0.01918927f, 0.05592841f, -0.07455934f, -0.06661752f, 
    0.00394828f, 0.09278847f, -0.02161803f, -0.00810084f, 0.03303705f, 0.05047392f, 0.16233638f, 0.11214488f, 
    -0.00035180f, -0.04190979f, 0.08187257f, 0.15377747f, 0.06396642f, 0.08644048f, 0.07467553f, -0.00237110f, 
    -0.00960373f, 0.12678142f, 0.14226285f, 0.11626264f, -0.11500751f, 0.02290363f, 0.05730598f, 0.01104877f, 
    0.06088477f, 0.08650391f, 0.04255683f, 0.11542580f, -0.31102300f, 0.15833336f, 0.31757674f, -0.07839590f, 
    0.02795195f, -0.04705416f, 0.02705624f, 0.07010429f, -0.04247316f, 0.15239576f, -0.03202784f, -0.07577996f, 
    0.23365872f, 0.28474173f, 0.11458319f, 0.11304635f, 0.05808617f, 0.05958128f, -0.08405959f, -0.00938054f, 
    -0.02092876f, -0.02894378f, -0.05199079f, 0.03642829f, 0.06002571f, 0.01911276f, 0.20645870f, -0.09037568f, 
    -0.00363323f, 0.02876828f, -0.16240989f, 0.01600784f, 0.04246781f, -0.02064288f, 0.01686228f, -0.02521389f, 
    -0.24047768f, -0.02665284f, 0.03096979f, 0.11292619f, 0.10459890f, -0.10170280f, 0.11240135f, 0.10439588f, 
    -0.11774967f, 0.00941108f, -0.02807215f, 0.08791239f, 0.08986022f, -0.09809674f, 0.03687691f, 0.37494269f, 
    -0.00815119f, -0.02559972f, -0.12559281f, 0.00911641f, -0.10290211f, -0.05275622f, 0.20030645f, 0.18470441f, 
    0.01051364f, -0.06686424f, -0.07146131f, -0.01825951f, -0.00530568f, 0.09035541f, -0.08683286f, -0.07476099f, 
    0.10628227f, -0.02529574f, 0.04631564f, 0.16507173f, 0.21876714f, 0.12333234f, -0.18602219f, 0.11026678f, 
    -0.06512305f, -0.03651302f, 0.03555775f, 0.28812236f, 0.12558691f, 0.09545442f, 0.01577794f, -0.03126922f, 
    -0.15227400f, -0.15659633f, -0.11554681f, 0.07779983f, -0.02016982f, -0.00324576f, -0.08386319f, 0.05350927f, 
    -0.02722304f, -0.07666471f, 0.07318754f, -0.17845988f, -0.36446384f, 0.07072096f, -0.13130939f, 0.43660247f, 
    0.05481208f, -0.01807568f, -0.06242180f, -0.06000573f, -0.11464904f, -0.02519559f, 0.00767639f, 0.27332011f, 
    0.04072247f, -0.00635129f, 0.07701966f, 0.04985744f, -0.09396768f, 0.15944965f, -0.15602675f, -0.02753060f, 
    -0.10238568f, -0.12328265f, 0.03401187f, -0.09578123f, -0.10925083f, -0.14486638f, 0.00537556f, 0.27029195f, 
    0.15257497f, -0.17171992f, 0.17347020f, 0.00037448f, -0.07281346f, -0.07372066f, -0.02692811f, -0.07754133f, 
    -0.12795724f, -0.09584903f, -0.02730849f, 0.06768800f, 0.00747910f, 0.03342167f, -0.04433257f, 0.02447720f, 
    -0.03817072f, -0.00363762f, 0.04777038f, -0.18010281f, 0.29502833f, -0.01480703f, -0.00012832f, -0.02383848f, 
    0.05447050f, -0.23420127f, 0.05969496f, -0.12151694f, -0.01752857f, -0.02565333f, 0.10204758f, 0.09694151f, 
    -0.04874398f, -0.00225892f, 0.06414171f, 0.00222064f, -0.01880268f, 0.05334036f, 0.01289609f, -0.00376811f, 
    0.16689909f, 0.09096092f, -0.02617538f, -0.10804751f, 0.12650937f, 0.20869145f, 0.24632549f, 0.09752953f, 
    0.00816683f, -0.03579776f, 0.02901940f, -0.02413890f, 0.07648931f, -0.03684284f, -0.06206262f, -0.05688985f, 
    -0.15730299f, 0.20344132f, -0.10259991f, -0.04809283f, -0.05511652f, 0.00076764f, 0.00569843f, -0.03190958f, 
    0.15593049f, 0.02115105f, 0.05790783f, -0.06513462f, -0.12445995f, -0.03458701f, 0.20960714f, 0.20460407f, 
    -0.10303909f, -0.07345217f, -0.06921761f, 0.06484454f, -0.00280929f, 0.04279971f, 0.01462468f, -0.08135954f, 
    -0.13110118f, 0.17222774f, 0.26830968f, -0.10966187f, 0.02943223f, 0.00064239f, -0.01290039f, 0.00533364f, 
    -0.03866030f, 0.02742451f, 0.03335376f, -0.12288549f, -0.07770205f, 0.02641884f, -0.08886611f, -0.06836179f, 
    0.01317894f, 0.07498000f, -0.02273570f, 0.04753012f, 0.05990719f, 0.15150857f, -0.09659110f, 0.11314234f, 
    0.37079009f, -0.10677563f, 0.37263304f, 0.10475237f, -0.18391535f, 0.04901227f, -0.26865366f, 0.01987984f, 
    0.00542757f, -0.09582397f, 0.08590192f, -0.01337685f, -0.06901651f, 0.18476148f, 0.11486142f, 0.11779875f, 
    0.02990711f, 0.11257240f, -0.04660905f, -0.06876215f, 0.04618811f, 0.01216411f, -0.09238115f, -0.00755052f, 
    0.19286245f, 0.16022672f, 0.07879299f, -0.31289631f, 0.06364895f, 0.06144361f, 0.01017777f, 0.14501223f, 
    0.11853597f, -0.05734839f, -0.07286395f, -0.16317038f, -0.22792375f, 0.16627556f, -0.15227944f, 0.25927302f, 
    0.01362609f, 0.01763289f, -0.01515776f, -0.09212779f, -0.07063030f, -0.11844251f, -0.07728004f, 0.01469392f, 
    -0.07041178f, 0.06111921f, 0.05987154f, 0.21776529f, 0.01460710f, -0.09997346f, -0.03282186f, -0.04427902f, 
    -0.03508018f, 0.08033314f, 0.07670242f, 0.06291053f, -0.21130097f, -0.08759201f, -0.06385496f, 0.22325303f, 
    0.09734663f, -0.10578922f, -0.01460405f, -0.10870516f, 0.04449991f, 0.05664136f, 0.05161950f, 0.20165667f, 
    -0.02333824f, 0.12373992f, 0.06584319f, 0.23776908f, 0.05510982f, 0.07741760f, -0.06664852f, -0.00518843f, 
    -0.06773637f, -0.06187729f, 0.01588708f, 0.00038529f, 0.06852549f, 0.12677407f, 0.10259114f, 0.32394683f, 
    -0.16354643f, -0.04204587f, -0.04873960f, 0.03405798f, -0.01304429f, -0.08222137f, -0.12081707f, 0.03896553f, 
    -0.02647368f, 0.46544281f, -0.03502972f, -0.26842573f, -0.01520677f, 0.00081529f, 0.07680241f, -0.01879041f, 
    -0.05558872f, 0.02656964f, -0.05990475f, 0.07967293f, -0.10239030f, -0.10962749f, -0.03624878f, -0.13516811f, 
    -0.02250735f, 0.03674738f, -0.16238266f, -0.09000052f, 0.02072744f, -0.02989814f, -0.10463097f, -0.11293110f, 
    0.00685143f, -0.03768380f, 0.11489815f, -0.03916435f, 0.04026209f, -0.01138857f, 0.04792026f, 0.07899287f, 
    0.02620935f, -0.00946250f, -0.04320012f, -0.07667281f, -0.18216081f, 0.06584165f, -0.09037099f, -0.03440863f, 
    0.06025855f, -0.12723359f, -0.13929974f, -0.17920391f, 0.01418745f, 0.17025205f, 0.09923515f, 0.16461326f, 
    0.23438221f, 0.19748478f, 0.02883071f, -0.05177138f, 0.03263001f, 0.03804879f, 0.07835329f, -0.07054274f, 
    0.10570452f, 0.14421335f, 0.02371675f, 0.00158731f, -0.23756404f, 0.03978262f, -0.09598807f, -0.08837061f, 
    -0.02235357f, -0.08344471f, -0.09064563f, 0.02177637f, 0.00240864f, 0.01071592f, 0.17511654f, 0.13970709f, 
    0.07356806f, 0.03327685f, 0.14412379f, -0.07157769f, 0.04204964f, 0.02580183f, 0.06653272f, 0.06753477f, 
    0.02982580f, 0.01336773f, 0.02958006f, 0.04303297f, -0.21432273f, -0.01312187f, 0.05346830f, 0.12604436f, 
    0.07772707f, 0.03473352f, -0.00522168f, 0.08607294f, -0.06051776f, -0.07821744f, -0.00717630f, -0.10868678f, 
    0.48539934f, 0.07121149f, 0.16328400f, 0.30361637f, 0.08830569f, 0.03767366f, -0.00443717f, 0.20371835f, 
    -0.04951974f, 0.03575277f, 0.12852059f, -0.04222612f, 0.25753972f, -0.05066048f, 0.02933250f, -0.06353123f, 
    -0.02160505f, 0.01233382f, 0.11912754f, 0.16085123f, 0.03021683f, -0.01044298f, 0.06378825f, 0.06472263f, 
    -0.30673844f, 0.17185251f, 0.13289687f, 0.14421751f, 0.07356987f, 0.01736478f, 0.07620463f, -0.09509246f, 
    -0.08662632f, -0.00599407f, 0.01306055f, 0.01466586f, 0.07593004f, 0.29962009f, -0.17308274f, -0.20376746f, 
    -0.04473247f, 0.04518620f, 0.04840528f, 0.05281839f, -0.03430156f, -0.07132158f, -0.00555901f, 0.07404040f, 
    -0.07739429f, 0.11121386f, -0.11221947f, 0.26924232f, 0.01248316f, 0.06916296f, -0.08090298f, 0.07670399f, 
    0.13926131f, 0.07548524f, 0.16553751f, -0.03297340f, 0.19431777f, 0.08560600f, 0.13433558f, -0.20763360f, 
    0.04779089f, 0.05988682f, 0.13136210f, 0.05630921f, 0.02780504f, -0.02719728f, 0.20886430f, 0.05439658f, 
    -0.17025103f, -0.02004310f, -0.07993932f, 0.07931509f, 0.03130917f, 0.10594685f, 0.03661564f, 0.04874068f, 
    0.09657159f, 0.09454165f, -0.01216019f, -0.06390057f, -0.21276210f, 0.04357613f, 0.00120738f, 0.32218146f, 
    0.14720941f, 0.00372885f, 0.00789726f, 0.11303509f, 0.00378119f, -0.01991116f, -0.09326272f, -0.03770549f, 
    0.10297671f, 0.08426184f, 0.05432989f, -0.11239172f, 0.10363509f, 0.03869062f, 0.06972960f, 0.02878877f, 
    0.01534282f, 0.00661723f, 0.00011456f, 0.02368871f, 0.21083695f, -0.12476692f, 0.11386488f, -0.25914729f, 
    -0.14841965f, 0.04307615f, -0.06889283f, -0.12615271f, -0.07733772f, -0.12967822f, 0.02694250f, -0.03362932f, 
    -0.08370504f, 0.01218871f, -0.02286030f, 0.03561380f, -0.04463709f, -0.11948558f, 0.01829824f, 0.03050492f, 
    0.01413560f, -0.07887809f, -0.03027379f, 0.10112444f, 0.21756232f, -0.06155016f, 0.10887174f, -0.35386616f, 
    0.08267436f, 0.02173442f, 0.00766023f, -0.14130980f, 0.07826441f, -0.00524333f, -0.04281688f, -0.11285031f, 
    -0.10819035f, 0.00712225f, 0.03432893f, 0.02154365f, 0.01031479f, -0.00196752f, 0.00919884f, -0.16824533f, 
    0.10694490f, -0.08962145f, 0.03774829f, -0.01854437f, 0.01293330f, -0.03976065f, -0.17213595f, -0.01693148f, 
    0.08035568f, -0.04891246f, -0.12942947f, -0.04869438f, 0.06989042f, 0.12288533f, 0.09356015f, -0.09486358f, 
    -0.02661361f, -0.19058917f, 0.08391622f, 0.01112362f, 0.00549477f, -0.03450098f, 0.01116589f, 0.20813091f, 
    0.02322414f, 0.03904829f, 0.16120560f, -0.05356012f, 0.06304361f, -0.00239985f, -0.09287020f, 0.04686389f, 
    -0.02509141f, -0.01217566f, -0.00791199f, -0.05516599f, 0.09258613f, 0.03964137f, 0.05350018f, -0.01630720f, 
    -0.04497019f, 0.00286384f, -0.04215956f, 0.27103350f, 0.01125035f, 0.08945013f, 0.03475375f, 0.05569281f, 
    0.00281886f, -0.00253096f, 0.07736361f, -0.01670028f, -0.17472087f, -0.06048599f, -0.03681626f, -0.10971497f, 
    -0.04257882f, -0.01330477f, 0.01533322f, -0.02819670f, -0.16121006f, -0.03418014f, -0.02622410f, 0.00861533f, 
    0.25835845f, 0.30184603f, 0.14351130f, -0.21952921f, 0.27196580f, 0.01822463f, -0.04588888f, 0.11800303f, 
    0.08553451f, 0.06419411f, 0.04237051f, 0.00564807f, 0.26154456f, -0.12347677f, -0.09210690f, -0.00607857f, 
    -0.07124233f, -0.02181332f, -0.08455808f, 0.03767314f, -0.05589413f, -0.01951027f, -0.01680462f, 0.01700545f, 
    -0.28183436f, -0.04436907f, -0.14771384f, 0.27103761f, -0.00182461f, 0.04033827f, -0.00807336f, 0.02725648f, 
    -0.01715556f, 0.00606949f, -0.11862274f, 0.07224691f, 0.04962032f, 0.24220791f, -0.06781448f, -0.07697725f, 
    -0.08752000f, 0.13128512f, 0.04210258f, 0.13827984f, 0.01735713f, -0.02885591f, 0.02315349f, -0.07401164f, 
    0.09831664f, 0.16280653f, 0.12152267f, 0.11904877f, 0.14203078f, 0.00264977f, -0.11215838f, -0.01331337f, 
    -0.01076568f, 0.00526923f, -0.02402957f, 0.05897182f, -0.02763148f, 0.02228737f, -0.04185420f, -0.11279462f, 
    -0.01444059f, -0.05025914f, -0.00678381f, -0.02630351f, -0.08489799f, 0.03782051f, 0.06451724f, 0.06557761f, 
    0.10616193f, -0.24464273f, 0.27098766f, -0.32692486f, -0.15116844f, -0.07691771f, -0.04758364f, -0.02306269f, 
    0.07197960f, 0.03925376f, -0.02474906f, -0.01473966f, 0.15096854f, -0.06469323f, 0.12787850f, -0.10671125f, 
    0.06017162f, 0.05966687f, -0.07403272f, -0.07170974f, -0.08833797f, -0.05859456f, -0.06176846f, 0.01258660f, 
    -0.18977027f, -0.05414022f, 0.04167731f, 0.12261895f, -0.00014176f, 0.01670928f, -0.09766183f, 0.07633515f, 
    -0.06053771f, -0.07545540f, 0.01680536f, 0.03802747f, 0.12102681f, 0.14592680f, -0.20755190f, -0.04006294f, 
    0.11906660f, -0.01339078f, 0.04172874f, 0.00833684f, 0.08643166f, 0.05948211f, -0.05031569f, -0.06958868f, 
    0.11985578f, -0.01241033f, -0.07692023f, -0.04937869f, -0.05075757f, 0.00221276f, 0.06177213f, -0.01930744f, 
    0.00191220f, 0.03219090f, -0.00195643f, 0.06911617f, -0.39576223f, -0.30522299f, -0.19786370f, -0.02997612f, 
    0.04090222f, 0.05801871f, -0.00377382f, 0.17180605f, -0.01896203f, 0.05100674f, -0.01738354f, -0.01620341f, 
    0.21298271f, 0.12094818f, 0.04665371f, -0.14641604f, 0.02584253f, 0.01558585f, -0.04372618f, -0.02582535f, 
    -0.05861460f, -0.07057307f, -0.04182564f, -0.07083868f, 0.16131222f, -0.00283189f, -0.08364164f, -0.01237458f, 
    0.13112731f, 0.02605572f, -0.01157628f, 0.05515676f, 0.01555852f, 0.13959756f, 0.08014322f, 0.06631416f, 
    0.10791942f, -0.24532337f, -0.17874187f, -0.19191171f, 0.15850598f, 0.03994547f, 0.07801298f, -0.01591252f, 
    -0.04907379f, -0.01233127f, 0.09087336f, 0.00191211f, 0.31966707f, -0.18307491f, 0.13497415f, 0.06710991f, 
    0.20436038f, -0.03959716f, -0.09928080f, -0.03129417f, -0.00704044f, -0.00017233f, 0.02360544f, 0.02350399f, 
    -0.20257922f, -0.10592659f, -0.18288030f, 0.03294320f, -0.02467965f, -0.01114499f, -0.14536375f, 0.03514393f, 
    0.08040438f, -0.02820777f, 0.01244977f, 0.01090484f, -0.23886774f, -0.18776621f, 0.07278880f, 0.22180720f, 
    0.04774582f, -0.05705025f, 0.03088457f, 0.10880882f, -0.00362218f, -0.00405171f, 0.08183032f, -0.07368073f, 
    -0.24895728f, -0.04506698f, -0.05221522f, 0.19388083f, 0.04412629f, -0.14888921f, -0.12710451f, -0.03566310f, 
    0.05561688f, -0.04128274f, 0.18043822f, 0.00483217f, 0.40195376f, -0.06532624f, 0.21689793f, -0.13968210f, 
    0.00992466f, 0.03168124f, 0.02034871f, -0.12175789f, 0.09602116f, 0.11537182f, 0.13899992f, 0.07651903f, 
    -0.10498196f, 0.01918530f, 0.04482310f, -0.05649475f, -0.01761035f, -0.00640091f, -0.01508641f, -0.17992909f, 
    -0.07034147f, 0.01661607f, 0.09128325f, 0.07173876f, 0.03988400f, -0.06510425f, -0.09313871f, 0.27057421f, 
    0.17503093f, 0.01588024f, -0.07132315f, 0.01070727f, 0.02832839f, 0.04664723f, 0.17153481f, 0.10340451f, 
    0.01729332f, -0.16012500f, 0.02272575f, -0.06002312f, 0.06611306f, -0.04652459f, -0.02285718f, -0.06161233f, 
    0.07697126f, 0.04600241f, 0.07769138f, 0.11845651f, -0.07515883f, 0.02477168f, -0.03924511f, -0.15368651f, 
    0.02354357f, 0.14896439f, 0.07373183f, 0.14434293f, 0.01018749f, -0.00267265f, 0.03438790f, 0.08982906f, 
    -0.12044507f, 0.01102501f, -0.07475055f, -0.13803406f, -0.02803516f, -0.05058821f, -0.12140241f, 0.12174650f, 
    -0.05377387f, -0.04045330f, 0.08709984f, -0.12813115f, 0.18799020f, 0.08543874f, -0.09109279f, -0.17160876f, 
    0.07432149f, 0.11674101f, 0.11082630f, 0.07983231f, 0.00960801f, -0.03165824f, -0.02855863f, -0.01570657f, 
    -0.33522591f, 0.13846923f, 0.00453995f, 0.08470612f, 0.03520962f, -0.08210409f, 0.05561487f, -0.01690550f, 
    0.00990234f, -0.00357818f, 0.01779631f, 0.06062073f, 0.35615945f, 0.22946949f, -0.06177775f, -0.07151815f, 
    0.27942124f, 0.06270618f, 0.13983454f, 0.11602467f, 0.03669964f, -0.04094209f, -0.00820116f, -0.00851303f, 
    -0.35520276f, -0.07314619f, -0.09721626f, 0.22723606f, -0.05292091f, 0.00528412f, 0.00180329f, 0.08440547f, 
    -0.16341735f, 0.02156814f, 0.07903373f, 0.00589010f, -0.25449488f, 0.00188396f, -0.04868079f, -0.13992509f, 
    -0.05728764f, -0.04546294f, -0.09408946f, -0.05820003f, 0.04057371f, -0.02725845f, 0.04196738f, 0.11124049f, 
    0.31157380f, 0.05352839f, 0.19245742f, 0.04640797f, 0.05735827f, 0.05609542f, -0.18584879f, 0.07859159f, 
    0.12060223f, -0.02816957f, -0.01266175f, -0.10268652f, 0.01183881f, 0.37734044f, -0.04923258f, 0.16337520f, 
    -0.11043292f, 0.29554969f, 0.04356683f, 0.04695465f, -0.02180616f, 0.00223188f, 0.02725739f, -0.02102813f, 
    0.00043610f, -0.10265440f, -0.20557940f, 0.02180756f, 0.12478925f, 0.02429111f, -0.04023021f, 0.16929537f, 
    -0.02866589f, 0.08518027f, 0.24007629f, -0.00920948f, -0.03628540f, -0.07401182f, -0.12899463f, -0.20301948f, 
    0.05089942f, 0.05433685f, -0.04356244f, -0.15350963f, -0.04407905f, 0.01494362f, -0.00428623f, 0.01599739f, 
    -0.04279971f, -0.19771782f, -0.17097962f, -0.08111813f, 0.08081510f, 0.04091461f, 0.01292852f, -0.00171616f, 
    0.07363284f, 0.00526226f, -0.03137547f, -0.05835474f, 0.27081782f, -0.03101995f, -0.01185234f, -0.08188409f, 
    0.05880751f, 0.08581354f, 0.03561854f, -0.13155583f, 0.12681836f, -0.03852556f, 0.05258491f, 0.04808394f, 
    0.49520093f, -0.03613057f, 0.27213058f, 0.05113110f, 0.02942103f, 0.10963897f, -0.11973623f, -0.12071956f, 
    -0.06003176f, 0.01485399f, -0.01253221f, -0.08442520f, 0.01951255f, -0.17520276f, -0.12132371f, 0.02015094f, 
    -0.03400616f, 0.08559119f, -0.12791184f, 0.00429010f, 0.04221366f, 0.00930905f, -0.14642686f, 0.09557669f, 
    0.00415081f, 0.01482744f, -0.01806707f, -0.03228045f, -0.00207501f, -0.03237518f, -0.03092770f, -0.02399453f, 
    -0.01872198f, 0.00317668f, 0.02054181f, -0.00759810f, -0.03251443f, -0.00491075f, 0.01380967f, 0.02496728f, 
    0.01664766f, -0.03117704f, 0.01743123f, -0.02389939f, 0.00191359f, 0.02591995f, -0.03895579f, -0.00866607f, 
    -0.00272297f, 0.02835704f, -0.01365691f, -0.02215205f, 0.02645911f, -0.01525178f, 0.01939106f, 0.02845665f, 
    0.02820333f, -0.02069271f, 0.01294689f, 0.01959539f, -0.00308329f, -0.02688554f, 0.00889216f, -0.04415694f, 
    -0.00003131f, -0.02871515f, -0.01567515f, 0.02338865f, -0.03118159f, -0.03169707f, 0.01849195f, 0.00828695f, 
    -0.01288707f, 0.02080942f, -0.04019615f, 0.01582568f, -0.00769271f, -0.00129017f, 0.02003887f, 0.04165751f, 
    0.03346497f, -0.01801808f, -0.01995052f, -0.01535415f, -0.02535606f, -0.01819052f, -0.02355041f, -0.02699644f, 
    0.00643111f, -0.02551418f, -0.00875363f, -0.03212536f, 0.01485858f, -0.01978941f, -0.02259270f, -0.01079066f, 
    0.01254734f, -0.01667932f, -0.02472107f, -0.02569047f, -0.02667984f, -0.02632692f, 0.01561052f, -0.00935583f, 
    0.02267365f, -0.02491636f, -0.02080714f, 0.00257152f, -0.03617787f, -0.03108805f, 0.00657511f, -0.00018285f, 
    0.00284690f, 0.00627998f, 0.01667305f, 0.02399423f, -0.03169416f, -0.03577448f, 0.00011832f, 0.02741813f, 
    0.00466887f, 0.00395883f, -0.00641073f, -0.02700963f, -0.00240278f, -0.00503927f, -0.00590387f, 0.03705059f, 
    -0.02163148f, -0.02898624f, 0.02512781f, 0.00423918f, 0.01189400f, -0.02238191f, -0.02405841f, 0.01559220f, 
    0.01990834f, -0.01352010f, -0.00435412f, 0.00726634f, -0.00049420f, -0.04307250f, -0.01459282f, 0.01902389f, 
    -0.01064282f, 0.02848913f, -0.00804126f, -0.02095931f, -0.01460152f, 0.02210617f, -0.02654167f, -0.02640777f, 
    -0.00430474f, -0.01258426f, 0.00605193f, -0.02489848f, -0.04078165f, -0.02082442f, -0.02583632f, 0.02661051f, 
    0.01386065f, -0.01870998f, 0.00171489f, -0.01052085f, 0.01718697f, 0.01389241f, -0.04256639f, 0.00307024f, 
    -0.02269346f, 0.03650440f, 0.00112977f, -0.03125187f, -0.02891197f, -0.01439840f, -0.02843960f, 0.01199433f, 
    -0.02382520f, -0.00343572f, 0.00471964f, -0.02206611f, -0.02972309f, -0.02653050f, -0.03282147f, 0.00061761f, 
    -0.01235161f, -0.02339534f, 0.01120182f, 0.01178494f, -0.00589376f, 0.00245719f, 0.00370985f, 0.01684392f, 
    -0.01514176f, 0.00053713f, -0.02454392f, -0.02894798f, -0.01764717f, -0.00710905f, 0.00936781f, -0.01856703f, 
    -0.02061714f, 0.01133466f, 0.02662825f, -0.00587222f, -0.04360314f, -0.01096089f, 0.01790636f, -0.03346212f, 
    0.02428845f, -0.02044603f, 0.02219855f, -0.00181518f, -0.01948071f, 0.00971123f, -0.03189660f, -0.03351799f, 
    0.02592967f, 0.03211595f, 0.00407458f, 0.01610390f, -0.01988681f, -0.00919832f, 0.00845057f, -0.03061525f, 
    -0.03003812f, -0.00318252f, 0.02569120f, 0.02372487f, 0.02731849f, -0.04371497f, 0.00364669f, 0.02284154f, 
    -0.02964589f, 0.00035822f, -0.00880901f, -0.02839889f, 0.00706630f, -0.02599622f, 0.01676315f, -0.02163324f, 
    -0.03356572f, -0.04038843f, 0.02239116f, 0.00371204f, 0.00575513f, -0.01718787f, 0.02353879f, -0.03087046f, 
    -0.00869925f, -0.01638808f, -0.00421826f, -0.03729448f, -0.00668328f, 0.00287386f, -0.01345132f, -0.03586423f, 
    0.02874680f, -0.00022966f, 0.00469403f, 0.01976993f, -0.02469561f, 0.01134985f, 0.01125508f, -0.03301425f, 
    0.03566108f, 0.02396953f, 0.02879291f, -0.00709649f, 0.00851026f, -0.02826060f, -0.03349601f, -0.00012191f, 
    -0.00439746f, 0.00649855f, 0.01434714f, -0.01514738f, 0.01909678f, -0.00385463f, 0.00281824f, 0.02597822f, 
    -0.00960528f, -0.03361249f, -0.03743777f, -0.01558660f, -0.03313160f, 0.01332135f, -0.01959494f, -0.00962181f, 
    -0.00821766f, -0.02644221f, -0.00750960f, -0.04158407f, 0.01171930f, 0.02193235f, 0.02284711f, 0.02252698f, 
    0.03231699f, -0.02095912f, 0.02747602f, -0.02091598f, 0.02594035f, 0.00811495f, 0.01050713f, -0.03055279f, 
    -0.01154201f, 0.01344159f, 0.00205655f, 0.01652201f, -0.01893665f, -0.03154701f, 0.02310139f, 0.01985088f, 
    -0.00208467f, 0.01402804f, -0.03027344f, -0.03259121f, -0.00430954f, 0.00473608f, -0.01844549f, -0.00153484f, 
    -0.03067609f, -0.03166972f, -0.03395764f, 0.02710044f, -0.02483068f, -0.02017085f, 0.00249040f, -0.00111183f, 
    -0.02146886f, -0.02587896f, 0.01935608f, -0.03730412f, -0.01908712f, 0.02111739f, -0.02468180f, 0.02745531f, 
    -0.00446438f, -0.02011282f, -0.02610845f, 0.02179853f, 0.00420514f, -0.03221180f, -0.02329453f, -0.01118153f, 
    0.01459041f, -0.03261480f, -0.02184114f, -0.02364542f, -0.01011237f, -0.03043008f, 0.01456942f, -0.03249356f, 
    0.00759314f, -0.03479834f, -0.00493050f, -0.03208934f, -0.03695221f, -0.02107469f, -0.01544290f, -0.03145588f, 
    -0.03825678f, -0.04387377f, -0.01005299f, 0.01119320f, 0.01251961f, -0.02246933f, 0.01497238f, -0.01033111f, 
    -0.01020830f, 0.00894073f, 0.00226554f, -0.03212955f, -0.01477502f, -0.02146118f, -0.00906772f, 0.00329465f, 
    -0.00516434f, -0.01056424f, -0.01535624f, -0.02525636f, -0.03969656f, 0.02584272f, 0.00756581f, -0.02357502f, 
    -0.02999633f, -0.00163681f, -0.02209764f, -0.03039198f, 0.02126545f, 0.02040639f, -0.02146301f, -0.01188806f, 
    0.00938172f, -0.03929902f, -0.02861105f, -0.00846477f, -0.02357320f, 0.01764363f, -0.00477405f, -0.04390086f, 
    -0.03200202f, 0.00607788f, -0.01345895f, -0.03388323f, -0.03012278f, -0.02125619f, 0.02278092f, 0.00809508f, 
    -0.00666660f, -0.02064239f, -0.02560751f, 0.02136445f, -0.00297188f, -0.03734739f, -0.01966316f, -0.03613629f, 
    0.00144188f, -0.02100153f, -0.00060087f, -0.00401177f, -0.00598661f, -0.02724351f, 0.00673923f, 0.02753086f, 
    -0.02178211f, -0.02592003f, -0.03220445f, -0.03343694f, 0.01709320f, -0.02238927f, 0.00622977f, 0.02367031f, 
    -0.03152229f, -0.03263276f, 0.01997495f, 0.01348746f, 0.02639730f, 0.02039784f, -0.01549540f, -0.02155277f, 
    0.00214469f, 0.02529898f, -0.02464448f, 0.02576831f, -0.01773528f, -0.01900481f, -0.00805207f, -0.01770046f, 
    -0.01975488f, 0.03587448f, -0.02044145f, -0.01132395f, -0.02531970f, 0.02958102f, 0.02747037f, -0.00826053f, 
    -0.02287473f, 0.03514145f, 0.00398689f, 0.03432170f, 0.04165041f, 0.02917813f, -0.01375497f, 0.04017864f, 
    0.00812427f, 0.02282876f, -0.02541027f, 0.00835891f, 0.01338728f, -0.01914693f, -0.03274144f, -0.03520325f, 
    -0.03047698f, -0.00813268f, -0.02272156f, -0.03331121f, -0.04264277f, 0.02456745f, 0.02688803f, -0.00257185f, 
    -0.00401691f, 0.00315028f, -0.00408072f, -0.04427382f, 0.00848491f, 0.01415938f, -0.00310500f, 0.02181292f, 
    -0.03465631f, 0.02128995f, 0.01990057f, -0.03549949f, 0.04065644f, -0.01736454f, 0.00372088f, 0.00168582f, 
    -0.01619124f, -0.01366932f, 0.00631350f, -0.03332455f, -0.01227174f, 0.00835411f, 0.01937573f, 0.02554359f, 
    -0.01900004f, -0.02201881f, 0.01512676f, 0.02319092f, -0.03497441f, 0.00868353f, -0.00015720f, -0.03482147f, 
    0.01767340f, 0.00420518f, -0.03337595f, -0.01851394f, 0.01188873f, 0.01804488f, 0.00264017f, -0.01390218f, 
    -0.03828514f, -0.03532000f, -0.03788519f, -0.01341189f, -0.02813550f, -0.03705222f, 0.02031663f, -0.01526343f, 
    0.00873797f, 0.02489118f, -0.01552871f, -0.01178963f, -0.00142942f, -0.00698737f, -0.00892344f, -0.04178515f, 
    -0.04400255f, 0.00256905f, 0.01697930f, -0.03195607f, 0.00328774f, 0.02143023f, 0.00972443f, -0.00597423f, 
    -0.00881122f, -0.04253433f, -0.01958903f, -0.00856805f, -0.00524003f, -0.02597493f, 0.01758141f, 0.01473662f, 
    -0.00330565f, 0.00124606f, 0.01297386f, 0.02294040f, -0.03621627f, 0.00207342f, -0.00179574f, -0.00272829f, 
    0.00397136f, -0.02636059f, -0.02494218f, -0.03812059f, -0.01662402f, 0.01747204f, 0.00428044f, 0.02700249f, 
    0.00198543f, 0.02719381f, -0.01156482f, -0.03075725f, -0.02490322f, 0.00193313f, -0.02793832f, 0.01662887f, 
    -0.01989986f, -0.01770103f, -0.02092050f, 0.01814315f, -0.01224515f, 0.00710736f, -0.00323959f, -0.00154561f, 
    -0.01242674f, 0.02176814f, -0.02048013f, -0.02621399f, 0.02016726f, -0.00795417f, 0.00973113f, -0.03209304f, 
    -0.00863856f, 0.01240559f, 0.01936714f, -0.03503877f, -0.01571313f, -0.03745214f, -0.00727933f, -0.03186244f, 
    0.00952366f, 0.00341697f, 0.01100788f, 0.00552350f, 0.01817307f, 0.01824893f, -0.03063603f, 0.02410933f, 
    0.02691166f, -0.02625317f, -0.03909323f, -0.02463790f, -0.01326006f, -0.01910271f, 0.01888193f, -0.00961261f, 
    -0.01527886f, 0.00603236f, 0.00890653f, 0.01157435f, -0.01168484f, 0.03404989f, 0.00781975f, -0.00788387f, 
    -0.01159830f, 0.01148856f, 0.00554518f, 0.02138786f, -0.03841317f, -0.03022316f, -0.03311964f, 0.00953501f, 
    -0.00907451f, -0.03318904f, -0.01254534f, -0.01051674f, -0.01942473f, -0.01498509f, -0.01456844f, -0.00734770f, 
    -0.01005436f, 0.01113294f, 0.01558162f, -0.03405786f, -0.01460070f, -0.01275547f, -0.00697033f, 0.00804157f, 
    0.02708547f, -0.02366367f, -0.02503975f, -0.02651513f, -0.01764550f, -0.02108639f, 0.02371134f, -0.02256393f, 
    0.00090804f, -0.03089589f, -0.00821695f, -0.00710873f, -0.04201932f, 0.00974961f, 0.02844377f, 0.02374940f, 
    0.01877107f, -0.02019674f, -0.01772800f, -0.00446945f, -0.02854945f, 0.01860203f, 0.02243488f, -0.01706655f, 
    0.02625990f, 0.01180614f, 0.02126119f, -0.03104229f, -0.04031213f, -0.02613204f, -0.00106252f, -0.02037118f, 
    -0.02424429f, -0.03762115f, -0.03180152f, -0.02963799f, 0.01708462f, 0.00455870f, -0.03442623f, 0.00344412f, 
    0.02468747f, -0.00302784f, -0.02158429f, 0.02661361f, 0.01726832f, 0.01858688f, -0.01480227f, -0.03504416f, 
    -0.01753994f, -0.03141321f, -0.01392133f, 0.02949381f, -0.00830891f, -0.03448215f, -0.00186662f, 0.00019472f, 
    -0.00335217f, 0.02596672f, 0.02954346f, 0.00531723f, 0.00777481f, 0.00671161f, -0.01878651f, -0.03583506f, 
    0.02220402f, 0.02212465f, -0.03423074f, -0.03553120f, -0.01224787f, -0.01171410f, -0.01264194f, 0.00330363f, 
    -0.00125861f, -0.03454771f, 0.01288116f, -0.02717233f, 0.00368671f, -0.03755517f, 0.01244784f, 0.01578412f, 
    0.00988961f, 0.02221772f, 0.02612968f, 0.01007450f, -0.04154813f, -0.02076352f, 0.02559199f, 0.01063818f, 
    -0.03719961f, -0.03378010f, 0.02615413f, -0.03227210f, -0.01490520f, -0.03539323f, -0.03080750f, -0.00373671f, 
    -0.00949331f, -0.03027177f, -0.02458505f, 0.00950737f, 0.01962269f, 0.01583469f, -0.00565023f, -0.03491539f, 
    -0.00770565f, -0.01535059f, 0.01282039f, -0.00783603f, -0.00367492f, 0.02016901f, -0.02011745f, 0.01918739f, 
    0.01299578f, -0.04125229f, 0.00649716f, -0.01458690f, 0.00198211f, 0.00553812f, -0.02730167f, 0.00442386f, 
    0.01235562f, -0.01915560f, -0.01198220f, -0.02714734f, 0.02773190f, 0.00618218f, -0.01263856f, -0.00677768f, 
    -0.03655365f, 0.02485875f, -0.00668466f, 0.00381826f, -0.00582792f, -0.00346189f, -0.03161071f, -0.02593151f, 
    0.00504410f, -0.00243861f, -0.00610494f, -0.04182459f, 0.02221107f, -0.01707952f, -0.02815898f, -0.01902130f, 
    0.19261421f, 0.34715310f, 0.20947313f, -0.07702970f, 0.18007949f, 0.13294373f, 0.10002743f, 0.08683798f, 
    0.08530654f, -0.00653397f, -0.05918277f, 0.17880850f, -0.01774382f, -0.03828447f, -0.07950382f, -0.03765547f, 
    0.07552082f, 0.10706365f, -0.04105052f, -0.01402040f, -0.01983597f, 0.20320313f, 0.04967713f, 0.13018265f, 
    -0.10417230f, 0.24142504f, 0.03784725f, -0.05831065f, 0.06313726f, -0.01367465f, -0.07244782f, 0.05663009f, 
    -0.01957269f, -0.03762098f, -0.18216497f, -0.32443643f, -0.01353812f, 0.07193265f, 0.11276690f, 0.09879087f, 
    -0.14442849f, -0.12126932f, -0.04726513f, -0.14046329f, 0.03880051f, 0.09868915f, 0.16366842f, 0.04632405f, 
    -0.08558190f, -0.33607244f, -0.20534641f, -0.12586382f, 0.18008666f, 0.14064544f, 0.17992646f, 0.31318974f, 
    0.08867317f, 0.15578350f, 0.09967729f, 0.12120180f, 0.02976537f, 0.08368606f, 0.17397325f, 0.04016553f, 
    0.02766939f, 0.08922356f, -0.01720962f, -0.04189223f, 0.11244917f, 0.07168364f, 0.16800435f, 0.18300295f, 
    0.36599371f, 0.10284530f, -0.02611913f, 0.01042166f, 0.14272918f, 0.03467856f, -0.01808009f, -0.13689639f, 
    -0.03044010f, -0.04804496f, -0.08147399f, -0.01371069f, -0.17519151f, -0.32383168f, 0.09221216f, -0.01385897f, 
    0.01129662f, 0.05816836f, -0.09231564f, 0.06377819f, 0.07450536f, -0.02285294f, -0.03518739f, 0.04253052f, 
    -0.22162139f, -0.09561741f, -0.12902783f, -0.14087485f, 0.13066640f, 0.05063345f, 0.02392397f, -0.07049917f, 
    0.04377966f, -0.07087150f, 0.23547652f, 0.13774118f, 0.34508690f, 0.03506911f, 0.14490496f, 0.07619941f, 
    0.09357713f, 0.09683101f, -0.05039833f, -0.03997763f, -0.12427229f, -0.03840942f, -0.08637334f, -0.11611681f, 
    0.32857510f, -0.22676700f, 0.66239309f, -0.25245327f, 0.09115421f, -0.01128251f, 0.09661067f, 0.10745484f, 
    -0.13005714f, -0.05809745f, 0.35998985f, 0.14344181f, 0.21450342f, 0.05876571f, 0.01429372f, -0.17833051f, 
    -0.05680613f, -0.01499992f, 0.06697223f, -0.01339833f, 0.09104419f, 0.16290201f, 0.05528222f, 0.15265262f, 
    0.25882295f, -0.21006045f, 0.25265667f, -0.05841248f, -0.06547041f, 0.04950528f, -0.02905323f, 0.03248911f, 
    0.02352533f, -0.14124000f, -0.16343552f, -0.04023707f, 0.25513449f, -0.09381497f, 0.24362452f, -0.28357235f, 
    0.13972326f, 0.15677284f, -0.06982601f, 0.27611238f, -0.04876933f, 0.18195236f, -0.08502002f, -0.00170336f, 
    -0.12640360f, -0.07906482f, 0.06204494f, 0.08326641f, 0.00298169f, 0.08189709f, -0.05767816f, 0.07693059f, 
    -0.06359114f, -0.01829416f, -0.10100798f, -0.29086071f, -0.26003763f, 0.26293823f, 0.26802441f, -0.11495669f, 
    -0.17911428f, -0.19702470f, -0.14577323f, -0.05182796f, -0.16295753f, -0.01926808f, 0.00646480f, 0.06037583f, 
    0.08280305f, 0.00119861f, -0.06235677f, -0.02223690f, 0.10824961f, -0.06613681f, -0.02337014f, 0.00854148f, 
    -0.02515664f, -0.00550261f, -0.00488239f, -0.15192541f, -0.12554693f, 0.15964983f, -0.11837352f, 0.02634075f, 
    -0.12405036f, -0.12423962f, -0.01743879f, -0.07119422f, -0.02992252f, 0.16427697f, 0.11018265f, 0.01362173f, 
    0.14929995f, 0.23345371f, 0.22144859f, 0.15874591f, -0.08729058f, 0.01076989f, -0.07908984f, -0.00696531f, 
    -0.02060092f, 0.02339236f, 0.11311486f, -0.16805033f, -0.13565679f, 0.11519179f, -0.14769259f, -0.07366271f, 
    0.17343131f, 0.01769247f, 0.07638723f, 0.24507433f, -0.03678643f, 0.12288941f, 0.08864748f, 0.15048771f, 
    0.03712679f, 0.31856072f, -0.40850356f, 0.29569146f, -0.15221541f, 0.02429308f, -0.03379781f, -0.00926558f, 
    0.03296978f, 0.05088715f, -0.14571048f, 0.01253334f, -0.22966197f, -0.10326187f, -0.13730279f, -0.08108795f, 
    0.00080662f, 0.04254217f, 0.12271191f, 0.04358555f, 0.14933515f, 0.18051960f, 0.19856963f, 0.15882123f, 
    -0.04059524f, -0.15903743f, 0.37105423f, 0.08427548f, 0.05501990f, 0.02101544f, 0.10144731f, -0.02167428f, 
    0.11686417f, 0.04659531f, 0.01874511f, -0.24733324f, 0.20157751f, 0.21898082f, 0.03283463f, 0.08857012f, 
    -0.15995771f, -0.09552309f, -0.01893630f, -0.01144935f, -0.06240449f, 0.10783502f, 0.00744624f, 0.12138492f, 
    -0.00701250f, 0.18366094f, 0.43885148f, 0.23383294f, -0.06770636f, -0.05858403f, -0.13055930f, -0.02542992f, 
    -0.13952547f, 0.02570488f, -0.21799213f, 0.08160798f, -0.00483905f, 0.03908107f, -0.02120898f, -0.01184222f, 
    -0.12856159f, -0.14507318f, -0.10809440f, -0.10693254f, -0.10775272f, 0.06962057f, 0.06650472f, 0.06376972f, 
    0.08990906f, 0.16339710f, -0.35964438f, 0.08557528f, 0.20331641f, 0.03034577f, 0.13347626f, 0.08328159f, 
    0.07507960f, -0.03360844f, -0.06306566f, 0.04373581f, 0.00342817f, 0.03100218f, 0.12308465f, 0.07245246f, 
    0.10351608f, 0.01866801f, 0.02476149f, 0.06024979f, -0.01853835f, 0.03358947f, 0.05000484f, 0.15887275f, 
    -0.15902583f, -0.11984931f, 0.09110011f, 0.10151378f, -0.05662001f, 0.15958378f, 0.03591523f, 0.13643669f, 
    0.02789282f, -0.11779131f, 0.02679341f, 0.11322494f, 0.24440223f, 0.37874532f, -0.17262985f, -0.08085918f, 
    -0.22350255f, -0.00977915f, -0.03534172f, 0.04819404f, -0.08297871f, -0.04956483f, -0.09479520f, -0.00308099f, 
    0.31872633f, 0.07883190f, 0.19955574f, -0.00676433f, -0.01468690f, -0.08789387f, 0.07633801f, -0.10502576f, 
    0.10571069f, 0.03961619f, 0.08224475f, 0.06218397f, 0.14766350f, 0.13104078f, 0.01589008f, -0.04277581f, 
    -0.12394230f, -0.04626014f, -0.03369854f, -0.09571908f, 0.14756115f, 0.14218710f, 0.04651281f, 0.16857690f, 
    -0.32711196f, 0.30458772f, -0.14323911f, 0.07449482f, 0.13916160f, -0.09870824f, -0.02641162f, 0.05419075f, 
    -0.13790198f, 0.14963263f, 0.27926615f, 0.08040019f, 0.02978492f, 0.35237980f, -0.10807467f, 0.08111598f, 
    -0.06241165f, -0.07164110f, 0.01172908f, -0.06045437f, -0.03747280f, 0.13382488f, 0.04953945f, 0.09840526f, 
    -0.08343405f, -0.07805441f, 0.19288489f, -0.03608117f, 0.13941313f, 0.12372935f, 0.00978839f, 0.09133357f, 
    0.08209313f, 0.10034565f, -0.04286474f, 0.23997058f, -0.04016396f, -0.17464437f, -0.15576498f, 0.00151894f, 
    0.06661346f, 0.19088537f, 0.09997553f, 0.01080353f, -0.00790103f, -0.16151063f, -0.02772961f, 0.06351768f, 
    -0.07899623f, -0.24810554f, -0.13103470f, -0.01600490f, 0.09240309f, 0.07071264f, 0.02658930f, -0.09031507f, 
    0.02483799f, -0.00366950f, -0.02363547f, -0.02347851f, -0.00774079f, -0.17948337f, -0.11338586f, 0.01172461f, 
    -0.08874010f, 0.09632896f, 0.15298936f, 0.06599473f, 0.09275020f, -0.06575040f, 0.00515781f, -0.12817930f, 
    -0.04888286f, 0.23967607f, 0.08285272f, 0.05302711f, -0.09587637f, -0.16745059f, -0.23469238f, -0.07798883f, 
    -0.11745436f, 0.05926601f, -0.09997003f, 0.01218196f, 0.07935522f, -0.08503695f, 0.00886786f, 0.09653708f, 
    0.01396084f, 0.24578197f, -0.10624847f, -0.04202150f, 0.05752638f, 0.10755701f, 0.01956817f, 0.12417457f, 
    -0.20035045f, -0.01622379f, -0.35974109f, -0.20267633f, 0.01783372f, 0.03516537f, 0.11573976f, 0.06435823f, 
    -0.07620528f, -0.08614737f, 0.23197885f, -0.08901750f, -0.03417649f, 0.03188915f, 0.25827307f, -0.04412949f, 
    -0.02825366f, -0.09122746f, 0.11708058f, -0.00727440f, -0.06826301f, 0.10230058f, -0.03061088f, 0.07172598f, 
    -0.08263175f, -0.16829133f, 0.26608682f, 0.06808124f, -0.07004598f, 0.01092576f, -0.00303005f, 0.16911237f, 
    -0.04010374f, 0.11191792f, -0.15445377f, -0.00145224f, -0.20917414f, -0.17911948f, 0.49404520f, 0.07981409f, 
    -0.08918923f, -0.21003382f, -0.10276282f, -0.01214450f, -0.04372528f, 0.05868408f, -0.19297591f, 0.01971352f, 
    -0.02283244f, 0.08396638f, 0.37802035f, 0.23610976f, -0.18533859f, -0.05599947f, -0.09477505f, -0.14285469f, 
    0.01699801f, 0.14853951f, -0.14720869f, 0.19944701f, -0.13807984f, 0.04756791f, -0.34522927f, -0.27637696f, 
    -0.09863049f, -0.12942265f, 0.03991788f, 0.07073753f, -0.03784883f, -0.12057678f, 0.11015331f, 0.04813413f, 
    0.01137532f, -0.00666599f, -0.14459370f, 0.21007960f, 0.09391289f, 0.13107251f, 0.24405441f, 0.10749216f, 
    0.22236222f, -0.03635180f, 0.27657333f, 0.05803674f, -0.17842105f, 0.56673181f, 0.34123665f, 0.10402602f, 
    0.11763506f, 0.05726540f, 0.22506450f, -0.02003967f, 0.08893394f, 0.11547244f, 0.11735934f, 0.15004748f, 
    -0.04718534f, 0.01632127f, 0.00405553f, -0.06740273f, -0.07081175f, 0.00080000f, -0.07096693f, -0.04053789f, 
    0.03355293f, 0.15078577f, 0.12826589f, 0.26489419f, 0.44617131f, 0.25273049f, 0.15496242f, 0.17329966f, 
    0.12485515f, 0.09818899f, -0.09445067f, -0.01155967f, -0.11994084f, -0.04477664f, -0.13065332f, -0.12565765f, 
    -0.03550898f, 0.01060794f, 0.00476936f, -0.04048740f, -0.01103674f, 0.13455705f, 0.06410607f, 0.18231198f, 
    -0.13183115f, -0.00042015f, 0.08376438f, -0.03499171f, -0.01312325f, -0.14580825f, -0.17729069f, 0.05723693f, 
    0.03794643f, 0.08043086f, -0.03918582f, 0.04012702f, -0.07441487f, -0.00890636f, -0.07191806f, 0.01259859f, 
    -0.01298216f, 0.04273492f, 0.32545537f, 0.17386860f, -0.19634040f, -0.09564311f, -0.05215711f, -0.01104427f, 
    -0.08333253f, 0.03047325f, 0.03084371f, -0.02573350f, 0.05364177f, 0.07361133f, -0.22394323f, -0.10074286f, 
    -0.01854594f, 0.01723386f, 0.07218910f, -0.15867744f, -0.05698832f, -0.04651998f, -0.00776726f, 0.00894277f, 
    -0.08082557f, -0.27452087f, -0.20639594f, 0.23679428f, -0.06640573f, 0.08431444f, 0.22674903f, 0.20656912f, 
    0.09091894f, 0.14890513f, -0.06561504f, 0.04644039f, -0.10713343f, 0.01881747f, 0.09305300f, 0.04856676f, 
    0.00057639f, 0.00056430f, 0.01801681f, 0.01851396f, 0.00033437f, 0.15033942f, 0.31608179f, 0.09767349f, 
    0.34157038f, -0.17346025f, -0.04032629f, -0.01714665f, 0.04835028f, 0.13200167f, 0.18634914f, -0.07498904f, 
    0.04526822f, 0.19908966f, -0.01795765f, 0.10785939f, -0.07565043f, 0.20286283f, -0.16452044f, -0.11086347f, 
    -0.03525821f, -0.02735996f, 0.03877580f, 0.10157194f, -0.02140647f, -0.02136080f, -0.00029586f, 0.15688898f, 
    0.23590003f, -0.24481377f, -0.08683798f, 0.16909389f, 0.06908797f, 0.31097546f, 0.02038915f, 0.10830492f, 
    -0.05541333f, 0.22561581f, 0.11154991f, -0.04412322f, -0.17876373f, -0.07732730f, -0.15351887f, -0.12723225f, 
    0.06185583f, 0.03642898f, 0.04310406f, 0.03000691f, 0.02442506f, 0.10134182f, 0.12014429f, 0.06781159f, 
    -0.33999237f, -0.34265256f, -0.20806594f, -0.09988390f, 0.02641843f, -0.02029757f, 0.11499013f, 0.03046824f, 
    -0.03071765f, -0.03724414f, -0.01526959f, -0.13324817f, -0.18729164f, -0.16924040f, -0.17846195f, -0.19173828f, 
    -0.10205919f, 0.02861160f, 0.08402194f, 0.01138869f, -0.11761769f, -0.05956744f, -0.02488364f, 0.02996149f, 
    0.24288198f, 0.36600110f, 0.16513741f, -0.21223673f, 0.30136770f, -0.10870278f, -0.09074462f, 0.08699647f, 
    -0.05135694f, 0.03172758f, -0.01175965f, -0.02734833f, -0.18555118f, -0.05197927f, 0.21818215f, -0.09249749f, 
    0.28300956f, 0.15135927f, 0.20647183f, 0.17009559f, 0.13014631f, -0.02683963f, 0.02301341f, 0.04452638f, 
    0.01569713f, 0.00023945f, -0.01125808f, 0.02199790f, 0.02980530f, -0.01864170f, 0.01409050f, -0.02318344f, 
    -0.00114066f, -0.00747093f, -0.03774883f, -0.00119223f, -0.00039290f, -0.03467980f, 0.02480519f, -0.01000779f, 
    0.01861862f, -0.04089283f, 0.01461189f, -0.02043311f, 0.00164393f, 0.00973313f, -0.04144904f, -0.03757237f, 
    -0.04038818f, 0.00108170f, -0.03538402f, 0.01463262f, -0.00804042f, 0.02816462f, 0.02817469f, 0.00448949f, 
    -0.03422584f, -0.02507879f, -0.03231684f, -0.02303994f, 0.01142689f, -0.00136404f, 0.00011575f, 0.01375274f, 
    0.01880931f, 0.00781470f, -0.01713100f, 0.00252384f, 0.00679965f, -0.02790413f, -0.00617000f, -0.00665638f, 
    -0.02879976f, 0.01584505f, -0.00928556f, -0.00213650f, -0.00508176f, 0.02124869f, 0.00239949f, -0.03304649f, 
    -0.01238229f, -0.03127553f, -0.00898078f, 0.01537123f, -0.02899818f, -0.03234624f, 0.00383403f, 0.02484247f, 
    0.02056649f, -0.03751947f, -0.00481147f, -0.03717685f, -0.00747525f, -0.01737364f, -0.01069419f, 0.01136092f, 
    0.01476821f, -0.00172620f, -0.01162278f, 0.00206767f, -0.04088340f, -0.01445296f, -0.00916483f, -0.00346365f, 
    -0.01803365f, -0.02717427f, 0.00465210f, -0.00421776f, 0.00985648f, -0.00133170f, -0.02396954f, 0.01950821f, 
    -0.02475500f, -0.03874693f, 0.01008640f, 0.00161202f, -0.01841981f, -0.02362244f, 0.00822283f, 0.00492655f, 
    -0.01052445f, 0.00786123f, -0.00031901f, 0.02984763f, -0.00598685f, -0.02857676f, 0.00833563f, -0.03442396f, 
    -0.02428696f, 0.02019336f, -0.01494968f, 0.02202683f, 0.00128896f, -0.02483721f, 0.01575547f, -0.02953878f, 
    -0.03140894f, -0.03536745f, 0.02959398f, -0.02547542f, 0.01375164f, 0.02885404f, -0.01246269f, -0.00962303f, 
    0.02258117f, -0.02701084f, -0.01733637f, -0.00682549f, 0.02429250f, 0.00420531f, -0.03620358f, 0.00328433f, 
    0.01251889f, 0.02383527f, 0.01527141f, 0.01101337f, 0.00912364f, -0.01136959f, -0.01119867f, 0.02303335f, 
    -0.00507537f, 0.00081655f, -0.00239244f, -0.02040508f, 0.01351412f, -0.04155123f, -0.02321135f, 0.02061384f, 
    0.02514182f, 0.01048168f, -0.03126251f, -0.01434833f, 0.01261169f, -0.03489517f, 0.02695163f, 0.02392535f, 
    0.02501564f, -0.00161625f, -0.00412381f, -0.03366587f, -0.01634751f, -0.03350352f, 0.00605038f, -0.01137564f, 
    -0.02403951f, -0.01439680f, 0.01563712f, 0.00036176f, -0.03219897f, 0.01106885f, -0.02121776f, 0.02344844f, 
    0.02904383f, -0.03368146f, -0.03242737f, 0.01592728f, 0.02726670f, -0.02167692f, 0.01798322f, -0.00234770f, 
    0.00696713f, 0.01015585f, 0.02832081f, -0.02693826f, 0.01857482f, 0.01617932f, -0.02598107f, -0.02702187f, 
    -0.01753841f, 0.00289629f, -0.02847697f, 0.00302577f, -0.01376480f, -0.02225336f, 0.02702621f, -0.00388707f, 
    -0.03801412f, -0.04189074f, 0.02302832f, -0.01407287f, -0.02115631f, -0.02999256f, -0.03954189f, 0.01952372f, 
    0.00663144f, -0.03917332f, 0.00558998f, 0.01342761f, 0.01888017f, 0.00820178f, 0.01354031f, -0.01785171f, 
    -0.03692378f, 0.01970832f, -0.01927171f, 0.02757872f, -0.03962580f, -0.01414655f, -0.01831338f, -0.03568273f, 
    -0.04015836f, -0.01980581f, -0.02665008f, 0.01387990f, -0.01134511f, 0.00314037f, 0.02286137f, -0.03160235f, 
    0.00867286f, 0.00860246f, 0.00511777f, -0.00876195f, -0.02322949f, 0.00873320f, -0.03289923f, -0.02731063f, 
    0.00036702f, -0.01028314f, -0.02149094f, -0.02165887f, -0.01878060f, -0.02548340f, -0.02378283f, 0.02646651f, 
    -0.02254404f, -0.04099213f, 0.02338160f, -0.02918253f, -0.00514455f, -0.04097528f, 0.02736804f, 0.02878068f, 
    -0.01070014f, -0.01472769f, 0.00792861f, 0.01726780f, 0.02072963f, 0.00891460f, 0.01132279f, -0.01897613f, 
    -0.02522537f, -0.04136966f, -0.03329704f, -0.01736001f, 0.02165716f, -0.01475928f, 0.01096760f, -0.01926806f, 
    0.02184642f, -0.02922230f, -0.03204182f, 0.02712354f, 0.02083055f, -0.02067253f, 0.02416700f, -0.03435360f, 
    -0.03194094f, 0.01029283f, -0.02926164f, 0.01241573f, -0.01394491f, -0.02811625f, 0.01418519f, -0.00245648f, 
    0.01522647f, -0.00550256f, 0.02566476f, 0.02122373f, -0.01768148f, -0.03797735f, 0.00957397f, 0.02332125f, 
    0.00587463f, 0.01510829f, -0.01579611f, 0.00777968f, -0.00341685f, -0.03098618f, 0.02689658f, -0.02783800f, 
    -0.02017295f, 0.00482381f, -0.03914614f, -0.02750028f, -0.04025904f, 0.00693336f, -0.04113622f, -0.00378815f, 
    -0.01316453f, -0.00227151f, -0.01023179f, 0.02008315f, -0.02857055f, -0.00965547f, -0.00132023f, 0.01821059f, 
    -0.03143742f, -0.01457932f, 0.01197197f, -0.01113664f, 0.02484103f, -0.02633991f, -0.02683177f, -0.03780158f, 
    -0.00249042f, -0.02045962f, -0.03464173f, -0.02529630f, -0.00579676f, -0.02678200f, 0.00302235f, 0.00176785f, 
    -0.00254165f, 0.02981719f, 0.01097348f, -0.00527662f, -0.00415615f, -0.02210127f, 0.02012414f, -0.02238270f, 
    0.01728617f, -0.01618040f, 0.01437568f, 0.02663678f, -0.01432638f, 0.02669485f, 0.00717307f, -0.00772599f, 
    -0.01001235f, -0.02062165f, -0.00193357f, 0.00549993f, 0.02800247f, -0.01866161f, -0.00249797f, 0.02923618f, 
    -0.02311260f, -0.01253148f, -0.03792099f, -0.01184249f, -0.03405280f, 0.00092912f, -0.02316661f, 0.00616320f, 
    -0.02886682f, 0.02715791f, -0.02990400f, 0.00321746f, -0.00740422f, 0.00978150f, 0.02573042f, 0.00391803f, 
    -0.01881740f, -0.01298603f, -0.03085055f, -0.00708288f, -0.00290009f, 0.00561147f, -0.01689264f, -0.04135893f, 
    -0.02051112f, -0.00479060f, -0.00715527f, -0.03205722f, -0.00486949f, -0.02770519f, -0.03652358f, -0.00717947f, 
    0.01701689f, 0.00843001f, 0.00332653f, 0.02361239f, -0.01932748f, -0.03745189f, -0.00826953f, -0.00575416f, 
    -0.01403274f, 0.01522164f, 0.00041058f, 0.00912593f, 0.00264305f, -0.01142296f, -0.03808121f, -0.02316136f, 
    -0.04146656f, -0.01902317f, -0.03623162f, 0.02430159f, -0.02860929f, -0.00902808f, -0.01658921f, -0.00018387f, 
    -0.03340189f, -0.02568064f, -0.02394850f, 0.01753892f, -0.01157657f, 0.01661841f, -0.01510451f, 0.01005691f, 
    0.00378224f, -0.03205396f, 0.00894552f, -0.02927068f, 0.02263229f, -0.03388503f, -0.03524928f, 0.01907809f, 
    0.00162218f, -0.04059392f, -0.02162188f, -0.04054209f, 0.02245568f, -0.04119730f, 0.01819301f, -0.03453887f, 
    0.02720559f, -0.02967982f, 0.01155901f, -0.01251003f, 0.01990583f, -0.01057803f, -0.03896094f, 0.00151916f, 
    0.01935252f, -0.03279217f, 0.02487193f, 0.01984123f, 0.00084122f, -0.04204189f, 0.02196911f, -0.00795932f, 
    -0.00583877f, -0.02695039f, -0.03282995f, -0.01291656f, -0.02940751f, -0.03237338f, -0.01555297f, -0.02727108f, 
    0.03775411f, -0.01738347f, 0.00900732f, -0.03374761f, 0.01293609f, 0.02328478f, 0.02484679f, -0.01670826f, 
    0.00254454f, -0.03100004f, -0.02615608f, 0.00212772f, -0.00562996f, -0.00879719f, 0.01263153f, -0.03479399f, 
    0.00872608f, -0.01925723f, 0.02904858f, 0.02303367f, 0.01776905f, 0.02590979f, 0.00030132f, 0.02557122f, 
    -0.03947013f, -0.04198972f, 0.01199589f, -0.02374036f, -0.02345352f, -0.02659782f, -0.01186971f, -0.02812571f, 
    0.02735844f, -0.04169154f, -0.02326179f, 0.01557307f, 0.00287496f, 0.00589506f, -0.01649106f, 0.02406511f, 
    -0.03355820f, 0.02089657f, -0.03172021f, 0.01520780f, 0.00189255f, -0.01884669f, -0.02051893f, -0.02750301f, 
    -0.03167469f, -0.03307470f, 0.02200795f, 0.00932378f, 0.01838920f, -0.01367153f, 0.02272017f, 0.00175977f, 
    -0.01844441f, 0.02017513f, 0.02189920f, 0.00251554f, -0.02181497f, 0.01287928f, 0.02969108f, 0.00293489f, 
    -0.01056905f, -0.00095928f, -0.02190525f, 0.01454690f, -0.02783917f, 0.02928406f, -0.03953100f, 0.01467642f, 
    0.00469860f, 0.02969755f, 0.02096379f, -0.03625062f, 0.00482102f, 0.01836436f, 0.00990017f, -0.00395373f, 
    0.01481783f, -0.03158828f, -0.01872040f, -0.00847911f, 0.00717093f, -0.03735130f, -0.02066728f, 0.02097602f, 
    0.02693654f, -0.03960022f, -0.03030275f, 0.01187545f, 0.01905458f, 0.00286087f, 0.00550446f, 0.01323665f, 
    0.01506653f, -0.03800937f, -0.01413226f, 0.02579258f, -0.00364101f, 0.02377655f, -0.03737637f, -0.01139610f, 
    -0.00773228f, 0.01907937f, -0.01028700f, -0.03506413f, -0.00900533f, -0.01504555f, 0.01059416f, -0.00836715f, 
    0.01305762f, -0.00854880f, -0.03850606f, -0.02163823f, -0.02720524f, -0.03748791f, 0.02568657f, 0.01384931f, 
    -0.01414223f, 0.00584934f, -0.03253473f, 0.00735747f, -0.03267312f, -0.00708278f, 0.02232916f, 0.01962750f, 
    -0.03363290f, -0.02115213f, -0.00978912f, -0.02406265f, -0.03456130f, 0.02688798f, 0.00120075f, 0.01784761f, 
    0.00844843f, -0.03959919f, -0.03854961f, -0.00233888f, -0.02639601f, -0.03542992f, -0.02927858f, -0.02098123f, 
    0.00205861f, -0.00099841f, -0.03156864f, -0.03715276f, 0.01039447f, -0.01454846f, -0.00201130f, -0.00450117f, 
    0.01168740f, 0.02177991f, 0.02296788f, -0.03005731f, -0.00277468f, 0.00403287f, 0.00492494f, -0.01580684f, 
    -0.00153720f, -0.03365219f, 0.01184243f, -0.03518832f, 0.00846659f, -0.01101858f, 0.02850332f, -0.00221450f, 
    -0.04130355f, -0.00155800f, 0.02498910f, 0.01252337f, -0.03978417f, -0.02210037f, -0.01195421f, -0.03796726f, 
    -0.01288206f, -0.02312981f, -0.04002349f, -0.03382772f, -0.00751464f, 0.02996069f, 0.01270041f, 0.00495318f, 
    -0.03982468f, 0.02355154f, -0.01141965f, 0.02587385f, -0.01954803f, -0.01003451f, -0.02836024f, -0.00739417f, 
    -0.01466282f, 0.01511578f, -0.04100548f, 0.01769616f, 0.00469815f, -0.01080916f, -0.02267286f, -0.03014483f, 
    0.01282013f, 0.02854391f, 0.00460435f, -0.01612818f, 0.01690097f, -0.03555962f, -0.03931950f, 0.02580638f, 
    -0.02841033f, 0.02574440f, -0.02984888f, -0.03297627f, 0.01658832f, 0.02877422f, -0.00831841f, -0.03952549f, 
    0.01849333f, -0.03126646f, 0.02588851f, 0.00900777f, -0.01895430f, 0.01420532f, 0.02646809f, 0.00346272f, 
    -0.01792320f, 0.01602260f, -0.02359499f, -0.02554569f, 0.02957329f, -0.00044962f, -0.00196925f, -0.02858515f, 
    0.02980139f, 0.00287991f, -0.04198775f, 0.01405348f, 0.00449102f, -0.02241202f, -0.03519653f, -0.01797779f, 
    0.01621723f, 0.01680265f, 0.02391271f, 0.01015475f, -0.01306803f, -0.03724636f, -0.02462924f, -0.00969551f, 
    -0.00885849f, 0.01719126f, -0.00537964f, -0.01702075f, -0.03730201f, 0.01873565f, -0.01943487f, -0.01012853f, 
    -0.03216904f, 0.01917161f, 0.01984187f, 0.02500006f, -0.02213215f, -0.02965184f, -0.00736638f, 0.01110720f, 
    -0.00200276f, 0.00444006f, 0.01001613f, -0.01086701f, -0.02285669f, -0.00237217f, 0.00331934f, 0.00486242f, 
    -0.00712917f, 0.02949694f, 0.02350169f, 0.00787190f, -0.01092237f, 0.01426059f, 0.01783442f, -0.01837100f, 
    -0.02855965f, -0.01116792f, 0.01997694f, -0.01217747f, -0.01408628f, -0.00607786f, -0.00704784f, -0.02276676f, 
    0.02365126f, -0.01837720f, -0.03648452f, 0.01555001f, -0.03421153f, 0.00307365f, -0.02017933f, -0.01049723f, 
    -0.01483933f, 0.02882298f, -0.03540010f, 0.00420128f, -0.02747203f, -0.02377927f, -0.01165113f, 0.02635334f, 
    -0.00339745f, -0.03896825f, 0.02516945f, -0.03989552f, 0.02256461f, 0.01090966f, 0.00611906f, -0.03590829f, 
    -0.13716315f, -0.10581569f, 0.13209020f, 0.10171112f, -0.01211558f, -0.11110713f, -0.01416316f, 0.17397325f, 
    0.10893425f, -0.02225233f, -0.05651316f, 0.02941405f, 0.06354441f, 0.07820766f, -0.05506724f, -0.02027956f, 
    0.04562248f, -0.01179851f, 0.05099927f, 0.00562508f, 0.04681978f, -0.03509795f, 0.03359370f, 0.07064112f, 
    0.05045358f, -0.04583228f, -0.00212530f, -0.07853273f, 0.03585317f, 0.00386007f, -0.06974673f, -0.09933590f, 
    -0.09838448f, -0.13410936f, -0.15150639f, -0.09713320f, 0.01040257f, -0.08888821f, 0.05280557f, -0.01506920f, 
    -0.01327615f, 0.08130074f, -0.01808470f, -0.09427196f, 0.00541315f, -0.03623106f, -0.06253899f, 0.01799263f, 
    -0.06889736f, -0.03822843f, 0.12041717f, 0.16482385f, 0.07718086f, 0.06068504f, 0.09412660f, -0.05604311f, 
    -0.00434542f, -0.08932976f, 0.09396090f, -0.05937137f, -0.21275362f, -0.01611207f, 0.03753488f, -0.09814177f, 
    0.08117687f, 0.06422060f, -0.13427247f, 0.01498676f, -0.01043657f, 0.00811017f, -0.14048412f, 0.10376917f, 
    -0.21722388f, -0.01948006f, 0.05036033f, 0.01565693f, -0.06055216f, -0.06701829f, -0.12292951f, -0.09983069f, 
    -0.00625476f, -0.06670897f, -0.01780645f, 0.02114535f, -0.17686486f, 0.09520046f, -0.05290384f, 0.04861074f, 
    0.04423118f, 0.06010774f, -0.03107655f, -0.01086114f, -0.01052701f, 0.01140408f, 0.02364420f, -0.12830232f, 
    -0.13501646f, 0.07997298f, 0.11405016f, 0.45759013f, 0.12440629f, 0.16638716f, -0.11105803f, 0.02203154f, 
    -0.05691156f, 0.03092066f, -0.01218843f, -0.04336246f, -0.14230253f, 0.16406691f, 0.03745350f, -0.02651430f, 
    0.05368264f, -0.11677959f, 0.01625502f, -0.02506013f, -0.02259127f, -0.01155946f, -0.10182085f, 0.00497213f, 
    -0.10334232f, 0.04998456f, -0.09377732f, 0.29511985f, 0.14763820f, -0.01555047f, -0.01940142f, -0.12175593f, 
    0.02415732f, -0.01168034f, -0.07454648f, 0.06954813f, 0.06459152f, 0.03468842f, 0.01394946f, 0.17801940f, 
    0.09270117f, -0.18849114f, 0.03047039f, 0.03598876f, 0.10603656f, 0.04979238f, -0.11759435f, -0.02140789f, 
    0.17549253f, 0.16678214f, -0.16850740f, 0.13004367f, 0.07347941f, -0.01005435f, 0.05760249f, -0.06904834f, 
    -0.04100920f, -0.07193542f, -0.05074164f, -0.04835716f, -0.05269829f, -0.04162790f, -0.03762509f, 0.12711188f, 
    0.10557453f, -0.14672230f, 0.03998655f, 0.02151265f, 0.01893825f, -0.02159044f, -0.06990999f, -0.01278649f, 
    0.08955917f, 0.15281235f, -0.00286738f, -0.08560021f, 0.05742462f, -0.00039164f, -0.07931184f, -0.00170904f, 
    -0.05196340f, -0.22547744f, -0.01519922f, -0.24835728f, 0.05100613f, 0.26640838f, 0.11395444f, 0.06190590f, 
    0.15088850f, 0.01511819f, -0.11070167f, 0.12900372f, -0.01101830f, -0.01082613f, 0.00551820f, -0.12604307f, 
    -0.09507991f, 0.05148696f, 0.16798837f, 0.06348716f, 0.00736667f, -0.01585139f, 0.01724102f, 0.15834689f, 
    0.09741717f, -0.06259911f, -0.02648772f, -0.00720866f, 0.00654216f, 0.02833999f, -0.00933383f, -0.10940549f, 
    -0.04425066f, -0.07244822f, 0.04999835f, -0.05812956f, -0.06645876f, -0.07162456f, 0.00058485f, 0.09437601f, 
    0.20604700f, 0.27342477f, 0.07945384f, 0.01756962f, 0.02907739f, -0.01935236f, -0.01627145f, -0.07309681f, 
    0.03917260f, 0.04362048f, -0.11657007f, 0.05283182f, 0.04609517f, -0.07000334f, 0.09595720f, 0.05115217f, 
    -0.00184097f, 0.06616126f, 0.14377691f, 0.05525528f, 0.05483598f, -0.00506661f, 0.06327733f, 0.09890115f, 
    0.05978669f, 0.05042444f, 0.06262781f, -0.12783556f, -0.05521829f, 0.03663161f, -0.04788541f, 0.05596072f, 
    -0.01084857f, 0.00346773f, -0.16109730f, -0.04921293f, 0.13818859f, -0.00781292f, -0.07170306f, 0.03248326f, 
    -0.08253901f, -0.01322857f, 0.09514764f, 0.04573043f, 0.09543993f, -0.03146601f, 0.08678655f, -0.00544420f, 
    0.14836125f, 0.17519267f, -0.16210432f, 0.06331689f, 0.17238523f, 0.06997573f, -0.18170185f, -0.08605199f, 
    -0.11118081f, -0.14928201f, -0.09399515f, -0.10732056f, 0.19316383f, 0.14745949f, -0.03197134f, 0.00126544f, 
    0.00467837f, -0.00537788f, -0.05698979f, 0.01769270f, 0.01498294f, -0.09876934f, 0.13352542f, 0.01860868f, 
    0.28404993f, 0.15211834f, -0.00560538f, 0.06797098f, 0.01450417f, 0.00780961f, 0.00358991f, 0.00546047f, 
    0.00940125f, -0.17676349f, 0.12369008f, -0.08148693f, -0.02899721f, -0.04305206f, -0.04346943f, -0.03541694f, 
    -0.02686415f, -0.05288658f, -0.09551673f, -0.03594487f, 0.07812354f, -0.00368229f, 0.06076510f, 0.08443164f, 
    -0.20103025f, -0.06859254f, 0.37565500f, 0.06157433f, -0.09095623f, 0.07741088f, -0.07362944f, 0.08234405f, 
    0.04624430f, -0.02698988f, -0.03976597f, 0.00767106f, -0.19267435f, 0.04212803f, 0.19890900f, 0.06366301f, 
    0.03649525f, 0.01733904f, 0.05611715f, 0.04164770f, 0.08131756f, -0.01897295f, 0.05595244f, 0.06803177f, 
    0.05445985f, 0.03390391f, 0.13285853f, -0.09921748f, 0.02658558f, 0.05209072f, 0.00837162f, -0.06024596f, 
    0.10401094f, -0.12062109f, 0.08059075f, -0.00460954f, 0.08037158f, 0.11026206f, 0.02568987f, -0.13499753f, 
    -0.10847465f, -0.00231840f, 0.05639155f, 0.21437401f, 0.06079880f, -0.02717577f, -0.09382450f, -0.07916114f, 
    -0.17514375f, 0.00729180f, 0.07547604f, 0.11070258f, 0.13735147f, 0.01058539f, -0.00705482f, 0.08613800f, 
    -0.07198180f, 0.05624171f, 0.05729031f, -0.06747307f, 0.05055590f, -0.02341559f, -0.01766972f, -0.04019040f, 
    -0.02682599f, -0.08254319f, -0.03497914f, -0.06787889f, 0.06389774f, -0.06727954f, -0.01635853f, 0.02737036f, 
    -0.11509468f, 0.07172524f, 0.08970186f, 0.15055799f, -0.06216583f, 0.02573301f, -0.05003780f, -0.03237817f, 
    0.01367248f, -0.00616863f, -0.05670735f, 0.19290304f, 0.09619689f, 0.04428072f, 0.22061642f, 0.14538226f, 
    -0.00820628f, 0.01182510f, -0.06861611f, 0.09607282f, 0.04345296f, -0.03459786f, 0.16683654f, 0.02165637f, 
    -0.20300546f, 0.04540604f, 0.01179015f, 0.15244667f, 0.06795035f, 0.09219545f, -0.13066939f, -0.01527516f, 
    0.06014454f, 0.00067775f, 0.01106541f, 0.13802916f, 0.01206647f, 0.21389186f, 0.19901676f, 0.06374457f, 
    0.01856639f, 0.08934374f, 0.15844528f, 0.02759260f, 0.11414665f, 0.06773346f, -0.01702429f, 0.02824030f, 
    -0.00590315f, 0.18100166f, 0.20804588f, 0.13437855f, 0.12370141f, 0.07135814f, 0.12496401f, 0.02099741f, 
    0.13659465f, -0.00302743f, -0.00776412f, -0.01523667f, -0.04510843f, -0.13955072f, -0.06129960f, -0.09108552f, 
    -0.02904617f, -0.01781982f, -0.04069232f, -0.06144805f, 0.02677566f, -0.00365952f, -0.11757977f, -0.02629885f, 
    -0.15382178f, 0.01292359f, 0.07822017f, -0.07155320f, 0.07398981f, -0.02984685f, -0.06133311f, -0.09662845f, 
    -0.03461868f, 0.02746315f, -0.00832030f, -0.05523116f, 0.05025283f, 0.17537697f, 0.16287620f, 0.18958330f, 
    0.01791643f, 0.21424361f, 0.02451526f, -0.02026520f, 0.08533526f, -0.00938800f, 0.00424208f, 0.02676567f, 
    -0.03452526f, -0.17703044f, -0.02977413f, 0.00633181f, -0.07642838f, -0.03261577f, -0.00640231f, 0.08282081f, 
    -0.07140026f, -0.01117948f, -0.16002427f, -0.04579993f, -0.30349308f, 0.18728289f, -0.01071230f, 0.37925458f, 
    -0.03018904f, -0.07071830f, 0.11866445f, -0.04461887f, -0.02903112f, -0.05611407f, 0.04190708f, 0.17400981f, 
    0.04663413f, 0.12288506f, -0.11691844f, 0.04683794f, 0.19104189f, 0.06947754f, 0.08429874f, -0.06652661f, 
    0.06413409f, -0.00681510f, 0.05992897f, 0.05766679f, 0.36087412f, 0.26713961f, -0.16830155f, -0.01925689f, 
    0.04097698f, -0.00479492f, -0.05864890f, 0.12570885f, 0.11241904f, 0.01109106f, -0.05210726f, -0.03701587f, 
    0.29217699f, 0.14634529f, -0.04599601f, 0.17576900f, 0.18248791f, 0.03706376f, 0.00609729f, 0.04412582f, 
    0.14113389f, -0.10450872f, 0.03322463f, 0.10246660f, 0.06337749f, -0.01841689f, -0.08984306f, 0.10507698f, 
    -0.12000959f, 0.02366426f, 0.01158831f, -0.05713758f, -0.11044873f, -0.06862037f, 0.02036347f, 0.03558685f, 
    0.05497526f, -0.01204116f, 0.23811233f, -0.00201826f, -0.13418499f, 0.19205183f, -0.10435836f, 0.07933485f, 
    0.05759089f, -0.10367206f, 0.17708130f, -0.08625662f, 0.10391684f, -0.07234434f, -0.00401553f, -0.02516361f, 
    0.00087023f, 0.11152302f, 0.12022710f, 0.11062735f, 0.09164082f, -0.04952377f, 0.00076338f, -0.15243515f, 
    -0.06028059f, -0.06632993f, 0.10268256f, 0.01930654f, -0.06514903f, -0.01962829f, -0.03659368f, -0.06303999f, 
    0.10820291f, 0.05071001f, 0.05768045f, -0.04931371f, -0.00309421f, -0.00227178f, 0.04633432f, 0.06015062f, 
    -0.06101853f, -0.17364445f, -0.05100648f, -0.01854726f, -0.08181444f, -0.06008270f, -0.06156456f, -0.06139937f, 
    -0.07429603f, -0.00389224f, 0.00717540f, -0.09231284f, 0.09370697f, -0.01364461f, -0.00298392f, -0.02648995f, 
    0.02171276f, 0.02348853f, 0.03132239f, 0.06277266f, -0.00983715f, 0.12324223f, 0.32691348f, 0.26855686f, 
    0.05374752f, 0.11388373f, 0.14410026f, 0.14113013f, 0.08003464f, 0.05832431f, -0.00574483f, 0.05944462f, 
    0.29269245f, 0.29881635f, -0.01413841f, -0.00473013f, 0.05024587f, -0.06204912f, 0.07532434f, 0.05115627f, 
    0.05974069f, 0.01520552f, -0.05051136f, -0.04629619f, -0.23505512f, 0.03675028f, 0.26398227f, 0.19392383f, 
    -0.08157455f, -0.03580731f, -0.05639684f, 0.06633782f, -0.00345246f, 0.03288244f, -0.01102530f, -0.02116038f, 
    0.02782257f, -0.18325585f, 0.12727664f, -0.09528624f, 0.06559286f, 0.12602724f, -0.00412025f, -0.07217720f, 
    0.03235529f, -0.15355867f, 0.16378535f, -0.03798269f, -0.07689699f, 0.03155884f, 0.07165515f, -0.02600423f, 
    -0.01438053f, 0.01117002f, -0.00977386f, 0.00317461f, 0.07189526f, 0.10355292f, -0.02346998f, 0.15970774f, 
    -0.05802631f, 0.16928005f, 0.10375252f, 0.14919271f, -0.06538714f, 0.12704855f, -0.03788676f, -0.10417146f, 
    0.02617646f, -0.09885015f, -0.05940041f, 0.15127662f, 0.20643386f, 0.29568091f, 0.09402516f, 0.06039281f, 
    -0.04153287f, -0.07979155f, 0.02699641f, 0.03297531f, -0.01171561f, -0.01119416f, -0.09662912f, -0.03296417f, 
    -0.01692531f, -0.05464039f, 0.02912633f, -0.05618049f, 0.05713994f, 0.18720840f, 0.04901678f, -0.01026339f, 
    0.17344959f, 0.02631909f, -0.06448577f, 0.20993048f, 0.04613996f, -0.08125456f, -0.10638200f, 0.00931918f, 
    -0.13048542f, 0.00845697f, -0.04138188f, 0.02259389f, 0.09142141f, -0.06263547f, 0.02723613f, 0.03476685f, 
    0.20262742f, -0.08995468f, -0.06307243f, 0.06239413f, -0.04485413f, 0.04674779f, 0.03230764f, 0.02655130f, 
    0.11079668f, 0.03305404f, -0.02043913f, -0.12661523f, 0.09493932f, -0.05700387f, -0.07275556f, 0.03244676f, 
    -0.04644795f, -0.10117385f, -0.03992017f, -0.00889055f, 0.13494571f, 0.07054341f, 0.03815744f, 0.00577348f, 
    -0.11909583f, 0.03390506f, 0.01022233f, 0.31910580f, -0.13153405f, -0.06767651f, 0.11096996f, -0.04850059f, 
    0.06822040f, 0.02477673f, 0.05885356f, 0.11297856f, -0.02516913f, 0.06216363f, -0.05218141f, 0.09803245f, 
    0.02526576f, 0.05631970f, 0.07566302f, -0.03794308f, 0.17202304f, -0.05674925f, -0.13167776f, -0.02413946f, 
    -0.33560410f, 0.35104156f, 0.02316252f, 0.13753717f, -0.10822973f, 0.10875671f, 0.10020339f, 0.18513198f, 
    0.12113019f, 0.04080001f, 0.18468207f, 0.06494193f, -0.03240245f, 0.01710138f, 0.00979663f, 0.03040554f, 
    0.10793141f, 0.05698983f, -0.02169884f, -0.00109561f, -0.00427653f, -0.05355334f, -0.02657178f, -0.02119309f, 
    -0.09944053f, -0.13690732f, 0.03160508f, -0.01263816f, -0.00795755f, -0.03970295f, 0.01793070f, 0.05272849f, 
    0.03910470f, -0.04800584f, -0.03248277f, -0.02714627f, -0.15012428f, -0.01600421f, -0.04275318f, -0.01292843f, 
    -0.06055102f, -0.11938104f, -0.12516433f, -0.04602265f, 0.00226614f, -0.01049920f, -0.10693548f, 0.11667806f, 
    -0.03475380f, 0.10567610f, 0.19075589f, -0.17490412f, -0.05868797f, 0.08636994f, -0.05481675f, 0.11014682f, 
    0.03126935f, -0.00520206f, -0.05812277f, -0.09442756f, 0.23947865f, -0.10578190f, -0.06012056f, 0.16710356f, 
    0.02212447f, 0.05770858f, 0.06209973f, 0.10180118f, 0.08096024f, 0.05140816f, 0.05958043f, -0.01812896f, 
    0.11068442f, 0.17488821f, 0.13811643f, -0.00639686f, 0.05945371f, -0.00664390f, 0.07575417f, 0.01658524f, 
    -0.10844276f, -0.08290251f, 0.04803054f, 0.08116560f, 0.13025446f, -0.07227200f, -0.09837165f, -0.00449655f, 
    0.04682986f, 0.04680235f, -0.00860011f, -0.04134231f, -0.03967938f, 0.09976715f, -0.00256650f, -0.08900401f, 
    0.38584298f, 0.04873095f, 0.21673143f, -0.12227791f, 0.18907221f, 0.05581750f, 0.21878408f, 0.00751704f, 
    0.09872892f, 0.00209628f, -0.09552959f, -0.05113888f, -0.20382909f, 0.20614293f, 0.10950287f, -0.12275825f, 
    -0.02336697f, -0.00697654f, 0.00634927f, 0.10176311f, -0.14663853f, -0.07990087f, 0.00908802f, -0.00657055f, 
    -0.17338750f, -0.23722051f, 0.18276906f, 0.01137787f, 0.13238072f, 0.06297022f, 0.09983121f, 0.01703311f, 
    -0.12177685f, 0.04927839f, -0.00898919f, -0.05940032f, -0.33124551f, -0.03664995f, 0.04456686f, 0.06912846f, 
    0.04129643f, -0.04911025f, -0.01508211f, -0.02286806f, 0.08446889f, -0.06834228f, 0.03723264f, 0.09274685f, 
    -0.16980805f, -0.00119919f, -0.00229939f, 0.00490395f, -0.00950264f, 0.03545771f, 0.05186338f, 0.09379152f, 
    0.03510292f, 0.15263221f, 0.10436606f, 0.01042788f, -0.79419780f, 0.03461363f, 0.13297167f, 0.12000255f, 
    0.05150894f, -0.06346540f, 0.04102716f, 0.35242075f, 0.04417471f, 0.14021967f, 0.13976227f, 0.00942346f, 
    0.07487272f, -0.06540780f, -0.10797285f, -0.00310902f, 0.06853321f, 0.08279562f, 0.08015139f, 0.06396020f, 
    -0.05111843f, 0.05026252f, 0.06770226f, -0.02598704f, 0.54010236f, 0.01912341f, -0.06642200f, -0.05703303f, 
    0.11074841f, 0.13923134f, 0.21376596f, -0.08351233f, -0.03758085f, -0.02741111f, 0.03052748f, -0.01828525f, 
    0.19132181f, 0.13057858f, 0.03526720f, -0.04587121f, 0.10088616f, 0.08415060f, 0.13771015f, -0.01212975f, 
    -0.00320393f, -0.01307985f, 0.03326455f, 0.08313072f, 0.00948177f, -0.00707350f, 0.01051495f, 0.03130600f, 
    0.17572658f, -0.03181504f, 0.01788974f, -0.10912398f, -0.01510578f, -0.07984156f, 0.03967774f, 0.11272631f, 
    0.07304732f, 0.18589364f, -0.05422204f, 0.24229407f, 0.00131707f, -0.03386081f, 0.13764530f, 0.01650883f, 
    -0.03585593f, -0.09752590f, -0.03649450f, 0.17029418f, -0.08108000f, 0.01952958f, 0.04260490f, 0.04782471f, 
    0.04819579f, 0.02472197f, 0.15072180f, -0.07859578f, 0.11807553f, -0.11624703f, -0.01205521f, -0.09410624f, 
    0.05298435f, -0.00528376f, -0.13917953f, -0.02201010f, -0.01068173f, 0.07825378f, 0.11465399f, 0.04838358f, 
    -0.03663876f, -0.01541242f, 0.03858105f, -0.05826053f, -0.22430959f, -0.08340253f, 0.04777249f, 0.17686407f, 
    0.00958028f, -0.07137261f, -0.02754973f, 0.00251906f, 0.15091290f, 0.00418184f, 0.01297830f, 0.00145993f, 
    0.22575970f, -0.07900041f, 0.02181842f, -0.10895670f, 0.02973374f, -0.03441040f, -0.03498284f, 0.18610728f, 
    0.10862141f, -0.09446112f, 0.01760674f, 0.06373337f, 0.19458880f, 0.08172541f, 0.14138679f, 0.23397814f, 
    -0.04400493f, 0.00747098f, -0.01615490f, -0.05270988f, 0.00688392f, -0.02080875f, 0.12199496f, 0.11148664f, 
    0.34103730f, -0.06941096f, -0.20298760f, 0.03475293f, 0.07351201f, 0.10463513f, 0.07702042f, -0.03163248f, 
    -0.11278646f, 0.00458360f, -0.11621132f, -0.03812824f, 0.14922799f, 0.08771653f, 0.02658728f, 0.05411685f, 
    0.05163006f, 0.04733603f, -0.04648698f, 0.00304501f, 0.00130779f, 0.08152192f, -0.02574091f, 0.05738667f, 
    0.15839858f, 0.11905877f, 0.19043872f, 0.00468925f, 0.02632013f, 0.00866659f, 0.12032367f, 0.05684186f, 
    0.03465197f, -0.03639103f, 0.09787193f, 0.00394069f, 0.31156600f, -0.02016241f, -0.01146841f, 0.13897844f, 
    -0.02614674f, 0.12170916f, 0.22059093f, 0.09242193f, -0.01425434f, -0.07222818f, -0.01709057f, 0.00811699f, 
    0.39331871f, -0.21836764f, -0.14746319f, -0.00099073f, 0.07928459f, 0.12878759f, 0.18910389f, 0.05120632f, 
    -0.02422243f, 0.04955910f, -0.08637446f, -0.09432307f, -0.06012167f, 0.00811815f, -0.04838112f, 0.01255713f, 
    -0.05902353f, 0.02581207f, 0.03406300f, -0.04427879f, -0.01989923f, 0.00198610f, 0.02934278f, -0.01207514f, 
    0.12850975f, -0.10239415f, 0.07585342f, 0.00802151f, 0.25031883f, 0.00420332f, -0.07499594f, 0.05819058f, 
    -0.01461485f, -0.00081565f, -0.07680416f, 0.03651860f, 0.14613828f, 0.03810944f, 0.02711069f, 0.30010140f, 
    -0.02417832f, -0.02753573f, -0.04807103f, -0.00321474f, -0.00487334f, -0.04027796f, 0.10732333f, 0.10304078f, 
    0.01305999f, -0.05058232f, 0.05130050f, 0.15102232f, -0.01265228f, -0.00063701f, 0.10751510f, 0.03493933f, 
    0.17620184f, 0.00543036f, 0.12280105f, 0.00293609f, 0.21164200f, -0.05953525f, 0.10600137f, -0.14090358f, 
    0.08170796f, 0.15470535f, -0.05584298f, 0.05523951f, 0.01224941f, -0.04592301f, -0.02239840f, 0.08679491f, 
    0.13279104f, -0.01658122f, -0.06880507f, 0.06195650f, 0.00043448f, 0.10081838f, 0.08636366f, 0.11628780f, 
    0.06138605f, -0.04132556f, 0.17011593f, 0.03686014f, 0.28753752f, 0.09057456f, 0.00612262f, -0.05895506f, 
    0.04617116f, -0.05634258f, -0.08789108f, -0.13862389f, 0.02574114f, -0.04012658f, -0.11249590f, 0.00668507f, 
    0.20734483f, 0.14507926f, -0.01510360f, -0.12841152f, 0.08286276f, -0.03914011f, -0.03818325f, -0.04230364f, 
    0.00332162f, -0.05321992f, 0.03389401f, 0.02543234f, 0.20795463f, -0.04203790f, -0.14099315f, -0.15487541f, 
    0.03658641f, -0.05119474f, 0.02651642f, -0.03008945f, 0.04411419f, -0.09209985f, -0.01091714f, -0.05003612f, 
    0.15307248f, 0.15768915f, 0.00807827f, 0.01807812f, 0.21152134f, 0.12248823f, 0.07700064f, -0.09031139f, 
    -0.06814443f, -0.13225485f, -0.07300891f, 0.01164188f, -0.00084251f, 0.07218873f, -0.01082404f, -0.16693252f, 
    0.07028826f, -0.04304292f, -0.02410407f, 0.04141651f, -0.07798743f, 0.01042335f, -0.01217643f, -0.02029922f, 
    -0.02775979f, -0.14241908f, -0.26225048f, 0.06049224f, 0.00409779f, 0.05052766f, 0.04019350f, 0.03371080f, 
    0.02660296f, -0.04684650f, 0.02491626f, 0.07931997f, 0.17846850f, 0.03765295f, 0.16349459f, -0.19744745f, 
    0.09884512f, 0.20433401f, -0.06606503f, -0.07020123f, 0.02585290f, -0.08356109f, -0.05203071f, 0.07494937f, 
    0.14812015f, -0.08528603f, 0.00220531f, -0.07445537f, 0.07212486f, 0.14156091f, 0.05245310f, 0.11422507f, 
    0.05365190f, 0.01084068f, 0.01326532f, -0.08527458f, 0.08098298f, 0.05926603f, -0.05787347f, 0.01799032f, 
    -0.00026342f, 0.00464829f, -0.03633466f, -0.05464832f, 0.07568385f, 0.00319283f, 0.09106847f, -0.07460770f, 
    0.24759112f, -0.02117224f, -0.14958481f, -0.14970644f, -0.00779772f, -0.10175962f, -0.03791015f, 0.01015820f, 
    0.02992570f, -0.00471651f, 0.11409486f, -0.09333473f, -0.24195328f, -0.01649545f, 0.12491173f, 0.16401441f, 
    -0.11240235f, -0.12525919f, -0.01392710f, 0.04718700f, 0.13803740f, 0.03723996f, 0.15625970f, 0.12421477f, 
    0.05411963f, 0.02082262f, -0.09047719f, -0.14130312f, -0.05121225f, 0.04530108f, -0.07322025f, 0.03892826f, 
    0.00371031f, -0.03679425f, -0.07853108f, 0.05119309f, -0.01874396f, -0.37651858f, -0.04260694f, 0.01420274f, 
    0.08205208f, 0.03620750f, -0.06361037f, -0.06891998f, 0.20878008f, -0.01004154f, 0.13751063f, 0.03864745f, 
    0.19442311f, 0.06531036f, 0.03287219f, 0.04972404f, 0.02085478f, -0.00788157f, 0.01164032f, 0.09519252f, 
    0.09655644f, 0.09448664f, 0.16882886f, 0.05332655f, -0.61411864f, 0.10251459f, 0.01479586f, -0.21645415f, 
    0.03629412f, 0.06767480f, 0.09518812f, 0.14939024f, -0.08623563f, 0.03252448f, -0.05880257f, -0.06678297f, 
    -0.01734886f, 0.03363295f, -0.02705842f, 0.06473879f, 0.06056719f, 0.11358295f, 0.00629670f, 0.14469805f, 
    0.02706154f, 0.01005577f, -0.05959808f, -0.00134721f, 0.08241223f, 0.19899759f, 0.14596522f, -0.06043766f, 
    -0.04263001f, 0.00993738f, -0.01782126f, -0.11665777f, -0.02517041f, -0.10480376f, -0.11440494f, -0.07091998f, 
    0.03725815f, 0.06916052f, -0.13551567f, -0.11794306f, 0.03572847f, 0.11661377f, 0.05205944f, -0.09134485f, 
    0.03015549f, 0.14490747f, -0.00286990f, 0.00870149f, 0.34692553f, 0.21170200f, 0.15342398f, -0.06530121f, 
    0.02213888f, -0.00342692f, 0.02752268f, -0.22556847f, -0.07449596f, -0.05743853f, -0.05863282f, -0.01822281f, 
    0.26890370f, 0.01625815f, -0.07840781f, -0.06677774f, 0.02816303f, 0.12982100f, -0.02454975f, 0.07977618f, 
    -0.05242128f, 0.00035176f, -0.03711243f, -0.12025405f, 0.08769219f, 0.08031546f, -0.03894186f, -0.02246673f, 
    0.01613980f, 0.00037385f, 0.03647224f, -0.01292970f, 0.09325996f, 0.01758307f, 0.08674999f, -0.01064933f, 
    0.22635439f, 0.04399486f, 0.32393765f, -0.19294330f, 0.05291243f, 0.00563322f, -0.07193846f, 0.18501434f, 
    -0.01053310f, -0.07770081f, 0.03686898f, 0.01977858f, 0.03391796f, -0.07591724f, 0.01094522f, -0.02894116f, 
    -0.08937294f, 0.15394175f, 0.05480547f, -0.06770643f, -0.04300835f, -0.07279991f, -0.04571602f, 0.01575482f, 
    -0.22016832f, -0.04486907f, 0.02509782f, -0.02931140f, -0.02220512f, 0.02034873f, 0.12043601f, 0.03629962f, 
    0.00249851f, -0.03079061f, 0.06439473f, -0.00028001f, -0.25654510f, -0.14240229f, 0.06249572f, 0.12550788f, 
    -0.00421975f, -0.03329612f, 0.05499949f, 0.03190748f, 0.18403132f, 0.05253477f, -0.01032715f, 0.09548181f, 
    -0.30704123f, 0.10522268f, -0.02291866f, -0.13908747f, -0.09396890f, -0.05667825f, 0.00249761f, 0.07264856f, 
    -0.02586485f, 0.04754234f, 0.00662050f, -0.05152415f, -0.08126244f, -0.00070983f, 0.04009725f, -0.06247427f, 
    -0.06581894f, 0.01193000f, -0.05399787f, 0.00301183f, -0.02585978f, -0.01733348f, 0.18101493f, 0.02226365f, 
    0.15729830f, 0.04493406f, 0.21606471f, 0.17808044f, 0.10087345f, 0.05031680f, 0.06033775f, -0.07170992f, 
    0.02177203f, -0.06925182f, -0.05027818f, -0.07641251f, 0.04308368f, -0.06153971f, 0.00264695f, -0.08219454f, 
    0.08591414f, -0.06263629f, 0.02549880f, 0.03104248f, 0.03904132f, -0.10258234f, -0.09261565f, -0.01760834f, 
    0.00232238f, 0.22224426f, -0.32500151f, 0.16265748f, -0.04056402f, -0.06684270f, 0.09718981f, 0.09514062f, 
    -0.21092762f, -0.03443791f, 0.21294577f, 0.06465384f, -0.00540286f, 0.03260611f, -0.01054759f, -0.06927858f, 
    -0.01301790f, 0.12631427f, -0.04329463f, -0.00753861f, -0.09008259f, -0.09167778f, -0.06856123f, -0.14878248f, 
    -0.06758869f, 0.07195107f, -0.00915298f, 0.05550132f, -0.11669029f, -0.04230894f, -0.06530748f, -0.00404137f, 
    0.16791999f, 0.12443142f, 0.10635764f, 0.32511735f, -0.00778643f, 0.26483724f, -0.00917467f, 0.05053224f, 
    0.15323295f, 0.05828507f, -0.05498774f, 0.03221221f, 0.01357767f, -0.07614786f, -0.06044625f, 0.07507178f, 
    0.32149476f, 0.43632695f, 0.18760546f, -0.08189620f, -0.08897383f, 0.05524654f, -0.05280059f, 0.11768977f, 
    -0.12198422f, -0.02181198f, -0.05151607f, 0.00882852f, 0.05021216f, -0.04563210f, -0.07445562f, 0.02841178f, 
    -0.04321112f, -0.01235638f, -0.01327167f, -0.02094323f, -0.12708627f, -0.00850383f, -0.05151007f, -0.07186051f, 
    -0.10239775f, -0.18021420f, 0.00243946f, -0.03338785f, 0.08912942f, 0.03310098f, 0.05619271f, 0.10373888f, 
    -0.02393800f, 0.02005178f, 0.05464153f, 0.01143349f, 0.02526602f, 0.06717129f, 0.11129908f, 0.15529265f, 
    0.05129127f, -0.09478221f, 0.10058343f, 0.04462819f, 0.02684000f, -0.01336289f, 0.01671311f, -0.06086190f, 
    0.20009719f, -0.10799551f, 0.40855560f, 0.35652235f, 0.06095107f, 0.18292196f, -0.00050124f, 0.08525008f, 
    -0.03806534f, 0.09855127f, -0.16907616f, -0.06381107f, 0.24055281f, -0.12472108f, 0.02675658f, -0.00759190f, 
    -0.08464548f, 0.03865800f, 0.05053252f, 0.16431743f, 0.05226697f, 0.02404045f, -0.00471403f, 0.13431440f, 
    0.20564134f, -0.30363914f, 0.25374353f, -0.09649997f, -0.08085844f, 0.00264400f, 0.06283467f, -0.18782327f, 
    0.03987380f, 0.07530713f, -0.08967876f, 0.00641775f, 0.29310995f, -0.05036812f, -0.04154966f, -0.07975531f, 
    0.14972380f, 0.12775137f, 0.06146901f, 0.01960907f, -0.01669233f, -0.10743245f, -0.10389621f, -0.03906456f, 
    0.18671641f, 0.19587557f, 0.05764395f, -0.05047306f, -0.09128164f, -0.04921564f, -0.03553741f, -0.04336475f, 
    0.08959589f, 0.07888954f, 0.35388240f, 0.08058082f, 0.40877676f, 0.09478776f, -0.04293392f, -0.02215299f, 
    -0.27246299f, 0.22053781f, 0.22938055f, 0.17816602f, 0.09130675f, -0.02814541f, 0.10751618f, -0.08919604f, 
    -0.08627838f, 0.21562168f, -0.05740447f, 0.20118259f, -0.06365161f, -0.05100612f, 0.01143906f, 0.05622158f, 
    0.21782184f, 0.14561179f, 0.13267463f, 0.25696272f, 0.10769787f, -0.11276639f, 0.17246909f, 0.19381545f, 
    0.13085090f, 0.11532654f, 0.31872851f, 0.14298157f, 0.01960743f, -0.01815768f, 0.00789488f, -0.07416329f, 
    -0.02941071f, 0.00830502f, -0.11154057f, 0.05478117f, 0.09994082f, 0.09053640f, -0.00367180f, -0.04587893f, 
    0.00181246f, -0.00795090f, 0.03533503f, 0.21570416f, -0.00994811f, -0.02119316f, -0.01127300f, 0.01453826f, 
    -0.03652625f, 0.08302667f, -0.13424736f, -0.03100563f, -0.01835113f, -0.03979546f, 0.00750718f, -0.01060195f, 
    -0.18482266f, 0.05635278f, 0.11729916f, 0.08223882f, 0.04387079f, -0.00037938f, 0.12347805f, -0.12753974f, 
    -0.06461161f, -0.09719770f, -0.02462529f, -0.01984687f, 0.05180224f, 0.21286438f, 0.11211248f, 0.03122308f, 
    -0.10217323f, 0.23070894f, -0.01704549f, -0.20687447f, 0.01182649f, -0.05450602f, 0.05513544f, -0.16941515f, 
    -0.55275202f, 0.32362854f, 0.02363303f, 0.36186859f, 0.01354463f, -0.02620642f, -0.08062853f, 0.00323012f, 
    0.09269404f, -0.00497142f, 0.08295613f, 0.10918937f, 0.04787334f, 0.11285173f, 0.06469925f, -0.03600406f, 
    0.02282185f, -0.05872013f, -0.04319068f, -0.02211629f, -0.07254235f, -0.03848025f, -0.07179730f, -0.18530126f, 
    0.16505091f, 0.18440855f, 0.02781948f, -0.00910023f, -0.25597402f, 0.14361551f, -0.03515637f, 0.29400218f, 
    -0.01884314f, 0.11714573f, -0.04026858f, 0.13775729f, -0.06701330f, 0.03141435f, -0.02959440f, -0.11464961f, 
    0.04061165f, 0.04620805f, -0.01492056f, 0.00722377f, -0.08157435f, -0.02063445f, 0.03912790f, -0.07329579f, 
    0.20142512f, 0.02095790f, -0.22173022f, 0.13584924f, -0.02061394f, -0.01040174f, -0.07485109f, 0.07494466f, 
    0.01668230f, 0.01327504f, 0.11856002f, 0.01906953f, -0.00428725f, -0.06417596f, -0.09291399f, -0.04633859f, 
    0.04081174f, 0.01068745f, 0.05703975f, -0.01934978f, -0.04054542f, 0.00842831f, -0.03071520f, 0.02490551f, 
    0.05709812f, 0.23242590f, 0.18169363f, -0.11944924f, 0.12754658f, 0.11321762f, -0.08573819f, -0.09037871f, 
    -0.07595269f, -0.06036481f, 0.07582009f, 0.04097652f, 0.18666387f, -0.01605436f, -0.00166410f, -0.09743407f, 
    -0.17634939f, -0.03156050f, 0.01772537f, 0.03340539f, -0.09866571f, -0.03062483f, -0.00525164f, -0.07710545f, 
    -0.07903801f, -0.00344771f, -0.17542544f, 0.31442684f, -0.03883754f, -0.04540716f, 0.10644287f, -0.03331592f, 
    -0.06904917f, -0.16307750f, 0.09824579f, -0.00165101f, -0.19354294f, 0.10820765f, 0.13697951f, 0.32877141f, 
    0.23079555f, 0.07021073f, -0.02250551f, -0.06392322f, -0.02927760f, -0.04469490f, 0.09116982f, -0.01507884f, 
    0.08288693f, -0.04161966f, 0.03313679f, -0.02266211f, -0.04735726f, 0.15317227f, -0.05047289f, -0.00765057f, 
    -0.08826479f, 0.01507266f, -0.10081165f, 0.04506809f, -0.23844674f, -0.11064423f, -0.13715905f, -0.11181714f, 
    0.05919692f, 0.00812913f, 0.03669582f, -0.00420758f, -0.04981757f, 0.01568848f, -0.05502911f, -0.01475578f, 
    -0.18832019f, 0.07793610f, -0.01645170f, 0.08766840f, -0.15580444f, -0.03185722f, -0.02763564f, -0.06430123f, 
    -0.02507373f, -0.08203232f, -0.09150535f, -0.13647485f, -0.02235370f, -0.16642712f, 0.03459796f, 0.01426615f, 
    -0.19572756f, 0.01324461f, -0.05994484f, 0.11221856f, -0.04683930f, -0.07281338f, -0.04531360f, -0.05640400f, 
    0.08719527f, -0.01677242f, -0.14824229f, 0.09365439f, -0.18727911f, 0.06887968f, -0.08165091f, -0.03049317f, 
    -0.03269660f, -0.04405771f, 0.04812991f, -0.14313123f, 0.13133173f, 0.25335807f, 0.15229146f, 0.01531017f, 
    0.12637281f, -0.03902372f, -0.12440988f, -0.02177058f, 0.02237059f, 0.11390805f, 0.05393741f, -0.06502909f, 
    0.08415251f, 0.14839099f, -0.14830008f, 0.06885617f, -0.07242103f, -0.08680579f, -0.09662400f, 0.01907452f, 
    0.01035327f, 0.00996028f, -0.05116215f, 0.06176477f, -0.32416454f, 0.10780422f, 0.00838932f, 0.08441102f, 
    0.01808733f, -0.07476659f, -0.04955751f, 0.20377150f, -0.07062984f, 0.11398902f, -0.07706603f, -0.02355698f, 
    0.00490348f, 0.04107303f, 0.01420379f, 0.05858712f, -0.02234199f, 0.08624607f, 0.03406068f, -0.05324060f, 
    -0.00219431f, 0.02847882f, 0.03318748f, -0.05205267f, 0.23413314f, -0.06101747f, 0.07840516f, 0.10284911f, 
    0.15949702f, -0.01252202f, -0.07885850f, 0.11754742f, 0.01033184f, -0.10702918f, 0.03257679f, -0.01606369f, 
    -0.23403709f, 0.09738878f, -0.05034439f, -0.00624538f, 0.12449386f, -0.00712606f, 0.07381036f, 0.11224248f, 
    0.06528564f, 0.17434542f, 0.12444207f, 0.06909054f, 0.21970667f, -0.29685965f, 0.19683482f, 0.12939540f, 
    0.03337911f, 0.06046207f, -0.01268856f, 0.06047287f, -0.04729087f, -0.01982688f, 0.14811581f, 0.04141570f, 
    0.04817560f, 0.06327219f, 0.07341399f, 0.10274465f, -0.16483711f, 0.05017373f, 0.01639979f, -0.08470969f, 
    0.03834514f, -0.10358463f, 0.04640975f, -0.07193764f, 0.21314949f, -0.04408424f, -0.01971700f, 0.13245380f, 
    -0.09455618f, -0.02313484f, 0.02917262f, 0.07171714f, -0.01852057f, 0.07671428f, 0.06510082f, -0.06398515f, 
    -0.02575108f, -0.03723251f, -0.27160707f, 0.12552640f, -0.12173608f, 0.00900299f, 0.02896254f, -0.01206511f, 
    0.00372061f, -0.15764168f, 0.19227411f, -0.11978523f, -0.28029218f, 0.16120534f, 0.00846987f, 0.10219397f, 
    0.01214521f, 0.07115947f, -0.06205031f, -0.01969203f, 0.17880642f, 0.07605521f, 0.05186116f, 0.13162193f, 
    -0.15044157f, 0.10930034f, -0.24363400f, 0.05459497f, -0.10844658f, -0.01639257f, -0.18827364f, -0.01589556f, 
    -0.04728381f, 0.00411862f, -0.17500901f, -0.12513323f, -0.04379345f, -0.23257932f, 0.11706455f, 0.21109496f, 
    0.13384561f, 0.09762638f, -0.00738013f, -0.04031358f, -0.21050657f, 0.03961141f, -0.01209468f, 0.03740174f, 
    -0.01535448f, -0.21909836f, -0.09942359f, -0.06493860f, -0.03022052f, 0.01519178f, 0.01326227f, 0.01926342f, 
    -0.11257614f, -0.10789047f, 0.14335695f, -0.05458763f, 0.48379380f, -0.21304542f, 0.18859585f, -0.01189585f, 
    0.11392115f, 0.02770143f, 0.16729783f, 0.15416946f, 0.02113095f, 0.07795085f, 0.07426119f, 0.08358007f, 
    0.06340610f, 0.03737868f, 0.03107034f, 0.06463921f, -0.11881046f, -0.05335383f, -0.09091093f, -0.03809556f, 
    0.08615024f, 0.05976395f, -0.02737157f, -0.05625835f, 0.21740873f, 0.24992892f, 0.11386766f, 0.00861757f, 
    0.03066371f, 0.03472914f, 0.03219941f, 0.02508423f, 0.03698207f, 0.01186499f, -0.00813633f, -0.04869101f, 
    -0.29159242f, 0.25348082f, -0.13726175f, 0.17166753f, 0.07428239f, -0.08182851f, 0.04971143f, -0.00485056f, 
    0.03532017f, -0.06255189f, 0.06166722f, 0.00997221f, 0.28038689f, 0.12960705f, 0.20765896f, 0.08816821f, 
    0.18126653f, 0.15806384f, -0.03959364f, 0.11934687f, -0.05834167f, 0.02940158f, -0.03946071f, -0.03867511f, 
    -0.06403214f, -0.05000494f, -0.00270749f, 0.20800929f, -0.05522771f, -0.15362462f, -0.01548395f, 0.09017745f, 
    -0.20269693f, -0.07665653f, 0.01093518f, -0.12294136f, -0.00496288f, -0.02933017f, -0.11565408f, -0.02922452f, 
    0.01180424f, -0.06779804f, -0.02863500f, -0.00815151f, -0.06316965f, -0.01527714f, -0.17779493f, -0.07990766f, 
    0.30325249f, -0.02320511f, 0.50856686f, -0.07172953f, -0.06493975f, 0.08867991f, -0.30237988f, 0.21708915f, 
    0.02685310f, -0.04636527f, 0.01987295f, -0.05466524f, 0.04201187f, 0.25276318f, 0.14398372f, 0.23805182f, 
    -0.01685260f, 0.20714653f, -0.00756863f, -0.05719758f, -0.04110515f, -0.03527065f, -0.00346036f, 0.05278914f, 
    0.27573869f, -0.16366115f, 0.39763385f, 0.04176711f, 0.09061486f, -0.06155644f, 0.03806915f, 0.16704524f, 
    0.13655280f, -0.19358373f, 0.20595595f, -0.08647501f, -0.03072843f, 0.24981430f, -0.02028625f, -0.05588541f, 
    0.09637956f, -0.03923288f, -0.01249075f, -0.11130584f, -0.02095691f, 0.06883720f, -0.06929475f, -0.04086846f, 
    0.03928290f, 0.22219345f, 0.03407253f, 0.12395871f, 0.03918512f, -0.06376450f, -0.03944112f, 0.03748789f, 
    0.06368930f, 0.06421760f, 0.03944844f, 0.01364708f, 0.04086141f, 0.02097696f, -0.01685191f, -0.01222496f, 
    0.05234574f, 0.03766062f, 0.00384614f, -0.04876106f, 0.12777184f, -0.04150760f, 0.07543433f, 0.04399867f, 
    -0.11495297f, -0.05603296f, 0.16768607f, 0.07764757f, -0.17094530f, 0.18598577f, -0.00767832f, -0.12665781f, 
    -0.04010770f, -0.08522569f, -0.00149040f, -0.04550489f, 0.18116575f, 0.14803283f, -0.07502674f, 0.04241459f, 
    -0.16993190f, -0.13082595f, -0.19362237f, -0.02231900f, -0.00601139f, 0.00358916f, -0.14246640f, 0.07849357f, 
    -0.03458750f, -0.03877120f, -0.03123055f, 0.01400664f, 0.00092917f, -0.00300060f, 0.01072181f, -0.01576482f, 
    0.00540058f, -0.01797589f, -0.03977889f, -0.03180419f, 0.01339955f, 0.02278992f, 0.01053957f, 0.00712089f, 
    -0.01976475f, -0.04101695f, 0.01912060f, 0.02449834f, -0.01957621f, 0.01061013f, -0.04377576f, 0.01518548f, 
    -0.00218022f, -0.00500406f, 0.02169457f, -0.00956444f, 0.01622545f, -0.01917113f, -0.00573832f, 0.01553349f, 
    -0.01916595f, 0.02149116f, 0.02639549f, -0.02573982f, -0.01157401f, -0.00112527f, 0.01341372f, -0.04042536f, 
    -0.02845773f, 0.00086521f, 0.00618173f, 0.00728757f, 0.01175829f, 0.01767237f, -0.02438708f, -0.01708689f, 
    -0.02642347f, 0.00943857f, 0.02923687f, 0.00612051f, 0.00789113f, -0.02852340f, -0.03243680f, -0.02790551f, 
    -0.01469945f, -0.00116656f, -0.03921414f, 0.02153866f, -0.02675255f, 0.01985796f, -0.02320924f, 0.00656236f, 
    0.02507327f, 0.00932531f, -0.02722345f, 0.02195429f, 0.01565382f, -0.04250982f, 0.00104443f, 0.02472166f, 
    -0.02510619f, 0.02734884f, -0.00910897f, -0.01363966f, 0.00045871f, -0.01927949f, 0.00792855f, 0.01035262f, 
    -0.00675288f, 0.00738285f, 0.00126002f, 0.01604133f, 0.00728180f, -0.03599016f, -0.03744974f, -0.00112840f, 
    0.00670979f, -0.00730795f, 0.01561975f, -0.00307645f, 0.01521173f, -0.00870657f, -0.01139127f, -0.03702563f, 
    -0.01851340f, -0.03261558f, -0.00516678f, -0.03611752f, 0.02675666f, -0.02225536f, -0.02623410f, 0.00799595f, 
    0.01730190f, 0.00483856f, 0.02462011f, -0.03738420f, -0.00326041f, -0.02517296f, -0.01975978f, -0.03397123f, 
    0.02662202f, 0.00047770f, -0.02557541f, -0.02281442f, 0.00606851f, -0.02166558f, 0.01929175f, -0.01032359f, 
    0.00838605f, 0.02611738f, -0.03355166f, -0.00746966f, 0.00116482f, -0.03261670f, -0.02706987f, -0.02578905f, 
    -0.01218162f, -0.02640949f, -0.04354960f, -0.03183553f, -0.03107101f, -0.03727949f, -0.00694187f, 0.02014456f, 
    0.00268823f, 0.02787969f, -0.02166167f, -0.01472796f, -0.01417849f, -0.00957498f, 0.02053289f, 0.00487443f, 
    -0.00301974f, -0.03021499f, 0.02296741f, -0.02248896f, -0.03133856f, -0.03322380f, 0.01309924f, -0.03671260f, 
    -0.02440967f, 0.00570589f, 0.00422975f, 0.01462825f, 0.02316031f, -0.02843352f, 0.01879492f, 0.01885204f, 
    -0.03948682f, -0.01683306f, -0.00914249f, 0.02445580f, -0.03245429f, -0.01825735f, -0.00307771f, -0.00775160f, 
    -0.03044332f, -0.04284462f, -0.00369693f, -0.04004141f, -0.00319578f, -0.04126846f, 0.01311336f, 0.00830027f, 
    0.01063378f, -0.03932339f, 0.00416567f, 0.00187682f, -0.01891515f, 0.01415987f, 0.00678878f, 0.01923848f, 
    0.00426330f, -0.01877658f, -0.00185843f, 0.00355496f, 0.00327121f, 0.00453843f, -0.01149299f, -0.03440021f, 
    0.02102559f, 0.00833570f, 0.01961334f, 0.01330152f, 0.01140654f, 0.01748758f, -0.01671982f, -0.00702282f, 
    -0.01723993f, -0.01340105f, -0.01048704f, 0.02058623f, 0.01268723f, -0.01688829f, -0.02234109f, 0.02173916f, 
    0.01587952f, -0.00125849f, 0.02041545f, 0.00852974f, -0.01321439f, -0.01303887f, -0.03194511f, -0.00783034f, 
    0.01745958f, -0.04040669f, -0.03956231f, -0.00838234f, -0.02385198f, -0.03575318f, -0.03960420f, -0.00308887f, 
    -0.02054846f, 0.00929815f, -0.00245024f, -0.02412673f, 0.00756378f, 0.01952298f, -0.03958866f, -0.03358127f, 
    0.02023976f, 0.01567124f, -0.01503265f, 0.00979187f, -0.03451262f, 0.01419356f, -0.00567960f, -0.00093694f, 
    -0.01996202f, -0.03525101f, 0.00063473f, -0.03947760f, -0.00017866f, -0.00154477f, -0.03729137f, -0.00280047f, 
    -0.01735861f, -0.03945668f, -0.00661206f, 0.01206542f, 0.00463053f, -0.01111108f, 0.02043251f, -0.01364802f, 
    -0.03870578f, 0.00867060f, -0.03657473f, -0.01928252f, 0.01097189f, -0.02533689f, -0.04112399f, -0.02545117f, 
    -0.03452156f, 0.00310993f, -0.01162238f, 0.02417006f, -0.03748394f, 0.01059153f, -0.01308274f, -0.01743401f, 
    0.01530446f, 0.01105583f, 0.02389030f, -0.02992488f, -0.03380788f, -0.03884085f, 0.00097522f, 0.01603993f, 
    -0.00714593f, 0.01841546f, 0.00866627f, 0.00433275f, -0.01224876f, 0.01299196f, -0.01423732f, -0.00023132f, 
    -0.02441651f, -0.02641641f, -0.00601116f, -0.01527955f, 0.02360811f, -0.03014212f, 0.00652879f, -0.02588647f, 
    0.00992137f, -0.02045023f, 0.01883354f, -0.01471785f, -0.01973357f, -0.04323736f, 0.00268872f, -0.02548281f, 
    0.02455338f, 0.00855832f, -0.02874003f, -0.02304937f, 0.01352138f, 0.01293936f, 0.01560921f, -0.00377900f, 
    -0.00376833f, -0.01214589f, -0.03081968f, -0.02384017f, -0.02442600f, 0.00511085f, -0.01486403f, -0.01814729f, 
    -0.01827770f, -0.00308514f, -0.01097017f, 0.00893064f, 0.00078756f, -0.00573105f, 0.00024093f, 0.02079852f, 
    0.01991118f, -0.03985992f, -0.02116396f, -0.02698111f, -0.01407854f, -0.03567994f, 0.01246942f, 0.02493290f, 
    -0.02074237f, -0.01743830f, -0.01884410f, -0.01649612f, 0.01606578f, -0.03772805f, -0.01361979f, -0.01645767f, 
    -0.02778906f, -0.00047381f, -0.03479026f, -0.02143961f, -0.01566397f, -0.00965088f, -0.00891776f, 0.02405016f, 
    -0.03902786f, 0.00940703f, -0.01990094f, 0.02173925f, 0.01151326f, -0.02355620f, 0.01590457f, 0.00222071f, 
    -0.03195613f, -0.04130351f, 0.01579453f, 0.00485401f, -0.02747914f, 0.01826400f, 0.00277236f, -0.00997055f, 
    -0.04217627f, 0.02409401f, -0.01220760f, -0.00171216f, -0.03907762f, -0.02556966f, 0.01409319f, 0.01804063f, 
    0.00161660f, -0.02868853f, -0.01899809f, -0.02007720f, 0.01379890f, 0.00874109f, -0.02648366f, 0.01811895f, 
    -0.01498652f, 0.01841439f, -0.02452253f, -0.01247638f, -0.03136385f, -0.04303754f, 0.01567368f, 0.01573650f, 
    -0.00556488f, -0.03448276f, -0.00359404f, -0.03059833f, -0.00354850f, -0.03646516f, -0.01642982f, -0.01114963f, 
    -0.01610718f, 0.02683222f, -0.01064747f, -0.00490767f, 0.01937762f, -0.04166491f, 0.02194601f, -0.02458446f, 
    -0.01943466f, 0.02223746f, -0.03116572f, 0.01182440f, -0.04213850f, -0.03651287f, -0.02238564f, -0.02498012f, 
    0.01943531f, -0.03124778f, 0.01882490f, -0.02245568f, 0.02414260f, -0.03517340f, -0.03293839f, 0.01862963f, 
    0.01757216f, -0.02048085f, -0.01953178f, 0.00319450f, -0.01141563f, -0.03673567f, 0.00056131f, -0.00359768f, 
    -0.02486037f, 0.01084945f, 0.02907611f, -0.00924486f, -0.00381248f, -0.03923359f, 0.00379712f, 0.02372964f, 
    -0.01195056f, 0.02650102f, -0.00546512f, 0.02393427f, 0.00033259f, -0.04047431f, -0.04278940f, -0.03842102f, 
    -0.02043442f, -0.00523509f, -0.02531336f, -0.01039178f, -0.02244220f, -0.04399274f, 0.00564233f, -0.03923678f, 
    -0.02771576f, -0.01283759f, 0.02118105f, -0.00908290f, -0.00378924f, 0.02426737f, 0.02251980f, -0.02031504f, 
    -0.03769850f, 0.00611766f, 0.01977331f, 0.00631983f, 0.00685475f, 0.02424860f, -0.03738331f, 0.01144778f, 
    0.02420061f, 0.02533834f, 0.01742994f, 0.01860843f, 0.00992927f, 0.01172764f, -0.03299339f, 0.02098179f, 
    0.01615415f, -0.01281027f, -0.02899563f, -0.03614955f, -0.01674170f, -0.00957617f, 0.01980392f, 0.00899518f, 
    -0.02554692f, 0.00895494f, -0.02791679f, -0.00711708f, 0.02486576f, -0.00859854f, -0.02102756f, -0.04324123f, 
    0.00047467f, 0.02506973f, 0.01221061f, 0.01077242f, 0.01488715f, -0.01353854f, 0.00623024f, -0.00224588f, 
    -0.00248282f, -0.02876405f, -0.03067200f, 0.02039894f, -0.03839080f, -0.01119906f, -0.00984845f, 0.01764813f, 
    -0.02766971f, 0.01483272f, -0.01443935f, 0.02035059f, -0.02040857f, -0.01471626f, 0.01702666f, 0.00919843f, 
    -0.00663736f, -0.00435721f, -0.03928203f, 0.00906130f, -0.00714687f, 0.01066868f, -0.03876312f, -0.00701817f, 
    0.00480869f, -0.01796469f, -0.02210989f, -0.02641161f, 0.01763448f, -0.03322906f, 0.00205565f, -0.00063836f, 
    -0.02122650f, -0.02439889f, 0.01272565f, -0.01939585f, 0.02020227f, -0.02151511f, 0.01296310f, -0.04011929f, 
    -0.02259041f, -0.01634811f, 0.01808186f, -0.02481045f, 0.02035600f, -0.02272843f, -0.02478489f, -0.03744030f, 
    0.02487551f, 0.00072211f, 0.00007827f, -0.01535318f, -0.02772670f, -0.02093400f, -0.02101559f, -0.02402726f, 
    -0.00065889f, 0.01611942f, -0.02370821f, 0.00644870f, -0.00876234f, -0.00229459f, -0.02719412f, -0.02664318f, 
    -0.03357574f, -0.00227731f, 0.01350093f, -0.03551324f, 0.02202201f, -0.03505617f, 0.00450618f, -0.04211949f, 
    -0.00742372f, -0.03176039f, -0.00816118f, -0.04063841f, -0.00580139f, -0.02017735f, -0.02446400f, 0.01709201f, 
    0.02388329f, -0.03470175f, 0.02024212f, 0.02115145f, -0.00900289f, -0.02678331f, 0.02162739f, 0.02107590f, 
    0.00760164f, -0.01827933f, -0.02340368f, 0.02411497f, -0.02991944f, -0.01078831f, 0.01278885f, 0.01601141f, 
    -0.02465730f, -0.04448096f, 0.01300209f, -0.00780748f, 0.01974033f, -0.00385445f, 0.01434060f, 0.00999522f, 
    0.01739618f, 0.02532240f, -0.01736790f, 0.00321477f, 0.00824101f, -0.03458540f, -0.03321946f, 0.01833293f, 
    0.01568187f, 0.01671810f, -0.02358350f, 0.02332581f, -0.03770586f, -0.00443779f, -0.01464970f, -0.02814318f, 
    0.02175608f, -0.00974068f, 0.00377270f, -0.02258580f, 0.00834543f, 0.00308879f, 0.02091701f, 0.00538648f, 
    0.00956416f, -0.01664833f, -0.01674332f, -0.02625863f, 0.00470111f, -0.02691824f, 0.00537368f, -0.02032135f, 
    -0.02451144f, 0.02658409f, 0.02944778f, -0.02934179f, -0.03620821f, -0.02915122f, -0.02002242f, -0.03561785f, 
    -0.03100603f, 0.02519324f, 0.01904714f, 0.01439965f, -0.01296655f, 0.02449947f, -0.00963878f, -0.02781618f, 
    -0.01858862f, 0.01605737f, 0.01692920f, -0.03062779f, 0.00865481f, -0.03581490f, 0.02226159f, -0.01002601f, 
    0.01927641f, -0.01851283f, 0.00521077f, -0.01379237f, -0.02205495f, -0.02752932f, 0.02396288f, 0.01090611f, 
    -0.01817681f, 0.00458724f, -0.03204427f, 0.02550006f, 0.02056007f, 0.00928203f, -0.03713343f, 0.01925491f, 
    0.01038564f, 0.01666843f, 0.00231790f, 0.02726656f, 0.01358413f, 0.01778375f, -0.03794424f, -0.01877923f, 
    -0.02429857f, 0.00057050f, -0.02819330f, 0.02554145f, -0.00051471f, -0.00457352f, -0.01861011f, -0.02875240f, 
    -0.03222205f, 0.01663149f, -0.03187999f, -0.01314941f, -0.00004696f, 0.01632176f, -0.00452298f, -0.03878029f, 
    0.00275125f, -0.03284441f, -0.03344729f, -0.02752847f, 0.00727777f, 0.01284324f, -0.02655965f, -0.00013738f, 
    0.02002463f, -0.03112854f, -0.00469156f, 0.00899872f, 0.01784622f, -0.02634972f, -0.00672800f, -0.01074075f, 
    0.01339016f, -0.03269888f, -0.00095743f, 0.01083980f, -0.02425907f, 0.00600875f, 0.02237387f, -0.02231367f, 
    -0.02570476f, -0.02204430f, -0.00892679f, -0.04154180f, -0.03831523f, 0.02180907f, 0.00676140f, 0.01068300f, 
    0.01897847f, -0.00531313f, -0.02403502f, 0.00544241f, 0.01369184f, -0.01540659f, -0.00389789f, 0.00762897f, 
    -0.02758729f, -0.03235148f, 0.02644966f, -0.01876224f, 0.02537165f, -0.02077680f, 0.00663552f, -0.01021667f, 
    0.01756174f, 0.00739397f, 0.00627225f, -0.03458288f, -0.04072374f, 0.00969247f, -0.00557224f, -0.04186654f, 
    -0.00456625f, 0.02014332f, -0.03230346f, 0.02204139f, -0.03674701f, -0.02333206f, -0.03890112f, -0.03770288f, 
    0.01739957f, 0.01537401f, 0.02490446f, 0.02203047f, -0.00110824f, 0.00325865f, -0.00769847f, -0.02801147f, 
    -0.01207094f, 0.00653541f, -0.00159792f, -0.03860268f, -0.02942966f, 0.02744102f, 0.00289840f, -0.03668634f, 
    -0.03866297f, 0.00897506f, -0.02275411f, -0.03344807f, -0.01008875f, -0.02941830f, 0.02233959f, -0.00690820f, 
    0.00136490f, -0.01779133f, 0.01364443f, 0.00766381f, 0.03773960f, -0.01264129f, 0.02279578f, -0.00755889f, 
    0.02035990f, -0.02591804f, 0.00600381f, -0.00962190f, 0.02859516f, -0.02256609f, -0.01458101f, -0.01597139f, 
    0.02866338f, -0.00202397f, -0.02869524f, 0.02590225f, -0.02145438f, -0.00108878f, 0.03020190f, 0.01952594f, 
    0.02735247f, -0.03241685f, 0.01260563f, 0.02946363f, -0.00601025f, 0.00554389f, 0.00060176f, -0.00125627f, 
    0.01909056f, 0.02905782f, -0.00038189f, 0.02459722f, -0.02973059f, -0.03328973f, -0.03280265f, 0.01102591f, 
    -0.02599146f, 0.00985408f, 0.01103407f, -0.04146281f, 0.01857928f, 0.00525423f, -0.03410859f, 0.02495986f, 
    -0.03107048f, 0.00012458f, 0.02588047f, 0.01507463f, -0.03145913f, 0.00891340f, -0.02982560f, -0.04110901f, 
    -0.01909507f, -0.03026737f, 0.02585065f, -0.01220109f, -0.01114901f, 0.02802984f, -0.01034627f, 0.00595290f, 
    -0.03106203f, -0.02309272f, -0.04090803f, -0.02194848f, -0.01863180f, -0.03208698f, -0.04125940f, 0.00256808f, 
    0.02408028f, 0.00353666f, -0.02360155f, -0.00455075f, 0.02694388f, -0.03163667f, -0.00486700f, -0.00760803f, 
    0.02291935f, 0.01864097f, -0.03779119f, 0.01141948f, -0.01492465f, 0.01528557f, -0.00575866f, -0.01123538f, 
    -0.00877267f, -0.00911978f, -0.00170203f, 0.02631336f, -0.01160876f, 0.01502557f, -0.00999592f, 0.01888229f, 
    0.00877816f, 0.00909426f, 0.00304163f, -0.03973684f, 0.01843471f, 0.00089464f, 0.01735054f, -0.01629004f, 
    0.02370418f, 0.01814808f, 0.00910251f, -0.04125327f, -0.02289720f, 0.01963465f, -0.00479970f, -0.00495305f, 
    0.02199782f, -0.00276787f, -0.00416103f, -0.00973626f, 0.02974252f, -0.00123623f, -0.00556201f, -0.02176947f, 
    -0.00401638f, 0.02637998f, -0.02835770f, -0.03602813f, -0.00409234f, -0.03337377f, -0.00286242f, -0.02300625f, 
    -0.02152407f, 0.02845832f, 0.02515155f, -0.03006505f, -0.03671063f, -0.00669538f, 0.01947827f, 0.03412158f, 
    -0.00283590f, 0.00300487f, 0.00737524f, -0.00241732f, -0.02000537f, 0.03074030f, -0.02297054f, 0.03873023f, 
    0.00612444f, -0.02767442f, 0.02094324f, -0.00770888f, -0.01246840f, -0.02114444f, -0.01085601f, 0.02449474f, 
    -0.03478407f, 0.02906916f, -0.00907906f, -0.00566916f, 0.01370000f, -0.03041373f, -0.01858094f, -0.01031609f, 
    -0.00824227f, 0.01528141f, -0.00210534f, -0.01720065f, -0.01760606f, 0.00066542f, -0.02591162f, -0.00503275f, 
    -0.02062299f, 0.01553538f, -0.02514448f, -0.03036544f, -0.02589564f, -0.02979593f, 0.00691256f, 0.00264143f, 
    -0.00660211f, -0.02365914f, -0.01142189f, -0.02830266f, -0.04108705f, -0.01288010f, -0.02636769f, -0.01208179f, 
    -0.01777115f, -0.03079996f, 0.02662575f, -0.03713796f, 0.02640763f, -0.03518338f, 0.01386144f, -0.03447291f, 
    0.00707416f, -0.00407014f, -0.01011988f, -0.00612205f, -0.04159107f, -0.03581786f, -0.01780897f, -0.01951793f, 
    -0.00098519f, 0.03928757f, -0.00973078f, -0.02409123f, 0.01188355f, 0.01613706f, 0.00814375f, 0.01741809f, 
    -0.03799350f, -0.00417863f, 0.01966620f, -0.03969603f, 0.02181282f, -0.02663701f, -0.01187662f, -0.00961943f, 
    0.02669756f, -0.00922503f, -0.01653470f, 0.01346737f, -0.02591160f, 0.01994592f, 0.02428500f, -0.00774645f, 
    0.01334906f, -0.00760310f, 0.00969368f, 0.00699180f, -0.02550693f, 0.00481767f, -0.04205298f, 0.01039827f, 
    -0.01235615f, 0.01564305f, 0.00327029f, -0.03202070f, -0.00594734f, 0.01092233f, -0.04206163f, -0.01150030f, 
    0.00577117f, -0.02163186f, 0.04077058f, 0.01625002f, -0.02872690f, 0.02087330f, -0.00647612f, -0.03439190f, 
    -0.02340492f, -0.01528709f, -0.00519995f, 0.02907302f, 0.01687166f, -0.00850075f, 0.00355194f, 0.00768371f, 
    -0.01974402f, 0.01482978f, -0.01421096f, -0.03093148f, 0.02268622f, 0.02044072f, -0.02368575f, -0.01519753f, 
    0.00820776f, 0.01377309f, 0.01601586f, 0.01773432f, 0.03125283f, 0.02278280f, 0.01231937f, -0.02903545f, 
    0.03842588f, -0.02804497f, 0.02307164f, 0.00183654f, -0.01491648f, -0.01849167f, -0.02838848f, -0.04078075f, 
    -0.02582981f, 0.00634180f, -0.00228120f, 0.01443817f, 0.00656389f, 0.02797164f, 0.02024039f, 0.01508940f, 
    -0.04038152f, -0.04127583f, -0.02557305f, 0.01391879f, 0.02138050f, -0.02128089f, -0.00924406f, -0.00050372f, 
    -0.03114477f, -0.04096763f, 0.02866365f, -0.01527295f, -0.00455074f, 0.01297783f, 0.00958567f, -0.03811030f, 
    -0.03408867f, 0.00282107f, 0.02957176f, -0.01896421f, -0.02996905f, -0.01142142f, -0.03307328f, -0.02772762f, 
    0.00793874f, 0.00115881f, -0.00976629f, -0.03951788f, -0.00394409f, -0.03963004f, 0.01182238f, -0.02678337f, 
    0.00344950f, -0.04091077f, 0.01494482f, -0.02896338f, -0.02273592f, 0.02937468f, 0.01947480f, 0.01142076f, 
    -0.02586598f, -0.04127946f, -0.03080655f, 0.01997153f, -0.02723733f, -0.03846768f, -0.00500412f, -0.03461193f, 
    -0.01531023f, -0.00720445f, -0.00662648f, -0.04018103f, 0.02801793f, -0.03558562f, 0.00761381f, -0.03280750f, 
    -0.00043362f, 0.00141398f, -0.02045750f, -0.01233425f, 0.03681437f, 0.02090780f, -0.00674771f, 0.01885159f, 
    -0.00299859f, -0.04186438f, 0.02651786f, -0.01849173f, -0.02458389f, 0.02836517f, 0.02207943f, -0.00434157f, 
    0.00172159f, -0.00471289f, -0.02139931f, -0.03890913f, -0.01461933f, 0.00421730f, 0.01934662f, -0.02268450f, 
    -0.00259365f, -0.03059423f, 0.00636559f, -0.02003571f, 0.02107736f, 0.00223708f, 0.00077038f, -0.00598714f, 
    0.01155662f, -0.02476544f, -0.03777525f, 0.00169620f, 0.00642623f, 0.02863945f, -0.01916873f, 0.02967431f, 
    -0.03293071f, -0.00748810f, -0.02089820f, -0.04167364f, -0.01069811f, -0.01958505f, -0.01801948f, 0.02685379f, 
    -0.03270105f, 0.01721675f, -0.01025335f, -0.01931540f, -0.03861141f, 0.02030886f, -0.00963612f, -0.01821915f, 
    0.02185593f, 0.00014837f, -0.00936664f, 0.00978813f, -0.02156798f, -0.02040402f, -0.00718833f, 0.02248501f, 
    0.02217356f, -0.03365530f, 0.00840571f, 0.01104385f, 0.02405385f, -0.03712353f, 0.00584353f, -0.03744580f, 
    0.02575860f, 0.02965588f, 0.02702320f, 0.02614397f, -0.03285364f, 0.02124762f, 0.01497027f, 0.00032098f, 
    -0.02011590f, 0.01334449f, -0.00540887f, 0.00989279f, -0.03583610f, 0.02376728f, -0.01788039f, -0.02662121f, 
    -0.03637032f, 0.02529428f, -0.01212043f, -0.03626893f, -0.01933895f, -0.00413991f, -0.02377942f, -0.03744208f, 
    -0.03913520f, -0.00590145f, 0.02497177f, -0.01916748f, -0.03721410f, 0.00702914f, -0.03517374f, -0.01974801f, 
    -0.00022770f, -0.02907487f, -0.04181888f, 0.02254631f, 0.00746180f, -0.01644522f, -0.03583721f, 0.02069628f, 
    -0.01597268f, 0.02638014f, -0.02714032f, -0.00474029f, -0.00777812f, 0.01955877f, -0.00229367f, -0.00151981f, 
    0.02282503f, -0.04020818f, 0.01070788f, -0.02669812f, 0.01276445f, -0.02295588f, 0.01117826f, 0.00893094f, 
    -0.02731429f, 0.00547525f, -0.01275257f, -0.03727363f, -0.02476399f, -0.03564084f, -0.00751912f, -0.00819669f, 
    -0.03938283f, 0.00580860f, -0.00464252f, -0.00356195f, -0.00394951f, 0.00984803f, 0.00382675f, -0.04206450f, 
    -0.03071955f, -0.00190630f, -0.02598378f, -0.01588790f, 0.00043955f, -0.03136588f, 0.00242122f, -0.03828599f, 
    0.01165840f, 0.02253662f, 0.01192987f, 0.02750133f, -0.02708671f, -0.01024988f, -0.00946465f, 0.02469246f, 
    0.01139651f, -0.02149895f, 0.00058319f, -0.01144155f, -0.03436139f, -0.01273633f, -0.03691244f, 0.01548420f, 
    -0.02235438f, -0.03009192f, -0.02512246f, -0.00074674f, 0.01622614f, 0.02599608f, -0.02848591f, -0.02636580f, 
    -0.00227053f, 0.01603335f, 0.01639043f, 0.00020355f, -0.03640602f, -0.02657410f, 0.01125959f, -0.01881785f, 
    -0.00670139f, -0.00864205f, -0.04148474f, -0.00306530f, -0.02307171f, 0.02807724f, -0.02801028f, -0.00834196f, 
    -0.00233127f, -0.01433273f, 0.01918732f, 0.01736319f, 0.00564427f, -0.03171257f, -0.00776892f, 0.01140024f, 
    -0.01127805f, -0.01184926f, -0.02939670f, 0.01103053f, -0.03705772f, -0.02594399f, 0.02281219f, 0.01371127f, 
    -0.02056564f, 0.01485161f, 0.00496938f, -0.00094289f, -0.02993427f, 0.00719115f, 0.00617605f, 0.01497625f, 
    -0.03670687f, 0.02131103f, -0.04040791f, 0.02080798f, 0.02393399f, -0.02827708f, 0.02741496f, -0.01659061f, 
    -0.03460721f, 0.04179645f, -0.00618658f, 0.00983881f, -0.02868788f, -0.02446369f, 0.00431494f, -0.01311363f, 
    0.01865955f, 0.01293279f, 0.02823791f, 0.00953824f, -0.01841005f, -0.01998313f, 0.00192819f, -0.03943624f, 
    0.01391607f, -0.01524195f, -0.02647102f, 0.02268863f, 0.02743490f, 0.01190925f, -0.03402843f, -0.01979921f, 
    -0.01735809f, 0.02755530f, -0.01074627f, 0.01221083f, -0.02674627f, -0.00469149f, -0.00933314f, -0.01607123f, 
    -0.03975121f, 0.02663227f, -0.04127433f, -0.02792632f, -0.02508363f, -0.02547671f, -0.00726830f, -0.03847257f, 
    -0.02291264f, 0.02152502f, 0.02025448f, -0.01257365f, -0.03041722f, -0.00396713f, -0.01542797f, -0.00456641f, 
    0.02175127f, 0.00625687f, 0.01411444f, -0.01620730f, -0.01323947f, -0.02856868f, 0.03500164f, -0.02172852f, 
    -0.03824435f, 0.00981598f, -0.02972285f, 0.00604995f, -0.03044469f, -0.02799175f, -0.02071548f, -0.00720963f, 
    -0.01033171f, 0.02082364f, -0.01216866f, -0.01091546f, 0.01669546f, 0.00621254f, -0.01108387f, -0.01621827f, 
    -0.01179384f, -0.01889795f, 0.02364457f, 0.02439687f, 0.00878094f, -0.00486668f, -0.03352930f, -0.00310739f, 
    -0.01691187f, 0.00280812f, 0.01878320f, 0.00446899f, -0.04186906f, -0.01986579f, 0.02577640f, 0.01143401f, 
    0.00691241f, -0.00728852f, -0.04130529f, -0.00386011f, -0.02713512f, 0.01632304f, 0.02906353f, -0.02493046f, 
    0.00492095f, -0.00617653f, 0.01696532f, -0.01237402f, -0.03046284f, 0.02744258f, 0.00294038f, 0.01572026f, 
    -0.01645251f, 0.00476709f, 0.01401797f, -0.01495737f, -0.03946868f, 0.01283918f, 0.00532146f, 0.00957075f, 
    0.02943050f, 0.02508256f, -0.03148722f, 0.00178649f, -0.01414971f, 0.01694326f, -0.00892087f, -0.00684295f, 
    0.02188950f, -0.03099903f, -0.00887262f, -0.01442193f, 0.01804167f, -0.02773447f, -0.03885229f, -0.03880971f, 
    0.01558257f, -0.01669077f, 0.02516583f, -0.02704775f, -0.00697581f, -0.03243627f, 0.01810478f, -0.03363021f, 
    0.00589658f, -0.02701786f, -0.01882574f, -0.00956946f, 0.01663202f, 0.01423842f, 0.02079345f, -0.01901031f, 
    -0.02902283f, 0.01377226f, -0.00846264f, -0.02598845f, -0.03389351f, -0.00238634f, -0.04170435f, -0.00159706f, 
    0.02049784f, -0.03648130f, -0.03725496f, -0.01769527f, -0.00440865f, -0.01534255f, 0.01726699f, 0.02169260f, 
    0.02669422f, -0.01008287f, 0.00842209f, 0.00751089f, -0.00451327f, 0.02441972f, -0.00252564f, -0.02079712f, 
    -0.03294076f, 0.02270059f, 0.03771208f, 0.01724926f, -0.02213436f, 0.00255129f, -0.00228553f, 0.01752743f, 
    -0.08699398f, 0.41639048f, 0.18298118f, -0.22571278f, 0.09594363f, 0.05198234f, 0.11405924f, 0.24081706f, 
    0.05502722f, -0.01897950f, 0.03147444f, 0.14736287f, -0.09736755f, -0.11470900f, -0.06218470f, -0.00316500f, 
    -0.02903615f, -0.02656075f, 0.01468540f, -0.08193818f, 0.12457842f, 0.11348701f, 0.05099534f, 0.16774614f, 
    -0.14427467f, 0.03094669f, 0.06432638f, 0.02836248f, 0.02769562f, 0.00571591f, 0.04427725f, 0.10288220f, 
    0.00550017f, -0.18857083f, -0.14271162f, -0.34326649f, -0.08139884f, -0.12013991f, -0.09100816f, 0.02127004f, 
    -0.12425928f, -0.12908025f, -0.11610138f, -0.05993483f, 0.15896925f, 0.12633896f, 0.07943846f, 0.26210850f, 
    0.13475540f, 0.02295235f, 0.04217608f, -0.13550919f, 0.06481271f, 0.00839837f, 0.11529831f, 0.10733064f, 
    -0.03833935f, 0.06681993f, 0.05965216f, -0.01513157f, 0.04791595f, -0.04770407f, -0.21418633f, -0.01703845f, 
    0.05532936f, -0.16507821f, -0.06287957f, 0.07818504f, 0.10219793f, -0.00047225f, 0.17995088f, 0.04107311f, 
    0.20240271f, 0.01747713f, 0.04898114f, 0.04872505f, 0.04119935f, -0.00834520f, 0.06697594f, -0.10098899f, 
    -0.07240219f, -0.07042905f, 0.02074611f, 0.08679367f, 0.05528209f, -0.15157349f, -0.11752930f, 0.06222001f, 
    -0.04862525f, -0.06449836f, 0.04471246f, 0.08371175f, -0.09775823f, -0.14338207f, -0.04006028f, -0.07452682f, 
    0.52453464f, 0.07445889f, -0.02256450f, -0.23333383f, 0.09703635f, 0.10297096f, 0.04881837f, -0.06038435f, 
    0.07896178f, 0.14701837f, 0.03496060f, 0.05456636f, 0.24723780f, -0.04667015f, -0.03715810f, 0.05141212f, 
    0.00519076f, -0.04033523f, -0.05134950f, 0.06448198f, -0.05987850f, -0.05313019f, 0.03036333f, -0.04934274f, 
    0.21586359f, 0.07817420f, -0.09525552f, 0.05746966f, 0.04663065f, -0.23149817f, 0.01782818f, 0.13169639f, 
    -0.22793505f, -0.02043815f, -0.02209962f, 0.03995027f, -0.07787388f, 0.01922038f, 0.07656146f, -0.01543892f, 
    0.01488931f, -0.18247543f, -0.04176901f, 0.03443777f, 0.08266182f, 0.02446165f, 0.01852270f, 0.12297064f, 
    0.00791545f, -0.08262747f, 0.15633123f, -0.06241157f, 0.00351410f, 0.08802012f, 0.02151945f, 0.03301632f, 
    0.05349071f, -0.13323314f, -0.12131004f, -0.04007486f, -0.23076175f, -0.04641440f, 0.01014577f, -0.01845105f, 
    -0.01312005f, -0.03756762f, -0.08574720f, 0.25656712f, 0.03311672f, 0.02395868f, 0.09035823f, -0.01808698f, 
    0.02764838f, -0.13404122f, -0.05042087f, -0.02599251f, 0.00741182f, 0.13736831f, 0.03887802f, 0.08101389f, 
    -0.01058965f, -0.09653734f, -0.11169736f, -0.33169079f, 0.14283547f, -0.22298084f, -0.27886266f, 0.08239885f, 
    0.12672414f, 0.02467643f, -0.02446487f, -0.07824884f, 0.00706368f, 0.00923914f, -0.02331171f, 0.01306653f, 
    0.11693417f, 0.06564394f, 0.01434297f, -0.07221141f, 0.13272946f, 0.06889182f, 0.06182864f, -0.02943058f, 
    -0.03365035f, 0.04645519f, -0.03253702f, -0.01267687f, -0.08179930f, 0.02104874f, -0.14100614f, 0.00641148f, 
    0.03239631f, -0.08325098f, 0.05582814f, -0.03032023f, 0.05066848f, -0.04354066f, 0.04324000f, 0.15674980f, 
    0.02476202f, -0.20463894f, 0.09552595f, 0.20556161f, 0.05148279f, -0.08950504f, -0.04781377f, 0.07121582f, 
    -0.03205311f, -0.05352048f, -0.00896471f, 0.16003732f, -0.06757819f, 0.12930730f, -0.13495524f, -0.11162512f, 
    0.11545938f, -0.10883003f, 0.09541649f, 0.03750779f, 0.05810919f, 0.14357169f, 0.05238155f, 0.17530602f, 
    0.13140152f, 0.12908927f, -0.15318854f, -0.21534996f, 0.05989823f, -0.03103960f, 0.03229925f, -0.02365675f, 
    0.11627130f, -0.12183327f, -0.00509908f, -0.02780889f, -0.27389672f, -0.15802602f, 0.12224445f, 0.03225616f, 
    0.01090798f, 0.04810593f, -0.04110765f, -0.00446705f, 0.11310263f, 0.22920769f, 0.16441067f, 0.24944983f, 
    -0.07173651f, -0.18694112f, 0.08692188f, -0.12216683f, -0.02685795f, 0.00900384f, -0.11999250f, 0.06841780f, 
    0.02565721f, -0.09652738f, 0.03795495f, -0.22070763f, -0.07650725f, -0.22949474f, -0.05930726f, 0.05014746f, 
    -0.07893252f, -0.08440343f, -0.01071731f, -0.09706924f, 0.02143160f, -0.05615555f, -0.02778824f, 0.26214644f, 
    -0.11843335f, -0.04936193f, -0.02543041f, 0.02720025f, 0.00513205f, 0.06568755f, 0.00941241f, -0.00813657f, 
    -0.09254920f, -0.07607420f, -0.13130958f, -0.00479299f, -0.16000947f, -0.16140430f, -0.12844940f, -0.05428128f, 
    -0.05454747f, -0.14272468f, -0.14197733f, -0.13063432f, -0.12749569f, -0.04285070f, -0.09795705f, -0.04867168f, 
    -0.02149677f, 0.15506144f, 0.03403390f, -0.06196102f, 0.12042399f, -0.04689030f, 0.07294351f, 0.10570414f, 
    -0.04669829f, 0.06395599f, -0.00680532f, 0.12069423f, 0.22308396f, -0.02275691f, -0.20742212f, 0.02475172f, 
    0.06422012f, 0.07052187f, 0.12523164f, 0.02404618f, 0.03048911f, 0.06656750f, 0.04224721f, 0.05327965f, 
    0.28276819f, -0.05972519f, -0.25527081f, 0.01373206f, -0.10054928f, 0.02025069f, 0.04403441f, 0.06944976f, 
    0.15585688f, 0.00507361f, -0.17371534f, -0.08663271f, 0.07738131f, -0.04827720f, 0.09368175f, 0.04027855f, 
    -0.04857666f, 0.01076030f, 0.02029623f, 0.06901674f, -0.02076233f, -0.01331270f, -0.04631005f, -0.03096072f, 
    0.11128605f, -0.16551536f, 0.10204899f, -0.03087441f, 0.09020525f, 0.04855980f, -0.10104959f, 0.10017394f, 
    0.06153672f, 0.02254936f, 0.09791557f, 0.02641039f, -0.04926107f, -0.06773386f, -0.03965396f, 0.13556108f, 
    -0.07879049f, -0.12337577f, -0.06243584f, -0.00996676f, 0.00242944f, -0.06439139f, 0.09876819f, 0.22417918f, 
    -0.07998738f, -0.07182243f, -0.15251090f, -0.12529875f, 0.03039238f, -0.00212185f, -0.03356093f, 0.00259061f, 
    0.08925000f, -0.03928600f, 0.15392677f, -0.02830944f, -0.09918488f, 0.08531993f, -0.09471070f, -0.01991987f, 
    0.03567962f, 0.09629597f, -0.03847172f, -0.01439022f, -0.02212408f, 0.06906569f, 0.08959177f, 0.06275005f, 
    0.06737064f, 0.01377978f, -0.13003202f, 0.05086042f, 0.13485949f, -0.03892520f, 0.01657477f, 0.15222034f, 
    0.10710855f, -0.06705838f, 0.16152042f, 0.18679509f, 0.06044163f, 0.04563053f, -0.15840106f, -0.03137455f, 
    0.12861438f, 0.22675999f, 0.03460504f, -0.18389840f, 0.03706282f, 0.03491747f, 0.06106911f, 0.06216612f, 
    0.00810329f, -0.03263215f, -0.12122893f, -0.10550323f, 0.19071943f, 0.10319132f, 0.04678050f, -0.03121905f, 
    0.04837357f, 0.03747445f, 0.01502476f, -0.01552319f, 0.22446270f, -0.01653959f, -0.21397497f, 0.03643813f, 
    0.14306787f, 0.04716421f, -0.01068584f, 0.12051699f, 0.19954379f, 0.02429802f, 0.13228892f, -0.01666769f, 
    -0.10245903f, -0.03947299f, -0.04726813f, -0.10330167f, 0.08770701f, -0.02280250f, 0.06823581f, -0.12359509f, 
    0.01132909f, -0.02468151f, -0.06813909f, 0.02659036f, 0.21812338f, 0.01277090f, -0.09645567f, -0.01901798f, 
    0.11817096f, 0.14420761f, -0.05540539f, -0.04309129f, 0.03745380f, 0.09896818f, 0.10228824f, 0.11407210f, 
    -0.18499380f, -0.01722617f, -0.20644237f, -0.07583666f, 0.04562308f, 0.09631710f, -0.10617936f, -0.00884546f, 
    -0.00723167f, -0.03054499f, 0.05136980f, -0.09313035f, 0.11376202f, 0.11513456f, -0.14289713f, -0.46434566f, 
    0.16197863f, -0.11987815f, -0.00588768f, 0.03668610f, -0.08966880f, 0.00804904f, 0.09410283f, -0.01382406f, 
    0.06474064f, -0.10866980f, 0.05773863f, -0.08156303f, -0.03157395f, 0.02208150f, 0.00732328f, 0.17551437f, 
    0.07748228f, -0.10217885f, -0.01459475f, -0.01995927f, -0.10812144f, -0.18213116f, -0.00756921f, -0.09797454f, 
    0.01420192f, 0.05093600f, -0.02044241f, -0.08309042f, -0.12210584f, 0.04121128f, 0.13148530f, -0.04163693f, 
    0.16371648f, 0.06957491f, -0.01381961f, 0.00621069f, -0.05921284f, 0.01059084f, -0.11908632f, -0.02971986f, 
    0.13545127f, -0.03287440f, 0.04502281f, 0.08659732f, -0.25208244f, 0.06861590f, -0.07754165f, -0.22151631f, 
    -0.03768343f, -0.07574217f, 0.01993240f, -0.00548892f, -0.00337300f, -0.02898707f, -0.01775957f, 0.06927371f, 
    0.08086435f, 0.16506545f, -0.06427605f, -0.04029550f, 0.02169585f, -0.02769931f, 0.17491153f, -0.07007415f, 
    0.23676291f, 0.05612368f, 0.19801089f, 0.13176854f, -0.07614855f, 0.07808489f, 0.00319966f, 0.07743579f, 
    0.08310460f, 0.19475488f, -0.10974033f, 0.13074459f, 0.12525295f, -0.04069985f, 0.07381268f, 0.14810234f, 
    -0.10468389f, 0.06270467f, -0.08784664f, -0.03245777f, -0.01242720f, -0.06504648f, -0.04972943f, -0.02393242f, 
    0.01706186f, 0.14622350f, 0.21107446f, 0.22110352f, -0.02753354f, 0.01023190f, 0.06217368f, 0.04149800f, 
    0.08566628f, -0.00963733f, 0.06547826f, -0.01056509f, -0.10013156f, 0.00401186f, -0.09882233f, -0.09239172f, 
    -0.07636864f, -0.08834134f, -0.10488996f, -0.07915795f, -0.04500220f, -0.04845469f, 0.00741081f, 0.15965888f, 
    -0.04925223f, -0.02570169f, 0.09648149f, 0.02584817f, -0.04225259f, -0.04034900f, -0.06268007f, -0.09267040f, 
    0.08517175f, 0.21345437f, 0.05451636f, -0.03143794f, -0.01324197f, -0.03681466f, 0.03176285f, 0.00941276f, 
    -0.05561683f, -0.11385343f, -0.04852966f, -0.05706471f, 0.04306587f, -0.02499478f, -0.05678407f, 0.01095168f, 
    -0.06521494f, 0.03404231f, -0.08936376f, 0.04364517f, 0.12095761f, 0.18361911f, -0.08857891f, -0.08669920f, 
    0.04984783f, 0.00828418f, 0.06466862f, -0.24739200f, 0.01215130f, 0.02678347f, 0.00681031f, 0.04336911f, 
    0.10298899f, -0.02332440f, -0.25624913f, 0.15860014f, 0.06621208f, 0.14852001f, 0.04323545f, 0.06750191f, 
    0.12582158f, -0.02929641f, -0.01849593f, 0.13033438f, -0.10288462f, -0.06771005f, -0.03897875f, 0.02022720f, 
    -0.00966997f, -0.01339872f, 0.01418646f, -0.00320677f, 0.16245227f, 0.00752627f, 0.19515717f, 0.03684047f, 
    0.03561436f, -0.05670689f, -0.10773110f, 0.05915784f, 0.13390474f, -0.02042622f, 0.09362704f, -0.00541779f, 
    0.08844890f, -0.01291556f, -0.01406204f, 0.16610041f, -0.02179336f, -0.07266283f, -0.24322402f, -0.07346365f, 
    0.03924400f, 0.05519795f, 0.05358736f, -0.00014101f, -0.06962727f, -0.02644961f, 0.05017045f, 0.09556398f, 
    -0.00188186f, -0.13319547f, 0.01598960f, 0.36457267f, -0.02197750f, 0.15483636f, 0.11654902f, -0.02997189f, 
    -0.03665628f, 0.01732383f, 0.19891848f, 0.22990718f, -0.30558261f, -0.25647631f, 0.22002770f, -0.13065562f, 
    0.01507304f, 0.03148643f, 0.01087304f, -0.01386775f, 0.04982125f, 0.16028187f, 0.07137053f, 0.14833467f, 
    -0.47271812f, -0.06329077f, 0.00824522f, -0.15135506f, 0.09199943f, 0.14667934f, 0.07203685f, -0.00745339f, 
    0.03818668f, -0.00519182f, -0.05889481f, -0.12761918f, -0.15459478f, -0.05776562f, -0.11073967f, -0.15453784f, 
    -0.02762925f, -0.03530736f, 0.02799896f, -0.00539422f, -0.11336946f, -0.02614953f, -0.03607527f, 0.13276893f, 
    0.31780425f, 0.23423558f, -0.10961983f, -0.10495818f, 0.20014554f, -0.07319293f, -0.11755033f, -0.00825463f, 
    -0.10487552f, 0.06612799f, -0.00613228f, 0.00471961f, -0.07480419f, -0.01940436f, -0.02616920f, -0.01315948f, 
    0.24036729f, 0.09804380f, -0.02235995f, 0.23824570f, 0.24864423f, 0.00160780f, -0.06273939f, -0.03837631f, 
    0.00172184f, -0.02180729f, -0.01628218f, -0.00090411f, -0.04192448f, -0.00968358f, 0.00867170f, 0.01182721f, 
    -0.00468180f, -0.03598620f, -0.00594406f, 0.00307806f, -0.02304961f, 0.00859883f, -0.03659914f, 0.02238931f, 
    -0.03574857f, -0.02058430f, 0.01783321f, 0.00978548f, -0.00684423f, -0.04576089f, -0.04185162f, 0.00465516f, 
    -0.01866916f, -0.03926729f, 0.00979756f, -0.00851417f, -0.01944840f, 0.01152172f, -0.01571361f, -0.01992233f, 
    0.02492495f, -0.03663080f, 0.02608558f, -0.02174846f, -0.01329691f, 0.02101401f, 0.02917977f, 0.01404728f, 
    -0.02663688f, -0.00739519f, -0.03556475f, 0.01879919f, -0.02175508f, -0.02822357f, 0.00061385f, -0.04122780f, 
    -0.02275685f, 0.02043070f, -0.03537213f, -0.00253345f, 0.02203028f, -0.02655469f, 0.01078840f, -0.00893568f, 
    -0.03967144f, -0.00543141f, 0.01427580f, 0.00378440f, -0.00389426f, 0.02035622f, -0.01621130f, -0.03509954f, 
    -0.02005483f, -0.03759552f, 0.02233530f, -0.02926757f, -0.04112022f, -0.01459923f, -0.03242911f, -0.01587455f, 
    0.00237774f, -0.03714707f, 0.02763386f, -0.00470523f, 0.02102138f, -0.02010527f, -0.00691875f, -0.02517482f, 
    0.01856058f, -0.00756250f, 0.00655209f, 0.01534491f, -0.01488398f, -0.01488531f, -0.02941598f, 0.01572911f, 
    0.03202387f, 0.00233864f, -0.00511504f, 0.01876710f, -0.00911788f, 0.01216870f, -0.02320881f, -0.01628951f, 
    0.02066728f, -0.03131197f, 0.03091808f, -0.03250656f, -0.01151885f, -0.00903443f, 0.02153482f, -0.02620909f, 
    -0.01144869f, -0.01059981f, 0.02319116f, -0.00373868f, -0.03402241f, 0.01312499f, 0.00992816f, 0.00088589f, 
    -0.01793506f, -0.03503665f, -0.01236404f, -0.00921234f, 0.01276843f, -0.01258720f, -0.04474080f, -0.00832829f, 
    0.00100723f, -0.02969895f, -0.02704376f, -0.02358801f, -0.01529896f, -0.01129933f, 0.00900745f, -0.02455185f, 
    -0.00430316f, 0.02538840f, -0.02350194f, 0.00373725f, 0.00911210f, 0.01761511f, -0.01253774f, -0.03050097f, 
    0.00472613f, 0.02329779f, 0.01214794f, -0.03663804f, -0.04355402f, 0.01168144f, 0.02225640f, 0.01160847f, 
    -0.00090380f, -0.03544895f, -0.00086059f, -0.02925642f, -0.03872304f, 0.01500932f, 0.00904767f, -0.02256686f, 
    0.01066963f, -0.01646979f, -0.01611679f, 0.03060944f, -0.01740727f, -0.00353542f, -0.02607276f, -0.03205703f, 
    0.02700642f, 0.02441894f, -0.03852332f, 0.03640674f, 0.01449444f, -0.02612746f, 0.02549520f, 0.00206229f, 
    -0.00371644f, 0.01660174f, 0.02819479f, -0.04152459f, -0.00486941f, 0.02819890f, -0.00834785f, 0.00922409f, 
    0.01719421f, 0.01138769f, -0.02964218f, -0.02057879f, -0.00161654f, 0.02012762f, 0.00536233f, 0.02059492f, 
    -0.01094118f, -0.03491718f, 0.00693875f, -0.04112282f, 0.02475500f, 0.01567339f, -0.02814051f, -0.03952081f, 
    0.00210652f, -0.03407698f, 0.00632440f, -0.00407409f, -0.03478587f, -0.01823551f, -0.03717739f, 0.00883074f, 
    0.01547344f, 0.01473986f, -0.02710172f, 0.01709411f, 0.03056691f, 0.00825689f, -0.00751089f, 0.01656182f, 
    -0.01208981f, 0.00342416f, -0.01164859f, 0.01895195f, 0.00037921f, -0.02754249f, 0.00683559f, -0.01119075f, 
    0.02407487f, 0.03325607f, -0.00554215f, 0.02395823f, 0.02398963f, 0.01166682f, -0.01312588f, 0.02800792f, 
    -0.00251403f, 0.00887418f, 0.00641361f, -0.01191196f, 0.01211711f, -0.01565842f, -0.00388162f, -0.02949354f, 
    -0.00115048f, -0.01378331f, 0.01992971f, -0.03045497f, -0.03341434f, -0.02660685f, 0.00987326f, -0.04259343f, 
    0.02365571f, 0.04058572f, -0.01672290f, -0.02246214f, 0.00283962f, -0.02894298f, 0.02505438f, 0.01149272f, 
    0.01217373f, 0.02459468f, -0.04267488f, -0.03743288f, 0.03005523f, -0.01559909f, -0.00732785f, 0.01771828f, 
    0.02065869f, -0.00968628f, -0.01558280f, 0.01837038f, -0.00068988f, -0.03181801f, -0.03224195f, -0.00354659f, 
    0.02957544f, -0.01218145f, -0.03830228f, 0.02274984f, -0.03102338f, -0.02460517f, 0.01525387f, 0.02047951f, 
    -0.00398325f, -0.01504244f, -0.02997057f, -0.00850101f, -0.02595377f, -0.03558372f, 0.02203337f, 0.00820447f, 
    0.02605685f, -0.01571924f, -0.00767876f, 0.01773958f, -0.03188162f, 0.02415619f, -0.04324326f, -0.01247090f, 
    -0.02853951f, -0.02442740f, -0.02445682f, -0.03341709f, -0.03529066f, 0.00779849f, 0.01152736f, 0.01019033f, 
    -0.03922004f, 0.02036216f, -0.02554523f, -0.01036848f, -0.00352069f, -0.01845671f, -0.01355430f, -0.03590165f, 
    -0.00874290f, -0.02752328f, -0.00410426f, 0.02255600f, 0.01685596f, 0.01859925f, -0.00923660f, -0.00770589f, 
    0.00718985f, -0.02450133f, 0.01202128f, 0.01153602f, -0.03002421f, 0.00073166f, -0.02367830f, -0.03810932f, 
    -0.00511576f, -0.01574038f, -0.01938396f, 0.02247901f, 0.02122142f, 0.02622208f, -0.01042954f, -0.01181497f, 
    0.01283535f, -0.00091581f, 0.00632795f, -0.02621350f, 0.00504772f, -0.03640224f, 0.02096131f, -0.02210540f, 
    0.01431408f, -0.01665394f, 0.02431688f, -0.02300804f, 0.00921149f, 0.00992682f, 0.01892663f, 0.01926370f, 
    -0.03215254f, -0.02249321f, -0.03017782f, -0.03114607f, -0.00433526f, 0.00103082f, -0.01054446f, -0.02905795f, 
    0.00173325f, 0.02310060f, -0.00150094f, 0.02615161f, -0.01924591f, -0.00470914f, -0.01598106f, 0.02332172f, 
    -0.00903485f, 0.01543768f, -0.02621896f, -0.01127755f, -0.00043413f, -0.01127327f, -0.02489218f, -0.02746755f, 
    -0.02080696f, 0.01976600f, -0.03840426f, -0.04243327f, 0.01054824f, 0.00422446f, 0.00968387f, -0.00590232f, 
    -0.01514135f, -0.00648865f, -0.04695841f, -0.02107565f, -0.03268743f, 0.02584529f, 0.01938132f, 0.02151839f, 
    -0.00725760f, -0.01461359f, -0.00494792f, -0.02924933f, -0.01583646f, 0.02113708f, -0.01289581f, -0.01867878f, 
    -0.00437169f, 0.00187819f, 0.01545023f, 0.00991797f, -0.00703773f, 0.00526222f, 0.02792892f, -0.00271323f, 
    0.00078754f, -0.00151623f, -0.00082685f, -0.04353267f, -0.01639209f, -0.01765998f, -0.02273924f, 0.00643749f, 
    -0.01325341f, -0.03990497f, -0.03835300f, -0.02800612f, -0.04068610f, 0.00901889f, -0.03259392f, -0.02301370f, 
    0.02496484f, 0.02368963f, -0.00121598f, 0.00809309f, -0.03146122f, -0.03726766f, 0.02952589f, 0.00851663f, 
    0.00291492f, -0.03998663f, 0.03295341f, 0.00905396f, -0.00592195f, 0.02483792f, -0.00483721f, -0.00408133f, 
    0.00138441f, -0.00805799f, -0.00532318f, 0.01015052f, 0.00883779f, 0.00289226f, -0.01235732f, -0.03142603f, 
    -0.03352095f, -0.01795254f, 0.02797395f, -0.03777254f, 0.00301629f, -0.02633063f, -0.02390070f, 0.00835060f, 
    0.01824510f, -0.00163133f, -0.01367976f, 0.00407204f, -0.00481244f, -0.00691404f, 0.02586173f, 0.01894451f, 
    -0.01834611f, 0.02240238f, 0.01206907f, 0.01648658f, -0.02924005f, -0.03346255f, 0.02314031f, 0.01119903f, 
    0.00868119f, 0.01315542f, -0.02342728f, 0.00859846f, -0.03582389f, 0.00819129f, 0.03220306f, 0.00972096f, 
    -0.02377379f, -0.01988239f, -0.02312554f, -0.01299776f, -0.03329194f, 0.01582219f, -0.00923986f, 0.01833106f, 
    0.02625712f, 0.01736923f, -0.03330530f, 0.01946849f, 0.00484949f, -0.03265465f, -0.01986554f, -0.00689629f, 
    -0.00568000f, 0.01871730f, -0.03673126f, 0.01579500f, 0.01988262f, 0.02189769f, -0.02489718f, -0.00024672f, 
    -0.02459240f, 0.02073571f, -0.01508694f, 0.01544475f, -0.02198671f, -0.03280861f, -0.01777367f, -0.00811160f, 
    -0.03181352f, 0.01890647f, 0.01202526f, 0.02237756f, -0.01798964f, -0.01691904f, -0.02565652f, 0.02463780f, 
    -0.02178665f, -0.00993632f, -0.02095122f, 0.01548029f, -0.02385532f, -0.01127509f, 0.01632466f, 0.00740417f, 
    0.02079447f, -0.02654216f, 0.03020190f, 0.00837695f, 0.02294980f, -0.01365356f, -0.02693790f, -0.02918148f, 
    0.02932763f, -0.00598867f, -0.04190988f, -0.03275189f, -0.02617944f, -0.00480114f, -0.01641394f, -0.01224888f, 
    -0.04219410f, 0.02567520f, -0.00748431f, -0.03620876f, -0.01749374f, -0.01902457f, -0.02314182f, -0.02485323f, 
    0.01920462f, -0.04136835f, -0.01387294f, -0.04325073f, 0.03032763f, 0.01143140f, 0.00194115f, -0.00549592f, 
    -0.00395325f, -0.02386553f, 0.00786629f, 0.01504764f, 0.01182305f, -0.03810292f, -0.03880053f, -0.01939760f, 
    -0.03706451f, 0.02406151f, -0.02587656f, 0.01565963f, 0.00521937f, 0.02301839f, 0.02301045f, -0.02219365f, 
    -0.02489668f, -0.02374917f, -0.00484794f, -0.01735077f, 0.02814826f, -0.02160039f, -0.03784091f, 0.01543956f, 
    0.01560521f, 0.01297690f, -0.02890482f, -0.00175735f, -0.02477878f, 0.00509440f, -0.00739017f, -0.02542965f, 
    0.01508823f, -0.02915992f, -0.03054805f, 0.00022208f, -0.00949676f, 0.02147421f, -0.02853516f, -0.03537951f, 
    -0.01770969f, 0.01312938f, 0.00578241f, 0.01537747f, -0.03990653f, -0.03719741f, 0.00470324f, 0.00694237f, 
    -0.00022685f, -0.00497266f, -0.04316626f, 0.01135069f, -0.00054343f, 0.00126143f, 0.01309112f, -0.00369266f, 
    0.00731895f, -0.03276831f, -0.02664461f, -0.04091201f, -0.04170957f, -0.02645254f, -0.00583440f, 0.01007327f, 
    -0.02327579f, -0.02872869f, -0.02396709f, 0.01575142f, -0.02220701f, -0.02906934f, -0.04400561f, 0.01715027f, 
    0.01497044f, 0.03393110f, -0.03131660f, -0.04125736f, -0.01199526f, 0.02205383f, 0.02328563f, 0.02482209f, 
    0.01861820f, 0.00276013f, -0.02387941f, -0.01700115f, -0.03418257f, 0.00187649f, -0.02003354f, 0.01359818f, 
    -0.04216405f, -0.00897565f, -0.00358415f, 0.00691122f, -0.00136390f, -0.03777212f, 0.00218644f, 0.01852671f, 
    -0.00434786f, -0.04086989f, 0.03022799f, -0.02205891f, -0.02948327f, -0.01165009f, -0.03822183f, -0.01105575f, 
    0.00014658f, -0.01315062f, 0.01378567f, 0.00164113f, -0.00179362f, -0.00795745f, -0.02072066f, 0.02212454f, 
    0.00837403f, -0.02841303f, 0.01539526f, -0.04036413f, 0.03059471f, 0.02842406f, -0.03916331f, -0.02310560f, 
    0.02757437f, -0.02722555f, 0.01843416f, 0.00590579f, 0.01416312f, 0.00757171f, 0.02577261f, -0.03185041f, 
    0.01590445f, -0.00503735f, 0.02781217f, 0.02816893f, 0.00328832f, -0.01678996f, -0.02834903f, 0.00165120f, 
    -0.02059474f, -0.01158218f, 0.02303878f, 0.00086809f, -0.04243786f, 0.00913003f, 0.01090359f, 0.02121233f, 
    0.00848560f, -0.03200452f, -0.01257903f, 0.00090943f, 0.01930619f, 0.03406844f, -0.02779992f, 0.00480497f, 
    -0.00089743f, 0.02232942f, -0.01641901f, 0.01395120f, 0.00948824f, -0.01525081f, -0.00185380f, 0.00646292f, 
    -0.00022464f, -0.04002558f, -0.00582948f, -0.00676120f, 0.02893687f, -0.00286540f, 0.01915675f, -0.00065745f, 
    -0.02865006f, -0.01451620f, -0.00113987f, -0.02631782f, -0.02585535f, -0.00750409f, -0.02962634f, -0.00606774f, 
    0.01016965f, 0.03192263f, -0.02181158f, 0.02041814f, -0.02458008f, -0.02744666f, 0.01985634f, 0.01176757f, 
    -0.03577731f, -0.01117797f, -0.00772221f, -0.03640749f, 0.00348121f, 0.00971754f, -0.02386942f, 0.02245926f, 
    0.02436291f, 0.01835678f, -0.00036719f, 0.00593696f, -0.03323453f, 0.00353212f, 0.03029879f, 0.02825073f, 
    0.00502773f, -0.01512258f, -0.01957349f, 0.02346777f, -0.03466615f, -0.02179503f, 0.01110722f, -0.01521762f, 
    -0.01485370f, 0.01622194f, 0.02544531f, -0.00239435f, -0.01168811f, 0.00310026f, 0.00952787f, 0.02825448f, 
    -0.16119799f, 0.30460879f, -0.14062226f, -0.04825326f, -0.00248007f, 0.14159265f, 0.00074853f, -0.06528254f, 
    -0.05526308f, -0.01512449f, 0.07346685f, 0.01577866f, 0.01937360f, 0.03900952f, -0.00203186f, -0.01543579f, 
    0.11188902f, 0.13808441f, -0.06481649f, -0.11545043f, -0.06657927f, -0.07418337f, -0.06724367f, -0.15811564f, 
    0.12140968f, -0.01113481f, 0.03504935f, -0.01457799f, -0.00697169f, -0.05439403f, -0.01346878f, 0.04270158f, 
    0.00005413f, 0.08588158f, 0.02596708f, -0.06928469f, 0.17683481f, 0.19211735f, -0.04670379f, -0.01452780f, 
    0.10770753f, -0.02391773f, -0.00166900f, -0.14347520f, -0.19056159f, 0.09821188f, 0.00508528f, 0.17103367f, 
    -0.16557562f, 0.15288298f, 0.11261231f, 0.04862445f, -0.02665446f, -0.01555015f, 0.14495680f, 0.12971653f, 
    0.00511764f, 0.01643203f, 0.04602558f, 0.01141503f, -0.02560700f, -0.07701690f, 0.10627089f, -0.15125081f, 
    -0.11252854f, 0.04954993f, 0.01410210f, -0.10294957f, -0.02526715f, -0.09715709f, 0.07305145f, 0.04002988f, 
    0.16077662f, 0.01048362f, 0.17290762f, -0.11491399f, 0.01200371f, 0.00116768f, -0.01755030f, 0.08237085f, 
    0.02949073f, 0.03738474f, 0.01126700f, 0.10695094f, -0.07864983f, 0.21121483f, 0.13005529f, -0.03659871f, 
    -0.02482393f, 0.12855931f, 0.04817462f, 0.13427135f, -0.08599281f, 0.00042850f, -0.02694236f, -0.02770736f, 
    0.11994010f, 0.16430876f, 0.20400836f, 0.36034688f, 0.04730907f, 0.01400746f, -0.01648252f, 0.14369547f, 
    -0.06688496f, 0.00712078f, 0.06514525f, -0.06306511f, 0.30424923f, 0.01774043f, 0.10363431f, -0.13514300f, 
    -0.04801147f, -0.02925314f, 0.13317981f, 0.12849306f, 0.03804623f, 0.00557081f, -0.01693602f, 0.13873687f, 
    -0.35183817f, 0.20821466f, 0.14705604f, -0.15623453f, 0.06398372f, 0.03845448f, 0.22728740f, -0.05709404f, 
    0.03285991f, 0.10817041f, 0.16270316f, 0.12228346f, -0.08920573f, 0.24698688f, 0.07838371f, -0.06661621f, 
    0.02721243f, 0.13901012f, -0.13758208f, 0.09316118f, -0.03748924f, -0.12225341f, -0.06342671f, 0.05529038f, 
    0.06832325f, 0.10521343f, -0.02926682f, 0.16242190f, -0.04336089f, 0.01579289f, -0.00420263f, 0.03228259f, 
    0.13013561f, 0.04419683f, 0.04734316f, 0.07520100f, 0.01942541f, -0.19601128f, 0.11850023f, -0.19630367f, 
    0.11596113f, -0.03711194f, 0.03347040f, -0.12970056f, -0.01004400f, -0.01651634f, 0.00042353f, -0.00947921f, 
    -0.06342344f, 0.04898923f, -0.02618001f, -0.05756036f, -0.11428190f, 0.05771506f, 0.03483694f, 0.07963280f, 
    0.05830328f, 0.01043468f, 0.02004646f, 0.01876592f, 0.20311876f, 0.05473097f, -0.07888965f, 0.12505676f, 
    -0.11584917f, -0.01921131f, -0.02110971f, 0.14789994f, -0.01277226f, -0.03177274f, 0.00815470f, 0.03136755f, 
    -0.04039676f, 0.10100222f, -0.00303751f, -0.02569726f, 0.09476742f, 0.00543768f, 0.00251384f, 0.04647763f, 
    0.02322817f, 0.07337622f, 0.04191107f, 0.03356255f, 0.15794004f, -0.11544086f, 0.01776908f, -0.24125963f, 
    -0.03655294f, 0.11520790f, -0.05507436f, 0.01197786f, 0.00195239f, 0.08366593f, 0.15423942f, -0.03274710f, 
    0.10207650f, -0.01437127f, -0.09200571f, -0.14275505f, -0.09353983f, -0.00399736f, -0.04347354f, -0.09940708f, 
    -0.02691376f, -0.04851450f, 0.01946799f, -0.02075669f, 0.11549686f, -0.03518474f, 0.14159369f, -0.17300861f, 
    0.03823796f, 0.07522657f, 0.03156402f, -0.02088910f, -0.08395294f, 0.04591535f, 0.00118542f, -0.10764938f, 
    -0.08419809f, 0.14563908f, -0.05918581f, 0.04729277f, 0.02693905f, 0.00453761f, -0.03282784f, -0.06372681f, 
    0.05823908f, 0.06569186f, 0.09189462f, -0.04752300f, 0.06091220f, 0.09947600f, -0.19343352f, -0.02801772f, 
    0.06500407f, 0.02471366f, -0.08771124f, -0.02183042f, -0.09554705f, -0.00944970f, 0.01100500f, -0.09582224f, 
    0.23017316f, -0.28199095f, -0.02425885f, 0.08639959f, -0.03498395f, -0.15711206f, 0.04755330f, 0.14195254f, 
    -0.02787825f, -0.04161118f, 0.02847889f, 0.04603084f, 0.12484613f, -0.03527870f, 0.06475288f, 0.02366751f, 
    0.01938140f, 0.07715182f, -0.03319791f, 0.02377547f, 0.04275092f, 0.17715222f, 0.03528250f, 0.13061373f, 
    0.15218951f, 0.13157864f, 0.02770603f, 0.15114084f, 0.00232678f, 0.04955499f, 0.00362791f, 0.15020335f, 
    0.08063510f, 0.09554698f, 0.06924213f, 0.09496704f, 0.00979152f, 0.03983789f, 0.02005682f, -0.01012046f, 
    -0.11666655f, 0.05047844f, 0.03596705f, 0.03554946f, 0.09733479f, 0.13891473f, 0.17156713f, 0.05149813f, 
    -0.15189798f, 0.20162144f, 0.08070029f, -0.09468377f, 0.22739580f, -0.02675919f, -0.03586896f, 0.05014790f, 
    -0.01195380f, -0.01371373f, -0.00070986f, -0.01956259f, 0.20496985f, -0.16251770f, 0.06445713f, 0.06891207f, 
    0.10445701f, -0.00118870f, -0.05465387f, -0.03731215f, -0.04336160f, -0.00175117f, -0.11656372f, -0.01149394f, 
    -0.23014945f, -0.01869794f, 0.20116420f, -0.01162135f, -0.09750183f, 0.02839063f, 0.02028604f, 0.01438620f, 
    -0.06016453f, 0.03803356f, 0.02990070f, 0.07209929f, 0.03067805f, 0.11195355f, -0.05453419f, -0.08057477f, 
    -0.11128118f, 0.16559522f, -0.16911536f, 0.07489923f, -0.00810592f, -0.02521842f, 0.04193318f, 0.03441571f, 
    0.05674941f, 0.12727191f, 0.03770744f, -0.00872776f, 0.10927559f, -0.03444852f, -0.05110226f, -0.15442097f, 
    -0.03374060f, 0.05891206f, -0.02842220f, 0.05791727f, -0.03367596f, 0.04925819f, 0.01548117f, -0.05652949f, 
    -0.01023078f, 0.04174769f, -0.02167275f, -0.10099594f, -0.09135120f, 0.12791076f, 0.10416617f, -0.00421663f, 
    0.01804119f, -0.26315153f, 0.18563460f, -0.19577815f, -0.17033713f, -0.07750019f, 0.09690590f, -0.07699299f, 
    0.01228942f, 0.12800999f, 0.05378173f, 0.00073314f, 0.15502556f, 0.00256384f, 0.01050034f, -0.08757823f, 
    0.03899245f, -0.02853548f, 0.00272603f, -0.01231367f, -0.05988894f, 0.00528309f, 0.06569826f, -0.01904891f, 
    -0.10938750f, -0.18479449f, 0.21199501f, 0.02075407f, -0.08034737f, -0.05319547f, -0.05785633f, -0.05954831f, 
    -0.06670958f, -0.04602075f, 0.02078295f, -0.06231387f, -0.02558065f, 0.08270334f, -0.05604671f, 0.13815980f, 
    0.12898123f, 0.03121110f, 0.16482180f, 0.12166057f, 0.04407308f, -0.01548125f, -0.02466348f, -0.06497489f, 
    0.02789317f, 0.02333058f, -0.01234466f, 0.12613764f, -0.05586984f, 0.02026474f, 0.02302024f, 0.08112483f, 
    0.01059999f, 0.09412511f, -0.05408493f, 0.03477681f, -0.27942994f, -0.36836702f, -0.16011232f, -0.29502609f, 
    -0.02344198f, 0.03447282f, 0.06029038f, 0.01813043f, -0.10305175f, 0.07060505f, -0.03804876f, -0.10331681f, 
    0.41542047f, 0.04608126f, -0.10094093f, -0.14154013f, -0.02539019f, 0.05048255f, -0.08285274f, -0.01147522f, 
    0.05392202f, 0.06022368f, -0.04719010f, -0.08342802f, 0.19275559f, 0.09410517f, -0.00598706f, 0.14588122f, 
    -0.16494988f, 0.01456531f, 0.09941244f, 0.02238025f, 0.07027406f, 0.09055959f, 0.01913939f, -0.02513850f, 
    0.16584782f, -0.17875795f, -0.15157694f, -0.15330239f, 0.09087202f, -0.01611606f, 0.04697588f, 0.02261913f, 
    -0.07352117f, -0.11591580f, 0.09914128f, -0.02861959f, 0.32219654f, -0.23194990f, 0.01698757f, 0.20705174f, 
    0.24701692f, -0.01936293f, 0.00526207f, 0.04199974f, 0.02464531f, -0.02547140f, 0.08100615f, 0.05885700f, 
    -0.10076426f, -0.06758615f, -0.18514955f, -0.04027424f, -0.21894790f, 0.05036372f, 0.04830102f, 0.04218572f, 
    0.02389745f, 0.04790446f, -0.01952855f, 0.01898887f, 0.08430127f, -0.09789281f, 0.07801908f, 0.11346518f, 
    -0.08636087f, -0.08975518f, 0.13180862f, 0.09150167f, -0.01560831f, 0.02040588f, 0.02482340f, 0.05892408f, 
    0.02176931f, 0.13640124f, 0.02263347f, 0.14562206f, -0.10956403f, -0.06221284f, 0.02812486f, -0.10573362f, 
    -0.09572087f, 0.00430343f, 0.03949930f, -0.06823950f, 0.20278153f, -0.18989426f, 0.18642020f, 0.00225149f, 
    0.03164617f, 0.10471225f, -0.00521565f, -0.16778496f, 0.16218047f, 0.09345948f, 0.09843349f, 0.04097202f, 
    0.08303005f, -0.07443094f, 0.18416333f, 0.00991321f, -0.02013969f, -0.02539042f, -0.00169378f, -0.07848471f, 
    -0.03601810f, 0.05497254f, 0.00730463f, 0.02876208f, 0.00942903f, 0.05950278f, -0.00693341f, 0.20437886f, 
    0.09027520f, -0.01328055f, -0.06294055f, -0.07970887f, -0.04007043f, -0.04070358f, 0.07695550f, -0.01923740f, 
    0.07255764f, -0.21626189f, 0.05229498f, -0.07090155f, 0.05063861f, 0.00036464f, -0.06770348f, -0.12771541f, 
    0.06217334f, 0.04615904f, 0.07630048f, -0.01277390f, -0.04481372f, -0.04942914f, 0.10371649f, -0.36305761f, 
    -0.02931436f, 0.22796805f, -0.04939087f, 0.03190545f, 0.00015136f, 0.02296582f, 0.03868252f, 0.12655759f, 
    -0.04632666f, 0.03159859f, -0.02377992f, -0.15784194f, -0.02570883f, 0.09656294f, 0.00222640f, -0.06575289f, 
    0.02320347f, -0.04133698f, 0.00870232f, -0.15298998f, 0.11442121f, 0.14084375f, 0.09850325f, 0.00642009f, 
    0.01765722f, 0.02377259f, 0.05129854f, 0.00585807f, -0.02897379f, -0.04509402f, -0.02802993f, -0.09705965f, 
    -0.09303766f, 0.21002907f, 0.07086160f, 0.17457259f, -0.17578255f, -0.00270190f, 0.05790668f, -0.06379879f, 
    0.00267875f, -0.01824565f, 0.05425517f, 0.09548855f, 0.19249323f, 0.12978235f, 0.06267261f, 0.07124866f, 
    0.13083567f, -0.01982566f, 0.05423693f, 0.23150767f, -0.03399643f, -0.03987565f, -0.04174909f, -0.02977075f, 
    -0.23496108f, -0.11080003f, 0.13282448f, -0.10760952f, -0.05796614f, 0.02969809f, 0.07701088f, 0.11140213f, 
    -0.14691161f, 0.05490703f, -0.03541540f, -0.05116902f, -0.14086074f, -0.00820668f, -0.04629281f, -0.13153741f, 
    0.00913633f, 0.03721728f, 0.05705112f, -0.05869758f, -0.00413306f, -0.03601365f, 0.06435072f, 0.01511388f, 
    0.15917671f, -0.05197700f, 0.09442653f, -0.02050675f, 0.02399065f, -0.04818098f, -0.13686135f, 0.04009737f, 
    0.01175522f, 0.05360148f, 0.00346964f, -0.06323025f, 0.02190364f, 0.15029925f, 0.10963579f, 0.21326184f, 
    -0.16056903f, 0.16604869f, -0.06036044f, 0.05041469f, 0.01990195f, -0.03705193f, -0.04182163f, 0.01260827f, 
    0.00718475f, -0.13036439f, -0.09341718f, -0.15487806f, 0.14541470f, 0.01667607f, 0.01044978f, 0.14758500f, 
    -0.04401537f, 0.13875879f, 0.17661706f, -0.04738007f, 0.08962431f, 0.14173944f, -0.24725921f, -0.16909730f, 
    0.15948303f, 0.03550133f, -0.08973945f, -0.16717310f, 0.00420628f, -0.04485775f, -0.02022827f, 0.01991289f, 
    -0.03587571f, -0.28372869f, -0.27559900f, -0.24188438f, 0.04513698f, 0.04707238f, -0.01349637f, -0.05514538f, 
    0.01626051f, -0.02505500f, 0.00029088f, -0.07218671f, 0.12462392f, -0.04200945f, 0.03246130f, 0.02951528f, 
    0.14118846f, 0.01316574f, -0.05585816f, -0.13598685f, 0.03647190f, -0.01621906f, 0.00107066f, 0.02716842f, 
    0.13356438f, -0.31740108f, 0.32948521f, 0.10786787f, -0.00856722f, 0.09434806f, -0.03550968f, -0.12374771f, 
    0.02794699f, 0.08411323f, -0.02172451f, -0.12900725f, 0.06367039f, 0.00926956f, -0.13617943f, -0.00288057f, 
    -0.02544021f, 0.02309265f, -0.08733099f, 0.05099311f, 0.05622291f, -0.02319492f, -0.05440151f, 0.00456764f, 
    0.06485411f, -0.17432092f, 0.13142905f, 0.19827865f, -0.03536709f, 0.26985353f, 0.02982744f, -0.02493607f, 
    0.26075256f, 0.09631319f, 0.04417470f, 0.04665001f, -0.00367158f, -0.01278459f, -0.01967746f, 0.06927766f, 
    0.16941652f, -0.03386238f, 0.02658142f, 0.00619220f, -0.05131409f, 0.00296590f, 0.06256768f, 0.08666473f, 
    0.03860270f, 0.19337855f, -0.08437443f, -0.05851630f, 0.02524397f, 0.04881959f, 0.05167400f, -0.05014743f, 
    0.01158882f, 0.03082678f, 0.05746670f, 0.07068141f, 0.06331753f, -0.10924602f, 0.12305702f, 0.02535621f, 
    -0.03931833f, -0.08916055f, -0.01899637f, -0.00172757f, -0.13904081f, -0.07048158f, -0.02531783f, -0.03183788f, 
    -0.21884914f, -0.13753179f, 0.17244640f, 0.01477337f, 0.03249834f, 0.12286708f, -0.11583706f, 0.08710799f, 
    0.19552819f, -0.01026369f, 0.02441989f, 0.01001898f, 0.07031559f, -0.05107699f, 0.05748465f, -0.10461850f, 
    -0.07279025f, 0.11304060f, 0.06305444f, 0.03659211f, 0.01189547f, 0.09449904f, 0.00166358f, -0.01176031f, 
    0.09965010f, 0.21387134f, -0.04125016f, 0.01870034f, 0.06200020f, 0.12499340f, 0.00489103f, -0.09040453f, 
    0.05031109f, 0.06256157f, 0.00656906f, -0.14639680f, -0.00066985f, -0.05596524f, -0.06386872f, -0.15821742f, 
    0.11718965f, 0.11471467f, -0.08048217f, 0.01784166f, 0.13512582f, 0.21921015f, -0.01363879f, 0.12352885f, 
    -0.40686658f, 0.32096696f, -0.20760866f, -0.31375781f, 0.01426079f, 0.06791525f, 0.04819255f, -0.00484079f, 
    0.03795817f, -0.06032667f, 0.01672139f, -0.07991696f, -0.24462406f, 0.14407185f, 0.11477388f, -0.10669675f, 
    0.06166275f, 0.09356125f, -0.03023261f, -0.10685778f, -0.06474961f, -0.01170680f, -0.02256512f, -0.10011679f, 
    0.01804315f, -0.05900192f, 0.13642509f, -0.18335532f, 0.08832263f, 0.06430503f, -0.04464679f, 0.12911810f, 
    0.10745094f, -0.05009759f, 0.04401900f, 0.08425824f, -0.15574346f, -0.32732680f, 0.14746793f, 0.06703106f, 
    -0.03535812f, 0.06972609f, -0.10261509f, -0.05428220f, -0.04769323f, 0.03628577f, 0.09442437f, -0.01324420f, 
    0.06047050f, -0.17166278f, 0.15012278f, -0.05537159f, 0.03537048f, 0.00751676f, 0.08621772f, 0.02646558f, 
    -0.08326912f, -0.05624336f, -0.26598558f, 0.08970527f, -0.48166341f, 0.05936337f, -0.01641386f, -0.04874444f, 
    0.22608712f, -0.01890749f, 0.12362091f, -0.13582885f, 0.06840442f, 0.17505875f, -0.12525797f, 0.16577971f, 
    0.16096132f, -0.00667804f, 0.15967485f, -0.02744920f, 0.08427959f, -0.01990492f, -0.01081828f, -0.00928016f, 
    -0.17310934f, -0.01674632f, -0.03893093f, 0.13868001f, 0.11939479f, 0.10207835f, 0.05369908f, -0.29576632f, 
    -0.12970528f, 0.14418864f, -0.11046786f, -0.08220284f, -0.15713982f, -0.04374393f, 0.03248619f, 0.04600989f, 
    0.17209947f, 0.00945726f, -0.06347432f, 0.03212071f, 0.03586431f, 0.02804026f, -0.03441456f, -0.05978950f, 
    0.09966469f, 0.07327862f, 0.04700467f, -0.05537524f, -0.03809343f, 0.08599771f, -0.09863893f, 0.04426069f, 
    0.10263858f, -0.04158575f, 0.05757556f, -0.04480760f, -0.06988586f, 0.10845021f, -0.04919896f, -0.03937536f, 
    0.17624074f, 0.23505506f, 0.19521889f, -0.05013644f, -0.12892155f, 0.08512001f, -0.10272068f, 0.02697502f, 
    -0.03132644f, 0.08191191f, 0.01885224f, -0.14263123f, -0.23589550f, 0.04382711f, -0.12090081f, 0.20689723f, 
    0.14703366f, 0.02012291f, 0.05777912f, 0.04227564f, -0.12400457f, -0.05595583f, -0.06817301f, 0.13083902f, 
    0.40621254f, 0.02462763f, -0.06833456f, 0.02468033f, -0.11075264f, 0.06774025f, 0.04651662f, 0.12691118f, 
    -0.19070379f, 0.20698074f, -0.09159833f, -0.00336098f, 0.02727435f, 0.09919950f, 0.19835003f, 0.18779382f, 
    -0.13445096f, -0.02034663f, -0.03116640f, -0.05385248f, 0.09367398f, -0.10656937f, 0.01858750f, 0.16042832f, 
    0.02609002f, 0.17219390f, -0.01253180f, -0.08574580f, 0.20472112f, -0.12355251f, 0.10012852f, -0.07490395f, 
    0.09991256f, 0.06092184f, -0.00231304f, 0.00367606f, 0.13902618f, 0.12192538f, 0.09872851f, 0.20999242f, 
    -0.12996571f, 0.00248087f, -0.06844974f, 0.01782042f, -0.04617990f, -0.03753686f, 0.00968708f, 0.05873328f, 
    0.12521809f, -0.03974123f, 0.10683776f, 0.12028216f, -0.02831534f, -0.02327481f, -0.00762564f, -0.05091853f, 
    -0.11496305f, 0.01405975f, -0.18552709f, 0.07925281f, 0.06473032f, 0.03592887f, 0.07656030f, 0.07122040f, 
    -0.05637505f, -0.06727977f, -0.04047448f, -0.08947879f, 0.00772926f, 0.02531998f, 0.03200237f, 0.00996855f, 
    -0.06761025f, -0.03080500f, -0.14654139f, 0.31908882f, -0.05313985f, 0.14617191f, 0.03308209f, -0.11601242f, 
    0.14606524f, 0.00253793f, -0.06676827f, -0.03614764f, -0.36495018f, 0.25406086f, 0.15584959f, 0.00254075f, 
    0.14761065f, 0.13587004f, 0.12774384f, 0.01742687f, 0.06694704f, -0.06867490f, -0.04971156f, 0.06264808f, 
    0.03765272f, -0.10648572f, 0.32104105f, -0.35032687f, 0.01705693f, 0.01379693f, 0.09176379f, 0.09877072f, 
    -0.05947547f, 0.05987642f, -0.00322853f, 0.10907917f, 0.12850179f, -0.21878894f, -0.01400973f, -0.07655755f, 
    0.03338733f, -0.00704023f, -0.02195529f, -0.04280278f, -0.05945908f, -0.03522034f, -0.05675276f, 0.01448366f, 
    -0.12473843f, -0.25896764f, 0.05660119f, -0.03922650f, 0.04777215f, -0.10144712f, 0.14115198f, 0.02030604f, 
    0.03121586f, -0.04440558f, 0.00526451f, -0.02745647f, 0.10319261f, 0.07659521f, 0.11310799f, 0.18436816f, 
    -0.11878001f, -0.01263919f, -0.06398741f, -0.07954640f, 0.05162788f, 0.07083526f, 0.05521135f, 0.09595808f, 
    -0.00907208f, 0.27148110f, -0.22647384f, 0.32178652f, 0.08581222f, -0.03041515f, 0.06083274f, -0.02516999f, 
    -0.04651681f, 0.14290702f, 0.15019365f, 0.23968445f, -0.06061876f, 0.15660258f, -0.03775868f, 0.12149410f, 
    0.15229365f, -0.02080312f, 0.06476770f, -0.02528136f, -0.06058498f, -0.02315962f, -0.01576623f, 0.01061062f, 
    0.06335787f, 0.02610301f, 0.05395794f, -0.08740717f, 0.11365371f, 0.01040327f, 0.15968546f, 0.00435603f, 
    0.03102020f, 0.03126860f, -0.00540106f, 0.02869509f, 0.08769088f, -0.04869506f, 0.08948386f, -0.03806914f, 
    -0.06314838f, -0.03418062f, -0.03728375f, 0.14901784f, 0.13620253f, -0.04377258f, -0.00187911f, 0.04016315f, 
    0.08024290f, 0.07395578f, -0.02924105f, -0.00471594f, 0.08986847f, -0.01135248f, -0.04954936f, -0.00105857f, 
    0.10806717f, -0.00469205f, 0.03581875f, -0.00332811f, 0.42611957f, 0.13711008f, 0.17795789f, -0.07536390f, 
    -0.14471956f, -0.03539680f, -0.08352448f, -0.19955301f, -0.01121046f, -0.07575033f, 0.03355464f, -0.01825777f, 
    -0.03576094f, 0.11176832f, -0.06365170f, -0.02183865f, 0.06199483f, 0.03633455f, -0.04142648f, -0.07322009f, 
    -0.09014659f, -0.06456946f, -0.02761727f, -0.00347804f, -0.06402420f, -0.03855425f, 0.02751130f, -0.11273134f, 
    -0.07418439f, -0.02791035f, 0.06862132f, 0.01320953f, -0.08111835f, 0.01162873f, -0.02918796f, 0.05477229f, 
    0.05993117f, 0.10238016f, -0.00923628f, 0.13263848f, -0.16820374f, -0.06861275f, -0.08487125f, -0.08638439f, 
    0.08628149f, -0.04169451f, -0.08889243f, 0.06403878f, -0.31562829f, 0.27662453f, -0.09387496f, -0.00673230f, 
    -0.10549819f, 0.11619516f, 0.13426396f, 0.08722474f, 0.04272215f, 0.01056781f, -0.09041470f, 0.05313201f, 
    0.00527164f, -0.05928439f, 0.02341193f, -0.03237161f, 0.11907586f, -0.01644976f, 0.06181984f, 0.04347343f, 
    -0.19292355f, 0.22399645f, -0.08621106f, 0.08709502f, 0.00747789f, 0.18996704f, -0.08527412f, -0.06076916f, 
    0.01923164f, -0.07616854f, -0.05653321f, 0.10241168f, 0.06887385f, -0.02779721f, -0.24698167f, 0.01503123f, 
    0.06819224f, -0.08377712f, 0.04701453f, 0.12975813f, 0.00053028f, -0.03617250f, -0.00227089f, 0.05217314f, 
    -0.12494143f, 0.18745586f, -0.12516114f, -0.01153816f, -0.07039650f, 0.14323057f, -0.16020118f, 0.20495749f, 
    -0.13338053f, -0.11764833f, -0.10117400f, -0.02487778f, -0.06571092f, -0.03372104f, -0.00813629f, 0.06690743f, 
    0.30960381f, -0.00981609f, 0.00996757f, 0.05524214f, 0.07502060f, 0.05999545f, 0.00420766f, 0.19275677f, 
    -0.03417150f, 0.03513615f, 0.09397098f, 0.08611324f, -0.01513843f, 0.04950306f, 0.00898961f, -0.19238447f, 
    -0.01361882f, 0.11549741f, 0.09382962f, 0.15824015f, 0.11404417f, 0.00043817f, -0.05002256f, 0.04089037f, 
    0.04204862f, 0.24439166f, 0.06033241f, 0.02711064f, -0.06158810f, -0.00516506f, 0.02831508f, -0.01626997f, 
    -0.01180660f, 0.07319494f, -0.02949842f, 0.00266871f, -0.01802272f, 0.17923014f, 0.10325282f, -0.07469388f, 
    -0.00722476f, -0.01740044f, -0.01624673f, -0.08026899f, 0.00674185f, 0.06809030f, -0.01783341f, -0.14504308f, 
    -0.08292843f, -0.00803702f, 0.02610720f, -0.00297364f, 0.03953847f, 0.23206617f, 0.11526749f, -0.04179051f, 
    -0.04752068f, -0.10903510f, -0.07700669f, -0.04258709f, 0.02654593f, 0.05171512f, 0.14067933f, 0.15038103f, 
    -0.09796666f, -0.09739846f, -0.02955226f, 0.05468197f, -0.10208544f, -0.03115365f, -0.03288400f, -0.00399604f, 
    0.34880531f, -0.23679952f, 0.07473779f, 0.03689062f, -0.07842502f, 0.10511559f, -0.14459434f, 0.02650752f, 
    -0.05395204f, 0.06056001f, -0.10792298f, -0.04316552f, -0.06470921f, -0.02893284f, 0.08281523f, 0.07290526f, 
    -0.12590753f, -0.09608529f, -0.10492696f, 0.02824616f, -0.02248466f, 0.00174800f, -0.03501835f, -0.00067855f, 
    0.32571080f, -0.01583842f, 0.20035027f, -0.19838454f, 0.02683515f, 0.03480790f, 0.00462501f, 0.08825017f, 
    0.10224143f, 0.12535776f, -0.10381428f, -0.05363967f, 0.14946617f, 0.05814698f, 0.07246282f, 0.09317014f, 
    -0.05653156f, 0.02948712f, 0.07780430f, 0.00966053f, 0.00455731f, 0.05626790f, 0.09916949f, -0.01248575f, 
    -0.15000822f, -0.07985390f, 0.01251814f, -0.01566459f, -0.01722137f, 0.03621479f, 0.19328818f, 0.09085344f, 
    -0.12032493f, 0.18116277f, -0.00030907f, 0.06042250f, 0.06073758f, -0.39152309f, -0.00200261f, -0.13633609f, 
    0.08649643f, -0.13188507f, -0.08453983f, -0.00284748f, -0.00136041f, -0.00032988f, -0.07947540f, -0.05024030f, 
    0.16019179f, 0.13168462f, 0.24452822f, -0.15056974f, -0.08961362f, -0.00232777f, 0.12074834f, 0.01983044f, 
    -0.02981499f, 0.04340800f, -0.14409506f, -0.12169100f, 0.05563540f, 0.20789082f, -0.03279768f, 0.22767545f, 
    -0.10586881f, -0.07646508f, 0.01482976f, -0.07604651f, 0.00190028f, -0.07330579f, -0.01904381f, 0.11263330f, 
    0.24162941f, 0.21089625f, 0.08917190f, 0.06983747f, -0.12277527f, -0.07719874f, -0.11170303f, -0.04056739f, 
    -0.10031468f, -0.00850827f, -0.00503062f, 0.04781813f, -0.18905847f, 0.04061851f, 0.02205151f, 0.07313082f, 
    -0.11933077f, -0.07812688f, -0.11403516f, 0.04906441f, -0.06664628f, -0.03185120f, 0.09858739f, 0.05030378f, 
    -0.36360762f, 0.43714026f, -0.15046827f, -0.01811463f, 0.04755994f, -0.11973807f, 0.22265850f, 0.04462030f, 
    0.04467509f, -0.12808892f, -0.03168587f, 0.12696981f, 0.10889704f, 0.21195193f, 0.11850861f, -0.00328053f, 
    0.01686329f, -0.06782918f, 0.29433492f, 0.04661174f, 0.03527561f, -0.10562953f, 0.16765121f, -0.08468015f, 
    0.41397682f, -0.15595999f, -0.06593037f, -0.02445196f, 0.02949967f, 0.00117313f, 0.08147381f, 0.00350876f, 
    -0.03925445f, 0.02425317f, -0.09434590f, 0.10946172f, 0.01258348f, -0.09100709f, -0.01292725f, -0.02889501f, 
    -0.08049882f, -0.08728325f, -0.18893622f, 0.03813365f, -0.12104079f, -0.02807990f, -0.02033108f, -0.10177293f, 
    -0.06461783f, 0.05419586f, -0.11559163f, 0.06171260f, -0.05533409f, 0.03856857f, -0.00638411f, -0.01760228f, 
    0.25924075f, 0.19119450f, 0.08348375f, 0.16499111f, -0.01994651f, 0.04370892f, 0.05136072f, 0.02889018f, 
    0.07820006f, -0.11719308f, -0.11829366f, 0.01706528f, -0.10150883f, 0.01076662f, 0.12601849f, -0.01215050f, 
    0.30486429f, 0.02229310f, -0.20040470f, 0.03671674f, 0.10238174f, -0.11490146f, 0.05167082f, -0.00184081f, 
    0.02566827f, 0.21133688f, 0.04031653f, -0.02096924f, -0.19299445f, 0.14783843f, -0.09911039f, -0.00998291f, 
    0.03988298f, -0.14952147f, -0.09329034f, -0.05811308f, -0.02599196f, -0.00292981f, 0.12414186f, -0.00795356f, 
    -0.23855704f, -0.25434509f, -0.13520244f, 0.04376711f, 0.00561919f, 0.01493152f, 0.04696527f, 0.00769820f, 
    -0.02694896f, 0.02237114f, -0.00465166f, 0.05394292f, -0.15009303f, -0.10669442f, 0.12699495f, 0.18125300f, 
    0.13679039f, -0.01775421f, 0.13584991f, 0.10517734f, 0.07860522f, 0.00073035f, -0.07290333f, 0.06270934f, 
    0.11035140f, -0.09220351f, -0.13702981f, 0.20163880f, 0.04130039f, -0.00764739f, -0.02267327f, 0.03487138f, 
    -0.01193693f, 0.15531106f, 0.05222765f, -0.04197708f, 0.26037854f, -0.31440237f, -0.04829248f, 0.22657163f, 
    -0.04766845f, 0.05295368f, -0.00648149f, -0.01711840f, 0.02101669f, -0.05454937f, 0.02785412f, 0.05185792f, 
    0.41807899f, 0.20554285f, -0.05200548f, -0.01748675f, -0.03393861f, 0.03568789f, -0.08206838f, -0.08655392f, 
    0.01336514f, 0.00597712f, -0.02312044f, 0.08470974f, 0.36884904f, -0.01767867f, 0.07359868f, -0.10343509f, 
    -0.04849530f, 0.04101157f, -0.07267147f, -0.07614804f, -0.12731040f, -0.04062099f, 0.03713167f, 0.03299035f, 
    0.08390986f, 0.06548311f, 0.17953762f, -0.08192163f, -0.01743969f, -0.08986072f, -0.10956609f, 0.00874427f, 
    -0.02299285f, 0.13684061f, 0.15124030f, 0.04433404f, 1.01846170f, -0.09634563f, -0.28886446f, -0.03533209f, 
    -0.05664625f, 0.11525637f, 0.16555335f, 0.06453033f, 0.01292659f, -0.11629215f, 0.12932585f, 0.01214676f, 
    -0.07421127f, 0.00443699f, 0.05227790f, 0.16006945f, 0.00715476f, 0.00583365f, 0.06407373f, 0.00889431f, 
    0.24099138f, 0.21970765f, 0.03470227f, 0.12914710f, -0.39256623f, 0.04538735f, 0.23172076f, 0.30346623f, 
    0.16154657f, 0.15666519f, 0.08875825f, -0.09281997f, 0.03841454f, -0.02761541f, -0.11944789f, -0.10750458f, 
    -0.21331352f, -0.19261117f, -0.04922036f, 0.05356086f, -0.07542889f, -0.05418935f, 0.06223219f, -0.00775130f, 
    0.04504000f, 0.06010766f, 0.08286087f, 0.11203817f, -0.06726298f, 0.05861184f, -0.03567950f, 0.06999281f, 
    -0.05322451f, -0.10883520f, -0.12210442f, 0.07733698f, -0.03159954f, -0.07419267f, -0.09724478f, -0.06655995f, 
    -0.20545177f, -0.07129113f, 0.22629830f, 0.22308968f, 0.05566517f, -0.04466488f, -0.07280198f, -0.02152702f, 
    -0.03623075f, 0.01886834f, -0.01106891f, 0.02429262f, 0.00788516f, 0.04141154f, -0.13023958f, -0.08134955f, 
    -0.02482111f, -0.06695887f, -0.10969406f, 0.08728053f, -0.12236165f, 0.06245296f, -0.11308695f, 0.02325830f, 
    -0.24850149f, 0.03656233f, 0.08220257f, 0.07417487f, 0.06235817f, 0.02086151f, -0.00835351f, 0.00443455f, 
    0.10717642f, -0.00564478f, 0.06991723f, 0.23111679f, 0.07940806f, 0.18590672f, 0.15842384f, -0.05598029f, 
    0.01603960f, -0.00200420f, 0.02422636f, 0.01011633f, -0.03532707f, 0.11279149f, 0.01922299f, 0.05912483f, 
    -0.23513606f, 0.02009036f, -0.05855479f, 0.06606475f, -0.17109507f, 0.08753833f, 0.09168527f, 0.05580711f, 
    -0.08223604f, 0.04719207f, 0.08541200f, -0.04735545f, -0.30388853f, -0.06304698f, -0.09681632f, -0.17453289f, 
    -0.08379790f, -0.12734519f, 0.00957245f, -0.02210414f, -0.10964036f, 0.01754574f, -0.10575040f, 0.03802197f, 
    -0.22619593f, -0.07366577f, 0.23279683f, -0.06350148f, -0.14375354f, -0.05537021f, -0.05577875f, -0.03493006f, 
    0.03952369f, 0.16508928f, 0.11567488f, 0.06622801f, -0.36296603f, -0.20072982f, -0.28894812f, -0.27802521f, 
    0.05842800f, -0.03696574f, -0.02895002f, 0.01774726f, -0.05276391f, 0.00416232f, 0.02677592f, -0.05259435f, 
    -0.04645403f, -0.08726116f, -0.18596545f, 0.02027762f, 0.00961197f, 0.01988168f, -0.06259551f, -0.02199347f, 
    0.01307050f, 0.11531425f, 0.03017545f, 0.05671874f, -0.09634380f, 0.05597836f, -0.10418953f, -0.20596017f, 
    0.03431271f, -0.00099881f, 0.06008671f, 0.03551255f, -0.00308015f, -0.00024509f, -0.01099912f, -0.08461791f, 
    -0.25582862f, 0.33485404f, -0.18825810f, 0.24067613f, 0.01324130f, 0.07526351f, -0.02311639f, 0.05351380f, 
    0.12440705f, 0.07309543f, 0.10004392f, 0.08778884f, -0.04447854f, 0.13755961f, 0.31125835f, 0.23313570f, 
    0.18403429f, 0.06597120f, 0.09031457f, -0.07741475f, 0.02018226f, -0.02140682f, -0.09550438f, 0.05014232f, 
    0.00002532f, 0.10609699f, -0.08664006f, 0.03262763f, -0.09420584f, -0.01268347f, -0.07243317f, 0.04906118f, 
    -0.05210758f, -0.21253002f, 0.10218479f, 0.04400667f, -0.05884312f, 0.01535800f, -0.11201050f, -0.25981927f, 
    0.00440402f, -0.04338804f, 0.01890296f, 0.01125536f, 0.01490486f, 0.03310851f, 0.05238003f, 0.12310340f, 
    -0.01499819f, 0.03659235f, -0.12305591f, -0.11789767f, 0.04593773f, 0.05904748f, -0.11704975f, -0.04795786f, 
    -0.06608607f, -0.02575423f, -0.05840286f, -0.08519047f, 0.05236981f, 0.05692418f, -0.03388463f, 0.21126616f, 
    -0.01318460f, -0.05650613f, -0.02136421f, 0.01232842f, -0.05931927f, 0.01998345f, 0.00734603f, -0.09402150f, 
    -0.04335497f, 0.04769972f, -0.03527146f, 0.06161273f, -0.00858115f, 0.05735753f, 0.06370312f, 0.09528390f, 
    -0.03003761f, 0.06279363f, -0.14109918f, -0.05083149f, -0.17037405f, -0.04778600f, 0.07505095f, 0.08968561f, 
    0.02175718f, 0.07729054f, -0.00901031f, 0.12736793f, 0.11606754f, 0.05106577f, 0.09837956f, -0.05092139f, 
    -0.23375036f, -0.16262077f, -0.03113204f, 0.06101693f, -0.05796473f, 0.04873800f, 0.00650429f, 0.05465201f, 
    0.02115109f, 0.02053099f, -0.01826845f, 0.06617934f, -0.18395618f, 0.40406945f, 0.28404573f, 0.30433670f, 
    0.00393757f, 0.01459703f, 0.12150908f, 0.18282606f, 0.01749771f, 0.11162826f, -0.04150983f, 0.08148067f, 
    -0.10155644f, -0.18802685f, 0.09996632f, 0.16196340f, 0.02463144f, 0.08594476f, 0.14026345f, 0.03688829f, 
    -0.00732259f, -0.04142311f, 0.02873051f, -0.00394245f, -0.05037755f, -0.15454726f, 0.09478434f, 0.00611318f, 
    0.07645404f, 0.01050134f, -0.09159468f, 0.12320331f, -0.04099767f, -0.02402830f, 0.01165201f, 0.01986639f, 
    -0.41351575f, 0.22374588f, 0.29845107f, 0.03015871f, 0.07371170f, 0.08047421f, 0.16325207f, 0.07863735f, 
    -0.02111430f, -0.02598366f, 0.07834625f, -0.06577745f, 0.17070411f, 0.12377035f, -0.00337872f, 0.08530658f, 
    0.02983342f, 0.05455479f, -0.03043949f, -0.01522053f, 0.00655642f, -0.05825271f, 0.15914485f, -0.04126484f, 
    -0.11874121f, 0.05767265f, 0.20958945f, 0.12647736f, 0.09721974f, 0.06174984f, -0.08229187f, 0.02153624f, 
    0.03503432f, -0.02460615f, 0.01307983f, 0.10353799f, -0.15488355f, 0.10156387f, 0.24700427f, 0.10472239f, 
    -0.04509775f, -0.00413048f, 0.00454421f, 0.02452787f, 0.06962468f, 0.07466053f, 0.02094039f, -0.02737307f, 
    -0.37499717f, -0.20620906f, 0.13640024f, 0.22250450f, -0.01452196f, 0.00532971f, -0.16401272f, -0.02755809f, 
    -0.08885479f, 0.08702056f, 0.05045709f, -0.06528252f, -0.12861282f, -0.05385352f, -0.26140746f, -0.26852813f, 
    0.04928881f, -0.04005330f, -0.08480342f, 0.04259191f, -0.05624432f, 0.08428351f, -0.02493303f, -0.00968134f, 
    -0.02898099f, 0.12631623f, 0.08983454f, 0.18842046f, 0.08239286f, -0.13511537f, 0.11432371f, -0.04659079f, 
    -0.06023292f, 0.10873131f, 0.08517160f, -0.02316090f, -0.18975271f, 0.35636976f, 0.13778234f, 0.21477701f, 
    0.03052784f, -0.00851487f, 0.13346323f, 0.05302100f, -0.04014489f, 0.12600797f, -0.09364467f, 0.06195012f, 
    -0.15708062f, 0.15582427f, -0.17465632f, -0.10800380f, -0.04777205f, -0.03283903f, 0.01652544f, -0.05384132f, 
    -0.01944286f, 0.01177361f, -0.01492131f, 0.08615945f, 0.59948349f, -0.26171902f, 0.01021751f, 0.38189435f, 
    0.09369648f, -0.12931205f, 0.06315547f, 0.00110924f, -0.04734777f, -0.01940922f, 0.06381978f, 0.14151497f, 
    0.04860492f, -0.08558790f, -0.01845371f, 0.02551732f, -0.08718194f, -0.05566748f, 0.05081075f, -0.06025730f, 
    -0.15192221f, -0.06845672f, -0.22437482f, -0.10737289f, -0.05670382f, -0.18991798f, -0.17244881f, -0.01629454f, 
    0.05704546f, 0.00399130f, 0.01436172f, 0.09326401f, -0.04026832f, 0.09573415f, 0.01234120f, -0.07884911f, 
    -0.25883278f, 0.02802287f, 0.28872454f, 0.17145531f, 0.11921651f, 0.01325032f, -0.15305504f, -0.00610081f, 
    -0.02878891f, -0.03633772f, 0.04161136f, -0.07921196f, -0.22637163f, -0.18674900f, -0.12463488f, 0.03163978f, 
    -0.03689074f, 0.02591441f, -0.06729461f, 0.00947263f, -0.06562679f, -0.01473582f, -0.02399377f, 0.01922710f, 
    -0.25325441f, 0.19192597f, 0.06865661f, 0.26917183f, -0.00693547f, -0.16521691f, 0.09318691f, -0.00907962f, 
    0.05296592f, 0.04162312f, -0.05546315f, 0.03580613f, -0.02081450f, -0.06502610f, 0.05077234f, 0.11639013f, 
    0.03427110f, -0.07768705f, -0.15918653f, 0.04735533f, -0.02448364f, -0.07108158f, 0.04800816f, -0.01313103f, 
    0.10061153f, 0.01640683f, -0.05582777f, 0.19399239f, 0.02456360f, 0.08307412f, -0.04107946f, 0.01317639f, 
    0.08016306f, 0.03743102f, 0.09013310f, -0.03822473f, -0.12477049f, 0.10522353f, 0.09470135f, 0.11611443f, 
    0.22215195f, 0.04454843f, 0.05079557f, -0.02319440f, -0.01597783f, 0.03173055f, 0.06299166f, -0.00688564f, 
    0.22039150f, 0.21089014f, 0.10417529f, 0.18146712f, -0.04696780f, -0.04196380f, -0.06055667f, -0.01876359f, 
    -0.02319641f, -0.01158941f, -0.05030600f, -0.13519390f, -0.06825222f, 0.08073143f, 0.02251927f, -0.01868548f, 
    0.00021068f, 0.00642653f, -0.04259591f, 0.07762698f, -0.12623492f, 0.09669613f, 0.02471368f, -0.04180946f, 
    0.04316270f, 0.07666225f, 0.24586657f, 0.18762732f, 0.04705371f, -0.04241545f, 0.06446195f, 0.07016166f, 
    0.06231834f, 0.03613761f, 0.03110249f, -0.00441515f, -0.16122092f, 0.04755884f, -0.17034844f, -0.04471082f, 
    0.06366326f, -0.04564803f, 0.07597290f, 0.05081995f, 0.07352219f, 0.08184186f, -0.16596769f, -0.02527337f, 
    0.19448258f, 0.06424358f, -0.28500953f, -0.12525491f, 0.05875209f, 0.05592488f, -0.02481746f, 0.01950721f, 
    -0.08241571f, -0.06316113f, -0.00702523f, 0.01980544f, -0.00659190f, 0.00979772f, -0.01979865f, 0.11769454f, 
    -0.03090027f, 0.03875284f, 0.00932753f, 0.11469404f, 0.01683945f, -0.01046758f, 0.01177761f, 0.03960717f, 
    -0.08760569f, 0.09773786f, 0.04608299f, 0.10578229f, 0.04779552f, -0.06694667f, -0.11831251f, -0.08579268f, 
    -0.00222177f, 0.09634618f, 0.05648879f, 0.02259803f, -0.07243713f, -0.11229059f, -0.10996696f, -0.00818306f, 
    0.11521055f, 0.05254283f, 0.02754184f, -0.03415453f, -0.00884300f, -0.22358519f, -0.20051633f, -0.18712759f, 
    0.07030692f, -0.13161649f, 0.18823594f, 0.09566796f, 0.06670801f, -0.00822532f, 0.05094802f, 0.01089315f, 
    -0.09828131f, 0.06535631f, 0.18760005f, 0.08524395f, 0.02856196f, -0.19363500f, -0.16267486f, -0.06153731f, 
    0.07378544f, -0.07307647f, 0.12296362f, -0.15565978f, -0.05757156f, -0.00010542f, -0.22523716f, -0.15781441f, 
    0.05753270f, 0.30600756f, 0.13748415f, 0.24716230f, 0.03524642f, 0.02026108f, 0.00721565f, -0.08085280f, 
    -0.00089935f, -0.06616041f, -0.07525744f, 0.02168904f, -0.32549822f, -0.02203275f, -0.15873183f, -0.35030279f, 
    -0.05923275f, 0.11303651f, -0.09118038f, -0.05170721f, 0.01030427f, -0.01954141f, -0.04820637f, 0.00707851f, 
    0.19878767f, 0.36471319f, 0.28347832f, 0.02043097f, 0.07280828f, 0.09905965f, -0.02313732f, 0.10058555f, 
    -0.02760864f, -0.05390871f, 0.04595599f, 0.16693708f, 0.00392702f, 0.28357828f, -0.09528793f, -0.17997225f, 
    0.06702387f, 0.19645730f, -0.00672282f, -0.09269790f, 0.10805867f, 0.25077346f, 0.12081160f, 0.00473298f, 
    -0.10315226f, 0.24589626f, 0.26153934f, -0.21015464f, -0.00588653f, 0.08166649f, -0.11623595f, 0.13967085f, 
    -0.04283825f, -0.08558048f, 0.03103935f, -0.03013358f, -0.14888744f, 0.35716808f, 0.18162721f, 0.08890930f, 
    0.16487990f, 0.03292463f, 0.16961280f, 0.01328333f, 0.00816704f, 0.01051505f, 0.06110065f, 0.20964813f, 
    -0.44483671f, 0.33500370f, -0.39715186f, 0.27282935f, -0.07076572f, -0.04857790f, -0.06403159f, -0.01228745f, 
    0.14524671f, -0.07407229f, -0.05583631f, 0.07841385f, -0.25561973f, 0.24750724f, -0.12108514f, 0.21872692f, 
    0.12976219f, -0.01014707f, -0.02343246f, 0.11680730f, -0.02175536f, -0.06758849f, 0.01665314f, -0.07090322f, 
    -0.23263288f, 0.11957579f, -0.13268755f, 0.35221750f, 0.03876091f, -0.04991619f, 0.08514103f, 0.09937274f, 
    0.05269309f, 0.06111136f, 0.08177746f, 0.02559822f, -0.92087728f, 0.13863319f, 0.04973985f, 0.30812001f, 
    0.19099024f, -0.02654218f, -0.03355594f, -0.37338343f, 0.07875150f, 0.02293022f, -0.08335715f, 0.15995164f, 
    0.00986081f, -0.12891003f, -0.00557107f, -0.17536882f, 0.03413676f, 0.03833806f, 0.09203726f, 0.00161129f, 
    0.06677568f, 0.10335229f, 0.06752818f, 0.27827334f, -0.11266792f, -0.10995313f, -0.14511374f, -0.01147003f, 
    0.18958546f, -0.00361224f, -0.11548816f, 0.19590075f, -0.01247055f, -0.14446063f, -0.07526277f, -0.02278641f, 
    0.24242631f, 0.27430189f, 0.20983851f, -0.00911999f, 0.07940763f, 0.09956158f, 0.07542408f, 0.15315716f, 
    -0.00885801f, -0.08159668f, -0.05521046f, 0.09142163f, 0.15924791f, -0.24868137f, 0.21573868f, -0.16398510f, 
    0.03541027f, 0.04788186f, -0.06557722f, -0.07199311f, -0.05538308f, -0.14451109f, 0.01819656f, -0.19417644f, 
    -0.01777567f, -0.19541192f, -0.33424515f, -0.39996150f, 0.00126626f, -0.01336560f, -0.11441338f, 0.09082289f, 
    0.13227493f, -0.13836175f, -0.19152944f, -0.02709125f, 0.21946371f, -0.18858318f, 0.10518543f, -0.24907312f, 
    0.08367446f, 0.10329854f, -0.02238761f, 0.08063406f, 0.02312468f, -0.15450601f, -0.16047592f, -0.18823023f, 
    0.34311897f, -0.30444479f, 0.13215625f, -0.31767455f, 0.02767311f, -0.16888869f, 0.02222847f, -0.12780577f, 
    0.15047924f, 0.18536395f, 0.00473319f, 0.00334388f, 0.30307868f, 0.06395274f, -0.00452369f, 0.11406533f, 
    -0.00369206f, 0.07290187f, -0.09329243f, 0.00753143f, -0.03767705f, -0.05081207f, 0.04943644f, -0.16540015f, 
    -0.08270307f, 0.06227808f, -0.00746431f, -0.01071923f, 0.18723819f, -0.00789420f, 0.10552037f, -0.04101417f, 
    0.02072106f, -0.02861327f, 0.19350775f, 0.10851828f, 0.00781545f, -0.17050691f, -0.06263652f, 0.13622798f, 
    0.06946389f, 0.01670500f, -0.04945666f, 0.05471047f, 0.07949515f, -0.03761340f, 0.10383060f, -0.01537888f, 
    -0.14302883f, -0.07117027f, -0.04263669f, 0.13472188f, 0.05407854f, 0.02266817f, 0.18284588f, -0.09275936f, 
    0.06145311f, -0.07419823f, 0.10396463f, 0.05928728f, -0.07879395f, -0.02728022f, 0.14035538f, 0.22012313f, 
    -0.06971327f, 0.08036357f, -0.01966764f, -0.05761591f, 0.04228582f, 0.00002101f, 0.03694179f, 0.11784071f, 
    0.25219584f, 0.08353817f, 0.21245633f, 0.01192701f, 0.13351156f, 0.02707171f, -0.01772314f, 0.26118785f, 
    0.03152066f, -0.00902952f, -0.05685386f, -0.01667719f, -0.35099664f, -0.15552479f, -0.05815516f, 0.18076804f, 
    0.01067462f, 0.09564579f, -0.17245385f, -0.04053912f, 0.06250963f, -0.00264225f, -0.07820497f, -0.09485959f, 
    -0.14287020f, -0.00307747f, 0.09354562f, -0.51450676f, -0.02044500f, 0.03849253f, -0.05908356f, -0.04426162f, 
    0.07363033f, 0.10973921f, 0.04992959f, 0.14239545f, 0.31519210f, 0.02166781f, 0.00312673f, -0.23585029f, 
    -0.01504743f, -0.04186431f, 0.20367217f, 0.36625171f, 0.03676576f, 0.03748647f, 0.01634555f, -0.01364053f, 
    -0.26106647f, -0.05803258f, -0.07298214f, 0.20987317f, 0.14367734f, -0.03154226f, -0.03165195f, -0.19185935f, 
    -0.10819697f, -0.00155910f, -0.13255422f, -0.16344728f, -0.01191295f, -0.01777485f, 0.16691899f, 0.16411994f, 
    -0.05090915f, 0.02207803f, -0.12936778f, -0.10008410f, -0.17625503f, 0.03430961f, 0.05565849f, -0.03442449f, 
    0.10835985f, -0.37334916f, 0.27549157f, -0.33907029f, -0.19602685f, -0.03637709f, -0.14818476f, 0.04790269f, 
    0.19227315f, -0.00085847f, 0.15281031f, 0.14668769f, -0.14182982f, -0.03690946f, 0.23023604f, 0.02112263f, 
    0.18366529f, 0.07745799f, -0.00115657f, -0.13025409f, -0.01596649f, -0.16490194f, -0.10535361f, 0.00318549f, 
    -0.13253030f, -0.00795699f, 0.11667153f, -0.12022331f, 0.08120568f, -0.04410623f, 0.01218772f, 0.00764278f, 
    0.10175665f, 0.06678398f, 0.12367903f, 0.08947787f, 0.29139674f, 0.19312574f, -0.16892397f, -0.06317854f, 
    0.08458294f, -0.03726496f, 0.16085775f, 0.06872178f, 0.06981061f, -0.00799118f, -0.02862343f, 0.04470687f, 
    0.31810036f, 0.20303537f, 0.19021904f, -0.05389198f, 0.07439880f, 0.13333654f, 0.04966029f, 0.07857405f, 
    0.03442676f, -0.02100734f, 0.03837170f, 0.00682252f, 0.17914326f, -0.09236491f, -0.01985006f, -0.36038169f, 
    -0.06474823f, -0.00598828f, 0.03221603f, -0.11604340f, 0.11521646f, -0.02099036f, 0.04278923f, 0.12533714f, 
    -0.02148323f, -0.07335028f, 0.05981291f, -0.21506706f, 0.15734223f, 0.07073943f, -0.07453302f, 0.05604807f, 
    -0.00243903f, -0.14880182f, -0.31143999f, -0.10336562f, 0.03616280f, 0.29095972f, -0.11853119f, 0.04302273f, 
    -0.02746881f, 0.10422381f, 0.19679108f, 0.01075277f, -0.04345505f, -0.01580432f, 0.00552463f, 0.08225220f, 
    0.63856405f, -0.30943298f, 0.34597829f, -0.06879059f, -0.11985686f, -0.13964243f, -0.05718758f, 0.01141410f, 
    0.11966116f, -0.00469858f, -0.03192702f, 0.20835844f, -0.11794526f, -0.13287413f, -0.10612237f, 0.04698879f, 
    0.01740395f, -0.02080959f, -0.01900353f, -0.06901369f, -0.05975921f, -0.00514878f, -0.18748647f, 0.02950827f, 
    -0.19592050f, 0.02786270f, -0.51496738f, -0.29527566f, -0.15881498f, 0.05699580f, 0.01858490f, -0.04360276f, 
    0.06110138f, 0.07968810f, 0.01211906f, 0.19316013f, -0.19823414f, -0.12439983f, -0.26989591f, 0.00840639f, 
    0.01018663f, 0.12737641f, 0.08304907f, 0.20932423f, 0.01611199f, 0.00177364f, 0.07878814f, 0.12515764f, 
    0.10634832f, 0.10982575f, -0.06733843f, -0.09705199f, 0.12375730f, 0.01571361f, -0.07757358f, 0.10036862f, 
    -0.02128702f, -0.05389709f, 0.04513702f, 0.06543195f, 0.47153130f, -0.11924300f, 0.53320485f, 0.29361382f, 
    -0.05537607f, -0.12575974f, -0.24756184f, -0.20361595f, 0.04092630f, 0.13989653f, 0.05257607f, 0.08460883f, 
    0.12892483f, 0.10957468f, 0.08257835f, -0.16235521f, -0.01782534f, 0.00926170f, 0.00043470f, -0.17276864f, 
    0.01837745f, -0.08356404f, -0.00484234f, 0.04037343f, 0.38046628f, -0.24413449f, -0.29664269f, -0.32629633f, 
    0.03483677f, 0.00051421f, -0.18960874f, 0.13928595f, -0.01358282f, -0.09047628f, 0.13548610f, -0.01020545f, 
    0.05727626f, -0.03478676f, 0.08359124f, 0.15331656f, -0.03866671f, -0.06288768f, -0.19546483f, -0.20137717f, 
    0.05831542f, -0.03603191f, -0.09140557f, -0.07797433f, -0.39373422f, 0.49733025f, -0.04111919f, -0.19972801f, 
    -0.06354722f, 0.18562600f, 0.09189604f, 0.03492922f, 0.04055673f, 0.04276180f, 0.12182041f, 0.19194788f, 
    -0.20112409f, -0.00219489f, -0.12640458f, -0.10366295f, 0.16693684f, 0.02638158f, -0.07831164f, -0.05796021f, 
    0.09670196f, 0.02334869f, 0.09293900f, -0.03569544f, 0.17631187f, 0.25353113f, 0.13958684f, -0.10014545f, 
    0.12943751f, 0.02618043f, 0.18709031f, 0.10535138f, 0.00042431f, -0.13081381f, -0.00601336f, 0.03525077f, 
    0.17209932f, -0.17042860f, -0.09316298f, -0.19055697f, -0.08737425f, 0.01951375f, 0.06408766f, 0.10093258f, 
    0.07709669f, 0.06001362f, 0.09821781f, 0.02271616f, 0.26365572f, 0.12292780f, 0.11694036f, -0.07523564f, 
    0.14642227f, -0.04299214f, 0.19733705f, 0.33959815f, -0.01224586f, -0.07518702f, 0.00530496f, 0.04440184f, 
    0.10137568f, 0.24060620f, 0.05269886f, -0.43201545f, -0.00979903f, 0.10062198f, -0.04308036f, 0.05089116f, 
    0.01256034f, 0.08209510f, 0.02543914f, 0.02622746f, -0.06579229f, -0.03313636f, -0.24428116f, -0.21893819f, 
    -0.00662009f, -0.02075390f, 0.03366521f, -0.03308921f, 0.04472521f, -0.00318173f, -0.08989402f, 0.09534775f, 
    -0.17033298f, 0.22786890f, -0.15272389f, 0.11914919f, 0.10839039f, -0.02966619f, 0.23735920f, -0.17337815f, 
    -0.16616809f, 0.08927052f, 0.05073011f, -0.12176802f, 0.17328897f, -0.12075218f, -0.08800668f, -0.09145223f, 
    -0.01029905f, 0.05466593f, 0.05648502f, 0.31796208f, -0.06604195f, -0.11244972f, -0.03299456f, 0.00394942f, 
    -0.14127648f, 0.32968044f, -0.32723680f, -0.26167381f, 0.15057079f, 0.04567142f, -0.06353407f, 0.06480390f, 
    -0.03672661f, 0.08746473f, -0.07580350f, 0.11952306f, 0.38816822f, 0.05783502f, 0.23163162f, 0.14344116f, 
    -0.11715574f, 0.09485691f, -0.15314250f, -0.02821505f, -0.01087893f, -0.13775188f, -0.03620754f, -0.01996535f, 
    0.37037042f, 0.04699315f, 0.09895229f, -0.03494468f, -0.00398869f, -0.01966870f, -0.01195920f, -0.04379369f, 
    0.05660403f, 0.07171443f, 0.05042784f, 0.11018430f, 0.27921131f, -0.04804577f, 0.26678482f, 0.30755445f, 
    0.08673241f, -0.01613621f, -0.07679588f, -0.15180299f, 0.12522662f, 0.11564480f, 0.12717839f, 0.26565579f, 
    -0.09546068f, -0.05044744f, 0.31935409f, 0.13795581f, -0.06996258f, 0.15764548f, -0.17039047f, 0.05155585f, 
    0.07632983f, -0.01716064f, -0.07193574f, -0.03376730f, 0.25202712f, -0.01153309f, 0.09726311f, 0.11365804f, 
    -0.00613940f, 0.04838333f, 0.09214508f, -0.09695671f, 0.01070264f, -0.14977057f, 0.11832228f, -0.01099462f, 
    0.14837354f, 0.07806646f, 0.07596584f, -0.14779145f, 0.06294908f, 0.00135585f, 0.04537105f, -0.00360707f, 
    -0.06329456f, -0.05601600f, -0.07688974f, 0.07168076f, -0.03635579f, -0.06313037f, -0.05150831f, -0.10060807f, 
    -0.05603634f, 0.01203980f, -0.02406364f, -0.01899520f, 0.03344445f, 0.00513099f, -0.13827085f, -0.11956790f, 
    0.01123452f, -0.07513186f, 0.04477678f, 0.05345655f, -0.00508917f, -0.08581522f, -0.01149335f, 0.07467259f, 
    0.12746380f, 0.09753975f, -0.01447359f, -0.14128159f, -0.13694873f, 0.06093689f, 0.05195073f, -0.06475143f, 
    -0.01381150f, -0.07197436f, -0.08796521f, -0.15043701f, -0.13372298f, 0.14584248f, 0.12047326f, 0.02723397f, 
    0.00808487f, -0.04242335f, -0.21694881f, -0.02146523f, 0.10266306f, -0.14539889f, 0.18668400f, 0.03468284f, 
    0.03090609f, 0.15648031f, 0.03938523f, -0.09435084f, -0.07407511f, 0.23849970f, 0.01278758f, -0.00675587f, 
    -0.15437695f, 0.01325600f, -0.08176348f, -0.12716307f, 0.12864128f, -0.00777245f, 0.14361738f, 0.16726927f, 
    -0.06768163f, -0.11703890f, 0.05917801f, -0.05246503f, -0.06220474f, -0.09312037f, -0.04879103f, 0.06962131f, 
    -0.01560224f, -0.10510289f, -0.02959663f, 0.08129368f, -0.25411156f, -0.14454971f, 0.09260282f, -0.02258445f, 
    0.03326492f, 0.03065624f, 0.01439674f, 0.00617214f, -0.08962452f, -0.00114661f, -0.01907989f, -0.03404410f, 
    0.12536326f, -0.21256396f, -0.13104026f, 0.29456314f, 0.01566627f, 0.04071943f, -0.05378799f, 0.10510787f, 
    0.08076648f, -0.07014295f, 0.18241586f, 0.10333952f, 0.25047913f, -0.07579662f, 0.01729228f, 0.12950918f, 
    0.04729291f, 0.00225154f, 0.13713272f, 0.09140572f, 0.02539311f, -0.08377062f, -0.06161301f, 0.01662507f, 
    0.00112662f, 0.21565968f, 0.12114792f, -0.02070912f, 0.08090287f, 0.02079504f, 0.06459424f, -0.06581991f, 
    -0.00170550f, 0.07884384f, 0.00463192f, 0.10654446f, 0.13955466f, 0.41209808f, -0.08575652f, -0.12062767f, 
    0.02752046f, -0.00208802f, -0.05788388f, 0.08124979f, -0.04367179f, 0.03445612f, -0.04272920f, 0.14194071f, 
    0.06578556f, 0.04079273f, -0.01203222f, -0.03916427f, -0.06129508f, 0.13605456f, -0.05753407f, 0.08807904f, 
    0.08520923f, 0.10857432f, 0.11628968f, -0.03312266f, 0.56400871f, -0.05470426f, 0.01575022f, -0.11058838f, 
    0.09144592f, 0.01873007f, 0.00456492f, 0.13386458f, -0.01150473f, -0.01616870f, 0.04114410f, -0.02086281f, 
    -0.21467705f, -0.07251734f, -0.02393841f, -0.05850667f, -0.07910874f, 0.19633242f, 0.04307886f, 0.07108750f, 
    0.21202640f, 0.12139796f, 0.03890151f, -0.07306597f, -0.29871321f, 0.03277376f, -0.02815755f, 0.17422992f, 
    0.00721202f, -0.09298427f, -0.01396734f, -0.05966118f, 0.04517926f, -0.09928460f, -0.11728539f, 0.05598206f, 
    -0.08415215f, -0.03982048f, 0.07488120f, 0.00997523f, -0.00872455f, -0.07949049f, 0.03509484f, 0.03463591f, 
    0.03792665f, 0.00378233f, -0.02315194f, -0.05114284f, 0.01677153f, -0.06374885f, -0.06450269f, -0.11038733f, 
    -0.30321550f, -0.08284236f, -0.01706656f, -0.05903984f, -0.08821294f, -0.16168015f, 0.07988270f, 0.03370859f, 
    -0.02020718f, -0.11680119f, -0.12686610f, 0.18952759f, 0.02830249f, -0.06126262f, -0.06613403f, -0.01853643f, 
    -0.04541079f, -0.00400519f, 0.00413525f, 0.13356708f, 0.20520779f, -0.14970133f, -0.01479814f, -0.23104718f, 
    0.01131155f, -0.01971538f, -0.02207605f, 0.12167385f, 0.04695058f, -0.03434131f, -0.08467653f, -0.13526928f, 
    -0.19094466f, 0.12682091f, 0.10313483f, -0.02380945f, 0.10346823f, 0.00060223f, -0.05598422f, -0.04009346f, 
    0.08858643f, -0.05340563f, 0.03432121f, 0.14505021f, -0.09144119f, 0.03488213f, -0.05051557f, -0.08306638f, 
    0.11319864f, 0.00141800f, -0.15413904f, 0.06630529f, -0.03718650f, 0.16090167f, 0.04121847f, -0.06875350f, 
    -0.08838449f, -0.20328201f, 0.06069541f, 0.12902400f, -0.05042984f, -0.04797009f, 0.05259633f, 0.06419261f, 
    -0.05387779f, 0.00564254f, 0.09956685f, -0.22861947f, -0.06125598f, 0.05199787f, -0.08410008f, -0.13660075f, 
    -0.07214482f, -0.04577843f, -0.01530598f, -0.02084872f, -0.00635775f, 0.01121397f, 0.04192491f, 0.02433999f, 
    -0.05189870f, 0.03974317f, 0.20523831f, -0.02093413f, 0.00906145f, 0.06334386f, -0.03952706f, 0.00363531f, 
    0.02425352f, 0.15582880f, 0.06575738f, -0.12975676f, -0.20268634f, -0.12619495f, -0.11791878f, -0.17247631f, 
    -0.16722718f, -0.17955619f, -0.13735917f, -0.07164779f, -0.09992887f, -0.05471223f, 0.02050760f, -0.04927471f, 
    -0.04259482f, 0.01707282f, -0.12102491f, -0.10797215f, 0.21432264f, -0.00202688f, 0.02508605f, 0.20161220f, 
    0.09694301f, 0.02513454f, -0.02453364f, 0.00656587f, 0.33741480f, -0.04051470f, -0.13501914f, 0.14096712f, 
    0.00044792f, -0.01676884f, -0.04633922f, 0.05229857f, -0.02650898f, 0.00897482f, -0.11407685f, -0.03977818f, 
    0.00358761f, 0.30028978f, -0.02341848f, 0.19183043f, -0.04803640f, 0.22390179f, -0.06740133f, 0.05830308f, 
    0.07261981f, 0.10481358f, 0.03421373f, 0.00257440f, -0.03596507f, 0.37677091f, 0.05493970f, -0.09112347f, 
    -0.03326578f, 0.07132338f, 0.02069172f, 0.02353279f, -0.05454826f, -0.03328957f, 0.04741453f, 0.04317748f, 
    0.26608184f, 0.29947671f, -0.05545583f, 0.17064671f, 0.00954116f, -0.02614250f, -0.08451397f, -0.04083983f, 
    0.04730001f, -0.01046194f, 0.00854377f, 0.05688948f, -0.04247395f, 0.09514333f, -0.06296451f, -0.21715584f, 
    -0.09854428f, -0.05252563f, -0.03295451f, 0.00346594f, -0.00954348f, 0.04524404f, 0.04532710f, 0.03534056f, 
    -0.07001434f, -0.14339666f, 0.21572788f, -0.29794353f, -0.12314919f, 0.05651431f, -0.03609639f, 0.03253847f, 
    0.05744219f, -0.06566210f, 0.01322698f, -0.13985176f, 0.07832184f, -0.01898960f, -0.09605579f, 0.05679651f, 
    -0.08369261f, 0.00049082f, 0.07860507f, -0.05519770f, -0.00971529f, 0.02935102f, 0.07369254f, 0.00208940f, 
    -0.11268693f, 0.01705451f, 0.19413975f, -0.02796678f, -0.07029796f, 0.06913459f, -0.07863437f, 0.09545135f, 
    -0.02188898f, -0.02171740f, -0.08950597f, 0.06831238f, -0.16609891f, -0.09363959f, -0.12201373f, 0.01964933f, 
    0.10140123f, 0.02078191f, 0.09213824f, -0.01904096f, -0.04682910f, -0.08657246f, 0.02594563f, -0.06321973f, 
    -0.19277175f, -0.16196050f, -0.04911336f, -0.06413337f, -0.05739819f, 0.01581482f, 0.03170401f, -0.08166386f, 
    -0.04613845f, 0.01130747f, -0.08990537f, -0.04610584f, -0.35590270f, 0.17189892f, 0.08534624f, 0.07611594f, 
    -0.01068578f, 0.07402551f, 0.14586805f, 0.12793091f, -0.02510689f, 0.10670277f, 0.07592309f, 0.01886770f, 
    0.02649504f, -0.17831746f, -0.04788205f, -0.08145397f, -0.10701475f, -0.10054188f, -0.13032851f, 0.07759044f, 
    0.02094897f, -0.09733412f, -0.07594272f, -0.00451644f, 0.06114308f, -0.05595143f, -0.03155793f, 0.02422181f, 
    0.09259436f, 0.08914154f, 0.01626024f, -0.08547636f, 0.03143717f, 0.13076822f, -0.00830254f, -0.04804364f, 
    -0.16918898f, -0.10401460f, 0.17001916f, -0.12724604f, 0.09730688f, 0.02272424f, 0.09619403f, -0.06162056f, 
    -0.03048038f, 0.01442629f, 0.22396386f, 0.03133643f, 0.28482020f, -0.09532775f, -0.05030814f, 0.12734662f, 
    0.12554242f, -0.03433223f, 0.08101717f, -0.18036729f, 0.05829670f, 0.00280141f, -0.00264132f, -0.02496163f, 
    -0.08399549f, -0.02622760f, 0.06175697f, 0.00727978f, -0.02136119f, 0.02340093f, -0.07921101f, 0.05560353f, 
    0.05511175f, -0.07204325f, 0.00876874f, -0.03823512f, -0.26864764f, -0.13312051f, 0.21840191f, 0.09936361f, 
    -0.07015086f, 0.01946486f, 0.10957416f, -0.02468173f, -0.04142221f, 0.09053420f, 0.06036050f, -0.00639643f, 
    -0.10226984f, 0.14701003f, 0.17905909f, -0.00167056f, -0.08389723f, -0.03968361f, -0.02799904f, -0.11034192f, 
    0.01506657f, 0.01457511f, -0.01155636f, -0.04874096f, 0.21238713f, -0.27636606f, 0.10125419f, -0.23692828f, 
    0.03104059f, -0.04794532f, 0.10626450f, 0.03225426f, 0.15452816f, 0.07052220f, 0.16812271f, 0.00505802f, 
    -0.09421011f, 0.10829863f, 0.24342920f, -0.02280994f, 0.15408561f, -0.06543735f, 0.11705781f, -0.07302013f, 
    -0.11876073f, 0.10612424f, 0.12198115f, 0.01680299f, -0.09738389f, 0.37805879f, 0.08293719f, 0.27916625f, 
    0.00492672f, 0.07442103f, -0.02546074f, -0.01236009f, 0.03891413f, 0.10545048f, 0.14422041f, 0.00946733f, 
    -0.06124758f, -0.05142122f, -0.02365664f, -0.05972311f, -0.00301736f, -0.09570771f, -0.09088451f, -0.05995826f, 
    0.10387848f, 0.09488859f, 0.07186635f, 0.16049647f, 0.19412111f, 0.06542868f, -0.01919830f, 0.19317138f, 
    0.04504127f, 0.09438696f, -0.00536684f, 0.06066679f, -0.05503072f, -0.02015967f, -0.00032986f, 0.10769207f, 
    -0.08819789f, -0.07569417f, -0.16920762f, -0.20470355f, -0.07639777f, -0.08052871f, -0.09021422f, 0.09471048f, 
    -0.17832683f, -0.03507155f, -0.04537326f, -0.12159754f, -0.10102561f, -0.20324856f, -0.15637340f, -0.09385420f, 
    0.10509761f, 0.10251746f, 0.05727927f, 0.10759346f, -0.05511902f, -0.04319134f, -0.02751353f, -0.05096352f, 
    -0.22312556f, 0.12437062f, 0.14981735f, -0.05958676f, 0.03270763f, -0.04782119f, 0.02796958f, -0.05319700f, 
    0.01264923f, 0.02950951f, 0.10147829f, 0.03400088f, -0.14211191f, -0.03912663f, -0.21770392f, -0.10035355f, 
    0.12024680f, 0.00804931f, 0.07700226f, 0.04053213f, -0.03876680f, -0.14039201f, -0.00526555f, 0.01428781f, 
    -0.32517788f, 0.21908388f, -0.08638822f, 0.15162382f, -0.05065345f, -0.06148794f, 0.05834544f, 0.03847560f, 
    -0.14860834f, 0.02380273f, 0.04161862f, 0.12556571f, -0.13063215f, 0.04735725f, -0.00754645f, -0.04816710f, 
    -0.00873402f, -0.05899004f, -0.07740134f, -0.03590125f, 0.05700677f, 0.00639509f, 0.12468371f, 0.11708137f, 
    0.12143452f, -0.03797158f, -0.18677741f, 0.14129888f, 0.10396260f, 0.05153521f, -0.00967980f, -0.08815194f, 
    0.25101352f, -0.02933994f, -0.01825091f, 0.02475280f, -0.12742431f, 0.34821570f, 0.00563938f, 0.04361987f, 
    -0.02334726f, 0.19398504f, 0.03146622f, -0.01700592f, -0.02709879f, 0.00180716f, 0.11743192f, 0.07980736f, 
    0.00249531f, 0.05870725f, -0.24983306f, 0.16652592f, 0.13128285f, 0.10586342f, -0.20451103f, 0.00873079f, 
    -0.06878048f, 0.16512378f, 0.15198484f, 0.09512877f, -0.10708056f, -0.18684715f, 0.14950217f, 0.01026927f, 
    0.11882532f, -0.00318954f, -0.16593394f, 0.05076066f, 0.02362162f, 0.00226545f, 0.07804869f, 0.03387275f, 
    -0.08852284f, -0.18143873f, 0.04124437f, 0.01380188f, -0.00883096f, -0.06005721f, 0.07143969f, 0.04399655f, 
    0.07946850f, 0.08116556f, 0.08142197f, -0.01917724f, 0.17970960f, -0.01533533f, -0.00916477f, -0.14936985f, 
    0.08785216f, 0.06518201f, 0.07740161f, -0.08751507f, 0.00454315f, 0.05727445f, -0.10735653f, -0.00742350f, 
    0.44427246f, -0.22749470f, 0.05189000f, -0.00599277f, 0.13076679f, 0.10639978f, -0.05258985f, 0.09260358f, 
    0.00854084f, 0.02341384f, -0.02487321f, -0.06245659f, -0.03217848f, -0.12734090f, 0.07069941f, 0.07333821f, 
    -0.03830801f, 0.08571143f, -0.15987010f, -0.00321094f, 0.07592428f, 0.02477149f, -0.12126571f, 0.09051234f, 
    -0.20064467f, -0.19624288f, 0.11711136f, 0.05885739f, 0.22127284f, -0.01082797f, -0.06858627f, 0.09165858f, 
    0.08957059f, 0.03857160f, -0.03805296f, -0.02710170f, -0.02060600f, -0.02617833f, 0.01460577f, -0.03990305f, 
    0.00551986f, 0.08577242f, 0.02628919f, -0.01545421f, 0.08291079f, -0.03751798f, -0.07228258f, -0.02224712f, 
    0.25221425f, -0.17386146f, -0.02858840f, 0.08013555f, 0.06235601f, 0.01190993f, 0.01455224f, -0.02083859f, 
    0.09375903f, 0.10647646f, 0.04606649f, 0.05148437f, -0.05064791f, -0.22515611f, -0.11132555f, -0.25814080f, 
    0.00489196f, -0.01897788f, 0.04158863f, 0.02130574f, -0.03324367f, -0.01605337f, -0.06851276f, -0.03365375f, 
    -0.01432903f, -0.03394064f, -0.07375638f, 0.08463883f, 0.06193739f, -0.14211400f, 0.03736112f, -0.18717784f, 
    0.06021553f, 0.05650048f, -0.02713908f, 0.05311262f, -0.08936872f, -0.00014067f, -0.05834209f, -0.00939066f, 
    0.08792561f, -0.03717842f, 0.04033888f, 0.09873749f, 0.05717249f, 0.03384978f, 0.18419072f, 0.25253507f, 
    -0.23012502f, -0.00459050f, 0.05679255f, 0.06426573f, -0.12437829f, -0.13841575f, -0.00757347f, 0.04024112f, 
    0.00983425f, -0.02895311f, 0.05990942f, 0.05206878f, 0.01439216f, 0.10599043f, -0.04319514f, -0.10930218f, 
    -0.05090582f, 0.11626489f, 0.04398622f, -0.01808524f, -0.02219862f, -0.01449217f, -0.04603120f, -0.02420560f, 
    0.05078613f, -0.04889966f, 0.02834443f, 0.27581388f, 0.12235741f, -0.15401930f, -0.04410967f, 0.00193224f, 
    0.05348905f, -0.12028676f, 0.02369161f, 0.02450479f, -0.37972867f, 0.11991832f, 0.06818869f, -0.02342744f, 
    0.06093506f, -0.12579241f, 0.07773148f, -0.02787707f, 0.03937748f, -0.01154544f, 0.01483391f, -0.00957102f, 
    -0.07762305f, 0.34903207f, -0.44469047f, 0.22058882f, 0.20415586f, 0.04967804f, 0.11898470f, -0.03171116f, 
    0.04404370f, -0.07028740f, -0.14472058f, 0.01688690f, -0.26244965f, 0.17824014f, -0.09533633f, 0.04462193f, 
    0.17773221f, 0.09665665f, -0.09394710f, 0.01521161f, 0.01267249f, 0.01336122f, 0.01429334f, -0.00516522f, 
    -0.09378585f, 0.17864063f, -0.29041871f, -0.05897863f, 0.08147167f, 0.00692485f, 0.02221372f, 0.03540955f, 
    0.09208957f, 0.11609453f, 0.17817546f, 0.00120626f, -0.01394066f, -0.16217229f, -0.14254065f, 0.13066475f, 
    0.18475080f, -0.04693995f, -0.11455685f, 0.06095017f, -0.07140304f, 0.06435328f, 0.01201657f, 0.06498103f, 
    0.13830367f, -0.00155708f, 0.09194069f, -0.22483468f, -0.01538529f, 0.03882296f, 0.17579022f, -0.01088930f, 
    0.10806813f, 0.06362536f, 0.17333364f, -0.01115650f, 0.02925304f, 0.12185482f, 0.00034413f, -0.14507270f, 
    0.09043391f, -0.10661862f, 0.07206426f, 0.09503555f, 0.06095798f, -0.03894947f, -0.03360669f, -0.03870963f, 
    -0.12126709f, 0.02564269f, 0.24149835f, -0.02507805f, -0.07271316f, -0.09865595f, 0.00635499f, 0.06274034f, 
    0.06557919f, 0.10198940f, -0.04763702f, -0.03687276f, 0.10161852f, -0.05834249f, 0.12207691f, 0.02640919f, 
    -0.05636069f, -0.10833673f, 0.03026447f, 0.08029776f, -0.01649722f, -0.12621693f, -0.05864574f, -0.00059883f, 
    0.20939104f, -0.05758802f, -0.43203878f, 0.04622631f, -0.03931849f, -0.02572805f, -0.03728238f, 0.10914559f, 
    0.09707536f, -0.05874440f, -0.08405269f, 0.03466791f, 0.06041769f, -0.35837784f, 0.03017889f, 0.06381923f, 
    -0.05891431f, -0.14151494f, -0.11261894f, 0.07536583f, 0.07787515f, -0.03147525f, -0.04864956f, 0.04097267f, 
    0.23017393f, -0.32264304f, 0.33739546f, -0.35244617f, 0.09308106f, 0.02925941f, -0.00830324f, 0.06050583f, 
    0.06642427f, -0.05050707f, 0.04426597f, 0.11211137f, 0.09078747f, -0.02676766f, -0.13848749f, 0.18088938f, 
    0.06136643f, 0.02310421f, 0.02763234f, 0.00211173f, 0.02846048f, -0.01443923f, -0.06824099f, 0.04652264f, 
    0.29016021f, 0.00357842f, -0.18909556f, 0.06351796f, 0.10636684f, -0.02935252f, 0.19050917f, -0.12257085f, 
    -0.04784454f, -0.10904789f, -0.01826480f, -0.03146000f, -0.01057867f, -0.01359813f, 0.08670849f, 0.16574676f, 
    -0.00611449f, 0.00043548f, -0.05341451f, 0.03411633f, 0.01845055f, -0.12714209f, 0.02085651f, -0.04580384f, 
    0.30077687f, 0.03674654f, -0.06396992f, -0.50403005f, 0.05410248f, 0.02441463f, 0.11385411f, -0.05269671f, 
    0.03957181f, -0.05452221f, 0.03445498f, -0.15053074f, -0.00819231f, 0.00622149f, 0.01670031f, -0.05703397f, 
    -0.06302634f, -0.05595070f, -0.00702275f, 0.02173227f, -0.02141496f, -0.13565503f, 0.02237730f, 0.13573794f, 
    0.02174714f, -0.31368008f, 0.32864320f, 0.02281141f, -0.07523117f, -0.08225214f, -0.04301992f, 0.11762352f, 
    0.10682402f, 0.09297265f, 0.02569855f, 0.01174320f, 0.09331802f, -0.07848924f, -0.02782889f, 0.18145660f, 
    0.22515282f, 0.00671636f, 0.01413563f, 0.04108533f, 0.11682415f, 0.09945424f, 0.01043696f, 0.00585370f, 
    0.17119800f, 0.24198650f, 0.12457237f, -0.24567127f, 0.08451767f, 0.07666759f, 0.00470288f, -0.13221778f, 
    0.01459582f, 0.26201621f, 0.08328369f, -0.08398429f, 0.04489854f, 0.01966479f, 0.01719478f, -0.28969473f, 
    0.12692253f, 0.06590118f, 0.10318509f, 0.01487340f, 0.03807584f, 0.03226050f, -0.02144906f, 0.00964558f, 
    0.07850619f, 0.12827784f, -0.18673715f, 0.25534081f, 0.17041087f, 0.00840995f, 0.07790928f, 0.06816927f, 
    0.00563021f, -0.03083967f, 0.03866047f, -0.09561118f, 0.13627423f, 0.06522162f, 0.10104492f, 0.02879818f, 
    0.06510294f, -0.05224038f, -0.08061510f, -0.01201294f, -0.14206220f, -0.09772500f, 0.05222351f, 0.00302605f, 
    0.40244022f, -0.21432441f, 0.04166998f, -0.01387731f, 0.08881053f, 0.01065124f, -0.06890552f, 0.06952403f, 
    0.17888664f, -0.04865902f, -0.07700128f, 0.05993356f, 0.37053314f, 0.01231189f, 0.18396778f, 0.14031753f, 
    0.14714344f, 0.02863398f, 0.02337200f, -0.01775232f, 0.04284392f, -0.02355927f, -0.03181570f, -0.00777310f, 
    0.00372769f, 0.10005955f, 0.04680172f, 0.10384662f, 0.06904874f, -0.06856838f, 0.14107141f, 0.05476861f, 
    -0.07962987f, 0.12001770f, -0.14212261f, 0.16939582f, -0.00774804f, -0.09025239f, -0.04238717f, -0.05446066f, 
    0.02547157f, -0.05991438f, 0.03432293f, -0.08789357f, -0.08237272f, 0.07133052f, -0.01273241f, 0.03468752f, 
    -0.03222746f, -0.01557911f, 0.13168153f, -0.02516538f, -0.09917032f, -0.03156124f, 0.01921169f, -0.12699269f, 
    0.00639573f, 0.02895609f, 0.06885628f, 0.00898620f, 0.01252993f, 0.22642909f, 0.10329627f, -0.13846494f, 
    -0.09738421f, 0.06187690f, 0.16338298f, 0.06404038f, 0.02127746f, -0.03801048f, -0.03373270f, 0.17129764f, 
    0.07517710f, -0.09219660f, -0.06435613f, 0.05892304f, 0.09961191f, 0.01080578f, 0.04562098f, 0.09031410f, 
    0.05465153f, -0.04194320f, -0.07418969f, -0.04266304f, -0.10953175f, 0.15601783f, -0.00657735f, -0.11154947f, 
    0.00628076f, -0.05971937f, 0.02868372f, -0.03155198f, 0.01843407f, 0.00971144f, -0.04707254f, -0.00650940f, 
    0.15658341f, -0.26891762f, 0.19993523f, -0.07415800f, -0.07578333f, -0.02602534f, 0.05141766f, 0.11781966f, 
    0.07901539f, -0.03195518f, -0.00507505f, 0.07101360f, 0.16974053f, 0.15086523f, -0.14074972f, 0.47348079f, 
    0.10705660f, 0.02300984f, -0.20757814f, -0.03113457f, 0.09694288f, -0.06591368f, 0.00734168f, 0.00286872f, 
    0.04853637f, 0.12362354f, -0.16912912f, -0.23549305f, 0.04975647f, -0.10153320f, 0.12427090f, 0.12685110f, 
    0.15203762f, -0.04310000f, -0.08038578f, 0.05509531f, 0.10841197f, 0.14297783f, -0.24889149f, 0.08330528f, 
    0.02658229f, 0.08380955f, 0.11129070f, 0.11349849f, -0.04250955f, -0.06766348f, 0.05464167f, 0.04712355f, 
    -0.08219764f, -0.03191712f, 0.25441843f, -0.24894235f, 0.14037384f, 0.03779164f, 0.02654265f, 0.08982217f, 
    0.08069597f, -0.03301645f, -0.11096507f, 0.00931990f, 0.29231343f, -0.29744941f, 0.12456004f, 0.22598538f, 
    -0.01191312f, -0.11654060f, -0.06567434f, -0.05394454f, 0.10665264f, 0.07373822f, 0.09270521f, 0.11446967f, 
    0.04536353f, -0.03796931f, 0.46940777f, -0.10375057f, 0.05527220f, 0.08212899f, 0.08729964f, 0.13512759f, 
    0.06722734f, -0.05207922f, -0.02201899f, 0.06831092f, 0.20761828f, -0.09167832f, -0.19825968f, 0.02206512f, 
    0.15776418f, -0.19460337f, 0.10131713f, 0.20032634f, 0.13362756f, -0.06888317f, 0.06785983f, 0.00552832f, 
    0.04459123f, 0.15901569f, 0.01394708f, 0.08990642f, 0.07321358f, 0.00612010f, -0.04041038f, -0.04444562f, 
    0.12129804f, 0.01955656f, 0.03573225f, 0.09996853f, -0.53834778f, 0.14770995f, -0.21886784f, 0.11050896f, 
    -0.00026840f, -0.16797015f, 0.01711945f, 0.01501007f, 0.08949327f, 0.05013412f, 0.01718352f, 0.22963537f, 
    0.00265164f, -0.05400306f, -0.08265960f, -0.10166065f, 0.22340052f, -0.03664952f, 0.08999641f, 0.05871198f, 
    -0.01764990f, 0.09628530f, 0.03824859f, 0.03634547f, -0.18146168f, -0.12222315f, 0.04542479f, -0.12803712f, 
    0.05789895f, 0.02121021f, 0.09243445f, -0.03388431f, 0.07112189f, 0.01075448f, 0.00131748f, -0.04137953f, 
    0.00137351f, 0.08086400f, 0.11091880f, -0.29380244f, 0.08980456f, 0.06086795f, -0.02294865f, 0.08515281f, 
    0.02705102f, 0.08166587f, 0.03459155f, 0.00352647f, -0.16800681f, -0.10884778f, 0.07651984f, 0.03273334f, 
    -0.11584743f, -0.10438884f, 0.00178989f, -0.04163656f, 0.08283903f, 0.00134980f, -0.03821164f, -0.00115807f, 
    -0.02401174f, 0.34386733f, 0.11331332f, -0.19824798f, -0.01061368f, 0.05174027f, -0.03334409f, 0.05038119f, 
    0.02998051f, 0.02434850f, 0.00865768f, -0.03170350f, 0.03503984f, 0.00236977f, -0.04120919f, -0.06870731f, 
    0.07965769f, 0.03748259f, 0.03592456f, 0.10262773f, 0.11786024f, 0.00400069f, -0.04867394f, 0.17883970f, 
    -0.03105003f, 0.13689110f, -0.16547385f, 0.09952834f, 0.06476619f, -0.05432634f, -0.02486254f, -0.16062798f, 
    0.10320944f, -0.05859409f, 0.08099466f, -0.01510175f, -0.01604536f, 0.07550339f, 0.11200634f, -0.03905590f, 
    0.06200783f, 0.04227763f, 0.00595526f, -0.07179921f, -0.00812166f, 0.00243595f, -0.01021527f, -0.02108526f, 
    -0.32608843f, 0.34675452f, -0.27616921f, -0.04406578f, 0.12300485f, 0.02642559f, -0.12841256f, 0.01068396f, 
    0.02801978f, 0.11472556f, -0.10985996f, 0.10115380f, 0.12857169f, -0.23967732f, 0.08329240f, 0.15284660f, 
    0.00729714f, -0.03407074f, -0.03697110f, 0.03385421f, 0.18586271f, -0.17011073f, 0.10621279f, 0.09495293f, 
    0.06421963f, 0.05864548f, 0.19049554f, 0.04366676f, -0.10378812f, -0.10391539f, 0.03516508f, 0.01197273f, 
    0.09086551f, 0.05698847f, 0.07181972f, 0.04600969f, 0.05652833f, -0.12320969f, 0.07526824f, 0.17775981f, 
    0.01983575f, -0.03482731f, -0.04238901f, -0.06561754f, 0.12786253f, 0.14021154f, 0.03638491f, 0.15481615f, 
    0.13477243f, -0.27743626f, -0.04060349f, 0.65958536f, 0.35318816f, -0.03491330f, -0.17877942f, 0.05707201f, 
    0.01966545f, 0.03386152f, 0.07710762f, -0.00214396f, -0.01444188f, -0.16378963f, 0.07759269f, 0.16602068f, 
    -0.04074961f, 0.05787237f, 0.06243361f, -0.13387281f, 0.02427511f, -0.01741798f, 0.04683790f, 0.18486446f, 
    -0.11891467f, -0.09555236f, 0.05143698f, 0.01489104f, 0.01689701f, -0.03424190f, -0.05415523f, 0.00800617f, 
    0.06177305f, -0.10269136f, -0.06924409f, 0.00751115f, 0.05325062f, 0.02474727f, -0.07008640f, 0.01129422f, 
    0.07156036f, 0.04641854f, 0.03389391f, -0.03082199f, 0.03389504f, -0.02375297f, 0.01427111f, 0.00477651f, 
    0.03350304f, -0.03921233f, -0.00473677f, -0.04329379f, -0.02718346f, -0.02211152f, -0.05023307f, -0.07322660f, 
    -0.17955643f, -0.16807355f, -0.03443472f, -0.10039967f, 0.18520442f, 0.07681880f, 0.01984140f, 0.07038426f, 
    0.02794619f, 0.09369723f, -0.01316024f, -0.07398299f, 0.03066504f, 0.05416071f, 0.00031158f, 0.01965458f, 
    -0.16937377f, 0.07381817f, 0.19669451f, 0.31283271f, 0.10555267f, 0.08232924f, 0.15038513f, 0.00475581f, 
    -0.02442542f, -0.08931451f, 0.07640665f, -0.00570586f, -0.06292778f, 0.01008861f, -0.01548302f, -0.21063215f, 
    0.01622240f, -0.00651630f, -0.03973281f, -0.03911749f, 0.02372370f, -0.02122315f, -0.01890515f, 0.00562357f, 
    -0.07148561f, -0.06055394f, 0.07432759f, 0.01051078f, -0.01600816f, 0.00741637f, -0.07732028f, -0.04449772f, 
    0.01972245f, -0.03611269f, -0.10071711f, 0.04098518f, -0.16350755f, 0.08864076f, -0.04992757f, 0.02857549f, 
    0.05712357f, 0.21607019f, 0.15658590f, 0.23403300f, -0.03568672f, 0.03889797f, 0.03125124f, -0.04249846f, 
    -0.09624052f, 0.12497930f, 0.13236317f, 0.33559734f, -0.08015314f, 0.14588034f, -0.11191282f, 0.08495735f, 
    -0.20031217f, 0.02467838f, -0.01389549f, 0.03622183f, 0.15695442f, 0.00237833f, -0.03680599f, -0.01144732f, 
    0.05775655f, -0.08259185f, 0.01891095f, -0.06612753f, 0.00498064f, -0.00594225f, -0.10092922f, 0.03741890f, 
    -0.21667190f, 0.42221668f, -0.28070307f, 0.10399181f, -0.01134250f, 0.05142922f, 0.05335646f, 0.01409322f, 
    0.09359589f, 0.07183088f, 0.06171118f, 0.12193864f, 0.03092289f, 0.09722696f, 0.14962098f, 0.19569336f, 
    -0.06303387f, 0.00225642f, -0.02173780f, 0.06326913f, -0.01182498f, 0.04303949f, -0.08426392f, 0.01345533f, 
    0.13450387f, 0.14685313f, -0.08592642f, 0.21506220f, -0.04550193f, -0.05506767f, 0.01891683f, -0.04033978f, 
    -0.04903709f, -0.18843333f, -0.21287829f, 0.01421438f, 0.14924668f, -0.07152411f, -0.10350545f, 0.03242498f, 
    0.05776110f, -0.13548511f, -0.03797809f, -0.24267107f, -0.01012606f, -0.11531906f, -0.05418945f, 0.01374812f, 
    0.06682392f, 0.08981998f, 0.00763936f, -0.04465410f, -0.03650423f, 0.02163760f, -0.03649914f, 0.02209469f, 
    -0.10665283f, -0.25211275f, -0.15593851f, -0.19783483f, 0.22221988f, -0.01217640f, -0.12101866f, 0.09166732f, 
    0.11729289f, 0.11136176f, -0.09183056f, 0.13831718f, -0.03767894f, -0.05408534f, -0.03618436f, -0.01588194f, 
    -0.05220171f, 0.02290709f, 0.11030689f, 0.06502771f, -0.00658909f, 0.06247777f, -0.01925510f, 0.13608116f, 
    0.02687387f, -0.03506637f, -0.05720502f, 0.04785292f, 0.03092126f, -0.10514691f, -0.04423695f, -0.12273085f, 
    0.05394887f, 0.06617691f, -0.00120120f, -0.04751144f, -0.03106799f, 0.02908952f, 0.06306850f, 0.02392271f, 
    0.23814112f, 0.00502569f, -0.00153248f, -0.14037292f, -0.01778831f, -0.05833585f, -0.06545950f, -0.05130485f, 
    0.00152236f, 0.04972469f, -0.04945474f, -0.06647245f, 0.04791690f, 0.09172521f, 0.09735990f, -0.07861184f, 
    0.00104687f, 0.12556706f, 0.05765431f, 0.15074305f, -0.03289517f, 0.07059836f, 0.06671033f, 0.04071848f, 
    0.06440686f, 0.05279969f, 0.07347886f, -0.12130396f, 0.03627324f, -0.02972762f, -0.09143507f, -0.03241270f, 
    0.02935066f, -0.00295099f, -0.06010825f, -0.04785533f, 0.19911624f, 0.19401301f, 0.03378042f, 0.05834232f, 
    -0.04323565f, -0.00195307f, -0.00349140f, -0.03116117f, -0.05451486f, 0.02935106f, 0.13921432f, 0.11755428f, 
    0.23895423f, -0.00913113f, -0.15257622f, 0.06354443f, 0.02060338f, -0.09603917f, -0.14800788f, -0.03064660f, 
    -0.10220248f, -0.07967710f, -0.14661014f, -0.03704298f, 0.09396379f, 0.01355582f, 0.08229992f, 0.05895869f, 
    0.01736798f, -0.02971424f, -0.02020123f, -0.05371466f, 0.01715719f, 0.05782694f, -0.06062905f, 0.07260072f, 
    0.10929261f, 0.10559025f, 0.02750544f, 0.15086792f, -0.00650136f, -0.05780815f, -0.00888557f, -0.01548464f, 
    0.06736828f, -0.02193173f, 0.12480006f, 0.05528240f, -0.01650708f, -0.00617522f, 0.02930154f, 0.01968008f, 
    -0.01618189f, -0.06409355f, -0.09268545f, -0.10014251f, 0.16288485f, 0.10808647f, 0.05143432f, 0.04405342f, 
    -0.39125910f, -0.02994257f, 0.22950234f, 0.01947920f, -0.00093168f, 0.02315847f, -0.03084583f, 0.05061821f, 
    -0.09297308f, -0.04516130f, -0.08950301f, -0.03308795f, -0.07872987f, -0.01880393f, 0.08901623f, -0.10920376f, 
    0.11990951f, 0.04019438f, 0.02058444f, -0.04036216f, 0.01554871f, -0.04797791f, -0.04512326f, -0.02532855f, 
    -0.09445854f, 0.03244023f, 0.18405573f, -0.19087869f, -0.04575159f, -0.09382442f, -0.00961719f, -0.00343437f, 
    0.08739794f, -0.00306009f, 0.11860853f, 0.07155246f, 0.09819209f, 0.01761933f, 0.12976676f, -0.05211816f, 
    -0.05752443f, 0.13133290f, -0.02647845f, 0.23008016f, 0.03718854f, -0.01807014f, -0.04132958f, -0.02292796f, 
    -0.17825894f, -0.01146678f, -0.07051131f, -0.02363614f, 0.02973434f, -0.04638183f, 0.01992546f, -0.02862306f, 
    -0.06195127f, 0.08054456f, 0.04880744f, -0.00412155f, 0.02093425f, 0.00496938f, 0.12001436f, 0.00406493f, 
    -0.02061239f, -0.02101077f, -0.01394081f, -0.09806081f, 0.01261057f, 0.02919239f, -0.02673466f, -0.04429015f, 
    -0.06150300f, -0.07083676f, 0.06804095f, -0.06787647f, -0.06005227f, -0.05292867f, -0.03067627f, -0.06989502f, 
    0.05110465f, 0.02248985f, -0.05247172f, 0.15278314f, 0.02294371f, 0.04225756f, 0.04111716f, 0.01029981f, 
    0.03540846f, -0.02305987f, -0.02534766f, 0.03307236f, 0.00948343f, -0.08880329f, 0.08939122f, -0.03431486f, 
    -0.16687144f, -0.05095350f, 0.04478308f, -0.02689344f, 0.11150159f, 0.06231146f, -0.07061262f, -0.02114792f, 
    0.12156236f, 0.07708330f, -0.03293581f, 0.04757289f, -0.08103567f, 0.13316846f, 0.21565773f, 0.22930922f, 
    0.03600863f, 0.18689127f, 0.21365389f, 0.12852086f, 0.01496659f, -0.02137273f, 0.02673675f, -0.07529726f, 
    -0.06617282f, 0.14741945f, 0.23230615f, 0.31421375f, 0.05543713f, 0.17935485f, 0.15197435f, 0.14138705f, 
    0.02816829f, 0.02856245f, -0.07095614f, 0.00414460f, 0.01624537f, -0.28766423f, -0.11937036f, -0.19393763f, 
    -0.03372090f, -0.03713614f, -0.10118528f, -0.05264141f, -0.01588822f, 0.07908582f, 0.02917733f, -0.05041470f, 
    -0.03087609f, -0.19624133f, -0.10462016f, -0.17960900f, 0.12904549f, 0.14518845f, 0.07154951f, 0.00484535f, 
    -0.05067449f, 0.05969590f, -0.00205499f, -0.06930778f, 0.20108430f, 0.25677371f, 0.17093617f, 0.32304189f, 
    -0.08696214f, 0.12936819f, 0.11037856f, 0.03711787f, 0.04054744f, -0.00658510f, 0.05215857f, 0.05250530f, 
    0.07176204f, 0.00244900f, -0.01052522f, -0.10394163f, 0.04298866f, -0.14205283f, -0.16005205f, -0.06060115f, 
    -0.15557343f, -0.07075249f, -0.12787385f, -0.07812049f, -0.07923757f, -0.04759951f, -0.14647898f, 0.21817528f, 
    0.12891644f, -0.07617725f, 0.11213537f, 0.13534908f, -0.05889945f, -0.07476617f, 0.08083578f, 0.13873845f, 
    -0.04559271f, 0.15297697f, -0.10445940f, 0.05077902f, -0.01436583f, -0.00063217f, 0.16102129f, -0.06093557f, 
    0.02457264f, 0.07723270f, 0.05528016f, 0.04644218f, 0.36843631f, 0.12955791f, -0.04048417f, 0.12756351f, 
    -0.07635472f, -0.09262946f, 0.06027890f, 0.15526691f, 0.05482794f, 0.03481787f, 0.08625426f, 0.01968513f, 
    0.29171792f, 0.11668621f, -0.07436894f, 0.19678693f, 0.01969895f, 0.04971649f, 0.04448958f, 0.01815794f, 
    0.00459341f, -0.03629916f, -0.01820086f, 0.04145656f, 0.07435214f, -0.04970602f, -0.01664375f, -0.06635515f, 
    -0.04134775f, 0.03339656f, 0.00285404f, -0.11745486f, -0.11461224f, -0.03389901f, -0.05225620f, 0.01110536f, 
    0.16244444f, 0.02019997f, 0.21877590f, 0.11599077f, -0.11851420f, 0.06784408f, 0.04895189f, 0.12825891f, 
    0.03414978f, 0.09812678f, 0.18972185f, 0.04013044f, 0.14424895f, 0.15376601f, 0.03193706f, 0.08865796f, 
    -0.01200531f, 0.14150789f, 0.02757131f, 0.06684380f, -0.05161978f, -0.06164151f, -0.00844529f, -0.16028689f, 
    -0.03427985f, -0.08128635f, 0.03686731f, -0.06273823f, -0.06842417f, -0.03242433f, -0.07555968f, -0.10130227f, 
    0.09205861f, -0.01745218f, -0.00006015f, -0.10975208f, 0.24340108f, -0.17910050f, 0.08266525f, -0.08601854f, 
    -0.00001766f, -0.04973808f, -0.03559325f, -0.13699555f, -0.06737667f, -0.07343341f, -0.08212566f, 0.03493749f, 
    -0.03488111f, -0.03404981f, -0.03161495f, -0.05582492f, 0.05064696f, 0.00781464f, 0.04224266f, -0.05717738f, 
    0.00202821f, -0.05242866f, -0.03730942f, 0.00117618f, -0.00654785f, 0.12998658f, 0.31564736f, 0.20464969f, 
    0.04194922f, 0.10333891f, 0.11476676f, 0.10686550f, -0.01779739f, 0.02602463f, 0.00119074f, 0.07499292f, 
    0.20019498f, 0.13744414f, -0.02816090f, 0.12060318f, -0.06262900f, -0.06302591f, 0.03225571f, 0.01526015f, 
    0.02668786f, -0.00653006f, -0.03102975f, -0.00926485f, -0.26755536f, 0.03335800f, 0.20097496f, 0.29818386f, 
    -0.02695642f, 0.04295422f, -0.06034623f, 0.16752957f, -0.05629178f, 0.00516610f, -0.00350317f, -0.01271782f, 
    -0.10741143f, -0.24941440f, 0.10079347f, -0.09691749f, 0.01495321f, -0.00508226f, -0.01823353f, -0.04495395f, 
    0.02117911f, 0.01102722f, 0.14401270f, 0.07408173f, -0.08943180f, -0.02332421f, -0.02173672f, -0.05123635f, 
    -0.03116874f, 0.01001415f, -0.04063841f, -0.04037470f, 0.08777276f, 0.06803938f, -0.02660485f, 0.07485494f, 
    -0.15260792f, 0.09855331f, -0.10515722f, 0.18038017f, -0.06769542f, 0.07399506f, 0.03871224f, -0.02300473f, 
    -0.07364941f, 0.02263232f, -0.06876263f, -0.00894879f, 0.25576511f, 0.11979994f, 0.18695605f, 0.14728673f, 
    -0.07738063f, -0.03967983f, -0.05856417f, 0.09804060f, 0.04215126f, 0.00094417f, -0.06959842f, -0.08237455f, 
    0.09044337f, -0.05661576f, 0.06946818f, 0.00273786f, 0.09934054f, 0.10047575f, 0.01484239f, 0.13386028f, 
    0.10288327f, 0.16961828f, 0.05986915f, 0.22766933f, 0.25192818f, 0.20536259f, -0.07003156f, -0.09604799f, 
    -0.02634989f, -0.00515925f, -0.11403535f, -0.12704170f, -0.05984052f, -0.10052738f, 0.00235868f, 0.04280259f, 
    0.13095644f, -0.21794496f, -0.19187930f, -0.13616088f, -0.01417425f, 0.02402809f, -0.07701971f, -0.02114359f, 
    -0.00125709f, 0.03099640f, -0.03902647f, -0.07400423f, 0.07726752f, -0.02423478f, -0.05448002f, 0.02019768f, 
    0.00823046f, -0.08859126f, -0.10283146f, -0.06797259f, 0.03914592f, 0.04252743f, -0.12762654f, -0.05043069f, 
    -0.17280364f, -0.12894170f, -0.07188727f, 0.10727783f, -0.11782330f, 0.09986542f, 0.06202001f, -0.03849431f, 
    0.02865106f, 0.04527041f, -0.06091419f, 0.07118605f, 0.04888139f, 0.23190671f, -0.11770108f, 0.12069574f, 
    -0.02869273f, 0.02247335f, 0.03208473f, 0.08858699f, 0.06492998f, -0.00259147f, -0.00826144f, -0.06625310f, 
    0.55209732f, -0.32678765f, -0.02186959f, 0.02954493f, -0.09105401f, 0.15330282f, 0.05710873f, -0.14934587f, 
    -0.05634532f, 0.03703299f, -0.11494431f, 0.00531957f, 0.09729591f, -0.02377155f, -0.02897519f, -0.00630374f, 
    0.03155498f, 0.05015897f, 0.04402225f, -0.02256649f, 0.00998762f, 0.00881861f, 0.10661530f, 0.09209920f, 
    0.03322599f, 0.08299032f, -0.09049630f, -0.05985822f, -0.04630886f, -0.01808668f, -0.03073922f, -0.09623009f, 
    0.00400917f, 0.04813150f, 0.07812180f, 0.20323795f, 0.11481114f, -0.10949680f, 0.01266511f, -0.03384338f, 
    0.19598961f, 0.02737198f, 0.03762994f, 0.03188397f, -0.05173795f, 0.02455836f, 0.11023177f, 0.05793068f, 
    0.06555178f, -0.00666280f, -0.07141671f, 0.20662041f, 0.05351188f, 0.04032768f, -0.00201640f, -0.11081790f, 
    -0.03187775f, -0.05803083f, 0.14961676f, 0.12222208f, -0.04426587f, 0.00650741f, 0.00213421f, -0.17701524f, 
    0.01332600f, -0.01085408f, -0.00304779f, 0.07103392f, 0.17989479f, 0.19538791f, 0.09669795f, -0.06493367f, 
    -0.00390669f, -0.04582986f, -0.13312721f, -0.00085650f, 0.06179499f, 0.07002679f, 0.02274259f, 0.02199902f, 
    0.02455686f, -0.05161024f, -0.06582740f, -0.10962637f, -0.09808767f, 0.09173919f, 0.02219357f, 0.06761301f, 
    -0.01548498f, -0.12220892f, -0.01785227f, 0.11344022f, 0.14362188f, 0.13830835f, 0.02283000f, 0.00176240f, 
    -0.18595354f, 0.21041402f, -0.19207017f, -0.08033346f, -0.13395846f, -0.13455926f, -0.03547495f, 0.12038173f, 
    0.03506564f, 0.02840859f, 0.01677802f, -0.04281400f, 0.08660080f, -0.10963240f, -0.04283598f, 0.12582234f, 
    0.06071579f, 0.12772070f, 0.02571559f, -0.03310144f, -0.00647363f, -0.02142286f, -0.11376824f, -0.03299945f, 
    -0.09004293f, 0.39291826f, -0.31877485f, 0.00881496f, -0.09965029f, 0.05455693f, -0.05472373f, 0.09818905f, 
    0.22596657f, 0.15067652f, 0.10645312f, 0.06889842f, 0.24227643f, -0.11879768f, 0.05145015f, 0.04542290f, 
    -0.08550296f, 0.18324405f, -0.07225134f, -0.03181836f, -0.13458362f, 0.00488383f, -0.02607719f, -0.08017857f, 
    0.02146694f, 0.05653438f, 0.06729379f, 0.17867640f, -0.01866039f, -0.13110268f, -0.05130055f, -0.01895647f, 
    -0.09555737f, -0.05506849f, -0.14986314f, 0.08929269f, 0.38151765f, 0.07204268f, -0.33693627f, -0.21895003f, 
    0.02318630f, -0.07641073f, 0.11499725f, -0.36056677f, 0.00147447f, -0.05115401f, -0.03155592f, 0.26825011f, 
    0.05397382f, -0.00695677f, 0.02814656f, 0.18355574f, -0.08348863f, -0.17956169f, -0.01996872f, -0.03513931f, 
    -0.02736923f, 0.01423647f, -0.05711947f, 0.23964906f, -0.21553636f, 0.04569525f, 0.12575012f, 0.13623503f, 
    -0.09594601f, 0.14574206f, 0.04285705f, 0.09669093f, 0.03672272f, 0.00094252f, 0.00587890f, -0.01083212f, 
    -0.02056480f, -0.06802132f, -0.07742200f, 0.05120560f, 0.09867517f, 0.03449783f, -0.01772009f, 0.02470498f, 
    0.00915988f, -0.06070325f, 0.05610131f, 0.05145667f, 0.07771726f, -0.00182059f, -0.00718647f, -0.00914844f, 
    0.05497878f, -0.00302357f, -0.05319484f, -0.00137833f, 0.06501673f, -0.00597250f, -0.08043931f, -0.01430237f, 
    -0.00275099f, 0.10518254f, 0.21979924f, -0.11764450f, -0.03877350f, 0.01981454f, -0.04593043f, 0.06611423f, 
    -0.09354329f, 0.04602980f, 0.02680200f, -0.14437988f, 0.12883539f, -0.06708799f, -0.12331434f, -0.05700183f, 
    0.07410995f, -0.01616606f, -0.11669593f, 0.04514629f, -0.08100747f, 0.10652540f, -0.12617734f, 0.16190071f, 
    0.09335333f, -0.21923694f, 0.28025520f, 0.07364303f, 0.05223733f, -0.02041326f, -0.04496017f, 0.10288916f, 
    -0.01892587f, 0.14636396f, 0.16529869f, 0.09100237f, 0.43071803f, 0.16899458f, 0.06381316f, -0.11468007f, 
    -0.06051682f, 0.06714159f, 0.03945796f, -0.06163687f, 0.05569706f, -0.00007518f, 0.06419903f, 0.21937881f, 
    -0.18452846f, 0.14119288f, -0.16930097f, -0.09701329f, 0.01724029f, -0.17240062f, -0.10868153f, -0.07087018f, 
    -0.01503578f, 0.03487834f, -0.06566963f, 0.19778267f, 0.01166231f, 0.07334883f, 0.19308020f, 0.07728267f, 
    0.01333010f, 0.07125248f, 0.02963310f, -0.00694189f, 0.04229034f, 0.03563848f, -0.04909308f, -0.06771915f, 
    -0.36005384f, -0.14804763f, 0.07958739f, 0.01995498f, -0.03908919f, -0.12565368f, 0.00215480f, -0.04232438f, 
    0.01931715f, -0.07665229f, 0.02082151f, -0.01970555f, -0.01143059f, 0.07369534f, 0.09621396f, -0.03243170f, 
    -0.01779733f, 0.02475055f, 0.02098259f, 0.05481996f, 0.17040269f, 0.13756108f, 0.15668949f, 0.09073207f, 
    0.06962455f, -0.01217128f, -0.11380395f, 0.11691999f, -0.08719618f, 0.12152480f, -0.05615081f, -0.09548774f, 
    -0.06748487f, -0.11933360f, -0.01796259f, -0.02633627f, -0.32193407f, 0.18397015f, 0.06411202f, -0.14619650f, 
    0.14457029f, 0.11752416f, -0.00720043f, -0.03244695f, 0.12607422f, 0.03834601f, 0.02702902f, -0.03762363f, 
    -0.30498424f, 0.07428110f, 0.26316121f, -0.00348324f, 0.01933580f, -0.12806886f, 0.01819218f, 0.02320972f, 
    0.00461374f, -0.00731846f, 0.03993039f, 0.13097754f, 0.04893739f, -0.23849814f, 0.15572813f, 0.04498594f, 
    0.10582127f, 0.12352881f, 0.01420404f, -0.02980842f, -0.06929239f, -0.01783780f, -0.00037422f, -0.01308140f, 
    -0.21554908f, 0.01486418f, -0.04178526f, -0.08679271f, -0.06281608f, -0.06370808f, 0.04772165f, 0.07901993f, 
    0.10298632f, -0.10001738f, -0.01770158f, -0.08715684f, 0.29210320f, 0.09684025f, 0.13652544f, -0.08016285f, 
    -0.04689198f, 0.04750776f, 0.01741496f, -0.05205695f, 0.01716528f, 0.01337669f, 0.07362987f, 0.04140272f, 
    0.24375769f, 0.08189132f, -0.13857497f, 0.01513120f, 0.02323013f, 0.03046191f, 0.00038911f, -0.06161843f, 
    -0.10997026f, 0.14925140f, -0.12491287f, 0.15666252f, -0.04418637f, 0.07095332f, 0.05721185f, 0.17995137f, 
    0.04505561f, -0.02668937f, 0.00560510f, 0.00293377f, 0.05135043f, -0.10083214f, -0.02907868f, -0.04197055f, 
    -0.06361100f, 0.05428125f, -0.09467857f, 0.04555820f, 0.02733393f, -0.13045676f, 0.10726845f, 0.00132842f, 
    -0.01279852f, 0.11525200f, -0.00724762f, -0.11002088f, -0.03973083f, 0.02606181f, 0.13689667f, 0.04882358f, 
    0.05716303f, 0.06013466f, 0.09193970f, 0.28163221f, 0.06462157f, 0.11569071f, 0.10869628f, 0.00769691f, 
    0.01416785f, 0.00586600f, -0.00093984f, 0.04941055f, -0.00803455f, 0.01314980f, 0.03736581f, 0.19069631f, 
    0.01654261f, 0.03708962f, 0.04345372f, 0.05116024f, 0.05936139f, 0.06665491f, 0.22143726f, 0.11126099f, 
    -0.07254336f, -0.04257031f, -0.04206599f, 0.10701195f, -0.04171929f, 0.04995666f, 0.12251560f, 0.12240374f, 
    0.03696444f, -0.14671750f, -0.02576503f, 0.05525545f, -0.05583976f, 0.09213380f, -0.02218588f, -0.02311869f, 
    0.06576151f, 0.02809474f, -0.00665709f, -0.03789856f, -0.11504974f, -0.11180169f, 0.02308241f, 0.03783225f, 
    -0.03018137f, -0.05384051f, 0.23977815f, 0.23812273f, -0.09268188f, -0.08310617f, 0.00363783f, 0.02580966f, 
    0.38049617f, 0.11987564f, 0.23189320f, -0.06714412f, -0.07352924f, -0.13028222f, -0.10786469f, -0.03309046f, 
    0.21711785f, 0.08958333f, -0.10070100f, 0.02501888f, -0.05727271f, 0.20655239f, -0.17904028f, 0.05300054f, 
    -0.13398325f, 0.11634424f, 0.08551073f, 0.05661296f, 0.10383916f, -0.04850605f, 0.06623616f, -0.04991309f, 
    -0.14960326f, 0.10602196f, -0.00013370f, 0.05514219f, 0.04096279f, -0.07916413f, 0.13357639f, 0.02720614f, 
    -0.14373960f, 0.18534066f, 0.04565863f, 0.18820621f, -0.07996862f, 0.13231547f, -0.06332295f, 0.02379990f, 
    -0.00489915f, -0.04764698f, 0.14818691f, 0.12732917f, 0.03409321f, 0.00595820f, -0.04163535f, -0.01230556f, 
    -0.35590994f, -0.17531824f, 0.04323741f, 0.34189364f, 0.02081831f, 0.04078122f, 0.10961108f, 0.03378739f, 
    -0.05139809f, 0.19318002f, -0.02312871f, 0.03998899f, 0.28898558f, 0.03361598f, -0.09503084f, -0.11642385f, 
    0.07607862f, 0.04278569f, -0.07781707f, -0.14066942f, -0.05611324f, 0.05504546f, -0.10315679f, -0.08933820f, 
    0.10352574f, -0.08349881f, 0.05808259f, 0.17166311f, 0.18442550f, -0.07362796f, 0.05268113f, -0.02990254f, 
    -0.10463088f, 0.06841660f, 0.16921298f, 0.15984553f, 0.14033672f, 0.22266451f, -0.06976394f, -0.07769119f, 
    -0.09516412f, -0.01438282f, 0.16267358f, 0.12175369f, -0.11997232f, 0.01690697f, -0.09191842f, 0.01996771f, 
    -0.02124057f, 0.28299981f, 0.04704297f, -0.06040622f, 0.02941347f, 0.00700623f, 0.04567020f, -0.08554503f, 
    0.04238461f, 0.06611855f, -0.02592394f, -0.00498597f, 0.42428109f, -0.13575760f, -0.00340902f, 0.11778172f, 
    -0.04766313f, -0.01091146f, 0.00288096f, 0.00452938f, 0.06318019f, -0.05553285f, 0.04859653f, -0.06566289f, 
    0.05689096f, 0.04044401f, 0.04689928f, -0.00455834f, 0.14286681f, 0.21778947f, 0.23020308f, -0.08015850f, 
    0.13011606f, 0.04834554f, 0.03186261f, -0.04145958f, -0.06747068f, -0.18637407f, -0.09321409f, -0.01967226f, 
    -0.03966103f, -0.03679710f, 0.01298424f, 0.10275231f, -0.06933296f, -0.02206094f, -0.00102332f, 0.07397382f, 
    0.08778504f, -0.18735883f, 0.16107397f, 0.33309469f, 0.04912506f, 0.03211740f, 0.12437805f, 0.17391071f, 
    -0.08849995f, 0.09328719f, 0.00020998f, 0.00066923f, -0.13244958f, -0.07895706f, 0.06446586f, 0.05905737f, 
    -0.07917920f, 0.00316145f, -0.10467166f, 0.22681488f, -0.02382047f, -0.08187679f, -0.01057474f, 0.01807431f, 
    -0.12710366f, -0.07776318f, 0.19798180f, 0.03548588f, 0.03256965f, -0.07033293f, 0.07930477f, 0.04781134f, 
    0.05153291f, 0.03306653f, 0.11162302f, 0.05600925f, 0.12585823f, 0.02821502f, 0.08643106f, 0.10046521f, 
    0.01278839f, 0.00567006f, 0.02630623f, 0.08375752f, -0.02305700f, 0.04861626f, 0.04865640f, -0.07828787f, 
    -0.21549356f, 0.06241563f, -0.14849371f, 0.19083507f, 0.04607910f, 0.00774377f, 0.18452443f, 0.03338611f, 
    0.02828951f, -0.04365471f, -0.05257990f, -0.08931355f, 0.08243774f, -0.26541880f, 0.06680310f, -0.01056219f, 
    0.24062869f, 0.01671585f, 0.06100388f, 0.23171097f, -0.03576055f, -0.01284507f, 0.02974187f, -0.10579209f, 
    0.11143386f, 0.19690856f, 0.05776342f, -0.04398598f, -0.06203806f, -0.05808770f, 0.07462452f, 0.00274490f, 
    0.00150530f, 0.00764944f, 0.00524604f, -0.08736262f, 0.58729166f, 0.21922553f, -0.08542863f, -0.06843556f, 
    -0.04593378f, 0.01274017f, 0.00109161f, -0.01025229f, 0.08131301f, 0.08242234f, 0.08641501f, 0.03729218f, 
    0.46658960f, 0.12076323f, 0.15757924f, 0.12530139f, -0.03231341f, 0.00613594f, -0.13255711f, -0.08452933f, 
    -0.03419050f, -0.02159644f, 0.05938208f, 0.19341081f, -0.02820070f, 0.07693322f, 0.02907410f, 0.03524733f, 
    -0.04090596f, -0.00742268f, -0.07146940f, -0.02751297f, 0.05311415f, 0.01449423f, -0.13157924f, 0.04522462f, 
    -0.06330423f, 0.21807615f, -0.35928172f, -0.03772584f, 0.03428915f, 0.06590313f, 0.03954880f, -0.16828153f, 
    0.02183358f, -0.04590281f, -0.00414629f, 0.09250656f, 0.08821846f, 0.18363364f, -0.08010650f, 0.07969390f, 
    -0.03987053f, -0.05332693f, 0.24912663f, 0.09712704f, -0.07928731f, 0.07625456f, 0.16812578f, -0.10570542f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04539102f, 0.10267660f, 0.11516755f, 0.06139715f, -0.03888635f, -0.01029273f, 0.09536762f, -0.03087751f, 
    0.01057758f, 0.08807708f, -0.01015418f, -0.00067542f, 0.03365390f, -0.01635162f, -0.00360439f, 0.09347475f, 
    -0.00463151f, 0.11624759f, 0.08063854f, -0.10838648f, 0.00577565f, -0.00337054f, 0.13056794f, 0.02154201f, 
    -0.05166190f, 0.10582201f, 0.00181661f, 0.04501923f, 0.04666970f, 0.08749240f, 0.02717352f, 0.00032709f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08379690f, -0.34306303f, -0.57358754f, 0.27699456f, -0.50331813f, -0.02815953f, 0.07962701f, 0.12484190f, 
    -0.11649408f, -0.25591537f, 0.21358417f, 0.02274338f, -0.13555402f, 0.31002691f, 0.15449996f, -0.09029071f, 
    0.09357601f, -0.22982045f, 0.26433438f, 0.21664086f, 0.04053891f, -0.02615766f, -0.01942101f, -0.06181207f, 
    0.06621928f, -0.03015732f, -0.48821765f, 0.30331892f, -0.48586363f, -0.37885654f, -0.23605676f, -0.02563698f, 
    0.29485655f, 0.40066138f, -0.22228694f, 0.26308340f, -0.20149927f, -0.03986092f, -0.03334491f, -0.14653349f, 
    -0.10291331f, -0.14338344f, 0.16589256f, -0.15942651f, -0.18113673f, -0.50128663f, -0.11079005f, 0.26784173f, 
    -0.17136417f, 0.23040923f, 0.01231162f, -0.29113945f, -0.01385079f, -0.08096560f, 0.08153057f, -0.05160642f, 
    -0.08137053f, 0.25096908f, -0.57484108f, -0.00187273f, -0.40984878f, -0.02842421f, 0.21359649f, -0.02507828f, 
    0.25762382f, -0.21087043f, 0.16626151f, 0.29972649f, -0.21117435f, 0.12110762f, 0.16081752f, -0.06858988f, 
    0.14321023f, -0.33831605f, -0.16849136f, 0.12040264f, 0.07654803f, -0.33831406f, -0.18323556f, 0.09563849f, 
    0.06476726f, 0.04972568f, -0.45021227f, -0.21578489f, -0.01001267f, 0.12009389f, -0.18241973f, 0.11217064f, 
    -0.67575538f, 0.10281859f, 0.31862971f, 0.14195471f, 0.35339177f, 0.19542436f, -0.34783000f, 0.06302375f, 
    0.01941155f, -0.18634185f, -0.29561806f, 0.01331127f, 0.24448241f, 0.10253155f, -0.43772188f, 0.06132873f, 
    0.09609741f, -0.49311408f, 0.16620854f, 0.12067068f, 0.10420726f, 0.22362037f, 0.06325921f, 0.13326484f, 
    0.00288605f, -0.07853550f, -0.48435840f, 0.17883000f, 0.09310860f, 0.12289874f, 0.04461060f, -0.10731405f, 
    0.13156435f, -0.35529828f, 0.41995037f, -0.16634178f, 0.17734525f, -0.28534719f, 0.17019103f, 0.12467590f, 
    0.08640720f, -0.52810597f, -0.17666532f, 0.18276770f, 0.11759907f, -0.10236251f, -0.15478772f, 0.12385501f, 
    -0.00768195f, 0.06563972f, 0.07253669f, -0.01319545f, 0.24870855f, -0.12118263f, -0.05458724f, -0.53357047f, 
    0.09065040f, 0.22931284f, -0.04786014f, 0.16034117f, -0.02933653f, -0.16512148f, -0.18375213f, 0.03913598f, 
    -0.11353174f, -0.06064321f, 0.10987084f, -0.00774552f, -0.61557090f, -0.01338033f, 0.14359871f, 0.15585358f, 
    -0.41737214f, -0.11202607f, 0.36424342f, 0.01285732f, -0.43743816f, -0.08234351f, -0.12222131f, -0.04064700f, 
    -0.15698282f, 0.21610981f, -0.00541497f, -0.18140082f, -0.10542911f, 0.23442383f, 0.08788980f, -0.09173243f, 
    -0.01662412f, 0.26988685f, 0.34261495f, -0.05225354f, -0.11585243f, 0.01920166f, 0.22629443f, -0.04845650f, 
    0.04995326f, -0.28537804f, -0.56212306f, 0.06742891f, 0.03447223f, 0.04635489f, 0.16885947f, -0.35417938f, 
    -0.12235646f, 0.34648106f, 0.25244054f, 0.16927901f, 0.33629790f, -0.16344909f, 0.24116632f, 0.18211617f, 
    -0.13673337f, 0.03260897f, -0.30060068f, -0.14135031f, -0.37030599f, -0.53815377f, 0.15261260f, -0.26311952f, 
    -0.03838075f, -0.53530890f, 0.21322502f, -0.07212869f, -0.06467797f, -0.06063384f, 0.07443244f, -0.04149377f, 
    -0.42244607f, 0.07401476f, 0.18433358f, -0.46418875f, 0.02789676f, 0.08834012f, -0.40071821f, 0.00014310f, 
    0.23310666f, 0.07076263f, 0.11184926f, -0.14783041f, 0.06896997f, -0.01771601f, -0.37744588f, 0.04667819f, 
    -0.17012912f, 0.11402770f, -0.10063767f, 0.05767083f, -0.55565161f, 0.27228230f, 0.05850339f, -0.13060960f, 
    0.07756112f, 0.21060380f, -0.47665998f, -0.05893464f, -0.04441883f, -0.10271601f, -0.60454422f, 0.02427861f, 
    0.34075737f, -0.22327016f, -0.23455550f, 0.09333557f, 0.27298048f, 0.07025167f, 0.33460414f, 0.18637352f, 
    -0.02666632f, -0.45942527f, -0.07200871f, -0.37646112f, 0.13657859f, -0.06678365f, -0.36183158f, 0.12836245f, 
    0.15502739f, 0.05957664f, -0.14895216f, 0.03600799f, -0.35790646f, 0.51993883f, -0.00393470f, 0.33465013f, 
    0.17030606f, -0.08516582f, -0.05975429f, -0.49505922f, -0.03435197f, 0.02764886f, 0.17331727f, -0.13562419f, 
    -0.00464401f, -0.01769195f, 0.27645740f, -0.45693129f, 0.26691976f, 0.01238242f, -0.21411879f, 0.17424619f, 
    -0.44191673f, 0.11628488f, 0.15916780f, -0.12323235f, 0.20049258f, -0.15907434f, 0.08961997f, 0.01975778f, 
    0.00730236f, -0.21643296f, -0.35248518f, -0.05004754f, 0.02377136f, -0.14989972f, 0.03083100f, -0.65890294f, 
    -0.03457730f, -0.18155025f, 0.00199605f, -0.22809148f, -0.11643570f, -0.15039217f, -0.18466860f, -0.15509699f, 
    0.23508812f, 0.26918229f, -0.18251577f, 0.42600545f, -0.04887148f, 0.16349588f, 0.18283588f, 0.26390055f, 
    -0.36553669f, -0.12067842f, 0.42574403f, -0.17650402f, -0.31016695f, 0.09765199f, 0.01435930f, -0.00531972f, 
    0.01348282f, -0.03568572f, -0.02210473f, 0.11159965f, -0.04932374f, -0.29861838f, 0.15468715f, 0.16488670f, 
    -0.14652418f, 0.26800436f, -0.24114130f, 0.22101361f, -0.04349494f, 0.13317974f, 0.08667264f, -0.07245388f, 
    -0.19566765f, 0.33146930f, 0.20741428f, -0.69654751f, -0.29069135f, -0.60604441f, 0.29861575f, 0.21074767f, 
    0.12639342f, 0.06093055f, -0.31609535f, -0.24794944f, 0.18590307f, -0.07300073f, 0.24652974f, -0.17860816f, 
    -0.14844351f, -0.13822600f, -0.44101405f, -0.06657982f, 0.37229463f, 0.21649960f, -0.07727772f, 0.25736794f, 
    0.06676343f, -0.11186811f, 0.28915030f, 0.22016957f, -0.02658970f, -0.13517193f, -0.25153664f, 0.16042893f, 
    0.32715628f, -0.01172146f, -0.17127727f, -0.59538549f, 0.13163757f, -0.02514816f, -0.24178907f, -0.31641755f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03563054f, -0.02036486f, -0.05533744f, -0.13160454f, -0.06900217f, 0.10270318f, 0.12726183f, -0.03075589f, 
    -0.08230016f, -0.07359487f, 0.00097293f, -0.10118178f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
