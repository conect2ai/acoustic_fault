#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.31414562f, 0.26020366f, -0.17603785f, -0.17497195f, -0.42236069f, 0.20394681f, 0.10096395f, -0.00593720f, 
    0.40727568f, -0.00389326f, -0.04542344f, -0.30213729f, -0.08342497f, -0.20861752f, 0.13650046f, 0.46235892f, 
    -0.07017177f, -0.01841988f, -0.04319080f, 0.11483020f, -0.08174548f, -0.10873815f, 0.23184295f, -0.25559488f, 
    0.35491729f, -0.07401154f, -0.45320749f, 0.06637462f, -0.21441416f, -0.39184171f, -0.01396914f, 0.25134295f, 
    0.19814351f, 0.65667182f, -0.50266981f, -0.26394695f, 0.22242296f, 0.08638722f, -0.18157977f, -0.30147648f, 
    0.28902078f, -0.00159271f, -0.29257503f, -0.00883750f, -0.16303594f, 0.23700666f, -0.04232449f, -0.07545893f, 
    -0.41869462f, -0.04147298f, -0.42197371f, -0.50331354f, -0.10909719f, 0.22160195f, 0.21843129f, -0.30043837f, 
    -0.29073107f, -0.25006238f, -0.32488185f, -0.49669310f, 0.02369875f, 0.14101879f, 0.31500947f, -0.29946226f, 
    -0.15028264f, 0.08622881f, 0.19540960f, 0.17952316f, 0.17486480f, 0.11156173f, 0.01065098f, -0.39048788f, 
    -0.20216906f, 0.20989025f, 0.07098805f, 0.11694865f, -0.82042050f, -0.12176825f, -0.08973268f, -0.06206939f, 
    -0.06245570f, -0.13079756f, -0.33398345f, -0.32590893f, 0.15368514f, -0.49140024f, -0.30514884f, -0.50843358f, 
    0.00567515f, 0.37980828f, -0.06597007f, -0.28873533f, -0.28828391f, -0.10695793f, -0.06304284f, -0.18331008f, 
    -0.39181715f, -0.30902296f, -0.29868540f, -0.36039475f, 0.53113240f, 0.45717406f, 0.53712392f, -0.40947786f, 
    -0.08735774f, -0.21703377f, 0.06666267f, 0.10870630f, -0.05674552f, -0.00624290f, -0.00699876f, -0.00595279f, 
    -0.06816386f, 0.37095341f, -0.21072006f, -0.06093172f, -0.27169120f, 0.11473668f, -0.18976220f, 0.06059738f, 
    0.28226992f, 0.07064172f, -0.22386050f, -0.17759253f, -0.05747785f, 0.32834369f, 0.48108292f, 0.35177326f, 
    -0.20792389f, -0.43588033f, -0.41090065f, 0.04391583f, -0.28480607f, 0.09622312f, 0.30398598f, 0.38270307f, 
    0.08551797f, -0.21478975f, -0.25803778f, 0.07296269f, 0.13536614f, 0.02177809f, 0.04132687f, 0.18612286f, 
    -0.40219790f, 0.02378941f, 0.33171171f, -0.12912384f, -0.16805799f, 0.06964914f, -0.39634469f, 0.01757045f, 
    0.26307845f, -0.34999874f, -0.36997041f, 0.02955514f, 0.19234395f, 0.02714036f, 0.29008922f, -0.10333833f, 
    0.06938537f, 0.20527902f, 0.30432302f, -0.25285536f, -0.32256001f, -0.19414537f, -0.14154047f, -0.24314946f, 
    0.06413982f, 0.19098675f, 0.08683302f, 0.22531800f, 0.13741119f, -0.16470945f, 0.38949203f, 0.45777160f, 
    0.02149675f, -0.52957261f, -0.52518451f, -0.04116226f, 0.12633766f, 0.09360711f, 0.44098318f, 0.09799666f, 
    0.06575423f, 0.31077293f, -0.09125739f, 0.33143592f, -0.13280235f, -0.30948037f, 0.27043852f, -0.16940184f, 
    -0.20740668f, -0.33707651f, 0.20394339f, -0.17310263f, -0.14691690f, 0.12262724f, 0.19686948f, 0.28000197f, 
    0.37009507f, 0.33031538f, 0.06614381f, -0.39836985f, 0.14146617f, 0.30019307f, 0.26982230f, -0.03564797f, 
    -0.22949001f, -0.19284314f, 0.09605391f, 0.12794234f, -0.04315350f, -0.23664747f, 0.06055303f, -0.06490809f, 
    -0.15777703f, -0.11421676f, -0.14244211f, -0.06203201f, 0.03868462f, -0.20133123f, -0.31200096f, -0.39909646f, 
    -0.42160890f, -0.48739773f, -0.54132760f, -0.43876407f, -0.02665130f, 0.31777161f, -0.45661372f, -0.39930189f, 
    0.11923046f, -0.17058924f, -0.36293742f, -0.35298160f, -0.16789508f, -0.19815286f, 0.51748621f, -0.29360095f, 
    -0.19869296f, -0.08555812f, 0.19054724f, -0.32748327f, -0.35139936f, 0.23421419f, 0.14888354f, 0.16287965f, 
    -0.05105238f, 0.33553711f, -0.49679241f, 0.10851722f, 0.11512093f, 0.36338210f, 0.19366838f, 0.38542408f, 
    0.43098769f, 0.31027675f, 0.22933786f, 0.14883965f, 0.19541070f, -0.09291117f, 0.08103824f, -0.15528685f, 
    0.03581608f, -0.03520139f, 0.00931368f, -0.08338269f, -0.07740464f, 0.02014531f, 0.02997958f, -0.05170637f, 
    0.08070952f, -0.01546154f, -0.05463292f, 0.13907918f, 0.53795397f, -0.03229862f, -0.22667891f, -0.29018232f, 
    0.17908297f, -0.15123191f, 0.12186522f, -0.43658414f, -0.50179040f, 0.20334302f, -0.00950073f, 0.44649759f, 
    -0.50151271f, 0.00634237f, -0.00969255f, -0.29504520f, -0.30835918f, -0.25360364f, -0.26155800f, -0.18061052f, 
    -0.07909550f, -0.24990846f, -0.26503426f, -0.17689472f, -0.40614864f, -0.10898448f, 0.17794289f, 0.24307050f, 
    0.14563744f, 0.04143170f, -0.16142601f, 0.26052985f, -0.02155051f, 0.24839485f, 0.17750628f, -0.09496696f, 
    -0.07382553f, 0.31784922f, -0.31877393f, -0.16203605f, -0.00889782f, -0.01366291f, -0.17093912f, 0.16748434f, 
    0.20411097f, -0.08821297f, 0.01741358f, 0.07735700f, 0.12072924f, -0.47333920f, -0.28364179f, -0.28498653f, 
    -0.58004719f, -0.17470080f, -0.00804058f, 0.19355364f, 0.33158159f, -0.16726746f, -0.20361759f, -0.27390549f, 
    -0.09863257f, 0.14440714f, -0.03903270f, -0.11889302f, 0.04975376f, -0.63696408f, -0.18853243f, -0.12522589f, 
    -0.43937239f, -0.13537513f, 0.35926703f, 0.34084785f, -0.00083526f, 0.06722269f, 0.66932166f, 0.61366361f, 
    0.08954070f, 0.32829502f, -0.37529227f, -0.46204406f, -0.32496458f, 0.11509356f, -0.17595486f, -0.43955556f, 
    -0.10248302f, -0.35916245f, -0.19745092f, 0.09768802f, 0.34501985f, 0.27095580f, 0.49613601f, 0.10734479f, 
    -0.02113151f, -0.40052226f, -0.24551143f, -0.13273461f, -0.19073157f, 0.14037070f, -0.12238926f, 0.10797952f, 
    -0.04258023f, -0.42369464f, -0.09014892f, -0.08667341f, -0.40676570f, -0.35948434f, -0.08866883f, 0.04102876f, 
    -0.38726223f, -0.15389620f, -0.51511377f, -0.25138870f, 0.61263263f, 0.00583584f, -0.09822076f, -0.00512134f, 
    -0.07399862f, 0.15489711f, 0.28290245f, 0.10619188f, -0.00534127f, 0.02369924f, 0.18027839f, -0.16380821f, 
    1.02421486f, -0.65183669f, -0.16253708f, -0.55966681f, -0.48184478f, 0.10746627f, 0.39354947f, 0.32240683f, 
    -0.01213392f, 0.09644683f, 0.20750092f, -0.32604533f, -0.10748335f, 0.11174152f, 0.00749119f, -0.17050895f, 
    -0.10725822f, 0.02145330f, 0.11873128f, 0.25688058f, -0.33578426f, 0.22785425f, 0.22318305f, -0.09021878f, 
    -0.13370299f, -0.55643219f, -0.52375102f, -0.46178329f, -0.53518057f, 0.16784863f, -0.15118793f, -0.31816396f, 
    -0.33384490f, -0.29751676f, 0.04857044f, 0.11365208f, 0.01465621f, -0.02113252f, 0.19363144f, -0.11709879f, 
    -0.29743457f, -0.01249792f, -0.03471522f, -0.31496856f, -0.35791546f, -0.30273932f, 0.06236010f, 0.19923399f, 
    -0.18560147f, -0.05051688f, -0.73764563f, -0.69644189f, -0.59806067f, -0.36341235f, 0.49948153f, -0.09420474f, 
    -0.30632424f, 0.33968461f, 0.37965089f, 0.07667899f, -0.15594767f, -0.37260616f, -0.32353023f, 0.09446006f, 
    -0.13705848f, 0.19226362f, -0.19109613f, 0.23048998f, 0.19998358f, -0.37652391f, -0.40575936f, 0.03079287f, 
    0.24004126f, -0.21799062f, -0.03841846f, -0.28612635f, -0.20189562f, 0.50157332f, -0.36573002f, -0.52936113f, 
    -0.32634982f, -0.24150278f, -0.60490900f, -0.50234419f, -0.32588154f, 0.41516119f, 0.09474958f, 0.25356939f, 
    0.28724211f, 0.22185585f, 0.06031002f, -0.23370628f, 0.03488471f, -0.24941145f, -0.37027252f, 0.10220011f, 
    0.00956194f, 0.09868985f, 0.09416229f, -0.06305767f, -0.17597696f, 0.12399775f, -0.08656139f, 0.11998112f, 
    0.11575302f, -0.07811952f, -0.35613093f, 0.15099004f, 0.12429389f, 0.03459911f, 0.15630692f, 0.18813422f, 
    -0.42403224f, -0.04024481f, 0.27867004f, -0.02526204f, 0.12846848f, -0.38076735f, -0.10461319f, 0.08770783f, 
    0.24475612f, 0.24461553f, 0.16750053f, 0.08343278f, -0.11575992f, 0.66168052f, 0.18485035f, 0.03320034f, 
    0.19180071f, -0.36103770f, 0.36228094f, -0.00930225f, 0.21611525f, 0.28777406f, -0.26062423f, -0.01637733f, 
    0.04464860f, -0.10645449f, -0.31268084f, -0.13637672f, 0.19149265f, 0.02091355f, 0.07161483f, -0.35030103f, 
    -0.23036326f, 0.21820965f, -0.03291431f, -0.10623843f, 0.08426704f, -0.05420136f, 0.36215839f, 0.35550976f, 
    0.28876415f, 0.34907815f, 0.26163313f, 0.14435327f, 0.23530568f, 0.01947030f, 0.06827778f, 0.19098158f, 
    0.14947134f, 0.04420484f, 0.06052588f, 0.08990994f, -0.22011788f, -0.05407176f, 0.09973884f, -0.18591452f, 
    0.05820893f, -0.19428338f, -0.07424795f, 0.12575173f, 0.03612924f, -0.12955113f, -0.05618990f, -0.67310375f, 
    0.07293759f, 0.22712089f, 0.11556572f, 0.44375786f, -0.20606101f, -0.20050964f, 0.47871616f, 0.01919809f, 
    -0.13874499f, -0.09692562f, -0.36568731f, 0.23229745f, -0.19329433f, -0.07891103f, 0.39462596f, -0.10722945f, 
    -0.26981103f, 0.05186162f, -0.23556037f, -0.28068787f, -0.13266848f, 0.25682092f, 0.31664348f, 0.24321800f, 
    0.24519829f, 0.22697917f, 0.28308663f, -0.07887713f, -0.01157796f, 0.12194683f, -0.17733876f, -0.10771368f, 
    0.13047355f, -0.10038187f, 0.26340035f, -0.25269923f, -0.08435805f, -0.00689276f, -0.08453985f, 0.16132848f, 
    -0.06456698f, 0.00302129f, -0.02867227f, 0.03124010f, 0.14851801f, -0.11492021f, 0.13709313f, -0.10844906f, 
    -0.35024023f, 0.69811916f, -1.26762974f, -0.20119856f, 0.74026185f, 1.01440358f, -0.26332527f, 0.19291994f, 
    -0.46475780f, -0.56085068f, -0.08161304f, 0.26680735f, -0.36681834f, 0.26908383f, -0.08657900f, -0.11105158f, 
    -0.02659295f, -0.05443766f, 0.24417329f, 0.09697277f, -0.11726910f, -0.11205011f, 0.15079167f, 0.00235374f, 
    -0.15452169f, -0.03427763f, 0.79052460f, -0.41927850f, -0.34178901f, -0.20782843f, 0.54277235f, -0.08521812f, 
    -0.09977410f, 0.07593174f, -0.22131574f, -0.27184421f, -0.13871491f, 0.37535849f, -0.08983490f, 0.01579342f, 
    -0.14031671f, -0.04576402f, 0.31594336f, 0.03955372f, -0.16699909f, -0.21019916f, -0.06031091f, 0.08678146f, 
    0.15728898f, 0.33073011f, -0.04557609f, -0.25018847f, -0.23880608f, 0.23580751f, 0.39989442f, 0.00579593f, 
    0.23674121f, 0.02603816f, -0.21890803f, 0.32314560f, 0.10271720f, 0.23139180f, -0.24758717f, -0.17584907f, 
    0.34011137f, -0.02727964f, -0.27377549f, 0.03287417f, 0.27317247f, -0.19395401f, -0.06147398f, -0.12265526f, 
    0.05429420f, 0.01499026f, 0.32772624f, -0.22200814f, -0.44908670f, 0.03046526f, 0.58949858f, -0.33770066f, 
    -0.23291387f, -0.22680607f, -0.00893015f, -0.01476358f, 0.09633397f, 0.29761702f, 0.22321151f, 0.10176072f, 
    -0.14096987f, -0.08816534f, -0.08299426f, -0.17653678f, -0.19108099f, 0.24133186f, -0.21050799f, 0.02710168f, 
    0.05192611f, 0.30053386f, 0.09168212f, -0.15674122f, 0.45145896f, -0.95664173f, -0.67965996f, -0.57470375f, 
    0.17409393f, -0.15458442f, 0.12838902f, -0.01589832f, 0.32838011f, 0.62389082f, 0.68841273f, 0.24861336f, 
    0.03501265f, 0.10660054f, 0.09155419f, 0.25984776f, -0.06441103f, -0.07824241f, 0.16302048f, -0.15938298f, 
    -0.23052332f, -0.20233460f, 0.11139993f, -0.11043986f, 0.00318470f, 0.23301524f, -0.30999458f, -0.00292092f, 
    0.01859623f, 0.08804658f, -0.03739348f, -0.32590410f, -0.71933562f, -0.32716689f, 0.05217383f, -0.26264393f, 
    0.03658546f, -0.08740404f, -0.31778759f, -0.14080411f, -0.43433502f, -0.08145405f, -0.29316330f, -0.13965535f, 
    -0.37515104f, -0.25587112f, -0.16330768f, 0.20957130f, 0.10032064f, -0.16255489f, -0.10763608f, 0.49746108f, 
    -0.40443254f, -0.49791631f, -0.20429537f, -0.47086501f, -0.00061413f, -0.29919690f, -0.39279991f, 0.02861923f, 
    -0.24410917f, 0.24204379f, -0.26331842f, 0.16647074f, 0.41879895f, 0.08905280f, -0.18499325f, 0.34132409f, 
    -0.06886882f, -0.26399487f, -0.34678587f, -0.36181384f, -0.21792425f, 0.04020002f, -0.18101677f, -0.20457765f, 
    -0.32957309f, -0.30870643f, 0.15674844f, -0.19780719f, 0.07145403f, 0.22641805f, -0.09059712f, -0.11363379f, 
    0.39462909f, 0.09868603f, -0.14600123f, -0.14502649f, 0.12955096f, 0.29206347f, -0.07811168f, 0.03994569f, 
    0.15135460f, -0.12330937f, -0.09376145f, 0.04618907f, 0.13701883f, 0.32461584f, 0.35429025f, 0.08065550f, 
    0.06584947f, 0.07624697f, 0.05067508f, 0.18398005f, 0.16810121f, 0.21434548f, 0.01069745f, -0.06852034f, 
    -0.34031612f, 0.26250106f, -0.33038598f, -0.07305302f, 0.21677823f, 0.10415286f, 0.05367613f, 0.00771335f, 
    -0.28481767f, -0.12674196f, -0.17192782f, 0.18750471f, 0.18976516f, -0.14443192f, -0.08503225f, 0.10856105f, 
    -0.14603022f, 0.26213735f, -0.99064678f, 0.39893049f, 0.03509651f, -0.44409588f, -0.21309899f, -0.04648965f, 
    -0.11025357f, 0.36672518f, 0.31881103f, 0.31079307f, -0.18519998f, -0.32635382f, 0.15609545f, -0.43007499f, 
    -0.05209221f, 0.07708992f, -0.15017922f, -0.17311940f, 0.28941977f, 0.36638269f, -0.00697728f, -0.00009368f, 
    -0.18060429f, -0.34861600f, -0.41227680f, 0.27326435f, 0.59681940f, -0.23284210f, -0.43493721f, -0.42375606f, 
    -0.45238277f, -0.29944077f, -0.26200560f, 0.24627742f, 0.18448560f, 0.09048906f, 0.13521510f, 0.18651040f, 
    0.27137306f, 0.23254848f, 0.18352301f, 0.11182128f, 0.19436979f, -0.54571944f, -0.13054632f, -0.18537803f, 
    0.10194948f, -0.30147609f, -0.20317209f, 0.20178078f, 0.40480202f, 0.37757209f, -0.63135469f, -0.37749484f, 
    0.06719811f, -0.51108259f, -0.19678639f, 0.25356573f, 0.28174141f, 0.45749992f, -0.03748600f, 0.15911464f, 
    0.00145320f, -0.13836306f, 0.16073975f, 0.10924879f, -0.12118208f, -0.36771646f, 0.01629076f, -0.11747623f, 
    0.19828674f, -0.00771923f, -0.14410178f, 0.22996707f, -0.28401631f, 0.21306962f, 0.32148302f, 0.36901379f, 
    -0.24683695f, -0.08140394f, -0.34978667f, 0.15278864f, 0.29365000f, -0.21194272f, -0.24540965f, 0.14157924f, 
    -0.09784486f, 0.14190941f, -0.32157567f, -0.28061888f, 0.22625513f, -0.07437453f, -0.01718836f, -0.05182338f, 
    0.06438956f, 0.37080953f, -0.33912647f, -0.40422273f, -0.14149386f, -0.32278416f, -0.84859341f, -0.12984775f, 
    -0.20360164f, 0.17664377f, 0.42075512f, 0.52153659f, -0.53010762f, -0.66789144f, -0.45305321f, -0.15576001f, 
    -0.21095423f, -0.16641857f, -0.28002319f, -0.19589356f, -0.12812594f, 0.00106206f, -0.42952612f, -0.14729665f, 
    0.19921003f, -0.25843078f, 0.11151968f, 0.15878105f, -0.31922200f, -0.12273330f, 0.00367449f, -0.68810868f, 
    -0.58344603f, -0.43066850f, -0.12131876f, 0.43919376f, 0.26117629f, -0.01992411f, -0.11132375f, 0.57466519f, 
    -0.22602019f, 0.29994392f, 0.49713367f, -0.13820356f, 0.20488010f, -0.09335736f, -0.28244895f, 0.13316660f, 
    -0.30152830f, 0.18129452f, -0.01453627f, 0.14042230f, 0.17011555f, 0.21325074f, -0.08691686f, 0.00159380f, 
    0.17155477f, -0.06967779f, -0.08999783f, -0.50353110f, -0.17665701f, -0.49859500f, -0.20532918f, -0.03761187f, 
    0.05627391f, 0.36393097f, 0.30530414f, 0.23402397f, 0.20523101f, -0.05703086f, -0.29258841f, 0.14913401f, 
    -0.00629435f, 0.14394617f, 0.27356327f, 0.00676220f, 0.32107469f, -0.09601160f, -0.16753237f, -0.13791372f, 
    -0.06037515f, -0.83387160f, 0.53223377f, -0.31384799f, -1.02209055f, -0.71072763f, -0.04572769f, 0.52271962f, 
    0.73943418f, 0.21070884f, -0.13117008f, -0.17792238f, -0.26211429f, -0.39236754f, -0.39973679f, 0.06633610f, 
    0.06275427f, 0.03596726f, -0.03421330f, 0.13767189f, -0.21564423f, -0.01971112f, 0.19525482f, -0.02850875f, 
    0.02021596f, -0.05997307f, -0.04378043f, 0.30096018f, -0.32733658f, 0.13969280f, 0.43824029f, -0.29230621f, 
    -0.16291584f, -0.23403917f, -0.05300798f, 0.19380362f, 0.10965908f, -0.09662186f, -0.05170798f, 0.35077187f, 
    0.45962930f, 0.31076083f, -0.39262646f, 0.10042614f, -0.30454764f, -0.41331753f, -0.14549789f, 0.19906268f, 
    0.22585407f, -0.01770911f, 0.32913658f, -0.24231569f, -0.10173821f, 0.32133240f, 0.11089404f, 0.25340661f, 
    -0.48800388f, -0.09492087f, 0.15008512f, 0.20185043f, 0.26803160f, 0.24839851f, -0.22204675f, -0.08435045f, 
    0.06142788f, -0.11258554f, 0.01882087f, -0.24531162f, 0.28693232f, 0.05978271f, -0.26788193f, -0.13761938f, 
    -0.08682629f, -0.21360876f, -0.33819428f, -0.27318439f, -0.55908829f, -0.03180988f, 0.46680561f, -0.43420374f, 
    -0.26034415f, -0.15322119f, -0.05766542f, -0.19201797f, 0.57266879f, 0.14409363f, -0.17297237f, -0.20676702f, 
    0.27284002f, -0.07135990f, 0.20126313f, 0.27828121f, -0.12771006f, 0.11900525f, -0.38633019f, 0.16804697f, 
    -0.16838638f, -0.01887490f, 0.16791265f, -0.07019019f, -0.15795632f, -0.10482633f, -0.30599216f, 0.37502182f, 
    0.01176623f, -0.11869344f, -0.03845171f, -0.42082578f, 0.40106925f, -0.31895670f, 0.17850643f, -0.03275732f, 
    -0.01523597f, 0.27737951f, 0.11330396f, -0.14868650f, -0.33690530f, 0.32805076f, -0.11855213f, -0.31909463f, 
    0.35825157f, 0.36589012f, 0.02047108f, 0.08632341f, -0.31142703f, -0.22854979f, -0.31543612f, -0.39756361f, 
    -0.39397147f, -0.30343595f, -0.23653269f, -0.41460052f, -0.48509032f, -0.36935547f, -0.50794309f, -0.46993086f, 
    0.23869944f, 0.13224080f, 0.06717060f, -0.19065936f, -0.22463715f, 0.21454287f, -0.33911228f, -0.18506101f, 
    0.16323255f, -0.10393538f, 0.09435023f, -0.05941049f, -0.08516020f, -0.22964570f, 0.23453930f, -0.19272967f, 
    -0.24035396f, -0.22678539f, 0.14988619f, 0.15684791f, 0.36678442f, 0.27244660f, 0.05925759f, 0.40992093f, 
    0.12796806f, 0.16613308f, -0.13323562f, -0.30902833f, -0.07099427f, 0.12441222f, -0.17226948f, -0.05327265f, 
    -0.22156373f, 0.00486042f, -0.25933495f, 0.28903240f, 0.21279848f, -0.19870353f, 0.39115620f, 0.18058302f, 
    0.18441065f, 0.56518960f, 0.10602687f, 0.12471852f, -0.73149586f, -0.21250938f, 0.15691583f, -0.18365321f, 
    -0.02206317f, 0.20591071f, -0.17741723f, -0.00921092f, 0.17803505f, -0.23277551f, -0.18961820f, 0.17997344f, 
    0.18394290f, -0.06444608f, -0.08725026f, 0.09502189f, -0.27972692f, -0.08865581f, 0.06713536f, -0.21412146f, 
    0.53433955f, -0.18834005f, 0.18329994f, 0.13151300f, 0.17052275f, -0.23462106f, 0.00202444f, -0.05213234f, 
    -0.12618963f, 0.06346054f, -0.05841434f, -0.00831439f, 0.17395961f, -0.31777439f, 0.08357592f, 0.29423839f, 
    -0.16235317f, 0.07519408f, -0.21222425f, -0.01955702f, 0.01936324f, 0.05016866f, 0.20999341f, 0.10493450f, 
    0.32741237f, 0.34055260f, 0.02894543f, 0.61705792f, 0.45376679f, 0.19489095f, -0.28478524f, -0.50395441f, 
    -0.24815255f, -0.08055450f, -0.13174973f, -0.29714796f, -0.02880624f, -0.18057227f, -0.10442302f, 0.61654896f, 
    -0.33069634f, 0.24420354f, -0.00288898f, 0.06591871f, 0.15176035f, -0.11660708f, -0.23768030f, -0.03670885f, 
    -0.14420520f, 0.01985389f, 0.28682053f, 0.37669620f, -0.18556358f, -0.24543159f, -0.54833037f, -0.34485495f, 
    0.15679997f, -0.30560240f, -0.15370566f, 0.16122244f, -0.45788839f, 0.41792458f, 0.54116738f, 0.11530378f, 
    -0.00484825f, 0.25083628f, -0.10378817f, -0.08809321f, -0.15344086f, -0.23278819f, 0.00869297f, -0.10295697f, 
    0.32266504f, 0.05853086f, 0.23237807f, -0.13993722f, -0.97193480f, -0.70845300f, 0.08692698f, 0.41105032f, 
    0.95116919f, 0.21860743f, -0.07646042f, -0.27148241f, -0.06583247f, 0.28485692f, 0.21976875f, 0.18778174f, 
    -0.54449898f, -0.14353846f, -0.18678571f, 0.21883817f, -0.15409391f, -0.02572865f, 0.01156244f, 0.16372265f, 
    -0.11000843f, -0.10033028f, -0.07708200f, -0.20909390f, -0.06696582f, 0.72167701f, -0.85444599f, -0.00058143f, 
    0.30111527f, -0.56947452f, 0.79876035f, -0.16153820f, -0.34901249f, -0.29076096f, -0.32117519f, 0.12225422f, 
    0.33292300f, -0.31118241f, 0.00212473f, -0.30044708f, -0.00937753f, 0.13056043f, 0.24958375f, 0.20828542f, 
    -0.31666124f, -0.28350729f, 0.18748175f, -0.05677147f, 0.18650354f, -0.11011682f, 0.22790337f, 0.39848250f, 
    0.10273323f, -0.13462654f, 0.31282908f, -0.55944198f, -0.25895628f, 0.07190503f, 0.34979030f, 0.16966905f, 
    0.18435451f, 0.07614315f, 0.10000041f, -0.18312317f, -0.04837351f, 0.04525643f, 0.25940797f, -0.06744125f, 
    -0.07496273f, -0.40871918f, -0.07267918f, 0.18057874f, 0.13441476f, 0.12451887f, -0.30288240f, -1.05253661f, 
    -0.51510340f, -0.22377619f, 0.20717442f, -0.26803809f, 0.37474018f, 0.44506446f, 0.22257335f, 0.33615610f, 
    0.26931414f, 0.01494164f, -0.01388457f, 0.14953889f, 0.16127992f, -0.01390931f, 0.02330708f, 0.01160265f, 
    -0.25233689f, -0.03715601f, -0.00162228f, -0.07458150f, -0.04290026f, 0.08302572f, 0.03592917f, 0.04603404f, 
    0.43624350f, 0.48969206f, 0.34976876f, -0.44878012f, 0.06139232f, -0.41726741f, -0.08282315f, 0.20674217f, 
    0.19991954f, -0.58646810f, -0.46331081f, -0.23756556f, -0.30061084f, 0.09007371f, 0.43583521f, 0.13880607f, 
    0.11503092f, -0.15695296f, -0.14920969f, 0.00263748f, -0.22008274f, -0.06272076f, -0.15694405f, -0.33506614f, 
    -0.30906957f, -1.06444764f, -0.53178507f, -0.21128225f, -0.47111437f, -0.62718683f, 0.56911582f, 0.67757463f, 
    -0.27193892f, -0.12150180f, 0.35608220f, -0.09470587f, -0.14274968f, -0.25126326f, -0.34403008f, -0.42085972f, 
    0.19182810f, 0.17505260f, 0.09821086f, 0.15933800f, 0.12892522f, 0.00184122f, -0.04181164f, 0.02344069f, 
    -0.05700634f, -0.03486893f, -0.50564665f, 0.03889792f, -0.29630834f, -0.09222083f, -0.28171301f, -0.51608509f, 
    -0.22046828f, -0.12178663f, 0.00027769f, -0.33339435f, 0.02978333f, -0.14339815f, -0.07038674f, -0.06783735f, 
    -0.22355895f, -0.10239840f, -0.11833102f, 0.03398522f, -0.31453067f, -0.37256068f, -0.27321133f, -0.20281093f, 
    0.05045497f, 0.07501019f, 0.40573949f, 0.33878580f, 0.40193307f, 0.24601577f, -0.29480928f, 0.08364076f, 
    -0.19551055f, -0.19026685f, 0.13538092f, -0.01679773f, -0.34468281f, -0.31524938f, -0.31439877f, 0.01519329f, 
    0.21969949f, -0.23209392f, 0.12514299f, 0.02025789f, -0.04481210f, 0.11519442f, -0.17058860f, -0.26907179f, 
    0.27003938f, 0.16821766f, 0.25095242f, -0.00009582f, 0.55576795f, 0.33696213f, 0.35605210f, 0.12892303f, 
    -0.57585895f, 0.16088206f, -0.23843847f, -0.17619613f, -0.37225118f, -0.06080896f, -0.03171486f, -0.15244958f, 
    -0.03201980f, 0.09096488f, -0.29307160f, -0.08164818f, -0.23947592f, -0.03750243f, 0.24161854f, -0.02615782f, 
    0.12547781f, -0.01425574f, -0.21214046f, 0.13520701f, 0.15758362f, -0.61630082f, 0.52456397f, -0.21423137f, 
    0.15810817f, -0.24598385f, -0.37011689f, -0.41175929f, -0.09684954f, 0.45584366f, 0.49177524f, -0.43925393f, 
    -0.43654996f, -0.26687360f, 0.25149721f, -0.09789993f, 0.17028135f, 0.22371696f, 0.36913085f, -0.21497194f, 
    -0.08366445f, -0.33052015f, -0.09221985f, -0.43936285f, -0.18462224f, -0.17400461f, 0.14087336f, 0.36397019f, 
    0.22617348f, -0.22487201f, -0.01910259f, -0.31840166f, -0.10486534f, 0.20313321f, 0.05240948f, -0.07148703f, 
    -0.19803357f, 0.22386460f, -0.00242426f, 0.42064735f, -0.44810131f, 0.22008254f, 0.07949407f, -0.23769307f, 
    0.11527700f, 0.07309152f, 0.08472618f, 0.08818439f, -0.01918242f, -0.20628169f, 0.20939410f, -0.61286062f, 
    -0.43624717f, -0.39451560f, 0.27592269f, 0.33371130f, -0.35291240f, -0.40958586f, -0.71712691f, -0.52849078f, 
    -0.15827675f, 0.40861517f, -0.02984435f, 0.55338186f, 0.20810583f, 0.12318781f, -0.07519274f, -0.03284729f, 
    -0.15888841f, -0.27152333f, 0.04353964f, 0.42658985f, -0.31644559f, -0.17975327f, -0.03102004f, 0.10167872f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03227291f, 0.25284693f, -0.03730981f, 0.10763548f, 0.02336636f, 0.37588564f, 0.26988921f, 0.33202419f, 
    0.17902865f, -0.11582822f, 0.04303914f, -0.06730858f, -0.09489824f, -0.13934089f, 0.02708589f, -0.06962448f, 
    0.15790728f, -0.11998537f, -0.22808880f, 0.32825613f, 0.27168602f, 0.21311247f, -0.25457430f, 0.17631382f, 
    0.05464843f, 0.17902645f, 0.17985500f, 0.28315845f, 0.08520704f, 0.14601633f, -0.14317857f, -0.07844272f, 
    -0.12609391f, 0.17012145f, 0.07546910f, 0.01794478f, 0.02788720f, 0.18399252f, 0.12373137f, 0.15382548f, 
    -0.02894421f, -0.11076194f, 0.04541714f, 0.00898228f, 0.31918034f, 0.28299215f, -0.14204454f, -0.00706935f, 
    0.21543503f, 0.19923593f, 0.09185652f, 0.02773000f, 0.36174989f, 0.33533654f, 0.37427583f, 0.13132745f, 
    -0.11089994f, -0.40223068f, -0.12934133f, 0.11321212f, 0.12610009f, 0.04841143f, 0.24122961f, 0.04537578f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.10295112f, 0.05327380f, 0.31043541f, 0.05278526f, 0.08691889f, 0.04609691f, 0.06528419f, -0.10208495f, 
    0.06086714f, -0.00204839f, -0.03205434f, -0.00122833f, 0.07218004f, 0.26536551f, 0.16203406f, 0.13040206f, 
    -0.05199557f, 0.12369996f, 0.12797303f, -0.08694524f, 0.09150328f, 0.16592120f, 0.16940954f, 0.04369863f, 
    -0.23357818f, -0.24914002f, -0.16914244f, 0.01007773f, -0.28313881f, -0.05334250f, 0.06287158f, -0.17964496f, 
    0.04283659f, -0.02229444f, 0.04910546f, -0.01770081f, 0.04133178f, -0.06401426f, 0.00143724f, 0.06686503f, 
    0.08057229f, 0.07506080f, 0.09449666f, 0.05998411f, -0.07074417f, 0.01971637f, 0.12409286f, 0.02867518f, 
    0.22838882f, -0.03970226f, 0.26099595f, -0.23289365f, -0.05261626f, -0.00276919f, 0.02592061f, 0.05712247f, 
    -0.05854687f, -0.08553518f, -0.04452145f, -0.04531901f, 0.22826764f, -0.04229090f, 0.19370708f, -0.00228307f, 
    0.01604977f, 0.04618496f, 0.05290669f, 0.08624180f, 0.01376581f, 0.01180315f, 0.03833342f, -0.03303001f, 
    0.07672505f, 0.11165053f, 0.12050499f, -0.05461379f, 0.10434779f, 0.11603284f, 0.03232181f, 0.16701289f, 
    -0.02523114f, 0.05878413f, -0.04705500f, -0.00641618f, 0.22147302f, 0.13099955f, 0.24333066f, -0.05307793f, 
    -0.01703694f, 0.07222563f, 0.05955638f, 0.20498030f, 0.12868792f, 0.11747094f, 0.01543402f, -0.00310976f, 
    0.13286832f, 0.00486974f, 0.10383549f, -0.18266420f, -0.03006491f, -0.04244155f, 0.01758992f, -0.02298678f, 
    -0.13235053f, 0.01899725f, -0.03014542f, 0.03200476f, -0.27124983f, 0.01604663f, 0.04637536f, -0.05609985f, 
    -0.05101473f, -0.04605618f, 0.00911106f, -0.09299660f, -0.06380782f, -0.04801830f, 0.02589263f, -0.06179937f, 
    -0.08591985f, -0.07175677f, -0.01003124f, 0.02399109f, -0.01996456f, -0.03413063f, -0.02792390f, -0.02690763f, 
    0.12831762f, 0.12648183f, 0.06055965f, 0.11889357f, -0.16392912f, -0.24033156f, 0.12891266f, -0.34604764f, 
    0.03851192f, 0.00972672f, 0.06325227f, 0.01596767f, 0.04642970f, 0.07092267f, 0.06099446f, 0.09629502f, 
    -0.05895758f, 0.01197333f, -0.07443643f, 0.00531886f, 0.02662402f, -0.01861436f, -0.03457404f, -0.00639864f, 
    0.02378180f, -0.03411232f, 0.04427538f, -0.02779726f, -0.10063449f, 0.01103194f, 0.31349251f, -0.09188185f, 
    -0.12785248f, 0.00864062f, 0.08016740f, 0.10836820f, -0.05518327f, -0.02252478f, -0.02769714f, -0.00011482f, 
    0.10516269f, -0.05658234f, -0.00178592f, -0.12525395f, 0.00320696f, -0.00276701f, 0.21960120f, -0.22210485f, 
    -0.02532436f, -0.05836193f, -0.08478323f, -0.01942408f, -0.08059526f, -0.07795083f, 0.03264780f, -0.14416356f, 
    0.01770821f, -0.17097792f, 0.00655681f, -0.00838174f, 0.00105446f, -0.05954446f, 0.08054350f, -0.05246379f, 
    0.24114971f, 0.34326598f, 0.19438678f, 0.08274342f, -0.08207193f, 0.07043806f, -0.12822600f, 0.10109443f, 
    0.13100694f, 0.11016080f, 0.16894087f, 0.03243757f, -0.20158498f, 0.06406403f, 0.11354367f, 0.03137664f, 
    -0.10171023f, -0.01902113f, 0.00951703f, 0.03502868f, -0.12569177f, 0.06326833f, -0.01866437f, 0.03189041f, 
    -0.29152778f, 0.17055124f, 0.05858807f, -0.00485235f, -0.03296902f, -0.13045268f, 0.09615908f, 0.08782633f, 
    -0.04223499f, 0.03536471f, 0.05459861f, -0.08247699f, -0.21414641f, -0.28487822f, -0.08684549f, -0.16293877f, 
    0.03506916f, -0.02567976f, 0.01761934f, -0.09522284f, -0.08696176f, -0.03223228f, 0.02990883f, 0.03007983f, 
    -0.04606424f, 0.04959249f, -0.10570250f, 0.08270908f, 0.13254467f, 0.07292530f, -0.07113417f, 0.06908283f, 
    -0.01346783f, -0.01334649f, 0.10376534f, 0.02631598f, 0.12440536f, 0.11913157f, 0.15703802f, -0.02207873f, 
    -0.07902481f, -0.01604140f, -0.00392774f, -0.04917078f, -0.06174330f, 0.09828073f, -0.10279624f, 0.03609931f, 
    0.08887446f, 0.10275479f, 0.06200759f, -0.01487951f, -0.06274081f, -0.06376779f, -0.03010036f, -0.03435883f, 
    -0.16506378f, -0.08710048f, -0.07006139f, -0.08946043f, 0.09805443f, -0.24010821f, -0.07235209f, 0.10237363f, 
    0.11219466f, -0.05911412f, -0.00036673f, 0.03747643f, 0.03519279f, 0.09146205f, 0.05349087f, 0.08419115f, 
    0.14106695f, 0.03779108f, 0.08583379f, 0.08207417f, -0.03548400f, 0.01450306f, 0.04113508f, -0.02992678f, 
    -0.09398712f, 0.00240785f, -0.03341952f, 0.00662755f, -0.32049263f, 0.13883623f, -0.32439047f, 0.29600042f, 
    0.05577877f, 0.22243036f, -0.01800416f, 0.24774355f, -0.05192907f, -0.04744576f, 0.04238940f, -0.02868669f, 
    0.07998308f, 0.10302629f, -0.13096800f, 0.09162538f, -0.25931618f, 0.26600471f, 0.02039325f, 0.25715601f, 
    -0.05908241f, 0.12238798f, -0.05170798f, 0.09596197f, -0.12209922f, 0.18218006f, -0.05068147f, 0.20607212f, 
    0.06016145f, -0.07410765f, 0.05979752f, 0.12885052f, 0.02803731f, 0.03989908f, 0.11354462f, 0.12576625f, 
    -0.02457090f, -0.01471821f, -0.02315726f, -0.04040439f, 0.14251502f, -0.02396322f, -0.03641368f, 0.15455121f, 
    -0.08714835f, -0.01575685f, 0.10720891f, 0.00738381f, -0.45392734f, 0.28054425f, 0.00811214f, 0.05832067f, 
    -0.03633329f, 0.03453373f, -0.02240080f, -0.03639294f, 0.00896673f, 0.06333764f, 0.07018669f, 0.09220590f, 
    -0.26325226f, -0.14908417f, -0.35888121f, -0.20354742f, 0.16571106f, -0.01059646f, -0.00672493f, -0.02548996f, 
    0.01040499f, 0.00819256f, 0.02685083f, -0.03109842f, -0.24939196f, 0.12823017f, -0.02025168f, -0.15270886f, 
    0.07607428f, -0.08360422f, 0.17657600f, -0.07930414f, 0.01712552f, 0.02576891f, 0.07539348f, 0.04923938f, 
    -0.13254769f, -0.09687465f, 0.00278890f, 0.03854876f, 0.01193143f, -0.02261464f, 0.01272790f, 0.07079728f, 
    -0.09181976f, -0.09463986f, -0.02087461f, 0.00065052f, -0.00443700f, 0.13685586f, 0.04089699f, -0.02672521f, 
    -0.05893261f, 0.06304526f, -0.06086740f, -0.01626321f, 0.00403835f, -0.01481075f, 0.01459647f, 0.00073797f, 
    -0.02681183f, 0.09741176f, -0.00645606f, 0.10954319f, -0.02402169f, 0.02934154f, 0.02270716f, -0.08438909f, 
    0.12845184f, 0.12830560f, 0.05880906f, -0.03395090f, 0.08955631f, -0.08141395f, -0.03116243f, -0.21196176f, 
    0.12809455f, 0.02405631f, -0.16779579f, -0.10099070f, 0.13984349f, 0.07040089f, -0.04492000f, 0.09288237f, 
    0.22527193f, -0.02133852f, 0.08117174f, 0.21681066f, 0.04881028f, 0.08740429f, -0.10255381f, 0.16676114f, 
    0.05386911f, 0.18222052f, 0.17809430f, 0.17817125f, 0.19516277f, -0.10769962f, 0.17320615f, -0.19630979f, 
    0.05243763f, 0.04080382f, 0.04726008f, 0.07376006f, -0.01044629f, -0.04034154f, -0.01160999f, 0.03821021f, 
    -0.09179715f, -0.14363691f, -0.19316685f, 0.33140016f, 0.11698438f, -0.07441905f, 0.14183541f, -0.05162127f, 
    0.06441840f, 0.01557203f, 0.13165371f, 0.01080551f, -0.29284006f, 0.08826539f, 0.10326649f, 0.18626924f, 
    -0.04846829f, 0.00520773f, -0.08331525f, 0.14694476f, 0.00028272f, 0.07171797f, 0.06876072f, -0.00074836f, 
    -0.07366318f, -0.06456766f, -0.02875770f, -0.05016780f, 0.17937501f, 0.06601782f, 0.03936157f, 0.01770731f, 
    -0.00274393f, 0.05414375f, -0.05504790f, 0.02882126f, -0.29260039f, 0.17852673f, 0.39501187f, -0.26251820f, 
    -0.07245018f, 0.12586713f, -0.00017850f, -0.10087509f, 0.01189127f, 0.01533911f, -0.01015049f, -0.12952718f, 
    0.17145275f, -0.23985921f, -0.15554059f, 0.10509659f, 0.08791547f, -0.00328505f, -0.02508520f, 0.07387301f, 
    0.05619736f, 0.09552843f, 0.14721738f, 0.13720071f, 0.06587062f, -0.00653653f, -0.10701035f, 0.01745589f, 
    -0.00360628f, -0.03304628f, -0.05042550f, 0.03719100f, -0.05904587f, 0.06547847f, -0.01886151f, -0.06642161f, 
    0.08047515f, 0.09911049f, 0.03487359f, 0.11615829f, 0.13930286f, -0.00411226f, 0.12854581f, 0.09704719f, 
    0.07839894f, 0.08965302f, 0.11102491f, 0.09763552f, 0.12121313f, 0.12206264f, 0.08182691f, 0.03480067f, 
    0.04566349f, 0.01234832f, 0.03586280f, 0.04500000f, 0.14889964f, -0.06960160f, 0.23888572f, 0.02769842f, 
    -0.16663334f, -0.17890258f, -0.03418716f, -0.01716720f, -0.11812302f, -0.09252242f, -0.07535210f, -0.16901802f, 
    -0.00486892f, 0.02620378f, -0.01631925f, -0.06698129f, -0.32424140f, -0.09857976f, -0.06228294f, 0.09447753f, 
    0.06692497f, -0.12190603f, -0.07119826f, -0.03241477f, 0.03130790f, 0.08092538f, 0.03697013f, 0.02712326f, 
    0.06862779f, -0.02473752f, 0.29977229f, -0.17729564f, -0.00918663f, 0.06493019f, 0.06880233f, 0.05912985f, 
    0.05727176f, 0.12130016f, -0.10251793f, 0.00155247f, -0.02062343f, -0.01596578f, -0.00672579f, -0.03184577f, 
    0.16218273f, -0.00589688f, 0.01723771f, 0.02243027f, -0.00850626f, 0.05448245f, 0.05746833f, 0.04360462f, 
    0.10133173f, -0.20805068f, 0.10008639f, -0.29518947f, 0.06020714f, 0.01698706f, 0.14442942f, -0.16091226f, 
    0.02941573f, -0.02922691f, -0.01140472f, 0.05872793f, -0.13552813f, -0.07244081f, -0.07596841f, -0.02787214f, 
    -0.12221397f, -0.10255856f, -0.11607120f, -0.09171511f, -0.06588113f, 0.05788913f, -0.16055097f, 0.03393319f, 
    -0.04769181f, -0.13735701f, -0.12957349f, 0.21368314f, 0.02358268f, 0.22828341f, 0.04613621f, 0.13294731f, 
    0.12617603f, 0.06342147f, 0.18028650f, 0.06445930f, -0.03283012f, 0.14900163f, -0.06471163f, 0.04448900f, 
    0.00954200f, -0.00467129f, 0.09244733f, 0.11609334f, 0.00442405f, 0.05341943f, 0.01573446f, 0.01835619f, 
    0.28639767f, -0.00255940f, 0.13721187f, 0.06617475f, 0.03694896f, 0.05885105f, 0.01794288f, 0.09583318f, 
    -0.02913157f, 0.11285549f, 0.00171733f, 0.02018977f, -0.17878838f, -0.02407276f, 0.21968862f, 0.09840413f, 
    -0.04018291f, -0.02828932f, 0.02486175f, -0.06921127f, 0.01969470f, 0.09862660f, 0.07127155f, 0.06905157f, 
    0.25232989f, -0.05795656f, 0.03968559f, -0.13192581f, 0.02656095f, -0.05558018f, 0.00729253f, -0.00856523f, 
    -0.13870025f, 0.01556239f, -0.26321146f, 0.02505899f, 0.08791810f, 0.14065909f, 0.37960038f, 0.23033762f, 
    -0.09759854f, -0.11201502f, -0.01676447f, -0.19792768f, -0.00974190f, 0.03760023f, 0.00521500f, -0.04236875f, 
    -0.15183862f, -0.04718617f, -0.09614743f, -0.29980877f, -0.02512935f, -0.04994259f, -0.01032076f, -0.02570478f, 
    -0.05955401f, 0.02250412f, -0.00829179f, -0.02192343f, 0.17527133f, -0.09717705f, 0.10321499f, -0.21646082f, 
    -0.03486211f, -0.00870134f, 0.01216541f, -0.01115843f, -0.05988496f, -0.00464409f, -0.04591409f, 0.00549807f, 
    0.12142966f, 0.04486828f, 0.38087729f, -0.18996522f, -0.00482596f, -0.00476090f, 0.06415121f, 0.02711695f, 
    -0.01942719f, -0.06335496f, 0.07553913f, 0.00513579f, -0.02435737f, 0.12946999f, -0.13566683f, 0.09215201f, 
    0.01220717f, -0.01718696f, -0.02254636f, 0.26167506f, 0.11530074f, 0.15252821f, 0.03909571f, -0.03530517f, 
    0.10459872f, -0.00835600f, 0.15972576f, -0.03112794f, 0.01209266f, 0.08149616f, 0.09617156f, 0.14479311f, 
    0.00976069f, -0.01580731f, 0.05629814f, 0.04478808f, -0.49359649f, -0.36010051f, -0.17823127f, 0.06163250f, 
    -0.04310848f, -0.17492230f, 0.12697376f, -0.21122196f, -0.02080063f, -0.05856251f, 0.04388288f, -0.00439111f, 
    0.44409055f, -0.18779230f, 0.18891461f, 0.07538564f, -0.01424840f, 0.02078530f, 0.05921524f, 0.11482703f, 
    -0.04902675f, -0.14712209f, 0.04273422f, 0.13216954f, 0.07971524f, -0.05367088f, 0.23255154f, -0.07443401f, 
    0.16707917f, 0.02902701f, -0.02222751f, -0.02654503f, -0.00901664f, -0.07480364f, 0.03187761f, 0.03149818f, 
    0.02994044f, 0.07137998f, 0.32536283f, 0.11744724f, 0.13509524f, 0.09219354f, -0.06287844f, -0.06323399f, 
    -0.14678280f, 0.09760021f, -0.00743679f, -0.05286527f, -0.39547700f, 0.02904169f, -0.09592802f, 0.06572903f, 
    -0.02450728f, 0.05353932f, 0.10733391f, 0.07895795f, 0.12193611f, 0.14567135f, -0.03330246f, 0.12733494f, 
    0.11778965f, -0.30714682f, 0.18834637f, -0.05837917f, -0.06039126f, 0.12047589f, 0.05838860f, -0.17443524f, 
    0.05051945f, 0.00771652f, 0.05317585f, -0.06643075f, 0.04520778f, -0.01775598f, -0.32121715f, 0.09367703f, 
    -0.03217813f, -0.09547041f, 0.06362282f, -0.01048244f, -0.04592616f, 0.00160679f, -0.03480583f, -0.04803824f, 
    0.10326471f, -0.18843283f, 0.18634591f, 0.00018170f, 0.06638213f, 0.09416911f, 0.01795158f, -0.02682971f, 
    0.04160372f, 0.04617847f, -0.00485726f, -0.03778497f, 0.06493594f, -0.13004379f, 0.04533640f, 0.16996767f, 
    -0.00019265f, 0.07897533f, -0.27765331f, 0.12271738f, -0.01939624f, 0.02040250f, 0.03347256f, -0.04317442f, 
    -0.00897439f, 0.12795754f, -0.11124437f, 0.04940524f, 0.00462898f, 0.06660375f, -0.02239135f, -0.04946452f, 
    0.01291958f, -0.01051993f, 0.14174968f, 0.10144382f, 0.10364133f, -0.04191212f, 0.13110234f, 0.10328046f, 
    -0.09056105f, -0.01612935f, -0.18953028f, -0.04683473f, 0.01594798f, 0.08852573f, 0.06039455f, -0.03799867f, 
    -0.29271445f, -0.20677795f, -0.11447132f, -0.12722197f, 0.15961833f, 0.05700358f, 0.01339119f, 0.01898456f, 
    -0.04697040f, -0.02802414f, 0.01321473f, -0.05767037f, 0.10965576f, 0.15126358f, 0.21977405f, 0.10858756f, 
    0.14659733f, 0.08250532f, -0.00607719f, -0.05426582f, -0.05531705f, 0.06978790f, 0.04926986f, 0.11877769f, 
    -0.13963908f, -0.02492646f, 0.25297680f, 0.23872954f, 0.08948752f, -0.03690844f, -0.11774835f, 0.05533026f, 
    -0.01844409f, 0.07229246f, -0.07174431f, -0.14751858f, 0.23806007f, -0.09180532f, 0.03017011f, 0.11804081f, 
    -0.00435409f, -0.14029105f, -0.24005312f, -0.10304263f, 0.00105273f, -0.11714038f, 0.13632961f, 0.00813460f, 
    0.65044677f, 0.03532918f, 0.06547009f, 0.08375426f, -0.12111389f, 0.05786619f, -0.06640403f, 0.24435402f, 
    0.06504753f, 0.16924952f, 0.02969527f, -0.03421990f, 0.07823236f, -0.05098667f, 0.06937581f, 0.12676956f, 
    -0.09301728f, 0.09789836f, -0.13362068f, -0.04781437f, 0.00204045f, 0.04345196f, -0.08926089f, 0.01305464f, 
    -0.21047488f, 0.06855335f, -0.14510308f, 0.20119388f, -0.08907926f, 0.11631926f, 0.02320277f, -0.00510526f, 
    -0.14141917f, -0.02310582f, 0.00716360f, 0.10911697f, 0.02065497f, 0.05691696f, -0.04833844f, 0.04509580f, 
    -0.01802415f, -0.09382965f, -0.07120381f, -0.20317958f, 0.06936912f, 0.09352459f, 0.00047683f, 0.05625481f, 
    -0.03046192f, -0.28152531f, -0.06574767f, -0.08479405f, -0.11508029f, 0.08171123f, -0.14095813f, -0.06564348f, 
    -0.00008720f, -0.02288012f, 0.21648557f, -0.01563851f, 0.05145389f, 0.18478762f, 0.11631776f, 0.21708989f, 
    0.05033771f, 0.02440681f, 0.08632568f, -0.10690199f, 0.04338235f, -0.04039474f, -0.14548312f, -0.04680332f, 
    -0.03820727f, 0.03347183f, 0.02423537f, -0.14316344f, -0.01531598f, 0.01289299f, 0.01234677f, 0.08340149f, 
    0.14650875f, -0.12989971f, -0.02401643f, -0.13866523f, -0.02951478f, -0.21833393f, 0.03279963f, -0.12711795f, 
    -0.02489015f, 0.02168235f, 0.02296023f, -0.04298016f, -0.00429852f, 0.01828818f, 0.00774967f, -0.14541309f, 
    0.03325287f, -0.12722673f, -0.09825653f, -0.07503290f, -0.00070921f, 0.03102230f, -0.03690750f, 0.04383680f, 
    -0.06133560f, -0.01913241f, -0.05960071f, -0.09414335f, 0.11472972f, -0.08162536f, 0.25453702f, -0.13696903f, 
    0.03568564f, 0.14559340f, -0.23813872f, 0.10340963f, -0.10007024f, -0.07239114f, -0.07948056f, -0.06629720f, 
    -0.00694253f, -0.03958250f, -0.01764490f, -0.00348353f, -0.14286077f, 0.01646153f, -0.07123313f, -0.08538834f, 
    0.06984726f, -0.09709754f, 0.04515691f, -0.01648501f, -0.36411411f, 0.27723682f, -0.17437753f, 0.53744251f, 
    0.06499492f, 0.03663377f, -0.09766711f, 0.03482446f, 0.00630130f, -0.03483630f, -0.04996420f, 0.04936514f, 
    -0.04963272f, 0.01124768f, 0.19199091f, 0.00065849f, -0.00987629f, 0.25728297f, 0.04291368f, 0.15169086f, 
    -0.16307504f, -0.13262725f, -0.00013768f, -0.10489351f, -0.23123600f, -0.16533865f, 0.01069272f, 0.17964408f, 
    0.10373907f, 0.06650626f, 0.02441030f, -0.19263351f, 0.00543116f, 0.04526749f, -0.03046361f, 0.00091116f, 
    0.02944481f, 0.02196934f, 0.06471410f, 0.06830524f, -0.03798531f, 0.03408321f, 0.19022577f, -0.11800231f, 
    0.07727697f, -0.03009667f, -0.09139922f, -0.14621858f, -0.12161448f, 0.01753405f, 0.03355115f, 0.11030076f, 
    -0.02437089f, -0.09007082f, -0.05152224f, 0.04421537f, -0.11160306f, -0.00506047f, 0.03463684f, -0.14654146f, 
    0.14404659f, 0.03595718f, 0.26445219f, 0.08769579f, -0.02152269f, 0.08273010f, 0.06217650f, -0.09398308f, 
    -0.03882087f, -0.07771797f, -0.00590150f, 0.08446317f, -0.05388298f, 0.04043240f, -0.04076931f, 0.22762807f, 
    -0.03844706f, 0.11787683f, -0.13353501f, 0.01730019f, 0.01727678f, 0.08393544f, 0.11012375f, 0.27282673f, 
    0.03520500f, -0.10463360f, 0.13093883f, 0.03288546f, 0.16270190f, 0.08878159f, 0.10842094f, -0.05945236f, 
    0.15639572f, 0.04962694f, -0.07816932f, -0.06640691f, -0.08440005f, -0.01501803f, 0.10451789f, 0.14035536f, 
    0.08487303f, 0.20462529f, 0.01984790f, -0.07911460f, -0.07907277f, -0.07439378f, 0.00464770f, 0.04057817f, 
    0.33228168f, -0.15585718f, 0.10176010f, -0.25611073f, 0.09304513f, 0.04527446f, 0.12641567f, 0.07804892f, 
    0.14853972f, 0.12197892f, 0.09654325f, 0.09434620f, 0.28984904f, -0.10170484f, 0.07187084f, 0.04746146f, 
    -0.06347996f, 0.09795132f, 0.04277886f, 0.09716321f, -0.03305294f, 0.05582106f, -0.04407960f, -0.09812852f, 
    0.54187703f, 0.10697459f, -0.11116840f, -0.11452256f, 0.01177859f, 0.12774929f, -0.00616158f, 0.21457125f, 
    0.03740296f, 0.11831842f, 0.02153405f, -0.01319508f, 0.12954493f, 0.06921741f, 0.09748384f, -0.10064258f, 
    -0.08268537f, -0.02402250f, 0.05677515f, 0.07902890f, 0.11134900f, 0.00966382f, 0.06829256f, -0.00290585f, 
    -0.15987916f, 0.01741940f, 0.05949690f, 0.11258267f, 0.02091082f, 0.03721119f, -0.03264066f, -0.11992250f, 
    -0.05314580f, -0.05853493f, 0.02079056f, 0.16522384f, -0.18427612f, 0.16351239f, 0.37740713f, 0.01052819f, 
    0.03603267f, -0.04010631f, -0.18562397f, -0.13644929f, 0.17319733f, 0.02217656f, 0.06669827f, -0.06696483f, 
    0.13176920f, 0.00199991f, -0.11570162f, 0.05894677f, 0.02615411f, 0.06423620f, 0.07376131f, 0.00575619f, 
    0.09589390f, 0.18688659f, -0.12519787f, -0.08300354f, 0.52994531f, -0.18478023f, -0.01527084f, 0.08028018f, 
    0.07532623f, -0.19096890f, -0.13166057f, 0.07082500f, 0.02228198f, -0.05821415f, 0.08324592f, 0.15107352f, 
    0.23676175f, 0.19813401f, -0.04084977f, 0.11471572f, -0.04267706f, 0.08676603f, 0.01275416f, 0.35679740f, 
    -0.04902778f, -0.00401578f, 0.07019801f, -0.06443411f, -0.00444952f, -0.19077247f, -0.05446411f, 0.01974297f, 
    0.00018739f, -0.00700005f, -0.05431069f, -0.09102874f, 0.12648988f, 0.11098550f, 0.15982349f, 0.24688901f, 
    0.14284678f, -0.14989297f, 0.25412774f, -0.00317065f, -0.04473032f, -0.06653285f, 0.07764113f, -0.11124129f, 
    0.02451061f, -0.01135939f, -0.04669668f, 0.00304543f, -0.09195513f, -0.23260275f, 0.35915044f, -0.06188505f, 
    -0.06916873f, 0.13268088f, -0.13359183f, 0.06463203f, -0.03730571f, 0.11936677f, -0.06419194f, -0.07112824f, 
    0.08914074f, -0.03178741f, 0.13904434f, 0.15991849f, 0.00829575f, 0.05993506f, -0.00394222f, -0.11298220f, 
    0.01002148f, 0.01601805f, -0.01873161f, -0.00343074f, -0.02381037f, 0.06431273f, -0.09167540f, 0.15676251f, 
    0.16697060f, 0.01300687f, -0.06014149f, 0.00331766f, -0.15173408f, -0.06084760f, 0.03923988f, 0.16039240f, 
    0.28844783f, -0.20693770f, -0.00427731f, 0.13041727f, -0.09729286f, -0.02340031f, 0.08423386f, -0.00869072f, 
    -0.07580771f, -0.05709033f, -0.02167752f, -0.09044420f, 0.05059462f, 0.01838190f, -0.01407706f, 0.04811992f, 
    0.05429245f, 0.13644956f, 0.14762193f, 0.00173355f, -0.01311364f, -0.01702586f, -0.17226598f, -0.06569878f, 
    0.32303092f, -0.02139027f, 0.31654552f, 0.24014592f, 0.01780676f, 0.17989334f, -0.04618499f, 0.02933550f, 
    -0.00351295f, 0.12261019f, 0.00373841f, -0.01319644f, 0.17531592f, 0.22029386f, 0.34571472f, 0.09568397f, 
    -0.03199074f, -0.00184107f, 0.17568815f, 0.05375876f, 0.00187727f, -0.05942230f, 0.08931611f, 0.01129088f, 
    -0.47431058f, 0.10847399f, -0.07652739f, -0.02763842f, 0.08916288f, 0.08592640f, -0.08945185f, -0.04940600f, 
    -0.05577656f, 0.01385086f, 0.11304368f, 0.09796079f, -0.35965529f, 0.17894268f, -0.00375958f, 0.35567746f, 
    -0.05010574f, -0.14044012f, 0.21673088f, -0.10857011f, -0.11278941f, -0.03965216f, 0.09712835f, -0.16568156f, 
    0.13938715f, -0.06485379f, 0.00462306f, -0.14707203f, -0.10977933f, 0.05972385f, -0.13823506f, 0.08726609f, 
    -0.09904888f, -0.04258648f, -0.01129272f, -0.16961361f, -0.26520509f, -0.03118287f, 0.14863908f, -0.09795131f, 
    0.06786218f, 0.00394739f, 0.00218198f, -0.04447750f, -0.14741710f, -0.01495884f, -0.02394304f, -0.03498690f, 
    0.45389959f, 0.06053605f, 0.13658568f, -0.14915670f, -0.12483013f, 0.11090541f, 0.06947933f, 0.03966643f, 
    0.13496701f, 0.07479182f, 0.10529245f, 0.09638071f, -0.38170916f, -0.10607141f, 0.08180565f, 0.13769476f, 
    0.14917210f, -0.03588141f, 0.23735924f, -0.15994839f, -0.17930950f, 0.03686481f, 0.04312300f, 0.14198373f, 
    0.18527873f, -0.09130845f, 0.07793958f, 0.22744256f, -0.12570773f, -0.00760305f, -0.03236281f, -0.02011649f, 
    -0.05952633f, 0.04569829f, 0.02752105f, -0.08037141f, 0.37406987f, -0.19739236f, -0.02623777f, -0.14341165f, 
    -0.05172357f, 0.15489703f, -0.13342635f, 0.03246851f, -0.05334447f, -0.01116604f, -0.03271944f, -0.17839809f, 
    -0.02036268f, 0.03965069f, 0.04115570f, 0.10870709f, 0.03629520f, 0.02811048f, 0.08525806f, -0.11945582f, 
    -0.00435636f, 0.01401766f, -0.13359621f, 0.00782659f, 0.38223889f, -0.08623353f, 0.01783871f, 0.00407180f, 
    -0.13210903f, -0.04379182f, 0.07683340f, 0.20540820f, -0.04328320f, 0.08661114f, 0.19873181f, -0.00916509f, 
    0.20251432f, -0.15042582f, 0.15036295f, -0.02301420f, 0.04783741f, 0.13214326f, -0.03141164f, -0.07914412f, 
    0.09393889f, 0.12553272f, 0.06799092f, -0.19919507f, 0.07674271f, 0.05776927f, 0.08012674f, 0.16957900f, 
    0.17118442f, 0.03839913f, -0.03119230f, 0.04631780f, 0.05689629f, -0.01181790f, -0.01418051f, -0.02927252f, 
    -0.01182328f, -0.01273899f, 0.02003312f, -0.01195702f, -0.01845331f, -0.01085685f, -0.02284229f, -0.01190972f, 
    0.02605319f, -0.03976015f, -0.03637336f, -0.00430441f, -0.01000239f, 0.00391603f, 0.01767817f, 0.02013437f, 
    0.00858575f, 0.02217969f, 0.00231282f, -0.01482503f, -0.02479019f, -0.01160400f, -0.02768838f, -0.01522216f, 
    -0.02689346f, 0.00335142f, -0.01360845f, -0.01750268f, -0.00411311f, 0.01834404f, -0.01364639f, 0.02133907f, 
    -0.01961152f, -0.03613731f, 0.00324290f, -0.02684192f, 0.02368905f, -0.01820424f, 0.00202779f, -0.00620108f, 
    -0.01991127f, -0.03124526f, 0.01725766f, -0.03793722f, 0.00805563f, 0.01274072f, 0.00457744f, -0.02900909f, 
    0.01358101f, 0.01803152f, -0.02708790f, -0.00628395f, -0.00162709f, 0.01926393f, -0.01776584f, 0.00033987f, 
    0.01728202f, 0.01953356f, 0.01808058f, 0.03007384f, 0.02040862f, 0.01784188f, 0.02549165f, 0.00752820f, 
    -0.02418736f, 0.01641679f, -0.00973643f, -0.02205690f, 0.02364442f, 0.02490192f, 0.00065910f, -0.03207558f, 
    0.00251143f, -0.02360941f, -0.00365185f, -0.01852215f, -0.02819706f, -0.02900825f, 0.00168217f, 0.03119565f, 
    0.02989557f, 0.00860928f, 0.02821276f, 0.00893197f, -0.02755107f, -0.04013849f, -0.00947910f, 0.00984878f, 
    0.02078901f, -0.01501126f, 0.01031214f, -0.02917847f, 0.00476071f, -0.01717052f, -0.00853126f, 0.01458508f, 
    0.01505293f, 0.01698368f, -0.03454107f, 0.01453376f, 0.01166687f, -0.04023254f, -0.03238060f, -0.02995857f, 
    -0.03579454f, 0.00006601f, 0.01609892f, 0.02685351f, -0.02473959f, 0.00034793f, 0.03792314f, 0.03589132f, 
    -0.00106176f, -0.01311296f, -0.02560161f, -0.01247403f, -0.01058461f, -0.02830110f, -0.02343525f, -0.02423881f, 
    0.00791543f, 0.02234039f, 0.02027666f, -0.00664380f, -0.03075811f, -0.01625672f, -0.01454159f, -0.01095807f, 
    -0.00341386f, 0.02747020f, 0.02044004f, -0.03097009f, 0.03167057f, -0.03777169f, -0.00730627f, 0.01036142f, 
    0.01251198f, 0.01416581f, -0.00033246f, -0.00147307f, -0.03457087f, -0.02719416f, -0.03645743f, -0.00916901f, 
    -0.00091924f, -0.04216260f, -0.04022481f, 0.02285810f, -0.01965926f, 0.01412880f, 0.01321922f, 0.02728128f, 
    -0.00034246f, -0.00186213f, -0.01182408f, 0.01358769f, -0.00619073f, -0.01637713f, -0.02488630f, -0.01841830f, 
    -0.00691228f, -0.02409776f, -0.01782998f, 0.02064962f, -0.04039604f, -0.03745631f, 0.02599495f, 0.00782811f, 
    -0.03942784f, 0.02579695f, 0.00288004f, -0.03688985f, 0.00324625f, -0.01851640f, -0.00787875f, 0.01667687f, 
    0.03283835f, -0.03553016f, -0.03987355f, -0.00425193f, -0.02136811f, 0.00884240f, -0.00029930f, -0.01895571f, 
    -0.02212693f, 0.03100636f, 0.00544037f, 0.01484528f, 0.01298815f, -0.03177363f, -0.04557540f, -0.02962197f, 
    -0.03376685f, 0.00002002f, 0.01668509f, -0.00644183f, 0.00393034f, -0.00263533f, -0.03681880f, -0.04385345f, 
    -0.03631716f, 0.01232919f, 0.01627602f, 0.02196172f, 0.00083388f, 0.01864453f, -0.03138300f, 0.01099491f, 
    0.01785542f, -0.02048509f, 0.00110612f, -0.01438949f, 0.02455911f, -0.00678988f, -0.02062103f, -0.03767123f, 
    0.03263813f, -0.02202263f, -0.02967780f, 0.03066906f, 0.03293645f, -0.02730368f, 0.00866373f, 0.00020709f, 
    -0.00834363f, 0.00227184f, 0.01537610f, 0.01382126f, 0.01509894f, -0.03192103f, 0.02480325f, -0.02372400f, 
    -0.02205416f, 0.00631979f, 0.03696163f, 0.01744487f, -0.03317231f, 0.01119687f, -0.03837032f, 0.02545628f, 
    -0.01378909f, 0.01437997f, 0.02902905f, -0.03184414f, -0.01073030f, -0.03557302f, 0.02074348f, 0.02577261f, 
    0.00573417f, 0.00781811f, 0.02077031f, 0.00222739f, -0.03383313f, 0.00776433f, 0.02095172f, -0.01801734f, 
    0.02096830f, 0.01687045f, -0.04212970f, 0.00765648f, -0.00122841f, -0.01553567f, 0.01615549f, -0.01556617f, 
    0.02427593f, -0.01705439f, 0.01431843f, -0.02410153f, -0.02812496f, -0.03183595f, 0.02341009f, 0.02606860f, 
    -0.00542333f, -0.03143421f, -0.00467144f, -0.00754322f, -0.01196591f, -0.02189933f, 0.01759523f, -0.03623769f, 
    0.02177379f, 0.00317115f, -0.02301586f, -0.01197224f, 0.03783261f, 0.01906232f, 0.01217574f, -0.03279298f, 
    -0.04530500f, -0.02286530f, 0.00721521f, 0.02202380f, -0.03167859f, -0.02940891f, -0.03844946f, -0.03308677f, 
    0.00350391f, 0.00604684f, -0.00048911f, 0.00837405f, 0.02171081f, -0.02876396f, -0.04439037f, -0.01012461f, 
    -0.00971481f, 0.00995984f, 0.04043834f, -0.01119602f, -0.03956500f, 0.02269937f, -0.03170463f, 0.01130332f, 
    -0.00729420f, 0.01356826f, 0.00298340f, 0.00728976f, 0.01023480f, 0.00667661f, 0.00745080f, 0.00056753f, 
    -0.00992690f, -0.02602826f, 0.02615957f, 0.00658504f, 0.01067737f, 0.01127927f, 0.00710757f, -0.00445606f, 
    -0.00522564f, 0.00742689f, -0.01593274f, 0.00022489f, -0.00689551f, 0.03258442f, 0.00281176f, -0.02025191f, 
    0.02819033f, -0.00893432f, -0.00874949f, 0.01882845f, -0.00477010f, -0.00996047f, -0.00557555f, -0.01759863f, 
    -0.02435812f, -0.03167510f, 0.00160856f, -0.00263470f, -0.04117102f, 0.00382575f, -0.02479360f, -0.01128143f, 
    -0.00963680f, 0.00734772f, -0.03965796f, 0.00909119f, -0.01456965f, -0.02649112f, -0.01343414f, -0.02465728f, 
    -0.02749917f, 0.02764291f, -0.00796171f, -0.02347228f, -0.02871970f, 0.01418943f, -0.01623989f, 0.01978786f, 
    0.02497212f, 0.01108674f, -0.02086738f, 0.02225661f, 0.02721131f, -0.03559666f, -0.02732948f, 0.03091408f, 
    -0.00172212f, -0.03478808f, -0.00447501f, 0.01481859f, 0.00456549f, -0.04130974f, -0.00918189f, 0.01658849f, 
    -0.04205111f, -0.00150032f, -0.02211468f, 0.02044274f, -0.01452958f, 0.01456490f, 0.01423724f, -0.03050390f, 
    0.02490896f, 0.03121540f, -0.00327006f, -0.00021368f, -0.04472335f, 0.02670123f, 0.00104524f, 0.01696670f, 
    -0.03472198f, 0.01588292f, 0.01514034f, 0.01217194f, -0.01535604f, -0.01852486f, -0.03189043f, -0.03284452f, 
    -0.02125426f, 0.00727726f, -0.01850016f, -0.03221438f, 0.02418842f, 0.00301706f, 0.00047121f, 0.02381078f, 
    0.00519284f, 0.01026017f, 0.00565373f, -0.00077000f, -0.00821880f, 0.01375957f, -0.03513817f, 0.00066625f, 
    0.03380595f, -0.00980170f, 0.00284627f, -0.04210584f, 0.03146769f, -0.03310035f, -0.04028450f, -0.02221624f, 
    0.00588676f, -0.00118707f, 0.03319345f, 0.01567367f, -0.03990112f, 0.01148247f, 0.00131563f, -0.00301803f, 
    0.00129549f, -0.04095886f, -0.01253303f, -0.03147534f, 0.01865140f, -0.00517235f, -0.00339847f, -0.00695767f, 
    -0.00330584f, 0.00981240f, 0.01388983f, 0.00982412f, 0.02267468f, -0.00369447f, -0.02856989f, -0.04527362f, 
    0.00643165f, 0.01284549f, -0.01597870f, -0.00204601f, -0.03322899f, -0.02881541f, -0.01502941f, 0.01419117f, 
    -0.03973420f, -0.01506438f, -0.02910283f, 0.02203116f, -0.00512531f, -0.02249277f, -0.00028974f, -0.00682998f, 
    -0.00552757f, 0.01888896f, 0.01025713f, 0.03311583f, 0.01425704f, 0.01840069f, -0.01235387f, -0.00120119f, 
    0.01260731f, -0.01159518f, -0.00810593f, 0.01928650f, 0.00071019f, -0.02255051f, -0.00958029f, 0.02035932f, 
    0.01300223f, 0.00073646f, -0.01170882f, -0.00898519f, -0.00129292f, 0.01921512f, -0.00543047f, 0.00375512f, 
    -0.02207159f, -0.01521065f, -0.00211739f, 0.00546470f, -0.02251413f, -0.01350399f, 0.01088113f, 0.02330861f, 
    0.01233083f, 0.03583293f, -0.02284270f, -0.02477275f, 0.02063513f, -0.03663800f, -0.00127594f, 0.01262115f, 
    -0.03178882f, -0.01843264f, 0.00758299f, -0.03418369f, -0.00751392f, -0.04129900f, -0.00527764f, -0.03797541f, 
    0.01617174f, 0.01776450f, -0.04272081f, -0.00658664f, 0.00073429f, -0.02004858f, -0.01994356f, -0.02228774f, 
    0.02158634f, 0.02411116f, -0.02609883f, 0.01156706f, 0.03513825f, -0.02076792f, 0.02147844f, 0.01208658f, 
    -0.01804411f, -0.03305437f, 0.00782007f, -0.01954295f, -0.00748332f, -0.01769379f, -0.03560237f, -0.00663682f, 
    0.00055565f, -0.01308348f, 0.01988132f, -0.00834551f, 0.02272491f, -0.03324504f, 0.01698491f, -0.04629862f, 
    -0.01236526f, -0.00540394f, -0.01648713f, 0.03437074f, -0.02678513f, -0.03021336f, 0.00383454f, -0.00111520f, 
    0.02544031f, -0.00680892f, 0.00101313f, 0.02125349f, -0.01918912f, 0.00723474f, 0.01902081f, -0.03462218f, 
    -0.02130121f, 0.01059968f, 0.02578108f, -0.03376435f, 0.00888149f, 0.02286558f, -0.00195589f, -0.03735375f, 
    -0.02747785f, 0.00125460f, -0.00172823f, -0.03849006f, 0.01083096f, -0.03546109f, -0.04572217f, -0.02692887f, 
    0.02978786f, -0.03051899f, -0.01621919f, -0.01274828f, -0.03095908f, -0.01702803f, 0.02474030f, 0.01893089f, 
    -0.00526216f, 0.03403125f, -0.01744186f, 0.02962395f, -0.03575961f, -0.03374571f, 0.00551137f, -0.02875037f, 
    -0.01129154f, 0.02324920f, 0.00296786f, -0.04163652f, -0.02311692f, -0.00391866f, 0.00858769f, -0.03383665f, 
    0.01618471f, 0.02151184f, 0.00422355f, -0.02208085f, -0.00209311f, 0.02819629f, -0.00980274f, 0.01928454f, 
    0.00973622f, 0.01018935f, 0.00673738f, -0.01298378f, 0.01072612f, -0.02987892f, -0.03606891f, 0.02837393f, 
    -0.02208227f, 0.01682036f, 0.00679307f, -0.03264683f, 0.01574836f, -0.00445216f, 0.02204458f, -0.03455128f, 
    -0.02253406f, 0.02438081f, 0.00656579f, -0.03739116f, -0.02873844f, -0.02096347f, -0.02734957f, -0.03669841f, 
    0.00277943f, 0.02263209f, -0.02088453f, -0.03582861f, -0.00697711f, -0.03958464f, -0.03136127f, 0.02514579f, 
    -0.01147272f, 0.00832673f, 0.03252811f, -0.02426404f, -0.03099416f, 0.01267492f, -0.00037569f, -0.03019956f, 
    -0.03743600f, -0.00944007f, -0.01820043f, -0.01054264f, -0.04002866f, -0.03538329f, -0.03327894f, 0.00994205f, 
    0.02312746f, -0.00321342f, -0.02197623f, -0.02138364f, -0.01552107f, -0.00117543f, -0.03299104f, 0.00282259f, 
    0.02190448f, 0.00606678f, 0.00267325f, -0.02811454f, -0.00867759f, 0.02338463f, -0.02175810f, -0.01098681f, 
    -0.02934297f, 0.01258419f, -0.02465679f, -0.03290872f, -0.03910915f, 0.01253467f, -0.01508731f, -0.01178145f, 
    -0.02345667f, 0.02032825f, 0.01568023f, 0.02733993f, -0.02890484f, -0.01462794f, -0.02484775f, 0.03302965f, 
    0.01072388f, 0.03111648f, 0.02857460f, -0.02267832f, 0.01148909f, 0.02023832f, -0.01137151f, 0.02974839f, 
    0.00470119f, 0.00249309f, 0.01851782f, -0.02012454f, -0.02281999f, -0.00246661f, -0.01142243f, -0.03878387f, 
    0.01099872f, -0.02507464f, -0.00577554f, -0.00236651f, -0.01974327f, -0.02983155f, -0.01637419f, -0.03387557f, 
    -0.02458409f, 0.00876359f, 0.02835966f, -0.02867112f, -0.02165553f, -0.02260508f, -0.00357153f, -0.01225383f, 
    0.02137625f, -0.00274933f, -0.00061583f, -0.01095974f, -0.02987072f, -0.04220454f, -0.01562404f, -0.01180271f, 
    0.01554514f, -0.03037694f, -0.02821258f, -0.02393233f, 0.00603719f, 0.02179663f, 0.02432137f, -0.00049068f, 
    -0.02268364f, 0.01434788f, -0.02606004f, -0.04093155f, -0.03225389f, 0.00216530f, -0.01110272f, 0.02042212f, 
    0.00415931f, -0.02054772f, -0.01913781f, -0.00742195f, 0.03149759f, 0.02141891f, 0.02337566f, -0.00438564f, 
    -0.01542506f, 0.03084585f, -0.00308592f, 0.00519129f, -0.00897191f, -0.01526209f, -0.00253195f, 0.02438664f, 
    -0.20182085f, 0.14391208f, 0.05213014f, -0.15664269f, 0.08722012f, 0.06154390f, -0.02253242f, -0.10262877f, 
    -0.02339772f, -0.05746642f, -0.02886295f, -0.00074134f, 0.03257605f, -0.10705224f, -0.17113878f, -0.16127351f, 
    -0.04296160f, 0.00291007f, 0.00712402f, 0.05095798f, -0.03899965f, 0.02006152f, 0.21774295f, 0.05030505f, 
    0.18560420f, 0.12573153f, -0.04093482f, -0.16969122f, 0.04977635f, -0.01503415f, 0.11293203f, 0.04228114f, 
    0.02708133f, 0.00105022f, 0.07437444f, 0.02311175f, 0.28159827f, 0.07505889f, 0.13006034f, 0.04698637f, 
    -0.00102737f, -0.05391871f, -0.14772801f, -0.04325348f, -0.02010734f, 0.02801506f, 0.08920952f, 0.02242602f, 
    0.23394656f, -0.10978884f, 0.01164858f, 0.00051223f, 0.00934085f, 0.02008193f, -0.07400693f, 0.02034355f, 
    -0.02111511f, -0.05920664f, 0.00651558f, 0.08030365f, 0.12557921f, -0.08398101f, 0.13191916f, 0.00159441f, 
    0.03822849f, 0.07935575f, -0.03325546f, 0.02464161f, 0.01399494f, -0.13347220f, 0.06477530f, 0.00669011f, 
    -0.08477484f, 0.04252107f, -0.10787521f, 0.02248037f, 0.11676909f, 0.06192167f, -0.02239538f, 0.00449597f, 
    0.02651470f, 0.10108708f, -0.10915352f, 0.01089504f, 0.40101618f, 0.04594525f, -0.00486259f, -0.14650558f, 
    -0.01089167f, 0.05551560f, 0.04172518f, 0.09203243f, 0.20127670f, -0.02182587f, -0.01466302f, -0.01240052f, 
    0.10648988f, -0.16263554f, -0.20316824f, -0.07198635f, 0.01120823f, 0.00499358f, -0.03847766f, -0.00137591f, 
    -0.12455932f, -0.06590591f, -0.02493724f, 0.04887632f, 0.02091162f, 0.06929243f, 0.21390338f, -0.17260897f, 
    0.09146154f, 0.06356647f, 0.27890727f, -0.08798037f, -0.00183669f, -0.02408323f, 0.07719336f, -0.10938672f, 
    0.00840233f, -0.01995135f, 0.02691769f, 0.12360889f, -0.04105232f, -0.07142713f, 0.00286217f, 0.02127982f, 
    -0.02216890f, 0.05070084f, -0.01031977f, 0.09234549f, 0.08123396f, -0.10942663f, -0.12292756f, -0.11593771f, 
    -0.00585324f, -0.04452005f, -0.04935765f, -0.04673431f, -0.04348956f, 0.08296183f, 0.10227535f, 0.14192246f, 
    -0.09426216f, -0.00059430f, 0.02978231f, 0.12923236f, -0.00235030f, -0.01490970f, 0.02397791f, 0.02508194f, 
    0.02032998f, -0.06751000f, 0.01759683f, 0.06434543f, -0.01638779f, 0.19173487f, 0.05599197f, -0.10313011f, 
    0.02822137f, 0.04631902f, 0.07054327f, -0.11467320f, -0.04101017f, -0.06941476f, -0.03881324f, -0.06562400f, 
    0.06069867f, -0.04148045f, 0.12238038f, -0.11925273f, 0.11414938f, -0.10948487f, -0.02219589f, -0.12549047f, 
    0.01392333f, 0.00774638f, 0.08462828f, 0.04705353f, 0.06102801f, 0.08114354f, 0.20697580f, -0.13829641f, 
    0.04240948f, 0.00108938f, -0.02845279f, 0.06834779f, -0.06299596f, 0.01179969f, 0.02157883f, 0.01887740f, 
    0.56738180f, 0.13567290f, -0.36951217f, 0.01091852f, 0.07707366f, -0.03493170f, -0.11872634f, 0.08019686f, 
    0.14581643f, 0.10370707f, 0.20945708f, 0.04900352f, 0.14615247f, 0.20288481f, 0.22772069f, 0.00849590f, 
    -0.02019540f, 0.05084953f, 0.00859538f, -0.02181536f, 0.07285737f, -0.11791379f, -0.02396881f, -0.05513908f, 
    -0.07292561f, 0.28580290f, 0.23397782f, -0.04765733f, 0.00918466f, 0.02946993f, 0.09899000f, -0.20015199f, 
    0.05697796f, -0.07160433f, 0.10644996f, -0.07920896f, -0.04657883f, 0.03019642f, -0.00287655f, -0.20557413f, 
    0.00304554f, 0.05254488f, -0.07257301f, -0.04162715f, -0.01907692f, -0.05904867f, -0.04087161f, -0.00667424f, 
    -0.04378523f, 0.04045580f, 0.04335427f, 0.09955863f, -0.05270235f, 0.07131468f, -0.04578366f, 0.04861977f, 
    -0.02387319f, -0.00728652f, -0.11354712f, 0.00795119f, 0.55988842f, 0.01467230f, 0.03727939f, 0.11366016f, 
    -0.01583418f, -0.02478505f, 0.00162552f, 0.04211006f, -0.00652723f, 0.05652066f, -0.03420424f, 0.07912818f, 
    0.08789572f, 0.01110580f, 0.10973556f, 0.19789630f, -0.03904428f, 0.02828003f, 0.01544414f, 0.01710575f, 
    -0.00633665f, -0.00358762f, 0.07546554f, 0.03107708f, -0.24560277f, -0.05489156f, 0.18101564f, 0.16003196f, 
    0.00888634f, 0.01295278f, 0.08114569f, -0.01735255f, -0.02941537f, 0.01447654f, -0.00222229f, 0.02716102f, 
    0.05046520f, 0.00872893f, -0.02520745f, 0.06114752f, 0.03034341f, 0.01065608f, 0.02646635f, 0.03636071f, 
    -0.05708356f, 0.03115004f, 0.06419180f, -0.03525100f, 0.18120624f, 0.22744155f, 0.04572139f, -0.26609680f, 
    -0.13023204f, -0.09047355f, 0.01251172f, 0.07355771f, -0.04850679f, 0.03635569f, -0.02744805f, -0.00648514f, 
    0.43831843f, 0.17659961f, -0.30050519f, -0.12861475f, -0.16131938f, 0.27588615f, -0.01529755f, -0.08478606f, 
    -0.09543721f, 0.00092031f, -0.04770676f, 0.07768166f, 0.02647105f, -0.10562629f, 0.04673397f, 0.22372468f, 
    -0.06394739f, -0.01567608f, -0.00808487f, 0.07978429f, 0.01764801f, -0.11599586f, 0.02378849f, -0.00652449f, 
    -0.06720518f, 0.05816719f, 0.20246308f, -0.13148832f, 0.05173859f, 0.10035135f, -0.05136306f, 0.01714062f, 
    -0.05684446f, 0.01687197f, -0.06846841f, -0.05551827f, -0.50705391f, 0.12623018f, 0.04791111f, 0.04268024f, 
    -0.11163109f, 0.03050842f, -0.01592719f, -0.00202737f, -0.00868829f, -0.06960040f, 0.01258705f, -0.11733792f, 
    -0.03941838f, 0.15069646f, -0.07282945f, -0.15216614f, -0.04205635f, -0.13604157f, -0.03295890f, 0.08564264f, 
    -0.02781424f, -0.02182626f, -0.03312716f, -0.01215777f, 0.19520003f, 0.06438617f, 0.06603583f, -0.16920128f, 
    -0.04880155f, 0.01709780f, 0.04142997f, -0.11309113f, 0.09522854f, -0.05055957f, 0.03678677f, 0.03505842f, 
    -0.11858294f, -0.03633192f, 0.01914971f, 0.04483651f, -0.01654945f, -0.03022277f, -0.03646749f, -0.01765588f, 
    -0.06307412f, -0.13469097f, 0.00570555f, -0.09433056f, 0.01779178f, 0.03527187f, 0.00791770f, 0.16411544f, 
    -0.01478862f, -0.00733571f, -0.00709906f, 0.03994659f, -0.04252412f, 0.04402249f, 0.01599237f, 0.03773543f, 
    -0.51783818f, 0.17466909f, -0.00449533f, -0.00349500f, 0.04941500f, 0.03001300f, -0.12290508f, -0.05972386f, 
    0.02937689f, 0.00401051f, 0.05471973f, -0.00080386f, 0.09919645f, -0.11765406f, 0.00208102f, -0.06231396f, 
    0.04994702f, 0.19926050f, -0.12176490f, 0.00855714f, 0.15955883f, 0.12940645f, -0.03005898f, 0.09364310f, 
    0.11680059f, -0.09100525f, 0.02574646f, 0.23553315f, -0.05491196f, 0.09334581f, -0.06878509f, 0.10914913f, 
    0.06340882f, -0.00112441f, -0.04455654f, 0.06954888f, 0.06881326f, -0.16291083f, -0.04159640f, -0.09429494f, 
    0.06799790f, -0.07892513f, -0.08757753f, -0.02300379f, 0.01547564f, -0.08910244f, -0.01214185f, 0.08193021f, 
    0.02304214f, 0.15756549f, -0.00794883f, 0.05870237f, 0.02117919f, -0.03409416f, 0.08685509f, 0.01186798f, 
    0.03953740f, 0.01210701f, 0.01441503f, -0.13269414f, -0.21269159f, 0.09078217f, -0.05465917f, 0.09097658f, 
    -0.06500721f, -0.00707640f, 0.03804649f, 0.10286696f, -0.04849168f, -0.02102815f, 0.01471675f, -0.07884314f, 
    0.03144475f, -0.00753439f, 0.06753617f, 0.03722114f, 0.12269970f, 0.03482533f, -0.24002907f, 0.03085332f, 
    -0.01890793f, -0.02881851f, 0.06548465f, 0.06150322f, -0.41248482f, 0.48879495f, 0.07016151f, -0.28474993f, 
    -0.04807095f, 0.05304822f, 0.01073504f, -0.06476107f, -0.06035994f, 0.00233487f, -0.08036152f, -0.00644682f, 
    -0.04126512f, -0.04552642f, 0.07527410f, 0.08540869f, -0.04062182f, 0.17493621f, -0.01850692f, 0.07464156f, 
    -0.00486974f, 0.01734641f, 0.04507743f, 0.10869373f, -0.09670536f, -0.00405596f, -0.00178916f, 0.03501729f, 
    0.04682957f, 0.01532636f, -0.00419209f, 0.11206866f, -0.14547095f, -0.07059278f, -0.04706755f, 0.11292298f, 
    -0.22261859f, -0.05449533f, 0.00059099f, 0.03403388f, 0.10188987f, 0.02870457f, -0.08604863f, 0.00125787f, 
    0.01098829f, 0.00899500f, 0.05989768f, -0.02550733f, 0.12290668f, 0.00060338f, 0.06330979f, -0.18629923f, 
    0.01719974f, -0.00623123f, 0.05410364f, 0.05010820f, 0.09224276f, -0.09216843f, 0.13104863f, 0.11583456f, 
    0.14030297f, 0.25290111f, 0.09590257f, -0.04536672f, 0.14961764f, 0.10941356f, 0.08662516f, -0.01896360f, 
    0.03542677f, -0.02607343f, -0.08412410f, 0.09823123f, -0.12256876f, -0.02132121f, -0.00993078f, 0.15515722f, 
    -0.05439223f, -0.00474313f, -0.04905578f, 0.01385188f, 0.04302094f, 0.00211767f, -0.06017605f, -0.14519648f, 
    0.22517747f, -0.03650713f, 0.04664049f, -0.15266708f, 0.10741688f, -0.01317517f, -0.11857891f, -0.01512650f, 
    0.05997847f, 0.04716146f, -0.02003088f, 0.04538982f, -0.00037156f, -0.01300849f, 0.03770142f, 0.06972168f, 
    0.06498382f, 0.03265268f, 0.01758099f, 0.05088928f, -0.09806284f, -0.05582323f, -0.04736428f, -0.02385454f, 
    -0.00266734f, -0.15240125f, -0.05994988f, -0.12107932f, 0.12534072f, -0.10012961f, -0.10258738f, -0.08558281f, 
    -0.01932969f, -0.03716248f, -0.00805163f, 0.12569204f, 0.24235813f, -0.10408633f, -0.25927281f, -0.21138908f, 
    -0.06042957f, 0.05873021f, -0.04497303f, -0.11125036f, 0.08841137f, 0.08324692f, -0.11395848f, -0.05065507f, 
    0.14271504f, -0.01704526f, 0.10534939f, 0.22118513f, -0.04179437f, 0.06576996f, 0.02553317f, 0.14465779f, 
    0.15968721f, -0.10408334f, -0.07467136f, 0.20869426f, 0.42178571f, 0.12539761f, -0.16699876f, -0.37904680f, 
    -0.01050772f, 0.02872216f, 0.05583886f, 0.05687423f, 0.00310645f, 0.03958990f, 0.02937884f, 0.07214636f, 
    -0.02668397f, -0.11951126f, 0.25838685f, 0.13294584f, 0.05158539f, 0.01880872f, 0.00220971f, 0.07674719f, 
    0.01036477f, 0.04203666f, 0.03872033f, 0.03661032f, -0.22639181f, -0.19067489f, -0.03401392f, 0.10769085f, 
    -0.02591839f, -0.06525672f, 0.00762885f, 0.01014423f, -0.01805025f, -0.04737188f, 0.00389823f, 0.04198740f, 
    0.05912497f, -0.05392883f, 0.03548174f, -0.06622427f, 0.03162779f, -0.01124448f, -0.05123692f, 0.01524882f, 
    0.03674472f, 0.18191861f, -0.12041252f, -0.17830543f, 0.24574907f, 0.36647773f, -0.01006092f, -0.11118221f, 
    -0.06139841f, 0.00026483f, 0.02846086f, 0.02301592f, 0.04582600f, 0.03456792f, 0.03086488f, -0.01411111f, 
    0.03673524f, 0.14229931f, 0.11224730f, -0.11127344f, 0.11969614f, 0.07310450f, -0.15050276f, -0.02706610f, 
    0.00890380f, 0.00637143f, -0.08702923f, 0.03286109f, 0.20248055f, -0.02912506f, 0.05702535f, -0.04388529f, 
    -0.03913949f, -0.05434386f, 0.05143056f, -0.00847287f, -0.08449298f, -0.03955425f, -0.04051694f, -0.04036436f, 
    0.37537619f, 0.11159660f, -0.12226119f, -0.14724575f, 0.04023295f, -0.07873806f, -0.06386968f, 0.03397468f, 
    -0.04063785f, -0.05504519f, 0.04694494f, 0.00526984f, -0.37823159f, 0.10076259f, 0.16776195f, 0.06353281f, 
    0.09149493f, 0.06721727f, -0.19399337f, 0.04186262f, 0.12714839f, -0.00508758f, -0.02528264f, 0.02573285f, 
    0.06366280f, 0.00158155f, 0.04870092f, 0.05830730f, -0.01747066f, 0.01487143f, -0.03277349f, -0.02561719f, 
    -0.02786565f, -0.01450433f, -0.02368752f, 0.05938172f, -0.01216199f, 0.15858723f, 0.05470334f, -0.15070228f, 
    0.01660644f, -0.12746626f, 0.04988583f, -0.00488010f, 0.16654359f, -0.12445330f, 0.01611868f, 0.04308597f, 
    0.00563530f, 0.01282498f, -0.02096640f, 0.02246534f, 0.00086858f, -0.01235806f, 0.01634630f, 0.03366487f, 
    0.00997457f, -0.01584228f, -0.03544959f, -0.03980494f, 0.01730837f, -0.01727062f, 0.02084273f, 0.01592744f, 
    -0.03281819f, -0.02034259f, 0.02396633f, 0.01136987f, 0.02709132f, -0.03618527f, -0.02584830f, 0.02617920f, 
    -0.02414729f, -0.00499997f, -0.00670717f, -0.01557088f, -0.00472881f, 0.02831155f, -0.02295302f, 0.01845965f, 
    -0.00479227f, 0.03074449f, -0.00495595f, 0.01232640f, -0.02746056f, -0.03138497f, -0.01597697f, 0.00004974f, 
    -0.02692312f, 0.02890130f, 0.02038676f, 0.01904913f, -0.02940944f, -0.00860248f, 0.02737648f, 0.01122488f, 
    -0.03146803f, 0.00406765f, 0.00408209f, 0.01133661f, 0.01411556f, 0.00349626f, 0.02912613f, -0.00662924f, 
    -0.03680807f, 0.00839893f, -0.00885001f, 0.00023904f, -0.03006795f, -0.00247131f, 0.00264323f, 0.01998940f, 
    -0.02142163f, 0.01750694f, 0.00055875f, -0.00403439f, -0.03390148f, 0.00974841f, -0.02696966f, -0.00595317f, 
    -0.02781688f, -0.03921977f, 0.01587111f, 0.00396360f, 0.04200614f, 0.02053131f, 0.01415978f, -0.00964954f, 
    -0.02074143f, 0.00253419f, -0.03013655f, 0.00758258f, -0.03998991f, -0.00439552f, 0.02957098f, -0.03324562f, 
    0.01239782f, 0.02642334f, -0.01829669f, 0.02904083f, 0.02476941f, 0.00539556f, 0.01243480f, -0.03375527f, 
    -0.02842594f, -0.02489273f, -0.00831078f, -0.04430419f, -0.04117912f, -0.00402457f, 0.00840093f, -0.01745052f, 
    -0.01686570f, -0.00698781f, -0.00629855f, -0.02428266f, 0.01559835f, 0.01794161f, 0.02130953f, 0.02073576f, 
    -0.00986664f, 0.00293305f, -0.02050563f, 0.01329993f, -0.02956427f, 0.02456522f, -0.00725197f, 0.01569504f, 
    -0.00691741f, -0.01308167f, -0.03298184f, 0.02624873f, -0.00391886f, -0.03982287f, -0.03673155f, 0.01278609f, 
    0.01307577f, -0.01761637f, -0.01513971f, -0.01940523f, 0.02911066f, -0.01868006f, -0.02735246f, -0.02554297f, 
    0.00155693f, 0.01129368f, -0.02636260f, 0.02362118f, -0.03278701f, 0.02260980f, -0.01452529f, 0.01442384f, 
    -0.01231841f, 0.00660738f, -0.01295401f, -0.03220537f, 0.02512648f, -0.02878026f, 0.00509040f, -0.02222897f, 
    -0.00797362f, -0.01052734f, 0.02122586f, -0.00480908f, 0.01453017f, 0.01608089f, -0.00396735f, 0.01242253f, 
    0.00442615f, -0.03264004f, -0.04191558f, 0.01730146f, -0.03571320f, -0.00946563f, -0.04058924f, 0.01632692f, 
    -0.03584479f, -0.00250741f, -0.02964833f, -0.03303090f, 0.00986232f, 0.03160106f, 0.01595082f, 0.00879773f, 
    0.00537262f, -0.01167428f, -0.03199885f, -0.02164168f, 0.00348966f, -0.03114892f, 0.01782003f, 0.00607340f, 
    -0.01865459f, 0.03609889f, -0.03749755f, 0.03077433f, 0.02645811f, 0.01007334f, -0.01068360f, 0.02380736f, 
    0.00215922f, 0.02943867f, -0.00299426f, 0.02043108f, 0.00618878f, 0.00921768f, 0.02042235f, 0.02259040f, 
    -0.01764031f, -0.01618522f, 0.01695198f, -0.02211428f, 0.02848465f, 0.03496888f, 0.02922943f, -0.00776340f, 
    0.00036507f, -0.02580442f, 0.02309026f, -0.02457415f, 0.02967815f, -0.02636082f, 0.00348173f, -0.03068667f, 
    -0.02582120f, 0.02064570f, 0.01608715f, -0.02825552f, 0.00689943f, -0.00279395f, 0.00204267f, -0.01314018f, 
    0.01290158f, 0.01893461f, -0.00076272f, -0.01694906f, -0.03219431f, -0.03787796f, -0.02995846f, 0.02119737f, 
    -0.01032081f, -0.01770269f, 0.03740691f, 0.01200799f, -0.01285046f, 0.00980776f, 0.00367217f, -0.00242596f, 
    0.02491422f, -0.02849708f, 0.00701169f, -0.02841354f, -0.00728285f, 0.01357585f, 0.02152740f, -0.01476339f, 
    0.00477340f, 0.01418133f, 0.00357541f, 0.00007726f, -0.02409879f, -0.03502982f, 0.01675886f, 0.00157310f, 
    0.02098193f, -0.03361747f, -0.01311626f, 0.01118479f, -0.03778728f, 0.02437856f, -0.01945155f, 0.01719302f, 
    -0.00933576f, -0.03876830f, -0.00769495f, 0.02541294f, 0.01702424f, 0.02657032f, -0.03621779f, 0.00375362f, 
    -0.01818071f, 0.00261405f, -0.03880400f, 0.00424172f, -0.02108294f, 0.01475941f, -0.04159730f, 0.02792165f, 
    0.02604028f, -0.02679551f, -0.04045795f, -0.01181651f, 0.01838973f, -0.03826367f, -0.00566993f, 0.02905457f, 
    -0.00020130f, -0.01902925f, 0.02686600f, -0.02413476f, 0.01310687f, 0.01907160f, -0.03874219f, -0.00213505f, 
    -0.03921467f, 0.02900468f, -0.03411599f, 0.01184554f, -0.02282097f, -0.02320067f, -0.04136390f, -0.02317619f, 
    0.00682798f, -0.03172917f, -0.01224339f, -0.02421827f, -0.01364570f, -0.00663160f, -0.01417673f, 0.01482650f, 
    -0.00406055f, 0.02818944f, -0.01307627f, -0.03861629f, 0.00827144f, 0.01904132f, 0.02017326f, 0.02719814f, 
    0.00047332f, 0.00068498f, 0.01773220f, 0.01698030f, -0.04095123f, 0.00891178f, -0.02146669f, 0.00590642f, 
    0.01784868f, 0.00943775f, -0.00995356f, 0.00526385f, 0.00673327f, -0.00202271f, -0.00410506f, 0.00852078f, 
    0.02040380f, 0.02490661f, -0.00718014f, -0.00734442f, 0.00819005f, -0.00251822f, 0.00952913f, -0.02818702f, 
    0.00314440f, 0.02134313f, -0.04193791f, 0.02954677f, 0.01828899f, -0.00328229f, 0.02497498f, 0.02810705f, 
    0.02267654f, -0.00523266f, -0.00440381f, -0.02224796f, 0.00227032f, 0.01374929f, 0.02281089f, 0.01134438f, 
    0.00632760f, -0.03022430f, 0.02174458f, 0.03499005f, 0.01529858f, 0.02276284f, -0.00060870f, -0.00021439f, 
    0.02998905f, -0.00705838f, 0.02585557f, -0.00320920f, 0.01987566f, 0.00272582f, 0.01996044f, 0.01239625f, 
    -0.00760925f, 0.01162721f, -0.01303197f, 0.00007471f, -0.02845932f, 0.02623355f, -0.01543173f, -0.01086775f, 
    -0.03047536f, 0.01835414f, -0.01130879f, 0.02748764f, 0.00219191f, 0.04100534f, 0.00183503f, 0.02098054f, 
    -0.00335399f, 0.01636300f, 0.00416560f, -0.00483046f, 0.01373258f, 0.00291625f, 0.02469234f, 0.01400198f, 
    -0.02883705f, -0.04106630f, 0.02968945f, 0.02802162f, 0.00585132f, -0.02744029f, -0.02462891f, 0.00269716f, 
    0.00023613f, 0.00927177f, -0.04171101f, 0.02321019f, -0.00191630f, -0.03697268f, -0.02609199f, -0.03382205f, 
    -0.01397414f, 0.02596073f, 0.00718849f, -0.02371778f, -0.00048342f, -0.04028261f, 0.01458806f, 0.02999075f, 
    -0.03185125f, -0.03987297f, -0.03424234f, 0.03747931f, -0.03662347f, 0.00673435f, 0.02107586f, 0.01645994f, 
    -0.03287045f, 0.00087517f, -0.02464303f, -0.03637229f, -0.00675788f, -0.02451800f, 0.02265600f, -0.01794096f, 
    0.01040189f, -0.02075237f, 0.04205851f, 0.02125882f, -0.00943302f, -0.01128808f, 0.02131707f, -0.02853043f, 
    0.02565963f, -0.01340460f, -0.00255897f, -0.00716076f, -0.01749662f, -0.04136275f, 0.01392335f, 0.00516991f, 
    -0.03930300f, -0.00836590f, -0.00976145f, -0.03861149f, -0.01853190f, -0.03443494f, 0.00478859f, 0.02453622f, 
    0.01259738f, 0.00430545f, -0.01778605f, -0.03105502f, -0.03154876f, 0.00107090f, -0.02460468f, 0.01855838f, 
    -0.03752105f, 0.01133054f, 0.00468873f, 0.00146195f, 0.02680096f, 0.01045709f, -0.02359365f, 0.02750958f, 
    -0.02659877f, -0.01428171f, 0.02638452f, 0.01284314f, -0.03082740f, 0.01270261f, -0.01654099f, -0.02053471f, 
    0.01027851f, 0.01002291f, 0.02770785f, 0.02200258f, -0.03001632f, 0.00228266f, 0.00107162f, 0.01048132f, 
    0.04402976f, 0.00169930f, -0.00019727f, -0.02442013f, -0.01128818f, 0.02458174f, -0.01413267f, 0.00119126f, 
    0.02700153f, -0.04245776f, 0.00317718f, -0.01276857f, 0.00815229f, -0.00354376f, 0.01232120f, -0.01596948f, 
    0.01277991f, -0.02496256f, -0.03545075f, -0.02544128f, 0.01028870f, -0.02203962f, -0.02197114f, 0.02958056f, 
    -0.03016154f, 0.01825900f, 0.01426004f, 0.02289120f, -0.02718255f, -0.01708766f, -0.00209795f, -0.00673807f, 
    -0.02257071f, -0.00824842f, -0.00791129f, -0.03353582f, -0.02038619f, -0.00327064f, -0.00735861f, 0.03535130f, 
    0.00848451f, 0.00252722f, -0.03081044f, -0.01448473f, -0.02711427f, -0.00101463f, -0.01279262f, -0.03002639f, 
    -0.03057584f, -0.01567544f, -0.00733778f, -0.01382486f, 0.01415604f, -0.00905018f, 0.00246600f, 0.00630812f, 
    0.03591995f, 0.00496028f, 0.04183646f, 0.02976306f, 0.02236639f, 0.01172691f, -0.00504669f, -0.02539945f, 
    0.02128528f, -0.04135571f, -0.03152536f, -0.02303282f, 0.01406005f, 0.00149108f, -0.03187052f, -0.03625397f, 
    -0.01686704f, 0.02373064f, 0.01791055f, -0.03965689f, -0.00087193f, 0.00906892f, -0.01844620f, 0.02862882f, 
    -0.03125795f, -0.01212652f, 0.02705045f, -0.03835559f, -0.02711536f, -0.02249009f, -0.01256424f, 0.01190977f, 
    -0.01438821f, 0.00773110f, 0.00950433f, 0.00035603f, 0.02814634f, 0.02218334f, -0.00794852f, -0.03800583f, 
    -0.02626645f, -0.00477369f, -0.03611997f, -0.03919655f, 0.01366245f, 0.00182716f, -0.01581321f, -0.03650356f, 
    0.02980157f, 0.02142890f, -0.01722426f, 0.02433583f, -0.02949507f, -0.02132421f, -0.00626825f, -0.03412785f, 
    0.02368018f, -0.02350128f, 0.00712287f, -0.00941029f, -0.00580800f, 0.02150328f, -0.00549538f, 0.00936714f, 
    -0.02400322f, -0.00271340f, -0.00742924f, 0.01106852f, -0.00397076f, -0.01934253f, 0.01703316f, 0.00873455f, 
    0.02200837f, -0.00728595f, 0.00082756f, 0.03435029f, 0.00859642f, 0.01228785f, 0.02191139f, 0.01227848f, 
    -0.03296662f, 0.00841416f, 0.00659536f, 0.00339398f, 0.02928107f, -0.02561754f, 0.01803453f, -0.04043437f, 
    -0.01274891f, 0.03552069f, 0.01357349f, -0.00820921f, 0.00526737f, -0.02894949f, 0.02139943f, -0.00032306f, 
    -0.02458640f, -0.04160735f, -0.00475230f, -0.03684461f, -0.02198802f, -0.02565949f, -0.00330851f, -0.03178016f, 
    -0.03080840f, -0.01603379f, -0.02890640f, 0.03076047f, -0.02168120f, 0.02738523f, -0.00964572f, -0.03038055f, 
    -0.00417366f, -0.00616264f, -0.02125072f, -0.01306020f, -0.00805710f, 0.02042042f, -0.03034443f, 0.01086818f, 
    0.03138185f, -0.01804806f, -0.01510322f, 0.01263323f, 0.01812271f, 0.02864161f, -0.01990122f, -0.00673103f, 
    -0.03996490f, -0.00448694f, -0.02502065f, -0.04118516f, 0.01667036f, -0.00424782f, -0.03929203f, -0.03946527f, 
    0.04363895f, 0.00047463f, 0.00623247f, -0.00158163f, -0.04126277f, 0.00029553f, -0.00825893f, -0.01038506f, 
    0.01343739f, -0.01658512f, -0.03322416f, 0.01448162f, 0.01079523f, -0.03910452f, 0.02417311f, 0.00284924f, 
    -0.02004431f, 0.02916402f, -0.02538243f, -0.02708915f, -0.02369896f, -0.02438745f, -0.02401509f, -0.02927640f, 
    -0.02827089f, 0.01170944f, 0.01892035f, -0.02155028f, 0.00109694f, 0.01010898f, -0.02955473f, 0.00849683f, 
    0.00003910f, 0.00226476f, -0.01500109f, -0.03936938f, -0.01542233f, -0.03227661f, -0.04110534f, -0.00205023f, 
    -0.02302080f, 0.01415639f, -0.00314697f, -0.00417180f, 0.01797828f, -0.01788035f, 0.00407043f, -0.02596541f, 
    -0.01609168f, -0.03024305f, -0.02798789f, -0.00924321f, -0.02979181f, -0.00827986f, 0.01056176f, 0.01270719f, 
    0.02291026f, 0.01290970f, 0.00823269f, 0.02538610f, -0.01110018f, -0.01840370f, -0.02322083f, -0.00439468f, 
    0.00040701f, 0.00257377f, -0.02787706f, -0.00479953f, -0.04128598f, -0.01713787f, -0.01006842f, -0.03419265f, 
    -0.00433029f, -0.00057121f, 0.02466867f, -0.02133833f, -0.01398570f, 0.02132151f, -0.04126403f, -0.01425313f, 
    0.24772753f, -0.11130132f, 0.09374103f, 0.03306504f, 0.16683072f, 0.07150868f, 0.08644590f, 0.00728566f, 
    -0.10820051f, -0.04023723f, -0.04478690f, 0.26929289f, 0.39616737f, 0.06041583f, 0.02088885f, 0.18840398f, 
    0.08195042f, 0.12525710f, 0.17382309f, 0.02509901f, 0.03443375f, -0.06578793f, 0.00818125f, 0.08736095f, 
    0.03595569f, 0.04176553f, 0.16799766f, 0.10344726f, 0.03727935f, 0.18577178f, 0.02428184f, -0.03176193f, 
    0.03224031f, 0.01471461f, 0.02043247f, -0.04095127f, -0.12589410f, 0.02405979f, 0.20334646f, 0.10411085f, 
    0.06440771f, -0.00883265f, -0.08690411f, 0.00477569f, 0.07778824f, 0.03089225f, -0.15326144f, -0.10982503f, 
    -0.10980970f, -0.17266755f, 0.35795599f, -0.07932874f, -0.01874539f, -0.04582716f, -0.12138008f, 0.02251540f, 
    -0.16870570f, -0.08824150f, 0.06590140f, -0.02467322f, -0.29085615f, 0.19466820f, 0.09140918f, 0.12633270f, 
    0.20761979f, -0.06848665f, -0.13209471f, 0.16278589f, 0.00025176f, -0.00045063f, -0.01083769f, -0.00274772f, 
    0.07717656f, -0.05174782f, -0.09325933f, 0.14046957f, 0.06481442f, 0.14347215f, 0.11327783f, 0.10109351f, 
    0.01432999f, 0.08150903f, 0.05066348f, -0.04462722f, -0.06432211f, -0.04289449f, 0.02703659f, 0.09987687f, 
    -0.03026082f, 0.16538312f, -0.07687714f, -0.06317138f, 0.20774068f, 0.06723403f, -0.08664513f, 0.20450939f, 
    -0.02587694f, 0.07386762f, -0.02683357f, -0.10082366f, -0.05161361f, 0.02829831f, -0.06036747f, -0.06772789f, 
    0.07689082f, 0.07688660f, -0.12275688f, -0.15029544f, 0.00796535f, -0.07361794f, 0.04657609f, 0.08841556f, 
    0.01074656f, 0.08500323f, -0.01669722f, 0.21995462f, 0.07859081f, 0.07155704f, 0.06359848f, 0.09107911f, 
    -0.17496921f, -0.21989696f, -0.19636814f, -0.18187219f, -0.01130904f, -0.09180126f, 0.00114708f, -0.00134819f, 
    0.12104765f, 0.09883611f, 0.05005724f, 0.02809374f, 0.02081856f, 0.05247383f, 0.11199090f, 0.02853656f, 
    0.08028229f, 0.09077000f, -0.03817879f, -0.07903900f, -0.01381033f, -0.00006565f, 0.02424575f, -0.14327484f, 
    -0.01108918f, -0.03024133f, -0.05426287f, -0.11788225f, -0.02472589f, -0.15935753f, 0.02168932f, 0.02225001f, 
    0.01919108f, -0.03295543f, 0.11300537f, -0.01321360f, 0.05963735f, -0.03838967f, 0.18301500f, 0.09408225f, 
    -0.00134904f, 0.04149795f, 0.05627256f, 0.02339714f, 0.13100079f, -0.02445712f, -0.01305536f, -0.06359120f, 
    -0.24641816f, -0.04400486f, 0.04849688f, 0.20090042f, 0.00290850f, 0.01801516f, -0.21250747f, 0.00079229f, 
    -0.01447704f, -0.06646915f, -0.02143940f, -0.10981643f, -0.09470458f, -0.17248508f, 0.03981229f, 0.19322816f, 
    0.06483251f, 0.17638189f, 0.17441429f, -0.02270637f, -0.00175263f, 0.03313305f, -0.00012843f, -0.08581610f, 
    -0.22365575f, -0.00331179f, 0.04000554f, 0.01182702f, -0.09238997f, 0.18697743f, -0.16035536f, -0.00254454f, 
    0.05894275f, 0.04943081f, -0.13351965f, -0.00469901f, -0.01505310f, -0.03873378f, -0.00636600f, 0.07703723f, 
    -0.13871525f, -0.06529702f, 0.03309649f, 0.01576737f, 0.09315540f, 0.00794613f, 0.01855854f, 0.09845127f, 
    -0.27159670f, -0.12296369f, -0.06456395f, -0.06606388f, -0.04963715f, -0.06827651f, 0.00722416f, -0.12478911f, 
    -0.03577956f, -0.00574872f, 0.05965497f, 0.06220938f, -0.01154654f, -0.12831858f, 0.13114256f, 0.11304463f, 
    0.20615172f, 0.09899520f, 0.11668957f, -0.00387204f, -0.01177772f, 0.02168203f, -0.05275263f, 0.04509431f, 
    -0.02922185f, 0.04098065f, 0.00947477f, 0.00270743f, 0.00809933f, -0.10163684f, 0.09260739f, -0.05185216f, 
    0.01484508f, 0.08903287f, 0.01301564f, 0.16568659f, -0.19797902f, 0.00845838f, 0.05435644f, 0.08115306f, 
    -0.03456622f, -0.06541565f, -0.08746442f, -0.00143274f, 0.00999311f, 0.01216170f, -0.01338136f, 0.00928395f, 
    -0.17993197f, -0.04117588f, 0.00407461f, -0.07044226f, -0.08596336f, -0.12816566f, -0.09012001f, -0.05450093f, 
    -0.06493145f, -0.07151727f, -0.00604281f, -0.02605070f, 0.35309136f, -0.07064576f, -0.01045132f, -0.01977332f, 
    0.01175515f, -0.02779423f, -0.10136151f, -0.10744019f, 0.09967206f, 0.01876488f, 0.05308783f, 0.19119523f, 
    -0.15518159f, 0.02645193f, 0.04988192f, -0.11735197f, -0.00276423f, -0.05526620f, 0.00059636f, -0.03443760f, 
    0.02738631f, -0.10804218f, -0.04124043f, -0.01899009f, 0.05536281f, 0.68221086f, -0.10003327f, 0.35658282f, 
    -0.11415054f, 0.13382873f, -0.08168194f, 0.00831813f, -0.05391517f, -0.10021962f, 0.00716755f, -0.05399739f, 
    -0.07788120f, -0.03533991f, 0.13271178f, 0.20707072f, 0.00430753f, 0.28742272f, -0.00335777f, 0.07089178f, 
    0.03850964f, -0.02872104f, 0.05227363f, 0.07826000f, -0.00361679f, 0.04406621f, -0.11727113f, 0.02336606f, 
    0.07506154f, -0.08055153f, 0.05113405f, -0.04421478f, -0.00132773f, 0.14545910f, 0.12246948f, 0.17532489f, 
    0.10272229f, 0.05236233f, -0.15024844f, 0.09881184f, 0.15993349f, 0.03068338f, -0.02565795f, 0.12770782f, 
    0.03047561f, 0.05446791f, 0.02931497f, 0.03364021f, -0.12439773f, -0.17185131f, -0.28274530f, -0.04189073f, 
    -0.04657097f, 0.06278149f, -0.03030938f, 0.13248442f, 0.03949760f, -0.03402401f, 0.02737590f, -0.06320222f, 
    0.01980817f, 0.04213547f, 0.23425654f, 0.02093204f, 0.06664264f, -0.00703917f, 0.07469228f, -0.06080382f, 
    -0.00879984f, 0.00994477f, 0.00947351f, 0.06381762f, -0.20544332f, 0.01801964f, -0.00034647f, 0.09461292f, 
    0.00063185f, 0.03871216f, -0.09032328f, -0.14049727f, 0.03133047f, -0.11043846f, -0.03277165f, 0.07342675f, 
    -0.07145336f, -0.15589467f, -0.01408434f, 0.01052515f, 0.10850430f, 0.03681323f, 0.11095980f, -0.11493068f, 
    -0.00935603f, 0.04782148f, -0.04889174f, 0.07506973f, 0.12334421f, 0.16920787f, 0.15550932f, 0.00293831f, 
    -0.10267608f, 0.05460480f, -0.00388908f, -0.09714592f, 0.03605394f, -0.02660504f, -0.02855978f, 0.03168618f, 
    0.36898181f, -0.10795225f, -0.02910583f, -0.02452176f, -0.00154078f, -0.09330474f, 0.03834954f, 0.09969866f, 
    -0.03049772f, 0.13115790f, -0.06083961f, -0.17352283f, -0.19317542f, -0.19571403f, 0.04457763f, 0.07753530f, 
    0.10093942f, -0.01593892f, -0.09146270f, -0.05107597f, -0.06786302f, -0.02703523f, -0.11063519f, 0.01097398f, 
    0.10898933f, -0.06862431f, 0.10188813f, 0.18687877f, -0.02577731f, 0.11650087f, 0.00480126f, 0.05114096f, 
    0.03830837f, 0.10542491f, -0.03635330f, 0.12136298f, 0.24228559f, 0.03425696f, 0.17694576f, 0.02623838f, 
    0.01363019f, -0.01695145f, -0.03912567f, 0.11244729f, -0.01570206f, 0.00893141f, -0.04861610f, -0.12480280f, 
    -0.13525078f, 0.01496414f, 0.10002489f, -0.04801540f, 0.10552548f, -0.03813073f, 0.02544229f, 0.10759737f, 
    0.00006282f, 0.04996018f, -0.02921321f, 0.08272290f, 0.03933988f, -0.24601504f, -0.10658634f, -0.09548898f, 
    -0.07200275f, -0.07154777f, 0.06543469f, 0.13087034f, 0.13763505f, 0.10635545f, 0.01900265f, -0.02280985f, 
    0.03489027f, -0.18715787f, -0.25591177f, 0.03325656f, 0.02016986f, 0.01034143f, -0.06217050f, 0.14505012f, 
    -0.04694896f, 0.04145080f, -0.02777371f, -0.05468264f, 0.32900268f, 0.18277152f, 0.23775277f, 0.25253183f, 
    0.00610834f, -0.08454392f, -0.05319647f, 0.06500700f, -0.03096442f, -0.02025156f, -0.03634877f, 0.04076349f, 
    -0.01992446f, -0.17483842f, -0.06951346f, -0.05874653f, -0.10284057f, 0.04826746f, -0.17706971f, 0.10734356f, 
    0.00654825f, -0.00847249f, 0.09523274f, 0.20559692f, 0.11572663f, -0.10240554f, -0.12138660f, -0.07264279f, 
    0.00109154f, -0.05250986f, -0.05851849f, -0.10659581f, 0.00527896f, 0.02035989f, 0.03918361f, 0.01825597f, 
    0.25375602f, -0.13494205f, 0.12536998f, 0.16237907f, 0.16309902f, -0.14269865f, 0.31201535f, -0.10366214f, 
    0.01636127f, 0.12286564f, -0.02718317f, 0.01642947f, 0.35359585f, -0.04309529f, -0.08015082f, 0.13766889f, 
    0.08040685f, -0.03665362f, 0.18818697f, 0.06622496f, 0.00617498f, 0.14626144f, 0.13436246f, -0.06085608f, 
    -0.06918392f, -0.15711145f, 0.12383879f, 0.16599779f, 0.10536710f, 0.23676305f, 0.07861062f, -0.02385388f, 
    0.02439305f, -0.01360760f, 0.00228011f, 0.08929536f, -0.17552164f, -0.20592371f, -0.12088570f, -0.04566199f, 
    -0.06254384f, -0.06222396f, 0.00644413f, -0.06621899f, 0.08348451f, 0.05013613f, 0.02468795f, 0.18106666f, 
    -0.00441487f, -0.01900350f, 0.17002614f, 0.11711227f, 0.06702965f, -0.08954597f, -0.08126672f, 0.00911551f, 
    -0.00209392f, -0.00233718f, 0.02411609f, -0.01344771f, -0.06066149f, -0.05136348f, 0.00657166f, -0.02684359f, 
    0.12882872f, 0.01588739f, -0.06077899f, 0.03812188f, 0.03560531f, 0.06145439f, -0.01513840f, 0.07720866f, 
    0.03112306f, -0.01506070f, 0.38770691f, 0.28305992f, 0.01087524f, 0.02315471f, -0.13874798f, -0.00599549f, 
    0.02536227f, -0.03193796f, 0.10712560f, -0.07698881f, -0.39889368f, -0.15969466f, 0.03170579f, 0.12419312f, 
    -0.11361495f, 0.03342058f, 0.07143658f, 0.07580429f, -0.04099435f, 0.06327564f, -0.13106097f, 0.02332227f, 
    -0.14506453f, 0.14567704f, -0.20292296f, -0.17683026f, 0.05948998f, -0.00802376f, -0.06347642f, 0.06876418f, 
    -0.02412090f, -0.00809325f, -0.08595487f, 0.17661972f, -0.30588472f, 0.54934508f, 0.08807553f, 0.22436123f, 
    0.10910539f, 0.00455041f, 0.13084687f, 0.03995337f, 0.01820985f, -0.05577816f, 0.10328963f, 0.06454399f, 
    0.05070306f, 0.10715550f, 0.21708763f, 0.03687843f, 0.03042996f, -0.00886163f, -0.08916922f, -0.00698555f, 
    -0.01467290f, 0.07480931f, 0.13200428f, 0.09692603f, -0.13922381f, -0.32238409f, 0.01104607f, -0.14586024f, 
    -0.01947853f, 0.02274931f, 0.01358762f, 0.05781839f, 0.13141656f, 0.06674113f, -0.04277157f, -0.05583870f, 
    0.09704908f, -0.09822831f, 0.10436766f, -0.03068058f, 0.00798597f, 0.05376563f, -0.10829961f, -0.05990548f, 
    -0.02733990f, 0.01097076f, -0.20252155f, -0.05556326f, -0.31885380f, 0.01241773f, 0.34795561f, 0.29577392f, 
    0.03911914f, -0.12449364f, -0.04277558f, -0.11465954f, -0.11181221f, 0.01707593f, -0.00641440f, -0.01285592f, 
    0.07752617f, -0.00779307f, 0.03299690f, 0.22505353f, -0.08105428f, 0.11961095f, 0.03737992f, -0.06617930f, 
    0.07804531f, -0.00900875f, 0.00589750f, 0.13111490f, 0.15151660f, -0.01020205f, 0.12557450f, 0.08447590f, 
    0.07353650f, -0.00477174f, -0.10178707f, -0.05603886f, 0.04329677f, 0.00708015f, 0.00747841f, -0.05429369f, 
    -0.36342779f, 0.22949320f, 0.33686191f, 0.08869534f, -0.00139946f, -0.03814727f, -0.11482173f, 0.01296408f, 
    -0.01032249f, -0.02214434f, 0.00764556f, -0.12747124f, 0.29196167f, -0.18650669f, -0.02073250f, 0.10846182f, 
    0.05552576f, -0.00575605f, -0.01491285f, -0.00413110f, -0.13105004f, -0.01675174f, 0.00295918f, -0.14477006f, 
    0.08125326f, -0.13063307f, 0.16417225f, 0.04233776f, 0.07638405f, 0.06080331f, 0.00459768f, 0.14151944f, 
    0.01543040f, 0.05744052f, 0.09892975f, 0.03242186f, 0.21524727f, -0.13665389f, 0.07786229f, 0.05109305f, 
    0.14569801f, 0.12344995f, 0.04004565f, 0.04672265f, 0.05670862f, 0.03239401f, -0.02885200f, 0.09121729f, 
    0.09342232f, -0.08069863f, -0.22222878f, 0.08196136f, 0.06167495f, 0.11688376f, -0.05627732f, 0.03075768f, 
    -0.02857039f, 0.03081177f, 0.07918607f, 0.01995643f, 0.09758988f, -0.17659719f, -0.01091857f, 0.01899325f, 
    0.24642850f, 0.12429313f, 0.15694633f, 0.12877692f, 0.01404655f, -0.04966452f, -0.00295753f, 0.12795949f, 
    0.12186599f, 0.13561308f, -0.02147832f, -0.03901141f, 0.24629669f, -0.01546044f, 0.02824123f, 0.06902049f, 
    0.00764888f, -0.00154038f, -0.01381353f, 0.06141441f, 0.12670958f, -0.04592499f, 0.02539157f, 0.06208773f, 
    0.14054261f, -0.01701920f, 0.09359002f, 0.07558173f, 0.08926717f, -0.07750883f, 0.02204206f, -0.25557131f, 
    -0.14519216f, 0.23947220f, -0.08190820f, 0.19904141f, 0.01256473f, -0.07011689f, 0.00110556f, 0.03565223f, 
    -0.14897147f, 0.03101304f, -0.01335663f, 0.04004044f, -0.09733763f, 0.06897980f, -0.15045314f, 0.12081939f, 
    -0.02063259f, -0.08221912f, 0.09461664f, 0.09899693f, -0.07379170f, 0.03843851f, 0.05045978f, -0.06229311f, 
    -0.17246237f, -0.11760363f, -0.09452882f, 0.18641998f, 0.01950692f, 0.01032241f, 0.10825019f, 0.03858823f, 
    -0.00310680f, 0.12536499f, 0.12309369f, 0.06405087f, -0.13013990f, -0.08298811f, -0.15884063f, 0.04469364f, 
    0.01794749f, -0.01477406f, 0.05336864f, -0.06797574f, 0.11260749f, 0.06205714f, 0.03201850f, 0.08724959f, 
    -0.17046112f, 0.11181334f, 0.17254426f, 0.11466409f, -0.04746421f, 0.01078998f, -0.03229228f, -0.03068855f, 
    0.12631117f, -0.00525957f, -0.02049714f, -0.19207722f, 0.19527483f, 0.13262704f, -0.03657010f, -0.09101287f, 
    0.19762297f, -0.11220049f, 0.08459225f, 0.11536933f, 0.03181781f, 0.00122081f, -0.07206327f, 0.10788295f, 
    0.05304782f, 0.09296176f, 0.05832958f, -0.03319544f, -0.08170567f, -0.03043874f, -0.04833541f, -0.12621367f, 
    0.12647444f, 0.05388777f, 0.08168378f, 0.06987258f, -0.05632997f, 0.13420963f, -0.11464189f, 0.16772790f, 
    -0.00390651f, 0.09939060f, 0.07007863f, 0.14072300f, -0.06721324f, -0.02499732f, -0.07708341f, -0.15317674f, 
    0.14574490f, -0.02008661f, 0.06231387f, -0.04004860f, -0.03615921f, -0.01946413f, -0.09704506f, -0.05842049f, 
    0.00785202f, -0.00838337f, 0.04382807f, 0.01218019f, -0.00138636f, -0.04083892f, -0.20564511f, -0.09711198f, 
    0.15836969f, 0.04096898f, 0.14891633f, 0.08012514f, 0.12109299f, 0.12897944f, -0.01031710f, 0.13709874f, 
    -0.13638300f, -0.20740150f, 0.09090474f, 0.01514065f, -0.00121812f, 0.06192276f, 0.07034765f, 0.08648455f, 
    0.00406137f, -0.09938502f, 0.08120193f, -0.12440892f, 0.27846590f, -0.03352054f, -0.02097580f, 0.04028226f, 
    0.25002000f, 0.03488274f, 0.06916352f, -0.06057236f, 0.07714628f, -0.02297841f, -0.03174173f, -0.05710750f, 
    0.22515947f, -0.33023378f, -0.14763063f, 0.05104608f, 0.00873402f, 0.03784400f, 0.14988989f, 0.01803078f, 
    0.05030464f, 0.10196488f, -0.08967529f, -0.09586732f, 0.08055247f, -0.08997374f, -0.14915368f, -0.16627876f, 
    0.15592948f, 0.10884543f, 0.12763569f, 0.04170034f, -0.02017495f, -0.06971245f, -0.03442485f, -0.02099114f, 
    0.40217492f, 0.01437706f, -0.05345134f, -0.22074595f, 0.14492810f, 0.09526373f, 0.13407613f, -0.02088170f, 
    0.08518978f, -0.10315117f, -0.06169569f, 0.04184040f, 0.01218963f, -0.01951776f, -0.04029705f, -0.10946853f, 
    0.06683076f, 0.09423443f, 0.00732486f, 0.12074040f, 0.05201090f, -0.03219053f, -0.02300526f, -0.06269456f, 
    0.02563465f, -0.03093151f, 0.00325683f, -0.07111678f, 0.07285320f, 0.01418469f, 0.01749302f, -0.00891897f, 
    -0.08899670f, 0.16611892f, 0.11667663f, 0.05453654f, -0.07051574f, -0.05721983f, 0.10449985f, 0.26305148f, 
    -0.04176562f, -0.04706674f, -0.09809030f, -0.05726924f, -0.10047700f, -0.01428902f, 0.05803223f, 0.08488186f, 
    -0.05499275f, 0.09454288f, 0.01682422f, -0.00922852f, -0.01991966f, -0.00052526f, -0.02530201f, -0.03501694f, 
    -0.05744284f, -0.03295523f, 0.01834940f, 0.01639755f, 0.16596131f, 0.16510689f, 0.01727516f, -0.05763655f, 
    -0.00851962f, 0.02691927f, -0.05313245f, -0.10516522f, 0.08609813f, 0.01409394f, 0.02884367f, 0.13907917f, 
    -0.17173031f, 0.04130256f, 0.06630010f, -0.07835655f, -0.03721570f, -0.02962009f, -0.02335407f, 0.01430982f, 
    -0.06105025f, -0.01659405f, -0.07572975f, -0.07959495f, 0.29346469f, 0.19484363f, 0.04393778f, -0.24037145f, 
    0.12315778f, -0.06383527f, 0.13510130f, -0.19814882f, 0.02403991f, 0.10367574f, -0.05099216f, -0.00839028f, 
    -0.27318433f, -0.03345407f, 0.01918946f, -0.06426573f, 0.34711662f, -0.01837781f, 0.08305872f, -0.06395460f, 
    0.13200928f, 0.06385966f, 0.04720413f, 0.05271739f, 0.12973386f, 0.00073418f, 0.04351738f, -0.08223382f, 
    0.00454079f, 0.13879219f, -0.14758161f, -0.08449640f, 0.20222962f, 0.08700190f, 0.16916268f, 0.20395365f, 
    -0.00962151f, -0.07802797f, -0.09783668f, 0.17517555f, 0.01706703f, 0.00012372f, 0.04705630f, -0.02016243f, 
    0.05641310f, 0.15032089f, 0.05352560f, 0.11740214f, 0.00700466f, -0.38617486f, -0.19617909f, -0.25656509f, 
    0.09943537f, -0.01504318f, 0.01060074f, 0.07109497f, 0.17291810f, -0.06956980f, 0.00557621f, -0.00309253f, 
    0.12072941f, 0.13833222f, 0.10736635f, 0.04948708f, -0.05331730f, -0.04528294f, 0.04218638f, 0.05725316f, 
    0.02690145f, 0.02318099f, -0.07087900f, 0.05197978f, 0.15183072f, -0.15059742f, -0.08721119f, -0.06278223f, 
    0.07824410f, 0.12387386f, 0.03568416f, 0.06230325f, -0.10847138f, -0.00391200f, -0.01561565f, -0.12602066f, 
    -0.04653436f, -0.07336607f, -0.08862726f, -0.14031878f, 0.17785805f, 0.08901830f, 0.02465737f, 0.02189118f, 
    -0.05868090f, 0.11455740f, 0.00207988f, 0.14194606f, 0.15750799f, 0.00371373f, 0.06027729f, 0.04367835f, 
    0.04247794f, 0.05038572f, 0.07373334f, -0.08770812f, 0.00107369f, -0.03293110f, 0.00316006f, -0.00014390f, 
    -0.11698046f, 0.00048064f, 0.02336838f, -0.15741424f, 0.10274673f, 0.07696752f, 0.04601228f, 0.06304168f, 
    -0.04186806f, 0.01375530f, -0.02162752f, -0.06078987f, -0.01882611f, 0.04364181f, -0.07703537f, -0.05203037f, 
    -0.09420913f, -0.17905562f, 0.15572764f, 0.16079938f, -0.12768015f, -0.11193041f, 0.02381679f, -0.05059708f, 
    0.23035538f, 0.04349656f, -0.05029236f, -0.08573690f, 0.03955340f, -0.17168355f, 0.04677375f, -0.18093678f, 
    -0.04173712f, 0.03999470f, 0.02353480f, -0.06792492f, -0.12942928f, 0.06201574f, 0.08793673f, 0.19859721f, 
    -0.00691935f, 0.00435380f, 0.04579997f, 0.10646790f, -0.18587066f, 0.19750689f, -0.02761503f, -0.09290211f, 
    0.06708002f, 0.21685022f, 0.12422093f, -0.14557751f, -0.06404443f, 0.07449003f, 0.18169737f, 0.12185872f, 
    0.00949205f, 0.02467412f, -0.03902655f, 0.04072264f, 0.08864819f, -0.08744514f, -0.04589304f, -0.23259887f, 
    0.03131894f, 0.09406792f, 0.08543751f, -0.00536702f, -0.10090949f, 0.05693544f, 0.15069199f, -0.04920295f, 
    -0.00989328f, -0.12883383f, -0.02757589f, -0.11694817f, 0.02812035f, -0.01294590f, 0.12670282f, 0.16072790f, 
    -0.12188119f, -0.12360755f, -0.05543992f, 0.02536031f, 0.02572029f, -0.02009419f, -0.24920319f, 0.17523168f, 
    0.06866124f, 0.08478685f, 0.10736464f, 0.21108438f, -0.08102055f, -0.04366735f, 0.00710933f, 0.04883610f, 
    0.08019523f, 0.15617892f, -0.02931444f, -0.23557679f, -0.08322588f, -0.06539332f, -0.01196274f, -0.11848176f, 
    0.06933470f, 0.12669732f, 0.13705190f, 0.00345486f, 0.13230346f, 0.01670337f, 0.07839882f, -0.02583890f, 
    -0.03669521f, 0.01458018f, -0.03928655f, 0.02492397f, 0.02407727f, -0.00341721f, -0.17177567f, -0.10309635f, 
    0.08983441f, -0.03551845f, -0.10966128f, -0.14817065f, 0.04933395f, 0.13108417f, -0.01578449f, 0.17664178f, 
    0.13073139f, 0.00831105f, -0.03264669f, -0.04066607f, 0.07401851f, -0.07879492f, -0.05606649f, 0.11873895f, 
    0.08011744f, 0.04834433f, 0.08005908f, 0.14240807f, -0.00656402f, 0.11159804f, 0.09386532f, 0.00134926f, 
    0.06795438f, 0.07224167f, -0.04002763f, -0.02020193f, 0.19211496f, 0.13791105f, 0.13974144f, 0.03888932f, 
    -0.02282423f, -0.00047751f, 0.02708116f, -0.00334759f, -0.03919410f, -0.13678117f, -0.07673840f, -0.14099675f, 
    -0.07540352f, 0.00551167f, -0.03368128f, -0.17163062f, 0.11390156f, 0.11688083f, 0.28539926f, 0.15644930f, 
    0.00785303f, 0.06717286f, -0.04239317f, 0.28885645f, 0.00327572f, -0.08257064f, -0.02079775f, -0.02061531f, 
    -0.01693702f, -0.04350375f, 0.04484126f, 0.10086016f, -0.02140284f, -0.05494876f, -0.04528255f, -0.09272011f, 
    -0.09903011f, 0.07068410f, -0.02165408f, -0.03582835f, 0.05540044f, 0.12313184f, 0.06960919f, 0.12416458f, 
    -0.04081002f, 0.06970988f, -0.06430881f, 0.02471698f, -0.01010580f, 0.04138765f, 0.20461287f, 0.04320231f, 
    -0.05606667f, -0.01813179f, 0.02348188f, 0.02509387f, 0.02563928f, -0.04357393f, -0.17688693f, 0.02626752f, 
    0.05888805f, -0.01851003f, -0.05324697f, 0.18746060f, -0.10193070f, -0.01110799f, 0.16948982f, -0.17189033f, 
    0.18335421f, 0.20839524f, 0.03886808f, -0.26591638f, 0.12145994f, 0.01151779f, 0.14694649f, 0.03025346f, 
    0.15475662f, -0.13719970f, -0.04366724f, -0.06314199f, 0.06754137f, 0.12364618f, 0.01756734f, 0.06135052f, 
    0.01403785f, 0.10543817f, 0.09125302f, 0.05638903f, -0.02160442f, 0.03030930f, 0.00930277f, -0.00210075f, 
    0.00787063f, 0.21846253f, -0.04109996f, -0.04135749f, 0.01856561f, -0.01531510f, -0.00954623f, -0.01004718f, 
    -0.02382786f, 0.04118497f, 0.07138857f, -0.01494749f, -0.13270094f, -0.14206535f, -0.37745374f, -0.23359269f, 
    0.01735633f, 0.07526001f, -0.07324373f, -0.00934244f, 0.12633897f, 0.04179097f, 0.00548764f, 0.02866767f, 
    -0.14968099f, -0.16013210f, 0.22885492f, 0.08841116f, 0.01475077f, -0.03552601f, -0.00881542f, 0.23343642f, 
    -0.00783604f, -0.09490980f, -0.02205329f, -0.13270317f, -0.02676720f, -0.00131067f, -0.32762250f, -0.29692274f, 
    0.14736468f, 0.22907965f, 0.04809973f, 0.13302270f, -0.04230755f, -0.05881927f, -0.01495058f, 0.04585054f, 
    0.09295421f, -0.04498730f, 0.01186118f, -0.00066041f, 0.02512515f, 0.08389957f, 0.03673234f, 0.06801991f, 
    0.10060009f, 0.00031966f, -0.02528715f, 0.16524120f, -0.17996216f, 0.08554564f, -0.00260205f, 0.06421050f, 
    0.06805748f, -0.01404187f, 0.01005517f, -0.12783334f, 0.04722906f, 0.00053065f, 0.00251343f, 0.08094925f, 
    0.10430863f, 0.03797736f, -0.08207242f, 0.11760228f, -0.05038359f, 0.00965382f, -0.00115317f, -0.09204125f, 
    -0.05347361f, -0.02739965f, -0.02745631f, 0.02702355f, 0.01055124f, -0.00345869f, 0.13240787f, -0.02741230f, 
    -0.03043935f, -0.04077504f, 0.01077355f, 0.03631162f, -0.13020404f, -0.06637656f, 0.01538874f, -0.14676420f, 
    -0.19443269f, 0.04562858f, -0.08249719f, 0.07539476f, 0.00785596f, -0.01161424f, 0.15581334f, 0.11073415f, 
    -0.03395662f, 0.04510367f, 0.05038745f, 0.15259533f, 0.23301570f, 0.17742556f, 0.02498123f, -0.22090071f, 
    0.04174337f, 0.12944609f, 0.11063797f, 0.13756195f, 0.12804024f, -0.06999751f, 0.01231268f, -0.03156700f, 
    -0.17686205f, 0.11303422f, -0.17583671f, 0.03354000f, 0.15236288f, -0.03664641f, -0.12964320f, -0.07691468f, 
    -0.06128913f, 0.09266675f, -0.05892595f, 0.09451963f, -0.12173924f, -0.20408930f, -0.28652260f, 0.13582657f, 
    -0.05854031f, 0.12927946f, 0.09747178f, -0.01934956f, 0.11265376f, 0.00528818f, 0.00343605f, 0.04567180f, 
    0.07650736f, -0.08609351f, 0.08314867f, 0.03465675f, -0.05501799f, -0.04987190f, 0.06041994f, 0.01331398f, 
    0.04409020f, -0.01962392f, -0.03248452f, 0.01949353f, 0.20246889f, -0.21837400f, 0.17827919f, 0.08854152f, 
    0.04080122f, 0.03821537f, -0.14008316f, 0.00057488f, -0.01911394f, 0.08249274f, -0.04413972f, 0.09498964f, 
    0.02172530f, 0.33398768f, -0.11028621f, 0.14716996f, -0.01126692f, 0.01539607f, -0.01191321f, -0.00176813f, 
    0.02988054f, -0.01702753f, 0.02119353f, 0.07748438f, -0.03719604f, 0.05343651f, 0.09280246f, -0.02268167f, 
    0.07521553f, 0.16648905f, -0.09138053f, 0.14571428f, 0.24925721f, 0.06770581f, 0.07891928f, 0.03546023f, 
    0.00244897f, 0.04978486f, -0.31236532f, 0.01721564f, 0.15995255f, 0.00130195f, -0.01056376f, 0.04915943f, 
    0.07308113f, 0.11368243f, -0.02834829f, 0.10952605f, -0.02681023f, 0.13095498f, 0.00802423f, -0.07206023f, 
    0.03058313f, 0.02315345f, 0.05708621f, -0.06472931f, 0.00369076f, 0.00757880f, 0.05001562f, 0.07893800f, 
    0.01990063f, 0.08078033f, 0.11560053f, 0.00711465f, 0.01723282f, -0.02088899f, -0.03546024f, -0.03455582f, 
    0.10444058f, 0.15079086f, 0.04437519f, 0.05380132f, -0.03490621f, -0.25663117f, 0.11495144f, -0.03102730f, 
    0.12138397f, -0.12327547f, 0.25178242f, 0.09662290f, -0.01971021f, -0.02604466f, 0.04517977f, 0.02277449f, 
    0.20504308f, 0.10331831f, 0.05340002f, 0.06643566f, 0.01947327f, 0.02098028f, -0.02369052f, -0.01162942f, 
    -0.00467357f, -0.04577902f, 0.09177496f, 0.02878935f, -0.06533366f, 0.16200639f, -0.19891393f, -0.12004568f, 
    -0.10256286f, -0.02095824f, 0.03551243f, -0.01692824f, 0.12183043f, -0.00621905f, 0.11661369f, 0.03399077f, 
    0.18923879f, -0.03345378f, -0.17596328f, 0.03488607f, 0.05065770f, 0.01767979f, 0.05175945f, -0.00333947f, 
    -0.04027140f, -0.05697423f, 0.00908832f, 0.00157591f, -0.25509903f, 0.21418941f, 0.03903699f, 0.08191487f, 
    -0.01191352f, -0.00686392f, 0.02889019f, -0.12483863f, 0.08950283f, -0.00606974f, 0.05594103f, -0.13229585f, 
    -0.03620031f, 0.17364891f, -0.03700548f, 0.16377854f, 0.05672911f, -0.08057178f, 0.06516640f, 0.01613959f, 
    0.12319049f, 0.05121730f, 0.08323989f, 0.03635600f, -0.13044707f, -0.01130021f, 0.12936403f, 0.15999725f, 
    0.04301681f, 0.00736303f, 0.02859479f, -0.02026976f, -0.04525480f, -0.03027877f, 0.05077996f, -0.04301077f, 
    0.06382136f, 0.17784393f, 0.00770594f, -0.21979672f, 0.11183605f, 0.04342284f, 0.06514094f, -0.04949218f, 
    0.09840153f, -0.12846455f, 0.30356252f, 0.23693863f, 0.08827641f, -0.24074335f, 0.29905978f, 0.10960231f, 
    -0.05318012f, -0.06475005f, 0.00932755f, 0.11609497f, 0.13309215f, -0.04410335f, 0.08240240f, 0.08519699f, 
    -0.09935440f, -0.09080184f, 0.21337378f, 0.25084448f, 0.00913174f, -0.16583452f, -0.22406416f, -0.14726955f, 
    0.07377695f, -0.06609457f, 0.04046409f, 0.01633899f, -0.03012328f, 0.06421673f, 0.03792214f, 0.17799534f, 
    0.07436319f, -0.00766733f, -0.03471398f, 0.06819276f, 0.00315449f, -0.01420591f, 0.04242250f, -0.03352902f, 
    0.03599054f, -0.07233533f, -0.10225992f, 0.07435257f, 0.10117896f, -0.02287820f, 0.02230219f, 0.01537844f, 
    0.06445836f, -0.00032066f, -0.13944118f, 0.03738998f, 0.30930814f, 0.02934443f, 0.14658342f, 0.10378723f, 
    0.04130704f, 0.04626285f, -0.00261330f, 0.06188502f, 0.08230497f, -0.00509108f, -0.05455410f, 0.07128722f, 
    0.04232266f, 0.10699888f, 0.14797585f, 0.17770988f, 0.00753447f, 0.01117574f, -0.01238893f, -0.01899192f, 
    0.12296753f, -0.04332707f, 0.05248393f, 0.12571557f, -0.17312257f, 0.17304073f, -0.28698888f, 0.13479330f, 
    0.19015989f, -0.02363114f, 0.10548741f, -0.10518092f, 0.01418902f, 0.00700728f, 0.01908524f, -0.11801216f, 
    0.09947229f, 0.08975177f, 0.04117754f, -0.05302016f, 0.07312508f, -0.01034929f, 0.11787803f, 0.06303213f, 
    0.05110922f, 0.01744657f, 0.09901915f, -0.02644205f, 0.46734869f, -0.06597278f, 0.47340226f, -0.43101951f, 
    0.04898158f, -0.11889483f, 0.05318980f, -0.09066756f, 0.09908678f, 0.05985754f, -0.12447871f, -0.01970900f, 
    0.22137314f, -0.06971058f, 0.00485413f, -0.08555382f, 0.05291033f, -0.06111346f, 0.22642179f, -0.33091736f, 
    0.15740404f, -0.02877723f, 0.01536804f, 0.01054808f, 0.36983743f, -0.08290607f, -0.07574346f, -0.03904685f, 
    -0.01076100f, -0.01648609f, -0.00462329f, 0.01562518f, 0.07223585f, 0.03444438f, 0.12715240f, -0.05283590f, 
    -0.04746877f, 0.05887087f, -0.12782964f, 0.11102587f, 0.28025690f, 0.10035349f, -0.25974858f, 0.05054525f, 
    -0.00631719f, 0.12115503f, -0.01643793f, 0.02465587f, 0.37847638f, -0.15800267f, -0.00732481f, 0.13161843f, 
    -0.02623132f, -0.01545854f, -0.01145195f, -0.06594995f, 0.00226099f, 0.02041556f, 0.01820121f, 0.16055357f, 
    -0.12952885f, -0.11775646f, 0.13772734f, 0.22429523f, 0.09636942f, 0.00276010f, 0.03013343f, 0.07896067f, 
    -0.00128473f, 0.00038225f, 0.02507851f, -0.04132557f, 0.18568592f, 0.05195634f, 0.38130021f, -0.13005838f, 
    0.00570782f, 0.14076458f, 0.00518981f, -0.17193304f, 0.11660657f, 0.04784382f, 0.04638575f, -0.00203213f, 
    0.06392778f, -0.06780209f, -0.02104328f, 0.01968462f, -0.02207123f, 0.09157410f, 0.00957468f, 0.02517254f, 
    0.04541967f, -0.04949854f, 0.02894741f, -0.03355528f, 0.03893822f, -0.04020582f, 0.10295165f, -0.04205749f, 
    0.05372199f, -0.00998082f, 0.07886498f, 0.07428896f, -0.01277945f, 0.01959270f, -0.03030714f, 0.02303412f, 
    -0.12501954f, 0.13894904f, -0.29435468f, 0.16012393f, -0.08559598f, -0.03030939f, -0.04189378f, -0.04799388f, 
    -0.09033163f, -0.05569877f, 0.01830460f, 0.18567240f, -0.14299893f, 0.09969964f, 0.05689576f, 0.08285601f, 
    -0.04038781f, 0.14615861f, -0.10788742f, -0.00430288f, 0.15653746f, 0.22462329f, -0.02629817f, 0.05942670f, 
    -0.18326630f, -0.19889417f, 0.05664145f, 0.00558895f, 0.01202256f, -0.02428910f, -0.09612399f, -0.10778512f, 
    0.16673653f, 0.07862183f, -0.10406142f, 0.07376520f, -0.04415518f, 0.13000709f, -0.07628800f, 0.02051752f, 
    0.01233627f, -0.03336137f, 0.05905101f, -0.02955985f, 0.03424985f, 0.08135005f, 0.01469806f, 0.01230741f, 
    -0.19042395f, -0.07638774f, 0.38599974f, -0.06811252f, 0.10864821f, -0.09215207f, -0.16301648f, 0.11965042f, 
    -0.02957870f, 0.03198207f, 0.12481938f, -0.03338852f, 0.29156414f, -0.37348118f, -0.13650295f, 0.06877678f, 
    0.05239188f, -0.08306765f, 0.00683827f, 0.10289605f, 0.13748613f, -0.06243230f, -0.01609040f, 0.09307668f, 
    -0.03016085f, 0.02300921f, 0.09836717f, 0.07032544f, 0.07280855f, 0.02033624f, -0.17166711f, -0.09945825f, 
    -0.01843347f, 0.05408449f, 0.06513456f, 0.01693250f, -0.44346341f, 0.53005564f, -0.15183750f, -0.07379241f, 
    0.09123886f, -0.28119418f, 0.06433529f, -0.11188725f, -0.05206210f, -0.01512720f, -0.01968325f, 0.01388920f, 
    -0.05622222f, -0.22220887f, 0.22438502f, 0.15348567f, -0.06121536f, -0.01206706f, -0.09160011f, 0.01345878f, 
    -0.00612621f, -0.03967694f, -0.01596252f, 0.03895595f, 0.12934163f, 0.00474352f, -0.03167911f, 0.02279113f, 
    0.00705147f, 0.01149053f, -0.06503353f, -0.04110572f, 0.03285860f, 0.04575561f, 0.05159131f, -0.05425204f, 
    -0.10009815f, 0.10235673f, -0.25439578f, 0.16832067f, 0.09048203f, 0.10471766f, -0.05800858f, -0.09587812f, 
    0.05214431f, 0.08423156f, 0.03505664f, -0.11202633f, 0.31273109f, 0.16630462f, -0.41608945f, -0.07484857f, 
    0.11492496f, 0.12280660f, 0.08628463f, -0.09765904f, 0.08518165f, 0.01618539f, -0.05218715f, 0.00739075f, 
    -0.12467443f, 0.19153602f, 0.29432783f, 0.05892982f, -0.02094284f, 0.01091330f, 0.09639260f, 0.09343753f, 
    0.01959551f, 0.00780710f, 0.02742452f, 0.02264052f, 0.13812563f, -0.17660199f, 0.08740258f, 0.01235411f, 
    -0.00960946f, 0.08847276f, -0.05128458f, 0.01265325f, -0.07238527f, 0.00594399f, -0.10377982f, 0.00598851f, 
    0.03063599f, 0.19877745f, -0.14152953f, -0.05965810f, 0.13766555f, -0.06981149f, -0.08455507f, 0.14387853f, 
    0.05790406f, 0.08745494f, -0.01053241f, -0.00892308f, 0.04599134f, -0.00398911f, -0.06242929f, 0.08227780f, 
    0.03152335f, 0.00163874f, 0.02418690f, 0.07186822f, -0.01340322f, -0.05670770f, -0.07273309f, 0.01156855f, 
    -0.05189612f, -0.03215755f, -0.14248498f, 0.29456997f, 0.07300615f, 0.00096265f, 0.00181580f, 0.07880916f, 
    0.04977364f, -0.09860369f, 0.09480501f, 0.04484341f, -0.16492917f, 0.00339060f, 0.01643760f, -0.04307180f, 
    0.17257598f, -0.04636716f, -0.00544353f, 0.12432250f, 0.22401303f, 0.09753592f, -0.03304785f, 0.01619950f, 
    0.20075715f, -0.28371203f, 0.08482388f, 0.10459944f, 0.00100694f, -0.05586219f, -0.12936288f, 0.09806591f, 
    0.12941112f, 0.08313261f, -0.20795569f, 0.16044064f, 0.24174772f, 0.09742042f, 0.25111890f, -0.35438186f, 
    -0.05161875f, 0.02651419f, -0.19471952f, 0.00190374f, 0.10133208f, 0.02888279f, -0.03052604f, 0.03665654f, 
    0.06275374f, 0.01720022f, 0.21599390f, 0.05386505f, 0.09908634f, -0.00103134f, 0.01109018f, -0.03717966f, 
    0.19174641f, -0.02093405f, 0.00484841f, 0.09711298f, 0.23061472f, -0.07660901f, -0.11496619f, 0.18042257f, 
    -0.06102850f, -0.05092890f, -0.00556060f, -0.05148789f, 0.02318933f, -0.06813615f, 0.08152133f, 0.15137957f, 
    -0.06052497f, -0.00399202f, -0.20422164f, 0.17379929f, 0.07626715f, -0.00803191f, 0.07265447f, -0.07607888f, 
    0.02307478f, 0.13945110f, 0.04966886f, 0.11506455f, -0.12012190f, 0.17478602f, -0.02494479f, 0.12238868f, 
    -0.20896545f, -0.08466110f, -0.14017786f, 0.11354121f, 0.13950071f, -0.00265776f, 0.06735178f, 0.13369878f, 
    -0.14188091f, 0.01960433f, 0.06063060f, 0.19326489f, 0.12344528f, 0.01254735f, -0.08231346f, -0.08920795f, 
    0.06046991f, 0.03665230f, 0.08134986f, 0.08195275f, -0.03795692f, 0.05939504f, 0.09959583f, 0.06819277f, 
    0.20936382f, -0.02918454f, 0.05027905f, -0.01678189f, 0.01597811f, -0.02893628f, 0.02548581f, -0.03465173f, 
    0.14113431f, 0.14179908f, -0.00344228f, -0.13454787f, 0.02738808f, 0.02984778f, 0.03925895f, 0.12916090f, 
    -0.02619745f, -0.07605164f, 0.06647886f, -0.07449461f, -0.00796229f, -0.21477327f, 0.04626251f, 0.15154985f, 
    0.10607878f, 0.00817141f, -0.15119612f, -0.27158040f, -0.02727116f, -0.03676917f, -0.05628301f, 0.21514338f, 
    0.02244226f, -0.00828284f, -0.13717711f, 0.01866843f, 0.13990827f, 0.09987129f, 0.03759030f, 0.00799251f, 
    0.08128322f, -0.02459591f, 0.03076047f, 0.07998396f, 0.09584012f, -0.09419671f, 0.24274094f, 0.01958757f, 
    -0.04347041f, -0.18812586f, -0.05247536f, 0.00123607f, -0.03093466f, 0.02644615f, -0.06470975f, 0.01935837f, 
    -0.02791666f, -0.02845376f, 0.00902470f, 0.02507359f, -0.03514698f, 0.01600696f, -0.01200526f, -0.01572367f, 
    0.00885435f, -0.02310387f, 0.02897687f, 0.00069996f, 0.02068766f, 0.03559985f, 0.03212530f, -0.00009459f, 
    0.02879307f, 0.01404206f, 0.00097246f, 0.02348435f, -0.03696515f, 0.00189671f, -0.01461941f, 0.00288651f, 
    -0.02951840f, -0.01573968f, -0.02020353f, 0.00341026f, 0.02066637f, 0.02283779f, -0.03153642f, 0.02403747f, 
    -0.01132030f, 0.02603590f, 0.01284254f, -0.00735288f, -0.03279927f, 0.01263576f, -0.01684839f, 0.03102738f, 
    0.03468812f, -0.03860288f, -0.01248220f, -0.01149504f, 0.00992486f, 0.00086443f, -0.02115823f, 0.00891413f, 
    -0.02528480f, 0.01504167f, 0.00854711f, -0.01594872f, -0.00465369f, -0.03407771f, 0.01796071f, 0.02354649f, 
    -0.03953835f, -0.04184667f, -0.03074176f, -0.00238391f, -0.02919919f, 0.00281395f, -0.00259722f, -0.01535297f, 
    0.00403933f, -0.00281246f, -0.01866812f, 0.01597388f, -0.01765796f, 0.01028115f, -0.02877409f, 0.01093486f, 
    -0.00723551f, -0.00878882f, -0.02191309f, 0.02230741f, -0.00150504f, -0.02791386f, -0.02823023f, -0.03958027f, 
    0.00476102f, 0.00699245f, -0.03501038f, -0.02704412f, -0.01170708f, -0.01244617f, 0.00554089f, -0.03911497f, 
    -0.01633602f, -0.02063021f, -0.01444166f, 0.00411888f, -0.01442775f, 0.01309585f, -0.00334865f, -0.00849566f, 
    -0.01292424f, 0.01479739f, -0.02859959f, 0.01242718f, -0.02856272f, -0.00400787f, -0.01441682f, -0.03027232f, 
    0.02120615f, -0.03650213f, -0.00774735f, 0.01672289f, -0.02986615f, 0.01353118f, -0.00255642f, 0.00410767f, 
    0.02109195f, -0.00365386f, -0.00353505f, -0.04009024f, -0.02227019f, -0.02198591f, -0.00250495f, -0.00551000f, 
    -0.02888012f, -0.00561032f, 0.00518766f, -0.03331912f, -0.03521592f, 0.02774622f, 0.00823558f, -0.03919173f, 
    0.02424970f, -0.00103880f, 0.00296601f, 0.00718678f, -0.00996121f, -0.02627399f, -0.00417014f, 0.03107462f, 
    0.00874855f, -0.01948627f, 0.02752352f, -0.02705335f, -0.01727363f, -0.00587208f, -0.00426203f, 0.00318772f, 
    -0.00489289f, -0.03344984f, -0.00500007f, -0.00497037f, -0.03130661f, 0.02401636f, 0.02653690f, -0.01186816f, 
    -0.00139954f, -0.01662884f, -0.03287790f, -0.01213908f, -0.00834916f, 0.01284676f, 0.02291793f, 0.00864430f, 
    0.01424917f, -0.00642618f, 0.00932839f, -0.02298117f, -0.02470786f, -0.00846087f, -0.00687072f, 0.01837987f, 
    -0.02327104f, -0.04158147f, -0.02911564f, 0.01494606f, 0.01355144f, 0.01019543f, -0.00944204f, 0.00339424f, 
    -0.02319039f, -0.02935214f, 0.02199088f, 0.02451096f, 0.00822012f, 0.03298251f, 0.02730195f, 0.01841141f, 
    0.00503861f, -0.01619056f, -0.03705470f, 0.00820487f, 0.03349233f, 0.03666371f, -0.00388883f, 0.00786470f, 
    -0.01708996f, -0.00435417f, -0.03863088f, 0.02003805f, 0.02599780f, -0.03011151f, 0.01429659f, 0.00617596f, 
    -0.02840117f, -0.02558191f, 0.00198325f, 0.01086526f, -0.03930987f, 0.02398169f, 0.02841718f, -0.01827974f, 
    0.01821313f, -0.02906043f, -0.03205561f, 0.02575556f, -0.03463154f, 0.03360885f, -0.01940366f, -0.03432795f, 
    0.01720803f, 0.00584188f, -0.00633463f, 0.02052295f, -0.02393246f, -0.02586913f, 0.00237277f, -0.01545389f, 
    0.00048349f, 0.01152515f, 0.01327990f, -0.02406054f, 0.00748872f, 0.01380800f, 0.03092479f, -0.03571096f, 
    -0.01933258f, -0.01285111f, 0.01037564f, -0.02714266f, -0.03555055f, 0.02913592f, -0.00337136f, 0.01990455f, 
    -0.00741513f, 0.02697245f, -0.02166129f, -0.02111849f, -0.02706623f, -0.03154455f, 0.00071994f, 0.00592507f, 
    -0.04458220f, -0.01215819f, -0.02744977f, 0.01931272f, -0.02436627f, 0.02123522f, -0.03785921f, -0.02542367f, 
    0.01071422f, 0.02784598f, -0.02433559f, 0.01577441f, -0.01859148f, 0.01877987f, -0.01525478f, 0.01134442f, 
    0.00524155f, 0.02226695f, 0.02589676f, -0.02722648f, 0.02745934f, 0.02929165f, 0.00362104f, 0.01473811f, 
    -0.02144313f, -0.02273118f, -0.01638028f, -0.04154227f, 0.02197282f, -0.02846366f, 0.00178742f, 0.02460880f, 
    -0.03582251f, -0.03559105f, -0.03227562f, 0.00814084f, 0.00057676f, -0.03110758f, -0.01810101f, 0.03035224f, 
    0.01653668f, 0.01319967f, -0.03658890f, -0.02282925f, 0.00647312f, -0.02397211f, -0.02776245f, -0.00189259f, 
    0.02846126f, -0.00251286f, -0.00427844f, 0.01653094f, 0.02737087f, -0.02051971f, 0.02750498f, -0.00083041f, 
    0.00135833f, -0.01219117f, -0.02330272f, -0.03212821f, -0.01689203f, 0.00352425f, -0.01619031f, -0.03147265f, 
    -0.01848356f, -0.04216706f, 0.02428886f, 0.02293078f, 0.00454216f, 0.02698491f, 0.01580204f, 0.02783187f, 
    -0.01770309f, -0.00308047f, -0.03385103f, -0.00711643f, -0.01898185f, 0.00885475f, -0.00872311f, -0.00181742f, 
    -0.01548985f, 0.01514439f, 0.02173984f, 0.03274032f, 0.00598517f, -0.01878967f, 0.00025896f, 0.00918411f, 
    0.01278501f, -0.03776472f, -0.02053016f, -0.02483591f, -0.00718523f, 0.02067124f, 0.00138613f, 0.00934693f, 
    0.02175675f, -0.02803368f, -0.02322891f, 0.02785413f, -0.03601338f, 0.00934495f, 0.01608810f, -0.00124575f, 
    -0.01118696f, 0.03339072f, -0.02346027f, -0.03122741f, 0.01583583f, 0.02246683f, -0.02662294f, -0.03517742f, 
    0.01383509f, -0.01881745f, -0.02402676f, 0.02177233f, -0.03676419f, 0.02046979f, 0.02831114f, 0.02292442f, 
    -0.02566273f, 0.01646549f, 0.01700175f, 0.00425736f, -0.02802669f, 0.02411156f, 0.01889424f, -0.03809322f, 
    -0.02437751f, -0.03388153f, 0.02437311f, 0.01642490f, 0.00969257f, -0.02463740f, -0.00154246f, 0.00854155f, 
    0.01996265f, 0.03347377f, -0.00668234f, -0.02689235f, -0.01997869f, 0.01615785f, 0.00789963f, -0.00308859f, 
    -0.04300537f, -0.03487458f, -0.01416246f, -0.03347011f, -0.00713551f, -0.04206233f, -0.00098094f, 0.00615235f, 
    0.01238632f, 0.01072352f, 0.02132573f, 0.00152744f, 0.00329538f, 0.01578538f, -0.03007315f, -0.01126057f, 
    -0.04587609f, -0.02215758f, 0.02545214f, -0.01659261f, -0.03014567f, 0.00857555f, 0.00857596f, -0.02968268f, 
    0.02141259f, 0.01904329f, -0.01029705f, -0.02748213f, -0.00434327f, 0.02110851f, 0.03391725f, -0.01189120f, 
    0.00008493f, -0.00522525f, -0.01330432f, -0.02860041f, -0.00674577f, -0.00445533f, -0.01193899f, -0.03744857f, 
    -0.01293805f, -0.03676203f, 0.02953663f, 0.02246965f, -0.03064429f, -0.01703569f, -0.03887268f, -0.04046158f, 
    0.00374750f, 0.00876441f, 0.00077481f, -0.00677819f, -0.01645753f, -0.03725813f, 0.01174215f, 0.01355427f, 
    0.02692721f, 0.01795132f, 0.02706497f, 0.01721898f, -0.01360572f, 0.01304554f, 0.01033595f, -0.03664343f, 
    -0.00371179f, 0.01505678f, 0.01784293f, -0.02150314f, -0.02766836f, -0.03560092f, -0.01267980f, 0.02737430f, 
    0.00696940f, -0.03987930f, -0.02212119f, -0.00947750f, -0.00963378f, 0.02314360f, 0.02603107f, 0.02889565f, 
    -0.01313461f, -0.03212793f, 0.01707901f, 0.01647045f, 0.01381941f, 0.02928453f, 0.01295099f, 0.02826523f, 
    0.01304863f, -0.02554910f, 0.03061156f, -0.00993439f, -0.03491799f, -0.04709299f, -0.03761303f, 0.01682311f, 
    0.02606214f, -0.01063996f, -0.02192974f, -0.02353396f, 0.01122149f, -0.00401771f, -0.03797835f, -0.03580290f, 
    -0.01664888f, -0.02048843f, 0.00173486f, 0.00787929f, -0.02742350f, -0.03385956f, 0.00845138f, -0.02189441f, 
    0.01260835f, 0.00377377f, -0.00743504f, -0.03106500f, -0.02364485f, -0.00884772f, -0.04039783f, -0.01610025f, 
    0.00852409f, 0.01190575f, 0.01058693f, -0.00854777f, 0.00499223f, 0.01974877f, -0.00217263f, -0.01657532f, 
    0.01749432f, -0.00800004f, -0.01097676f, -0.03160165f, 0.02621913f, -0.00458360f, -0.04610906f, 0.01931310f, 
    -0.00338728f, -0.02918558f, 0.01980019f, 0.01788890f, -0.02549143f, 0.01046409f, -0.02708570f, 0.00553090f, 
    -0.04343739f, -0.02591400f, -0.04148171f, 0.01158259f, 0.02327952f, 0.01971428f, 0.02698299f, 0.02517623f, 
    -0.01113249f, -0.03014777f, -0.03048379f, -0.02582134f, 0.01676556f, -0.02855764f, -0.01709396f, 0.01293888f, 
    -0.02013445f, -0.03388883f, 0.00946193f, -0.00072067f, -0.02795976f, -0.01838640f, 0.01708048f, 0.00513174f, 
    -0.02040951f, -0.01429195f, 0.02670630f, -0.02256152f, -0.01509021f, 0.02451752f, -0.00198675f, -0.01428966f, 
    -0.03077596f, 0.00408762f, 0.02210533f, -0.02310398f, 0.02952282f, 0.02159001f, 0.02721341f, 0.02592938f, 
    -0.01216180f, 0.00379104f, 0.00099944f, -0.00693916f, -0.01344169f, -0.00153501f, 0.02131353f, 0.01895150f, 
    0.01324421f, 0.01545971f, 0.02059968f, 0.01629345f, -0.03563455f, -0.01294821f, -0.02284955f, -0.01037128f, 
    0.00713024f, -0.00623041f, -0.03837909f, 0.01778261f, 0.02076197f, 0.00451672f, 0.00261022f, -0.02776922f, 
    -0.01907836f, 0.02451221f, -0.02491710f, 0.00888635f, -0.03271066f, -0.03460812f, 0.03372289f, 0.01894713f, 
    0.01503125f, -0.00807927f, -0.03356648f, 0.01909004f, 0.01188558f, -0.00729920f, 0.02161977f, -0.03350415f, 
    0.02574637f, -0.00454990f, -0.03358514f, -0.02697664f, -0.03454809f, -0.03313322f, -0.01009414f, -0.00726602f, 
    -0.02614818f, -0.02686254f, -0.00287762f, 0.03284959f, 0.01077523f, 0.02248087f, -0.03337510f, -0.03704207f, 
    0.02556898f, -0.00930836f, -0.00920302f, -0.04170426f, -0.01854140f, -0.00505362f, -0.01796902f, 0.01474522f, 
    0.00953842f, 0.00168794f, -0.01556855f, 0.02105334f, -0.02726074f, -0.01737324f, 0.02308042f, 0.02732139f, 
    -0.01582604f, 0.00899192f, -0.02449992f, 0.00662870f, -0.00931165f, 0.00809704f, 0.00240022f, -0.01986539f, 
    -0.02786305f, -0.01625922f, -0.03678775f, 0.02886205f, 0.02043854f, 0.01614255f, 0.01638256f, 0.01887355f, 
    0.02287498f, 0.03232350f, 0.01131907f, 0.02943409f, -0.03875034f, -0.01214209f, 0.00405687f, 0.02111092f, 
    -0.04444055f, 0.02112785f, 0.00343168f, -0.02528041f, -0.02572061f, 0.01833685f, -0.02170817f, 0.00975963f, 
    -0.02716297f, -0.01998407f, -0.03649706f, 0.01790239f, -0.00899405f, -0.00652657f, -0.02969295f, -0.02114600f, 
    0.02750190f, -0.02316385f, -0.03926436f, 0.03477947f, -0.03130229f, -0.00909318f, 0.03609025f, -0.02584321f, 
    -0.00834981f, -0.02187388f, -0.01629364f, -0.04365936f, -0.04149472f, -0.03756331f, 0.03022000f, -0.01573270f, 
    -0.00891964f, -0.03115893f, -0.03043136f, 0.02568338f, -0.02843787f, -0.02399080f, -0.04239835f, -0.01026081f, 
    0.01153179f, -0.00651461f, -0.00261541f, -0.02067678f, 0.00545994f, 0.00253436f, 0.00907145f, -0.00446882f, 
    0.02244057f, -0.01866952f, -0.01756351f, -0.04176016f, -0.03523875f, -0.01199366f, -0.02488850f, 0.02363920f, 
    0.01639247f, -0.00699631f, -0.00647036f, -0.03202327f, -0.04019604f, -0.00952264f, -0.01244418f, 0.01864810f, 
    0.01726121f, 0.00427341f, 0.00472741f, -0.02866606f, -0.01374006f, 0.00364528f, -0.02562474f, 0.00178294f, 
    0.00376248f, -0.02467322f, 0.01248240f, -0.00239383f, -0.02423249f, 0.01441148f, -0.01556156f, 0.01400346f, 
    0.00579373f, -0.01877903f, -0.04079240f, -0.02234605f, -0.03035202f, 0.00059832f, 0.01352259f, -0.03619196f, 
    -0.00421599f, 0.02450543f, -0.02828461f, -0.01836127f, -0.00818485f, -0.01981053f, 0.03245982f, 0.00325987f, 
    -0.05348288f, 0.01698650f, -0.19683222f, -0.13212895f, 0.02345704f, 0.08458073f, 0.06642015f, 0.24466531f, 
    -0.02323657f, 0.06691504f, 0.05713295f, 0.17205372f, 0.04610562f, -0.00335235f, -0.04441453f, -0.13244174f, 
    0.05069396f, -0.07339231f, -0.12696770f, 0.22961827f, -0.04572746f, -0.11583800f, -0.03442230f, 0.03072088f, 
    0.30526114f, 0.16812751f, 0.20692657f, -0.13359931f, 0.22160524f, 0.14557476f, -0.00335047f, 0.21266709f, 
    -0.03891268f, 0.04285379f, 0.05863794f, 0.01184262f, 0.16636296f, 0.19714050f, 0.10387062f, -0.10706281f, 
    -0.08173876f, -0.16154589f, -0.02226566f, 0.06066550f, 0.03314210f, -0.09732027f, -0.19425499f, -0.00180345f, 
    -0.15374342f, -0.25077212f, -0.27734628f, 0.20630358f, 0.03875512f, 0.05920547f, -0.00441223f, -0.07215848f, 
    0.03019148f, 0.07141179f, 0.00805298f, 0.02612792f, -0.09429526f, 0.00285676f, -0.23889229f, 0.08986632f, 
    0.12948568f, -0.05638046f, 0.03874354f, -0.05783309f, 0.01169507f, 0.07575537f, -0.03776260f, 0.04488064f, 
    -0.09039360f, -0.07391331f, 0.08605394f, 0.07666297f, -0.05576955f, 0.03980300f, 0.11537185f, -0.15116772f, 
    0.03357679f, -0.12460922f, 0.13488896f, 0.00042797f, -0.05671957f, -0.11545721f, -0.10460307f, 0.06139037f, 
    0.04547866f, -0.02014320f, -0.04526477f, -0.04683988f, 0.06843308f, -0.17956638f, -0.03950414f, 0.15766655f, 
    -0.08263423f, -0.12534502f, -0.31816235f, 0.13526154f, 0.03186955f, 0.04040457f, 0.02579625f, 0.00834891f, 
    0.10869898f, -0.13118054f, -0.04511541f, -0.02977546f, 0.19479379f, 0.14500597f, 0.10935951f, 0.02926215f, 
    0.15617210f, 0.19666292f, 0.00283146f, 0.06998488f, 0.07254217f, 0.06631475f, 0.01385485f, 0.03460012f, 
    0.04159179f, -0.03965737f, 0.03444504f, 0.00038677f, 0.02425894f, -0.02866834f, -0.01656713f, -0.01017657f, 
    -0.09723818f, -0.13041325f, -0.13400729f, -0.01987057f, 0.22950308f, 0.17245458f, -0.07072777f, 0.28014266f, 
    0.00799236f, 0.01764130f, -0.01689414f, -0.05220271f, -0.06212533f, -0.11060569f, -0.00523990f, -0.02027607f, 
    -0.09714896f, -0.02459939f, 0.12965770f, 0.14185561f, 0.01261945f, -0.00592277f, -0.02269214f, -0.01299498f, 
    -0.00392627f, 0.04888432f, -0.02923022f, 0.02892551f, 0.13018779f, 0.10571308f, -0.09402362f, -0.11766247f, 
    0.16409871f, 0.08746707f, 0.00182889f, -0.15128583f, 0.03482570f, -0.00455075f, -0.05539518f, 0.02507842f, 
    -0.03467122f, 0.04942495f, -0.01900390f, -0.05123368f, 0.12018700f, 0.15885933f, -0.19751805f, 0.13158865f, 
    0.02728991f, -0.02430613f, 0.04493409f, -0.00361719f, 0.16613653f, 0.28123930f, 0.09646869f, 0.00812158f, 
    0.10826602f, 0.21774675f, 0.05471200f, 0.07176959f, -0.02185148f, 0.11961959f, -0.07630320f, 0.04550306f, 
    0.13785751f, -0.27994967f, -0.25830764f, -0.00847251f, 0.13936599f, -0.15069282f, 0.01240364f, 0.11943797f, 
    -0.03137646f, 0.09597534f, -0.23307203f, 0.02340711f, 0.19380829f, 0.21790339f, 0.04302320f, -0.07289998f, 
    0.10128323f, 0.11837687f, 0.03140143f, -0.15348069f, 0.13039726f, -0.03853147f, -0.02485745f, -0.07259087f, 
    0.02542993f, 0.07542612f, 0.20345758f, -0.03479288f, -0.03853169f, 0.17312618f, 0.12833562f, -0.03045492f, 
    0.05365151f, -0.04708346f, -0.13899218f, 0.02097943f, 0.21598884f, 0.32615429f, 0.06698001f, -0.01930837f, 
    -0.01449515f, 0.09933253f, 0.11702465f, -0.06283385f, 0.07410056f, 0.01904518f, 0.01102668f, 0.01324160f, 
    -0.01495008f, 0.04099656f, 0.13958782f, -0.03499106f, -0.21895020f, -0.07861661f, 0.14637257f, -0.06078220f, 
    0.04570302f, 0.07221624f, 0.02679050f, 0.01806750f, 0.02492797f, 0.07317932f, -0.30539933f, 0.10961354f, 
    0.01594009f, 0.00889276f, -0.03896926f, 0.03707791f, 0.09640870f, -0.08092920f, 0.18634978f, -0.01550839f, 
    -0.07133517f, -0.15335757f, -0.02767656f, -0.01050938f, 0.09521218f, 0.05316069f, -0.00051100f, -0.00108507f, 
    0.05772740f, 0.05405939f, 0.02643025f, 0.11360383f, -0.18849643f, 0.00119004f, 0.32453904f, 0.11678847f, 
    -0.04315098f, 0.04477580f, 0.00813338f, 0.01908904f, 0.04886305f, -0.07313448f, -0.03038212f, 0.09245583f, 
    -0.12363364f, -0.11362559f, -0.07036968f, 0.04900802f, 0.05819213f, -0.01904040f, -0.04537807f, -0.00209762f, 
    -0.04760681f, -0.00174479f, -0.03379155f, 0.04558419f, 0.31736416f, -0.27816901f, 0.43068555f, -0.30855542f, 
    -0.02849466f, -0.11805675f, 0.07595382f, 0.09028086f, 0.02837300f, -0.03697705f, 0.01025233f, 0.02544231f, 
    0.06728573f, 0.05001917f, -0.00917609f, -0.08851528f, 0.21148022f, 0.06608305f, -0.15476966f, 0.02535057f, 
    0.07788995f, -0.09246080f, 0.16071551f, -0.07058753f, 0.08543392f, -0.22585416f, 0.15900479f, 0.01910033f, 
    -0.00635104f, 0.00872238f, 0.06614800f, -0.08785266f, 0.05496765f, -0.03217622f, -0.11678480f, 0.02387863f, 
    -0.09859921f, -0.03067098f, 0.13174833f, -0.04035750f, -0.18872115f, -0.02524208f, 0.18387887f, -0.12490486f, 
    0.06268036f, -0.02330100f, -0.01716101f, 0.09930110f, -0.09310116f, -0.00458404f, 0.03990569f, -0.00772746f, 
    -0.00869371f, 0.03602925f, 0.09674469f, 0.10481278f, 0.06868856f, -0.10747214f, -0.03587652f, -0.04186287f, 
    0.23255509f, 0.23983136f, 0.21823564f, 0.02374175f, -0.10374061f, 0.09205070f, 0.08280370f, -0.01521565f, 
    0.03337387f, -0.01294670f, -0.02395125f, 0.04943084f, 0.23754379f, 0.08189047f, -0.01107696f, -0.03929852f, 
    0.02450242f, 0.00092895f, -0.10907213f, 0.09419077f, -0.08167683f, -0.06329590f, -0.04307475f, -0.13807841f, 
    0.02467344f, 0.07535619f, 0.01437921f, 0.01060611f, 0.01516317f, -0.07498742f, 0.00591758f, -0.11601865f, 
    0.07016297f, 0.10785799f, -0.04641097f, 0.00545835f, -0.00435164f, -0.07004398f, -0.05236283f, 0.09794615f, 
    0.05121342f, -0.08570183f, 0.05467830f, 0.01750495f, 0.01992766f, -0.01594727f, -0.01920259f, -0.02031174f, 
    -0.44459814f, -0.05743887f, 0.15039326f, -0.11375537f, 0.03544584f, -0.06669559f, 0.00727061f, 0.19723013f, 
    -0.04562749f, -0.06586343f, -0.08136494f, -0.00588113f, -0.01759998f, 0.02111740f, -0.00822200f, 0.12803543f, 
    -0.09714264f, -0.06279366f, 0.21053010f, -0.00627195f, -0.10169583f, -0.07055296f, 0.07443027f, -0.04894587f, 
    0.02147772f, 0.14583005f, 0.05508164f, -0.13555686f, -0.05131403f, -0.05043635f, 0.12146258f, -0.09075770f, 
    -0.03516282f, -0.12915173f, 0.00556155f, -0.17207904f, -0.08831090f, 0.03970471f, -0.18651922f, 0.10967320f, 
    0.02652037f, -0.04342742f, -0.06053058f, -0.08025239f, -0.03521791f, -0.08315793f, 0.03662629f, -0.02570158f, 
    0.20849347f, 0.20329422f, 0.12878858f, -0.22071932f, -0.11837338f, 0.20183450f, 0.05720657f, 0.07590217f, 
    0.00454094f, -0.01451425f, -0.14404252f, 0.01607609f, 0.08603260f, 0.24528788f, 0.11300603f, -0.11293154f, 
    0.04530879f, -0.00111246f, 0.07068827f, -0.13680936f, 0.17417942f, 0.04432593f, -0.02927883f, -0.00005436f, 
    0.03762406f, 0.05896788f, 0.01953529f, 0.01291719f, -0.03620901f, -0.11704516f, -0.00872044f, 0.21598950f, 
    0.07712399f, 0.07426453f, 0.07953554f, 0.00594448f, -0.16871606f, 0.04706603f, -0.21319313f, -0.07467976f, 
    0.03318585f, 0.04172336f, 0.07218561f, 0.21742451f, 0.05349909f, 0.02305931f, 0.04540798f, 0.03374833f, 
    -0.24673246f, 0.34140903f, 0.07052249f, -0.09491456f, -0.03691929f, 0.02106840f, 0.12707512f, -0.01479625f, 
    0.02009169f, -0.04474199f, -0.24489981f, 0.05156026f, -0.17782906f, 0.00036591f, 0.09362169f, 0.01528495f, 
    -0.02322743f, -0.04204158f, 0.10176268f, 0.02550432f, -0.04092079f, -0.09258015f, -0.03932604f, 0.20659995f, 
    -0.20829029f, 0.00799755f, 0.15291606f, 0.00005986f, -0.03665355f, -0.03495825f, 0.00041608f, 0.04168551f, 
    -0.08931989f, -0.15948196f, -0.00514166f, 0.04903153f, 0.03605847f, -0.14226837f, 0.24182077f, 0.08811841f, 
    -0.01637061f, -0.00270430f, -0.02736876f, 0.07563994f, -0.05634820f, 0.04313789f, -0.07357404f, -0.09012596f, 
    0.21649978f, 0.21150270f, 0.04248847f, -0.02674477f, 0.11829550f, 0.11872736f, 0.12556075f, 0.13383043f, 
    0.01994827f, 0.03714332f, 0.03514650f, 0.05094860f, 0.11715263f, 0.02099241f, 0.07823720f, -0.08975226f, 
    -0.13255891f, 0.04490643f, -0.00983614f, -0.07452092f, 0.10967872f, 0.00117390f, -0.00595429f, 0.00664046f, 
    0.05491198f, -0.09434006f, -0.19984958f, 0.22171840f, 0.08255527f, -0.01233004f, 0.00675962f, 0.00248400f, 
    0.07531136f, -0.07947276f, 0.07982720f, 0.06974770f, 0.04439463f, -0.00543034f, 0.05601306f, 0.02685105f, 
    -0.15559101f, 0.02023768f, 0.02746624f, -0.05791649f, -0.00370237f, 0.00566368f, 0.01342756f, 0.00803591f, 
    -0.05907488f, 0.10058742f, -0.15110864f, 0.13867359f, 0.02089201f, -0.04363804f, -0.18393223f, 0.16463056f, 
    0.02927421f, 0.12430598f, -0.07047398f, 0.03510758f, 0.30512634f, 0.19939288f, 0.04215972f, -0.07427998f, 
    0.03348425f, 0.09634314f, 0.11358851f, -0.01494148f, 0.10625228f, -0.07944139f, 0.07513448f, -0.07536252f, 
    0.21305731f, 0.08242217f, 0.52161849f, -0.01711018f, -0.07718526f, -0.14581829f, 0.02023700f, -0.07558472f, 
    -0.07628060f, -0.12785698f, -0.06196522f, -0.05466089f, 0.34733209f, 0.09710579f, 0.02646827f, -0.14959386f, 
    0.12633669f, 0.14664020f, -0.03162404f, 0.02269044f, 0.00990036f, 0.01608735f, 0.10315434f, -0.01405280f, 
    -0.28816482f, 0.04348551f, -0.11861666f, 0.10290485f, 0.02781838f, 0.03694601f, 0.02072654f, -0.05707260f, 
    0.02486048f, -0.05588657f, 0.11052193f, -0.02597190f, -0.08401122f, -0.07420462f, -0.09442481f, -0.05726366f, 
    -0.02213419f, 0.00133679f, -0.01243591f, 0.08243747f, 0.10706725f, 0.02759815f, -0.08841564f, -0.03763774f, 
    -0.28135288f, 0.09688329f, -0.16105242f, 0.10551835f, 0.01868609f, 0.05958229f, -0.01025651f, 0.04179421f, 
    0.03075171f, -0.01610386f, 0.11329728f, -0.06572179f, -0.09157787f, -0.06743416f, -0.20612849f, -0.25322229f, 
    0.01051329f, 0.08960068f, 0.04011739f, 0.11982846f, 0.00736632f, -0.02429393f, 0.06139056f, -0.08450554f, 
    0.12844574f, 0.17524716f, 0.09796994f, 0.13250040f, 0.09794211f, 0.09152276f, 0.07660331f, 0.18295620f, 
    0.00542701f, -0.02726192f, -0.00596071f, 0.09240089f, -0.06826652f, 0.08523394f, -0.15744440f, 0.21118945f, 
    0.02270515f, 0.09660326f, -0.03505347f, 0.02418604f, 0.05833576f, 0.05818444f, -0.01192887f, 0.01862422f, 
    0.06874111f, -0.12246326f, -0.49587801f, 0.19004719f, 0.02460481f, -0.00560561f, -0.07092305f, 0.04887800f, 
    0.02412921f, 0.01363160f, -0.08324824f, 0.07876814f, -0.21335240f, 0.05708421f, 0.15531644f, 0.00778546f, 
    0.02256859f, 0.01024166f, 0.07693766f, -0.02568037f, -0.06582590f, -0.22920118f, -0.00874163f, 0.03649594f, 
    -0.11516123f, 0.01585016f, -0.08745438f, 0.07077154f, -0.00294670f, -0.01343610f, -0.10422949f, 0.02309743f, 
    0.01736632f, 0.12011356f, -0.04152453f, 0.04854507f, 0.33735353f, 0.34941027f, 0.25200179f, -0.09631119f, 
    -0.04610085f, 0.17719619f, -0.14510395f, 0.12461181f, 0.07328732f, 0.05422081f, -0.01179118f, -0.00548431f, 
    -0.00324133f, -0.00688963f, 0.00440195f, 0.03055515f, -0.01772032f, -0.00500441f, -0.00515023f, -0.04277629f, 
    -0.02366780f, -0.03419347f, -0.03321005f, 0.00401735f, 0.00677201f, 0.02866751f, -0.01965249f, -0.00230490f, 
    -0.01250919f, -0.04073531f, -0.02626488f, 0.01499322f, 0.00751669f, -0.00779229f, 0.01026334f, -0.01068758f, 
    -0.02884624f, 0.00134770f, -0.01324213f, -0.03673778f, 0.00158379f, -0.00945554f, -0.04102828f, -0.01612535f, 
    -0.01463862f, 0.01209018f, 0.02634270f, -0.02689113f, 0.00870772f, 0.01165287f, 0.00214069f, 0.01722601f, 
    -0.01437075f, 0.00400932f, 0.02417064f, 0.00309905f, -0.03252313f, 0.02341592f, -0.00009185f, 0.00866605f, 
    -0.00185374f, -0.01867787f, -0.02479723f, 0.02288044f, -0.00272572f, 0.02423246f, -0.02239114f, 0.01854125f, 
    0.02672593f, 0.02597672f, -0.03733559f, 0.02114613f, -0.04164287f, 0.01199245f, 0.01335564f, 0.01897484f, 
    0.00105607f, 0.02296908f, -0.01466923f, 0.00797706f, -0.00432406f, -0.03276535f, -0.02454052f, -0.01986462f, 
    -0.03215251f, 0.01204194f, -0.01454417f, -0.00746886f, -0.03121720f, -0.03406664f, 0.00785041f, -0.03421659f, 
    -0.02684795f, -0.01563262f, 0.00307798f, -0.03503237f, -0.00779113f, -0.02414186f, -0.02864338f, -0.02105261f, 
    0.01952342f, -0.02698066f, -0.00948803f, 0.00321806f, -0.01481981f, 0.02458981f, -0.02360266f, -0.04009644f, 
    -0.02088757f, -0.00405328f, 0.01077376f, 0.00495307f, -0.00410367f, -0.02876012f, 0.01328118f, -0.03530537f, 
    -0.01184116f, 0.01287029f, 0.02428379f, 0.02207575f, 0.01700405f, -0.02224529f, 0.00472885f, -0.00718692f, 
    -0.03268476f, -0.03808481f, -0.01838152f, -0.00730072f, 0.00583988f, -0.03362547f, 0.00779867f, 0.02152316f, 
    0.00262492f, 0.02432835f, 0.00945180f, -0.01024901f, -0.01117065f, -0.01635715f, 0.01915425f, -0.03257607f, 
    -0.03856684f, -0.03145200f, 0.00530457f, -0.03238102f, -0.04156841f, -0.02093026f, 0.02365149f, -0.00379298f, 
    -0.03595151f, 0.01835413f, -0.00968105f, -0.03932971f, -0.03495564f, -0.02559292f, 0.02521631f, 0.00534000f, 
    -0.03035821f, -0.03897519f, -0.00421910f, 0.02780136f, -0.01197470f, 0.03588803f, 0.01972169f, 0.01598959f, 
    -0.02185018f, -0.02678620f, 0.02527737f, 0.01503965f, 0.00146267f, 0.02334523f, 0.00076085f, 0.01112861f, 
    0.00449755f, 0.02181640f, -0.00069097f, -0.01055330f, -0.01188725f, -0.01168911f, -0.01246640f, -0.00153424f, 
    -0.00852686f, -0.03581632f, -0.02012305f, -0.01749536f, 0.02517581f, -0.00426630f, 0.01759587f, -0.01674119f, 
    0.02002291f, -0.01940158f, -0.01011909f, 0.01273571f, 0.02542902f, -0.02165196f, 0.01470743f, 0.00385860f, 
    -0.03895979f, 0.00056727f, -0.02975116f, -0.02702666f, 0.00603288f, -0.00231980f, -0.03801653f, -0.00311876f, 
    -0.04378481f, 0.02151695f, -0.00894762f, -0.00419899f, -0.01568771f, -0.03993069f, -0.03776821f, 0.00192048f, 
    0.02540957f, -0.02879053f, 0.00088931f, -0.02130508f, -0.02670019f, -0.02976795f, 0.01160834f, -0.03455244f, 
    -0.01441973f, -0.01144738f, -0.03341629f, 0.00616075f, -0.01493035f, 0.00242389f, -0.01000202f, -0.02584352f, 
    -0.02055204f, 0.02243288f, 0.00072222f, 0.02417261f, -0.03204180f, 0.00907756f, -0.03344581f, -0.03467475f, 
    0.01047147f, 0.02060031f, 0.00650687f, 0.01942198f, 0.00702017f, -0.03857536f, -0.03337543f, -0.02009858f, 
    -0.02813542f, 0.02588249f, -0.01137598f, 0.00904809f, -0.00184969f, -0.03161139f, 0.00193690f, 0.02501191f, 
    -0.00406858f, -0.01948048f, -0.01020261f, -0.03683031f, -0.02276105f, -0.03566064f, 0.00021967f, 0.01972743f, 
    -0.01858617f, 0.00850736f, -0.01914769f, 0.01582628f, 0.00857164f, -0.01374018f, 0.02153435f, -0.03955532f, 
    0.02183826f, 0.02706681f, -0.03745848f, 0.00203352f, -0.00190154f, -0.02654834f, -0.01676011f, -0.01875104f, 
    -0.03787766f, 0.02512117f, 0.01830243f, -0.00925685f, 0.02141045f, 0.00510591f, -0.00995322f, -0.00442265f, 
    0.01690331f, 0.01178418f, -0.00638887f, 0.00622230f, -0.00491324f, 0.01978086f, -0.03265928f, -0.00949669f, 
    0.02318559f, 0.01330582f, -0.02325521f, 0.01402192f, -0.03520738f, 0.02827613f, -0.00058191f, 0.02664209f, 
    -0.00094605f, -0.00349280f, 0.00562910f, -0.00127932f, 0.01193424f, 0.01356357f, -0.03052190f, -0.03579855f, 
    -0.00358217f, 0.02269139f, -0.04050590f, -0.01912569f, -0.00838900f, -0.02595219f, 0.01528398f, -0.03940688f, 
    -0.04077436f, 0.02861837f, 0.00491047f, 0.01210035f, 0.00568157f, 0.01841928f, 0.01820856f, -0.03384270f, 
    -0.00280893f, 0.01311647f, -0.03864950f, -0.00848572f, 0.00905120f, 0.02023434f, 0.02665784f, -0.03479953f, 
    0.01450361f, 0.02692014f, -0.01169563f, 0.00356392f, -0.01018585f, -0.02388850f, 0.02227555f, -0.00957098f, 
    0.00665434f, 0.01684195f, -0.00683282f, 0.00911131f, 0.00031615f, -0.03864347f, 0.02354040f, 0.01242145f, 
    -0.01027781f, 0.01864825f, 0.02075942f, -0.01568347f, -0.01708072f, 0.01447557f, -0.03833169f, 0.02863317f, 
    0.01308866f, 0.02018032f, -0.01389393f, -0.01389280f, 0.02137434f, 0.02686290f, -0.01715965f, -0.03292182f, 
    -0.00656168f, 0.01010372f, -0.02046512f, -0.04383078f, -0.00068371f, -0.00049120f, -0.02140386f, -0.03600440f, 
    -0.02232420f, 0.00055509f, -0.03260967f, 0.01235193f, 0.00118904f, -0.02266825f, -0.02514503f, -0.03842790f, 
    -0.00730064f, 0.02651954f, -0.04147433f, 0.01232457f, 0.02856150f, -0.02710426f, 0.01704554f, -0.01710031f, 
    -0.01041518f, 0.01069030f, -0.03266686f, -0.00877072f, -0.00147114f, 0.02106120f, -0.01293882f, -0.00756439f, 
    -0.00753739f, -0.01129015f, 0.01604033f, 0.00608821f, -0.00063697f, -0.02706747f, -0.00149127f, 0.00310725f, 
    0.01267935f, -0.01172645f, -0.01510368f, 0.02132086f, -0.02179632f, -0.00578859f, -0.03168891f, -0.01770959f, 
    -0.03152598f, -0.00353369f, -0.03799119f, -0.03791902f, 0.01447779f, -0.04451244f, 0.02066983f, 0.00860236f, 
    -0.03823387f, 0.00293185f, -0.01761853f, 0.01934502f, -0.02779347f, -0.03340350f, -0.03695668f, 0.02219189f, 
    0.00241331f, 0.00960136f, 0.00888153f, 0.00135048f, 0.01175117f, 0.02598416f, -0.02812214f, -0.03063207f, 
    -0.02349644f, -0.00952028f, 0.01270435f, 0.02369608f, -0.03546163f, -0.00752135f, -0.01718742f, 0.01858272f, 
    -0.03428093f, -0.02435393f, -0.01844480f, 0.00057780f, -0.00065200f, 0.01965075f, 0.02734308f, 0.00134262f, 
    0.02246643f, -0.03794186f, 0.01019266f, -0.03419798f, -0.02816247f, -0.01019268f, 0.00095040f, -0.03793898f, 
    0.01303113f, -0.03175253f, -0.00720264f, -0.00117238f, 0.00588180f, -0.01709545f, 0.01878577f, 0.00666300f, 
    -0.00052886f, -0.01475759f, -0.01563555f, 0.01141748f, 0.02366282f, 0.00255355f, -0.01159353f, -0.02621046f, 
    -0.01242703f, -0.03209951f, -0.00907325f, 0.02431428f, -0.01143686f, 0.02472690f, -0.03076833f, -0.01110844f, 
    -0.04278058f, -0.03409991f, -0.01787124f, -0.01281771f, -0.00235265f, -0.01892821f, 0.00602791f, -0.01560801f, 
    -0.02868793f, -0.03126026f, 0.03881539f, 0.00550835f, 0.01844823f, -0.00377279f, -0.01647625f, 0.00772659f, 
    -0.01410296f, -0.00171655f, 0.02677551f, -0.00908723f, -0.00332980f, 0.00982863f, -0.02358692f, -0.01112529f, 
    -0.00750669f, 0.01849394f, 0.00046388f, -0.02559567f, -0.00871455f, 0.01105545f, -0.01626647f, 0.02484202f, 
    -0.03489438f, -0.00015525f, 0.00535072f, 0.00015119f, -0.03800722f, -0.02709973f, 0.01516255f, 0.02595547f, 
    -0.03812320f, -0.01411575f, 0.00132803f, -0.00773604f, 0.01716527f, 0.00953203f, 0.02230712f, 0.01962923f, 
    0.00689742f, -0.02757145f, -0.00292877f, -0.04066730f, -0.04115406f, -0.00484154f, -0.04220093f, -0.03325130f, 
    -0.01362458f, 0.00460871f, 0.01633939f, -0.00204653f, -0.00867524f, 0.00065288f, 0.01256635f, 0.00037169f, 
    -0.04099547f, -0.00386967f, -0.02097817f, 0.00267076f, -0.02031782f, -0.03309981f, -0.02809489f, -0.02284075f, 
    0.00089277f, -0.02238806f, -0.02228864f, -0.02646823f, -0.00833493f, -0.00634138f, -0.00318902f, -0.01984467f, 
    0.03246039f, 0.02041626f, -0.00415962f, -0.03034930f, -0.00718878f, -0.04317649f, 0.02271469f, 0.00518244f, 
    0.01772196f, 0.01333504f, -0.02740158f, 0.01987280f, 0.02612758f, 0.03959092f, 0.00755976f, -0.01751181f, 
    0.00845597f, -0.03302289f, -0.04211784f, 0.01507320f, 0.01597906f, 0.00565645f, -0.01464784f, -0.00352510f, 
    -0.02642458f, 0.02077605f, 0.02860203f, -0.01706738f, 0.00185744f, 0.00360804f, 0.01862581f, -0.02219096f, 
    0.02723848f, -0.03453002f, -0.03821517f, -0.00505938f, 0.01346021f, 0.02689406f, -0.02420047f, 0.02590564f, 
    0.02070115f, -0.00173582f, -0.03185302f, 0.03217263f, 0.02100065f, -0.01688764f, -0.01029250f, -0.01712421f, 
    -0.03605305f, 0.02318945f, -0.03101612f, 0.00295441f, -0.03152902f, -0.02465117f, 0.00974960f, -0.00995583f, 
    -0.02104206f, 0.02668458f, 0.02157097f, -0.01889373f, -0.02086466f, -0.03544576f, 0.01008648f, -0.02425794f, 
    -0.04024931f, -0.03986656f, -0.01256881f, -0.01396387f, -0.02811869f, -0.03466281f, 0.01228608f, 0.00079821f, 
    0.00346375f, -0.03013450f, -0.01566780f, 0.02804950f, -0.01386065f, 0.00102525f, -0.01607195f, 0.00911948f, 
    0.00931028f, -0.01223837f, 0.00074507f, -0.00926622f, 0.00206022f, 0.00449533f, 0.01913362f, 0.02776500f, 
    0.02585815f, 0.00784099f, -0.03013967f, 0.00868168f, -0.00839794f, -0.01893629f, -0.01695580f, 0.03026527f, 
    0.00425645f, -0.02138880f, 0.02354482f, -0.03181995f, 0.00490861f, -0.01394692f, 0.01632950f, 0.02546680f, 
    -0.00127260f, 0.02498664f, 0.00396374f, -0.04240245f, 0.00074839f, -0.03121189f, 0.02243873f, -0.01763935f, 
    -0.01903789f, -0.00928778f, -0.04278055f, 0.01984479f, 0.00439956f, -0.00378797f, -0.00362652f, -0.01703075f, 
    0.00833234f, 0.01797870f, 0.02849538f, 0.00380810f, 0.00270769f, -0.00865566f, -0.03094230f, -0.02969225f, 
    0.04132593f, 0.00340729f, -0.03720089f, 0.00799205f, -0.02227940f, 0.00626406f, 0.00933411f, -0.04428210f, 
    0.00096269f, 0.01443205f, 0.00690122f, -0.03496164f, -0.00799960f, -0.02094595f, 0.00241819f, -0.01611521f, 
    0.03948980f, 0.01950652f, 0.02109162f, 0.00702844f, -0.00969382f, 0.00448590f, -0.01177635f, -0.00169726f, 
    0.01277073f, -0.03976104f, 0.00710708f, -0.04198567f, -0.00608375f, -0.04081227f, 0.02237022f, -0.02542038f, 
    -0.03008246f, -0.03500457f, -0.03772355f, -0.01858977f, 0.00373846f, -0.03287620f, 0.02588701f, -0.01869628f, 
    -0.00762179f, -0.00925894f, -0.02542057f, 0.01262880f, 0.01927169f, 0.01685752f, -0.00562787f, -0.01431636f, 
    0.00414591f, -0.01707254f, 0.02815520f, -0.03844132f, -0.00011261f, -0.03803991f, -0.02238274f, -0.04267710f, 
    0.00197462f, -0.03874762f, -0.01526902f, -0.00324822f, -0.02045825f, -0.03749804f, 0.02318382f, -0.00725486f, 
    0.01771367f, -0.01908434f, -0.00183349f, -0.04418382f, 0.00804221f, -0.02391143f, -0.00728239f, -0.01129337f, 
    0.01172415f, -0.02441736f, -0.00663199f, -0.02536098f, 0.02689068f, -0.03978879f, -0.00406609f, -0.00912590f, 
    -0.01807277f, -0.02067238f, -0.00168659f, 0.00677166f, -0.01665765f, 0.01924971f, 0.01578663f, -0.03669251f, 
    0.21756005f, 0.15310079f, -0.16471210f, -0.07887208f, 0.07822164f, 0.18663475f, 0.05232712f, -0.03060027f, 
    0.03339423f, 0.02798600f, 0.06921624f, 0.18872343f, 0.27570698f, 0.21281050f, -0.14630255f, 0.07693919f, 
    0.00404851f, 0.00040291f, 0.00823666f, 0.11981530f, -0.03055754f, -0.08372278f, -0.11314890f, -0.05722125f, 
    -0.10291073f, 0.15022293f, -0.10117663f, -0.01307177f, 0.13826238f, 0.16001381f, 0.03460009f, 0.07340405f, 
    0.01141141f, 0.00299700f, 0.06237916f, 0.06014227f, 0.10019838f, 0.16564605f, 0.13853760f, 0.17797819f, 
    0.12566204f, 0.06919042f, -0.18022701f, -0.05837184f, -0.01866600f, 0.05515679f, 0.02737173f, -0.13895668f, 
    -0.21184412f, -0.05331148f, -0.19958305f, -0.02277409f, -0.09620737f, -0.12146748f, -0.12516518f, -0.01497848f, 
    0.00276521f, 0.00432123f, 0.01319523f, 0.03720666f, -0.23371738f, 0.00128279f, 0.10540751f, -0.09214827f, 
    0.00674614f, 0.03438802f, -0.05695963f, 0.06539179f, 0.10955759f, -0.03149403f, -0.04520666f, 0.09131753f, 
    0.03761385f, 0.02312439f, 0.03663653f, 0.03120803f, 0.03497852f, 0.15802519f, -0.03912659f, 0.19399700f, 
    0.08553629f, 0.12019314f, 0.08572824f, 0.19624995f, 0.24578078f, 0.12621734f, -0.00135717f, 0.06711815f, 
    0.04159427f, 0.00284259f, 0.13408345f, -0.22125377f, 0.10230733f, 0.11037312f, 0.01923753f, 0.25321063f, 
    0.11181469f, -0.02991345f, 0.11336248f, 0.01813346f, -0.05079702f, -0.05303722f, -0.08671619f, -0.00584353f, 
    -0.01813369f, -0.04295639f, -0.17147762f, -0.14057222f, 0.00854179f, 0.30031407f, -0.00688163f, 0.18765478f, 
    0.00321872f, 0.14342704f, 0.16553535f, 0.20236394f, 0.02281843f, 0.00617446f, -0.00157298f, 0.05894680f, 
    -0.09931508f, -0.01932239f, -0.02524130f, 0.04897291f, -0.02484285f, -0.08291414f, -0.11168274f, -0.03691356f, 
    -0.02333541f, -0.01128101f, 0.03635488f, 0.04286700f, 0.08549545f, -0.09858671f, 0.00339365f, 0.12426057f, 
    0.04199291f, 0.03625078f, -0.08963837f, -0.03825665f, -0.05260699f, -0.14200330f, -0.08215185f, -0.13038641f, 
    -0.28973573f, -0.08546123f, -0.10426550f, -0.06484762f, -0.11821894f, -0.03770395f, -0.04332281f, -0.07383759f, 
    0.06116312f, 0.05835368f, 0.01349394f, 0.07948860f, 0.13007729f, 0.21999180f, 0.06399212f, 0.13730730f, 
    0.01246967f, 0.11984444f, 0.09684861f, -0.00060007f, 0.03096218f, 0.02194877f, -0.13512246f, -0.00055770f, 
    -0.43063065f, -0.46740079f, -0.09011170f, 0.01675024f, 0.04162687f, 0.06679803f, 0.03675809f, -0.12505071f, 
    -0.05467719f, -0.01752442f, -0.03876319f, -0.01720286f, 0.01327722f, -0.05535367f, -0.15412003f, 0.09604906f, 
    0.04305954f, -0.02241950f, 0.18144424f, -0.02927176f, 0.04699649f, 0.04505028f, 0.02051417f, -0.04994091f, 
    -0.10727064f, -0.00070631f, -0.04054474f, -0.13514778f, 0.05615363f, -0.10289513f, -0.17580242f, 0.04176030f, 
    0.20206803f, 0.08715140f, -0.02760263f, -0.00783523f, 0.06672586f, 0.05889053f, 0.04230307f, 0.12812272f, 
    0.10919060f, 0.07666072f, 0.17132504f, 0.24506950f, -0.02084526f, -0.05810477f, 0.00092469f, 0.05304328f, 
    -0.04514033f, 0.36086079f, 0.04740616f, 0.19455090f, 0.14800288f, 0.00585672f, 0.20215337f, -0.06721784f, 
    0.01051496f, -0.01407609f, -0.10838891f, 0.00337648f, 0.21103545f, 0.02093004f, 0.13570297f, -0.05967877f, 
    0.12059787f, 0.11610918f, 0.09982539f, 0.26146209f, 0.01017414f, -0.02096906f, 0.04796850f, 0.01110203f, 
    -0.07646273f, -0.13416803f, -0.07004341f, -0.03093156f, 0.12141915f, -0.05830723f, 0.09212063f, 0.05062449f, 
    0.11927453f, 0.11887833f, 0.05029963f, 0.21596134f, -0.08480245f, -0.00079597f, -0.14898287f, -0.00025039f, 
    -0.05828261f, 0.01417648f, -0.06040375f, -0.01270781f, -0.04599719f, 0.00817011f, 0.01366677f, 0.07382513f, 
    -0.29702619f, -0.24892323f, -0.09181213f, 0.06788832f, -0.12136512f, -0.10512242f, -0.04868757f, -0.13492849f, 
    0.00190746f, 0.06542481f, 0.11698882f, 0.05188912f, -0.16628730f, 0.18072520f, -0.06963345f, 0.19142073f, 
    -0.03643752f, 0.05570306f, 0.02190082f, -0.11420567f, 0.02327665f, 0.02356686f, -0.03672390f, 0.14707263f, 
    -0.22950444f, -0.08109526f, -0.23535928f, -0.07939056f, -0.09966291f, -0.05643309f, -0.00555203f, 0.07550994f, 
    -0.05352570f, 0.01871589f, -0.04329270f, 0.03564271f, -0.02033961f, 0.44973320f, -0.46499154f, 0.03380580f, 
    -0.03368562f, 0.04053631f, 0.00390497f, 0.11178283f, -0.07341664f, -0.01172723f, 0.01972414f, -0.02676395f, 
    -0.02948149f, -0.12633236f, -0.06555113f, 0.15352431f, 0.12106666f, -0.06022865f, 0.16548221f, -0.08065221f, 
    -0.04662520f, 0.08006608f, 0.03673910f, 0.11451022f, 0.00415820f, 0.26725295f, -0.14014234f, -0.13279332f, 
    -0.06636704f, 0.01203700f, -0.00417155f, 0.05278865f, -0.08336419f, -0.12471712f, 0.12206636f, 0.00512339f, 
    0.17875543f, 0.10020246f, 0.04192439f, -0.07529972f, 0.08613130f, 0.13145754f, -0.07436594f, 0.14130792f, 
    0.11804711f, 0.12905201f, 0.02047813f, 0.11879259f, -0.02160609f, 0.06632099f, 0.03493651f, 0.05931299f, 
    0.02364768f, 0.02709514f, -0.13946782f, -0.03996452f, -0.07036696f, 0.01389407f, 0.01435592f, 0.00558646f, 
    -0.03410616f, 0.06224198f, -0.08769394f, -0.05796153f, 0.00458900f, 0.05413999f, 0.06399773f, 0.10625980f, 
    0.03761169f, -0.00008304f, -0.12719411f, 0.03586451f, 0.01935367f, 0.04323778f, -0.01691573f, 0.05096989f, 
    -0.01933579f, -0.04903968f, 0.06593483f, 0.04620185f, -0.00291556f, -0.03678330f, -0.15545456f, -0.07836972f, 
    -0.11249976f, 0.04439221f, -0.06280025f, -0.02594560f, -0.02835695f, 0.09297934f, -0.04392136f, -0.02043200f, 
    0.08554094f, 0.07159956f, 0.01163324f, 0.12873445f, -0.13434920f, -0.03791965f, -0.02089087f, -0.04837109f, 
    -0.00787063f, -0.00798723f, -0.02380168f, -0.00570873f, 0.00174726f, -0.02970204f, 0.03320710f, -0.03320831f, 
    0.09769915f, 0.11729524f, 0.07789943f, 0.09260745f, -0.00663171f, -0.06814255f, -0.06673623f, -0.13966760f, 
    -0.08276908f, 0.03484817f, -0.05638248f, -0.09056973f, -0.22263569f, -0.02246333f, -0.05551513f, -0.01448027f, 
    -0.00294882f, -0.04600669f, 0.00408502f, -0.04706198f, 0.01202924f, 0.06108307f, -0.08991322f, 0.16636455f, 
    -0.14121138f, 0.25624880f, 0.27227253f, 0.18678404f, -0.02691899f, -0.07381146f, 0.04814237f, -0.20056684f, 
    0.13676368f, -0.04157569f, 0.00730921f, 0.09069242f, -0.06661297f, -0.12441283f, 0.02703682f, 0.03558573f, 
    -0.01956219f, 0.05045880f, -0.01147839f, 0.10701993f, -0.09237750f, 0.04862070f, -0.04752295f, -0.06762537f, 
    -0.02870416f, 0.20392685f, -0.04772112f, -0.05498037f, 0.05927838f, 0.16846500f, 0.08372689f, 0.18923481f, 
    0.05401634f, 0.03428299f, -0.04143638f, -0.13726908f, -0.01863453f, 0.16772519f, -0.19768074f, -0.03696261f, 
    0.00633630f, -0.05656425f, 0.12838155f, 0.15291928f, 0.01388961f, 0.22230290f, 0.08739556f, 0.11983858f, 
    -0.20637819f, 0.10892156f, -0.01898186f, -0.08151023f, 0.09133551f, 0.04427613f, -0.07295152f, 0.11050222f, 
    -0.04275836f, -0.05739408f, 0.09725428f, 0.09919438f, 0.50015628f, 0.22799273f, 0.23003012f, 0.24300024f, 
    0.06798794f, 0.00605492f, 0.09540083f, 0.00412003f, -0.01908915f, -0.02791514f, -0.12598555f, 0.05987031f, 
    -0.14301437f, -0.02567154f, -0.10315974f, -0.09292533f, -0.03145947f, 0.03470894f, 0.12223639f, -0.14366534f, 
    0.03669682f, 0.03241060f, 0.02139867f, 0.16373907f, -0.07595523f, 0.05528011f, -0.02290348f, -0.00179050f, 
    -0.08451457f, -0.05344104f, -0.06488502f, -0.08892480f, -0.02932953f, -0.08400883f, -0.12647551f, -0.15986285f, 
    0.15081117f, 0.17147046f, -0.00309866f, 0.06137843f, -0.02147854f, -0.03907900f, 0.06706529f, 0.07237233f, 
    -0.00687606f, 0.15258875f, -0.03637617f, -0.00552448f, 0.11451545f, 0.11391029f, -0.11278225f, 0.17423113f, 
    0.00294203f, -0.07944676f, 0.04838400f, 0.04694061f, 0.06982985f, 0.16615124f, -0.05536129f, 0.04837963f, 
    -0.08167107f, 0.09879869f, -0.05521856f, 0.05760476f, 0.15552790f, 0.31663638f, 0.03962995f, 0.08273313f, 
    0.05040839f, -0.00142031f, -0.00469446f, 0.05354207f, 0.09218708f, 0.05480804f, 0.04374167f, 0.11609071f, 
    -0.05602789f, 0.03177425f, 0.00932261f, -0.05005905f, 0.12802806f, 0.08693273f, 0.12494523f, 0.11370803f, 
    -0.02095487f, -0.01265462f, 0.02995337f, -0.12722963f, -0.10451202f, 0.02840736f, -0.13618323f, 0.01504828f, 
    0.05143914f, -0.08703534f, 0.00273684f, 0.13388635f, -0.07119401f, -0.14864624f, -0.01665507f, -0.10744605f, 
    0.08314303f, -0.08115938f, -0.02354230f, 0.05975920f, 0.15796672f, 0.13021025f, 0.20800561f, 0.17712615f, 
    -0.19837850f, 0.03660060f, -0.18677589f, -0.01529621f, -0.08723018f, 0.00915853f, 0.08138613f, -0.08738853f, 
    0.02290894f, 0.04088352f, 0.02267301f, -0.04004271f, -0.07983654f, 0.00279224f, -0.18640247f, 0.03080253f, 
    0.08946428f, 0.03624063f, 0.11326855f, 0.11979223f, 0.02893622f, 0.20878476f, -0.01192009f, 0.04607255f, 
    -0.03864168f, 0.29638535f, -0.00227925f, 0.07286189f, 0.17132597f, 0.01443314f, 0.00579287f, 0.15644243f, 
    0.05853566f, -0.00982443f, -0.28042901f, 0.00694366f, -0.05897460f, 0.11064056f, -0.06236643f, -0.06828983f, 
    0.11415643f, 0.11439785f, -0.03354046f, 0.12128743f, 0.02815247f, 0.03358860f, 0.11876047f, 0.15805128f, 
    -0.35926589f, -0.08846763f, 0.01386669f, 0.13008834f, -0.03581710f, -0.11592910f, 0.02240007f, -0.14344208f, 
    0.03339969f, 0.04540706f, 0.05445960f, 0.16930529f, 0.02211224f, 0.21352755f, 0.15203398f, 0.06787176f, 
    0.02578049f, 0.06839627f, -0.14946847f, -0.01247532f, -0.08963412f, -0.00846047f, 0.03195296f, 0.00881228f, 
    -0.08382089f, -0.26190537f, 0.03406671f, -0.06954840f, 0.04223810f, 0.00434570f, -0.16394149f, 0.02329597f, 
    -0.07928394f, 0.06456269f, -0.23441537f, -0.18388388f, 0.29092786f, 0.21591577f, 0.35240135f, -0.12262088f, 
    0.21606645f, 0.10660227f, -0.11346609f, 0.04576564f, 0.02441191f, -0.00520488f, -0.02135283f, -0.00554100f, 
    0.06680864f, 0.13435222f, 0.08244378f, 0.04581339f, 0.14926700f, 0.20238389f, 0.09658311f, -0.02393431f, 
    -0.00087333f, 0.05324156f, -0.00131498f, 0.08835127f, -0.26109153f, -0.30173075f, -0.14264028f, 0.06363629f, 
    -0.11696801f, -0.10975085f, 0.00764484f, -0.00547166f, -0.01141647f, 0.03912950f, -0.01875158f, -0.01265662f, 
    -0.32316405f, -0.20948289f, -0.19694260f, 0.03036814f, -0.04807986f, -0.02503943f, -0.07182603f, 0.04996822f, 
    0.05619761f, -0.05968483f, -0.01978734f, -0.02610350f, 0.04576917f, 0.08076394f, 0.02109415f, 0.10399839f, 
    0.07768738f, -0.01718692f, -0.05418121f, -0.12936552f, 0.00388248f, -0.07520523f, -0.02923283f, -0.05969661f, 
    -0.10719448f, 0.05292997f, -0.11591527f, -0.05876432f, -0.05577105f, 0.01374013f, 0.09483971f, 0.13648692f, 
    0.09870784f, 0.07763851f, 0.04125469f, 0.11506544f, 0.04028429f, 0.16009948f, -0.09883343f, -0.08978714f, 
    0.13761057f, 0.22753353f, 0.04254954f, 0.22210698f, 0.03240548f, -0.04616915f, -0.00747981f, 0.03888499f, 
    0.02627389f, -0.03438460f, -0.03253465f, 0.00837552f, 0.01862769f, -0.01034540f, 0.01396988f, 0.02300092f, 
    -0.02843157f, -0.01892303f, 0.01627367f, 0.00800573f, 0.02649168f, -0.00376193f, -0.02018329f, 0.00729285f, 
    -0.01427344f, 0.01803164f, -0.00097818f, -0.00801162f, 0.01397830f, 0.01106198f, -0.01269708f, -0.00433255f, 
    0.00796773f, 0.01107103f, 0.02225117f, 0.00806705f, -0.00112824f, -0.04150137f, -0.02187061f, 0.01750384f, 
    0.01639878f, -0.02611037f, 0.00243498f, -0.02751702f, -0.03131743f, 0.02032121f, 0.02179268f, -0.02741737f, 
    -0.03112336f, -0.01912415f, -0.00819110f, -0.03608298f, 0.00975684f, -0.00498556f, 0.02721211f, 0.01254842f, 
    0.02076184f, -0.00216989f, -0.03024242f, 0.00377443f, -0.02365547f, -0.00616133f, 0.01936289f, -0.02077554f, 
    0.00161536f, 0.01945246f, -0.03080090f, -0.02079532f, 0.00979671f, -0.04105862f, 0.02427336f, 0.02713988f, 
    -0.02677860f, 0.00166746f, -0.03404788f, 0.02099694f, 0.01482030f, 0.01258866f, -0.03675071f, -0.03128138f, 
    -0.04010045f, -0.02288407f, 0.01485187f, -0.01297752f, -0.00602683f, 0.02355744f, 0.01036345f, 0.01411050f, 
    -0.02439001f, -0.01237461f, -0.01046915f, -0.02298038f, -0.01712940f, -0.00736105f, 0.01501407f, 0.02077363f, 
    -0.02884387f, -0.00690758f, -0.02797160f, -0.03208145f, 0.02476686f, -0.00301194f, -0.03208819f, -0.02510999f, 
    -0.02671584f, -0.02010911f, -0.03123765f, 0.01169794f, -0.03494227f, 0.02426098f, 0.00368423f, -0.03672187f, 
    -0.01485588f, -0.03792454f, 0.00638322f, 0.02458052f, -0.00191097f, 0.02939204f, -0.03841891f, -0.01401813f, 
    0.02693439f, -0.00309856f, -0.03514688f, -0.02546662f, -0.00842215f, -0.02339214f, -0.00703271f, 0.02103837f, 
    0.00341687f, 0.02721405f, 0.01553091f, -0.02124935f, -0.02500011f, -0.01113577f, 0.01376569f, -0.03255942f, 
    -0.00308422f, -0.00168021f, 0.01921104f, -0.02910658f, 0.00422587f, 0.00812923f, -0.00104285f, -0.03027191f, 
    -0.02650772f, -0.03048731f, 0.02124104f, -0.00375159f, -0.03549506f, -0.02679953f, -0.02982832f, -0.01770506f, 
    0.00199705f, 0.00537015f, 0.02509202f, -0.04234419f, -0.00410668f, 0.02069000f, -0.00358859f, -0.03948032f, 
    -0.03512242f, 0.00937361f, -0.01195515f, -0.02452451f, -0.00494372f, -0.02316822f, 0.01051263f, -0.03424685f, 
    -0.02711784f, 0.02516921f, -0.03584842f, 0.00713039f, 0.02720570f, -0.02357782f, 0.00961821f, 0.01260332f, 
    -0.01319089f, -0.02871812f, -0.00588881f, 0.02253485f, -0.02677465f, -0.02100765f, -0.02006711f, 0.00991245f, 
    0.01673824f, -0.02993519f, 0.02603560f, -0.00279530f, -0.03511534f, 0.00108473f, -0.02495901f, -0.00477538f, 
    0.01835461f, -0.01732980f, -0.01284949f, -0.00360546f, 0.01240060f, -0.01317150f, 0.01274232f, 0.00392393f, 
    -0.04030081f, -0.02324190f, -0.03510892f, 0.00541748f, -0.01145650f, -0.02618783f, 0.01779538f, -0.03886119f, 
    0.00414832f, -0.01261577f, -0.03928111f, -0.03801231f, -0.00388603f, 0.02861530f, 0.00006191f, -0.01254343f, 
    0.00151702f, 0.01222540f, 0.00101212f, 0.01459671f, -0.02474006f, -0.02864336f, 0.02457700f, 0.01941536f, 
    -0.01534223f, -0.01296874f, -0.02810810f, -0.03047979f, -0.03123780f, 0.02549713f, 0.00101403f, 0.01317804f, 
    -0.02388471f, 0.02854513f, 0.02634832f, -0.01804526f, -0.01599469f, 0.00131059f, -0.04166947f, -0.03191999f, 
    0.00384296f, -0.02720799f, -0.04054736f, -0.02171049f, -0.03513338f, -0.02353612f, -0.01681015f, 0.00276611f, 
    -0.02991195f, -0.00513887f, 0.01796396f, -0.03085318f, -0.03091428f, 0.02663992f, 0.01825735f, 0.02872273f, 
    0.01939345f, -0.00276688f, -0.01594035f, 0.01479819f, -0.03217754f, 0.00006484f, 0.00983555f, -0.03225278f, 
    -0.02256399f, -0.01055386f, 0.01892497f, -0.04404950f, -0.02993915f, -0.02590036f, -0.03857770f, 0.00884199f, 
    0.02284952f, 0.00845741f, 0.01231266f, -0.00178421f, 0.02057635f, -0.04012083f, 0.00602777f, 0.00002065f, 
    -0.03883214f, -0.00149326f, -0.03160902f, -0.03914490f, 0.00764705f, -0.02755079f, -0.02043691f, 0.01007806f, 
    -0.02940968f, -0.02205981f, 0.00022753f, -0.01892914f, -0.00540451f, -0.01313644f, -0.03124515f, -0.02140378f, 
    0.00899873f, -0.02206984f, -0.01578073f, 0.01452454f, -0.03193826f, -0.02987489f, -0.00509416f, -0.04176486f, 
    -0.03738138f, -0.00622535f, -0.02876846f, 0.02066557f, -0.01843273f, -0.02629118f, -0.00964229f, -0.04146058f, 
    -0.01023938f, -0.02908210f, 0.00377480f, -0.00344219f, -0.04333016f, -0.04209704f, -0.03284306f, 0.02477338f, 
    0.00900031f, -0.03396599f, -0.02041166f, 0.01468728f, 0.00516616f, -0.01119431f, -0.02584381f, -0.04269350f, 
    -0.00839579f, -0.02758651f, 0.02366205f, -0.02454182f, 0.00015582f, -0.00065165f, -0.02907067f, -0.00734797f, 
    0.01600301f, 0.01668578f, 0.00527008f, -0.01590035f, -0.02641961f, -0.02425659f, -0.03826480f, 0.02014853f, 
    -0.00952059f, -0.03351216f, -0.02095141f, -0.01311935f, -0.00793617f, -0.01729284f, 0.00909170f, 0.00722411f, 
    -0.03248570f, 0.02460542f, -0.01129423f, 0.02734787f, -0.00405413f, -0.04071255f, -0.00705914f, -0.02002855f, 
    0.01521455f, 0.02614001f, 0.02480821f, -0.00331122f, -0.00189578f, -0.03770684f, -0.02818271f, 0.02277329f, 
    -0.00384435f, 0.00305775f, 0.02127039f, -0.02880418f, -0.03636189f, 0.01211006f, -0.00036766f, -0.04463331f, 
    0.02806182f, -0.01201944f, -0.01246103f, 0.00294612f, 0.01524866f, -0.02388409f, -0.04217225f, -0.01807486f, 
    -0.01396442f, -0.03358606f, -0.00438323f, 0.01756676f, -0.04260712f, -0.04082672f, 0.02409655f, -0.00347430f, 
    -0.04098050f, -0.01150948f, -0.00888370f, -0.03424935f, 0.01202525f, 0.00904004f, 0.02835087f, -0.03137343f, 
    -0.01834710f, -0.03449693f, -0.01667880f, -0.01238585f, -0.01195856f, 0.00207062f, -0.02988661f, 0.02052657f, 
    0.02449528f, -0.00791456f, 0.01322696f, -0.01218947f, 0.01153792f, -0.01802174f, 0.01631190f, 0.01840879f, 
    0.01760891f, 0.02036648f, -0.03936170f, 0.00074585f, 0.02309465f, 0.02672638f, -0.03777161f, -0.02214581f, 
    -0.01923976f, -0.02505575f, -0.00336534f, -0.03045605f, -0.00097575f, 0.03943472f, -0.04035639f, -0.01818658f, 
    -0.02693620f, -0.03858658f, -0.01967002f, -0.03848214f, 0.00165054f, 0.02911896f, 0.02202453f, -0.01222982f, 
    -0.01207200f, 0.01029538f, -0.00372545f, 0.02814542f, 0.01250407f, 0.02048479f, 0.01238445f, 0.00145967f, 
    -0.00114452f, -0.00671013f, 0.01736076f, -0.02155918f, -0.01750119f, -0.03287704f, 0.02140648f, -0.00938767f, 
    -0.03071607f, 0.01631102f, -0.00632246f, -0.01809341f, 0.02467152f, 0.01532518f, 0.00613786f, -0.01614899f, 
    -0.01878882f, -0.04070082f, 0.02666554f, 0.00904337f, -0.01596370f, 0.01831558f, 0.01661746f, 0.02388971f, 
    -0.03683023f, 0.00681286f, 0.00920747f, 0.00872932f, -0.02399873f, 0.01527092f, -0.00439149f, 0.02149474f, 
    -0.00071388f, -0.03723212f, 0.02898581f, -0.04204426f, -0.04184786f, -0.01166937f, -0.04024763f, 0.02150262f, 
    -0.02574766f, -0.02849509f, -0.03071409f, 0.00597873f, -0.01450346f, -0.03256394f, -0.02219141f, 0.01545986f, 
    -0.02875038f, -0.03300919f, 0.02546452f, 0.00057967f, 0.02595998f, 0.00253401f, 0.01319652f, -0.02871356f, 
    0.02150930f, -0.02596436f, 0.00019436f, 0.01916100f, -0.03323355f, 0.02250800f, -0.02727963f, 0.01212813f, 
    0.01591462f, 0.01606292f, 0.02214519f, -0.01676809f, -0.01939937f, -0.03990064f, -0.03696672f, -0.02478725f, 
    -0.02324231f, -0.01811229f, 0.01794989f, 0.01029107f, 0.02609222f, 0.00134688f, 0.02111859f, -0.03017070f, 
    -0.00322402f, -0.02688492f, -0.01532170f, -0.02732125f, -0.02381908f, 0.02573093f, -0.03705126f, 0.01908007f, 
    0.01127387f, -0.03143617f, -0.01214821f, 0.01754378f, -0.00283122f, 0.01864459f, -0.04003584f, 0.01499041f, 
    0.00065517f, -0.04115359f, 0.02827740f, -0.02716378f, 0.02636163f, 0.00304136f, 0.02252285f, -0.00769564f, 
    -0.04229236f, -0.01666004f, -0.03508021f, -0.02355565f, 0.02503968f, 0.00088474f, -0.01703611f, -0.03030413f, 
    -0.01246733f, 0.01025093f, -0.00284066f, -0.02211712f, -0.01311823f, -0.04054267f, -0.00886290f, 0.00645856f, 
    -0.01788224f, -0.02116773f, -0.00437483f, -0.03691725f, -0.03061531f, 0.01855563f, -0.00250912f, -0.00026413f, 
    -0.04217988f, 0.02498239f, -0.00551135f, -0.03672009f, -0.01028499f, 0.02669932f, -0.00310425f, 0.01459167f, 
    -0.00810715f, 0.00870070f, 0.00383667f, -0.02595939f, 0.02141783f, -0.02632895f, 0.01594940f, 0.01004525f, 
    0.00895658f, -0.02045886f, -0.01536557f, 0.01063695f, 0.01791568f, 0.02313039f, -0.04211775f, -0.04004747f, 
    -0.02962446f, -0.02973393f, -0.03156043f, -0.03053854f, 0.00419155f, -0.01557817f, -0.04258358f, 0.02622845f, 
    -0.03407261f, -0.00393825f, -0.02692985f, -0.00456294f, 0.01954406f, -0.03953046f, -0.03335673f, -0.01767246f, 
    -0.00577186f, -0.01196557f, -0.02538357f, 0.02012403f, -0.03502212f, 0.01080757f, -0.01697953f, -0.00847688f, 
    0.01554874f, -0.02934836f, -0.02979532f, -0.04159798f, 0.01678857f, 0.01840680f, -0.02343531f, 0.02222778f, 
    0.01128358f, -0.04015994f, -0.02954246f, -0.01417180f, -0.00315501f, -0.00701490f, 0.02622951f, 0.00692193f, 
    0.01630988f, -0.03466903f, -0.02017701f, -0.01814934f, 0.02531451f, -0.00884990f, 0.00664291f, 0.02709525f, 
    -0.02636322f, -0.01700940f, -0.02203976f, 0.02806601f, 0.00106208f, 0.02594546f, 0.01218054f, -0.03477602f, 
    0.01861548f, -0.03789963f, -0.02596941f, -0.01317737f, -0.00490469f, -0.00341923f, -0.00599630f, -0.01844310f, 
    0.02198621f, 0.02632688f, 0.00573447f, 0.01882880f, -0.02351171f, -0.02389392f, 0.02489063f, -0.02004897f, 
    -0.01083515f, -0.02196104f, 0.00079746f, -0.03199035f, 0.02759557f, 0.00285272f, 0.01090892f, 0.00238775f, 
    0.02492869f, 0.00419514f, 0.02782474f, -0.03051054f, -0.00176140f, -0.01705180f, 0.00397706f, 0.02448849f, 
    -0.01699506f, 0.00522075f, -0.01557074f, -0.00679536f, -0.04322677f, -0.03402418f, 0.02458256f, -0.01396756f, 
    0.00721374f, -0.04035379f, -0.02056071f, 0.01386277f, 0.01654190f, 0.01482706f, -0.00054077f, -0.00876835f, 
    0.02408479f, -0.00455393f, -0.02543879f, 0.01104536f, 0.00794185f, -0.01874740f, 0.01522741f, -0.03799002f, 
    -0.03207932f, -0.00124477f, -0.03389161f, -0.00676857f, 0.00877322f, 0.00573240f, -0.01350853f, -0.00699458f, 
    -0.01428316f, 0.01547656f, 0.01167351f, 0.00105405f, -0.04034748f, -0.00932133f, 0.02690680f, 0.02042283f, 
    -0.03937905f, 0.00587491f, 0.02695638f, -0.03244987f, 0.01602813f, 0.02092606f, -0.03250114f, -0.01518366f, 
    -0.02344081f, 0.02245592f, -0.02169283f, -0.03714079f, -0.00386599f, 0.00400913f, 0.02530774f, 0.02310684f, 
    -0.02370411f, 0.00132197f, 0.02361475f, 0.00394403f, -0.00233952f, -0.03071826f, -0.02856920f, 0.00561956f, 
    -0.00297705f, -0.03857072f, -0.03081779f, -0.01910720f, -0.00842175f, -0.01471341f, -0.01594418f, -0.02700221f, 
    0.02428297f, -0.03395995f, 0.00495359f, 0.01701817f, -0.01838416f, -0.01935933f, -0.02651176f, 0.00103222f, 
    -0.00854703f, -0.01360465f, 0.02156658f, -0.00359824f, 0.01602247f, -0.03758527f, 0.02490409f, -0.00680969f, 
    -0.14833158f, 0.07153987f, -0.08147085f, -0.08001803f, 0.10905419f, -0.07971518f, -0.04018236f, 0.12048621f, 
    -0.08422223f, 0.03365098f, -0.02549386f, 0.07659502f, 0.09452473f, -0.16781458f, -0.08295154f, -0.02968458f, 
    0.03337865f, -0.02593014f, -0.03133744f, 0.02065406f, 0.01751509f, 0.11626777f, 0.01464411f, 0.04659203f, 
    0.33973774f, 0.20740426f, 0.21245950f, -0.03499294f, -0.03606462f, 0.00729147f, 0.08468736f, 0.10836279f, 
    0.05702357f, -0.02244277f, -0.03527017f, 0.00130320f, 0.29373309f, 0.12158376f, 0.14131819f, -0.06023533f, 
    0.02050812f, -0.09754701f, -0.10073463f, 0.05828509f, 0.06646784f, -0.07439132f, -0.13408086f, -0.06016826f, 
    -0.12137743f, -0.45728695f, -0.42627779f, 0.06771915f, 0.07502294f, 0.03069476f, -0.04468059f, -0.03500892f, 
    -0.03433035f, -0.01561889f, 0.01418698f, 0.09623336f, -0.09578583f, -0.10490073f, -0.11016919f, 0.07657892f, 
    0.03938043f, -0.07164294f, -0.02849170f, 0.02143652f, 0.04284750f, 0.02349563f, 0.02888366f, 0.02633491f, 
    -0.07686842f, -0.04453687f, -0.10633354f, 0.03709150f, 0.09293225f, -0.02735379f, 0.11601169f, -0.17292972f, 
    0.00470357f, -0.01524667f, -0.05715752f, 0.04300767f, 0.05396262f, -0.10358710f, -0.09907620f, 0.03096577f, 
    -0.01532066f, 0.07109374f, -0.04927240f, 0.05372234f, 0.09443402f, -0.15909830f, -0.04739851f, 0.13393915f, 
    -0.13075517f, -0.18680546f, -0.38575232f, -0.06153143f, -0.00052040f, 0.00044882f, 0.00315583f, -0.02559864f, 
    -0.00778974f, -0.03028526f, -0.01404922f, 0.00913619f, 0.10319106f, 0.08406428f, 0.25203332f, -0.07205813f, 
    0.13130112f, 0.04969720f, 0.17164421f, -0.03367189f, 0.04448093f, 0.00040466f, -0.02085884f, -0.00206836f, 
    -0.04288352f, -0.15832640f, -0.05146073f, -0.06916054f, 0.01852095f, -0.10463486f, -0.00187270f, 0.04775474f, 
    0.03648620f, 0.05512976f, -0.00988424f, 0.07250679f, 0.19874063f, 0.10672756f, -0.13945727f, 0.00238907f, 
    -0.02078494f, -0.03734721f, -0.03837695f, -0.07689369f, -0.05841696f, 0.01954839f, 0.03344952f, 0.04752687f, 
    -0.02308621f, -0.17349443f, -0.06988585f, 0.04343070f, 0.00593660f, -0.06548859f, -0.03532572f, 0.01745742f, 
    0.02550588f, -0.01057216f, -0.01694574f, 0.05593963f, 0.08122900f, 0.16448161f, -0.01243899f, -0.05191726f, 
    0.09599964f, 0.04981000f, 0.07655385f, -0.05155133f, 0.06723434f, -0.02141285f, -0.08691995f, -0.08788661f, 
    -0.00639106f, 0.12009579f, 0.00381844f, -0.14751911f, 0.04225428f, -0.03492656f, -0.18470389f, -0.02861983f, 
    -0.01289619f, 0.01407275f, 0.12886377f, -0.01335090f, 0.18783824f, 0.29563329f, 0.32537088f, 0.02064615f, 
    0.12390189f, 0.12164921f, -0.04449040f, 0.08760753f, -0.02447388f, 0.03897360f, -0.01431646f, 0.00318379f, 
    0.43660581f, -0.04341373f, -0.23714535f, 0.01232583f, 0.12861525f, 0.02548709f, 0.02457356f, 0.12567422f, 
    -0.01240359f, -0.02414776f, -0.03231777f, 0.04055463f, 0.19941959f, 0.20913811f, 0.17537332f, -0.00353640f, 
    0.02381439f, 0.11569536f, -0.02031442f, -0.09782343f, 0.11400463f, -0.08335276f, 0.03117547f, -0.03836570f, 
    0.04837926f, 0.09571539f, 0.19339076f, -0.08904770f, 0.00715254f, 0.11658520f, 0.03404475f, -0.01580787f, 
    0.08482578f, -0.01574839f, -0.06731234f, -0.06810176f, 0.11705705f, 0.20773263f, 0.04228117f, -0.00879377f, 
    0.00963481f, 0.07141157f, 0.05601465f, 0.01087528f, -0.01149152f, 0.04253783f, 0.01474379f, -0.01403303f, 
    -0.08338411f, 0.01655525f, 0.07761120f, 0.04206535f, -0.18378580f, -0.01217557f, -0.07492270f, -0.04916630f, 
    -0.02928167f, 0.00319087f, -0.05106190f, -0.04726038f, 0.14951257f, -0.18767504f, -0.23129158f, -0.07066309f, 
    -0.06410712f, -0.06112608f, -0.00909011f, 0.02591704f, 0.03859652f, -0.05480527f, 0.08212847f, -0.02523285f, 
    -0.07210010f, -0.14936925f, -0.10907273f, 0.02069006f, 0.09044980f, 0.05421377f, -0.00741862f, 0.02598151f, 
    0.05840813f, 0.00271125f, 0.03600273f, 0.14302373f, -0.18380921f, -0.00386600f, 0.16044940f, 0.06045182f, 
    0.13349748f, -0.03257579f, -0.00124527f, 0.05779073f, 0.08022020f, 0.02105722f, -0.08094060f, -0.04448497f, 
    -0.17990591f, -0.16381979f, -0.18264481f, -0.12044869f, 0.05906519f, -0.01221820f, -0.07252554f, 0.04753794f, 
    -0.04040917f, -0.02524082f, 0.02805720f, -0.06906763f, 0.41474575f, -0.23256177f, 0.50202972f, -0.41545472f, 
    0.00626371f, -0.07250717f, 0.12294891f, 0.06676943f, 0.02071984f, 0.00361350f, -0.07522011f, 0.00828094f, 
    0.23999189f, 0.08295649f, -0.18929470f, -0.25848776f, 0.02770431f, 0.15926388f, -0.07514041f, -0.01412787f, 
    0.06905697f, -0.01997212f, 0.05279894f, -0.06229312f, -0.01681623f, -0.44013757f, 0.09225305f, 0.00855790f, 
    0.00804851f, -0.08382069f, 0.02037044f, -0.01869115f, 0.14609653f, 0.03514228f, -0.14707543f, -0.00492928f, 
    -0.09350867f, 0.03275868f, 0.10267438f, 0.00758999f, 0.02433292f, -0.05811946f, 0.05850571f, -0.07340581f, 
    -0.00521892f, -0.12772922f, -0.07681119f, 0.01898844f, -0.10242810f, 0.00807848f, 0.00428688f, -0.03841658f, 
    0.02653328f, 0.06093326f, 0.08124778f, 0.09211272f, 0.16827896f, -0.01768227f, -0.01064781f, -0.06716515f, 
    0.15806247f, 0.19268417f, 0.12951016f, 0.03567082f, -0.02267676f, -0.04297595f, -0.04234717f, 0.07779021f, 
    -0.00188004f, -0.03399537f, -0.00654597f, 0.00426123f, 0.32645535f, 0.13263683f, 0.16908191f, -0.08260931f, 
    0.05627891f, 0.11993847f, -0.11245545f, 0.00799144f, -0.00217219f, -0.10823385f, 0.00277076f, 0.01899625f, 
    0.01913093f, -0.00621077f, 0.07396702f, 0.04413014f, 0.08673283f, 0.01610029f, 0.03103168f, -0.02921448f, 
    0.00143722f, -0.00965015f, -0.06288571f, -0.12090234f, 0.06463683f, -0.04127230f, -0.17457443f, -0.02970214f, 
    0.03000258f, -0.04741066f, 0.04914280f, -0.02118581f, -0.01091844f, 0.00427234f, 0.02024537f, 0.08732555f, 
    -0.46453726f, 0.02177913f, 0.02041955f, -0.01544502f, 0.01175378f, -0.04173353f, -0.06494753f, 0.09013765f, 
    0.02035833f, 0.04452052f, -0.01560143f, -0.02208296f, 0.13809565f, -0.00723708f, 0.07907393f, 0.09967446f, 
    -0.03320285f, 0.06722030f, 0.01317619f, 0.03912750f, 0.03655056f, 0.04993948f, 0.01557698f, 0.02424242f, 
    0.06120000f, -0.19060484f, 0.04408327f, -0.05855454f, -0.02114937f, 0.01412117f, -0.09582212f, 0.06013383f, 
    0.01390165f, -0.07673895f, 0.03723431f, -0.13518374f, 0.01496996f, 0.01603296f, -0.20935293f, 0.00763171f, 
    -0.03565111f, -0.06916335f, -0.01284963f, -0.10366508f, -0.02938367f, -0.12543441f, 0.01439172f, -0.02314194f, 
    0.17543046f, 0.13400371f, 0.20273276f, -0.07578187f, -0.01732909f, -0.03319211f, 0.03437498f, 0.08705149f, 
    0.03098178f, 0.03917373f, -0.08516639f, -0.03482158f, 0.11766850f, 0.02535165f, 0.08307923f, 0.02135786f, 
    -0.01316268f, 0.01234597f, 0.10796718f, -0.10759259f, 0.04097524f, -0.04150373f, -0.06212525f, -0.02232510f, 
    0.12448979f, -0.03423152f, 0.06961983f, 0.03644713f, 0.04351857f, -0.09073602f, -0.13453326f, 0.10620723f, 
    -0.01041252f, 0.02904871f, 0.01315887f, -0.06518451f, -0.32622412f, 0.35153612f, -0.10208735f, -0.10847757f, 
    -0.01697205f, 0.02683889f, -0.05800543f, 0.06394508f, -0.00709376f, 0.03564327f, -0.03595639f, -0.03199338f, 
    -0.23892465f, 0.01377449f, 0.18006878f, -0.03134063f, -0.02239059f, 0.03572319f, -0.04980804f, 0.09059931f, 
    -0.02166948f, -0.00146154f, -0.15241683f, 0.12241717f, -0.24926654f, -0.05660989f, 0.01324497f, -0.03735625f, 
    0.07082034f, -0.07231051f, 0.02008952f, 0.03672422f, -0.16536334f, -0.11792281f, -0.10729374f, 0.08338679f, 
    -0.16159017f, -0.01545199f, 0.08018577f, 0.09515249f, 0.12494933f, 0.02788368f, -0.03927377f, 0.00981676f, 
    0.02582316f, -0.07762514f, 0.03524516f, -0.04132582f, 0.06951302f, -0.12506342f, 0.06676557f, -0.06163150f, 
    0.01164073f, -0.01139236f, -0.05112321f, 0.03319848f, -0.04240024f, -0.00400912f, 0.05892595f, -0.02447400f, 
    0.20957050f, 0.25792497f, 0.20169754f, 0.08058025f, 0.08153052f, 0.04644836f, 0.01393089f, 0.03751373f, 
    0.02517389f, 0.01806427f, -0.01095251f, 0.11448048f, -0.05185407f, -0.14818475f, -0.01505354f, -0.11756842f, 
    -0.10798667f, -0.00023670f, -0.04711213f, 0.01269640f, 0.14934552f, -0.02384620f, -0.07562105f, -0.04966218f, 
    0.08955370f, -0.14656547f, -0.15356557f, 0.01011260f, 0.12636219f, -0.03424236f, -0.04510811f, 0.04550271f, 
    0.05534978f, -0.06593443f, -0.05393541f, 0.03998500f, -0.03349925f, -0.01890101f, -0.00225601f, 0.01797060f, 
    0.01175334f, 0.05589972f, 0.00112687f, 0.01116346f, -0.06674433f, -0.03727783f, -0.08744724f, -0.00398142f, 
    -0.02923510f, -0.02785515f, -0.09486035f, 0.04643510f, 0.12370040f, -0.10208356f, -0.13547860f, 0.11860579f, 
    0.00739031f, -0.03220229f, -0.11700958f, 0.06999299f, 0.29167271f, 0.10376541f, -0.04515048f, -0.03217370f, 
    0.01209400f, 0.10035916f, -0.00497062f, -0.02304648f, -0.00298944f, -0.15442884f, -0.04671248f, -0.00329207f, 
    0.28854960f, -0.09339826f, 0.38110924f, 0.08738855f, -0.03874826f, -0.05726922f, 0.05751617f, -0.01972277f, 
    0.06578838f, -0.12962900f, -0.04136674f, -0.02526948f, 0.46332496f, 0.21688798f, 0.11899614f, -0.26850358f, 
    0.01159710f, 0.04274786f, 0.01996971f, -0.05203985f, 0.00024370f, -0.04494594f, -0.09509960f, -0.03853462f, 
    -0.33817568f, -0.08496463f, -0.01776500f, -0.00770074f, -0.04552530f, -0.02932577f, -0.08121756f, 0.06663594f, 
    0.10219434f, 0.01243929f, 0.05981001f, -0.02100942f, -0.12884878f, -0.21274483f, -0.16567110f, 0.02127896f, 
    0.00500865f, -0.03361414f, 0.04813267f, 0.03527830f, 0.15887049f, 0.02818394f, -0.06989998f, -0.01311356f, 
    -0.16799961f, 0.04082633f, -0.19514835f, 0.07057031f, 0.02089732f, 0.04921823f, -0.02210888f, -0.08308037f, 
    0.04818860f, 0.03861834f, 0.08348996f, -0.14444456f, 0.09733323f, 0.30145407f, -0.11634720f, -0.01362136f, 
    -0.08881332f, 0.01315566f, 0.08623475f, 0.00840584f, 0.01134145f, 0.03575300f, 0.01283240f, -0.04764046f, 
    0.15017021f, 0.18869632f, 0.11895826f, 0.13590902f, 0.04229978f, 0.06591757f, 0.01005366f, 0.08158971f, 
    0.04463215f, -0.05809832f, -0.04827482f, 0.11018982f, -0.08266361f, 0.09688515f, -0.11836641f, 0.05102241f, 
    0.08132046f, 0.05819441f, -0.03725443f, 0.02273968f, 0.06092657f, 0.00184478f, -0.01768290f, -0.01436550f, 
    0.20246041f, -0.04382966f, -0.41424415f, -0.09673990f, 0.04229792f, -0.06061956f, -0.06064661f, 0.05110301f, 
    0.00484650f, -0.06764270f, 0.00775043f, 0.03763020f, -0.22415400f, -0.01356085f, 0.18035816f, -0.00178480f, 
    0.04322321f, 0.01608718f, -0.09329766f, -0.00256666f, 0.08179641f, -0.06736739f, -0.11853790f, 0.01481659f, 
    -0.02051385f, -0.11903641f, -0.11318073f, 0.12731351f, -0.01533633f, 0.02743427f, -0.06443094f, 0.01512586f, 
    0.02106208f, -0.05479136f, -0.04869156f, 0.02777164f, 0.31665149f, 0.34127477f, 0.32609245f, 0.00952883f, 
    -0.08925857f, -0.07073427f, -0.05255536f, -0.01388537f, 0.12137207f, 0.01087033f, -0.04098365f, 0.06967618f, 
    -0.03379803f, -0.04371405f, 0.07723837f, 0.15538135f, 0.17006893f, -0.02205396f, 0.08214775f, 0.03652977f, 
    0.02501939f, -0.07868063f, 0.01593434f, -0.05767660f, 0.34423131f, 0.10591000f, 0.13836722f, -0.13953741f, 
    0.13024014f, 0.04217336f, -0.05996414f, 0.05583531f, 0.07778753f, 0.10679725f, 0.04854858f, 0.14186117f, 
    -0.16215244f, 0.07669152f, -0.03217465f, 0.05744858f, -0.14635977f, 0.09039138f, 0.09531344f, -0.24640881f, 
    0.01995508f, 0.02835325f, 0.01749107f, 0.03947765f, 0.16302203f, 0.01372720f, -0.02808152f, 0.14700262f, 
    0.01663998f, 0.07695412f, 0.02268889f, 0.17306760f, 0.20963977f, -0.09661891f, 0.05605332f, -0.28819621f, 
    0.21699122f, 0.03016189f, -0.01550380f, -0.01940054f, -0.06355739f, -0.00252289f, 0.00054275f, 0.03757871f, 
    -0.13622154f, -0.06373191f, -0.02576054f, 0.03836038f, 0.24550138f, -0.04676995f, 0.03310335f, 0.00607689f, 
    0.14609259f, -0.03511878f, 0.12818003f, 0.06854495f, -0.03621456f, 0.09364692f, 0.01552367f, -0.10165787f, 
    -0.06891535f, -0.02630318f, 0.12887964f, 0.21089172f, -0.04357796f, 0.01375651f, 0.17245297f, 0.01506842f, 
    -0.07763848f, 0.12214484f, -0.00819715f, 0.08153140f, 0.23961061f, 0.10402520f, 0.09030349f, 0.13857940f, 
    -0.01007304f, -0.05375792f, 0.00386384f, 0.11230917f, 0.35701892f, 0.09122165f, 0.02357480f, 0.04238039f, 
    0.13978425f, 0.02044224f, 0.04815999f, -0.08791192f, 0.03597280f, -0.00387873f, 0.03754595f, -0.01849547f, 
    0.07384380f, -0.04042281f, -0.13632762f, -0.18992549f, -0.13745542f, 0.18567787f, -0.04239785f, 0.05567615f, 
    0.13145317f, -0.12073714f, 0.10097930f, -0.08854724f, 0.01545822f, 0.08896357f, 0.01885733f, 0.09452518f, 
    0.07211760f, 0.05079461f, 0.03850303f, 0.06323674f, -0.08087472f, -0.02063772f, -0.03900413f, -0.03787166f, 
    0.25426653f, 0.19086410f, 0.11410315f, 0.20096360f, 0.11123785f, -0.17844905f, 0.16124608f, 0.05707475f, 
    0.10677839f, 0.04188511f, 0.10115642f, 0.08101201f, 0.01195648f, -0.10127237f, -0.14615029f, -0.13432431f, 
    0.08167965f, 0.08250248f, 0.02695566f, 0.08145048f, -0.01406320f, -0.06854384f, -0.04895063f, -0.03944512f, 
    0.02914700f, -0.03057072f, 0.08508611f, 0.02069050f, -0.10136384f, -0.16519691f, 0.03958970f, -0.21916594f, 
    0.03216276f, -0.02800063f, 0.13793091f, 0.25285149f, 0.08092847f, 0.28123102f, -0.04919538f, -0.00785235f, 
    -0.04299115f, -0.19121265f, 0.00198221f, 0.01309000f, 0.09523622f, 0.17327929f, 0.12904942f, -0.12366154f, 
    -0.15888950f, -0.13872752f, 0.00764142f, -0.08597166f, 0.07910067f, -0.01480377f, -0.18244521f, 0.02624348f, 
    0.26949188f, 0.02414674f, 0.06291591f, -0.08951485f, 0.04482580f, -0.03539681f, 0.01214591f, 0.01675276f, 
    0.39128906f, 0.09098768f, -0.07775519f, 0.06823602f, -0.02522073f, 0.17305709f, -0.02210260f, 0.21866912f, 
    0.14709318f, 0.01954162f, -0.07439869f, -0.20655489f, -0.24421714f, 0.06449816f, -0.00128780f, -0.11326079f, 
    -0.04734262f, 0.03665239f, 0.16396369f, 0.03456136f, 0.02470065f, 0.11885709f, -0.01578128f, -0.03508808f, 
    -0.23632631f, 0.04601568f, -0.26121262f, -0.15150003f, -0.21341337f, -0.00571311f, 0.13972603f, -0.00337343f, 
    0.01683297f, 0.03965418f, -0.07439400f, -0.12702890f, -0.08512411f, -0.26060790f, -0.07601628f, -0.27914685f, 
    0.11296263f, 0.02775243f, 0.01228611f, 0.03961684f, -0.03824625f, 0.00832033f, 0.02358594f, -0.00387118f, 
    -0.04040002f, 0.00374466f, 0.01832622f, -0.01652230f, 0.03887985f, 0.02584044f, -0.11724344f, -0.00427069f, 
    -0.09954037f, 0.04049137f, 0.21796373f, -0.00110724f, 0.14630443f, 0.20745683f, 0.12993236f, -0.04956056f, 
    -0.02959982f, -0.01876482f, -0.06866618f, -0.07328591f, -0.00407163f, -0.01242507f, -0.07467049f, 0.08757403f, 
    0.09147909f, 0.14590219f, -0.00681994f, 0.03163382f, -0.02232303f, -0.02958890f, -0.04639139f, -0.02985824f, 
    -0.14445454f, 0.03500721f, -0.02727869f, -0.00335047f, 0.09694138f, -0.07714580f, 0.12347608f, 0.04843951f, 
    0.04775428f, -0.04574691f, -0.07504922f, 0.05302092f, 0.04473371f, 0.11205787f, 0.06881382f, 0.13564287f, 
    -0.01774113f, 0.06369485f, 0.03227093f, 0.06047715f, -0.02851064f, 0.07313336f, -0.09472280f, 0.01424103f, 
    -0.00630668f, -0.02741324f, -0.04840825f, -0.07293277f, -0.17920966f, 0.21874271f, -0.17909931f, 0.25675935f, 
    0.14669271f, 0.04702337f, 0.15667009f, 0.01760035f, -0.04552890f, 0.05110477f, -0.03601578f, 0.08184549f, 
    -0.13470653f, 0.02929355f, -0.01423648f, -0.03039276f, 0.12622336f, 0.27481008f, -0.09768420f, 0.22824371f, 
    0.06561415f, 0.10128950f, -0.00333969f, 0.18378733f, 0.01776003f, 0.10492393f, 0.07244146f, 0.06902358f, 
    -0.01166152f, -0.00331097f, -0.03326146f, 0.07816026f, 0.00906095f, 0.15387674f, 0.10904410f, 0.27300870f, 
    -0.06511820f, -0.07374138f, 0.02499017f, 0.14675602f, 0.02818475f, -0.24431765f, 0.11615819f, 0.04519162f, 
    -0.04510840f, 0.01241760f, 0.15426050f, 0.03275542f, -0.68161720f, -0.02459985f, -0.12211905f, -0.14861019f, 
    -0.09257721f, 0.03095846f, -0.01774296f, 0.10641187f, 0.07487294f, 0.03317863f, 0.12329149f, -0.11941296f, 
    -0.01902339f, -0.00172368f, -0.14510374f, -0.23899350f, -0.05609975f, -0.10665872f, -0.04596727f, -0.02909182f, 
    0.00637492f, 0.10161838f, -0.01137500f, -0.01880746f, -0.06351738f, 0.07331990f, -0.26529527f, -0.18349700f, 
    0.14026161f, -0.00329375f, 0.06736369f, -0.04808519f, 0.08577582f, -0.18729739f, -0.08252133f, -0.17588127f, 
    -0.13267803f, -0.05746784f, -0.05684404f, -0.02028707f, 0.17212881f, -0.13027535f, -0.02008891f, 0.03469909f, 
    -0.11019136f, 0.03752161f, 0.01093510f, 0.06976596f, 0.00566024f, 0.20164935f, 0.11691368f, 0.15997852f, 
    0.06097231f, 0.01616625f, 0.03880770f, -0.05838647f, 0.04791676f, -0.04787055f, 0.03123541f, 0.13931310f, 
    -0.09219779f, -0.10275027f, 0.08308038f, -0.02609427f, -0.05633308f, -0.01059525f, -0.00873029f, -0.02387972f, 
    -0.11214833f, 0.05712819f, 0.07883281f, -0.24358343f, 0.05996576f, -0.08655281f, -0.16412890f, -0.05836194f, 
    0.06437461f, -0.14526823f, 0.17618479f, 0.27540690f, 0.10572556f, -0.04818935f, -0.00423826f, 0.01013336f, 
    0.55925494f, 0.16438954f, -0.15581007f, -0.02582969f, 0.07518483f, -0.02084020f, 0.03362384f, 0.19716085f, 
    0.09373595f, 0.14616591f, 0.19517310f, -0.10211307f, 0.19304225f, -0.03230994f, -0.01287294f, 0.03373199f, 
    0.00420827f, 0.02040608f, 0.04683747f, 0.00499891f, -0.05364131f, 0.03655615f, -0.01251647f, -0.08836064f, 
    -0.00514528f, 0.02711570f, -0.04310491f, 0.13021956f, 0.16444550f, -0.08414604f, 0.21679837f, -0.04388731f, 
    0.15650153f, 0.10499460f, 0.02528192f, 0.05269192f, -0.34465975f, 0.06198911f, 0.18032508f, -0.02575795f, 
    -0.15794905f, -0.01252478f, 0.03620177f, 0.02240152f, -0.14300729f, 0.14521593f, 0.03739331f, -0.00135688f, 
    -0.06743207f, -0.17999761f, -0.10855363f, -0.04982179f, 0.02479304f, 0.08532101f, 0.07278883f, 0.33651599f, 
    -0.10816029f, -0.05562965f, -0.15701948f, -0.09373334f, -0.27745253f, -0.08063050f, -0.00551260f, 0.15040416f, 
    -0.15892436f, 0.00581266f, -0.14818873f, 0.06863884f, 0.00873819f, -0.01834656f, -0.03080780f, -0.10337171f, 
    0.06002197f, -0.11720075f, -0.13199735f, -0.12355424f, -0.04811401f, -0.02532103f, 0.07663164f, 0.10544985f, 
    0.01500341f, 0.14573555f, 0.15837154f, 0.16457093f, 0.05437991f, 0.02471495f, -0.03456696f, -0.03480123f, 
    -0.01221178f, -0.03305610f, -0.00034541f, 0.08656748f, -0.06435367f, 0.08120625f, -0.20387152f, -0.07771627f, 
    -0.07091095f, -0.19811855f, 0.04925082f, 0.11322602f, 0.11184099f, -0.02893424f, -0.02798699f, 0.22999728f, 
    0.04506201f, 0.00243497f, 0.01110683f, 0.09182905f, 0.15599917f, -0.11934718f, 0.22327666f, 0.15501787f, 
    0.05652646f, 0.01590075f, 0.12078993f, 0.17104501f, -0.12773304f, 0.05985106f, 0.22561018f, 0.16513261f, 
    0.03558616f, -0.11592229f, 0.04604493f, 0.14590497f, 0.05206351f, 0.15770386f, -0.07912944f, -0.22179967f, 
    0.03790005f, 0.01982940f, -0.00936997f, 0.07042485f, -0.16657807f, 0.00996918f, 0.01361539f, 0.09516530f, 
    -0.12382073f, -0.17045759f, -0.00082437f, -0.00593550f, 0.13031478f, 0.13240708f, 0.20779805f, 0.14972492f, 
    0.13406162f, -0.06812096f, 0.19506022f, 0.01156566f, 0.02223394f, 0.06705835f, 0.08223463f, -0.00128658f, 
    0.05502185f, -0.03961243f, -0.03152263f, 0.01667748f, -0.07218432f, -0.03072061f, -0.01498213f, 0.00922758f, 
    -0.01168075f, 0.04495538f, 0.02444379f, 0.00784967f, 0.06629198f, 0.08937992f, 0.13222156f, 0.07816851f, 
    -0.02339939f, -0.04003079f, -0.05305672f, -0.10367905f, 0.00976908f, 0.07664299f, 0.13029182f, -0.18063565f, 
    -0.07738118f, -0.00877025f, -0.04900417f, 0.01892109f, -0.10908816f, 0.15148075f, -0.14481956f, -0.07035688f, 
    -0.04218835f, 0.00393038f, -0.04077614f, -0.01699614f, -0.13338581f, -0.16873479f, 0.07403871f, 0.00419515f, 
    -0.00152800f, -0.02499516f, 0.04862102f, -0.14487010f, 0.13993457f, -0.07116193f, 0.20936540f, 0.19462816f, 
    0.08920025f, -0.07092422f, 0.14231443f, -0.02268102f, 0.21245655f, 0.29391152f, -0.06090063f, 0.14344876f, 
    0.13905333f, 0.08221446f, 0.12474472f, -0.07183256f, -0.01199693f, 0.05889622f, 0.01727611f, 0.03006213f, 
    0.15866260f, 0.13351144f, -0.03338552f, -0.04658452f, 0.00048748f, -0.05792038f, -0.03931532f, 0.11037757f, 
    -0.07303657f, 0.16664794f, 0.03088735f, 0.01326927f, -0.35539824f, -0.20286824f, 0.00408190f, -0.14984603f, 
    -0.04648806f, 0.03284784f, -0.02095432f, 0.04687793f, 0.19328184f, 0.13307928f, 0.07554192f, -0.03481745f, 
    0.10119750f, -0.11765770f, 0.11338676f, 0.02568635f, -0.02309514f, 0.05293395f, 0.03416727f, 0.10354317f, 
    -0.07655326f, -0.04236045f, 0.03793038f, -0.23045039f, -0.17047025f, -0.07831220f, 0.06039054f, 0.12345813f, 
    -0.02748741f, -0.11695241f, -0.11971719f, -0.29836851f, -0.12906340f, -0.03700510f, -0.06158012f, -0.16794451f, 
    -0.00236720f, -0.06664119f, -0.03249362f, -0.15396030f, -0.12462696f, 0.16468698f, 0.00510038f, -0.08011277f, 
    0.07674654f, 0.11025529f, 0.01855922f, 0.09055495f, -0.02542852f, 0.00941700f, 0.08178297f, -0.05786586f, 
    0.01618391f, 0.03765605f, -0.07757219f, -0.03417724f, -0.04056433f, 0.04502376f, -0.02658597f, 0.09223899f, 
    0.16428851f, -0.00223041f, -0.04202825f, 0.08131369f, 0.02234593f, -0.03064570f, -0.03096307f, -0.09832963f, 
    0.03505582f, -0.02194711f, -0.01675615f, 0.08646171f, -0.15465136f, -0.01870189f, -0.08759810f, 0.02344356f, 
    0.04009761f, 0.09659096f, -0.06735308f, 0.15417898f, -0.01961203f, -0.02745597f, -0.14192219f, -0.19965214f, 
    0.07102013f, -0.01289587f, 0.03141069f, 0.01863685f, 0.02527893f, 0.03036963f, 0.15651739f, 0.05073931f, 
    -0.06179579f, -0.03776185f, 0.10138368f, 0.02316878f, -0.12397436f, -0.08253639f, -0.06569917f, 0.07508724f, 
    -0.10094294f, -0.00114262f, 0.09747041f, -0.20354213f, 0.05580102f, 0.09451284f, 0.06590012f, 0.08361750f, 
    0.00589363f, 0.00745378f, -0.00865795f, -0.03660208f, -0.03442693f, -0.03431052f, 0.02951143f, -0.03377585f, 
    -0.01264092f, -0.00209314f, 0.00334194f, 0.00418549f, -0.02244070f, 0.01367729f, -0.04137531f, 0.02927024f, 
    -0.03368516f, -0.00134395f, -0.02006076f, 0.02512636f, 0.00005254f, -0.02578616f, 0.01952307f, -0.03568606f, 
    -0.03284134f, -0.01013488f, -0.03537677f, 0.02430236f, -0.01590872f, -0.03855519f, 0.00262540f, -0.03678230f, 
    0.01005629f, -0.00415455f, 0.00550123f, -0.03386346f, 0.01129509f, -0.02566631f, -0.02441370f, 0.01650170f, 
    -0.01321507f, -0.01427680f, 0.01004187f, -0.01544578f, 0.01975544f, 0.01085873f, -0.00002964f, -0.02873049f, 
    0.02454757f, -0.02853227f, -0.04234704f, -0.02326517f, 0.00111041f, -0.01240055f, -0.00463078f, 0.02494998f, 
    -0.03840381f, 0.01988527f, 0.01249007f, -0.03952276f, 0.02506857f, 0.02126432f, 0.02105572f, -0.01651199f, 
    0.02766189f, -0.04111565f, 0.01285279f, -0.02967079f, 0.01335420f, 0.00861670f, 0.00784709f, -0.03995239f, 
    -0.03402704f, 0.01467698f, 0.02635778f, 0.01533443f, -0.01913189f, -0.01816276f, 0.00533557f, -0.03498759f, 
    0.01427734f, -0.00813898f, 0.02698538f, -0.01559087f, 0.02930922f, -0.02411885f, 0.01078471f, -0.02114126f, 
    -0.02519999f, -0.03474947f, -0.00927101f, -0.02821510f, 0.01140452f, -0.02048692f, 0.02660474f, -0.00769426f, 
    0.02402567f, 0.01366668f, -0.00217133f, -0.04042308f, -0.01472766f, -0.00048987f, -0.03127879f, 0.02740895f, 
    -0.00333238f, -0.02562040f, 0.00717902f, -0.00642275f, 0.01371663f, -0.04111395f, -0.02104748f, 0.01276454f, 
    0.00630915f, -0.02965615f, 0.01671947f, -0.00743988f, -0.03490639f, -0.01379476f, -0.01538443f, 0.00192091f, 
    -0.00710687f, -0.00850459f, -0.03158383f, 0.02880603f, -0.03781452f, 0.00782285f, -0.04068429f, 0.02788849f, 
    -0.03675207f, 0.02203801f, -0.02149823f, -0.02781027f, -0.01801856f, -0.02645937f, 0.02509838f, 0.01885853f, 
    -0.04148372f, 0.00332266f, 0.01967141f, 0.00797025f, -0.00358928f, -0.01726389f, 0.00926507f, -0.03011664f, 
    -0.01392432f, -0.01536204f, -0.02854267f, -0.02521031f, 0.02004847f, 0.01586253f, -0.03028114f, -0.00783631f, 
    0.01515587f, 0.00111635f, -0.03722458f, -0.03892231f, -0.00388853f, -0.02149904f, -0.01636064f, -0.04114407f, 
    0.00571700f, -0.03314257f, 0.01253193f, -0.04033187f, -0.01775907f, 0.01044413f, -0.03957681f, 0.00323794f, 
    -0.01521793f, -0.01112999f, -0.03560603f, 0.02029710f, -0.02771723f, 0.02609301f, -0.02293434f, 0.00735055f, 
    -0.01060698f, 0.00893092f, 0.00327920f, -0.00645729f, -0.03846242f, -0.01168111f, 0.00166825f, -0.03185071f, 
    -0.00537887f, -0.01413338f, 0.02796693f, -0.01709128f, 0.02946421f, -0.00560512f, 0.00679332f, 0.01535473f, 
    0.00009333f, -0.01926159f, -0.02926508f, -0.00341950f, -0.02416795f, -0.03979313f, -0.02465091f, 0.00412579f, 
    0.01348654f, 0.01026561f, 0.02328675f, -0.01397278f, -0.01680484f, 0.00236195f, -0.02446525f, -0.02551348f, 
    0.01318726f, -0.02400576f, -0.02247571f, -0.01296809f, 0.02227944f, 0.01097859f, -0.00431040f, -0.03808394f, 
    0.01809407f, -0.01959231f, 0.02702998f, -0.01103586f, -0.01277525f, 0.01144751f, 0.01299138f, -0.01192973f, 
    0.00343883f, -0.02088335f, -0.03709782f, -0.02978753f, -0.00752487f, 0.02706972f, 0.01406834f, -0.01814156f, 
    0.02925256f, -0.00506676f, -0.01269074f, 0.01443650f, -0.01217644f, 0.01669859f, -0.02709890f, 0.02685124f, 
    0.00778601f, 0.02396863f, -0.02492337f, 0.00194087f, 0.00336912f, -0.00492098f, -0.02618024f, 0.00702827f, 
    -0.03248884f, 0.02185969f, -0.01514468f, -0.03992518f, 0.00380059f, -0.01307914f, 0.00115723f, 0.02084111f, 
    0.00697423f, -0.00882386f, -0.00457786f, -0.02292681f, -0.01487629f, -0.03208760f, 0.01132011f, -0.01713217f, 
    -0.03001303f, -0.01932525f, -0.01848551f, 0.02149293f, -0.00010422f, 0.00849028f, 0.00696966f, 0.01674448f, 
    -0.02963317f, 0.00917473f, -0.01679961f, 0.00656055f, 0.02722367f, 0.03104613f, -0.01978876f, 0.00524630f, 
    -0.01061965f, -0.03532713f, -0.00729978f, 0.00022731f, -0.02188692f, -0.00458695f, 0.01298090f, 0.02850860f, 
    -0.00451979f, -0.01379427f, -0.03913566f, -0.00976790f, 0.00673804f, -0.01467513f, -0.03602037f, 0.00077801f, 
    -0.00372657f, -0.02619274f, -0.02265461f, 0.00483238f, 0.02396383f, 0.01461624f, -0.02580838f, -0.02693658f, 
    -0.03711240f, 0.03033836f, 0.01327626f, -0.00129424f, -0.03369155f, 0.00636405f, 0.02678183f, -0.00112020f, 
    -0.03937731f, 0.03158994f, 0.02624254f, 0.00068742f, -0.00940195f, -0.03695709f, 0.01212065f, 0.02232659f, 
    -0.02819458f, 0.01686651f, -0.03263850f, 0.01431641f, 0.00154413f, 0.00024033f, 0.02830578f, -0.03713032f, 
    0.00326819f, -0.01092170f, -0.02809088f, 0.00823401f, -0.01981398f, -0.00957808f, 0.00642640f, 0.00525668f, 
    -0.00303620f, 0.02770052f, -0.02582510f, 0.01517921f, -0.04031945f, 0.02102401f, -0.03654665f, 0.02923169f, 
    0.00862421f, 0.02317176f, -0.03190632f, 0.00952325f, -0.01294313f, 0.00520360f, 0.01709912f, 0.00825249f, 
    -0.00032253f, 0.00718550f, -0.00416375f, 0.02837721f, -0.00405882f, -0.01674706f, -0.01604326f, -0.02675153f, 
    -0.04183471f, -0.01067526f, 0.00700615f, -0.02702516f, -0.00284317f, -0.03286861f, -0.00349406f, -0.02032269f, 
    0.01304828f, -0.04001433f, 0.00685196f, -0.03532549f, -0.00460805f, 0.00257115f, -0.03458623f, 0.01296533f, 
    -0.03279634f, 0.02745780f, -0.02407713f, -0.03107421f, -0.02541142f, 0.01731971f, 0.00592855f, -0.03599594f, 
    -0.00327690f, -0.03219835f, 0.00297142f, -0.00114159f, -0.04105045f, -0.01594669f, 0.01249668f, -0.02990659f, 
    0.00211770f, 0.01403983f, 0.00978897f, -0.01898236f, -0.03861497f, -0.00677058f, -0.00684016f, -0.00951405f, 
    0.01962644f, 0.02255352f, 0.02896195f, -0.03231113f, 0.01903672f, 0.02854462f, -0.00687968f, -0.01899793f, 
    -0.03561547f, -0.03255832f, 0.01047129f, 0.01099783f, 0.00449105f, -0.01807184f, 0.00603727f, 0.01684413f, 
    -0.00080105f, -0.02225038f, 0.00688407f, -0.02476344f, -0.04038386f, -0.03211357f, 0.02761349f, 0.03103126f, 
    -0.01422550f, 0.00905274f, 0.00437425f, -0.00137061f, 0.00950259f, -0.03368713f, -0.01598407f, -0.03041906f, 
    0.00940738f, -0.04178471f, -0.03806846f, -0.02616259f, 0.01985698f, 0.01401451f, 0.00300160f, 0.02893434f, 
    -0.03923312f, -0.02296519f, -0.03811166f, -0.03484782f, 0.00075560f, 0.01968619f, 0.02665116f, -0.03413894f, 
    0.00598144f, -0.02708067f, -0.03198573f, -0.02992413f, 0.00283702f, 0.02707834f, 0.00908530f, 0.00154188f, 
    -0.02687566f, 0.00707713f, -0.01022099f, -0.01403870f, 0.00265953f, 0.01121894f, -0.03052616f, -0.00257179f, 
    -0.00381421f, -0.01848732f, -0.01891017f, 0.00689953f, -0.03288877f, -0.00079428f, -0.02692569f, -0.04209743f, 
    0.03070322f, -0.03526327f, -0.02446106f, -0.00258778f, -0.03685221f, -0.04007437f, -0.01907397f, 0.00595846f, 
    -0.03480602f, 0.02467390f, -0.00904478f, -0.02643624f, 0.01260317f, 0.00040392f, -0.00107429f, -0.01704518f, 
    -0.03561221f, -0.03880741f, -0.02027269f, -0.00785057f, -0.01109234f, -0.03701051f, -0.00054969f, 0.00220653f, 
    0.01605489f, 0.01236100f, -0.03662869f, -0.03291478f, 0.02488514f, -0.03166874f, -0.02872206f, 0.02696110f, 
    -0.00787714f, -0.00634985f, -0.03212023f, 0.01448497f, -0.03663669f, -0.00316841f, 0.02615046f, 0.02927466f, 
    0.02230368f, -0.02096981f, -0.02413572f, 0.02275658f, 0.00988936f, -0.03849500f, -0.03425253f, 0.01739592f, 
    -0.03221712f, -0.02049222f, -0.00737324f, -0.01804233f, -0.03875823f, -0.02598555f, 0.01640203f, 0.02803952f, 
    -0.03077077f, -0.03234623f, 0.01826793f, 0.01796762f, 0.02073001f, -0.01595527f, 0.01617910f, 0.00460155f, 
    -0.02036172f, -0.03369100f, 0.02674967f, 0.00399744f, 0.01016210f, 0.02590501f, 0.01526090f, 0.00567087f, 
    0.01545274f, -0.00601645f, -0.01162388f, 0.00628987f, 0.00055008f, -0.01210576f, 0.01918346f, -0.04097680f, 
    0.00991190f, -0.03567506f, 0.00154867f, 0.00064547f, 0.02523556f, 0.00049539f, -0.03968871f, -0.01359992f, 
    -0.03896545f, 0.01377987f, -0.00802846f, -0.03429003f, -0.01505380f, 0.01405473f, 0.01797362f, -0.02798948f, 
    -0.00507782f, -0.03713587f, -0.00458664f, 0.02607019f, -0.03428355f, -0.01292022f, -0.00924430f, -0.02941821f, 
    0.02646977f, -0.04082786f, 0.00809258f, 0.02094660f, 0.00960222f, -0.03152958f, 0.02351734f, -0.03519528f, 
    0.02872355f, -0.00167079f, -0.04024448f, -0.03874431f, 0.02325925f, -0.04024621f, -0.02764659f, -0.03315924f, 
    0.02081221f, -0.02032312f, 0.01027861f, -0.02174682f, 0.01605363f, 0.02975322f, -0.02971084f, -0.02740019f, 
    -0.00291123f, -0.02474446f, 0.02683837f, -0.00878369f, -0.02545693f, -0.02267156f, -0.01472285f, 0.00432099f, 
    -0.03662122f, 0.01439923f, -0.01193677f, 0.01557887f, -0.02846147f, -0.02346567f, -0.02361504f, 0.00484362f, 
    -0.01956889f, -0.02375123f, 0.01380560f, -0.01906000f, 0.00411642f, 0.01425974f, 0.01291784f, -0.03119807f, 
    0.02746762f, 0.01607418f, -0.02606462f, -0.02880908f, -0.00366449f, -0.02326322f, 0.01226933f, -0.01834833f, 
    -0.03951946f, -0.04234561f, 0.02489332f, 0.01852740f, -0.01608158f, 0.01107429f, -0.03213958f, 0.02310123f, 
    0.02917268f, 0.01214587f, -0.01280670f, -0.01595696f, -0.01409911f, 0.01445421f, 0.00572191f, -0.01488453f, 
    0.00197040f, 0.01024590f, 0.00978682f, -0.01974066f, -0.00632274f, 0.00003497f, -0.03092111f, -0.01528214f, 
    0.02393820f, -0.01167111f, -0.01257740f, -0.01782692f, -0.01959289f, -0.01685486f, -0.01871436f, 0.00413349f, 
    -0.02548693f, 0.00175693f, -0.01175037f, -0.02021344f, -0.03628058f, -0.00960355f, 0.00188076f, -0.03742670f, 
    0.03361122f, 0.00826535f, 0.00462490f, 0.02293592f, -0.03714903f, -0.02775394f, 0.02655624f, 0.00476494f, 
    -0.02577062f, -0.03378327f, -0.02200272f, -0.03329971f, -0.01594771f, -0.02317946f, 0.00649563f, 0.02249252f, 
    -0.03811154f, 0.01782833f, 0.01351795f, -0.03259104f, 0.01481148f, 0.00087247f, -0.02133815f, 0.01256377f, 
    0.01404100f, -0.03702533f, 0.02588141f, -0.03696195f, -0.00664045f, -0.04064906f, 0.00829601f, 0.00231679f, 
    -0.03464270f, -0.00190292f, 0.00707080f, -0.01657009f, -0.02657384f, 0.01901137f, -0.00565204f, 0.02789161f, 
    -0.01897102f, -0.03761117f, -0.02754470f, 0.01646890f, 0.02660567f, -0.00811173f, -0.02810738f, -0.02300348f, 
    0.01327285f, 0.00965745f, -0.00987566f, -0.00692635f, -0.02269635f, -0.03911364f, 0.02788426f, -0.01619689f, 
    -0.01108710f, 0.00637254f, -0.00137392f, -0.03993494f, 0.00731206f, -0.03957241f, -0.00641276f, -0.01072705f, 
    -0.01297025f, -0.02761861f, -0.00167225f, -0.02677294f, -0.02810260f, -0.01936906f, 0.01481737f, -0.01224944f, 
    -0.03604407f, 0.01852953f, 0.01641561f, -0.03673669f, 0.00257122f, -0.01720264f, -0.00985694f, -0.03787853f, 
    0.02490769f, 0.02617163f, -0.03018570f, 0.01858010f, -0.01597696f, -0.00532585f, -0.00803204f, -0.02920748f, 
    -0.03306541f, 0.02612698f, -0.00279807f, 0.02805626f, -0.02185128f, 0.02445348f, -0.02523118f, -0.01372307f, 
    -0.21879528f, 0.18083194f, 0.02727734f, 0.00949486f, 0.01249417f, 0.09360848f, 0.10984179f, 0.00413009f, 
    0.13539992f, 0.09010132f, -0.03984616f, -0.07397967f, -0.14406826f, 0.27778345f, 0.02057261f, 0.09027348f, 
    -0.04434303f, -0.12395591f, 0.00713430f, 0.06263168f, 0.07127704f, 0.10965850f, 0.04811217f, -0.05993108f, 
    -0.16141860f, -0.21158439f, -0.03328810f, -0.05578423f, -0.11881631f, -0.01740930f, -0.04955177f, 0.11398353f, 
    0.03339894f, -0.07903346f, 0.01237453f, -0.03947768f, 0.18868858f, 0.00409139f, 0.02120539f, -0.07540324f, 
    0.12874566f, 0.12066720f, 0.03224790f, 0.06569745f, -0.01035995f, 0.03666129f, 0.09365715f, 0.00917722f, 
    0.05933348f, 0.20340790f, -0.13044687f, -0.04987700f, -0.04782972f, -0.01944849f, 0.01643847f, 0.06820685f, 
    0.01344454f, 0.01174980f, -0.10412869f, 0.02796827f, 0.04083052f, 0.01744848f, 0.10928670f, -0.05604016f, 
    0.03722749f, 0.16751385f, 0.09276915f, 0.01973194f, 0.09976729f, 0.04887398f, 0.04117407f, 0.11281931f, 
    0.00702595f, 0.17492473f, 0.10591365f, -0.07034590f, 0.01963980f, -0.04352573f, 0.08958620f, 0.11849563f, 
    -0.02627698f, -0.02058806f, 0.11007912f, 0.04632167f, 0.12579203f, 0.14990596f, 0.20666254f, -0.07414526f, 
    -0.02317771f, -0.02169976f, 0.13082244f, -0.01885358f, 0.02142565f, 0.07438195f, 0.03874938f, 0.08084788f, 
    0.11434922f, 0.03914013f, 0.16363004f, -0.04943549f, -0.00902687f, -0.03391336f, 0.00322125f, -0.03067340f, 
    -0.00526972f, -0.03790009f, -0.02791252f, 0.09371063f, -0.18235046f, 0.09247766f, -0.09759514f, 0.04280489f, 
    0.15875700f, 0.03740292f, 0.01176513f, 0.00483358f, -0.02352272f, -0.00956804f, -0.04415775f, -0.05579624f, 
    0.12436055f, 0.09062850f, 0.12689899f, 0.10969483f, -0.09427401f, -0.02968142f, -0.04757466f, -0.09215519f, 
    0.11109056f, 0.08420685f, 0.03538511f, 0.08025414f, -0.01667013f, -0.09072524f, -0.04149995f, -0.05665888f, 
    -0.07688496f, -0.06943619f, 0.07422762f, 0.06233818f, 0.05125283f, -0.12063248f, -0.00307660f, 0.01817115f, 
    -0.00275814f, 0.00070648f, -0.05542943f, -0.00318306f, -0.00069705f, 0.00270258f, -0.01619424f, -0.08193973f, 
    -0.04169345f, 0.02740920f, 0.01543330f, 0.00993548f, -0.17291850f, 0.11234640f, 0.12412280f, -0.12144277f, 
    -0.03740655f, 0.04274727f, 0.13744086f, 0.10891888f, -0.04043616f, -0.01638524f, -0.08800000f, 0.02827744f, 
    -0.10674863f, -0.03612821f, -0.20408349f, -0.21483298f, 0.17265153f, 0.10068212f, 0.26322871f, -0.12644340f, 
    -0.13517021f, -0.05445197f, -0.09881783f, 0.01507793f, -0.03636608f, 0.18444960f, -0.01461314f, -0.08358091f, 
    0.10690378f, -0.11578930f, 0.07897597f, 0.10615156f, -0.03557561f, 0.01583620f, 0.02302343f, -0.04605630f, 
    0.24351624f, 0.05508224f, 0.18554923f, -0.13114779f, 0.03228993f, -0.17481567f, 0.16793925f, 0.12464165f, 
    0.04143078f, 0.04404531f, 0.20915681f, -0.09605225f, -0.05010789f, 0.09298197f, 0.04464227f, 0.01964934f, 
    0.03224481f, 0.03280816f, -0.00449175f, 0.16035685f, -0.04286505f, -0.04348338f, -0.03027408f, -0.08865707f, 
    -0.06049055f, 0.25388208f, 0.13083804f, 0.29541072f, 0.05741994f, -0.05616400f, 0.10923605f, 0.22103609f, 
    0.02727309f, 0.01722023f, -0.04997507f, -0.08441775f, -0.09564552f, 0.02257888f, 0.01358470f, -0.13542402f, 
    -0.02336383f, -0.00129931f, 0.00246337f, -0.03039720f, -0.02812296f, 0.03388748f, 0.01390526f, 0.07500917f, 
    -0.02154100f, -0.01395914f, -0.02059485f, 0.11800231f, 0.14562415f, 0.03090664f, -0.01350564f, 0.11117587f, 
    0.00390786f, 0.06454815f, 0.03256604f, 0.01321397f, 0.11035234f, 0.22516382f, -0.04151915f, 0.20329919f, 
    -0.00526612f, 0.00521201f, -0.01321129f, -0.00704511f, 0.03177272f, -0.10067193f, -0.04843840f, 0.06365571f, 
    0.05549548f, 0.00953552f, -0.00465420f, -0.04574953f, -0.04372533f, 0.00052838f, -0.02314927f, -0.05011792f, 
    -0.04008150f, 0.02645597f, -0.03321651f, -0.00453400f, -0.19007869f, 0.05503848f, -0.17109537f, 0.24305837f, 
    0.11250770f, -0.00266210f, 0.12596770f, -0.03473103f, -0.05099345f, 0.08420054f, 0.02921847f, -0.02433215f, 
    0.08106339f, -0.02734137f, -0.07034169f, 0.06215783f, -0.01372634f, 0.00790179f, -0.00420446f, -0.01668260f, 
    -0.06980876f, 0.00167965f, -0.02109564f, 0.07981384f, -0.03330279f, -0.55293274f, 0.21416213f, -0.26168618f, 
    0.14533551f, 0.19833918f, 0.13793670f, 0.28534436f, 0.02663744f, 0.01363705f, 0.00156034f, -0.00384693f, 
    0.04143349f, 0.00866743f, -0.01131160f, -0.01360372f, -0.02691699f, -0.00847038f, 0.00859492f, 0.26493034f, 
    0.06631161f, 0.08343803f, 0.03027651f, 0.04438858f, 0.05631762f, 0.21820755f, 0.05786737f, 0.11275989f, 
    -0.05707356f, 0.02289972f, 0.01445474f, 0.09818824f, 0.04760968f, -0.05760538f, 0.04841925f, -0.05652762f, 
    -0.05609127f, -0.04017828f, 0.03003450f, -0.06768471f, 0.04643416f, 0.02725552f, -0.05943918f, 0.14640406f, 
    -0.03278340f, 0.01338872f, 0.05977378f, 0.08517725f, 0.29136503f, 0.27705157f, 0.19833928f, 0.04223891f, 
    -0.06689207f, 0.00173060f, -0.10173488f, -0.14226709f, 0.04493211f, 0.02991206f, 0.13997522f, 0.17132293f, 
    -0.16748004f, -0.06512380f, -0.20282729f, 0.05589722f, 0.13927400f, 0.03844061f, -0.01244210f, 0.02456760f, 
    0.04807512f, 0.00256930f, -0.01263926f, -0.06760755f, 0.03665651f, 0.13746251f, -0.02219465f, -0.16670951f, 
    0.05191611f, -0.08157293f, 0.14746350f, 0.17008974f, -0.02466172f, 0.04714070f, 0.05451604f, -0.17117693f, 
    -0.00785574f, 0.04858436f, -0.09099572f, -0.01610268f, -0.10479055f, -0.01605905f, 0.04001984f, 0.08096475f, 
    -0.10116360f, -0.04346557f, 0.03821447f, -0.01976566f, 0.01115885f, 0.11228286f, -0.18169291f, -0.10675726f, 
    -0.03895274f, -0.01464505f, -0.00811684f, 0.00817777f, 0.08050078f, 0.06386655f, 0.00837135f, -0.13673367f, 
    -0.24368764f, 0.25082818f, 0.04722809f, 0.17867076f, -0.06277638f, 0.01511456f, -0.10408147f, -0.03705820f, 
    0.10691524f, -0.01585185f, -0.07701892f, 0.03180173f, -0.10576473f, 0.07620886f, -0.03594271f, -0.12925243f, 
    0.05496980f, -0.04115939f, 0.11722901f, 0.01351608f, 0.08917528f, 0.08502028f, 0.04122561f, 0.04029920f, 
    -0.27834946f, 0.08254932f, 0.30987960f, -0.10364757f, 0.01531868f, -0.11113142f, -0.09017394f, -0.06543487f, 
    0.16734278f, -0.00430615f, 0.10144851f, -0.02839529f, -0.07174704f, -0.01268816f, -0.04412128f, 0.08189783f, 
    0.09696572f, 0.09553913f, 0.02701969f, 0.09062231f, -0.04962283f, -0.05933212f, -0.03643616f, 0.12836361f, 
    0.01068303f, -0.12269721f, -0.04458866f, 0.10850623f, -0.07197209f, 0.09744946f, 0.05903704f, 0.07487392f, 
    0.09065091f, 0.01772104f, 0.02356946f, -0.14605579f, 0.15699747f, 0.16736805f, 0.06553212f, 0.16080499f, 
    0.05494880f, 0.02693472f, -0.02945921f, -0.00569495f, -0.08897544f, -0.01546809f, 0.10034663f, 0.04809825f, 
    -0.14207958f, 0.07967354f, 0.12774155f, -0.10278895f, 0.15656732f, -0.00734873f, 0.09102592f, 0.01926177f, 
    -0.00953775f, 0.09023090f, -0.00805597f, 0.05409730f, -0.47736681f, 0.05030607f, 0.05557242f, -0.24296860f, 
    -0.06165480f, 0.17929192f, 0.25670809f, -0.06235321f, 0.00412271f, 0.01352625f, -0.10879252f, -0.14622062f, 
    -0.12555629f, 0.06214203f, 0.05042160f, 0.00515003f, 0.07255138f, 0.04468710f, 0.11641496f, -0.23774368f, 
    0.05084151f, 0.00738221f, 0.00651521f, 0.03604915f, -0.01129589f, 0.15076232f, 0.06710390f, -0.01432358f, 
    -0.00840489f, 0.04598850f, 0.00871489f, -0.02489263f, 0.02487316f, -0.03328889f, -0.08031548f, -0.09033027f, 
    -0.07137481f, 0.23014480f, -0.02166629f, -0.02554427f, 0.04261112f, 0.09300904f, 0.01823700f, 0.17378075f, 
    0.10729360f, 0.12769812f, 0.12582925f, 0.00901837f, -0.00544131f, 0.19322056f, 0.01818251f, 0.06409762f, 
    0.07180154f, -0.03868703f, -0.00029079f, 0.09299858f, 0.15865679f, 0.00267830f, 0.14200073f, 0.11077122f, 
    -0.12212120f, -0.01832971f, -0.08285375f, -0.08520232f, -0.08343124f, -0.08533994f, -0.01881773f, 0.09366991f, 
    0.02751291f, -0.05384246f, -0.04246743f, -0.04237208f, 0.03812124f, 0.06222492f, 0.03804110f, -0.01022522f, 
    -0.06827065f, -0.01121148f, -0.05621004f, -0.01783991f, 0.01457966f, 0.01860447f, -0.04555074f, -0.14900964f, 
    -0.17052864f, 0.08905819f, 0.03164339f, -0.15032355f, 0.09756575f, 0.17101355f, 0.02226916f, -0.01315549f, 
    -0.01238884f, 0.05552672f, 0.00624404f, 0.09952876f, -0.00368170f, -0.00951468f, 0.00582008f, -0.05401977f, 
    -0.09066193f, 0.06750386f, 0.05324106f, 0.00158687f, 0.05324354f, 0.01166606f, 0.11070536f, -0.01236481f, 
    -0.04908131f, 0.00123826f, -0.22132216f, -0.20282848f, 0.08113398f, 0.02671564f, 0.25557247f, 0.10149670f, 
    -0.06634434f, -0.01484498f, -0.04982650f, -0.00484115f, 0.03814262f, 0.15243730f, 0.00203065f, 0.03021258f, 
    -0.04840340f, -0.13326257f, 0.00538214f, 0.01398413f, 0.00719969f, 0.00546265f, -0.01836990f, 0.04955562f, 
    0.20732780f, -0.14853723f, 0.25848016f, 0.33004695f, 0.08017220f, 0.06310397f, 0.05366907f, 0.00248275f, 
    0.16644579f, 0.05975584f, 0.07739062f, -0.14215896f, 0.33425921f, -0.20493957f, 0.13334478f, -0.17179544f, 
    -0.02527128f, 0.10366996f, -0.03036757f, 0.19091816f, 0.05965175f, 0.02765565f, -0.08043859f, 0.07835224f, 
    -0.06450846f, 0.01066053f, -0.07713994f, 0.08099625f, 0.07431994f, 0.02688328f, 0.11160585f, -0.09820950f, 
    0.04898568f, -0.02833344f, -0.05103841f, 0.10472410f, 0.40016931f, 0.28445935f, 0.10460858f, 0.21712624f, 
    -0.09896070f, -0.07281718f, -0.06255542f, -0.12523855f, 0.06367378f, 0.08721448f, 0.13007943f, 0.02472466f, 
    -0.07251985f, 0.14006504f, -0.28954872f, 0.07592223f, 0.05478411f, -0.02833743f, 0.03292147f, -0.01077482f, 
    -0.13020615f, -0.04832780f, -0.03875218f, -0.04617932f, 0.12079237f, -0.07578535f, 0.04683410f, -0.12085444f, 
    -0.15967998f, -0.03855514f, -0.13570763f, 0.12882900f, 0.13224372f, -0.02419217f, -0.10136810f, -0.10662640f, 
    -0.16778116f, 0.06992483f, 0.00562582f, -0.10749067f, 0.09724092f, -0.03085446f, 0.07817056f, 0.12937334f, 
    -0.03617168f, 0.03610612f, 0.01839171f, -0.04234495f, -0.18478990f, -0.00279503f, -0.14952476f, -0.07493342f, 
    0.06517536f, 0.00069705f, 0.11043289f, -0.01722147f, -0.03449059f, 0.02625901f, -0.00800623f, 0.00474996f, 
    0.22589169f, -0.05015076f, -0.02698035f, -0.12491538f, -0.01017104f, 0.05076780f, 0.09060574f, 0.00892091f, 
    0.02287992f, -0.00740469f, 0.03914792f, -0.03861362f, -0.14687641f, 0.17968798f, -0.09976538f, 0.01329144f, 
    0.12795688f, 0.03530654f, 0.03611556f, 0.01771768f, 0.17280677f, 0.04374623f, -0.10682784f, 0.07132346f, 
    -0.09309152f, 0.04631293f, -0.03135367f, 0.01895457f, 0.04734072f, 0.02208420f, 0.09911085f, 0.09696501f, 
    -0.01301862f, -0.02383650f, 0.00460072f, 0.09006662f, -0.24402083f, -0.08105899f, 0.03735682f, 0.05388793f, 
    -0.05639071f, 0.02049442f, 0.03717152f, -0.04475473f, 0.02571473f, -0.03466301f, 0.02489328f, -0.01498392f, 
    0.10952927f, -0.08670201f, -0.20886625f, 0.09236761f, 0.09610426f, 0.07335287f, 0.03557429f, 0.12443861f, 
    0.05375906f, -0.01352076f, 0.01267309f, 0.09076790f, 0.02227019f, 0.00566302f, 0.07507657f, 0.01712973f, 
    0.21796222f, 0.11016766f, 0.15659559f, -0.05144762f, 0.07545023f, 0.09367192f, 0.12302712f, 0.25493172f, 
    -0.19850889f, -0.20793369f, 0.09799396f, -0.04404795f, 0.16391459f, -0.06307635f, 0.02758820f, 0.09684862f, 
    -0.05491639f, 0.06734684f, -0.04637874f, -0.02554582f, -0.06815856f, -0.21892488f, 0.11522950f, 0.14404565f, 
    0.05066394f, -0.01614553f, 0.12091497f, 0.15895751f, 0.09093826f, 0.07822649f, 0.06135283f, 0.09886486f, 
    0.02332602f, 0.04262044f, -0.00946974f, -0.14661737f, -0.02650324f, 0.02871837f, 0.07261662f, -0.06918862f, 
    -0.08722527f, 0.01436242f, -0.03992259f, 0.07278847f, 0.08513672f, 0.19469723f, -0.33775455f, 0.07792995f, 
    0.02459453f, -0.00137733f, 0.12345020f, 0.14062998f, 0.08379477f, 0.11254533f, 0.05761121f, -0.00441983f, 
    -0.13388662f, -0.03465676f, -0.06584228f, 0.14591296f, 0.09647933f, -0.05064593f, -0.01105628f, 0.00861902f, 
    0.09628493f, 0.01421013f, -0.01223529f, 0.10437903f, 0.06757264f, 0.27068633f, 0.17233814f, -0.10892817f, 
    0.01300273f, -0.03268740f, -0.11600044f, -0.06403528f, 0.06306344f, 0.18365921f, 0.10619145f, -0.00083587f, 
    -0.14723012f, 0.22994508f, 0.16039649f, -0.08657182f, 0.02963834f, 0.07849628f, 0.04643689f, -0.03425618f, 
    0.17746016f, 0.17758675f, 0.25778317f, 0.08789041f, -0.07759720f, -0.16292414f, -0.06008241f, 0.05864395f, 
    0.10574852f, -0.24624036f, -0.02636213f, 0.02627138f, -0.00438371f, -0.00762836f, -0.02655456f, 0.00886958f, 
    -0.15252575f, 0.07297689f, 0.01584465f, 0.02817470f, -0.04379317f, 0.00148907f, -0.07353210f, -0.03836957f, 
    0.06235713f, -0.03546525f, 0.08400983f, -0.01602219f, -0.11140602f, 0.26619846f, 0.09881523f, -0.05451876f, 
    -0.02003897f, 0.10610507f, 0.11877144f, -0.02259799f, 0.04344155f, 0.14129417f, 0.22079092f, 0.07493879f, 
    -0.03361699f, -0.16316527f, -0.03349521f, 0.12634537f, 0.02419669f, -0.01075406f, -0.07659911f, -0.01645700f, 
    -0.08015055f, 0.01946057f, 0.04554668f, -0.09720598f, -0.16141754f, 0.03366250f, -0.09526356f, -0.11250667f, 
    0.01153487f, -0.10379586f, -0.07948212f, -0.13126162f, 0.09102497f, 0.03853103f, 0.12605911f, -0.05954083f, 
    0.22569874f, -0.13495648f, -0.26070169f, -0.04634327f, 0.05814734f, 0.10879508f, 0.09830608f, 0.16943015f, 
    0.00510656f, -0.06846139f, 0.06705920f, 0.01643212f, -0.09226713f, -0.10108727f, -0.14977105f, 0.13523471f, 
    0.15157947f, 0.00926469f, 0.07397035f, -0.08373209f, 0.01842488f, -0.00614947f, -0.02300966f, 0.01935583f, 
    0.10788532f, 0.11880102f, -0.01958157f, -0.14453152f, -0.10516539f, 0.16403182f, 0.09304297f, -0.09668390f, 
    0.08892168f, 0.00565136f, 0.20682159f, 0.09860855f, -0.17777944f, -0.22227339f, 0.06117866f, -0.04633004f, 
    -0.07192652f, -0.18625474f, -0.02821567f, 0.04387154f, 0.04447293f, -0.03543545f, -0.01327830f, 0.04434457f, 
    -0.02730678f, -0.29997030f, 0.09164961f, 0.15401517f, -0.02488517f, -0.12388761f, -0.10519772f, 0.07105335f, 
    0.05552262f, -0.08868936f, 0.07419836f, -0.02802324f, -0.02183754f, 0.07224311f, 0.00422743f, -0.02579678f, 
    0.02454632f, 0.03016149f, 0.06664730f, -0.06118212f, 0.10000739f, -0.04307644f, -0.05496469f, -0.07034902f, 
    0.07685211f, 0.02176565f, -0.05436521f, 0.07697289f, 0.00753717f, 0.00320511f, 0.05435283f, 0.02436828f, 
    0.11089267f, 0.01469936f, 0.00716367f, -0.08628332f, -0.08428445f, -0.09989921f, 0.03849555f, -0.08700385f, 
    0.03739125f, -0.03232362f, 0.03285453f, -0.08184537f, 0.03019300f, 0.07114486f, 0.04270292f, -0.04063008f, 
    0.00817731f, -0.07689220f, -0.00267467f, -0.10478074f, -0.01313049f, -0.02691244f, -0.03737479f, -0.00493646f, 
    -0.04534531f, -0.08477931f, -0.03652672f, -0.10006649f, -0.02109656f, 0.06878160f, -0.05488250f, 0.07500345f, 
    0.12139843f, 0.05150243f, -0.14152378f, -0.01439382f, -0.00769431f, -0.01360808f, -0.03061173f, 0.02475814f, 
    -0.01615939f, -0.03835206f, -0.07764290f, -0.14063415f, 0.03318758f, 0.05524122f, 0.03016182f, -0.05651239f, 
    -0.01503002f, -0.01549922f, 0.04981503f, -0.01962860f, -0.11345944f, -0.17909062f, 0.14151543f, -0.11330619f, 
    0.18850411f, -0.01347147f, 0.02888681f, 0.12400814f, 0.10694822f, 0.07978007f, -0.03458884f, -0.08393721f, 
    -0.25016105f, -0.21131821f, 0.21410441f, -0.25847772f, 0.28031054f, 0.03301400f, 0.15613148f, -0.00893836f, 
    0.10826362f, -0.04931847f, -0.00346742f, 0.00518569f, 0.01591632f, -0.13293637f, 0.02430911f, 0.21802761f, 
    -0.00995388f, 0.09622199f, -0.09229595f, -0.08492129f, 0.12220252f, 0.05890643f, 0.23260574f, 0.08577172f, 
    -0.12409869f, -0.02362773f, -0.17960654f, 0.24897419f, 0.04675633f, -0.02577494f, 0.05165501f, 0.00161865f, 
    0.12536649f, 0.03324158f, -0.08218990f, 0.04183382f, 0.20500545f, -0.28395090f, 0.15152194f, 0.20540483f, 
    -0.10544041f, -0.16649088f, -0.09882835f, 0.08924448f, 0.09112599f, 0.04565244f, 0.09206045f, 0.05250369f, 
    0.01460201f, -0.14780264f, 0.20164290f, 0.22161742f, -0.09981176f, 0.05620724f, 0.08480088f, -0.05378715f, 
    0.04697238f, -0.01251285f, 0.04877608f, -0.07090084f, -0.10522752f, -0.06240453f, 0.01295080f, -0.04037676f, 
    -0.06863856f, 0.05919457f, -0.03371618f, -0.01709230f, 0.02152357f, 0.05160630f, 0.01357582f, -0.00302800f, 
    -0.02671963f, -0.11455958f, -0.05682430f, -0.06968337f, 0.06923502f, 0.07049341f, 0.05099289f, -0.03803547f, 
    0.03302021f, -0.07779562f, -0.08806925f, -0.00586216f, 0.12933330f, -0.06997789f, 0.08727305f, 0.22520362f, 
    0.11908481f, 0.14774896f, 0.10251904f, 0.02048613f, -0.02427664f, -0.08213851f, 0.01208188f, 0.06003091f, 
    0.00469977f, 0.09953475f, -0.07219753f, 0.00710803f, 0.00213755f, 0.02112368f, 0.06856603f, 0.00795409f, 
    0.14858422f, 0.00787597f, 0.16188613f, 0.25143424f, 0.13842517f, 0.22279204f, -0.07575256f, -0.07335456f, 
    -0.06737855f, -0.12840374f, 0.13752225f, 0.26109871f, 0.04977102f, -0.01668938f, -0.00645160f, -0.04950777f, 
    0.59759432f, 0.17256172f, -0.06706990f, -0.03879735f, 0.00307616f, -0.13392861f, -0.02158960f, -0.06567039f, 
    0.05998451f, 0.19808432f, 0.10501733f, -0.12045842f, -0.12088879f, 0.22235450f, -0.11567900f, -0.09864745f, 
    0.01128777f, -0.01651816f, 0.24619962f, 0.10776502f, -0.06604812f, 0.17815341f, 0.07238429f, -0.07715394f, 
    -0.29654139f, -0.07900721f, 0.36810341f, 0.00353329f, -0.02512990f, 0.13813581f, 0.07156133f, 0.03754643f, 
    0.01219845f, -0.02794266f, 0.00881801f, 0.09114935f, -0.06969059f, -0.17752220f, 0.34083745f, 0.06132882f, 
    -0.00240967f, -0.08916612f, -0.08839127f, -0.10290525f, 0.03871334f, -0.02851935f, 0.09852473f, 0.01926228f, 
    0.01702377f, 0.02303479f, -0.02400966f, -0.10758156f, 0.09686271f, 0.06751681f, 0.19405976f, 0.00895619f, 
    -0.02464345f, 0.11615831f, -0.14320149f, -0.01468111f, -0.23455893f, 0.07547162f, -0.24130341f, -0.02705909f, 
    0.01640572f, -0.23091641f, 0.17059937f, -0.01032316f, 0.07265259f, -0.04798222f, 0.03176047f, 0.00704530f, 
    0.18894009f, -0.04644871f, 0.08368296f, -0.03456031f, -0.05327596f, -0.00921004f, -0.05597638f, 0.11135115f, 
    0.04670578f, -0.04787055f, 0.02505676f, -0.01792774f, 0.14482197f, -0.13954222f, -0.04222356f, 0.16172820f, 
    -0.03110741f, 0.05330142f, 0.00161153f, 0.03523437f, 0.31768289f, 0.21272676f, 0.10436015f, 0.04955588f, 
    0.06046947f, -0.02290276f, -0.17055328f, 0.12701382f, -0.06389713f, 0.11579334f, -0.03838582f, 0.03600393f, 
    0.16596690f, 0.05268301f, 0.03225910f, -0.05876987f, 0.25695398f, 0.00589648f, -0.03171257f, 0.20742117f, 
    0.17803781f, 0.19775553f, 0.14175673f, 0.08631984f, 0.04531693f, 0.17506321f, 0.07151313f, 0.06926955f, 
    -0.15865789f, -0.08575170f, 0.10169140f, 0.04389142f, 0.01219630f, 0.05553330f, 0.21301797f, -0.00627463f, 
    -0.01727038f, -0.00625196f, 0.03880028f, -0.01364699f, -0.02370198f, -0.14979655f, 0.07665382f, 0.05133769f, 
    0.00301673f, -0.04821987f, -0.04679028f, -0.07715226f, -0.08032166f, 0.03151231f, 0.24637404f, 0.07068801f, 
    0.11103919f, 0.07381876f, -0.31536055f, 0.10605815f, 0.15614597f, -0.14074107f, 0.07206000f, 0.05817945f, 
    0.01378650f, 0.02917903f, -0.01786656f, 0.11184815f, 0.01466406f, 0.00403916f, -0.07469431f, -0.01473383f, 
    -0.09396286f, 0.10662674f, 0.07771687f, -0.02505031f, 0.02535160f, -0.07383885f, -0.14399227f, -0.01171195f, 
    -0.04907711f, -0.09722561f, -0.18524039f, 0.20983931f, 0.07361646f, 0.09627672f, 0.20040372f, 0.06247828f, 
    -0.06331169f, 0.00060684f, 0.07106073f, 0.11655015f, -0.08607854f, 0.20066340f, 0.14067841f, -0.13617784f, 
    -0.03863300f, -0.18837442f, -0.02160666f, -0.00217032f, 0.00449012f, -0.12161151f, 0.11003517f, -0.12691703f, 
    -0.38601154f, -0.01398915f, 0.27528343f, 0.14340161f, 0.11614310f, -0.00325305f, -0.07431620f, 0.14379963f, 
    0.21914798f, -0.01114376f, 0.16487049f, 0.09093093f, -0.14313240f, 0.20229395f, 0.18695334f, -0.04640944f, 
    -0.05122733f, 0.11009329f, 0.03162421f, 0.00942266f, 0.00161869f, 0.00648280f, -0.00509761f, -0.15593109f, 
    0.24300677f, 0.06463987f, -0.12130518f, -0.00312326f, 0.04983429f, 0.09285270f, -0.05110338f, 0.04036252f, 
    0.05613492f, 0.00865102f, 0.04587109f, -0.20486157f, -0.30512577f, 0.09630141f, -0.06720970f, 0.16894642f, 
    -0.04143716f, -0.05022530f, -0.14036293f, -0.02492961f, 0.09567858f, 0.06329989f, 0.09871020f, 0.10556545f, 
    -0.01303370f, -0.06776689f, -0.12148400f, -0.05184110f, 0.02109132f, 0.04704687f, 0.15782411f, 0.11513027f, 
    0.08597770f, -0.08696797f, 0.04270204f, 0.11058698f, -0.72873116f, -0.20694505f, -0.08685078f, -0.12659869f, 
    0.03353044f, 0.02305708f, 0.02987022f, 0.00512166f, -0.00133589f, -0.03846005f, 0.07396697f, 0.10330720f, 
    -0.09168100f, -0.07572845f, -0.04348115f, 0.05312406f, -0.02734607f, -0.03725917f, -0.06816363f, 0.04799675f, 
    -0.00393476f, -0.01373599f, 0.01142625f, -0.00645751f, 0.00549392f, -0.02711676f, -0.12593451f, -0.13415402f, 
    0.16410586f, 0.10383863f, 0.04176977f, -0.01811310f, -0.01263693f, -0.07750396f, -0.03649071f, -0.01316606f, 
    0.06825014f, 0.21173476f, -0.09168839f, -0.10298315f, 0.05074453f, 0.06902634f, 0.09881645f, -0.08147465f, 
    -0.05637922f, -0.00001542f, -0.11008843f, 0.00890771f, 0.26502433f, -0.22604094f, -0.04791742f, 0.19160736f, 
    -0.05519744f, -0.00225560f, 0.11150827f, 0.02071559f, -0.00966859f, 0.03814120f, 0.20197262f, 0.06087118f, 
    -0.01260234f, 0.02126057f, -0.13810475f, 0.01248491f, 0.18233158f, 0.08939876f, 0.12424996f, -0.03309343f, 
    0.05750410f, 0.11843592f, 0.01025509f, 0.01678747f, -0.11119684f, -0.21598449f, 0.07442181f, -0.04267749f, 
    -0.00500921f, -0.05296819f, -0.01525696f, 0.15833195f, 0.04164449f, -0.01698304f, -0.01489143f, -0.06439009f, 
    -0.01882801f, 0.01801520f, -0.00104449f, -0.00044018f, -0.01275916f, -0.02808445f, -0.03658310f, 0.00634995f, 
    -0.02433435f, -0.03987044f, -0.04218142f, -0.03973713f, -0.03593380f, 0.01594040f, 0.00775624f, -0.01703075f, 
    0.00860328f, 0.02807209f, -0.00537088f, 0.00799347f, -0.00480170f, -0.03410778f, -0.01094472f, 0.00237598f, 
    0.01313235f, -0.04461627f, 0.00326574f, -0.02487278f, -0.02076541f, -0.00671824f, -0.02338032f, -0.01358171f, 
    -0.03102020f, 0.01505996f, 0.03023832f, -0.00360280f, -0.00664993f, 0.02951813f, -0.03860010f, -0.03641406f, 
    0.02077218f, -0.03403200f, -0.02643481f, -0.04295450f, -0.01546353f, 0.00437090f, 0.01129204f, 0.01041375f, 
    -0.02087618f, 0.02113256f, -0.02225155f, -0.02430913f, 0.01464103f, -0.01883212f, -0.00598028f, 0.02241922f, 
    -0.01674050f, -0.02660988f, 0.00621329f, 0.02474180f, -0.03695073f, 0.00223952f, 0.02245215f, -0.00012548f, 
    -0.03980150f, -0.02212329f, -0.03410184f, -0.03031341f, -0.03351710f, -0.03393239f, -0.00119308f, -0.03782359f, 
    0.02730365f, -0.01998585f, 0.00087355f, -0.02789848f, 0.02159079f, -0.03150859f, 0.02149605f, -0.00437769f, 
    0.00629385f, -0.00110226f, -0.02384675f, 0.02135219f, -0.01800074f, 0.01393495f, -0.03814393f, -0.01611566f, 
    0.02388367f, -0.04454871f, 0.00055979f, -0.02638075f, 0.01105804f, -0.00326524f, -0.01031971f, -0.02517482f, 
    0.01236826f, -0.01651291f, 0.01883960f, -0.00785873f, 0.01065746f, 0.00653279f, -0.01301764f, -0.01462930f, 
    -0.00262309f, 0.01478646f, 0.00635647f, -0.01015847f, -0.00706541f, -0.00207439f, -0.01985856f, 0.00617896f, 
    0.02056041f, 0.00965644f, -0.00188196f, -0.00925040f, 0.02712878f, -0.00284872f, -0.00927323f, 0.00860980f, 
    -0.02356531f, -0.02809288f, 0.00476687f, -0.00311262f, -0.01741648f, -0.00449841f, -0.01783860f, 0.01976651f, 
    0.01798963f, -0.03376373f, -0.01953063f, -0.03584963f, 0.00378903f, -0.00375814f, -0.03344014f, -0.01662702f, 
    -0.03824640f, -0.02600374f, 0.01883092f, -0.03315232f, 0.00992829f, -0.01438687f, -0.03653609f, 0.00403864f, 
    0.02753259f, 0.02663385f, 0.01686026f, -0.02190439f, -0.03425912f, 0.03290344f, 0.03381510f, -0.00224758f, 
    -0.00085712f, 0.01310477f, 0.02635869f, 0.02209784f, -0.00879129f, -0.01620164f, 0.00135985f, 0.01705383f, 
    -0.03679538f, -0.00667555f, -0.03539560f, -0.04047394f, -0.00387390f, 0.00794391f, -0.03567468f, -0.00940088f, 
    0.00935911f, -0.01323306f, 0.03451044f, -0.01221237f, 0.00480087f, -0.00813188f, -0.04003074f, 0.00732265f, 
    0.02894738f, 0.02652982f, -0.04069327f, -0.01179866f, -0.01577395f, 0.03412506f, -0.04114188f, 0.00348786f, 
    -0.03751171f, 0.02339583f, 0.02017973f, 0.01488570f, 0.03229531f, -0.00119775f, 0.03126832f, -0.02130177f, 
    -0.01592427f, -0.02475200f, -0.02530479f, 0.02613582f, 0.02251284f, -0.01462798f, -0.02694828f, 0.00215914f, 
    0.00082315f, 0.01406959f, -0.00209444f, -0.02557617f, -0.03704689f, 0.01189469f, -0.02068353f, -0.00794195f, 
    0.01888191f, -0.04301666f, -0.02156953f, 0.00793508f, 0.00412608f, -0.00290370f, 0.00217733f, -0.02932189f, 
    0.00701676f, 0.02017287f, -0.02173721f, -0.01237400f, 0.01448181f, -0.00847483f, 0.00910597f, 0.01680734f, 
    -0.00869232f, -0.01600340f, 0.02286402f, -0.01591677f, -0.01169193f, 0.00819473f, -0.03736143f, -0.00336494f, 
    -0.01917853f, -0.00893929f, -0.02433920f, -0.01349962f, -0.01248018f, -0.00798997f, 0.02083601f, 0.01214175f, 
    -0.03353428f, 0.01200808f, -0.01365231f, -0.03854941f, 0.01258646f, 0.00545669f, -0.02241207f, -0.02858725f, 
    -0.01700687f, -0.01625279f, -0.00060533f, 0.02327295f, -0.01338971f, 0.01354953f, -0.00240859f, 0.00627205f, 
    0.00964356f, 0.01526828f, -0.00642059f, 0.03002150f, 0.00109943f, -0.03717883f, 0.01178927f, -0.00204013f, 
    -0.01928123f, 0.00051980f, -0.00583638f, 0.02584679f, 0.01181957f, 0.02409256f, -0.01626853f, 0.01881671f, 
    0.00647003f, -0.04026277f, -0.04213104f, 0.00819791f, -0.03820830f, 0.02031134f, -0.01527753f, -0.02794580f, 
    0.01199550f, -0.03315399f, -0.03558450f, -0.01357321f, 0.01511591f, -0.03945915f, -0.02402385f, -0.02225452f, 
    0.00388284f, 0.02490101f, -0.03118116f, -0.01565560f, 0.00263757f, 0.00147334f, 0.02665597f, -0.00112239f, 
    -0.00628036f, -0.03158652f, -0.04190935f, -0.00387284f, 0.01271667f, -0.00755565f, 0.00050075f, 0.00643862f, 
    0.02058150f, -0.03232513f, -0.02727137f, -0.01674028f, -0.01998866f, 0.01614167f, 0.01628310f, -0.03440968f, 
    0.01153858f, 0.02551868f, 0.01080038f, 0.02603224f, -0.02597720f, -0.01074862f, -0.02611180f, 0.00952509f, 
    -0.03930564f, -0.02439599f, -0.03862186f, 0.01167692f, 0.02516015f, -0.01732079f, 0.00517571f, 0.02361265f, 
    -0.02036327f, -0.00512913f, 0.00513533f, 0.02057562f, -0.02980824f, -0.03885194f, 0.01824044f, -0.04086363f, 
    0.00414155f, 0.01649300f, -0.01877454f, 0.01397807f, -0.02768057f, -0.00927509f, -0.03113554f, 0.00527581f, 
    0.02982607f, -0.03413942f, -0.01268145f, 0.02670268f, -0.02052082f, -0.01362350f, -0.01856420f, -0.03172224f, 
    0.02573757f, -0.01115395f, -0.03002816f, 0.03046186f, -0.00537788f, -0.03363720f, -0.00141068f, 0.01054190f, 
    -0.01137890f, -0.00851439f, -0.01081366f, -0.02239799f, 0.01167454f, -0.02357354f, -0.02908164f, 0.01388524f, 
    -0.02858933f, -0.02299190f, 0.02128154f, 0.01972614f, 0.02365906f, 0.00960677f, 0.00385803f, -0.03488148f, 
    -0.02823718f, -0.03627812f, -0.02218592f, 0.01444911f, -0.02641319f, 0.00091996f, 0.01384899f, -0.00099693f, 
    0.01244599f, 0.01199207f, -0.01467643f, 0.02981467f, -0.02478862f, -0.01286731f, -0.01803804f, -0.03616920f, 
    0.00202189f, -0.02015262f, 0.03516755f, -0.02932974f, -0.04245492f, 0.02397814f, -0.00472209f, -0.01604792f, 
    -0.00942441f, -0.00220928f, -0.03734303f, 0.00285614f, -0.02204017f, -0.00991443f, 0.00016732f, -0.00391036f, 
    -0.03445809f, -0.03241734f, -0.02832106f, -0.02135942f, -0.00563119f, -0.03280591f, -0.02105566f, 0.00043479f, 
    0.01476418f, 0.01706476f, 0.00673760f, -0.02600438f, 0.02141958f, -0.02516610f, 0.03498726f, 0.02568255f, 
    -0.00255246f, 0.00769082f, 0.00707743f, -0.00507158f, 0.01133148f, -0.03114606f, 0.01516542f, 0.01488158f, 
    -0.01675021f, 0.01312458f, -0.00371537f, -0.01304718f, 0.02681984f, 0.02751720f, 0.01241643f, -0.00573553f, 
    -0.03087984f, 0.00300390f, 0.01670733f, -0.00541173f, -0.02572260f, 0.00615295f, -0.03559796f, -0.00328604f, 
    -0.00870572f, -0.04262875f, 0.01852859f, -0.02506522f, 0.02114687f, 0.01829324f, 0.01020083f, -0.00504203f, 
    0.02273281f, 0.00064251f, 0.01377512f, -0.03095280f, -0.00541764f, -0.04328828f, -0.03739873f, 0.02329603f, 
    -0.03276694f, 0.02293072f, -0.02078312f, -0.01000016f, -0.01947845f, -0.01131591f, -0.00078591f, -0.02863196f, 
    -0.01440920f, 0.00694946f, -0.03731253f, 0.02897166f, 0.01836028f, -0.01656746f, -0.01347934f, 0.02264005f, 
    -0.03076512f, -0.00087157f, 0.02744870f, 0.02457630f, 0.02720508f, -0.03246539f, 0.02663427f, -0.00399161f, 
    -0.01903065f, 0.02526634f, -0.00050940f, -0.02190813f, 0.00309709f, 0.01930708f, 0.00745277f, 0.00071175f, 
    -0.03825548f, 0.02259691f, -0.03178919f, -0.01470946f, 0.01117869f, 0.02458688f, 0.00957452f, -0.02099139f, 
    -0.03486799f, 0.02161189f, 0.00321705f, -0.03910370f, -0.01967443f, -0.02392158f, 0.01589254f, -0.01736939f, 
    -0.01186530f, -0.03275428f, -0.02773448f, 0.00034545f, 0.00163048f, 0.02476447f, -0.00767599f, -0.03165486f, 
    0.02739609f, -0.02485524f, -0.00838822f, -0.02150911f, -0.02047059f, 0.01656442f, 0.01085058f, 0.01582323f, 
    -0.03421819f, -0.01903471f, -0.01481462f, -0.04033414f, -0.00357773f, 0.02398274f, -0.00737454f, 0.01089956f, 
    -0.01120468f, -0.03323079f, -0.00505550f, 0.01790226f, -0.02673050f, -0.04133016f, 0.02452897f, -0.00416356f, 
    0.02528188f, -0.03154131f, -0.01383901f, -0.01805129f, -0.02843591f, -0.03768913f, 0.01099272f, -0.02532826f, 
    0.01827793f, -0.02432187f, -0.02395068f, 0.00890159f, -0.00411994f, -0.03851311f, 0.01020865f, 0.02438981f, 
    -0.00406573f, 0.01367059f, -0.00164376f, 0.02515956f, -0.00339515f, -0.01184420f, -0.01691960f, 0.01954524f, 
    -0.01535307f, -0.02016601f, 0.02529084f, 0.03330667f, -0.03219536f, -0.02333605f, -0.03624270f, -0.03290317f, 
    -0.02838906f, 0.01088085f, -0.01482164f, 0.00822712f, 0.01020799f, 0.02362211f, -0.03982477f, 0.02425741f, 
    -0.01344695f, 0.02237504f, -0.04221511f, -0.03185315f, -0.02731124f, -0.02917440f, -0.01524067f, 0.01414413f, 
    0.00985892f, -0.00773625f, -0.00166612f, 0.00538994f, -0.01450135f, 0.01478280f, -0.00138008f, -0.00296147f, 
    -0.04346251f, 0.00603063f, -0.00472529f, -0.00953455f, 0.01686001f, -0.01653747f, 0.00991738f, -0.03714048f, 
    0.02358116f, -0.01035794f, -0.02238968f, -0.00976002f, -0.00074017f, 0.02534304f, -0.02045043f, -0.02193272f, 
    -0.02748128f, -0.02607727f, 0.02733414f, 0.01323912f, -0.03603690f, -0.01005223f, 0.01104326f, -0.01032792f, 
    -0.01127677f, 0.01175989f, -0.03879939f, 0.02182332f, 0.01208344f, 0.00377738f, -0.02306179f, -0.04420101f, 
    -0.01476558f, 0.00951802f, -0.01576654f, -0.00329239f, -0.02666176f, -0.02129515f, 0.01087852f, -0.01198591f, 
    -0.03410313f, -0.01960927f, 0.00422275f, -0.00169623f, -0.02921161f, 0.01196726f, -0.01402518f, 0.02578612f, 
    0.00937382f, -0.03945848f, 0.00861533f, 0.00746021f, -0.03934883f, 0.00457973f, 0.02716872f, 0.00179802f, 
    -0.01775690f, -0.01461856f, 0.00057904f, -0.03977183f, 0.00869279f, 0.01837093f, 0.01108254f, -0.00966971f, 
    0.01402923f, -0.03675262f, 0.02815421f, 0.01076018f, -0.02069475f, 0.00804478f, -0.00116961f, -0.01908149f, 
    0.00766379f, 0.00025091f, 0.01899037f, 0.02419707f, 0.00837050f, -0.00394031f, -0.00545518f, -0.00648492f, 
    0.03003547f, -0.02364730f, -0.01099629f, -0.01365658f, -0.03576637f, 0.01297094f, 0.00273282f, 0.01389202f, 
    0.02420265f, 0.00994310f, -0.00155464f, -0.01255679f, -0.03670267f, -0.00998034f, -0.04233358f, 0.02643477f, 
    -0.01055468f, 0.01540013f, -0.03911357f, -0.03029273f, -0.01573669f, -0.03631037f, 0.00591761f, 0.01161587f, 
    0.00306957f, 0.01156324f, -0.02362569f, -0.03806786f, -0.03449802f, 0.00715993f, 0.01477056f, -0.00922753f, 
    -0.02832537f, -0.00388559f, -0.00270037f, -0.01634625f, 0.02425252f, -0.01177897f, -0.02357132f, -0.01777647f, 
    0.02797703f, -0.01191791f, -0.00944974f, 0.01300904f, 0.00605455f, 0.01111786f, -0.02829183f, 0.00272324f, 
    0.03486775f, 0.01298600f, -0.00792750f, -0.00145361f, -0.00239020f, -0.02927990f, 0.01726912f, 0.00416514f, 
    -0.00537842f, -0.03586959f, -0.01039284f, 0.00667141f, -0.03490526f, 0.01076027f, 0.00206693f, 0.00186607f, 
    -0.00324890f, -0.03542108f, -0.02102990f, -0.00217820f, 0.02215710f, -0.02722477f, -0.02555184f, -0.01003569f, 
    -0.03069177f, 0.02346235f, -0.01204681f, 0.02851947f, -0.01564143f, -0.02240921f, -0.00409204f, -0.01853878f, 
    -0.03704498f, -0.03841422f, -0.03146973f, -0.01588746f, -0.02974972f, -0.04233279f, 0.01492084f, -0.01199488f, 
    -0.04905630f, -0.03753991f, 0.19391491f, -0.16698903f, 0.00827552f, 0.06152752f, -0.08171891f, -0.20692839f, 
    0.07882408f, -0.12475513f, -0.02447371f, -0.17142023f, 0.09326751f, -0.10904820f, -0.01661452f, 0.25119743f, 
    -0.06355530f, 0.09057460f, 0.12180065f, 0.06549280f, -0.03079922f, 0.01119679f, 0.04666167f, -0.14271331f, 
    -0.06680243f, 0.13477050f, 0.01193561f, 0.23876984f, -0.11300547f, -0.02409237f, 0.00828780f, -0.00724107f, 
    0.04864926f, -0.12703593f, -0.11842648f, -0.02539430f, -0.00563459f, 0.12220675f, -0.01377763f, -0.04281089f, 
    0.13298307f, 0.09802917f, -0.02119091f, -0.06869301f, -0.02484461f, 0.07283983f, 0.10439195f, -0.00830003f, 
    0.15763576f, 0.29542413f, 0.40959281f, 0.18461186f, -0.05642095f, -0.03182425f, -0.05835954f, 0.05930827f, 
    0.00667268f, -0.02518219f, 0.05478632f, 0.02340831f, -0.13356143f, 0.15712664f, 0.39371726f, 0.02445454f, 
    -0.14186281f, 0.19013356f, -0.09623186f, -0.04065591f, -0.15961842f, -0.04297968f, 0.04773483f, -0.00698178f, 
    0.14140666f, 0.05639363f, -0.10651018f, -0.17649478f, -0.00848346f, 0.10476245f, 0.02374834f, 0.17158325f, 
    -0.12537012f, 0.10098787f, -0.04848601f, -0.09839436f, 0.00066751f, -0.13661264f, -0.02389025f, -0.24702121f, 
    0.01169801f, 0.09679350f, 0.09697384f, -0.01253983f, -0.04808155f, 0.19147016f, 0.05312236f, 0.00325131f, 
    0.09311713f, 0.12005024f, 0.19343950f, 0.12433749f, -0.04681068f, -0.05015535f, -0.11403774f, -0.04008876f, 
    -0.17926392f, 0.00251771f, -0.03832838f, -0.11620288f, 0.03530299f, 0.15001747f, 0.08453235f, 0.10227579f, 
    -0.05971665f, 0.06690854f, 0.09369786f, 0.08216344f, -0.04083738f, -0.08123416f, 0.00585467f, -0.06699008f, 
    0.00270149f, 0.02141781f, -0.05192410f, -0.07010207f, 0.00075578f, 0.00920243f, 0.05827115f, -0.07567034f, 
    -0.01369293f, 0.13477805f, 0.09112506f, 0.01377423f, -0.09846251f, -0.13944981f, 0.07845064f, -0.16526429f, 
    -0.00932551f, 0.05961644f, -0.03983114f, 0.14906308f, -0.06230015f, 0.09997518f, -0.04700680f, -0.11637733f, 
    0.04255984f, 0.10357327f, 0.09012941f, -0.17236404f, -0.01111472f, -0.06910495f, 0.10236187f, -0.11452709f, 
    0.09706774f, 0.00990967f, -0.01776040f, 0.04448687f, 0.05944080f, -0.03137740f, 0.05464973f, 0.21057624f, 
    -0.04373647f, 0.06208040f, 0.05453419f, 0.10747238f, 0.03611747f, 0.09047162f, 0.00785056f, 0.05660447f, 
    0.10910016f, 0.19345222f, 0.22962448f, 0.11130581f, 0.04039549f, -0.12367163f, 0.03287044f, 0.14383768f, 
    -0.07943080f, 0.02459759f, -0.11787751f, -0.02033245f, 0.15990533f, -0.05107959f, 0.13214684f, 0.00582415f, 
    -0.05239402f, -0.14542678f, 0.04915458f, 0.15254335f, -0.07271361f, -0.11723072f, -0.00209657f, -0.00730628f, 
    -0.12070804f, -0.25127438f, 0.09655765f, 0.01641819f, -0.04201813f, 0.18360068f, 0.03969905f, -0.08722407f, 
    -0.20789619f, 0.05094403f, 0.02418867f, 0.03388892f, 0.06985617f, -0.12425289f, -0.18176086f, 0.19745563f, 
    0.11676025f, 0.06869784f, 0.04412148f, 0.18406437f, 0.03859828f, 0.04770200f, 0.00756116f, -0.01109481f, 
    0.28382784f, 0.21593690f, -0.09425110f, -0.04887114f, 0.27236390f, -0.07035788f, 0.08292533f, -0.12085143f, 
    0.00989774f, 0.11071896f, 0.06032924f, 0.12401897f, -0.15145862f, -0.07933051f, 0.04628779f, 0.15107769f, 
    0.02866816f, 0.05273008f, 0.05678108f, 0.31041729f, 0.03394685f, 0.03992999f, 0.03321983f, 0.02051251f, 
    -0.05256852f, 0.04141616f, 0.09060774f, -0.02189781f, 0.22924080f, 0.07496037f, 0.00688339f, -0.00940600f, 
    -0.08626646f, -0.01764589f, -0.01636338f, 0.06158762f, 0.14482461f, 0.01266404f, 0.18069708f, 0.35385433f, 
    -0.03255902f, 0.00571751f, -0.04034067f, -0.02848119f, -0.20683561f, 0.09293686f, -0.01041267f, 0.09350805f, 
    0.13512915f, 0.25600526f, 0.19255239f, 0.14516373f, -0.09240059f, -0.03861021f, -0.05003519f, -0.00371829f, 
    -0.08319887f, 0.05007435f, 0.00570054f, -0.03165776f, 0.05663207f, 0.05844882f, 0.05004572f, -0.07575540f, 
    0.01871241f, -0.08767441f, -0.05719615f, -0.09890628f, 0.04377493f, 0.03508467f, -0.02272283f, -0.05741369f, 
    0.11518890f, 0.11375729f, 0.16283502f, 0.14681126f, -0.05977678f, -0.06780469f, 0.00244570f, 0.05417909f, 
    -0.01336601f, 0.11165380f, 0.06849574f, -0.03037676f, -0.06806651f, 0.59900707f, -0.27230263f, -0.01012698f, 
    -0.20215790f, 0.15053879f, 0.06978182f, -0.12447055f, -0.12878363f, 0.04391274f, 0.05685615f, -0.04545840f, 
    0.22875552f, 0.18046726f, -0.13259183f, 0.29281351f, -0.06343818f, 0.06153860f, 0.10760678f, -0.00844915f, 
    -0.17294981f, 0.10069169f, -0.15097809f, 0.00669756f, 0.03924211f, 0.19492720f, 0.00565289f, 0.04034451f, 
    -0.01594788f, -0.03321581f, -0.06859409f, 0.02725413f, 0.00560713f, 0.02324588f, 0.06178237f, 0.01857685f, 
    0.16601738f, 0.02901524f, -0.05480739f, -0.14392626f, 0.05949279f, 0.08936488f, -0.13761669f, 0.08443672f, 
    -0.12000357f, 0.13032965f, -0.05894697f, -0.06076841f, 0.23299272f, -0.21747124f, -0.39557442f, -0.30894572f, 
    0.14490089f, 0.06421314f, -0.03776865f, -0.17114630f, 0.04395587f, 0.03216299f, -0.01612294f, -0.05305379f, 
    -0.07762657f, -0.00882870f, -0.05202400f, 0.16548051f, 0.08564307f, -0.08711778f, -0.04040133f, 0.09378990f, 
    -0.01904154f, 0.13652454f, -0.01932492f, 0.03847357f, -0.06009743f, -0.22837211f, 0.11461346f, 0.15809166f, 
    -0.04562530f, -0.11448473f, 0.16052207f, 0.16821493f, 0.08143824f, -0.04101440f, -0.05731968f, 0.08369279f, 
    -0.04513076f, 0.00621629f, 0.03629420f, -0.03431790f, 0.07067586f, 0.15280138f, -0.05518358f, -0.04382189f, 
    -0.06103818f, -0.06699093f, -0.02386658f, -0.02295449f, 0.30122143f, 0.04944855f, 0.05574969f, -0.17985485f, 
    -0.09820294f, -0.13014463f, -0.12851244f, -0.00883840f, 0.01203277f, 0.04258586f, -0.05227704f, 0.00907768f, 
    0.28285959f, -0.05549038f, 0.01265991f, -0.18800193f, 0.09305369f, 0.04109802f, -0.05203728f, -0.14064822f, 
    -0.00059671f, 0.03925215f, -0.08907588f, -0.03587838f, -0.23750241f, -0.22641997f, 0.19405858f, -0.05338119f, 
    0.24554434f, 0.12258902f, -0.12235611f, -0.10399490f, -0.03778395f, 0.04137883f, -0.03685716f, 0.04713222f, 
    -0.43674371f, -0.31336820f, 0.28798527f, 0.14325252f, 0.04515338f, 0.10362816f, -0.03673298f, 0.01358909f, 
    -0.01317046f, -0.00054906f, -0.01943957f, 0.22867630f, 0.13500412f, 0.02067258f, 0.31233045f, 0.10620050f, 
    -0.02111825f, 0.05992035f, -0.04364322f, 0.11374839f, -0.02067497f, 0.05325813f, -0.02132559f, 0.09106434f, 
    0.06243051f, 0.00856235f, 0.00469041f, 0.13053118f, 0.05363731f, -0.02687300f, 0.01288620f, 0.02181930f, 
    0.00660976f, 0.01104351f, 0.11225078f, 0.03047168f, 0.13845073f, -0.18869530f, -0.42553750f, 0.03701744f, 
    0.05916308f, 0.09929954f, 0.03281549f, 0.15153700f, -0.04122728f, 0.02708003f, 0.00299808f, -0.10098071f, 
    -0.10898500f, -0.09191632f, 0.08036623f, -0.06072466f, -0.05377270f, 0.04634079f, 0.03151153f, -0.20029403f, 
    -0.17211711f, -0.17486978f, 0.04796306f, -0.09516737f, 0.50016475f, -0.04164513f, 0.22671998f, 0.12425153f, 
    0.08065476f, 0.21403278f, 0.07361624f, 0.00573412f, -0.08334342f, 0.05930403f, -0.06765595f, 0.11862823f, 
    0.22567163f, 0.07955230f, 0.00310027f, -0.01831598f, 0.09152345f, 0.04132551f, -0.02227575f, -0.10726070f, 
    0.00598596f, -0.00766429f, 0.19021250f, 0.02180479f, 0.09500326f, -0.01057880f, 0.09351897f, -0.08287568f, 
    -0.03218648f, 0.01948719f, -0.12576753f, -0.09889743f, -0.01519447f, -0.11219665f, 0.03041566f, -0.23102066f, 
    0.03818876f, 0.01810311f, 0.06688230f, -0.25864437f, 0.09648453f, 0.01492234f, 0.09161444f, 0.00069087f, 
    0.03723228f, 0.09815803f, 0.02143936f, -0.09244183f, -0.12996598f, 0.22311875f, -0.07211110f, -0.12002657f, 
    -0.00771940f, -0.09201519f, 0.12238748f, -0.05987949f, 0.01658334f, -0.04429338f, 0.01705404f, 0.02469350f, 
    0.07024604f, -0.00376749f, -0.02159503f, 0.13627407f, -0.10589931f, -0.01919896f, -0.04831970f, 0.01570241f, 
    -0.03619916f, 0.03410939f, 0.00795555f, -0.10644042f, -0.06765494f, -0.02990973f, -0.04775819f, 0.05754744f, 
    0.18924809f, 0.06015107f, 0.05827613f, 0.01791521f, -0.05804818f, -0.01387436f, 0.05834019f, -0.00156995f, 
    -0.08652692f, 0.13215739f, 0.25566432f, 0.02268077f, -0.05698582f, 0.02765021f, -0.15586375f, -0.14213590f, 
    -0.07819499f, 0.04487425f, 0.00882441f, -0.15787435f, 0.00398476f, 0.03332815f, -0.04670060f, -0.07498077f, 
    0.22941448f, -0.05431948f, -0.13014385f, 0.02420382f, -0.01101344f, 0.03480620f, 0.02264252f, 0.07332932f, 
    0.35024256f, 0.13775066f, 0.43255746f, 0.01817838f, 0.01778051f, -0.16466410f, 0.00669663f, -0.03468075f, 
    0.09395349f, -0.08231631f, 0.04738797f, -0.11055750f, -0.18944049f, -0.37439054f, 0.00551605f, 0.19242534f, 
    -0.01653760f, 0.15626512f, 0.05303280f, 0.21182899f, 0.00110325f, 0.26034477f, -0.06430545f, 0.00168153f, 
    0.02063337f, 0.21005170f, -0.53681540f, -0.10538488f, 0.05008386f, 0.12809318f, 0.07945974f, -0.01470920f, 
    0.04944116f, 0.18146434f, -0.04046932f, 0.07149286f, -0.05047619f, -0.03300811f, -0.12526453f, 0.29289168f, 
    -0.12162680f, -0.00408389f, 0.07922341f, 0.27535692f, -0.09964941f, -0.02030593f, 0.01574702f, 0.11295114f, 
    0.13021633f, 0.14855050f, 0.37605056f, 0.10156516f, 0.01162608f, 0.05330057f, -0.04172740f, 0.00684325f, 
    -0.07494607f, 0.00180125f, -0.02936766f, 0.04276934f, 0.27368760f, 0.02147803f, -0.16762455f, -0.09955493f, 
    0.09854748f, 0.05130732f, 0.00294455f, -0.12334173f, -0.07508495f, -0.00418034f, -0.01293095f, -0.02664600f, 
    0.30701330f, 0.10000961f, 0.26978043f, -0.00420027f, 0.06235318f, -0.01832862f, -0.13266784f, -0.02516444f, 
    -0.06990204f, 0.08733907f, -0.00614139f, 0.07262228f, 0.62132061f, 0.24534145f, -0.14776266f, 0.08736491f, 
    0.11234143f, 0.16686828f, -0.03061218f, -0.01425875f, -0.00474225f, -0.04277331f, -0.02494360f, 0.07124327f, 
    0.08383710f, -0.02113326f, 0.03508902f, 0.07117833f, 0.16785741f, -0.00773384f, -0.02035332f, 0.00762020f, 
    0.04949694f, 0.06680050f, 0.00563588f, 0.04299408f, 0.19775373f, -0.05604596f, 0.14109296f, 0.12907584f, 
    -0.05572439f, -0.15964161f, -0.04658288f, -0.03983620f, -0.08518725f, -0.05261225f, 0.05787305f, -0.01060989f, 
    0.10385032f, 0.11050064f, 0.33747098f, 0.19008172f, -0.06586269f, -0.11510407f, -0.13022609f, -0.04463315f, 
    -0.04546623f, -0.07312263f, 0.03205934f, 0.00805274f, 0.05309794f, 0.08392866f, 0.12998265f, -0.09377059f, 
    0.15246937f, 0.00432622f, -0.04390504f, -0.08042677f, 0.19086854f, 0.13047217f, 0.03746797f, -0.06466468f, 
    0.09630062f, 0.07181530f, 0.20964807f, -0.09475197f, 0.07438672f, -0.02944130f, 0.04015525f, 0.00840131f, 
    -0.02805640f, -0.08677539f, 0.08820014f, -0.04856605f, -0.07551719f, 0.03494525f, -0.05830322f, 0.09980776f, 
    0.04254803f, 0.11195227f, 0.27323762f, -0.00966386f, 0.00467107f, 0.01524358f, 0.08499441f, -0.07691723f, 
    0.18991232f, -0.09447161f, 0.01549812f, 0.30287501f, 0.00259785f, 0.02439494f, -0.07576422f, 0.11925391f, 
    -0.29502305f, -0.06703884f, -0.16523890f, 0.09054243f, -0.15614292f, 0.16497697f, 0.09944732f, 0.10796901f, 
    -0.01668545f, -0.03122866f, 0.16521858f, -0.04849837f, 0.13041170f, 0.01766275f, 0.05609438f, 0.18857788f, 
    0.16218588f, -0.03071625f, -0.17729345f, -0.09609288f, 0.06922217f, 0.02869764f, 0.12195949f, 0.11210768f, 
    -0.10216847f, 0.06652290f, -0.12536576f, -0.12349618f, -0.09388182f, -0.03378614f, -0.05182227f, 0.05409350f, 
    0.07240911f, 0.02933658f, 0.15923125f, 0.07835918f, 0.23513138f, 0.11361874f, 0.14695802f, 0.34841797f, 
    -0.21228936f, -0.00710460f, -0.12145882f, -0.22092104f, 0.06425564f, 0.02034273f, -0.04990739f, -0.37569124f, 
    0.05293048f, -0.15218814f, 0.03129696f, 0.06088714f, -0.04878655f, -0.21580243f, -0.16687343f, 0.07103578f, 
    -0.05308847f, 0.10394754f, -0.00679335f, -0.05143812f, 0.06943051f, -0.05954067f, 0.00295394f, 0.23642130f, 
    -0.00523595f, 0.07257618f, -0.01638163f, 0.02752388f, 0.04279969f, -0.00438137f, -0.13392207f, -0.05999627f, 
    0.04511916f, -0.20835485f, -0.12035052f, -0.17927678f, -0.09762646f, 0.38150662f, -0.01374324f, 0.28180733f, 
    0.00850504f, -0.05599229f, -0.10409559f, 0.04760380f, -0.06388701f, -0.00161498f, 0.02984591f, -0.14715551f, 
    -0.02589494f, 0.02383639f, -0.09172618f, 0.08803377f, -0.04993301f, -0.17905091f, -0.03587571f, -0.04965517f, 
    0.21491218f, 0.34388182f, 0.26451257f, 0.30356643f, 0.12654132f, -0.26953903f, -0.14120284f, -0.13043743f, 
    -0.02618816f, 0.12335722f, -0.05587470f, 0.02127641f, -0.08238862f, -0.21154726f, -0.06564879f, -0.05843774f, 
    0.02363205f, -0.01486834f, -0.05561341f, -0.28836241f, -0.04675173f, -0.06942178f, -0.00397453f, 0.13024597f, 
    -0.00034777f, 0.01547087f, 0.04476573f, 0.08883082f, -0.02493948f, 0.26816103f, 0.01060923f, 0.21865478f, 
    0.04593786f, -0.15396127f, -0.09938296f, -0.06346215f, 0.11262280f, 0.28357515f, 0.28271207f, 0.24212006f, 
    -0.02801649f, 0.08351994f, -0.14335860f, -0.14733754f, 0.02376775f, 0.22178014f, -0.13484122f, 0.08280118f, 
    -0.26316026f, -0.01724621f, -0.18086722f, -0.18290085f, 0.05826856f, 0.04113128f, -0.00879796f, 0.18487626f, 
    0.02587747f, 0.11168786f, 0.00381918f, 0.02375401f, 0.01552553f, -0.08117563f, 0.09450094f, 0.10683908f, 
    -0.44130793f, 0.04380617f, 0.19236705f, 0.28196812f, 0.04463460f, 0.03644928f, 0.12808637f, 0.03963376f, 
    0.12041005f, 0.17427644f, -0.04949543f, -0.04414537f, -0.18208647f, -0.09407472f, -0.03229500f, -0.03836997f, 
    -0.04388663f, 0.12275501f, 0.01846266f, 0.00569992f, 0.02866738f, -0.08891777f, -0.09369624f, -0.14714901f, 
    -0.50967515f, 0.40309140f, 0.16568455f, 0.12440450f, 0.02782355f, -0.00013985f, 0.16654906f, 0.02474477f, 
    0.12909146f, 0.03171640f, -0.00478502f, 0.18534614f, 0.11307883f, 0.07760058f, 0.07259106f, 0.01055497f, 
    -0.03938510f, 0.06250710f, -0.09263932f, -0.07753228f, 0.09449986f, 0.02838821f, 0.06615731f, 0.03862449f, 
    0.23462282f, -0.13155526f, 0.08411696f, 0.08282588f, 0.06666987f, 0.16014990f, -0.09432037f, 0.16776760f, 
    0.09258046f, -0.07707675f, 0.13300899f, 0.13351798f, 0.19446182f, 0.00176907f, -0.02972721f, 0.09585598f, 
    -0.00790252f, -0.02489452f, 0.01084442f, -0.12567407f, 0.03889233f, -0.01259175f, -0.09877458f, -0.04069912f, 
    0.03548153f, -0.14297931f, -0.10158209f, -0.14712116f, -0.05455845f, 0.10479973f, 0.12410569f, -0.08271056f, 
    0.08930666f, -0.22235370f, -0.23537746f, -0.15794256f, -0.37727326f, 0.03621261f, 0.01972790f, -0.21293859f, 
    -0.01436166f, 0.01267044f, 0.00819127f, 0.09501767f, 0.05615282f, 0.03501583f, 0.08240789f, -0.02837848f, 
    -0.23898225f, -0.34008297f, -0.28157011f, -0.31183547f, -0.04863171f, -0.06305978f, -0.06641911f, 0.05160604f, 
    -0.02387824f, -0.09677787f, 0.02495781f, 0.13936603f, 0.06345951f, 0.29358611f, -0.07507823f, 0.01182864f, 
    0.07574380f, 0.05713663f, -0.16995598f, 0.08067630f, -0.36372560f, -0.13431995f, 0.12680165f, -0.22214372f, 
    -0.16204596f, -0.12468368f, 0.04860044f, -0.05625833f, -0.00962287f, 0.02638799f, 0.10384569f, -0.06616615f, 
    0.07730825f, -0.17117487f, -0.00693021f, 0.10608976f, 0.11095680f, -0.26374981f, 0.27901986f, 0.36713862f, 
    0.23511672f, 0.01948179f, -0.04759638f, 0.01335070f, 0.23501824f, 0.00475397f, -0.18979651f, -0.03147012f, 
    -0.17724515f, -0.18058224f, 0.15488143f, 0.11201502f, 0.07731818f, -0.21806793f, -0.04209431f, -0.14527637f, 
    -0.09073278f, -0.26792249f, -0.11238071f, -0.25510311f, -0.04073854f, -0.04462704f, 0.19884551f, -0.23138255f, 
    -0.04100999f, -0.05058216f, -0.06601499f, -0.07239480f, 0.02268685f, 0.04707823f, -0.02357623f, -0.00712086f, 
    0.01412443f, 0.00045665f, 0.01280870f, 0.08437788f, 0.04340219f, 0.19842340f, -0.05351682f, -0.17026015f, 
    -0.02410075f, -0.16710037f, -0.16220619f, -0.39445496f, 0.46149603f, 0.30619952f, 0.57401365f, 0.34959576f, 
    -0.11732476f, -0.07634357f, 0.04236469f, 0.08482729f, 0.08911826f, 0.12453827f, 0.01727477f, 0.13766474f, 
    0.08170887f, 0.03872367f, 0.16690984f, 0.00321665f, 0.06851161f, 0.09961785f, -0.02357921f, -0.02616453f, 
    0.03364423f, -0.17373915f, 0.06425840f, 0.02924560f, -0.01257768f, 0.10862202f, 0.12862357f, 0.13685822f, 
    -0.01658678f, 0.15804353f, -0.16813074f, -0.02727434f, 0.18106154f, 0.18294509f, 0.14358477f, 0.27755108f, 
    0.04661108f, -0.23396930f, -0.02431734f, -0.03164445f, -0.03360947f, 0.16141234f, -0.14749761f, 0.01942105f, 
    -0.00985800f, -0.28947103f, -0.35691389f, -0.21291561f, -0.30326688f, -0.01598189f, 0.08556514f, -0.00341371f, 
    0.06378967f, 0.05028279f, -0.05552254f, 0.02231010f, -0.03087896f, -0.11008947f, -0.03122074f, -0.20600203f, 
    0.38849199f, 0.05413529f, -0.05356006f, 0.28413153f, 0.00414446f, 0.04187735f, 0.05156128f, 0.11661388f, 
    0.24972871f, 0.14184767f, 0.22694962f, 0.35831890f, 0.29751194f, 0.08422295f, 0.04715407f, 0.13985062f, 
    -0.13072811f, 0.08649758f, 0.08461160f, -0.06404091f, 0.08130056f, -0.00730459f, 0.03604702f, -0.06525493f, 
    0.12742747f, 0.22084211f, -0.32269570f, 0.19461177f, -0.00140685f, -0.09774434f, 0.20439748f, -0.13984761f, 
    -0.01100843f, 0.11415995f, -0.11859425f, 0.11521137f, -0.08871274f, 0.12349299f, -0.01852696f, 0.05986546f, 
    -0.09171535f, -0.00376783f, 0.19394316f, 0.08349232f, 0.26919118f, 0.14182508f, 0.14423682f, 0.13716349f, 
    0.17241135f, 0.06768613f, -0.07533952f, 0.02540256f, 0.12411869f, 0.01241691f, -0.09865100f, 0.05241263f, 
    -0.14690226f, 0.00566530f, 0.07970082f, 0.05110570f, 0.26802626f, 0.29599416f, 0.33246821f, 0.01507037f, 
    -0.06694742f, -0.06383350f, -0.03176970f, 0.10817046f, 0.11909503f, -0.13239528f, -0.23736836f, -0.11348540f, 
    0.02554175f, 0.34239867f, -0.35672396f, 0.17567371f, 0.00677659f, 0.04589022f, 0.07942809f, -0.04410529f, 
    0.05121767f, 0.11274318f, 0.05991541f, -0.03618936f, 0.04812272f, -0.10398039f, 0.06723224f, 0.28409305f, 
    0.07361802f, 0.10977952f, 0.02387670f, 0.09213866f, 0.01010350f, -0.19772398f, 0.16934605f, 0.16679329f, 
    -0.11371151f, -0.14590435f, 0.01627775f, 0.19440198f, 0.04673721f, -0.11229374f, -0.12249928f, -0.18963033f, 
    -0.26622361f, -0.26145783f, 0.02564258f, -0.36096218f, -0.00269730f, -0.05572907f, -0.13396223f, 0.03038901f, 
    -0.04066881f, 0.00879389f, 0.02310982f, -0.06333616f, 0.20134929f, 0.18845448f, 0.32946116f, 0.36610347f, 
    0.39977881f, 0.09291505f, -0.10817283f, 0.21286507f, -0.19103371f, 0.18547612f, 0.07496491f, -0.08532210f, 
    0.06740309f, -0.01961500f, -0.16420747f, 0.15282047f, 0.11942568f, -0.01002249f, 0.10561720f, 0.07265396f, 
    0.07302450f, 0.23017673f, -0.10077416f, -0.00074724f, 0.19031820f, -0.04618562f, -0.15530518f, 0.07342505f, 
    -0.03535035f, -0.07921761f, -0.17014022f, -0.10207501f, 0.11704358f, -0.06570026f, 0.08298149f, 0.17585005f, 
    0.03901014f, -0.10666466f, 0.02292121f, -0.04647566f, 0.26004329f, 0.09157696f, 0.10776349f, 0.05759259f, 
    0.00708860f, 0.03134398f, -0.00902055f, -0.04423463f, -0.16960554f, -0.08967878f, -0.11521395f, -0.07828818f, 
    -0.16846450f, 0.00900610f, -0.12716959f, -0.03628743f, -0.02418613f, -0.08536902f, 0.02349170f, 0.11854054f, 
    -0.14484937f, 0.13178188f, 0.08129013f, -0.15227421f, -0.05919371f, 0.08462807f, -0.06339449f, 0.02370371f, 
    -0.00782055f, 0.01117229f, 0.09132010f, -0.05386046f, -0.28188586f, -0.33021373f, -0.40779534f, -0.46607468f, 
    -0.26973891f, 0.09537800f, 0.08905622f, 0.15061761f, 0.07701497f, 0.07993854f, 0.07638003f, 0.12700179f, 
    -0.08747600f, 0.06108089f, 0.17325844f, -0.20368329f, 0.11676490f, 0.19843082f, -0.05888416f, -0.13072346f, 
    -0.06823334f, -0.12406802f, -0.03856658f, -0.10490590f, 0.16218197f, -0.13228630f, -0.16533025f, -0.03743646f, 
    0.21153364f, 0.15686786f, 0.15821695f, 0.09314903f, 0.07096966f, -0.00019206f, -0.05636834f, 0.05186433f, 
    0.07192843f, 0.20058714f, 0.16658162f, 0.15566412f, -0.34414741f, -0.10847761f, 0.21128908f, -0.05870750f, 
    0.11656404f, 0.06146153f, 0.10595923f, -0.11371079f, -0.02704567f, -0.03902996f, -0.03446002f, -0.01116709f, 
    -0.05475057f, -0.23793349f, -0.10811403f, 0.01328325f, -0.13088852f, 0.02337432f, -0.00978773f, -0.14917013f, 
    -0.06222528f, -0.10741829f, 0.01242022f, 0.11637430f, 0.27067807f, 0.23691908f, 0.41207200f, 0.24453297f, 
    -0.24175054f, -0.04699076f, 0.02450680f, 0.15835293f, 0.03591157f, 0.06776877f, 0.06545459f, 0.14119916f, 
    -0.19040167f, 0.23933582f, 0.15989128f, 0.22602272f, -0.06353254f, -0.02647475f, 0.11051534f, 0.00650348f, 
    0.26553929f, 0.02811365f, 0.20305644f, 0.31265330f, -0.17916323f, -0.15247700f, 0.24524464f, 0.33023757f, 
    0.06647138f, -0.04358488f, 0.10305935f, 0.21768515f, -0.09867264f, 0.02458663f, 0.19362202f, 0.11207233f, 
    0.03623987f, -0.03911452f, -0.05360618f, 0.06114848f, 0.01077224f, -0.08959322f, 0.05336347f, 0.14622094f, 
    -0.01089976f, 0.07441191f, 0.05005608f, -0.10371061f, -0.33215043f, 0.05717694f, 0.23000711f, 0.02175559f, 
    0.13451318f, -0.01264953f, -0.04095113f, 0.04567150f, -0.24622309f, -0.27042973f, 0.01010580f, -0.28912941f, 
    -0.34830940f, 0.07115114f, 0.22636080f, -0.06327175f, 0.22311048f, 0.09002227f, 0.03376983f, -0.07368878f, 
    -0.12581748f, -0.13371566f, -0.09119917f, -0.36525959f, 0.45612016f, -0.03959319f, 0.06839486f, 0.15181439f, 
    -0.04326375f, 0.14977264f, 0.11854562f, -0.01620454f, 0.05166016f, 0.18296030f, 0.22990991f, 0.24251842f, 
    -0.19275273f, -0.04033415f, -0.29529318f, -0.12841852f, -0.01468561f, 0.10933050f, -0.09949586f, 0.02815604f, 
    0.03729894f, -0.06243296f, -0.21730538f, -0.28352493f, 0.23926766f, -0.10038344f, -0.14709014f, -0.10697772f, 
    0.14052299f, -0.00547135f, -0.11593354f, 0.17440785f, 0.07308829f, 0.02244184f, -0.09297105f, -0.07606903f, 
    -0.01478698f, 0.01024648f, -0.04370846f, 0.01337571f, 0.00552589f, -0.01951759f, -0.02666663f, 0.00606670f, 
    -0.03184405f, -0.00412235f, -0.02097543f, 0.02204037f, -0.04145354f, 0.00515434f, 0.01215050f, -0.03674527f, 
    0.01788227f, -0.00123857f, 0.01750325f, -0.03421561f, -0.02766821f, -0.00447475f, 0.02268221f, -0.03606013f, 
    -0.01739639f, 0.01335174f, -0.02966234f, -0.01971798f, 0.00547032f, -0.01644149f, -0.02650968f, -0.00386190f, 
    -0.02146637f, -0.02303626f, 0.02222804f, 0.00859051f, -0.00844873f, -0.00869251f, 0.01265639f, -0.02158132f, 
    -0.01778754f, 0.01385650f, -0.03115211f, 0.01653773f, -0.01521105f, -0.02104924f, -0.03020891f, -0.02996328f, 
    -0.03568278f, 0.01938395f, -0.02411253f, -0.03583211f, -0.01759518f, 0.02053040f, -0.02179562f, 0.00748997f, 
    0.01488324f, -0.00873220f, -0.00128323f, 0.00152053f, -0.01301645f, -0.01277648f, -0.03367769f, -0.00615335f, 
    0.02144504f, -0.03115632f, -0.01339499f, -0.01785976f, 0.02586226f, -0.01008617f, 0.02277886f, -0.02578614f, 
    0.02643757f, 0.02024192f, 0.01354344f, 0.02587048f, -0.01750856f, -0.01039399f, -0.00023164f, 0.01715197f, 
    -0.02748615f, -0.04003161f, -0.02143160f, 0.00656141f, 0.01071462f, 0.01089311f, 0.01891613f, 0.00505949f, 
    -0.04021693f, -0.02182111f, -0.01624109f, -0.03975715f, 0.01068168f, 0.02339012f, 0.00248844f, 0.00770786f, 
    0.00092832f, 0.00627761f, -0.00132658f, -0.01958963f, 0.01481502f, -0.02013203f, -0.00985837f, -0.02802298f, 
    -0.03121038f, -0.01071827f, 0.01909140f, -0.04227068f, 0.00632792f, -0.01894283f, -0.01301652f, 0.02493876f, 
    0.02638559f, -0.01246855f, 0.02192786f, -0.01827211f, 0.01611215f, 0.02725650f, -0.02311379f, -0.01324225f, 
    0.00786776f, 0.02190452f, -0.01065086f, -0.00943118f, 0.00894427f, -0.02124148f, -0.02828845f, -0.03503577f, 
    -0.02265808f, 0.00473705f, -0.03106637f, 0.00936329f, -0.01536489f, -0.00225852f, -0.01888759f, -0.04391078f, 
    -0.01591288f, -0.00199948f, -0.02416820f, 0.00700661f, -0.04238694f, 0.02089166f, -0.01828261f, -0.02705306f, 
    -0.03027393f, 0.01689842f, 0.02471995f, -0.01105119f, -0.03176092f, -0.01783476f, 0.01502398f, 0.02416246f, 
    -0.04001168f, -0.01573261f, -0.03582708f, 0.00943617f, 0.01124089f, 0.01252476f, -0.01713535f, 0.03051202f, 
    0.00931337f, -0.00156152f, 0.03266554f, -0.03296949f, -0.02131650f, -0.03784886f, -0.00469623f, -0.02638224f, 
    -0.04291283f, -0.01359416f, 0.02248004f, 0.02589605f, -0.03345435f, 0.00437656f, -0.03595684f, -0.00611075f, 
    -0.00406488f, 0.00119710f, -0.01026437f, -0.03655910f, -0.04429022f, -0.03294028f, -0.01851567f, 0.00968926f, 
    -0.03948532f, -0.00897679f, -0.03158465f, -0.02698527f, 0.02886010f, 0.02660274f, 0.02029198f, -0.04169285f, 
    -0.04213779f, 0.02650954f, -0.01280733f, 0.01300441f, -0.02645030f, 0.01659044f, -0.01815523f, -0.01067311f, 
    -0.03175417f, 0.00916001f, 0.01391916f, -0.02926394f, -0.02777311f, 0.01414003f, -0.02038957f, 0.01660292f, 
    0.02768986f, 0.00875163f, -0.04337445f, -0.02253558f, 0.02412554f, 0.03336849f, -0.00486796f, -0.03980301f, 
    -0.00541564f, 0.01987902f, 0.01112875f, 0.00878735f, -0.00922157f, -0.01991551f, 0.00214073f, 0.02279172f, 
    0.00731428f, 0.02711257f, -0.03243176f, -0.03317826f, -0.02440938f, 0.00969145f, 0.00782319f, 0.02896502f, 
    -0.01151305f, 0.02472396f, -0.04172527f, -0.01432861f, 0.00458461f, -0.03134577f, 0.02124071f, -0.02721112f, 
    -0.02415612f, -0.00521413f, -0.02878966f, 0.00826602f, 0.00008027f, -0.03023639f, 0.00288571f, -0.02965046f, 
    -0.02243499f, -0.03705032f, 0.01790801f, 0.01966096f, 0.01962556f, 0.01686442f, 0.02159696f, -0.01814367f, 
    -0.00082296f, 0.02588474f, 0.01012368f, -0.01809704f, -0.02091537f, 0.00401920f, 0.00663846f, 0.02982427f, 
    -0.01069367f, 0.00028494f, -0.01974451f, -0.03254633f, 0.02328493f, -0.01666022f, -0.03404217f, 0.01719594f, 
    -0.00723076f, 0.01913959f, -0.00251028f, 0.01451137f, -0.01237119f, -0.03631523f, -0.03153161f, -0.01067816f, 
    -0.00652530f, 0.02675827f, 0.01434383f, 0.01969413f, 0.01062113f, -0.01624320f, -0.00779778f, 0.02908251f, 
    -0.03145841f, -0.02056742f, -0.01109611f, -0.04079762f, 0.00111132f, -0.00025021f, 0.00691372f, -0.01666557f, 
    -0.00582303f, -0.02467803f, -0.03443554f, -0.01255718f, -0.02406175f, -0.03195799f, 0.01780302f, 0.00662339f, 
    -0.02202268f, 0.00619669f, -0.02925879f, -0.02880684f, 0.01637517f, -0.01898141f, 0.01581098f, 0.01344647f, 
    0.02374053f, -0.02445738f, 0.01307024f, -0.01342663f, -0.01585111f, -0.03228274f, -0.02273815f, -0.00407839f, 
    0.00531179f, 0.02275354f, 0.00594323f, 0.00104336f, -0.01479111f, 0.01065828f, -0.04357907f, 0.02320976f, 
    -0.02463824f, 0.01729533f, -0.03894978f, -0.02828251f, 0.01269082f, -0.00461533f, 0.01764498f, -0.03214101f, 
    -0.00710226f, 0.00138589f, -0.03351620f, -0.00915252f, -0.03805505f, -0.02203312f, -0.02494611f, 0.01658359f, 
    -0.00031603f, -0.03776499f, 0.02815982f, 0.02694706f, 0.02284058f, -0.00193489f, -0.03857937f, -0.00667570f, 
    -0.00053852f, 0.02533733f, -0.03407690f, 0.01585056f, 0.02345117f, -0.03149129f, 0.00648818f, -0.03458768f, 
    0.02254932f, -0.02359639f, -0.01925879f, -0.01800388f, -0.00781384f, -0.03771911f, 0.01642415f, 0.00581198f, 
    0.03075434f, 0.03043299f, 0.02649142f, -0.01881257f, -0.02476814f, -0.03628659f, 0.02184539f, 0.02225458f, 
    0.02765948f, -0.01786548f, -0.03174461f, -0.00088890f, -0.02801833f, 0.01448912f, 0.00448309f, -0.02073826f, 
    0.01606452f, 0.00414980f, -0.00422278f, 0.02512722f, 0.02520545f, -0.02210252f, 0.00075180f, 0.00118202f, 
    -0.03748782f, -0.02407896f, -0.00117193f, 0.02397896f, 0.02250181f, -0.02610065f, -0.01016455f, -0.02750205f, 
    -0.02679660f, 0.01156336f, -0.00992646f, -0.02712049f, -0.02128364f, -0.04590457f, -0.02401219f, 0.02560029f, 
    -0.02850465f, 0.01645595f, -0.03303150f, -0.00538478f, -0.03477859f, 0.02391603f, 0.00999293f, 0.00664529f, 
    0.01181389f, -0.03031045f, -0.00331820f, -0.00131906f, -0.00004705f, 0.01032797f, 0.00327104f, -0.02979445f, 
    -0.02742433f, 0.01856700f, -0.04400216f, -0.00907314f, -0.01798546f, -0.02218544f, 0.01600408f, -0.00398869f, 
    0.00375506f, -0.03923833f, 0.01694514f, -0.03224676f, -0.00538278f, -0.01834988f, 0.01732463f, 0.01409480f, 
    -0.03734843f, -0.00634565f, -0.04262895f, -0.01514554f, -0.02193469f, 0.02572453f, 0.01165469f, -0.01432831f, 
    0.01383749f, -0.01379343f, -0.01082420f, 0.01373247f, 0.01228726f, -0.01100177f, 0.01112413f, 0.01821726f, 
    -0.02157929f, -0.03609651f, -0.00647606f, -0.00541111f, 0.00522207f, 0.00788822f, -0.03428484f, -0.03147006f, 
    -0.01070312f, -0.01783160f, -0.00098086f, -0.01222304f, 0.00867981f, -0.03952181f, 0.00346418f, -0.03821938f, 
    0.01358953f, -0.01435374f, -0.02132663f, -0.00047502f, -0.03098221f, -0.02759429f, 0.00822487f, -0.01084676f, 
    -0.00960032f, -0.00479199f, -0.03699320f, -0.03396729f, -0.03170335f, 0.01523813f, -0.01462380f, -0.02234730f, 
    -0.02216908f, -0.01478649f, -0.01143628f, 0.00964803f, 0.02071282f, 0.00714931f, -0.03943104f, -0.02836525f, 
    -0.03085912f, 0.00816402f, 0.02220982f, -0.03245982f, -0.01511274f, -0.01096512f, -0.03086607f, 0.03312638f, 
    -0.00079729f, -0.02820374f, 0.00546569f, -0.03978668f, -0.02034423f, 0.00182770f, 0.02202868f, -0.03089152f, 
    0.00903243f, 0.02554370f, -0.03797779f, -0.00645969f, 0.00524768f, -0.03219162f, -0.00262766f, -0.01610204f, 
    -0.00712086f, 0.00022150f, 0.00629369f, 0.00236082f, 0.01522745f, -0.01649571f, -0.00679608f, 0.02210043f, 
    0.02388415f, -0.02308101f, -0.02625623f, -0.02310730f, 0.02071827f, -0.02739098f, 0.02658570f, 0.00364036f, 
    -0.01681222f, -0.03988997f, -0.04000865f, 0.00117196f, 0.01601101f, 0.00097728f, 0.02607541f, -0.03781027f, 
    -0.03255607f, -0.03347237f, 0.01302804f, 0.00129730f, -0.00029086f, -0.03114262f, -0.03421374f, 0.02686387f, 
    -0.01116929f, 0.03232930f, -0.02249122f, 0.02221094f, -0.01750356f, -0.02138855f, 0.01119281f, 0.00692799f, 
    -0.02679834f, -0.02180192f, 0.01950346f, -0.02184320f, -0.00913183f, 0.00324874f, -0.02053319f, -0.02087372f, 
    -0.03060234f, 0.00797280f, -0.01655921f, -0.00504012f, 0.01633963f, 0.01033905f, 0.01163012f, -0.04372218f, 
    -0.03175190f, 0.00464214f, -0.00711509f, -0.03880031f, -0.00150926f, 0.00046733f, -0.03906856f, 0.01058677f, 
    -0.01114079f, 0.00283127f, -0.00368898f, -0.00503549f, 0.00559672f, -0.02957313f, 0.02137653f, -0.04374045f, 
    -0.02546172f, 0.01762540f, -0.00735847f, -0.03231160f, 0.02169175f, 0.01275323f, -0.03653302f, -0.03305962f, 
    -0.02924717f, 0.00392137f, 0.02356188f, -0.02074029f, 0.02415951f, -0.02343616f, 0.02345113f, -0.00012235f, 
    -0.02050813f, -0.00405708f, -0.00322281f, -0.02912219f, -0.01379146f, 0.01660783f, -0.02329037f, 0.02496869f, 
    -0.04330949f, 0.01411394f, -0.00669774f, -0.04149377f, -0.02111701f, -0.02516068f, 0.01348668f, 0.02511455f, 
    0.00288029f, -0.04432476f, -0.02233570f, 0.02609675f, -0.00953873f, -0.03685556f, 0.00989695f, 0.01763866f, 
    0.00114363f, 0.00230267f, -0.02319208f, 0.01088445f, -0.03627616f, -0.01949047f, -0.00274546f, 0.00382835f, 
    -0.02682741f, 0.00982373f, 0.01903473f, -0.02662119f, 0.00765662f, 0.01989217f, 0.01179757f, 0.02040704f, 
    -0.03266005f, -0.02829836f, -0.01442288f, 0.00035347f, 0.01393777f, -0.02230337f, -0.03460534f, -0.00364463f, 
    -0.04407691f, -0.00172324f, 0.00545925f, -0.01627786f, -0.03029212f, 0.02595185f, -0.00077987f, -0.03295843f, 
    0.01977803f, -0.03559439f, -0.00173282f, 0.00324918f, -0.04145034f, 0.02131748f, 0.02226754f, -0.01773277f, 
    0.01409157f, -0.02371424f, 0.02711606f, -0.02610944f, -0.03496674f, 0.02174634f, 0.02728950f, 0.02298643f, 
    -0.00001085f, -0.02951383f, -0.03366850f, 0.02444233f, 0.02010753f, -0.00478721f, -0.00459220f, 0.02068837f, 
    0.00239950f, -0.04134344f, -0.04193826f, -0.02105878f, 0.02153902f, -0.03180233f, -0.00248103f, -0.02047171f, 
    0.02639905f, 0.03426308f, -0.01058739f, -0.02587186f, -0.03217311f, -0.03895723f, -0.01597555f, 0.00107225f, 
    -0.00109086f, 0.00352879f, -0.00326971f, -0.03345341f, -0.02818921f, -0.04321409f, -0.01694778f, -0.03637359f, 
    -0.01452407f, -0.00976739f, 0.02161512f, -0.01269783f, -0.04097175f, 0.01107260f, -0.00463772f, -0.01857238f, 
    -0.04435064f, 0.00993970f, 0.00409524f, 0.00238257f, 0.00411968f, 0.01749367f, 0.00683022f, -0.01422841f, 
    -0.02745933f, -0.04536376f, -0.01127265f, -0.04345509f, 0.01019420f, -0.00725631f, -0.04355988f, -0.02316196f, 
    -0.00314408f, -0.01957076f, -0.02106019f, -0.04067748f, -0.03361309f, -0.02014280f, -0.00123910f, 0.00550083f, 
    -0.03141369f, 0.02044245f, -0.03580661f, -0.01947228f, 0.01677271f, 0.02271369f, 0.00275646f, -0.02534682f, 
    -0.00902492f, 0.01818451f, -0.02877815f, -0.03691471f, -0.04241071f, -0.02186325f, 0.02117781f, -0.00039049f, 
    -0.01071938f, -0.03763352f, -0.02735590f, 0.00204229f, -0.03706650f, 0.03244589f, -0.02576574f, -0.01931202f, 
    -0.02913678f, -0.02983119f, 0.02229413f, 0.01229751f, -0.00515046f, -0.03207439f, -0.01220883f, -0.00572941f, 
    -0.00818108f, -0.02049249f, -0.01065350f, 0.00152211f, 0.01308096f, -0.01503675f, 0.02101768f, 0.02407862f, 
    -0.01064295f, -0.02857383f, 0.02702880f, -0.02543218f, 0.02266400f, -0.00731505f, -0.04161844f, 0.02266627f, 
    0.00916688f, -0.03642012f, -0.03109673f, 0.01336698f, -0.01229632f, -0.00811722f, 0.02246059f, 0.00769470f, 
    -0.00216696f, -0.00393140f, 0.00118986f, 0.02187336f, -0.03513453f, 0.02046391f, -0.02399921f, -0.00885210f, 
    -0.03774435f, 0.00150342f, 0.02613332f, 0.00706107f, -0.03975087f, -0.04190357f, 0.02193017f, -0.00181164f, 
    -0.04319345f, 0.02431916f, -0.03731572f, -0.01755142f, 0.01378782f, -0.02002830f, -0.00159637f, -0.01839232f, 
    -0.01597851f, -0.01567157f, -0.03534449f, -0.02658379f, -0.00468145f, -0.02902220f, 0.00920640f, 0.01933073f, 
    -0.01667175f, -0.01706602f, -0.00380095f, -0.02771733f, 0.01726701f, 0.01593303f, 0.00836390f, -0.02302519f, 
    -0.04051661f, 0.00535960f, -0.00253751f, -0.03555764f, 0.01258674f, 0.02774522f, -0.02347468f, 0.02230331f, 
    -0.00112124f, -0.01139592f, 0.01603713f, -0.00482357f, -0.00239215f, -0.01318408f, -0.03739354f, 0.00261509f, 
    0.01674409f, -0.01136492f, -0.01448041f, -0.02269711f, 0.01696354f, 0.02753369f, -0.00317769f, -0.02746123f, 
    0.01787224f, -0.02703482f, 0.02336781f, -0.02773645f, 0.01405145f, 0.01766309f, -0.01849247f, 0.00717964f, 
    0.01284519f, -0.03599040f, -0.00357738f, -0.01549987f, -0.01711815f, -0.02346863f, 0.01906765f, -0.02968304f, 
    -0.00009849f, -0.03375768f, -0.02168034f, -0.04045443f, -0.03970268f, 0.01917801f, -0.03892639f, 0.02339089f, 
    -0.00624643f, 0.02811204f, 0.02469416f, -0.01190080f, -0.00789309f, -0.00127480f, -0.01421057f, -0.00669681f, 
    -0.03137606f, -0.04340061f, -0.04009384f, -0.01239297f, -0.03275317f, 0.02255519f, 0.01849949f, 0.00520547f, 
    0.02654455f, 0.01686919f, 0.01842945f, -0.03517869f, 0.02198905f, -0.01286077f, -0.02081960f, 0.01367086f, 
    0.02207463f, 0.00583017f, -0.01078276f, -0.04185565f, -0.00486324f, -0.02910832f, -0.03135929f, -0.00841218f, 
    -0.03997623f, 0.02540108f, -0.02766994f, -0.00628813f, 0.01165868f, -0.01104103f, 0.01951350f, 0.00239035f, 
    -0.04362701f, 0.01752827f, 0.01674294f, 0.01195355f, -0.04179300f, 0.01866279f, -0.02260946f, 0.00839498f, 
    -0.01825019f, 0.00046046f, 0.02467109f, 0.00213693f, -0.03139258f, -0.01622661f, 0.01898023f, 0.01837967f, 
    -0.03856850f, -0.02354734f, 0.02923049f, 0.00396033f, -0.00295203f, -0.00788187f, 0.02158146f, -0.01236941f, 
    0.01879285f, -0.00201372f, 0.02058431f, 0.02274849f, 0.01912043f, 0.00285369f, -0.04313475f, -0.01595624f, 
    0.01791423f, -0.04093223f, -0.02605681f, 0.00535984f, -0.00723158f, 0.01052759f, 0.02466285f, -0.00212140f, 
    -0.00390609f, 0.01354731f, -0.02976181f, 0.02108920f, -0.02149899f, -0.03819297f, -0.00445548f, -0.02078886f, 
    -0.00836993f, -0.03485725f, -0.00906556f, -0.02484262f, 0.01504832f, -0.02288190f, 0.01048417f, 0.01177480f, 
    -0.00061698f, -0.01692497f, -0.03679490f, -0.04267411f, 0.01512554f, -0.01072070f, -0.00108646f, -0.02798277f, 
    -0.01196586f, 0.01023673f, 0.00035483f, -0.01215269f, -0.02903527f, 0.01442095f, -0.02977640f, -0.02118747f, 
    0.00655755f, 0.00636977f, -0.00214211f, -0.01933804f, -0.04273782f, -0.02236043f, -0.01652725f, -0.03474698f, 
    0.00627416f, -0.02399860f, 0.01790166f, 0.02388623f, 0.01818913f, -0.03007871f, -0.01161453f, -0.03418364f, 
    0.02579418f, -0.00182515f, -0.02283050f, 0.00920104f, -0.00318628f, -0.00453325f, -0.00748261f, 0.02061795f, 
    0.02742432f, -0.03486687f, 0.00730842f, -0.00935078f, 0.01224510f, -0.03599875f, -0.03161241f, -0.00483964f, 
    0.00983519f, -0.02069015f, -0.03405944f, -0.00686160f, -0.01663469f, -0.01482094f, 0.01080404f, -0.00502248f, 
    -0.03158997f, 0.02409483f, 0.01217453f, 0.01953092f, 0.00017133f, 0.00026480f, -0.02291501f, -0.03657469f, 
    0.01020531f, 0.01044788f, 0.02097224f, -0.00959417f, -0.00566883f, -0.00918855f, 0.02057238f, 0.02196587f, 
    0.00095481f, -0.03607071f, 0.00892177f, 0.02586602f, 0.02120253f, 0.01840910f, 0.00923702f, 0.02541381f, 
    0.00420815f, 0.02505198f, -0.01185229f, -0.01053633f, 0.00588751f, -0.03726197f, 0.01164416f, 0.01537290f, 
    -0.00967196f, 0.01364589f, -0.00481965f, -0.04163207f, -0.03883877f, -0.01801701f, 0.01381772f, 0.02264054f, 
    -0.02005398f, -0.01558934f, -0.03500115f, -0.01189266f, -0.02791063f, -0.00120408f, -0.02487293f, -0.03477236f, 
    0.00602742f, -0.03740848f, -0.00022316f, 0.02317526f, -0.04128705f, -0.00452552f, 0.01623870f, 0.00851892f, 
    0.00909922f, -0.03649191f, -0.01225938f, -0.02969641f, -0.03508477f, -0.01466351f, 0.00574076f, 0.02096300f, 
    0.02619360f, -0.02851315f, 0.01063613f, -0.02108520f, 0.02183837f, 0.01703330f, -0.03311060f, 0.02216144f, 
    -0.02210269f, -0.00347291f, -0.03611010f, -0.00911965f, -0.03666228f, 0.01753997f, -0.01736862f, 0.00930771f, 
    0.00465500f, 0.02005582f, -0.01795433f, -0.00910003f, -0.03705251f, -0.03988206f, 0.02579607f, -0.00675764f, 
    -0.00718209f, -0.01530089f, -0.02441357f, -0.02425637f, -0.01114753f, -0.03776861f, -0.03130937f, -0.01796638f, 
    -0.01864694f, -0.02950337f, 0.01324089f, -0.03927898f, -0.01701632f, -0.02218345f, -0.04363311f, -0.00076021f, 
    0.02273339f, -0.02073086f, -0.00520618f, 0.01186030f, -0.03641513f, 0.01470918f, 0.01112172f, -0.04079238f, 
    -0.00684323f, -0.02281093f, -0.00094720f, -0.02827153f, -0.03272792f, -0.00343913f, 0.00673050f, -0.03031415f, 
    0.02121154f, -0.04179092f, -0.01653344f, -0.02321647f, 0.02788705f, -0.03246929f, -0.01910504f, -0.00907307f, 
    -0.00573088f, 0.01818314f, 0.01316958f, -0.02942313f, 0.00043783f, 0.00139861f, 0.01707655f, -0.02702757f, 
    0.00324567f, 0.00946616f, -0.02378744f, 0.00488305f, 0.00390194f, -0.00347466f, -0.01676863f, -0.00804428f, 
    -0.02628109f, -0.01757054f, -0.03345760f, 0.00750331f, -0.03232201f, -0.01389374f, -0.00531970f, -0.03623341f, 
    0.00123968f, 0.00933271f, 0.00241388f, -0.02776209f, -0.00072263f, 0.00408440f, 0.02129644f, -0.01141760f, 
    0.00242541f, 0.01823258f, -0.00671351f, -0.04166701f, 0.01624571f, -0.03031849f, -0.02576258f, 0.02262074f, 
    -0.01546775f, 0.02127857f, 0.01068853f, -0.00180565f, -0.04326998f, -0.00544643f, 0.02232985f, -0.02774105f, 
    -0.02949371f, -0.01331202f, 0.01538432f, -0.03728934f, -0.00818291f, 0.02390352f, 0.01471545f, 0.01049099f, 
    -0.00671012f, 0.00506863f, -0.03761549f, -0.03330850f, -0.00495764f, -0.00788819f, -0.02456162f, 0.02254926f, 
    -0.02539418f, -0.03184448f, -0.01992105f, -0.01249717f, -0.02753022f, -0.00792946f, 0.00992799f, -0.01581681f, 
    -0.01550916f, -0.02849702f, -0.03401973f, 0.02439627f, 0.01141805f, -0.02933836f, -0.04308422f, 0.01960585f, 
    -0.01240053f, 0.01869830f, -0.02299972f, -0.03160662f, 0.01742470f, 0.02095790f, -0.00075635f, -0.00410847f, 
    -0.00600542f, 0.01630476f, 0.01965023f, -0.01336898f, -0.00381337f, -0.01336665f, -0.00228362f, -0.00314043f, 
    -0.00586533f, 0.02412756f, 0.01465816f, -0.02524351f, -0.02944192f, -0.03079490f, -0.03185377f, -0.02525941f, 
    0.00396349f, -0.03078698f, -0.01189531f, -0.00673288f, 0.02029934f, -0.03648064f, -0.01468036f, 0.02597962f, 
    -0.01257906f, -0.03711616f, -0.00942809f, -0.04140474f, -0.03287334f, 0.02333841f, -0.03473980f, 0.02756198f, 
    0.02622883f, 0.00933217f, -0.01981945f, -0.02210467f, -0.03997811f, -0.03494518f, -0.01842957f, 0.01211356f, 
    0.02637018f, 0.00224034f, -0.01105257f, 0.00522021f, 0.02654501f, 0.00846282f, 0.02469696f, 0.00561329f, 
    0.01893016f, 0.00489541f, 0.00318853f, -0.02803637f, 0.01904262f, -0.02727280f, -0.02177481f, 0.01186952f, 
    -0.02237890f, 0.00003383f, -0.02814591f, 0.01734975f, -0.03884557f, 0.02723277f, -0.00461643f, -0.03217340f, 
    -0.01861732f, 0.01718845f, 0.00998286f, 0.01918394f, 0.02479373f, -0.00582810f, 0.01656770f, 0.02327237f, 
    -0.04363471f, 0.01595245f, -0.03500832f, -0.00941626f, -0.02633801f, -0.03907088f, -0.04035802f, -0.01443887f, 
    0.00264161f, -0.00117055f, -0.00654841f, 0.02634128f, -0.02706113f, -0.02978667f, -0.02334883f, 0.01331521f, 
    -0.04194969f, -0.01419584f, -0.03807456f, 0.02619544f, -0.01372888f, -0.03923194f, 0.01739569f, 0.01346825f, 
    0.00045968f, 0.00222399f, 0.00842527f, -0.01558306f, -0.03565892f, 0.01510081f, 0.00294321f, -0.01942908f, 
    -0.00875749f, -0.03443763f, -0.03559450f, 0.01839708f, 0.00160199f, 0.00080477f, 0.02302636f, 0.02416798f, 
    0.01354553f, -0.04341971f, -0.02790591f, -0.01062745f, -0.02982816f, -0.02394192f, -0.00496400f, -0.02222487f, 
    -0.02738393f, 0.00480038f, -0.02809990f, 0.02554408f, -0.03637758f, -0.01864907f, -0.03558113f, -0.03829391f, 
    -0.03209718f, -0.03692285f, 0.01608394f, 0.02360589f, -0.01058451f, -0.03816866f, -0.00247341f, -0.03532852f, 
    0.00219416f, -0.02841713f, -0.02568535f, -0.03894169f, 0.01662156f, 0.02531778f, -0.03121866f, 0.01691296f, 
    0.00162461f, -0.03083534f, -0.02401223f, -0.01998283f, 0.01265828f, -0.03036455f, -0.00943008f, 0.00065338f, 
    -0.03825975f, -0.01233364f, 0.02609337f, -0.01884046f, -0.02692844f, 0.01302159f, -0.02404770f, 0.01087624f, 
    0.01929656f, -0.03106257f, 0.02005905f, 0.02392903f, -0.00854087f, 0.01429217f, -0.01643510f, -0.02528173f, 
    -0.02504607f, -0.04071308f, 0.02865764f, -0.03823480f, -0.02724137f, -0.00588772f, 0.02584765f, 0.02292255f, 
    -0.02934126f, 0.01563991f, -0.02259217f, -0.03767283f, -0.00611421f, 0.00722020f, -0.01080563f, -0.03857544f, 
    0.02364740f, 0.00058178f, -0.01540842f, -0.03383294f, -0.00199006f, -0.00649033f, 0.00095078f, -0.03918745f, 
    -0.04060067f, -0.01241524f, -0.02551745f, 0.01237294f, -0.01025996f, 0.00965187f, -0.03227837f, 0.01058521f, 
    0.02240331f, -0.01756368f, 0.01962118f, -0.03403923f, -0.00366649f, 0.00781843f, 0.01621224f, 0.02490138f, 
    -0.02728131f, -0.03178341f, -0.03385966f, -0.00877582f, -0.03786388f, 0.00439426f, 0.01887645f, -0.00241869f, 
    0.01801415f, -0.02437982f, -0.01559224f, 0.01666276f, -0.02259332f, -0.01248911f, 0.00233127f, 0.00355128f, 
    0.02638419f, 0.00008306f, -0.00603908f, -0.00997817f, -0.00731515f, 0.01819013f, 0.00576987f, -0.01877101f, 
    0.00708377f, 0.01183167f, 0.00486074f, -0.03034747f, 0.02820256f, -0.01595285f, -0.02896659f, 0.01170629f, 
    -0.02528657f, -0.03103031f, 0.02557987f, 0.00653870f, -0.02101996f, 0.00840748f, -0.00532883f, 0.00763828f, 
    -0.03402106f, -0.01113632f, -0.02952943f, -0.00225764f, 0.00481724f, 0.00437516f, 0.01808698f, 0.01787618f, 
    -0.00998864f, -0.03567771f, -0.03683776f, -0.04079983f, 0.00191172f, -0.00426852f, 0.01202276f, 0.00348831f, 
    -0.03227759f, 0.02131497f, -0.03292166f, -0.02178694f, 0.02554114f, -0.01172488f, 0.01645821f, -0.02671560f, 
    -0.02724696f, -0.04335491f, -0.00386342f, -0.01798867f, 0.02327705f, -0.02777963f, 0.00538082f, 0.02012529f, 
    0.16318899f, 0.01691666f, 0.34391978f, 0.30288103f, 0.00735622f, 0.06424429f, -0.03032827f, -0.20325668f, 
    -0.01575570f, -0.05167075f, 0.03568353f, -0.08024438f, 0.12429553f, 0.09682783f, 0.10007384f, 0.05657818f, 
    -0.01394355f, 0.12048835f, 0.21485744f, -0.05191355f, -0.04203400f, 0.10549221f, 0.08657083f, 0.06088979f, 
    0.03065240f, 0.04925653f, -0.31484017f, 0.00578732f, -0.02119520f, -0.05441387f, 0.08456441f, -0.20568174f, 
    -0.00430242f, -0.00566674f, -0.00236021f, -0.00950273f, -0.02321655f, 0.01342559f, -0.07174279f, 0.05040028f, 
    0.05960309f, 0.02943807f, 0.03123813f, -0.04705384f, -0.01964151f, -0.04031976f, 0.14590141f, -0.01773018f, 
    0.09917598f, -0.07622142f, 0.17859772f, -0.19086553f, -0.04984412f, -0.00567591f, -0.04303053f, 0.08544689f, 
    -0.06940866f, -0.02195039f, 0.07127989f, -0.01705562f, 0.10888758f, -0.16573210f, 0.28462586f, -0.08910272f, 
    -0.06057412f, 0.07573948f, -0.02875818f, 0.05331202f, -0.03929222f, -0.13421373f, 0.11703438f, -0.09659935f, 
    0.13198636f, 0.00316357f, 0.12015231f, 0.03588173f, -0.02869535f, 0.02241358f, -0.05147603f, 0.06405146f, 
    -0.09452979f, 0.05126869f, -0.04431891f, -0.08971991f, 0.10889855f, 0.08433007f, -0.02030747f, 0.20791452f, 
    -0.04196727f, 0.01694256f, 0.05640198f, 0.15922865f, 0.07271513f, 0.07589802f, -0.03137643f, -0.07805105f, 
    -0.01017853f, -0.09884903f, 0.03457712f, -0.06355925f, 0.00725184f, -0.00756479f, -0.03821399f, -0.03030116f, 
    -0.11372799f, -0.02490720f, -0.07651441f, -0.03659493f, 0.05286243f, 0.09841730f, -0.03715494f, -0.18771878f, 
    -0.13400625f, 0.00010787f, 0.05956407f, -0.08714110f, -0.03789005f, -0.08284905f, -0.07135399f, -0.07250562f, 
    -0.04893932f, -0.09297942f, -0.02394898f, -0.05923553f, 0.00404697f, 0.01421391f, 0.07463992f, 0.02681982f, 
    0.04270208f, 0.12117068f, 0.03989763f, 0.04103431f, -0.08663171f, -0.19450556f, 0.04407445f, -0.03456010f, 
    0.01696713f, -0.12731940f, -0.03112058f, -0.02385854f, -0.04210537f, 0.03896558f, -0.00345534f, 0.06393357f, 
    0.06496370f, 0.07043274f, -0.03564435f, -0.15234438f, -0.00992052f, -0.04101939f, 0.01190550f, 0.05275663f, 
    0.06120676f, -0.00463795f, -0.00062876f, -0.00047396f, 0.10691041f, -0.08831076f, 0.06090294f, 0.06516755f, 
    0.00472116f, 0.02902611f, 0.06187665f, 0.11057289f, -0.09965169f, -0.02769781f, -0.04194232f, 0.12700321f, 
    -0.02973477f, -0.21453618f, 0.28549594f, -0.06071402f, -0.11641188f, -0.02390142f, 0.13397482f, -0.12034012f, 
    0.04028162f, 0.09251075f, -0.05298250f, 0.04781765f, 0.06522348f, -0.15742059f, -0.01663517f, -0.15155986f, 
    0.03594914f, -0.03201032f, -0.03762126f, -0.01007468f, 0.03513354f, -0.10543031f, 0.06930388f, -0.04804702f, 
    -0.10398195f, 0.35077539f, 0.12002539f, 0.30046242f, -0.05663656f, 0.04486122f, -0.04163023f, 0.03568595f, 
    0.07863057f, 0.08582996f, 0.04602387f, 0.02801882f, -0.01519184f, 0.00777693f, -0.13808019f, 0.03026501f, 
    0.04010748f, 0.16866708f, 0.06477694f, 0.03806168f, -0.13065636f, -0.02514026f, -0.04439833f, 0.03930187f, 
    0.16311209f, 0.19299822f, -0.10614279f, -0.22385274f, 0.09380738f, 0.07518697f, 0.10795620f, 0.07827544f, 
    -0.09494362f, 0.03814434f, 0.05744806f, -0.00197958f, -0.01912270f, -0.38092113f, -0.04306974f, -0.12073158f, 
    0.12707479f, 0.00621556f, -0.03791733f, 0.02233422f, -0.02079879f, -0.01166914f, 0.02835516f, 0.03363346f, 
    -0.04195278f, 0.02605036f, -0.04140684f, -0.02302612f, 0.10198691f, 0.05000472f, -0.13955098f, 0.06318761f, 
    0.00239386f, 0.00498675f, 0.05304758f, 0.03832875f, -0.08716452f, 0.05671663f, 0.18172370f, -0.09073798f, 
    -0.05128784f, 0.01599540f, -0.00841640f, -0.00735130f, -0.04563365f, 0.14862296f, -0.10001402f, 0.04283911f, 
    -0.02162063f, 0.11316760f, -0.01914721f, -0.01566949f, -0.05974100f, 0.00555297f, 0.00339039f, 0.01104336f, 
    -0.13902779f, -0.05376674f, 0.00508973f, -0.09119172f, 0.31859562f, 0.01348515f, -0.06486227f, -0.20055217f, 
    -0.01101679f, -0.01338608f, 0.01664229f, 0.06362447f, -0.03671939f, 0.15119536f, 0.12742196f, 0.12113170f, 
    -0.03135719f, 0.03259907f, 0.09056764f, -0.00191980f, -0.05678223f, 0.01442442f, -0.00382565f, 0.02995218f, 
    -0.02150584f, 0.05709719f, 0.05472274f, -0.00071433f, -0.20871824f, 0.62980771f, -0.51461095f, 0.49376434f, 
    0.00310572f, 0.08732869f, -0.06797284f, -0.04278505f, -0.05845090f, 0.05735397f, 0.09003371f, 0.06239864f, 
    -0.10645933f, 0.15027499f, -0.13459457f, 0.17191285f, -0.15459073f, -0.00487481f, 0.02983576f, -0.03612009f, 
    -0.07962196f, 0.12461990f, -0.06131781f, 0.12549435f, -0.12840118f, 0.21858174f, -0.05376781f, -0.04033935f, 
    0.03199316f, -0.03311218f, 0.02728965f, 0.09795357f, 0.00274404f, 0.12076388f, 0.01639105f, 0.12988076f, 
    0.14748843f, -0.00592251f, 0.10822849f, -0.02777793f, 0.09622527f, 0.06501469f, -0.10026363f, 0.10688605f, 
    -0.05636374f, 0.03706597f, 0.09414284f, -0.14835580f, -0.31651428f, 0.23244447f, -0.04977557f, -0.07891917f, 
    0.02443890f, 0.16390319f, 0.04960836f, 0.06852028f, -0.04740790f, 0.05712980f, 0.06046309f, 0.00607210f, 
    -0.04134591f, 0.02624091f, -0.22870250f, -0.27115089f, 0.08008279f, -0.04774256f, -0.10331649f, 0.02898850f, 
    -0.07933484f, 0.00645144f, -0.08589873f, 0.04186732f, -0.11502197f, -0.05355655f, -0.08877519f, 0.00122827f, 
    0.03278479f, -0.03251471f, 0.11815967f, -0.04924400f, 0.09963398f, 0.01033661f, -0.05227692f, 0.16234195f, 
    -0.08080468f, -0.04784730f, 0.01384075f, -0.01387040f, 0.01784053f, -0.09823194f, -0.09334730f, 0.03064259f, 
    -0.10523510f, -0.04577210f, 0.00231475f, 0.02117171f, -0.08858509f, 0.13811330f, 0.02223144f, 0.01599961f, 
    -0.07174827f, 0.04811475f, -0.02841242f, -0.00385808f, 0.01078753f, 0.03061860f, 0.05505111f, 0.01781667f, 
    0.34515187f, -0.01013490f, 0.08991531f, 0.15518583f, 0.05207148f, 0.10571229f, 0.07318423f, -0.03485101f, 
    0.04821322f, 0.09515652f, 0.02988457f, -0.06141049f, 0.16501266f, -0.17666833f, 0.00542970f, -0.13614021f, 
    0.09980162f, 0.10576231f, -0.05961972f, -0.01257805f, 0.05023992f, 0.02320046f, 0.01006678f, 0.03967384f, 
    0.32936141f, 0.03240104f, -0.19833733f, 0.28408039f, 0.04019419f, 0.04581004f, -0.02197629f, 0.18343106f, 
    -0.01125900f, 0.03111462f, 0.07588672f, 0.28283104f, 0.11980338f, -0.15838593f, 0.28273138f, -0.09519229f, 
    -0.01245483f, 0.07848044f, 0.00826650f, 0.00780622f, 0.04170526f, 0.01499514f, 0.04145056f, 0.07150022f, 
    0.10658015f, 0.15947479f, -0.30522227f, 0.16501138f, 0.22427292f, -0.07691309f, 0.10650625f, -0.06076472f, 
    -0.02880536f, -0.00602674f, 0.02026271f, -0.01766740f, -0.18869230f, 0.18321463f, -0.01444066f, 0.01317355f, 
    -0.04649812f, 0.17074397f, 0.00782008f, 0.16454139f, -0.22872518f, 0.01233876f, 0.00193645f, -0.03951913f, 
    0.00667970f, -0.01757939f, -0.04112173f, -0.00309032f, -0.02606521f, 0.13546075f, -0.02088263f, 0.03101381f, 
    -0.06246175f, -0.09659184f, -0.03725898f, 0.05426435f, 0.27695784f, -0.02319363f, 0.33780682f, 0.22885758f, 
    -0.00867886f, 0.19445066f, -0.08558572f, 0.00006304f, -0.00336745f, -0.03466902f, 0.05710985f, 0.02644247f, 
    0.12817530f, -0.04774937f, -0.19175771f, -0.02282864f, 0.02188122f, 0.08646663f, -0.00400580f, 0.03527341f, 
    -0.00005022f, 0.14170243f, 0.20188543f, -0.01761431f, 0.05091245f, 0.02062295f, -0.05840666f, -0.13451590f, 
    0.01320769f, 0.01839457f, -0.02595752f, 0.03832356f, -0.15042989f, 0.02435451f, -0.05702390f, -0.01776128f, 
    0.27999219f, -0.04290104f, 0.08924208f, 0.03465264f, 0.11982781f, 0.02271034f, 0.10264812f, 0.07834476f, 
    0.01953142f, 0.11461896f, 0.02015655f, 0.04852032f, -0.01319376f, -0.00058355f, 0.08035038f, -0.03833840f, 
    -0.00384861f, -0.04262372f, 0.02138115f, 0.03320995f, 0.06299169f, -0.06820828f, 0.15111016f, 0.05393121f, 
    0.02907564f, -0.07553272f, -0.22522622f, -0.04751164f, 0.05852726f, 0.03586614f, -0.11514489f, -0.15153851f, 
    -0.05504487f, -0.01240076f, -0.04686277f, -0.04113020f, -0.20890541f, 0.06635262f, -0.14663884f, 0.05651741f, 
    0.11538759f, -0.05253807f, 0.03420172f, -0.00121620f, 0.09810481f, 0.09573819f, 0.03573862f, 0.07808725f, 
    0.01196074f, -0.00341272f, 0.33315399f, -0.15128340f, -0.09867705f, 0.05426418f, 0.02460224f, -0.10253021f, 
    -0.06838189f, 0.02945285f, -0.06616518f, -0.03243376f, 0.02131571f, 0.01723951f, -0.00228916f, -0.00162049f, 
    0.15771341f, -0.08020286f, -0.05341766f, 0.00489644f, -0.03042977f, 0.05393290f, 0.05041222f, -0.02153525f, 
    0.09946949f, -0.18638608f, 0.17274548f, -0.31095874f, -0.09265646f, 0.00766450f, 0.02940270f, -0.19256347f, 
    -0.01009733f, -0.01868122f, 0.08534652f, 0.03996476f, -0.04973040f, -0.12595643f, -0.18449408f, 0.19003956f, 
    -0.01478786f, 0.03233093f, -0.08389571f, 0.02239951f, -0.07292762f, 0.06664251f, -0.03220756f, -0.00250754f, 
    0.22598320f, 0.18266965f, -0.44189706f, -0.12682302f, 0.04099027f, 0.12073399f, 0.13067737f, 0.10083845f, 
    0.00734972f, 0.05192413f, 0.03397046f, 0.06772294f, -0.25608411f, 0.00718440f, -0.11481050f, 0.26245815f, 
    0.01071550f, -0.09181546f, 0.15504730f, -0.08522516f, -0.07186075f, 0.08590922f, 0.03165365f, 0.10486984f, 
    0.12867929f, -0.06254350f, 0.09620977f, -0.12659854f, -0.01105742f, -0.05947858f, -0.01306220f, 0.13872431f, 
    -0.13337697f, 0.13970360f, -0.05438562f, 0.04380902f, -0.07155078f, -0.06005675f, 0.19982409f, -0.07590061f, 
    0.08091206f, 0.04490133f, 0.07560915f, -0.00442976f, -0.04209615f, 0.08915489f, 0.01813291f, -0.02665775f, 
    0.13277888f, -0.24776445f, 0.41053915f, -0.10106171f, -0.02944604f, 0.00312434f, -0.08219154f, -0.00858213f, 
    0.01053939f, 0.07517169f, -0.14979166f, -0.06636804f, 0.53371507f, 0.25318784f, 0.21588109f, 0.19722551f, 
    0.15945622f, 0.04803600f, 0.01297526f, 0.01875428f, -0.04965938f, 0.02828871f, -0.04348208f, 0.01494093f, 
    0.08280153f, -0.04581776f, -0.06581812f, -0.24477671f, -0.07753500f, 0.02833589f, -0.05456766f, -0.07139456f, 
    -0.10031033f, -0.03921460f, -0.08531838f, -0.03960482f, 0.11434177f, -0.11779212f, 0.18670496f, -0.14506853f, 
    -0.14549962f, -0.07886045f, -0.03218041f, -0.01637072f, -0.07183671f, -0.02944505f, 0.02464701f, 0.04154867f, 
    -0.16743965f, -0.01709120f, 0.31561011f, -0.11372550f, -0.01812659f, -0.02734309f, 0.00462595f, -0.01136746f, 
    -0.01496985f, -0.02061321f, 0.10384572f, -0.00576964f, 0.01805518f, 0.11869872f, -0.00734820f, -0.10288172f, 
    -0.02003904f, 0.10492165f, -0.00734786f, 0.26463476f, 0.06688999f, 0.16695738f, 0.04015186f, -0.04500981f, 
    0.06612372f, -0.09771025f, 0.20178527f, -0.08266505f, -0.15517130f, 0.08587914f, -0.03442673f, 0.01469886f, 
    -0.08369045f, -0.03854721f, 0.04628215f, -0.03617363f, -0.07704368f, -0.08501342f, -0.33633494f, -0.06264790f, 
    0.09119122f, 0.04404899f, 0.15128438f, -0.03875001f, 0.02174013f, -0.03827015f, -0.00640464f, 0.00984662f, 
    -0.02853614f, -0.00275607f, 0.01504772f, 0.00528629f, 0.00713632f, -0.02851210f, -0.04041323f, 0.02587561f, 
    0.02069214f, 0.02893060f, -0.03121067f, 0.00121764f, 0.01193894f, 0.01814597f, 0.01405610f, -0.03037623f, 
    0.01512673f, 0.01902804f, -0.00955342f, 0.03218085f, -0.00354259f, -0.01441381f, 0.02181702f, 0.01785127f, 
    -0.02032681f, -0.03006278f, -0.02377807f, -0.01604841f, -0.02369298f, -0.00380907f, 0.00265239f, -0.02515956f, 
    0.00496124f, 0.02467935f, 0.00980857f, -0.00320507f, 0.02446210f, -0.02556229f, 0.01599433f, -0.02468695f, 
    -0.01593050f, -0.01681467f, -0.02768790f, -0.02406974f, 0.00182533f, 0.01696054f, -0.02341839f, -0.02644968f, 
    -0.03271785f, -0.00130365f, 0.03826501f, 0.01732948f, -0.03043202f, -0.01004663f, -0.01673809f, 0.02386375f, 
    -0.03789852f, -0.02353466f, -0.03564589f, -0.00321178f, 0.00905926f, 0.01908643f, 0.00348443f, -0.02192658f, 
    -0.00622900f, 0.01536667f, -0.00325310f, 0.00870030f, -0.00484849f, -0.01873156f, 0.00757330f, 0.00283643f, 
    0.00367913f, 0.02185925f, -0.03331338f, 0.00250398f, 0.00198077f, 0.01449001f, -0.01102784f, -0.00652726f, 
    0.01709336f, 0.01828343f, 0.01586859f, -0.01421902f, -0.00086263f, 0.01511993f, 0.00882995f, 0.01195136f, 
    0.02590133f, -0.03479483f, 0.00120376f, 0.01620977f, -0.01636111f, -0.00587294f, 0.00568009f, -0.00105685f, 
    -0.00902767f, 0.01846641f, -0.00267630f, 0.01931377f, -0.03186420f, -0.00463366f, -0.00036514f, -0.03201142f, 
    0.01281946f, 0.02357619f, 0.00041246f, -0.02896689f, 0.02806636f, 0.00963247f, -0.02392302f, -0.02780986f, 
    -0.01704914f, 0.00257147f, -0.01373597f, -0.00881907f, 0.02410633f, 0.00382567f, 0.02177973f, -0.04375012f, 
    -0.01647042f, -0.00684329f, 0.01383054f, -0.02837485f, -0.01927711f, -0.00120122f, -0.02112111f, 0.00391791f, 
    -0.00501167f, -0.00012087f, 0.01113226f, 0.03184549f, 0.01886229f, -0.01622530f, 0.03326240f, -0.01926899f, 
    -0.03583941f, 0.01622548f, -0.01460927f, -0.01306737f, -0.02969204f, 0.00566789f, -0.02804136f, 0.01295884f, 
    -0.01457454f, -0.03706523f, 0.01710295f, -0.02163940f, 0.01890644f, -0.01901159f, 0.01645053f, -0.04290445f, 
    -0.02462066f, -0.04106187f, -0.03700309f, 0.00701687f, 0.00968564f, 0.01557553f, 0.00351855f, 0.03764737f, 
    -0.00362559f, -0.03174965f, 0.00831177f, 0.01248691f, -0.01023918f, -0.04166742f, 0.01331643f, -0.00523098f, 
    -0.03520518f, 0.00634285f, -0.00435779f, 0.00596655f, -0.00962801f, -0.04317065f, -0.02037629f, 0.03229405f, 
    0.01916775f, -0.00172218f, -0.03776063f, -0.01404263f, 0.02036548f, -0.00600961f, 0.00569900f, -0.04160337f, 
    0.02733316f, 0.03350389f, -0.00437219f, 0.03114565f, -0.02689919f, 0.01198781f, 0.01951694f, -0.02440248f, 
    -0.01086959f, 0.01684054f, -0.03456962f, -0.01323520f, -0.01602502f, -0.02519410f, -0.01783095f, 0.00564845f, 
    -0.00783396f, 0.00583183f, 0.01562923f, 0.01274177f, -0.01928126f, -0.02731464f, -0.01952242f, -0.01650409f, 
    0.03212427f, -0.02856227f, -0.02263677f, 0.02666038f, -0.01095244f, 0.00829982f, -0.01996807f, 0.00648677f, 
    0.02305218f, -0.01595509f, -0.01596290f, -0.02372237f, -0.00840117f, -0.02857040f, -0.01677750f, -0.00948206f, 
    -0.03114726f, 0.01426797f, -0.03855629f, -0.01436916f, 0.01516813f, -0.00769991f, 0.01188687f, -0.00309319f, 
    -0.02497896f, -0.02296456f, 0.00380682f, 0.00567955f, 0.00971649f, -0.02544444f, -0.00746411f, -0.02030630f, 
    0.02303902f, 0.02565179f, -0.02716208f, 0.00691842f, 0.00068080f, 0.02623865f, 0.02729440f, 0.01332028f, 
    0.00173002f, -0.02756576f, -0.03150914f, -0.03185002f, -0.03222404f, 0.00089360f, -0.03305206f, 0.00513498f, 
    -0.00415246f, -0.03208290f, -0.01377970f, -0.02210987f, -0.01945123f, -0.00254259f, -0.01811476f, -0.02555013f, 
    0.00212057f, 0.03239400f, 0.00521150f, 0.02847916f, 0.00294567f, 0.00850535f, -0.03057502f, 0.02540188f, 
    -0.00883644f, 0.00681921f, -0.00155649f, -0.03480813f, -0.02028268f, -0.03402640f, -0.01158654f, 0.00633034f, 
    -0.03413583f, 0.02435253f, -0.04430381f, 0.00464471f, 0.02328660f, -0.02961840f, 0.02154143f, -0.03439204f, 
    -0.00872584f, 0.01193226f, -0.03552706f, 0.02468091f, 0.01025977f, -0.02649848f, 0.02108463f, 0.01406936f, 
    -0.00474438f, 0.00744676f, -0.03134993f, -0.01445161f, -0.04229775f, 0.03022039f, -0.02237039f, 0.00697919f, 
    0.00616382f, -0.03661834f, -0.02471987f, -0.02256691f, -0.03979180f, -0.00562118f, -0.01955615f, 0.00242205f, 
    -0.01632053f, -0.02984674f, -0.01606820f, 0.00409260f, -0.01269588f, 0.00047158f, 0.00790247f, 0.01646057f, 
    -0.00063357f, 0.00167291f, 0.02423053f, 0.01787996f, 0.02381524f, 0.00839552f, 0.00152076f, 0.01144864f, 
    0.01388618f, -0.04517750f, 0.02366192f, -0.02738492f, -0.03643611f, 0.00803590f, 0.02346330f, 0.00488572f, 
    -0.01447231f, 0.02270090f, -0.00964043f, 0.01361794f, -0.01500851f, 0.02922156f, -0.00077381f, 0.01675714f, 
    0.00293815f, -0.00445731f, -0.02665581f, 0.01099919f, 0.03281167f, -0.03525413f, -0.00435514f, 0.02233234f, 
    0.01403235f, 0.02502730f, -0.00447030f, -0.00980996f, -0.01621399f, 0.01648347f, -0.03088088f, -0.03513349f, 
    -0.00364305f, -0.03368359f, 0.00082224f, -0.00412738f, -0.00804930f, -0.03492193f, -0.02622093f, -0.02438828f, 
    0.02334108f, 0.00482683f, -0.00772153f, -0.03403041f, -0.00279895f, 0.03309407f, -0.02196943f, -0.00271193f, 
    -0.00013133f, 0.02188437f, -0.02271725f, 0.02204854f, 0.00171942f, -0.02420861f, -0.00396555f, 0.02944002f, 
    -0.01186064f, -0.01289750f, -0.02039070f, -0.02713428f, 0.02588570f, 0.03131604f, -0.02150662f, -0.03733394f, 
    -0.04528925f, -0.01692364f, -0.00526844f, -0.00660599f, -0.03821245f, 0.03144050f, -0.03198842f, 0.01593670f, 
    -0.04614076f, 0.01196234f, -0.03236815f, -0.04245972f, 0.00657836f, 0.01804025f, -0.04002446f, -0.02681149f, 
    -0.02983547f, -0.01217726f, 0.02042114f, -0.03117298f, -0.02143550f, -0.03650142f, -0.01889342f, -0.02210848f, 
    0.02496528f, -0.00048071f, -0.02346906f, -0.00105130f, -0.03573238f, -0.03447200f, -0.02293828f, -0.00357148f, 
    -0.02857117f, -0.02777326f, -0.03497207f, -0.02719079f, -0.01509817f, -0.03422367f, -0.04111874f, -0.03811235f, 
    0.02107880f, -0.00110006f, 0.00238594f, -0.00206221f, -0.03376454f, -0.00287630f, -0.01204018f, -0.04312322f, 
    -0.02361162f, -0.03417176f, 0.02461801f, -0.02240758f, -0.01897269f, 0.01430346f, -0.01481540f, -0.02202029f, 
    0.02595541f, -0.01928223f, -0.03925851f, 0.00227949f, 0.01110430f, -0.01841259f, 0.02914675f, -0.03014418f, 
    0.03602463f, 0.03651132f, -0.01210224f, -0.01550644f, 0.01520541f, -0.03134819f, -0.00726302f, 0.02165529f, 
    -0.01885991f, -0.00618640f, -0.00299472f, -0.02340215f, -0.00512390f, 0.01203610f, -0.01974885f, -0.03273107f, 
    0.00138856f, 0.01068935f, -0.02194740f, 0.01428360f, -0.02380892f, 0.02397848f, 0.00188556f, -0.01369142f, 
    0.00573485f, -0.02508025f, 0.01525689f, -0.01591576f, -0.01526241f, 0.02278205f, 0.03496888f, -0.01353685f, 
    0.00238736f, 0.02379461f, -0.02422878f, 0.01469189f, 0.02644982f, 0.01922195f, 0.00948434f, 0.01170200f, 
    0.01854414f, -0.01002175f, 0.00652721f, -0.03249362f, 0.01854709f, -0.00868935f, 0.00296475f, -0.03575660f, 
    0.03457426f, 0.00344473f, -0.03805643f, -0.02815952f, -0.02984415f, 0.00685046f, 0.01048192f, -0.02267700f, 
    0.00673487f, 0.00581230f, -0.03807417f, -0.00242604f, -0.00228151f, 0.01834184f, 0.00132195f, 0.02237542f, 
    -0.02636228f, 0.01755716f, -0.00018015f, -0.02208662f, 0.02715178f, 0.03132824f, 0.01276651f, 0.00508460f, 
    -0.01594732f, -0.02233263f, -0.02986616f, 0.01042601f, -0.02841328f, 0.00222724f, -0.02590271f, -0.01274552f, 
    0.00894682f, 0.02679902f, -0.00646882f, 0.01941419f, -0.01850790f, 0.03095158f, 0.00829361f, 0.02445778f, 
    -0.03897601f, 0.01460640f, 0.01363571f, -0.03329346f, -0.00569945f, 0.01487109f, 0.00528833f, 0.01830530f, 
    -0.00236955f, 0.00217193f, 0.01173984f, 0.00234060f, -0.02616634f, -0.00127397f, 0.00404421f, 0.01244572f, 
    -0.04276859f, -0.00935675f, 0.02454177f, 0.01672908f, -0.00806499f, -0.00772091f, 0.00598516f, 0.01605884f, 
    -0.00550131f, -0.01970221f, -0.03749651f, 0.00485798f, -0.02351794f, 0.01999488f, -0.03584671f, 0.00849653f, 
    0.02475561f, -0.03451200f, 0.01728358f, -0.02643235f, 0.02512726f, -0.00984090f, -0.03757898f, -0.00958289f, 
    0.02202182f, -0.00843045f, -0.03114590f, 0.00314817f, -0.01525339f, 0.01466898f, 0.02615646f, -0.03013587f, 
    0.01695882f, 0.00417714f, -0.04141371f, 0.00155856f, 0.00860490f, -0.02353483f, -0.02588248f, 0.02646263f, 
    -0.02396596f, -0.02966651f, 0.03023895f, 0.02714175f, 0.02124603f, 0.01452924f, -0.00508891f, -0.00462771f, 
    -0.02723968f, -0.02437296f, 0.02220688f, -0.02125327f, -0.00218513f, -0.01868140f, 0.00361567f, -0.04219060f, 
    0.01835685f, -0.01859893f, 0.02855705f, -0.03399229f, 0.02202626f, -0.00322780f, -0.01131197f, 0.01975725f, 
    0.03604643f, -0.00611433f, -0.00875865f, 0.02422844f, -0.00269664f, -0.00418736f, -0.03152731f, 0.00469198f, 
    0.02845098f, 0.02980203f, 0.00638352f, 0.01856985f, 0.01715897f, 0.00056689f, -0.01951460f, -0.02271853f, 
    -0.02267145f, -0.01046794f, 0.00806543f, 0.02307361f, -0.00922390f, -0.03591312f, -0.02063877f, 0.01979279f, 
    -0.04257924f, 0.00858724f, -0.01285602f, -0.02920442f, 0.00324067f, -0.02475824f, 0.02733150f, -0.03027073f, 
    -0.04216566f, -0.01714765f, -0.04297611f, -0.03888239f, -0.00583388f, 0.01093732f, -0.03318752f, -0.01308745f, 
    -0.01434166f, 0.00639011f, -0.02536267f, -0.02459485f, -0.00835552f, 0.00126258f, 0.00521653f, -0.02800726f, 
    0.01425451f, 0.03348035f, 0.02206439f, -0.01088710f, -0.01476608f, -0.02173124f, -0.01395969f, 0.01568030f, 
    -0.00787673f, -0.03962491f, -0.04025570f, 0.02798066f, 0.00434815f, 0.00453259f, -0.02734882f, -0.01277397f, 
    -0.03024137f, 0.01429942f, -0.00138999f, -0.00495479f, -0.03078067f, -0.01580648f, 0.00436660f, -0.02881967f, 
    0.00898304f, 0.01818181f, -0.01286796f, 0.02393122f, -0.01886572f, 0.01822405f, -0.02190899f, -0.02645874f, 
    -0.01008656f, -0.01372294f, -0.00250027f, 0.01869065f, 0.02307332f, 0.00454176f, -0.03111811f, -0.03449132f, 
    0.02593142f, -0.01756321f, -0.02870394f, 0.01029157f, 0.00411417f, -0.02513712f, -0.04153333f, -0.01076005f, 
    0.00443877f, 0.00556641f, 0.00965750f, 0.01232119f, -0.03548850f, -0.03486069f, 0.01561521f, -0.04208423f, 
    0.01343540f, -0.00473158f, -0.02458361f, -0.02662788f, -0.00517329f, 0.01484711f, -0.01789830f, -0.02441205f, 
    -0.00045798f, 0.02587907f, 0.00341446f, -0.00273215f, -0.01120766f, 0.02218434f, 0.00063296f, 0.00024886f, 
    -0.03328459f, -0.01412309f, 0.01102336f, 0.02583688f, -0.04300493f, 0.02252924f, -0.04430225f, -0.01046588f, 
    0.01018624f, -0.03571397f, -0.02892549f, -0.00378668f, -0.01560134f, -0.00209420f, -0.00822894f, -0.02031432f, 
    0.02542812f, -0.02479383f, -0.00433788f, 0.00138581f, 0.01155500f, 0.02186937f, -0.04130276f, -0.00055986f, 
    -0.12642252f, 0.01737388f, -0.01989779f, 0.02583115f, 0.01828659f, 0.14750476f, 0.27254027f, 0.03828854f, 
    -0.00699648f, -0.03739154f, -0.09395479f, -0.00544949f, -0.00884983f, 0.23286948f, -0.03678709f, 0.17834897f, 
    -0.19311363f, -0.12146029f, -0.05542650f, 0.00458488f, 0.05193799f, -0.07407260f, 0.00331431f, -0.12744206f, 
    -0.12310137f, -0.15289989f, 0.22011310f, 0.14870520f, -0.12342399f, 0.14651585f, -0.07715373f, 0.00065147f, 
    -0.07883780f, -0.02342388f, -0.03703667f, -0.00091429f, -0.04465618f, 0.09281731f, -0.00295785f, -0.00852117f, 
    -0.04367404f, 0.02525614f, 0.05323600f, 0.09756635f, 0.00828563f, 0.08829219f, -0.16175663f, 0.02969066f, 
    0.17982168f, 0.13236532f, 0.01659298f, 0.09817281f, -0.06287514f, -0.04697741f, -0.01226997f, 0.02053439f, 
    0.04928621f, 0.03080851f, 0.03415795f, -0.06124560f, 0.05754609f, -0.03169248f, 0.24261005f, -0.00060474f, 
    0.11909540f, 0.06080241f, 0.02449097f, -0.00878858f, 0.04564394f, 0.01209378f, -0.01522546f, 0.09426482f, 
    0.13573819f, 0.06848174f, -0.01822261f, 0.01302643f, -0.06264666f, -0.03704875f, 0.03350659f, -0.04167436f, 
    0.06404693f, 0.00007175f, 0.09538405f, 0.07101645f, 0.10806636f, -0.12927523f, -0.11653054f, -0.02420039f, 
    -0.13988420f, 0.13031439f, 0.06999833f, -0.02783274f, 0.19283909f, -0.09526078f, -0.01199536f, 0.14117093f, 
    0.16197328f, 0.03374920f, -0.08379035f, 0.01469178f, 0.02012648f, -0.07072201f, 0.01234121f, 0.02796921f, 
    0.10139095f, -0.18611649f, -0.11354497f, -0.12327213f, -0.20446695f, -0.00199630f, 0.07520977f, 0.19223979f, 
    0.03479770f, 0.14236319f, 0.03915064f, 0.09802735f, -0.00129461f, 0.05994150f, 0.06213402f, 0.03316825f, 
    0.20247638f, 0.04327308f, 0.06836812f, -0.09723943f, 0.00309203f, -0.06567528f, -0.00550423f, -0.02743516f, 
    -0.11760610f, -0.07051206f, -0.13287686f, -0.05820291f, 0.13799971f, 0.01736064f, 0.14588830f, 0.01899317f, 
    0.00834803f, -0.05095902f, 0.03657864f, -0.03238997f, 0.10302541f, -0.17364912f, -0.07444998f, -0.07617340f, 
    0.12247358f, 0.20915803f, 0.01883711f, -0.10855834f, -0.07546143f, -0.02197943f, -0.01533739f, -0.07406335f, 
    -0.02585999f, 0.03838889f, -0.06182542f, -0.05277806f, -0.04132209f, 0.05535630f, 0.12497007f, 0.07362052f, 
    -0.05998207f, -0.04494761f, 0.06747371f, 0.10586214f, 0.05485792f, 0.01093577f, -0.00290316f, -0.08841872f, 
    0.08451722f, 0.23726848f, -0.00862078f, 0.06180148f, 0.01672317f, 0.05309320f, 0.00482944f, -0.07427883f, 
    -0.10843898f, 0.02389797f, 0.01324613f, 0.01902790f, -0.22452037f, 0.07085335f, 0.01690487f, 0.06976128f, 
    -0.08579015f, 0.09769836f, 0.10571206f, 0.03240218f, -0.09931318f, 0.02845335f, -0.02281548f, -0.01973402f, 
    0.06545776f, 0.06766915f, 0.03558567f, -0.03020443f, -0.04180308f, -0.04075316f, 0.29109377f, 0.05906242f, 
    -0.13582709f, 0.07742693f, 0.08788420f, -0.04369027f, -0.04234540f, 0.05356191f, 0.07933646f, 0.13863640f, 
    -0.05587493f, -0.00716097f, 0.03195680f, 0.08299227f, 0.08286942f, -0.00224221f, -0.01398990f, -0.02616653f, 
    -0.17985789f, -0.00991328f, -0.05840329f, 0.10962394f, -0.13814227f, -0.01163120f, -0.09479921f, 0.09098733f, 
    -0.06000820f, -0.00544867f, -0.16426927f, -0.15087546f, -0.18841991f, -0.07339738f, 0.13170603f, 0.26109272f, 
    0.08501709f, -0.01301113f, 0.02993388f, -0.01945692f, -0.04479688f, 0.00029021f, 0.01826793f, 0.00904060f, 
    0.01863901f, 0.02317862f, 0.03146914f, 0.09780307f, 0.03300704f, -0.11330464f, 0.07165561f, 0.08886848f, 
    -0.02969594f, -0.04665419f, -0.01080961f, 0.04173847f, 0.36540490f, 0.15727647f, 0.04556962f, 0.03383214f, 
    0.02551909f, -0.00035732f, -0.03647824f, 0.05285614f, 0.10423915f, -0.10090820f, -0.02603639f, 0.04754182f, 
    0.22416477f, 0.18446863f, 0.13855323f, -0.00544379f, -0.02413828f, -0.01630146f, 0.01068028f, -0.03519780f, 
    0.06153857f, 0.02642368f, -0.00229666f, 0.02299958f, 0.07649317f, -0.13275075f, -0.09740230f, 0.15676700f, 
    -0.01902718f, -0.00800326f, 0.10705739f, -0.08676594f, 0.02745247f, 0.06100938f, -0.08772440f, -0.02763300f, 
    0.19118263f, 0.13179576f, 0.07443666f, 0.02107005f, 0.00105470f, -0.06150864f, -0.03153257f, 0.03665825f, 
    0.04987894f, 0.00602634f, 0.06513942f, 0.07838596f, -0.22024775f, -0.13130005f, 0.40635780f, -0.05978519f, 
    0.01856572f, 0.21034823f, 0.23782468f, 0.13257934f, 0.05340966f, -0.06563351f, 0.00703164f, 0.07245141f, 
    0.09680523f, 0.10280914f, 0.28207240f, 0.02709744f, -0.03312603f, 0.25370288f, 0.06750903f, 0.12610571f, 
    -0.02576796f, -0.02767523f, 0.12698627f, 0.01600351f, 0.22868451f, 0.14460176f, 0.09221772f, -0.20204213f, 
    -0.02562109f, 0.04128866f, 0.05262152f, 0.04810094f, -0.00599517f, 0.12347984f, -0.07035231f, -0.13789274f, 
    0.01782383f, -0.02445831f, 0.04212467f, 0.06417821f, -0.01412075f, 0.06520416f, 0.02887962f, -0.02685486f, 
    0.01269711f, -0.04685598f, 0.03092030f, 0.02611488f, 0.19918327f, -0.18450229f, -0.27420723f, -0.19272625f, 
    -0.08305562f, 0.03476328f, -0.02321667f, -0.04204763f, -0.02946311f, 0.04769687f, 0.04240647f, -0.09860940f, 
    -0.06443240f, -0.05962561f, 0.20517880f, 0.27637610f, 0.14137754f, 0.09778289f, -0.01489842f, 0.03107930f, 
    -0.03488682f, -0.07939123f, -0.07760008f, -0.02191971f, -0.08306206f, 0.09748966f, 0.14178753f, 0.08969939f, 
    0.08637400f, -0.02393696f, 0.08755936f, 0.01257135f, 0.06294892f, 0.00845151f, -0.04633695f, -0.04412457f, 
    0.10173801f, 0.03668197f, 0.01424794f, -0.02836824f, -0.21607666f, -0.09315812f, 0.03713913f, 0.01337138f, 
    -0.04345052f, 0.03444124f, 0.07505703f, -0.02758934f, -0.00987788f, 0.18140326f, 0.03720233f, -0.10295812f, 
    -0.07942560f, 0.00550314f, -0.02714351f, 0.01002290f, -0.01000807f, 0.09990880f, -0.03062072f, -0.01396867f, 
    0.16519527f, -0.03754030f, -0.10577314f, -0.04744258f, -0.08543433f, -0.09532714f, -0.03831348f, -0.02160793f, 
    -0.08237051f, -0.07622907f, -0.16290395f, -0.04578916f, -0.26531529f, -0.19455051f, -0.03682509f, 0.09542028f, 
    0.12409275f, 0.20733117f, 0.05607173f, 0.06171064f, 0.17820315f, 0.09537894f, -0.02838255f, -0.00736402f, 
    -0.27337268f, -0.29339778f, 0.02078152f, -0.12773865f, 0.00206772f, 0.04248716f, 0.05704867f, 0.18773042f, 
    0.18457419f, 0.05198692f, 0.00198280f, -0.07765973f, 0.18333139f, 0.08865286f, -0.06542977f, 0.06792597f, 
    0.02638578f, -0.06443138f, 0.00511344f, -0.01074777f, 0.14089879f, -0.15100531f, -0.07369311f, 0.17376806f, 
    -0.12332655f, -0.14657006f, 0.27173397f, 0.15629736f, 0.07431882f, -0.04537228f, -0.06125696f, 0.13601212f, 
    -0.01545811f, -0.04170776f, -0.04396800f, -0.01830745f, 0.18149716f, -0.05813800f, -0.12717639f, -0.00506260f, 
    -0.11528913f, -0.04520620f, 0.01372368f, 0.01523264f, 0.07410115f, 0.03841607f, 0.01783382f, 0.00185864f, 
    -0.05214711f, -0.09492379f, -0.06229970f, 0.06916881f, -0.00316543f, -0.02803288f, -0.19867004f, -0.03774238f, 
    0.02523397f, 0.01788770f, -0.01973739f, 0.00081342f, -0.16739558f, 0.10698038f, 0.04187110f, -0.08148411f, 
    0.04248735f, -0.04373875f, 0.12562726f, -0.01759889f, -0.00707399f, 0.01551724f, -0.20325610f, -0.04927618f, 
    -0.17368476f, -0.02853622f, 0.14289093f, 0.10864210f, -0.00624948f, 0.12186427f, 0.02469327f, 0.05939462f, 
    0.00249945f, -0.03045684f, -0.02719274f, 0.03952418f, 0.03388177f, 0.01938543f, -0.05193404f, -0.06378978f, 
    -0.04133128f, 0.00248006f, 0.03685497f, -0.05026370f, -0.04063445f, -0.08021889f, -0.02501177f, 0.00102316f, 
    -0.15522996f, -0.13728373f, 0.00746329f, 0.05721808f, 0.01283314f, 0.02211069f, 0.03896900f, -0.00247241f, 
    -0.10371899f, 0.02741861f, 0.08568878f, -0.04398538f, 0.01182537f, -0.00099808f, 0.04186804f, 0.03737638f, 
    0.00367293f, -0.09450226f, -0.02834978f, 0.05519141f, -0.07761860f, 0.09593906f, 0.10488830f, 0.08020396f, 
    -0.05441693f, -0.00606727f, 0.18816093f, 0.22059833f, -0.10530573f, 0.07274757f, -0.09835444f, 0.08403675f, 
    -0.00256787f, -0.06059107f, -0.07302762f, 0.04061565f, 0.14352265f, 0.01116701f, 0.00715267f, -0.15389557f, 
    -0.02569169f, 0.01805709f, 0.04822386f, 0.06525775f, 0.03802630f, 0.01171319f, -0.18411328f, -0.02882140f, 
    0.18985485f, 0.13572563f, 0.03056419f, 0.00807591f, -0.01216780f, 0.11412853f, 0.04128143f, -0.08378949f, 
    0.10197792f, 0.04472400f, -0.00469723f, 0.06124406f, 0.06397320f, 0.08144334f, 0.07970631f, -0.01183259f, 
    -0.03745807f, 0.05105241f, 0.01711843f, -0.03881232f, -0.05777197f, -0.00095482f, 0.00876419f, -0.03698318f, 
    0.08561113f, 0.06785686f, 0.07701250f, 0.10425103f, -0.08395313f, -0.00642117f, -0.07046958f, 0.00991371f, 
    -0.03513488f, 0.04346831f, -0.04124321f, -0.02066648f, -0.22895932f, 0.03774837f, 0.17816556f, 0.03004299f, 
    -0.00884167f, 0.03054272f, 0.17003216f, 0.00678216f, 0.12280518f, 0.03072816f, 0.07136969f, 0.03827962f, 
    0.16186519f, -0.25078928f, 0.02543078f, 0.03651698f, -0.05448443f, 0.00831270f, -0.07183526f, 0.03579437f, 
    -0.06413901f, 0.05316741f, -0.04647435f, 0.00925982f, 0.08166832f, 0.02478005f, 0.30669931f, -0.03025793f, 
    0.04850313f, -0.00851121f, 0.01906404f, -0.02124568f, 0.00705703f, -0.06867442f, 0.07684308f, -0.03130517f, 
    0.02146662f, -0.11151661f, 0.18481886f, 0.01041517f, 0.01040494f, 0.00858115f, -0.05416587f, -0.04247328f, 
    0.01900302f, -0.05487357f, 0.02033851f, 0.01864123f, 0.45056942f, -0.10272446f, -0.07565165f, -0.14518814f, 
    -0.07374869f, -0.04492762f, 0.00500147f, -0.03782710f, -0.00644166f, 0.07267060f, 0.02515448f, -0.05529049f, 
    0.16871227f, 0.28543362f, -0.23071879f, 0.08442904f, -0.05784527f, -0.03133133f, 0.07414428f, -0.17052554f, 
    -0.01793102f, 0.03367155f, -0.05081846f, -0.01313012f, -0.11985065f, -0.09610933f, 0.16475558f, 0.16083770f, 
    -0.06086463f, -0.27260306f, -0.08328973f, -0.02044426f, -0.00403270f, -0.07462391f, -0.13051763f, -0.08251730f, 
    -0.02980434f, 0.10111900f, 0.10004925f, 0.24927630f, -0.06854834f, 0.03735129f, 0.05618860f, 0.01732529f, 
    0.03512497f, 0.00161556f, -0.00945184f, 0.01505555f, 0.13785306f, 0.12392875f, -0.01823030f, 0.09550011f, 
    -0.05439333f, 0.03177885f, 0.03532171f, -0.00699958f, 0.00864916f, 0.01551781f, -0.01660421f, -0.04279289f, 
    0.19720921f, 0.24557266f, -0.01301587f, -0.02877893f, -0.10652741f, 0.01632627f, -0.06458395f, -0.02760709f, 
    0.01912313f, 0.05166825f, 0.04813606f, -0.05886993f, -0.03470482f, -0.12092717f, -0.06997716f, -0.05906174f, 
    -0.02636407f, -0.00866933f, 0.06565828f, -0.02237870f, 0.00750392f, -0.12171485f, -0.18565643f, 0.09139591f, 
    0.11572096f, 0.02878937f, 0.06758902f, 0.08165798f, 0.11294023f, 0.01002625f, -0.03477178f, -0.10413019f, 
    0.01293824f, 0.00326376f, 0.03487616f, 0.06116929f, -0.10200041f, -0.09281272f, 0.33424106f, 0.33240631f, 
    -0.04563857f, 0.03868591f, -0.08143185f, -0.07384703f, -0.07452789f, 0.04709871f, -0.00933692f, 0.07184301f, 
    0.07065881f, -0.08553461f, 0.00753351f, -0.07783644f, 0.00690868f, -0.13235451f, 0.06464910f, 0.16727549f, 
    0.07742317f, 0.00457291f, 0.01864704f, 0.03871583f, 0.01038708f, 0.01666578f, 0.28413138f, 0.04750577f, 
    0.03719142f, 0.01645265f, -0.03654006f, -0.04981884f, 0.03879682f, 0.11832950f, 0.00074087f, 0.05521103f, 
    -0.08646063f, -0.13159811f, 0.15992510f, 0.11439522f, -0.11839657f, -0.04065654f, -0.03837800f, 0.06623984f, 
    -0.00612826f, -0.01691485f, -0.04543226f, -0.05462519f, -0.11910363f, 0.03303420f, -0.06287739f, -0.06752659f, 
    -0.03855262f, 0.05136810f, 0.17733097f, 0.07775245f, 0.13067932f, 0.03143441f, 0.00104081f, 0.08963597f, 
    -0.16801482f, -0.00103293f, 0.23457478f, -0.02410870f, 0.02243230f, -0.04397748f, 0.09404263f, 0.01505573f, 
    0.01440597f, 0.02809052f, -0.03264458f, -0.00284294f, 0.01865938f, 0.16493621f, -0.23495826f, 0.11865168f, 
    -0.03885690f, -0.15131962f, 0.21866119f, -0.01005543f, -0.00475445f, 0.18744107f, -0.00889618f, -0.03425809f, 
    -0.04286735f, 0.00593288f, 0.11324283f, -0.02861269f, 0.01185866f, 0.02720908f, 0.12568732f, 0.00320506f, 
    0.05395633f, -0.06089838f, -0.00754802f, -0.03643600f, -0.19196118f, -0.14425203f, 0.24480276f, -0.01301643f, 
    0.02449280f, 0.01459436f, -0.12801650f, 0.08971913f, -0.16553174f, 0.03726695f, 0.06863268f, -0.07485143f, 
    -0.14934099f, -0.01602182f, 0.10746728f, 0.00681590f, 0.00141959f, 0.00370514f, 0.06289365f, -0.01471584f, 
    0.04091872f, 0.11525203f, 0.14775555f, 0.16631152f, -0.01908198f, -0.12917803f, -0.02790975f, 0.14204875f, 
    -0.02516971f, -0.06450942f, -0.22447532f, 0.01907876f, -0.01809492f, 0.06203748f, -0.02864750f, 0.05095954f, 
    -0.07826429f, 0.03434701f, -0.02370253f, -0.02432102f, -0.00678993f, 0.04919804f, 0.01026629f, 0.02155571f, 
    0.09088333f, 0.10284554f, 0.04807404f, 0.08628346f, -0.03421767f, 0.09597960f, 0.17713223f, -0.00576958f, 
    0.03851595f, 0.11179053f, 0.01881105f, 0.00556585f, 0.09892621f, 0.10381359f, -0.03985640f, 0.02656909f, 
    -0.00237203f, -0.07889257f, 0.09089809f, -0.00081757f, 0.01933392f, 0.03998179f, -0.03411819f, -0.02468744f, 
    0.04646876f, 0.00866356f, 0.03903748f, 0.02811520f, -0.00925801f, -0.18660106f, -0.01150198f, 0.03860589f, 
    -0.04755790f, -0.05709808f, -0.07673188f, 0.04157469f, -0.00513496f, 0.05345261f, 0.07129544f, 0.01970691f, 
    0.10505289f, 0.22651844f, -0.16945446f, -0.00407218f, -0.04631148f, 0.00022261f, 0.03512030f, 0.30412462f, 
    -0.02440971f, -0.01478852f, -0.08419482f, -0.06838840f, 0.04725863f, 0.06851387f, -0.03825684f, 0.10436592f, 
    -0.03086589f, 0.08386423f, -0.02317691f, 0.03382486f, -0.01540566f, -0.00518102f, -0.07328032f, 0.04096588f, 
    -0.24251345f, -0.22732428f, 0.23297848f, -0.03940408f, -0.12562935f, 0.05434232f, -0.03791591f, 0.10549857f, 
    -0.16044594f, 0.00831703f, -0.11564143f, 0.09333663f, -0.12101646f, -0.03582845f, -0.08758507f, -0.00247061f, 
    -0.03949881f, -0.13491604f, -0.10901412f, -0.04537296f, 0.02349730f, 0.12414040f, 0.03941676f, 0.09332570f, 
    -0.07771013f, -0.25673109f, 0.00105640f, 0.15126571f, 0.01861852f, 0.00285139f, -0.05091842f, 0.08175990f, 
    -0.04803917f, 0.04907736f, -0.04647973f, 0.08165270f, 0.05234475f, 0.23463234f, 0.06904077f, 0.10368034f, 
    -0.10721529f, -0.01966165f, 0.08336644f, -0.02246282f, 0.05276992f, 0.05465455f, 0.01346747f, 0.00701995f, 
    0.09381668f, 0.02809826f, -0.01472649f, -0.06016573f, -0.00922326f, 0.15523461f, 0.08631109f, -0.03418916f, 
    -0.00384237f, -0.02128033f, 0.13214558f, 0.00281888f, -0.34184787f, -0.04997770f, -0.08508816f, -0.07668714f, 
    -0.01703921f, -0.02679419f, 0.07026666f, -0.06010012f, 0.02845531f, 0.00269854f, 0.06985977f, -0.17620765f, 
    -0.01388360f, 0.01289341f, -0.08933290f, -0.06297258f, 0.00201073f, 0.07002039f, 0.02036633f, 0.04702058f, 
    0.03303807f, 0.06268777f, -0.02187144f, -0.03332961f, 0.11933839f, -0.15676723f, 0.19702861f, -0.08272029f, 
    0.10684633f, 0.03482128f, -0.08509684f, 0.02105977f, 0.08987706f, -0.09264191f, -0.00291153f, -0.02972481f, 
    0.03929612f, -0.02381466f, 0.03365013f, -0.01802463f, 0.00938773f, 0.00825444f, 0.04839752f, -0.01119144f, 
    0.05214028f, 0.01228585f, -0.03125846f, -0.02429137f, 0.05114215f, -0.34684044f, -0.02136758f, 0.16000648f, 
    0.16207436f, 0.10921577f, -0.06355921f, 0.06452077f, -0.01904194f, -0.04661794f, 0.04268266f, -0.08407280f, 
    -0.08526376f, -0.08495182f, 0.17266062f, -0.01116214f, 0.11630654f, 0.06072036f, -0.03501916f, 0.25723097f, 
    0.03919790f, 0.04493956f, 0.04213135f, -0.11381460f, 0.00007844f, -0.02245895f, -0.02991198f, 0.16434623f, 
    0.05252476f, 0.01884562f, 0.02625765f, -0.10021456f, 0.05739790f, 0.10140105f, 0.07063586f, 0.10505292f, 
    -0.00950542f, 0.02209527f, -0.12608109f, 0.05423973f, -0.07022107f, -0.06834667f, 0.23589027f, -0.04081324f, 
    0.05245965f, -0.04582564f, -0.04036283f, 0.04444103f, 0.18558338f, 0.01001404f, 0.06764559f, 0.06917683f, 
    0.01454993f, -0.08386756f, 0.00835489f, 0.00237743f, 0.07965461f, 0.01531052f, -0.06289481f, 0.07919358f, 
    0.09516213f, -0.11188634f, 0.08795095f, 0.06646615f, 0.07803177f, 0.17077230f, 0.08833123f, -0.07372731f, 
    -0.00542841f, -0.00788297f, 0.11293118f, 0.00521932f, -0.02175291f, 0.03504091f, -0.01297105f, 0.16231880f, 
    0.02349183f, -0.04676041f, -0.11207985f, 0.21942775f, -0.06475378f, 0.03950032f, 0.13250721f, 0.03390090f, 
    0.00834965f, 0.00417420f, -0.05499303f, -0.03113156f, 0.11955014f, 0.09674725f, 0.12120370f, 0.00604351f, 
    0.12181585f, 0.09048557f, -0.00362237f, 0.08970635f, 0.13505352f, -0.07387843f, 0.06166825f, -0.00333919f, 
    0.06247142f, 0.03948205f, 0.05052605f, 0.03001706f, 0.03933877f, 0.01457247f, -0.07201882f, 0.05336537f, 
    0.19383675f, -0.11721902f, 0.04425631f, -0.18405989f, -0.01216265f, -0.05786159f, 0.09457274f, 0.10659716f, 
    0.05687160f, 0.06186864f, 0.06369936f, 0.13845259f, 0.02603159f, 0.21315050f, 0.01051601f, 0.03829454f, 
    -0.05881215f, -0.17627564f, 0.00376369f, -0.03044731f, -0.04607322f, -0.06670322f, 0.06539592f, -0.07164351f, 
    -0.06568689f, 0.13139386f, 0.16921435f, -0.18981178f, 0.04055933f, 0.08623102f, 0.06819404f, 0.01106093f, 
    -0.09448527f, 0.10382063f, 0.16854078f, -0.03673269f, -0.06293971f, 0.04343222f, 0.07673666f, 0.01831600f, 
    -0.01688062f, -0.01709680f, 0.09705353f, 0.06494603f, 0.01693391f, -0.01956677f, 0.01203675f, -0.08146535f, 
    0.01657611f, -0.19464117f, 0.00932325f, 0.00202477f, -0.02341890f, 0.10677096f, -0.06295072f, -0.11919316f, 
    0.00937527f, -0.01524681f, -0.01126661f, 0.15959327f, 0.00168370f, -0.02767186f, 0.12854353f, -0.01613241f, 
    0.07932503f, 0.00145775f, -0.08575835f, -0.10712928f, 0.19458361f, -0.01469595f, -0.00983697f, 0.05992814f, 
    0.01965797f, -0.05263013f, 0.01640779f, -0.00540462f, -0.03687985f, -0.02725990f, 0.23839507f, 0.02280937f, 
    0.08474715f, 0.07143483f, -0.06540550f, -0.15234663f, 0.15459113f, -0.37036213f, -0.09097549f, -0.00650792f, 
    0.03617292f, -0.04393890f, -0.04015781f, 0.09987262f, 0.05577336f, 0.04305564f, 0.10197720f, -0.06134591f, 
    0.20904739f, 0.10998134f, -0.00489281f, -0.03619959f, 0.12480131f, -0.08940349f, -0.02503607f, 0.06841490f, 
    0.03553857f, -0.02884892f, 0.01173451f, 0.02803131f, 0.01738572f, -0.08095050f, 0.05391128f, 0.02706075f, 
    0.00427143f, -0.01378629f, 0.04845099f, -0.05803827f, 0.25803608f, 0.15069820f, 0.22475670f, 0.12828468f, 
    -0.02034066f, 0.10208676f, 0.07991885f, -0.01968361f, 0.02915864f, -0.06940722f, 0.07544967f, -0.00050189f, 
    0.15719658f, -0.05399331f, -0.00932895f, 0.09510560f, -0.08966517f, 0.09783785f, 0.15833981f, 0.12486324f, 
    0.04746760f, 0.11020968f, 0.06346706f, -0.11629134f, -0.00961385f, 0.03017106f, -0.00097882f, -0.02846834f, 
    -0.02554749f, -0.10846742f, 0.06482461f, -0.00551867f, -0.18415356f, -0.16696677f, 0.00188741f, 0.01905717f, 
    -0.00697328f, 0.00896088f, 0.05256045f, -0.07307920f, 0.04787581f, 0.05110864f, 0.05911217f, 0.04852404f, 
    -0.00791924f, -0.02054049f, -0.04379864f, -0.01660332f, -0.01256303f, 0.03678411f, 0.07997774f, 0.13688393f, 
    -0.16738966f, -0.06932835f, -0.04002663f, 0.23846415f, -0.08042546f, -0.03494029f, 0.16353710f, 0.09710405f, 
    0.05334580f, 0.03984523f, 0.00782370f, -0.08327854f, -0.01322117f, 0.02666439f, 0.00128827f, -0.03124666f, 
    0.07141812f, 0.08460134f, 0.10355878f, 0.01583795f, 0.07893514f, 0.04177214f, 0.00612999f, 0.04898987f, 
    0.01566959f, 0.19307150f, 0.09493908f, 0.12342138f, 0.10329761f, 0.10384960f, 0.07031608f, 0.25357077f, 
    0.08274716f, -0.00887842f, -0.04149089f, -0.02040528f, -0.05929359f, 0.04736676f, 0.42799962f, 0.02823369f, 
    0.00298792f, -0.01050110f, -0.06501056f, -0.01124577f, -0.06942831f, -0.12798162f, 0.03890598f, 0.03215244f, 
    -0.26833758f, -0.01742008f, 0.09925718f, 0.14073110f, -0.07017410f, 0.01601862f, 0.00363169f, -0.17979757f, 
    -0.07693013f, 0.16165389f, 0.32708883f, -0.05539010f, -0.09099848f, -0.08244192f, 0.11517084f, 0.34941250f, 
    0.01317048f, 0.05068812f, 0.00938318f, 0.04974130f, -0.02898659f, 0.01070601f, -0.04038991f, -0.08939835f, 
    0.15312283f, 0.16372469f, -0.15375932f, -0.01878303f, 0.00646097f, 0.04489865f, 0.06833728f, 0.01477718f, 
    -0.03555307f, -0.02532000f, 0.01480887f, -0.08366443f, -0.11849753f, 0.12789676f, 0.00355321f, -0.03526975f, 
    -0.05022209f, -0.00799588f, 0.01374762f, 0.03009177f, 0.17729421f, 0.04936944f, -0.03446279f, 0.04854132f, 
    -0.05741872f, 0.19027719f, -0.12204598f, -0.13107210f, 0.03582450f, 0.01276950f, 0.10558972f, 0.04917472f, 
    -0.02384643f, -0.22308984f, 0.08991013f, 0.19498587f, -0.42556542f, -0.33011794f, -0.09833290f, 0.12141028f, 
    -0.06254413f, -0.01416705f, 0.16573747f, -0.17794740f, -0.00594546f, 0.02134995f, 0.05692559f, -0.02296086f, 
    -0.00651944f, -0.09520976f, -0.01657877f, 0.09444343f, -0.05663687f, -0.06376345f, 0.15262996f, 0.10404355f, 
    0.08008721f, 0.01813447f, 0.12248846f, -0.02006660f, 0.00706704f, 0.02388735f, -0.08359893f, 0.05253434f, 
    0.09551847f, 0.04009224f, -0.02137505f, 0.03521078f, 0.06680337f, 0.06624914f, -0.06085220f, 0.02691886f, 
    -0.18155065f, -0.09241739f, 0.18336117f, 0.31264794f, -0.02729906f, 0.04194832f, 0.08792529f, -0.00322579f, 
    -0.01969559f, 0.05743517f, -0.10401233f, -0.00093219f, 0.25101575f, -0.00872886f, -0.13056779f, -0.06542770f, 
    0.01937179f, -0.11295065f, 0.17290865f, 0.05370809f, 0.08035965f, 0.04173969f, 0.14803627f, 0.03497839f, 
    0.02565685f, 0.04829163f, 0.03094198f, -0.00007945f, 0.17064439f, -0.03058288f, 0.12126123f, 0.05573709f, 
    0.06963754f, 0.05288365f, 0.03039370f, -0.07060588f, 0.05827327f, -0.06272792f, 0.02899435f, 0.19935824f, 
    -0.10052697f, 0.01189602f, -0.08128745f, -0.06105553f, -0.06032564f, 0.07254748f, 0.03942403f, -0.01488926f, 
    -0.19373019f, 0.11975975f, 0.07522215f, -0.18070643f, 0.07058334f, -0.04801287f, 0.01910213f, -0.02500709f, 
    0.06171748f, -0.08571925f, -0.05692253f, -0.13214758f, -0.06088910f, 0.09834234f, 0.02707128f, 0.01333036f, 
    -0.12753540f, -0.14320135f, -0.15411361f, 0.01480233f, 0.05375533f, 0.10447162f, 0.06620095f, -0.17271791f, 
    -0.15195611f, 0.04294547f, 0.05283218f, 0.14972688f, -0.16878703f, 0.01302423f, -0.02431545f, -0.02880683f, 
    -0.00096751f, 0.00797644f, -0.01797771f, -0.07317238f, -0.04097993f, 0.16287093f, -0.00091350f, 0.04088847f, 
    0.02800271f, 0.15467802f, -0.06238722f, -0.00145773f, 0.06537366f, 0.16999598f, 0.05860299f, 0.18268989f, 
    0.18732277f, 0.04617850f, -0.02838617f, 0.06555836f, -0.09424955f, -0.02213518f, -0.00324957f, -0.03031508f, 
    0.14473343f, -0.02538571f, 0.00594004f, 0.05160514f, 0.08607257f, 0.08356339f, 0.04201467f, -0.10748230f, 
    -0.04706850f, 0.14346476f, 0.06873942f, -0.07687945f, 0.10211333f, 0.09058790f, -0.01081408f, 0.06430409f, 
    0.02860761f, 0.16229779f, 0.05960036f, -0.15937729f, 0.03746563f, 0.03267584f, -0.03181843f, 0.02048774f, 
    -0.07265738f, 0.03946761f, -0.06787893f, 0.04406592f, 0.34874249f, 0.03099592f, 0.28000531f, -0.12974827f, 
    0.00565139f, -0.05560789f, -0.04306576f, -0.00076387f, -0.03672251f, 0.08144928f, 0.08339295f, 0.07166892f, 
    0.26152626f, -0.02150696f, 0.05266286f, -0.01460988f, -0.02188926f, 0.00359424f, -0.07283602f, -0.00868502f, 
    -0.07713840f, -0.01729137f, 0.02476135f, 0.13173828f, -0.13397172f, 0.07518004f, 0.14757793f, 0.20592105f, 
    -0.06784117f, 0.17249779f, 0.08332525f, 0.05696702f, -0.01308503f, -0.03774788f, 0.02793476f, -0.04849896f, 
    0.01556504f, 0.01882540f, 0.05972823f, 0.19128397f, 0.01968997f, -0.03197066f, -0.00692850f, -0.05201320f, 
    0.01778420f, 0.06587899f, 0.10045823f, 0.10426701f, 0.15374839f, -0.17260666f, 0.15341829f, -0.06894241f, 
    -0.06533314f, 0.02644353f, -0.02842985f, -0.05106922f, 0.05382102f, -0.04896925f, 0.01880118f, 0.13900210f, 
    -0.13645253f, -0.01091123f, 0.05300692f, 0.14261173f, 0.01541743f, 0.03132541f, 0.01485509f, -0.10210256f, 
    0.02812438f, -0.03327607f, -0.09210508f, 0.03124376f, 0.02022252f, 0.17375794f, 0.18611394f, 0.14680831f, 
    -0.15834267f, -0.03607861f, -0.04538165f, 0.00724200f, -0.02248520f, -0.06558850f, 0.01659851f, -0.02857067f, 
    0.16124144f, 0.14679354f, -0.11621787f, -0.01421387f, 0.11106211f, -0.07107397f, 0.11753547f, 0.03407265f, 
    -0.12346949f, 0.06309260f, -0.11930583f, 0.05673037f, -0.10047427f, 0.12976578f, 0.09188464f, -0.02869299f, 
    -0.25842988f, -0.07340563f, -0.07641176f, 0.09909397f, -0.07196166f, -0.04878239f, 0.00338617f, -0.01020028f, 
    0.11292300f, 0.00453701f, 0.07150294f, -0.21388516f, -0.01285122f, -0.00701570f, -0.08937689f, 0.09676896f, 
    -0.00882716f, -0.03298843f, 0.22416492f, 0.05676905f, -0.04447787f, 0.04151458f, 0.16085379f, 0.24919055f, 
    -0.00880104f, -0.12007119f, 0.02535537f, 0.10000784f, 0.04565962f, 0.08074202f, 0.05575997f, 0.02867412f, 
    -0.34321603f, 0.16819070f, 0.16261071f, 0.44444954f, 0.07793610f, -0.07983792f, -0.01747828f, -0.08080453f, 
    -0.06111370f, 0.04558447f, -0.01141422f, -0.02619094f, 0.04765473f, 0.20965478f, 0.13467138f, 0.10135113f, 
    -0.05538232f, -0.00875303f, 0.04139344f, 0.07860517f, -0.06985600f, -0.01464860f, -0.01558214f, 0.02952064f, 
    -0.08705231f, -0.04769367f, 0.01988923f, 0.02776953f, 0.14159313f, 0.06129774f, 0.04623894f, 0.12500674f, 
    0.01140890f, -0.08134772f, -0.03410257f, 0.02806089f, 0.31005955f, 0.05607003f, -0.07449628f, 0.07643912f, 
    -0.02464256f, -0.01890705f, 0.03217854f, 0.00946437f, -0.04222068f, -0.06025777f, -0.01085896f, 0.02139432f, 
    0.10787880f, -0.03869115f, 0.03049096f, 0.12803727f, -0.06091951f, -0.02684410f, 0.01389241f, -0.01932279f, 
    0.06712241f, 0.10152628f, 0.08585270f, 0.02793299f, -0.37703711f, -0.06816649f, 0.05808596f, 0.16077907f, 
    0.05695712f, 0.00482630f, 0.02431913f, -0.02911035f, 0.03553124f, -0.04574944f, -0.13525717f, -0.15591539f, 
    0.21696560f, -0.04015536f, -0.13672057f, 0.14343260f, 0.00072877f, -0.01893895f, 0.00226447f, 0.00414633f, 
    -0.04960154f, 0.06190034f, 0.08360292f, 0.02027643f, -0.23049738f, -0.10938706f, -0.14982617f, 0.09521119f, 
    0.04035553f, 0.06958360f, -0.05393885f, 0.17205413f, -0.06671526f, -0.13259448f, 0.00300498f, 0.05718450f, 
    0.43966669f, 0.04816158f, -0.07398921f, 0.02433934f, -0.06271341f, 0.09675728f, 0.08253376f, 0.01629755f, 
    -0.18448758f, -0.00682584f, -0.07846732f, -0.04991191f, 0.04793416f, 0.13118790f, -0.00717408f, 0.22894390f, 
    0.01054307f, -0.00601815f, 0.02835598f, 0.01615806f, -0.06361231f, -0.09854662f, 0.02163594f, -0.13262866f, 
    -0.04224315f, 0.12489878f, 0.07521346f, -0.19258906f, 0.04060099f, -0.00075963f, -0.03882018f, -0.00327088f, 
    -0.07452417f, -0.07339880f, -0.09189229f, -0.02452957f, 0.00404241f, 0.23052350f, 0.11618599f, 0.16308713f, 
    -0.05830948f, -0.11641742f, -0.11049626f, -0.16800299f, -0.10494453f, 0.09069453f, 0.04737093f, 0.08387195f, 
    -0.10382228f, -0.07125632f, -0.24795170f, -0.01001544f, 0.11978427f, 0.10579786f, 0.06750805f, 0.02797304f, 
    0.00779914f, 0.07041216f, 0.01754655f, -0.02216544f, 0.07471169f, 0.14797305f, 0.13455129f, 0.11638901f, 
    -0.01016089f, -0.10669631f, 0.06167909f, 0.15226077f, 0.18420821f, 0.03990284f, 0.08168915f, 0.10158971f, 
    -0.01884839f, 0.10538621f, -0.02284248f, 0.01217991f, -0.01906484f, 0.06334477f, -0.01306622f, 0.00031704f, 
    -0.05723390f, -0.11218172f, 0.00607405f, -0.11987613f, 0.06030410f, -0.06698852f, -0.06350177f, 0.07326804f, 
    0.09028701f, -0.04701826f, -0.08288679f, 0.09338873f, 0.05437993f, 0.01806064f, -0.04335775f, 0.06168785f, 
    -0.05765501f, -0.00244461f, -0.05601453f, -0.07580918f, 0.00644181f, -0.01286545f, -0.11872067f, -0.20972204f, 
    -0.00029843f, 0.04391634f, -0.01688294f, 0.04508541f, -0.19977395f, 0.05535696f, 0.04235992f, -0.12225939f, 
    0.07904991f, 0.11054429f, -0.06813432f, 0.01548083f, 0.16129451f, 0.14853521f, -0.03256746f, 0.01393887f, 
    -0.37219492f, 0.07360832f, 0.38764593f, -0.14082137f, -0.02911759f, 0.12992887f, -0.05229861f, 0.05961144f, 
    0.07751124f, 0.01807472f, 0.08168904f, 0.09928274f, 0.08749430f, -0.07707126f, -0.05535731f, -0.08142358f, 
    -0.04265239f, 0.03458887f, -0.00679894f, 0.05697620f, 0.15961155f, -0.11315040f, 0.03465818f, 0.14261103f, 
    -0.09232888f, -0.24166617f, -0.12055794f, 0.25431266f, 0.08200938f, 0.02129366f, -0.05565546f, -0.05182998f, 
    0.04768167f, 0.05410741f, 0.01928045f, -0.03047064f, -0.11466869f, 0.07730835f, -0.01405802f, 0.19304624f, 
    -0.02316101f, -0.13242473f, -0.12933436f, -0.01504805f, 0.03239776f, 0.02536674f, -0.03793892f, 0.03195095f, 
    -0.16294618f, 0.03300582f, 0.15899810f, -0.05308731f, 0.06652566f, 0.02745283f, 0.00287386f, -0.10735249f, 
    -0.01348766f, 0.08352539f, 0.00729025f, -0.07406908f, 0.14996754f, -0.01441890f, 0.20024715f, -0.16099991f, 
    0.02490942f, -0.05682731f, -0.05321852f, -0.23308225f, 0.00356242f, -0.01904767f, -0.02003820f, -0.09392478f, 
    0.14043418f, 0.00009215f, -0.07179824f, 0.08108959f, 0.11101782f, 0.06655207f, 0.08796882f, 0.04232373f, 
    -0.06864972f, -0.05873432f, -0.02803572f, -0.00446415f, -0.13505709f, 0.02962087f, 0.00887207f, 0.02098777f, 
    -0.01555317f, -0.03401754f, -0.07805226f, -0.04784397f, 0.10637346f, 0.03258093f, 0.13678828f, 0.02044057f, 
    -0.27765256f, 0.13746578f, 0.04120285f, -0.04831091f, 0.07037013f, -0.07360746f, -0.02591478f, -0.02720196f, 
    0.06765846f, 0.06802814f, 0.00682427f, -0.01799146f, -0.19387954f, 0.20381394f, 0.07902425f, -0.10298513f, 
    0.01986200f, 0.01659798f, -0.02991334f, -0.01101203f, -0.00120120f, -0.02833808f, -0.05216810f, 0.11577292f, 
    -0.06076239f, 0.03768440f, 0.18292859f, 0.10639936f, -0.19308966f, -0.00787853f, -0.05752494f, -0.00548748f, 
    0.03534909f, 0.05101266f, -0.00768376f, -0.03578092f, 0.09540665f, 0.18809748f, 0.14268728f, 0.29029241f, 
    0.02918481f, -0.03021997f, -0.04810918f, 0.02256964f, -0.09615100f, -0.01082599f, -0.07772395f, -0.03178100f, 
    -0.03065452f, -0.06593128f, 0.01731868f, -0.15297909f, -0.06212922f, 0.04047366f, -0.06070348f, 0.04552241f, 
    0.06420671f, -0.01841597f, -0.00235443f, -0.12192453f, -0.02371947f, 0.03374514f, -0.00673323f, 0.03414295f, 
    0.12171384f, 0.03895817f, 0.05413536f, 0.04047423f, -0.00739572f, -0.08601641f, -0.01247067f, -0.05680663f, 
    0.12868112f, 0.08816719f, 0.04841639f, 0.09505872f, 0.13884951f, -0.07494389f, 0.00888189f, 0.03113696f, 
    0.00419197f, 0.00483190f, -0.13054663f, -0.06277917f, 0.10119132f, 0.02095219f, 0.27198067f, -0.03931850f, 
    -0.02944626f, 0.03995687f, 0.12183416f, 0.01136989f, 0.12161916f, 0.13732459f, -0.14472321f, 0.06095423f, 
    -0.32701638f, -0.15664534f, 0.02936694f, 0.49312738f, 0.06135166f, 0.03011426f, -0.08430365f, -0.09096619f, 
    0.06477664f, 0.19519871f, -0.01469924f, 0.06331906f, 0.16126142f, -0.17097670f, -0.04348586f, 0.01221346f, 
    -0.02049394f, -0.01225704f, -0.11228061f, 0.14993058f, -0.02261481f, -0.03317333f, -0.00313452f, 0.03369201f, 
    -0.02899561f, -0.00002489f, 0.08726566f, 0.09367655f, 0.04630182f, 0.00631037f, 0.02852562f, -0.07230260f, 
    -0.03246237f, 0.02255469f, -0.04494065f, 0.07590809f, 0.14110272f, 0.35497722f, 0.17477724f, 0.19157590f, 
    -0.01172300f, -0.07448170f, -0.04368769f, -0.15702789f, -0.07016802f, -0.01218366f, 0.01173798f, 0.00351508f, 
    0.23790124f, 0.14076406f, -0.18729122f, -0.12534563f, -0.05102558f, -0.02028679f, 0.04915102f, -0.05388705f, 
    -0.00032735f, 0.07485580f, 0.15384899f, 0.15196399f, 0.18871357f, 0.09558950f, 0.19672866f, 0.15093425f, 
    -0.12495051f, -0.05431044f, -0.05116805f, -0.22399461f, -0.02542176f, -0.09940837f, -0.02161402f, 0.02347585f, 
    -0.03383042f, 0.08398134f, 0.10922684f, -0.00032673f, 0.12002397f, 0.11169080f, 0.08621182f, -0.00986355f, 
    0.01725830f, 0.08537563f, 0.11912373f, -0.02505438f, 0.18887171f, -0.11207969f, -0.07316803f, 0.04722333f, 
    -0.08900369f, -0.04977756f, -0.01163625f, 0.01736364f, -0.05927442f, -0.04544961f, -0.07944684f, -0.07458460f, 
    0.18199192f, -0.06790317f, -0.04200353f, 0.14615241f, -0.11095783f, -0.06736161f, 0.06841080f, -0.04008111f, 
    -0.04484373f, -0.06460495f, -0.01750557f, -0.05476470f, -0.06756312f, 0.09324138f, -0.11368524f, 0.00187936f, 
    0.13255772f, -0.00882050f, -0.00442953f, -0.05325101f, 0.14841786f, 0.07044760f, -0.02024431f, 0.15782812f, 
    0.10107825f, 0.04402151f, 0.03971114f, -0.07455942f, 0.06816471f, 0.04013988f, 0.06094924f, 0.00030745f, 
    0.02171591f, -0.01108108f, 0.03639035f, -0.05090994f, -0.19189765f, 0.02681416f, 0.05062449f, 0.25193310f, 
    0.00398956f, -0.00208189f, -0.05530323f, -0.11769599f, -0.00507448f, 0.05216201f, -0.02311350f, -0.00622409f, 
    0.02699650f, -0.00104027f, -0.03472888f, -0.00008595f, -0.02108656f, -0.02595107f, 0.01761491f, -0.00911935f, 
    0.00482309f, 0.00749818f, 0.00340082f, 0.01462960f, 0.01275802f, -0.04131950f, 0.00438728f, -0.01822637f, 
    -0.03220313f, -0.00029816f, -0.03127088f, 0.00441711f, -0.03424890f, 0.00813718f, -0.04740016f, -0.01454807f, 
    -0.01768273f, 0.02220847f, -0.03378750f, -0.02843364f, -0.03375436f, -0.02525506f, -0.00176571f, 0.02870202f, 
    -0.01654265f, -0.03559457f, -0.01415424f, -0.01148704f, 0.02154131f, -0.03278252f, 0.00332440f, 0.02011286f, 
    0.00742764f, 0.00953301f, -0.01265829f, -0.01911828f, 0.00790245f, -0.01114756f, -0.00277083f, 0.00802308f, 
    0.01156896f, -0.03857937f, 0.02013880f, 0.00142655f, -0.01576087f, -0.00580983f, 0.01885596f, 0.01973328f, 
    0.02189770f, -0.02512384f, -0.00936758f, -0.04073081f, -0.01481887f, -0.01594826f, -0.01302414f, 0.01646759f, 
    -0.02412669f, 0.02780395f, 0.00853958f, -0.00851345f, -0.00477614f, 0.01133197f, -0.04088980f, -0.02014920f, 
    -0.00639981f, -0.01862176f, -0.02314636f, -0.00193180f, -0.01092327f, -0.00377102f, -0.01038901f, 0.01267270f, 
    -0.02925899f, -0.01504031f, -0.01537440f, 0.00453552f, -0.02611730f, 0.01134123f, -0.02400363f, 0.01083438f, 
    0.00341314f, 0.00416988f, 0.00440374f, -0.02423203f, 0.00716659f, -0.02980371f, 0.01792461f, 0.01338155f, 
    -0.02480506f, 0.00990411f, 0.01826000f, 0.01678386f, 0.01423964f, 0.02436958f, -0.03037770f, -0.02146274f, 
    -0.01152598f, -0.01820586f, -0.03251960f, 0.01622066f, -0.01572136f, 0.00317164f, 0.01925227f, -0.00385400f, 
    -0.01363714f, 0.00349712f, -0.01794873f, 0.01000405f, -0.00737014f, -0.01859697f, -0.01548692f, 0.01518125f, 
    -0.01262016f, 0.00749497f, 0.02775216f, -0.00598601f, -0.01703780f, -0.01167172f, 0.01597279f, 0.00784648f, 
    0.01237031f, 0.01819705f, 0.01691446f, -0.04292611f, -0.03060413f, -0.01292200f, -0.03978109f, 0.00309247f, 
    0.00811101f, -0.00914042f, -0.00245347f, 0.01301020f, -0.00995135f, 0.00268722f, 0.00331250f, 0.00922889f, 
    -0.01087697f, 0.02408479f, -0.02136394f, -0.03020878f, 0.00651278f, -0.01379941f, 0.02955988f, 0.01343842f, 
    0.00079862f, 0.00936642f, 0.00966015f, -0.02734399f, 0.00038805f, -0.02105689f, -0.03437967f, 0.00881894f, 
    -0.03821284f, 0.03707014f, 0.01544563f, 0.00708819f, -0.01836814f, 0.00707114f, -0.01315801f, 0.00748788f, 
    -0.01435100f, 0.02939295f, 0.01677408f, -0.02817759f, -0.02358669f, -0.00433100f, -0.03451530f, -0.03420528f, 
    0.01479397f, 0.00101935f, -0.00092279f, -0.00318173f, 0.01902777f, -0.00975756f, -0.01996500f, -0.01393809f, 
    0.01450850f, -0.00838541f, -0.01835366f, 0.00367364f, -0.00346300f, -0.01895279f, -0.03153612f, -0.01843109f, 
    0.02326068f, -0.01100441f, 0.01125668f, 0.01519200f, 0.00033730f, -0.02610954f, -0.03507008f, -0.03177140f, 
    0.01500800f, -0.00484462f, -0.01940998f, -0.03755574f, 0.00722948f, 0.01105513f, -0.02292373f, -0.00858753f, 
    0.00133853f, 0.01518247f, 0.00240706f, -0.00158025f, -0.01540053f, 0.01766674f, -0.02702123f, -0.01089822f, 
    0.00712362f, -0.00063333f, 0.01959117f, -0.00133005f, -0.03332699f, 0.02005849f, -0.03530179f, 0.02042174f, 
    -0.02588534f, 0.02344736f, -0.02781863f, 0.00156626f, -0.00451144f, 0.02016827f, 0.02811328f, 0.01382536f, 
    -0.03971610f, -0.00222401f, -0.00837915f, -0.00708967f, -0.00570020f, 0.03184624f, -0.00659335f, 0.01228870f, 
    0.02095742f, -0.00118561f, 0.02826229f, 0.02346540f, 0.00941187f, 0.01880033f, 0.01976413f, 0.01118793f, 
    0.02734899f, 0.00231877f, 0.01839070f, 0.03280462f, 0.02491563f, 0.01488603f, 0.00264888f, -0.03720913f, 
    -0.03895096f, -0.02740488f, -0.02865334f, -0.01066741f, -0.04302208f, -0.02182285f, 0.02743626f, -0.02100403f, 
    0.00620141f, 0.00156921f, -0.01214759f, 0.00641617f, 0.03114545f, 0.03231654f, 0.03166509f, 0.03269539f, 
    -0.01392808f, 0.00733653f, 0.00545364f, -0.00969288f, 0.00682489f, 0.01372114f, -0.02836274f, -0.00393714f, 
    0.00709764f, -0.03501415f, -0.02059924f, 0.00533140f, 0.02292719f, -0.00519957f, -0.03067878f, -0.04445863f, 
    -0.01305832f, -0.02632700f, -0.03179235f, 0.01751474f, -0.04495834f, -0.01741906f, -0.00629885f, 0.01319592f, 
    0.02434136f, -0.02974598f, -0.03993249f, 0.02244462f, -0.02526332f, -0.00245412f, 0.02180106f, -0.03128595f, 
    0.00180011f, -0.03125871f, -0.01092078f, 0.01438592f, 0.01017213f, -0.00084035f, 0.00325981f, -0.03122122f, 
    0.00388762f, -0.00102452f, -0.03817556f, -0.03606918f, -0.00065675f, -0.02171948f, -0.02739152f, -0.03919582f, 
    -0.02189420f, -0.01714522f, 0.01928261f, -0.02126482f, -0.00834878f, -0.03005092f, -0.00816588f, 0.01420329f, 
    -0.01218712f, -0.03526083f, -0.02841189f, -0.01030727f, -0.04534296f, 0.02236444f, -0.02061849f, 0.00302657f, 
    0.00540082f, -0.00428255f, -0.03286420f, 0.02407449f, -0.00560868f, 0.00597791f, 0.00645379f, -0.00418458f, 
    -0.00265838f, -0.00931992f, -0.02872792f, 0.02193709f, 0.01571403f, -0.04332923f, 0.00181956f, -0.02772268f, 
    0.02006444f, -0.00427540f, -0.01875509f, 0.02173887f, -0.03432046f, -0.00429577f, 0.02445262f, -0.00922211f, 
    -0.02121191f, 0.02118962f, 0.01048894f, -0.00463064f, -0.01129144f, 0.02339168f, -0.03426994f, -0.00681187f, 
    -0.03439603f, -0.02482211f, 0.00589883f, -0.01779494f, -0.01449411f, -0.02108622f, 0.00295294f, -0.02042651f, 
    0.02608338f, 0.01543615f, 0.00913622f, 0.01158016f, 0.00169148f, -0.01108266f, -0.03174379f, -0.00591734f, 
    -0.00983372f, 0.03067726f, 0.00584922f, -0.02927077f, -0.04093944f, -0.01350277f, -0.00780013f, -0.02649684f, 
    -0.01832274f, -0.02699867f, -0.02251522f, -0.01644476f, 0.02386525f, 0.01063363f, -0.00870677f, 0.01566841f, 
    -0.01178027f, -0.03560340f, -0.00400332f, 0.01505703f, -0.03347706f, -0.02669051f, 0.01880250f, -0.03453797f, 
    -0.00046922f, 0.01909255f, -0.04048279f, -0.03577982f, -0.02326900f, -0.01048325f, -0.01148276f, -0.01871853f, 
    0.02292562f, -0.03655534f, -0.03451018f, 0.00754392f, -0.02575945f, -0.01559638f, -0.00547921f, -0.02209648f, 
    -0.00680512f, -0.00429416f, -0.00585338f, 0.01993277f, -0.00771948f, 0.00900149f, -0.00962520f, -0.00152090f, 
    -0.01117614f, 0.01400384f, 0.02404255f, -0.00086342f, -0.03060778f, -0.02956400f, 0.02553979f, 0.00581729f, 
    0.00415530f, -0.01815106f, -0.02816938f, 0.02219266f, -0.03519874f, -0.01194201f, -0.02057642f, -0.00898027f, 
    0.01282043f, -0.02860043f, -0.03010697f, -0.01802588f, 0.01120695f, 0.00655382f, -0.03345339f, -0.03710302f, 
    -0.00008284f, -0.01234146f, 0.02089148f, -0.02563659f, 0.00853845f, -0.02448976f, 0.01344342f, -0.02269154f, 
    -0.00106884f, -0.03085107f, 0.02774348f, -0.01928374f, -0.02634763f, 0.01533879f, -0.00060917f, 0.01000617f, 
    0.00755591f, 0.01416904f, -0.00379092f, -0.03253086f, 0.00780778f, 0.01172677f, -0.02554224f, -0.00833725f, 
    -0.01858860f, 0.00900480f, 0.00924378f, -0.03187106f, -0.02620021f, -0.00361100f, -0.01306699f, -0.02490770f, 
    -0.02624951f, 0.01251887f, -0.00174692f, -0.03838512f, 0.01571874f, 0.00205378f, 0.01576596f, 0.02166203f, 
    -0.02312136f, 0.00272255f, 0.00722924f, -0.01855478f, 0.00359679f, -0.03449745f, 0.00682620f, -0.01755295f, 
    -0.02591337f, 0.02445630f, 0.02975257f, -0.03038737f, 0.00665386f, 0.00070510f, 0.00824872f, 0.01052752f, 
    0.02073829f, -0.02174490f, -0.00246852f, -0.03467524f, 0.01324924f, 0.02451660f, 0.02047698f, -0.03566003f, 
    0.02600702f, 0.01301424f, 0.01446809f, 0.00571638f, -0.03581282f, -0.00606197f, 0.00522671f, -0.02828339f, 
    0.00570313f, 0.01099148f, 0.01606064f, -0.03247678f, -0.02563983f, -0.04093969f, -0.04385753f, 0.02622276f, 
    -0.02008667f, -0.03422238f, -0.03981402f, 0.02164308f, 0.00754614f, 0.02976009f, 0.00278713f, -0.00741567f, 
    0.02314709f, -0.02172818f, 0.01363398f, -0.02743139f, 0.00276869f, 0.01486950f, 0.00637801f, -0.01231102f, 
    -0.00217791f, 0.01064944f, -0.00526655f, -0.01089496f, -0.01689016f, 0.02671631f, -0.02786040f, -0.01345827f, 
    0.02801476f, 0.01526360f, -0.02546722f, -0.03112418f, -0.01709583f, 0.01211776f, -0.00315093f, 0.00307275f, 
    0.02757300f, 0.00578178f, 0.00374838f, 0.01707752f, 0.02257277f, -0.00968106f, 0.03232485f, -0.04105532f, 
    -0.00353360f, 0.02316349f, 0.00442315f, 0.00203621f, -0.03124243f, -0.03880390f, 0.00581252f, -0.00375551f, 
    0.01861152f, -0.02925494f, 0.00445730f, -0.03162963f, -0.02309943f, -0.03021557f, -0.01671792f, 0.01964825f, 
    -0.03107748f, -0.02804413f, 0.02359128f, -0.02394451f, 0.01227973f, 0.01320781f, -0.03288369f, -0.01002729f, 
    0.01259276f, 0.03916763f, 0.02135901f, 0.03086798f, -0.03999155f, -0.04434437f, -0.04634728f, -0.02368458f, 
    0.01050083f, -0.03035285f, 0.01325514f, -0.04467947f, 0.02073239f, 0.01542410f, 0.03303806f, 0.01096676f, 
    0.00971739f, -0.01473128f, -0.01174615f, 0.01606544f, 0.00992297f, 0.02424456f, 0.00346061f, -0.00233451f, 
    0.01900111f, 0.00860897f, 0.02120860f, -0.04005967f, -0.01219315f, -0.04444882f, -0.00507441f, 0.01887459f, 
    0.00901453f, -0.01774151f, -0.00734652f, -0.02224952f, 0.02167568f, 0.01042068f, -0.03463246f, 0.01302790f, 
    -0.00396000f, -0.03752948f, 0.00112526f, 0.01117353f, -0.00207602f, 0.01751569f, -0.03640465f, -0.00073265f, 
    -0.04024207f, -0.01699258f, -0.02966914f, 0.01260217f, -0.01349521f, -0.00986796f, -0.01072224f, 0.00878923f, 
    0.01203883f, 0.01138699f, -0.04253963f, 0.00999322f, 0.01967898f, -0.00821523f, 0.01482791f, -0.04641285f, 
    -0.01129393f, -0.01267255f, -0.02099714f, 0.00065574f, -0.02067197f, -0.02773095f, 0.02320511f, 0.01878626f, 
    -0.02504360f, 0.02479843f, -0.02529939f, 0.00666215f, -0.00304135f, 0.01983084f, -0.02136562f, 0.01823432f, 
    -0.01042130f, -0.00488508f, -0.01193815f, 0.02309281f, -0.00471162f, 0.03175550f, 0.00235339f, 0.01417456f, 
    0.02140022f, -0.01584682f, 0.00409798f, 0.00458360f, 0.02308030f, -0.03621703f, 0.01937580f, -0.01240757f, 
    0.01773268f, 0.00245615f, -0.00549756f, -0.01084907f, 0.02271649f, 0.00510748f, -0.02367284f, 0.01265216f, 
    -0.01761075f, 0.01295755f, 0.00356845f, 0.01277372f, -0.00755027f, -0.01733989f, 0.00427674f, 0.02501313f, 
    -0.00604825f, 0.02386945f, -0.00104020f, 0.02469773f, 0.00224849f, -0.00561302f, 0.01710932f, 0.00885143f, 
    -0.01415987f, -0.03862676f, 0.00243038f, 0.02389369f, -0.03387403f, 0.02749541f, 0.02368967f, 0.02267514f, 
    0.00343524f, 0.02117463f, 0.03353165f, -0.04711027f, -0.03001138f, 0.00986183f, -0.01206583f, 0.00047948f, 
    0.00990782f, -0.03467689f, -0.03213886f, 0.01489957f, -0.03339881f, 0.02374804f, 0.01650413f, -0.01807352f, 
    -0.01675728f, 0.02623838f, 0.01675840f, -0.03322143f, -0.03988186f, -0.02733490f, 0.01707307f, 0.02450127f, 
    0.03130718f, -0.03690608f, -0.02852919f, 0.00587155f, 0.02283365f, 0.01243230f, 0.00003330f, 0.01524489f, 
    -0.00662384f, -0.00156553f, 0.00013239f, 0.02165784f, -0.02457090f, -0.03288304f, -0.04004843f, -0.01773632f, 
    -0.25294876f, 0.02877628f, 0.03651280f, 0.01380502f, -0.03639815f, -0.02501211f, 0.01954424f, -0.01975834f, 
    0.14305025f, 0.14019988f, 0.08599967f, -0.22481725f, -0.32264313f, 0.00420395f, 0.02788550f, -0.00296301f, 
    -0.20156144f, -0.15776563f, -0.16711737f, -0.06206227f, -0.03039896f, 0.14887331f, -0.08199422f, -0.08392877f, 
    -0.05058292f, 0.01838074f, -0.06711908f, 0.08987335f, -0.07176352f, 0.09483438f, 0.10546634f, 0.05216732f, 
    0.04980807f, 0.01080762f, -0.09089190f, 0.01327914f, -0.03415686f, 0.10131023f, -0.21513294f, -0.03116421f, 
    0.06977799f, 0.09044530f, 0.07227623f, -0.03411497f, -0.06755144f, 0.00218441f, 0.12001994f, 0.13346162f, 
    0.29773644f, 0.11106156f, -0.23977377f, 0.17212254f, -0.05370838f, 0.06565308f, 0.01665222f, -0.07674637f, 
    0.14666799f, 0.09257320f, -0.08297831f, -0.00515085f, 0.20264469f, -0.39358222f, 0.06984750f, -0.15751866f, 
    -0.13255839f, 0.11292007f, 0.04763611f, -0.14245105f, 0.03865684f, -0.00320368f, -0.06564154f, -0.01358579f, 
    -0.03539059f, -0.02492270f, 0.17261916f, -0.12740120f, -0.09974980f, 0.01621625f, -0.07463024f, -0.03020885f, 
    -0.00928270f, -0.04459092f, -0.03896599f, -0.08229821f, 0.11175404f, -0.11280163f, -0.13814834f, 0.16594945f, 
    -0.12722476f, -0.06536065f, 0.06100049f, 0.11642915f, -0.09976353f, -0.10567129f, 0.07519423f, -0.06238127f, 
    0.31695366f, -0.04493286f, 0.11939236f, 0.33437371f, -0.00241087f, -0.17068109f, -0.01903646f, -0.00000914f, 
    -0.16129796f, -0.02447447f, 0.10912960f, 0.20627445f, -0.01830578f, 0.11863477f, 0.10722978f, 0.10257080f, 
    0.01692680f, 0.08225183f, 0.19903994f, -0.04532247f, -0.13715152f, -0.06444597f, 0.00244368f, -0.13958038f, 
    0.31096908f, 0.19140679f, 0.13533859f, 0.06032550f, -0.13381860f, -0.03189329f, -0.08941323f, -0.06807111f, 
    -0.01629417f, 0.06057099f, 0.00967792f, 0.03670226f, 0.23845640f, -0.00942721f, -0.02021493f, 0.14028820f, 
    -0.00445809f, -0.17677800f, 0.12076792f, 0.07677773f, 0.00147313f, -0.02151209f, -0.10550131f, 0.17161843f, 
    0.02831262f, 0.11944602f, 0.09418750f, -0.06637397f, -0.04083117f, 0.14984289f, -0.06967191f, -0.12209759f, 
    -0.06579868f, -0.01617468f, -0.09624148f, 0.08479821f, 0.08356093f, 0.05302460f, -0.00912637f, 0.24629015f, 
    0.02049335f, -0.00899919f, -0.00279018f, 0.07858953f, -0.10132447f, 0.06138374f, 0.02401411f, 0.09807663f, 
    0.29537663f, 0.07031942f, -0.02567249f, -0.10153414f, 0.01908375f, 0.12976629f, 0.22767863f, 0.14874081f, 
    -0.08760870f, 0.07954536f, -0.13285430f, 0.11726312f, 0.00810997f, 0.15529706f, 0.13690396f, -0.02583626f, 
    -0.04616901f, 0.01177548f, -0.02483761f, 0.16387835f, -0.01229909f, -0.15851337f, -0.01197168f, 0.03350160f, 
    0.10724038f, 0.07569606f, -0.13860297f, 0.16206060f, -0.01375895f, -0.13721851f, 0.23535392f, 0.10340697f, 
    0.01714967f, -0.11569054f, 0.12973908f, 0.13778828f, 0.14749473f, 0.15093812f, 0.07687936f, 0.17480876f, 
    0.03356737f, 0.11159027f, 0.00357830f, 0.03741907f, 0.01965067f, 0.07236097f, 0.02278651f, -0.03840270f, 
    0.20035572f, 0.08946166f, -0.14859845f, 0.06076137f, 0.02830268f, 0.16547722f, -0.06034055f, 0.09917346f, 
    0.05974174f, 0.14401674f, -0.05842404f, 0.02582887f, -0.06179427f, 0.06214784f, 0.04758686f, 0.13121706f, 
    -0.08081265f, -0.01991033f, 0.00595305f, 0.14793360f, -0.03931309f, 0.02970221f, 0.10851851f, 0.01887846f, 
    -0.09478854f, -0.06804669f, -0.02574850f, -0.09384686f, 0.15106311f, 0.05613665f, -0.04240553f, 0.05379604f, 
    -0.05479893f, -0.15135191f, 0.01077703f, -0.18048878f, 0.34264615f, 0.04822225f, 0.08183300f, -0.00072660f, 
    -0.08188646f, 0.00602124f, 0.10814440f, -0.09203087f, -0.03706236f, -0.04414016f, -0.03627387f, 0.03035768f, 
    0.21602637f, 0.09947385f, 0.13174544f, 0.16403729f, 0.03353434f, 0.09583501f, 0.01146079f, -0.05621094f, 
    -0.01416882f, 0.05211983f, -0.04087077f, 0.04466348f, -0.34025145f, 0.00401811f, 0.03314780f, -0.00793469f, 
    0.07502362f, -0.03072322f, 0.13434508f, 0.11015597f, -0.20660806f, 0.07017823f, 0.00401574f, -0.30947211f, 
    0.10931101f, -0.05636288f, 0.03109437f, 0.15950042f, 0.05045683f, 0.03767430f, -0.07141884f, 0.00258094f, 
    -0.03887506f, 0.05447126f, 0.02079326f, -0.00322238f, -0.20096916f, -0.34769922f, 0.10448498f, -0.14401348f, 
    0.21495254f, 0.15371554f, 0.17485932f, -0.06482003f, 0.05382198f, -0.02579418f, -0.00549542f, 0.10220825f, 
    0.21946046f, 0.15376532f, 0.01264654f, -0.11035801f, 0.03281320f, 0.09184978f, 0.12585698f, -0.03201272f, 
    -0.09347472f, 0.01535221f, -0.07860682f, -0.09867178f, 0.06663644f, 0.06487379f, 0.14835678f, -0.24051529f, 
    -0.22501513f, -0.00075728f, -0.06987984f, -0.04085637f, 0.01666832f, 0.04347140f, -0.06215108f, -0.15420750f, 
    -0.15082011f, -0.17659925f, 0.17288661f, 0.03811603f, -0.02833734f, 0.05656463f, -0.05271827f, -0.08873421f, 
    -0.05119067f, -0.12919521f, 0.01880389f, -0.10489542f, 0.16536824f, 0.24214664f, 0.00327527f, -0.26414928f, 
    -0.15401974f, -0.04246315f, -0.04768449f, -0.18124984f, 0.11689590f, 0.05577321f, 0.00488383f, 0.16488557f, 
    0.01238463f, 0.10109607f, -0.11069455f, 0.10477985f, 0.10472763f, 0.08725027f, -0.05457067f, 0.08500031f, 
    -0.04124859f, -0.03180433f, 0.04489945f, -0.02579135f, 0.27403927f, 0.06919857f, 0.03015871f, 0.10067988f, 
    0.03335890f, 0.04123529f, 0.19056173f, 0.09069870f, 0.07240209f, 0.10241864f, 0.02381237f, 0.02058025f, 
    0.02935279f, 0.11694293f, 0.03138849f, -0.04427319f, -0.05642108f, 0.03010310f, -0.13627784f, 0.17323251f, 
    -0.15369225f, -0.09507824f, 0.14326067f, -0.22610569f, -0.11533704f, -0.05898769f, -0.06376585f, -0.13491359f, 
    0.08560482f, -0.01047247f, -0.10463244f, -0.01772483f, -0.14006069f, -0.01922946f, -0.06088149f, -0.11428945f, 
    -0.00967519f, 0.02714435f, -0.10574529f, -0.03413925f, -0.05854446f, 0.07192271f, -0.00307924f, -0.14757609f, 
    0.00077238f, 0.03195558f, -0.05158555f, 0.16552015f, 0.14351834f, -0.14100523f, -0.17102814f, -0.09549608f, 
    -0.16382024f, 0.08451430f, 0.15468511f, 0.11078344f, 0.13239883f, 0.10531829f, 0.06006042f, 0.00223300f, 
    -0.04009740f, -0.07280779f, -0.29284662f, -0.25134134f, 0.05297646f, -0.08502315f, -0.06844750f, 0.05428192f, 
    -0.02624763f, 0.05647179f, 0.16459738f, 0.10893455f, -0.02642995f, -0.03615727f, -0.04333783f, 0.00306238f, 
    -0.00049251f, 0.03493571f, 0.12638327f, -0.06104780f, 0.19907522f, 0.04246272f, -0.01125191f, 0.19558571f, 
    0.18313880f, -0.04336699f, -0.00370284f, 0.23285650f, 0.08265767f, -0.00941055f, 0.05477569f, -0.03732932f, 
    -0.00509197f, -0.02402696f, 0.10808595f, 0.01713509f, -0.04544741f, 0.20981017f, -0.04246949f, -0.02187883f, 
    -0.11873055f, 0.00356779f, -0.19548669f, 0.02232934f, -0.01381439f, -0.08811440f, -0.08906761f, -0.00016208f, 
    -0.13452546f, -0.07500469f, 0.06545798f, -0.04679563f, -0.08355999f, 0.01918317f, 0.02023946f, -0.09882243f, 
    0.18049045f, 0.07056390f, 0.07934538f, -0.01769361f, 0.01610261f, -0.20868830f, 0.01601318f, 0.05170032f, 
    0.05642014f, 0.06423362f, 0.02281741f, -0.11605335f, 0.06574611f, 0.03275771f, 0.05091775f, 0.16800912f, 
    -0.07462276f, 0.12470307f, -0.05160671f, -0.00042526f, -0.06560539f, -0.07609506f, 0.17628078f, -0.04734227f, 
    -0.11653540f, -0.00956337f, -0.04566971f, -0.20301865f, -0.07264114f, 0.22537899f, 0.22058554f, -0.10216873f, 
    -0.04956746f, -0.00653220f, -0.00438324f, -0.00280244f, -0.00819848f, 0.09976267f, 0.05004546f, 0.18067102f, 
    -0.18130559f, 0.03900908f, -0.12534074f, -0.15063000f, -0.05148747f, 0.14194699f, -0.20125203f, 0.07890439f, 
    -0.08699214f, 0.06371408f, 0.03926320f, 0.04463329f, -0.33839589f, 0.09112145f, 0.15435724f, -0.16025594f, 
    0.01894610f, 0.07123628f, -0.19565921f, -0.00532346f, 0.03168627f, -0.11304466f, -0.09714171f, 0.04739933f, 
    0.19279134f, 0.21386604f, 0.10704949f, 0.16137251f, -0.09648664f, -0.06757225f, -0.05935738f, -0.01641609f, 
    -0.03069276f, 0.00973439f, -0.03538435f, -0.05419962f, 0.09890968f, 0.16975167f, -0.09881018f, -0.06241756f, 
    0.03362204f, -0.09191414f, 0.02069302f, 0.08587702f, -0.01751505f, -0.01986375f, -0.02172630f, -0.11337296f, 
    0.14005809f, -0.02836738f, 0.02302462f, -0.23177692f, -0.00851255f, 0.17870173f, 0.05464357f, -0.00257360f, 
    -0.02434367f, 0.02986097f, -0.02921167f, -0.08418807f, 0.00491344f, 0.02781234f, -0.03163053f, 0.06400538f, 
    0.01087584f, -0.04212639f, 0.02580422f, -0.04825095f, -0.16424787f, -0.16101833f, 0.05162435f, -0.18604782f, 
    0.02994250f, 0.00164407f, -0.20952451f, -0.27134219f, 0.04076430f, 0.07197808f, 0.13710733f, -0.05826008f, 
    -0.14042301f, -0.07871053f, -0.22477469f, -0.04991999f, 0.35770142f, 0.15290080f, 0.19477293f, 0.03303523f, 
    0.00964459f, -0.10270713f, 0.01062408f, 0.03513027f, 0.08416521f, -0.00639458f, 0.13640364f, -0.01575913f, 
    0.30900675f, -0.08797538f, -0.07270882f, 0.03072577f, -0.07306399f, -0.04897678f, 0.07580634f, -0.02933495f, 
    0.11476452f, 0.19486468f, 0.16126116f, -0.09326718f, 0.25632513f, -0.45926592f, 0.00290144f, -0.03657224f, 
    -0.01439472f, 0.01341803f, 0.10443112f, -0.04251097f, 0.07587545f, 0.09793049f, 0.02599613f, 0.01603465f, 
    -0.03665896f, -0.21476875f, -0.09070510f, -0.15237765f, -0.06460682f, -0.04545788f, -0.00787245f, -0.00533203f, 
    -0.00886660f, -0.07892639f, -0.19776353f, -0.09610005f, 0.33586517f, 0.26265880f, -0.03029631f, -0.11636802f, 
    -0.09247034f, -0.14324844f, -0.01814245f, -0.19118133f, 0.07355023f, 0.01345054f, 0.03883899f, 0.08991473f, 
    0.21426830f, 0.22056457f, 0.13354063f, 0.18950827f, -0.01127272f, 0.01015612f, 0.18853223f, -0.07571645f, 
    -0.08474455f, 0.12451741f, 0.10954794f, 0.08350864f, 0.55590260f, -0.06226076f, -0.06260716f, 0.07281809f, 
    0.04404573f, -0.06249624f, 0.09683326f, 0.12436152f, 0.13065135f, 0.03821187f, -0.02899467f, 0.03420738f, 
    0.06144645f, 0.01344360f, 0.09514734f, 0.10970742f, 0.01345806f, -0.00847090f, 0.04261439f, 0.07617775f, 
    -0.08836745f, 0.03789762f, 0.03015247f, -0.07254618f, -0.00771701f, 0.06474616f, -0.10701824f, 0.08204527f, 
    0.01337624f, 0.12866975f, 0.01256493f, 0.06417979f, -0.09471480f, -0.01534570f, -0.06976675f, -0.07671840f, 
    0.39484340f, -0.16247568f, -0.16664185f, 0.00533769f, -0.00339969f, -0.02614025f, 0.06433188f, -0.10330443f, 
    -0.09381897f, -0.09861506f, 0.02645777f, 0.09860480f, -0.25961071f, 0.09586672f, 0.07216138f, -0.17582999f, 
    0.02447307f, 0.08513387f, 0.04359441f, -0.02535037f, 0.12583704f, 0.10001385f, -0.00423895f, 0.26836723f, 
    -0.01527664f, 0.00893167f, -0.16116300f, -0.15975708f, 0.01428937f, 0.08674423f, 0.01233749f, -0.15110195f, 
    -0.02955190f, -0.07013366f, -0.06706242f, -0.18710403f, -0.09624835f, 0.22918591f, 0.10051463f, 0.26304018f, 
    0.06513532f, 0.01165618f, 0.05002262f, -0.00275541f, -0.02011635f, 0.02060854f, 0.03574123f, -0.00721986f, 
    -0.02585173f, 0.01008809f, -0.02453969f, -0.02040994f, -0.02229441f, 0.00450581f, -0.01704526f, -0.02630775f, 
    -0.01333184f, 0.02243002f, -0.00686237f, -0.00986195f, -0.00057578f, -0.03161466f, -0.01785439f, -0.03974111f, 
    -0.00620744f, -0.02261369f, -0.01810021f, 0.02467451f, 0.00367813f, 0.02583559f, -0.03260055f, 0.02166889f, 
    0.00050762f, -0.04241402f, -0.02071649f, -0.03421926f, 0.00512621f, -0.02636479f, -0.01511288f, -0.03010757f, 
    0.01097638f, -0.00737963f, 0.00618696f, -0.02356643f, 0.01559231f, -0.01650116f, 0.00702797f, -0.00917296f, 
    0.00718265f, -0.03481020f, 0.00964156f, 0.00555797f, 0.00600038f, 0.02734536f, 0.02741684f, 0.01435004f, 
    -0.01322823f, 0.01687451f, -0.01155294f, -0.03523475f, -0.04166136f, -0.03383337f, -0.03999601f, 0.01297016f, 
    -0.01770960f, -0.00174093f, -0.03835747f, -0.03743577f, 0.01381568f, 0.01526728f, -0.02583765f, 0.02445678f, 
    -0.00323611f, 0.02342720f, -0.02480171f, 0.02384558f, 0.00061263f, 0.00355684f, -0.03229376f, 0.02305350f, 
    -0.02565974f, -0.02782659f, -0.02890166f, 0.00508541f, -0.02760561f, 0.02427015f, -0.00192620f, 0.01736377f, 
    0.02499598f, -0.00255143f, -0.03177936f, 0.02536985f, 0.00941157f, 0.01514350f, 0.00148965f, -0.04339765f, 
    -0.00358946f, 0.02181542f, -0.01066739f, 0.00911958f, 0.00935213f, -0.00942618f, -0.01764988f, 0.00690459f, 
    0.00120735f, 0.00407289f, -0.04158406f, 0.00041941f, 0.02261470f, -0.02717238f, -0.03858355f, -0.00294950f, 
    0.03170500f, 0.03088392f, -0.00327011f, -0.02862971f, 0.00641393f, 0.00590210f, -0.00267031f, -0.01823390f, 
    -0.00492586f, 0.02648794f, -0.02507575f, -0.00405167f, -0.00644839f, -0.00262132f, -0.01586860f, -0.02662374f, 
    0.02295905f, -0.00366193f, 0.00519533f, 0.02193769f, -0.03481311f, 0.00089506f, -0.01663207f, -0.03073050f, 
    -0.00627886f, 0.02031881f, -0.01269094f, -0.01181542f, -0.00771338f, 0.00531231f, -0.04292872f, -0.04185758f, 
    -0.03520968f, -0.00282038f, -0.03084290f, -0.04076732f, 0.01268741f, 0.02360257f, 0.02547455f, -0.00741866f, 
    -0.00187651f, 0.00689730f, -0.00920436f, -0.00464839f, 0.01078316f, -0.01526620f, -0.01567623f, 0.01319921f, 
    0.01671243f, 0.00444897f, -0.03588326f, -0.02155686f, 0.01397087f, -0.04233969f, -0.02218635f, -0.02381615f, 
    0.00267286f, 0.01236349f, 0.03171742f, 0.02795792f, -0.00792469f, 0.01959429f, 0.00036317f, -0.01236977f, 
    -0.01385284f, -0.01110758f, -0.00409608f, -0.02210589f, 0.01230927f, -0.03404917f, -0.03124054f, -0.03115399f, 
    0.00704120f, 0.01970052f, -0.00676138f, -0.03696835f, -0.01717982f, 0.01335177f, -0.01125775f, -0.01543396f, 
    0.02585697f, -0.00378669f, 0.01764282f, 0.00413650f, -0.02941241f, -0.03089601f, -0.01562019f, -0.02985542f, 
    -0.02309114f, 0.02430620f, -0.02294611f, -0.00679897f, -0.00793107f, -0.02243962f, 0.01960880f, -0.02030664f, 
    0.02487176f, 0.00976328f, -0.00409607f, 0.00356110f, -0.01075332f, 0.02760392f, 0.00935460f, -0.00590478f, 
    -0.04293800f, -0.01369755f, 0.01196027f, -0.03909440f, -0.04204722f, 0.00167812f, 0.02461317f, -0.02153887f, 
    0.00070319f, 0.01895891f, -0.04223026f, -0.02118517f, 0.01775756f, -0.00994518f, 0.00028246f, 0.01065243f, 
    0.00313511f, -0.01200911f, -0.01233354f, 0.01072929f, -0.02177147f, -0.03153983f, 0.00830923f, -0.01835626f, 
    -0.01586837f, 0.00068438f, 0.02562604f, 0.01532447f, 0.01958474f, 0.02592497f, 0.00946421f, -0.03830088f, 
    -0.02854398f, -0.00215802f, -0.02836724f, -0.00585992f, -0.03340250f, 0.01674315f, -0.01300137f, -0.00188726f, 
    0.00257623f, -0.04271166f, -0.04214079f, 0.00068606f, 0.00592905f, -0.03526895f, -0.04249104f, -0.03730356f, 
    0.01509426f, 0.02901155f, 0.01929402f, -0.03659507f, 0.00638287f, -0.03840419f, 0.02796032f, 0.01677886f, 
    0.00428568f, -0.03866624f, 0.02569447f, -0.01919509f, -0.04100174f, -0.01994002f, -0.02181088f, -0.03362818f, 
    -0.02624626f, 0.01656093f, -0.03616943f, -0.01577962f, -0.00684890f, 0.01398014f, 0.02550965f, 0.01453384f, 
    -0.04272597f, 0.00886471f, -0.04209935f, -0.02933466f, -0.03334802f, -0.02390940f, 0.01835669f, -0.04011321f, 
    -0.01033856f, 0.02692414f, -0.02477879f, -0.04019796f, -0.02994991f, 0.00345949f, 0.01895480f, 0.01542304f, 
    -0.01703738f, -0.03063002f, -0.02049905f, -0.00513179f, 0.02243057f, 0.00085381f, -0.00541335f, -0.04300456f, 
    -0.01153528f, -0.04221208f, 0.01149267f, -0.02644748f, 0.02354418f, -0.02372249f, -0.02501485f, -0.02214414f, 
    -0.01526166f, 0.01642229f, 0.00298608f, -0.02034226f, 0.00902767f, -0.03819029f, 0.02006633f, 0.00241265f, 
    0.01576373f, 0.00735547f, -0.00811406f, 0.02949315f, 0.00598994f, 0.02357648f, -0.02118466f, -0.00726951f, 
    -0.02439001f, 0.01034803f, -0.01083945f, 0.02298958f, 0.00875018f, -0.01562042f, -0.04013857f, -0.01460892f, 
    -0.03048276f, -0.03018645f, 0.00594268f, 0.01081735f, 0.02641371f, -0.00674916f, 0.00237236f, 0.00348175f, 
    -0.00049328f, 0.01817201f, 0.02696741f, -0.00964253f, 0.02218950f, -0.00002334f, -0.03185264f, -0.00229897f, 
    -0.00445647f, -0.02462815f, -0.02661311f, -0.01829915f, 0.02068288f, -0.02536829f, 0.01530397f, -0.02100017f, 
    0.02047784f, 0.01231259f, -0.01306756f, -0.03350137f, -0.02524571f, -0.01268558f, -0.02901681f, -0.03529574f, 
    0.01203594f, 0.00116200f, -0.02720352f, 0.01405626f, 0.03042656f, -0.03387716f, -0.00083654f, -0.01331382f, 
    0.01150479f, -0.01154134f, -0.02115052f, -0.04334860f, 0.01113249f, -0.02708078f, -0.01526729f, -0.03359701f, 
    -0.01660322f, 0.00851771f, 0.02649317f, -0.02391882f, 0.01735219f, -0.01986023f, -0.00100153f, -0.01747408f, 
    -0.04049450f, -0.04343380f, -0.01211775f, 0.00747715f, 0.00995728f, -0.04036285f, 0.02356040f, -0.01358382f, 
    0.02938747f, -0.02468612f, -0.02198050f, 0.00366826f, -0.00625817f, -0.02205948f, 0.00079192f, 0.01044221f, 
    0.02378875f, 0.02229923f, 0.01912551f, -0.02851305f, -0.02419483f, -0.03013625f, 0.01594003f, 0.01510265f, 
    0.02571529f, -0.04219671f, -0.00944072f, -0.02898215f, -0.02489306f, 0.00781490f, -0.02984498f, 0.00766893f, 
    -0.00353644f, -0.01049864f, 0.01314434f, 0.01514065f, 0.01850477f, -0.00933997f, -0.00035075f, 0.01844939f, 
    0.01757849f, -0.03478757f, -0.02884613f, -0.01706067f, -0.00307067f, -0.03541585f, -0.03278803f, -0.01693801f, 
    -0.03392998f, 0.00219108f, -0.03089193f, 0.02849271f, -0.04434541f, -0.01916112f, 0.02789020f, 0.01329950f, 
    -0.02541055f, -0.02925704f, 0.01739356f, 0.02057180f, -0.01819928f, -0.01631955f, 0.01075360f, 0.01180902f, 
    -0.03264942f, 0.01401606f, -0.03855408f, 0.01968108f, -0.03821748f, 0.01252032f, 0.00897271f, 0.01433601f, 
    0.02906898f, -0.02452228f, -0.02391521f, -0.02997864f, 0.01702366f, 0.01065697f, 0.00268390f, 0.02132991f, 
    -0.03596125f, -0.01253967f, -0.04247510f, 0.01793183f, -0.01493920f, -0.00897838f, -0.00239762f, -0.03682761f, 
    -0.01330577f, 0.02254835f, 0.01435957f, 0.01856594f, -0.04109319f, 0.01975270f, 0.00589925f, 0.00158721f, 
    -0.00659376f, 0.00477332f, 0.00546643f, 0.00591517f, 0.01524948f, -0.02451575f, -0.03940981f, -0.03940728f, 
    0.01909960f, -0.01939876f, -0.01097570f, -0.01140905f, 0.00109748f, -0.02665363f, -0.03045810f, -0.03470732f, 
    -0.03443571f, -0.01430443f, 0.02938564f, 0.02353273f, 0.00682124f, 0.00059825f, -0.02079715f, 0.02031669f, 
    -0.03105493f, 0.01179366f, 0.01976993f, 0.01464090f, -0.03788526f, 0.02576675f, 0.00285582f, 0.02904915f, 
    -0.01163152f, -0.02484545f, -0.01622054f, -0.01269702f, -0.01712572f, 0.02735513f, -0.00831211f, 0.00273474f, 
    -0.01391168f, -0.02869657f, -0.01870681f, -0.03258340f, -0.00222623f, -0.00198696f, -0.02130366f, 0.02667489f, 
    0.01780980f, 0.01265321f, -0.02130471f, -0.03638299f, 0.02535559f, -0.01331430f, 0.00526180f, 0.02743142f, 
    0.00252778f, 0.01076678f, -0.02800841f, -0.02662287f, -0.00835132f, -0.01259891f, -0.02142720f, -0.03305237f, 
    -0.03740895f, 0.00578472f, 0.01435207f, 0.00359571f, -0.03414395f, 0.00123822f, -0.03368672f, -0.02653359f, 
    -0.02455752f, 0.00599901f, -0.03211849f, 0.01030419f, -0.01460764f, 0.02774164f, 0.02060562f, 0.01346237f, 
    -0.01984061f, -0.02672841f, -0.01816314f, -0.00807740f, -0.02216452f, 0.01457813f, -0.00807233f, -0.00326602f, 
    -0.00964247f, 0.01244864f, -0.03111770f, 0.01086138f, -0.01276554f, -0.00422664f, 0.00649267f, -0.03722770f, 
    -0.03494405f, 0.00218588f, -0.00373956f, -0.03074293f, 0.02948896f, -0.03385474f, -0.00564606f, -0.02262501f, 
    -0.04096166f, 0.01390061f, -0.03657492f, -0.01975363f, 0.00542064f, 0.00211632f, -0.00900219f, -0.01473762f, 
    -0.03680741f, -0.00103428f, 0.02660624f, -0.03503380f, -0.01483179f, 0.00586917f, -0.02071843f, -0.01019507f, 
    -0.01840840f, 0.00403385f, 0.02959720f, -0.00324827f, -0.00171612f, 0.01688474f, -0.02509459f, 0.01706661f, 
    0.00554638f, 0.00958620f, -0.03184606f, -0.00127996f, -0.03079562f, -0.04428151f, -0.00808698f, -0.04182789f, 
    0.02371863f, 0.01832458f, -0.03581081f, 0.00817638f, -0.02067413f, -0.03734265f, -0.00050066f, -0.03826716f, 
    0.01072098f, -0.02680776f, -0.04223773f, -0.03662832f, 0.01682396f, 0.00181455f, -0.00612636f, -0.01928272f, 
    -0.02400610f, -0.00474212f, 0.00299744f, -0.00764601f, -0.01254788f, -0.01136450f, -0.00941092f, 0.02467938f, 
    0.00566918f, -0.00330270f, -0.02725158f, -0.03371469f, -0.02651882f, 0.00470513f, -0.04009588f, -0.02086685f, 
    0.02672170f, -0.00337050f, -0.00607942f, 0.01327456f, -0.00400877f, -0.01343049f, -0.02856143f, 0.02846511f, 
    -0.03400387f, 0.02629826f, 0.01701035f, 0.00120903f, 0.00914798f, -0.02798117f, 0.00412060f, -0.00683806f, 
    0.00681799f, -0.03639168f, 0.02324191f, -0.02446694f, -0.03357507f, -0.03433328f, 0.00381854f, -0.02843698f, 
    0.01528459f, 0.01179470f, -0.00728484f, -0.00646165f, 0.03324032f, 0.00659542f, -0.01308644f, -0.04011675f, 
    0.01997999f, 0.01908245f, -0.01482233f, -0.02470042f, -0.03137910f, -0.03313035f, -0.03306481f, 0.00615038f, 
    -0.01183784f, -0.02107728f, -0.00563038f, -0.02841537f, -0.03492642f, -0.03328123f, -0.03141682f, -0.01387969f, 
    0.01939600f, -0.01003381f, -0.01599773f, -0.00640121f, -0.03897810f, 0.00587985f, -0.04180108f, 0.00743343f, 
    0.01193146f, 0.01856845f, -0.00398950f, 0.02009323f, -0.01256322f, -0.01798734f, 0.00657778f, -0.00000397f, 
    -0.03071785f, -0.03076156f, -0.00291062f, -0.01778496f, -0.00895367f, -0.00433834f, -0.00120799f, -0.04223058f, 
    0.01530090f, 0.01913159f, 0.00851279f, -0.00424830f, -0.00344630f, 0.01481093f, 0.02245765f, -0.02468062f, 
    -0.04161773f, 0.00032639f, 0.02492975f, -0.03546003f, 0.00305520f, -0.03837619f, -0.01019441f, -0.02548897f, 
    0.01225716f, -0.00042334f, 0.02639437f, 0.03046507f, 0.02345774f, 0.00875212f, -0.01286018f, -0.00891955f, 
    0.01472104f, -0.00536284f, -0.00857063f, 0.02773733f, 0.01474494f, 0.01972378f, -0.01759443f, -0.00061194f, 
    -0.02763177f, 0.01127720f, -0.01122942f, 0.02963652f, 0.02418688f, -0.03217479f, -0.00411179f, 0.01586449f, 
    -0.00894753f, -0.01047997f, -0.02899279f, -0.01477624f, -0.03335531f, 0.01427606f, -0.00109446f, 0.01565959f, 
    0.00379009f, -0.02062486f, 0.00195774f, -0.02001762f, 0.00033604f, -0.00999373f, -0.03821065f, -0.01544160f, 
    0.02675571f, 0.02884437f, 0.00316979f, -0.03289114f, 0.00353371f, -0.00155627f, -0.04015315f, -0.01984943f, 
    0.03191840f, -0.02483303f, -0.00634187f, 0.02912059f, -0.03668923f, -0.01673692f, -0.01469336f, -0.02316041f, 
    -0.02838337f, 0.00332199f, -0.03358117f, 0.00572367f, 0.02512439f, 0.00813554f, 0.00325884f, -0.01649493f, 
    -0.01795039f, 0.00820757f, -0.01514151f, 0.03710262f, 0.00608298f, -0.03225165f, -0.04238508f, -0.02601293f, 
    -0.00306141f, -0.03114424f, 0.01059917f, -0.04595159f, 0.02481182f, 0.02565217f, 0.02339897f, -0.02446582f, 
    -0.01132037f, 0.00576931f, -0.02922338f, -0.01778596f, 0.01397414f, 0.00112332f, 0.01079950f, -0.03376600f, 
    0.01193036f, 0.00721505f, -0.02307384f, 0.02659342f, -0.00601167f, -0.04176031f, 0.01305889f, -0.01733102f, 
    -0.00259373f, -0.03716163f, 0.01979618f, -0.01644200f, -0.02941754f, -0.02471241f, 0.02196447f, -0.00044814f, 
    -0.00971984f, -0.01862914f, 0.02758783f, -0.01039269f, 0.01021030f, -0.00775425f, -0.00571221f, -0.03940418f, 
    -0.00946849f, -0.02476847f, -0.00733344f, 0.00123674f, 0.01860267f, -0.01940720f, 0.00180735f, -0.03359491f, 
    0.02796008f, -0.01844400f, 0.00424437f, 0.00850850f, -0.02691459f, -0.00855678f, -0.00796448f, 0.03686482f, 
    0.02774129f, -0.02129253f, -0.03716709f, -0.01322956f, -0.00341281f, 0.00066687f, -0.02324307f, 0.00655990f, 
    -0.03016545f, 0.02376078f, 0.00053228f, 0.01232089f, -0.01494504f, -0.02992714f, 0.01856756f, 0.00138087f, 
    -0.03432931f, -0.04409426f, 0.01292082f, 0.00682538f, -0.02475134f, -0.01235650f, -0.02799166f, -0.00657671f, 
    -0.00599475f, 0.00157072f, 0.01068158f, -0.00755038f, -0.00707114f, -0.01945460f, 0.00932923f, -0.02210587f, 
    -0.02295514f, 0.01317024f, 0.00753728f, 0.01288265f, -0.03610187f, 0.01268658f, -0.00796194f, 0.02108529f, 
    -0.01285121f, -0.03868894f, 0.02593039f, -0.00637496f, -0.03881482f, -0.02563955f, -0.04039997f, -0.00262411f, 
    0.00958945f, 0.00543230f, -0.01424238f, 0.00211823f, 0.01519613f, -0.01662599f, 0.01067065f, -0.02162847f, 
    -0.01469312f, -0.03439762f, -0.03527325f, -0.03598713f, 0.02771207f, -0.00030880f, -0.01648025f, 0.00823747f, 
    -0.02295120f, -0.00985906f, 0.00279737f, -0.00163570f, -0.01074350f, -0.00642161f, -0.03271406f, 0.01882196f, 
    -0.01759062f, -0.03718633f, 0.01961992f, -0.02113294f, -0.00995906f, 0.01781348f, 0.03473883f, -0.00381626f, 
    0.01784076f, -0.00064399f, 0.00067371f, -0.02007377f, 0.01397497f, 0.01838028f, -0.00046128f, -0.02182863f, 
    -0.01050010f, -0.00138772f, -0.03530129f, -0.02230863f, -0.03037600f, -0.00603331f, -0.03697618f, 0.02858521f, 
    0.02936277f, -0.01840162f, 0.01377613f, 0.00033296f, -0.03833605f, -0.00587030f, -0.02057968f, -0.03524873f, 
    -0.03552552f, -0.02009484f, 0.02561617f, 0.01066933f, -0.02706925f, -0.01885969f, 0.02905744f, -0.00606169f, 
    -0.01106043f, 0.03572030f, -0.03182746f, 0.01567131f, -0.01809837f, 0.02383083f, 0.00072264f, 0.00467887f, 
    -0.02612791f, -0.02106277f, -0.00836223f, -0.00611944f, 0.02557499f, -0.01665387f, 0.00180155f, -0.03878188f, 
    0.00246093f, 0.01978599f, -0.01874388f, 0.00055401f, -0.04028324f, 0.01220978f, 0.02174413f, 0.01212064f, 
    -0.00601416f, -0.02073591f, -0.00771426f, 0.01172064f, -0.01553752f, -0.03221095f, 0.01605235f, 0.00093657f, 
    -0.03681136f, 0.02866611f, 0.01249445f, 0.02949357f, 0.02935365f, 0.01092116f, -0.02169473f, -0.02924553f, 
    0.01302332f, -0.00485037f, -0.01918537f, 0.01616040f, -0.00649486f, 0.01667942f, 0.00426362f, 0.00788196f, 
    -0.01142985f, -0.01392508f, 0.02342243f, 0.02423943f, -0.00822768f, 0.00636695f, 0.01507713f, 0.01366423f, 
    -0.02567955f, 0.02702938f, 0.01916813f, 0.01721913f, -0.03830221f, -0.04173022f, -0.03617135f, -0.00418114f, 
    -0.03519702f, -0.01271803f, -0.00638861f, -0.01299249f, -0.02126615f, 0.00779324f, -0.00810825f, 0.00847687f, 
    0.00530171f, -0.01245394f, 0.00994730f, -0.01063970f, 0.00561769f, -0.01132657f, -0.01210750f, -0.03457693f, 
    -0.01224048f, 0.02213695f, 0.00886635f, -0.01955004f, -0.03666192f, -0.02246638f, 0.00660158f, -0.00131311f, 
    -0.03307948f, -0.03963753f, 0.00407416f, -0.03116299f, -0.03146031f, -0.00943958f, -0.00375565f, -0.00933195f, 
    -0.00034543f, -0.00169256f, 0.01057885f, 0.02998488f, -0.02095030f, -0.03783740f, 0.02650935f, -0.01006749f, 
    0.00176675f, 0.00107985f, -0.02987153f, 0.03315211f, -0.00795593f, -0.03707184f, -0.00606675f, -0.01884043f, 
    0.00027775f, 0.01337119f, 0.01005352f, -0.03340725f, -0.00065547f, 0.00617577f, 0.00052898f, -0.02430717f, 
    -0.01997093f, -0.00126861f, 0.02479862f, -0.01593569f, 0.02713622f, -0.01110035f, -0.02672258f, -0.04280265f, 
    0.01167334f, -0.03542509f, 0.00471941f, -0.02442812f, -0.03769650f, 0.01086438f, 0.02899666f, 0.01385818f, 
    -0.00986572f, -0.03233640f, -0.00627317f, 0.01801645f, 0.01664601f, -0.00033167f, -0.03492452f, 0.02614286f, 
    -0.00282305f, 0.01897692f, -0.00793337f, -0.03942525f, 0.01978741f, 0.01695298f, -0.03890329f, -0.00572797f, 
    -0.03040321f, 0.01079159f, -0.00653304f, 0.00513868f, 0.00160003f, -0.00324681f, 0.02983809f, 0.01846622f, 
    0.03077727f, 0.00266497f, -0.03475055f, -0.02977150f, -0.03564461f, -0.00327088f, -0.03452840f, -0.00892476f, 
    -0.00854570f, -0.02949531f, -0.03645920f, 0.02473533f, -0.02756930f, 0.00917316f, 0.02370026f, 0.01303688f, 
    0.02521285f, 0.00187249f, 0.02595642f, 0.02523237f, 0.00561029f, 0.01096790f, -0.00659529f, -0.00244102f, 
    -0.04325832f, 0.01632865f, 0.01353919f, -0.01453790f, -0.03036006f, 0.01056865f, 0.02127639f, -0.02293392f, 
    -0.01850601f, -0.00458029f, -0.01369370f, -0.02408989f, -0.02204330f, 0.00606095f, -0.04167550f, -0.00716849f, 
    0.00438725f, 0.00708265f, -0.01703378f, -0.04474533f, 0.02145581f, 0.00343950f, 0.00538854f, 0.03084634f, 
    0.01032061f, -0.00215545f, -0.04140044f, -0.03212951f, -0.01586520f, -0.00101491f, -0.00535929f, -0.02950660f, 
    0.01816798f, -0.01953753f, -0.03920672f, -0.03493077f, 0.00913761f, -0.02697830f, -0.01212375f, 0.00291194f, 
    0.00088529f, 0.00179419f, 0.00993256f, 0.00078423f, 0.01026124f, 0.02561505f, -0.04160557f, -0.01422126f, 
    -0.03114053f, -0.04146859f, -0.00054894f, 0.01707683f, -0.01258703f, -0.00441213f, -0.00292592f, 0.00764798f, 
    0.00671079f, -0.02459566f, 0.02534830f, 0.02132540f, 0.02795147f, 0.00426896f, 0.02444309f, 0.02336929f, 
    -0.00770279f, 0.00640601f, -0.01218427f, -0.00973029f, -0.04061182f, 0.00699199f, 0.01548999f, 0.02080638f, 
    -0.03453025f, -0.01924074f, -0.03432130f, 0.01051133f, 0.02017388f, 0.02648173f, 0.00209108f, 0.02838602f, 
    -0.02929198f, -0.00704284f, -0.02479910f, 0.00709745f, 0.01710304f, -0.03096189f, -0.03143580f, 0.02370990f, 
    -0.03662488f, 0.01521771f, -0.00484997f, 0.03405321f, 0.00662834f, 0.01784645f, -0.02335459f, -0.02649725f, 
    0.00616142f, -0.00641644f, -0.00152289f, -0.04059549f, -0.03115544f, -0.03086699f, -0.00510059f, 0.00400887f, 
    -0.04339843f, -0.01977562f, -0.03771815f, -0.04280803f, 0.01427953f, -0.01274479f, 0.00594262f, -0.04073091f, 
    -0.03005327f, -0.01126929f, 0.01154419f, 0.00790458f, 0.01019170f, -0.03507542f, -0.03050907f, -0.01318288f, 
    -0.01528948f, 0.01692505f, 0.03481668f, -0.01321418f, -0.00965916f, 0.02209116f, 0.01951355f, -0.02274171f, 
    -0.03592001f, -0.02831064f, 0.01623345f, 0.00240949f, -0.00392047f, -0.01473669f, -0.04040745f, 0.00379557f, 
    -0.03713718f, 0.00945148f, -0.00744235f, 0.01250037f, -0.03585757f, 0.00437998f, 0.01624191f, -0.03200689f, 
    -0.00797846f, -0.00582204f, -0.00328308f, 0.01235434f, 0.01909913f, 0.00865491f, -0.00288586f, -0.00290190f, 
    -0.00977006f, -0.01636004f, -0.01110638f, -0.03041789f, -0.00107921f, -0.03742991f, 0.02079089f, 0.00369209f, 
    -0.00163773f, 0.02587088f, 0.02956025f, 0.00450568f, -0.02209927f, -0.02567898f, -0.03713042f, -0.03766515f, 
    0.01721072f, -0.01664244f, 0.00630377f, -0.04158205f, 0.00898442f, -0.00825382f, -0.03900712f, 0.03108650f, 
    -0.02912793f, 0.00932353f, 0.02451286f, 0.00790101f, 0.02885485f, -0.01291359f, -0.00416589f, 0.02625193f, 
    0.00387478f, -0.02131519f, 0.00993584f, 0.00430496f, 0.01967916f, 0.01522780f, -0.01218601f, -0.00211311f, 
    0.02112680f, -0.02089562f, 0.01040521f, 0.00935753f, 0.02854334f, 0.00270585f, 0.00562390f, -0.02373729f, 
    -0.03313841f, -0.01742073f, -0.00437108f, -0.01716706f, -0.02854842f, -0.03120804f, -0.01797751f, 0.02743778f, 
    0.00974942f, -0.03236465f, 0.00154878f, 0.01764893f, 0.00462625f, 0.01827221f, -0.03578153f, -0.02123766f, 
    -0.03463805f, -0.00146053f, 0.01128306f, -0.03421348f, -0.02872317f, -0.03427833f, -0.00751603f, -0.00687548f, 
    -0.01483588f, -0.01029884f, -0.00512741f, -0.02063182f, -0.02364257f, -0.01964005f, -0.02345096f, -0.02571252f, 
    -0.04015500f, -0.03485850f, 0.00799883f, 0.00249789f, -0.01216657f, -0.03503999f, -0.01711040f, -0.04170943f, 
    -0.02474113f, -0.03319401f, -0.01988448f, -0.04360296f, 0.01861517f, -0.03025028f, -0.00409573f, 0.00210912f, 
    -0.01916874f, 0.01902635f, 0.00822208f, -0.00695836f, 0.01510142f, -0.04216403f, 0.02059800f, -0.03041272f, 
    -0.03902321f, -0.02344687f, 0.01846612f, -0.03483709f, -0.02254265f, 0.00855161f, 0.00800342f, 0.01015083f, 
    -0.00989029f, 0.01665444f, 0.00640107f, -0.03507003f, -0.03656354f, 0.02627685f, -0.01815224f, 0.01335236f, 
    -0.03052013f, 0.00265737f, 0.01990427f, -0.00683198f, -0.02553436f, -0.02908692f, -0.00277590f, 0.00308531f, 
    0.03111895f, -0.01487538f, -0.01246390f, -0.01193639f, 0.00701665f, 0.03514913f, -0.01074804f, -0.01760174f, 
    0.01393874f, -0.04031325f, 0.01494708f, -0.00134115f, -0.02363446f, -0.02929570f, 0.02568432f, -0.03274934f, 
    -0.03538172f, -0.03191410f, -0.03377514f, -0.02927939f, -0.02047682f, 0.02452643f, -0.01643500f, -0.01606798f, 
    -0.02789206f, 0.00917726f, -0.02586388f, 0.01484036f, 0.02437039f, 0.00498854f, -0.01707719f, -0.03534818f, 
    -0.01293428f, -0.03262349f, 0.00888014f, 0.00645849f, 0.01419663f, 0.01154919f, -0.01487850f, 0.01537953f, 
    -0.02636705f, 0.01757323f, 0.00210609f, -0.01036326f, -0.02977910f, -0.03242413f, -0.03445072f, -0.03305587f, 
    -0.00819146f, -0.02231451f, 0.03084549f, -0.02291714f, 0.01632905f, -0.02292480f, 0.00889564f, -0.00988081f, 
    -0.03831241f, 0.02597838f, 0.00817770f, -0.03007957f, 0.00935517f, -0.03844730f, 0.00482435f, 0.01534538f, 
    -0.01527352f, -0.03320020f, 0.02421840f, -0.00256696f, -0.01033892f, -0.02721714f, 0.01477622f, -0.00728455f, 
    -0.01146959f, -0.00108307f, -0.03332056f, 0.01343249f, 0.02161320f, -0.02702650f, 0.00264609f, -0.01199407f, 
    0.02640452f, 0.00565629f, 0.02141559f, -0.03393646f, -0.03859666f, 0.00962049f, 0.02128079f, -0.01763284f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.16760075f, -0.06140983f, 0.01372797f, 0.10897273f, 0.00534700f, 0.05532049f, 0.00361971f, 0.09365115f, 
    0.00577992f, -0.05757331f, 0.01813529f, 0.09278718f, -0.00245237f, 0.02129093f, 0.14591575f, -0.02487103f, 
    0.11783318f, 0.07724470f, 0.01932318f, 0.00718121f, -0.02732875f, -0.02326115f, -0.01658155f, 0.04559966f, 
    0.01982123f, 0.04270374f, -0.02742502f, 0.06192555f, -0.00625380f, -0.03381864f, -0.02468845f, -0.03028545f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.15983528f, -0.13232526f, -0.09601820f, 0.25420156f, 0.07880688f, -0.34977806f, 0.19497678f, -0.06558948f, 
    0.04801363f, 0.30961916f, -0.02682087f, 0.07568596f, 0.14371786f, 0.26119730f, -0.35502028f, 0.03970772f, 
    0.00326961f, -0.55062586f, -0.06507041f, -0.10287941f, 0.26359889f, 0.07567181f, 0.16565245f, 0.21460097f, 
    -0.17091428f, -0.61787361f, -0.22020547f, -0.19664454f, 0.13192040f, 0.19166459f, 0.12682097f, 0.06967100f, 
    0.10394848f, -0.45944235f, -0.04325174f, 0.31947267f, -0.16943222f, -0.06358591f, -0.05931538f, 0.13087660f, 
    -0.08971050f, -0.17480485f, 0.05565352f, 0.18728071f, 0.03167511f, 0.09330140f, 0.07145575f, 0.14680491f, 
    0.07659487f, -0.26041305f, 0.12393284f, 0.35983518f, -0.73670536f, 0.08863826f, 0.14594170f, 0.16843443f, 
    -0.16807641f, 0.17884600f, -0.33719364f, 0.33757630f, 0.04308701f, 0.25841507f, -0.02905524f, -0.08787541f, 
    0.23948808f, -0.34307420f, 0.14425422f, 0.11856971f, -0.02198359f, 0.32745376f, -0.50369823f, 0.19920561f, 
    -0.13162078f, -0.26507840f, 0.11054938f, 0.31593603f, -0.00868778f, -0.30449685f, -0.16395772f, -0.12900428f, 
    0.15248130f, -0.02418405f, -0.17277300f, -0.25431159f, 0.41198200f, -0.16625841f, 0.13165937f, 0.20712224f, 
    0.06011434f, -0.14978254f, -0.15979300f, -0.04815325f, -0.08294483f, -0.53429848f, -0.16453280f, -0.06532787f, 
    -0.36763805f, 0.33702824f, -0.07690094f, -0.41286597f, -0.02171468f, 0.19955827f, 0.12872162f, -0.00902079f, 
    -0.07238512f, -0.16275279f, 0.04902337f, 0.28751197f, -0.08982708f, -0.25287446f, -0.27798009f, 0.10787787f, 
    -0.63293916f, -0.00437772f, -0.00723768f, 0.22144464f, 0.17543964f, 0.08965374f, 0.13497569f, 0.35619622f, 
    0.13902950f, -0.25441569f, 0.01882903f, -0.09283586f, -0.17833216f, -0.04429505f, 0.07174752f, -0.13664192f, 
    -0.31798896f, 0.21591724f, 0.12556590f, -0.05879172f, 0.10487687f, 0.04444354f, -0.39913714f, 0.17950796f, 
    -0.14627293f, 0.19457334f, -0.02576477f, -0.18197843f, -0.03659384f, 0.22002955f, -0.31154200f, -0.11278865f, 
    -0.20932439f, -0.13816860f, 0.08465698f, -0.24242853f, 0.20737618f, 0.09401838f, -0.10736966f, -0.31122836f, 
    -0.05445242f, 0.20219025f, 0.25879908f, 0.20692408f, 0.03955321f, 0.15065356f, -0.04709047f, -0.17802083f, 
    -0.20838052f, 0.00322729f, 0.16297875f, 0.13130225f, 0.07694293f, 0.17353150f, 0.40165395f, 0.11297601f, 
    0.06945490f, 0.24044569f, 0.07264231f, 0.16346368f, 0.03994079f, 0.28366458f, 0.16840759f, -0.06298377f, 
    -0.14342733f, 0.31464753f, -0.10428913f, -0.40809694f, -0.23744759f, -0.03673745f, -0.03007208f, -0.30572733f, 
    -0.12710665f, -0.06199256f, -0.10403119f, -0.25733095f, 0.11854504f, -0.33774453f, -0.03620492f, 0.16319171f, 
    0.24910034f, 0.18417072f, -0.11912480f, -0.09519149f, -0.08752387f, -0.33637917f, -0.10808046f, -0.03327068f, 
    0.01137240f, -0.30615854f, -0.10424250f, -0.58217376f, -0.08803460f, -0.18388674f, 0.33672047f, 0.02843729f, 
    0.08167478f, 0.26404616f, -0.16615230f, -0.80914253f, 0.18446329f, -0.06782462f, -0.09023000f, 0.25635666f, 
    -0.17128523f, -0.14849542f, 0.14379355f, -0.16494687f, -0.13444455f, 0.09789377f, -0.00752720f, 0.11170983f, 
    -0.20134275f, -0.43293330f, 0.09556912f, -0.27367604f, -0.06771758f, -0.14991543f, 0.25715223f, 0.20082806f, 
    -0.01863289f, 0.00402460f, -0.13822570f, -0.41383943f, -0.13943824f, -0.01660452f, -0.26720732f, 0.03841601f, 
    0.24748792f, 0.07578824f, -0.08627004f, 0.05342788f, 0.19362220f, 0.10731003f, 0.06444163f, -0.15486805f, 
    -0.00277087f, 0.36248946f, -0.11552351f, -0.55345768f, 0.13272804f, 0.31126624f, -0.10734640f, -0.12582698f, 
    -0.00829214f, -0.67676455f, 0.06011014f, -0.42625809f, -0.14464237f, 0.27714354f, 0.45770046f, 0.06184610f, 
    -0.05640352f, -0.21521126f, -0.04112360f, 0.01769574f, -0.11007858f, -0.18306780f, 0.23866728f, -0.05334032f, 
    0.00379051f, -0.10431523f, 0.00264540f, 0.33106893f, -0.21436098f, 0.14541738f, 0.06163612f, 0.25556719f, 
    -0.16782719f, -0.17060496f, 0.19326894f, -0.65845233f, -0.03400129f, -0.64656538f, 0.15164413f, -0.15830721f, 
    -0.10268877f, -0.29906461f, -0.01260543f, -0.14084715f, -0.00316508f, -0.55260551f, -0.11150981f, 0.14528969f, 
    0.11953593f, -0.00170716f, -0.03951157f, 0.08283152f, 0.17801498f, -0.22428501f, -0.35838339f, -0.09444710f, 
    0.34099951f, 0.29892492f, 0.13158914f, -0.21074148f, 0.20100628f, -0.11545783f, 0.01501645f, -0.75611168f, 
    -0.05868486f, -0.36319694f, 0.30309016f, 0.45000792f, -0.14004238f, -0.03758505f, 0.02851326f, -0.12874509f, 
    0.07337487f, 0.05413176f, 0.13034827f, -0.57566589f, -0.13012841f, 0.13216409f, -0.15379925f, -0.61618721f, 
    0.08050872f, 0.15741821f, 0.11690015f, 0.37403965f, -0.01760549f, -0.40532878f, 0.29689920f, 0.03516582f, 
    0.24299362f, -0.39804712f, 0.05145274f, -0.00436927f, -0.38877261f, 0.02558490f, 0.12717305f, 0.09564028f, 
    0.09600997f, 0.34789982f, 0.18929669f, 0.21760890f, 0.02555867f, -0.12924643f, -0.16159132f, 0.08988622f, 
    0.21198057f, 0.48892665f, 0.12966387f, 0.08291109f, -0.02107456f, 0.24126340f, -0.14280353f, -0.13696729f, 
    -0.06721634f, -0.44836801f, 0.00263299f, -0.61361402f, -0.14815190f, -0.14103334f, -0.13439688f, 0.16223463f, 
    -0.21119015f, 0.06946193f, 0.08584948f, 0.45557731f, -0.23493551f, -0.17680001f, -0.02696656f, 0.21118413f, 
    0.14104366f, -0.09698971f, 0.21938603f, 0.04775878f, 0.15620223f, -0.34310880f, -0.15707336f, -0.07351908f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02261630f, -0.13891466f, 0.00596045f, 0.05118720f, -0.15864214f, 0.01636702f, 0.11792690f, -0.05862549f, 
    -0.05335631f, -0.04922560f, -0.08303969f, -0.20632264f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
