#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.96395504f, 0.45943519f, -0.14648388f, 0.56951630f, 0.46012294f, -0.22832339f, -0.24578276f, 0.01826147f, 
    0.00404807f, -0.22152837f, -0.13685969f, -0.09248292f, 0.12369548f, -0.10931444f, 0.08900358f, 0.27022254f, 
    -0.08603425f, -0.12459695f, -0.10659280f, 0.05179274f, 0.22202876f, -0.04186658f, 0.32531783f, -0.00438753f, 
    0.08221570f, -0.42010665f, -0.41742998f, -0.16123995f, -0.41801003f, -0.42162621f, 0.18464366f, -0.49713349f, 
    0.21899559f, 0.28148672f, -0.37047487f, -0.28491113f, -0.09667609f, 0.33953553f, 0.07446666f, -0.35197172f, 
    0.14175817f, 0.22096881f, -0.06505376f, -0.05704949f, 0.12725739f, -0.33200020f, 0.21954985f, 0.25686061f, 
    -0.21787825f, -0.13035350f, 0.08731201f, 0.26011264f, -0.52618808f, -0.50869870f, 0.06502496f, 0.56603289f, 
    -0.05902079f, -0.57076031f, -0.12152887f, -0.39411131f, -0.05064609f, -0.29711872f, -0.21527439f, 0.00542731f, 
    -0.11591185f, -0.03198510f, 0.23521821f, -0.27930948f, -0.15624397f, -0.08604749f, -0.01321951f, -0.04657285f, 
    0.27789757f, -0.00749200f, -0.14970052f, 0.81844616f, 0.03561795f, 0.60244417f, 0.57902128f, 0.54160303f, 
    0.39978978f, 0.11637913f, -0.19658996f, 0.09114398f, -0.21021971f, -0.30366915f, -0.10387243f, -0.17012666f, 
    0.15143457f, -0.03474564f, -0.04850829f, 0.24120772f, 0.17703833f, 0.07807253f, -0.02346523f, -0.08373632f, 
    0.08681165f, -0.25357044f, -0.17142466f, -0.12348861f, 0.19629334f, -0.87781274f, 0.12736629f, 0.64374787f, 
    0.40868545f, -0.52856243f, 0.22187120f, 0.47600874f, -0.44834578f, 0.12592512f, 0.24451317f, 0.17265323f, 
    -0.08287907f, -0.00451906f, -0.03556158f, -0.02697114f, 0.12001537f, 0.23112534f, -0.02629266f, -0.10154395f, 
    0.02900991f, 0.17389977f, 0.18561310f, 0.05469369f, -0.05436758f, -0.20751016f, -0.07711510f, -0.19700292f, 
    -0.53112483f, -0.27536461f, 0.09503222f, -0.79784369f, -0.36393830f, -0.41586563f, -0.09440919f, -0.14730035f, 
    -0.08456297f, 0.40585160f, 0.25579008f, 0.25481239f, -0.11433074f, 0.00630403f, -0.06092271f, 0.06833888f, 
    0.00236904f, 0.13307722f, 0.27700678f, 0.03713151f, -0.07561466f, 0.04243269f, 0.55312955f, -0.20743553f, 
    -0.61199081f, -0.59999108f, -0.09616331f, 0.52051872f, -0.31785959f, 0.37553602f, 0.43204901f, 0.19912007f, 
    -0.53220356f, -0.11819491f, -0.09676393f, 0.03707507f, -0.19329971f, -0.06755008f, -0.12816498f, -0.20229535f, 
    -0.06998695f, -0.01697566f, 0.02059662f, -0.00648968f, -0.11617654f, -0.12638704f, -0.05948559f, -0.74531227f, 
    -0.78585184f, 0.01275368f, 0.49008688f, -0.05677591f, 0.61618108f, 0.55129015f, 0.06649657f, 0.31012070f, 
    0.13743754f, -0.29704490f, 0.06258250f, 0.05085175f, 0.37841380f, 0.18639156f, -0.13060494f, 0.02858250f, 
    -0.13589981f, -0.07562401f, 0.04249723f, 0.01473069f, -0.01106467f, -0.04732493f, -0.13937542f, -0.08227378f, 
    -0.24969326f, 0.12302192f, 0.15386711f, 0.43054610f, 0.53533441f, -0.52773523f, -0.48239464f, -0.77047002f, 
    -0.44866198f, 0.07454257f, -0.15701941f, 0.32325092f, 0.48885921f, 0.04862696f, -0.09056783f, -0.00044752f, 
    0.06423074f, 0.16037562f, 0.03936034f, 0.08973052f, 0.01493010f, -0.05715287f, 0.09007994f, 0.08077472f, 
    -0.12202828f, -0.09738760f, -0.48014957f, -0.42328623f, -0.15500335f, -0.39335197f, -0.11199805f, 0.34623820f, 
    0.61758554f, -0.05616175f, -0.19235963f, 0.25589153f, 0.05305342f, -0.34039158f, 0.00587297f, 0.19153757f, 
    -0.16275497f, 0.15679258f, -0.22891884f, 0.11046177f, 0.14071020f, 0.14628205f, 0.05096639f, 0.14683624f, 
    -0.02092714f, -0.01113549f, 1.04942656f, 0.44022760f, 0.15991871f, -0.56852639f, -0.34729072f, -0.47352588f, 
    -0.29316822f, -0.08989888f, 0.04239318f, 0.09437899f, -0.03000383f, 0.18698078f, -0.04629721f, -0.02521122f, 
    -0.15445748f, -0.10809275f, 0.00201352f, -0.04069771f, 0.01795486f, 0.20660929f, -0.03788325f, 0.09474365f, 
    -0.08926555f, 0.11395323f, -0.05927139f, 0.58022779f, 0.26777378f, 0.01364621f, 0.84225434f, 0.38479012f, 
    0.44343528f, 0.25074065f, -0.19106048f, -0.18128240f, 0.07450521f, 0.08209526f, 0.13850622f, -0.02844039f, 
    0.13769564f, -0.18877804f, -0.10663419f, -0.26465458f, -0.05861400f, 0.13983864f, -0.16444238f, 0.16064039f, 
    0.09399650f, 0.14592433f, 0.14453509f, 0.14418872f, -0.03888027f, -0.15474802f, -0.13856664f, 0.27465472f, 
    -0.16811387f, -0.27409714f, -0.14449388f, 0.17208624f, -0.35818890f, 0.23365173f, -0.08479772f, -0.24540152f, 
    0.15176369f, -0.11498751f, 0.42637542f, 0.26300398f, 0.10800927f, 0.12275002f, 0.25535953f, 0.53719294f, 
    0.45328602f, 0.10538860f, -0.21107368f, -0.04625452f, -0.19416535f, -0.41282025f, -0.74492157f, -0.75823885f, 
    -0.53807676f, 0.24082084f, -0.13993245f, -0.02018217f, -0.07199414f, -0.14776637f, 0.37888119f, -0.02346308f, 
    -0.10472196f, 0.14461726f, -0.06938913f, 0.19661674f, 0.20188791f, -0.06834784f, 0.17812331f, -0.02669702f, 
    -0.11009123f, -0.12407677f, -0.23601101f, -0.09562679f, 0.20073646f, 0.05968488f, -0.46586561f, -0.45332909f, 
    -0.35343120f, -0.20392662f, -0.18625629f, -0.35934520f, -0.17369297f, 0.33316755f, -0.20697893f, -0.24537434f, 
    0.03753160f, 0.14759059f, -0.03176177f, 0.02969754f, -0.03393029f, -0.12297655f, -0.23714392f, -0.19467163f, 
    -0.48874119f, -0.00866755f, -0.01852398f, -0.10720815f, 0.08152668f, 0.47230399f, -0.14179000f, 0.53730184f, 
    0.40879568f, -0.57982343f, -0.60456818f, -0.40944788f, 0.37773141f, 0.37028307f, -0.24691497f, -0.18957634f, 
    -0.01165250f, 0.22237113f, 0.32325593f, 0.25646272f, 0.24347816f, 0.17691952f, 0.01663863f, 0.18407731f, 
    0.23544636f, 0.14253338f, 0.14836867f, 0.18986617f, 0.12194584f, 0.26829043f, 0.01170386f, 0.25498253f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06010431f, -0.02503976f, 0.06463401f, 0.15502760f, -0.03064254f, 0.22262460f, -0.16306625f, -0.08500915f, 
    0.07132182f, 0.25237003f, 0.16865313f, 0.23037541f, 0.03024848f, 0.26425177f, 0.22464496f, 0.18872590f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01213139f, 0.16482456f, -0.12314647f, -0.10928429f, 0.10922129f, 0.05245848f, 0.11983478f, 0.02468170f, 
    0.03485540f, 0.09071581f, 0.00579693f, -0.00001514f, -0.00425177f, -0.06673253f, -0.07597388f, 0.01057025f, 
    -0.03367464f, 0.09438869f, -0.10134812f, -0.02631100f, 0.11928467f, 0.02853548f, 0.06583745f, 0.01475050f, 
    -0.12072012f, -0.28326082f, 0.01317541f, 0.07590710f, 0.09787498f, 0.05522023f, -0.07483191f, 0.01984936f, 
    -0.00874557f, 0.02836725f, 0.15627141f, 0.08928236f, 0.00586407f, 0.12648180f, -0.04838692f, -0.14707729f, 
    0.16593264f, 0.12654048f, 0.01604630f, 0.01928046f, 0.08788078f, -0.10662500f, -0.15854539f, 0.11143404f, 
    0.04437782f, 0.01143579f, -0.04613981f, 0.03296471f, 0.10401767f, 0.10060218f, -0.05682379f, -0.01556500f, 
    -0.08401409f, -0.07618742f, -0.15633492f, -0.00872024f, -0.02538484f, -0.05874573f, -0.18408892f, -0.18730728f, 
    0.01672857f, 0.11640918f, 0.03877761f, -0.03530938f, 0.16264394f, 0.01932148f, -0.01204624f, 0.08739325f, 
    -0.36782369f, 0.08245324f, 0.05322807f, 0.14036481f, -0.03460227f, -0.13616107f, 0.06332863f, 0.05419687f, 
    0.00002401f, -0.03681284f, -0.04030724f, 0.20019402f, 0.13882607f, -0.07013781f, -0.08001236f, -0.19230683f, 
    0.08206663f, -0.00942727f, -0.01925163f, 0.03179331f, -0.00549188f, -0.06530872f, 0.01240265f, 0.17054971f, 
    -0.10820559f, 0.11921868f, 0.07017287f, 0.03560730f, 0.06841854f, 0.10801412f, -0.06277735f, 0.01810175f, 
    0.04360422f, 0.05518510f, -0.04150520f, 0.02747744f, -0.09262219f, 0.12846112f, 0.07222489f, 0.04861342f, 
    0.09923418f, -0.02432862f, 0.13006014f, 0.01264441f, 0.07614773f, -0.05318221f, 0.13700190f, -0.07455687f, 
    0.00481888f, 0.24832818f, 0.10216577f, 0.19187006f, -0.00732383f, 0.14388563f, 0.15882075f, 0.01090584f, 
    0.02785183f, 0.07791729f, 0.06802587f, 0.11746990f, 0.06731877f, 0.13311420f, -0.14250526f, -0.19231997f, 
    0.20049739f, -0.02992536f, 0.14937073f, 0.04149579f, -0.04663962f, 0.07727966f, -0.00358971f, 0.07427470f, 
    0.07512386f, 0.08862112f, 0.13328183f, 0.10338952f, -0.11616685f, 0.05306229f, 0.20594062f, -0.04684532f, 
    0.01285196f, -0.18694603f, -0.18477513f, -0.05926616f, 0.13232374f, -0.18072696f, -0.03732625f, 0.08784263f, 
    -0.03059363f, -0.16841951f, 0.04791519f, 0.04035657f, 0.01140091f, 0.09815056f, -0.02596038f, 0.01335078f, 
    -0.09146664f, 0.02486878f, -0.03773325f, 0.03392075f, -0.08401870f, 0.15435001f, -0.17692830f, 0.04347731f, 
    0.02745377f, 0.03894123f, 0.02334497f, -0.07044242f, 0.01740013f, -0.13571204f, 0.15215001f, 0.09080767f, 
    0.16690607f, 0.03456173f, 0.06246856f, 0.06734668f, 0.00079399f, 0.03746535f, -0.13489988f, -0.08780869f, 
    -0.01673718f, 0.10155469f, -0.09218013f, -0.14041242f, 0.08941919f, 0.06177350f, -0.11984166f, -0.08388024f, 
    -0.01517906f, 0.09905767f, 0.15343009f, -0.06799729f, 0.33294502f, 0.13466199f, -0.11139759f, 0.14500034f, 
    0.08569127f, 0.09498374f, 0.08237609f, 0.11392185f, 0.09960201f, 0.02078070f, -0.00137003f, 0.04386356f, 
    0.07600873f, 0.10730376f, 0.04953911f, 0.17016418f, -0.06469814f, 0.01941621f, -0.08196560f, 0.11505035f, 
    0.01880107f, -0.05769961f, 0.15629087f, 0.09494834f, -0.14160727f, 0.08240182f, 0.05345904f, 0.01264018f, 
    0.04020279f, 0.04877839f, -0.01261849f, -0.06507587f, -0.08156913f, 0.03952157f, 0.02040696f, 0.11289124f, 
    0.43740737f, -0.01623227f, -0.01107622f, -0.00721341f, 0.10147803f, -0.06266594f, -0.04473577f, -0.12105341f, 
    -0.02224383f, 0.09980828f, -0.13255295f, 0.00352715f, 0.10015492f, 0.00275148f, -0.01385464f, -0.10681356f, 
    0.02906005f, 0.02214536f, -0.07907911f, -0.04413732f, 0.11137131f, 0.02471871f, 0.04878295f, 0.07802486f, 
    0.08809765f, 0.24507245f, -0.03665935f, 0.16509834f, 0.00948827f, 0.16127153f, 0.23130366f, 0.09289409f, 
    -0.05877148f, -0.05040006f, 0.02047389f, 0.15646873f, 0.15677327f, -0.21245874f, 0.21794872f, -0.11442854f, 
    0.00066337f, -0.06157961f, -0.03152839f, 0.09639852f, 0.06058976f, -0.05870760f, -0.05273376f, 0.03746292f, 
    -0.11465526f, 0.04480037f, 0.04618905f, 0.15649773f, 0.01161246f, 0.10469171f, -0.08933331f, 0.08671976f, 
    0.00285796f, 0.05672411f, -0.14169613f, -0.09440990f, 0.09625495f, 0.07594897f, 0.26965788f, -0.10142945f, 
    -0.04617618f, 0.04931842f, 0.22944364f, 0.00238186f, -0.02689529f, -0.05618859f, 0.11508083f, 0.14962611f, 
    -0.13574529f, 0.05841551f, -0.05970470f, 0.10904909f, 0.02864861f, 0.24999931f, -0.11333535f, -0.02536849f, 
    0.05706587f, 0.01058023f, -0.06999478f, 0.06599974f, -0.06023622f, 0.08026285f, -0.21618654f, -0.17436591f, 
    0.03810438f, -0.03983335f, 0.01740292f, 0.00132251f, -0.10682520f, -0.08669448f, 0.02784412f, -0.00295824f, 
    0.24882601f, 0.05984967f, 0.13902240f, 0.01832059f, -0.02958244f, 0.12472312f, 0.26840630f, -0.04345042f, 
    0.08032484f, -0.15232241f, -0.07746432f, -0.02616819f, -0.15646639f, -0.03416918f, 0.08597653f, 0.12874240f, 
    -0.00736532f, -0.20052350f, -0.02733570f, 0.00855980f, 0.10368685f, 0.10679852f, -0.09712677f, -0.08499859f, 
    0.00171793f, 0.27177647f, 0.08974399f, 0.03316071f, -0.04253450f, 0.06756468f, -0.08635566f, -0.11169164f, 
    0.01871306f, 0.03887750f, 0.11285251f, 0.07717524f, -0.16393179f, 0.20068710f, -0.04914567f, 0.04274828f, 
    -0.06162788f, 0.10501502f, -0.06087331f, -0.03195359f, 0.09908506f, -0.00524106f, -0.20838968f, -0.03982784f, 
    0.05606663f, 0.01854759f, -0.03558629f, -0.06887047f, 0.05038164f, 0.04579614f, -0.00136709f, 0.00206248f, 
    -0.05531679f, 0.05116016f, -0.07132836f, 0.03794737f, 0.06442055f, -0.07594921f, 0.02151257f, 0.02159859f, 
    -0.05598869f, -0.04491452f, -0.02813219f, -0.03638284f, -0.03521832f, -0.00496711f, -0.00292801f, -0.06242165f, 
    -0.00379832f, 0.00217743f, -0.06268171f, -0.05631846f, 0.05737811f, -0.06185706f, -0.06793235f, -0.00692230f, 
    -0.01066603f, 0.06306329f, 0.03927055f, 0.03070191f, 0.01471563f, 0.01454453f, 0.02048641f, -0.04994401f, 
    -0.05281712f, -0.03862138f, -0.03681904f, 0.00860732f, 0.02910110f, -0.07359969f, 0.00546118f, 0.02499364f, 
    -0.05343524f, 0.02000293f, 0.06514317f, -0.00430279f, 0.04557839f, 0.02172469f, -0.02557986f, -0.04729594f, 
    -0.01233776f, -0.03630173f, -0.01196643f, -0.02934634f, -0.06642124f, -0.00551297f, -0.03716312f, 0.03237333f, 
    0.04109215f, -0.05097424f, 0.04941657f, -0.05481831f, -0.07228016f, 0.00387018f, -0.07549985f, -0.07336246f, 
    0.03013014f, 0.03484038f, 0.03320777f, 0.03132121f, -0.02762154f, 0.01857846f, -0.00605964f, 0.03818468f, 
    -0.06200337f, -0.01473620f, -0.02844163f, -0.06649485f, 0.06125613f, 0.06284548f, 0.00513657f, -0.07195595f, 
    -0.06968428f, -0.01084700f, 0.00662670f, 0.04416934f, -0.07597508f, -0.05368437f, -0.05101322f, -0.04896447f, 
    -0.03289730f, 0.04868043f, -0.04580334f, -0.02570640f, -0.02060978f, -0.04685454f, 0.01214139f, -0.03284551f, 
    -0.06481979f, -0.03531979f, 0.04563297f, 0.02844313f, 0.01454440f, -0.03302943f, -0.00401769f, 0.01621623f, 
    0.06125890f, 0.03918758f, 0.00989501f, -0.00734696f, -0.05583936f, -0.06946176f, 0.02199635f, -0.00047308f, 
    -0.05447583f, -0.04066309f, 0.02746498f, -0.03902132f, 0.05122472f, -0.00022004f, 0.03209828f, -0.05545056f, 
    0.04350167f, -0.04554116f, -0.03506530f, -0.01345434f, 0.02914029f, 0.04780302f, -0.02949559f, 0.00263180f, 
    0.06476395f, -0.02691716f, -0.04469806f, 0.05969504f, -0.06410217f, -0.01524199f, -0.00554555f, 0.04692687f, 
    -0.05674579f, -0.07401587f, 0.03539993f, 0.04468167f, -0.02077183f, -0.02428271f, -0.07744171f, 0.05087576f, 
    0.00730054f, -0.04885267f, -0.04712462f, -0.03837748f, -0.03606604f, -0.07740514f, 0.02488488f, -0.02071002f, 
    -0.06369364f, 0.05410427f, -0.04873402f, -0.03431729f, -0.04452833f, 0.02519385f, -0.01792489f, 0.03283976f, 
    0.05954059f, -0.04782194f, -0.05897694f, -0.06315043f, -0.07046789f, 0.01661293f, 0.01758022f, 0.00100515f, 
    0.00774615f, 0.00250673f, -0.05089282f, 0.06039260f, 0.06556518f, 0.00438309f, 0.01978416f, -0.03743581f, 
    0.05938631f, -0.03544797f, -0.03747771f, -0.06755939f, -0.06041282f, -0.01311247f, -0.00285888f, 0.00541678f, 
    0.06350718f, 0.07027192f, 0.10029735f, 0.03465282f, -0.18969949f, 0.04236665f, 0.14631873f, -0.10793875f, 
    -0.05576342f, -0.02197521f, -0.11162498f, 0.07148785f, -0.27268332f, -0.15277551f, -0.09287073f, 0.03739234f, 
    0.00898776f, 0.10559308f, 0.05491045f, -0.04860359f, -0.03356893f, 0.00519233f, -0.06303918f, -0.00090905f, 
    -0.12922029f, -0.12525553f, 0.37610036f, -0.07014246f, 0.06172172f, 0.14168772f, -0.00106989f, 0.13311695f, 
    0.15057391f, -0.00888801f, -0.06457674f, -0.03859662f, 0.27878830f, 0.15646841f, 0.16303712f, 0.06577088f, 
    0.05795597f, 0.04720625f, 0.02509065f, -0.11839958f, -0.01053949f, -0.02504849f, -0.04703918f, 0.02240883f, 
    0.34738070f, 0.13118291f, -0.00279964f, 0.13830352f, -0.07677758f, 0.08681201f, 0.02351921f, 0.06777735f, 
    0.11181660f, -0.03884124f, 0.04838000f, 0.10429903f, -0.23510709f, -0.00092852f, 0.14345315f, 0.09025582f, 
    0.06035329f, -0.05645047f, 0.04726071f, -0.12090325f, -0.00356922f, -0.04920286f, 0.05127830f, -0.04848090f, 
    0.14086398f, -0.07026664f, -0.12898944f, -0.25311959f, 0.04665973f, -0.07112490f, 0.11222090f, 0.08012508f, 
    0.27047157f, 0.08418448f, 0.05279729f, 0.03744206f, -0.04096939f, 0.03974606f, -0.37967610f, -0.20805863f, 
    0.03750111f, 0.03272948f, -0.02238875f, 0.09246470f, 0.01017090f, 0.16630523f, -0.00448524f, -0.15165940f, 
    0.25614175f, -0.04523121f, 0.11819530f, 0.01704845f, 0.01779831f, -0.01746160f, -0.01847456f, -0.17388673f, 
    0.05218593f, 0.08120181f, 0.13410556f, 0.14986543f, 0.01823017f, -0.05315460f, -0.19055377f, -0.02219101f, 
    0.11482562f, 0.02774349f, -0.03524442f, 0.05811021f, -0.01627325f, 0.04472625f, 0.03108449f, -0.10566656f, 
    -0.16124146f, 0.07318584f, 0.15226774f, 0.15509193f, -0.03911860f, -0.11494061f, 0.06630947f, 0.13315260f, 
    -0.14749537f, 0.03346111f, 0.08418870f, 0.04551093f, 0.04214779f, 0.02269633f, 0.24827941f, -0.02393819f, 
    -0.07910753f, 0.10184250f, 0.03849976f, 0.02937878f, -0.02478288f, 0.05921659f, -0.02333318f, -0.06403434f, 
    -0.02528116f, -0.12066851f, -0.11758617f, 0.09702182f, 0.11374839f, 0.08139833f, -0.10523465f, -0.05387661f, 
    -0.09010549f, 0.03701784f, 0.14141570f, -0.03582479f, -0.18327363f, -0.28035608f, -0.11420655f, -0.15218931f, 
    -0.00840826f, 0.10863400f, -0.12108775f, -0.08261221f, 0.04733561f, 0.06226110f, 0.07251206f, 0.12137017f, 
    -0.16701539f, -0.29302150f, -0.17792505f, 0.14880796f, -0.03146280f, -0.05879388f, 0.00910232f, -0.01747989f, 
    0.09158370f, 0.09722734f, 0.02761724f, 0.08543666f, -0.23160981f, -0.13767137f, 0.13908148f, -0.09799616f, 
    0.01412456f, -0.02830335f, 0.07014407f, 0.05530061f, 0.15738361f, -0.00856460f, -0.02716769f, 0.02755116f, 
    0.32540143f, -0.02277515f, -0.07570477f, 0.17675988f, 0.26203746f, -0.01691866f, -0.03508111f, -0.07177562f, 
    0.09486300f, -0.00852809f, -0.08053908f, -0.11884981f, -0.01368329f, -0.11173006f, -0.04492737f, 0.23189011f, 
    -0.10543494f, 0.14915447f, -0.12452508f, 0.04367010f, 0.06278627f, -0.10011189f, 0.00087995f, 0.03942510f, 
    0.17734599f, 0.14282617f, -0.05956279f, 0.10845169f, 0.04290012f, 0.01262459f, -0.04899916f, -0.00322394f, 
    0.02378088f, -0.03159889f, 0.07324103f, 0.10548460f, -0.07168013f, -0.07665118f, 0.01551277f, 0.20418486f, 
    -0.04505562f, 0.15764785f, -0.02692155f, -0.02661257f, 0.02869667f, -0.07323480f, 0.02454901f, 0.02204008f, 
    -0.33142781f, -0.08365766f, 0.17703319f, -0.04957188f, 0.12943636f, 0.08653388f, -0.03227482f, -0.02073817f, 
    -0.07969651f, -0.08347439f, -0.12432555f, 0.00313673f, 0.18952098f, -0.00410569f, 0.03199757f, -0.03399349f, 
    -0.02246168f, 0.05185198f, -0.18100941f, -0.06151916f, 0.29060224f, 0.06873135f, -0.00636130f, 0.15029898f, 
    -0.24868283f, 0.05717407f, 0.10231555f, 0.25750160f, -0.00819599f, 0.07297292f, -0.04005802f, 0.13118246f, 
    0.05446524f, 0.08549960f, 0.02349456f, 0.06640551f, 0.23114994f, -0.05377483f, 0.08824014f, -0.18675390f, 
    -0.08898304f, -0.07752892f, 0.02522880f, 0.05827396f, 0.05584564f, -0.15160334f, 0.14720336f, 0.06556366f, 
    -0.32326493f, -0.08926720f, 0.16196890f, 0.32384419f, -0.00011349f, 0.04593650f, 0.03269608f, 0.03159181f, 
    -0.09140306f, 0.01018767f, -0.15047562f, -0.08926195f, 0.11450838f, -0.04346849f, 0.11726406f, 0.02710400f, 
    -0.14098404f, -0.00709639f, -0.02950578f, 0.04758279f, -0.09208857f, -0.00975416f, 0.00459993f, 0.05814539f, 
    0.08413946f, 0.16502157f, -0.04848184f, -0.10618977f, -0.04289621f, 0.20223300f, 0.17675996f, 0.10510678f, 
    0.06878569f, 0.19472161f, -0.01808478f, 0.11507790f, -0.01653647f, -0.05396757f, -0.00863111f, -0.02992753f, 
    0.19461580f, -0.05790902f, -0.01871547f, -0.08267573f, -0.05232995f, -0.02893783f, 0.07221483f, 0.05371712f, 
    0.31031817f, -0.10517082f, 0.06773204f, 0.02929918f, -0.16065541f, 0.04375897f, 0.17712283f, -0.18782234f, 
    0.02445175f, 0.04148317f, -0.09557823f, -0.00895821f, 0.03267633f, -0.05201242f, -0.00958236f, 0.36208710f, 
    -0.11873696f, -0.13895087f, 0.05530069f, 0.13209128f, -0.02026463f, 0.07654747f, 0.14137158f, -0.10922567f, 
    0.22103783f, 0.06879967f, 0.15325204f, -0.03433197f, 0.01932753f, -0.13345595f, -0.02787150f, 0.06968519f, 
    -0.01696680f, -0.10113042f, 0.00834640f, 0.07435140f, 0.21967772f, 0.10005630f, 0.08619384f, 0.01186666f, 
    0.02062829f, -0.04016782f, -0.05832921f, 0.02986097f, -0.15251622f, -0.04408538f, 0.01110450f, -0.04479194f, 
    0.02493473f, 0.02844767f, -0.04232255f, 0.14662631f, 0.02251419f, 0.08948951f, -0.01404074f, 0.06664402f, 
    0.05390339f, 0.08181335f, -0.01258007f, -0.07533356f, 0.06790641f, 0.06162864f, 0.00207092f, -0.08754940f, 
    0.04499478f, -0.01787779f, -0.10165212f, 0.01786638f, -0.07694288f, 0.00432838f, 0.09929397f, -0.08596724f, 
    -0.34925109f, -0.12081297f, -0.03162532f, -0.03372911f, 0.05727499f, 0.09986169f, -0.03460455f, -0.10194555f, 
    -0.05740822f, -0.13829602f, 0.05317459f, 0.09276199f, 0.03517237f, 0.05261359f, -0.06364851f, 0.08632604f, 
    0.00208928f, -0.00340330f, 0.03773424f, -0.00618273f, 0.03668139f, 0.06519510f, -0.06925017f, 0.00191903f, 
    -0.30812308f, 0.03847471f, -0.15513366f, 0.07896393f, -0.01355465f, -0.14411826f, -0.02201309f, -0.07007574f, 
    0.02926501f, -0.06149444f, 0.07338142f, 0.11576080f, -0.15462495f, 0.03668778f, -0.01606904f, -0.21058272f, 
    -0.01690068f, 0.17951731f, 0.18679465f, 0.00865139f, 0.15201271f, -0.01211808f, -0.08109863f, 0.03389034f, 
    0.37455770f, 0.11315458f, 0.02196676f, 0.03781731f, 0.06043121f, 0.01351386f, -0.00410288f, 0.00539381f, 
    0.06425329f, -0.01776888f, 0.08370026f, -0.03326158f, 0.20122457f, 0.22101295f, 0.02384184f, 0.13133022f, 
    0.06034271f, 0.08589914f, 0.01781785f, 0.07269169f, 0.07557478f, 0.01625117f, 0.06946862f, 0.15824649f, 
    -0.06080122f, -0.05493787f, -0.00166840f, -0.00465300f, -0.01774988f, -0.10473696f, -0.09616747f, 0.04024133f, 
    0.08480022f, 0.04041308f, 0.00907940f, 0.03150737f, 0.02102125f, 0.00277421f, 0.00830726f, -0.02144481f, 
    -0.06126350f, 0.07365201f, -0.02752523f, 0.11685317f, 0.01520394f, -0.08587290f, -0.01907985f, 0.01971111f, 
    0.27415901f, 0.09781480f, 0.13592005f, -0.14873359f, -0.06538579f, -0.04277825f, 0.12073290f, 0.08250178f, 
    0.00298047f, 0.02355577f, 0.07662027f, 0.07258055f, -0.12155636f, 0.22386903f, -0.17103660f, 0.07544363f, 
    0.14483055f, 0.02409659f, 0.01086845f, -0.01358702f, -0.06703044f, 0.04570132f, -0.04646584f, -0.05082016f, 
    0.06679686f, 0.17820263f, -0.09944364f, 0.00480648f, -0.05066606f, 0.01930655f, 0.06554440f, -0.17882781f, 
    -0.00414639f, -0.03835949f, -0.04590202f, 0.19626498f, 0.33917847f, -0.14245231f, 0.00685712f, 0.05574947f, 
    0.02027324f, -0.13034526f, 0.02799950f, 0.08872376f, 0.00504543f, 0.09661997f, -0.03145994f, -0.10950055f, 
    0.17150588f, -0.03026790f, 0.03860669f, 0.06172638f, 0.01071846f, 0.10163070f, -0.11916529f, 0.13970295f, 
    -0.05372234f, 0.00731340f, 0.00128256f, -0.11831720f, -0.01487515f, -0.04300449f, 0.18124099f, -0.28254214f, 
    0.11939887f, 0.02209358f, 0.07557210f, 0.02767405f, 0.00701593f, -0.05322810f, 0.03005590f, 0.03690624f, 
    0.04187831f, 0.02684827f, -0.01557879f, -0.03965712f, -0.06318142f, -0.06633807f, 0.04149051f, 0.03669961f, 
    -0.03473619f, -0.07221317f, 0.01543479f, -0.02182147f, -0.07578007f, 0.04595017f, -0.00624866f, -0.05540077f, 
    0.03368876f, 0.04146412f, -0.04607743f, 0.01099222f, -0.05315980f, -0.05267067f, -0.00639074f, 0.00551747f, 
    -0.05666671f, -0.00460351f, 0.00937952f, 0.05856529f, -0.07442938f, -0.00009955f, -0.03450510f, -0.07928461f, 
    -0.06171922f, 0.01252146f, 0.01792378f, -0.00510270f, -0.07470954f, 0.05061157f, 0.02294914f, -0.07621295f, 
    0.05207358f, -0.03022313f, -0.05135498f, 0.00616012f, 0.01528716f, -0.06916220f, 0.04967992f, -0.05978705f, 
    0.02762128f, -0.06150242f, -0.07303669f, -0.00666043f, -0.01699203f, -0.05675034f, 0.03587006f, 0.04955065f, 
    -0.03029967f, -0.05651519f, -0.02182042f, -0.04970258f, -0.06975769f, -0.06233604f, -0.04224484f, -0.03695603f, 
    0.04769110f, -0.02216714f, 0.06259749f, -0.06486931f, 0.00129458f, -0.05508642f, -0.00191227f, -0.03377331f, 
    0.00466889f, 0.00031156f, 0.03922212f, -0.00209241f, -0.01399752f, -0.00238337f, 0.03164955f, 0.03927475f, 
    -0.02846447f, -0.02361380f, -0.03097683f, 0.04616619f, 0.07108492f, -0.00976187f, -0.02863976f, -0.04036205f, 
    0.02581425f, 0.07151808f, 0.02517484f, -0.00162145f, -0.02261599f, -0.05378587f, -0.01730776f, -0.02775375f, 
    -0.04649286f, 0.00974550f, 0.04008843f, 0.00595002f, 0.00093669f, -0.00624898f, 0.03986037f, 0.03688795f, 
    0.04575884f, -0.03515185f, -0.04739950f, -0.05928802f, -0.01315727f, -0.05429079f, 0.02892498f, -0.00420034f, 
    -0.02641553f, -0.04271665f, -0.00643936f, 0.04463389f, 0.03076678f, -0.01747497f, -0.03855092f, 0.06291778f, 
    -0.06357807f, -0.01913298f, 0.03538100f, 0.05859267f, -0.06809239f, 0.04032403f, -0.04772587f, -0.02311625f, 
    -0.04557707f, 0.00895422f, 0.00325372f, -0.03586946f, 0.04491539f, 0.02080760f, 0.03715084f, -0.05397771f, 
    0.06998914f, -0.02323935f, 0.01232097f, 0.02899102f, -0.00120208f, -0.02195586f, -0.00860658f, 0.02016938f, 
    -0.06917897f, 0.05504408f, 0.00196415f, -0.01822596f, -0.05901262f, -0.02640965f, 0.06166003f, -0.07239714f, 
    -0.07883593f, -0.04612578f, 0.05899530f, 0.05533344f, -0.03623910f, -0.02104893f, 0.05536475f, -0.05505124f, 
    0.00432437f, -0.02047550f, -0.01949953f, -0.02730353f, 0.04737945f, 0.00992259f, -0.00683065f, 0.00361651f, 
    -0.06728038f, 0.04137329f, -0.07366039f, -0.02777251f, 0.01129866f, 0.01787543f, 0.01561137f, -0.06835486f, 
    0.03564600f, -0.04897673f, 0.00416577f, -0.05130205f, -0.00827701f, -0.00209416f, -0.02302795f, 0.05872841f, 
    0.03537634f, 0.01774636f, -0.04112929f, -0.06630618f, 0.03959598f, -0.05651744f, -0.04029108f, 0.04080104f, 
    0.27551788f, -0.11227058f, 0.05848635f, 0.11028668f, -0.10223407f, 0.01939302f, 0.01473050f, -0.11027520f, 
    -0.01106233f, -0.11319315f, 0.04178941f, -0.01155357f, -0.14001566f, -0.12057327f, -0.04689031f, -0.01660836f, 
    0.08826056f, 0.06304854f, -0.04390931f, -0.00124525f, -0.05479801f, 0.02265688f, 0.04337120f, 0.01720538f, 
    0.18279633f, 0.24605611f, 0.18236500f, -0.16351335f, -0.08414187f, 0.07158807f, 0.08808472f, 0.12247730f, 
    0.14846618f, 0.05519081f, -0.02776783f, -0.03112362f, 0.21114869f, -0.02531716f, 0.08130137f, 0.24879046f, 
    -0.01105525f, -0.12655340f, -0.07695062f, -0.12038641f, -0.01396125f, -0.00558941f, 0.14255586f, 0.01936414f, 
    0.13164221f, -0.06385165f, 0.00388795f, 0.15536289f, 0.02521474f, -0.04274818f, -0.13806973f, -0.08372386f, 
    -0.12706587f, -0.11070620f, -0.02172890f, -0.01987905f, -0.16930190f, 0.00699368f, 0.14687353f, 0.12206337f, 
    -0.00204750f, -0.03573647f, 0.04613315f, 0.01445211f, 0.04077024f, 0.06919096f, 0.15607995f, 0.05588829f, 
    0.40365750f, -0.16226001f, -0.20285696f, -0.22973007f, 0.04964221f, 0.01062092f, 0.03092405f, -0.03063591f, 
    -0.05852763f, 0.01872116f, 0.18507333f, -0.08443911f, -0.31765503f, 0.07325554f, 0.17054339f, -0.07243380f, 
    -0.11885430f, 0.00132885f, -0.02706254f, 0.08609975f, 0.10604697f, -0.05550748f, -0.00246025f, -0.01097837f, 
    0.15160809f, 0.04323375f, 0.10860263f, 0.10086420f, 0.05832016f, -0.07245430f, 0.00257876f, 0.00204895f, 
    0.06561741f, -0.04200282f, 0.07244466f, 0.08800376f, -0.22530210f, 0.04358211f, -0.09604844f, -0.13535331f, 
    0.16255152f, -0.04684611f, 0.06631766f, 0.05040453f, 0.02543045f, 0.02191175f, 0.04390809f, 0.10913434f, 
    -0.00360107f, 0.01779203f, 0.00781301f, -0.06981042f, 0.13366209f, -0.01363895f, -0.02752201f, -0.00385367f, 
    0.02017207f, -0.03471884f, 0.04315680f, -0.04276766f, 0.12748259f, -0.02900266f, 0.13477078f, 0.21805552f, 
    -0.02688282f, -0.03603852f, -0.03623756f, 0.00987817f, -0.11466192f, -0.09868172f, 0.04102845f, -0.16479036f, 
    0.07453206f, -0.19635470f, -0.07344849f, -0.01646107f, 0.03482216f, -0.00299333f, -0.07969998f, 0.03668121f, 
    0.05344467f, -0.06460595f, 0.14885210f, 0.14002463f, -0.25905794f, 0.08635464f, 0.13630207f, -0.15082489f, 
    -0.01019541f, 0.08835667f, -0.01228086f, 0.00722235f, 0.02948490f, 0.03318781f, 0.05484771f, -0.00188606f, 
    -0.16205037f, 0.04965249f, 0.07152316f, -0.02412406f, 0.07268838f, 0.00038997f, 0.06653451f, -0.09207284f, 
    -0.00769470f, 0.03715283f, 0.07254373f, 0.12119653f, -0.20416741f, 0.05122679f, -0.14960489f, -0.18371338f, 
    -0.03439606f, -0.04393935f, 0.06200550f, -0.10500919f, 0.10953427f, 0.04865744f, 0.02239142f, 0.04838282f, 
    -0.04212717f, 0.08032525f, 0.16547197f, 0.06152879f, -0.10005370f, 0.07921463f, 0.03116534f, -0.06669094f, 
    -0.06828085f, -0.05653650f, -0.02801241f, 0.14611220f, 0.25616300f, 0.06292973f, 0.04582332f, 0.27710018f, 
    -0.03152866f, 0.13223320f, -0.04416073f, 0.04415509f, 0.04793162f, 0.03447460f, -0.06516314f, 0.06475569f, 
    -0.03037678f, 0.26209521f, -0.09056094f, 0.20818116f, 0.00194706f, 0.14128436f, -0.05642091f, 0.14494072f, 
    0.04162580f, 0.00190095f, 0.05130228f, 0.10768975f, 0.08510384f, 0.28823325f, 0.04153788f, -0.05436205f, 
    0.03993258f, -0.01585263f, 0.05493089f, -0.06055471f, -0.04465001f, 0.03241328f, 0.10414333f, 0.05366316f, 
    -0.11518291f, 0.06086930f, 0.18850291f, -0.22546625f, -0.02879771f, -0.08900845f, 0.05498090f, -0.07551252f, 
    0.05139009f, 0.03535771f, 0.02876211f, -0.06504534f, 0.05665606f, 0.03527918f, 0.16686052f, 0.16005313f, 
    0.05227585f, -0.01702993f, -0.09972904f, 0.08098249f, -0.08393881f, -0.10671718f, -0.00200943f, -0.02167896f, 
    0.14147362f, 0.15780692f, 0.04717010f, 0.09879791f, -0.05251630f, 0.02182983f, 0.08731972f, 0.10044191f, 
    0.10264276f, 0.06579054f, 0.06370512f, 0.10963556f, -0.31388187f, 0.03600411f, 0.10551886f, 0.01035061f, 
    0.10030117f, -0.07678272f, 0.06483854f, -0.01641216f, 0.00074543f, 0.00099409f, 0.04693254f, -0.01595237f, 
    -0.33772767f, -0.09277231f, 0.13903366f, -0.05254372f, 0.03578639f, -0.08413574f, -0.03967174f, -0.04253408f, 
    0.02537934f, -0.01665728f, -0.09688322f, 0.03118434f, 0.04448094f, 0.02508565f, -0.02275027f, 0.07976994f, 
    0.02463134f, 0.10007169f, -0.05802086f, 0.06128629f, 0.01300397f, 0.09400257f, 0.04798400f, 0.00826695f, 
    0.13039081f, -0.13742806f, -0.04526220f, 0.21193932f, -0.07023644f, 0.08978195f, -0.07865240f, -0.00854947f, 
    0.02777966f, 0.07069499f, -0.08548962f, 0.04868439f, -0.29332006f, 0.23121537f, -0.01235900f, -0.19349833f, 
    -0.00236016f, -0.06057229f, 0.02228383f, -0.03480857f, 0.02437234f, -0.16145402f, 0.11637233f, -0.10139327f, 
    0.01116848f, -0.07676328f, 0.11992805f, -0.19700138f, -0.05115299f, -0.02238613f, 0.07403398f, 0.02649601f, 
    0.01205468f, 0.04813173f, 0.01340473f, -0.15269873f, -0.26760414f, 0.05527654f, -0.03225537f, -0.02497832f, 
    0.06148720f, -0.06801050f, 0.03887510f, 0.01591601f, 0.05331645f, -0.06724049f, 0.04836454f, -0.06393191f, 
    0.07437345f, -0.07848029f, 0.07160715f, 0.08317048f, -0.03120606f, -0.05596635f, 0.04266386f, 0.03669800f, 
    -0.00256103f, 0.01589107f, -0.06525600f, 0.08864987f, -0.07296711f, 0.25113431f, -0.05582894f, 0.30081746f, 
    0.01980627f, 0.10610551f, -0.09767645f, 0.02863657f, 0.04217917f, 0.01103035f, -0.06269848f, -0.06114037f, 
    0.03262793f, -0.04301236f, -0.06609964f, 0.01020272f, 0.00800924f, -0.04174099f, 0.05161375f, -0.08144633f, 
    0.01155527f, -0.04435581f, 0.02085932f, 0.07108302f, -0.02078705f, 0.02910030f, -0.04556865f, 0.04550444f, 
    -0.02175430f, 0.03549058f, 0.01260637f, -0.00993415f, 0.02403386f, -0.08688612f, -0.00049976f, -0.03800914f, 
    -0.09050714f, -0.07936276f, -0.02253287f, -0.04381217f, -0.00108230f, 0.01369210f, 0.00341624f, -0.00450367f, 
    0.03377914f, 0.01138822f, -0.04662826f, -0.02423982f, 0.03867101f, -0.05243324f, -0.03928920f, -0.00838844f, 
    -0.00552984f, -0.04183779f, -0.02452792f, -0.01904123f, 0.06643166f, 0.05053801f, 0.01168576f, 0.05431532f, 
    0.06522914f, 0.05472934f, 0.03942480f, -0.00450508f, -0.05039438f, 0.00497587f, -0.08349961f, -0.09058956f, 
    0.03664418f, -0.02968914f, 0.02601623f, 0.01987566f, -0.01189175f, -0.05127057f, -0.02027064f, -0.05465239f, 
    0.02524071f, 0.05561720f, -0.09416278f, 0.02439183f, 0.01377308f, -0.04484618f, -0.05710353f, -0.00508140f, 
    0.00642925f, -0.02486859f, -0.05827115f, 0.05289533f, 0.04720118f, -0.06915574f, 0.04509810f, 0.03353067f, 
    -0.06274646f, -0.00234978f, -0.04882113f, 0.05717817f, 0.04619331f, -0.00877947f, -0.03532097f, 0.05441523f, 
    0.04525972f, -0.05326564f, -0.06301005f, 0.04445016f, -0.00663200f, -0.07096654f, 0.00802512f, 0.03593562f, 
    -0.07053906f, 0.02323051f, -0.04591356f, 0.02923941f, -0.00314007f, -0.07774163f, 0.04863873f, -0.00319492f, 
    -0.09188482f, 0.02629379f, 0.03168844f, -0.05257729f, -0.06203845f, 0.02468482f, -0.04050814f, -0.00452264f, 
    -0.06523868f, -0.03293711f, 0.00206100f, 0.05070240f, -0.04328522f, 0.05708848f, 0.00829984f, 0.05178381f, 
    -0.03299136f, 0.01698705f, 0.06549747f, -0.07042746f, -0.02549160f, 0.04707091f, -0.05397791f, -0.05649542f, 
    0.01365509f, -0.07629532f, 0.04015990f, -0.02897835f, 0.01322608f, -0.04444301f, -0.01270417f, -0.07803476f, 
    -0.00328860f, -0.01117191f, -0.05397228f, -0.02162717f, 0.00654934f, -0.01911169f, 0.02722762f, -0.00306142f, 
    -0.00996112f, 0.01720513f, 0.00402702f, 0.03564711f, -0.08901180f, -0.04945710f, 0.00772754f, -0.02329864f, 
    -0.02512880f, 0.00002762f, -0.05259153f, -0.02541616f, -0.06970955f, -0.07326879f, 0.02594182f, -0.06238469f, 
    -0.05098893f, -0.02849520f, -0.03040617f, -0.06876934f, 0.02358847f, -0.03452348f, -0.01686872f, -0.01919387f, 
    0.03716839f, -0.06423885f, 0.02535230f, -0.02082017f, -0.05314659f, -0.01046441f, -0.03305272f, -0.01051217f, 
    -0.06805478f, -0.02970391f, -0.01128801f, -0.06221965f, 0.00226622f, -0.00607213f, 0.04848658f, -0.09190811f, 
    0.05040664f, -0.03722261f, -0.07552061f, 0.01860187f, -0.02143366f, 0.00685299f, 0.02294805f, 0.07006500f, 
    0.50007188f, -0.14140111f, -0.07147722f, 0.19091423f, 0.12712878f, 0.01751687f, -0.07180355f, -0.05537594f, 
    0.19214934f, -0.01496662f, -0.10092665f, -0.08020762f, -0.15747215f, -0.19917506f, -0.05760788f, -0.09927835f, 
    -0.07554656f, 0.11510985f, 0.00032898f, 0.00757715f, 0.07305901f, -0.05585311f, 0.09026568f, -0.01401705f, 
    0.30157247f, 0.04779581f, 0.11085784f, -0.01782459f, -0.06753693f, -0.02649465f, 0.14834271f, 0.13818732f, 
    0.12266089f, 0.01203123f, 0.02579819f, 0.03024323f, -0.04276288f, -0.32436830f, 0.08759999f, 0.31731513f, 
    -0.00152175f, 0.03097313f, -0.12295751f, -0.02788552f, 0.12688351f, -0.07043096f, 0.09446445f, 0.01081617f, 
    -0.35602826f, -0.08556362f, 0.23784985f, 0.01215260f, 0.00870897f, 0.08805469f, 0.10459914f, -0.04882804f, 
    0.01889905f, -0.02670849f, -0.05335022f, 0.07794952f, 0.07893562f, -0.01942476f, 0.04700522f, -0.10907721f, 
    0.02263143f, 0.05416495f, -0.05195514f, 0.07938857f, 0.12154039f, 0.03528928f, 0.05358557f, -0.00065697f, 
    -0.15796171f, -0.17097804f, -0.00949532f, -0.08064794f, -0.05061611f, -0.07466368f, -0.07302196f, -0.00675529f, 
    -0.04960073f, 0.15649027f, 0.02065901f, 0.01203680f, -0.06160303f, 0.13852170f, 0.09830470f, -0.15885939f, 
    -0.07766829f, -0.04202951f, -0.00674909f, 0.15926015f, 0.09500685f, 0.01148469f, 0.03319488f, -0.00376347f, 
    -0.16769345f, -0.02852529f, 0.03807020f, 0.18528199f, 0.04236874f, 0.05268832f, 0.07542860f, 0.09412482f, 
    0.02117574f, 0.08632371f, 0.01725904f, 0.03132585f, -0.16976136f, -0.09644426f, 0.04615006f, -0.15757008f, 
    0.02270367f, -0.01375199f, 0.04874153f, 0.14368396f, 0.07026385f, -0.07368349f, 0.03354211f, 0.13188192f, 
    -0.02851364f, 0.02521185f, -0.01448782f, -0.24544774f, -0.01646063f, 0.05283534f, 0.04824181f, 0.10065888f, 
    0.09040180f, 0.14679542f, 0.09108690f, 0.07085528f, 0.25879365f, -0.18095736f, 0.11169516f, 0.18889515f, 
    -0.07434886f, 0.03627979f, 0.00113234f, -0.01877978f, 0.11781678f, 0.00108899f, -0.02912484f, 0.05315604f, 
    0.15080801f, -0.09780799f, -0.06028596f, 0.10138650f, 0.00162692f, -0.07555737f, -0.04648447f, -0.01016999f, 
    0.03472510f, -0.04400907f, 0.08410946f, -0.04480196f, -0.05269296f, 0.02959521f, 0.04530979f, 0.02294311f, 
    -0.05574979f, -0.10156569f, -0.02288870f, 0.11525694f, 0.00698451f, 0.06764252f, 0.13695645f, -0.06625794f, 
    -0.00536842f, 0.00064468f, 0.03591102f, -0.17661943f, 0.02590830f, -0.21553694f, 0.19765261f, 0.05060663f, 
    -0.06572855f, 0.00714171f, 0.02979699f, -0.00041541f, 0.01958376f, 0.02549164f, -0.08627403f, -0.08218170f, 
    -0.06022706f, 0.03296475f, 0.01088315f, 0.05566289f, 0.03201381f, -0.02857251f, 0.01471593f, 0.05528602f, 
    -0.12146953f, -0.37040421f, -0.04921778f, -0.16351123f, -0.10353114f, -0.04154940f, 0.02701068f, -0.01708696f, 
    -0.08500917f, -0.02924185f, -0.00441460f, 0.01596327f, -0.01968541f, 0.02652146f, -0.01758579f, -0.06144031f, 
    0.10353444f, 0.11752920f, 0.12731433f, 0.08069637f, -0.04258146f, 0.12969080f, 0.02447286f, -0.13501030f, 
    -0.00620206f, -0.03974743f, 0.20207404f, -0.05581691f, -0.00680161f, 0.09076530f, 0.03665322f, -0.02805884f, 
    0.04433510f, -0.01143899f, -0.10881627f, -0.04805689f, -0.28680325f, -0.27970555f, -0.05651950f, 0.26974702f, 
    0.05771112f, -0.05377565f, 0.03744152f, -0.10303445f, -0.13133986f, 0.03332272f, 0.04161449f, 0.05831932f, 
    0.06935546f, -0.01375398f, -0.00785915f, 0.10099969f, -0.00567213f, 0.18195324f, -0.06124888f, -0.07177795f, 
    -0.03532800f, 0.06523890f, 0.12697953f, 0.03138643f, 0.10388206f, 0.12885508f, 0.09986186f, -0.04291280f, 
    0.04442099f, 0.13808976f, 0.12053023f, -0.09145457f, 0.02149631f, 0.04755162f, -0.10663454f, 0.04381907f, 
    0.17636842f, 0.04894990f, 0.05265837f, -0.06294447f, 0.02407690f, 0.11787333f, 0.00351328f, 0.00954873f, 
    -0.09531116f, 0.01392748f, 0.04099888f, -0.11117426f, 0.23885335f, 0.00332584f, -0.24053870f, 0.06837165f, 
    -0.19032504f, -0.04128639f, 0.13670297f, 0.02337000f, 0.04366570f, 0.05384566f, 0.00945321f, -0.12919514f, 
    0.37557635f, 0.18779095f, -0.01969630f, -0.01673625f, 0.07721777f, 0.01436117f, 0.10362899f, 0.03535365f, 
    -0.02151628f, 0.12823577f, 0.01362223f, 0.09022281f, 0.25842732f, -0.05846899f, -0.00403429f, 0.08459216f, 
    -0.03640640f, -0.00663455f, 0.08301537f, 0.08305231f, -0.00343911f, 0.04122748f, 0.02742431f, 0.06837998f, 
    -0.11686539f, -0.06813215f, 0.13854077f, -0.06976705f, 0.03387115f, 0.08441532f, 0.12803951f, 0.13876775f, 
    -0.04864758f, -0.06454754f, -0.14838389f, 0.06145637f, -0.26650292f, -0.11001508f, -0.04854885f, 0.08082507f, 
    0.01135131f, 0.07510223f, -0.04748446f, -0.02595811f, 0.09383970f, 0.05698363f, 0.08326531f, -0.02098612f, 
    0.17201467f, 0.03928791f, -0.08126763f, 0.03626703f, 0.17517984f, 0.13250089f, -0.02448072f, -0.07377256f, 
    -0.11240342f, 0.12313396f, 0.05790257f, 0.30331996f, 0.23332626f, 0.10221749f, -0.11252590f, -0.04091750f, 
    -0.03980462f, 0.05905484f, -0.00841999f, 0.03387283f, 0.01549786f, -0.00671207f, -0.09216186f, -0.03839772f, 
    0.16346808f, 0.07084635f, -0.06816208f, 0.12729415f, -0.05251912f, -0.00965928f, -0.00858905f, 0.03005475f, 
    0.06434076f, 0.04173309f, 0.02562532f, -0.04072939f, -0.24825792f, -0.06961048f, 0.19932826f, -0.14581054f, 
    -0.21803895f, -0.01857489f, 0.06345039f, 0.05087873f, 0.04612076f, -0.08250547f, 0.06681301f, 0.01376753f, 
    -0.01157140f, -0.00711339f, -0.01359609f, -0.02289773f, -0.05187079f, 0.04919022f, 0.03783857f, -0.06470434f, 
    -0.05655139f, -0.04207237f, -0.06151862f, -0.00609608f, 0.00269914f, -0.07257844f, -0.01122948f, -0.01915020f, 
    -0.08394545f, -0.08384664f, 0.03179875f, -0.07390083f, -0.03589446f, -0.00933614f, 0.05984446f, 0.04573610f, 
    0.01816176f, 0.05539387f, 0.02674155f, 0.05487890f, -0.02659274f, 0.01340633f, -0.04541801f, -0.02168978f, 
    -0.02813155f, 0.04781672f, 0.01355211f, -0.05210447f, 0.04445623f, 0.02408384f, -0.07537299f, -0.00647645f, 
    -0.05881346f, -0.06208554f, 0.00394026f, 0.05822203f, 0.01637204f, -0.01066866f, 0.00972314f, -0.01118116f, 
    -0.06785597f, 0.02442109f, -0.03379047f, -0.02989221f, -0.03046326f, -0.03497846f, -0.07015415f, 0.00857564f, 
    0.01267171f, -0.03042635f, 0.04736454f, -0.05256321f, 0.03154970f, 0.03412485f, 0.01707249f, -0.03417725f, 
    0.03652973f, -0.02030415f, -0.01140728f, 0.00476696f, 0.03000028f, 0.05675190f, 0.00751578f, -0.01923211f, 
    -0.00541394f, 0.00095976f, 0.03771831f, 0.05516545f, 0.05780096f, -0.03388547f, -0.02888969f, 0.03274868f, 
    -0.06905857f, -0.00797161f, -0.07998796f, 0.03087182f, -0.00868809f, -0.03333287f, 0.05094311f, 0.02019963f, 
    0.03183009f, -0.06320769f, -0.00051066f, -0.05452289f, -0.02224083f, 0.04779118f, -0.05939860f, -0.03398294f, 
    -0.02156042f, -0.00052861f, -0.01948062f, 0.00216683f, -0.05866335f, 0.04631788f, 0.04733571f, -0.02761744f, 
    0.04279094f, 0.06246619f, -0.02585717f, -0.04450994f, 0.04098650f, 0.05256314f, 0.04504532f, -0.00768410f, 
    0.02146453f, 0.01540533f, -0.06470239f, 0.00325824f, 0.05837961f, 0.02714368f, -0.06385797f, 0.01480466f, 
    0.01546774f, 0.05576592f, -0.07043499f, -0.06252215f, 0.01820116f, 0.02434513f, -0.00350883f, -0.02180140f, 
    0.01194347f, -0.05974704f, 0.00714301f, 0.05009921f, 0.06098025f, -0.07315936f, -0.06074499f, 0.03113050f, 
    0.03799505f, -0.00079676f, -0.07771555f, -0.03623508f, -0.00426365f, -0.06970102f, -0.07436781f, -0.07173070f, 
    -0.05364112f, 0.00213954f, 0.00066806f, -0.07921578f, -0.03457645f, -0.01337525f, -0.01341581f, -0.03452633f, 
    0.00617307f, 0.03814075f, -0.00815468f, -0.04531662f, -0.03916649f, -0.06548360f, 0.03709605f, 0.03661799f, 
    -0.00673613f, 0.02101409f, -0.05650714f, 0.04103362f, 0.02294290f, -0.04495698f, 0.05486006f, 0.05118787f, 
    -0.02345432f, -0.01325747f, -0.01599956f, -0.02322440f, -0.07199802f, -0.06199218f, -0.06211040f, 0.03165488f, 
    -0.07409603f, 0.00733760f, -0.06662361f, -0.00553021f, 0.04194629f, -0.05467369f, 0.00924456f, -0.05248466f, 
    0.01987341f, -0.00551017f, -0.00943907f, -0.07884270f, 0.05877716f, -0.08216213f, 0.06144268f, -0.03013797f, 
    -0.05552699f, -0.02647858f, 0.01003903f, -0.04561363f, 0.04968007f, -0.04935427f, -0.02266409f, -0.06059724f, 
    -0.02304709f, -0.00020649f, 0.06228732f, -0.03493137f, 0.05498980f, 0.05750736f, -0.03782854f, 0.03673941f, 
    0.05678500f, 0.02060384f, -0.00180083f, -0.05473607f, -0.00784210f, 0.06677935f, 0.04282454f, -0.01771014f, 
    0.06525552f, -0.05763815f, 0.01492126f, -0.07459297f, 0.01680172f, 0.03732651f, -0.03515087f, -0.01593079f, 
    -0.01312268f, 0.00365656f, -0.04765116f, 0.04892144f, -0.01368886f, 0.01341761f, 0.00256264f, -0.02964885f, 
    -0.00639429f, -0.05797702f, -0.02302993f, 0.05256279f, -0.04582316f, 0.00102197f, 0.02054247f, -0.05767309f, 
    0.02206503f, -0.02824157f, -0.01372142f, 0.00797932f, 0.03671466f, -0.01274189f, 0.02171358f, -0.06280182f, 
    0.00470479f, 0.03282513f, -0.03359171f, -0.02305420f, 0.02467736f, -0.04318677f, -0.03996700f, -0.05147830f, 
    -0.00204082f, 0.03975501f, -0.06756748f, 0.03096521f, 0.04842219f, 0.00882356f, -0.00114330f, -0.07058091f, 
    0.06419767f, -0.04506459f, -0.05935897f, 0.03551129f, -0.02535546f, 0.02500022f, 0.00304491f, -0.05321222f, 
    0.05708459f, -0.07191483f, -0.01746483f, -0.00844633f, -0.02099811f, -0.00091767f, -0.00419154f, 0.02217600f, 
    -0.07208200f, 0.06343368f, 0.01686226f, -0.01704608f, -0.07723381f, 0.01157946f, 0.04858829f, 0.01437040f, 
    -0.01350866f, -0.02117566f, -0.05221256f, -0.02780669f, -0.05177606f, 0.05022706f, -0.05667064f, 0.02504171f, 
    -0.02357519f, 0.05536397f, -0.00857446f, -0.01644596f, -0.07460798f, -0.02400829f, 0.06023438f, -0.06255756f, 
    0.00506138f, -0.00088651f, 0.02144855f, -0.01984938f, 0.04042084f, -0.04074635f, 0.02978085f, -0.02950134f, 
    0.02996088f, 0.03139030f, -0.01079430f, 0.01080246f, -0.05324717f, 0.05577848f, -0.03149800f, -0.05591146f, 
    -0.03628981f, 0.01380819f, 0.02376238f, -0.05718850f, 0.03088844f, -0.01014137f, -0.02084750f, 0.04130614f, 
    0.00047040f, 0.02201258f, -0.03212261f, -0.07442670f, -0.03777580f, -0.07524435f, -0.06701078f, -0.00296075f, 
    -0.06137274f, -0.04537116f, -0.05652626f, -0.06727110f, -0.07244863f, -0.00789769f, -0.07519627f, -0.07933900f, 
    -0.03719486f, 0.03642876f, 0.03875921f, -0.03711373f, -0.05797366f, -0.05678097f, -0.03479974f, -0.06213894f, 
    -0.02260491f, -0.00574289f, -0.02771700f, -0.05674268f, 0.04397430f, 0.02879235f, -0.07298832f, -0.05584477f, 
    0.03311739f, 0.01481338f, 0.04419362f, 0.00687259f, -0.04132156f, 0.02658424f, 0.03997822f, 0.04802246f, 
    -0.07255727f, -0.00639057f, 0.03279601f, -0.06552137f, -0.06449685f, -0.03498607f, -0.02996320f, -0.00357841f, 
    -0.05375157f, -0.04034187f, 0.04847008f, 0.03176036f, -0.05634495f, -0.02403271f, -0.06722611f, 0.02305342f, 
    -0.02629168f, -0.02053599f, 0.03557532f, -0.03118537f, -0.02122074f, -0.03559428f, -0.07680607f, -0.03736432f, 
    -0.00226662f, -0.01134628f, -0.03836347f, -0.03229841f, 0.00766990f, -0.05078756f, -0.07386922f, 0.00093784f, 
    -0.03181062f, -0.02283078f, 0.04301970f, 0.01124435f, -0.03922104f, 0.06454163f, -0.06120878f, 0.00130351f, 
    -0.00182909f, -0.00004466f, 0.05465104f, 0.04848059f, 0.06096170f, -0.03522216f, 0.00756439f, 0.00777366f, 
    -0.00346194f, 0.05474858f, 0.00876434f, -0.04069163f, 0.06105767f, 0.01796019f, 0.01123361f, -0.04642394f, 
    -0.02577006f, -0.01320460f, 0.00662301f, 0.04419642f, -0.03559106f, 0.01541586f, 0.00958983f, 0.03947986f, 
    -0.04238668f, 0.03654478f, -0.04158516f, 0.05978972f, 0.03384422f, -0.03553958f, -0.04944079f, -0.02217164f, 
    0.04326609f, 0.02165969f, -0.06808463f, -0.00649267f, 0.00160898f, 0.01141579f, 0.03073153f, -0.07273027f, 
    -0.05181140f, -0.01931076f, -0.04477362f, -0.01831901f, 0.05469649f, 0.00325442f, -0.06393325f, -0.04823922f, 
    -0.03696254f, 0.02901816f, -0.02833901f, 0.04916477f, -0.06333300f, -0.00825641f, 0.02343232f, 0.03720406f, 
    0.02957242f, 0.05976000f, 0.03952678f, 0.01295855f, -0.03222307f, 0.00139624f, 0.01982947f, -0.07196508f, 
    -0.06360756f, -0.00241410f, -0.04471347f, 0.02646800f, -0.06664934f, -0.05654585f, -0.02449840f, -0.02611308f, 
    -0.03702326f, -0.02568529f, -0.06479713f, -0.06390132f, 0.01349048f, -0.04436271f, -0.00795949f, 0.01022599f, 
    -0.06700825f, 0.06132419f, -0.03588056f, -0.02660079f, -0.00242236f, 0.05843696f, -0.01605725f, 0.05697752f, 
    -0.03100721f, -0.04674691f, -0.02456113f, 0.06769697f, 0.04693108f, -0.04517413f, -0.04441323f, 0.04251377f, 
    -0.05684998f, -0.01732940f, 0.03137606f, -0.06147654f, -0.06909865f, -0.03745051f, -0.07424045f, -0.04705403f, 
    0.04559213f, 0.06096544f, 0.01874940f, 0.01941923f, 0.04721435f, -0.01240475f, -0.07409544f, 0.05800959f, 
    0.00776815f, -0.04897451f, 0.02492024f, 0.00104454f, -0.03965780f, 0.03667768f, -0.03470835f, 0.04969855f, 
    0.00433557f, 0.06023061f, 0.02425392f, -0.03860985f, -0.01934603f, 0.06324127f, -0.02937356f, 0.02779177f, 
    -0.00956091f, -0.02717827f, 0.05693243f, 0.00124504f, -0.01088396f, -0.00057195f, -0.04759257f, 0.04939712f, 
    -0.07288415f, -0.02693589f, 0.01759186f, -0.04514356f, -0.00120845f, -0.00539333f, -0.00915558f, -0.02221879f, 
    -0.00408839f, 0.05557858f, -0.07085863f, 0.01251128f, -0.04350911f, -0.06311043f, -0.05580836f, 0.05225038f, 
    -0.06642317f, 0.04001657f, -0.04446467f, -0.03839217f, -0.07547531f, 0.01194015f, -0.00091212f, -0.01894311f, 
    -0.06746437f, 0.04701395f, -0.02520423f, -0.05608126f, -0.04866480f, -0.00720953f, -0.00781186f, 0.00969215f, 
    -0.03733658f, 0.06134472f, -0.07152802f, -0.03898729f, 0.00490231f, 0.01092933f, -0.03533376f, -0.05975457f, 
    -0.02444956f, -0.07649513f, 0.05921440f, 0.03936264f, 0.05286422f, 0.03404246f, -0.03684381f, 0.02822062f, 
    0.05933008f, -0.04371246f, -0.06257723f, 0.05036400f, -0.05935417f, -0.01706309f, 0.00529200f, -0.04181430f, 
    -0.05284042f, -0.05958832f, -0.03361896f, 0.05330791f, -0.08138227f, 0.05110702f, -0.01989355f, 0.01783422f, 
    0.01361016f, -0.00834296f, -0.05789905f, 0.00392650f, 0.00556857f, 0.01594291f, -0.03352967f, 0.00911540f, 
    0.01671417f, 0.03037986f, -0.03348128f, 0.04530791f, -0.05428626f, -0.02835837f, -0.05914159f, -0.07661162f, 
    -0.03516638f, 0.02442068f, -0.01746183f, -0.07203813f, -0.03324987f, 0.05505776f, 0.03681943f, -0.05871588f, 
    -0.04705543f, -0.05177112f, -0.05502925f, 0.04325695f, 0.03700932f, 0.05688682f, 0.00886585f, -0.06989112f, 
    -0.04167704f, -0.04756607f, 0.01980472f, 0.04319398f, 0.04557580f, 0.02998750f, 0.03708557f, -0.00750124f, 
    0.02993220f, 0.01109439f, -0.00697899f, -0.03515269f, -0.07513773f, -0.01526642f, -0.06184852f, 0.00983634f, 
    0.05249087f, -0.04790094f, 0.03781995f, -0.06729298f, -0.06311779f, 0.04847686f, 0.00009231f, 0.03044359f, 
    0.02860351f, 0.02594152f, -0.05241200f, 0.05407988f, -0.01066115f, 0.04494987f, 0.00054166f, -0.08112153f, 
    -0.01225954f, 0.03919948f, -0.05809194f, -0.06135902f, 0.02631791f, -0.00291863f, 0.04289402f, -0.05650903f, 
    -0.07217676f, 0.03556255f, -0.07221100f, 0.01787538f, -0.05807984f, -0.06470816f, -0.06540682f, -0.03351454f, 
    -0.03846542f, -0.01774702f, -0.05767921f, -0.05113890f, 0.06557395f, -0.07359722f, -0.02127022f, -0.04432928f, 
    0.03081654f, 0.06309848f, 0.06038218f, 0.01398059f, -0.04715812f, 0.01972286f, -0.04125506f, 0.05799098f, 
    0.00203843f, 0.03199099f, -0.04172199f, -0.04193258f, 0.05310340f, 0.04501236f, -0.00105263f, 0.05910863f, 
    -0.01835649f, 0.03187934f, 0.02865682f, 0.00731645f, 0.02874948f, -0.01640331f, 0.02771423f, -0.06316959f, 
    0.06359135f, 0.02225275f, 0.04080243f, -0.02163481f, 0.02172665f, -0.02622559f, -0.04876337f, -0.07443489f, 
    0.00042231f, 0.04104581f, -0.08141772f, 0.06042190f, 0.03246311f, -0.06297545f, -0.00623068f, 0.02798811f, 
    -0.06985398f, -0.02754325f, -0.01895177f, -0.07110412f, -0.07090107f, -0.04609821f, 0.02477746f, 0.03029527f, 
    -0.07400541f, 0.03758377f, -0.03457859f, 0.03093900f, -0.04455847f, -0.02257168f, -0.04900848f, -0.00160117f, 
    0.06128529f, -0.05907700f, 0.02950996f, -0.06746484f, -0.01058854f, -0.04926404f, -0.02717181f, -0.00743279f, 
    0.01990580f, -0.04041524f, 0.03344885f, -0.00021942f, -0.03493483f, -0.03017224f, -0.03023759f, -0.07136859f, 
    -0.23462905f, -0.20002264f, 0.10531062f, 0.15351999f, 0.17398351f, -0.09356935f, -0.02332544f, -0.20152713f, 
    0.06321213f, -0.01850971f, 0.03404637f, 0.28573099f, -0.06462006f, 0.07467885f, 0.10214512f, 0.12198442f, 
    0.00161018f, 0.11165364f, -0.04510594f, 0.08901332f, -0.00393735f, 0.02314732f, -0.06241196f, 0.01709792f, 
    -0.14200452f, 0.24537556f, 0.09581906f, 0.10130654f, 0.10575344f, -0.07357569f, 0.04775589f, -0.00138254f, 
    0.20926888f, 0.10609084f, -0.03584355f, 0.14218493f, -0.38590068f, -0.02636689f, 0.09728074f, 0.06425495f, 
    0.17591253f, 0.06238651f, -0.05176755f, -0.10732710f, -0.06620917f, 0.04289340f, 0.11579959f, 0.10979916f, 
    -0.11198078f, 0.02009277f, 0.13498010f, -0.28637141f, 0.30530947f, -0.08019960f, 0.03082256f, 0.01222511f, 
    0.09079076f, 0.02845760f, 0.04410369f, -0.01702342f, 0.07796260f, 0.11982531f, -0.15864572f, -0.03943256f, 
    0.06239019f, -0.06615604f, -0.11872771f, 0.09676862f, 0.16972066f, 0.05894686f, 0.09780812f, 0.11269393f, 
    -0.27466664f, -0.00993818f, 0.04707616f, 0.13839771f, -0.06099060f, 0.03571942f, -0.00165260f, 0.19575055f, 
    0.01162009f, 0.00133964f, -0.00733237f, -0.08447235f, 0.01502583f, 0.05403165f, -0.03460480f, -0.05931675f, 
    -0.06847133f, -0.07854638f, 0.02943460f, -0.04701162f, 0.02198477f, 0.08538842f, -0.08052565f, -0.05832874f, 
    0.11244249f, 0.00007641f, -0.11125431f, 0.03619165f, 0.09961507f, 0.02753973f, -0.00882316f, -0.03922455f, 
    -0.02649142f, 0.19995193f, 0.12484360f, 0.18576646f, 0.30643868f, 0.01044954f, 0.01607754f, -0.06269248f, 
    0.00597670f, -0.03570854f, 0.02507996f, 0.08840789f, -0.00682993f, 0.16471554f, -0.04381306f, 0.12593454f, 
    -0.23633452f, -0.16920303f, 0.23947267f, 0.12505507f, 0.06208358f, 0.24405782f, 0.22173148f, -0.12213217f, 
    0.14210048f, -0.06468178f, -0.02115478f, 0.09432995f, -0.11221974f, 0.03382713f, 0.14608917f, -0.23185447f, 
    0.18083300f, -0.03606532f, 0.01491382f, -0.09634392f, 0.16400288f, -0.10276482f, 0.15652719f, 0.06712755f, 
    0.11653320f, -0.25827530f, 0.08476654f, -0.06721723f, 0.00840403f, -0.05208287f, -0.00401558f, -0.01919509f, 
    0.06951009f, 0.22122826f, -0.07836810f, 0.01268394f, -0.04311848f, 0.07533363f, -0.09396467f, 0.30952317f, 
    0.11817300f, 0.04787098f, 0.14274058f, -0.06098967f, 0.04321931f, -0.06747110f, 0.11182965f, -0.02869747f, 
    0.05245818f, -0.09298710f, -0.03181295f, -0.06220052f, 0.15627795f, -0.10538082f, 0.18593073f, 0.10424002f, 
    -0.06768698f, -0.05396767f, -0.04607655f, 0.16913140f, 0.03456280f, 0.27873534f, -0.03946484f, -0.01924331f, 
    -0.03661876f, -0.04003313f, -0.02502433f, -0.05344022f, 0.18372461f, 0.04994006f, 0.07365925f, 0.07565396f, 
    -0.17561094f, 0.12792425f, -0.14688705f, -0.22576728f, 0.15688521f, -0.06992478f, 0.08610895f, 0.07736444f, 
    0.04673335f, -0.02494540f, 0.19958045f, 0.10644843f, -0.06556443f, -0.05820604f, 0.04640775f, -0.17406248f, 
    0.03402719f, -0.03620935f, -0.03671851f, -0.05183302f, -0.09461216f, -0.04353252f, -0.00617742f, 0.00555997f, 
    0.08223314f, -0.05154769f, 0.15049557f, 0.06861675f, -0.01247745f, -0.07455590f, 0.11792908f, -0.00489945f, 
    0.15049362f, 0.19420920f, -0.00566769f, -0.02508565f, -0.16991021f, -0.15059553f, -0.03450297f, -0.14729501f, 
    0.07818107f, -0.12865280f, 0.00553830f, -0.03486804f, 0.05968549f, 0.06543664f, 0.10540739f, 0.03116480f, 
    0.11682706f, 0.25916097f, -0.08091959f, -0.00141823f, 0.15856478f, 0.03642727f, -0.05628588f, -0.08070285f, 
    0.07580723f, -0.03247017f, 0.11461861f, 0.08982137f, -0.16773523f, -0.09636784f, -0.07626151f, -0.06023045f, 
    0.13177918f, 0.06816516f, 0.04890697f, 0.08572620f, 0.08401524f, 0.06276838f, 0.03287642f, 0.06828831f, 
    -0.07438061f, 0.02336688f, -0.13084762f, -0.27340063f, 0.00545466f, -0.09851908f, 0.02371659f, -0.03964477f, 
    0.01835618f, -0.13775304f, 0.02157472f, 0.05518644f, -0.09308128f, -0.22381097f, -0.01578609f, -0.05576287f, 
    -0.01546458f, -0.00809149f, 0.05306413f, 0.02476022f, 0.03518667f, 0.09066572f, 0.03275153f, -0.10038598f, 
    0.36113656f, 0.13746072f, -0.06786212f, -0.00355241f, 0.06618907f, -0.01099351f, 0.23934583f, 0.13616976f, 
    -0.00421681f, 0.08243742f, 0.16326803f, 0.17051502f, -0.07840054f, 0.17296246f, -0.12295769f, -0.19916530f, 
    0.14642724f, -0.01462654f, 0.18924522f, -0.13243091f, 0.05425030f, 0.11585155f, -0.00602742f, 0.04628848f, 
    -0.07612690f, 0.34300113f, 0.25450975f, 0.18225062f, 0.19227135f, 0.00730076f, -0.05059303f, -0.05732603f, 
    0.05991385f, -0.06887212f, 0.00433874f, 0.08964379f, 0.30774611f, -0.24749242f, 0.09958530f, -0.03978775f, 
    0.08921447f, 0.09930734f, 0.01664726f, -0.04981121f, 0.22742905f, 0.01633984f, 0.06260592f, 0.12911418f, 
    -0.15969707f, 0.08022009f, 0.14272586f, 0.11948905f, 0.18380642f, 0.00749727f, -0.05109513f, 0.08173375f, 
    0.00866255f, -0.13502593f, 0.00375159f, -0.00231613f, -0.13547203f, -0.03027519f, 0.01464560f, -0.23970269f, 
    0.05564043f, 0.05685652f, -0.00752318f, -0.06194136f, 0.10592426f, 0.08130120f, -0.05507740f, 0.02774512f, 
    -0.27962860f, 0.08611290f, -0.03727369f, -0.10942788f, -0.00543544f, 0.00063865f, 0.12204020f, 0.08016199f, 
    0.10908713f, 0.05342552f, 0.06608908f, 0.04790115f, -0.10072935f, 0.04707675f, 0.02345409f, 0.07527409f, 
    0.13672704f, 0.06528334f, 0.14186606f, -0.02722871f, 0.19660023f, 0.00723079f, 0.05160394f, 0.09416658f, 
    0.03314536f, 0.16123593f, 0.10002305f, 0.00723892f, 0.08697353f, -0.10627093f, -0.01184079f, -0.03115050f, 
    0.04152431f, 0.11291272f, -0.01696970f, 0.13660663f, -0.07060343f, -0.05570512f, -0.20237750f, -0.01060879f, 
    -0.00030800f, 0.17022952f, -0.01630981f, -0.00457774f, 0.00339428f, -0.02201993f, -0.09973139f, 0.03791763f, 
    -0.10411499f, -0.09789383f, -0.02502256f, 0.01049612f, 0.05275506f, -0.02538451f, 0.09252057f, 0.15063545f, 
    0.13083668f, 0.15219583f, 0.06864160f, 0.04105580f, 0.01011415f, 0.31423369f, 0.14035974f, -0.12662908f, 
    0.18921477f, 0.08217245f, 0.01225653f, 0.06980879f, -0.00598830f, 0.01258396f, 0.09381414f, 0.16176890f, 
    -0.15818126f, 0.05258824f, 0.09923021f, -0.35159665f, 0.15437123f, 0.01462863f, -0.00895420f, 0.11852434f, 
    0.00999663f, -0.03703835f, -0.06708837f, -0.00062296f, 0.01651541f, -0.16405006f, -0.00057776f, 0.13681169f, 
    0.03174784f, -0.06314854f, 0.00360932f, 0.03490604f, -0.01247690f, -0.06940216f, 0.06473618f, -0.04005422f, 
    -0.33014572f, -0.15814193f, -0.12980305f, 0.06178342f, 0.04294512f, -0.05044275f, 0.18495853f, 0.02886951f, 
    0.09241042f, 0.03306319f, -0.09572507f, 0.03551670f, -0.55908507f, -0.02013955f, -0.10113792f, -0.01789924f, 
    0.10786784f, 0.10131966f, -0.09021583f, -0.05178476f, 0.01317498f, 0.05955495f, -0.10831195f, 0.00103080f, 
    0.10536551f, 0.01737732f, 0.26158395f, -0.02564194f, -0.10475890f, -0.05782519f, 0.05758108f, 0.08032866f, 
    0.04345101f, 0.10983686f, 0.07551916f, 0.04894416f, -0.27435592f, -0.00038767f, -0.05599128f, -0.10438077f, 
    0.09255750f, 0.11048464f, -0.07805819f, 0.01811324f, 0.03308883f, 0.03742603f, -0.03751515f, 0.10528822f, 
    -0.16064578f, -0.19875327f, 0.14785388f, 0.20574372f, -0.08329923f, -0.06665271f, 0.10248106f, -0.04442981f, 
    0.06027738f, 0.09150755f, 0.02991494f, 0.05674839f, -0.15795302f, 0.05986660f, 0.09669142f, -0.11121175f, 
    0.05620796f, 0.17020679f, 0.03204304f, 0.13250892f, 0.07790253f, -0.08268436f, 0.02356916f, -0.01700548f, 
    0.07701472f, -0.32251313f, -0.04088459f, -0.04565023f, -0.05575764f, -0.00044564f, -0.04404369f, 0.07934980f, 
    -0.03876647f, 0.03249877f, 0.01099605f, -0.13874467f, -0.29488117f, -0.28040564f, -0.25035381f, 0.03300555f, 
    0.20314135f, -0.07663899f, -0.01809548f, 0.03948879f, 0.03136309f, -0.02257487f, 0.14180376f, -0.00817148f, 
    -0.06921301f, -0.15121584f, -0.06904001f, -0.16338763f, 0.05091969f, 0.04477387f, 0.13769600f, 0.02761871f, 
    -0.01946113f, -0.02744049f, 0.04388479f, 0.13898338f, -0.33432502f, -0.15528730f, -0.07035983f, 0.20908903f, 
    -0.08217523f, 0.00184494f, -0.02132705f, 0.06682128f, 0.11212254f, 0.10357404f, -0.00542072f, 0.00059912f, 
    0.35377863f, 0.11016803f, 0.17626941f, 0.19283913f, -0.18082041f, 0.11422240f, -0.00197216f, 0.02731686f, 
    -0.00196666f, -0.13255076f, 0.03712238f, -0.06476755f, 0.09772434f, -0.07117053f, -0.04522872f, -0.04348795f, 
    0.05025883f, 0.07484892f, -0.03566663f, 0.00979718f, 0.08496596f, -0.00469589f, -0.06353324f, 0.00778683f, 
    0.15523124f, 0.12052996f, 0.02966866f, 0.06370199f, -0.03763900f, 0.11365503f, 0.09684801f, 0.15023160f, 
    0.01859760f, 0.07125162f, 0.01334615f, 0.05702699f, 0.41486344f, 0.19541858f, 0.02241014f, 0.02496443f, 
    -0.03193147f, 0.00027392f, 0.05686855f, 0.09513170f, 0.05352256f, -0.00007625f, 0.02477343f, 0.06429733f, 
    -0.15422066f, 0.08491366f, 0.12765265f, 0.04530043f, 0.00369417f, -0.02318707f, -0.02867502f, 0.06524046f, 
    -0.00743128f, 0.04315782f, 0.03454935f, -0.08385784f, -0.00082497f, -0.10397395f, 0.21618664f, 0.20143022f, 
    -0.03006645f, -0.07773110f, 0.08287583f, -0.00855365f, -0.08518079f, -0.10694750f, 0.06947218f, -0.02400460f, 
    0.28243163f, -0.16888855f, -0.00935657f, -0.12703738f, 0.06456981f, 0.03848184f, 0.09151071f, -0.05241592f, 
    0.05575731f, 0.10701647f, 0.11069749f, 0.09479413f, -0.35197890f, 0.07645386f, -0.04990806f, 0.07047813f, 
    0.10620923f, 0.11870307f, 0.09870275f, -0.03240519f, 0.06893848f, 0.01451345f, 0.06241763f, 0.00460801f, 
    -0.08493156f, -0.07972164f, 0.29620025f, 0.09492543f, -0.00745253f, -0.02534598f, -0.04870672f, -0.09635981f, 
    0.04632076f, -0.13193400f, -0.00573237f, 0.01512297f, -0.19944137f, 0.03800133f, -0.16677825f, 0.01001898f, 
    0.15233009f, 0.15745892f, -0.07121529f, 0.07295222f, 0.04749885f, 0.01236618f, 0.01025709f, -0.00683000f, 
    0.20368367f, -0.04198720f, -0.02097096f, -0.00317633f, -0.08736467f, -0.05416620f, -0.03671952f, 0.04138863f, 
    -0.07198545f, -0.00268308f, 0.04317763f, -0.06487279f, 0.01799436f, 0.14410409f, 0.05970415f, 0.07748865f, 
    -0.09305573f, 0.03081994f, -0.00255358f, 0.01238966f, -0.04268977f, -0.05228873f, -0.05732987f, -0.07693885f, 
    -0.12750088f, -0.07710645f, 0.04544231f, -0.00704181f, 0.05669221f, -0.03824142f, 0.01043024f, 0.01079137f, 
    0.01611569f, -0.11038302f, 0.01851015f, -0.16707006f, -0.06297826f, -0.05658731f, -0.02173265f, -0.06413563f, 
    0.09290846f, 0.00538461f, 0.06690069f, 0.06341326f, -0.01071195f, 0.01775470f, -0.00651784f, 0.00483619f, 
    -0.07951505f, -0.10945199f, -0.01380986f, 0.00614224f, -0.05551171f, -0.05931956f, 0.09460589f, -0.03259711f, 
    0.00888640f, 0.14289410f, -0.07674640f, 0.04082439f, -0.06406445f, -0.08968593f, -0.04546632f, 0.14436525f, 
    0.03229516f, 0.03852517f, -0.00340743f, 0.03422272f, 0.01767337f, 0.07339030f, -0.12808870f, -0.04227656f, 
    -0.05458457f, -0.00601980f, 0.01050388f, 0.23459320f, -0.11527863f, 0.09147216f, 0.03433255f, -0.03973233f, 
    -0.02438879f, 0.04200662f, -0.02863724f, -0.08891713f, 0.01511294f, 0.14261785f, 0.09069233f, 0.06238287f, 
    0.05406417f, 0.07908220f, 0.01332441f, 0.09342899f, 0.01425597f, 0.14563282f, 0.00198286f, 0.07263196f, 
    -0.47867769f, 0.01656741f, 0.12175310f, -0.23677254f, 0.11388186f, 0.08830868f, -0.09676484f, 0.01360427f, 
    -0.18393362f, -0.15240711f, 0.08090527f, 0.07513475f, 0.11636186f, 0.32914498f, -0.02401981f, -0.00175896f, 
    0.07809881f, 0.05252133f, 0.01224081f, 0.14556481f, -0.09167416f, 0.02575769f, -0.06780332f, -0.02609096f, 
    0.12352943f, -0.11765409f, -0.16542409f, 0.03485665f, -0.00711892f, -0.00214522f, 0.03771516f, 0.01572016f, 
    0.08798135f, 0.08990450f, 0.04158369f, -0.03723272f, -0.35062423f, 0.00738559f, 0.12793933f, -0.19138727f, 
    -0.01149353f, -0.05891502f, 0.21903208f, -0.12803411f, 0.06111822f, -0.02541884f, -0.05586371f, 0.05871968f, 
    0.13743214f, 0.17994830f, 0.16438614f, 0.22740418f, -0.00479127f, 0.03688037f, -0.01142462f, 0.10534191f, 
    0.04943822f, -0.04632787f, 0.12331266f, 0.05787775f, 0.23822300f, 0.21899435f, 0.00646251f, 0.20433351f, 
    0.00808779f, -0.06554928f, -0.12357537f, 0.10157006f, -0.02924337f, 0.01976239f, -0.04128042f, 0.12469923f, 
    -0.22234568f, -0.18403552f, 0.06468448f, -0.13225210f, -0.05786238f, -0.03252652f, -0.10007586f, -0.04549224f, 
    0.05660435f, 0.09844997f, 0.02593227f, -0.05023035f, 0.07808635f, 0.05872264f, 0.01010992f, 0.16655919f, 
    -0.05065089f, 0.09146488f, -0.21717589f, 0.15665604f, 0.01655426f, -0.05456094f, 0.03164931f, -0.03740272f, 
    0.05431303f, -0.27831107f, 0.08566724f, -0.10387843f, -0.07517013f, -0.12137761f, 0.10515779f, -0.07838552f, 
    -0.18187712f, 0.03642185f, -0.05037833f, -0.06728109f, -0.09075802f, 0.46705383f, -0.05963429f, 0.13455574f, 
    0.06855798f, 0.08428141f, -0.05921237f, 0.08631276f, -0.12888590f, -0.00097165f, -0.02263296f, -0.00527164f, 
    0.09957913f, -0.00017735f, -0.13857117f, -0.02130588f, -0.03630363f, 0.08744577f, -0.04241848f, -0.16587286f, 
    0.09530058f, -0.07515036f, -0.04471250f, 0.05050991f, 0.17916417f, -0.20418018f, 0.05938679f, 0.17068878f, 
    0.05054917f, 0.01214214f, -0.00926707f, 0.14294390f, -0.12749740f, -0.08965211f, 0.03772984f, -0.05767173f, 
    0.11320805f, -0.18110275f, -0.13606226f, 0.09604021f, 0.00689594f, 0.08676321f, -0.00288392f, 0.11907890f, 
    -0.02699523f, -0.02505459f, -0.05520027f, -0.00435154f, 0.00965774f, 0.01625852f, 0.28354755f, -0.08806212f, 
    0.07538556f, -0.01148487f, 0.00698861f, -0.05560528f, -0.04792004f, -0.03225225f, 0.03716233f, -0.07008016f, 
    -0.07067636f, 0.24234463f, 0.05171552f, 0.13319413f, 0.00237689f, 0.02448956f, 0.05690768f, 0.05131714f, 
    -0.00857063f, 0.02091081f, 0.04051208f, 0.03125624f, 0.15390678f, 0.19460240f, 0.04468085f, 0.23659101f, 
    0.08594337f, -0.01327667f, -0.00395819f, -0.02773339f, -0.10072263f, -0.07352454f, -0.03256125f, -0.16715616f, 
    -0.16872716f, 0.06811079f, 0.03686453f, 0.24002917f, 0.07539806f, -0.03791599f, 0.01473258f, -0.09029287f, 
    -0.02183339f, -0.05877738f, -0.04114621f, 0.01335403f, 0.21462524f, 0.10127263f, -0.15263487f, -0.17258659f, 
    -0.04594308f, -0.03641955f, 0.04840875f, -0.14569876f, -0.10737330f, 0.01418322f, -0.05640240f, 0.11665532f, 
    -0.37115428f, 0.13817686f, -0.21432908f, -0.19766979f, -0.03720052f, -0.14984530f, -0.00871402f, 0.01769196f, 
    0.03892424f, -0.04001914f, 0.13820508f, 0.06786391f, -0.07636840f, 0.09363474f, 0.02645617f, 0.26521328f, 
    0.08633581f, -0.06223109f, 0.02554799f, 0.13234276f, 0.02600055f, 0.06645561f, 0.02535471f, -0.02797732f, 
    0.41468048f, 0.03300385f, -0.02808931f, -0.01670096f, 0.18863787f, -0.08152182f, -0.01835435f, -0.07977353f, 
    -0.06833387f, -0.15413484f, -0.08431471f, -0.07371584f, -0.47438139f, 0.16444196f, 0.13563511f, -0.00787729f, 
    0.22570899f, 0.08070165f, 0.13438728f, 0.02147611f, 0.04024952f, 0.02060280f, -0.10231797f, 0.00724943f, 
    0.01726575f, -0.06532699f, -0.08998866f, -0.01298775f, -0.14152072f, -0.18345627f, 0.00558597f, -0.06045692f, 
    0.12177008f, 0.04744161f, 0.07040121f, 0.17551519f, -0.15208800f, 0.09825307f, -0.04955545f, 0.08448521f, 
    0.08788022f, 0.09875657f, 0.01501176f, 0.02789694f, 0.04526677f, 0.05643031f, -0.05381312f, -0.01878931f, 
    0.20770282f, 0.19650763f, 0.01657033f, -0.00349980f, -0.10771958f, -0.08544773f, -0.06943613f, -0.09171902f, 
    0.08824848f, 0.02128035f, 0.00079097f, -0.07727466f, -0.04872079f, 0.07627077f, 0.07246065f, -0.11032648f, 
    -0.01121956f, -0.03147990f, 0.02792589f, -0.02555406f, 0.02373853f, 0.05804380f, -0.02166632f, -0.00743861f, 
    -0.02309935f, 0.09536702f, 0.00990046f, 0.11698943f, -0.00674293f, -0.10373196f, -0.08971079f, -0.01964171f, 
    0.08331119f, 0.01521502f, -0.07115180f, 0.03172398f, -0.07648890f, 0.14437473f, 0.01652399f, 0.22166030f, 
    0.10224640f, 0.01871550f, -0.05735533f, 0.15360788f, 0.05221443f, -0.09675403f, 0.02431856f, -0.12068851f, 
    -0.09673619f, 0.04311468f, 0.04036927f, 0.10090882f, 0.02045670f, 0.04024709f, 0.08297986f, 0.17008817f, 
    -0.12284429f, 0.10775803f, -0.09713760f, -0.09424209f, -0.01196704f, 0.12035140f, -0.13427089f, 0.13108285f, 
    0.17535348f, 0.00517569f, -0.00252372f, -0.11738286f, 0.00521860f, 0.09172326f, 0.00309728f, 0.16032052f, 
    -0.05105518f, 0.31510535f, -0.03054534f, 0.03814337f, 0.16917293f, 0.02118218f, 0.11604229f, 0.02955915f, 
    0.00911132f, -0.21888453f, -0.10567396f, 0.02927042f, 0.07694273f, -0.08934756f, -0.08842538f, 0.14642066f, 
    -0.05460197f, 0.02867697f, -0.11803059f, -0.08168877f, -0.01261448f, 0.00653315f, -0.10274735f, 0.01670268f, 
    -0.08062134f, -0.09499536f, -0.02890543f, 0.26350591f, 0.01425632f, 0.08744289f, -0.07451208f, 0.00358371f, 
    0.05160790f, 0.02737833f, 0.02241542f, 0.03025969f, 0.29809365f, 0.08650858f, -0.09988050f, -0.16381156f, 
    0.04409918f, 0.03913108f, 0.07488504f, -0.03521196f, 0.12857130f, 0.00665754f, 0.02631006f, 0.11767171f, 
    -0.40465471f, 0.13432707f, -0.08076472f, -0.18834646f, 0.07501718f, -0.06415232f, -0.00534835f, -0.03859297f, 
    -0.01308554f, 0.00976147f, 0.03050517f, -0.06176331f, 0.00395653f, -0.10016620f, -0.07303266f, 0.20291342f, 
    -0.16446859f, 0.01509798f, -0.05216969f, 0.11466737f, 0.12447083f, -0.07741822f, 0.00524315f, 0.06508757f, 
    0.13090301f, 0.08075304f, 0.06400348f, -0.12978210f, 0.10570787f, -0.17201075f, -0.06421633f, -0.02000836f, 
    0.00471046f, 0.06862635f, 0.14634357f, 0.08951979f, -0.28129098f, -0.01862589f, -0.07553679f, -0.01364858f, 
    0.12224942f, 0.06289186f, 0.04613799f, -0.02222247f, -0.11116593f, -0.04309533f, 0.10615431f, 0.14168242f, 
    -0.13324827f, -0.03987742f, -0.07922305f, 0.05605184f, -0.02144094f, -0.14715977f, 0.11652080f, -0.01050321f, 
    -0.10233061f, -0.05406221f, -0.01878591f, 0.01099437f, -0.20055184f, 0.06422181f, -0.05003627f, 0.02557557f, 
    0.03682576f, 0.03143994f, 0.07729086f, -0.04393745f, -0.08724087f, 0.03492213f, 0.04682791f, -0.12425449f, 
    0.49447733f, 0.45665219f, 0.00094779f, 0.14181352f, -0.00565358f, 0.02732021f, 0.03063684f, 0.08414710f, 
    0.02025299f, 0.03267461f, 0.02796099f, 0.02314501f, -0.03911344f, 0.08810321f, 0.12516825f, -0.07784366f, 
    0.16261768f, 0.03328539f, 0.09420013f, 0.02086036f, -0.08142271f, 0.02273366f, -0.11300803f, -0.00477371f, 
    -0.21524855f, 0.19324581f, 0.10762753f, 0.00150783f, 0.07816727f, -0.04934412f, 0.05954696f, -0.10589089f, 
    -0.02534800f, -0.18806714f, -0.16969797f, -0.15345584f, 0.05387974f, 0.04823310f, -0.10010205f, 0.05197554f, 
    -0.00428813f, 0.04112343f, 0.11017622f, 0.06131488f, 0.02244818f, 0.06499033f, 0.10007972f, -0.00533509f, 
    -0.23740117f, 0.01427370f, 0.07552022f, 0.10567431f, -0.01403700f, -0.18427029f, -0.02401786f, 0.19139604f, 
    -0.05248877f, 0.03200024f, 0.02648643f, -0.01233186f, 0.18108054f, -0.00033328f, -0.05639897f, 0.09885214f, 
    0.20181479f, 0.05982256f, -0.07251051f, -0.06110490f, -0.01192498f, 0.09864178f, -0.05877082f, 0.00680201f, 
    -0.11500154f, -0.31941596f, 0.06784559f, 0.11027423f, -0.07006089f, -0.02136216f, -0.07178136f, 0.02208988f, 
    0.08236692f, 0.09230398f, 0.08622146f, 0.05317069f, 0.16026871f, -0.00288448f, 0.06997711f, 0.06123813f, 
    -0.04058937f, 0.06376220f, 0.16719528f, 0.07949693f, 0.08153713f, 0.05034465f, 0.00394368f, 0.03609704f, 
    0.06947770f, 0.03518899f, -0.14422897f, -0.07300305f, -0.02525660f, -0.10346214f, -0.01564168f, 0.03039782f, 
    -0.03563001f, -0.04820824f, -0.12943672f, -0.03498191f, -0.36335987f, -0.04776659f, 0.11006425f, -0.07668988f, 
    0.01115623f, 0.03117411f, -0.05760168f, 0.07026055f, -0.06044682f, 0.01788334f, 0.09458917f, -0.06693593f, 
    -0.11928280f, -0.07464142f, 0.15828496f, -0.04885420f, 0.00566648f, -0.09305738f, -0.04446695f, -0.00933547f, 
    -0.02654633f, 0.03603005f, 0.07995763f, -0.08703979f, 0.33488703f, 0.18792219f, 0.06429684f, 0.09703644f, 
    0.03157275f, -0.02699530f, -0.10186750f, 0.05317999f, -0.07964569f, 0.09094441f, 0.14584337f, 0.05093318f, 
    -0.14278899f, -0.16873014f, 0.01985646f, 0.10286139f, -0.12865664f, 0.16886292f, -0.09520989f, 0.09378976f, 
    -0.14667101f, -0.05330057f, -0.16959450f, 0.00225736f, 0.03737527f, -0.04901765f, 0.05415113f, 0.03722128f, 
    -0.16538341f, -0.18852638f, 0.00679431f, -0.06241258f, 0.04443263f, -0.08774266f, 0.04503644f, -0.08941865f, 
    -0.00498438f, 0.02057275f, -0.00933219f, 0.11752123f, 0.02007692f, -0.07802104f, -0.01230545f, 0.05921988f, 
    -0.00563876f, -0.04150349f, 0.01891810f, 0.02467160f, 0.20952345f, -0.00610492f, 0.14196253f, -0.01825579f, 
    -0.07952306f, -0.03982998f, 0.07203011f, 0.06374148f, 0.06283530f, 0.14156106f, -0.02251342f, 0.15526563f, 
    -0.20701383f, -0.51064545f, 0.08045146f, -0.01910036f, 0.08855358f, 0.13520917f, -0.12042309f, -0.14157286f, 
    0.17841828f, 0.07082077f, -0.06921495f, -0.01362781f, 0.08875532f, -0.10173266f, -0.13908024f, 0.02555225f, 
    -0.08929364f, 0.10137180f, -0.10653950f, -0.03244022f, 0.22760050f, -0.03394108f, 0.13268360f, 0.12937173f, 
    -0.02544932f, -0.06811520f, 0.02375314f, 0.06018250f, -0.01841138f, -0.03191941f, 0.02598967f, 0.15673645f, 
    0.03118186f, 0.30539224f, 0.01754753f, 0.09229866f, 0.03955432f, 0.25219819f, 0.03805693f, 0.15726411f, 
    -0.05575295f, -0.02487053f, 0.11448116f, -0.08197289f, 0.01689772f, -0.08475233f, 0.02889307f, 0.00017459f, 
    0.21729343f, 0.10294857f, 0.06840373f, -0.12203459f, -0.05418608f, -0.05256758f, 0.20430107f, -0.07711039f, 
    0.08939137f, 0.00931837f, -0.10020112f, 0.01353574f, 0.06456003f, 0.09065218f, -0.15674032f, 0.06728970f, 
    -0.06963080f, 0.02434866f, -0.08192928f, 0.09862118f, 0.05851233f, 0.00919264f, 0.07651052f, 0.00741950f, 
    -0.41522542f, 0.03999510f, 0.08170285f, -0.15566385f, 0.02073737f, -0.01840794f, -0.02286275f, -0.04777797f, 
    0.04796054f, -0.01606840f, 0.07621370f, 0.18915375f, 0.26658261f, 0.11981250f, -0.02197952f, 0.20869568f, 
    0.05005801f, 0.02526917f, 0.02955793f, -0.05918898f, 0.12537158f, 0.07349392f, 0.02303362f, 0.04140512f, 
    0.12012446f, 0.18329778f, -0.09799559f, 0.37933505f, 0.10136212f, 0.03072765f, -0.16708450f, -0.02675913f, 
    -0.09374189f, 0.02489083f, -0.00922421f, -0.00505496f, -0.25293884f, 0.04512898f, 0.11447636f, -0.14580308f, 
    -0.03283957f, 0.00320600f, 0.04100630f, -0.04517665f, -0.09171497f, -0.03556212f, -0.00895739f, 0.11237444f, 
    0.05328400f, 0.00763515f, 0.08174618f, -0.15132214f, -0.04466689f, 0.01105568f, -0.00157960f, 0.05145747f, 
    0.01359012f, 0.00166958f, -0.00189831f, -0.11224028f, 0.35915485f, 0.13587187f, -0.06316989f, 0.26076671f, 
    0.15507072f, 0.01590160f, -0.09398975f, 0.04476514f, 0.02093353f, -0.04113058f, -0.00382939f, -0.07327076f, 
    -0.06990463f, 0.05087984f, 0.00230671f, 0.20609149f, -0.09242672f, 0.19478390f, -0.13421004f, 0.02570974f, 
    0.02064529f, 0.08319279f, 0.01209725f, -0.04231336f, -0.10876428f, -0.03750629f, 0.04777039f, -0.07460403f, 
    -0.05278538f, -0.07800417f, 0.03634085f, 0.01091950f, -0.01572196f, -0.06653789f, 0.11032106f, -0.06338215f, 
    0.08788610f, 0.17845808f, 0.01995668f, -0.01972956f, 0.04868604f, 0.06081953f, 0.05085815f, 0.06714545f, 
    -0.03593880f, -0.06444068f, -0.05421075f, 0.00687130f, 0.24817882f, -0.03106941f, 0.05814221f, 0.01365901f, 
    0.06192970f, -0.00713733f, 0.02222981f, 0.00158666f, -0.05714704f, 0.12321436f, 0.03961241f, -0.03676066f, 
    0.02944487f, -0.07997543f, -0.08837040f, 0.23519383f, 0.09888565f, 0.11177598f, -0.05006137f, -0.01256831f, 
    -0.02066329f, -0.01799415f, -0.14609653f, -0.04443246f, -0.33866271f, -0.04527608f, 0.01212511f, -0.32129756f, 
    -0.08262604f, -0.07037685f, 0.03549373f, 0.03317375f, 0.05201663f, -0.03615507f, 0.09681942f, 0.06681699f, 
    -0.08337007f, 0.01585095f, 0.22514638f, -0.10663996f, 0.00333282f, -0.06697156f, 0.02947065f, 0.09620149f, 
    0.03578319f, 0.07543056f, -0.02234817f, -0.05275897f, -0.04774595f, 0.21757667f, 0.06987724f, 0.00830356f, 
    -0.02578621f, 0.16341169f, 0.15951025f, -0.09230312f, 0.14464936f, 0.00482388f, -0.00993213f, -0.00640758f, 
    0.09882968f, 0.13069145f, 0.12292965f, 0.13335054f, 0.17296131f, 0.01780076f, 0.17759877f, -0.01704916f, 
    0.06398782f, -0.09751508f, -0.16559742f, 0.03867693f, -0.01055356f, 0.12594458f, -0.19853196f, 0.32168001f, 
    0.04618515f, 0.11573814f, -0.13662088f, 0.10506161f, 0.00547445f, 0.06914055f, -0.08070818f, -0.09570365f, 
    0.24643144f, -0.02172481f, 0.11042274f, -0.03665463f, 0.02499242f, -0.11858457f, -0.06326598f, 0.02006484f, 
    -0.02824333f, 0.05401942f, 0.03925924f, -0.04924856f, -0.09093106f, 0.16038255f, -0.08360829f, -0.09225967f, 
    -0.11554290f, -0.04660916f, 0.04360571f, 0.01305681f, 0.14393649f, 0.00137891f, 0.05843701f, 0.14243707f, 
    0.25880790f, -0.22938819f, 0.02372007f, -0.16210277f, -0.03869655f, -0.10831154f, 0.03113247f, 0.09275422f, 
    -0.03593682f, 0.04246291f, 0.09525679f, 0.00788486f, -0.02760777f, -0.17210791f, 0.02271172f, -0.06522731f, 
    -0.06586760f, 0.09829278f, -0.04584725f, 0.13514049f, 0.08952591f, -0.01350852f, 0.04070211f, 0.00411496f, 
    0.33033675f, -0.17716931f, 0.11072160f, 0.25483376f, 0.05739744f, 0.10455047f, -0.06570037f, 0.07317752f, 
    -0.17468572f, 0.07704125f, 0.00870166f, 0.07502612f, 0.16331908f, 0.02225632f, 0.00614745f, -0.10524911f, 
    -0.07929822f, 0.16407028f, -0.00268376f, 0.09046569f, -0.08171251f, 0.02201258f, -0.00177470f, 0.12154542f, 
    -0.27076814f, -0.19237006f, -0.05478961f, 0.02857741f, -0.10784917f, 0.11575336f, 0.18789099f, 0.09720224f, 
    -0.01823726f, 0.07439071f, 0.06128503f, 0.11080637f, 0.41051543f, 0.05783296f, -0.14792679f, -0.09128232f, 
    -0.13200857f, -0.00570342f, -0.07315947f, 0.26072764f, -0.00346954f, -0.08443408f, 0.00384675f, 0.04920211f, 
    0.15128389f, 0.08138101f, 0.14999135f, 0.18954152f, 0.11204629f, 0.18070723f, -0.12036416f, -0.00819641f, 
    0.07134095f, 0.07095307f, -0.07024588f, -0.07223261f, 0.19203606f, 0.03741203f, 0.11138297f, 0.01272458f, 
    -0.02595486f, -0.00261676f, 0.03293531f, -0.02406121f, 0.07328907f, -0.17964938f, 0.14091603f, 0.05054677f, 
    -0.29559335f, -0.10707591f, 0.13901012f, -0.01217575f, 0.12794885f, 0.12580208f, 0.03481121f, 0.05619903f, 
    -0.00513145f, 0.05357546f, 0.10626899f, 0.07939707f, 0.28847313f, -0.18595985f, 0.05691012f, 0.11294398f, 
    -0.04664906f, 0.03162162f, 0.00106299f, 0.15204470f, 0.06049861f, 0.06072377f, 0.04728938f, 0.17949724f, 
    0.08526521f, -0.04337750f, -0.00127057f, 0.21760064f, -0.02075917f, 0.17685397f, 0.03149501f, -0.00774323f, 
    0.02196073f, -0.08506367f, 0.10969285f, 0.02845270f, 0.30339143f, 0.05471469f, 0.06695968f, -0.06182739f, 
    -0.06135349f, -0.11175785f, 0.01250026f, 0.09656117f, 0.09017397f, 0.06877802f, -0.01623780f, 0.08813245f, 
    0.25692773f, 0.17190884f, -0.00988456f, -0.17043243f, -0.02383837f, 0.05605432f, -0.06325132f, -0.10853052f, 
    0.04673081f, 0.08095586f, 0.14756274f, 0.03181679f, -0.00985627f, -0.38041392f, 0.00228298f, -0.16835494f, 
    -0.07014107f, -0.12590244f, 0.01696823f, 0.08308986f, -0.10704073f, -0.09646711f, -0.05243861f, -0.15575269f, 
    -0.36829579f, 0.01355402f, 0.00947931f, -0.02614348f, 0.09461958f, -0.01840764f, 0.04353924f, 0.11125882f, 
    0.08484932f, 0.08527498f, -0.07901850f, 0.09692600f, -0.15229596f, 0.11278103f, 0.24547702f, -0.12010864f, 
    0.05351720f, -0.18495367f, 0.01275760f, -0.02209142f, -0.05785245f, -0.01651629f, -0.07302468f, -0.12800436f, 
    -0.17539249f, -0.01807553f, 0.04422747f, -0.10433834f, 0.10724349f, -0.03087168f, 0.03169922f, -0.06827188f, 
    -0.05817000f, -0.01531339f, -0.04744324f, 0.00934565f, -0.06954857f, -0.03940251f, -0.10584125f, -0.11157029f, 
    0.04686986f, -0.08217649f, -0.09752257f, -0.00560523f, 0.06346393f, 0.05259731f, 0.01864828f, -0.12178513f, 
    -0.10066286f, 0.03682151f, -0.22094004f, 0.10304984f, -0.06453226f, -0.13496432f, -0.04576431f, 0.06630410f, 
    0.03678014f, 0.07793362f, 0.25691694f, 0.03653332f, -0.20340669f, 0.01175814f, -0.15647094f, -0.09010198f, 
    -0.01559275f, -0.00513345f, 0.13440524f, 0.10553557f, 0.03227115f, 0.13760372f, -0.08346886f, -0.06049517f, 
    0.12333593f, 0.00608061f, 0.07720814f, -0.13344890f, -0.00192049f, -0.04701567f, -0.13694185f, -0.03372375f, 
    -0.08328028f, -0.07345231f, 0.08108804f, -0.15658553f, 0.20684732f, 0.07874843f, 0.06836276f, 0.15993065f, 
    0.02357405f, 0.07422134f, -0.00935096f, -0.12004059f, -0.07284651f, 0.15380260f, -0.02345910f, 0.03632156f, 
    0.26473001f, 0.01497130f, -0.26393935f, -0.21850908f, -0.07073026f, -0.14584082f, 0.10502932f, -0.01080787f, 
    -0.06493992f, 0.13316642f, 0.10885058f, 0.11409855f, 0.04393128f, 0.02642039f, -0.06316944f, 0.10210094f, 
    0.09119204f, -0.02318871f, -0.03397457f, -0.07511615f, -0.02180953f, 0.08552851f, -0.10149583f, -0.10365383f, 
    0.15910356f, 0.11316892f, 0.12874165f, 0.02157607f, 0.04152832f, -0.11662071f, -0.05202767f, -0.10030665f, 
    -0.01578015f, -0.01305592f, 0.10428924f, 0.04146311f, 0.14161569f, -0.08193207f, -0.01986595f, 0.12147167f, 
    0.04205551f, 0.00380715f, -0.04417022f, -0.07596131f, 0.09423381f, 0.13912062f, 0.04154022f, 0.04269819f, 
    -0.19000670f, 0.12264208f, 0.01575851f, 0.07453595f, 0.14601159f, 0.01859426f, -0.15162303f, 0.00458070f, 
    -0.01447666f, 0.09167716f, 0.05556550f, 0.12255087f, 0.22712234f, 0.03640969f, 0.08215165f, 0.00917207f, 
    -0.02109816f, 0.10044304f, 0.17252828f, -0.00425893f, -0.04618392f, -0.05270790f, -0.01852576f, 0.05748593f, 
    -0.03365949f, 0.01521377f, -0.00465750f, 0.09606045f, 0.02806195f, 0.05408642f, -0.06662624f, 0.11285593f, 
    0.04228998f, 0.05629039f, 0.09097514f, 0.06418555f, 0.22442405f, 0.07950678f, 0.07890827f, -0.13030723f, 
    0.12669083f, -0.06421528f, 0.10462479f, -0.03708724f, 0.03066645f, 0.08967090f, 0.14891677f, 0.05856140f, 
    0.25793245f, 0.29851785f, 0.17811827f, 0.08670200f, -0.00389872f, -0.11530631f, 0.03817951f, 0.05755512f, 
    0.06990407f, -0.01502142f, 0.03023926f, -0.03542633f, 0.11494711f, 0.01196200f, -0.00288501f, -0.15098809f, 
    -0.13377714f, -0.01417600f, 0.08451619f, -0.14398602f, 0.06451252f, 0.06744268f, -0.11156116f, 0.11704084f, 
    0.18792683f, -0.25090632f, -0.17387386f, 0.18175805f, -0.00729949f, -0.05072241f, -0.00175629f, -0.03812904f, 
    -0.07993674f, 0.07714334f, 0.12933877f, 0.17286277f, 0.21624507f, -0.01520602f, -0.04448203f, -0.28287378f, 
    -0.01302204f, 0.09165862f, -0.00508730f, -0.00312933f, -0.00529699f, -0.04481124f, 0.06486824f, -0.06221789f, 
    -0.32258049f, -0.01463591f, 0.07157306f, 0.10579164f, 0.02760390f, 0.00768217f, 0.02124100f, -0.00585117f, 
    -0.17251542f, 0.09356030f, 0.00997553f, 0.05088659f, 0.24004902f, -0.12490559f, -0.10189810f, 0.11049886f, 
    -0.04932079f, 0.17896667f, 0.06127943f, 0.04050023f, 0.02128301f, 0.03698488f, 0.09019703f, 0.07005268f, 
    -0.22180471f, -0.21216105f, -0.05529002f, -0.05068390f, -0.01220444f, 0.02057461f, 0.02494526f, -0.04555831f, 
    -0.08403756f, 0.02352422f, 0.02339019f, 0.01576598f, 0.27190500f, 0.06798586f, -0.13471445f, -0.07113738f, 
    0.08276474f, 0.07322314f, 0.01067323f, 0.11505690f, -0.03807092f, -0.04855478f, -0.00447501f, 0.08331580f, 
    -0.07953615f, 0.04172527f, 0.03768173f, 0.05485330f, 0.10200144f, 0.05097173f, -0.07664359f, -0.02300810f, 
    0.05436925f, 0.05360221f, -0.06900574f, -0.11045140f, -0.08424519f, -0.01562381f, 0.10705533f, 0.06276122f, 
    -0.03210799f, 0.01997012f, 0.02754064f, -0.00376796f, 0.00993523f, 0.03082212f, 0.04135331f, 0.04141907f, 
    0.05655044f, 0.00251512f, 0.12580553f, 0.14578943f, 0.12957667f, -0.05708154f, -0.04719467f, -0.06594010f, 
    0.08285867f, 0.13924886f, 0.14546444f, 0.01614603f, 0.31084374f, -0.20880131f, -0.01260145f, 0.10737219f, 
    0.02044682f, -0.01311377f, 0.04916120f, 0.08057830f, 0.09541358f, 0.13530254f, -0.10914034f, 0.04654844f, 
    -0.14016519f, 0.01710503f, 0.10138351f, 0.27928898f, -0.07158305f, 0.12401958f, -0.08340718f, -0.00089317f, 
    0.01790360f, -0.06391833f, -0.06734831f, -0.07202303f, 0.24909431f, 0.06644434f, -0.03781956f, -0.01085522f, 
    -0.05026123f, -0.02822286f, 0.13621186f, 0.05549199f, 0.02203600f, 0.05313018f, 0.01447979f, 0.07318977f, 
    0.05991505f, 0.01759689f, 0.03494564f, -0.13571341f, 0.10215162f, 0.09957797f, 0.03737519f, 0.02739209f, 
    0.10957744f, 0.03093671f, -0.01031157f, 0.02276819f, 0.22699052f, -0.30889151f, -0.13137726f, 0.09334652f, 
    0.21401532f, -0.04489231f, -0.05050668f, 0.06008956f, -0.04650234f, 0.06845497f, -0.02657082f, -0.08931264f, 
    -0.32304677f, 0.18453877f, -0.04368514f, -0.19951904f, -0.07510367f, 0.01997155f, 0.03730576f, 0.00949049f, 
    -0.05856133f, -0.05029652f, 0.05220427f, -0.01044131f, 0.23236468f, 0.10041422f, -0.06281315f, 0.18164393f, 
    0.00269032f, 0.03938358f, -0.00365533f, -0.01760391f, 0.00551286f, -0.02542434f, 0.05798332f, 0.08971694f, 
    0.00187753f, 0.12031479f, -0.13866791f, 0.29003248f, 0.09392445f, 0.09988756f, -0.14873868f, 0.14688590f, 
    0.05955438f, 0.07667150f, 0.05894832f, 0.06346124f, -0.15818216f, 0.15000154f, 0.15141065f, -0.25674710f, 
    0.05559767f, 0.02559027f, 0.08484027f, 0.07498533f, 0.00879139f, -0.04636991f, -0.09189483f, 0.01568985f, 
    0.40627298f, 0.04188616f, 0.14345574f, -0.25398543f, 0.10322846f, 0.10059664f, 0.01915437f, -0.05302795f, 
    0.01981360f, 0.08040840f, -0.05639856f, -0.00863178f, 0.02451544f, 0.08215261f, 0.01429897f, 0.18838231f, 
    0.10075517f, -0.05792949f, -0.05725204f, -0.00773707f, -0.15152529f, -0.12745136f, -0.00806387f, -0.04314312f, 
    -0.11449051f, 0.19765076f, -0.09587594f, 0.26161593f, -0.00554903f, 0.11510164f, 0.11976678f, 0.01788814f, 
    0.03711776f, -0.01914210f, -0.07412318f, 0.11318494f, -0.28269601f, -0.23666513f, 0.10015852f, -0.13964482f, 
    0.01941486f, -0.03516379f, 0.02970971f, -0.09820580f, 0.01173822f, 0.00775093f, 0.03024087f, -0.09199578f, 
    0.07431853f, 0.10535026f, 0.19256510f, -0.06113183f, 0.07698169f, 0.15128484f, 0.07861514f, 0.04058561f, 
    -0.04686632f, 0.02753264f, 0.03533402f, -0.01246592f, 0.09420066f, 0.04537313f, 0.07349976f, 0.02132172f, 
    0.03155281f, 0.05549364f, 0.09849986f, -0.04297624f, -0.02863557f, 0.04680225f, 0.12255498f, 0.03371301f, 
    -0.09463368f, -0.10118526f, 0.03249942f, 0.25432456f, -0.01488347f, 0.21756022f, 0.01709712f, -0.04370948f, 
    0.05067865f, 0.01528276f, -0.05336548f, -0.02310639f, -0.18769279f, 0.10135640f, 0.02143462f, -0.31617814f, 
    0.08930515f, -0.00778687f, 0.11114196f, -0.04565899f, 0.04709020f, -0.10988740f, 0.09841177f, -0.07070436f, 
    0.03898977f, -0.08317802f, 0.09816447f, -0.15659387f, 0.09817719f, -0.03262344f, 0.13894778f, 0.07651670f, 
    0.06076277f, -0.04652141f, 0.00823845f, -0.01774659f, -0.32460785f, -0.00179231f, 0.03921051f, -0.13697016f, 
    0.01266012f, 0.04468443f, 0.01291475f, -0.05171569f, 0.05462708f, 0.03265878f, 0.06946361f, 0.00806598f, 
    -0.05109888f, 0.00743185f, -0.04510798f, -0.03417777f, 0.07581764f, 0.01928633f, -0.03278561f, -0.06686490f, 
    0.07459880f, 0.04071532f, 0.06888893f, 0.07046466f, -0.17399652f, 0.11957249f, -0.07632484f, 0.34074092f, 
    -0.00570899f, 0.03988869f, 0.03700170f, 0.08295947f, 0.03146071f, 0.03331761f, -0.14570852f, -0.11203475f, 
    -0.03808894f, 0.02210412f, -0.01133345f, -0.07410295f, -0.06627682f, 0.03192183f, -0.00004181f, 0.05415807f, 
    0.03299848f, 0.03690977f, 0.06190787f, 0.00594747f, -0.05249195f, -0.07442893f, 0.00441883f, -0.04399891f, 
    -0.05578299f, 0.02236102f, -0.03924109f, -0.05774553f, 0.01307488f, 0.06711447f, -0.06431478f, 0.03960610f, 
    0.01371628f, -0.04817108f, 0.06154984f, 0.03690474f, 0.02387323f, 0.03422014f, -0.03518172f, -0.02988946f, 
    0.05508244f, 0.04740029f, 0.05421896f, 0.04173966f, 0.01676358f, 0.05257421f, -0.05350249f, -0.00550740f, 
    -0.03075608f, 0.03611440f, -0.04576429f, -0.06765208f, 0.01313393f, -0.01917502f, 0.05868254f, -0.05632547f, 
    -0.05174326f, -0.00534189f, 0.05289290f, 0.03500755f, 0.01569402f, -0.06981069f, 0.06239003f, -0.06925511f, 
    -0.02013541f, -0.06933068f, -0.05614049f, -0.00896727f, 0.03852171f, -0.05708326f, -0.02189696f, -0.07539140f, 
    0.06216349f, 0.04910647f, 0.00041294f, 0.04390534f, 0.04380476f, 0.00960443f, -0.02932477f, 0.00072369f, 
    0.03390061f, -0.01023507f, -0.05808834f, 0.02571783f, -0.05999200f, 0.01989046f, 0.04707778f, -0.01639450f, 
    -0.04421785f, -0.06182076f, -0.06737301f, -0.00919100f, 0.01798170f, -0.04792692f, -0.05178881f, -0.03125944f, 
    -0.03596632f, -0.01474766f, -0.01655543f, -0.06024365f, 0.04059380f, -0.04157811f, -0.06553194f, -0.06950118f, 
    -0.03124410f, 0.02311470f, 0.04454275f, -0.03068253f, -0.04846693f, -0.01335161f, -0.02356284f, -0.06484371f, 
    -0.00349178f, -0.07238504f, 0.00823973f, 0.02171431f, 0.03076497f, -0.03069292f, -0.03520369f, -0.04161622f, 
    -0.03117385f, -0.02778794f, -0.07716877f, -0.03926663f, 0.03224077f, -0.03713630f, -0.02061754f, 0.02264996f, 
    0.03181412f, -0.00696052f, -0.05426751f, -0.03942152f, 0.00669440f, 0.03656259f, -0.03774703f, 0.05512265f, 
    -0.00109508f, -0.02575257f, -0.01228553f, -0.05794099f, 0.00109452f, -0.03739398f, -0.04410930f, -0.02274198f, 
    0.01131998f, -0.00964237f, 0.05305914f, 0.04516823f, -0.00739569f, 0.00648556f, -0.06755850f, -0.00211175f, 
    0.00134237f, 0.04196388f, -0.02423343f, 0.04112593f, -0.00186751f, -0.00323081f, -0.05889928f, 0.01366592f, 
    -0.00380178f, 0.01654203f, -0.01444796f, -0.04142264f, 0.05842731f, 0.01228319f, -0.02108261f, -0.02038268f, 
    -0.04473600f, 0.03521735f, 0.04188770f, -0.05255168f, 0.05599413f, -0.08007678f, 0.00654452f, 0.03763732f, 
    0.00773423f, -0.02511556f, -0.07020514f, -0.05964505f, -0.06247054f, 0.06177965f, -0.01177415f, 0.03356615f, 
    0.00226345f, -0.02895025f, -0.06293931f, 0.06005124f, -0.04901411f, 0.05001868f, -0.04316958f, 0.06450414f, 
    -0.00346901f, -0.02607314f, -0.05121061f, 0.00026665f, -0.01324233f, -0.00867429f, 0.06825255f, 0.00615501f, 
    0.03690951f, -0.03244808f, -0.01532213f, 0.00320929f, 0.01114270f, -0.01743286f, -0.07549534f, -0.02349795f, 
    0.05629422f, 0.03612354f, 0.05325643f, -0.02769510f, 0.00219959f, -0.07358821f, 0.04677497f, -0.04863773f, 
    0.03387769f, -0.01300667f, -0.07169440f, 0.01799507f, -0.05464540f, 0.04871479f, 0.04799784f, -0.00653574f, 
    -0.01612699f, -0.04784869f, -0.03985509f, -0.01046458f, 0.00467299f, -0.04205498f, 0.05972258f, -0.05187686f, 
    0.05924483f, 0.04574026f, 0.02668699f, 0.04027978f, 0.03153934f, -0.06892934f, 0.03505106f, 0.01972694f, 
    -0.05948570f, -0.01595886f, -0.00787996f, 0.03985656f, -0.01591031f, 0.02521664f, -0.02792848f, 0.02325748f, 
    0.03793452f, -0.04610955f, -0.05446196f, -0.02916944f, -0.03919689f, -0.00382269f, 0.00966684f, 0.01895066f, 
    0.06553779f, -0.01981599f, -0.04843744f, -0.06114685f, -0.07405531f, -0.05417236f, -0.01274806f, -0.05750406f, 
    -0.04926207f, -0.01176779f, -0.05620949f, -0.04791033f, 0.06051260f, -0.05230075f, 0.05459923f, -0.05792199f, 
    0.02350941f, -0.06118604f, -0.07286106f, 0.04595098f, -0.03332585f, -0.01225343f, -0.01338223f, 0.02907012f, 
    -0.05439823f, -0.01211896f, 0.05620321f, -0.01842194f, -0.02243567f, 0.03519161f, -0.01492388f, -0.06996945f, 
    0.01535071f, 0.01016255f, -0.05898973f, -0.06132431f, -0.01743579f, 0.03948218f, -0.00327770f, -0.04120437f, 
    0.05997340f, -0.05106345f, -0.04581500f, 0.00650556f, -0.03229322f, 0.03053206f, -0.01609487f, -0.03195516f, 
    -0.04456891f, -0.05552984f, -0.05924568f, -0.02229196f, -0.03685554f, -0.07320746f, -0.00390677f, 0.04871343f, 
    0.01428370f, 0.00897986f, 0.01027933f, 0.04418851f, 0.00301593f, -0.03785564f, -0.03237256f, 0.03040294f, 
    0.01618919f, -0.06015551f, -0.04978130f, -0.00953386f, -0.00068235f, -0.06339952f, 0.03856501f, -0.06845859f, 
    0.05119659f, -0.05763149f, -0.07163947f, 0.03924210f, 0.02537985f, 0.02538791f, -0.03970517f, -0.02847727f, 
    -0.04293836f, -0.04148201f, 0.03397414f, 0.02921237f, 0.00586447f, 0.06263101f, -0.03265873f, 0.05907048f, 
    -0.03559071f, -0.06148003f, -0.00930212f, 0.01706224f, 0.03476726f, 0.02917028f, -0.05097804f, -0.01392054f, 
    0.03581126f, -0.03239621f, 0.00284299f, -0.06984221f, -0.04230497f, -0.01662230f, -0.03413192f, 0.06321453f, 
    0.04944174f, -0.05913919f, 0.05837543f, 0.05947701f, -0.03537855f, -0.03340933f, -0.03991760f, 0.04541212f, 
    0.00628865f, -0.05300206f, -0.01240673f, -0.05589838f, -0.02606621f, 0.05874576f, -0.04863188f, -0.07287475f, 
    -0.03916718f, -0.04295725f, -0.06681772f, -0.06034911f, 0.01483800f, -0.04521257f, 0.00701181f, -0.05246798f, 
    -0.04305370f, -0.02109713f, 0.03968805f, -0.01926147f, -0.07507507f, -0.05263137f, -0.06634820f, 0.03527447f, 
    0.04203929f, -0.07656366f, 0.05984125f, 0.04258235f, 0.00015738f, 0.01644601f, -0.04126740f, -0.06463101f, 
    0.01028656f, -0.00644053f, -0.00582263f, -0.07102512f, -0.01754075f, 0.01362816f, -0.01214354f, -0.04245245f, 
    0.06035157f, -0.01108965f, 0.06196652f, 0.05838344f, 0.02314379f, -0.05143860f, 0.02217969f, 0.01508853f, 
    0.00187249f, -0.07222988f, -0.06082484f, 0.00883830f, -0.06370120f, -0.04608433f, 0.05831932f, -0.00922677f, 
    0.00377830f, -0.04303599f, 0.04477739f, -0.03543334f, 0.02231220f, -0.06163944f, -0.07918534f, 0.03103911f, 
    -0.06081720f, -0.05814391f, 0.00583602f, 0.02382092f, 0.03339709f, -0.06249677f, 0.04885507f, -0.07415714f, 
    0.00384893f, 0.02224916f, -0.03296065f, -0.01286060f, 0.05583332f, -0.07686029f, 0.06148700f, -0.04359670f, 
    -0.06935920f, -0.07539812f, -0.04501893f, -0.05950621f, -0.01845653f, 0.06081831f, -0.01695144f, 0.03956919f, 
    -0.04411938f, 0.05577581f, -0.01341877f, -0.07787759f, -0.01331891f, -0.04698073f, 0.00485688f, -0.00781436f, 
    0.02677024f, -0.07842286f, -0.05614701f, -0.00887801f, 0.01378131f, 0.05715536f, 0.02661300f, -0.06740658f, 
    0.04918587f, -0.05733782f, 0.05268229f, -0.00576326f, -0.02173586f, -0.01985276f, 0.03455166f, -0.02694283f, 
    0.06371602f, -0.01537795f, -0.05575961f, 0.00787065f, -0.05359467f, 0.02549469f, 0.03158340f, -0.01449832f, 
    -0.06661830f, -0.04400707f, 0.03250431f, 0.03679861f, -0.02877706f, 0.05807063f, 0.02869598f, -0.02754050f, 
    -0.02845763f, 0.03168356f, 0.05782356f, 0.00767845f, -0.00009775f, -0.03680296f, 0.05611308f, -0.03543655f, 
    0.03991763f, -0.03674762f, -0.07087710f, -0.02202763f, -0.05444038f, -0.05549925f, 0.04792352f, 0.06255792f, 
    -0.06257139f, -0.05435071f, 0.02274247f, 0.05124402f, 0.05787824f, 0.05925309f, -0.06042545f, -0.06919515f, 
    0.00110935f, 0.05750680f, -0.01324745f, 0.01455577f, -0.04462279f, -0.05360950f, -0.02620948f, 0.03603879f, 
    -0.07618385f, -0.03632383f, 0.01119437f, -0.06463080f, -0.00734692f, -0.05892098f, 0.05850538f, -0.01161522f, 
    0.06274404f, 0.01488764f, -0.03353100f, 0.00099286f, -0.07319520f, -0.07425127f, -0.00378212f, -0.01573152f, 
    -0.03566437f, 0.03085136f, -0.06804615f, 0.05278230f, -0.05678356f, 0.02946122f, -0.02277249f, -0.00492864f, 
    0.06067307f, -0.00143639f, -0.02912129f, 0.05758467f, -0.05102925f, -0.03753240f, 0.03600482f, 0.01046886f, 
    0.01235444f, 0.06327275f, -0.01699700f, -0.02480952f, -0.06458274f, -0.03124269f, 0.03114141f, -0.06172712f, 
    -0.06464323f, 0.01108044f, -0.06117617f, 0.00328741f, -0.02682884f, -0.03333937f, -0.05311377f, -0.07690707f, 
    -0.06621166f, -0.05809653f, -0.02193884f, -0.00402689f, -0.06737547f, -0.01022745f, -0.00964455f, 0.03621245f, 
    0.08236471f, 0.07595591f, 0.22487429f, 0.19963396f, 0.06308392f, 0.08504666f, 0.01297182f, -0.08804478f, 
    -0.00249730f, -0.02621629f, -0.18048660f, 0.19489112f, -0.33451131f, -0.17500089f, 0.03691137f, 0.05675804f, 
    -0.02210882f, -0.03286937f, -0.00224551f, 0.09722243f, -0.00334790f, -0.09095882f, 0.05690046f, 0.03715279f, 
    0.01403046f, 0.16311300f, -0.01763144f, -0.08405924f, -0.00283972f, 0.01325024f, 0.11863580f, -0.10352118f, 
    0.08893338f, 0.03671746f, -0.17151868f, 0.05946561f, 0.21185750f, 0.05290848f, 0.21941762f, 0.23031232f, 
    0.03781656f, 0.13790841f, -0.17157155f, -0.04913179f, 0.03325131f, -0.05858468f, 0.18850452f, -0.00220509f, 
    -0.03262980f, 0.03254996f, 0.24469839f, -0.01088537f, 0.10678709f, 0.01963187f, 0.10246584f, 0.00978674f, 
    0.08817655f, -0.08111082f, -0.01263334f, 0.05817315f, -0.17454685f, 0.10532712f, -0.09422068f, -0.00487883f, 
    0.08316975f, -0.09301932f, -0.02535925f, 0.03546650f, 0.09447877f, 0.04652566f, 0.09098081f, -0.04939878f, 
    -0.25615430f, -0.17674807f, 0.05475688f, -0.10655247f, -0.12945355f, 0.08524525f, -0.06457794f, 0.10669506f, 
    0.02119372f, -0.03397798f, -0.13550872f, 0.03019148f, -0.16471894f, -0.07174110f, 0.09005589f, -0.10984064f, 
    0.04223966f, 0.10662178f, 0.00698272f, 0.02048929f, -0.02591289f, 0.02278186f, -0.00431762f, -0.09809192f, 
    0.01096014f, 0.02379190f, 0.03059435f, -0.08293338f, -0.00637420f, -0.07527040f, 0.09395978f, -0.07615184f, 
    -0.01642296f, 0.11854143f, 0.08253046f, -0.01623327f, -0.04814160f, -0.13969806f, -0.14574251f, -0.12618291f, 
    0.07613360f, 0.09808874f, -0.05066482f, 0.01906330f, 0.04391023f, 0.04798919f, -0.08875468f, 0.03330809f, 
    -0.15930733f, 0.03409553f, -0.10483938f, -0.01525269f, -0.01516975f, 0.05918629f, 0.02662427f, 0.04270533f, 
    -0.04721308f, -0.05917654f, -0.09641343f, 0.04855105f, 0.08143453f, -0.00105971f, 0.24203201f, 0.14407778f, 
    -0.00766334f, 0.08226828f, -0.01701213f, -0.05472884f, 0.04397556f, -0.07126565f, -0.06913986f, 0.08500312f, 
    -0.02655129f, -0.32107392f, -0.06322469f, 0.06990809f, 0.05445134f, -0.13694303f, -0.02077653f, 0.22609191f, 
    0.11056747f, 0.22136030f, 0.14574994f, -0.14618354f, -0.38120452f, 0.04614972f, 0.05311079f, -0.18785509f, 
    0.15651366f, 0.15762958f, 0.09792221f, 0.05549896f, -0.03389026f, -0.02436436f, 0.07189900f, 0.10780460f, 
    -0.23546870f, -0.27161643f, 0.10177246f, -0.18872187f, 0.18093851f, -0.11507656f, 0.27200106f, -0.00700390f, 
    -0.09595678f, 0.04715249f, 0.02248227f, 0.00529478f, 0.20178960f, 0.18325630f, -0.21803086f, -0.02569508f, 
    -0.10277095f, -0.01044828f, 0.00083049f, -0.08147835f, 0.04269333f, 0.01264380f, 0.02720610f, 0.08719852f, 
    0.06007904f, -0.06985614f, 0.05979102f, -0.01781261f, 0.02900917f, -0.05962450f, -0.07505098f, 0.05728814f, 
    -0.04820292f, -0.05880078f, -0.04119547f, 0.05081042f, -0.03189602f, 0.06596562f, 0.00205547f, -0.06983953f, 
    -0.03980990f, -0.00230208f, -0.07064145f, -0.03641309f, -0.04100378f, -0.00354563f, 0.06003926f, -0.07343347f, 
    -0.03107673f, 0.04666101f, 0.06720647f, -0.01203597f, -0.06821918f, -0.01087331f, -0.00418322f, -0.04305663f, 
    0.04030918f, -0.05998613f, 0.04347515f, -0.05208815f, -0.01929598f, -0.04747294f, 0.06293947f, -0.04543188f, 
    0.01397957f, 0.01943670f, -0.07447327f, -0.00390042f, 0.03927309f, -0.01834938f, 0.04929280f, -0.06339180f, 
    -0.03159494f, -0.02653856f, -0.03756011f, 0.01712135f, 0.01962066f, -0.05717848f, -0.05264477f, -0.02165924f, 
    -0.03001753f, 0.06168747f, 0.01775654f, 0.02568555f, -0.08057318f, 0.02018056f, -0.02421455f, 0.00282298f, 
    -0.02447930f, -0.01765477f, 0.04850781f, 0.01245628f, -0.07062004f, -0.07366277f, -0.02614069f, 0.01108329f, 
    -0.06877564f, 0.03610602f, -0.06457238f, 0.02515057f, 0.05347558f, 0.01891465f, -0.04310158f, 0.03808436f, 
    -0.03112998f, 0.05220091f, -0.00697857f, -0.06579692f, -0.06076241f, 0.00178430f, -0.06725609f, -0.07104541f, 
    0.05231858f, 0.04554318f, -0.05213019f, -0.01390369f, -0.05514700f, -0.04626176f, 0.04702860f, 0.00317329f, 
    0.02528794f, 0.01865898f, 0.00261221f, -0.03701734f, 0.04185523f, 0.02556302f, 0.04966523f, -0.01399061f, 
    0.02192724f, 0.01027884f, -0.04765477f, 0.03589664f, -0.02608378f, -0.05192031f, 0.05369743f, 0.05609898f, 
    0.04245714f, -0.00312762f, -0.06384379f, -0.00132407f, 0.03716015f, -0.00781202f, -0.06442847f, -0.06610094f, 
    -0.04706302f, -0.00953232f, 0.01501128f, 0.02200568f, 0.04449591f, -0.01088372f, -0.05617878f, -0.05090776f, 
    0.02388725f, -0.04739816f, -0.05941532f, -0.05298547f, -0.06571429f, 0.03858755f, 0.05512882f, -0.04623272f, 
    0.00918493f, 0.01395112f, -0.03817530f, -0.06866115f, -0.04734517f, -0.07506821f, 0.02280229f, -0.01283272f, 
    0.06372655f, 0.05426417f, -0.05453052f, -0.05779360f, -0.03046304f, 0.06483714f, -0.06599391f, 0.03032627f, 
    0.06379880f, 0.06113068f, -0.05671443f, 0.01522547f, 0.01108120f, -0.05462943f, 0.04598541f, -0.00870787f, 
    -0.02983880f, -0.01741857f, 0.00593878f, -0.01211798f, 0.03406864f, -0.03765436f, 0.03293166f, 0.03532055f, 
    -0.07263736f, -0.02071898f, -0.03414267f, 0.02915519f, 0.06220157f, 0.05517069f, -0.05689109f, 0.01525534f, 
    -0.05385692f, 0.03672242f, -0.00676984f, -0.06245659f, 0.00068609f, 0.01956676f, -0.01603597f, -0.01079058f, 
    -0.05421247f, 0.03905854f, -0.00381348f, 0.06195011f, 0.05331759f, -0.07368160f, -0.03706694f, -0.00206421f, 
    -0.01838272f, -0.00847644f, -0.01245921f, -0.07724190f, -0.06635603f, 0.04226862f, -0.04699226f, 0.01139506f, 
    -0.01261374f, -0.00134082f, 0.00674031f, -0.07927768f, 0.05990733f, -0.06396227f, 0.00853943f, -0.08223641f, 
    0.00267093f, 0.00861455f, -0.02510782f, -0.05834035f, -0.00632437f, 0.03141902f, 0.01918596f, 0.02608985f, 
    -0.02621032f, 0.00735518f, -0.01011845f, 0.05416733f, 0.02408094f, -0.03848251f, -0.04923149f, -0.06232484f, 
    0.01979910f, 0.04191583f, 0.02537211f, 0.05176648f, 0.04887336f, -0.00780332f, -0.02775672f, -0.06666586f, 
    0.04310387f, -0.02978070f, -0.06468496f, -0.00822152f, -0.01103377f, 0.05795620f, -0.00390819f, -0.00619749f, 
    -0.01438612f, -0.04228916f, -0.06053083f, -0.02635364f, 0.04283658f, 0.01262353f, -0.08288535f, 0.04472943f, 
    0.02982845f, 0.01672399f, -0.00248776f, 0.02970784f, 0.01303179f, -0.01609553f, -0.00670606f, -0.02021671f, 
    -0.00308675f, 0.05733952f, -0.01314247f, -0.00221224f, -0.00881203f, -0.00223284f, 0.03517671f, -0.02014483f, 
    -0.03718704f, -0.03450119f, 0.01036623f, 0.04072760f, 0.01791907f, -0.04420762f, 0.05943785f, -0.00977028f, 
    -0.07317343f, 0.02050036f, 0.01217732f, 0.02034872f, 0.02740769f, 0.02129146f, 0.03638160f, 0.06276643f, 
    0.01462922f, 0.03545163f, 0.00933063f, 0.05101310f, -0.04333068f, -0.06497475f, -0.03789527f, -0.06935961f, 
    0.04183057f, 0.04097693f, -0.06531208f, -0.05269043f, -0.03989332f, 0.04221100f, 0.01545807f, 0.04706482f, 
    -0.02304724f, -0.03968887f, 0.03492395f, -0.05819548f, -0.04952291f, 0.02855382f, 0.00013680f, -0.03820214f, 
    -0.07469884f, -0.06934623f, -0.02911822f, -0.04691702f, -0.04647562f, -0.01740394f, 0.01788246f, -0.00367831f, 
    0.00099333f, -0.04393733f, -0.03456490f, -0.03322157f, 0.05799321f, 0.04774442f, -0.03684305f, -0.01775158f, 
    0.01660695f, -0.04976169f, 0.00019403f, 0.00059127f, -0.05005750f, -0.01574542f, -0.03425389f, 0.01416884f, 
    -0.00840430f, -0.07969593f, -0.01212476f, -0.01271701f, -0.03459261f, -0.02065688f, 0.05597655f, 0.01824765f, 
    -0.03018039f, -0.01455358f, 0.04491202f, -0.03667647f, 0.01782499f, 0.02484528f, 0.03380243f, -0.00145514f, 
    0.05184583f, 0.05152590f, -0.07169344f, -0.00491573f, 0.00185544f, -0.05226326f, -0.05339434f, -0.01303754f, 
    0.04097199f, -0.06861470f, -0.04081096f, -0.07439747f, 0.03633421f, -0.03781682f, -0.05238732f, -0.06547869f, 
    -0.02676046f, -0.03440388f, 0.03640480f, 0.03886253f, -0.06887442f, -0.06284145f, 0.01988495f, -0.03501164f, 
    -0.01935326f, 0.05988239f, -0.04269625f, -0.02910169f, 0.05656780f, 0.05464422f, -0.06280315f, -0.03270800f, 
    -0.05292124f, -0.07262673f, -0.07653771f, 0.00089536f, -0.02307791f, -0.03517749f, -0.07252446f, -0.00955989f, 
    -0.03186756f, -0.05424710f, -0.07201436f, 0.02478948f, 0.06619751f, -0.02494728f, 0.00332007f, 0.04359251f, 
    -0.02155502f, 0.04984222f, -0.07340642f, -0.06111748f, -0.00201438f, -0.02251142f, 0.03092042f, 0.04221814f, 
    0.04450979f, -0.05629252f, -0.00853825f, -0.06792483f, -0.01188218f, -0.07670397f, -0.00102004f, 0.05308714f, 
    0.01869747f, -0.07729325f, -0.00013459f, -0.06303103f, 0.01310357f, 0.04171010f, -0.05861850f, 0.01741089f, 
    0.05253456f, 0.04450976f, -0.06269669f, -0.01603783f, -0.03617351f, -0.02717728f, -0.06605184f, -0.00087710f, 
    -0.02973925f, -0.06817882f, -0.06617030f, -0.04477143f, -0.03875308f, -0.05685915f, 0.05657366f, -0.04455421f, 
    -0.06876691f, -0.02489452f, -0.06986172f, -0.03309877f, 0.00004793f, 0.03187484f, -0.03988459f, -0.05739754f, 
    -0.00287985f, 0.00156113f, -0.06987193f, -0.02342187f, -0.03997024f, 0.04039312f, 0.03794263f, -0.03015716f, 
    -0.06063933f, 0.05603410f, 0.03454538f, -0.04466709f, 0.01384597f, -0.03047685f, -0.07287259f, -0.03905966f, 
    -0.05834540f, -0.01042163f, -0.01211463f, -0.04002327f, -0.00068050f, -0.01096136f, 0.02848429f, -0.06104841f, 
    -0.00491718f, -0.03693361f, 0.02347684f, 0.00551832f, 0.05095581f, 0.05538364f, 0.06057864f, 0.02702310f, 
    0.01594198f, -0.01000468f, 0.04527074f, 0.01369391f, -0.07296319f, 0.01450519f, 0.05004291f, 0.04630277f, 
    0.05380099f, 0.04506342f, -0.04185999f, 0.04912705f, -0.07071657f, 0.03479043f, 0.05755041f, -0.04202402f, 
    -0.06702130f, -0.01829444f, -0.02557516f, -0.07249874f, -0.05214512f, 0.01030088f, -0.02737543f, -0.04134514f, 
    -0.06276200f, -0.04472103f, -0.05010979f, -0.05131593f, -0.06069091f, -0.05550428f, -0.03899362f, 0.02646956f, 
    0.02396364f, -0.02856559f, 0.04603415f, 0.04189723f, -0.06142149f, 0.02198990f, 0.03215094f, -0.05601916f, 
    -0.01465270f, 0.00017527f, -0.04499478f, 0.05250642f, -0.02081334f, 0.05255938f, -0.07680388f, 0.06042213f, 
    -0.06671720f, -0.06632457f, 0.00525130f, -0.05735569f, -0.00835467f, -0.00850147f, 0.04088639f, -0.00622227f, 
    -0.04568142f, 0.06212635f, -0.01832843f, -0.04956459f, 0.05795071f, -0.02918768f, 0.03846189f, -0.06288754f, 
    -0.00404608f, -0.04502144f, -0.01964386f, 0.06479192f, -0.00374664f, 0.06182485f, -0.02292861f, -0.03308909f, 
    0.03211932f, 0.06616974f, 0.00159806f, 0.03485992f, -0.00445122f, 0.05939518f, 0.01606378f, -0.00072641f, 
    -0.06211285f, 0.01932863f, 0.00819552f, 0.02219499f, 0.02297024f, 0.04046013f, 0.03528026f, 0.00745566f, 
    -0.02807807f, -0.01263516f, 0.01045480f, 0.00522860f, 0.04652302f, -0.06015314f, 0.03937689f, 0.01681526f, 
    0.04073402f, -0.07916390f, -0.06755532f, -0.02947277f, -0.02017985f, -0.05919535f, 0.06793273f, -0.06835849f, 
    0.08595851f, 0.06577043f, 0.07755305f, 0.12089283f, 0.15389535f, 0.24102147f, 0.06980155f, 0.09189920f, 
    0.00792286f, -0.06571800f, 0.20477936f, 0.16738652f, 0.11729094f, 0.00181174f, -0.03931986f, 0.13730088f, 
    -0.16925873f, 0.08467718f, -0.08199770f, -0.05986151f, -0.06676039f, -0.13954848f, 0.08606722f, -0.20960961f, 
    0.07590771f, -0.08000310f, 0.06671694f, 0.14722650f, -0.02451095f, -0.06349616f, 0.04477331f, 0.05481195f, 
    -0.03246142f, -0.07105616f, -0.06196875f, -0.08729248f, -0.11855024f, -0.15100430f, 0.08463586f, -0.05080820f, 
    -0.02759746f, 0.15950316f, 0.02325737f, 0.09931215f, -0.14291175f, 0.01437103f, 0.13485628f, 0.11902277f, 
    -0.19564000f, 0.14546730f, 0.09100265f, -0.09545187f, 0.11441290f, 0.03259299f, 0.02354762f, 0.03682135f, 
    0.05343764f, 0.06125915f, -0.09200874f, 0.06644724f, -0.02965863f, -0.10890264f, -0.05120493f, 0.13219027f, 
    -0.00458560f, 0.04421940f, 0.06457885f, 0.08964903f, 0.14240174f, -0.07786734f, 0.02528493f, -0.07423218f, 
    -0.08740602f, -0.01257146f, 0.05325327f, 0.24844721f, 0.05889916f, -0.08561394f, -0.22354813f, -0.11442838f, 
    -0.06919605f, -0.03450389f, -0.18078831f, -0.17413129f, -0.41477153f, -0.04888695f, 0.22195882f, 0.02276193f, 
    0.00107164f, 0.17436112f, 0.00625796f, 0.16035962f, 0.04854544f, -0.05428433f, -0.04118147f, -0.18900955f, 
    -0.16990213f, -0.19578008f, 0.04188962f, 0.24890104f, -0.03108576f, -0.04799340f, -0.00990439f, -0.04771288f, 
    0.11788017f, 0.08167599f, 0.03692073f, 0.13820758f, -0.34800163f, 0.09086686f, 0.17560193f, -0.00844457f, 
    0.08142075f, -0.12573405f, 0.00267799f, -0.06168211f, 0.04111397f, 0.01046345f, 0.03108756f, -0.00004324f, 
    -0.11007680f, -0.02844132f, -0.31465033f, -0.16745396f, -0.03611390f, 0.04936755f, -0.05236794f, 0.02077004f, 
    0.13375451f, 0.00544282f, -0.11965459f, -0.08222199f, 0.01526745f, -0.00402599f, 0.14615351f, 0.01760566f, 
    0.16437814f, 0.01262198f, 0.17749199f, 0.06637612f, -0.14233509f, 0.02168948f, 0.04184104f, 0.09455310f, 
    -0.13235550f, -0.06132785f, 0.08310434f, 0.05717295f, -0.14744675f, -0.09102130f, -0.06065603f, 0.08474474f, 
    0.15453358f, 0.15434171f, 0.03431039f, -0.03872799f, -0.32068995f, 0.06512606f, -0.02653148f, 0.07093243f, 
    -0.10506893f, 0.05161124f, -0.00397603f, 0.00027396f, 0.11890060f, 0.12149878f, 0.08372012f, -0.05073250f, 
    -0.06921026f, -0.01397396f, 0.07121436f, -0.17475045f, 0.06020521f, -0.10539487f, 0.18880500f, -0.02273470f, 
    -0.08698860f, 0.03507030f, -0.12422951f, -0.22835577f, -0.07799423f, 0.03026116f, -0.04046758f, 0.19161722f, 
    0.01941138f, 0.08540719f, 0.04819265f, 0.06805914f, 0.05310968f, 0.02178875f, 0.02030330f, 0.16227148f, 
    0.31929648f, 0.07140911f, 0.04238819f, 0.11787120f, -0.09869701f, -0.03116765f, 0.08359268f, -0.04325240f, 
    0.02830313f, -0.22050469f, -0.02531336f, 0.09630179f, -0.14764965f, -0.28278431f, -0.10782053f, 0.03509761f, 
    -0.05339970f, 0.06783921f, -0.07252600f, 0.02477275f, 0.00456223f, 0.05525378f, -0.05371044f, 0.07810519f, 
    0.16524377f, 0.10245446f, 0.11557297f, -0.09303442f, 0.07950708f, -0.02691560f, 0.08143051f, 0.04888979f, 
    0.08447379f, 0.01418201f, -0.00924296f, 0.04394214f, 0.17193443f, -0.12683673f, 0.11975679f, 0.14506872f, 
    -0.03171759f, 0.02265162f, -0.05716258f, -0.04536649f, 0.03617773f, -0.01288825f, 0.11498746f, 0.02054073f, 
    -0.40448350f, 0.02568420f, 0.29168633f, 0.10248089f, 0.05662233f, 0.04324301f, 0.09312995f, -0.00014920f, 
    0.05741109f, -0.04966164f, 0.03974951f, -0.05048302f, 0.11514341f, -0.02564029f, 0.12445220f, 0.18739620f, 
    0.03958166f, 0.07771461f, -0.04273314f, 0.03964964f, 0.04339406f, 0.09864964f, 0.06338701f, 0.06244292f, 
    -0.05900938f, -0.21030913f, -0.03118438f, -0.22419015f, 0.02147561f, -0.06106249f, -0.15368836f, -0.16206764f, 
    0.00354711f, 0.15295964f, -0.00064703f, -0.03482636f, -0.24538720f, 0.20207503f, -0.12291256f, -0.12501861f, 
    0.00652797f, 0.00624576f, 0.06217773f, -0.07516160f, -0.02848312f, 0.07487796f, 0.02171814f, -0.00967859f, 
    0.10931070f, -0.05777475f, 0.04331814f, 0.03922519f, 0.14959478f, 0.04881472f, 0.18604141f, 0.01667838f, 
    0.04607339f, 0.01683420f, 0.03494569f, 0.12896182f, -0.13991532f, -0.09175433f, -0.21458106f, 0.04328429f, 
    0.01327096f, -0.08708207f, -0.00574019f, -0.03888194f, -0.03516127f, 0.09182874f, -0.09056071f, -0.02667732f, 
    0.25094363f, 0.09501417f, 0.02907687f, 0.05636823f, 0.04318773f, 0.02096855f, 0.18562220f, 0.07311836f, 
    0.04350412f, 0.03742588f, -0.02958680f, 0.06535207f, 0.04584594f, -0.13439874f, 0.22485630f, 0.06409306f, 
    -0.09555585f, 0.08098681f, 0.10240135f, 0.05059940f, -0.00425399f, -0.09151682f, -0.07499496f, -0.01691174f, 
    -0.03707175f, -0.13732645f, 0.03060307f, -0.01661466f, 0.17880435f, 0.02593456f, -0.04786340f, 0.01664323f, 
    -0.03197002f, -0.03125499f, 0.02310956f, -0.02749505f, 0.01186704f, 0.07186592f, -0.03454005f, -0.11425868f, 
    0.07582648f, 0.17582053f, 0.03529669f, 0.04696727f, 0.01338378f, 0.09053218f, 0.07783985f, 0.05423239f, 
    0.00327968f, -0.13897485f, -0.06781216f, -0.02238438f, 0.07139804f, -0.15578832f, 0.11155358f, 0.09782301f, 
    0.00524095f, 0.07284408f, -0.07441145f, 0.07352842f, 0.18591981f, -0.20039098f, -0.06411515f, 0.01730666f, 
    -0.02742288f, -0.05564976f, -0.05076064f, 0.04820694f, -0.03443824f, 0.04312283f, 0.12675387f, 0.05091334f, 
    -0.05308766f, 0.06440870f, 0.05631876f, -0.02598971f, 0.07862267f, -0.02515864f, -0.07158825f, -0.01660985f, 
    0.02673356f, 0.13552545f, 0.04052487f, -0.05460047f, -0.16050689f, 0.18868212f, 0.15530613f, -0.06668162f, 
    0.06565086f, 0.06337824f, -0.07574371f, 0.04666672f, 0.00556488f, -0.09619746f, 0.08226740f, 0.03096019f, 
    -0.01590477f, 0.17698030f, -0.19517772f, -0.26721650f, 0.04941944f, -0.16067740f, -0.03108470f, -0.05385880f, 
    0.03151033f, -0.11206443f, 0.05767843f, -0.02272791f, 0.06081197f, 0.09606830f, 0.10128374f, 0.06905053f, 
    0.04950422f, 0.05435942f, -0.07701281f, -0.00692036f, 0.10765373f, 0.06984011f, 0.12058690f, 0.04541513f, 
    0.44003940f, -0.18047413f, -0.01041785f, -0.06014080f, -0.07881032f, -0.01811496f, 0.06773928f, 0.02885844f, 
    0.09038560f, -0.00163249f, -0.13387848f, 0.07840989f, -0.30918053f, 0.14882466f, -0.06487648f, -0.32213047f, 
    -0.03145183f, -0.12270778f, -0.13433747f, 0.04229978f, 0.15014882f, -0.02512384f, 0.06044396f, -0.00105517f, 
    -0.06368183f, 0.23196642f, 0.06622981f, 0.11681239f, -0.04495654f, 0.20932271f, 0.06096269f, 0.05950167f, 
    0.04465276f, 0.02491135f, -0.01466529f, -0.03720857f, 0.33029741f, -0.22880085f, 0.35257587f, 0.03066958f, 
    -0.08582053f, 0.00107542f, -0.07098795f, 0.04156890f, -0.05827768f, 0.01819304f, 0.10474426f, -0.05150689f, 
    -0.29815233f, -0.01057075f, -0.17076780f, -0.05027545f, 0.00521008f, 0.09845479f, -0.08891936f, 0.08760198f, 
    0.10142916f, 0.02926438f, 0.05203606f, -0.10845965f, -0.01076469f, 0.02014350f, 0.08409629f, -0.01347354f, 
    -0.08524811f, -0.06362338f, 0.06075653f, -0.03767028f, -0.03273722f, -0.07210622f, 0.03945642f, 0.02745967f, 
    -0.04659203f, 0.14880173f, -0.35185203f, -0.24850136f, 0.03887183f, 0.08845560f, -0.09446179f, 0.06228557f, 
    0.09463393f, 0.08610029f, -0.02862205f, -0.01191752f, 0.23005846f, 0.05772048f, 0.03174350f, 0.11382720f, 
    0.04825349f, -0.05313924f, -0.13967919f, -0.08174185f, -0.01624320f, 0.02058321f, 0.06937724f, -0.06885163f, 
    0.10996132f, -0.12090240f, 0.07216651f, -0.24805723f, -0.05281536f, -0.09532215f, 0.16669737f, -0.02061244f, 
    0.11031731f, 0.02445342f, 0.06249111f, -0.03796285f, -0.31085023f, -0.03306250f, 0.23078825f, -0.03295894f, 
    -0.00022905f, 0.08966437f, 0.00766771f, -0.06923585f, 0.01034112f, 0.03284796f, 0.01751504f, -0.00356128f, 
    -0.08212685f, 0.10364819f, 0.13058549f, -0.08836059f, 0.18294048f, 0.10393581f, 0.08183174f, -0.19771622f, 
    0.00552095f, -0.05486935f, 0.10837577f, 0.01468184f, 0.05082188f, 0.33669516f, -0.14937156f, -0.05417769f, 
    -0.15593904f, -0.01752475f, 0.01748676f, -0.06755552f, -0.01947795f, 0.01736199f, 0.06138134f, -0.04997573f, 
    -0.19647947f, 0.07379387f, -0.01746270f, -0.00839617f, 0.32376102f, -0.06780229f, -0.00523641f, -0.03711264f, 
    0.00259706f, -0.00705892f, -0.03790427f, 0.03746951f, -0.08952165f, 0.07293987f, 0.15793678f, 0.03100080f, 
    0.03291812f, -0.05029976f, -0.07774620f, -0.07264660f, -0.02628086f, -0.02441420f, -0.01205503f, -0.16098434f, 
    -0.05669107f, -0.06651322f, 0.03089051f, 0.00762120f, 0.11407137f, -0.03235558f, -0.09000945f, -0.10649789f, 
    -0.03422679f, 0.03062969f, -0.03545963f, -0.01151177f, -0.16689487f, -0.23349203f, -0.07470559f, 0.01260323f, 
    0.04640277f, 0.00207249f, -0.09485465f, -0.13478407f, 0.02167033f, -0.01487785f, -0.04655595f, 0.04433062f, 
    -0.26550245f, 0.10847344f, -0.17992160f, -0.00910109f, 0.00351130f, -0.03770609f, -0.02287399f, 0.03928069f, 
    -0.03514209f, -0.05118321f, 0.10874118f, 0.03320907f, 0.01345282f, 0.12115037f, -0.19854419f, -0.15078683f, 
    0.07194797f, 0.15770510f, -0.05641662f, -0.01558827f, 0.18836774f, 0.07851353f, -0.00751501f, -0.01150384f, 
    -0.02321047f, 0.24148898f, 0.03586426f, 0.04283062f, 0.07275750f, -0.00649682f, -0.11977405f, 0.02623213f, 
    -0.09523313f, -0.00667778f, -0.04463676f, -0.10547210f, 0.24908477f, -0.09216817f, 0.09047744f, -0.07048421f, 
    0.08025375f, 0.08961021f, 0.11969497f, 0.05762522f, -0.02928459f, 0.04550058f, -0.06040505f, 0.08449313f, 
    0.06233059f, 0.08395056f, -0.27497673f, 0.08663663f, 0.01609614f, -0.10729604f, 0.02958686f, 0.08665399f, 
    -0.04523090f, 0.07375196f, 0.09901752f, 0.02924178f, 0.03726247f, 0.00663174f, 0.16848791f, 0.04271758f, 
    -0.01305852f, -0.06614584f, 0.03623763f, -0.14072169f, 0.00729232f, 0.05862423f, -0.06346579f, -0.03456049f, 
    0.08954313f, 0.37326971f, 0.04311304f, -0.01411094f, -0.04926651f, 0.00849078f, -0.05410767f, -0.05084936f, 
    0.12404830f, 0.07387439f, 0.01930970f, 0.08256669f, 0.01659470f, -0.04072510f, -0.05480878f, -0.06207427f, 
    0.12253455f, 0.03736275f, -0.00057780f, -0.04827072f, 0.08315919f, 0.06145780f, -0.07069682f, 0.06959716f, 
    0.08320066f, 0.18971483f, -0.01049767f, 0.17773470f, -0.02779519f, 0.00911012f, -0.02272536f, -0.09663372f, 
    0.03084697f, -0.10261574f, -0.22740699f, 0.13766024f, 0.11759949f, 0.12560424f, -0.00407083f, 0.18407546f, 
    -0.02873239f, -0.04388801f, 0.07520881f, -0.02716842f, 0.06926438f, -0.02246989f, 0.02328288f, -0.02710067f, 
    -0.08163089f, 0.13302764f, 0.05392776f, 0.08505967f, 0.01306335f, 0.00933797f, -0.09814002f, 0.04167650f, 
    0.09232397f, -0.00526402f, 0.10767370f, -0.12317482f, 0.07361480f, 0.20556308f, 0.08993385f, -0.11773788f, 
    0.10255619f, 0.00696502f, -0.00529457f, -0.03586539f, 0.00557265f, -0.00369142f, 0.06352171f, 0.03072153f, 
    0.40955546f, -0.04039952f, 0.20123079f, 0.24498169f, 0.06113499f, -0.04068490f, -0.02269419f, 0.00860583f, 
    0.14883447f, 0.04975454f, -0.04232037f, -0.02681973f, -0.06577960f, -0.00292424f, 0.08720150f, 0.12609933f, 
    -0.06601951f, -0.03577873f, -0.00215064f, -0.05591366f, 0.12351469f, 0.01855778f, -0.03505388f, 0.10763218f, 
    0.26988161f, 0.03321879f, -0.04970206f, 0.07452335f, 0.02501122f, -0.07438900f, 0.10292666f, -0.00292290f, 
    0.07078756f, -0.02397354f, -0.06159011f, 0.08626837f, 0.07500502f, -0.27380088f, 0.18788752f, 0.10252289f, 
    -0.12430689f, 0.06850804f, -0.02752998f, 0.00349429f, 0.09769930f, 0.00337565f, 0.16235436f, -0.00980930f, 
    -0.27366173f, -0.04545088f, 0.28217012f, 0.07339652f, 0.02906555f, 0.13805184f, 0.09913640f, 0.13494232f, 
    -0.05531969f, 0.03607780f, -0.00142068f, -0.00383310f, 0.34818915f, 0.12593481f, 0.05485963f, 0.11102489f, 
    -0.00762480f, 0.13773377f, -0.05518892f, 0.09018079f, 0.00053824f, 0.11408929f, 0.02555070f, 0.09408588f, 
    -0.06682700f, -0.29295215f, 0.00451100f, 0.10013350f, -0.03883161f, 0.01156037f, -0.09590362f, -0.03590070f, 
    -0.10924526f, 0.11844238f, 0.04830669f, -0.02356301f, 0.19198343f, 0.15800890f, 0.04056193f, -0.03940684f, 
    -0.06483386f, 0.00130102f, 0.06217156f, 0.11312021f, -0.00860260f, -0.04166245f, -0.01851440f, -0.00900465f, 
    0.04517679f, 0.03469719f, 0.04572691f, 0.24306798f, 0.06744689f, 0.09362319f, 0.02699411f, -0.01189262f, 
    -0.02751319f, -0.05022188f, 0.06731322f, -0.06648303f, 0.08501349f, -0.08773605f, 0.10688426f, 0.15453249f, 
    -0.00843694f, -0.05260897f, 0.06864394f, 0.01810393f, 0.11218344f, 0.07547476f, -0.01751406f, 0.07128649f, 
    0.02292023f, 0.01700883f, -0.04350584f, 0.00410741f, 0.04154474f, 0.07022045f, 0.02053996f, 0.10667056f, 
    0.11037030f, 0.08936406f, 0.12153962f, 0.10919527f, 0.27311391f, -0.26882541f, 0.09756165f, 0.12719327f, 
    -0.13547680f, -0.03158849f, -0.00887091f, 0.07097086f, 0.04818506f, 0.00102783f, -0.07686307f, 0.14996900f, 
    0.03902449f, -0.05215243f, 0.01968144f, 0.18073128f, 0.00338186f, 0.05411731f, -0.06622630f, 0.09027494f, 
    -0.03095471f, 0.09681790f, 0.11806038f, 0.06226161f, 0.17066203f, 0.15432590f, 0.09801045f, 0.21562940f, 
    0.04499702f, 0.05249899f, 0.03087248f, 0.04575473f, 0.01822913f, -0.05376217f, 0.04599768f, 0.08530340f, 
    0.32993856f, 0.01796398f, 0.02401817f, -0.13689721f, 0.07117131f, -0.03081404f, 0.08164445f, 0.00811595f, 
    0.09196103f, 0.06825419f, 0.00543785f, 0.05278166f, 0.34985918f, -0.08430062f, -0.12628154f, 0.01687186f, 
    -0.03590285f, -0.08451440f, -0.13777171f, -0.00699728f, -0.02632413f, 0.03034772f, 0.05001960f, 0.01550606f, 
    -0.52304596f, 0.07225159f, -0.05338255f, -0.33430538f, 0.06936044f, 0.02913431f, 0.02349694f, -0.03954336f, 
    0.00341909f, 0.00568975f, -0.03724419f, 0.20072231f, 0.01685844f, -0.03087326f, 0.01166317f, 0.07791714f, 
    0.15420544f, -0.06467924f, -0.00331905f, -0.07378265f, 0.05543479f, -0.07466923f, 0.09573173f, 0.10109753f, 
    -0.01241435f, 0.03057095f, -0.14174435f, 0.14602736f, 0.12090493f, 0.05300600f, -0.14271928f, -0.07746431f, 
    -0.02215190f, -0.04362220f, -0.04192065f, 0.01115944f, -0.19599152f, 0.04685585f, 0.10679759f, -0.12305554f, 
    0.05550550f, -0.05992267f, -0.03668450f, 0.00368691f, 0.02583574f, 0.01153100f, -0.04824733f, 0.02738499f, 
    0.42023525f, 0.06939283f, -0.03068791f, -0.12953754f, 0.09657799f, 0.15451229f, 0.03954758f, 0.01943209f, 
    0.02655854f, 0.02892850f, 0.01277643f, -0.08753750f, 0.06060151f, 0.05647648f, -0.21574378f, 0.00807715f, 
    0.09031662f, 0.03840331f, -0.04651614f, -0.05619248f, -0.01823021f, -0.00741012f, -0.00398184f, -0.02836687f, 
    -0.24827147f, 0.18606341f, -0.03037051f, 0.05042500f, 0.01012633f, 0.08674546f, -0.02950996f, 0.05297013f, 
    0.08166331f, -0.01034816f, -0.03682873f, 0.06179579f, 0.25595781f, -0.20144373f, -0.11052021f, -0.06653117f, 
    -0.03573019f, -0.00201078f, 0.07587772f, -0.03667170f, -0.06456295f, 0.04321414f, 0.00900713f, -0.00669450f, 
    0.27236643f, 0.15002583f, -0.21763541f, -0.09389362f, 0.01332413f, 0.06843756f, 0.08830204f, 0.02628748f, 
    -0.07747063f, -0.00669158f, 0.06252772f, 0.13406697f, 0.17011204f, 0.03675028f, -0.05158487f, -0.04439422f, 
    0.06521279f, -0.03968800f, 0.01821242f, -0.13985293f, -0.02930319f, 0.08858669f, 0.07730114f, 0.00889785f, 
    0.00247338f, 0.22484934f, -0.02801471f, 0.21023807f, 0.16426577f, 0.08066358f, 0.00137373f, 0.04330239f, 
    -0.01981433f, -0.05536973f, -0.03042031f, 0.04481757f, -0.08567555f, 0.00111398f, -0.03920771f, -0.24353699f, 
    0.13490470f, 0.05215139f, 0.09669384f, -0.06556059f, 0.00444817f, 0.01418317f, 0.02688693f, 0.12813200f, 
    -0.03399326f, 0.06954981f, 0.12985024f, -0.08853404f, 0.07355046f, 0.01363105f, 0.03826546f, 0.12228982f, 
    0.00985869f, 0.04471883f, -0.03369151f, -0.05049635f, -0.01464333f, 0.00298704f, -0.09842962f, -0.04444934f, 
    0.04957564f, 0.13106965f, 0.03235696f, -0.18948957f, 0.00956017f, 0.10829391f, -0.07421134f, 0.07262439f, 
    -0.04671484f, 0.01262185f, 0.06030644f, 0.07745138f, 0.01101808f, 0.03337012f, -0.06610333f, -0.00083008f, 
    0.21535872f, 0.03071323f, -0.02423855f, 0.03730546f, -0.04276261f, 0.05701642f, 0.06230802f, 0.11563912f, 
    -0.00749436f, 0.00120447f, -0.06123611f, 0.10260189f, 0.02396925f, 0.05152728f, -0.00805170f, 0.01488913f, 
    0.01837783f, -0.22249573f, 0.15358773f, -0.05657395f, -0.12959220f, -0.07190029f, -0.03639479f, 0.12481143f, 
    0.07905447f, 0.03717169f, 0.00386162f, 0.12488828f, -0.18847735f, -0.11441021f, 0.09251194f, -0.10002562f, 
    -0.05953833f, -0.14434744f, 0.14638487f, -0.01796511f, -0.01207459f, 0.05996379f, 0.03117777f, 0.15215266f, 
    0.00759149f, -0.08482555f, 0.04699012f, -0.23580663f, -0.05899501f, -0.08852714f, 0.04275657f, -0.04560453f, 
    -0.07539932f, 0.04624087f, -0.01118826f, -0.10057862f, 0.02411929f, -0.15855321f, 0.01979559f, 0.05387949f, 
    -0.09330641f, -0.01913497f, -0.02104457f, 0.04250566f, 0.04685662f, 0.06689097f, 0.00388028f, -0.03261122f, 
    0.05806903f, -0.20736998f, 0.02740958f, 0.21541888f, -0.02851096f, 0.02881329f, 0.08201226f, 0.16312271f, 
    -0.01610852f, -0.03213779f, 0.10817066f, 0.02457865f, 0.06092840f, 0.11046096f, -0.01714126f, -0.10099813f, 
    -0.00012379f, 0.09509452f, 0.13845295f, 0.09088898f, -0.05638677f, 0.07764253f, -0.04083595f, 0.00652623f, 
    -0.10504033f, -0.25076276f, 0.07716534f, -0.12477683f, 0.03445192f, -0.01443093f, -0.01669043f, 0.03421159f, 
    -0.03328236f, -0.07020477f, -0.04567614f, -0.07496510f, 0.37431946f, 0.07783449f, -0.20373270f, 0.10133210f, 
    0.03279310f, -0.06454086f, -0.06244864f, -0.05638253f, -0.02711505f, 0.05548347f, 0.01595401f, -0.01779744f, 
    0.26893774f, -0.01656060f, -0.01526530f, -0.09929999f, 0.03935301f, 0.02752055f, 0.02670128f, -0.00251369f, 
    0.03312334f, 0.05331372f, 0.08288483f, 0.03827562f, 0.17199548f, -0.05332088f, -0.02456030f, 0.07594790f, 
    0.01763622f, -0.02000370f, -0.03125098f, 0.02507811f, 0.13871305f, 0.02738684f, -0.12032663f, -0.04432418f, 
    -0.13506968f, -0.19273974f, 0.00762905f, 0.03748092f, 0.09957622f, -0.04477943f, 0.04264127f, 0.01129746f, 
    -0.07870459f, -0.06342165f, 0.03496658f, 0.09143719f, 0.09899034f, -0.05914225f, -0.05455501f, 0.24105832f, 
    -0.18186486f, 0.06475151f, -0.01009684f, 0.04646787f, 0.05871670f, 0.15635300f, -0.05636074f, 0.13518755f, 
    -0.13369854f, -0.04809894f, -0.11837047f, 0.04576520f, 0.02851235f, -0.00601892f, -0.06436761f, 0.10171726f, 
    0.00993822f, 0.19871491f, 0.16411757f, 0.10733879f, 0.21400322f, 0.07500120f, 0.07414807f, -0.14699608f, 
    -0.00900415f, 0.06433208f, 0.06419688f, 0.06271693f, 0.04085320f, -0.00555977f, 0.04214801f, 0.16236359f, 
    0.02666570f, -0.13343376f, -0.07854178f, -0.10019957f, 0.00862932f, 0.12696795f, -0.05910111f, -0.06781100f, 
    0.12377486f, -0.05465705f, 0.05325457f, 0.04081909f, 0.25337476f, -0.11749817f, 0.00499877f, -0.05678559f, 
    -0.00860268f, 0.04873744f, 0.01349914f, 0.04070146f, 0.03892254f, 0.06450650f, 0.08969726f, -0.02093294f, 
    -0.07633152f, 0.03535308f, 0.10385369f, -0.13613600f, -0.08530600f, 0.01034500f, 0.03308447f, 0.15936895f, 
    -0.08709503f, 0.12529881f, 0.09349183f, -0.05216201f, 0.00739187f, 0.31581154f, 0.13714081f, -0.16565703f, 
    0.01960255f, -0.09082603f, 0.21101122f, -0.05746481f, -0.04207950f, 0.13225718f, 0.05262942f, 0.14478855f, 
    -0.01535049f, -0.11186088f, -0.24360169f, -0.10147898f, 0.00726800f, 0.01657055f, 0.09045909f, -0.03686906f, 
    -0.11189787f, -0.05003084f, 0.13806249f, -0.04973847f, -0.04277148f, 0.01178569f, 0.05381414f, -0.14690258f, 
    0.02636545f, 0.10309454f, 0.11016084f, 0.14611413f, -0.01746043f, 0.01930161f, -0.12164127f, -0.11148863f, 
    0.57854587f, 0.01285469f, -0.15120362f, 0.18676716f, -0.10115054f, 0.07594126f, -0.03743161f, 0.13658158f, 
    -0.08117492f, 0.12747397f, -0.01462499f, 0.07620406f, -0.08473081f, -0.04800717f, 0.03680075f, -0.03673961f, 
    0.04287621f, -0.08747216f, 0.06750893f, 0.00310883f, -0.25956708f, -0.09592835f, 0.00482582f, -0.04662161f, 
    -0.03215430f, 0.02208474f, -0.04750539f, 0.09280800f, -0.01894633f, 0.06302261f, 0.12240975f, 0.05589724f, 
    0.08242701f, -0.06384175f, 0.01150767f, 0.06764062f, 0.35032648f, -0.11468948f, 0.24620365f, 0.22907238f, 
    -0.09655330f, 0.02744653f, -0.06096843f, 0.00193442f, 0.02228144f, 0.16430731f, -0.04998389f, 0.13328803f, 
    0.06208475f, 0.10860693f, -0.05588142f, -0.12748064f, -0.10494425f, -0.00262729f, -0.08078926f, 0.00003329f, 
    0.08431886f, -0.01058529f, -0.03308298f, -0.02679831f, 0.17297018f, 0.02798616f, 0.31096619f, 0.05154717f, 
    -0.05166357f, 0.03888121f, -0.01536638f, -0.06507977f, 0.00388261f, -0.09641962f, 0.08064228f, 0.04563792f, 
    -0.38792506f, -0.31798398f, 0.03354084f, 0.02291860f, 0.09088266f, -0.08595141f, -0.06451782f, 0.04700568f, 
    0.05495057f, -0.07813405f, -0.02345702f, -0.17440331f, 0.09500378f, -0.12980011f, -0.05843636f, 0.09724071f, 
    -0.07072716f, 0.00863216f, -0.00802028f, 0.13361365f, -0.05450258f, 0.02627596f, 0.03028538f, -0.02822928f, 
    0.05846755f, 0.08403398f, -0.08258133f, 0.08588912f, -0.03442131f, 0.13613336f, 0.01919767f, 0.18398933f, 
    0.10995379f, 0.02429236f, 0.16441916f, -0.01035356f, 0.03344352f, 0.14911634f, 0.13098635f, -0.16413480f, 
    0.02557505f, 0.01503199f, -0.07900727f, -0.09164206f, 0.03791333f, 0.01984786f, -0.05173582f, 0.20257014f, 
    0.05780045f, 0.06413228f, -0.08169767f, -0.17314155f, -0.03209135f, 0.23109044f, -0.16622141f, -0.25460014f, 
    0.00266833f, 0.03785151f, 0.01081151f, 0.03185158f, -0.01460145f, -0.06312633f, -0.07879759f, 0.08512168f, 
    0.01320393f, 0.13476196f, 0.09401362f, 0.04056634f, 0.02158318f, -0.02287845f, -0.05944370f, -0.11908024f, 
    -0.12063970f, -0.10304403f, 0.03506518f, -0.02344885f, -0.03334473f, 0.10184266f, -0.08245494f, 0.00004255f, 
    0.00960603f, 0.16477047f, 0.12846315f, -0.14030966f, 0.22647050f, 0.08600113f, 0.00039130f, -0.12118165f, 
    0.00466875f, 0.14351545f, -0.00228529f, 0.12477909f, 0.01447125f, 0.06659126f, 0.00934558f, -0.01920004f, 
    -0.23132844f, 0.01149408f, 0.10885113f, -0.18249527f, 0.09675436f, 0.08152292f, -0.04309273f, 0.09984415f, 
    -0.03275432f, -0.07447810f, 0.04973216f, 0.03663026f, -0.17407770f, 0.12208240f, -0.17522471f, -0.19802530f, 
    0.04433454f, -0.08280027f, 0.01965958f, -0.01939885f, -0.02494094f, 0.03320263f, -0.07186400f, 0.03534419f, 
    0.08833448f, -0.05646215f, -0.12995023f, 0.05451911f, 0.04374946f, -0.05737136f, -0.12653247f, 0.00152962f, 
    -0.04983822f, 0.02680744f, -0.02411906f, 0.01388008f, -0.16015019f, -0.06724902f, 0.06988639f, -0.33166826f, 
    0.07195794f, 0.17431754f, 0.11566801f, -0.05265914f, 0.04324071f, -0.07498638f, -0.07490409f, 0.07860829f, 
    -0.08305386f, 0.29180241f, 0.09590590f, 0.08597391f, 0.02943833f, -0.02292110f, 0.09044307f, 0.13859156f, 
    0.12775706f, -0.01395657f, -0.04547995f, 0.16801451f, -0.04155805f, 0.04246695f, -0.01834068f, 0.04759031f, 
    0.03522270f, -0.10928107f, -0.02270530f, 0.09473037f, 0.18601188f, 0.03060127f, 0.01624396f, -0.03525989f, 
    -0.07870162f, 0.00239282f, 0.23904493f, -0.00570524f, -0.12786846f, 0.03513674f, -0.12460712f, 0.07636500f, 
    0.03723508f, -0.00963100f, 0.00379904f, -0.03633046f, -0.06233848f, 0.10230582f, 0.08488113f, -0.07933450f, 
    -0.01385104f, 0.04738310f, -0.01561527f, 0.09973832f, -0.00864625f, -0.06591465f, 0.20236030f, 0.01558913f, 
    -0.13318403f, -0.15292118f, 0.27907866f, 0.03279907f, -0.02264076f, 0.17490785f, 0.02491316f, -0.13223739f, 
    0.03339725f, -0.05772275f, 0.05579668f, 0.04655062f, -0.02863544f, 0.17043541f, -0.25114161f, -0.17674884f, 
    0.01735478f, 0.02285641f, 0.06028561f, 0.02926463f, 0.03021307f, -0.03067806f, 0.19376494f, -0.01670925f, 
    0.08613087f, 0.07555166f, 0.10643618f, 0.08444136f, 0.06700262f, 0.05442033f, 0.09903198f, -0.05122527f, 
    0.04894354f, -0.04682862f, -0.10074520f, 0.02785091f, -0.07971804f, -0.22749542f, 0.05199148f, 0.11991635f, 
    0.06081222f, -0.15378670f, 0.06787564f, 0.09061129f, -0.12836954f, 0.10340029f, 0.07007807f, -0.11640359f, 
    -0.02366411f, 0.05349210f, -0.02950179f, 0.06531147f, -0.04910871f, 0.23970456f, 0.03498657f, 0.04848510f, 
    0.04458470f, -0.06436367f, 0.01239653f, -0.00924827f, -0.27009764f, 0.10383444f, 0.24651982f, -0.08227050f, 
    0.11384226f, 0.15294774f, 0.00171521f, 0.10188729f, 0.13181965f, -0.05274576f, 0.01826222f, 0.03078889f, 
    -0.34822249f, 0.08233934f, -0.06171151f, -0.13027036f, 0.09124133f, 0.06551696f, 0.01225810f, -0.05438051f, 
    -0.02164035f, 0.02990354f, -0.00120127f, 0.01649533f, -0.28960815f, -0.00445827f, 0.07755774f, 0.00991909f, 
    0.06748269f, -0.14805886f, 0.05155051f, 0.08885817f, 0.04984818f, 0.00490211f, 0.01523195f, 0.00010114f, 
    -0.23659419f, -0.09898280f, -0.03602956f, -0.02054753f, 0.04119984f, -0.05485816f, -0.04668924f, -0.04557546f, 
    0.00591452f, 0.05423512f, -0.02890033f, -0.03737402f, -0.05145185f, 0.07715093f, 0.16174477f, 0.13683982f, 
    0.02342815f, 0.03364293f, 0.00221262f, 0.00484466f, 0.11086428f, -0.07006820f, 0.04143005f, -0.08940648f, 
    0.31504682f, 0.10008377f, -0.05773216f, -0.10472924f, -0.00472176f, 0.08642027f, -0.01193118f, 0.07705821f, 
    0.07299311f, -0.06754023f, 0.08034305f, 0.07507417f, -0.30642083f, 0.12325581f, -0.29103336f, -0.16618820f, 
    0.01744092f, -0.11233795f, -0.01410117f, 0.00174898f, 0.13139533f, 0.06135115f, -0.01786401f, -0.08389771f, 
    -0.14594796f, 0.22030738f, 0.05105612f, -0.14084609f, -0.05114143f, -0.00777066f, -0.02243649f, 0.11612277f, 
    0.12875009f, -0.01520458f, -0.02801844f, 0.02400572f, 0.47927234f, -0.23878025f, 0.10151362f, 0.00857675f, 
    0.09238198f, -0.01176663f, 0.00695346f, -0.05107284f, -0.05505756f, 0.06487697f, -0.00762089f, -0.03819761f, 
    0.08483529f, 0.11967880f, -0.27321917f, -0.21680877f, 0.12268843f, 0.04631838f, 0.12289517f, -0.05324259f, 
    -0.01699723f, 0.05029831f, 0.13763300f, 0.06436271f, 0.08163787f, -0.07523334f, -0.01490797f, 0.03773832f, 
    0.09983214f, -0.09395218f, 0.00836065f, -0.01951562f, 0.04517704f, 0.05065266f, -0.09647753f, -0.05653729f, 
    0.12508488f, 0.28763548f, -0.13609415f, 0.14990842f, 0.15356615f, -0.01850907f, 0.05193886f, 0.12010743f, 
    0.02631030f, 0.03033422f, -0.00378582f, 0.11961896f, 0.09348387f, 0.11377649f, 0.20172514f, 0.03548915f, 
    0.18413316f, 0.06638238f, 0.05380235f, 0.00119812f, 0.15705228f, 0.13008775f, 0.02163534f, 0.03647890f, 
    -0.06779295f, 0.04016403f, -0.03458745f, -0.06874426f, 0.05868851f, -0.07082070f, 0.10825975f, 0.10618572f, 
    -0.03225947f, 0.08958495f, -0.10546123f, 0.02959202f, -0.06199376f, -0.05422131f, -0.07760876f, -0.18296646f, 
    -0.05134874f, 0.02924597f, -0.01608419f, -0.16640922f, -0.01848350f, 0.08602128f, 0.07835466f, 0.11379322f, 
    -0.20145705f, -0.01897336f, -0.02740804f, -0.03838866f, 0.01854065f, 0.02527324f, -0.02910247f, 0.02547987f, 
    0.04693814f, 0.03335250f, 0.02669393f, 0.02811461f, 0.24565651f, 0.24248070f, 0.10581096f, 0.00809463f, 
    0.08207386f, -0.03647640f, 0.09361015f, -0.09311236f, 0.05553358f, 0.04753310f, 0.07835733f, -0.01097208f, 
    -0.37614861f, -0.06168859f, -0.05774027f, -0.09237050f, 0.10954870f, -0.06908447f, 0.13351935f, 0.06327086f, 
    -0.01071104f, -0.00855128f, -0.00303012f, 0.11246393f, -0.19615215f, -0.14216697f, 0.08096602f, -0.07986620f, 
    0.07508931f, 0.00256405f, -0.06650468f, 0.06591842f, 0.05417212f, 0.04466446f, -0.00794935f, -0.01536094f, 
    -0.29700211f, -0.06655578f, 0.06405865f, -0.16967544f, 0.14484061f, -0.07719614f, 0.00737268f, -0.01976951f, 
    0.14125060f, -0.04011271f, -0.08773380f, 0.00180105f, -0.17931984f, 0.17122898f, -0.00320881f, -0.03708025f, 
    0.11194228f, 0.00273398f, 0.00009695f, 0.03591188f, -0.06830688f, -0.02258791f, 0.05513473f, -0.07242736f, 
    -0.05280790f, 0.10620090f, -0.02008329f, -0.12615207f, 0.09574603f, 0.03168156f, -0.04592315f, -0.01653728f, 
    0.03894423f, -0.04654558f, 0.07673641f, 0.03162682f, -0.14566356f, 0.02937819f, -0.08288207f, -0.07858396f, 
    0.05620601f, -0.10383172f, 0.04215671f, -0.07727462f, 0.06022969f, 0.07503905f, -0.04221686f, 0.00109345f, 
    -0.17167476f, 0.08375297f, 0.19067797f, -0.04992259f, -0.03820937f, -0.01919272f, -0.06767645f, 0.03287447f, 
    0.05091916f, 0.04567128f, -0.03549611f, -0.04178627f, 0.16525444f, 0.08511029f, -0.15462103f, -0.05622718f, 
    -0.01384554f, -0.00282938f, 0.01357612f, -0.13449802f, 0.00581820f, 0.03740970f, 0.06937943f, -0.08996843f, 
    0.32844725f, 0.04879936f, -0.08040854f, -0.13202997f, 0.08556569f, 0.00375931f, 0.09987831f, -0.04815413f, 
    -0.02359640f, 0.13828704f, 0.18253396f, 0.23064725f, 0.19123712f, -0.01269190f, -0.20765328f, -0.03190444f, 
    0.09914669f, 0.03504795f, -0.12278015f, -0.06960189f, -0.04929199f, 0.15177499f, -0.12501077f, 0.06201640f, 
    -0.06600314f, 0.08928894f, 0.23586127f, 0.09828631f, -0.00749120f, -0.01749773f, 0.16427599f, -0.10583821f, 
    0.00892114f, -0.04298313f, 0.04835214f, 0.03724520f, -0.21941116f, 0.12789379f, 0.14770450f, -0.08904529f, 
    0.16546577f, 0.09126154f, 0.03319033f, -0.03920635f, 0.08274716f, 0.02963058f, 0.08574020f, -0.09528700f, 
    -0.06064675f, -0.03369251f, 0.05972035f, -0.03579973f, 0.10624920f, -0.04624518f, -0.04507801f, 0.03038260f, 
    -0.00787931f, 0.06871588f, -0.01996972f, 0.05918692f, -0.02553931f, -0.14236635f, -0.11783093f, -0.02285076f, 
    0.09997354f, 0.11776805f, 0.12033982f, -0.03635898f, -0.00607570f, 0.06228293f, 0.12143812f, 0.07867359f, 
    -0.04070854f, -0.07977454f, -0.03076027f, 0.01542654f, 0.00229394f, -0.03726367f, 0.05928962f, 0.08266959f, 
    -0.03507020f, -0.02397200f, 0.03534876f, 0.16181435f, 0.07882772f, 0.02433860f, 0.16529886f, -0.10280043f, 
    0.15500914f, -0.09453786f, 0.06828341f, 0.08728506f, 0.14847334f, -0.04673851f, 0.15206113f, 0.02552950f, 
    -0.11095145f, 0.08590828f, 0.02137949f, -0.12872280f, -0.17257656f, 0.11596861f, -0.02271583f, -0.11171096f, 
    0.06531347f, 0.02471550f, 0.05899572f, -0.20771940f, -0.00480785f, -0.06033050f, -0.14669947f, -0.10019512f, 
    0.04834340f, -0.05552309f, 0.07239072f, 0.11845005f, 0.01006414f, 0.02323753f, -0.05501411f, 0.12348133f, 
    -0.00526174f, -0.00007681f, -0.01784283f, -0.07911741f, -0.01857169f, 0.09623798f, -0.11825314f, 0.04455287f, 
    -0.02777870f, -0.01194485f, 0.04725180f, 0.04044473f, 0.22489598f, 0.07885155f, 0.03159522f, 0.01935621f, 
    -0.07888100f, -0.18154827f, 0.06709771f, -0.08619539f, 0.02324869f, -0.05040053f, -0.12164402f, 0.06214205f, 
    0.28599942f, -0.03095524f, 0.01459816f, 0.09763808f, 0.06802976f, -0.10132170f, 0.13885902f, -0.01130178f, 
    0.10957135f, 0.09346399f, -0.06033865f, 0.01432348f, 0.02255048f, 0.00815625f, -0.25388739f, -0.19568293f, 
    -0.05402582f, 0.12066479f, -0.07893939f, -0.09736291f, 0.00632893f, -0.06441040f, 0.01369579f, -0.05008248f, 
    -0.05113753f, 0.20411275f, 0.15511432f, -0.14251980f, -0.00563654f, 0.09465872f, 0.11770420f, 0.12407897f, 
    0.05423200f, 0.11794127f, 0.09800266f, 0.24314575f, 0.40614071f, -0.52151048f, 0.12558970f, 0.00148368f, 
    0.10646626f, -0.00985422f, 0.02282264f, -0.07368410f, -0.07528351f, -0.07803193f, 0.10820881f, 0.12331781f, 
    -0.07557150f, 0.21962939f, 0.01282072f, -0.21651782f, 0.11760721f, -0.04499570f, 0.10056869f, 0.07959565f, 
    0.06957510f, -0.03164625f, -0.15144265f, -0.02245211f, -0.02213639f, -0.01049294f, -0.06896118f, -0.12829097f, 
    0.12312622f, 0.06600566f, 0.11864535f, 0.03382344f, -0.05387963f, -0.08171867f, 0.07401568f, -0.07220933f, 
    0.39344358f, 0.34203273f, 0.01182889f, 0.13984980f, 0.06865739f, 0.02783793f, -0.11822917f, 0.01827223f, 
    -0.09484271f, 0.02597701f, -0.07162055f, 0.21970287f, -0.03528951f, 0.08547363f, -0.18638182f, -0.06325291f, 
    0.05788971f, -0.06842259f, 0.02028744f, -0.12443588f, 0.07086801f, 0.11086819f, -0.01136608f, 0.02114714f, 
    -0.02648746f, 0.28101549f, 0.07385144f, -0.05980064f, 0.23312479f, 0.08423062f, 0.30478042f, -0.10263892f, 
    -0.00870347f, -0.29011238f, 0.00470960f, -0.15930128f, -0.01492443f, -0.11768800f, -0.04307232f, -0.31420806f, 
    -0.00321398f, -0.11800038f, 0.06912886f, -0.09992728f, -0.01766066f, 0.16666973f, -0.14998002f, 0.00565574f, 
    -0.20045404f, 0.17774449f, 0.07617971f, 0.15388334f, -0.06695955f, 0.01094341f, -0.16539830f, 0.04650631f, 
    0.06559844f, 0.13434324f, 0.12502894f, 0.11976032f, 0.10558132f, -0.01988740f, 0.06624130f, 0.00904790f, 
    0.19971831f, 0.10462014f, -0.03419117f, 0.05539462f, 0.03499905f, -0.01808327f, -0.22446643f, -0.09259129f, 
    -0.13066950f, 0.05072903f, 0.05808086f, -0.00535149f, 0.02895792f, -0.03972996f, 0.12484109f, 0.03868587f, 
    0.04712735f, 0.05030989f, -0.16591996f, 0.12011528f, -0.20085980f, -0.04958516f, 0.12586978f, -0.11957385f, 
    0.00763494f, -0.08949759f, 0.06260114f, -0.04453712f, -0.04905431f, 0.06228733f, -0.05000272f, 0.11484217f, 
    0.00580509f, -0.21860626f, -0.13742833f, -0.09261781f, 0.09611441f, -0.10875398f, 0.07976507f, -0.05490119f, 
    -0.03853451f, 0.11054910f, -0.11072824f, -0.04635375f, 0.18322892f, 0.08580998f, 0.08598252f, -0.19202949f, 
    0.06689588f, 0.00798305f, -0.01848703f, 0.01733559f, 0.08349127f, -0.01238521f, 0.08427472f, -0.02488231f, 
    -0.06591131f, -0.05663323f, -0.01407266f, 0.12872763f, 0.07508674f, 0.08086110f, 0.04723330f, 0.12669864f, 
    -0.03020262f, -0.07597370f, 0.08023088f, 0.00456647f, -0.08516932f, 0.08693202f, -0.07300860f, 0.08862387f, 
    -0.03600436f, 0.06667781f, -0.02701556f, 0.04765660f, -0.02487287f, -0.02871866f, 0.03149533f, -0.00213476f, 
    -0.23571843f, -0.17391305f, 0.13280164f, -0.12379609f, 0.01302901f, -0.07759132f, -0.09221093f, 0.00591524f, 
    0.00732968f, -0.07658010f, 0.03952752f, -0.03564120f, 0.35215011f, 0.01309819f, -0.10217336f, 0.02574137f, 
    0.08839543f, 0.13321468f, -0.00202281f, -0.09760456f, -0.11494590f, 0.10692211f, 0.02901164f, 0.05281378f, 
    0.08767025f, 0.08813155f, -0.00542266f, -0.16081423f, -0.02096161f, 0.01879439f, 0.10516433f, 0.00099057f, 
    -0.02249326f, 0.08681783f, 0.12117131f, -0.01709100f, 0.07124524f, -0.06586520f, -0.03916284f, 0.12183636f, 
    0.03176794f, 0.00838240f, -0.10555433f, -0.05682684f, 0.01758183f, 0.04635506f, -0.06996655f, -0.05114526f, 
    0.08941841f, 0.14444356f, 0.03696258f, 0.08870438f, 0.05844694f, -0.09244753f, 0.04149991f, 0.04992700f, 
    0.02297731f, -0.06295698f, 0.11718121f, 0.07981716f, 0.21936679f, -0.07092881f, 0.12063400f, 0.07767101f, 
    0.08684292f, 0.03651892f, 0.08155447f, 0.10025491f, 0.10479886f, 0.12808196f, 0.00256551f, 0.04841672f, 
    -0.13484068f, 0.01189081f, 0.02476651f, 0.08071536f, 0.02446929f, -0.04688557f, -0.05772687f, 0.12729527f, 
    0.06470967f, 0.11550331f, 0.08701630f, -0.01410227f, 0.10519042f, 0.05414066f, -0.03662114f, -0.12190460f, 
    0.03142999f, 0.18564092f, 0.06892074f, -0.05890048f, 0.02377525f, -0.06949327f, -0.03421196f, 0.18241733f, 
    -0.12896383f, -0.15871477f, -0.07434595f, -0.10565272f, -0.01427339f, 0.02314183f, 0.03960114f, 0.07637467f, 
    0.08607972f, 0.01638871f, -0.02038675f, 0.07968481f, 0.29336402f, -0.06050672f, -0.04535403f, 0.09436288f, 
    0.11863632f, -0.02551937f, 0.05960044f, 0.10165629f, -0.01681174f, 0.02828153f, 0.16791485f, 0.01137674f, 
    0.00208395f, -0.04771646f, 0.00541240f, 0.06417012f, -0.03261049f, 0.12927213f, 0.15269592f, 0.05352571f, 
    -0.04497470f, -0.11696609f, -0.05203283f, 0.15276447f, -0.27042818f, -0.24587277f, -0.02200737f, -0.07149176f, 
    -0.00114441f, -0.00390927f, 0.04886018f, 0.07104717f, 0.00361969f, 0.08080447f, 0.02151002f, -0.02809385f, 
    -0.07291984f, -0.01415035f, 0.21924751f, -0.18148468f, 0.06097313f, 0.01878333f, 0.04244101f, 0.11207857f, 
    0.13968293f, 0.05994153f, -0.05665078f, -0.08152808f, 0.21178629f, 0.09302627f, 0.05600854f, 0.19163153f, 
    0.11535153f, -0.00016165f, 0.09037471f, -0.00051240f, 0.04208854f, -0.06679308f, 0.08842382f, 0.00320652f, 
    0.05909504f, 0.05660096f, -0.03260755f, -0.02517965f, -0.02383706f, -0.03435820f, 0.08365674f, 0.05577001f, 
    0.08690596f, -0.08019201f, 0.12774006f, -0.01642133f, -0.28443426f, -0.00740168f, 0.13667193f, -0.03969958f, 
    0.10234198f, -0.03669486f, 0.14809015f, 0.02759645f, -0.08163159f, 0.00569219f, -0.05945331f, -0.08924489f, 
    0.16534197f, -0.06788113f, 0.11425810f, -0.27413270f, 0.02269065f, -0.01638854f, -0.07772826f, -0.06122212f, 
    0.05743694f, -0.01288825f, 0.10117160f, -0.02357909f, -0.12151206f, 0.18465953f, -0.10019635f, 0.03165957f, 
    0.02682012f, 0.01246120f, -0.02520657f, -0.15563560f, -0.03925481f, 0.13937645f, 0.09638567f, 0.01283491f, 
    0.08328957f, -0.10054717f, -0.01779196f, -0.31612629f, -0.01766556f, -0.02063017f, 0.05437222f, -0.07847820f, 
    0.02656335f, -0.00711366f, 0.16077136f, 0.10636762f, 0.07899027f, -0.08366346f, -0.35308364f, 0.01924761f, 
    0.16385293f, -0.00529140f, -0.13830024f, 0.01457726f, -0.04294214f, 0.11110733f, -0.02392418f, -0.00523300f, 
    0.14307979f, 0.04573661f, 0.05558285f, -0.01438775f, 0.03055718f, -0.14421152f, 0.17405602f, 0.02635926f, 
    -0.13915499f, -0.06453903f, -0.03681933f, -0.04890617f, -0.07768328f, 0.12043625f, 0.17635077f, 0.10411135f, 
    -0.01702935f, 0.07093405f, 0.03298721f, 0.06288750f, 0.00865846f, 0.05553473f, 0.03787759f, -0.10123382f, 
    -0.13369013f, -0.03797270f, 0.00964450f, -0.15306772f, 0.20286644f, -0.03539715f, -0.06794331f, 0.14791735f, 
    -0.01341392f, 0.06149812f, 0.08435738f, 0.08004648f, -0.04786374f, -0.10355419f, 0.01356274f, -0.26744264f, 
    0.03130999f, 0.20807408f, -0.00329891f, -0.04464050f, -0.03892263f, 0.03576165f, 0.10074732f, 0.05689245f, 
    -0.05634375f, -0.21680836f, -0.06034333f, 0.03489024f, -0.03917744f, -0.09697835f, 0.08555009f, 0.10281510f, 
    -0.01209185f, -0.01259931f, -0.01933024f, 0.09573545f, 0.12967305f, 0.13281083f, 0.17422290f, -0.05227811f, 
    0.03608299f, 0.00143578f, 0.01250198f, 0.03409757f, 0.14430393f, -0.01076001f, 0.19127749f, 0.07323879f, 
    0.31809476f, -0.02350257f, -0.03599206f, 0.18417256f, -0.08565991f, 0.04406650f, -0.10742117f, -0.04260318f, 
    -0.00107512f, -0.00077082f, -0.01055889f, -0.09861230f, 0.36406699f, 0.19600683f, -0.08879208f, 0.02498849f, 
    0.09271438f, 0.22995615f, 0.08874404f, -0.00448066f, 0.02672902f, 0.08450714f, -0.02654457f, 0.03446538f, 
    0.00481607f, 0.13207607f, 0.12166412f, 0.10251036f, -0.00916958f, 0.10137290f, -0.08995692f, 0.07777122f, 
    0.03400808f, 0.00244806f, 0.08003896f, 0.08587934f, 0.02022697f, 0.11829557f, -0.11019275f, -0.05696659f, 
    -0.07422696f, 0.01069381f, 0.04785754f, -0.04619570f, -0.04299886f, 0.04467137f, -0.10607257f, 0.15275280f, 
    -0.15341157f, 0.00351634f, -0.04364371f, 0.07765745f, -0.04274521f, 0.02706963f, -0.15275520f, -0.02116602f, 
    -0.13892466f, 0.03111170f, 0.02768001f, -0.04366310f, 0.17929684f, 0.00918681f, 0.08765137f, -0.11852279f, 
    0.07894070f, 0.07028618f, 0.11803557f, -0.06359667f, -0.07557264f, -0.02438149f, -0.02844925f, 0.10041749f, 
    0.24912281f, 0.15851285f, -0.02629364f, 0.08948423f, 0.16310081f, -0.01918175f, 0.09445602f, 0.14594182f, 
    -0.06924687f, 0.10859240f, 0.08145795f, 0.11995476f, -0.13389479f, 0.12158046f, -0.15644528f, -0.02608474f, 
    0.02760268f, -0.00015453f, 0.07856818f, 0.20288330f, 0.13373998f, -0.09607683f, -0.07282665f, 0.05304460f, 
    0.00000914f, 0.07368665f, 0.20572603f, 0.17762499f, -0.05233218f, -0.08348499f, -0.15864114f, 0.09836400f, 
    0.07460246f, 0.00262465f, -0.12017826f, -0.09135934f, 0.05370044f, 0.12037942f, 0.10493340f, 0.04857505f, 
    -0.05126246f, 0.14840315f, 0.01446630f, 0.17561352f, -0.07447696f, -0.12485956f, 0.08875819f, 0.01044719f, 
    0.03076026f, -0.08741263f, 0.24085514f, -0.01458632f, -0.14160766f, 0.12772162f, 0.14286268f, -0.02137760f, 
    -0.03127749f, 0.11616842f, -0.03970155f, -0.02330333f, -0.17588201f, 0.14748977f, -0.09948145f, -0.02289874f, 
    -0.01558628f, -0.09746356f, -0.11872354f, -0.01148647f, -0.00736643f, -0.00253536f, 0.01678245f, 0.05929049f, 
    0.18205644f, 0.07815338f, -0.08064629f, 0.08285122f, -0.10880248f, 0.15832329f, 0.06932402f, -0.09705544f, 
    -0.02053287f, -0.12256145f, -0.03922607f, 0.04452771f, 0.26333791f, -0.08085632f, 0.03705986f, 0.14757884f, 
    0.07485788f, -0.08567303f, 0.06072537f, 0.08089870f, 0.03915755f, 0.09099234f, -0.05612199f, -0.02473456f, 
    0.19655783f, 0.11529370f, 0.05687007f, 0.14391632f, -0.01589742f, 0.16862199f, 0.00878148f, 0.07748526f, 
    -0.00370093f, -0.00232394f, 0.08714709f, -0.03598689f, -0.24123049f, -0.14525707f, 0.15092969f, -0.03360561f, 
    -0.01786406f, 0.10016262f, -0.03654539f, 0.12081806f, 0.03492199f, 0.01205306f, -0.02247533f, -0.05541468f, 
    0.52288306f, -0.09687040f, 0.19007303f, 0.44365016f, -0.01366892f, -0.03365131f, -0.01801442f, 0.03730993f, 
    0.06863052f, -0.11892272f, -0.10315949f, -0.01623174f, -0.18549328f, -0.19428062f, -0.10375370f, 0.04858192f, 
    -0.14182982f, 0.01422544f, -0.07827541f, -0.10951403f, 0.05957086f, -0.09319580f, -0.04258092f, -0.07501642f, 
    -0.02710577f, 0.06229341f, 0.16276890f, -0.18115281f, 0.05700464f, -0.00746238f, 0.03808494f, -0.00574483f, 
    0.01386034f, -0.00620241f, -0.05859366f, 0.08789160f, 0.34760875f, -0.08047300f, -0.08881796f, 0.11180001f, 
    0.00781998f, 0.07387877f, -0.13672057f, -0.07904797f, 0.01089838f, -0.13142651f, 0.09503995f, 0.00512090f, 
    -0.54825670f, -0.03531097f, 0.16526932f, 0.15712889f, 0.08781751f, -0.06474859f, -0.04514094f, -0.05899103f, 
    0.03104782f, -0.00554936f, 0.04875125f, -0.00015736f, 0.06603973f, -0.08291136f, 0.15939523f, -0.03528282f, 
    -0.03453084f, 0.02033737f, -0.03028935f, -0.02167115f, 0.11121126f, 0.00249557f, 0.03705746f, 0.07288102f, 
    0.00594165f, -0.20277449f, 0.07569770f, -0.09316954f, 0.00834784f, -0.02895161f, -0.11802730f, -0.07877216f, 
    -0.10051817f, 0.12537190f, -0.02603177f, -0.03224272f, -0.10677369f, 0.30601653f, -0.11587649f, 0.04169783f, 
    0.13278671f, 0.10476115f, 0.02633177f, 0.05703294f, 0.06005882f, -0.06322021f, 0.04718420f, 0.07485075f, 
    -0.17327797f, -0.10726834f, 0.12439365f, 0.23993461f, -0.08968374f, -0.06170936f, 0.08210730f, 0.05285837f, 
    0.00178864f, -0.03369042f, -0.02816479f, -0.00935893f, -0.18347678f, -0.11934890f, -0.07049331f, 0.02154671f, 
    0.03356316f, 0.09667385f, -0.11177804f, 0.14435403f, -0.07442725f, -0.02251626f, -0.04718256f, 0.01115633f, 
    0.19942416f, 0.02497789f, 0.10862478f, -0.19818589f, -0.03474712f, -0.02975177f, 0.09742244f, -0.04162552f, 
    0.08342182f, 0.06272300f, -0.04470783f, 0.08705545f, 0.09712756f, 0.10575680f, 0.13042001f, 0.19257063f, 
    0.00376488f, 0.05723022f, 0.06744563f, 0.01245424f, 0.00374235f, -0.07680400f, -0.02159941f, 0.01351423f, 
    0.01182619f, -0.11516353f, -0.05128373f, 0.09348129f, -0.07194862f, -0.01544430f, -0.04184167f, -0.10778347f, 
    0.05567879f, 0.09743232f, 0.04938498f, -0.00482194f, 0.17689887f, 0.00358073f, 0.07731258f, 0.11786560f, 
    0.04648711f, -0.00728671f, 0.02936524f, 0.10630192f, -0.04366877f, -0.03323283f, 0.07869262f, -0.05482855f, 
    0.01962114f, -0.10335675f, -0.03594856f, -0.03214287f, -0.03570484f, -0.10615539f, 0.04202451f, 0.06711211f, 
    -0.10473003f, 0.11604726f, -0.00891608f, 0.00737810f, 0.23220760f, 0.05770897f, 0.04400190f, -0.16921045f, 
    0.09738947f, 0.05485542f, 0.00323559f, -0.00286821f, 0.02360201f, 0.05601085f, 0.07851768f, 0.12582283f, 
    0.23231564f, 0.23638976f, 0.00943224f, 0.06812382f, 0.09558208f, 0.07972991f, 0.00591816f, 0.00482956f, 
    -0.06024448f, -0.00723948f, 0.15491800f, -0.08020463f, 0.29333857f, -0.05486488f, -0.12559837f, -0.03490179f, 
    -0.00391207f, 0.08678112f, -0.04075345f, -0.14849728f, -0.00549552f, -0.14930281f, -0.07114524f, -0.14834656f, 
    0.16646576f, -0.11833277f, 0.13154496f, 0.16386066f, -0.04316970f, -0.05447571f, 0.00461961f, 0.11095706f, 
    0.14102635f, 0.09125738f, 0.04406906f, 0.03495681f, 0.19647469f, 0.04669106f, -0.04357678f, -0.01086162f, 
    0.00394196f, -0.05701191f, 0.13887465f, 0.01985230f, -0.00551406f, 0.17274414f, -0.06949174f, 0.00562903f, 
    0.07121713f, 0.25908583f, -0.09212512f, -0.00673699f, 0.08705393f, -0.03281781f, -0.00891797f, -0.04359871f, 
    -0.02277979f, 0.04400680f, -0.11888149f, 0.03359311f, -0.08053313f, -0.21116039f, 0.05515015f, 0.08520806f, 
    -0.00887316f, -0.04484626f, -0.02898734f, -0.02276296f, -0.02951264f, -0.01171581f, 0.09611468f, -0.03917240f, 
    0.26427209f, -0.12009748f, -0.23801629f, 0.07800772f, 0.09484401f, -0.07629478f, 0.08164059f, -0.21076423f, 
    -0.07877105f, -0.12273385f, 0.09264255f, 0.12629901f, -0.47651809f, 0.03096846f, 0.07551892f, -0.08059413f, 
    0.08541252f, 0.11322687f, 0.07582390f, 0.16541207f, 0.19265980f, -0.06443878f, -0.04871103f, 0.01851394f, 
    0.02884519f, 0.04522932f, 0.13196270f, 0.18603575f, -0.05744409f, -0.03206271f, 0.00949928f, -0.06865139f, 
    0.07590324f, 0.03549594f, -0.08798191f, 0.11971289f, -0.38317236f, 0.15169626f, -0.05979979f, -0.10099725f, 
    0.11764522f, -0.04110059f, 0.09059687f, -0.09694280f, -0.01252662f, -0.07877750f, 0.14250012f, 0.11792091f, 
    -0.00763393f, 0.11339556f, 0.06534063f, 0.01988497f, 0.05771325f, -0.09085312f, 0.06502750f, -0.03238146f, 
    0.08071280f, 0.04375667f, 0.03626997f, -0.13343851f, 0.12529653f, -0.01620951f, 0.17125431f, 0.06817126f, 
    0.02327575f, -0.06849253f, 0.04913450f, 0.03108740f, -0.07671800f, -0.00899779f, 0.05371753f, -0.09651583f, 
    -0.03908494f, -0.08501420f, 0.03550196f, 0.04279789f, 0.02505016f, 0.00349912f, -0.10561375f, 0.00430942f, 
    0.12729131f, -0.25699583f, -0.01373814f, -0.14940663f, -0.11775760f, 0.04877118f, -0.05418462f, -0.01425810f, 
    0.03007638f, 0.00296703f, -0.11653934f, -0.03354453f, 0.08708521f, -0.04880387f, -0.00470610f, 0.01344053f, 
    -0.19284254f, 0.17279744f, -0.11481450f, -0.07423035f, 0.00939929f, -0.03639272f, 0.08322742f, -0.07139114f, 
    0.03468962f, 0.11998452f, 0.09646268f, -0.03795367f, -0.32177293f, -0.11535769f, -0.13676798f, 0.13724023f, 
    0.12542862f, 0.02543171f, 0.11466250f, -0.09652009f, 0.11444336f, 0.06222636f, -0.10029975f, 0.11488157f, 
    -0.06720265f, -0.02064987f, 0.14286327f, 0.18559024f, -0.13216065f, 0.04521478f, -0.02852718f, 0.03549572f, 
    0.00513196f, 0.00454332f, -0.00524279f, 0.15923361f, 0.01121730f, -0.13587120f, -0.06079752f, -0.02875369f, 
    -0.01530667f, 0.08784645f, 0.02336891f, 0.08335166f, -0.06692535f, -0.03184471f, -0.03769664f, -0.03835004f, 
    0.01641206f, 0.24669614f, 0.10201688f, 0.02981568f, 0.03616625f, 0.07943087f, 0.06849790f, 0.06396555f, 
    0.15017490f, -0.01602014f, -0.10880506f, 0.06766863f, 0.02528930f, 0.18506125f, 0.12985010f, 0.13882129f, 
    0.02451670f, -0.03846886f, -0.00765304f, 0.09334614f, 0.00166016f, 0.03711901f, 0.06314593f, 0.08274866f, 
    -0.19018108f, 0.06917303f, 0.13689961f, -0.21468094f, 0.13784739f, 0.05859569f, 0.08754176f, -0.00557483f, 
    0.08086777f, -0.08233783f, 0.06375161f, 0.05620553f, -0.10977916f, -0.00745490f, 0.08312456f, 0.05802597f, 
    0.11335475f, 0.00966411f, 0.04347288f, 0.00520240f, -0.07523566f, -0.07204793f, 0.10679371f, -0.06308761f, 
    -0.01835724f, -0.12230650f, -0.00396885f, -0.04105366f, -0.06611817f, -0.04238865f, -0.09624683f, -0.07220713f, 
    -0.00282401f, 0.04056546f, -0.05142508f, -0.12745295f, -0.54892164f, 0.16487806f, 0.00805484f, -0.03836570f, 
    0.00890770f, -0.05692058f, -0.01704640f, -0.09368367f, 0.01004977f, 0.04641692f, 0.05738096f, -0.16225813f, 
    0.10125718f, 0.02060707f, 0.09716300f, 0.01161312f, -0.06765184f, 0.02466356f, 0.09111781f, -0.01928396f, 
    0.05443205f, 0.05871196f, 0.05218349f, 0.13783774f, -0.21133919f, 0.03731174f, -0.24628666f, -0.04294017f, 
    -0.00283149f, 0.06490393f, -0.05239337f, 0.09753249f, -0.08363833f, 0.17530194f, -0.10421143f, -0.00508011f, 
    -0.01657709f, -0.20975441f, 0.01114824f, -0.03953424f, -0.13874248f, 0.00747297f, 0.09936137f, -0.00252890f, 
    -0.01567428f, -0.09037743f, -0.03465889f, 0.02235079f, -0.18429667f, 0.11491895f, 0.13299675f, 0.04034812f, 
    -0.03712102f, 0.00090112f, 0.06674127f, 0.08193855f, 0.03737123f, -0.07317429f, 0.14670196f, -0.11823498f, 
    -0.08662982f, -0.22906889f, -0.04104950f, -0.18456113f, 0.07486911f, -0.02284333f, -0.16713540f, 0.08200837f, 
    0.03272116f, 0.05912586f, 0.09571100f, 0.06684396f, -0.22374898f, -0.02319937f, 0.00531972f, -0.03916982f, 
    0.16797414f, 0.08773923f, -0.03431043f, 0.04718098f, 0.02153854f, -0.06558133f, 0.21780910f, -0.06563783f, 
    0.00584813f, -0.21189554f, -0.03859418f, 0.01498139f, 0.06004250f, -0.00342582f, 0.23971520f, 0.06870116f, 
    -0.02901367f, 0.01582414f, -0.05266643f, 0.08474116f, -0.09634044f, 0.10190579f, -0.06057591f, 0.18087019f, 
    -0.08214229f, 0.05064001f, 0.07047487f, 0.01682741f, 0.16310820f, 0.08358663f, 0.08466922f, 0.08081426f, 
    0.04204636f, -0.05577856f, -0.07424302f, 0.00416179f, -0.02920527f, -0.00967515f, 0.03392897f, -0.01777399f, 
    -0.01759123f, -0.02347200f, -0.02210905f, -0.03164206f, -0.01025683f, -0.03807709f, 0.03246641f, -0.02775448f, 
    0.04352481f, 0.00551035f, 0.00452519f, -0.04298656f, 0.01143518f, -0.04071279f, -0.06312238f, 0.02956525f, 
    0.01287878f, 0.02740081f, 0.00826242f, -0.01785935f, -0.00783333f, 0.03378372f, -0.05018990f, 0.01881979f, 
    -0.00518232f, 0.05541629f, 0.00245877f, 0.05610653f, -0.04115149f, -0.02951150f, 0.01664320f, -0.02327825f, 
    0.02708413f, 0.05998432f, -0.03606453f, 0.05388115f, 0.00472197f, -0.04969772f, -0.07437620f, -0.06022026f, 
    -0.06693660f, 0.03720271f, 0.02704964f, 0.06686504f, -0.01725237f, -0.07858764f, -0.01048834f, 0.06104728f, 
    -0.07584488f, 0.05967927f, 0.02153919f, 0.02954795f, -0.01763631f, 0.04698863f, -0.06318417f, -0.05908221f, 
    -0.07238491f, -0.03350975f, -0.03148304f, -0.07072834f, 0.04375912f, -0.02598956f, -0.02282864f, -0.00278389f, 
    -0.01384095f, -0.07292164f, -0.05124135f, -0.00138631f, -0.05761302f, 0.05538233f, -0.06021533f, -0.05564241f, 
    0.00591882f, -0.03739347f, 0.05448325f, 0.06033286f, 0.03885025f, 0.00613714f, 0.05147930f, -0.03082725f, 
    0.06680033f, -0.01916211f, 0.07044637f, -0.00388535f, -0.05898231f, 0.06400184f, 0.00916245f, -0.03473081f, 
    -0.07052133f, 0.05452577f, -0.05386514f, -0.05307878f, -0.05419926f, -0.07842474f, 0.03656276f, 0.02169888f, 
    -0.03776102f, 0.03052488f, -0.06839646f, -0.05611836f, 0.01090560f, -0.01995530f, -0.02850500f, -0.01047073f, 
    -0.05951803f, -0.07329070f, -0.07210203f, 0.05882460f, -0.07406906f, 0.05842663f, -0.04800682f, 0.06332188f, 
    -0.07632631f, 0.02448764f, 0.06468358f, -0.02021798f, -0.03076006f, 0.04014600f, 0.06300593f, 0.00360626f, 
    -0.04972774f, -0.05817299f, 0.05995556f, 0.00260217f, 0.04368951f, 0.04545066f, -0.01075039f, -0.06583034f, 
    -0.00526628f, 0.02245411f, -0.01612292f, -0.00474795f, 0.00472787f, -0.06393222f, -0.04678635f, -0.06350656f, 
    0.01386000f, 0.03216679f, -0.01549237f, -0.05796281f, 0.04127327f, -0.06543174f, 0.01704303f, -0.02452040f, 
    0.04910028f, -0.07467592f, -0.04399298f, 0.06510049f, -0.00116786f, -0.06600559f, 0.01753050f, 0.02317871f, 
    0.02854164f, -0.01660774f, -0.07829446f, 0.03286850f, 0.05910370f, -0.07163130f, 0.04563233f, 0.00261109f, 
    -0.05552025f, -0.06064393f, -0.00659861f, 0.00358434f, -0.07891230f, -0.04282247f, -0.00217730f, -0.01181364f, 
    -0.04192317f, -0.00891887f, 0.02080897f, 0.02059810f, -0.00324108f, -0.06411892f, -0.04768204f, 0.02415036f, 
    -0.00723427f, -0.00903740f, -0.01702366f, -0.05045466f, -0.05887882f, -0.04932448f, 0.04569326f, -0.06712741f, 
    0.12179450f, 0.14761075f, 0.16730458f, 0.15374446f, -0.14405353f, 0.10007352f, -0.04823476f, -0.06679354f, 
    -0.04438942f, 0.04397707f, 0.03961243f, 0.00818888f, -0.46267220f, 0.05842101f, -0.05099497f, -0.11987736f, 
    0.09500781f, -0.08520029f, 0.02837894f, 0.03563266f, 0.05818124f, -0.04044746f, -0.05444646f, 0.06061189f, 
    0.08629546f, -0.10179408f, 0.08513322f, -0.19528642f, -0.02442263f, -0.04699918f, -0.13048945f, 0.03476673f, 
    -0.03111440f, -0.02140687f, -0.01308880f, -0.06383594f, 0.25408909f, 0.18445377f, 0.29488820f, 0.25548819f, 
    -0.00434404f, 0.00870602f, 0.00107848f, -0.06810036f, 0.01360397f, 0.04207752f, -0.09090240f, -0.05873915f, 
    0.62831241f, -0.02288670f, -0.03268748f, 0.16030936f, -0.05954089f, 0.02719090f, 0.01007412f, -0.00366331f, 
    0.05240776f, 0.08473349f, 0.02552137f, 0.03456947f, -0.23422509f, -0.00850659f, -0.23750839f, -0.21544215f, 
    0.13845982f, -0.08096055f, -0.02312254f, -0.06460278f, -0.03524156f, -0.00172849f, -0.11576051f, -0.10436592f, 
    0.12929973f, -0.00444467f, -0.14539357f, -0.25507575f, 0.05279773f, 0.08250768f, 0.16608080f, 0.18641768f, 
    0.08821473f, 0.04625381f, -0.00214906f, 0.05636968f, 0.40581557f, -0.17024641f, 0.14848302f, -0.23248076f, 
    -0.03048511f, 0.12087294f, 0.00488613f, 0.14027536f, 0.01474117f, 0.13861354f, 0.08241672f, -0.09975937f, 
    0.22955307f, 0.18708138f, 0.07235553f, -0.04498152f, -0.01708299f, 0.03240466f, 0.03493517f, -0.12432973f, 
    0.04318847f, -0.05812866f, 0.03387172f, -0.01601052f, 0.05801041f, -0.12214249f, -0.00599367f, 0.01935059f, 
    0.03706072f, 0.02983093f, 0.04064548f, 0.00254581f, 0.10687106f, -0.10998061f, 0.03609789f, -0.06068577f, 
    -0.29689145f, 0.08864927f, -0.05637411f, 0.09273643f, 0.12899278f, -0.06895048f, 0.07142918f, -0.00062698f, 
    -0.20009223f, -0.09195789f, -0.09015253f, -0.00606907f, 0.17511281f, -0.03481180f, 0.24368078f, 0.22223122f, 
    -0.07515962f, -0.06893146f, -0.05828213f, -0.10012539f, 0.01409207f, 0.13159999f, 0.11938372f, 0.05836066f, 
    -0.03413920f, 0.02404303f, -0.11543028f, 0.06182740f, 0.08728188f, 0.10648622f, 0.06824161f, 0.16520575f, 
    0.05962532f, -0.08125649f, 0.11835381f, -0.13996950f, -0.17226985f, -0.14130202f, 0.19000484f, -0.30233949f, 
    0.15313575f, 0.16326258f, -0.09084487f, -0.06452601f, 0.03674605f, 0.01750805f, -0.01014070f, -0.06613253f, 
    -0.17316957f, -0.00022364f, -0.15477146f, -0.17989500f, 0.14772423f, 0.06178294f, -0.06658371f, -0.22920398f, 
    0.06365170f, 0.14011693f, -0.00276071f, -0.03188261f, -0.02164700f, 0.03333337f, -0.09533166f, -0.21353981f, 
    -0.03016461f, -0.08462542f, 0.10612184f, -0.03712261f, 0.04377684f, -0.09673477f, -0.02294162f, -0.05437073f, 
    -0.16871347f, -0.11233475f, -0.04923214f, -0.12247694f, 0.14731948f, -0.07711222f, -0.11319079f, -0.13458923f, 
    -0.03020790f, 0.05866682f, 0.08140118f, -0.05736495f, 0.03160105f, 0.23484179f, 0.10107324f, 0.24302748f, 
    0.13415673f, 0.04179136f, 0.07093229f, 0.03677613f, -0.01773590f, -0.01924927f, 0.00069872f, -0.13285145f, 
    0.06219494f, 0.11735368f, 0.06190098f, 0.07893851f, 0.02775175f, 0.02766168f, -0.04536295f, -0.10075167f, 
    -0.08308975f, -0.02136435f, 0.01361669f, -0.12926698f, -0.09812095f, -0.10782196f, 0.00044279f, 0.22994573f, 
    -0.03624270f, 0.01126825f, -0.00351450f, -0.09524579f, -0.00906644f, -0.02402680f, 0.07688844f, -0.06849607f, 
    0.29293886f, 0.04826124f, -0.20506127f, 0.00861465f, -0.10224013f, 0.03295060f, -0.04504713f, 0.03941888f, 
    -0.00911289f, 0.12042200f, 0.00571085f, -0.04546248f, -0.02827304f, 0.16596740f, 0.01457116f, 0.05041392f, 
    -0.03323849f, -0.04742822f, -0.00849957f, -0.03168586f, -0.00647396f, 0.06826704f, -0.11348849f, 0.03980364f, 
    0.26871759f, 0.17250465f, -0.02031011f, 0.03537386f, 0.04751325f, 0.07807628f, -0.02581377f, 0.07679839f, 
    -0.02835591f, 0.02878005f, -0.08719295f, -0.09188981f, 0.30105776f, -0.07355540f, 0.12010633f, 0.09884942f, 
    -0.09695279f, -0.08727706f, 0.05891442f, 0.02641314f, -0.02397319f, 0.08520630f, -0.07419256f, -0.02613105f, 
    0.08458788f, -0.01778293f, -0.16301347f, 0.07693499f, 0.05339660f, -0.07153723f, -0.03658222f, 0.02720223f, 
    -0.08237672f, 0.05568271f, 0.07632109f, -0.04592373f, 0.22284231f, 0.05620404f, 0.14405698f, 0.10948598f, 
    -0.03651886f, -0.01103708f, 0.08779465f, 0.05218216f, -0.03988788f, -0.00408119f, -0.08830977f, 0.01283563f, 
    -0.05005767f, 0.05714479f, -0.16686475f, -0.08344433f, 0.01352662f, 0.06250943f, -0.02738454f, 0.03746483f, 
    -0.08893748f, 0.01363729f, 0.00285669f, 0.10037021f, -0.07249972f, -0.05865183f, -0.07627523f, 0.05430040f, 
    0.05901984f, -0.02920231f, -0.10770316f, -0.09569652f, 0.07288118f, 0.08915923f, 0.02997357f, 0.06284092f, 
    0.23601077f, 0.04883362f, -0.09913024f, 0.09052805f, -0.00808296f, 0.11723746f, 0.03386626f, 0.03483887f, 
    -0.06009593f, 0.01521914f, -0.03535324f, 0.12211049f, 0.01196552f, 0.08245215f, 0.08378126f, 0.13026012f, 
    -0.11693237f, 0.05036746f, -0.05683512f, -0.05200775f, -0.04392212f, 0.01085142f, -0.03198060f, 0.00032431f, 
    0.07599907f, 0.18337734f, 0.10992257f, 0.10895099f, -0.04169128f, 0.01433381f, -0.06142177f, -0.05498318f, 
    0.06807741f, -0.00100975f, 0.03423762f, -0.00991119f, -0.09193154f, 0.10745230f, 0.00440854f, -0.19326259f, 
    -0.12091408f, -0.10419883f, 0.04205538f, -0.10457778f, 0.00513942f, 0.00517566f, 0.07873729f, 0.04189246f, 
    0.19287708f, 0.27001721f, 0.08346061f, 0.05468166f, 0.06102497f, -0.03771854f, 0.04117106f, 0.08262514f, 
    0.12421499f, 0.05179657f, 0.05665030f, -0.10579129f, 0.24135439f, 0.06544580f, -0.20805222f, -0.06639431f, 
    -0.14127603f, 0.13740478f, -0.03628573f, -0.06843746f, 0.12396753f, 0.05654710f, -0.01130399f, -0.01555137f, 
    -0.12417058f, -0.27109179f, -0.03731699f, 0.10007763f, 0.00915393f, 0.07385114f, -0.03997855f, 0.03226102f, 
    0.02553320f, 0.11357479f, 0.11275910f, 0.14792158f, 0.12746502f, 0.10076898f, -0.12718882f, -0.34209594f, 
    0.01076176f, -0.03324463f, -0.01523566f, 0.14051901f, -0.06893569f, 0.06965353f, -0.16741948f, 0.12879881f, 
    -0.22887607f, 0.05693229f, -0.13137396f, 0.06505836f, 0.11814804f, 0.06047326f, -0.12790482f, -0.02109755f, 
    -0.13244613f, 0.08070257f, -0.02337742f, 0.02285240f, 0.10172834f, -0.10114680f, 0.04390693f, -0.06668808f, 
    -0.00494438f, 0.18177043f, 0.10749456f, 0.09260389f, 0.05992462f, -0.10496530f, -0.00934112f, 0.12926370f, 
    -0.21656010f, 0.04241422f, -0.12049796f, 0.05125074f, 0.09251052f, -0.09595105f, 0.20153321f, 0.04143695f, 
    0.02481178f, -0.07384104f, -0.01173071f, 0.18805140f, 0.04948286f, 0.07343742f, -0.11649489f, 0.07767105f, 
    0.07513095f, 0.17200670f, -0.00137445f, 0.09170385f, 0.10057349f, -0.00209641f, -0.03316118f, 0.12447416f, 
    -0.14687066f, -0.07438852f, 0.17752704f, 0.10483737f, -0.05566666f, -0.00590823f, -0.12248857f, 0.06906713f, 
    0.06870528f, 0.08783150f, -0.07103661f, 0.04851848f, -0.23378235f, 0.02622977f, 0.05976787f, 0.00067169f, 
    -0.02116970f, 0.06937339f, 0.05795891f, -0.00278775f, 0.05258594f, -0.15217766f, 0.20947094f, -0.01862780f, 
    -0.02822613f, -0.02156885f, 0.18756796f, 0.02264323f, 0.03805426f, 0.00986623f, -0.05527270f, -0.10740606f, 
    0.07422723f, 0.08025075f, 0.12643151f, 0.01174649f, 0.12216122f, 0.15941961f, -0.08871812f, -0.06029428f, 
    0.05263999f, -0.03385945f, 0.00165813f, 0.01371679f, -0.01564981f, 0.01867970f, 0.03685328f, 0.05386116f, 
    -0.03894065f, 0.04592517f, 0.01620124f, 0.17765482f, -0.10875069f, 0.07034056f, 0.01268240f, -0.06229600f, 
    0.07248284f, -0.14790507f, -0.03870127f, -0.04887245f, 0.24198242f, -0.17584915f, -0.04839252f, 0.09800235f, 
    0.01512932f, -0.22764793f, -0.02361410f, 0.12405124f, 0.01429353f, 0.02528724f, 0.02129591f, -0.05798389f, 
    -0.02022743f, 0.00971530f, -0.08236112f, -0.14215526f, 0.02807633f, 0.18556808f, -0.01505287f, 0.08758235f, 
    0.07594445f, 0.07509843f, 0.06781044f, -0.04326685f, -0.05005574f, -0.22767995f, 0.01976551f, 0.02884679f, 
    0.20323691f, 0.06755482f, -0.00197141f, 0.00589092f, -0.08460218f, 0.03176614f, -0.06695919f, -0.06306320f, 
    0.00063300f, 0.00324073f, -0.00501028f, 0.18409058f, -0.12419673f, 0.03387124f, 0.01917993f, 0.02787803f, 
    -0.09464049f, 0.00540038f, -0.13742416f, 0.00113124f, -0.08009123f, -0.11684040f, -0.05836160f, -0.00727513f, 
    0.03432431f, 0.05472876f, -0.07511086f, 0.09605944f, -0.04512973f, 0.00998354f, -0.03805599f, -0.08622687f, 
    -0.36261430f, 0.15955284f, 0.18778630f, -0.17256716f, 0.06143524f, 0.20281090f, -0.01176129f, 0.03235509f, 
    -0.05858178f, -0.13315627f, -0.03237356f, -0.04437120f, 0.23340398f, 0.35782495f, -0.07993063f, 0.15185207f, 
    0.01842153f, -0.09319117f, 0.06564085f, 0.08268777f, -0.00439284f, 0.00237612f, 0.00729749f, -0.04985079f, 
    -0.14702794f, 0.04978969f, -0.17705327f, -0.05342186f, -0.07959648f, -0.14332201f, 0.08081112f, 0.05277825f, 
    0.00560839f, -0.00683159f, 0.11925890f, 0.00341191f, -0.21231280f, 0.03746353f, 0.18469800f, -0.07655461f, 
    -0.07805412f, -0.11572642f, 0.20640543f, -0.15384883f, 0.06614605f, -0.06191414f, -0.05381335f, -0.05253089f, 
    0.22844982f, 0.11457984f, 0.15267655f, -0.04276948f, -0.01536418f, 0.03555612f, -0.03967408f, 0.07654507f, 
    0.03835817f, 0.03598369f, 0.04586410f, 0.04418631f, -0.07921144f, 0.26600641f, 0.03745416f, 0.08893624f, 
    0.13731086f, -0.15111472f, 0.02739752f, 0.00487513f, 0.07541173f, 0.07444812f, 0.01058225f, 0.01608893f, 
    -0.10484993f, -0.13943155f, 0.08119325f, -0.04368920f, -0.08303073f, -0.14042383f, 0.04664353f, -0.02382038f, 
    0.07528945f, 0.07362609f, 0.03603378f, -0.00354431f, -0.02178499f, 0.06303975f, -0.14624053f, 0.03896488f, 
    -0.04966956f, 0.03947229f, -0.10474724f, 0.15215774f, -0.01476630f, -0.04941187f, 0.05887332f, -0.02736283f, 
    0.15473105f, -0.06555123f, -0.00160648f, -0.15111972f, -0.13718028f, -0.05211060f, -0.00177859f, 0.03086136f, 
    -0.01536526f, -0.07272904f, -0.03452158f, -0.00622174f, -0.05462987f, 0.37835515f, 0.03765972f, 0.08685625f, 
    0.02296633f, 0.04830521f, 0.06466962f, -0.00702504f, 0.01204284f, -0.00455040f, 0.01583706f, -0.08603121f, 
    0.04634167f, 0.07979172f, -0.03397353f, 0.03569553f, 0.07679525f, 0.04186872f, 0.08647791f, -0.06417577f, 
    0.03634694f, -0.01211643f, 0.00435081f, 0.06582242f, -0.03666596f, -0.20665903f, -0.07419435f, 0.01173825f, 
    0.08034663f, 0.03014988f, 0.05458179f, 0.01108284f, -0.05264273f, -0.03051128f, 0.07631199f, -0.10092379f, 
    -0.07985424f, -0.27989268f, -0.12339458f, 0.18734019f, -0.03700123f, 0.01272987f, 0.03686422f, 0.13360721f, 
    -0.12698346f, -0.00189118f, -0.08950827f, -0.02458729f, 0.03170604f, 0.12211543f, 0.26773113f, -0.05120797f, 
    0.04063873f, 0.04322890f, 0.07405520f, 0.07825693f, 0.06243601f, -0.02475784f, 0.09851405f, 0.04910949f, 
    -0.03889346f, -0.00955882f, 0.01379098f, 0.06078679f, -0.03365589f, -0.04961700f, -0.04987850f, 0.03381477f, 
    -0.01088287f, -0.05172603f, 0.01648000f, -0.04246541f, 0.06014271f, 0.06179050f, -0.06802026f, -0.03651091f, 
    -0.03088946f, 0.00823139f, -0.04861602f, -0.07344997f, -0.03870710f, 0.00692689f, 0.00874787f, 0.03804290f, 
    -0.03118718f, -0.00854947f, 0.01744856f, -0.06412112f, -0.04505369f, 0.03775981f, -0.03761799f, -0.05052556f, 
    -0.06818789f, -0.04992606f, -0.07692917f, -0.04557561f, 0.01811680f, -0.04590429f, -0.05664307f, -0.01057191f, 
    -0.04669556f, -0.00472704f, 0.03960167f, 0.00321626f, 0.04124968f, -0.03063486f, -0.04177557f, -0.00128971f, 
    -0.03367292f, 0.04090347f, 0.04392628f, 0.03425660f, 0.05211864f, -0.01210808f, -0.06460460f, -0.06709196f, 
    0.00235235f, -0.07742800f, -0.00302581f, 0.00872998f, 0.02471648f, -0.05712644f, -0.03069083f, -0.07813544f, 
    -0.04626121f, -0.00431691f, 0.06201501f, 0.04163865f, 0.05935606f, -0.05053926f, 0.05571378f, 0.02500698f, 
    0.01993073f, 0.02388700f, 0.01652890f, -0.00748223f, 0.04218305f, -0.01057575f, -0.06750984f, -0.00202777f, 
    0.02792218f, -0.06848501f, -0.00305368f, -0.03699477f, 0.04811097f, -0.06332974f, 0.04909101f, -0.02241861f, 
    -0.06079215f, -0.06284755f, -0.07142634f, -0.06029703f, 0.00504507f, -0.06438828f, 0.03464800f, -0.03796352f, 
    -0.06630235f, 0.05660100f, 0.02902602f, 0.01159666f, 0.05779570f, -0.01658231f, 0.06165518f, 0.04691299f, 
    -0.07106559f, -0.06669892f, -0.04382120f, -0.06512168f, -0.06030606f, 0.04355133f, -0.07067207f, -0.01443072f, 
    0.00425239f, -0.00522204f, -0.03015696f, -0.01526955f, 0.01384917f, 0.02713314f, 0.02188781f, -0.05086583f, 
    0.04591627f, -0.07550929f, 0.03142386f, -0.03134356f, -0.03913953f, 0.00142406f, -0.03583298f, 0.00921088f, 
    0.06337468f, -0.03070518f, -0.03308831f, 0.05837324f, -0.00096473f, -0.02064365f, 0.01226458f, -0.01466340f, 
    -0.00707186f, -0.02426710f, 0.01819966f, 0.01720278f, -0.02263588f, -0.03681338f, -0.01297622f, -0.06246837f, 
    0.01455898f, -0.06230816f, 0.01446510f, 0.00084884f, -0.05210236f, -0.03575823f, -0.02941181f, 0.04283225f, 
    -0.06887035f, 0.06050771f, -0.00739365f, -0.07140059f, -0.00939995f, 0.01916143f, 0.00053912f, 0.02052228f, 
    0.02670601f, -0.05245920f, 0.01069760f, 0.01360692f, 0.00410228f, -0.02502949f, -0.02848575f, 0.05555984f, 
    -0.01137518f, 0.05702778f, -0.00530683f, 0.02035743f, -0.05685243f, 0.02524401f, 0.01223307f, 0.04841315f, 
    -0.05528252f, 0.03155731f, 0.05094619f, -0.03672366f, -0.00157156f, 0.01017740f, -0.03357106f, -0.07427637f, 
    -0.07897385f, -0.01947290f, 0.00790639f, -0.06290346f, 0.00106278f, -0.05499883f, -0.02686267f, -0.07120605f, 
    0.26610276f, 0.25340000f, -0.02325942f, -0.02545030f, -0.02499489f, 0.03913724f, 0.04505956f, -0.01943861f, 
    -0.08375215f, -0.03065643f, 0.07943839f, -0.07204319f, 0.26396692f, 0.07566238f, -0.04520696f, 0.08010077f, 
    -0.06791681f, 0.01908100f, 0.03021107f, 0.03469532f, 0.06170639f, 0.01743470f, 0.07176773f, 0.03684352f, 
    0.17434265f, 0.07518950f, -0.11616636f, 0.26275885f, -0.05848036f, 0.10190041f, -0.17214212f, 0.01474147f, 
    -0.02021460f, -0.04346171f, 0.24514586f, 0.09201213f, 0.20915239f, 0.21226548f, -0.05579713f, -0.07382137f, 
    -0.07669114f, 0.15848200f, 0.08579393f, 0.05858613f, 0.01438185f, -0.02894589f, -0.08930363f, 0.16397469f, 
    0.27804732f, 0.03248639f, -0.04178877f, 0.01285045f, -0.10023309f, 0.06656472f, -0.04378705f, 0.04302460f, 
    -0.13648249f, 0.09944706f, -0.12371304f, -0.02824728f, 0.05399485f, -0.10969187f, 0.07906820f, 0.09549088f, 
    -0.03118083f, -0.01036449f, -0.07498793f, 0.06473328f, -0.09572328f, -0.04263024f, -0.06855204f, 0.09428807f, 
    0.07868389f, 0.12290635f, -0.08413473f, 0.16170071f, 0.05632054f, 0.14187728f, 0.25258783f, 0.07417812f, 
    0.00198142f, -0.00428655f, 0.15036553f, 0.27523959f, -0.07529279f, -0.17938147f, 0.11013188f, 0.02631476f, 
    0.08067323f, -0.01140345f, 0.01049380f, 0.10486104f, 0.07671147f, -0.11843953f, -0.02000168f, 0.15074401f, 
    -0.36140704f, -0.12331650f, 0.21450026f, 0.09197135f, -0.09009238f, 0.05496776f, -0.06736469f, 0.03658234f, 
    0.15456071f, -0.16500728f, -0.20635901f, -0.11889587f, -0.08672862f, 0.10642733f, 0.08591706f, 0.13084075f, 
    -0.05418748f, -0.02424619f, 0.06045469f, 0.08850309f, -0.04022856f, -0.07635182f, 0.11892580f, -0.05985809f, 
    0.03612375f, 0.04388444f, -0.11814947f, 0.03870147f, -0.00718924f, 0.15224753f, -0.04314444f, 0.02913328f, 
    0.00489490f, 0.10983906f, 0.05461772f, 0.04581891f, -0.07171416f, 0.20239697f, -0.08108883f, -0.03493484f, 
    0.01183046f, -0.04267825f, 0.05086725f, 0.04565466f, -0.13648602f, 0.02245211f, 0.06519403f, -0.03819501f, 
    0.11498420f, 0.01070616f, 0.07392107f, -0.01521146f, -0.14164111f, 0.00343162f, 0.10066090f, 0.00385796f, 
    0.02894610f, -0.18781362f, 0.06934180f, -0.18430975f, -0.20669985f, -0.02134884f, 0.09625339f, -0.04864531f, 
    -0.06795765f, -0.12800168f, -0.10438053f, -0.02301948f, 0.09550250f, -0.03934883f, -0.11563007f, 0.03744549f, 
    0.01138366f, 0.03093037f, 0.04621528f, 0.09328824f, -0.05097267f, 0.00872423f, -0.10708588f, -0.04623466f, 
    0.06384157f, 0.00814596f, 0.09142599f, 0.01873403f, -0.19849005f, -0.09678848f, 0.00297383f, 0.19964543f, 
    -0.00531972f, 0.07797749f, -0.03147419f, -0.05050435f, -0.08597817f, 0.03866766f, -0.19849358f, -0.05366080f, 
    0.06467631f, -0.02445342f, -0.06639989f, 0.02777640f, 0.00789086f, 0.01928943f, 0.01727874f, -0.06555080f, 
    0.01176049f, -0.04058566f, -0.01891694f, 0.02652743f, 0.02132176f, -0.06510990f, -0.03201699f, -0.01396354f, 
    0.03568056f, -0.04055178f, -0.05452342f, 0.03261393f, -0.03325554f, -0.00349265f, 0.00820211f, 0.00635089f, 
    0.01242146f, -0.00197524f, 0.02421009f, 0.05149806f, -0.06156050f, -0.00246417f, -0.01822150f, -0.04219572f, 
    0.03035916f, 0.01865838f, -0.06344542f, 0.05800265f, 0.00548068f, -0.05347044f, -0.07167072f, -0.03835003f, 
    0.01839370f, 0.00799363f, -0.01917669f, 0.05959702f, 0.04620623f, 0.04505071f, -0.07032736f, 0.05399757f, 
    -0.06325655f, 0.00223082f, -0.02354469f, -0.00435843f, 0.04802165f, -0.01592155f, -0.00004312f, 0.04236829f, 
    -0.05501170f, 0.05375927f, -0.05832516f, 0.04008859f, -0.00594778f, -0.05296493f, -0.02707735f, -0.02259316f, 
    0.05466795f, 0.01591386f, 0.01020357f, -0.01132552f, -0.02370423f, 0.01385705f, -0.07797402f, 0.04280001f, 
    0.04727456f, -0.04486134f, -0.05248865f, 0.04503253f, -0.02446344f, 0.03649655f, -0.04777739f, -0.02288184f, 
    0.00052656f, 0.00863939f, -0.05620397f, 0.02085143f, 0.05165958f, -0.07923833f, 0.01484248f, -0.03435623f, 
    -0.00478229f, 0.03190333f, -0.00121132f, -0.03377920f, -0.07333592f, -0.05534526f, -0.00806529f, -0.01023597f, 
    0.03251280f, -0.01697795f, 0.04904589f, -0.07568700f, -0.02407203f, -0.06281012f, -0.07575287f, 0.01432299f, 
    0.03743599f, 0.01288144f, -0.04727615f, -0.02067157f, -0.07718157f, 0.00707364f, -0.00018685f, -0.05419176f, 
    -0.01341374f, 0.04830188f, -0.03591885f, 0.00788502f, 0.05500837f, -0.00905155f, -0.04992593f, -0.01282999f, 
    0.00582223f, 0.00216472f, -0.01109149f, 0.00821212f, -0.03244136f, -0.04648551f, 0.05931553f, -0.07951429f, 
    0.06955869f, 0.04197930f, -0.03463984f, -0.04050449f, -0.05022554f, -0.01597237f, -0.03433967f, 0.04972239f, 
    -0.04489639f, 0.04471238f, 0.00288348f, 0.03021518f, 0.03281497f, 0.01379963f, -0.05865160f, -0.03219907f, 
    -0.04411505f, -0.07284667f, -0.00457574f, -0.04802864f, -0.03202366f, 0.02861583f, 0.04772703f, -0.06910198f, 
    -0.00806863f, -0.02434565f, 0.05203722f, 0.05677280f, -0.03603360f, -0.03593991f, 0.04588041f, -0.06401810f, 
    -0.04542987f, -0.00757551f, -0.05429819f, 0.00798189f, -0.07053766f, -0.06987856f, 0.05873262f, -0.03174879f, 
    0.01384358f, -0.00703089f, -0.04254538f, -0.04816226f, 0.03772832f, -0.02827997f, 0.02789752f, -0.05706849f, 
    -0.03414848f, -0.03316473f, -0.03456819f, -0.04561572f, -0.06088218f, -0.06782517f, -0.02478835f, 0.05537374f, 
    -0.02152385f, 0.03445489f, 0.00773639f, -0.05269485f, 0.03855382f, -0.02917732f, -0.07131085f, -0.01001523f, 
    -0.12796932f, -0.13490884f, -0.15393938f, -0.15037957f, 0.07828042f, 0.08040790f, 0.01682877f, -0.08336607f, 
    0.09020953f, 0.00371083f, 0.04637376f, -0.12958622f, 0.15846312f, -0.11167610f, -0.04686631f, -0.09478954f, 
    0.01762561f, 0.12201151f, -0.00168150f, 0.09862044f, 0.08265678f, 0.04447762f, 0.04185398f, 0.09447040f, 
    0.05555669f, -0.00584185f, 0.08278539f, 0.00535166f, -0.01236672f, 0.06073057f, -0.07634732f, 0.09755353f, 
    0.02694605f, 0.06577876f, 0.06701749f, -0.03505553f, -0.37576681f, 0.02457739f, 0.02319058f, 0.00996156f, 
    0.19472440f, 0.06702042f, -0.01679559f, 0.01611417f, -0.03344267f, 0.06347381f, -0.04655811f, 0.07222880f, 
    0.25498131f, 0.08171923f, 0.05202463f, -0.00160716f, 0.11178488f, 0.11995396f, 0.04050409f, -0.10250767f, 
    0.00317050f, -0.00662713f, -0.06880390f, -0.07112853f, 0.07361601f, -0.07902970f, 0.03405827f, -0.21581484f, 
    0.14317554f, 0.04097883f, -0.07858145f, -0.05611254f, -0.00316379f, -0.06173655f, -0.00582972f, 0.09483939f, 
    -0.19374000f, 0.20122860f, 0.09668562f, 0.15434472f, -0.10726926f, 0.07746956f, 0.17320479f, 0.10836646f, 
    0.14321908f, -0.04590788f, 0.05460726f, 0.19107614f, 0.06618956f, -0.18250635f, -0.04357782f, -0.11439985f, 
    -0.10569895f, -0.17556357f, -0.14740853f, 0.03836793f, 0.13496158f, -0.02804943f, 0.07740124f, 0.02285288f, 
    -0.05700877f, 0.12988280f, 0.21465619f, 0.11354420f, -0.01591771f, 0.12126419f, 0.02967092f, 0.14355800f, 
    0.05323981f, -0.01035351f, -0.05810751f, 0.00212181f, 0.17673945f, 0.12006447f, 0.04856332f, -0.03956946f, 
    -0.08501906f, -0.01120284f, 0.11466105f, 0.00165510f, -0.07484749f, -0.07390585f, 0.21229018f, 0.10996352f, 
    -0.19104227f, -0.10692114f, 0.16842310f, 0.08611657f, -0.10093477f, 0.24873801f, 0.10762029f, 0.01968504f, 
    0.04824049f, 0.06329460f, -0.04504173f, 0.11633704f, -0.22295317f, 0.16665642f, -0.07938597f, -0.17485948f, 
    0.10965712f, -0.07271384f, 0.05154625f, -0.02372315f, 0.02445046f, -0.07631680f, 0.09229401f, -0.06283313f, 
    0.21830519f, -0.01683385f, 0.09966245f, -0.08161674f, 0.00211920f, 0.07952166f, 0.23780195f, -0.04083186f, 
    -0.06494303f, -0.07751258f, -0.09206893f, 0.02493315f, -0.08432783f, -0.11733746f, -0.16852215f, 0.02628820f, 
    -0.04157278f, -0.22776064f, 0.01539461f, 0.00005752f, 0.03426562f, 0.08864669f, 0.03128413f, -0.03866581f, 
    0.15569690f, -0.00084133f, 0.05296398f, 0.05849337f, -0.03301553f, 0.00673118f, -0.07008972f, 0.07747099f, 
    0.10339122f, -0.08377202f, 0.07771980f, 0.08509080f, -0.22873564f, -0.02062247f, 0.25492379f, 0.06456704f, 
    0.05232038f, -0.01325201f, -0.04381551f, 0.05946721f, 0.02300283f, -0.00352736f, -0.10869051f, 0.04760741f, 
    0.21199362f, 0.15677065f, -0.03573253f, 0.17167006f, 0.01581439f, 0.15317667f, 0.07275580f, 0.13391344f, 
    -0.09877880f, 0.01949750f, 0.09107537f, -0.06627177f, -0.02300646f, 0.09093388f, 0.12260579f, -0.08844624f, 
    0.16496742f, 0.02182662f, 0.03819209f, 0.03071214f, -0.05988713f, -0.06206865f, -0.00180402f, -0.18403050f, 
    0.07165460f, -0.01227338f, 0.19088507f, -0.02961260f, -0.13535804f, 0.05583556f, 0.06161544f, 0.02368201f, 
    0.04677647f, -0.02295282f, 0.04714398f, -0.01429073f, 0.32590911f, -0.05867969f, -0.05151874f, 0.35547146f, 
    -0.10047150f, 0.03786719f, 0.11532445f, -0.00305784f, 0.02374068f, 0.09430759f, 0.00315128f, -0.08883873f, 
    0.20616686f, 0.02955207f, -0.31083333f, 0.17321596f, -0.15017889f, -0.07519413f, 0.01315361f, -0.02812770f, 
    0.01134831f, -0.03393217f, -0.03880629f, 0.07420066f, -0.29422206f, -0.01983247f, 0.06517286f, -0.00589123f, 
    -0.00652042f, -0.09185367f, 0.00569857f, 0.05294765f, 0.08907702f, -0.03753502f, 0.11400095f, 0.00829407f, 
    0.56128860f, 0.03257723f, -0.20795771f, -0.24816978f, 0.09698187f, 0.07707450f, 0.10433331f, -0.07989998f, 
    0.00721759f, 0.03762816f, 0.13712151f, -0.02540996f, -0.08766507f, 0.09199040f, 0.32231224f, 0.08611453f, 
    0.00838822f, 0.12611327f, 0.07188958f, -0.01192791f, 0.13794455f, -0.00893125f, 0.06707636f, -0.03196303f, 
    -0.00187837f, -0.05872906f, -0.12298354f, -0.07007886f, -0.04926717f, -0.03937479f, -0.03172447f, 0.00431622f, 
    0.02618622f, 0.01012642f, -0.02555940f, -0.05934007f, -0.24398279f, 0.05484729f, -0.03604716f, -0.08278000f, 
    0.04706421f, -0.05265114f, 0.05381216f, 0.00152205f, 0.09917403f, -0.07149596f, 0.02383574f, 0.06880092f, 
    0.24388023f, 0.28028187f, -0.20043328f, -0.21396597f, -0.01976192f, -0.09437605f, -0.06794796f, 0.03458802f, 
    -0.08412273f, -0.03387409f, 0.09956314f, 0.01232386f, 0.26075140f, 0.02149871f, 0.15236178f, 0.31196019f, 
    0.03626813f, 0.03941593f, -0.12185267f, 0.04186717f, -0.20307304f, 0.09666518f, -0.04981326f, 0.00679851f, 
    0.04496726f, 0.11179597f, -0.15652372f, 0.02373272f, 0.12614620f, 0.02348838f, -0.11245598f, 0.09123962f, 
    0.05222023f, -0.17533655f, 0.12749544f, -0.02614126f, -0.08789465f, 0.13908142f, 0.16386925f, -0.13080253f, 
    -0.02507721f, -0.02942615f, -0.01869630f, 0.04769056f, 0.01594964f, -0.03869475f, -0.11521272f, -0.02678796f, 
    -0.17671244f, 0.10482948f, -0.03263898f, -0.02689757f, 0.01686263f, 0.02801016f, -0.10654131f, -0.04705124f, 
    0.01868988f, 0.12102946f, 0.11706321f, -0.11349490f, -0.07069604f, 0.14978653f, 0.00925031f, -0.14915891f, 
    -0.09728079f, -0.07925440f, 0.14600377f, -0.16691442f, 0.03324541f, -0.02996795f, -0.05413690f, 0.11517625f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05052448f, 0.06034349f, 0.00460602f, 0.01566571f, 0.12546204f, 0.05293166f, -0.07550607f, -0.09522836f, 
    -0.05410843f, 0.02724061f, 0.00748982f, -0.01122856f, -0.06815873f, -0.00578146f, -0.04518770f, -0.01668373f, 
    0.18396395f, 0.13432088f, 0.03345427f, -0.05098398f, -0.00879180f, -0.02341014f, 0.04414342f, 0.11035427f, 
    0.01747393f, 0.11402572f, 0.03079212f, 0.08053186f, -0.02533944f, 0.04844890f, 0.03888860f, -0.05423333f, 
    0.06304987f, 0.03187507f, -0.05580369f, 0.03638680f, -0.12023628f, 0.02087024f, -0.13012786f, 0.12605414f, 
    0.03193372f, 0.03675422f, 0.11421055f, -0.06219199f, 0.09223301f, 0.06536801f, 0.06353145f, 0.00689725f, 
    0.07826489f, 0.05819250f, 0.01662514f, 0.01609774f, -0.09920011f, -0.07437982f, 0.04479095f, -0.07576904f, 
    -0.00205170f, 0.12419251f, -0.02348675f, -0.02887125f, -0.07150204f, 0.05144279f, 0.05540846f, -0.17283428f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09447511f, -0.11264737f, 0.00921148f, 0.12122101f, 0.13065231f, 0.03848082f, -0.03702286f, 0.01288192f, 
    0.02314167f, -0.07028587f, 0.15081440f, 0.24256097f, -0.05415282f, 0.03639384f, -0.02530718f, 0.10680977f, 
    -0.05185879f, -0.13411343f, -0.25495878f, 0.23347798f, -0.02684882f, 0.09491634f, 0.20773987f, -0.12417418f, 
    -0.16045822f, 0.10145781f, 0.02496531f, 0.18503231f, -0.34505472f, -0.07364508f, 0.06123669f, -0.06015999f, 
    -0.06245262f, 0.05383040f, 0.07444946f, -0.08343951f, -0.05712483f, 0.16651878f, -0.15055400f, 0.04053176f, 
    0.18651019f, -0.26706311f, 0.19765079f, -0.11526510f, -0.30433753f, -0.14230967f, -0.10693584f, 0.18821357f, 
    -0.04250789f, 0.04389705f, 0.18046677f, 0.24746951f, -0.11609582f, -0.10585552f, 0.05983543f, 0.02235928f, 
    -0.03739397f, 0.02068161f, 0.02710154f, 0.07175919f, 0.08250901f, -0.11848411f, -0.11761982f, 0.25880781f, 
    0.13140069f, 0.18324815f, 0.00303996f, -0.36866614f, 0.28828642f, 0.13261965f, -0.03422451f, -0.07611331f, 
    0.19873621f, 0.08370408f, 0.20864078f, -0.20541920f, 0.10214072f, -0.06537661f, -0.00851908f, 0.01679389f, 
    -0.03717888f, -0.11593287f, -0.28797635f, -0.02257212f, -0.13608092f, 0.01780598f, 0.29638818f, -0.07524903f, 
    0.12807655f, -0.18092443f, 0.00261610f, 0.06101334f, -0.17402813f, -0.05871294f, 0.09513900f, -0.10767802f, 
    0.28123438f, -0.11249175f, 0.08566511f, -0.01273803f, 0.05453262f, 0.00669446f, 0.33731496f, 0.27318004f, 
    0.06911060f, 0.02042987f, -0.07770140f, -0.32507142f, -0.10798132f, 0.26399004f, -0.15345161f, 0.32751960f, 
    0.10125224f, -0.11105834f, -0.05794503f, 0.27488837f, -0.23992269f, -0.15330499f, 0.07545430f, -0.13232310f, 
    0.15135565f, -0.19281293f, 0.08664785f, 0.04945583f, 0.02551005f, 0.07296485f, -0.03355257f, 0.00489376f, 
    0.16178530f, -0.00959188f, 0.08095458f, 0.32399637f, -0.04942225f, 0.14614262f, -0.01125102f, -0.01221680f, 
    0.19775900f, -0.08872520f, -0.18598622f, 0.00323445f, 0.01275576f, 0.01222147f, -0.08903493f, 0.02148939f, 
    -0.01831480f, 0.00385184f, 0.12126735f, 0.20074674f, 0.24222282f, 0.20963895f, 0.27006745f, -0.38482499f, 
    -0.03622648f, -0.13272697f, 0.08512691f, 0.09034550f, 0.20853466f, -0.09404569f, 0.05543931f, -0.00189410f, 
    -0.26098031f, 0.03891632f, 0.03587445f, -0.06554491f, -0.20499460f, -0.08090062f, -0.24528299f, -0.06969550f, 
    -0.19055349f, 0.14041056f, -0.13287029f, 0.04259042f, -0.07353171f, 0.17685811f, 0.17673670f, 0.19473793f, 
    -0.01876594f, 0.24413140f, 0.18515669f, 0.01582783f, 0.16504323f, 0.02768406f, 0.09010565f, 0.15326734f, 
    -0.05242699f, 0.20901749f, 0.19108294f, -0.05126451f, 0.08796491f, 0.11615793f, -0.04412631f, 0.08740991f, 
    -0.22116078f, 0.06067272f, -0.01103467f, 0.02950699f, 0.09064578f, 0.06391394f, -0.04066407f, 0.18091957f, 
    0.10045595f, -0.00322016f, -0.22689207f, 0.03199271f, 0.03983977f, 0.07081512f, -0.03082253f, -0.07291880f, 
    0.03560920f, -0.20722684f, 0.15579230f, 0.21616833f, 0.19702703f, 0.43369865f, 0.17245446f, 0.10826228f, 
    0.20799200f, -0.29992917f, 0.11404418f, -0.03771973f, 0.11810782f, 0.09316074f, 0.10914396f, -0.07620589f, 
    -0.02841075f, -0.05102285f, 0.09592442f, -0.02230387f, -0.18492612f, -0.01814481f, -0.10116139f, 0.07517084f, 
    0.05332943f, -0.03865223f, -0.32428700f, 0.01080915f, -0.21585360f, -0.25454041f, -0.02237819f, -0.17885886f, 
    -0.07126155f, -0.20968001f, 0.28377730f, 0.03354800f, 0.19698076f, 0.10443872f, -0.12360068f, 0.00719323f, 
    0.28584641f, -0.09284327f, 0.21904835f, -0.01945674f, 0.01909211f, -0.01055862f, -0.05789403f, -0.03096103f, 
    0.13762794f, 0.19063130f, 0.07887248f, -0.12548849f, 0.13249573f, 0.24181822f, -0.10951628f, 0.04464431f, 
    -0.13379289f, 0.05979141f, 0.13597365f, 0.19897451f, -0.01154447f, -0.03199348f, 0.10028200f, -0.09538326f, 
    0.18513864f, -0.22970022f, -0.29364198f, -0.15900013f, 0.39386711f, -0.30656162f, -0.25407761f, 0.21605377f, 
    -0.12916586f, 0.18973474f, -0.05082193f, 0.00793665f, -0.19087569f, -0.05064622f, -0.08222767f, -0.01254909f, 
    0.00124389f, 0.09314134f, -0.10070076f, -0.12160165f, -0.21556297f, -0.16344193f, 0.46545449f, 0.10046715f, 
    0.03431781f, -0.07508411f, 0.18905383f, 0.10611781f, 0.18058147f, 0.22261575f, 0.07210395f, 0.13670945f, 
    -0.08432388f, -0.03834949f, 0.12466142f, 0.11326203f, -0.42930865f, -0.10316295f, 0.10327149f, 0.30461061f, 
    0.13056214f, -0.11474104f, 0.11256666f, 0.10983124f, -0.13020231f, -0.10122178f, 0.25174797f, -0.04096046f, 
    -0.00783852f, -0.00314762f, 0.12382908f, 0.21243235f, 0.06477086f, 0.24293870f, -0.01476179f, -0.09405184f, 
    -0.04661771f, 0.06012053f, -0.00807353f, -0.18478355f, 0.01541113f, -0.02136095f, -0.09444609f, -0.05153130f, 
    -0.12767769f, 0.03241927f, 0.14005788f, 0.16864744f, 0.39515474f, -0.08467394f, -0.02761350f, -0.08145946f, 
    -0.19995554f, 0.12759137f, -0.02506496f, 0.09220576f, -0.05982999f, 0.06897452f, -0.04070437f, -0.05883606f, 
    -0.10850640f, 0.00530504f, -0.10836693f, -0.01489086f, -0.21152024f, -0.10971290f, 0.07079752f, -0.17196608f, 
    0.09256671f, -0.11029579f, 0.16300736f, 0.32339531f, 0.19418412f, -0.13650756f, -0.10518850f, -0.06733944f, 
    0.09314679f, 0.00599728f, 0.08492145f, 0.01289382f, 0.04867195f, -0.16305868f, -0.03089248f, 0.22368370f, 
    -0.19639292f, 0.25065351f, 0.10515859f, -0.04429576f, 0.13779588f, 0.04313938f, -0.05389947f, 0.04757727f, 
    -0.08473968f, 0.06006538f, 0.03318169f, 0.30246931f, 0.08994692f, -0.15038131f, -0.06527356f, 0.30525187f, 
    0.06256448f, 0.02358041f, 0.12857468f, 0.21501407f, 0.02888319f, -0.10820379f, -0.07423235f, -0.00497090f, 
    -0.06116346f, 0.13686755f, -0.02804697f, 0.07350544f, -0.13732786f, -0.19372509f, -0.14378110f, -0.25880647f, 
    -0.16672036f, 0.11155630f, 0.02820524f, -0.27574074f, 0.13008329f, -0.10866890f, -0.01666866f, -0.01150178f, 
    0.28336042f, -0.08502110f, -0.06507207f, 0.06191880f, 0.03941121f, 0.14004399f, 0.30282852f, 0.05860448f, 
    -0.05835339f, 0.06003750f, 0.11047114f, -0.09672030f, -0.14845482f, 0.19044110f, 0.12542753f, 0.13212492f, 
    0.10557386f, 0.33029729f, -0.18030414f, 0.02213996f, 0.03104931f, 0.11363748f, -0.11414000f, 0.32922921f, 
    0.24996108f, -0.30610439f, 0.11368783f, 0.01490180f, -0.08229268f, 0.10745294f, -0.09993055f, 0.32494479f, 
    0.20703888f, 0.00121091f, 0.06399792f, 0.05068832f, -0.00102390f, -0.06876888f, -0.04085661f, -0.26865396f, 
    0.12804312f, 0.05550767f, -0.19505900f, -0.11849964f, 0.05917054f, 0.02309093f, 0.02690787f, -0.04034725f, 
    -0.01254426f, -0.10084444f, 0.30267441f, 0.06172398f, 0.31448069f, -0.19398880f, -0.05866767f, 0.00656367f, 
    0.02370666f, 0.17268282f, 0.00074655f, 0.18595846f, 0.05349693f, -0.12063153f, -0.06428386f, 0.09077127f, 
    0.06465738f, 0.08170787f, 0.06561937f, 0.10679500f, -0.30022460f, -0.11649175f, 0.09324023f, -0.24354707f, 
    0.08294590f, 0.04876210f, 0.14175294f, 0.08099858f, 0.33484793f, 0.05013488f, 0.18646935f, 0.23754190f, 
    0.18337564f, 0.05279795f, -0.03178694f, -0.14523582f, -0.08294776f, -0.01779375f, -0.09162819f, 0.15174378f, 
    -0.31577522f, 0.17917374f, 0.10125128f, -0.09279894f, 0.19472395f, -0.03021651f, 0.24457262f, -0.29413408f, 
    0.03254293f, 0.28058761f, 0.03927764f, 0.06948937f, -0.03262376f, -0.04581984f, 0.01414654f, -0.03843859f, 
    -0.08745208f, -0.13542193f, -0.00331717f, 0.21822865f, -0.00915783f, 0.10947059f, -0.11136473f, 0.10426220f, 
    0.00535459f, 0.02321326f, -0.28297642f, -0.05382963f, -0.14720547f, -0.21536477f, -0.36156401f, 0.18412469f, 
    0.18794103f, 0.21144450f, -0.04589032f, -0.14031337f, 0.32839161f, 0.12273441f, -0.01589572f, 0.03378170f, 
    -0.29812589f, -0.12101536f, 0.09379685f, 0.06595296f, -0.05738012f, -0.24175820f, 0.20154089f, -0.05924684f, 
    0.06777761f, 0.22921409f, 0.11472187f, 0.41636220f, -0.03107542f, 0.22165835f, -0.05960422f, 0.06442729f, 
    -0.08081324f, -0.01281504f, 0.05010928f, -0.44473314f, 0.05005435f, -0.25728428f, -0.06970533f, 0.36184388f, 
    0.33232185f, -0.04716011f, -0.26188871f, 0.01657039f, 0.29204357f, 0.02896992f, 0.30956966f, 0.09925807f, 
    -0.01847062f, 0.37884262f, -0.04171883f, 0.10447587f, -0.03223461f, 0.03524825f, -0.02295211f, 0.19125980f, 
    -0.01351595f, -0.06542175f, 0.10081391f, 0.07278614f, -0.05385365f, -0.11330443f, 0.10479002f, 0.05866768f, 
    0.05964026f, 0.08945897f, 0.10128649f, 0.13643622f, 0.10019879f, 0.01339535f, -0.11192958f, -0.23103182f, 
    -0.25777316f, 0.08868308f, -0.07618178f, -0.07358700f, 0.00201343f, -0.04409869f, -0.08973753f, -0.00341401f, 
    -0.06645270f, -0.03127699f, 0.09459679f, -0.10105805f, -0.22148424f, -0.10566916f, -0.06965037f, 0.04037550f, 
    -0.17884287f, -0.29735351f, -0.22443612f, -0.19207038f, 0.39733687f, -0.27487844f, -0.08669793f, 0.11221901f, 
    -0.26110178f, -0.09270749f, 0.31600457f, 0.03954878f, 0.27882755f, -0.11499079f, 0.06993991f, -0.08955041f, 
    0.08583578f, 0.12378539f, 0.16832876f, 0.02339911f, 0.10828636f, 0.07906624f, 0.18620254f, 0.25985205f, 
    0.15946820f, -0.02159786f, 0.03716178f, 0.08507508f, 0.20453098f, 0.11026310f, 0.02693184f, 0.16200338f, 
    -0.08252148f, 0.15260810f, 0.37054420f, -0.19938366f, 0.07129823f, 0.08360159f, -0.04867721f, 0.09392470f, 
    -0.07314774f, -0.10448769f, 0.04209408f, 0.20272793f, 0.07574636f, 0.11410642f, 0.13536291f, -0.09689733f, 
    -0.20981008f, -0.00530121f, -0.22705866f, 0.11710723f, -0.16382022f, 0.01523356f, 0.04697073f, 0.11193171f, 
    0.14535385f, 0.00828645f, -0.06212006f, 0.09417980f, 0.46676025f, 0.19531125f, 0.18863529f, 0.04120412f, 
    0.12396930f, -0.27482322f, -0.17516288f, -0.02527953f, 0.01620651f, -0.23518358f, -0.00136538f, -0.06152539f, 
    -0.01991015f, 0.10106858f, 0.13062645f, 0.36672342f, 0.27014947f, -0.00712254f, -0.06738653f, -0.00116641f, 
    -0.18428987f, 0.12620646f, 0.02586764f, 0.09153270f, 0.23398586f, 0.02895392f, 0.07212661f, 0.30313787f, 
    0.25379494f, 0.27572563f, 0.03165819f, 0.03628030f, -0.00907606f, 0.12291028f, 0.11357391f, -0.24843965f, 
    0.17643252f, -0.04423462f, -0.35204813f, -0.20482975f, -0.03903359f, 0.12357295f, 0.02362380f, -0.01236619f, 
    0.02371990f, 0.01071378f, 0.12881267f, -0.01630590f, 0.11272297f, -0.00405908f, 0.29024729f, -0.23979670f, 
    0.13914758f, -0.04870783f, 0.03648024f, 0.00955580f, 0.25767586f, -0.01203280f, -0.08955206f, -0.01051588f, 
    -0.02324673f, -0.05030653f, -0.03852551f, 0.12010499f, -0.25097561f, -0.13638763f, 0.29907900f, 0.05747498f, 
    -0.22557357f, 0.25420538f, -0.18237695f, 0.04567294f, 0.01736262f, 0.37639382f, 0.15937626f, 0.33813253f, 
    0.00398376f, 0.09591565f, 0.10408045f, -0.31294656f, -0.08917573f, -0.21449251f, 0.12810357f, 0.18794557f, 
    0.05054411f, 0.05708615f, 0.04411855f, 0.09305783f, 0.26541144f, -0.06958437f, 0.18949476f, 0.07100674f, 
    -0.11576505f, -0.09120813f, -0.06865725f, 0.18452595f, -0.08962091f, -0.04150885f, 0.12193261f, 0.09185451f, 
    0.14728887f, -0.11046337f, 0.18901445f, 0.30547455f, 0.07804604f, -0.06686039f, -0.10690671f, -0.04064607f, 
    0.17574112f, 0.04764587f, 0.41212398f, 0.12201013f, -0.01789053f, -0.03431684f, -0.20506568f, 0.29924279f, 
    0.26402184f, 0.07184858f, -0.23050041f, 0.22964635f, 0.13620721f, -0.02872063f, -0.02791024f, 0.12877515f, 
    -0.05032750f, 0.03619717f, 0.02055304f, -0.03123041f, 0.24313073f, 0.24800169f, -0.32656968f, -0.27248797f, 
    0.19338520f, -0.11069997f, 0.20605418f, -0.11086813f, 0.05941623f, -0.33303264f, -0.05207625f, -0.42573142f, 
    -0.01349861f, 0.16834429f, 0.20259440f, -0.00802996f, 0.20823190f, 0.22908047f, 0.10484447f, -0.16179679f, 
    -0.16260384f, 0.05480124f, 0.02687297f, -0.01641177f, 0.00821745f, -0.00421099f, 0.07636372f, -0.25789532f, 
    -0.10206432f, -0.04597053f, 0.00646786f, 0.00360264f, -0.03180233f, 0.09030712f, -0.03167386f, -0.09556928f, 
    -0.13920046f, 0.07985923f, -0.10336887f, -0.02653050f, -0.11872938f, 0.08073346f, -0.03603968f, -0.08216804f, 
    -0.08161581f, 0.00214910f, -0.15380231f, -0.11663681f, -0.04074758f, 0.07304163f, -0.11762384f, -0.06164993f, 
    -0.00042802f, -0.10894597f, -0.07825550f, 0.11527001f, -0.16539843f, 0.08900362f, 0.05439870f, -0.04147261f, 
    -0.08097630f, -0.06216331f, -0.10857666f, 0.09325985f, -0.07985324f, -0.01240079f, 0.06672554f, 0.10651490f, 
    0.03798860f, -0.09198634f, 0.01786035f, 0.08107189f, -0.10636995f, 0.03230947f, -0.12801541f, -0.09005033f, 
    0.01636182f, 0.09936224f, 0.01670496f, -0.02140644f, -0.07678799f, 0.01933438f, -0.00067852f, 0.02142652f, 
    -0.00513210f, -0.10366981f, -0.07420848f, 0.00625044f, -0.06473889f, -0.11345065f, -0.06610443f, -0.07983683f, 
    -0.02481048f, -0.14725068f, 0.09621683f, -0.01124368f, 0.01843885f, 0.14935547f, 0.03126702f, 0.16213702f, 
    -0.26945010f, -0.04087958f, 0.13625401f, 0.06626769f, -0.00860037f, 0.07438118f, 0.05431793f, 0.02259819f, 
    -0.15490600f, -0.01037366f, -0.32183456f, 0.08987287f, 0.06496681f, 0.17019181f, 0.15036270f, -0.18439719f, 
    -0.27180713f, 0.15846585f, 0.28285182f, 0.22523472f, -0.47690126f, -0.02811417f, -0.09067442f, -0.05667288f, 
    0.06493699f, -0.11536495f, -0.12201267f, -0.01914795f, -0.10791063f, 0.08611856f, -0.07726378f, 0.28276935f, 
    0.16342478f, -0.14274275f, 0.10783143f, 0.02377598f, -0.08975127f, 0.08729104f, -0.04682354f, 0.21714079f, 
    -0.01178062f, -0.09335068f, 0.00358615f, 0.24956420f, -0.13407485f, -0.31220233f, -0.06631571f, 0.24071068f, 
    0.03613825f, 0.13453621f, 0.03712467f, -0.04974851f, 0.04001965f, -0.10681896f, -0.28375575f, 0.06236249f, 
    0.14710145f, 0.00380198f, -0.08658957f, 0.03485491f, 0.00166185f, 0.15445669f, 0.05448514f, 0.16314025f, 
    0.29293376f, 0.05790956f, -0.01589981f, -0.20863390f, -0.10902835f, 0.12009080f, -0.11658140f, 0.02389029f, 
    0.00148946f, 0.03123692f, 0.21555747f, 0.23866904f, -0.10529160f, 0.39903602f, 0.45142767f, -0.23607288f, 
    0.02148966f, -0.17668141f, 0.02337622f, 0.10688530f, -0.00119532f, -0.07000730f, -0.04338546f, -0.06544612f, 
    0.00939898f, -0.03008251f, 0.04594655f, -0.11948571f, 0.21961570f, 0.01751925f, -0.21390782f, 0.13249992f, 
    0.02790734f, 0.00084330f, -0.18785763f, -0.34217963f, 0.10423924f, -0.12040748f, -0.04841752f, -0.01660891f, 
    -0.05058622f, 0.19023280f, 0.03351386f, 0.10598923f, 0.51122695f, 0.20696597f, 0.11788407f, -0.32500288f, 
    -0.12159740f, 0.17630628f, 0.10605618f, -0.08416088f, 0.14120954f, -0.10248949f, -0.08763642f, 0.20061272f, 
    -0.10873694f, -0.12055121f, -0.07785766f, 0.17738907f, 0.09954596f, 0.13791755f, 0.07842789f, 0.20599756f, 
    0.00027180f, 0.13691859f, 0.20857306f, -0.26058757f, 0.01720452f, -0.09181755f, -0.03049882f, 0.01677031f, 
    0.12352171f, -0.02761752f, 0.06840465f, 0.17410262f, 0.12196989f, 0.07328380f, 0.11803960f, -0.10366578f, 
    -0.19723237f, -0.24665304f, 0.25454614f, 0.02427095f, -0.28020394f, -0.09818549f, -0.10849523f, 0.06244725f, 
    0.31374121f, 0.08859782f, 0.04877069f, -0.09254426f, 0.09038976f, 0.13978902f, -0.00636431f, 0.13232565f, 
    0.12950751f, -0.26057181f, 0.14070028f, -0.27319098f, 0.08225895f, 0.12082780f, 0.15715829f, -0.19509383f, 
    0.14252484f, 0.27263001f, -0.04859744f, 0.43646330f, -0.00724010f, 0.14968047f, 0.07979374f, -0.10192577f, 
    -0.09576088f, -0.01358568f, 0.32612777f, 0.08715613f, -0.07563917f, 0.11218732f, -0.23542947f, 0.18576699f, 
    -0.06349982f, -0.07289441f, 0.05021283f, -0.10301358f, -0.07152595f, -0.25247785f, -0.01617918f, 0.22680169f, 
    0.09294903f, -0.07438584f, 0.09014617f, -0.04963470f, -0.03533695f, 0.09272037f, 0.09252664f, 0.10541324f, 
    0.19746983f, 0.32112080f, 0.15666938f, 0.05520894f, -0.25481513f, 0.14456867f, -0.02766614f, 0.36026576f, 
    0.04951156f, 0.10455783f, 0.18978596f, 0.19925682f, 0.00844822f, 0.04195687f, 0.06146153f, -0.02707905f, 
    0.18236952f, -0.08189802f, 0.11867110f, -0.04797149f, 0.13872011f, 0.20363475f, -0.10835046f, -0.09647166f, 
    0.00076439f, 0.05037821f, 0.09154400f, -0.03064148f, -0.08905421f, -0.06337419f, 0.11808515f, -0.09855901f, 
    0.20028801f, 0.02808278f, -0.05581809f, -0.02595484f, 0.02116535f, 0.30157226f, -0.07373275f, 0.08826789f, 
    -0.10667966f, -0.04000985f, -0.03785664f, -0.03680144f, -0.19436245f, -0.03656019f, -0.10587183f, -0.00267716f, 
    0.07624555f, 0.30303377f, -0.09726702f, -0.20985743f, 0.18058856f, -0.20449363f, -0.00375929f, 0.10559510f, 
    0.07548228f, -0.11533720f, 0.26356199f, -0.34237784f, 0.07607459f, -0.07582913f, -0.06359763f, 0.01570229f, 
    0.11857965f, 0.19801305f, 0.14621498f, 0.18028152f, -0.25200838f, -0.13611807f, 0.00556828f, -0.04887231f, 
    -0.08882566f, 0.06104076f, -0.17834572f, 0.14606343f, 0.17643693f, 0.01947244f, -0.03595540f, 0.11931033f, 
    -0.07366126f, -0.13904333f, 0.04207703f, 0.00299006f, 0.28046167f, 0.00700076f, 0.42376184f, 0.01897229f, 
    0.06968379f, -0.03466281f, -0.22016042f, 0.08119509f, -0.07233676f, 0.00291120f, -0.14722839f, 0.18666534f, 
    -0.13992937f, -0.25337061f, -0.00573464f, 0.01456232f, 0.39671463f, -0.10288741f, -0.08016568f, -0.12725379f, 
    -0.21673889f, 0.26148063f, -0.06798275f, -0.09454729f, 0.18558687f, -0.00601795f, 0.10901891f, 0.11908188f, 
    0.04188543f, -0.16909890f, -0.00767712f, 0.28512451f, -0.17441680f, 0.15504105f, 0.01905485f, 0.07414124f, 
    0.06190836f, 0.03942319f, -0.02642515f, -0.08548682f, -0.07312215f, 0.09685414f, 0.11528988f, 0.10047640f, 
    -0.01403384f, 0.02147454f, 0.21199621f, 0.30055112f, 0.32569900f, -0.07479549f, -0.05680674f, -0.22912119f, 
    -0.33995494f, 0.07948510f, -0.04098848f, 0.01437986f, -0.13820584f, 0.09037030f, 0.10090355f, -0.02868757f, 
    0.12380248f, 0.11871684f, 0.08948146f, 0.02842185f, -0.26331419f, 0.16634972f, -0.18373777f, -0.20167962f, 
    -0.00969267f, -0.27893183f, 0.20526804f, 0.15240036f, 0.10984839f, -0.00838798f, 0.09141164f, 0.12591547f, 
    0.14824964f, 0.32484093f, 0.10592537f, 0.29055950f, 0.00905211f, 0.14280437f, 0.09690584f, 0.42280558f, 
    -0.15879226f, 0.12776449f, 0.38040078f, 0.02234416f, 0.16223782f, 0.03298137f, -0.04341675f, 0.15477787f, 
    0.33372545f, -0.16510159f, -0.07429752f, 0.03908338f, 0.17395118f, 0.29917482f, 0.11372129f, -0.22166240f, 
    -0.15468217f, -0.00441379f, 0.06489199f, 0.13254745f, -0.10144544f, 0.06922952f, 0.10362652f, 0.12557471f, 
    0.16440277f, 0.19075745f, 0.03336561f, -0.02245079f, 0.19444732f, 0.04143127f, 0.10693364f, -0.14919153f, 
    -0.06037408f, 0.19416782f, 0.18560663f, 0.10100933f, -0.07131097f, 0.08766352f, -0.08603171f, -0.02861140f, 
    -0.14924508f, 0.10760307f, 0.09829113f, 0.02453430f, -0.10771149f, -0.02483868f, -0.23410663f, 0.22605744f, 
    -0.06734996f, -0.05503377f, -0.00914857f, -0.22690931f, 0.17891540f, -0.13686971f, 0.14888829f, 0.00863195f, 
    0.19273874f, -0.06386951f, 0.07094825f, 0.14393012f, 0.01499681f, -0.07164813f, 0.02608933f, -0.15702628f, 
    -0.12317893f, 0.24398404f, 0.09395744f, 0.04969974f, -0.14045784f, 0.10410482f, 0.16065587f, -0.12376469f, 
    0.20219509f, 0.28416333f, -0.05659531f, -0.06051607f, 0.25903690f, 0.10702498f, -0.00718686f, -0.15151036f, 
    0.18008243f, -0.00203030f, 0.08686928f, -0.02922571f, -0.07077980f, 0.04517610f, -0.10548154f, 0.11091500f, 
    0.01898728f, -0.07750327f, 0.10175189f, 0.11161889f, 0.14004737f, -0.10373350f, 0.02130559f, 0.02355797f, 
    0.20450512f, -0.12251588f, -0.22804061f, -0.12350541f, 0.26064366f, 0.06738971f, 0.03508234f, 0.03448469f, 
    0.08317353f, 0.04382997f, -0.06385241f, 0.07770406f, 0.02238677f, 0.06550273f, 0.29510576f, -0.06043390f, 
    -0.08658449f, 0.08625357f, -0.22248806f, -0.15890750f, 0.19093148f, -0.11014814f, 0.08331422f, 0.24816911f, 
    -0.04368542f, -0.05118363f, 0.02810051f, 0.13481833f, -0.19837925f, 0.26412430f, 0.06312044f, -0.26757315f, 
    -0.07743055f, 0.15508582f, 0.19263288f, -0.12091586f, 0.20594715f, 0.07549839f, 0.37496465f, -0.31846580f, 
    0.02910559f, 0.27032471f, 0.05145861f, 0.00994338f, 0.09362390f, -0.23073018f, 0.08470377f, 0.15395911f, 
    -0.06259146f, -0.11979409f, 0.13820003f, 0.01072767f, 0.04123523f, -0.12567540f, -0.02822592f, -0.09294544f, 
    -0.08899800f, 0.13964082f, 0.14240800f, 0.02015788f, -0.18230194f, -0.25939643f, -0.05863936f, -0.06651851f, 
    -0.05688851f, 0.33632025f, -0.26460090f, 0.15192057f, 0.16452171f, -0.06310130f, -0.12401624f, -0.07409242f, 
    -0.11574752f, 0.05617316f, 0.09259956f, -0.11147416f, -0.01774807f, 0.09427963f, 0.16682589f, -0.15463594f, 
    0.02377411f, -0.10752608f, 0.09810506f, 0.06609378f, 0.16228822f, -0.32484373f, -0.17801896f, 0.22432677f, 
    0.11834232f, -0.21608274f, 0.05617312f, 0.02303550f, 0.21654376f, -0.14938290f, -0.02975155f, 0.03727088f, 
    -0.18561865f, 0.16609828f, -0.24447238f, -0.04929247f, 0.22299556f, -0.10064955f, 0.21241909f, -0.06579106f, 
    -0.04672826f, -0.08533999f, 0.01586005f, 0.00903169f, -0.11307602f, -0.08677965f, -0.04720342f, -0.12030721f, 
    -0.12407099f, -0.09857618f, -0.03009309f, -0.10276651f, -0.08571326f, 0.08754360f, 0.08673573f, -0.06808396f, 
    -0.05921219f, 0.04259924f, 0.01234736f, -0.02069494f, 0.02015904f, -0.12277542f, 0.09655099f, -0.04016835f, 
    0.00545661f, -0.08385125f, -0.01376589f, -0.01072603f, 0.08165403f, -0.02762444f, 0.11093935f, 0.01818317f, 
    0.08242337f, -0.09812345f, -0.02608308f, -0.00616647f, 0.11719554f, -0.02967257f, 0.11357383f, -0.01115025f, 
    -0.08014793f, 0.04231812f, -0.02391917f, -0.01176004f, 0.07661975f, -0.00998388f, 0.07191442f, 0.02919088f, 
    -0.10426024f, -0.07764933f, -0.05166496f, 0.06892926f, -0.09926348f, 0.08004807f, 0.08273093f, 0.05619477f, 
    -0.11708186f, 0.00977547f, 0.05132640f, -0.06772164f, -0.08802703f, -0.02969725f, 0.07520861f, 0.10379186f, 
    0.05967541f, -0.01571039f, 0.03908166f, -0.11420809f, 0.17320731f, -0.07484951f, -0.12176301f, -0.01271915f, 
    0.04080189f, -0.09266595f, 0.25793266f, -0.26508507f, -0.04693303f, 0.04850122f, -0.00102006f, 0.05654075f, 
    0.11169616f, 0.03363730f, -0.08282680f, -0.00563948f, -0.21030451f, -0.05794964f, -0.10976300f, 0.20666745f, 
    0.00801896f, 0.21941403f, 0.06324126f, 0.25928926f, 0.00837994f, -0.07694671f, -0.11164582f, 0.10115772f, 
    0.18584928f, 0.05770530f, 0.01903651f, -0.04808005f, 0.10018945f, 0.06971151f, 0.20775868f, -0.11638317f, 
    0.24923263f, -0.03613656f, 0.11200056f, 0.18031397f, -0.04437808f, -0.09471495f, -0.15888608f, 0.06945336f, 
    0.20464571f, -0.02284699f, -0.02829851f, -0.06189094f, -0.05456409f, -0.21001987f, 0.02129735f, 0.23970437f, 
    -0.10389547f, 0.09660235f, -0.27530730f, -0.02384399f, 0.01377586f, 0.07679069f, -0.13936651f, -0.01745649f, 
    0.02947881f, 0.09936781f, -0.11856952f, 0.03137366f, -0.12869568f, 0.09193827f, 0.06197737f, -0.05499440f, 
    -0.05019790f, 0.04960552f, 0.09254465f, -0.11892863f, -0.08220459f, -0.06090945f, -0.10241663f, -0.01591778f, 
    0.01179597f, -0.08710445f, 0.10627022f, 0.07638104f, 0.07470274f, -0.04889308f, -0.00760676f, 0.09635802f, 
    0.08549706f, -0.10818557f, 0.09325805f, -0.03150651f, -0.11214399f, 0.09470392f, -0.06504016f, -0.10718796f, 
    -0.07976378f, 0.03478514f, 0.10583352f, -0.01403922f, 0.06900902f, 0.09361614f, -0.10299710f, -0.06108866f, 
    -0.02432411f, -0.09735011f, -0.07099067f, 0.07761171f, -0.04813044f, 0.08296493f, -0.07437745f, 0.05124985f, 
    -0.08721843f, -0.07456633f, -0.12433501f, -0.00859104f, 0.06999403f, 0.00656931f, 0.07976426f, -0.05671743f, 
    -0.10492864f, -0.10477623f, -0.11002639f, -0.03678758f, -0.04223967f, -0.10672371f, 0.11605942f, -0.07796275f, 
    -0.06466909f, -0.24339153f, 0.10617878f, 0.36191481f, -0.12408099f, -0.13801225f, -0.06475886f, 0.16379523f, 
    0.03445861f, 0.08815415f, -0.04754023f, -0.00293764f, -0.05778696f, -0.01925726f, 0.08952758f, 0.03563542f, 
    -0.12122605f, 0.12806045f, 0.07226726f, 0.19228178f, 0.05926116f, -0.08900144f, -0.00094759f, -0.17756049f, 
    -0.00455539f, -0.11343918f, 0.04036010f, -0.05204767f, -0.00403481f, 0.02862343f, 0.11359333f, -0.07455649f, 
    0.34202510f, -0.11581060f, 0.05538709f, -0.05428566f, -0.24334380f, 0.16764909f, -0.15568425f, -0.01858624f, 
    -0.11184395f, 0.24365991f, 0.06400380f, -0.00740348f, -0.00496621f, 0.14046319f, 0.18091105f, 0.40400639f, 
    0.23033904f, 0.36655504f, -0.02085576f, 0.11549751f, -0.11694945f, 0.05519425f, -0.12634321f, 0.26423687f, 
    -0.12928970f, -0.11062234f, 0.14151584f, -0.08484253f, -0.08918098f, 0.11780502f, -0.11433104f, 0.11244899f, 
    -0.08265871f, 0.13418174f, -0.11213289f, -0.13987312f, 0.20922816f, -0.10060979f, -0.03698861f, -0.16835891f, 
    0.41511148f, -0.12322316f, -0.09603567f, -0.23809910f, -0.11763195f, 0.10728617f, 0.08067515f, 0.05512583f, 
    -0.02002478f, -0.27191082f, 0.24496046f, 0.20902337f, 0.10634641f, 0.21087745f, 0.17257257f, 0.28310442f, 
    0.32895291f, 0.00865171f, -0.22163780f, 0.10216919f, 0.23809983f, -0.04529731f, 0.05216528f, 0.09920087f, 
    0.05155187f, -0.08928886f, -0.01246304f, -0.03244535f, -0.05711708f, -0.16096950f, 0.19755796f, -0.05578179f, 
    0.17124605f, -0.00440427f, -0.13708222f, -0.01960288f, 0.15790074f, -0.18899098f, -0.22588296f, -0.09974420f, 
    -0.04934772f, -0.25958630f, 0.17854068f, -0.03920977f, -0.05272352f, -0.05521483f, 0.08746972f, -0.11195695f, 
    0.01735489f, 0.13320360f, 0.06263555f, 0.06815001f, 0.38953900f, 0.06116473f, -0.11256371f, -0.19303335f, 
    0.13709162f, -0.19389378f, -0.07994656f, 0.21915044f, 0.06824086f, 0.20280728f, 0.07936857f, -0.13687268f, 
    -0.24325004f, -0.06678698f, -0.03925569f, 0.17865981f, -0.05260170f, 0.07262775f, 0.06415576f, -0.09697410f, 
    0.04759989f, 0.09763872f, -0.29093927f, -0.10304149f, -0.09883788f, -0.00676356f, 0.27389786f, -0.23543102f, 
    -0.13757093f, 0.03408227f, 0.27583587f, 0.05168768f, -0.26151815f, -0.04058846f, 0.09943794f, 0.11166210f, 
    -0.11247133f, 0.10726396f, 0.02737088f, 0.08032903f, -0.08015126f, 0.16239856f, -0.28107157f, 0.18516645f, 
    0.16741313f, 0.16458967f, 0.05614552f, -0.19773702f, -0.20659830f, 0.11091490f, 0.14053920f, 0.04114144f, 
    0.12356672f, 0.08336388f, 0.04085705f, 0.15899891f, -0.19842099f, -0.34402406f, 0.03396347f, 0.00157883f, 
    0.07286744f, 0.17435375f, 0.08636334f, -0.03262669f, 0.02458071f, 0.06679735f, -0.10553339f, 0.05017690f, 
    -0.05370295f, -0.08037131f, 0.07730834f, -0.06760701f, -0.04217055f, 0.06914376f, 0.00399609f, -0.02156573f, 
    -0.11160904f, -0.03095738f, -0.00108339f, -0.04883292f, -0.08140351f, 0.07784584f, -0.01375730f, 0.08986655f, 
    0.05752299f, -0.06021674f, 0.09334022f, 0.06478264f, 0.04934350f, 0.02869519f, 0.02518124f, -0.02000199f, 
    -0.00368367f, -0.07379764f, -0.06490810f, -0.15233825f, -0.12310666f, 0.10631313f, 0.05743581f, -0.11264120f, 
    0.02516820f, -0.07866894f, 0.06053800f, -0.02648567f, 0.00234586f, -0.00980763f, 0.04557473f, -0.01537967f, 
    -0.10163197f, -0.00514778f, 0.00432768f, 0.01355270f, -0.05808094f, -0.08865694f, -0.13519803f, -0.10340507f, 
    -0.12094650f, -0.03449037f, 0.06186531f, 0.01035967f, 0.08349209f, -0.04930375f, -0.11197138f, 0.06339810f, 
    0.02000785f, 0.10484184f, 0.08613352f, 0.10631615f, -0.13918528f, -0.10323325f, -0.07494267f, -0.15044020f, 
    0.20782219f, 0.34026510f, 0.10348863f, -0.01962183f, 0.18609355f, -0.12907478f, -0.09780063f, -0.30035493f, 
    0.02702104f, -0.03312228f, -0.04796009f, 0.13708086f, 0.04804509f, -0.06629379f, -0.03668418f, 0.10629267f, 
    -0.01192162f, 0.11215971f, -0.27913272f, -0.19019613f, -0.02595140f, -0.16647746f, 0.02303681f, -0.06900036f, 
    0.15032738f, 0.11306515f, 0.00468115f, 0.19756266f, 0.16512452f, 0.06758840f, 0.08600282f, 0.08670796f, 
    -0.34677202f, -0.03363665f, -0.04122002f, 0.08067584f, -0.03720473f, -0.16045465f, 0.09947587f, 0.20736414f, 
    -0.02218658f, 0.38736448f, 0.04899560f, 0.19540253f, 0.19558200f, 0.15432823f, -0.02313746f, 0.20108794f, 
    -0.08952574f, -0.29960501f, 0.19380566f, -0.24034804f, -0.02589347f, -0.28612012f, -0.01917505f, -0.00359650f, 
    0.13620478f, 0.20234740f, -0.29887074f, -0.06566377f, 0.29074731f, -0.11074328f, 0.14153405f, -0.09572322f, 
    -0.14286785f, -0.01659552f, 0.07479060f, 0.03102988f, -0.07143057f, 0.06668405f, -0.12483872f, 0.36711520f, 
    0.11956431f, -0.12462856f, 0.23657569f, 0.04259575f, -0.03655265f, 0.02092929f, -0.10931528f, -0.06755522f, 
    -0.16706316f, 0.22567576f, -0.01112074f, 0.04734166f, -0.24825464f, -0.00258116f, 0.20737347f, -0.20912924f, 
    -0.09841302f, -0.09309781f, -0.09368281f, -0.08177164f, 0.04961625f, -0.00689958f, 0.12266052f, -0.05977587f, 
    -0.07303300f, -0.06936955f, 0.09164474f, 0.08938935f, 0.25252351f, 0.09215788f, -0.03788339f, -0.08498706f, 
    0.12165396f, -0.13104862f, 0.09802038f, -0.06899180f, -0.15548040f, 0.07410718f, -0.01971339f, 0.28124616f, 
    -0.04167685f, -0.01413830f, 0.07802621f, -0.05739123f, 0.17442890f, 0.06693280f, -0.03492844f, -0.07628520f, 
    0.10465115f, -0.03138635f, -0.07949506f, 0.04434958f, 0.21479453f, 0.09866080f, 0.05557714f, 0.07662061f, 
    0.01253235f, 0.22623405f, 0.05089515f, 0.07128923f, -0.14119554f, 0.22122101f, 0.03374882f, 0.31229234f, 
    -0.16920723f, 0.04163456f, -0.06501921f, 0.25593999f, 0.10207165f, -0.08087443f, -0.02428448f, -0.09252815f, 
    -0.00048309f, 0.02342630f, -0.38222802f, 0.00622570f, 0.00618561f, -0.06068331f, -0.06815196f, -0.34945342f, 
    -0.42002526f, 0.17012030f, 0.04941519f, -0.07598237f, -0.18937473f, -0.09385993f, -0.00502643f, 0.07828033f, 
    -0.23531753f, -0.03987154f, 0.02462805f, -0.03207427f, -0.45564765f, 0.08200748f, -0.11802045f, 0.07000522f, 
    0.00640439f, -0.14107011f, 0.12345704f, 0.10023901f, 0.10818978f, -0.07720336f, -0.03084892f, 0.06861350f, 
    -0.09096142f, 0.06710898f, 0.10634989f, -0.02035884f, 0.24706943f, -0.30751586f, -0.03091069f, 0.30467862f, 
    0.28675389f, -0.02045522f, -0.09251109f, 0.00596811f, -0.01627537f, -0.05967824f, -0.01511623f, 0.28551012f, 
    0.13709475f, -0.03349116f, -0.11006960f, -0.07597345f, -0.16497590f, 0.08138829f, -0.01233903f, 0.21048675f, 
    -0.21250111f, 0.09344993f, 0.20742805f, -0.02119022f, -0.06692626f, 0.03685601f, -0.06191875f, -0.00253031f, 
    -0.11145933f, 0.32333189f, 0.18863054f, 0.09322588f, -0.30341762f, 0.25556976f, 0.06071780f, 0.10954873f, 
    -0.04503100f, 0.16696888f, 0.04892953f, 0.27922490f, -0.05857530f, 0.03373151f, 0.01235777f, -0.00357214f, 
    -0.06519412f, 0.05150666f, 0.04389334f, -0.10296018f, 0.23904938f, 0.02095168f, -0.43112624f, 0.11860322f, 
    0.08408180f, -0.15230712f, 0.15887368f, 0.19999775f, 0.13822059f, -0.35995960f, -0.02329475f, -0.34153017f, 
    0.15297711f, -0.06483861f, 0.17225283f, 0.14031778f, 0.43659273f, 0.04669352f, 0.11567862f, -0.31247520f, 
    -0.00639899f, 0.28070986f, -0.21092923f, 0.09275910f, -0.06156651f, -0.08982530f, -0.10283413f, 0.16134894f, 
    -0.01671080f, 0.08302543f, 0.00865880f, 0.10187778f, 0.02446800f, -0.09259221f, 0.03789130f, 0.10271460f, 
    -0.03818730f, 0.08869399f, -0.06122201f, -0.10996844f, -0.11445978f, -0.08439249f, 0.10187723f, -0.11920807f, 
    -0.07583098f, 0.03974207f, -0.12489082f, -0.10049620f, 0.06159712f, -0.12656777f, 0.08137175f, 0.07835056f, 
    0.03512016f, -0.02141090f, 0.08142287f, 0.00887160f, -0.09853084f, 0.05250157f, -0.04368016f, 0.12354873f, 
    -0.06059765f, 0.06922942f, 0.11336511f, 0.09406763f, 0.02218114f, 0.01593434f, -0.15029854f, 0.05108003f, 
    -0.15780729f, 0.02616158f, -0.04882416f, -0.02127508f, -0.10685712f, 0.00629348f, -0.07641050f, 0.02847012f, 
    -0.10466143f, -0.04131785f, -0.13875724f, 0.00924139f, -0.09026098f, -0.11580580f, -0.09052899f, 0.05125520f, 
    -0.14438061f, -0.15308164f, 0.03850532f, 0.12350668f, -0.10286187f, -0.11528279f, -0.09634301f, -0.12182855f, 
    -0.15272045f, 0.03413869f, -0.11613765f, 0.17450139f, 0.12640803f, -0.23184226f, -0.10792550f, 0.21628071f, 
    0.28463405f, 0.06683724f, 0.25333014f, 0.01353117f, -0.07320935f, 0.06893101f, 0.03557662f, -0.04112531f, 
    0.18323034f, -0.11582809f, 0.17058112f, 0.03414544f, -0.22015676f, -0.14806879f, 0.07847012f, 0.06351379f, 
    0.19329320f, 0.09503055f, -0.17288192f, -0.08542802f, 0.27516589f, 0.10057203f, -0.06090204f, 0.07974727f, 
    0.36834049f, -0.03820738f, 0.08164408f, -0.08031620f, 0.05984536f, 0.26554608f, 0.19777320f, -0.16905776f, 
    0.18478081f, 0.09596715f, -0.03900993f, -0.25617182f, -0.32304248f, 0.08328704f, -0.03089448f, -0.13630280f, 
    -0.08529672f, -0.01680195f, -0.08288696f, -0.11326761f, 0.00058615f, 0.19397132f, -0.09357718f, -0.02662970f, 
    0.11966297f, -0.12471217f, -0.08670038f, 0.04847398f, 0.18281743f, 0.05072433f, -0.00579853f, -0.14793196f, 
    0.09042176f, -0.04735254f, 0.04557637f, 0.12294926f, -0.18449622f, -0.20859477f, -0.00235949f, -0.07722488f, 
    0.04674732f, 0.11412492f, -0.05088302f, -0.30649519f, -0.04732345f, 0.11005501f, -0.03518497f, 0.10544462f, 
    -0.02908529f, 0.17198063f, 0.19901128f, 0.22128703f, -0.15987076f, 0.05581325f, 0.28273350f, -0.09158063f, 
    0.09270911f, 0.02671691f, 0.00223534f, 0.21039650f, 0.18593620f, -0.05069481f, 0.10701551f, 0.06292824f, 
    0.33757412f, -0.09454203f, -0.08648941f, -0.09332749f, -0.37542728f, -0.06977434f, 0.15337105f, -0.09613873f, 
    0.00653177f, 0.05169783f, 0.17248365f, -0.00643491f, -0.03478487f, 0.32813802f, -0.06339347f, 0.51155180f, 
    0.26801190f, 0.14953099f, -0.12817252f, -0.06171968f, -0.03139847f, -0.02439300f, 0.00811792f, 0.32477054f, 
    -0.26397905f, -0.05871393f, -0.03278420f, 0.07378113f, 0.12923324f, 0.10465241f, -0.08886898f, -0.03079028f, 
    0.07168201f, 0.25522816f, -0.01622920f, -0.08262948f, 0.07475534f, -0.09329716f, 0.10808558f, -0.32317033f, 
    0.03394968f, 0.03061082f, 0.03881989f, 0.28038603f, 0.11367577f, 0.02697191f, 0.12355976f, -0.06700711f, 
    0.12878221f, -0.04860100f, 0.02524013f, -0.07413246f, 0.04304519f, -0.08237500f, -0.19368903f, 0.14572179f, 
    0.23512313f, 0.21457648f, -0.14008670f, -0.13756213f, 0.29266712f, -0.06363192f, 0.07208887f, -0.02132141f, 
    -0.32561940f, -0.07301382f, -0.08764938f, 0.03974262f, 0.07572631f, -0.11498636f, -0.16031161f, -0.08811240f, 
    0.07670595f, 0.26185814f, -0.00444268f, 0.01414796f, 0.32753929f, -0.08308972f, -0.03094224f, 0.09626841f, 
    -0.10252720f, -0.20774972f, 0.27115095f, -0.00939006f, -0.20661601f, 0.12248205f, 0.00439054f, -0.23513487f, 
    0.09375488f, 0.08543703f, 0.02515142f, -0.03479975f, 0.05550259f, 0.01318413f, 0.24258706f, -0.34395516f, 
    0.00831949f, -0.01136420f, 0.06633563f, 0.28540248f, 0.24429078f, 0.03584468f, -0.05309214f, 0.18917134f, 
    -0.04683233f, 0.07273172f, 0.20030655f, 0.16367929f, 0.03566190f, 0.08731786f, -0.08774985f, -0.10793804f, 
    0.00589583f, -0.05113174f, 0.07650810f, 0.20408422f, -0.02637830f, -0.27786270f, 0.04038788f, -0.16863950f, 
    -0.14593697f, 0.19931044f, -0.30171490f, 0.04813829f, -0.17939486f, 0.02768201f, -0.11863244f, 0.00956507f, 
    -0.12204555f, -0.10358468f, 0.00330272f, -0.05103072f, 0.02592662f, 0.27599636f, 0.06129318f, -0.14681175f, 
    0.19798551f, -0.10618750f, -0.08465301f, -0.38491526f, -0.04346573f, -0.29221189f, -0.14246613f, 0.07657725f, 
    -0.16625191f, 0.17109428f, 0.20858203f, 0.21641225f, 0.03238416f, 0.06549127f, -0.11692612f, 0.00782162f, 
    0.05315536f, -0.10835494f, -0.00890279f, 0.00841346f, 0.08739331f, -0.05099788f, 0.10159185f, 0.00863578f, 
    0.01200951f, 0.11800411f, -0.07374274f, -0.00654649f, -0.15968819f, 0.13669109f, -0.00892105f, -0.09612128f, 
    0.30986148f, -0.11105510f, -0.27173442f, -0.02484209f, -0.03743084f, 0.11889412f, -0.04337525f, 0.00523233f, 
    0.18535832f, -0.04260202f, 0.45979393f, 0.14206666f, 0.16858034f, 0.33084276f, -0.01014508f, 0.04126969f, 
    0.12367254f, -0.11189866f, 0.13585158f, 0.08145700f, 0.12833583f, 0.07894368f, -0.05130017f, -0.08813392f, 
    -0.04494545f, 0.01813068f, 0.04638090f, -0.01860873f, -0.04948445f, -0.02463293f, -0.32831332f, -0.10993385f, 
    0.01616982f, 0.06554034f, -0.14270622f, 0.14783520f, 0.34282631f, -0.09039140f, -0.01377955f, -0.14698938f, 
    -0.12846188f, -0.03476620f, 0.23650843f, 0.06971742f, 0.07313710f, 0.26412684f, 0.06737801f, -0.28178552f, 
    0.07915519f, 0.21189803f, 0.34026486f, 0.02806493f, -0.03576625f, 0.03703454f, -0.01106977f, -0.01623046f, 
    -0.08083414f, -0.02064339f, 0.07877840f, -0.03399455f, 0.04096919f, 0.12509181f, 0.06839872f, -0.01434897f, 
    0.08705837f, -0.00265923f, 0.07891046f, 0.20853753f, -0.07173646f, 0.11105563f, 0.08106584f, 0.08939993f, 
    0.08371146f, 0.24941777f, 0.21877776f, 0.01206766f, 0.09788202f, 0.18535613f, 0.10238998f, 0.05427264f, 
    -0.03294206f, -0.22516428f, 0.28369257f, -0.12562627f, -0.06160618f, 0.10940897f, -0.02916731f, 0.07665823f, 
    0.08858365f, -0.12055545f, 0.11419084f, 0.07129104f, -0.11505326f, 0.09038743f, -0.20200074f, 0.21325520f, 
    -0.12064600f, -0.02674970f, 0.08641281f, -0.26517448f, 0.21907161f, 0.21459472f, 0.32280672f, 0.02579310f, 
    -0.09456789f, 0.27995464f, 0.04031793f, 0.04778944f, -0.11397681f, 0.34608784f, -0.05400340f, -0.25903371f, 
    -0.15257418f, 0.03487838f, 0.16825274f, 0.07978499f, -0.14507994f, -0.00991820f, 0.12806369f, -0.15850203f, 
    0.15522479f, 0.03442146f, -0.04317793f, 0.02090009f, 0.24623582f, -0.11189731f, -0.11006364f, 0.08825973f, 
    -0.14246111f, 0.06253192f, 0.30545714f, 0.20054625f, -0.00842950f, 0.10434332f, 0.01884664f, -0.00068968f, 
    0.21737768f, 0.07551526f, 0.07253131f, -0.21655886f, -0.01011831f, -0.19295083f, -0.41331869f, 0.27329838f, 
    -0.11561284f, 0.14335501f, -0.17275262f, -0.08811368f, -0.03149615f, -0.06885812f, -0.05421846f, -0.03233697f, 
    0.25888819f, -0.00474222f, -0.01258944f, 0.12327258f, 0.01219840f, -0.10614745f, 0.30067414f, 0.16034184f, 
    0.19490471f, -0.12087900f, 0.10674567f, -0.08743744f, 0.16112867f, 0.10904957f, 0.16468032f, -0.27105656f, 
    -0.10650838f, -0.06670268f, -0.01224023f, 0.18693939f, -0.13656756f, 0.00883655f, -0.09988014f, -0.15111232f, 
    -0.09583314f, -0.03939841f, -0.04752489f, 0.04752401f, -0.15419564f, 0.00894508f, 0.23436771f, -0.26596817f, 
    -0.00373913f, -0.02377396f, -0.07293287f, -0.05035619f, 0.08206922f, -0.19891699f, -0.02779444f, -0.13986787f, 
    -0.15714763f, -0.03809651f, -0.03054666f, 0.04707181f, 0.10620415f, 0.02585849f, 0.11122680f, 0.08717024f, 
    0.13378084f, 0.14128624f, -0.05135064f, -0.13505290f, -0.14095592f, -0.22830144f, -0.26064295f, 0.30493402f, 
    0.10807963f, 0.25036120f, 0.15181945f, 0.23090522f, -0.08956736f, -0.09686071f, 0.06886075f, 0.11497124f, 
    0.34570372f, -0.07602122f, -0.07451504f, 0.08054507f, -0.12814569f, 0.12789483f, 0.04520389f, 0.10672399f, 
    0.16514996f, 0.20346594f, 0.16262114f, 0.03118534f, -0.06984316f, 0.25265193f, 0.22649561f, -0.03844991f, 
    0.19599809f, 0.02729714f, -0.04436890f, 0.07241627f, -0.23018786f, -0.18516999f, -0.09914114f, 0.16301411f, 
    0.09265368f, -0.13120347f, -0.21656920f, -0.03745003f, -0.29720631f, 0.07935886f, -0.06260662f, -0.20776074f, 
    -0.06968260f, 0.03758077f, 0.08875135f, 0.03514250f, 0.22498263f, -0.07898175f, 0.11894841f, 0.07877256f, 
    0.10544467f, 0.01833158f, 0.23726587f, -0.26327163f, 0.08027033f, -0.00120765f, -0.08824790f, -0.01250452f, 
    0.10996105f, -0.10622920f, 0.08039919f, 0.02331715f, 0.04429289f, 0.07663186f, 0.13120686f, 0.04202845f, 
    0.02080533f, 0.08690771f, -0.15814306f, 0.08707645f, -0.05270975f, 0.09498634f, -0.10219115f, 0.07674654f, 
    0.31147569f, 0.03219730f, -0.00934746f, 0.04618280f, 0.33964360f, 0.06846078f, 0.33750793f, 0.10052914f, 
    0.21891683f, -0.06826405f, -0.09763574f, -0.14493729f, -0.22885975f, 0.00704747f, -0.06213857f, -0.32802287f, 
    0.03296826f, -0.16589956f, -0.07992623f, 0.25003448f, 0.12536469f, 0.22450638f, 0.02214676f, -0.03110632f, 
    0.01377734f, -0.01632878f, -0.15710963f, -0.12489489f, 0.05532918f, 0.09923969f, -0.19093251f, 0.14983816f, 
    -0.26335251f, 0.02495424f, -0.06689902f, 0.08501516f, -0.15191860f, -0.00416187f, 0.07230277f, 0.52034819f, 
    -0.03578951f, 0.01958606f, -0.15352152f, 0.27956891f, -0.05027512f, -0.07631212f, -0.11001492f, 0.00515625f, 
    -0.01761012f, -0.08405809f, 0.19709353f, 0.16615821f, -0.12132578f, 0.19446418f, -0.01825067f, 0.00123261f, 
    0.18956900f, -0.19373783f, -0.06687868f, -0.19293244f, 0.20316871f, 0.01171768f, -0.09639911f, -0.10080139f, 
    -0.07282674f, 0.00111258f, 0.05860437f, -0.06462142f, 0.06536295f, 0.11961928f, -0.47868910f, 0.20070934f, 
    0.18083216f, 0.16040170f, -0.05706075f, -0.05014979f, -0.13126479f, -0.11972019f, 0.07362616f, -0.25855422f, 
    -0.20264255f, 0.07416897f, 0.18105114f, -0.02862530f, 0.33574137f, 0.34772250f, 0.08757113f, -0.13089390f, 
    0.14293204f, -0.22428171f, 0.14436160f, -0.05378219f, -0.23003176f, -0.11944085f, -0.06326622f, 0.13745105f, 
    0.06685853f, -0.14260784f, 0.06146370f, 0.11000367f, 0.01097151f, -0.08313834f, 0.07067215f, -0.05612126f, 
    -0.07378823f, 0.07325789f, 0.01011060f, 0.24112560f, 0.08155538f, 0.07313521f, 0.07821017f, 0.09594943f, 
    0.19491075f, 0.30269340f, 0.13946865f, -0.05780465f, -0.19999054f, -0.06732008f, 0.19579080f, -0.04120937f, 
    0.01708104f, -0.05119916f, 0.15233858f, -0.08681167f, 0.15831283f, -0.10433970f, -0.07455052f, -0.07793764f, 
    -0.02535389f, -0.02998368f, 0.07844275f, 0.02253029f, -0.17541429f, 0.17300753f, -0.26657835f, 0.28904784f, 
    0.09542823f, 0.32934046f, 0.00210065f, -0.34111562f, 0.07679363f, 0.33954293f, 0.33438036f, 0.06755362f, 
    0.18235117f, 0.17679825f, -0.08502648f, -0.17170939f, -0.14416109f, -0.05071365f, -0.04707204f, -0.07270353f, 
    0.02056899f, -0.15820099f, 0.02067642f, -0.03171738f, -0.27920032f, -0.00068283f, 0.23063323f, -0.09200457f, 
    -0.04441555f, 0.21239951f, -0.10583244f, -0.35525712f, 0.26219502f, 0.09262379f, -0.07018655f, -0.10215040f, 
    0.19313180f, -0.13222422f, -0.05246357f, 0.09718658f, -0.09276126f, -0.04780863f, -0.06528053f, 0.01968594f, 
    0.11833935f, -0.02264952f, -0.56672281f, 0.00739115f, -0.08130966f, 0.12751256f, 0.00554921f, 0.33858544f, 
    0.20364113f, 0.11732461f, 0.06446258f, 0.11588995f, -0.02141885f, 0.01485413f, -0.02576630f, -0.09238435f, 
    -0.33678201f, 0.10632245f, 0.07115811f, -0.01401719f, -0.12932892f, -0.00274913f, -0.21209055f, 0.20338278f, 
    0.14049751f, -0.09346063f, -0.06222995f, -0.00470823f, -0.24788438f, -0.13350214f, -0.08973996f, -0.21360645f, 
    -0.10607342f, -0.07588073f, 0.19483635f, 0.08118057f, -0.18761410f, -0.19973952f, 0.01976041f, -0.18633538f, 
    0.22032064f, -0.00012514f, -0.28960800f, -0.12006183f, 0.11402203f, 0.08390639f, -0.07748422f, -0.07129170f, 
    -0.20471199f, 0.00488272f, -0.05572021f, 0.00757601f, 0.16826664f, 0.16668622f, -0.07656047f, 0.27210003f, 
    0.03111536f, -0.01855064f, 0.09944704f, 0.18011294f, -0.02736231f, 0.11145663f, -0.03889659f, -0.08156981f, 
    0.21944368f, 0.02347917f, -0.23512737f, 0.05860904f, 0.08699160f, 0.25322163f, 0.04313360f, 0.12939100f, 
    0.12353511f, -0.19121771f, 0.07898156f, -0.11647756f, -0.22082333f, 0.11337561f, -0.03634489f, -0.02416115f, 
    0.23778386f, 0.01001662f, 0.01934991f, 0.10686198f, 0.10452979f, 0.11813304f, 0.17473829f, 0.08776720f, 
    0.17764948f, -0.05050121f, 0.15843229f, -0.12516764f, -0.10651521f, 0.08174761f, 0.01218270f, -0.10763223f, 
    -0.02714631f, 0.15011351f, 0.01317865f, 0.14240545f, -0.20983958f, 0.21122129f, 0.03585024f, -0.11194108f, 
    0.21781188f, -0.23941042f, 0.21565263f, -0.05070631f, -0.15180518f, 0.06792753f, -0.15922338f, 0.20949233f, 
    -0.06093950f, 0.07944756f, 0.01046760f, 0.06698231f, 0.08259743f, 0.01360952f, 0.01235685f, 0.06263770f, 
    0.01244137f, -0.08967879f, 0.07563201f, 0.02055243f, -0.03907311f, -0.11239526f, -0.06186418f, 0.00481185f, 
    -0.13229415f, -0.08395131f, 0.06782882f, -0.03892047f, 0.00111151f, 0.09531095f, -0.08376053f, -0.01037917f, 
    -0.12393323f, 0.10774053f, -0.02407950f, -0.09955683f, -0.03718413f, -0.05141568f, -0.03590955f, -0.11016744f, 
    -0.10911720f, 0.09158443f, -0.04717346f, 0.06147802f, -0.05402306f, 0.06358275f, -0.09072285f, -0.00111836f, 
    -0.11283119f, -0.03413733f, 0.07598422f, -0.01321473f, -0.09635884f, 0.02303066f, 0.09842914f, -0.10433015f, 
    -0.04178208f, -0.05271585f, -0.12174166f, -0.13101046f, -0.05972421f, -0.08891636f, -0.00519599f, -0.05151729f, 
    0.00936234f, -0.02183189f, -0.01576398f, 0.05905345f, 0.10978804f, 0.04946581f, 0.10664456f, 0.00143431f, 
    -0.12468868f, 0.04520165f, -0.06274924f, 0.19436158f, -0.10054734f, -0.02968249f, -0.10668550f, 0.33153859f, 
    -0.09065884f, -0.06810431f, 0.13904884f, 0.29543751f, 0.04937714f, 0.00542705f, 0.06974196f, 0.08916162f, 
    -0.13438961f, 0.00527002f, -0.11854251f, 0.19715719f, -0.16394089f, -0.25743827f, -0.10833968f, 0.25846329f, 
    -0.03721375f, 0.16651836f, 0.16418727f, 0.16799796f, -0.20454530f, -0.02052389f, 0.07034080f, 0.04663403f, 
    0.22007880f, -0.04145147f, 0.12096556f, -0.10369714f, -0.15582234f, 0.14269231f, 0.20187968f, -0.23063597f, 
    0.24245438f, -0.11491201f, 0.28614512f, 0.29153419f, -0.18436511f, 0.02118653f, -0.14829990f, 0.19794635f, 
    0.09171179f, 0.05509573f, 0.00460895f, 0.04499367f, -0.21776746f, 0.13814151f, 0.08439275f, 0.44530857f, 
    0.12318681f, -0.08104567f, 0.04988582f, -0.01570306f, -0.02327476f, 0.08845953f, 0.01631875f, 0.20897143f, 
    0.03881913f, 0.11500538f, 0.06612661f, -0.37234926f, 0.12012876f, 0.09517283f, 0.10118529f, -0.10114999f, 
    -0.04149374f, -0.11585910f, 0.14055553f, 0.20089763f, -0.08439231f, 0.03719611f, 0.06076229f, -0.07569812f, 
    0.16927236f, 0.16962411f, -0.65201378f, -0.12555206f, -0.21568330f, -0.03076590f, -0.15506680f, 0.24971186f, 
    0.16330935f, 0.16243525f, 0.04881113f, 0.10598960f, -0.07063612f, 0.08273948f, 0.05378836f, 0.03726256f, 
    -0.19976933f, -0.12015372f, -0.07024242f, 0.13076816f, -0.08770783f, -0.13196355f, 0.18476863f, 0.37091953f, 
    0.21724112f, 0.20839569f, 0.04906085f, -0.10335065f, -0.07183933f, 0.07563754f, 0.09506102f, -0.11828659f, 
    0.08957014f, -0.22654222f, -0.02996501f, 0.00863943f, -0.15678272f, -0.16701134f, 0.10502033f, -0.06610378f, 
    0.30420238f, -0.12358611f, -0.35541162f, -0.01535779f, -0.18822609f, -0.02803333f, 0.17946795f, -0.09711031f, 
    0.05585783f, 0.15848321f, 0.04019040f, -0.08730365f, 0.16795893f, 0.10718659f, 0.07085641f, 0.05532191f, 
    -0.00784143f, 0.04328611f, 0.14523575f, -0.10597293f, -0.10285497f, -0.07723340f, -0.03802513f, -0.01238618f, 
    -0.08809897f, 0.16374101f, 0.02857523f, -0.01577172f, -0.38887909f, 0.06666948f, 0.43430194f, -0.20844091f, 
    0.06812661f, -0.03049667f, -0.09350026f, 0.13176410f, -0.03237471f, -0.07373946f, 0.08741121f, -0.08977620f, 
    -0.13060977f, -0.08266699f, -0.03708227f, -0.04054746f, 0.20338283f, 0.25293308f, 0.07835224f, 0.03351215f, 
    -0.05508834f, -0.01767436f, -0.15138486f, -0.40025964f, -0.19286218f, 0.15553613f, -0.03592816f, 0.48736507f, 
    0.06283027f, -0.06965570f, -0.01632353f, 0.06517302f, 0.30931839f, -0.00485876f, 0.11712028f, -0.30736980f, 
    -0.12277447f, 0.04626424f, -0.07494894f, -0.10045344f, 0.18646863f, -0.12147823f, 0.13236979f, 0.28968272f, 
    -0.07628809f, -0.08074765f, -0.01312470f, -0.07001964f, -0.08747130f, -0.17890193f, -0.02292310f, -0.13263951f, 
    0.08364344f, 0.06366298f, -0.08680744f, -0.06356542f, 0.11245044f, -0.08594324f, 0.07312842f, -0.10724901f, 
    -0.09070144f, -0.07621805f, 0.00468810f, -0.14268105f, -0.12064397f, 0.01949175f, -0.06688493f, -0.06171510f, 
    0.04528648f, -0.01521489f, -0.03027860f, 0.09823187f, 0.03676170f, 0.05818513f, -0.06583846f, 0.06125458f, 
    -0.06151623f, 0.09851980f, -0.09078039f, -0.01785757f, -0.09758747f, -0.13123414f, -0.15246068f, -0.02586991f, 
    0.05963700f, -0.08854504f, -0.05000171f, 0.01298267f, -0.18565904f, -0.03559885f, -0.12092409f, 0.06077808f, 
    -0.14000389f, -0.15109044f, 0.08961943f, -0.16321129f, -0.04241106f, -0.06948375f, 0.01148047f, -0.08944468f, 
    0.01331610f, 0.05712126f, 0.08038931f, -0.05762449f, -0.03143638f, -0.04189706f, -0.05282198f, -0.06579584f, 
    0.08898120f, 0.06319278f, -0.04351589f, 0.29496029f, -0.10351965f, -0.12809682f, -0.10227475f, 0.44301918f, 
    -0.04318685f, 0.07077022f, 0.07775140f, -0.12845758f, 0.08955733f, 0.01503182f, -0.03685126f, -0.03752134f, 
    0.02308764f, 0.09773947f, 0.28984147f, 0.30395594f, 0.00220609f, 0.11105150f, 0.11344417f, -0.02953268f, 
    -0.21036138f, 0.06509510f, -0.14478707f, -0.03520551f, 0.11141451f, 0.08182985f, 0.00234383f, 0.04643268f, 
    0.30751169f, 0.10772543f, 0.08550368f, -0.08315525f, 0.33314764f, 0.08297278f, 0.16387358f, -0.19603667f, 
    0.02051357f, -0.13370873f, -0.03989886f, 0.12369373f, -0.20854811f, 0.03953564f, -0.06430051f, -0.03455351f, 
    -0.06665947f, 0.09949450f, -0.01678459f, 0.21751253f, 0.45612738f, 0.15301025f, 0.04147315f, 0.34947214f, 
    -0.11609414f, 0.02179475f, 0.04034588f, -0.07603516f, 0.06406203f, -0.05936282f, 0.00352154f, 0.37483507f, 
    0.24860410f, 0.01300778f, 0.01747808f, 0.02086936f, 0.12747525f, 0.23881935f, 0.07554446f, -0.41567084f, 
    0.04348657f, 0.02707078f, 0.10582452f, -0.00853782f, 0.11392646f, 0.03522173f, 0.10089993f, 0.08934964f, 
    0.09331791f, 0.16074824f, 0.12442072f, -0.03248467f, -0.14225359f, -0.11757140f, 0.28323641f, 0.06463730f, 
    -0.01379639f, -0.04609520f, 0.15432525f, 0.17294215f, -0.06263188f, -0.01538116f, -0.08963861f, 0.04721890f, 
    -0.16647345f, 0.11410441f, 0.01181883f, -0.07004522f, -0.15347680f, 0.22560094f, -0.33985832f, 0.19902699f, 
    0.09090643f, 0.19101010f, -0.04350846f, -0.34621367f, 0.17513277f, 0.17243792f, 0.13850068f, 0.22888818f, 
    0.18690957f, 0.00867849f, 0.10363943f, 0.16667017f, -0.21467909f, 0.06482662f, -0.12008306f, -0.44484323f, 
    -0.16931549f, 0.26879221f, -0.01903413f, -0.00590281f, -0.24425609f, 0.02388762f, 0.17318003f, -0.31517315f, 
    0.15788493f, 0.13328922f, 0.05115088f, -0.23711644f, 0.19504271f, 0.18161465f, 0.12647197f, -0.05285215f, 
    0.21518888f, 0.06080975f, -0.11391459f, 0.02707954f, 0.05352746f, -0.08628596f, 0.03487704f, 0.05807379f, 
    -0.03191343f, -0.24840638f, -0.05605804f, 0.16024181f, 0.17342214f, 0.12594116f, 0.04984120f, 0.14329208f, 
    -0.06860083f, 0.07688729f, -0.34627143f, -0.00150875f, 0.05327601f, -0.12272424f, -0.11375666f, -0.10952377f, 
    -0.11691894f, -0.02126153f, 0.04760769f, 0.11171146f, 0.04296480f, -0.08285109f, -0.02226584f, -0.15001111f, 
    0.11950408f, -0.24712202f, -0.03406311f, -0.09120888f, 0.19599214f, -0.38953546f, -0.08698160f, 0.01774294f, 
    -0.00398931f, -0.10886694f, 0.24194002f, 0.22541352f, -0.10833337f, 0.02584019f, 0.06932410f, -0.20223211f, 
    -0.12599443f, 0.04821313f, 0.23976773f, -0.05825942f, 0.34153855f, 0.02285856f, 0.21637438f, 0.02813037f, 
    0.07173073f, -0.02565143f, 0.03777043f, 0.10884042f, 0.07371869f, -0.05072411f, 0.04262040f, 0.20504358f, 
    -0.00677705f, -0.07315011f, -0.07298447f, 0.11369810f, -0.09794616f, -0.01001338f, -0.01420882f, -0.05550910f, 
    0.08506322f, 0.26290831f, 0.06602190f, 0.08438422f, -0.10360347f, -0.06873076f, -0.03453285f, 0.02008438f, 
    -0.00387788f, -0.12135760f, 0.14463812f, -0.21594167f, 0.30180499f, 0.12502152f, -0.07361557f, -0.05797046f, 
    0.18463923f, -0.03576480f, 0.12902676f, 0.04616529f, 0.05334970f, -0.01675591f, 0.05335319f, -0.08838334f, 
    -0.01613949f, 0.20533249f, -0.05405642f, 0.07875842f, 0.21851660f, 0.02146069f, 0.19599819f, 0.01607988f, 
    -0.02350645f, 0.14837848f, -0.02683929f, -0.08766394f, 0.11367581f, 0.23340589f, 0.07105733f, 0.12450764f, 
    -0.09142612f, -0.11855390f, 0.05932392f, 0.03696915f, -0.08236691f, 0.08073128f, 0.28432012f, 0.04377513f, 
    0.20743513f, 0.30023769f, 0.02648873f, -0.04262713f, 0.03330599f, 0.12494440f, 0.10324375f, -0.35067528f, 
    -0.17141286f, 0.04027108f, -0.13300955f, 0.06236849f, 0.09526554f, 0.00244074f, 0.12342443f, -0.07878590f, 
    0.18396385f, 0.05102716f, -0.13879795f, -0.25786811f, -0.03189495f, -0.12141443f, -0.05551002f, 0.13541329f, 
    0.14078954f, 0.17063692f, -0.01676255f, 0.15813427f, 0.27051756f, 0.04830994f, 0.06279554f, 0.11753760f, 
    -0.07632582f, 0.02347909f, -0.02621288f, -0.07406654f, -0.13103345f, -0.22289017f, 0.28730705f, 0.25547573f, 
    0.10915991f, 0.32697526f, 0.12708676f, 0.13620412f, 0.13716747f, 0.28430507f, 0.04619521f, 0.41370326f, 
    0.09954830f, -0.09396664f, 0.00280046f, -0.25655693f, -0.19078091f, -0.30380893f, -0.07246439f, 0.12410884f, 
    0.16743679f, 0.16936699f, -0.15743782f, -0.02253361f, -0.10146673f, 0.12515464f, 0.21016903f, -0.07528070f, 
    0.07946662f, 0.23317936f, -0.09994040f, 0.11518592f, -0.18812358f, -0.07825406f, -0.08364870f, 0.02533316f, 
    0.01851740f, -0.03761818f, -0.18718295f, 0.03405921f, -0.02264694f, 0.11397660f, 0.06751473f, 0.01781027f, 
    0.09312326f, 0.21317647f, 0.13603407f, 0.08009381f, 0.07226212f, 0.31578270f, 0.08758380f, -0.06094649f, 
    0.09735636f, -0.19085212f, 0.26976693f, -0.07272040f, 0.24649195f, -0.07502516f, -0.11930273f, 0.04719172f, 
    0.04157149f, -0.11223873f, -0.08819695f, -0.07250137f, 0.01383313f, -0.18614224f, 0.25031120f, 0.11089115f, 
    0.04983623f, 0.08307968f, -0.11787375f, 0.14707685f, -0.10497607f, 0.40221098f, -0.00811067f, 0.18096508f, 
    0.04597563f, 0.03560527f, -0.13350137f, -0.23160630f, 0.16268246f, 0.03700532f, -0.01273897f, 0.36077905f, 
    0.17299549f, -0.20212111f, 0.03853419f, 0.10216770f, 0.20002586f, 0.00926617f, -0.14838667f, 0.40877905f, 
    -0.08641932f, 0.01026270f, -0.06185108f, -0.04495516f, -0.03729907f, 0.33593518f, -0.11603831f, 0.11148305f, 
    -0.10174581f, 0.05039573f, 0.08687297f, 0.10889560f, 0.08513819f, 0.01190018f, 0.04658794f, -0.11411708f, 
    -0.07818744f, -0.11973962f, -0.35853177f, -0.09594055f, 0.31038320f, -0.17600228f, -0.33881098f, 0.03237201f, 
    -0.36164635f, 0.16399187f, 0.17925383f, -0.06876375f, -0.41915095f, 0.10231924f, 0.07394874f, 0.00338389f, 
    -0.02698597f, 0.06803484f, -0.02712715f, -0.00920171f, -0.07455119f, -0.14337945f, 0.38874543f, 0.03810772f, 
    0.03062284f, -0.12704001f, 0.10446259f, 0.22496274f, 0.14497276f, 0.20569846f, -0.10476785f, 0.08917920f, 
    0.04319142f, 0.06323106f, 0.08690654f, -0.04696968f, 0.05694540f, -0.14655545f, -0.07916217f, 0.46384907f, 
    0.19154547f, 0.10084931f, 0.19580743f, 0.04862434f, -0.00872259f, 0.00515129f, -0.14383966f, 0.43635973f, 
    -0.02621276f, -0.07038928f, -0.02719779f, 0.07766062f, 0.08700526f, -0.13182490f, -0.10779378f, -0.01255046f, 
    -0.07448086f, 0.02708614f, -0.04805372f, -0.00002179f, -0.02402107f, -0.09021169f, 0.01092078f, -0.07901752f, 
    -0.07352816f, -0.09702496f, -0.08668078f, 0.05597472f, 0.04314766f, -0.01432592f, 0.01757169f, -0.02602885f, 
    0.00546490f, -0.05164184f, -0.07473812f, 0.00853257f, -0.03051569f, -0.06397338f, 0.04284491f, -0.10673928f, 
    -0.08624848f, -0.01758815f, -0.08206926f, 0.04831477f, -0.08180548f, 0.06746335f, 0.05885391f, -0.10976213f, 
    -0.14557798f, -0.04520204f, -0.11161272f, -0.04166234f, -0.06291448f, 0.02750161f, -0.13254757f, 0.03998659f, 
    -0.11967869f, -0.06201778f, 0.09183437f, 0.02476969f, -0.11868054f, 0.01727630f, -0.04206750f, -0.10377069f, 
    0.01079771f, 0.00717773f, 0.06682108f, -0.10478710f, -0.13371845f, -0.03954081f, 0.03564805f, -0.09002562f, 
    -0.07732788f, -0.18590464f, 0.06278667f, 0.36143029f, 0.07422599f, 0.06765863f, 0.09394191f, 0.07596084f, 
    0.19788219f, 0.04660420f, 0.09593745f, -0.15020834f, 0.00019297f, 0.05030477f, -0.07514013f, -0.08048890f, 
    0.18504927f, -0.06052274f, 0.41076148f, -0.01767995f, 0.49510100f, -0.00568917f, -0.03110523f, -0.08139949f, 
    0.07971192f, -0.04292886f, 0.19614276f, -0.06759640f, 0.00641721f, 0.08715899f, -0.06923480f, 0.09072074f, 
    0.33979723f, 0.02406733f, -0.04397314f, -0.00799697f, -0.13702486f, 0.01386966f, 0.10429003f, -0.00046393f, 
    -0.08629721f, 0.05857464f, 0.15865810f, -0.09983859f, 0.06929463f, 0.14026330f, 0.21313743f, -0.20651375f, 
    0.18683463f, 0.33488521f, -0.06700174f, 0.18921770f, -0.25014085f, 0.23079652f, 0.00467566f, 0.26156801f, 
    -0.00301249f, -0.03239979f, 0.37962455f, 0.12483503f, -0.13522795f, 0.08265082f, -0.00254937f, -0.01850819f, 
    -0.01872122f, -0.07158622f, -0.00302743f, 0.02218884f, 0.03464938f, -0.04559606f, 0.04351392f, 0.00334886f, 
    -0.03862101f, -0.05763350f, -0.08705339f, 0.06683663f, 0.06326575f, -0.11343357f, -0.08562688f, 0.09165150f, 
    0.02185410f, -0.09875042f, -0.01498219f, -0.00627597f, 0.07198252f, 0.03985206f, -0.02799299f, 0.03624507f, 
    -0.08102725f, 0.05009665f, 0.03975951f, 0.07863659f, -0.08360095f, 0.08789995f, 0.12408745f, 0.09807001f, 
    -0.01113590f, -0.08073235f, -0.05450923f, 0.03488971f, -0.11255681f, 0.09964129f, 0.12045917f, 0.01691108f, 
    -0.09497061f, -0.02383905f, 0.08100520f, -0.08813138f, -0.11541922f, -0.11920310f, -0.08574355f, -0.11800596f, 
    -0.08483674f, -0.01274619f, 0.07093505f, -0.05176389f, 0.03419344f, -0.08534385f, -0.04397252f, 0.04943440f, 
    -0.13149685f, -0.03020212f, 0.01326691f, -0.02517168f, -0.02939716f, -0.03785827f, -0.07618476f, -0.04622263f, 
    0.13425820f, -0.22542247f, 0.04682949f, 0.14715412f, 0.05155658f, -0.10170484f, -0.03334267f, -0.17340268f, 
    -0.12682302f, 0.04010857f, -0.02560526f, -0.15018044f, 0.09346522f, -0.08492536f, -0.09198057f, -0.12405887f, 
    0.06215061f, -0.08104530f, 0.35739559f, 0.21056373f, -0.10826554f, 0.01245633f, 0.06930213f, 0.10883988f, 
    0.14258868f, 0.23915623f, 0.00261588f, 0.20318978f, -0.06312623f, 0.11105816f, 0.00226100f, -0.05301818f, 
    0.32721207f, -0.00238729f, 0.01085151f, 0.12208770f, -0.09079246f, 0.31571117f, -0.27668843f, -0.09792949f, 
    0.23315176f, 0.11000916f, 0.21477024f, -0.05003950f, -0.37709269f, -0.09897674f, 0.12343279f, -0.29680181f, 
    0.15744475f, 0.02865961f, -0.02679201f, 0.20839001f, -0.04480257f, 0.06382652f, 0.00446307f, -0.02709649f, 
    -0.22964363f, 0.19639969f, -0.17920803f, 0.03271083f, -0.09215519f, -0.07601266f, -0.20906430f, -0.15267970f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04597063f, 0.00418039f, 0.02468754f, -0.16792028f, 0.06386661f, -0.09301519f, -0.04714554f, 0.09887233f, 
    0.01783257f, 0.13497387f, -0.03881609f, 0.05034185f, 0.04999388f, -0.04197620f, 0.14934482f, -0.05543844f, 
    0.04278525f, 0.20625986f, 0.03732459f, 0.16559495f, 0.10779651f, -0.01772393f, 0.03961047f, 0.07740006f, 
    -0.01951688f, 0.00465806f, -0.01671555f, 0.05958389f, 0.10878430f, -0.03268739f, 0.03003710f, 0.00529921f, 
    0.04598219f, 0.07820250f, -0.05504945f, 0.06449378f, 0.09423029f, 0.12973712f, 0.08566955f, -0.00283098f, 
    0.12868629f, 0.06375164f, 0.07627027f, -0.00672043f, -0.06292704f, -0.01258381f, 0.11363599f, 0.00129475f, 
    -0.12818654f, 0.02356138f, 0.13517420f, 0.05172516f, -0.12042422f, 0.03448413f, 0.04781084f, -0.01094257f, 
    0.01597392f, 0.14607768f, -0.05254026f, -0.03299527f, -0.06328507f, 0.09973045f, 0.01723214f, 0.00365049f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.20774682f, -0.41183820f, 0.07192191f, -0.08551017f, -0.15872438f, 0.09206340f, 0.12297367f, -0.22378531f, 
    0.09715452f, 0.45962903f, 0.15588732f, -0.18538707f, -0.00959925f, -0.03657388f, 0.19111985f, 0.17470548f, 
    0.05447253f, -0.06683633f, -0.07043666f, 0.17349957f, -0.02255481f, -0.33467531f, 0.03309560f, 0.09730400f, 
    -0.17755131f, -0.13548544f, 0.04347095f, -0.49293500f, -0.01698438f, -0.07347113f, -0.07466976f, 0.26497972f, 
    0.41474539f, 0.15010032f, 0.01461535f, -0.39239359f, -0.09146351f, -0.21969225f, 0.21842928f, 0.06002668f, 
    -0.06374127f, -0.40368518f, -0.44886306f, -0.17112088f, 0.12731345f, -0.25648409f, -0.36255047f, 0.07078265f, 
    0.06525591f, 0.20068841f, -0.58858311f, 0.06457805f, -0.06577840f, 0.17163745f, -0.25178713f, 0.14131391f, 
    0.03668251f, -0.35541552f, 0.08190638f, 0.36894548f, -0.10778592f, -0.11963582f, 0.00430221f, -0.27278084f, 
    0.27054760f, 0.07343756f, -0.00218409f, 0.21072204f, 0.08411440f, 0.12917303f, 0.08887956f, 0.10962363f, 
    -0.39634648f, -0.64090145f, -0.04428659f, -0.19651709f, -0.04513052f, 0.02837866f, 0.25385496f, -0.13389963f, 
    0.19323073f, -0.02973308f, -0.55844867f, 0.24096557f, 0.11668914f, -0.29759288f, -0.23484115f, -0.02593594f, 
    0.04875897f, -0.02703196f, 0.28449529f, 0.28722686f, 0.25544959f, 0.05932930f, -0.27331397f, -0.21914533f, 
    -0.11194626f, -0.06645833f, -0.04963582f, -0.11971270f, 0.07635175f, -0.22001447f, 0.04443249f, -0.02742430f, 
    -0.07794000f, 0.00553688f, 0.25261611f, 0.01618420f, -0.47478580f, -0.04219718f, 0.14433743f, 0.05637896f, 
    -0.00753162f, 0.22028574f, -0.07500066f, -0.26321977f, -0.06776245f, -0.00314171f, 0.02959558f, 0.12365074f, 
    -0.16186079f, -0.21613927f, -0.13629995f, 0.11127097f, 0.03577007f, 0.19999023f, 0.05429481f, 0.26911852f, 
    -0.24344264f, -0.27057868f, 0.00617860f, -0.40563184f, 0.21480118f, 0.13908255f, 0.18817402f, 0.11890037f, 
    0.38925928f, 0.08134051f, 0.01200766f, 0.21202350f, -0.39894247f, -0.03804223f, -0.02551832f, -0.47282773f, 
    -0.19617090f, -0.26594076f, -0.14559460f, -0.10749672f, 0.20651940f, -0.17076795f, 0.02912405f, -0.12103468f, 
    0.03678325f, -0.10418626f, -0.24246207f, -0.40764770f, 0.15359005f, -0.04170668f, 0.22486474f, -0.34405726f, 
    0.36750209f, -0.16737922f, 0.05802197f, -0.42603731f, -0.18431942f, 0.06807122f, 0.04098160f, -0.20182279f, 
    -0.30364287f, 0.19988395f, 0.15657736f, -0.07810102f, 0.12127971f, 0.06933828f, -0.35532796f, -0.20554216f, 
    -0.08664626f, -0.05603025f, 0.09795099f, -0.48080638f, -0.05117004f, -0.00777329f, -0.15471685f, -0.10871849f, 
    0.11868145f, 0.28323951f, 0.16636562f, 0.31149295f, 0.03223901f, 0.05587845f, 0.01712947f, -0.22028999f, 
    0.17131670f, 0.21818049f, -0.35315526f, -0.27272364f, 0.11280949f, -0.41566044f, 0.12406059f, -0.12791109f, 
    0.14688593f, -0.02838510f, 0.06564637f, -0.25990021f, 0.19209388f, 0.02242197f, -0.15694611f, -0.16646655f, 
    -0.29761168f, -0.11797259f, 0.19717599f, -0.74830103f, -0.06550868f, 0.21611382f, 0.26481435f, -0.08427226f, 
    0.05446271f, -0.03394242f, -0.26795247f, 0.02364728f, -0.02247551f, 0.09689290f, 0.11565123f, 0.15272044f, 
    -0.09796741f, -0.14298180f, -0.05094080f, 0.24588987f, -0.43916237f, 0.15485288f, 0.49386007f, -0.16330698f, 
    -0.31556082f, 0.20024452f, 0.01992873f, 0.04893646f, -0.14538546f, -0.06062746f, 0.09097865f, 0.03095273f, 
    -0.06127761f, 0.13220318f, 0.11118019f, 0.15029973f, -0.00334211f, -0.25492808f, 0.07875533f, 0.21598671f, 
    -0.07637157f, 0.00529938f, -0.44197735f, -0.26774597f, 0.00025178f, -0.44449013f, -0.09054997f, 0.12413843f, 
    -0.12665910f, -0.21578056f, -0.04610666f, 0.04345817f, -0.12471438f, 0.17908318f, -0.34383714f, 0.13045819f, 
    -0.40868041f, 0.25408855f, 0.26522851f, -0.17749082f, 0.26749784f, -0.00316483f, -0.25975943f, 0.17077155f, 
    0.08535422f, 0.02656991f, 0.24508560f, 0.00331728f, 0.09422226f, 0.15470967f, 0.17000780f, 0.04599738f, 
    0.01939574f, -0.09602288f, -0.39930594f, 0.17605604f, -0.30494168f, 0.05441346f, -0.19035812f, -0.11352446f, 
    -0.30717641f, 0.21336415f, -0.04099629f, -0.05604541f, -0.17272463f, 0.05725736f, 0.10612709f, 0.20124830f, 
    -0.06846278f, 0.18465385f, -0.19420138f, 0.16898634f, -0.07842365f, -0.30756921f, -0.16934969f, -0.09005915f, 
    0.07549731f, -0.18656194f, -0.39981332f, -0.10272902f, 0.08132554f, 0.13870658f, -0.00219371f, 0.25187969f, 
    0.01619441f, -0.26893580f, -0.18246181f, -0.08867542f, -0.03472168f, 0.06891479f, -0.11587082f, 0.11912394f, 
    -0.19480480f, -0.11859455f, 0.04696903f, 0.13282238f, -0.48882970f, -0.22356254f, 0.19162753f, -0.15086554f, 
    -0.34203389f, -0.16785435f, 0.02502721f, -0.07596964f, 0.20522521f, 0.10311548f, -0.38605276f, 0.21589236f, 
    0.14046626f, 0.17459458f, -0.18792167f, -0.00857220f, 0.01331897f, -0.15991096f, -0.21871483f, -0.09390951f, 
    -0.26472616f, 0.00756828f, 0.15534455f, -0.37971535f, 0.03620882f, -0.11233559f, -0.48818761f, 0.13252370f, 
    -0.35563159f, 0.00499398f, -0.00959793f, 0.22879805f, -0.00706962f, -0.31492212f, 0.13531895f, 0.08374169f, 
    0.20687449f, -0.04464512f, -0.05554735f, 0.02603184f, 0.25919196f, 0.26726896f, -0.00040131f, 0.06741903f, 
    -0.02236828f, -0.10553339f, -0.04042182f, 0.09821947f, 0.09368192f, 0.18179195f, 0.04736936f, -0.28478318f, 
    0.21661027f, -0.32029620f, 0.16008052f, -0.59257859f, -0.07398771f, 0.22041762f, 0.11068250f, 0.12300300f, 
    -0.34085178f, -0.28449970f, 0.03374152f, -0.58533490f, -0.33103514f, 0.12173789f, 0.01793621f, 0.24387275f, 
    0.38153473f, -0.28002474f, -0.17483269f, 0.24475677f, -0.00637298f, 0.07164238f, -0.43539122f, -0.11246970f, 
    -0.26882848f, 0.11726614f, 0.18173330f, 0.02865213f, -0.21518408f, -0.10846123f, 0.29827297f, 0.08552513f, 
    0.19851537f, -0.00536075f, 0.12096915f, 0.07885946f, -0.26960251f, -0.09233654f, 0.06712665f, 0.00687676f, 
    -0.37179562f, -0.02588704f, -0.04804631f, 0.09840280f, 0.33120117f, -0.10459396f, -0.21823807f, 0.00398858f, 
    -0.28331450f, -0.29726344f, 0.13146950f, -0.12861817f, -0.55091763f, -0.09852403f, -0.04710514f, -0.31119639f, 
    -0.09087422f, 0.22208910f, -0.09729795f, -0.05342231f, 0.02333009f, 0.14668715f, -0.16328110f, -0.11770027f, 
    0.12968066f, 0.07873284f, 0.23224041f, -0.30289468f, 0.10174761f, -0.08872118f, -0.00166252f, 0.09693848f, 
    -0.06200901f, -0.02208913f, 0.07730342f, 0.27203867f, 0.05118825f, -0.12970021f, -0.05608975f, -0.18970817f, 
    0.31086889f, 0.10853495f, -0.30759549f, 0.23925823f, 0.03437141f, -0.08543251f, -0.19128565f, 0.03580135f, 
    -0.16779926f, -0.26014376f, -0.05065818f, 0.05805392f, -0.44997758f, 0.06314079f, -0.36038584f, -0.05992128f, 
    -0.20322408f, 0.00682306f, -0.16730419f, 0.19366217f, -0.36471942f, -0.09151629f, 0.15166527f, -0.20325691f, 
    -0.13381955f, -0.18815187f, -0.10484248f, 0.13399127f, -0.22972758f, 0.12067316f, -0.46080506f, 0.21604255f, 
    -0.34430617f, -0.23602976f, -0.13011855f, 0.09011000f, 0.33176318f, -0.34612259f, 0.19986901f, 0.12546302f, 
    -0.04510620f, -0.15356812f, 0.05186898f, -0.26597226f, -0.08670924f, 0.01207223f, -0.42414308f, 0.14510280f, 
    -0.16724347f, 0.06961392f, 0.31571758f, 0.21259157f, -0.04472909f, 0.08330795f, -0.03436190f, -0.28113335f, 
    -0.22709087f, 0.42681620f, -0.40623766f, -0.04022079f, 0.22301774f, -0.27411890f, 0.21167436f, -0.23441435f, 
    -0.15485427f, -0.23902859f, -0.00806817f, -0.09242905f, -0.41662112f, -0.10270661f, 0.01394993f, -0.20119013f, 
    0.21096531f, 0.11508781f, 0.10544246f, -0.26870218f, -0.24888684f, 0.01150611f, -0.36107564f, 0.01596240f, 
    0.14820673f, -0.09705753f, -0.10307515f, -0.20323716f, -0.17147511f, 0.01108955f, -0.25313348f, -0.03437106f, 
    -0.75708348f, -0.25076514f, -0.05746742f, 0.12333000f, 0.10206571f, -0.39097628f, -0.34930420f, -0.18973793f, 
    0.08714121f, 0.24179696f, 0.15078828f, 0.27247885f, -0.28740454f, -0.03729973f, -0.21674590f, 0.29876402f, 
    -0.03029318f, 0.18347956f, 0.14800413f, -0.04104755f, -0.00919906f, 0.07921655f, -0.25364190f, -0.19693850f, 
    0.14389761f, 0.03485643f, 0.23889902f, 0.24841027f, 0.05205486f, 0.20225032f, 0.05735587f, -0.25194299f, 
    -0.19152690f, 0.17021839f, 0.18635210f, 0.02022091f, 0.11921281f, 0.01460940f, -0.11958230f, 0.23626381f, 
    -0.14997028f, 0.15674126f, -0.14307785f, 0.32497811f, -0.15128867f, -0.04589234f, -0.05013777f, 0.13551924f, 
    -0.03337462f, -0.24120271f, -0.16406223f, 0.01025832f, 0.20938829f, 0.30184975f, -0.13753518f, -0.01612360f, 
    -0.46870095f, 0.03271592f, 0.10763330f, -0.03256265f, 0.06326053f, -0.01308641f, 0.07318155f, -0.19449694f, 
    -0.29568645f, -0.27762702f, -0.01115565f, -0.25101620f, 0.08225273f, 0.14186947f, -0.11964641f, 0.17325303f, 
    0.27412546f, -0.19764766f, -0.31247619f, -0.44969514f, 0.11185664f, 0.11252843f, -0.21679872f, -0.12521242f, 
    0.06380636f, -0.38821322f, -0.30330995f, 0.06513921f, -0.09858433f, -0.10936980f, 0.25264782f, 0.10508455f, 
    0.10004684f, 0.10617751f, 0.05086331f, -0.08501745f, 0.07544640f, 0.13169476f, 0.04731975f, -0.26386744f, 
    -0.24290207f, -0.34303597f, -0.27689469f, -0.15961222f, 0.16022696f, -0.16497138f, -0.39131060f, 0.03607339f, 
    0.17094302f, -0.02334854f, -0.63439536f, -0.33525747f, 0.21456146f, 0.05836044f, 0.01247257f, -0.31268838f, 
    -0.16550773f, 0.22222614f, -0.24733323f, -0.30678195f, 0.20266925f, -0.11583104f, -0.05115554f, -0.05933226f, 
    -0.03989110f, -0.02752874f, -0.23516887f, -0.15712175f, -0.00401428f, -0.14523575f, 0.14504752f, -0.45444250f, 
    0.03300783f, 0.20429446f, -0.09474171f, -0.14396428f, -0.19620131f, 0.20577125f, -0.51681525f, 0.14364155f, 
    0.21366821f, 0.22899811f, 0.28299326f, -0.28019020f, 0.16219239f, 0.20462218f, 0.15231395f, 0.05764473f, 
    -0.11204644f, 0.02365769f, 0.28899822f, -0.52184159f, -0.08837344f, -0.67861843f, 0.25185427f, -0.06467900f, 
    0.12535405f, 0.26604956f, -0.19563653f, 0.02780462f, 0.09443562f, -0.13883422f, -0.03415337f, -0.03995985f, 
    0.07280456f, 0.22264320f, -0.03447221f, -0.24115454f, -0.35666415f, -0.13712904f, -0.30742192f, -0.18259436f, 
    -0.21707790f, -0.19706216f, 0.10435399f, 0.02861046f, -0.19355752f, 0.03493837f, 0.26049441f, 0.27634060f, 
    -0.03441179f, -0.03067027f, 0.31580046f, -0.44174379f, 0.19624537f, -0.15184505f, 0.05980724f, 0.06119616f, 
    0.14137298f, 0.06991294f, -0.43511385f, -0.09341452f, 0.29136616f, -0.04894239f, 0.23755153f, 0.13683221f, 
    -0.05708622f, 0.23805189f, -0.04981933f, -0.12487824f, 0.06724980f, -0.17488350f, -0.22328824f, -0.08674469f, 
    -0.17886920f, -0.17828634f, 0.04884836f, 0.14840317f, -0.45919728f, 0.05175520f, 0.08096829f, -0.12603536f, 
    0.04394581f, -0.25145376f, 0.14941742f, 0.40562451f, -0.09332302f, -0.04042811f, 0.25391668f, -0.05950240f, 
    -0.16182809f, 0.09889009f, 0.05517375f, -0.14088017f, -0.13135779f, -0.54757756f, 0.09245134f, 0.09719045f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03254745f, -0.05689947f, 0.03972124f, 0.01050493f, 0.09200981f, 0.06142401f, 0.04874384f, -0.13315427f, 
    0.08442066f, -0.00142864f, 0.08638948f, 0.13532683f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
