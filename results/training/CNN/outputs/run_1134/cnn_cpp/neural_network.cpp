#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.49993384f, -0.25365695f, -0.25828916f, 0.27735946f, -0.18676001f, -0.08282846f, -0.38164431f, 0.05931274f, 
    0.32804495f, -0.24685435f, 0.44713968f, -0.33787918f, -0.15044329f, 0.47282565f, -0.21723028f, 0.01335699f, 
    0.27345103f, -0.40320548f, 0.02330421f, 0.19200598f, -0.02617330f, -0.00763930f, 0.14074340f, 0.30805534f, 
    0.34027371f, -1.32349885f, -0.64682490f, -0.23603752f, -0.19213609f, -0.24043187f, 0.43344435f, 0.93914139f, 
    -0.29244235f, -0.21842261f, 0.36971369f, 0.28765687f, 0.41722170f, -0.19523598f, 0.40409788f, -0.49545333f, 
    -0.28448975f, -0.18399622f, -0.22310890f, 0.11854070f, 0.22279000f, -0.04641635f, -0.08183981f, 0.19010866f, 
    0.55520386f, -0.08858480f, 0.65604091f, -0.72658932f, -0.70558584f, -0.28771406f, 0.14164969f, -0.16614969f, 
    -0.12034529f, 0.13424042f, -0.35329425f, -0.23284084f, -0.36122888f, -0.04837419f, 0.35616601f, -0.22927968f, 
    -0.41838586f, -0.24790828f, -0.19717352f, -0.00986056f, -0.31282437f, -0.63561076f, 0.16396721f, -0.09162136f, 
    -0.00137249f, 0.36906251f, 0.63111556f, 0.85238785f, 0.69167012f, 0.23040225f, -0.61477429f, -0.33971849f, 
    -0.09326806f, -0.15525085f, 0.07558741f, -0.30809841f, -0.05717001f, 0.11665016f, -0.00940512f, 0.48679510f, 
    -0.41109335f, -0.16312037f, -0.17600654f, 0.25974593f, 0.09614216f, 0.11566690f, -0.23670644f, -0.09687287f, 
    0.18019910f, -0.18627402f, -0.02458829f, -0.04745002f, -1.21471810f, -1.25477707f, 0.02497529f, 0.71377975f, 
    0.60299414f, 0.87047768f, -0.38528287f, -0.53655314f, 0.71452147f, -0.33375448f, -0.00996480f, -0.03206951f, 
    0.00021317f, 0.05013902f, -0.46421519f, -0.13506053f, 0.02227943f, 0.00322413f, -0.31754988f, 0.22847192f, 
    -0.16815205f, 0.06482062f, -0.26573104f, 0.09068211f, -0.01267909f, 0.64137852f, 0.61530751f, 0.40623882f, 
    -0.05648334f, -0.01396552f, -0.00116242f, 0.22608362f, -0.11196295f, -0.44451651f, -0.22777620f, -0.03587629f, 
    0.03809476f, 0.02888820f, 0.08618109f, -0.19196899f, -0.20444643f, -0.00427670f, 0.11437942f, 0.00664096f, 
    0.01915490f, 0.24834687f, -0.18864809f, -0.18254820f, -0.23717982f, -0.34448287f, 1.18099523f, -0.10609070f, 
    -0.84288955f, -0.81585717f, -0.87365311f, 0.43162051f, 0.38955176f, 0.20324953f, 0.30563003f, 0.25178385f, 
    0.28080654f, -0.02980916f, 0.04461267f, -0.17071933f, -0.11826377f, -0.03450426f, -0.49340025f, 0.34174857f, 
    0.29569274f, -0.27624193f, -0.04105709f, -0.05450467f, 0.27371922f, -0.16520116f, 0.16409473f, -0.57874388f, 
    0.27824947f, -0.58482474f, -1.02539802f, -0.63135302f, -0.36909920f, -0.26019573f, 0.31688619f, 0.46249214f, 
    0.09419831f, -0.47779751f, 0.17897137f, -0.13017021f, -0.41928199f, -0.32750580f, -0.55589676f, -0.22553174f, 
    -0.28268147f, -0.39182320f, 0.48890889f, -0.06342004f, -0.09677569f, 0.03627940f, 0.27976906f, 0.05157790f, 
    -0.77993822f, -0.37646210f, 0.62885100f, 0.20816459f, -0.27955753f, -0.34060603f, 0.93024981f, -1.13435054f, 
    0.34333792f, -0.66331255f, -0.06951179f, -0.20331083f, -0.31807265f, -0.12513374f, 0.30194554f, -0.29749161f, 
    -0.10776296f, 0.12098478f, 0.25670528f, 0.32785803f, 0.17125559f, -0.15724708f, 0.05794233f, -0.29854608f, 
    -0.15540521f, 0.51630706f, 0.43346000f, 0.44183350f, 0.34260535f, -0.43964377f, -1.12464547f, -0.79110634f, 
    -0.02692641f, 0.21932894f, 0.40605024f, -0.03322498f, -0.21814877f, 0.65489089f, 0.11478945f, -0.27676499f, 
    -0.07415292f, 0.06812520f, 0.03386336f, 0.16664182f, -0.52020615f, -0.04991863f, -0.08004337f, -0.14081016f, 
    -0.07538812f, 0.21467419f, -0.11223589f, -0.87294155f, -0.60657585f, 0.38828009f, -0.92403936f, 0.60842311f, 
    -0.14076337f, 0.31166133f, -0.12305224f, 0.61641020f, -0.09860028f, 0.12018812f, 0.08469861f, -0.26229411f, 
    0.35326779f, -0.05491317f, 0.14410177f, -0.01788271f, -0.19493917f, 0.33198643f, -0.29027262f, -0.25635737f, 
    -0.01687535f, -0.04180058f, -0.03614691f, -1.34777391f, 0.38063356f, -0.15676813f, -1.06488860f, -0.25004089f, 
    0.20533618f, 0.31377062f, 0.13006350f, 0.17785476f, 0.66540575f, -0.02734247f, -0.05972826f, 0.23326579f, 
    -0.13505532f, 0.14216603f, 0.14465781f, -0.14199322f, -0.08482698f, -0.17602345f, 0.00518370f, -0.02927743f, 
    -0.07509342f, -0.08955996f, -0.16220851f, -0.27946121f, 0.76780748f, 0.47746256f, 0.33606502f, -0.42089096f, 
    0.01138065f, -0.24568230f, -0.16916202f, 0.43008754f, 0.06337244f, -0.16425094f, 0.13163179f, 0.37236285f, 
    -0.34983319f, -0.25720650f, -0.00401556f, -0.10031444f, 0.00548365f, -0.14834884f, -0.23467726f, -0.23940548f, 
    -0.18114638f, 0.67022014f, 0.04973178f, -0.36093277f, -0.01478549f, -0.27209798f, -0.25416428f, -0.23738091f, 
    -0.11397575f, 0.17302333f, -0.46951798f, -0.91210818f, -0.57399035f, -0.55472732f, -0.65581810f, 0.31944633f, 
    0.21521541f, 0.15245484f, -0.27475652f, 0.24542551f, -0.19596587f, 0.23364681f, -0.00294117f, 0.11186980f, 
    0.29892403f, -0.27042809f, -0.28515807f, 0.03594302f, 0.05109872f, 0.33591661f, 1.11930799f, 0.56234550f, 
    0.07840383f, -0.62776947f, -1.21093917f, -0.07288577f, 0.36590216f, 0.39169398f, -0.11421506f, -0.34006414f, 
    -0.01563353f, 0.11159723f, -0.25765821f, -0.06458145f, -0.29962814f, 0.39947969f, -0.18176323f, 0.10417996f, 
    -0.29612455f, 0.07420586f, 0.03403977f, -0.23755907f, -0.15968920f, 0.24672036f, 0.11188891f, -0.56052887f, 
    -0.06419624f, -0.14369987f, 0.57607943f, 0.68187052f, 0.16467954f, 0.29524222f, 0.39759874f, 0.38049653f, 
    0.02396351f, 0.12005105f, 0.09461869f, 0.21646413f, 0.05668509f, -0.46351746f, 0.08653846f, -0.03899753f, 
    -0.00046676f, 0.13523470f, 0.14736250f, 0.03064820f, -0.25198627f, 0.05284740f, -0.05008221f, 0.10550788f, 
    -1.26239836f, 0.06069725f, 0.36921033f, 0.73928052f, -0.13692197f, 0.18715012f, -0.10420707f, 0.09593845f, 
    0.21861959f, -0.06260236f, -0.46874970f, 0.21041100f, -0.02875613f, 0.33878040f, -0.61257869f, 0.04262323f, 
    0.46086794f, -0.10411455f, -0.11917678f, 0.18638727f, 0.18481071f, -0.43747449f, -0.22269566f, 0.12123082f, 
    0.04329229f, -0.94939172f, -0.30204535f, -1.21323490f, -0.62144661f, -0.36814514f, -0.04769949f, 0.49202752f, 
    -0.26058057f, -0.37206286f, -0.42605802f, -0.01625055f, -0.25677201f, -0.21233478f, -0.06728494f, -0.26356554f, 
    -0.01206392f, -0.56689519f, 0.03244125f, 0.24342068f, -0.42642286f, 0.04316473f, 0.27783480f, 0.14130826f, 
    0.13800132f, 0.10420508f, 0.39048216f, -0.24538980f, -0.55202276f, 0.01981496f, 0.30361506f, 0.03287958f, 
    0.59467947f, 0.58355165f, -0.01958794f, -0.46530664f, -0.53868097f, 0.47948539f, -0.36382812f, -0.22759452f, 
    -0.16142048f, -0.24229518f, -0.07195207f, 0.15434597f, -0.11114874f, 0.07419503f, 0.28852251f, -0.08106800f, 
    -0.42790261f, 0.19554548f, 0.14812359f, -0.72487366f, 0.98454887f, 0.71706843f, -0.08036387f, -0.71861601f, 
    -0.98542917f, -0.09505603f, 0.67909700f, 0.10886630f, -0.05592868f, -0.31600058f, 0.25321358f, -0.11575322f, 
    0.19426546f, -0.36854553f, 0.15976731f, -0.08866262f, -0.34798506f, 0.01662767f, -0.21242283f, 0.09599794f, 
    -0.01938543f, -0.05185013f, 0.31405213f, -0.34340611f, -1.28896034f, -0.75342226f, -0.46400380f, -0.39551193f, 
    -0.25830895f, 0.95812792f, 0.02603573f, -1.01657796f, -0.64025152f, 0.14731421f, -0.37461650f, -0.37750149f, 
    -0.29972342f, -0.41539845f, -0.53048021f, 0.23183854f, 0.06416617f, -0.22523566f, -0.25643823f, -0.23376891f, 
    -0.15904096f, -0.15817687f, -0.24853027f, -0.09700622f, -0.15769567f, -0.14664708f, 0.56715888f, -0.32935119f, 
    -0.12316643f, -0.51303285f, -0.40709111f, -0.87675148f, -0.19759880f, -0.93051910f, -1.13086653f, 0.34872800f, 
    0.21436746f, -0.37955880f, -0.37362802f, -0.02652179f, -0.09043846f, -0.09707033f, -0.00464312f, -0.33095413f, 
    -0.03918585f, -0.16060333f, -0.04333920f, 0.00186903f, -0.37708706f, -0.50688398f, -0.03423930f, -1.13104880f, 
    -0.62766981f, -0.11420204f, -0.46499297f, -0.56843823f, -0.44299111f, -0.01656616f, 0.25924018f, -0.49063835f, 
    -0.15365452f, 0.41407472f, -0.10286215f, -0.05105515f, -0.12427593f, -0.18800260f, -0.63248533f, -0.04829928f, 
    0.06403378f, -0.05159590f, -0.31619525f, -0.01234651f, 0.00350902f, -0.40404370f, -0.38504076f, -0.17311120f, 
    0.88476974f, 0.28020918f, -0.28010288f, -0.16263191f, -0.42965239f, -0.45486096f, -0.25050056f, -0.31601083f, 
    -0.23811406f, 0.05248773f, 0.26847020f, 0.41648659f, 0.13563454f, 0.04599355f, 0.14850925f, 0.03212681f, 
    -0.12564087f, 0.18342252f, -0.34241617f, -0.14829004f, 0.01625577f, -0.36784738f, -0.29222801f, -0.27511489f, 
    0.47359857f, 1.17570984f, -0.30534258f, -0.60873133f, -0.42626506f, -0.21713471f, -0.47683302f, -0.48001733f, 
    -0.51472527f, -1.05727434f, -0.47659379f, 0.10784889f, -0.13920967f, 0.02476577f, 0.07267842f, 0.30879077f, 
    -0.12111042f, 0.16546832f, -0.19055721f, -0.03405225f, -0.00282309f, 0.20865363f, 0.17365965f, 0.13379362f, 
    0.01614033f, -0.61510116f, -0.53905147f, 0.01324374f, 0.09542011f, 0.19432069f, -0.39875007f, 0.11077104f, 
    0.17265989f, 0.60931724f, 0.88911599f, -0.15908788f, 0.35663342f, -0.40078810f, -0.23054577f, 0.31327283f, 
    -0.40393436f, -0.14737438f, -0.17339326f, -0.07707184f, -0.15748057f, 0.01831590f, 0.10917280f, 0.26370686f, 
    0.09320799f, 0.47133595f, -0.18132609f, 0.20851651f, -0.14892325f, -0.57674605f, -0.55655968f, 0.41461989f, 
    0.19975370f, 0.04324594f, 0.56765163f, 0.27983662f, -0.29692525f, -0.37414593f, 0.17515245f, -0.16795881f, 
    -0.08226494f, 0.26700386f, -0.02305426f, -0.46204814f, -0.13540462f, 0.09526543f, -0.14574152f, -0.20829979f, 
    -0.25211343f, -0.12239534f, -0.24161252f, 0.53059131f, -0.73788607f, -0.76799446f, -0.36876652f, -0.30533618f, 
    0.11578767f, 0.27711701f, 0.57834208f, 0.12060194f, 0.14422761f, -0.00809768f, 0.02463209f, 0.07653233f, 
    -0.34308356f, 0.11601838f, 0.08042762f, 0.16488850f, 0.12343674f, -0.05676411f, -0.10830899f, 0.21565457f, 
    -0.09439918f, -0.27865958f, 0.17590655f, -0.09960627f, -0.15379295f, -1.08121026f, -0.62296581f, -0.23418218f, 
    -0.53699338f, 0.00456287f, 0.36446664f, 0.05595680f, 0.18383269f, 0.11341455f, -0.38435662f, -0.38340336f, 
    -0.55405712f, -0.02750588f, 0.40282658f, -0.54638714f, -0.56309533f, -0.21785972f, -0.46011171f, -0.60434937f, 
    -0.29247218f, -0.46225011f, -0.10304683f, -0.29908994f, -0.90170431f, 0.30568001f, 0.37399095f, 0.13122892f, 
    -0.02072503f, -0.22355106f, 0.38849863f, -0.32051617f, -0.20955987f, -0.23695782f, -0.34034050f, -0.33409312f, 
    -0.33804104f, -0.06745658f, 0.02838863f, -0.33088863f, 0.31246033f, -0.00560107f, 0.23177958f, 0.32244167f, 
    -0.17850685f, -0.24885952f, -0.29676640f, -0.20057334f, 0.02731650f, 0.19222705f, 1.02791011f, -0.17505395f, 
    -0.48270816f, -0.50191760f, -0.80378151f, 0.49140778f, 0.16933218f, 0.17791972f, -0.10520313f, -0.01691363f, 
    -0.16049352f, -0.04870975f, -0.24501207f, 0.17743930f, 0.34974846f, -0.02717821f, -0.01274681f, 0.22806300f, 
    -0.23965223f, -0.05778624f, 0.00531869f, -0.39514205f, -0.21652786f, 0.15981609f, 0.34842712f, -0.32297978f, 
    -0.68495804f, -0.78432250f, -0.48553178f, -0.22925556f, -0.32942837f, -0.32328990f, -0.25810215f, -0.34216172f, 
    0.18335490f, 0.50160784f, 0.43810901f, 0.65729070f, 0.19853546f, 0.21708916f, -0.07092318f, -0.22014688f, 
    -0.19088301f, -0.39713109f, -0.28546080f, 0.61051214f, -0.32107198f, -0.01335071f, -0.04473862f, 0.32276031f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20638342f, 0.45083416f, -0.00175639f, 0.35885996f, 0.26889187f, 0.04416238f, 0.36599383f, 0.30713227f, 
    0.37915221f, 0.27063775f, -0.00569120f, 0.15021475f, 0.22070689f, 0.05350538f, 0.53507876f, -0.16679136f, 
    0.12115282f, -0.53857821f, 0.36377826f, 0.19036117f, -0.39015916f, 0.16246212f, 0.30715075f, -0.11154548f, 
    0.03899660f, 0.50928396f, -0.15067746f, 0.12666593f, -0.14158666f, -0.17504616f, 0.41452301f, 0.33773205f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05970750f, -0.03521912f, -0.01445048f, 0.02547941f, -0.22910008f, 0.04112724f, -0.20864712f, -0.10640832f, 
    -0.13419874f, 0.02784528f, -0.11744691f, -0.08044624f, 0.19242865f, 0.04329889f, -0.11525530f, -0.04270504f, 
    0.14510557f, 0.02320265f, 0.12197635f, -0.01184352f, -0.15523107f, -0.05919518f, -0.03013615f, -0.00205886f, 
    0.14898302f, 0.16341698f, -0.42011672f, -0.00920084f, 0.25652909f, -0.15432844f, -0.09214561f, -0.27558112f, 
    -0.04330246f, -0.11346436f, -0.10453437f, -0.11963421f, -0.23244090f, -0.29728258f, -0.60313714f, 0.15540144f, 
    0.02374116f, -0.00356693f, -0.11372531f, -0.12613060f, -0.07951666f, -0.03063038f, 0.00623938f, 0.01857637f, 
    0.71921861f, 0.41060749f, 0.34602025f, -0.39988768f, -0.34090325f, 0.01942961f, 0.20220447f, -0.17183606f, 
    -0.03110321f, -0.10010820f, -0.07904668f, -0.20769008f, -0.15971740f, -0.28086975f, -0.28279468f, 0.13226327f, 
    0.09926404f, 0.03302581f, -0.07206924f, 0.01843368f, 0.02988768f, -0.00900698f, 0.01574636f, 0.06961430f, 
    -0.22056158f, -0.56547010f, -0.51601285f, 0.19168399f, 0.14720072f, -0.00263863f, -0.13256861f, -0.21784779f, 
    0.04763194f, -0.25034082f, -0.24069847f, -0.16027629f, 0.06109973f, 0.08058336f, 0.04487700f, -0.16097045f, 
    0.02587541f, 0.17666507f, -0.01290272f, -0.04185115f, -0.03675542f, -0.14118378f, 0.02119738f, -0.00638030f, 
    0.37836617f, 0.10403474f, -0.12702790f, -0.39154643f, -0.19202054f, 0.01313689f, 0.06169153f, 0.05665728f, 
    -0.00137978f, -0.06820007f, -0.04191479f, 0.16652948f, -0.12544672f, -0.23714066f, 0.36540219f, -0.35559317f, 
    0.03904890f, -0.05972646f, -0.16652046f, 0.10432162f, -0.03843933f, -0.09536764f, -0.07206928f, 0.03209368f, 
    0.23546262f, 0.13712673f, 0.03224586f, -0.00011344f, 0.20570466f, 0.12463328f, 0.10960814f, -0.30656078f, 
    0.01992325f, 0.17817354f, 0.04375937f, 0.06885815f, -0.38626003f, -0.15831250f, 0.05058499f, 0.05092352f, 
    0.04787691f, 0.19245271f, 0.00424237f, 0.07554208f, -0.04636048f, 0.04159065f, -0.03957450f, -0.03706188f, 
    -0.22496234f, -0.97698933f, -0.48565304f, 0.28959170f, 0.05268401f, 0.06132125f, 0.00922577f, -0.05391444f, 
    -0.02600244f, 0.01089381f, -0.03658696f, -0.06202927f, 0.40546486f, 0.28390324f, -0.20315942f, -0.27635738f, 
    0.17274942f, -0.03965610f, -0.13536665f, 0.10826724f, -0.01459081f, -0.00860226f, 0.04959894f, -0.04212728f, 
    -0.35151634f, -0.80400383f, -0.29901862f, -0.02329740f, -0.00685284f, 0.10630717f, -0.09632962f, -0.07739589f, 
    -0.10116982f, -0.09568864f, -0.12688965f, -0.23396757f, 0.01878589f, 0.02301966f, 0.04610834f, 0.10670047f, 
    -0.06705449f, -0.02659594f, 0.05637584f, 0.02939689f, -0.32988572f, -0.16816747f, -0.07296720f, -0.05358236f, 
    0.13854147f, 0.02929090f, 0.11083008f, -0.19216152f, -0.09602302f, -0.09487781f, 0.10228311f, 0.08988996f, 
    0.01079611f, -0.08588466f, -0.06088402f, -0.15386693f, 0.34992194f, 0.29758909f, -0.12694825f, -0.01421528f, 
    0.15969680f, 0.21339540f, 0.25398132f, 0.01785236f, -0.10279419f, -0.08137925f, 0.03789078f, 0.08113264f, 
    -0.19122611f, -0.60139197f, -0.78284186f, 0.04192250f, -0.03586781f, 0.01809053f, -0.00774349f, 0.03851848f, 
    -0.01217598f, 0.01863895f, -0.00846521f, -0.23062673f, -0.70598125f, -0.63184422f, 0.33372793f, 0.21543217f, 
    -0.08408923f, -0.19763668f, 0.01337658f, 0.13456449f, 0.04739325f, -0.07603873f, -0.09767647f, 0.05908607f, 
    0.52281517f, 0.32775617f, -0.26533478f, -0.08764452f, 0.15187252f, 0.18049631f, 0.17286229f, 0.08243664f, 
    -0.12589401f, -0.02094845f, -0.01991798f, -0.04101470f, 0.28322616f, 0.12232856f, -0.16863710f, -0.09993850f, 
    -0.09144411f, -0.08473890f, 0.09674006f, 0.11846551f, -0.02275303f, 0.14215839f, -0.06512457f, -0.07427318f, 
    0.41706499f, 0.20601317f, -0.03839155f, -0.21658349f, 0.11685790f, -0.05956611f, 0.11625759f, 0.01879588f, 
    -0.11195278f, -0.16086550f, -0.16511531f, 0.06878521f, 0.02006526f, 0.09228693f, -0.05251514f, 0.10134045f, 
    -0.21668793f, 0.02129854f, -0.07145720f, -0.08456944f, -0.00473718f, 0.10645796f, -0.10968471f, -0.08324093f, 
    0.14099912f, 0.04027244f, -0.37995487f, -0.00723571f, -0.10394824f, 0.05392277f, -0.12953101f, -0.01944657f, 
    -0.00746514f, 0.09548875f, -0.01118932f, 0.07552420f, -0.31768259f, 0.07511991f, 0.23739827f, -0.21589734f, 
    -0.05903045f, -0.02138473f, -0.01945551f, 0.02775387f, -0.14263435f, -0.12851690f, -0.12688793f, -0.26111898f, 
    -0.65497983f, -0.39789537f, 0.01028316f, 0.01739403f, 0.05936350f, 0.06610405f, -0.12414532f, 0.01800913f, 
    0.12941603f, 0.00838530f, 0.10381667f, -0.05767867f, 0.02252051f, 0.04007690f, -0.06099985f, 0.06134385f, 
    0.16370291f, 0.10162823f, 0.01738954f, 0.06107406f, 0.01017416f, 0.06377962f, -0.00064407f, 0.12494268f, 
    0.31156582f, 0.12480701f, 0.04524951f, -0.01223001f, 0.03627074f, -0.02445923f, -0.03217944f, -0.21428373f, 
    -0.04295909f, -0.13802978f, -0.05601103f, 0.32036364f, -0.06002679f, 0.09340023f, -0.46070746f, 0.12601256f, 
    -0.00217613f, 0.00213685f, -0.01384981f, 0.06148916f, -0.04499289f, 0.00388424f, 0.02151503f, 0.09090475f, 
    -0.15827267f, -0.52457494f, -0.28859887f, 0.07335451f, 0.03383686f, 0.01387526f, -0.10366415f, -0.23662393f, 
    -0.06456565f, -0.00440866f, 0.00461814f, -0.12345795f, 0.33016264f, 0.27428010f, -0.14087652f, -0.31814498f, 
    0.08723167f, 0.15404193f, 0.13555329f, -0.20298670f, -0.13936831f, -0.10160258f, 0.00024908f, 0.03238370f, 
    -0.04860193f, 0.08145364f, 0.03350261f, 0.01216348f, 0.00235106f, 0.01943457f, 0.04741304f, -0.10784523f, 
    -0.09404083f, -0.05381921f, 0.04028657f, 0.00958584f, 0.25339830f, -0.36681479f, -0.43923047f, -0.30323321f, 
    -0.07384297f, -0.06366011f, 0.18116306f, 0.01944960f, -0.02861574f, -0.20696634f, -0.03713290f, 0.01360465f, 
    0.23469129f, 0.02010906f, 0.01529211f, 0.09460037f, -0.12224388f, 0.18098146f, 0.16669618f, -0.00830345f, 
    -0.02618737f, -0.03797956f, -0.02552203f, 0.06454353f, 0.28488457f, -0.14914164f, 0.05626215f, -0.26734203f, 
    0.07847740f, -0.11703467f, -0.03522795f, -0.02606760f, -0.08688804f, -0.06290530f, 0.02288000f, 0.07559211f, 
    -0.04510437f, -0.20078473f, -0.64013207f, 0.03557177f, -0.05982717f, -0.22391550f, 0.25400192f, 0.05827070f, 
    0.10241466f, 0.03954144f, -0.06419281f, -0.17040035f, 0.21965876f, 0.17208056f, 0.05254436f, 0.15391786f, 
    -0.04220307f, -0.07881541f, -0.12008748f, 0.03359031f, 0.01912437f, -0.01496004f, 0.05097454f, 0.07307985f, 
    0.57222819f, 0.01029467f, -0.03802107f, -0.27640733f, -0.04003204f, 0.01115694f, -0.02029365f, -0.03611372f, 
    -0.08149748f, 0.13562453f, 0.03663580f, -0.07830945f, -0.20343238f, 0.23303433f, -0.24375816f, -0.12397251f, 
    0.12095777f, 0.08992462f, 0.00963145f, 0.08319046f, -0.01723054f, 0.06851374f, -0.11922920f, 0.05853556f, 
    0.02303992f, -0.31465217f, -0.20624527f, -0.71632403f, -0.07766281f, -0.04021486f, -0.18171832f, 0.28532910f, 
    0.05920380f, -0.07453898f, 0.09825824f, 0.00750572f, -0.01636570f, 0.07827763f, 0.17585692f, -0.27789447f, 
    0.17054719f, 0.07542716f, -0.08819357f, -0.10283911f, 0.05084083f, -0.05569423f, 0.01145108f, -0.04488214f, 
    0.18389788f, 0.07056944f, -0.03977528f, -0.09770736f, -0.03002729f, 0.02518319f, 0.02522569f, -0.57891393f, 
    0.30219403f, -0.11348207f, -0.02996135f, -0.20635337f, -0.16756101f, -0.08609009f, -0.11197799f, -0.15102597f, 
    0.06707921f, 0.06727616f, -0.18746625f, 0.03571517f, -0.20169704f, 0.00649843f, 0.12709157f, -0.01680659f, 
    0.66768408f, 0.27277258f, 0.57860690f, -0.05572462f, 0.02061049f, 0.01838429f, -0.07565627f, 0.04863587f, 
    -0.06740866f, 0.03834558f, -0.19773826f, 0.15200628f, 0.04453462f, 0.20088921f, -0.13989662f, 0.14165239f, 
    -0.19460997f, -0.05680756f, 0.01398926f, -0.17045790f, -0.03849862f, 0.02098771f, -0.04838044f, 0.07632763f, 
    0.87717199f, -0.24038915f, 0.54807919f, -0.34534130f, -0.01547074f, -0.07678328f, 0.17579566f, -0.07320640f, 
    0.05596543f, -0.10447089f, -0.09752716f, 0.11728865f, 0.05326706f, -0.03567076f, 0.13776633f, 0.12171834f, 
    -0.00849833f, -0.07522774f, -0.02064415f, -0.06223096f, 0.03690322f, 0.06065035f, -0.03693507f, 0.05648608f, 
    -0.38988402f, 0.21539102f, 0.15087007f, -0.01161317f, -0.13984968f, 0.11589084f, -0.03457611f, 0.04186400f, 
    0.23912741f, -0.32896528f, -0.00224037f, 0.10919797f, 0.24404927f, 0.28166661f, 0.49019507f, 0.09734213f, 
    -0.13090385f, -0.13356288f, -0.11192526f, 0.02352554f, -0.01008778f, -0.00731966f, -0.04336454f, -0.02094516f, 
    0.65084726f, 0.08098079f, 0.27076903f, 0.31798214f, -0.10474027f, 0.02075920f, 0.11223774f, -0.03370742f, 
    0.17866904f, 0.10522245f, -0.11705164f, 0.06733143f, -0.22582148f, -0.49563524f, 0.28110915f, -0.39234462f, 
    0.04042191f, -0.12410570f, -0.02404503f, 0.10266256f, 0.02800536f, -0.08434078f, 0.15447089f, -0.11566291f, 
    0.65021437f, 0.13160308f, 0.15659848f, 0.27356699f, 0.19808093f, -0.04339048f, 0.04499650f, 0.15956149f, 
    0.07275312f, -0.01866055f, -0.11703809f, -0.14809482f, -0.16534038f, -0.17096470f, -0.13072073f, -0.40430227f, 
    0.01367150f, -0.11583805f, -0.21993633f, 0.21878205f, -0.10455104f, -0.03580246f, -0.09378891f, 0.12531151f, 
    -0.29089403f, 0.24484803f, -0.14648584f, -0.01390746f, -0.15691802f, 0.20189859f, 0.00707492f, -0.14479139f, 
    0.02997584f, -0.06036680f, 0.02386591f, -0.06930161f, -0.20096266f, -0.07253343f, 0.00118807f, -0.16586924f, 
    -0.02355343f, -0.13359421f, -0.10749612f, 0.13945013f, -0.07320408f, -0.12620245f, -0.02072798f, 0.30075744f, 
    0.12145995f, -0.02771641f, -0.25137493f, -0.18489766f, -0.37805933f, -0.18518046f, -0.04831470f, -0.10986571f, 
    -0.15658583f, 0.07462057f, -0.06763034f, 0.01806344f, -0.33984557f, 0.25267515f, 0.06492126f, -0.22579440f, 
    -0.06041738f, 0.17778875f, -0.03135268f, 0.05934147f, -0.01218610f, 0.16949280f, -0.11841773f, 0.13947979f, 
    -0.10113994f, 0.12885308f, 0.00641737f, -0.14476064f, -0.00180095f, -0.03587364f, 0.03597085f, -0.04725578f, 
    -0.41245052f, -0.16584626f, -0.09854969f, -0.61639273f, 0.49211606f, -0.08236437f, 0.10960609f, -0.01264134f, 
    -0.07177059f, -0.03892520f, 0.07380433f, -0.27636480f, 0.01734027f, -0.11578460f, -0.19022691f, 0.01162677f, 
    -0.03319312f, 0.07242931f, 0.17941475f, -0.32632107f, 0.01840431f, 0.10149581f, -0.08333100f, -0.04944684f, 
    -0.12119250f, -0.01864663f, -0.26902866f, -0.51818299f, 0.39041942f, -0.01572991f, -0.11345914f, -0.10562570f, 
    -0.03461660f, -0.07915760f, -0.09724995f, -0.19827811f, 0.20529118f, 0.00956911f, -0.05383142f, 0.01347554f, 
    0.75624514f, -0.22709960f, 0.00800359f, -0.08515111f, -0.00694643f, 0.06177788f, 0.10574277f, -0.11564812f, 
    0.36970952f, 0.06308189f, 0.00465466f, -0.15793829f, -0.60995591f, -0.21849298f, -0.10119630f, 0.10927037f, 
    0.10562291f, 0.17993174f, 0.10984435f, 0.01723500f, 0.10244806f, -0.02084424f, 0.02109524f, 0.06191372f, 
    -0.12842879f, 0.04221191f, -0.04465560f, -0.03265376f, -0.17669189f, -0.05451795f, 0.11145298f, -0.00945409f, 
    -0.00759664f, -0.04656094f, -0.01335000f, 0.02627875f, 0.16325225f, -0.14491422f, 0.33560598f, 0.07168806f, 
    -0.01460741f, -0.10173621f, 0.08999887f, -0.00773288f, 0.04787018f, -0.09345946f, 0.06702101f, -0.05291304f, 
    -0.08533695f, 0.06282415f, -0.06648617f, -0.12644815f, -0.14037621f, 0.15565255f, 0.06259953f, -0.18222719f, 
    0.00715880f, -0.02812268f, 0.01731137f, -0.18029810f, -0.25789133f, -0.19268610f, 0.42453697f, -0.16301355f, 
    0.06871536f, -0.09040397f, -0.04135953f, 0.04307309f, 0.11588779f, -0.06703109f, 0.04264420f, 0.04615776f, 
    -0.15906717f, 0.20222677f, -0.26291865f, 0.17560595f, 0.04362044f, -0.12383386f, -0.02854505f, 0.27671942f, 
    0.03085462f, 0.08326450f, 0.04200407f, -0.15637216f, -0.04843802f, -0.09287102f, 0.14741486f, -0.47073197f, 
    0.01556267f, -0.10853884f, -0.07448342f, 0.05651966f, -0.02221059f, -0.06227206f, -0.02130882f, -0.02563049f, 
    -0.44798243f, 0.79342848f, 0.30140322f, -0.05643607f, -0.08345038f, 0.05229462f, -0.09298823f, -0.08406421f, 
    -0.03445809f, 0.01844982f, -0.02349883f, -0.08247876f, 0.04947680f, 0.70719856f, 0.10835759f, 0.61904842f, 
    -0.01492719f, -0.03623871f, -0.05811000f, 0.06447363f, -0.02572748f, -0.02880322f, -0.17306748f, -0.07808914f, 
    0.32706586f, 0.05575056f, -0.30618975f, -0.10138702f, 0.10446285f, 0.01340004f, 0.08731898f, 0.14133938f, 
    0.03217967f, 0.06763932f, -0.07535999f, -0.08951031f, -0.72621101f, 0.03787864f, 0.21689758f, -0.04122966f, 
    -0.11421664f, 0.12625201f, 0.05666692f, -0.15222538f, 0.01124492f, -0.09507316f, 0.08355384f, -0.13380191f, 
    0.11077829f, -0.02208918f, 0.21472068f, 0.13120370f, -0.02523355f, -0.05882346f, 0.13965105f, -0.17636135f, 
    -0.06454376f, 0.21382636f, 0.01543436f, 0.17241365f, 0.46694532f, 0.16374670f, 0.20351627f, 0.29997551f, 
    0.05087936f, 0.04978927f, 0.11574399f, -0.09796293f, -0.11636718f, 0.04710122f, -0.08748850f, 0.04650519f, 
    -0.16405493f, -0.33009502f, 0.20322667f, -0.13016067f, 0.00168025f, 0.01101009f, -0.02752429f, -0.02143149f, 
    0.10302284f, -0.03519154f, -0.13739499f, 0.19019119f, -0.47620076f, -0.34247163f, -0.59941757f, -0.18008350f, 
    -0.03836602f, 0.07506888f, -0.00927793f, 0.03422168f, -0.06637906f, 0.08226275f, -0.01082911f, -0.04238452f, 
    -0.20341110f, 0.49651513f, 0.04053656f, -0.75393480f, 0.02225135f, -0.07600988f, -0.05422760f, 0.07649314f, 
    -0.00373941f, 0.14435740f, -0.11734357f, -0.05992236f, -0.13002253f, -0.08907690f, -0.08026479f, 0.08261465f, 
    -0.07744580f, 0.03514905f, 0.06518716f, 0.14375947f, -0.18857992f, 0.01436291f, 0.21013761f, -0.06240716f, 
    0.30909345f, -0.16865948f, -0.45631331f, 0.21498322f, 0.22231159f, 0.05909568f, -0.03952144f, 0.16908495f, 
    0.17898373f, 0.12906630f, 0.09669603f, -0.09364821f, -0.80397207f, -0.18965711f, 0.24680315f, -0.40553701f, 
    -0.00698005f, 0.06853626f, 0.08280727f, 0.02656762f, -0.00767785f, -0.07080270f, 0.02287517f, -0.11896250f, 
    -0.01337942f, -0.04280300f, 0.15456910f, 0.16604109f, -0.05850955f, 0.01574587f, 0.11942733f, 0.05935768f, 
    0.08066899f, -0.04684410f, -0.07979687f, 0.02972272f, 0.52082777f, -0.31554794f, 0.23926225f, -0.22544825f, 
    0.00846155f, -0.09178331f, 0.06971836f, 0.05076900f, -0.01085592f, -0.08290826f, -0.06460267f, 0.11804477f, 
    -0.55456728f, -0.33136871f, 0.49052492f, 0.30017930f, -0.01288845f, -0.21365164f, -0.19443394f, 0.02763182f, 
    0.03572520f, 0.02449516f, -0.00339910f, 0.00060561f, -0.74965781f, -0.28907883f, -0.07440397f, -0.31654301f, 
    0.03199319f, -0.00221881f, -0.15188007f, -0.22056587f, 0.02865792f, -0.02311599f, -0.02631657f, 0.04307005f, 
    -0.23224521f, 0.23702636f, -0.01072653f, 0.16395420f, -0.03547532f, -0.08230403f, 0.17441835f, 0.07389218f, 
    -0.00368126f, 0.00799539f, 0.03933047f, 0.03154098f, 0.04135110f, -0.17535962f, 0.13620809f, -0.10699362f, 
    0.11193439f, -0.29118985f, -0.32717627f, -0.19965935f, 0.07340376f, 0.00389206f, -0.01842209f, 0.00166754f, 
    -0.30949149f, -0.65102959f, 0.33102101f, -0.76013446f, -0.12512900f, -0.07995705f, -0.33454552f, -0.26857734f, 
    -0.02990233f, -0.04558211f, -0.09192272f, -0.02720941f, -0.11511134f, -0.15165451f, -0.12655184f, 0.03634077f, 
    0.06252310f, 0.13663939f, -0.07499607f, 0.00423602f, -0.09362932f, 0.06953763f, -0.41053608f, 0.11458652f, 
    -0.00332005f, 0.02746145f, -0.03258631f, 0.30943277f, -0.02051288f, 0.00681339f, 0.09484717f, -0.04808822f, 
    0.10394444f, 0.04477494f, 0.03306730f, 0.18532073f, -0.04803400f, 0.34108239f, 0.31099936f, 0.11343294f, 
    -0.04228108f, 0.05044275f, 0.10644276f, -0.09984566f, 0.04522733f, 0.03130092f, 0.07953804f, 0.07283696f, 
    -0.14547245f, 0.02998762f, 0.54490256f, 0.00681170f, -0.17048492f, -0.03239404f, 0.17683245f, 0.04693351f, 
    0.00469120f, 0.06257369f, 0.02911450f, 0.05760169f, -0.26713929f, -0.07342989f, 0.12219782f, -0.52278757f, 
    0.03397033f, 0.04203904f, -0.02927140f, -0.01062206f, -0.01176437f, -0.03271118f, 0.06244513f, -0.09084507f, 
    -0.32539746f, 0.47248089f, 0.30141944f, -0.25305396f, -0.04832738f, 0.04702942f, -0.05512606f, -0.22043553f, 
    -0.01897468f, 0.06014273f, 0.03771525f, 0.05049202f, 0.04470285f, -0.31518376f, -0.23355357f, 0.22975278f, 
    -0.01622064f, 0.07989144f, -0.08318127f, 0.02056252f, -0.00966554f, 0.00559863f, -0.04680237f, 0.05204061f, 
    -0.18919303f, -0.39127910f, 0.14582147f, -0.12265380f, 0.02203887f, -0.24467567f, -0.24912232f, -0.18260632f, 
    -0.13711275f, -0.10160466f, 0.06103835f, -0.27191639f, -0.06625336f, -0.00551169f, -0.21347384f, 0.03920248f, 
    0.18390463f, 0.18251303f, 0.07789681f, -0.18703198f, -0.15212908f, -0.01058169f, -0.08392293f, -0.05058440f, 
    -0.18751547f, 0.37842909f, 0.07771707f, 0.33720872f, -0.09009327f, -0.06882850f, 0.01468516f, -0.19956462f, 
    -0.04855061f, 0.18941540f, 0.02890221f, -0.16923134f, -0.58464593f, 0.11456883f, 0.01235745f, 0.06998121f, 
    -0.07267081f, -0.27101189f, -0.40154886f, -0.06829365f, 0.00912528f, 0.17336208f, -0.07839648f, -0.09965252f, 
    -0.73025692f, 0.49576929f, -0.49008712f, -0.94233096f, 0.16149469f, 0.19526525f, -0.16743213f, 0.04380025f, 
    -0.43105236f, 0.06634010f, -0.13697407f, -0.18462375f, -0.60282487f, -0.20320962f, -0.00550131f, 0.09733873f, 
    -0.10354964f, -0.03119495f, 0.12821008f, -0.10803068f, 0.23248684f, 0.01729575f, 0.03289296f, 0.19615540f, 
    -0.56402820f, 0.30651999f, -0.21791562f, 0.51717794f, 0.02567843f, 0.08993195f, -0.16218813f, -0.06027041f, 
    0.06088366f, 0.05466367f, 0.38935268f, 0.07190941f, 0.43844861f, -0.09856201f, -0.02829826f, 0.22791593f, 
    -0.02902812f, -0.14327040f, -0.05810749f, -0.05779366f, 0.00414646f, 0.11739967f, -0.12512605f, 0.22798593f, 
    0.06327529f, 0.05731771f, -0.03533645f, 0.04076821f, 0.01745887f, -0.06832456f, -0.05856443f, -0.07393225f, 
    0.02201125f, -0.03773886f, 0.03595136f, -0.04192618f, 0.08510658f, 0.01972149f, -0.03062720f, -0.18258835f, 
    -0.22048409f, -0.08183376f, -0.09815752f, -0.18834569f, 0.06004154f, 0.07033078f, -0.03830398f, -0.22849646f, 
    -0.75712514f, -0.32621148f, 0.21410106f, -0.16712864f, 0.15819037f, -0.10826869f, -0.10780557f, 0.05865419f, 
    0.00820054f, 0.15417308f, -0.16162674f, -0.04176353f, 1.04703891f, -0.25553301f, -0.10276170f, 0.21602173f, 
    0.11222956f, -0.08029497f, -0.03833145f, -0.27804521f, -0.16696693f, 0.01678803f, 0.00826668f, 0.04315376f, 
    -0.43946606f, 0.06710207f, 0.28014120f, -0.22368918f, -0.03945565f, 0.04009966f, -0.39881149f, -0.15858144f, 
    -0.24716012f, 0.06357743f, -0.07597808f, -0.08388346f, 0.00130897f, -0.24146479f, 0.02494568f, 0.08019994f, 
    -0.13939561f, 0.11439130f, 0.01107181f, -0.04238850f, 0.10436966f, -0.13645175f, -0.05426944f, 0.13280155f, 
    -0.31409124f, 0.06358271f, 0.06602745f, 0.27726528f, -0.01988547f, -0.09692165f, -0.11531131f, 0.01385936f, 
    -0.02979922f, 0.12647240f, 0.13078459f, -0.03762803f, -0.21875831f, -0.26286158f, 0.03032816f, -0.27222785f, 
    0.02167934f, 0.14801948f, 0.31358331f, -0.05140588f, -0.03784112f, -0.14630415f, -0.28308734f, -0.24276872f, 
    0.17040116f, 0.80951053f, -0.03444199f, -0.66152048f, -0.00757276f, -0.06382542f, 0.00390342f, -0.31577966f, 
    -0.70308203f, -0.01911029f, -0.26098770f, 0.11471982f, 0.22140785f, -0.08857691f, -0.04840248f, 0.19392419f, 
    0.03780152f, -0.07228205f, 0.00650817f, -0.10053579f, 0.08781099f, -0.04309224f, 0.17020215f, 0.02678388f, 
    0.48944506f, 0.38183826f, -0.22870688f, -0.20628588f, 0.24878334f, -0.07435404f, 0.19455129f, 0.05322890f, 
    -0.30987841f, -0.08018396f, -0.16758610f, -0.22456492f, 0.47695544f, 0.65976089f, 0.16508105f, -0.18056707f, 
    -0.26337120f, -0.20650481f, -0.03050248f, -0.02548701f, 0.08393300f, -0.19562604f, 0.01683821f, -0.00165793f, 
    -0.14416490f, 0.00635671f, -0.13752884f, 0.15657824f, 0.12689127f, 0.09701758f, 0.05144364f, -0.03718871f, 
    -0.07501648f, 0.16873731f, -0.05092590f, 0.09386224f, 0.01099070f, -0.29194546f, 0.10131372f, 0.13686226f, 
    0.01371766f, 0.12587698f, -0.04528206f, 0.10401303f, 0.02085542f, -0.10525014f, -0.19736588f, 0.00045450f, 
    -0.19249196f, -0.13140149f, -0.13430895f, 0.11088223f, 0.04324421f, -0.14394766f, -0.04610642f, -0.07842542f, 
    -0.09216160f, -0.07499346f, 0.23403946f, -0.03539882f, 0.01336143f, 0.24219219f, 0.32591066f, -0.04465720f, 
    -0.06269585f, 0.34974355f, 0.10554503f, 0.05506807f, 0.13693903f, -0.04570950f, 0.19791223f, 0.11276212f, 
    -0.07385740f, -0.23133017f, 0.40649426f, 0.27646989f, 0.10458397f, 0.08069865f, -0.19597547f, 0.11827423f, 
    -0.01193617f, -0.14728370f, 0.02672686f, -0.07102953f, 0.39668596f, 0.01812859f, 0.03542079f, -0.22736108f, 
    0.19886363f, -0.04436643f, 0.19578893f, -0.17922977f, 0.01084157f, 0.19913223f, -0.15892151f, 0.03776249f, 
    0.65152317f, -0.54921454f, 0.01645014f, 0.13691770f, 0.15427579f, 0.34274566f, 0.02522484f, 0.23341191f, 
    0.00554333f, 0.06078261f, 0.14592552f, 0.00584783f, -0.17180806f, 0.16700068f, -0.06931074f, 0.17035764f, 
    0.09687478f, 0.20278646f, 0.23289815f, -0.19526234f, -0.14795713f, 0.02072624f, -0.13765220f, 0.12214406f, 
    -0.11956244f, -0.01081476f, 0.10271043f, 0.19328344f, 0.00689696f, 0.01984864f, -0.03175591f, -0.12623784f, 
    -0.05210825f, 0.10748065f, 0.11014368f, 0.05194462f, -0.01180215f, 0.06444862f, 0.46178338f, 0.52436697f, 
    -0.18563820f, -0.00656093f, -0.09909002f, 0.13255203f, 0.05592967f, 0.10679264f, 0.16525017f, -0.03010687f, 
    -0.89493781f, -0.26311743f, 0.02429270f, 0.31640562f, -0.04626105f, -0.12499479f, 0.00249262f, -0.11754862f, 
    -0.11753269f, -0.18017039f, 0.12114992f, -0.08379778f, -0.05470001f, -0.07997264f, -0.10733612f, 0.16753678f, 
    0.00629552f, 0.03949427f, 0.06656925f, 0.14306958f, 0.00872569f, 0.18589120f, 0.03294795f, -0.02985756f, 
    0.10058484f, 0.02959094f, 0.07143655f, 0.10129611f, -0.06572361f, -0.11055896f, -0.06115344f, 0.22973515f, 
    0.07271428f, -0.17196746f, -0.18814681f, -0.10651471f, 0.28163728f, 0.33048952f, 0.05070945f, 0.12346004f, 
    -0.21516512f, -0.19248179f, 0.05570634f, -0.14757277f, -0.07684531f, -0.01994501f, -0.02683906f, 0.06992310f, 
    0.07403950f, -0.26314491f, 0.25834799f, 0.08484641f, 0.00832997f, 0.01484764f, -0.17822021f, 0.06577631f, 
    -0.14136621f, -0.18273288f, -0.01531164f, -0.21152176f, 0.23412386f, 0.04302014f, -0.18119769f, -0.02425208f, 
    0.00293233f, 0.09865275f, 0.10001305f, -0.22988914f, 0.12004765f, -0.03925356f, -0.01062035f, -0.18043065f, 
    0.29623067f, -0.67363936f, 0.36562458f, 0.06522819f, -0.28141323f, 0.13327190f, -0.06287881f, -0.15397491f, 
    -0.22510543f, 0.05852609f, -0.15454845f, -0.01954935f, 0.08553205f, -0.06869452f, -0.12936769f, 0.31042662f, 
    0.16199473f, 0.13315096f, 0.04158106f, 0.00735953f, 0.11576667f, 0.13238680f, -0.04644321f, 0.10288869f, 
    -0.34104049f, -0.16909657f, 0.05523499f, 0.01539642f, 0.08236460f, -0.07215616f, -0.03321762f, 0.02508216f, 
    -0.11655005f, -0.35413721f, -0.29533517f, 0.08343368f, -0.23804811f, -0.07269701f, 0.03689183f, 0.06123951f, 
    -0.00909154f, -0.12656868f, -0.18468963f, -0.06642926f, -0.00015889f, -0.08731593f, -0.11226600f, -0.13510375f, 
    -0.18583737f, -0.08300275f, 0.07662749f, 0.30068445f, -0.07129041f, -0.20465519f, 0.08498791f, -0.35761189f, 
    0.02955408f, 0.02134056f, -0.07449260f, 0.00271966f, -0.47240382f, -0.06600208f, -0.15834440f, 0.30668789f, 
    -0.42938572f, -0.02868290f, -0.05297494f, 0.00149916f, 0.01765640f, 0.01708725f, 0.01435250f, -0.05705005f, 
    0.04723591f, 0.02460638f, -0.04517692f, 0.06754801f, -0.14082649f, -0.21012636f, 0.16990677f, -0.10308333f, 
    -0.16247600f, -0.28290564f, -0.03014534f, 0.10594907f, -0.10482894f, 0.02200997f, -0.07593554f, -0.08011599f, 
    -0.05971784f, -0.05125139f, 0.03933234f, 0.04432215f, 0.09445079f, -0.16913065f, 0.02660679f, 0.02120651f, 
    -0.13841809f, -0.44074181f, -0.22062504f, -0.15123388f, -0.01444981f, 0.04730379f, 0.18153094f, -0.08925225f, 
    0.13631982f, -0.03645356f, 0.07536918f, -0.01227073f, 0.03903881f, 0.29574102f, 0.31821153f, 0.33768931f, 
    -0.14682318f, -0.04364556f, -0.02219966f, 0.22349283f, -0.01304197f, -0.00869580f, -0.00565996f, -0.10287685f, 
    -0.23076659f, 0.10950950f, -0.59851438f, -0.15495968f, 0.22685343f, -0.04842465f, -0.08381080f, -0.01126574f, 
    0.04651757f, 0.04234396f, -0.08347842f, -0.02623035f, 0.08717095f, 0.01976760f, 0.00921719f, 0.10989317f, 
    0.03729229f, 0.00195652f, -0.05833506f, 0.09363022f, -0.20311762f, 0.13595299f, 0.03823917f, 0.19615163f, 
    0.04910323f, -0.83500379f, 0.14574669f, -0.03916942f, -0.29495010f, 0.08065880f, 0.04092599f, 0.03343823f, 
    -0.07226994f, 0.09384729f, -0.03276324f, 0.03904439f, -0.08378452f, -0.08364765f, 0.07511128f, 0.27946445f, 
    -0.07725846f, -0.00128916f, -0.13563676f, -0.09359551f, 0.06420857f, 0.02097046f, -0.00196803f, -0.02725951f, 
    -0.48820412f, -0.12381110f, 0.10247719f, -0.24179088f, 0.00317054f, 0.11620767f, -0.11423653f, 0.05429884f, 
    -0.03867875f, -0.00641287f, -0.11939382f, -0.32992503f, 0.08513460f, -0.46800309f, -0.45503399f, 0.05717111f, 
    0.16428760f, 0.02751596f, -0.16800980f, -0.07562868f, 0.04068322f, -0.04532785f, 0.01851972f, -0.05862747f, 
    -0.28852418f, -0.21837282f, 0.07458071f, 0.05213602f, -0.08552292f, -0.06519940f, 0.02836970f, -0.07702958f, 
    -0.03935970f, -0.03700240f, 0.14617078f, 0.10055983f, 0.16574977f, 0.37352979f, 0.14518192f, 0.14943279f, 
    0.11709343f, -0.13776132f, -0.02093643f, 0.04536849f, 0.04968881f, -0.10585929f, 0.13652922f, -0.14617373f, 
    -0.08604345f, 0.01979453f, 0.35058123f, -0.00751464f, -0.13131706f, -0.02002474f, 0.02886075f, -0.07537682f, 
    0.11655008f, -0.00009979f, -0.03509083f, 0.06834532f, 0.25589424f, 0.09116986f, 0.10961598f, 0.37754247f, 
    0.12603690f, -0.04103183f, -0.04683797f, -0.22636916f, 0.14271297f, -0.06856478f, 0.15390086f, 0.00225879f, 
    0.09954510f, 0.43470812f, -0.11631995f, 0.28709590f, 0.18709862f, 0.14381401f, 0.15513551f, 0.26764613f, 
    0.03896187f, -0.02928567f, 0.00584574f, -0.11824533f, 0.10928686f, 0.14811780f, -0.14464110f, -0.00894788f, 
    -0.05229304f, -0.04053893f, 0.04858924f, 0.02117294f, -0.31766635f, -0.43434533f, -0.26733333f, -0.28293836f, 
    -0.17346688f, 0.12524867f, -0.03099571f, -0.09731076f, -0.02998120f, -0.10498568f, 0.10869902f, 0.04813445f, 
    0.11707523f, 0.08607209f, -0.04305107f, 0.27331147f, -0.18042150f, -0.07579461f, 0.05800342f, -0.00728682f, 
    -0.08774859f, -0.10639124f, -0.07099800f, -0.01988623f, 0.00711120f, -0.00624457f, -0.09429912f, -0.04337937f, 
    -0.08654327f, 0.07671501f, -0.04540566f, 0.10911426f, -0.05683547f, -0.04928070f, 0.09038471f, 0.07918571f, 
    0.34061515f, -0.00699522f, 0.03950554f, 0.29586780f, 0.12175997f, -0.06188951f, 0.20824209f, 0.08744818f, 
    0.16085567f, 0.06944115f, 0.08359272f, 0.16855066f, 0.01591533f, 0.01818379f, -0.06350777f, -0.04450881f, 
    -0.08906996f, 0.00133120f, 0.03897658f, 0.10489447f, -0.04201679f, -0.15819867f, -0.11120269f, -0.16809748f, 
    -0.23815779f, 0.22562717f, -0.12673219f, 0.11476973f, 0.35213557f, 0.28942811f, 0.32346570f, 0.28351185f, 
    -0.06118863f, -0.16113631f, -0.23097117f, -0.16028309f, 0.02519325f, -0.00476605f, -0.00442275f, 0.06460401f, 
    0.09563108f, -0.10867561f, -0.04902166f, -0.13444835f, 0.03260428f, 0.32036579f, -0.02278619f, -0.25587383f, 
    0.16062188f, 0.23048900f, 0.05917723f, 0.20499259f, -0.65933007f, -0.16183451f, 0.08437237f, 0.08512243f, 
    -0.00364977f, 0.23077948f, -0.12270358f, -0.01724758f, 0.27579361f, 0.39601550f, -0.00076679f, -0.11793478f, 
    -0.00608754f, 0.09293420f, -0.01685315f, -0.24527813f, 0.16456994f, 0.06979395f, -0.07140738f, 0.06924006f, 
    0.16103117f, -0.00384567f, 0.09449562f, 0.25251257f, 0.00443309f, -0.05697225f, -0.30222657f, 0.28202885f, 
    0.08730403f, 0.22852290f, -0.12188048f, 0.08665887f, 0.09404430f, -0.10098947f, 0.03911781f, -0.07936426f, 
    -0.01474063f, -0.30535477f, 0.23794080f, 0.35401279f, -0.10942277f, -0.15242708f, 0.05060657f, 0.01247204f, 
    0.12958856f, -0.22712268f, -0.00603852f, 0.21794675f, -0.20949651f, -0.15029749f, -0.23075312f, -0.07550710f, 
    0.05096646f, 0.09671064f, 0.00148012f, 0.01975379f, -0.01298377f, -0.07609990f, -0.04515204f, -0.32624590f, 
    0.34454700f, -0.61326009f, -0.58061624f, -0.19710127f, -0.05194610f, 0.09883085f, -0.04291440f, 0.05321942f, 
    0.19759087f, 0.09640387f, 0.02589721f, -0.00353618f, 0.14489652f, -0.02379287f, -0.04178043f, 0.00741917f, 
    -0.05895578f, 0.04233148f, -0.06596935f, -0.08023172f, -0.03813537f, 0.06693191f, 0.08329154f, -0.02707499f, 
    -0.11782959f, 0.31410179f, 0.11408138f, 0.27889124f, 0.06432402f, -0.03575760f, 0.06724404f, 0.13989465f, 
    -0.06008282f, 0.06546014f, 0.07636756f, -0.07051200f, 0.19718823f, -0.20183349f, -0.18038359f, 0.35663331f, 
    0.09944562f, -0.08493151f, -0.07772242f, 0.21579902f, -0.00930093f, 0.08088166f, 0.02573563f, 0.11766125f, 
    0.02742898f, -0.18383311f, -0.22733419f, -0.05624899f, 0.03124964f, 0.15577872f, -0.13613829f, 0.45155120f, 
    -0.25028187f, -0.01834373f, 0.02422924f, 0.00753171f, -1.07727170f, -0.07075603f, -0.19361454f, -0.14382014f, 
    0.04556797f, -0.02533061f, 0.07463973f, 0.08730803f, 0.17052571f, -0.01933165f, -0.19700578f, -0.13006450f, 
    -0.24120222f, -0.21169004f, -0.36488262f, 0.41079760f, 0.02965194f, -0.05956467f, -0.01564307f, 0.01639698f, 
    0.09046963f, -0.09062295f, 0.13398975f, -0.11049358f, 0.04195117f, 0.00341677f, 0.09536285f, -0.05324921f, 
    0.26619485f, 0.17849185f, 0.03272761f, -0.20941825f, -0.01739727f, 0.03444092f, 0.06175090f, 0.07508535f, 
    0.22568733f, 0.03631178f, -0.84806979f, 0.20500655f, 0.05531377f, 0.07436824f, -0.07486454f, -0.09769037f, 
    0.17005247f, -0.28900793f, -0.09608560f, 0.08252487f, 0.01509175f, 0.00878330f, -0.04783814f, 0.03173137f, 
    0.03124220f, -0.19790256f, -0.01722291f, 0.07582657f, -0.00836005f, -0.27843803f, 0.12921649f, 0.00925459f, 
    0.05300330f, -0.23986799f, 0.03309974f, 0.39658937f, 0.19068179f, -0.14003931f, -0.21058719f, 0.06539076f, 
    -0.08221891f, -0.02660544f, -0.07161376f, -0.22774419f, -0.24634843f, 0.26571080f, -0.23084801f, -0.33923689f, 
    0.16620180f, 0.06329172f, 0.26386252f, -0.02923916f, 0.09025791f, 0.02733072f, 0.05705712f, 0.03700265f, 
    -0.43744242f, -0.16998956f, -0.35864380f, -0.31493187f, 0.04162135f, -0.01616173f, -0.02153829f, -0.06957324f, 
    -0.04278499f, -0.20374626f, 0.15864410f, 0.25309512f, -0.26914230f, 0.02375941f, -0.33280694f, 0.44057867f, 
    0.10397492f, 0.01877520f, 0.01601133f, -0.03794221f, -0.07644664f, 0.22800036f, -0.20727442f, -0.07254476f, 
    -0.40446359f, 0.11395203f, 0.27586332f, -0.32176307f, -0.11511649f, -0.15701647f, -0.13717380f, 0.01964937f, 
    0.03887123f, -0.07691106f, -0.07628817f, 0.06480075f, 0.17441426f, 0.26733226f, 0.15365845f, 0.00902969f, 
    -0.12176514f, 0.01913761f, 0.19694445f, -0.14588717f, 0.03269158f, 0.00544009f, 0.03384044f, -0.03861360f, 
    0.38005763f, 0.09905748f, -0.01606228f, 0.07775527f, 0.05046349f, 0.04259716f, -0.05827650f, -0.09157261f, 
    -0.04371572f, -0.01054805f, -0.00702700f, -0.07145098f, -0.08172865f, 0.04153309f, -0.15230563f, 0.04104817f, 
    -0.07364634f, -0.09806967f, -0.00092478f, 0.04005248f, -0.18838267f, -0.03152544f, -0.05767750f, -0.32017544f, 
    0.09207849f, 0.19911504f, 0.01082378f, -0.30279574f, 0.11133496f, 0.10868724f, 0.24835268f, 0.17490575f, 
    0.06929620f, 0.05945532f, 0.12981774f, 0.00865571f, -0.38955730f, -0.48238689f, 0.25564319f, 0.49324885f, 
    -0.26136675f, -0.14735244f, -0.02885701f, 0.02272218f, 0.27908266f, -0.07252478f, 0.18257447f, 0.12776665f, 
    0.08931192f, -0.36612821f, -0.21106735f, -0.15729263f, -0.01830113f, -0.03626360f, 0.00412997f, -0.00815723f, 
    0.01103401f, -0.02254425f, -0.15796395f, 0.05019778f, -0.13449958f, -0.36307612f, -0.36675024f, -0.07127279f, 
    0.11378745f, -0.03637904f, -0.17262785f, 0.21862917f, -0.13577501f, -0.15552545f, 0.15907080f, -0.06166936f, 
    0.24566071f, -0.09257586f, 0.03224875f, -0.04328610f, 0.06793676f, -0.03748231f, -0.02426835f, -0.04474587f, 
    -0.11486799f, -0.10628387f, -0.15486431f, -0.48990697f, -0.01754773f, 0.03374344f, -0.52936262f, -0.26541606f, 
    0.07448378f, 0.03724751f, -0.21772157f, -0.05361360f, -0.08616466f, 0.06872386f, 0.04624376f, 0.00923584f, 
    -0.29985872f, -0.04046398f, -0.38996568f, -0.19636633f, -0.02738877f, -0.00005658f, -0.09476832f, 0.27885988f, 
    0.07657397f, -0.20714580f, -0.15169831f, 0.06636471f, 0.18062192f, -0.10222832f, 0.17984289f, -0.22647516f, 
    -0.02304619f, 0.10848496f, 0.04153664f, 0.11482129f, 0.00434568f, -0.09216067f, -0.10526793f, 0.02134125f, 
    0.03518153f, 0.07445051f, -0.08888356f, -0.09450737f, 0.04291172f, -0.17299081f, 0.02187495f, 0.03735144f, 
    0.05453394f, -0.13279270f, -0.00456495f, -0.17347853f, -0.71012872f, -0.10184699f, 0.89233530f, 0.32777455f, 
    -0.13552029f, -0.12507337f, -0.10219689f, -0.16537729f, -0.34500352f, 0.06800928f, -0.04296458f, 0.03653006f, 
    -0.34161079f, -0.40240458f, -0.16353343f, -0.49096882f, -0.14790916f, -0.38449177f, 0.03102840f, 0.11127043f, 
    0.02198048f, 0.12819007f, -0.21290240f, -0.11049142f, 0.32451960f, -0.27615634f, -0.02003629f, -0.32225874f, 
    -0.05827292f, 0.04444892f, 0.13625902f, 0.10556113f, 0.00730167f, 0.15951756f, -0.10008999f, -0.05652495f, 
    -0.24952550f, -0.22038205f, -0.16039439f, 0.05958627f, -0.02028975f, -0.00197086f, -0.11364483f, 0.10644725f, 
    0.06797816f, 0.10387310f, 0.27443457f, 0.08216350f, 0.10812864f, -0.15130657f, -0.04007059f, -0.17840487f, 
    -0.01414748f, 0.07006881f, 0.06887553f, -0.06705336f, -0.12842286f, -0.03045258f, -0.07873009f, 0.03976097f, 
    0.33542562f, 0.38579062f, -0.14682651f, 0.38339785f, 0.01980235f, -0.12973890f, 0.03437066f, 0.15194167f, 
    0.12723233f, 0.01941548f, -0.14490807f, -0.09886291f, -0.58785838f, -0.17057292f, 0.03385758f, 0.56623369f, 
    0.04680080f, 0.11257865f, -0.09876445f, 0.03319983f, 0.06047833f, -0.01383902f, -0.04369853f, -0.10460719f, 
    -1.05161989f, -0.69737613f, -0.12640007f, 0.61581457f, 0.10028116f, 0.23057508f, -0.05952969f, -0.32986021f, 
    0.00813724f, -0.02864615f, 0.02153408f, 0.05373526f, 0.45240882f, -0.18363237f, -0.72984707f, -0.35764655f, 
    -0.31513935f, 0.02363415f, 0.31032011f, 0.17388497f, -0.07673872f, 0.04036102f, -0.20966487f, -0.04779849f, 
    -0.25317097f, 0.24398006f, 0.04817181f, 0.15260711f, 0.03613279f, 0.05394817f, -0.07189582f, 0.16908644f, 
    0.05120128f, -0.09822482f, 0.26982033f, 0.08385594f, 0.14659081f, 0.17749208f, 0.26250431f, 0.20791908f, 
    -0.01248436f, -0.00089356f, 0.03948789f, 0.08467422f, -0.00234641f, 0.04269380f, 0.17972334f, 0.24468686f, 
    0.19199678f, 0.03967728f, -0.15496442f, -0.40724385f, 0.04240457f, -0.02961187f, 0.09791160f, -0.08557405f, 
    -0.03856983f, -0.05156308f, 0.08138607f, -0.17141008f, -0.81985784f, -0.77005321f, -0.43741536f, 0.11805564f, 
    0.00228823f, -0.28103158f, -0.13085344f, -0.12476508f, -0.02964973f, -0.04259225f, 0.00069543f, -0.02102881f, 
    0.41595203f, 0.04185740f, 0.06212097f, -0.15124065f, 0.04813747f, -0.01404259f, 0.14863558f, -0.05381609f, 
    0.07215907f, 0.20316644f, 0.11715717f, -0.01891283f, -0.13700712f, -0.07676692f, 0.11391163f, -0.12980832f, 
    0.03100029f, -0.13927431f, -0.00207393f, 0.03783068f, -0.12981269f, -0.11714610f, -0.19062433f, -0.19671461f, 
    -0.03822324f, -0.12884580f, 0.16120689f, 0.08370714f, -0.07911462f, 0.09730342f, 0.03757270f, -0.04173137f, 
    -0.12710091f, 0.20530269f, -0.06478997f, 0.28440422f, -0.83514935f, -0.93952602f, -0.28349730f, -0.28288025f, 
    -0.10646567f, -0.25469375f, -0.20585400f, -0.25817078f, -0.01948772f, 0.04378169f, 0.00385834f, -0.03215765f, 
    -0.32851034f, 0.14334567f, 0.13389987f, -0.05626337f, 0.14097144f, -0.07636719f, 0.01038499f, -0.13923183f, 
    -0.02159771f, 0.00027635f, -0.01655893f, 0.14129616f, 0.05007434f, 0.01595840f, -0.30708033f, -0.62452781f, 
    -0.11172130f, 0.12511256f, 0.11169853f, -0.01405328f, -0.10868958f, 0.05389851f, 0.10887340f, -0.02758033f, 
    -0.31746727f, -0.69177705f, -0.32374918f, -0.00861350f, -0.05639150f, -0.14175956f, -0.11777999f, -0.25819206f, 
    -0.03492694f, 0.09748502f, 0.05700675f, 0.01072076f, -0.83215481f, -1.26541770f, 0.04275098f, -0.09436863f, 
    0.07932588f, 0.13230193f, -0.01772191f, -0.28052914f, 0.01583870f, -0.02502094f, 0.14711349f, 0.07617325f, 
    -0.73740208f, 0.12633277f, 0.04461511f, -0.17595606f, -0.11149292f, 0.22380500f, -0.06017982f, -0.27428636f, 
    0.07522118f, 0.05756941f, -0.12086785f, 0.16742389f, -0.04840964f, -0.19912098f, -0.25406727f, -0.21873975f, 
    -0.11671957f, 0.01944060f, 0.28359103f, 0.14396307f, 0.16014668f, 0.21926811f, -0.12232859f, 0.07698904f, 
    -0.67692721f, -0.80368429f, 0.22329415f, -0.69635117f, 0.01449296f, -0.00155719f, 0.03341802f, -0.12067303f, 
    0.09011271f, -0.03760384f, -0.04911918f, -0.02966356f, -0.05856420f, -0.06856315f, -0.25755888f, 0.32574585f, 
    0.00643470f, -0.14356415f, 0.05858025f, 0.10003994f, -0.07604608f, -0.04765796f, 0.32718590f, 0.15213396f, 
    0.11769687f, -0.01831579f, 0.05995344f, 0.25129130f, -0.09542761f, -0.03764809f, -0.00226362f, -0.02316797f, 
    0.09342612f, 0.02087825f, 0.25750479f, 0.27030545f, -0.13936619f, 0.49467188f, -0.10942254f, 0.17740169f, 
    -0.05140979f, 0.05117476f, -0.00187771f, 0.28647935f, 0.07035236f, 0.11318500f, 0.17478149f, -0.04798355f, 
    -0.44132531f, -0.16975817f, -0.20453818f, -0.23941907f, -0.12064631f, 0.12982133f, -0.03257046f, -0.00062987f, 
    0.07274718f, 0.04822530f, 0.28835270f, 0.24765493f, -0.29264417f, -0.18296278f, 0.18954569f, -0.48601085f, 
    0.00965155f, 0.05406912f, 0.11218730f, -0.04263670f, 0.02471790f, -0.09840678f, 0.02024765f, 0.19871999f, 
    0.41931620f, 0.32436094f, 0.01891445f, 0.07748705f, 0.07682499f, -0.16284771f, 0.18871799f, 0.01090036f, 
    0.05024924f, -0.01400584f, 0.22992221f, 0.04620527f, -0.28184816f, 0.22837640f, -0.00690073f, -0.25645757f, 
    -0.08718422f, -0.22581275f, -0.13666259f, -0.02107160f, -0.02385394f, 0.04093072f, -0.07156547f, 0.00743335f, 
    -0.05409835f, 0.01307259f, 0.10647708f, -0.05665772f, -0.05743836f, 0.05034377f, 0.19050913f, 0.02264577f, 
    -0.07316213f, 0.10164543f, -0.06219364f, 0.10075446f, 0.73434758f, 0.13506992f, -0.69850475f, -0.62489587f, 
    -0.11378529f, -0.27411976f, -0.20438422f, 0.25920892f, 0.04042575f, 0.08292378f, -0.01021795f, 0.04258136f, 
    -0.11846352f, 0.30613747f, 0.56726635f, 0.10225163f, -0.00075835f, -0.11330367f, 0.13292709f, -0.12602669f, 
    0.00773158f, 0.00457164f, -0.04598252f, -0.05340431f, -0.17933729f, 0.13594761f, -0.04798251f, -0.01254041f, 
    -0.04400053f, -0.01777775f, 0.02590793f, -0.00471590f, 0.02265370f, -0.00669380f, 0.09046352f, -0.00201181f, 
    0.53966683f, -0.13463064f, 0.38971436f, -0.75943381f, 0.01749269f, 0.26797026f, -0.38860774f, 0.08876069f, 
    -0.16973981f, 0.11228354f, -0.10687388f, -0.10457586f, -0.05187689f, 0.16774876f, 0.05371804f, 0.05193857f, 
    -0.05427876f, 0.01017540f, -0.06241248f, 0.02206636f, 0.08979981f, 0.08726633f, 0.11542087f, -0.01778807f, 
    -0.34771383f, -0.11687095f, 0.12808207f, -0.03826175f, -0.13910289f, -0.02003485f, 0.21476887f, 0.03504916f, 
    -0.00422515f, -0.04939171f, 0.10705648f, 0.00050052f, -0.30282924f, -0.17952213f, -0.65002227f, -0.27234554f, 
    -0.05046678f, -0.14732520f, 0.20982790f, -0.05361648f, -0.05289070f, -0.02977640f, 0.02143333f, -0.01009981f, 
    -0.08180621f, -0.25456059f, -0.15471038f, -0.22149506f, -0.00553850f, -0.05787398f, -0.05716620f, -0.10348701f, 
    0.05903591f, 0.04304476f, 0.00284832f, -0.02083990f, -0.18400423f, -0.20006157f, -0.10088258f, 0.08746351f, 
    -0.03687783f, 0.12181833f, -0.23742127f, -0.00962763f, 0.08191555f, 0.01872977f, -0.06551098f, -0.00379844f, 
    0.04509956f, -0.16819598f, 0.08219655f, -0.09960775f, -0.26326704f, 0.01132951f, -0.18146922f, 0.04463313f, 
    0.07220574f, 0.10563936f, 0.12387960f, -0.20102103f, 0.73196208f, -0.65369648f, -0.44022998f, -0.11712604f, 
    -0.02586588f, 0.00278189f, -0.03405635f, -0.05347684f, 0.16324788f, -0.21756598f, -0.11514649f, -0.01685698f, 
    -0.19408850f, 0.00407195f, -0.06542723f, -0.04513576f, -0.01768414f, -0.07412070f, -0.02234831f, 0.02183490f, 
    0.13936011f, 0.02386150f, -0.04389192f, -0.13201198f, -0.40118098f, -0.38400921f, 0.32861796f, 0.21942174f, 
    -0.02483561f, 0.01353823f, -0.11621912f, 0.09452073f, 0.01187840f, 0.05450406f, -0.11827144f, -0.03743063f, 
    -0.55736345f, 0.26955122f, -0.18392144f, 0.30898637f, 0.01048158f, 0.22354186f, 0.13527356f, 0.01922392f, 
    -0.11677711f, 0.00459716f, -0.00293876f, -0.01928963f, 0.24039334f, 0.17935175f, -0.04377646f, -0.17601390f, 
    -0.02499863f, 0.05287393f, 0.06894556f, -0.09352037f, -0.34807029f, -0.06932806f, -0.23366162f, -0.18709511f, 
    0.33900499f, 0.27888221f, -0.02350187f, -0.12710196f, -0.11386678f, 0.02843911f, -0.12343162f, -0.06038864f, 
    -0.28952166f, 0.15208040f, -0.19690427f, 0.04192045f, -0.52974445f, -0.39383262f, -0.29090282f, -0.25225797f, 
    0.23855413f, -0.32393411f, 0.02236843f, 0.04977404f, 0.01546107f, -0.06277753f, 0.00323335f, 0.07137642f, 
    -0.01554344f, 0.06743230f, -0.07093952f, 0.04991879f, -0.00211722f, 0.03205437f, 0.06243610f, -0.04950825f, 
    -0.07973327f, 0.04922697f, -0.06322356f, -0.19397148f, -0.14544755f, 0.30678236f, -0.44691136f, 0.31837937f, 
    -0.24097243f, 0.09565403f, 0.00266403f, -0.04362074f, -0.10087513f, 0.08497327f, -0.12470824f, -0.00254768f, 
    0.35386011f, -0.48449379f, 0.61336726f, -0.29136020f, -0.04290009f, -0.02368395f, -0.19817133f, 0.28982341f, 
    0.04828191f, -0.05010133f, -0.03229395f, -0.02507072f, -0.65247011f, 0.56538874f, -0.01442850f, 0.19344050f, 
    -0.00151259f, 0.03763217f, 0.06081107f, 0.03405385f, -0.03395260f, -0.05243505f, 0.00280695f, -0.03470703f, 
    -0.32554007f, -0.53874892f, -0.12861376f, -0.02178961f, 0.00731105f, -0.04305713f, 0.11933253f, -0.01417401f, 
    0.00146265f, -0.13787225f, 0.02338525f, -0.10999204f, -0.09065762f, -0.12806202f, -0.25143558f, 0.08257839f, 
    0.01155379f, 0.18230665f, 0.21327569f, 0.00406849f, -0.04946129f, -0.09602292f, -0.01935199f, 0.04802872f, 
    -0.99428695f, 0.88135952f, -0.01695761f, 0.35706425f, 0.12439483f, -0.05863754f, 0.26387373f, -0.12131140f, 
    0.07905578f, -0.10048079f, 0.04806975f, 0.01106879f, 0.47044536f, -0.38122416f, -0.10229701f, -0.30052289f, 
    0.01813038f, 0.06517632f, 0.03366127f, 0.00505216f, -0.06004103f, 0.02547476f, -0.07779787f, -0.33214518f, 
    -0.22295360f, -0.00259937f, -0.15492669f, 0.11340743f, 0.06822320f, 0.17509082f, -0.05723819f, 0.06142519f, 
    0.13002707f, -0.04732852f, -0.11018002f, 0.20242660f, -0.21453461f, -0.30445284f, -0.07105844f, -0.11524425f, 
    -0.07575069f, -0.07795604f, 0.08920138f, -0.03021724f, 0.06332616f, 0.14479513f, -0.01525041f, -0.07602715f, 
    0.16920459f, -0.54773211f, -0.40529987f, -0.16661210f, -0.04439921f, -0.34460089f, -0.02782453f, 0.04865173f, 
    0.04020052f, 0.01725896f, 0.16003011f, 0.09265272f, 0.14130215f, 0.21527070f, 0.03988991f, -0.21011943f, 
    0.03900983f, 0.05176040f, 0.02249339f, -0.00224726f, -0.06428431f, -0.00967525f, 0.06631043f, 0.10370608f, 
    -0.13107839f, 0.12936272f, 0.01649287f, -0.05387950f, -0.05977342f, 0.03322724f, 0.10030200f, 0.01608084f, 
    -0.21373615f, 0.06182847f, -0.08769087f, -0.15505864f, -0.27700731f, -0.65791368f, -0.17811114f, 0.18074727f, 
    -0.00270055f, -0.01341452f, 0.03794627f, 0.05381833f, -0.02676509f, 0.13266414f, 0.02776340f, 0.02490179f, 
    0.01854751f, 0.02591642f, -0.01469210f, -0.05384935f, 0.13990268f, -0.01464023f, 0.03418034f, 0.00295266f, 
    0.24101575f, 0.17846230f, 0.21839948f, 0.17138019f, -0.01707759f, -0.36379263f, -0.26857659f, 0.05201142f, 
    -0.34098479f, 0.19997713f, 0.14511940f, 0.15328756f, 0.34423274f, -0.09947345f, 0.07267698f, -0.00372921f, 
    0.22490492f, -0.52678901f, -0.14768299f, 0.02051758f, 0.17659788f, 0.14792581f, 0.07052439f, 0.12503722f, 
    0.22177562f, 0.14520402f, 0.17596011f, 0.31335142f, -0.28316537f, -0.01558637f, -0.03194257f, 0.33095765f, 
    0.01693381f, 0.00282799f, -0.05335144f, 0.10409250f, -0.10392074f, 0.00795639f, -0.13255782f, -0.00527594f, 
    0.07199346f, 0.38512781f, -0.26488349f, -0.75107729f, 0.13423392f, -0.15761843f, 0.04067403f, -0.07895985f, 
    0.14615344f, 0.00898061f, 0.02017625f, 0.19060278f, -0.44685385f, 0.08739228f, 0.09855804f, 0.06288793f, 
    -0.08747356f, -0.03065228f, -0.13622360f, -0.02144860f, -0.24679230f, -0.03653224f, -0.12787765f, 0.04827377f, 
    -0.57701290f, -0.15028533f, 0.25848627f, 0.04807623f, -0.03957773f, 0.09323842f, 0.00974085f, -0.01529806f, 
    -0.09039966f, 0.10762303f, -0.11700177f, 0.03360914f, -0.07769095f, -0.37095746f, -0.11906273f, 0.57852113f, 
    0.01271164f, 0.18805659f, 0.26491594f, 0.20862067f, 0.09415586f, -0.13147828f, 0.20578517f, 0.08168920f, 
    0.15850303f, 0.36990684f, 0.06555049f, 0.17602465f, 0.03387316f, 0.03030108f, -0.22083415f, -0.03731628f, 
    -0.04477083f, -0.07563058f, -0.01252602f, 0.02360421f, 0.05270531f, 0.17920421f, -0.07132296f, 0.18324037f, 
    0.22348280f, -0.13418531f, 0.00881050f, -0.14298296f, 0.07527357f, 0.00324685f, 0.09263836f, 0.12869993f, 
    -0.19231418f, -0.23490837f, -0.28320903f, 0.12683100f, -0.00369144f, -0.05044177f, 0.17651682f, 0.06118036f, 
    -0.04658986f, -0.19133846f, -0.07007818f, 0.01481445f, -0.19576806f, -0.18836349f, -0.14439906f, -0.01364643f, 
    -0.10512841f, 0.11738744f, -0.01421785f, -0.02242887f, -0.18019150f, 0.12636867f, -0.22362675f, -0.40773728f, 
    -0.48933825f, 0.27277187f, -0.10202073f, 0.01214781f, 0.02368820f, -0.00220633f, -0.07830261f, 0.07357265f, 
    -0.04186403f, 0.08748598f, 0.06173284f, 0.23420097f, -0.00449104f, 0.00321804f, -0.13307665f, -0.16919093f, 
    -0.11100914f, -0.11950254f, 0.07642896f, -0.00002719f, 0.11702406f, -0.07901726f, 0.10166927f, 0.01106238f, 
    -1.00697374f, -0.03906367f, 0.37177670f, 0.45149472f, -0.16626658f, -0.07172775f, -0.31331199f, -0.00287234f, 
    -0.03465122f, -0.12793007f, 0.02958918f, -0.00559743f, 0.06635337f, -0.10961907f, -0.22760920f, -0.30407670f, 
    -0.15151341f, 0.01942721f, 0.04506204f, -0.13243850f, 0.09300277f, 0.04851000f, 0.07095008f, 0.08762662f, 
    0.20732433f, 0.14018968f, -0.29499906f, -0.23132217f, -0.05442612f, 0.14068730f, 0.10056423f, -0.01836982f, 
    0.13875748f, -0.15875860f, -0.16155246f, -0.02854859f, -0.34939578f, -0.75860381f, -0.53984177f, -0.10824438f, 
    -0.08312180f, 0.19448662f, 0.03471566f, 0.08074580f, -0.04599742f, 0.01456061f, -0.04723271f, 0.06703474f, 
    0.07052348f, -0.06721145f, 0.19015840f, -0.10835135f, -0.15869384f, -0.02927038f, -0.00712128f, -0.07269353f, 
    0.08001705f, 0.07814683f, 0.14613618f, 0.02329729f, 0.59294134f, 0.25426811f, 0.07470616f, 0.11267311f, 
    0.02142527f, 0.05979154f, -0.15521693f, 0.18855882f, 0.03463491f, 0.11214280f, 0.18374151f, 0.08263569f, 
    0.26009038f, -0.10437052f, -0.53967720f, -0.56043851f, -0.13413031f, -0.08274981f, 0.20112343f, -0.14462034f, 
    -0.04677944f, -0.07771987f, -0.09876409f, -0.19013958f, -0.03668132f, 0.04565005f, -0.26209766f, -0.14550197f, 
    -0.01523237f, 0.04782766f, -0.22191553f, -0.30566049f, -0.02439975f, 0.04415717f, 0.15758608f, 0.07729234f, 
    0.35806629f, -0.47152376f, -0.45298877f, -0.02036438f, 0.22302914f, 0.15864480f, -0.09638054f, 0.02280731f, 
    -0.04725809f, -0.05288681f, -0.08008748f, -0.05189689f, 0.03068101f, -0.09589678f, -0.05862118f, -0.10289825f, 
    0.02590479f, 0.01418210f, 0.09677383f, 0.18688574f, -0.42219502f, 0.01693760f, -0.24586213f, -0.22157140f, 
    -0.52210617f, -0.07367603f, 0.22774854f, 0.41091684f, -0.06559598f, -0.21120089f, -0.33590150f, -0.22045384f, 
    -0.03793029f, 0.01248666f, 0.12994961f, 0.06321492f, 0.14736485f, 0.05724093f, -0.23575678f, -0.09103618f, 
    0.04732261f, -0.01437739f, -0.01424953f, 0.00232431f, 0.20062198f, 0.16471709f, 0.26212794f, 0.13963567f, 
    -0.22825882f, 0.05265497f, 0.05542309f, 0.13072452f, -0.12728755f, -0.04892756f, -0.10419798f, -0.05719137f, 
    -0.35049406f, -0.01167517f, 0.11484293f, -0.51931858f, -0.02294633f, -0.29354295f, -0.15234122f, 0.00393920f, 
    -0.02969058f, 0.17337856f, 0.18599470f, -0.01394092f, 0.18832301f, -0.08384320f, -0.02112478f, 0.08567075f, 
    -0.06861760f, -0.32728085f, -0.23194504f, -0.12363154f, 0.13740335f, 0.14949441f, 0.06672376f, -0.02220564f, 
    -0.02923473f, -0.23898730f, -0.13032511f, -0.68291849f, -0.60710132f, 0.06538448f, 0.19002658f, 0.10274825f, 
    -0.04115817f, -0.17120670f, -0.10749678f, -0.14881682f, 0.01111427f, -0.20457388f, -0.04465020f, -0.14586028f, 
    -0.47683075f, -0.15839642f, 0.33079189f, 0.05447219f, 0.03478055f, -0.01512406f, 0.03749412f, 0.07028072f, 
    0.10818923f, 0.09040143f, -0.02024375f, 0.14064780f, -0.12377500f, -0.71685666f, -0.53083444f, -0.09702878f, 
    -0.03168367f, 0.04579097f, 0.06229558f, 0.01131980f, -0.27671960f, -0.09820742f, 0.02010709f, -0.00456731f, 
    -0.01965536f, -0.14167300f, -0.25344375f, -0.05331390f, 0.11623558f, -0.10586658f, -0.01993983f, 0.23368844f, 
    -0.15611553f, -0.10121589f, -0.14873654f, -0.19489388f, -0.00835922f, 0.00542434f, -0.03196370f, 0.05875514f, 
    0.12034854f, 0.15112710f, -0.50275916f, 0.07257169f, 0.10037628f, -0.34199208f, -0.09543120f, 0.12458650f, 
    0.04415184f, -0.10765173f, 0.04243027f, -0.22539608f, -0.03838733f, -0.07806019f, 0.05377312f, 0.14091772f, 
    -0.11665341f, 0.04381871f, -0.12588456f, -0.05625952f, -0.04951748f, 0.51024806f, -0.65351462f, -0.18848696f, 
    0.06379734f, -0.07216789f, 0.29982710f, 0.02216586f, 0.09342437f, -0.04080408f, -0.18395935f, 0.04572560f, 
    -0.60958391f, 0.16844499f, -0.07343342f, 0.27692577f, 0.00438654f, 0.09644556f, -0.33576912f, -0.05213929f, 
    0.04722248f, -0.02692582f, 0.01269739f, 0.10520758f, -0.02639786f, -0.10322770f, -0.11885031f, -0.25302631f, 
    0.14188625f, 0.23309781f, 0.27861664f, 0.06746283f, 0.21327144f, 0.14157084f, -0.04571491f, 0.15822758f, 
    0.26794377f, 0.10228648f, 0.66797745f, -0.80747348f, 0.12411661f, -0.44431239f, 0.05715919f, -0.13661225f, 
    -0.15754190f, 0.04322222f, -0.01772217f, 0.07046724f, -0.28544131f, -0.01512156f, 0.37252358f, -0.71446210f, 
    -0.23137076f, -0.54117161f, 0.20411736f, -0.08108450f, 0.02563410f, -0.05318841f, 0.16739742f, 0.04599658f, 
    -0.27675021f, -0.31871897f, -0.29063550f, -0.50040489f, -0.13610417f, -0.05990643f, -0.41389909f, 0.13969307f, 
    0.10823198f, -0.12655674f, 0.00109345f, 0.07773890f, -0.09041564f, 0.41343901f, -0.91577184f, 0.18405688f, 
    0.21218550f, -0.06216016f, 0.16546531f, -0.14882445f, 0.00345757f, -0.11904027f, -0.02518306f, -0.04128599f, 
    0.48065245f, -0.05086966f, 0.04298316f, -0.28787893f, -0.06652675f, -0.12016068f, -0.24067050f, -0.03903640f, 
    0.16488703f, -0.07700318f, 0.01659435f, 0.06594703f, -0.05234498f, 0.27992135f, 0.20548597f, -0.05233219f, 
    -0.22502476f, -0.01808682f, -0.18302542f, -0.20322514f, 0.10241088f, -0.00451064f, 0.04960420f, 0.05726360f, 
    -0.22175260f, 0.01810770f, -0.60925388f, 0.28497848f, 0.03875834f, 0.14797145f, 0.10962490f, 0.00830120f, 
    0.11399217f, 0.01119124f, -0.04279752f, -0.16292708f, -0.24576944f, -0.26869190f, 0.15630309f, -0.26633143f, 
    0.04563326f, -0.20125702f, 0.23755583f, 0.34209949f, -0.00680194f, 0.02446633f, 0.02753766f, -0.03723009f, 
    -0.56510955f, 0.13775349f, -0.10505074f, -0.23732075f, 0.09767160f, -0.04609039f, 0.21452639f, 0.01910929f, 
    -0.10326832f, 0.03482698f, 0.12519796f, -0.20199315f, -0.18302155f, -0.19597009f, 0.24685156f, 0.31831509f, 
    0.18095171f, 0.04264513f, -0.03434940f, -0.00067016f, 0.25213531f, 0.15801823f, 0.00750587f, 0.04296881f, 
    -0.27068663f, -0.07938058f, -0.60980481f, 0.16365461f, 0.01752098f, -0.12628864f, 0.04176487f, -0.13053624f, 
    0.10171699f, -0.06964403f, 0.02448144f, 0.01567989f, -0.14161980f, -0.35780621f, 0.10911401f, -0.17771271f, 
    0.00292070f, -0.09583633f, -0.17836334f, 0.09443535f, 0.06816176f, -0.02271254f, -0.03964638f, -0.08564387f, 
    0.04470923f, -0.12225436f, 0.06353226f, -0.24823090f, 0.15627564f, -0.05912508f, -0.02607069f, 0.27510506f, 
    -0.11673565f, 0.01588168f, -0.01165588f, 0.01231843f, -0.76442850f, 0.27351093f, -0.89539927f, 0.22564869f, 
    0.01831775f, -0.23192067f, 0.06469528f, -0.21822281f, 0.13997369f, -0.09518258f, -0.05263314f, -0.00645449f, 
    -0.16545254f, -0.14168137f, -0.13183521f, -0.11513337f, -0.14613965f, 0.26963982f, -0.02185616f, 0.05165173f, 
    0.19815244f, 0.17562221f, 0.03066725f, 0.04990529f, 0.09319569f, -0.09704084f, -0.51958740f, 0.09979705f, 
    -0.10621425f, 0.08262113f, 0.12475134f, 0.16788556f, 0.11880801f, 0.06015743f, 0.03735501f, -0.06644972f, 
    -0.12687866f, -0.04507339f, 0.21408798f, -0.03327028f, -0.04313919f, -0.26647416f, 0.04206209f, 0.25681838f, 
    0.06156938f, 0.08358003f, 0.08062920f, 0.03168960f, -0.02419012f, 0.37997621f, -0.25755426f, -0.16819477f, 
    0.03893400f, -0.02829476f, 0.14649461f, 0.03156397f, 0.21167885f, 0.00535122f, 0.14045069f, -0.00907752f, 
    0.15496103f, 0.36709079f, -0.57220924f, -0.01114081f, -0.12877285f, -0.17083411f, 0.11997152f, -0.03814222f, 
    -0.02359940f, 0.01201165f, -0.12875634f, -0.04092068f, 0.24776693f, 0.09066723f, 0.39170620f, 0.25527099f, 
    0.08316029f, -0.04282174f, -0.08394473f, -0.09721565f, -0.02076634f, 0.03586190f, -0.01252566f, -0.13522036f, 
    0.13841198f, 0.40913588f, -0.08038296f, -0.19259396f, -0.02771658f, -0.15142836f, -0.02833836f, -0.04368506f, 
    -0.05294836f, 0.11661067f, 0.01210850f, 0.06415856f, 0.27955601f, 0.03212283f, 0.38861772f, -0.10110168f, 
    0.17218961f, -0.22511269f, -0.04422873f, -0.14505495f, 0.09909943f, 0.04416164f, 0.01447579f, 0.06174519f, 
    0.12321537f, -0.14267597f, -0.01185508f, 0.32460070f, 0.06485014f, 0.05697926f, -0.05344987f, -0.02302822f, 
    -0.12736848f, -0.04542344f, 0.18168917f, 0.24631985f, -0.16603236f, -0.15356468f, -0.19833787f, 0.07833052f, 
    0.12615453f, -0.04295919f, 0.28240547f, 0.09043545f, -0.02005745f, 0.00071085f, -0.03616838f, 0.00128317f, 
    0.17725293f, -0.14628741f, 0.05752290f, -0.32789025f, -0.04441453f, -0.05946296f, -0.16672401f, 0.08305168f, 
    -0.12537754f, -0.04517171f, 0.00160684f, 0.05373055f, 0.02195126f, 0.30000252f, 0.42977107f, -0.14198740f, 
    -0.10957584f, -0.20369357f, -0.09453769f, 0.08864561f, -0.07939982f, 0.07270861f, 0.12857744f, -0.00553296f, 
    0.03824931f, 0.44292870f, -0.25748086f, 0.09992282f, -0.29549307f, 0.10330446f, 0.13766296f, 0.29568699f, 
    -0.03128667f, 0.33142662f, 0.16266751f, 0.27504736f, 0.19140838f, 0.34096035f, 0.43669632f, -0.23899101f, 
    0.06229656f, -0.05913408f, -0.17722689f, 0.02182628f, -0.01733215f, 0.29118648f, 0.13299491f, -0.08546932f, 
    -0.28535125f, -0.05500460f, -0.08210865f, 0.18327071f, -0.22699943f, 0.24758245f, -0.06452794f, 0.24453793f, 
    0.05589406f, -0.03893534f, 0.19189608f, 0.35840005f, 0.08609417f, -0.14066201f, -0.01345109f, 0.23423384f, 
    -0.07590417f, -0.32940182f, 0.11645558f, 0.11798804f, -0.26510611f, 0.09855909f, 0.04367432f, -0.01789799f, 
    -0.47605523f, 0.60165966f, -0.39513582f, 0.13347542f, -0.19114453f, 0.21006539f, 0.16183208f, -0.18859154f, 
    -0.26439875f, -0.20941727f, -0.04226692f, -0.07926932f, 0.20556490f, -0.34414420f, -0.17187576f, -0.09633589f, 
    -0.24072245f, -0.34701625f, 0.06934410f, -0.02608263f, -0.18090957f, -0.00391692f, -0.06119116f, -0.11462990f, 
    0.02926694f, -0.03086322f, 0.06999706f, 0.18766515f, 0.01669751f, -0.35359827f, 0.13433054f, -0.10049842f, 
    0.13521469f, 0.04440782f, -0.16359286f, -0.01671379f, 0.01049050f, -0.40462208f, 0.24041775f, -0.22685798f, 
    -0.17625357f, 0.05698060f, 0.00676394f, 0.07690585f, 0.14289942f, 0.08688136f, 0.00807002f, -0.11217122f, 
    -0.09748187f, 0.18057437f, 0.65445292f, 0.09584881f, 0.11583056f, -0.00192244f, -0.06710764f, -0.04209164f, 
    -0.10966922f, -0.11691564f, -0.08275355f, -0.09614359f, -0.41597927f, -0.05906872f, 0.07779790f, 0.02214516f, 
    -0.11150853f, -0.18829046f, 0.00010237f, 0.07325658f, -0.14239836f, 0.15850346f, 0.04930440f, 0.30629697f, 
    -1.02896309f, 0.23973602f, 0.21829672f, 0.37570953f, 0.05686240f, 0.37268335f, -0.32400674f, 0.15879846f, 
    -0.19605653f, 0.31463608f, 0.00210790f, -0.13870321f, 0.52276444f, 0.01012026f, 0.27946734f, -0.39615962f, 
    -0.02796360f, -0.20954970f, 0.10378745f, -0.03168876f, -0.32060453f, 0.01312689f, -0.09590018f, -0.15150595f, 
    -0.10196247f, -0.25172120f, -0.10800144f, 0.02185407f, -0.19727075f, -0.31710187f, 0.19528110f, -0.05027301f, 
    -0.34888887f, 0.04084015f, 0.20893745f, 0.07085227f, -0.38349998f, -0.02918361f, -0.03840231f, -0.08502217f, 
    -0.02428126f, -0.11741418f, -0.06517128f, -0.09014490f, -0.03327299f, 0.14800210f, 0.13703060f, -0.00965224f, 
    0.18863833f, -0.45963755f, 0.02897664f, -0.13592637f, -0.06264319f, 0.05882718f, -0.26724097f, 0.03289290f, 
    -0.03304718f, -0.12218173f, -0.00551061f, 0.10344774f, -0.51970112f, 0.06920048f, -0.24112056f, -0.58859849f, 
    -0.13414547f, 0.09181171f, -0.35517302f, -0.02073733f, 0.18900494f, -0.01188028f, -0.23756152f, -0.00925343f, 
    0.01501580f, 0.50803244f, 0.04116299f, -0.06710090f, -0.08227608f, 0.18760645f, -0.02711217f, -0.05089688f, 
    -0.14582251f, 0.11248393f, 0.28384569f, -0.37632421f, -0.03051633f, -0.49562299f, 0.18838425f, 0.04803874f, 
    -0.31829882f, -0.05323703f, -0.01885742f, 0.28048205f, 0.10286237f, 0.14167088f, -0.06270818f, 0.05105880f, 
    -0.23344980f, 0.16984394f, 0.47263372f, 0.23882347f, 0.04989247f, -0.00648639f, -0.29255012f, -0.00112599f, 
    0.00193345f, -0.09620377f, 0.15478466f, 0.12499468f, 0.20863329f, -0.11543956f, 0.35163590f, -0.19439074f, 
    -0.24569207f, 0.31068569f, 0.18139516f, 0.24062526f, 0.03123548f, 0.04679766f, -0.16435537f, 0.21495554f, 
    -0.06631853f, -0.38679120f, -0.59816504f, 0.08733685f, -0.03043651f, 0.02611504f, 0.01940792f, -0.11539923f, 
    0.02182497f, -0.09426169f, 0.00538602f, -0.20610225f, -0.00203569f, -0.44133687f, -0.12382142f, 0.09629507f, 
    -0.03505078f, 0.16405244f, 0.18409365f, -0.00347031f, 0.05664508f, 0.02090667f, 0.08942725f, -0.06632418f, 
    -0.38001427f, -0.01167905f, -0.06518458f, 0.07669965f, 0.03268416f, 0.11007683f, -0.07728709f, 0.13980174f, 
    -0.08156887f, 0.05205704f, -0.20869732f, -0.11860728f, 0.05414160f, -0.27150899f, 0.02343085f, -0.07327745f, 
    -0.10274129f, -0.10725947f, 0.28206971f, -0.12492350f, -0.19328810f, 0.00971396f, -0.34777215f, -0.10008429f, 
    0.06703578f, -0.50161195f, 0.22714096f, -0.10757532f, 0.08803600f, -0.02088742f, 0.25924325f, -0.00971818f, 
    0.13680622f, -0.01959154f, 0.07928038f, 0.17690380f, -0.19350252f, 0.30367440f, 0.11027795f, -0.29445499f, 
    -0.20036182f, -0.15717147f, 0.11105489f, -0.07489459f, 0.12852769f, -0.16726303f, 0.21547064f, -0.00092692f, 
    0.06357561f, -0.05994423f, 0.11420770f, -0.15205091f, 0.02969063f, -0.04888213f, -0.19731696f, -0.14646600f, 
    -0.00508792f, -0.09565931f, -0.44067615f, -0.45369115f, -0.33452204f, 0.25392869f, 0.00162791f, 0.01093357f, 
    0.03030193f, 0.09978127f, -0.30627903f, 0.10482139f, 0.14062749f, -0.00972707f, -0.02282335f, -0.01564191f, 
    -0.37762493f, 0.25073165f, -0.31462029f, -0.03140225f, -0.05461558f, 0.13202268f, -0.04900132f, 0.06686960f, 
    -0.00663505f, -0.13754462f, -0.46133372f, -0.66308427f, 0.21146804f, -0.19159944f, -0.32555723f, 0.31057069f, 
    -0.11424343f, -0.03688027f, -0.01975281f, -0.51207948f, -0.01527847f, -0.01700296f, -0.14043814f, -0.08103613f, 
    -0.01474622f, 0.16043757f, -0.11365264f, 0.32045156f, 0.22124597f, 0.06545329f, -0.24338345f, 0.01185324f, 
    0.09392783f, 0.02836079f, 0.07281066f, -0.24597083f, -0.32438496f, -0.06913586f, 0.03365779f, 0.06040114f, 
    -0.03790369f, 0.08379126f, 0.01417878f, -0.01406174f, 0.04668228f, -0.09056386f, 0.14015518f, -0.00078558f, 
    0.12085153f, -0.28068024f, 0.25668192f, 0.41914302f, 0.12696293f, 0.09475102f, 0.04273392f, 0.33904123f, 
    -0.08750662f, -0.26756907f, -0.17471308f, -0.11527905f, -0.71082550f, 0.20704365f, -0.61839640f, 0.43901205f, 
    0.36125514f, -0.12051328f, 0.02129041f, -0.07489387f, -0.17414525f, 0.12868704f, -0.33371353f, 0.03359611f, 
    -0.49020505f, 0.19274476f, -0.10958080f, -0.29971167f, -0.02755088f, -0.25929350f, -0.19790864f, 0.16837364f, 
    -0.24352692f, -0.01947914f, -0.15554026f, -0.25458992f, 0.11823200f, 0.06761525f, 0.75607675f, -0.21009116f, 
    -0.07338981f, 0.04844248f, -0.11498002f, -0.04393705f, -0.14064996f, 0.04078592f, 0.15412581f, -0.07109124f, 
    -0.42234528f, -0.70505685f, 0.54843807f, 0.80184639f, 0.53552550f, -0.05650960f, 0.00901484f, 0.07787817f, 
    0.00179461f, -0.05243855f, 0.25291908f, -0.01092338f, 0.30902907f, 0.14976850f, 0.36922008f, -0.14853613f, 
    -0.17920491f, 0.06206704f, -0.01255774f, 0.04256711f, -0.13481902f, 0.00896118f, 0.05187116f, -0.05683418f, 
    -0.42387086f, -0.19511162f, 0.15111279f, 0.10609776f, -0.00013654f, 0.22544460f, -0.08412787f, 0.13724419f, 
    -0.31982324f, -0.07273983f, 0.13400371f, -0.02250745f, -0.06498990f, -0.42104152f, 0.23629825f, -0.95385343f, 
    0.24646847f, -0.16638415f, 0.04539374f, 0.01556768f, 0.01275546f, 0.14141543f, 0.08638973f, -0.02826343f, 
    -0.12718682f, -0.06504531f, 0.08942953f, 0.25195292f, -0.22676142f, 0.19210964f, 0.38754717f, -0.08680128f, 
    0.04995529f, 0.11511594f, -0.07582552f, 0.05815595f, 0.67103595f, -0.02679201f, 0.69000560f, -0.11984405f, 
    0.23727405f, 0.01955568f, 0.10386011f, 0.10901479f, -0.19442649f, -0.03741199f, 0.02440003f, -0.10040779f, 
    -0.12950464f, 0.26752758f, -0.06447219f, -0.00388931f, -0.03329587f, -0.30620989f, 0.19390309f, 0.08311845f, 
    0.07312080f, -0.06044711f, -0.16849504f, -0.15056604f, -0.43113536f, 0.15601100f, -0.17651297f, -0.47622463f, 
    -0.10573849f, -0.06899405f, -0.03057296f, -0.06298554f, 0.01764957f, 0.11346021f, 0.09528863f, 0.00656109f, 
    0.40989769f, 0.18327565f, 0.20361955f, -0.01062556f, -0.16384800f, 0.24969061f, -0.11241367f, 0.06501764f, 
    -0.19307350f, -0.08853618f, 0.14600290f, -0.09689360f, 0.13930820f, -0.35507435f, 0.05048859f, 0.03338668f, 
    -0.23157033f, -0.13878068f, -0.09962024f, -0.25585648f, -0.01362170f, 0.01125012f, -0.17581765f, -0.04976253f, 
    -0.02215135f, -0.40298444f, 0.36729246f, -0.03518155f, 0.06400549f, 0.03870462f, -0.07705697f, 0.09267509f, 
    -0.19895557f, 0.02573032f, 0.01248119f, 0.05580235f, -0.23884220f, -0.03688534f, -0.28955653f, -0.18740807f, 
    0.10640617f, 0.11099017f, 0.02191449f, 0.12525323f, 0.19671181f, 0.22948596f, -0.00165455f, -0.00032423f, 
    -0.40993670f, -0.45562780f, 0.10800078f, -0.15920961f, 0.22610608f, -0.13779664f, 0.19324780f, 0.08939167f, 
    0.15509520f, 0.10382566f, 0.30282322f, 0.20529824f, 0.23941131f, -0.10842890f, -0.22334798f, 0.11057464f, 
    -0.20111947f, 0.07601284f, -0.26794276f, 0.08003308f, -0.03305949f, 0.02630384f, -0.14016953f, -0.18106274f, 
    -0.19678402f, 0.11226831f, -0.24169184f, 0.38863686f, -0.09494992f, 0.19042893f, -0.28573507f, 0.05676450f, 
    -0.07648157f, -0.08464439f, 0.02446894f, 0.21646762f, 0.40242404f, -0.13638128f, 0.52415884f, -0.28210476f, 
    0.17416842f, 0.09536878f, -0.03784761f, 0.08006229f, -0.10876369f, 0.11453765f, 0.18796626f, 0.05917523f, 
    -0.49997398f, 0.00920416f, -0.30029324f, 0.38950691f, -0.06823935f, 0.11245514f, 0.02337498f, -0.17052808f, 
    -0.04461452f, 0.06375733f, 0.09430705f, 0.05892858f, -0.16548546f, -0.38733754f, 0.41222274f, -0.23970106f, 
    -0.20145032f, -0.11831014f, -0.11303774f, -0.01405694f, 0.04501067f, 0.10550696f, -0.02383508f, 0.04927783f, 
    0.30327389f, -0.73224795f, -0.04815765f, 0.05064951f, -0.04045691f, -0.14780965f, -0.27061692f, 0.09743045f, 
    0.05163510f, 0.15302916f, 0.13513756f, 0.10627219f, 0.21489909f, -0.01436495f, 0.33181322f, -0.33268428f, 
    0.20293094f, 0.21650781f, -0.32552251f, 0.10349851f, -0.00093894f, 0.18187736f, 0.22179253f, 0.28895843f, 
    0.36245283f, -0.31015971f, 0.31372249f, 0.01115493f, -0.11995606f, 0.00892836f, -0.46765214f, -0.04929645f, 
    0.04335553f, 0.07075407f, 0.00296040f, -0.00238700f, -0.20904523f, -0.06777664f, -0.36394799f, 0.09187765f, 
    0.21617131f, -0.03103087f, 0.07413424f, -0.20246281f, -0.19086498f, 0.00850163f, -0.17836179f, -0.13898724f, 
    -0.25972819f, 0.16003957f, 0.41605523f, -0.28884247f, -0.02247950f, 0.01022115f, -0.01651801f, 0.04697468f, 
    0.07472114f, -0.01105612f, 0.11502837f, 0.05558294f, -0.40599218f, -0.00474167f, 0.08444753f, -0.06517597f, 
    -0.05098905f, -0.10875615f, 0.08634165f, 0.21502560f, -0.25715309f, 0.01692951f, 0.10795712f, -0.17533810f, 
    -0.23598385f, -0.22751781f, -0.29415753f, -0.18699475f, -0.07205234f, -0.05218492f, 0.00615568f, 0.05400349f, 
    0.03553678f, 0.07786199f, 0.10678042f, 0.27172118f, 0.24010749f, 0.06090080f, 0.27744201f, 0.07631205f, 
    -0.17954545f, -0.08006453f, -0.10164750f, 0.08039422f, -0.17376570f, 0.00263038f, -0.04393797f, 0.08319888f, 
    -0.43275800f, 0.07446784f, -0.05521728f, 0.12821463f, -0.05878289f, 0.02100047f, -0.00923137f, 0.16261391f, 
    -0.35812631f, -0.16655293f, -0.22793353f, 0.11233968f, -0.37996730f, -0.21157201f, -0.20022465f, 0.11738141f, 
    0.01471858f, -0.42722371f, -0.03563360f, -0.22937636f, 0.05789769f, 0.04637150f, -0.04240723f, -0.16615850f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.23942177f, 0.12486959f, 0.11366208f, -0.19451870f, -0.19046721f, 0.10273036f, -0.00812371f, -0.11915006f, 
    0.07823712f, 0.00676888f, 0.02926057f, 0.02553045f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
