#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.10298976f, -0.58406752f, -0.81103402f, -0.33495569f, 0.01873167f, -0.25439298f, 0.46232009f, -0.03802966f, 
    0.19221361f, 0.24932466f, -0.31656799f, -0.06217108f, -0.04349631f, 0.00207438f, -0.30674684f, -0.30876201f, 
    0.34622929f, -0.00985880f, -0.30035320f, -0.23785514f, 0.10463697f, -0.06350141f, 0.27688372f, 0.00769876f, 
    -0.02539918f, -0.73169428f, 0.50224924f, -0.02997080f, -0.42150971f, 0.67385596f, 0.16942757f, 0.70073533f, 
    0.60993230f, -0.11032940f, 0.11984671f, 0.35469249f, 0.23794390f, 0.34659192f, -0.14475773f, 0.15921468f, 
    -0.23759012f, 0.30294240f, 0.11623322f, 0.22191462f, 0.31967622f, 0.30125597f, -0.16537629f, 0.06469131f, 
    -0.11337239f, -0.29872018f, -0.44040054f, 0.30778870f, 0.68269068f, 0.29700506f, 0.07135684f, -0.80956405f, 
    -0.15767349f, -0.61700320f, -0.89745378f, 0.03607901f, 0.27123404f, 0.35453898f, 0.19392644f, 0.01460428f, 
    -0.13734107f, 0.04727383f, -0.26186594f, 0.29682338f, 0.06917832f, 0.23465234f, 0.00106169f, 0.15450780f, 
    -0.01036080f, 0.08155339f, 0.00537772f, 0.13169248f, -0.24591455f, -0.59399539f, -0.16149367f, -0.33522663f, 
    0.27694812f, 0.47844896f, 0.56982249f, 0.72474599f, 0.24329849f, -0.16836694f, -0.10351459f, -0.60983443f, 
    -0.25066707f, 0.05681214f, 0.15802793f, -0.38783509f, -0.22733253f, -0.18795471f, -0.05699492f, -0.13770612f, 
    -0.35299876f, 0.33491224f, -0.26235858f, -0.18038663f, 1.19310224f, 0.42358971f, -0.24696419f, 0.25432479f, 
    0.07206050f, -0.68332970f, 0.23786856f, -0.18417762f, 0.05753864f, 0.15059514f, -0.13579559f, -0.01440868f, 
    0.38048738f, 0.16615124f, -0.10935997f, -0.03298898f, -0.10183347f, 0.23060745f, 0.15233621f, 0.07157451f, 
    -0.02926463f, 0.21758679f, -0.02110469f, 0.20469427f, -0.01318475f, 0.76555866f, 0.12634486f, 0.10554957f, 
    0.99102157f, 0.58808273f, 0.27779889f, 0.18996753f, -0.37762564f, 0.48811477f, 0.17995492f, -0.22286862f, 
    -0.05979622f, -0.25962839f, 0.04813171f, -0.14661662f, 0.09740545f, -0.06774703f, -0.29509154f, 0.22212909f, 
    0.35439596f, 0.04351825f, -0.09195983f, 0.20202370f, -0.11858131f, 0.24397963f, -0.62359983f, -0.58167470f, 
    -0.61333680f, -0.29310900f, -0.54609108f, 0.17600632f, 0.11970996f, -0.27716237f, -0.03012371f, 0.46226975f, 
    0.23163559f, 0.21224333f, -0.11530610f, -0.04065092f, 0.00353354f, 0.29430750f, -0.11891190f, 0.44453526f, 
    0.36894166f, -0.21206263f, -0.21356750f, -0.21205373f, 0.09155981f, 0.26580310f, 0.32163107f, 0.35337526f, 
    0.55025148f, 0.69413269f, 0.43965191f, 0.64843637f, 0.09537853f, 0.03226295f, -0.45000383f, -0.43341845f, 
    -0.23200722f, 0.40743726f, 0.09646801f, 0.07677661f, 0.16031668f, -0.17371975f, 0.26123679f, -0.03400805f, 
    0.17505975f, -0.15643367f, 0.08225770f, -0.23595716f, 0.25514174f, 0.22895412f, 0.01441368f, -0.09340162f, 
    1.04388380f, 0.66869414f, 0.04366781f, -0.26067847f, -0.32260051f, 0.15315431f, 0.00627538f, 0.28203669f, 
    0.20779480f, 0.42991620f, 0.34554881f, 0.41178843f, -0.21516146f, -0.05169071f, 0.19300662f, 0.05023345f, 
    0.32289818f, -0.35089707f, -0.16169105f, 0.07960863f, -0.13303392f, 0.19290301f, 0.25117573f, 0.00259520f, 
    0.22376037f, -0.36376303f, -0.76647377f, 0.12702498f, 0.43814027f, 0.24142209f, 0.58356339f, 0.67320865f, 
    -0.38303417f, 0.41687858f, 0.26692882f, 0.19967963f, 0.05474911f, 0.25019222f, -0.01785221f, -0.54567730f, 
    -0.10498445f, 0.05993753f, 0.15977985f, 0.13794139f, -0.31460765f, -0.04758467f, -0.10714428f, -0.12539959f, 
    0.01274332f, -0.14799401f, -0.18056633f, 0.51455462f, -0.41203940f, -0.75189173f, -0.35374656f, 0.65366471f, 
    0.43032911f, -0.29103187f, 0.23164256f, 0.34732369f, 0.10398036f, -0.40524229f, -0.28500232f, -0.01499019f, 
    -0.17389275f, 0.06606837f, 0.05648289f, -0.06299815f, 0.24467073f, -0.01751832f, -0.25954321f, -0.20055397f, 
    -0.19322228f, -0.12125271f, 0.14309987f, -0.02831268f, -0.00178852f, -0.75397509f, -0.10650030f, 0.11374026f, 
    -0.59131014f, -0.89658427f, -0.26424113f, -0.28331676f, -0.28440276f, -0.22100480f, 0.21013401f, 0.36200094f, 
    0.15632637f, 0.04569276f, 0.24195535f, -0.10044689f, -0.02421462f, -0.01817882f, -0.14605314f, 0.18397455f, 
    0.19969232f, 0.10256468f, 0.04636405f, 0.16682887f, 0.65210319f, 0.34722161f, -0.81719059f, -0.26868951f, 
    -0.62349427f, 0.14386411f, -0.51830858f, -0.18556726f, -0.15684573f, -0.16921142f, -0.47852501f, -0.14760461f, 
    -0.13699424f, -0.02671770f, -0.08753560f, -0.39970866f, -0.06533441f, -0.09362820f, -0.13623551f, -0.41140538f, 
    0.23788512f, 0.09284842f, -0.08584328f, -0.14440256f, -0.01624648f, -0.05089393f, -0.85487843f, -0.54726648f, 
    -0.21766618f, -0.05209775f, -0.22583324f, 1.01187098f, -0.19535908f, -0.21813965f, 0.28380984f, 0.02857909f, 
    -0.14772618f, -0.26513073f, 0.12041435f, 0.07994400f, 0.08706357f, 0.08356967f, -0.06662917f, 0.13617061f, 
    0.13042612f, 0.17974432f, 0.11613913f, -0.10468376f, 0.05218822f, 0.22485918f, 0.42384464f, 0.15667818f, 
    0.57629174f, 0.79401928f, -0.07682451f, -0.20450038f, -0.55426204f, 0.42097688f, 0.19425169f, -0.41886005f, 
    -0.42730379f, 0.21056393f, 0.31260708f, 0.30202791f, -0.13432653f, -0.07500870f, -0.11876247f, 0.17404157f, 
    0.16928300f, -0.01222093f, -0.22622025f, -0.35104668f, -0.06816512f, -0.34649599f, -0.40176228f, 0.45311615f, 
    0.34461120f, 0.31741396f, 0.97151953f, 0.31644222f, -0.06707005f, 0.35415834f, 0.10068172f, -0.08877172f, 
    0.08238294f, 0.18578593f, -0.11776219f, -0.24551947f, -0.10174108f, -0.33543646f, -0.08766285f, -0.17388627f, 
    0.08161472f, -0.32000288f, -0.51587754f, -0.06478012f, 0.18974249f, -0.28403622f, 0.17189369f, -0.00507786f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17579496f, 0.01373540f, 0.27273622f, -0.07455478f, 0.01784149f, 0.21866404f, -0.08691517f, -0.14076321f, 
    0.16460533f, 0.15230016f, 0.06539831f, 0.36490664f, 0.26944965f, 0.15946798f, -0.06151711f, 0.17902406f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05253179f, 0.00561684f, -0.00030081f, 0.32083336f, -0.02333543f, -0.06798602f, 0.04597121f, 0.15411514f, 
    -0.00290633f, 0.11677905f, 0.17153226f, 0.00128601f, -0.05590214f, -0.25504825f, -0.23554346f, -0.04132330f, 
    -0.05974153f, 0.19326258f, 0.18797024f, 0.12094577f, -0.08203349f, -0.14312732f, -0.02782930f, -0.03533570f, 
    0.20493671f, 0.12682509f, 0.38266018f, 0.03854962f, 0.01833035f, 0.04369792f, -0.05882324f, 0.15888369f, 
    -0.01685367f, 0.02241338f, -0.16375019f, -0.02321896f, -0.06490573f, 0.06485660f, -0.06232049f, -0.01697961f, 
    0.02624311f, 0.22220302f, 0.00954840f, 0.28802225f, 0.01766462f, -0.04910900f, 0.32055777f, 0.05708316f, 
    -0.38909939f, 0.19551623f, 0.18695498f, 0.00591790f, -0.07739472f, 0.08181307f, 0.08317853f, -0.01230506f, 
    -0.06556290f, 0.02918986f, -0.06077336f, 0.05903568f, -0.30794585f, 0.33303696f, 0.01417423f, -0.36827657f, 
    -0.06033079f, 0.08825488f, 0.18188703f, 0.02578752f, 0.06683841f, -0.26367867f, 0.13521685f, 0.00260283f, 
    0.28433287f, -0.14698118f, 0.06278364f, 0.20440288f, 0.07363320f, -0.05063532f, 0.01795270f, 0.01245717f, 
    -0.04357541f, 0.23414813f, -0.09973536f, -0.06554811f, -0.13587978f, 0.14576645f, -0.17206647f, -0.40705213f, 
    -0.12148865f, -0.05022475f, -0.06189363f, -0.03338274f, -0.08568820f, 0.03976773f, 0.07992635f, -0.21830539f, 
    -0.22162059f, -0.10955114f, 0.15092683f, 0.08684222f, -0.05821699f, 0.08317188f, 0.06510714f, 0.03972689f, 
    0.13149478f, 0.12486548f, 0.11057371f, -0.15591753f, 0.10671112f, 0.20854464f, -0.04890858f, -0.09567080f, 
    0.11451704f, 0.03756995f, 0.05758236f, 0.04418778f, 0.13627104f, 0.18621978f, -0.05810567f, 0.03961624f, 
    -0.02128460f, -0.38808256f, 0.23423520f, 0.23684020f, 0.02105021f, -0.02261383f, 0.24177648f, 0.19083409f, 
    0.14860271f, 0.09720130f, 0.12703326f, 0.06089547f, 0.22009653f, -0.08445457f, -0.02238650f, 0.28313902f, 
    -0.10600404f, -0.00728084f, 0.05802904f, 0.01519763f, 0.05717386f, -0.05529070f, -0.00872343f, -0.11836543f, 
    -0.00932163f, 0.08834644f, 0.13832077f, 0.39259177f, 0.14728594f, 0.09119773f, 0.16970210f, -0.26857638f, 
    -0.05588536f, 0.14474155f, 0.12512983f, 0.26874319f, 0.08215193f, -0.18242981f, 0.20433009f, 0.08790573f, 
    0.06486423f, 0.00635124f, -0.10834347f, -0.05332210f, -0.10428528f, -0.06515875f, 0.17048723f, -0.09277453f, 
    0.05584514f, 0.15724462f, 0.03028706f, -0.22699815f, -0.11393236f, 0.14356726f, -0.00771287f, 0.09143741f, 
    0.24123201f, 0.01953582f, -0.17435645f, 0.02433768f, -0.09931356f, 0.09107480f, -0.04731020f, -0.38279879f, 
    -0.01499668f, 0.07348267f, 0.04793757f, 0.04706606f, 0.15540026f, 0.20085874f, -0.06060899f, 0.16635200f, 
    0.25877061f, -0.17644483f, -0.32297614f, -0.21932043f, 0.19198106f, 0.11268253f, 0.14669889f, -0.19327553f, 
    0.21100478f, -0.01630913f, 0.04427159f, 0.05408945f, -0.54812622f, -0.20519619f, -0.09390277f, -0.22098967f, 
    0.12604618f, 0.07700154f, 0.02322743f, 0.15528983f, -0.01305992f, 0.16395427f, -0.02095857f, 0.01871948f, 
    0.36805928f, 0.23347802f, -0.11486881f, 0.02008425f, -0.01596745f, -0.05999995f, 0.03336422f, 0.21713455f, 
    0.04060530f, -0.01056262f, 0.28454986f, 0.13177440f, 0.08095940f, -0.28184596f, -0.06418956f, -0.26246220f, 
    0.06351782f, 0.01717257f, 0.03630533f, -0.21363594f, 0.09849948f, 0.09329993f, -0.12606315f, 0.01826736f, 
    -0.08702716f, -0.10780212f, 0.18334064f, 0.16866499f, 0.10044513f, -0.07025898f, 0.02780454f, 0.11686155f, 
    0.12077659f, 0.01357037f, -0.00776632f, 0.01468712f, -0.10194343f, -0.25245097f, 0.19572902f, -0.47424930f, 
    -0.03380946f, -0.03028579f, -0.01200023f, -0.00241643f, 0.10959222f, 0.06911365f, -0.01353526f, 0.08049335f, 
    -0.17896053f, 0.13824493f, -0.40797287f, 0.00745474f, -0.03856016f, 0.09776051f, -0.07467818f, -0.11389496f, 
    0.12578249f, -0.04807543f, 0.01757732f, -0.01595599f, 0.15972421f, -0.08424676f, 0.09689283f, 0.05463473f, 
    -0.00284559f, -0.08018526f, 0.06482582f, -0.03544045f, 0.09305814f, 0.05083356f, 0.04535151f, 0.06014037f, 
    0.16567767f, 0.13556243f, -0.06131597f, 0.23651081f, 0.13177465f, 0.03749457f, -0.00047081f, -0.00216793f, 
    0.02405235f, 0.11079712f, 0.09136988f, -0.08409195f, 0.07293510f, -0.09502409f, -0.19623508f, -0.08807811f, 
    0.24326834f, -0.02186355f, 0.12830265f, -0.05578421f, -0.00175416f, -0.19634020f, -0.03365055f, 0.06300256f, 
    0.11233202f, -0.41851982f, -0.20506473f, 0.04731083f, -0.24151252f, 0.23779283f, 0.04500949f, -0.04887066f, 
    0.12902488f, 0.02089623f, -0.06960732f, -0.10521895f, 0.17474982f, 0.33301291f, 0.18786961f, 0.22672114f, 
    0.07724306f, -0.03631359f, 0.10363223f, 0.00314303f, -0.12478926f, 0.09667070f, 0.23427476f, 0.17359369f, 
    0.28642628f, 0.26663509f, 0.10319657f, 0.37622309f, 0.06588239f, 0.06351057f, -0.12869726f, 0.15431345f, 
    0.18248464f, -0.00057087f, 0.10142948f, -0.03596966f, 0.54123145f, -0.11692294f, -0.47476071f, 0.22181623f, 
    0.07421146f, 0.23482408f, 0.06680718f, -0.00156541f, 0.11326496f, 0.07154858f, 0.02157963f, 0.07078899f, 
    0.09854261f, 0.17381060f, 0.36011818f, -0.03634479f, -0.13752152f, -0.25916454f, -0.02173979f, -0.04809926f, 
    -0.08764224f, -0.17610656f, -0.05237268f, 0.06837793f, -0.14287969f, -0.00889048f, 0.04136093f, -0.38090417f, 
    -0.03835594f, 0.07167915f, 0.00284907f, 0.08780700f, -0.03961722f, 0.01836502f, -0.02439518f, 0.05262394f, 
    -0.00951000f, 0.02008351f, -0.00271958f, 0.00040862f, 0.03883850f, 0.02108852f, 0.05000357f, -0.03428441f, 
    0.06116137f, -0.04321281f, 0.03099188f, 0.03909274f, 0.01587396f, -0.06178305f, 0.05423748f, -0.07440120f, 
    -0.04749216f, 0.06134668f, 0.06417274f, -0.06359964f, 0.03048493f, 0.00355667f, 0.01921260f, -0.00036322f, 
    0.05944989f, -0.07364575f, 0.05634522f, 0.03797808f, -0.01126821f, -0.02962289f, -0.05434633f, 0.06372441f, 
    -0.03306436f, -0.05133041f, 0.04765354f, -0.07240933f, -0.01358523f, -0.00845510f, 0.05375924f, -0.06837546f, 
    -0.04870449f, -0.03118413f, 0.02114791f, 0.02209483f, -0.01450437f, -0.00348628f, -0.06362906f, -0.04665442f, 
    -0.03928667f, 0.01816833f, -0.07490882f, 0.04673976f, -0.00824075f, -0.06036419f, 0.03573054f, 0.01498106f, 
    -0.05184276f, 0.04553775f, 0.04964380f, 0.02487102f, -0.02248137f, -0.05627866f, -0.00430263f, -0.04273504f, 
    -0.05420748f, -0.06556605f, 0.00553565f, -0.05548073f, -0.04003760f, 0.02191969f, 0.01710363f, -0.02972898f, 
    0.03233698f, -0.03347946f, -0.05110278f, 0.00012115f, -0.02673980f, -0.05608477f, 0.05897319f, -0.05328201f, 
    -0.01321477f, 0.03498455f, 0.00096330f, 0.03361859f, -0.05597534f, -0.05582031f, 0.00798504f, -0.01910107f, 
    0.06279124f, -0.06645824f, -0.03861181f, -0.04539512f, 0.04997124f, -0.00096964f, 0.01772334f, 0.06044017f, 
    0.00641854f, 0.01591996f, -0.01073891f, 0.03134279f, -0.00859853f, -0.05880932f, -0.07668285f, -0.00250850f, 
    0.04985169f, -0.01266255f, -0.04347702f, -0.03546035f, -0.03972578f, -0.04216987f, 0.00088418f, -0.04740878f, 
    0.00279725f, -0.03080125f, -0.01810727f, 0.06540499f, -0.06564528f, -0.03040972f, -0.06556123f, 0.00190448f, 
    -0.05517664f, -0.00917241f, -0.05285211f, -0.02012692f, 0.03443500f, 0.05476423f, -0.04115973f, -0.02217221f, 
    -0.04997680f, 0.02169668f, -0.02732790f, -0.05976734f, -0.06071489f, 0.05136837f, 0.05524473f, -0.04486282f, 
    0.03721474f, -0.03169805f, -0.04035287f, -0.02107513f, 0.07155950f, -0.00124607f, 0.01668647f, -0.07543649f, 
    0.05424518f, 0.06661839f, 0.04444239f, -0.07239129f, 0.05840766f, 0.00070416f, 0.05362944f, -0.05520291f, 
    0.03876539f, -0.06854615f, 0.03746131f, -0.07434671f, 0.00838906f, -0.01741333f, -0.04344175f, -0.02616825f, 
    0.01693067f, -0.04146863f, -0.02442040f, -0.05961059f, 0.00615043f, 0.00183025f, -0.06753056f, 0.00224997f, 
    -0.03873529f, 0.06301925f, -0.02935010f, 0.02135705f, 0.00188901f, -0.02697262f, -0.06570052f, -0.03330352f, 
    -0.06809869f, 0.03909586f, -0.02005404f, -0.04772201f, -0.05101866f, 0.01251914f, 0.01375506f, -0.05295759f, 
    -0.07523093f, 0.05003515f, -0.00516420f, -0.06571376f, 0.03125743f, 0.01951431f, 0.03986302f, 0.05728799f, 
    0.10331490f, 0.29215017f, 0.04952141f, -0.12575555f, -0.16283743f, 0.20385279f, 0.10734224f, 0.05581485f, 
    -0.22802331f, 0.29415485f, 0.14063959f, -0.04033638f, -0.14976163f, 0.23693581f, 0.20967616f, -0.28250417f, 
    0.25050974f, 0.11039118f, -0.02848020f, -0.10141704f, 0.11933348f, -0.14088872f, -0.12783307f, 0.15576477f, 
    0.06857016f, 0.22141716f, 0.10698539f, 0.15665761f, 0.02421210f, 0.06505097f, -0.13234447f, 0.21033125f, 
    -0.03058854f, 0.04820130f, -0.02763250f, -0.02985851f, 0.39617410f, 0.20875700f, -0.18728557f, -0.30880362f, 
    0.01160857f, 0.12485489f, 0.17811936f, -0.09004288f, -0.10882701f, -0.01923199f, 0.14510420f, -0.11187731f, 
    0.02544577f, 0.03716903f, 0.01685198f, -0.11165208f, -0.09022570f, -0.02005989f, -0.22025698f, 0.09059463f, 
    0.06072575f, 0.15567154f, 0.13083339f, -0.02690256f, -0.02637517f, -0.20538802f, -0.29113114f, -0.03773209f, 
    0.00452618f, -0.20370165f, -0.18569116f, -0.10737079f, 0.13082330f, 0.03829496f, 0.06374987f, 0.02490418f, 
    0.29272461f, 0.15223901f, -0.16752082f, -0.33322048f, 0.13993415f, 0.14040790f, 0.13379622f, 0.05909379f, 
    0.20695195f, -0.05338166f, -0.06766033f, -0.01790138f, -0.06182027f, -0.10413894f, -0.24617286f, -0.09074482f, 
    -0.14748468f, -0.10442539f, -0.08346982f, 0.23080468f, 0.08993305f, -0.01051422f, 0.10115150f, -0.16056970f, 
    -0.10892019f, -0.45745215f, -0.07189775f, -0.23488422f, 0.10548691f, -0.05899156f, 0.05036798f, -0.12892057f, 
    0.01777184f, -0.08523093f, -0.03747962f, 0.19579919f, -0.00058060f, 0.31185490f, 0.05799653f, 0.10975672f, 
    -0.07603755f, 0.07105187f, 0.01976749f, -0.02995514f, -0.00436117f, 0.04439365f, -0.15256375f, -0.07422888f, 
    0.36472788f, 0.15003967f, 0.01477651f, -0.49851182f, 0.05713992f, 0.16286594f, 0.14714189f, -0.04614593f, 
    -0.12223362f, 0.03783702f, -0.09784029f, 0.06237896f, 0.38946176f, 0.01168407f, 0.18313088f, 0.20491987f, 
    -0.01489760f, 0.03195911f, 0.11602984f, 0.08436988f, -0.06486011f, 0.07177661f, 0.03202078f, -0.03279909f, 
    -0.05331769f, -0.02501900f, 0.25128028f, 0.22257315f, 0.04369095f, 0.01211344f, 0.00624284f, -0.11742451f, 
    -0.06782306f, -0.00723139f, -0.00362311f, 0.09093905f, -0.02886091f, 0.02838074f, 0.13794075f, -0.06687897f, 
    -0.08195201f, 0.07715555f, 0.07990912f, -0.10482993f, 0.06683889f, 0.01611780f, -0.04005074f, 0.21084811f, 
    0.46373463f, -0.01466068f, -0.12185111f, 0.08198239f, -0.02626253f, -0.12292751f, -0.11355215f, 0.06050007f, 
    0.17484567f, -0.05208404f, -0.11893345f, -0.02749304f, -0.11858485f, -0.02272556f, -0.41334257f, 0.07051177f, 
    -0.17316280f, -0.17725992f, -0.21528052f, -0.21849732f, -0.19492237f, -0.17540075f, 0.14416599f, -0.11382487f, 
    0.13999514f, -0.04675260f, -0.03945807f, -0.04808146f, 0.05300760f, 0.05833548f, 0.10422683f, -0.14778480f, 
    0.13131163f, -0.16374980f, -0.04873915f, -0.10417489f, 0.20220052f, 0.15108274f, -0.04403906f, 0.24991842f, 
    -0.11336412f, -0.12219688f, -0.04436028f, 0.01004556f, -0.00823545f, 0.19482435f, 0.02162166f, 0.18509933f, 
    0.39263251f, 0.22088115f, -0.23981713f, -0.07439296f, -0.02304668f, 0.10381570f, 0.09524387f, 0.07312310f, 
    -0.03387431f, 0.08113713f, 0.26840931f, 0.18166843f, 0.03921007f, -0.08203160f, 0.26054361f, 0.07915413f, 
    0.03952276f, -0.20386648f, 0.09791566f, 0.04655521f, -0.00976868f, -0.06561759f, -0.25416166f, -0.03705914f, 
    -0.21773621f, -0.15372509f, 0.01041582f, 0.21411543f, 0.15173255f, 0.14960346f, 0.13100781f, -0.03250896f, 
    0.07823370f, 0.14412729f, 0.18375424f, 0.04555657f, 0.19473097f, -0.48162112f, 0.13220109f, 0.11209062f, 
    0.04920263f, 0.02969111f, -0.03291101f, 0.06070564f, 0.02263740f, 0.22115494f, 0.01126485f, 0.12496779f, 
    -0.12073822f, 0.01061493f, 0.03950375f, 0.08782598f, -0.19293362f, -0.05966635f, -0.05671965f, 0.05674552f, 
    0.09232218f, -0.06107135f, 0.06175660f, 0.03095994f, 0.12456451f, 0.09224606f, 0.07342976f, 0.15753095f, 
    0.25805882f, -0.02198336f, -0.01626315f, -0.07656623f, 0.04359526f, 0.05208212f, 0.04654786f, 0.14420256f, 
    0.04841657f, 0.29059097f, -0.07088210f, 0.14158063f, 0.16043280f, 0.02494224f, 0.13183823f, -0.15086202f, 
    0.06032215f, -0.08350077f, 0.14106214f, 0.06192264f, 0.22616416f, -0.25611535f, 0.14788450f, 0.01231326f, 
    -0.03010222f, 0.03358343f, 0.05523448f, -0.01485592f, -0.03043255f, -0.25430113f, -0.04702781f, 0.05741742f, 
    0.06739534f, -0.01053431f, -0.29475236f, -0.04261490f, -0.06134564f, -0.02061763f, -0.05484351f, -0.18150797f, 
    -0.15026826f, -0.14313574f, -0.06139843f, -0.04644568f, -0.04107064f, 0.09835432f, -0.15748714f, -0.20926708f, 
    0.23086798f, 0.03231792f, 0.05134824f, 0.03015279f, 0.05073660f, 0.16557738f, 0.09959929f, 0.03166365f, 
    -0.27291429f, -0.01690174f, -0.16127846f, -0.17854352f, -0.01453133f, 0.07398365f, -0.09665596f, 0.11439227f, 
    0.22366565f, -0.06626948f, 0.01857072f, -0.26710665f, 0.32197899f, -0.01537122f, -0.18830296f, -0.15912904f, 
    -0.10745639f, 0.03910510f, 0.17013508f, 0.17340726f, 0.22954135f, 0.06843633f, 0.06722073f, 0.09573573f, 
    -0.58239639f, -0.00279013f, 0.01258804f, 0.07335497f, 0.12322694f, 0.00314392f, -0.20412719f, 0.02498273f, 
    -0.14534280f, 0.15761332f, 0.29570344f, -0.10546609f, 0.00708619f, 0.09762455f, 0.03078672f, -0.05229656f, 
    0.23231077f, 0.05785725f, -0.07597643f, 0.05185366f, 0.03607367f, 0.00393109f, 0.03326720f, -0.10567707f, 
    0.03479671f, -0.21052150f, -0.03322698f, -0.26601401f, 0.30952907f, 0.06018605f, -0.06063264f, 0.03104649f, 
    -0.06113583f, -0.04247057f, 0.20161979f, 0.07576797f, -0.28870940f, -0.36193302f, -0.15025155f, -0.26755720f, 
    0.24062815f, 0.18148956f, 0.04750648f, 0.13807635f, 0.01752712f, 0.01350149f, 0.10085812f, -0.21700372f, 
    -0.00233583f, -0.02922307f, -0.04996900f, -0.14441741f, 0.06412296f, -0.11536337f, -0.00606799f, 0.03567806f, 
    0.04632837f, 0.06648886f, 0.09077949f, 0.06472941f, 0.13795602f, -0.07130991f, 0.02319043f, -0.14551090f, 
    0.17920078f, 0.01634126f, -0.03408717f, 0.04702558f, 0.06528378f, 0.13318485f, 0.11357585f, 0.11808220f, 
    0.25082624f, 0.20552367f, 0.36772543f, 0.05638355f, -0.02830342f, -0.17772686f, -0.10473026f, -0.00643266f, 
    -0.02756813f, -0.08147246f, 0.01930244f, 0.00827082f, 0.19847764f, 0.10831314f, 0.17562249f, 0.05029963f, 
    -0.09386373f, 0.08419215f, 0.05655827f, 0.03879699f, 0.13890281f, -0.03998126f, -0.02104892f, 0.06463210f, 
    -0.11431267f, -0.05528392f, -0.12802587f, -0.16963390f, 0.08588423f, 0.12900108f, 0.13327058f, 0.07622781f, 
    0.04687145f, 0.00919774f, -0.09571159f, 0.03555278f, 0.34233326f, 0.23710935f, 0.19051819f, -0.31672502f, 
    -0.07327004f, -0.04323644f, 0.13414022f, 0.02009278f, 0.00438169f, 0.01562336f, 0.08077180f, 0.02495003f, 
    0.33570224f, 0.12358047f, 0.22888216f, 0.01342034f, 0.08148944f, 0.05359595f, 0.01500436f, 0.07304581f, 
    -0.22637664f, 0.07104873f, 0.13377006f, -0.01489000f, -0.02640452f, 0.02887918f, -0.20658401f, -0.04916003f, 
    0.25323915f, 0.04689009f, -0.01202414f, -0.01547850f, 0.00168362f, -0.05310619f, -0.07022616f, -0.04213035f, 
    0.00248979f, -0.40147117f, 0.27022293f, -0.21073321f, -0.00157666f, 0.09082851f, 0.06020820f, 0.07941306f, 
    0.15171281f, 0.17118542f, -0.02182086f, 0.01067408f, -0.22876126f, -0.00111184f, 0.22948690f, 0.22023913f, 
    -0.05429962f, -0.06053538f, 0.21794702f, 0.17378876f, -0.16822407f, -0.04204552f, 0.00846497f, 0.14090276f, 
    0.12938434f, -0.00776748f, 0.15975837f, 0.05491977f, 0.02216697f, 0.07602090f, -0.00430921f, 0.10739416f, 
    -0.01486387f, -0.09394608f, 0.08240138f, 0.00228611f, 0.02853503f, -0.22281547f, -0.26225159f, -0.02025200f, 
    0.16249122f, 0.19882739f, 0.03802250f, 0.00230455f, 0.18373665f, 0.02288230f, 0.02841769f, 0.05582863f, 
    0.30941269f, 0.39281020f, 0.09504353f, -0.06086360f, -0.04093576f, -0.09108570f, -0.00589554f, 0.00170799f, 
    0.02301089f, -0.18775961f, -0.11156128f, 0.10288688f, 0.02517023f, 0.34336144f, 0.15010607f, -0.00204893f, 
    -0.17654786f, 0.06126332f, 0.09058219f, 0.13783577f, -0.00665509f, 0.12435654f, 0.21312512f, 0.16973928f, 
    0.02365710f, 0.21108282f, 0.06518937f, 0.11032570f, -0.02968243f, -0.19897294f, 0.15534765f, -0.08840974f, 
    -0.15938124f, 0.20853171f, 0.03340932f, 0.12128490f, -0.05925534f, -0.19952495f, -0.04140051f, 0.19931601f, 
    -0.11149180f, 0.04760761f, 0.15817083f, 0.02909847f, -0.17344837f, -0.05143976f, -0.04148221f, 0.00453294f, 
    0.34857664f, -0.08003398f, -0.07211947f, 0.10314538f, 0.10785367f, 0.05299113f, 0.02223961f, -0.00628507f, 
    -0.11237124f, -0.12813400f, -0.13536100f, -0.03559899f, -0.42428419f, -0.06156317f, 0.03650858f, 0.02216464f, 
    0.06781437f, -0.01150553f, 0.07677155f, 0.19329998f, -0.06647843f, 0.02588752f, 0.17192304f, 0.14075814f, 
    0.16709957f, 0.44394633f, -0.18925716f, -0.01608234f, 0.13598409f, 0.13441604f, 0.00129162f, 0.00199556f, 
    -0.02143997f, -0.04654419f, -0.15232943f, 0.03658256f, 0.16607010f, 0.00639649f, -0.06927144f, -0.23171505f, 
    -0.04473757f, 0.03052072f, -0.02174584f, 0.14550437f, -0.08767910f, -0.15813139f, 0.21231462f, 0.02051503f, 
    0.39306295f, 0.01974230f, 0.01370803f, 0.11211856f, -0.14802942f, -0.13758589f, -0.13333878f, 0.02212557f, 
    -0.14128366f, 0.02774359f, -0.14037527f, -0.25292289f, 0.26318815f, -0.21155962f, -0.10815176f, 0.11184686f, 
    -0.05215393f, 0.01605690f, -0.20652546f, -0.12381257f, 0.03284771f, -0.03196109f, 0.10858136f, -0.22257185f, 
    -0.00077248f, -0.01189201f, 0.04838806f, 0.04007119f, -0.03159802f, -0.07805634f, 0.01791374f, -0.01299250f, 
    0.14806852f, 0.07883300f, 0.19630647f, -0.19134253f, 0.26505858f, -0.17406480f, 0.00790537f, -0.10114718f, 
    0.09445457f, -0.04402920f, 0.16853878f, 0.21492113f, -0.12646337f, 0.06180340f, -0.14606681f, -0.03332256f, 
    0.16914116f, -0.29048532f, -0.13323599f, 0.23516582f, -0.03378588f, 0.02091428f, 0.12452347f, 0.06651642f, 
    0.05621279f, 0.11471197f, -0.00338852f, 0.22528920f, 0.05773499f, 0.22907867f, -0.19966973f, -0.11003149f, 
    0.11303402f, -0.03778697f, 0.03703671f, -0.10747974f, 0.02526336f, -0.04445287f, -0.08618163f, -0.19322221f, 
    0.04553377f, 0.27220875f, -0.29582500f, 0.13670492f, -0.10748665f, 0.01236002f, 0.16481175f, -0.27455547f, 
    0.16518265f, 0.09225842f, 0.20521195f, 0.17807476f, 0.35490119f, 0.21068874f, 0.22237387f, -0.06496945f, 
    -0.05158158f, -0.00957353f, 0.09389132f, -0.10313777f, -0.01203409f, -0.22602729f, 0.06232468f, -0.03263738f, 
    -0.31671816f, 0.22907728f, 0.07099123f, -0.46762070f, -0.11489432f, 0.04884877f, -0.23352122f, 0.04956613f, 
    0.14411628f, 0.03807549f, -0.01729540f, -0.12790109f, 0.36455205f, 0.08171796f, -0.10729554f, -0.43124476f, 
    0.21446019f, -0.06797724f, -0.03029120f, -0.16157168f, -0.05000140f, 0.17018372f, 0.03242947f, 0.09106183f, 
    -0.10039800f, -0.00998369f, -0.04823383f, -0.06567197f, -0.00543199f, 0.13883443f, -0.02128939f, 0.03187630f, 
    0.02778233f, -0.06348237f, -0.02857505f, 0.10213877f, -0.22999294f, 0.40020606f, 0.25740981f, -0.00773234f, 
    0.08562689f, -0.14380828f, 0.02009073f, -0.07685308f, 0.12821089f, 0.07457256f, -0.07652840f, 0.07832689f, 
    -0.02349277f, -0.24673952f, 0.13044870f, 0.30569467f, -0.08650932f, -0.02107982f, 0.05186496f, -0.08983848f, 
    -0.02082559f, -0.04419735f, -0.10287736f, 0.10621264f, 0.06950395f, -0.06881288f, -0.14918180f, 0.06189737f, 
    -0.00125498f, 0.08564892f, 0.07609846f, -0.27053320f, -0.06515946f, 0.02143262f, -0.19942856f, 0.12762105f, 
    -0.01393445f, -0.20539182f, 0.04838344f, -0.03829892f, -0.15512684f, 0.00181036f, -0.07219096f, -0.06433814f, 
    0.07108492f, 0.05601110f, 0.18051398f, -0.11608472f, 0.13698356f, 0.08378624f, 0.06437545f, -0.14345576f, 
    0.01817621f, -0.09315207f, 0.02704805f, -0.11476071f, 0.04664625f, 0.07499458f, -0.13430479f, 0.01340083f, 
    -0.01534496f, -0.00029651f, 0.11810408f, 0.24466531f, 0.21893777f, 0.12434927f, 0.06131316f, 0.08842545f, 
    0.01579452f, -0.05805029f, 0.16912229f, -0.00379653f, -0.21971743f, 0.03114140f, 0.38139799f, 0.32219544f, 
    0.00453082f, 0.12093700f, 0.10361858f, 0.02835300f, -0.09415382f, 0.00921944f, -0.00522771f, 0.20658493f, 
    -0.19272403f, -0.11679740f, -0.17263773f, -0.15583856f, -0.08213628f, 0.03905996f, -0.03699308f, 0.07944470f, 
    0.07523686f, -0.01812560f, -0.18896817f, -0.00006098f, -0.25546417f, 0.23467200f, 0.11601667f, -0.25815973f, 
    -0.18139850f, 0.11876255f, -0.05205328f, -0.06259814f, 0.06133702f, 0.00653975f, 0.16631551f, -0.08317552f, 
    0.21647689f, 0.26276988f, -0.16631831f, 0.21903878f, 0.17884772f, 0.00720105f, 0.05922610f, -0.10943467f, 
    -0.03449688f, 0.00419575f, 0.02904674f, -0.08168720f, 0.12871875f, -0.00461925f, 0.06425111f, 0.20694295f, 
    -0.16213790f, -0.04005547f, -0.11865836f, -0.02490668f, 0.07037116f, -0.06733057f, 0.11669951f, 0.27028894f, 
    0.15140373f, -0.20022228f, -0.08758271f, 0.10781676f, -0.04299906f, 0.08035438f, 0.07816969f, 0.12652980f, 
    0.00498509f, 0.06218670f, 0.00707792f, -0.09282140f, -0.39876655f, 0.10260551f, 0.15601093f, 0.11181036f, 
    0.02404155f, -0.03974737f, -0.01721901f, 0.06031983f, -0.07324791f, -0.02895186f, -0.01908870f, 0.08854394f, 
    0.23561233f, 0.11445234f, 0.06574691f, 0.29070842f, 0.06180034f, 0.16620439f, 0.04650853f, -0.13841870f, 
    -0.18215491f, 0.05905769f, 0.03931282f, 0.10677741f, 0.18353663f, -0.07494873f, 0.17125225f, 0.09519449f, 
    -0.04467260f, -0.06412860f, -0.05932145f, -0.05423590f, 0.08780930f, -0.05602524f, -0.03019569f, 0.05303273f, 
    0.25537777f, 0.05883697f, 0.15134439f, 0.04545934f, 0.17871946f, 0.11665510f, -0.26758155f, 0.04482113f, 
    -0.02496628f, 0.02480484f, 0.07819642f, -0.02424796f, 0.03182374f, 0.01529055f, 0.00566249f, 0.03132013f, 
    0.06226524f, 0.03380156f, -0.12582386f, -0.09146333f, -0.08627631f, 0.03780083f, 0.05648889f, -0.12980060f, 
    0.28597859f, -0.37666565f, -0.33132827f, -0.09916122f, 0.05381546f, -0.17222966f, 0.02389217f, -0.03382868f, 
    0.12797850f, 0.10883112f, -0.03223106f, -0.13432565f, 0.22263180f, -0.00047299f, 0.03043191f, 0.13928498f, 
    -0.04843905f, 0.08469093f, -0.10094233f, -0.21607369f, -0.04936149f, -0.02592695f, -0.01571498f, 0.09193309f, 
    0.42188758f, 0.04469103f, -0.12003209f, 0.01600759f, 0.06697550f, -0.10682251f, -0.11686873f, -0.07909568f, 
    -0.04931910f, 0.06694693f, -0.19981007f, 0.08027303f, -0.10305471f, -0.00511678f, 0.06436318f, -0.04755302f, 
    0.12852296f, -0.05163587f, -0.08220267f, -0.04644798f, -0.13574667f, -0.16965130f, 0.04592349f, -0.09170002f, 
    0.29997253f, 0.41247430f, 0.31271341f, 0.42562816f, 0.25609848f, 0.22689427f, -0.00471104f, 0.14520642f, 
    -0.07269813f, 0.00739428f, -0.05668005f, -0.03517073f, -0.10237154f, 0.10785969f, -0.20939712f, -0.35387760f, 
    0.05967546f, 0.03842125f, -0.03026271f, -0.03088878f, -0.08698565f, 0.08322494f, 0.16941611f, -0.18645984f, 
    0.06983897f, 0.09721278f, 0.13619000f, -0.15229177f, -0.01083915f, 0.06402778f, -0.10231663f, -0.17269073f, 
    -0.19396941f, 0.22612011f, -0.22363485f, -0.06004632f, -0.28213239f, 0.20238960f, 0.07040150f, -0.09422600f, 
    -0.13197505f, 0.00596277f, 0.20068932f, -0.13055503f, -0.20343883f, -0.07607348f, 0.02481671f, -0.05730948f, 
    -0.03034880f, 0.21673642f, 0.01573253f, 0.16057448f, 0.12308108f, -0.00925604f, 0.19489177f, -0.03555486f, 
    -0.09197922f, 0.06855291f, -0.04510311f, 0.08286857f, -0.08636852f, 0.05370754f, 0.10297552f, 0.23924631f, 
    -0.21206838f, -0.18955880f, -0.12001197f, -0.00482466f, -0.33105165f, 0.24499762f, -0.11707728f, -0.05564874f, 
    0.06786142f, 0.13526566f, -0.08997800f, 0.22887877f, -0.15487787f, -0.05985044f, 0.04716680f, 0.01937950f, 
    -0.28950271f, -0.03690937f, -0.08356109f, -0.09033834f, 0.44013381f, 0.17939469f, 0.23909867f, 0.04881236f, 
    0.07413349f, 0.20906726f, 0.10554013f, -0.06223433f, 0.09148680f, 0.08903447f, -0.14053698f, 0.11363495f, 
    -0.02549727f, -0.00103388f, -0.22100978f, -0.24348009f, -0.01395848f, -0.12921700f, -0.04228250f, 0.09051702f, 
    -0.08242346f, -0.15462698f, -0.07716532f, -0.05054522f, 0.06752522f, -0.02975323f, 0.09184320f, -0.34156001f, 
    -0.02283072f, -0.06741022f, 0.03333555f, -0.06698550f, -0.12387680f, -0.09326754f, 0.06548484f, -0.05173853f, 
    -0.07197042f, 0.07017845f, 0.03414460f, 0.02314496f, 0.01659315f, 0.05437038f, 0.01897081f, -0.01145592f, 
    -0.04138304f, -0.01817833f, -0.01904107f, 0.02080308f, -0.00817880f, -0.01229890f, 0.01912188f, 0.01863030f, 
    -0.06662641f, 0.00701782f, -0.08086871f, -0.06503515f, -0.04203061f, 0.05329182f, 0.04005311f, -0.03281438f, 
    0.00411310f, -0.03945327f, -0.03751690f, 0.01502281f, -0.00183021f, 0.04320982f, -0.05161912f, 0.05916048f, 
    -0.01982490f, 0.00654279f, -0.06620070f, -0.03956459f, -0.00225076f, -0.02808312f, -0.04584236f, 0.00554988f, 
    0.03451482f, 0.03077763f, -0.05915437f, 0.05456355f, -0.00601388f, -0.06409355f, 0.05148970f, -0.01359528f, 
    -0.02760628f, -0.07364250f, -0.06620993f, 0.02643120f, 0.00416699f, -0.04205850f, 0.03953546f, 0.02278244f, 
    0.01148651f, -0.03283292f, -0.08554126f, 0.05024167f, 0.04786961f, -0.08554709f, -0.08950286f, 0.02251707f, 
    -0.04353651f, -0.05727584f, -0.07792008f, -0.06456132f, 0.04803551f, -0.08171163f, -0.06263270f, 0.01649438f, 
    -0.00018696f, -0.03543282f, 0.05952908f, 0.02976199f, -0.06500093f, -0.04938514f, 0.03324999f, 0.04949122f, 
    0.06287955f, 0.01972354f, 0.00376221f, 0.04045744f, 0.03878632f, -0.06836987f, 0.01189046f, -0.04730809f, 
    -0.06368699f, -0.02177394f, 0.03341396f, -0.03489079f, -0.06031371f, -0.04154883f, -0.03855595f, 0.03630994f, 
    -0.00792558f, -0.06850228f, 0.00185700f, 0.00148827f, 0.00195334f, -0.02983586f, 0.03623987f, 0.03549612f, 
    0.01477664f, -0.06981448f, -0.03675001f, -0.00957622f, 0.01958315f, 0.03410763f, -0.06767094f, 0.04207579f, 
    -0.09006429f, -0.07151758f, -0.05252044f, -0.04331807f, 0.04780329f, -0.06589159f, -0.01428617f, 0.03661226f, 
    -0.06936833f, -0.06465809f, 0.02811958f, -0.02567035f, -0.06740355f, -0.02448110f, -0.00541099f, -0.00866734f, 
    0.01550406f, -0.07060886f, 0.03962106f, -0.05082829f, 0.04496519f, 0.00784142f, -0.00643223f, -0.06585500f, 
    0.01072610f, 0.04505895f, -0.07216848f, 0.01925891f, -0.00921957f, 0.00333275f, -0.04034067f, -0.05726921f, 
    -0.05417003f, 0.01140817f, -0.03299371f, 0.04654590f, -0.06969377f, 0.00744545f, -0.00535443f, 0.02749201f, 
    -0.04681171f, -0.01846039f, 0.02986801f, 0.00996317f, -0.03986594f, -0.07741505f, -0.05973711f, -0.00911847f, 
    -0.06471756f, 0.00613098f, -0.07156876f, -0.06503530f, 0.06121509f, 0.03469403f, -0.03757325f, 0.05029349f, 
    0.03200699f, 0.00471473f, -0.05914504f, -0.00286883f, 0.04455842f, -0.07980554f, 0.00567319f, 0.04467000f, 
    -0.02446599f, 0.00482858f, -0.06167598f, 0.00571775f, 0.01419052f, 0.02960922f, 0.02765189f, -0.04922150f, 
    0.04866407f, -0.01479523f, 0.04585385f, 0.03378147f, -0.02849281f, -0.03082681f, 0.05438797f, 0.02328121f, 
    -0.09420343f, 0.00092043f, -0.06877464f, 0.33865175f, -0.05199964f, 0.04504798f, 0.11858527f, 0.14908895f, 
    -0.05013873f, 0.13350436f, -0.04822804f, 0.04661841f, 0.13515824f, 0.21459559f, 0.10559145f, -0.01359275f, 
    -0.01273769f, -0.01748402f, -0.00467457f, -0.03317391f, 0.05135015f, -0.09654294f, 0.06036234f, 0.13147175f, 
    -0.04692941f, -0.03427937f, 0.23615137f, 0.15415923f, -0.00196332f, 0.08663699f, -0.05888785f, -0.05373452f, 
    0.05119736f, 0.02917304f, -0.07769317f, 0.08741538f, 0.03627700f, 0.01648065f, -0.08172592f, 0.00553911f, 
    0.01565430f, 0.20106550f, -0.00556395f, -0.04242759f, -0.05231792f, -0.05727213f, 0.11229984f, -0.06928283f, 
    -0.26157877f, -0.22263570f, -0.03396034f, -0.19568890f, -0.15876096f, -0.00871450f, 0.00620068f, -0.02536109f, 
    0.01953787f, -0.11887417f, 0.08110828f, -0.01177277f, -0.37230676f, 0.32220989f, -0.00943042f, -0.21391907f, 
    -0.06401363f, -0.03463095f, 0.07452690f, 0.01902882f, -0.03406766f, -0.01051727f, -0.05368526f, 0.11562273f, 
    -0.11063316f, -0.09822349f, 0.06188638f, 0.06737296f, 0.17392147f, 0.10576069f, 0.13852909f, 0.04643615f, 
    0.04147397f, 0.03486656f, 0.03868070f, 0.02059159f, -0.49487016f, -0.23797120f, 0.00330627f, -0.05033341f, 
    -0.13249116f, -0.00013507f, -0.01145179f, 0.08461209f, -0.03946992f, -0.00779272f, 0.02184733f, 0.14632724f, 
    -0.11461026f, -0.29030141f, -0.03141557f, -0.14352617f, -0.01736430f, 0.11825471f, 0.00909407f, 0.08399010f, 
    0.13202262f, -0.00482664f, -0.22426698f, 0.09211860f, -0.35246721f, 0.36335659f, -0.01653773f, -0.11985709f, 
    0.09238750f, 0.05422372f, -0.05688494f, 0.06011082f, -0.03141131f, 0.13718751f, 0.06665122f, 0.11547143f, 
    -0.17142642f, 0.16209371f, 0.14686015f, 0.15679325f, 0.18293017f, -0.08501974f, 0.11941838f, 0.06963639f, 
    0.07281479f, -0.08765731f, 0.16624849f, 0.15781419f, 0.32573500f, -0.09223702f, -0.05129690f, 0.29756078f, 
    -0.03429742f, -0.04654801f, 0.06980960f, -0.04858031f, 0.00882102f, 0.13095218f, -0.00463856f, 0.06852522f, 
    0.04086761f, 0.07328647f, 0.28223190f, 0.07755225f, 0.10285193f, 0.03895634f, 0.02301249f, -0.13091858f, 
    -0.07889527f, 0.09518570f, 0.07131178f, 0.11375272f, -0.24848841f, -0.02670230f, 0.10794882f, 0.21704623f, 
    0.06228851f, -0.05798864f, -0.11328440f, -0.07003666f, -0.12256838f, 0.04960297f, -0.08117130f, 0.02715954f, 
    0.19959590f, -0.25708583f, -0.06162595f, 0.01868436f, -0.00520652f, 0.18885414f, 0.10552255f, 0.02708355f, 
    0.00357951f, 0.02331278f, 0.06180628f, 0.06234697f, -0.28242680f, -0.17755677f, -0.03487477f, -0.05322496f, 
    -0.04129229f, -0.05249058f, -0.04620085f, -0.03097668f, 0.13409482f, -0.02976055f, -0.06028601f, 0.05519284f, 
    -0.03328949f, -0.21273512f, 0.08021967f, -0.00829262f, -0.11369431f, -0.18241034f, 0.00605059f, -0.03854210f, 
    -0.18717171f, -0.10979164f, 0.18645087f, -0.17412469f, 0.37370703f, 0.24787444f, -0.13951044f, 0.24472345f, 
    0.11296502f, -0.07020310f, -0.05001324f, -0.10322005f, -0.14830750f, 0.16392449f, 0.10401279f, 0.08718713f, 
    -0.23268764f, -0.00251962f, -0.10996793f, -0.03813582f, 0.08130784f, -0.16061600f, 0.07163040f, -0.00813195f, 
    0.06541299f, -0.26960188f, -0.08304081f, -0.09651435f, -0.00663640f, 0.18374024f, 0.04035717f, 0.08517319f, 
    -0.02628420f, -0.15099564f, -0.18435520f, -0.08507241f, -0.17390005f, -0.04360596f, 0.15814179f, -0.12016863f, 
    -0.15702036f, -0.07360113f, 0.16056150f, -0.04388383f, -0.00798118f, -0.10399245f, -0.05089296f, 0.24007794f, 
    0.15380889f, 0.13946788f, 0.04059391f, -0.13678974f, 0.16927491f, 0.18436036f, 0.04455781f, 0.37188175f, 
    0.02293514f, 0.06569462f, -0.05205408f, 0.15771307f, -0.19032294f, -0.06008433f, -0.18019311f, -0.17381419f, 
    0.06580488f, 0.01017876f, -0.22419813f, 0.02065400f, -0.01333641f, 0.07128247f, -0.00578152f, -0.10957434f, 
    0.09131421f, 0.31361741f, 0.10390465f, 0.08401784f, 0.21207052f, 0.15016672f, -0.11416917f, 0.00853007f, 
    0.11479482f, 0.03194807f, 0.01387825f, 0.16891718f, 0.08916957f, 0.11953431f, -0.06670750f, -0.22033921f, 
    -0.29171336f, -0.05159239f, 0.08831101f, 0.02444606f, -0.04009205f, 0.02276073f, -0.19008906f, 0.17344770f, 
    0.04267208f, 0.05779148f, -0.03203809f, 0.16396123f, 0.36916742f, -0.09779676f, -0.03230278f, 0.18015042f, 
    -0.10206403f, -0.01145297f, 0.14286354f, 0.12973911f, 0.01874526f, 0.11505428f, -0.00055025f, -0.06380124f, 
    0.00946729f, 0.01066637f, 0.00327783f, 0.06309260f, 0.02673712f, -0.09702674f, 0.00285592f, 0.16933703f, 
    0.07746600f, 0.01796305f, 0.05530663f, -0.10979096f, -0.02422258f, -0.37330601f, 0.13578074f, -0.34359628f, 
    -0.00136755f, 0.09353539f, 0.09470038f, 0.12442482f, 0.14325391f, -0.12644397f, -0.09860472f, -0.04431731f, 
    -0.32956779f, -0.02597286f, 0.00389939f, -0.36359346f, 0.15161537f, 0.03414905f, -0.13168323f, -0.05828274f, 
    -0.30537719f, -0.32467988f, 0.03221268f, -0.00132466f, -0.02248983f, -0.17729300f, 0.11965733f, -0.11561051f, 
    -0.06993885f, 0.13023931f, -0.15875252f, -0.12736499f, -0.01903193f, -0.00668964f, 0.15110694f, 0.15261507f, 
    0.00874923f, 0.12283398f, 0.12075156f, 0.08787453f, -0.07008366f, 0.03109811f, -0.02088711f, 0.07215604f, 
    0.01024740f, -0.16684601f, -0.16107571f, -0.01775537f, 0.20129681f, 0.02863116f, -0.14738677f, 0.46035099f, 
    -0.05543575f, 0.20403478f, 0.20095451f, 0.16574737f, -0.07372212f, -0.09399623f, 0.01123494f, -0.30897400f, 
    0.03510474f, -0.06305037f, 0.03432770f, 0.00304398f, 0.04492342f, 0.04176453f, 0.01050063f, -0.01930591f, 
    0.05558600f, 0.04061902f, -0.05370742f, -0.03921264f, -0.01499168f, 0.01446246f, 0.05349198f, 0.04236396f, 
    0.01210261f, -0.05842721f, 0.01185297f, -0.04758155f, -0.00860664f, -0.06905901f, -0.03766084f, -0.04790283f, 
    -0.06036372f, -0.00963128f, 0.04300918f, -0.01655067f, -0.05525493f, -0.07291121f, 0.03869820f, 0.05524531f, 
    -0.03834302f, -0.00575037f, -0.05579255f, 0.01096499f, -0.06722023f, 0.00221169f, -0.02587079f, 0.01510391f, 
    -0.02851559f, 0.01362415f, -0.02340824f, -0.04327456f, -0.04479416f, -0.00690851f, -0.01853372f, -0.06402270f, 
    0.01524505f, -0.01070652f, -0.02733007f, -0.07335547f, -0.04328733f, -0.05686599f, -0.02498704f, -0.04684902f, 
    -0.01178820f, -0.04812615f, -0.04224844f, -0.03001625f, -0.01764935f, 0.02745957f, 0.05912139f, -0.01140354f, 
    -0.05813279f, -0.01300757f, -0.06903268f, -0.03514696f, -0.00085238f, 0.04581409f, 0.02387513f, -0.04117456f, 
    0.04884282f, 0.03784657f, -0.05825017f, -0.00428821f, -0.01947984f, -0.04874757f, -0.05095550f, -0.04004220f, 
    -0.03675858f, 0.02099250f, 0.00607726f, -0.07687461f, 0.03282543f, 0.02248554f, -0.04460825f, 0.04325690f, 
    0.02289573f, -0.04470592f, 0.05956345f, -0.02772395f, -0.02623848f, -0.03521489f, 0.02935102f, 0.00717813f, 
    -0.04499492f, -0.05658894f, 0.04532330f, -0.00282681f, -0.06830530f, 0.01504159f, 0.04881850f, -0.06029250f, 
    0.01970790f, 0.02442561f, -0.00539707f, 0.03854715f, 0.05236908f, -0.07242504f, 0.01216216f, 0.04716709f, 
    -0.02420161f, 0.05661286f, 0.05140894f, 0.02995891f, -0.02903862f, 0.02692654f, 0.02587044f, -0.04792171f, 
    -0.03196228f, -0.04132669f, -0.04991417f, -0.07583632f, -0.07541591f, 0.05622219f, -0.05747503f, 0.04701596f, 
    -0.03650117f, 0.00372058f, -0.05263045f, 0.02773992f, -0.07139400f, -0.00035729f, -0.04912553f, -0.01625147f, 
    -0.04618410f, 0.06291107f, 0.05388401f, 0.03495676f, -0.01505289f, -0.04874608f, 0.03176582f, 0.04574618f, 
    -0.05234967f, -0.01830819f, 0.00995829f, 0.00422092f, 0.00353312f, -0.05454007f, -0.07592578f, -0.04169350f, 
    -0.00792283f, -0.04646045f, -0.00757032f, 0.01274497f, 0.00037204f, -0.03445951f, 0.03731623f, -0.06262340f, 
    0.00387770f, -0.00129912f, -0.05712999f, -0.04736707f, -0.04191039f, 0.04163530f, -0.07572633f, -0.06075391f, 
    -0.02843476f, 0.03538222f, 0.02508027f, 0.04105737f, -0.01301517f, -0.04580721f, 0.05927702f, -0.05329754f, 
    -0.02886266f, -0.00211548f, 0.02867481f, 0.06086371f, -0.05239462f, -0.02721063f, -0.06322352f, -0.02650511f, 
    0.04760898f, 0.05038969f, -0.06569210f, 0.04659138f, -0.00874811f, 0.01975922f, 0.01104721f, 0.01786582f, 
    -0.07296997f, -0.07785566f, -0.07296382f, -0.00491370f, -0.06548569f, -0.05542649f, -0.02495706f, -0.00212691f, 
    0.05064352f, 0.01818966f, -0.02190662f, 0.00381587f, -0.00398860f, 0.03943748f, -0.05863430f, 0.02415435f, 
    0.00228708f, 0.04382637f, -0.02141996f, -0.07640888f, -0.03361824f, 0.02866829f, 0.02567410f, -0.05115923f, 
    0.05155160f, 0.03814682f, 0.00772057f, -0.05944284f, 0.00003353f, -0.06473818f, 0.04980654f, 0.00843102f, 
    0.03161474f, -0.01638549f, 0.04806596f, -0.07089781f, 0.01071881f, -0.01146437f, -0.05399280f, 0.04181855f, 
    0.00692234f, -0.04322473f, 0.04710068f, -0.04716541f, 0.04744644f, -0.03624050f, 0.02951355f, -0.04869569f, 
    -0.06957483f, 0.05095031f, -0.01252093f, -0.02037217f, 0.00546892f, -0.01940837f, 0.00133440f, 0.05722094f, 
    -0.06111288f, -0.04657052f, -0.04793063f, -0.02099784f, 0.00533226f, 0.04100446f, 0.01183442f, -0.00455282f, 
    -0.01573844f, 0.04618362f, -0.03412887f, -0.01775124f, -0.02946619f, 0.02676011f, -0.07599268f, -0.02081712f, 
    0.04141124f, 0.04281023f, -0.07274831f, 0.01120767f, -0.06828209f, -0.02460976f, 0.05263678f, -0.03670997f, 
    0.05259832f, -0.06308056f, 0.02612685f, -0.05065852f, 0.01273728f, -0.07412072f, -0.07601822f, -0.01232626f, 
    -0.05451012f, -0.02677725f, -0.05795684f, -0.06244816f, -0.01272586f, -0.00851825f, -0.07100657f, -0.04953852f, 
    -0.00692562f, -0.03645040f, 0.01170552f, -0.06182610f, -0.02430034f, 0.04040603f, -0.06474703f, 0.00903769f, 
    -0.04739556f, 0.06013439f, -0.01315701f, -0.01606968f, -0.04005196f, -0.01772671f, 0.01255425f, -0.07817567f, 
    -0.04541854f, -0.00256760f, 0.02670370f, 0.00651664f, -0.00631723f, -0.03854096f, 0.02866278f, -0.03918717f, 
    -0.00707797f, -0.04708309f, 0.01223021f, 0.05591296f, 0.03119778f, -0.05629573f, -0.02107269f, 0.00642502f, 
    -0.03163676f, -0.02544983f, -0.04666180f, -0.02391537f, 0.01328214f, 0.05801390f, 0.01909882f, -0.03377547f, 
    0.01215047f, 0.03485089f, 0.00267257f, -0.06651789f, 0.05152029f, 0.03532919f, 0.02693557f, -0.01478529f, 
    0.03221962f, 0.03335426f, -0.04805016f, -0.00533494f, 0.02193448f, -0.07726049f, -0.00630781f, -0.06381017f, 
    0.02065536f, 0.00483790f, -0.00656811f, -0.03118367f, -0.07193732f, 0.03206476f, -0.02024806f, 0.04383926f, 
    -0.04912480f, -0.01820870f, 0.01255815f, -0.01927282f, 0.03410866f, -0.03492085f, -0.03490392f, -0.04797075f, 
    0.01591784f, 0.05045461f, 0.06003439f, -0.00450295f, 0.02968388f, 0.03727628f, 0.05958731f, 0.05429180f, 
    0.00643342f, -0.00842904f, -0.04168564f, -0.06688821f, -0.04010466f, 0.05834134f, -0.07036245f, -0.02038555f, 
    0.01776093f, 0.05743005f, 0.04187966f, -0.02373509f, 0.01014462f, 0.00694842f, -0.01262577f, -0.05537748f, 
    -0.03356901f, 0.03800574f, -0.02805217f, -0.13770086f, -0.16208977f, 0.22771876f, 0.17713971f, -0.06608874f, 
    -0.08886167f, 0.10511883f, 0.09343423f, -0.10842477f, -0.39533716f, 0.26328245f, 0.24895889f, -0.14551319f, 
    0.36259335f, -0.03590149f, 0.12682822f, -0.09094033f, 0.03139331f, -0.00084227f, -0.05993192f, 0.20338656f, 
    0.16287388f, 0.26545620f, 0.04840568f, 0.39538822f, -0.04516392f, -0.03255282f, 0.05206784f, 0.04045245f, 
    -0.03563993f, -0.01098752f, 0.05675727f, 0.06268283f, 0.12562348f, 0.15255328f, -0.14619519f, -0.11198512f, 
    -0.12744792f, 0.00573486f, 0.13871334f, -0.25626808f, -0.10581221f, -0.09003079f, -0.23169044f, -0.24080786f, 
    -0.34891772f, -0.02370055f, 0.11603614f, -0.09461310f, -0.08861986f, 0.00615702f, 0.03509666f, 0.23314734f, 
    0.08508113f, 0.04310599f, 0.21938030f, -0.00735320f, -0.06376874f, -0.29333526f, -0.13818102f, -0.09359423f, 
    0.06698818f, 0.01870568f, -0.06100752f, 0.12465265f, 0.20292410f, 0.12650634f, -0.07105225f, 0.10858221f, 
    0.30996141f, 0.05687255f, -0.07794196f, 0.06691351f, 0.11835659f, 0.09071122f, 0.07681350f, 0.17554471f, 
    0.08836640f, -0.01087785f, 0.06789495f, -0.00193618f, -0.11964440f, -0.11937267f, -0.05498033f, -0.05950305f, 
    -0.06310581f, 0.05808373f, 0.03182472f, 0.13923791f, 0.01215049f, 0.03244833f, 0.05429169f, 0.14099728f, 
    -0.34072733f, -0.25862998f, 0.06454364f, -0.25186673f, 0.14741409f, -0.09122346f, 0.21903513f, 0.16370779f, 
    0.08329101f, -0.02412261f, 0.04486040f, 0.17165568f, -0.08939505f, 0.29103670f, -0.04465738f, -0.02466535f, 
    -0.21722201f, 0.02528426f, 0.03427485f, -0.06527964f, 0.08534646f, -0.16955587f, 0.04538482f, -0.00949469f, 
    0.54147935f, -0.02857313f, -0.05229471f, -0.06543407f, 0.02292508f, 0.07623921f, 0.21422337f, -0.18952584f, 
    -0.10228610f, 0.03375280f, 0.03302054f, -0.02269842f, 0.43613815f, 0.10592804f, 0.03779961f, 0.14960082f, 
    0.11809851f, 0.03842710f, 0.02879659f, 0.06731157f, 0.02106113f, 0.09225138f, 0.14207381f, 0.01845128f, 
    -0.13832651f, -0.33934215f, -0.02710306f, 0.02948660f, 0.02800979f, 0.03101327f, -0.00692977f, -0.04958949f, 
    -0.02778107f, -0.07157776f, 0.01788094f, -0.02173047f, -0.09847607f, -0.00741180f, 0.30465952f, 0.14692110f, 
    -0.08180790f, -0.15149911f, 0.02557678f, 0.08382555f, 0.10924105f, 0.08142402f, -0.04261543f, 0.09905581f, 
    0.14895332f, 0.11920124f, 0.01954906f, 0.27059072f, 0.10557266f, 0.06897958f, 0.08624513f, -0.12147823f, 
    0.05015832f, 0.09870024f, -0.03671362f, -0.04958755f, -0.06275639f, 0.09678923f, -0.06232042f, -0.23162054f, 
    -0.08297228f, -0.02180169f, -0.09722190f, -0.03784214f, -0.03530798f, -0.06729127f, 0.08304756f, 0.01744835f, 
    0.04335478f, 0.23809685f, 0.01558236f, 0.24346358f, -0.04419348f, 0.00793904f, -0.03125427f, -0.07822952f, 
    0.04381381f, 0.12043989f, -0.03547877f, 0.11184214f, 0.20922680f, 0.11464136f, 0.26428503f, 0.23137091f, 
    -0.29757169f, -0.04568938f, 0.13421719f, -0.03680774f, -0.13229878f, 0.13425553f, -0.11529427f, 0.22487965f, 
    0.31191596f, -0.12495369f, -0.11398873f, 0.12429083f, -0.02829804f, -0.07270911f, 0.03255206f, 0.03347714f, 
    0.05503364f, -0.04154965f, -0.15345576f, 0.00618944f, -0.21682724f, 0.17861058f, 0.05230509f, 0.17883430f, 
    -0.04980185f, -0.02194093f, 0.14562723f, 0.06407269f, -0.00715223f, -0.12355641f, 0.03147160f, 0.09999983f, 
    -0.00806747f, 0.25992402f, -0.35081527f, -0.13788591f, 0.12121041f, 0.05837601f, -0.00576452f, -0.09744951f, 
    -0.06753793f, 0.06577883f, -0.03789172f, -0.06211602f, -0.13931069f, 0.13445134f, 0.00264604f, -0.18160284f, 
    -0.01251792f, -0.00512193f, -0.00080221f, -0.05802699f, -0.09390834f, -0.01119362f, 0.01175967f, -0.11295014f, 
    0.23509388f, 0.26776680f, 0.19399887f, 0.22345106f, -0.08128596f, -0.07668319f, -0.10278133f, 0.08108165f, 
    -0.02185196f, 0.00789977f, 0.05576492f, -0.21826483f, 0.02281795f, -0.22205259f, -0.11313648f, 0.29060832f, 
    -0.00635508f, 0.06446014f, -0.17020747f, -0.02274760f, 0.04774413f, -0.01651397f, -0.05056919f, -0.10285223f, 
    -0.05656572f, -0.00539918f, -0.10392727f, -0.05445817f, -0.03137549f, 0.00614093f, -0.02230946f, -0.08070368f, 
    0.16598175f, 0.04155304f, -0.05583503f, -0.00290662f, 0.04503432f, 0.00910426f, 0.31604633f, -0.19832695f, 
    -0.14386183f, 0.05668431f, 0.05844372f, 0.17484328f, -0.02216233f, 0.09059192f, -0.05296947f, 0.07596190f, 
    0.08365494f, 0.43177497f, -0.27750149f, 0.34356970f, -0.05090246f, 0.10739692f, 0.02768106f, 0.10476967f, 
    0.02254991f, 0.02403938f, 0.15182123f, 0.02323850f, 0.04844008f, 0.18849246f, -0.24083713f, -0.06481217f, 
    0.13704385f, -0.07471976f, -0.11259489f, -0.11675040f, 0.23829170f, -0.02499896f, -0.04649770f, -0.06322920f, 
    0.05394918f, 0.17836954f, -0.24008407f, 0.26832023f, 0.01779316f, -0.00381896f, 0.07640557f, -0.04832517f, 
    0.06311741f, 0.01925210f, 0.19800209f, 0.07582643f, 0.10736899f, 0.27758855f, 0.18879548f, 0.17068894f, 
    0.11312547f, 0.03917364f, 0.06079869f, -0.01873950f, -0.13602771f, -0.08832441f, 0.11322213f, 0.03319647f, 
    -0.15756851f, -0.05304511f, -0.03343240f, -0.08954760f, 0.00291692f, 0.11330370f, 0.01331871f, 0.04322889f, 
    0.01733308f, 0.02862519f, 0.04365630f, -0.09186248f, 0.22911912f, -0.23509993f, -0.02544038f, -0.20167720f, 
    0.12277252f, -0.18636943f, -0.02133995f, -0.06207931f, 0.09246251f, -0.01746070f, -0.06052249f, -0.10749545f, 
    0.37721789f, -0.14834015f, 0.08398731f, 0.45682627f, -0.10627533f, -0.06391507f, -0.02850005f, 0.15372302f, 
    0.02715176f, 0.14699584f, 0.08546630f, -0.06784949f, 0.35873327f, 0.35804629f, -0.01709649f, -0.22706047f, 
    0.00287736f, -0.00905431f, -0.08361425f, 0.13203035f, 0.05762612f, -0.15311046f, 0.09054658f, -0.04003168f, 
    -0.27208778f, 0.20709129f, 0.15042986f, -0.08886182f, 0.04543997f, 0.20752871f, -0.04283200f, -0.04605131f, 
    -0.06028580f, 0.11702383f, 0.17003885f, 0.04872103f, 0.31850746f, 0.00169917f, 0.35605472f, 0.19246669f, 
    0.02149166f, -0.09279141f, 0.16008988f, 0.24656078f, 0.08861902f, 0.12846702f, 0.02910619f, -0.10383755f, 
    0.14755870f, -0.21436062f, -0.29617360f, -0.08972234f, 0.05026162f, 0.03142592f, 0.00997273f, -0.01120022f, 
    0.18292938f, -0.07636770f, -0.24880973f, 0.05994889f, 0.31512126f, -0.27191928f, -0.20693976f, 0.29897571f, 
    0.07841586f, 0.05695486f, -0.06276128f, 0.02883963f, 0.00757359f, 0.13017726f, 0.15976770f, 0.14561352f, 
    0.31650931f, 0.04619658f, 0.35923424f, 0.22300500f, -0.14587757f, -0.16824675f, 0.12365758f, 0.22189873f, 
    -0.03755350f, -0.02585022f, 0.02360186f, 0.02428759f, -0.01632351f, -0.13409883f, 0.04308315f, 0.10473979f, 
    0.14052834f, 0.06108335f, -0.20137307f, -0.10288471f, 0.05860582f, -0.10340380f, 0.07385770f, 0.03110348f, 
    0.06204745f, -0.25720647f, 0.27801982f, -0.15335318f, 0.04282783f, -0.23655772f, 0.15849926f, -0.07120121f, 
    -0.16541104f, -0.02426030f, 0.08697870f, 0.05263277f, 0.14722565f, 0.00095832f, -0.06076910f, 0.29549000f, 
    -0.05510208f, 0.06405140f, -0.04415433f, 0.22169295f, 0.04976259f, -0.01371549f, 0.15237802f, -0.04167146f, 
    -0.29719302f, 0.21708876f, 0.39526400f, -0.21941352f, 0.01025768f, -0.18644086f, -0.03829324f, 0.16693632f, 
    0.03775499f, 0.01259100f, 0.01184616f, 0.00227014f, 0.22905360f, 0.06863217f, -0.01386160f, -0.24225521f, 
    -0.00197152f, -0.02077940f, 0.10163220f, 0.01441323f, 0.13791843f, 0.28326178f, -0.16282642f, -0.10483904f, 
    -0.21742520f, -0.23572022f, 0.19955094f, -0.41732970f, 0.07014536f, -0.05406889f, 0.11281738f, -0.01405644f, 
    -0.03431635f, 0.10291721f, 0.06946132f, 0.02900910f, 0.31139749f, 0.00290117f, 0.18130863f, 0.25300154f, 
    -0.13407898f, -0.04000834f, -0.00620167f, 0.05414957f, 0.14225052f, 0.05840652f, -0.15987489f, -0.11500101f, 
    -0.32250068f, -0.25124231f, -0.27543935f, 0.20858541f, 0.04695714f, 0.07276231f, -0.16820100f, -0.02125344f, 
    0.19207300f, -0.01501296f, -0.06798364f, -0.01291963f, -0.13159564f, -0.16293140f, -0.09999600f, 0.24981758f, 
    0.01593797f, 0.14793231f, -0.04452822f, -0.14725702f, -0.02041622f, 0.09966209f, 0.04813473f, -0.13001643f, 
    -0.06186210f, 0.02799015f, 0.04874488f, 0.01379357f, -0.01581085f, 0.03120086f, 0.02694049f, 0.05321898f, 
    -0.01260371f, 0.06716913f, -0.00712891f, 0.00974155f, 0.01835700f, -0.07013582f, 0.01282887f, -0.06146323f, 
    -0.01722973f, 0.04195912f, 0.01241831f, -0.03462579f, -0.04484455f, -0.03901746f, -0.03821019f, 0.02048686f, 
    -0.06260169f, -0.07213761f, -0.05049869f, -0.05006701f, -0.03629959f, -0.00504202f, 0.06374246f, 0.06432920f, 
    0.06712731f, -0.03709498f, 0.03487480f, -0.04299190f, 0.01041437f, 0.01379051f, 0.05458068f, -0.02253953f, 
    0.03318826f, -0.06068019f, -0.03160689f, -0.02667723f, -0.07162790f, -0.07554486f, -0.01781153f, -0.06883056f, 
    -0.07142433f, -0.07197727f, -0.07571882f, 0.03592406f, 0.00636450f, -0.02651082f, 0.05564693f, 0.04077332f, 
    0.01184004f, 0.01749961f, -0.05428186f, 0.04340795f, -0.00371400f, -0.01818071f, -0.06871947f, -0.02564768f, 
    0.05374557f, -0.00341955f, 0.05758566f, -0.03723044f, -0.04748357f, -0.02604077f, 0.03694334f, 0.02275636f, 
    0.03916766f, -0.05006149f, -0.00230064f, -0.07350695f, -0.00710835f, 0.03893847f, -0.00831178f, -0.06999410f, 
    -0.05603782f, -0.01748839f, -0.02902824f, 0.00882365f, -0.03219360f, 0.05146855f, -0.06284934f, -0.02947950f, 
    -0.00208221f, -0.00880784f, 0.03310934f, -0.03971409f, 0.01987377f, -0.02409815f, 0.05752532f, 0.02457377f, 
    0.03139706f, 0.01134728f, -0.05044470f, 0.00264737f, -0.06489559f, -0.00567684f, -0.05424346f, -0.05199407f, 
    0.01640938f, -0.07697823f, 0.02080546f, -0.04890393f, -0.05645347f, -0.06775812f, -0.02766111f, -0.05743096f, 
    -0.00466917f, 0.00505458f, -0.01349918f, -0.06860770f, -0.05274887f, 0.04290315f, 0.05072251f, -0.06748982f, 
    0.05097722f, 0.04904053f, -0.02784705f, -0.03407036f, 0.06974376f, -0.06008108f, -0.03291364f, 0.04465602f, 
    -0.06933097f, -0.00523132f, -0.01749793f, 0.02929468f, 0.03732634f, 0.05965080f, -0.01623355f, -0.03733448f, 
    -0.05390742f, -0.04569427f, -0.03846454f, 0.00898711f, -0.07229847f, -0.07519401f, 0.01260331f, -0.06128539f, 
    -0.01400349f, -0.03748717f, 0.06471101f, 0.02569448f, 0.06764766f, -0.02210428f, 0.00561848f, 0.07063766f, 
    -0.03721780f, -0.06932357f, 0.04527426f, -0.06274348f, -0.04773549f, -0.01786922f, -0.02508942f, 0.06228642f, 
    0.03090047f, 0.01828798f, -0.00565299f, -0.01640965f, 0.05814775f, 0.04311988f, 0.04227420f, 0.02047480f, 
    0.02124136f, -0.06242328f, -0.01380469f, 0.04284824f, -0.01451157f, -0.03913013f, 0.01883120f, -0.06662107f, 
    -0.03866360f, 0.04597973f, 0.03643154f, 0.05865380f, -0.04521058f, 0.05029225f, -0.04622771f, -0.07320537f, 
    -0.05885053f, -0.03356640f, -0.05887584f, 0.01697601f, -0.00728822f, -0.01948281f, 0.05826857f, -0.02877369f, 
    0.21905860f, -0.05114909f, -0.03750647f, -0.03204174f, 0.19310182f, -0.04618376f, -0.00390854f, 0.05746556f, 
    0.05586167f, 0.00590592f, 0.07428622f, 0.06527844f, -0.12313930f, 0.25155893f, 0.26369077f, -0.10888524f, 
    0.04478676f, -0.09135804f, 0.04424910f, -0.03955061f, -0.02635812f, 0.04708484f, -0.05691165f, -0.09687105f, 
    -0.24372269f, -0.39067629f, -0.14733191f, 0.18638599f, -0.14278869f, -0.06463207f, 0.03916373f, -0.00177886f, 
    -0.02540192f, -0.02720963f, 0.11157054f, 0.03251413f, 0.00467978f, -0.07171728f, 0.02263008f, 0.07803248f, 
    0.02270750f, -0.07885620f, 0.09674150f, 0.01648224f, 0.04337448f, 0.21908730f, -0.10357447f, 0.17600735f, 
    0.61256093f, 0.02696052f, -0.15758507f, -0.13875142f, -0.16722395f, -0.21429023f, 0.00628001f, 0.02513256f, 
    0.02705748f, -0.12273307f, 0.00885186f, 0.01616249f, 0.63662195f, -0.25600702f, 0.13889891f, 0.20280528f, 
    -0.01081367f, -0.03436262f, -0.08468168f, 0.06395987f, -0.10076259f, 0.08422893f, 0.03154771f, -0.02913228f, 
    0.07344338f, 0.22278404f, 0.13154250f, 0.20245902f, 0.07286485f, -0.02497787f, -0.00261673f, 0.23642452f, 
    -0.15740582f, -0.02816812f, 0.02252532f, 0.07252838f, 0.35683191f, 0.02124767f, 0.32692873f, 0.34700662f, 
    0.08905100f, 0.08584676f, 0.09400506f, -0.04698041f, 0.02232758f, 0.03795073f, 0.06585564f, 0.19722359f, 
    0.02336719f, -0.05499179f, 0.14148381f, -0.33222467f, -0.07944038f, -0.14576270f, -0.03132254f, -0.02025372f, 
    -0.21165030f, 0.02129980f, 0.10220998f, -0.01935416f, -0.16189729f, -0.09070134f, 0.06058026f, -0.15404437f, 
    -0.16872180f, 0.03410678f, 0.00123191f, 0.09533195f, -0.10355593f, -0.15595718f, 0.01883597f, -0.13806836f, 
    0.06932310f, 0.11701524f, 0.07475521f, 0.02942834f, 0.16392596f, -0.08051957f, 0.04768111f, 0.00717566f, 
    0.05693459f, 0.17005651f, -0.03321975f, -0.03494017f, -0.21822414f, 0.04776538f, 0.01155558f, 0.00225436f, 
    -0.10463575f, -0.09850335f, 0.07094169f, -0.06478038f, 0.03458726f, 0.03414290f, -0.01630442f, 0.15084659f, 
    0.14837421f, -0.18802267f, -0.29212338f, -0.28561223f, 0.00115803f, -0.02180282f, 0.14248848f, 0.15788488f, 
    0.05892223f, -0.13036464f, 0.05435900f, -0.18037805f, 0.00223603f, 0.07047439f, 0.08650308f, 0.07102133f, 
    0.09809998f, 0.03168583f, 0.02977443f, 0.13545011f, 0.21455371f, 0.02162829f, -0.16758691f, 0.12423114f, 
    0.00074504f, 0.37356895f, -0.15657918f, 0.23736170f, -0.07708643f, 0.06856982f, -0.01524017f, -0.04085741f, 
    -0.07964396f, -0.15207812f, 0.10520221f, -0.02854269f, 0.44405621f, 0.16837871f, 0.22348921f, 0.14117992f, 
    0.04005697f, 0.11784314f, 0.13428932f, 0.11471603f, 0.02466374f, -0.04184774f, 0.06399950f, -0.10012118f, 
    -0.35268703f, 0.02257526f, 0.00908654f, 0.37633815f, -0.04204279f, 0.01621054f, 0.03448203f, -0.00994370f, 
    0.24304554f, -0.00946058f, -0.17329678f, -0.07901184f, 0.44565618f, -0.21104230f, -0.08859596f, 0.37317336f, 
    -0.16964209f, -0.16363302f, 0.00924271f, 0.02789775f, -0.02462150f, -0.04997654f, 0.02508311f, 0.01052034f, 
    0.42013210f, -0.08841109f, 0.13753539f, -0.17495696f, 0.19913426f, 0.00520408f, -0.05800464f, 0.00057731f, 
    0.05804596f, 0.04181852f, 0.07598250f, 0.18297602f, -0.38487756f, 0.13845468f, 0.00372351f, 0.25561637f, 
    0.07148843f, -0.01463189f, -0.14877810f, 0.26215023f, 0.05612192f, -0.15006121f, 0.09452590f, 0.05913318f, 
    -0.48047271f, 0.26890478f, 0.09388892f, 0.07032484f, 0.22950594f, 0.30239928f, 0.22175747f, -0.25394559f, 
    -0.07112183f, -0.09297660f, -0.00431193f, 0.01920946f, -0.34580964f, 0.20077389f, 0.05180688f, -0.30069312f, 
    0.13954170f, 0.12530157f, 0.11109427f, -0.14500512f, 0.06802838f, 0.00470358f, 0.12216803f, 0.02232160f, 
    -0.31043005f, -0.31165186f, 0.21776326f, 0.11182260f, -0.13170752f, -0.09769857f, -0.13880230f, -0.01805883f, 
    0.13294621f, 0.02033281f, 0.13239135f, -0.10794462f, -0.01362861f, 0.14947651f, -0.16741228f, -0.13647704f, 
    0.22061628f, -0.01156556f, -0.11341984f, -0.08324809f, -0.00966393f, 0.03039675f, -0.09453364f, -0.02588249f, 
    0.27154791f, 0.46002972f, -0.01581694f, 0.23342423f, 0.02643541f, 0.19438174f, 0.08319285f, -0.03187091f, 
    0.19375159f, 0.02329263f, -0.07891617f, 0.01072095f, 0.06087966f, -0.10346529f, 0.14141445f, 0.02150503f, 
    0.12332863f, -0.05465680f, -0.03164030f, 0.07600204f, 0.11448489f, 0.05233457f, 0.05659173f, 0.17810315f, 
    -0.10714890f, -0.01811355f, -0.03796548f, 0.23900062f, -0.02693181f, -0.00186415f, -0.04577976f, 0.11578447f, 
    0.00498169f, -0.11772925f, 0.21529140f, -0.02668407f, -0.20478556f, -0.18367074f, -0.25228876f, 0.03150662f, 
    0.08438350f, 0.02600550f, -0.05989945f, 0.03393912f, 0.15846139f, -0.01858474f, 0.02526497f, -0.03436718f, 
    -0.15293361f, 0.35206583f, 0.09140058f, 0.09898613f, 0.07245860f, 0.10301318f, 0.03931378f, 0.03665485f, 
    0.15618074f, 0.18118250f, 0.07998683f, 0.05199625f, -0.09874161f, -0.04470630f, -0.09283353f, 0.09372935f, 
    0.08443981f, -0.01884809f, -0.01151680f, -0.04330491f, -0.16431764f, -0.06662710f, 0.07690235f, -0.08407614f, 
    -0.37863758f, -0.27754599f, -0.00931983f, -0.20480667f, 0.08536177f, 0.13222152f, 0.02825674f, 0.12205353f, 
    -0.02209861f, 0.24944130f, 0.10194840f, -0.07652339f, -0.07398639f, -0.02571972f, -0.02673846f, -0.34789628f, 
    0.32855073f, -0.12033516f, -0.08629382f, -0.02181044f, 0.10299028f, 0.04286683f, -0.03896991f, -0.01390206f, 
    0.02804320f, -0.09871797f, -0.08233519f, -0.07815108f, 0.05476872f, 0.03720672f, -0.06832989f, -0.02607165f, 
    0.06139316f, -0.02645375f, -0.03024937f, -0.06775777f, 0.23793182f, 0.05082276f, 0.00543792f, 0.00227214f, 
    0.01234194f, -0.11232981f, -0.08716520f, 0.01904951f, 0.11707973f, 0.11020104f, 0.05657550f, 0.02858287f, 
    0.22816809f, 0.14807104f, -0.26337290f, -0.12613958f, 0.01949070f, 0.08742028f, 0.00141255f, 0.02921936f, 
    -0.06315677f, 0.15575103f, 0.28491971f, 0.05885024f, 0.18830518f, 0.10621537f, 0.16734232f, 0.06977889f, 
    0.10612748f, -0.20186809f, 0.06081952f, 0.05786802f, 0.09617589f, 0.05699381f, -0.21311814f, -0.00915318f, 
    0.06870161f, 0.03473389f, -0.01333638f, 0.10549463f, 0.23519325f, 0.11227161f, 0.22012618f, 0.06848799f, 
    -0.02967488f, 0.07542983f, 0.11200650f, 0.02688714f, 0.17669950f, -0.28786162f, -0.03361778f, 0.27792308f, 
    0.12277659f, 0.08656286f, -0.00410259f, 0.08791645f, 0.10625548f, 0.23149832f, 0.09979257f, 0.07890806f, 
    -0.22177821f, 0.01016037f, -0.00789448f, -0.04278484f, -0.23904873f, -0.05128342f, -0.04114173f, 0.11174848f, 
    0.12400705f, -0.05917704f, 0.09737767f, 0.17064138f, 0.27543813f, 0.10922328f, 0.03522803f, 0.03575052f, 
    0.23584267f, -0.04561419f, -0.00084867f, 0.01597941f, 0.16481443f, 0.02277805f, -0.04813050f, 0.20909227f, 
    0.32097581f, 0.37926054f, 0.06446638f, 0.07397389f, 0.15085144f, -0.06185872f, 0.24197623f, -0.02483433f, 
    -0.02989131f, -0.01696623f, 0.23190849f, 0.15788087f, 0.23897037f, -0.33495906f, 0.19299293f, 0.18300131f, 
    0.02232602f, 0.06682312f, -0.00531726f, 0.06014319f, 0.04877228f, -0.08592175f, 0.01259274f, 0.02506531f, 
    0.01926755f, -0.00154194f, -0.01128957f, -0.17034946f, -0.08889347f, 0.00594846f, -0.02616090f, 0.02127999f, 
    -0.07664502f, -0.09615033f, -0.01009696f, -0.04645204f, -0.23969910f, -0.00402672f, -0.04205082f, -0.22198041f, 
    0.20911106f, 0.03879654f, 0.06363876f, 0.06778448f, 0.02428447f, 0.12872508f, 0.09694193f, 0.04255972f, 
    -0.15452290f, -0.05276085f, 0.03076585f, -0.29418752f, -0.00323612f, 0.08066904f, -0.10766837f, 0.22411911f, 
    0.21790458f, -0.06922523f, -0.02464182f, -0.17251141f, 0.29873288f, -0.14872944f, -0.13150686f, -0.15450120f, 
    -0.03523953f, 0.00636968f, 0.04201148f, 0.13365936f, 0.18937522f, 0.10633083f, 0.01472566f, 0.09816080f, 
    -0.38181221f, -0.05169297f, 0.00362244f, 0.00774428f, 0.08312356f, 0.02634288f, -0.14764601f, -0.01003330f, 
    -0.06676051f, 0.02035413f, 0.29461020f, 0.06127955f, 0.01251978f, 0.10947957f, 0.09331906f, 0.14998652f, 
    0.17078514f, 0.02267473f, -0.05642066f, 0.12994748f, -0.01560635f, 0.00407772f, 0.12573253f, -0.10518777f, 
    -0.46045914f, 0.11984670f, 0.11044639f, -0.07821140f, 0.16072981f, -0.07475695f, 0.08038937f, 0.13992640f, 
    0.06700893f, -0.06963027f, 0.03592255f, 0.07302047f, -0.16686355f, 0.08784390f, -0.04075755f, 0.21152367f, 
    -0.05208626f, 0.09730642f, 0.16498624f, 0.05786181f, 0.10988133f, 0.09434876f, 0.06387987f, 0.03210600f, 
    -0.30421144f, -0.23709410f, 0.31673515f, -0.01877519f, -0.11887672f, -0.11070465f, 0.07376906f, -0.01043940f, 
    0.15306893f, 0.09153537f, -0.12469660f, 0.20109372f, -0.44636497f, -0.01634512f, -0.06566136f, 0.00040798f, 
    0.07156027f, 0.13474594f, -0.07642218f, -0.08202228f, 0.01155438f, -0.06856716f, 0.11522181f, 0.09598683f, 
    0.09367503f, -0.19080828f, 0.22895496f, 0.27744216f, -0.04472246f, 0.04897537f, -0.19379054f, -0.20789276f, 
    0.07271782f, 0.06976531f, 0.08454078f, 0.00831772f, -0.09788364f, 0.26095158f, 0.15559283f, 0.00609186f, 
    0.02576738f, -0.01181686f, 0.11248636f, 0.01334631f, 0.14267159f, -0.12350942f, -0.07376395f, 0.00667222f, 
    -0.22911538f, -0.01755916f, -0.04797108f, 0.03619756f, 0.19370013f, 0.18001708f, 0.07916931f, -0.12544715f, 
    -0.01709710f, 0.07282584f, -0.04685219f, -0.11194430f, -0.26801908f, 0.10671752f, 0.12823585f, -0.05831354f, 
    0.06635064f, 0.06551360f, 0.16970441f, 0.17478400f, -0.05214273f, 0.12676042f, 0.03348501f, 0.05887364f, 
    0.04874680f, 0.02685240f, -0.15863065f, 0.10155485f, 0.12556127f, 0.22978325f, -0.19835033f, -0.11598322f, 
    0.16079263f, 0.01381758f, -0.25481272f, 0.08071658f, -0.28581160f, 0.30279884f, -0.12945466f, -0.07616213f, 
    0.06899880f, 0.07834598f, -0.04186625f, -0.07119153f, 0.11237291f, 0.11858317f, -0.05537571f, 0.03628223f, 
    -0.00425667f, -0.13453273f, -0.12011437f, 0.17825842f, 0.16333318f, -0.00426051f, 0.19052948f, -0.06439825f, 
    0.16185790f, 0.03634815f, 0.10608509f, 0.04415710f, -0.08276611f, -0.14358431f, 0.08903240f, 0.32997575f, 
    -0.30283850f, -0.01338352f, -0.07749525f, 0.04994248f, 0.01990772f, -0.11703178f, 0.10710979f, 0.23883940f, 
    0.13188720f, 0.00644509f, 0.03141603f, 0.15087231f, -0.00860611f, 0.05136504f, 0.08776332f, 0.01205469f, 
    -0.00676568f, 0.00323884f, -0.02213412f, 0.10617730f, -0.70685261f, 0.26486439f, -0.04934430f, 0.01733173f, 
    0.15442678f, -0.02776535f, -0.05323830f, -0.06926801f, 0.01832460f, -0.13113442f, 0.07558578f, 0.00497587f, 
    0.29486087f, -0.12736587f, 0.22589195f, -0.03192437f, 0.04124129f, -0.08221663f, 0.00022361f, 0.10191099f, 
    -0.13677305f, 0.05632753f, 0.02656932f, 0.05485510f, 0.19199665f, 0.04562465f, 0.16552444f, 0.15203553f, 
    0.09228557f, -0.05951546f, 0.00685986f, 0.10350161f, 0.12410658f, 0.09199619f, 0.10480630f, 0.22684366f, 
    0.25116199f, -0.24256015f, 0.13822003f, -0.19438076f, 0.05231554f, -0.13492119f, 0.06853613f, -0.10641369f, 
    0.06813577f, 0.04807074f, 0.08732212f, 0.20491724f, -0.33391610f, -0.02362342f, -0.00173350f, -0.07657095f, 
    0.02953199f, 0.00964879f, 0.10804105f, 0.18934333f, -0.06817439f, 0.03942408f, -0.20430616f, 0.05471581f, 
    -0.14002703f, 0.05123147f, 0.10900346f, 0.08587252f, 0.07199581f, 0.20787437f, 0.01537023f, 0.09099278f, 
    0.01546521f, -0.04482788f, -0.07700503f, -0.11773922f, -0.01445347f, -0.45013401f, 0.08734763f, -0.09589935f, 
    -0.21357539f, -0.01147741f, -0.06590644f, -0.20993847f, 0.00917838f, 0.16700485f, 0.02107805f, 0.15294248f, 
    0.10550204f, -0.18174776f, 0.10652040f, 0.00488938f, 0.08721168f, 0.10795009f, 0.06322715f, 0.19317223f, 
    -0.09731173f, -0.03164605f, 0.06473517f, 0.15888563f, 0.25317642f, 0.04475451f, 0.13181774f, -0.04681602f, 
    -0.12152494f, 0.04035198f, 0.00215113f, 0.11519163f, 0.00253590f, -0.07800093f, 0.10091664f, -0.04242596f, 
    0.03302552f, 0.37290418f, -0.34861505f, -0.15002397f, -0.29621628f, -0.17718799f, -0.17925192f, -0.10221305f, 
    -0.11041095f, 0.09303804f, -0.08463984f, 0.07608010f, 0.15566222f, -0.08190475f, 0.26681626f, 0.07574621f, 
    0.08975962f, 0.04904110f, 0.15435125f, 0.06492698f, -0.06124200f, -0.10883646f, 0.08483525f, -0.16468571f, 
    -0.29762116f, -0.16569060f, -0.19558451f, 0.29473728f, 0.01578473f, -0.07049002f, -0.00784975f, 0.14886291f, 
    0.04166267f, -0.04062755f, -0.01612113f, -0.13667676f, 0.30069977f, -0.07119015f, -0.20528510f, 0.04671043f, 
    -0.26491871f, -0.00011030f, -0.14096794f, 0.09622185f, -0.00087293f, 0.06120439f, 0.03378101f, -0.00379403f, 
    -0.25037658f, -0.01528279f, -0.41200036f, 0.20609576f, -0.17550968f, 0.10566961f, 0.04218043f, -0.16085133f, 
    0.06565104f, 0.11802465f, -0.03765508f, -0.06889191f, 0.34119108f, 0.15205723f, 0.15663671f, 0.07589956f, 
    0.05514432f, 0.15474153f, -0.00231822f, 0.01946341f, 0.03558431f, -0.01995502f, 0.06159461f, 0.11388897f, 
    0.42609325f, -0.31307194f, -0.35135287f, 0.36168769f, 0.05039993f, 0.11361349f, 0.07148990f, 0.18209788f, 
    0.05420042f, 0.20164312f, -0.12445596f, 0.16158617f, 0.44132319f, -0.17148118f, -0.16628437f, 0.07643161f, 
    -0.08740234f, 0.02568153f, 0.14055382f, 0.04058932f, 0.04845431f, -0.04485558f, 0.05696664f, 0.03938071f, 
    0.08073179f, 0.15352559f, 0.19875425f, -0.09415955f, -0.08539643f, 0.06431813f, 0.10592972f, 0.00665638f, 
    0.01007409f, -0.10869275f, -0.14650682f, 0.06348778f, 0.15963583f, -0.01813206f, 0.19465528f, 0.02986125f, 
    -0.04229810f, 0.26532859f, 0.23727295f, 0.24215448f, 0.08924229f, 0.05520440f, 0.05993553f, 0.26495937f, 
    -0.14650507f, 0.02112003f, -0.43757278f, 0.20890273f, 0.05195968f, 0.27292573f, 0.02516317f, 0.09494565f, 
    -0.04587962f, 0.11187868f, 0.04667325f, 0.10853441f, 0.01508038f, -0.04389367f, 0.36507773f, -0.24399546f, 
    0.16271195f, 0.21474053f, 0.00907007f, -0.17158167f, 0.08346768f, -0.08902030f, -0.02096786f, -0.02737898f, 
    0.14150578f, 0.07503954f, 0.10850733f, 0.46378994f, -0.02322646f, 0.13897899f, -0.12521444f, 0.02899204f, 
    -0.03229556f, -0.06393440f, -0.01360843f, 0.08829413f, 0.04426139f, 0.22261068f, -0.46095434f, -0.07430218f, 
    0.17800608f, 0.14223152f, 0.04911844f, 0.01987700f, -0.09024426f, 0.15647639f, 0.04070132f, -0.18999942f, 
    0.05999134f, 0.53567910f, 0.16694851f, -0.07127813f, -0.15910508f, 0.13305961f, 0.17225373f, 0.14253838f, 
    0.02079744f, -0.13587929f, 0.05972379f, -0.11514582f, 0.06928793f, 0.21994121f, -0.01122202f, -0.26237500f, 
    0.04043009f, 0.07242430f, 0.02159858f, -0.14560050f, 0.06617995f, 0.07506108f, -0.16772649f, 0.06749918f, 
    0.12370320f, -0.63297594f, 0.03860235f, -0.13970827f, 0.20486590f, -0.10699350f, -0.10304726f, 0.03659347f, 
    0.40282288f, -0.02568380f, -0.01724050f, -0.13038126f, 0.35015014f, -0.04097249f, 0.08609469f, 0.28232378f, 
    0.01061017f, 0.22245535f, 0.02518140f, 0.11401934f, 0.08905998f, -0.03731127f, -0.03886032f, 0.03714503f, 
    0.57293004f, -0.11276966f, 0.23279828f, -0.04032610f, -0.09799848f, 0.04608304f, 0.18842737f, 0.30171132f, 
    -0.02666956f, 0.01887228f, -0.01596999f, -0.15714958f, -0.30221853f, 0.17888297f, 0.13249545f, -0.17808947f, 
    0.36586323f, 0.00104300f, 0.12572819f, -0.01982706f, 0.06901309f, 0.11531118f, 0.09337258f, 0.09941314f, 
    0.57916880f, -0.28817108f, 0.64139313f, -0.14063488f, 0.05982369f, 0.01531013f, 0.03143806f, 0.03364621f, 
    0.04443753f, 0.02601537f, 0.02771358f, 0.03404438f, 0.05059529f, 0.04544820f, -0.04260180f, 0.47602236f, 
    -0.09356303f, -0.11507931f, 0.00819836f, 0.03517333f, 0.09208043f, 0.08638204f, 0.02044937f, 0.18624608f, 
    0.20178422f, 0.05509450f, 0.25300410f, 0.04825142f, 0.23693332f, -0.05853214f, 0.01927990f, -0.08855692f, 
    -0.02218951f, 0.07097302f, 0.14569797f, 0.14572738f, -0.47934487f, -0.22393836f, -0.18022485f, 0.21394433f, 
    0.20382281f, -0.07027654f, -0.13380729f, -0.17143601f, -0.26125604f, 0.08534755f, -0.08719272f, -0.08928019f, 
    0.50462407f, 0.40943810f, -0.02547636f, 0.23731124f, -0.08204098f, 0.21185891f, 0.07826145f, 0.13703801f, 
    -0.01418957f, -0.14130323f, 0.02654436f, 0.11153521f, -0.02827525f, 0.11529697f, -0.07807217f, 0.04230701f, 
    -0.08218166f, 0.06652336f, 0.01693433f, -0.04888751f, 0.03779268f, 0.05995271f, 0.03949149f, -0.12654409f, 
    -0.07282956f, 0.28329048f, 0.06562905f, 0.25987285f, -0.04811086f, -0.15810262f, 0.04132566f, 0.11342657f, 
    -0.02053438f, 0.20447868f, 0.17114712f, 0.05787811f, -0.16451110f, 0.13168775f, -0.04651384f, 0.11969237f, 
    -0.02223042f, 0.24440293f, 0.11919069f, 0.02529041f, -0.04801009f, -0.09435710f, 0.05517075f, 0.02414896f, 
    -0.32582587f, -0.21811369f, 0.20349154f, 0.15069021f, -0.13616128f, -0.04461347f, 0.01728804f, 0.05457840f, 
    0.09689493f, 0.00787814f, -0.09887887f, -0.02124791f, -0.32145983f, -0.04264407f, -0.01489571f, 0.12700784f, 
    0.09304404f, 0.07426852f, 0.17374784f, 0.07756313f, -0.09209994f, 0.14361538f, 0.09939492f, 0.06662150f, 
    0.48285541f, -0.05606404f, -0.19077626f, -0.05815682f, -0.00276801f, -0.06012034f, -0.13487577f, -0.08682004f, 
    0.20998140f, 0.02952628f, -0.15556866f, -0.08222987f, 0.26439798f, 0.08307263f, -0.11692239f, 0.03200237f, 
    0.05803551f, -0.12815733f, 0.02133007f, 0.13353714f, -0.06548642f, -0.17503835f, 0.05334651f, -0.02304111f, 
    0.27852058f, -0.03061710f, 0.17521197f, 0.21893044f, 0.10650664f, 0.05761262f, 0.03135066f, -0.04121876f, 
    -0.11407468f, 0.02007493f, -0.09616983f, -0.19881117f, -0.10124670f, -0.12741858f, 0.02938512f, 0.12028018f, 
    -0.15887372f, -0.02930496f, -0.17718782f, 0.09577540f, 0.00667740f, -0.07854497f, 0.16137271f, -0.00916330f, 
    0.13378510f, -0.55063355f, -0.03160049f, -0.25178602f, 0.08734132f, -0.02440943f, -0.25918895f, 0.01441282f, 
    0.04579847f, 0.10426293f, -0.04622783f, -0.02326083f, -0.33398134f, 0.24681242f, -0.09216041f, -0.10082972f, 
    -0.04293487f, 0.03792481f, 0.15449879f, 0.14066166f, -0.00957065f, 0.08741543f, -0.08524815f, -0.07561659f, 
    0.10283975f, 0.03425087f, 0.10652904f, 0.12114961f, 0.10593364f, -0.00775139f, 0.07580925f, 0.05313690f, 
    0.10440192f, 0.16214497f, 0.00263248f, 0.08085217f, 0.21761397f, 0.17088883f, -0.03771350f, 0.16687262f, 
    -0.13405207f, 0.00110475f, 0.05820378f, -0.03914422f, 0.15908547f, -0.00457361f, -0.11893202f, -0.02192931f, 
    0.11646675f, -0.03424704f, -0.16044271f, -0.02312756f, 0.02808001f, 0.04316045f, 0.13064925f, -0.26384488f, 
    0.02020364f, 0.11010838f, 0.10666613f, 0.02995646f, -0.41327581f, 0.32973835f, 0.13701661f, 0.18446951f, 
    0.10357957f, -0.09111083f, -0.02997827f, -0.14773944f, -0.05504322f, -0.23545288f, 0.04429977f, -0.00476025f, 
    0.09898239f, -0.14626986f, -0.01783211f, -0.16337137f, -0.08394849f, -0.04938664f, -0.12185536f, 0.02862799f, 
    0.17922150f, -0.04589017f, -0.07320087f, -0.04265576f, 0.34080297f, -0.11848925f, -0.00928856f, -0.08014069f, 
    0.14879958f, -0.13433819f, 0.07851946f, -0.03864969f, 0.01435979f, 0.10334078f, 0.04014013f, 0.00331321f, 
    -0.04351278f, 0.10558759f, -0.00356385f, 0.05246906f, -0.02705592f, -0.13808587f, -0.04942813f, 0.07734095f, 
    -0.12970851f, 0.31404084f, -0.01259006f, 0.04196711f, 0.13869576f, -0.04782682f, 0.07311859f, -0.09535000f, 
    0.04810265f, 0.17418042f, 0.07450902f, 0.01858643f, 0.00928509f, -0.08828263f, -0.03809891f, -0.14080001f, 
    -0.30675799f, 0.10427832f, 0.03048155f, -0.04312746f, 0.01525626f, 0.15079725f, -0.02769525f, 0.05776828f, 
    0.06209796f, 0.12544905f, -0.02352120f, -0.09416997f, 0.02347125f, 0.06735355f, -0.04492366f, -0.06111351f, 
    0.14870667f, 0.00902024f, 0.11700346f, 0.05112449f, 0.04540641f, 0.16128322f, 0.24332716f, -0.05612721f, 
    0.64491534f, 0.23796658f, -0.31730500f, -0.05950513f, 0.06610238f, 0.04944051f, -0.14587390f, 0.01665626f, 
    -0.04426093f, 0.01702986f, -0.15060748f, 0.14381385f, 0.33251664f, -0.16615741f, -0.11592586f, 0.55591583f, 
    0.08301219f, 0.03574138f, -0.03485570f, -0.02233025f, -0.08846646f, 0.00989006f, 0.07101671f, 0.12088823f, 
    0.13088028f, -0.27824745f, -0.01326260f, -0.29736757f, -0.05582851f, -0.03886482f, -0.01034754f, 0.02778075f, 
    0.08976992f, 0.00255745f, -0.09987420f, -0.02659149f, 0.45353141f, 0.05572035f, 0.05090839f, 0.21608922f, 
    0.06378926f, 0.11550921f, -0.11950376f, 0.02524253f, 0.18597409f, -0.02055070f, -0.09531408f, -0.20033091f, 
    0.42977732f, -0.16219950f, 0.05014766f, -0.04238454f, 0.06542313f, 0.00484241f, -0.05823298f, 0.05568183f, 
    -0.07260083f, -0.06807983f, 0.04261489f, 0.03914341f, 0.02884447f, -0.28898746f, -0.05083925f, 0.26407218f, 
    0.15821406f, 0.00914134f, 0.06577991f, 0.17126650f, 0.01845978f, 0.09950668f, 0.00188891f, 0.09776837f, 
    0.23282515f, 0.00424634f, 0.30928081f, -0.33679292f, -0.00027868f, 0.04845754f, -0.21410924f, 0.13552003f, 
    -0.02784885f, 0.06295938f, -0.05124940f, 0.06354266f, -0.19111371f, 0.01116831f, -0.01625744f, -0.11631212f, 
    -0.05573050f, -0.05362711f, 0.03615372f, 0.09202489f, 0.10563484f, 0.15218408f, 0.00264170f, -0.08559018f, 
    0.18262975f, -0.01427713f, 0.10692465f, -0.36408851f, 0.06845345f, -0.09638690f, -0.02103278f, 0.02619346f, 
    -0.09689685f, 0.03195371f, 0.07581282f, 0.09277838f, -0.29247323f, 0.14230531f, -0.05517462f, -0.03856515f, 
    0.06527797f, -0.07558586f, 0.01873573f, -0.11604401f, 0.02347869f, 0.01387216f, -0.04903190f, -0.05009478f, 
    0.25346285f, 0.00805126f, -0.13801013f, 0.18419476f, -0.01659274f, -0.05348575f, -0.04169236f, 0.10891499f, 
    0.18341376f, 0.01059947f, 0.04515526f, 0.07421597f, 0.07156947f, -0.03931136f, -0.08620279f, 0.49508893f, 
    -0.03744681f, -0.00362643f, 0.10441847f, -0.00912869f, -0.12669641f, -0.01267522f, 0.06911052f, -0.23321973f, 
    0.04882263f, -0.05105215f, -0.04744389f, -0.02311978f, -0.06471039f, 0.01885741f, -0.00477109f, -0.02415164f, 
    0.02627387f, 0.00486162f, -0.02631721f, 0.05329477f, 0.05590123f, -0.01504880f, 0.01362697f, 0.00712682f, 
    -0.07779869f, -0.06376336f, -0.06610424f, 0.01543036f, 0.04959526f, -0.05062010f, 0.00181631f, -0.03131441f, 
    0.03356734f, 0.04857168f, -0.03499644f, 0.04505387f, -0.06739988f, 0.01436196f, -0.01261173f, -0.04240236f, 
    -0.06516487f, -0.06684001f, -0.04402403f, -0.07839999f, -0.06269534f, -0.06828103f, 0.00591416f, -0.04656835f, 
    0.00260050f, 0.03299535f, 0.01842635f, -0.07344191f, -0.05265772f, -0.03708222f, -0.04556312f, -0.04249410f, 
    0.00900646f, 0.06395195f, -0.05356066f, -0.01287388f, -0.05084174f, 0.03200701f, 0.01813254f, -0.03093774f, 
    0.01039698f, 0.04868964f, 0.01159917f, -0.01079419f, 0.06199193f, -0.03771992f, -0.04658892f, -0.03624021f, 
    0.04681265f, 0.02643740f, 0.04126309f, 0.01206537f, -0.04403730f, 0.02427140f, -0.06380769f, 0.01834359f, 
    -0.02609825f, -0.02275695f, -0.04264902f, 0.02451822f, 0.03382383f, -0.04889766f, 0.05061423f, 0.03502374f, 
    0.00192176f, -0.02365261f, 0.01278676f, -0.01972008f, 0.05053159f, 0.04069988f, -0.03439963f, -0.03958904f, 
    0.04154066f, -0.05887214f, -0.07968141f, 0.00022535f, -0.04690410f, -0.03806841f, 0.04870830f, -0.00711128f, 
    -0.00185324f, -0.02572071f, 0.05894059f, -0.02735407f, -0.04700932f, -0.07793455f, 0.05169102f, -0.03849969f, 
    -0.00139456f, -0.01699738f, -0.01776549f, 0.03129219f, -0.05055948f, 0.05044482f, -0.01607215f, 0.05746714f, 
    0.03459918f, -0.02589584f, 0.05541686f, 0.02480366f, -0.00507964f, 0.02554569f, 0.00096652f, -0.07793878f, 
    -0.07359603f, -0.04857438f, -0.06395488f, 0.01947892f, 0.00920237f, -0.06716663f, -0.03263737f, 0.04703217f, 
    0.03966023f, 0.03665889f, -0.03093076f, -0.07307462f, 0.02694428f, 0.05409242f, 0.01366499f, 0.05705520f, 
    -0.04826636f, -0.06840931f, -0.06291557f, -0.00107527f, 0.01363847f, -0.06495922f, -0.01559788f, -0.00414014f, 
    0.03317732f, -0.06828953f, -0.04884209f, -0.05013704f, 0.03980651f, -0.01933582f, 0.04158565f, -0.06690548f, 
    0.02938484f, -0.04269968f, -0.07866874f, -0.00808260f, -0.07796796f, -0.03416424f, 0.03586715f, -0.00947667f, 
    0.02841917f, -0.07201672f, -0.04781401f, -0.01751292f, -0.00705732f, -0.05524820f, -0.00247394f, -0.04852527f, 
    -0.06952138f, -0.07466616f, -0.04713418f, 0.03254876f, 0.01315937f, 0.05500909f, -0.05337622f, 0.06628052f, 
    -0.07343797f, -0.01425164f, -0.06029206f, 0.03536436f, -0.02542101f, -0.07182328f, 0.03639824f, -0.00392051f, 
    -0.04852246f, -0.07488675f, 0.03851175f, -0.07737205f, -0.00518120f, -0.05892895f, -0.02262541f, 0.06259865f, 
    0.20213631f, 0.14919974f, -0.15661931f, 0.09955372f, -0.14530492f, 0.12773174f, -0.01204003f, -0.09308808f, 
    0.22104040f, -0.07479266f, 0.06411101f, -0.07143067f, -0.05639461f, 0.42205083f, 0.12595539f, 0.00575380f, 
    -0.00359024f, -0.05458653f, -0.00743632f, 0.01738000f, -0.01184237f, 0.23844685f, 0.07602945f, 0.12619632f, 
    0.06906830f, 0.04150020f, -0.02925269f, -0.04462321f, 0.05116744f, -0.03797324f, 0.05577740f, 0.09806838f, 
    -0.00090288f, -0.02474158f, 0.17986409f, 0.09806423f, 0.01262230f, -0.15038098f, 0.20497772f, -0.06324609f, 
    -0.02053967f, -0.04521462f, 0.06762535f, -0.16333558f, 0.02819573f, 0.04974924f, -0.21827945f, -0.06905585f, 
    -0.06196389f, -0.37502941f, -0.11741579f, 0.02753640f, 0.12343641f, 0.07489919f, -0.07471049f, -0.08185742f, 
    0.18574999f, -0.02850440f, -0.02081697f, -0.04534250f, -0.20739606f, -0.22824718f, -0.02534273f, -0.18897600f, 
    -0.01255920f, -0.02126032f, 0.03436102f, 0.00016489f, -0.03426386f, 0.12709434f, -0.03758026f, -0.04088161f, 
    0.08854303f, 0.39040038f, 0.08500446f, 0.08995689f, -0.02030754f, 0.00058947f, 0.02692491f, -0.00164110f, 
    0.08289350f, -0.03453319f, 0.02462371f, -0.05362155f, -0.26849499f, -0.29888368f, 0.00428891f, 0.27588639f, 
    0.01691202f, -0.01629961f, -0.04143463f, 0.00015275f, 0.01820524f, 0.00065612f, 0.13111848f, 0.14464137f, 
    0.08379646f, -0.12955481f, -0.10004366f, -0.00101942f, 0.24674354f, -0.03176889f, -0.06786822f, -0.11838266f, 
    0.09063323f, 0.16195610f, -0.10310210f, 0.13811429f, -0.22660024f, 0.41038975f, 0.10746444f, -0.10430308f, 
    -0.06405231f, 0.01266675f, 0.04263253f, 0.08192098f, -0.06537058f, -0.11588190f, 0.03536558f, 0.09285488f, 
    -0.22065364f, 0.32977158f, -0.26283178f, 0.13142857f, -0.13264357f, 0.04898467f, -0.04371805f, 0.16311793f, 
    0.02284429f, -0.01453962f, -0.06588274f, 0.01639688f, 0.24200298f, 0.19156408f, -0.10993372f, 0.07381925f, 
    0.08711500f, 0.09429566f, 0.05723076f, -0.01725722f, -0.09463919f, 0.15153769f, 0.09506611f, 0.13634638f, 
    0.05200172f, 0.15554267f, 0.17916943f, 0.30038568f, -0.11285530f, 0.08121832f, -0.06605411f, 0.13591075f, 
    0.06738959f, -0.07202534f, 0.08207174f, -0.05751136f, 0.32345471f, 0.25712597f, -0.14422140f, 0.31805769f, 
    0.03160228f, 0.10770141f, 0.02065004f, 0.11499392f, 0.10891355f, 0.05744287f, 0.03889729f, -0.02288056f, 
    0.00550477f, -0.31845877f, 0.19409998f, -0.00757218f, 0.08826078f, -0.15458363f, 0.09661118f, -0.06932403f, 
    -0.00740362f, -0.08262344f, 0.12424412f, 0.00838148f, -0.09664175f, -0.43470663f, -0.07475433f, -0.09626917f, 
    0.00726340f, -0.03424809f, -0.08520046f, -0.05065337f, 0.00672128f, -0.11432143f, -0.09961625f, 0.07789434f, 
    0.05867330f, -0.04319729f, -0.07543707f, -0.02765775f, 0.03362722f, 0.06127195f, 0.04642546f, -0.06228830f, 
    0.00724829f, -0.05912950f, -0.06470001f, 0.03555317f, -0.06387576f, -0.05947949f, -0.06233621f, 0.02082849f, 
    -0.05321810f, 0.04440221f, -0.05755175f, -0.01901732f, 0.01292173f, -0.06992782f, 0.05019014f, 0.03423787f, 
    0.01862151f, -0.02318376f, -0.04798403f, -0.00687212f, -0.00756264f, 0.01081380f, 0.05680985f, 0.01192774f, 
    -0.01979344f, 0.02247241f, 0.00311885f, 0.05505489f, 0.05046650f, 0.01848160f, -0.03791873f, -0.03529855f, 
    -0.04046176f, 0.03375421f, -0.02717489f, -0.05406661f, 0.04982694f, -0.03242623f, -0.00528651f, -0.07548835f, 
    -0.06911343f, -0.01347327f, -0.08340605f, 0.01619728f, -0.06219065f, 0.02035952f, -0.07769075f, 0.05446949f, 
    0.00953461f, 0.05032942f, 0.04370843f, 0.01894401f, -0.07345024f, -0.07952987f, -0.08475987f, -0.04023539f, 
    -0.04109330f, -0.03854057f, -0.04849004f, -0.05622642f, -0.07905493f, 0.03310568f, -0.07049640f, -0.01746103f, 
    -0.07691952f, -0.00458120f, -0.05730759f, -0.02012561f, -0.03566127f, -0.00593782f, 0.00595441f, 0.05495620f, 
    -0.00826676f, 0.01320065f, -0.01917367f, -0.04294869f, -0.00729242f, 0.03134349f, 0.05331353f, 0.03613718f, 
    -0.07827625f, -0.01901175f, 0.05426123f, -0.04012141f, -0.06613474f, -0.03760793f, -0.04825059f, 0.05195246f, 
    0.00025871f, 0.03688140f, -0.03580478f, -0.00585188f, -0.03114265f, 0.00684761f, -0.02525111f, 0.02483160f, 
    -0.05835469f, 0.02152672f, -0.03357694f, 0.02435057f, 0.00403066f, -0.00707545f, 0.06005727f, 0.03349826f, 
    -0.00699881f, -0.00506023f, -0.04363218f, -0.02954427f, -0.06965988f, -0.02586350f, 0.02524327f, -0.06741349f, 
    -0.04247911f, -0.02561929f, -0.02873530f, -0.02391944f, 0.01025932f, -0.03287867f, -0.06308372f, -0.04137661f, 
    -0.00475068f, 0.03986571f, -0.06065701f, 0.05715501f, -0.07269444f, 0.00989714f, -0.00530806f, 0.04568764f, 
    0.02877801f, 0.01875992f, 0.05095562f, -0.01999176f, -0.01962459f, 0.03287900f, 0.01550243f, 0.00963532f, 
    0.01514292f, 0.03280547f, -0.05816957f, -0.05199205f, -0.04516022f, -0.04459125f, -0.04234340f, -0.06288598f, 
    0.01884015f, 0.01087118f, -0.03799274f, -0.06665096f, 0.03263142f, -0.04960477f, -0.04945225f, 0.05253080f, 
    -0.03257681f, -0.00136596f, -0.00707197f, 0.04878936f, 0.05364142f, -0.03041158f, -0.05041408f, 0.05147532f, 
    0.06086095f, -0.01711482f, 0.03749298f, 0.05693197f, -0.00384066f, -0.01773123f, 0.03936019f, -0.02704045f, 
    -0.01408989f, -0.05194572f, 0.00780667f, -0.02341559f, 0.05182752f, 0.03335043f, -0.01178326f, -0.04352079f, 
    0.04401520f, 0.01455281f, -0.04558654f, -0.07521423f, 0.05076351f, -0.01210444f, 0.03557863f, -0.06132538f, 
    0.00691212f, 0.20654099f, 0.19259791f, 0.24626055f, -0.22596343f, -0.11421220f, 0.07475174f, 0.05625766f, 
    -0.09981585f, 0.23406844f, 0.00928147f, 0.10931227f, 0.30736825f, -0.04607965f, -0.09799960f, 0.08425291f, 
    -0.12577651f, -0.01568348f, -0.03399661f, 0.10874034f, -0.03415850f, -0.07680964f, -0.08851461f, 0.04875756f, 
    0.08578762f, 0.22811823f, 0.28566882f, 0.07072273f, 0.13673583f, 0.06913672f, -0.08542268f, 0.06758812f, 
    -0.02726323f, -0.06023942f, -0.23892020f, -0.00945193f, -0.01697192f, 0.09689723f, -0.06151089f, -0.01140561f, 
    -0.20242588f, 0.11963119f, 0.03726629f, 0.23897529f, -0.00555707f, -0.07174970f, 0.36425915f, 0.03253487f, 
    -0.39215899f, 0.08725382f, -0.02171781f, -0.11585368f, 0.07286809f, 0.17207555f, 0.09515122f, -0.07297296f, 
    -0.12341625f, 0.10234437f, -0.03027971f, 0.05036955f, -0.26813045f, 0.12582047f, -0.12577496f, -0.12475216f, 
    0.00480550f, 0.01987902f, -0.03412675f, 0.00959350f, -0.02288175f, -0.06203320f, 0.10215758f, 0.08892161f, 
    0.42206788f, -0.05777302f, 0.14747918f, 0.02036031f, -0.12122809f, -0.17381097f, -0.10465082f, -0.06023075f, 
    -0.03935050f, 0.14268099f, 0.01439761f, -0.07664835f, -0.13795964f, -0.06367920f, -0.29618016f, -0.26231632f, 
    -0.05173277f, -0.06862481f, -0.21597245f, 0.00892908f, 0.03655408f, 0.00421302f, -0.08069818f, -0.18811871f, 
    -0.31933272f, -0.04655715f, 0.06985686f, 0.10091616f, -0.02687156f, 0.08974536f, 0.11729942f, 0.11805023f, 
    0.17927550f, 0.06466335f, 0.00831215f, -0.16874866f, 0.32859758f, -0.01408003f, 0.15143023f, 0.01166321f, 
    -0.02280694f, 0.03311900f, -0.00323594f, 0.16342512f, 0.06967578f, 0.21887466f, 0.04705390f, 0.06572160f, 
    0.09075900f, 0.15379570f, 0.06795710f, 0.14477322f, -0.12019311f, -0.04753264f, 0.09437064f, 0.17370057f, 
    0.03567080f, -0.01258513f, 0.14184482f, 0.08735202f, 0.31856593f, -0.03417922f, -0.02728424f, -0.01132722f, 
    0.06484055f, -0.00116927f, -0.09356510f, -0.10287714f, 0.09434476f, 0.07038397f, -0.09854759f, -0.11164520f, 
    -0.14552055f, 0.01878122f, 0.02969819f, 0.18803644f, 0.04799776f, -0.09210548f, 0.17909871f, -0.25413832f, 
    -0.13043447f, 0.08749696f, 0.12562862f, 0.25378925f, 0.24497341f, 0.05407891f, 0.28099453f, -0.09442548f, 
    -0.11078060f, -0.03955659f, 0.00243141f, -0.07972527f, -0.07568914f, 0.01417273f, 0.07525114f, 0.03208545f, 
    -0.04312561f, -0.09745285f, -0.00002072f, -0.04405502f, 0.05025211f, 0.10668580f, 0.03155557f, -0.01696299f, 
    0.29604632f, 0.17303614f, -0.22174804f, -0.02588480f, -0.26509187f, -0.05618675f, -0.13937274f, -0.17003815f, 
    0.07672881f, -0.01038209f, -0.11801972f, -0.09227269f, 0.03019261f, 0.08263861f, -0.07777882f, -0.00099641f, 
    -0.14368378f, -0.09331826f, 0.19220527f, -0.13204561f, 0.03871876f, 0.04119417f, -0.07451655f, 0.36620447f, 
    -0.11494101f, 0.02098224f, -0.01343552f, 0.14530483f, 0.21914229f, -0.03915648f, -0.28702715f, 0.01151255f, 
    0.00062625f, -0.08131770f, 0.05078898f, 0.06074436f, 0.06373809f, -0.12582538f, -0.01600955f, -0.12518160f, 
    -0.34444332f, 0.12087408f, 0.24082322f, -0.16905849f, 0.06931288f, 0.16538298f, 0.05209481f, -0.11862830f, 
    0.14515610f, 0.05513017f, -0.08663378f, 0.01401678f, 0.14651676f, 0.01593764f, -0.06734189f, 0.04153455f, 
    0.03288369f, 0.08085960f, -0.13065587f, 0.05804821f, 0.07002540f, -0.04488513f, 0.24020645f, 0.12109685f, 
    -0.06054161f, -0.10946994f, 0.31774604f, 0.07890037f, -0.16105628f, -0.03834816f, 0.11173937f, -0.08176488f, 
    -0.12204094f, 0.03399166f, 0.15734547f, 0.29853907f, 0.16456328f, 0.39194351f, 0.10025889f, 0.34379917f, 
    0.05245563f, -0.07744474f, 0.03186251f, -0.02046306f, 0.12616464f, 0.05086022f, 0.06471842f, 0.16855322f, 
    -0.16824093f, -0.28045535f, -0.00500837f, -0.25662115f, 0.06279596f, 0.07548795f, -0.01505979f, 0.05360100f, 
    -0.12380938f, 0.00725175f, -0.05013932f, 0.15883054f, -0.07599494f, 0.35596624f, 0.22723737f, -0.29090321f, 
    0.01360668f, 0.04099670f, 0.06163677f, 0.01976264f, -0.03500410f, 0.07062919f, -0.14235383f, -0.08723935f, 
    -0.25274006f, 0.13119315f, -0.01060193f, 0.12402148f, -0.14044741f, 0.02562387f, 0.05083125f, 0.09690756f, 
    0.01956050f, -0.05748555f, -0.01698782f, -0.08762245f, 0.28193527f, -0.15700279f, -0.09072137f, 0.08701419f, 
    0.00837973f, 0.07816007f, -0.17849837f, 0.05635946f, 0.09624065f, 0.22963513f, 0.16601862f, 0.00645514f, 
    -0.09706916f, -0.02094477f, 0.16124704f, -0.04516674f, 0.07822569f, -0.09594130f, -0.00809241f, 0.05982227f, 
    0.00595408f, 0.02449396f, 0.12873837f, -0.00729083f, -0.13895877f, -0.32273608f, 0.15294823f, 0.01000225f, 
    0.04078520f, 0.11703093f, -0.08823011f, 0.12333141f, 0.12951994f, -0.13595365f, 0.11494545f, 0.14527547f, 
    -0.02341599f, -0.23384923f, 0.14235596f, -0.07385527f, 0.08009116f, -0.04347454f, 0.23167361f, 0.00273741f, 
    -0.08491530f, 0.15626885f, -0.08100703f, 0.22624865f, -0.32527432f, -0.25409994f, -0.00299308f, -0.36368227f, 
    0.02734447f, -0.05872279f, 0.06849486f, 0.01607288f, -0.06880421f, -0.03823294f, 0.02311031f, 0.01723372f, 
    0.09610077f, -0.03993356f, 0.07650989f, 0.12933820f, 0.10101859f, 0.15053222f, -0.00970795f, 0.08800814f, 
    0.06615370f, 0.12823968f, -0.11651743f, 0.19704141f, 0.02340797f, 0.33634305f, 0.17386813f, 0.51761520f, 
    -0.01461745f, 0.02150892f, 0.09608704f, 0.17190640f, 0.12940307f, 0.21749970f, 0.16281621f, 0.15562253f, 
    0.03306422f, -0.07692389f, 0.03352020f, -0.05389851f, 0.03699942f, -0.00924636f, -0.02424307f, -0.06247656f, 
    0.01437721f, -0.07118597f, -0.04459098f, -0.02611995f, 0.06307063f, -0.00456743f, 0.03587280f, -0.00543874f, 
    0.05566332f, -0.06970914f, -0.06242613f, -0.05278059f, -0.01583915f, -0.04765842f, -0.08112264f, 0.04917677f, 
    -0.03872596f, -0.03288474f, -0.05055948f, 0.03173945f, -0.05584724f, 0.04787026f, 0.03679263f, 0.05883982f, 
    0.03719142f, -0.01318922f, 0.02998088f, -0.01455016f, 0.01265957f, 0.04688749f, 0.01293759f, -0.03198265f, 
    0.01859597f, -0.07501999f, 0.01762967f, 0.00558315f, -0.06682727f, 0.00679676f, 0.06597351f, 0.05393862f, 
    0.05877218f, 0.00866402f, -0.07443635f, 0.04849525f, 0.06469885f, 0.01315222f, -0.00359681f, 0.03327059f, 
    0.03858143f, -0.04242118f, -0.01842812f, -0.05348551f, 0.03139959f, -0.02425973f, 0.06068869f, 0.03732863f, 
    -0.00670919f, 0.00698966f, -0.03901844f, -0.02340496f, 0.06688286f, -0.00034995f, -0.01952649f, 0.01796534f, 
    -0.05892287f, -0.02080673f, -0.00229954f, -0.02735804f, 0.04280047f, 0.05173815f, -0.04419012f, -0.02901209f, 
    -0.02778227f, -0.00717767f, -0.04422050f, -0.04265086f, -0.04226750f, -0.00759112f, -0.08011170f, 0.00439742f, 
    -0.05281140f, -0.06648734f, 0.01133888f, 0.05538143f, 0.00898375f, 0.06167864f, -0.08382008f, -0.01072072f, 
    -0.07144139f, -0.03638400f, -0.00451083f, -0.06710128f, -0.06893878f, -0.00200983f, 0.01671929f, -0.06171099f, 
    -0.00772313f, 0.06187218f, 0.03454728f, -0.04168253f, -0.04990551f, 0.02033020f, -0.01483480f, -0.04567457f, 
    0.00906183f, 0.06575740f, -0.00882546f, 0.00050426f, -0.04985050f, 0.06354630f, 0.01944166f, 0.04180264f, 
    -0.05418969f, 0.02457167f, 0.06419384f, -0.03144135f, -0.03233064f, -0.00339989f, -0.00815286f, 0.03501493f, 
    0.01602519f, 0.01718777f, 0.04240665f, -0.00558807f, -0.01962917f, 0.03942762f, -0.06377620f, -0.00722810f, 
    0.00391094f, -0.03525616f, 0.03813888f, -0.06034856f, -0.08093517f, -0.03164990f, 0.01640817f, -0.03203030f, 
    -0.00151286f, -0.00817320f, 0.00908578f, 0.06244769f, 0.02340312f, -0.01755020f, -0.06492703f, -0.07061755f, 
    0.01484803f, 0.00418700f, 0.00773792f, -0.06510789f, 0.03068142f, -0.02160177f, -0.05157868f, 0.02407886f, 
    -0.05887511f, -0.00117876f, 0.05328837f, 0.02772094f, 0.04840049f, 0.02367789f, -0.02029470f, 0.00254487f, 
    -0.06699292f, -0.05136510f, 0.05567563f, -0.02554297f, 0.06411122f, -0.03982416f, -0.06081250f, 0.00195421f, 
    -0.06848461f, -0.02157183f, 0.04440921f, -0.04813103f, 0.04973627f, -0.01201830f, 0.01111335f, -0.05530886f, 
    -0.06205558f, -0.06503118f, -0.02406785f, -0.03714496f, -0.06203467f, 0.00985814f, -0.04679987f, -0.05003614f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13887428f, 0.07726808f, 0.02357397f, 0.06131141f, 0.11871223f, -0.01274696f, 0.00591732f, 0.07805829f, 
    -0.14421754f, 0.04859556f, 0.11548363f, -0.13412684f, 0.04187201f, 0.04106548f, 0.03845078f, -0.04565268f, 
    -0.03147439f, 0.04477930f, -0.02521345f, 0.21564814f, 0.03140712f, 0.13535839f, -0.00685946f, 0.11293184f, 
    0.04940559f, -0.06065800f, -0.05043570f, 0.05850417f, -0.07550821f, 0.10519122f, 0.05438423f, -0.03289157f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04047042f, 0.09346393f, 0.05338227f, -0.03040853f, 0.15792376f, -0.16175514f, -0.17080685f, 0.14282624f, 
    0.13936563f, -0.06826717f, -0.14869411f, 0.10530075f, 0.07647655f, 0.04924538f, -0.12857062f, -0.02205646f, 
    -0.19547825f, 0.01031184f, -0.07611349f, -0.07306241f, -0.05393883f, -0.17141195f, 0.12556085f, -0.19937341f, 
    -0.14409213f, 0.09435506f, 0.07994468f, -0.04424842f, 0.05149200f, -0.12417944f, -0.09622076f, 0.02624942f, 
    -0.17479172f, 0.28519630f, 0.16514978f, -0.10733037f, 0.49725398f, -0.17314851f, 0.21322013f, 0.23943706f, 
    -0.27968767f, 0.00575857f, -0.07518395f, -0.61716372f, -0.14827745f, -0.17697226f, 0.27124462f, 0.48779821f, 
    -0.09289332f, -0.05628424f, -0.16653368f, 0.54243279f, 0.28521013f, -0.01672967f, -0.17342700f, 0.09296767f, 
    -0.35343221f, -0.06029866f, 0.05332232f, 0.39020672f, -0.13434573f, 0.13638172f, -0.23559268f, -0.14344342f, 
    0.21558148f, 0.24405676f, 0.12130377f, -0.08941515f, -0.31165054f, 0.16336785f, 0.25014663f, 0.07858042f, 
    -0.03552682f, -0.07535432f, 0.28858376f, 0.00686710f, -0.07617478f, -0.09232178f, -0.07524196f, 0.07896740f, 
    -0.56471640f, -0.12433474f, -0.03530863f, 0.33542773f, -0.01267490f, 0.48160174f, -0.21533768f, 0.36024472f, 
    0.35693380f, 0.15306565f, -0.03649583f, -0.35627502f, -0.06066557f, -0.10243785f, 0.16865556f, -0.14064094f, 
    -0.06303718f, -0.22897734f, -0.12672161f, -0.29877013f, -0.12304698f, -0.14653833f, 0.23386553f, -0.10524907f, 
    -0.13394435f, -0.14012675f, -0.14984334f, 0.16350329f, 0.10249448f, -0.01051854f, -0.18040980f, 0.05988949f, 
    -0.00693846f, -0.03194514f, -0.17375176f, 0.11809933f, -0.08320570f, -0.06102504f, 0.15035310f, -0.02497351f, 
    -0.20596269f, 0.00308774f, -0.17149810f, -0.05336167f, 0.00344085f, 0.13436721f, 0.15862833f, 0.07178268f, 
    -0.02663191f, -0.13967635f, -0.15656298f, 0.01114774f, -0.12644775f, -0.16271415f, -0.30514899f, 0.55432808f, 
    0.00396300f, 0.15587267f, 0.25516987f, -0.08039626f, -0.05221438f, 0.02552778f, 0.22891936f, -0.06517854f, 
    0.14553878f, -0.06966284f, 0.40090635f, -0.11745684f, -0.13448167f, 0.09474895f, 0.02639981f, 0.14206985f, 
    0.50569659f, 0.07961101f, 0.16918220f, -0.06130736f, -0.07435067f, -0.21964149f, -0.03578139f, -0.06580986f, 
    0.24279904f, -0.05625295f, 0.09397091f, 0.06160432f, -0.20255668f, 0.17241234f, -0.18738513f, -0.07007836f, 
    0.09002655f, 0.13149250f, 0.33263263f, -0.08353598f, -0.12578642f, 0.03521223f, -0.14372058f, -0.23859668f, 
    0.02319931f, -0.13326395f, -0.24842300f, 0.37444407f, -0.10448874f, 0.50495136f, -0.10548914f, 0.20510353f, 
    0.14145608f, -0.01337206f, 0.00122807f, 0.20098613f, 0.10800447f, -0.10830920f, 0.09803838f, -0.02726467f, 
    -0.08210905f, -0.08465583f, 0.11890939f, -0.19104365f, -0.12437929f, -0.05154598f, -0.01062292f, -0.04994872f, 
    -0.13679758f, 0.00034845f, -0.02535102f, -0.08034279f, 0.05777325f, -0.02359577f, -0.07747363f, -0.03212043f, 
    0.06118500f, -0.11794945f, -0.07457952f, -0.18022169f, -0.02666112f, -0.18829088f, 0.10147805f, 0.09892821f, 
    -0.11615966f, -0.16969663f, -0.06476577f, -0.10044330f, -0.00823387f, -0.17694050f, 0.13602318f, 0.03800745f, 
    0.51872456f, 0.28078145f, -0.14317621f, 0.08666722f, -0.17303319f, 0.21681362f, -0.28965664f, -0.26984504f, 
    -0.05189082f, 0.16063438f, 0.06927720f, -0.09893988f, 0.00730558f, -0.16205934f, 0.23024939f, -0.33811995f, 
    0.03981408f, -0.11596497f, -0.07527729f, -0.03448854f, 0.07586230f, -0.16499336f, 0.49692678f, 0.27488485f, 
    -0.54119527f, -0.26242840f, 0.07816838f, -0.07180475f, 0.15319972f, 0.32763034f, 0.29991728f, 0.12921225f, 
    0.23550819f, -0.21241961f, -0.15443785f, 0.02264147f, -0.33942577f, -0.10630255f, -0.03709047f, 0.02439093f, 
    0.07243998f, 0.00877121f, 0.35947907f, 0.42472264f, -0.10058912f, -0.05496200f, 0.10484369f, -0.19727756f, 
    0.27306497f, -0.16377418f, -0.14126877f, -0.00265720f, -0.18004067f, 0.08314503f, -0.06916026f, 0.04639871f, 
    0.40432224f, 0.24933337f, -0.00517997f, -0.09686474f, -0.00208049f, 0.31404823f, 0.19086920f, 0.05373204f, 
    0.29375523f, -0.15528063f, 0.01111216f, 0.39486316f, -0.19729289f, 0.05732342f, 0.42913869f, 0.25577506f, 
    -0.48855373f, -0.06034321f, 0.25621426f, 0.35991803f, 0.02785805f, 0.06535997f, 0.16076015f, 0.22748637f, 
    -0.10845648f, -0.06681154f, -0.16781023f, -0.06727700f, -0.27898455f, 0.34663162f, -0.06672855f, 0.00642464f, 
    0.34762657f, 0.15243900f, -0.08481292f, -0.03054411f, 0.14925212f, 0.39868799f, 0.12863787f, -0.00607569f, 
    -0.09222727f, 0.03985669f, -0.10263450f, -0.11668804f, 0.06253634f, -0.10903528f, -0.14628755f, 0.01807322f, 
    -0.07735603f, 0.04756042f, -0.07198262f, 0.05988710f, 0.12759475f, -0.05566243f, 0.02586868f, -0.10082788f, 
    -0.18749112f, 0.08439439f, -0.17213474f, 0.05479495f, -0.15221816f, 0.10612349f, -0.02485935f, -0.17823592f, 
    0.13052803f, -0.05771346f, -0.09329023f, -0.10342623f, 0.07618707f, 0.06025381f, 0.00529082f, -0.06055826f, 
    -0.21306773f, 0.23252361f, 0.05962170f, 0.31296346f, 0.32893217f, 0.08349969f, -0.41594216f, 0.30277973f, 
    0.37081417f, -0.15793814f, 0.01111679f, -0.02076582f, -0.03005200f, 0.04767156f, 0.41873562f, -0.34488904f, 
    0.04987965f, 0.03621591f, 0.26735216f, -0.29119888f, 0.26104301f, 0.14199768f, 0.27300036f, -0.21373150f, 
    -0.23009674f, -0.19033915f, -0.09192438f, 0.23712435f, -0.10937782f, -0.26913461f, 0.15295365f, 0.08878463f, 
    0.03533658f, -0.15071328f, -0.11173189f, 0.10821527f, -0.04954012f, -0.00977011f, 0.06253198f, 0.09221686f, 
    -0.11527370f, -0.00250536f, -0.14058316f, 0.05674306f, -0.06047708f, 0.04750738f, 0.14886633f, 0.05760116f, 
    -0.02909007f, 0.14886795f, -0.08326818f, -0.19136649f, -0.05973260f, 0.05736823f, -0.10509026f, -0.21037890f, 
    0.03425263f, -0.15341170f, -0.10297908f, -0.07011840f, 0.04829126f, -0.16344532f, 0.07625984f, 0.08261800f, 
    -0.18823950f, 0.01631982f, -0.08851521f, 0.52168220f, 0.00606594f, 0.20027542f, -0.60448343f, 0.17390814f, 
    -0.11519153f, 0.03266821f, -0.01552041f, -0.24291599f, -0.00355412f, 0.16812845f, 0.28652984f, -0.51689512f, 
    0.00502264f, -0.06398531f, 0.17209309f, -0.29379061f, 0.08639787f, 0.09783275f, -0.23113455f, 0.27615800f, 
    0.14067090f, 0.28775781f, -0.09330813f, -0.04800970f, 0.04181051f, -0.44832247f, -0.02189369f, -0.10138979f, 
    0.21128513f, 0.42605412f, 0.06877647f, 0.12363455f, -0.10808039f, 0.19536534f, -0.23686007f, 0.27440307f, 
    0.42663896f, 0.03317507f, 0.12339780f, -0.12345602f, -0.10613809f, -0.09624584f, 0.35156560f, -0.26091003f, 
    -0.39852831f, 0.17950909f, -0.05868252f, -0.16390345f, -0.19492394f, 0.06199025f, -0.18802731f, 0.09287859f, 
    -0.01177014f, -0.32074070f, 0.06538704f, 0.09127003f, -0.02360320f, -0.17905231f, -0.16713636f, -0.16719599f, 
    0.14399938f, 0.23187624f, 0.11781351f, -0.07880018f, -0.03957308f, -0.02084053f, 0.56604707f, -0.00811821f, 
    -0.82096398f, 0.00403061f, -0.21910961f, 0.13358314f, 0.15468630f, -0.17089204f, 0.04400027f, 0.03540775f, 
    -0.20445086f, -0.13804963f, 0.04264221f, -0.20065528f, -0.13126869f, 0.23816399f, 0.59900224f, -0.09573027f, 
    0.56840724f, 0.15992537f, 0.00096641f, 0.10750587f, 0.10647757f, 0.02293720f, 0.10117651f, -0.03447458f, 
    0.19421345f, -0.16961303f, -0.13086188f, -0.27544078f, -0.00723323f, 0.20664223f, -0.05189464f, 0.39362627f, 
    -0.40953630f, 0.02015331f, -0.06175066f, 0.14715011f, 0.12458710f, -0.05628441f, 0.21170630f, -0.18070981f, 
    -0.15322419f, 0.13372976f, 0.15129545f, 0.04729393f, -0.15462160f, 0.22057702f, 0.24922545f, 0.17528769f, 
    -0.09838929f, -0.17174430f, 0.17602292f, -0.62053418f, 0.09814382f, 0.18972398f, 0.41222298f, -0.01978265f, 
    -0.15933578f, -0.33266285f, 0.14198299f, 0.62887686f, -0.02211210f, -0.02591478f, -0.43574002f, -0.07578909f, 
    -0.34480697f, -0.04390792f, 0.32631969f, 0.26578236f, 0.01153024f, 0.07647658f, 0.17618512f, -0.16646133f, 
    0.37253913f, -0.15640733f, -0.07160430f, -0.01539055f, 0.19059458f, -0.02968023f, -0.48478818f, 0.13794212f, 
    0.01551336f, 0.33739898f, -0.03549787f, -0.00268560f, 0.07600918f, 0.28757453f, 0.27690530f, -0.15002452f, 
    0.10040876f, 0.32812244f, -0.05482408f, 0.54614860f, -0.10296210f, -0.01575704f, -0.53756630f, 0.37987298f, 
    0.07822137f, -0.02193667f, 0.40990457f, -0.31937864f, 0.16771929f, 0.07482015f, 0.20176007f, 0.09112690f, 
    0.16735515f, 0.11734162f, -0.13956179f, -0.38396183f, -0.27099821f, 0.02643278f, 0.03545979f, 0.19501375f, 
    0.10944568f, -0.27056703f, 0.17469698f, 0.46312892f, 0.17900014f, 0.05104730f, -0.16604763f, -0.16096044f, 
    0.17338684f, -0.36793911f, -0.06994573f, -0.41358858f, 0.04258887f, 0.24063671f, 0.25518814f, 0.33631232f, 
    0.77131331f, 0.15239517f, -0.11394479f, 0.04028450f, 0.06676608f, -0.17203882f, -0.30685604f, 0.23116921f, 
    0.05964253f, 0.13670923f, 0.56088042f, 0.11754512f, 0.21225379f, -0.06115712f, -0.30979064f, 0.05281182f, 
    -0.04405338f, 0.13159776f, -0.00594228f, -0.28339866f, -0.08393284f, -0.03806557f, 0.39335868f, -0.04654081f, 
    -0.28261054f, 0.02198587f, -0.01148708f, -0.47597498f, 0.29283321f, 0.04429055f, 0.27239221f, -0.01742213f, 
    0.15025643f, 0.06136215f, -0.37143150f, 0.17672263f, 0.03732903f, -0.03979084f, -0.14405453f, 0.16821174f, 
    0.24193886f, -0.13872427f, 0.53772581f, -0.26210526f, 0.21140698f, 0.07996172f, -0.00916008f, 0.12251731f, 
    0.49176550f, 0.34550270f, 0.15783486f, 0.12952204f, -0.13907820f, -0.33946434f, -0.09727055f, 0.11454535f, 
    -0.02496408f, -0.03126601f, 0.17638315f, 0.01385051f, -0.03957523f, -0.16756572f, -0.12369723f, 0.13035685f, 
    -0.15798837f, 0.17079315f, -0.13759059f, 0.09411415f, -0.02061352f, -0.01259472f, 0.03942298f, -0.06683329f, 
    0.02624348f, 0.00390560f, -0.12567425f, -0.15670037f, -0.06373235f, 0.14355084f, -0.11172369f, -0.10221449f, 
    -0.03715319f, -0.04311346f, -0.15945412f, -0.13160822f, -0.12094204f, -0.07582154f, 0.05085941f, -0.09267356f, 
    0.25137207f, 0.22535908f, 0.11256079f, 0.17428021f, 0.17113283f, -0.22719401f, 0.61285347f, -0.09895643f, 
    -0.68229121f, -0.01718882f, 0.37939951f, -0.10934771f, 0.16454607f, 0.08009572f, 0.29301259f, 0.21241230f, 
    0.17384352f, -0.11292176f, -0.09669191f, 0.23856062f, -0.04449911f, -0.24679768f, 0.16316064f, 0.10879768f, 
    0.23220567f, -0.29752779f, 0.13858806f, 0.27988687f, -0.07496726f, 0.33789378f, -0.30711663f, -0.05438815f, 
    -0.10150613f, -0.21854442f, 0.10230071f, 0.28678930f, -0.12406312f, -0.24382558f, -0.19929431f, 0.42713949f, 
    -0.02963639f, -0.05919115f, 0.20331979f, 0.40067670f, 0.06217489f, 0.12238877f, 0.09001302f, 0.32074115f, 
    0.30769330f, 0.02454715f, 0.16608725f, -0.39694622f, -0.14553377f, 0.02663876f, 0.59849960f, -0.13626565f, 
    0.29450253f, -0.00069838f, 0.11423395f, 0.21348311f, 0.11500333f, 0.34993529f, 0.21673359f, -0.14775525f, 
    -0.07611289f, -0.02479783f, -0.02062218f, 0.52476335f, -0.18696047f, 0.22180961f, 0.50927156f, 0.17474656f, 
    -0.07727052f, 0.06218670f, -0.21423829f, 0.17309888f, 0.13727339f, 0.03116831f, 0.35245538f, 0.12036030f, 
    -0.16976839f, -0.13753949f, 0.28084099f, -0.58164370f, -0.16805680f, -0.06039229f, -0.07862185f, 0.27763245f, 
    0.33504716f, 0.17042054f, -0.16118674f, -0.14586888f, 0.05442625f, -0.01390665f, -0.22244225f, -0.08650861f, 
    0.29442072f, -0.14519547f, -0.16889776f, -0.03420045f, 0.43428114f, 0.07359451f, 0.29248902f, -0.47163153f, 
    -0.05304680f, 0.14289983f, -0.00255038f, 0.01221903f, 0.04662946f, -0.12337446f, 0.05657826f, -0.05635693f, 
    0.57924432f, -0.12963098f, 0.02868655f, 0.48257664f, 0.37052810f, -0.26627004f, -0.63792783f, 0.12339284f, 
    0.09669840f, 0.13663600f, 0.02490486f, -0.22409679f, 0.00243650f, 0.19223610f, 0.12509097f, 0.05215522f, 
    0.32093379f, 0.45272410f, 0.08711754f, 0.05638507f, 0.16250287f, 0.41360638f, 0.22019506f, -0.37612554f, 
    -0.04896335f, 0.17523029f, -0.26313132f, -0.12634830f, -0.10978556f, -0.13492489f, -0.11271340f, -0.31741789f, 
    -0.08773828f, -0.06130967f, -0.15324196f, 0.02958005f, 0.08455020f, 0.16333272f, 0.13873878f, -0.02336792f, 
    0.03175416f, 0.11055751f, 0.16728210f, 0.04408244f, 0.00333889f, 0.09552397f, 0.11914702f, -0.06723719f, 
    -0.02178714f, -0.16242313f, 0.10660607f, -0.10979658f, 0.08945499f, -0.07804973f, -0.54791009f, 0.52585381f, 
    -0.01052423f, 0.01597324f, 0.34249082f, -0.13384013f, 0.01199579f, -0.13603999f, -0.10852581f, 0.32885173f, 
    -0.31564584f, -0.05787060f, 0.12859094f, 0.44472489f, -0.09946560f, 0.41353127f, -0.23603068f, 0.12167010f, 
    0.01337849f, -0.21009585f, -0.11488403f, 0.15919679f, 0.10801367f, 0.04681748f, 0.11761959f, -0.14472963f, 
    -0.18360621f, 0.48220530f, 0.08282753f, -0.20372985f, -0.13953479f, 0.38214722f, -0.37736791f, 0.10151939f, 
    0.32422796f, -0.15210706f, -0.00269827f, -0.11065089f, 0.13844180f, 0.08636610f, -0.22742502f, -0.16420564f, 
    0.12153400f, -0.09167176f, 0.29714364f, -0.01075467f, 0.08011987f, -0.13572028f, 0.27620932f, 0.37909997f, 
    -0.12418361f, 0.48533714f, -0.03007104f, 0.04004614f, -0.02746752f, -0.22166273f, 0.08155033f, 0.10949813f, 
    0.18547648f, 0.06210745f, 0.02218201f, -0.03514933f, -0.30891672f, 0.12312506f, 0.34948751f, 0.03189661f, 
    0.95511979f, 0.10718969f, 0.16373715f, -0.20477279f, -0.03752075f, 0.12279343f, 0.01142272f, 0.29426229f, 
    0.22506361f, 0.08774231f, 0.30023998f, -0.03036039f, -0.18022342f, 0.13793960f, 0.01263943f, -0.13702776f, 
    0.55041569f, -0.33566096f, 0.17166311f, 0.29610628f, 0.14980528f, -0.01749564f, -0.38047585f, 0.18249984f, 
    -0.14130141f, -0.18744507f, 0.03656939f, 0.06832515f, -0.03065265f, 0.00077534f, -0.12822445f, 0.10307130f, 
    -0.06784034f, -0.08934593f, -0.03269295f, -0.12568527f, 0.12902829f, 0.13673106f, 0.03144546f, 0.11976306f, 
    0.01647210f, 0.05523489f, -0.18893075f, -0.10625855f, 0.06569380f, -0.05122200f, 0.14789373f, -0.21030854f, 
    -0.20757870f, -0.09693234f, 0.14924921f, -0.16464064f, 0.05828020f, 0.10346697f, -0.08556457f, 0.01999532f, 
    0.27077603f, -0.03817541f, -0.00609911f, 0.66095465f, -0.13317510f, -0.10775054f, 0.51424968f, 0.03297859f, 
    -0.28092727f, -0.05090604f, 0.24924961f, 0.00193003f, -0.04519864f, -0.15574640f, 0.39121008f, 0.42191276f, 
    -0.05252303f, 0.02405607f, 0.17127715f, 0.00479900f, -0.07188866f, -0.48253176f, 0.11448676f, 0.25589234f, 
    -0.16594276f, 0.12883371f, -0.10988599f, -0.02713855f, 0.05179156f, 0.40205577f, -0.25464547f, 0.01823781f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12659289f, 0.16062765f, -0.11908476f, 0.16221412f, 0.10684478f, -0.07212648f, 0.15159963f, 0.18252361f, 
    -0.08059778f, 0.00327884f, -0.08839466f, 0.12135839f, 0.03051857f, -0.03444114f, -0.09793611f, -0.14912099f, 
    0.07696588f, 0.14317930f, 0.10660373f, 0.00532904f, -0.11102154f, -0.01365246f, -0.08554422f, -0.03738802f, 
    -0.16669588f, 0.31137690f, 0.05805865f, 0.14330900f, 0.08933710f, -0.00653206f, -0.12330404f, -0.01062762f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.19976799f, -0.59616762f, 0.07079362f, -0.16037823f, 0.06341666f, -0.26887423f, -0.04069566f, -0.12708977f, 
    0.09695746f, 0.22585465f, -0.06689037f, 0.24445115f, -0.11511510f, 0.53387660f, -0.49103716f, -0.11163943f, 
    0.02011845f, 0.43259922f, -0.18822180f, -0.22376773f, 0.00151605f, 0.03734431f, -0.33147976f, -0.02256584f, 
    0.59950125f, -0.06313064f, -0.05552547f, -0.53825843f, -0.11026365f, -0.79364651f, 0.00805929f, 0.18573156f, 
    -0.09901552f, -0.37161988f, -0.24365985f, 0.06839880f, 0.04824603f, -0.30435225f, -0.10601621f, 0.00340175f, 
    -0.03470858f, -0.59987867f, 0.10427030f, 0.35536095f, 0.04610694f, 0.21518144f, -0.41245177f, -0.11340561f, 
    -0.03676049f, -0.21663249f, -0.09175148f, 0.09904161f, 0.36732647f, 0.00769104f, -0.40849170f, 0.00092681f, 
    -0.15891767f, -0.02432518f, 0.24283068f, -0.49579334f, 0.38630474f, 0.42715958f, -0.09884689f, -0.48190618f, 
    0.07936051f, 0.10897144f, -0.27182457f, -0.29853988f, -0.08784399f, -0.80537587f, 0.09513264f, 0.04416739f, 
    0.04578208f, -0.19080807f, 0.13493250f, -0.46317866f, -0.11444637f, -0.72512883f, -0.31232467f, -0.40457535f, 
    0.27421761f, 0.01530626f, -0.75538146f, 0.34354886f, 0.02844181f, 0.09876960f, 0.22944167f, -0.05476886f, 
    -0.20706804f, 0.42765805f, -0.21481626f, -0.49189794f, -0.07262742f, -1.07739508f, -0.02024285f, 0.44428778f, 
    0.10502030f, -0.10326889f, -0.25185376f, -0.05771284f, 0.27909926f, -0.04961454f, -0.03658376f, -0.00120437f, 
    0.20929602f, 0.17476703f, -0.06262342f, -0.16429727f, 0.04979887f, -0.04574890f, -0.86383367f, 0.21947066f, 
    -0.34067756f, 0.24506170f, 0.32274362f, -0.81832218f, -0.35884172f, -0.07407421f, 0.18372670f, 0.36620575f, 
    0.05683794f, -0.41473365f, -0.31227130f, -0.01291990f, 0.14272548f, -0.22854662f, -0.13976261f, 0.20712197f, 
    0.02787901f, -0.50996482f, 0.19904284f, 0.09566497f, 0.34225675f, 0.20036195f, 0.04982636f, -0.19452205f, 
    0.31576291f, 0.28306141f, -0.18019228f, -0.19873224f, -0.08658037f, -0.06066000f, 0.29693586f, 0.18148170f, 
    0.23875499f, 0.01985674f, -0.11112675f, -0.01599835f, 0.04248839f, -0.17199068f, 0.00646912f, -0.05730798f, 
    -0.16633058f, -0.08724312f, -0.15875642f, 0.21230513f, -0.25237989f, 0.18763100f, -0.12033451f, -0.38213655f, 
    -0.11086799f, 0.30520284f, 0.25831810f, -0.10743313f, 0.17239323f, -0.00453254f, -0.09818229f, 0.08292178f, 
    -0.81222475f, -0.34252846f, -0.06265081f, 0.26076573f, -0.21430574f, 0.35007042f, 0.56590253f, -0.41778249f, 
    0.14748178f, -0.39201385f, 0.24573658f, -0.00916163f, -0.15624160f, -0.02823639f, -0.21771197f, -0.43742612f, 
    -0.08122963f, -0.14315028f, -0.12395542f, 0.39999256f, 0.18325420f, -0.29308620f, -0.09659364f, -0.14752880f, 
    -0.17770511f, 0.07319956f, 0.30894014f, -0.31668848f, -0.76200181f, -0.11085302f, -0.11742301f, 0.23712362f, 
    -0.32200801f, 0.18619621f, -0.10802975f, 0.09059227f, 0.09495726f, -0.77054566f, -0.54876930f, 0.39458376f, 
    0.36227220f, -0.90416807f, -0.79827118f, -0.09749857f, -0.27339399f, -0.17164207f, -0.14525928f, 0.00673577f, 
    -0.19120748f, -0.19662756f, 0.33026463f, -0.02174944f, 0.03030781f, -0.74105400f, -0.00498939f, -0.04372976f, 
    -0.03779332f, -0.20269573f, -0.09718293f, -0.06998000f, 0.14852379f, -0.00415148f, -0.14272915f, -0.27956274f, 
    0.06986948f, 0.10905254f, 0.02908800f, -0.06979606f, -0.01355823f, -0.28991991f, 0.59817642f, -0.36170232f, 
    -0.33234158f, -0.21673928f, 0.11864207f, 0.16466577f, 0.05866693f, 0.02004763f, 0.00396967f, 0.29048127f, 
    0.26803559f, -0.39264998f, -0.54460299f, 0.35957336f, -0.41359851f, 0.41111621f, -0.10901007f, 0.16681878f, 
    -0.01032604f, 0.53601676f, -0.05872800f, 0.06197900f, -0.07663172f, -0.29503760f, 0.13404694f, -1.00177658f, 
    -0.48506376f, -0.32915136f, -0.12762977f, 0.14131354f, 0.04769470f, -0.10565635f, 0.02310262f, -0.38383949f, 
    -0.41949418f, 0.33105779f, -0.44505253f, 0.08828373f, 0.33274058f, -0.13924682f, -0.33407632f, -0.05473871f, 
    -0.64252877f, 0.28985891f, -0.20599742f, 0.46981844f, -0.08967704f, -0.30764905f, -0.11735424f, -0.49113956f, 
    -0.12414814f, -0.25391087f, 0.27748790f, 0.14515196f, -0.47913739f, 0.40222290f, -0.16544357f, 0.12130660f, 
    0.26821223f, 0.14810842f, -0.10581178f, -0.70145231f, -0.14566641f, -0.45875806f, -0.04070945f, -0.50946903f, 
    -0.05478366f, 0.26838580f, 0.04048969f, 0.05522172f, -0.50682104f, -0.01750923f, -0.12871739f, -0.73594302f, 
    -0.54734671f, 0.20188093f, 0.14304990f, 0.11757815f, 0.07081360f, -0.12089413f, -0.03815484f, -0.03275020f, 
    0.10481587f, 0.39985773f, -0.55385804f, 0.07106800f, -0.32766145f, -0.04983927f, 0.07883646f, 0.27557036f, 
    -0.19384427f, 0.00517123f, 0.08061781f, 0.46182424f, -0.11631797f, -0.55948633f, 0.43373954f, -0.29985544f, 
    -0.24380374f, 0.17658521f, 0.29004845f, -0.78372246f, -0.69430697f, 0.08862485f, 0.31902394f, -0.03598881f, 
    -0.36316299f, 0.25983521f, 0.15043378f, 0.00499356f, -0.53028584f, -0.23942016f, 0.01679732f, 0.04175061f, 
    -0.05779492f, 0.22779243f, 0.18736175f, -0.05710840f, -0.05195373f, -0.10108656f, 0.12542038f, -0.25415060f, 
    -0.33985627f, 0.04895303f, 0.05788379f, -0.43487507f, 0.00050672f, -0.29790586f, -0.60060614f, 0.28747788f, 
    -0.41545162f, -0.57428938f, -0.22408871f, -0.35467428f, 0.37955868f, -0.09720237f, 0.37748367f, -0.48207873f, 
    0.29554275f, 0.14466578f, 0.14904107f, -0.28776649f, -0.00167608f, 0.00188790f, 0.13019671f, 0.16058408f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.26825765f, 0.08707552f, -0.07916392f, -0.07253580f, -0.00332373f, 0.04101077f, 0.08547988f, -0.35553804f, 
    0.06984761f, 0.00046706f, 0.09444744f, 0.04019657f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
