#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.90374619f, -0.62147397f, -0.18768206f, -0.68719405f, -0.42045462f, -0.42192644f, -0.79903007f, -0.66760200f, 
    -0.49415275f, -0.52764148f, -0.08303144f, 0.03495733f, -0.00202404f, 0.36764815f, -0.05530179f, 0.08764350f, 
    -0.24773587f, -0.10384176f, 0.15823884f, -0.03029328f, 0.15797557f, 0.53272301f, 0.28983849f, 0.30611083f, 
    0.49707738f, -1.36827230f, 0.65654451f, 0.74429643f, -0.25063354f, -0.13991328f, -0.66200763f, -0.22240098f, 
    0.15149774f, 0.12305269f, 0.35527292f, -0.32839194f, -0.38905218f, -0.28464887f, 0.06485804f, 0.27996323f, 
    -0.07686077f, 0.21785051f, 0.03132971f, -0.02847091f, 0.30891207f, -0.18858369f, 0.07269925f, -0.18595433f, 
    -0.27255851f, -0.29328340f, -1.52752888f, -0.76294506f, -0.58619052f, -0.89980555f, -0.16680874f, 0.35058469f, 
    0.02492995f, -0.26959357f, -0.07080686f, 0.30483720f, -0.03503398f, -0.51096851f, -0.43727055f, -0.28701496f, 
    -0.04959100f, 0.18308632f, 0.05437817f, -0.09671021f, 0.25536841f, -0.29490682f, -0.10798766f, -0.38459170f, 
    -0.08845018f, -0.16153075f, -0.35805669f, 1.26318061f, -1.29558122f, -1.16859925f, 0.51567829f, 0.16614918f, 
    0.94391793f, 0.66833347f, 0.16302103f, -0.51318932f, -0.07193519f, 0.20446198f, -0.23467980f, -0.50229508f, 
    -0.24616051f, 0.20821165f, 0.07263348f, -0.02896284f, 0.28587955f, -0.11219713f, -0.44768888f, -0.17981647f, 
    -0.06290549f, -0.31133625f, -0.09578300f, -0.07020635f, -0.16071993f, 0.35083345f, 0.31761903f, -0.23238671f, 
    0.21143860f, 0.02179150f, -0.14075851f, -0.43153974f, -0.01176316f, 0.24975529f, 0.09237202f, 0.52187651f, 
    -0.38116530f, -0.39294758f, -0.40703717f, -0.13297901f, -0.38344598f, -0.07409301f, -0.20026322f, 0.14279367f, 
    -0.11814445f, 0.02134783f, -0.20127438f, -0.18252616f, -0.45294580f, 0.27522561f, 0.21518703f, -0.31992340f, 
    -0.05086567f, -0.13141479f, 0.22197628f, -0.21963297f, -0.41111448f, -0.23233306f, 0.66301471f, -0.10841517f, 
    0.30108073f, 0.38595241f, -0.13141446f, -0.33729169f, -0.06866358f, -0.46061331f, 0.25766131f, 0.18129285f, 
    0.00688770f, -0.06957180f, 0.08456088f, 0.00407732f, -0.14779986f, 0.31676617f, -0.60650402f, -0.20612949f, 
    0.17061310f, 0.25781354f, 0.19573860f, 0.27316666f, 0.66587579f, -0.08866989f, -0.17762740f, 0.04646517f, 
    -0.27551204f, 0.02952447f, 0.36239150f, 0.06721199f, -0.29205343f, 0.10050746f, -0.15423709f, 0.06483331f, 
    0.14674906f, -0.30264381f, -0.10600887f, 0.05165565f, -0.14810525f, 0.05674091f, 0.24681011f, 0.01304500f, 
    -0.59344029f, -0.61093175f, -0.70947951f, -0.67479336f, -0.24167004f, 0.10165280f, -0.25584608f, -0.21018800f, 
    -0.07373556f, 0.12451871f, -0.24136503f, -0.68928736f, -0.80720919f, 0.29380539f, -0.58330280f, -0.32312506f, 
    -0.40033823f, -0.77958655f, -0.61876810f, -0.50414819f, -0.26816684f, 0.14444101f, -0.37684876f, -0.34146491f, 
    -1.04809713f, -0.64775932f, 0.52370244f, 0.78239012f, 0.30948880f, 0.54081565f, -0.71421599f, -0.72055209f, 
    0.08347913f, -0.17785886f, -0.38586920f, -0.29871246f, -0.28801888f, 0.45231992f, -0.37765443f, -0.03559172f, 
    -0.38499802f, 0.26259598f, 0.37566227f, -0.11575369f, 0.00917374f, -0.14422983f, -0.29216179f, -0.00017563f, 
    -0.09955654f, 0.50054771f, 0.34374899f, 0.08918127f, -0.10444970f, -0.23065658f, -0.52312410f, -0.13284266f, 
    0.34310549f, 0.43052891f, 0.27129424f, 0.22348079f, 0.19612756f, 0.37635595f, -0.35184398f, -0.12032679f, 
    0.07254496f, -0.15800186f, -0.09443108f, -0.23724730f, -0.02950444f, 0.22487839f, 0.24465695f, 0.07034905f, 
    0.04811315f, 0.14654082f, 0.48197332f, 0.48990715f, 0.47445896f, -0.27649492f, -0.87898862f, -0.30485359f, 
    0.06312936f, 0.24243115f, 0.13893411f, -0.11443544f, -0.40530577f, -0.17289281f, -0.04186252f, 0.28413484f, 
    0.30758163f, -0.07745018f, 0.42972559f, -0.01131259f, -0.46829021f, -0.06415666f, -0.06216398f, 0.04686539f, 
    -0.19546114f, -0.35646212f, -0.19251215f, -0.39939550f, -1.36541855f, 0.26714110f, 0.51578963f, 0.53323305f, 
    -1.02178538f, -1.27078855f, 0.34027621f, -0.45242438f, -0.29764515f, 0.43647778f, 0.71028835f, 0.03819213f, 
    0.28204632f, -0.39015162f, -0.00833472f, 0.17183237f, -0.21830645f, -0.38884738f, -0.54623306f, -0.08518646f, 
    0.19030489f, 0.09053805f, -0.34573773f, -0.13206680f, -0.37635532f, -0.16460153f, -0.17995651f, 0.58836490f, 
    0.72414774f, 0.38579151f, 0.39038044f, -0.48525989f, -0.56364632f, -0.40086278f, -0.40734828f, -0.20193231f, 
    0.17953399f, -0.27695838f, -0.14724040f, -0.03917126f, 0.10636459f, 0.23033343f, 0.13067628f, -0.16214338f, 
    0.16598509f, 0.00213645f, 0.06612120f, 0.22994089f, 0.07183230f, -0.48310503f, -0.87861264f, -0.72675276f, 
    -0.62547338f, -0.63057733f, 0.32092789f, 0.17222798f, 0.09624707f, -0.26181391f, -0.36724526f, -0.40201241f, 
    0.14413579f, 0.10203355f, -0.29688880f, -0.15706374f, -0.25118098f, -0.92936552f, -0.35182470f, 0.30540156f, 
    -0.08780452f, -0.13414930f, 0.19187136f, -0.27059618f, 0.13800897f, 0.15059717f, 0.39879930f, 0.86837375f, 
    0.23965824f, -0.10825343f, 0.31066182f, -1.10911477f, -1.04471934f, -0.11869677f, 0.34977815f, 0.17441416f, 
    -0.14119452f, -0.34025931f, -0.07704893f, -0.11099319f, -0.41242045f, -0.16385567f, 0.17783032f, 0.07387559f, 
    0.22507618f, -0.11776266f, -0.12978449f, 0.10663296f, -0.11192419f, 0.16914631f, -0.13347375f, -0.01354758f, 
    -0.50765634f, 0.28349480f, 1.16541076f, 0.20905778f, 0.19618744f, 0.03199342f, -0.29471913f, -0.58804297f, 
    -0.60449779f, 0.25085923f, -0.21442993f, 0.34354782f, -0.02612257f, 0.29063490f, -0.60940915f, -0.30779979f, 
    0.30048606f, -0.06530707f, 0.22213541f, 0.12516780f, -0.15121241f, 0.03583238f, 0.18663725f, 0.02791716f, 
    -0.26456589f, -0.40636104f, -0.60101169f, -0.48420694f, -0.49829438f, 0.07836906f, 0.43531695f, 0.40071362f, 
    0.47459331f, 0.01388455f, -0.04138834f, 0.52532035f, -0.01840958f, 0.03143627f, -0.32603103f, -0.30499443f, 
    -0.27968654f, 0.04418532f, -0.21882527f, -0.40371531f, 0.02076367f, -0.15370387f, -0.17957680f, 0.41701883f, 
    0.69441152f, -0.98179448f, -0.12949543f, 0.44731212f, 0.72218847f, 0.27860075f, -0.49418074f, -0.53166252f, 
    0.43101060f, 0.20103107f, 0.34716368f, -0.38723925f, 0.01277337f, 0.28935167f, -0.02281469f, -0.29819709f, 
    0.38556722f, -0.00465733f, 0.20119019f, -0.36608192f, 0.10975453f, -0.03772412f, -0.51361048f, -0.09348486f, 
    0.25218135f, -0.05987708f, 0.77483630f, -0.71867400f, 0.04366615f, 0.42485490f, -0.21146259f, -0.11362916f, 
    0.96977854f, -0.37811434f, -0.70313513f, 0.30385250f, -0.14416249f, -0.00127905f, 0.01064248f, -0.13552265f, 
    -0.03854036f, 0.15348481f, -0.33155248f, -0.01323886f, 0.23833533f, -0.04997315f, -0.18992014f, -0.00457589f, 
    0.19229621f, 0.04389294f, -0.05228371f, 0.37816310f, -0.49959987f, -0.75113875f, -0.61198068f, -0.53465313f, 
    0.29006112f, -0.34153655f, -0.11687559f, -0.12278727f, 0.32884687f, 0.44574869f, 0.14984840f, 0.42595997f, 
    0.27677536f, 0.26512200f, 0.02043710f, -0.03225882f, 0.09985202f, -0.18636219f, -0.23780140f, -0.33603290f, 
    -0.15745459f, 0.18240644f, 0.04361005f, -0.26545173f, 0.17897326f, -0.06182817f, -0.29207596f, -0.43440789f, 
    -1.00522113f, -0.87461215f, -0.81171811f, -0.79916042f, -0.87742192f, -1.03917778f, 0.32028824f, -0.36500743f, 
    -0.03049885f, 0.25843960f, 0.12832026f, 0.22577484f, 0.25414777f, -0.08634694f, -0.14948812f, -0.08322833f, 
    -0.27466953f, -0.17608356f, -0.11953189f, -0.22823580f, 0.03713693f, -1.19171727f, -0.39642727f, -0.49581483f, 
    -0.68764699f, -0.83585393f, 0.69835949f, 0.44290891f, 0.30659646f, 0.33706069f, 0.80139816f, -0.00887806f, 
    0.14866720f, -0.03422776f, -0.00765832f, -0.15144797f, 0.05937028f, 0.11280742f, -0.17738824f, 0.02880596f, 
    -0.01933931f, -0.07355710f, 0.02986700f, 0.12783901f, -0.07863733f, -0.10337906f, -1.64295566f, 0.27779651f, 
    -0.22051404f, 0.04979365f, 0.69987810f, 0.52056664f, 0.11400991f, 0.21855250f, 0.26110259f, -0.11755008f, 
    0.08287916f, -0.19573991f, 0.01041928f, -0.19833101f, -0.13001427f, 0.06321699f, -0.07327611f, -0.26731411f, 
    -0.02829955f, -0.43535331f, 0.18982869f, 0.35971341f, -0.16948937f, 0.09704242f, -0.06973035f, -0.26583967f, 
    0.18123749f, 0.37794730f, 0.33865687f, 0.04106623f, 0.30815271f, 0.51799774f, 0.39984900f, -0.19411933f, 
    -0.11798798f, -0.04911200f, 0.09316132f, -0.34878629f, -0.20915484f, 0.29308543f, -0.16479985f, -0.13203815f, 
    -0.22326209f, -0.44991854f, 0.17636672f, -0.04326837f, -0.02603109f, -0.02975178f, -0.10478042f, -0.02544129f, 
    -0.23104239f, -0.05417627f, -0.15336950f, 0.42523438f, 0.28816032f, 0.14526524f, -0.43091321f, -0.02616986f, 
    0.52817363f, -0.08390544f, -0.44177619f, -0.00288957f, -0.17772105f, 0.40385097f, 0.26929882f, -0.01457477f, 
    0.19281763f, -0.25249624f, -0.32349735f, -0.12103325f, 0.04037082f, 0.32447401f, -0.13153653f, -0.20482279f, 
    0.19520931f, -0.12394886f, 0.10994380f, 0.37520713f, -0.30859256f, -0.10244782f, -0.02025073f, -0.23529390f, 
    0.12132096f, -0.33150265f, -0.48292950f, -0.21647368f, -0.42060816f, -0.20706837f, 0.75863552f, -0.64567435f, 
    0.30121100f, 0.17343089f, -0.15580650f, -0.13774367f, 0.09326888f, -0.55238378f, -0.32136223f, -0.01415089f, 
    0.35150039f, 0.41745839f, -1.13828015f, -0.03144901f, -0.19277303f, -0.58372039f, 0.14560710f, 0.07948823f, 
    -0.41541862f, 0.10065654f, 0.80972105f, 0.62221444f, 0.04488195f, -0.41239116f, 0.42662737f, -0.54161310f, 
    0.25958398f, -0.30206910f, -0.40592730f, 0.07987798f, 0.23008806f, 0.07924490f, 0.11288286f, 0.13705039f, 
    0.18109512f, 0.09143753f, 0.01125996f, 0.76584995f, -0.78078771f, 0.13715823f, 0.41241756f, -0.49743077f, 
    0.36347553f, 0.13665490f, -0.42758799f, -0.62366462f, 0.12370794f, -0.11350862f, -0.22423092f, -0.25463426f, 
    -0.05522354f, 0.48684862f, -0.33063719f, -0.16653307f, -0.13311014f, 0.22008336f, 0.31860453f, -0.06750693f, 
    -0.36358881f, -0.31750536f, -0.40552431f, -0.74023008f, 0.56846529f, 0.40829131f, 0.64965308f, 0.68164176f, 
    -0.15575479f, -0.40205351f, 0.12224806f, -0.36878332f, -0.57225543f, -0.44435710f, 0.31249711f, 0.16404641f, 
    -0.02760684f, 0.05975810f, 0.24659213f, 0.31178573f, 0.03516141f, -0.10614582f, -0.38656244f, 0.41915977f, 
    -0.06937151f, -0.04076287f, 0.17657796f, 0.16955009f, -0.15583742f, -1.42184746f, 0.58341879f, -0.53503859f, 
    -0.18646112f, 0.67850703f, 0.09361044f, 0.02591774f, 0.31407467f, 0.01277838f, 0.04088641f, -0.37867463f, 
    -0.35681972f, -0.14452986f, -0.25707218f, -0.09894133f, 0.38136005f, -0.29155105f, -0.41337454f, -0.23760578f, 
    -0.14196685f, -0.32737479f, -0.27026248f, -0.39539850f, -0.46611282f, -0.69732839f, 0.94924706f, -0.70721436f, 
    -0.65428704f, 0.17099835f, 0.00462025f, -0.12411995f, 0.04648902f, 0.46791875f, 0.34837002f, 0.29468685f, 
    0.05361670f, 0.39096752f, -0.40098977f, -0.32617003f, -0.10658205f, -0.24806666f, 0.00008890f, 0.17560568f, 
    -0.04363478f, -0.15488316f, 0.14169589f, 0.14268170f, -0.04939225f, -0.32122579f, -0.24967645f, 0.20966095f, 
    -1.28576684f, -0.18519759f, 0.42801616f, 0.65832829f, -0.47292924f, -0.30413851f, -0.03432517f, -0.15822829f, 
    0.00762193f, 0.30361322f, -0.29888022f, 0.42632720f, -0.64918453f, 0.31943396f, 0.17795579f, 0.07160029f, 
    0.09568358f, 0.20671970f, 0.29031539f, -0.21361053f, -0.33217272f, -0.28074393f, 0.04243465f, 0.11157567f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.13465086f, 0.38584945f, -0.01210176f, 0.28983486f, -0.26063961f, 0.29449287f, 0.39497545f, -0.17449324f, 
    0.05997287f, 0.01450375f, 0.47496483f, 0.27559397f, 0.08423765f, 0.08288625f, 0.21084946f, 0.01997673f, 
    0.51446468f, 0.48798725f, 0.32280666f, 0.27091464f, -0.18742941f, 0.16802701f, 0.24789310f, -0.04443064f, 
    0.56566662f, 0.37273493f, 0.41636360f, 0.13591397f, 0.32359102f, -0.12527509f, 0.18101098f, 0.23766126f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.40532646f, 0.25522393f, 0.02643861f, -0.29718819f, -0.06741136f, 0.04229307f, -0.03521595f, -0.02204922f, 
    0.01886410f, 0.00934416f, -0.04717187f, -0.05130629f, -0.47738105f, 0.08223328f, 0.30034378f, -0.27503225f, 
    -0.05979567f, 0.10108494f, 0.01152799f, -0.05334062f, 0.19034144f, -0.04958430f, 0.00570033f, -0.05139129f, 
    0.44457257f, 0.34271106f, -0.03765877f, -0.19859749f, 0.11774820f, 0.38814589f, 0.13513209f, 0.05049912f, 
    0.01105666f, 0.00126824f, 0.03330703f, -0.02784461f, 0.24398331f, -0.68655604f, -0.72149831f, 0.07436175f, 
    -0.02632600f, 0.00829781f, 0.01270638f, -0.14052348f, 0.08033894f, -0.00687035f, -0.20169969f, 0.03991777f, 
    -0.46468523f, 0.46822569f, -0.19602039f, 0.13419756f, 0.01916350f, 0.02060890f, 0.03300722f, 0.10020010f, 
    -0.02732429f, -0.05992227f, 0.02747826f, -0.01837586f, -0.18398198f, -0.13046101f, -0.33213109f, 0.00465290f, 
    -0.07720100f, -0.19176590f, -0.02287174f, -0.30331576f, -0.15111053f, -0.11337684f, 0.03073260f, -0.05599486f, 
    0.03982040f, -0.07853378f, -0.07190766f, -0.01957086f, 0.00214735f, -0.04614301f, 0.07664192f, 0.03286739f, 
    -0.23308715f, -0.23658051f, -0.20131475f, -0.17802474f, 0.28514463f, 0.14339679f, -0.07702128f, -0.09152035f, 
    -0.07637307f, -0.16698062f, -0.26322189f, -0.28551942f, -0.26633567f, -0.22000171f, -0.06323116f, 0.01334754f, 
    0.76702440f, 0.14623578f, -0.09563475f, -0.58955151f, 0.05878093f, -0.17825557f, 0.08470442f, 0.10155219f, 
    0.06905793f, -0.10105514f, -0.00435004f, -0.06708011f, -0.06326347f, -0.13371478f, -0.06845339f, 0.04542686f, 
    -0.09014965f, 0.06612150f, 0.00082925f, 0.04174740f, -0.06708757f, -0.14904518f, -0.01001142f, -0.00561186f, 
    -0.43886885f, -0.69837689f, 0.17853691f, 0.02541769f, 0.04805959f, 0.02910743f, -0.19208279f, 0.06829043f, 
    -0.04260363f, -0.28887296f, -0.15067965f, -0.14263073f, 0.29998496f, 0.50843310f, 0.21900831f, -0.46123388f, 
    -0.13905817f, -0.06426433f, -0.14397883f, -0.18642327f, 0.02846693f, -0.10293283f, -0.25846288f, -0.08850087f, 
    0.25219142f, 0.20666404f, -0.18514991f, -0.09598310f, -0.08825114f, -0.19669831f, 0.05218197f, -0.00315813f, 
    -0.05565059f, -0.04706756f, 0.09400357f, 0.04995047f, 0.37092459f, 0.08323421f, -0.16185567f, -0.15464841f, 
    0.18473004f, -0.04502103f, 0.00801154f, -0.16769944f, -0.08272371f, -0.08895431f, -0.08170154f, 0.10644070f, 
    -0.69578630f, 0.49584854f, 0.09691899f, -0.10564341f, -0.01356611f, -0.01203497f, -0.01355262f, 0.07162563f, 
    -0.00100321f, 0.01199902f, 0.03890419f, 0.08596237f, 0.03782007f, -0.29248932f, -0.00623987f, -0.24578419f, 
    -0.04614455f, -0.10287835f, 0.03127632f, -0.01205602f, 0.01509222f, 0.02305784f, 0.05308940f, 0.11994539f, 
    -0.23712555f, -0.26328111f, -0.13562882f, -0.00230283f, 0.16171120f, 0.09625316f, -0.04715249f, -0.08916621f, 
    -0.13157044f, -0.21118931f, 0.01474759f, -0.12626764f, -0.21489526f, -0.00113679f, 0.27758837f, -0.05387440f, 
    -0.01793623f, -0.03951387f, 0.05839698f, 0.13274790f, -0.30674583f, -0.21553032f, -0.11695099f, 0.09197228f, 
    -0.14048141f, -0.09817106f, 0.04189206f, 0.06856236f, -0.02243450f, -0.13432479f, 0.10657429f, -0.08831745f, 
    -0.05340315f, -0.02254066f, 0.01258253f, 0.03599208f, 0.28368455f, 0.13874581f, -0.10596425f, 0.11318620f, 
    0.00092327f, 0.07482592f, 0.00495880f, -0.02384794f, -0.10298990f, 0.05720612f, -0.03004792f, 0.08092206f, 
    0.34454817f, 0.18184222f, -0.11002808f, -0.34558296f, 0.11836583f, 0.07806053f, -0.09740818f, 0.14790629f, 
    0.00698662f, 0.07744244f, 0.03705556f, 0.01859192f, -0.07615622f, -0.17364395f, 0.10214797f, 0.05354171f, 
    0.18622884f, 0.26001057f, 0.03354019f, 0.07577094f, -0.04217599f, 0.16767670f, 0.03211444f, 0.04279184f, 
    0.19104800f, 0.23353472f, 0.16788483f, -0.30613524f, -0.07844147f, 0.12351447f, 0.12977593f, -0.00422686f, 
    -0.27033654f, -0.03875438f, -0.26362863f, -0.15587282f, 0.03531174f, -0.15790176f, -0.19656526f, -0.16704455f, 
    -0.00109991f, 0.01063269f, 0.09388471f, 0.03222667f, -0.06856161f, -0.04504601f, 0.11771379f, 0.00689068f, 
    -0.65735418f, -0.18602601f, 0.09391396f, -0.27909100f, -0.14442749f, -0.10993800f, 0.12804969f, 0.05802665f, 
    0.01063648f, -0.01887460f, -0.18045139f, -0.43629903f, -0.05096943f, -0.10782264f, -0.27593651f, -0.24598081f, 
    0.00891369f, 0.00190531f, 0.02750676f, 0.11032666f, -0.07547889f, -0.00300535f, -0.06913322f, 0.03035674f, 
    -0.13068441f, 0.19019127f, 0.24787907f, -0.29165030f, -0.11525328f, 0.09714027f, 0.08511120f, -0.20442158f, 
    0.08536140f, -0.03597521f, -0.07085133f, -0.20015356f, 0.15959464f, 0.01380688f, -0.08759852f, -0.18629047f, 
    -0.03348846f, -0.13425058f, -0.03015902f, -0.18095185f, 0.03917005f, -0.07877663f, 0.12260890f, 0.13901705f, 
    -0.15187837f, -0.12791009f, -0.10418725f, -0.11307783f, -0.29903412f, -0.20719747f, -0.19143312f, 0.03388679f, 
    -0.04793734f, 0.06346209f, 0.03647837f, 0.00814371f, -0.02653551f, 0.23303640f, -0.09401366f, 0.00356806f, 
    -0.03805075f, 0.20076084f, 0.02053913f, 0.01744014f, 0.06298190f, 0.12320843f, 0.19943109f, 0.13987882f, 
    -0.24903411f, 0.02421949f, 0.00214159f, 0.10745882f, 0.05954862f, -0.02754197f, 0.07195202f, 0.06944129f, 
    -0.06245684f, -0.07346278f, -0.22131577f, 0.03994424f, 0.20491248f, 0.03979259f, 0.08287236f, -0.14349476f, 
    0.09355352f, -0.11939688f, 0.02903913f, -0.24587810f, 0.03072513f, 0.02631476f, -0.03414506f, 0.00781701f, 
    0.08690285f, 0.08474045f, 0.20167021f, 0.38933527f, -0.14014018f, 0.04374818f, -0.05186565f, 0.10137350f, 
    -0.08268028f, -0.00694409f, 0.03705674f, -0.06929754f, -0.42867410f, 0.04685204f, 0.03915454f, -0.24677117f, 
    0.22472033f, -0.16074190f, -0.25008836f, -0.08122032f, 0.05136759f, 0.02240374f, -0.04230212f, -0.20904079f, 
    0.32733738f, 0.26696506f, 0.18889342f, 0.13411596f, 0.21442744f, -0.06106777f, -0.19918793f, -0.29767245f, 
    0.00111028f, -0.00496635f, -0.12274165f, -0.20421742f, 0.98281109f, -0.16125607f, -0.16369535f, 0.01224402f, 
    -0.01809731f, -0.01145214f, -0.04213915f, -0.08914654f, 0.08761641f, -0.27210042f, -0.14938551f, 0.16604789f, 
    0.08050826f, 0.20705931f, 0.03696067f, -0.05610901f, -0.04845876f, 0.00900160f, -0.10921682f, 0.10279460f, 
    -0.01420579f, -0.00710416f, -0.09799244f, -0.12811638f, 0.10088766f, 0.13720007f, 0.07411040f, -0.00031957f, 
    0.10206215f, 0.16131650f, -0.11208075f, -0.01066718f, 0.01118781f, 0.02971705f, 0.15599893f, -0.08041009f, 
    0.07814458f, 0.00598409f, 0.16449653f, 0.23260884f, -0.05292707f, 0.05083558f, 0.12244203f, -0.03384595f, 
    0.18593557f, -0.12249646f, -0.04560873f, 0.03200429f, 0.22162484f, 0.03527055f, 0.20273286f, -0.28091067f, 
    -0.00616031f, 0.12407900f, 0.03651457f, 0.39339882f, -0.08502834f, -0.01238456f, -0.27316058f, -0.07940225f, 
    -0.30025497f, -0.24304874f, -0.39703834f, -0.13580434f, -0.03936884f, -0.24305877f, 0.04363436f, 0.10288004f, 
    0.20374858f, -0.03633321f, 0.12218626f, -0.20864499f, 0.15107675f, 0.04077074f, 0.21561308f, -0.01689682f, 
    0.07572915f, 0.08011578f, -0.08647516f, -0.02017884f, 0.01605753f, -0.03986388f, -0.03022452f, 0.10471726f, 
    0.18050894f, -0.00060039f, 0.22080475f, -0.15240642f, 0.06466398f, 0.08930253f, -0.00284735f, 0.01646266f, 
    0.08668752f, 0.09015600f, -0.30170920f, -0.08982137f, -1.02486432f, -0.12783356f, -0.75033569f, -0.06946510f, 
    -0.24352053f, 0.02731815f, 0.25194085f, 0.29815426f, -0.13986261f, 0.12974991f, -0.14513879f, 0.12343889f, 
    -0.10560617f, -0.27470329f, 0.08338172f, 0.11583079f, -0.06070099f, -0.05412606f, 0.11400031f, -0.03555167f, 
    0.02404886f, 0.03395222f, 0.03863928f, 0.02697822f, 0.17456801f, 0.32916263f, 0.21655260f, 0.18253955f, 
    -0.14280848f, 0.23317747f, 0.10715546f, -0.04379767f, -0.02564042f, 0.02052031f, -0.02238661f, 0.07112098f, 
    -0.09900655f, 0.09889321f, 0.40407130f, -0.10579795f, 0.02802650f, -0.07815791f, -0.16979119f, 0.00804226f, 
    -0.04177302f, -0.05651553f, 0.04189113f, 0.01986942f, -0.13309519f, 0.11639797f, -0.02885416f, 0.01115886f, 
    -0.08964074f, -0.07682818f, 0.03551538f, -0.14066201f, 0.05419836f, -0.04161912f, 0.15766460f, 0.08385169f, 
    0.01674054f, -0.35387051f, -0.31748584f, -0.36742726f, 0.01249419f, 0.18959887f, 0.17274506f, -0.04509057f, 
    0.25501683f, 0.22426131f, -0.04393560f, -0.06833307f, -0.28508544f, 0.16732903f, 0.12105818f, 0.09193379f, 
    0.02389483f, 0.07568531f, 0.00031191f, -0.01494720f, -0.07638772f, -0.01118425f, 0.03975813f, 0.08772297f, 
    0.73074156f, 0.19155918f, -0.10154687f, 0.00539992f, -0.10067963f, 0.06486714f, 0.05178772f, 0.01910633f, 
    -0.13897319f, -0.01666381f, 0.21388027f, 0.02115502f, -0.11960980f, -0.15808222f, -0.14333765f, -0.16694683f, 
    0.11722916f, 0.00479849f, 0.02407494f, 0.04651028f, 0.14698751f, 0.20340538f, 0.07191644f, -0.05713412f, 
    0.04369206f, -0.00311398f, 0.06859250f, -0.07130343f, 0.08739719f, -0.25281781f, -0.05974479f, -0.07501883f, 
    -0.00605778f, -0.02874197f, 0.01875907f, 0.12522034f, 0.29153895f, 0.11647198f, -0.32955536f, -0.07964534f, 
    0.02109720f, 0.07249391f, -0.09581234f, -0.22704418f, -0.13918336f, -0.04250896f, -0.13836420f, -0.13608076f, 
    -0.41160193f, -0.07055026f, 0.07406511f, 0.36783004f, -0.00610274f, -0.03906339f, -0.07009373f, 0.07551887f, 
    -0.03673382f, -0.04608042f, -0.05644561f, 0.19164321f, 0.48084694f, 0.08489170f, 0.41532665f, 0.12294387f, 
    -0.04335958f, 0.02474452f, -0.04019451f, -0.03711499f, 0.15435891f, 0.05049012f, -0.08370958f, -0.21124975f, 
    -0.08762193f, 0.30999234f, 0.03521680f, 0.17025104f, 0.12761171f, 0.08970878f, -0.07934059f, 0.06132329f, 
    -0.04442826f, 0.03496585f, 0.15589382f, 0.14074536f, 0.18924759f, -0.19633530f, -0.25460917f, 0.06291629f, 
    0.00271896f, 0.01705099f, 0.19169283f, -0.22064449f, 0.23603025f, 0.01449718f, -0.20866212f, -0.02872757f, 
    -0.67738849f, 0.43511903f, -0.31814119f, -0.21667363f, 0.11647918f, 0.11808657f, 0.05663566f, 0.08787106f, 
    -0.20316464f, 0.17884232f, -0.11780061f, -0.08410293f, 0.33632857f, 0.13699944f, -0.10999829f, -0.18521582f, 
    0.01285323f, 0.00514914f, -0.12521611f, -0.05438524f, -0.27346221f, -0.04464930f, 0.40164927f, -0.23925640f, 
    0.25921729f, 0.06817661f, -0.00768007f, -0.09677579f, -0.30124182f, -0.07634491f, -0.05274987f, -0.00633987f, 
    -0.07608705f, 0.04247637f, 0.02501601f, 0.08018246f, -0.36534569f, -0.26646277f, 0.00361748f, 0.09393103f, 
    0.00812420f, 0.00067732f, -0.09476626f, -0.00556810f, -0.46572384f, -0.17617522f, -0.38294011f, -0.32872939f, 
    0.37143761f, 0.08631170f, 0.13223465f, 0.03920974f, -0.04647985f, -0.03455843f, -0.12947841f, 0.01682121f, 
    0.02417065f, 0.01371508f, -0.20076367f, 0.07874715f, -0.29244572f, 0.09030619f, -0.24608293f, 0.11107337f, 
    -0.29990157f, 0.05566371f, 0.08053520f, -0.10238183f, 0.01799716f, -0.23915905f, 0.03663711f, -0.03083579f, 
    -0.48258191f, -0.37888283f, -0.37802958f, -0.17448431f, 0.02482674f, -0.05076737f, 0.03599001f, 0.07013974f, 
    -0.08010828f, -0.07539029f, -0.00433410f, -0.00977973f, 0.51645499f, -0.01899708f, -0.32360575f, 0.09058076f, 
    0.00161582f, 0.09361383f, -0.17867370f, -0.03423762f, -0.05610385f, 0.07667387f, -0.04974417f, -0.02030929f, 
    -0.14046453f, 0.17402695f, 0.67663634f, 0.44088477f, 0.00677121f, -0.11369003f, 0.04774719f, 0.19612186f, 
    -0.02011959f, -0.02704252f, 0.16585925f, -0.00563282f, -0.05712416f, 0.01131948f, 0.48361540f, -0.19111523f, 
    0.01085065f, -0.09917275f, -0.02711393f, 0.01121711f, 0.12987350f, 0.18037643f, 0.05673012f, 0.10692614f, 
    0.23395756f, -0.14147797f, -0.04669485f, -0.07919001f, 0.01405756f, 0.03768899f, -0.01780830f, -0.04778282f, 
    -0.01665164f, -0.11112875f, -0.07159904f, 0.13496870f, 0.16676179f, -0.10720395f, 0.13982876f, -0.14055115f, 
    0.10809717f, -0.02146657f, -0.26238564f, 0.22765790f, 0.09934507f, -0.08189489f, 0.14004739f, -0.09983369f, 
    -0.03773204f, -0.10440463f, -0.10984573f, -0.02937484f, 0.01515136f, -0.02513639f, 0.01756667f, 0.14241810f, 
    -0.13989185f, -0.16807386f, 0.29258946f, -0.17573597f, -0.52269018f, 0.08736818f, 0.46626875f, -0.04786323f, 
    -0.07798278f, 0.00462177f, 0.04884335f, -0.17284238f, -0.03287346f, 0.05435806f, -0.26123857f, -0.04145333f, 
    -0.37143558f, 0.28385329f, -0.34938890f, 0.15499356f, -0.04266233f, -0.06393326f, -0.15411747f, 0.14007258f, 
    -0.14045374f, -0.13418645f, 0.08830055f, -0.19234933f, -0.23091047f, -0.06788662f, -0.06850601f, -0.07501009f, 
    -0.00607050f, 0.05741113f, -0.00545062f, 0.03661030f, -0.01188650f, -0.05631477f, -0.07464200f, 0.06925957f, 
    -0.03212303f, 0.11221899f, 0.00725426f, -0.06549288f, -0.02160170f, -0.05500943f, -0.06731091f, -0.07462732f, 
    0.18337761f, 0.12639380f, -0.03643544f, 0.22004835f, -0.08004611f, -0.30602732f, -0.85681248f, 0.19802321f, 
    0.00429505f, 0.03801178f, -0.00570513f, -0.11757620f, 0.03927111f, -0.06092019f, -0.07484598f, -0.08181626f, 
    -0.05426530f, 0.19441250f, -0.27007198f, -0.13873942f, 0.14991087f, -0.08173585f, 0.06630025f, -0.04509570f, 
    0.00139709f, -0.05426658f, -0.03104743f, -0.08356051f, -0.12331787f, 0.32824460f, 0.53960776f, 0.41525909f, 
    0.00650760f, -0.13994685f, 0.04376318f, 0.07193275f, -0.07894601f, 0.04166665f, -0.07522677f, -0.02295856f, 
    -0.45072371f, -0.46603751f, 0.84428751f, 0.17129683f, -0.03437744f, 0.07245857f, 0.00746279f, 0.12416943f, 
    0.02499037f, -0.03789432f, 0.03910481f, 0.03221973f, -0.09572962f, 0.41094810f, -0.35759854f, -0.22224090f, 
    -0.17853071f, -0.39772284f, -0.09285969f, 0.18225096f, -0.11987406f, 0.14410220f, -0.00078861f, -0.15060937f, 
    0.21425004f, 0.43925208f, 0.17405748f, -0.01474339f, -0.00505266f, 0.05614080f, 0.06669773f, -0.10722332f, 
    -0.20781194f, -0.07583909f, -0.24715522f, 0.08289108f, 0.08854956f, -0.04831000f, -0.19513519f, 0.14447831f, 
    0.03423666f, 0.01026571f, 0.02196570f, -0.01134536f, 0.02795538f, -0.00268913f, -0.01535247f, -0.11171310f, 
    -0.35060707f, 0.17873877f, -0.07627955f, -0.46718368f, -0.00032480f, 0.00983826f, -0.08745547f, 0.11878913f, 
    -0.03496160f, -0.09046540f, 0.12654072f, -0.03915692f, -0.02387992f, 0.14795013f, 0.15040334f, 0.05855921f, 
    -0.09066948f, -0.02052163f, 0.05172134f, -0.27129698f, 0.09254815f, -0.03234158f, 0.01229733f, 0.04766019f, 
    -1.30945873f, -0.68050945f, -0.24029404f, -0.46669123f, 0.01079249f, 0.06115148f, -0.06891041f, -0.35178560f, 
    0.00528607f, 0.04143369f, -0.03783946f, 0.02360010f, 0.30026725f, 0.34801728f, 0.38428149f, 0.35477754f, 
    -0.02182987f, 0.05067975f, 0.15728143f, -0.01975084f, 0.21093833f, -0.09515130f, -0.01471283f, 0.14096397f, 
    -0.18215978f, -0.37502819f, -0.30716079f, 0.16332644f, 0.11599679f, -0.04094697f, -0.01041085f, -0.05157688f, 
    0.05873113f, -0.10278855f, -0.19463702f, 0.00534169f, 0.09298673f, -0.11098921f, -0.62259716f, -0.24795400f, 
    -0.01488289f, -0.05619724f, 0.01656207f, 0.06914948f, -0.10280365f, 0.05446896f, -0.30318099f, 0.21187040f, 
    -0.08293135f, 0.09645478f, -0.26311669f, 0.22768360f, -0.06034184f, 0.03808605f, -0.04165129f, 0.11353262f, 
    0.00290314f, 0.02177297f, -0.26758656f, 0.13819546f, -0.11177932f, -0.01427805f, -0.18477394f, -0.08862650f, 
    0.11277109f, -0.08288009f, 0.05695967f, -0.02425287f, -0.07249157f, -0.00520996f, 0.09427390f, -0.05416890f, 
    -0.15106088f, 0.23246782f, -0.21802530f, 0.59372348f, 0.10958830f, 0.02196428f, -0.08766007f, -0.01500759f, 
    -0.08317146f, -0.03018718f, -0.00899978f, -0.04509761f, 0.01868780f, 0.11775240f, 0.10809188f, -0.14998212f, 
    0.00176428f, -0.11192007f, -0.08718223f, -0.11254807f, 0.17106202f, 0.31058818f, -0.05659736f, 0.12684964f, 
    -0.32845700f, 0.11627807f, 0.00200977f, -0.04331081f, -0.08936156f, -0.20885035f, -0.11974513f, -0.00335255f, 
    -0.02467902f, 0.01029561f, -0.04810276f, 0.04324390f, 0.08663649f, -0.05746793f, -0.14648502f, 0.27491027f, 
    -0.02306951f, -0.05126551f, -0.00571408f, -0.05326519f, 0.14326039f, 0.21660069f, 0.11070395f, 0.12758245f, 
    -0.18688624f, 0.13168144f, 0.00587146f, 0.10297649f, -0.06173928f, -0.00590055f, -0.01605105f, -0.02171338f, 
    -0.10827863f, 0.06639495f, -0.01852068f, 0.27652118f, 0.05057848f, -0.06364135f, -0.13303192f, 0.11002310f, 
    -0.10981761f, 0.18740790f, -0.07842516f, -0.00710364f, -0.07583093f, 0.04701715f, 0.09396131f, -0.04928385f, 
    0.14238478f, -0.00404297f, -0.04702635f, 0.30087405f, 0.04087213f, 0.09715921f, -0.02148826f, 0.10945293f, 
    0.12247951f, 0.08214070f, -0.04527976f, -0.02718641f, 0.78057933f, 0.25379023f, 0.09622568f, -0.41479063f, 
    0.08361942f, 0.02286640f, -0.03106514f, -0.20678169f, -0.04719692f, -0.09205122f, 0.00170088f, -0.03525135f, 
    0.05337633f, -0.16619761f, -0.08042181f, 0.10018510f, 0.13144523f, 0.01031937f, 0.02166206f, -0.16166937f, 
    0.02156859f, 0.12981932f, 0.14447032f, 0.14919576f, -0.39355290f, 0.85707140f, -0.32635495f, 0.12752299f, 
    0.15307677f, 0.01450377f, 0.01255253f, -0.05882484f, -0.20733103f, 0.26310942f, -0.03552491f, 0.13614811f, 
    0.01988943f, 0.25926304f, -0.01811433f, -0.17787732f, -0.29583851f, -0.03926035f, -0.09236302f, 0.01720289f, 
    0.15921709f, 0.02238343f, -0.07257625f, 0.19828209f, -0.21640036f, -0.17569226f, -0.50972468f, -0.17682691f, 
    -0.03092491f, 0.08509361f, -0.34751210f, -0.29361379f, -0.09338845f, -0.22604306f, -0.02682750f, -0.12857544f, 
    -0.55797631f, 0.44465175f, -0.40094003f, -0.71090275f, 0.18599983f, 0.09612938f, -0.01553201f, 0.04811218f, 
    -0.36541274f, -0.29078925f, -0.18099996f, -0.21129088f, -0.14215709f, -0.10698829f, 0.04552676f, 0.28705430f, 
    -0.02130948f, -0.00798464f, -0.09492411f, -0.10830462f, -0.04996546f, 0.13653001f, -0.03470928f, 0.10708423f, 
    -0.41225505f, 0.50640881f, -0.05186291f, 0.06765088f, -0.05830738f, 0.01113762f, -0.12136175f, -0.03497322f, 
    -0.12203295f, -0.03108718f, 0.03977057f, -0.01204032f, 0.02658419f, 0.05132714f, -0.02962810f, 0.15360636f, 
    -0.04756490f, 0.00748206f, -0.18689126f, -0.04953632f, -0.22276716f, 0.07401589f, -0.00319571f, -0.09016270f, 
    -0.09373424f, -0.24254903f, 0.25271800f, 0.02751138f, -0.30967122f, -0.11962363f, -0.21490273f, 0.08731535f, 
    -0.10393261f, 0.08641662f, 0.03567744f, 0.08586098f, 0.11553188f, -0.08066913f, -0.28306380f, 0.06434919f, 
    0.09349151f, -0.03670785f, -0.06210216f, 0.21265782f, -0.09802067f, -0.03911928f, 0.00931623f, 0.01213443f, 
    -0.08116850f, 0.57385707f, -0.27457583f, 0.28635335f, 0.00020721f, 0.06897488f, -0.07061130f, -0.08254678f, 
    -0.14772592f, 0.11562103f, -0.08528009f, 0.14183323f, -0.21325769f, -0.09776945f, -0.05498878f, 0.31398526f, 
    0.08820731f, -0.02857758f, -0.01751661f, -0.01235923f, 0.01458417f, -0.09156420f, 0.21012796f, -0.00279849f, 
    -0.02764779f, -0.48102462f, 0.32590860f, -0.09137424f, -0.53250903f, -0.18103674f, -0.14930253f, -0.03544105f, 
    -0.00562440f, 0.20325802f, 0.10568518f, -0.01983055f, -0.01328806f, 0.60064638f, -0.22254826f, 0.56267118f, 
    0.18006617f, -0.07747695f, 0.14582673f, -0.03000530f, -0.10062762f, -0.09980535f, 0.13366781f, 0.18630184f, 
    0.01730920f, 0.01396206f, -0.00936006f, 0.29043835f, 0.15291357f, -0.17620037f, 0.06086138f, -0.09447403f, 
    -0.15968411f, 0.03771736f, 0.01947983f, 0.05779445f, 0.01662791f, 0.48709565f, -0.30536792f, -0.59910345f, 
    -0.24810515f, -0.26518732f, -0.00169212f, -0.10794943f, 0.02569682f, 0.15266337f, -0.19492491f, -0.01486573f, 
    -1.24720073f, 0.27651128f, -0.58444822f, 0.26558393f, 0.19949391f, -0.23082662f, 0.04244634f, -0.09761930f, 
    0.05894298f, -0.23612565f, 0.02571774f, -0.11840787f, -0.61502486f, -0.40556446f, -0.13146876f, 0.13109587f, 
    0.08684839f, 0.13314751f, 0.16953112f, -0.11008174f, 0.02581797f, -0.11130111f, 0.00503760f, 0.06059318f, 
    -0.05078018f, -0.30920744f, 0.15371545f, 0.26482594f, -0.12193844f, 0.16164467f, -0.02369009f, 0.15941539f, 
    0.06573037f, -0.02669708f, -0.02460450f, -0.16358082f, 0.45027074f, -0.39473909f, 0.09265102f, 0.12585920f, 
    0.31472179f, 0.15072453f, 0.08224943f, -0.00518368f, -0.10465357f, 0.00912567f, 0.00841533f, 0.15284051f, 
    0.34426114f, 0.29294068f, -0.09231493f, -0.42978382f, 0.23608254f, 0.21477717f, 0.04885824f, -0.03557958f, 
    -0.35177645f, -0.09619109f, 0.00895987f, 0.00354012f, -0.26501560f, 0.16076112f, 0.02030561f, -0.44840264f, 
    0.06049710f, -0.08342975f, 0.03201139f, 0.11005935f, -0.10349670f, -0.11905423f, 0.00042026f, -0.02461875f, 
    0.28229192f, 0.11649626f, -0.16798261f, -0.68801689f, -0.07355573f, -0.10844248f, -0.09254664f, 0.11330171f, 
    -0.22220242f, 0.10241652f, -0.13981162f, -0.13856967f, 0.11251080f, -0.12907806f, 0.07625656f, -0.02465112f, 
    -0.47218999f, -0.02017143f, -0.32468355f, -0.11481694f, -0.11610424f, -0.10247023f, 0.14710660f, -0.23667380f, 
    0.96241546f, -0.08501421f, -0.16990061f, -0.06215819f, 0.23102178f, -0.07330296f, -0.08120783f, -0.00472935f, 
    0.12570389f, -0.06663773f, -0.09300869f, 0.04888022f, -0.65992510f, -0.05906213f, 0.15717922f, 0.40208083f, 
    -0.02955161f, -0.09370808f, 0.00934721f, -0.05093971f, 0.06435477f, 0.05887768f, 0.04344912f, 0.02974153f, 
    -0.00110718f, -0.14206952f, 0.15871355f, 0.36899105f, 0.09862232f, -0.31188038f, 0.00060268f, 0.02823861f, 
    0.06741264f, 0.01535721f, 0.09188817f, 0.04994275f, 0.38999236f, -0.00513219f, -0.20833279f, -0.18242900f, 
    0.11183698f, 0.02066732f, 0.15542185f, -0.07106477f, -0.08690807f, 0.07234621f, -0.06439506f, 0.07532572f, 
    -0.46172953f, 0.18930113f, -0.03919933f, -0.02081091f, -0.01579798f, 0.26755205f, -0.00694462f, -0.00772127f, 
    -0.27615234f, 0.16519482f, -0.17740712f, -0.01431774f, -0.22146797f, 0.63124448f, -0.35914809f, 0.07919073f, 
    -0.00440822f, -0.13973722f, -0.08518046f, -0.16998848f, 0.23121849f, -0.01220949f, -0.10162715f, -0.05421187f, 
    0.17576471f, 0.19054486f, 0.19566235f, 0.24423623f, -0.08846706f, -0.01993726f, 0.07341928f, -0.03257842f, 
    0.12799582f, 0.03284392f, 0.04368576f, 0.02244297f, 0.02719275f, -0.29383415f, -0.39129063f, 0.23378547f, 
    -0.10103696f, -0.10574668f, 0.05984400f, -0.48076704f, -0.00968320f, -0.32948521f, -0.00437295f, 0.13356759f, 
    -0.34856036f, -0.18104024f, -0.11675886f, 0.23287970f, -0.02281270f, -0.03474826f, -0.14151676f, -0.22057289f, 
    -0.05841836f, 0.06628340f, -0.08483181f, 0.19212320f, -0.12026576f, -0.37244642f, -0.36244941f, -0.25334588f, 
    0.02213835f, 0.02294731f, -0.11326374f, -0.02459488f, 0.08245342f, -0.09409063f, -0.19115324f, 0.10825585f, 
    0.68324018f, -0.12515925f, -0.26113150f, 0.38682324f, 0.07383741f, -0.10664061f, 0.03571708f, -0.04338393f, 
    -0.04614751f, -0.01105263f, 0.11937459f, 0.10787979f, -0.01692265f, 0.15988173f, -0.37625080f, 0.00584330f, 
    -0.02389173f, -0.13712101f, 0.12809539f, -0.05339110f, -0.24272655f, -0.09421686f, -0.00949762f, -0.26471260f, 
    0.18579416f, -0.02582041f, -0.09357200f, -0.05855749f, 0.08496865f, 0.07682477f, 0.02633116f, -0.01030088f, 
    -0.18079451f, 0.00686185f, -0.06042185f, -0.04920091f, -0.07768650f, 0.06893257f, 0.00384710f, 0.10535982f, 
    0.06193447f, -0.04760418f, -0.00838367f, -0.08152967f, 0.07245491f, -0.03666340f, -0.01198420f, 0.16157661f, 
    0.15814635f, -0.56491363f, 0.30099538f, 0.11689546f, -0.28184515f, 0.18605147f, -0.07004733f, -0.12115291f, 
    -0.17892724f, 0.02552980f, -0.09960648f, 0.26183513f, 0.05442586f, 0.07400110f, 0.09236076f, 0.03461674f, 
    -0.01090559f, -0.06436533f, 0.03420945f, 0.08804002f, 0.08611219f, -0.02410807f, -0.16300766f, -0.26514730f, 
    -0.12498720f, 0.14774787f, -0.22115779f, 0.04017769f, 0.02001094f, -0.14965065f, -0.14948387f, -0.14285649f, 
    -0.10295706f, -0.00898039f, 0.10103855f, 0.00353264f, 0.16940090f, -0.00492227f, 0.51351851f, 0.01228685f, 
    -0.13894539f, 0.04276485f, -0.05633163f, -0.20874435f, 0.02620525f, -0.05082216f, 0.15757562f, -0.01607751f, 
    0.11135487f, -0.39170691f, 0.42929998f, 0.15404770f, 0.14571877f, 0.32420033f, 0.04460284f, 0.18500000f, 
    -0.00906685f, -0.08233166f, -0.04910186f, -0.07070287f, -0.06373354f, -0.00183492f, 0.10331262f, 0.09726042f, 
    -0.17094384f, -0.09835018f, -0.08694297f, -0.26464370f, -0.00520690f, 0.03628548f, -0.02107356f, 0.01241387f, 
    0.42420018f, -0.23644562f, -0.21180722f, 0.10142490f, -0.08991925f, 0.12335403f, 0.10949997f, 0.09840769f, 
    0.08854606f, 0.00574365f, 0.04437857f, -0.01704580f, -0.14600714f, -0.14190398f, 0.27273449f, 0.19765194f, 
    0.26867154f, -0.20434615f, 0.07120845f, 0.09240901f, -0.08162795f, 0.04049742f, -0.06502156f, -0.04605249f, 
    0.13148910f, 0.17096931f, -0.00794239f, 0.16018669f, -0.09160863f, -0.07309812f, -0.07525203f, 0.00390283f, 
    -0.27761540f, -0.24967441f, 0.02674429f, -0.23782207f, 0.00414306f, -0.20571363f, -0.00108937f, -0.01712933f, 
    -0.06775311f, -0.03400851f, 0.02982693f, -0.02502831f, -0.22463439f, 0.04957783f, -0.03726021f, 0.10820234f, 
    -0.22143649f, -0.50535375f, -0.11974856f, -0.32949293f, 0.03097641f, 0.04086629f, -0.05118725f, 0.01072383f, 
    -0.21908450f, 0.01807848f, -0.14553457f, -0.00359571f, 0.22020656f, 0.18560250f, 0.07315136f, 0.19595416f, 
    0.08116722f, -0.03544618f, 0.02593045f, 0.07158019f, 0.02210744f, -0.07951027f, -0.03549609f, 0.00824118f, 
    0.18049800f, 0.47946936f, 0.26239905f, 0.19096558f, 0.05160479f, 0.08253960f, -0.05781442f, -0.01119134f, 
    0.01470665f, -0.01599696f, -0.00271981f, -0.06795876f, 0.02048162f, 0.32507306f, 0.03403537f, 0.09022769f, 
    -0.12695174f, -0.14541459f, 0.01823627f, 0.09407543f, 0.07616296f, -0.10054038f, 0.04308741f, 0.02050438f, 
    0.09394556f, -0.64086759f, -0.10597187f, 0.14978614f, 0.09885019f, -0.00613743f, -0.10699438f, -0.07477053f, 
    0.28092206f, 0.03580794f, -0.28399411f, -0.12890239f, 0.02014089f, -0.56856805f, -0.52823400f, -0.00323582f, 
    0.08295517f, -0.01085986f, 0.08091205f, -0.05925497f, -0.03944286f, -0.04945396f, 0.12440436f, -0.06625661f, 
    -0.05844528f, -0.53891003f, -0.11901844f, -0.03685104f, -0.12034564f, 0.02912674f, -0.16779909f, 0.02348975f, 
    0.03027612f, -0.21283741f, -0.21910854f, -0.13937691f, -0.36608195f, 0.12853281f, 0.14783730f, -0.05420300f, 
    0.01730742f, 0.03636031f, -0.17718534f, 0.08791375f, -0.12682469f, -0.05455063f, -0.17162903f, -0.13240567f, 
    -0.37353495f, 0.04981400f, -0.10766029f, 0.01531326f, -0.32942250f, 0.01254123f, -0.14878462f, 0.03224050f, 
    -0.02394746f, -0.20494904f, -0.07471019f, 0.04356766f, -0.02986774f, 0.12479822f, 0.06552958f, -0.06483072f, 
    -0.00798414f, -0.07633528f, 0.01411143f, 0.06005706f, 0.20930207f, -0.11667084f, -0.34414181f, 0.20032896f, 
    0.04676541f, 0.10663055f, 0.19085082f, 0.24084269f, 0.01032895f, 0.29760343f, -0.12161144f, 0.11254290f, 
    0.03850580f, 0.05005948f, -0.00833930f, -0.09672847f, 0.07358546f, -0.26167727f, 0.08457870f, 0.08880530f, 
    0.05647189f, -0.08458363f, -0.02357993f, 0.02340554f, 0.23925477f, 0.26013631f, 0.13871497f, 0.28579205f, 
    0.00122363f, -0.25218132f, 0.00180167f, -0.18932767f, 0.06364891f, 0.04758024f, 0.11494991f, 0.09620848f, 
    0.10513493f, -0.05418821f, -0.11664321f, 0.10005159f, 0.16532286f, -0.04943724f, 0.27075562f, 0.12554623f, 
    -0.29540879f, -0.11230962f, -0.15921003f, 0.13240503f, -0.12953731f, 0.03588423f, -0.08338075f, -0.01670140f, 
    -0.07032779f, 0.01435131f, 0.11914223f, -0.30071831f, 0.40411836f, 0.21252516f, 0.21740410f, -0.04910203f, 
    0.08049095f, 0.09848811f, -0.00449124f, 0.07425988f, -0.69301087f, -0.07389818f, 0.24150753f, 0.35183364f, 
    -0.12123979f, -0.18207543f, 0.15831067f, 0.39379966f, -0.28009877f, 0.15478115f, -0.13563330f, -0.08562162f, 
    -0.36749595f, 0.18559651f, 0.12581851f, -0.34252083f, -0.18361616f, -0.16856742f, 0.13623439f, 0.17537917f, 
    0.09308868f, -0.10231003f, -0.15419623f, -0.05287140f, -0.34111908f, 0.12441829f, 0.10179942f, -0.43266609f, 
    -0.02279942f, -0.08636923f, 0.08180860f, 0.03991511f, -0.07690450f, -0.31398973f, -0.11662801f, -0.41161075f, 
    -0.46551147f, -0.31285515f, -0.02217674f, 0.03039941f, -0.00963573f, -0.01464806f, 0.10191698f, -0.02868070f, 
    0.04986367f, -0.13713877f, 0.07675540f, -0.16577141f, 0.15682438f, -0.12203067f, 0.01921034f, -0.06587280f, 
    -0.46494499f, 0.03949352f, -0.05589648f, 0.22662422f, 0.10457575f, -0.02878378f, -0.09589846f, 0.12173401f, 
    -0.08137602f, -0.04890114f, -0.05405299f, -0.03379789f, -0.03113177f, -0.13572380f, -0.19803467f, 0.03920146f, 
    0.19392669f, 0.16696341f, 0.15603854f, 0.22796462f, 0.25027904f, 0.10574104f, -0.10901573f, -0.06388734f, 
    -0.14144890f, -0.01491481f, 0.09184722f, -0.01376716f, 0.23940559f, -0.00999774f, 0.06997492f, -0.16665982f, 
    -0.23447806f, 0.13783664f, 0.27240077f, -0.10149191f, -0.02520082f, -0.02491581f, -0.09757932f, -0.07447598f, 
    -0.03506022f, 0.05912505f, -0.06190833f, -0.06780449f, -0.17540395f, -0.09312376f, -0.22811979f, 0.12995660f, 
    0.13931642f, -0.05627014f, -0.04782676f, -0.09055804f, 0.06576869f, 0.04035476f, 0.21019569f, 0.04418084f, 
    0.02226265f, -0.20454794f, -0.39670095f, 0.35950813f, 0.06067376f, 0.05887380f, 0.09204558f, 0.06107930f, 
    0.09906973f, 0.05724081f, 0.09161785f, -0.19044304f, 0.56753492f, -0.04639398f, 0.53428346f, 0.18562032f, 
    0.09480580f, -0.05462680f, 0.19481583f, -0.23466206f, 0.13248864f, -0.07419237f, 0.08426451f, -0.00744971f, 
    0.02466357f, 0.31142649f, -0.06796809f, -0.23612186f, -0.29077071f, -0.12339428f, -0.05885330f, 0.08322231f, 
    0.03349264f, 0.02141563f, 0.04661835f, -0.03325862f, 0.10131405f, 0.07847313f, -0.02352501f, -0.22516757f, 
    0.25895542f, 0.15010823f, -0.00588895f, -0.04493175f, 0.04881939f, 0.11380820f, -0.03316681f, -0.02041082f, 
    0.12193528f, 0.13087292f, -0.29426125f, 0.06619993f, 0.12400106f, -0.05482175f, -0.04944116f, 0.07162325f, 
    0.08533975f, 0.09453988f, -0.02513436f, 0.02217026f, 0.45933735f, -0.22346553f, -0.04607416f, 0.06838483f, 
    -0.00716836f, 0.24826701f, -0.03770269f, 0.13659558f, 0.00030564f, -0.03068300f, -0.19299154f, 0.00158233f, 
    -0.13371621f, -0.29497370f, -0.00790332f, -0.00833757f, -0.09061434f, 0.00748921f, -0.08017517f, 0.00977649f, 
    0.22280549f, -0.18627228f, -0.08432223f, 0.20575653f, 0.18166365f, -0.39077976f, 0.09933735f, 0.24145986f, 
    0.01711419f, -0.02016558f, -0.09392802f, 0.12969860f, 0.07205356f, -0.31548741f, 0.12398270f, -0.26481691f, 
    0.25519753f, -0.10764590f, -0.10946590f, -0.05097279f, 0.11379691f, -0.12399980f, -0.01615779f, 0.00048282f, 
    0.28178215f, 0.15067872f, -0.26797217f, 0.06231509f, 0.08620298f, -0.00145538f, 0.06030536f, -0.21102639f, 
    -0.06775885f, 0.09744813f, -0.06981046f, -0.04976111f, 0.03254110f, -0.04709877f, -0.05420665f, -0.10200778f, 
    0.08025409f, 0.20629631f, -0.02394496f, -0.00642217f, 0.04517549f, 0.06330767f, 0.02778019f, -0.05293679f, 
    -0.01960502f, -0.04282492f, 0.01555668f, 0.09625186f, -1.03590405f, -0.46165344f, -0.37442407f, -0.32623029f, 
    0.03463186f, -0.08198944f, -0.08133104f, 0.11256701f, 0.03414149f, -0.04920973f, -0.00955983f, -0.03657200f, 
    -0.56334722f, 0.34116432f, 0.23551273f, -0.16440879f, -0.19476195f, 0.06604909f, 0.12475595f, -0.06346315f, 
    0.04243022f, -0.00752464f, 0.05983590f, 0.09641606f, -0.25631574f, -0.15124425f, -0.09775819f, 0.23687305f, 
    0.05242134f, 0.02379797f, -0.04979226f, 0.10361870f, -0.07128758f, -0.05790387f, -0.05962224f, 0.01010606f, 
    0.05648763f, -0.31111333f, 0.20814487f, 0.26320696f, 0.04633957f, 0.05485766f, 0.11430507f, -0.07369649f, 
    0.23201329f, 0.09348506f, 0.09849381f, 0.07077982f, 0.20308661f, 0.03109986f, -0.12906572f, 0.07383636f, 
    0.01875828f, -0.04345548f, -0.02037665f, -0.17378479f, -0.03825739f, 0.02382838f, 0.24683256f, 0.22858541f, 
    -0.35136577f, -0.42518646f, 0.27926090f, 0.06043385f, -0.11734954f, -0.05340806f, -0.10224270f, -0.07134981f, 
    0.12077942f, 0.11355408f, 0.20735632f, 0.12428971f, 0.02302383f, -0.13218372f, 0.02199330f, -0.07632709f, 
    0.02343523f, 0.11407246f, 0.06639212f, 0.21962534f, -0.26435962f, 0.18177620f, -0.29105392f, -0.37576956f, 
    -0.17202689f, -0.22446132f, -0.25868478f, -0.01931749f, 0.59542626f, -0.09602529f, -0.22178102f, -0.02809106f, 
    0.05700102f, 0.02280132f, 0.08945269f, 0.01623281f, -0.39609399f, 0.33080375f, 0.13405654f, -0.28073871f, 
    -0.02869114f, 0.00789719f, 0.04101162f, -0.00501374f, -0.14535366f, -0.54099488f, -0.34381601f, -0.47978464f, 
    0.05713733f, -0.37869951f, -0.12486913f, 0.09461422f, 0.13263898f, -0.02144594f, -0.01226443f, 0.00325463f, 
    0.08120211f, -0.27001795f, 0.31701565f, -0.25672969f, 0.30082119f, -0.23298025f, 0.33065924f, -0.13221924f, 
    0.48756972f, 0.09460624f, 0.02723160f, 0.08228194f, -0.04730046f, 0.16447528f, 0.04513878f, 0.19718103f, 
    -0.78960764f, -0.90119082f, -0.64409292f, -0.47159046f, -0.10099594f, -0.44671053f, -0.27195594f, -0.47495323f, 
    -0.01492010f, -0.05603399f, -0.09109174f, -0.04936834f, 0.02608027f, -0.19223383f, -0.28141236f, 0.29366639f, 
    -0.30295175f, 0.21593916f, 0.09002966f, 0.08605906f, 0.03873336f, 0.00139676f, 0.19720483f, 0.04189057f, 
    -0.76861548f, -0.79640639f, 0.06491860f, -0.21732754f, -0.29652706f, 0.01055640f, 0.08620448f, 0.04657432f, 
    -0.10110866f, 0.12083253f, 0.06785457f, -0.15457192f, -0.40703440f, 0.32556939f, 0.12674108f, 0.09025139f, 
    0.12907059f, 0.04778427f, -0.03776749f, 0.02338221f, 0.06466959f, 0.06355063f, 0.27028093f, -0.02301169f, 
    0.16752961f, -0.15209767f, -0.38990778f, -0.11908302f, 0.05985631f, 0.02608262f, -0.03388503f, 0.03385879f, 
    -0.07836162f, 0.08220617f, 0.21546508f, -0.03843436f, 0.15593472f, -0.24491647f, 0.04575492f, 0.06482030f, 
    0.16159695f, -0.10477946f, 0.14927186f, -0.05840742f, 0.13236597f, -0.00899366f, -0.18900783f, 0.01322456f, 
    0.04190930f, -0.04452870f, 0.17901482f, -0.22451377f, -0.01864976f, -0.05554371f, 0.03588082f, 0.01964111f, 
    -0.18288755f, 0.05280554f, -0.13466315f, 0.03328927f, -0.46001241f, -0.34623116f, -0.31073090f, -0.04417321f, 
    -0.08286379f, -0.06577627f, -0.11376159f, 0.04183913f, -0.04448171f, -0.05548772f, 0.37976792f, 0.13220353f, 
    0.16548507f, -0.71303552f, -0.25824684f, 0.27212974f, 0.05541706f, 0.28300738f, -0.07647010f, -0.05948510f, 
    0.02714381f, 0.09455907f, 0.03926248f, 0.13881457f, 0.25527936f, -0.05754214f, -0.40681139f, 0.02787572f, 
    -0.07751985f, -0.14356484f, 0.17422116f, 0.01124316f, -0.12267556f, -0.00787635f, -0.10788377f, -0.42936555f, 
    0.52107018f, 0.03761655f, 0.02216299f, -0.03884272f, -0.13450310f, -0.03208959f, 0.12603964f, -0.05128917f, 
    -0.02646732f, 0.00986362f, 0.02241972f, 0.09518714f, -0.81567770f, -0.52627778f, -0.13673562f, -0.55190104f, 
    -0.06962282f, -0.04965890f, -0.20873575f, -0.04564625f, -0.06870867f, 0.04049050f, 0.00446714f, 0.00663319f, 
    -0.26920134f, -0.42484504f, -0.14811696f, 0.32264504f, 0.31591544f, 0.13376744f, -0.10279304f, -0.02354145f, 
    -0.03626643f, 0.02852230f, -0.00929382f, 0.02629479f, -1.18546402f, -0.00058440f, 0.27548158f, 0.12268461f, 
    -0.02320153f, -0.25802067f, -0.05505737f, -0.41631013f, -0.05269441f, -0.05869559f, 0.02735480f, 0.05949120f, 
    -0.04600555f, -0.40890005f, -1.02504027f, -0.31363282f, -0.10434470f, 0.16857572f, 0.08353463f, -0.01318582f, 
    -0.11101464f, -0.01210866f, 0.02234495f, -0.00212710f, -0.66649002f, -0.24568680f, -0.19046101f, 0.52689677f, 
    0.15464087f, 0.31290329f, 0.09225284f, -0.12255865f, 0.05610036f, -0.18107323f, -0.08652628f, 0.16277185f, 
    -0.37710768f, 0.29897007f, 0.39740974f, 0.38948640f, -0.04930751f, -0.20630263f, 0.17496662f, 0.16219492f, 
    -0.04850280f, 0.16235332f, -0.11529298f, -0.04161592f, 0.07621045f, 0.02624676f, -0.13755485f, 0.08782423f, 
    -0.16184196f, 0.08677458f, 0.05375280f, 0.18860455f, 0.07869877f, 0.18042347f, 0.02921822f, 0.03003044f, 
    -0.14146073f, -0.11096399f, -0.11553793f, 0.10910071f, 0.07043283f, 0.07622725f, 0.04976355f, -0.06824523f, 
    0.19039683f, 0.06584811f, -0.09081868f, 0.03347296f, 0.21810089f, 0.42249280f, -0.09763034f, -0.07611708f, 
    0.01826919f, -0.04827218f, -0.19741434f, 0.01172068f, 0.06670240f, 0.01532878f, 0.04796664f, 0.00201041f, 
    -0.67984223f, -0.74227047f, -0.76873422f, -0.17876013f, -0.06714694f, -0.05649765f, 0.03720590f, -0.44440418f, 
    0.01922190f, -0.01162894f, -0.01282275f, -0.04218502f, -0.39231575f, 0.01225541f, 0.49939322f, 0.27657026f, 
    -0.03071346f, -0.03699463f, -0.04648640f, 0.15395609f, -0.00571111f, 0.15220173f, 0.12805073f, 0.06277876f, 
    -0.02247516f, -0.29143375f, 0.37892383f, -0.71810108f, -0.11065978f, -0.24088988f, 0.00986654f, -0.00528876f, 
    -0.02255930f, 0.19634409f, 0.12282829f, -0.10149592f, 0.00649700f, 0.01642290f, -0.03312039f, 0.14417627f, 
    0.03472344f, -0.01597352f, -0.00021455f, 0.00048814f, -0.00973555f, -0.26271835f, 0.13324441f, 0.06707567f, 
    -0.14862062f, 0.16693658f, 0.02168196f, 0.02270617f, -0.03420914f, 0.06401179f, -0.03824945f, -0.05281512f, 
    0.02854284f, -0.03702467f, 0.16342242f, 0.14629088f, -0.03952727f, -0.05707146f, 0.13181673f, -0.35721332f, 
    0.04147670f, 0.12430442f, 0.00130358f, 0.04578095f, -0.06878807f, -0.02154614f, -0.07245328f, 0.12457784f, 
    -0.28620851f, 0.05664891f, 0.48177102f, 0.72920996f, -0.16714060f, -0.06798714f, -0.07306533f, 0.18167216f, 
    -0.13822214f, -0.00061794f, 0.04329820f, 0.15816838f, -0.03661002f, -0.08409254f, 0.12117413f, 0.29473478f, 
    0.07239389f, 0.04623706f, 0.11879677f, -0.12755519f, 0.10673030f, -0.08431592f, 0.13481368f, 0.06159116f, 
    0.02621771f, -0.36952174f, -0.18480384f, 0.03974301f, 0.07471056f, 0.24964175f, 0.19623607f, -0.21364807f, 
    0.01010965f, -0.09514865f, -0.08737630f, -0.04450141f, 0.03823104f, 0.05190040f, 0.00663156f, -0.14609501f, 
    -0.06468099f, -0.05144070f, 0.17180462f, -0.01544689f, 0.19428658f, 0.07685622f, 0.32537249f, 0.07553035f, 
    0.05533076f, 0.30919740f, 0.04983247f, 0.02079216f, -0.05942616f, 0.04509633f, 0.00071008f, -0.00289859f, 
    0.07463256f, 0.00935239f, 0.19392492f, 0.07086112f, -0.19526190f, 0.02415564f, -0.00779741f, 0.30689621f, 
    -0.22850427f, -0.19509342f, 0.04065607f, 0.28896785f, 0.05795812f, -0.01249323f, -0.00133464f, -0.07913671f, 
    -0.46590367f, -0.41223332f, 0.04177661f, 0.37609243f, -0.03012463f, 0.13987571f, -0.11657512f, 0.14954329f, 
    0.06296543f, -0.00524284f, 0.03431087f, 0.02922321f, 0.31694999f, 0.01461197f, -0.03667615f, 0.23071329f, 
    0.09311116f, 0.12733601f, -0.08927767f, -0.14761980f, -0.05284644f, -0.02524852f, -0.06463362f, 0.12536301f, 
    0.65781438f, -0.86441696f, -0.57405043f, -0.53262973f, -0.11686692f, -0.07992540f, -0.11288830f, 0.40174198f, 
    0.12075859f, -0.08028430f, -0.15111384f, 0.03483312f, -0.01350196f, -0.32244697f, 0.43421158f, -0.09800359f, 
    0.01068996f, -0.08561290f, 0.02171743f, -0.08805858f, 0.01016118f, 0.12112334f, 0.14376411f, -0.05626174f, 
    0.11898044f, 0.10868545f, 0.32754290f, -0.14501001f, 0.13606666f, -0.03067227f, -0.11501285f, -0.01296403f, 
    0.04500896f, 0.07967307f, 0.03398903f, -0.03661832f, -0.08102798f, 0.05120266f, 0.19065957f, -0.09777291f, 
    -0.07093259f, 0.02231295f, -0.04133946f, 0.03700399f, -0.04670642f, 0.06825995f, -0.01552376f, -0.04695619f, 
    0.16297363f, 0.14317665f, -0.07639819f, -0.05343007f, 0.05227232f, 0.05284272f, 0.01536740f, 0.00748166f, 
    -0.15268295f, -0.16374701f, -0.18339877f, -0.33615214f, -0.47194541f, -0.24334033f, -0.28597537f, 0.13107093f, 
    -0.03106910f, -0.22193885f, -0.04511415f, -0.13912417f, 0.06882411f, -0.15554117f, 0.05377206f, -0.10995990f, 
    0.39615095f, -0.42675266f, 0.40131286f, -0.24323148f, -0.02518180f, 0.01736581f, -0.14575830f, 0.31053627f, 
    -0.03570688f, 0.08311302f, -0.02568052f, 0.01666633f, -0.08404204f, -0.03083889f, 0.03203424f, 0.07170257f, 
    0.01323454f, -0.07363965f, 0.03908160f, -0.03193399f, 0.01630608f, 0.05714234f, -0.05074648f, -0.03646397f, 
    -0.02188095f, 0.09783667f, -0.03956694f, 0.16242468f, -0.03272326f, 0.07739906f, 0.06349761f, -0.01056339f, 
    0.05795619f, -0.17298429f, -0.08706014f, -0.08031547f, -0.32355836f, -0.51582706f, 0.08468404f, 0.57613832f, 
    0.17827544f, 0.19744377f, 0.08168345f, -0.02941371f, 0.10490194f, -0.10092620f, 0.04726676f, 0.03048411f, 
    0.41411555f, -0.07382629f, 0.14604896f, -0.30533233f, 0.09475918f, -0.19925836f, -0.01275256f, 0.02243203f, 
    0.07047252f, 0.03791636f, 0.00961208f, -0.01933149f, -0.57606053f, -0.60673773f, -0.31111565f, -0.35253519f, 
    0.04488208f, -0.27107868f, -0.02243622f, 0.22055878f, 0.00968657f, -0.06451328f, -0.01615019f, 0.02286808f, 
    -0.24912308f, -0.31820253f, -0.04076426f, -0.07057913f, 0.11847903f, 0.01833804f, -0.01890716f, -0.15078671f, 
    0.13455759f, 0.05416875f, 0.09344763f, 0.06443995f, -0.04090658f, 0.06690327f, 0.09329840f, -0.43394825f, 
    -0.02886868f, 0.17817548f, 0.04943914f, 0.17045578f, 0.02210922f, 0.10526005f, 0.09261837f, -0.15218973f, 
    0.12211604f, -0.20019828f, -0.70210087f, -0.46943060f, -0.11961105f, 0.13958204f, -0.00415184f, 0.00809561f, 
    -0.09427920f, 0.07781360f, 0.00922959f, -0.00209747f, 0.28304783f, 0.02435088f, -0.06260110f, -0.01824977f, 
    -0.01544585f, -0.01737824f, -0.07825252f, -0.13268246f, -0.27900440f, 0.09808751f, -0.15589146f, -0.00027408f, 
    -0.15630114f, 0.06048923f, 0.25461012f, 0.06726156f, 0.06029297f, -0.03490808f, 0.07624997f, -0.15997079f, 
    0.02401920f, 0.10031436f, 0.00397436f, -0.00676772f, -0.08749681f, -0.25401545f, 0.07062694f, -0.07038625f, 
    -0.00374064f, 0.02799549f, -0.01931839f, 0.03486451f, 0.09260756f, -0.01621550f, 0.04681326f, 0.06812789f, 
    -0.43892866f, -0.18515812f, -0.16963451f, 0.41553062f, 0.01734474f, 0.02596799f, 0.21582770f, 0.14244267f, 
    0.06052479f, -0.02939278f, -0.07847710f, -0.05709130f, 0.62093008f, -0.64024347f, -0.15894827f, -0.24854657f, 
    -0.04491969f, -0.04369652f, -0.24876045f, -0.01392202f, 0.07819581f, -0.06102404f, -0.01540392f, 0.06487937f, 
    0.74350315f, 0.16085711f, -0.30908522f, -0.52586365f, 0.03719349f, -0.04743233f, -0.05708547f, 0.12488290f, 
    -0.11119426f, -0.11875838f, 0.06339084f, -0.33263785f, 0.14698121f, 0.09737649f, 0.05612076f, -0.00258904f, 
    0.02215469f, -0.00892635f, 0.03560404f, 0.00711000f, -0.00741352f, 0.08955164f, 0.04149543f, -0.31805092f, 
    0.27412409f, -0.18001530f, 0.07484818f, -0.20855384f, -0.08407155f, -0.05912710f, 0.01200065f, -0.13584659f, 
    0.02817410f, 0.03396099f, -0.03098371f, -0.33090779f, -0.23927747f, 0.30451787f, 0.00137748f, -0.15147297f, 
    -0.11551980f, 0.14814915f, -0.04783678f, -0.19859207f, -0.15566540f, -0.00199331f, -0.04995275f, 0.00275490f, 
    0.83224720f, -0.66915464f, -0.57734090f, -1.06578791f, 0.00766294f, -0.12704414f, -0.34415284f, 0.11706573f, 
    0.05071496f, -0.15976182f, 0.13494991f, -0.23732468f, 0.10237207f, -0.13868310f, 0.07433051f, -0.20189089f, 
    -0.00642679f, 0.05526390f, 0.05300087f, 0.06307569f, -0.14822657f, -0.05149879f, 0.13486567f, 0.01586785f, 
    -0.10391245f, 0.07548385f, 0.03599925f, -0.02713161f, -0.02571833f, -0.04405490f, 0.19278842f, 0.00363585f, 
    0.03247079f, 0.01531079f, 0.05222803f, -0.00047015f, 0.41891092f, -0.08895954f, -0.40939853f, 0.22227013f, 
    0.05040082f, -0.10680986f, -0.07728760f, -0.16691880f, 0.24692202f, -0.07705985f, 0.01308364f, 0.03376994f, 
    -0.08997101f, -0.05051937f, 0.14202154f, -0.10120861f, 0.05212523f, 0.01146012f, 0.00877858f, -0.10941850f, 
    -0.24565575f, 0.14319909f, 0.05294760f, -0.11844384f, 0.14014447f, -0.12270467f, 0.04022532f, -0.12936443f, 
    0.03709666f, -0.13589820f, 0.13969368f, -0.31170449f, -0.06156510f, 0.09476818f, -0.02162357f, 0.00840623f, 
    -0.24855630f, -0.67712784f, -0.51521224f, -0.11178784f, 0.01035381f, -0.10168736f, 0.00017592f, 0.08895569f, 
    0.00767311f, 0.03088051f, 0.11144630f, 0.10789991f, 0.50050241f, 0.25015801f, 0.06801317f, -0.26913989f, 
    0.17350875f, 0.08788908f, -0.00627438f, 0.22942466f, 0.01036938f, 0.09420419f, 0.14486741f, 0.10751479f, 
    -0.09181421f, -0.44272032f, -0.82118249f, -0.59572077f, -0.08804121f, -0.00537423f, 0.17019881f, -0.01834680f, 
    -0.17897455f, -0.09657976f, -0.10594659f, -0.19186568f, -0.19132419f, -0.26265121f, -0.12432189f, -0.06523823f, 
    -0.06789009f, 0.00643165f, 0.10711274f, -0.04247747f, -0.09917643f, -0.15052529f, 0.06049765f, -0.07661827f, 
    -0.15772977f, 0.09979347f, -0.14272346f, -0.08257614f, -0.03664309f, -0.08351418f, 0.06577102f, 0.00792521f, 
    -0.20026866f, 0.09673585f, -0.34562117f, -0.20143487f, -0.04815394f, -0.27174827f, -0.08987406f, 0.11049081f, 
    0.13885568f, -0.08439381f, 0.24648345f, 0.07629572f, -0.08279093f, 0.07303604f, 0.17275979f, 0.09882431f, 
    0.10583387f, -0.03984946f, -0.09490693f, -0.11423437f, -0.14286585f, -0.03299435f, -0.01258509f, 0.11990380f, 
    0.15789783f, 0.07591932f, 0.12363777f, 0.09607202f, -0.61266625f, -0.53839952f, -0.06053929f, -0.47827917f, 
    0.08896041f, 0.16399045f, 0.12657730f, 0.09755445f, 0.08060438f, 0.04966494f, -0.26381594f, -0.36003217f, 
    0.53365177f, 0.50390679f, 0.00069726f, -0.43024820f, 0.19238852f, -0.14286035f, 0.11628514f, -0.08795422f, 
    0.10137904f, 0.09885997f, -0.07000782f, -0.04195982f, -0.21553014f, 0.14482424f, -0.02529266f, 0.02209648f, 
    0.04999935f, -0.02527532f, -0.09255321f, 0.00196502f, -0.03639438f, 0.10846931f, 0.12725553f, 0.14716502f, 
    -0.62922555f, 0.09888780f, 0.17317773f, 0.16855018f, 0.06023574f, 0.04808460f, -0.13997544f, 0.04925332f, 
    -0.23085873f, -0.01184224f, 0.01343633f, -0.09218735f, 0.92270166f, -0.20189492f, -1.11598861f, -0.03588506f, 
    -0.03492947f, 0.00037890f, 0.06801479f, 0.01827397f, 0.07100752f, 0.28566706f, 0.22781907f, 0.05368073f, 
    0.14163218f, 0.29542160f, 0.07777540f, 0.04256007f, -0.16071409f, -0.29259083f, -0.05354876f, -0.07472725f, 
    0.05756672f, 0.06017935f, 0.05673830f, 0.07898317f, 0.08617353f, -0.92691123f, -0.77777117f, 0.14636448f, 
    -0.08321241f, 0.19275169f, 0.07503329f, -0.02816689f, -0.05299075f, -0.07279349f, 0.07287958f, 0.01483565f, 
    0.03396207f, 0.38655344f, 0.06337247f, 0.06671140f, 0.03895927f, -0.19742505f, 0.03476058f, -0.07593178f, 
    -0.10405436f, -0.05901807f, 0.00148992f, -0.00043616f, 0.30561516f, -0.04451288f, 0.03382419f, -0.25309250f, 
    -0.27552643f, -0.02037326f, 0.03314893f, -0.25183952f, 0.06189162f, -0.05810520f, -0.08798368f, 0.03332673f, 
    -0.33748361f, -0.25387031f, -0.14437014f, 0.25450182f, -0.05478149f, 0.16199555f, 0.14876240f, 0.11061873f, 
    0.31326202f, -0.07952294f, 0.15037258f, 0.18600027f, 0.48851159f, -0.10241713f, -0.34024432f, -0.29055631f, 
    0.03389631f, -0.01978752f, 0.02369300f, -0.00438261f, 0.22481981f, -0.02585919f, 0.06310645f, -0.08181488f, 
    0.11007421f, -0.01267885f, 0.45862418f, 0.14839944f, -0.14568564f, 0.09549972f, -0.09131159f, -0.08798534f, 
    -0.00749592f, 0.11269864f, 0.04116698f, 0.13167065f, -0.21781637f, -0.34418309f, -0.13977948f, -0.03023602f, 
    -0.05944688f, -0.04562533f, -0.05940957f, 0.17142870f, -0.21113774f, -0.03974546f, -0.25134832f, -0.13709070f, 
    -0.31772128f, -0.09613794f, 0.00233570f, -0.01696405f, 0.02222323f, -0.01207387f, -0.20871669f, -0.11287382f, 
    -0.06007523f, -0.03803766f, 0.04844930f, -0.00181423f, -0.68104291f, -0.55667871f, -0.14052361f, 0.20346062f, 
    -0.10496920f, 0.20421511f, 0.20865008f, 0.24372767f, 0.02092464f, 0.15506104f, -0.06192617f, -0.07001680f, 
    0.09555539f, -0.28613612f, -0.56082910f, -0.50161767f, -0.18411307f, -0.16366562f, 0.01436186f, -0.01972780f, 
    0.17315549f, 0.23778152f, 0.14813939f, 0.22642633f, -0.29825461f, -0.04021130f, 0.05651352f, -0.25484747f, 
    -0.08331572f, -0.02162662f, -0.02904458f, 0.02246665f, -0.01732562f, -0.05560793f, 0.00446384f, 0.04407538f, 
    -0.05704603f, 0.01355718f, 0.12858678f, -0.30590552f, 0.07948937f, 0.05998991f, 0.02404207f, -0.00959214f, 
    0.02658615f, 0.07451929f, 0.01924943f, 0.15952475f, -0.03338061f, 0.23856096f, 0.32122478f, 0.23518303f, 
    0.09162068f, -0.13551256f, -0.04902972f, 0.16015616f, 0.26744303f, 0.04289175f, 0.17657173f, 0.02620293f, 
    0.18105072f, -0.30913407f, -0.67211199f, -0.06047140f, 0.17227086f, 0.00037208f, 0.19077218f, 0.20278807f, 
    0.05013130f, -0.09229366f, -0.04027130f, 0.04805210f, -0.05853153f, -0.16604930f, 0.03929337f, 0.14895399f, 
    0.03657423f, 0.03959342f, 0.13230611f, 0.00050192f, -0.18647151f, -0.25945148f, -0.20447302f, -0.23830792f, 
    -0.18017808f, 0.09431268f, 0.14146982f, 0.07221978f, -0.13642748f, -0.06102762f, -0.02836386f, -0.16000292f, 
    0.09109934f, -0.00964244f, 0.00903400f, -0.04717591f, 0.07614285f, -0.08247834f, -0.01045200f, -0.09351949f, 
    0.05192854f, 0.01947321f, 0.02005710f, 0.14393908f, -0.16795623f, 0.04890426f, -0.14001471f, -0.51788241f, 
    -0.44470239f, -0.02756150f, -0.07914022f, -0.17676654f, -0.10192587f, -0.02710985f, 0.10858330f, -0.10559323f, 
    0.11697283f, 0.01881017f, -0.22063036f, -0.04608879f, 0.34463230f, -0.03548823f, -0.24031736f, -0.06905028f, 
    0.12828696f, 0.15202774f, 0.09709752f, -0.28989998f, 0.16728130f, -0.00938755f, -0.00039057f, -0.01601022f, 
    -0.32914376f, 0.08325955f, -0.09438106f, -0.17682166f, -0.23431399f, -0.14847539f, -0.05577701f, 0.11144235f, 
    0.00140127f, -0.08264391f, 0.01914331f, -0.05115616f, -0.46659639f, 0.07048182f, -0.41414234f, 0.08621624f, 
    0.00905649f, -0.13340116f, -0.23405294f, -0.14966880f, -0.04264855f, -0.15161726f, 0.16141517f, 0.17963034f, 
    -0.36893535f, -0.17657402f, 0.33727133f, 0.32098341f, -0.00189446f, 0.07775896f, -0.11949308f, -0.11838248f, 
    0.15743338f, 0.08679681f, 0.18746541f, 0.00940014f, 0.31180692f, -0.61198980f, 0.26493755f, -0.07771873f, 
    -0.09962513f, -0.00618358f, -0.01899196f, 0.06031247f, -0.05320311f, 0.02322924f, 0.09252139f, -0.07946200f, 
    -0.36050892f, -0.74406993f, -0.03929026f, -0.12856579f, -0.03596062f, 0.12015514f, 0.14446913f, -0.03862026f, 
    0.21892144f, 0.09676187f, -0.12468055f, 0.01945206f, -0.20908642f, -0.09573837f, 0.10003854f, -0.39229757f, 
    0.14259823f, -0.01804374f, 0.14159772f, -0.16986406f, 0.09880857f, 0.17454404f, -0.08237212f, 0.14811021f, 
    -0.26927173f, -0.26903310f, 0.19578849f, 0.27504456f, 0.06230808f, 0.10567190f, -0.16412355f, 0.04168266f, 
    0.08655840f, 0.16852842f, -0.17297012f, -0.05617198f, 0.18487899f, -0.02159093f, 0.25236046f, -0.25381303f, 
    0.01925831f, 0.09537800f, -0.03430951f, -0.00923841f, 0.07084971f, 0.05216928f, 0.12800121f, 0.03298219f, 
    -0.55325276f, -0.54730862f, -0.00125000f, 0.21244653f, -0.00890661f, 0.30792606f, -0.00021973f, 0.16914602f, 
    0.02680587f, 0.09666419f, -0.04467188f, -0.02470611f, -0.29922479f, 0.10610201f, -0.14059667f, 0.08354791f, 
    0.07367675f, -0.01114281f, 0.08384538f, -0.11429942f, 0.26637200f, 0.01888022f, -0.19523367f, -0.15705879f, 
    -0.22031690f, 0.32196063f, -0.53897858f, -0.08461296f, 0.06962237f, -0.05118894f, 0.13740371f, 0.04241885f, 
    0.10602542f, 0.02229795f, 0.11212489f, 0.22462770f, -0.28420925f, -0.10200902f, -0.46680945f, 0.27386570f, 
    0.21425104f, 0.04186789f, -0.06549989f, 0.11049364f, 0.10348911f, -0.00570095f, -0.03495758f, -0.04553439f, 
    -0.28643674f, -0.81244695f, 0.35306635f, -0.20488183f, 0.04827672f, 0.05284487f, -0.00869405f, 0.15387097f, 
    -0.12982611f, -0.07004561f, -0.05287842f, 0.01881676f, -0.29154626f, -0.04435698f, 0.00232200f, -0.40014517f, 
    -0.10342301f, -0.02973956f, -0.03826272f, 0.22128332f, 0.00129569f, -0.00109103f, 0.04605396f, 0.07963341f, 
    -0.34104306f, -0.04170101f, -1.18692410f, 0.27082300f, 0.17309213f, -0.01621282f, 0.26103514f, -0.04060818f, 
    -0.05709475f, -0.06531602f, -0.07727296f, 0.03612831f, 0.43285581f, -0.97731853f, 0.37660989f, -0.34023234f, 
    0.08715675f, 0.10580477f, -0.12633173f, 0.03542027f, -0.13567279f, -0.04381513f, 0.05990519f, -0.13994749f, 
    0.42550260f, 0.26424485f, 0.24486032f, -0.29965368f, 0.10393914f, -0.23546605f, -0.18123582f, -0.09824696f, 
    -0.20860903f, 0.09761665f, 0.12621124f, 0.12961698f, -0.16190127f, 0.06386541f, -0.02387691f, 0.32108054f, 
    0.14248841f, 0.02562151f, 0.00443285f, -0.06084236f, 0.15552062f, 0.01351734f, 0.05029853f, 0.02026914f, 
    -0.01093123f, -1.12739003f, 0.07097433f, -0.70267242f, 0.07093639f, 0.00619801f, -0.14965989f, -0.25831601f, 
    -0.08566767f, -0.11576611f, -0.16905524f, -0.10163634f, 0.28140309f, 0.05285810f, 0.54970211f, -0.24231432f, 
    -0.07714640f, -0.25431076f, -0.08709997f, -0.01840728f, -0.13205872f, 0.14844267f, 0.07500114f, 0.05291111f, 
    -0.03222735f, 0.18815801f, 0.08577965f, -0.26648125f, -0.21471128f, -0.07210546f, 0.24861638f, 0.32223332f, 
    -0.05980796f, 0.12172584f, 0.06896964f, -0.10178824f, 0.27053821f, 0.30188414f, -0.04001474f, -0.07743062f, 
    -0.17293535f, -0.13976321f, -0.18451743f, -0.39503801f, 0.12966864f, -0.05096019f, 0.01604148f, 0.08872819f, 
    -0.30409902f, 0.46228114f, 0.25166747f, 0.87625682f, 0.10572641f, 0.12440468f, -0.31817755f, -0.12669975f, 
    -0.02117202f, -0.25042310f, -0.02345962f, -0.17789933f, -0.27136290f, -0.01361281f, 0.12636049f, 0.12643394f, 
    -0.00940405f, 0.12118130f, -0.03402577f, 0.05133818f, -0.06247354f, 0.11025153f, 0.20486139f, 0.11353865f, 
    0.13385077f, -0.11579587f, -0.17667416f, 0.04597856f, 0.04801610f, -0.04692589f, 0.09310643f, -0.06931529f, 
    -0.00996076f, -0.18469872f, 0.06573299f, -0.06752264f, -0.54240954f, -0.10952469f, -0.35606065f, 0.19170359f, 
    0.05814616f, -0.08851641f, 0.12920319f, 0.11699808f, 0.00567608f, -0.14796139f, 0.03313350f, -0.16823237f, 
    0.03315721f, -0.22238928f, 0.25148627f, -0.10687765f, -0.03061444f, -0.06118650f, 0.02552010f, -0.22191685f, 
    0.06624696f, -0.14483067f, -0.20357464f, -0.00699868f, 0.22327378f, -0.29706576f, 0.12950464f, -0.30714917f, 
    -0.08924237f, -0.02919046f, -0.06583460f, -0.05968659f, 0.08034112f, -0.03156759f, 0.09679071f, 0.34710225f, 
    0.44993049f, -0.26674503f, -0.38513407f, -0.07104215f, 0.10261648f, 0.24942754f, 0.20357524f, 0.15212151f, 
    0.06684116f, -0.06862579f, -0.14132935f, -0.12514116f, -0.30918273f, 0.12636474f, 0.09078210f, 0.34712493f, 
    0.07747946f, 0.05522431f, -0.17436326f, -0.10944566f, 0.16913459f, 0.06847779f, 0.20009695f, 0.19729401f, 
    0.06089489f, -0.22019760f, 0.49366742f, 0.01299578f, -0.02582348f, -0.09906588f, -0.00369616f, -0.09329114f, 
    0.03632692f, 0.14354010f, -0.03488864f, 0.00410279f, -0.11562321f, -0.35541841f, 0.09963660f, -0.29312590f, 
    0.15667063f, -0.06292095f, 0.15389800f, -0.03247259f, 0.05180277f, -0.09797614f, -0.13947338f, -0.08728062f, 
    -0.15416253f, 0.07753840f, -0.05419289f, 0.01101587f, -0.14979433f, -0.00539246f, -0.00498677f, 0.11463667f, 
    -0.06231423f, 0.16264543f, 0.10144445f, 0.17883307f, 0.18808205f, -0.20500985f, 0.26711926f, -0.29662916f, 
    -0.13001326f, -0.05248627f, 0.06890055f, 0.17856081f, -0.11780374f, 0.05044689f, -0.22460420f, -0.20469281f, 
    0.05668605f, -0.43383050f, -0.44732222f, 0.17977920f, 0.02651063f, -0.05474304f, -0.00760130f, 0.12939225f, 
    -0.11725856f, 0.02013285f, -0.16651011f, -0.20649257f, -0.30249983f, 0.69768161f, -0.12931669f, 0.66986519f, 
    0.11922991f, 0.07561208f, -0.18180566f, 0.04427794f, -0.15531799f, -0.06660555f, -0.12396721f, -0.11181536f, 
    0.00542116f, 0.29786244f, 0.24941908f, -0.08888984f, -0.01741504f, -0.15726900f, 0.07254440f, 0.10825331f, 
    -0.00817703f, -0.14230488f, -0.15772054f, -0.07540394f, -0.10639471f, 0.55230367f, -0.08006090f, 0.19455203f, 
    0.00062473f, -0.04470727f, 0.29416880f, 0.08429851f, -0.01339214f, 0.03582088f, 0.08909141f, 0.06704397f, 
    -0.13304009f, 0.02270217f, 0.41547862f, -0.25902447f, -0.11124381f, -0.05058424f, -0.06169390f, -0.08051911f, 
    0.02103626f, 0.09746315f, 0.15408312f, 0.06579003f, -0.23590313f, 0.19111077f, -0.45325392f, 0.26314843f, 
    0.13050367f, 0.05027844f, 0.06882209f, 0.11905723f, -0.03043193f, 0.10066452f, -0.46081808f, -0.34134543f, 
    -0.53289139f, 0.59789133f, -0.53609133f, 0.10618711f, -0.02275199f, -0.02734977f, 0.13538636f, -0.36576200f, 
    -0.06901969f, -0.05486254f, -0.37614441f, 0.08156468f, -0.23669083f, -0.09717001f, 0.06320447f, -0.33052772f, 
    -0.35245585f, 0.09406753f, 0.04441888f, 0.06428459f, -0.00200012f, -0.12896866f, 0.35024428f, 0.20472777f, 
    0.01483936f, -0.09825046f, 0.07837850f, -0.15970325f, -0.02174270f, -0.20190479f, 0.11654523f, 0.16737905f, 
    -0.36987787f, -0.29343331f, -0.18359357f, -0.09612913f, -0.85716295f, 0.47589862f, -0.01740870f, 0.16333024f, 
    0.04307650f, 0.12206288f, -0.13650088f, 0.07288206f, -0.04623498f, 0.18568447f, -0.06578785f, -0.04766214f, 
    -0.10680876f, -0.32904065f, -0.02888853f, 0.14179870f, -0.20217134f, 0.11833642f, -0.00392766f, -0.02819745f, 
    -0.00392842f, -0.16894624f, 0.04028306f, 0.11463755f, -0.04374767f, -0.35251659f, 0.08546846f, 0.06777672f, 
    -0.04680345f, 0.19776562f, -0.07607737f, 0.14220609f, 0.08451190f, 0.07358767f, 0.05453533f, -0.22447373f, 
    -0.11469053f, 0.29912284f, -0.89940751f, -0.05271972f, -0.14153519f, -0.01521020f, -0.01111069f, -0.25009152f, 
    -0.18658139f, 0.11414333f, -0.12145326f, 0.00205683f, -0.55631638f, 0.16777913f, 0.09362326f, 0.21374716f, 
    -0.19127201f, 0.31012291f, -0.36405751f, 0.00288934f, 0.19991039f, 0.01335342f, 0.01756490f, 0.03577316f, 
    0.23388509f, 0.08603229f, 0.36366808f, -0.00992667f, -0.21028075f, 0.04425143f, -0.11735807f, -0.00670348f, 
    0.24616589f, -0.15097617f, 0.26007858f, -0.16140905f, -0.34723380f, 0.03158226f, 0.38572076f, -0.24621160f, 
    -0.11625375f, 0.15545425f, -0.11325474f, 0.07767820f, -0.01866676f, -0.15497518f, -0.23368745f, 0.08319880f, 
    -0.40280077f, 0.23632312f, 0.53192753f, 0.03968518f, 0.04093984f, 0.07378010f, -0.15892226f, 0.14176494f, 
    -0.11941256f, 0.14191617f, -0.02759148f, -0.01653325f, -0.43898651f, 0.20549047f, -0.35290545f, 0.49276242f, 
    0.10153111f, -0.19389603f, -0.09930403f, 0.17903545f, -0.24209133f, -0.06568823f, -0.07325489f, 0.06238878f, 
    -0.03965639f, -0.40174094f, -0.45281440f, 0.04700094f, -0.01978537f, 0.07617541f, 0.07002327f, -0.08928216f, 
    0.07561793f, 0.10064110f, -0.09955492f, 0.00458771f, 0.22500312f, 0.08800390f, 0.24651420f, -0.08775590f, 
    0.12301008f, -0.18263291f, -0.04020217f, 0.05616232f, -0.19470458f, 0.22054119f, -0.10832337f, -0.26326209f, 
    0.62246823f, 0.03625541f, -0.28433800f, -0.23829858f, -0.12937307f, 0.03607446f, 0.26492694f, 0.00791726f, 
    0.07820170f, 0.08265867f, -0.06064687f, 0.00094862f, 0.09085517f, -0.37025473f, 0.07867886f, -0.39922792f, 
    -0.14131427f, -0.11025371f, -0.06838129f, -0.17283805f, 0.10327681f, 0.12925908f, -0.16397837f, -0.07850523f, 
    -0.12654191f, 0.35649589f, -0.30923274f, 0.13437140f, -0.24343918f, 0.02347656f, 0.13133629f, -0.12044403f, 
    0.01436254f, 0.08601358f, 0.03266091f, 0.08951429f, 0.32243618f, 0.45658305f, 0.09051084f, 0.14392853f, 
    -0.07667670f, 0.13235036f, -0.05338118f, 0.03871134f, 0.10096721f, 0.34583408f, -0.01856128f, 0.02265178f, 
    0.08443558f, 0.02352425f, 0.48394936f, -0.00266522f, 0.04728153f, -0.06166242f, 0.13558429f, -0.00504894f, 
    -0.08827748f, -0.01697619f, 0.13794905f, -0.01092802f, -0.08301573f, 0.34762159f, -0.07794829f, 0.04564034f, 
    0.04170353f, 0.14064951f, -0.00861721f, 0.04840418f, 0.04504537f, -0.17060186f, -0.42724836f, -0.38246125f, 
    -0.37926233f, -0.66492391f, 0.09051281f, -0.38928750f, -0.13098416f, 0.16168915f, -0.03215881f, -0.09296063f, 
    -0.21452743f, 0.07807629f, 0.11181725f, 0.00765410f, 0.39564621f, -0.03118531f, -0.08538523f, -0.33737564f, 
    -0.07141162f, 0.05897649f, -0.06228077f, 0.00059967f, -0.16778395f, -0.22994934f, -0.48642769f, -0.44653597f, 
    -0.61772096f, 0.37422928f, -0.24843104f, -0.14626002f, -0.06732878f, -0.24575968f, -0.11763614f, 0.00771379f, 
    -0.04470720f, -0.08382823f, 0.11418255f, -0.16263118f, -0.78740805f, 0.33774626f, 0.16677639f, 0.16288933f, 
    0.14121665f, 0.25532502f, -0.11271878f, 0.15905051f, -0.19045179f, -0.04660759f, 0.27285242f, 0.01706120f, 
    0.09148978f, -0.10911336f, 0.08665872f, -0.12572420f, 0.08755103f, -0.32916978f, 0.06381081f, -0.22384711f, 
    0.00313116f, -0.06698746f, -0.16457291f, -0.14816232f, 0.09701222f, -0.23439461f, 0.06590614f, -0.22558333f, 
    0.03477881f, 0.11915023f, 0.41696694f, 0.07350224f, 0.17832808f, 0.09170692f, 0.00031251f, 0.06415911f, 
    -0.00569769f, 0.07502349f, -0.16175041f, -0.11515740f, -0.11879283f, -0.04765074f, 0.09387033f, -0.12251723f, 
    -0.03002317f, 0.11595416f, 0.28480002f, 0.12409846f, -1.03636134f, 0.26317069f, -0.52795810f, 0.47168982f, 
    0.03356796f, 0.04785629f, 0.10284946f, 0.20553541f, -0.20750383f, 0.04698588f, 0.16438238f, 0.11858600f, 
    -0.10679795f, 0.06979620f, 0.09598873f, 0.13464826f, -0.00139481f, 0.08205604f, 0.03167382f, -0.23018296f, 
    -0.11893341f, 0.05907017f, 0.01953051f, -0.04534861f, 0.16814806f, 0.10556762f, 0.28342310f, 0.22019382f, 
    -0.02252987f, 0.16480811f, -0.03047131f, -0.03275805f, -0.03688545f, -0.00870557f, -0.16838437f, -0.01951254f, 
    -0.29226360f, -0.04080503f, -0.50724542f, 0.08679906f, 0.04544245f, -0.06173468f, 0.00316133f, 0.01642209f, 
    -0.04259374f, 0.20471564f, -0.12613423f, -0.05340370f, -0.55677694f, -0.39306396f, -0.43771434f, -0.24036239f, 
    0.02972518f, 0.02662397f, -0.10470778f, -0.36415374f, -0.08733046f, 0.06859192f, 0.12496695f, 0.01533392f, 
    -0.20943765f, -0.61302972f, -0.00255181f, 0.59941435f, 0.18116726f, -0.19213213f, 0.25093660f, -0.05703923f, 
    0.04088961f, 0.13785842f, 0.14988601f, 0.23312975f, 0.27881497f, -0.04405119f, 0.39040723f, -0.19716501f, 
    -0.00509245f, 0.11421893f, 0.03102734f, 0.09176368f, -0.31073511f, 0.01304350f, -0.11018847f, -0.23784751f, 
    0.09802748f, 0.01058273f, 0.29554436f, -0.20512304f, 0.20148501f, -0.02109400f, 0.08300615f, -0.04093489f, 
    -0.02090801f, 0.05150749f, 0.09953327f, 0.00136588f, -0.01864629f, -0.37225074f, 0.22610961f, -0.15654384f, 
    0.11084656f, -0.09643837f, -0.25201875f, 0.16668642f, 0.04034409f, -0.00033621f, 0.11585554f, -0.02499187f, 
    -0.21379673f, 0.43630898f, -0.34791109f, -0.13386917f, -0.09414966f, 0.13728498f, -0.06234073f, -0.07704797f, 
    -0.07538719f, -0.07299213f, -0.05597742f, -0.16655999f, 0.01525522f, -0.41712740f, 0.14767478f, -0.25045267f, 
    0.01006560f, -0.02354199f, -0.11722938f, 0.23672764f, 0.08645527f, 0.08054651f, -0.04204134f, -0.09164134f, 
    0.89930421f, -0.02652024f, 0.56810445f, -0.00839275f, 0.02532977f, 0.04535078f, -0.29081389f, 0.12524852f, 
    -0.26509500f, -0.03091419f, -0.10890405f, -0.14107773f, -0.19307062f, 0.40428996f, -0.04901525f, -0.07664511f, 
    -0.01541936f, -0.20283243f, 0.03384243f, -0.06210675f, 0.09981874f, -0.05282974f, 0.06650472f, 0.06912877f, 
    -0.19153635f, -0.16645826f, -0.31415948f, -0.09648389f, 0.19254851f, -0.21369746f, -0.13031076f, 0.20651525f, 
    -0.34556842f, 0.04228303f, -0.06426182f, -0.18825354f, -0.00143760f, -0.20469326f, -0.02224687f, -0.35898635f, 
    0.11543494f, -0.10488825f, 0.05025245f, 0.01470968f, -0.00862948f, 0.41426343f, 0.23355126f, 0.15863268f, 
    -0.28805745f, 0.59302229f, -0.71283728f, 0.54593253f, -0.22039677f, -0.01640001f, 0.16279048f, 0.38079372f, 
    -0.04267978f, -0.13823931f, -0.10404924f, -0.24861272f, -0.39178464f, -0.03907329f, 0.08818984f, 0.35680765f, 
    -0.27494928f, 0.02325898f, -0.11576087f, 0.10451293f, 0.10944620f, 0.00694967f, -0.15522753f, 0.06859715f, 
    -0.18533376f, -0.45222485f, 0.18777502f, -0.07598325f, -0.30920810f, -0.29177848f, -0.20668203f, -0.07509446f, 
    0.05080774f, -0.06196930f, 0.00859534f, -0.02411169f, -0.44960567f, 0.44450301f, -0.34249336f, -0.25446805f, 
    -0.02987359f, -0.10959021f, 0.06024269f, -0.19157024f, 0.03777236f, -0.02207439f, -0.05933927f, -0.02832436f, 
    -0.79623532f, -0.35211712f, -0.33317292f, 0.12981619f, 0.04193363f, 0.18208383f, -0.06892800f, -0.04485530f, 
    -0.23324557f, -0.11756847f, 0.14356045f, -0.09888556f, -0.24026182f, 0.17668854f, -0.20748961f, -0.20312722f, 
    -0.01663292f, -0.04610445f, 0.04328209f, -0.06119893f, 0.17283307f, 0.13484316f, -0.09718158f, -0.06358945f, 
    -0.02624490f, -0.09169335f, -0.02011629f, 0.09478805f, 0.11015952f, -0.12298369f, -0.02013391f, 0.01661060f, 
    0.08131078f, -0.12442979f, -0.05222351f, 0.00188079f, 0.29733765f, -0.16072145f, 0.57038862f, 0.13674434f, 
    -0.00165094f, -0.12112196f, 0.05120416f, 0.07313420f, -0.01342603f, 0.00787133f, 0.02154345f, 0.09304579f, 
    -0.00924373f, -0.33571801f, 0.08886664f, -0.17162620f, 0.21418215f, -0.03409421f, 0.17624699f, -0.01446930f, 
    -0.00465568f, 0.12892625f, 0.00596485f, -0.08596494f, -0.26970676f, 0.18178460f, -0.16189970f, 0.28269568f, 
    0.03596479f, -0.17157061f, 0.18173996f, 0.09118272f, 0.17389224f, 0.09484863f, 0.05248841f, 0.02049003f, 
    0.44148698f, 0.48102233f, 0.29171798f, -0.11489055f, -0.05831789f, -0.14031185f, 0.16416875f, 0.06443025f, 
    -0.04650659f, -0.00404628f, 0.04186661f, -0.02484339f, -0.12278555f, -0.10457407f, 0.10854466f, -0.16521510f, 
    0.12689061f, 0.09897158f, -0.01530997f, 0.12570910f, 0.14541121f, 0.08301631f, 0.18343803f, 0.18696584f, 
    -0.12310790f, -0.21488477f, -0.30975971f, 0.53699636f, 0.13587268f, 0.14151414f, 0.13091536f, 0.21198173f, 
    0.01569722f, 0.10607925f, 0.23766440f, 0.07084772f, -0.01248568f, -0.19038656f, 0.02952822f, -0.08717658f, 
    -0.11540573f, -0.19211248f, -0.01520453f, 0.06165772f, -0.00467791f, 0.07851265f, -0.03946988f, -0.16158007f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20591368f, 0.15025406f, 0.11498972f, -0.12182922f, -0.15715247f, 0.05943890f, 0.04871392f, -0.19771075f, 
    0.08048312f, -0.02599003f, 0.08901132f, -0.03122662f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
