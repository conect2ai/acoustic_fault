#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.84067863f, -0.31744972f, -0.13136160f, 0.45484406f, 0.20541021f, 0.13542983f, -0.37612975f, 0.25625917f, 
    -0.08908568f, 0.20016843f, 0.71138459f, 0.53341037f, 0.04489987f, -0.37722790f, -0.11708702f, -0.15260051f, 
    -0.36877188f, 0.32251254f, -0.56488431f, 0.53810459f, 0.09971096f, -0.42940742f, 0.06516670f, 0.49273959f, 
    -0.26648811f, 0.16018529f, 0.00848401f, 0.56827825f, 0.21948925f, 0.24096310f, -0.24909116f, 0.34184355f, 
    0.17331506f, 0.00392436f, 0.27913049f, 0.18489347f, 0.38307238f, 0.84733820f, 0.14222457f, -0.50418442f, 
    -0.53053039f, -0.20183758f, 0.26350969f, -0.34211290f, -0.30630609f, -0.39039585f, -0.84660149f, -0.67776841f, 
    -0.65971708f, -0.32067052f, 0.17577034f, 0.38298208f, -0.17200124f, -0.14272228f, -0.73939359f, -0.75069696f, 
    0.04390803f, 0.80986774f, 0.32972515f, 0.02832393f, 0.34930754f, 0.01502868f, -0.14969826f, 0.55434453f, 
    -0.93379039f, 0.07113352f, -1.05837226f, -0.93083274f, -0.46020287f, -0.46733075f, -0.81629157f, -0.17479087f, 
    -0.83080751f, -0.48895273f, -0.71232361f, 0.01964789f, 0.31322598f, 0.08261496f, -0.47784889f, -0.56541944f, 
    -0.75432599f, -0.08845632f, -0.99535948f, 0.13867527f, 0.30444908f, 0.60670567f, 0.24423864f, -0.20052359f, 
    -0.62923753f, 0.38713986f, 0.14556578f, 0.26304859f, -0.80619079f, -0.04545974f, -0.66394776f, -0.96950835f, 
    -0.55450124f, 0.22234994f, 0.53933859f, -1.26875055f, 0.07857828f, -0.90573585f, 1.00901973f, -0.56604475f, 
    0.55682826f, -0.06532650f, 0.18279029f, 0.18030544f, 0.76948947f, 0.32636240f, -0.16213778f, -0.73201072f, 
    0.67235118f, 0.38571104f, -0.59599704f, -0.04243857f, -0.64347339f, -0.44443202f, -0.10580128f, 0.56113297f, 
    0.31786987f, -0.14453022f, -0.26653090f, -0.37545520f, 0.47974336f, 0.05886817f, 0.39984754f, -0.94974577f, 
    0.64621806f, 0.34360677f, -0.42785463f, -0.58570963f, -0.56595016f, -0.24948923f, -0.78305382f, -0.05579837f, 
    0.54666221f, -0.00287062f, -0.55022663f, 0.24937785f, 0.38117158f, 0.04162198f, 0.10611964f, 0.16123571f, 
    -0.02561895f, -0.53936464f, -0.05852843f, -0.15140845f, 0.34449157f, -1.14631391f, -0.03457677f, -0.43461969f, 
    -0.75276756f, -1.22279298f, -0.45560250f, -0.89391494f, 0.30087388f, -0.41597575f, -0.43156108f, -0.19063386f, 
    -0.45211980f, -0.38032734f, 1.05080605f, -0.18152967f, -0.49454266f, 0.51023763f, -0.32776344f, 0.02925788f, 
    0.60376942f, -0.40592754f, -0.27151412f, -0.03725481f, 0.93346649f, -0.17480837f, -0.82717097f, 0.27281675f, 
    -0.62215972f, 0.30312043f, 0.42781940f, 0.28516230f, 0.64016247f, 0.76770842f, -0.59248030f, -0.11801072f, 
    -0.40294054f, 0.08224176f, -0.35967535f, 0.09490786f, 0.39753479f, -1.37239599f, 0.98580557f, 0.15327732f, 
    -0.24439511f, -0.07865204f, 0.74124157f, -0.34719533f, -0.15060435f, 0.33620873f, 0.58001083f, -0.76439577f, 
    -0.28457889f, -0.56240445f, -0.09825166f, 0.24453883f, 0.30607691f, -0.13782170f, 0.63812119f, 0.38913816f, 
    -0.31119159f, 0.88195837f, -0.93889308f, -0.64274043f, 0.19654460f, -0.05258180f, 0.03066411f, 0.47814447f, 
    -0.67996162f, 0.81483012f, -0.37919736f, -0.06258857f, -0.00466133f, 0.22878978f, -0.03524778f, -0.42258012f, 
    0.44402266f, -0.47272477f, -0.77541411f, -0.00705542f, -0.76295686f, -1.33179808f, -0.81419706f, 0.55506337f, 
    0.30192611f, 0.21522625f, 0.89157283f, -0.91488159f, -0.99859595f, 0.55913925f, 0.85822338f, 0.60115087f, 
    -0.48200920f, -0.38007739f, -0.16211389f, -1.12257457f, -0.54767138f, 0.15664312f, -0.44287163f, 0.86638719f, 
    -0.56493664f, 0.14170264f, 0.55527288f, -0.48669359f, -1.01678121f, -0.48647109f, 1.35825169f, -0.67403811f, 
    -0.83909124f, 0.37177414f, 0.34309101f, -0.07891668f, -0.44024453f, 0.59654123f, 0.07585596f, -0.72727251f, 
    -0.05144021f, 0.09477963f, 0.05405156f, 0.19273743f, -0.01773646f, 0.18542904f, -0.71184492f, -0.95754087f, 
    -0.92318535f, 0.34827060f, 0.60467708f, 0.22579655f, 0.36955470f, 0.27330428f, 0.01004180f, 0.95689666f, 
    -1.45921481f, 0.13548431f, -0.59554172f, -0.52670228f, 0.74710464f, -0.15949759f, 0.39387888f, -0.48186591f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06009500f, 0.06793980f, 0.41469881f, -0.21947706f, 0.14411750f, -0.12746957f, 0.05596804f, -0.10711551f, 
    -0.32286736f, -0.12932782f, 0.21675494f, 0.13018392f, 0.33086082f, 0.05622572f, 0.01234698f, 0.33676147f, 
    -0.08014482f, -0.49398267f, 0.12871315f, -0.11161063f, 0.26057482f, 0.23424308f, 0.10125630f, 0.18707255f, 
    0.02867766f, 0.10982866f, 0.17894864f, 0.15342472f, 0.26694158f, 0.27952012f, 0.06696410f, 0.35319680f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20306015f, -0.12534681f, -0.08569042f, 0.02491241f, 0.04344642f, 0.05025619f, 0.05863837f, 0.05288979f, 
    0.06619012f, 0.06429969f, 0.14664418f, 0.05230526f, -0.03662437f, -0.14512506f, -0.03164483f, -0.04925057f, 
    0.08228891f, -0.13236772f, 0.01393059f, 0.02721313f, -0.33208847f, -0.16869269f, -0.05989986f, -0.09285954f, 
    -0.00065047f, 0.02072556f, 0.00500946f, 0.00472716f, 0.10952837f, 0.03441000f, 0.00998246f, 0.01289510f, 
    0.01744743f, 0.08143034f, 0.07093161f, -0.04134459f, -0.01262051f, -0.18975303f, 0.00375326f, -0.09154242f, 
    -0.77333391f, -0.33974153f, 0.15368095f, 0.06504510f, -0.13112372f, 0.01917589f, -0.10327493f, -0.05764896f, 
    0.04119697f, 0.00952677f, -0.03216168f, 0.00538931f, -0.00752931f, -0.08340335f, -0.02909681f, -0.17165510f, 
    -0.11318485f, -0.02448160f, -0.12776406f, 0.03184989f, -0.03050059f, -0.00519894f, 0.00989446f, 0.04002099f, 
    0.06699292f, 0.03921056f, 0.05627632f, 0.08193146f, 0.04965105f, 0.07415020f, -0.07199177f, 0.00292138f, 
    0.10523392f, -0.00835558f, 0.04472752f, -0.09231857f, -0.28821838f, -0.04313082f, -0.06737901f, -0.01210599f, 
    -0.61956245f, 0.22739583f, 0.16876973f, 0.00770480f, -0.13785385f, -0.04578413f, -0.07314364f, -0.13608375f, 
    0.06397915f, 0.03041179f, 0.02404772f, -0.00937770f, 0.00336126f, 0.04283593f, 0.09360913f, 0.16214149f, 
    0.09005568f, 0.02504108f, 0.01612751f, 0.03821564f, 0.38174045f, 0.25904948f, 0.06013861f, -0.40255368f, 
    -0.13270226f, 0.26502633f, 0.17732292f, 0.23290111f, -0.11288192f, -0.06155821f, -0.03161650f, -0.04059437f, 
    -0.04580733f, 0.03957116f, 0.05818603f, -0.02243670f, -0.02802613f, -0.03391620f, -0.04865060f, -0.03313539f, 
    0.17276020f, -0.02378331f, -0.30162227f, -0.00437629f, 0.12167179f, 0.08593084f, 0.11090238f, 0.11167213f, 
    -0.02387710f, 0.15794289f, -0.00736662f, 0.04374472f, -0.06273468f, 0.05361637f, 0.03506477f, -0.04064905f, 
    0.04642259f, 0.04887546f, 0.01179653f, -0.02578624f, 0.11880769f, 0.22826833f, 0.24746732f, -0.41414642f, 
    -0.04829174f, 0.06565851f, 0.14192244f, 0.06998302f, -0.19027850f, -0.09599857f, -0.00290223f, -0.02369884f, 
    -0.00496289f, 0.00639208f, -0.10300662f, -0.06449328f, -0.12726437f, -0.09414975f, 0.11530191f, 0.05866547f, 
    0.34782341f, 0.15579160f, 0.16901824f, -0.09607527f, -0.09425817f, 0.20441476f, 0.18917377f, 0.21082783f, 
    -0.02480986f, 0.06095356f, 0.02424148f, 0.02842834f, 0.00809910f, 0.07161262f, -0.00418123f, 0.01517954f, 
    -0.08071234f, 0.01586357f, 0.07589392f, -0.04367520f, -0.00782112f, -0.12363022f, -0.10339374f, -0.03617992f, 
    0.05890536f, 0.02780164f, -0.05659180f, 0.05751298f, 0.05831504f, 0.03473134f, 0.12941618f, 0.06425425f, 
    -0.06809963f, -0.05382919f, -0.08329486f, -0.05469737f, 0.12008234f, 0.09454490f, 0.04771196f, 0.03533116f, 
    0.07865083f, 0.09073327f, -0.25237909f, -0.27428666f, -0.33801508f, 0.08416973f, -0.06129982f, 0.00528093f, 
    -0.13019219f, 0.08590014f, 0.03215026f, -0.06905511f, 0.03637601f, -0.04016113f, 0.07770084f, -0.02388421f, 
    0.00414429f, -0.03066608f, 0.03649828f, -0.19340080f, 0.22828409f, 0.02548460f, 0.08960981f, -0.13386451f, 
    0.12740739f, 0.06577757f, 0.25144580f, 0.17878985f, -0.14932266f, 0.02591031f, -0.18754521f, -0.04448919f, 
    0.04610173f, -0.03461230f, 0.09363071f, -0.03940546f, 0.08313406f, 0.00690168f, -0.07093470f, -0.02582023f, 
    -0.24765882f, 0.05075009f, 0.21543942f, 0.20833968f, -0.28002378f, 0.00380061f, 0.01909943f, -0.06234574f, 
    0.06479628f, 0.08578005f, 0.03958421f, 0.02731980f, -0.04286390f, 0.01679175f, -0.01780424f, -0.10645346f, 
    0.07658642f, 0.01726310f, -0.14892982f, -0.01170351f, 0.07098186f, 0.00266235f, 0.04828229f, -0.03249617f, 
    0.08945145f, -0.06503294f, 0.07889249f, 0.00508622f, -0.00092068f, 0.07081661f, -0.18091021f, -0.22116746f, 
    -0.05933462f, -0.29406020f, -0.07238536f, -0.04381093f, 0.04278424f, -0.02500116f, 0.02668370f, -0.03343019f, 
    0.21639700f, 0.11983624f, -0.01378647f, -0.47601154f, 0.22114426f, -0.07465780f, -0.26320362f, 0.05015855f, 
    -0.11555383f, 0.04075827f, -0.04063696f, 0.00184116f, -0.04544997f, 0.00064419f, -0.01842564f, 0.03781492f, 
    0.01746027f, 0.12300774f, 0.01322881f, 0.04188119f, -0.12271345f, -0.09349690f, 0.04553763f, 0.07445343f, 
    -0.03164845f, -0.02905298f, -0.05781475f, 0.05502133f, 0.03077787f, 0.01757059f, -0.06701168f, 0.03021642f, 
    -0.06938658f, -0.04477403f, 0.05398104f, -0.03463556f, -0.10028855f, -0.09034825f, -0.03005322f, -0.02145299f, 
    0.36168528f, 0.04812708f, 0.00059185f, -0.33200926f, 0.02484588f, 0.11872854f, 0.02797171f, -0.01636213f, 
    -0.19748734f, 0.16573298f, -0.03120958f, 0.05879427f, -0.09154037f, 0.03825076f, -0.07174664f, 0.08386277f, 
    -0.21401574f, 0.16038851f, -0.06991694f, 0.17978090f, 0.41157955f, 0.25746536f, 0.10382432f, -0.32883203f, 
    -0.01784465f, 0.13379699f, 0.30645201f, 0.21787529f, 0.06000375f, 0.15332341f, 0.02828979f, 0.00308398f, 
    0.00865720f, -0.05324456f, 0.04053885f, -0.09599341f, -0.14142029f, -0.03869369f, -0.25959823f, -0.05508818f, 
    -0.58362776f, -0.27708766f, -0.40055698f, 0.07693364f, -0.15069948f, -0.03364604f, 0.07590627f, 0.00161266f, 
    0.00555327f, 0.00960491f, -0.11328311f, 0.05781933f, 0.01945592f, -0.09683929f, 0.04819996f, -0.20736960f, 
    -0.10903315f, -0.00385194f, -0.02595937f, -0.03728371f, 0.03757138f, 0.01878064f, -0.02580151f, 0.06292533f, 
    -0.02165958f, -0.14751968f, -0.17232241f, -0.07216419f, 0.02946619f, 0.03618664f, -0.01663025f, 0.09129041f, 
    0.02386649f, -0.06541902f, -0.06263622f, -0.07888343f, -0.06636048f, -0.05168655f, -0.19946007f, -0.12847079f, 
    -0.36067519f, -0.30701864f, -0.15740237f, 0.01662170f, -0.19279583f, 0.02515698f, -0.05636593f, -0.11052547f, 
    -0.06145256f, 0.01069204f, -0.01860970f, 0.04217041f, -0.08991895f, 0.08044264f, 0.11443644f, -0.12379055f, 
    -0.03910261f, -0.14638576f, 0.01318453f, -0.12405782f, -0.70968908f, -0.27809805f, 0.30645281f, -0.07245564f, 
    0.14978671f, -0.07363135f, -0.19390498f, 0.03845932f, 0.07245275f, -0.11789864f, -0.07101022f, -0.04394417f, 
    0.05752669f, -0.18936986f, -0.03337683f, -0.02537000f, -0.12420146f, 0.02341046f, -0.20641968f, -0.06157856f, 
    0.19219346f, 0.28887478f, 0.05941346f, -0.11934114f, -0.01621206f, -0.06487355f, -0.09060358f, 0.08432623f, 
    -0.25046614f, -0.33177945f, -0.09909151f, -0.09518486f, -0.10137387f, 0.01077144f, 0.03836689f, -0.04691146f, 
    -0.09446007f, -0.06674228f, -0.05824988f, -0.02427734f, -0.15074918f, 0.03472260f, 0.27305982f, -0.34854123f, 
    -0.04983411f, -0.39864871f, -0.00481320f, -0.13287798f, -0.19908607f, -0.25287369f, 0.03515086f, -0.03729230f, 
    -0.01355517f, 0.02489193f, -0.06106447f, -0.09533169f, -0.02581624f, -0.01594041f, -0.02939129f, -0.22265677f, 
    -0.51482004f, -0.18524496f, 0.19792299f, -0.06552907f, 0.26023528f, 0.08044276f, -0.14118922f, -0.15133673f, 
    0.05792021f, -0.13930395f, -0.01920674f, -0.14988321f, 0.04218386f, -0.06857958f, -0.01779745f, -0.11701404f, 
    -0.11237389f, -0.00448873f, -0.29268017f, -0.23051555f, 0.37182003f, 0.34599888f, 0.03138749f, -0.49780223f, 
    -0.15300985f, 0.10639876f, 0.09868509f, -0.10901808f, 0.03351359f, 0.10669468f, 0.07455746f, 0.00456430f, 
    -0.05113598f, 0.03186908f, 0.01800324f, -0.00477869f, -0.00820128f, -0.02475557f, 0.19754256f, 0.07014232f, 
    0.21534114f, -0.46696091f, -0.75447762f, 0.09625458f, -0.08203590f, 0.04208121f, 0.03385146f, 0.10439249f, 
    -0.03914511f, 0.08768542f, -0.00133812f, 0.10738587f, -0.11432746f, -0.03768609f, -0.10249709f, 0.02078980f, 
    0.16826536f, -0.00500435f, -0.01384385f, 0.00848202f, 0.33239588f, 0.14542677f, -0.08866689f, -0.30990195f, 
    -0.16384746f, -0.05145637f, -0.11305915f, 0.16934851f, 0.12113435f, 0.06788118f, -0.05664795f, -0.05125330f, 
    -0.10688828f, 0.02552987f, -0.08293847f, 0.00341698f, -0.01395404f, -0.08557006f, -0.02340844f, 0.11971986f, 
    0.19471735f, 0.20132041f, 0.53078187f, -0.42893949f, 0.12296556f, -0.05998222f, 0.05927561f, -0.06639304f, 
    -0.02922832f, -0.08941721f, 0.02629917f, -0.11538026f, -0.22656453f, -0.00054073f, -0.07691018f, -0.01603690f, 
    0.01173607f, -0.11706848f, 0.05450840f, -0.10556179f, -0.03846810f, -0.00321008f, -0.15975350f, 0.09806945f, 
    0.02400426f, 0.01785859f, -0.00639890f, 0.00372884f, 0.04232756f, -0.00003710f, -0.26450315f, -0.13855052f, 
    -0.21488786f, -0.11228028f, -0.02737112f, -0.04083985f, 0.02393930f, -0.09400596f, -0.00039242f, -0.03052096f, 
    0.37320122f, 0.25679892f, -0.31130376f, 0.07577612f, 0.13599044f, 0.20450693f, 0.15972406f, 0.21233685f, 
    -0.22404410f, -0.24909002f, -0.11778092f, -0.09043338f, -0.14329882f, 0.09590384f, 0.04728752f, 0.04155878f, 
    0.05282617f, 0.00513156f, 0.02254149f, 0.04246160f, 0.07844142f, 0.03745166f, -0.06341563f, -0.32671651f, 
    -0.05659605f, -0.01735344f, -0.11692023f, 0.12261291f, -0.19666879f, 0.04805702f, -0.06339452f, -0.01777669f, 
    -0.10119177f, -0.01177886f, -0.18590140f, 0.06783316f, -0.09462585f, -0.00704257f, -0.01149044f, 0.01048996f, 
    0.71827936f, 0.06051929f, 0.05835915f, 0.11234612f, 0.04074819f, -0.02063840f, -0.00534233f, -0.02401914f, 
    0.00677349f, -0.05079164f, -0.16292451f, 0.14398603f, -0.04020184f, 0.03512148f, 0.00337439f, -0.03418818f, 
    -0.07430183f, -0.06410692f, 0.02948662f, -0.03758873f, 0.21631652f, 0.07338869f, -0.10884491f, -0.05103670f, 
    0.11492517f, -0.02850707f, -0.06809312f, -0.06971385f, -0.05657549f, -0.02028728f, -0.01301108f, 0.04708510f, 
    0.06620655f, 0.01553971f, 0.01745453f, 0.08282738f, 0.11252536f, -0.02549171f, 0.04428436f, 0.07722244f, 
    -0.15572512f, -0.25002366f, 0.18747185f, 0.04126708f, 0.18785013f, -0.02986574f, 0.04226495f, 0.04540986f, 
    -0.09378444f, 0.04338622f, 0.21557976f, 0.05955764f, 0.05883837f, 0.02005720f, 0.01274719f, -0.01681050f, 
    0.05048201f, -0.01084316f, 0.13901378f, 0.08200583f, 0.09785242f, 0.05149994f, 0.09805086f, 0.03933377f, 
    0.15238009f, -0.01584252f, -0.06770211f, -0.07205126f, -0.08398300f, -0.02876739f, -0.00106552f, -0.02071464f, 
    0.09024283f, 0.08194805f, 0.00355803f, -0.23073232f, 0.05753794f, -0.10493205f, 0.04183084f, -0.01945219f, 
    0.15507065f, 0.03920262f, 0.11890285f, -0.20272005f, -0.10391280f, -0.00380173f, -0.07380839f, -0.07995521f, 
    -0.19579659f, 0.01246542f, -0.02940448f, -0.03942377f, 0.01841708f, 0.01383273f, 0.08708823f, -0.04619293f, 
    -0.08322708f, -0.01703549f, 0.02165298f, -0.20758097f, -0.17792387f, 0.27636057f, 0.16056904f, 0.26106292f, 
    0.14263196f, -0.08646523f, -0.01154219f, 0.13574964f, -0.25991875f, 0.11002865f, -0.05131195f, -0.08609816f, 
    0.00829838f, -0.00657907f, -0.00098197f, 0.03020855f, 0.00277322f, 0.00063920f, -0.12674128f, 0.12920766f, 
    0.22754344f, -0.15757525f, -0.28967199f, -0.02100687f, -0.08816545f, -0.07626010f, -0.09999039f, 0.07298509f, 
    0.05698966f, -0.05387651f, -0.00519912f, -0.05178418f, 0.09240638f, -0.12608919f, -0.04546442f, -0.04111904f, 
    -0.08389084f, -0.05385916f, 0.04559027f, -0.03604418f, -0.28429043f, 0.20306419f, -0.22238041f, -0.12164388f, 
    -0.30151987f, -0.06312949f, -0.09617884f, -0.05679050f, -0.11234433f, -0.00550554f, -0.02375781f, 0.04276790f, 
    0.09915805f, -0.00438007f, 0.06528699f, -0.03235161f, -0.04016001f, 0.14121692f, -0.48391232f, -0.15383379f, 
    0.20385548f, 0.27592233f, 0.44498435f, 0.06698886f, -0.15138720f, 0.14831862f, -0.17861292f, 0.14512204f, 
    0.14759089f, 0.08624511f, 0.04333024f, -0.02475551f, -0.06316151f, -0.03346309f, 0.05198813f, 0.19385268f, 
    -0.15183218f, -0.05879293f, 0.00691529f, -0.03514850f, 0.01337613f, -0.36199301f, 0.20797819f, 0.12838453f, 
    0.00059840f, -0.07775200f, 0.03652437f, 0.00216626f, -0.08185842f, -0.13333960f, 0.10544242f, -0.23169217f, 
    0.15859623f, -0.06240785f, -0.12779148f, 0.01228592f, -0.04193614f, -0.04929412f, -0.03030259f, -0.07368217f, 
    -0.03261128f, -0.13854647f, -0.27951628f, 0.28605226f, -0.36226928f, -0.01420366f, -0.01007514f, -0.36386567f, 
    0.02045601f, 0.02647717f, 0.01940804f, 0.00744074f, 0.05194313f, 0.06268670f, 0.08318563f, -0.08207663f, 
    0.09482513f, -0.03809367f, 0.00181430f, 0.02404728f, -0.66936988f, 0.05003692f, -0.36282283f, -0.21017641f, 
    -0.04612080f, -0.06190340f, 0.05007980f, 0.10005516f, 0.09062463f, -0.28242153f, -0.10932606f, -0.02451165f, 
    -0.07302365f, -0.07326043f, -0.07161069f, 0.00243844f, 0.05019025f, 0.02528166f, -0.03777886f, 0.02454380f, 
    0.62385559f, 0.21035479f, 0.21491769f, 0.06972645f, 0.04283533f, -0.05277143f, -0.02275736f, 0.02087670f, 
    -0.06581107f, 0.00503720f, -0.03098720f, 0.08900248f, -0.00828521f, 0.05139498f, 0.04161013f, 0.03256349f, 
    -0.07039859f, -0.07377177f, 0.12889671f, 0.10036531f, -0.02811007f, 0.01932712f, 0.10831498f, 0.04030237f, 
    0.13165982f, 0.08335734f, -0.08751665f, 0.06701767f, 0.06120992f, 0.00981888f, 0.00703392f, 0.09786664f, 
    0.06795055f, 0.16258460f, -0.00037474f, -0.17916743f, 0.03293867f, 0.08144974f, -0.06681065f, -0.10028677f, 
    -0.17111239f, -0.12001795f, -0.37916720f, -0.25797805f, -0.05981931f, 0.07837899f, 0.04143537f, -0.12503514f, 
    0.15303993f, -0.16222359f, 0.05705454f, 0.09106530f, -0.04476025f, -0.01545702f, 0.06053363f, -0.13206421f, 
    -0.39292234f, -0.37070569f, -0.26334736f, -0.28757223f, 0.08244862f, -0.01272499f, 0.13193214f, 0.03352923f, 
    0.08724958f, 0.00886114f, -0.00939771f, -0.02738939f, 0.00429733f, -0.00666838f, 0.09858632f, -0.03716597f, 
    0.02985423f, 0.09614401f, -0.00863778f, -0.12987919f, 0.10990836f, -0.11518365f, 0.05692900f, -0.00250984f, 
    0.28127569f, -0.04195540f, -0.18643798f, -0.30716607f, 0.04324880f, 0.19886778f, -0.13162208f, -0.05726106f, 
    0.27058649f, 0.17189337f, 0.08925498f, 0.01428492f, 0.14629307f, -0.07139379f, 0.11148519f, -0.25471801f, 
    -0.04594464f, -0.19822885f, -0.06090378f, -0.07531545f, 0.23066187f, 0.39493412f, 0.33987662f, 0.25153109f, 
    -0.05934656f, 0.05104458f, -0.24851054f, -0.09363826f, -0.00112877f, -0.21733281f, -0.01765399f, -0.00494202f, 
    0.00526628f, -0.15390047f, -0.00021269f, 0.03840096f, 0.06213352f, -0.03974833f, -0.14697282f, 0.02522733f, 
    0.39849260f, 0.17823093f, -0.02342649f, 0.13180876f, -0.02982475f, -0.02847807f, -0.08160946f, 0.01202953f, 
    0.04630216f, -0.07423870f, -0.00515073f, -0.05549045f, -0.07720908f, 0.03957973f, -0.02298742f, 0.13214219f, 
    -0.12368874f, 0.12702170f, 0.16204008f, -0.04266758f, -0.04396100f, -0.12227089f, -0.02824049f, -0.07273076f, 
    -0.13910562f, -0.01767949f, -0.00690205f, -0.20998785f, 0.08223665f, 0.06477798f, 0.01977524f, -0.10882457f, 
    -0.03544766f, 0.24406093f, 0.16118175f, -0.03601853f, -0.00209289f, -0.15899631f, 0.08417062f, 0.01704235f, 
    0.08206036f, 0.02710073f, 0.08275532f, -0.04641694f, 0.02695980f, 0.02981102f, -0.05325067f, -0.06932980f, 
    -0.06183919f, -0.01947909f, -0.04914730f, -0.01800295f, 0.11392406f, 0.10389783f, -0.09413206f, -0.03445903f, 
    0.05602971f, 0.01275904f, 0.04687748f, 0.02850283f, -0.56254601f, -0.38912052f, 0.11357132f, 0.04097524f, 
    0.15924187f, 0.06711201f, -0.04378326f, 0.09607165f, -0.06544161f, -0.03655449f, 0.03514704f, 0.03000716f, 
    -0.09658027f, 0.06166303f, 0.10956641f, 0.08995788f, 0.03633554f, 0.02880517f, 0.03258828f, -0.03286654f, 
    -0.17024696f, -0.09933916f, -0.15645264f, 0.01561290f, -0.08827376f, -0.05332560f, 0.26085368f, 0.23371577f, 
    -0.17088780f, 0.18351220f, 0.14751478f, -0.15263224f, 0.12252182f, 0.03632726f, -0.02744313f, -0.02845564f, 
    -0.03033284f, -0.01493706f, 0.02676277f, -0.00456943f, -0.13052848f, 0.11955339f, 0.02503542f, -0.21437858f, 
    -0.02515790f, -0.09103388f, -0.01803089f, -0.09871685f, -0.06440591f, 0.12417915f, 0.02287397f, -0.00025312f, 
    0.02566394f, 0.05363017f, -0.05299110f, 0.08003803f, 0.04618260f, 0.00450436f, 0.16293941f, -0.05181678f, 
    -1.13678539f, -0.37661922f, 0.12330642f, -0.05635817f, 0.00248726f, 0.14035597f, -0.00839489f, 0.11927774f, 
    -0.08757404f, -0.04082844f, -0.03584000f, 0.32696638f, -0.00354169f, 0.02687116f, -0.18640946f, 0.15881455f, 
    0.18441679f, -0.08199427f, -0.03390257f, 0.04967236f, -0.37655765f, 0.17529830f, -0.09250256f, 0.26126707f, 
    0.21656314f, -0.00403351f, -0.01899743f, 0.04632087f, 0.15537299f, -0.05005428f, -0.07536352f, 0.02359853f, 
    0.01251422f, 0.00258850f, 0.03595101f, -0.00040696f, 0.00474599f, 0.05416938f, -0.25460061f, 0.07987284f, 
    1.10463798f, -0.14271347f, 0.34978530f, 0.28710616f, -0.26483694f, -0.00147284f, -0.07327587f, 0.04265737f, 
    -0.08783223f, -0.01330478f, 0.24951363f, -0.34693891f, -0.14255798f, -0.21722679f, -0.03641913f, 0.12523061f, 
    -0.02520901f, -0.27211723f, -0.03175056f, 0.02557621f, -0.00374011f, -0.12720196f, -0.20652357f, -0.16087252f, 
    0.01213962f, -0.24516255f, 0.16840529f, -0.13831845f, 0.11219421f, 0.06267246f, 0.06196371f, 0.02975839f, 
    -0.02319374f, -0.00144214f, -0.03766502f, 0.01464659f, 0.06445356f, -0.07871351f, 0.04632923f, -0.00470236f, 
    -0.80515260f, -0.03645783f, -0.17744303f, -0.41402641f, 0.23384668f, 0.08436374f, 0.00047141f, -0.20020556f, 
    0.28973871f, 0.01223589f, -0.01690038f, 0.13216589f, 0.06401231f, -0.07693311f, -0.02288023f, -0.06709591f, 
    -0.00745143f, 0.08931109f, -0.08422185f, -0.18515870f, 0.07528249f, -0.06143113f, 0.03260344f, -0.02480708f, 
    -0.06711024f, 0.00117390f, -0.01171532f, 0.05201764f, 0.03640331f, 0.02209886f, 0.28132105f, 0.12023082f, 
    -0.01864505f, 0.08143389f, 0.01576887f, -0.11212374f, -0.03121605f, 0.00783017f, 0.04718568f, 0.05964023f, 
    0.08612318f, -0.22274770f, -0.22597995f, 0.00389368f, -0.15252469f, -0.03995133f, 0.03429354f, 0.15671857f, 
    -0.05829443f, -0.08654453f, 0.01057254f, -0.06990424f, -0.07275710f, -0.07072611f, -0.01221342f, -0.04175829f, 
    -0.04098130f, -0.08813486f, 0.01262215f, -0.00360521f, 0.12402295f, 0.58503860f, -0.32048929f, -0.04937702f, 
    0.28540564f, -0.16044362f, 0.21159706f, -0.04439631f, -0.04643956f, 0.29984903f, -0.12372998f, 0.03177096f, 
    -0.07558565f, 0.02862053f, -0.03383750f, -0.00442109f, 0.07727808f, 0.04155921f, -0.15785636f, 0.12911481f, 
    -0.47246358f, 0.03459736f, -0.26184374f, -0.14556935f, -0.05797340f, -0.01305866f, -0.02097174f, -0.08905762f, 
    0.00105702f, 0.08775619f, 0.01358901f, -0.05104034f, -0.07968166f, 0.05783789f, 0.08643176f, 0.05242534f, 
    0.03219718f, 0.20098768f, 0.10312161f, -0.04631383f, -0.34600660f, -0.04948752f, 0.01188673f, -0.41879898f, 
    0.07865110f, 0.00512078f, -0.01235545f, -0.03626046f, 0.06065945f, 0.00150605f, 0.03251330f, -0.02405610f, 
    0.01645773f, -0.00259135f, 0.01445848f, -0.11231557f, -0.04377005f, -0.05340121f, -0.00949924f, 0.00064608f, 
    0.26898208f, -0.03874572f, -0.13099654f, -0.09910894f, 0.15435205f, -0.03990017f, 0.04419761f, 0.00459254f, 
    -0.00082324f, 0.05222717f, 0.03421862f, -0.10629297f, -0.04433639f, 0.11241892f, -0.01061933f, 0.06063105f, 
    0.12753366f, 0.06465065f, 0.13236710f, -0.02895163f, -0.23091643f, -0.13492686f, 0.01656546f, -0.07472280f, 
    0.08294322f, -0.11880271f, -0.05399049f, -0.01918009f, -0.02186766f, 0.07375178f, -0.03055407f, -0.13868840f, 
    -0.05637523f, -0.03191242f, -0.07256617f, -0.11170144f, -0.30248946f, -0.01914069f, 0.00745003f, 0.01184038f, 
    -0.48550940f, -0.45301867f, 0.57974386f, -0.34532577f, -0.26819405f, 0.07130393f, 0.09507522f, -0.00529014f, 
    -0.02559645f, 0.09206004f, 0.01621478f, -0.02227612f, -0.02792389f, 0.05958142f, -0.06161977f, 0.00591122f, 
    0.05133120f, -0.12321136f, -0.00938768f, 0.01609303f, -0.16525763f, 0.18356965f, 0.01003584f, -0.00758312f, 
    0.10373673f, 0.15263270f, -0.04287025f, -0.06185906f, 0.04450969f, 0.03590666f, -0.02368380f, 0.05029990f, 
    0.08752651f, 0.00496966f, -0.02441502f, -0.01177195f, -0.01299337f, -0.06175093f, -0.00782974f, 0.07505908f, 
    0.02954115f, -0.23368056f, 0.55103505f, 0.07914348f, 0.26514980f, 0.04405795f, -0.04171641f, 0.00523758f, 
    0.18411656f, -0.26412275f, 0.04641518f, 0.01487254f, -0.16760816f, -0.06638560f, 0.05331209f, -0.01308405f, 
    -0.07331628f, -0.03843268f, -0.00760144f, -0.02783228f, -0.65033787f, -0.42037559f, -0.43778747f, 0.14598411f, 
    -0.59081757f, -0.01922417f, 0.05394794f, -0.11383891f, -0.06627537f, 0.07008049f, -0.00516669f, -0.02348980f, 
    0.00312789f, -0.03957805f, -0.02766058f, -0.15658697f, -0.00408814f, 0.00060446f, 0.02890974f, 0.14914446f, 
    -0.41535336f, -0.45089835f, 0.54739070f, 0.22268297f, 0.19165093f, -0.15005878f, -0.11854364f, -0.01106435f, 
    -0.14343564f, -0.03337821f, -0.03714070f, -0.03410433f, -0.00037675f, -0.15748408f, -0.11092849f, -0.05747260f, 
    0.07025146f, -0.16341291f, -0.07841603f, 0.02297697f, 0.07083370f, -0.10732382f, 0.25384399f, -0.02844843f, 
    0.14630765f, -0.03863367f, 0.03590113f, 0.10767878f, 0.01515012f, -0.09941856f, 0.00758669f, -0.04422962f, 
    0.10145910f, -0.11687568f, 0.15583488f, -0.06975626f, 0.01263338f, 0.01539050f, 0.01724204f, -0.12684843f, 
    -0.19764365f, -0.55254811f, -0.00580136f, -0.19230548f, -0.15155248f, 0.12002594f, 0.06359711f, -0.01528650f, 
    0.05788400f, -0.19570710f, -0.04976529f, 0.04525621f, 0.05622517f, -0.03146503f, -0.03714547f, 0.03458124f, 
    -0.01064257f, 0.04305277f, 0.10255264f, 0.06847256f, -0.19671156f, 0.00295238f, 0.19382150f, 0.36052576f, 
    0.03456264f, 0.11173437f, -0.18341073f, 0.10437647f, 0.19634917f, -0.21203528f, 0.07284059f, 0.11272335f, 
    -0.00530852f, 0.10927467f, 0.10202412f, 0.02285290f, -0.00031871f, 0.04305322f, 0.02714407f, -0.00411461f, 
    0.01568009f, -0.26633233f, -0.25961077f, -0.09697367f, -0.30804071f, -0.02684898f, 0.05744780f, 0.01866350f, 
    0.02087468f, 0.11716384f, 0.04679133f, -0.03856710f, -0.05857003f, 0.10943208f, -0.02810386f, 0.16651142f, 
    -0.05269037f, -0.00732608f, 0.13119207f, -0.04661527f, 0.21407436f, 0.05509000f, -0.14135787f, 0.01811147f, 
    0.11310574f, 0.10794881f, -0.12720752f, 0.03809163f, 0.04046399f, 0.09097917f, -0.03077120f, -0.06773671f, 
    -0.00273072f, 0.05208433f, -0.06947438f, 0.02496459f, -0.06216986f, 0.01227369f, 0.04286170f, 0.01098252f, 
    -0.13178307f, 0.41028714f, -0.26948997f, 0.01414568f, -0.28414035f, 0.10117904f, 0.02799595f, -0.04885117f, 
    -0.01780103f, -0.01084962f, -0.02649386f, -0.03292071f, 0.04256230f, -0.07720258f, 0.00665151f, 0.11945108f, 
    0.31332123f, 0.22033548f, 0.19863023f, 0.02717515f, -0.04574521f, -0.06439234f, 0.04467325f, -0.05477812f, 
    0.10997646f, -0.03430684f, -0.00121037f, -0.02373580f, -0.00709815f, 0.06220560f, -0.00315618f, -0.06982675f, 
    -0.07951062f, 0.02021437f, -0.07215551f, 0.00339725f, -0.14615980f, -0.00082502f, 0.07294967f, -0.04065849f, 
    -0.25503618f, -0.22845733f, 0.01629309f, 0.15385865f, -0.30321902f, 0.04491403f, -0.05094649f, -0.08146034f, 
    -0.00236441f, -0.15594055f, -0.00371693f, -0.05902667f, 0.01192699f, 0.01291142f, 0.01395989f, -0.06824949f, 
    -0.00472848f, 0.01291610f, 0.14581776f, 0.19201274f, -0.58055288f, -0.51869637f, 0.44394153f, 0.61518514f, 
    -0.28729141f, 0.10964719f, -0.01743525f, -0.11321449f, 0.22946636f, -0.05375419f, -0.03516931f, -0.01427042f, 
    -0.02630623f, 0.04663178f, -0.02920197f, -0.03727312f, -0.01020476f, 0.03484209f, 0.04545326f, 0.01591962f, 
    -0.44012141f, 0.25295472f, -0.03524678f, -0.19719370f, -0.05889314f, 0.00538240f, -0.02356034f, -0.04033720f, 
    -0.03183657f, 0.13056102f, 0.00367596f, 0.10148948f, -0.20119251f, 0.06843656f, -0.11522511f, 0.04597547f, 
    0.01433677f, -0.12245011f, 0.16389981f, -0.09058370f, 0.00621582f, -0.15345217f, 0.07411216f, -0.11132728f, 
    0.07343358f, 0.00164381f, -0.16133611f, -0.46212041f, -0.12630399f, -0.01843049f, 0.03911335f, -0.06348816f, 
    0.02310650f, 0.00351422f, -0.03489573f, 0.08831734f, -0.09503677f, -0.11842615f, 0.02835160f, 0.03691156f, 
    -0.28794464f, -0.00413758f, 0.18241151f, -0.14314282f, 0.10821202f, -0.06535349f, 0.00177406f, -0.01397525f, 
    -0.00003387f, 0.05457740f, 0.00293593f, 0.00842926f, 0.06356443f, -0.01298360f, 0.01204714f, 0.05195733f, 
    -0.13477498f, -0.23516658f, 0.05200334f, -0.01333823f, 0.27488634f, -0.00115064f, -0.40954989f, 0.05916688f, 
    0.10437743f, -0.10355406f, 0.04099629f, 0.05010648f, -0.07692693f, -0.00945564f, -0.19359234f, -0.02990985f, 
    0.00759516f, -0.13332219f, -0.00695353f, 0.01758322f, 0.05694865f, 0.04961037f, 0.12863450f, 0.07650755f, 
    -0.03268245f, 0.06600536f, -0.13304052f, 0.13876650f, 0.18913774f, -0.07970455f, 0.00728078f, -0.15488335f, 
    -0.16967449f, -0.14538723f, 0.19448557f, 0.05704737f, 0.08951855f, 0.02979710f, 0.02042707f, -0.01748733f, 
    0.03860961f, -0.00588700f, 0.03522646f, -0.06003991f, -0.27890611f, 0.08707912f, -0.10319325f, 0.05962485f, 
    -0.03691352f, -0.12875120f, -0.08190094f, -0.22456658f, -0.33321002f, 0.08289830f, 0.04869071f, -0.01461370f, 
    0.01823956f, 0.05575462f, -0.05184464f, 0.04472776f, -0.06670585f, 0.08787841f, -0.23146790f, -0.11652899f, 
    0.58919448f, -0.31230363f, -0.34142631f, 0.19813535f, -0.15228038f, -0.01748959f, -0.16507539f, 0.15548152f, 
    -0.17568167f, -0.19255960f, -0.20944610f, -0.07422038f, 0.02221389f, -0.13297817f, 0.20105903f, -0.03054337f, 
    0.12487233f, -0.14014551f, 0.21260744f, 0.00106225f, -0.55478424f, -0.37696549f, -0.68585187f, -0.17141005f, 
    -0.56966233f, 0.15086521f, 0.10142902f, -0.07565276f, 0.03198038f, -0.12732603f, -0.04171160f, 0.06228780f, 
    -0.03611481f, 0.04010561f, -0.07983060f, -0.01222061f, 0.00576828f, 0.01274686f, -0.26440477f, 0.00931819f, 
    -0.30128098f, 0.28948915f, 0.81932443f, -0.03787674f, 0.12225140f, 0.00265249f, -0.08890995f, -0.03139319f, 
    -0.04397691f, 0.12671356f, 0.14731745f, 0.08475514f, 0.16403674f, -0.12902604f, 0.02809082f, 0.01371290f, 
    0.10712326f, 0.12831703f, 0.10936149f, -0.10498830f, 0.31994784f, -0.21746281f, 0.21022376f, 0.00615807f, 
    0.30321851f, -0.08804385f, 0.11330565f, -0.22949517f, 0.29807916f, 0.10261810f, 0.00414199f, 0.01828993f, 
    0.01623118f, 0.04773431f, 0.00208485f, 0.05411047f, -0.03009291f, -0.12498473f, 0.02060489f, 0.07724071f, 
    0.79747677f, 0.34676665f, -0.80113745f, 0.16016644f, 0.12685478f, 0.09397413f, 0.10571130f, -0.14958078f, 
    0.14665650f, 0.12327297f, -0.02588286f, -0.03242554f, 0.04112706f, -0.01795377f, -0.13870223f, -0.05450324f, 
    0.01243063f, 0.13014275f, -0.22323124f, 0.02242134f, -0.04446048f, 0.13407174f, 0.05336842f, 0.04968133f, 
    0.03164655f, -0.04193747f, -0.02922887f, -0.01781053f, -0.00527100f, -0.04614659f, -0.11781240f, -0.19528019f, 
    0.00737152f, 0.01100603f, 0.08730716f, 0.02047862f, -0.01549532f, 0.00880359f, 0.03905091f, -0.11350685f, 
    0.00512967f, 0.05955484f, 0.55142272f, 0.05514829f, 0.28000906f, -0.17499557f, -0.07965207f, 0.01403051f, 
    0.16159606f, -0.04477733f, 0.05771923f, 0.00895676f, -0.04964679f, -0.05524595f, 0.05602967f, 0.00203891f, 
    -0.01194621f, -0.00881295f, 0.01570939f, -0.06808888f, -0.02093809f, 0.55017000f, -0.39305457f, 0.28741968f, 
    0.04275120f, -0.08846593f, 0.16698150f, -0.10321452f, -0.16335280f, 0.23113345f, 0.08906054f, 0.15295775f, 
    -0.10790997f, -0.01513065f, 0.04790391f, -0.05448961f, -0.00269552f, -0.08252047f, -0.02924849f, -0.06007561f, 
    -0.98631960f, -0.43114147f, -0.11141583f, 0.23570560f, 0.02958093f, 0.35383618f, 0.31033450f, 0.21148635f, 
    0.09216301f, -0.06787217f, -0.03470520f, -0.04115522f, 0.01857325f, 0.08467133f, -0.13379233f, -0.04399614f, 
    -0.08914933f, 0.05214152f, -0.18994021f, 0.00703205f, -0.33928096f, -0.36700466f, 0.68691552f, -0.33648261f, 
    -0.05841318f, -0.30239907f, -0.23945206f, -0.24042517f, 0.04455373f, -0.04291698f, 0.18111470f, 0.03250328f, 
    0.14291099f, -0.07125256f, 0.10429545f, 0.10349187f, -0.01104937f, -0.04603114f, -0.16167614f, -0.07626363f, 
    0.67785800f, 0.29408464f, 0.02581567f, -0.32955414f, -0.50520766f, -0.13260788f, -0.04484058f, 0.03917570f, 
    -0.10830612f, -0.14092520f, -0.15133156f, -0.03908472f, 0.03474412f, 0.08386277f, -0.06291702f, -0.01930431f, 
    -0.00239474f, -0.00986054f, -0.06471767f, 0.05989584f, -0.22889723f, -0.63765407f, -0.20973806f, -0.02485481f, 
    -0.40477872f, -0.07858428f, -0.23619397f, 0.08396880f, -0.18372892f, -0.09181675f, -0.03053704f, 0.07202585f, 
    -0.06392939f, -0.04999804f, 0.04329407f, 0.07414263f, 0.09938419f, -0.00438292f, -0.27337855f, -0.18404818f, 
    -0.16356383f, -0.66183841f, 0.56042153f, -0.02115611f, 0.41705424f, -0.18668577f, -0.02867173f, -0.10670915f, 
    0.27240944f, -0.05287855f, 0.12926428f, -0.04659326f, -0.13243350f, -0.12735969f, 0.07936599f, -0.13408789f, 
    -0.05796628f, 0.04748262f, 0.05361735f, -0.05795782f, 0.01826110f, -0.04946333f, -0.09474932f, -0.04021760f, 
    0.29299739f, 0.04990885f, 0.05681999f, -0.10519500f, -0.02231857f, -0.15426753f, -0.05389027f, 0.02641151f, 
    0.02481687f, 0.03418490f, 0.04883404f, -0.12242899f, -0.05088093f, 0.10762277f, -0.08537112f, -0.01473378f, 
    -0.67277867f, 0.53620368f, -0.09579716f, -0.22523630f, 0.27334982f, 0.40669888f, 0.10801028f, -0.02037203f, 
    -0.04050631f, -0.21169464f, -0.29408297f, 0.05089615f, 0.03706742f, -0.00145084f, 0.11918739f, -0.06218372f, 
    0.07994503f, -0.12494997f, 0.12229477f, 0.03330183f, -0.22064649f, -0.02405359f, -0.21890272f, 0.18588831f, 
    0.28122678f, -0.09835780f, 0.03501276f, -0.03674540f, -0.02987732f, 0.04426339f, -0.08986086f, 0.03477894f, 
    -0.09253297f, -0.19299057f, 0.00119718f, -0.13858484f, -0.08957367f, -0.03759214f, -0.06224254f, -0.02338362f, 
    0.17921871f, -0.00001179f, -0.23150325f, 0.00376702f, 0.30282718f, 0.08282427f, 0.11140852f, 0.00121594f, 
    0.03636599f, 0.02609064f, 0.00434969f, 0.03914580f, 0.09650729f, 0.12259968f, 0.10221486f, -0.00771153f, 
    0.16473465f, 0.13730444f, -0.03291637f, 0.08668785f, -0.80574119f, 1.22029173f, -0.11679588f, -0.34979123f, 
    -0.22063838f, 0.45192158f, 0.20091234f, 0.10606728f, 0.08027039f, 0.22425361f, -0.18578170f, -0.15122831f, 
    0.02204576f, -0.18082221f, 0.13005614f, -0.10645068f, 0.18347627f, -0.13255209f, 0.04250642f, -0.18745999f, 
    -0.04114390f, -0.08570527f, -0.16193889f, 0.05168265f, 0.33148229f, 0.00311485f, -0.02334743f, 0.04173749f, 
    -0.09441949f, 0.12695314f, -0.05446022f, -0.04454033f, -0.16870460f, -0.07156010f, -0.13232046f, -0.12793681f, 
    -0.15314016f, 0.12570082f, 0.01019835f, 0.05363693f, 0.29335940f, -0.31360054f, -0.30215490f, -0.11267456f, 
    0.34368753f, 0.33159187f, 0.11892793f, -0.04540421f, 0.07219699f, -0.36644843f, -0.05610568f, 0.00568614f, 
    0.01430981f, 0.12346283f, 0.05278036f, -0.04714391f, 0.02162458f, 0.39918956f, 0.10256401f, 0.01813124f, 
    0.08338157f, -0.07455553f, 0.35258278f, -0.07061416f, -0.17784716f, -0.09624515f, -0.16580763f, 0.12691405f, 
    0.25202620f, -0.09947998f, -0.03314137f, -0.04004529f, 0.11282196f, 0.02245913f, -0.09875499f, -0.12235145f, 
    0.00240193f, -0.16397697f, 0.02780159f, 0.00147439f, -0.18917382f, 0.82688802f, -0.45524693f, -0.31739756f, 
    -0.21247347f, -0.16263092f, -0.04397893f, -0.20291594f, 0.02094382f, -0.08902910f, -0.16398655f, -0.11031583f, 
    -0.42310950f, 0.03866310f, -0.02755040f, -0.07527901f, -0.06018442f, -0.04833483f, -0.08936301f, -0.07411580f, 
    -0.70659798f, 0.14811023f, 0.09079590f, 0.25500536f, -0.07664247f, -0.13749987f, 0.01792550f, 0.07854046f, 
    -0.04777484f, -0.02302206f, -0.13484070f, 0.08770980f, -0.04246819f, 0.02884227f, 0.00420829f, 0.20264351f, 
    -0.04052629f, 0.23272857f, -0.20039514f, -0.01100838f, -0.47342965f, -0.09524706f, 0.14335862f, -0.16864370f, 
    -0.36585909f, -0.19659042f, -0.21607383f, -0.27379072f, -0.12969725f, -0.12429488f, -0.06421971f, -0.00469195f, 
    0.01092682f, -0.08005819f, 0.00513956f, -0.02913524f, -0.03940400f, -0.10366671f, -0.17180285f, -0.07217978f, 
    -0.22590464f, 0.11688805f, -0.16308485f, 0.15268812f, 0.12072364f, 0.02202649f, 0.09728698f, 0.03974426f, 
    0.05861864f, 0.06575461f, -0.00256098f, 0.03784569f, 0.06134547f, 0.01971311f, -0.08965790f, 0.11398958f, 
    0.07395325f, 0.07727428f, 0.04755001f, -0.08000518f, 0.17320585f, -0.18025856f, -0.32601056f, -0.00383801f, 
    0.39956686f, 0.11756080f, 0.10407373f, -0.02514274f, -0.01869884f, -0.00525239f, -0.03104472f, 0.05697414f, 
    -0.01882777f, 0.15330024f, 0.11301228f, -0.02694684f, 0.03657949f, 0.10622742f, 0.02048738f, 0.09593123f, 
    -1.15788901f, -0.05153085f, -0.07149933f, 0.09332307f, 0.10593316f, 0.01540993f, -0.10849327f, -0.20728202f, 
    -0.21213828f, -0.26017970f, -0.08668967f, 0.11056714f, 0.08369310f, 0.21532586f, -0.12028573f, 0.00052496f, 
    0.14206170f, 0.10732639f, -0.10255962f, -0.07728426f, -0.21843408f, 0.13908377f, 0.40670758f, -0.06277360f, 
    0.34915820f, -0.00299286f, 0.05022260f, -0.01150665f, 0.01950305f, 0.08942183f, -0.05428144f, -0.10969605f, 
    -0.02699589f, -0.07569061f, 0.09893198f, -0.10705917f, -0.06035345f, -0.19384022f, 0.11142510f, 0.03402176f, 
    -0.49027330f, 0.03228176f, 0.64798558f, 0.16461717f, 0.27896890f, -0.00584970f, -0.10393183f, -0.27980623f, 
    -0.13507137f, -0.08935653f, 0.15136695f, 0.07401624f, -0.06607747f, -0.04370990f, 0.11533067f, -0.01879744f, 
    0.03412255f, 0.15578479f, -0.07575991f, -0.13196914f, 0.98823869f, 0.44058266f, -0.26133144f, -0.02346959f, 
    -0.32927397f, 0.05557567f, 0.06022616f, -0.00415856f, -0.24797365f, -0.18957718f, -0.22602193f, 0.02633607f, 
    0.06882840f, 0.14977992f, -0.12298579f, 0.02878376f, 0.00199170f, 0.01277049f, -0.00562549f, 0.03511354f, 
    -0.27257058f, 0.08741556f, -0.16225342f, 0.05866394f, 0.16360912f, 0.03069686f, -0.09669421f, 0.05329572f, 
    0.05066721f, 0.09492002f, -0.02160087f, 0.07043756f, 0.02244261f, -0.12898763f, -0.03631517f, 0.24921066f, 
    -0.08929493f, -0.03661373f, -0.00266333f, -0.12856795f, 0.12268850f, -0.08487687f, 0.14014119f, 0.03057704f, 
    0.14226460f, -0.02783172f, -0.08377120f, -0.09221312f, -0.06088328f, -0.08002084f, 0.16605321f, 0.14050607f, 
    -0.09219204f, -0.04358608f, 0.10164095f, 0.07011871f, -0.03381736f, 0.03348144f, -0.24090752f, -0.09737324f, 
    0.55011249f, -0.09746230f, -0.07599497f, 0.00573438f, 0.05305792f, -0.02400147f, 0.16334169f, -0.11763654f, 
    -0.29188615f, -0.07628142f, 0.01797160f, 0.08930175f, 0.15021729f, 0.03892422f, -0.33679390f, 0.08282292f, 
    -0.21555559f, -0.09236848f, 0.11751768f, -0.16184354f, 0.08074058f, -0.11917800f, -0.22734731f, -0.01913637f, 
    0.26001245f, 0.14110531f, 0.12904902f, -0.00115442f, 0.11750536f, 0.03945097f, -0.00978627f, -0.06916495f, 
    0.02006538f, -0.06522097f, -0.07861598f, -0.03633595f, -0.05808091f, 0.12525415f, -0.26330310f, 0.03354910f, 
    0.17588866f, 0.99278718f, -0.02617935f, 0.11281451f, 0.08049674f, 0.23501663f, -0.01593090f, 0.12670849f, 
    0.10296534f, 0.08073991f, -0.14142242f, -0.03755452f, -0.08364372f, 0.02742018f, 0.15089501f, -0.03335215f, 
    -0.13503592f, 0.05757582f, -0.03022555f, -0.07735746f, 0.00668409f, 0.20247358f, -0.18167211f, -0.17846142f, 
    0.30213216f, 0.14384390f, -0.10789445f, -0.06169755f, -0.13216543f, -0.07710931f, -0.11889230f, 0.05742319f, 
    -0.09192198f, 0.04853892f, 0.05027504f, 0.03128093f, 0.08809692f, 0.09573701f, 0.07992182f, 0.11542884f, 
    0.07589105f, 0.26055172f, -0.15478639f, -0.37943986f, 0.18363121f, 0.07357287f, 0.07817286f, -0.24014592f, 
    -0.08707155f, -0.08791958f, 0.04503683f, 0.00689255f, -0.08596180f, 0.01503152f, -0.05105907f, 0.00733237f, 
    0.04843394f, 0.02901663f, -0.14692111f, -0.04836358f, -0.27982736f, 0.14867125f, -0.17878474f, 0.28735673f, 
    0.25315669f, -0.08506893f, -0.09221532f, -0.01331653f, -0.23354039f, -0.03497210f, -0.01898619f, -0.01269170f, 
    0.01203867f, -0.14156510f, -0.17316718f, 0.00848910f, -0.02896775f, 0.05698555f, 0.03627068f, -0.17663026f, 
    -0.14569724f, 0.17695752f, -0.16364592f, 0.05623004f, 0.43456942f, 0.26604354f, -0.07472816f, 0.01234691f, 
    -0.18040715f, -0.07345542f, -0.05821014f, 0.12725633f, 0.08494922f, 0.07842441f, 0.05282355f, 0.08284695f, 
    -0.08618072f, 0.02964990f, -0.01898098f, 0.17632733f, -0.60426205f, 0.12273269f, 0.02579453f, -0.04242710f, 
    0.01374157f, -0.15994821f, 0.00775965f, -0.04020454f, -0.15584637f, -0.13472761f, -0.08223644f, 0.06450054f, 
    -0.28420433f, -0.06346469f, -0.08970362f, -0.00394825f, 0.00886224f, 0.15882261f, -0.12222869f, -0.03626293f, 
    0.17325468f, 0.12640069f, 0.07925379f, -0.11330231f, -0.07123528f, 0.08372711f, 0.05850562f, 0.08488085f, 
    0.04405108f, 0.10572756f, 0.10840190f, 0.18379223f, -0.02728474f, -0.05163300f, -0.01344241f, -0.04626117f, 
    0.03359228f, -0.20097792f, -0.16090004f, 0.04116091f, 0.27116171f, 0.08531816f, -0.18182081f, 0.27970341f, 
    0.26409420f, -0.01992087f, 0.06112672f, 0.06422886f, 0.01599118f, 0.06404745f, 0.05924511f, 0.03907147f, 
    -0.01256154f, -0.03707563f, 0.06677212f, -0.06551462f, 0.00172739f, 0.15951449f, -0.01669729f, -0.03435166f, 
    0.33345890f, -0.22962008f, -0.27171040f, -0.24193539f, -0.05289734f, 0.18318361f, -0.08462030f, -0.11155757f, 
    0.05826471f, -0.02356949f, 0.07134512f, -0.13356468f, -0.07760295f, -0.12914510f, 0.07702315f, -0.12428326f, 
    -0.32768294f, -0.01798302f, -0.21078682f, 0.04193655f, 0.07098815f, 0.00749798f, 0.01390722f, 0.00406764f, 
    -0.00422897f, 0.15774344f, 0.17029922f, 0.09084088f, -0.04833474f, 0.03489966f, 0.07600584f, 0.13107391f, 
    -0.03953991f, 0.00548440f, 0.15404762f, 0.11622012f, -0.03307612f, -0.06236080f, -0.00944061f, 0.00073287f, 
    0.11164829f, 0.27313218f, -0.40383762f, 0.21524237f, 0.07181288f, 0.01807614f, 0.00874994f, 0.08595360f, 
    0.15997669f, 0.11791844f, 0.03994968f, 0.02127367f, 0.03222396f, -0.01250761f, 0.03264274f, -0.09908835f, 
    0.08254548f, 0.05074782f, 0.02763544f, 0.11896483f, 0.03055487f, 0.02010943f, 0.26172888f, 0.18666330f, 
    0.12083098f, -0.21351312f, -0.03753786f, -0.10611814f, -0.06613592f, -0.00295176f, 0.08039675f, 0.05921041f, 
    -0.01215019f, 0.02796970f, 0.05790656f, 0.00687943f, 0.02048837f, -0.05276784f, 0.03195617f, -0.03768067f, 
    0.29266357f, -0.25855681f, 0.11601637f, 0.09496963f, 0.00105251f, -0.10043921f, -0.10362674f, -0.01355501f, 
    -0.09652267f, 0.19616111f, 0.09967207f, -0.05112961f, -0.04459691f, -0.13343865f, -0.14396241f, 0.11694533f, 
    0.01854341f, 0.08795995f, -0.00669860f, -0.02763802f, 0.14368944f, 0.08731145f, 0.27054751f, -0.00465687f, 
    0.14805639f, 0.00880206f, 0.32607767f, 0.10986182f, 0.21988726f, 0.07628770f, -0.00913724f, -0.07976603f, 
    0.00110245f, 0.05647023f, 0.03199667f, 0.07958859f, 0.10352083f, -0.06889661f, 0.09039996f, 0.19543333f, 
    -0.36615053f, -0.13242994f, 0.01118804f, 0.07587812f, 0.19172655f, -0.08410136f, 0.12273550f, 0.00305502f, 
    -0.23615244f, -0.03224141f, -0.01502772f, 0.06510636f, -0.01535381f, -0.06336430f, -0.12072576f, -0.03043856f, 
    0.11152873f, 0.02667863f, -0.05657449f, 0.15911415f, 0.15745284f, 0.04351383f, -0.01255005f, -0.16572268f, 
    -0.04529338f, -0.10421569f, -0.05115044f, 0.04126934f, 0.08064082f, 0.09036612f, -0.05501773f, -0.02960894f, 
    -0.07917918f, 0.00589471f, -0.09906843f, -0.00302562f, -0.04418774f, 0.05513113f, -0.03549119f, -0.05356648f, 
    0.10923932f, 0.24522652f, 0.33025953f, 0.05145327f, 0.20200105f, -0.04258293f, -0.02144557f, 0.08485952f, 
    0.20441474f, 0.09458786f, 0.02162837f, -0.03384374f, -0.00188093f, -0.04517192f, -0.09045664f, -0.01910416f, 
    -0.05041546f, -0.11110011f, -0.06033773f, -0.15614668f, 0.26226768f, -0.17189015f, 0.26535022f, 0.22571918f, 
    -0.08883657f, -0.22132328f, -0.15916070f, -0.15153328f, 0.03782989f, -0.02542654f, 0.13492525f, -0.02120571f, 
    -0.02877056f, 0.01741130f, 0.07249072f, 0.03780146f, 0.01919886f, -0.06703828f, -0.04152383f, -0.06186013f, 
    -0.61063766f, 0.47191700f, -0.47215044f, -0.39718893f, -0.03525395f, 0.16626740f, 0.04941503f, -0.01552495f, 
    0.06507193f, 0.05209592f, 0.09331762f, 0.04063190f, 0.02991560f, -0.01189085f, 0.04049164f, 0.09728813f, 
    0.05977881f, 0.25290266f, -0.23836282f, 0.13457201f, 0.05948252f, 0.00827508f, -0.03918134f, -0.03556404f, 
    -0.08476356f, 0.14149462f, -0.06495251f, 0.02445170f, -0.00570676f, -0.00837566f, -0.14378180f, 0.06657322f, 
    0.03825764f, -0.01858346f, -0.02687625f, 0.02560032f, -0.18721455f, 0.01567340f, -0.07670305f, -0.09690385f, 
    0.16944441f, -0.08576701f, 0.08543763f, -0.12732029f, 0.04744666f, -0.23632468f, 0.09052872f, 0.09614061f, 
    0.03729559f, -0.05306729f, -0.02015145f, -0.01951536f, 0.02315307f, 0.00071283f, -0.04165996f, 0.06807649f, 
    0.19878517f, 0.13141447f, 0.19424936f, 0.36849922f, -0.03098411f, -0.04887391f, -0.16737588f, -0.05559478f, 
    -0.08154653f, 0.08583082f, 0.13558571f, 0.04746643f, 0.00220198f, -0.01139001f, 0.08898760f, -0.06680461f, 
    -0.02745880f, -0.08555657f, 0.01932518f, -0.01277884f, -0.18816945f, 0.02071275f, -0.09146060f, -0.04182524f, 
    -0.04410423f, 0.07253823f, 0.11375791f, 0.00771643f, -0.03930775f, -0.02050907f, -0.01411002f, -0.02599922f, 
    -0.16219948f, 0.04464494f, -0.03988726f, 0.06575306f, -0.08664666f, 0.01989538f, -0.09143600f, 0.08124591f, 
    0.09570701f, -0.18933094f, -0.09166947f, 0.16336186f, -0.16952045f, -0.23284554f, 0.04280454f, 0.20906356f, 
    0.06220574f, -0.14313276f, 0.02662006f, -0.02000941f, 0.06535821f, -0.04737200f, -0.01487712f, 0.01832606f, 
    0.02418290f, 0.08994425f, -0.02550783f, 0.12862617f, 0.10853604f, -0.00958642f, 0.20014556f, 0.09358928f, 
    0.20510097f, -0.07137203f, 0.05385885f, -0.21975435f, -0.12012010f, 0.11063496f, -0.00991797f, 0.03798256f, 
    0.01992249f, -0.01961572f, 0.12557860f, -0.04045533f, 0.00286910f, -0.06734876f, -0.19214411f, -0.06986588f, 
    -0.06268838f, -0.23497805f, -0.17981388f, 0.03520559f, 0.01326769f, 0.08325704f, -0.04726698f, 0.03255036f, 
    0.05371181f, 0.20864710f, 0.16996536f, 0.14050092f, -0.06792650f, 0.05465382f, 0.11907364f, 0.00811020f, 
    0.06969884f, -0.11864680f, 0.04280807f, -0.01671503f, -0.10792892f, -0.13030083f, -0.20633280f, -0.15020524f, 
    -0.00665873f, -0.12593670f, -0.19914667f, -0.05771775f, 0.11794740f, -0.01634852f, 0.00195280f, 0.07400598f, 
    -0.02267213f, -0.06512593f, 0.04331329f, 0.04559352f, -0.02362308f, -0.12207478f, 0.01778834f, -0.06018751f, 
    -0.14177696f, 0.10141757f, -0.11777081f, -0.04893119f, 0.31529278f, -0.60494959f, -0.14685982f, -0.23273328f, 
    -0.11681024f, 0.10725328f, -0.07225648f, -0.21392533f, 0.04907196f, -0.03516264f, -0.03551419f, -0.06032474f, 
    -0.07217287f, -0.23739231f, 0.08414716f, -0.01637910f, -0.16776624f, -0.01602470f, -0.15738125f, 0.00979829f, 
    0.16763666f, -0.09303099f, 0.23572965f, 0.03106643f, 0.04503604f, 0.02734898f, 0.00259479f, -0.06022655f, 
    -0.16498949f, -0.08789789f, -0.08741573f, -0.14139840f, -0.05043501f, -0.03596382f, 0.00142160f, -0.06865716f, 
    -0.11726383f, -0.02995073f, 0.00258461f, -0.15702137f, -0.22549641f, -0.11862473f, 0.06754652f, 0.11055826f, 
    0.29225332f, -0.14265823f, 0.16756208f, -0.05648077f, 0.09992944f, 0.15538995f, -0.03177606f, 0.02095205f, 
    -0.05183418f, -0.11376516f, 0.03281208f, -0.07272435f, -0.06780322f, -0.10444146f, -0.00100100f, -0.17113008f, 
    0.45716554f, -0.07159183f, -0.17204426f, -0.28235561f, -0.27129424f, -0.04727315f, -0.11631196f, -0.23682034f, 
    0.07892276f, -0.32743734f, 0.02866890f, -0.10350023f, -0.02486725f, -0.18640117f, 0.08852516f, -0.00489635f, 
    -0.03439002f, -0.03993134f, -0.16933517f, 0.04610648f, 0.11597247f, 0.21450402f, 0.40467194f, 0.28475884f, 
    0.28073823f, -0.16333911f, -0.03780631f, -0.06515079f, 0.04119410f, 0.18281715f, 0.04874772f, 0.03682789f, 
    0.01162794f, 0.03056054f, 0.01764155f, -0.00239741f, -0.00665820f, -0.14351608f, 0.01169144f, -0.33884409f, 
    -0.75909340f, -0.33006129f, 0.03793363f, -0.48219642f, -0.11238660f, 0.05472003f, 0.16572562f, -0.11831598f, 
    0.10279165f, 0.02684444f, -0.16922018f, -0.12019432f, -0.04709509f, 0.19443011f, -0.04701988f, -0.10971151f, 
    0.03792730f, -0.02273958f, -0.03724722f, -0.03733940f, 0.07795051f, 0.00915512f, 0.07556307f, 0.35997969f, 
    0.28721222f, 0.00517414f, -0.05684616f, 0.10397630f, -0.38492998f, -0.10213839f, -0.13141593f, 0.00850242f, 
    0.09693929f, -0.00083659f, 0.03142815f, -0.07712401f, -0.13444342f, 0.09140038f, -0.13973996f, -0.03548506f, 
    -0.19254358f, -0.24672981f, -0.03867303f, 0.25859040f, -0.22620855f, -0.30001828f, -0.08048716f, -0.04446052f, 
    -0.25839990f, -0.11453239f, -0.07074421f, -0.12980530f, 0.07678241f, 0.00192770f, -0.03877850f, 0.02984445f, 
    -0.08033608f, -0.21162912f, 0.04816045f, -0.04230470f, 0.02012890f, -0.13328013f, 0.04448287f, -0.11406798f, 
    0.03321388f, 0.05472319f, 0.00786594f, 0.03684969f, -0.02396009f, -0.00800835f, -0.06959829f, -0.16309230f, 
    0.11137365f, -0.04151138f, -0.05224162f, 0.04289513f, -0.01928324f, -0.14793587f, -0.09650365f, -0.04465598f, 
    0.10791088f, -0.12387967f, 0.11989971f, 0.04863897f, 0.05607794f, -0.13001770f, -0.05281246f, -0.09833885f, 
    -0.03787876f, 0.04470623f, 0.05917436f, -0.03244816f, -0.00253319f, 0.00545720f, 0.02480644f, 0.09649224f, 
    0.09203686f, 0.07806152f, -0.01599943f, -0.05234784f, -0.10239419f, -0.34277025f, 0.19997333f, -0.51355702f, 
    -0.10187349f, -0.21306497f, -0.03243304f, 0.06271573f, -0.05713514f, -0.48987088f, 0.05133492f, -0.11749528f, 
    0.06681848f, -0.01354665f, -0.01420795f, 0.00591075f, 0.00429653f, -0.00888808f, -0.12554996f, -0.03661635f, 
    -0.54628974f, -0.10966486f, -0.15083349f, 0.03291870f, 0.13641095f, -0.04329870f, 0.02444124f, -0.08483326f, 
    -0.07464460f, -0.04963094f, 0.26362589f, -0.23313692f, -0.03955444f, -0.09138779f, 0.20020838f, -0.10324329f, 
    -0.09871027f, 0.31588149f, 0.00860783f, -0.03760132f, -0.24594320f, -0.11114722f, -0.05800712f, 0.24242365f, 
    0.06789951f, 0.13056788f, 0.07460088f, 0.02012505f, 0.00606134f, 0.02417001f, 0.03234069f, -0.04430798f, 
    -0.05050600f, 0.01515050f, -0.01617869f, -0.09068798f, -0.16321506f, 0.16879992f, -0.07798524f, -0.10435205f, 
    -0.37513727f, 0.24797106f, -0.35415539f, 0.36735004f, -0.05486125f, 0.05170655f, -0.03978982f, -0.11753956f, 
    0.05621516f, 0.04316999f, -0.08190241f, 0.08273064f, -0.02068062f, -0.02510489f, -0.01305980f, 0.14748412f, 
    -0.01805657f, 0.12675413f, 0.00170607f, -0.01984371f, 0.00849085f, -0.06920759f, -0.12591290f, 0.07089328f, 
    0.03950412f, 0.07004151f, 0.03355454f, 0.01541787f, -0.01159905f, 0.00703986f, 0.05755729f, -0.09174689f, 
    0.01794845f, 0.06972317f, 0.05117801f, 0.16840763f, 0.00723814f, 0.14492254f, -0.05000454f, -0.03336515f, 
    0.24647109f, 0.04694174f, -0.36198816f, -0.03881642f, 0.01809331f, 0.17146717f, -0.00904560f, -0.03903417f, 
    0.03728047f, 0.03541058f, 0.02805970f, 0.04501039f, 0.03893374f, 0.01433483f, -0.00970379f, 0.09278471f, 
    -0.18912230f, 0.13342129f, 0.04217007f, -0.02985165f, 0.06193062f, -0.18517096f, -0.09084453f, 0.03396056f, 
    -0.20315224f, 0.12797822f, 0.08551214f, 0.02285388f, 0.09911689f, -0.02313816f, 0.02619165f, -0.01472621f, 
    -0.05381627f, -0.02876072f, -0.06778975f, -0.04913858f, 0.08658505f, 0.00838982f, 0.10126946f, 0.03979967f, 
    -0.49719334f, 0.09303778f, -0.33175159f, -0.27789038f, -0.17190726f, -0.00519240f, 0.11392497f, 0.00940320f, 
    0.01608814f, -0.11879031f, 0.12063594f, -0.03141430f, -0.12590626f, 0.12431219f, -0.05313352f, -0.03088770f, 
    0.02802970f, 0.09622964f, -0.04718746f, -0.01057786f, 0.40420660f, -0.03430989f, 0.24093696f, 0.25117746f, 
    -0.22978684f, 0.09829835f, 0.01783479f, 0.03840641f, 0.06253721f, 0.21383823f, 0.14013031f, 0.10030473f, 
    0.03956880f, 0.00524089f, -0.01892406f, 0.00053348f, 0.00355239f, -0.11395040f, -0.15610787f, -0.16029312f, 
    -0.19142754f, 0.12610212f, -0.10595192f, -0.00092248f, -0.14659403f, -0.15406007f, -0.22765402f, -0.09869485f, 
    -0.10714787f, -0.13459432f, -0.00096294f, -0.02957666f, -0.04353267f, -0.00433084f, 0.04735899f, -0.20578073f, 
    -0.16213563f, -0.15483649f, -0.21908645f, -0.21008070f, 0.22804548f, -0.34052476f, -0.31377813f, -0.17462119f, 
    0.06744058f, 0.03730153f, -0.14201564f, -0.12434802f, -0.04090462f, 0.08161309f, -0.09746045f, 0.22930695f, 
    -0.22097367f, 0.14863412f, 0.16233808f, -0.09283035f, -0.08164019f, 0.02996455f, 0.02012805f, 0.19036692f, 
    0.21905707f, 0.18142147f, 0.24972138f, -0.04239340f, 0.02548080f, -0.01888345f, -0.05021523f, 0.12881616f, 
    -0.05969297f, -0.00720694f, 0.00402474f, -0.03377746f, 0.06149441f, -0.03143308f, 0.06310220f, 0.09970104f, 
    -0.01381230f, -0.12281537f, -0.09533387f, 0.30616462f, -0.79177064f, 0.30437160f, -0.13195480f, -0.25343871f, 
    -0.13241670f, 0.03990290f, 0.01322597f, 0.03623726f, -0.19170856f, 0.11196423f, 0.14255263f, -0.03525998f, 
    0.01803071f, -0.15508935f, -0.03105057f, -0.05671094f, -0.06188730f, 0.00838328f, 0.06010130f, 0.07326722f, 
    0.08045790f, -0.34968233f, -0.07070870f, 0.03977777f, 0.13209185f, 0.07484885f, -0.02668800f, -0.01909276f, 
    0.01015467f, -0.03395120f, 0.10140496f, -0.07683641f, 0.00331814f, 0.03788342f, 0.09723154f, -0.29199201f, 
    -0.20811848f, 0.10538921f, 0.18559691f, -0.26926324f, 0.02959470f, -0.21342909f, -0.10785743f, 0.12361399f, 
    -0.05633207f, -0.13859038f, 0.05127916f, -0.23514564f, -0.03845420f, 0.03052737f, 0.26445088f, -0.04729300f, 
    0.12360530f, -0.06300901f, 0.03931759f, 0.17392400f, 0.04321763f, -0.02846692f, 0.06994310f, 0.18493700f, 
    0.24025869f, 0.04338361f, 0.33887309f, -0.01001538f, -0.03079102f, -0.04170145f, 0.13352269f, -0.07679194f, 
    -0.05298787f, 0.01527559f, -0.01829639f, -0.01224583f, 0.04428870f, -0.03667672f, -0.00733372f, -0.26910913f, 
    -0.00103889f, -0.21860044f, -0.03861568f, -0.30614382f, -0.10927349f, -0.13973929f, -0.33923277f, 0.11047138f, 
    0.03431496f, 0.16427341f, -0.11682276f, -0.09806368f, -0.00440494f, 0.06961981f, -0.09388933f, 0.02926172f, 
    0.02331244f, 0.03628945f, 0.01173694f, 0.20480397f, -0.01754177f, 0.20013043f, 0.01984282f, 0.03522157f, 
    -0.08518499f, 0.13974154f, 0.25130281f, 0.00839374f, -0.03827660f, -0.10976178f, 0.03057614f, 0.18528761f, 
    0.05699972f, -0.22828487f, 0.01900732f, 0.00985677f, 0.02157551f, 0.01604814f, 0.04992840f, 0.00989480f, 
    0.00197310f, -0.26065126f, -0.01727687f, -0.31054625f, -0.47617000f, 0.09497954f, 0.04012158f, -0.19405797f, 
    -0.19247331f, 0.00070032f, 0.00590709f, 0.12484376f, -0.11731865f, 0.01722489f, 0.09065955f, -0.03862172f, 
    0.03142045f, 0.08177171f, 0.03871685f, 0.12026536f, -0.01582595f, -0.02040549f, -0.01971631f, 0.00594885f, 
    0.08731738f, -0.13217597f, -0.21181200f, -0.51979315f, 0.27517158f, 0.06653682f, 0.13394594f, -0.11384721f, 
    -0.11005645f, 0.00822084f, 0.17465945f, -0.09383912f, 0.03480711f, 0.05378621f, 0.26639688f, -0.07113589f, 
    0.02124102f, -0.12087156f, -0.00526363f, -0.03377477f, -0.08684959f, 0.13003823f, -0.01173932f, 0.06961853f, 
    0.14089864f, -0.02788419f, -0.31304020f, 0.25245434f, 0.00758023f, -0.17786540f, -0.22503048f, -0.00792126f, 
    -0.11944817f, -0.04184122f, -0.08097753f, 0.11817516f, 0.06920031f, 0.37903067f, 0.01528184f, -0.00540226f, 
    0.44245949f, -0.13613026f, -0.31919593f, 0.10555433f, 0.07042845f, -0.11919651f, 0.27058673f, 0.05372476f, 
    -0.05807297f, 0.09860789f, 0.04229741f, -0.08456103f, -0.05752195f, -0.04098062f, 0.01176420f, 0.19383240f, 
    -0.00782361f, -0.15521458f, -0.14447840f, 0.06955098f, -0.45968273f, 0.46865711f, 0.01779144f, 0.20999141f, 
    -0.03340431f, 0.02916113f, 0.00874809f, -0.14168890f, 0.08261597f, 0.12177753f, 0.11976809f, -0.07626007f, 
    -0.13149188f, 0.01736494f, -0.19307438f, -0.04911257f, 0.03605274f, 0.04875923f, 0.04436199f, 0.04538885f, 
    0.30523703f, -0.07888807f, 0.02458356f, -0.13032502f, -0.15050271f, 0.02425127f, -0.07508543f, -0.11789453f, 
    0.09598191f, 0.15527371f, -0.07188775f, 0.19237660f, -0.12888902f, -0.04762710f, -0.03107162f, 0.01545426f, 
    0.10538574f, 0.00604754f, -0.02585689f, 0.28907409f, -0.01670281f, -0.20206682f, 0.01826753f, 0.28683811f, 
    -0.31701618f, 0.18037918f, -0.00670374f, 0.05701301f, 0.02491916f, 0.16055907f, -0.05757736f, 0.07175446f, 
    -0.07324325f, 0.01764603f, 0.04354049f, -0.06171539f, 0.04363221f, 0.01749667f, -0.22664280f, 0.26311484f, 
    -0.37183535f, 0.44964576f, 0.04078643f, 0.15829381f, -0.01156887f, -0.07167406f, -0.03526762f, -0.06292517f, 
    0.13477929f, 0.18380573f, 0.00484570f, -0.33641481f, 0.05143956f, 0.13981906f, 0.14903039f, 0.01110033f, 
    -0.02891285f, 0.14797094f, 0.18424021f, 0.17450626f, 0.20068641f, -0.06948746f, 0.31184593f, -0.06601175f, 
    -0.26493004f, 0.11348566f, 0.17867596f, 0.05092116f, -0.27414238f, -0.12507778f, 0.04578263f, 0.00558595f, 
    0.01722665f, -0.00582466f, 0.00233400f, -0.00592807f, 0.04585924f, -0.05754027f, 0.17425810f, 0.19380765f, 
    -0.22459413f, 0.03704665f, -0.42934355f, -0.37330756f, 0.16364895f, -0.08131057f, -0.08306656f, -0.00157433f, 
    -0.03916077f, -0.04599590f, -0.07613054f, 0.12026905f, -0.02316505f, -0.13975787f, 0.05139517f, -0.12984717f, 
    -0.13638128f, 0.13517815f, -0.06328396f, 0.03431658f, -0.23538488f, 0.02813042f, 0.20898204f, 0.05315300f, 
    -0.29001737f, -0.00372013f, -0.05876966f, 0.10677078f, 0.00550605f, -0.04466948f, 0.03067652f, -0.01141716f, 
    0.02528689f, -0.06711328f, 0.08054472f, -0.04184153f, 0.03803745f, 0.13657850f, 0.02489820f, 0.05753113f, 
    0.12948368f, -0.14768249f, 0.35130882f, 0.19563392f, -0.43954077f, 0.04094569f, -0.15248176f, 0.31212822f, 
    -0.09005105f, 0.04766477f, 0.00297968f, 0.03211504f, -0.10314018f, -0.13485807f, 0.18094496f, -0.07249689f, 
    -0.02062794f, 0.08544134f, -0.13157445f, 0.05323739f, 0.10625402f, -0.02771250f, -0.19530822f, -0.04902992f, 
    0.03069238f, -0.00028860f, 0.05935873f, -0.02843113f, -0.14335264f, 0.10731027f, -0.07082054f, 0.02071715f, 
    -0.00674786f, -0.07276446f, -0.09544572f, 0.03937580f, 0.12311704f, -0.02973123f, -0.03221961f, 0.14748938f, 
    -0.54970413f, 0.01313526f, -0.29590371f, -0.35157132f, -0.19857483f, 0.07395255f, -0.01320985f, -0.04230475f, 
    -0.00979771f, 0.14265138f, 0.00921221f, -0.01565065f, -0.04408314f, 0.00064938f, -0.14886698f, -0.07889719f, 
    -0.02460777f, 0.05872407f, -0.06411515f, 0.03521697f, 0.36777136f, -0.49221760f, 0.25333798f, 0.13674186f, 
    -0.19372244f, 0.19279017f, -0.06756343f, -0.12418463f, 0.06311890f, 0.01479560f, 0.20264919f, -0.13881476f, 
    0.06252775f, 0.01937722f, 0.03572530f, -0.06080636f, -0.09326197f, -0.00466147f, 0.18420509f, -0.11990388f, 
    -0.15499757f, 0.06956144f, 0.11747380f, -0.16583906f, 0.03367876f, 0.03585758f, -0.00169352f, 0.07987029f, 
    -0.04447304f, -0.09527955f, 0.04148789f, -0.03807347f, 0.01911724f, -0.04889872f, -0.06065740f, 0.10512868f, 
    -0.13947205f, 0.07477481f, -0.19422550f, 0.00852349f, 0.02761905f, -0.06057951f, -0.04783759f, -0.08265550f, 
    0.12480921f, -0.09802125f, 0.09722546f, 0.03347300f, -0.06332066f, 0.01660672f, -0.01409659f, -0.03483389f, 
    -0.03589448f, -0.03510057f, -0.01650878f, -0.00326503f, -0.18388265f, -0.18861145f, 0.07938858f, 0.07732696f, 
    -0.01375859f, 0.12519777f, -0.06218380f, -0.15423654f, 0.19915968f, -0.05676973f, -0.00966679f, 0.08721916f, 
    0.00758240f, 0.12427983f, -0.02899847f, -0.00837460f, 0.06775264f, -0.12225816f, -0.03904294f, -0.05852871f, 
    0.28560227f, -0.14270875f, 0.06896648f, 0.03179142f, 0.15561320f, -0.06023045f, -0.14615229f, -0.11141901f, 
    -0.01404928f, -0.04063263f, -0.03738462f, 0.01887487f, -0.06225392f, 0.03579740f, -0.11534852f, -0.08830481f, 
    -0.21296644f, -0.15216912f, -0.18711650f, -0.10303406f, -0.24445428f, -0.07662231f, 0.00111714f, 0.03732983f, 
    0.03821804f, -0.49808624f, -0.51719052f, -0.30645183f, 0.03107912f, -0.00626202f, 0.10899064f, 0.19240957f, 
    0.01543221f, -0.08363359f, -0.03029458f, 0.01034979f, 0.01458332f, -0.07938907f, 0.02477085f, -0.05168280f, 
    -0.09080911f, 0.05908252f, -0.00002976f, 0.15707342f, -0.78064322f, -0.40672430f, -0.14493880f, -0.21055652f, 
    -0.65694064f, -0.29986677f, -0.02555174f, -0.09475000f, -0.13508311f, -0.25521168f, 0.04314479f, -0.01921227f, 
    -0.01106221f, -0.08871368f, 0.02919012f, 0.02783289f, -0.03550562f, 0.01554547f, 0.17969988f, -0.19355242f, 
    -0.44066310f, 0.12697363f, 0.52936494f, -0.04539515f, 0.10394716f, -0.03810956f, -0.05190920f, -0.07995833f, 
    -0.11823410f, 0.18535157f, -0.16801491f, 0.08391765f, 0.04233080f, 0.05900690f, 0.04759581f, 0.04468541f, 
    -0.00265388f, -0.05039224f, -0.02583133f, 0.04277324f, -0.78174359f, -0.91656262f, -0.89207667f, -0.24803971f, 
    0.23748247f, -0.17311604f, 0.06210963f, 0.02071249f, -0.13225265f, -0.40034702f, 0.03276858f, -0.05474725f, 
    -0.08952215f, 0.02374653f, 0.09941635f, -0.02500075f, -0.04424261f, 0.14630562f, 0.24231394f, 0.11987422f, 
    -0.05178542f, -0.65056193f, -1.08562541f, -0.26376608f, 0.67050493f, -0.07880648f, 0.05661482f, -0.04391688f, 
    -0.15281725f, -0.10118593f, 0.03511967f, -0.04907896f, -0.01405926f, 0.04791911f, -0.16163807f, -0.10059046f, 
    0.02877036f, 0.14284512f, 0.19409077f, -0.12694363f, -0.25331473f, 0.29895142f, 0.09728606f, -0.01081865f, 
    0.19428694f, -0.04566549f, 0.02548209f, -0.10616902f, 0.03971966f, 0.16313127f, -0.01060223f, 0.01334033f, 
    -0.04779939f, 0.15211879f, -0.11001326f, 0.02006310f, 0.05016127f, -0.05553659f, 0.05131197f, 0.07203852f, 
    -0.33829445f, -0.27600268f, -0.61937881f, -0.12148642f, -0.05039670f, -0.00379244f, 0.06577011f, -0.03887302f, 
    0.02172964f, -0.59010345f, 0.00283661f, -0.01278292f, -0.14474197f, 0.05929118f, -0.01543603f, 0.00425544f, 
    -0.00691976f, 0.17732044f, -0.04339951f, -0.03830904f, -0.87309211f, 0.47977662f, 0.56027186f, -0.13778679f, 
    0.22399405f, -0.06292617f, -0.20077336f, -0.01183347f, -0.19568416f, 0.44546023f, -0.14356245f, 0.05270947f, 
    -0.03048795f, 0.12875424f, 0.08513160f, -0.00823285f, 0.00528495f, -0.01013551f, -0.02428923f, 0.04808920f, 
    -0.32697532f, -0.04346134f, 0.02175998f, -0.36932391f, -0.09336954f, -0.02883071f, 0.01705360f, 0.08155207f, 
    -0.06311139f, -0.03239724f, -0.00571851f, -0.05552001f, 0.03034363f, -0.06877003f, -0.07287259f, 0.02586727f, 
    0.11819305f, -0.11817067f, -0.11979778f, 0.27985767f, -0.11355063f, -0.10420821f, 0.04199254f, -0.00717942f, 
    -0.08439976f, 0.05063543f, 0.06538779f, -0.02614193f, 0.01204296f, 0.01244060f, 0.17283510f, 0.13421956f, 
    0.09663030f, 0.16670747f, -0.27624702f, 0.02835203f, 0.06023695f, -0.09120299f, 0.07304803f, 0.00943121f, 
    -0.03559189f, -0.09134655f, -0.21271114f, 0.05190518f, -0.38284302f, 0.03971649f, 0.16844666f, 0.08182974f, 
    0.01073765f, 0.08858903f, -0.01269652f, -0.03084408f, 0.02265302f, 0.07505850f, 0.04980398f, 0.15620875f, 
    0.15857971f, 0.15557128f, 0.12864187f, 0.01228176f, 0.11822899f, -0.09101877f, -0.10386252f, -0.06288852f, 
    0.06735986f, -0.06876449f, 0.01540356f, 0.12233791f, 0.10280326f, 0.06488881f, -0.01541009f, -0.01072450f, 
    -0.01703844f, -0.22913662f, -0.10015598f, -0.17771122f, -0.06077343f, -0.11617579f, 0.03292994f, -0.02234938f, 
    -0.32130519f, -0.45800790f, -0.36360374f, 0.37837198f, -0.27434638f, 0.00848333f, 0.06693109f, -0.07034521f, 
    -0.15772103f, -0.34822282f, -0.00099409f, 0.01855238f, 0.01213392f, 0.07878502f, 0.14369136f, 0.06116892f, 
    0.06250086f, 0.30255303f, 0.08940207f, 0.03110958f, -0.76460534f, -0.76609188f, -0.69852263f, -0.28074983f, 
    -0.07238502f, -0.06130836f, -0.26344463f, -0.18572240f, -0.12066299f, 0.04391621f, -0.07951219f, 0.03257697f, 
    0.00442748f, -0.03141819f, -0.02069969f, -0.05217060f, -0.13133322f, -0.03183329f, 0.02653966f, -0.11358854f, 
    0.18451457f, 0.14726651f, 0.07817262f, -0.14192270f, -0.09020050f, 0.10580670f, -0.01787915f, 0.07774659f, 
    -0.02968701f, -0.09087650f, 0.09004047f, 0.05837538f, 0.05482651f, -0.14101572f, 0.08590131f, 0.01931805f, 
    0.25965086f, -0.15916586f, -0.24001524f, 0.12419178f, 0.05148523f, -0.07449164f, 0.00242107f, 0.02419694f, 
    0.12145801f, -0.02589648f, -0.07118817f, 0.06680194f, 0.11770443f, -0.13066147f, 0.10085116f, 0.00589823f, 
    -0.14823532f, -0.05963735f, 0.04033196f, -0.04685201f, -0.02282856f, 0.15024814f, -0.05803781f, -0.13973998f, 
    0.25369912f, -0.01100135f, -0.00419071f, -0.11630560f, 0.13665636f, -0.06624057f, -0.01652646f, 0.17346963f, 
    0.15288633f, -0.10678397f, 0.03926235f, -0.03934565f, -0.14197738f, -0.02103972f, 0.04177203f, 0.00847305f, 
    0.01388353f, 0.00727473f, -0.08657176f, 0.10528396f, -0.07901438f, 0.15893383f, -0.00937421f, -0.09240960f, 
    0.15713064f, -0.14540499f, 0.11203021f, 0.08247868f, -0.01438713f, 0.25493035f, -0.01428767f, 0.13209674f, 
    0.01893488f, 0.13310657f, 0.07923507f, -0.02134136f, 0.18021265f, -0.14383070f, -0.02732746f, -0.01838959f, 
    -0.06825867f, 0.45025530f, -0.10442556f, -0.08288933f, 0.06280510f, -0.10915200f, -0.14556022f, -0.38813528f, 
    0.25587898f, 0.02834828f, 0.01859968f, 0.18404868f, -0.05613726f, 0.00184291f, 0.07506173f, -0.02539723f, 
    -0.06418452f, 0.03206422f, 0.00493923f, -0.15825234f, 0.16164939f, -0.27484205f, -0.61288381f, -0.14353853f, 
    0.29180300f, -0.04606367f, 0.09045874f, 0.28367165f, 0.35295290f, 0.00269861f, -0.09545895f, -0.03507015f, 
    -0.07171430f, -0.04221448f, 0.04232180f, 0.01985263f, 0.04718470f, -0.04178946f, 0.25994077f, 0.05148913f, 
    -0.08083223f, 0.08297223f, -0.02570080f, 0.03118400f, 0.36899018f, -0.15834825f, 0.08397509f, 0.14079344f, 
    0.17299619f, 0.10377492f, 0.12409456f, 0.18640693f, -0.01640197f, 0.21778162f, 0.06353917f, -0.08421019f, 
    0.01362919f, -0.07062475f, -0.05049870f, -0.03590101f, -1.00067437f, -0.87525535f, -0.58309519f, -0.17262973f, 
    -0.01958286f, -0.11132810f, -0.04895466f, -0.22141349f, -0.16363053f, -0.49763554f, 0.01077529f, -0.02451403f, 
    -0.04225852f, -0.02976103f, -0.01311070f, -0.04016123f, -0.01793156f, 0.09627294f, 0.09544645f, -0.01067625f, 
    -0.32132605f, 0.30279997f, -0.03258327f, 0.02511507f, 0.35935766f, -0.04077968f, 0.01739348f, -0.03063974f, 
    0.05980822f, -0.00036335f, 0.18990527f, 0.21462579f, 0.19063820f, 0.11131116f, -0.08017750f, 0.06256480f, 
    0.02741046f, 0.10621277f, 0.12488643f, 0.03851949f, -0.52409577f, -0.35871136f, 0.79268301f, 0.35039979f, 
    -0.00581821f, -0.38603926f, -0.15519699f, 0.17238793f, -0.05275894f, 0.08877550f, -0.01855948f, 0.03892089f, 
    0.05188806f, -0.06414093f, 0.02171643f, -0.00014752f, 0.03963386f, 0.03184151f, 0.07213526f, -0.08316787f, 
    -0.27837294f, -0.05248919f, -0.73576510f, 0.03349913f, 0.29743412f, -0.12042827f, 0.06141092f, -0.01869788f, 
    -0.13715385f, 0.11413769f, -0.06752168f, -0.00554945f, 0.12196726f, 0.03311279f, 0.05848552f, 0.07344229f, 
    0.05887771f, -0.18809131f, 0.21926521f, -0.12911424f, 0.14077631f, 0.21699567f, -0.01727183f, -0.10122251f, 
    0.01206199f, 0.00632732f, -0.06415834f, -0.08195785f, 0.00453931f, 0.01070103f, 0.08223020f, -0.05851955f, 
    -0.08622181f, 0.00741873f, 0.11537132f, 0.04857330f, -0.11331572f, -0.11133189f, -0.05402171f, -0.06460375f, 
    -0.96628857f, 0.62052673f, 0.55781281f, -0.05986324f, 0.09626795f, -0.16167597f, -0.06856684f, -0.09986131f, 
    -0.30529511f, 0.16162717f, -0.17089237f, 0.05947568f, 0.10066392f, 0.05512328f, 0.04249828f, -0.00181438f, 
    -0.03482665f, -0.01021660f, -0.02738000f, -0.05841251f, -0.09147525f, 0.48752421f, -0.50090581f, -0.25143853f, 
    -0.02759819f, -0.14151864f, -0.10285140f, 0.24662584f, 0.15267219f, 0.11073180f, 0.09768208f, 0.03686265f, 
    0.13656972f, -0.08433656f, -0.10037043f, -0.00041177f, 0.01094921f, 0.05986773f, 0.18303218f, -0.02822719f, 
    -0.01738158f, 0.07594176f, 0.07903556f, 0.09196243f, -0.07914734f, 0.04871371f, 0.04190113f, 0.06883715f, 
    -0.01548556f, -0.01545004f, 0.08103821f, -0.11274938f, 0.02696044f, 0.02833664f, -0.16141845f, 0.00679017f, 
    0.07567841f, -0.17328064f, 0.01763586f, -0.00329825f, 0.01952736f, 0.14558585f, -0.02805505f, 0.05038504f, 
    -0.20572905f, -0.00391713f, 0.03400303f, -0.02333280f, -0.06603558f, -0.00227490f, 0.07206844f, 0.01523506f, 
    0.05519993f, -0.00139644f, -0.02129136f, -0.12698598f, -0.04360889f, -0.03976532f, 0.06713381f, 0.01186068f, 
    0.15027149f, 0.25900927f, -0.14254826f, 0.06741670f, -0.29363519f, -0.09076847f, 0.06082966f, 0.02378257f, 
    -0.11898839f, -0.06620342f, -0.05142119f, 0.08548491f, -0.06031678f, -0.02089502f, -0.03741171f, -0.12677252f, 
    -0.19184865f, 0.10240389f, -0.12707955f, -0.04343559f, 0.03881386f, 0.12939176f, 0.03377344f, 0.06026072f, 
    -0.09005275f, 0.01533414f, -0.03263478f, 0.00479199f, -0.03696368f, -0.04620392f, 0.04461085f, -0.00838024f, 
    -0.02249175f, -0.01696863f, -0.06434091f, -0.03143849f, -0.05686207f, 0.06037891f, 0.05287901f, 0.01495222f, 
    -0.20814526f, 0.21701424f, 0.19887495f, -0.09053806f, -0.24477148f, -0.05435788f, 0.11012512f, -0.10617406f, 
    -0.03828000f, -0.12207799f, 0.04832235f, 0.01582048f, 0.04199953f, 0.02625171f, 0.02480096f, 0.00663158f, 
    0.10470203f, -0.25402206f, -0.07710624f, -0.07169142f, 0.26827300f, -0.47489670f, -0.38860604f, -0.24329050f, 
    -0.09883644f, 0.01436704f, 0.04902815f, -0.01479615f, 0.21185206f, 0.02343844f, -0.01197037f, 0.07251881f, 
    -0.01993568f, -0.02391417f, -0.00186609f, -0.05383668f, 0.01826494f, 0.04266624f, -0.08923154f, -0.15201744f, 
    0.26225746f, 0.05801589f, -0.01155361f, -0.27679294f, -0.09790543f, -0.05528365f, 0.04690998f, -0.08970245f, 
    0.05670213f, -0.11794512f, 0.07190838f, -0.01905417f, 0.03566786f, 0.06637049f, 0.11809159f, 0.01576767f, 
    0.00117991f, -0.04430325f, 0.04910246f, -0.01237863f, -0.59929466f, -0.52937758f, 0.06635490f, 0.42295384f, 
    0.23105645f, 0.20642957f, 0.01210857f, 0.06606158f, -0.05181181f, 0.07842775f, 0.00861805f, -0.03308980f, 
    -0.12901212f, -0.02667339f, -0.07413603f, 0.08929731f, 0.14249112f, 0.00443688f, 0.07540467f, -0.05266374f, 
    0.09417549f, -0.68581647f, -0.70963615f, -0.70955390f, -0.41970488f, 0.11150987f, 0.06032722f, -0.13394171f, 
    0.22789919f, 0.02095473f, 0.00642901f, 0.05156476f, -0.09231938f, 0.15545686f, 0.06666606f, -0.09830758f, 
    0.03627849f, -0.00409870f, 0.05593170f, 0.04210913f, 0.08298833f, 0.14663741f, -0.24652921f, -0.02270768f, 
    -0.13107020f, 0.04710803f, 0.05205055f, -0.07843690f, -0.00457087f, 0.00072817f, -0.08429612f, -0.04587805f, 
    -0.09280263f, -0.08313845f, -0.13967654f, 0.04548153f, -0.00889962f, -0.06491960f, 0.05094190f, 0.09742028f, 
    -0.90198308f, -0.52308947f, 0.48909000f, 0.01728949f, 0.23828794f, -0.22622359f, 0.03802104f, 0.03833108f, 
    0.05480269f, -0.04764547f, 0.02193028f, -0.02270260f, -0.06838858f, -0.07701901f, -0.13104671f, 0.07242127f, 
    -0.06076501f, -0.25556463f, -0.14429836f, 0.07282942f, 1.03958118f, -0.69646782f, -0.02991025f, -0.17760383f, 
    -0.27254054f, -0.19261654f, 0.01098092f, -0.12775327f, 0.04240170f, -0.47778440f, 0.06601284f, -0.02781913f, 
    0.02046000f, -0.01190285f, -0.06153372f, -0.02007900f, -0.01375595f, -0.02073348f, 0.08763403f, 0.02569699f, 
    -0.08731212f, 0.09297056f, -0.22211753f, 0.15864579f, -0.19673654f, 0.00806039f, 0.08916591f, 0.06089412f, 
    -0.10219472f, -0.06174667f, 0.06000866f, 0.07408835f, 0.02889664f, 0.01907580f, 0.02228851f, 0.06740167f, 
    -0.00115556f, -0.09077531f, -0.18960923f, 0.17436624f, 0.08972650f, 0.11666418f, 0.10809359f, -0.05095036f, 
    -0.04598494f, -0.03491991f, 0.06827886f, 0.04412114f, 0.00805078f, -0.07184816f, -0.26160485f, 0.01759057f, 
    0.04271493f, -0.22067101f, -0.09007724f, 0.01006884f, -0.00945819f, 0.02597012f, -0.06625109f, -0.06656795f, 
    0.42424738f, -0.29353547f, 0.38129693f, 0.00467471f, 0.28063175f, 0.05876658f, -0.22683689f, -0.11902894f, 
    -0.14675434f, 0.07503509f, -0.03873665f, 0.00433087f, 0.06510859f, 0.00780468f, -0.05295900f, 0.10476046f, 
    0.02622904f, -0.12425858f, 0.07990047f, -0.00800841f, 0.03965721f, 0.11724622f, -0.07585593f, 0.02254312f, 
    -0.14037363f, -0.01190009f, -0.02669508f, 0.03121682f, -0.06583566f, -0.08603457f, 0.05045850f, 0.02515849f, 
    -0.03461264f, -0.06736923f, 0.01188251f, -0.07923072f, -0.08794123f, 0.10616385f, -0.01122276f, 0.06189298f, 
    -0.23922947f, -0.68088096f, 0.35664615f, -0.08315270f, 0.17026044f, -0.17252229f, -0.08039806f, -0.03706300f, 
    0.01777522f, 0.03365736f, -0.03260082f, -0.00905595f, -0.08304465f, -0.03795089f, -0.19948535f, 0.04535998f, 
    0.12795040f, 0.04842003f, 0.24567358f, -0.06787372f, 0.49634174f, -0.57471746f, -0.13654192f, -0.56291324f, 
    -0.33947518f, 0.01603218f, 0.09752459f, -0.20266551f, 0.29821774f, 0.09211275f, 0.04228731f, -0.02644946f, 
    -0.03427398f, -0.07941904f, 0.03125272f, -0.09798703f, -0.01346435f, -0.07809008f, 0.05542412f, -0.08062103f, 
    -0.01268206f, 0.05576004f, 0.20738918f, -0.06222428f, 0.11829065f, 0.00427590f, 0.04329528f, 0.09470771f, 
    -0.02703591f, -0.01164177f, 0.08044360f, -0.06672127f, 0.07948265f, -0.00067673f, -0.03280330f, 0.06860819f, 
    -0.17161982f, -0.21275280f, 0.08565088f, 0.04593813f, 0.03630415f, 0.01312361f, -0.04418920f, 0.02197343f, 
    -0.15304314f, 0.02095092f, 0.02640069f, 0.04128595f, 0.05991511f, -0.00222476f, 0.02179052f, -0.03622413f, 
    0.04876123f, 0.02026293f, -0.07612312f, 0.00265311f, -0.05135594f, 0.00729523f, -0.04236417f, 0.06292806f, 
    -0.10363877f, 0.14695452f, -0.07094901f, 0.08188649f, -0.09350451f, -0.00756182f, -0.03379286f, -0.02500200f, 
    -0.02265324f, -0.03327914f, 0.05087505f, 0.03710200f, 0.03193180f, -0.01413281f, -0.01712837f, -0.00106013f, 
    -0.28645018f, -0.11495865f, -0.00964934f, 0.05615147f, 0.46109483f, 0.37129813f, -0.40709990f, 0.01917601f, 
    -0.32881057f, -0.02488432f, 0.11854036f, 0.04403562f, -0.14801176f, -0.06513331f, -0.24069183f, -0.20527655f, 
    0.13935706f, 0.10362199f, -0.08071840f, -0.04932143f, -0.16888313f, -0.00735581f, -0.06895726f, -0.09884944f, 
    -0.11245522f, -0.36348552f, -0.27067447f, 0.01837207f, 0.07403261f, 0.12971546f, 0.00919503f, 0.05265309f, 
    0.02122810f, -0.04245869f, -0.13341342f, 0.20689033f, -0.02335455f, 0.09911442f, -0.01539308f, 0.00649293f, 
    -0.01503527f, 0.03975663f, -0.10906839f, -0.08052997f, -0.05684081f, -0.31111935f, -0.32526979f, 0.19664294f, 
    -0.15998863f, -0.04644809f, -0.00282015f, -0.14841600f, -0.07141640f, -0.01022267f, 0.11010903f, 0.05488031f, 
    -0.01473908f, -0.02288375f, -0.03711188f, -0.00864363f, 0.00476458f, -0.03283018f, -0.08442310f, 0.07450292f, 
    0.93148786f, 0.19533379f, -0.39485288f, 0.02143395f, -0.27415878f, 0.09438329f, -0.01071576f, -0.03806188f, 
    -0.22183299f, 0.05120115f, -0.06400558f, -0.12325093f, 0.12042821f, 0.03523557f, -0.04324957f, -0.05035174f, 
    -0.16451553f, 0.00514139f, -0.14156576f, 0.03271135f, -0.27785563f, -0.54986584f, 0.16092451f, 0.58785266f, 
    0.03542444f, -0.07228716f, 0.17002724f, -0.01339292f, 0.08094611f, 0.15170836f, 0.03517368f, 0.00706321f, 
    -0.03787352f, -0.04741614f, 0.01508015f, -0.00098605f, 0.00731934f, -0.03513496f, 0.17943889f, -0.10148916f, 
    -0.32437897f, -0.14252271f, -0.25531411f, 0.16549189f, -0.03487755f, 0.06293286f, 0.03397398f, 0.26655483f, 
    -0.04684074f, 0.02002918f, -0.24147809f, 0.12926207f, -0.01209638f, 0.02054029f, -0.03830427f, -0.08445267f, 
    0.00352672f, -0.03335430f, 0.10414901f, 0.15599963f, 0.38764516f, -0.70873934f, -0.50187093f, -0.19351691f, 
    -0.15540570f, 0.25695917f, -0.11023724f, -0.11292877f, 0.10125310f, 0.06976341f, 0.05883024f, 0.02753874f, 
    0.14521225f, -0.03335433f, 0.04124983f, -0.03331895f, 0.04749360f, -0.01283192f, -0.00391394f, -0.06710532f, 
    0.03975911f, -0.44257188f, -0.13272254f, 0.63629073f, -0.07391981f, -0.03743662f, 0.15001157f, -0.11115084f, 
    0.01322848f, 0.06634275f, 0.06694563f, 0.10692303f, -0.07177602f, -0.05241863f, 0.02752900f, -0.12656824f, 
    0.01344038f, -0.02491704f, 0.05161348f, 0.02568023f, -0.07989593f, 0.00990766f, -0.00244926f, -0.05296478f, 
    0.02904654f, 0.05412537f, -0.00670835f, -0.00503125f, 0.00800170f, -0.02050905f, -0.19673733f, 0.03296812f, 
    -0.01618007f, 0.10097942f, 0.03345825f, -0.00915957f, -0.02946816f, -0.03482199f, -0.05884799f, -0.03426443f, 
    0.66963744f, -0.57643288f, -0.46421093f, -0.17916913f, -0.29899591f, -0.00271187f, -0.16263300f, 0.03903921f, 
    0.13975243f, -0.14794254f, 0.08805773f, 0.06981926f, 0.13153930f, 0.06108763f, 0.10056411f, 0.03184238f, 
    0.05614866f, 0.04614552f, 0.05284102f, 0.04907523f, -0.19051236f, -0.45284674f, -0.28607106f, -0.07279273f, 
    0.30441651f, 0.00638694f, -0.01884067f, 0.15498540f, -0.28100708f, -0.04421015f, 0.00439319f, 0.08189942f, 
    0.04941249f, 0.01232619f, -0.03789617f, 0.01822576f, -0.05318856f, 0.01490884f, -0.11358971f, -0.11733980f, 
    -0.41294095f, -0.13589813f, 0.18319413f, -0.01896872f, -0.14622125f, -0.07983384f, -0.04566780f, -0.11371376f, 
    -0.11737345f, 0.04851869f, -0.09351653f, -0.04138549f, 0.04427500f, 0.14708742f, 0.07690805f, 0.11696655f, 
    -0.00801430f, -0.00914531f, -0.03885840f, 0.12241416f, -0.29711661f, 0.10819927f, 0.16302414f, 0.08634571f, 
    -0.27217728f, 0.02238259f, -0.11828108f, -0.03610606f, -0.04624403f, -0.12699643f, -0.12667981f, -0.04541762f, 
    -0.03268760f, -0.08295292f, -0.00151853f, 0.07179616f, 0.00429536f, -0.10677967f, -0.13093497f, 0.02790505f, 
    0.31557345f, 0.17879423f, 0.19355172f, 0.02654933f, -0.12787844f, -0.03084530f, 0.10005426f, 0.01908888f, 
    0.03975145f, -0.11050183f, 0.00142984f, -0.04738935f, 0.00568031f, 0.01968631f, 0.14125425f, 0.10474098f, 
    0.09198748f, -0.20036373f, 0.11187097f, -0.09364576f, -0.20310172f, 0.02085700f, 0.10560384f, -0.03373900f, 
    -0.24631366f, -0.10977765f, -0.02741732f, -0.07535387f, -0.06701634f, -0.10371289f, -0.07908008f, -0.02742509f, 
    -0.07744904f, 0.09012709f, 0.04073410f, 0.09662426f, 0.21443625f, 0.03415356f, 0.07692774f, 0.06961730f, 
    -0.33631709f, 0.29044750f, 0.23183540f, 0.21629542f, 0.00516214f, 0.06044690f, -0.13814561f, -0.06707958f, 
    -0.02859759f, -0.29722065f, -0.13491234f, -0.06437353f, -0.02583135f, -0.06880279f, -0.03043333f, -0.19957453f, 
    -0.08097635f, 0.00268148f, -0.26641026f, -0.17209738f, -0.16590226f, -0.69999135f, -0.84696907f, -0.55596310f, 
    0.05455808f, -0.18203059f, -0.08695054f, -0.04131254f, 0.00977274f, 0.00915818f, -0.01455902f, -0.03365940f, 
    -0.12054505f, 0.02310269f, 0.00613427f, 0.04572625f, -0.00550841f, 0.06545849f, 0.09209767f, 0.14050025f, 
    -0.02955429f, -0.25331768f, -0.63199997f, -0.13075596f, -0.04070379f, -0.12800135f, -0.02249861f, 0.17910613f, 
    0.12779260f, 0.09690385f, 0.18067501f, 0.00412829f, 0.11091509f, -0.01361731f, -0.03779830f, -0.02904276f, 
    0.08204605f, 0.01311317f, 0.02305402f, 0.02710118f, 0.68338639f, -0.37853140f, -0.24273467f, -0.13229117f, 
    -0.24600446f, 0.09777663f, -0.36342096f, -0.14873470f, -0.19286714f, -0.36775938f, 0.06428053f, 0.01458966f, 
    0.04431399f, 0.03125766f, 0.02602427f, 0.08876085f, 0.02057255f, 0.09746929f, -0.29894245f, -0.24936256f, 
    0.09832364f, -0.16541891f, -0.90881807f, -0.48441616f, 0.17986414f, -0.12182803f, 0.06719208f, 0.07334414f, 
    0.19287474f, 0.02520301f, -0.01806295f, -0.06617599f, -0.07489039f, 0.00303067f, 0.20911074f, 0.16483989f, 
    0.00516687f, -0.08294522f, -0.11893170f, -0.16259272f, 0.01519405f, -0.22163798f, -0.06498245f, -0.14164901f, 
    -0.10425676f, -0.03456458f, 0.08683611f, 0.05777677f, 0.02129105f, 0.02375642f, 0.11269952f, -0.05947104f, 
    -0.00616797f, 0.01523898f, 0.01253976f, 0.07341959f, 0.02981068f, 0.00123696f, 0.06206192f, -0.02360508f, 
    -0.30006257f, -0.31441391f, -0.18641999f, -0.03098850f, -0.11002334f, 0.08003860f, 0.01486687f, 0.00640044f, 
    0.01297379f, -0.09011800f, 0.03293771f, 0.13930744f, 0.08866602f, 0.04595314f, 0.05886791f, 0.05099554f, 
    0.10970663f, 0.17513216f, 0.16901349f, -0.03566058f, 0.13460082f, -0.86574882f, -1.05688095f, -0.15985689f, 
    0.09117378f, 0.00407094f, -0.03290434f, 0.18478617f, 0.12035075f, 0.25380239f, 0.13133059f, -0.01136364f, 
    -0.02784625f, -0.01525035f, -0.10112539f, 0.00543472f, 0.05650248f, -0.07301924f, -0.14765352f, 0.02696253f, 
    -0.52025229f, 0.07449083f, 0.30753055f, 0.17750797f, -0.00351685f, -0.08181774f, -0.04371299f, -0.14447989f, 
    -0.08136393f, 0.02413309f, -0.13469324f, -0.15118042f, -0.01680176f, -0.08303751f, -0.04649633f, -0.20483240f, 
    -0.22120744f, -0.26403201f, -0.20113172f, -0.38185793f, 0.01035769f, 0.02999880f, -0.05424043f, -0.12972476f, 
    -0.24759521f, -0.05341447f, -0.02622688f, -0.00847884f, 0.06815358f, -0.03822184f, 0.09664913f, 0.01415643f, 
    -0.02274829f, 0.03252416f, 0.09748010f, -0.02513754f, 0.17826100f, 0.05337581f, 0.12033962f, 0.07894228f, 
    0.55976713f, 0.07713135f, 0.23001331f, 0.01104397f, -0.04906495f, 0.07463851f, -0.17047383f, -0.10870404f, 
    0.15041314f, 0.07706273f, 0.03793714f, 0.03372009f, -0.00276077f, 0.02040325f, 0.03363706f, -0.20376329f, 
    -0.06138263f, -0.27900195f, -0.35293874f, -0.71394992f, -0.03960187f, 0.19417354f, 0.06507565f, 0.03348345f, 
    -0.13514583f, -0.07555778f, 0.03545287f, 0.04418489f, 0.00509424f, -0.05928695f, -0.05203049f, -0.04018350f, 
    -0.00023447f, 0.06121393f, 0.02033985f, 0.03344890f, 0.13959464f, 0.01507770f, 0.10000011f, 0.05601641f, 
    0.26846391f, -0.13398831f, -0.10887379f, -0.03583695f, -0.11406969f, 0.03374646f, -0.14518291f, -0.02624772f, 
    -0.09056697f, -0.02986356f, 0.01847798f, 0.03141528f, 0.00909282f, 0.07642207f, 0.08974010f, 0.04304899f, 
    0.01440621f, -0.07083245f, -0.33919224f, -0.35524747f, -0.23996131f, -0.24008249f, -0.82420421f, -0.64177072f, 
    -0.10244133f, -0.14926675f, -0.36670902f, 0.14420494f, -0.19152403f, -0.49537912f, -0.00450463f, -0.07293914f, 
    -0.10230111f, 0.07308367f, 0.10269622f, 0.04440303f, -0.03454389f, 0.03842641f, -0.03192130f, 0.00657144f, 
    -0.48150617f, -0.05662556f, 0.14070095f, 0.03195865f, 0.15266757f, 0.06762388f, -0.04479536f, 0.05045478f, 
    -0.04835073f, -0.00829952f, -0.03785356f, -0.17415023f, 0.09576386f, 0.00425990f, -0.00225073f, -0.16641749f, 
    0.06080470f, 0.07007622f, -0.10043411f, 0.06528296f, 0.10544935f, 0.02385481f, -0.05132966f, 0.00783999f, 
    -0.12229411f, -0.09057792f, -0.03784792f, -0.07870656f, -0.01236071f, -0.27112889f, -0.08637928f, 0.04020645f, 
    0.09631664f, -0.03841550f, -0.00591072f, -0.00632896f, 0.20379743f, 0.16200541f, 0.27799919f, 0.17655425f, 
    -0.39951470f, 0.05439223f, 0.19075930f, 0.14397225f, -0.08770107f, 0.06618910f, 0.03483463f, -0.01026007f, 
    -0.00559258f, -0.03605844f, -0.02902995f, -0.01445462f, -0.03466906f, 0.06106890f, 0.03043268f, 0.04365327f, 
    0.01105207f, 0.02236817f, 0.02914340f, 0.05607025f, 0.46471512f, 0.01710295f, -0.13593742f, -0.15053597f, 
    -0.15813406f, 0.01435860f, 0.15771046f, 0.03476861f, -0.00134240f, -0.07242493f, 0.05852026f, 0.07142156f, 
    0.04457433f, 0.12425824f, -0.03297643f, 0.08597811f, 0.11361055f, -0.11741663f, 0.05634209f, 0.11105241f, 
    0.35122025f, -0.21099895f, -0.26867095f, -0.02249644f, 0.09988823f, 0.04330012f, -0.08899927f, -0.07519763f, 
    -0.06533298f, 0.10676736f, -0.13779880f, 0.06415339f, -0.10463413f, 0.05461992f, -0.08223622f, 0.02536256f, 
    0.03952282f, 0.07279523f, 0.15438300f, 0.03377860f, 0.60502577f, 0.30593571f, 0.02892580f, 0.08831679f, 
    -0.31914797f, 0.13725801f, -0.24027398f, -0.02451755f, -0.02864098f, -0.23959750f, 0.03053126f, 0.01527517f, 
    0.06539628f, 0.01625313f, 0.00426495f, -0.08915830f, 0.08496913f, 0.11562429f, 0.15014139f, -0.01011399f, 
    0.58441943f, 0.03573222f, -0.37536070f, -0.12791254f, 0.05298932f, 0.02249604f, 0.24687211f, 0.12885734f, 
    0.13704628f, -0.00380215f, -0.01392124f, 0.22153802f, -0.07969518f, -0.17740348f, -0.06358457f, 0.10564570f, 
    0.11073297f, -0.08388062f, 0.08729251f, 0.07014798f, 0.21907976f, -0.44122103f, -0.46056888f, -0.21659543f, 
    -0.06995153f, -0.02989934f, -0.15127708f, 0.05386988f, 0.07008591f, 0.06455326f, -0.11228031f, -0.05448922f, 
    0.04588180f, 0.01737374f, 0.03534546f, 0.02661322f, 0.05956065f, 0.13038214f, 0.01042526f, 0.22037378f, 
    -0.15000568f, -0.53255653f, 0.21838525f, 0.09609313f, 0.27241200f, -0.12410272f, 0.00865636f, -0.04625130f, 
    -0.13408501f, -0.08736498f, 0.09104457f, -0.04205464f, 0.00861913f, 0.17845555f, 0.03638601f, -0.02491436f, 
    -0.05240305f, 0.00561227f, -0.03190603f, -0.09749631f, -0.01206463f, -0.07020599f, -0.70722711f, -0.18436235f, 
    -0.08733699f, 0.12262961f, 0.17937429f, 0.17885928f, 0.08836819f, 0.04849572f, 0.01312946f, -0.08923274f, 
    -0.14532809f, 0.06806650f, 0.04872919f, 0.00820063f, -0.02245699f, 0.02516427f, 0.04206594f, -0.02198764f, 
    0.65396380f, 0.25863156f, -0.20494777f, -0.19263601f, 0.10861647f, 0.15544078f, 0.04590961f, 0.01193394f, 
    0.14455657f, -0.11773340f, 0.17937176f, 0.06092288f, 0.20331843f, 0.10360841f, 0.02718944f, 0.02421549f, 
    0.07315907f, -0.06496213f, 0.20883206f, -0.08001109f, -0.28279001f, -0.14929686f, -0.01796689f, 0.04195772f, 
    0.07241029f, -0.01862919f, 0.03161108f, -0.02031678f, 0.05157739f, 0.00998854f, 0.04174807f, 0.05209663f, 
    0.05892286f, 0.11595191f, -0.08274372f, -0.04918050f, 0.03361413f, 0.17205797f, 0.11077568f, 0.06665932f, 
    -0.09893136f, -0.62807024f, -0.69116998f, -0.19002940f, -0.03150046f, -0.18474182f, 0.12392216f, 0.17744306f, 
    0.19213897f, 0.10854261f, 0.04701707f, -0.14010082f, -0.05907071f, -0.11490823f, -0.08418173f, -0.05409299f, 
    0.00701837f, -0.01331438f, -0.00569746f, -0.05697018f, 0.91279459f, 0.02087356f, -0.47317970f, 0.17825387f, 
    0.15472123f, 0.22805855f, 0.15107194f, 0.04475909f, 0.08010388f, 0.26486403f, 0.07492656f, 0.07685509f, 
    0.10807638f, 0.18213640f, 0.01801356f, -0.08065867f, 0.07456187f, -0.09856952f, -0.05420422f, 0.04341339f, 
    -0.10095540f, -0.20790938f, 0.06165504f, -0.31516832f, 0.20760220f, 0.11442556f, -0.16067965f, 0.03415342f, 
    0.01731547f, -0.10389865f, -0.06361320f, -0.06545317f, 0.01449667f, -0.02550875f, -0.19052041f, 0.09118135f, 
    0.03212274f, -0.09577919f, -0.01210382f, 0.04708953f, -0.14344373f, 0.05823563f, -0.38887233f, 0.00805368f, 
    -0.07880890f, 0.11478313f, 0.03857122f, 0.30078861f, 0.01264712f, 0.10882870f, -0.00716120f, -0.01304965f, 
    -0.08287080f, 0.04438146f, -0.07351735f, 0.00786829f, 0.11935587f, -0.01838668f, 0.00660325f, 0.12046254f, 
    -0.44143230f, 0.08801495f, -0.21006222f, 0.31779280f, -0.00047031f, 0.04820216f, -0.11291339f, 0.13716413f, 
    -0.14907031f, -0.03341020f, 0.10903732f, -0.04178797f, 0.04804803f, 0.04929256f, -0.00483015f, 0.07418231f, 
    0.02908320f, -0.04224842f, 0.08627784f, 0.11768050f, -0.17716844f, -0.03392713f, -0.09123375f, -0.21737686f, 
    0.04161303f, 0.09442059f, 0.13611205f, 0.24541469f, 0.07217748f, -0.06762899f, 0.18130839f, 0.02567474f, 
    -0.05310646f, -0.03451990f, -0.01082593f, 0.17824520f, -0.04282140f, -0.03609297f, 0.03491040f, 0.06671844f, 
    -0.00656202f, 0.06154476f, -0.97620845f, 0.20930418f, 0.21840513f, -0.12546088f, 0.18677624f, 0.27227885f, 
    0.05594319f, 0.11546207f, -0.01247191f, -0.02229108f, -0.08359513f, 0.00686635f, -0.04325158f, -0.04220305f, 
    0.18284580f, -0.09383547f, -0.05704269f, 0.00841457f, -0.53912753f, -0.25707984f, 0.49840239f, 0.30184501f, 
    -0.67010075f, 0.18790998f, -0.38482416f, 0.04532945f, 0.19607852f, 0.26366624f, 0.00666124f, 0.04601460f, 
    0.05571532f, 0.01363725f, -0.02062073f, 0.03026231f, 0.02957093f, 0.03925027f, -0.07198001f, -0.06791674f, 
    -0.00772098f, 0.15450005f, 0.34098971f, 0.58722061f, -0.11700408f, -0.12323793f, 0.07480887f, -0.41896397f, 
    -0.11267198f, -0.23228893f, 0.05263901f, -0.15008679f, 0.09287697f, 0.15045342f, 0.14304999f, 0.09367609f, 
    -0.00625453f, -0.09055511f, 0.02946840f, -0.00036694f, 0.24843961f, -0.40150747f, -0.47599310f, 0.04055518f, 
    -0.09835573f, -0.01065067f, -0.33805183f, 0.04411376f, 0.03276194f, 0.09033014f, -0.01306635f, 0.09381937f, 
    0.06599768f, -0.02698968f, 0.05295075f, 0.00425824f, 0.07819641f, 0.10942777f, 0.14790276f, 0.15471831f, 
    0.10405416f, 0.00462288f, 0.00843938f, 0.57398921f, -0.73479170f, 0.07754796f, -0.08351147f, -0.18718210f, 
    0.11009750f, 0.03278911f, 0.02806121f, -0.05843273f, 0.10432339f, -0.01093768f, 0.01832417f, 0.06091081f, 
    0.16493358f, 0.10709005f, 0.11496066f, 0.13835719f, 0.04149886f, 0.19115441f, 0.03986424f, 0.41319150f, 
    -0.06509758f, -0.10429768f, 0.04074722f, -0.19522448f, -0.03932296f, -0.36753830f, 0.02111891f, 0.06005068f, 
    0.07220697f, 0.07174485f, -0.07097240f, 0.10138881f, 0.10383011f, -0.08774549f, -0.08065315f, 0.07853261f, 
    0.00159311f, 0.15927112f, 0.00252884f, -0.09540538f, -0.12679169f, -0.18209006f, 0.08836226f, 0.02523627f, 
    -0.05615842f, 0.22677831f, -0.02966873f, -0.01645064f, 0.01621955f, -0.11525427f, -0.04359050f, -0.04020991f, 
    -0.00666084f, 0.13091829f, -0.09297615f, -0.13137324f, 0.21402945f, 0.09452613f, -0.05041819f, -0.09440545f, 
    -0.40501657f, -0.12500310f, -0.05757444f, -0.39690068f, -0.07199650f, -0.08301578f, 0.15858077f, -0.02330431f, 
    0.10582022f, 0.09163260f, 0.04699355f, 0.11042129f, -0.04730930f, -0.02660304f, -0.04427170f, -0.00344040f, 
    -0.20412937f, -0.21754947f, -0.37388870f, -0.23176585f, 0.31465375f, 0.09918941f, -0.02300030f, 0.16980433f, 
    0.04777624f, 0.03806693f, 0.02131411f, -0.02875607f, -0.00544555f, -0.06209163f, -0.01316108f, 0.09780643f, 
    0.16078269f, -0.01705585f, 0.01126589f, 0.06842695f, -0.26432633f, -0.13481626f, -0.05880170f, 0.01470699f, 
    0.34099135f, -0.16990270f, 0.18339556f, -0.14973044f, -0.07973216f, -0.09190349f, 0.00919559f, 0.02374924f, 
    -0.03650647f, -0.10545281f, -0.01086218f, 0.15407383f, 0.00152198f, -0.03986150f, -0.14684054f, -0.02448085f, 
    -0.21196587f, -0.47172216f, -0.13326564f, 0.08732478f, 0.11830790f, -0.06356870f, 0.15977581f, -0.08975624f, 
    0.12474833f, 0.00523624f, -0.02674206f, -0.09732506f, 0.07534990f, 0.09582407f, -0.12570500f, 0.06569693f, 
    0.11713725f, -0.02558746f, 0.10888810f, 0.20736553f, -0.26490736f, 0.19954681f, -0.19897141f, -0.00040423f, 
    0.12372185f, 0.01087041f, 0.07961901f, 0.19379193f, 0.00755664f, -0.05979772f, 0.11831132f, 0.03392798f, 
    -0.06863724f, -0.01270789f, 0.00290894f, 0.05033231f, 0.13634259f, -0.15024291f, 0.06903876f, 0.01803070f, 
    0.14169787f, -0.45570213f, -0.10932685f, -0.06262642f, 0.00744369f, -0.15993725f, 0.09067590f, -0.06545593f, 
    0.13466525f, 0.11189866f, 0.03620600f, -0.01508623f, 0.08225955f, -0.03728824f, -0.03412599f, -0.15283655f, 
    0.24868242f, 0.03098585f, 0.12146125f, 0.20382027f, -0.06677914f, -0.23074788f, 0.11813197f, 0.24060388f, 
    -0.90397745f, -0.19402125f, 0.08084202f, -0.04103402f, 0.00180823f, 0.14190251f, 0.13653289f, 0.00631055f, 
    0.05109767f, 0.04448199f, 0.00174642f, -0.13184375f, 0.03791249f, 0.10946485f, 0.02600038f, -0.11818654f, 
    0.15875912f, -0.48448277f, -0.18746527f, -0.43936291f, 0.10821907f, -0.18870136f, -0.02087284f, 0.09868979f, 
    0.16039094f, 0.08980531f, -0.09824923f, -0.03812905f, -0.00081234f, -0.20487408f, -0.01152183f, 0.24399287f, 
    0.06451105f, 0.19823042f, -0.05406227f, 0.05565611f, -0.13568839f, 0.41277644f, -0.05333434f, -0.21150686f, 
    0.00311684f, 0.09187782f, 0.12144563f, 0.18897417f, -0.05021102f, 0.04003400f, 0.08767607f, -0.03909096f, 
    -0.08763867f, -0.01779950f, -0.00010827f, 0.03088069f, -0.07197410f, -0.29873070f, -0.06694642f, -0.16319703f, 
    -0.17230320f, 0.23900659f, -0.36884466f, -0.01890675f, -0.20449157f, 0.15781295f, -0.11696544f, 0.09861579f, 
    -0.01104103f, 0.04163241f, 0.02901378f, -0.03142729f, -0.05845209f, 0.01072887f, 0.01989931f, -0.10465747f, 
    0.04654284f, -0.04324267f, 0.02461144f, -0.05649115f, -0.58933550f, 0.19441493f, -0.19032426f, 0.46765041f, 
    0.01238935f, -0.00520724f, -0.19987904f, 0.00386136f, -0.20149583f, -0.03137815f, 0.20247199f, -0.07604516f, 
    0.01301481f, -0.05849677f, -0.10322228f, -0.10417496f, -0.05691352f, -0.03275580f, 0.05320401f, 0.08291467f, 
    -0.13991138f, 0.10871215f, 0.53756642f, -0.09495214f, -0.31149092f, 0.09593166f, -0.22187483f, -0.03979846f, 
    -0.10115355f, -0.09507687f, -0.00798990f, -0.11073615f, 0.02682560f, -0.02899115f, 0.01527135f, -0.05869136f, 
    -0.02396105f, -0.06988456f, 0.01121405f, -0.02561773f, 0.13972327f, 0.28404522f, -0.80209392f, 0.12084926f, 
    -0.12917590f, 0.19421177f, 0.04629704f, 0.06159757f, -0.00949876f, -0.15170881f, 0.10201135f, -0.11802214f, 
    -0.02560720f, -0.03968467f, -0.05870127f, -0.01301099f, 0.04030543f, -0.06349702f, -0.02969170f, -0.01252682f, 
    -0.89474714f, 0.43988076f, -0.25639233f, 0.25226313f, -0.39911753f, 0.00141193f, -0.06284793f, -0.18588482f, 
    -0.35478994f, 0.01774908f, 0.12378360f, -0.17029977f, -0.16163227f, -0.07496052f, 0.04488790f, -0.20262009f, 
    -0.06885062f, 0.01540415f, -0.14733167f, -0.14008301f, -0.01614674f, -0.22718067f, 0.16425222f, 0.06208935f, 
    -0.27319732f, -0.13033102f, -0.28634784f, 0.22207594f, 0.10108180f, 0.21972191f, -0.01079738f, 0.00283768f, 
    -0.04244080f, -0.01639308f, -0.08671467f, 0.11711893f, -0.01314058f, 0.00956043f, 0.06800375f, -0.20217325f, 
    -0.01914965f, -0.20346849f, 0.07841464f, 0.05806516f, -0.16014574f, 0.04790855f, -0.16508263f, -0.06938650f, 
    0.08979210f, -0.18963787f, -0.10453004f, 0.09186243f, -0.00824891f, 0.02608335f, -0.04189634f, 0.08251533f, 
    0.06139630f, 0.09771043f, 0.02079845f, 0.19337857f, -0.78661406f, 0.05273695f, -0.04254832f, 0.12952520f, 
    -0.58343977f, 0.18496411f, 0.00469669f, -0.13551199f, 0.02333158f, -0.00445843f, 0.06639082f, -0.07063160f, 
    0.01701598f, 0.05495394f, -0.05618942f, 0.12286425f, 0.03850852f, -0.04213938f, 0.00770472f, 0.04221393f, 
    -0.35173449f, -0.16502166f, -0.52777129f, 0.17566878f, -0.35202786f, -0.06266699f, -0.10421832f, -0.07479370f, 
    -0.00505382f, -0.03342431f, 0.04036493f, 0.00681615f, 0.04244245f, 0.06797092f, -0.04833156f, -0.04932403f, 
    0.08138568f, -0.13627094f, 0.13564304f, 0.10902950f, -0.01328228f, 0.22508992f, 0.46779341f, -0.16048783f, 
    -0.10226534f, 0.06443014f, -0.12973239f, -0.05217701f, 0.00046681f, 0.01135590f, 0.01526116f, 0.04041727f, 
    0.08103948f, 0.03508977f, 0.01857121f, 0.04421052f, 0.01425304f, -0.02514330f, -0.05431285f, -0.00066576f, 
    0.09871650f, -0.04879150f, 0.40273511f, 0.46378547f, -0.60162026f, 0.12260662f, -0.11060575f, -0.45737001f, 
    -0.06103633f, -0.16668721f, 0.08792002f, -0.00101101f, 0.02397824f, 0.13088951f, 0.05297784f, 0.03862224f, 
    -0.02170233f, -0.04079424f, -0.03423383f, -0.00051226f, -0.44653714f, -0.43081978f, 0.27137882f, 0.23294914f, 
    -0.36256903f, 0.10327329f, -0.33798626f, -0.03978963f, -0.08348399f, -0.11028945f, -0.08058262f, -0.01187114f, 
    -0.02317115f, -0.06503150f, 0.12059893f, 0.16826828f, 0.00414062f, -0.13504781f, 0.00723029f, 0.03787708f, 
    -0.39152816f, -0.17068349f, -0.25568691f, 0.05715002f, -0.28952649f, -0.01047580f, -0.15324730f, -0.24551228f, 
    0.15211020f, 0.04915347f, -0.13092552f, 0.06080822f, 0.09482924f, 0.00941180f, 0.06046093f, -0.05974213f, 
    0.13221511f, -0.06786654f, 0.15921471f, -0.01729264f, 0.00324449f, -0.34187895f, -0.01359871f, 0.12860827f, 
    -0.15024585f, -0.20160779f, -0.10892165f, 0.01416460f, -0.12044328f, -0.14661808f, -0.07986141f, 0.07065134f, 
    -0.07278243f, 0.01306997f, 0.06554738f, 0.03807688f, -0.16018620f, -0.09615095f, 0.04182345f, -0.04777765f, 
    0.19184262f, -0.27442229f, 0.23275496f, -0.17838487f, -0.02199729f, -0.11137444f, 0.06638430f, 0.06275819f, 
    0.08978344f, -0.01301498f, -0.06836653f, 0.02224948f, -0.06775060f, 0.05212196f, -0.02319804f, 0.02216540f, 
    0.02506806f, 0.07930106f, 0.01666346f, -0.14934441f, -0.23173110f, -0.54506040f, -0.17995720f, -0.32605070f, 
    -0.31354138f, -0.09591912f, -0.14597249f, -0.13032965f, 0.11992193f, -0.07465780f, -0.23991282f, 0.05696817f, 
    0.06557811f, -0.15693833f, -0.04767059f, 0.06812745f, 0.05727758f, 0.04751441f, 0.16286966f, 0.00400499f, 
    0.02770668f, -0.20467125f, -0.40836748f, 0.04960897f, 0.09641780f, -0.04459451f, -0.13270929f, 0.17744733f, 
    -0.33107722f, -0.13412137f, -0.11332746f, 0.03642404f, -0.13668510f, 0.06623330f, 0.07515351f, 0.16714218f, 
    -0.29060233f, -0.11603308f, -0.29040155f, -0.06389519f, -0.46406350f, 0.01909429f, -0.37691575f, 0.07861505f, 
    0.10578123f, -0.12968242f, -0.04517620f, -0.27346265f, 0.05869706f, -0.05381237f, 0.00394985f, -0.02500891f, 
    -0.10319572f, 0.01314763f, 0.04133569f, 0.01199224f, -0.01592521f, -0.10491292f, 0.01800303f, 0.00348062f, 
    0.23636988f, 0.14510180f, -0.11400211f, 0.01939514f, 0.01769171f, 0.06353751f, -0.04179339f, -0.03175722f, 
    -0.16022232f, 0.06061482f, -0.22816578f, 0.06261016f, -0.11081103f, -0.14205012f, -0.08589515f, -0.02269326f, 
    -0.09326597f, -0.07446308f, 0.01211439f, 0.06158881f, -0.36569566f, 0.04121051f, -0.27186683f, 0.00992205f, 
    0.04509819f, -0.07736272f, 0.01916399f, -0.17554282f, 0.27173427f, -0.09221615f, 0.00843234f, 0.12823449f, 
    0.08331031f, 0.05418088f, 0.01546864f, 0.12843931f, -0.13251252f, -0.26363653f, -0.17115375f, -0.33349338f, 
    -0.27266586f, -0.03361943f, -0.44415638f, 0.06933306f, -0.08792228f, -0.09748571f, 0.01211827f, 0.00140433f, 
    -0.02546240f, 0.02373831f, -0.04456113f, 0.11420754f, -0.05068612f, -0.13960363f, -0.11476619f, 0.05038945f, 
    -0.04295918f, 0.10755206f, -0.16355124f, -0.17726904f, -0.18339092f, -0.07143382f, 0.09454475f, 0.04424094f, 
    -0.06127664f, 0.10390878f, -0.18745436f, -0.10255857f, 0.18950489f, -0.02699605f, -0.10686895f, 0.10100123f, 
    -0.04855218f, 0.15107964f, 0.00196211f, -0.09175852f, -0.04368055f, -0.04515507f, 0.04952849f, -0.06104830f, 
    -0.15316707f, 0.02951158f, -0.06651674f, -0.05531311f, 0.03507686f, 0.19327801f, 0.01645146f, 0.08208238f, 
    -0.13299170f, -0.09087007f, 0.05107395f, -0.12829480f, 0.10584812f, 0.11523123f, -0.07302658f, 0.02717127f, 
    0.02871640f, -0.03052751f, 0.09156130f, -0.05062297f, 0.43908030f, 0.18665129f, 0.18703884f, 0.33368844f, 
    0.17851116f, 0.04442940f, 0.19192523f, 0.01546222f, 0.05518543f, 0.10626189f, -0.22911489f, 0.19267873f, 
    0.03925414f, -0.32365116f, -0.27279824f, 0.02690487f, -0.02161692f, -0.09187600f, 0.18913165f, 0.01728706f, 
    -0.04002419f, -0.03461933f, 0.22316150f, 0.01713864f, 0.10886283f, -0.04144840f, 0.01143199f, -0.09188143f, 
    -0.10327368f, -0.24832229f, -0.11668421f, 0.12183136f, 0.00475333f, 0.07483459f, 0.04112976f, -0.04066362f, 
    0.02386198f, -0.10258740f, -0.34482878f, -0.26508853f, 0.15529801f, -0.27753204f, 0.12057244f, 0.11400265f, 
    -0.06628376f, 0.00834850f, -0.00730930f, 0.16062936f, -0.12372345f, 0.03727685f, -0.01940292f, 0.03550601f, 
    0.00941966f, 0.06560933f, 0.13549283f, -0.14007716f, 0.06613167f, 0.04294414f, 0.01882210f, 0.07407564f, 
    -0.28439873f, 0.14630370f, -0.46161038f, 0.32069770f, 0.15429202f, 0.04656534f, 0.02014531f, 0.16806777f, 
    0.06205692f, -0.08999111f, 0.02525478f, -0.00586223f, -0.03980416f, -0.02871390f, 0.04371976f, -0.12335290f, 
    -0.19519489f, -0.29705334f, -0.29176402f, 0.07325082f, -0.08787972f, -0.31722653f, 0.05485526f, -0.07581993f, 
    -0.19194263f, -0.08263062f, 0.01961023f, 0.11002517f, -0.07075925f, -0.10591865f, -0.07902792f, -0.04148480f, 
    -0.02567897f, 0.06706048f, 0.02131632f, -0.03080386f, 0.13035880f, 0.10801408f, 0.07064183f, 0.00723408f, 
    -0.26685867f, 0.13756436f, 0.17704624f, 0.10478299f, 0.02610779f, 0.15173835f, -0.12458136f, 0.00225194f, 
    -0.13423069f, -0.04183145f, 0.04699945f, 0.03576355f, -0.03553411f, -0.03582051f, 0.06316852f, -0.02976099f, 
    -0.18481076f, 0.15434486f, -0.34093434f, -0.17603844f, -0.20377716f, 0.12065007f, -0.77294350f, -0.05675918f, 
    0.07666712f, -0.07447201f, -0.13563196f, 0.01961014f, 0.00037923f, 0.08601125f, -0.04604840f, 0.16853514f, 
    0.07151274f, -0.16354506f, -0.08995354f, 0.06935401f, -0.02308964f, -0.02326757f, 0.04266449f, -0.10334782f, 
    0.01340169f, -0.03066724f, -0.47447971f, 0.44696134f, -0.01063044f, -0.08855948f, -0.18479906f, -0.16402900f, 
    0.03497742f, 0.12784861f, -0.16827595f, 0.13181461f, -0.26876470f, 0.05201785f, 0.14279480f, 0.02277850f, 
    -0.12529609f, -0.05498841f, 0.00841378f, 0.16623583f, -0.26079762f, -0.38324907f, 0.14039138f, 0.01005218f, 
    -0.13215315f, -0.10373487f, 0.07703348f, 0.22482808f, -0.08946338f, -0.09633747f, 0.03350148f, -0.08379214f, 
    0.03697416f, 0.02148890f, -0.04702383f, 0.03843560f, 0.15791026f, 0.26945803f, 0.06142833f, 0.18871979f, 
    -0.18631637f, -0.08564427f, -0.15763742f, 0.11153779f, -0.25123116f, 0.00226539f, 0.02688257f, 0.10451905f, 
    0.00801373f, -0.04854986f, -0.12256379f, -0.03206398f, 0.10763136f, -0.02104516f, -0.08314686f, -0.04359975f, 
    0.01393580f, 0.12708232f, 0.16163248f, -0.02295882f, 0.36092991f, -0.26275575f, 0.32625395f, -0.08968323f, 
    0.03879593f, -0.14048664f, 0.06171687f, 0.12057006f, 0.13691199f, 0.11355802f, -0.09506987f, -0.00779281f, 
    -0.11638761f, -0.04054234f, 0.00785629f, 0.00664617f, -0.06443167f, 0.06964359f, 0.04758619f, -0.08327489f, 
    -0.45337170f, 0.00471131f, -0.01112955f, 0.28642073f, 0.05763105f, -0.01009337f, 0.09159062f, -0.17908368f, 
    0.32154390f, 0.05667016f, 0.04987555f, -0.20222688f, 0.06370001f, 0.11720887f, 0.10952723f, 0.11705334f, 
    0.10173143f, -0.18800893f, 0.31132710f, 0.26459786f, -0.56613803f, -0.46963876f, 0.20714489f, -0.08233853f, 
    0.00229357f, -0.06184398f, -0.17843381f, 0.12136388f, 0.29395121f, 0.04821748f, -0.16649525f, 0.02438109f, 
    -0.03048893f, 0.06379798f, -0.01345044f, 0.12313834f, 0.02845892f, 0.08017313f, 0.24303691f, 0.11852442f, 
    0.23071001f, -0.28560227f, 0.30933669f, 0.15811679f, 0.17977364f, -0.06617056f, 0.04104282f, 0.32209653f, 
    0.03455449f, 0.10830654f, -0.19582257f, 0.01736665f, -0.04505102f, 0.04431793f, 0.05484845f, -0.02754670f, 
    0.07770730f, 0.23741832f, 0.07742043f, 0.15267061f, -0.44171005f, 0.04877537f, -0.44344017f, -0.02386688f, 
    0.08534016f, -0.01730921f, 0.00117579f, -0.05872591f, -0.05844507f, 0.02172113f, -0.07776436f, 0.12365276f, 
    0.00275428f, 0.10647965f, 0.01560843f, 0.13361542f, 0.00836916f, -0.13353492f, 0.06261442f, 0.11075591f, 
    -0.27056563f, 0.26710609f, -0.02780527f, -0.07855091f, -0.04697349f, 0.12042505f, -0.09693982f, -0.00648890f, 
    0.01316739f, -0.01756795f, 0.02796361f, 0.02881832f, -0.05183746f, -0.10788563f, 0.02712577f, -0.05018478f, 
    -0.02322287f, -0.09707963f, 0.00265493f, -0.22741474f, 0.01295855f, 0.13666634f, 0.19795495f, 0.06500398f, 
    0.06203433f, -0.02966587f, -0.04425442f, 0.00943359f, 0.13672063f, -0.06487366f, -0.08433959f, 0.04527852f, 
    0.09167139f, 0.01053047f, -0.06692114f, -0.00521358f, 0.04312256f, 0.02620012f, 0.05757844f, 0.08461417f, 
    -0.12710528f, 0.05465477f, 0.22724904f, -0.05821622f, 0.13575099f, -0.03123139f, -0.06704413f, 0.24006951f, 
    0.08582757f, 0.03851387f, -0.09618536f, 0.00308615f, -0.11099010f, 0.08578386f, -0.00108265f, 0.09318160f, 
    -0.22865549f, 0.06272402f, -0.04871173f, -0.02318249f, 0.05543313f, -0.08423269f, -0.11331634f, 0.27174392f, 
    -0.05527620f, -0.04459292f, 0.01263865f, 0.07737051f, -0.00416933f, 0.00410774f, -0.00383159f, -0.18679234f, 
    0.07400479f, 0.04749263f, 0.09211332f, -0.05697042f, 0.01216762f, 0.13328600f, 0.17346579f, 0.16379574f, 
    -0.09163893f, 0.12923740f, -0.06801517f, 0.02837031f, -0.01552628f, 0.00962059f, 0.00529839f, -0.20543927f, 
    0.08558326f, 0.03162630f, -0.05761779f, 0.08147060f, -0.04770485f, -0.18614438f, -0.11460990f, -0.00330824f, 
    0.00279313f, -0.05852856f, 0.02138512f, 0.00804909f, -0.73633671f, 0.26964414f, 0.23139159f, 0.09130694f, 
    0.08776024f, 0.09026030f, 0.04617542f, -0.22400934f, 0.24537373f, -0.03485914f, -0.13553365f, -0.04940021f, 
    0.10819347f, -0.04051620f, 0.15797834f, 0.04293929f, 0.04773420f, -0.04940570f, -0.03294713f, -0.01867765f, 
    -0.17037499f, -0.10057164f, -0.45904469f, 0.27286288f, -0.02325763f, -0.09661135f, 0.11884836f, 0.06428929f, 
    0.18816739f, 0.03052971f, -0.25024003f, -0.13696465f, -0.02887964f, -0.07155692f, 0.00519976f, 0.07587304f, 
    0.07017709f, 0.08699890f, -0.20139645f, -0.15283887f, 0.42113128f, -0.10720478f, 0.42414743f, -0.36295992f, 
    -0.19080992f, 0.02115474f, 0.02473992f, -0.07658597f, 0.14397457f, -0.04871637f, -0.09599128f, 0.06712528f, 
    -0.01096248f, -0.04909030f, -0.07686041f, -0.07673257f, 0.21292238f, -0.01338296f, 0.11792179f, -0.01631706f, 
    0.09125595f, -0.23538853f, 0.18085942f, -0.40303046f, 0.17795694f, 0.04360775f, 0.21592537f, -0.09691652f, 
    0.15607786f, -0.02576337f, -0.06773945f, 0.10195409f, 0.09585807f, 0.00742295f, -0.09700502f, -0.02810610f, 
    0.07152983f, 0.03212579f, -0.16668676f, 0.01341692f, 0.28623796f, 0.22166361f, 0.18515468f, 0.04051190f, 
    -0.03944881f, -0.07144075f, 0.15819713f, 0.01077079f, 0.12387086f, 0.06659116f, -0.27283105f, -0.00113963f, 
    0.05496830f, -0.01928661f, -0.04779058f, 0.02306308f, 0.01349787f, 0.05971361f, -0.17188106f, -0.02199738f, 
    0.66033071f, -0.04729243f, 0.57698840f, 0.13673037f, -0.05710137f, -0.22187209f, -0.13401993f, -0.35020256f, 
    0.14742176f, 0.00369428f, -0.11626737f, -0.08551355f, 0.00532183f, -0.11772598f, -0.04787536f, 0.00633524f, 
    -0.02247282f, -0.23418814f, 0.13895243f, 0.18682621f, 0.21916850f, -0.13360487f, -0.12496740f, -0.20471719f, 
    -0.24622601f, -0.05418444f, -0.21127070f, -0.06054500f, -0.05403355f, -0.07102646f, 0.02067578f, 0.10422631f, 
    0.01533890f, -0.16068393f, -0.09435870f, 0.01439469f, 0.05249519f, -0.00787551f, 0.08788076f, -0.01541849f, 
    -0.63969207f, -0.00228728f, -0.35479686f, 0.31201604f, -0.30088395f, 0.09882437f, 0.01680584f, 0.09375030f, 
    -0.20171137f, 0.21111919f, -0.13596271f, -0.11278903f, 0.09076497f, 0.06799997f, -0.08066337f, -0.04265078f, 
    -0.02518146f, 0.00139119f, 0.02520795f, -0.03025225f, 0.07960604f, -0.18943435f, -0.06432135f, -0.16835999f, 
    0.10812259f, -0.23884143f, -0.52509969f, -0.07433661f, -0.00112345f, -0.30695054f, -0.02555724f, -0.00241598f, 
    0.07393911f, -0.03257416f, -0.06509068f, 0.06913959f, -0.12055923f, 0.02499072f, 0.26319194f, -0.08426203f, 
    -0.03381606f, -0.26631913f, -0.10091040f, -0.38777238f, -0.35131583f, -0.04241893f, 0.11653189f, 0.03307921f, 
    -0.19637235f, -0.04852225f, -0.10593364f, 0.01777874f, 0.21865603f, 0.21247536f, 0.06209562f, 0.10116182f, 
    0.15360017f, 0.03681078f, 0.14914842f, 0.16530256f, -0.40125105f, 0.03664153f, -0.28331265f, 0.15106580f, 
    -0.23297977f, 0.15453950f, 0.12417257f, 0.00746328f, -0.06354642f, 0.00760572f, -0.09978169f, -0.11329762f, 
    0.03710755f, 0.03003545f, 0.03964252f, 0.08986668f, -0.14894244f, -0.06140083f, -0.10182860f, -0.06262379f, 
    -0.08226786f, -0.13245788f, 0.13829605f, 0.21364811f, 0.07376163f, -0.08371206f, -0.13202682f, -0.02815872f, 
    0.02457236f, -0.02329948f, 0.09598709f, 0.10227216f, -0.07441857f, 0.10329293f, 0.07053448f, 0.04323544f, 
    -0.07004518f, 0.16096693f, 0.10512076f, -0.03211662f, -0.68162340f, -0.26523283f, 0.19297451f, 0.24591264f, 
    -0.33913341f, -0.06525376f, -0.24474704f, -0.08808044f, -0.10941187f, 0.17845951f, -0.11318205f, -0.20516987f, 
    -0.16437364f, -0.15168616f, -0.01431623f, -0.04119439f, -0.10067529f, -0.15683705f, 0.12012409f, 0.00242914f, 
    0.37222144f, -0.28541687f, -0.24967699f, 0.23109639f, 0.16755317f, -0.10592138f, 0.08765854f, -0.14358525f, 
    0.04619259f, -0.29589665f, -0.08419701f, 0.03022220f, 0.01305526f, -0.17794575f, -0.07087287f, 0.18224086f, 
    -0.09637775f, 0.06996390f, -0.00414848f, 0.04253328f, -0.32178521f, 0.04003409f, -0.15139177f, -0.09734771f, 
    0.01391489f, 0.03393677f, 0.09372846f, 0.21117370f, -0.02217945f, -0.03752569f, -0.14302222f, 0.10718078f, 
    -0.03263386f, 0.04782652f, 0.11470395f, -0.04718634f, -0.15995254f, -0.07982312f, -0.06322725f, -0.12084447f, 
    -0.21812439f, -0.29281592f, -0.14849442f, 0.30411649f, -0.16338308f, 0.21238016f, -0.11093523f, 0.18017216f, 
    -0.15290225f, -0.07869206f, 0.08352061f, -0.00255648f, -0.04910538f, 0.08309083f, 0.11726909f, 0.06123820f, 
    0.04279860f, 0.26383424f, 0.09437230f, 0.03926183f, 0.32036880f, 0.01538935f, 0.32634351f, -0.10433236f, 
    0.02167228f, 0.07138084f, 0.21081798f, -0.04470264f, 0.11118665f, 0.01506266f, -0.16646041f, 0.00664284f, 
    0.00470233f, 0.00612451f, -0.02362971f, -0.02217718f, 0.02849630f, -0.06480863f, -0.12623714f, -0.01841339f, 
    -0.25177169f, -0.02213261f, -0.50202179f, 0.22335911f, 0.13936050f, -0.05079382f, -0.01310576f, 0.05488355f, 
    -0.19333515f, 0.05423559f, 0.00122338f, 0.05001200f, -0.03017230f, -0.10035874f, 0.04620079f, 0.16178687f, 
    -0.06689277f, 0.18138225f, 0.01415987f, 0.15529256f, -0.01166582f, -0.18843724f, -0.05096577f, -0.37393650f, 
    -0.13460161f, -0.08541436f, -0.12774129f, 0.03930630f, -0.13616006f, 0.13628721f, -0.02413475f, 0.09772115f, 
    0.12894487f, -0.04116898f, -0.02754345f, 0.03427408f, 0.01873694f, -0.10834001f, 0.01593038f, 0.11707006f, 
    -0.20819888f, -0.13272093f, -0.03265892f, 0.47476557f, -0.43240973f, -0.12060578f, 0.03099205f, 0.04994599f, 
    0.05214005f, 0.03539078f, -0.20015535f, -0.03444760f, 0.10035356f, 0.22102036f, -0.03767533f, -0.07369115f, 
    -0.00131028f, 0.15561588f, -0.07226185f, -0.23903984f, 0.28159237f, 0.05834629f, 0.10856429f, 0.14481732f, 
    0.14548270f, -0.07580692f, 0.09144550f, -0.11961517f, -0.01884484f, 0.02975658f, -0.09545591f, 0.14188960f, 
    0.01136656f, 0.03090746f, 0.08125146f, 0.00683549f, -0.06495982f, -0.19544110f, -0.09538317f, 0.11458471f, 
    0.41795743f, -0.06236453f, 0.43150124f, 0.05326397f, -0.11087483f, -0.01484584f, 0.16822439f, -0.15637639f, 
    0.19260164f, 0.03682030f, -0.12304313f, 0.10267706f, 0.00509192f, 0.02560911f, 0.03507971f, -0.08509956f, 
    0.26003370f, 0.09102380f, -0.01086077f, -0.02532085f, -0.09370203f, -0.32597199f, 0.30755231f, -0.56650108f, 
    0.28952730f, 0.11783191f, 0.23195226f, -0.03715465f, 0.08251388f, 0.15525161f, 0.09014573f, 0.04892132f, 
    0.07190529f, 0.10337061f, 0.05266898f, -0.13863871f, 0.03542535f, -0.06538192f, -0.14419250f, 0.01069885f, 
    -0.04972979f, -0.30680147f, 0.23538579f, 0.08716058f, -0.01267595f, -0.07417189f, -0.06349646f, 0.01663464f, 
    -0.01279555f, -0.16590069f, 0.00205347f, -0.05798351f, 0.01937301f, -0.10450155f, 0.02984569f, -0.07151897f, 
    0.00922938f, 0.04392772f, -0.01911844f, -0.22795029f, 0.48518422f, 0.37695381f, 0.60103714f, -0.18630634f, 
    0.09982340f, 0.07304361f, 0.05191937f, 0.08898346f, 0.05728764f, -0.20877096f, -0.23826814f, -0.08177353f, 
    0.17425548f, 0.10473383f, 0.05708973f, 0.00689698f, -0.16845162f, 0.02061921f, -0.08877840f, -0.03025948f, 
    0.21389489f, -0.17639637f, 0.48385867f, -0.29037341f, 0.25769433f, 0.12229791f, 0.14772795f, -0.36387226f, 
    0.29069802f, 0.19954561f, 0.10879448f, 0.27113822f, -0.07083842f, 0.10330993f, -0.20701419f, -0.27039698f, 
    0.00239991f, -0.08774593f, 0.22336507f, -0.12091911f, 0.07475457f, -0.42716444f, -0.22813877f, 0.01127315f, 
    -0.00704172f, -0.12689815f, -0.41126680f, -0.02975798f, -0.21159519f, -0.16919950f, 0.06279483f, 0.06405273f, 
    0.01797844f, -0.10934296f, -0.02236499f, 0.02887275f, -0.06458674f, 0.01611915f, -0.03068835f, -0.20026708f, 
    -0.71629047f, 0.04557459f, -0.38725710f, 0.24819931f, -0.17417112f, -0.00381809f, 0.22509490f, -0.07507565f, 
    0.09340812f, -0.02984606f, -0.32804275f, -0.07104870f, 0.14805663f, 0.13775915f, 0.05530492f, 0.07397247f, 
    -0.06921621f, 0.08055449f, -0.08990694f, 0.21481670f, -0.06918713f, 0.15204471f, -0.48689672f, 0.05511913f, 
    -0.26819050f, -0.01959591f, 0.02926761f, -0.16094752f, -0.22033031f, 0.06168506f, -0.00204194f, 0.17379598f, 
    0.02207172f, 0.05545531f, -0.09452196f, 0.00440103f, -0.04332540f, 0.06014311f, -0.08159706f, 0.02803878f, 
    0.19491608f, -0.47600460f, 0.25803539f, 0.06191806f, 0.31003180f, 0.10688026f, -0.05415822f, 0.20864977f, 
    -0.00697913f, 0.01110622f, 0.09808367f, -0.22556962f, 0.09179481f, -0.01522937f, -0.03319554f, 0.14405583f, 
    0.06773371f, 0.17898223f, -0.03208602f, 0.10614894f, -0.16047291f, -0.21571691f, 0.03265569f, 0.18551295f, 
    0.05672086f, -0.10641541f, 0.09720874f, 0.02691163f, 0.19404916f, -0.00395496f, -0.05352322f, 0.07799271f, 
    -0.02785564f, 0.01292106f, 0.15271339f, -0.18127921f, -0.06865329f, -0.00516445f, -0.08490410f, -0.15333536f, 
    -0.49897227f, -0.00593396f, -0.38576177f, 0.25387111f, -0.30766633f, -0.01751480f, 0.01840332f, -0.03559700f, 
    0.01902482f, 0.02139100f, -0.03127021f, -0.02369454f, 0.02551467f, -0.03596514f, -0.03964429f, -0.02165670f, 
    -0.01874613f, -0.05559271f, -0.11419101f, -0.00176749f, -0.15905406f, -0.47588888f, 0.36195952f, 0.51843166f, 
    -0.21939631f, 0.17698286f, 0.03000891f, -0.09453758f, 0.18731846f, -0.30966526f, -0.10607206f, 0.01030080f, 
    0.04818344f, -0.02162004f, 0.12441587f, 0.01067186f, 0.08949967f, 0.13512871f, 0.14193563f, -0.04737428f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22375299f, 0.14255980f, 0.05102765f, -0.12793522f, -0.05669408f, 0.01380396f, 0.04937622f, -0.10188314f, 
    0.06488970f, 0.04870881f, 0.01610994f, -0.01249284f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
