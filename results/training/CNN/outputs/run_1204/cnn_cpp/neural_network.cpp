#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.80194163f, 0.24483371f, 0.65138298f, 0.03368475f, 0.12183227f, 0.11200417f, 0.22729699f, 0.02456238f, 
    0.35051775f, -0.04122609f, 0.06348610f, -0.10350636f, 0.91767228f, -0.73063469f, -0.23977351f, -0.14152308f, 
    0.05993142f, -0.05557738f, -0.57092404f, -0.50019360f, -0.15535392f, 0.22025315f, -0.26663527f, -0.40153429f, 
    0.03800856f, -0.06350509f, 0.37816793f, -0.13700844f, 0.62888277f, 0.72068888f, -0.06489404f, -0.55268049f, 
    -0.39273024f, 0.05079096f, -0.13794696f, -0.00204440f, -0.01859434f, 0.17567396f, -0.19246881f, -0.01783420f, 
    0.09841964f, 0.36685076f, 0.51132172f, -0.60854256f, -0.00559910f, -0.02458850f, -0.13781190f, 0.50963372f, 
    -0.22512162f, 0.02541523f, 0.28949982f, 0.02746720f, 0.26139227f, -0.35112482f, 0.02767005f, -0.16853818f, 
    -0.13383248f, 0.52967048f, -0.58363461f, 0.81409127f, -0.10205366f, -0.17149183f, -0.19693562f, 0.03164553f, 
    -0.36628181f, -0.15775177f, -0.50816602f, -0.49045533f, -0.52471334f, 0.49099401f, 0.06180136f, -0.07666260f, 
    0.43801615f, -0.55995941f, -0.60970640f, 0.12323138f, 0.14745024f, 0.05294131f, 0.43277723f, 0.33886942f, 
    0.33619830f, 0.24406801f, -0.80662245f, 0.32721734f, 0.04118595f, 0.42324120f, 0.14867066f, -0.08311992f, 
    -0.26175466f, -0.22613926f, -0.27328435f, 0.47740620f, -0.02912405f, 0.09568030f, 0.55616724f, 0.32538921f, 
    0.30137831f, -0.20959088f, 0.17558122f, 0.01915373f, 0.37909457f, 0.33870941f, 0.16384633f, 0.19127524f, 
    0.29540119f, 0.16739814f, -0.56048119f, -0.21065052f, -0.25671589f, 0.64438462f, -0.03589517f, -0.53451729f, 
    -0.25765085f, -0.08889290f, 0.39607489f, 0.19525848f, 0.42131749f, -0.05360047f, -0.15419848f, 0.21236704f, 
    -0.13122013f, -0.18880445f, 0.12688164f, 0.31139126f, -0.10280266f, 0.62202120f, -0.05788511f, -0.39775351f, 
    0.61819810f, -0.02957151f, 0.08706550f, 0.48262048f, -0.10371210f, -0.02733290f, 0.46057594f, -0.35209680f, 
    -0.38921493f, -0.67386085f, 0.19047970f, 0.61879086f, -0.51741183f, 0.02384957f, -0.04369726f, -0.17882995f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09042545f, 0.16579597f, -0.03050151f, -0.02716489f, 0.25571153f, 0.29200321f, -0.05125596f, 0.06242754f, 
    0.31322691f, 0.05545961f, -0.06377220f, -0.12768146f, -0.22390486f, 0.08928443f, 0.15162134f, 0.17202875f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.10416701f, 0.34126100f, 0.05874933f, 0.03451134f, 0.05152621f, 0.04777225f, -0.06629211f, 0.07063719f, 
    -0.12314434f, -0.18270937f, 0.14002930f, 0.43000033f, 0.03958913f, 0.00969225f, -0.21809745f, -0.09473088f, 
    -0.04130337f, -0.12649241f, 0.15236776f, 0.14493994f, 0.18048388f, 0.01932807f, 0.04841578f, -0.04720607f, 
    0.16111630f, 0.06976136f, -0.00423448f, -0.17499550f, 0.09411449f, -0.11338724f, -0.08191422f, 0.05727774f, 
    -0.16594048f, 0.01322542f, 0.09054010f, -0.03867004f, -0.09667857f, 0.01565046f, 0.19140613f, -0.11681406f, 
    0.08886813f, 0.07413480f, -0.08608519f, -0.11804623f, 0.20443633f, -0.08157769f, 0.03359789f, 0.07287660f, 
    -0.21050215f, 0.15855029f, -0.07277310f, -0.01269399f, 0.17276713f, -0.00937093f, -0.62276262f, 0.12039080f, 
    0.31989944f, 0.09041721f, -0.12803937f, -0.06178490f, 0.04430514f, -0.15962014f, -0.05144991f, -0.03679839f, 
    0.09287917f, 0.16526516f, -0.21370187f, -0.02586470f, -0.00919703f, 0.03300575f, 0.15249391f, 0.02277645f, 
    -0.08369919f, -0.14822103f, 0.00284064f, 0.10706443f, 0.05360435f, 0.10300865f, 0.05441100f, 0.06031295f, 
    -0.09337480f, -0.09358574f, -0.34104940f, -0.24730378f, 0.11157183f, 0.05142352f, 0.05349955f, -0.11648349f, 
    -0.06947756f, 0.13377173f, 0.02881030f, 0.07616729f, 0.06313452f, 0.00304329f, 0.05319777f, -0.03943852f, 
    0.01080428f, 0.03427151f, 0.04141240f, -0.17110215f, 0.03917161f, 0.01915278f, -0.01294881f, -0.27817562f, 
    -0.14077759f, 0.09253260f, 0.03572028f, 0.07188945f, -0.34201920f, -0.00663504f, 0.02923768f, 0.12825406f, 
    0.08184320f, -0.05755514f, 0.09585080f, -0.05344635f, -0.00161005f, -0.16447349f, 0.39371404f, 0.11389759f, 
    0.17184360f, 0.03038830f, -0.27206090f, -0.02710616f, 0.14226244f, 0.05421527f, -0.30380785f, 0.05037083f, 
    -0.38145143f, 0.03976802f, 0.07837007f, 0.15135460f, -0.05448872f, -0.01681833f, 0.09133939f, 0.02007205f, 
    0.18228576f, 0.22837530f, 0.13755627f, -0.05492828f, -0.17155735f, -0.00076168f, 0.04013686f, -0.00689072f, 
    0.34277445f, 0.17926526f, 0.20492098f, -0.08555473f, -0.08261624f, 0.12068027f, 0.00968050f, 0.08069080f, 
    0.06393707f, -0.26518813f, -0.07861132f, 0.16297512f, -0.02218831f, -0.15262432f, -0.12145889f, 0.23022127f, 
    0.09169576f, 0.11220294f, -0.18110895f, -0.12494038f, -0.00484727f, -0.18121974f, -0.01856831f, -0.22593817f, 
    -0.04787492f, -0.00595486f, 0.08400775f, 0.22361545f, -0.31584650f, 0.17897481f, -0.21714008f, 0.08566266f, 
    -0.26820385f, -0.01885344f, 0.09951337f, -0.14489558f, 0.28301239f, -0.05070665f, 0.04339537f, -0.06644213f, 
    0.10467687f, -0.00694520f, 0.10966328f, 0.02044694f, 0.05317498f, 0.22241083f, -0.25925735f, 0.07241666f, 
    -0.01351782f, 0.02020198f, 0.15099050f, 0.03265747f, -0.01784758f, 0.09592045f, -0.69481003f, -0.34484702f, 
    0.07002160f, 0.02106646f, 0.15409550f, -0.09681830f, -0.01314265f, -0.23777543f, 0.04270459f, -0.01249684f, 
    0.00378219f, -0.11876392f, -0.06621758f, 0.14619794f, -0.10031507f, -0.03191330f, -0.03139310f, 0.01495765f, 
    -0.14660352f, 0.17529562f, 0.08365346f, 0.13043576f, 0.07871874f, 0.15424447f, 0.03750294f, -0.05811204f, 
    -0.02267868f, 0.10074159f, 0.07368460f, -0.11255173f, -0.02925709f, 0.01653195f, -0.03683620f, -0.05634192f, 
    -0.05104083f, 0.06899565f, -0.23704924f, -0.17320104f, -0.14677784f, -0.12732357f, -0.12757166f, -0.08816656f, 
    0.03237406f, 0.07192720f, 0.08100145f, -0.26300448f, -0.07321576f, 0.06646353f, -0.07139566f, -0.25376734f, 
    0.01449216f, 0.04082603f, 0.03987516f, 0.08190300f, 0.11622643f, -0.28985044f, -0.22680673f, -0.09556051f, 
    -0.16356914f, 0.02918096f, -0.14008944f, 0.08763943f, -0.05983413f, 0.13645212f, -0.03046322f, 0.11637331f, 
    -0.06916384f, -0.03277085f, -0.19438067f, 0.06633963f, 0.14133139f, -0.07432032f, 0.36026388f, -0.16226158f, 
    -0.01271177f, -0.01701864f, 0.00870355f, 0.01918335f, 0.09385053f, 0.08434254f, 0.04356999f, -0.43086720f, 
    0.06526223f, 0.26934186f, -0.09059098f, 0.21995400f, 0.16349250f, -0.00942988f, 0.11947901f, 0.14121348f, 
    -0.05224156f, 0.01838744f, 0.04200336f, -0.01374182f, -0.01800100f, -0.03566151f, -0.04140043f, 0.04727964f, 
    -0.00374743f, 0.00656073f, -0.06022156f, 0.00619534f, 0.05035293f, -0.04824382f, 0.02583217f, -0.04232175f, 
    0.05839664f, -0.04224741f, -0.07378423f, -0.02529040f, -0.04508458f, -0.01845940f, 0.01576766f, -0.04538994f, 
    0.00601960f, -0.01648333f, -0.00993986f, 0.05830331f, -0.06751017f, 0.03200020f, 0.05510548f, 0.02528493f, 
    0.03130506f, 0.01361188f, -0.03437614f, -0.06320849f, 0.05277280f, -0.04152109f, 0.06158188f, -0.03197350f, 
    -0.00544729f, 0.00149727f, 0.05200192f, -0.01639411f, 0.00420944f, -0.03120988f, 0.04042298f, 0.07145292f, 
    -0.07400235f, -0.08388589f, -0.00908724f, -0.05555402f, -0.02173951f, -0.01720612f, -0.07568088f, -0.03929527f, 
    -0.03265595f, -0.06370378f, 0.06035544f, 0.03707249f, -0.08301891f, 0.01375075f, 0.05807386f, 0.01740646f, 
    0.04705080f, -0.05122950f, -0.02797421f, 0.00209649f, -0.00044844f, -0.00574626f, -0.02045720f, 0.01340681f, 
    -0.05646271f, -0.05364297f, -0.04034217f, 0.01191045f, -0.03664372f, 0.06668829f, -0.07527795f, -0.07840988f, 
    0.03310236f, -0.02353764f, -0.00239475f, -0.08284143f, 0.04377570f, 0.05479665f, -0.06621912f, -0.02529090f, 
    0.07400124f, -0.01218873f, 0.03599159f, 0.05693800f, 0.01733722f, 0.05810728f, -0.07552598f, -0.01102881f, 
    0.07107279f, -0.04632102f, -0.07282431f, -0.03244340f, 0.03698146f, -0.05650011f, 0.02177921f, -0.03023288f, 
    0.04568303f, 0.01382121f, 0.01635372f, 0.05413237f, -0.01240097f, 0.07526997f, -0.01951710f, 0.05039186f, 
    0.01310383f, -0.03815340f, -0.03367547f, 0.04711038f, -0.04697331f, 0.00404101f, 0.01083856f, -0.07573051f, 
    0.04792169f, -0.07007242f, -0.05015289f, -0.05678523f, -0.00301598f, 0.03956030f, -0.06566099f, -0.02239391f, 
    -0.04678619f, 0.02902308f, 0.07294928f, -0.01603859f, -0.03704324f, -0.03190746f, -0.08542830f, 0.00817843f, 
    -0.06181944f, -0.08567664f, -0.07908349f, -0.06199210f, 0.00160216f, 0.02459018f, 0.01540480f, -0.07513156f, 
    -0.32073715f, 0.22714840f, 0.12393244f, -0.19480357f, -0.12572061f, -0.00965118f, -0.04641830f, -0.04290451f, 
    -0.15284765f, 0.29401892f, 0.10059410f, 0.05345974f, 0.01163929f, -0.11348369f, -0.12334107f, -0.12032390f, 
    -0.06218849f, 0.05317287f, 0.04043450f, 0.03880620f, 0.09145926f, -0.05072547f, -0.05106978f, 0.06407331f, 
    0.06752452f, 0.05348616f, -0.11525922f, -0.19851066f, -0.12950762f, 0.11598045f, 0.10358500f, -0.01642476f, 
    0.12714216f, 0.00020339f, -0.05572560f, 0.05386545f, 0.14040272f, 0.04900445f, 0.05324974f, -0.05334903f, 
    -0.01727768f, 0.02622010f, -0.05890517f, -0.07533851f, 0.04764525f, 0.05543867f, 0.06105484f, 0.20605625f, 
    -0.04251819f, 0.06857578f, 0.08323938f, -0.08018354f, -0.09715543f, -0.10412081f, 0.26683605f, 0.17738257f, 
    0.09720315f, 0.00143125f, 0.02592957f, 0.17268768f, -0.14580970f, -0.20935614f, -0.20729232f, -0.11274283f, 
    0.08354691f, -0.31549501f, 0.17667639f, 0.04477444f, -0.13231002f, -0.00035351f, 0.16273388f, 0.07514351f, 
    0.11241599f, -0.25409302f, -0.15190482f, 0.04094850f, 0.04616279f, -0.05817775f, 0.02062969f, 0.17718029f, 
    0.22005337f, -0.13040255f, -0.10866372f, -0.04339486f, 0.23120230f, 0.03797290f, 0.14487335f, -0.07361862f, 
    -0.27629584f, -0.28051195f, 0.15279430f, -0.03225917f, 0.16498956f, 0.21817316f, -0.03698143f, 0.11812438f, 
    0.05496619f, -0.03599629f, 0.16274637f, 0.03905003f, 0.10925701f, -0.01086747f, 0.23501697f, -0.14123760f, 
    -0.00369531f, -0.27453876f, 0.01804156f, -0.22229248f, 0.06710435f, 0.04661358f, 0.14458564f, 0.16525845f, 
    0.05138226f, 0.00300585f, 0.24398418f, 0.18448301f, 0.21705063f, 0.16503526f, 0.17896661f, -0.09232185f, 
    0.11931130f, 0.07550926f, -0.13425189f, 0.00039311f, 0.17499509f, 0.19323006f, -0.02374376f, 0.09001964f, 
    0.08085615f, 0.01552411f, 0.05988077f, -0.05775303f, 0.00544617f, -0.16912486f, -0.05600908f, 0.04825944f, 
    0.10856577f, 0.10849078f, -0.07563583f, 0.01327059f, -0.05206855f, -0.09534489f, -0.12897222f, -0.04164469f, 
    0.47173172f, -0.08095112f, 0.09147855f, -0.07287652f, -0.07850710f, 0.00392665f, -0.16601017f, 0.00753628f, 
    -0.06964274f, -0.12161329f, -0.19392256f, 0.20501804f, -0.10437254f, -0.04833294f, -0.22919717f, 0.16231437f, 
    -0.00583392f, -0.04330176f, 0.28022590f, 0.12820154f, 0.42331746f, -0.08704953f, 0.08127272f, -0.17789286f, 
    -0.06566650f, 0.10184441f, -0.05578071f, -0.10686760f, -0.31465250f, -0.43870029f, 0.07015885f, 0.06948743f, 
    -0.08306552f, -0.01376454f, 0.12641798f, -0.10384310f, 0.08113831f, -0.00828668f, 0.07455517f, 0.10455386f, 
    0.03798636f, 0.02332107f, 0.01107536f, 0.08921437f, 0.12203725f, 0.12651969f, -0.01401144f, 0.01406925f, 
    0.10606489f, 0.00245205f, 0.04158460f, -0.11453166f, -0.06591479f, 0.03145168f, -0.00809416f, -0.03818905f, 
    0.21431178f, 0.08538692f, 0.08069044f, 0.03584423f, -0.01692198f, 0.01753335f, 0.10901099f, -0.14047506f, 
    -0.38669330f, -0.34848988f, 0.01711044f, 0.02911765f, -0.14153631f, -0.05630466f, -0.03242175f, 0.06211088f, 
    0.09066201f, 0.27680767f, -0.10263509f, -0.02343478f, -0.07976136f, 0.02947390f, -0.04273576f, 0.00652204f, 
    -0.07121821f, 0.02636207f, 0.00085015f, -0.06568997f, 0.05512914f, -0.00059831f, -0.11306684f, 0.08102368f, 
    -0.12869501f, 0.24382283f, 0.05098644f, 0.03376940f, 0.12822363f, -0.05599178f, 0.06892711f, 0.00700738f, 
    0.09299524f, -0.06831574f, -0.01052714f, 0.01122790f, 0.26990461f, 0.15059258f, -0.11906137f, -0.17961723f, 
    -0.12539954f, -0.14573355f, 0.04830422f, 0.28981280f, -0.20382325f, -0.65381098f, -0.60717857f, 0.02506923f, 
    0.12790969f, 0.04357770f, 0.00367105f, 0.02631172f, -0.01205704f, 0.00597758f, 0.08253154f, 0.11992946f, 
    0.05126980f, -0.02276854f, -0.02114854f, 0.02129427f, -0.01154584f, 0.05231593f, 0.12034427f, 0.15707470f, 
    -0.11887951f, -0.06574333f, 0.10161277f, 0.08641618f, 0.06591859f, -0.02353858f, -0.02218812f, -0.11907887f, 
    -0.11829162f, 0.11186898f, -0.00343638f, 0.08490933f, 0.10037939f, -0.07809905f, -0.08911014f, 0.01665996f, 
    0.01533394f, -0.05819411f, -0.01678880f, -0.04536831f, -0.04151886f, -0.05782293f, 0.02521693f, 0.00433367f, 
    -0.04884444f, -0.07618684f, 0.00966193f, -0.03679175f, -0.09156490f, 0.05533550f, -0.07360516f, 0.02205423f, 
    -0.05327444f, -0.02867608f, -0.07803961f, 0.01514272f, -0.01151081f, 0.00195337f, -0.06026251f, -0.04244307f, 
    -0.02201410f, 0.04580731f, -0.06207172f, -0.06567890f, 0.02907692f, -0.08836067f, -0.05297977f, 0.05778631f, 
    0.02297664f, -0.01398859f, 0.06992004f, -0.08070800f, 0.06116932f, 0.01468881f, -0.08324270f, 0.00855818f, 
    -0.08335348f, 0.00505451f, -0.06370795f, -0.05052057f, 0.01105836f, 0.05271256f, -0.07358702f, 0.06306901f, 
    0.01718253f, -0.05421894f, -0.04727038f, 0.07514048f, 0.03781404f, -0.08162893f, -0.05408327f, -0.05815477f, 
    0.04594340f, -0.05815345f, 0.02832154f, 0.04525186f, -0.01807466f, -0.04802301f, 0.08725841f, 0.04460774f, 
    -0.08684549f, 0.06442058f, -0.01610554f, -0.06998298f, -0.06412064f, -0.01847729f, 0.04613535f, 0.06056527f, 
    -0.06827115f, -0.05854139f, 0.01795004f, 0.02381239f, -0.01340313f, -0.04913465f, -0.00696001f, 0.00097088f, 
    0.06345425f, 0.04661698f, 0.07572624f, -0.07578567f, -0.02921677f, 0.04690333f, 0.06880083f, -0.05058228f, 
    -0.07724471f, 0.07524551f, -0.08611573f, 0.07007897f, 0.02245331f, 0.03751458f, 0.00682521f, -0.04593489f, 
    0.06485994f, -0.09072947f, -0.07274252f, 0.02667752f, -0.05549249f, 0.05703159f, 0.01390038f, 0.03112912f, 
    -0.00140809f, -0.02683987f, -0.07239768f, 0.07986028f, -0.01162829f, -0.04583016f, -0.02731769f, -0.05399632f, 
    -0.06917675f, 0.02100856f, -0.03538018f, -0.06491301f, -0.00601545f, 0.01055501f, 0.06218519f, -0.05875434f, 
    -0.01104046f, 0.07917256f, 0.00705238f, 0.07030340f, 0.03838623f, -0.07450254f, -0.07507850f, 0.05789939f, 
    0.01855364f, 0.05257792f, 0.04348467f, 0.04140508f, -0.03784826f, -0.08324194f, -0.05652513f, -0.01778895f, 
    0.01229351f, 0.00864314f, -0.07996710f, 0.02228601f, -0.04774371f, -0.01262911f, 0.02935934f, -0.08408194f, 
    0.00979957f, -0.24083909f, 0.03506080f, 0.10173079f, 0.02297313f, -0.04019088f, -0.00503387f, 0.01220729f, 
    -0.02458304f, -0.40949681f, 0.25155288f, -0.00044268f, -0.20196696f, -0.00197172f, -0.10846240f, 0.10472421f, 
    -0.05144104f, -0.02717842f, 0.36014923f, 0.27960426f, 0.01081095f, -0.12099573f, -0.13390575f, 0.13042472f, 
    0.04065436f, 0.09417679f, 0.05269744f, 0.05706196f, -0.43773624f, -0.04535203f, 0.07078776f, 0.07720790f, 
    -0.18613690f, 0.01313560f, -0.02178313f, -0.01740806f, -0.00188830f, 0.28852683f, -0.05776990f, 0.01986596f, 
    -0.04447649f, -0.17658731f, -0.06491242f, 0.00577091f, 0.03477413f, -0.19355273f, -0.10515333f, 0.18940718f, 
    -0.07527446f, 0.21147300f, 0.07283116f, 0.13199021f, -0.02499578f, -0.10632219f, -0.01122774f, 0.11709805f, 
    0.20546114f, -0.06123574f, -0.17123944f, -0.10669896f, -0.02760014f, 0.07368968f, -0.04337154f, 0.15474877f, 
    0.34270412f, 0.20887804f, -0.07427194f, 0.04029639f, -0.14072739f, 0.04291705f, -0.02343116f, -0.00203600f, 
    -0.01078747f, 0.15285139f, -0.40190294f, 0.00065513f, 0.00534200f, 0.06025513f, 0.02531166f, 0.07672449f, 
    0.10558017f, -0.21835750f, -0.60178488f, -0.05868650f, -0.01682465f, -0.09667219f, 0.09767528f, -0.00912799f, 
    0.00964974f, 0.08445220f, 0.26485088f, 0.43256277f, -0.05247187f, -0.30497226f, -0.05182426f, -0.27348492f, 
    0.03781528f, -0.01880760f, 0.00921176f, 0.14523149f, 0.11567294f, 0.11492398f, 0.06513083f, -0.00570830f, 
    -0.24155129f, 0.00194135f, -0.01441984f, 0.00909560f, 0.01331880f, -0.35518831f, -0.00435332f, -0.00964819f, 
    0.07201662f, -0.02152341f, 0.05352293f, 0.06779995f, -0.01768135f, -0.08500448f, -0.00965468f, 0.10182703f, 
    0.02990367f, 0.05657914f, -0.02013775f, -0.14991495f, -0.01257247f, -0.08111278f, 0.17075014f, -0.32213458f, 
    0.10741197f, -0.23487601f, 0.12273611f, -0.03176122f, 0.08202912f, -0.06768478f, -0.01705675f, -0.03355039f, 
    0.00647144f, 0.02532523f, 0.06020397f, -0.12502423f, 0.09938297f, 0.00053655f, 0.12406684f, -0.01659999f, 
    0.16179383f, -0.09896707f, -0.00870660f, 0.11650945f, -0.00805129f, 0.09647365f, 0.10874993f, -0.03833747f, 
    0.09634510f, -0.07713750f, -0.01890757f, -0.07070846f, 0.03821132f, 0.06074864f, 0.05032090f, 0.20047961f, 
    0.10912830f, 0.09500589f, -0.39036843f, 0.16788737f, -0.11389100f, -0.01882027f, 0.12400724f, -0.14278652f, 
    0.03967234f, 0.00425851f, 0.09687237f, 0.15376318f, -0.03733219f, 0.13853970f, -0.00773337f, -0.09247623f, 
    0.02652049f, 0.03715448f, -0.14158066f, 0.01000854f, 0.13822724f, 0.07292029f, 0.19711345f, -0.04354380f, 
    0.08744986f, 0.02788827f, 0.06410619f, 0.11666998f, -0.12798822f, -0.02080679f, 0.13043730f, 0.07809450f, 
    0.10635799f, -0.00197043f, -0.07426244f, -0.04253360f, 0.06207261f, -0.20348051f, 0.25938770f, 0.12579140f, 
    -0.02353029f, -0.17369270f, 0.02497743f, -0.04824568f, -0.10610368f, -0.07143832f, -0.21413606f, -0.00026523f, 
    -0.12994781f, -0.13666229f, 0.05271920f, -0.08621500f, -0.04698081f, 0.16759965f, -0.00240779f, -0.01288820f, 
    0.17197263f, 0.26502529f, -0.17049836f, 0.03164022f, 0.02864922f, 0.10760707f, -0.00590925f, -0.09953889f, 
    0.15787658f, 0.16903183f, 0.15958981f, 0.20217294f, 0.06863599f, 0.04659485f, -0.12653005f, 0.06125767f, 
    0.10324558f, -0.04932258f, -0.07230365f, 0.15891561f, 0.39048904f, -0.16722542f, -0.21405467f, 0.03610504f, 
    0.02713833f, -0.04652611f, -0.24421969f, -0.02903610f, 0.00580700f, 0.03769336f, 0.13466528f, -0.00157266f, 
    -0.02889479f, 0.14120625f, -0.05824506f, 0.17477189f, -0.13196982f, -0.11537259f, 0.08398400f, 0.04179765f, 
    0.15014741f, -0.14856352f, -0.14064373f, -0.32660803f, -0.12266538f, -0.19796102f, 0.09025843f, 0.10261562f, 
    0.00723162f, -0.05690204f, 0.07460559f, -0.20755292f, -0.18961121f, -0.04270500f, 0.09221347f, 0.27106938f, 
    0.29389995f, -0.06897398f, -0.07859615f, 0.23370697f, -0.02862144f, -0.02963002f, -0.11388610f, -0.35106274f, 
    -0.23148100f, -0.11128968f, -0.04124498f, -0.21147481f, 0.04019211f, 0.07818653f, 0.05145220f, -0.06974222f, 
    -0.08763590f, -0.02734876f, -0.02553105f, -0.08390515f, 0.02334910f, 0.03807967f, 0.03298185f, 0.04416494f, 
    -0.07605311f, 0.01583323f, 0.03607070f, 0.02153315f, -0.07510772f, 0.01903952f, 0.06104694f, 0.01545284f, 
    -0.05708735f, -0.08693762f, -0.08739016f, 0.05437448f, -0.06011215f, -0.06176689f, -0.04744919f, -0.05772055f, 
    0.01009710f, -0.04966010f, 0.06865829f, 0.05663843f, 0.06559786f, -0.07358885f, 0.04553252f, -0.07901591f, 
    -0.00540445f, 0.03022241f, 0.00969613f, -0.00555971f, 0.01754408f, -0.01998800f, 0.04546743f, -0.00137867f, 
    -0.08243942f, -0.01740924f, 0.03492454f, -0.08694400f, -0.06015207f, -0.00315313f, 0.06868198f, 0.03557097f, 
    -0.04764573f, 0.00609907f, 0.01993766f, -0.03741731f, 0.06110670f, -0.05532401f, -0.05147685f, -0.07888997f, 
    0.08083388f, 0.05608341f, 0.01333454f, -0.02615691f, -0.02131789f, 0.05043781f, -0.02600806f, -0.02472617f, 
    -0.07120784f, 0.00491284f, -0.03333759f, -0.06564297f, 0.03841774f, -0.01447656f, -0.05430732f, -0.04814122f, 
    -0.02603014f, -0.07753053f, -0.08547699f, 0.04421301f, -0.06680420f, 0.02163772f, -0.04051714f, 0.00935256f, 
    -0.08531845f, 0.01808863f, -0.01586663f, -0.06761073f, 0.05089649f, -0.07480307f, 0.06629469f, -0.02657963f, 
    -0.01341029f, 0.05693674f, 0.07092854f, -0.01110411f, -0.06821596f, -0.04992302f, 0.01784215f, -0.03874074f, 
    0.00785914f, 0.04030221f, 0.05851248f, -0.04700558f, -0.01100904f, 0.00808005f, 0.05629284f, 0.03299654f, 
    -0.07667710f, 0.02495281f, -0.04256140f, -0.05533465f, -0.01071304f, 0.04199081f, 0.01341993f, -0.07922398f, 
    -0.03376719f, 0.02959263f, -0.00973808f, -0.00790968f, -0.03912229f, 0.03163013f, 0.07310852f, -0.01865188f, 
    0.03951753f, 0.00147071f, 0.06857567f, 0.01306339f, -0.08032012f, -0.04357362f, 0.02842788f, -0.03341245f, 
    0.05512035f, 0.00365987f, -0.06322355f, 0.00345852f, 0.01306144f, -0.02808475f, 0.06198116f, 0.07225032f, 
    -0.04003259f, 0.05683528f, -0.05242046f, -0.03139196f, -0.07034721f, 0.04589429f, -0.01625997f, 0.04036937f, 
    -0.09303234f, -0.11913113f, -0.06667048f, 0.02589081f, 0.08310887f, 0.05005962f, -0.05987458f, -0.04422823f, 
    0.00175519f, 0.01126595f, 0.00135007f, -0.08442900f, -0.06972802f, -0.07172299f, -0.04699407f, 0.01942019f, 
    -0.09292851f, -0.00608732f, 0.07342409f, 0.03584582f, 0.03359397f, 0.00311223f, -0.06156912f, 0.00979953f, 
    0.02024744f, 0.02896467f, -0.03661075f, 0.02153478f, 0.03628556f, -0.02995299f, 0.00256602f, 0.04794202f, 
    -0.09266834f, -0.06092400f, -0.00389296f, -0.01702920f, -0.06498097f, 0.04259781f, 0.02719619f, 0.02026182f, 
    0.00985806f, -0.05121725f, -0.00877895f, 0.06574276f, -0.09031380f, -0.09861938f, -0.01341362f, 0.03763365f, 
    -0.09999108f, -0.00624008f, -0.00069655f, -0.04538078f, 0.04974431f, 0.00591550f, 0.03441715f, -0.13029824f, 
    -0.04422862f, 0.00516276f, 0.03005376f, 0.03980795f, -0.06740929f, -0.05144862f, 0.04330599f, 0.04912304f, 
    0.00314890f, 0.01020988f, -0.06009468f, -0.10235799f, -0.01565327f, -0.06543352f, -0.05594724f, -0.06394282f, 
    -0.04972525f, 0.04849777f, -0.03167141f, 0.07487597f, 0.06146961f, 0.01999248f, -0.11876058f, -0.05585870f, 
    -0.02028164f, -0.12055539f, -0.09114398f, -0.04001521f, 0.04605783f, 0.01134447f, -0.00571036f, -0.06215759f, 
    -0.08855734f, -0.05824468f, -0.11225629f, -0.02263822f, -0.06783751f, 0.08802265f, -0.01725438f, 0.06845825f, 
    0.03348351f, -0.10307872f, -0.02544346f, -0.05501180f, -0.02220549f, -0.11710890f, -0.02154348f, -0.06937502f, 
    -0.06723356f, 0.02158664f, -0.09673128f, -0.01466865f, 0.01155392f, 0.00196512f, 0.07437380f, -0.01867279f, 
    -0.00146876f, -0.02393238f, 0.04748327f, -0.10410073f, -0.09100726f, -0.03473861f, -0.00252853f, -0.04179687f, 
    -0.08849965f, -0.11137947f, 0.03989647f, -0.02539439f, -0.06165367f, -0.02843937f, -0.10439696f, -0.08543751f, 
    -0.01714372f, 0.01632989f, -0.01963913f, 0.03295680f, 0.04259210f, 0.01895415f, -0.08690902f, -0.00529388f, 
    0.02405685f, 0.05164353f, -0.08126160f, 0.04636621f, -0.06474142f, -0.08922169f, -0.04789628f, 0.01856673f, 
    0.00064227f, -0.03063785f, 0.11817002f, 0.10640800f, 0.07199799f, 0.14181836f, 0.05992392f, -0.03862132f, 
    0.27139708f, -0.10109041f, -0.10955731f, -0.05275840f, 0.02151534f, -0.03212922f, 0.07245866f, 0.04749694f, 
    0.04836182f, 0.06724431f, -0.42159203f, 0.28442466f, 0.00517494f, -0.06835420f, -0.10777871f, 0.16239575f, 
    0.03707688f, -0.07997680f, 0.05943173f, -0.05467015f, -0.22684725f, 0.26389474f, 0.15120523f, -0.01839324f, 
    0.00879667f, -0.02164936f, -0.00929669f, -0.02455812f, 0.13457631f, 0.11156985f, -0.02838990f, -0.27580097f, 
    0.11538455f, -0.20526791f, -0.00812631f, -0.01063265f, -0.22143823f, 0.04147409f, -0.02237436f, 0.10064767f, 
    -0.00957511f, 0.10064500f, -0.00076950f, -0.00013772f, -0.01041629f, 0.05429295f, -0.15011001f, -0.05250254f, 
    0.00567885f, 0.14183410f, -0.15191746f, -0.29824451f, -0.23473139f, 0.03555463f, -0.20052905f, -0.20794195f, 
    0.04585666f, -0.23395741f, -0.01187139f, 0.00641010f, 0.15221152f, 0.01907588f, 0.14521572f, -0.05535965f, 
    0.41636443f, 0.22626899f, -0.03386607f, 0.03053179f, -0.08334906f, -0.01253885f, 0.15965152f, -0.00338551f, 
    0.08817137f, 0.08209541f, -0.06603240f, 0.03258157f, -0.01728934f, 0.07638035f, -0.09717420f, -0.06342172f, 
    -0.10539610f, -0.17278478f, -0.03640014f, 0.02365595f, 0.12934342f, 0.10270149f, 0.06550486f, -0.12366265f, 
    -0.02131793f, -0.10646408f, -0.18141849f, 0.00480236f, -0.20978758f, -0.09658771f, 0.00287670f, 0.22790404f, 
    -0.02421545f, -0.06835077f, -0.10418767f, -0.07828368f, 0.05231956f, 0.05173094f, -0.08533543f, -0.14120132f, 
    -0.04605762f, 0.22240637f, 0.13598414f, 0.02182423f, 0.16022749f, 0.04213171f, 0.08245403f, -0.02913477f, 
    0.12890717f, 0.26524302f, 0.20308274f, 0.13755129f, 0.19903246f, 0.19627447f, -0.07200353f, 0.03680340f, 
    0.21478043f, 0.01782028f, -0.06956452f, 0.00823362f, 0.12316757f, 0.05553965f, -0.04397442f, -0.06116048f, 
    0.05505511f, 0.07534298f, -0.04511441f, -0.04998255f, -0.14532816f, -0.15586659f, -0.25010279f, -0.16476129f, 
    -0.03704638f, -0.24217644f, -0.26526302f, 0.05321746f, 0.12525626f, 0.00508231f, -0.03122663f, 0.02333749f, 
    0.13474633f, -0.07955835f, 0.10562877f, -0.26700962f, -0.01600582f, 0.11084883f, -0.02324665f, -0.04863777f, 
    0.02685507f, 0.11100392f, 0.30448818f, 0.12666257f, 0.11921566f, 0.06161371f, -0.02176230f, 0.08460156f, 
    0.12170115f, 0.04919846f, 0.13165382f, -0.34082195f, -0.02913911f, 0.00603414f, -0.28737551f, 0.00166928f, 
    0.12222452f, 0.04923097f, 0.08143766f, -0.04657678f, -0.18906778f, -0.26944184f, -0.02456309f, 0.17388831f, 
    -0.00571373f, 0.05588010f, 0.17195646f, -0.05170499f, 0.05375881f, -0.13370135f, -0.18038319f, 0.08175433f, 
    0.06858367f, -0.00344739f, -0.04687132f, -0.07697690f, -0.02645474f, -0.05452260f, 0.19634950f, 0.07811033f, 
    0.06793376f, -0.17498529f, 0.17899641f, -0.02686508f, 0.00062008f, 0.20155087f, -0.05294345f, 0.21745244f, 
    0.22450188f, 0.01122713f, -0.06440984f, 0.05186732f, -0.04992232f, -0.01710976f, -0.05346634f, -0.00497689f, 
    -0.04249101f, 0.10364593f, -0.37236714f, 0.09036367f, 0.14388749f, 0.05643960f, 0.06039656f, 0.15526411f, 
    0.03894774f, 0.26083404f, -0.24244252f, -0.10724463f, 0.00673825f, -0.18769433f, 0.14827012f, -0.07258172f, 
    0.11755186f, -0.00495318f, 0.00651047f, -0.31709564f, -0.46014243f, 0.07827625f, -0.03624019f, 0.11096232f, 
    0.17855050f, 0.13839562f, -0.04027103f, 0.16700855f, -0.22802615f, -0.27540648f, 0.13588448f, -0.11269119f, 
    0.02317503f, 0.06318522f, -0.16164465f, 0.11446455f, -0.01994590f, 0.15029344f, -0.04391973f, -0.29388162f, 
    -0.16367839f, -0.07855681f, -0.20239663f, 0.19719626f, 0.01926779f, -0.05404394f, 0.09103702f, 0.29841554f, 
    0.09737285f, -0.06360328f, 0.06139798f, 0.03768134f, -0.05922753f, 0.07217376f, -0.11722117f, -0.14499533f, 
    -0.48887065f, -0.08986767f, 0.06981897f, 0.12025005f, 0.07576267f, 0.06020825f, 0.05558620f, 0.21353120f, 
    0.02568801f, -0.15873702f, 0.17350236f, 0.17045349f, 0.27089226f, 0.09232420f, -0.04666606f, -0.06154759f, 
    -0.05265455f, -0.07704788f, 0.02951132f, 0.03799931f, 0.02066561f, -0.04033658f, -0.05185573f, 0.03210252f, 
    -0.01433469f, 0.07135288f, 0.04592092f, -0.02509488f, -0.07710892f, -0.05075346f, -0.04220505f, -0.02640407f, 
    0.04810273f, 0.02491407f, -0.02269764f, -0.00559112f, -0.08304821f, -0.01064018f, -0.00288319f, -0.05230068f, 
    -0.06633269f, 0.01007974f, -0.04178414f, -0.07006079f, -0.05773505f, 0.02319725f, -0.06116933f, -0.06200162f, 
    0.05396130f, -0.03869063f, -0.08331169f, 0.07205474f, -0.04048073f, 0.07189751f, 0.03353215f, -0.06039338f, 
    0.04521642f, -0.06027353f, 0.04638710f, -0.02755825f, -0.06987900f, 0.07165160f, 0.00849799f, -0.04772682f, 
    0.04117558f, 0.04162199f, 0.05647030f, -0.02645650f, -0.01429617f, -0.06380641f, 0.07571646f, -0.04065281f, 
    -0.02512806f, -0.03245525f, 0.07037193f, 0.00858714f, -0.02772458f, 0.06845931f, -0.07120052f, -0.00447844f, 
    0.08182031f, -0.07199445f, -0.05470067f, -0.05447764f, 0.04729786f, -0.00613194f, 0.02656368f, 0.06135399f, 
    0.07415076f, 0.04382829f, -0.02462156f, 0.04576622f, -0.08079056f, -0.04412455f, 0.05584766f, -0.08472051f, 
    -0.06658617f, -0.02604176f, 0.02355683f, 0.06445950f, -0.01985505f, -0.05656958f, -0.08291879f, -0.00443292f, 
    -0.01683438f, -0.00870832f, 0.03639047f, 0.06468587f, -0.06362467f, -0.08143136f, -0.07067171f, -0.02273512f, 
    -0.02448907f, -0.04862485f, 0.02211450f, 0.06048891f, -0.07568703f, -0.07109950f, 0.01375544f, -0.07615446f, 
    0.03805007f, 0.01856949f, -0.08417459f, -0.08578616f, -0.07421959f, -0.06043380f, 0.02268603f, -0.05749109f, 
    -0.00520760f, -0.00854655f, -0.04627657f, 0.04921428f, 0.04268092f, -0.08298601f, -0.00766011f, 0.02579257f, 
    -0.02514251f, -0.01544497f, -0.03737640f, 0.02666555f, -0.03267071f, -0.04839191f, -0.08416434f, 0.02709921f, 
    0.06088806f, -0.07374477f, 0.00727971f, 0.03207994f, 0.00430401f, 0.00478121f, -0.01991412f, -0.02605076f, 
    -0.02695457f, 0.04763083f, -0.08469053f, -0.05993890f, 0.04651043f, -0.06109764f, 0.03490755f, 0.01321621f, 
    -0.34694475f, 0.05131935f, -0.03821213f, -0.21413337f, 0.08565775f, 0.01963647f, -0.15761320f, 0.02841163f, 
    0.09353118f, 0.13884020f, -0.00111955f, 0.10307001f, 0.03791829f, 0.06301944f, 0.06553286f, 0.13619219f, 
    0.07349565f, 0.07988806f, -0.11196138f, 0.10859866f, 0.37354186f, -0.10063584f, 0.09306269f, 0.06889679f, 
    0.03467372f, 0.15307035f, -0.04070918f, -0.33662039f, -0.21387090f, -0.20896164f, -0.00883819f, 0.05242271f, 
    0.02448388f, -0.05136444f, 0.08519844f, 0.08793224f, -0.21156669f, 0.09893703f, 0.19196396f, 0.18941823f, 
    0.07992426f, 0.04965644f, 0.26420888f, -0.05829263f, 0.03481038f, 0.08133537f, -0.04092459f, 0.37275401f, 
    0.21707825f, 0.16193087f, 0.27350509f, 0.04714590f, 0.17119861f, 0.05115309f, -0.10639326f, -0.12811708f, 
    -0.06966170f, -0.04963525f, -0.00009196f, -0.19992457f, 0.06462758f, -0.18940958f, -0.09796047f, -0.16232993f, 
    -0.05085448f, 0.08077550f, -0.03713233f, 0.09049326f, 0.02286176f, 0.08803481f, 0.07995936f, -0.06116622f, 
    0.10234099f, -0.20086813f, -0.04206693f, -0.13895074f, 0.18446915f, 0.07945596f, 0.11657807f, -0.02396778f, 
    0.09234883f, -0.05347848f, 0.07567967f, 0.12380290f, 0.08121789f, 0.00250387f, -0.11173612f, -0.03052400f, 
    0.04088862f, -0.04231472f, -0.14979683f, -0.22734447f, 0.11152274f, -0.11434706f, -0.14025038f, -0.09934017f, 
    -0.16982496f, 0.10079388f, -0.03758815f, -0.24540484f, -0.20246752f, -0.13490964f, 0.03132747f, 0.03475446f, 
    -0.10126195f, 0.03249061f, -0.06454292f, -0.04718221f, -0.12726991f, -0.14888372f, 0.09695856f, -0.05481976f, 
    0.05305328f, -0.27289680f, 0.04497984f, -0.03347482f, 0.19772692f, 0.10868499f, -0.02877101f, -0.04377222f, 
    -0.06331652f, 0.17238323f, 0.02310835f, 0.15829957f, -0.00862053f, 0.22859000f, -0.03743247f, -0.16135651f, 
    -0.18530124f, -0.06655409f, 0.03071156f, -0.11565273f, 0.11326017f, -0.02428046f, 0.13715178f, 0.26432991f, 
    0.24597014f, -0.01938060f, 0.07134138f, 0.08338810f, 0.02695880f, 0.06221567f, 0.05132901f, 0.11642062f, 
    0.17185393f, 0.24021818f, -0.26561475f, 0.01989999f, -0.15361461f, -0.07322627f, -0.06748694f, -0.00282394f, 
    -0.09544914f, 0.18492575f, 0.00980031f, -0.01029337f, 0.04991658f, -0.04288753f, 0.10270950f, 0.04076377f, 
    -0.03608573f, -0.01201698f, 0.29531133f, -0.11006642f, 0.02805946f, 0.22888620f, -0.05174953f, 0.09533438f, 
    0.01318506f, -0.03946193f, -0.00536334f, 0.31155783f, 0.32189927f, 0.20083298f, -0.20243989f, -0.02814988f, 
    -0.00022790f, -0.19042383f, 0.05853498f, 0.08689169f, 0.03863271f, -0.04803822f, -0.19684060f, -0.00684156f, 
    -0.01463193f, -0.00897883f, 0.15409091f, 0.11872649f, 0.11093614f, 0.11817446f, -0.05180918f, -0.20934814f, 
    -0.03218556f, -0.04244111f, 0.02511745f, -0.03222515f, 0.00063806f, -0.02654010f, -0.09923226f, 0.07274152f, 
    0.10867084f, 0.07082590f, 0.07519867f, 0.04594301f, 0.25856298f, 0.22982174f, 0.05544346f, 0.14785568f, 
    0.15955742f, 0.05920798f, 0.14038345f, 0.26596037f, 0.01831916f, 0.02734952f, 0.07723506f, 0.05876254f, 
    -0.18177797f, -0.03340319f, 0.06788515f, -0.01294047f, 0.10938933f, 0.02123209f, -0.09521887f, -0.06428382f, 
    -0.16178706f, -0.19579953f, -0.01861365f, -0.09021493f, 0.12147667f, -0.04763941f, 0.20459738f, 0.23285042f, 
    0.07863516f, 0.09778719f, -0.11888112f, -0.07115033f, 0.04026309f, 0.18924993f, 0.22010864f, 0.07549215f, 
    -0.01321601f, -0.09463830f, -0.01974604f, 0.04024121f, 0.18018748f, -0.01875769f, 0.17699912f, 0.24059716f, 
    -0.02838445f, 0.12651522f, 0.00041296f, 0.05462682f, 0.04153301f, 0.03360207f, 0.02415290f, 0.11176713f, 
    -0.12704651f, -0.03665386f, -0.10044194f, -0.14107506f, -0.29844818f, -0.09966429f, -0.08035158f, -0.02874096f, 
    -0.00129991f, -0.00805613f, -0.03266127f, 0.02249082f, 0.12251667f, -0.33307934f, 0.25556257f, -0.06001387f, 
    -0.02157113f, 0.00366890f, 0.17845334f, 0.09067595f, -0.02602031f, -0.12024712f, -0.17434986f, -0.00230492f, 
    -0.09830303f, -0.04100774f, -0.01769149f, 0.11802763f, -0.03019281f, -0.12248673f, 0.05554087f, 0.27078417f, 
    0.24295716f, 0.32046440f, 0.16564688f, -0.06954622f, 0.01079697f, -0.05080599f, -0.00775915f, 0.04334782f, 
    -0.00689875f, -0.24065328f, -0.26651227f, 0.16387708f, -0.01506780f, 0.05651747f, -0.03823569f, 0.18868721f, 
    0.04323518f, -0.07881454f, 0.38743785f, -0.16160485f, -0.06949856f, -0.12518902f, -0.17309432f, -0.18622135f, 
    0.05896612f, -0.07990326f, 0.03764679f, 0.25302604f, 0.04171906f, 0.15902956f, -0.03438111f, -0.11657751f, 
    -0.08608975f, -0.06418651f, 0.09751281f, 0.11877704f, 0.02689791f, 0.14905588f, 0.18791991f, 0.16674353f, 
    0.02793455f, -0.11009980f, -0.01492014f, 0.17269613f, 0.03681330f, 0.00972745f, -0.10652032f, 0.24521844f, 
    0.17998794f, 0.08805522f, 0.01381862f, -0.01235567f, -0.01873176f, 0.10956963f, -0.36756700f, -0.44654420f, 
    0.02718470f, -0.16321994f, -0.09359723f, 0.02433953f, 0.08350559f, 0.00252747f, -0.02910904f, 0.14169259f, 
    -0.27557248f, 0.09298052f, -0.14169228f, -0.08752315f, 0.02719410f, -0.10464671f, 0.01976572f, -0.01089409f, 
    -0.10682288f, -0.48687211f, -0.14656064f, -0.04140226f, 0.16589935f, 0.11304408f, 0.13883272f, -0.12335926f, 
    0.03872970f, 0.14239056f, -0.25265390f, -0.15017511f, -0.00230880f, 0.11667691f, 0.02175626f, 0.02206773f, 
    -0.00746357f, 0.04305454f, 0.28760535f, 0.25868440f, -0.04359610f, -0.20944542f, -0.03258760f, -0.13807485f, 
    -0.02539427f, -0.08924914f, -0.15553203f, 0.04688127f, 0.10028739f, 0.16590209f, -0.19950703f, -0.04402610f, 
    -0.06006400f, -0.05157159f, -0.05685013f, 0.08282486f, 0.19151635f, -0.17465362f, 0.01519384f, -0.09098463f, 
    0.01702438f, -0.25115293f, 0.02391545f, 0.00265011f, 0.06545496f, 0.06295275f, 0.06990588f, 0.05240132f, 
    0.19956048f, 0.04553710f, 0.07025638f, 0.06324796f, 0.01210928f, 0.08952434f, 0.04700297f, 0.00571368f, 
    -0.16965200f, -0.13324434f, 0.05419211f, -0.03290118f, 0.08660245f, -0.04654031f, -0.06002406f, 0.12466077f, 
    -0.20541903f, -0.53001672f, -0.02477410f, 0.19656011f, 0.04034890f, -0.03579911f, -0.03908754f, 0.00771607f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07180547f, 0.26187578f, 0.05681223f, -0.08381674f, 0.11245889f, -0.02110477f, -0.03759621f, 0.10428522f, 
    -0.07728042f, -0.06592413f, -0.00922962f, -0.08629830f, -0.05549930f, 0.27964824f, 0.06484166f, 0.20717527f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18350978f, -0.20305111f, 0.05023974f, -0.09900900f, 0.31680331f, 0.05467859f, -0.14753935f, -0.37684467f, 
    0.01841000f, -0.10733972f, -0.02336134f, 0.31050178f, 0.07947853f, 0.14049910f, 0.02722164f, -0.42972520f, 
    0.13685711f, -0.12622848f, -0.16874932f, -0.28539029f, 0.46289128f, -0.14351390f, -0.32926351f, -0.02187244f, 
    0.14660084f, 0.13068604f, 0.09951536f, -0.05687649f, -0.05768931f, 0.30459818f, -0.20838155f, -0.36163074f, 
    -0.04316533f, -0.18087895f, -0.02942112f, -0.32245389f, 0.34930265f, -0.15411600f, 0.21603969f, 0.14004260f, 
    0.18395191f, -0.09217475f, -0.36710164f, 0.38934356f, 0.11907788f, -0.10589128f, -0.13269626f, 0.34393582f, 
    -0.14298539f, 0.18684404f, -0.12858114f, -0.16605237f, 0.00101434f, 0.06042679f, -0.17580973f, -0.23484348f, 
    0.24658716f, -0.09228910f, -0.11738888f, 0.00379433f, 0.19713491f, -0.11772675f, -0.06440117f, 0.04469731f, 
    0.21351486f, -0.09282998f, 0.03310886f, 0.10604399f, 0.07747152f, -0.21788719f, 0.00607476f, -0.11224149f, 
    0.23784801f, -0.12627384f, -0.22555901f, -0.06178882f, 0.00875303f, -0.27287713f, -0.03128239f, -0.20068638f, 
    -0.26346454f, -0.04248572f, -0.02234163f, -0.00018487f, -0.21463461f, -0.16434783f, -0.28542519f, 0.07544226f, 
    0.07368666f, 0.25263515f, 0.37644193f, -0.07086386f, -0.11974916f, 0.23319899f, -0.08942544f, 0.27916905f, 
    0.36101341f, 0.04555456f, 0.00334249f, -0.01686102f, -0.46452907f, 0.00117875f, -0.25222892f, -0.23651321f, 
    0.03901210f, 0.31083560f, 0.34243694f, 0.04342244f, -0.10357094f, 0.17936194f, -0.05941867f, 0.14637315f, 
    0.05256375f, 0.04716119f, 0.08296277f, -0.28558293f, -0.26866284f, -0.15829144f, -0.25964984f, 0.28409535f, 
    0.08706629f, -0.05825461f, -0.17019999f, 0.18836397f, 0.14227310f, -0.20070904f, 0.26680112f, 0.43361962f, 
    -0.42172670f, -0.24931571f, -0.01355078f, 0.26861697f, -0.06556015f, 0.19340262f, -0.32316378f, -0.12339701f, 
    -0.07267073f, -0.27684104f, -0.11965254f, 0.38381723f, -0.23839727f, 0.24257547f, 0.24555016f, 0.13928474f, 
    0.19719470f, -0.33671445f, -0.22510991f, 0.17204890f, -0.17504257f, 0.07128954f, -0.19675568f, -0.20484288f, 
    0.02931848f, -0.16127138f, 0.09715506f, 0.32373595f, 0.25211897f, 0.23852064f, -0.14984189f, -0.23182420f, 
    -0.19230598f, -0.09428509f, 0.22794697f, 0.09105144f, 0.22507863f, 0.09053069f, 0.14395957f, -0.02236784f, 
    0.03179589f, -0.12551677f, 0.31385395f, -1.29793394f, 0.01821637f, -0.82261258f, -0.11621884f, 0.21346264f, 
    0.11624121f, 0.20886986f, 0.15779112f, -0.04948233f, 0.20090050f, 0.16252548f, -0.36144766f, 0.10825300f, 
    -0.03148516f, 0.17274286f, 0.02046850f, -0.05434836f, 0.02253152f, 0.06928284f, -0.06049031f, 0.08338694f, 
    0.20988804f, 0.12387346f, 0.23343283f, 0.34047011f, -0.50793034f, 0.23219119f, -0.14947595f, 0.17582729f, 
    0.07845829f, 0.08083331f, 0.37996292f, 0.22723021f, -0.18065874f, -0.22025278f, -0.13362178f, 0.11652585f, 
    0.29143071f, 0.27656943f, -0.12618414f, -0.24743837f, -0.16181207f, -0.17199044f, 0.26390916f, 0.13723046f, 
    -0.09906728f, 0.17500381f, -0.42705882f, 0.03569791f, -0.14018165f, -0.14628090f, 0.25013447f, 0.07088652f, 
    -0.00466514f, 0.31738216f, 0.10428181f, -0.09122993f, -0.53913850f, -0.18549955f, 0.11980887f, 0.03243891f, 
    0.21383017f, 0.01452872f, 0.16524255f, 0.09642360f, -0.02698235f, -0.20540839f, 0.32666683f, -0.37944803f, 
    -0.31533679f, -0.05173055f, 0.00068010f, -0.04376374f, -0.45560357f, -0.08935595f, 0.12553392f, -0.24249394f, 
    -0.20959079f, 0.13610257f, 0.16045500f, 0.31881002f, 0.07909017f, 0.32754102f, 0.03354017f, 0.34978485f, 
    -0.19220342f, 0.20597184f, 0.03398234f, -0.17328806f, -0.16553898f, 0.05472377f, -0.11591119f, 0.15478222f, 
    -0.22971866f, 0.09376019f, -0.05342579f, -0.06209609f, -0.06125942f, -0.09524413f, -0.07262954f, -0.07101509f, 
    -0.36198184f, 0.08045242f, 0.12543994f, 0.07118821f, 0.30766422f, -0.08961960f, 0.23245580f, 0.11390119f, 
    0.16793296f, 0.17032206f, 0.21681775f, 0.42537057f, -0.08273433f, -0.24846697f, 0.07421991f, -0.22834067f, 
    -0.02491654f, -0.41903052f, -0.07083136f, 0.31522226f, 0.01398055f, 0.12404206f, 0.40613529f, 0.27133554f, 
    0.19924966f, 0.08368468f, -0.04815163f, 0.32857177f, -0.17307159f, 0.08998054f, -0.29612806f, -0.17853735f, 
    0.26077062f, -0.04682899f, -0.17478254f, 0.22869037f, 0.09135011f, -0.19800836f, -0.06475799f, -0.02591377f, 
    -0.04610986f, -0.12709302f, -0.22231558f, -0.05394204f, -0.05675360f, -0.20572244f, 0.22876841f, 0.03193042f, 
    0.02064765f, 0.07265136f, -0.20709568f, -0.07712457f, 0.35833377f, -0.21794629f, 0.25469828f, -0.04150088f, 
    0.04952510f, -0.11198763f, -0.07638250f, 0.49533626f, -0.12791291f, -0.10604300f, 0.07780518f, -0.00060853f, 
    0.26143458f, -0.11607706f, -0.22416148f, -0.55060291f, 0.02765330f, 0.19328606f, -0.01588535f, -0.06472672f, 
    0.00789995f, 0.19504750f, 0.11625825f, -0.02514271f, 0.03318863f, -0.21747322f, 0.43081346f, -0.02097580f, 
    0.40185076f, 0.00399523f, 0.15004821f, 0.17491972f, 0.01806597f, -0.03656629f, 0.34228018f, -0.36380839f, 
    0.09740662f, 0.18156151f, -0.51750147f, 0.30415574f, -0.03458114f, -0.17070590f, 0.05110001f, 0.31721246f, 
    -0.10510632f, -0.44700068f, -0.14507595f, -0.12608770f, -0.06762531f, -0.22396375f, -0.34750283f, -0.13937019f, 
    0.21515858f, -0.28322107f, -0.23534267f, 0.28777021f, -0.14138052f, 0.22302264f, 0.24902691f, -0.22146338f, 
    -0.37020990f, 0.01812620f, 0.23023757f, 0.09477589f, 0.31096068f, 0.01759829f, -0.14116988f, 0.18070027f, 
    0.14827777f, 0.05085161f, 0.01213684f, -0.04182365f, 0.17541951f, 0.22096133f, 0.07949438f, -0.48576441f, 
    0.00409387f, -0.65174806f, 0.01905581f, -0.02282027f, 0.31121895f, 0.22268981f, -0.11537898f, 0.11289045f, 
    -0.18074268f, 0.17786083f, -0.31612012f, 0.35845238f, 0.09300297f, 0.02363972f, -0.10386776f, -0.01398323f, 
    -0.43054226f, 0.33948323f, -0.09850589f, -0.15293042f, -0.25431454f, -0.18923320f, 0.47452813f, -0.12891659f, 
    0.08681858f, -0.10726377f, 0.15664169f, 0.03404899f, 0.11424493f, 0.14528574f, 0.13702860f, -0.08442774f, 
    -0.06740597f, 0.36207500f, 0.22430697f, -0.29209870f, 0.16267113f, 0.15437046f, -0.60618132f, 0.25317895f, 
    -0.16083695f, -0.07235292f, 0.06589445f, 0.04633383f, -0.04366513f, 0.24035910f, -0.27361372f, 0.13212699f, 
    0.21358269f, 0.49434787f, 0.11228688f, -0.02746019f, -0.11038932f, 0.02965751f, 0.05254994f, -0.25351164f, 
    0.01180778f, -0.00040922f, -0.21350954f, -0.40580606f, -0.04738039f, 0.05651865f, 0.18008763f, 0.28757986f, 
    -0.04633547f, 0.33852670f, 0.16069175f, -0.02987669f, -0.10057998f, 0.11784238f, 0.38583815f, -0.17109101f, 
    -0.07394244f, 0.28846350f, 0.08940114f, 0.07107868f, 0.16315167f, -0.08907134f, 0.00980337f, 0.11993848f, 
    0.28132236f, 0.58724529f, 0.11999176f, 0.08513431f, 0.36379513f, -0.10758315f, -0.04659225f, -0.26191527f, 
    0.10457960f, -0.06058739f, -0.19369178f, -0.21931136f, 0.08616354f, 0.01659110f, 0.04502007f, -0.41516882f, 
    -0.17692341f, -0.25959098f, -0.13554215f, -0.03938030f, 0.36983961f, -0.08863056f, -0.12710086f, 0.22631292f, 
    0.14583106f, 0.06027613f, -0.00997083f, 0.33504611f, 0.12965606f, -0.28989244f, 0.32899460f, -0.08686706f, 
    0.38971093f, 0.36706224f, 0.15989353f, -0.14185786f, 0.04068199f, 0.02681745f, -0.14984138f, 0.09091450f, 
    -0.06601621f, -0.16872269f, -0.29983941f, 0.01071800f, -0.01720046f, 0.02188718f, -0.20961742f, 0.36316729f, 
    0.12394956f, -0.36365360f, -0.19972524f, -0.55484450f, -0.48285010f, 0.11169638f, 0.37461218f, -0.48534885f, 
    -0.01771402f, 0.02321926f, -0.25757161f, -0.03794487f, 0.01349720f, -0.09879612f, 0.15812054f, -0.22350773f, 
    0.10334969f, -0.18428254f, -0.00173905f, -0.29907978f, 0.23022942f, -0.09433266f, 0.13951246f, 0.28803265f, 
    -0.09176850f, -0.02383842f, -0.16758561f, 0.32102245f, 0.08638893f, -0.24227773f, 0.22637361f, 0.14875633f, 
    -0.08603584f, -0.60563654f, 0.01228166f, -0.08239482f, -0.07466840f, 0.15503906f, 0.21729231f, 0.33691922f, 
    -0.21288520f, -0.21733251f, 0.00622894f, 0.00896063f, -0.11579186f, 0.37133020f, -0.20123687f, 0.09235252f, 
    -0.40514383f, 0.20705679f, 0.13585787f, -0.02417856f, -0.22835913f, -0.06493737f, 0.01160795f, 0.34471783f, 
    0.21601665f, 0.19959670f, 0.12349133f, -0.02908111f, -0.06723674f, 0.02166889f, 0.13378125f, -0.12451207f, 
    -0.34882507f, 0.28522187f, 0.10008536f, 0.11200669f, 0.31704706f, 0.05384334f, -0.04905065f, -0.22148578f, 
    0.17637356f, 0.08179164f, 0.01687674f, -0.09801084f, -0.20080779f, 0.09418529f, 0.19806360f, 0.26328671f, 
    -0.01270163f, 0.22496961f, -0.01896865f, -0.38058919f, 0.22153667f, -0.01019476f, -0.42933983f, -0.35807022f, 
    0.21911681f, 0.26926842f, 0.36199015f, 0.07922145f, 0.18404374f, -0.03597561f, -0.03582979f, 0.00233288f, 
    -0.29279235f, 0.12897755f, 0.04014490f, 0.03616148f, 0.16595030f, 0.14811189f, 0.00399343f, 0.09947214f, 
    -0.20567724f, -0.17846969f, -0.15502256f, -0.25642833f, -0.17756818f, 0.03339223f, 0.28283256f, -0.45318201f, 
    0.09402865f, -0.18877403f, 0.01904911f, -0.31805921f, -0.37194142f, -0.21248844f, 0.49632823f, -0.02827434f, 
    0.12072539f, 0.14403263f, -0.18025172f, 0.32841524f, 0.01239511f, 0.23765808f, -0.23635907f, -0.45368487f, 
    0.02878968f, -0.00963758f, -0.00278401f, 0.03508625f, 0.42173398f, -0.21375045f, 0.56728834f, 0.01523581f, 
    -0.15606786f, 0.15446520f, 0.21728799f, -0.02288218f, -0.15846486f, 0.02333775f, -0.04134859f, -0.45598069f, 
    -0.22539005f, -0.15495983f, -0.02575180f, 0.09529927f, 0.17335886f, 0.18535918f, 0.01092920f, -0.24983326f, 
    -0.04130411f, -0.19123203f, -0.18900180f, -0.22246405f, -0.16699883f, -0.23691165f, -0.22207227f, 0.14345098f, 
    0.06444527f, 0.08983075f, -0.23110582f, -0.21556142f, 0.01967551f, -0.05503373f, -0.35604218f, 0.11925235f, 
    -0.05905369f, -0.15331772f, -0.01724021f, -0.03955843f, -0.16316979f, 0.00446016f, 0.20600383f, -0.49623612f, 
    -0.30817688f, -0.40573150f, -0.04674977f, 0.09624835f, 0.15144119f, 0.11703587f, -0.49723330f, 0.04862373f, 
    -0.17501369f, -0.09401875f, 0.01302654f, 0.14698823f, -0.16829273f, 0.27946812f, 0.06561483f, 0.03256610f, 
    -0.16493750f, 0.35600629f, -0.07050528f, 0.22036959f, 0.25007665f, -0.16735967f, -0.12297080f, -0.01879639f, 
    0.13176835f, -0.14063090f, -0.22465277f, 0.10798133f, -0.04357897f, 0.09291884f, -0.07164635f, -0.13535069f, 
    0.10158404f, -0.33036435f, -0.18453851f, -0.13861102f, -0.04552691f, 0.14427289f, 0.25338751f, 0.06063343f, 
    -0.19826472f, -0.12195921f, 0.27734223f, -0.24560696f, -0.03738329f, -0.77644366f, -0.21193942f, -0.34878102f, 
    -0.35509232f, -0.23922192f, -0.03878969f, -0.17261387f, 0.15568593f, 0.26191032f, 0.38148916f, 0.02746756f, 
    -0.00648832f, -0.19307151f, -0.12197083f, -0.32050416f, 0.02144158f, 0.16452430f, 0.31786042f, 0.12972888f, 
    0.29384831f, 0.24568331f, -0.05480137f, 0.14323856f, -0.20759796f, 0.12845469f, -0.43787646f, 0.24048580f, 
    0.22623116f, -0.11006834f, 0.00222745f, -0.08169847f, -0.09438879f, 0.26406386f, -0.20949268f, -0.16978148f, 
    -0.03616126f, 0.52403218f, -0.25697249f, 0.35599810f, 0.45930511f, -0.09892317f, -0.15647952f, -0.21613678f, 
    0.07593557f, -0.01798968f, -0.01497717f, -0.02412352f, 0.01449393f, 0.16922827f, -0.12869890f, -0.35696951f, 
    -0.23736075f, -0.10443100f, -0.01683864f, 0.00112718f, -0.15757172f, 0.24645191f, -0.25224590f, 0.05635173f, 
    -0.17148292f, 0.08442044f, -0.01767796f, 0.25794899f, -0.09725642f, -0.09009999f, -0.20946944f, 0.03254100f, 
    -0.00213432f, 0.33391628f, -0.03485835f, 0.13238937f, -0.29232395f, -0.20640278f, 0.31138217f, 0.29719454f, 
    0.18787058f, 0.17618333f, -0.21522817f, -0.25771740f, -0.15114263f, 0.01235266f, 0.18354337f, -0.05163637f, 
    -0.07527403f, -0.31268713f, -0.02944225f, -0.35797873f, 0.05791685f, 0.08450010f, -0.44302925f, -0.10465816f, 
    -0.16587412f, 0.07357897f, -0.09789260f, 0.38212031f, -0.18036075f, 0.18014118f, 0.01599488f, -0.05695595f, 
    0.38720623f, 0.34203249f, -0.05939122f, -0.01866232f, 0.29334724f, -0.22336611f, -0.27296472f, -0.19118504f, 
    0.18793462f, 0.22743841f, -0.44808444f, -0.21426302f, 0.02675808f, 0.21298075f, -0.06272577f, 0.17833121f, 
    -0.10254021f, -0.08466545f, -0.05695630f, 0.11892973f, 0.03957821f, -0.17506269f, 0.03261416f, -0.25672492f, 
    -0.00434494f, 0.20767242f, -0.05982442f, 0.50085062f, 0.16970930f, 0.21061325f, -0.12428935f, 0.22244014f, 
    0.24016231f, -0.04145675f, 0.01630614f, -0.36097777f, 0.36413792f, 0.22837220f, -0.41190553f, 0.11703675f, 
    0.07384769f, 0.02173797f, 0.11284320f, -0.12817934f, 0.14355265f, 0.08349756f, 0.18888776f, -0.53339690f, 
    0.29832089f, 0.31467947f, -0.16370253f, -0.06621948f, 0.10999661f, 0.03990972f, -0.16001399f, -0.12094969f, 
    -0.04961845f, -0.04861565f, 0.20978104f, -0.31671682f, -0.10214018f, 0.00335442f, 0.04326976f, -0.11413883f, 
    0.34478059f, -0.14917608f, -0.20388849f, 0.13456537f, -0.40647197f, -0.16999890f, 0.01506322f, -0.12681617f, 
    0.14377925f, 0.24697867f, -0.16962965f, -0.02423555f, -0.23132849f, 0.40683919f, -0.08738343f, 0.25425166f, 
    0.04011830f, -0.24782898f, 0.12677777f, -0.25639510f, 0.02720167f, -0.12597498f, 0.17938925f, -0.04194817f, 
    -0.04661319f, -0.03962592f, 0.26482713f, -0.34107354f, 0.04029331f, 0.31907019f, -0.14146498f, 0.17308477f, 
    -0.16568820f, -0.24369569f, 0.11084580f, 0.06273086f, 0.19864216f, 0.01251191f, -0.17153403f, -0.55692011f, 
    0.07242879f, -0.00240860f, 0.31226721f, 0.44695750f, 0.09956117f, 0.16470765f, -0.28212142f, -0.51052392f, 
    0.25903699f, 0.11591379f, -0.09424335f, 0.27801022f, 0.30024219f, 0.09070948f, 0.13303317f, 0.17715785f, 
    0.08711615f, 0.28129995f, -0.25755194f, 0.03510181f, -0.13438466f, -0.02719066f, -0.10871895f, 0.00648903f, 
    0.13444142f, -0.35650638f, -0.21224004f, -0.14665505f, -0.26855266f, 0.09212184f, 0.44925135f, 0.19946957f, 
    0.06615087f, -0.15134393f, 0.10941838f, 0.25661018f, -0.16293718f, 0.13761537f, -0.02774753f, -0.45969433f, 
    0.50511533f, -0.02054767f, 0.11021549f, -0.24107499f, -0.06607802f, -0.16448052f, -0.06933947f, -0.29261115f, 
    -0.18691337f, 0.22611362f, -0.17675251f, -0.16527437f, -0.05127776f, -0.08092817f, 0.31926313f, 0.23636630f, 
    -0.30568194f, 0.15087017f, 0.09367298f, -0.26981208f, 0.43359718f, -0.19236425f, 0.76481372f, 0.10073814f, 
    0.08402017f, -0.07920603f, -0.25399053f, -0.35215077f, 0.03787325f, 0.21470045f, 0.03143149f, -0.22605914f, 
    -0.04930104f, -0.23773971f, -0.00062034f, -0.06241467f, -0.13708580f, -0.11902442f, 0.41021666f, 0.25033960f, 
    0.07734188f, -0.13296078f, -0.19119406f, 0.32984596f, 0.07254059f, -0.04511498f, 0.21059988f, 0.41671103f, 
    -0.21199077f, 0.36577263f, 0.13184124f, -0.38978192f, -0.26329607f, -0.02304749f, 0.08613778f, -0.00551028f, 
    0.15466300f, 0.10899980f, 0.09180856f, -0.14104588f, 0.24248388f, 0.16679007f, 0.28333914f, -0.40099084f, 
    -0.12188710f, 0.27265844f, 0.11263279f, 0.04853093f, 0.06264988f, 0.23522474f, 0.55854791f, 0.01209714f, 
    0.03099918f, 0.21138616f, -0.15624875f, 0.19289339f, -0.23424393f, 0.25984836f, -0.17182229f, -0.59231764f, 
    0.38850355f, 0.33514109f, 0.06304776f, -0.05800748f, 0.21696661f, -0.16494270f, -0.09684714f, 0.01649112f, 
    -0.21428059f, -0.12018278f, -0.10714567f, -0.27279902f, -0.19549604f, 0.23798978f, -0.10205090f, -0.00388917f, 
    -0.22570361f, 0.61293310f, -0.04022059f, 0.04468069f, 0.10106076f, 0.11745149f, -0.39611390f, -0.12031063f, 
    -0.05731100f, 0.09805684f, -0.07867430f, 0.01973754f, -0.17892475f, 0.22851926f, -0.07050516f, -0.01291153f, 
    0.29349074f, 0.66552645f, 0.14273958f, 0.23027930f, 0.14565694f, -0.16956089f, 0.04073598f, -0.56142861f, 
    -0.06820258f, -0.01073952f, -0.26010692f, -0.35572487f, 0.16111310f, 0.00352019f, 0.21385066f, 0.26589319f, 
    -0.21818176f, 0.12969510f, 0.13943544f, 0.01086002f, -0.39620662f, -0.15620300f, -0.27176562f, 0.18689486f, 
    0.08496862f, -0.01842065f, 0.04376360f, -0.12037501f, -0.08047996f, 0.10999111f, 0.18951999f, -0.08654828f, 
    0.44554913f, -0.23591277f, -0.10223547f, -0.20987733f, -0.15755393f, 0.07687894f, 0.06962371f, -0.13560857f, 
    -0.16975465f, 0.14406638f, 0.27885419f, -0.07662980f, 0.02232999f, 0.24711595f, -0.17120597f, 0.44778046f, 
    0.26849312f, 0.30704051f, 0.08134970f, -0.49331978f, -0.25425673f, 0.12537642f, -0.11182327f, 0.16965228f, 
    0.20528498f, -0.19884774f, -0.18291692f, -0.14581390f, 0.09668601f, 0.15278944f, 0.33046448f, -0.46444789f, 
    0.20688012f, 0.21265396f, 0.14180939f, 0.07928067f, 0.09024814f, -0.01876530f, 0.07755093f, 0.15529810f, 
    0.20968696f, 0.05713669f, -0.27071485f, -0.46356604f, -0.20402712f, 0.01587545f, 0.25590089f, -0.41082427f, 
    0.25324073f, 0.38896149f, 0.14004576f, -0.12213823f, 0.15675975f, 0.08655960f, 0.00978375f, -0.07951557f, 
    0.10591312f, 0.09308967f, -0.06707693f, -0.31750673f, -0.15824845f, 0.09973098f, 0.04218525f, -0.35436875f, 
    0.25444695f, -0.16718231f, -0.12608635f, 0.32777184f, 0.12107133f, 0.10248233f, -0.09486768f, -0.24680033f, 
    0.22458979f, -0.17571644f, 0.02283758f, -0.03341924f, -0.19232512f, 0.32098174f, -0.34013286f, -0.53499967f, 
    -0.03074021f, -0.11420561f, 0.07846522f, 0.28343645f, 0.10295184f, 0.22106105f, 0.49753219f, -0.31200936f, 
    0.00225212f, 0.07716834f, 0.26541245f, 0.11955928f, -0.17061649f, -0.07093605f, -0.05431849f, 0.44714388f, 
    -0.14507395f, 0.24470785f, -0.02181727f, -0.14041027f, -0.23814249f, -0.19592208f, 0.21474281f, -0.22062138f, 
    -0.08894038f, 0.21795228f, 0.04101515f, -0.08578777f, -0.06155911f, -0.02928603f, -0.06011203f, -0.20853662f, 
    -0.08997715f, -0.13135600f, 0.03920707f, 0.37423405f, 0.16841666f, -0.20623702f, -0.37649024f, 0.42661378f, 
    -0.07174438f, 0.10882801f, -0.04593823f, 0.08619230f, -0.14358619f, -0.11072995f, -0.11304343f, -0.00724248f, 
    0.22489141f, -0.09536090f, 0.14719029f, -0.20312391f, -0.56378001f, 0.18318480f, 0.23782448f, 0.02039281f, 
    -0.11834303f, 0.17376783f, -0.18271099f, 0.11537574f, -0.20908186f, 0.29486635f, 0.05459920f, -0.27556875f, 
    -0.02245602f, 0.26929805f, 0.18544431f, -0.05135747f, 0.12890700f, 0.01673277f, -0.19615206f, -0.02453206f, 
    -0.23721541f, 0.11466435f, -0.12435126f, 0.15658644f, 0.19390255f, -0.09974019f, 0.35051727f, 0.40591228f, 
    0.03650123f, 0.16998097f, 0.15889876f, 0.00261145f, -0.30474019f, 0.04430431f, 0.08127233f, -0.09020682f, 
    0.06014926f, -0.09032458f, 0.19692381f, 0.30775678f, 0.03203528f, -0.18292235f, -0.00351414f, 0.12243368f, 
    -0.31515828f, 0.38940766f, -0.24173702f, 0.09256421f, 0.22698556f, -0.06258837f, -0.22237782f, -0.32455534f, 
    0.04257107f, -0.14014296f, -0.07050765f, 0.03642846f, 0.17650753f, 0.12127298f, 0.09816908f, 0.03865468f, 
    0.28530097f, 0.01022559f, -0.18323188f, 0.12706010f, 0.12731408f, 0.03031216f, 0.24296348f, 0.09813689f, 
    0.15813345f, 0.01914275f, 0.00497080f, -0.23897025f, 0.13628754f, -0.13276654f, 0.16911632f, 0.45387957f, 
    0.07424636f, -0.31462124f, 0.13357770f, 0.19006948f, 0.00820078f, -0.22661093f, 0.59820008f, 0.26761153f, 
    0.24941695f, -0.12507161f, -0.38759086f, 0.13255124f, 0.16159718f, 0.05028030f, -0.20768306f, 0.00465995f, 
    -0.06583825f, -0.97313160f, -0.04349157f, -0.23510325f, 0.21909633f, 0.13775221f, -0.08012930f, -0.01339526f, 
    -0.15547940f, -0.05055603f, -0.27621064f, 0.43734625f, -0.14134955f, 0.00881849f, -0.10166478f, 0.40740287f, 
    0.04471648f, -0.12536027f, 0.11014668f, -0.07215548f, -0.15560041f, 0.00661481f, -0.21058404f, -0.12280875f, 
    0.22615618f, -0.03246415f, -0.08493674f, -0.02889976f, 0.18374650f, 0.06347010f, -0.20513006f, 0.22014388f, 
    0.25520128f, 0.44094643f, -0.13488796f, 0.32145569f, -0.10045581f, 0.02522405f, -0.43052500f, -0.08836075f, 
    -0.14585762f, -0.12472042f, 0.07405102f, -0.16098581f, 0.18714800f, 0.30786961f, -0.29551113f, -0.13929103f, 
    0.29506406f, 0.20264229f, -0.07290654f, 0.13171561f, 0.00509134f, 0.20004924f, -0.11525168f, 0.01337986f, 
    -0.19236694f, 0.08411335f, -0.11477239f, 0.01173277f, -0.23662871f, -0.01646655f, -0.09718949f, 0.09857918f, 
    0.24359629f, -0.05238064f, 0.24566594f, -0.01768469f, 0.23245077f, -0.02244106f, -0.18760194f, -0.32651305f, 
    0.11896157f, 0.00282710f, -0.20384470f, -0.28137425f, 0.20337248f, 0.27837119f, -0.00611991f, 0.22324336f, 
    -0.10793768f, -0.08165612f, 0.09546240f, -0.02130617f, 0.19115056f, -0.07038428f, 0.54423815f, 0.22271782f, 
    -0.22113594f, 0.28164220f, -0.44104487f, 0.09932851f, -0.01387325f, 0.10404845f, -0.28272635f, 0.30984250f, 
    0.27419943f, 0.11445951f, -0.10584124f, 0.02414972f, -0.23020434f, 0.20664144f, -0.32250598f, 0.39370719f, 
    0.00665493f, 0.20931998f, 0.24386711f, -0.21995440f, -0.12374032f, -0.10336492f, -0.09403922f, -0.24275796f, 
    -0.25089100f, 0.33915472f, 0.23829909f, -0.00783654f, 0.26758522f, 0.00894420f, 0.34998345f, -0.14341380f, 
    -0.05568108f, -0.19866581f, -0.09013634f, 0.25515097f, -0.06803755f, 0.07094717f, -0.28680512f, 0.21709351f, 
    -0.25466645f, 0.12729685f, -0.13017917f, 0.13873033f, -0.41047925f, -0.20396551f, 0.51295203f, -0.10207675f, 
    0.11605459f, -0.23697460f, 0.32049599f, 0.08335284f, -0.24331829f, 0.09617383f, -0.07883790f, -0.24870025f, 
    -0.20945911f, -0.27191076f, -0.16350770f, 0.19733047f, 0.01895918f, 0.09725735f, -0.25975335f, -0.10302597f, 
    0.21012747f, -0.24856433f, -0.16347800f, 0.03598091f, -0.09847686f, -0.28828689f, 0.07694585f, -0.14894509f, 
    0.14891022f, 0.37822536f, -0.13678741f, -0.25165880f, 0.20567837f, 0.16989890f, -0.25620469f, 0.15184294f, 
    -0.14697511f, 0.03297003f, -0.04728333f, -0.24174152f, -0.07339172f, 0.22468702f, -0.00029777f, -0.18146692f, 
    0.28215858f, -0.32463518f, -0.14409447f, -0.23549043f, -0.03821204f, -0.18532935f, 0.13970007f, -0.70971918f, 
    -0.13438496f, -0.16502863f, -0.25582394f, 0.39208341f, 0.03839409f, -0.18121992f, -0.17556188f, -0.20966293f, 
    0.11702186f, 0.40874904f, -0.18217710f, -0.23425651f, -0.15096921f, 0.11145312f, -0.35965446f, 0.16916792f, 
    -0.16179767f, 0.12097955f, -0.12966414f, 0.15892039f, -0.12448427f, -0.01348861f, 0.27596742f, -0.45603743f, 
    -0.22479282f, -0.11569507f, 0.13658805f, 0.22684698f, -0.32736918f, -0.01719400f, -0.16804342f, -0.26024759f, 
    -0.21101999f, 0.12152579f, 0.25240302f, 0.00156649f, -0.13888906f, -0.02062509f, 0.22009045f, 0.17606206f, 
    0.25554359f, -0.16216163f, 0.01738387f, 0.22927508f, -0.22874036f, -0.14691865f, -0.60863751f, -0.33713168f, 
    -0.11449683f, -0.11774361f, -0.01191243f, -0.11118936f, -0.23021764f, 0.22820836f, 0.06325176f, 0.30115554f, 
    0.26491132f, -0.03682839f, -0.06703356f, -0.46737459f, -0.24202755f, 0.11205725f, -0.26738846f, 0.03406323f, 
    -0.06530678f, 0.01347292f, 0.36483377f, -0.16304293f, 0.21587917f, 0.06665726f, 0.25017750f, -0.38374090f, 
    0.21705580f, 0.26411885f, 0.14365973f, -0.10946056f, -0.54801017f, -0.15517938f, -0.01713431f, -0.35211873f, 
    0.01088259f, -0.01734576f, -0.01160340f, 0.17188407f, 0.18695247f, 0.31326991f, 0.16276120f, -0.39981371f, 
    -0.17148410f, -0.21897782f, -0.23088729f, 0.02475024f, 0.31443214f, 0.16823961f, -0.21612352f, -0.23972829f, 
    -0.04025543f, -0.17973046f, 0.31994790f, -0.16303702f, -0.01940569f, 0.32019627f, 0.09202439f, -0.53236222f, 
    -0.19413689f, -0.05797815f, -0.05090523f, -0.19958943f, -0.21447703f, 0.04825646f, 0.03014866f, -0.04896003f, 
    0.16057000f, -0.02099797f, -0.22723073f, 0.00779146f, 0.16824308f, -0.16151083f, -0.07025346f, -0.08255363f, 
    0.08279902f, -0.17224127f, 0.14561583f, 0.05872786f, -0.55530703f, 0.04748926f, 0.29697502f, -0.30497786f, 
    -0.06603971f, -0.01901511f, 0.25009423f, 0.17774147f, -0.01393388f, 0.22422315f, 0.08978455f, 0.11251435f, 
    0.31090277f, 0.08307265f, -0.06092173f, 0.35845447f, -0.50996792f, -0.00375830f, 0.26928198f, -0.11219294f, 
    0.07799327f, 0.13607520f, -0.09972788f, -0.24945982f, 0.13618150f, 0.27880132f, -0.24941406f, -0.20438538f, 
    0.02552584f, -0.05011275f, -0.13968402f, -0.12207589f, -0.53752512f, -0.08798835f, 0.12062083f, -0.29871956f, 
    -0.00921303f, 0.02538045f, -0.38942802f, 0.14328133f, 0.21539196f, -0.02349431f, 0.29001731f, -0.03961799f, 
    0.46029684f, -0.05091455f, 0.09873218f, -0.40240821f, -0.27338210f, 0.02366031f, 0.32196894f, 0.27307850f, 
    0.22772813f, 0.06428353f, 0.03565050f, -0.36100361f, 0.05322276f, 0.01512397f, 0.10260655f, -0.17969267f, 
    -0.34392834f, 0.32855424f, -0.15871462f, 0.03715961f, -0.33547240f, -0.11273763f, -0.43781987f, -0.11515424f, 
    0.20276497f, 0.12775280f, -0.03152390f, 0.21076149f, -0.11664540f, 0.04509195f, 0.25510538f, 0.21627374f, 
    -0.33079639f, 0.36970448f, 0.02827862f, 0.27704111f, -0.07854262f, -0.13495339f, -0.27208191f, -0.01733984f, 
    0.17072256f, -0.22072525f, 0.23312986f, -0.23533759f, 0.18976606f, 0.26848713f, 0.11331612f, -0.26897797f, 
    0.04491898f, -0.24071744f, 0.04099142f, -0.28535709f, -0.41662917f, -0.06444093f, -0.11408344f, -0.21857177f, 
    0.03338665f, -0.17956033f, 0.12243466f, 0.29566133f, 0.24711150f, 0.16558662f, 0.21632674f, -0.07856205f, 
    0.23323268f, 0.39734364f, -0.09169725f, -0.24329016f, -0.12938286f, -0.07554689f, 0.05485367f, 0.19177821f, 
    -0.24115239f, -0.11990600f, 0.16679612f, 0.01706448f, 0.10535439f, 0.14749612f, -0.28484830f, 0.35771513f, 
    0.17218217f, -0.06597895f, -0.00852710f, 0.13159625f, 0.03496950f, 0.19466515f, -0.13688707f, -0.13850936f, 
    0.03288528f, -0.07276933f, -0.57227010f, 0.30610403f, -0.11965857f, -0.14407839f, 0.19683349f, 0.28432944f, 
    0.42303234f, -0.45959809f, -0.06381717f, -0.08088861f, -0.01507869f, -0.17984903f, 0.47377509f, 0.08051749f, 
    -0.00613090f, 0.20079866f, 0.00274893f, -0.03621900f, 0.06467354f, 0.13537264f, -0.11923593f, -0.48999658f, 
    0.14510064f, 0.39539450f, 0.10026817f, -0.08119188f, 0.27753440f, -0.04855061f, 0.00287049f, -0.02900525f, 
    0.15211280f, 0.20299265f, -0.13709173f, 0.13548960f, -0.05564258f, -0.26943687f, 0.19982801f, 0.10156702f, 
    -0.17200789f, 0.43947724f, -0.18262832f, -0.12511383f, 0.15407301f, 0.18088891f, -0.36003950f, -0.14998503f, 
    0.11737490f, -0.14635128f, 0.03232116f, -0.07825866f, -0.16813558f, 0.30480585f, -0.04744405f, -0.01725147f, 
    0.02192341f, -0.20792611f, -0.10336939f, 0.11845507f, -0.06370508f, 0.07280320f, -0.28895983f, 0.12004998f, 
    0.24691027f, 0.23304352f, -0.08815271f, -0.60123861f, -0.23703462f, -0.35528371f, -0.16081476f, 0.47295696f, 
    -0.05590646f, 0.33416504f, 0.07004104f, -0.26081818f, 0.08482370f, 0.25429398f, -0.55092829f, -0.47951707f, 
    -0.05931966f, 0.06711961f, 0.17536677f, -0.04853459f, 0.22513615f, 0.29372874f, 0.17729847f, -0.22334175f, 
    0.00500170f, 0.32739392f, 0.14099795f, -0.28691500f, -0.18393461f, -0.22891983f, -0.22360247f, -0.11513491f, 
    0.22843882f, -0.10857739f, -0.39102060f, 0.07962847f, -0.07958677f, -0.08600211f, 0.49890438f, 0.05444697f, 
    -0.12796745f, 0.13542256f, -0.02785388f, -0.25831282f, 0.02364028f, -0.21742940f, 0.28858489f, 0.18386525f, 
    -0.16428161f, 0.09065886f, -0.21057150f, 0.15048869f, 0.21210900f, -0.09824513f, 0.37425280f, -0.29622272f, 
    0.37695062f, 0.11093003f, -0.14144728f, -0.09007716f, -0.02737640f, -0.12153021f, -0.23648058f, -0.18388593f, 
    -0.19735812f, -0.10758185f, 0.07939839f, -0.29695851f, 0.13931516f, 0.24605511f, -0.00024548f, -0.24528605f, 
    0.17077695f, 0.42203787f, -0.01123065f, 0.03855879f, -0.05805963f, -0.24826296f, -0.33198997f, -0.41785657f, 
    0.19669047f, -0.20654847f, -0.04919677f, 0.00193524f, 0.08384559f, 0.21075742f, -0.18080778f, -0.11186492f, 
    -0.06512267f, 0.46915582f, -0.14765273f, -0.21879682f, 0.47250423f, 0.13040906f, -0.04097444f, -0.10324038f, 
    -0.18869638f, 0.20169309f, -0.15056647f, 0.18092790f, 0.00728357f, -0.13772091f, 0.11056694f, -0.33767211f, 
    0.15614723f, 0.08059190f, 0.10301832f, 0.35687366f, -0.38834217f, 0.15694201f, -0.23827378f, 0.09782051f, 
    0.24409093f, 0.16851597f, -0.01968923f, 0.24149717f, 0.04708720f, -0.18565963f, 0.09469619f, 0.25570747f, 
    0.10093971f, 0.65280783f, 0.17281145f, -0.33714560f, 0.30012292f, 0.21089397f, 0.01059490f, 0.02065727f, 
    0.03870139f, -0.21195337f, -0.08326648f, -0.10292718f, -0.19422485f, 0.21105345f, -0.21112758f, 0.06733754f, 
    -0.28120133f, 0.15308292f, 0.16762258f, 0.03075762f, 0.07501327f, -0.14545442f, 0.33793271f, -0.10790882f, 
    0.18549097f, 0.21053906f, -0.19815397f, 0.30847430f, 0.03254192f, 0.24358627f, -0.14835890f, -0.48682809f, 
    0.35113406f, 0.08234391f, -0.07563951f, -0.41106462f, 0.02094118f, -0.13393228f, 0.10718792f, 0.00458530f, 
    0.14609152f, -0.13375291f, 0.03323774f, -0.21436666f, 0.19609982f, -0.07127591f, 0.16292025f, 0.18892775f, 
    -0.11827526f, 0.05392469f, -0.09673125f, -0.10714246f, -0.23318999f, 0.09585825f, -0.46908718f, 0.43376452f, 
    -0.09790567f, -0.07425856f, -0.17681421f, -0.44761735f, 0.10576186f, 0.00955363f, -0.00600096f, 0.29994649f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07551388f, 0.60358876f, 0.29544932f, 0.12049328f, 0.06304603f, 0.12570252f, 0.07113169f, 0.29936925f, 
    0.13752478f, 0.26206619f, -0.05145892f, -0.32968193f, -0.22421890f, -0.13676468f, 0.38394213f, 0.23564850f, 
    -0.08417464f, 0.07359654f, -0.03173086f, -0.12496221f, -0.56874049f, 0.05293168f, -0.04256529f, -0.09557913f, 
    0.06329746f, -0.38090044f, 0.35229990f, 0.13130601f, 0.43286824f, 0.31078333f, 0.03990890f, -0.07429750f, 
    -0.06286656f, 0.18536520f, -0.25450706f, -0.01121737f, 0.37159348f, -0.14552228f, -0.12766217f, 0.42339939f, 
    -0.40066317f, -0.31093925f, 0.17206335f, 0.27928618f, -0.04544615f, 0.10042121f, 0.01732031f, 0.18259090f, 
    -0.08075868f, -0.04850769f, -0.15382092f, -0.07408939f, 0.10208815f, -0.10635571f, 0.18581621f, -0.12698956f, 
    -0.27608427f, 0.14714716f, 0.48504436f, -0.10305347f, -0.44897288f, -0.02300749f, -0.16832738f, 0.10271687f, 
    -0.13235313f, 0.20514192f, -0.11707928f, -0.15539782f, 0.51718801f, 0.15906182f, 0.51716000f, 0.03829242f, 
    0.22699156f, 0.41854095f, 0.37610242f, 0.29499537f, -0.04978828f, -0.22446412f, -0.25607905f, 0.35397106f, 
    -0.06961204f, 0.18215196f, 0.25354731f, -0.31537139f, 0.19508198f, -0.22175854f, 0.07624526f, 0.03043391f, 
    -0.35417646f, 0.29406971f, 0.19042295f, 0.40422139f, 0.28551501f, -0.26189318f, -0.12733293f, 0.33433858f, 
    -0.21681076f, -0.18984087f, 0.15847981f, -0.04011065f, 0.39869693f, -0.00362957f, -0.04387518f, -0.22158501f, 
    0.30355772f, 0.08859746f, 0.04720723f, 0.29837802f, 0.16639189f, -0.05067689f, 0.27058652f, -0.25289488f, 
    -0.06449049f, 0.00527543f, 0.10473054f, 0.47996891f, 0.34045419f, 0.07310334f, 0.21404237f, 0.32002676f, 
    0.26342973f, 0.50724262f, 0.09071263f, -0.24453090f, 0.29347408f, 0.15752350f, 0.17659101f, 0.11730296f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04146995f, 0.15950811f, -0.21750678f, -0.03353990f, -0.02813322f, -0.10298974f, -0.03128324f, 0.10797025f, 
    -0.14401406f, -0.16192630f, -0.01205926f, -0.03482324f, -0.13869308f, 0.22905122f, 0.24987414f, -0.14688623f, 
    0.00703256f, -0.03702799f, -0.29701495f, 0.03673384f, 0.00962980f, 0.39908022f, -0.05622244f, -0.01860089f, 
    -0.09960754f, -0.31855553f, 0.03126581f, -0.00917175f, 0.11886261f, 0.06721690f, 0.48037913f, 0.00439472f, 
    -0.00311455f, -0.02973352f, 0.05403646f, -0.02812462f, -0.03244841f, -0.05486007f, -0.16395840f, 0.27294520f, 
    -0.01923544f, -0.15197323f, -0.01834427f, 0.44090796f, -0.05371690f, 0.08741000f, 0.01083202f, 0.20285167f, 
    -0.11958664f, -0.14395809f, 0.07705921f, 0.22762720f, 0.05537639f, -0.02215518f, -0.15912612f, 0.10296494f, 
    0.02933013f, -0.12272397f, -0.09147757f, -0.43071303f, -0.11194457f, 0.09309587f, 0.24965732f, 0.34042126f, 
    -0.02773341f, 0.26272035f, 0.03788945f, 0.06586547f, -0.04554833f, 0.07002848f, 0.19141348f, -0.13415654f, 
    0.13911138f, 0.28782898f, 0.08574451f, 0.06245148f, -0.26104629f, 0.05132265f, 0.03717146f, -0.01404516f, 
    0.14265832f, -0.01680383f, 0.11225794f, -0.07706107f, -0.02649920f, -0.47469360f, -0.07960325f, -0.07929157f, 
    -0.08267571f, 0.14668268f, -0.30129683f, 0.14741418f, -0.19253692f, -0.19267371f, -0.07355767f, 0.20867617f, 
    -0.37335923f, 0.29076353f, -0.06870896f, -0.28668737f, 0.24340551f, 0.04861000f, 0.02165845f, -0.08474463f, 
    0.04599422f, -0.04769376f, 0.07774327f, 0.29600611f, 0.07151132f, -0.12550846f, -0.02555966f, -0.04624878f, 
    0.06383193f, 0.02082195f, 0.13242416f, 0.05488105f, 0.21186577f, 0.18640643f, 0.14077038f, 0.20540172f, 
    0.15576865f, -0.07064369f, 0.46860841f, -0.08732922f, 0.09972017f, -0.05812817f, 0.16137543f, 0.30632049f, 
    0.31645411f, 0.01829083f, 0.06154950f, 0.03745258f, -0.05336422f, -0.15270028f, 0.16119073f, -0.02878025f, 
    0.05943650f, 0.29388571f, 0.30599031f, -0.13266329f, 0.09171940f, -0.00266117f, 0.12889454f, 0.07290243f, 
    0.04276448f, 0.07990195f, 0.26051283f, -0.08733536f, -0.01494497f, -0.09791109f, 0.08876944f, 0.14039478f, 
    0.03081824f, 0.25677112f, 0.00140906f, -0.23821430f, -0.27742118f, -0.06141928f, -0.06648246f, 0.01468413f, 
    -0.20140357f, 0.20378946f, -0.05429282f, 0.11466015f, -0.18738727f, -0.33410853f, 0.46406576f, -0.08760146f, 
    0.28711832f, -0.02057661f, -0.05760960f, -0.03323802f, -0.04692103f, -0.02537281f, 0.39619938f, -0.15716316f, 
    -0.03896859f, -0.03928049f, 0.07136820f, -0.22051471f, 0.20312092f, -0.21231906f, 0.21228039f, 0.06073213f, 
    -0.17660397f, 0.13544470f, -0.06499270f, 0.66425657f, -0.19298218f, 0.26809269f, -0.01547235f, -0.02463785f, 
    -0.02671400f, 0.09963992f, 0.17232592f, -0.29770499f, -0.18413001f, -0.42899454f, -0.04150253f, -0.01229968f, 
    0.06487868f, -0.28907061f, -0.11941814f, 0.07575709f, 0.01386000f, 0.07227556f, 0.04273345f, 0.16783085f, 
    -0.10997603f, 0.08327632f, -0.09643628f, -0.32694292f, 0.18888271f, 0.56533355f, 0.04103289f, -0.14022525f, 
    -0.02703383f, 0.03296905f, -0.25340152f, 0.10306987f, -0.11855087f, 0.17191660f, -0.02447146f, -0.11457927f, 
    0.34990677f, 0.03280509f, 0.01421028f, 0.04890529f, 0.03533067f, 0.18128853f, 0.01562673f, 0.04621295f, 
    0.09273075f, 0.08625935f, 0.08389558f, 0.05799361f, 0.07146509f, -0.06442965f, 0.19339222f, -0.10567143f, 
    0.10680094f, 0.16880542f, -0.17890990f, -0.05808083f, -0.21875964f, -0.08171842f, -0.00240225f, 0.13717878f, 
    0.11448889f, -0.10137746f, 0.12079471f, -0.22073339f, -0.05304856f, 0.18368800f, -0.04148207f, 0.10304776f, 
    -0.05691533f, 0.07718570f, -0.19590658f, 0.07615481f, -0.05438603f, -0.04258405f, -0.11100956f, 0.02963853f, 
    0.10777535f, -0.18405171f, 0.00677021f, -0.03019838f, -0.05430459f, 0.08554551f, 0.11819260f, -0.01635393f, 
    0.00650486f, -0.07497860f, -0.08305481f, 0.09493237f, -0.04809976f, -0.08014766f, -0.15152602f, 0.03737929f, 
    0.12621544f, 0.36643538f, 0.19352099f, -0.09333683f, 0.25069916f, 0.00667169f, 0.26790997f, -0.00168266f, 
    -0.17936143f, -0.22853810f, -0.09762734f, -0.02524501f, 0.03930266f, 0.15418772f, -0.06423814f, 0.21155994f, 
    -0.47360736f, -0.02753046f, -0.04268388f, 0.20549172f, 0.15493244f, 0.16733733f, -0.30934227f, 0.33258823f, 
    -0.00709156f, 0.15173128f, -0.02215856f, -0.08479862f, -0.13685849f, 0.02922864f, -0.02077943f, -0.09340859f, 
    -0.02504359f, -0.12506270f, 0.09267905f, -0.06339439f, -0.10565279f, -0.29855958f, -0.08828790f, 0.29708919f, 
    -0.05912238f, 0.27012256f, -0.24497733f, 0.00487081f, 0.38540149f, 0.15404809f, 0.32250664f, -0.34583250f, 
    0.11452667f, 0.15023558f, 0.11804086f, 0.04041952f, 0.08383391f, 0.03795610f, -0.15427238f, -0.06788167f, 
    0.10197793f, -0.05508921f, 0.18493114f, -0.05643084f, -0.15524076f, -0.16113375f, -0.03249279f, 0.17105824f, 
    -0.13887644f, 0.16936883f, 0.02196103f, -0.05687397f, 0.08956835f, -0.05269887f, 0.03355098f, 0.15750161f, 
    -0.46957371f, 0.05441619f, 0.14927515f, 0.23327842f, -0.06667677f, 0.05611493f, 0.24017410f, 0.02181413f, 
    -0.04919850f, -0.02624747f, 0.07778523f, -0.08808174f, 0.13176827f, 0.09720118f, -0.09612748f, -0.18145500f, 
    0.07803953f, -0.20804046f, -0.07522399f, 0.19589184f, 0.20087883f, 0.08937768f, 0.13284068f, 0.17219010f, 
    0.04733166f, -0.03593539f, 0.28572360f, -0.02211377f, -0.05016839f, -0.00120229f, -0.12192328f, 0.14236142f, 
    0.07936235f, 0.27391338f, 0.04465340f, 0.01167249f, 0.05747684f, -0.50226027f, -0.20047605f, -0.03357237f, 
    0.05879166f, -0.10448346f, -0.23374581f, -0.02113995f, -0.37659130f, 0.09808084f, 0.21321012f, -0.00156293f, 
    0.06100520f, 0.00949397f, -0.31089035f, -0.01861980f, -0.00041909f, 0.33489993f, 0.09335843f, 0.01691094f, 
    0.06363276f, -0.21757865f, 0.09459249f, -0.18603148f, 0.21275777f, 0.08617616f, 0.56527478f, 0.10298039f, 
    -0.01555649f, 0.02158174f, 0.01136872f, -0.17478320f, -0.24192445f, 0.03327220f, -0.08467824f, 0.25413880f, 
    -0.20243488f, 0.10324569f, 0.08543607f, 0.55971187f, -0.07875869f, 0.10248552f, -0.00058841f, 0.06125765f, 
    -0.18740699f, 0.26393759f, 0.05429265f, -0.25326747f, 0.09094876f, 0.24186251f, -0.10769317f, 0.31542102f, 
    -0.10511258f, -0.12287957f, -0.08789067f, -0.34957284f, -0.12808020f, -0.02632449f, 0.40639943f, 0.24717002f, 
    -0.03229555f, 0.20249718f, -0.05387286f, 0.00460993f, 0.14414926f, 0.30331925f, 0.03023707f, -0.21327551f, 
    0.22522189f, 0.23780061f, 0.26221469f, 0.08464604f, -0.21804923f, -0.04516936f, -0.08848185f, -0.00287261f, 
    0.04684436f, -0.15915020f, 0.14151946f, -0.04057388f, -0.15998195f, -0.36717835f, -0.05696677f, -0.09540530f, 
    -0.00746435f, 0.15980391f, -0.29105243f, -0.18402398f, -0.08255303f, -0.32835391f, 0.06192767f, 0.18400167f, 
    -0.34462187f, 0.24010754f, -0.14498802f, -0.02489319f, 0.08466255f, 0.08500615f, 0.23887992f, -0.07030310f, 
    -0.13836321f, -0.12792954f, 0.02443689f, 0.11936359f, -0.07704580f, -0.12666251f, -0.01617076f, -0.32918182f, 
    0.19048148f, 0.08286912f, 0.15510012f, 0.09963067f, -0.38420725f, 0.24925026f, 0.26770693f, 0.32226622f, 
    0.24725354f, 0.05628587f, 0.51185530f, -0.27385780f, 0.10609370f, -0.05279517f, 0.20715833f, -0.37378603f, 
    -0.23510511f, 0.08772489f, 0.29368281f, -0.07790741f, 0.06064371f, 0.16093752f, 0.04098449f, -0.08999123f, 
    0.30102417f, 0.15732743f, 0.15853199f, 0.04471369f, -0.05987233f, -0.16990250f, -0.09124807f, 0.28332174f, 
    -0.03891003f, 0.11502539f, 0.10139988f, -0.02590948f, 0.16383603f, -0.25416782f, 0.00079453f, -0.38578853f, 
    -0.00739568f, 0.60037255f, 0.17291112f, -0.16511351f, 0.05156784f, 0.14793500f, -0.19607063f, 0.02526436f, 
    -0.03406347f, -0.26504761f, -0.09881536f, -0.10984498f, 0.01180540f, 0.06671811f, 0.28659692f, 0.08196528f, 
    -0.24557945f, 0.15159774f, -0.03558614f, -0.23781623f, 0.08049027f, 0.04744854f, 0.05557513f, 0.05384262f, 
    -0.05400399f, 0.04969758f, -0.08848891f, 0.14458400f, -0.38945302f, 0.05148512f, 0.37068477f, -0.02601488f, 
    0.04649246f, 0.13965330f, 0.06273234f, 0.19020870f, -0.05746271f, 0.00004190f, -0.16067967f, -0.03636816f, 
    0.05209279f, -0.39609921f, -0.11597960f, -0.04542699f, 0.18483591f, 0.14041018f, 0.17009476f, 0.15540770f, 
    -0.44201392f, -0.03868495f, 0.04608634f, 0.02304308f, 0.04320623f, 0.03556052f, -0.27274218f, -0.48196250f, 
    0.10916566f, 0.16312152f, 0.24376808f, 0.08371254f, -0.07556328f, 0.25484046f, 0.13756189f, 0.00070092f, 
    -0.06028606f, 0.11006635f, 0.17581408f, -0.06178423f, 0.22113326f, 0.28883839f, 0.07267217f, -0.04490894f, 
    -0.34374484f, -0.49123111f, 0.24618600f, 0.22746123f, -0.12384871f, -0.12120695f, -0.04603207f, -0.00704201f, 
    0.14998616f, -0.13106415f, -0.84911925f, -0.06518051f, 0.08220998f, 0.05134901f, -0.22499913f, -0.00898928f, 
    -0.00608462f, -0.54675001f, 0.02061290f, 0.23686384f, 0.26633325f, 0.00063989f, -0.22724697f, -0.03236106f, 
    0.05028386f, -0.18856953f, 0.19179097f, -0.02061134f, 0.05966748f, -0.25179109f, -0.05549792f, -0.35775906f, 
    -0.18497033f, -0.10492286f, -0.66139686f, 0.02159822f, 0.03876870f, -0.19092460f, 0.05659354f, 0.01033603f, 
    -0.16890436f, -0.18892863f, -0.10674435f, -0.04302698f, 0.12154713f, 0.28425890f, 0.31977409f, -0.04167162f, 
    0.03754297f, -0.18700778f, -0.30064690f, -0.15049598f, -0.22523783f, 0.23327157f, -0.00469763f, 0.09929073f, 
    -0.04383161f, -0.33752024f, 0.07147735f, 0.03439740f, 0.28370637f, 0.09721696f, 0.36323553f, -0.20411490f, 
    0.06877622f, 0.12324195f, -0.09332132f, -0.27229568f, -0.03522897f, -0.00411549f, -0.38633165f, 0.06153879f, 
    -0.04803495f, -0.16424087f, -0.05672994f, 0.17447104f, -0.28517267f, 0.09938263f, 0.21222940f, -0.09217869f, 
    0.11652672f, -0.11179405f, 0.06202937f, 0.08871783f, -0.06034325f, 0.02895823f, -0.17455085f, 0.01136175f, 
    0.00845048f, 0.07683998f, 0.06651835f, -0.68265516f, -0.07971389f, 0.02512862f, 0.26852596f, -0.19176759f, 
    -0.11587364f, 0.43538582f, 0.14544784f, 0.05076037f, 0.09726289f, 0.21899462f, 0.06730314f, -0.05386650f, 
    0.38307083f, 0.27879861f, 0.16451055f, -0.06496217f, -0.32598636f, -0.05416120f, -0.14658661f, 0.28613761f, 
    -0.05262325f, -0.03350507f, -0.02565321f, -0.13948464f, -0.21405177f, -0.58408105f, 0.03786552f, 0.01863679f, 
    -0.01725687f, -0.06730463f, -0.64334857f, 0.28880930f, -0.13589053f, -0.32157850f, -0.06793220f, 0.19001500f, 
    -0.45175639f, 0.41934854f, -0.12776540f, -0.24281220f, 0.16957751f, 0.11614469f, -0.30669290f, 0.01250365f, 
    0.01997579f, 0.17065424f, 0.19723974f, 0.41740802f, 0.07111823f, -0.04550585f, 0.06194560f, 0.12697086f, 
    -0.11414357f, 0.17342021f, -0.02520781f, 0.04795012f, -0.14760081f, -0.01703824f, 0.31299236f, 0.17566814f, 
    0.12269235f, 0.15050510f, -0.32518876f, 0.09464570f, 0.16236998f, 0.05940369f, 0.16450474f, 0.06857151f, 
    -0.06083821f, -0.26139784f, -0.03233945f, 0.01147230f, -0.05718306f, -0.03065534f, 0.08309152f, 0.12466590f, 
    0.14124495f, -0.01692318f, -0.30018133f, -0.05144491f, -0.15998420f, -0.06113330f, 0.30302805f, 0.30127001f, 
    -0.02180721f, 0.09108298f, -0.00071567f, -0.03234322f, -0.18126246f, -0.01421302f, -0.32404134f, -0.05856911f, 
    -0.02649595f, -0.62311810f, 0.18529537f, -0.09211440f, 0.22263914f, 0.03920915f, -0.32400528f, -0.08218516f, 
    -0.04811089f, -0.03177571f, -0.01332260f, 0.20751348f, 0.13883817f, 0.03463323f, -0.25636736f, 0.18558148f, 
    0.07326853f, -0.18300492f, 0.00969985f, -0.00966159f, -0.01374555f, -0.01939736f, -0.12340131f, 0.29063088f, 
    -0.17823394f, -0.21142146f, -0.03301274f, 0.17782968f, -0.21834172f, -0.37494659f, -0.01925743f, -0.15926754f, 
    -0.00653897f, -0.00313521f, 0.18494436f, -0.19599994f, -0.11607194f, 0.25371256f, -0.07880475f, 0.18584195f, 
    0.22412007f, 0.21241356f, 0.38885152f, -0.07532813f, -0.03274757f, 0.07837678f, 0.12853232f, -0.06706354f, 
    -0.04970466f, 0.01833281f, -0.03594436f, -0.06179928f, 0.01434078f, 0.03453552f, -0.02922804f, 0.24470994f, 
    0.16250482f, -0.01327876f, 0.08167646f, -0.01735343f, 0.20480616f, -0.90950477f, -0.05969970f, -0.07486238f, 
    -0.06170847f, 0.03166191f, 0.43855554f, -0.09846826f, 0.12121594f, 0.18178204f, 0.08027644f, -0.04237974f, 
    -0.57084560f, -0.10278018f, -0.01574857f, -0.21703139f, 0.09335630f, 0.17154284f, -0.01892456f, 0.06169515f, 
    0.21677113f, -0.02219517f, -0.03099162f, 0.08305641f, -0.01745915f, 0.00632578f, 0.13936861f, 0.10752797f, 
    -0.26721111f, 0.11227942f, 0.04394119f, -0.06991553f, 0.27320907f, -0.25038224f, -0.17343943f, 0.01519067f, 
    -0.12686044f, -0.30566335f, -0.43907526f, -0.06968102f, 0.00056474f, 0.25206518f, 0.18944034f, 0.25312281f, 
    -0.12035027f, 0.17277075f, 0.14558667f, -0.02865802f, -0.07100905f, -0.30924058f, 0.21298176f, 0.21173605f, 
    -0.06629677f, 0.09305910f, 0.07616455f, -0.10404696f, -0.08564526f, 0.16803883f, -0.00813278f, -0.02053671f, 
    -0.04403421f, -0.12441073f, -0.35643288f, 0.06491942f, 0.12351243f, 0.36867276f, 0.23450224f, 0.09050542f, 
    -0.40391591f, -0.37619221f, -0.13911057f, -0.23170079f, 0.17977720f, 0.00056912f, 0.02122858f, -0.00031681f, 
    0.08824941f, -0.02935603f, 0.08254902f, -0.29905882f, -0.35412100f, -0.02539701f, -0.20514056f, -0.26021513f, 
    -0.15774292f, -0.17720415f, 0.08822740f, 0.24185820f, -0.02468801f, -0.10084756f, 0.06315339f, 0.17032035f, 
    -0.17209178f, -0.19151685f, 0.04072747f, -0.11950345f, 0.07072655f, 0.24510758f, 0.05887843f, 0.18783362f, 
    -0.14277270f, 0.00906401f, 0.01109180f, -0.54816049f, -0.09926461f, 0.03152417f, 0.53176278f, -0.03456455f, 
    0.09092917f, -0.26631683f, -0.30079329f, -0.03640166f, -0.04715938f, 0.35641009f, -0.19946918f, 0.16811861f, 
    0.04317672f, -0.00718686f, 0.10425465f, -0.08832118f, 0.01784461f, 0.05188358f, -0.12876691f, 0.04795231f, 
    0.15274292f, -0.01064515f, -0.02749335f, -0.02152899f, -0.14276804f, -0.56642306f, -0.03648240f, -0.10617857f, 
    0.02371748f, 0.27859962f, -0.11504265f, -0.42493182f, -0.02437114f, -0.33362162f, 0.07371832f, -0.06316670f, 
    -0.64565021f, 0.11952920f, 0.12393400f, 0.29387575f, 0.09825832f, 0.15213107f, 0.00632355f, -0.05745023f, 
    -0.03172533f, -0.03182683f, 0.00623823f, 0.03149398f, 0.06170116f, -0.41615373f, 0.12085722f, -0.15579337f, 
    0.20075525f, 0.07746158f, 0.03485763f, -0.12018728f, 0.55228639f, 0.15107083f, 0.27057824f, 0.05738659f, 
    0.09319372f, 0.07149718f, -0.05418941f, 0.09987089f, -0.05840542f, -0.24535052f, 0.15982968f, 0.00608210f, 
    -0.00755696f, 0.01374060f, -0.05564851f, 0.01032764f, -0.06960791f, 0.00794788f, 0.04696428f, -0.04630646f, 
    -0.06631754f, 0.00224321f, 0.06903448f, 0.03253740f, -0.07649928f, -0.00844686f, 0.00480581f, 0.04984640f, 
    -0.00776702f, -0.05135761f, 0.00089377f, -0.08001989f, -0.05360754f, 0.01553830f, -0.08805013f, 0.01962037f, 
    0.03256452f, -0.02715177f, 0.05649734f, -0.04043278f, -0.08301749f, -0.01510914f, -0.09613085f, -0.01883083f, 
    0.07568577f, -0.01986388f, -0.07478082f, -0.10507438f, -0.01962327f, -0.05114151f, -0.02201450f, -0.06101407f, 
    -0.03901331f, -0.01429064f, -0.06264476f, 0.01948494f, -0.08066014f, 0.00924333f, -0.04754468f, 0.00320257f, 
    0.00448833f, -0.04824357f, 0.03406020f, -0.06275678f, 0.03687596f, -0.04502121f, -0.05607059f, -0.08798724f, 
    0.03216285f, -0.05807493f, -0.06185117f, -0.01821090f, -0.09532668f, 0.06179387f, -0.08207059f, -0.03383777f, 
    -0.04205306f, 0.04982454f, 0.03161458f, 0.01927179f, -0.08003653f, -0.05356108f, -0.06663716f, -0.00332351f, 
    -0.05941972f, -0.07944891f, 0.04238648f, -0.11253387f, 0.02865625f, -0.06177204f, -0.05977628f, 0.04269234f, 
    -0.06905235f, 0.05815818f, 0.06727942f, 0.04212451f, 0.03770403f, -0.04188438f, 0.06489660f, 0.01742540f, 
    0.07179434f, -0.04124852f, -0.03517468f, 0.02628119f, -0.00633966f, -0.05359370f, -0.04642603f, -0.03505818f, 
    0.07124560f, -0.00821301f, -0.04650767f, 0.02380183f, -0.00007796f, -0.06718274f, 0.05121581f, 0.02554498f, 
    0.05961962f, -0.00101174f, -0.06546853f, -0.01890126f, -0.07165802f, 0.04454834f, 0.01389454f, -0.03877185f, 
    0.05425018f, 0.01878279f, 0.01526521f, -0.09518406f, -0.06839275f, -0.09963841f, 0.00328887f, 0.00263693f, 
    -0.09226195f, -0.03425494f, 0.01611153f, -0.00015000f, 0.04912204f, -0.01799124f, 0.00215114f, 0.02650050f, 
    -0.01592553f, 0.20280786f, -0.03216490f, 0.08033001f, 0.14408815f, 0.01643589f, 0.07116533f, 0.25289848f, 
    -0.35496685f, 0.20850055f, -0.19282894f, 0.02947195f, 0.08789416f, -0.16428380f, -0.08124541f, -0.17374341f, 
    0.07757086f, 0.01351898f, 0.03812419f, -0.01800102f, -0.42411494f, 0.28682449f, -0.13932148f, -0.03102760f, 
    0.14667562f, -0.62647665f, -0.17963818f, 0.29220912f, 0.13467588f, -0.05783921f, -0.12051491f, -0.07296544f, 
    0.24866398f, -0.09660420f, 0.01735207f, 0.48231456f, 0.08413550f, -0.17139204f, -0.01262856f, -0.11711666f, 
    -0.24459247f, 0.00622682f, -0.06611571f, 0.17534891f, 0.05474301f, -0.12466602f, 0.03329117f, -0.12348590f, 
    0.16163296f, -0.13554911f, -0.08691809f, -0.01412921f, -0.00583233f, 0.30198735f, -0.16588411f, 0.35091010f, 
    0.05313293f, 0.01809281f, 0.20081414f, 0.31413546f, 0.00010696f, 0.15571192f, 0.19413622f, 0.00657130f, 
    -0.16246077f, -0.25717679f, -0.32289854f, 0.18286124f, -0.02249434f, -0.06042404f, -0.02735740f, 0.26737291f, 
    -0.20674261f, 0.17334054f, 0.14517322f, 0.14279298f, -0.16491243f, -0.00042020f, -0.02740930f, -0.05127271f, 
    -0.19578867f, -0.03206482f, -0.09971833f, 0.06776284f, 0.07591967f, -0.21721894f, 0.13109148f, 0.18125758f, 
    0.01529665f, 0.17695376f, -0.02718552f, 0.19519125f, -0.39239460f, -0.00729565f, 0.01101642f, 0.27005231f, 
    -0.29327106f, -0.11429100f, -0.06672706f, 0.03575536f, 0.17647649f, -0.07844418f, 0.27616477f, -0.06232047f, 
    0.06093428f, 0.18698788f, -0.65346128f, 0.27344742f, -0.18079925f, -0.05590357f, -0.09663933f, 0.13224651f, 
    -0.15663628f, 0.27619258f, -0.07517137f, 0.01793496f, -0.43139160f, -0.10599727f, -0.22661887f, -0.11160614f, 
    0.10526879f, 0.02238904f, 0.03625803f, -0.12181173f, -0.00222754f, -0.35598263f, 0.35993320f, 0.23726167f, 
    0.05897158f, 0.12168992f, -0.08608579f, 0.05233901f, 0.11068469f, -0.62101054f, -0.36967319f, -0.08700900f, 
    0.16403486f, -0.06407723f, 0.26380450f, -0.02771728f, -0.57392853f, 0.20883797f, 0.09443324f, -0.20097160f, 
    -0.06478714f, -0.00657020f, -0.12673387f, 0.10734106f, 0.20737430f, 0.17605965f, 0.15817638f, 0.26902035f, 
    0.22104767f, 0.28789723f, -0.01143235f, -0.06494623f, 0.02603026f, -0.10990074f, 0.60665971f, 0.08393495f, 
    0.03830619f, -0.06535903f, 0.07232317f, -0.27319959f, -0.18746673f, -0.03688811f, -0.37625295f, 0.56279421f, 
    -0.14422254f, -0.08217059f, 0.05673928f, 0.36389878f, -0.03046658f, 0.23390836f, -0.00892590f, 0.00403470f, 
    0.02192002f, 0.30841264f, -0.08648562f, -0.02698112f, 0.12216675f, 0.25243300f, -0.05417931f, 0.22426303f, 
    -0.10711578f, -0.11724609f, -0.32373810f, -0.60256392f, 0.08700255f, -0.15279090f, 0.11403976f, 0.20906529f, 
    -0.24319883f, 0.17781898f, -0.01796963f, 0.09200364f, 0.24493676f, 0.15114078f, -0.07742391f, -0.44940507f, 
    0.26003537f, 0.28431004f, 0.09381643f, 0.10761417f, -0.41198471f, -0.03129712f, -0.09776739f, 0.07827502f, 
    0.07103537f, -0.26489076f, 0.09979588f, -0.18597484f, -0.08091997f, -0.06872937f, -0.03845502f, -0.00160013f, 
    -0.07478019f, 0.16334799f, -0.23819919f, -0.14074612f, 0.12443931f, -0.42995945f, 0.03576463f, 0.17607816f, 
    -0.32067600f, 0.40559900f, -0.40012351f, -0.11950772f, -0.00986229f, -0.03072335f, 0.16946654f, -0.08209011f, 
    -0.27472600f, -0.01601721f, 0.28857574f, 0.02044278f, 0.01549478f, -0.01742359f, -0.06925654f, -0.27748755f, 
    0.28413555f, 0.03027840f, 0.13682072f, 0.13925071f, -0.03850272f, 0.16955967f, 0.31408969f, 0.35456845f, 
    0.08036467f, 0.18371385f, 0.42252359f, -0.32678837f, 0.08409712f, 0.12917447f, -0.07579242f, -0.47871116f, 
    0.04118578f, 0.02838445f, 0.06496669f, -0.03588240f, 0.08798874f, 0.01900742f, -0.05178105f, 0.06612307f, 
    -0.00234280f, -0.04909024f, 0.02941268f, -0.08900091f, -0.02976383f, -0.05407682f, -0.08629891f, -0.08974604f, 
    -0.07719838f, -0.01779713f, -0.09271236f, -0.07399548f, -0.01414428f, -0.09748731f, 0.05618695f, 0.02592765f, 
    -0.01106015f, -0.02655882f, 0.06483129f, -0.09044308f, -0.06735011f, 0.00745802f, -0.05047079f, -0.00823715f, 
    -0.02379098f, -0.03199905f, -0.04465467f, -0.08478304f, 0.06254900f, -0.06166588f, -0.01621837f, -0.02914577f, 
    -0.05471637f, -0.08953856f, -0.07743686f, 0.06094325f, -0.05503887f, -0.09267040f, -0.06052590f, -0.02814239f, 
    -0.10215862f, -0.08982383f, -0.03127542f, 0.00428904f, -0.00681233f, -0.01361381f, 0.03620847f, -0.03041252f, 
    -0.07709879f, -0.06381217f, 0.02475127f, -0.02452151f, 0.07039187f, 0.01618502f, -0.05211806f, -0.10043629f, 
    0.05408343f, -0.08605352f, 0.01601237f, -0.05863701f, -0.06045835f, -0.05682020f, -0.00742861f, -0.06045624f, 
    -0.06538086f, 0.01280068f, -0.05619838f, 0.07480436f, -0.01866632f, 0.00395038f, 0.04353916f, -0.08052151f, 
    0.02285384f, -0.07885726f, -0.01120248f, -0.07390598f, 0.05814998f, 0.00573614f, -0.05241502f, -0.06511991f, 
    -0.07107955f, 0.04857353f, 0.05545219f, -0.03073175f, 0.02867335f, -0.08005005f, 0.01545649f, -0.00840240f, 
    0.03497808f, -0.02736835f, 0.04600819f, 0.00751362f, 0.03318210f, -0.02566572f, 0.06727441f, 0.04993793f, 
    -0.04336625f, 0.01168991f, -0.03264219f, -0.02742689f, -0.00790796f, -0.01779585f, 0.02457849f, 0.03188211f, 
    -0.06229433f, 0.02892366f, 0.03288059f, 0.03959223f, 0.06253396f, -0.02798796f, 0.07439187f, 0.00512551f, 
    0.00100770f, 0.03967132f, 0.08760847f, -0.05528963f, 0.03168523f, -0.03803708f, 0.01818847f, 0.04912102f, 
    -0.17178898f, 0.00329528f, 0.16595739f, 0.07093766f, -0.07536072f, 0.04825525f, 0.11302122f, 0.33230653f, 
    -0.30545589f, -0.01724035f, -0.14574412f, -0.01085794f, 0.11959945f, 0.08048465f, 0.30706283f, -0.05720928f, 
    -0.00019700f, 0.10585449f, -0.32683212f, -0.17741781f, -0.06523194f, 0.38082263f, -0.51792949f, 0.08348715f, 
    -0.12524934f, -0.01159122f, -0.06260345f, 0.34307712f, -0.10961298f, 0.03291401f, -0.21022815f, 0.11346931f, 
    0.24979964f, -0.28413856f, 0.22824031f, 0.16500486f, 0.16716085f, -0.05081181f, 0.26879168f, -0.06162657f, 
    -0.18841033f, -0.29570568f, -0.05733716f, 0.30043784f, -0.08260643f, -0.10363430f, 0.28742188f, -0.29647940f, 
    -0.06011187f, -0.48953223f, 0.05309772f, 0.04443115f, -0.00353486f, -0.04446919f, -0.20804031f, 0.23392776f, 
    0.07819719f, -0.43314973f, -0.01995056f, -0.17366177f, -0.07657692f, 0.36190352f, -0.14464456f, -0.08538663f, 
    0.07514519f, 0.17302303f, 0.01511410f, 0.14385128f, -0.07350933f, -0.16260931f, 0.04803772f, 0.03893898f, 
    -0.02251162f, -0.16504829f, -0.01653665f, -0.64791989f, -0.19151841f, -0.06897011f, -0.08186665f, -0.09107299f, 
    0.07355475f, 0.24259388f, -0.17284682f, -0.01779037f, -0.10992157f, -0.16470605f, 0.05684134f, -0.20579122f, 
    0.03135154f, -0.17177679f, 0.22311874f, 0.17302079f, -0.03021393f, 0.28512272f, -0.02741613f, 0.32669625f, 
    -0.30094701f, 0.15909700f, -0.10550427f, -0.50389880f, 0.33053681f, -0.06636215f, -0.29793268f, -0.02712731f, 
    -0.03126524f, -0.84013808f, -0.35864601f, 0.22357441f, 0.10117018f, -0.22908503f, 0.09820706f, 0.16552554f, 
    -0.09547985f, -0.19853978f, 0.13548952f, 0.21796031f, -0.01800872f, 0.00022280f, -0.10149177f, -0.00412936f, 
    -0.06897969f, -0.46911374f, -0.01510861f, 0.05354375f, 0.25421709f, -0.20932995f, 0.16754839f, 0.27475309f, 
    -0.60076809f, -0.10068095f, 0.39272335f, 0.03925509f, -0.03050058f, -0.12417030f, -0.39253613f, 0.15406971f, 
    -0.01378223f, -0.36390772f, 0.06533865f, -0.02537489f, -0.18996842f, 0.38672984f, -0.02334489f, -0.34972706f, 
    -0.05217847f, 0.12808022f, -0.21779978f, -0.04708885f, 0.42706373f, 0.20304771f, 0.35542250f, -0.31218675f, 
    -0.01009856f, 0.31497884f, 0.12447058f, -0.08209263f, 0.03560001f, 0.15796292f, 0.14158961f, -0.05188722f, 
    0.07163963f, -0.04764956f, 0.19246618f, 0.06736580f, 0.07882742f, 0.09034559f, -0.32648820f, 0.05267671f, 
    -0.16524702f, 0.03554399f, 0.03968542f, 0.08653706f, -0.13581000f, 0.02541940f, 0.05702955f, 0.07813010f, 
    -0.21383496f, -0.13428594f, -0.03376897f, 0.18989180f, -0.46176207f, -0.01006819f, -0.17138003f, -0.00891634f, 
    -0.00840532f, -0.39211309f, -0.09054280f, -0.29305273f, -0.10792044f, 0.03019569f, 0.24942918f, 0.25281286f, 
    0.27931967f, -0.00693804f, -0.01038834f, 0.10900223f, -0.05549342f, 0.03825572f, 0.10819533f, -0.16636080f, 
    0.15156491f, -0.03777592f, 0.13985999f, -0.45996869f, 0.07275353f, -0.02593926f, -0.17867731f, -0.31332844f, 
    0.18470925f, 0.21041518f, 0.07860051f, -0.03168935f, 0.24225512f, 0.47935790f, -0.07982592f, -0.26739523f, 
    0.07222194f, 0.00081270f, 0.24486953f, -0.15197809f, 0.26151633f, -0.11859968f, 0.03530794f, 0.02031352f, 
    -0.18199241f, 0.20445155f, -0.06534619f, -0.39621043f, 0.05360730f, -0.14048153f, -0.31837851f, 0.03130474f, 
    -0.16578659f, -0.46958038f, 0.09798915f, 0.08434650f, 0.02675046f, -0.15005566f, -0.29397190f, 0.15672402f, 
    0.34808087f, -0.12166535f, 0.21435609f, -0.04785004f, 0.15540782f, -0.15139461f, 0.11296348f, 0.34287569f, 
    -0.06577048f, -0.64419466f, 0.43177819f, 0.00692210f, 0.16206758f, -0.25579622f, 0.09553534f, -0.19463731f, 
    -0.03737701f, -0.20174094f, 0.10200515f, -0.02850801f, 0.06572372f, -0.08884012f, 0.23724620f, 0.03617249f, 
    -0.04474404f, -0.06779212f, -0.00470283f, 0.00940789f, -0.04847879f, 0.17410867f, 0.14238767f, -0.03817885f, 
    0.04033916f, 0.05896537f, 0.06589831f, 0.01084525f, 0.19276743f, 0.27376348f, 0.29898277f, 0.07729369f, 
    -0.12342203f, 0.18498756f, 0.03251864f, -0.14614940f, 0.00851714f, 0.08704536f, -0.17712988f, 0.09383732f, 
    -0.07511357f, -0.03877747f, 0.17751099f, 0.21759835f, -0.06775540f, -0.08315456f, 0.11892363f, -0.15949924f, 
    -0.00378495f, -0.10295794f, -0.07044575f, -0.06295135f, -0.05863026f, -0.00585876f, 0.06124298f, 0.33330405f, 
    -0.07673876f, -0.20642565f, -0.01496693f, 0.07607255f, 0.01979186f, -0.17015922f, 0.03774339f, -0.37623852f, 
    0.01347861f, 0.12742554f, 0.22089747f, -0.09474650f, 0.05489400f, 0.11563599f, 0.24895212f, 0.41410482f, 
    0.20881163f, 0.20762810f, 0.09057794f, 0.06724374f, -0.36634064f, -0.10449428f, -0.03636869f, 0.19126716f, 
    0.12948498f, -0.02412844f, -0.01986648f, 0.01309729f, 0.07325067f, 0.03100565f, -0.03061974f, -0.00682463f, 
    0.08210783f, 0.10680911f, -0.23356326f, 0.13851082f, 0.29151967f, -0.18247977f, -0.00966321f, -0.05176980f, 
    0.11102857f, -0.12782997f, -0.07774308f, -0.09902128f, -0.01735657f, -0.16993314f, 0.03040717f, -0.14940472f, 
    -0.38480368f, 0.10814380f, -0.05453650f, 0.27470860f, -0.13257547f, -0.13176326f, -0.13877459f, -0.06429857f, 
    0.10090686f, -0.16951148f, -0.05040143f, 0.11321446f, -0.14261094f, -0.17882353f, -0.10128462f, 0.14631712f, 
    0.12878722f, 0.00787081f, 0.04029847f, -0.35725495f, 0.00181591f, -0.06433030f, 0.13538237f, 0.16497341f, 
    -0.10112560f, -0.39314008f, 0.22473840f, 0.02613809f, -0.09645550f, -0.00815523f, 0.04650000f, -0.21516204f, 
    -0.12444502f, 0.03857942f, -0.16280921f, -0.04230896f, 0.01551912f, -0.09220065f, 0.18866792f, -0.04873704f, 
    -0.04650761f, 0.19269428f, -0.43129539f, 0.02619507f, 0.00039883f, -0.07954253f, 0.10413222f, 0.05453585f, 
    -0.02968708f, -0.26661739f, -0.20529084f, -0.21405958f, -0.22375351f, -0.18369892f, 0.26391688f, -0.07544702f, 
    -0.21495654f, -0.42657328f, 0.04471719f, 0.13581181f, 0.12517443f, 0.19433780f, 0.20220080f, -0.38333172f, 
    0.24566457f, -0.01139693f, -0.29375827f, -0.22766168f, -0.14983380f, -0.09461550f, 0.40031391f, -0.11550825f, 
    -0.05416514f, -0.07309185f, 0.01400198f, -0.00992459f, -0.06928860f, 0.05918681f, -0.31945550f, -0.33182907f, 
    0.08546464f, 0.18662080f, -0.01725467f, -0.15019856f, -0.00781222f, 0.06481950f, 0.20501141f, -0.11125820f, 
    0.13319811f, 0.18271045f, 0.00094961f, -0.13546938f, -0.08465061f, -0.17422156f, 0.11608793f, -0.25465205f, 
    -0.30032173f, -0.07885429f, 0.03201970f, 0.08743541f, 0.33926630f, 0.23033667f, 0.02127540f, 0.07959835f, 
    -0.01462840f, 0.09077367f, 0.16884103f, 0.06370567f, -0.11285512f, 0.02363475f, -0.43719891f, 0.16776714f, 
    0.01663056f, 0.01785171f, 0.21184523f, -0.16251649f, -0.00946785f, -0.60939902f, -0.08031510f, 0.29663962f, 
    -0.04602722f, 0.13018273f, 0.09501679f, -0.19804886f, 0.11428231f, 0.18389183f, 0.03909814f, 0.04072498f, 
    0.18801294f, -0.07294767f, 0.07638214f, 0.15717165f, 0.07058116f, 0.21369854f, -0.04930455f, 0.06848276f, 
    0.08395072f, 0.26002973f, -0.00314087f, 0.00412837f, 0.04045169f, -0.06672869f, 0.10422890f, 0.12800765f, 
    -0.06053982f, -0.00802522f, 0.04491221f, 0.26557553f, 0.35403141f, 0.23971689f, 0.06459146f, -0.25220057f, 
    0.18395574f, 0.50123131f, -0.44221514f, -0.11547812f, 0.16145824f, 0.06597047f, 0.10350972f, 0.00912983f, 
    -0.01797441f, -0.00975728f, 0.00169213f, 0.06625684f, 0.00246235f, -0.02030343f, 0.00605548f, -0.07585717f, 
    0.04767020f, -0.05799104f, -0.01388178f, -0.08784863f, 0.00325719f, -0.08413839f, 0.04174769f, -0.08652314f, 
    -0.03107359f, -0.04950709f, 0.03544480f, -0.08808348f, 0.00212230f, -0.00551470f, -0.03551681f, -0.07539495f, 
    0.09332998f, -0.08959268f, -0.08712712f, -0.03286640f, -0.09257101f, -0.01552781f, -0.12419730f, 0.08060325f, 
    -0.01040708f, -0.06693992f, -0.01689984f, -0.03319183f, -0.03023736f, 0.03170355f, -0.00185750f, 0.02128038f, 
    -0.12037779f, -0.08318727f, -0.01132531f, 0.07526752f, -0.00481908f, -0.12084665f, -0.05725250f, -0.02373836f, 
    0.03342791f, -0.07203667f, 0.01153642f, 0.00530160f, -0.02792912f, -0.08160448f, -0.05779918f, 0.01358959f, 
    0.04619249f, 0.01206932f, -0.00411893f, 0.06980264f, 0.03267087f, -0.13157047f, 0.06320538f, 0.08818173f, 
    -0.10542364f, 0.04432816f, -0.00219534f, 0.04829637f, 0.07231499f, 0.00205989f, 0.10178234f, 0.02310306f, 
    -0.06433795f, -0.02338178f, -0.08413522f, -0.03187843f, -0.10252257f, -0.01641556f, -0.06297376f, -0.06651527f, 
    0.00014903f, -0.00967899f, -0.03170610f, -0.01554446f, 0.00455713f, -0.03579609f, -0.05906906f, -0.02682802f, 
    -0.05675516f, 0.07313243f, -0.04448375f, -0.10798024f, -0.02369603f, 0.00946404f, 0.04901905f, -0.08323242f, 
    -0.10316747f, -0.08277550f, -0.04981611f, 0.06497654f, -0.05190819f, -0.00690866f, -0.00833192f, -0.07705069f, 
    -0.06926951f, -0.06717376f, -0.01633746f, -0.08532909f, 0.04692259f, 0.01460898f, 0.00449162f, -0.09880144f, 
    -0.02768905f, -0.02967694f, -0.00540730f, 0.01099758f, 0.02888745f, -0.06744070f, -0.03419879f, -0.09933469f, 
    -0.02899716f, -0.04506524f, 0.02912585f, 0.06217903f, -0.02637062f, -0.10043258f, 0.06481668f, 0.00444158f, 
    -0.26860684f, -0.19046369f, 0.05678508f, 0.07589562f, 0.07355409f, -0.12543014f, 0.33950076f, 0.08296780f, 
    0.01952190f, 0.19130374f, -0.25094199f, 0.02830975f, 0.09922969f, 0.13115111f, 0.02144977f, 0.00594685f, 
    -0.05206584f, -0.07667782f, 0.09604351f, 0.02786158f, 0.07606546f, 0.17505786f, 0.43180549f, -0.10791337f, 
    -0.01785375f, -0.45573729f, 0.01118840f, -0.03402912f, 0.12077252f, 0.12467732f, -0.25347519f, 0.04954920f, 
    0.07618444f, -0.06299949f, 0.05272455f, -0.09445002f, -0.09312110f, 0.00219727f, 0.06532554f, -0.19903734f, 
    -0.21822880f, -0.08655355f, 0.07462252f, -0.11150768f, 0.04848864f, 0.07254776f, -0.22978109f, 0.07063259f, 
    0.07800148f, -0.07183442f, 0.05307314f, 0.11167049f, -0.02555656f, 0.03776370f, 0.01284428f, -0.10074588f, 
    -0.03461036f, 0.11963946f, 0.14322686f, -0.38576531f, 0.17219448f, 0.06778840f, 0.39152145f, -0.11072034f, 
    0.21088088f, -0.08826315f, 0.00808268f, 0.17017166f, -0.24522938f, 0.12911995f, 0.01389426f, 0.24571657f, 
    -0.07172649f, 0.03401623f, 0.10837357f, 0.02585180f, 0.06621298f, -0.08636948f, -0.04580195f, 0.07166574f, 
    0.16249867f, 0.10418828f, -0.01767373f, 0.07917923f, 0.25794795f, -0.92871135f, -0.05735019f, 0.15102287f, 
    0.08447032f, 0.15367289f, 0.02791759f, -0.09968238f, 0.05018059f, 0.07738680f, -0.00894859f, 0.04112400f, 
    -0.67328286f, -0.13757519f, -0.09950937f, 0.28483272f, 0.08595120f, 0.16475210f, -0.27605763f, 0.00731601f, 
    0.22150260f, 0.05591628f, -0.13025437f, 0.10769136f, -0.14104930f, -0.10528838f, -0.03298913f, 0.17557688f, 
    0.18568537f, 0.03791268f, 0.09662265f, -0.13820064f, -0.38123092f, -0.18968894f, 0.06160239f, -0.04033775f, 
    -0.02831022f, -0.09445861f, -0.28491932f, 0.12280787f, -0.00048541f, -0.04815640f, 0.14754356f, -0.29514194f, 
    -0.00876041f, -0.09322257f, 0.32965702f, 0.07378499f, -0.00889225f, -0.11746898f, 0.02461142f, -0.05569048f, 
    0.36718982f, 0.24815208f, 0.12376940f, 0.01592214f, 0.17220472f, -0.06167742f, 0.00500626f, 0.21517807f, 
    0.07549406f, 0.13997117f, 0.23145477f, 0.19134998f, 0.45672539f, 0.04355911f, 0.23797825f, 0.06109043f, 
    0.06300971f, -0.13854600f, -0.02498373f, -0.25476861f, -0.16361974f, 0.02443485f, -0.45464414f, 0.22260134f, 
    -0.14728931f, -1.04995859f, 0.26339445f, -0.29974753f, 0.03275224f, 0.09600536f, 0.13398512f, -0.12754101f, 
    -0.56053835f, 0.09062155f, -0.07078897f, -0.05146831f, 0.06848273f, -0.10609229f, 0.20192242f, -0.16082104f, 
    -0.15117928f, -0.02786819f, 0.07941503f, 0.07604556f, 0.13428536f, -0.16827989f, 0.28559238f, 0.07836138f, 
    0.01067756f, -0.03978526f, -0.15108427f, 0.25250682f, 0.14319727f, 0.11058592f, 0.05203262f, -0.46768707f, 
    0.19802505f, -0.47586480f, -0.06332908f, -0.09374201f, -0.47064218f, -0.09279070f, -0.18959662f, -0.01283862f, 
    -0.03144290f, -0.01214302f, -0.10956293f, 0.09729296f, 0.18615398f, -0.05801738f, 0.06438627f, -0.17940418f, 
    0.15158407f, 0.26193169f, -0.18729879f, 0.04285296f, 0.07956411f, -0.80265534f, -0.05878430f, -0.15371557f, 
    0.11838564f, -0.31044808f, -0.13320883f, -0.16410567f, 0.09512141f, -0.01817258f, 0.00593351f, -0.34457374f, 
    -1.17455649f, 0.14478715f, 0.06809448f, 0.36193311f, -0.25780520f, -0.12788737f, -0.11847633f, -0.07905756f, 
    0.11248977f, -0.50718117f, -0.42061463f, -0.41703713f, 0.05307484f, -0.12480815f, 0.00426214f, 0.16632621f, 
    0.24815880f, -0.31681377f, 0.12904765f, -0.45421615f, 0.27370119f, -0.23163721f, -0.01295695f, 0.13952950f, 
    -0.32281256f, -0.60884005f, -0.04252059f, 0.13049838f, -0.28008312f, -0.05052780f, -0.12014822f, -0.28948280f, 
    0.02388033f, 0.02416428f, -0.03061537f, -0.06910978f, -0.01046161f, 0.02813428f, -0.05017263f, 0.05924210f, 
    -0.08658364f, -0.03254444f, 0.01061061f, 0.01053063f, -0.01012438f, 0.08064776f, -0.08412280f, -0.09866823f, 
    -0.07194807f, -0.00861786f, 0.02913551f, 0.00220069f, -0.03718613f, 0.03841542f, -0.01031015f, 0.05428169f, 
    -0.06507800f, -0.08571241f, -0.02714716f, -0.03555719f, 0.05572023f, -0.04898833f, -0.08356769f, -0.10740068f, 
    -0.04856450f, 0.00735431f, -0.01215773f, -0.01575961f, -0.09553652f, -0.02462449f, 0.02786191f, -0.00326209f, 
    0.00034688f, 0.04556333f, 0.06869154f, 0.03874862f, -0.04567308f, 0.02651578f, 0.01147245f, 0.00416682f, 
    -0.02401636f, 0.03065800f, 0.01418579f, 0.02716753f, 0.06652096f, -0.04333731f, -0.09670746f, -0.03274833f, 
    -0.11916286f, -0.05459748f, -0.11459121f, 0.03829040f, -0.09593058f, 0.04647020f, 0.03106718f, 0.00543555f, 
    -0.02265937f, -0.02274774f, 0.04336764f, -0.02143125f, -0.05956002f, -0.04338862f, -0.09914711f, -0.02296065f, 
    -0.08513677f, 0.01501066f, -0.07884315f, -0.06373855f, -0.00734385f, -0.04013057f, -0.04941874f, -0.03364040f, 
    -0.04007779f, -0.08196113f, 0.00761998f, -0.07858042f, 0.03458662f, 0.00404607f, -0.03192257f, -0.09107406f, 
    -0.09064706f, 0.08443336f, -0.05664535f, -0.04144222f, -0.01642161f, 0.00543179f, 0.05714135f, 0.03259102f, 
    -0.01081052f, -0.02897698f, -0.09945712f, -0.08438318f, -0.07943500f, -0.08975250f, 0.00657417f, 0.07514450f, 
    -0.11078469f, 0.02445953f, 0.04481791f, 0.02533535f, -0.03839677f, -0.04329569f, -0.01072859f, -0.09956958f, 
    -0.01884702f, -0.04323163f, 0.00225972f, -0.05312533f, -0.05672190f, -0.00706168f, -0.05570263f, -0.03613094f, 
    -0.05977319f, 0.06742629f, 0.02870457f, -0.03636673f, 0.01140259f, 0.03695804f, -0.05167720f, 0.00092101f, 
    -0.11493729f, -0.01029258f, 0.11882229f, -0.01090742f, -0.03782087f, 0.06470490f, 0.19116886f, -0.02710932f, 
    -0.20115712f, 0.11576308f, -0.14572322f, 0.02871912f, 0.06636715f, 0.10292554f, -0.08715967f, 0.02331464f, 
    -0.09319138f, -0.10170522f, 0.06337387f, 0.08931299f, -0.33846346f, 0.05369270f, 0.13023336f, -0.09535287f, 
    -0.03964586f, -0.51744258f, 0.05360275f, -0.09716772f, 0.22047710f, 0.15652415f, -0.23427548f, -0.05908196f, 
    0.02102671f, -0.04328705f, 0.06705955f, 0.24002026f, -0.00631843f, 0.02508372f, 0.24415900f, -0.11399405f, 
    -0.27931151f, -0.02819806f, 0.04417624f, -0.07374655f, -0.16753270f, -0.11002072f, -0.19842264f, 0.09672584f, 
    0.03290952f, -0.11397611f, -0.01576463f, 0.12765475f, -0.17730527f, -0.09534369f, -0.13292761f, -0.17760326f, 
    0.13498770f, 0.22522400f, 0.25796324f, -0.19531719f, -0.04750882f, 0.07470187f, 0.16525753f, 0.12789033f, 
    0.01012083f, -0.13101190f, -0.02849652f, 0.11945866f, -0.09153629f, 0.17755139f, -0.05426604f, 0.22309391f, 
    -0.10635123f, 0.04103820f, 0.06285378f, 0.01689835f, 0.11664129f, 0.04905184f, -0.10667710f, 0.18274951f, 
    0.06499151f, 0.03127749f, -0.00291240f, 0.16996725f, 0.31546628f, -0.69133681f, -0.01150742f, 0.05404248f, 
    0.00030158f, 0.12715320f, 0.14095150f, 0.04581217f, 0.01428333f, -0.06176304f, -0.09451142f, 0.06974610f, 
    -0.42936739f, -0.30779195f, -0.11093859f, 0.19661169f, -0.05134593f, 0.00896941f, -0.20800360f, -0.05247908f, 
    0.21663307f, 0.31861103f, 0.04987615f, 0.30301556f, -0.18327473f, -0.04033411f, -0.04817247f, 0.13411117f, 
    0.05046448f, 0.04432980f, 0.16805445f, -0.07063220f, -0.49194649f, -0.09446803f, -0.14631827f, -0.05281029f, 
    0.06445428f, -0.03440142f, -0.27905798f, -0.09664334f, 0.02344405f, 0.04092098f, 0.20522694f, -0.01057267f, 
    0.08683469f, -0.04473263f, -0.04625421f, 0.00840734f, 0.02500019f, 0.06307945f, -0.01008749f, 0.44766420f, 
    0.10450127f, -0.12331423f, -0.00860272f, 0.00623394f, -0.06375280f, 0.14703850f, 0.08042476f, 0.01684007f, 
    0.03629922f, -0.08431821f, -0.44942141f, 0.05588628f, -0.17064938f, 0.24504477f, -0.29082051f, 0.08872973f, 
    -0.06660175f, -0.13849659f, 0.08976433f, 0.21563521f, 0.20630889f, 0.04540798f, 0.22593863f, -0.01960591f, 
    0.18790220f, -0.15369456f, 0.06385972f, 0.05927191f, 0.12208242f, 0.11360408f, -0.57533598f, 0.20171832f, 
    -0.43918660f, -0.37835261f, -0.05852505f, 0.34056145f, -0.09685415f, 0.12937967f, 0.08429658f, 0.09760249f, 
    0.13064511f, -0.14468580f, -0.03789333f, 0.18136312f, -0.02880127f, 0.09881146f, -0.26051527f, 0.15978432f, 
    -0.02680193f, -0.08768871f, -0.00475951f, 0.32643637f, -0.14797965f, -0.16200489f, -0.06906849f, 0.09822971f, 
    0.01813290f, 0.26537710f, -0.34274650f, 0.13796590f, 0.32226813f, 0.10935207f, 0.21409225f, -0.09639367f, 
    0.17911477f, 0.06079272f, 0.04781068f, -0.22670060f, -0.21028103f, 0.06118736f, -0.00455085f, -0.16658907f, 
    0.20868029f, -0.01652714f, 0.06809728f, -0.04055092f, -0.17174596f, -0.28454268f, 0.06413464f, 0.05605899f, 
    0.06858107f, 0.03023913f, 0.10951458f, 0.01474407f, 0.00125611f, -0.15834354f, -0.00665323f, 0.18384331f, 
    -0.32675600f, 0.09710993f, 0.11136587f, -0.03140815f, 0.13579148f, -0.11945776f, -0.24663517f, -0.03052203f, 
    -0.08905955f, -0.09480942f, 0.06774288f, -0.01048652f, 0.20834276f, 0.07578684f, 0.04971450f, 0.14099780f, 
    -0.03027987f, -0.29863057f, 0.11281458f, 0.08128045f, 0.23090804f, 0.08865080f, 0.21598986f, 0.20224373f, 
    0.12672497f, -0.10016298f, 0.18659125f, 0.08415367f, 0.05677500f, -0.18236479f, 0.20402935f, 0.40696532f, 
    -0.11283712f, -0.14509666f, -0.35264552f, 0.03744238f, -0.05724361f, 0.00653458f, 0.33557719f, 0.11829720f, 
    0.09645622f, 0.10924630f, -0.39674780f, -0.14483763f, 0.31582484f, 0.25493452f, 0.28144136f, 0.17503132f, 
    -0.08148481f, -0.04208526f, -0.00084178f, -0.15649098f, 0.00771235f, 0.16578878f, 0.25841933f, 0.15635394f, 
    -0.20710100f, 0.42980888f, 0.04131853f, -0.09799869f, 0.10811504f, 0.09984838f, -0.01824218f, -0.07674547f, 
    -0.08210105f, 0.20362099f, 0.09675570f, 0.21506706f, -0.21567956f, -0.18193826f, -0.01272090f, 0.05419444f, 
    0.06307405f, -0.08203810f, -0.04364238f, 0.05179463f, -0.04803190f, -0.05835589f, 0.06409990f, 0.08236068f, 
    0.04397380f, -0.35686192f, 0.07861196f, -0.07095886f, 0.09044586f, -0.19374754f, 0.12577026f, -0.08891185f, 
    -0.01389111f, 0.23344646f, 0.06309402f, -0.21958549f, -0.16997015f, 0.27529848f, 0.36435124f, -0.20686115f, 
    0.14999764f, 0.09939905f, -0.06401040f, -0.17422685f, -0.24612035f, 0.06590329f, 0.10183827f, 0.35258824f, 
    0.10983436f, -0.03949056f, 0.02961875f, -0.03612991f, 0.10176503f, -0.01515374f, -0.31469271f, 0.17720534f, 
    0.11982936f, 0.13706602f, -0.00972465f, 0.03146657f, 0.03123383f, 0.01246067f, -0.07912920f, -0.04806279f, 
    0.04756003f, -0.05129303f, -0.30949715f, 0.10721432f, -0.12670264f, -0.00329803f, -0.07352123f, -0.14837727f, 
    -0.63210881f, 0.22395097f, 0.11087106f, 0.28078878f, 0.05305260f, 0.09941739f, -0.06021666f, -0.06250534f, 
    0.22157574f, -0.04181450f, 0.25940472f, 0.16931345f, 0.03693783f, -0.19241253f, 0.21197577f, 0.17219697f, 
    0.26198074f, 0.23944396f, -0.08421886f, -0.08789672f, -0.42386410f, -0.15757674f, 0.05269905f, 0.04480986f, 
    0.11029123f, -0.23071562f, -0.06374276f, 0.11832431f, 0.00922587f, -0.01367241f, 0.12101907f, -0.45714995f, 
    -0.01644448f, 0.23986316f, -0.34097457f, 0.03730280f, 0.19276661f, -0.21458250f, 0.24359338f, -0.12690035f, 
    -0.05852834f, 0.32267091f, 0.12803268f, -0.05424754f, -0.12317546f, -0.22620840f, 0.01190614f, 0.03675686f, 
    0.03259457f, -0.42577964f, 0.15361115f, -0.04506933f, -0.25427052f, -0.12193266f, -0.00347799f, 0.13675627f, 
    -0.02635317f, -0.88513130f, -0.14538340f, 0.07013363f, -0.10985135f, -0.11855054f, 0.08967389f, -0.27825403f, 
    0.02907055f, -0.15388711f, -0.37318802f, 0.21654825f, -0.20750375f, -0.40667856f, -0.01401175f, -0.27696052f, 
    0.01860866f, -0.08632916f, 0.08133463f, 0.15442342f, -0.11978327f, 0.15463194f, 0.32905436f, -0.42457914f, 
    0.20911846f, 0.00670545f, -0.00955772f, -0.07705803f, 0.09959042f, 0.11793166f, 0.03106898f, 0.13217661f, 
    -0.01824687f, 0.22894073f, -0.00014423f, 0.17639199f, 0.11119107f, 0.20745659f, 0.03963380f, -0.44178328f, 
    -0.16251773f, -0.24893537f, 0.12107774f, 0.12739681f, 0.04076842f, -0.21962479f, 0.10596964f, 0.25763968f, 
    0.20201288f, 0.08427040f, -0.00580018f, 0.29884216f, -0.23726992f, 0.00715539f, 0.11964065f, 0.33452272f, 
    -0.09506099f, -0.03049127f, -0.06354589f, -0.21368574f, 0.19287077f, -0.96988428f, -0.07866058f, 0.27545422f, 
    0.13331276f, 0.11328696f, -0.40574506f, 0.22720456f, 0.02554175f, -0.19701606f, -0.02314857f, 0.03689754f, 
    -0.43539640f, 0.07994501f, -0.21582536f, 0.18079326f, 0.14296643f, 0.15150541f, 0.07863348f, 0.04031953f, 
    0.10402469f, 0.40682167f, -0.17078529f, 0.23335776f, -0.13501011f, -0.15974015f, 0.11846522f, -0.03476124f, 
    -0.17805152f, 0.51890194f, -0.26236784f, -0.01759940f, -0.37504333f, -0.05022068f, -0.31796458f, -0.21451989f, 
    0.19125177f, 0.34444219f, -0.45326617f, -0.17343895f, 0.07198806f, -0.01776497f, -0.08034538f, -0.56144506f, 
    0.20642482f, 0.36702964f, -0.03089475f, -0.09400978f, 0.10479750f, 0.12999208f, 0.33257347f, -0.01580892f, 
    0.19319658f, 0.13725406f, 0.41015846f, -0.11375131f, -0.11363926f, -0.11831785f, -0.01216157f, 0.08713735f, 
    -0.06283850f, -0.25309068f, -0.40877336f, -0.17460217f, -0.32179663f, -0.02666066f, -0.04224738f, 0.19410481f, 
    -0.03533944f, -0.15825011f, 0.00092094f, 0.15496285f, -0.00047100f, -0.03643710f, 0.08633298f, -0.14292353f, 
    0.08791585f, -0.11937878f, -0.18906897f, -0.42528534f, -0.03200327f, -0.18548357f, 0.12523535f, -0.09505014f, 
    -0.01560303f, -0.34568545f, -0.08296682f, 0.20851655f, -0.00912736f, -0.00260846f, 0.28222895f, -0.33529332f, 
    0.14293477f, 0.03748521f, 0.02286929f, -0.18597160f, 0.43489644f, 0.17335171f, 0.18737340f, 0.11610489f, 
    -0.07957167f, 0.08633844f, 0.01635354f, 0.17493176f, -0.24799719f, -0.20191169f, 0.08377559f, -0.34011534f, 
    -0.28014317f, 0.06065941f, -0.14438546f, -0.00613208f, 0.29259256f, 0.06119990f, 0.14626606f, 0.17292777f, 
    0.06868481f, -0.09621110f, 0.11948029f, 0.21319969f, -0.33270392f, 0.00042658f, -0.45621988f, 0.19898786f, 
    -0.04116569f, 0.03697718f, 0.14755876f, -0.27627686f, -0.34443405f, -0.13167284f, -0.03916270f, 0.23830743f, 
    -0.22607662f, 0.23573358f, -0.24412410f, 0.08815368f, -0.10653848f, -0.12322454f, -0.01563390f, 0.15924972f, 
    -0.05103363f, 0.16805704f, 0.15114556f, 0.38748848f, 0.13490161f, 0.19286750f, -0.00980096f, 0.04231214f, 
    0.11083204f, 0.09031244f, -0.09828582f, -0.13313372f, 0.07872593f, 0.03760485f, 0.19476672f, -0.16901608f, 
    -0.02489670f, -0.14964426f, -0.10846046f, 0.28648746f, 0.18560541f, 0.22290191f, 0.15842710f, -0.11183153f, 
    0.21760701f, 0.54237169f, -0.21384926f, 0.00427661f, 0.05854070f, -0.01319642f, 0.05665335f, -0.40176412f, 
    -0.25768098f, -0.02650506f, -0.30179119f, 0.07596359f, -0.00076252f, -0.13401563f, 0.00500215f, 0.02092957f, 
    -0.01857442f, -0.12208582f, -0.22191344f, -0.04300836f, -0.02596541f, 0.03759674f, 0.17756940f, 0.07250538f, 
    -0.00757397f, -0.01948931f, -0.24077778f, 0.10736973f, -0.23932917f, -0.26782295f, 0.18004565f, -0.11913736f, 
    0.09044871f, -0.33005869f, 0.21231131f, -0.20968112f, 0.26784065f, 0.00315940f, 0.33530837f, -0.05426861f, 
    0.09102163f, -0.38979080f, -0.27445871f, -0.17875172f, -0.05244102f, 0.08526689f, 0.22354169f, 0.13316762f, 
    -0.41977018f, 0.06677253f, 0.08127172f, -0.02892212f, 0.03011444f, 0.06170118f, 0.02111385f, -0.01924465f, 
    0.09163627f, 0.29873604f, -0.00250999f, 0.28261679f, -0.13185358f, 0.11403903f, -0.07679674f, -0.19300734f, 
    0.15758207f, 0.03705339f, -0.06404155f, -0.11149770f, 0.05674049f, -0.30995801f, 0.17627546f, 0.01940826f, 
    -0.11562143f, 0.02829805f, -0.25393349f, 0.17157163f, 0.30041984f, 0.28852239f, 0.21848850f, -0.12953904f, 
    0.04052416f, 0.31319663f, 0.19479907f, 0.02876023f, -0.00974972f, -0.05005876f, -0.05242202f, -0.11444005f, 
    0.04262473f, 0.00377149f, 0.09225060f, 0.13161008f, -0.01778175f, -0.46923995f, -0.02178887f, 0.21627022f, 
    -0.00930049f, 0.23184374f, 0.08704144f, -0.00582793f, 0.02299346f, 0.17109640f, 0.02413247f, 0.12797059f, 
    -0.28561407f, 0.01300666f, 0.09668171f, 0.16662276f, 0.04685167f, 0.16605814f, -0.01573088f, 0.04341882f, 
    -0.01161435f, 0.29563755f, -0.01831367f, -0.06216758f, 0.21137594f, 0.20126177f, -0.04680039f, -0.09658953f, 
    0.19050284f, -0.30208164f, -0.04601052f, 0.22689016f, 0.21673769f, 0.08140725f, 0.18310677f, -0.14683715f, 
    0.10558001f, 0.27586800f, 0.14273621f, 0.09691082f, 0.10234746f, -0.14768116f, -0.15735872f, 0.14385873f, 
    -0.15867379f, -0.49657142f, 0.34076253f, -0.06144365f, 0.09033456f, -0.12026211f, -0.12559673f, 0.28528184f, 
    0.09220829f, -0.18604061f, -0.26505312f, -0.04805565f, 0.17640759f, 0.29439977f, 0.08044615f, 0.03272939f, 
    -0.04812046f, 0.01533126f, 0.10734022f, 0.22514878f, 0.38568226f, 0.06107118f, 0.34301138f, -0.14646128f, 
    0.00474169f, -0.05741771f, -0.03748862f, 0.02319892f, -0.10374538f, 0.16026936f, -0.13764785f, 0.15331870f, 
    0.02943549f, -0.43173602f, 0.11096948f, -0.45128319f, 0.08968306f, 0.02568946f, -0.37001115f, -0.06064926f, 
    -0.05811794f, -0.02874637f, 0.01902942f, -0.04854941f, 0.06725921f, 0.04971475f, -0.15753424f, -0.47656789f, 
    0.21338589f, 0.11681823f, 0.00576930f, 0.19519798f, -0.18193066f, -0.09549122f, 0.21018827f, -0.01968374f, 
    0.03381897f, -0.20714509f, -0.28069943f, -0.30121908f, 0.19921334f, 0.07858864f, -0.02451865f, -0.23657236f, 
    0.25161111f, -0.27288207f, -0.19762471f, -0.01306920f, -0.13646145f, -0.08071055f, 0.00211301f, -0.25495067f, 
    -0.04859799f, -0.09732589f, -0.17360952f, -0.64275390f, 0.01970856f, -0.07148117f, 0.08425025f, -0.17401382f, 
    0.13241205f, 0.27742863f, -0.03554409f, 0.07715161f, 0.22530605f, 0.04375454f, 0.10294344f, -0.01424090f, 
    0.22364335f, -0.14415416f, 0.25029835f, -0.10769698f, 0.12917963f, -0.00943264f, -0.07982882f, -0.12578256f, 
    -0.30038545f, 0.35630065f, 0.04567521f, -0.03555516f, -0.33652228f, -0.21354811f, -0.12966989f, -0.06494769f, 
    -0.12768784f, -0.56429631f, -0.06009737f, -0.29624984f, 0.07672863f, 0.06382015f, -0.04196483f, -0.05408739f, 
    0.26428908f, -0.12442960f, 0.04599838f, -0.28141555f, -0.10851511f, -0.22639100f, 0.17659810f, 0.43798578f, 
    -0.48257792f, -0.52112830f, 0.17478773f, 0.26279515f, -0.06038277f, -0.25820130f, -0.14094473f, -0.24391247f, 
    0.00337925f, 0.04892240f, 0.10041497f, 0.05583671f, -0.08488754f, -0.02540881f, 0.01088151f, -0.03238113f, 
    0.06399498f, 0.06047840f, -0.02778909f, -0.12341358f, -0.08958273f, -0.00889551f, 0.02335777f, -0.08643846f, 
    -0.01010584f, 0.06898385f, 0.07218382f, -0.09888463f, 0.05910044f, 0.04883585f, -0.05957506f, -0.07325089f, 
    -0.05470109f, -0.08205786f, -0.00175307f, -0.07129367f, -0.00533984f, -0.08876783f, -0.05067349f, -0.00833144f, 
    0.01259027f, -0.09331841f, 0.02884056f, 0.05213439f, 0.06225196f, 0.04915554f, -0.11672705f, -0.01671696f, 
    0.01952866f, -0.04977581f, 0.03928056f, -0.07350108f, -0.02168932f, -0.11531757f, -0.02086246f, -0.07034345f, 
    -0.01839535f, -0.07908247f, 0.06511699f, -0.08084135f, 0.00984313f, -0.01596232f, -0.05400935f, -0.04777525f, 
    -0.10083114f, -0.05560515f, 0.02509306f, 0.03166306f, -0.06128581f, -0.07568078f, 0.00774142f, -0.05536476f, 
    -0.02185718f, -0.03708632f, -0.05064874f, -0.09518056f, 0.01509553f, -0.00412463f, 0.00779218f, -0.04418999f, 
    -0.05654224f, -0.05401587f, -0.08630390f, -0.04344341f, 0.05516949f, 0.01129181f, 0.06215452f, -0.08111246f, 
    -0.01758801f, -0.02595147f, -0.10470280f, 0.05486114f, -0.05033828f, -0.00281761f, 0.02907447f, 0.03566776f, 
    -0.07921018f, -0.03406497f, 0.12503928f, -0.10354702f, 0.02226703f, 0.10026838f, 0.04551947f, -0.09279887f, 
    -0.18666524f, -0.07249469f, -0.02471399f, -0.05209857f, -0.11320654f, -0.02398768f, 0.00804060f, -0.04669572f, 
    -0.06582452f, 0.01188343f, -0.02439426f, -0.00315823f, 0.00904808f, -0.02412196f, -0.04742481f, 0.04858954f, 
    0.05621385f, 0.03856856f, -0.08975640f, -0.09525163f, -0.04809617f, 0.00624554f, -0.11155763f, 0.00851045f, 
    -0.09774925f, -0.00458730f, -0.06445740f, -0.03020187f, 0.01619624f, 0.01554959f, -0.08975408f, -0.00462249f, 
    -0.17912263f, -0.02539696f, -0.05072846f, -0.00438508f, -0.05668397f, -0.19206858f, -0.08803468f, 0.14011337f, 
    0.02786774f, -0.30971724f, -0.50253052f, 0.01070536f, 0.04874849f, 0.21837348f, 0.05645045f, -0.14523418f, 
    -0.01967301f, 0.16488433f, 0.06314591f, 0.01735765f, 0.14806701f, -0.09821804f, 0.15491444f, -0.19454840f, 
    0.02160433f, -0.14424647f, 0.10647047f, 0.11221877f, 0.03239505f, 0.04381334f, 0.19361511f, -0.01623569f, 
    0.10388525f, -0.35416850f, 0.16821808f, -0.17918903f, 0.01548089f, -0.02165031f, 0.13037477f, 0.03750611f, 
    -0.31135201f, -0.09716218f, 0.08352783f, -0.08454192f, -0.03845517f, 0.17925712f, -0.34840053f, -0.31979054f, 
    0.06738108f, 0.14003855f, 0.07910780f, 0.06922852f, -0.10169926f, 0.27932572f, -0.00122045f, -0.09594000f, 
    0.03551013f, -0.22343372f, -0.05819331f, -0.07343034f, 0.16261694f, -0.18638279f, -0.01501678f, -0.02126045f, 
    0.20929816f, -0.01172478f, -0.13344239f, 0.14381607f, 0.11969362f, 0.04172342f, 0.03016321f, -0.30946290f, 
    -0.03270198f, 0.14324525f, 0.12253433f, -0.27267706f, 0.05121121f, -0.04074154f, 0.03454490f, -0.20061842f, 
    0.19108145f, 0.21484862f, -0.01932785f, -0.00100353f, 0.08187749f, -0.17088737f, -0.09094118f, 0.07544582f, 
    0.19218026f, 0.09348006f, -0.02968034f, -0.20804049f, 0.35047090f, 0.06263997f, -0.04774585f, 0.05555794f, 
    -0.24355245f, 0.16709784f, -0.06341694f, -0.23233218f, -0.04291868f, -0.09695061f, -0.17073195f, -0.07077142f, 
    -0.22497182f, -0.20233653f, -0.13710383f, -0.20327722f, -0.00257621f, -0.03809242f, -0.17138253f, 0.17793779f, 
    0.13341980f, -0.30353874f, 0.22159764f, 0.08032695f, -0.40703660f, 0.05134900f, 0.15348633f, 0.17007017f, 
    0.00007904f, 0.06676545f, 0.39154109f, 0.01276758f, 0.22851782f, -0.06381799f, 0.07399803f, -0.44149864f, 
    0.09218420f, 0.07576918f, 0.20149647f, 0.04541331f, 0.07112464f, -0.30053008f, -0.19488540f, 0.21235429f, 
    -0.03747185f, -0.14427391f, -0.13774039f, -0.11469793f, -0.55648184f, 0.26380026f, 0.10470000f, -0.06486246f, 
    -0.05018983f, -0.04588733f, -0.39904606f, 0.00376997f, -0.02868573f, 0.50360453f, 0.05803411f, 0.13986892f, 
    -0.10785052f, -0.04233458f, 0.04743501f, -0.34850258f, 0.19441859f, 0.10052869f, -0.04332560f, 0.09825019f, 
    -0.09384542f, 0.21651343f, 0.17681414f, -0.10082944f, -0.09221189f, -0.00935188f, 0.03717230f, 0.45005104f, 
    0.12559140f, -0.07944029f, 0.07067517f, 0.16536331f, -0.18556219f, -0.07743797f, -0.02482365f, 0.71987963f, 
    -0.51956165f, -0.50893348f, -0.00601726f, -0.02097078f, 0.16155338f, -0.12249035f, -0.12746289f, 0.11393424f, 
    -0.11291386f, -0.08000532f, 0.05361765f, -0.54086536f, -0.37751001f, 0.17240843f, 0.38631135f, 0.38503841f, 
    0.19867234f, 0.39414105f, 0.01259272f, -0.20914441f, -0.31885988f, 0.10249981f, -0.01130795f, -0.14132495f, 
    0.22644545f, 0.14129128f, 0.12204448f, -0.16784571f, -0.09585704f, 0.01723894f, -0.25544235f, 0.15886785f, 
    0.08475620f, -0.06094066f, -0.02451405f, -0.04299051f, -0.08792043f, 0.12408484f, -0.03057451f, -0.58321720f, 
    -0.28577921f, 0.06552620f, 0.00288585f, -0.18235193f, 0.00042976f, -0.14976953f, 0.01400447f, 0.06583675f, 
    -0.43815696f, 0.02111620f, -0.05605271f, -0.08565703f, 0.20587671f, 0.09858657f, 0.07333577f, 0.01621145f, 
    -0.02461071f, -0.36760256f, 0.24709368f, 0.34314150f, 0.02803761f, -0.31417051f, 0.04535602f, -0.18826972f, 
    0.13220862f, 0.18305440f, 0.09149930f, -0.08919862f, 0.59277660f, 0.15634888f, 0.23416547f, 0.35522914f, 
    -0.03366765f, -0.32925618f, 0.61547089f, -0.35384634f, 0.06032309f, -0.00369354f, 0.21189786f, 0.19344018f, 
    -0.50239825f, 0.07499659f, 0.16121107f, 0.01575200f, -0.07240655f, -0.21699099f, -0.55876708f, -0.03062894f, 
    -0.28555116f, -0.52156782f, -0.28746814f, -0.11819293f, -0.20570481f, 0.18732065f, -0.01344715f, -0.17175545f, 
    0.01272321f, -0.00580655f, -0.08734030f, 0.01776987f, 0.28055784f, 0.10482671f, 0.18852164f, -0.44279534f, 
    0.04770678f, 0.18608108f, 0.19650795f, 0.01900104f, -0.09333404f, 0.08709218f, 0.15630998f, -0.08528128f, 
    0.02789359f, 0.00493225f, 0.11388925f, -0.17614897f, -0.07001188f, -0.00550135f, -0.27734199f, 0.03938031f, 
    -0.10664046f, 0.29118207f, -0.02524514f, 0.10972978f, -0.30732188f, 0.02961798f, -0.02387256f, 0.00569622f, 
    -0.18548289f, -0.02102220f, 0.01280107f, 0.01317391f, -0.25313276f, -0.00747776f, -0.26941463f, 0.14835484f, 
    -0.04835391f, -0.62667572f, -0.05613942f, -0.01193053f, 0.02518063f, -0.25871116f, 0.05389887f, 0.26102701f, 
    -0.00075180f, 0.11180316f, -0.01806217f, 0.12936062f, -0.05363482f, 0.05122895f, -0.09003320f, 0.00252970f, 
    0.08292580f, 0.11566571f, 0.07522216f, -0.18464465f, -0.01914702f, -0.07900152f, -0.16983145f, -0.45651570f, 
    -0.05935314f, 0.10500560f, -0.02516123f, -0.08366422f, -0.02491083f, 0.27946559f, -0.01178927f, -0.24634548f, 
    0.00806289f, -0.13066922f, 0.13579872f, -0.03047299f, 0.19240861f, -0.19876458f, 0.00588295f, 0.05156381f, 
    0.06053080f, 0.19730884f, -0.54412776f, -0.42805341f, 0.07844279f, -0.34236386f, 0.01517471f, -0.01331745f, 
    -0.39655900f, -0.16244045f, -0.38578528f, 0.03600984f, -0.13444810f, -0.12564203f, -0.35653332f, 0.15305743f, 
    -0.09755971f, -0.44690260f, 0.12511371f, 0.07329395f, -0.07426925f, -0.05933043f, -0.02864120f, 0.12723832f, 
    -0.06793280f, -0.36626950f, 0.33083889f, -0.18805464f, 0.18542250f, -0.25011602f, 0.09829947f, -0.30995768f, 
    0.30457714f, 0.20178814f, 0.14742309f, -0.06314118f, 0.03303033f, -0.20287102f, -0.01905938f, -0.20716609f, 
    0.09363790f, 0.08049989f, 0.01378630f, -0.17291421f, -0.39374050f, -0.09594736f, 0.24318774f, 0.06233875f, 
    0.01444200f, -0.07538377f, -0.05229746f, -0.22202991f, -0.03462174f, -0.17654356f, -0.02648982f, 0.18461078f, 
    -0.01777099f, 0.28547016f, 0.07336643f, -0.05138696f, 0.09509499f, 0.12039606f, 0.28739175f, -0.21118884f, 
    0.03830784f, -0.14915824f, -0.36336532f, -0.38098228f, -0.08433613f, -0.28807905f, -0.37058872f, 0.10657441f, 
    -0.06639770f, -0.03454287f, 0.08810074f, 0.10920150f, -0.18258777f, -0.01607170f, -0.04502350f, -0.24936129f, 
    0.17121471f, 0.24672821f, 0.07622705f, -0.21335386f, 0.27318728f, 0.11644161f, 0.15326837f, 0.01008007f, 
    -0.02366237f, -0.04994968f, -0.01807866f, 0.41079918f, -0.01961664f, 0.18233071f, -0.27547684f, -0.14712484f, 
    -0.25179780f, 0.24014406f, 0.22442688f, 0.02061150f, 0.25565916f, 0.00088175f, -0.02035007f, -0.05764049f, 
    0.16960816f, 0.11790287f, 0.19414337f, 0.29343411f, -0.27845481f, -0.07444336f, -0.55428553f, 0.08256375f, 
    -0.17960766f, -0.05870421f, 0.04518275f, -0.31466168f, -0.09041771f, 0.68766952f, 0.01687523f, 0.05609187f, 
    0.00847984f, -0.01806463f, -0.11734068f, 0.37947419f, 0.12026791f, 0.06075275f, -0.06460588f, 0.08934344f, 
    0.68094319f, 0.10939430f, -0.20937632f, -0.18012811f, 0.08406992f, 0.19050926f, -0.00723013f, -0.02650756f, 
    -0.06226631f, 0.14474179f, 0.04167545f, 0.01496419f, 0.02300606f, 0.05190959f, 0.14638677f, -0.07758469f, 
    -0.12572181f, 0.16545133f, -0.14316259f, 0.22467881f, -0.04542178f, 0.14724973f, 0.06334833f, 0.03950338f, 
    0.07020812f, 0.35402879f, -0.05345163f, -0.42022970f, 0.10331547f, 0.32565993f, 0.01027640f, -0.44610295f, 
    -0.47228903f, -0.07866625f, 0.34250709f, 0.07032015f, 0.01259313f, -0.04317772f, 0.20561305f, 0.17198427f, 
    -0.02416225f, -0.02917680f, -0.70520514f, -0.05170051f, -0.12484253f, 0.28354988f, -0.12374879f, 0.30182821f, 
    -0.04337565f, -0.03922848f, 0.14543171f, -0.00029323f, 0.16156137f, 0.25150663f, 0.45779154f, -0.15072845f, 
    -0.35392264f, -0.34601203f, 0.06000423f, -0.11377755f, 0.25703251f, 0.18015529f, -0.29849315f, -0.10324202f, 
    0.19976212f, -0.20402272f, 0.16276160f, -0.28555849f, -0.10536137f, -0.02421750f, 0.47656816f, -0.26273727f, 
    -0.16815315f, -0.03134199f, -0.04009967f, -0.19819969f, -0.02756876f, -0.10399823f, 0.01951504f, 0.18247685f, 
    -0.11006184f, -0.28093404f, 0.00396486f, -0.05366586f, -0.13261135f, 0.01104505f, 0.25833353f, -0.11110608f, 
    0.04668354f, 0.25202239f, 0.25703990f, -0.49220112f, -0.19487180f, -0.00028032f, 0.37364334f, 0.03916987f, 
    0.24475467f, -0.24506178f, -0.12881252f, 0.04988176f, -0.05742502f, 0.25766793f, -0.05802735f, 0.43213105f, 
    0.02434351f, -0.00914721f, 0.06526871f, -0.20067911f, 0.13463233f, 0.02406292f, -0.57445103f, 0.07058556f, 
    0.03651323f, 0.11946622f, 0.02355548f, 0.06517522f, 0.11909819f, -1.00929892f, -0.06711004f, -0.06363518f, 
    0.04939021f, 0.07961820f, 0.09121335f, -0.32976511f, 0.25017190f, 0.03352513f, 0.07183821f, 0.01075712f, 
    -0.73179358f, -0.15574142f, 0.10071367f, 0.56872898f, 0.02088986f, -0.02576907f, -0.31034845f, 0.00273549f, 
    0.24705522f, -0.02235570f, -0.09166055f, 0.27707607f, 0.10484856f, -0.27477568f, 0.05570462f, 0.12774813f, 
    0.23585789f, -0.13696598f, 0.04316261f, -0.13496059f, -0.08348391f, 0.02361633f, 0.14194769f, 0.20027824f, 
    0.02919468f, -0.34023640f, -0.04498027f, -0.14642879f, 0.17198274f, -0.13428326f, 0.25530568f, -0.19340089f, 
    0.20028314f, 0.38597679f, 0.23185806f, -0.06379083f, -0.00679267f, -0.28967893f, 0.09417125f, 0.12447145f, 
    0.09345271f, 0.12251431f, -0.23971902f, 0.08647356f, -0.47954026f, 0.14869522f, -0.31430048f, -0.16349241f, 
    0.07071950f, -0.39126691f, -0.27327979f, 0.11801895f, 0.11432391f, 0.07617258f, 0.20469870f, 0.19213012f, 
    0.12539631f, 0.39955053f, -0.19678470f, 0.13865460f, -0.02691393f, -0.13041355f, 0.12774423f, 0.08286015f, 
    0.14892854f, -0.22151832f, 0.16781558f, -0.03867444f, -0.41484532f, 0.00761969f, -0.01052556f, -0.09475540f, 
    -0.13995084f, -0.28585815f, 0.06625299f, 0.27580759f, 0.22376473f, 0.10280356f, 0.02465843f, -0.10041282f, 
    0.22665374f, 0.21463630f, 0.03350604f, -0.37558019f, 0.33311278f, 0.34519240f, 0.03649566f, 0.29124045f, 
    0.01411211f, 0.16261090f, -0.09603717f, 0.16627401f, 0.14987025f, -0.10121597f, 0.42359859f, -0.22651672f, 
    -0.12130565f, -0.26059112f, -0.40638030f, 0.11790892f, 0.14632730f, 0.09019004f, -0.03573083f, 0.10247319f, 
    0.12147353f, -0.02065690f, 0.03136235f, 0.09825789f, -0.24803519f, -0.04274775f, 0.09547823f, -0.11605287f, 
    0.11396040f, -0.14806584f, 0.04125421f, 0.03219333f, -0.29442385f, 0.45613644f, 0.07691314f, 0.17625311f, 
    0.10802139f, 0.27688524f, -0.23168379f, -0.11877459f, -0.17696442f, -0.48751712f, 0.01132696f, 0.17343000f, 
    -0.02600177f, 0.10903066f, -0.14931782f, 0.39853850f, 0.08894375f, 0.09964716f, 0.32674104f, 0.01580617f, 
    -0.14182764f, -0.08022650f, -0.03494898f, -0.03500995f, 0.08323456f, -0.13794418f, 0.12462758f, -0.28451514f, 
    0.28882310f, -0.21439067f, 0.02609946f, 0.07392573f, 0.23933801f, 0.25121000f, 0.21581298f, -0.14758785f, 
    0.19958010f, 0.30936399f, 0.05565417f, -0.15003568f, 0.05133104f, -0.24260882f, -0.02694424f, -0.01982333f, 
    -0.23727310f, 0.17051844f, 0.29203716f, 0.07311148f, 0.03234859f, 0.06177421f, 0.18012887f, -0.12780803f, 
    0.25821614f, 0.21032514f, -0.55765104f, -0.09285190f, -0.01916228f, -0.24833860f, -0.13932109f, 0.28565058f, 
    0.03641598f, -0.19390263f, 0.13172035f, -0.05246799f, 0.06515570f, -0.28609470f, 0.00761816f, -0.16664930f, 
    -0.01027379f, 0.07624552f, -0.03174195f, 0.14586343f, 0.03045649f, 0.12778607f, -0.04196498f, -0.24301574f, 
    0.14889680f, -0.03052041f, -0.17352892f, 0.02459368f, -0.27679577f, -0.06804314f, 0.45109969f, -0.06744026f, 
    0.06630431f, 0.07130098f, 0.07281747f, -0.25550541f, -0.05897161f, 0.00729252f, -0.29340741f, -0.08903499f, 
    0.15606070f, 0.17152853f, 0.06159823f, -0.16251102f, -0.07037063f, 0.16069916f, 0.31492767f, 0.01691045f, 
    -0.13550793f, 0.40287498f, -0.05235762f, 0.00357139f, 0.04225524f, 0.11800870f, -0.17450200f, -0.04428547f, 
    -0.06616318f, -0.27199706f, 0.07563234f, 0.00286557f, 0.30427143f, 0.03239540f, -0.04272820f, 0.25220972f, 
    -0.05160337f, -0.18912038f, -0.07553094f, 0.22820036f, 0.01391043f, -0.01408739f, -0.31051496f, 0.07430615f, 
    -0.07577638f, 0.09530695f, 0.14156038f, -0.09151006f, 0.13228586f, 0.38251773f, 0.03744977f, 0.23661090f, 
    -0.04072730f, 0.11267238f, 0.30588818f, -0.32792574f, 0.26954308f, 0.09277815f, 0.06410761f, 0.05448978f, 
    0.60919261f, -0.29531282f, 0.13652188f, 0.31924915f, 0.01196834f, 0.03809365f, 0.18869461f, 0.07403392f, 
    0.22317736f, 0.37485376f, -0.14974096f, -0.09793244f, 0.07231806f, 0.02652989f, -0.02509526f, 0.04091376f, 
    -0.00525419f, 0.23287095f, -0.22182862f, 0.25505412f, -0.34475338f, 0.18054761f, -0.30966812f, -0.36630234f, 
    0.13214009f, 0.41735825f, 0.17031057f, -0.11820526f, 0.07387591f, -0.01751810f, -0.08095772f, -0.67203397f, 
    -0.02126746f, 0.05288770f, -0.53306532f, 0.04675058f, 0.07195628f, 0.07131350f, 0.25970277f, -0.08597014f, 
    -0.14437664f, 0.15401334f, -0.59983182f, 0.03473696f, 0.13707444f, 0.11077859f, 0.10867294f, -0.05571275f, 
    -0.03859721f, -0.23807396f, -0.00262972f, -0.00892625f, -0.22265184f, 0.33804879f, 0.03473210f, 0.09239333f, 
    -0.13807440f, -0.32118890f, -0.01486787f, 0.13317053f, 0.13461734f, -0.04413075f, -0.17199343f, -0.13119213f, 
    0.02224825f, 0.07736249f, 0.03507531f, 0.25655532f, -0.06616080f, -0.17368434f, -0.09304246f, -0.12693851f, 
    0.01477322f, -0.16706668f, -0.01724162f, 0.21806030f, 0.11926545f, -0.09769890f, -0.26663622f, 0.03370573f, 
    0.33306047f, -0.17862666f, 0.03628619f, 0.04740745f, 0.08911029f, -0.07605228f, -0.09792221f, 0.03235836f, 
    0.04677427f, 0.23617385f, 0.25830349f, -0.35397777f, -0.05546956f, 0.15169191f, 0.34349313f, -0.22158358f, 
    -0.08380891f, -0.03466969f, -0.13627811f, 0.12542386f, -0.14264160f, 0.02764927f, 0.07256396f, 0.27293605f, 
    0.17650127f, 0.12109159f, 0.13625468f, 0.17145203f, -0.14033824f, -0.02678078f, 0.09625412f, 0.09813720f, 
    -0.08948847f, 0.07463247f, -0.12163592f, 0.08134610f, -0.00885273f, -0.64948493f, -0.07211599f, 0.15690212f, 
    0.10486707f, 0.08952247f, -0.44571224f, 0.22627373f, -0.45591906f, -0.00834677f, -0.06191654f, 0.10385420f, 
    -0.73117685f, 0.16305201f, -0.00487405f, 0.16462490f, 0.22062072f, 0.01744135f, -0.12649973f, -0.05818758f, 
    0.11643890f, 0.16533838f, -0.02934611f, 0.24934979f, 0.00350623f, -0.04264645f, 0.04222333f, 0.11908641f, 
    -0.09660721f, 0.09162072f, -0.13663384f, -0.14383671f, -0.45454141f, 0.02624935f, 0.07494546f, -0.10446054f, 
    0.11917853f, -0.10380086f, -0.20621574f, 0.11319213f, -0.04600862f, -0.08898760f, 0.01471934f, -0.00197397f, 
    -0.07104105f, -0.07863724f, 0.06871144f, -0.03775182f, -0.06279691f, 0.25994030f, 0.26478887f, -0.62683082f, 
    0.00887815f, 0.23902835f, -0.06487252f, -0.07092903f, 0.17577939f, -0.19592336f, 0.06731312f, 0.24617031f, 
    0.00134157f, 0.08578969f, 0.16548520f, -0.29005593f, -0.19162546f, -0.56394315f, -0.00197747f, 0.04557438f, 
    -0.02084725f, 0.14221832f, 0.13096060f, 0.01478694f, -0.73337281f, 0.09722965f, -0.88191438f, -0.17582625f, 
    -0.60283494f, -0.56648654f, -0.67946643f, 0.35809201f, 0.12169255f, -0.14735843f, -0.21051741f, -0.48090297f, 
    0.17799871f, 0.09139603f, 0.05469847f, -0.62087905f, 0.01845756f, -0.17580868f, -0.01611072f, -0.28272527f, 
    0.07744874f, -0.12330636f, -0.08596315f, -0.05424848f, -0.04214647f, -0.38388920f, 0.17750700f, -0.90377378f, 
    -0.08133028f, 0.20625918f, 0.24341993f, 0.13584045f, -0.20862076f, 0.27170154f, -0.92840958f, -0.11955376f, 
    -0.02556295f, -0.40252540f, -0.02403049f, -0.53890860f, -0.22202787f, -0.75187802f, -0.06237107f, 0.24441841f, 
    -0.28474569f, -0.37047097f, -0.34749991f, 0.13716796f, 0.09044507f, -0.01704689f, -0.04566509f, 0.09219139f, 
    -0.39414486f, 0.25313255f, -0.26314950f, -0.10460284f, 0.22169432f, 0.13938615f, 0.06281427f, 0.00622936f, 
    -0.19910754f, -0.14797330f, 0.15687491f, 0.16003428f, 0.04857202f, 0.56686252f, 0.03387983f, -0.48540646f, 
    -0.74691820f, -0.38233349f, 0.30084702f, -0.00046559f, -0.15401469f, -0.00262293f, 0.05551806f, 0.03282692f, 
    0.20657533f, 0.25654721f, -0.12468799f, 0.05345839f, -0.20489869f, 0.15141143f, 0.13064554f, 0.04281186f, 
    -0.19657618f, 0.12150278f, -0.65083343f, -0.08487187f, -0.28528085f, -0.48669553f, -0.60428923f, -0.17224959f, 
    -0.18529509f, -0.19408733f, -0.99519777f, 0.01284763f, -0.25822097f, 0.07892486f, -0.26229420f, 0.13951074f, 
    -0.23371346f, -0.03495468f, -0.09650991f, -0.08176918f, -0.08874989f, 0.13160527f, 0.44211456f, 0.04053212f, 
    -0.17118603f, 0.15689512f, -0.30313289f, 0.11953852f, 0.06028840f, -0.04259614f, 0.10107157f, -0.02740231f, 
    0.03662132f, -0.04141425f, -0.09421254f, 0.05822380f, -0.27476197f, 0.09745562f, 0.12596358f, -0.20601551f, 
    -0.14285687f, -0.47490960f, 0.06500307f, -0.20799987f, 0.06667436f, 0.15718262f, -0.12964271f, 0.02209261f, 
    -0.10707757f, 0.04081978f, 0.07018264f, -0.18166517f, -0.03283477f, 0.05269525f, 0.17937236f, -0.12394492f, 
    -0.32398570f, -0.04947235f, -0.07392615f, -0.11614336f, 0.01182919f, -0.06806175f, -0.41989797f, 0.33908296f, 
    0.04623304f, -0.13340379f, 0.02299781f, 0.04233542f, -0.22966772f, -0.04737482f, -0.07939811f, -0.01655438f, 
    0.14244226f, -0.06615611f, 0.16243723f, -0.05151438f, -0.10168726f, -0.16148500f, 0.29784173f, 0.06692302f, 
    0.01254860f, -0.18125606f, -0.19934475f, 0.11402252f, -0.09068336f, 0.24361223f, -0.01097429f, 0.23861244f, 
    -0.06464587f, 0.17070203f, -0.00285674f, -0.01871774f, 0.13823348f, -0.01843894f, 0.01913033f, -0.04181615f, 
    0.18395478f, 0.20092224f, 0.06699038f, 0.19863605f, -0.14685789f, -0.33094767f, 0.05497371f, 0.04587863f, 
    0.05990297f, 0.06190689f, -0.16813804f, 0.18543354f, 0.05608688f, -0.07202902f, 0.01645106f, -0.01902201f, 
    -0.12349536f, -0.34647110f, 0.12758796f, 0.18825778f, 0.16298561f, -0.00312171f, -0.11599285f, 0.04946088f, 
    0.22188964f, 0.13007997f, -0.08870647f, 0.23324549f, -0.14112778f, 0.09090468f, 0.11112251f, 0.13481268f, 
    -0.01833540f, -0.21103270f, 0.16249213f, -0.08313848f, -0.27803743f, 0.01240179f, -0.04303833f, -0.29071039f, 
    0.03709041f, 0.04873810f, -0.25986964f, 0.02116588f, -0.01450170f, -0.22599791f, 0.15141448f, -0.09105730f, 
    0.03844729f, -0.16311669f, -0.28472269f, -0.04282359f, 0.04558304f, 0.09645152f, 0.13977176f, 0.14624682f, 
    0.17384116f, 0.13788049f, 0.21782120f, -0.40766355f, 0.20273417f, 0.01233806f, 0.22482595f, 0.14539476f, 
    0.00686880f, -0.22561525f, -0.02995858f, -0.10316636f, -0.04321455f, 0.34343633f, 0.00915825f, 0.21389078f, 
    -0.11271957f, 0.21261176f, 0.11772091f, -0.14706416f, -0.01643915f, -0.07321263f, -0.14479175f, -0.10224826f, 
    -0.36685488f, 0.30359417f, -0.18791184f, 0.23276591f, -0.16639857f, -0.27131706f, 0.05008319f, -0.19837849f, 
    0.31029728f, -0.15815650f, 0.01019356f, 0.14157324f, 0.02830720f, -0.20191427f, 0.08823181f, -0.11222109f, 
    -0.06324305f, -0.32077977f, 0.06087802f, -0.18751156f, 0.24530673f, -0.20450209f, 0.11267643f, 0.04251242f, 
    -0.11989946f, 0.19305578f, -0.13563299f, -0.22560510f, -0.39920518f, 0.21643475f, 0.33370388f, -0.33097738f, 
    0.10991661f, 0.18223572f, -0.09559151f, -0.23836276f, -0.27321941f, -0.19217505f, 0.14741626f, 0.04247866f, 
    0.18101004f, -0.23373041f, -0.13401882f, -0.02883044f, -0.12510659f, -0.00802106f, 0.02400419f, 0.25159380f, 
    -0.04137861f, 0.03120417f, -0.16098890f, -0.19560504f, -0.08458038f, 0.19855009f, 0.03879456f, -0.22480543f, 
    -0.21594264f, -0.06759936f, -0.53627551f, -0.13975233f, -0.31165573f, 0.17765424f, 0.07145685f, -0.15456037f, 
    -0.63687253f, 0.21257131f, 0.29447633f, 0.21609493f, 0.25542697f, 0.22222888f, 0.12092469f, 0.04487254f, 
    0.16856639f, 0.12745088f, 0.28128618f, 0.17866166f, 0.08893930f, -0.08670717f, 0.29382941f, -0.24059094f, 
    -0.03844751f, 0.20753978f, -0.18227020f, -0.14283341f, 0.11172266f, 0.04495485f, 0.19273956f, 0.14895555f, 
    0.07432948f, -0.15365985f, -0.44431737f, 0.26222160f, -0.15147229f, -0.07909653f, 0.09225302f, -0.35782543f, 
    0.30024290f, 0.03892880f, -0.29153576f, -0.00167772f, -0.06470319f, 0.01527633f, 0.06352068f, 0.15912342f, 
    0.03244324f, -0.08898669f, -0.33085623f, -0.13329634f, -0.00201077f, 0.14796364f, 0.35076180f, 0.18197638f, 
    0.09063096f, 0.00995175f, -0.25260380f, -0.12384494f, -0.27978355f, 0.24877805f, -0.12941740f, 0.27272752f, 
    -0.09983741f, 0.39742404f, 0.20610295f, 0.07895226f, 0.05481075f, 0.04671736f, -0.12697582f, -0.07736134f, 
    -0.07236692f, 0.04796203f, -0.00542375f, -0.09900516f, 0.06728557f, -0.06735376f, -0.08918778f, 0.08376316f, 
    0.18074195f, -0.17634609f, 0.00370670f, 0.27347565f, -0.16054660f, -0.07632482f, 0.01014444f, 0.09166133f, 
    -0.02543544f, -0.37609467f, 0.06799378f, 0.10167043f, 0.14374672f, -0.25779036f, -0.06423755f, 0.09619378f, 
    -0.08527631f, -0.06433746f, 0.08345478f, -0.18385158f, -0.38574493f, 0.15442860f, 0.11195821f, -0.13835037f, 
    -0.00429349f, 0.35651788f, 0.11270162f, -0.06053102f, 0.05722255f, 0.01781799f, 0.16360377f, -0.01399624f, 
    0.23299101f, 0.05927915f, 0.08305679f, -0.20721406f, -0.26615363f, -0.03481919f, -0.31984046f, 0.30013052f, 
    -0.02903165f, -0.05976963f, -0.03912095f, -0.05495445f, -0.22497898f, 0.63946062f, -0.03545912f, -0.25292140f, 
    -0.20416395f, -0.05701247f, -0.19562112f, 0.15773137f, -0.17372024f, -0.17304821f, -0.04871401f, 0.15663278f, 
    -0.12395640f, 0.17051689f, -0.04531384f, -0.26632077f, 0.26406878f, 0.16097929f, -0.23842055f, -0.05793183f, 
    0.15944351f, -0.17012940f, 0.38626191f, 0.30092564f, 0.13000348f, -0.13723280f, 0.30346653f, 0.03405522f, 
    -0.13765678f, 0.03571408f, -0.03261274f, 0.07279510f, -0.16053610f, 0.05977546f, 0.19122645f, 0.21810508f, 
    0.07223180f, -0.08508504f, -0.31897858f, 0.01688677f, 0.04049923f, 0.15162845f, 0.15823352f, 0.10437640f, 
    -0.67387003f, -0.20935622f, 0.16782708f, 0.07978229f, 0.00998998f, 0.00107419f, 0.21119036f, 0.31920922f, 
    -0.06713753f, -0.27406633f, 0.03395757f, 0.10670469f, 0.02741852f, 0.34133863f, -0.22927323f, -0.11517373f, 
    -0.04677174f, -0.21158129f, -0.37232772f, 0.19601542f, -0.05079713f, 0.03187402f, 0.47290018f, -0.00918977f, 
    -0.12380605f, -0.27873230f, -0.09442624f, 0.24574637f, 0.39133269f, 0.02431355f, -0.06270440f, -0.07743525f, 
    0.40342522f, 0.35410172f, 0.15861958f, -0.33210436f, -0.06371399f, 0.14764771f, -0.47443730f, -0.31808165f, 
    -0.05284010f, -0.26037586f, -0.04526370f, -0.27667788f, -0.21070017f, 0.17531949f, 0.28702044f, -0.10151118f, 
    0.13809346f, -0.01932370f, -0.05445420f, 0.19040705f, -0.30016077f, 0.26182342f, -0.04534940f, 0.11206917f, 
    0.11959245f, 0.19448425f, -0.06163377f, -0.06445583f, 0.02624958f, -0.54908693f, 0.25930959f, -0.23603877f, 
    0.06328218f, -0.36241934f, -1.00223839f, 0.34714460f, 0.17820986f, 0.41849253f, -0.06864984f, 0.09895105f, 
    -0.03821860f, 0.02653308f, 0.12745887f, -0.29028779f, 0.00949425f, -0.04636752f, -0.17268988f, -0.16724493f, 
    0.25287732f, 0.03206663f, 0.08578692f, 0.11881430f, 0.01845056f, -0.27722195f, -0.00766978f, 0.15757822f, 
    0.25210115f, 0.30606502f, 0.32272446f, -0.01418928f, 0.08755774f, -0.36239827f, 0.05446194f, 0.23565556f, 
    -0.18388617f, -0.14380214f, -0.02082890f, 0.46135792f, 0.04307262f, -0.10914072f, -0.33663401f, -0.06351154f, 
    -0.08786005f, 0.04494067f, 0.33167982f, 0.05738500f, 0.04464796f, -0.04074645f, -0.17630707f, 0.22409841f, 
    0.24366534f, -0.58221143f, 0.21279682f, -0.05524827f, -0.07015520f, -0.00397049f, 0.26029295f, -0.08533323f, 
    0.15646312f, -0.08035874f, -0.17987037f, 0.15183882f, 0.13032934f, -0.79645687f, 0.26709440f, -0.06082326f, 
    -0.04168519f, -0.03642838f, -0.26164687f, 0.03622942f, -0.08279310f, -0.16957557f, 0.03379558f, 0.01367854f, 
    0.14567254f, -0.04913458f, 0.28626823f, -0.10192726f, 0.18305413f, 0.21298067f, 0.30481014f, 0.07616016f, 
    -0.05487416f, -0.07864220f, -0.08691258f, -0.07756262f, -0.07952094f, 0.01329193f, 0.25320274f, -0.01291163f, 
    -0.04931786f, 0.48220667f, 0.12195046f, -0.02783011f, 0.03848105f, 0.01137218f, 0.41787863f, -0.07275409f, 
    0.09816205f, 0.04401173f, -0.07125406f, -0.52384388f, -0.05650315f, -0.07253271f, -0.28987923f, -0.02037243f, 
    0.18483698f, -0.34139067f, 0.02593372f, 0.16563310f, -0.15500672f, 0.02653454f, 0.00022201f, -0.54825807f, 
    0.14213479f, 0.02643061f, 0.04607050f, 0.11203776f, 0.01156074f, 0.04012610f, 0.05864168f, -0.10180759f, 
    -0.03751520f, 0.01564752f, -0.26842630f, -0.17091790f, -0.11526369f, 0.03518476f, 0.13902044f, -0.42554221f, 
    -0.10884889f, 0.14478645f, 0.16586028f, -0.04059245f, 0.23646225f, -0.00635530f, 0.20094933f, -0.23433603f, 
    0.20659685f, 0.03404702f, 0.09010731f, -0.02283330f, -0.33187559f, 0.00256713f, -0.45717663f, 0.14348955f, 
    -0.03429613f, 0.11747172f, 0.00581450f, -0.22515629f, -0.29359895f, 0.07184789f, 0.08723955f, 0.11916927f, 
    -0.11920128f, -0.16231704f, -0.44261387f, 0.02632958f, -0.13036704f, 0.04164385f, -0.06453120f, 0.05320518f, 
    0.14361100f, 0.32194746f, -0.01618329f, -0.05532600f, 0.11407228f, 0.17576844f, -0.12323584f, -0.06150362f, 
    0.06198330f, 0.08462365f, 0.19580288f, 0.06137411f, 0.08057960f, -0.07447553f, 0.10416990f, -0.14979404f, 
    0.15483703f, -0.06315669f, 0.01721466f, 0.07723145f, 0.84189039f, 0.16125336f, 0.17032690f, 0.18076405f, 
    0.09219713f, 0.29221752f, -0.22691707f, 0.29160428f, 0.08215342f, 0.11379769f, -0.02002776f, -0.45680231f, 
    -0.02849401f, -0.00633371f, 0.00873420f, 0.05478601f, 0.02084646f, 0.06456000f, 0.07095219f, -0.02579138f, 
    -0.06405686f, 0.01567501f, -0.07800440f, -0.08878438f, -0.08802679f, -0.02518141f, 0.03110666f, -0.07291327f, 
    0.01827473f, -0.05690922f, 0.03549527f, 0.08784271f, -0.08068657f, -0.01038900f, -0.04921548f, 0.02344282f, 
    -0.07418299f, -0.00247369f, -0.02483659f, -0.06250314f, -0.05468451f, -0.03070293f, 0.02897631f, 0.04139878f, 
    -0.04759955f, 0.05400285f, -0.07037818f, 0.00891582f, 0.00457083f, -0.00638917f, 0.07575034f, -0.04379068f, 
    0.08477645f, -0.04729641f, -0.06036860f, 0.00060313f, 0.05708317f, -0.05991381f, -0.07507535f, 0.07194360f, 
    0.06543419f, -0.05982542f, -0.00910870f, 0.01619658f, -0.08600996f, -0.07223975f, 0.00381529f, -0.08658071f, 
    -0.06698118f, -0.00445018f, 0.01544322f, 0.02116496f, -0.02711909f, -0.01150762f, 0.06838520f, 0.05124903f, 
    -0.01265108f, -0.08399612f, -0.00063632f, 0.05403588f, 0.04852381f, 0.03490925f, -0.07881967f, 0.06608636f, 
    0.02530207f, -0.01702010f, 0.02642006f, 0.03551170f, -0.03554492f, -0.01816122f, 0.07538620f, 0.01307573f, 
    -0.09294223f, -0.09277025f, -0.01691703f, -0.07957626f, 0.01706748f, 0.03177032f, 0.02249037f, 0.05353884f, 
    -0.00948354f, -0.07591645f, 0.04580735f, -0.05850907f, 0.05446341f, -0.08304985f, -0.07911213f, 0.03541182f, 
    -0.01513091f, -0.01464565f, 0.03279599f, 0.02303444f, -0.08287769f, -0.02218838f, -0.01596467f, 0.05184792f, 
    0.00567566f, -0.01016682f, -0.07266833f, -0.00513881f, 0.06584810f, -0.05063032f, 0.07673731f, 0.04385667f, 
    0.04298320f, -0.07208176f, -0.05292055f, -0.02978609f, 0.05566129f, 0.00309966f, -0.04536654f, -0.01557440f, 
    -0.09437283f, 0.00052301f, -0.03108514f, -0.03224324f, 0.00788689f, -0.06073057f, 0.00943323f, 0.03814394f, 
    0.42082185f, 0.23416281f, -0.27689183f, -0.07249870f, 0.05340505f, -0.05054718f, 0.13620459f, 0.15428051f, 
    -0.06035009f, 0.05172906f, -0.17685315f, 0.02812023f, -0.11218662f, -0.01838034f, 0.25238001f, 0.02654083f, 
    0.08305644f, -0.16661052f, -0.09226322f, 0.12075133f, -0.27055308f, 0.47738913f, -0.24474888f, 0.20903668f, 
    -0.14498563f, -0.78275025f, 0.00837549f, -0.03147383f, 0.02227926f, 0.07755984f, -0.19931504f, 0.12866239f, 
    -0.17669508f, -0.05065877f, 0.05555398f, 0.17802131f, 0.00888426f, -0.03362482f, -0.20627888f, 0.00190757f, 
    0.04474700f, -0.20091884f, 0.04347091f, 0.24708526f, -0.01151972f, -0.21197790f, 0.17501715f, 0.19349188f, 
    0.00690280f, -0.42882514f, -0.05303064f, -0.09832461f, 0.24650267f, -0.18068308f, 0.00856722f, 0.19278650f, 
    -0.03524672f, 0.02439929f, 0.24103808f, 0.01782276f, -0.24406826f, 0.20715170f, 0.20388716f, -0.24996658f, 
    0.07394484f, 0.21793427f, 0.32737499f, -0.04912444f, -0.10238560f, -0.08667640f, 0.07135288f, 0.15065955f, 
    0.24040915f, 0.21073520f, 0.07646915f, 0.00419883f, -0.22695698f, 0.01508512f, 0.11747155f, 0.23889612f, 
    0.02783159f, -0.08014140f, -0.10964146f, -0.05037253f, -0.13470913f, -0.49071604f, 0.05723033f, -0.15006185f, 
    -0.06961872f, 0.09403619f, -0.59072948f, 0.18853612f, -0.21907453f, -0.34747633f, 0.04688225f, 0.04430923f, 
    -1.03081477f, 0.15773755f, -0.09840422f, -0.11345158f, 0.32818830f, 0.13181166f, 0.04701455f, -0.05580506f, 
    0.11901706f, -0.15014082f, -0.11105541f, 0.44291380f, -0.00298477f, -0.23915699f, 0.14978537f, 0.03410010f, 
    -0.10980030f, 0.43519610f, 0.02619996f, 0.03521080f, -0.48444232f, 0.08203992f, 0.13835002f, 0.12070020f, 
    0.16420211f, -0.04785900f, -0.35000876f, -0.05266334f, 0.02943096f, 0.29238090f, 0.32342544f, -0.07159272f, 
    -0.12257065f, -0.03356899f, 0.41330183f, 0.06508916f, 0.02253017f, -0.02261952f, -0.15708998f, 0.06436674f, 
    -0.10771623f, -0.23020536f, 0.09953789f, 0.04684306f, 0.04502749f, 0.34337869f, -0.53947711f, -0.26392764f, 
    0.03497582f, 0.04748706f, 0.07953756f, 0.09726789f, 0.16325080f, -0.01025727f, 0.43195385f, 0.05177516f, 
    0.07977469f, 0.62429911f, -0.17270732f, -0.04972372f, 0.15098219f, 0.08771323f, -0.18684424f, 0.06781214f, 
    0.27428183f, 0.06160869f, 0.04888886f, -0.27677751f, 0.08827529f, -0.05199672f, -0.39395109f, -0.13733658f, 
    0.17438035f, 0.04987657f, -0.02387152f, -0.02773994f, -0.00262847f, -0.08141275f, 0.17805366f, -0.20526499f, 
    0.18718369f, 0.05239293f, -0.00816469f, 0.17687677f, 0.10492714f, 0.18748201f, 0.11259838f, 0.33403549f, 
    0.12990214f, 0.17962125f, -0.18969101f, 0.18012610f, 0.11415832f, 0.11258236f, 0.27894753f, -0.00904481f, 
    -0.06808859f, -0.61716056f, -0.24464732f, 0.02777614f, -0.07341617f, 0.21217892f, -0.14454871f, -0.07553031f, 
    -0.04743467f, 0.10913943f, -0.01908295f, -0.32179004f, -0.10890358f, -0.06240777f, -0.04631362f, -0.15160120f, 
    0.01032508f, -0.17009963f, 0.03603983f, 0.00373273f, 0.06836497f, 0.50557148f, 0.07759886f, -0.01687195f, 
    -0.00528539f, 0.13784762f, 0.20125392f, 0.09979354f, -0.00126200f, 0.04712599f, 0.06953116f, 0.07213780f, 
    0.56062263f, 0.03178623f, -0.22586165f, 0.09821571f, -0.28058791f, -0.17536943f, 0.00092640f, 0.07507785f, 
    -0.17631952f, -0.06473510f, -0.00303437f, 0.12458819f, 0.05170588f, 0.00486535f, -0.24811770f, -0.03652430f, 
    0.29148975f, 0.27308679f, 0.10140613f, -0.15899009f, -0.26591066f, -0.35026979f, 0.24710202f, 0.27971902f, 
    0.00865669f, -0.23339380f, 0.00484340f, -0.06667527f, 0.12554683f, -0.35520843f, 0.03450324f, 0.06585650f, 
    -0.23786201f, 0.13266768f, -0.00578389f, 0.04422107f, -0.09728862f, -0.00951064f, -0.05028104f, -0.11636686f, 
    -0.08610630f, -0.20701109f, 0.01176682f, -0.17226924f, -0.31622991f, 0.24503723f, 0.03978378f, 0.03785596f, 
    -0.02286557f, -0.07982950f, 0.11605442f, -0.20958552f, 0.04502982f, 0.03908136f, 0.08555026f, -0.12521057f, 
    0.12134393f, -0.39286169f, 0.20457049f, -0.09600756f, 0.28584844f, 0.14736179f, 0.28970057f, -0.07136118f, 
    -0.08795092f, -0.08778629f, -0.09079608f, 0.03940053f, 0.05893193f, 0.08818894f, 0.59049553f, 0.22566026f, 
    -0.11993727f, 0.15380505f, 0.07053399f, 0.12332725f, -0.15827261f, 0.09547884f, -0.11611675f, 0.31269294f, 
    -0.15088873f, -0.11826864f, 0.00434300f, 0.05944601f, -0.13990426f, -0.01042204f, -0.16908717f, -0.05140784f, 
    -0.09765505f, -0.02564467f, 0.23165882f, -0.53633434f, -0.12700038f, 0.09966434f, -0.00313955f, 0.59065932f, 
    0.01460624f, 0.28253838f, 0.20364752f, 0.05722186f, -0.12974644f, 0.21021205f, 0.13018738f, -0.17521559f, 
    0.14472942f, 0.09050500f, 0.26992127f, 0.04041737f, 0.02655961f, 0.03277413f, -0.30862522f, -0.02205056f, 
    0.03484643f, -0.12066418f, 0.09143640f, -0.13200246f, 0.17480373f, -0.73831642f, -0.02903462f, -0.00670916f, 
    -0.18514711f, 0.07358733f, 0.09177762f, -0.19493601f, 0.16563515f, 0.06541531f, -0.05150265f, 0.08546795f, 
    -0.61777997f, -0.02776318f, -0.12613188f, -0.11723067f, 0.16006787f, -0.04450740f, -0.00559163f, 0.03184821f, 
    -0.00280518f, 0.03777227f, -0.06892237f, 0.32755831f, -0.05592635f, -0.09520114f, 0.00483259f, -0.06907232f, 
    -0.12568115f, 0.12643364f, 0.04557787f, 0.02488789f, 0.22363947f, -0.07177869f, 0.17899494f, 0.17926285f, 
    0.16892175f, -0.27815083f, 0.52392644f, -0.34210417f, 0.25214949f, 0.08785711f, 0.08420593f, -0.14387837f, 
    0.11355771f, -0.01998049f, 0.18251446f, -0.05977022f, -0.09513276f, -0.03888787f, -0.03297302f, -0.02307249f, 
    -0.10086232f, 0.08804088f, 0.02887365f, 0.04445936f, 0.02601355f, 0.08212806f, -0.82710564f, 0.01883226f, 
    -0.08604456f, 0.03919202f, -0.10524704f, 0.05120574f, 0.38843560f, -0.02805711f, 0.33360189f, -0.13503188f, 
    -0.04842054f, -0.21083124f, -0.08329547f, 0.19704817f, 0.11095493f, 0.02263301f, 0.10126914f, 0.11603144f, 
    0.16793816f, -0.00782751f, 0.21042514f, -0.10831124f, 0.06851676f, -0.01973242f, -0.26648229f, -0.15453325f, 
    0.13307720f, -0.00085154f, 0.08295786f, -0.35982901f, -0.00002609f, 0.25675714f, 0.08689632f, -0.19789302f, 
    0.07812557f, 0.05946125f, 0.06276420f, 0.09968328f, -0.33728507f, 0.34003067f, 0.22830777f, 0.30577144f, 
    0.05243329f, 0.09273683f, 0.03247170f, -0.03301225f, -0.02518785f, 0.11126398f, 0.18844931f, 0.15433283f, 
    0.04031089f, -0.67325252f, 0.25005820f, 0.24242029f, -0.04332530f, 0.36359119f, -0.20168945f, 0.11168208f, 
    -0.15205781f, 0.15279338f, 0.06811840f, -0.03635040f, -0.00694710f, 0.08549189f, 0.00143616f, -0.31777680f, 
    0.19840848f, -0.07794594f, 0.12796462f, 0.12444014f, 0.04291274f, -0.24726796f, -0.06163800f, 0.18354367f, 
    0.19481678f, 0.07547028f, 0.19173989f, -0.00112078f, 0.09217660f, 0.34161308f, 0.04159173f, 0.08790614f, 
    -0.27920580f, -0.20930265f, -0.18535320f, -0.07732454f, -0.43929917f, -0.36137307f, -0.24135682f, 0.00747246f, 
    -0.12713240f, -0.18675141f, 0.03247533f, -0.19706073f, -0.05392833f, 0.04979517f, -0.55902004f, 0.21231042f, 
    0.12613848f, -0.20366763f, 0.06114282f, -0.08319256f, -0.22143276f, -0.12094928f, 0.09482337f, 0.14428356f, 
    0.16034903f, -0.10664309f, -0.04041088f, -0.04491495f, 0.19977337f, -0.13210458f, 0.08801001f, 0.12428021f, 
    -0.02756087f, 0.00275414f, -0.08664020f, 0.02420928f, 0.07802903f, -0.00991546f, 0.04686857f, 0.02023870f, 
    -0.01406070f, -0.03390297f, 0.07526632f, 0.04545771f, -0.07159815f, -0.06083854f, -0.05587639f, -0.04892999f, 
    -0.00289372f, -0.08262458f, 0.04104283f, 0.02410891f, 0.07846524f, 0.01494397f, 0.06154934f, -0.00373317f, 
    -0.09096225f, 0.05289755f, 0.05360248f, -0.01560666f, -0.08899102f, 0.07226198f, -0.01206854f, -0.07043121f, 
    0.01840752f, 0.06756783f, -0.09538309f, -0.04194335f, 0.03400848f, -0.04197279f, -0.00204509f, -0.04453534f, 
    -0.05307066f, -0.02129296f, 0.04757711f, 0.00724977f, 0.06262186f, -0.02107533f, 0.00733066f, 0.01311477f, 
    -0.07681667f, -0.08242434f, 0.04303601f, 0.07644788f, -0.04274777f, 0.07547968f, -0.08771288f, -0.01893257f, 
    -0.06425247f, -0.07694049f, -0.05096987f, 0.02185553f, 0.04721106f, 0.06914253f, -0.03111518f, 0.06007756f, 
    0.04234977f, 0.00449232f, 0.06975193f, -0.04306023f, -0.03310153f, 0.07558832f, -0.03314149f, -0.06450887f, 
    -0.05527917f, 0.03384243f, -0.08209673f, -0.01918917f, 0.02585625f, 0.06737533f, -0.02993697f, -0.02761043f, 
    0.02454136f, -0.00076638f, -0.04716235f, 0.02035074f, -0.07743870f, 0.03101485f, -0.08145776f, -0.08100159f, 
    0.06962286f, -0.02904388f, 0.05836373f, -0.08490448f, -0.06057595f, -0.08641558f, 0.07945856f, 0.01705015f, 
    -0.03361486f, 0.00240382f, 0.05295158f, 0.04565785f, -0.08392393f, 0.07588861f, 0.08332064f, 0.01732920f, 
    0.07074390f, 0.00814943f, 0.04161588f, -0.07376627f, 0.05067763f, -0.05513208f, -0.06113729f, 0.03496573f, 
    -0.05380363f, -0.01749611f, -0.03238517f, -0.05611018f, -0.00457372f, -0.05185224f, -0.04723775f, 0.00804268f, 
    -0.03739812f, 0.08710745f, 0.02878319f, -0.04540004f, -0.04512821f, -0.06317681f, -0.08869974f, -0.02829168f, 
    0.03437832f, -0.08216172f, -0.00592521f, 0.02959873f, 0.02751560f, -0.02994266f, 0.03650465f, -0.08676222f, 
    -0.02661328f, -0.01507122f, -0.02879785f, 0.03041172f, -0.08634868f, -0.03784296f, 0.04152894f, 0.00365724f, 
    -0.02245465f, 0.02400077f, 0.05474678f, 0.03602356f, -0.06428245f, 0.00288033f, 0.08849949f, -0.03394147f, 
    -0.09747462f, -0.06455751f, -0.06448751f, -0.05831110f, -0.08444625f, -0.07127135f, 0.09820846f, -0.07625061f, 
    0.04258061f, -0.03739443f, -0.12059794f, -0.05744710f, -0.00204326f, -0.11310076f, -0.03884161f, -0.09265982f, 
    -0.05935936f, -0.10823994f, 0.00593112f, -0.06375911f, 0.04074272f, 0.00448601f, 0.05179072f, 0.02385999f, 
    -0.10996152f, 0.04053845f, -0.08020920f, -0.03516722f, -0.08929229f, -0.02681712f, -0.03105805f, 0.01599442f, 
    -0.04224987f, 0.02227063f, 0.03564507f, -0.06629109f, 0.02911113f, 0.07471418f, -0.03646690f, 0.08286353f, 
    -0.11606638f, -0.01826647f, -0.08272274f, -0.00092853f, 0.02038390f, -0.07010391f, -0.03226714f, -0.08332759f, 
    0.06302374f, 0.03134325f, -0.02257080f, -0.00208823f, -0.01765760f, -0.00902400f, 0.00910423f, -0.03423790f, 
    0.01690996f, -0.10062777f, -0.00806915f, -0.04120385f, -0.04625771f, 0.04886770f, -0.02218981f, -0.02545484f, 
    -0.02965835f, -0.02012573f, -0.06220490f, 0.00557986f, -0.03766641f, -0.02134395f, 0.01630978f, 0.00478588f, 
    -0.02052824f, -0.03587384f, 0.04507867f, 0.00621039f, 0.04199683f, 0.06559525f, -0.06930772f, -0.05582508f, 
    0.02943651f, -0.06202969f, -0.00049872f, 0.06466562f, 0.04448501f, -0.02672299f, 0.06908023f, -0.13160019f, 
    -0.01269924f, -0.04842077f, 0.01199231f, -0.00534569f, -0.01281643f, -0.05478082f, 0.06851593f, 0.03083644f, 
    -0.03547723f, 0.03304955f, -0.03534278f, -0.10472419f, 0.07766487f, 0.05805666f, -0.07370198f, -0.04388162f, 
    0.23007417f, 0.09603082f, -0.24722935f, -0.02205367f, 0.08744908f, -0.12989452f, -0.24705283f, 0.11982705f, 
    0.02189127f, -0.09334175f, 0.58933932f, -0.17874356f, -0.29136828f, 0.01792545f, 0.17649595f, 0.16218381f, 
    0.04064182f, -0.19204548f, -0.14317118f, -0.21518531f, -0.29888237f, 0.14098045f, -0.25067461f, 0.08273210f, 
    0.05714966f, 0.65121627f, 0.05888880f, -0.01608561f, 0.17114103f, 0.09332065f, 0.28390840f, -0.03102539f, 
    -0.09664395f, 0.06385954f, -0.05736557f, -0.05760474f, 0.22070320f, 0.08543267f, -0.35415459f, 0.45741877f, 
    -0.05593232f, -0.00933762f, -0.04214109f, 0.16207159f, 0.00926078f, 0.02018285f, 0.06513251f, 0.30578244f, 
    -0.05905099f, 0.05382546f, -0.01526340f, 0.20234305f, 0.12969059f, 0.04567508f, -0.05306473f, 0.07076216f, 
    -0.00027481f, 0.02290384f, 0.05415308f, -0.19442099f, -0.21178810f, 0.05408639f, 0.02459832f, 0.09612882f, 
    -0.07111023f, 0.37877798f, 0.17934383f, 0.02520414f, 0.10164144f, 0.04049421f, 0.12857546f, -0.31351751f, 
    0.26800492f, 0.17998745f, 0.06899966f, 0.00657323f, -0.44211596f, 0.06632487f, -0.49773255f, 0.19676206f, 
    0.04927586f, -0.13176619f, 0.11065982f, -0.20695460f, -0.35331902f, 0.78480458f, -0.00432790f, 0.05184843f, 
    -0.12859549f, 0.15538487f, -0.43445417f, 0.25582534f, 0.02640384f, -0.38267559f, -0.01853969f, 0.10656155f, 
    0.34599710f, 0.06973314f, -0.13992451f, -0.20419282f, 0.08600280f, 0.08470235f, 0.01434854f, -0.03628240f, 
    0.04089573f, -0.00591841f, 0.07628450f, 0.19526848f, 0.14068691f, 0.10625484f, 0.00986390f, -0.10639130f, 
    -0.01097098f, 0.17135596f, 0.03828909f, 0.16269009f, -0.10569839f, 0.05525151f, 0.16443546f, 0.11519172f, 
    0.11024962f, 0.10951420f, 0.17355728f, -0.34430328f, 0.13169087f, 0.08758342f, -0.03466021f, 0.17945856f, 
    -0.09220772f, 0.19990152f, 0.02323302f, 0.08319695f, -0.03420052f, -0.11387816f, -0.24508327f, 0.29122788f, 
    0.14075369f, -0.22103831f, 0.46103606f, 0.09816684f, -0.06388553f, 0.22090265f, -0.11518180f, -0.07196371f, 
    -0.09076832f, -0.06922637f, -0.54420465f, 0.05023362f, 0.06150801f, 0.05388896f, 0.04232662f, 0.13905354f, 
    -0.07273610f, -0.36850324f, -0.08069975f, 0.10761428f, 0.12773794f, 0.06068508f, 0.38897628f, -0.07799668f, 
    0.24951653f, 0.04769494f, 0.05297728f, -0.28794679f, 0.01230349f, 0.14947434f, -0.28648832f, -0.04853521f, 
    -0.12787993f, -0.21711051f, 0.01837081f, 0.31746438f, -0.06171132f, 0.11039630f, -0.17380275f, -0.10211758f, 
    0.15668157f, 0.04380327f, 0.05069770f, 0.12788688f, 0.09194411f, 0.23072778f, -0.02383735f, 0.12251701f, 
    -0.00323812f, -0.04513894f, -0.08403272f, 0.13245061f, 0.03467607f, -0.41746667f, 0.03426375f, 0.01551442f, 
    0.10771918f, 0.02539184f, -0.47164735f, 0.20533563f, 0.45698059f, 0.12508640f, 0.08595445f, -0.20059770f, 
    0.14004141f, 0.01722702f, 0.08903207f, -0.10985870f, -0.14590271f, -0.02759369f, -0.01903202f, -0.20416488f, 
    0.25886264f, -0.06470915f, 0.16972344f, -0.01016712f, -0.33158743f, 0.15994118f, 0.07726843f, 0.18783642f, 
    0.07876857f, 0.11060686f, -0.03648975f, -0.07484304f, 0.05389480f, -0.07098335f, -0.08684769f, 0.12568010f, 
    -0.34742519f, 0.27415869f, -0.02328720f, 0.11104883f, 0.13587624f, -0.03402123f, -0.04919839f, -0.03976154f, 
    -0.28314817f, -0.14767370f, 0.12310810f, -0.13900019f, 0.21266802f, 0.03574299f, -0.06120417f, 0.03669412f, 
    0.13483864f, -0.50776905f, 0.13379903f, 0.31642273f, 0.12155855f, 0.21044274f, 0.15848204f, 0.15610127f, 
    0.16868867f, 0.28715128f, 0.23459418f, 0.09734818f, 0.13606714f, -0.27090195f, 0.11613978f, -0.09093058f, 
    0.01548793f, -0.04081875f, -0.04357237f, 0.08503767f, 0.07011438f, -0.07518337f, -0.01220701f, -0.04739512f, 
    -0.06148788f, 0.02870896f, -0.07216533f, -0.03547070f, -0.08609460f, 0.06304536f, -0.04904948f, -0.00698650f, 
    -0.01222508f, 0.04979413f, 0.04747175f, 0.02298643f, -0.09215321f, -0.01752254f, -0.08154667f, 0.08360924f, 
    -0.09606256f, 0.02926492f, 0.01339013f, -0.09196640f, -0.04274131f, -0.00432299f, -0.02539830f, -0.07736248f, 
    0.04683569f, 0.05054788f, -0.08838078f, -0.01973349f, 0.01366684f, 0.06940053f, 0.04949398f, -0.01926372f, 
    -0.01420532f, -0.04534374f, 0.05897209f, -0.05846594f, 0.05711403f, -0.05132394f, -0.03260621f, 0.06786603f, 
    0.03517953f, 0.04178414f, -0.03536286f, -0.03587935f, -0.06806223f, -0.04028650f, -0.08143490f, -0.09377227f, 
    0.07073096f, 0.01290953f, 0.02340952f, -0.01600582f, -0.01633048f, -0.07834433f, 0.04092466f, 0.01979149f, 
    0.07011614f, -0.06472280f, -0.07732862f, -0.03674500f, 0.05462969f, 0.04073728f, -0.08062126f, -0.05956982f, 
    0.02630630f, 0.02209194f, -0.01558862f, -0.00870480f, -0.07149670f, -0.03500245f, 0.05373453f, 0.03991865f, 
    0.04384223f, 0.01935152f, -0.01431612f, -0.07144784f, -0.04984209f, 0.00603943f, 0.03460667f, -0.02775661f, 
    -0.07628394f, -0.00347982f, 0.01438443f, -0.01997687f, -0.07909918f, 0.06671949f, -0.04656128f, -0.03503220f, 
    -0.04358065f, -0.00956746f, -0.07375345f, -0.06190715f, 0.02678552f, -0.03108106f, -0.01038456f, -0.07936922f, 
    -0.07238777f, -0.07590023f, -0.02471525f, -0.04562252f, 0.00920371f, 0.00853210f, -0.06626746f, 0.01067906f, 
    -0.08720148f, -0.07312709f, 0.00170227f, -0.03481667f, -0.00018976f, -0.07311288f, -0.06533360f, -0.08725248f, 
    0.04121811f, 0.04073597f, 0.05135078f, -0.04309257f, 0.01698756f, -0.03678641f, -0.10381312f, -0.07810862f, 
    0.01949013f, -0.06337158f, 0.33972976f, -0.06346811f, -0.07222807f, -0.38192824f, 0.06333204f, 0.28725520f, 
    0.02060960f, -0.01228772f, 0.16920310f, -0.33546591f, 0.00467993f, 0.22724074f, 0.10433730f, 0.14720601f, 
    -0.06470669f, -0.15834360f, 0.02435701f, -0.25345469f, 0.05464489f, 0.08299182f, 0.02168981f, 0.15714630f, 
    -0.40836570f, 0.69158357f, -0.09004478f, -0.24440466f, 0.04880195f, 0.00315253f, 0.01921417f, -0.17827103f, 
    0.31391057f, 0.22635657f, 0.12057446f, 0.14714113f, -0.14001575f, -0.45118603f, -0.53627723f, -0.11995803f, 
    0.45516413f, -0.23507898f, -0.05912128f, 0.19474845f, -0.05690962f, -0.05335686f, -0.03209138f, -0.02932585f, 
    0.05374587f, -0.48361325f, -0.00024006f, 0.05520217f, 0.24098849f, 0.06673436f, 0.11181737f, 0.02177786f, 
    -0.24769297f, 0.04212426f, -0.34207162f, -0.19388382f, -0.28935140f, 0.17393591f, 0.31091067f, -0.20080510f, 
    0.16246438f, 0.00289099f, 0.05686492f, -0.07754406f, -0.27930483f, -0.21146768f, -0.01837905f, 0.00999614f, 
    0.07285552f, -0.10461146f, -0.09688327f, -0.03627499f, -0.20239136f, -0.03134591f, -0.34035757f, 0.10904460f, 
    0.07444131f, -0.03357559f, -0.31606567f, -0.23361443f, -0.04606460f, 0.85448408f, -0.05304770f, -0.22012030f, 
    -0.02540449f, -0.19620587f, -0.08627737f, 0.01514511f, -0.13124697f, 0.09076484f, -0.06133142f, -0.21992631f, 
    0.44742823f, 0.18808056f, -0.09509483f, 0.02080049f, 0.06795685f, 0.08638638f, -0.28300333f, -0.04605293f, 
    0.01388622f, 0.04768946f, 0.22471547f, 0.16448063f, -0.00196921f, -0.42139450f, 0.06478689f, -0.01832170f, 
    0.22951443f, 0.11449090f, -0.10242903f, -0.24148822f, 0.18291768f, -0.08044600f, 0.20208812f, 0.15061565f, 
    0.02538565f, -0.18979925f, 0.22160597f, 0.32714680f, -0.09623138f, 0.03637177f, 0.02038549f, 0.49058527f, 
    0.02481700f, 0.03049480f, 0.05864793f, 0.05822710f, 0.05492384f, -0.02276905f, 0.01271210f, -0.07150525f, 
    -0.04654769f, -0.00568776f, 0.05643046f, -0.03718601f, -0.05426457f, -0.10556285f, -0.07014679f, 0.01043007f, 
    -0.03168381f, 0.02663723f, -0.04240706f, -0.13035056f, 0.06330148f, 0.04123962f, -0.09826153f, 0.07761838f, 
    -0.12861969f, -0.05052215f, -0.02366132f, -0.03844513f, 0.01948107f, -0.13366885f, -0.07667436f, -0.00440151f, 
    0.06576234f, -0.01065992f, -0.04895196f, -0.05668253f, -0.09932922f, 0.03580845f, 0.03765187f, -0.07128949f, 
    -0.02436672f, -0.08279792f, 0.01101034f, -0.02214754f, -0.03634207f, -0.06621468f, 0.08543509f, 0.00006829f, 
    0.00672100f, -0.02065665f, -0.07379841f, 0.01090410f, 0.02424574f, -0.09286260f, -0.00214179f, -0.04277873f, 
    -0.09208513f, 0.00366491f, -0.04550794f, 0.07724541f, -0.11586902f, 0.06548900f, 0.03476946f, -0.06290701f, 
    -0.06966403f, -0.02506752f, -0.00961709f, -0.09543265f, 0.00729945f, 0.03370897f, -0.04874099f, -0.11951473f, 
    0.07386913f, 0.02507746f, -0.09466814f, -0.03295731f, -0.01871527f, -0.04661276f, -0.03236805f, -0.00027226f, 
    0.03159322f, -0.11916739f, -0.02210331f, 0.02965939f, -0.07024802f, -0.06954602f, -0.01939014f, -0.02567192f, 
    -0.01144561f, -0.01432786f, 0.01217315f, -0.00465038f, -0.08781360f, -0.00096562f, -0.01513907f, -0.03502626f, 
    -0.00767256f, 0.06536804f, -0.03764175f, 0.00073130f, 0.02426743f, -0.09223408f, 0.00095298f, 0.07679801f, 
    -0.00758555f, 0.07122587f, -0.05844266f, -0.00931380f, -0.03595537f, 0.01813214f, -0.03083288f, -0.05697097f, 
    -0.04463510f, -0.02026908f, -0.01454321f, -0.03841436f, -0.03372679f, -0.07397385f, 0.04502338f, 0.05087001f, 
    -0.01474929f, -0.02492094f, 0.07908983f, 0.00164036f, -0.02922490f, -0.01213808f, -0.07841139f, -0.04008070f, 
    -0.18332638f, -0.32276660f, 0.30324841f, 0.03896194f, 0.02335332f, -0.10018730f, -0.22492924f, 0.08587261f, 
    0.23163977f, -0.23852573f, -0.30673596f, -0.00124508f, 0.02052413f, 0.22599277f, 0.12411615f, 0.00193444f, 
    0.06312869f, 0.17601179f, 0.11746053f, 0.08009043f, 0.38599703f, 0.08754983f, 0.13495830f, -0.14788002f, 
    0.07042246f, 0.04386106f, 0.18564776f, 0.08679685f, -0.16990571f, 0.15040103f, -0.16121109f, 0.20815399f, 
    0.01056891f, -0.40976292f, 0.30510736f, -0.19439091f, -0.07109290f, 0.06567228f, -0.10678304f, 0.09814210f, 
    -0.12567089f, 0.10183591f, 0.08826333f, -0.12577426f, 0.05670192f, 0.11645057f, -0.22533140f, -0.13681674f, 
    0.00901184f, 0.06301013f, 0.00899184f, 0.12371935f, -0.18829514f, -0.10699107f, 0.06270481f, -0.08176320f, 
    -0.10238982f, -0.12761755f, -0.28758922f, -0.38019150f, 0.18329078f, 0.01177051f, 0.03270173f, -0.17247032f, 
    0.25704882f, 0.15198505f, -0.20187797f, 0.06269532f, -0.05130274f, -0.18614365f, 0.00475188f, -0.33887345f, 
    0.06158575f, 0.03310081f, -0.07511897f, -0.60756058f, 0.03500619f, -0.01878864f, -0.11792611f, -0.10732923f, 
    0.22299162f, 0.14176960f, -0.03917865f, -0.01073401f, 0.15785682f, 0.13536368f, -0.05952100f, -0.15058489f, 
    0.15554191f, -0.18291046f, 0.14313430f, -0.19923767f, 0.08573910f, -0.12144054f, 0.03873827f, -0.15502904f, 
    -0.57427543f, 0.27688563f, -0.04643355f, 0.01861926f, -0.12197711f, -0.23406765f, -0.10634546f, -0.05644400f, 
    -0.01358075f, -0.63475317f, -0.26221114f, -0.13745184f, 0.05974905f, -0.09103538f, -0.26119936f, 0.04133072f, 
    0.30713016f, -0.25779474f, 0.19692044f, -0.10925279f, -0.27327403f, 0.01687720f, 0.18044601f, 0.29307798f, 
    -0.37065700f, -0.61213344f, 0.30814201f, 0.13018037f, 0.00312292f, -0.16683407f, -0.10339210f, -0.67594123f, 
    0.09235052f, 0.32299012f, 0.07279501f, 0.00165147f, 0.10466722f, -0.11541805f, 0.10290109f, -0.37842101f, 
    -0.17735459f, 0.17634521f, -0.03244124f, 0.11220165f, -0.23010053f, -0.06033938f, -0.15786713f, 0.04406542f, 
    -0.05550205f, -0.48478115f, 0.11662417f, -0.10591561f, -0.08216295f, -0.17678249f, 0.12148109f, 0.06811126f, 
    -0.25876424f, -0.59237736f, 0.05742586f, 0.18692191f, 0.00723229f, -0.04345515f, 0.14527091f, -0.56974483f, 
    0.19244188f, 0.35713491f, -0.25191221f, 0.23840418f, -0.70115709f, -0.27393144f, 0.05836987f, -0.68345553f, 
    0.33475089f, -0.02807497f, -0.01766498f, -0.37784618f, -0.13266580f, -0.09538938f, 0.03633115f, -0.30190042f, 
    0.10263278f, 0.01917305f, -0.04805606f, 0.01965376f, 0.05031783f, 0.24468563f, 0.06744702f, -0.09422953f, 
    -0.02904739f, 0.25844869f, 0.30601022f, 0.06629081f, 0.05092226f, 0.12538137f, 0.03121075f, 0.12715882f, 
    -0.16381255f, -0.03435285f, 0.06785840f, 0.22051962f, 0.05852266f, -0.07511174f, -0.21038212f, 0.30652291f, 
    0.07256449f, -0.09595335f, 0.16386543f, 0.19386090f, -0.17291196f, 0.06677910f, -0.04095392f, 0.16126478f, 
    -0.24347618f, -0.15416853f, -0.09732242f, -0.03646544f, 0.16731606f, -0.61314481f, -0.00553221f, 0.01912346f, 
    0.03834794f, 0.14423753f, 0.02495941f, -0.18434672f, 0.14560115f, 0.07172094f, -0.01499792f, 0.18713000f, 
    0.11054642f, -0.28534672f, -0.41976309f, 0.08420347f, 0.04549153f, 0.09957401f, 0.02464592f, 0.05062301f, 
    0.07075304f, 0.38202757f, -0.04227287f, 0.12883799f, -0.17349496f, -0.23011582f, -0.05211874f, 0.02381979f, 
    -0.12499935f, 0.32385540f, -0.13121578f, 0.06547046f, -0.48229802f, 0.03502797f, -0.34589222f, -0.31464243f, 
    0.23356138f, 0.31149474f, -0.14405575f, -0.58782387f, 0.13471177f, 0.07257931f, 0.03107068f, -0.44157830f, 
    0.01775065f, -0.00774627f, -0.14775281f, -0.01749127f, -0.09288839f, 0.02582082f, -0.09969319f, 0.16398750f, 
    -0.24154085f, -0.16685838f, -0.10325874f, 0.01244738f, 0.05309040f, 0.00821277f, 0.17953902f, -0.03429124f, 
    0.09012948f, 0.00497013f, -0.05612159f, -0.11237317f, -0.09284510f, 0.11898033f, -0.28656289f, -0.25296062f, 
    -0.03582440f, 0.04000035f, 0.18493047f, 0.36528903f, 0.15109202f, 0.12504411f, 0.17101181f, -0.01623540f, 
    0.20165887f, -0.15748003f, -0.14566483f, 0.22772381f, 0.15200520f, 0.10736470f, 0.60717660f, 0.07484574f, 
    -0.12722270f, 0.06618988f, 0.08537062f, 0.23877619f, -0.04631000f, 0.20805059f, -0.04088370f, 0.14735453f, 
    0.00561428f, 0.15559615f, 0.03120384f, 0.08490701f, -0.04568567f, 0.06358830f, -0.13460054f, 0.03058269f, 
    0.13664445f, -0.16735376f, 0.01209703f, 0.16254586f, -0.08936437f, 0.12456732f, -0.08899933f, 0.13245744f, 
    -0.09070948f, 0.17993231f, 0.15852931f, 0.09707605f, 0.29525194f, -0.00498065f, 0.05817594f, -0.15843859f, 
    -0.10800979f, 0.05103952f, 0.11506936f, -0.09892214f, -0.08922596f, -0.08002374f, -0.16420047f, -0.02319083f, 
    -0.01685204f, 0.03647163f, 0.15013503f, 0.03059632f, 0.14898883f, 0.10043523f, 0.06117158f, 0.02233612f, 
    -0.08322141f, -0.05856997f, 0.12295403f, -0.09451217f, 0.11168685f, 0.32499817f, -0.02873126f, 0.14344737f, 
    -0.02709470f, 0.00009845f, 0.01898247f, -0.52367198f, 0.13016635f, -0.04786493f, 0.08701482f, 0.08489924f, 
    -0.04575094f, -0.15520266f, -0.12766978f, -0.06760027f, 0.00692320f, 0.11403479f, -0.09637656f, 0.18057582f, 
    -0.19838665f, -0.07730973f, 0.07320852f, 0.31531715f, -0.09656908f, 0.09892230f, -0.11769222f, 0.03336901f, 
    -0.09145823f, -0.01936628f, 0.39145094f, -0.17828186f, 0.32709447f, 0.09979164f, 0.07745270f, 0.42562786f, 
    0.42872164f, 0.12414943f, 0.20264252f, 0.03599656f, 0.00315082f, 0.04035046f, 0.26360875f, 0.14993046f, 
    0.38683861f, 0.35811368f, -0.49642056f, -0.05393577f, -0.01607615f, -0.08297537f, 0.18406989f, 0.43842605f, 
    -0.05038461f, -0.13238773f, 0.29327103f, -0.07447343f, -0.34889856f, 0.07836660f, -0.19451655f, 0.22170638f, 
    -0.02261935f, -0.08879860f, 0.11067068f, 0.02816113f, 0.05255370f, 0.03152162f, -0.35038114f, -0.06858119f, 
    0.07432101f, -0.20169885f, -0.11906733f, 0.45997146f, -0.02774525f, -0.10764429f, -0.04158431f, 0.01571916f, 
    0.14412437f, -0.24257904f, -0.00591659f, 0.07911500f, 0.16469868f, 0.09172965f, 0.38105607f, -0.00172429f, 
    0.05254921f, -0.22831787f, 0.07597431f, -0.06607410f, 0.35566169f, -0.05246582f, 0.42269808f, -0.00110919f, 
    -0.27036312f, 0.52035499f, 0.13948674f, 0.20597178f, -0.31363115f, 0.45387715f, -0.00656027f, -0.17006949f, 
    0.09530428f, 0.10010362f, 0.04018103f, -0.06624254f, 0.22016777f, -0.14841110f, 0.18840671f, 0.26009580f, 
    -0.02305229f, -0.09785755f, 0.09548352f, 0.32085466f, -0.17671727f, 0.07615489f, -0.21300362f, 0.33573207f, 
    0.09258990f, 0.03643995f, -0.00922923f, -0.18513307f, 0.46283644f, 0.18733832f, 0.06372643f, 0.11557087f, 
    -0.09236678f, 0.16385233f, 0.21031937f, 0.12596738f, 0.01440722f, -0.42731786f, 0.03808295f, 0.01589188f, 
    0.19809017f, -0.05827398f, 0.14738892f, 0.46874180f, 0.20038162f, 0.11606736f, 0.04536884f, 0.06801065f, 
    0.45734715f, 0.02623152f, -0.34088448f, 0.17270587f, 0.13445504f, -0.00895170f, 0.09101856f, -0.16074349f, 
    0.00395547f, 0.28826773f, 0.00656857f, 0.21923494f, -0.51253927f, 0.05317355f, 0.06689315f, -0.06474531f, 
    0.09682807f, 0.15277591f, -0.39315566f, 0.02133636f, -0.03587878f, 0.16857100f, 0.08685455f, -0.03782913f, 
    0.02299906f, 0.03881036f, 0.05559791f, -0.06484070f, -0.07223497f, -0.00560366f, -0.04348813f, -0.09110567f, 
    -0.02842578f, -0.03851556f, -0.07484126f, -0.05088925f, -0.04895459f, 0.03947497f, -0.00018515f, -0.06104529f, 
    -0.06776598f, -0.08187650f, -0.10504401f, 0.01602971f, 0.05292222f, -0.03928221f, 0.03194826f, -0.01669560f, 
    0.02829409f, -0.01389706f, -0.03488768f, 0.05032839f, -0.00697080f, -0.06589536f, 0.01245357f, -0.06355531f, 
    -0.01990681f, 0.04819307f, -0.01508436f, -0.02023045f, 0.03199709f, -0.01651382f, -0.03604020f, -0.07320889f, 
    -0.02971340f, 0.06294905f, -0.01298914f, 0.02126500f, 0.03787887f, 0.03675628f, -0.08682349f, -0.10236225f, 
    0.07364380f, -0.07255841f, 0.03207366f, 0.00773504f, -0.05105334f, 0.05895865f, -0.02629050f, -0.01985591f, 
    -0.08419985f, -0.10673912f, -0.00550982f, 0.08233610f, 0.05226648f, 0.02137012f, -0.02769713f, 0.03995215f, 
    0.03614066f, 0.02845866f, -0.08185389f, -0.08229585f, -0.05221457f, -0.09342226f, -0.09380034f, -0.01216324f, 
    0.02809080f, -0.04556096f, -0.03297442f, 0.04481410f, -0.00091783f, 0.06560126f, -0.08527742f, 0.01496107f, 
    0.07125223f, -0.01586025f, -0.09028694f, -0.10550063f, 0.08133103f, -0.06702528f, 0.06851963f, 0.00553706f, 
    -0.09248192f, 0.06603130f, 0.03077697f, -0.08647451f, -0.07679158f, -0.08585344f, 0.00905286f, -0.04495378f, 
    -0.03565428f, 0.02017632f, -0.08631944f, -0.02841079f, 0.07760896f, -0.01805151f, -0.03198076f, -0.04184529f, 
    0.08106637f, -0.03551165f, 0.01165653f, -0.05167399f, 0.04173456f, 0.05464274f, 0.07523207f, -0.02684742f, 
    -0.06547652f, -0.08480107f, 0.04747331f, -0.02994774f, 0.05356606f, -0.07826731f, 0.04326187f, -0.00983356f, 
    -0.02324932f, -0.05050258f, 0.01121755f, 0.05377001f, -0.00641811f, -0.02786585f, 0.02362886f, -0.06003611f, 
    0.15753157f, 0.23283550f, -0.16663353f, 0.02383660f, -0.01870827f, 0.14375935f, 0.07689606f, 0.11757499f, 
    0.15702219f, 0.02865350f, 0.09164777f, -0.07679434f, -0.05115248f, -0.21922414f, -0.06649908f, 0.12322926f, 
    0.01074001f, 0.03654367f, -0.16994329f, 0.02859731f, -0.31584671f, -0.17672767f, -0.14231442f, 0.11605305f, 
    0.06566418f, 0.08653679f, -0.00306188f, 0.15852562f, 0.07663599f, 0.08977592f, -0.04295361f, -0.10512450f, 
    -0.02851695f, -0.53186846f, -0.29437876f, -0.05953142f, 0.11363919f, 0.12036009f, 0.03895966f, 0.02193702f, 
    -0.09881613f, -0.14665233f, -0.04022920f, -0.00622805f, 0.10124297f, 0.02132276f, -0.14552549f, 0.00058790f, 
    0.14359936f, 0.02579196f, -0.03854512f, 0.11077287f, 0.07551438f, 0.15248317f, -0.00560435f, 0.02903526f, 
    0.05101619f, 0.12738405f, -0.10671837f, 0.45020747f, -0.10291185f, -0.09445544f, -0.12661299f, -0.13012859f, 
    -0.04032274f, -0.10206240f, -0.18698439f, 0.02345308f, 0.44260737f, 0.14391746f, 0.26528975f, 0.03107459f, 
    -0.16882917f, -0.03941359f, -0.00851948f, 0.02791730f, 0.04278324f, -0.02308305f, -0.10713688f, 0.00207873f, 
    0.03533105f, -0.03192173f, 0.23814908f, -0.05228674f, -0.19677640f, 0.36379048f, 0.05390279f, 0.11449213f, 
    -0.02451864f, 0.30102122f, 0.08543943f, 0.07452200f, -0.00079034f, 0.17425373f, 0.00637811f, 0.22306652f, 
    0.06266715f, -0.06394524f, 0.27689856f, 0.17759229f, 0.13791063f, 0.08866618f, 0.14083935f, -0.00774510f, 
    -0.01206534f, -0.05185289f, 0.04220919f, -0.21097963f, 0.18503255f, 0.21854225f, -0.03634109f, -0.11505796f, 
    -0.10865584f, -0.24961090f, -0.14885692f, 0.31433579f, -0.16644137f, 0.21446536f, -0.06931494f, -0.21976900f, 
    0.20498076f, 0.33902374f, -0.16891034f, 0.08151711f, 0.05185442f, -0.02373355f, 0.01644311f, 0.18068750f, 
    -0.04897653f, 0.27128404f, 0.02191202f, -0.01043427f, 0.07337497f, 0.04574287f, 0.03747660f, -0.05124570f, 
    -0.03950666f, -0.03245991f, 0.10297671f, 0.10054404f, -0.10214635f, -0.25018767f, -0.25489232f, 0.03474281f, 
    -0.06928774f, -0.24591066f, -0.14562416f, -0.23752643f, -0.18280505f, -0.24111307f, -0.18515143f, -0.27354392f, 
    0.11439154f, -0.30950639f, 0.00541283f, 0.27060217f, 0.14305282f, 0.01386257f, 0.08427958f, -0.27937615f, 
    0.19567545f, -0.22797392f, -0.30318227f, 0.02481889f, -0.09542985f, 0.11538020f, 0.53237736f, -0.07032321f, 
    0.10910445f, 0.01269146f, 0.03902271f, -0.17083688f, -0.00432558f, 0.09307891f, 0.14208630f, -0.18950567f, 
    0.17992422f, 0.29292914f, 0.05569063f, -0.06716435f, -0.01550292f, 0.15064393f, 0.21187782f, 0.13062492f, 
    0.06362299f, 0.12680861f, 0.10391880f, 0.12231173f, -0.11715560f, -0.12551448f, -0.30319518f, -0.05496842f, 
    -0.18551569f, -0.11047341f, -0.00876722f, 0.14589782f, 0.55591863f, 0.07872774f, 0.07970192f, 0.22564936f, 
    -0.18313608f, -0.12150032f, 0.16246523f, 0.13217252f, -0.00838554f, 0.03040178f, -0.16423899f, -0.05498736f, 
    0.06220965f, -0.13869502f, 0.07713101f, -0.05196141f, -0.10082568f, -0.09770376f, 0.06604455f, 0.16738100f, 
    0.07127059f, 0.15099877f, 0.11443987f, -0.10393045f, 0.20478924f, 0.14865339f, -0.00978998f, 0.25272703f, 
    0.44661546f, -0.18858239f, 0.03912842f, 0.01669671f, 0.02031349f, -0.04939306f, 0.04487564f, -0.03897559f, 
    -0.00896051f, 0.12684461f, -0.33075544f, -0.20565242f, 0.06689944f, 0.15500633f, -0.03192847f, 0.18702446f, 
    -0.14166106f, -0.05755486f, -0.06853673f, 0.50298172f, -0.05347728f, 0.20570686f, -0.08163099f, -0.34809870f, 
    0.22415757f, 0.41337910f, 0.02868944f, -0.17061076f, 0.25808185f, -0.05245283f, 0.12665200f, 0.13462019f, 
    0.11977326f, -0.22783163f, 0.26801553f, -0.03081474f, 0.00020979f, -0.27942094f, -0.03502311f, 0.27219024f, 
    0.02942586f, -0.04728339f, 0.32464659f, -0.24684870f, 0.04366010f, 0.32096648f, 0.08019900f, 0.14604512f, 
    -0.06695581f, -0.18582086f, -0.04681037f, -0.06015617f, 0.13892467f, 0.16773839f, 0.14393483f, 0.10649368f, 
    -0.37309393f, 1.04223776f, -0.04053302f, -0.38446921f, 0.12031320f, -0.03349954f, -0.09354503f, -0.02483108f, 
    0.07355035f, 0.21940434f, 0.27515039f, 0.06944022f, -0.20891723f, -0.26200411f, -0.02478594f, -0.16004965f, 
    0.45013931f, -0.08505508f, -0.06831995f, 0.18352963f, 0.05020650f, -0.11646380f, 0.00180096f, 0.11046883f, 
    -0.12244671f, -0.53098822f, 0.04974228f, -0.00529621f, 0.22282977f, 0.14276437f, 0.13158777f, -0.03839719f, 
    -0.41220027f, 0.17073885f, -0.35182890f, -0.32944587f, -0.12320133f, 0.20933834f, 0.42253044f, -0.15044270f, 
    0.18741488f, 0.00670349f, -0.04316692f, -0.15444410f, -0.20008999f, -0.11284242f, -0.01064971f, -0.04591285f, 
    0.21374843f, -0.08187809f, -0.15424669f, -0.14783095f, -0.29214159f, 0.03961606f, -0.00847988f, 0.21282960f, 
    0.09535631f, 0.09336678f, -0.10703095f, -0.18337797f, 0.07923754f, 0.84973806f, 0.09751981f, -0.16730186f, 
    -0.05560537f, -0.07704774f, -0.09971086f, -0.41870290f, -0.10302978f, -0.17312638f, 0.03971050f, -0.23879302f, 
    0.21599826f, 0.29435873f, -0.10133817f, -0.01803200f, -0.02520164f, -0.04236768f, -0.32146984f, -0.03988503f, 
    0.04034430f, -0.14690600f, 0.23322675f, 0.11918707f, -0.05395430f, -0.44492212f, 0.06421671f, -0.10084311f, 
    0.24333149f, 0.25812328f, -0.12077488f, -0.18278632f, 0.28178474f, -0.02547591f, 0.13233569f, 0.13224609f, 
    -0.04079501f, -0.31148195f, -0.00793053f, 0.49808112f, -0.16537909f, -0.07906527f, 0.09297151f, -0.04317673f, 
    -0.72044021f, -0.24312136f, 0.06772047f, 0.03801181f, 0.00961508f, 0.00064566f, 0.08365901f, 0.27227843f, 
    -0.31597042f, -0.42223269f, -0.19252431f, 0.02737793f, 0.07839630f, 0.23009560f, 0.01293986f, -0.05573237f, 
    -0.04147649f, 0.05384478f, -0.08208511f, 0.14251845f, 0.09301244f, 0.06574851f, 0.31967190f, -0.29374516f, 
    -0.11853021f, 0.32576647f, -0.00977894f, 0.13827284f, 0.07023260f, 0.19591209f, 0.17308044f, -0.02677954f, 
    0.28840855f, -0.09268893f, 0.02441574f, -0.33214980f, 0.15901996f, 0.02340381f, -0.41656637f, -0.22983387f, 
    0.05744102f, 0.00071783f, -0.02256095f, -0.06940611f, -0.01066842f, 0.06600910f, 0.01955126f, -0.21366973f, 
    0.09710141f, 0.09681313f, 0.06134649f, 0.14253418f, -0.64852136f, 0.21855459f, -0.18453613f, -0.10304391f, 
    0.05687785f, -0.18362221f, -0.13244565f, -0.47728851f, 0.11333612f, -0.12647025f, 0.09242098f, -0.03967270f, 
    0.06892871f, -0.02489599f, -0.42117986f, 0.04908333f, -0.04387863f, 0.05350645f, -0.10214485f, -0.01624022f, 
    0.04882514f, 0.03316972f, 0.12705591f, -0.74761009f, -0.06857751f, -0.01997848f, -0.02636098f, -0.36343312f, 
    0.12067425f, 0.26243562f, 0.04503693f, 0.09318589f, 0.08755079f, 0.41324881f, 0.03427359f, 0.11307789f, 
    0.12236488f, 0.05430102f, 0.09211117f, 0.08522373f, 0.16848566f, 0.42420128f, 0.04340673f, 0.15947585f, 
    -0.03139554f, 0.13326973f, 0.12550214f, -0.09266879f, 0.01014240f, -0.19816896f, -0.13136284f, 0.06661080f, 
    -0.17102328f, -0.24505556f, 0.08126479f, -0.12565914f, 0.14121200f, 0.13500518f, -0.23472799f, 0.07819858f, 
    0.09163410f, -0.41345596f, 0.02564866f, -0.02148432f, -0.17331551f, 0.05830828f, 0.12276815f, 0.10414068f, 
    -0.10403181f, -0.14653502f, 0.17811517f, 0.14225788f, 0.07024527f, -0.47934255f, 0.12679850f, 0.12021557f, 
    0.24468336f, 0.11054663f, 0.08127525f, -0.05352307f, -0.06402631f, 0.11263631f, -0.05009444f, 0.09663026f, 
    0.36704415f, 0.05084897f, 0.25142139f, 0.01351334f, 0.03414450f, -0.14360853f, -0.11293022f, 0.38566917f, 
    -0.06796969f, 0.05055045f, -0.17687017f, -0.18686509f, -0.03436750f, -0.20143491f, -0.27594674f, 0.16897595f, 
    0.04937376f, -0.13449925f, 0.17899683f, 0.25470564f, 0.10562811f, 0.10463773f, -0.06128230f, 0.06342298f, 
    0.16028692f, -0.24561426f, -0.05275485f, -0.33970740f, 0.02478704f, 0.06597162f, -0.07197100f, 0.02684489f, 
    -0.00544183f, -0.14952412f, -0.01128821f, -0.10225698f, 0.15434046f, 0.07854942f, 0.26477900f, -0.13024394f, 
    -0.08888017f, 0.05045283f, 0.01433896f, -0.06645548f, 0.21878791f, 0.09900537f, 0.35983256f, -0.06588101f, 
    0.00079084f, 0.05258277f, -0.01835426f, 0.23799933f, -0.14045675f, -0.14707758f, -0.43991968f, -0.21226765f, 
    -0.02999449f, 0.04435108f, -0.10046856f, -0.06413803f, 0.37753159f, 0.09361801f, 0.12017266f, -0.16473472f, 
    -0.14705731f, -0.36675844f, -0.15348497f, -0.11110629f, 0.10771924f, 0.05756288f, -0.01260490f, -0.00516267f, 
    0.10434598f, 0.05991209f, 0.16609836f, -0.07675204f, -0.30103096f, -0.39853612f, -0.01664142f, -0.07220821f, 
    -0.01201990f, 0.09036843f, 0.13414326f, -0.20887405f, 0.11470031f, 0.30602562f, -0.01627996f, -0.00258131f, 
    0.22533645f, -0.09805432f, 0.10141996f, 0.15657851f, -0.03778902f, 0.07790242f, 0.07405856f, 0.02652225f, 
    0.07975519f, -0.22730888f, -0.05016248f, -0.55197018f, 0.33127826f, 0.11408171f, 0.03410393f, -0.00596751f, 
    -0.09714799f, -0.33628812f, 0.01304030f, 0.40893793f, -0.01400892f, 0.30468500f, 0.04420039f, -0.16299242f, 
    -0.14012812f, 0.36200127f, -0.39240277f, 0.03365446f, 0.05264644f, 0.11924758f, 0.00519807f, 0.09001011f, 
    0.04346486f, -0.00017490f, 0.02200234f, 0.08512436f, 0.00566153f, -0.05518319f, 0.01252654f, -0.13105971f, 
    0.01583697f, -0.03068520f, 0.11809927f, -0.09641169f, -0.02814135f, 0.04663683f, -0.03363476f, -0.02244546f, 
    0.01964132f, -0.01613042f, -0.03473026f, -0.06394731f, -0.07594836f, -0.04157557f, 0.05649792f, 0.04459633f, 
    -0.03952552f, 0.00769390f, -0.12345129f, -0.02594104f, -0.01698219f, -0.03071816f, -0.06778758f, 0.02681785f, 
    -0.10400551f, -0.06210685f, -0.02033765f, 0.06364320f, -0.07598905f, 0.02332331f, -0.05769405f, 0.02169358f, 
    -0.01639505f, -0.03895305f, 0.05902610f, -0.07680121f, -0.03721426f, -0.07196160f, 0.00556625f, -0.01691338f, 
    -0.08759266f, 0.05008453f, -0.02122116f, -0.10755324f, -0.08963522f, 0.01899680f, -0.06430618f, 0.02977434f, 
    0.03973878f, 0.02184484f, -0.06970678f, 0.02290265f, -0.04648938f, -0.03949997f, -0.00508147f, -0.06896341f, 
    -0.01133358f, 0.06462608f, -0.09634971f, -0.08586868f, -0.12769763f, -0.04575518f, -0.08182770f, 0.04188871f, 
    0.00300489f, -0.10572859f, 0.02486891f, -0.08024640f, -0.09453361f, -0.04817550f, -0.08867502f, 0.03550722f, 
    0.04349620f, -0.01955342f, -0.11058731f, 0.00291312f, 0.02965276f, -0.02877817f, 0.04800106f, 0.01790123f, 
    0.03219520f, -0.05855916f, -0.04179977f, -0.00577916f, -0.00156165f, -0.02899908f, 0.03416566f, -0.01173246f, 
    0.00034865f, -0.08700982f, -0.05043362f, 0.01011473f, -0.03286628f, -0.04596093f, -0.01685308f, -0.08740955f, 
    -0.06009718f, -0.01731939f, -0.03542212f, 0.06873853f, -0.08408272f, 0.03268587f, 0.00599275f, 0.02248902f, 
    -0.03030700f, 0.08540665f, -0.10824893f, -0.00895159f, -0.03323999f, -0.00105658f, -0.07139689f, -0.00977473f, 
    -0.10140806f, -0.01324679f, 0.00972160f, -0.00809510f, 0.03976696f, -0.04969336f, -0.12775730f, -0.03219356f, 
    0.05232265f, 0.19482909f, 0.39306450f, 0.05320225f, 0.04392053f, -0.16296524f, 0.10298691f, -0.04295749f, 
    -0.02136543f, 0.13234356f, -0.28776553f, 0.03357839f, -0.45690852f, 0.07349904f, -0.08024289f, 0.04728021f, 
    0.05481274f, -0.20880841f, -0.21506503f, -0.06717430f, -0.02839820f, -0.08256201f, 0.09228240f, -0.05282852f, 
    -0.06338833f, 0.06597058f, 0.02702664f, 0.15714304f, 0.08467922f, 0.04276187f, 0.32842290f, -0.20350826f, 
    0.16421713f, -0.42637208f, -0.13642898f, -0.28000012f, -0.11957728f, 0.05652146f, 0.30354062f, 0.04262961f, 
    -0.23993489f, -0.09796542f, 0.05737909f, 0.00599702f, 0.05143613f, 0.07294475f, -0.01432677f, -0.08259822f, 
    0.07474904f, 0.27352342f, 0.05952803f, -0.15485717f, -0.07479341f, 0.39574957f, 0.11797843f, -0.01111140f, 
    -0.01745971f, 0.14929348f, 0.01416740f, 0.25221035f, -0.02803886f, -0.15597698f, 0.01817138f, 0.04806419f, 
    -0.06936504f, -0.07233204f, 0.00181025f, 0.16362403f, 0.42304125f, 0.22087169f, 0.13389370f, 0.02451649f, 
    -0.04598003f, 0.04497561f, 0.16124780f, 0.15246125f, -0.03185039f, 0.05383789f, -0.37980780f, -0.03050496f, 
    0.12224203f, -0.10987992f, 0.24245809f, -0.18772927f, -0.06786052f, -0.14589261f, -0.08624406f, 0.29817489f, 
    -0.04048565f, 0.22582279f, 0.22993177f, -0.15765013f, 0.24886514f, 0.18126130f, -0.05763119f, 0.08638676f, 
    0.03089561f, 0.00889730f, 0.04053270f, 0.15071794f, -0.06091630f, 0.09020246f, 0.09793406f, -0.04717015f, 
    -0.08523933f, 0.14338517f, -0.05846598f, -0.03400364f, 0.06387375f, -0.06084386f, -0.07596903f, 0.02312356f, 
    0.12443300f, -0.21798275f, -0.02956648f, 0.33475310f, 0.30150577f, 0.24030292f, 0.10350473f, -0.00939719f, 
    0.06710201f, 0.52223098f, 0.07544744f, -0.33488959f, 0.17059003f, -0.04015691f, 0.06788909f, -0.25345537f, 
    -0.05357637f, 0.21704787f, 0.33348647f, -0.01037925f, 0.13363795f, 0.06880981f, -0.02072817f, 0.00696828f, 
    0.02591857f, 0.12751524f, 0.42184153f, 0.00528402f, -0.11386278f, -0.11370010f, -0.39774886f, 0.09039748f, 
    0.01998758f, -0.07978113f, -0.09246303f, -0.04904723f, -0.24813998f, -0.16238801f, -0.10064685f, 0.06594987f, 
    -0.07009260f, -0.71630192f, 0.03837152f, 0.33127454f, 0.00678644f, 0.06094725f, -0.21159334f, -0.10242122f, 
    0.16198771f, 0.26746923f, -0.15472400f, 0.04792704f, -0.07006270f, 0.03851619f, 0.32254654f, -0.33382246f, 
    0.11199283f, -0.09015123f, -0.01130592f, -0.01311014f, 0.08298599f, -0.04190687f, 0.01541775f, -0.31499940f, 
    -0.08434824f, 0.01234535f, -0.04338461f, -0.06441686f, 0.13426724f, 0.07694741f, 0.02873695f, 0.15670949f, 
    0.06999880f, 0.13129723f, 0.27324811f, -0.05271601f, 0.05638353f, 0.04170835f, -0.17369851f, -0.27698079f, 
    -0.14380363f, -0.15945198f, 0.04701011f, 0.17730242f, 0.15052275f, -0.19448203f, -0.00307976f, 0.27508998f, 
    0.01086588f, -0.16671959f, 0.00619047f, 0.11821816f, -0.04627737f, -0.05323393f, -0.05862735f, 0.03844783f, 
    -0.06185084f, -0.04824108f, 0.03110213f, -0.05343244f, 0.18788405f, -0.63503647f, 0.04581210f, 0.03099816f, 
    -0.04772687f, 0.30301228f, 0.29320374f, -0.02969362f, 0.07969932f, -0.09531510f, -0.00359753f, 0.18202390f, 
    -0.08988898f, -0.31287357f, -0.08252765f, -0.04824532f, 0.07912645f, 0.01948334f, -0.00323218f, 0.08420387f, 
    0.01229336f, 0.16082701f, -0.28794059f, 0.08533510f, 0.01014642f, 0.00502945f, -0.07215694f, 0.08288453f, 
    -0.07427129f, 0.06599230f, 0.03325808f, 0.35454994f, 0.21032770f, 0.16443862f, -0.23973273f, -0.14945328f, 
    0.25050014f, 0.15565903f, -0.31356278f, -0.03050701f, 0.22122511f, 0.10044985f, 0.08302745f, 0.23680055f, 
    0.08315653f, -0.72722882f, -0.23200077f, 0.08042199f, -0.06527761f, 0.26563081f, -0.15695117f, 0.03657364f, 
    0.51559716f, -0.09547386f, 0.33961114f, -0.00577975f, 0.15387329f, -0.45591640f, 0.00747713f, -0.09035439f, 
    0.01007708f, -0.01839236f, 0.00732681f, 0.09339835f, -0.38454452f, -0.62073100f, -0.31807783f, 0.11800177f, 
    -0.04936673f, 0.53976691f, -0.12372389f, -0.21974346f, 0.02919447f, -0.07681553f, -0.52398980f, -0.06876943f, 
    -0.42141593f, -0.03684225f, -0.19833364f, -0.10744378f, 0.19358262f, 0.06539016f, -0.21683639f, -0.13538300f, 
    -0.02614800f, -0.15086403f, -0.02013490f, -0.28714910f, 0.07244427f, -0.18299305f, -0.04929825f, 0.22070020f, 
    0.18635571f, -0.23197958f, 0.04267039f, 0.23597902f, -0.18509382f, -0.15881848f, -0.17148329f, -0.26686344f, 
    -0.13280143f, 0.11563497f, 0.10271637f, -0.72432500f, -0.03291910f, -0.03533332f, -0.35279268f, -0.27926606f, 
    -0.00114969f, -0.19067939f, -0.17581707f, -0.01878526f, 0.13070782f, 0.01901234f, 0.83269674f, -0.08712398f, 
    -0.31699803f, -0.08701102f, -0.32257274f, -0.35934761f, 0.05003095f, -0.07138869f, 0.08260643f, -0.23710053f, 
    0.03406975f, 0.03212224f, -0.04409438f, 0.06044682f, -0.23099329f, 0.16692668f, -0.02826420f, 0.09126431f, 
    -0.08627984f, 0.05528466f, 0.35588440f, 0.08806843f, -0.25453162f, 0.03274092f, -0.00104290f, -0.02749231f, 
    0.06627269f, -0.22636990f, 0.30953634f, 0.22570999f, -0.22184958f, -0.51576191f, -0.09259390f, -0.00565238f, 
    0.00935663f, -0.30337840f, -0.07035064f, -0.12625094f, 0.49330732f, 0.22666256f, -0.13235341f, -0.03314495f, 
    0.21298426f, -0.39759526f, -0.10399900f, 0.07424932f, 0.53541428f, -0.16667889f, 0.11167326f, -0.50657541f, 
    -0.36527666f, -0.23782414f, -0.49366295f, 0.11911780f, -0.44564140f, 0.17719871f, -0.26893348f, 0.59358639f, 
    0.11089627f, -0.06000532f, -0.25090739f, 0.06598815f, -0.04759608f, 0.04947075f, 0.01505466f, 0.05726182f, 
    0.11571372f, 0.00720043f, -0.06408836f, -0.16756119f, -0.03390069f, 0.13267653f, 0.25362703f, 0.25788844f, 
    0.03222629f, -0.02359000f, 0.15840375f, -0.13444525f, -0.05445693f, -0.16030216f, 0.09548933f, 0.09685200f, 
    0.01948076f, -0.11420947f, 0.17391793f, 0.04682865f, 0.05875102f, 0.15374839f, 0.00427315f, -0.17679036f, 
    0.01532995f, 0.12649180f, -0.16270445f, -0.03337161f, 0.18186033f, -0.20151289f, -0.31513149f, 0.03359935f, 
    0.17862654f, -0.19812137f, 0.03882885f, 0.04855235f, -0.00829297f, 0.06583916f, -0.14043571f, -0.06281399f, 
    0.06540965f, 0.09219512f, -0.03352980f, 0.14727455f, 0.08183870f, -0.12139155f, 0.08701143f, -0.20422851f, 
    -0.25382194f, 0.15717450f, 0.02084387f, -0.23542807f, 0.02744802f, 0.21909100f, -0.18043093f, 0.08708981f, 
    0.11557044f, 0.19698192f, 0.33896807f, -0.17451596f, 0.26979765f, -0.16985554f, 0.08323450f, -0.13677424f, 
    0.10680909f, 0.09872694f, 0.01410199f, -0.03778375f, -0.40909132f, 0.04566060f, -0.10311355f, 0.23300421f, 
    -0.02951306f, 0.05482860f, -0.02375865f, -0.25216249f, 0.30869102f, -0.39621389f, -0.01439861f, 0.04854166f, 
    -0.04740619f, 0.01099837f, 0.34520614f, -0.05076477f, 0.17469251f, 0.13600056f, -0.01351541f, 0.07387844f, 
    -0.06791802f, 0.16502020f, -0.14926013f, -0.26719430f, 0.01908379f, 0.22798185f, -0.22673245f, -0.08701005f, 
    0.18269315f, 0.14061439f, -0.01021582f, 0.08476000f, 0.11348952f, -0.05987890f, 0.14553146f, -0.05770047f, 
    -0.02054208f, 0.07861574f, -0.13194796f, 0.12691107f, -0.06122772f, -0.01882592f, 0.04353715f, 0.22360003f, 
    0.09720688f, 0.24337626f, -0.40087038f, 0.20922709f, 0.12990640f, 0.28079936f, -0.00792262f, 0.10017529f, 
    -0.10927957f, -0.05786815f, -0.07110631f, -0.03582289f, 0.01034747f, 0.08276787f, -0.02317400f, 0.02462341f, 
    0.05752557f, -0.02859818f, -0.00527012f, -0.03834549f, 0.06614922f, -0.09552204f, -0.08809025f, 0.05609867f, 
    -0.01415882f, 0.01819403f, -0.06534357f, 0.06305936f, -0.07714516f, -0.02110682f, -0.04009094f, -0.07230233f, 
    -0.04279970f, 0.07106852f, 0.00308982f, 0.02053992f, 0.06258943f, -0.07633521f, -0.02844085f, -0.03143068f, 
    -0.00299076f, -0.07107422f, -0.02464143f, -0.06268887f, -0.09612821f, -0.05055013f, -0.03895533f, -0.08313783f, 
    0.00709336f, 0.04772940f, -0.07580103f, -0.12930845f, -0.10053575f, -0.07774413f, -0.10194825f, -0.06846506f, 
    -0.08140452f, 0.06255229f, 0.02508205f, -0.06379065f, -0.10141286f, 0.02949898f, 0.04856986f, -0.05695788f, 
    -0.05366572f, 0.02887768f, -0.00937888f, 0.07213427f, -0.04082482f, 0.05456072f, -0.03467892f, -0.02311747f, 
    -0.08385848f, -0.03309179f, -0.00585198f, 0.03473187f, -0.09999148f, -0.00336359f, -0.08619144f, -0.02982974f, 
    0.03211088f, 0.03787084f, -0.10641797f, -0.04865820f, -0.03506802f, -0.00927910f, 0.00825375f, -0.00703580f, 
    -0.08936971f, -0.01137437f, -0.02028850f, 0.06695125f, 0.01509826f, 0.06709471f, 0.05131442f, -0.08235675f, 
    0.00013667f, 0.03450236f, -0.00123308f, -0.07707974f, 0.07696167f, -0.05668154f, 0.02250067f, -0.04917340f, 
    0.04762322f, -0.13671063f, -0.09067363f, 0.03869942f, -0.04000933f, -0.11948238f, -0.03819557f, 0.07069842f, 
    0.02502532f, -0.05168017f, -0.08645336f, -0.03289669f, -0.07958736f, 0.05970315f, -0.07747285f, -0.09523462f, 
    0.04160144f, -0.00101507f, -0.11884654f, -0.08897034f, -0.03824244f, -0.08482637f, 0.05234721f, -0.03362125f, 
    -0.02327473f, 0.02082298f, 0.03433720f, -0.03825048f, 0.04002805f, -0.11161886f, -0.07802079f, -0.03571933f, 
    -0.35901031f, 0.19314057f, -0.23611113f, -0.09388812f, -0.05831198f, 0.12613107f, 0.07454926f, -0.11739357f, 
    -0.26144198f, 0.06108011f, -0.42814928f, 0.07202004f, -0.11334213f, 0.11976433f, 0.05184691f, -0.10316478f, 
    0.08461215f, -0.19671568f, 0.09297974f, -0.06037344f, -0.09341861f, 0.11685586f, -0.03995570f, -0.14560306f, 
    -0.11384783f, -0.58285403f, -0.00299720f, 0.21463558f, 0.10045289f, 0.08683144f, 0.08384833f, -0.20119570f, 
    -0.02013706f, 0.23971471f, 0.01806874f, 0.29593879f, -0.10292166f, 0.02892562f, 0.63883877f, 0.10105219f, 
    0.05317815f, 0.07450538f, -0.07902426f, 0.03749157f, -0.04593684f, 0.01363682f, -0.34770966f, 0.06091720f, 
    0.07628576f, 0.04263748f, 0.06047151f, 0.05727046f, -0.07786854f, 0.13334192f, -0.07496046f, -0.04533977f, 
    0.10571708f, 0.10218830f, 0.26951599f, -0.54823762f, -0.07767128f, 0.05173059f, 0.13738011f, 0.20539583f, 
    -0.06797560f, -0.09608893f, 0.05382584f, 0.11875538f, -0.04321038f, 0.05830762f, -0.00945123f, 0.19352412f, 
    0.01727629f, 0.27560136f, 0.14704232f, 0.19367912f, -0.04999360f, -0.01821639f, -0.00956286f, 0.08759230f, 
    -0.05979385f, 0.04200716f, -0.03163507f, 0.05723539f, 0.05098155f, -0.73674601f, -0.07860461f, 0.04652337f, 
    0.04846353f, 0.15032203f, -0.03810401f, 0.01829176f, -0.11215401f, -0.06848954f, -0.04231316f, 0.13795575f, 
    -0.14612463f, 0.03528502f, -0.13980249f, -0.02714211f, 0.16942938f, 0.00477292f, 0.05455575f, 0.08520329f, 
    0.09479005f, 0.24452852f, -0.12619078f, 0.28460723f, -0.15197600f, 0.00255096f, -0.00862328f, 0.14736576f, 
    -0.12315650f, 0.26774341f, -0.03604716f, -0.01170534f, -0.03963612f, -0.13475516f, -0.07692885f, -0.02635364f, 
    0.19151749f, -0.03607381f, 0.57810867f, -0.24979204f, 0.10545555f, -0.13571602f, 0.14830890f, -0.20709665f, 
    -0.04334212f, -0.07345625f, 0.07719219f, -0.06944322f, -0.07631134f, -0.19574019f, -0.02923596f, 0.05956054f, 
    0.10837662f, 0.13422911f, 0.04943420f, -0.11109960f, 0.11973381f, 0.12519805f, 0.23807879f, 0.16761333f, 
    -0.00297118f, -0.07406540f, 0.09378812f, -0.05674202f, 0.25361487f, 0.11169246f, -0.10431319f, 0.08313832f, 
    -0.11525328f, -0.24812275f, 0.09470706f, -0.13395780f, -0.09947206f, 0.08381255f, -0.16031134f, -0.05966940f, 
    0.15641265f, 0.08003547f, 0.20015097f, 0.16418289f, -0.12379487f, -0.16344549f, -0.25256786f, -0.19880632f, 
    0.15708180f, -0.08723424f, -0.05169008f, 0.05616262f, -0.10552340f, -0.11915106f, -0.01419870f, -0.02716408f, 
    0.17056479f, -0.25054458f, 0.12124785f, 0.21090086f, 0.04454240f, -0.22892193f, 0.02630563f, 0.01001493f, 
    -0.11649681f, 0.18485770f, 0.06656737f, -0.22097619f, 0.00797078f, 0.33348611f, 0.01458496f, 0.17637047f, 
    0.17289093f, 0.22729681f, 0.29553396f, 0.06692859f, -0.18504816f, -0.30131048f, 0.07886668f, 0.03175619f, 
    0.19487795f, -0.18213429f, 0.08704379f, -0.07432329f, -0.06679270f, 0.04147713f, -0.05949431f, 0.25669008f, 
    -0.04111819f, -0.04773176f, -0.13045599f, 0.03218865f, 0.11279198f, -0.43113112f, 0.07096000f, -0.06870236f, 
    0.15670130f, -0.06162435f, 0.10225143f, -0.16340826f, 0.12696274f, 0.13472290f, -0.07809702f, 0.03715440f, 
    -0.41455975f, 0.18315378f, -0.13046239f, -0.21197923f, 0.04965027f, 0.00513531f, 0.12900716f, -0.03249378f, 
    0.02062428f, -0.01189503f, -0.06607144f, 0.30118030f, -0.00841011f, -0.34813821f, 0.07959513f, 0.19573578f, 
    -0.13253644f, 0.22733206f, 0.02271971f, -0.23581252f, 0.16103001f, -0.21774024f, -0.15040997f, 0.10113493f, 
    0.03090654f, -0.20609263f, -0.08023176f, 0.06715062f, 0.08109457f, 0.16131829f, 0.13272874f, 0.14692275f, 
    0.18182088f, 0.37420216f, -0.21685429f, 0.02851055f, 0.08365681f, -0.12852113f, -0.00222015f, -0.10924187f, 
    0.01432688f, -0.00170021f, 0.29472017f, -0.00493314f, -0.31059700f, 0.04453872f, 0.09207130f, -0.01282719f, 
    -0.07151666f, -0.10118335f, -0.01132053f, -0.10775678f, -0.14196087f, 0.06649621f, -0.19293059f, 0.04743065f, 
    0.22949921f, -0.31656140f, 0.02284694f, 0.12540287f, 0.13605972f, -0.00211171f, 0.29825538f, -0.12733530f, 
    -0.10901245f, -0.08363798f, -0.10544124f, -0.04139553f, -0.11175719f, -0.01241421f, -0.43254933f, 0.32360688f, 
    -0.03591135f, 0.06376032f, -0.01882708f, 0.28171051f, 0.14307298f, 0.19234750f, 0.12517618f, -0.03828994f, 
    0.23841818f, 0.18572785f, 0.04806873f, 0.03943673f, 0.17316283f, 0.14451624f, -0.05249442f, 0.20823750f, 
    -0.01324988f, 0.11018772f, 0.14267550f, -0.03061089f, 0.03311586f, 0.08158340f, -0.17116441f, 0.15595873f, 
    -0.05290506f, 0.23045728f, 0.24075398f, 0.10030989f, 0.23981480f, 0.08949645f, 0.17835432f, -0.11493212f, 
    0.17927045f, 0.28749356f, 0.11563968f, 0.31786960f, -0.46658292f, 0.07296663f, -0.10247666f, 0.09243505f, 
    -0.12680297f, -0.27039975f, 0.02311606f, -0.29573217f, 0.08680136f, -0.61065894f, -0.01943432f, 0.06843152f, 
    -0.15675005f, 0.16951686f, -0.12966953f, 0.02159901f, -0.06103370f, -0.03726331f, -0.07115930f, 0.22081973f, 
    -0.32998994f, 0.11073301f, -0.27118722f, -0.17100178f, 0.12196822f, 0.09738097f, 0.18641433f, -0.03545032f, 
    -0.09765206f, 0.25545081f, -0.13447155f, 0.22888562f, -0.00388327f, -0.12265295f, -0.02049201f, -0.08675727f, 
    -0.10686535f, 0.07788958f, -0.10398552f, 0.19788469f, -0.09435349f, 0.12906964f, 0.00066275f, 0.11876445f, 
    0.18288404f, 0.26649076f, 0.15882035f, -0.43810090f, 0.13286841f, 0.22950019f, 0.08984618f, 0.11770577f, 
    0.12889819f, 0.51624072f, -0.13176419f, 0.01762711f, -0.02296342f, 0.10636040f, 0.28534052f, 0.06243891f, 
    0.02544815f, 0.13653806f, -0.04969266f, -0.08105531f, 0.01458674f, -0.33670482f, -0.00473089f, -0.02365933f, 
    -0.03454508f, -0.23914438f, -0.12661590f, -0.15527181f, -0.45631036f, 0.12852193f, -0.30471894f, 0.13847265f, 
    0.08435977f, -0.20276617f, -0.06969476f, 0.08980845f, -0.14479311f, -0.08430403f, -0.09515881f, -0.08857688f, 
    -0.37266341f, -0.13633391f, -0.28288341f, -0.03646726f, -0.07233060f, -0.26445067f, -0.21075132f, -0.04786362f, 
    -0.19104263f, -0.33146536f, -0.03492643f, 0.44551238f, 0.26649651f, -0.02801964f, 0.28814334f, -0.26103237f, 
    0.23044203f, -0.08463813f, 0.05291032f, -0.30305776f, 0.31894445f, 0.03296073f, -0.06531083f, 0.21338619f, 
    -0.06931776f, 0.14282639f, 0.27054676f, 0.17805761f, -0.46891391f, -0.03115795f, -0.02454507f, -0.57340199f, 
    -0.22548939f, -0.00661156f, -0.12994003f, 0.00146552f, 0.21973456f, -0.25082642f, 0.27568641f, 0.17615445f, 
    0.11977267f, 0.07669700f, 0.13534555f, 0.28405532f, -0.17959931f, 0.06505679f, -0.01008547f, 0.17199409f, 
    -0.03730012f, -0.06816445f, -0.01789275f, -0.27505708f, -0.12779851f, -0.20633797f, -0.06438247f, 0.22119343f, 
    -0.24986035f, 0.16381538f, -0.67479193f, 0.37649620f, -0.28732452f, -0.17200205f, 0.02743678f, 0.19602856f, 
    -0.36103165f, 0.03164311f, 0.26368859f, 0.21232368f, 0.33787054f, 0.16981265f, 0.31435120f, 0.03526687f, 
    0.05692912f, 0.04814683f, -0.11938572f, 0.04764152f, 0.07654426f, 0.16575222f, 0.21351023f, -0.16724536f, 
    -0.08208523f, -0.01913480f, -0.15241161f, 0.29377323f, -0.36956245f, 0.17409444f, 0.03986522f, -0.02042611f, 
    0.26355791f, 0.38008890f, -0.37117854f, -0.05373704f, -0.15773258f, 0.04199363f, -0.04766155f, -0.51806867f, 
    0.03476992f, -0.06834769f, -0.01336766f, -0.06358674f, 0.07711112f, 0.00870323f, -0.03736998f, 0.06412960f, 
    0.01373853f, 0.04146127f, 0.03001537f, 0.05676094f, -0.08857828f, -0.10301788f, -0.03551278f, 0.07220282f, 
    -0.00899325f, -0.02871345f, -0.06587305f, 0.00928941f, -0.09049808f, -0.01034016f, 0.06247741f, 0.01512224f, 
    0.06332223f, 0.00064233f, 0.02495834f, -0.08582073f, -0.01823588f, 0.00841420f, 0.06326061f, 0.03798387f, 
    0.02013291f, -0.01184383f, -0.08816288f, -0.03209775f, 0.03867006f, -0.03518052f, -0.00299015f, -0.04469990f, 
    -0.03053372f, 0.04984655f, 0.07093082f, -0.01553420f, 0.03390788f, -0.09581678f, 0.07105269f, 0.01318006f, 
    0.04673201f, -0.06660777f, -0.00516201f, -0.09641234f, 0.05505212f, 0.01545815f, -0.00523595f, -0.09963857f, 
    0.02201728f, -0.04929865f, -0.05208875f, 0.07882264f, -0.09283115f, -0.04871942f, -0.08374081f, 0.04009803f, 
    0.05843963f, 0.07280269f, 0.07273560f, 0.04748932f, -0.02203788f, 0.05645750f, -0.06668346f, -0.07613769f, 
    0.01686601f, 0.01988624f, 0.07004753f, -0.03031645f, 0.02374574f, -0.00101707f, 0.00190563f, 0.00810822f, 
    0.02972456f, -0.08373769f, -0.08485962f, -0.05454526f, -0.10192850f, 0.04792357f, 0.05435839f, 0.02965748f, 
    -0.02274587f, -0.03878801f, 0.04849553f, -0.06714693f, 0.03764226f, -0.00453964f, 0.05821706f, 0.05726019f, 
    -0.01227882f, -0.06522302f, -0.00227447f, 0.02007795f, -0.08342239f, -0.00100434f, -0.05476581f, -0.08382402f, 
    -0.02493998f, -0.03044146f, -0.06428848f, 0.04499856f, -0.07725570f, -0.03184458f, 0.07227483f, -0.01274703f, 
    0.00259422f, -0.02796587f, -0.09992375f, 0.01023029f, 0.04745236f, -0.01902201f, -0.06110157f, -0.07254703f, 
    -0.08742658f, 0.02756606f, 0.05872675f, 0.04314943f, -0.00660162f, -0.07565131f, 0.01613491f, 0.08535818f, 
    0.00488981f, 0.05759034f, -0.04383771f, 0.09048922f, 0.08498929f, 0.04387263f, -0.34906512f, 0.06236516f, 
    0.09860432f, -0.32206881f, -0.03343240f, -0.07997891f, -0.19383919f, -0.03655719f, 0.10330544f, 0.11073885f, 
    -0.00721234f, 0.07860288f, 0.09086819f, -0.04012902f, -0.27902335f, -0.10946946f, -0.38231272f, -0.14041483f, 
    0.01333673f, -0.29689550f, 0.13552110f, 0.02572633f, 0.07519244f, -0.09424387f, 0.11824059f, 0.03157132f, 
    -0.08459953f, -0.25733051f, -0.02702914f, 0.24244191f, 0.13172860f, 0.02984852f, -0.20374757f, 0.44366741f, 
    -0.34949213f, 0.09366957f, -0.07228003f, -0.01481929f, 0.17662416f, 0.05875563f, 0.10197701f, 0.27839100f, 
    -0.13187516f, 0.08833606f, 0.00799623f, -0.00199679f, -0.20057608f, -0.24124584f, -0.07944074f, -0.11223114f, 
    -0.11720084f, -0.04125000f, 0.27400804f, -0.08170542f, -0.05921485f, -0.08327628f, -0.25162730f, 0.38549951f, 
    0.05907018f, 0.46290988f, 0.17188668f, -0.02889141f, 0.18895616f, -0.06454121f, 0.14368863f, -0.23602988f, 
    0.14130348f, 0.17955543f, 0.02444458f, 0.07184801f, 0.02909201f, 0.00000194f, 0.02077215f, 0.08463888f, 
    -0.04619980f, -0.17027089f, 0.06315660f, -0.06258541f, 0.15851836f, 0.03355503f, 0.02707120f, -0.05133445f, 
    -0.08269638f, -0.01120783f, 0.14187393f, -0.18218648f, 0.00099809f, 0.12929133f, 0.10571545f, 0.04344001f, 
    -0.02283604f, -0.00654282f, 0.03918765f, -0.22074035f, 0.05048610f, -0.06346018f, 0.12557457f, -0.08241019f, 
    -0.09357835f, -0.05268322f, -0.08783324f, -0.01467877f, 0.11958022f, 0.02362921f, 0.01926005f, -0.04682055f, 
    -0.11809418f, -0.03105840f, -0.11447683f, 0.17333709f, 0.54884064f, 0.00580051f, 0.14913687f, 0.15713227f, 
    -0.01204286f, -0.09134534f, -0.08217160f, -0.12815730f, 0.04097286f, 0.17689188f, 0.07494553f, 0.21302195f, 
    -0.12284679f, 0.20335367f, -0.17026812f, -0.03555042f, 0.09595233f, -0.12188668f, 0.05244107f, -0.18591671f, 
    -0.21699460f, 0.09933570f, -0.29692361f, 0.00156540f, 0.02116232f, 0.16536367f, 0.03804510f, -0.12480307f, 
    0.04394414f, -0.54175442f, 0.12445842f, 0.10420802f, -0.09131014f, 0.01379253f, 0.14833650f, -0.17426176f, 
    -0.08630870f, -0.58704460f, -0.11312337f, 0.15306576f, 0.17924505f, 0.04004094f, 0.27545923f, -0.24569315f, 
    0.19512144f, 0.04126532f, -0.10484501f, 0.11975102f, -0.37249470f, -0.25148866f, -0.42604253f, -0.32902071f, 
    0.12545712f, 0.04202545f, -0.01790920f, -0.17821819f, -0.19821316f, -0.04837037f, -0.11784911f, -0.31673682f, 
    0.11379098f, -0.01612658f, -0.01563139f, 0.07164600f, 0.03692957f, 0.22288677f, -0.12494034f, 0.06007789f, 
    0.06571357f, 0.17198017f, 0.20073378f, -0.38476869f, 0.05612051f, 0.14782432f, 0.27224159f, -0.23036700f, 
    -0.06897716f, -0.10278419f, -0.00112093f, 0.18201044f, -0.09121030f, 0.18562205f, -0.08186007f, 0.32306033f, 
    0.16005886f, 0.24084561f, 0.20788786f, 0.24569659f, -0.07126512f, 0.08672184f, 0.08076455f, 0.03240880f, 
    -0.15003277f, -0.06972583f, -0.19460049f, 0.00241005f, 0.19357997f, -0.80454671f, -0.07624785f, 0.22227246f, 
    0.06837197f, 0.13402200f, -0.20442910f, -0.01728241f, -0.15647924f, 0.07074658f, -0.08444923f, 0.18057700f, 
    -0.24831423f, -0.09135690f, -0.15740296f, 0.09011409f, 0.05226835f, 0.06146660f, 0.00158364f, 0.08149663f, 
    0.01467162f, 0.24987271f, -0.11947165f, 0.32483616f, -0.22516783f, -0.23584621f, 0.05700689f, 0.03596216f, 
    0.09429666f, 0.32541725f, -0.06759325f, -0.05164831f, -0.15506613f, -0.00264946f, -0.09123363f, -0.02485953f, 
    0.14238548f, 0.18277068f, -0.33769411f, -0.06912602f, 0.04540564f, -0.15051159f, 0.15625334f, 0.09237606f, 
    0.33106616f, 0.10338597f, 0.18757215f, 0.09269566f, 0.06894499f, 0.23369946f, -0.10853286f, 0.14081568f, 
    0.27061430f, 0.10722788f, 0.11522840f, 0.06260562f, 0.03659710f, -0.16534381f, -0.21375966f, 0.22848313f, 
    0.01793907f, -0.08110087f, 0.16848323f, -0.09556670f, -0.12038525f, -0.18108098f, -0.08714538f, 0.22021666f, 
    0.01287011f, 0.28420904f, -0.06786039f, 0.35256964f, -0.41474035f, -0.11284498f, -0.35956505f, -0.02940405f, 
    -0.03146300f, 0.09178728f, 0.11165892f, 0.40464038f, 0.11238024f, -0.16147208f, 0.07293634f, -0.25551295f, 
    0.13101354f, -0.06909405f, 0.06776508f, -0.10538345f, 0.15440027f, 0.05501537f, 0.23569593f, -0.09965356f, 
    -0.07454432f, -0.32531205f, -0.04540078f, -0.14727934f, 0.19434901f, -0.15540788f, 0.17695864f, -0.01897166f, 
    -0.07492703f, 0.15692219f, 0.12118445f, 0.41524062f, -0.05705696f, 0.14828975f, -0.28812227f, -0.14910269f, 
    0.14638808f, -0.03513588f, 0.04182449f, -0.04235765f, -0.10163024f, -0.75741476f, 0.11186690f, 0.14797449f, 
    -0.04641895f, -0.48244712f, -0.09901181f, -0.07313287f, -0.10428547f, 0.06830374f, 0.09731759f, 0.05241673f, 
    -0.04913517f, -0.01553238f, -0.10725437f, -0.08116837f, 0.18236604f, 0.72981882f, 0.06023971f, -0.01983326f, 
    -0.02037374f, -0.10787699f, 0.24190484f, 0.06284682f, -0.03764829f, 0.13091230f, -0.01376479f, 0.06206452f, 
    0.33295640f, -0.32175848f, 0.01103205f, 0.06096379f, 0.00130346f, -0.13478725f, -0.00614021f, 0.05142102f, 
    -0.02449139f, -0.19885032f, 0.00779573f, -0.22271512f, -0.02784678f, -0.04792834f, 0.11429817f, 0.08654058f, 
    -0.01401207f, 0.10859653f, -0.26157907f, 0.16527291f, 0.15337802f, 0.04447784f, -0.07770291f, 0.06842079f, 
    -0.18045522f, -0.03045853f, 0.00946191f, 0.04727048f, 0.02074498f, 0.19575536f, 0.00695722f, 0.84900343f, 
    -0.09814117f, -0.31996110f, 0.26759288f, 0.01590487f, -0.11344893f, -0.37247798f, 0.06173934f, 0.22025943f, 
    -0.03262402f, 0.02917641f, -0.41368699f, -0.21954481f, -0.18923235f, 0.30332330f, 0.04383803f, -0.00646546f, 
    0.03081204f, -0.04693705f, -0.14738815f, 0.10618565f, 0.19992517f, 0.17790921f, 0.40149215f, 0.14500386f, 
    -0.48661572f, 0.96647680f, -0.09795380f, -0.37572500f, 0.25167003f, 0.07077663f, 0.05152437f, -0.03624823f, 
    0.12735949f, 0.29097104f, 0.07920388f, -0.04889097f, -0.17136167f, 0.09377625f, 0.09118876f, -0.01910214f, 
    0.29038477f, -0.25427875f, 0.01169050f, -0.02524350f, -0.16214047f, -0.08367498f, -0.01749009f, 0.39402723f, 
    -0.32197753f, -0.40554628f, -0.01356479f, 0.18596306f, 0.21960552f, 0.18851802f, 0.05999171f, -0.20675480f, 
    -0.08123577f, 0.04909398f, -0.26021615f, -0.33999047f, 0.01399517f, 0.05453452f, 0.60624057f, 0.29712322f, 
    0.14272785f, -0.07685062f, 0.05742336f, -0.01757883f, -0.46766084f, 0.20614393f, -0.11049955f, -0.06040395f, 
    -0.01754116f, -0.02943429f, -0.10955185f, -0.14000157f, -0.01713509f, -0.06756856f, -0.09982333f, 0.14716320f, 
    0.11600363f, -0.01396430f, -0.04860293f, -0.01325962f, 0.12976491f, 0.77257997f, 0.02524390f, -0.44193658f, 
    -0.04516850f, 0.04938810f, 0.17397849f, -0.41118336f, 0.03928068f, 0.05135291f, 0.07279600f, -0.14621522f, 
    0.48224670f, 0.06040179f, -0.05063127f, 0.13932340f, -0.14167203f, 0.15118432f, -0.40553117f, 0.00834608f, 
    0.01745262f, -0.11894830f, 0.22632246f, 0.11652344f, -0.07270923f, -0.41528195f, 0.07853727f, -0.04873594f, 
    0.17410727f, 0.13095103f, 0.11946205f, -0.47649983f, 0.52326274f, -0.10119344f, 0.29225096f, 0.20182313f, 
    -0.08601117f, -0.29544187f, 0.25178534f, 0.00001223f, -0.05086548f, -0.03055338f, 0.17415780f, 0.21835448f, 
    -0.14672633f, 0.01972796f, 0.02865908f, 0.00156713f, 0.00489710f, -0.08637892f, 0.01245671f, 0.04678985f, 
    -0.03600579f, 0.00206886f, -0.19970769f, -0.07199128f, 0.09962492f, 0.10256913f, -0.11439833f, -0.17313370f, 
    0.07574593f, -0.10603119f, 0.23364083f, 0.03864137f, 0.03793069f, 0.05728020f, 0.31794995f, -0.14657441f, 
    -0.11547639f, -0.50825530f, -0.11127147f, -0.00818865f, 0.05810582f, 0.03484040f, -0.11008383f, -0.18049006f, 
    0.16251945f, -0.03279724f, -0.04531385f, 0.22505851f, -0.11187443f, -0.15743797f, -0.28700730f, -0.39584705f, 
    0.07256980f, -0.27412316f, -0.01943966f, -0.02803706f, 0.01857149f, 0.12560730f, -0.07864293f, -0.37314829f, 
    0.27421293f, -0.10571959f, -0.05369830f, 0.07555646f, 0.00980176f, 0.05819771f, 0.04343334f, -0.14557604f, 
    -0.02283889f, 0.14299197f, 0.10378720f, -0.30297375f, 0.01087384f, 0.00527152f, 0.25119543f, -0.22564560f, 
    -0.01221274f, -0.33724117f, -0.10788213f, 0.10422279f, -0.16137473f, 0.06775253f, 0.12277126f, 0.25346825f, 
    0.10447762f, 0.11398831f, 0.04111632f, -0.01464509f, 0.01607116f, 0.01529372f, -0.07479564f, 0.05865306f, 
    -0.03356811f, 0.10063411f, -0.01677239f, -0.01944068f, 0.32693437f, -0.77251488f, -0.06023800f, 0.21158350f, 
    0.03213889f, 0.08630781f, -0.09385629f, 0.04182962f, -0.03815115f, 0.02677077f, -0.07214060f, -0.00012447f, 
    -0.57184410f, 0.05890940f, -0.00634546f, 0.11796947f, -0.05140067f, -0.12079491f, -0.13575351f, -0.05294929f, 
    0.05380296f, 0.12112510f, -0.04749542f, 0.02060915f, -0.04134188f, 0.02923838f, -0.10582326f, 0.06864440f, 
    0.12197672f, 0.26013106f, -0.09849011f, -0.15161766f, -0.10574676f, -0.09949641f, 0.02902843f, 0.13533488f, 
    0.10054287f, -0.06464836f, -0.15333089f, 0.03636050f, -0.01325865f, -0.06584480f, 0.00708067f, -0.11959809f, 
    0.14031528f, 0.03502617f, -0.23381104f, 0.02555091f, -0.09510265f, -0.21875839f, 0.04317875f, 0.08095996f, 
    -0.00341459f, 0.05318002f, 0.11506465f, -0.18531691f, 0.18062842f, 0.19040531f, 0.54128915f, 0.03283782f, 
    -0.07613999f, -0.16742869f, -0.12175349f, -0.10122921f, -0.19374238f, 0.16871199f, 0.20380782f, 0.12010800f, 
    -0.12444873f, 0.48014787f, 0.05363594f, -0.13813365f, 0.18965545f, 0.05652953f, 0.37125081f, -0.16976044f, 
    0.03454662f, 0.03133406f, -0.12331188f, -0.63578665f, -0.02507553f, -0.16182172f, -0.33336896f, 0.07525765f, 
    -0.03447463f, -0.39546344f, -0.01888693f, 0.27861956f, -0.17252405f, -0.04196635f, 0.00684596f, -0.50596249f, 
    0.11055075f, 0.05813539f, -0.07922124f, 0.01967639f, 0.19318791f, -0.02485314f, -0.04161876f, -0.13747780f, 
    -0.04599157f, 0.07562850f, -0.30578774f, -0.08761077f, -0.18153992f, -0.00457869f, 0.26069769f, -0.32191321f, 
    -0.19215828f, 0.26150906f, 0.04453975f, -0.02851837f, 0.19923693f, 0.14411901f, 0.18002218f, -0.09439513f, 
    0.14158309f, 0.05896460f, 0.07086370f, 0.13276663f, -0.34097081f, 0.06912915f, -0.60903710f, 0.27852628f, 
    -0.04015951f, 0.18929446f, -0.02889616f, -0.10205813f, -0.38852635f, 0.43588513f, 0.07321330f, 0.11350881f, 
    -0.16553859f, -0.15261504f, -0.32709104f, 0.12294888f, -0.10424452f, -0.18660079f, -0.08297470f, 0.09206912f, 
    0.12498492f, 0.39627928f, 0.07403429f, -0.09659424f, 0.13977470f, 0.27543652f, -0.21415263f, 0.05979541f, 
    0.09804545f, -0.05729105f, 0.31249812f, 0.15134738f, 0.16030432f, 0.04670729f, 0.21577969f, -0.15281866f, 
    0.16353609f, -0.03425182f, 0.03540234f, 0.01238426f, 0.60535836f, 0.15815063f, 0.33508825f, 0.06090532f, 
    0.02971648f, 0.31362033f, -0.21044172f, 0.27513653f, 0.04633326f, 0.07287192f, 0.11214989f, -0.32995981f, 
    0.07281914f, 0.36124843f, -0.22959380f, -0.03248609f, 0.02150473f, -0.10608958f, 0.12508361f, -0.04964611f, 
    0.08835305f, 0.10826412f, -0.05116102f, -0.07007325f, -0.07388765f, -0.10996833f, 0.15152353f, -0.07136734f, 
    0.01073146f, -0.07458887f, -0.31680197f, -0.06761856f, -0.04689838f, 0.09116171f, -0.10229977f, 0.09318453f, 
    0.08235987f, -0.05803695f, 0.00086864f, 0.04070590f, -0.05146164f, 0.01169780f, 0.48227945f, -0.08001451f, 
    0.09030153f, 0.04297252f, -0.06328545f, -0.33484051f, 0.05801074f, -0.13924284f, -0.23509084f, 0.06412541f, 
    -0.13095464f, 0.00200505f, -0.02635595f, 0.29951245f, 0.00926210f, -0.05296320f, 0.04697469f, -0.41076672f, 
    0.18484001f, 0.25878191f, 0.04824218f, -0.00517645f, 0.14185761f, 0.04013180f, 0.12008578f, 0.19360097f, 
    0.07785743f, 0.05391455f, -0.05735554f, -0.04117655f, -0.09183031f, -0.02698394f, 0.05334729f, -0.03172517f, 
    -0.28713444f, 0.18205291f, -0.01767466f, 0.12626293f, 0.32191259f, 0.09165022f, 0.05229276f, 0.04792418f, 
    0.19838895f, 0.07534052f, 0.17282853f, 0.24590810f, -0.20563714f, 0.04317705f, -0.18612620f, 0.11073539f, 
    0.03089281f, 0.10211061f, 0.10035228f, -0.13119704f, -0.14672418f, -0.07843000f, -0.00557810f, 0.21662554f, 
    -0.11645245f, -0.01323765f, -0.15488762f, 0.27193046f, 0.03467274f, -0.20553972f, -0.01687567f, 0.26799387f, 
    -0.12181380f, 0.28719622f, -0.06257738f, -0.06342546f, 0.20711359f, 0.12559325f, 0.06018114f, 0.04432158f, 
    0.07003146f, 0.06956485f, -0.08219927f, 0.20359631f, 0.05726178f, 0.03742333f, 0.02265135f, -0.04563164f, 
    -0.16438784f, -0.04617900f, 0.04986293f, 0.33580357f, 0.05162448f, 0.23685855f, 0.10456931f, 0.03525123f, 
    0.27386728f, 0.40875074f, 0.14698735f, -0.15366733f, 0.11772421f, 0.08661135f, 0.06585423f, -0.24619550f, 
    0.05002775f, -0.02881355f, 0.05951470f, 0.00964942f, 0.00615810f, 0.01276826f, -0.00582502f, -0.10423537f, 
    0.06932691f, -0.03982871f, -0.01019199f, 0.05729611f, -0.06859374f, -0.07772550f, -0.02314178f, -0.00623556f, 
    0.02403864f, -0.07126956f, 0.03499066f, -0.08088515f, 0.01704418f, 0.06398686f, 0.05872993f, -0.08023079f, 
    -0.08933945f, -0.04427718f, -0.08154956f, -0.00323749f, 0.00578674f, -0.01423685f, 0.03709060f, -0.08237831f, 
    0.01840035f, 0.03520714f, 0.03543497f, -0.01978356f, 0.03266434f, 0.02446458f, -0.03962786f, -0.01755976f, 
    0.04071123f, -0.05362542f, 0.03767688f, -0.00746906f, 0.00055166f, 0.03341828f, -0.02772395f, -0.08159462f, 
    -0.05096994f, 0.05376251f, 0.06372835f, -0.00948993f, -0.03935169f, 0.03882727f, -0.07846270f, 0.05842524f, 
    -0.00302126f, 0.04956470f, -0.01625828f, 0.07423458f, 0.05697631f, 0.04098234f, 0.05798344f, 0.02881023f, 
    0.07341398f, 0.03465569f, -0.01489086f, 0.02862620f, -0.03327665f, -0.07372524f, -0.05429670f, 0.06773835f, 
    -0.07225873f, -0.03321066f, 0.01153381f, -0.09528065f, 0.01798214f, -0.01000073f, -0.01593021f, -0.04224278f, 
    -0.10501112f, -0.06903583f, 0.01263828f, -0.09494651f, -0.02996822f, -0.06633057f, 0.00779893f, -0.04131158f, 
    -0.04845653f, -0.03042652f, 0.03843029f, -0.06694201f, 0.03746926f, -0.05235037f, -0.06963167f, 0.00499515f, 
    -0.06104518f, -0.00553182f, 0.04677312f, -0.01851793f, 0.05786269f, -0.03890274f, -0.04532745f, -0.03017926f, 
    -0.09678553f, -0.04088462f, -0.04459614f, -0.02893995f, 0.06095124f, 0.00148611f, 0.02890596f, -0.08853278f, 
    -0.03360369f, -0.00186437f, -0.04474413f, -0.09119130f, -0.05971730f, -0.02910881f, -0.05213583f, 0.05452692f, 
    -0.01967384f, -0.04691649f, 0.08276862f, 0.08797289f, -0.00200111f, -0.07560430f, -0.02711940f, 0.00594222f, 
    -0.04424936f, -0.08342823f, -0.10114431f, -0.08934832f, -0.01595457f, 0.00242963f, 0.08027668f, -0.04320025f, 
    0.13483100f, 0.07233430f, -0.20762666f, 0.00163881f, 0.04425280f, -0.24832241f, 0.11383414f, 0.27803102f, 
    0.06550746f, 0.14717463f, -0.09478946f, 0.03134470f, -0.05795508f, -0.25087392f, -0.22915725f, -0.02717755f, 
    -0.01624950f, -0.45034850f, 0.19776554f, -0.05545134f, 0.12611707f, 0.22945841f, -0.04797563f, 0.07045538f, 
    -0.02511681f, -0.18732506f, -0.01563454f, -0.39771327f, 0.09744941f, 0.05593035f, 0.18063755f, 0.23240535f, 
    -0.03649212f, 0.01377862f, -0.08388876f, -0.16897298f, -0.11812412f, 0.02807838f, 0.13142219f, -0.09633654f, 
    -0.08449493f, 0.10824494f, -0.01816830f, -0.02367791f, -0.11797323f, 0.04818904f, 0.18232794f, 0.03365094f, 
    -0.01847868f, 0.09165838f, -0.14124909f, -0.04808409f, -0.00713729f, 0.07372607f, -0.35885161f, -0.24444211f, 
    -0.11779457f, -0.00143865f, 0.11386838f, -0.17145854f, 0.35316247f, 0.21731879f, 0.06754055f, -0.06991345f, 
    -0.23233639f, -0.01575986f, -0.09342040f, -0.21264853f, -0.04021006f, 0.04303019f, 0.08050727f, 0.12486583f, 
    0.00682100f, 0.18256505f, 0.17631921f, -0.03299350f, -0.19891612f, -0.67305499f, 0.06047618f, 0.01602829f, 
    -0.10547019f, 0.02327784f, 0.30948240f, -0.04842631f, 0.19268902f, 0.43909115f, 0.00567439f, 0.04719194f, 
    0.21523459f, -0.27024055f, 0.22027092f, -0.16328174f, 0.02993564f, 0.07348040f, 0.13240431f, 0.01628448f, 
    0.07410964f, 0.17791840f, 0.02104273f, -0.17373064f, 0.07745191f, 0.14997122f, 0.06015782f, -0.06513934f, 
    -0.13334656f, -0.17482460f, 0.04851797f, 0.23073393f, -0.24266134f, 0.17269000f, -0.17132525f, -0.12250680f, 
    -0.06673402f, 0.33255464f, -0.45607945f, 0.02324136f, 0.13422209f, 0.04436700f, -0.11870080f, -0.21162377f, 
    0.00145160f, 0.30708548f, -0.06477860f, -0.07205064f, -0.02839356f, -0.13952072f, -0.05437832f, 0.19149391f, 
    0.07358912f, -0.11502907f, -0.14499444f, -0.08580096f, -0.25352421f, 0.11096797f, 0.06281212f, -0.11127951f, 
    -0.03176634f, -0.06406224f, -0.36909747f, -0.05105549f, -0.03105315f, 0.33638811f, -0.25735161f, 0.08893943f, 
    0.28736463f, 0.06647959f, 0.07796951f, -0.05874538f, 0.06823320f, -0.05560568f, 0.28221509f, 0.09825421f, 
    -0.13294783f, -0.21636276f, 0.17881608f, -0.12526043f, 0.17169821f, 0.04563496f, -0.02410663f, 0.24417725f, 
    -0.21624069f, -0.21778378f, 0.05784604f, 0.47071761f, 0.12472254f, 0.04544551f, 0.06993905f, 0.07887813f, 
    -0.03306488f, 0.07516877f, 0.01872257f, 0.08366939f, 0.06232585f, 0.08217862f, -0.12644264f, 0.38010159f, 
    0.00567306f, -0.05441586f, 0.02529225f, 0.13525075f, -0.21593286f, -0.21919043f, 0.15748483f, 0.05679829f, 
    -0.09600304f, 0.15424423f, -0.20049874f, 0.01759887f, 0.13052014f, -0.08465225f, 0.08499359f, -0.12040274f, 
    0.19455847f, 0.10774430f, 0.10582706f, -0.03511858f, -0.35704592f, -0.06506401f, 0.04460188f, -0.15181683f, 
    0.07587509f, 0.03636660f, 0.06870164f, 0.00540964f, -0.19275509f, 0.08600046f, 0.02299920f, 0.02444424f, 
    -0.08006446f, 0.14401402f, -0.18717712f, 0.24193129f, -0.09828073f, -0.25767350f, -0.00690919f, 0.23357968f, 
    -0.08353183f, 0.14837721f, 0.02796571f, -0.06391353f, 0.26535422f, -0.04173819f, 0.20738669f, -0.01334195f, 
    0.00593366f, -0.21355897f, 0.05285728f, 0.01141873f, 0.10765496f, 0.13420600f, 0.06442448f, -0.09937927f, 
    0.03234436f, -0.27006033f, -0.00334781f, 0.15051891f, -0.20970573f, 0.27434742f, 0.27098939f, 0.24400659f, 
    0.17140901f, -0.04457514f, 0.41501874f, -0.19683340f, -0.02910230f, -0.18505672f, -0.06131715f, 0.24821405f, 
    -0.06374917f, -0.03657022f, -0.03160408f, -0.01605578f, -0.08125191f, -0.04265633f, -0.10461850f, -0.04506623f, 
    -0.07410267f, 0.04485755f, -0.01894263f, -0.00729289f, -0.05850418f, -0.03007836f, -0.05364702f, -0.04542569f, 
    -0.03051673f, -0.02521523f, -0.03730027f, 0.05174164f, -0.09417169f, -0.08463793f, -0.09141175f, 0.04419562f, 
    0.02681906f, -0.07554295f, -0.04517683f, -0.03594596f, -0.00414380f, 0.01878898f, -0.00937593f, -0.01631952f, 
    0.00958267f, -0.02639268f, 0.04990546f, -0.04654132f, -0.04606095f, -0.10127184f, 0.03961948f, 0.01739240f, 
    -0.05143255f, -0.04521812f, 0.04757642f, -0.08514195f, -0.01985385f, 0.05954662f, -0.05064801f, -0.02298818f, 
    0.02060860f, -0.11505365f, 0.03139789f, -0.03406312f, 0.02610546f, 0.04401422f, 0.00289837f, 0.02272500f, 
    -0.06319269f, 0.03044886f, 0.00017758f, -0.04617361f, -0.07038061f, -0.09051183f, -0.00986061f, 0.02098321f, 
    0.00206180f, -0.01515847f, -0.00411915f, -0.00552956f, -0.09875069f, -0.11339476f, -0.11194246f, -0.01380000f, 
    -0.08380531f, -0.01677094f, -0.07781078f, -0.03755800f, -0.06190920f, 0.08000860f, 0.06551857f, -0.04000752f, 
    -0.06534839f, -0.05002741f, -0.07391389f, -0.08173335f, -0.11163323f, -0.01608238f, 0.05095394f, -0.05492279f, 
    -0.08322734f, 0.00517149f, -0.01210427f, -0.08697020f, -0.01375957f, 0.06081277f, 0.00821034f, 0.01529506f, 
    0.04962025f, 0.00251544f, -0.05993237f, 0.05672126f, -0.02707394f, -0.05589518f, 0.02900129f, 0.04156651f, 
    -0.10713830f, 0.04691520f, -0.03168214f, -0.07081708f, -0.04392886f, -0.02068871f, -0.05114442f, -0.05441298f, 
    0.00601680f, -0.01845729f, -0.05604924f, 0.03071420f, 0.00842491f, 0.04307422f, -0.02782418f, -0.06475981f, 
    -0.07156933f, -0.08757146f, -0.02888529f, 0.05263424f, 0.02129880f, -0.09103231f, 0.01209097f, 0.00983410f, 
    -0.02050251f, 0.01848830f, 0.05780563f, -0.00472347f, -0.03619333f, -0.02737433f, 0.05884168f, -0.06443298f, 
    -0.08190706f, -0.01078996f, -0.04145343f, -0.10469285f, -0.02324478f, -0.04914955f, 0.02443967f, -0.05272715f, 
    -0.05381078f, -0.04615720f, 0.06771155f, -0.02747884f, -0.00141567f, -0.01530898f, -0.10445521f, 0.02533228f, 
    -0.06713466f, 0.04372426f, -0.08575515f, -0.08670235f, 0.00433420f, 0.01438871f, -0.02770786f, -0.01709815f, 
    0.07620595f, 0.06971701f, -0.09933849f, 0.01667135f, 0.07581306f, -0.08230787f, 0.03109458f, -0.07447973f, 
    -0.04106086f, 0.03584968f, 0.03799701f, -0.03003363f, -0.09006035f, 0.02869049f, 0.05617967f, 0.04623975f, 
    0.06010418f, -0.03532573f, 0.05251645f, 0.01053472f, 0.00413884f, 0.04618365f, -0.04624326f, 0.01910016f, 
    -0.01899182f, -0.02157123f, 0.06606533f, 0.05813709f, 0.03963945f, -0.05777737f, 0.00465405f, 0.04538052f, 
    -0.00152685f, 0.04999610f, -0.08001611f, 0.06870529f, -0.03438013f, -0.01927861f, 0.03440210f, -0.06688625f, 
    -0.08104178f, -0.06945313f, 0.03959833f, -0.04159971f, 0.01911060f, 0.03699378f, 0.03598751f, -0.05122107f, 
    -0.02491565f, -0.00490769f, -0.06876641f, -0.05133642f, 0.06388258f, 0.06362352f, 0.02316974f, -0.07162800f, 
    0.03500444f, -0.09980538f, -0.00483805f, -0.02639497f, -0.07141891f, 0.02558425f, -0.04390362f, -0.02517152f, 
    -0.08202377f, -0.04449491f, 0.04555940f, 0.02766789f, -0.09458110f, 0.06413068f, -0.05085555f, -0.02597974f, 
    -0.02218544f, -0.04969396f, -0.08675418f, -0.02502802f, -0.01298617f, -0.06074031f, -0.02018888f, 0.01456462f, 
    -0.01340786f, -0.02050361f, -0.08368323f, 0.01894969f, -0.00521868f, -0.08914346f, -0.05754511f, -0.03470611f, 
    -0.02965822f, -0.07202121f, 0.05031782f, -0.07511565f, -0.00944318f, 0.04229755f, -0.06095125f, 0.03173140f, 
    -0.10770776f, 0.07022864f, -0.16845386f, 0.04210384f, -0.05490949f, 0.01356561f, 0.10533964f, 0.13016291f, 
    0.03746375f, 0.02346145f, 0.00048907f, -0.00709506f, -0.01755870f, -0.12086468f, 0.09440038f, 0.19753544f, 
    -0.05019912f, 0.00394009f, -0.38476491f, -0.05679695f, -0.10156751f, -0.22551246f, -0.07414886f, -0.08173953f, 
    -0.11597322f, -0.19585676f, 0.17495152f, 0.27221203f, 0.14223957f, 0.10765572f, 0.34367356f, -0.05606935f, 
    0.10956773f, -0.36387178f, -0.00288520f, -0.38247314f, -0.03647784f, 0.08485062f, 0.07936445f, -0.17255932f, 
    -0.01014101f, -0.29395029f, -0.02932070f, -0.09971873f, -0.06144408f, -0.01768593f, 0.02491702f, -0.29147437f, 
    -0.06394966f, 0.14179730f, 0.01918626f, -0.04888986f, -0.03286700f, 0.11776120f, 0.16710828f, -0.13571788f, 
    0.06823558f, 0.13402329f, -0.22154699f, 0.04642627f, -0.12322699f, -0.12696576f, -0.12629686f, -0.29621023f, 
    -0.18825108f, 0.03209547f, -0.01144911f, 0.14386320f, 0.56630719f, 0.25108081f, 0.01237976f, -0.04994691f, 
    -0.07797987f, -0.05498849f, 0.04359480f, 0.05450759f, 0.00029198f, 0.05773682f, -0.04394754f, 0.06293786f, 
    0.14652985f, 0.15402821f, 0.24036555f, -0.06837511f, -0.36429709f, -0.25731507f, -0.07533296f, 0.15829803f, 
    0.01982020f, 0.14817195f, 0.04638712f, -0.03584784f, 0.08205469f, 0.06716258f, 0.04845163f, 0.18932137f, 
    -0.01345922f, -0.03996219f, -0.06704995f, 0.04779747f, 0.01908481f, 0.28420308f, -0.08112827f, -0.06719142f, 
    -0.02459549f, 0.24062958f, 0.15915228f, -0.22776172f, 0.25267500f, -0.05171255f, 0.08495449f, 0.13435975f, 
    0.02506465f, -0.24499536f, 0.04923461f, 0.49845925f, 0.15889762f, 0.26575005f, 0.01105976f, -0.24264579f, 
    0.16252488f, 0.59860206f, -0.19301628f, 0.10310787f, 0.24281244f, 0.09022118f, 0.09631337f, 0.26383418f, 
    0.23938189f, 0.09249558f, 0.40927231f, 0.07955302f, -0.02486044f, -0.08924886f, -0.13475698f, 0.08370159f, 
    0.16301516f, -0.02940319f, 0.30555832f, -0.08322793f, -0.11368981f, 0.10952528f, -0.03111581f, -0.03137592f, 
    -0.02419577f, 0.15749028f, 0.11126955f, -0.05664970f, 0.23522775f, 0.16803421f, -0.01248647f, 0.12877035f, 
    0.02365089f, 0.67413253f, -0.07401041f, 0.01655478f, -0.08614650f, -0.05606880f, -0.22956926f, 0.13787930f, 
    0.02875729f, 0.09615126f, 0.17329690f, 0.14978564f, -0.04853003f, 0.08498764f, 0.04870548f, 0.03841456f, 
    0.03170701f, 0.12745462f, 0.08147364f, -0.01936308f, 0.12915142f, 0.02825733f, 0.16470505f, 0.07535709f, 
    -0.23450738f, -0.13861832f, 0.00605792f, -0.24304435f, 0.14189753f, 0.00394634f, 0.02635213f, -0.06393674f, 
    -0.11075264f, -0.01738892f, -0.01543884f, 0.54672152f, -0.04539602f, 0.04868164f, 0.09685504f, 0.15695687f, 
    0.01876334f, 0.18839011f, 0.03642328f, -0.11697202f, -0.00882429f, -0.13205704f, -0.09890816f, 0.00931709f, 
    0.01399706f, -0.25037214f, -0.16453287f, 0.06834693f, 0.13679704f, 0.06294609f, -0.01450236f, -0.02824085f, 
    0.02429491f, -0.04377640f, 0.04452754f, 0.04135385f, 0.06915650f, 0.91920042f, -0.08214629f, -0.14856367f, 
    -0.00330829f, -0.06007809f, -0.00944701f, -0.11892551f, 0.01190919f, -0.12484789f, -0.02981590f, -0.02402225f, 
    0.53467828f, -0.02066827f, -0.05569044f, 0.16286898f, -0.11685256f, -0.16687351f, 0.10331903f, 0.02709483f, 
    0.01656684f, -0.41964054f, 0.10956340f, -0.16341437f, -0.02927929f, -0.06092425f, 0.04383470f, 0.02685283f, 
    0.18419071f, 0.04513117f, -0.00297852f, 0.00642186f, 0.30867162f, 0.13274090f, 0.26850557f, 0.14489807f, 
    -0.12019882f, -0.23821242f, 0.12011502f, -0.03957742f, 0.03337739f, 0.13102111f, 0.09175020f, -0.09756272f, 
    -0.03168244f, -0.05490177f, -0.00250491f, -0.05367535f, -0.06176780f, -0.05953809f, 0.02449515f, -0.03286479f, 
    -0.05038595f, -0.05229364f, 0.03062629f, 0.06005144f, 0.01941812f, -0.06413595f, 0.04717755f, 0.02316200f, 
    0.00144681f, -0.05624405f, 0.01613207f, -0.09624351f, 0.06054133f, -0.08043716f, 0.05633442f, -0.05800880f, 
    0.05916949f, 0.06335221f, -0.07073075f, -0.10167287f, -0.01534074f, -0.10195874f, -0.02571917f, 0.00663300f, 
    -0.01114481f, 0.08437800f, 0.03029619f, 0.00765473f, 0.06111747f, 0.02753272f, -0.08579121f, -0.04005844f, 
    -0.02782890f, 0.00562904f, -0.04371881f, 0.04783477f, 0.01359426f, 0.00730445f, -0.04929332f, -0.00844460f, 
    0.06230941f, 0.00638949f, 0.06434888f, 0.03122498f, -0.02338733f, -0.07911327f, -0.05808011f, 0.06878234f, 
    -0.09534459f, -0.01237445f, 0.03478487f, -0.01773301f, -0.00416091f, -0.04806577f, -0.01445695f, -0.07219268f, 
    0.06577544f, 0.05435565f, 0.00490193f, -0.02331408f, 0.05370090f, 0.03164604f, -0.04927019f, -0.05250030f, 
    0.03149482f, -0.03670387f, -0.06944112f, 0.03739747f, 0.03133498f, -0.05541377f, -0.08597304f, 0.04786730f, 
    -0.07444786f, -0.01147002f, -0.06400681f, -0.04780708f, -0.06863258f, -0.00205435f, 0.02721193f, -0.08006331f, 
    -0.09389867f, 0.02631976f, -0.05776282f, -0.07532406f, -0.06863759f, -0.03118259f, -0.08456051f, -0.01297835f, 
    0.02840476f, 0.02066007f, -0.02894173f, 0.01868400f, 0.01572403f, -0.04614489f, -0.08843613f, 0.04344895f, 
    0.01139730f, 0.01763402f, -0.05600980f, -0.02323522f, 0.02273088f, -0.05037791f, 0.03200503f, -0.06680753f, 
    -0.10449759f, 0.01952623f, -0.06562696f, -0.08182527f, -0.06000880f, -0.01914461f, -0.00568614f, -0.05427909f, 
    -0.02184307f, 0.06526516f, 0.08273704f, -0.05246734f, -0.02275551f, -0.01304391f, -0.08321785f, -0.03629354f, 
    -0.00207135f, 0.00342603f, 0.07292099f, -0.05873094f, -0.04745803f, 0.11741804f, -0.15364502f, 0.09139855f, 
    0.06786498f, -0.07940513f, -0.30831873f, -0.08147728f, -0.01243690f, 0.02939664f, 0.14423236f, -0.03064234f, 
    0.02374811f, 0.00002302f, 0.02132826f, 0.00363313f, 0.04750002f, 0.14702570f, -0.38081244f, 0.01932782f, 
    -0.04110504f, -0.43557250f, 0.10598183f, -0.01879264f, 0.10224691f, 0.08629271f, -0.01359630f, 0.00583793f, 
    -0.13217707f, 0.05943526f, -0.00426360f, 0.24480990f, 0.06147793f, 0.01324186f, -0.27427679f, 0.26053661f, 
    -0.03551954f, -0.01714958f, 0.08154624f, 0.12039477f, 0.05646427f, -0.01839055f, -0.48893285f, 0.33213609f, 
    -0.06880483f, -0.08123009f, -0.00926599f, 0.11694632f, -0.05262376f, -0.26764363f, -0.07101333f, -0.18672353f, 
    -0.12944104f, 0.01542792f, 0.23898074f, 0.00162850f, -0.18706183f, 0.21945538f, 0.00227236f, 0.17778547f, 
    0.18481311f, 0.23837920f, 0.29553226f, -0.04554305f, -0.07670897f, -0.03952899f, 0.07289927f, 0.08349415f, 
    0.04494789f, 0.09637439f, 0.01580795f, -0.03938401f, -0.00277000f, 0.05199210f, -0.09206881f, 0.15392408f, 
    0.09090321f, 0.00772555f, -0.07951917f, -0.06209782f, -0.00559760f, -0.62908536f, -0.03200754f, -0.04911276f, 
    0.00397878f, -0.03038582f, 0.09324695f, -0.05156080f, 0.02041185f, -0.00252608f, 0.05624335f, 0.11398343f, 
    -0.76431501f, 0.07584788f, 0.10664684f, -0.16271295f, 0.19041148f, 0.11226901f, 0.05257375f, -0.06609637f, 
    0.07669282f, -0.16424917f, 0.00774281f, 0.28468412f, 0.01711204f, -0.06195750f, -0.01989825f, 0.03091734f, 
    -0.23937017f, 0.10132400f, -0.02881848f, -0.11929521f, 0.30639479f, -0.18022348f, -0.01735633f, 0.23881458f, 
    0.07733067f, -0.36382300f, -0.02605660f, -0.07422354f, 0.04955598f, 0.21428758f, 0.04982168f, 0.14662850f, 
    0.29756272f, -0.03223199f, 0.22084941f, 0.00764841f, -0.10822982f, 0.09934928f, -0.12810068f, 0.11980645f, 
    0.25231737f, 0.02956889f, 0.34055433f, -0.07345171f, -0.01398715f, -0.13700712f, -0.05702210f, 0.29588225f, 
    0.01456694f, 0.00993268f, 0.08200478f, -0.24123879f, -0.07044476f, -0.46056619f, -0.18760258f, 0.03925334f, 
    -0.12127286f, 0.15885349f, 0.04482358f, 0.20097961f, -0.05581104f, 0.10041517f, -0.29635429f, -0.09224747f, 
    0.13789655f, -0.05323590f, -0.16931778f, 0.06224346f, 0.13207418f, 0.03473281f, 0.14332980f, 0.01781174f, 
    0.13134830f, -0.07156908f, -0.00862080f, -0.35412219f, 0.07469656f, 0.07438804f, 0.34822440f, -0.12786651f, 
    -0.10544909f, -0.10624859f, -0.02331602f, -0.19306314f, 0.08228800f, 0.06846326f, 0.24046655f, -0.13565050f, 
    -0.12379211f, 0.03283069f, 0.04604733f, 0.39204946f, -0.24385895f, -0.00414636f, -0.29809251f, -0.06984564f, 
    0.08417697f, -0.01779341f, 0.00529133f, -0.09088461f, 0.43237430f, -0.06903335f, 0.05222846f, -0.07944679f, 
    -0.16059098f, -0.36720854f, -0.15470681f, -0.01944557f, -0.09732609f, -0.01637333f, -0.03247233f, -0.05096613f, 
    0.12375283f, 0.10496299f, 0.02031374f, -0.02384374f, 0.01797619f, 0.51515430f, 0.08695875f, 0.11557341f, 
    -0.07962546f, 0.07989455f, 0.33826384f, -0.07324366f, 0.11498652f, 0.19154461f, -0.07503038f, -0.01351032f, 
    0.56907475f, -0.20302953f, 0.09885807f, 0.10718312f, -0.19936505f, -0.07047733f, 0.08465692f, -0.07453892f, 
    -0.01680427f, -0.04766934f, 0.03899421f, -0.31631005f, 0.27544078f, 0.10769603f, -0.05986530f, 0.00789939f, 
    0.06363720f, -0.08791915f, -0.06084304f, 0.34889650f, 0.35385963f, 0.17854659f, -0.01042239f, -0.13176730f, 
    -0.06149705f, 0.05215740f, -0.14196299f, -0.01070789f, 0.04102413f, 0.17285548f, -0.10436089f, 0.35114044f, 
    0.35613808f, 0.16006520f, 0.12467412f, 0.07890121f, -0.05896639f, -0.06923778f, 0.08273337f, -0.13403043f, 
    0.08343207f, 0.16748202f, 0.04577488f, -0.12556478f, -0.29168868f, -0.21630128f, -0.06893638f, 0.14521757f, 
    -0.04105160f, -0.04673516f, 0.10310890f, -0.46329212f, 0.15348630f, -0.16006351f, -0.00097001f, 0.12530573f, 
    -0.14337164f, 0.14920515f, 0.14456873f, 0.21912983f, -0.29146957f, 0.04270272f, -0.14675672f, -0.33372071f, 
    -0.11873332f, -0.08820947f, -0.26458248f, 0.08587042f, -0.21814610f, -0.18052818f, 0.49025673f, -0.48154500f, 
    0.14900881f, -0.05104959f, -0.07172207f, -0.29258189f, -0.01971986f, 0.02042479f, -0.02881623f, -0.43077430f, 
    -0.08897234f, 0.08684674f, -0.03510880f, -0.60004938f, 0.21764895f, -0.11509082f, 0.25534412f, -0.18513496f, 
    -0.22795573f, 0.08940241f, 0.06068704f, 0.55380720f, -0.23672500f, 0.04227988f, -0.18919362f, -0.23375262f, 
    -0.12190723f, 0.03158115f, 0.24235742f, -0.26970285f, 0.16679391f, -0.43405837f, -0.02620151f, 0.11040197f, 
    -0.03207460f, -0.62764412f, -0.07106464f, 0.20067045f, 0.02371647f, -0.08689523f, -0.43690127f, 0.06994037f, 
    0.01373243f, 0.06557558f, 0.01743599f, -0.65767109f, 0.10429067f, 0.49555191f, 0.07694936f, 0.08978603f, 
    -0.19894385f, 0.06558251f, -0.11281168f, -0.48292902f, 0.20630866f, 0.19741741f, -0.05824703f, -0.08171016f, 
    0.58114201f, -0.11564038f, -0.02744141f, 0.01378050f, 0.02922689f, 0.08742069f, 0.07294571f, -0.01653568f, 
    0.07638072f, 0.10521515f, 0.06963552f, -0.07782471f, 0.10763322f, -0.17602931f, 0.16155346f, -0.03079874f, 
    -0.05570014f, 0.13306676f, -0.10188646f, 0.14209710f, -0.04522517f, 0.15006347f, -0.05405358f, 0.00218247f, 
    -0.04337269f, 0.20946352f, 0.19427320f, -0.58778769f, 0.05992146f, 0.24559022f, -0.00886585f, -0.15371884f, 
    -0.11990618f, -0.12781391f, -0.23122409f, -0.05278734f, -0.07038308f, -0.13113911f, -0.03308614f, 0.05803229f, 
    -0.00272613f, -0.09913638f, -0.62246233f, -0.14994088f, 0.09682216f, 0.19478689f, 0.35474229f, -0.02265943f, 
    -0.06495061f, -0.08859403f, -0.09081021f, -0.07445910f, 0.01055660f, -0.05005822f, 0.19570771f, -0.13742708f, 
    -0.03363702f, -0.30616394f, 0.24216250f, -0.37206593f, 0.34932286f, 0.16534178f, 0.39475769f, -0.13412610f, 
    -0.05707896f, -0.04972056f, -0.16365215f, -0.15335526f, 0.01795211f, -0.09252818f, 0.02876258f, 0.37105292f, 
    -0.19133872f, 0.08106837f, 0.00015004f, 0.11284044f, -0.07386877f, 0.12334660f, -0.09929986f, 0.12150596f, 
    -0.00626948f, 0.09043942f, 0.03925764f, 0.33521026f, -0.09525976f, 0.08001794f, -0.06243066f, -0.24706760f, 
    -0.03741790f, -0.03703213f, -0.05650004f, -0.24201582f, 0.03549869f, 0.09660881f, 0.19447362f, 0.35656741f, 
    0.12899308f, 0.31379151f, 0.16728850f, 0.00823323f, 0.01102015f, 0.34932381f, 0.15620229f, -0.10948635f, 
    0.10742190f, 0.37143606f, 0.05680484f, 0.03265402f, -0.01825804f, 0.08736544f, -0.18550329f, -0.03899719f, 
    -0.01844412f, 0.11533505f, 0.01770683f, -0.06465019f, 0.02195059f, -0.52554339f, -0.08255684f, 0.14980894f, 
    -0.04944754f, -0.07779202f, 0.07115465f, 0.04532426f, -0.00821666f, 0.10275442f, -0.08878899f, -0.02024874f, 
    -0.35086608f, 0.07908224f, 0.17366405f, 0.03199491f, 0.12602055f, 0.12603638f, 0.13938574f, -0.05566441f, 
    0.06609093f, 0.04769685f, -0.02197044f, 0.22801363f, 0.09854470f, 0.04333070f, 0.05984160f, -0.10583798f, 
    0.06289542f, -0.08719960f, -0.00195111f, -0.05641501f, 0.61285132f, 0.01097476f, 0.30089974f, 0.23992732f, 
    0.08524447f, 0.11462850f, 0.30064586f, -0.02897829f, -0.03308965f, 0.14841789f, 0.03679056f, 0.51171046f, 
    -0.01078271f, -0.03924596f, -0.00650803f, 0.02627512f, 0.02572025f, -0.03900602f, -0.07070238f, -0.04842993f, 
    -0.08176366f, -0.07191721f, 0.06682979f, 0.06737575f, -0.05090128f, -0.06915593f, -0.08786926f, 0.07849128f, 
    0.08462838f, -0.03283194f, 0.04715002f, 0.05675709f, -0.01431025f, 0.08710131f, -0.02759430f, 0.04356246f, 
    -0.00837905f, 0.02222535f, -0.05045656f, -0.02160662f, 0.07042120f, -0.04328225f, -0.04158590f, 0.05060223f, 
    0.06644895f, -0.06012950f, -0.00090402f, 0.07598415f, -0.01722381f, -0.05870960f, 0.05367576f, 0.00739987f, 
    0.01817221f, -0.07837313f, 0.05888285f, 0.04580749f, 0.04647021f, -0.04126279f, 0.03950268f, 0.01333137f, 
    -0.05915821f, 0.07528383f, 0.08634933f, 0.06370870f, 0.03457396f, -0.05648274f, 0.01876118f, 0.04125875f, 
    -0.07311209f, -0.08057642f, 0.06509659f, -0.00565649f, 0.06779267f, -0.04445338f, 0.04425549f, -0.01985576f, 
    -0.06496843f, -0.01941636f, -0.02743780f, -0.01727213f, 0.06362589f, 0.02719053f, 0.05150117f, -0.06940363f, 
    -0.08242850f, 0.06961150f, -0.07271773f, -0.05149592f, -0.03864837f, 0.02674114f, 0.00877863f, -0.07732280f, 
    -0.03533266f, -0.06228625f, -0.00656475f, -0.05650943f, 0.02070665f, -0.01598378f, -0.02774982f, 0.00867396f, 
    -0.01784945f, -0.07553268f, -0.06162348f, -0.07002103f, 0.05838766f, -0.05963194f, -0.05777228f, -0.03175107f, 
    0.06304793f, 0.01295629f, -0.01140468f, -0.00583057f, -0.05041948f, -0.01998827f, 0.05866913f, -0.04588060f, 
    0.00030111f, -0.01198168f, 0.01899958f, -0.08609183f, 0.00299040f, -0.01854691f, 0.03412779f, -0.07833388f, 
    -0.02115691f, 0.01899942f, -0.02789337f, -0.04841388f, -0.01485929f, 0.00228635f, 0.02224814f, -0.07491970f, 
    0.02184217f, 0.01074555f, 0.02859884f, -0.06127091f, -0.00389213f, -0.04346473f, -0.00369494f, 0.00003992f, 
    -0.03523723f, 0.00050824f, 0.00019022f, -0.06661098f, 0.07229536f, -0.10539076f, -0.06431463f, 0.00685584f, 
    0.04583978f, 0.06281671f, 0.05012335f, -0.15034147f, -0.02839077f, -0.10596630f, -0.06051355f, 0.01502257f, 
    -0.03809668f, -0.03849353f, -0.08964413f, -0.00490467f, 0.00453262f, 0.01311873f, -0.05633699f, 0.02874555f, 
    -0.06513023f, -0.10052411f, -0.07381570f, -0.09444082f, -0.01694528f, -0.01132095f, -0.11597666f, 0.03935216f, 
    -0.05287952f, -0.06262100f, -0.01450158f, -0.05206425f, -0.05654464f, -0.01487502f, -0.05763482f, -0.00741843f, 
    -0.04461728f, -0.04731970f, 0.05743017f, 0.00602430f, -0.05457342f, -0.07317162f, -0.07118572f, -0.04084076f, 
    -0.10173536f, -0.11938320f, 0.00773790f, -0.16549101f, -0.00382187f, -0.05472402f, -0.06537385f, 0.04069037f, 
    -0.04823137f, -0.07398874f, -0.07437619f, -0.04749215f, -0.00871880f, -0.08659205f, 0.01122579f, 0.00122337f, 
    -0.00529651f, 0.01147666f, 0.03010498f, -0.08468495f, -0.02331350f, -0.04712798f, -0.02723232f, 0.07709551f, 
    0.05330328f, -0.09704417f, 0.02267109f, -0.08471906f, -0.02927423f, -0.08263352f, -0.08403693f, 0.05964485f, 
    0.02862721f, 0.01366283f, -0.05566870f, -0.03108201f, -0.04072111f, -0.00414746f, 0.07988205f, -0.11170676f, 
    -0.02966438f, -0.04440456f, 0.01399547f, -0.12104447f, -0.03192682f, 0.06615583f, -0.05364989f, -0.13387942f, 
    -0.09140035f, 0.01772158f, 0.03046279f, -0.03743943f, -0.02497695f, 0.04226174f, 0.04614956f, -0.06956422f, 
    0.06670932f, 0.01396749f, -0.03929215f, -0.03357350f, 0.00099797f, -0.06392357f, -0.00376902f, -0.15467924f, 
    -0.05936156f, -0.04920638f, -0.15296783f, -0.14824130f, -0.08415105f, -0.05934677f, -0.01942954f, -0.00427831f, 
    -0.08357678f, -0.11452845f, -0.06130795f, 0.00533233f, -0.14246349f, -0.10479093f, -0.06966317f, -0.08178499f, 
    -0.01696758f, 0.03537767f, 0.03782362f, 0.00323954f, -0.06122532f, -0.05462122f, -0.02098364f, -0.11778353f, 
    -0.02644537f, 0.05220470f, 0.02291892f, -0.02105512f, 0.00832984f, 0.03851851f, -0.00500396f, 0.04037357f, 
    0.02949229f, -0.07843714f, -0.11405278f, 0.01356925f, 0.00439417f, 0.04597726f, -0.08360700f, -0.03622663f, 
    -0.09694173f, 0.01118218f, -0.01851902f, -0.07404418f, 0.04277675f, 0.02075510f, 0.01345080f, -0.03196689f, 
    0.08024177f, 0.01953423f, 0.02241343f, -0.07454120f, -0.01425807f, 0.00016570f, -0.05256894f, -0.00036601f, 
    0.04419000f, -0.06757767f, -0.04614147f, 0.02427056f, -0.06116790f, -0.06191991f, 0.02000595f, 0.01861725f, 
    0.01460597f, -0.06834891f, -0.06295619f, -0.04731203f, -0.00841774f, -0.11747818f, -0.06506971f, -0.01502315f, 
    -0.07302581f, -0.06035262f, 0.02817553f, 0.01157606f, -0.06181199f, 0.06204876f, 0.04450144f, 0.02854993f, 
    -0.06381261f, 0.00946335f, -0.06338564f, -0.07679477f, -0.08531635f, -0.09717061f, -0.05660019f, -0.10824201f, 
    -0.03643173f, 0.02141001f, -0.12404107f, -0.05541087f, 0.01820600f, -0.02306541f, -0.06865895f, 0.05937915f, 
    0.02605228f, -0.12199897f, -0.01447563f, -0.01236712f, -0.01826116f, -0.05349590f, -0.01811951f, -0.01677726f, 
    -0.03695244f, 0.03148164f, -0.04863971f, 0.00660339f, -0.06028176f, 0.07940026f, -0.06792269f, -0.10950655f, 
    0.04967505f, -0.02015850f, -0.02668853f, -0.10511878f, -0.08513268f, 0.00339862f, -0.01234141f, 0.06803461f, 
    -0.01793760f, -0.07180160f, -0.05130497f, -0.04987571f, -0.06224018f, 0.02756971f, -0.02877160f, -0.04330557f, 
    -0.02617588f, 0.07664327f, -0.00521031f, -0.07525136f, 0.04320518f, -0.03324619f, 0.00825035f, -0.08620305f, 
    0.02176020f, -0.03017025f, -0.01082720f, -0.03520118f, -0.04289466f, -0.09212689f, -0.11684015f, -0.07194554f, 
    0.17857052f, 0.33580160f, -0.23917162f, -0.09840264f, 0.09153998f, -0.21164159f, -0.23529576f, 0.17932101f, 
    -0.01514337f, -0.18458180f, -0.06385837f, -0.08509555f, -0.18631697f, 0.21458806f, 0.12533779f, -0.03930191f, 
    0.02392343f, 0.11276147f, -0.48622537f, 0.02762086f, 0.08368387f, 0.28335875f, -0.22428918f, 0.11054131f, 
    0.11253569f, -0.07744373f, 0.07644603f, -0.06593223f, 0.07902411f, -0.05102639f, 0.44763243f, 0.08668286f, 
    -0.12862240f, -0.25157651f, 0.02227881f, -0.32081005f, 0.05071987f, 0.04557502f, -0.14700480f, 0.26592419f, 
    -0.20718485f, -0.14647385f, -0.04718072f, 0.46265242f, -0.04981696f, 0.06617118f, -0.26973790f, 0.12000084f, 
    0.02414795f, 0.21310852f, -0.04289435f, 0.09197371f, 0.21088268f, 0.13347445f, -0.11357458f, 0.28543472f, 
    0.04156693f, -0.26172394f, -0.12085669f, 0.03693312f, -0.04722511f, -0.06656207f, 0.11570802f, 0.09661308f, 
    -0.13847539f, 0.34925228f, -0.11343526f, 0.11526237f, 0.31088153f, -0.00630585f, 0.06857657f, -0.36157122f, 
    0.25186342f, 0.11426776f, 0.19235648f, -0.07188406f, -0.34292072f, 0.06771570f, 0.06861555f, -0.10446398f, 
    0.02281401f, -0.13600345f, 0.13869554f, -0.01150965f, -0.42978492f, 0.09956073f, 0.04731871f, 0.07920039f, 
    -0.02036915f, 0.08096838f, -0.25556436f, 0.03023097f, -0.17391536f, -0.36937878f, -0.04392159f, 0.28422207f, 
    -0.01796559f, 0.30210915f, 0.01381604f, -0.20856971f, 0.28558400f, -0.03364516f, 0.22391725f, -0.07406250f, 
    -0.21243696f, -0.36695176f, 0.08483323f, -0.00881076f, 0.03961625f, 0.14943935f, -0.01064892f, -0.16657396f, 
    0.07716522f, -0.39173573f, 0.10669481f, 0.16697466f, -0.31604651f, 0.31673461f, 0.21182725f, 0.24529232f, 
    0.23233613f, 0.02835478f, 0.40907928f, -0.04975384f, 0.16324760f, -0.04941393f, 0.05452811f, 0.07269643f, 
    0.18486883f, -0.17612588f, 0.17865805f, 0.07062980f, -0.09466776f, -0.00301429f, 0.28636485f, -0.00163510f, 
    0.25346315f, 0.06963228f, 0.26562360f, -0.12905701f, 0.10356394f, 0.11661174f, 0.10851483f, 0.34090370f, 
    -0.05613376f, 0.06251314f, 0.02615144f, -0.22877309f, 0.07424697f, -0.10102189f, 0.45447677f, 0.21604016f, 
    -0.21561913f, 0.21709426f, 0.11940954f, -0.05743497f, 0.19803120f, 0.23796712f, -0.03360983f, -0.08978121f, 
    0.05106242f, -0.04050593f, -0.10773525f, -0.40398157f, -0.13630395f, 0.11598641f, -0.00245731f, -0.07817341f, 
    0.09521047f, -0.17492883f, 0.00944927f, -0.03382150f, 0.02855354f, 0.14706025f, 0.02786596f, -0.19515036f, 
    0.02454332f, 0.04712344f, 0.08865719f, -0.13489248f, 0.13002941f, 0.14674190f, 0.35193250f, -0.21169281f, 
    -0.05602136f, 0.30046362f, -0.09821559f, 0.10348751f, -0.17783086f, 0.13729654f, 0.13686077f, -0.13031478f, 
    0.01064904f, 0.07636449f, 0.15829241f, -0.11829585f, 0.31693897f, 0.21124645f, 0.08337434f, 0.11915405f, 
    0.01244671f, -0.12525049f, -0.07534228f, -0.06775063f, 0.14904168f, 0.08722408f, -0.33878866f, 0.23172405f, 
    0.13318174f, 0.16888103f, 0.18939084f, -0.09479597f, -0.05387807f, -0.03346643f, -0.03715888f, 0.20880747f, 
    0.02734303f, 0.10475859f, 0.18369655f, -0.30063236f, 0.31614482f, 0.13032576f, -0.04142643f, -0.08850156f, 
    0.42263031f, 0.00106966f, 0.28898737f, 0.34375265f, 0.07120612f, 0.32420605f, -0.05278786f, -0.03761058f, 
    0.32381004f, -0.00373102f, 0.28388453f, -0.26975384f, 0.17700966f, -0.04531465f, 0.22821432f, -0.06093175f, 
    0.33105233f, -0.17174616f, 0.05304650f, 0.16286899f, 0.02139254f, 0.04867386f, 0.18210746f, -0.05265832f, 
    0.11109170f, 0.37736008f, -0.37771812f, 0.06020467f, 0.02209634f, 0.24466014f, -0.00533543f, -0.27901173f, 
    -0.10584395f, 0.13912807f, 0.37206316f, -0.02667663f, 0.06018167f, 0.11963339f, 0.24536251f, 0.27105066f, 
    0.02554914f, 0.11675385f, 0.13651228f, 0.11127840f, -0.12631923f, -0.12264765f, -0.20853746f, 0.11013651f, 
    0.05663271f, -0.11661614f, -0.14745276f, -0.03259504f, -0.04876902f, 0.13185641f, -0.13983510f, -0.09736081f, 
    -0.08232114f, -0.76256740f, 0.04356911f, 0.19685803f, 0.15184759f, 0.08697838f, -0.33437937f, -0.01385953f, 
    0.08441315f, -0.05172534f, 0.03074217f, 0.10414185f, -0.06049138f, 0.15155043f, 0.28857300f, -0.22595853f, 
    -0.09542010f, -0.17964287f, 0.04491486f, -0.10799647f, 0.12205744f, -0.05236090f, -0.11336493f, 0.13265711f, 
    -0.09549014f, -0.16722926f, -0.01458337f, -0.03132421f, 0.00673488f, 0.01254940f, 0.12219334f, 0.19547823f, 
    -0.05940414f, 0.25800514f, 0.15023310f, 0.00723458f, -0.06935079f, 0.03185427f, 0.11833638f, -0.14430697f, 
    0.10159831f, -0.27001250f, -0.22439803f, 0.04051866f, 0.13227561f, -0.03195797f, 0.10648341f, 0.32975677f, 
    -0.20991878f, -0.16518719f, -0.01626715f, -0.05207187f, 0.06579494f, 0.03997525f, -0.31214923f, 0.03284057f, 
    0.21119386f, 0.03327300f, 0.04326821f, 0.03320430f, -0.06534272f, -0.91016245f, 0.06732537f, -0.00653405f, 
    -0.09770875f, 0.25193769f, 0.09038732f, -0.28475264f, 0.00104036f, 0.06770187f, 0.07768998f, 0.13250791f, 
    -0.67072421f, -0.16145818f, 0.02049093f, 0.29478738f, 0.04747658f, -0.02598820f, 0.07896985f, 0.07269900f, 
    0.18550475f, 0.10980044f, -0.17128022f, 0.04203473f, 0.04325885f, 0.02415739f, 0.08932396f, -0.04589910f, 
    -0.04695694f, -0.05767790f, 0.08141378f, 0.34602091f, -0.14591669f, 0.03563404f, -0.06615317f, -0.07755038f, 
    0.09898080f, 0.09947045f, -0.22199355f, -0.15812029f, 0.19193955f, -0.11949409f, 0.11560016f, 0.08068205f, 
    0.40229866f, 0.12033586f, -0.05545033f, 0.10042340f, -0.01555970f, -0.34492716f, 0.15387955f, -0.08375093f, 
    0.21423565f, 0.25939605f, 0.00316611f, -0.24316165f, -0.21091747f, -0.07863073f, 0.01844311f, 0.27768600f, 
    -0.04693224f, -0.05280962f, 0.21229602f, -0.19485427f, 0.14634605f, -0.00840609f, 0.06099117f, 0.24238312f, 
    -0.08463851f, 0.07309105f, 0.13748659f, -0.06776872f, -0.29177251f, 0.02057911f, 0.00336052f, -0.17303918f, 
    -0.11683659f, 0.19796742f, -0.22988583f, 0.17399134f, -0.36347172f, -0.17219658f, 0.35537007f, -0.57217425f, 
    0.50497073f, 0.22298667f, -0.06052536f, -0.28001648f, -0.09147182f, -0.01875409f, 0.01535881f, -0.46548909f, 
    0.02326188f, -0.03173431f, -0.02836242f, -0.48312363f, 0.40968853f, -0.05058932f, 0.28987563f, -0.00094756f, 
    -0.15412076f, 0.13955471f, -0.09887567f, 0.57945442f, 0.03159822f, 0.30438852f, 0.11210793f, -0.22392772f, 
    -0.02194981f, 0.15451461f, 0.25984859f, -0.14225249f, 0.01243252f, -0.31846634f, -0.08867390f, 0.23133138f, 
    0.07620438f, -0.54659587f, -0.03699498f, 0.10354496f, -0.03470800f, 0.08749256f, 0.34652284f, 0.16736504f, 
    0.05133080f, 0.09268306f, -0.04502392f, -0.42335132f, 0.14586079f, 0.27808475f, -0.00668890f, -0.05706412f, 
    0.00314431f, 0.00652927f, -0.30574730f, -0.45412865f, 0.10792065f, 0.35113055f, -0.05254820f, -0.24210706f, 
    0.28538939f, 0.06916409f, -0.01937316f, 0.00244177f, 0.04776071f, 0.14552227f, 0.08112004f, 0.01526767f, 
    0.16714996f, 0.15046410f, 0.21359198f, -0.06745279f, 0.00951108f, -0.25499269f, 0.33092237f, -0.01063900f, 
    0.10698819f, 0.21538231f, -0.13943335f, -0.02867595f, 0.01602589f, 0.16098827f, 0.10526428f, -0.02716911f, 
    -0.01868749f, 0.11009106f, 0.21066119f, -0.37103775f, -0.02515699f, 0.23812926f, 0.01358479f, 0.12695497f, 
    -0.11178182f, 0.02748020f, -0.18545020f, -0.03831388f, 0.01971050f, 0.19183888f, 0.02175775f, 0.16253915f, 
    -0.10347465f, -0.11242060f, 0.02989638f, -0.04427642f, -0.01559016f, 0.09426865f, 0.21374875f, 0.01699167f, 
    -0.06979601f, 0.10745955f, -0.07412426f, 0.06332438f, -0.11981856f, 0.06393362f, -0.17269272f, -0.13337423f, 
    -0.04404938f, 0.09364910f, 0.09220559f, 0.27804652f, 0.11436421f, 0.13105509f, 0.09884810f, 0.05923449f, 
    0.18462747f, -0.35991552f, -0.07325483f, 0.07263270f, 0.21319072f, -0.05553968f, 0.66122997f, 0.17061731f, 
    -0.72587752f, -0.09122467f, 0.04818957f, 0.00771951f, 0.02319712f, 0.10305481f, -0.00829441f, 0.27098066f, 
    0.09471548f, -0.00518998f, -0.00755890f, 0.13150226f, -0.18305944f, 0.07279459f, -0.05148120f, -0.01334083f, 
    -0.03599194f, -0.27594361f, 0.14524737f, 0.16930319f, 0.00383247f, -0.10283827f, -0.07906961f, 0.42341241f, 
    0.01321171f, 0.15969440f, 0.03472840f, 0.00825112f, 0.20101421f, 0.07602494f, 0.12735531f, -0.12990314f, 
    0.05799425f, 0.11839414f, 0.09794269f, -0.20694719f, -0.05463345f, 0.04638627f, -0.09083386f, -0.21428002f, 
    0.02775046f, 0.15224214f, 0.17871815f, 0.08194989f, 0.35335118f, 0.31469029f, -0.02308919f, 0.02753375f, 
    0.03895745f, 0.03037014f, 0.23865373f, -0.14308603f, 0.08197881f, 0.10028889f, -0.01381025f, 0.05908468f, 
    -0.37189579f, 0.02590108f, 0.18343066f, -0.29756799f, -0.01742966f, -0.06207152f, -0.00140641f, 0.07618423f, 
    -0.04706066f, -0.07367059f, -0.19673166f, 0.03685420f, 0.12826492f, -0.00118548f, -0.04066233f, 0.09930080f, 
    -0.07295793f, -0.25212327f, 0.11830880f, 0.09362993f, 0.00101620f, -0.08825646f, 0.06429379f, 0.19939238f, 
    -0.08167528f, 0.03730619f, 0.54819047f, 0.01008074f, 0.19559205f, 0.02374187f, 0.17726719f, 0.21709107f, 
    -0.04492770f, -0.07665513f, 0.08481908f, 0.06682137f, -0.07156347f, -0.04929827f, 0.05428914f, 0.06962672f, 
    0.01601435f, -0.00318375f, 0.03511960f, 0.00206571f, -0.02706173f, -0.04052138f, 0.01494905f, -0.07811146f, 
    -0.03557315f, 0.07065084f, -0.07949682f, 0.08664512f, -0.02313845f, 0.00793765f, -0.06237916f, 0.01174435f, 
    -0.03159352f, -0.07958207f, -0.00648568f, 0.08104047f, 0.05821282f, -0.06187226f, 0.07908376f, -0.01998684f, 
    0.08132143f, 0.00193198f, -0.04499570f, -0.05921909f, -0.01205324f, 0.06598233f, -0.05473227f, 0.01932126f, 
    0.06059069f, 0.02896918f, 0.01464932f, -0.06393123f, -0.06091842f, -0.01957444f, 0.04514112f, 0.01234377f, 
    -0.05351400f, -0.04211748f, 0.00465781f, -0.07398659f, 0.02223932f, 0.06086608f, -0.06858936f, -0.08689288f, 
    0.05184130f, 0.06584495f, -0.08491661f, 0.02403097f, -0.04816144f, -0.01317956f, 0.06087299f, -0.00145136f, 
    -0.01359163f, 0.08519666f, 0.04422228f, 0.01628652f, 0.00930266f, 0.03239634f, 0.05750661f, 0.01408964f, 
    -0.02450523f, -0.07464876f, -0.06422713f, 0.03935032f, -0.01304631f, 0.00797804f, 0.05623071f, -0.03160121f, 
    0.00842028f, 0.07604285f, -0.04196080f, -0.08122127f, -0.07387845f, -0.05938775f, -0.07544332f, -0.08712881f, 
    -0.06204063f, -0.02137676f, -0.05549584f, -0.07068217f, -0.07891480f, 0.04103404f, -0.05845900f, 0.05776546f, 
    -0.05504142f, 0.08300954f, -0.06087431f, -0.05285986f, -0.03161171f, -0.05527288f, -0.03512212f, 0.01165631f, 
    0.08452088f, 0.07829475f, -0.07210720f, -0.05409696f, 0.02947412f, -0.08646728f, -0.05070528f, 0.00241994f, 
    -0.00317806f, -0.07336109f, -0.00181199f, -0.06096920f, -0.06557121f, -0.00647463f, 0.01272518f, -0.04706597f, 
    0.05451116f, 0.06232811f, -0.04882393f, -0.06555340f, -0.08779934f, -0.00650673f, -0.08106839f, -0.01852694f, 
    0.05752854f, -0.07174768f, -0.01394745f, 0.00841526f, -0.08701000f, 0.03197899f, 0.05611024f, 0.02453797f, 
    0.00203951f, -0.07463345f, 0.08000354f, -0.03047415f, -0.04794955f, 0.00275683f, 0.05642963f, -0.00951691f, 
    0.06897099f, 0.02041162f, -0.04611537f, 0.01268718f, -0.01595372f, -0.01542694f, -0.04430888f, 0.07804412f, 
    -0.08446110f, 0.04677819f, -0.10178943f, -0.05546078f, -0.05200799f, -0.09494163f, -0.00812574f, -0.07630920f, 
    0.00490069f, 0.01081060f, 0.04100770f, 0.07539412f, 0.01840781f, 0.05158075f, -0.04585789f, -0.00597618f, 
    0.06682435f, -0.10991243f, 0.01361942f, -0.10081690f, 0.02043308f, -0.00496235f, -0.01820273f, -0.02311907f, 
    -0.03696802f, 0.03724212f, -0.05375855f, -0.05341225f, -0.07074808f, 0.04481184f, 0.04094316f, -0.01283023f, 
    -0.10462124f, 0.01523507f, -0.02058012f, -0.07310196f, -0.10313740f, -0.02357125f, -0.03663464f, -0.08176365f, 
    -0.10946438f, 0.01339873f, 0.04977671f, 0.02137904f, 0.02011745f, -0.03087122f, -0.00511240f, -0.05837716f, 
    0.00856679f, 0.06542130f, 0.05366816f, -0.08854473f, -0.04377385f, -0.06731655f, -0.02892458f, -0.00645145f, 
    -0.10613012f, -0.03687682f, -0.04329324f, -0.08747032f, 0.03532942f, -0.02279047f, 0.02263391f, 0.04201182f, 
    -0.00359362f, -0.04277893f, -0.02247411f, -0.02512404f, 0.04372619f, 0.02348171f, -0.00223503f, 0.03159817f, 
    -0.08544900f, -0.05900350f, -0.02019756f, -0.03646712f, -0.10261544f, -0.04011199f, 0.05287282f, 0.05523792f, 
    -0.08940749f, -0.05594960f, -0.04364907f, 0.03852153f, -0.05972996f, 0.01128616f, -0.08218855f, 0.04388912f, 
    -0.03220874f, -0.08307777f, 0.02362745f, 0.00458798f, 0.02770470f, -0.03248482f, -0.07008561f, -0.02997641f, 
    -0.08565741f, -0.05847000f, 0.02196625f, -0.02411553f, -0.04440467f, 0.04617929f, 0.05912311f, 0.02702824f, 
    -0.20311460f, -0.11156442f, -0.58171445f, -0.03048085f, -0.01734300f, 0.10767770f, 0.23673879f, 0.01112078f, 
    0.04558277f, 0.01535290f, -0.24959828f, 0.08798482f, 0.23722109f, -0.14012018f, 0.31978333f, 0.08969757f, 
    -0.09329669f, 0.12642154f, -0.30617663f, -0.05181988f, -0.14170834f, -0.01945493f, -0.11876064f, -0.04943286f, 
    -0.11065743f, -0.04143811f, 0.09211788f, 0.02859543f, 0.23459871f, 0.03786494f, 0.32948965f, 0.00097567f, 
    0.02171483f, -0.15259232f, -0.11137789f, -0.60285193f, 0.07902184f, -0.05506657f, 0.03243736f, 0.09479401f, 
    -0.43097329f, -0.07463236f, -0.01596842f, 0.12321465f, 0.05665982f, -0.08292903f, -0.05670017f, -0.12095854f, 
    0.13968517f, 0.07294103f, 0.03602482f, -0.17360742f, -0.11624641f, 0.10845830f, -0.06694033f, 0.06938566f, 
    0.13457051f, 0.00475287f, -0.08223482f, 0.05246561f, -0.22033043f, -0.20941204f, 0.12346073f, -0.15966861f, 
    -0.16572797f, 0.18393819f, -0.24081957f, -0.04529447f, 0.41559473f, 0.20812158f, 0.00246874f, -0.00091338f, 
    0.01041535f, 0.02676520f, -0.01594809f, -0.02683286f, 0.07235297f, 0.02983135f, -0.05422661f, -0.05721780f, 
    -0.00920137f, 0.16485527f, 0.20866841f, -0.01606839f, -0.60422236f, -0.19402431f, -0.04717809f, 0.04491488f, 
    -0.03773431f, 0.10830449f, -0.09870309f, 0.09418287f, -0.03903427f, -0.03957991f, 0.03288681f, 0.12543635f, 
    -0.18108511f, -0.02569043f, 0.16698970f, 0.12925394f, 0.17062820f, 0.21799256f, 0.00417494f, 0.07391392f, 
    0.13781926f, 0.02659602f, 0.12418273f, 0.03133872f, 0.19365717f, 0.12099561f, 0.02718814f, 0.08891643f, 
    -0.08087353f, -0.41626588f, 0.05521556f, 0.19656494f, 0.02057748f, 0.24091670f, 0.04404247f, -0.19423619f, 
    0.06954572f, 0.33812380f, -0.01139894f, 0.13236783f, 0.08895791f, -0.12432244f, 0.00016357f, 0.15020779f, 
    -0.03766580f, -0.08256166f, -0.08204212f, -0.03198421f, -0.00372208f, -0.08381963f, -0.07448345f, 0.03117056f, 
    0.00331715f, -0.03229658f, -0.07826190f, 0.07960849f, -0.06716157f, -0.07033484f, 0.07082763f, 0.00765116f, 
    -0.00047944f, 0.05730205f, -0.03145739f, -0.01267849f, -0.07847635f, -0.09840615f, -0.09329978f, 0.03919598f, 
    -0.04439334f, 0.00204333f, -0.07004627f, -0.04428918f, -0.04076757f, 0.05124053f, -0.10462705f, -0.07057516f, 
    -0.04809101f, -0.01475554f, -0.06429801f, 0.02599523f, 0.05774359f, -0.06207345f, 0.02803118f, 0.02759709f, 
    -0.01644508f, -0.07033003f, 0.06616145f, 0.00992438f, 0.08461527f, -0.00583290f, 0.01320013f, 0.09048897f, 
    0.03279087f, 0.07038102f, -0.08425950f, 0.03522843f, -0.06635993f, -0.09836460f, -0.03755712f, -0.00642741f, 
    0.01165719f, -0.03445711f, -0.06544611f, -0.03271807f, 0.06328821f, 0.07061487f, 0.04553479f, -0.00906042f, 
    -0.05150690f, 0.04377843f, -0.02426780f, 0.03939918f, -0.09619508f, -0.02408083f, -0.00914047f, -0.08944676f, 
    0.06566674f, -0.08573764f, -0.07885637f, 0.09891451f, -0.05662246f, 0.03646060f, 0.01860845f, -0.08603933f, 
    -0.09499173f, -0.09411243f, 0.04734942f, 0.05792979f, -0.09555119f, 0.07377574f, -0.08193944f, -0.06127724f, 
    0.02372247f, 0.04724970f, -0.09389468f, 0.00357384f, 0.05538841f, -0.06932320f, -0.05635058f, -0.02582548f, 
    0.02432849f, -0.08557693f, -0.01734195f, 0.06850804f, 0.04853437f, -0.06318200f, 0.03216486f, 0.01299267f, 
    0.06217288f, -0.08312718f, -0.07717025f, -0.05205733f, -0.04332913f, -0.02256540f, 0.03407834f, -0.06929158f, 
    -0.05934715f, -0.00719699f, -0.06039782f, 0.02042016f, 0.03430021f, -0.02655185f, -0.02275130f, -0.00494228f, 
    0.03378551f, -0.05582533f, 0.04252217f, -0.07038099f, -0.04782993f, 0.00730843f, -0.02663003f, -0.05676979f, 
    -0.03021185f, 0.04232989f, 0.13996844f, 0.02467871f, -0.05572798f, 0.07468171f, -0.05447320f, 0.22947752f, 
    0.21874014f, -0.00758871f, -0.19221662f, -0.05212808f, -0.00869809f, -0.14673786f, 0.08195639f, 0.17258379f, 
    0.00667310f, 0.13414589f, 0.17487772f, 0.12983729f, -0.16258238f, -0.03324926f, -0.56272638f, 0.00217131f, 
    0.11544984f, 0.04840903f, 0.09197003f, 0.12879105f, 0.08903016f, 0.14604908f, -0.10231157f, 0.04862196f, 
    0.06218920f, -0.09127588f, -0.09653287f, -0.06523005f, 0.13518423f, -0.02594039f, -0.02520010f, 0.44233090f, 
    0.05980084f, 0.03050543f, -0.06770471f, -0.19223112f, 0.03806752f, 0.04546163f, -0.03112088f, 0.24125072f, 
    -0.20841916f, 0.16606362f, 0.05873369f, -0.03454028f, -0.13280052f, -0.17708385f, 0.16463950f, -0.02120348f, 
    -0.09902199f, -0.12673341f, -0.09382022f, 0.14795382f, -0.07670367f, 0.15639386f, -0.26972559f, -0.29732779f, 
    0.00040690f, -0.05952297f, 0.14141820f, -0.19610068f, 0.22110337f, 0.02071295f, -0.03874869f, -0.10686506f, 
    -0.06518060f, 0.10287387f, 0.06341112f, -0.20129921f, 0.08733802f, 0.07511830f, -0.06697720f, 0.00937012f, 
    0.11628054f, 0.21216951f, 0.08949723f, -0.11111185f, -0.09114847f, 0.09958652f, 0.01811522f, -0.07191767f, 
    0.04167239f, 0.05445888f, 0.22331385f, -0.06623341f, 0.10891108f, 0.27859074f, 0.04221454f, -0.01961438f, 
    0.70170486f, -0.23754540f, 0.28157988f, -0.22155547f, 0.13699740f, 0.11014973f, 0.29454076f, -0.07633828f, 
    0.12335383f, -0.01880253f, -0.08853930f, -0.06198779f, 0.19324104f, 0.16789363f, -0.01850292f, -0.17860790f, 
    -0.08550264f, 0.00266066f, -0.03521256f, 0.30141586f, -0.07087482f, -0.04099968f, -0.16627024f, 0.05455697f, 
    -0.02620722f, 0.02780725f, -0.19580689f, 0.01748891f, 0.10394551f, 0.16472049f, 0.11200146f, -0.11991776f, 
    0.19785190f, -0.31158775f, 0.08471891f, 0.09908223f, 0.02713320f, 0.09897330f, 0.11418001f, 0.14559734f, 
    0.21058019f, 0.02632037f, -0.17826849f, -0.01801293f, -0.12923412f, 0.02386410f, -0.05184419f, 0.16120280f, 
    -0.01324345f, 0.11265213f, 0.26868305f, -0.13283272f, 0.20856056f, -0.24233940f, 0.00978666f, 0.15570000f, 
    0.02661642f, 0.24794924f, 0.17130983f, 0.05949466f, -0.16985829f, 0.07327465f, 0.03913807f, -0.05472780f, 
    -0.10874640f, 0.17142451f, 0.04388483f, 0.23553471f, 0.00720254f, -0.06738001f, -0.06225920f, 0.00138959f, 
    0.26777187f, -0.17294176f, -0.08744824f, -0.32568669f, 0.11933540f, 0.13893196f, -0.01819964f, 0.11952326f, 
    -0.01643575f, -0.01275941f, 0.10087510f, 0.00010501f, -0.05750520f, -0.21527353f, 0.33298579f, -0.18096346f, 
    -0.28165457f, 0.07721529f, -0.16966294f, 0.39986137f, 0.06436624f, 0.20503537f, -0.36939016f, 0.14696963f, 
    0.12316240f, 0.01492450f, 0.25583297f, -0.09811938f, -0.04636481f, -0.10540242f, -0.04132658f, -0.11155726f, 
    0.04620053f, -0.10069789f, -0.10678055f, 0.02666068f, 0.02019666f, 0.01903403f, 0.06631705f, 0.21329059f, 
    0.02675184f, 0.01016998f, 0.16915123f, -0.16748706f, 0.18621729f, 0.35130957f, 0.06574391f, -0.16659366f, 
    -0.04788564f, -0.10667546f, 0.27893105f, -0.23024593f, 0.35053799f, 0.20894931f, -0.01700017f, -0.11148649f, 
    0.26280427f, -0.00804323f, 0.03470646f, -0.36951840f, 0.04846865f, 0.24972257f, -0.09987918f, 0.08136254f, 
    0.11005712f, 0.10842448f, 0.15944955f, -0.20050851f, 0.18915324f, -0.03664834f, 0.12965301f, -0.01255640f, 
    0.11512090f, 0.16309012f, 0.05008740f, -0.11310846f, -0.40114424f, -0.12044768f, 0.01571531f, 0.05301208f, 
    -0.00360602f, -0.15901721f, -0.20954956f, -0.00605988f, 0.01410277f, 0.29344982f, -0.09736203f, 0.25184301f, 
    -0.06510348f, 0.05287808f, -0.03612541f, -0.04200561f, -0.06514988f, 0.03651900f, 0.02745538f, -0.02719542f, 
    -0.09093204f, -0.08037526f, -0.04630115f, -0.04588077f, -0.01131912f, -0.00877016f, -0.04827159f, -0.03935146f, 
    -0.00539709f, -0.02411658f, 0.01416139f, 0.00059421f, -0.02997276f, 0.06130604f, -0.01120880f, 0.02236037f, 
    0.02810238f, 0.04772636f, -0.07287148f, -0.04572858f, 0.00173012f, 0.03242851f, -0.10038219f, 0.02678247f, 
    0.04892989f, -0.02901856f, 0.02698307f, -0.02817672f, 0.01886207f, -0.07831313f, -0.03642599f, -0.07950712f, 
    -0.05377700f, 0.01042357f, 0.03818983f, -0.05535854f, 0.00794959f, -0.00292816f, 0.06016697f, -0.07040067f, 
    0.06856604f, 0.04994227f, -0.02636953f, -0.00641244f, -0.01895330f, -0.05330040f, -0.06913846f, -0.07536974f, 
    0.06054627f, -0.00564007f, -0.08666394f, -0.06017766f, -0.00949553f, 0.03174504f, -0.09337701f, 0.05446626f, 
    0.00777596f, 0.05063822f, 0.03279648f, -0.08367218f, -0.07393008f, -0.05458167f, -0.09649603f, 0.04477562f, 
    0.01379535f, -0.09395555f, -0.07631584f, 0.06526128f, 0.00429444f, -0.02097865f, -0.03432165f, 0.06489863f, 
    0.05794829f, -0.09209821f, 0.03818307f, -0.08721523f, 0.02747357f, -0.07923134f, 0.06381231f, 0.03188029f, 
    -0.06213874f, -0.04961988f, -0.09151986f, 0.00059634f, -0.08829058f, 0.07104999f, 0.08253427f, 0.01615174f, 
    -0.00377837f, -0.07394658f, -0.09481189f, -0.08787797f, 0.02731206f, -0.02967893f, 0.01215609f, -0.00405909f, 
    -0.05381749f, -0.06704131f, 0.05983755f, 0.01615704f, -0.05724350f, -0.00006645f, 0.01455055f, 0.01051296f, 
    0.06353230f, -0.00280589f, 0.03602492f, 0.07392088f, -0.02027619f, -0.03124149f, 0.03820150f, 0.00943080f, 
    -0.04184425f, -0.05751443f, 0.01855974f, -0.02984656f, -0.03777595f, 0.05546983f, -0.06433367f, 0.04541663f, 
    -0.14628874f, 0.07528463f, 0.17813377f, 0.06317228f, 0.02159845f, -0.07455380f, 0.11634356f, -0.03670929f, 
    -0.03951469f, 0.14776844f, -0.08608176f, 0.07682097f, -0.10536924f, 0.19545965f, -0.25827923f, -0.00678441f, 
    0.02989267f, -0.27726689f, -0.05222187f, 0.10972455f, -0.08395836f, -0.27507922f, 0.31561914f, -0.08980845f, 
    -0.31089559f, -0.70750076f, 0.05551423f, 0.20655616f, 0.23103057f, 0.09208971f, -0.05262793f, -0.32013655f, 
    0.41349560f, -0.04200366f, -0.12010562f, 0.13147528f, -0.30347747f, 0.03518647f, 0.20333478f, -0.59725851f, 
    0.04091592f, -0.05415819f, -0.02530484f, -0.44227445f, -0.20248602f, 0.03854182f, -0.08207638f, -0.17960212f, 
    0.00857889f, -0.00953283f, -0.03849969f, -0.02865990f, -0.18227991f, 0.26740152f, 0.15333407f, -0.15978774f, 
    0.08205210f, 0.29592881f, 0.20651816f, 0.15961914f, 0.13297211f, -0.19606723f, 0.18251102f, -0.14212666f, 
    -0.01783979f, -0.29283395f, -0.02897892f, 0.22081584f, 0.09681182f, 0.22859535f, -0.03406843f, 0.43309054f, 
    -0.10919181f, -0.12355076f, 0.06109231f, -0.04517730f, 0.14038236f, -0.03474085f, -0.27452907f, 0.04777451f, 
    0.09006497f, -0.07623456f, -0.01748393f, 0.11037711f, 0.30662638f, -0.84159893f, 0.07946403f, 0.19483924f, 
    0.10037900f, 0.20272891f, 0.38159937f, -0.35232487f, 0.09639655f, 0.31983113f, -0.03545953f, 0.12848295f, 
    0.00648897f, -0.27615911f, -0.11789557f, 0.25136554f, -0.06908846f, 0.07427980f, -0.15000261f, -0.07091388f, 
    0.05361724f, 0.24841307f, -0.14431886f, -0.10535718f, 0.02587938f, -0.13461059f, -0.13149042f, 0.14525655f, 
    0.12985274f, 0.13068189f, -0.04891128f, 0.09380353f, 0.10403124f, -0.03536536f, 0.02845943f, -0.27942917f, 
    0.16094886f, 0.38785794f, -0.27932888f, -0.03893132f, 0.17744659f, -0.01555041f, -0.00307014f, 0.11303099f, 
    0.09428991f, 0.17008431f, -0.16574390f, -0.00467038f, 0.13209802f, 0.00607554f, -0.22118269f, 0.11729323f, 
    0.15910223f, -0.01916199f, 0.23772779f, -0.10871568f, -0.28286827f, -0.10347012f, -0.00793221f, 0.14604780f, 
    0.06835087f, -0.03937366f, -0.24422075f, -0.09011654f, -0.08349250f, 0.07663547f, -0.27353242f, 0.14384396f, 
    0.13831677f, 0.26999506f, -0.01158875f, -0.14578511f, 0.18502824f, -0.08874393f, -0.08830870f, -0.08508756f, 
    -0.24576792f, 0.10689941f, -0.15605986f, -0.13476427f, 0.03534082f, 0.01605459f, -0.48753771f, 0.46300161f, 
    -0.05763523f, -0.01100605f, 0.01547198f, 0.26802877f, 0.11831272f, 0.02706814f, 0.05709023f, 0.46865684f, 
    -0.02278828f, -0.09446310f, -0.06689012f, 0.05189703f, 0.19214469f, -0.09042715f, -0.01749207f, 0.10462098f, 
    -0.03973786f, 0.06554619f, 0.08712620f, 0.20298769f, -0.23838297f, 0.07978578f, -0.05588013f, 0.02754132f, 
    -0.07412349f, 0.19926101f, -0.02528339f, -0.04358511f, 0.05454467f, 0.12667565f, 0.14648400f, -0.23119622f, 
    0.20724516f, 0.22362204f, 0.06084733f, -0.00392724f, -0.20410056f, -0.05820462f, -0.28163755f, 0.07326929f, 
    -0.01005225f, -0.09916006f, 0.09401342f, -0.12617558f, -0.23080215f, 0.48236123f, 0.05636603f, -0.09407119f, 
    -0.09367610f, 0.07680456f, -0.20115168f, 0.06794664f, -0.05506019f, -0.29109207f, 0.13768850f, 0.04108208f, 
    0.08674026f, 0.04418844f, 0.08865711f, -0.07888574f, 0.06938132f, -0.01631665f, 0.15033995f, 0.07132696f, 
    -0.04580877f, -0.17391481f, 0.10712271f, 0.08025572f, 0.13990107f, 0.16201100f, 0.06854639f, -0.22626400f, 
    -0.12543786f, -0.05472408f, -0.00682523f, 0.11925066f, 0.50842190f, 0.07863292f, 0.13232604f, 0.25291327f, 
    0.12652031f, -0.08670271f, 0.01802430f, -0.25890318f, -0.08770190f, 0.15097702f, 0.09737168f, 0.18049052f, 
    0.01890977f, 0.11216472f, 0.21159644f, 0.02171184f, -0.02700632f, 0.05427002f, -0.08647558f, -0.00664624f, 
    0.11522017f, -0.08589323f, 0.14943601f, -0.03759490f, -0.21327308f, 0.02951638f, -0.01787762f, 0.22026403f, 
    -0.03951176f, -0.16639936f, -0.01603639f, -0.18833476f, -0.00681337f, -0.09144888f, -0.11844692f, -0.08183730f, 
    0.02063187f, -0.47986943f, 0.18924442f, 0.09228307f, 0.20105056f, 0.15310344f, 0.20122203f, -0.16946322f, 
    -0.02735315f, -0.24200240f, -0.15247357f, 0.06524241f, -0.06075657f, -0.00014758f, 0.35766491f, 0.36273891f, 
    -0.09587327f, 0.28783020f, -0.00281036f, -0.01475285f, 0.02519131f, 0.05353574f, -0.03917658f, 0.13318698f, 
    -0.09076172f, 0.04721439f, -0.03528743f, 0.06953795f, 0.00159071f, -0.03903748f, 0.09565313f, 0.00618915f, 
    -0.11113484f, 0.10746843f, 0.12378491f, 0.24087426f, -0.10263931f, -0.04920276f, -0.05677223f, 0.32042986f, 
    -0.04338563f, 0.33785394f, 0.15848531f, 0.03527512f, 0.23194459f, 0.09552301f, -0.11925766f, -0.06561513f, 
    -0.01076380f, 0.04700871f, 0.19961849f, 0.03735178f, -0.00622993f, 0.02398399f, -0.40108016f, -0.12416703f, 
    -0.01383657f, -0.05430711f, 0.04379359f, -0.06529583f, 0.03653251f, -0.49137351f, -0.07663204f, 0.02610592f, 
    -0.03920135f, 0.29094335f, 0.18163551f, -0.21410055f, 0.17655899f, 0.06898053f, -0.04545412f, 0.02473727f, 
    -0.31772929f, 0.03036848f, -0.01291409f, 0.10732896f, -0.03188013f, -0.02399487f, 0.26885197f, 0.07288973f, 
    0.09536628f, 0.10897370f, -0.08678725f, 0.04224826f, -0.07351369f, -0.09482878f, 0.00106116f, 0.00133752f, 
    -0.07302162f, -0.01860154f, -0.00200301f, 0.14105026f, 0.45845768f, 0.16402628f, 0.10566247f, 0.14166836f, 
    0.04196030f, 0.06817162f, 0.30031398f, -0.40992585f, 0.21167444f, 0.11418158f, 0.12177745f, -0.14678891f, 
    -0.00282385f, 0.34398523f, -0.04700712f, -0.03090698f, 0.08367112f, 0.01688603f, -0.37538439f, 0.23098980f, 
    -0.18968116f, -0.36235708f, 0.01460748f, 0.02506015f, -0.06842475f, 0.06616499f, 0.04994537f, -0.19502856f, 
    -0.00797831f, 0.03921767f, -0.03939721f, -0.05448763f, 0.02472980f, 0.19434132f, -0.30012548f, -0.19109631f, 
    0.13202056f, -0.22504459f, 0.10233369f, 0.36340401f, 0.16374719f, 0.04190224f, 0.49963075f, -0.02069264f, 
    0.20729430f, -0.12798914f, 0.08009823f, 0.13736588f, 0.09745359f, 0.06700940f, -0.21996301f, 0.21566068f, 
    -0.64843071f, 0.07424843f, 0.07100861f, 0.34432322f, 0.10148155f, 0.02145117f, 0.00557796f, -0.03108012f, 
    0.10474444f, 0.25356668f, -0.06051716f, 0.04875240f, -0.04793582f, 0.11024325f, -0.23871292f, 0.25279456f, 
    0.03066360f, -0.35959691f, 0.01148815f, -0.06931851f, 0.10666519f, -0.08610122f, -0.09559911f, 0.22261009f, 
    -0.16636267f, 0.24404171f, -0.10287755f, 0.25473565f, 0.41013649f, 0.06784167f, 0.07435639f, -0.31514788f, 
    0.25508153f, 0.13539621f, 0.25807130f, -0.12835538f, -0.06091626f, 0.02006582f, 0.08404684f, -0.05858633f, 
    -0.04711826f, -0.02033768f, 0.16722520f, -0.07181405f, -0.02887660f, 0.12800580f, 0.08140243f, 0.13961381f, 
    0.06004972f, 0.00265237f, 0.03930172f, 0.01690854f, -0.05520199f, 0.02091418f, 0.01289912f, 0.20481572f, 
    -0.00577879f, 0.45836246f, -0.07667769f, -0.64085454f, 0.15891473f, -0.14230412f, 0.34215683f, 0.06827159f, 
    -0.40257183f, -0.35736412f, -0.10885579f, 0.00627419f, 0.11406354f, 0.12076327f, -0.06485020f, 0.10453046f, 
    -0.19039525f, -0.10629132f, 0.10517081f, 0.36490810f, 0.21492149f, 0.20378974f, 0.14463003f, 0.22602770f, 
    0.15288430f, 0.01518345f, 0.38769072f, -0.06747933f, 0.24359703f, -0.12688327f, 0.10728023f, 0.36736465f, 
    -0.18769790f, -0.02504513f, 0.40498489f, -0.01472365f, 0.06813169f, -0.31977937f, 0.01661040f, 0.18118435f, 
    0.13174801f, -0.15570079f, -0.22970968f, -0.00477606f, -0.23233663f, 0.23116663f, -0.26943985f, -0.04876698f, 
    -0.04757606f, -0.17578132f, -0.12761816f, 0.00871029f, 0.29617694f, 0.15279956f, 0.40859067f, -0.08267017f, 
    -0.11648176f, 0.54886216f, -0.15787472f, -0.04133727f, -0.00450126f, -0.05751343f, -0.06011315f, 0.06820033f, 
    0.21608867f, 0.03328023f, 0.15016668f, -0.29401630f, -0.26000136f, 0.06131927f, -0.00436870f, -0.09818529f, 
    -0.07588902f, -0.14367129f, -0.05583118f, 0.10064975f, 0.21844685f, 0.10284068f, -0.04309268f, 0.09562013f, 
    -0.04917977f, -0.22215840f, -0.01134153f, -0.18828750f, -0.00576736f, 0.26902461f, 0.01202077f, 0.03425807f, 
    -0.03853567f, 0.05754434f, -0.26578814f, 0.33806619f, 0.04944669f, -0.28667128f, 0.45618644f, -0.04075140f, 
    0.25973666f, -0.32822007f, -0.54965973f, 0.03078958f, -0.16126443f, 0.10540064f, -0.06285739f, 0.08982212f, 
    0.04626824f, -0.09116105f, -0.03025157f, -0.03219346f, -0.04047437f, -0.04821922f, -0.26841900f, -0.19673121f, 
    0.08790773f, 0.01588192f, 0.09815103f, -0.04629403f, 0.19473293f, 0.52257323f, -0.05970345f, -0.19449975f, 
    0.09869261f, 0.24635223f, 0.11569097f, -0.51965284f, 0.05426319f, -0.60207158f, 0.07279712f, -0.04027477f, 
    0.44763651f, 0.13547719f, -0.08267513f, 0.56541264f, 0.04620024f, -0.20450611f, -0.01370818f, -0.03772279f, 
    -0.02106003f, -0.06448690f, 0.00199524f, -0.00572878f, 0.06642380f, -0.29639226f, -0.10155535f, -0.02805430f, 
    0.40603212f, -0.01536450f, 0.06649599f, -0.22604094f, -0.30543551f, 0.05254788f, 0.39242867f, 0.08551165f, 
    0.12981896f, -0.19514316f, 0.26251546f, -0.13208386f, 0.05005436f, -0.56316495f, 0.13795145f, -0.32265642f, 
    0.05887364f, -0.02091999f, 0.29248002f, 0.03878299f, -0.01430706f, -0.03114434f, -0.06808983f, 0.14162567f, 
    0.02053078f, -0.00569592f, 0.49955338f, -0.10603349f, -0.35885924f, 0.03880579f, 0.00457258f, 0.09220913f, 
    0.00493355f, -0.04037417f, 0.09843995f, -0.22165745f, -0.12542091f, -0.11095506f, -0.07898058f, -0.08129737f, 
    -0.08120043f, -0.84081697f, 0.16323051f, -0.00363237f, 0.07157610f, 0.16512063f, -0.11620007f, -0.07939289f, 
    0.09922151f, -0.30333063f, -0.08785231f, -0.02522387f, 0.16417655f, -0.00436371f, 0.34771660f, 0.19527617f, 
    0.00090061f, 0.17805740f, 0.01787861f, -0.05632726f, -0.19500199f, -0.06295684f, 0.24168240f, 0.03850407f, 
    -0.18420860f, -0.13953674f, 0.04539228f, 0.06948979f, -0.11511046f, -0.13501860f, -0.07670969f, -0.21618830f, 
    -0.11224768f, -0.01818441f, 0.17754924f, 0.37224108f, -0.26384526f, 0.01187432f, -0.21006945f, 0.42829075f, 
    0.03723383f, 0.27943906f, 0.35443461f, -0.08560682f, 0.21084601f, -0.04095096f, 0.12828462f, -0.08014855f, 
    0.05346918f, 0.05825810f, 0.13020076f, -0.08492497f, -0.14089441f, 0.01151619f, -0.26684907f, 0.04089785f, 
    -0.00901004f, -0.09266851f, 0.06493144f, -0.02688341f, 0.32147050f, -0.68960482f, -0.07962499f, -0.14162204f, 
    -0.18629493f, 0.06786384f, 0.40099695f, -0.23358458f, 0.28023300f, 0.31605163f, -0.10446464f, 0.15798526f, 
    0.05769473f, -0.22038832f, -0.08387022f, -0.08695399f, -0.07716388f, 0.04761976f, 0.06656390f, -0.05821430f, 
    0.12698840f, 0.01133450f, -0.04545730f, 0.13597070f, 0.06905382f, -0.16800489f, -0.00548749f, 0.11388879f, 
    0.00773905f, -0.02472214f, 0.00184738f, 0.04708055f, 0.62863272f, -0.02803718f, 0.04303763f, 0.17896307f, 
    -0.02849682f, 0.02891239f, 0.04484145f, -0.19798253f, 0.08467647f, 0.26430058f, 0.04902348f, 0.15904187f, 
    0.07569783f, -0.01149221f, -0.03162921f, -0.02076507f, 0.07726613f, -0.09300916f, 0.03647054f, 0.01520407f, 
    0.02911881f, -0.09050335f, 0.03936607f, -0.06410470f, 0.01967281f, -0.01027534f, -0.06524049f, 0.01351031f, 
    0.06758709f, 0.03763811f, 0.00270706f, -0.09154081f, 0.03664595f, 0.03539308f, -0.02408860f, 0.00153206f, 
    0.03457251f, 0.03952402f, 0.02986551f, -0.08236698f, 0.07264155f, 0.01020535f, -0.07480691f, -0.07906009f, 
    0.08003338f, -0.05494059f, -0.03730063f, -0.07595256f, 0.06807551f, -0.06191994f, 0.05353810f, -0.02764561f, 
    -0.03401797f, -0.00642204f, 0.04374959f, -0.03998835f, 0.05346979f, 0.01646099f, 0.08563447f, 0.05158138f, 
    0.00684912f, -0.06097940f, 0.06062004f, 0.05653543f, 0.02713297f, 0.05935566f, -0.00223977f, -0.05636191f, 
    0.04688448f, -0.02220596f, -0.06226088f, -0.01462145f, 0.08807129f, 0.06313134f, 0.07399231f, -0.09181403f, 
    -0.06679720f, -0.02208117f, 0.04997891f, 0.02029248f, -0.00784253f, -0.02022227f, -0.05856503f, -0.05303723f, 
    0.01769670f, -0.06627134f, -0.04594347f, -0.08523975f, -0.04127616f, 0.04176408f, -0.02713609f, -0.06281149f, 
    -0.02069564f, -0.02154329f, 0.03099988f, -0.03915003f, -0.02729038f, 0.03936286f, 0.03460525f, 0.00298759f, 
    -0.06724040f, -0.08962084f, -0.00714325f, -0.08743247f, 0.00617018f, -0.02363547f, 0.02936530f, 0.06868618f, 
    -0.00535357f, -0.07544568f, -0.01266465f, 0.07670677f, -0.09530792f, 0.01019469f, -0.02319464f, -0.05881315f, 
    -0.00207128f, 0.00268780f, 0.03535860f, 0.05530968f, -0.07012294f, 0.01292029f, 0.00419881f, -0.06057662f, 
    0.02297626f, -0.05590769f, -0.00885608f, -0.02547013f, -0.06683429f, 0.04459814f, 0.04435177f, 0.05297174f, 
    -0.00423292f, 0.02390109f, 0.01530221f, 0.04362761f, -0.01165270f, -0.02856561f, 0.03388193f, 0.03963189f, 
    -0.49181744f, -0.42215332f, -0.03261843f, 0.07528625f, -0.00131307f, 0.06622153f, 0.03118858f, -0.05028332f, 
    0.18194684f, -0.43610540f, -0.22192110f, 0.14681716f, 0.05905238f, 0.15556601f, -0.64916259f, 0.14615785f, 
    0.03426870f, -0.03514727f, 0.03882233f, 0.07221630f, 0.35875568f, -0.06028300f, 0.25131771f, -0.36245531f, 
    0.00039643f, -0.02695917f, 0.02438121f, 0.18448177f, -0.06387045f, 0.05444944f, -0.10020522f, 0.06969760f, 
    0.11211807f, 0.01553778f, 0.28403470f, 0.07529531f, -0.00046731f, -0.02373713f, -0.33195809f, -0.05818110f, 
    0.40531188f, -0.02745852f, 0.01426464f, -0.42070180f, 0.10831992f, 0.09598345f, 0.09205209f, -0.03788779f, 
    0.25730780f, -0.04580704f, 0.15192990f, -0.06532079f, -0.63713342f, 0.12068620f, 0.18778251f, 0.17742097f, 
    -0.01713258f, 0.03768991f, -0.04882498f, -0.19950804f, 0.10114534f, -0.39113736f, 0.26548311f, 0.15824217f, 
    0.13859943f, -0.43317491f, -0.50340742f, 0.20028859f, -0.06064533f, 0.07594322f, -0.06352569f, 0.05421288f, 
    -0.09763858f, 0.08036718f, 0.02581587f, -0.64045155f, -0.08076292f, -0.00165067f, 0.06025536f, -0.28484035f, 
    0.23505087f, 0.01835572f, 0.01134098f, 0.12521753f, 0.25321415f, 0.09003226f, -0.02286625f, 0.10161763f, 
    0.10462431f, -0.05568614f, 0.24139461f, -0.01621264f, -0.00273934f, -0.21598290f, 0.01927902f, 0.10401400f, 
    -0.02353742f, -0.10428388f, -0.21564311f, -0.08172267f, -0.55019718f, -0.44641355f, -0.21815485f, 0.02075882f, 
    -0.05413128f, -0.27439415f, 0.01975490f, -0.23674206f, -0.06787313f, -0.07887007f, -0.82468921f, 0.15499146f, 
    0.20394950f, -0.33693814f, 0.18869410f, -0.23583002f, -0.10477947f, -0.23768498f, 0.02151640f, 0.16577266f, 
    -0.24057578f, -0.55910921f, -0.26450571f, 0.13726935f, -0.02852177f, -0.56936854f, -0.02217579f, 0.02556732f, 
    0.31124827f, 0.11478674f, -0.35630852f, 0.09420852f, 0.03982501f, 0.01157248f, -0.01636602f, 0.15150127f, 
    0.09379224f, 0.17496490f, 0.16552152f, -0.10096974f, -0.29264629f, -0.16368930f, 0.04584303f, 0.14822364f, 
    -0.01085998f, -0.12099878f, 0.16104491f, -0.13970032f, -0.13592054f, 0.20488745f, -0.24180579f, 0.19657500f, 
    0.15738332f, -0.87030214f, 0.07297437f, 0.05047766f, -0.59555411f, -0.03632477f, -0.27480656f, -0.09991355f, 
    -0.55753481f, 0.02544409f, -0.18086876f, 0.57848018f, 0.08150917f, -0.17775446f, 0.33241454f, -0.03268480f, 
    0.04983242f, -0.06338178f, -0.04894302f, 0.16367470f, 0.17669176f, -0.06280839f, -0.06405558f, 0.15573317f, 
    -0.04166570f, -0.14503877f, -0.04293619f, -0.06150348f, 0.23354861f, -0.25452498f, 0.05033737f, 0.06781093f, 
    -0.34116295f, 0.04190234f, 0.06634160f, 0.32850063f, -0.10861225f, 0.22998229f, -0.20307061f, 0.01795673f, 
    -0.01340974f, 0.29933691f, 0.08022349f, -0.29989025f, -0.13017453f, -0.59161687f, 0.08680158f, 0.13005461f, 
    0.03948858f, -0.06292227f, -0.03088002f, -0.02158240f, -0.22126241f, -0.01756040f, 0.16729619f, 0.14860864f, 
    -0.13847184f, -0.07216877f, -0.06360988f, -0.22599976f, 0.21477957f, -0.51191473f, -0.02049423f, -0.03844267f, 
    -0.25944692f, 0.00698807f, -0.48862794f, -0.07383211f, -0.06148152f, 0.07429067f, -0.00089658f, -0.06849455f, 
    -0.82698929f, 0.09325996f, -0.04607936f, 0.05542836f, 0.15636587f, 0.15557346f, 0.24198677f, -0.01979297f, 
    0.01673534f, 0.03832123f, -0.03298990f, 0.17334376f, -0.08399298f, 0.03282700f, 0.12536827f, -0.21147162f, 
    -0.19162138f, 0.25104570f, -0.23446937f, -0.09849022f, 0.08131141f, 0.04428564f, -0.07756344f, 0.06747559f, 
    0.02738675f, -0.12666179f, 0.02984361f, -0.20584133f, -0.13070433f, 0.14866057f, 0.04272844f, 0.41544101f, 
    -0.13778800f, 0.13972034f, -0.44889969f, 0.03839132f, 0.07649691f, 0.17016751f, -0.06175890f, -0.00076336f, 
    -0.05793538f, -0.05979765f, -0.46728483f, 0.10900263f, -0.06595176f, 0.04620400f, 0.16789541f, 0.02964923f, 
    -0.06050134f, -0.03291006f, -0.06069688f, -0.03107074f, -0.24169241f, 0.03058327f, -0.07848294f, -0.11522155f, 
    -0.00485779f, -0.27586851f, 0.21456352f, 0.08494263f, 0.20144461f, 0.07295971f, 0.51428193f, -0.04155513f, 
    0.01004991f, -0.00055667f, -0.17596985f, 0.08380865f, -0.00433524f, -0.05323731f, 0.50696349f, 0.29731938f, 
    -0.02199266f, 0.03290589f, 0.03087196f, 0.22383596f, 0.08576418f, 0.16991581f, -0.33690143f, 0.09493681f, 
    0.13595594f, 0.20047411f, -0.06786384f, 0.05305627f, -0.09963787f, 0.13369466f, -0.05196144f, 0.03054812f, 
    0.13859044f, -0.10627674f, 0.04230072f, -0.05717295f, -0.05857621f, 0.01094282f, -0.03887308f, 0.11594655f, 
    -0.19610910f, 0.11134743f, 0.05379916f, 0.20773450f, 0.28237849f, 0.26529160f, 0.21668017f, -0.10838597f, 
    0.07606369f, 0.31133616f, 0.22886641f, 0.25930071f, -0.02610139f, -0.05500793f, -0.03480154f, 0.07246609f, 
    0.12421127f, -0.05999646f, 0.09943400f, -0.03462998f, 0.04293244f, -0.24430184f, -0.01051432f, 0.26297140f, 
    0.04854948f, 0.14604701f, -0.08355320f, 0.02043767f, 0.11116518f, 0.17312589f, -0.07194678f, 0.27668574f, 
    -0.28468069f, 0.09520009f, 0.04981518f, -0.25255430f, 0.23270191f, 0.14100409f, 0.07472413f, 0.06716491f, 
    0.00916756f, 0.26007354f, 0.11549415f, 0.10844263f, 0.03876388f, 0.11102414f, 0.08765908f, -0.00305417f, 
    -0.01943842f, -0.08041986f, -0.05866440f, 0.17904507f, 0.17636262f, 0.21479277f, 0.04863246f, -0.08147895f, 
    0.10428815f, 0.32379499f, 0.31509408f, -0.17435527f, 0.11683327f, 0.07124277f, 0.00076207f, 0.30960399f, 
    -0.05344550f, -0.17430572f, -0.43703085f, -0.07762051f, -0.05114693f, -0.07975260f, 0.15307297f, 0.10114611f, 
    -0.02720973f, -0.03964943f, -0.17277580f, -0.17296524f, 0.12808274f, 0.12487254f, 0.21385452f, -0.03167957f, 
    -0.03750888f, -0.52751106f, -0.29266641f, 0.10594950f, -0.18349503f, 0.09048022f, 0.10246343f, 0.21867740f, 
    -0.43012697f, -0.30631530f, -0.05086908f, -0.20431298f, 0.32713205f, -0.11247332f, 0.06595705f, -0.15592940f, 
    0.11610236f, 0.17342408f, -0.13909507f, -0.07773595f, -0.19506933f, -0.06851929f, -0.45527419f, -0.21076432f, 
    0.07581428f, -0.42446038f, -0.06771026f, 0.11086798f, -0.04174318f, -0.18030985f, -0.13200870f, 0.06265202f, 
    0.04924458f, -0.37160379f, 0.07290513f, 0.16887723f, 0.05679601f, 0.25704104f, -0.14404793f, -0.07885718f, 
    -0.10795823f, 0.12753834f, 0.01161107f, -0.48128262f, -0.14123367f, 0.07615152f, 0.67670232f, -0.33778635f, 
    0.02750312f, 0.06903933f, -0.13515380f, -0.03700025f, -0.08892038f, 0.33478993f, 0.12449224f, 0.11874118f, 
    0.10188398f, 0.18586005f, -0.04346991f, -0.04271905f, -0.09009336f, -0.00081003f, 0.06504055f, 0.21445718f, 
    0.00367511f, -0.05163539f, -0.18266992f, 0.02707494f, -0.29903859f, -0.40201357f, 0.01242212f, -0.08263517f, 
    0.03116387f, 0.13047920f, -0.50970894f, -0.01520123f, -0.44954711f, -0.26251084f, -0.03379324f, 0.03233141f, 
    -0.36384174f, 0.08779807f, 0.18331823f, 0.22973961f, 0.12741277f, 0.14694300f, -0.14371476f, 0.00416118f, 
    0.02657238f, 0.02965698f, 0.31873554f, 0.11611116f, 0.06860264f, -0.07494710f, 0.18101880f, 0.00009987f, 
    -0.00718511f, 0.16327672f, -0.08395933f, -0.25305742f, 0.24666911f, 0.11842664f, 0.24779482f, -0.08595092f, 
    0.17066063f, -0.05392724f, -0.46393672f, 0.26194221f, -0.04223213f, -0.04488143f, 0.05363630f, 0.37089190f, 
    -0.04769671f, -0.00057896f, 0.06283788f, 0.05777276f, -0.06830169f, -0.03168781f, -0.07872083f, 0.04705769f, 
    -0.00484501f, -0.09507793f, -0.00840619f, -0.07468833f, -0.03445264f, -0.00786295f, -0.00357022f, 0.04944593f, 
    -0.04763932f, 0.00180913f, -0.02882044f, 0.01295234f, -0.09348213f, 0.00877060f, -0.06515665f, -0.06891623f, 
    0.03557751f, -0.03217463f, 0.05519181f, 0.05103847f, -0.02009380f, 0.05108723f, 0.06671055f, -0.11823959f, 
    -0.05746727f, -0.02531007f, -0.10438979f, -0.08756328f, -0.06258715f, -0.05178777f, 0.07668483f, 0.00575184f, 
    -0.07708297f, 0.04495062f, 0.06589981f, 0.03256254f, -0.08989448f, -0.04467199f, 0.04881333f, 0.03741531f, 
    -0.02771522f, 0.03673795f, 0.04239581f, -0.06050290f, -0.03220112f, 0.04220412f, 0.04104858f, 0.07367869f, 
    -0.09054566f, 0.00541163f, 0.03161656f, -0.01945071f, -0.01218747f, -0.09877813f, -0.04663864f, -0.03685952f, 
    0.00570926f, 0.02543490f, -0.05536665f, -0.08087914f, 0.01719718f, -0.03686821f, 0.00976998f, 0.04714036f, 
    -0.06895296f, -0.06281205f, -0.07812805f, 0.04452415f, -0.03215066f, 0.02451900f, -0.08591264f, -0.06988367f, 
    0.01146008f, -0.01233997f, -0.08251807f, 0.00139774f, 0.04649305f, 0.06191587f, 0.01907049f, -0.06417008f, 
    0.02812006f, -0.01308319f, -0.00938216f, -0.07644485f, 0.05918500f, -0.10957394f, -0.02992772f, -0.03374261f, 
    -0.01783364f, -0.08067476f, -0.10963029f, -0.07439772f, -0.02622325f, -0.04298329f, -0.04882445f, 0.04730445f, 
    -0.05941993f, 0.02055809f, -0.04410072f, -0.04881201f, 0.07243423f, 0.06492344f, 0.05111793f, -0.05147255f, 
    -0.10505266f, 0.02456458f, 0.00396156f, 0.02476545f, -0.08893505f, -0.04806360f, -0.00165734f, -0.08371542f, 
    0.02941999f, 0.01472933f, 0.07226559f, -0.01064265f, 0.05976006f, -0.00469652f, -0.09502073f, -0.03962815f, 
    0.02928735f, 0.34211236f, -0.12872389f, 0.05548260f, 0.12056119f, 0.11508615f, 0.07195652f, 0.08834138f, 
    0.17906682f, 0.00728730f, 0.05987683f, -0.01718043f, -0.02801633f, -0.15526296f, 0.07649276f, 0.10034771f, 
    0.07051031f, -0.03858323f, -0.18629391f, -0.03574174f, -0.17251779f, 0.09439642f, -0.34206021f, 0.06237599f, 
    -0.00653754f, -0.10513023f, 0.07169594f, 0.28455609f, 0.07911959f, 0.07310198f, 0.22373854f, 0.03309934f, 
    0.06796836f, -0.27509943f, -0.05289297f, -0.16945833f, 0.13764006f, -0.03530420f, -0.13394894f, 0.20232311f, 
    -0.14152722f, -0.02085803f, 0.00815795f, 0.48135406f, 0.06920009f, -0.02491597f, 0.11635047f, -0.05106199f, 
    -0.02173966f, 0.06518374f, 0.01693445f, -0.14302324f, 0.06655427f, 0.20431775f, -0.02394355f, 0.19753745f, 
    0.02269156f, -0.08885565f, -0.04058684f, 0.20446554f, -0.13288663f, -0.01521228f, -0.12956688f, -0.19826868f, 
    0.00516776f, 0.10850177f, -0.06999512f, 0.11091466f, 0.48290971f, 0.19240174f, 0.04717707f, -0.04743067f, 
    0.07247841f, -0.11268738f, 0.01458313f, 0.04949306f, -0.15000993f, -0.06583923f, -0.03127850f, 0.04347240f, 
    0.13731338f, 0.06280521f, 0.10490969f, -0.08013637f, -0.31374925f, -0.32987031f, -0.00096126f, -0.02424298f, 
    -0.02674468f, 0.24432822f, -0.08799604f, 0.04489534f, 0.08778507f, -0.17115191f, -0.00388932f, 0.20315005f, 
    -0.13960414f, 0.06354024f, 0.09690058f, -0.01853336f, 0.18587720f, 0.02711118f, 0.22005047f, -0.05622391f, 
    -0.00002671f, 0.01880664f, 0.07308314f, -0.09821118f, 0.22402905f, 0.08032852f, 0.08487473f, 0.08014156f, 
    -0.06216370f, -0.15550387f, 0.09995003f, 0.57601190f, 0.16405044f, 0.40076119f, -0.01750966f, 0.07402691f, 
    0.19493976f, 0.50529802f, 0.21220252f, -0.03527262f, 0.05604366f, 0.02185909f, 0.00962486f, 0.16327311f, 
    0.41267496f, -0.13768362f, 0.14167173f, -0.05560112f, -0.01695530f, 0.09125546f, -0.13718919f, 0.17612603f, 
    0.15687580f, -0.15881757f, 0.04021029f, -0.03031092f, -0.03413237f, 0.11731041f, 0.15395151f, 0.21139900f, 
    0.07271074f, 0.14770737f, 0.20937860f, -0.01792314f, -0.12746060f, 0.07371760f, -0.18426940f, 0.10919893f, 
    0.07344932f, 0.46702775f, 0.14646898f, -0.02248759f, 0.16357991f, -0.01981962f, -0.15858026f, 0.02749765f, 
    -0.11703343f, 0.05596724f, 0.00213535f, 0.06637368f, 0.08231262f, -0.02714759f, -0.23546721f, 0.33420938f, 
    0.09546565f, 0.06409451f, -0.04193357f, -0.04889199f, 0.07694548f, 0.08457066f, 0.36722043f, 0.16428337f, 
    -0.24625759f, -0.01472065f, 0.01891077f, -0.02348143f, 0.09802476f, -0.28137442f, 0.03987434f, -0.20637695f, 
    -0.09528317f, 0.01121732f, 0.08334493f, 0.38015082f, -0.08619322f, 0.22655220f, -0.10343273f, 0.13365638f, 
    0.01300680f, 0.46414053f, 0.39820024f, -0.15834281f, 0.09355239f, 0.02705216f, -0.03590200f, -0.01670785f, 
    0.02960538f, -0.09461428f, 0.03639591f, -0.09195410f, -0.05061754f, -0.08367318f, -0.04046623f, 0.13127393f, 
    -0.02606680f, 0.07796726f, 0.11378201f, -0.06645294f, 0.18489315f, 0.86394006f, 0.08302763f, -0.12586601f, 
    -0.05455252f, -0.00368663f, 0.22339533f, 0.01811242f, 0.07849585f, 0.05642213f, 0.01847196f, 0.00487728f, 
    0.66888207f, -0.09742806f, 0.08122088f, -0.24594733f, 0.00017419f, 0.10719611f, 0.14011733f, 0.08012772f, 
    0.11241681f, -0.18029501f, 0.15381493f, -0.00010905f, 0.04412912f, -0.02437947f, 0.17142978f, -0.09059884f, 
    -0.05929238f, 0.03296262f, -0.11667287f, -0.03882448f, 0.25812095f, 0.03390123f, 0.13508911f, 0.20314062f, 
    -0.02165448f, -0.16578604f, -0.29692665f, -0.02192860f, 0.06351621f, 0.43439057f, 0.05549892f, 0.19941100f, 
    -0.02446358f, -0.22890885f, -0.24147901f, -0.06298253f, -0.05467213f, -0.07328432f, -0.09338900f, -0.06903760f, 
    -0.01723908f, -0.10585299f, -0.18686216f, 0.07097251f, 0.03187497f, 0.26385367f, 0.28304183f, -0.04358099f, 
    0.03782779f, 0.04099820f, 0.03526789f, -0.01020923f, 0.27487260f, -0.12971714f, 0.20736919f, -0.12263813f, 
    -0.04640563f, -0.35619229f, 0.18550110f, -0.21314523f, 0.15461174f, 0.18453901f, 0.31786698f, -0.07702170f, 
    -0.00027049f, -0.04025640f, -0.04870886f, -0.21213064f, 0.07026479f, 0.18081799f, 0.01556803f, -0.05387259f, 
    0.03845603f, 0.03060784f, -0.08713095f, -0.07356687f, -0.02893818f, 0.08628776f, -0.47628793f, 0.17892934f, 
    0.00779510f, 0.17529842f, -0.13244978f, 0.17039774f, -0.18670233f, 0.08354577f, -0.07784271f, -0.29807004f, 
    0.02663211f, -0.14168850f, 0.02057987f, 0.07388238f, 0.08798873f, -0.15093280f, 0.01222056f, 0.38680989f, 
    0.14870693f, 0.32043150f, 0.01972325f, 0.03123063f, 0.05305217f, 0.28598648f, -0.00972601f, -0.22233318f, 
    0.13531573f, 0.17127430f, 0.13277996f, -0.10597704f, 0.14787365f, 0.05233265f, -0.11143991f, -0.08070403f, 
    0.06651549f, 0.10140426f, 0.08812958f, 0.07092945f, -0.15178367f, -0.63565058f, -0.08163714f, 0.02496178f, 
    0.09935072f, 0.06071519f, 0.02360084f, -0.12225142f, 0.26804674f, 0.17559060f, -0.04422373f, -0.01256477f, 
    -0.34579858f, 0.11064564f, 0.12755111f, 0.06080369f, -0.00486992f, 0.04904872f, -0.03800248f, -0.03722250f, 
    -0.07130896f, 0.05995467f, 0.14521354f, 0.06375799f, 0.11738083f, -0.01963087f, 0.05744463f, -0.00901131f, 
    0.09328899f, -0.24474403f, 0.14046694f, 0.03513862f, 0.08338775f, 0.07047574f, 0.16210310f, 0.13815106f, 
    0.07482181f, -0.00227574f, 0.46872899f, -0.05989911f, -0.04913437f, 0.06477456f, -0.06478820f, 0.05035079f, 
    -0.08117166f, 0.07664566f, -0.02404561f, 0.00967065f, -0.05486708f, -0.06619519f, 0.05512802f, -0.01672277f, 
    -0.02237085f, 0.00698823f, 0.03896633f, -0.02898512f, -0.04019789f, 0.04403079f, 0.02623609f, 0.06206444f, 
    0.03078761f, -0.11284073f, 0.06613239f, 0.04505017f, 0.00217908f, -0.02649454f, -0.06510574f, -0.05943405f, 
    -0.06564224f, -0.04989899f, 0.04192257f, -0.03739300f, -0.04685230f, -0.03124110f, -0.05598286f, -0.02898448f, 
    -0.02321666f, 0.04566462f, 0.00942024f, -0.09055480f, -0.06225925f, 0.00335696f, -0.07274886f, -0.06595964f, 
    0.06780402f, -0.04182969f, 0.03580069f, 0.07691806f, -0.06201681f, -0.06147337f, 0.02594428f, 0.04705664f, 
    -0.04418657f, 0.00913058f, -0.05783702f, 0.04221058f, -0.04288177f, -0.02320910f, -0.08836449f, -0.01033029f, 
    -0.05640199f, -0.06625722f, -0.09715526f, -0.01088557f, 0.04516223f, -0.06173629f, -0.02474140f, -0.00260835f, 
    -0.04886488f, -0.09133667f, -0.04158600f, 0.01273252f, -0.06774278f, 0.00042714f, -0.00901011f, -0.06981467f, 
    -0.03335251f, 0.02152043f, 0.00030437f, 0.00813762f, 0.02482865f, 0.03931446f, 0.00570258f, -0.04089558f, 
    0.05194562f, -0.01745271f, -0.09606261f, -0.00747570f, -0.01455685f, -0.10284259f, 0.03850197f, -0.07118639f, 
    -0.09507580f, 0.00926823f, 0.04004288f, 0.07486966f, 0.05065048f, 0.01643251f, 0.02305298f, -0.07203709f, 
    -0.04802548f, -0.10675228f, -0.05539158f, -0.03793544f, 0.01585682f, -0.00458658f, 0.00999915f, -0.03054660f, 
    -0.08456525f, -0.03684812f, -0.03778392f, -0.02667790f, 0.05959839f, -0.02106719f, -0.09650350f, -0.02247004f, 
    0.04573254f, 0.05356432f, -0.05818313f, -0.07095469f, -0.03493622f, -0.10812798f, 0.06172582f, -0.03422680f, 
    -0.00051799f, -0.08529369f, -0.00489556f, -0.08119233f, -0.09334612f, 0.02321377f, 0.02349614f, -0.03573409f, 
    -0.28191933f, 0.14953457f, -0.01427351f, 0.04224923f, 0.07019726f, 0.09226867f, 0.19266135f, -0.15591533f, 
    -0.12496750f, 0.02090204f, -0.56093442f, -0.00686836f, -0.14265595f, 0.17453520f, -0.33168420f, 0.05346512f, 
    -0.08368561f, -0.52636355f, 0.10004654f, 0.05661144f, -0.12285728f, -0.08423958f, 0.18717402f, -0.18202326f, 
    -0.27352232f, -0.65396404f, 0.03321714f, 0.06008669f, 0.31891471f, 0.15069382f, -0.03248839f, -0.37511191f, 
    0.23767084f, 0.08221519f, -0.06666247f, 0.35160193f, -0.29914355f, 0.00571762f, 0.37682238f, -0.34677932f, 
    0.12932055f, 0.09601911f, 0.08316331f, -0.34704980f, -0.07936884f, 0.08175118f, -0.25924739f, -0.14989890f, 
    0.07242297f, 0.08582889f, -0.09347179f, 0.11649732f, -0.16492827f, 0.34984851f, 0.05860012f, -0.15444458f, 
    0.10363211f, 0.16501673f, 0.31380022f, -0.15865831f, 0.06240369f, 0.01312557f, 0.10211247f, 0.08650585f, 
    -0.14631978f, -0.38565814f, 0.06001167f, 0.29185849f, 0.08188900f, 0.32690573f, 0.00598153f, 0.27246863f, 
    -0.09824203f, 0.11395339f, 0.09167432f, 0.04563660f, 0.06354544f, -0.03981141f, -0.25658831f, 0.02220431f, 
    -0.03914457f, -0.10907637f, -0.02877248f, 0.16343701f, 0.35732394f, -0.79418850f, 0.03141996f, 0.13649566f, 
    0.05876328f, 0.30455691f, 0.31765056f, -0.30758172f, 0.09062981f, 0.23274887f, 0.02940110f, 0.12695038f, 
    -0.07175773f, -0.35412455f, -0.12229085f, 0.07530449f, -0.05319421f, 0.04285837f, -0.18422638f, -0.05320708f, 
    0.16314778f, 0.46314368f, -0.01480004f, 0.22660653f, -0.08655418f, -0.11394832f, -0.00329906f, 0.08951831f, 
    0.01658258f, 0.30090865f, -0.00476100f, 0.02730329f, -0.18905500f, 0.02474593f, -0.16195120f, -0.32350311f, 
    0.19806291f, 0.18353592f, -0.25631511f, -0.16207074f, 0.22689667f, -0.04285116f, 0.08949133f, 0.19363181f, 
    0.01557013f, -0.06071444f, 0.03206848f, -0.05267831f, 0.07888934f, 0.02376833f, 0.26532021f, 0.08661015f, 
    -0.18302760f, 0.02568787f, -0.84630424f, -0.08395420f, -0.03159472f, 0.13836692f, 0.12621923f, -0.09029399f, 
    0.05557820f, 0.12008853f, -0.19944839f, 0.00280407f, -0.00341171f, 0.37687820f, 0.21767536f, 0.00602309f, 
    -0.27118656f, -0.60625046f, 0.01519824f, -0.01055020f, 0.16180725f, 0.04066847f, 0.04831504f, -0.02282480f, 
    0.00498662f, -0.09670831f, 0.20111161f, -0.13980465f, -0.14055036f, 0.01315240f, 0.37490514f, -0.01382869f, 
    -0.19584097f, 0.02313683f, 0.05238803f, 0.08642681f, -0.12557845f, -0.06646590f, -0.28347242f, 0.20093402f, 
    -0.19389446f, -0.32424486f, 0.10966311f, 0.01616260f, -0.06307241f, 0.03830042f, 0.00283983f, 0.03259781f, 
    -0.08989805f, 0.00687818f, 0.26668289f, -0.22889660f, -0.21344754f, 0.05946988f, 0.44002631f, 0.03182124f, 
    0.07737590f, -0.06679185f, -0.20206875f, -0.05182772f, -0.24466977f, 0.27658141f, 0.00218718f, 0.16262460f, 
    0.09732639f, 0.24216212f, -0.01146716f, -0.05097225f, 0.07627226f, 0.08724181f, -0.03137792f, 0.08495333f, 
    0.09537789f, 0.02369669f, 0.03036899f, 0.10737368f, -0.10214133f, -0.67612880f, 0.00399911f, -0.13368985f, 
    -0.20889139f, 0.07773639f, -0.16816433f, 0.06431513f, -0.12066340f, -0.06227052f, -0.00094769f, -0.06155893f, 
    -0.49616495f, -0.05122246f, -0.07883717f, 0.09346518f, 0.20300226f, 0.08400330f, 0.03185866f, 0.03042499f, 
    0.04053209f, -0.08659734f, -0.07847724f, 0.27010977f, -0.00249691f, -0.38367534f, 0.11159793f, 0.06690983f, 
    0.06302410f, 0.06469366f, 0.13016735f, -0.12828267f, -0.11429955f, -0.02423090f, 0.12553599f, -0.00213910f, 
    0.03097955f, -0.02463016f, 0.01454248f, -0.05848361f, -0.06292579f, -0.15612289f, 0.14836103f, 0.16748960f, 
    -0.01890882f, 0.05082537f, 0.07094989f, -0.07401987f, 0.06412403f, 0.02153095f, -0.03428159f, -0.09351957f, 
    -0.00039066f, 0.03677886f, 0.02774105f, 0.04245287f, -0.05974652f, -0.09088120f, 0.06658878f, -0.08400913f, 
    -0.05677327f, 0.07522533f, 0.05003077f, 0.00373549f, -0.00459277f, -0.03275333f, -0.01103741f, -0.03940503f, 
    -0.07309434f, 0.08504730f, -0.09772437f, -0.00111855f, -0.00276253f, 0.04574990f, -0.08342644f, -0.04799243f, 
    0.00266896f, 0.03238232f, -0.03625063f, -0.05994865f, -0.02386786f, 0.02260789f, -0.05852986f, 0.00223646f, 
    0.08395112f, -0.00065847f, 0.08780523f, 0.04191641f, 0.06416389f, -0.08190449f, -0.01154917f, -0.05603726f, 
    0.01560237f, -0.00941697f, 0.08313636f, -0.05904399f, -0.04008175f, -0.07409868f, -0.01689445f, -0.07570970f, 
    -0.04755392f, -0.04693269f, 0.05394280f, -0.02667784f, -0.06198092f, 0.05883499f, 0.00111435f, -0.10598659f, 
    -0.03253040f, -0.02257751f, -0.04428329f, -0.01531201f, 0.01689825f, 0.07063853f, -0.01021691f, -0.06530768f, 
    0.06400394f, 0.07570175f, -0.08048140f, -0.04545626f, -0.05518916f, -0.02611545f, 0.02742782f, -0.02021728f, 
    0.02262079f, -0.05848686f, 0.02338707f, -0.03771971f, 0.04708889f, -0.06732241f, 0.04125231f, 0.01469365f, 
    0.01878550f, -0.09215592f, 0.00977186f, -0.03009074f, -0.03604756f, 0.01873916f, -0.01312956f, -0.06011418f, 
    0.05910894f, -0.08415660f, -0.07936872f, 0.06756661f, 0.04737833f, 0.05699277f, 0.07301497f, -0.08211494f, 
    -0.09323773f, -0.01575588f, -0.04012878f, -0.02508872f, -0.05768633f, 0.04792409f, 0.06065920f, 0.05168562f, 
    -0.05459333f, 0.05719783f, -0.06455927f, -0.09631922f, 0.01080175f, -0.03749391f, -0.04504395f, 0.09610465f, 
    -0.06436432f, -0.00530055f, -0.03082659f, 0.00372959f, -0.07660941f, 0.00553940f, 0.02915638f, 0.01891595f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12265009f, 0.04789895f, 0.14802979f, 0.03025952f, 0.05763745f, -0.05827681f, 0.21916215f, -0.03975181f, 
    -0.05862203f, 0.10569467f, -0.02884871f, -0.08396948f, 0.21383652f, -0.01879789f, -0.04849459f, 0.07585777f, 
    -0.07336636f, 0.09434234f, -0.10294341f, -0.04085216f, 0.16202497f, 0.07576767f, -0.05128265f, 0.02136306f, 
    0.18062656f, 0.06541657f, 0.00690655f, 0.00220022f, -0.02909544f, 0.06464888f, -0.07442807f, 0.08792418f, 
    0.08801758f, 0.04471452f, 0.01552708f, -0.02414807f, 0.03582919f, 0.15595409f, -0.07178353f, 0.17482542f, 
    0.09233380f, 0.06950883f, -0.00015875f, 0.12860145f, -0.16373390f, 0.04913474f, -0.18170169f, -0.09055748f, 
    -0.11457501f, 0.08651163f, -0.06465616f, -0.09703859f, -0.07036371f, -0.10593276f, -0.09268805f, 0.00534440f, 
    0.03688003f, 0.30264083f, -0.02860584f, 0.19487378f, 0.01693706f, -0.21073006f, 0.11919817f, 0.02752310f, 
    -0.01054783f, 0.19855480f, 0.13553450f, 0.14569011f, 0.07053256f, -0.02278001f, 0.10970552f, 0.00884975f, 
    0.07540432f, 0.24070886f, -0.01844854f, 0.21596232f, 0.05421072f, 0.10443319f, -0.19728892f, 0.01434457f, 
    0.12856244f, 0.18014939f, 0.04860069f, 0.03590110f, 0.09497152f, -0.09860979f, -0.05310130f, 0.19155298f, 
    0.00000924f, -0.07081971f, 0.10650194f, 0.17713119f, 0.01610806f, 0.07846590f, -0.00114756f, -0.11212435f, 
    0.04332185f, 0.07873976f, 0.15391049f, 0.14822686f, -0.00461880f, 0.26942185f, -0.04155024f, -0.03087614f, 
    0.20429069f, -0.05119555f, 0.26509604f, 0.09615058f, 0.01711169f, 0.09476916f, 0.11455792f, 0.19558525f, 
    0.09599029f, -0.01933988f, 0.07665111f, -0.02291198f, -0.18719895f, 0.03975484f, 0.13192284f, -0.03170146f, 
    -0.08430579f, 0.28791288f, 0.11379056f, 0.04396395f, -0.04532965f, 0.02047482f, 0.12682039f, -0.10107823f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.46167812f, 0.24571547f, -0.09050014f, -0.59204346f, 0.08038477f, -0.20545594f, -0.00597367f, -0.17231995f, 
    -0.05629707f, -0.06660616f, -0.28280586f, 0.05162341f, -0.75346881f, -0.49136457f, 0.05558877f, -0.30402952f, 
    0.02396206f, 0.05683456f, 0.08261611f, 0.07164087f, -0.18362990f, 0.09060805f, 0.10489202f, -0.03638592f, 
    -0.15615253f, -0.32305866f, -0.15081002f, -0.01428128f, -0.11991417f, -0.05123072f, -0.08501960f, -0.02240004f, 
    0.06315294f, 0.00669413f, 0.09510493f, -0.27239275f, 0.01786588f, -0.52312386f, 0.14549689f, 0.06227932f, 
    -0.81663710f, 0.03207270f, -0.07819047f, -0.01075915f, 0.22997804f, 0.12733699f, -0.07892425f, 0.02959454f, 
    -0.09675752f, -0.01064565f, -0.02311857f, 0.02538467f, 0.24306811f, -0.01482696f, -0.19115421f, -0.16386777f, 
    0.03472399f, 0.14125165f, -0.00075485f, -0.47139975f, -0.14146569f, 0.23281932f, -0.12714133f, -0.07131957f, 
    0.02917660f, -0.54404145f, -0.32314655f, -0.01554436f, 0.09175003f, -0.00712789f, -0.24850857f, 0.09626926f, 
    -0.53145909f, -0.51624203f, 0.06124162f, 0.16665025f, -0.00052113f, 0.25796658f, 0.21631256f, 0.02035372f, 
    -0.01049670f, -0.20718591f, 0.05510589f, -0.03194080f, -0.09941639f, 0.04413407f, -0.06390001f, -0.45633060f, 
    0.15381163f, 0.02190422f, -0.06081841f, 0.08824013f, 0.00891119f, -0.30181992f, -0.02447816f, -0.06978888f, 
    0.07668106f, -0.24985234f, 0.12236040f, -0.15954930f, 0.18132949f, 0.01038104f, -0.02481215f, -0.01545187f, 
    -0.29819468f, -0.02269402f, 0.04299017f, 0.18192376f, 0.06000726f, -0.03789019f, 0.01147483f, -0.34979343f, 
    0.06756510f, 0.17820351f, -0.09587710f, -0.03514480f, -0.26582381f, 0.01556836f, -0.53157282f, -0.02495635f, 
    -0.01217133f, -0.49123362f, 0.16590659f, -0.19844538f, -0.06279493f, -0.10374606f, -0.41021779f, -0.03872629f, 
    -0.12476008f, 0.11991744f, -0.06393640f, -0.27305958f, -0.06010592f, -0.27845389f, -0.01632807f, -0.60251015f, 
    -0.02573117f, 0.02600083f, -0.70039189f, 0.05471954f, 0.23785782f, 0.23457251f, -0.14990635f, -0.02776986f, 
    -0.07102216f, -0.00714134f, -0.08776565f, -0.04691944f, 0.00099110f, 0.19582719f, -0.19237541f, 0.22139871f, 
    0.07657427f, -0.22941305f, 0.15143299f, 0.00011037f, 0.04699801f, -0.66372687f, -0.13651273f, 0.11933445f, 
    -0.14033104f, 0.06402094f, 0.04154090f, -0.07110465f, 0.21306427f, -0.11401150f, 0.15686588f, 0.00261250f, 
    0.29377300f, -0.23387174f, -0.08215462f, 0.15356420f, 0.21839485f, -0.62134725f, 0.06760482f, 0.06338193f, 
    -0.05986585f, -0.13173811f, 0.28131157f, 0.05308245f, -0.24752459f, -0.06661863f, 0.08646353f, 0.40404829f, 
    0.06567271f, 0.14786310f, 0.06366123f, 0.11881275f, 0.08914277f, -0.56262368f, 0.11627615f, 0.12645383f, 
    0.00292234f, -0.00642157f, 0.16287144f, 0.04141054f, -0.03022704f, 0.05636433f, -0.15364946f, 0.04435988f, 
    0.09451585f, 0.27114639f, -0.06474314f, -0.01963400f, 0.06095626f, 0.23182295f, -0.81302768f, 0.06920806f, 
    -0.17481090f, 0.03827689f, -0.06754822f, 0.03833568f, 0.06565155f, 0.07747468f, 0.02377889f, 0.02693579f, 
    -0.06106186f, -0.00505571f, -0.00466437f, 0.14389485f, 0.33639601f, -0.41204929f, -0.00228201f, -0.09299070f, 
    0.00466607f, 0.07131222f, -0.00693759f, 0.10424855f, 0.22152384f, 0.05708000f, 0.03094291f, -0.01508707f, 
    -0.16922092f, -0.05988518f, 0.08626829f, -0.00870095f, -0.04371319f, 0.14783047f, 0.06314863f, 0.00837987f, 
    0.15368910f, 0.08964053f, 0.04113308f, 0.02396911f, 0.04610774f, 0.39174488f, -0.09362938f, -1.08200586f, 
    -0.00082786f, 0.09970477f, -0.00871281f, -0.13430792f, 0.07246648f, 0.03456891f, -0.18752503f, -0.02099706f, 
    0.16175669f, -0.47974160f, 0.07935934f, 0.19545728f, -0.08543972f, 0.11820105f, -0.02873660f, -0.10267638f, 
    -0.01548479f, -0.02855175f, 0.32000515f, 0.02050338f, -0.30979678f, -0.52604872f, -0.04893990f, 0.03046762f, 
    -0.08938816f, -0.49047473f, 0.11878388f, 0.08513062f, -0.14135489f, 0.06957906f, -0.73200059f, -0.44184238f, 
    0.08481753f, 0.04247066f, -0.19131516f, -0.00689578f, -0.06301302f, -0.12896591f, -0.24178356f, 0.19883209f, 
    -0.75598532f, 0.09062693f, -0.18009563f, -0.22569689f, 0.12915160f, -0.26217383f, -0.36671069f, 0.08336061f, 
    -0.51515895f, 0.08464107f, 0.05409558f, 0.03569283f, -0.16700952f, 0.02198554f, 0.01929966f, 0.05386313f, 
    0.00823995f, 0.18102877f, 0.10382359f, 0.01974686f, -0.26903257f, -0.12304014f, -0.13020243f, -0.08966952f, 
    0.02512426f, -0.04701758f, -0.02004898f, 0.01787277f, 0.03257025f, -0.27950662f, -0.37936366f, 0.06589241f, 
    0.01845239f, 0.05415233f, 0.13856351f, 0.05131719f, 0.05827243f, -0.06602008f, -0.08541516f, -0.38055545f, 
    0.19000280f, 0.10451259f, -0.01990354f, 0.17258701f, 0.08008731f, 0.30245829f, -0.38394892f, -0.27942362f, 
    0.06346390f, 0.15027186f, 0.03619288f, 0.01229664f, 0.14494476f, -0.02287953f, -0.00668936f, 0.03658149f, 
    0.12469836f, 0.05956777f, -0.00931701f, 0.24022989f, -0.67023277f, 0.04641412f, 0.07365333f, 0.02691729f, 
    0.04880467f, 0.22130796f, -0.09752063f, -0.28579894f, -0.51563764f, 0.03899722f, 0.04660182f, 0.05991317f, 
    0.05039156f, -0.08490320f, -0.01659107f, -0.20146444f, -0.01300268f, -0.49857491f, 0.16519207f, 0.12068027f, 
    0.12950511f, -0.66268009f, 0.08567233f, -0.09601658f, 0.22799025f, -0.34171095f, 0.11592088f, -0.15229109f, 
    0.06965453f, 0.09228168f, 0.11678549f, -0.04894200f, 0.08243862f, -0.04096918f, -0.16673870f, -0.05019085f, 
    -0.03785159f, 0.01822207f, 0.00787654f, 0.12661661f, 0.35968697f, 0.07947940f, -0.07288568f, 0.21132524f, 
    -0.03434401f, 0.40703732f, 0.19707924f, -0.08106534f, -1.44518626f, -0.33324966f, -0.01344487f, -0.15010171f, 
    0.08320884f, 0.01505542f, -0.05052987f, 0.03343244f, -0.21319297f, 0.07607089f, 0.09569548f, -0.00658640f, 
    0.11522735f, -0.01633759f, -0.47301942f, 0.05347629f, -0.45948538f, 0.16754647f, -0.09971695f, 0.05737068f, 
    -0.01850043f, 0.46003568f, -0.07138091f, 0.03817378f, 0.71070254f, 0.05338543f, 0.16037323f, 0.12646279f, 
    0.08937737f, 0.07595910f, -0.06274214f, 0.07763734f, 0.02738833f, -0.22683463f, 0.19751038f, -0.00763641f, 
    -0.08929478f, 0.14261523f, 0.06285840f, -0.05644466f, 0.14042158f, 0.01844217f, -0.32438013f, -0.48741412f, 
    -0.60884601f, 0.12722115f, -0.01104625f, 0.06177880f, -0.33901283f, 0.19689636f, -0.34586334f, 0.10749938f, 
    0.01242375f, -0.05197830f, -0.18436028f, -0.78586268f, -0.05670892f, 0.02797180f, -0.36083999f, -0.07881334f, 
    -0.07990697f, 0.26026371f, 0.03078380f, -0.12525658f, -0.43605357f, 0.05268663f, 0.07298795f, -0.17386310f, 
    0.15433516f, 0.13652085f, 0.03572726f, -0.05790406f, 0.10473114f, 0.02320836f, 0.06762257f, -0.00545552f, 
    0.16220886f, -0.03862160f, -0.00455369f, -0.01021278f, -0.05668793f, -0.03532548f, 0.02369190f, 0.05776156f, 
    -0.00561700f, 0.03089300f, 0.13322218f, -0.00657059f, 0.03703937f, -0.54742521f, -0.05042721f, -0.02722145f, 
    0.14886467f, -0.00699276f, 0.03226272f, -0.03697658f, -0.09147404f, -0.35660720f, 0.15089743f, -0.12195522f, 
    -0.86928153f, 0.07859448f, -0.21053624f, 0.01662952f, 0.14399229f, 0.02157927f, -0.16188990f, 0.23947653f, 
    0.03156047f, 0.10063562f, 0.05865495f, -0.10557764f, -0.03990677f, -0.61388314f, 0.08802570f, 0.04192786f, 
    0.10193851f, -0.02919493f, -0.50140899f, 0.05561037f, 0.15766649f, 0.19731452f, 0.13319577f, 0.20263994f, 
    -0.01990731f, -0.51125067f, 0.03167580f, 0.01288848f, 0.30867466f, -0.18057810f, 0.14773086f, -0.06852285f, 
    -0.01482192f, 0.21080606f, 0.29093489f, 0.04589167f, 0.00886358f, -0.58710849f, 0.14226796f, 0.07754663f, 
    -0.06398974f, -0.60743815f, 0.22502699f, -0.01100021f, 0.18706268f, 0.07659734f, -0.30951911f, -0.07810260f, 
    0.18472366f, -0.36638787f, -0.07964160f, 0.15833914f, -0.44901741f, -0.09031714f, 0.16021712f, 0.08836165f, 
    -0.63291305f, 0.12004427f, -0.07404733f, 0.11158359f, -0.18247582f, 0.09224068f, 0.14129451f, 0.03827964f, 
    0.00512432f, -0.01201627f, -0.91177136f, -0.04683847f, 0.11210324f, 0.00330125f, 0.34530288f, 0.07508976f, 
    -0.08140153f, 0.09071791f, -0.09504908f, -0.53064102f, -0.46442541f, 0.18296464f, 0.01212341f, -0.13288853f, 
    0.07773792f, -0.16402762f, 0.02576181f, -0.09031750f, 0.13578589f, -0.14165974f, 0.06239356f, 0.16742951f, 
    0.06031615f, -0.05020932f, -0.02313898f, -0.20915838f, 0.18576801f, -0.14011687f, 0.10329302f, 0.08897878f, 
    0.06796400f, 0.03339291f, 0.02820448f, -0.11320874f, -0.35142511f, 0.00751721f, 0.06618911f, -0.07221796f, 
    -0.03860187f, 0.05345666f, 0.12003335f, -0.26168960f, -0.28947458f, 0.10870165f, -0.01278498f, -0.06086356f, 
    0.05707486f, -0.32007200f, 0.09761222f, 0.02233829f, 0.01549280f, -0.06603006f, 0.08798419f, 0.00297678f, 
    -0.56698155f, -0.06704540f, -0.03116505f, 0.04554128f, 0.04873385f, -0.11845449f, -0.15042938f, -0.11552162f, 
    -0.25612074f, -0.52639914f, -0.15842739f, -0.01296631f, 0.02579236f, 0.06576026f, -0.09212437f, 0.20546973f, 
    -0.05737293f, -0.10351608f, -0.03031128f, 0.03278555f, -0.00889505f, -0.06242464f, 0.20523077f, 0.00242197f, 
    -0.24427171f, -0.01702648f, -0.02567394f, -0.26754808f, -0.12801351f, 0.07081409f, 0.03846186f, -0.45601717f, 
    -0.01910286f, -0.40039533f, -0.11386328f, -0.00264799f, -0.39731508f, -0.46706930f, -0.08185592f, 0.17309496f, 
    -0.02215659f, 0.06355599f, 0.05348384f, 0.00453669f, -0.03838642f, -0.05933575f, -0.06430309f, 0.06959435f, 
    0.05795924f, 0.11987548f, 0.24832486f, -0.08078352f, 0.23296267f, -0.82656986f, -0.35499221f, 0.19607472f, 
    -0.07621793f, -0.34866858f, 0.08507285f, -0.34906486f, -0.77248752f, -0.05580803f, -0.14304654f, 0.02534285f, 
    -0.00350786f, 0.15418676f, 0.00840097f, 0.00718146f, -0.07730918f, -0.01869149f, -0.18531941f, -0.02684634f, 
    -0.04652009f, -0.01455707f, -0.23458318f, -0.08258940f, 0.03185084f, -0.05700810f, 0.30298820f, -0.09091140f, 
    -0.08301452f, 0.11367015f, -0.07734505f, -0.00849674f, 0.08424261f, -0.06239089f, 0.20531619f, 0.14605871f, 
    -0.08848040f, 0.17519727f, -0.02873823f, -0.02233485f, 0.13208957f, -0.03386085f, -0.05010007f, -0.04730507f, 
    0.05209281f, -0.03107059f, -0.03876521f, -0.01406164f, -0.05071188f, -0.14026013f, -0.14928171f, -0.03499527f, 
    0.14562821f, 0.13070768f, -0.08678284f, 0.11940166f, -0.28749812f, -0.01693832f, 0.05662419f, 0.19202599f, 
    -0.06422711f, -0.08480195f, -0.05092098f, 0.12572819f, 0.07301728f, 0.05181513f, -0.08138362f, -0.07172261f, 
    -0.11691457f, -0.36571956f, 0.22529332f, -0.03697856f, 0.07619173f, -0.02648969f, 0.06181708f, -0.08772413f, 
    0.09399518f, -0.02161459f, 0.11944714f, 0.07716984f, -0.08831739f, 0.09340604f, -0.03197617f, 0.05755245f, 
    -0.12401868f, -0.42515305f, 0.09061182f, -0.03071565f, 0.14389654f, -0.09844946f, 0.00064018f, -0.20299260f, 
    -0.05732175f, 0.07254328f, 0.09328167f, 0.06337807f, 0.03085072f, 0.01714987f, -0.25122666f, -0.06842346f, 
    0.17127916f, -0.34345052f, 0.25079596f, 0.29297540f, 0.00884311f, -0.11456366f, -0.14615603f, -0.15866031f, 
    -0.03797561f, -0.18718079f, 0.44399866f, 0.06705251f, 0.09241372f, 0.23110904f, 0.04120395f, -0.43023705f, 
    -0.10149844f, -0.44199407f, -0.14724211f, 0.01098185f, -0.21098928f, 0.18311462f, -0.27719346f, -0.43081787f, 
    -0.86269951f, 0.14519365f, 0.00769402f, 0.02273885f, 0.12888299f, 0.19953965f, 0.28757823f, -0.52221286f, 
    -0.36817062f, 0.04100841f, -0.44472650f, -0.34913921f, -0.72897387f, -0.14370939f, -0.26849857f, -0.40228313f, 
    -0.16234046f, -0.55344701f, -0.08451927f, -0.39316037f, -0.19120991f, 0.21210645f, -0.31118315f, 0.00623755f, 
    -0.13131230f, 0.13404836f, 0.15599923f, -0.03063708f, -0.14635156f, 0.03202030f, 0.10064211f, -0.17163023f, 
    0.09919395f, -1.01169384f, -0.03854703f, 0.04855796f, 0.09886357f, -0.07108506f, 0.10078418f, -0.38333187f, 
    -0.02012699f, 0.09420085f, -0.14474632f, 0.21048103f, -0.99450523f, 0.01568972f, 0.09279685f, -0.04723009f, 
    0.23824811f, -0.54755896f, 0.04685711f, 0.19240057f, 0.06632877f, 0.03569720f, 0.06666737f, -0.09826856f, 
    -0.56879711f, 0.06953084f, -0.06164645f, -0.15661252f, 0.20861039f, 0.04039044f, 0.06506502f, -0.07351561f, 
    0.08061764f, 0.00856460f, 0.10384613f, -0.12045988f, -0.09908146f, 0.14763527f, -0.02499700f, 0.00840492f, 
    0.04975370f, 0.26843792f, -1.00725651f, -0.78756928f, -0.20826654f, 0.11306857f, 0.05289277f, -0.04001923f, 
    -0.00315684f, -0.08750807f, -0.03537360f, -0.52249944f, 0.01187461f, -0.55955231f, 0.06067659f, 0.15816486f, 
    0.23713174f, -0.07032004f, 0.00195503f, 0.04094599f, -0.35618475f, -0.22392331f, 0.12264250f, 0.00417915f, 
    -0.06705190f, 0.11752160f, -0.03727393f, 0.20624486f, -0.07255925f, -0.22034818f, -0.06488343f, 0.01105455f, 
    -0.05826025f, -0.55209547f, -0.08761348f, 0.19065230f, 0.04821071f, -0.56062669f, -0.22737908f, 0.33720392f, 
    -0.01459512f, -0.12965901f, 0.04763912f, 0.05487427f, -0.38555720f, 0.08184075f, 0.21408834f, -0.14394286f, 
    -0.02597201f, 0.20104468f, 0.02436666f, 0.06630999f, 0.15937409f, -0.11775509f, 0.11098047f, -0.26673076f, 
    -0.33393145f, 0.05418130f, 0.01694786f, -0.06561153f, 0.00892978f, 0.31900340f, 0.33182970f, -0.42060220f, 
    0.34173554f, 0.21102847f, 0.10585306f, 0.36060187f, 0.16490372f, 0.11706093f, -0.15908659f, -0.25911692f, 
    0.08332761f, -0.14473638f, 0.04266571f, -0.59987903f, 0.10455744f, 0.22721745f, 0.01324080f, 0.06114137f, 
    -0.01905636f, -0.07334663f, 0.01901455f, -0.08500904f, 0.01390180f, 0.03031134f, 0.10924269f, -0.19129552f, 
    -0.08321099f, 0.10136585f, -0.06022017f, 0.00145782f, 0.00356973f, 0.25066167f, 0.02591734f, -0.29835978f, 
    -0.05086548f, 0.20412499f, -0.11308679f, 0.16977742f, -0.45159161f, -0.00127732f, -0.05358500f, -0.05462387f, 
    -0.26358265f, -0.21256058f, -0.04139398f, -0.06469152f, -0.23948516f, -0.26181388f, 0.41379115f, 0.31398144f, 
    -0.33348241f, -0.81418818f, 0.00645999f, -0.36607677f, -0.09630745f, 0.00369575f, -0.01643941f, -0.39568147f, 
    0.09082625f, -0.08836088f, -0.11779279f, -0.23248830f, 0.03023247f, 0.09203778f, 0.05315355f, -0.08024216f, 
    -0.05447730f, -0.12424227f, 0.09059086f, -0.09235984f, -0.25784782f, 0.04546693f, -0.00770512f, 0.02007975f, 
    -0.23695602f, -0.07286286f, -0.56506217f, -0.72180063f, -0.06322493f, 0.14455794f, -0.12497387f, 0.10981525f, 
    -0.16575882f, 0.43274048f, 0.03357203f, 0.07580408f, 0.06194076f, -0.16582383f, -0.10687566f, -0.09998064f, 
    -0.06654324f, -0.23537372f, -0.25234273f, 0.07366014f, 0.05622155f, 0.01540923f, 0.10925404f, -0.03854549f, 
    -0.19204001f, -0.79877549f, 0.02537866f, -0.34932193f, 0.25757477f, -0.84110069f, 0.28350499f, -0.11304540f, 
    0.00102159f, 0.00741463f, -0.66732627f, 0.04328622f, 0.09762136f, -0.21573181f, -0.43641937f, 0.20024163f, 
    -0.06570420f, 0.03776372f, -0.31873262f, 0.05603856f, 0.12390485f, -0.11535253f, -0.28261790f, -0.51153666f, 
    0.05634617f, 0.18311836f, -0.31675893f, -0.06467792f, -0.08693049f, -0.06446058f, -0.22019891f, -0.63708436f, 
    0.21252683f, 0.12774892f, 0.38634580f, -0.25445482f, -0.40270856f, 0.12875241f, -0.42863148f, -0.80351824f, 
    0.04112817f, -0.58134753f, 0.03751179f, -0.87959671f, -0.13966495f, -0.07231250f, -0.16333142f, 0.00945651f, 
    -0.04387776f, -0.69677663f, -0.12250639f, -0.09770320f, -0.29488084f, -0.01672645f, -0.63192618f, -0.19231860f, 
    0.11062389f, 0.05841368f, 0.00904866f, 0.19861081f, 0.23948853f, -0.31689563f, -0.16618492f, 0.19106987f, 
    0.02628789f, 0.14996634f, 0.18592665f, 0.04720571f, -0.18413624f, 0.03160409f, 0.08978114f, -0.05972068f, 
    -0.30323109f, -0.28871226f, -0.00444049f, -0.03549413f, -0.39491978f, -1.02044344f, -0.13156609f, -0.13517529f, 
    -0.58827776f, -0.03361580f, 0.07240500f, 0.22207512f, -0.22007245f, 0.07555594f, 0.07407105f, 0.22113429f, 
    -0.34104833f, 0.02444711f, 0.08539962f, 0.15559410f, -0.39784944f, 0.02277033f, -0.02298726f, -0.03149892f, 
    0.00488726f, -0.40083787f, 0.15244329f, 0.25265035f, -0.87307435f, 0.08481567f, -0.01778112f, -0.05710766f, 
    0.14344937f, 0.05621020f, 0.18887222f, -0.07167336f, -0.06755190f, 0.35922661f, -0.02096311f, 0.16258775f, 
    -0.13151029f, -0.11236189f, 0.04730687f, -0.01067210f, -0.27895975f, -0.16479489f, 0.16718687f, -0.04641661f, 
    0.00592086f, 0.16622578f, -0.01931322f, 0.00494650f, -0.02194192f, 0.33340019f, 0.13876750f, -0.03162977f, 
    0.18842269f, -0.32024869f, 0.01142074f, 0.05603802f, -0.44916001f, 0.13698566f, 0.32538152f, -0.15577196f, 
    0.05954048f, 0.22217405f, -0.03321877f, 0.04685970f, 0.30842730f, 0.02534463f, 0.22751820f, -0.48447856f, 
    -0.00616436f, 0.11140638f, -0.36211646f, -0.11444850f, 0.25567415f, 0.12227850f, 0.07950360f, -0.06598122f, 
    -0.46772793f, -0.18003304f, -0.16934668f, -0.05600162f, -0.06618179f, 0.33553228f, -0.20976608f, -0.03245269f, 
    0.08782833f, -0.58383679f, -0.10522277f, 0.02652499f, -0.38722315f, 0.09148754f, -0.47733688f, 0.16036433f, 
    -0.01023202f, -0.13741374f, 0.03053542f, 0.21226045f, -0.40097746f, 0.26655334f, -0.35225287f, 0.02953039f, 
    -0.10223391f, 0.25075930f, -0.22508253f, -0.04799715f, -0.67082191f, 0.02562199f, -0.07844398f, 0.13347021f, 
    0.13294788f, 0.03256072f, 0.01430765f, -0.13781933f, -0.46526155f, -0.24930048f, 0.03312027f, -0.44854045f, 
    0.06289952f, -0.28676635f, -0.19805287f, -0.69262266f, 0.02249271f, -0.08788120f, 0.06418750f, 0.09944861f, 
    0.08631980f, -0.38298571f, 0.01260352f, 0.25478306f, -0.52447116f, -0.44270107f, 0.09625364f, -0.03866163f, 
    -0.04582473f, -0.10904944f, 0.09412730f, -0.23465398f, 0.09542362f, -0.00868591f, -0.05689996f, -0.21142454f, 
    0.04719165f, -0.04976872f, 0.21933803f, -0.23453538f, -0.96433681f, 0.19500886f, -0.07072556f, -0.05362012f, 
    -0.00057415f, 0.07169756f, -0.10877442f, -0.15857565f, -0.59101778f, 0.11291666f, 0.01483550f, 0.04792622f, 
    -0.04091683f, -0.03162742f, 0.03321483f, 0.09630376f, 0.04177152f, -0.16096032f, 0.22258119f, 0.09448150f, 
    -0.04942461f, -0.35791266f, 0.24592693f, -0.02117306f, -0.25980163f, 0.20267071f, 0.07404128f, -0.13855021f, 
    -0.03968394f, 0.01296886f, 0.26119503f, 0.04189812f, -0.06292307f, -0.33712652f, 0.19122879f, -0.01455293f, 
    -0.08202722f, -0.33817524f, -0.14769135f, 0.04601309f, -0.35540804f, -0.04292342f, -0.52698821f, 0.16270636f, 
    0.03604507f, 0.33098322f, 0.06895124f, -0.05614850f, -0.31173614f, -0.12132498f, 0.07294134f, 0.19123080f, 
    0.06974094f, 0.14323057f, 0.20912722f, 0.03164110f, 0.11282992f, -0.33320314f, -0.05399614f, 0.34085590f, 
    0.09051638f, -0.02059066f, -0.25623873f, -0.07134405f, -0.51315290f, -0.22523244f, -0.36873093f, 0.02901399f, 
    -0.08262865f, 0.18784370f, 0.20123908f, 0.27506173f, -0.01949384f, 0.08808769f, -0.34574404f, -0.43569180f, 
    -0.57524312f, 0.04201370f, -0.03854144f, -0.00602411f, 0.00416472f, -0.29638499f, -0.48219150f, -0.04254682f, 
    -0.02389446f, -0.11160888f, -0.38035733f, 0.07587669f, -0.44233260f, 0.03542910f, -0.13689061f, 0.27495408f, 
    -0.10752035f, 0.11997144f, 0.01650389f, -0.00804134f, 0.08243169f, -0.50291800f, -0.57407868f, -0.18208475f, 
    0.06778577f, 0.11212631f, 0.15671755f, -0.65514296f, -0.11830723f, -0.10321702f, 0.21779448f, -0.26139200f, 
    0.14024623f, 0.25776851f, 0.07405248f, -0.03429822f, 0.35638642f, -0.38569376f, -0.40494445f, 0.18592393f, 
    0.09026727f, 0.14474650f, 0.00725499f, -0.05373182f, 0.10578796f, 0.02247084f, 0.03677233f, 0.06071224f, 
    -0.20719960f, -0.06921867f, -0.43714389f, -0.19664422f, 0.02412917f, -0.18358232f, 0.00133522f, -0.03924280f, 
    -0.00570864f, -0.03544825f, -0.18508354f, 0.07304377f, -0.28632841f, -0.26180109f, -0.00287051f, 0.06972543f, 
    -0.06763262f, -0.00097852f, -0.01081421f, -0.47791904f, -0.03247063f, 0.03889960f, -0.09487861f, -0.25184697f, 
    -0.02358681f, -0.13632679f, -0.52422643f, -0.09472036f, -0.35853359f, -0.28963333f, 0.07733005f, -0.11777292f, 
    -0.02129177f, 0.03032725f, -0.67427135f, -0.41621450f, -0.03665805f, 0.21553737f, 0.06121725f, -0.01744630f, 
    0.07099021f, -0.37794936f, 0.03921470f, 0.00335862f, -0.29101324f, 0.07252889f, -0.16624156f, 0.19928500f, 
    0.04583552f, 0.06360178f, 0.04463070f, 0.04626276f, 0.03394820f, 0.02294593f, -0.04832656f, 0.09984880f, 
    -0.03635010f, 0.08366103f, -0.16199000f, -0.03028065f, 0.05178420f, 0.08894786f, 0.01149134f, -0.75728154f, 
    0.00821523f, 0.19038612f, -0.04848665f, -0.06114369f, 0.11285777f, -0.16634311f, -0.34152558f, -0.40460300f, 
    -0.15376918f, 0.16549507f, -0.53852040f, 0.23396121f, -0.31614783f, 0.04107746f, 0.51822567f, 0.17349337f, 
    0.15179592f, 0.27255058f, -0.00294465f, -0.15328681f, 0.14363550f, -0.04844406f, 0.14994170f, 0.02703635f, 
    0.03292101f, -0.31856450f, 0.13504624f, 0.03372220f, -0.15755679f, -0.10082192f, -0.10245447f, -0.67872429f, 
    0.12104958f, -0.31575981f, -0.06968399f, 0.02788421f, -0.07799981f, -0.16727877f, 0.12951066f, -0.15809131f, 
    -0.06397975f, -0.01187088f, -0.05640531f, -0.65289837f, -0.00045168f, -0.05428002f, -0.00358966f, -0.72172767f, 
    -0.21679209f, -0.00766849f, -0.06397296f, -0.17625055f, 0.30648005f, 0.28688961f, 0.16799384f, 0.10781480f, 
    0.23365745f, -0.07878351f, -0.07595073f, 0.00319161f, 0.06461411f, 0.02658962f, 0.03119272f, 0.06988696f, 
    -0.25057882f, 0.02479478f, -0.21299486f, -0.38316467f, -0.37470293f, 0.06792056f, 0.06991661f, -0.08594009f, 
    -0.00300487f, 0.14632213f, 0.02437349f, -0.09478916f, -0.89617026f, 0.06656301f, 0.07807754f, 0.01086693f, 
    0.08138848f, -0.12298747f, -0.22223707f, 0.20025629f, -0.01399295f, 0.16798310f, -0.46056265f, -0.16106257f, 
    0.11792272f, 0.00404831f, -0.23823775f, -0.01816961f, 0.13932422f, -0.35433900f, 0.12762137f, 0.21648940f, 
    0.03316510f, 0.01841559f, -0.19135153f, 0.11325292f, 0.07156170f, 0.15137959f, 0.08200061f, -0.08782130f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.11737900f, -0.00258448f, -0.04761536f, 0.09824639f, -0.18183573f, 0.10508004f, -0.05151688f, -0.10437500f, 
    0.15182424f, 0.13454503f, 0.06156344f, -0.06743062f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
