#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.17695892f, -0.69101387f, 0.33212367f, 0.45227525f, 0.23685057f, -0.03056731f, -0.42365679f, 0.51274699f, 
    0.10131773f, -0.59957707f, -0.50928867f, -0.99853313f, 0.46772042f, 0.16460469f, -0.04819640f, 0.56575137f, 
    0.16810878f, 0.61421436f, 0.48175266f, 0.87514704f, 0.72598064f, -0.50902665f, -0.61760741f, 0.45691982f, 
    -0.63040376f, -0.34655917f, -0.43663836f, 0.27490717f, 0.28299242f, -0.20304026f, 0.80869716f, 0.49731156f, 
    0.38020229f, 0.08506379f, 0.96441007f, -0.89784521f, 0.64682257f, 0.18709590f, -0.53745103f, 0.07548247f, 
    0.34143594f, -0.07394429f, -0.46635845f, 0.39220592f, 0.82768291f, -0.04873879f, -0.77691203f, 0.61041379f, 
    -0.31386310f, -0.63696837f, -0.06102887f, 0.38868248f, 0.80501199f, -0.12383758f, -0.96692401f, -1.00467718f, 
    -0.06941404f, 1.18827343f, 0.90777129f, -0.52435887f, -0.08892444f, -0.48552236f, -0.64625823f, -0.41563159f, 
    -0.27478364f, -0.29963955f, -0.99393195f, -0.50384122f, -0.46688831f, -0.12427601f, -0.72287494f, -0.61548638f, 
    0.11226254f, -0.51463860f, -0.46437046f, -0.47861847f, -0.62748975f, -0.70244169f, 0.41952059f, 0.11213183f, 
    0.56987959f, 0.33107847f, 0.52760375f, 0.24302290f, -0.46350104f, 0.30433157f, 0.21444002f, 0.79276621f, 
    -0.02206721f, -0.49854103f, 0.15916871f, 1.30516183f, -0.29603305f, -0.54757786f, -0.28306472f, -0.43474033f, 
    0.09869391f, 0.59007883f, -0.14742719f, -1.01054406f, -0.11166105f, 1.00148833f, -0.83792287f, -0.65478218f, 
    -0.81650442f, -0.33102903f, 0.55940169f, -0.34975755f, -0.50877357f, -0.17062907f, 0.53543800f, -0.31597540f, 
    -0.17062877f, -0.51011014f, -0.66682613f, 0.30101261f, 0.90078676f, 0.24690524f, -1.31995988f, 0.03794597f, 
    0.46512070f, -0.62182879f, -0.29281840f, -0.40258360f, 0.00602336f, -0.30254126f, 0.72050464f, 0.36039129f, 
    0.19847184f, -0.81218410f, 0.43622538f, -0.24228160f, 0.32996151f, -0.45314440f, 0.02466121f, -1.07261539f, 
    0.11794671f, -0.47558662f, 0.52083129f, 0.84384722f, -0.20547751f, 0.27288550f, -0.08329320f, 0.39143172f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02716647f, 0.23924138f, 0.08312956f, 0.09732009f, -0.06689705f, 0.10165395f, 0.19606718f, 0.09508516f, 
    0.30181259f, 0.01450112f, 0.14608163f, -0.37627652f, 0.48629487f, 0.38808590f, 0.08960485f, 0.24368802f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03264742f, -0.05548217f, 0.03596798f, -0.03773911f, 0.04568774f, 0.03369625f, 0.01900922f, 0.01643407f, 
    0.04477828f, -0.01313932f, -0.03018724f, -0.02677691f, 0.03250531f, -0.01161638f, -0.01982677f, -0.00593442f, 
    0.01579707f, 0.00183796f, 0.02397365f, 0.00119666f, 0.03480882f, -0.03006588f, -0.02952912f, -0.01535829f, 
    -0.04160554f, 0.01842683f, -0.04017873f, -0.03465569f, -0.02825928f, 0.00554181f, -0.03285122f, 0.01058216f, 
    0.02111826f, -0.00188637f, 0.01144044f, -0.03876161f, -0.03546192f, 0.05915072f, 0.00766151f, -0.04927652f, 
    -0.03611973f, 0.01322701f, 0.02106363f, -0.02391234f, -0.02621870f, -0.02810231f, 0.00500917f, 0.01867451f, 
    0.00801584f, 0.03037676f, -0.01078770f, 0.03213949f, -0.04362319f, 0.01659157f, -0.04045392f, 0.02827653f, 
    0.04616224f, 0.00625275f, 0.01516517f, -0.04715652f, 0.00018422f, 0.01263718f, 0.01905938f, 0.01640217f, 
    0.04643507f, -0.03777353f, -0.03551846f, 0.04282043f, 0.00134699f, -0.04247624f, 0.00451508f, 0.03791463f, 
    0.00290441f, -0.04120136f, -0.02211814f, 0.02640887f, -0.00988004f, -0.00631952f, -0.00062829f, -0.05995500f, 
    -0.04539750f, -0.02314385f, -0.01612687f, 0.02530353f, 0.04587335f, -0.05665310f, -0.03941384f, -0.03344573f, 
    0.00310946f, 0.02543939f, -0.00225455f, 0.00911477f, -0.01719520f, 0.00868210f, -0.01891097f, 0.02980001f, 
    0.00759115f, 0.02156659f, 0.01574496f, 0.02865263f, 0.03999036f, -0.03214886f, -0.03343681f, -0.02157731f, 
    -0.01190155f, -0.00365460f, -0.00394755f, -0.00680266f, -0.01308739f, -0.02107589f, -0.03600135f, -0.00309954f, 
    -0.02776852f, 0.03588830f, -0.03872200f, -0.03551101f, 0.00087609f, 0.01226591f, 0.03700623f, 0.00337659f, 
    0.02126546f, 0.01218402f, -0.04728952f, -0.01728740f, -0.01303624f, 0.01824865f, -0.01491568f, 0.03189918f, 
    -0.03521227f, -0.03189640f, -0.01396791f, -0.03128380f, 0.02896341f, -0.03821912f, -0.00011019f, -0.02973273f, 
    0.04318368f, -0.00394904f, -0.05350361f, -0.00302336f, -0.02609718f, -0.05213825f, 0.04143859f, 0.02081219f, 
    0.00619995f, 0.04584849f, -0.01265947f, 0.04133313f, 0.01646286f, 0.04323040f, 0.00598287f, -0.03443318f, 
    -0.04095196f, -0.02013087f, -0.03884768f, -0.05769508f, -0.00371855f, -0.00772874f, -0.02547135f, 0.02945405f, 
    -0.06018240f, 0.02181845f, 0.04474232f, -0.00501620f, -0.02339772f, 0.01507248f, -0.02585594f, -0.01193288f, 
    -0.04554251f, 0.00357152f, -0.01198166f, -0.05813932f, 0.01986543f, 0.00966987f, -0.06103845f, -0.00084906f, 
    -0.02861008f, -0.06026506f, -0.01768228f, -0.00095221f, -0.01084249f, -0.06061376f, 0.00082039f, -0.04031775f, 
    0.02962493f, 0.01919917f, -0.00754284f, -0.02620552f, 0.02342385f, 0.02996925f, -0.03606628f, -0.04122313f, 
    0.01909371f, 0.01279724f, -0.04183178f, 0.04595980f, 0.03717025f, -0.05748402f, 0.01748658f, 0.02406697f, 
    -0.02234607f, -0.01848934f, -0.00957216f, 0.04337910f, -0.03935646f, -0.03947445f, -0.05418244f, 0.01615561f, 
    0.01073389f, -0.06211834f, -0.00948035f, 0.02121191f, -0.03370459f, 0.01888321f, -0.04163177f, -0.00429399f, 
    0.04476307f, 0.00735328f, 0.01643404f, -0.02985798f, -0.01175701f, 0.04501412f, 0.02114823f, -0.03893045f, 
    -0.04729632f, 0.02398721f, -0.03616809f, -0.03503671f, -0.03782544f, 0.03251439f, 0.00668263f, -0.00025320f, 
    -0.04161094f, -0.02386746f, 0.05207736f, 0.03435194f, 0.00202782f, 0.04612398f, -0.02191652f, 0.01997735f, 
    -0.02005527f, 0.02336540f, 0.00975733f, -0.02236710f, 0.03080086f, -0.04846825f, 0.03253385f, -0.00291454f, 
    -0.02616340f, 0.04635096f, -0.04036332f, -0.03053120f, 0.00248523f, -0.03396160f, -0.06173024f, -0.05841170f, 
    -0.04923022f, -0.06055325f, -0.04345737f, -0.05070791f, -0.04314089f, 0.03794431f, 0.00549180f, -0.01525418f, 
    -0.03931902f, -0.00152287f, -0.03729680f, 0.03367386f, -0.03705616f, -0.00762737f, -0.03981798f, -0.01809201f, 
    -0.01884313f, 0.03290777f, 0.02616623f, -0.03324187f, -0.05549362f, 0.02828102f, 0.03816700f, 0.00861118f, 
    -0.00321794f, 0.03084358f, -0.04780201f, -0.04025853f, 0.00331155f, -0.04042193f, -0.03790744f, -0.03671042f, 
    -0.01615838f, 0.01381116f, -0.02107727f, 0.04281627f, 0.01230778f, 0.00078409f, -0.02416557f, 0.04082395f, 
    0.02827694f, -0.05778797f, 0.01051717f, -0.00193253f, 0.04904610f, 0.00092056f, -0.04697588f, 0.03243070f, 
    -0.02571895f, -0.06329113f, -0.04228599f, -0.02267345f, 0.01435577f, -0.04378836f, -0.04820837f, -0.02771033f, 
    0.03405520f, 0.01811904f, 0.02229231f, 0.01800755f, -0.01728294f, 0.00330111f, -0.02948062f, -0.02852821f, 
    -0.45293152f, -0.48517126f, -0.17612168f, 0.16307566f, 0.29710811f, -0.25250509f, -0.14794575f, -0.16901937f, 
    0.11875784f, -0.22032674f, 0.25022715f, -0.02727550f, 0.17227061f, -0.11852301f, -0.02257143f, -0.10223592f, 
    -0.03539757f, 0.13123333f, -0.10700165f, 0.19503194f, 0.45345762f, 0.15978116f, -0.13018328f, -0.13986443f, 
    -0.23267439f, -0.00602799f, -0.03866952f, -0.14019649f, 0.11113638f, 0.07189094f, 0.04473969f, -0.01433884f, 
    0.10168650f, 0.06409278f, 0.00897195f, 0.02138960f, -0.04531380f, -0.00458017f, -0.02055193f, 0.02414549f, 
    -0.06165545f, 0.12015114f, -0.67316937f, 0.52126962f, 0.24496168f, 0.03486154f, -0.18241256f, -0.22223647f, 
    -0.13089401f, -0.05448424f, 0.07246518f, -0.02493116f, -0.02226861f, -0.02921215f, 0.00368368f, -0.09744833f, 
    0.02074048f, 0.01133058f, 0.13139547f, 0.15975757f, 0.10327036f, 0.18470557f, 0.10499531f, -0.48675019f, 
    0.26602742f, 0.11637034f, -0.22095621f, -0.24790937f, -0.16708668f, -0.05883050f, -0.00314492f, 0.15312470f, 
    -0.04773421f, 0.08830319f, 0.06537588f, -0.13574564f, -0.12269175f, 0.11405912f, 0.01472014f, -0.22905815f, 
    0.08929895f, -0.03776634f, -0.33054689f, -0.19301344f, -0.20672597f, 0.03636334f, -0.29046392f, 0.16768396f, 
    -0.18830922f, -0.01581280f, -0.03917354f, -0.17204252f, 0.10827210f, 0.14744356f, -0.02176594f, 0.15861274f, 
    -0.10217862f, -0.04006585f, -0.10684542f, -0.02546137f, 0.10381930f, 0.10389172f, 0.65400451f, -0.17663728f, 
    -0.15357485f, 0.04340240f, 0.14138280f, 0.18133020f, 0.02126365f, 0.08709069f, -0.02022445f, 0.06117821f, 
    0.05508605f, -0.06700112f, 0.05807984f, 0.03863883f, -0.08496540f, -0.09968424f, 0.07854213f, -0.07938275f, 
    -0.06824023f, -0.22434430f, -0.03203757f, -0.19101554f, -0.12114533f, -0.07448786f, 0.00859646f, -0.15136668f, 
    -0.11990391f, 0.01139682f, -0.04538395f, 0.03189817f, -0.10660977f, -0.00746707f, 0.15292083f, -0.03676382f, 
    0.19421543f, 0.06538472f, 0.04581661f, 0.12116894f, 0.03377784f, 0.21166275f, 0.45786849f, 0.15131561f, 
    -0.02038519f, 0.07749160f, 0.10549564f, 0.11601023f, -0.00178020f, 0.16303185f, 0.02043643f, 0.01657671f, 
    0.10298401f, 0.11263929f, 0.03469798f, 0.10511527f, 0.05250190f, -0.13557734f, -0.02745471f, 0.10389986f, 
    0.21409875f, 0.33649176f, 0.59682417f, -0.08631314f, 0.08583710f, 0.17414758f, 0.17998551f, 0.10079899f, 
    0.09598696f, 0.14552261f, -0.09348705f, 0.03764290f, 0.01210397f, 0.02424421f, 0.08804671f, 0.00532445f, 
    0.06672405f, -0.27032846f, 0.01464080f, 0.06040365f, -0.57759398f, -0.54187030f, -0.32743365f, 0.26228940f, 
    0.24509569f, 0.03172019f, 0.02266593f, 0.05502835f, -0.13009022f, -0.05140266f, 0.07880673f, 0.04124284f, 
    0.02889813f, 0.07484628f, 0.24065152f, 0.08578835f, 0.00946572f, 0.07233006f, -0.03386459f, -0.16869664f, 
    -0.08438609f, 0.53096724f, -0.35734254f, 0.16919324f, -0.22166081f, 0.01755187f, 0.05269767f, 0.38836995f, 
    -0.10049488f, 0.13476227f, -0.09189095f, 0.17112154f, 0.03120155f, -0.15281226f, -0.17041206f, -0.00982453f, 
    0.05611030f, 0.14332315f, -0.06612394f, -0.18979903f, -0.05638971f, -0.02557363f, 0.50736696f, 0.31834605f, 
    -0.19190149f, -0.02397308f, 0.19196829f, 0.28429645f, 0.00777164f, 0.07221728f, 0.08279400f, -0.02429754f, 
    0.12867680f, -0.01358772f, -0.02086238f, -0.01612350f, 0.00339168f, 0.11209550f, 0.02834548f, -0.02431782f, 
    -0.06999781f, 0.25294259f, 0.29516628f, 0.00280427f, -0.00156063f, 0.10589116f, 0.09951852f, 0.00602461f, 
    0.05177782f, 0.10389494f, 0.07694347f, -0.01782943f, 0.01278920f, -0.00755840f, -0.05335772f, -0.00729304f, 
    -0.07936630f, -0.02429470f, 0.03814099f, 0.03574730f, 0.24700148f, -0.04698019f, 0.32301739f, -0.13460027f, 
    0.12544701f, -0.05377905f, 0.14595293f, 0.00164243f, 0.00448489f, 0.11347035f, -0.01775983f, -0.15312226f, 
    -0.01180651f, -0.03200905f, -0.00531057f, 0.11535032f, 0.00724357f, -0.25778538f, 0.13583383f, -0.05144940f, 
    -0.20871283f, -0.42492190f, -0.17728199f, 0.08442815f, 0.02875437f, 0.17099757f, 0.02100227f, -0.18659569f, 
    -0.28349930f, -0.05520823f, 0.28860286f, -0.01499165f, -0.04558408f, 0.08995682f, 0.18284835f, -0.10808285f, 
    0.03714179f, 0.13651907f, -0.15406291f, -0.06071023f, 0.06438658f, 0.10087656f, -0.39604014f, -0.11278004f, 
    -0.20011400f, -0.24548818f, -0.19648452f, -0.33400828f, 0.08647067f, -0.06647041f, 0.06571438f, 0.07093633f, 
    0.00873491f, 0.03033746f, -0.04313181f, -0.09738667f, -0.13052239f, 0.16335936f, -0.09721217f, -0.02431916f, 
    0.18397591f, 0.06558940f, -0.03417430f, 0.14955123f, 0.16123989f, -0.26672283f, 0.02817343f, -0.22286686f, 
    -0.13264953f, -0.28768009f, 0.14120094f, 0.07054967f, 0.16883744f, -0.01879072f, -0.11800168f, -0.02659013f, 
    0.06379587f, 0.14003474f, 0.05065147f, -0.17270876f, 0.12060615f, -0.34883046f, -0.26197439f, 0.05633914f, 
    -0.04368506f, 0.07157832f, -0.13127200f, 0.08429696f, -0.04776339f, -0.13816802f, -0.00344165f, -0.04648558f, 
    0.05002469f, 0.04279834f, 0.02908857f, -0.09566655f, -0.05753291f, 0.08409028f, -0.00737340f, 0.06212776f, 
    0.29194349f, -0.30564269f, 0.49510038f, -0.06365840f, -0.00245814f, -0.05913941f, -0.20132586f, -0.15534605f, 
    0.04596836f, 0.05026933f, -0.01718624f, -0.03208165f, 0.02036230f, -0.14197849f, -0.13655347f, 0.02736297f, 
    0.24075387f, 0.42195770f, -0.00848816f, 0.01022974f, 0.00349055f, -0.07176883f, -0.49363962f, -0.12506109f, 
    0.43590927f, -0.12074023f, -0.07733364f, 0.02746697f, 0.04649159f, -0.16919711f, 0.03036566f, 0.04619594f, 
    -0.12980080f, 0.27473938f, -0.06672227f, 0.06271277f, 0.03210145f, 0.21687640f, 0.36195686f, -0.04668979f, 
    0.12018383f, -0.23250827f, 0.38227916f, 0.07651141f, -0.16529815f, -0.27022856f, -0.09517554f, -0.14095718f, 
    -0.01294882f, 0.05851917f, 0.18365480f, 0.15603961f, -0.04446227f, -0.02137867f, 0.10211329f, -0.06074578f, 
    0.02538188f, 0.01990801f, -0.10131447f, -0.15724796f, 0.10035554f, 0.01175852f, -0.43255919f, -0.10956554f, 
    -0.03607208f, 0.13867275f, 0.04119307f, -0.02762101f, 0.15099828f, 0.08065308f, 0.12664016f, -0.01692626f, 
    -0.22906539f, -0.03943170f, -0.17634062f, 0.11797485f, -0.11626406f, -0.03354675f, -0.22346355f, -0.11027692f, 
    -0.22229521f, 0.43149617f, 0.10613056f, 0.06751578f, -0.06231476f, 0.10088223f, 0.18542030f, 0.10415280f, 
    0.08562030f, -0.07528080f, 0.03729301f, -0.12383710f, 0.06551132f, 0.02289021f, 0.21315314f, 0.03873481f, 
    0.18322629f, 0.10219643f, 0.14676997f, 0.22164693f, 0.31910953f, -0.01309026f, 0.27092010f, -0.07847571f, 
    -0.03316715f, 0.10095938f, -0.00303601f, 0.04103320f, 0.02828841f, 0.19310851f, -0.01909313f, 0.00121303f, 
    0.09978306f, -0.02843985f, 0.05207463f, -0.03744659f, -0.04236478f, 0.00198454f, -0.12060358f, 0.11545435f, 
    0.18539183f, -0.15989527f, -0.12109591f, -0.12441011f, -0.16539548f, 0.18216436f, 0.01317271f, 0.17959103f, 
    0.00063559f, 0.11657672f, -0.03531242f, -0.00595081f, 0.12271057f, -0.04153223f, -0.01822767f, -0.02488254f, 
    0.18335429f, 0.04129870f, -0.01884964f, 0.01199248f, -0.14920767f, 0.00863006f, 0.33227795f, 0.39620784f, 
    0.21949758f, -0.20051301f, 0.03015677f, -0.33742791f, -0.01742652f, -0.22163926f, -0.05347015f, 0.00009479f, 
    -0.00802660f, 0.25652394f, -0.04278972f, 0.08541541f, -0.02508500f, 0.09206707f, 0.13134262f, -0.02158871f, 
    -0.16612102f, -0.01926761f, 0.40074348f, 0.04760572f, 0.14997019f, 0.01611224f, 0.08980954f, -0.43617123f, 
    0.06554801f, 0.13607158f, 0.04011352f, 0.03269469f, -0.13435061f, 0.23779073f, -0.07991765f, 0.13424434f, 
    -0.03343847f, -0.39490506f, -0.00193899f, 0.04319835f, 0.32384878f, 0.26494008f, 0.04142186f, -0.35207248f, 
    -0.13373080f, 0.07870636f, 0.05744637f, -0.11576717f, 0.09612083f, 0.16191287f, -0.05908822f, 0.01804394f, 
    -0.14053950f, 0.08734296f, -0.16105883f, -0.17175026f, -0.05858695f, 0.21511634f, -0.12549180f, 0.22407055f, 
    0.22530712f, 0.15972783f, -0.10445522f, -0.03632106f, -0.03866035f, -0.01104522f, 0.04406621f, 0.07249428f, 
    -0.02675254f, 0.12695639f, -0.04127279f, 0.18351778f, 0.05796503f, 0.00319453f, -0.00986570f, 0.02246219f, 
    -0.15853538f, 0.00987883f, -0.12417181f, 0.02023947f, 0.08626364f, 0.16731185f, 0.12567438f, -0.01112315f, 
    -0.06695970f, 0.15057324f, -0.10306270f, -0.02946998f, 0.06731577f, -0.00064481f, 0.02708705f, 0.03962343f, 
    0.10911017f, -0.04534008f, 0.01619165f, 0.18924731f, -0.04179401f, 0.08891132f, 0.07905852f, 0.01457598f, 
    -0.02784863f, -0.05418473f, 0.27132440f, 0.21600327f, 0.02066464f, -0.05950683f, 0.06320797f, -0.25288406f, 
    0.20589533f, -0.10771661f, 0.03805096f, -0.05989617f, 0.03132217f, 0.08079500f, -0.03512260f, -0.00717558f, 
    -0.03535738f, -0.03264458f, 0.28441548f, 0.10815575f, -0.16009784f, -0.25577581f, -0.42410448f, 0.26770854f, 
    -0.07237642f, -0.02913596f, -0.02466109f, -0.03243676f, -0.07608343f, -0.09856026f, 0.04790327f, -0.21397272f, 
    0.07317413f, 0.05384570f, 0.01776569f, -0.05832882f, -0.07769521f, -0.01078780f, 0.18633988f, 0.00290115f, 
    0.24467301f, -0.17214909f, 0.05359160f, -0.34723020f, 0.01625614f, -0.02446626f, -0.09646813f, -0.09441724f, 
    -0.07712859f, -0.05471306f, -0.15860848f, 0.17986383f, -0.08606452f, 0.11217164f, -0.05564060f, 0.15501402f, 
    0.03173613f, -0.10827139f, 0.01816722f, -0.00858061f, 0.38597977f, 0.25769186f, 0.29673153f, 0.28355789f, 
    -0.01773166f, -0.09779947f, 0.02208519f, -0.14586870f, 0.12921207f, -0.15435450f, 0.16042472f, 0.06716809f, 
    0.07200275f, 0.12309843f, 0.09123052f, 0.02485378f, -0.06153220f, 0.09655253f, -0.03937276f, -0.14085607f, 
    -0.03509375f, -0.01378966f, -0.75070155f, 0.21302441f, 0.15194662f, -0.04128953f, -0.06351017f, 0.05280757f, 
    -0.11900629f, -0.03754263f, 0.02891082f, 0.00340351f, -0.04761229f, 0.07086812f, -0.06266093f, 0.13362905f, 
    0.28463182f, -0.07099037f, 0.07016630f, 0.21921943f, 0.47740796f, 0.07610276f, 0.27228576f, -0.11000226f, 
    0.11624356f, -0.11738852f, -0.19032061f, -0.02659747f, 0.07534153f, -0.01514631f, 0.03717540f, 0.12450568f, 
    -0.03617120f, -0.24443780f, 0.04998155f, 0.16807848f, 0.07416571f, -0.28463373f, -0.00478279f, 0.08961537f, 
    -0.02412559f, 0.21259417f, -0.12924868f, -0.35694465f, -0.19890930f, 0.06596529f, -0.11590575f, -0.10770737f, 
    -0.05796047f, -0.11901481f, -0.08615472f, 0.07088578f, 0.08530065f, -0.02799094f, 0.18260159f, 0.11811911f, 
    0.11359841f, -0.12980045f, 0.08284784f, -0.11525474f, -0.43328249f, 0.00456782f, 0.06703047f, -0.00165752f, 
    0.26001006f, -0.03747986f, 0.00664215f, 0.06046550f, 0.08034765f, 0.09389597f, 0.01173394f, -0.00453744f, 
    0.23051652f, 0.05156292f, -0.05101829f, 0.06547473f, -0.03444785f, -0.04752119f, -0.03363705f, -0.06503490f, 
    0.37756285f, -0.21155216f, 0.32124397f, 0.27189410f, 0.09786477f, 0.12118300f, 0.00321433f, -0.23553790f, 
    0.07226344f, -0.15275392f, 0.28545830f, 0.01819646f, 0.03324907f, -0.01354437f, -0.06532369f, 0.06294811f, 
    0.10883004f, 0.10010157f, 0.05591052f, 0.18035679f, -0.19659825f, 0.18612865f, 0.00891867f, 0.00791409f, 
    0.01180599f, 0.12430999f, -0.07290437f, -0.05336234f, -0.01877506f, 0.22188181f, 0.00520617f, 0.09546749f, 
    -0.04107323f, 0.00693882f, 0.09809341f, -0.00779120f, 0.06878994f, 0.12269096f, 0.14730904f, 0.27260873f, 
    -0.09800089f, 0.21880656f, 0.12584084f, 0.09797025f, 0.01906294f, -0.11986200f, 0.01839368f, 0.12165711f, 
    0.03358737f, 0.04060378f, 0.07119872f, 0.04963895f, 0.04658016f, 0.03721505f, 0.01548447f, 0.01373723f, 
    -0.02739814f, -0.04429137f, 0.06236582f, -0.15021290f, 0.03671789f, -0.34427750f, -0.24302359f, -0.28122500f, 
    0.02565756f, -0.12564068f, 0.13303813f, 0.16396783f, 0.00201810f, -0.01245832f, 0.16006677f, -0.02568436f, 
    -0.00641715f, -0.06827350f, 0.09289207f, 0.12178211f, 0.07677221f, -0.01514270f, -0.08078292f, -0.02634475f, 
    -0.12309757f, -0.25412163f, -0.34430441f, -0.06077068f, -0.19544046f, 0.20353217f, 0.15415940f, -0.06475755f, 
    -0.05466381f, 0.17477724f, 0.19383891f, -0.13155481f, 0.07267322f, 0.04693830f, 0.05522088f, -0.18864825f, 
    -0.08197636f, -0.25834441f, 0.08598668f, 0.02255796f, -0.34763145f, 0.15671721f, -0.31999928f, 0.27482107f, 
    0.22420828f, -0.05518915f, -0.04213881f, 0.21625145f, 0.15817888f, 0.14033651f, 0.00916674f, -0.02177966f, 
    0.03011417f, -0.07083716f, -0.12419061f, 0.04148045f, 0.01917196f, -0.03862778f, 0.05197593f, -0.14580560f, 
    -0.23386167f, 0.09357356f, -0.14071490f, -0.02313971f, 0.08318549f, 0.07104578f, 0.12921230f, 0.14927036f, 
    -0.00638926f, 0.10675993f, 0.02192554f, 0.04383568f, -0.01752226f, -0.01831261f, -0.05740418f, -0.05335934f, 
    -0.07598739f, 0.17137121f, -0.05071831f, -0.37873682f, -0.18326594f, -0.09381702f, 0.01309972f, -0.00093402f, 
    -0.04472017f, -0.14020580f, 0.21534196f, 0.05270556f, 0.03129327f, -0.15527993f, 0.08037859f, -0.07583044f, 
    -0.01416165f, 0.13593115f, 0.07727206f, -0.08318917f, 0.16554546f, 0.02305062f, -0.03896815f, 0.15516168f, 
    -0.00018312f, 0.00925786f, -0.51566833f, -0.33912715f, -0.02150430f, -0.06717291f, 0.01309183f, 0.08801166f, 
    0.00667329f, 0.12162395f, 0.02911398f, 0.00034161f, -0.03398715f, -0.04027266f, 0.12529121f, 0.02466084f, 
    0.03974526f, -0.01273251f, -0.02155422f, 0.01866989f, 0.41244841f, -0.00920471f, 0.36453295f, 0.16804190f, 
    0.03384630f, -0.09406435f, -0.07742520f, -0.15962864f, -0.12171385f, -0.02458478f, 0.04037090f, -0.07886727f, 
    0.08949976f, 0.06007379f, 0.14082929f, 0.12657912f, 0.04833524f, -0.14712723f, -0.22719359f, -0.13781750f, 
    0.03864058f, -0.04462985f, 0.01961428f, 0.03310350f, -0.06167280f, -0.03757973f, -0.01561141f, 0.04004996f, 
    0.01445392f, -0.00535693f, -0.02964064f, -0.05414740f, -0.00423792f, 0.00935766f, -0.02467712f, -0.03283267f, 
    0.04547326f, -0.01077854f, 0.00413812f, -0.03863093f, -0.06379615f, -0.05085846f, -0.04776694f, -0.05849300f, 
    -0.00278008f, 0.02433837f, -0.04480429f, 0.02029071f, 0.00230164f, -0.02106912f, 0.00146491f, 0.02217236f, 
    -0.00733319f, 0.02621415f, -0.05669609f, -0.00175109f, -0.03624243f, -0.02358398f, -0.04180210f, -0.02535062f, 
    -0.02557109f, -0.06153009f, -0.04355865f, 0.04338288f, 0.00243461f, -0.04595651f, 0.01575336f, -0.05672992f, 
    0.03110005f, -0.00662184f, 0.02707462f, -0.04681036f, 0.04447926f, 0.02584326f, 0.01833944f, 0.03701871f, 
    -0.01171110f, -0.02964210f, -0.06414455f, 0.00739054f, -0.03130850f, 0.02274080f, -0.03555861f, -0.05973053f, 
    0.04650375f, -0.01327337f, 0.01285626f, 0.00430277f, 0.02233265f, 0.02473645f, 0.03393091f, 0.03179215f, 
    0.03447824f, -0.01637178f, 0.05007256f, -0.03810792f, -0.00295338f, -0.00564151f, 0.03093509f, 0.01303800f, 
    -0.03357628f, 0.01048440f, -0.02554573f, -0.04393186f, -0.00358393f, 0.02676440f, -0.00447467f, 0.02238510f, 
    -0.03044068f, 0.03639449f, 0.01749356f, 0.01259648f, 0.05201431f, 0.03037225f, -0.01783930f, -0.03970357f, 
    -0.05787184f, -0.03293929f, -0.02767633f, -0.03529255f, 0.00210174f, 0.00343300f, 0.04175115f, 0.02882983f, 
    0.02584004f, 0.03316895f, -0.01670593f, 0.01805690f, -0.02036669f, -0.02569195f, 0.02976074f, -0.01092383f, 
    0.04446829f, 0.01535073f, 0.02257372f, -0.05830096f, -0.01209564f, -0.03914465f, -0.02160024f, 0.01237727f, 
    -0.02828222f, -0.03085542f, 0.00911884f, -0.03760717f, -0.01870361f, 0.00515008f, 0.00577928f, -0.00955576f, 
    0.02622358f, 0.00314491f, -0.03009116f, 0.00607158f, -0.01426715f, -0.01550600f, 0.01969783f, -0.01489426f, 
    0.00154476f, 0.00055008f, 0.02572783f, -0.00516041f, 0.03058648f, 0.00376883f, 0.00117829f, 0.01469369f, 
    -0.05406636f, -0.01934222f, 0.03454517f, -0.00361752f, -0.04167704f, 0.00275685f, -0.05635739f, -0.06070088f, 
    -0.00837433f, -0.03912690f, -0.05800674f, -0.04451644f, -0.00297869f, -0.01763396f, -0.04444935f, -0.02635924f, 
    0.02633159f, -0.06589969f, -0.03162938f, -0.04123663f, 0.03459890f, 0.03238599f, -0.05004327f, -0.00633204f, 
    0.01866604f, -0.00545888f, -0.03329602f, -0.05786163f, -0.06097645f, -0.04381064f, 0.02500709f, -0.01001139f, 
    0.03663366f, 0.02225858f, 0.01548536f, -0.06210347f, -0.03347578f, 0.01000006f, -0.01052799f, -0.03483020f, 
    0.03014270f, -0.01222955f, 0.01986074f, 0.01724049f, 0.00429883f, 0.00984114f, -0.04974261f, 0.01675075f, 
    -0.00384611f, -0.02571132f, 0.00223657f, -0.05294367f, -0.00833718f, -0.05916365f, 0.01981749f, -0.00536705f, 
    0.03833395f, 0.03446857f, -0.03184665f, -0.04366152f, 0.01138585f, -0.06585091f, 0.03626301f, 0.01158620f, 
    -0.02404052f, 0.00819299f, 0.01751076f, 0.02657134f, -0.00997200f, -0.01263919f, 0.00566152f, -0.04789508f, 
    0.00786273f, 0.02667111f, 0.00169052f, -0.03247751f, -0.00399400f, -0.02162109f, 0.02475350f, -0.04382198f, 
    -0.00465448f, -0.01841618f, -0.01488719f, -0.03930323f, 0.03460118f, -0.04429089f, -0.00575730f, -0.02722259f, 
    -0.01863338f, -0.01337205f, 0.03915964f, -0.05311127f, 0.01628601f, -0.04164094f, -0.02546178f, -0.00113866f, 
    -0.01791843f, -0.00921298f, -0.01490277f, -0.02589616f, -0.03523080f, -0.02362463f, -0.03130052f, -0.06484234f, 
    0.03230978f, -0.02152038f, -0.02571642f, -0.06462010f, 0.01249151f, 0.00126019f, 0.02604685f, 0.03493461f, 
    -0.06490779f, -0.04560289f, -0.03287155f, -0.00791975f, 0.02442623f, -0.05956581f, 0.02627599f, -0.03265160f, 
    0.02590958f, -0.00849931f, -0.00687124f, -0.05927081f, -0.04299672f, 0.01555474f, 0.00343508f, -0.05273000f, 
    -0.00623750f, -0.05738746f, 0.00231295f, 0.02552306f, -0.03927371f, -0.00532810f, -0.00536014f, -0.04396766f, 
    0.00150602f, -0.02829949f, 0.03457188f, 0.03235133f, -0.04493622f, -0.04907492f, 0.04017765f, -0.02656651f, 
    -0.00328721f, 0.00074140f, 0.01027366f, 0.00311555f, -0.05229949f, 0.00790820f, 0.01314504f, -0.02912254f, 
    0.00263859f, -0.02434460f, 0.00596581f, -0.04604390f, 0.01866192f, 0.04072263f, -0.06250983f, 0.02921196f, 
    -0.03679585f, -0.02281732f, 0.01970939f, -0.03982684f, -0.02847280f, -0.01118533f, 0.00900667f, 0.03068019f, 
    0.00757423f, -0.04856104f, 0.00637114f, -0.00795027f, -0.01783538f, 0.03679209f, -0.04033021f, 0.02883053f, 
    0.29115868f, 0.06870703f, 0.08128457f, 0.12442041f, -0.03988302f, -0.19316231f, -0.13255808f, -0.17781474f, 
    0.09965333f, 0.08843604f, -0.03839479f, 0.13066860f, 0.13908553f, 0.09161519f, 0.08176918f, -0.17722070f, 
    0.11022727f, -0.01934306f, 0.30625474f, 0.08043686f, 0.19313987f, -0.49581447f, -0.17181937f, 0.01285215f, 
    -0.16038604f, -0.08274601f, 0.15073141f, 0.14461440f, 0.15643351f, 0.07045166f, -0.06104029f, 0.00593716f, 
    -0.06068506f, -0.03853792f, -0.11750645f, -0.01951567f, 0.09510499f, -0.06724020f, 0.03617502f, 0.09678669f, 
    0.35768193f, 0.37406632f, 0.14662783f, 0.05428861f, -0.09013441f, -0.17286636f, -0.11730883f, -0.11560867f, 
    -0.16068113f, -0.08566063f, -0.11270130f, 0.04535024f, -0.00130429f, -0.05194364f, -0.05825056f, -0.05390847f, 
    -0.26045656f, -0.12148294f, 0.01541660f, -0.14609808f, 0.16600807f, -0.08247764f, 0.16334668f, 0.09381568f, 
    -0.19468506f, -0.12060097f, -0.07487132f, -0.12897605f, -0.00289231f, -0.13750362f, 0.13431391f, -0.00446032f, 
    -0.09154245f, -0.09315058f, 0.18413329f, -0.19297725f, -0.10841989f, -0.08488230f, 0.15585585f, -0.06979884f, 
    0.04468646f, -0.15049571f, 0.01189961f, 0.10997800f, -0.13496692f, -0.10628927f, 0.09790616f, -0.05221715f, 
    0.03995559f, 0.00994286f, 0.09851894f, -0.07872283f, 0.24729988f, 0.12498640f, 0.01688413f, -0.01441954f, 
    0.18269666f, -0.08074737f, 0.37203124f, 0.12864910f, -0.45789292f, -0.02329021f, 0.00538044f, -0.05727991f, 
    -0.01001196f, 0.11841351f, 0.13506885f, 0.21529897f, 0.25785932f, 0.18564752f, -0.12155196f, 0.19963224f, 
    0.16070050f, 0.16475278f, 0.03763504f, -0.08324012f, 0.12737715f, -0.05520290f, 0.12537742f, 0.25260493f, 
    0.31209397f, -0.39758265f, 0.38528761f, 0.04101611f, -0.02214366f, 0.15046261f, -0.03153382f, 0.07798373f, 
    0.07702362f, -0.14557767f, 0.07569869f, -0.11418876f, -0.21018298f, -0.20563112f, -0.07482854f, 0.15698226f, 
    -0.16559935f, -0.17427240f, -0.05809217f, -0.20326766f, -0.12921265f, 0.21926330f, -0.05304835f, 0.08617106f, 
    -0.21752928f, 0.10167089f, 0.01778230f, 0.10240752f, 0.00194795f, 0.02459232f, -0.09201600f, 0.03918542f, 
    -0.01181535f, -0.12080090f, 0.09376618f, -0.11955455f, -0.08598205f, 0.14046158f, -0.03441863f, -0.10805386f, 
    -0.36106053f, -0.10636737f, -0.13881147f, 0.19530466f, -0.14576729f, 0.07783456f, 0.20413151f, -0.16615483f, 
    -0.17075297f, -0.12480450f, -0.02064656f, -0.04276518f, 0.13907871f, 0.05162367f, 0.04276761f, -0.02862708f, 
    0.09466871f, -0.07609733f, 0.00623768f, 0.40399882f, 0.18078947f, -0.00634252f, 0.27822310f, 0.10912640f, 
    0.02854217f, 0.00158303f, 0.00029961f, 0.05050115f, 0.01010172f, -0.09042301f, 0.05618588f, -0.01703890f, 
    -0.00514934f, 0.07791267f, 0.20604788f, 0.08893288f, 0.07148404f, 0.17340764f, 0.08499864f, -0.09268899f, 
    -0.17055306f, -0.32474294f, 0.08619494f, -0.08915512f, -0.42769799f, 0.23156413f, -0.00520549f, -0.10037058f, 
    0.05668538f, -0.07030901f, -0.19188681f, -0.06062935f, 0.14014326f, 0.18345094f, 0.01125641f, 0.00936967f, 
    0.16886428f, 0.16380818f, 0.15875740f, 0.22150317f, -0.30803627f, -0.33221191f, 0.32743105f, 0.20607202f, 
    -0.29582420f, 0.01111569f, -0.16901457f, 0.03899492f, 0.18443254f, -0.05882587f, -0.00848165f, 0.10472374f, 
    0.15461306f, 0.02769145f, 0.17319526f, 0.05772385f, -0.01288126f, -0.21343043f, -0.06281701f, -0.08021890f, 
    -0.12602939f, -0.01300642f, 0.36926731f, 0.23174089f, -0.09354948f, 0.06295348f, 0.10663065f, 0.07249294f, 
    0.11857937f, 0.09007972f, 0.21122794f, -0.01077347f, 0.30848107f, 0.03324226f, 0.04018249f, 0.01326913f, 
    0.22816843f, -0.04505511f, -0.01485440f, 0.36513105f, 0.08850072f, 0.15976876f, 0.06113262f, 0.13426687f, 
    -0.08474468f, 0.16667265f, 0.11968057f, -0.00532705f, 0.19064415f, 0.13966405f, -0.03102602f, -0.03773119f, 
    0.09790701f, -0.16846205f, 0.01866360f, -0.02148854f, 0.07775310f, -0.25514609f, 0.19508511f, 0.03345993f, 
    0.41478920f, 0.12910020f, 0.38796523f, 0.07544367f, -0.11578001f, -0.17039131f, -0.12297831f, -0.14772484f, 
    -0.14628589f, -0.03759639f, -0.15098321f, -0.08891895f, 0.00382447f, 0.03420190f, 0.00306993f, 0.12526235f, 
    -0.00308035f, 0.10708057f, 0.03735709f, 0.03337563f, 0.35670409f, -0.31522694f, 0.06869494f, -0.07180484f, 
    -0.13212912f, -0.12105961f, 0.07807610f, 0.11175125f, 0.17643766f, -0.08136763f, -0.06904322f, 0.09852164f, 
    -0.03892250f, 0.15535428f, -0.10541915f, 0.01292888f, 0.06253893f, 0.07256300f, 0.06187297f, 0.07209121f, 
    -0.03888432f, 0.08941230f, -0.10088456f, -0.09004867f, -0.05690174f, -0.02084154f, -0.00705848f, 0.16594796f, 
    0.01948047f, -0.03068085f, -0.11002858f, 0.05500996f, 0.06178376f, 0.22844023f, 0.17944102f, 0.17050996f, 
    -0.15956652f, 0.00514821f, -0.01777469f, -0.13036932f, -0.87591749f, 0.14382233f, 0.33183146f, -0.12243212f, 
    0.15265761f, -0.19319069f, -0.09348089f, -0.02586103f, -0.02460749f, 0.32959172f, 0.06002512f, 0.04085551f, 
    -0.06713260f, -0.05100025f, -0.12416476f, -0.04939843f, 0.05109862f, 0.03027779f, -0.08289276f, -0.04918827f, 
    0.05896315f, -0.47699735f, 0.45335889f, -0.42320609f, -0.01141569f, -0.09667423f, 0.02140958f, -0.04670315f, 
    0.00215919f, -0.02215495f, -0.06515034f, -0.06545924f, -0.08496917f, -0.07642069f, 0.02546644f, 0.00400493f, 
    -0.03708414f, 0.04155355f, -0.06772663f, -0.01834941f, -0.22145487f, 0.03670240f, -0.15749922f, 0.18513061f, 
    -0.14156449f, 0.08898579f, 0.09729862f, -0.02048596f, -0.10019600f, 0.01072449f, 0.27012116f, 0.03118865f, 
    0.35227603f, 0.29727772f, 0.15029576f, -0.07244325f, -0.05992799f, -0.08777123f, -0.20655340f, -0.10915779f, 
    0.19312553f, 0.05275598f, -0.00114932f, -0.25546378f, 0.24590819f, -0.06977412f, -0.01986045f, -0.02780264f, 
    0.12705559f, -0.09274828f, 0.07177218f, 0.30938563f, 0.09223370f, 0.16525503f, 0.05285857f, 0.01483559f, 
    -0.15088409f, 0.14457110f, -0.21137577f, -0.09928730f, -0.13375726f, -0.21542051f, -0.39986315f, 0.10103560f, 
    -0.13416669f, 0.06503833f, 0.11531434f, -0.00027168f, 0.00553471f, -0.06115164f, 0.15755826f, -0.16839014f, 
    -0.06467319f, -0.13385589f, -0.00061756f, -0.03739036f, 0.05901415f, 0.17448503f, 0.12260450f, -0.02098022f, 
    -0.56417453f, 0.37140447f, 0.03398447f, 0.07308076f, 0.17099956f, 0.18257059f, 0.07417265f, 0.26928470f, 
    0.01127051f, 0.07620398f, 0.00421675f, 0.00636286f, 0.16816229f, 0.21579148f, 0.07155397f, 0.11073758f, 
    0.08612946f, 0.10306220f, 0.10483782f, -0.10350325f, -0.09851736f, -0.26568329f, -0.38325715f, 0.16596338f, 
    0.15537624f, -0.16143844f, 0.00717907f, 0.07820275f, 0.07958891f, -0.06561078f, 0.02653133f, -0.03530524f, 
    -0.02821936f, -0.05423863f, -0.01071641f, -0.01631426f, -0.01852085f, 0.12351634f, 0.03726976f, -0.04866464f, 
    -0.19763201f, -0.20565295f, -0.24451560f, 0.02415634f, 0.09571985f, -0.02287390f, -0.00108551f, 0.06693105f, 
    0.10613064f, -0.05220579f, 0.11973981f, -0.03055007f, -0.01648027f, -0.11622957f, -0.11104494f, 0.10372314f, 
    -0.01440275f, 0.21243803f, -0.04078751f, 0.07107427f, 0.44992840f, 0.11717749f, -0.14919196f, -0.06491233f, 
    -0.06406392f, 0.04368507f, -0.06396523f, 0.04002597f, 0.00755875f, 0.09843690f, 0.04638435f, -0.03046905f, 
    -0.02362563f, -0.08830764f, -0.04339562f, -0.03384624f, 0.02428369f, -0.06091330f, -0.04488082f, 0.06584325f, 
    0.22667937f, -0.16145426f, 0.31348112f, -0.13562942f, 0.41614419f, 0.04685827f, 0.29288158f, 0.10954720f, 
    0.07684857f, -0.26477301f, 0.15291902f, 0.00774716f, -0.07454283f, -0.09088943f, 0.22507611f, -0.00108164f, 
    -0.11802275f, 0.05957394f, 0.15087795f, 0.12342873f, -0.13809621f, -0.24032411f, -0.34214357f, -0.13702542f, 
    0.31932536f, 0.04411963f, 0.02954727f, -0.26004085f, -0.08513055f, -0.06897759f, 0.01457722f, -0.08060092f, 
    -0.09036980f, 0.15063262f, 0.16351195f, -0.14354265f, 0.14805324f, 0.10548006f, 0.09856544f, 0.14021419f, 
    0.01505271f, -0.21586268f, -0.20988896f, 0.03555035f, 0.18887505f, 0.20903070f, 0.10732015f, 0.12291942f, 
    0.16597906f, 0.03648911f, 0.06701820f, 0.11153568f, -0.15509909f, 0.13755246f, 0.12225755f, -0.00548220f, 
    0.14520350f, 0.01833819f, 0.09059692f, 0.24531145f, -0.24289754f, 0.05732093f, -0.24029273f, 0.31798321f, 
    0.01961789f, 0.11265251f, -0.01616293f, 0.08059856f, 0.20909674f, 0.10305706f, -0.06955448f, 0.14031900f, 
    0.02893194f, 0.09481366f, 0.09660057f, 0.16953696f, -0.00137893f, 0.44872254f, 0.01919686f, 0.06902025f, 
    0.41332057f, -0.03729463f, -0.10932148f, 0.09004959f, 0.19000824f, 0.01192674f, -0.08729098f, 0.24340974f, 
    -0.04486366f, -0.09239604f, -0.01007878f, -0.06213070f, -0.00415337f, -0.14170921f, -0.09614575f, -0.04208053f, 
    0.01960667f, 0.12045251f, 0.08315562f, 0.18969730f, -0.63888687f, 0.24141155f, 0.41776863f, -0.11134777f, 
    0.16590916f, 0.09349127f, -0.01909963f, 0.02445165f, -0.04530122f, 0.20961447f, 0.11647944f, 0.15311135f, 
    0.08245599f, 0.08513489f, -0.07789283f, -0.11278792f, -0.04674011f, 0.03488185f, 0.10690297f, 0.00096219f, 
    -0.24850085f, -0.01454678f, -0.27635074f, 0.05334028f, 0.10724002f, -0.03648968f, 0.09213156f, 0.13764332f, 
    0.09245574f, -0.09070504f, 0.04283975f, 0.01021189f, 0.04552810f, -0.07068034f, -0.03455514f, 0.17501508f, 
    -0.07704241f, 0.01432465f, -0.21225631f, -0.20154195f, -0.34307757f, 0.05362377f, 0.13472961f, 0.03025207f, 
    0.12295998f, -0.04237287f, -0.16554716f, -0.09388797f, -0.12323574f, 0.08750501f, 0.11909512f, -0.06479505f, 
    -0.10150740f, -0.04957603f, -0.00717263f, 0.01040387f, -0.07739291f, -0.01422527f, -0.04829208f, -0.11163019f, 
    0.51508045f, -0.24813797f, 0.33981410f, -0.09214515f, 0.16284212f, -0.12721044f, 0.03445785f, -0.01834864f, 
    0.14380594f, 0.10234153f, -0.01697042f, 0.00957637f, -0.08350503f, -0.09781806f, 0.02559545f, 0.12694269f, 
    0.17548740f, 0.35278359f, 0.05250015f, 0.22622730f, -0.32179588f, 0.11247336f, -0.50821066f, -0.05237764f, 
    0.06275698f, 0.14971897f, 0.13883440f, 0.05754979f, -0.00514869f, 0.03761352f, -0.03736100f, -0.02476072f, 
    0.00329943f, 0.17069232f, -0.09008230f, 0.06613938f, -0.05625049f, 0.20909990f, -0.09601483f, -0.07086514f, 
    0.21866092f, 0.05265262f, 0.19352117f, -0.05010534f, 0.27274519f, -0.11005054f, -0.03674162f, -0.00154140f, 
    -0.04796569f, -0.06335223f, -0.11106261f, 0.04301874f, 0.02475540f, -0.06511542f, -0.05588175f, 0.07592901f, 
    -0.11738668f, 0.06685565f, -0.38090444f, -0.17440307f, 0.18487985f, 0.00455838f, -0.03190644f, 0.12008578f, 
    -0.20024395f, 0.16012785f, 0.04539908f, -0.05008952f, -0.08089027f, -0.15372005f, 0.13413182f, 0.06726879f, 
    -0.15816653f, -0.10007229f, -0.00434707f, 0.14414774f, -0.16803783f, -0.01651561f, -0.11143596f, -0.21012740f, 
    -0.86198205f, 0.24648342f, -0.17090629f, 0.00502578f, -0.15528749f, 0.18592827f, 0.10810184f, 0.14530981f, 
    -0.23724580f, 0.15482596f, -0.22893356f, 0.10571686f, 0.04218380f, 0.31072158f, 0.14332980f, -0.14400391f, 
    0.09485166f, 0.25458413f, 0.10120869f, 0.13099772f, 0.14844929f, -0.15703614f, 0.06900705f, 0.11694577f, 
    0.20001179f, -0.03270561f, 0.09953503f, 0.14121793f, 0.02764755f, 0.02361919f, 0.06095880f, 0.07186738f, 
    0.03979098f, 0.14467511f, -0.04825262f, 0.12241087f, 0.09244636f, -0.15244448f, 0.06187609f, 0.16417652f, 
    0.10104648f, -0.02144426f, 0.12300974f, -0.10496382f, 0.04515044f, 0.14231750f, -0.07567904f, 0.06822159f, 
    -0.01548720f, 0.03773938f, 0.01477966f, 0.13181639f, -0.03943993f, -0.03586390f, -0.05377445f, 0.02795925f, 
    0.03435721f, 0.04603509f, -0.02411656f, -0.22956097f, 0.06106728f, -0.02232334f, -0.02423129f, 0.05798137f, 
    0.00374364f, -0.06628020f, -0.10510444f, -0.12236197f, -0.11390514f, 0.09369415f, -0.02820386f, 0.06852465f, 
    -0.06983311f, 0.03896577f, -0.04985370f, 0.08343998f, 0.02169991f, -0.08686283f, -0.23704481f, 0.04279761f, 
    0.27775979f, 0.40275413f, 0.16042089f, 0.21873765f, 0.48946553f, -0.22882320f, 0.09260861f, 0.00428853f, 
    0.01698513f, 0.05104728f, -0.02465501f, 0.11157954f, -0.04520363f, -0.10012887f, -0.06297632f, 0.13123903f, 
    -0.16864796f, -0.09818787f, -0.11071385f, -0.14581685f, 0.27478769f, -0.12044982f, 0.28638372f, 0.02159758f, 
    0.12965061f, 0.09710333f, 0.19425033f, 0.15333585f, -0.20867445f, 0.02757947f, -0.07003926f, -0.11215696f, 
    -0.05912945f, 0.11657146f, 0.02411908f, -0.02105591f, 0.06886375f, 0.21335547f, -0.06829132f, 0.29592052f, 
    0.12564394f, 0.11907501f, -0.05594468f, -0.20668958f, 0.10568390f, 0.00194663f, 0.00535500f, -0.11384605f, 
    0.01210295f, 0.16583650f, 0.00254617f, 0.05166201f, -0.03580208f, -0.00470363f, 0.07325166f, -0.02336741f, 
    -0.06180375f, -0.01811195f, 0.05571265f, -0.04434555f, -0.00298772f, 0.00843104f, 0.17357010f, 0.14883699f, 
    -0.00519536f, -0.01145945f, -0.07184025f, -0.10524796f, -0.01581420f, -0.10417070f, -0.02340497f, 0.10665253f, 
    0.02957839f, -0.00370617f, 0.08715470f, 0.23287605f, 0.08403048f, 0.28671786f, 0.12006140f, 0.08438674f, 
    0.25565752f, -0.12736425f, 0.03954724f, 0.13364792f, 0.16805489f, -0.01678473f, 0.04383579f, 0.02637256f, 
    -0.01865806f, -0.05311267f, 0.14074565f, -0.11568797f, -0.07749480f, -0.10667592f, -0.00233575f, 0.04392714f, 
    0.09728068f, 0.03507670f, 0.00695286f, 0.10970640f, -0.62284011f, 0.13959832f, -0.11250926f, 0.16743067f, 
    0.07176250f, 0.09187746f, -0.09770761f, -0.10188551f, 0.04933691f, 0.17627071f, 0.07233967f, 0.03639691f, 
    -0.17845112f, -0.09190308f, -0.07364213f, -0.07853539f, -0.21381436f, -0.01147971f, -0.00998483f, -0.04005906f, 
    -0.50406617f, 0.27986789f, 0.04409393f, -0.00225067f, -0.19916856f, 0.04861925f, -0.06357244f, -0.03650803f, 
    -0.27116796f, -0.25616774f, 0.03630082f, -0.05912324f, -0.05090765f, 0.10602752f, 0.01346838f, -0.09446317f, 
    0.09495470f, -0.02941369f, -0.14374971f, -0.09034906f, 0.59915555f, -0.72398829f, 0.04554954f, 0.14008573f, 
    -0.00878538f, 0.00679038f, -0.01685385f, 0.01111149f, 0.20407176f, -0.05740213f, 0.01335626f, -0.03905739f, 
    -0.02411304f, -0.07106927f, 0.06182440f, -0.03866677f, -0.07438996f, 0.04401068f, -0.07593128f, 0.11456176f, 
    -0.13155842f, 0.19687618f, 0.26507628f, 0.18803653f, -0.22253697f, 0.05296060f, -0.01039239f, -0.06374454f, 
    -0.07321030f, 0.10332947f, -0.11572210f, -0.08902302f, 0.07717531f, -0.04940624f, -0.03456086f, -0.05075941f, 
    -0.08337501f, 0.10566447f, -0.17274120f, 0.13408460f, -0.12669876f, 0.02133168f, 0.13156001f, -0.39265707f, 
    -0.03871965f, -0.27970517f, 0.02261928f, 0.09192412f, -0.16952212f, -0.18724000f, 0.10251060f, 0.02372322f, 
    -0.12570989f, 0.25001135f, 0.08199953f, -0.05757407f, -0.04516762f, -0.08641990f, 0.20792480f, -0.02075935f, 
    -0.57350874f, 0.18202910f, 0.07791769f, 0.21305600f, -0.19518895f, -0.13585447f, -0.01246412f, 0.15457818f, 
    -0.16781062f, -0.02715584f, 0.01504694f, 0.30571714f, -0.07316951f, 0.13790335f, 0.14172421f, -0.07622296f, 
    -0.04001344f, 0.05958609f, -0.07799521f, -0.03386280f, 0.17951410f, -0.41209123f, -0.52387178f, 0.59359735f, 
    -0.04327355f, 0.20890260f, 0.00461255f, 0.03302387f, 0.07051951f, 0.16080040f, 0.06746259f, 0.09370337f, 
    -0.22528790f, -0.07715613f, -0.08407427f, -0.11297387f, 0.12953696f, -0.12090415f, -0.04767102f, -0.03538139f, 
    -0.15705083f, -0.31355324f, 0.30767006f, 0.06617432f, 0.22736149f, -0.02230821f, 0.17160366f, -0.01347896f, 
    0.31719649f, -0.12796432f, 0.03740770f, -0.09824353f, 0.18079443f, 0.04534575f, 0.19108717f, -0.02405963f, 
    -0.07952838f, 0.00785192f, 0.00602745f, 0.20729738f, -0.08384939f, -0.20920077f, -0.12522261f, 0.23398171f, 
    -0.19732168f, 0.15000021f, -0.07262079f, -0.02307327f, 0.19698830f, 0.18209007f, 0.08918289f, 0.05330322f, 
    0.03416753f, 0.14554156f, 0.00916044f, -0.11634353f, 0.03899921f, 0.02758860f, -0.01351993f, 0.15551317f, 
    -0.07536087f, -0.53197932f, 0.00139903f, 0.23333810f, -0.03478080f, 0.16872364f, 0.09114593f, 0.15381862f, 
    0.01860382f, 0.17625450f, 0.00411743f, 0.05058647f, 0.04682207f, -0.22650182f, -0.01419953f, -0.02466691f, 
    -0.02564629f, 0.13492486f, -0.05582345f, 0.01766216f, -0.14355914f, 0.40988371f, 0.23783845f, 0.00471128f, 
    -0.09811247f, -0.26606759f, 0.27048200f, -0.07393844f, -0.00475042f, -0.20008427f, -0.01649871f, -0.00170405f, 
    -0.10197718f, 0.11400767f, -0.04062728f, -0.14473343f, 0.06296598f, -0.04801648f, 0.07310925f, -0.00296061f, 
    0.07053576f, 0.15954931f, 0.21630146f, 0.08887877f, 0.24356715f, 0.08354871f, 0.16988507f, -0.34853882f, 
    0.02995164f, 0.05023746f, 0.09637897f, 0.00059004f, -0.09699706f, -0.00477911f, -0.01953979f, 0.16468810f, 
    0.05985734f, -0.15941566f, -0.01211594f, -0.01709383f, 0.26771754f, -0.39956260f, -0.09083905f, 0.20426665f, 
    -0.32554230f, 0.07985984f, -0.04634059f, -0.23809016f, 0.10043988f, -0.00800813f, 0.06516475f, 0.07611929f, 
    -0.17445210f, 0.06991399f, -0.00006718f, -0.04985995f, -0.15855674f, -0.08505987f, -0.06517517f, 0.06068682f, 
    0.34794396f, -0.20810798f, -0.03534650f, 0.36005285f, -0.06033090f, -0.04610000f, 0.13296168f, 0.11754703f, 
    0.10822821f, 0.11760049f, 0.12092732f, 0.06795216f, -0.08291646f, 0.02446679f, 0.16495113f, 0.09504069f, 
    -0.08087323f, 0.06411644f, 0.04400814f, 0.25558579f, 0.20611264f, 0.00838984f, 0.41699627f, -0.08860770f, 
    0.14694978f, 0.06724437f, -0.14060088f, 0.01846621f, 0.14290695f, 0.19861445f, 0.22576338f, -0.07781508f, 
    0.09279472f, -0.03305686f, 0.07481413f, 0.12582120f, -0.08594274f, 0.26733488f, 0.03326628f, 0.00034819f, 
    -0.57944834f, 0.33159688f, 0.22989593f, 0.12809709f, -0.12647828f, 0.10775648f, 0.14321509f, -0.05738836f, 
    -0.23947151f, -0.02254085f, 0.01536221f, -0.10217533f, -0.03437777f, -0.01265923f, -0.18552659f, 0.05315113f, 
    0.05067082f, -0.01785405f, 0.03310820f, 0.02409417f, 0.53277797f, 0.01667227f, -0.19930069f, -0.00787662f, 
    -0.04294326f, 0.01754791f, 0.19093883f, -0.14191626f, 0.10310511f, -0.17032951f, -0.00338497f, 0.00632277f, 
    0.08339759f, 0.03514386f, 0.15012802f, 0.13566992f, -0.12897955f, -0.04989777f, 0.05565686f, 0.18521492f, 
    -0.33739254f, -0.15516470f, -0.10250693f, -0.11317185f, -0.10615495f, -0.05196164f, -0.30764192f, -0.14399058f, 
    -0.21960019f, 0.06577203f, -0.16157162f, 0.06016285f, -0.14137372f, 0.06226710f, -0.14154057f, 0.05887063f, 
    0.10513719f, 0.02632295f, 0.17874178f, 0.03989733f, 0.45355308f, 0.01583054f, -0.24997070f, 0.19827133f, 
    0.53287333f, 0.23930198f, 0.03404235f, 0.23115924f, 0.16557236f, -0.20219265f, -0.07047582f, 0.19100335f, 
    0.15687852f, -0.00111846f, 0.13741104f, 0.13942640f, 0.01744436f, 0.08359311f, 0.10938447f, -0.04061029f, 
    -0.66877323f, -0.10762173f, 0.18225981f, 0.23222691f, 0.09163050f, -0.10286185f, -0.08264592f, -0.04887535f, 
    -0.13965456f, -0.06689662f, -0.00832198f, -0.12795776f, -0.12089134f, -0.07855546f, -0.05799033f, 0.11283437f, 
    0.11961517f, 0.11485270f, 0.04234683f, -0.10921923f, 0.24726440f, -0.21763067f, 0.25283092f, -0.21758775f, 
    -0.37219042f, -0.07807906f, -0.45116869f, 0.07575824f, 0.05803500f, -0.06612527f, -0.07119150f, 0.07448706f, 
    -0.05013494f, -0.18275265f, -0.10347868f, 0.13327786f, -0.11088045f, -0.18279085f, 0.19341344f, -0.17297459f, 
    -0.67275798f, -0.41327819f, -0.28692740f, 0.11520263f, -0.42435914f, 0.06490360f, -0.21621953f, -0.21828330f, 
    -0.20044135f, 0.03972661f, 0.26437214f, -0.19415294f, -0.05259604f, 0.10657418f, 0.12437555f, 0.02239032f, 
    0.28444454f, 0.15742940f, 0.22295137f, -0.05635829f, -0.04147039f, 0.07798030f, -0.14715877f, -0.16445392f, 
    0.18999310f, 0.06061821f, -0.00564754f, 0.03103750f, 0.21454479f, 0.27000353f, 0.03865264f, 0.19516124f, 
    0.02538124f, 0.23567005f, -0.06360960f, 0.06515105f, -0.09118953f, 0.23796563f, -0.17589830f, 0.31302971f, 
    0.69128597f, 0.46685129f, 0.60103405f, 0.00928122f, 0.52460873f, 0.25664458f, 0.06282620f, 0.01700428f, 
    0.15701520f, 0.04461205f, 0.06176261f, 0.06476223f, 0.01951190f, -0.25387403f, 0.24720883f, 0.03787617f, 
    -0.00205719f, -0.07285476f, 0.00983359f, 0.07069062f, -0.02703094f, 0.14199992f, 0.09235698f, -0.11249155f, 
    0.10998527f, -0.01051136f, 0.21417002f, -0.02063311f, 0.05549743f, 0.32997200f, -0.11211624f, 0.00254854f, 
    -0.04103216f, -0.03060957f, 0.06280866f, 0.08169188f, 0.04993686f, 0.07564892f, -0.13200811f, 0.08977490f, 
    -0.06562127f, 0.16428986f, -0.15854627f, 0.19373626f, 0.14683607f, 0.13650014f, 0.18717568f, 0.04037869f, 
    0.12444799f, 0.26529026f, -0.02121357f, 0.03505928f, 0.19878456f, 0.16142930f, 0.01847995f, 0.03136739f, 
    0.01618437f, -0.03681045f, 0.09278758f, 0.32984549f, -0.47799867f, -0.42456210f, 0.07093839f, 0.02868430f, 
    -0.28506270f, -0.08607185f, -0.04426653f, 0.05550881f, -0.08785924f, -0.28234628f, -0.01079558f, -0.09082614f, 
    -0.10495800f, 0.12898585f, 0.05161720f, 0.08605696f, 0.06462302f, -0.04716657f, 0.05767399f, 0.01526949f, 
    -0.61192602f, -0.32136253f, 0.49238068f, -0.12618527f, -0.20952311f, 0.35939640f, 0.16167812f, -0.01051554f, 
    0.01383747f, 0.18667980f, -0.05191561f, -0.11715081f, 0.00906073f, 0.12753581f, 0.06896968f, -0.20275915f, 
    -0.01641658f, -0.14942566f, -0.04313951f, 0.11468232f, 0.26757902f, 0.55095667f, -0.11163212f, 0.08017261f, 
    0.31701776f, 0.12145863f, 0.19080526f, 0.01787718f, 0.31635901f, 0.29407701f, -0.09035435f, 0.14302389f, 
    0.02165548f, -0.00665345f, -0.08123292f, 0.11676793f, -0.12344364f, 0.05888496f, -0.24263571f, -0.03406623f, 
    0.17675836f, 0.15777279f, 0.09278082f, -0.02303306f, -0.02357006f, 0.20010059f, 0.08232033f, 0.17040290f, 
    0.12176372f, 0.20253983f, 0.01562093f, 0.09076878f, 0.00469460f, 0.15292270f, 0.04521214f, 0.01367829f, 
    -0.11382297f, 0.00833101f, -0.05176818f, -0.01482671f, -0.34011039f, 0.34321851f, 0.12211551f, 0.03387952f, 
    0.48036256f, -0.17181024f, 0.15489358f, 0.09717361f, -0.07862680f, 0.12256240f, 0.05706667f, 0.05311341f, 
    -0.00792527f, -0.08379637f, 0.08931306f, -0.11974319f, 0.09795548f, -0.11867238f, -0.15143713f, 0.15964223f, 
    -1.07732189f, -0.20326762f, 0.09015120f, 0.43182418f, -0.29627669f, -0.22583500f, 0.02624738f, -0.26446980f, 
    0.17680556f, -0.03053633f, -0.23258957f, -0.04579153f, 0.00260481f, -0.02103044f, 0.00564103f, -0.06483841f, 
    0.14218639f, -0.01175890f, 0.09837175f, -0.09364183f, 0.75547129f, -0.21861352f, 0.19786628f, -0.13653716f, 
    0.22028929f, 0.20243746f, -0.08757542f, 0.16592756f, -0.02855890f, -0.26893678f, -0.14156833f, 0.05408404f, 
    0.23430739f, -0.04807205f, 0.17695586f, 0.09503158f, 0.12350570f, -0.01729689f, 0.06653804f, -0.16353919f, 
    -0.15206838f, -0.16138430f, 0.05379983f, -0.01669023f, -0.23917869f, -0.06067412f, -0.12178702f, -0.14198211f, 
    -0.12656727f, 0.05396880f, -0.03638897f, -0.20383881f, 0.10646126f, -0.17407010f, 0.11851734f, -0.14378278f, 
    0.10388016f, 0.09895067f, 0.05199667f, 0.12664971f, -0.28892663f, -0.18130518f, -0.40490872f, -0.12235243f, 
    -0.08320717f, 0.18381006f, 0.16313452f, 0.11024056f, 0.02016939f, 0.24350645f, -0.21822843f, -0.03714530f, 
    -0.06807890f, 0.02870476f, -0.00983528f, -0.05310859f, 0.11631007f, -0.04627143f, 0.08123141f, 0.13429153f, 
    -0.78061891f, 0.13518901f, 0.28555313f, 0.10369403f, -0.14230917f, 0.07893993f, -0.09265292f, -0.00137446f, 
    -0.06934220f, -0.08229033f, -0.05925973f, 0.01064933f, -0.06365497f, 0.00173550f, -0.08061419f, -0.10484041f, 
    -0.15754721f, -0.11097245f, -0.02498077f, -0.17175920f, -0.40400112f, -0.18491571f, 0.09154306f, 0.00989273f, 
    -0.25421774f, -0.17548746f, -0.10885102f, -0.13598867f, -0.09880912f, -0.11079247f, -0.02177186f, 0.18561646f, 
    0.11307806f, 0.06164461f, 0.07729267f, -0.10248469f, -0.05964525f, 0.04572231f, 0.03391188f, -0.07760089f, 
    -0.31830320f, -0.42323482f, 0.05048126f, 0.17065912f, -0.35607964f, -0.04812270f, 0.04342394f, -0.07893344f, 
    0.02854016f, 0.00341133f, 0.14276251f, 0.12191855f, -0.01952159f, 0.08470560f, 0.08690351f, -0.10426848f, 
    0.16225120f, -0.04053029f, 0.12993741f, 0.24619792f, 0.46434212f, 0.09410831f, -0.00187365f, -0.17572670f, 
    -0.01619323f, -0.13065451f, 0.01730612f, -0.03287163f, 0.05849686f, 0.01279072f, -0.01806637f, 0.09841228f, 
    0.10386715f, -0.00514002f, 0.11078430f, -0.03151335f, 0.18475643f, 0.08612792f, 0.14451823f, 0.19233941f, 
    0.45443195f, 0.20410739f, -0.19107753f, -0.12117650f, 0.02695652f, -0.06728834f, -0.06611001f, 0.17638804f, 
    0.16611059f, -0.02894295f, 0.05446298f, -0.06804649f, -0.08212352f, -0.02301078f, -0.00266072f, 0.13013014f, 
    -0.07789991f, -0.05032397f, -0.00293584f, -0.16667663f, 0.15278360f, 0.10125487f, 0.21699779f, -0.18819265f, 
    -0.05584336f, 0.02676891f, -0.01072972f, 0.02403340f, -0.00267115f, -0.07834326f, 0.02922598f, -0.06071771f, 
    -0.05476758f, 0.05387951f, 0.03593161f, -0.00139948f, -0.07764489f, 0.03414182f, -0.14212519f, -0.33833459f, 
    0.26744312f, -0.04836882f, -0.09736900f, -0.04396747f, -0.08052259f, 0.08404517f, 0.00650377f, -0.05594353f, 
    0.08387654f, 0.04193125f, -0.09790380f, -0.03606630f, 0.08660181f, 0.11596081f, 0.12584440f, 0.01495701f, 
    0.07079611f, 0.07703219f, 0.08582842f, 0.29441932f, -0.23912159f, 0.17243300f, 0.13841428f, -0.04617377f, 
    -0.04590728f, -0.07969498f, -0.11123887f, 0.00768592f, 0.06837052f, -0.13843763f, -0.25683570f, -0.02793378f, 
    0.00130757f, -0.03824582f, -0.07990197f, -0.01151084f, -0.00161650f, 0.12712395f, 0.21104521f, -0.00318957f, 
    -0.13046411f, -0.09141174f, 0.15595308f, -0.08093288f, -0.50226146f, -0.05757711f, -0.15925683f, 0.14150490f, 
    -0.01958160f, -0.01892462f, -0.12031811f, 0.16685605f, 0.01590019f, -0.03518927f, -0.03408592f, 0.07216177f, 
    0.15821064f, 0.29696363f, 0.11550335f, 0.25764722f, 0.18788424f, 0.24318017f, 0.02773951f, -0.25307223f, 
    -0.26781940f, 0.13647668f, -0.15604635f, -0.23031805f, 0.16217086f, -0.07047196f, 0.08208153f, 0.04707493f, 
    -0.01288605f, 0.07390118f, 0.01468649f, 0.10213456f, 0.02903346f, 0.00383356f, 0.05924483f, -0.15684254f, 
    0.28181353f, 0.22888979f, 0.03690083f, 0.23409010f, -0.10348306f, 0.03227332f, 0.00188525f, 0.11832840f, 
    0.05619842f, -0.09252220f, 0.13448460f, 0.10591439f, 0.08952114f, -0.01424718f, 0.06716786f, 0.06920703f, 
    0.14680643f, -0.03830774f, 0.19315261f, 0.30963534f, 0.39751592f, 0.15913293f, -0.09844203f, -0.04181309f, 
    0.05857203f, 0.14605403f, -0.10044830f, 0.10441678f, 0.07371737f, 0.17317615f, 0.03309652f, 0.09021996f, 
    0.06375770f, -0.00918430f, 0.05164914f, 0.18295565f, -0.08879806f, -0.14373656f, -0.08374727f, -0.24009806f, 
    -0.57609534f, -0.06343246f, 0.17442270f, 0.05267546f, 0.03683912f, 0.05804820f, 0.09702498f, -0.15095451f, 
    0.09595569f, 0.00058904f, -0.24926318f, 0.02826562f, 0.03015925f, 0.05266166f, -0.10707851f, 0.08158419f, 
    0.02472780f, -0.06588202f, 0.03629743f, 0.02343581f, -0.19318002f, -0.19675548f, -0.29856247f, -0.14884284f, 
    -0.09198823f, -0.07074986f, -0.02465117f, 0.10378714f, -0.01206498f, 0.04043492f, 0.03767415f, 0.02730840f, 
    0.06825142f, 0.07928041f, -0.01702634f, -0.00426297f, 0.23220931f, 0.08114870f, 0.09610548f, 0.06987964f, 
    0.01269701f, 0.03768223f, 0.00781832f, 0.00835468f, 0.03344356f, 0.03364837f, 0.01918399f, -0.01220772f, 
    0.04027078f, 0.00851649f, -0.06153531f, 0.02523397f, -0.04443118f, 0.03211918f, 0.00364919f, 0.04651383f, 
    0.01649050f, -0.05968963f, -0.05978638f, -0.05979602f, 0.02601696f, -0.01722217f, 0.05679626f, -0.01438519f, 
    0.03271696f, -0.05495916f, -0.02662948f, 0.03718719f, -0.00661590f, 0.05562821f, -0.05795803f, 0.02846549f, 
    -0.04140482f, -0.00877704f, 0.00156496f, -0.02530863f, -0.05644828f, 0.02563181f, -0.06050395f, -0.02669288f, 
    -0.05748468f, 0.02064199f, 0.02036021f, 0.01686622f, -0.03611572f, 0.01064278f, -0.05513646f, 0.03093119f, 
    -0.04633984f, -0.03206947f, -0.02124745f, -0.05343937f, 0.00602801f, -0.03445083f, -0.03615098f, 0.05419585f, 
    -0.01618573f, -0.05474484f, -0.06437150f, -0.02820479f, 0.02166679f, -0.01692263f, -0.01265272f, -0.03242505f, 
    0.00397921f, 0.01159036f, 0.01409965f, 0.03747223f, -0.01722267f, 0.00331830f, 0.04373108f, -0.01137302f, 
    -0.02271688f, 0.03095968f, -0.00892809f, -0.06212978f, -0.04827753f, -0.01156073f, -0.00436115f, -0.07146065f, 
    -0.05051726f, -0.00333000f, -0.00779357f, 0.02650246f, -0.01460151f, -0.02483730f, 0.02629653f, 0.03640058f, 
    0.00052844f, 0.00920843f, 0.04413752f, 0.02032807f, -0.04124548f, -0.00700609f, -0.02129477f, -0.00692729f, 
    0.00443941f, 0.00556154f, 0.02902044f, -0.07219081f, 0.05646934f, -0.00355702f, -0.00391448f, 0.03967261f, 
    -0.00890210f, 0.01180877f, -0.01997075f, -0.02387735f, 0.01651610f, 0.03146201f, 0.00221694f, 0.02799304f, 
    0.03242365f, 0.03649453f, 0.03484438f, 0.02674070f, 0.03152769f, -0.06233871f, -0.00018126f, -0.06109321f, 
    0.01129190f, -0.05253279f, -0.03813132f, -0.00731886f, 0.01729345f, 0.04047227f, 0.00956946f, 0.03621094f, 
    -0.00723077f, 0.03454910f, 0.03234974f, -0.02601514f, -0.03878954f, 0.03377117f, 0.00309100f, 0.05238641f, 
    0.03039135f, -0.00383251f, 0.03644641f, -0.00309909f, 0.00866892f, -0.04063154f, 0.00822748f, 0.01395565f, 
    -0.02839952f, -0.00968359f, -0.04471572f, 0.00082979f, -0.00533705f, -0.04680727f, -0.03329280f, -0.01018745f, 
    -0.00893149f, -0.03918964f, -0.01570895f, -0.04769344f, -0.06656161f, 0.03581972f, 0.01610672f, -0.03017964f, 
    0.00512893f, -0.05264000f, 0.00855760f, -0.03879866f, 0.04244794f, -0.05350478f, 0.04776433f, 0.01519907f, 
    -0.02924816f, 0.00913979f, -0.01508891f, 0.02455983f, -0.04383682f, 0.01502895f, 0.02820292f, 0.00478815f, 
    0.01527315f, 0.02309663f, -0.05542713f, -0.06502096f, 0.04027638f, 0.02970181f, 0.00178634f, -0.02239573f, 
    -0.00213687f, -0.00914715f, -0.00542141f, -0.01771964f, 0.03757785f, -0.07035418f, -0.06288271f, -0.03598893f, 
    -0.06459863f, -0.03192830f, -0.04120989f, 0.00876774f, 0.01378752f, 0.03539655f, -0.02694956f, -0.06113664f, 
    -0.02218071f, -0.05410486f, -0.00056422f, -0.02699737f, 0.01027997f, 0.01129997f, -0.01067613f, 0.04708991f, 
    0.03488614f, -0.00216200f, 0.01382824f, -0.03631521f, -0.03985286f, 0.00040291f, 0.04383098f, -0.03754072f, 
    -0.04206789f, 0.04349593f, 0.04241855f, 0.00173751f, -0.01315434f, 0.00049707f, -0.04272934f, 0.01782193f, 
    0.01019388f, -0.06614832f, -0.02015745f, 0.04094059f, 0.03387121f, -0.03300213f, 0.02814300f, 0.00452867f, 
    -0.01286357f, 0.03311469f, 0.03305418f, -0.00860517f, -0.06489864f, -0.03107691f, -0.01463069f, 0.05749508f, 
    -0.01083325f, -0.00876376f, -0.03623439f, 0.02884758f, 0.05479776f, 0.03502360f, -0.04077868f, 0.00644203f, 
    -0.01741174f, -0.01806739f, 0.02049778f, 0.00423922f, 0.03992813f, -0.04979182f, -0.03874292f, 0.01321229f, 
    0.03220349f, -0.06379618f, -0.01630713f, 0.01929813f, 0.04002551f, -0.02408268f, 0.01503146f, -0.02118197f, 
    -0.02431209f, 0.02123610f, -0.05678499f, -0.05753061f, -0.04656458f, 0.01863118f, 0.03791825f, -0.05531899f, 
    0.01108317f, -0.04152555f, 0.00337699f, 0.03052438f, -0.03800952f, 0.01707428f, 0.04322793f, -0.05712818f, 
    0.04416033f, -0.05965780f, 0.03905611f, -0.04600260f, 0.04092387f, 0.01621035f, 0.00697606f, 0.01465433f, 
    -0.02212889f, 0.02380481f, 0.01950951f, 0.00038926f, 0.00859268f, 0.00075540f, -0.03521560f, -0.00488820f, 
    0.04258145f, 0.00001371f, -0.02879699f, -0.04847815f, 0.00428667f, 0.01115158f, 0.02905427f, -0.00444315f, 
    0.00571126f, 0.05183050f, 0.03756426f, 0.02084505f, -0.07055572f, 0.02852079f, -0.01250275f, -0.01613688f, 
    -0.05193938f, 0.01201512f, 0.02795268f, 0.03568764f, -0.00001789f, -0.02043249f, 0.02501978f, -0.06980779f, 
    -0.02745632f, -0.04594284f, -0.02464398f, -0.04249349f, 0.04566777f, -0.03438663f, 0.03814565f, 0.00572877f, 
    0.00758454f, 0.04543000f, -0.03639238f, 0.03739868f, -0.02657148f, 0.01414633f, -0.05301178f, -0.05490818f, 
    0.01894064f, -0.00311583f, -0.04656475f, -0.01491711f, -0.04903585f, 0.04216509f, -0.01259356f, -0.04186541f, 
    -0.05225916f, 0.04095343f, -0.04487691f, 0.03530564f, -0.02957264f, -0.03318014f, 0.02263730f, -0.03369810f, 
    0.04906551f, -0.03233319f, 0.01569471f, -0.01735821f, -0.04126841f, 0.01194345f, 0.03295036f, 0.00161040f, 
    0.04508322f, 0.01726520f, -0.04238111f, -0.01351738f, 0.03998264f, 0.01457035f, -0.01115940f, -0.03133212f, 
    0.03853049f, -0.04744242f, 0.00670733f, -0.02950332f, -0.00404802f, 0.03984470f, 0.02754521f, -0.05243758f, 
    -0.04731820f, 0.03950622f, -0.00747454f, -0.02692744f, 0.01543165f, 0.03182581f, -0.04530193f, -0.02360982f, 
    -0.04636814f, -0.05122766f, 0.00912200f, -0.01465085f, 0.02962762f, -0.01087328f, 0.04762046f, 0.04296902f, 
    0.04492879f, 0.02988788f, -0.03580553f, -0.03375494f, -0.02028500f, 0.00782026f, -0.00129483f, -0.01318678f, 
    -0.05568177f, 0.00319080f, -0.05985745f, -0.02528351f, 0.03452476f, -0.00654073f, -0.03070275f, -0.03786404f, 
    -0.01920015f, 0.02669745f, 0.04003045f, -0.04466341f, -0.00683779f, -0.03599134f, 0.00238755f, -0.05172733f, 
    -0.03994865f, 0.01783839f, 0.00627208f, -0.05633995f, -0.00768385f, 0.03055963f, -0.01726781f, -0.01087899f, 
    -0.04903353f, -0.01625314f, -0.03930281f, -0.04208530f, -0.00344547f, -0.06108997f, -0.02836519f, 0.01949296f, 
    -0.02307001f, -0.03311776f, 0.04395054f, -0.02930062f, -0.03722590f, -0.04340444f, -0.05682828f, 0.00211059f, 
    0.04508032f, 0.01692126f, -0.02567842f, -0.00738106f, 0.01303097f, 0.02269933f, 0.03984499f, -0.03030878f, 
    -0.01233384f, -0.00912332f, -0.02503625f, -0.00841388f, -0.03673046f, 0.03760082f, -0.00217883f, 0.01195721f, 
    -0.02728759f, 0.02731160f, -0.05834411f, 0.00014831f, 0.00100654f, -0.04358523f, -0.05337396f, -0.04315338f, 
    -0.01002538f, 0.04191213f, 0.00726989f, -0.01814664f, -0.05351427f, -0.01770968f, 0.01200776f, -0.00226107f, 
    0.00241449f, -0.04862103f, 0.04579522f, 0.02305831f, -0.04525247f, 0.03938924f, -0.03494795f, 0.03898347f, 
    0.05274862f, -0.05154290f, -0.01592109f, -0.03444152f, 0.01332151f, -0.03817708f, 0.01114338f, 0.04784240f, 
    0.02014938f, 0.04970046f, -0.04733820f, 0.02314703f, -0.03232292f, 0.00493415f, 0.00253762f, -0.04399633f, 
    -0.05018736f, 0.02867057f, -0.03846950f, 0.02178492f, 0.00645795f, -0.01491721f, 0.02273446f, 0.02587364f, 
    0.02923343f, -0.02867597f, 0.04688378f, -0.03223116f, -0.02303831f, -0.04610960f, 0.04366893f, -0.01508546f, 
    -0.04338941f, -0.04470160f, -0.04369873f, -0.04374000f, -0.00222597f, -0.00114747f, -0.02794098f, 0.04532687f, 
    0.01360013f, -0.01384421f, -0.05172000f, 0.02313197f, 0.00705458f, -0.05598439f, 0.04789662f, 0.00177520f, 
    -0.03931807f, -0.03910952f, -0.03655429f, -0.04751085f, -0.05853313f, -0.01639002f, 0.02679889f, -0.05490798f, 
    -0.01713375f, 0.00162586f, 0.01061983f, 0.02337249f, -0.01268521f, -0.00139097f, 0.01046282f, -0.00425273f, 
    -0.02710479f, -0.04947355f, 0.00704951f, -0.01771002f, -0.04110010f, -0.01861691f, -0.01621266f, 0.01516342f, 
    0.01733792f, 0.00461691f, 0.04030200f, -0.05569058f, 0.00259595f, -0.03483778f, 0.03177340f, -0.05403781f, 
    -0.05125190f, -0.00048161f, 0.02601012f, -0.01928740f, -0.03398421f, -0.01806678f, -0.00118561f, -0.03624791f, 
    -0.03613598f, -0.02155101f, -0.01618716f, 0.00039509f, -0.02817738f, -0.01136484f, -0.03487604f, -0.04859653f, 
    -0.02710218f, 0.04219304f, 0.03162394f, -0.00837095f, -0.03539711f, 0.04832539f, 0.04202005f, 0.00349926f, 
    -0.04772083f, 0.04935049f, 0.05492026f, -0.02516071f, -0.02686596f, 0.01712283f, -0.03648156f, -0.04763627f, 
    0.03247628f, -0.01984225f, -0.04261861f, 0.04609627f, -0.01862910f, 0.00703707f, -0.04565997f, -0.04224206f, 
    0.03420290f, 0.00670604f, 0.03620015f, -0.04099223f, 0.01558808f, 0.00908356f, 0.00194390f, -0.01449069f, 
    -0.04914657f, 0.00283320f, 0.03763687f, 0.02576334f, -0.03549766f, 0.01799030f, -0.02951596f, -0.05378348f, 
    -0.03162215f, -0.02001056f, 0.00940042f, 0.01390639f, 0.03001525f, 0.00505847f, -0.03201037f, -0.02218926f, 
    -0.02650201f, -0.02432181f, -0.00735550f, -0.05793823f, 0.04492930f, -0.04660173f, 0.01639928f, 0.00017500f, 
    -0.03446491f, 0.00603288f, -0.04632967f, 0.02710156f, -0.06104177f, 0.02369657f, 0.01522746f, 0.00416855f, 
    0.13296804f, 0.07128140f, 0.18027554f, -0.07677413f, -0.13094118f, 0.10914087f, -0.07333186f, -0.09163741f, 
    -0.18248454f, -0.19505396f, 0.22987598f, 0.16358808f, -0.09962435f, 0.07749970f, 0.05867356f, -0.26226553f, 
    0.01888444f, -0.06640062f, -0.10937832f, -0.15488473f, 0.35217631f, -0.27581260f, -0.24257475f, -0.49995133f, 
    -0.23441063f, 0.01442991f, -0.07900231f, 0.01862050f, 0.35185701f, 0.13635530f, 0.15753777f, 0.17505416f, 
    -0.10155283f, -0.03175952f, 0.08271236f, -0.07456072f, -0.06408443f, 0.01098468f, -0.06201995f, -0.00021202f, 
    -0.03032589f, 0.38043314f, 0.09815084f, 0.19418605f, -0.06884436f, -0.01652082f, 0.05476300f, 0.10465232f, 
    0.00416286f, 0.07254949f, 0.15905288f, -0.07126397f, 0.08283474f, 0.11210055f, -0.07710637f, 0.09687375f, 
    -0.02576600f, -0.15594277f, 0.08766235f, 0.04212862f, 0.04454526f, -0.01362210f, 0.13705434f, -0.25084201f, 
    -0.15700957f, -0.03134433f, -0.05723990f, 0.06986960f, -0.02703285f, -0.21416949f, 0.21926622f, -0.00757528f, 
    0.00845135f, -0.04084466f, 0.03757915f, 0.00944330f, -0.07533020f, -0.13470939f, -0.13466124f, 0.03143023f, 
    -0.21785018f, 0.10798872f, 0.07341677f, 0.06809769f, -0.09674764f, 0.01067503f, 0.00844948f, 0.02609839f, 
    -0.02549092f, -0.09343967f, 0.27965099f, 0.12158364f, -0.12833396f, -0.02049576f, 0.01917700f, -0.18157460f, 
    -0.11702101f, -0.07856863f, -0.23107897f, 0.05847105f, -0.36411950f, -0.33783895f, -0.01183469f, 0.31247103f, 
    0.10706963f, 0.33221418f, -0.04257770f, -0.15145791f, 0.14556263f, 0.20723478f, 0.00291249f, -0.01006666f, 
    -0.00183121f, -0.15209574f, -0.13869895f, 0.00571724f, 0.15796065f, -0.11833820f, 0.00986753f, -0.14993998f, 
    0.42990923f, -0.38387266f, -0.19962512f, -0.21183866f, 0.01926264f, 0.00912902f, 0.19473389f, -0.06404752f, 
    0.45693538f, 0.00314488f, 0.01868665f, -0.08470419f, 0.02907024f, 0.03672324f, 0.11015959f, 0.04682773f, 
    0.04184023f, -0.11980068f, 0.03959085f, 0.06306673f, -0.14362738f, -0.25803328f, -0.51436031f, -0.06970210f, 
    -0.19371371f, 0.13110065f, 0.04027557f, 0.01693062f, 0.20860289f, 0.21163249f, 0.06053086f, -0.00716298f, 
    -0.08342420f, 0.13523388f, 0.04835843f, -0.08682905f, 0.01529697f, 0.14889961f, 0.31229281f, 0.11049842f, 
    -0.23260625f, -0.34171516f, -0.10246710f, -0.05056984f, -0.09380250f, 0.10571969f, 0.10473181f, -0.09203224f, 
    0.14892781f, 0.17494076f, 0.05364355f, 0.08304941f, 0.04337783f, -0.07830454f, -0.03316792f, 0.08953061f, 
    -0.04112837f, 0.06594887f, 0.10161658f, 0.10462131f, 0.15059887f, 0.20119824f, 0.04799832f, 0.04598856f, 
    -0.01222963f, 0.02565811f, 0.09946343f, -0.08068722f, -0.04715322f, -0.11541352f, -0.03609508f, -0.00892146f, 
    0.03580375f, -0.11787450f, -0.13620545f, -0.10461239f, 0.09849527f, 0.03794526f, -0.01433066f, 0.02573352f, 
    -0.13737272f, -0.11418371f, 0.03634312f, 0.14670962f, -0.22093283f, -0.06114961f, 0.05044447f, -0.07010069f, 
    -0.17902645f, -0.02143422f, -0.03373725f, -0.13492236f, -0.05877586f, -0.14881836f, -0.06961213f, 0.03568580f, 
    0.07252172f, 0.09141117f, -0.05022459f, 0.00789101f, 0.10553276f, -0.10220803f, -0.16664653f, 0.01452581f, 
    -0.13293220f, 0.11041065f, 0.00943095f, -0.08374895f, 0.28371534f, 0.11645725f, 0.04490462f, 0.07257511f, 
    -0.04929148f, -0.05881138f, -0.05153142f, 0.06035371f, -0.08050057f, 0.04284152f, 0.20106542f, 0.03927018f, 
    0.03089224f, -0.00270220f, 0.07731061f, 0.02095658f, -0.07732651f, 0.08201336f, 0.11908197f, 0.08410013f, 
    0.08717904f, -0.06827877f, 0.01302225f, -0.00687383f, -0.01492479f, -0.07852484f, -0.12647553f, 0.10734102f, 
    0.07838685f, 0.03236619f, -0.01632559f, 0.13873377f, -0.04130097f, -0.27738622f, 0.02475639f, -0.26934433f, 
    0.17057420f, 0.03851862f, 0.03124366f, 0.00710692f, 0.14385335f, 0.21741231f, 0.02171202f, 0.08879717f, 
    -0.06872609f, 0.07009667f, 0.10698819f, -0.08677819f, 0.16509075f, 0.26487687f, 0.02997664f, -0.00035818f, 
    0.06980446f, 0.47461572f, 0.09016041f, -0.08667278f, 0.02850481f, -0.07287351f, -0.01576791f, 0.06155819f, 
    -0.12243531f, -0.00103500f, 0.04762569f, -0.04047117f, 0.05034292f, 0.01541309f, -0.06138242f, 0.02399221f, 
    0.05851430f, 0.17562348f, 0.03152956f, -0.00101208f, 0.62088907f, 0.26308095f, -0.01783818f, -0.31800997f, 
    -0.32085210f, -0.04490044f, -0.03547532f, 0.02050080f, 0.05610413f, -0.06392670f, 0.06179420f, 0.07411543f, 
    0.00284827f, 0.02162714f, 0.06090617f, 0.02665276f, -0.06088123f, -0.14377722f, -0.12668900f, 0.06396486f, 
    0.34215540f, -0.02477311f, 0.04425655f, -0.04573624f, 0.22294496f, 0.02080784f, 0.00661838f, -0.11711913f, 
    -0.17696656f, 0.01493163f, 0.16591857f, -0.07943071f, 0.10502490f, -0.12621339f, 0.04459239f, -0.01729673f, 
    -0.00580683f, 0.08649369f, -0.08202968f, 0.03677658f, -0.09820506f, 0.07806721f, 0.13564387f, 0.00101312f, 
    -0.24932447f, 0.10413730f, -0.00564793f, 0.14235349f, 0.02034388f, -0.06653531f, -0.06612023f, -0.12815961f, 
    -0.13607614f, -0.08376249f, -0.00393424f, -0.14934820f, -0.11778373f, 0.01036813f, -0.04255099f, 0.03116226f, 
    -0.03931224f, 0.26894119f, -0.12495258f, 0.12344795f, 0.24400178f, 0.17336702f, -0.02702190f, 0.11683252f, 
    0.01995652f, 0.16652520f, -0.07766978f, -0.04783488f, 0.01117613f, 0.01900477f, -0.02176533f, -0.05021431f, 
    0.08105224f, 0.17263284f, 0.02249238f, -0.02669180f, 0.03965208f, 0.00534943f, -0.25091952f, 0.00900759f, 
    0.40610310f, -0.17796040f, -0.00968795f, -0.03915532f, 0.04452873f, 0.01816702f, 0.16515869f, 0.23658213f, 
    -0.06491391f, 0.17595851f, 0.15406229f, 0.07666184f, 0.08370312f, 0.05650970f, 0.11107336f, 0.08905974f, 
    0.06284177f, 0.04573039f, 0.07254821f, -0.00844254f, 0.13471130f, -0.01305186f, -0.12942095f, 0.01050428f, 
    0.01772187f, -0.03298334f, 0.03113858f, 0.25138685f, -0.09541994f, 0.02720592f, -0.00879133f, 0.08357333f, 
    0.07054751f, -0.12902653f, 0.03045766f, 0.11977449f, 0.52174467f, 0.03814210f, -0.05734121f, -0.07902415f, 
    -0.01835616f, -0.21459414f, 0.05879097f, -0.06472543f, -0.08369077f, 0.01476676f, -0.10988290f, 0.06433568f, 
    -0.15256555f, 0.02308350f, -0.06011789f, -0.14210251f, -0.00015920f, -0.04510920f, 0.10226597f, 0.07088682f, 
    0.12710220f, -0.22160257f, -0.01078260f, 0.14211120f, -0.21725515f, -0.36634082f, 0.03747447f, -0.10483849f, 
    0.15491100f, -0.28190011f, 0.20141716f, -0.11443800f, 0.17086393f, 0.07005154f, -0.04220537f, 0.12508048f, 
    0.08307637f, 0.05921654f, -0.02352789f, 0.00762151f, 0.13390110f, 0.07374404f, 0.33491242f, -0.21166888f, 
    -0.20028943f, 0.23794943f, -0.08644136f, 0.12775160f, 0.00674422f, -0.02760591f, 0.03829698f, 0.02567589f, 
    0.11643615f, -0.02312381f, -0.01054140f, -0.08281031f, -0.06310976f, 0.07660642f, 0.06774729f, 0.27492025f, 
    0.29366532f, 0.04695368f, 0.14775673f, -0.08948518f, -0.22446729f, 0.00886618f, -0.04272809f, 0.02517719f, 
    -0.04503952f, -0.11190522f, 0.03735695f, 0.05206726f, 0.12751237f, -0.06505892f, -0.02478725f, -0.08597360f, 
    0.01474937f, 0.20921509f, 0.02786076f, -0.04612992f, 0.02190245f, 0.22288615f, -0.08981304f, -0.08018579f, 
    0.33099240f, 0.07790822f, 0.10318054f, -0.06518079f, 0.13234207f, 0.12605128f, 0.04540695f, 0.01021471f, 
    -0.05043335f, 0.13325502f, -0.11378919f, -0.00877626f, 0.05190240f, -0.04497136f, 0.16950889f, -0.05880829f, 
    0.34187171f, 0.14986669f, -0.41151157f, -0.05508430f, -0.21761517f, -0.08731072f, -0.16524737f, -0.27762663f, 
    0.00834308f, -0.04413711f, 0.10659914f, 0.11491167f, -0.12814252f, 0.03661738f, -0.14648652f, 0.06706185f, 
    0.16230294f, -0.20520261f, 0.01589878f, -0.10739277f, -0.08025098f, 0.01620178f, -0.24012631f, -0.41611993f, 
    -0.48113132f, 0.13620435f, -0.00210652f, -0.12165386f, 0.08876424f, -0.04749965f, 0.06018514f, -0.05086184f, 
    -0.08357184f, -0.01175663f, -0.05090711f, -0.06161374f, 0.01545455f, 0.14745720f, 0.23429514f, 0.06759081f, 
    0.14757057f, 0.12425485f, -0.06985144f, 0.14598419f, -0.00995697f, -0.08747000f, 0.03163803f, 0.03180101f, 
    0.02583921f, -0.02631371f, 0.10874262f, 0.01583736f, 0.12497972f, -0.02751901f, 0.06472225f, 0.03928567f, 
    0.00880419f, 0.08467028f, 0.13120012f, 0.03031795f, 0.47905865f, -0.08590306f, -0.05007284f, -0.10824007f, 
    -0.29919451f, 0.12201122f, -0.03735773f, 0.04974146f, -0.02984683f, -0.00252173f, 0.06405865f, 0.05439714f, 
    0.11871229f, 0.03066225f, -0.07514071f, 0.07176591f, -0.08137649f, 0.16487673f, -0.00626565f, 0.06058128f, 
    0.22949272f, -0.04475537f, -0.28592211f, -0.37700769f, 0.39728585f, 0.23603450f, 0.04823024f, -0.00264890f, 
    0.03582364f, 0.23042195f, 0.09328949f, 0.06684448f, 0.03542645f, 0.03040859f, -0.03549157f, 0.07839452f, 
    0.05279937f, -0.10858547f, 0.04553405f, 0.04939208f, -0.46727547f, 0.08478528f, -0.12412965f, 0.21950619f, 
    0.14990681f, -0.03527681f, 0.07883666f, -0.03595845f, 0.06056806f, -0.03992361f, 0.20290586f, -0.10463749f, 
    -0.01563936f, 0.04248277f, 0.05597086f, 0.06140577f, -0.03448543f, -0.00555911f, 0.07909046f, 0.03696681f, 
    0.45129597f, 0.07189807f, 0.09905369f, -0.04810351f, -0.03628555f, -0.04813683f, -0.05164292f, 0.06259164f, 
    0.00548139f, -0.04610011f, -0.22936046f, 0.13191029f, -0.02666864f, 0.03742281f, -0.07410942f, 0.00777619f, 
    0.02453711f, -0.10419113f, 0.03345083f, -0.11607058f, -0.38035104f, -0.10028245f, -0.11518329f, 0.02238905f, 
    0.07757986f, 0.06479506f, -0.03626182f, 0.10421630f, -0.02526301f, -0.11881056f, -0.05715916f, 0.08485049f, 
    0.05847267f, 0.12093838f, 0.03520345f, 0.02390479f, 0.03773797f, 0.02053265f, -0.09490673f, 0.01212041f, 
    0.36293739f, -0.59177917f, 0.22786650f, -0.64803183f, -0.17481226f, -0.21205360f, 0.00342226f, 0.08915935f, 
    -0.06644772f, -0.09062854f, 0.07604841f, 0.00629498f, -0.01249158f, -0.03211665f, 0.00725464f, 0.10277488f, 
    0.02258965f, -0.02301848f, 0.02931389f, 0.04800468f, 0.21975793f, -0.06372470f, -0.12599212f, 0.11166561f, 
    -0.18192554f, 0.03179279f, 0.03924114f, 0.03674609f, 0.09458284f, -0.02496257f, -0.10362698f, -0.08530478f, 
    -0.02445681f, -0.20110700f, -0.08080665f, 0.01455407f, -0.09162463f, -0.11794864f, -0.06105395f, -0.08142101f, 
    0.23268822f, -0.13190512f, 0.18455549f, -0.02468866f, -0.02601243f, 0.01969319f, 0.04857685f, -0.10223393f, 
    0.07588215f, -0.10323045f, 0.12928124f, 0.04680686f, -0.04464050f, -0.14668794f, 0.18282475f, -0.16680403f, 
    0.17930646f, -0.11010759f, 0.00284500f, -0.01799873f, -0.57223743f, -0.04621605f, -0.34519571f, 0.00593047f, 
    0.21715140f, 0.14302312f, 0.06354857f, -0.09502073f, 0.23690423f, 0.14870161f, 0.02607161f, -0.05754565f, 
    0.15300490f, 0.09253293f, 0.02450602f, 0.14025837f, -0.00881558f, 0.16887014f, -0.03262432f, 0.06102814f, 
    0.43407467f, 0.39688683f, 0.12216880f, 0.09885069f, 0.03536588f, 0.21138480f, 0.14750239f, 0.15527350f, 
    0.02854333f, 0.12205923f, 0.09595152f, -0.07543255f, 0.07490612f, -0.14963342f, -0.02526253f, 0.14325926f, 
    -0.00348870f, -0.06036451f, 0.07350925f, 0.01575234f, 0.06861734f, 0.00003378f, -0.21856557f, -0.07933823f, 
    0.22830734f, -0.01325137f, -0.10674839f, 0.00325052f, -0.10289967f, 0.05542246f, -0.05760833f, -0.04386218f, 
    -0.03454520f, -0.15384807f, 0.11235940f, -0.09819464f, -0.14917298f, 0.09185249f, -0.01837081f, -0.08818413f, 
    -0.43633112f, -0.07689073f, -0.37292552f, 0.09553567f, 0.05565410f, -0.03364573f, -0.00555180f, -0.02384392f, 
    0.05827823f, -0.12581307f, 0.06663624f, -0.11761974f, 0.03997876f, 0.13416891f, 0.02671674f, -0.00787785f, 
    -0.06216484f, 0.08352208f, -0.06260218f, 0.16177933f, 0.38582498f, -0.05041003f, 0.18116121f, 0.09302904f, 
    -0.18205562f, -0.00378823f, 0.00834109f, -0.05178869f, 0.00827855f, -0.00933767f, -0.02612198f, -0.03102921f, 
    -0.01030807f, -0.00481739f, -0.07899780f, 0.03178971f, 0.04175745f, -0.01587792f, 0.04426064f, 0.04143616f, 
    -0.21622542f, -0.52323109f, 0.47955310f, -0.07170141f, -0.13327220f, 0.10506270f, 0.18019348f, -0.29447222f, 
    0.30884570f, 0.22034903f, 0.11830054f, -0.13803814f, 0.01229937f, 0.18282993f, 0.18169001f, -0.08686680f, 
    -0.02028284f, -0.13902193f, 0.26049355f, 0.19098350f, -0.05645490f, 0.39192036f, -0.38299075f, -0.04353918f, 
    0.47885147f, -0.01659794f, -0.10487656f, -0.15153171f, 0.05197213f, 0.11113255f, -0.04336299f, 0.07758591f, 
    0.03834787f, 0.02062710f, -0.02078941f, -0.09943420f, -0.07891344f, -0.01198455f, -0.17147271f, -0.03477614f, 
    -0.28061366f, 0.11532310f, -0.10634485f, 0.00487820f, 0.19972992f, 0.10927953f, 0.04098963f, 0.08734106f, 
    0.04757813f, 0.06577319f, -0.10359666f, 0.17589848f, 0.03717026f, 0.11771851f, -0.03266871f, -0.10726269f, 
    0.08573754f, 0.04853684f, -0.17964399f, 0.01479601f, -0.34328419f, 0.21641953f, -0.20330168f, 0.23086092f, 
    0.14004572f, -0.00454852f, 0.06510220f, 0.08055373f, 0.00964982f, 0.00960152f, -0.05671900f, 0.11349242f, 
    0.05123133f, -0.04871593f, -0.00314068f, -0.11865312f, -0.06392633f, 0.14093029f, -0.09465324f, 0.11308620f, 
    0.50824630f, 0.05157557f, 0.17292738f, 0.03387855f, -0.14181753f, -0.33022738f, -0.19019200f, 0.05831141f, 
    0.11804597f, -0.02399998f, -0.09480887f, 0.04875217f, 0.06772140f, -0.06371859f, -0.03478130f, 0.02162698f, 
    -0.10569275f, -0.02221150f, 0.29558587f, 0.14623559f, -0.03142617f, -0.16243921f, 0.26066267f, 0.04151256f, 
    -0.05473667f, 0.18826571f, -0.02040545f, 0.11324826f, -0.07066265f, -0.08622120f, -0.16911097f, -0.01072181f, 
    0.07201249f, 0.07972843f, -0.02281885f, 0.02766977f, 0.01631378f, -0.05091025f, 0.01551963f, -0.07079130f, 
    -0.55075604f, -0.01715904f, -0.09668423f, -0.10480534f, -0.09590009f, 0.10030361f, -0.04617117f, -0.09366663f, 
    -0.01665739f, -0.10525569f, 0.06327187f, -0.03130102f, -0.01666880f, 0.06612857f, 0.07741078f, 0.10756528f, 
    -0.12027233f, 0.09801863f, 0.02697855f, 0.04271983f, 0.20695779f, -0.05468088f, 0.58469325f, 0.12693565f, 
    -0.00255418f, -0.06562372f, -0.06886509f, -0.20112911f, 0.09329686f, 0.17762563f, 0.08762621f, 0.01398904f, 
    0.10405861f, 0.00691496f, 0.04758740f, 0.04454887f, -0.01774463f, 0.05135009f, -0.05382547f, -0.05764718f, 
    -0.28100950f, 0.04163918f, -0.30801454f, 0.32771876f, 0.06411978f, -0.00188417f, 0.05281588f, -0.01102043f, 
    -0.11649197f, 0.01432630f, -0.09694347f, -0.10926952f, -0.08676776f, -0.07325378f, -0.08509190f, -0.14211164f, 
    -0.15058599f, 0.10081348f, -0.04298816f, 0.22620864f, -0.18206960f, 0.09609595f, 0.24021836f, -0.27724993f, 
    -0.03217631f, -0.06872941f, -0.02562610f, -0.10271221f, -0.22858931f, -0.04982429f, 0.16501100f, 0.16744012f, 
    0.20603734f, 0.18463349f, 0.19112746f, 0.04492782f, 0.03092849f, 0.00155192f, 0.06626701f, -0.05506575f, 
    -0.18747862f, 0.28473112f, -0.06581075f, -0.11326566f, 0.05224179f, -0.11769524f, -0.10726336f, 0.00202145f, 
    -0.20753220f, -0.14021601f, -0.06610001f, 0.16798058f, 0.25301600f, 0.18205304f, -0.03180717f, 0.08015022f, 
    -0.16212101f, 0.11537123f, -0.00829135f, 0.08907272f, -0.01729974f, -0.25158587f, -0.02467687f, 0.40309799f, 
    -0.10378966f, 0.19680634f, 0.03251990f, 0.18105100f, -0.01998202f, 0.02630291f, 0.00644303f, -0.01933643f, 
    0.02968129f, -0.08184393f, 0.06528638f, -0.04695787f, 0.01959120f, -0.00611916f, 0.10542496f, 0.03009886f, 
    -0.50479388f, -0.22827862f, 0.41484663f, 0.26668435f, 0.12844461f, -0.02050901f, 0.16238825f, -0.01428430f, 
    0.24600822f, 0.03509522f, 0.02958495f, 0.01136660f, 0.07397144f, 0.07828059f, 0.10676920f, 0.01725760f, 
    0.08269339f, -0.07572579f, 0.11878383f, 0.10124270f, -0.36007115f, -0.22512460f, -0.21882264f, 0.40509573f, 
    -0.11262564f, -0.07084941f, -0.00860465f, 0.09872235f, 0.19498020f, 0.06117072f, 0.02312337f, 0.09311135f, 
    0.04514416f, 0.19912504f, 0.05676734f, 0.07347136f, 0.25986451f, -0.01018118f, 0.14571768f, 0.12501556f, 
    -0.10377171f, -0.11913967f, 0.21486820f, 0.24177763f, 0.09093963f, 0.06492068f, 0.04316356f, 0.12572074f, 
    0.05438014f, 0.07970487f, -0.04168807f, 0.10714991f, -0.07002718f, -0.08435618f, 0.00732761f, 0.05523556f, 
    0.02340115f, 0.02547434f, -0.03366137f, -0.03099675f, -0.00996245f, 0.02336811f, -0.14060181f, -0.25500906f, 
    -0.08981311f, -0.01972206f, 0.02652468f, 0.15136161f, -0.05636707f, 0.05264831f, 0.12591627f, 0.03384832f, 
    -0.10166889f, -0.16873629f, -0.03443090f, 0.04788236f, 0.15549627f, 0.13308987f, -0.02122901f, -0.02512668f, 
    0.18819378f, 0.30066633f, -0.01241059f, -0.04577592f, 0.39676857f, 0.08136696f, 0.19737890f, 0.46676627f, 
    0.03185329f, 0.00885616f, 0.11375363f, -0.01096897f, -0.00868450f, -0.21559164f, -0.07773326f, 0.11514208f, 
    -0.12625489f, 0.19725370f, 0.16177753f, 0.00200100f, -0.21035826f, -0.59901106f, -0.00399873f, 0.35607710f, 
    -0.08627240f, -0.09284214f, -0.00162269f, -0.05316403f, -0.08326323f, 0.00781879f, 0.02459843f, -0.01751514f, 
    0.01847377f, 0.05485587f, 0.14502931f, 0.04187302f, -0.02072009f, 0.05887402f, 0.09126785f, 0.03208057f, 
    -0.02943578f, -0.18155411f, 0.07280321f, 0.24784410f, 0.10004209f, 0.02399792f, 0.17596324f, 0.04788787f, 
    0.22562420f, 0.10311385f, 0.08897394f, -0.05671971f, -0.09131827f, 0.00592191f, 0.01858251f, 0.21327576f, 
    0.12772237f, 0.13372114f, 0.10048260f, 0.25317177f, -0.06174851f, -0.16202520f, 0.17200649f, 0.13043863f, 
    0.01070337f, 0.01616193f, 0.01712401f, 0.01150938f, 0.23255871f, 0.06727026f, 0.14918794f, 0.04166969f, 
    -0.00813744f, 0.04722089f, 0.02197168f, 0.16882317f, 0.06373284f, 0.19593382f, 0.18238886f, 0.11694764f, 
    -0.16738273f, 0.06726246f, -0.16721795f, 0.01844756f, 0.05714785f, 0.15080990f, 0.12718678f, 0.19965065f, 
    -0.09285957f, 0.11010993f, 0.11885092f, -0.12157922f, -0.21379498f, -0.06078902f, -0.08711884f, 0.03231326f, 
    0.06485701f, 0.11578689f, 0.01055007f, 0.09167460f, 0.17893797f, 0.23972735f, 0.35913181f, -0.06859352f, 
    0.07829089f, -0.07796524f, -0.01095416f, -0.12800728f, -0.00472599f, 0.08855034f, 0.16663554f, 0.13004556f, 
    0.13780552f, 0.06609377f, 0.19204222f, 0.00484508f, -0.13447802f, 0.08256696f, 0.08061543f, 0.07074077f, 
    0.25834784f, 0.02764795f, 0.25513631f, 0.07508148f, 0.12905556f, 0.02000957f, -0.08023827f, 0.11239908f, 
    0.02526585f, 0.00348644f, 0.02072799f, 0.03971745f, 0.06135653f, 0.04986165f, 0.07217575f, -0.12866320f, 
    0.03037456f, -0.08582056f, -0.18107708f, -0.09659880f, -0.24393782f, 0.18781324f, -0.33476743f, -0.27346408f, 
    -0.19641779f, 0.02498035f, 0.06222479f, -0.05982287f, -0.08612497f, 0.06508749f, -0.08596845f, 0.13365208f, 
    0.01731240f, 0.06189474f, -0.03493343f, -0.07491244f, -0.15419804f, -0.02472469f, 0.00704741f, -0.03405793f, 
    0.31960899f, 0.43451354f, 0.12321027f, -0.03862793f, 0.30577037f, -0.11109146f, -0.08380962f, 0.16775867f, 
    0.01254901f, -0.08275032f, -0.07358211f, -0.06455474f, 0.00188237f, -0.00155948f, 0.06003017f, 0.17346232f, 
    0.00484732f, -0.32378858f, 0.07880024f, -0.03258923f, 0.12462234f, 0.12430207f, 0.23206814f, 0.32550323f, 
    0.15575971f, 0.05231266f, 0.05031835f, -0.12859115f, -0.10776389f, -0.04225290f, 0.07738274f, 0.09088392f, 
    0.22075489f, 0.06174289f, 0.03497112f, -0.17220180f, -0.11085831f, -0.12420323f, -0.06537785f, -0.11737129f, 
    -0.08440314f, 0.11411497f, 0.17394154f, 0.07342825f, -0.04555373f, -0.04037357f, -0.16245550f, 0.10387968f, 
    0.05370734f, 0.04570509f, 0.05079072f, 0.02210907f, -0.16558680f, 0.30753696f, -0.01877353f, -0.15710413f, 
    -0.03740104f, -0.06044949f, 0.02991384f, -0.15940620f, -0.01791454f, -0.11712381f, 0.37719515f, -0.33951482f, 
    0.08415419f, -0.14973381f, 0.14177671f, 0.05525621f, -0.06823361f, -0.01169809f, 0.11893595f, 0.07647789f, 
    -0.20522684f, 0.01648376f, -0.02531758f, -0.07765106f, 0.03342338f, 0.03288589f, 0.05085951f, -0.09113111f, 
    0.33544600f, 0.13257629f, -0.76334786f, -0.15750217f, 0.02484918f, 0.04079444f, 0.20595306f, -0.07333299f, 
    -0.02797079f, 0.09951144f, -0.03208189f, -0.22746553f, -0.07816145f, 0.27368164f, 0.02974427f, 0.11740502f, 
    0.00426737f, 0.18826550f, 0.16790058f, 0.28380880f, 0.31704336f, 0.06335427f, -0.14997785f, -0.33000734f, 
    0.28657436f, 0.00623358f, -0.01087087f, -0.00517814f, 0.10027041f, 0.12708744f, -0.08655059f, -0.06453598f, 
    0.09553938f, -0.03868847f, 0.10986803f, 0.03090305f, -0.09145030f, 0.11321358f, 0.09136096f, -0.01704476f, 
    0.11007966f, 0.08347127f, -0.00466210f, -0.25324041f, -0.00204921f, 0.01706066f, -0.15082517f, 0.00556199f, 
    0.19385377f, 0.17706753f, 0.06251323f, 0.14836428f, -0.07285181f, -0.03295692f, -0.02401384f, -0.07458839f, 
    -0.11123460f, 0.13319628f, -0.10764508f, -0.10598918f, 0.25139305f, 0.23664385f, 0.02665845f, 0.24435155f, 
    0.23512268f, 0.01094577f, 0.05210042f, 0.04329897f, 0.05909988f, -0.07910670f, -0.11049057f, 0.14220884f, 
    0.10372061f, -0.10576040f, 0.05536133f, -0.18372558f, 0.11549401f, -0.17657790f, 0.08060794f, -0.04024759f, 
    -0.02433221f, -0.00297222f, -0.10416304f, 0.15233603f, -0.03011827f, -0.29242486f, 0.15542771f, 0.27342385f, 
    0.13056755f, -0.08001222f, -0.03185873f, -0.09594667f, -0.08882762f, -0.13761614f, 0.08118223f, 0.00812068f, 
    0.07405727f, 0.12709235f, 0.08586740f, -0.03566832f, 0.25270310f, 0.54868597f, -0.29390284f, -0.24842279f, 
    0.34820676f, 0.07231297f, -0.07931723f, 0.07758038f, 0.04306738f, -0.01611522f, 0.04481234f, 0.06082761f, 
    -0.02875321f, 0.01447259f, -0.05406453f, 0.01807082f, 0.02852817f, 0.22023247f, 0.18052600f, -0.01186049f, 
    -0.10664537f, 0.26471689f, -0.00754082f, -0.05915456f, 0.02489329f, 0.01624401f, -0.14652315f, 0.09898336f, 
    0.01940824f, -0.03808164f, 0.10769635f, 0.13512860f, -0.11034276f, 0.17738336f, -0.08134004f, -0.27182087f, 
    0.02851218f, 0.02802667f, 0.17120408f, -0.18369170f, 0.06671474f, -0.18503919f, -0.51664698f, -0.19789284f, 
    0.19753376f, 0.09317098f, -0.14171852f, 0.07511323f, 0.05180869f, 0.13700008f, -0.13627596f, -0.01385474f, 
    -0.01099780f, 0.16706300f, 0.09856557f, -0.13847488f, 0.11878310f, 0.19799118f, -0.13817561f, 0.12681916f, 
    0.43852130f, 0.28959253f, 0.19461298f, 0.14293645f, 0.22813502f, -0.03539682f, -0.10681252f, 0.19757643f, 
    -0.03457876f, -0.05019135f, -0.02207685f, 0.02469725f, 0.02141397f, -0.03034983f, 0.01284586f, 0.14634988f, 
    0.23582970f, 0.07506941f, 0.03724403f, -0.00005231f, -0.07719053f, 0.27252468f, -0.18521056f, 0.03466590f, 
    -0.10013085f, -0.00369458f, -0.05403311f, -0.13025886f, -0.07058412f, -0.09973747f, -0.05009996f, 0.00965138f, 
    -0.01922927f, 0.04372415f, -0.08636554f, -0.16455226f, -0.09663947f, 0.00757628f, -0.05170814f, 0.00562496f, 
    0.10967644f, -0.26486370f, -0.15583339f, -0.06343339f, -0.08808535f, 0.03153234f, 0.13836299f, 0.11561353f, 
    0.05132153f, 0.06986745f, -0.02528364f, 0.20755497f, 0.24765733f, -0.10905185f, 0.07755216f, 0.03286337f, 
    0.06460365f, -0.01651584f, -0.03884061f, 0.06275710f, -0.10637707f, 0.30428368f, -0.33169356f, -0.03166531f, 
    0.13690963f, 0.22605820f, 0.28318521f, 0.17514001f, -0.04586808f, 0.10353082f, 0.03809730f, 0.05714996f, 
    0.00537031f, -0.02916467f, 0.00720361f, -0.03459485f, 0.12017560f, -0.00858794f, 0.05283210f, -0.02260644f, 
    0.07289066f, -0.01165255f, -0.14455292f, -0.14131564f, -0.21030571f, 0.00379858f, -0.17991039f, -0.00996602f, 
    -0.00964502f, 0.01739998f, 0.08442669f, 0.09314581f, 0.00491884f, 0.03682763f, -0.10654908f, -0.00275674f, 
    -0.07117792f, -0.00000535f, 0.13171400f, -0.06017333f, -0.27586126f, -0.05316487f, -0.21647190f, 0.01674056f, 
    -0.13013175f, -0.06084552f, 0.12632515f, 0.09059025f, 0.05473065f, 0.10859325f, -0.06198739f, 0.01382974f, 
    0.05386424f, -0.13301581f, -0.12557769f, -0.14556116f, -0.04152802f, 0.02788790f, -0.11298845f, 0.07125338f, 
    0.12115265f, -0.22603057f, -0.10682493f, 0.06002232f, -0.01785681f, 0.14255708f, 0.06868248f, -0.07911342f, 
    0.13280721f, 0.09210420f, -0.05123317f, 0.01842304f, 0.05619748f, 0.03556502f, 0.06832585f, 0.12006792f, 
    0.19347577f, 0.00145481f, -0.01100833f, -0.04517773f, 0.22159532f, 0.41201976f, 0.40161103f, 0.00002051f, 
    0.17099546f, 0.01068402f, 0.00890181f, -0.02060265f, -0.03230788f, 0.02895592f, 0.09240586f, 0.00011837f, 
    0.08326620f, 0.01089519f, -0.00500648f, 0.01572889f, -0.00777399f, 0.02366734f, 0.20539904f, 0.01436478f, 
    0.64647990f, 0.42130694f, -0.30059135f, -0.16326490f, -0.07622947f, 0.06981768f, 0.16915153f, 0.22894067f, 
    -0.12953593f, 0.14227298f, 0.02394794f, -0.04125350f, -0.03290096f, 0.13880610f, 0.01573215f, -0.12700151f, 
    -0.06892277f, -0.07693093f, -0.04450863f, -0.08520965f, 0.29158214f, 0.22014180f, 0.33065987f, -0.10831241f, 
    0.26721701f, 0.08925746f, -0.07086010f, -0.04285517f, -0.08273771f, 0.00906634f, -0.02530839f, -0.06880105f, 
    -0.08080189f, -0.05239241f, 0.09712278f, -0.04648416f, -0.13121474f, 0.06150632f, 0.07693668f, -0.21975973f, 
    0.44388476f, 0.47889471f, 0.25026092f, 0.00788686f, 0.13277432f, -0.06934252f, -0.07345907f, -0.02321478f, 
    0.10934202f, 0.10534301f, -0.02530606f, -0.20116134f, -0.00213415f, 0.03551261f, -0.00185993f, -0.05182534f, 
    0.02042654f, 0.00049747f, 0.11009267f, 0.15810515f, -0.37312540f, -0.22386989f, -0.10014900f, 0.00102859f, 
    -0.20198727f, -0.10804290f, 0.04946430f, -0.05030421f, 0.01672263f, -0.00902766f, -0.09287221f, 0.04359592f, 
    0.10413595f, -0.09319360f, -0.04635400f, -0.06211500f, -0.00609553f, 0.13085213f, -0.05513556f, 0.03984642f, 
    -0.06751271f, 0.19318479f, 0.02648444f, 0.14244071f, -0.32304272f, -0.13684656f, -0.06778798f, -0.04884133f, 
    0.15509826f, -0.04283807f, -0.05455511f, 0.19290656f, -0.05288741f, 0.10847852f, 0.06140329f, -0.13496739f, 
    0.04469498f, 0.12086466f, -0.04422931f, 0.03176916f, 0.18162471f, 0.50769866f, 0.22018999f, 0.00280308f, 
    0.20927829f, 0.12640075f, -0.03081349f, -0.07381623f, 0.06665985f, 0.01313064f, 0.10845844f, 0.01199254f, 
    -0.02693878f, -0.08482551f, -0.07490947f, -0.16146104f, -0.02589634f, 0.05273060f, 0.11601956f, 0.01123155f, 
    0.14383057f, 0.46461251f, 0.19941857f, 0.10275186f, 0.08779023f, 0.18405916f, -0.13544379f, 0.05885572f, 
    -0.04296730f, -0.04670117f, 0.01938982f, 0.05222502f, -0.10274293f, -0.01771920f, 0.03138154f, -0.09811261f, 
    -0.01569498f, -0.06157898f, 0.03569478f, -0.01882629f, 0.16249664f, 0.11834960f, -0.01434567f, -0.01465450f, 
    0.10949547f, 0.03066788f, -0.02957467f, 0.00768065f, 0.08399247f, 0.01256351f, -0.16043621f, -0.10432702f, 
    -0.10745879f, -0.08930945f, -0.03854750f, -0.01912626f, -0.12178662f, -0.13410173f, 0.06021735f, -0.12573072f, 
    -0.13090841f, -0.23717543f, -0.29567552f, -0.17392665f, -0.14343882f, -0.25439554f, -0.11432876f, -0.09961312f, 
    0.12450031f, -0.00152233f, -0.02670417f, 0.07352161f, 0.08138659f, 0.01030160f, -0.08778107f, -0.03857672f, 
    -0.11508479f, -0.07537571f, -0.15322551f, -0.03688775f, -0.33528739f, -0.04122360f, -0.33244139f, -0.01016508f, 
    -0.05722671f, -0.00189507f, 0.17611250f, 0.10920195f, -0.06928426f, 0.15007299f, 0.02488077f, -0.04161734f, 
    -0.10546278f, -0.01801858f, -0.03065855f, -0.00226569f, 0.15420848f, 0.01123619f, -0.04622079f, -0.06006875f, 
    -0.03854693f, 0.01594664f, -0.02745398f, -0.06565464f, -0.01564829f, 0.00182975f, -0.06049060f, -0.05084021f, 
    0.03140955f, 0.01666600f, 0.03513372f, -0.03512778f, 0.04305373f, -0.03702318f, 0.02328256f, -0.02755678f, 
    -0.05266976f, -0.03423320f, 0.01098866f, 0.00859649f, -0.04699249f, -0.06382158f, -0.02569089f, -0.05655315f, 
    -0.01998584f, -0.01018433f, -0.02833131f, -0.04651451f, -0.06171294f, -0.00849707f, -0.05807658f, 0.01190293f, 
    0.02349753f, -0.02496383f, 0.04288255f, 0.02735164f, 0.02133297f, -0.03324599f, 0.03148161f, -0.03734799f, 
    -0.04316045f, 0.02928649f, 0.02396753f, 0.04024312f, 0.03668917f, 0.00739963f, -0.03798743f, 0.00260342f, 
    -0.06072425f, -0.02567805f, -0.00773270f, -0.03232515f, 0.02206954f, 0.00816915f, 0.02336997f, 0.01074408f, 
    -0.02396956f, 0.02048201f, -0.00801951f, 0.01394705f, 0.02671461f, 0.03579408f, 0.03808533f, -0.03159911f, 
    -0.00899867f, 0.02369766f, -0.00038153f, -0.02670921f, 0.00350317f, -0.02528990f, 0.01854496f, -0.01886936f, 
    -0.02912557f, 0.01340315f, -0.02861575f, 0.03204456f, -0.03482416f, -0.05687798f, 0.00288469f, 0.01935138f, 
    -0.01137044f, 0.01919388f, 0.03627549f, -0.02673201f, 0.03619178f, -0.02081706f, -0.02367571f, 0.04326744f, 
    -0.00667840f, -0.03440646f, 0.01312264f, 0.04418628f, -0.03010567f, -0.04272991f, 0.02517529f, 0.03027363f, 
    0.03833331f, 0.02847059f, -0.01828483f, -0.03218233f, -0.00429620f, 0.01735706f, 0.03905591f, -0.03176219f, 
    0.02980516f, -0.04755677f, 0.04047262f, -0.00083810f, 0.01874029f, 0.03701897f, 0.01499042f, 0.01172063f, 
    -0.04294053f, -0.06186736f, -0.02205525f, 0.02930431f, 0.04136173f, -0.04637349f, -0.06441761f, 0.04133958f, 
    0.03424582f, -0.05586968f, -0.03422113f, 0.04209936f, -0.06002693f, -0.04064074f, -0.00847617f, -0.05259196f, 
    -0.04567318f, -0.01048023f, -0.01894011f, -0.05243368f, -0.06334148f, -0.02516534f, 0.01915657f, -0.06203222f, 
    -0.02091609f, -0.03106131f, -0.00888304f, -0.01816495f, -0.03818710f, -0.01722804f, -0.06047112f, -0.02096936f, 
    -0.04574419f, -0.02402860f, 0.01250374f, -0.05976778f, 0.01023957f, 0.04013895f, -0.06308022f, 0.01352543f, 
    0.04365250f, 0.02972570f, -0.06459565f, -0.02491155f, 0.01310687f, -0.01324219f, -0.05286347f, 0.00135567f, 
    -0.02583909f, -0.00035091f, -0.02862860f, 0.01298879f, 0.01333893f, 0.04032363f, -0.03628686f, -0.04962878f, 
    0.00146293f, -0.01759194f, -0.00665415f, -0.04904892f, 0.02449148f, -0.04666768f, -0.00452494f, 0.02545111f, 
    0.03700531f, 0.04528663f, 0.00369220f, 0.02154627f, -0.00903786f, -0.04155540f, -0.03652352f, -0.06493327f, 
    -0.06636691f, 0.00746478f, -0.03841773f, -0.01322985f, -0.02192937f, -0.00067530f, 0.03349093f, 0.01752093f, 
    0.00452728f, -0.02848885f, 0.04391312f, -0.01016006f, 0.02006765f, 0.00505213f, -0.00850825f, 0.02410293f, 
    -0.04243774f, 0.01090101f, 0.01174282f, -0.00730091f, -0.01106546f, -0.04528004f, 0.03804788f, -0.02882210f, 
    0.01407143f, -0.05110065f, -0.06357394f, 0.00452403f, 0.02284456f, -0.00772917f, -0.05149560f, -0.02893349f, 
    -0.05039312f, -0.01295040f, -0.02169680f, 0.02899833f, 0.00422724f, 0.01554746f, -0.03296847f, 0.02900128f, 
    -0.01284528f, -0.03132519f, -0.01693296f, -0.01622527f, 0.00150870f, -0.03935496f, 0.04423944f, 0.01993995f, 
    0.01954487f, -0.00206926f, -0.02803654f, -0.05397670f, -0.03337271f, 0.01631281f, -0.04220878f, -0.06097635f, 
    0.00988786f, -0.00499780f, -0.04147397f, -0.01829553f, 0.02409543f, 0.03669114f, -0.00049774f, 0.00785266f, 
    -0.01036576f, -0.01860303f, 0.04129462f, 0.02259940f, -0.02383640f, 0.03227806f, 0.01367762f, 0.03823239f, 
    0.03387236f, -0.03178317f, -0.03788465f, -0.05179531f, 0.01586398f, 0.00675280f, 0.00574635f, -0.00724762f, 
    -0.04227512f, -0.00715831f, -0.05900593f, -0.02141686f, 0.02733159f, -0.03629488f, -0.05777804f, -0.01387540f, 
    0.00541081f, 0.00837194f, -0.05265726f, -0.04167182f, 0.03244969f, -0.04469555f, 0.01779071f, -0.06121275f, 
    -0.06001712f, -0.03282355f, 0.03111276f, -0.02521120f, -0.02842640f, 0.01767662f, 0.00068601f, -0.01532014f, 
    0.01162234f, -0.01814602f, 0.01658167f, 0.00311689f, -0.04811913f, 0.03489713f, -0.02882696f, -0.01559740f, 
    0.00335835f, -0.02635421f, 0.04642049f, -0.01163554f, 0.04345516f, -0.03844848f, -0.01728369f, 0.03998064f, 
    0.04033038f, -0.02855121f, -0.04014447f, -0.02418230f, -0.04440062f, -0.05569292f, 0.04032224f, -0.02937697f, 
    -0.02522644f, -0.05746927f, -0.05969717f, -0.05382811f, -0.04309259f, 0.00105172f, -0.00914759f, 0.03486242f, 
    0.03281770f, -0.02666332f, -0.05451253f, 0.00151635f, 0.00626832f, -0.00541812f, -0.04500705f, 0.02681111f, 
    0.02765777f, 0.02658036f, 0.02410210f, -0.00090584f, -0.02437933f, -0.03479100f, 0.02433006f, -0.00859486f, 
    0.02140496f, -0.05506291f, 0.00103639f, -0.03716224f, -0.05925554f, -0.03645405f, -0.01171788f, -0.00668863f, 
    -0.00970469f, 0.00718990f, -0.06102997f, -0.04313722f, -0.04586648f, -0.03983845f, -0.00219703f, 0.01710108f, 
    -0.04356850f, 0.02521645f, -0.06276453f, -0.01520030f, -0.04913035f, 0.03345195f, 0.04660825f, 0.02031953f, 
    -0.01022140f, 0.04699895f, -0.05841096f, -0.03051194f, -0.03034813f, -0.02030853f, 0.01736396f, -0.03860236f, 
    0.04527750f, -0.00095997f, 0.04721899f, 0.03508859f, 0.03556047f, -0.00801310f, -0.01643467f, -0.01864300f, 
    -0.04127305f, 0.02789560f, 0.01459328f, 0.03182655f, 0.00698862f, -0.01969668f, -0.02806986f, -0.02506971f, 
    -0.03825954f, 0.03535307f, 0.04821764f, -0.05202069f, 0.02625609f, -0.01042766f, -0.01544358f, 0.04103288f, 
    0.04138681f, -0.02256071f, 0.00245514f, -0.04217925f, 0.01381924f, -0.01681211f, 0.03970802f, 0.02500472f, 
    0.02007091f, 0.02620735f, -0.03305464f, 0.00369777f, -0.03123377f, -0.03045576f, -0.00030799f, 0.04020620f, 
    -0.05434445f, -0.03036263f, 0.02708565f, 0.02141779f, -0.02885032f, 0.04261188f, -0.01011558f, -0.00977701f, 
    -0.03274222f, 0.03442669f, -0.05829362f, -0.02953622f, 0.03889880f, -0.00677823f, -0.03267018f, 0.01376165f, 
    -0.00840667f, -0.04920511f, 0.02928077f, 0.02837631f, -0.03078007f, -0.01698341f, -0.04509431f, 0.00967775f, 
    -0.06053039f, -0.02360260f, -0.00856520f, 0.02676443f, -0.05468360f, 0.01090432f, -0.03750794f, -0.04615638f, 
    0.04266203f, 0.02560813f, -0.01806558f, 0.01662504f, -0.05580528f, 0.04376379f, 0.00967983f, 0.00613022f, 
    0.04988671f, 0.04263716f, -0.00068788f, -0.06266834f, 0.04369828f, -0.04619395f, 0.00327666f, 0.01329049f, 
    0.02348516f, 0.00280192f, 0.00369585f, 0.00571636f, -0.02244687f, -0.00047854f, -0.05402238f, -0.02310778f, 
    -0.01455184f, -0.03501735f, 0.00201807f, 0.01066531f, 0.01625042f, -0.06164113f, -0.00827691f, 0.03135968f, 
    0.04592099f, -0.01586433f, 0.04212604f, -0.05656876f, -0.00399283f, -0.04500217f, 0.02354579f, -0.00231988f, 
    0.04810962f, 0.01108144f, 0.02077370f, 0.03276397f, 0.01276445f, -0.01008883f, -0.04119967f, -0.06063128f, 
    -0.04818077f, -0.00465465f, 0.01039222f, -0.05686324f, -0.04851927f, 0.01990133f, 0.02143756f, -0.06154022f, 
    -0.06118959f, 0.01963586f, -0.00713446f, -0.01954499f, 0.01556249f, 0.00681602f, 0.00233829f, 0.03009809f, 
    -0.02073683f, -0.04639809f, 0.04975438f, -0.05834214f, -0.00292826f, -0.05944344f, -0.05159885f, 0.04420875f, 
    -0.01686034f, -0.04503373f, 0.00433972f, -0.05256930f, 0.02204879f, -0.00492015f, 0.03541154f, 0.03002890f, 
    0.00286208f, -0.00200881f, -0.04616621f, -0.01812130f, 0.02675123f, -0.05894141f, 0.00049907f, -0.02911788f, 
    0.02982614f, -0.03414309f, 0.02098227f, -0.04350974f, 0.00665927f, -0.03467972f, 0.02232010f, 0.02041216f, 
    -0.00310568f, 0.00910732f, 0.00601745f, -0.01533235f, 0.04072770f, -0.05538665f, -0.04633478f, -0.05293794f, 
    0.00673060f, -0.03394680f, -0.04147358f, -0.03465844f, 0.02818187f, -0.01099270f, -0.02470833f, -0.04586965f, 
    -0.01052991f, -0.01662402f, -0.05746166f, -0.03586622f, -0.02637213f, 0.00012896f, -0.01796529f, 0.02999551f, 
    0.01972928f, -0.06335775f, -0.03075499f, -0.01311790f, -0.01581345f, 0.01701718f, 0.04020338f, 0.03141516f, 
    0.02747537f, -0.01547098f, -0.02003396f, 0.02370595f, 0.03350917f, 0.02544441f, 0.01359012f, 0.04776081f, 
    -0.00534692f, 0.03655661f, -0.03822021f, -0.02887510f, -0.05386672f, 0.02289924f, 0.03908061f, -0.04637892f, 
    0.04405038f, 0.01236818f, -0.01981018f, -0.04394101f, -0.00925844f, 0.03442656f, -0.03991756f, -0.02499161f, 
    0.04519618f, -0.02057172f, -0.05583922f, -0.01878738f, -0.04789307f, 0.02386599f, 0.01649810f, -0.02168911f, 
    0.04253907f, -0.03021740f, 0.00856715f, -0.03602471f, 0.00227295f, 0.04708123f, -0.05911194f, -0.03255125f, 
    -0.04901409f, -0.03410898f, -0.03105944f, -0.03418533f, 0.02420186f, -0.05655527f, -0.02195365f, -0.03232777f, 
    -0.01052748f, -0.00335785f, 0.03632328f, -0.04338372f, 0.03698748f, -0.02600777f, 0.00922089f, 0.03451571f, 
    0.04091664f, 0.04746700f, 0.01389307f, 0.00592874f, 0.02085623f, -0.03432686f, 0.02484932f, 0.02480642f, 
    -0.01595535f, 0.01078095f, -0.00034325f, 0.02001404f, -0.02940951f, -0.02534758f, 0.03325200f, -0.04879737f, 
    -0.02542889f, -0.01271777f, 0.01855340f, -0.05782759f, -0.02923979f, 0.02968031f, 0.01914195f, -0.05858333f, 
    -0.01944800f, -0.00425448f, 0.03128424f, -0.01386210f, 0.03100211f, -0.02608800f, -0.01976124f, -0.03123162f, 
    -0.01468339f, -0.00275889f, 0.01253213f, 0.04108438f, -0.00716330f, 0.02703019f, 0.03896730f, -0.01997961f, 
    0.04297730f, 0.04945075f, 0.01662262f, 0.03841529f, -0.04978349f, 0.04206894f, -0.04092028f, -0.01942495f, 
    0.04494107f, 0.02904582f, -0.02592434f, -0.00431379f, 0.02205623f, 0.03673392f, -0.00520797f, 0.01229151f, 
    0.00597760f, -0.04235255f, -0.01083063f, -0.06269614f, 0.03282838f, 0.03515286f, 0.03729902f, 0.02597860f, 
    0.03019991f, 0.03461198f, 0.01135447f, -0.06232639f, -0.01384954f, 0.01793402f, -0.01020918f, -0.02551802f, 
    0.03023401f, 0.01334158f, 0.01074260f, -0.02175067f, 0.03609940f, 0.00570626f, 0.02361212f, 0.02635548f, 
    -0.02797731f, -0.04604471f, 0.03586384f, 0.01537654f, -0.00227741f, 0.04577169f, -0.03745286f, -0.00718095f, 
    0.04648217f, 0.02136312f, 0.00620490f, 0.04387120f, 0.01155563f, -0.05195325f, -0.06564886f, -0.05044619f, 
    0.03858113f, 0.02435206f, 0.01049526f, 0.04460965f, -0.05790561f, 0.03575557f, -0.05904004f, -0.05322400f, 
    -0.03371093f, -0.03510709f, 0.01162425f, -0.04495024f, 0.04473234f, -0.04123822f, -0.00406602f, -0.04457447f, 
    0.02908530f, -0.00037093f, -0.03920127f, 0.00347626f, -0.03658689f, 0.03084010f, 0.00534352f, -0.01590009f, 
    0.00564140f, 0.02142602f, -0.00428313f, 0.04007252f, -0.00213344f, -0.00692671f, -0.03612769f, -0.04555974f, 
    0.04812270f, 0.02430301f, 0.03691130f, -0.03160213f, 0.01035588f, -0.04123593f, -0.06224944f, 0.02023439f, 
    0.01280727f, 0.04332921f, 0.02637784f, -0.04344995f, -0.05204150f, 0.01355662f, -0.00368084f, -0.05103128f, 
    -0.01756270f, -0.05918806f, 0.04275281f, -0.02620120f, -0.03105701f, 0.00435599f, -0.05369128f, -0.03289068f, 
    0.03178419f, 0.00059372f, 0.04232531f, 0.04076628f, 0.04748876f, -0.04884558f, -0.02649311f, -0.04663138f, 
    -0.05763502f, -0.00809613f, -0.06055265f, 0.04612692f, -0.00198617f, 0.01387822f, -0.03971346f, -0.05515685f, 
    -0.01345970f, -0.00829707f, 0.04602828f, 0.00495142f, -0.00884481f, -0.03830390f, -0.04256685f, -0.01218156f, 
    0.05207166f, 0.03917080f, -0.01178130f, -0.05797961f, 0.02937317f, 0.04482461f, -0.00675616f, -0.02975941f, 
    -0.03372972f, 0.00601168f, -0.04379176f, -0.02082943f, 0.01312394f, -0.02287972f, -0.04436832f, -0.02206729f, 
    -0.04809025f, -0.05957452f, 0.02773302f, -0.03681305f, -0.03018482f, 0.02617740f, -0.01266157f, -0.02124653f, 
    0.03341899f, 0.02171697f, 0.02763334f, 0.02273752f, 0.01058067f, 0.02737838f, -0.02697204f, -0.03481279f, 
    -0.03848808f, 0.00965276f, 0.02634219f, -0.05406745f, -0.02154281f, -0.03858302f, -0.00983973f, -0.04870090f, 
    -0.03189545f, -0.01433187f, -0.04312414f, -0.04335213f, 0.02012957f, 0.03973205f, 0.03692281f, 0.01958144f, 
    0.04254425f, -0.02244639f, -0.04022659f, 0.00014912f, 0.03192926f, 0.00813909f, -0.06011226f, -0.02116609f, 
    -0.01205364f, -0.01366248f, -0.05828125f, -0.00758306f, 0.02824765f, 0.03141674f, 0.02190057f, -0.05854448f, 
    -0.00971898f, -0.06093073f, 0.00772184f, 0.00229894f, 0.02067180f, -0.06002013f, 0.02894400f, -0.00290273f, 
    -0.01778794f, -0.05967754f, -0.00472309f, 0.03216666f, -0.05241578f, 0.04137632f, 0.00726140f, -0.06077154f, 
    -0.05194180f, -0.01857428f, 0.03860861f, -0.04516632f, 0.01023939f, 0.04994126f, 0.03520649f, 0.01051058f, 
    0.03585309f, 0.04107403f, 0.01377323f, -0.00522261f, -0.00130690f, -0.03939901f, -0.05703600f, -0.00448790f, 
    0.00035349f, -0.04397142f, -0.00625544f, -0.05066275f, 0.04385444f, -0.00175373f, 0.03612207f, 0.00390354f, 
    0.02411744f, 0.03109369f, -0.04066534f, 0.01271962f, -0.02001502f, 0.03519252f, 0.01103182f, 0.01572339f, 
    0.03097339f, -0.05276916f, -0.01586417f, -0.04062792f, -0.05037480f, -0.01211963f, -0.05438070f, 0.04258629f, 
    -0.04941970f, -0.04757687f, -0.00793513f, -0.03350504f, 0.00882347f, -0.02231496f, -0.02322281f, -0.02563609f, 
    -0.01180353f, 0.00093639f, -0.03974550f, 0.02718227f, -0.06019156f, -0.04158890f, -0.04232673f, -0.01081690f, 
    -0.01414107f, -0.01302636f, -0.01258036f, 0.03683183f, 0.01637725f, -0.00447451f, -0.04501330f, -0.00759661f, 
    -0.01803339f, -0.03890842f, -0.02629717f, 0.01384554f, -0.01242042f, 0.04135859f, -0.02409756f, 0.02287678f, 
    0.02280828f, -0.00628833f, -0.01597564f, -0.03958559f, 0.02170422f, 0.01560094f, 0.02296256f, -0.00336855f, 
    -0.05674489f, 0.01960438f, -0.02786287f, 0.01164922f, -0.04520961f, 0.00779120f, -0.05935276f, -0.05652250f, 
    0.02241062f, 0.00983978f, -0.04494856f, -0.02464526f, 0.04898278f, 0.00323404f, 0.03646002f, 0.04642497f, 
    0.02508468f, -0.00885643f, -0.01987622f, 0.04714404f, 0.00411096f, 0.01379160f, 0.02958573f, 0.03523761f, 
    -0.02699926f, 0.03914157f, -0.03458346f, 0.04057588f, 0.01672499f, -0.00378946f, -0.04904561f, 0.00782045f, 
    -0.05279201f, -0.00766466f, -0.03333000f, -0.01745089f, -0.02192741f, -0.03487911f, 0.05090818f, -0.00109679f, 
    0.00490196f, 0.03535739f, 0.04360456f, -0.03161589f, -0.02672986f, 0.02171306f, -0.03066014f, -0.00187126f, 
    -0.04245232f, -0.04984071f, 0.02389739f, -0.04424918f, -0.02158668f, -0.05859962f, -0.05119152f, -0.02638170f, 
    -0.02039758f, -0.04377410f, -0.04208492f, -0.02495125f, -0.03108952f, 0.03186823f, 0.00462346f, -0.05471575f, 
    0.03876911f, -0.03267979f, 0.03565185f, 0.01737762f, -0.01988017f, -0.00864209f, -0.00376027f, -0.05742319f, 
    -0.01351021f, -0.02296994f, 0.02133099f, 0.02555062f, 0.04320082f, -0.02243706f, -0.02968031f, -0.02145064f, 
    0.03459515f, -0.00393976f, -0.02072119f, -0.00466873f, -0.01615373f, 0.04734930f, -0.02057914f, 0.05275811f, 
    -0.05859850f, 0.00842346f, 0.00219664f, 0.03307294f, 0.03875401f, -0.06012735f, 0.01634785f, -0.03102460f, 
    -0.03829404f, 0.03230767f, -0.04744740f, 0.02577438f, -0.05599925f, -0.04460383f, 0.00930924f, 0.03758788f, 
    -0.00548052f, -0.00486297f, -0.01219549f, -0.00893919f, -0.00594886f, -0.00690572f, 0.00967382f, 0.04915152f, 
    -0.01067230f, 0.01880423f, 0.04228601f, -0.04211692f, -0.05534885f, 0.03208108f, 0.03115523f, -0.05692669f, 
    -0.00350471f, -0.01112279f, 0.02502907f, 0.00052755f, 0.00699328f, -0.01847362f, 0.00888994f, -0.05232437f, 
    -0.04579406f, 0.03677348f, 0.00634833f, 0.04242894f, 0.01302638f, 0.00067931f, 0.04726397f, 0.02351751f, 
    -0.03653612f, -0.02467212f, 0.02305191f, -0.02032107f, -0.02172076f, 0.01291826f, -0.02952946f, -0.04375622f, 
    0.04930764f, -0.02865282f, -0.00420411f, 0.04774903f, -0.03091358f, 0.02473707f, 0.03626909f, -0.02021080f, 
    -0.02332292f, -0.00935684f, 0.04142692f, -0.01279983f, -0.03764956f, -0.01395904f, 0.02151760f, 0.04346054f, 
    0.04057855f, 0.05170960f, -0.01004708f, 0.03239282f, -0.04270513f, 0.03315566f, -0.02930286f, 0.00808601f, 
    -0.03396280f, -0.02929455f, -0.04601936f, -0.03113435f, -0.05876790f, -0.01668725f, -0.00892591f, 0.00524098f, 
    0.01497970f, -0.04289750f, -0.04217769f, 0.00901580f, -0.00363011f, -0.04566995f, -0.03850633f, 0.04799844f, 
    0.00701888f, -0.00673006f, 0.00360124f, 0.04032494f, -0.03228532f, -0.03347575f, 0.02656537f, 0.04635833f, 
    0.01894059f, -0.05266142f, -0.03222727f, 0.04876866f, 0.01291840f, -0.01005598f, -0.03854958f, 0.03869434f, 
    0.03138663f, -0.00643383f, 0.01175410f, 0.02962548f, 0.04104545f, -0.03075661f, 0.03167711f, -0.04453969f, 
    -0.05100260f, -0.00415239f, -0.05375497f, 0.04762632f, 0.03786397f, -0.04435214f, -0.03008195f, -0.04164064f, 
    -0.02980440f, 0.01214286f, -0.04386321f, -0.04401040f, 0.02661819f, 0.04523684f, 0.02220341f, 0.05160611f, 
    0.05548068f, -0.03807830f, -0.06081588f, -0.05001432f, 0.03213610f, -0.02667665f, 0.04899101f, 0.04648758f, 
    -0.02586326f, -0.05705100f, 0.01985320f, -0.02845680f, -0.00916990f, 0.05139206f, -0.03726972f, 0.02232878f, 
    -0.04200686f, 0.01205922f, -0.02581883f, -0.00765383f, 0.00030557f, -0.04376918f, -0.00662511f, -0.05365933f, 
    0.02285784f, -0.01885063f, -0.02314726f, -0.04080859f, -0.03187005f, -0.00252951f, 0.05160719f, -0.03897679f, 
    0.03099715f, -0.04635280f, 0.00538717f, 0.00473555f, -0.04878259f, 0.02673656f, -0.02169726f, -0.02880463f, 
    -0.02737782f, -0.05097450f, -0.01039428f, -0.05388312f, 0.02534292f, -0.02377928f, -0.02321769f, -0.01185469f, 
    0.00016497f, -0.01936333f, -0.05709447f, -0.02651499f, -0.00217338f, 0.04253649f, 0.04171712f, 0.03458588f, 
    -0.00179848f, -0.03180406f, -0.02587517f, 0.00416385f, 0.02400053f, -0.03931862f, 0.00950782f, 0.00107481f, 
    -0.00316699f, 0.02109011f, 0.03112406f, 0.00118742f, 0.04349285f, 0.01790266f, 0.02650292f, -0.01281688f, 
    -0.03193692f, -0.01602065f, 0.02049121f, -0.02409902f, 0.04500149f, 0.01190151f, 0.01100910f, -0.02149699f, 
    0.04925343f, -0.06059258f, 0.03455744f, -0.02730581f, 0.02616370f, -0.01157197f, 0.03773892f, -0.02139611f, 
    -0.01499692f, 0.00189665f, 0.00918376f, 0.03482464f, 0.04839776f, -0.05654622f, 0.02246632f, 0.00304792f, 
    -0.03072126f, -0.00008449f, 0.01871452f, 0.04297734f, 0.04448226f, 0.01633569f, -0.02054522f, 0.04220797f, 
    -0.02628335f, -0.02248318f, -0.06018925f, -0.03244447f, -0.05300276f, -0.00700727f, -0.04763077f, 0.04808798f, 
    -0.03544628f, 0.04803559f, -0.00148212f, 0.01701100f, -0.04617774f, -0.05084499f, 0.01331334f, 0.01288590f, 
    0.03395266f, -0.02043706f, -0.06186499f, 0.01046089f, -0.04655185f, -0.05509282f, 0.01388536f, 0.04358324f, 
    -0.02447068f, -0.04400321f, -0.03426210f, -0.05903063f, -0.04265642f, -0.03498782f, -0.00895639f, 0.03149178f, 
    -0.01641625f, -0.01403913f, 0.02477017f, -0.04251264f, 0.04359494f, 0.00579335f, 0.00262562f, -0.04136378f, 
    -0.01210630f, -0.06147203f, 0.00537992f, -0.04594043f, 0.04728793f, 0.01567309f, 0.02174320f, -0.05139371f, 
    0.04178314f, 0.00722555f, -0.03631106f, -0.00522539f, -0.03671046f, -0.03243697f, -0.05532943f, -0.00304705f, 
    0.02691852f, -0.05598296f, 0.05051086f, 0.02969884f, 0.03736309f, -0.00932126f, -0.00527092f, -0.04501179f, 
    0.04020354f, -0.04442983f, -0.04056785f, 0.03398144f, 0.01636893f, 0.00208290f, -0.01113223f, -0.04635472f, 
    0.00766929f, -0.04427998f, -0.03523239f, 0.02215106f, 0.03366780f, -0.03239319f, -0.05782236f, 0.04306275f, 
    -0.06063214f, -0.00778748f, 0.03344085f, 0.01232744f, -0.03358362f, -0.01397364f, 0.01004846f, 0.04172553f, 
    -0.01011778f, -0.03424359f, 0.01681262f, 0.02984435f, 0.03257160f, 0.03422998f, -0.03988349f, -0.05095307f, 
    0.03318994f, -0.01030472f, -0.01260188f, -0.05802085f, 0.01790040f, -0.02903698f, -0.05938532f, -0.02495055f, 
    -0.03877267f, 0.03844609f, -0.04566345f, -0.03997261f, 0.04732605f, 0.02720224f, 0.00589780f, -0.02343317f, 
    -0.05917552f, -0.00346030f, 0.02296238f, 0.02204129f, -0.01827945f, -0.05626112f, -0.03873060f, -0.00096191f, 
    0.03838000f, -0.04473110f, -0.05090631f, 0.03360715f, -0.00428137f, -0.00156555f, -0.04866794f, -0.05257209f, 
    -0.01392665f, -0.04397635f, 0.01988801f, 0.03320229f, -0.02828943f, -0.03837985f, -0.00874040f, 0.01258316f, 
    -0.00020571f, 0.01057998f, -0.03895474f, 0.03878228f, -0.01741038f, 0.04813613f, 0.00774379f, 0.00699551f, 
    0.00794356f, -0.02700213f, 0.02556750f, 0.03224427f, -0.03928024f, -0.00736581f, -0.03895053f, -0.02254926f, 
    -0.04052938f, -0.03657956f, -0.04278263f, -0.03429902f, -0.02277733f, -0.04741938f, -0.00652510f, 0.00114238f, 
    -0.00780277f, -0.05351017f, 0.03626091f, -0.01307005f, 0.01984468f, 0.01106234f, 0.04816705f, -0.02401448f, 
    -0.03856437f, 0.01876941f, 0.01651466f, -0.04839303f, 0.00342280f, -0.01513036f, -0.02454960f, -0.03315099f, 
    0.02077344f, 0.02331069f, -0.02011250f, -0.02890954f, -0.03242308f, 0.00908228f, 0.02349779f, 0.04635876f, 
    -0.00913476f, -0.02711017f, 0.03869724f, -0.05058604f, 0.02812547f, -0.04347388f, 0.03582929f, -0.03201524f, 
    0.03493861f, -0.00202468f, 0.03282960f, 0.00170166f, -0.03712597f, -0.01957834f, -0.04950142f, 0.02694404f, 
    0.02191217f, -0.05683767f, -0.00640283f, 0.04549803f, -0.05838167f, 0.03590791f, -0.00335627f, 0.02040192f, 
    -0.01789793f, -0.00807190f, 0.01261661f, -0.03032965f, -0.03839083f, 0.04023159f, 0.02975623f, 0.01763376f, 
    -0.01547019f, 0.02856634f, 0.04449670f, 0.02856001f, -0.06045385f, 0.05201339f, 0.00875625f, 0.03792338f, 
    -0.03144482f, 0.01343725f, 0.04224623f, -0.02264572f, -0.04639677f, -0.02505940f, -0.00355383f, -0.03588337f, 
    -0.05486934f, 0.00003983f, -0.02380901f, 0.01298237f, 0.02362587f, 0.05036008f, -0.02187875f, 0.03948899f, 
    0.03362164f, 0.00416387f, -0.03947264f, -0.03382276f, -0.02231984f, -0.00194472f, -0.00439565f, 0.00880349f, 
    -0.00297181f, 0.03203268f, -0.05399440f, -0.02223064f, -0.00690124f, -0.02947151f, 0.04794555f, -0.05009805f, 
    -0.03925326f, 0.03115800f, -0.05019789f, 0.02166845f, 0.02684427f, -0.04780246f, -0.00581213f, -0.01487449f, 
    0.04407207f, -0.03845960f, -0.01758098f, 0.03721253f, 0.04680337f, -0.04613943f, 0.04282521f, 0.04820461f, 
    -0.03358737f, -0.00673077f, -0.04838882f, -0.04366994f, -0.03689379f, 0.04356264f, -0.01577318f, -0.05342657f, 
    -0.01005337f, -0.01928587f, -0.03128894f, -0.05731229f, 0.01700440f, 0.01349940f, 0.00703103f, 0.04463193f, 
    -0.02704380f, -0.04156968f, -0.04191046f, -0.00666257f, -0.01696021f, -0.01724011f, 0.04129570f, -0.01506123f, 
    -0.03681926f, -0.05793382f, -0.01164291f, -0.05853763f, 0.05176497f, -0.01969382f, -0.01055717f, 0.00157302f, 
    -0.02400093f, -0.04389300f, -0.04935834f, -0.00656111f, -0.01003240f, -0.03980269f, -0.05362598f, -0.01298464f, 
    0.16965875f, -0.03601837f, -0.12097745f, 0.16945462f, -0.12075826f, -0.08842371f, 0.07530017f, -0.02335635f, 
    -0.18094262f, 0.03913803f, 0.07470726f, -0.02392574f, 0.00565425f, -0.15610629f, 0.15403444f, 0.05217027f, 
    0.00688080f, 0.03215814f, -0.02288632f, -0.07080741f, -0.44889981f, -0.12996358f, -0.44687906f, -0.19206986f, 
    0.05807406f, 0.07823116f, 0.02824616f, 0.25378093f, 0.00096826f, 0.27039817f, 0.07380942f, -0.01776626f, 
    -0.12083583f, -0.05319951f, -0.03377844f, 0.05145731f, 0.15090154f, 0.04175496f, -0.02739887f, 0.10725857f, 
    -0.01963850f, -0.15044986f, 0.65671188f, -0.14091967f, -0.16831982f, 0.07654649f, 0.01269643f, -0.12884137f, 
    0.03322817f, 0.02516282f, 0.05561787f, 0.08964770f, 0.07660974f, -0.01178746f, -0.02888172f, -0.03530657f, 
    -0.14567730f, 0.16864263f, -0.02366330f, -0.23042700f, -0.11841999f, -0.00347957f, -0.40686086f, 0.11411170f, 
    -0.07987630f, 0.08640871f, 0.01901567f, 0.08038332f, -0.04985777f, -0.03501206f, 0.18427147f, -0.01964074f, 
    0.13766344f, 0.12887748f, -0.05582125f, -0.13107294f, 0.04645180f, 0.05746152f, 0.01148529f, -0.16933544f, 
    0.18180701f, -0.36969402f, -0.20060153f, 0.15019487f, 0.05529860f, 0.02149797f, 0.07586601f, -0.05759822f, 
    -0.06406257f, 0.08282734f, 0.14075042f, 0.12699650f, -0.33579922f, -0.15083657f, 0.03686498f, 0.12158697f, 
    0.04413699f, -0.03719496f, -0.14003602f, -0.02015001f, 0.42533535f, 0.15041623f, -0.17547347f, -0.04360186f, 
    -0.11864754f, 0.08712486f, 0.06328759f, -0.12303682f, 0.13670510f, 0.02347475f, 0.02619998f, 0.08304808f, 
    -0.05976776f, 0.00917073f, 0.08007659f, -0.08002131f, 0.04544500f, 0.06690483f, 0.30340797f, 0.17487808f, 
    0.01805655f, 0.57717347f, -0.17141727f, -0.27998653f, 0.09137807f, 0.05798271f, 0.01252452f, 0.37790629f, 
    0.02531891f, 0.17913756f, -0.02650188f, 0.00128067f, 0.00244632f, 0.03985955f, 0.01647936f, -0.06800271f, 
    -0.16763104f, -0.06872676f, -0.09337395f, -0.21531180f, 0.22490853f, -0.04399157f, 0.07541992f, -0.03632832f, 
    0.18632127f, -0.06262328f, 0.03130176f, 0.05112182f, 0.06924766f, -0.03322732f, -0.02418518f, -0.00048983f, 
    0.05019582f, 0.06470536f, 0.00163609f, -0.01052740f, -0.08410434f, 0.01900287f, -0.16438463f, -0.26693577f, 
    0.14766635f, -0.18626341f, -0.08894882f, -0.05172949f, 0.06583676f, 0.21674567f, 0.11598029f, -0.02057393f, 
    0.06439174f, 0.11225273f, 0.07996863f, -0.02281891f, 0.03200694f, 0.08920328f, 0.01006686f, 0.05981571f, 
    0.04808237f, 0.10942737f, 0.11243475f, 0.21632336f, -0.02533138f, 0.24927701f, 0.08688583f, 0.09414420f, 
    0.02355197f, 0.14570674f, -0.09081025f, -0.27078480f, -0.00523175f, -0.05537264f, -0.02988368f, -0.02869796f, 
    -0.05879121f, 0.03056714f, -0.01773108f, -0.00340870f, 0.00484349f, -0.00540658f, 0.00932401f, -0.05865245f, 
    0.07839322f, 0.05649330f, 0.39239138f, -0.02213108f, 0.13425954f, 0.08270078f, 0.00417154f, -0.17634633f, 
    0.11534268f, -0.09610286f, -0.08633907f, 0.15041885f, -0.08151860f, 0.04723730f, 0.03753293f, 0.03589654f, 
    0.07799599f, 0.08032726f, -0.06598943f, 0.04177710f, 0.26594234f, 0.12167144f, 0.21573532f, -0.05662737f, 
    0.01789273f, 0.22758155f, 0.08634108f, -0.22843318f, 0.10361422f, 0.04747650f, 0.03346824f, 0.01243603f, 
    0.04114865f, 0.09641762f, 0.01023347f, -0.09464484f, 0.01725477f, 0.02667618f, -0.01756485f, 0.12390539f, 
    0.26293400f, 0.08326549f, 0.03280852f, 0.11561506f, -0.05225266f, 0.15675163f, -0.06975611f, 0.06325541f, 
    0.11786222f, 0.06113208f, -0.08631682f, 0.12450749f, -0.08735891f, 0.02133996f, 0.05203033f, 0.02207535f, 
    -0.04024014f, -0.15070985f, 0.11580551f, 0.30242264f, 0.12646879f, 0.28038993f, 0.05848848f, 0.04253905f, 
    0.21366835f, 0.15472940f, -0.08037712f, 0.05218146f, 0.06031606f, 0.28098312f, 0.05610601f, 0.10503466f, 
    0.03248700f, 0.01754796f, -0.09312946f, 0.13169198f, -0.18137862f, 0.18686582f, -0.02540079f, -0.06066487f, 
    -0.08328930f, 0.08282574f, 0.15626223f, 0.20869733f, 0.08226530f, 0.01154153f, -0.05253414f, -0.08561914f, 
    0.11622905f, -0.14130832f, -0.03725148f, 0.03140568f, 0.08706427f, -0.03140364f, -0.01283916f, -0.05826652f, 
    -0.03938360f, 0.03287268f, -0.19263925f, -0.02736354f, -0.43535817f, -0.06239111f, -0.37737969f, -0.31820431f, 
    -0.06630205f, 0.01695874f, 0.08488262f, 0.19433478f, 0.06004734f, 0.10333905f, 0.17399217f, 0.09863975f, 
    -0.08398601f, -0.03114739f, -0.00862938f, -0.02682178f, 0.11468432f, 0.02473524f, 0.06752574f, 0.06136676f, 
    0.28294361f, -0.20274809f, -0.10998121f, 0.21512412f, 0.04909275f, -0.13778581f, -0.02562378f, -0.20436062f, 
    0.19395158f, 0.04568908f, 0.01037373f, -0.04328701f, 0.05911088f, -0.23499306f, 0.14291166f, -0.00288786f, 
    0.08892595f, 0.12359487f, 0.13439552f, 0.12438162f, 0.11977788f, -0.04636380f, -0.11508019f, -0.03011385f, 
    -0.38754848f, -0.03767888f, 0.14395039f, -0.01121739f, -0.07330418f, 0.11650045f, 0.01925271f, 0.03169142f, 
    -0.04276386f, -0.12385782f, -0.10788768f, -0.09843741f, 0.09128018f, -0.05589841f, -0.05462229f, 0.04008454f, 
    0.41860557f, 0.18646012f, -0.25339970f, 0.31455654f, -0.01542942f, 0.04854782f, -0.01237846f, -0.19060352f, 
    -0.05749801f, -0.04526573f, -0.14362451f, -0.00494850f, -0.14587839f, -0.10394932f, -0.03700602f, -0.03484596f, 
    -0.16455047f, 0.00277736f, 0.11503569f, 0.01092744f, 0.03584047f, -0.15159667f, -0.12792818f, 0.11294001f, 
    0.07727349f, -0.09181213f, -0.02344021f, -0.22282822f, -0.12169347f, -0.13149248f, 0.05983250f, 0.16348289f, 
    -0.08273355f, 0.01515583f, 0.11258844f, -0.18410940f, 0.03987324f, 0.14727166f, 0.08255921f, -0.05927807f, 
    0.39579657f, -0.24049009f, -0.07918895f, 0.04688859f, -0.04804038f, -0.07966369f, 0.04263046f, -0.13623515f, 
    0.08335853f, 0.00316589f, -0.00985702f, -0.12428948f, 0.06513339f, -0.10803877f, 0.07045823f, 0.13748164f, 
    0.04250538f, -0.06887581f, 0.10216671f, 0.09668975f, -0.00941101f, 0.20381677f, 0.44437820f, 0.02189547f, 
    -0.11922659f, -0.19960837f, 0.15044293f, 0.09244328f, 0.12094787f, 0.05028736f, -0.18073565f, 0.02692690f, 
    0.09647232f, 0.02968183f, 0.09819012f, -0.07199317f, 0.03332836f, -0.00502212f, 0.27488840f, 0.06449518f, 
    -0.08248506f, -0.21576202f, 0.05291801f, -0.18753305f, -0.19754320f, 0.02819072f, -0.09050766f, 0.17266540f, 
    -0.03079743f, -0.24908817f, 0.19882947f, 0.12588052f, -0.09345426f, -0.03567760f, -0.07573032f, -0.00045707f, 
    -0.12710275f, -0.11045212f, -0.12573849f, -0.18556517f, 0.00926702f, 0.30689663f, 0.46980447f, 0.18797965f, 
    -0.19424759f, 0.10298297f, 0.04817997f, 0.15866372f, 0.07887445f, -0.07286923f, -0.03683724f, -0.03094323f, 
    0.04889047f, 0.07564843f, 0.02147821f, 0.01770332f, -0.00460401f, -0.04272197f, -0.02283707f, -0.16518149f, 
    0.12371767f, 0.21479243f, 0.34648782f, 0.08683481f, -0.03932286f, -0.00588725f, 0.07194932f, -0.12324556f, 
    -0.06545253f, -0.04013801f, -0.08357272f, -0.05628746f, 0.06218155f, 0.10466582f, -0.02753456f, -0.08613459f, 
    0.12609360f, -0.16690631f, 0.03567909f, 0.15060084f, -0.08146256f, -0.13973869f, 0.01164744f, 0.14904104f, 
    0.10482339f, 0.10035072f, -0.14761801f, -0.01047933f, -0.02480495f, 0.03001274f, -0.05387112f, -0.01363702f, 
    -0.08750080f, 0.08827922f, 0.13631923f, 0.27443111f, 0.01069986f, 0.19121464f, -0.05937669f, -0.09575360f, 
    0.20200625f, 0.10482956f, -0.13705635f, 0.03248269f, -0.25034365f, 0.05665770f, -0.18581849f, 0.26315314f, 
    0.06097249f, -0.02550346f, -0.13292402f, 0.13650158f, -0.02265312f, 0.07001074f, 0.00454294f, 0.10376137f, 
    0.18808141f, 0.22811916f, -0.05121220f, 0.02507107f, -0.35178855f, -0.30337405f, 0.61725765f, 0.26361120f, 
    -0.53223491f, 0.01277718f, -0.04338096f, 0.19745037f, 0.19465013f, -0.16351180f, -0.02773292f, -0.01078023f, 
    0.15195425f, 0.05175434f, 0.14762133f, -0.00116104f, 0.02376516f, -0.07941423f, -0.02376124f, -0.02452574f, 
    0.04233645f, 0.10751486f, 0.52081525f, 0.23860499f, -0.10836691f, -0.01939149f, 0.03598324f, -0.05112029f, 
    0.14431445f, 0.04559208f, 0.04057601f, -0.07849402f, 0.12626366f, -0.04861286f, 0.06794707f, 0.13906698f, 
    0.01571339f, -0.10458790f, 0.08265173f, 0.26874745f, 0.27271676f, 0.22048762f, 0.29012683f, 0.08010853f, 
    -0.20529576f, 0.17417109f, 0.13165087f, 0.00356798f, 0.13864619f, 0.09396203f, 0.05419313f, -0.03525829f, 
    0.08401178f, -0.06301981f, -0.03796320f, 0.05477275f, -0.04469256f, -0.35084689f, 0.20784613f, 0.01888534f, 
    0.46017969f, -0.21593049f, 0.26240614f, -0.08030652f, 0.08761188f, 0.06631447f, 0.02615889f, -0.11150684f, 
    -0.04362677f, -0.01380309f, -0.02727940f, -0.13924547f, -0.13485543f, 0.10233782f, -0.03528518f, 0.11539917f, 
    -0.05419430f, 0.08317959f, -0.21976949f, 0.03643413f, -0.18211012f, -0.04418056f, -0.29307058f, 0.02805267f, 
    -0.09464961f, -0.14345057f, -0.02937384f, 0.04091922f, 0.12085687f, -0.09908585f, 0.15681940f, 0.20457213f, 
    -0.12848119f, 0.02966310f, -0.02149732f, 0.02692654f, 0.04139357f, 0.12991059f, 0.00288497f, 0.12255291f, 
    0.07413522f, -0.21871515f, 0.05060403f, -0.28297082f, 0.08063444f, -0.02846432f, -0.02835600f, -0.13715355f, 
    -0.39502078f, 0.02814739f, 0.21390809f, -0.19041680f, -0.01171866f, 0.00596498f, 0.10573455f, 0.11228526f, 
    -0.12616013f, 0.07547292f, -0.12690765f, 0.01306691f, -0.42391115f, 0.49980274f, 0.60876799f, -0.22002520f, 
    -0.08424328f, -0.03551248f, -0.03405963f, 0.02830678f, 0.05216287f, 0.15147664f, -0.04478441f, -0.09582748f, 
    -0.05660932f, 0.06124750f, -0.00959318f, -0.00869428f, -0.05678614f, 0.11241686f, -0.08698783f, -0.03070867f, 
    -0.44541100f, 0.05727845f, -0.26915511f, 0.02118498f, 0.23114213f, 0.06113901f, 0.01025666f, 0.04324853f, 
    -0.06484647f, 0.08386920f, -0.08074132f, -0.13837746f, -0.07769292f, -0.02447506f, -0.01773085f, -0.10165302f, 
    0.01818672f, 0.04497702f, 0.10953769f, 0.06845060f, 0.05874160f, 0.07169043f, -0.03264387f, -0.14769718f, 
    0.16714242f, 0.02591013f, -0.20475979f, -0.11730156f, -0.16086061f, 0.06620151f, 0.29064986f, 0.04928397f, 
    -0.00082826f, 0.04484073f, 0.08989517f, 0.06946129f, 0.01746426f, 0.03830961f, 0.05444559f, 0.01219012f, 
    0.04166657f, 0.07487852f, -0.31100070f, -0.32937074f, 0.06555668f, 0.16012698f, -0.18148527f, 0.01377560f, 
    -0.24148107f, -0.20483401f, 0.01259196f, 0.04315446f, -0.08872521f, 0.15578435f, -0.09786405f, 0.15019569f, 
    -0.09831571f, -0.06148975f, -0.02447924f, -0.04129703f, 0.50364137f, -0.00652683f, 0.01384923f, -0.32690817f, 
    -0.20899384f, 0.02637057f, 0.12398835f, -0.05950236f, 0.02398775f, 0.03519420f, -0.02981863f, -0.04839465f, 
    0.16516757f, 0.01540620f, 0.12274092f, -0.09433313f, -0.02997413f, -0.05778807f, 0.07251725f, -0.01030830f, 
    0.14229810f, 0.07676017f, 0.32195589f, 0.29812527f, 0.21871029f, -0.17669478f, -0.10755839f, -0.13226540f, 
    0.12977463f, -0.10644535f, 0.14545715f, -0.01098505f, 0.03752637f, -0.06229309f, 0.08629010f, 0.11111679f, 
    0.08713721f, -0.06690854f, -0.02727344f, -0.00733877f, -0.16177297f, 0.12573709f, 0.43242782f, 0.00249056f, 
    -0.08598880f, 0.17977239f, 0.15396011f, 0.13381661f, 0.11144032f, -0.08562893f, 0.03824029f, -0.06202204f, 
    -0.04487131f, 0.03029434f, 0.11402312f, -0.03365781f, 0.05602361f, -0.03859361f, 0.04244390f, 0.09951583f, 
    0.19387293f, 0.27806425f, -0.04837895f, -0.30477697f, -0.24660774f, 0.09296752f, 0.11701670f, -0.00922642f, 
    0.16119602f, -0.09104607f, 0.06681862f, 0.09908558f, 0.03730583f, -0.00654703f, 0.01081398f, -0.04029302f, 
    -0.07086063f, 0.05838016f, -0.07414950f, 0.10387643f, -0.02840234f, 0.07975371f, -0.40855420f, -0.24513444f, 
    0.20441593f, 0.25280061f, -0.03804984f, 0.12178666f, -0.08087306f, 0.11106488f, 0.19004168f, 0.03360030f, 
    -0.14061764f, 0.00705606f, -0.05621360f, -0.01619701f, -0.05995684f, 0.04696386f, 0.13144709f, -0.06319113f, 
    0.15292099f, 0.09729683f, -0.69062448f, -0.22887875f, -0.23263045f, 0.23729236f, -0.10940626f, 0.02515949f, 
    0.05550556f, -0.15260942f, 0.13463543f, 0.08667149f, -0.08409569f, -0.02684761f, -0.01940206f, -0.01689637f, 
    0.11735951f, 0.06219190f, 0.09742831f, -0.00103734f, -0.34312704f, -0.05773144f, -0.48031878f, -0.30026060f, 
    -0.36771151f, 0.03398568f, 0.24512401f, -0.20960321f, 0.13207848f, -0.01125070f, -0.01449513f, -0.12035304f, 
    -0.04777576f, -0.03060457f, 0.09965728f, -0.03425062f, -0.00188700f, 0.06408219f, 0.18106189f, -0.00147039f, 
    0.15481599f, 0.02651845f, -0.39105055f, 0.14118619f, -0.02354183f, 0.01002270f, 0.14648314f, 0.13535589f, 
    0.30648765f, -0.02699870f, 0.06793484f, 0.04931607f, 0.09714060f, 0.04370005f, 0.07390783f, 0.02680643f, 
    0.04446420f, 0.14258195f, 0.17230012f, 0.18711397f, 0.43965977f, -0.16233018f, -0.10947707f, -0.13555945f, 
    -0.30697262f, 0.01932162f, 0.20819740f, 0.08799196f, -0.01972957f, 0.16088843f, 0.17280744f, -0.00841391f, 
    0.01101901f, 0.05601535f, -0.03125250f, 0.06462855f, -0.02795206f, 0.13721909f, -0.05818364f, 0.16879039f, 
    -0.02525295f, -0.16779163f, -0.56368572f, -0.21119647f, 0.25424656f, 0.18978119f, 0.07172774f, 0.22912607f, 
    -0.16683871f, 0.17966235f, 0.20988815f, -0.03006202f, -0.13642147f, -0.04326157f, -0.00864196f, -0.04864398f, 
    0.05569746f, -0.00688366f, -0.05394569f, 0.01598896f, -0.46132240f, 0.18960615f, 0.23414305f, 0.03485769f, 
    0.22487715f, -0.12403354f, -0.10254929f, -0.05728156f, -0.01268635f, -0.02555129f, 0.20371881f, 0.10072104f, 
    0.11949792f, 0.10473765f, 0.06976713f, 0.09564123f, 0.04214440f, -0.03061944f, -0.02376739f, 0.01859899f, 
    -0.05111135f, -0.00934798f, -0.05540655f, -0.01570480f, -0.05324733f, -0.01210594f, -0.05362902f, -0.00617242f, 
    -0.02266768f, 0.00604907f, 0.00003349f, 0.00563552f, 0.00622073f, 0.02914585f, 0.02073237f, -0.04794071f, 
    0.01761921f, -0.01775890f, -0.02339946f, 0.00870002f, 0.02230953f, 0.04602794f, -0.03234160f, 0.00423364f, 
    -0.04244813f, -0.04274386f, -0.06136509f, -0.02215555f, 0.01834651f, 0.04857174f, -0.04642752f, 0.03599792f, 
    0.03704461f, 0.01493265f, -0.01956039f, -0.00585669f, -0.04676657f, -0.04366557f, -0.02283564f, 0.04740182f, 
    -0.02515318f, 0.00310067f, 0.04597465f, -0.03576635f, -0.05178308f, -0.06150788f, 0.03982512f, 0.02227128f, 
    0.03521640f, 0.00039757f, -0.05956840f, 0.02513351f, 0.00655373f, 0.04346072f, -0.02169825f, 0.03252348f, 
    0.00292048f, -0.01264448f, -0.02225457f, -0.02814824f, -0.04755392f, 0.01760134f, 0.01824879f, -0.02485962f, 
    0.02639031f, -0.02619997f, -0.04758566f, -0.05768697f, 0.03454824f, -0.01504211f, -0.02427216f, 0.02064698f, 
    -0.05882220f, 0.03733899f, 0.00520368f, 0.01175284f, -0.03134137f, 0.00482441f, -0.01961216f, -0.02436283f, 
    0.00674915f, 0.03836603f, 0.02364274f, -0.00079166f, 0.01132964f, -0.03199924f, 0.02417802f, -0.03522540f, 
    -0.01277103f, 0.04489636f, 0.00881073f, 0.02253064f, -0.03756590f, -0.04824676f, 0.03470556f, -0.01231464f, 
    -0.02136959f, -0.03508978f, 0.00079357f, 0.00298948f, 0.02636713f, -0.01124135f, -0.01617432f, -0.02767282f, 
    -0.00133778f, 0.00515071f, 0.03273395f, 0.02867013f, -0.04704044f, -0.03708095f, -0.04420628f, 0.02231399f, 
    0.03193668f, -0.01597380f, -0.03552526f, 0.03549188f, -0.02458947f, -0.05989579f, -0.05989095f, 0.03011633f, 
    -0.04347762f, 0.01853638f, -0.04411871f, -0.02924459f, -0.00850207f, -0.00763562f, -0.01223672f, 0.02456845f, 
    -0.01990988f, 0.00971971f, 0.00445843f, -0.03849371f, 0.01607657f, -0.05647578f, -0.05921739f, 0.00012359f, 
    0.02867442f, 0.03933592f, 0.02972835f, -0.04989935f, 0.00637795f, -0.02063270f, 0.01202463f, 0.00210348f, 
    -0.03249422f, -0.05676355f, -0.03310646f, -0.03146600f, 0.00665582f, 0.00651461f, -0.06436341f, -0.02011094f, 
    -0.05408071f, 0.03620325f, -0.02732272f, 0.02702593f, -0.00441563f, -0.05446614f, 0.00590199f, 0.03633362f, 
    -0.03060220f, 0.03735734f, -0.01928362f, -0.01137234f, 0.00510037f, 0.03284144f, -0.02852082f, 0.01988371f, 
    0.03885646f, 0.02319311f, 0.02456242f, -0.05836305f, 0.02735089f, 0.02104402f, 0.04664420f, -0.03586258f, 
    -0.00901792f, -0.02395384f, -0.01006475f, 0.03774041f, 0.02795744f, 0.00687090f, -0.00729085f, 0.04412142f, 
    -0.05134692f, -0.03254783f, 0.04104745f, 0.04766652f, -0.05730836f, -0.02741259f, -0.00339121f, 0.00663903f, 
    0.01962655f, -0.01758954f, -0.02820333f, -0.04763238f, 0.01184918f, 0.01766769f, 0.00304459f, 0.00929222f, 
    0.02176383f, -0.03267317f, -0.02503270f, -0.01308901f, 0.01663144f, -0.02486038f, -0.00366286f, -0.04994482f, 
    0.04570607f, 0.04513461f, -0.05545520f, 0.00075796f, -0.03239461f, -0.02683585f, -0.02805354f, 0.04380163f, 
    -0.03945157f, 0.02629381f, 0.00790245f, 0.00202612f, 0.03415480f, 0.03701753f, -0.05330813f, -0.05360328f, 
    -0.04178496f, -0.02086242f, -0.05279324f, -0.03827915f, -0.01946431f, -0.02256651f, -0.00068496f, -0.01297493f, 
    -0.04949077f, 0.02996451f, -0.03551547f, -0.03245927f, -0.01710096f, -0.03196335f, -0.00121593f, -0.00956537f, 
    -0.00291274f, -0.03354172f, 0.00711267f, 0.00459511f, -0.04724532f, 0.02482574f, -0.00618806f, 0.00189646f, 
    -0.05403834f, 0.02233418f, 0.01886622f, -0.04704592f, -0.02788020f, 0.01385184f, -0.01809182f, 0.02059960f, 
    0.00038293f, -0.00889805f, -0.03393313f, -0.04360994f, 0.03962361f, -0.03976193f, -0.00878448f, -0.02416121f, 
    -0.02038878f, -0.01969771f, 0.03838911f, -0.01242312f, -0.01290330f, -0.02464778f, -0.02851953f, 0.01102030f, 
    -0.01214655f, -0.02281195f, 0.02786061f, 0.02718631f, 0.02904913f, -0.00627851f, -0.01475068f, -0.01513819f, 
    0.03420103f, 0.00085550f, 0.04277495f, -0.02584345f, -0.03346370f, -0.01255157f, 0.00550511f, -0.00580830f, 
    0.04749912f, -0.00079071f, -0.01319474f, -0.01632725f, 0.04499568f, 0.02136274f, -0.03243826f, -0.00107259f, 
    0.04294904f, 0.02522613f, 0.03931589f, -0.04969098f, 0.00788717f, 0.02442870f, -0.04869058f, -0.00112408f, 
    -0.00111308f, 0.01929332f, 0.00903440f, -0.03405476f, -0.06107044f, 0.02847791f, -0.05270659f, -0.04268636f, 
    -0.02597976f, 0.00932459f, 0.00837537f, 0.02217063f, -0.05396676f, -0.05936086f, -0.01127081f, 0.00157194f, 
    0.03111258f, 0.01052374f, -0.04707412f, -0.00407377f, 0.03362235f, -0.05615756f, 0.01653309f, -0.03702905f, 
    0.02204119f, -0.00453523f, 0.03333285f, -0.05247674f, 0.04296653f, -0.00850887f, 0.03046426f, -0.03252049f, 
    -0.03728723f, -0.06396554f, 0.00976767f, -0.03967911f, -0.02408635f, 0.02754600f, 0.01792245f, -0.04011422f, 
    -0.05432135f, -0.04690253f, -0.04432532f, -0.05640734f, -0.01862495f, -0.05139602f, -0.02736476f, 0.02726221f, 
    -0.03737801f, -0.00572795f, -0.01708601f, 0.04015099f, -0.05934412f, 0.00507050f, 0.03522043f, -0.01445263f, 
    0.02229890f, -0.05264225f, 0.01504490f, 0.00288447f, 0.02456867f, 0.04530425f, 0.01160960f, -0.04111120f, 
    -0.00672902f, -0.01005891f, -0.05241516f, -0.04191598f, -0.00715119f, 0.04742665f, -0.00992910f, 0.00875972f, 
    0.00391611f, 0.02839348f, 0.03603868f, -0.04409109f, 0.04137833f, 0.03337487f, 0.02678773f, -0.03390741f, 
    0.00516116f, -0.03169620f, 0.04003190f, -0.00593516f, -0.02580018f, -0.00077774f, -0.01152013f, -0.01581186f, 
    -0.03128199f, 0.04241420f, 0.04611067f, -0.01970068f, -0.04795523f, 0.01353660f, -0.02063790f, 0.04595592f, 
    0.04308524f, -0.02930977f, -0.00191791f, 0.00518362f, -0.00443199f, -0.03591457f, 0.00204560f, 0.00920618f, 
    -0.06413580f, 0.02510388f, 0.02103103f, 0.00336894f, -0.06060627f, -0.03262857f, -0.03447181f, -0.06013959f, 
    0.02490295f, -0.06278208f, 0.03184615f, -0.00091055f, 0.02846689f, 0.02325797f, 0.02007467f, -0.04711122f, 
    0.02087647f, 0.04834045f, 0.04992376f, -0.03163120f, -0.03054408f, -0.02821006f, 0.02645270f, -0.04542428f, 
    -0.01605866f, -0.04533872f, -0.05025974f, -0.01682869f, -0.00618467f, -0.05875780f, -0.02153025f, 0.02382056f, 
    -0.00631757f, -0.01397167f, -0.05881387f, -0.05441689f, -0.00800747f, 0.03652541f, -0.04417649f, -0.01222651f, 
    0.01057703f, 0.01927732f, 0.02814914f, -0.05048823f, -0.02117191f, -0.02216164f, -0.05041166f, -0.01915859f, 
    0.04803412f, 0.03372162f, 0.04299631f, -0.04125470f, 0.03843173f, -0.03010635f, -0.01212022f, 0.02236809f, 
    -0.04542017f, -0.02246919f, -0.02273554f, 0.00401726f, -0.02689436f, 0.02719312f, 0.04629729f, -0.00164842f, 
    -0.02941718f, -0.05348297f, 0.05047554f, 0.02980796f, -0.04397827f, -0.03001105f, -0.01903042f, -0.04084904f, 
    0.03477326f, 0.03322122f, 0.02031761f, 0.01959669f, -0.01174748f, -0.02989289f, 0.00935755f, -0.06102257f, 
    -0.02431975f, 0.01080615f, -0.02260647f, 0.02551631f, 0.02096370f, 0.01340410f, 0.02946763f, 0.02603759f, 
    -0.00108028f, -0.02469544f, -0.02550922f, 0.02526676f, -0.01179358f, -0.02474998f, -0.05311757f, -0.04226346f, 
    -0.05861220f, -0.00704175f, -0.05820482f, 0.00457531f, 0.02973207f, -0.02150645f, 0.01768367f, 0.00363529f, 
    -0.05152334f, -0.02042544f, -0.00841323f, 0.03283079f, 0.01748706f, -0.04674420f, 0.02478931f, -0.06031819f, 
    -0.03929548f, 0.03904327f, -0.00413474f, -0.01169301f, 0.00496374f, -0.02046283f, 0.03233815f, 0.03530664f, 
    0.04294871f, 0.04186309f, 0.00075877f, -0.06012393f, -0.03456369f, 0.00076821f, -0.03292764f, -0.02090591f, 
    0.03749220f, 0.00419369f, -0.03198416f, 0.03637703f, -0.00896481f, 0.02878343f, -0.03215836f, -0.04766664f, 
    0.02305332f, 0.00180715f, 0.01203981f, 0.00359436f, -0.01799633f, 0.05209606f, 0.00834779f, 0.02677667f, 
    -0.02402217f, 0.03470188f, 0.02547198f, -0.01143307f, -0.01439366f, -0.01011420f, -0.05319382f, -0.03125790f, 
    0.01522245f, -0.02869980f, -0.02797965f, 0.04459614f, -0.00023034f, -0.01839527f, -0.01418986f, 0.04560001f, 
    0.00553254f, -0.03390529f, -0.01720239f, 0.04659606f, -0.06050314f, -0.01296313f, -0.01825577f, -0.02798364f, 
    0.00850528f, 0.01267870f, -0.00501601f, -0.01520921f, -0.00579920f, -0.04056042f, 0.01959255f, -0.00289553f, 
    0.03739425f, -0.06064199f, -0.02591446f, 0.04234129f, -0.05966325f, -0.01677174f, -0.02462050f, 0.01524703f, 
    -0.04464053f, 0.04810603f, -0.02013543f, 0.00274640f, -0.04084965f, -0.00123141f, -0.01890651f, -0.05032604f, 
    -0.03356918f, 0.04041471f, -0.01491086f, 0.00381361f, 0.03339496f, -0.02351160f, 0.00759060f, 0.02638766f, 
    -0.06075058f, 0.01033261f, 0.02220701f, 0.01975127f, 0.00948520f, -0.06275912f, 0.04219446f, -0.03735670f, 
    0.04509771f, 0.01632391f, 0.04127237f, 0.01453196f, 0.00702256f, -0.06277902f, -0.02269846f, -0.00052061f, 
    -0.01140455f, 0.00150636f, -0.03089217f, -0.00763447f, -0.05764919f, -0.04317088f, 0.01356063f, -0.05842976f, 
    -0.00593380f, -0.01211749f, 0.03126339f, 0.03476693f, -0.05445182f, -0.02284602f, 0.00294198f, -0.05866383f, 
    -0.29959613f, 0.26596978f, 0.07341157f, 0.05733137f, -0.27640310f, 0.02041516f, 0.04262657f, 0.00720601f, 
    0.33367935f, 0.07626867f, -0.02584623f, 0.09285112f, -0.06886115f, 0.17990167f, 0.16334777f, 0.07409509f, 
    0.11132611f, -0.14615940f, 0.08151860f, -0.05153713f, 0.12346319f, -0.14045526f, -0.04329819f, 0.22297843f, 
    0.33792555f, -0.07820839f, -0.05822989f, -0.12490872f, 0.02562467f, 0.17072973f, 0.11930363f, 0.06522033f, 
    0.01063921f, -0.07654271f, -0.05346598f, 0.01049428f, 0.00737149f, -0.11420266f, 0.05257643f, -0.03823206f, 
    0.15481882f, 0.10071892f, 0.80580723f, -0.21502246f, -0.12261821f, -0.18426245f, 0.03801282f, -0.07551467f, 
    0.04702175f, -0.08350775f, 0.02822857f, 0.03059271f, -0.02800079f, -0.06898780f, -0.00346749f, 0.09832434f, 
    -0.26021850f, -0.10468261f, -0.14847726f, -0.00227343f, -0.19076207f, 0.05676617f, 0.38913059f, 0.19301204f, 
    -0.39101088f, 0.04724890f, 0.02316632f, 0.09412887f, 0.05481827f, 0.09220567f, -0.10832484f, -0.20407680f, 
    0.05048377f, 0.06701961f, 0.02838260f, -0.05810830f, -0.04958118f, -0.14856966f, -0.12031864f, -0.09034746f, 
    -0.20426816f, 0.02368978f, 0.15198074f, 0.04955998f, -0.07245266f, -0.05295761f, 0.17757449f, -0.10246279f, 
    0.14151993f, 0.00932311f, -0.04615799f, -0.12806994f, 0.15957710f, 0.00354740f, 0.09757341f, -0.11786862f, 
    -0.09202407f, 0.13266978f, 0.10779323f, -0.10812187f, -0.29169694f, -0.15980119f, -0.10909984f, 0.12977485f, 
    0.09631767f, 0.17227407f, -0.05743191f, -0.05265441f, -0.04603785f, -0.02700525f, 0.14356950f, 0.09717754f, 
    0.12964490f, -0.07533584f, -0.02345120f, -0.02986964f, 0.08769418f, 0.06631387f, 0.01315480f, 0.07951993f, 
    -0.22385961f, 0.07102398f, 0.05243038f, 0.08681250f, 0.33048588f, 0.27135345f, -0.05676389f, 0.14308889f, 
    -0.26236126f, 0.12465005f, -0.24195711f, 0.16344075f, -0.00353531f, 0.05875219f, 0.02770612f, -0.09678488f, 
    -0.02486222f, 0.05926036f, -0.04632960f, -0.09074291f, -0.06302650f, -0.21504112f, -0.59922713f, -0.07932448f, 
    0.10155478f, -0.21030976f, 0.13846964f, -0.05017925f, 0.00763010f, -0.19043656f, -0.10509124f, 0.00123328f, 
    -0.04702627f, 0.15209995f, -0.15940343f, 0.14698197f, 0.09511672f, -0.00304099f, 0.05062108f, -0.07615222f, 
    -0.26136708f, -0.26914254f, -0.40160516f, 0.25102782f, 0.27521181f, 0.02694206f, 0.02575654f, -0.03893162f, 
    0.02334213f, -0.00912830f, -0.00828548f, 0.04169967f, 0.02776735f, -0.00866846f, -0.08075492f, -0.03113356f, 
    0.01681279f, -0.10964427f, 0.11953093f, 0.06443869f, 0.21115248f, 0.22511522f, 0.39616084f, 0.07154311f, 
    -0.25017497f, 0.04579025f, -0.10328773f, 0.04424598f, 0.01945394f, -0.06167303f, -0.01599158f, -0.02684122f, 
    0.02137901f, -0.02620207f, 0.12259828f, 0.12950294f, -0.06736603f, 0.07803138f, -0.08168802f, 0.11339300f, 
    0.00170856f, -0.26109698f, 0.52405012f, 0.03971759f, 0.33411679f, 0.04438056f, 0.01347844f, 0.32910416f, 
    -0.03669571f, -0.00949714f, 0.00058872f, 0.07725988f, 0.19108500f, 0.04467035f, 0.16621634f, -0.11821803f, 
    -0.11357474f, 0.18935919f, 0.04165199f, 0.20246597f, 0.18682484f, -0.22321185f, 0.18734165f, 0.01526974f, 
    0.35105607f, -0.01263564f, -0.08295190f, 0.06075425f, -0.23213848f, -0.14505585f, -0.18000589f, -0.01147117f, 
    0.05225359f, -0.03996198f, 0.08598012f, 0.05403718f, 0.06483132f, -0.18055791f, -0.07488801f, -0.00307360f, 
    -0.01428166f, -0.20973864f, 0.08242679f, -0.15787393f, 0.24001704f, 0.08858999f, -0.00721139f, -0.02033502f, 
    0.07687543f, 0.08545487f, -0.10518363f, -0.07221255f, -0.06343807f, 0.03490010f, 0.06156347f, 0.08167132f, 
    0.11865685f, -0.15427788f, 0.09277891f, 0.03279154f, -0.25882635f, 0.12577125f, -0.20110519f, 0.25693157f, 
    0.26860312f, -0.04825136f, 0.00886825f, 0.08771867f, 0.04447175f, -0.06378176f, -0.08047073f, 0.01229203f, 
    -0.05404587f, 0.04081980f, 0.08849494f, 0.03223189f, 0.18226805f, 0.05435750f, 0.09380831f, -0.04471798f, 
    -0.07741740f, 0.51626867f, 0.70688301f, 0.37003991f, -0.19340144f, -0.08163325f, 0.03469193f, -0.14621429f, 
    0.04529312f, -0.07865579f, -0.16436242f, -0.05208888f, 0.01964795f, 0.04167361f, 0.06272472f, 0.04102687f, 
    0.01227406f, 0.04193918f, 0.00663197f, 0.07240602f, 0.49050212f, -0.05327019f, 0.40008825f, -0.07064503f, 
    0.06577935f, 0.09201488f, -0.01833291f, 0.10136595f, 0.12203174f, 0.25816691f, -0.00593534f, 0.19757234f, 
    0.04614734f, -0.08062844f, 0.05477168f, -0.05536957f, -0.01964724f, 0.02571970f, 0.08671512f, 0.00396500f, 
    -0.00354530f, -0.03756196f, 0.02082862f, 0.04857393f, 0.05499272f, 0.00489570f, 0.03598749f, -0.00290557f, 
    -0.02171757f, -0.03953130f, 0.00042984f, 0.04608960f, -0.05166959f, 0.02264299f, 0.05041690f, -0.05338187f, 
    -0.03362871f, 0.05126470f, -0.05203975f, -0.01047081f, -0.01751314f, 0.00020432f, -0.00384090f, 0.01458975f, 
    -0.03910255f, -0.02153040f, -0.03429450f, -0.04745516f, 0.02178892f, -0.02953959f, 0.01510229f, -0.02323952f, 
    0.03360730f, -0.04272098f, 0.03836317f, 0.03552122f, -0.03229120f, 0.04585475f, -0.04419628f, 0.00205209f, 
    -0.02113922f, 0.04762474f, 0.00682740f, -0.03176995f, -0.04604759f, -0.04865297f, 0.04270560f, -0.01916923f, 
    0.01391433f, 0.00367723f, -0.04759925f, 0.03442901f, 0.01719891f, 0.00102379f, 0.04139807f, 0.02167105f, 
    -0.04361057f, -0.05342010f, -0.05288837f, -0.01946424f, 0.02355837f, 0.03352706f, -0.04640842f, 0.00011546f, 
    -0.01484863f, -0.02636790f, -0.02543453f, 0.01512056f, -0.00279135f, -0.03901780f, -0.01296240f, -0.05763483f, 
    0.01439222f, 0.02705432f, 0.01961409f, -0.02125352f, -0.03415908f, 0.04512334f, -0.00361100f, 0.04070346f, 
    0.04430285f, -0.04558147f, 0.04216380f, 0.00093603f, 0.02087405f, 0.03127229f, 0.04798059f, -0.01595366f, 
    -0.01726296f, -0.04813803f, -0.01450273f, -0.02966152f, 0.01980872f, 0.03548180f, 0.04474292f, 0.03277054f, 
    0.01627745f, 0.01196612f, 0.03878136f, 0.01700094f, 0.01836058f, -0.05238713f, -0.05488784f, 0.02349790f, 
    0.00830533f, 0.03230391f, 0.01637455f, -0.04618140f, -0.01136014f, -0.05750035f, 0.00804540f, -0.02556948f, 
    0.01921086f, -0.04071561f, -0.01327381f, 0.02115200f, 0.00657216f, 0.04671746f, -0.02370877f, 0.00716256f, 
    -0.05632327f, -0.02270420f, -0.04442769f, -0.04857841f, -0.03554259f, 0.02351395f, -0.01166505f, -0.01513993f, 
    -0.01650684f, 0.04078896f, -0.01118767f, -0.02620694f, -0.05201935f, -0.02194620f, 0.03624015f, -0.03923083f, 
    -0.05260772f, 0.01663540f, -0.04619990f, 0.02598265f, 0.03584854f, 0.03569911f, 0.02255804f, -0.00397932f, 
    -0.01728497f, -0.05910334f, 0.00519687f, 0.02824669f, -0.00479936f, -0.02360824f, -0.04232858f, 0.00112279f, 
    -0.05324077f, -0.04222888f, 0.02442208f, -0.01209882f, 0.02191372f, 0.02074002f, 0.04206318f, 0.04117991f, 
    0.01514654f, 0.02592528f, 0.04742765f, 0.00424039f, -0.02965591f, -0.01179303f, -0.03163285f, -0.03470681f, 
    -0.02354485f, 0.03556287f, -0.04245350f, 0.02252309f, -0.04469070f, 0.02058733f, -0.05384452f, -0.01023687f, 
    0.01637204f, -0.03922434f, 0.04396736f, -0.02532762f, -0.02793637f, 0.01712399f, 0.05249099f, 0.00962263f, 
    -0.05465686f, -0.04078166f, -0.02538895f, 0.03574440f, 0.00298275f, -0.04893086f, -0.02046081f, -0.04016243f, 
    -0.03455481f, -0.00788931f, 0.00418247f, -0.04713053f, 0.00504234f, -0.03797437f, -0.03822393f, -0.05088514f, 
    -0.03176454f, -0.05193797f, 0.02516216f, 0.03352768f, -0.02156913f, 0.03923718f, 0.00025841f, -0.01048865f, 
    0.04955002f, 0.02479784f, 0.03916594f, -0.04248411f, -0.03249667f, -0.02303893f, -0.03906342f, -0.05373309f, 
    0.01699317f, 0.00428970f, 0.00371224f, 0.02765859f, -0.05657084f, -0.02224704f, 0.03512131f, 0.02371798f, 
    -0.04352612f, -0.04673577f, 0.04033624f, -0.00585165f, -0.03468610f, -0.02064936f, -0.05353922f, 0.01545047f, 
    -0.00650636f, -0.03397675f, -0.01072969f, 0.04801095f, -0.03943536f, -0.03761707f, 0.02951219f, -0.00106194f, 
    0.03608597f, -0.01461873f, -0.05873578f, 0.04602531f, -0.03887784f, -0.00850897f, -0.05785978f, -0.02795916f, 
    -0.00260966f, 0.01425673f, -0.01953247f, -0.01319617f, 0.02137979f, 0.03529542f, 0.02520897f, 0.02855292f, 
    -0.06120152f, -0.05437151f, 0.00042188f, -0.03143107f, 0.01652794f, 0.01496713f, 0.00273964f, -0.01439699f, 
    0.04999181f, 0.01585494f, -0.05052257f, -0.04339186f, 0.00560597f, -0.04607219f, -0.01881346f, 0.03542615f, 
    -0.05195473f, -0.05995432f, -0.01359067f, -0.02299929f, 0.04893398f, -0.04899611f, 0.00617400f, 0.01473203f, 
    -0.02400916f, -0.02892283f, -0.00903973f, 0.01977399f, -0.00417546f, -0.05548998f, -0.03770507f, -0.04930671f, 
    -0.02911408f, 0.02231815f, -0.02633153f, -0.04461437f, 0.02283821f, -0.03290700f, -0.01674242f, -0.02685927f, 
    -0.04989713f, -0.01023456f, 0.04792959f, 0.00300716f, -0.01784314f, -0.05419062f, 0.04635648f, 0.02797123f, 
    0.03481461f, 0.02134853f, -0.00184227f, 0.00954864f, 0.00254202f, 0.01323914f, 0.01796114f, 0.03279037f, 
    -0.02418522f, -0.02191547f, -0.02484133f, 0.03056922f, 0.00115452f, -0.04088600f, 0.04726805f, -0.00705445f, 
    -0.17903438f, -0.04676981f, -0.14047249f, -0.31519920f, -0.03214582f, 0.06413334f, 0.06532502f, 0.16876550f, 
    0.11167907f, -0.23674209f, -0.05529808f, 0.31595302f, -0.08792305f, 0.14761627f, -0.01634211f, 0.09666203f, 
    0.16898964f, -0.01930982f, -0.30152237f, -0.10909478f, 0.37870356f, 0.20465784f, 0.24277568f, 0.32292026f, 
    0.08848366f, -0.02970354f, 0.05443305f, -0.00614544f, 0.08484563f, -0.11284640f, 0.05937439f, 0.02622022f, 
    0.11282521f, -0.00434171f, 0.09179711f, 0.02375733f, -0.14245386f, -0.01548959f, -0.08460010f, -0.26407129f, 
    0.31293896f, -0.09123625f, -0.24662121f, -0.02999484f, 0.10853343f, -0.02650357f, -0.02552495f, 0.07391325f, 
    0.06042838f, -0.11272863f, 0.01610859f, 0.05916519f, 0.04147262f, 0.00666390f, -0.09505232f, 0.12284347f, 
    0.33076501f, 0.06045788f, -0.01609603f, 0.23684578f, -0.11220393f, 0.08879080f, -0.08790425f, -0.12044048f, 
    0.06922963f, -0.01050873f, 0.10560452f, 0.14349145f, 0.21730009f, 0.03832204f, -0.08950748f, 0.13816890f, 
    0.09585532f, 0.01582984f, 0.14576733f, 0.09858115f, 0.09193373f, -0.10663976f, -0.33054000f, -0.10403502f, 
    -0.02240903f, 0.30502510f, 0.28598905f, -0.28001976f, -0.13481548f, 0.01711854f, -0.02264093f, 0.00150862f, 
    0.00395080f, -0.07560532f, -0.00430412f, 0.10593309f, 0.09778466f, 0.05143710f, 0.22125521f, -0.15985627f, 
    0.17105871f, -0.02039926f, -0.26259777f, -0.17609502f, -0.17159769f, 0.25045484f, 0.18018033f, 0.01385906f, 
    0.14491363f, -0.00911504f, -0.03783036f, 0.04202336f, 0.08120689f, 0.02520975f, 0.04887563f, -0.01296135f, 
    0.03850067f, -0.04322103f, -0.18956812f, 0.16232693f, -0.15063573f, -0.02293898f, -0.11023865f, -0.03144660f, 
    -0.05926003f, -0.13847557f, 0.10815235f, 0.34131977f, 0.00332143f, 0.15354916f, 0.06633170f, -0.09759942f, 
    -0.07753059f, 0.15111022f, -0.01336688f, -0.03692875f, 0.05858614f, 0.13516667f, 0.05540128f, -0.04665321f, 
    0.14930525f, 0.23250769f, -0.03195248f, 0.30799022f, 0.07660195f, 0.15124221f, 0.08359649f, 0.07796881f, 
    0.13791882f, 0.02785977f, -0.14122744f, 0.02491091f, -0.03224319f, 0.15348822f, 0.08902644f, 0.18127391f, 
    0.09104259f, 0.14612027f, 0.09774702f, 0.15579049f, 0.02173102f, 0.02965529f, 0.17444359f, 0.31231090f, 
    0.14845406f, 0.21985620f, 0.20745482f, 0.07566549f, 0.12267061f, -0.11356977f, -0.19766304f, 0.12977882f, 
    0.09857996f, 0.07799985f, -0.00049249f, 0.03023881f, -0.07373527f, -0.07207301f, 0.02041544f, -0.03674015f, 
    -0.03568046f, -0.06786620f, 0.11314274f, -0.23302238f, -0.22689897f, -0.34207514f, 0.09671961f, -0.07320824f, 
    -0.11166859f, -0.39879945f, 0.33512038f, 0.07052679f, -0.01005021f, -0.10269614f, 0.07885656f, -0.08093929f, 
    0.10688644f, 0.00573452f, 0.09614166f, 0.14878392f, 0.20390269f, -0.14465329f, -0.32907477f, 0.00141631f, 
    -0.06115263f, 0.04456368f, 0.00994206f, 0.17833121f, 0.04642580f, 0.03450906f, 0.06690592f, 0.06566793f, 
    -0.10934503f, 0.24194691f, 0.03924995f, -0.03818960f, 0.07251473f, 0.01470567f, 0.08914745f, -0.25648117f, 
    -0.04992514f, -0.22067109f, -0.08975037f, -0.00423709f, 0.05041715f, 0.25392848f, -0.03223461f, 0.18977672f, 
    0.24578717f, -0.19490311f, -0.13092582f, 0.28279811f, -0.06763180f, 0.20571108f, 0.05472591f, 0.03362057f, 
    0.10784832f, -0.07017819f, -0.11777268f, 0.11869276f, -0.02256007f, -0.04382175f, -0.03699875f, 0.01159448f, 
    -0.05837109f, 0.21768472f, 0.06740745f, -0.15126270f, 0.16213234f, 0.06504344f, -0.11893779f, 0.04915567f, 
    -0.10926645f, 0.27042902f, -0.11295326f, -0.03796077f, -0.08220492f, -0.00225059f, -0.05669125f, -0.06561087f, 
    -0.09482846f, 0.04017431f, -0.10022934f, -0.38107371f, -0.15119213f, -0.05079567f, -0.01877055f, 0.12113874f, 
    -0.03770409f, -0.15623125f, -0.01297076f, 0.13333330f, -0.02728618f, -0.22431284f, 0.02848391f, -0.04003784f, 
    -0.04298387f, 0.14537320f, 0.07966154f, 0.04577093f, 0.14012904f, 0.11297850f, 0.13016529f, 0.11836009f, 
    -0.02500993f, -0.01919918f, 0.00273897f, 0.06060414f, -0.19542843f, -0.15199688f, 0.12418287f, 0.02422664f, 
    0.15605074f, -0.14234141f, -0.00527698f, -0.05728877f, -0.10126511f, -0.02549346f, 0.13399564f, 0.08634493f, 
    0.07491367f, 0.03497766f, 0.06070311f, 0.02518610f, 0.10494990f, -0.02262038f, 0.23330675f, 0.38953695f, 
    -0.02045482f, -0.06734508f, 0.05263831f, -0.14793989f, -0.13864182f, 0.13598613f, -0.03502963f, -0.11963873f, 
    -0.11644733f, -0.06051353f, -0.00529922f, -0.05885566f, -0.12855394f, -0.03728334f, -0.28667194f, -0.28214240f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02683560f, -0.12956406f, 0.07319844f, -0.01157975f, 0.02676779f, 0.27878723f, 0.25121549f, -0.07697134f, 
    0.22659206f, 0.00534111f, 0.13860784f, -0.00618488f, 0.04923852f, 0.13162161f, 0.12502450f, 0.10923728f, 
    0.22674087f, 0.08473267f, -0.14288054f, -0.01838879f, -0.02875647f, -0.05791895f, -0.01584876f, 0.04677952f, 
    0.03623683f, 0.09672937f, 0.22865392f, 0.04670226f, -0.00254607f, 0.11092846f, 0.01311175f, -0.10914154f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10178851f, 0.16803616f, 0.08800925f, -0.50312167f, -0.08378963f, -0.04180126f, 0.14606549f, 0.37214470f, 
    0.17129670f, -0.04882911f, 0.15222520f, 0.11201326f, 0.04456079f, -0.28300518f, -0.06823923f, -0.06641287f, 
    0.05772950f, -0.19806413f, 0.01350897f, 0.13205695f, 0.09758355f, -0.07521231f, 0.13519281f, -0.06460942f, 
    0.34107587f, 0.02731236f, -0.26294732f, 0.01423467f, 0.08495925f, 0.44095683f, -0.13198568f, 0.05657532f, 
    -0.12906367f, 0.07589208f, 0.04195211f, -0.14849472f, 0.09189214f, 0.31644788f, -0.25671372f, -0.28541389f, 
    0.27393469f, 0.10273276f, 0.52119118f, -0.12221747f, 0.07315967f, -0.10752276f, 0.27950466f, -0.44420728f, 
    0.10154649f, 0.02594768f, 0.09488358f, 0.05671486f, 0.00638892f, -0.04089546f, -0.05555077f, 0.00539358f, 
    -0.17079565f, 0.24614429f, 0.13088319f, 0.04959759f, -0.00143307f, -0.01864283f, -0.03306179f, -0.06989814f, 
    0.14033772f, 0.05230753f, -0.18973130f, 0.00264535f, 0.10854565f, -0.10934446f, 0.43249038f, 0.37830642f, 
    -0.11750111f, 0.05131662f, -0.18781251f, 0.13949925f, -0.02538715f, -0.18249671f, -0.34871346f, 0.16563623f, 
    0.44431394f, -0.22497092f, -0.14907764f, 0.08207293f, -0.02292406f, -0.17359163f, 0.08244463f, -0.12478766f, 
    -0.04910303f, 0.17594141f, -0.19049698f, -0.10581115f, 0.04259258f, 0.15194911f, 0.05459051f, 0.07327615f, 
    -0.07320826f, -0.18214460f, -0.01983033f, 0.26943907f, -0.09746334f, 0.22171380f, 0.05008930f, -0.29442516f, 
    -0.05152417f, 0.06512307f, 0.22812206f, 0.05003372f, -0.06278958f, 0.16230109f, -0.23402838f, 0.38278541f, 
    -0.22962983f, 0.40747836f, 0.16576910f, -0.15418048f, -0.12197728f, -0.10658931f, 0.16937935f, 0.11888076f, 
    -0.04003386f, -0.05025319f, -0.20111461f, 0.09930541f, 0.09129415f, 0.17812148f, 0.11261210f, 0.21465613f, 
    -0.16899167f, -0.18207984f, 0.26472750f, -0.36596042f, 0.15108056f, -0.02422704f, 0.38254893f, 0.15792876f, 
    0.15322442f, -0.09076508f, 0.18083961f, -0.09614241f, -0.01092042f, 0.15859674f, 0.08222185f, -0.04646773f, 
    0.23584679f, -0.36875090f, 0.09152550f, -0.03260135f, 0.11378245f, 0.03022986f, 0.05105347f, -0.14581469f, 
    0.11919162f, -0.00511367f, 0.09104960f, 0.06220200f, 0.16732769f, -0.06169222f, 0.07424197f, -0.17402193f, 
    -0.02140531f, -0.27318245f, -0.27171424f, 0.15361550f, 0.11833804f, 0.18530153f, 0.23934935f, -0.33035585f, 
    0.25414324f, -0.16589510f, 0.00722683f, -0.08052607f, -0.13198008f, 0.60809976f, 0.24844100f, 0.11500783f, 
    0.24326463f, 0.31833073f, -0.03502127f, 0.11998024f, -0.08464807f, 0.05555535f, 0.14317033f, -0.05238407f, 
    0.10992424f, 0.30433297f, 0.15797339f, 0.07760943f, 0.03670496f, -0.39276636f, -0.09806811f, -0.18686424f, 
    -0.15532430f, 0.41327500f, 0.32429308f, 0.04987283f, 0.14902094f, -0.69133765f, -0.21694839f, 0.27262297f, 
    0.16224860f, 0.31902790f, -0.00520513f, 0.13946381f, 0.04582797f, -0.11144277f, -0.11085610f, -0.23928282f, 
    0.02231258f, 0.26152042f, 0.21473470f, 0.12345489f, -0.09015339f, 0.03482039f, 0.02808214f, 0.12807760f, 
    0.01358724f, -0.27348378f, 0.18152659f, 0.09713460f, -0.13406530f, -0.41064155f, 0.09415244f, 0.04959342f, 
    -0.09106040f, 0.05277600f, 0.00940983f, 0.07927239f, -0.02330788f, 0.14430279f, 0.28891775f, -0.09350728f, 
    -0.30416164f, 0.29199457f, 0.23311321f, -0.13071883f, 0.06617716f, -0.08060107f, 0.13777307f, 0.10366040f, 
    -0.18134473f, 0.12262924f, 0.03091302f, -0.13731205f, -0.15214051f, 0.00323252f, -0.11608842f, 0.08897363f, 
    0.00841934f, 0.10946360f, 0.58979207f, -0.10314687f, -0.14266640f, -0.05065957f, -0.14356039f, -0.37251744f, 
    0.02043347f, 0.26443923f, -0.18068005f, 0.17771903f, -0.00237356f, 0.24765463f, -0.09871188f, -0.07308975f, 
    0.14157666f, 0.05647033f, 0.10507731f, -0.00114320f, -0.14487500f, -0.50644171f, 0.02171918f, -0.65439773f, 
    0.38790643f, -0.48006949f, -0.07306404f, 0.10570518f, -0.14300363f, -0.00499006f, 0.08605876f, 0.09751585f, 
    0.00996662f, 0.45549455f, 0.26000190f, 0.04468360f, -0.15296157f, -0.07698887f, 0.05991419f, -0.20188150f, 
    -0.15004051f, 0.07059027f, 0.40591726f, 0.24716035f, -0.07082411f, -0.22581960f, 0.01114110f, -0.15793306f, 
    0.08568736f, 0.41603890f, -0.02163845f, -0.12603272f, -0.11281603f, -0.05306425f, 0.02935547f, -0.04813899f, 
    0.04880137f, -0.71312726f, -0.00019265f, -0.13511333f, 0.01213034f, 0.18423539f, 0.05067604f, 0.09277628f, 
    0.13106064f, -0.19037321f, 0.33614504f, -0.09660976f, 0.11106006f, -0.36729726f, -0.12297919f, 0.21187201f, 
    0.11641409f, -0.15928885f, 0.20769221f, 0.44019642f, -0.12991652f, -0.10262533f, 0.25767544f, 0.45549205f, 
    0.24929866f, -0.04077043f, -0.59575254f, 0.10920604f, -0.04661072f, -0.09788872f, 0.11970707f, -0.00781695f, 
    0.14505360f, -0.15035015f, -0.02870097f, 0.08248918f, -0.09419715f, 0.04849609f, 0.06370837f, -0.12124442f, 
    -0.23226663f, -0.21916535f, 0.26921821f, -0.15626875f, 0.03560312f, -0.19757594f, -0.07979277f, 0.38621739f, 
    -0.07138599f, 0.50163180f, 0.35576263f, -0.20076150f, 0.02275340f, -0.12155876f, 0.20623176f, 0.57332176f, 
    -0.22766392f, -0.27706727f, -0.18952966f, -0.11222562f, 0.13379937f, -0.30779299f, 0.22572601f, -0.02896030f, 
    -0.01238325f, 0.20615512f, 0.13305607f, 0.01226361f, 0.02736741f, 0.00155091f, 0.05108063f, -0.11368413f, 
    0.16861123f, 0.24219343f, 0.29232109f, 0.04007221f, -0.12623332f, -0.12929651f, 0.09495294f, 0.20660965f, 
    0.06862070f, -0.50494206f, 0.02652658f, 0.07931276f, -0.05852374f, 0.14440747f, 0.28501582f, -0.19206528f, 
    0.08030779f, -0.01504805f, 0.18755712f, -0.15844058f, -0.09367841f, -0.08136693f, 0.02629713f, 0.18709032f, 
    0.29170680f, -0.23356928f, -0.15833648f, 0.14927514f, -0.17463572f, -0.08882825f, -0.03203814f, 0.00468302f, 
    0.00364546f, -0.00190889f, 0.15922092f, -0.00304840f, 0.10550842f, 0.29999179f, 0.14578159f, 0.02459881f, 
    -0.03664995f, 0.00789993f, 0.10309035f, 0.11397851f, 0.08555264f, -0.14552583f, -0.02754691f, 0.02589731f, 
    0.11347342f, -0.14012878f, -0.09924824f, 0.15564755f, -0.04528610f, -0.24209957f, -0.13477141f, -0.03993963f, 
    -0.00586527f, 0.13691211f, -0.20472568f, 0.11201262f, 0.10437090f, 0.08367755f, -0.12488838f, 0.11358601f, 
    0.07277319f, -0.23426509f, -0.08061557f, 0.11446735f, -0.16535188f, -0.08369967f, 0.03303285f, -0.16661777f, 
    0.01353599f, 0.44627732f, -0.29056635f, -0.04304709f, -0.09995629f, 0.23440854f, -0.17413455f, 0.07381622f, 
    -0.27523944f, -0.30700293f, 0.14483884f, -0.07284039f, -0.01507287f, -0.11559732f, -0.05013896f, 0.11620558f, 
    -0.43653008f, 0.39631894f, -0.21674629f, -0.11191377f, 0.03626839f, -0.01858979f, -0.11451998f, -0.06660660f, 
    0.21179955f, -0.17681555f, -0.14571545f, 0.14954098f, 0.10412560f, 0.23515730f, 0.07055520f, -0.01011857f, 
    -0.10865183f, -0.01237020f, -0.46018755f, 0.03093267f, 0.14283295f, -0.06906424f, 0.09015025f, -0.09779366f, 
    -0.21089549f, 0.20425034f, 0.29895648f, 0.14042243f, -0.12919213f, -0.14102365f, -0.12388925f, -0.09432013f, 
    0.18371829f, 0.45095956f, 0.11654551f, -0.01486781f, -0.02640987f, 0.07708035f, -0.02588488f, 0.11359527f, 
    0.01111082f, -0.18425837f, 0.28751290f, 0.08364346f, -0.04531684f, 0.20268700f, 0.04897467f, -0.07698516f, 
    0.03081976f, 0.18195643f, 0.03781822f, 0.02899016f, 0.04675535f, 0.36618516f, -0.20404121f, -0.03306147f, 
    0.32852250f, 0.25422934f, -0.51191300f, -0.15665624f, -0.02570736f, 0.13651235f, -0.35505918f, 0.13437644f, 
    0.21859717f, -0.50898910f, -0.20706691f, -0.03591032f, -0.12747660f, -0.18455049f, -0.12902957f, 0.01480741f, 
    -0.02108197f, 0.09251512f, -0.23537545f, 0.03826581f, 0.02077190f, 0.26195541f, -0.14712621f, -0.01955360f, 
    -0.16703156f, 0.20230727f, 0.56289059f, -0.06751438f, -0.05556392f, 0.32574618f, -0.07458105f, 0.06254749f, 
    0.06640302f, -0.44820076f, -0.55629885f, -0.15034170f, -0.00531555f, 0.28065825f, 0.08142076f, 0.02991475f, 
    -0.00934745f, 0.35703957f, -0.03863162f, 0.10040209f, 0.01703427f, 0.12186366f, -0.01896585f, 0.00747460f, 
    0.04012225f, 0.10987614f, -0.32081941f, -0.12501287f, 0.13251862f, 0.00422109f, -0.05893604f, -0.01935978f, 
    0.15609527f, 0.52556938f, -0.22907794f, 0.08408664f, -0.14456330f, 0.00884961f, -0.00443113f, -0.12889753f, 
    -0.37836826f, 0.33991194f, -0.10482536f, 0.14662072f, -0.03381734f, -0.17643736f, -0.40785536f, 0.07941572f, 
    -0.08900164f, 0.25633076f, 0.40822518f, 0.04932796f, -0.01014180f, 0.13052645f, 0.10569275f, -0.02336098f, 
    -0.03693033f, 0.08695766f, -0.15570143f, -0.16174448f, -0.14972624f, 0.20987703f, -0.12535234f, 0.28884184f, 
    -0.12719426f, 0.13370080f, 0.33895814f, -0.37568030f, -0.08964457f, 0.38615331f, -0.05453135f, -0.26138970f, 
    0.25467667f, 0.38083693f, 0.53318965f, 0.00365358f, 0.01166370f, 0.14364505f, -0.22702342f, -0.15097313f, 
    -0.22936375f, 0.19782613f, 0.25414771f, 0.06087078f, -0.09337673f, 0.06699172f, 0.01614330f, -0.16135421f, 
    0.44853032f, 0.43540141f, -0.08113927f, -0.02656077f, 0.08141196f, 0.13852392f, -0.16365503f, -0.31634837f, 
    0.04784979f, 0.61398220f, -0.09766082f, 0.40637121f, -0.16265438f, 0.10527264f, -0.13946456f, -0.32824230f, 
    -0.15595268f, 0.26695454f, 0.00716145f, 0.04618819f, -0.14285779f, -0.27801129f, -0.25781459f, 0.09209953f, 
    -0.00878680f, -0.16939726f, 0.48264065f, -0.04857660f, -0.16896941f, -0.12848932f, -0.04496211f, 0.13338792f, 
    -0.02544373f, 0.34944144f, 0.07254670f, -0.06174521f, -0.02457903f, -0.35294363f, -0.12857905f, 0.40536064f, 
    -0.01718986f, -0.34619766f, 0.51705551f, -0.23658022f, -0.00634088f, 0.17904761f, 0.23865001f, 0.30493981f, 
    0.04059000f, 0.28635296f, -0.02450049f, 0.09559868f, -0.01514000f, -0.18752950f, -0.07333835f, 0.23140271f, 
    -0.20454095f, -0.21707147f, 0.27371266f, 0.08942909f, -0.02601726f, -0.02604153f, 0.15214106f, 0.11299273f, 
    0.19377179f, 0.05932877f, -0.10493573f, -0.03219848f, 0.13468808f, 0.08512063f, 0.10075801f, 0.18779123f, 
    -0.05916341f, 0.08051335f, -0.40720269f, 0.35952470f, 0.08505371f, -0.12767588f, 0.24731733f, 0.04310033f, 
    0.13924551f, -0.11627798f, -0.49956542f, 0.06914360f, -0.06823968f, -0.13432923f, -0.18369097f, -0.39172313f, 
    0.42793056f, -0.01449216f, -0.02033831f, -0.09445552f, 0.16588248f, 0.08872595f, -0.09513322f, -0.00775651f, 
    -0.31301737f, -0.09097274f, 0.29254839f, 0.03645936f, 0.15393744f, 0.18161610f, 0.00461458f, 0.32242849f, 
    -0.14452106f, -0.09358844f, -0.23543377f, -0.04876325f, -0.12157389f, 0.11938998f, -0.08689988f, -0.24418768f, 
    -0.20899199f, -0.35586917f, 0.12645234f, -0.00681544f, 0.06046481f, 0.09168397f, 0.07314099f, 0.36167720f, 
    -0.14910300f, -0.28158444f, -0.46419945f, 0.09103053f, 0.02415459f, 0.04114636f, 0.00224150f, 0.16663945f, 
    0.06881088f, -0.04296703f, -0.00423025f, 0.16709499f, -0.16407882f, 0.03852112f, 0.15233643f, -0.19964443f, 
    0.08742461f, 0.17815369f, 0.00014704f, -0.20535509f, 0.02380341f, 0.19831850f, 0.01560480f, -0.06174126f, 
    0.40395543f, -0.01608840f, 0.16390280f, -0.02107599f, -0.02583230f, 0.29611760f, 0.02440969f, -0.70039016f, 
    0.37166348f, -0.02208916f, -0.37001243f, 0.17087190f, 0.05562874f, -0.00910381f, 0.01472460f, 0.07884505f, 
    -0.12450754f, -0.03745689f, 0.13184404f, -0.08436362f, 0.16074525f, -0.19444041f, -0.06348713f, -0.28449768f, 
    -0.00365740f, -0.11605787f, -0.66224200f, 0.20708604f, -0.15833223f, 0.19679257f, -0.12564680f, -0.25117943f, 
    -0.19773097f, -0.09033768f, 0.04974682f, 0.13769928f, -0.07661443f, -0.16958886f, 0.17931017f, 0.10258944f, 
    0.08689298f, -0.14792480f, 0.27742401f, 0.13285473f, 0.16819561f, 0.12358159f, 0.09878098f, -0.09339166f, 
    0.09921348f, -0.07168407f, 0.02849056f, 0.07897056f, 0.10389804f, 0.03911718f, -0.11752899f, -0.16938818f, 
    -0.06281652f, -0.18871374f, 0.09085196f, -0.16589858f, 0.12021217f, -0.18596183f, 0.34158418f, -0.01434085f, 
    0.36992991f, 0.20421934f, 0.06365252f, -0.07548229f, 0.00918981f, 0.51982576f, -0.23265813f, 0.06566751f, 
    0.11508679f, 0.24530300f, -0.09488902f, 0.13953389f, 0.02848684f, 0.02423791f, 0.06649400f, -0.03298600f, 
    0.16406800f, -0.38154727f, -0.08488914f, -0.10238178f, 0.02091228f, 0.24474920f, -0.10732756f, -0.22096600f, 
    0.14399508f, 0.03172430f, 0.06495184f, 0.46103138f, -0.01690254f, 0.23507658f, -0.18843086f, -0.44823900f, 
    0.16339125f, 0.19118893f, -0.11969243f, -0.04139157f, 0.04887705f, 0.26200068f, 0.19657429f, 0.20077728f, 
    0.07917876f, 0.02387896f, -0.25955796f, -0.00180078f, -0.01902842f, -0.10367328f, -0.02243447f, 0.06085728f, 
    -0.47334385f, 0.11769463f, -0.18118660f, 0.01730786f, -0.06744658f, 0.10720068f, 0.06067013f, 0.29271269f, 
    -0.11025072f, -0.07308217f, -0.11123703f, -0.10057531f, -0.01823509f, -0.17272474f, -0.20323887f, 0.12910198f, 
    0.04823051f, -0.02926778f, 0.12779517f, 0.15008640f, -0.13384269f, 0.12956257f, -0.11693559f, -0.08876241f, 
    -0.14841618f, -0.08509842f, -0.09131567f, -0.14315149f, -0.12627338f, -0.06991537f, 0.06583690f, 0.02967180f, 
    -0.00093989f, 0.03515831f, -0.17591955f, 0.06017948f, 0.16970068f, -0.09200002f, -0.01226515f, 0.10123731f, 
    0.06880453f, -0.31055617f, -0.18391192f, -0.20200624f, 0.09406278f, 0.10903760f, -0.29753819f, 0.14011149f, 
    -0.48207510f, -0.16300270f, 0.04439936f, -0.11909363f, 0.06617948f, -0.20868014f, 0.21967334f, 0.26527193f, 
    -0.03847354f, -0.23115575f, 0.27433115f, -0.10063031f, 0.13681839f, 0.11789993f, 0.04449990f, 0.08564204f, 
    0.41671175f, 0.01623673f, -0.23930813f, 0.11614298f, 0.01918746f, -0.02232735f, 0.09610623f, -0.26215884f, 
    0.16590342f, 0.29718912f, 0.47874820f, 0.26930425f, 0.08176401f, -0.45696798f, -0.19518514f, 0.29653808f, 
    0.30646148f, 0.22451353f, -0.26668501f, -0.08224270f, -0.01568156f, -0.14740895f, -0.11276118f, -0.65394342f, 
    0.10244957f, 0.13931328f, -0.27013716f, -0.05936008f, -0.05658078f, -0.00876536f, 0.03895594f, -0.00706678f, 
    -0.23702894f, -0.14832290f, 0.00730782f, -0.07669792f, 0.07475627f, -0.12515458f, 0.05719829f, 0.40851337f, 
    0.16209742f, 0.29703757f, 0.06114814f, -0.01067415f, -0.01825960f, -0.30349556f, 0.01371563f, -0.29246861f, 
    -0.28612974f, -0.02856688f, -0.13525297f, 0.16497833f, 0.13084631f, -0.23241343f, 0.11731771f, -0.06510683f, 
    -0.17198221f, 0.17763132f, 0.20259745f, 0.15536036f, 0.08716942f, -0.03467155f, -0.09467506f, -0.01871206f, 
    -0.00343096f, -0.14896947f, 0.15758947f, -0.04252046f, -0.11066058f, 0.09930795f, -0.07132412f, -0.19619241f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15945037f, 0.00904667f, 0.22931001f, -0.05170522f, 0.04852387f, 0.25684401f, -0.14210443f, 0.21026805f, 
    0.12529905f, -0.21684769f, 0.23650002f, -0.12028232f, 0.29425082f, -0.01470929f, 0.14875093f, 0.14485316f, 
    0.15972714f, 0.12041891f, -0.07996114f, -0.08061937f, -0.07310162f, 0.20995903f, 0.25348958f, 0.00932416f, 
    0.12111636f, -0.14692231f, -0.02962226f, 0.10779737f, -0.12737781f, -0.14187278f, -0.23182176f, -0.02543236f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.13263182f, 0.25608018f, -0.80208623f, 0.15854813f, -0.42317200f, -0.28514311f, 0.28285396f, 0.19029091f, 
    -0.27687883f, 0.03459640f, -0.17576195f, 0.22095172f, -0.61257756f, -0.14698356f, -0.82381678f, 0.00390785f, 
    -0.64089847f, 0.03594277f, 0.17124873f, 0.15591443f, 0.24004787f, -0.00926554f, -0.63291734f, -0.19971761f, 
    0.05423650f, 0.09839477f, -0.51789904f, 0.01561171f, -0.13462022f, 0.10499797f, 0.24640727f, 0.03550389f, 
    -0.36798424f, 0.03119817f, -0.18746784f, 0.24338758f, -0.04145129f, 0.29035646f, -0.27570981f, 0.21862502f, 
    0.00568885f, 0.32155007f, 0.00543174f, -0.18981236f, 0.08190669f, -0.18525064f, 0.18840347f, -0.10441606f, 
    -0.08004999f, 0.40336403f, 0.08025064f, 0.12509546f, 0.34803119f, 0.10743128f, -0.74474865f, -0.31907710f, 
    -0.42187372f, -0.09822834f, -0.10417117f, 0.07429919f, 0.15047958f, -0.06967075f, -0.89347643f, -0.02191129f, 
    -0.05587557f, 0.24576473f, -0.04112533f, -0.28678760f, 0.10715771f, -0.24715655f, -0.25432956f, 0.15063202f, 
    0.13708255f, 0.35100484f, 0.17119730f, -0.18430862f, 0.23870295f, 0.03322617f, -0.46479815f, -0.34105694f, 
    0.53938442f, -0.46007621f, -0.39179394f, -0.36804354f, -0.57760602f, 0.22493830f, 0.03947821f, -0.07284269f, 
    0.15602298f, 0.07798970f, -0.03400278f, 0.22800709f, -0.09996153f, -0.00833676f, 0.24705409f, -0.06049982f, 
    0.27374059f, -0.51635528f, 0.10463165f, 0.14704522f, 0.06535537f, -0.25347918f, 0.24822833f, 0.02565529f, 
    -0.72235918f, 0.18088168f, -0.00550439f, -0.14499715f, -0.04271534f, 0.07603851f, -0.90064687f, 0.11355875f, 
    -0.04393855f, -0.53471875f, 0.16897270f, -0.00759949f, 0.00882461f, 0.28719094f, -0.27144182f, -0.78510219f, 
    0.04965176f, -0.19539091f, 0.59159029f, -0.29918641f, -0.05326746f, -0.09411068f, 0.14523757f, -0.36390889f, 
    0.15657572f, -0.05445204f, -0.00183852f, -0.09995358f, -0.45135483f, -0.48577687f, 0.00611577f, -0.24391417f, 
    0.20616357f, 0.01062534f, 0.18283270f, 0.11890265f, -0.22676493f, -0.19020246f, 0.28646940f, 0.14284648f, 
    0.17871644f, 0.01626258f, 0.16209239f, -0.23324323f, 0.13311107f, -0.05027464f, 0.26623836f, 0.15146036f, 
    -0.52729559f, 0.28313056f, -0.57226187f, 0.01279815f, -0.03140197f, 0.22909528f, 0.29005381f, -0.34531420f, 
    0.22207642f, 0.11730792f, 0.07793497f, -0.60902399f, 0.17322069f, 0.08118388f, -0.11704566f, 0.10190529f, 
    0.40956664f, 0.00907186f, -0.21261543f, 0.30789822f, -0.20823866f, -0.13667518f, 0.12772456f, -0.14299218f, 
    -0.12985371f, 0.05358815f, -0.01679482f, 0.18847013f, 0.11177523f, -0.04572168f, -0.19558799f, 0.21589062f, 
    0.48271993f, -0.15084237f, -0.31277964f, -0.46634609f, 0.08775771f, -0.19064915f, -0.29789588f, -0.17890976f, 
    -0.33830312f, -0.45501474f, 0.34109256f, -0.07739499f, -0.01654159f, 0.23805620f, -0.45628786f, 0.38716194f, 
    -0.34427345f, -0.58277482f, 0.33344892f, 0.03292812f, 0.27522585f, 0.09844151f, -0.59915596f, 0.36002216f, 
    -0.60054839f, -0.50793016f, -0.43381664f, -0.74738950f, -0.87641835f, -0.45103139f, 0.41847265f, 0.22452617f, 
    -0.12234971f, -0.07983081f, 0.16526718f, -0.09233607f, -0.03172181f, 0.17165817f, -0.32493526f, -0.40596789f, 
    -0.03391555f, 0.03975732f, 0.11292014f, 0.14933491f, -0.20180885f, 0.23787189f, -0.07287186f, -0.40506911f, 
    -0.24053504f, -0.72733063f, -0.10435006f, -0.67046642f, -0.02261111f, 0.01445019f, 0.01464336f, -0.41892964f, 
    0.67071337f, -0.02503745f, -0.29765528f, 0.08314641f, -0.58833039f, -0.43527448f, 0.04566415f, 0.09818471f, 
    0.33025414f, 0.23186706f, 0.14662635f, 0.27737918f, -0.07354715f, 0.22868697f, 0.19293079f, 0.23029773f, 
    0.32200238f, 0.42789009f, -0.46295956f, 0.01948465f, 0.22946793f, 0.14489512f, -0.34333178f, 0.06620577f, 
    0.19157653f, -0.49279380f, -0.51211673f, -0.40865350f, 0.27831391f, 0.12949476f, -0.53249282f, 0.36666399f, 
    -0.47381598f, -0.35190943f, -0.35408983f, 0.24186097f, -0.73964638f, -0.04790085f, -0.23836027f, -0.31055981f, 
    0.14059606f, 0.03790601f, 0.32498980f, -0.27731106f, 0.10786703f, -0.26271507f, -0.22851796f, -0.47923487f, 
    -0.41197604f, 0.03205676f, -0.10964196f, 0.03954855f, -0.05067308f, 0.12491352f, 0.30832610f, -0.18360372f, 
    -0.02364535f, -0.07975106f, 0.23617524f, -0.07613266f, 0.08988099f, 0.04100803f, -0.78960311f, -0.03888017f, 
    -0.71494848f, 0.15750752f, -0.05027601f, -0.82397974f, 0.06790051f, -0.46700051f, 0.25308037f, -0.00773526f, 
    0.26946929f, 0.08810163f, -0.18837449f, 0.42104360f, 0.12065410f, -0.23132512f, 0.48669323f, -0.94539034f, 
    0.19584396f, 0.13097332f, 0.42128393f, 0.28039524f, -0.33218816f, -0.31964195f, -0.66525173f, 0.28002438f, 
    0.08068553f, -0.65936005f, -0.63534862f, -0.47405219f, 0.22099580f, 0.11291498f, -0.66863835f, 0.21628803f, 
    0.43613347f, -0.67690873f, 0.30091977f, 0.05214792f, 0.05834607f, 0.00041334f, 0.11178882f, -0.68957061f, 
    -0.02507716f, -0.19932763f, -0.20732324f, 0.27853933f, 0.14391845f, -0.24648717f, -0.62103003f, -0.43997157f, 
    0.51257670f, -0.32414183f, 0.37975568f, 0.18891717f, 0.29648638f, -0.09712827f, -0.35109812f, -0.41911510f, 
    -0.51794618f, -0.61964101f, 0.22857615f, 0.40565968f, 0.04094329f, -0.05576279f, -0.18404119f, -0.43805873f, 
    -0.21835561f, 0.13088091f, -0.03801352f, -0.13497256f, -0.35303840f, 0.37387043f, -0.05960961f, -0.60100460f, 
    -0.51849538f, -0.45517308f, -0.00753153f, -0.15405937f, 0.00942387f, -0.58969742f, -0.23868161f, -0.24976733f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.32774892f, 0.09077977f, 0.04455065f, -0.06226502f, 0.09308901f, -0.09411852f, 0.00515898f, -0.04286553f, 
    -0.08330168f, 0.00759439f, 0.00671821f, 0.21589568f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
