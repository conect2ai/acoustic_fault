#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.12733528f, -0.57020807f, -0.81688017f, 0.04767690f, 0.63826996f, 0.67842084f, 0.07533320f, 0.20479763f, 
    -0.20409979f, 0.69334674f, 0.46479794f, 0.34219381f, 0.37595078f, 0.50623870f, -0.14909092f, 0.18139905f, 
    -0.01223808f, 0.50889069f, 1.08234870f, -0.79322612f, -0.68341511f, 0.05321397f, 0.05797290f, 0.04535984f, 
    -0.07585876f, 0.01344354f, -0.07648405f, 0.41543096f, 0.59335399f, -0.67845494f, 0.29141203f, -0.48631683f, 
    -0.19509189f, -0.11586623f, 0.24552523f, 0.11821696f, -0.12801799f, 0.05545042f, -0.63060844f, -0.36095282f, 
    -0.19520815f, -0.56694710f, -0.08788791f, -0.38845178f, -0.29674247f, -0.28013560f, 0.02450325f, -0.03620075f, 
    -0.52752370f, -0.62991631f, -0.53578931f, 0.40204808f, 0.42128012f, 0.24040194f, -0.75358278f, -0.42301786f, 
    0.01007651f, -0.37190267f, 0.56585795f, -0.47212207f, 0.23644206f, 0.01490497f, 0.17787151f, -0.05126283f, 
    0.08408201f, 0.19440924f, -0.05887977f, 0.02142463f, -0.19122185f, 0.48805311f, -0.58453631f, 0.06643122f, 
    -0.12595041f, 0.45284906f, 0.36930162f, -0.13466001f, -0.75790668f, -0.43067199f, -0.12156499f, -0.23291922f, 
    -0.29220387f, 0.49458286f, 0.49326116f, 0.18521713f, -0.41058043f, 0.48092914f, 0.35961628f, 0.21167465f, 
    -0.00342593f, -0.24549977f, 0.12595508f, -0.15845904f, -0.41004196f, -0.26465592f, 1.13338101f, -0.84030896f, 
    -0.29384267f, -0.15739156f, 0.03384482f, -0.18726867f, 0.00290055f, -0.54788822f, -0.23515977f, 0.15187603f, 
    0.07236310f, -0.45532307f, -0.18065010f, -0.57915926f, -0.24270627f, -0.21105546f, -0.15102884f, 0.50816363f, 
    -0.13090526f, 0.84582484f, -0.20189817f, 0.30312893f, 0.10976988f, -0.48305190f, 0.00400544f, 0.24877761f, 
    0.14860152f, 0.13763860f, 0.67458868f, -0.39970794f, 0.03399518f, -0.50786811f, 0.37643752f, 0.77387780f, 
    -0.31308377f, -0.46572089f, 0.15529692f, -0.09427928f, -0.15087888f, 0.02949178f, 0.00938984f, 0.26248813f, 
    -0.27382442f, 0.25859976f, -0.13449752f, -0.01167888f, 0.02557574f, -0.05683914f, 0.20440765f, 0.63022369f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14879137f, 0.01871983f, -0.10162538f, 0.12838939f, -0.05838411f, 0.18276678f, -0.08192173f, 0.38903359f, 
    -0.25274169f, 0.06417294f, -0.08410361f, -0.35500625f, -0.26418903f, -0.05113886f, 0.17008039f, 0.17576635f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.20850627f, 0.20880997f, 0.19939978f, -0.13718419f, 0.13049604f, -0.04258756f, 0.16970956f, 0.02831005f, 
    0.04972083f, 0.10920005f, -0.04965552f, 0.10787898f, -0.05589285f, -0.12970467f, 0.10292982f, -0.06522834f, 
    0.06467247f, 0.02690734f, 0.08082067f, 0.20096412f, -0.51253265f, -0.06439173f, -0.04718857f, -0.15071106f, 
    -0.06610363f, -0.04173946f, -0.00826624f, 0.34293884f, -0.18077889f, -0.04880761f, -0.01760563f, -0.06413383f, 
    -0.17124549f, 0.17557505f, 0.21183072f, -0.01568023f, -0.06970830f, 0.05791154f, -0.17382286f, 0.05946270f, 
    0.07625473f, 0.21775936f, 0.04833536f, 0.00238403f, 0.06516712f, -0.20777071f, -0.13158791f, -0.35256693f, 
    -0.11078825f, 0.18195225f, -0.17199901f, 0.18665005f, 0.09308280f, -0.00809037f, -0.24677283f, -0.12730996f, 
    0.29239261f, 0.10035603f, 0.04757199f, -0.11687601f, 0.07032059f, -0.04560547f, 0.03733413f, -0.03629846f, 
    -0.07170586f, -0.06683097f, 0.05317540f, 0.03527351f, 0.07686108f, -0.01239966f, 0.01824144f, 0.26521900f, 
    -0.43496302f, -0.33719528f, -0.19313748f, -0.13287814f, 0.15257779f, -0.17807208f, 0.10514692f, -0.10545899f, 
    0.06010096f, 0.33667567f, 0.03355193f, -0.03320913f, -0.09524163f, -0.08178006f, 0.00511821f, 0.08948545f, 
    0.07053436f, 0.12505017f, -0.51389754f, -0.46450412f, 0.26014704f, 0.03786917f, -0.10289732f, 0.03817107f, 
    0.13123107f, -0.03868435f, 0.23809853f, 0.07527354f, 0.01181382f, 0.31496805f, -0.15119068f, -0.07454926f, 
    0.01234905f, 0.04756004f, -0.02648129f, -0.01595549f, -0.34955418f, 0.09536916f, -0.20391421f, 0.03626730f, 
    0.00090144f, 0.16900453f, -0.15782866f, -0.01605983f, 0.08065299f, 0.06552602f, -0.10895182f, -0.19761683f, 
    -0.10860138f, -0.13516687f, -0.05903241f, -0.10911933f, -0.01229623f, 0.07611040f, 0.33436930f, -0.18989715f, 
    -0.07867373f, -0.08002024f, 0.04575781f, 0.20116691f, -0.05724807f, 0.09718461f, 0.10237359f, 0.37566128f, 
    0.07183282f, -0.28168118f, 0.03395427f, 0.06770720f, 0.01830389f, 0.14951296f, 0.09406680f, 0.19780472f, 
    -0.08332472f, -0.15190896f, 0.00909818f, -0.06844728f, -0.07089728f, -0.13447499f, -0.09265203f, -0.06879962f, 
    0.01984347f, -0.17074628f, 0.17505637f, 0.10377956f, -0.01870877f, -0.11246243f, -0.02518845f, 0.20095876f, 
    0.00975048f, 0.05242353f, 0.00544156f, -0.21644408f, 0.07978643f, -0.08614816f, 0.02640566f, 0.26111293f, 
    -0.01831593f, -0.04755705f, -0.03072862f, -0.14308487f, -0.16103590f, 0.03790133f, -0.07241516f, 0.09197310f, 
    0.22127137f, 0.12675095f, 0.04738576f, 0.02212303f, 0.12142207f, 0.27197298f, -0.06393301f, -0.00321357f, 
    0.09555081f, 0.10297038f, 0.02059461f, 0.10816105f, -0.01943179f, -0.05180071f, -0.04966316f, 0.13333558f, 
    0.02448026f, -0.00734124f, 0.08024376f, 0.20783481f, 0.15637180f, 0.08081867f, -0.06928214f, 0.10329873f, 
    0.21971717f, 0.17390156f, -0.19879374f, -0.06812494f, 0.02577463f, 0.12606594f, -0.03419699f, -0.11206723f, 
    0.03023875f, -0.05453708f, 0.01585458f, 0.10520776f, 0.08878861f, -0.13745970f, 0.09492220f, -0.08294918f, 
    -0.01271136f, -0.51031947f, -0.15523656f, 0.14252003f, -0.09440869f, 0.00764564f, 0.12472241f, -0.23037405f, 
    -0.04448781f, -0.15149063f, 0.21316567f, 0.07962096f, 0.09283817f, 0.10198180f, 0.00388128f, -0.03063137f, 
    -0.17877498f, -0.05496333f, 0.04748984f, 0.28259879f, -0.17590615f, 0.05749644f, 0.10987155f, 0.06211420f, 
    0.03853532f, -0.05819327f, -0.02946362f, -0.09567050f, -0.01827236f, -0.09540089f, 0.10945504f, -0.06311209f, 
    -0.07097673f, 0.04977309f, -0.09726087f, 0.09189185f, 0.00300626f, -0.01847437f, -0.09666155f, 0.06948983f, 
    0.08333772f, -0.02329150f, -0.06170156f, 0.16517100f, -0.05682754f, -0.19216093f, 0.14330494f, 0.01259786f, 
    0.05451385f, 0.08729040f, -0.04804097f, -0.15035523f, -0.56231946f, -0.32888839f, 0.01139366f, 0.08824372f, 
    -0.28240001f, 0.13618343f, 0.16743803f, 0.03509919f, -0.08377559f, -0.15962559f, -0.17139916f, 0.03613422f, 
    -0.04515897f, 0.13334771f, -0.01291345f, 0.10032135f, -0.00049887f, 0.17221595f, 0.22620849f, 0.36216491f, 
    0.23452590f, -0.09583478f, 0.02588591f, 0.07498972f, -0.03321547f, 0.14723964f, 0.01332960f, 0.03651044f, 
    -0.04483938f, -0.24986312f, -0.07328457f, -0.06832746f, 0.07315212f, 0.06074926f, -0.04392389f, -0.05132767f, 
    -0.01327527f, 0.10651137f, 0.12146062f, -0.23486169f, -0.02323376f, 0.15473485f, -0.01038356f, 0.09400839f, 
    -0.00973154f, -0.19830675f, -0.19849794f, -0.16829754f, -0.36126229f, 0.13027245f, -0.12063712f, -0.15202165f, 
    0.12061978f, -0.04616816f, 0.04540562f, -0.00716333f, 0.23317504f, 0.20573860f, -0.16391814f, 0.02496349f, 
    0.09666858f, 0.08535653f, -0.02448376f, 0.02019650f, -0.12157363f, 0.06265379f, 0.08761780f, 0.29980186f, 
    0.00327016f, -0.01454348f, 0.00586086f, -0.02369747f, 0.20459251f, 0.27694297f, 0.50297213f, 0.16800974f, 
    0.10023779f, 0.06984270f, 0.07881352f, -0.07256930f, 0.06380921f, 0.04526357f, 0.02005013f, -0.09991346f, 
    -0.01600656f, 0.13967833f, 0.00038492f, -0.19147801f, -0.05724831f, 0.13332915f, 0.12554710f, 0.11912994f, 
    0.03777223f, -0.30539110f, -0.20538011f, -0.01698821f, 0.03541793f, 0.07828908f, -0.10146208f, -0.06269895f, 
    0.04860185f, -0.07374907f, -0.33082426f, 0.19575484f, 0.01054763f, -0.09552682f, 0.18940723f, -0.14914496f, 
    0.32120752f, 0.03693553f, 0.03968586f, 0.09454287f, 0.23983631f, 0.05361603f, -0.07149313f, -0.03611329f, 
    -0.03441693f, 0.04155855f, -0.14589822f, 0.14894162f, 0.18012458f, -0.06781041f, 0.01033492f, -0.02706209f, 
    -0.26108268f, -0.05780523f, 0.02226414f, -0.00310803f, -0.13624106f, 0.06633527f, 0.24242966f, -0.11245179f, 
    0.00183902f, -0.18437816f, 0.07680688f, -0.01886666f, -0.03197129f, -0.38925806f, 0.17198655f, 0.15772054f, 
    0.06702671f, 0.01356012f, 0.01049993f, 0.02593564f, -0.06284601f, -0.00102584f, -0.08519500f, -0.44530034f, 
    0.21368952f, 0.04616440f, -0.08816730f, 0.04985777f, 0.10870492f, 0.12647302f, -0.00785564f, -0.05596111f, 
    0.25573081f, -0.07035509f, -0.14656147f, 0.17936333f, -0.12181703f, -0.05048158f, 0.07691117f, 0.09865350f, 
    0.21851173f, -0.05729736f, -0.00609617f, 0.10846738f, 0.01616023f, 0.03597999f, 0.01388275f, 0.09336248f, 
    0.08250760f, 0.15115172f, -0.10151618f, -0.17986247f, 0.14241187f, 0.08830551f, 0.12734549f, -0.10110868f, 
    -0.16274856f, 0.03130798f, -0.14656909f, 0.18446980f, 0.10013164f, -0.21087551f, -0.01189194f, -0.00793591f, 
    -0.05247869f, 0.12508290f, 0.01310365f, -0.24437986f, 0.16063718f, -0.34598824f, -0.01655715f, 0.09891079f, 
    0.04160901f, 0.10168868f, 0.00958084f, -0.11887474f, 0.16031632f, 0.09904443f, 0.06120532f, 0.08392580f, 
    -0.06516036f, -0.04229176f, 0.08959457f, -0.18494448f, 0.05134311f, 0.06314886f, 0.03616144f, -0.06036394f, 
    0.14258766f, 0.04241222f, -0.05198916f, -0.21156901f, -0.24305996f, -0.10019904f, -0.01417046f, 0.07924627f, 
    0.16403554f, 0.09418616f, 0.03570232f, 0.21117505f, 0.24932837f, 0.10628865f, -0.14872733f, -0.04783535f, 
    -0.00177321f, -0.09683408f, -0.03717794f, -0.04347505f, 0.01906372f, -0.02284472f, -0.03914915f, 0.04138022f, 
    -0.17239431f, 0.22329423f, 0.20082363f, 0.13269149f, 0.01056982f, -0.00954785f, 0.16222541f, -0.01532359f, 
    0.09148014f, -0.21727595f, -0.10544000f, -0.07239114f, 0.14158121f, 0.05562809f, 0.12928717f, 0.04809775f, 
    0.09473900f, 0.02640056f, 0.16509420f, -0.00824665f, 0.27872461f, 0.08765883f, -0.04711379f, 0.02818019f, 
    -0.03494743f, 0.13527334f, 0.10520186f, 0.17755671f, -0.04838967f, 0.26170841f, 0.00571100f, 0.06218098f, 
    0.08701146f, -0.06805827f, 0.10099047f, -0.04098831f, 0.09786421f, 0.00583492f, -0.27185270f, 0.17579050f, 
    0.09378350f, -0.02707374f, -0.04503166f, -0.06751620f, 0.08781871f, -0.04271727f, -0.04107225f, -0.27977911f, 
    -0.03517968f, 0.03656046f, 0.08360222f, 0.02901099f, 0.02568644f, 0.13744341f, -0.39249539f, 0.13873734f, 
    -0.40327701f, 0.02284289f, -0.19751671f, 0.02959723f, 0.12932180f, -0.06422638f, 0.04098239f, -0.18789448f, 
    0.08345536f, -0.09406848f, -0.00160112f, -0.07770749f, -0.02384689f, -0.24535559f, -0.07952239f, -0.27336481f, 
    0.19571735f, -0.19295667f, -0.20563745f, -0.09556787f, -0.03200898f, 0.15386002f, -0.03332319f, -0.04280313f, 
    0.05160668f, 0.08456262f, 0.16069359f, -0.21995902f, 0.06100563f, -0.07189126f, -0.00852130f, -0.01214624f, 
    -0.13210933f, -0.07040554f, -0.29631922f, 0.09429798f, 0.19610678f, 0.07447743f, 0.14796637f, 0.06286912f, 
    0.05133954f, -0.04842968f, 0.12253746f, 0.16869096f, 0.03613720f, 0.16421528f, 0.12533243f, 0.05220344f, 
    0.08416621f, -0.03616173f, 0.04740101f, -0.01530364f, 0.21215992f, -0.09705994f, 0.05728570f, 0.12429166f, 
    0.04292498f, -0.06935077f, -0.07777997f, 0.02921721f, 0.07074695f, -0.01002699f, -0.06687550f, -0.07286697f, 
    0.20997022f, -0.01890231f, 0.02830690f, -0.19118102f, -0.03747494f, -0.15495777f, 0.01716670f, -0.10970847f, 
    -0.31202143f, 0.26400328f, 0.06457923f, 0.12636217f, -0.18810369f, -0.13922162f, -0.15705271f, 0.07062481f, 
    0.05559565f, 0.09815119f, 0.11455444f, 0.01175731f, 0.01951531f, 0.05341307f, 0.07414354f, 0.06803990f, 
    0.22540008f, 0.11034552f, 0.19279863f, 0.14217661f, -0.08605807f, -0.02333317f, -0.03199309f, 0.09379849f, 
    -0.05818960f, -0.20992775f, 0.28385773f, 0.24885218f, 0.17165755f, -0.06621527f, -0.06731518f, 0.10515856f, 
    0.07553368f, 0.02152834f, -0.05468869f, -0.14329761f, -0.20166640f, 0.06496974f, 0.10851582f, 0.05678632f, 
    0.03871666f, 0.01422203f, 0.07161672f, 0.16483608f, -0.11523703f, -0.19733314f, -0.07344665f, -0.01859156f, 
    0.17348747f, 0.08871562f, -0.00166135f, 0.33451086f, 0.04230745f, -0.62474275f, -0.02141925f, 0.02645348f, 
    -0.05328863f, 0.19602922f, -0.07498742f, -0.25288254f, -0.20515414f, -0.12029853f, -0.17774506f, -0.17504355f, 
    -0.01915985f, -0.21065526f, 0.12194385f, 0.11262909f, 0.23780248f, 0.05065559f, 0.03201554f, 0.15881521f, 
    0.05482635f, -0.03408996f, 0.06603106f, -0.08996042f, -0.02783836f, -0.07283150f, 0.03633322f, -0.03607569f, 
    0.00051676f, -0.14965175f, 0.05582890f, 0.11644382f, -0.15323997f, -0.04876232f, -0.29740474f, -0.37041724f, 
    -0.09861179f, 0.24731255f, 0.24293326f, -0.30739409f, 0.04867817f, 0.10390973f, 0.02769053f, 0.08611644f, 
    -0.02634696f, -0.40950215f, -0.03361559f, -0.11296177f, 0.05375461f, 0.07283301f, 0.03196922f, 0.21094005f, 
    -0.04436775f, 0.17358121f, -0.17735514f, -0.13703173f, -0.42312694f, 0.06645324f, 0.04926953f, -0.08179123f, 
    -0.06854645f, -0.18699040f, -0.10417119f, 0.07629374f, -0.16135252f, -0.26117197f, -0.31708238f, 0.13237327f, 
    -0.10210551f, 0.16008511f, 0.13681050f, 0.06629943f, -0.06332689f, 0.16391702f, 0.14726482f, 0.11842047f, 
    -0.08866564f, 0.13256471f, 0.07215087f, -0.03176441f, 0.10384310f, 0.29091200f, 0.34091210f, 0.29978144f, 
    -0.05172611f, 0.05225907f, 0.04020440f, 0.15779345f, 0.02138503f, 0.06149933f, 0.15495603f, 0.15750736f, 
    0.23025811f, -0.15451431f, -0.19097567f, 0.02244046f, -0.00983288f, 0.08032583f, -0.05009984f, 0.08154938f, 
    0.09939316f, 0.05043638f, 0.08345946f, 0.07213573f, 0.09431804f, 0.02909517f, -0.02720059f, -0.02160804f, 
    0.24677435f, -0.12194981f, 0.25015354f, 0.19145447f, 0.00272466f, -0.09953754f, -0.00038478f, -0.12129908f, 
    -0.05277175f, -0.43068054f, -0.09499381f, -0.15402356f, 0.05905578f, -0.06429633f, -0.14453220f, 0.06961169f, 
    0.12283731f, 0.09942304f, -0.34423906f, 0.12968007f, -0.09776059f, -0.19771253f, -0.16297948f, -0.16579923f, 
    -0.00063129f, 0.04061916f, 0.13333294f, -0.16068208f, -0.13403690f, -0.09610820f, -0.08178003f, -0.14482330f, 
    0.14708839f, 0.01840870f, -0.06792352f, -0.04817433f, 0.30529389f, -0.07451602f, -0.21243517f, -0.17480657f, 
    0.24403013f, -0.13846862f, 0.14535348f, 0.12474490f, 0.17215657f, -0.00336470f, -0.07759741f, -0.04938427f, 
    -0.26068395f, 0.01213964f, -0.05063431f, -0.16461831f, -0.01819509f, 0.07540853f, 0.37375066f, -0.65287793f, 
    -0.43005618f, -0.07892796f, 0.04786425f, 0.06656940f, 0.25602072f, 0.03342944f, 0.04466977f, -0.17441049f, 
    -0.13580869f, -0.02958908f, 0.06120285f, 0.13596003f, -0.08233225f, -0.12113503f, 0.03504585f, 0.04872853f, 
    -0.15044618f, -0.71127647f, -0.31161192f, -0.17208168f, -0.01443761f, 0.13367924f, 0.12438178f, -0.01464235f, 
    0.07454695f, 0.32616207f, 0.00890099f, 0.17822401f, -0.04673581f, -0.04337387f, -0.03757675f, 0.00534490f, 
    0.00184985f, -0.03055510f, 0.16892049f, 0.02140680f, -0.20785761f, -0.04413868f, 0.35703999f, 0.06363890f, 
    0.17387041f, -0.08279484f, -0.10711844f, 0.36408570f, -0.00025950f, -0.24917789f, -0.04068698f, 0.19165659f, 
    0.27026886f, -0.03116575f, -0.06271853f, -0.01932427f, -0.51206690f, -0.23826616f, -0.12179276f, -0.03142698f, 
    0.01392185f, -0.04157847f, -0.01316162f, 0.05732776f, -0.00580384f, -0.30624050f, 0.32311547f, 0.02976517f, 
    0.04621465f, -0.08672322f, -0.01755830f, 0.05784469f, 0.00210189f, 0.13178012f, -0.13516237f, -0.00625870f, 
    -0.27868026f, -0.15016367f, -0.06792698f, -0.02738571f, 0.09097246f, -0.04549360f, -0.13199791f, 0.17849015f, 
    0.28304315f, 0.05044143f, 0.15071906f, 0.11162296f, -0.05635155f, 0.08320627f, -0.12025230f, 0.11043886f, 
    0.14832552f, -0.05114326f, 0.22027044f, -0.02792390f, -0.03365054f, 0.00619303f, 0.10288144f, -0.07143431f, 
    0.14719179f, 0.14496523f, -0.00698574f, 0.13437206f, 0.04611164f, -0.05777026f, 0.00753919f, 0.06998412f, 
    -0.00354830f, 0.01635408f, -0.45769444f, 0.57530117f, -0.57798320f, -0.09334053f, 0.02218276f, 0.01565740f, 
    -0.20454268f, -0.04588390f, 0.10440765f, 0.06216758f, -0.38399795f, -0.54202390f, 0.03881406f, 0.06352600f, 
    -0.13830088f, 0.09427557f, 0.00821517f, -0.07780862f, 0.25043589f, -0.13171317f, -0.14484020f, -0.14359429f, 
    -0.07523225f, -0.36034468f, -0.09004519f, -0.08994683f, -0.15555923f, 0.14711900f, 0.21249571f, 0.06965830f, 
    -0.21062945f, -0.08383854f, -0.04076128f, 0.08569735f, -0.11344574f, -0.12298761f, 0.13328016f, -0.25687149f, 
    0.05489039f, 0.18462887f, 0.10777979f, -0.06161402f, -0.00384368f, -0.00166172f, -0.01109837f, -0.22619194f, 
    0.05622261f, -0.03160661f, -0.00977599f, 0.13058007f, 0.13875091f, 0.05229556f, 0.05380074f, 0.10255716f, 
    -0.19679311f, -0.28620443f, 0.01488185f, -0.02069774f, 0.05910774f, 0.14240524f, -0.00827572f, 0.05621620f, 
    0.16249339f, 0.11381499f, 0.16655581f, 0.09219577f, -0.13661687f, -0.10131174f, 0.09867568f, -0.01469152f, 
    -0.00632901f, -0.07615250f, -0.13487412f, 0.22980276f, 0.48736480f, -0.15323840f, 0.12628202f, 0.10454550f, 
    0.06166597f, 0.04021379f, -0.07850948f, 0.29906189f, 0.14116548f, 0.05646310f, 0.01788291f, 0.03494957f, 
    -0.08374693f, 0.01756678f, 0.17546436f, -0.08490808f, 0.17479892f, 0.01916915f, 0.28484416f, 0.11176904f, 
    0.03985589f, -0.02487547f, 0.12915394f, 0.10521054f, 0.17431581f, 0.05651221f, 0.04896637f, 0.00263709f, 
    0.15665194f, -0.04208705f, 0.03834022f, -0.01667027f, -0.06537470f, -0.09469274f, 0.06650195f, -0.19421668f, 
    0.09442307f, 0.07173415f, -0.12050525f, 0.09741294f, 0.14997071f, -0.01679864f, -0.05649278f, 0.14600880f, 
    0.20849046f, 0.23576032f, 0.23332751f, 0.06749325f, 0.09116593f, 0.09227340f, 0.03354111f, -0.01108719f, 
    0.32483318f, 0.01966304f, 0.24690224f, -0.09891446f, -0.03297194f, -0.10384981f, 0.08771142f, 0.05316036f, 
    -0.15925980f, 0.09026294f, 0.28638199f, 0.04526641f, 0.14632525f, -0.05999685f, -0.01898459f, 0.10678007f, 
    -0.02783258f, 0.00703087f, -0.19697480f, 0.42715859f, 0.37733454f, 0.07235571f, 0.08534735f, -0.06764685f, 
    0.32327187f, 0.03749947f, 0.01605244f, 0.08072918f, 0.06908060f, 0.12417123f, -0.02390631f, 0.23027091f, 
    0.10785414f, 0.02081387f, 0.07152382f, 0.19898823f, -0.25910324f, -0.13246195f, -0.11223602f, 0.13139477f, 
    -0.07471468f, 0.03154402f, -0.08811945f, -0.01219583f, -0.12691139f, -0.21262826f, -0.23437636f, -0.23345116f, 
    -0.10442561f, 0.01011058f, -0.01090455f, 0.22726068f, -0.01184399f, 0.01935607f, 0.10303076f, 0.13891941f, 
    -0.00914758f, -0.07388907f, 0.06437588f, -0.04080783f, -0.09736194f, 0.13581212f, 0.05900544f, -0.05195438f, 
    0.01010930f, 0.11461988f, -0.21014565f, 0.04655781f, -0.22706965f, -0.01543532f, -0.03499217f, -0.38912690f, 
    -0.42687997f, -0.20440295f, -0.14380911f, 0.15846802f, 0.06289718f, -0.02157536f, -0.02879748f, 0.06559343f, 
    0.04088837f, 0.22679032f, 0.23969489f, -0.08720769f, -0.20917246f, -0.05424415f, -0.15878315f, 0.07548770f, 
    -0.00906152f, -0.01396649f, -0.39956895f, -0.41264585f, -0.65647256f, 0.11969855f, 0.08397532f, 0.09024189f, 
    0.01752555f, 0.08781711f, 0.08474405f, -0.27091965f, -0.08114398f, 0.12242949f, -0.09949075f, 0.01071747f, 
    0.02380287f, -0.00579666f, 0.09913248f, 0.05501863f, 0.14408728f, -0.30530331f, -0.37528452f, -0.25145927f, 
    0.18260425f, -0.12385292f, 0.15683100f, -0.00008518f, 0.11113819f, -0.17717779f, -0.23230842f, -0.06145920f, 
    0.03178166f, -0.07794153f, -0.07569490f, 0.04672151f, 0.04531081f, 0.10180975f, 0.19822457f, -0.38849947f, 
    0.08404573f, -0.10606132f, 0.05607445f, 0.05758102f, -0.00821025f, -0.04447503f, -0.08818708f, 0.23734321f, 
    0.10536611f, 0.17731833f, -0.16184737f, 0.10011180f, -0.00209332f, 0.19461302f, 0.40739831f, 0.06469379f, 
    -0.01276842f, 0.27356696f, -0.13446623f, -0.22855014f, -0.17857720f, -0.01208363f, -0.02044497f, 0.02290032f, 
    0.02402436f, 0.22765060f, 0.41860119f, -0.09114411f, -0.08023320f, -0.09367173f, -0.03756600f, -0.14487417f, 
    -0.04135451f, 0.01417436f, -0.84705228f, -0.10147008f, 0.14703509f, 0.07382604f, -0.01456203f, -0.23674674f, 
    0.02877407f, -0.01049649f, 0.08535954f, 0.06393582f, -0.63319057f, -0.07081162f, -0.02921997f, 0.00122709f, 
    0.05129595f, 0.18484499f, -0.12624055f, -0.05533500f, -0.74097753f, -0.21859513f, -0.15740603f, -0.07305764f, 
    0.07584080f, 0.04229821f, 0.14515088f, -0.10168083f, -0.18793385f, 0.10925087f, 0.23153868f, 0.00635619f, 
    -0.00940196f, -0.18001248f, -0.23848222f, -0.00920011f, -0.13629325f, 0.20976698f, 0.28345367f, 0.20664045f, 
    0.09408934f, 0.00023061f, -0.00560961f, 0.07843750f, -0.04394874f, -0.05985462f, 0.15611689f, 0.22208282f, 
    -0.08000485f, -0.03658357f, 0.00804257f, 0.01238708f, -0.00025460f, 0.18647335f, 0.16028887f, -0.00748078f, 
    0.11582419f, -0.10458305f, -0.00717420f, -0.00129463f, -0.05150469f, -0.05808736f, -0.12306106f, -0.03268399f, 
    0.02803732f, 0.01481852f, -0.01685172f, 0.06649125f, -0.15422536f, -0.19313122f, 0.01392558f, 0.04538763f, 
    0.24276227f, 0.18546899f, -0.05251036f, -0.07315670f, 0.00672921f, -0.20556243f, -0.22240639f, -0.11245197f, 
    0.05067831f, -0.00028195f, 0.22773872f, -0.05035023f, -0.09635400f, 0.00097273f, -0.18085110f, -0.15923609f, 
    -0.02627039f, -0.09268553f, 0.18959206f, 0.02336343f, 0.31386715f, -0.14718890f, -0.10037223f, 0.01495763f, 
    -0.17749190f, -0.22754805f, -0.10770054f, -0.18185283f, 0.15782215f, 0.14387999f, -0.07071967f, -0.12198577f, 
    0.05020636f, 0.15650271f, -0.00654693f, 0.20316729f, -0.00719767f, -0.23133194f, 0.51188779f, 0.06022295f, 
    -0.03780903f, 0.16964278f, -0.01126017f, 0.02483045f, -0.01940518f, 0.09662022f, -0.04671211f, -0.12900077f, 
    0.00176110f, 0.07068612f, 0.12812169f, 0.06904517f, -0.14502454f, 0.12491483f, 0.17296183f, -0.01042405f, 
    0.27319789f, 0.03963325f, 0.17228286f, -0.10011975f, 0.16496204f, -0.38583848f, 0.05292564f, 0.05483230f, 
    0.13493679f, -0.08493347f, -0.16470128f, -0.03680504f, 0.01598109f, 0.14831832f, -0.00043236f, 0.17562670f, 
    0.08423522f, 0.04423322f, 0.02383701f, -0.09946208f, -0.02454628f, 0.17060757f, -0.31488684f, -0.15667482f, 
    0.03575282f, -0.11790948f, 0.18819968f, 0.22837172f, -0.11452834f, -0.07312664f, 0.14437152f, 0.00786654f, 
    -0.12203617f, -0.03207041f, -0.04028245f, 0.24027470f, -0.11951115f, 0.07859205f, 0.45061597f, 0.15961924f, 
    0.10212645f, 0.05796837f, -0.15943050f, 0.10540862f, -0.19920959f, 0.12573227f, -0.04921586f, 0.09149432f, 
    0.04358688f, 0.15067357f, 0.25741398f, -0.13520089f, 0.02842342f, 0.03218092f, -0.24924789f, 0.06465594f, 
    0.06380082f, -0.14073473f, -0.05214173f, -0.03898124f, 0.17179015f, -0.03329403f, 0.08187892f, -0.45780328f, 
    -0.06728988f, 0.15318783f, 0.12477987f, 0.09605294f, 0.05746282f, -0.11175428f, 0.02374260f, -0.14168495f, 
    -0.12155290f, -0.42373055f, -0.20882565f, 0.11485659f, 0.02848908f, 0.10024983f, -0.00812342f, 0.06837767f, 
    -0.00623681f, 0.12158537f, -0.44976455f, -0.27154928f, -0.13108194f, 0.08813753f, -0.14296584f, -0.08249386f, 
    -0.12899047f, 0.16364942f, 0.28050324f, -0.07539538f, -0.21458223f, 0.01911643f, -0.00330388f, -0.12237515f, 
    0.09201381f, -0.02961615f, -0.02322732f, 0.29577619f, 0.03521051f, -0.43478480f, -0.16298226f, -0.00737073f, 
    -0.18352371f, 0.04542509f, 0.08139720f, -0.03655243f, -0.02046527f, 0.16719133f, 0.25730392f, 0.04140607f, 
    0.02607008f, 0.01939371f, 0.27719969f, -0.10304939f, -0.18664713f, 0.13167520f, 0.19744024f, 0.19862135f, 
    -0.03069868f, -0.02506715f, 0.05491842f, 0.04086076f, 0.14821143f, 0.09083830f, -0.09195812f, 0.09696569f, 
    0.20503601f, 0.04344525f, 0.06029642f, 0.05005163f, 0.21533886f, 0.05117580f, 0.06029795f, 0.10220086f, 
    0.29683650f, 0.03819182f, -0.04713295f, -0.07255188f, 0.00560648f, 0.06338495f, -0.10253342f, 0.07070911f, 
    -0.17803615f, 0.11301398f, 0.04741036f, 0.00558104f, -0.03495323f, 0.06582918f, -0.02922151f, 0.11510338f, 
    0.00470123f, 0.19191952f, -0.33503881f, 0.10447826f, 0.03977781f, -0.20308131f, 0.11724854f, 0.05239965f, 
    0.11535589f, -0.13125779f, -0.17006038f, 0.16049071f, 0.22636776f, 0.01896074f, 0.08290026f, -0.08106204f, 
    -0.01324160f, 0.14046636f, -0.00909902f, -0.14596824f, 0.07807910f, 0.15880468f, -0.03006550f, -0.04025262f, 
    0.03890739f, 0.17133625f, 0.00047789f, -0.10893245f, -0.14095406f, -0.13593987f, -0.36853331f, 0.17185341f, 
    -0.04194750f, 0.01587020f, -0.09931373f, 0.17889000f, -0.07938813f, -0.49606779f, -0.27844310f, -0.00478608f, 
    -0.02227335f, -0.18169202f, -0.06560411f, 0.00658581f, -0.07465655f, 0.10543728f, 0.30715746f, -0.09551282f, 
    -0.48527083f, 0.05666818f, 0.00873934f, 0.03748173f, -0.01122811f, -0.03528255f, -0.05883388f, -0.01583039f, 
    -0.25810599f, 0.08945186f, 0.07522158f, 0.18504399f, 0.02993392f, 0.06839708f, -0.04216085f, 0.08811171f, 
    -0.35989726f, 0.11569130f, -0.04326703f, 0.10000619f, -0.09661008f, 0.08494020f, 0.11848455f, -0.00129715f, 
    -0.03262319f, 0.08232141f, 0.28730631f, -0.12267227f, -0.04860713f, -0.17763925f, 0.02560679f, 0.09697170f, 
    -0.05844197f, 0.01600285f, 0.25358778f, -0.53672874f, -0.08551452f, -0.05016374f, 0.04282897f, 0.22055720f, 
    -0.00118100f, 0.03449708f, 0.16992751f, -0.23489676f, -0.38853529f, 0.10236207f, 0.05193483f, 0.02767813f, 
    0.04752802f, -0.08944612f, 0.34009764f, 0.03979661f, 0.05381315f, 0.01366887f, 0.08667354f, 0.06772259f, 
    0.20371471f, 0.04836165f, 0.14924401f, -0.06452122f, 0.02849123f, -0.14565258f, 0.08931571f, 0.23349211f, 
    0.08695164f, -0.11065905f, -0.06651907f, -0.10940351f, 0.06465093f, 0.04136209f, -0.01561618f, 0.21138932f, 
    0.37504584f, -0.14840828f, -0.07929580f, -0.14279246f, 0.05116073f, 0.08053860f, -0.03580050f, -0.10018278f, 
    -0.10317691f, 0.25560147f, 0.01299478f, -0.04400600f, -0.14485087f, -0.14695419f, -0.13286175f, 0.15865873f, 
    -0.26848757f, -0.29356131f, 0.01475120f, -0.06342924f, 0.01472217f, -0.02199412f, 0.08712354f, 0.07727560f, 
    -0.00133646f, -0.13233730f, 0.18551920f, 0.00200808f, -0.10738110f, -0.18298228f, -0.12689745f, 0.04461313f, 
    -0.03201325f, 0.06381083f, 0.24251446f, 0.67715681f, 0.51657075f, 0.16154872f, 0.02732560f, -0.15316004f, 
    -0.13728745f, 0.01899432f, 0.00837904f, -0.06207041f, -0.02503755f, -0.10304467f, 0.17165120f, -0.00204422f, 
    -0.09822377f, 0.16031910f, -0.13546734f, -0.03168717f, -0.08158047f, 0.37199077f, 0.36001480f, -0.08020066f, 
    -0.06834668f, 0.11925011f, 0.06298490f, -0.10252798f, -0.10358164f, -0.50475639f, 0.11404737f, -0.11795956f, 
    -0.03442958f, -0.00868968f, -0.14463173f, 0.02888264f, -0.00471953f, 0.11042732f, -0.12201932f, -0.01052129f, 
    0.09571220f, 0.04333139f, 0.11308129f, -0.23484190f, 0.05136805f, -0.04022995f, -0.08796263f, 0.16557622f, 
    0.11902375f, -0.11047340f, 0.03100797f, -0.05838114f, 0.05643053f, -0.16502617f, -0.20230146f, 0.11561751f, 
    0.02556577f, 0.32170105f, 0.19797964f, 0.05270170f, 0.09614117f, -0.00436039f, 0.08412602f, 0.03118121f, 
    0.04218616f, -0.15235130f, -0.32482284f, -0.23354232f, -0.27127326f, -0.15588468f, -0.15389648f, -0.02990480f, 
    0.27891719f, 0.02899301f, 0.54732364f, 0.21789411f, -0.04531132f, -0.10400354f, 0.09000703f, -0.14694437f, 
    0.04276304f, 0.17915829f, 0.05121110f, -0.14927900f, 0.14759541f, 0.07714678f, -0.05613764f, 0.05636885f, 
    -0.03712380f, -0.03142183f, -0.06154864f, 0.30104530f, -0.07330424f, -0.01640800f, -0.00742368f, 0.14629900f, 
    0.04035497f, 0.01315295f, 0.14712602f, -0.05133394f, 0.04246770f, -0.07175612f, -0.06659157f, 0.14003214f, 
    -0.01717059f, 0.00438291f, 0.03377674f, -0.07928656f, -0.04443461f, 0.02091550f, 0.00793413f, 0.12689993f, 
    0.03580759f, 0.09540886f, 0.21765198f, 0.08544599f, 0.13208435f, -0.01287849f, 0.03365609f, 0.31759712f, 
    0.28621793f, 0.15654835f, 0.03768042f, 0.03446702f, 0.11713977f, 0.24814306f, 0.20285897f, 0.32611972f, 
    -0.38467830f, -0.08199053f, -0.16843905f, -0.04836078f, -0.16470703f, -0.16622308f, 0.01858110f, -0.01103851f, 
    0.02123170f, -0.04578849f, -0.41414884f, -0.06184324f, -0.33961213f, -0.20588905f, -0.14950429f, 0.09110107f, 
    -0.06337225f, 0.14598709f, 0.14541006f, 0.05468421f, 0.24700193f, 0.03606422f, -0.07590690f, -0.16120152f, 
    0.17453483f, -0.08031908f, 0.04429581f, 0.21420579f, 0.17542934f, 0.17861931f, -0.06530986f, -0.11907633f, 
    -0.08951357f, 0.29635090f, -0.10435820f, -0.04711352f, -0.50128943f, -0.54830474f, -0.22627395f, -0.04820440f, 
    -0.22023550f, -0.00060351f, 0.09813277f, 0.13192827f, 0.02670111f, 0.02750469f, -0.00934542f, -0.08975375f, 
    0.13088256f, -0.23694119f, 0.02877547f, -0.13118368f, -0.02741284f, 0.10392288f, -0.35342383f, -0.16566338f, 
    0.23558788f, 0.03777000f, -0.14403409f, -0.08636588f, -0.02947067f, 0.01072515f, 0.06011091f, 0.24061769f, 
    -0.07810921f, -0.03021516f, -0.02311093f, 0.12021205f, -0.02360108f, 0.10564647f, 0.04526574f, 0.21745868f, 
    0.36007771f, -0.34867692f, -0.41146785f, 0.04011026f, -0.02266807f, 0.10287992f, 0.01836440f, 0.06849131f, 
    0.00663888f, 0.13475421f, 0.24343069f, -0.02038620f, 0.00219484f, -0.12807658f, -0.10362262f, -0.02136348f, 
    0.05360103f, 0.05052566f, 0.24856542f, -0.05033545f, -0.13517281f, -0.02867949f, -0.05104405f, -0.04910899f, 
    0.03119087f, 0.00007814f, -0.05046028f, -0.36089492f, -0.10063916f, -0.65855253f, -0.01187510f, -0.00668550f, 
    0.10169899f, -0.01994382f, 0.21129592f, -0.00140625f, -0.05400981f, 0.09003585f, 0.10135257f, -0.02281354f, 
    0.04852169f, 0.08464267f, -0.15525408f, -0.08498976f, 0.04690383f, 0.20498800f, 0.34125888f, 0.01081705f, 
    -0.06966350f, 0.07976618f, -0.32453394f, 0.01593750f, -0.01135944f, 0.02759102f, 0.45128000f, 0.00392472f, 
    0.05366600f, -0.03700851f, -0.09388332f, 0.19397235f, 0.13008484f, -0.07631328f, -0.03282148f, -0.18220487f, 
    -0.10013629f, 0.03971568f, 0.07287243f, -0.00544682f, -0.11823345f, 0.09681191f, -0.09268826f, -0.10836573f, 
    -0.29270765f, 0.40660757f, 0.03536132f, -0.03966811f, -0.01264253f, -0.21129006f, 0.08332562f, 0.05708998f, 
    0.11897195f, -0.08385973f, 0.01580873f, 0.19622242f, -0.17403519f, 0.00988558f, -0.28102821f, -0.01891180f, 
    0.02394147f, -0.00883655f, 0.22560778f, -0.29891425f, -0.01853290f, -0.10872912f, -0.06344794f, 0.04130893f, 
    0.17776182f, 0.00882487f, 0.00368281f, 0.12908396f, 0.05699789f, 0.18195130f, 0.06005461f, 0.15924127f, 
    0.05623615f, 0.02822979f, 0.08788717f, -0.08612631f, 0.13680132f, -0.29382285f, 0.15607971f, -0.18986218f, 
    0.03232072f, -0.08097592f, -0.03781531f, -0.15969518f, -0.09529907f, -0.02851166f, -0.27378130f, 0.21844062f, 
    -0.26329696f, -0.03103150f, -0.02062098f, 0.11131278f, 0.13528635f, -0.02373640f, -0.25678959f, -0.11884834f, 
    -0.24336307f, 0.08046734f, -0.05455399f, 0.00466281f, 0.06868152f, 0.08992133f, -0.07745884f, -0.08029167f, 
    -0.08481811f, 0.10755634f, -0.11341321f, 0.02692840f, -0.11145552f, 0.11795547f, 0.08537258f, -0.07933301f, 
    0.12537184f, -0.19583423f, -0.31594098f, -0.04678672f, -0.09332458f, 0.08844794f, -0.02893508f, 0.07304546f, 
    0.22415370f, 0.24013697f, 0.34213305f, -0.03286586f, 0.02287266f, -0.15805563f, -0.04191502f, -0.02495895f, 
    0.22350526f, -0.10822959f, -0.24845159f, -0.59550601f, -0.03827253f, 0.07458173f, 0.16163395f, 0.35949281f, 
    -0.18309662f, -0.08264918f, -0.09462451f, 0.07645663f, -0.04448560f, 0.14403851f, -0.05233193f, -0.01822950f, 
    0.17464665f, 0.13717893f, 0.11549458f, 0.09121960f, 0.01260538f, 0.21008864f, 0.06920888f, -0.27195925f, 
    0.01212426f, 0.15123382f, 0.09894938f, -0.02536051f, -0.15398465f, -0.23466930f, -0.16533728f, 0.23156996f, 
    -0.12624472f, 0.05384830f, -0.20831296f, 0.06221057f, 0.08189147f, 0.05476361f, 0.05445051f, -0.05343961f, 
    0.55783451f, -0.20343600f, -0.09046191f, -0.21042407f, 0.08222915f, 0.10812552f, -0.04477165f, -0.04099149f, 
    0.08123504f, 0.15849662f, -0.11061580f, 0.06508674f, 0.01502576f, -0.01929271f, 0.33636689f, 0.04812584f, 
    0.06051101f, 0.39724150f, -0.03295058f, -0.20488352f, -0.19057298f, -0.00734528f, 0.03631536f, 0.00682484f, 
    -0.00175210f, 0.00321651f, 0.09450691f, -0.01343205f, -0.05130383f, -0.18111764f, -0.13734989f, -0.09777381f, 
    0.11562721f, -0.04444927f, 0.14591734f, -0.57243109f, 0.44383267f, 0.04110755f, -0.00607428f, -0.02747699f, 
    0.08546814f, -0.12316719f, -0.25209078f, 0.09527964f, 0.04753572f, -0.21445176f, 0.09395725f, -0.03194956f, 
    -0.07807565f, -0.03707804f, -0.02300241f, 0.07605571f, 0.02656622f, 0.28008759f, -0.04173348f, 0.19628079f, 
    0.00479337f, -0.17618015f, -0.21215974f, -0.01193495f, -0.24331832f, -0.12968147f, 0.16985139f, -0.32489485f, 
    0.01609251f, -0.03666360f, -0.08657863f, -0.09723166f, -0.37733322f, 0.15173168f, 0.07542279f, 0.03972051f, 
    0.03698420f, 0.08277255f, -0.02084520f, -0.09589031f, 0.03388222f, 0.04494819f, 0.14407320f, -0.04238662f, 
    0.01414434f, -0.17675789f, -0.03136165f, 0.07720763f, -0.04332540f, 0.19675413f, 0.10435734f, -0.13913776f, 
    -0.03030220f, 0.05508901f, 0.25057432f, -0.04245463f, 0.07945843f, 0.10717832f, 0.06074740f, -0.19825819f, 
    -0.08746767f, -0.09270658f, 0.16690314f, 0.08085637f, 0.12470939f, -0.02278522f, -0.11359791f, -0.00181534f, 
    0.01674385f, 0.11361504f, 0.23648597f, 0.14617372f, -0.17710075f, 0.12784804f, -0.12637579f, 0.03413463f, 
    -0.01943233f, -0.06096071f, -0.01438096f, -0.34824917f, -0.31231186f, 0.17981400f, -0.02961936f, 0.10753847f, 
    -0.03715210f, 0.00544896f, 0.06965250f, 0.13391212f, -0.02631137f, -0.09235889f, 0.00505868f, 0.01091469f, 
    0.01660372f, 0.15311919f, -0.08429592f, 0.07655253f, -0.03688296f, 0.10571706f, -0.14799698f, -0.02743462f, 
    0.00026142f, 0.03045097f, 0.01673483f, 0.23852113f, 0.10045023f, 0.29856879f, 0.05499969f, -0.09999283f, 
    0.06339602f, -0.06699509f, -0.20738721f, 0.05253496f, -0.12726633f, 0.09285092f, 0.08650550f, -0.11299533f, 
    -0.20474589f, -0.04290165f, 0.13002858f, 0.13043706f, -0.10457425f, -0.17287405f, 0.22827044f, 0.09686322f, 
    -0.63075387f, -0.08861195f, -0.06101424f, 0.11106036f, -0.12804514f, -0.08207545f, -0.09172749f, 0.09502863f, 
    -0.22673091f, -0.21906401f, 0.11602090f, 0.13424821f, 0.04446245f, 0.13563100f, -0.11100598f, 0.02222382f, 
    -0.11416129f, -0.03362038f, -0.03877034f, -0.03196899f, -0.04735977f, 0.02464290f, 0.04626305f, -0.04052725f, 
    -0.01523904f, -0.14738385f, -0.20711738f, -0.07122334f, 0.15073138f, 0.17157842f, -0.10464235f, -0.03630696f, 
    0.00733635f, -0.25464290f, -0.15916389f, -0.02494894f, -0.24694425f, -0.05775718f, 0.08189878f, 0.17329302f, 
    -0.01934778f, 0.09564059f, 0.02897038f, 0.12414774f, -0.01046005f, -0.31242418f, -0.07395378f, -0.05587277f, 
    -0.00832398f, -0.03000005f, -0.01852337f, -0.05737426f, -0.05647406f, -0.07120143f, -0.27582824f, -0.00712565f, 
    0.21523793f, 0.08279848f, 0.10577947f, -0.17227209f, 0.03542191f, 0.01537375f, 0.05473122f, 0.10712709f, 
    -0.00112199f, 0.01145625f, 0.02933143f, 0.08442233f, 0.16538532f, 0.25249881f, -0.01652287f, 0.15330003f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.29451859f, 0.01208119f, -0.01674578f, -0.17861713f, 0.09096017f, 0.16168709f, 0.09173347f, 0.18820764f, 
    0.28881130f, -0.07459671f, -0.02217595f, 0.07352100f, 0.24851541f, -0.05641120f, 0.12126869f, 0.15765391f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16541593f, 0.25441888f, -0.18350951f, -0.36370668f, -0.00729948f, 0.26715004f, -0.26437491f, 0.29853290f, 
    0.25236106f, -0.36234295f, 0.28739947f, -0.19415773f, 0.03533941f, -0.36668721f, 0.27012140f, 0.32484260f, 
    0.05461607f, -0.30194944f, -0.06393059f, -0.17834380f, 0.30577424f, 0.02117822f, -0.26339892f, 0.27798375f, 
    0.50342625f, 0.23983809f, 0.05717909f, -0.12828688f, -0.08665267f, -0.06371462f, 0.42657709f, 0.11760144f, 
    -0.10045394f, -0.09651662f, 0.16080664f, -0.05161628f, -0.26419312f, 0.37917534f, 0.31817180f, -0.21008877f, 
    0.07306211f, -0.14569572f, 0.45625079f, 0.20568796f, 0.25133264f, 0.41939873f, 0.49442917f, -0.00320795f, 
    0.02781055f, -0.19650847f, 0.46580830f, 0.04014788f, -0.13116764f, 0.29614902f, -0.10250726f, -0.16927186f, 
    0.05398909f, -0.43355909f, 0.33343437f, 0.02554722f, -0.09844951f, 0.37768298f, -0.05327230f, 0.10608797f, 
    0.27150372f, 0.25433755f, -0.25966257f, 0.19103858f, -0.05920351f, 0.47400230f, 0.01145310f, 0.26135299f, 
    -0.26606268f, -0.65953356f, 0.20027697f, 0.08028153f, -0.20058550f, -0.26360434f, 0.49431917f, -0.13931206f, 
    -0.37130678f, -0.21375050f, 0.14906275f, 0.34960338f, 0.16347268f, 0.05724829f, 0.41015574f, 0.02348590f, 
    0.16763183f, 0.00645395f, 0.09538295f, 0.17457834f, -0.12707475f, 0.64101464f, 0.02572311f, -0.35991189f, 
    0.12588733f, 0.08804327f, 0.36944896f, -0.06514427f, 0.21816775f, 0.04623040f, 0.29401851f, -0.22024657f, 
    0.39853066f, 0.10738558f, 0.01137858f, 0.18114111f, -0.05559379f, 0.47195655f, 0.45137575f, -0.20118880f, 
    -0.16707057f, -0.05336350f, 0.10486564f, -0.22055972f, -0.20019501f, -0.23073938f, -0.23135427f, 0.13835582f, 
    -0.24467716f, -0.20934746f, 0.06048179f, -0.16268921f, -0.06370065f, -0.23736969f, -0.21340308f, -0.03296119f, 
    0.06201951f, -0.45307902f, -0.28932321f, 0.16430913f, 0.22316289f, 0.31602859f, -0.09755348f, 0.32879627f, 
    -0.26222941f, 0.03360779f, 0.15910076f, -0.44547480f, 0.15278365f, 0.25562906f, 0.41241729f, 0.01526162f, 
    0.30962601f, -0.04905518f, -0.24489722f, 0.12897299f, 0.03189657f, 0.05579315f, 0.41029444f, 0.06299853f, 
    -0.20404233f, 0.21145755f, 0.29937407f, 0.28783730f, -0.06724494f, -0.27757531f, 0.18841557f, -0.30998507f, 
    0.01050175f, 0.10195614f, -0.20219204f, -0.17122698f, -0.06675458f, 0.07574120f, -0.11004772f, -0.00883407f, 
    -0.17686412f, -0.11314569f, 0.22290254f, -0.00829261f, -0.24169162f, 0.07503297f, -0.00684149f, -0.21956304f, 
    -0.40648872f, -0.19532602f, 0.23904879f, 0.26734802f, -0.24542619f, -0.19470036f, -0.26985642f, -0.03881681f, 
    -0.06199532f, 0.59672707f, 0.13316502f, -0.44028571f, -0.01044497f, 0.18292964f, 0.00596718f, -0.20525342f, 
    -0.22786966f, 0.13235435f, 0.27155593f, -0.24709803f, -0.15915255f, -0.12892777f, 0.30652058f, 0.04931328f, 
    0.53105563f, -0.20408136f, -0.07198526f, -0.18708926f, 0.36552301f, 0.39125422f, 0.09982178f, 0.20950723f, 
    -0.21492442f, -0.18789828f, -0.10962731f, 0.08008859f, 0.18846488f, 0.11830619f, 0.23567104f, -0.24703154f, 
    0.01866752f, -0.22782397f, -0.11382070f, -0.10990921f, -0.18208498f, -0.04252580f, -0.09330010f, -0.17898625f, 
    -0.08019977f, -0.05558959f, -0.26427612f, 0.31329241f, 0.28556341f, 0.20138699f, -0.04481881f, 0.27250189f, 
    -0.26328063f, 0.51829100f, 0.13524149f, -0.22820610f, -0.24165589f, -0.04647127f, 0.08001695f, -0.32152277f, 
    0.05445058f, -0.05244661f, 0.30044553f, 0.22434127f, -0.50481850f, -0.10051987f, -0.05451134f, -0.30343443f, 
    -0.60403961f, -0.19032420f, 0.25245953f, -0.28565711f, 0.43324283f, 0.01170666f, -0.15352301f, 0.04550128f, 
    -0.33667570f, 0.00417633f, -0.15811245f, 0.08022930f, 0.42811948f, 0.29732910f, 0.24391612f, 0.08732020f, 
    -0.01003637f, 0.41323379f, 0.10046839f, -0.24738386f, 0.09747626f, 0.47097588f, -0.06886078f, -0.38602912f, 
    -0.11315224f, -0.35433158f, -0.65581435f, -0.37296787f, 0.00421671f, -0.64274484f, 0.44329143f, -0.11930768f, 
    0.11040019f, 0.14088403f, -1.28377628f, 0.34202090f, -0.94325566f, -0.73853087f, 0.23062037f, 0.07723304f, 
    0.11884881f, -0.28328103f, 0.30425218f, 0.26381305f, 0.22719629f, 0.08943893f, 0.01355361f, -0.11441932f, 
    0.32312131f, 0.30807748f, 0.31444442f, -0.54048932f, 0.48108283f, -0.02321218f, 0.04845483f, -0.10208588f, 
    -0.40391481f, -0.26627541f, -0.22520502f, 0.12203942f, 0.53355974f, 0.17628029f, -0.13248041f, -0.01899476f, 
    -0.06432200f, -0.28713486f, 0.33648211f, 0.21133365f, 0.13085374f, -0.32468218f, 0.42429495f, -0.48216459f, 
    -0.04512790f, 0.13483295f, -0.06602558f, 0.09801101f, 0.20707974f, -0.25543803f, 0.54636139f, 0.33778504f, 
    -0.15544307f, -0.25674993f, -0.36212876f, -0.19131966f, -0.13849056f, -0.23497176f, 0.17798801f, -0.36000314f, 
    0.39455676f, 0.04897616f, -0.21329854f, 0.08559882f, 0.08097503f, 0.04640090f, -0.23064208f, 0.10659690f, 
    -0.71602017f, -0.19534175f, 0.34141025f, 0.21352173f, 0.34288448f, -0.19588614f, -0.50833350f, 0.32044896f, 
    -0.19469585f, -0.38065341f, 0.02690128f, 0.01610041f, 0.14295565f, 0.21610926f, -0.32233387f, 0.29497659f, 
    -0.09024362f, 0.56112564f, -0.39490128f, 0.47616863f, -0.14341116f, -0.48236841f, 0.60314196f, -0.37417054f, 
    0.03133251f, -0.07447950f, -0.18232858f, -0.02368923f, 0.18435833f, 0.10626473f, -0.08268164f, 0.14654911f, 
    0.00864593f, -0.19728948f, -0.32118419f, 0.06400688f, 0.23887834f, -0.40217790f, -0.29237038f, 0.22483622f, 
    -0.72627765f, -0.48661312f, -0.00271688f, 0.30585191f, 0.35453263f, 0.31294799f, -0.58063698f, -0.08209414f, 
    0.00968423f, 0.07115743f, 0.23321472f, 0.32971901f, -0.01354904f, 0.07673193f, 0.03744153f, -0.43155929f, 
    0.24624957f, 0.20832618f, 0.01331875f, -0.25547078f, 0.02675963f, 0.19697157f, -0.00837819f, -0.25830397f, 
    0.14629669f, -0.20859048f, 0.39993978f, 0.38088134f, 0.11476206f, -0.44842124f, 0.06732598f, 0.06870463f, 
    0.09419389f, -0.06494120f, 0.06667691f, -0.00487452f, -0.53148115f, 0.20020504f, -0.08102193f, -0.09725302f, 
    -0.43499553f, -0.18730773f, 0.34957501f, 0.41969264f, 0.11926500f, 0.21624196f, -0.18115199f, -0.00659012f, 
    0.04872967f, -0.48180535f, 0.06569730f, 0.18979615f, 0.26537111f, 0.28432453f, 0.13718930f, 0.21254271f, 
    -0.26927832f, 0.26188898f, 0.01918701f, -0.07354311f, 0.02312090f, -0.42174721f, -0.12145276f, -0.31773278f, 
    -0.00631288f, -0.21828641f, -0.02425194f, -0.03561269f, -0.03631467f, 0.05155366f, -0.16841090f, 0.04219063f, 
    0.19533053f, -0.10220470f, 0.13492756f, -0.25132775f, -0.19832617f, -0.00065565f, -0.18217811f, -0.19134691f, 
    -0.54597902f, 0.27429408f, 0.26775151f, -0.16760458f, 0.14820358f, 0.26619685f, -0.07260782f, 0.25242600f, 
    0.48324201f, -0.14216498f, -0.02078571f, -0.29414266f, 0.29965851f, 0.52058876f, -0.09456172f, 0.08022848f, 
    -0.21064548f, 0.28779486f, 0.11155389f, -0.24012193f, 0.32752317f, 0.28185710f, 0.11861621f, -0.23493399f, 
    0.84375888f, -0.03853272f, 0.33218533f, -0.23961861f, 0.08703956f, 0.59344959f, -0.02224027f, -0.02017186f, 
    0.08424374f, 0.13041720f, 0.21745849f, -0.19807698f, -0.02142151f, -0.01357999f, -0.02636411f, -0.26534748f, 
    0.57378894f, 0.05065820f, 0.40201452f, 0.36732042f, 0.17759381f, -0.05914132f, 0.00192178f, 0.10248949f, 
    -0.24191245f, 0.31865051f, -0.28036708f, -0.20261490f, -0.08028518f, 0.33000344f, -0.47698322f, 0.35664555f, 
    -0.18154311f, -0.14069471f, 0.34390077f, 0.35467860f, 0.30904490f, -0.49096593f, -0.27296329f, 0.31779575f, 
    -0.10271540f, -0.28447241f, -0.17873575f, 0.20904189f, -0.08764112f, -0.00897822f, 0.15556282f, 0.17734604f, 
    -0.11779018f, 0.09272312f, -0.13798103f, 0.48048162f, 0.03510229f, -0.32418460f, 0.72642493f, -0.36889356f, 
    -0.20208649f, 0.31424603f, 0.06107486f, -0.05204358f, 0.05683422f, -0.08610819f, -0.54755944f, 0.16476595f, 
    -0.21435286f, -0.37064800f, -0.15749240f, -0.40985748f, 0.44840634f, -0.24698257f, -0.19053626f, 0.24552380f, 
    0.41762906f, -0.44741067f, -0.13640565f, -0.18379623f, -0.07184026f, -0.13917714f, -0.43005437f, -0.06620162f, 
    -0.12173577f, 0.03858809f, -0.06877466f, 0.40167600f, 0.40335661f, -0.37461194f, 0.21589687f, 0.14203359f, 
    -0.52674395f, 0.13594519f, 0.30270988f, 0.04143848f, -0.23483829f, 0.16265647f, 0.25474823f, 0.15760115f, 
    -0.05091232f, -0.17287636f, -0.11948281f, 0.09843405f, 0.26289210f, -0.69219881f, 0.44830561f, -0.40218070f, 
    0.05205165f, 0.22440822f, -0.09735402f, -0.34639397f, -0.10959813f, -0.00569668f, 0.03581555f, -0.13404770f, 
    0.75552237f, 0.03586262f, 0.29576367f, 0.03934717f, 0.11488321f, -0.13934951f, 0.58928108f, -0.05920428f, 
    0.16473506f, 0.12433220f, 0.04204055f, -0.08559465f, 0.10634039f, 0.29953080f, 0.19464301f, -0.16543540f, 
    0.29355207f, 0.15151955f, 0.14804596f, 0.20855552f, -0.15585351f, 0.02392644f, 0.51423848f, -0.29676977f, 
    0.34781542f, -0.04216684f, -0.35946256f, -0.19132952f, 0.18392095f, 0.37929210f, -0.04336613f, 0.22444892f, 
    0.13881615f, -0.02523118f, -0.16507731f, 0.19934285f, -0.08373613f, -0.14995831f, 0.10969909f, 0.13104680f, 
    0.02632690f, -0.16584523f, -0.27334255f, -0.00607582f, -0.08256033f, 0.01444754f, -0.43398148f, 0.37560201f, 
    0.21845096f, 0.12789941f, -0.06506179f, -0.38823465f, 0.44236580f, 0.15500237f, 0.27242768f, 0.04732019f, 
    0.32507667f, -0.41808686f, -0.23586723f, 0.15112968f, 0.41822284f, -0.19126171f, 0.12594785f, 0.26267761f, 
    -0.42560157f, 0.06064045f, -0.23911780f, 0.34712783f, 0.15237537f, -0.13932723f, -0.35073599f, -0.06969974f, 
    0.11544947f, 0.29846916f, -0.19921669f, 0.09658218f, 0.31166393f, 0.19711611f, 0.28914768f, 0.27884436f, 
    -0.37267318f, 0.11544184f, 0.21048765f, -0.32229897f, -0.17210416f, 0.05773180f, -0.37450647f, -0.01934653f, 
    0.22417638f, -0.38620543f, -0.09991331f, -0.38270992f, 0.24195972f, -0.09379020f, -0.45189047f, 0.12865090f, 
    0.53633332f, -0.13057666f, -0.13863760f, 0.17646569f, 0.06806951f, -0.12315856f, 0.04771379f, 0.15174522f, 
    0.19561683f, 0.00657943f, 0.12250326f, -0.15023559f, 0.12639083f, 0.70764971f, -0.24975763f, -0.10297512f, 
    -0.32505116f, 0.23870003f, 0.30299404f, -0.19903016f, -0.25023460f, -0.25896847f, 0.01879410f, -0.14048414f, 
    0.12043861f, -0.31487432f, 0.12696066f, 0.11142593f, 0.37543052f, -0.11307412f, 0.22420391f, 0.14529593f, 
    -0.24745433f, 0.40835166f, -0.19866332f, -0.12682155f, -0.21774772f, 0.27438658f, 0.25875109f, -0.28038687f, 
    0.02458678f, -0.13453968f, -0.09903912f, -0.08124675f, 0.19718957f, -0.11874130f, -0.11170057f, 0.40267602f, 
    0.45637608f, -0.03101989f, -0.08487970f, -0.10272111f, -0.04575530f, -0.11575297f, 0.44093427f, -0.40059716f, 
    -0.23152936f, -0.13710237f, 0.22856489f, 0.38260344f, -0.13545355f, 0.34525469f, -0.41831842f, 0.20443787f, 
    0.06056251f, -0.19228882f, 0.19106051f, -0.18552120f, -0.00028651f, 0.54107511f, -0.08310167f, 0.12536934f, 
    -0.12816525f, 0.26709494f, 0.38626772f, 0.07791461f, 0.05200180f, -0.07757096f, 0.16687314f, -0.29082826f, 
    0.13354097f, -0.01842450f, 0.17766862f, 0.45753118f, -0.11017241f, -0.10248803f, 0.09691199f, 0.21549615f, 
    0.10230803f, -0.43768445f, -0.39278460f, -0.21525611f, 0.14427786f, 0.33319390f, -0.23465200f, 0.38622025f, 
    -0.24482216f, 0.35019413f, -0.10032167f, 0.10430022f, 0.12457413f, -0.49422723f, -0.02508510f, 0.07285602f, 
    -0.28427666f, -0.18589818f, 0.06716893f, 0.34442273f, 0.03930855f, -0.34573361f, -0.10270845f, -0.14954448f, 
    -0.36714947f, 0.53718674f, -0.10451926f, -0.00203962f, 0.24994825f, 0.76010269f, 0.22681379f, 0.18498042f, 
    -0.28644755f, 0.24341604f, 0.42751482f, 0.26073354f, -0.19554184f, 0.29132673f, -0.39307466f, -0.20429087f, 
    -0.18674046f, -0.14232925f, 0.46926156f, 0.07952496f, -0.19419301f, 0.34427127f, 0.09658016f, -0.14356700f, 
    0.06477104f, -0.30400953f, 0.13358255f, -0.03456589f, -0.22697775f, -0.15747513f, 0.00043711f, 0.06658958f, 
    -0.45487523f, -0.08828514f, 0.40218642f, 0.49273312f, 0.32050186f, 0.09264566f, 0.49303973f, -0.00820719f, 
    -0.41737556f, 0.27571645f, 0.51643574f, 0.24935040f, 0.00785169f, 0.14358687f, -0.49047035f, -0.00480604f, 
    0.02214910f, -0.34617791f, 0.21818358f, 0.16597310f, 0.39144143f, -0.37308225f, -0.39531505f, 0.23002768f, 
    0.10808297f, 0.28478506f, -0.24423130f, 0.00964077f, 0.19723621f, 0.45167744f, -0.49777353f, 0.06242536f, 
    -0.37659663f, -0.29671291f, 0.19395040f, 0.13932657f, 0.28136724f, -0.51477462f, 0.12577616f, 0.38342330f, 
    0.33066699f, -0.19079350f, -0.10370723f, -0.21786152f, -0.04115218f, -0.33367801f, -0.37617752f, 0.35364541f, 
    0.22590733f, -0.00097007f, -0.04093806f, -0.11413369f, 0.39727771f, -0.10079312f, -0.33887497f, -0.00246554f, 
    -0.15073909f, 0.10536738f, -0.10223150f, 0.31774169f, -0.15215981f, 0.36250433f, 0.28684589f, -0.09082229f, 
    -0.49072129f, -0.42889988f, 0.66295010f, -0.12080502f, 0.32152668f, 0.09404724f, 0.19826758f, -0.11646017f, 
    0.34724551f, -0.07264372f, 0.01778135f, 0.19024880f, 0.10113278f, -0.57353926f, 0.10010460f, -0.05076986f, 
    -0.19493926f, 0.44338959f, 0.30397740f, -0.06773961f, 0.22927439f, 0.07683711f, -0.31445661f, 0.14933877f, 
    0.09283391f, 0.04787237f, 0.20690979f, 0.09796814f, -0.16541724f, -0.25691164f, -0.48445621f, -0.15116712f, 
    0.45053306f, 0.12334023f, -0.15647480f, 0.41735744f, 0.12516198f, -0.20001402f, 0.16923654f, 0.07074330f, 
    -0.15088694f, -0.11240096f, 0.01733648f, 0.09378494f, 0.14820802f, 0.50755674f, 0.20303591f, 0.16636807f, 
    -0.23518641f, -0.20209640f, 0.22693948f, -0.14038444f, -0.07665808f, 0.34614578f, 0.17798126f, -0.20354791f, 
    0.38839668f, -0.12680022f, -0.18073076f, -0.23900533f, 0.36614978f, 0.25830421f, 0.18221821f, 0.13920116f, 
    0.50218087f, -0.26866817f, 0.00620447f, -0.26724792f, 0.23300701f, -0.25728193f, -0.04268981f, 0.16003489f, 
    -0.42981872f, -0.10197461f, 0.35321927f, 0.07183373f, 0.20887643f, 0.29860070f, 0.08348265f, -0.03012387f, 
    -0.22333278f, -0.14984035f, 0.11037890f, 0.37519342f, 0.03985246f, -0.29737556f, 0.35396340f, 0.09415361f, 
    0.14264658f, 0.07051592f, -0.00285001f, -0.09059525f, -0.17069693f, -0.13719440f, -0.01849934f, 0.23077263f, 
    0.02816479f, -0.30590829f, -0.12141460f, -0.18545158f, 0.35234442f, -0.22180542f, -0.46818113f, 0.25686565f, 
    0.43591443f, -0.00489555f, 0.08031866f, 0.00635652f, -0.40550727f, -0.33284307f, 0.32255423f, -0.00670115f, 
    0.13495088f, -0.44769433f, 0.23047800f, 0.29364187f, 0.36300689f, -0.18039279f, -0.22016566f, 0.01569989f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.32670620f, 0.19660163f, -0.14033170f, 0.06068368f, 0.26014385f, 0.05599966f, -0.32161066f, -0.03616086f, 
    0.40338922f, -0.23015912f, 0.05910682f, -0.20600209f, -0.17720978f, -0.17516160f, 0.05353853f, -0.04470887f, 
    0.30561849f, 0.28282446f, 0.39201334f, -0.04613839f, 0.03385669f, -0.01529800f, -0.04049613f, 0.42513961f, 
    -0.10899846f, 0.05828454f, 0.00119490f, 0.15622677f, -0.18509521f, -0.02489005f, -0.01436899f, -0.23648104f, 
    0.37317136f, 0.04304078f, 0.40410289f, 0.53418165f, 0.02967411f, -0.19679677f, -0.23321082f, 0.25994718f, 
    0.57140452f, 0.35279724f, -0.28457972f, 0.41306537f, -0.11627799f, 0.15323222f, 0.38095492f, -0.03845026f, 
    -0.00707603f, 0.14617044f, 0.01358770f, 0.15064350f, -0.08259790f, 0.16059035f, 0.49205759f, 0.37635788f, 
    -0.10407022f, -0.23182678f, -0.04460663f, -0.13696653f, 0.08592424f, 0.16515633f, 0.06185289f, -0.16479178f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.32876953f, 0.20429005f, 0.14618364f, 0.06376418f, 0.12154938f, -0.21143137f, 0.02393213f, -0.00920510f, 
    0.06020815f, -0.12506598f, 0.06771141f, -0.54009473f, 0.26349741f, -0.06299227f, -0.19760139f, -0.13526402f, 
    0.02545056f, -0.76862675f, -0.06480423f, -0.45488039f, -0.28931338f, 0.11960594f, 0.00923987f, 0.14879662f, 
    -0.69311923f, 0.23959477f, -0.08009241f, -0.26255676f, -0.11834276f, 0.07346632f, 0.13145962f, 0.17640416f, 
    0.04195237f, 0.02116843f, 0.10529123f, 0.28583577f, -0.12186443f, 0.17742889f, -0.08404546f, 0.08766669f, 
    0.16446993f, 0.21964306f, -0.40806472f, 0.42315397f, -0.29159278f, -0.00043240f, 0.05833137f, -0.04625866f, 
    0.13464683f, -0.05171095f, -0.02427141f, -0.02889930f, 0.23431697f, -0.04497207f, 0.15708807f, 0.25819620f, 
    -0.09082852f, -0.15201935f, 0.41880065f, -0.02104798f, 0.03114645f, 0.09934752f, 0.16467574f, 0.12204301f, 
    0.20276512f, 0.20258969f, 0.24687664f, -0.02222669f, 0.26481521f, 0.12735645f, 0.23644060f, -0.08794852f, 
    -0.07489827f, 0.21090522f, -0.04569656f, -0.35644653f, -0.19921488f, 0.08056056f, 0.19565739f, -0.42093265f, 
    0.00014858f, 0.78989887f, 0.15858667f, -0.35422301f, 0.06549245f, -0.04021983f, 0.05942804f, -0.00615646f, 
    -0.23487490f, -0.04505895f, -0.08513562f, 0.13114135f, 0.01100910f, -0.17771412f, 0.19263989f, 0.02952381f, 
    -0.07226720f, 0.26800773f, -0.50996244f, -0.09331735f, 0.11360148f, 0.28262913f, 0.37173969f, 0.19829075f, 
    -0.03306875f, 0.07961865f, -0.01844759f, -0.13622200f, 0.35585287f, 0.09246808f, 0.19013092f, -0.23595132f, 
    -0.12543519f, 0.08815658f, -0.43617073f, 0.01742036f, -0.14778423f, -0.25808352f, -0.02450228f, -0.18621451f, 
    -0.20086211f, -0.07773725f, 0.10558884f, 0.03009666f, 0.12676695f, -0.19912215f, -0.03595013f, 0.06852783f, 
    -0.15780981f, 0.19286296f, 0.15531236f, -0.12092709f, -0.14573599f, 0.23655167f, -0.03255510f, 0.03874494f, 
    0.25068182f, -0.09023908f, -0.08481546f, 0.61565733f, 0.23340721f, 0.05500945f, 0.18817076f, 0.12319084f, 
    0.25605494f, -0.58425832f, 0.09335568f, 0.27530244f, 0.30104357f, -0.16061012f, 0.16616909f, -0.08428268f, 
    0.12132393f, -0.57857919f, 0.03168690f, 0.18945551f, 0.14386642f, 0.26778951f, 0.08464778f, -0.37060398f, 
    0.03716878f, 0.28518555f, 0.11487868f, -0.46458617f, 0.42679149f, -0.03637335f, -0.18492095f, -0.16070578f, 
    0.14363009f, -0.03024855f, -0.04649380f, -0.17274259f, -0.18952221f, 0.21749067f, 0.23638104f, 0.14886118f, 
    -0.16463506f, -0.02374373f, 0.28245255f, -0.05543691f, 0.08166149f, 0.09073079f, -0.20338465f, -0.09290540f, 
    0.20509575f, 0.00785930f, -0.10530260f, 0.08272770f, -0.05986628f, 0.09522355f, -0.07207289f, -0.22018740f, 
    -0.26674435f, -0.04950852f, 0.00801362f, 0.24337336f, -0.37816507f, 0.30768421f, 0.12572786f, -0.05006114f, 
    0.00784962f, -0.47942826f, 0.12030622f, 0.27655065f, 0.39445198f, -0.08400428f, -0.17499253f, 0.42822319f, 
    0.17078191f, 0.06118550f, 0.22391392f, 0.30129489f, 0.27118099f, -0.09684397f, 0.00437048f, -0.17292802f, 
    0.11174481f, -0.09742843f, 0.19475347f, 0.03837373f, -0.08495852f, 0.32247394f, 0.15810627f, 0.03869839f, 
    0.08082768f, -0.09438225f, 0.10846584f, -0.23051484f, 0.34884426f, -0.51764226f, -0.43030706f, -0.41682407f, 
    0.13930576f, 0.07546925f, -0.10982006f, 0.10128636f, -0.27723432f, -0.02573653f, 0.08686236f, 0.20959148f, 
    0.01763377f, -0.44865525f, 0.58667195f, 0.13859287f, 0.16216016f, 0.20569248f, -0.14316495f, 0.03417791f, 
    0.04269842f, 0.00269702f, -0.04268425f, 0.06128561f, -0.22638451f, 0.29102626f, 0.01971794f, 0.01833789f, 
    0.05460651f, -0.06129562f, 0.03731669f, -0.04862405f, -0.09946588f, 0.06321288f, 0.07071206f, -0.09078869f, 
    0.01124380f, -0.08407371f, 0.04583277f, 0.01903010f, 0.01925390f, 0.11708683f, -0.10531820f, -0.12428330f, 
    -0.01153379f, 0.02528995f, -0.00261348f, 0.04548404f, 0.10269707f, -0.00777496f, 0.03949318f, -0.14223696f, 
    -0.07145916f, 0.04640367f, -0.11386023f, -0.08422203f, 0.03696856f, 0.01469541f, -0.03729384f, -0.14577462f, 
    -0.13837111f, -0.00492225f, 0.03132836f, 0.00378516f, 0.06213116f, -0.06932322f, 0.05711466f, -0.11059763f, 
    -0.04660435f, -0.14558922f, 0.06736894f, -0.08435679f, 0.03437284f, 0.04915842f, -0.11553206f, -0.13689938f, 
    -0.14945856f, 0.00830354f, 0.02771042f, 0.00377241f, -0.03701660f, 0.02730330f, 0.06849897f, 0.01938511f, 
    -0.09443529f, -0.04808898f, 0.06068803f, -0.04953488f, -0.04988353f, 0.03382126f, 0.04379692f, -0.14079091f, 
    -0.05310261f, 0.12940288f, -0.16598926f, -0.31774798f, -0.10692669f, -0.17938779f, -0.03610634f, 0.04641016f, 
    0.06894831f, -0.04719901f, 0.11624052f, 0.39630824f, -0.16481219f, 0.04471967f, 0.13707386f, 0.15834697f, 
    -0.01423545f, 0.43982279f, 0.11691929f, -0.49810567f, -0.06559405f, 0.38637796f, -0.17099640f, 0.27290344f, 
    -0.21817012f, 0.09561326f, 0.04246783f, 0.12527420f, -0.07606129f, 0.02660112f, -0.02250594f, -0.04135584f, 
    0.40554497f, -0.11852483f, 0.25457796f, 0.41179386f, -0.05223946f, -0.16981332f, -0.25444323f, 0.09829839f, 
    0.31253386f, 0.10034365f, 0.17485495f, 0.23388898f, -0.17991540f, 0.08655269f, 0.00731781f, -0.19500409f, 
    0.07525193f, 0.35394114f, 0.12123422f, -0.28673592f, -0.06290328f, 0.07844892f, 0.36855289f, 0.32025641f, 
    0.03217688f, 0.30414441f, -0.18155305f, -0.09721474f, -0.01660079f, -0.08146234f, 0.17636694f, -0.08800313f, 
    0.23504403f, 0.50240314f, 0.06517449f, -0.00299970f, 0.25333202f, -0.20879868f, -0.01649799f, -0.03293568f, 
    0.23759700f, 0.00052641f, -0.06337190f, -0.24374734f, 0.10726982f, -0.01097611f, 0.18492600f, -0.02861723f, 
    -0.16112295f, -0.85122156f, 0.04741545f, 0.39681017f, -0.17933284f, -0.14270414f, -0.11935465f, -0.17878364f, 
    0.13536769f, -0.11500768f, -0.19467047f, -0.31887659f, 0.04089195f, 0.15928525f, 0.22234026f, 0.12219036f, 
    -0.01568400f, -0.08732718f, -0.01786427f, 0.15908420f, -0.22302748f, 0.35786241f, -0.06065905f, 0.14006189f, 
    0.16898336f, -0.18984567f, -0.00346623f, 0.31234682f, -0.12539956f, 0.00854577f, 0.24510549f, 0.13171747f, 
    -0.21778892f, -0.10394111f, -0.21532005f, 0.07726792f, -0.02019405f, -0.05604248f, 0.05865813f, 0.15851371f, 
    0.04132099f, 0.25958052f, 0.19120920f, -0.03247984f, 0.15825509f, -0.02241344f, 0.00081925f, -0.12314742f, 
    0.09498120f, 0.13449353f, 0.09025220f, -0.12686619f, 0.13658604f, 0.00118489f, -0.00008045f, 0.03832677f, 
    -0.19383799f, 0.02053530f, -0.03551343f, -0.41586903f, -0.06718623f, -0.02495916f, 0.06831271f, -0.34288824f, 
    0.06240802f, -0.56000727f, -0.04087684f, 0.64276516f, -0.18333818f, -0.19562462f, 0.49998331f, -0.15878582f, 
    0.25145167f, 0.19662739f, -0.12291443f, -0.07391781f, -0.07789817f, 0.18962076f, 0.18395431f, 0.34926477f, 
    0.12503339f, 0.23500916f, 0.04246166f, -0.06513496f, 0.32855991f, 0.16960302f, 0.20653751f, 0.07204597f, 
    -0.16258065f, -0.19592400f, -0.26078632f, 0.09417380f, 0.22320347f, -0.13681144f, 0.05934165f, 0.07488104f, 
    0.29467827f, -0.01342470f, -0.18009895f, 0.11931553f, -0.07362338f, 0.31048542f, 0.04690086f, -0.14356031f, 
    -0.17094947f, -0.22925173f, 0.39581925f, 0.07919084f, -0.14396584f, 0.32526642f, -0.20038496f, -0.06348280f, 
    0.08241640f, 0.02267189f, 0.48014334f, 0.37531957f, 0.04307437f, 0.48777485f, 0.25994423f, 0.06357300f, 
    -0.00264557f, -0.09205768f, 0.00647799f, -0.30475295f, 0.18217218f, 0.02206083f, -0.03767570f, -0.05181222f, 
    0.14566016f, -0.63678074f, 0.13599874f, 0.07420101f, -0.04329821f, -0.18085809f, -0.13921745f, -0.23321138f, 
    0.24084286f, 0.17496964f, 0.14435929f, -0.16663718f, 0.09191993f, 0.19575877f, 0.38698649f, 0.31118277f, 
    -0.09173257f, 0.14580752f, -0.24753952f, -0.17409395f, 0.24061693f, 0.45947930f, 0.22056063f, -0.03510093f, 
    -0.08372127f, -0.11473183f, -0.27999800f, -0.23145269f, -0.33490404f, 0.02075817f, 0.03125212f, 0.18501534f, 
    0.26923394f, -0.32008666f, 0.02485122f, 0.40673077f, 0.31724057f, 0.19896142f, -0.03387673f, -0.22792551f, 
    0.07257511f, 0.00060100f, 0.43022716f, 0.19095537f, -0.07823000f, 0.18836430f, -0.09241224f, 0.02512170f, 
    0.05088589f, 0.12547559f, 0.11573080f, 0.22389673f, 0.24811284f, 0.38519666f, -0.00828501f, -0.04543118f, 
    0.25194693f, 0.21345492f, -0.11956242f, -0.47581220f, -0.29956976f, -0.09632303f, 0.40762520f, -0.05296762f, 
    0.24598600f, -0.57500237f, 0.10254336f, 0.37675211f, 0.06689197f, 0.02897340f, -0.07699698f, -0.31152982f, 
    0.41848949f, -0.09322561f, 0.11400370f, 0.06342851f, 0.10626196f, -0.00466423f, 0.15270552f, -0.11574344f, 
    0.06591836f, 0.04483354f, -0.02333086f, -0.19978127f, -0.26978382f, -0.00526574f, 0.26844263f, -0.05884554f, 
    0.08224710f, 0.02943784f, 0.16500247f, -0.54929787f, 0.22981921f, -0.01212085f, -0.05178129f, 0.08546276f, 
    -0.19440858f, 0.06339864f, -0.11286110f, 0.26358780f, 0.12054114f, -0.05218883f, 0.13164067f, -0.23083910f, 
    0.32897618f, -0.12524462f, -0.34361553f, 0.26438522f, -0.06530294f, 0.01124486f, -0.15582255f, -0.21874100f, 
    0.06884794f, -0.06323788f, -0.13121212f, 0.08640978f, 0.01523270f, -0.07249720f, 0.05926263f, -0.10419725f, 
    0.08504957f, -0.01328987f, 0.02725045f, 0.06177503f, -0.07702732f, 0.00835186f, 0.05021714f, -0.09392279f, 
    0.09638283f, 0.02375644f, -0.12884739f, -0.02505350f, 0.04710059f, -0.01653781f, 0.08825231f, -0.09159337f, 
    0.01135733f, -0.10643263f, 0.00045673f, 0.03983327f, 0.00277394f, -0.04709701f, -0.03720532f, 0.05709448f, 
    0.03368860f, -0.14562149f, -0.13905248f, 0.07272275f, -0.08584082f, 0.02218124f, -0.12543820f, -0.12259687f, 
    -0.12288188f, 0.05353882f, 0.05877458f, -0.09396183f, -0.05987476f, -0.12275333f, -0.02426293f, -0.09197195f, 
    -0.12944885f, 0.09672868f, -0.12094123f, -0.11594838f, -0.00183787f, 0.09549651f, 0.02720803f, 0.04470389f, 
    -0.07076589f, -0.07779729f, -0.07996455f, 0.09977461f, -0.06167353f, 0.08982343f, -0.03799469f, -0.13500686f, 
    0.09408943f, -0.26482117f, 0.21396704f, 0.20033473f, -0.04970398f, -0.04418843f, -0.02829189f, -0.03088737f, 
    -0.06869053f, -0.07841773f, -0.11933589f, -0.68099529f, -0.04627413f, 0.10355736f, -0.37882978f, 0.23879510f, 
    -0.13488132f, 0.24806449f, -0.04629317f, 0.11780550f, -0.03267295f, 0.17085615f, -0.04443737f, 0.07511960f, 
    0.01628435f, 0.32903978f, 0.23723976f, 0.13889852f, -0.10503824f, 0.00415522f, 0.20264091f, 0.33804810f, 
    0.02821074f, -0.13359143f, -0.03499736f, 0.18810736f, 0.44212034f, 0.31841207f, 0.14466152f, -0.06123479f, 
    -0.14639592f, -0.02995868f, -0.30883169f, -0.21211888f, 0.27198505f, -0.39065370f, -0.33155754f, 0.04669054f, 
    0.21764384f, -0.11588670f, -0.19627139f, 0.15191638f, 0.10827775f, 0.31431538f, 0.06201486f, -0.19921659f, 
    0.15331715f, -0.24809749f, 0.10068996f, -0.01288215f, 0.00317632f, 0.24387023f, 0.06093628f, 0.32088667f, 
    0.20276976f, 0.18905981f, -0.37595648f, -0.13076736f, 0.24645679f, -0.37385139f, -0.34695643f, 0.08200212f, 
    0.10244180f, -0.07813273f, 0.10901025f, 0.28100547f, -0.50470978f, 0.08714998f, 0.20045620f, 0.02731025f, 
    0.06832499f, 0.15494986f, -0.07576484f, 0.12528096f, -0.04996217f, 0.18165478f, 0.57063878f, 0.36821491f, 
    0.01928325f, -0.09456295f, 0.11257584f, 0.28654778f, 0.04581663f, -0.05886076f, -0.48930281f, -0.33195773f, 
    0.36476010f, 0.22197811f, 0.17586808f, 0.45879227f, 0.09930912f, -0.18587272f, -0.29270285f, 0.22219087f, 
    0.17641796f, 0.30544350f, 0.17602548f, 0.49938670f, 0.24037600f, -0.03658478f, 0.19833092f, -0.11306401f, 
    -0.18792023f, 0.50820315f, -0.16682376f, -0.15427859f, -0.00444815f, 0.14008667f, 0.31144315f, 0.29154527f, 
    -0.09979178f, -0.22908980f, -0.15807967f, -0.02475909f, 0.10079014f, 0.23085707f, 0.18652022f, -0.03348546f, 
    -0.18838291f, -0.57395619f, 0.20153698f, 0.12528250f, -0.31922013f, 0.07258289f, -0.01934481f, 0.10404931f, 
    -0.10585553f, -0.31380433f, 0.00746389f, 0.01421818f, 0.17824647f, 0.01412669f, -0.30130076f, 0.43809801f, 
    -0.12381963f, 0.28648731f, 0.15570697f, -0.21434753f, 0.25142983f, -0.02829021f, -0.37798977f, -0.01698012f, 
    -0.25777552f, 0.03199193f, 0.05979884f, -0.07504678f, 0.02563553f, 0.09080017f, 0.07940496f, 0.12418647f, 
    0.01191960f, -0.32134643f, 0.22939190f, -0.05306406f, 0.31342953f, -0.35154283f, -0.29787767f, -0.45149153f, 
    -0.02864691f, -0.17482273f, -0.24537168f, -0.49460769f, -0.22491120f, -0.31086540f, -0.36397508f, 0.06698373f, 
    0.08816359f, -0.25999522f, 0.21431161f, 0.20407850f, -0.01283863f, 0.24766101f, 0.08596035f, 0.11177996f, 
    0.12068962f, -0.10695024f, 0.05234862f, 0.03677362f, -0.02335227f, 0.00812477f, -0.02900671f, 0.18362692f, 
    0.09546118f, 0.02100025f, 0.02187292f, 0.02965803f, -0.01786904f, 0.36634311f, -0.03185583f, -0.07052423f, 
    0.10063436f, -0.34025726f, -0.07698458f, -0.07024746f, -0.28561622f, 0.11676112f, 0.11595407f, -0.31577855f, 
    0.05213372f, 0.10253807f, 0.16090883f, 0.59027678f, -0.87578911f, 0.16489139f, 0.44213319f, -0.06391136f, 
    0.64864451f, -0.01584470f, 0.04737109f, -0.07841479f, 0.07570073f, 0.27362919f, 0.19824059f, 0.19312494f, 
    0.31828701f, 0.06875826f, 0.07117324f, 0.11857272f, 0.20001465f, -0.10273275f, -0.12359949f, -0.07634445f, 
    0.19759996f, -0.10981161f, 0.03148470f, -0.03645319f, -0.23374552f, -0.22858851f, -0.08907802f, 0.23494239f, 
    0.01574312f, 0.05632187f, 0.27151662f, 0.08571351f, 0.14991052f, 0.27647179f, 0.23203844f, 0.03122784f, 
    0.06453903f, -0.06156836f, 0.00175554f, 0.00618943f, -0.19040841f, 0.16357873f, -0.19493306f, -0.25964561f, 
    0.16711237f, 0.12542805f, 0.17944644f, 0.00208367f, 0.16923499f, -0.34819350f, -0.08830647f, -0.05065754f, 
    0.05250346f, 0.01989125f, 0.00175405f, -0.20100379f, -0.20200257f, -0.04121035f, -0.04429535f, 0.07219151f, 
    -0.16116685f, -0.05617850f, -0.04716121f, 0.06992768f, -0.13044776f, 0.01881466f, 0.51505876f, 0.16874354f, 
    -0.04622237f, 0.10067738f, -0.07983138f, 0.06184765f, -0.09184289f, -0.07678542f, -0.24043007f, -0.09605857f, 
    0.23592398f, 0.40880212f, -0.00793088f, 0.43041274f, 0.46426332f, 0.11085395f, 0.02174088f, 0.16239133f, 
    0.04333836f, 0.00916663f, -0.36672717f, 0.18241853f, 0.68757296f, 0.01226400f, 0.08445343f, -0.08494634f, 
    0.12941498f, 0.41841713f, -0.26158252f, -0.01238469f, 0.09583621f, -0.06623328f, 0.31139266f, -0.15135078f, 
    -0.01769088f, -0.47457916f, 0.08426892f, -0.04209322f, -0.10744402f, 0.24137978f, -0.01856940f, -0.22032653f, 
    0.05457542f, -0.04433913f, 0.34496957f, 0.35960498f, 0.12179789f, 0.25654748f, 0.06854032f, -0.06885271f, 
    0.32021946f, 0.04076429f, -0.08226662f, -0.11020762f, 0.04253962f, 0.04257029f, 0.09989377f, 0.37389135f, 
    0.17586754f, 0.83494639f, 0.21779822f, -0.39395511f, 0.33583218f, 0.10068085f, -0.64110708f, -0.05957494f, 
    -0.06714596f, -0.07259234f, 0.23616868f, 0.35526729f, 0.09816410f, -0.05064363f, 0.13933152f, -0.13297306f, 
    0.05935949f, -0.14045720f, 0.04821755f, -0.28968880f, 0.02271147f, 0.01559122f, -0.07803695f, -0.01135275f, 
    0.18253206f, -0.01435168f, 0.10589267f, -0.70946646f, 0.21236108f, -0.08041042f, -0.07197309f, -0.00648102f, 
    -0.17350551f, -0.02637478f, -0.02708898f, 0.07498552f, 0.20644405f, -0.02026830f, -0.05614552f, -0.02763292f, 
    0.38248038f, -0.10235180f, -0.31903765f, 0.36196029f, 0.05711940f, -0.08254277f, 0.18957168f, 0.15888372f, 
    0.24102363f, 0.23899519f, -0.14358516f, -0.09458705f, -0.10224733f, -0.34093368f, -0.17487791f, -0.10237937f, 
    0.24235612f, 0.01295618f, -0.03903217f, 0.22820705f, -0.09734211f, 0.06153403f, 0.07700618f, 0.13362996f, 
    -0.05419702f, 0.51936579f, 0.21191120f, 0.01758764f, -0.00137051f, 0.21683256f, -0.09826921f, 0.15402238f, 
    -0.20220667f, -0.08983990f, 0.01403088f, -0.00433887f, 0.07201624f, 0.06697968f, 0.07685488f, -0.11441961f, 
    0.12710111f, -0.09386274f, 0.27817664f, 0.44106901f, -0.11928163f, 0.04447393f, -0.10460724f, -0.02643997f, 
    0.32714278f, 0.04032518f, -0.10505158f, 0.32113636f, -0.35479489f, 0.06661350f, 0.32275018f, -0.13516872f, 
    -0.28934276f, 0.36134356f, 0.08083360f, -0.22149618f, -0.04029652f, 0.05048977f, 0.22349593f, 0.64751959f, 
    -0.12189376f, 0.19462498f, 0.09334280f, -0.14972062f, 0.29996258f, -0.03962177f, 0.19556575f, 0.17128798f, 
    0.21434999f, 0.12153066f, -0.22694428f, -0.11188843f, 0.42474234f, -0.19358090f, -0.03584688f, 0.10438336f, 
    0.31691310f, 0.15524931f, 0.10420109f, -0.18740201f, -0.28183281f, 0.06732899f, 0.16213226f, -0.30774632f, 
    0.23649582f, -0.83464229f, -0.03935792f, 0.35222194f, 0.08628727f, 0.11939153f, 0.47630310f, 0.23955737f, 
    -0.01017313f, -0.04149621f, 0.05985964f, 0.41552106f, -0.05654775f, -0.13770477f, -0.38715690f, -0.25027096f, 
    0.19424517f, 0.08459444f, 0.09022722f, 0.26090100f, -0.31239557f, -0.02905311f, -0.14172412f, 0.26335257f, 
    0.22524042f, 0.28160641f, 0.18694106f, 0.19902305f, 0.18342093f, -0.05506139f, -0.02726038f, -0.10786075f, 
    -0.09163900f, 0.38867351f, -0.25388253f, -0.11109322f, -0.01953958f, -0.22255909f, 0.06408309f, 0.29971990f, 
    0.21657969f, -0.01679558f, -0.25375313f, 0.29931673f, 0.25125238f, -0.01990151f, 0.03939776f, 0.11962084f, 
    -0.02885259f, -0.09935159f, -0.17434761f, 0.06256358f, -0.13907108f, -0.16273166f, -0.00975973f, -0.05616942f, 
    -0.11952949f, -0.10014743f, -0.12162341f, 0.05385008f, 0.06830240f, -0.01376195f, 0.05532761f, -0.02383938f, 
    0.02640102f, 0.05544357f, -0.07475768f, 0.08302274f, 0.04827112f, -0.08881734f, 0.04565990f, -0.01716760f, 
    0.02174293f, 0.03485940f, 0.07967392f, -0.00501289f, -0.07780190f, -0.15443553f, 0.05749656f, -0.04086618f, 
    -0.07036453f, -0.13434266f, -0.01891153f, -0.06071392f, -0.02885794f, 0.02361050f, 0.00595212f, -0.13124436f, 
    -0.05127181f, 0.01508945f, 0.06197439f, -0.09718727f, -0.10871885f, 0.04272477f, 0.01537141f, -0.06567241f, 
    -0.11750610f, 0.00600617f, -0.01722625f, 0.07080311f, 0.07590013f, -0.05510967f, -0.08612429f, 0.04920603f, 
    -0.17075461f, 0.05838329f, -0.02809529f, -0.13525078f, -0.11905622f, -0.13931771f, 0.08117000f, -0.01682007f, 
    0.09220392f, 0.15153372f, 0.08250538f, 0.00010769f, 0.02391383f, 0.49712169f, 0.15076719f, -0.11807093f, 
    -0.06365965f, -0.26752144f, -0.06413779f, 0.79368061f, 0.46090922f, 0.09196045f, 0.19126746f, 0.15286577f, 
    0.24334989f, -0.19152515f, 0.10419352f, 0.25694478f, 0.15394087f, -0.19574223f, 0.09851908f, 0.07533029f, 
    0.31241295f, -0.23268130f, 0.03757015f, 0.06981366f, 0.04109384f, 0.51189822f, 0.43029290f, -0.11600577f, 
    0.02596891f, -0.11782660f, 0.31128749f, -0.59348589f, 0.46073985f, -0.09579684f, 0.13656688f, 0.00878103f, 
    0.09699449f, -0.15302405f, 0.17724526f, -0.07069944f, 0.11014958f, 0.05610598f, 0.20849890f, 0.32947052f, 
    -0.06719695f, -0.17675109f, 0.15561756f, 0.18841703f, -0.26718289f, 0.20972477f, -0.00246914f, -0.01164967f, 
    -0.09552247f, -0.36976507f, -0.20783593f, 0.15515088f, 0.02878765f, 0.10967369f, 0.09227869f, -0.38056520f, 
    -0.20841068f, -0.11684575f, -0.02047972f, 0.18513533f, -0.40018496f, 0.11362698f, -0.30144638f, -0.01659861f, 
    0.02916853f, -0.24800168f, -0.07888614f, 0.23643732f, -0.26235542f, 0.09973779f, -0.03875889f, 0.41663343f, 
    -0.16319376f, 0.02197184f, 0.15122528f, -0.10687166f, -0.41162363f, 0.27412620f, 0.09404182f, -0.10691626f, 
    0.01534688f, -0.12159097f, 0.15874672f, -0.08577865f, 0.12150773f, 0.04952425f, -0.31409681f, -0.17770845f, 
    0.11450616f, -0.17184733f, 0.08598197f, 0.18576583f, -0.08659567f, -0.44696218f, -0.43905282f, -0.11560562f, 
    0.24687718f, 0.10957264f, -0.10005862f, 0.15881233f, -0.23981188f, -0.07736590f, -0.28100249f, 0.19354063f, 
    -0.10578401f, -0.12470140f, 0.45340458f, 0.15198705f, 0.16202143f, 0.14678478f, 0.03241468f, 0.23404109f, 
    -0.13825862f, 0.38803378f, 0.08059930f, -0.20919997f, -0.27302396f, 0.04388011f, 0.13027081f, 0.00511593f, 
    -0.27961269f, -0.04457357f, 0.28761071f, 0.12357637f, -0.28599387f, 0.54571563f, 0.25749278f, 0.05528292f, 
    0.13967063f, 0.18808943f, -0.02625765f, 0.77455688f, 0.26714864f, 0.07593381f, 0.18601356f, 0.12321199f, 
    0.25073558f, -0.36722535f, 0.22599982f, 0.11824152f, -0.13332041f, -0.16543399f, -0.09635600f, -0.08793397f, 
    0.31939167f, -0.19980200f, -0.07686794f, 0.12885644f, -0.08199763f, 0.23654842f, 0.35121912f, 0.25399244f, 
    -0.27530992f, 0.01357630f, -0.12654784f, -0.37446761f, 0.14603689f, 0.20787454f, 0.12046590f, -0.18740039f, 
    -0.04353261f, 0.01932125f, 0.09523212f, -0.28773132f, -0.40930337f, 0.17323500f, -0.08186083f, 0.13776661f, 
    0.24119714f, -0.16969985f, 0.66514295f, 0.26301944f, 0.12107186f, -0.00947389f, -0.29699734f, -0.00294171f, 
    0.10888957f, 0.46619251f, 0.17673744f, 0.02082925f, -0.05186086f, 0.19203560f, -0.03438356f, 0.12359527f, 
    0.18748109f, 0.03374860f, 0.32820138f, -0.27733046f, -0.00056254f, 0.05242476f, 0.14524138f, 0.05987327f, 
    0.02762569f, 0.16058038f, -0.02060190f, -0.14398111f, 0.16727887f, -0.04741172f, 0.23525405f, -0.06096196f, 
    0.12222595f, -0.10996204f, 0.08237077f, 0.33593947f, 0.24534340f, -0.24977213f, 0.27040276f, -0.00079673f, 
    0.09992978f, 0.12605931f, 0.07380301f, 0.03279556f, -0.13202570f, 0.24961181f, 0.08472824f, 0.18736799f, 
    0.15342931f, 0.36306885f, -0.04622244f, -0.10510945f, 0.78397477f, 0.28413826f, 0.14610551f, 0.07072952f, 
    0.00896444f, -0.06010025f, -0.04016684f, -0.56036556f, 0.04433433f, -0.06392868f, -0.04622804f, 0.11474145f, 
    0.22887653f, -0.15214635f, -0.13636678f, 0.25475821f, 0.07735150f, 0.22471166f, 0.00698444f, -0.32361171f, 
    0.20336857f, -0.29591000f, 0.11970872f, -0.00364310f, -0.12170962f, 0.52517784f, -0.17377885f, -0.15004940f, 
    -0.14315797f, 0.11913251f, -0.22541369f, 0.02270360f, -0.02628373f, 0.29162988f, -0.12773392f, 0.08460866f, 
    0.22724378f, -0.00383068f, 0.09051313f, 0.78129011f, -0.47644091f, -0.11850752f, 0.53816593f, -0.21446832f, 
    0.40166405f, -0.08699892f, 0.05524016f, 0.51697397f, 0.18119261f, 0.15380816f, 0.68270713f, 0.05480553f, 
    0.59932685f, -0.21539092f, 0.04452325f, 0.38769525f, -0.07907917f, 0.13418251f, -0.12992123f, -0.38433528f, 
    0.17315637f, 0.19714628f, -0.07157546f, -0.29901028f, 0.01251627f, -0.44794890f, -0.12528789f, 0.02110672f, 
    0.08581087f, 0.10942924f, 0.14367206f, 0.31436178f, 0.42614892f, 0.23910435f, 0.23459762f, 0.31959775f, 
    -0.34326899f, 0.48697293f, 0.16557977f, 0.14281371f, -0.04974063f, 0.01355244f, 0.16399913f, 0.03019122f, 
    -0.05665939f, -0.18525942f, -0.46642655f, 0.31511784f, -0.10960054f, 0.14154404f, -0.22214215f, -0.50618273f, 
    0.00285955f, 0.09367170f, -0.05401152f, -0.14705026f, -0.39065143f, -0.29115248f, -0.12457529f, -0.10821007f, 
    -0.15570483f, -0.29531839f, -0.06560673f, 0.30056378f, 0.39945927f, -0.04940329f, -0.27130631f, 0.33530554f, 
    0.05788020f, -0.18236612f, 0.26008880f, -0.14694650f, -0.74988657f, 0.03308065f, -0.18982963f, -0.02596603f, 
    -0.30348215f, 0.06664190f, -0.11669146f, 0.01482537f, 0.02526083f, 0.33116123f, 0.29504859f, 0.26874936f, 
    0.28282928f, -0.45884714f, 0.42489401f, 0.37266821f, 0.14259239f, 0.12697096f, -0.36470893f, -0.16905831f, 
    0.19442350f, -0.06776020f, -0.39614525f, 0.17984135f, -0.52607596f, -0.36477792f, -0.09800739f, -0.10971709f, 
    -0.08478352f, 0.04159022f, 0.17353424f, -0.16399589f, 0.12063796f, 0.29636315f, 0.11592738f, 0.30299354f, 
    0.02619118f, 0.28827137f, 0.16472301f, -0.27432752f, 0.04077546f, 0.03250878f, 0.01069939f, 0.07460452f, 
    0.04631498f, 0.21556541f, -0.19841422f, -0.05221080f, -0.10896288f, -0.15803169f, -0.13555323f, 0.00268225f, 
    0.22218624f, -0.46089149f, 0.11493565f, 0.32718229f, 0.17362092f, -0.09859219f, 0.09376940f, -0.07761691f, 
    0.25481257f, -0.33650917f, 0.14489104f, 0.32530785f, -0.12661014f, -0.08938875f, 0.18355988f, 0.13848607f, 
    0.18323216f, -0.18102033f, -0.09623317f, -0.00107614f, 0.07430872f, 0.32907239f, 0.28138003f, -0.10096106f, 
    -0.09529418f, 0.01116864f, 0.12600876f, -0.30068102f, 0.06891993f, 0.07829806f, -0.06520263f, 0.00594549f, 
    0.15935661f, -0.13249859f, -0.07447219f, 0.38441688f, 0.17271781f, 0.00456111f, 0.08875363f, 0.10682645f, 
    -0.31050014f, 0.10192291f, 0.02720561f, -0.19420144f, -0.34322169f, 0.20245732f, -0.02906987f, 0.06100367f, 
    -0.20385547f, -0.52838260f, -0.03750351f, 0.22026493f, 0.15653627f, -0.03003053f, -0.00009797f, -0.27083999f, 
    -0.07357524f, 0.00222974f, -0.02868623f, -0.09969135f, -0.00101848f, -0.00159960f, -0.02212555f, 0.07846791f, 
    -0.12881722f, 0.12231347f, -0.11097959f, 0.04139242f, -0.02184510f, 0.06917992f, 0.06346676f, -0.10751556f, 
    -0.11659617f, -0.05047581f, 0.01666060f, -0.00929433f, -0.00895529f, 0.09067518f, 0.08585256f, -0.02549480f, 
    -0.01631577f, 0.00486124f, -0.12061385f, 0.07895782f, 0.00415741f, 0.10621408f, -0.05133021f, 0.08646009f, 
    -0.06847028f, 0.02397563f, 0.07947519f, -0.03269624f, 0.04718017f, -0.13975334f, 0.00663896f, -0.10552195f, 
    0.04405082f, 0.06997556f, 0.04754925f, 0.03890954f, 0.01571986f, -0.09788051f, 0.05274663f, 0.06416344f, 
    -0.09211882f, -0.13582078f, -0.06860639f, -0.05592716f, -0.01590294f, -0.10268962f, -0.12592198f, -0.10877026f, 
    -0.12464401f, -0.04290558f, 0.09326685f, -0.14163564f, -0.10199250f, 0.04031284f, -0.06513890f, -0.09449030f, 
    -0.15699235f, 0.15336816f, 0.12681745f, -0.56910962f, -0.21878543f, -0.24954751f, 0.10424225f, 0.03541705f, 
    0.10096681f, 0.13567431f, 0.09644726f, 0.17089905f, -0.16119093f, -0.08989719f, 0.07200831f, -0.17050561f, 
    -0.08923514f, 0.59502006f, 0.27247629f, -0.50119561f, -0.09742856f, 0.12252958f, 0.23946290f, 0.12758072f, 
    -0.58253741f, -0.04994306f, -0.35345650f, 0.11206827f, 0.11538839f, -0.34006429f, -0.32638940f, 0.14855307f, 
    -0.10583527f, 0.30110243f, 0.02441194f, 0.66849077f, -0.24189121f, -0.09009516f, 0.02654181f, 0.02212252f, 
    0.06636941f, 0.18064016f, -0.11321116f, 0.32965615f, -0.32943848f, 0.16117479f, 0.24126457f, -0.25544721f, 
    -0.04538688f, 0.12505209f, -0.00390503f, -0.50441104f, 0.32495070f, -0.36176631f, 0.00983882f, 0.16053164f, 
    -0.06378102f, 0.42585820f, 0.21892737f, 0.00205926f, -0.00623323f, -0.06222721f, 0.12186961f, 0.11136759f, 
    0.03308933f, -0.09506258f, 0.17001228f, -0.03864411f, 0.06379728f, 0.17070328f, -0.06709712f, -0.11273217f, 
    -0.11824993f, 0.12923032f, -0.02250955f, -0.53152096f, 0.01421981f, -0.06780857f, 0.14140899f, -0.08306113f, 
    0.26285246f, 0.37778187f, -0.01880362f, 0.25944397f, -0.02785206f, -0.04975139f, 0.07866700f, 0.03518320f, 
    0.08594860f, 0.28951833f, 0.20275937f, 0.06230831f, -0.08278742f, 0.14575717f, 0.23761669f, 0.18470611f, 
    0.08468406f, -0.08198360f, -0.10075730f, -0.09395060f, 0.38716233f, 0.08475049f, 0.12043696f, -0.03174781f, 
    -0.09976625f, -0.05813566f, 0.03940150f, -0.23931815f, -0.04332464f, 0.01225893f, -0.15494834f, 0.03960721f, 
    0.24267229f, -0.03633736f, -0.29688919f, 0.23618449f, 0.10997132f, 0.27065465f, 0.17817253f, -0.10353853f, 
    0.20283844f, -0.10829851f, -0.01759003f, 0.04951436f, -0.08344638f, 0.43092966f, -0.02818657f, -0.00454581f, 
    0.08505162f, 0.29690960f, -0.03334086f, 0.08971159f, -0.04539710f, 0.24829841f, -0.27429992f, 0.10020113f, 
    0.28114006f, -0.60101306f, -0.08734100f, 0.67088419f, -0.37201142f, -0.00899674f, 0.26680294f, -0.14236815f, 
    0.21716079f, 0.18704790f, 0.24534343f, 0.39747262f, -1.08242714f, 0.06687751f, 0.32996568f, -0.09315901f, 
    0.42961431f, -0.35073680f, -0.02103745f, 0.17849995f, 0.05571310f, 0.09422154f, -0.07990342f, -0.25821280f, 
    0.06531878f, 0.04625541f, 0.09072883f, 0.02182194f, -0.17601417f, -0.33982319f, -0.39343658f, -0.01618179f, 
    0.28443918f, -0.03213236f, 0.08237014f, 0.31053841f, 0.21568690f, 0.13297518f, -0.02384288f, 0.30951893f, 
    -0.40331310f, 0.18803772f, 0.44606176f, 0.13286699f, 0.04111149f, 0.04827506f, 0.05935713f, -0.05245828f, 
    0.03074420f, -0.04739663f, -0.19220142f, 0.03115041f, -0.26328108f, 0.09136397f, -0.25943443f, -0.43506330f, 
    0.03564100f, -0.03901272f, -0.01772302f, 0.17188197f, 0.01425164f, -0.12528911f, -0.18984278f, -0.04798056f, 
    -0.13179399f, 0.01977421f, -0.01172926f, -0.67372787f, -0.20675921f, 0.06694865f, -0.03276220f, 0.21688421f, 
    -0.06853791f, 0.05049913f, 0.10405163f, 0.21282960f, -0.51167959f, 0.32296115f, 0.00761479f, 0.11326566f, 
    0.15003265f, 0.22815830f, 0.29699993f, -0.05258150f, -0.02350619f, 0.00729318f, -0.33158392f, 0.02280134f, 
    0.14714907f, 0.01761689f, 0.24093238f, 0.41886765f, 0.26999664f, -0.22223836f, -0.16827293f, -0.09129202f, 
    0.02820582f, 0.01879610f, -0.12538336f, 0.03423491f, 0.13495527f, -0.23577221f, -0.28068885f, 0.13251358f, 
    -0.02819441f, -0.01892705f, -0.16702232f, 0.01850485f, 0.29301009f, 0.26515090f, 0.25507885f, 0.00341324f, 
    0.11525265f, -0.02967425f, -0.11377662f, -0.07633112f, -0.12926105f, 0.27290472f, -0.05697762f, 0.01652675f, 
    -0.04261235f, 0.18651769f, -0.03260523f, -0.68007386f, 0.04279988f, -0.39272943f, 0.13705325f, 0.00177445f, 
    0.08912697f, -0.02213827f, -0.00159959f, 0.13105711f, 0.07046107f, 0.05323082f, 0.06715680f, -0.30979490f, 
    -0.06479082f, 0.24710415f, -0.11926021f, 0.67620903f, -0.08042084f, -0.20534831f, 0.49351409f, -0.01419291f, 
    0.25103873f, -0.26821166f, -0.52142328f, -0.21216418f, 0.00789735f, -0.13310930f, -0.44228908f, -0.03775489f, 
    0.06996804f, 0.52644843f, -0.02890573f, 0.27686724f, -0.04380394f, -0.01680626f, 0.13979274f, 0.03481584f, 
    0.14941368f, -0.03242203f, -0.04066761f, 0.19854431f, -0.03666312f, 0.11025827f, 0.12590635f, 0.18457684f, 
    0.03130194f, 0.08872021f, 0.51670414f, 0.01505630f, 0.32504672f, -0.13663001f, 0.10668845f, 0.09830733f, 
    -0.14680314f, -0.32743785f, 0.38817433f, 0.01337769f, -0.02557612f, -0.15215530f, 0.00800030f, -0.15420942f, 
    0.23327768f, -0.08478554f, 0.20964177f, 0.36472231f, 0.33542463f, -0.13887568f, -0.24987413f, 0.12068954f, 
    0.29162484f, -0.07936713f, 0.03571132f, -0.72878706f, -0.23525345f, -0.04763834f, 0.12249880f, 0.12376082f, 
    0.15559620f, -0.37372226f, 0.06236847f, 0.21022505f, 0.01275884f, 0.15177390f, -0.23475918f, 0.05181940f, 
    0.17964956f, 0.07332292f, 0.11090781f, 0.07533649f, 0.06414424f, 0.17122488f, 0.10237569f, -0.14591588f, 
    0.24840038f, -0.24434346f, 0.10959655f, -0.36830553f, 0.02392040f, -0.06712480f, 0.03297851f, -0.07263119f, 
    0.03744372f, -0.10038003f, 0.12952651f, -0.36371595f, 0.72314519f, -0.22768869f, -0.10170800f, 0.27355018f, 
    -0.33371034f, 0.11452674f, -0.22654271f, 0.26435456f, -0.01671076f, 0.03815840f, 0.18086746f, -0.07036386f, 
    0.38287744f, -0.49589682f, -0.54801244f, 0.44876072f, -0.00554144f, 0.10061287f, 0.02630124f, -0.13748641f, 
    0.26601186f, 0.13176157f, -0.06234514f, 0.19312513f, -0.04193597f, 0.25248048f, -0.20561267f, 0.05824262f, 
    0.10195975f, -0.19592741f, -0.01272697f, 0.27284253f, 0.34217322f, -0.02762564f, 0.11499356f, 0.22810091f, 
    0.32170758f, -0.46402147f, 0.19048162f, -0.34247619f, 0.01548224f, -0.10068755f, -0.53129625f, -0.00161272f, 
    -0.10881983f, -0.03157388f, 0.01696438f, 0.15261191f, 0.02082703f, 0.41649684f, 0.39799270f, -0.02475436f, 
    0.09730802f, -0.55915540f, 0.29858169f, -0.49052265f, -0.24596159f, 0.10597077f, -0.12324363f, 0.10284835f, 
    0.26184547f, -0.10216095f, 0.18486224f, 0.06689937f, -0.25486523f, -0.06525318f, 0.04977357f, 0.16674764f, 
    -0.13681443f, -0.01864908f, 0.11303237f, -0.08675773f, -0.46342227f, 0.18488108f, 0.15714774f, 0.17430258f, 
    0.10343301f, -0.22804408f, -0.35242128f, 0.08275682f, 0.09599081f, -0.07042437f, 0.11934138f, -0.24616051f, 
    0.20431283f, 0.21431963f, 0.01743088f, 0.34101376f, -0.01279605f, 0.08014441f, 0.09019136f, -0.09830345f, 
    -0.05915777f, -0.13754305f, 0.04492709f, -0.26518506f, 0.16098788f, 0.05302744f, -0.21152128f, 0.34157038f, 
    -0.02942319f, 0.81727111f, 0.00218916f, -0.13550337f, -0.11235097f, 0.07880381f, -0.66748565f, 0.03052427f, 
    0.08455456f, 0.12209041f, 0.10051432f, -0.17716667f, 0.00784129f, 0.31605878f, 0.44846869f, 0.08683943f, 
    -0.04410662f, -0.28158855f, 0.19028416f, -0.14197344f, -0.01586423f, 0.13087870f, 0.15944499f, 0.08689260f, 
    -0.01293214f, -0.15875933f, -0.07698092f, 0.11984683f, -0.02688883f, -0.14457880f, 0.05701812f, 0.07581725f, 
    -0.00786852f, -0.31511268f, -0.00232438f, 0.23744544f, -0.20244718f, 0.16338587f, 0.03477771f, -0.03059773f, 
    0.01937444f, -0.02244596f, -0.05607421f, 0.16843750f, 0.24536934f, -0.10811725f, -0.14358464f, -0.02852539f, 
    0.27049693f, 0.16251636f, -0.12106190f, -0.15045325f, 0.16166845f, -0.39614317f, -0.26275700f, -0.04921636f, 
    0.14182135f, -0.09476627f, -0.02092199f, -0.00658579f, -0.28688663f, 0.10571922f, -0.09603973f, 0.15996726f, 
    -0.12793675f, -0.00607371f, 0.21007983f, 0.05487458f, -0.26709324f, 0.25778630f, 0.21869482f, 0.18281458f, 
    -0.13935874f, 0.24631575f, 0.07913913f, 0.05550801f, -0.04266708f, 0.06892986f, -0.29479268f, -0.00412497f, 
    0.31970325f, 0.04771979f, 0.23124589f, 0.74212426f, 0.28720549f, 0.01531114f, -0.08838393f, 0.18122768f, 
    0.24507421f, 0.09772054f, -0.20792262f, 0.69251722f, 0.07836428f, -0.05143838f, 0.17407553f, -0.19741452f, 
    -0.07127117f, 0.39470869f, -0.29906926f, -0.14248843f, 0.04912302f, 0.18054384f, 0.22242469f, 0.50207460f, 
    -0.00631227f, -0.08851386f, 0.04007023f, -0.18531761f, 0.03841700f, 0.01888542f, -0.06133877f, 0.10943130f, 
    -0.11838900f, -0.08050535f, 0.03829954f, -0.13193208f, 0.05437475f, -0.03114079f, 0.06659448f, -0.00553553f, 
    -0.13702321f, 0.02348111f, 0.05915959f, -0.09917752f, -0.10311581f, 0.03312401f, 0.00334841f, 0.07812210f, 
    -0.03307913f, 0.10671133f, 0.04911207f, -0.07097217f, -0.01944250f, -0.12014356f, -0.08078762f, 0.04165674f, 
    -0.07790814f, -0.10273763f, -0.09000703f, -0.11281088f, -0.09816101f, 0.01382779f, 0.06210634f, 0.02453024f, 
    -0.09504269f, -0.13239449f, -0.13561402f, -0.04453130f, -0.06214878f, 0.08161466f, -0.10583529f, -0.15986457f, 
    0.06619179f, 0.00310996f, -0.14149378f, -0.09662259f, 0.03677403f, -0.11275926f, -0.11139365f, -0.04712881f, 
    -0.02816879f, 0.07135992f, -0.11896956f, 0.01525442f, 0.03297209f, -0.06869557f, 0.04596202f, 0.02102059f, 
    -0.14049073f, 0.03939372f, -0.00393846f, 0.02985965f, -0.13299933f, -0.12798898f, -0.10814187f, -0.03750511f, 
    -0.22959335f, -0.27112621f, 0.19190694f, 0.05539731f, 0.03491732f, 0.41457024f, -0.14397429f, -0.12127817f, 
    -0.18905823f, -0.05706554f, 0.05261333f, 0.44185200f, 0.00238065f, -0.01123685f, -0.10406096f, 0.10525415f, 
    0.09555395f, 0.13913660f, -0.17233792f, 0.01287326f, 0.19063646f, 0.18864337f, 0.19530222f, -0.17191473f, 
    0.04525809f, 0.01199785f, 0.19847782f, -0.00545175f, 0.09060532f, 0.04075773f, -0.20172752f, -0.07654918f, 
    0.20416059f, 0.28961420f, -0.03008500f, -0.10517104f, 0.44065267f, -0.21550106f, -0.08992913f, -0.23133945f, 
    -0.11868611f, 0.06798685f, -0.19545747f, -0.53065610f, -0.20212226f, -0.08381858f, -0.25736749f, 0.04925542f, 
    0.25849715f, -0.27229267f, 0.38235152f, 0.41086370f, 0.34889358f, 0.31914923f, 0.04793743f, -0.11189021f, 
    0.20486830f, -0.07306077f, 0.06514525f, 0.09698300f, -0.30102748f, 0.31729636f, -0.24535972f, 0.02869051f, 
    0.04158390f, -0.36068213f, 0.12157007f, 0.15778139f, -0.37444586f, -0.35093433f, -0.20036250f, 0.07387128f, 
    0.12849233f, -0.34714019f, 0.11400335f, 0.42575949f, 0.25550658f, 0.04133108f, -0.32800516f, 0.65076512f, 
    -0.19547676f, 0.05540804f, 0.17198002f, -0.50995499f, -0.02784687f, 0.09692028f, -0.63887441f, 0.08354375f, 
    -0.25522599f, -0.00964524f, 0.18331268f, -0.09842510f, -0.01907226f, 0.09847119f, -0.17450863f, -0.04719323f, 
    0.14907749f, -0.51954097f, 0.19171780f, 0.14970279f, 0.18627855f, -0.16315418f, -0.42030320f, -0.23643957f, 
    0.14959504f, -0.09450490f, -0.30593196f, -0.55763423f, -0.08593411f, -0.30413383f, -0.51259738f, 0.25569385f, 
    -0.19311410f, -0.07064211f, 0.21777469f, 0.13730463f, 0.28581217f, 0.15725818f, 0.12485520f, 0.23722212f, 
    0.26896530f, 0.28665876f, -0.16938162f, -0.13749112f, -0.06905415f, -0.04470214f, 0.25040409f, 0.22262487f, 
    0.19644649f, 0.26130757f, -0.08741470f, -0.20114598f, 0.02329934f, -0.20419964f, 0.09761794f, -0.10149917f, 
    0.02949215f, 0.09113081f, -0.06151097f, 0.26482886f, -0.07763600f, -0.11313125f, 0.06327076f, -0.46024105f, 
    -0.13140255f, 0.92222065f, -0.05979931f, -0.68215376f, -0.05159802f, -0.01142505f, -0.41517070f, 0.13857627f, 
    0.14082424f, 0.05858142f, -0.51673710f, -0.19983627f, 0.10500164f, -0.03908514f, 0.23555744f, 0.18078995f, 
    0.39201769f, 0.10249252f, -0.18927662f, -0.65780431f, -0.32161555f, 0.08089900f, 0.05325610f, 0.06055392f, 
    -0.23081414f, -0.05387227f, 0.04013152f, 0.40986264f, 0.67223781f, 0.20420276f, 0.09932464f, -0.14452136f, 
    0.11486110f, 0.11171307f, 0.24956921f, 0.02853240f, -0.74332291f, 0.08710790f, 0.14894444f, -0.12001440f, 
    -0.21900018f, -0.01869414f, -0.12254324f, 0.10181597f, 0.05726785f, -0.42324260f, -0.05365918f, -0.09056156f, 
    0.03635162f, -0.15934931f, 0.40462482f, 0.18096803f, 0.17747664f, -0.13566679f, -0.19124913f, 0.00870676f, 
    0.09896664f, -0.07465321f, 0.12133607f, -0.90260714f, -0.20308666f, -0.11425035f, -0.11221755f, 0.21087383f, 
    -0.04462608f, 0.06719263f, 0.07199892f, -0.02509810f, -0.23094811f, 0.25203267f, -0.16873489f, -0.12154213f, 
    -0.18914033f, 0.38092467f, 0.44264823f, 0.00520893f, 0.07920632f, -0.10539807f, -0.12794167f, 0.08992381f, 
    0.25798577f, 0.13699460f, 0.17216668f, 0.24148649f, 0.07771986f, -0.05380461f, -0.11248541f, -0.07331315f, 
    0.20307416f, -0.05411948f, -0.12726828f, -0.18802670f, 0.06734651f, -0.16345946f, -0.26051369f, 0.12025722f, 
    0.15024513f, 0.13434730f, 0.01674707f, 0.26993746f, 0.46931377f, 0.01116817f, 0.34247062f, -0.07649182f, 
    0.22740154f, -0.31350252f, -0.18156722f, 0.25234914f, 0.05175221f, 0.35792169f, -0.13980162f, -0.10469560f, 
    -0.01742787f, 0.04335353f, 0.06634908f, -0.01284156f, -0.14091329f, -0.08151058f, 0.02721648f, 0.08242975f, 
    0.01179501f, -0.08505468f, -0.10712174f, 0.08743737f, -0.03531099f, -0.07234597f, -0.10343295f, 0.07774885f, 
    -0.14139019f, 0.04822325f, 0.04011923f, 0.03067432f, -0.16630103f, 0.03176785f, -0.14062980f, -0.04510907f, 
    -0.07447416f, -0.02630880f, -0.05148628f, 0.02834445f, -0.06301831f, -0.14226827f, 0.03065192f, -0.08342385f, 
    0.05818892f, 0.00393409f, -0.13693751f, -0.07428967f, -0.08842701f, -0.06865367f, 0.08939511f, -0.11913374f, 
    -0.08202516f, -0.06894332f, 0.04095617f, -0.07581016f, 0.06650684f, 0.08588340f, -0.06600331f, -0.08989727f, 
    0.01263041f, 0.12271337f, 0.02925956f, -0.09379323f, -0.00457914f, 0.03502887f, -0.12185357f, -0.12516190f, 
    -0.05752777f, -0.13218313f, -0.07724626f, 0.07860488f, 0.06046676f, -0.04799098f, -0.08917150f, -0.05709803f, 
    0.08963174f, 0.06936508f, -0.18425351f, -0.23475431f, 0.02089597f, 0.14022470f, 0.00541372f, 0.05309160f, 
    0.06788191f, -0.17044215f, 0.11335984f, 0.29076400f, 0.01709917f, 0.12082528f, -0.13199042f, -0.17522624f, 
    -0.07635166f, -0.44137034f, -0.18297917f, -0.39193138f, -0.02887231f, 0.28088406f, 0.00707609f, 0.22840674f, 
    -0.32085145f, -0.00792915f, 0.01238699f, -0.11485928f, 0.02120586f, 0.19142918f, 0.14157258f, 0.07529088f, 
    0.31398866f, -0.18415111f, 0.22500822f, 0.23975919f, -0.26534820f, 0.11126594f, -0.23177564f, -0.00054956f, 
    0.02990386f, 0.23705398f, 0.03358884f, 0.51038015f, -0.50676888f, -0.09977368f, 0.20260271f, -0.21370387f, 
    0.03417045f, 0.20622222f, -0.08503162f, -0.21287741f, 0.04493553f, 0.22253086f, 0.25082380f, 0.29936400f, 
    -0.13277026f, 0.06169187f, 0.09420530f, -0.13191603f, 0.06942509f, -0.00206047f, 0.07395139f, -0.00283700f, 
    -0.04193167f, -0.08318555f, 0.27833980f, 0.46388406f, 0.28740534f, 0.51123822f, 0.06845545f, 0.07905908f, 
    0.07207501f, 0.23476869f, -0.03097460f, -0.47791582f, 0.09696002f, 0.02333982f, 0.18292397f, 0.02641365f, 
    0.27176797f, 0.03765139f, 0.16812539f, 0.04455650f, 0.29385701f, -0.06059670f, -0.41845623f, 0.02067124f, 
    0.03416565f, -0.00036822f, 0.27812105f, 0.10818512f, 0.01818512f, -0.03166335f, 0.46304637f, -0.00142495f, 
    -0.05000373f, -0.18208246f, -0.11610553f, -0.50460279f, -0.11012740f, 0.10197170f, 0.00886986f, -0.06672898f, 
    -0.08899451f, 0.12180627f, 0.31024027f, -0.44074130f, 0.00021505f, 0.16585734f, -0.10677215f, 0.12234351f, 
    -0.00044968f, -0.02593353f, 0.00322925f, 0.24457498f, 0.01872189f, -0.02212799f, -0.00458626f, -0.12326503f, 
    0.38163579f, -0.14872223f, -0.37481067f, 0.34516644f, 0.06657444f, 0.08944175f, -0.06736211f, 0.19211121f, 
    -0.05436040f, -0.02169577f, -0.14146496f, -0.14854120f, 0.08772641f, 0.06246233f, 0.03609698f, 0.07710148f, 
    -0.06061444f, -0.12491483f, -0.06489059f, -0.09471273f, 0.05386402f, -0.06235828f, 0.01201022f, 0.07922001f, 
    -0.09945139f, -0.03258049f, -0.00506553f, 0.08452728f, -0.05569084f, -0.13806129f, -0.09606713f, 0.01128443f, 
    -0.05986935f, -0.02970598f, -0.12481796f, -0.08204249f, 0.05547687f, 0.07005297f, -0.12172963f, -0.15683559f, 
    -0.02469330f, -0.02821759f, 0.08053780f, -0.00855953f, 0.02233972f, 0.12133920f, -0.05269327f, -0.02994749f, 
    0.08747916f, 0.05772566f, -0.09794118f, 0.02538671f, -0.05755771f, -0.09466471f, -0.12053506f, -0.09757492f, 
    0.04277917f, 0.08666741f, 0.04395930f, -0.07189471f, -0.08634081f, 0.05348448f, -0.07929753f, -0.11912479f, 
    -0.11564205f, 0.04075503f, -0.01139810f, -0.13109289f, 0.03135223f, -0.00984129f, -0.12442101f, -0.10510637f, 
    -0.13609956f, -0.12428686f, 0.02099310f, 0.01458582f, 0.02622554f, -0.05976142f, 0.09759378f, -0.03977960f, 
    -0.05718816f, -0.12020778f, -0.11986175f, -0.00501388f, -0.10587811f, -0.06276959f, -0.14350781f, -0.07856674f, 
    -0.00988492f, 0.10973297f, -0.04259681f, -0.03987497f, 0.04943310f, 0.01048692f, 0.00189686f, -0.01966105f, 
    -0.00577843f, 0.08365580f, -0.13890587f, -0.08778820f, -0.02209958f, -0.05959230f, 0.02330558f, -0.02565962f, 
    0.01884550f, 0.05023021f, 0.05689308f, -0.07367565f, 0.07056946f, -0.11620376f, -0.05541101f, -0.12912132f, 
    0.03914379f, 0.08342618f, 0.06970128f, 0.05701004f, -0.06699654f, 0.05212689f, 0.05019399f, -0.08611434f, 
    -0.09635403f, 0.02600542f, -0.06374286f, 0.02745404f, -0.04304352f, 0.10188225f, -0.05057049f, -0.05162817f, 
    -0.10195284f, -0.05503461f, -0.00758366f, 0.03989550f, -0.14584230f, 0.02851224f, -0.13528587f, 0.03194718f, 
    0.20097052f, 0.25558755f, -0.01708737f, 0.12860876f, 0.10774444f, -0.48389271f, -0.00384386f, 0.02902013f, 
    0.13890819f, -0.14151514f, 0.11855447f, -0.69206768f, 0.24473514f, 0.07313727f, -0.32962638f, 0.27584752f, 
    0.00480098f, 0.44780487f, 0.13465366f, -0.64457488f, -0.00038547f, 0.06497929f, -0.26289618f, 0.10226406f, 
    -0.58912671f, -0.04366152f, -0.05415949f, -0.08786958f, -0.00148812f, 0.09477004f, 0.01798120f, 0.02579099f, 
    -0.02057514f, -0.24018912f, 0.31379703f, 0.26775980f, -0.06141244f, -0.13220812f, 0.02677932f, 0.15112962f, 
    0.22121032f, 0.17174503f, -0.07421372f, 0.30481505f, 0.03305294f, -0.09076343f, 0.19070116f, -0.04908952f, 
    -0.12136020f, 0.06760085f, -0.02248958f, -0.28709367f, -0.05178274f, 0.14646599f, 0.20501523f, 0.39686719f, 
    -0.03894204f, -0.16465972f, 0.15803829f, 0.08462005f, 0.04308631f, 0.06253477f, 0.09218586f, 0.11493509f, 
    -0.03288305f, 0.29591456f, 0.33169067f, -0.16517340f, 0.01094312f, 0.40347177f, 0.28338900f, 0.12082955f, 
    0.13162799f, -0.00881593f, 0.10549472f, -0.08720919f, 0.38485786f, 0.06214330f, -0.24327745f, -0.10662717f, 
    0.25384909f, 0.67883891f, 0.04345724f, -0.22537220f, 0.10478035f, -0.46405590f, -0.26463026f, 0.02576521f, 
    -0.01201103f, 0.20328435f, -0.34747726f, -0.10295542f, -0.00540254f, 0.05715163f, 0.63112706f, 0.14040451f, 
    -0.03560241f, 0.16933210f, -0.27496818f, -0.24692714f, 0.44755188f, 0.29355648f, 0.18485212f, 0.04799370f, 
    0.00086734f, -0.10173843f, -0.23253837f, -0.26061660f, -0.04088543f, 0.02513117f, 0.19543380f, -0.36694035f, 
    0.12566048f, -0.03586606f, -0.02288402f, -0.08846190f, 0.17089306f, -0.31158039f, -0.17854024f, -0.22972423f, 
    -0.03061871f, 0.03504965f, 0.04456759f, 0.25240499f, 0.00275924f, 0.23204328f, -0.17497391f, -0.12134498f, 
    0.00684114f, -0.12956597f, -0.08930607f, -0.11978692f, 0.06256326f, 0.05254328f, 0.01148948f, 0.00447461f, 
    -0.03896201f, -0.01130408f, 0.10530271f, 0.05005057f, 0.01270722f, 0.05807009f, -0.07291313f, -0.09532139f, 
    -0.04782435f, 0.02619435f, -0.01637921f, 0.12360840f, 0.04643476f, -0.05173490f, -0.03882378f, 0.03212391f, 
    0.06757757f, -0.05033147f, -0.06162700f, -0.09424409f, 0.03889167f, -0.08905189f, -0.01354871f, 0.12147219f, 
    -0.06330162f, -0.08850376f, 0.09187692f, -0.01689436f, -0.08741537f, -0.04015300f, 0.10059680f, -0.07156211f, 
    -0.11810730f, 0.06355979f, -0.08471300f, 0.05201872f, -0.09113005f, -0.01878260f, 0.02800339f, -0.03297131f, 
    -0.08136306f, 0.10329852f, 0.04145718f, 0.08895142f, -0.10249222f, 0.01939175f, 0.11132427f, -0.01657245f, 
    -0.05749543f, 0.02246910f, -0.10846426f, -0.09021512f, -0.05451050f, -0.12047830f, 0.06860697f, -0.08462891f, 
    0.28178996f, -0.00032572f, 0.20322809f, -0.05763296f, 0.21258475f, -0.05344561f, 0.09677007f, -0.07926399f, 
    -0.00366723f, 0.10197812f, -0.03590579f, -0.43872538f, 0.21568465f, -0.08579452f, 0.18967023f, -0.14445183f, 
    0.23603772f, -0.85218257f, 0.04475582f, 0.62349969f, 0.18056180f, -0.17848089f, 0.13752291f, -0.00782253f, 
    0.22515585f, -0.01791707f, -0.13550833f, 0.00201762f, 0.06045178f, 0.25115323f, 0.26907134f, -0.02510479f, 
    0.03732464f, -0.10297959f, -0.12312004f, -0.47114605f, 0.31198817f, 0.31157050f, 0.01911711f, 0.01473150f, 
    0.08349858f, -0.13566732f, 0.06277685f, -0.32534856f, 0.54460526f, 0.11699466f, 0.02364983f, 0.17323016f, 
    0.05151857f, -0.08127460f, -0.36102355f, 0.19052303f, -0.18616170f, -0.03889494f, 0.06874235f, -0.31652930f, 
    0.21427479f, -0.25057289f, -0.18554999f, 0.35851896f, 0.16819963f, 0.20813772f, -0.06699957f, -0.08423106f, 
    -0.00568157f, -0.00153872f, 0.03780276f, -0.18589902f, 0.18732202f, -0.30018494f, -0.18964560f, 0.06974839f, 
    0.17771536f, -0.01072352f, -0.11269992f, 0.06681871f, -0.05294791f, -0.03115726f, 0.29827300f, 0.05319256f, 
    0.15200943f, -0.11836008f, 0.19918975f, -0.31889987f, 0.01553243f, 0.18117256f, 0.06813523f, 0.12106580f, 
    -0.36302364f, -0.10808329f, -0.15990016f, 0.19863704f, -0.08015735f, 0.06280133f, -0.16491646f, -0.31977639f, 
    -0.03966442f, 0.07493463f, 0.17808914f, 0.05314595f, 0.05421998f, -0.09095283f, -0.19602488f, 0.01273526f, 
    0.02678234f, 0.21358594f, -0.02144909f, -0.08313922f, 0.10684554f, 0.05901471f, 0.10496449f, -0.17333691f, 
    -0.40410131f, 0.41436073f, -0.14230047f, -0.34541294f, 0.04297570f, -0.10963200f, 0.02737628f, 0.17193781f, 
    0.14950822f, -0.18761928f, -0.33847094f, 0.17660180f, 0.07262296f, -0.15089716f, 0.14044140f, 0.06233293f, 
    0.11207726f, 0.28718233f, 0.26896197f, -0.54607230f, 0.16948338f, 0.56874585f, 0.13885969f, 0.00946929f, 
    0.15455906f, 0.05474191f, 0.02873637f, -0.36115348f, -0.02727582f, 0.09129275f, 0.18987902f, -0.32857355f, 
    0.13774450f, 0.40222162f, 0.12713341f, -0.06936119f, 0.10125407f, -0.32093927f, 0.22088234f, 0.05491794f, 
    -0.30776912f, -0.10132132f, -0.28302130f, 0.14030620f, -0.01323010f, -0.00823593f, 0.19992957f, -0.01288638f, 
    -0.17061463f, 0.59029287f, -0.09925468f, -0.04258924f, 0.44777524f, 0.25818139f, 0.17065328f, -0.00283848f, 
    0.07244179f, -0.00719766f, -0.24166131f, -0.20514685f, -0.00883352f, 0.03394767f, 0.37382552f, -0.23011032f, 
    -0.20181105f, 0.16106676f, -0.33624223f, -0.36803904f, 0.20977697f, -0.37519425f, -0.10298393f, -0.11804384f, 
    0.13471290f, -0.40761769f, -0.00858605f, 0.22339422f, 0.14885256f, 0.12415740f, -0.03666338f, -0.11674285f, 
    -0.16326694f, 0.04048209f, 0.04978419f, -0.00956536f, -0.02017001f, 0.00629024f, 0.02244325f, -0.00441872f, 
    -0.17312081f, 0.03954935f, 0.03840884f, -0.00798928f, -0.10145833f, 0.01923129f, 0.08225405f, -0.06431235f, 
    0.02853419f, -0.06034241f, -0.00799675f, 0.10778070f, 0.06792238f, 0.00934983f, 0.08724999f, -0.09328788f, 
    -0.02573213f, 0.07433300f, 0.06306849f, 0.00921545f, -0.03570926f, 0.02390184f, -0.09223007f, -0.13257614f, 
    -0.08950870f, -0.10738043f, -0.09563725f, 0.10113952f, -0.16892390f, -0.01097287f, 0.00597202f, -0.03120125f, 
    -0.13112405f, -0.06788520f, 0.07082416f, 0.12500422f, 0.04953283f, -0.04670957f, -0.05708068f, -0.07169601f, 
    0.01471293f, -0.06510112f, -0.11545541f, -0.04974850f, -0.04315978f, -0.08884671f, 0.09088598f, 0.05010091f, 
    0.02228714f, -0.06191955f, -0.01417629f, -0.01885180f, -0.04451619f, -0.13994615f, -0.12504488f, -0.10734493f, 
    0.12592532f, 0.22863056f, -0.03993705f, -0.14241998f, -0.10718646f, 0.12175093f, -0.15934871f, 0.03987405f, 
    0.38468993f, -0.05181159f, 0.11544526f, 0.61508954f, -0.20399629f, -0.05184937f, 0.26689494f, -0.17122076f, 
    0.24779530f, -0.27791807f, 0.11618172f, 0.21898600f, -0.06766379f, 0.07601642f, 0.45377055f, 0.09205546f, 
    0.02974416f, -0.25098607f, -0.07592567f, 0.28438991f, -0.04918432f, 0.02428470f, -0.38364249f, -0.20705891f, 
    0.07071792f, 0.32929990f, 0.00788575f, 0.13064694f, 0.04021295f, -0.02835098f, -0.04376380f, 0.04574637f, 
    0.37212417f, 0.27791780f, 0.07334401f, 0.35687694f, -0.09543413f, 0.19740859f, 0.12771606f, 0.10945611f, 
    -0.43012989f, 0.51618350f, 0.10716806f, -0.13266830f, 0.07551087f, -0.16070443f, 0.06862877f, 0.36254376f, 
    0.15494317f, 0.08813588f, -0.23275924f, 0.17017767f, -0.00187937f, 0.02904109f, -0.07720072f, -0.16873787f, 
    -0.11649043f, 0.18277650f, 0.28101501f, -0.36240101f, -0.20429896f, 0.44962886f, 0.04763287f, 0.06377359f, 
    0.06570796f, 0.11869781f, -0.02639405f, -0.36553371f, 0.09249338f, -0.00237317f, 0.04875335f, -0.25502545f, 
    0.24636135f, 0.78846538f, 0.36698937f, -0.51482308f, -0.10014877f, -0.18119358f, -0.30966976f, -0.09359086f, 
    -0.25236252f, 0.04282928f, -0.14417937f, 0.33069336f, -0.04400962f, -0.06553072f, 0.56712031f, 0.12419738f, 
    -0.10028780f, 0.14788312f, -0.45259756f, -0.10515368f, 0.08629002f, 0.18893990f, 0.07911114f, 0.04381251f, 
    -0.03097669f, 0.20365806f, -0.14515606f, -0.13390496f, -0.03801205f, 0.09457412f, 0.09624749f, -0.50691736f, 
    -0.22903955f, -0.07450245f, -0.22113222f, -0.49161762f, 0.20963770f, -0.45468801f, -0.15160131f, 0.19126870f, 
    0.12632859f, -0.01678954f, -0.05258445f, 0.19369015f, 0.20496267f, -0.19173875f, -0.17840722f, -0.02203374f, 
    0.04806364f, -0.13322629f, 0.26341218f, 0.55163556f, 0.09200870f, 0.28839320f, -0.02826516f, -0.08210951f, 
    0.01611390f, -0.17006566f, 0.11666861f, -0.39012867f, -0.11012145f, 0.00074959f, -0.04151802f, -0.02801025f, 
    -0.07893076f, -0.23144044f, 0.08163559f, 0.00654410f, -0.36769992f, 0.20370071f, -0.02590252f, -0.19819385f, 
    0.22408496f, 0.23685905f, 0.26377398f, -0.00490658f, 0.00174348f, 0.18488169f, 0.43077365f, 0.23813848f, 
    0.18627156f, -0.14244771f, -0.13906784f, -0.12296062f, 0.03691287f, 0.10109039f, 0.05368334f, -0.03332832f, 
    0.12422794f, -0.19022450f, 0.02726535f, -0.09516743f, 0.25182059f, -0.18751177f, -0.26130676f, 0.23359942f, 
    0.00095119f, -0.18245237f, -0.07026077f, 0.23686785f, 0.23806517f, 0.18970625f, 0.24791348f, -0.22528595f, 
    0.24147679f, -0.41256750f, -0.02791617f, 0.10740213f, -0.13802709f, 0.19003549f, -0.19467488f, -0.06306353f, 
    -0.13356249f, 0.21424815f, 0.01913784f, 0.14248292f, -0.40719852f, 0.15612531f, 0.20830446f, -0.10320193f, 
    0.00010679f, -0.57251424f, -0.05005527f, 0.26505306f, 0.36298013f, 0.06081013f, -0.35682723f, -0.02355794f, 
    0.02598214f, -0.71641541f, 0.20050667f, -0.03376121f, -0.20035522f, -0.20457798f, 0.13559780f, 0.09291068f, 
    0.05317322f, -0.26952136f, -0.10250783f, -0.16978280f, -0.09952335f, 0.36480287f, 0.34124365f, 0.04559373f, 
    -0.14699252f, -0.14773326f, 0.30102682f, -0.05708624f, 0.06887887f, 0.11489122f, -0.19640994f, -0.13739464f, 
    0.19922432f, -0.10099322f, -0.50787979f, 0.39820787f, -0.06338463f, 0.04334021f, 0.23275031f, 0.09266713f, 
    0.14251445f, -0.03986983f, 0.18684001f, -0.05574993f, -0.24870786f, 0.32366279f, -0.17452765f, 0.24113300f, 
    -0.25181362f, -0.32580033f, 0.24259497f, -0.07765515f, -0.00545131f, 0.18514650f, 0.02779362f, -0.11964412f, 
    -0.08482026f, -0.01435340f, -0.02343781f, -0.06989399f, 0.02022797f, 0.10795829f, -0.03342913f, 0.09523690f, 
    0.19235756f, 0.05347137f, -0.08775634f, -0.18607958f, -0.14090829f, 0.06753258f, 0.16176924f, -0.26811478f, 
    0.24964397f, -0.38283461f, 0.03164618f, 0.38502327f, 0.21603093f, -0.21335000f, 0.55939186f, -0.03933183f, 
    0.14630540f, -0.26577941f, -0.22397445f, 0.14553483f, -0.09837456f, 0.06784759f, -0.20817366f, -0.33855131f, 
    -0.04639851f, 0.42742196f, -0.00022503f, -0.15118846f, 0.80570066f, 0.09648220f, 0.08785495f, -0.00609778f, 
    0.03016817f, -0.02002393f, -0.15419635f, -0.12193675f, 0.40808049f, 0.15555678f, 0.21470596f, -0.18024755f, 
    -0.23970720f, 0.13634782f, -0.50984532f, -0.17815322f, -0.03900661f, 0.00753802f, 0.09196505f, -0.22431856f, 
    0.16146454f, -0.61939019f, -0.12963922f, 0.34711564f, -0.07891165f, 0.30322418f, -0.18989176f, -0.04975614f, 
    -0.08382498f, -0.00932679f, -0.08613236f, 0.02937126f, 0.06153081f, 0.01186579f, -0.14852059f, 0.03017557f, 
    -0.10674001f, -0.01471997f, 0.02831165f, 0.03845397f, -0.01357696f, 0.11864835f, -0.14362359f, 0.01542751f, 
    -0.07076655f, 0.06575948f, -0.00467585f, 0.07242680f, -0.04834578f, 0.04489019f, 0.05158369f, -0.08079857f, 
    -0.14012973f, -0.02664449f, 0.10480788f, -0.04299997f, -0.11670911f, 0.04524672f, -0.01865926f, 0.02433340f, 
    -0.08109989f, -0.00716947f, -0.14585300f, -0.05691183f, -0.13814285f, -0.13674563f, 0.03307727f, -0.13096346f, 
    0.02040691f, 0.07144783f, 0.00315463f, -0.01861989f, 0.03730444f, -0.01064467f, 0.09205534f, 0.08332150f, 
    0.00086601f, 0.00931128f, -0.08441287f, -0.13273954f, -0.01912106f, -0.10973436f, -0.11072615f, 0.00871467f, 
    -0.10867175f, -0.05485101f, -0.11914743f, 0.05356317f, -0.15097009f, 0.08469062f, -0.12400229f, -0.05774011f, 
    0.21453534f, 0.42458743f, -0.09673266f, 0.04545637f, -0.12026395f, -0.39930975f, 0.07522253f, 0.09428531f, 
    0.23034306f, -0.03600315f, -0.08335270f, -0.13393511f, 0.07021096f, -0.01044013f, -0.14321356f, 0.13004290f, 
    0.02958888f, 0.44755748f, 0.13787168f, -0.56171477f, -0.07087249f, 0.01673741f, -0.32656232f, 0.28011885f, 
    -0.57528281f, 0.00470182f, -0.06042033f, 0.06746725f, -0.08676621f, 0.08392132f, -0.07861760f, -0.04494347f, 
    0.11721698f, 0.09202240f, 0.16281419f, 0.37362620f, 0.07444208f, 0.05063483f, -0.24596903f, 0.04653760f, 
    0.12409265f, 0.11546268f, -0.26979613f, 0.40946010f, -0.20907407f, 0.15583156f, 0.32051021f, -0.15028657f, 
    -0.10509067f, 0.05740487f, 0.22159186f, -0.08621862f, 0.11173564f, 0.05084629f, 0.17670482f, 0.59522247f, 
    -0.15051639f, -0.04720071f, 0.31214902f, 0.00295991f, 0.21893029f, -0.08320913f, 0.02268911f, 0.06903668f, 
    -0.08143391f, -0.05809788f, 0.07371520f, 0.02292774f, 0.05463177f, -0.11165573f, -0.11812674f, -0.05909316f, 
    -0.11284663f, -0.04638492f, -0.07021901f, 0.00750641f, -0.14621633f, 0.00203954f, -0.02227194f, 0.08522360f, 
    0.06092612f, -0.09493649f, 0.04770084f, 0.09581400f, -0.11141281f, -0.13744549f, 0.07736841f, -0.04191511f, 
    -0.06107840f, 0.03144902f, -0.08906718f, 0.05853933f, -0.02456847f, -0.04618442f, -0.08758677f, -0.01096352f, 
    -0.07791905f, 0.01534353f, 0.06728502f, 0.03479049f, -0.13491572f, 0.11320691f, -0.10591391f, -0.12377524f, 
    -0.09347217f, -0.07181969f, -0.00661227f, -0.10101515f, -0.07033566f, -0.06228116f, -0.11954074f, 0.01494585f, 
    -0.01959937f, 0.09125049f, 0.07167950f, 0.05588592f, 0.06478965f, -0.06759726f, -0.08299568f, -0.10994218f, 
    -0.12759654f, -0.02086937f, -0.14396912f, -0.08812612f, -0.00520071f, -0.10440372f, 0.05014882f, 0.06757730f, 
    0.06353670f, -0.02669271f, 0.17307132f, -0.04010293f, -0.21665734f, 0.06714528f, -0.31324223f, 0.11255211f, 
    -0.10623886f, -0.34664616f, -0.01015773f, 0.16212285f, -0.06130709f, 0.03985785f, 0.03717712f, 0.36651942f, 
    0.22784780f, -0.00315141f, 0.33572459f, 0.09608170f, -0.34749269f, 0.12062292f, -0.26218146f, 0.03265098f, 
    -0.09394602f, 0.04617301f, 0.05500889f, 0.08006024f, 0.02149068f, 0.43909761f, 0.47111022f, 0.12422686f, 
    0.38120595f, -0.22279349f, 0.42444885f, 0.07583141f, 0.15773621f, -0.10069337f, -0.35138556f, -0.16498254f, 
    0.11699896f, -0.00072854f, -0.07325391f, 0.11019636f, -0.53057933f, -0.36986673f, -0.13504785f, 0.16009668f, 
    0.16663386f, -0.13380280f, 0.32609954f, -0.14428622f, 0.01304800f, 0.50227571f, 0.21679325f, 0.14746931f, 
    0.24529883f, 0.13197383f, 0.11778183f, -0.09474535f, -0.04111435f, 0.17059270f, 0.05307240f, -0.09159633f, 
    0.33784452f, 0.29199106f, -0.05528085f, -0.08731253f, 0.12851968f, -0.25995111f, -0.14839821f, 0.05492026f, 
    0.08820154f, 0.11290240f, -0.08067527f, -0.09117710f, -0.17835729f, -0.04176483f, -0.10134895f, 0.21668249f, 
    -0.18998593f, 0.69089079f, 0.10035408f, 0.29093283f, -0.00319629f, 0.14848694f, 0.13864011f, 0.28512609f, 
    0.08619585f, 0.30613887f, 0.03288406f, 0.12596239f, 0.09436214f, -0.17709327f, -0.19493043f, 0.10153105f, 
    0.30099675f, 0.15290311f, 0.33368737f, 0.66503716f, 0.08222842f, 0.18106566f, -0.11622879f, 0.26183236f, 
    0.03838922f, 0.16877994f, 0.02172856f, 0.46664494f, 0.10004891f, -0.13973609f, 0.09625231f, -0.09001131f, 
    -0.08337759f, 0.39046282f, -0.23128437f, -0.07848065f, -0.10258204f, 0.19639455f, 0.13160270f, 0.33505556f, 
    -0.07742208f, 0.02280005f, 0.01905339f, -0.14945310f, 0.32974806f, -0.07123845f, 0.17552730f, 0.07093327f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.30866849f, -0.02645821f, 0.13481037f, 0.09071659f, -0.05132291f, 0.22696479f, 0.07619692f, -0.17441785f, 
    -0.04234925f, -0.01408399f, -0.13854371f, -0.08306810f, 0.05591954f, -0.07179905f, 0.12329444f, 0.04481203f, 
    0.18541767f, 0.30220017f, 0.19658932f, -0.00090105f, 0.11319274f, 0.04056369f, -0.17971978f, 0.01685895f, 
    0.04126175f, 0.10873082f, 0.09934325f, -0.11034635f, 0.05048395f, 0.13288820f, 0.05730212f, 0.16140388f, 
    0.00885918f, 0.05014376f, 0.30723068f, 0.03249303f, 0.29632843f, -0.05972487f, -0.03148102f, 0.18638033f, 
    0.19515792f, 0.21043386f, -0.11907173f, 0.02606792f, 0.02711369f, 0.06913667f, -0.08195078f, 0.34450141f, 
    0.05566743f, -0.05055503f, 0.08421592f, 0.31252542f, 0.01529021f, -0.00137907f, 0.06875489f, 0.11256402f, 
    -0.04043478f, -0.04149674f, 0.01497766f, 0.01764652f, 0.34145579f, -0.06103415f, 0.16832498f, 0.13440576f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.02365157f, -0.13564068f, 0.12651800f, 0.24514076f, 0.00029448f, -0.14259999f, -0.25580692f, -0.10573826f, 
    0.15308762f, 0.12859592f, -0.03235590f, -0.27741167f, -0.57975918f, -0.01869642f, 0.10964994f, -0.40160191f, 
    0.02549719f, -0.56899619f, -0.38785097f, -0.05105203f, 0.15679865f, 0.18358961f, 0.33115152f, -0.08205853f, 
    0.20400187f, -0.31709912f, 0.01071433f, 0.08027107f, 0.18770862f, -0.03624780f, 0.18041633f, -0.10088983f, 
    0.06579480f, 0.00639187f, 0.12191576f, -0.01165305f, -0.76811743f, -0.04800525f, 0.13603079f, -0.16199210f, 
    -0.33406714f, -0.07382502f, -0.13906622f, -0.21804732f, 0.23914261f, 0.00469009f, 0.04658815f, -0.05809518f, 
    -0.04398122f, -0.06745069f, -0.05712990f, -0.39783254f, -0.18744864f, -0.03008377f, -0.02891832f, -0.24768054f, 
    0.17400293f, 0.30330449f, -0.20137161f, 0.06393505f, -0.18238559f, 0.02826517f, -0.00137879f, -0.78027463f, 
    -0.05776439f, 0.19373816f, -0.23255153f, 0.35122484f, -0.06443772f, 0.09505621f, -0.09877207f, -0.19989333f, 
    -0.02090004f, -0.20521192f, -0.10917234f, 0.22150724f, -0.34684852f, 0.50920838f, -0.19774207f, -0.07702089f, 
    0.20346268f, 0.03130567f, -0.38537386f, 0.03682587f, -0.01616711f, 0.22459301f, -0.00796141f, -0.02716452f, 
    -0.86291558f, 0.27887049f, -0.22572231f, -0.04884397f, 0.08992274f, -0.01906746f, -0.24472567f, 0.11271032f, 
    -0.16678728f, 0.03171295f, 0.13417220f, 0.20771503f, -0.00997684f, 0.10090022f, 0.13411008f, 0.54547209f, 
    0.18365832f, 0.10486586f, -0.01787649f, -0.09619316f, 0.07508133f, -0.02387553f, 0.03232841f, 0.08480696f, 
    0.33518153f, -0.12452287f, -0.12355524f, -0.09333553f, 0.20323275f, -0.10082089f, -0.48400506f, 0.39349648f, 
    0.08263791f, -0.14958899f, -0.28626505f, -0.09886955f, 0.08631906f, 0.08707846f, 0.12642324f, -0.02097781f, 
    0.07251146f, -0.52835995f, -0.39828995f, -0.75282937f, 0.04635783f, 0.23182271f, -0.06596640f, -0.75892419f, 
    -0.37373456f, -0.21462013f, -0.08121804f, -0.31279892f, 0.22469786f, -0.74106032f, 0.15956835f, 0.04405031f, 
    -0.14398095f, 0.15799433f, 0.05137253f, -0.05304311f, -0.59621322f, 0.23213010f, 0.15139192f, -0.45914862f, 
    0.05409756f, 0.27528867f, 0.10048162f, -0.09729074f, 0.26704895f, -0.24123369f, 0.28497121f, 0.22059505f, 
    -0.20371839f, -0.04125225f, 0.17794827f, -0.17179292f, 0.24248108f, 0.01422023f, -0.71775681f, 0.06664000f, 
    -0.00001515f, -0.02625467f, 0.01730262f, 0.11923667f, -0.20922813f, -0.03020459f, -0.07191368f, 0.11809158f, 
    0.08088221f, -0.06807537f, -0.50268251f, 0.13435000f, -0.75900060f, 0.05852935f, 0.25099790f, -0.46876249f, 
    -0.63682705f, -0.52382767f, -0.65792227f, -0.00545945f, 0.04195921f, -0.06503902f, 0.03448477f, 0.02894597f, 
    -0.19704156f, -0.65881252f, 0.23430324f, 0.10317712f, -0.08621271f, 0.07287042f, 0.01562263f, -0.00696354f, 
    -0.21622263f, -0.01209101f, -0.08478238f, -0.64219242f, 0.12964483f, -0.18894383f, 0.14205581f, -0.10173462f, 
    -0.14476264f, 0.11655500f, -0.07337827f, 0.07092206f, 0.14444937f, 0.09371945f, 0.15175459f, 0.06570942f, 
    0.27509642f, 0.12011107f, 0.14575629f, 0.06133906f, -0.60977042f, -0.09268975f, 0.14396727f, -0.06521148f, 
    0.38231906f, -0.07686355f, 0.07209463f, -0.43326417f, -0.04496215f, -0.13982737f, 0.08279370f, 0.00066439f, 
    0.02296578f, -0.17863980f, -0.01733010f, 0.01920010f, -0.18362431f, 0.04513754f, 0.08080740f, -0.32637006f, 
    -0.77618605f, 0.09463270f, -0.00795864f, -0.07939192f, -0.14564894f, -0.15136500f, 0.16520493f, -0.27161297f, 
    -0.20365185f, 0.16223174f, 0.09039737f, -0.10482876f, -0.05368308f, 0.05501476f, 0.06675175f, -0.01950804f, 
    -0.65706110f, 0.15596415f, -0.13229260f, -0.01788963f, -0.05616586f, -0.13261063f, 0.02858012f, 0.24164666f, 
    0.02996595f, 0.17303576f, 0.09488797f, 0.01409673f, 0.02492846f, -0.25736302f, 0.17918418f, 0.10177021f, 
    -0.08483513f, -0.35909310f, -0.04099650f, -0.03781704f, -0.02609528f, 0.03982376f, -0.04799242f, 0.10984142f, 
    0.18628486f, -0.34656072f, 0.00266676f, -0.06611361f, -0.14855821f, 0.12997726f, 0.05355823f, 0.19698770f, 
    -0.09540034f, 0.20537502f, -0.03482964f, -0.08376244f, -0.07881181f, -0.08986223f, 0.04644570f, -0.44242597f, 
    0.02522612f, 0.06398816f, -0.04705695f, -0.46512416f, 0.12398981f, -0.11504057f, -0.03567166f, -0.65611660f, 
    -0.10012566f, -0.12271971f, 0.22364090f, -0.41163078f, -0.43442577f, -0.08771968f, -0.15508115f, -0.36006570f, 
    0.17384207f, -0.18086334f, 0.09300730f, -0.10806011f, -0.80840588f, -0.12239448f, -0.01941851f, 0.00055648f, 
    -0.03153807f, -0.07340250f, -0.04643292f, -0.14357731f, -0.03125026f, 0.02468204f, 0.12289930f, -0.08183558f, 
    0.05050555f, 0.26570866f, -0.11922780f, -0.02238383f, -0.11029051f, -0.24510467f, 0.06932418f, -0.06229585f, 
    0.23139057f, 0.06022957f, 0.05035647f, -0.05617994f, -0.09800721f, 0.00064595f, -0.13171215f, 0.04589574f, 
    -0.22502285f, 0.01669805f, -0.44255528f, 0.02951661f, -0.25965551f, -0.03590174f, -0.19113645f, 0.07551389f, 
    -0.34928611f, 0.16778445f, 0.08342721f, -0.00071520f, -0.06669664f, -0.13343953f, 0.14160702f, 0.10912581f, 
    -0.27774647f, 0.25224021f, -0.00101615f, 0.01500991f, 0.20874007f, -0.05947087f, -0.09395093f, -0.07932275f, 
    -0.15889262f, 0.03749451f, 0.08656851f, 0.05715991f, -0.01921955f, -0.11307190f, -0.02852540f, 0.08816621f, 
    0.15558757f, -0.72966099f, -0.27726969f, 0.11449984f, -0.01888292f, 0.09036359f, 0.06320966f, -0.03039706f, 
    0.10547756f, 0.06391036f, -0.36820623f, -0.31529349f, 0.06574585f, 0.00347978f, 0.04094973f, -0.35906366f, 
    -0.40366626f, -0.25728157f, 0.06232067f, -0.17445306f, 0.35141489f, -0.06145614f, -0.52329487f, 0.09417684f, 
    -0.09003148f, 0.32859036f, 0.33215854f, 0.06943277f, -0.96190941f, -0.80632520f, -0.36303031f, -0.69578648f, 
    0.10048293f, -0.41136622f, -0.15150476f, 0.05722481f, 0.30191290f, -0.60744798f, 0.00545394f, -0.59236628f, 
    0.08117686f, -0.87905955f, -0.55904979f, 0.12762809f, 0.25960335f, 0.01845650f, -0.41772214f, -0.39944130f, 
    -0.09425482f, -0.81415617f, -0.06727070f, 0.11091343f, -0.17363626f, -0.08153807f, -0.01880383f, 0.12193413f, 
    -0.51387256f, -0.06120811f, -0.44966990f, 0.15136117f, -0.17156084f, 0.00413819f, 0.20758837f, 0.03395359f, 
    -0.59447783f, -0.28599930f, -0.07447711f, -0.08908857f, 0.20162183f, 0.01352351f, -0.96362090f, 0.29265171f, 
    0.15264654f, 0.02942449f, 0.55841702f, 0.33418131f, -0.07950435f, -0.99952942f, -0.06163712f, 0.05695418f, 
    0.21063820f, -0.02510195f, -0.04250653f, 0.47897831f, -0.32731897f, -0.08057701f, -0.79609913f, -0.21836773f, 
    0.13843808f, -0.30236101f, -0.07520905f, -0.01160908f, -0.09757890f, -0.39968675f, 0.29319099f, 0.09762599f, 
    0.04193523f, -0.08988839f, -0.06002355f, -0.11863806f, -0.11090259f, 0.03894202f, -0.16398415f, -0.32335958f, 
    -0.19494806f, -0.25242618f, -0.55363119f, -0.12093467f, -0.44542539f, -0.11948672f, 0.12125829f, -0.08767315f, 
    -0.32215157f, -0.73871356f, -0.00060419f, -0.53863627f, 0.17775698f, 0.01462036f, 0.01799631f, -0.12117695f, 
    0.17903028f, 0.06914601f, 0.25070116f, 0.03923634f, -0.02546645f, 0.04339671f, 0.13854818f, 0.14158644f, 
    -0.59798944f, 0.19288634f, 0.22808504f, -0.07439480f, -0.09925790f, 0.04737987f, -0.46545732f, -0.21445407f, 
    0.19554168f, -0.14406347f, -0.09163076f, 0.08060724f, 0.01121894f, -0.13805962f, 0.24732007f, 0.20318118f, 
    0.05777687f, -0.51664823f, 0.06030495f, 0.18468396f, -0.20472182f, -0.12428813f, 0.03835427f, -0.19871743f, 
    -0.46098086f, 0.10781288f, -0.15648822f, -0.04180026f, 0.33673444f, -0.40797585f, -0.22300768f, -0.19370449f, 
    -0.50740284f, 0.38992661f, 0.40085647f, -0.10949769f, -0.28716588f, -0.12878852f, -0.19454800f, -0.41079587f, 
    -0.19787228f, -0.45624158f, 0.24117403f, 0.42041364f, 0.05688635f, -0.07888920f, -0.46422416f, -0.38598844f, 
    0.15869094f, -0.40116471f, 0.06869975f, 0.29475993f, -0.22205290f, 0.00473833f, -0.00693983f, 0.18703987f, 
    -0.08612397f, 0.01416674f, 0.09130126f, -0.21222033f, -0.26547155f, 0.03703508f, -0.60469681f, -0.15435232f, 
    0.15943061f, 0.57197833f, -0.43183076f, -0.11555985f, 0.11276273f, 0.01027735f, 0.32312468f, 0.09035542f, 
    -0.03656917f, -0.12270189f, 0.14026906f, -0.75976717f, 0.05448303f, 0.04612989f, -0.18297325f, -0.28068262f, 
    -0.65994191f, -0.01581652f, -0.10454362f, 0.12038881f, 0.31261423f, -0.18764661f, -0.24269120f, 0.18818700f, 
    0.17597675f, 0.01211515f, 0.20494920f, -0.01669896f, 0.15683264f, -0.07735126f, -0.89928317f, -0.14829808f, 
    0.39997286f, -0.59613228f, 0.29039219f, 0.01015712f, -0.25432372f, -0.14754605f, -0.12754026f, -0.16200496f, 
    -0.18238090f, 0.31011489f, 0.15573914f, -0.23538446f, 0.04742210f, -0.03602316f, -0.39552081f, -0.30867329f, 
    0.14457580f, -0.15657887f, 0.06038704f, 0.00548819f, 0.05010799f, 0.06827988f, -0.01153376f, 0.14163212f, 
    -0.29384553f, 0.10104972f, 0.16653994f, 0.23784943f, -0.15362564f, -0.04147455f, 0.12408943f, -0.23904878f, 
    -0.14007734f, -0.12535657f, 0.29876217f, 0.04041040f, -0.04204199f, 0.05089793f, -0.22761901f, 0.02913086f, 
    0.15267809f, -0.16529395f, -0.51235670f, 0.02534320f, -0.02691539f, 0.15611671f, -0.44962856f, 0.31785858f, 
    0.13577257f, -0.49120399f, 0.01083985f, 0.35723636f, 0.16192435f, 0.00390541f, 0.14271347f, 0.28316516f, 
    -0.61303341f, -0.15029964f, -0.13487519f, 0.01326332f, -0.54805946f, -0.13828434f, -0.07492756f, 0.25522530f, 
    -0.44591036f, 0.12158626f, -0.54543144f, -0.09162460f, 0.20745501f, 0.23409496f, -0.73603642f, 0.15195917f, 
    -0.14548837f, -0.69385207f, -0.53521848f, -0.27958044f, 0.20816104f, -0.03658770f, 0.38518730f, -0.04867279f, 
    -0.83288795f, 0.16681084f, -0.07797343f, 0.25756302f, -0.36451244f, -0.11834563f, -0.10604501f, -0.13203827f, 
    -0.86373144f, -0.01474702f, -0.54882747f, -0.05953170f, -0.19485356f, -0.09967215f, -0.26831692f, -0.48388243f, 
    -0.16013715f, 0.00571786f, -0.21639122f, -0.12470519f, 0.04575027f, -0.09060667f, 0.09417065f, 0.08620269f, 
    0.24534129f, 0.05832227f, 0.08067670f, -0.02347100f, -0.01659506f, -0.07984626f, 0.19928560f, 0.14014281f, 
    0.01852115f, -0.06956390f, 0.09710883f, -0.44856390f, -0.02617758f, 0.00198566f, 0.11757417f, 0.45186269f, 
    -0.48036334f, 0.02445255f, -0.05556729f, -0.05903437f, -0.19237433f, -0.44631436f, -0.34392434f, 0.09613463f, 
    -0.36454862f, -0.37882563f, 0.14046426f, 0.07968938f, 0.22180027f, -0.24117213f, 0.34659472f, -0.15051202f, 
    0.35869166f, -0.40525952f, -0.42125949f, -0.26993227f, 0.17530282f, -0.08253587f, -0.51533747f, -0.20433810f, 
    -0.05481493f, -0.14580399f, -0.16051231f, -0.12494048f, -0.51471764f, 0.07765751f, 0.05721065f, 0.11879126f, 
    0.13701726f, 0.05301892f, 0.04581467f, -0.06899350f, 0.24348672f, -0.06877626f, -0.09584712f, -0.05944037f, 
    -0.33800507f, -0.09125908f, 0.16818598f, 0.03941038f, 0.12187175f, -0.13099603f, -0.31149232f, 0.02658516f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17196484f, 0.02441059f, 0.13039295f, 0.08436485f, -0.01631744f, 0.07108851f, -0.04378429f, 0.08128621f, 
    0.06229186f, 0.18811812f, 0.04931139f, 0.11766884f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
