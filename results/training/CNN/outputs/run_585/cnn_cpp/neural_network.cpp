#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.31497344f, -0.78106236f, 0.10785758f, 0.57318413f, -0.83866405f, 0.35327685f, 0.12535499f, 0.27762291f, 
    -0.39006165f, -0.31233987f, 1.00359333f, -0.81794345f, 0.76035988f, 0.21321556f, -0.29109076f, -0.05457258f, 
    0.45208564f, -0.04212430f, 0.72095633f, 0.64250809f, 0.10650567f, -0.35422775f, -0.10600644f, 0.34867296f, 
    0.11152145f, -0.37699372f, -0.42851418f, -0.46109420f, -0.68107301f, -0.54747975f, 0.46331975f, 0.29279256f, 
    0.30883372f, -0.49898854f, -0.10768627f, -0.41142589f, -0.42358562f, 0.15058626f, -0.03532843f, -0.50352734f, 
    0.69271624f, 0.10277876f, -0.20270008f, -0.13114463f, -0.52487302f, 0.05484292f, -0.51125938f, -0.73779923f, 
    -0.15065892f, -0.14440723f, 0.84620643f, 0.19853520f, -0.00818629f, 0.20811866f, -0.56759524f, -0.47614223f, 
    -0.00414025f, -0.32166806f, -0.32813832f, -0.67156225f, 0.38203815f, 0.42397198f, 0.40360820f, -0.62028122f, 
    -0.45546418f, -0.33977729f, 0.38963526f, 0.69054759f, 0.16619676f, -0.08452527f, -0.23247619f, 0.10304523f, 
    -0.18553936f, -0.35697529f, -0.16004036f, -0.74907380f, 0.07023988f, 0.68825924f, 0.31717238f, -0.11964367f, 
    0.20987931f, 0.29357922f, 0.48241198f, -0.34623674f, -0.80771756f, -0.23369521f, -0.64217150f, 0.38812882f, 
    0.52749467f, -0.02805965f, -0.73906887f, 0.40487838f, -0.50188136f, -0.26913911f, 0.35288918f, -0.61921597f, 
    0.20567572f, -0.51539022f, 0.16852231f, 0.24351192f, -0.03075514f, 0.25509745f, -1.03596997f, 0.30039951f, 
    -0.39285094f, -0.04448249f, 0.07611582f, -0.15161251f, 0.71391171f, 0.34244692f, 0.54382473f, 0.20845510f, 
    0.26020974f, 0.01224911f, 0.11341596f, 0.58949238f, 0.03678479f, 0.06048264f, 0.64435667f, -0.79162526f, 
    -0.46634340f, 0.46473202f, 0.58106095f, 0.12407481f, 0.13412416f, -0.51951981f, 0.04057221f, -0.89444458f, 
    -0.68940938f, 0.42080310f, -0.09507614f, -0.19491747f, 0.24856605f, -0.34319454f, -0.00526180f, -0.64652002f, 
    -0.59723276f, -0.56503832f, -0.62657952f, 0.32987022f, 0.35572216f, -0.14385654f, 0.22556715f, -0.14467514f, 
    0.80278796f, 0.66965330f, 0.70377725f, -0.00339399f, -0.75802553f, -0.02301717f, -0.00382514f, 0.23677666f, 
    0.11786461f, -0.59419245f, -0.09040868f, -0.22373725f, -0.20394821f, 0.77127546f, 0.71871555f, 0.02876344f, 
    -0.18816654f, 0.28503674f, -0.93121016f, -0.66045743f, -0.63753378f, 0.25508088f, -0.20972967f, -0.26030481f, 
    0.26190186f, 0.21623479f, 0.08754640f, -0.39444703f, 0.31948689f, 0.42894870f, 0.38412642f, 0.65447420f, 
    -0.62137359f, 0.64959180f, 0.40397787f, 0.29379514f, 0.18176013f, 0.48362672f, 0.78180999f, 0.48639965f, 
    -0.17690127f, 0.67714220f, 0.16058862f, -0.23968683f, -0.17684440f, 0.21214852f, -0.48088408f, -0.28899145f, 
    0.42344934f, 0.35390034f, -0.08931186f, -0.45250976f, 0.30402237f, 0.51986587f, -0.11186341f, 0.70012569f, 
    0.86347187f, -0.68221927f, 0.09936864f, -0.24208152f, -0.16244216f, 0.11907942f, 0.05158321f, 0.60695338f, 
    0.19732179f, 0.57183933f, 0.79509199f, 0.35044914f, 0.20295422f, 0.22015615f, 0.36605462f, 0.29736942f, 
    -0.30440468f, -0.77943665f, -0.30902722f, -0.66376871f, 0.37465906f, -0.64878923f, -0.03099068f, -0.09983605f, 
    -0.18401596f, -0.68580240f, -0.22009002f, 0.58467007f, 0.63144338f, 0.58893454f, 0.30279699f, 0.17651221f, 
    -0.08340876f, 0.38179690f, 0.73392075f, 0.34767485f, 0.59109640f, -0.00896263f, 0.35534623f, 0.22313721f, 
    -0.13427649f, -0.12016884f, 0.39914596f, -0.67808110f, 0.51633495f, 0.11443609f, 0.14703993f, -0.50274843f, 
    -0.46744695f, -0.32671306f, 0.09421018f, 0.57530278f, 0.56444889f, -0.87901396f, -0.32078338f, -0.62096512f, 
    -0.49500194f, -0.14175703f, -0.09605578f, 0.14351566f, 0.35095784f, -0.22558804f, -0.19181095f, -0.63741815f, 
    -0.09626029f, -0.36343706f, -0.51115805f, -0.39903304f, 0.24682611f, 0.07832598f, 0.21138287f, -1.04057896f, 
    0.73458940f, 0.40384629f, 0.10235184f, 0.83474928f, 0.01127251f, -0.54458535f, 0.27362150f, -0.62559491f, 
    0.24342771f, -0.14531264f, 0.45437676f, 0.71489471f, 0.42585522f, 0.64837497f, -0.23195685f, -0.20464818f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22403497f, 0.10911357f, 0.04480881f, -0.18914954f, 0.03443624f, -0.27594587f, 0.08777748f, -0.03168755f, 
    0.07239150f, -0.20291343f, -0.09818270f, 0.14692095f, 0.07773507f, -0.19123280f, -0.05927664f, 0.00753008f, 
    0.11840097f, -0.23687525f, 0.00557095f, -0.38432261f, 0.11301116f, 0.09180508f, 0.07563745f, 0.09076128f, 
    -0.00755342f, 0.05994891f, 0.22280242f, 0.00034643f, 0.16628388f, 0.15632786f, -0.33176616f, 0.14881116f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.04433163f, -0.06206813f, -0.05904765f, -0.02504407f, -0.04678002f, 0.03809899f, 0.05612434f, 0.01946129f, 
    -0.02123971f, -0.03294739f, 0.01645682f, -0.00989517f, -0.00699827f, -0.03053322f, -0.04207338f, 0.03565253f, 
    0.04429730f, 0.02672414f, 0.04485689f, 0.05867260f, -0.04016536f, -0.04591054f, -0.01371743f, 0.00773323f, 
    0.01944137f, 0.02935285f, 0.00552970f, -0.03102684f, -0.04448751f, -0.02915403f, 0.04347812f, 0.01831846f, 
    0.04299173f, -0.04714273f, -0.03891500f, 0.04237551f, -0.01972279f, 0.03231977f, 0.04735508f, -0.02699051f, 
    -0.04717746f, -0.03237225f, 0.00859012f, 0.01457629f, -0.03207697f, -0.05467585f, -0.04267863f, 0.02545003f, 
    -0.05681264f, -0.05907649f, -0.06525805f, -0.04030775f, 0.04418661f, 0.02235576f, 0.02488749f, 0.00489807f, 
    -0.02856426f, -0.04405865f, -0.02808490f, -0.03849276f, 0.04333976f, -0.04744175f, -0.01641299f, 0.00509254f, 
    0.00748444f, -0.03538856f, -0.05928086f, 0.02216882f, -0.02161927f, -0.01019720f, -0.00544577f, -0.02801953f, 
    0.03616785f, 0.04250453f, 0.05025834f, 0.02444363f, 0.02836707f, -0.01566998f, 0.03326825f, -0.04419989f, 
    -0.01086874f, 0.02534135f, 0.01564668f, -0.02515171f, -0.05081918f, -0.01242301f, 0.00245678f, -0.02184263f, 
    0.03376505f, 0.03547455f, -0.02389343f, -0.00764482f, -0.00531071f, -0.00099013f, 0.01454418f, -0.01940630f, 
    -0.06230604f, -0.01605347f, 0.04819657f, 0.04080757f, 0.00082392f, 0.00182003f, -0.01892473f, -0.01818359f, 
    0.02288701f, -0.00177392f, -0.04392429f, -0.05587561f, -0.05426981f, 0.03779840f, -0.04341694f, 0.05213074f, 
    0.00562578f, 0.01027241f, 0.03368095f, -0.03216269f, -0.04521158f, -0.00792325f, 0.02635434f, -0.04030788f, 
    0.00853996f, 0.04462956f, -0.05718212f, 0.00190788f, -0.01170419f, -0.05185255f, -0.03003159f, -0.01212962f, 
    0.05186498f, -0.00854566f, -0.02651861f, 0.04366378f, -0.04232564f, -0.05537839f, 0.04542971f, -0.00166960f, 
    -0.06646881f, 0.02931324f, -0.05833353f, -0.00242670f, -0.05973260f, -0.02320216f, -0.03023032f, 0.04977661f, 
    -0.01668654f, 0.01432603f, -0.02723513f, -0.01562563f, 0.02807789f, 0.02001655f, -0.04493067f, -0.03025133f, 
    -0.01325684f, 0.04103061f, 0.03425102f, -0.06417201f, -0.03663878f, 0.01501604f, 0.01790091f, 0.02642258f, 
    0.03844424f, -0.04244790f, -0.03132793f, -0.02176982f, -0.00000580f, -0.04771191f, 0.01616182f, 0.00205861f, 
    0.04340713f, 0.02615020f, 0.04312698f, -0.05057185f, -0.02923772f, 0.01082590f, -0.00811207f, -0.03148754f, 
    0.02149174f, 0.02637205f, -0.01575212f, -0.02953966f, -0.02437544f, -0.01202426f, -0.02172521f, -0.01136444f, 
    -0.02556868f, -0.01276196f, 0.03854287f, -0.04244293f, 0.03295651f, -0.04736715f, -0.03337017f, 0.03531144f, 
    -0.01612630f, -0.04831684f, -0.02410371f, 0.03305907f, 0.02690110f, 0.01366672f, 0.00227400f, 0.06366540f, 
    -0.05954032f, 0.03317682f, 0.00271199f, -0.02138424f, -0.01261268f, -0.00930310f, 0.01223922f, 0.03985011f, 
    -0.01450667f, -0.03866236f, -0.01978995f, -0.03848427f, -0.02598010f, 0.03368706f, -0.00529228f, 0.00981595f, 
    0.01763949f, -0.02909425f, 0.00488195f, 0.02320395f, -0.03695487f, -0.02627470f, -0.03171440f, -0.06916745f, 
    -0.00444171f, 0.02741382f, 0.01094966f, 0.02193059f, -0.01244041f, 0.00847473f, -0.06202125f, 0.01586198f, 
    0.04709285f, 0.04764881f, 0.02740817f, -0.02682526f, 0.04368503f, -0.05533990f, 0.04374177f, 0.00725352f, 
    0.04804594f, -0.03895661f, 0.01943490f, -0.04975770f, -0.04694934f, 0.02053394f, -0.02871664f, -0.00121124f, 
    -0.05244312f, 0.01921835f, 0.03430922f, -0.02689202f, 0.03834489f, -0.04948625f, -0.01589069f, 0.02720955f, 
    -0.02659742f, -0.01653449f, 0.01662478f, 0.02852078f, -0.02620853f, -0.04337015f, -0.01771055f, 0.02706180f, 
    -0.05407761f, -0.04037582f, 0.02992071f, 0.04377073f, 0.01428500f, 0.00705115f, -0.04988978f, 0.04905596f, 
    -0.02884288f, -0.01920088f, 0.00224013f, 0.04549433f, -0.05434054f, 0.05178772f, -0.01350746f, -0.03771111f, 
    0.01146880f, -0.05543957f, -0.05036102f, 0.01314340f, -0.00611342f, -0.06281301f, -0.05261236f, -0.00654408f, 
    0.52705050f, 0.00183374f, -0.10766681f, 0.00540951f, 0.10419359f, 0.09126160f, 0.02289348f, 0.00888426f, 
    0.19462998f, -0.25474733f, 0.00198331f, -0.51823628f, -0.13030078f, -0.04254529f, -0.04531748f, 0.00241630f, 
    -0.01228696f, 0.10001783f, 0.20354758f, -0.14908062f, 0.04968680f, 0.05842157f, 0.06341909f, 0.22653151f, 
    0.27175924f, 0.05254819f, 0.01670865f, -0.10716494f, 0.11697260f, 0.10495927f, -0.05187613f, -0.08189161f, 
    -0.13105147f, 0.11269673f, -0.03104427f, 0.04284693f, -0.08661762f, -0.51437867f, -0.10074118f, -0.16168804f, 
    0.02039212f, -0.00373227f, 0.08559214f, 0.12105423f, 0.05154523f, -0.32159168f, 0.15336110f, 0.16274801f, 
    -0.20533487f, 0.22610345f, 0.20028059f, -0.15580358f, 0.19878402f, -0.21790376f, -0.22107215f, -0.04960806f, 
    0.07129696f, 0.03759932f, 0.03364618f, -0.13661143f, 0.10979056f, -0.11370356f, -0.01615902f, -0.01097635f, 
    -0.02534539f, 0.03214767f, -0.13052718f, -0.01060430f, 0.10559290f, -0.03398086f, -0.04009954f, -0.07823163f, 
    -0.12708630f, 0.05901878f, 0.23006468f, -0.02384980f, -0.02781485f, 0.09940991f, -0.02694662f, 0.25546679f, 
    0.00119073f, 0.21248139f, 0.10068621f, -0.43016675f, 0.11777586f, 0.10259321f, -0.02706812f, -0.03098263f, 
    0.16033234f, -0.09503592f, -0.44725034f, -0.37926781f, -0.37545687f, -0.01689470f, -0.10813835f, 0.02344925f, 
    0.05226334f, 0.11643583f, 0.05475620f, 0.12608114f, -0.21288323f, -0.01061506f, 0.06147226f, 0.13741295f, 
    0.06808836f, -0.06422980f, 0.00584294f, 0.17731415f, 0.36447617f, 0.14365278f, -0.22901981f, 0.01759742f, 
    0.18644044f, -0.04121546f, -0.04962292f, 0.01147658f, -0.14591113f, 0.08936572f, -0.17554964f, 0.02853642f, 
    -0.00271762f, 0.01726539f, 0.00594617f, -0.02307870f, 0.12139813f, 0.03352740f, 0.10132084f, 0.10683168f, 
    0.09507044f, 0.05598832f, -0.12535080f, 0.03550979f, -0.09467369f, -0.03769456f, -0.08143135f, -0.39670134f, 
    0.03898350f, -0.05698035f, -0.01271485f, 0.08637711f, -0.01885084f, 0.00484037f, 0.06587349f, 0.00075877f, 
    0.15634373f, 0.26328212f, -0.04811737f, 0.08365417f, 0.07354897f, -0.05432096f, 0.16274248f, 0.02131477f, 
    0.04514319f, 0.11729276f, -0.25132096f, 0.09514277f, -0.05926035f, -0.03550371f, 0.10571206f, -0.07824291f, 
    -0.03989454f, -0.05912080f, -0.06836452f, 0.18531328f, 0.10758382f, -0.12260766f, -0.04460484f, 0.00829577f, 
    -0.09808534f, -0.00573132f, -0.10334486f, -0.20517325f, -0.03339372f, -0.11780754f, 0.11013940f, 0.06238298f, 
    -0.06882174f, -0.03561722f, 0.09255575f, 0.10745393f, 0.05343888f, 0.27288905f, 0.08435500f, 0.02692456f, 
    -0.12438436f, 0.05384973f, 0.08482415f, -0.01497566f, -0.01318034f, -0.12546046f, 0.14731628f, -0.27154452f, 
    0.08296893f, 0.09892321f, 0.06204978f, -0.00936197f, -0.02053330f, 0.00238731f, 0.03197214f, -0.18588914f, 
    0.03852938f, 0.23660558f, -0.09478965f, -0.05696575f, -0.05733842f, 0.10796959f, 0.05521659f, -0.01207583f, 
    0.20589396f, -0.30257106f, 0.02574321f, 0.01298149f, -0.13822332f, -0.04250400f, -0.05304927f, 0.00948197f, 
    -0.37150037f, 0.10286085f, -0.11890887f, -0.02257394f, -0.02722239f, -0.01653918f, 0.07368676f, 0.03352745f, 
    0.22069457f, -0.06126050f, 0.04525162f, -0.07550128f, -0.03562921f, -0.00252720f, 0.11682825f, -0.04721739f, 
    -0.00684563f, -0.01376661f, 0.10367326f, 0.00267244f, 0.10803392f, 0.01780177f, 0.10496890f, -0.07371677f, 
    -0.09663498f, 0.10356303f, -0.05152021f, 0.12958980f, -0.07099645f, -0.29850405f, 0.12183062f, -0.03351730f, 
    -0.08399358f, 0.00402846f, 0.12998055f, 0.10405507f, -0.21669769f, -0.06084986f, -0.05145964f, 0.19636601f, 
    0.00428111f, -0.04938764f, 0.02950544f, 0.03462615f, -0.16110817f, -0.20446531f, 0.04033997f, -0.30796343f, 
    0.11816022f, -0.09353162f, 0.03662337f, -0.14666399f, -0.04997839f, -0.05905053f, 0.15747698f, -0.03075040f, 
    0.04466382f, -0.05309562f, -0.13164933f, -0.01612667f, 0.02403293f, 0.06485629f, -0.02250660f, -0.12515453f, 
    -0.10374920f, -0.03267264f, 0.03529578f, -0.13105853f, 0.01326393f, 0.01628427f, 0.04201272f, -0.00930152f, 
    0.01132016f, 0.07531916f, 0.09375141f, -0.05615233f, 0.03091405f, 0.03881329f, -0.02566926f, 0.05335363f, 
    0.04552876f, 0.26565868f, 0.10229533f, -0.01131663f, -0.15615037f, 0.16282469f, -0.00061547f, -0.06981833f, 
    -0.06669859f, 0.02160399f, 0.03746630f, 0.11417495f, -0.26825079f, 0.13076325f, 0.25811908f, 0.12710185f, 
    0.11900152f, 0.03718156f, -0.01953776f, -0.41045952f, 0.07307234f, 0.40021279f, -0.02477718f, -0.03813267f, 
    0.05919524f, -0.02475535f, -0.10083430f, 0.16442277f, -0.06092229f, 0.22157690f, 0.17952032f, -0.07719963f, 
    -0.15805297f, 0.05110504f, 0.01659640f, 0.17427598f, 0.14153321f, 0.00532623f, 0.07693577f, -0.17110033f, 
    0.00462521f, 0.13641532f, 0.20513147f, -0.04499518f, -0.15019418f, -0.06719430f, -0.12737486f, 0.01425008f, 
    0.04788509f, 0.11701960f, 0.18488380f, -0.09001382f, 0.08683415f, -0.06457774f, 0.10859488f, -0.27219710f, 
    -0.03483602f, 0.27509603f, 0.15543403f, 0.05600756f, 0.01219469f, -0.00735708f, 0.00369267f, 0.08376659f, 
    -0.14334469f, 0.05197617f, -0.11042218f, -0.06510981f, 0.23133968f, 0.01541225f, 0.17043024f, -0.14066619f, 
    -0.07240362f, 0.21234722f, 0.17790443f, -0.06159014f, 0.06241541f, -0.00523425f, -0.15041323f, -0.17178126f, 
    0.10114048f, 0.12979765f, 0.09901650f, -0.06793875f, 0.01629246f, 0.04488682f, 0.07982968f, -0.14599498f, 
    0.09716270f, -0.10586536f, 0.14651573f, 0.17700049f, 0.36294198f, 0.00584551f, -0.09885143f, 0.00112850f, 
    -0.19223179f, -0.19954741f, 0.15423755f, 0.10085996f, -0.11207311f, -0.02798857f, -0.16917329f, -0.04031165f, 
    -0.03179128f, -0.01185824f, -0.08012176f, 0.06971350f, -0.09141255f, -0.03837858f, 0.12452579f, 0.04933685f, 
    -0.06798224f, 0.23085767f, 0.11125929f, 0.06953805f, -0.11133780f, 0.04082446f, -0.17689824f, 0.18151830f, 
    0.14885971f, -0.21765824f, 0.04591234f, 0.13517731f, 0.01302946f, 0.13180962f, -0.00805855f, -0.22238570f, 
    0.10490812f, 0.11712860f, -0.00522539f, 0.02952597f, -0.01349440f, -0.03337809f, -0.04702039f, 0.12713701f, 
    -0.00741500f, -0.12302655f, -0.00238026f, 0.08944897f, 0.08503277f, -0.01936207f, 0.09332157f, -0.05478940f, 
    -0.08864509f, -0.27050725f, 0.14459755f, 0.19154713f, 0.03885303f, -0.04433519f, -0.05345605f, 0.14127912f, 
    -0.21449029f, 0.01740363f, 0.07189806f, -0.07100816f, 0.01546299f, -0.04612782f, 0.13020508f, -0.04267876f, 
    0.03211955f, -0.06016586f, -0.01085068f, 0.02433339f, 0.12395876f, -0.01814211f, 0.13834019f, -0.12172654f, 
    0.08130563f, -0.15179457f, 0.03513493f, -0.13470906f, -0.15077078f, -0.10058959f, -0.09244154f, -0.07704245f, 
    0.10375247f, 0.24849589f, 0.02292088f, -0.25005519f, -0.30739576f, -0.10149963f, 0.10712858f, 0.17660356f, 
    -0.11070820f, -0.06146642f, 0.01264796f, 0.15769005f, -0.00300658f, -0.04947465f, 0.23570952f, 0.10429765f, 
    0.11417383f, -0.08917823f, -0.03111434f, -0.07973691f, 0.04590338f, -0.04291421f, 0.03320032f, -0.26389500f, 
    -0.24702236f, -0.12595738f, 0.01499653f, -0.10934104f, 0.07265376f, -0.12375826f, 0.05130943f, -0.22044656f, 
    -0.17232358f, 0.15779775f, 0.19993182f, -0.01310505f, -0.17234083f, -0.14335518f, -0.00931710f, 0.09240965f, 
    0.35866192f, -0.09455916f, -0.05849700f, 0.06053126f, 0.08644310f, -0.01719468f, 0.05122955f, -0.02212871f, 
    0.05126891f, -0.24695580f, 0.12243088f, 0.05457706f, -0.07958522f, 0.01074578f, 0.06072689f, 0.01089751f, 
    -0.07253162f, 0.16679946f, -0.01376292f, 0.18075965f, 0.12013391f, 0.15134628f, -0.04776181f, -0.00251411f, 
    0.02513221f, -0.00944887f, 0.04636571f, -0.03096639f, 0.21583819f, 0.00237350f, -0.11588825f, 0.09368387f, 
    0.01002277f, -0.01694755f, 0.09166735f, 0.09010015f, -0.07771587f, -0.04187807f, 0.12477532f, 0.09912565f, 
    -0.05279185f, -0.03314199f, 0.01748599f, 0.27075180f, -0.02360094f, 0.13897143f, 0.09894633f, -0.20114602f, 
    -0.33350623f, -0.07805256f, 0.08268629f, 0.04481516f, -0.12171642f, -0.23193313f, -0.31239364f, -0.10514512f, 
    -0.00792452f, -0.03138902f, 0.16140836f, 0.08506960f, 0.05270426f, -0.16104923f, -0.16902232f, 0.18949775f, 
    -0.08589210f, -0.14528726f, 0.02554251f, -0.02978458f, 0.05071676f, 0.12142402f, 0.18044378f, 0.01132141f, 
    -0.18880317f, 0.33037311f, 0.03747302f, -0.09805874f, -0.08890755f, 0.05963010f, -0.12351228f, 0.06782411f, 
    0.11485224f, 0.01746627f, 0.09292119f, -0.17998743f, -0.27599117f, 0.04866585f, -0.03455039f, -0.08182355f, 
    -0.04126354f, 0.11609170f, -0.04676849f, 0.24522750f, 0.25379413f, 0.18654390f, -0.11083575f, -0.04639773f, 
    -0.05207608f, -0.13839580f, 0.15536942f, 0.02297323f, 0.03590279f, 0.05208231f, 0.01484734f, -0.01159829f, 
    -0.10318757f, -0.03631456f, -0.12055334f, 0.08031085f, 0.05592995f, 0.11963465f, 0.17750026f, 0.02066844f, 
    -0.09020407f, -0.13688757f, 0.05119986f, -0.02083470f, 0.05769823f, -0.07841099f, -0.05282676f, 0.01804199f, 
    -0.02794130f, -0.07878735f, -0.05904363f, 0.08139276f, -0.01893012f, 0.00768348f, -0.07487480f, 0.29118857f, 
    0.24856532f, 0.23474970f, -0.04351428f, 0.01582346f, -0.09787031f, -0.02932653f, 0.07875784f, 0.05817874f, 
    -0.00488996f, 0.22479567f, -0.13347997f, 0.02098428f, -0.11198019f, 0.01609205f, 0.06258087f, -0.00657592f, 
    0.09260191f, 0.20036693f, -0.14078590f, -0.01206998f, -0.07745271f, -0.29585499f, 0.22845896f, 0.10640352f, 
    -0.02511617f, -0.31701374f, 0.20863564f, 0.02071108f, -0.09726745f, -0.16004002f, 0.07449804f, 0.10594064f, 
    0.00758954f, -0.00621716f, -0.23688935f, -0.04073507f, 0.00089137f, -0.18340223f, 0.13026313f, -0.08134075f, 
    0.06306293f, 0.07882576f, -0.04153517f, -0.15180518f, -0.01581320f, 0.05757627f, 0.21934047f, -0.04862174f, 
    -0.10327806f, -0.06333628f, 0.00261643f, -0.17988566f, 0.10464365f, -0.02728855f, 0.12282734f, -0.17867029f, 
    -0.00760376f, -0.10266311f, 0.00260857f, -0.02640217f, 0.01546346f, 0.03651062f, -0.03795945f, -0.07151463f, 
    0.07405432f, -0.13599965f, 0.02590966f, 0.01975848f, -0.07493622f, 0.16088066f, -0.04104770f, 0.18273197f, 
    0.13801625f, 0.05563017f, 0.09777790f, -0.18332927f, -0.05023216f, -0.08520258f, -0.08167523f, 0.08867127f, 
    0.30446368f, -0.23055373f, -0.13887553f, -0.06258892f, -0.13159661f, -0.01193913f, -0.02327510f, -0.01951629f, 
    0.13530268f, 0.05600213f, 0.27592990f, 0.17124213f, 0.16516168f, 0.10526703f, -0.14104366f, 0.00662991f, 
    -0.25501096f, 0.02496541f, -0.02153519f, 0.12862968f, -0.01671539f, -0.10919914f, -0.07420360f, -0.13110328f, 
    0.16398497f, 0.13133292f, -0.00862084f, 0.21554880f, -0.02136216f, 0.18974808f, 0.13893303f, -0.05015600f, 
    -0.07747310f, 0.18560188f, 0.13621745f, 0.05318899f, -0.19385082f, -0.06520194f, -0.23709068f, 0.19823505f, 
    -0.02033462f, 0.17391197f, -0.18558632f, 0.13872880f, -0.13000095f, -0.05326952f, 0.08737185f, -0.09784739f, 
    0.07873385f, -0.06522220f, 0.01555294f, 0.21129857f, -0.08283130f, 0.01620563f, -0.08253673f, -0.00798969f, 
    0.08853354f, 0.04457371f, -0.09269238f, 0.08615759f, -0.18006827f, 0.02466617f, 0.04900590f, -0.09072471f, 
    0.12311358f, 0.03916070f, -0.07327332f, 0.01968930f, 0.02820576f, 0.02559268f, 0.00292475f, 0.21988463f, 
    0.23319335f, 0.29724336f, -0.23821133f, 0.08410358f, 0.00994307f, 0.06102126f, 0.02719059f, 0.08823819f, 
    -0.31661975f, -0.18239060f, 0.22332041f, 0.16876462f, 0.09966630f, -0.03035043f, -0.11529195f, -0.04342451f, 
    -0.09613539f, 0.02317550f, 0.00127678f, 0.16282557f, 0.02492176f, -0.02259136f, 0.04843334f, -0.04189854f, 
    -0.03677570f, 0.00454311f, 0.13046071f, 0.03394182f, -0.14383894f, 0.15152267f, -0.13777103f, 0.05521015f, 
    0.02409052f, 0.03988976f, -0.26498759f, 0.04215052f, 0.10458565f, 0.11359674f, -0.03088141f, -0.11705828f, 
    -0.23498739f, 0.14086783f, -0.04687474f, -0.02324720f, -0.07405726f, 0.24385209f, -0.01862427f, 0.02826744f, 
    -0.03599237f, -0.03241495f, -0.07259164f, 0.03124189f, 0.21784543f, -0.10242262f, -0.39799765f, -0.10673268f, 
    -0.08193198f, -0.01082200f, -0.05308909f, -0.12237706f, -0.16597080f, -0.05758859f, 0.11873002f, 0.10047067f, 
    0.08300511f, 0.08098979f, 0.17599286f, 0.05023152f, -0.04718735f, 0.12707698f, 0.02948613f, -0.04527444f, 
    -0.25747761f, -0.24545218f, -0.03690130f, -0.19347598f, 0.10559803f, -0.15176831f, 0.06441065f, 0.06029344f, 
    0.07797997f, -0.23926952f, -0.13862751f, -0.10298087f, 0.09925345f, 0.15933712f, 0.00627741f, 0.02288471f, 
    0.03295564f, -0.00002564f, -0.05418846f, 0.17630683f, 0.08623359f, -0.11498098f, -0.11407924f, -0.09415472f, 
    -0.00415159f, 0.19464321f, 0.14690232f, 0.07541205f, 0.13977768f, -0.54497486f, 0.11040986f, 0.10947949f, 
    0.03376058f, 0.12726615f, 0.14808369f, -0.09207270f, 0.03011744f, -0.13389610f, -0.22791305f, 0.07277944f, 
    0.08007498f, 0.13713180f, 0.01873321f, 0.05465150f, 0.07085219f, -0.17398176f, -0.22573669f, -0.49391609f, 
    0.12777175f, 0.05233104f, -0.07850136f, -0.02762069f, 0.05053680f, -0.10381211f, -0.08069517f, -0.11651286f, 
    -0.03299075f, 0.14196430f, 0.15015131f, -0.01713507f, 0.02596126f, 0.20512712f, 0.03176183f, 0.08140174f, 
    0.23796229f, -0.43830493f, 0.15629776f, 0.12146825f, 0.13862306f, 0.14129387f, -0.21338566f, -0.10887283f, 
    -0.18989667f, -0.30751243f, -0.29476577f, 0.13143669f, 0.02434647f, 0.16644882f, -0.00750509f, -0.07325197f, 
    0.00584402f, -0.00815828f, 0.03687225f, 0.02696510f, -0.14446925f, -0.14177895f, -0.03964822f, -0.02901189f, 
    -0.02087921f, 0.12003215f, -0.18905008f, 0.09514445f, -0.07611484f, -0.03138415f, -0.20379737f, 0.05720153f, 
    0.20209488f, -0.00873655f, 0.00885576f, 0.00384673f, -0.09954887f, -0.02094717f, 0.00107275f, 0.07737303f, 
    0.18377577f, 0.10968706f, 0.02881476f, 0.21545206f, 0.14364308f, 0.06178968f, 0.10818050f, 0.01506531f, 
    -0.04122773f, 0.03502357f, 0.16249795f, -0.17716891f, -0.14798069f, -0.16552687f, -0.02521368f, -0.25130993f, 
    0.03035774f, -0.14519012f, -0.11887520f, 0.01896921f, -0.06912085f, -0.07510100f, -0.18023683f, -0.02200418f, 
    -0.07414854f, 0.15146242f, -0.02919034f, -0.07453657f, 0.04323206f, 0.04027675f, -0.19976173f, -0.07794514f, 
    -0.15917514f, -0.26758873f, 0.17835277f, 0.10483883f, 0.20508996f, -0.11617040f, -0.12933049f, 0.11077157f, 
    0.26203418f, 0.22741833f, 0.17442694f, -0.11443709f, -0.01866014f, -0.11536632f, 0.16162668f, 0.06665425f, 
    0.03896443f, 0.00169226f, -0.07067644f, -0.37912565f, 0.00736368f, 0.10471544f, 0.16937010f, -0.00239038f, 
    -0.17330301f, -0.08345746f, -0.43059179f, -0.05584616f, -0.10116450f, 0.10534928f, 0.20066875f, -0.01923606f, 
    0.10201648f, -0.07805690f, -0.00724911f, 0.07574517f, -0.25770605f, 0.31850728f, -0.06951644f, 0.28126684f, 
    -0.02787382f, -0.18043265f, -0.09470382f, -0.00445624f, 0.09063473f, 0.04056979f, 0.23572300f, 0.08485226f, 
    0.15513393f, 0.06189417f, 0.03968251f, -0.05771833f, 0.02516445f, -0.05018399f, -0.25833985f, -0.24865308f, 
    0.00942233f, 0.02839464f, 0.00014627f, 0.02724640f, 0.00210459f, -0.01279034f, 0.04429559f, 0.13316618f, 
    0.14967495f, -0.10065932f, 0.00006020f, -0.08436611f, 0.17460610f, 0.05117643f, 0.09491815f, 0.10726514f, 
    0.12736087f, 0.30867389f, 0.10161884f, 0.12334110f, 0.04675782f, -0.00538487f, -0.22251967f, -0.07666856f, 
    -0.02150166f, -0.10400958f, -0.06514980f, 0.20494536f, 0.05213193f, 0.05106507f, -0.10644665f, -0.07796510f, 
    -0.00575409f, -0.04177044f, 0.02332104f, 0.12896428f, 0.10362365f, 0.10194571f, -0.05303753f, -0.03947565f, 
    -0.12522510f, -0.08202590f, 0.19945349f, 0.15979047f, 0.06468955f, 0.12782142f, 0.17656055f, 0.02495620f, 
    -0.04048631f, -0.01906098f, -0.07471578f, 0.02927752f, -0.11266539f, 0.05684694f, 0.01299340f, -0.11346819f, 
    0.01917558f, 0.02751368f, 0.12773900f, 0.19302747f, -0.20170024f, -0.13301270f, 0.07910529f, -0.13574342f, 
    0.06537711f, -0.04832093f, 0.01534957f, 0.14015844f, 0.18876639f, -0.10974862f, -0.10043712f, 0.05001039f, 
    0.16991511f, -0.00179116f, 0.02126813f, 0.08360141f, 0.04613101f, 0.18599367f, -0.37785712f, -0.08674327f, 
    -0.17723830f, 0.00150431f, 0.07150436f, -0.04820049f, 0.01622622f, -0.00723673f, 0.05505128f, 0.09348046f, 
    0.09360289f, -0.06653602f, 0.02609759f, 0.26946336f, 0.20533119f, 0.03738314f, -0.06154818f, 0.08387521f, 
    0.06330618f, 0.01788678f, -0.00780315f, 0.05837107f, -0.00411221f, 0.04226862f, 0.00868189f, 0.04864220f, 
    -0.05784261f, 0.45338565f, -0.13145469f, -0.14090115f, -0.02525927f, 0.01523492f, 0.12935890f, -0.03397059f, 
    0.15071498f, -0.09830866f, -0.19515148f, -0.40653506f, -0.14402576f, -0.09442769f, 0.03566997f, -0.00519359f, 
    -0.01002415f, -0.10251018f, -0.08715449f, 0.15942749f, 0.06083227f, -0.12196580f, 0.02775823f, 0.11253513f, 
    0.13265486f, 0.05950001f, 0.13903490f, 0.10426183f, 0.01244696f, 0.04034245f, 0.09043775f, -0.00890503f, 
    -0.14013153f, 0.04765065f, 0.08739410f, -0.00086635f, -0.03532021f, -0.01641662f, -0.13697152f, 0.01580573f, 
    0.05808361f, -0.09137566f, 0.00023654f, -0.03778038f, 0.14324775f, 0.09690940f, 0.04852890f, 0.18768296f, 
    0.07156198f, 0.00456088f, 0.08702179f, -0.12402247f, -0.12235749f, 0.00371977f, -0.00023630f, -0.01978517f, 
    0.07350781f, 0.02817903f, 0.01467731f, -0.02811081f, 0.06681754f, -0.03932527f, 0.16344289f, 0.05861516f, 
    -0.06920619f, -0.06647523f, -0.06979535f, -0.15620211f, -0.13015626f, -0.01857343f, 0.11094096f, 0.02776638f, 
    -0.03974680f, 0.05221444f, 0.09293357f, -0.05921473f, -0.06840026f, 0.15740284f, -0.00262065f, -0.02491777f, 
    -0.03726524f, -0.11059844f, 0.05004613f, 0.02550541f, 0.02753733f, -0.12546057f, 0.02047444f, 0.16783382f, 
    -0.19255242f, -0.08200403f, -0.02702836f, -0.07859108f, 0.17828393f, 0.05035524f, -0.03075590f, 0.05378452f, 
    0.13347495f, 0.05201011f, -0.10077570f, 0.02852448f, -0.45614961f, -0.43815756f, -0.04673519f, -0.05659155f, 
    0.06839038f, 0.11369155f, -0.04562012f, 0.14155895f, -0.01301927f, -0.03713780f, -0.13925871f, 0.01753914f, 
    -0.14479598f, -0.05003567f, 0.03553937f, -0.03080118f, -0.03122147f, -0.16059050f, 0.09663589f, -0.03782122f, 
    -0.20330533f, 0.11579021f, -0.03402321f, 0.04832142f, -0.00531837f, 0.22107467f, 0.02605779f, 0.05729344f, 
    0.15409184f, -0.02042397f, -0.07303914f, -0.07596474f, -0.06625179f, 0.03914699f, 0.03118503f, -0.01271386f, 
    -0.10732883f, -0.79368812f, -0.05025268f, -0.05939860f, 0.08814209f, 0.09958146f, -0.02534794f, 0.03252290f, 
    -0.00209890f, -0.05688808f, 0.04240081f, 0.08413866f, 0.01983500f, -0.15995310f, -0.09913725f, 0.21629283f, 
    0.04308508f, -0.01163836f, -0.13304716f, 0.07652651f, -0.00897112f, -0.07239787f, 0.04845527f, -0.09226735f, 
    0.03796365f, 0.06677692f, 0.05352182f, -0.01904779f, 0.01794210f, 0.03468052f, 0.04910527f, -0.15714978f, 
    -0.10554673f, -0.15283419f, 0.02553505f, -0.10367567f, -0.41321686f, -0.15284654f, 0.06979130f, 0.09183816f, 
    -0.05359334f, 0.14838429f, -0.07500128f, 0.07544620f, 0.13389389f, 0.04848651f, 0.06509408f, -0.09415573f, 
    -0.02755976f, -0.04812662f, 0.15000138f, 0.13393091f, -0.01520790f, 0.04776655f, 0.17845626f, 0.01509731f, 
    0.29211926f, 0.09085217f, -0.04445731f, 0.11133967f, -0.05988643f, -0.06842238f, -0.04398177f, -0.32688326f, 
    -0.14175685f, 0.00206085f, 0.16781498f, -0.05173830f, 0.10366559f, -0.10049211f, 0.09368986f, 0.08685337f, 
    -0.05812332f, 0.20094770f, 0.07794474f, 0.02168097f, 0.05791787f, 0.00445130f, -0.00287085f, -0.08972503f, 
    -0.11093893f, -0.07635410f, -0.06330822f, 0.05617270f, -0.14771456f, -0.02041411f, -0.14179955f, -0.06314933f, 
    0.07503139f, 0.19670103f, -0.58707529f, 0.00788052f, 0.03830408f, -0.03370969f, 0.04967825f, -0.02217691f, 
    -0.05012279f, -0.00848224f, 0.00542689f, 0.28358972f, -0.21740679f, 0.11053832f, -0.03207227f, -0.07403167f, 
    -0.02505489f, 0.07853417f, -0.07072899f, 0.08851759f, 0.23636709f, 0.26210371f, -0.14395112f, -0.11199930f, 
    -0.18534040f, -0.05513705f, 0.13204366f, -0.00085353f, 0.00727830f, 0.11239316f, 0.10416634f, 0.01429354f, 
    0.08426930f, 0.06755584f, 0.05808247f, -0.03223038f, -0.04474112f, -0.06651190f, 0.14885277f, -0.20100959f, 
    -0.19993974f, 0.05668852f, 0.03305506f, -0.15202282f, -0.00624906f, 0.20838709f, 0.04821265f, -0.05622560f, 
    0.02153810f, 0.10035845f, -0.03860739f, -0.11291621f, 0.07486747f, 0.04314385f, 0.06911092f, 0.07946417f, 
    -0.22646113f, -0.07407770f, 0.01505475f, -0.04357833f, -0.20259932f, 0.07321192f, 0.15989003f, -0.12548186f, 
    -0.05620328f, -0.22997417f, 0.08949756f, 0.24864763f, 0.12498715f, 0.05323556f, 0.02344305f, -0.13090457f, 
    -0.17659149f, -0.14582105f, 0.01945045f, -0.07519248f, 0.17824812f, 0.05141156f, 0.03362249f, 0.10150486f, 
    -0.01332335f, -0.08540577f, -0.05248657f, -0.04640716f, -0.00970383f, 0.22444831f, 0.10409679f, 0.04494740f, 
    -0.02942209f, -0.01741217f, -0.04813357f, -0.04049568f, 0.08387708f, 0.06415313f, 0.03409985f, -0.03128996f, 
    0.10383151f, -0.12018000f, 0.12370752f, -0.09380759f, 0.02294486f, -0.25375646f, -0.17078064f, 0.02360084f, 
    0.11667193f, 0.13969398f, -0.09631824f, 0.01424554f, -0.10086139f, -0.01130846f, 0.19118500f, 0.07368556f, 
    -0.09840335f, 0.01970218f, 0.04507769f, 0.04778671f, 0.00417796f, 0.03678043f, 0.09990058f, -0.35818326f, 
    -0.23835213f, 0.20394705f, 0.07243074f, 0.05058488f, 0.02851113f, -0.05265469f, 0.02244112f, 0.02340015f, 
    -0.26066378f, -0.07850415f, -0.13420181f, -0.00103390f, -0.02187755f, 0.17088293f, 0.04601059f, 0.11792326f, 
    -0.13833779f, 0.06710443f, 0.02806166f, -0.06264820f, -0.19901809f, -0.11432039f, -0.03750143f, 0.11810514f, 
    0.05424873f, -0.00203442f, -0.30651131f, 0.04786896f, 0.00371940f, 0.11646365f, 0.04068519f, -0.02372845f, 
    0.07793681f, -0.11656135f, -0.14063211f, -0.00889103f, 0.22107939f, 0.07348725f, -0.04261316f, 0.10883597f, 
    0.03286043f, -0.00389655f, -0.05908645f, 0.09644239f, -0.10958291f, 0.21039718f, 0.01581322f, 0.12117647f, 
    -0.00689392f, -0.03432317f, -0.06831057f, 0.05399850f, 0.09352790f, -0.03932011f, -0.23165071f, -0.14049958f, 
    -0.02521438f, -0.05439596f, -0.14087951f, 0.04104215f, 0.09336733f, 0.15422586f, -0.20614053f, -0.16863324f, 
    0.28132892f, 0.13168189f, -0.02471385f, 0.06670296f, 0.01301871f, 0.10737821f, 0.06857208f, -0.36808288f, 
    -0.06284929f, 0.14631262f, 0.13718474f, 0.25171965f, 0.01158559f, -0.08649343f, -0.05408482f, -0.05251851f, 
    -0.19278260f, 0.01567804f, 0.30564064f, 0.13421340f, 0.14717120f, -0.00538151f, -0.17730251f, 0.14003985f, 
    -0.01700151f, -0.46590415f, -0.27997646f, 0.07723123f, 0.13483003f, 0.12452547f, 0.01835708f, -0.02807344f, 
    -0.05315806f, -0.03326943f, -0.43303210f, -0.20475341f, 0.15793379f, 0.13092998f, 0.14917345f, 0.06495341f, 
    0.04845371f, 0.10600148f, 0.04959263f, -0.11817338f, -0.23254548f, -0.09538903f, 0.04001888f, -0.02968060f, 
    -0.06003926f, -0.12147894f, -0.10718632f, 0.13237521f, 0.14961176f, 0.01384526f, -0.00459854f, 0.04432921f, 
    -0.04120235f, 0.07433473f, 0.02779610f, -0.11434358f, 0.05176141f, 0.09612485f, -0.04254575f, 0.05125355f, 
    -0.07973730f, -0.06368166f, -0.00345529f, -0.01390406f, -0.06764913f, -0.07998331f, -0.05920967f, 0.13960035f, 
    0.07751447f, 0.16742624f, -0.04593629f, -0.08668048f, -0.01005306f, 0.02357184f, -0.01243604f, -0.05284325f, 
    0.05191987f, -0.27908120f, -0.09706789f, 0.00868707f, 0.05150490f, -0.01980148f, 0.11370506f, 0.04207134f, 
    -0.11472508f, 0.06814577f, 0.00611254f, 0.06566665f, 0.12103424f, 0.09266927f, -0.05928132f, -0.15158783f, 
    -0.15558867f, 0.07388538f, -0.21688530f, -0.03203119f, 0.00998083f, 0.07393212f, 0.07903982f, 0.07670223f, 
    0.00347406f, 0.03367809f, 0.15563451f, 0.17593424f, 0.06518882f, 0.13619134f, 0.00752261f, 0.02841674f, 
    0.11038483f, 0.00824242f, -0.02223833f, -0.12756984f, -0.01819873f, -0.08042550f, 0.13363713f, -0.03900449f, 
    0.09477791f, 0.03021685f, 0.06222418f, 0.28774953f, -0.12461287f, -0.06877360f, 0.02249550f, -0.14181054f, 
    -0.05625377f, -0.01580155f, -0.01010067f, -0.03254411f, -0.02654126f, 0.10636938f, 0.02538866f, 0.14530379f, 
    0.04369307f, -0.02557706f, -0.03031993f, 0.09315377f, 0.07115279f, -0.16885404f, 0.18641113f, -0.32499772f, 
    -0.12882808f, -0.08368675f, -0.02277510f, -0.11266056f, 0.11021462f, -0.10189202f, 0.06098168f, -0.09071366f, 
    -0.04457548f, 0.05882337f, -0.07842677f, 0.01130905f, 0.05118348f, 0.17661175f, -0.00487199f, 0.02374610f, 
    -0.00041108f, 0.11249282f, -0.09732471f, 0.09942289f, -0.15966645f, -0.03321941f, 0.03986358f, 0.09739214f, 
    0.03139268f, 0.04692567f, -0.09902780f, -0.17895207f, 0.01377524f, 0.16005725f, 0.07438660f, 0.16932836f, 
    -0.03354381f, -0.15786272f, -0.27132112f, -0.07526856f, 0.01989142f, 0.18733490f, -0.02473065f, -0.06909028f, 
    -0.05459905f, -0.13031733f, 0.08956759f, 0.15797292f, 0.03228205f, -0.00897834f, 0.15160802f, 0.06582221f, 
    -0.00020351f, -0.07953127f, 0.09419073f, -0.06797844f, -0.03737188f, -0.15251216f, -0.09800752f, 0.07645188f, 
    0.00200807f, -0.09032759f, -0.03078826f, 0.01205788f, -0.23814124f, -0.02889690f, -0.02361142f, 0.04389143f, 
    -0.01679986f, 0.11980981f, 0.04914556f, -0.15046652f, 0.16345912f, 0.00287645f, 0.08659123f, 0.30442265f, 
    0.11123903f, -0.10861672f, -0.27278858f, 0.23321931f, -0.11722073f, -0.03712587f, -0.00041634f, 0.32580760f, 
    0.20657258f, 0.08199642f, -0.07749055f, 0.07375221f, -0.05294789f, 0.07162807f, -0.05655690f, 0.07369667f, 
    -0.05435210f, -0.04979845f, 0.09265587f, -0.02753825f, -0.00391534f, -0.13498282f, -0.01111987f, -0.02803873f, 
    0.00860311f, -0.10308429f, 0.11174808f, 0.03213644f, 0.03571819f, 0.07332758f, 0.10063000f, -0.15659836f, 
    -0.02955393f, -0.10275985f, 0.11255874f, 0.19376074f, 0.11957586f, -0.07900768f, -0.18196891f, -0.05577425f, 
    -0.04609494f, -0.02374875f, -0.05691907f, 0.01659738f, 0.09798905f, 0.20493211f, 0.26494035f, 0.09083521f, 
    -0.00339318f, 0.01366208f, -0.03099299f, -0.02895255f, -0.42517856f, -0.21231459f, -0.22698383f, 0.07909648f, 
    0.06562943f, -0.07506331f, 0.05755510f, 0.07060967f, 0.05813177f, -0.16077127f, -0.16953480f, -0.10155354f, 
    0.01053525f, 0.00778741f, -0.03958309f, -0.05252856f, -0.04690761f, 0.23664382f, 0.12800868f, 0.08850002f, 
    -0.11345416f, 0.00260674f, -0.03728960f, 0.03233045f, 0.05533864f, 0.00537648f, 0.04195542f, 0.08684320f, 
    0.03157311f, 0.14641826f, -0.03657616f, -0.02787006f, -0.26105744f, -0.07875078f, 0.12865630f, 0.01835478f, 
    -0.23326993f, -0.23015483f, 0.14703877f, 0.20096524f, -0.02666322f, 0.16140711f, -0.19072703f, -0.08592930f, 
    0.02400026f, 0.18067449f, -0.04637389f, 0.05158330f, 0.04355814f, 0.10339482f, -0.04059827f, 0.06135523f, 
    0.07373555f, 0.02286448f, -0.00752343f, -0.02211093f, 0.10489477f, -0.29430693f, -0.00500534f, -0.06776076f, 
    -0.10937750f, -0.00961936f, 0.04948228f, -0.15745670f, -0.00961945f, -0.01137362f, -0.21532409f, -0.24664259f, 
    -0.01888264f, -0.02678300f, -0.02084315f, 0.14433682f, -0.39150462f, -0.32371676f, -0.12709987f, 0.00775077f, 
    -0.01788328f, 0.04256991f, -0.05629866f, -0.14265832f, 0.20308009f, 0.11324235f, 0.06187513f, 0.11041921f, 
    0.05753577f, -0.20070085f, -0.04663951f, 0.13831544f, 0.15576626f, 0.26907173f, 0.06649245f, 0.01328644f, 
    -0.16844362f, 0.11351515f, 0.02933933f, 0.07202679f, -0.05202756f, -0.01537091f, -0.07691129f, -0.31716383f, 
    -0.23311590f, -0.19678618f, -0.10280802f, 0.01578050f, -0.23002997f, 0.08293234f, 0.01081903f, 0.10273676f, 
    -0.12537882f, 0.07178170f, 0.17350809f, -0.05620336f, -0.08569618f, 0.16250843f, -0.00301735f, -0.10031603f, 
    -0.13373797f, 0.14147183f, 0.07990268f, -0.01958681f, -0.02428137f, 0.03866258f, -0.02133309f, 0.12450612f, 
    -0.00165480f, 0.07962743f, -0.62300187f, -0.38824022f, -0.08974094f, 0.01518181f, -0.07983895f, -0.08081222f, 
    0.11505464f, -0.07763253f, 0.06591971f, 0.14947072f, -0.03998529f, -0.11945693f, -0.01471216f, 0.10640173f, 
    -0.07047154f, -0.01941341f, 0.11330277f, 0.03405953f, 0.12503490f, 0.14042634f, 0.06214559f, 0.11497298f, 
    -0.05056098f, 0.10014740f, -0.08489428f, -0.08301316f, -0.12244696f, 0.08961699f, -0.02374211f, 0.07353350f, 
    -0.08052319f, -0.05695259f, 0.01959763f, -0.04696537f, 0.06366292f, 0.01501690f, -0.05183994f, 0.01326666f, 
    0.02261167f, 0.15483475f, 0.29048920f, -0.00816002f, -0.09998718f, 0.27124238f, -0.00499130f, 0.18524309f, 
    0.00434899f, -0.03170880f, -0.08056664f, -0.07743211f, -0.22972810f, 0.31161022f, 0.01423240f, 0.06320296f, 
    0.00083936f, -0.04013494f, -0.05645045f, 0.04971885f, 0.02735372f, -0.01005173f, -0.01548321f, -0.00970527f, 
    -0.02898590f, 0.04597632f, 0.00524647f, -0.05405585f, 0.00875841f, 0.04092545f, -0.03213056f, -0.01720755f, 
    0.04140704f, -0.03632881f, 0.02311197f, -0.01395368f, 0.01808066f, -0.06143323f, -0.04941154f, -0.05797515f, 
    0.04425094f, 0.00599701f, -0.01817390f, 0.04400466f, 0.02409882f, 0.01918838f, -0.00600525f, 0.01676970f, 
    -0.06271210f, -0.00841274f, -0.02289489f, -0.00619167f, -0.02485992f, 0.03539752f, -0.00651581f, -0.01334417f, 
    0.00400274f, -0.01267105f, -0.00420508f, -0.00877003f, -0.02082513f, -0.03690301f, -0.02401794f, 0.00949972f, 
    0.04599684f, 0.01604966f, -0.00070357f, -0.00188239f, 0.01046480f, 0.01523557f, 0.04073343f, -0.04733386f, 
    0.01691673f, -0.00241046f, -0.02582213f, -0.05060522f, 0.01753101f, 0.02611366f, 0.01426109f, -0.04219283f, 
    -0.01487449f, 0.02379921f, 0.01530438f, -0.03521166f, 0.04461994f, 0.02708514f, 0.00793952f, 0.01841926f, 
    0.03533583f, 0.04642677f, 0.01903444f, -0.03025506f, -0.02722278f, -0.04485841f, -0.04807711f, -0.04627869f, 
    -0.01858736f, 0.01945487f, 0.04522716f, -0.02795342f, -0.05858110f, -0.04117239f, -0.03432868f, -0.02293263f, 
    -0.05612825f, -0.06642828f, -0.03065647f, -0.03733553f, -0.04647767f, -0.00311594f, 0.01592601f, 0.04421465f, 
    0.02719502f, -0.01410469f, 0.03979723f, 0.02780659f, -0.04168318f, 0.04771075f, -0.00204178f, -0.01347797f, 
    -0.04840397f, -0.01893544f, 0.03232754f, -0.01735787f, 0.03570528f, -0.02547728f, -0.00125541f, 0.03342096f, 
    -0.05379497f, -0.02189611f, -0.04735292f, -0.01852585f, -0.00473998f, -0.04439107f, 0.00008647f, -0.00974689f, 
    0.03180934f, 0.00731290f, -0.00041207f, 0.02369893f, 0.02035569f, -0.01800853f, 0.04988617f, -0.02692859f, 
    -0.05261731f, 0.03703153f, -0.00458023f, 0.00947724f, -0.02614169f, -0.02546346f, 0.02539679f, 0.04155438f, 
    -0.00606126f, 0.03125161f, 0.02647407f, -0.03705608f, -0.03343756f, 0.04755435f, 0.04350826f, -0.05806590f, 
    -0.00483519f, -0.03070257f, 0.02900305f, 0.01573560f, 0.04876690f, -0.05475682f, 0.04044078f, -0.01800829f, 
    -0.02445173f, -0.03051844f, -0.04038718f, -0.02498146f, -0.00020224f, 0.02688476f, -0.01906323f, 0.01887727f, 
    0.00008035f, -0.05209436f, -0.04472172f, -0.05433451f, -0.04475024f, 0.00178471f, -0.02441049f, 0.04537828f, 
    0.04805990f, -0.00048703f, 0.00949474f, -0.02203832f, 0.00313430f, 0.03009155f, -0.02665162f, 0.01135041f, 
    -0.01861091f, 0.04506418f, 0.04988108f, -0.01480696f, 0.04842541f, 0.02211302f, 0.05391926f, -0.02055966f, 
    0.00895023f, 0.02253196f, 0.05623869f, -0.00408363f, -0.06081958f, 0.04731102f, 0.02181398f, -0.05532042f, 
    -0.04425485f, 0.02256772f, -0.06190619f, 0.00692145f, 0.03409592f, -0.01005825f, -0.04019250f, -0.06335729f, 
    0.03190543f, -0.03444367f, -0.02152402f, 0.01616170f, 0.01675626f, 0.02382152f, -0.02930272f, -0.05146841f, 
    -0.04411193f, -0.01278390f, 0.01407083f, -0.03263234f, -0.00809231f, 0.00696506f, -0.04961043f, -0.02805161f, 
    -0.01884669f, 0.00906487f, -0.02696524f, 0.04064233f, 0.00316647f, 0.03683544f, -0.05174248f, 0.03779846f, 
    0.00826505f, -0.05900435f, -0.03797034f, 0.00278834f, 0.04133832f, -0.02788472f, 0.03929744f, 0.03572971f, 
    0.01976487f, 0.02487962f, -0.00528979f, 0.05433185f, -0.01145102f, 0.00272029f, -0.04107500f, -0.00886849f, 
    -0.05474949f, 0.04498491f, -0.04406203f, -0.00464273f, -0.01619618f, -0.03434317f, -0.05283159f, -0.03224869f, 
    0.00853262f, -0.06332850f, -0.02716964f, -0.04376915f, 0.02672774f, -0.06164875f, -0.03773730f, -0.02194946f, 
    -0.04468757f, -0.02200032f, -0.04098102f, -0.01029357f, -0.04419824f, -0.00894705f, 0.01641726f, 0.01681569f, 
    0.02337836f, -0.05835062f, -0.06336556f, -0.02866573f, 0.02930385f, -0.04656561f, -0.01482186f, 0.02859831f, 
    -0.03855745f, -0.05606097f, 0.00012642f, -0.01392333f, 0.04404186f, -0.03342284f, -0.01347582f, -0.00641989f, 
    0.01137014f, 0.04139620f, -0.01152009f, -0.01265550f, 0.01770909f, 0.00944261f, -0.00435590f, -0.03175984f, 
    0.02340931f, -0.01538067f, 0.00153527f, 0.15494277f, -0.05250032f, 0.05440563f, 0.06876463f, 0.00728801f, 
    0.05614880f, -0.14348516f, -0.12819840f, 0.00960970f, 0.09443723f, -0.02576299f, -0.04270522f, 0.12490939f, 
    -0.06928772f, 0.11679706f, -0.13520534f, -0.05194161f, -0.11887969f, 0.09502898f, 0.13514869f, -0.11279225f, 
    0.15348022f, -0.01477733f, -0.20786290f, 0.10064494f, 0.07505942f, 0.07696575f, -0.11256874f, -0.09555023f, 
    0.03834113f, 0.04211375f, 0.07459600f, -0.00666404f, -0.06953558f, 0.01038274f, -0.12196629f, -0.15805404f, 
    0.02934707f, 0.04967912f, 0.19081956f, 0.03114731f, -0.10959021f, -0.06796077f, -0.11039273f, 0.06963538f, 
    0.08815385f, -0.03790434f, 0.02037565f, 0.06933311f, 0.10568075f, -0.11306042f, 0.13111046f, 0.17620637f, 
    -0.06383081f, -0.07815224f, -0.22226587f, -0.07664214f, -0.05739619f, -0.19427507f, 0.11777989f, 0.13679105f, 
    0.04217130f, -0.11918448f, -0.10470992f, 0.07099944f, 0.05931034f, 0.05380902f, 0.24115917f, 0.00244253f, 
    -0.19655082f, 0.12983643f, -0.14428224f, 0.03880080f, 0.04117281f, 0.02888434f, -0.10663645f, 0.10273551f, 
    0.14046715f, 0.08597852f, 0.06499693f, -0.09427322f, 0.06050211f, -0.11911047f, -0.16511370f, 0.01013242f, 
    -0.09106648f, 0.05113837f, 0.07690420f, -0.13584760f, 0.02778271f, 0.01146932f, -0.05621085f, 0.01100536f, 
    0.13939631f, 0.16907150f, 0.15957074f, -0.10805544f, -0.10727862f, 0.04274582f, 0.13062130f, -0.06248385f, 
    -0.07425638f, 0.11061765f, 0.08825182f, 0.06304789f, -0.46194002f, -0.35770419f, -0.30330640f, 0.16235885f, 
    0.04680990f, 0.07911617f, 0.06420800f, 0.09479418f, 0.03852247f, -0.09991968f, 0.06064497f, 0.01202014f, 
    -0.06756325f, 0.18605442f, -0.06345769f, 0.08414244f, -0.17524719f, -0.08594260f, -0.03599060f, 0.13145334f, 
    -0.01305803f, -0.00345508f, 0.04162186f, -0.15562750f, -0.03902488f, 0.09862162f, -0.03152641f, 0.00924635f, 
    -0.05287363f, -0.17191216f, -0.02782990f, 0.03720595f, -0.05818683f, -0.08359978f, 0.10268291f, -0.04737060f, 
    -0.29155535f, -0.42754737f, -0.17471866f, 0.08710696f, 0.09027934f, -0.01618397f, 0.03639340f, 0.12038215f, 
    0.01575650f, 0.02264724f, -0.00619037f, -0.10907967f, -0.06216878f, -0.06788834f, 0.02688071f, 0.00252530f, 
    0.19911236f, 0.13782021f, 0.14139417f, -0.08717972f, 0.02260743f, -0.09481912f, 0.04891510f, -0.12501447f, 
    0.02066013f, -0.06809247f, 0.13789532f, -0.12643988f, 0.27584440f, -0.19537121f, -0.06050277f, 0.02591658f, 
    -0.08881622f, 0.22365013f, 0.00383791f, 0.20464796f, -0.30939877f, -0.19309741f, 0.01873646f, 0.17557357f, 
    0.14547542f, 0.04328343f, 0.08204969f, 0.05366177f, -0.22137085f, 0.09604749f, -0.00060452f, 0.01710128f, 
    0.11153208f, 0.00446811f, 0.05261797f, 0.21590450f, 0.01681847f, 0.06560685f, -0.10854504f, -0.04395235f, 
    0.09751784f, 0.09633255f, -0.08846818f, -0.01690441f, 0.09400903f, -0.02954876f, 0.04705130f, -0.25232062f, 
    -0.10944024f, -0.13010265f, 0.03760295f, 0.08107314f, 0.12787054f, -0.04738481f, 0.10103898f, -0.01964456f, 
    -0.06952359f, 0.03633534f, 0.01115632f, 0.07657397f, -0.12883754f, -0.01171115f, 0.05169496f, 0.04092225f, 
    0.03030772f, 0.28407493f, 0.12645058f, -0.07592518f, 0.06500962f, -0.06799441f, 0.07534614f, -0.02595108f, 
    0.05001630f, 0.03346666f, -0.17838068f, -0.39680034f, -0.00267507f, 0.06668103f, 0.12381595f, 0.02712129f, 
    -0.07629710f, 0.18910860f, -0.19379079f, -0.00347474f, -0.01016526f, -0.09376615f, 0.04382804f, -0.01805639f, 
    -0.01792823f, 0.01073519f, -0.03637445f, -0.04964864f, 0.10928775f, 0.01418043f, -0.08118965f, -0.05894369f, 
    -0.12857467f, -0.02788097f, 0.19432521f, 0.01760306f, 0.06377035f, 0.21676518f, -0.06643799f, 0.06859592f, 
    -0.00576877f, 0.01793616f, -0.01543214f, 0.00591014f, 0.07801861f, -0.05726131f, 0.18685152f, 0.06594813f, 
    -0.00985286f, 0.01218052f, -0.14827265f, -0.07671334f, 0.03386628f, 0.01265453f, -0.14296781f, -0.04813591f, 
    0.05761510f, -0.06532986f, 0.16424823f, 0.23050548f, 0.02140958f, 0.11394367f, 0.23492053f, -0.00106065f, 
    0.00625495f, 0.05151339f, 0.04642261f, 0.04709117f, -0.01285706f, -0.04633864f, -0.05063985f, -0.06060667f, 
    -0.01415040f, -0.01223166f, 0.01315889f, -0.04145943f, -0.00590503f, -0.03071499f, -0.04504476f, 0.01673093f, 
    -0.02703856f, 0.01842552f, 0.03691929f, -0.04011445f, -0.03704680f, -0.03836446f, 0.02857142f, -0.04322363f, 
    -0.04420583f, 0.03247736f, -0.03258653f, -0.03462539f, -0.04670234f, -0.01618062f, 0.04250814f, -0.05781905f, 
    -0.01210879f, -0.04329887f, -0.01912941f, 0.00213196f, 0.03735416f, 0.05259047f, -0.03826431f, -0.05347707f, 
    -0.04471788f, -0.01234757f, 0.03919632f, -0.03838409f, 0.01069259f, 0.00020054f, -0.00857330f, -0.06060961f, 
    -0.05241060f, -0.01145688f, 0.03517006f, 0.03206484f, 0.00513847f, 0.05141412f, -0.02783502f, 0.01948314f, 
    -0.04176097f, -0.02751710f, -0.06203337f, -0.00787908f, -0.05572283f, -0.06097313f, 0.01504984f, 0.00766037f, 
    0.05614137f, -0.06289443f, -0.01259429f, 0.05105958f, 0.00702498f, -0.02367934f, -0.03385529f, 0.04854617f, 
    -0.04574029f, 0.00918416f, -0.04933449f, 0.04187313f, 0.04953625f, -0.05656974f, -0.03710764f, -0.06465703f, 
    0.03608750f, -0.03229500f, 0.02173755f, -0.06182229f, -0.04567059f, 0.05112753f, 0.04939865f, -0.04466611f, 
    0.03544378f, -0.03128573f, 0.01861708f, -0.00104484f, 0.01489300f, -0.02894892f, -0.01005362f, -0.00155448f, 
    -0.02622171f, -0.06470385f, 0.02253642f, 0.00241772f, -0.01729102f, 0.01154386f, 0.02539269f, 0.04292416f, 
    -0.00108234f, -0.06317191f, -0.06428839f, 0.00101697f, -0.03988190f, -0.00203872f, -0.04397548f, 0.00275994f, 
    -0.04557674f, -0.05703281f, -0.01322944f, -0.05578560f, 0.01130300f, -0.04196503f, 0.03854746f, 0.04464950f, 
    0.00102275f, 0.03364016f, -0.05580269f, -0.03607860f, -0.05080177f, 0.00934209f, 0.03649813f, -0.04832764f, 
    -0.05511142f, 0.01827776f, 0.00858962f, -0.03934332f, 0.02417483f, -0.05784160f, -0.03943688f, -0.02655416f, 
    -0.02055107f, -0.00895090f, 0.01038649f, -0.02741949f, 0.02541329f, -0.04653898f, -0.03774992f, 0.05047547f, 
    0.02760367f, 0.01367776f, -0.05175040f, 0.02278587f, -0.01928792f, -0.05182916f, -0.03820055f, -0.06010312f, 
    -0.03842891f, 0.00684906f, -0.03187941f, -0.06025517f, -0.05756691f, 0.04315311f, 0.04857165f, 0.01752812f, 
    0.03336806f, -0.02040844f, -0.03496193f, -0.04328228f, 0.01115177f, 0.00486397f, -0.05866850f, -0.04929736f, 
    0.01627445f, -0.01165909f, -0.05783773f, 0.01557538f, -0.02414516f, -0.01594034f, -0.03574768f, -0.02223781f, 
    -0.06250839f, -0.00675806f, -0.06132491f, -0.01112297f, -0.06102341f, 0.00268939f, 0.04909809f, 0.00529564f, 
    0.04807430f, 0.00413245f, -0.05304464f, -0.02122087f, -0.01047287f, -0.00405741f, -0.02754885f, -0.05217814f, 
    0.03936002f, 0.00645241f, -0.02445639f, -0.02459451f, -0.00051127f, -0.01573507f, -0.02350120f, 0.01035754f, 
    0.02990147f, -0.00161965f, -0.02547868f, -0.03874568f, -0.04664800f, -0.00537144f, 0.02366817f, -0.02642828f, 
    -0.03859421f, 0.04899288f, -0.02801740f, -0.01025415f, -0.02105668f, -0.00823426f, 0.05164104f, 0.02727250f, 
    -0.03591419f, 0.02318200f, -0.04864219f, -0.02654190f, 0.01257580f, -0.04226602f, -0.00412633f, -0.05574492f, 
    0.04720266f, -0.05816093f, -0.03753930f, -0.01499298f, 0.03969480f, 0.00843458f, -0.02579540f, -0.00758178f, 
    0.01291994f, 0.05050221f, -0.01309970f, 0.00233503f, -0.03080621f, -0.00466970f, 0.04453852f, 0.01708793f, 
    0.02847907f, 0.04075124f, -0.03621023f, -0.01708082f, -0.01789407f, -0.05115530f, 0.02212447f, -0.00516748f, 
    -0.03129955f, 0.00070647f, 0.05141198f, 0.00006078f, -0.06155703f, -0.02209118f, -0.02824208f, 0.02105097f, 
    -0.00543735f, -0.05767337f, -0.04834031f, 0.03300439f, -0.02867282f, 0.02191395f, 0.04267513f, -0.03334398f, 
    0.05223826f, -0.03468359f, 0.03327357f, -0.03897862f, 0.00325017f, 0.02687437f, 0.02242613f, 0.01197956f, 
    -0.04450867f, -0.01105897f, -0.05416737f, 0.03839475f, 0.00548357f, 0.03589990f, -0.01212014f, -0.00741010f, 
    -0.04328099f, 0.03368890f, 0.02726399f, -0.01942798f, 0.03081971f, 0.03151715f, -0.02318201f, 0.03371556f, 
    -0.05496185f, -0.15805008f, -0.04223266f, 0.03771385f, 0.23060378f, 0.13979445f, -0.00919668f, 0.03269164f, 
    0.01974747f, 0.23875745f, 0.31989160f, 0.10382859f, 0.04206205f, -0.01599796f, 0.10405062f, 0.00571256f, 
    -0.02656344f, 0.00874005f, 0.12186126f, 0.17989223f, -0.10853882f, -0.00450284f, 0.17722243f, -0.01667800f, 
    0.03240567f, 0.19638288f, -0.18406887f, -0.04348249f, -0.14560451f, -0.02316190f, -0.02202882f, -0.05861938f, 
    -0.07525986f, -0.13731803f, 0.16263175f, 0.27536124f, -0.28079969f, 0.07269965f, -0.02244534f, -0.02360266f, 
    -0.00496338f, 0.10113404f, -0.14569554f, 0.10081644f, 0.21396649f, -0.01817956f, -0.16223012f, -0.05645398f, 
    0.03452324f, -0.13349128f, -0.03140843f, -0.01754221f, 0.06747628f, -0.12524818f, -0.19668570f, -0.12532932f, 
    0.02659210f, 0.14049132f, -0.02264170f, 0.08461803f, 0.12611012f, 0.14054561f, -0.13478673f, -0.05520510f, 
    -0.19486007f, 0.09602754f, 0.02556995f, -0.13820758f, 0.05406325f, -0.05059473f, 0.00032988f, 0.11910029f, 
    -0.08419842f, -0.07003991f, 0.10663495f, -0.06042880f, 0.05586331f, 0.10896949f, 0.14175755f, 0.19739446f, 
    -0.04410648f, -0.13259512f, 0.29144061f, -0.16305164f, 0.03187151f, -0.08308186f, -0.33360818f, -0.00302055f, 
    0.07890598f, -0.02963220f, -0.18887635f, 0.07741538f, 0.03801510f, -0.09934436f, 0.11468493f, 0.21789935f, 
    -0.17679685f, -0.20578162f, 0.06974939f, -0.32667968f, 0.31210110f, -0.01571847f, 0.05484308f, -0.02579950f, 
    0.09717566f, -0.00632626f, 0.17828339f, 0.10219265f, 0.17128454f, -0.05807655f, -0.33865058f, 0.11842169f, 
    0.03265491f, 0.01827992f, -0.00565770f, 0.04861655f, 0.22118734f, -0.27723041f, 0.13732536f, -0.00888418f, 
    -0.24359593f, -0.07516631f, 0.02151384f, 0.08882704f, 0.15975676f, -0.00731643f, -0.00345546f, -0.05438252f, 
    0.19960731f, 0.08722067f, -0.09410055f, 0.00660717f, 0.02230358f, 0.06132853f, 0.04562651f, -0.16467386f, 
    -0.08238437f, 0.18296139f, 0.16102482f, -0.13367881f, -0.13399379f, -0.03892045f, 0.05699666f, 0.06767353f, 
    0.17586878f, 0.12617853f, -0.36914527f, -0.08455316f, 0.17400885f, 0.07833850f, 0.21437426f, 0.02204880f, 
    -0.19804442f, -0.09101610f, -0.09316994f, 0.08373174f, -0.10830477f, -0.07652614f, 0.08547475f, -0.00899993f, 
    -0.00121869f, 0.00169140f, 0.01819650f, -0.20340817f, 0.25805792f, 0.16460767f, 0.05480869f, 0.09211672f, 
    0.14845261f, 0.04479255f, -0.04522219f, -0.09758720f, -0.06042645f, -0.25695497f, 0.24662265f, 0.07380862f, 
    0.14293884f, -0.00202686f, -0.27749303f, 0.03204133f, -0.13354285f, -0.09019607f, -0.28961539f, 0.05608090f, 
    0.05047778f, 0.10826648f, -0.09957943f, 0.04442366f, -0.01126802f, 0.13294326f, -0.06244019f, 0.08860423f, 
    0.10075281f, 0.04883352f, 0.21502827f, 0.21449190f, -0.00740254f, -0.06701292f, -0.07511764f, 0.47394934f, 
    -0.50228500f, 0.07850436f, -0.15735236f, 0.13242725f, -0.03460059f, 0.29453209f, 0.03090251f, 0.14509439f, 
    -0.27210578f, -0.24250004f, 0.11273702f, 0.09677493f, 0.12135145f, 0.10478286f, -0.07518214f, 0.12344611f, 
    -0.33174956f, -0.12291633f, 0.11349376f, 0.05540697f, 0.00423581f, 0.10278785f, -0.14554191f, 0.06914142f, 
    0.07126921f, 0.13011101f, 0.05485306f, -0.03794257f, 0.07103825f, 0.02642480f, 0.01129082f, 0.08336509f, 
    -0.09782978f, -0.00751590f, 0.08021568f, 0.05686041f, -0.21312198f, 0.13064949f, 0.01537000f, 0.12676115f, 
    -0.08957634f, -0.08666197f, 0.01495538f, -0.00390469f, 0.02056402f, -0.04865034f, -0.01382311f, 0.02194109f, 
    0.10888509f, -0.04549094f, -0.05137621f, -0.07984976f, -0.28799146f, 0.03412787f, 0.13559255f, 0.13160892f, 
    -0.04305566f, -0.04542812f, 0.21354887f, 0.08122345f, 0.13868186f, -0.03038489f, -0.04835545f, 0.22998154f, 
    0.06004577f, 0.04048464f, -0.06534810f, 0.03733580f, 0.02712308f, 0.18191324f, 0.28930813f, -0.18596092f, 
    -0.24865383f, 0.08350723f, -0.23901871f, 0.04415067f, -0.01490192f, -0.09307372f, 0.06713306f, 0.07349176f, 
    0.04118397f, 0.08455603f, 0.06798047f, 0.06614181f, 0.27244928f, -0.02120693f, -0.05394210f, 0.00945541f, 
    0.12337591f, 0.01744154f, 0.18141218f, 0.01498972f, -0.09255058f, 0.07132237f, -0.00141470f, 0.06734630f, 
    -0.11278413f, 0.11654863f, -0.28004399f, -0.08819913f, -0.06972571f, -0.04201749f, -0.00533920f, 0.04433077f, 
    0.05061854f, -0.13917293f, 0.06792966f, 0.08040649f, -0.17963082f, -0.02965601f, -0.14471039f, 0.14531332f, 
    0.09612674f, 0.03289718f, -0.08637162f, 0.33674842f, 0.11224112f, -0.01314938f, -0.03646880f, -0.02517913f, 
    -0.06453851f, 0.27705458f, 0.37703875f, 0.07732204f, -0.14451788f, 0.13469407f, -0.14295040f, 0.07694905f, 
    -0.08579354f, -0.06038615f, 0.09550979f, 0.07575540f, -0.13378155f, 0.22903094f, -0.02342390f, 0.06179286f, 
    -0.04164434f, -0.06488235f, 0.05809624f, 0.13287626f, 0.01464998f, 0.15326010f, -0.19431107f, -0.12553258f, 
    -0.01467017f, 0.01107723f, 0.11409248f, -0.03728938f, -0.04050042f, -0.01637108f, 0.07787598f, 0.32616964f, 
    0.34805268f, -0.00730769f, -0.07160746f, -0.01133001f, 0.04342074f, 0.12776910f, 0.01490334f, 0.14040110f, 
    -0.03411501f, -0.06029600f, -0.26067549f, 0.07173613f, -0.10573360f, 0.04443812f, 0.02352659f, 0.03911862f, 
    0.07488421f, -0.35464641f, -0.12898816f, -0.00155962f, -0.10170625f, 0.13524786f, 0.04828513f, -0.06016904f, 
    -0.03172379f, -0.14963904f, 0.16164069f, 0.05003867f, -0.06342018f, 0.09142681f, 0.03039776f, 0.26193455f, 
    -0.00910120f, -0.11880241f, -0.03064200f, -0.11206009f, -0.23344935f, -0.26677960f, 0.09655133f, 0.06001782f, 
    0.08404005f, -0.10644446f, 0.03786591f, -0.07509804f, 0.00643881f, 0.10397781f, 0.13483769f, 0.00836385f, 
    -0.03070557f, -0.10279256f, -0.03086778f, -0.10171188f, 0.15465967f, 0.06271727f, -0.01189821f, -0.20870325f, 
    0.07197828f, -0.06388844f, -0.06496743f, 0.09678099f, -0.02601856f, 0.09962740f, 0.12888013f, 0.11446193f, 
    -0.01545667f, -0.22763455f, 0.12241130f, -0.01687133f, -0.00610114f, 0.17698897f, -0.12436172f, 0.15919431f, 
    -0.04019652f, 0.19308707f, 0.09334211f, -0.19376132f, 0.06533420f, -0.07619552f, 0.05258597f, 0.05922362f, 
    -0.29615080f, -0.07778297f, -0.26443395f, 0.01949075f, 0.02707388f, 0.01661763f, -0.09025437f, -0.02518419f, 
    -0.06245628f, 0.38691655f, 0.22217453f, -0.13153897f, 0.06382193f, -0.12031486f, 0.06246596f, -0.02664625f, 
    -0.10577181f, 0.07440199f, 0.09174647f, 0.25941402f, 0.20670941f, -0.08540414f, -0.22600694f, 0.18114826f, 
    0.06691745f, 0.01931169f, 0.04193904f, -0.50366729f, -0.02331620f, 0.09973904f, -0.28305650f, 0.14172691f, 
    -0.19342516f, -0.07947162f, -0.06433368f, -0.03678709f, 0.09756488f, -0.00526318f, -0.08126429f, -0.17612147f, 
    0.13414799f, 0.04210906f, -0.09587308f, 0.13139284f, -0.08526012f, 0.05679901f, 0.12431759f, -0.03683597f, 
    0.04669174f, 0.01371158f, -0.06652573f, 0.08046315f, -0.02654344f, 0.03518255f, -0.34417906f, -0.01594248f, 
    -0.19521195f, 0.03226572f, 0.14633232f, -0.03066148f, -0.22656848f, 0.01719323f, 0.04432619f, -0.07901283f, 
    0.09550206f, 0.02179905f, 0.05541378f, -0.02897886f, -0.04504769f, -0.08254139f, -0.03739100f, 0.14713158f, 
    0.14989617f, -0.02925267f, 0.00477368f, 0.09602372f, 0.01852256f, 0.07695348f, -0.03844778f, -0.02004184f, 
    -0.00552803f, -0.14212148f, 0.29559880f, 0.04555009f, -0.07675660f, 0.07835197f, 0.06750666f, 0.07004090f, 
    -0.07924367f, -0.00992344f, 0.03421073f, 0.09712428f, 0.08825112f, -0.12708732f, -0.04700664f, 0.11758222f, 
    0.14079152f, 0.01106407f, 0.05760930f, -0.13113667f, -0.10798040f, -0.37148643f, 0.03867940f, -0.00325389f, 
    -0.07272313f, 0.02099330f, -0.01795075f, 0.08996794f, -0.34498355f, -0.08173579f, 0.10593849f, -0.02468581f, 
    0.22983272f, -0.05913389f, -0.10027657f, 0.12446740f, 0.03307503f, -0.22929807f, -0.15882312f, -0.12572888f, 
    0.02406536f, 0.02153163f, 0.07537965f, -0.04102318f, 0.00349840f, 0.04465597f, -0.27490756f, 0.10464133f, 
    -0.06365910f, 0.18354644f, 0.06761688f, -0.19442278f, 0.00772545f, 0.00273735f, -0.01227237f, 0.35580307f, 
    0.19526322f, -0.00884748f, 0.06140379f, 0.13854653f, -0.07526786f, 0.04931837f, 0.05614555f, -0.06525115f, 
    -0.03472486f, -0.02895084f, -0.05624241f, 0.02936326f, 0.05353484f, -0.01781514f, -0.03253222f, -0.13298503f, 
    -0.03689812f, 0.07433284f, 0.10228434f, -0.06874593f, -0.06434044f, 0.05677849f, 0.14055453f, 0.06585857f, 
    0.03081187f, -0.01035790f, 0.03120189f, 0.02057349f, 0.14952458f, 0.00656600f, -0.04224831f, -0.04092458f, 
    0.22912049f, 0.14992824f, 0.07293945f, 0.13575377f, -0.29889628f, 0.17957479f, -0.13421445f, -0.02143112f, 
    0.17072338f, 0.06530129f, -0.03638798f, 0.16093893f, 0.00648441f, 0.07093567f, 0.07195797f, -0.08490851f, 
    0.09210370f, -0.00918577f, 0.02516483f, 0.10318249f, -0.04744997f, 0.06140148f, 0.00873699f, -0.09684423f, 
    -0.03274623f, 0.09241091f, 0.03788751f, 0.09604923f, 0.02585048f, -0.05322440f, 0.02350053f, -0.14153966f, 
    0.05908762f, -0.05707615f, -0.12961547f, -0.14608879f, -0.06575206f, 0.04804981f, 0.08136065f, 0.40302822f, 
    0.04364161f, 0.02774177f, 0.08306471f, -0.04544874f, -0.02537004f, 0.12224720f, 0.06620446f, 0.08581004f, 
    0.28661263f, -0.09017099f, -0.24313115f, -0.10619185f, -0.12563547f, 0.02684589f, -0.02979883f, -0.09072656f, 
    -0.08557826f, 0.14131677f, -0.00952329f, -0.01212522f, -0.05798628f, 0.06098069f, -0.31191730f, -0.17296980f, 
    -0.13556971f, 0.13670073f, 0.22163227f, -0.02624269f, 0.04067644f, 0.02533499f, -0.00502409f, -0.10189397f, 
    -0.04920853f, -0.08902833f, -0.07480314f, 0.14176315f, 0.11890158f, -0.02359926f, -0.09225481f, 0.08037437f, 
    -0.17678583f, -0.02920820f, -0.01017456f, -0.06094946f, -0.12672222f, 0.07106850f, 0.12623425f, -0.06697408f, 
    0.06632068f, -0.00724624f, 0.02430645f, -0.01619259f, -0.01771038f, -0.03792787f, 0.06026257f, -0.27691975f, 
    -0.02940098f, 0.16544427f, 0.00895981f, -0.00573359f, 0.05460734f, 0.14903818f, -0.20660646f, -0.35815319f, 
    0.06887246f, -0.02936770f, 0.24607381f, 0.05052096f, -0.07097033f, 0.00216267f, -0.04642561f, 0.38636601f, 
    -0.15024357f, 0.02387840f, -0.15637632f, 0.03567827f, -0.05036307f, -0.00160865f, 0.03321079f, -0.01866200f, 
    -0.23696990f, 0.03406736f, 0.17150071f, -0.09682097f, 0.00273828f, -0.16669729f, -0.03299620f, 0.00423847f, 
    -0.02782097f, 0.32055950f, 0.09971962f, -0.11321264f, 0.04561826f, -0.23579662f, 0.09033579f, 0.14259315f, 
    0.10863798f, -0.14377259f, 0.30491167f, -0.50433844f, 0.08047936f, 0.03037619f, -0.00642925f, 0.13505532f, 
    -0.07070448f, -0.03089610f, -0.01033016f, -0.00056546f, -0.08010667f, 0.15371762f, -0.00440102f, 0.06655519f, 
    -0.03631910f, 0.11427517f, -0.13646916f, -0.06232810f, -0.13783474f, 0.08200221f, 0.13317420f, -0.12936337f, 
    0.26440033f, 0.07528095f, 0.06392866f, 0.01514667f, -0.02646166f, 0.12415197f, -0.16536446f, 0.11052036f, 
    0.24311310f, -0.01540742f, 0.01036354f, 0.01880992f, 0.09903045f, -0.14542904f, 0.06516717f, 0.02539555f, 
    0.06074180f, -0.15703294f, 0.02288789f, -0.10961477f, 0.08909918f, 0.02384185f, -0.14967890f, -0.29250190f, 
    -0.12605223f, 0.08584407f, 0.00027493f, 0.11135595f, -0.01286778f, 0.01780164f, 0.06590845f, -0.11509235f, 
    0.14776979f, -0.13024098f, 0.12137798f, 0.01273848f, 0.07781137f, -0.12464193f, 0.04566686f, 0.00361510f, 
    -0.09507411f, 0.25265434f, 0.12742335f, 0.13294695f, 0.09592558f, -0.01672117f, 0.06531432f, 0.06003423f, 
    0.07030950f, -0.01746297f, -0.01261123f, 0.11404670f, 0.16718344f, 0.05188761f, 0.15624179f, 0.17373593f, 
    -0.02595219f, 0.01900507f, 0.00566710f, 0.02915352f, 0.22843955f, 0.08125937f, -0.08582295f, -0.08240700f, 
    -0.09499379f, 0.08603117f, 0.13515939f, 0.02271937f, 0.26490244f, -0.29277924f, -0.01996402f, -0.12664160f, 
    0.09840429f, -0.02738534f, -0.11412300f, -0.09642658f, -0.02363339f, -0.33904392f, -0.09279323f, 0.05296039f, 
    -0.08026265f, 0.00974339f, 0.11588190f, 0.04496199f, -0.17091900f, 0.12033487f, -0.29218978f, 0.03953684f, 
    -0.17476833f, 0.18210934f, 0.07747738f, 0.11716788f, 0.05182008f, -0.01395264f, -0.17306849f, 0.38620144f, 
    -0.00022073f, 0.00095181f, 0.00185066f, 0.09390429f, -0.08771366f, -0.00203935f, 0.03212021f, 0.01817065f, 
    -0.01172745f, -0.03864606f, -0.04253823f, -0.04560306f, -0.02879009f, -0.04636293f, 0.01092429f, 0.03427378f, 
    0.04843555f, -0.05057103f, -0.04034520f, 0.02348638f, -0.03104649f, -0.06355402f, -0.06541390f, -0.05515325f, 
    0.04514128f, -0.00098840f, -0.02426633f, 0.00370488f, -0.04451986f, -0.03065819f, 0.03067897f, -0.04412290f, 
    -0.00277669f, -0.03788772f, 0.02355382f, -0.06505924f, -0.02655932f, 0.00604303f, -0.05985438f, -0.05478419f, 
    0.00294389f, -0.02836206f, -0.05180633f, -0.00292186f, -0.05747780f, 0.00335624f, 0.04047156f, 0.01201184f, 
    -0.02819214f, 0.04626651f, -0.05035824f, -0.01183909f, 0.00229411f, 0.00269564f, -0.04975314f, 0.03441364f, 
    0.01869915f, 0.04313236f, 0.00692340f, -0.03923211f, -0.01569667f, 0.02873516f, -0.02178260f, 0.00561430f, 
    -0.05651523f, -0.05207813f, -0.05126048f, -0.03185292f, -0.05793185f, 0.02263220f, 0.01483176f, -0.04452784f, 
    0.00334916f, 0.01459199f, -0.02520666f, -0.01338018f, -0.00206947f, -0.03910766f, -0.00922004f, -0.01422873f, 
    0.00210084f, -0.04388892f, -0.06290859f, -0.05510287f, 0.01331086f, -0.05728336f, -0.04985289f, -0.01895699f, 
    0.00926395f, 0.03042346f, -0.06196470f, -0.02860002f, -0.00471714f, -0.04963988f, -0.05262009f, 0.00546123f, 
    0.00180796f, 0.04013622f, -0.05141359f, 0.04261696f, 0.03272106f, -0.04164357f, 0.01325807f, -0.01580214f, 
    0.00667004f, -0.05217080f, -0.01678527f, -0.00069480f, 0.00385126f, -0.01873384f, 0.02395151f, -0.06031230f, 
    0.03227657f, 0.04467800f, 0.01739857f, -0.06411323f, -0.00628154f, 0.04766067f, -0.02059631f, 0.02473905f, 
    -0.04647051f, -0.04253284f, 0.03217481f, 0.05766761f, 0.04597217f, 0.04841236f, -0.00853116f, 0.01373481f, 
    -0.01565457f, -0.00915300f, -0.00197164f, 0.01451604f, 0.01233726f, 0.04983982f, -0.04125439f, 0.04052714f, 
    0.02393073f, 0.02313272f, -0.03016867f, 0.03267536f, 0.02690916f, -0.06192042f, -0.04160737f, -0.00272115f, 
    0.00498104f, -0.00689518f, 0.03041900f, 0.01948323f, 0.04963841f, -0.06151254f, 0.02126863f, 0.01435244f, 
    -0.05655452f, -0.03585250f, 0.02223406f, 0.02974728f, -0.01420893f, 0.03247371f, 0.00217267f, -0.04669560f, 
    -0.01081582f, -0.01499531f, 0.04217366f, -0.04994752f, 0.02915376f, -0.02279932f, 0.04596198f, -0.02969549f, 
    -0.04718174f, -0.00212999f, 0.02933452f, 0.02629395f, 0.04120974f, 0.02464030f, 0.00129932f, -0.04149676f, 
    -0.02094805f, 0.02438036f, 0.02242961f, -0.05162998f, 0.03017023f, 0.04417949f, 0.03387611f, -0.02307950f, 
    -0.02081988f, -0.00914484f, 0.05127744f, -0.03847112f, -0.03566867f, -0.01072467f, 0.02088329f, 0.01786827f, 
    -0.00165600f, 0.03482461f, 0.00967358f, -0.01467918f, -0.03515771f, 0.04962572f, -0.01704365f, -0.01022206f, 
    0.03032971f, -0.05427786f, 0.03121272f, -0.00536365f, -0.00089408f, -0.02673102f, -0.03945930f, -0.03972788f, 
    -0.06057320f, -0.04618840f, 0.02079906f, -0.01534164f, -0.05494541f, 0.01810425f, 0.02238861f, -0.04102960f, 
    0.01975933f, 0.05117397f, 0.04559778f, 0.03706311f, -0.04254176f, 0.01511167f, -0.05268031f, 0.05119270f, 
    -0.05622754f, -0.07199872f, -0.06092104f, -0.04528156f, -0.02063445f, 0.03850789f, 0.01874607f, 0.03468826f, 
    0.02864672f, 0.02210616f, 0.03432988f, -0.01990861f, 0.00460794f, -0.06229174f, 0.02168514f, 0.02954680f, 
    -0.04161457f, -0.00359108f, -0.00634081f, -0.01451740f, 0.02920420f, -0.05303298f, -0.06165298f, -0.04124432f, 
    -0.03801836f, -0.04969635f, 0.02263084f, 0.00504857f, -0.02815360f, 0.02298545f, 0.04888912f, 0.02547342f, 
    -0.05517435f, -0.05500387f, -0.03766587f, -0.03325630f, 0.02948053f, -0.04406591f, 0.04332348f, -0.03737660f, 
    0.04940065f, 0.04745207f, 0.00519318f, -0.03648854f, -0.02913217f, 0.04552449f, -0.06752463f, -0.03073700f, 
    -0.06390082f, 0.04457319f, 0.02172338f, -0.06247282f, -0.04949168f, -0.01287960f, 0.01748189f, 0.02029864f, 
    -0.00598632f, -0.00295660f, 0.04774622f, -0.01390846f, 0.05396195f, -0.05610118f, 0.05118179f, 0.00434365f, 
    -0.03407685f, 0.00766474f, 0.03838872f, 0.02325221f, -0.06237020f, -0.00500058f, -0.05153470f, 0.02875940f, 
    0.15542072f, 0.05824180f, 0.10958381f, 0.03505608f, -0.05153985f, 0.18514453f, 0.18880923f, 0.15869322f, 
    0.12705742f, -0.01055212f, -0.17847466f, -0.24053265f, 0.04831949f, 0.15376441f, -0.09838048f, -0.17043856f, 
    -0.08242420f, 0.09814139f, -0.02079244f, 0.11723666f, -0.06003158f, 0.17378980f, -0.21717575f, 0.03181084f, 
    0.10227747f, 0.00808787f, 0.06973207f, 0.21781380f, 0.10472218f, -0.48963532f, 0.05231539f, 0.02074705f, 
    -0.16628048f, 0.06922728f, -0.01152913f, -0.08370059f, 0.03183983f, -0.05616921f, -0.06089564f, -0.03277254f, 
    0.02795027f, -0.07085714f, 0.28665975f, -0.01638341f, -0.34569553f, -0.32401809f, 0.11023445f, -0.23951997f, 
    -0.03304698f, 0.01229442f, 0.00187193f, 0.00302507f, -0.08639791f, -0.10328893f, 0.01209774f, -0.36671042f, 
    -0.25234184f, -0.08828710f, 0.09001957f, 0.12179030f, 0.03715416f, -0.05609710f, -0.07223358f, 0.13403209f, 
    0.26327431f, -0.23912786f, 0.02806107f, 0.01780646f, -0.03095772f, -0.04147942f, -0.14240009f, -0.10793260f, 
    -0.27521372f, 0.29107803f, -0.06406937f, 0.11950286f, 0.07934210f, -0.03374133f, 0.00249816f, -0.00974511f, 
    0.07266971f, 0.05956709f, -0.06760519f, -0.05734162f, 0.01484156f, 0.06773307f, 0.18118870f, 0.04998478f, 
    -0.32863221f, 0.15365648f, -0.08262827f, -0.12689370f, -0.05777984f, 0.07280149f, 0.21832636f, 0.11240248f, 
    -0.01683298f, 0.01412340f, -0.14395346f, 0.08350471f, -0.16190115f, -0.11004883f, 0.15845016f, 0.07250361f, 
    0.24448778f, 0.14747265f, -0.09785675f, 0.02781704f, 0.13028836f, -0.00580192f, 0.02335584f, 0.08058459f, 
    0.02589773f, -0.05794902f, 0.03375475f, 0.13741396f, 0.06451371f, 0.05204800f, 0.16185863f, 0.00096838f, 
    -0.06415614f, -0.07192086f, -0.12209585f, 0.06496456f, 0.06970814f, 0.13225244f, 0.05312929f, -0.11113585f, 
    0.03413204f, 0.05242131f, 0.13800032f, -0.03976211f, 0.22796474f, 0.14658478f, -0.15781818f, -0.22478779f, 
    -0.03173711f, -0.20936972f, 0.06830213f, 0.02075313f, 0.02602832f, 0.07870841f, -0.04522109f, -0.12697366f, 
    0.22314757f, 0.11063429f, -0.02282164f, 0.14063841f, -0.37016600f, 0.08989040f, 0.02479071f, 0.04709361f, 
    0.17860661f, -0.09472626f, 0.25445122f, -0.27571914f, -0.03616123f, -0.01688130f, -0.10682758f, -0.08867183f, 
    -0.07402858f, -0.07629182f, -0.18867382f, 0.22439502f, -0.12671892f, -0.08391823f, -0.01464349f, -0.01748750f, 
    0.05558889f, -0.02208521f, -0.03871867f, -0.12808244f, -0.18203954f, 0.33367991f, -0.30067098f, 0.07249259f, 
    0.02008241f, 0.02164931f, 0.01771276f, 0.03443684f, -0.04379066f, 0.00407150f, 0.11384520f, 0.08567742f, 
    -0.15732656f, -0.09480613f, -0.01509915f, 0.11020471f, 0.09853745f, 0.00058418f, -0.24609223f, -0.09595248f, 
    0.01487107f, 0.16925953f, 0.11285823f, 0.08329343f, -0.16796373f, 0.26195151f, 0.01516230f, 0.01813706f, 
    -0.28774965f, 0.03621491f, 0.06659304f, 0.15583269f, -0.11475544f, 0.14284408f, 0.13001743f, 0.04809030f, 
    -0.01970846f, 0.20809342f, -0.13145024f, 0.09747488f, -0.10031994f, 0.17346741f, 0.03104596f, 0.05712134f, 
    0.01437332f, -0.21962640f, 0.20046130f, 0.16505840f, 0.01698898f, 0.18695699f, 0.13090347f, -0.05959338f, 
    -0.23433119f, -0.30971006f, 0.14445974f, 0.15157628f, 0.09735472f, 0.08397841f, -0.12689447f, -0.12467004f, 
    -0.04538686f, 0.06152194f, -0.02004687f, 0.11648398f, -0.10978495f, 0.04263938f, -0.08482728f, 0.00303606f, 
    0.02872960f, 0.08813677f, 0.04872700f, -0.09768534f, -0.10230774f, -0.02488569f, 0.03867126f, -0.05997254f, 
    0.05868318f, -0.02376581f, 0.22209726f, 0.09401809f, -0.30485043f, -0.36657438f, 0.26599646f, 0.04372862f, 
    0.13005291f, 0.16865110f, -0.01232051f, -0.05641159f, -0.06636231f, 0.05696376f, -0.15226355f, -0.07764103f, 
    -0.07280509f, 0.13320778f, 0.12796259f, -0.00251344f, -0.30048263f, 0.14418569f, -0.31256226f, 0.26761639f, 
    0.00279226f, -0.06679521f, -0.00568858f, -0.11325022f, 0.23168617f, -0.02634270f, 0.13341257f, 0.13596542f, 
    0.19436090f, -0.14438066f, -0.01355714f, 0.07219159f, -0.01684062f, 0.09796577f, -0.02477396f, -0.04296223f, 
    0.00399850f, 0.05023533f, -0.00105096f, 0.01356960f, 0.03525759f, -0.04113416f, 0.02622022f, -0.03528367f, 
    -0.04027557f, -0.04641524f, 0.04020955f, -0.02567439f, -0.04395039f, 0.00691679f, 0.00361451f, -0.05404798f, 
    -0.06510361f, -0.01942785f, -0.03865280f, 0.02173234f, 0.03938115f, 0.02449612f, -0.03989927f, -0.06382263f, 
    -0.06404171f, 0.01475703f, -0.03389346f, 0.00567061f, 0.02758139f, 0.02226180f, 0.02188597f, -0.04956772f, 
    0.04643656f, -0.01014522f, -0.03415892f, 0.02339212f, 0.03967791f, 0.03588172f, 0.01844021f, -0.03532354f, 
    -0.05266644f, -0.00064011f, 0.00544320f, -0.02625132f, -0.01456726f, -0.01168508f, 0.02716223f, -0.00097741f, 
    -0.02921586f, -0.02513787f, 0.03809084f, -0.06181023f, -0.03956823f, -0.05279087f, -0.04512049f, -0.03768526f, 
    -0.05444963f, 0.04852267f, -0.02163594f, -0.02746645f, 0.04475006f, -0.00673563f, 0.02530410f, 0.03190231f, 
    -0.05312865f, 0.04184931f, 0.04055477f, -0.03228129f, -0.00744784f, 0.00621200f, 0.00340618f, 0.00188987f, 
    0.04162099f, 0.03486325f, 0.02206314f, -0.00986211f, -0.04642005f, -0.04599279f, -0.01847388f, -0.01877717f, 
    -0.01630258f, -0.00724479f, 0.02900278f, 0.01016910f, -0.05368482f, -0.05893279f, -0.02859638f, -0.00180416f, 
    -0.02332767f, -0.01188698f, 0.02890110f, -0.05849482f, 0.02566315f, 0.01126930f, -0.05547803f, -0.00027110f, 
    0.01842944f, -0.00902826f, 0.03676255f, 0.03252297f, -0.04369486f, 0.04174468f, -0.04494508f, -0.03162356f, 
    -0.04808509f, -0.01176650f, -0.06484937f, -0.05934503f, -0.04633359f, 0.04952957f, -0.02046472f, -0.05748319f, 
    0.04091345f, 0.03536231f, 0.04526716f, -0.03271377f, -0.03472996f, 0.03754961f, -0.00149197f, -0.02303311f, 
    0.03816384f, -0.00724367f, 0.00613151f, 0.02084287f, -0.05344040f, 0.03731963f, -0.03541863f, -0.04676895f, 
    -0.04266680f, -0.00039210f, -0.02442666f, 0.02447382f, 0.04477100f, -0.01660962f, 0.01131774f, 0.02914147f, 
    0.03757467f, 0.03394376f, -0.06380673f, -0.02988644f, 0.03249318f, -0.03365900f, -0.01727240f, 0.03009726f, 
    -0.03714933f, 0.01796893f, -0.06008366f, -0.00612975f, -0.00520290f, -0.00943611f, 0.04155815f, 0.02961828f, 
    -0.01617606f, 0.01985017f, 0.00587056f, -0.00878932f, -0.02462591f, 0.00497390f, -0.02509199f, -0.04643334f, 
    -0.01553376f, -0.05347747f, -0.02703863f, -0.06579883f, -0.02335151f, -0.04746404f, 0.04740541f, 0.03634281f, 
    0.02091773f, -0.00927553f, 0.04480726f, 0.02314408f, 0.03959697f, 0.00227446f, -0.01639453f, -0.03570502f, 
    0.00296401f, 0.05326435f, -0.05002928f, -0.02469992f, -0.06462334f, 0.01213775f, -0.01201383f, 0.01182766f, 
    -0.01223294f, 0.04171414f, 0.04375142f, -0.04277617f, -0.02808464f, 0.01532543f, 0.04383043f, -0.06209188f, 
    0.04784936f, -0.05592815f, -0.05713992f, -0.01417342f, -0.06393114f, 0.04302480f, 0.04389720f, 0.01413679f, 
    -0.03202304f, -0.02429438f, 0.01600068f, -0.05641172f, -0.03177361f, -0.05478982f, -0.06013238f, 0.04180660f, 
    0.04502424f, -0.05535333f, -0.03295046f, 0.02100483f, -0.02930964f, 0.02393831f, -0.05159196f, 0.01256571f, 
    0.02039894f, 0.04620814f, 0.00242987f, -0.05256451f, 0.00774744f, -0.00323398f, -0.03517756f, -0.05778487f, 
    -0.05482307f, -0.00747752f, 0.01763307f, 0.00653882f, -0.04784244f, -0.06526002f, 0.01632144f, 0.01143361f, 
    -0.01063122f, 0.01080649f, -0.00226870f, 0.03541255f, 0.00224686f, -0.05862483f, -0.00341468f, 0.02082947f, 
    0.01263465f, -0.03204356f, -0.06299362f, 0.01814889f, 0.00785986f, -0.02978154f, 0.03948356f, 0.00093760f, 
    -0.04516057f, -0.05511112f, -0.05795214f, -0.00322642f, 0.03915442f, 0.01974164f, -0.03543245f, -0.05074195f, 
    -0.04651218f, 0.04468317f, 0.01854575f, 0.00172149f, 0.01369712f, -0.06794744f, 0.00322655f, -0.05628498f, 
    -0.04456468f, -0.04439672f, -0.00166680f, 0.00584470f, 0.03839162f, -0.04366704f, -0.04019569f, 0.04219764f, 
    0.02366440f, -0.01024605f, 0.00104563f, -0.03861585f, -0.00325729f, 0.03566301f, 0.05009800f, 0.04073651f, 
    -0.02329733f, -0.03369829f, 0.03237997f, -0.03607912f, -0.01149560f, -0.00738187f, 0.02349907f, 0.02005716f, 
    -0.32106388f, 0.18851870f, 0.16730846f, 0.10995525f, 0.01073448f, 0.06009208f, 0.06300573f, 0.10503771f, 
    0.01377939f, -0.02616038f, -0.31319785f, -0.10162805f, 0.09224643f, 0.06793065f, 0.02934612f, -0.12051354f, 
    0.00940467f, 0.05218988f, -0.20496830f, -0.05050423f, 0.07263022f, 0.13779615f, -0.02640883f, 0.05705237f, 
    -0.10729819f, -0.13051806f, -0.02054803f, 0.05677798f, 0.15789945f, -0.00599180f, -0.22406954f, 0.10609071f, 
    -0.23794194f, -0.19951715f, 0.03649840f, -0.06608529f, -0.10108609f, -0.18000074f, -0.18103851f, -0.05731734f, 
    0.14793251f, -0.07580400f, -0.01964871f, -0.10213885f, -0.18985842f, 0.23006660f, -0.18521667f, 0.21410638f, 
    -0.06777819f, -0.10584076f, -0.01046508f, 0.06078513f, -0.05217324f, 0.11709960f, 0.11915587f, 0.07889393f, 
    -0.18831992f, -0.11171361f, 0.03073404f, 0.11123025f, 0.10815428f, 0.05306106f, -0.22083093f, 0.09518186f, 
    0.09470074f, 0.02842050f, -0.23872672f, -0.03905788f, -0.09152534f, -0.03144877f, -0.00201983f, -0.00600230f, 
    0.21292709f, 0.08062196f, -0.09310253f, 0.04833457f, 0.01896770f, 0.05436582f, 0.03568726f, -0.00337931f, 
    -0.00434928f, 0.36441368f, 0.02490635f, -0.03926001f, 0.04664253f, -0.04658604f, 0.18260486f, -0.17476030f, 
    0.08920474f, 0.02428047f, -0.15001248f, -0.12372717f, -0.28812817f, 0.01351486f, 0.27036908f, 0.02087834f, 
    -0.02971167f, 0.01606358f, 0.17709269f, 0.35128090f, 0.35204646f, -0.08299673f, 0.01266991f, 0.11658453f, 
    0.20461191f, 0.05418923f, 0.02223189f, -0.06770221f, -0.31215683f, -0.08433400f, 0.05380641f, 0.10575543f, 
    0.16192204f, -0.05884272f, 0.15139681f, 0.05591028f, 0.15615812f, 0.06532661f, -0.22948934f, -0.02222175f, 
    -0.02649125f, 0.04333702f, -0.16554376f, 0.04839212f, 0.11341105f, 0.15738812f, 0.00606504f, 0.16698503f, 
    -0.01389893f, 0.00827357f, 0.04313903f, -0.02811926f, 0.02971189f, 0.02925790f, 0.09378769f, 0.04138701f, 
    -0.10751259f, -0.05043182f, -0.09793478f, 0.01947690f, -0.05987958f, 0.00392982f, -0.00426464f, -0.18696548f, 
    -0.32697660f, -0.07199349f, 0.15238725f, 0.21546124f, 0.13338310f, 0.02251470f, -0.05492843f, 0.04856271f, 
    -0.01833570f, 0.16181804f, 0.07291073f, -0.02105173f, -0.11734489f, 0.20234732f, -0.06201280f, 0.04789590f, 
    -0.03731563f, -0.02757552f, 0.01895892f, 0.11981170f, -0.10997996f, -0.28658441f, 0.09843244f, 0.13997871f, 
    -0.02891487f, 0.19535072f, -0.12336124f, -0.11351284f, -0.03075805f, -0.22819437f, -0.04386629f, -0.05201748f, 
    -0.05186077f, 0.16238466f, 0.06023026f, 0.14454255f, -0.10736269f, -0.04839859f, -0.05093289f, 0.29223749f, 
    -0.03424517f, -0.09922674f, -0.01297466f, -0.04652278f, 0.02692750f, 0.02058335f, 0.03951036f, 0.14322925f, 
    -0.05422647f, 0.03723742f, 0.07264878f, 0.03348896f, -0.02534732f, 0.14526328f, 0.12316279f, 0.10101756f, 
    -0.02948515f, 0.11422760f, 0.05011160f, 0.11451798f, 0.02808159f, -0.09514577f, 0.02303864f, -0.32424346f, 
    -0.12157768f, 0.06830729f, 0.08393642f, -0.06280969f, -0.09314818f, 0.03508172f, 0.04901595f, 0.07982348f, 
    -0.16759273f, -0.16944264f, -0.31478566f, 0.00427902f, 0.05379555f, 0.07290047f, 0.00184280f, -0.01572411f, 
    -0.09330028f, 0.04305430f, 0.16043599f, -0.05614315f, -0.00208370f, -0.03657594f, -0.03696834f, 0.02347849f, 
    -0.00931695f, 0.06518887f, -0.21060190f, -0.23060498f, 0.03791336f, 0.12267990f, -0.08847490f, 0.01262006f, 
    0.08140729f, -0.15572476f, 0.15403385f, 0.11204376f, -0.00655457f, -0.26518556f, 0.08702163f, 0.13360813f, 
    0.05616874f, -0.13038041f, 0.02769944f, 0.08746664f, 0.06434426f, -0.19175805f, -0.19996192f, 0.12015890f, 
    0.03121167f, 0.22542161f, 0.06603061f, -0.10979903f, 0.01923121f, -0.11021480f, -0.09720964f, -0.30461422f, 
    0.10081461f, 0.09761669f, 0.05880685f, -0.16313137f, 0.18496381f, -0.10750822f, -0.12905495f, 0.22195685f, 
    0.25369874f, 0.03999211f, -0.02180696f, -0.13775137f, 0.02406851f, 0.03200714f, -0.01588770f, 0.32695571f, 
    0.12830016f, 0.07137182f, -0.08013152f, -0.03803237f, -0.12304065f, 0.21262173f, -0.02337390f, 0.02523215f, 
    -0.08944231f, 0.22440603f, -0.02441197f, 0.16214593f, -0.14884588f, -0.08062335f, 0.07572712f, 0.04573354f, 
    -0.00442371f, 0.03383366f, -0.19739752f, 0.09486863f, 0.10686214f, -0.09019566f, 0.05060012f, -0.27763659f, 
    -0.04192878f, -0.04165930f, 0.18060133f, 0.08210168f, 0.00236468f, 0.07738377f, 0.06902034f, 0.04590903f, 
    0.13569765f, -0.09897862f, -0.14493541f, 0.02495977f, -0.11097720f, 0.13422227f, -0.10774893f, 0.00802800f, 
    -0.02956034f, -0.01521811f, 0.07609446f, 0.03529478f, -0.17710277f, 0.15697099f, -0.00800750f, -0.03543324f, 
    -0.12572144f, 0.05756512f, -0.19467881f, -0.00352017f, 0.21544260f, 0.09717555f, -0.11734887f, 0.12441678f, 
    -0.08205071f, -0.12465061f, -0.00281655f, -0.10075718f, -0.01119772f, -0.05567062f, 0.19136921f, 0.05134933f, 
    -0.02727078f, -0.09406994f, -0.18814316f, -0.05207002f, 0.00328489f, 0.01865682f, -0.15857744f, 0.19280213f, 
    -0.00500221f, 0.16801833f, -0.13590187f, -0.17767788f, -0.02591848f, 0.06166688f, 0.02967006f, -0.01240569f, 
    0.20043550f, 0.01849189f, 0.04679844f, -0.16862978f, 0.01084240f, -0.13436195f, -0.04770975f, 0.16316798f, 
    0.06177399f, 0.26348627f, 0.13316658f, 0.06410969f, 0.20034754f, 0.01788007f, -0.07900687f, -0.06255537f, 
    0.13833925f, -0.03309912f, 0.02907605f, -0.07826409f, -0.10440391f, 0.14206459f, -0.07161167f, -0.02700838f, 
    0.13547882f, 0.02684525f, 0.08255459f, 0.16075633f, 0.31862038f, -0.15931700f, 0.04384462f, 0.07692861f, 
    0.08508132f, 0.01336343f, 0.14473625f, 0.05955752f, -0.17766620f, -0.10026963f, -0.05536735f, 0.02600207f, 
    0.02018338f, 0.19911322f, -0.06231973f, 0.02172300f, -0.02249063f, -0.10458864f, -0.14773588f, 0.19467443f, 
    0.03437981f, 0.01680257f, 0.06971436f, -0.08191540f, 0.05172720f, -0.12597863f, -0.00724053f, -0.17726471f, 
    0.17130528f, -0.09450090f, 0.09820741f, -0.03262187f, -0.13259940f, -0.00012810f, 0.00770945f, 0.10184798f, 
    0.05306371f, -0.03025813f, -0.28896183f, 0.04348730f, 0.02055475f, -0.09236587f, 0.07802108f, -0.00232870f, 
    -0.02325371f, 0.06779872f, -0.04386781f, 0.19580811f, 0.08275048f, 0.13064143f, -0.03002670f, 0.06937400f, 
    -0.06099919f, 0.09253240f, 0.10434861f, 0.06453868f, -0.37477633f, -0.07594410f, -0.10706528f, -0.00748488f, 
    0.03111521f, -0.09222903f, 0.03037738f, -0.16754517f, 0.06356739f, -0.14307646f, -0.11650653f, -0.12381905f, 
    -0.17354220f, 0.06486137f, -0.05640450f, 0.23782669f, 0.00666433f, -0.10666155f, -0.29854852f, -0.06329221f, 
    0.02744253f, -0.06331271f, 0.12680383f, -0.02181878f, -0.20210034f, -0.08150227f, -0.07893188f, -0.01704115f, 
    0.14017543f, 0.05379190f, 0.02509228f, -0.13982368f, -0.00232330f, 0.12319712f, 0.02458171f, 0.09218453f, 
    -0.00695955f, -0.10429194f, -0.11224166f, 0.13142294f, 0.15721047f, -0.18102042f, 0.40165442f, 0.16084741f, 
    -0.04874485f, 0.15488921f, 0.07945260f, 0.12360436f, -0.11888837f, -0.16893291f, -0.06410330f, -0.32523584f, 
    -0.22563016f, -0.04356612f, -0.06254735f, 0.07493334f, 0.16729416f, -0.03453253f, 0.03494256f, -0.03714533f, 
    -0.17543532f, -0.04745177f, -0.04204417f, 0.05580226f, 0.04181866f, -0.10174383f, -0.13147721f, -0.01022074f, 
    0.01861266f, 0.35637373f, -0.05694577f, 0.13644050f, -0.29207718f, -0.07613860f, -0.03567961f, 0.14009696f, 
    -0.03921871f, -0.05277511f, -0.18468943f, -0.08773931f, -0.06066134f, 0.10404626f, 0.18022174f, 0.10917667f, 
    0.01000414f, -0.11753619f, 0.01904766f, 0.07066312f, 0.05202526f, 0.09006742f, 0.07392901f, -0.05387508f, 
    0.04316074f, 0.15118399f, -0.03861873f, -0.06647737f, 0.22815090f, 0.01931576f, -0.04831569f, 0.04467111f, 
    0.03341373f, 0.09418231f, 0.13222492f, 0.03997726f, 0.08410718f, -0.12173636f, -0.10957691f, 0.02833487f, 
    0.05881999f, -0.14001343f, -0.06298685f, 0.12430091f, 0.01664595f, -0.02090829f, 0.05449504f, -0.04174465f, 
    0.18915701f, -0.18133628f, -0.05117700f, -0.06738055f, 0.02833462f, 0.01974111f, -0.10893653f, 0.23639388f, 
    0.01305239f, 0.15552086f, -0.10632807f, -0.05569275f, 0.03431254f, 0.08321409f, 0.03902538f, 0.11611270f, 
    -0.00225193f, 0.01984607f, -0.02234091f, -0.14188580f, -0.05945863f, -0.03477930f, -0.14200525f, 0.01160761f, 
    0.01129659f, -0.19010730f, 0.05358029f, 0.18425339f, 0.08349367f, -0.00580310f, 0.07576583f, -0.03654039f, 
    0.07330202f, -0.01706453f, -0.12537709f, 0.03217542f, 0.07900247f, -0.04391538f, -0.10585037f, -0.05145568f, 
    0.07709504f, 0.01641526f, -0.00501700f, 0.30047712f, 0.15730186f, 0.09531780f, 0.29972529f, 0.03895783f, 
    -0.02176838f, 0.12181675f, -0.00962920f, 0.10141497f, 0.02309015f, 0.04913761f, 0.05948519f, 0.21885756f, 
    -0.00998112f, 0.00156846f, -0.10978511f, 0.04882938f, 0.12192848f, 0.17607626f, 0.06728540f, 0.25855348f, 
    -0.14040691f, 0.04815419f, -0.09356502f, 0.13993309f, 0.12563314f, -0.01963950f, 0.16216017f, -0.00429099f, 
    0.09049819f, 0.01941752f, 0.02076153f, 0.06508668f, -0.14132769f, 0.03861554f, -0.00219562f, 0.05975333f, 
    0.09825505f, 0.10055791f, 0.13094346f, 0.06704623f, 0.06527763f, 0.03663477f, 0.00815866f, -0.01448142f, 
    -0.00560456f, -0.06375582f, 0.03585059f, -0.06617523f, -0.11395799f, 0.00484293f, 0.04709550f, -0.01795180f, 
    0.01666341f, -0.24769716f, -0.18053697f, 0.12370106f, -0.02359521f, -0.09508287f, -0.07559480f, -0.14522785f, 
    -0.05115801f, 0.03902389f, -0.16749114f, -0.01391157f, 0.18675594f, -0.01085984f, 0.18623851f, 0.12501499f, 
    -0.23994963f, -0.01987795f, -0.05118695f, -0.04290039f, -0.21957053f, 0.04165539f, 0.08569551f, 0.01046507f, 
    -0.10476078f, -0.11679370f, -0.00409272f, -0.02868106f, -0.14479870f, -0.23560680f, 0.08861883f, -0.04324942f, 
    -0.05357390f, -0.03535890f, 0.06360796f, -0.05388473f, 0.00391462f, 0.12219912f, 0.00024526f, 0.17055789f, 
    0.01373650f, -0.05367604f, -0.05000702f, 0.07050712f, 0.12840959f, -0.01031443f, 0.09053189f, 0.09492314f, 
    0.25509578f, -0.08424982f, 0.10273657f, -0.06028741f, 0.04471736f, 0.04545565f, 0.01896858f, 0.15254860f, 
    0.00880765f, 0.26199248f, 0.15930673f, 0.04274548f, 0.01921230f, -0.05341208f, 0.01231811f, 0.13909106f, 
    -0.12943643f, -0.05904638f, -0.06920762f, -0.10629846f, -0.16355900f, -0.05859141f, 0.00136102f, 0.02524294f, 
    -0.11548197f, 0.03664244f, -0.14602582f, 0.09602671f, 0.06058611f, -0.01450626f, -0.01567066f, -0.06031046f, 
    0.01216173f, 0.12545851f, 0.13578722f, 0.11752054f, 0.39099020f, 0.19089051f, 0.05704667f, 0.22262107f, 
    0.04091097f, 0.04957950f, 0.05222408f, -0.15201561f, 0.01214106f, 0.02941900f, -0.05992903f, 0.00195129f, 
    -0.05068135f, 0.05471336f, -0.01823484f, -0.04967207f, 0.12211833f, 0.07217719f, 0.01081795f, -0.08989086f, 
    0.06611772f, -0.09204260f, 0.13817182f, 0.06050619f, 0.07956702f, 0.09064241f, -0.16134144f, 0.05386940f, 
    0.03246230f, 0.05207039f, -0.06187604f, -0.09888399f, 0.03853734f, -0.01457740f, -0.14364387f, -0.05707448f, 
    -0.00418166f, -0.10149875f, -0.07733944f, 0.05833066f, -0.11913823f, 0.03847778f, 0.00297234f, -0.04652310f, 
    -0.10604884f, 0.20288719f, 0.00236040f, 0.05853637f, 0.02208981f, 0.19099864f, 0.09712982f, -0.08646221f, 
    -0.01950000f, 0.06662823f, 0.22310908f, 0.27706298f, -0.02658724f, 0.09959807f, -0.17363118f, 0.05167501f, 
    -0.07498316f, 0.11784302f, 0.09342414f, 0.00048216f, -0.02309925f, 0.03953516f, 0.00717703f, 0.00606851f, 
    -0.00625652f, -0.00376062f, -0.08761247f, -0.08883468f, 0.13026875f, 0.04288434f, -0.05042545f, -0.06177338f, 
    0.07362986f, -0.01675730f, 0.03958949f, 0.01689173f, -0.09492702f, -0.05393545f, -0.08278368f, -0.09459658f, 
    0.11378621f, -0.13922074f, 0.10217961f, -0.09821790f, 0.31390268f, 0.11338212f, 0.05640174f, -0.08945142f, 
    0.02234551f, 0.04679258f, -0.25190833f, -0.02345378f, -0.03326448f, 0.10660695f, 0.06707536f, 0.23568554f, 
    -0.14714508f, 0.00264155f, 0.10137291f, 0.00893019f, 0.07448758f, -0.20446129f, -0.08978698f, -0.05481715f, 
    -0.11337390f, 0.08268894f, -0.08819608f, -0.04289569f, 0.12392448f, -0.05579737f, -0.02380465f, -0.03947350f, 
    0.06638537f, 0.18114935f, -0.12620063f, 0.04171624f, -0.01017090f, -0.02154701f, 0.08508393f, 0.05658524f, 
    -0.02148759f, 0.03700860f, -0.25108007f, 0.18847886f, -0.05325347f, 0.00368462f, -0.14594682f, 0.08022301f, 
    -0.04243191f, 0.09535076f, -0.01270199f, -0.00665733f, 0.11460759f, 0.02029658f, -0.11313235f, 0.11431269f, 
    -0.07330184f, 0.00057161f, 0.34237748f, 0.29905400f, -0.34269810f, 0.11226326f, 0.06433817f, -0.02322231f, 
    0.09201428f, 0.03935141f, 0.09815123f, 0.23994306f, -0.00540377f, 0.09303367f, -0.05589587f, 0.18990546f, 
    -0.00982689f, -0.05452024f, 0.04688142f, 0.01621223f, -0.23179948f, 0.10921505f, -0.17637536f, -0.00274331f, 
    -0.10886524f, -0.06941967f, -0.19022904f, -0.05826057f, -0.05944684f, -0.03192608f, 0.01700411f, 0.06810765f, 
    0.19870256f, 0.11223401f, -0.08971915f, 0.14596669f, 0.18709184f, 0.07343069f, -0.08996666f, -0.06680111f, 
    -0.16885144f, -0.16647859f, 0.01169113f, 0.01809372f, 0.03425897f, -0.07353177f, -0.20142286f, -0.04947099f, 
    0.01558870f, 0.03431143f, 0.10266583f, 0.09503214f, 0.11194757f, -0.14787412f, 0.06701913f, 0.01694675f, 
    -0.26181027f, 0.14173937f, 0.01633653f, -0.06861122f, 0.08672008f, -0.04070949f, 0.04237711f, 0.03100840f, 
    0.11152915f, 0.20808659f, 0.05525656f, 0.04721428f, 0.11780082f, -0.02503056f, 0.20765923f, 0.03976246f, 
    -0.09832571f, -0.09709963f, -0.17319164f, -0.13159347f, -0.10797209f, -0.12778956f, -0.05722310f, -0.11275768f, 
    -0.00794390f, 0.09796350f, 0.04627850f, 0.10201176f, 0.16776618f, -0.30169788f, 0.03990053f, -0.04380325f, 
    0.01258718f, 0.02395713f, -0.09702705f, -0.13567811f, 0.37133807f, -0.15945272f, 0.06832693f, -0.05409611f, 
    -0.00091430f, 0.08489673f, 0.01819412f, -0.10512001f, 0.04025567f, -0.13186011f, -0.02653023f, 0.05840952f, 
    -0.04940411f, 0.08185817f, -0.03950791f, -0.21523000f, -0.03964094f, 0.06301232f, 0.13564996f, -0.00433278f, 
    0.01498260f, 0.13090487f, 0.02361792f, -0.09962690f, -0.13250911f, -0.01235907f, 0.03019192f, -0.17878678f, 
    0.26904652f, -0.04608956f, 0.00198922f, -0.11497404f, -0.06696825f, 0.00366640f, -0.07257541f, 0.04142047f, 
    0.38843989f, 0.14344496f, -0.07187041f, 0.08233173f, -0.03622303f, 0.02595809f, 0.10489868f, 0.04957201f, 
    0.18329678f, -0.42445999f, 0.12659872f, -0.04336328f, 0.09080377f, -0.00015167f, 0.06637006f, -0.16675580f, 
    0.00022082f, 0.06062740f, 0.09976117f, 0.15669255f, -0.06914505f, 0.01733836f, 0.00832428f, 0.11412876f, 
    -0.05611233f, 0.04956501f, 0.04297991f, 0.25525868f, 0.10455169f, -0.14200045f, 0.02283154f, -0.00553783f, 
    0.21861008f, -0.06934451f, 0.05195205f, 0.08671708f, 0.20705564f, -0.56110740f, -0.09797230f, 0.22243111f, 
    0.07576223f, -0.06314092f, -0.16541971f, 0.10865699f, -0.12265959f, 0.10851976f, -0.11655083f, -0.12052482f, 
    0.01532116f, -0.05430616f, 0.00676855f, 0.07290192f, -0.09330930f, -0.18931107f, 0.37020740f, -0.11245883f, 
    -0.08645355f, -0.00157430f, -0.02908687f, -0.03526298f, 0.09463091f, -0.15301800f, 0.07925524f, 0.09190531f, 
    -0.27038774f, 0.00905869f, 0.03625237f, 0.09021743f, -0.02770565f, -0.03313182f, -0.01108015f, -0.11080916f, 
    -0.07279254f, 0.22785185f, -0.23643623f, 0.05397686f, 0.06121019f, -0.09216660f, -0.09596414f, 0.01291864f, 
    0.06022091f, -0.43793279f, -0.13475518f, -0.09396444f, 0.01461622f, 0.12738486f, 0.00972479f, -0.06359819f, 
    0.18190971f, -0.07512727f, 0.04429592f, 0.10364925f, 0.04051527f, 0.08674604f, -0.03808735f, -0.06471635f, 
    0.01577738f, -0.01119536f, -0.11365747f, -0.31943792f, 0.06874201f, -0.11509709f, -0.12957953f, 0.08614227f, 
    0.10904232f, 0.00813642f, -0.21446209f, -0.00234667f, -0.09432871f, 0.11950005f, -0.20299914f, 0.08045275f, 
    -0.17353527f, 0.01141294f, 0.01946731f, 0.06133911f, -0.09052335f, 0.12198281f, 0.14356275f, -0.10068372f, 
    -0.04253779f, -0.09794179f, -0.25819126f, -0.03300581f, 0.08776832f, 0.04106287f, -0.62296116f, 0.04815080f, 
    0.05568440f, 0.11297116f, -0.00398631f, 0.04550481f, -0.02756334f, -0.00386509f, -0.04212846f, -0.21024749f, 
    -0.18557389f, -0.01107870f, 0.03185012f, 0.04652921f, 0.02315276f, -0.06381115f, 0.27740625f, 0.07443106f, 
    -0.01952992f, -0.06259122f, -0.05783854f, 0.01749172f, -0.03279619f, -0.03541219f, 0.00793409f, 0.05035489f, 
    -0.02539803f, 0.02133302f, 0.02287787f, 0.01663045f, -0.03180130f, 0.00201474f, 0.05109029f, 0.05366258f, 
    0.01345381f, -0.04506062f, -0.05956373f, 0.04748572f, 0.02819930f, -0.05414860f, 0.02510930f, 0.02694471f, 
    -0.00061531f, -0.00545552f, 0.01920996f, 0.03918142f, -0.01247150f, -0.04940451f, -0.02919753f, -0.02147155f, 
    -0.00781967f, 0.05014585f, -0.04801686f, 0.00018277f, 0.01603594f, 0.00294634f, 0.04139236f, -0.02213176f, 
    0.04860518f, 0.02138063f, -0.06415360f, 0.03220488f, -0.03267617f, -0.02346265f, -0.06557003f, -0.03783162f, 
    0.01119221f, 0.04593387f, 0.01062294f, -0.01077190f, -0.05141458f, 0.02357892f, -0.04412499f, 0.02546887f, 
    0.01853599f, -0.05248715f, 0.04864875f, -0.01440053f, -0.03816426f, 0.03098896f, 0.03790195f, 0.02983397f, 
    -0.04941844f, 0.04237080f, -0.01724048f, -0.03903998f, -0.02769905f, 0.00429863f, 0.04037208f, -0.00712200f, 
    -0.01530740f, 0.04387264f, 0.00592284f, -0.06515872f, 0.02945656f, -0.06211648f, 0.00454911f, 0.02794106f, 
    -0.06769830f, 0.04825433f, -0.01507012f, -0.04799305f, 0.01276198f, 0.03911789f, 0.01421270f, -0.01516867f, 
    -0.04962290f, 0.03380540f, 0.03719172f, 0.00599392f, -0.05947849f, 0.05307319f, -0.04952176f, 0.04503839f, 
    -0.00925593f, -0.01571468f, -0.03462894f, -0.04996210f, -0.06544418f, 0.04298270f, -0.00338039f, -0.03179706f, 
    -0.00738543f, 0.00649504f, -0.02771564f, -0.03376926f, 0.01399366f, 0.02390327f, 0.04047503f, 0.03508772f, 
    -0.02773953f, 0.02552231f, 0.04243890f, -0.04218179f, 0.03171255f, -0.01629195f, -0.02908771f, -0.00694194f, 
    0.03418702f, 0.03164903f, 0.00875913f, -0.02976935f, -0.03168523f, 0.02536071f, -0.00238376f, -0.01024935f, 
    0.02118401f, -0.05590909f, 0.02450549f, 0.01911841f, -0.05952920f, 0.03454486f, 0.03830516f, -0.05610316f, 
    0.02582276f, -0.06705444f, -0.02035004f, 0.05478282f, 0.03013630f, 0.02062445f, -0.04959575f, -0.03955268f, 
    -0.03500208f, -0.00291303f, -0.00030586f, 0.03907275f, 0.00386591f, -0.05540626f, 0.03296760f, 0.03355758f, 
    -0.01820915f, -0.00562228f, -0.04163659f, 0.00800334f, 0.06753706f, 0.02124386f, -0.00571218f, -0.05422471f, 
    0.01068365f, 0.00613138f, -0.01876500f, -0.03321095f, -0.06399708f, -0.03261456f, -0.05822774f, 0.05074532f, 
    0.03735613f, 0.01253225f, 0.01854552f, -0.02546898f, -0.02091862f, -0.01483169f, 0.03583206f, -0.00705983f, 
    -0.00379435f, 0.02346108f, -0.05047716f, -0.03823315f, -0.05534257f, -0.02628917f, -0.06713859f, -0.04052793f, 
    -0.04723325f, 0.00242458f, 0.05149329f, 0.01470104f, 0.05663566f, -0.03418267f, -0.01146879f, 0.03139740f, 
    -0.01902980f, 0.04024955f, 0.00252364f, -0.01642166f, -0.05550862f, 0.04370232f, 0.02262846f, -0.01751928f, 
    -0.02508345f, 0.02025643f, 0.01551110f, -0.02468284f, -0.02678997f, -0.05500143f, -0.00195819f, 0.03249139f, 
    -0.03827438f, -0.04743740f, -0.03196612f, -0.01230796f, -0.00392426f, -0.01155580f, 0.01818555f, 0.04168854f, 
    -0.01751481f, 0.00983699f, 0.01275465f, -0.02121122f, -0.03905270f, 0.00553998f, -0.03771288f, -0.02000912f, 
    0.01672398f, 0.03838430f, -0.01846825f, -0.02011135f, 0.02344524f, -0.05290999f, -0.02810707f, 0.01064898f, 
    0.04282728f, 0.00296318f, -0.05488526f, -0.04523510f, 0.00419274f, -0.03520870f, -0.05044169f, -0.01484197f, 
    -0.02373410f, 0.03354054f, -0.03803553f, -0.03758224f, -0.04822180f, -0.03768791f, -0.05426239f, -0.03463429f, 
    -0.01881522f, 0.01235841f, -0.06016799f, -0.06313590f, -0.00260228f, -0.02682853f, 0.01594552f, 0.00260662f, 
    -0.02347854f, -0.03267107f, -0.02735832f, -0.03880453f, 0.00636056f, 0.00348110f, 0.01462320f, 0.04909200f, 
    -0.06233739f, 0.02811008f, 0.00872580f, -0.00805946f, 0.00155638f, 0.04515294f, -0.04359908f, -0.03503010f, 
    0.03407980f, -0.03997228f, -0.00238321f, -0.05071532f, -0.03461876f, -0.03780693f, -0.04907535f, 0.05021254f, 
    0.04610039f, -0.00324476f, -0.00781749f, 0.00029671f, 0.03809140f, 0.02094525f, 0.01672488f, 0.01994157f, 
    0.05116937f, -0.03183527f, -0.02747736f, -0.03095175f, -0.03124863f, -0.02820097f, 0.02277033f, 0.02700207f, 
    0.02089385f, 0.00575681f, -0.04200901f, 0.05134076f, -0.00575558f, -0.04650765f, -0.05922963f, -0.02229267f, 
    0.05397168f, -0.03344692f, 0.02822217f, 0.01021369f, 0.03123813f, -0.04602648f, 0.00019250f, -0.01592276f, 
    0.01663602f, 0.04274230f, 0.01767430f, -0.00566233f, -0.06040558f, -0.01853929f, 0.04955675f, -0.01681875f, 
    -0.05835090f, 0.00622226f, 0.00264208f, 0.00952041f, -0.05156105f, 0.03926249f, 0.00594846f, 0.05230494f, 
    0.00414558f, -0.03781831f, 0.04360961f, -0.02077419f, 0.01563942f, 0.00008970f, -0.04965394f, -0.03106918f, 
    0.01392932f, 0.01189277f, 0.01350050f, -0.04072864f, -0.04926769f, 0.01461909f, 0.00324427f, -0.04573273f, 
    0.02116302f, -0.03573652f, -0.05424350f, -0.02144652f, -0.02878887f, -0.05983194f, -0.01701145f, 0.04486831f, 
    -0.00594000f, 0.03446719f, 0.00088462f, 0.04902145f, -0.02787377f, 0.00373019f, -0.03775070f, 0.01383025f, 
    -0.00782664f, 0.01494835f, 0.02711668f, -0.00207818f, -0.01798769f, -0.00080016f, 0.02708257f, -0.00319966f, 
    0.05223703f, -0.03061672f, -0.05246269f, -0.05277016f, -0.05580433f, -0.05911633f, 0.02085281f, -0.01755642f, 
    0.02230376f, -0.02916495f, 0.00554987f, -0.03286190f, -0.04081038f, 0.00152555f, -0.05175221f, 0.01648411f, 
    0.05087833f, -0.02031611f, 0.05189314f, 0.04270830f, -0.03271595f, 0.05290485f, 0.04517972f, 0.04877706f, 
    -0.04217856f, 0.02351529f, -0.02979390f, -0.05750191f, 0.01205075f, -0.06174456f, -0.03583089f, 0.00930116f, 
    -0.01978009f, 0.02383486f, 0.04498284f, -0.02445312f, 0.00552478f, -0.06435965f, -0.02798930f, 0.02162482f, 
    -0.00038756f, 0.04770358f, -0.03814390f, 0.01802771f, 0.04647754f, -0.02887398f, 0.00685235f, 0.01537218f, 
    0.01435775f, -0.03101386f, 0.01814983f, -0.00255375f, 0.03460549f, -0.02026098f, 0.03471196f, -0.00889498f, 
    -0.03205565f, -0.01855663f, 0.02628651f, -0.01203891f, -0.03648384f, -0.04030974f, 0.03526941f, -0.04841547f, 
    -0.01287436f, -0.06108566f, -0.02048668f, -0.01345873f, 0.02133838f, 0.02087031f, -0.03588147f, 0.00573773f, 
    -0.02306398f, 0.04096213f, -0.04825513f, -0.03289589f, 0.05436276f, 0.00696299f, 0.05189826f, -0.04678689f, 
    -0.05468615f, 0.02811677f, 0.00606380f, -0.02503519f, 0.03560180f, -0.02647691f, 0.00936060f, -0.00412405f, 
    -0.00164135f, 0.00015734f, 0.03229636f, 0.03408591f, -0.02970267f, 0.00844384f, -0.01328964f, -0.05139654f, 
    0.02163603f, 0.01600857f, -0.03785366f, -0.03624174f, -0.02209535f, 0.03507170f, 0.01121165f, -0.05583699f, 
    0.04309765f, -0.05821798f, 0.03590709f, -0.05636572f, -0.04368385f, -0.01533491f, -0.04727548f, -0.05102070f, 
    -0.05537910f, -0.05269353f, 0.04973141f, -0.03070930f, -0.00417817f, 0.00927473f, -0.00779226f, 0.02425995f, 
    -0.04482390f, 0.05047195f, 0.04562538f, -0.01352528f, 0.01929050f, -0.04763261f, 0.01400476f, 0.03042858f, 
    0.03777123f, 0.02162591f, 0.02907497f, -0.02249865f, -0.02627616f, -0.04375277f, -0.00687414f, -0.00973722f, 
    -0.00676649f, -0.03232824f, 0.00971574f, -0.02770701f, -0.03284752f, 0.02567278f, 0.03157587f, -0.04014854f, 
    0.05185936f, -0.02852898f, 0.04753035f, 0.05449826f, -0.03137771f, -0.05834728f, 0.00973029f, -0.03214438f, 
    0.01942148f, -0.05321864f, -0.04646975f, 0.05034624f, -0.05477240f, 0.02540067f, 0.03595369f, -0.03272826f, 
    0.01442859f, -0.04944859f, -0.04356637f, 0.02617345f, 0.00444837f, 0.01222681f, -0.05082969f, -0.06125550f, 
    -0.00037003f, 0.01966850f, -0.05169453f, -0.04609808f, -0.00665035f, -0.02450441f, -0.00744978f, -0.01474449f, 
    -0.00098778f, 0.00759158f, 0.00974877f, -0.01517963f, 0.02657255f, -0.04446961f, 0.04617248f, 0.01905002f, 
    -0.05543337f, -0.00311172f, -0.04524161f, 0.04258608f, -0.03824091f, -0.06267086f, 0.02541321f, 0.00473462f, 
    -0.00695814f, -0.02427428f, -0.04694463f, 0.05190496f, 0.01515616f, -0.02914798f, 0.03578256f, -0.06244339f, 
    -0.02518559f, 0.02284261f, 0.02729194f, -0.00811092f, -0.03614432f, -0.05392377f, 0.05384924f, -0.06091132f, 
    -0.04892114f, -0.03927051f, -0.04415675f, -0.05616490f, -0.06282805f, -0.05125797f, 0.00873802f, -0.04323939f, 
    0.04311933f, 0.02357359f, 0.04258227f, 0.03046275f, -0.05579732f, -0.04888272f, 0.03427725f, -0.06463403f, 
    0.03204440f, -0.05156013f, -0.00387546f, -0.06190653f, -0.05985420f, -0.00875267f, 0.02461551f, -0.01238889f, 
    0.00400662f, 0.01921015f, -0.01496553f, 0.02229357f, -0.00772002f, 0.02865768f, -0.01284500f, -0.00876867f, 
    -0.05111805f, -0.01397123f, -0.00361986f, -0.05183062f, -0.02092179f, 0.03357099f, 0.02855940f, -0.01777809f, 
    0.01352313f, 0.05115737f, -0.05848011f, -0.03534592f, 0.00788389f, -0.05550177f, 0.02564602f, -0.02587739f, 
    -0.01307956f, -0.04634864f, -0.04668770f, 0.03413825f, -0.00666455f, 0.03431680f, -0.04880928f, 0.03608128f, 
    0.04226206f, 0.03597123f, 0.04733722f, -0.04553285f, -0.04278611f, 0.04616105f, 0.03147795f, -0.05669412f, 
    -0.06317835f, 0.03988351f, -0.02751308f, -0.05753781f, 0.02045128f, -0.03397245f, 0.01885834f, 0.05016745f, 
    0.03521231f, -0.01069149f, -0.01516403f, -0.00254220f, -0.01751832f, -0.00776419f, 0.01836197f, -0.00711087f, 
    0.03284147f, 0.04338080f, 0.00582284f, -0.00770753f, -0.05169954f, -0.05349114f, -0.04170994f, -0.01485980f, 
    -0.05244490f, 0.03393016f, 0.01212041f, -0.03615509f, -0.02122159f, -0.02362039f, -0.02246811f, 0.01472343f, 
    -0.05052897f, -0.02213490f, -0.01922640f, 0.04947617f, -0.00492424f, 0.04793444f, -0.05356728f, 0.04540561f, 
    -0.00518120f, 0.05244043f, 0.00546708f, -0.04530880f, 0.01710245f, 0.01974407f, 0.02416921f, 0.03617653f, 
    0.01592587f, 0.01183606f, 0.00849818f, -0.02594393f, 0.00046714f, 0.02538182f, -0.02832452f, -0.05356868f, 
    0.03139852f, -0.00246439f, 0.03778140f, -0.04095470f, -0.04433065f, 0.02557163f, -0.03496213f, -0.04994964f, 
    0.03169398f, 0.05224945f, -0.03339447f, 0.00032116f, 0.00048785f, -0.01824593f, 0.00559270f, -0.04936087f, 
    0.01705972f, -0.04912549f, -0.00390342f, 0.03476864f, 0.04757253f, 0.02534429f, -0.02194597f, 0.05172408f, 
    0.03281039f, 0.02613397f, -0.01162610f, 0.04321903f, -0.01443283f, 0.02986615f, 0.01392219f, -0.03869689f, 
    -0.06154377f, 0.03283219f, -0.00722734f, -0.04592233f, -0.02382310f, -0.03483092f, 0.01818992f, 0.02308171f, 
    -0.02328125f, -0.01057578f, 0.02329553f, 0.01342848f, -0.06353050f, 0.02454926f, -0.01468418f, 0.01396270f, 
    -0.04136310f, 0.06075862f, -0.00681563f, 0.05088579f, 0.01825288f, -0.06275099f, -0.03975593f, -0.04042821f, 
    0.04783954f, -0.03854102f, 0.00059064f, 0.04834130f, -0.01366476f, -0.00857059f, -0.05620402f, -0.06422438f, 
    -0.02662828f, 0.03196037f, -0.02847469f, 0.03927997f, -0.05032770f, -0.01368265f, 0.02732040f, 0.04102018f, 
    0.03280529f, -0.03872161f, -0.03193694f, -0.05421373f, -0.02898625f, -0.04829681f, 0.01650013f, -0.05487885f, 
    0.04039770f, 0.02711807f, -0.05325393f, -0.03084802f, 0.04742988f, -0.02538623f, -0.02374479f, -0.02014553f, 
    0.05357447f, -0.02407020f, -0.02667006f, -0.04516585f, 0.04815780f, -0.05966032f, 0.01223319f, -0.03086834f, 
    0.01296888f, 0.04174805f, -0.06178145f, 0.03365549f, -0.03918698f, -0.02498830f, -0.02904847f, -0.04006358f, 
    -0.03884855f, -0.04948248f, 0.00493632f, -0.02625046f, -0.04072804f, -0.04963893f, 0.02570587f, -0.01788542f, 
    -0.03529309f, -0.03278006f, -0.00370138f, 0.04660661f, -0.00332207f, -0.01407312f, 0.03885578f, -0.05603288f, 
    0.01226807f, -0.01097360f, 0.04273646f, 0.04702217f, -0.02110561f, 0.04328077f, -0.02152814f, -0.00145490f, 
    -0.05749237f, -0.03709637f, 0.04543644f, 0.03012547f, -0.02904391f, -0.02530412f, -0.06433754f, -0.01022002f, 
    0.01994564f, 0.01602693f, -0.01287892f, -0.00558029f, -0.05920632f, -0.00835468f, -0.02147426f, -0.02867467f, 
    0.00281834f, 0.04744143f, 0.01360985f, -0.05767995f, 0.00603022f, 0.00779066f, 0.02564597f, 0.04207399f, 
    0.03547386f, -0.04018483f, -0.01956192f, 0.04561507f, 0.04911210f, -0.04730743f, 0.06134624f, -0.05681409f, 
    -0.02525638f, -0.05059485f, -0.05913839f, -0.00724837f, 0.01409476f, 0.03833864f, 0.03871950f, -0.01344592f, 
    0.33896416f, 0.24008575f, 0.13537104f, -0.00870792f, -0.00319989f, 0.15497802f, -0.04385326f, 0.03294023f, 
    0.17348945f, -0.11081260f, -0.08893684f, 0.43644756f, -0.01378837f, -0.05142850f, -0.15336499f, 0.05275656f, 
    0.06100534f, -0.01043061f, -0.08463178f, 0.20670317f, 0.18028770f, -0.07936233f, -0.01031179f, -0.06384174f, 
    -0.08143422f, 0.03096624f, -0.03100552f, -0.02410597f, 0.04890742f, -0.23712954f, 0.01947372f, 0.03313037f, 
    0.08550230f, 0.03376057f, -0.01858382f, -0.09083211f, -0.02999559f, -0.34231251f, -0.01620062f, -0.09614250f, 
    0.04179202f, -0.10514358f, 0.03386947f, 0.00987992f, -0.06020353f, -0.20851949f, 0.05011933f, -0.17166582f, 
    -0.05484596f, 0.08064418f, 0.04928805f, -0.13452974f, -0.05014861f, -0.08859739f, -0.10745890f, 0.04795324f, 
    -0.14914717f, 0.14044991f, 0.11911567f, -0.02026941f, 0.00130229f, -0.19488907f, -0.11105180f, 0.21860167f, 
    -0.06163561f, -0.17737402f, 0.07539862f, -0.05730050f, 0.04361907f, -0.02940254f, -0.07116383f, -0.03367073f, 
    0.05207595f, -0.20640020f, -0.13580066f, -0.08973464f, 0.06781305f, 0.11058317f, 0.09142303f, 0.13024111f, 
    0.01054072f, -0.02593670f, -0.01976063f, -0.14235957f, 0.12439731f, 0.04504899f, -0.05621541f, -0.00503620f, 
    0.02565682f, -0.17247345f, 0.10735548f, -0.03394678f, -0.21814758f, -0.06929252f, -0.11510929f, -0.09438988f, 
    0.11883060f, 0.00167563f, -0.04939729f, -0.09782533f, -0.13567865f, 0.22597334f, -0.02107044f, -0.01425639f, 
    0.07955030f, 0.05930987f, -0.04977097f, 0.14098880f, 0.04663964f, 0.10810692f, 0.22040088f, -0.15765442f, 
    0.04987228f, -0.12926213f, 0.00057524f, 0.07169043f, 0.01439601f, -0.24081545f, -0.12022985f, 0.06029569f, 
    0.03500028f, -0.02634650f, 0.12134176f, -0.01564149f, -0.04242118f, 0.14529431f, 0.23501466f, 0.06447728f, 
    -0.32931229f, 0.06913726f, -0.00357282f, 0.05951153f, 0.01685666f, 0.09192756f, 0.09547272f, -0.17415655f, 
    -0.21425715f, -0.21190064f, -0.08245166f, 0.16748919f, 0.05433013f, 0.02264419f, -0.13498156f, -0.00555630f, 
    0.14400308f, 0.35488003f, 0.26995492f, -0.07622874f, -0.03092087f, 0.05385426f, -0.05510393f, -0.02361196f, 
    0.16260885f, 0.20474631f, -0.15732001f, -0.15877101f, 0.00017446f, 0.02272816f, -0.01271208f, -0.03072065f, 
    -0.15627003f, -0.17442904f, -0.27968723f, -0.11444233f, -0.12644762f, 0.08309385f, 0.07888738f, -0.06541620f, 
    0.11897798f, -0.01086629f, -0.02704985f, 0.16782130f, -0.11684266f, -0.16450676f, -0.11421578f, -0.06736874f, 
    -0.13415800f, 0.00340604f, 0.06148716f, -0.03092902f, 0.10585473f, 0.04603942f, 0.06262008f, 0.03288393f, 
    0.05234004f, 0.22105373f, -0.00055348f, 0.02822745f, -0.09836034f, -0.15709090f, 0.06434907f, -0.05943760f, 
    0.11527956f, -0.00152050f, -0.02891598f, 0.05368780f, -0.07533219f, -0.02691162f, 0.32923740f, -0.09834464f, 
    0.18030468f, -0.03181249f, -0.03488859f, -0.13143387f, 0.01233361f, -0.09142189f, 0.00089045f, -0.26714802f, 
    -0.07891599f, -0.03424382f, -0.00954921f, 0.12855455f, 0.09834169f, 0.11860310f, -0.01755999f, -0.09883306f, 
    -0.10241477f, 0.00325170f, -0.24956326f, 0.01013894f, 0.14756660f, -0.01021769f, -0.03988977f, -0.15457293f, 
    0.09215830f, 0.01541602f, -0.28209767f, -0.03097685f, 0.09055130f, 0.20268531f, 0.01466305f, 0.07472165f, 
    -0.05614580f, -0.20977899f, -0.28554210f, -0.08156163f, 0.12994818f, 0.09740658f, 0.06155059f, -0.00807151f, 
    0.02846474f, -0.05057868f, -0.13479866f, 0.07876808f, -0.16946904f, -0.01799911f, -0.04650062f, 0.07448737f, 
    -0.18700610f, 0.02739401f, -0.01025313f, -0.03180869f, 0.11117294f, -0.10852708f, -0.11548398f, -0.12781718f, 
    0.12562782f, 0.06816712f, 0.01767746f, 0.10243777f, -0.12295759f, -0.33231834f, 0.17842089f, -0.10333398f, 
    -0.00756563f, -0.00154491f, 0.02018372f, 0.08653057f, 0.05380654f, -0.07000447f, 0.76508391f, -0.10954511f, 
    -0.28893778f, -0.07173008f, 0.05842820f, 0.05429687f, -0.03558518f, -0.02994362f, -0.03977860f, 0.01263909f, 
    -0.38128978f, -0.15277204f, 0.06529311f, 0.05260009f, 0.02999211f, -0.00728725f, -0.07272782f, 0.08745632f, 
    0.11314938f, 0.09747241f, -0.21738313f, 0.01165640f, 0.04098323f, -0.11350269f, 0.09260597f, -0.13838370f, 
    -0.08283950f, 0.15366383f, 0.24308810f, -0.02249702f, -0.03035442f, -0.20864658f, 0.07142773f, 0.25228992f, 
    -0.03987972f, 0.15480204f, -0.36364707f, -0.09114042f, -0.39535591f, 0.05042100f, 0.00615009f, 0.12431245f, 
    0.00839618f, -0.08197859f, -0.36390036f, 0.11895459f, -0.03858773f, 0.27814648f, 0.01950532f, 0.23019032f, 
    0.13283047f, -0.12702373f, -0.08052179f, 0.20568459f, 0.12147969f, 0.22581032f, 0.17269689f, -0.09217259f, 
    -0.08862464f, 0.05740451f, 0.16411084f, -0.02802590f, 0.09996665f, 0.08317954f, -0.00957532f, -0.03627171f, 
    0.11900064f, 0.01049398f, -0.04422263f, -0.02006327f, -0.09146577f, 0.14857240f, -0.18036133f, -0.04481184f, 
    0.09060177f, 0.09623061f, 0.09853877f, -0.17099105f, -0.04629896f, 0.00991392f, 0.02833835f, -0.03383778f, 
    0.14438143f, 0.25609908f, -0.02751701f, 0.07272522f, 0.20278993f, 0.04073751f, 0.08451367f, 0.04387552f, 
    -0.02016852f, -0.10776720f, 0.00718111f, 0.06056421f, -0.04629302f, -0.01931478f, -0.14068922f, -0.10362764f, 
    -0.00631769f, -0.04915052f, 0.16343810f, -0.21654917f, -0.04665768f, -0.18464197f, -0.16197723f, -0.16485508f, 
    0.11848806f, 0.06341964f, -0.16425391f, 0.17863546f, -0.05675661f, 0.04530753f, 0.16311327f, -0.03614514f, 
    -0.10257005f, -0.05244374f, 0.27452326f, 0.01320950f, -0.15574412f, -0.05639933f, 0.11443164f, -0.02024339f, 
    0.02857946f, 0.11335270f, 0.08564949f, -0.12932062f, -0.10732348f, -0.03249689f, -0.07026129f, -0.12277409f, 
    -0.03404758f, 0.05231830f, -0.12424289f, 0.02495893f, -0.09024867f, -0.17076422f, 0.11114332f, -0.14266774f, 
    -0.19696477f, 0.03872027f, 0.05019467f, 0.16335747f, -0.12211155f, -0.01297585f, -0.08309235f, 0.16806357f, 
    -0.10590863f, -0.07805408f, 0.09384206f, -0.03415293f, -0.02093556f, -0.05707475f, -0.02788675f, 0.14381999f, 
    -0.01324683f, 0.31531245f, 0.06871316f, 0.08089057f, 0.02114409f, -0.12892970f, -0.09190819f, -0.02695810f, 
    -0.04738902f, -0.15807869f, -0.16288859f, -0.07943494f, 0.08744425f, -0.07452627f, -0.06552936f, 0.02267371f, 
    -0.25178468f, 0.15070441f, 0.11443285f, 0.17113544f, -0.04534537f, 0.04011999f, 0.15002762f, 0.10491268f, 
    0.03876620f, 0.01274825f, -0.10716698f, -0.04059732f, 0.08695453f, 0.19137402f, 0.13262643f, 0.02620521f, 
    -0.12280706f, -0.07544605f, -0.00123560f, 0.20132233f, 0.23147260f, 0.35403186f, 0.12798923f, 0.03863141f, 
    -0.13794379f, -0.00711186f, -0.08513997f, -0.06155993f, 0.01756668f, 0.03360229f, -0.04280405f, -0.09903494f, 
    0.13428271f, -0.04432630f, 0.08463814f, -0.08448330f, -0.17368449f, 0.03738919f, -0.00829202f, 0.01004772f, 
    -0.05390433f, 0.01202745f, 0.01602645f, -0.06950296f, 0.08497211f, -0.12286825f, 0.18674847f, -0.13384163f, 
    0.38556293f, -0.06540811f, 0.06910915f, -0.07052791f, 0.01280358f, -0.08610402f, -0.10703739f, 0.04716622f, 
    -0.09398206f, 0.01698656f, -0.05225769f, -0.01371378f, 0.01886470f, -0.08115638f, -0.01626335f, -0.11458877f, 
    -0.04853728f, 0.08954571f, 0.13979745f, 0.05428474f, 0.10349152f, -0.12031699f, -0.24823639f, -0.03598462f, 
    -0.02760158f, 0.18224151f, 0.02259432f, 0.14444022f, 0.09277608f, 0.04741322f, -0.06525396f, -0.13221942f, 
    0.07641441f, -0.00337823f, 0.04280372f, 0.02032389f, -0.17702439f, -0.11611337f, 0.07589979f, 0.02168860f, 
    -0.09534274f, 0.09572528f, -0.08091454f, 0.12629373f, -0.15360902f, 0.11704855f, -0.05349153f, -0.09486480f, 
    -0.08196701f, 0.01569559f, 0.13713031f, -0.03219988f, 0.22990735f, 0.21188769f, 0.04907253f, -0.02804055f, 
    -0.27475104f, -0.19282633f, -0.00153626f, -0.01116146f, -0.05539883f, -0.03474874f, 0.08113258f, -0.02029620f, 
    0.02127055f, -0.12096582f, -0.20374037f, -0.00308597f, -0.05366654f, -0.00346074f, 0.43506336f, -0.22138290f, 
    -0.25115606f, -0.11266641f, 0.10791017f, -0.10777038f, 0.13588193f, 0.03811603f, -0.10731867f, -0.04471606f, 
    0.27650145f, 0.00293232f, 0.03811792f, 0.02951173f, 0.06799819f, -0.02835266f, -0.05940453f, 0.21586254f, 
    -0.00816221f, 0.00423755f, 0.04132435f, 0.00782167f, -0.05364837f, 0.02209813f, -0.06323318f, 0.04093184f, 
    -0.00411947f, 0.02443997f, -0.00108288f, -0.03020680f, 0.01662454f, -0.01527104f, -0.03679182f, 0.03641582f, 
    0.04460004f, 0.04902897f, -0.05454277f, -0.03652601f, -0.04027105f, -0.03635769f, 0.01000261f, 0.03461023f, 
    0.01486466f, 0.03488969f, 0.00168523f, 0.04144541f, 0.02468134f, 0.02022351f, -0.05365477f, 0.01983285f, 
    -0.05931513f, -0.03032699f, -0.02774516f, 0.01694052f, 0.04464829f, -0.05303848f, -0.02007892f, -0.05662078f, 
    0.01395560f, 0.01067691f, -0.05911282f, -0.00575822f, -0.05136636f, -0.02789210f, 0.00688140f, -0.03736955f, 
    -0.04538262f, 0.01021807f, -0.05816921f, -0.00309150f, -0.01277834f, 0.03291245f, 0.04912335f, 0.04589086f, 
    -0.01088702f, 0.02148386f, 0.02319667f, -0.06087324f, 0.04305648f, 0.01061152f, -0.00364566f, 0.01636467f, 
    -0.04406046f, -0.03653465f, -0.01861349f, 0.04733429f, 0.02488934f, 0.01204602f, -0.02097502f, -0.04575046f, 
    0.04878594f, -0.01019410f, -0.00522605f, -0.02813514f, -0.02658116f, -0.01767923f, -0.04129514f, -0.00869605f, 
    -0.04626673f, -0.00037042f, -0.02218892f, -0.06225001f, -0.02355340f, -0.03780295f, 0.04500512f, 0.04450609f, 
    -0.03590625f, 0.04215297f, 0.04196533f, -0.01580980f, 0.04150315f, -0.00270748f, -0.05441500f, 0.04492385f, 
    0.00132448f, -0.05521904f, -0.06258840f, -0.03752386f, -0.02349280f, -0.05950799f, -0.05984282f, 0.00800526f, 
    -0.06288155f, -0.06009262f, -0.06346834f, -0.06370091f, -0.00675598f, 0.00353297f, -0.03382778f, -0.00043293f, 
    0.01490482f, -0.04478259f, 0.01957908f, 0.04610870f, -0.04411976f, 0.04694761f, -0.05104338f, 0.01217316f, 
    0.04268457f, -0.02871494f, -0.01753110f, -0.01745508f, 0.01720867f, 0.02876946f, -0.00469742f, 0.04383773f, 
    0.03843574f, 0.01282935f, -0.00850612f, 0.01854392f, -0.01924965f, 0.04406906f, 0.01829079f, -0.05112203f, 
    -0.04717962f, -0.03539301f, -0.04093390f, 0.02650547f, 0.03340628f, 0.03911665f, -0.03271255f, -0.03829303f, 
    -0.01209510f, -0.00309159f, 0.03871637f, -0.03186865f, -0.05850518f, -0.01287427f, 0.00483942f, -0.05527901f, 
    -0.04768373f, -0.04222561f, -0.03132031f, -0.01462555f, 0.02131481f, -0.04010804f, -0.03133813f, -0.02324096f, 
    0.02594448f, 0.00438265f, 0.03671493f, -0.04478949f, 0.00744144f, 0.03961079f, 0.01642675f, 0.02076159f, 
    -0.02568790f, -0.01798890f, -0.02208800f, -0.02879812f, -0.04629785f, 0.00998657f, 0.00754583f, -0.01672690f, 
    0.04493840f, 0.04251740f, 0.02059567f, 0.01230655f, -0.03679844f, -0.04691248f, -0.06509585f, -0.02240385f, 
    0.01067162f, -0.04966005f, -0.04759637f, -0.00205992f, -0.04700835f, -0.01227813f, -0.05411554f, 0.01978558f, 
    0.01564109f, 0.04588152f, -0.04623074f, 0.04610867f, 0.00050566f, -0.04182418f, 0.00583008f, -0.00955243f, 
    -0.00446148f, -0.03314164f, 0.04092625f, 0.00466609f, 0.04004418f, 0.00906442f, 0.00583474f, 0.02704787f, 
    0.03581418f, 0.01106321f, -0.03954800f, -0.02460727f, 0.01938346f, -0.01386336f, -0.00274748f, -0.06616226f, 
    -0.01929501f, 0.01759179f, 0.00337805f, -0.00405768f, -0.06411637f, 0.00484845f, -0.00562964f, -0.00361891f, 
    0.02107264f, -0.06266474f, -0.03886645f, -0.01317092f, 0.03594132f, 0.03251962f, 0.02739113f, 0.00077959f, 
    -0.05777208f, -0.03935757f, 0.04768021f, -0.05309467f, -0.00869827f, 0.00406449f, 0.01745706f, 0.01926402f, 
    0.01299330f, -0.01813147f, 0.03722902f, -0.06128580f, -0.05794308f, 0.04405454f, -0.01001837f, 0.01078752f, 
    -0.05890129f, -0.02267459f, -0.03286406f, 0.04814625f, -0.00751913f, -0.01400172f, -0.02272566f, -0.00569414f, 
    0.00702108f, 0.01232600f, -0.02130578f, 0.04491237f, -0.01311500f, -0.01120343f, -0.01967210f, -0.02422244f, 
    0.01390828f, -0.00810491f, -0.05306938f, 0.04775872f, 0.02093492f, -0.03227255f, -0.05140911f, -0.05788988f, 
    -0.01363847f, -0.04430632f, 0.04894275f, 0.03243379f, 0.02017926f, -0.02214326f, -0.00475659f, -0.03238992f, 
    -0.01792420f, 0.00602653f, 0.02814005f, -0.02391610f, -0.04970085f, -0.01481206f, -0.06674802f, -0.03975937f, 
    -0.05379640f, -0.00133165f, -0.07230914f, -0.07322340f, -0.09811151f, -0.00954917f, 0.00078161f, 0.04998124f, 
    -0.00967538f, -0.07795047f, -0.05709975f, -0.43509740f, 0.10013644f, -0.16970982f, -0.02806716f, -0.01023987f, 
    -0.06235372f, 0.08055662f, -0.20872453f, -0.12792782f, -0.05156436f, 0.06712510f, -0.07766826f, -0.02523262f, 
    -0.13610184f, 0.13672519f, 0.10458167f, 0.06700209f, 0.00761834f, 0.17946142f, -0.01913262f, 0.02853640f, 
    -0.03802433f, 0.09786843f, 0.04898743f, 0.08291514f, 0.02669940f, -0.11182870f, -0.22417453f, -0.00722969f, 
    0.07768691f, 0.02258398f, 0.17972340f, 0.01461764f, -0.09189887f, -0.25771761f, 0.02482167f, 0.06646528f, 
    -0.26150233f, -0.08189329f, -0.26404929f, -0.10110801f, -0.05377661f, 0.00256716f, -0.24773875f, -0.11256554f, 
    0.10112896f, -0.04657515f, -0.17519820f, -0.10152020f, -0.05938218f, 0.05030286f, 0.06217789f, -0.08169955f, 
    -0.15679108f, 0.37731519f, -0.15799521f, -0.03647928f, 0.03988677f, 0.00520790f, -0.06503748f, -0.03669565f, 
    -0.18278331f, 0.08185218f, 0.16512917f, -0.15400465f, 0.01671615f, 0.03959759f, 0.06176596f, 0.04122661f, 
    0.12093602f, -0.27045727f, 0.01047236f, -0.32860553f, -0.20409206f, -0.01014801f, 0.00777862f, 0.03283532f, 
    -0.07547856f, -0.24750564f, -0.16468993f, -0.16452268f, -0.20473282f, 0.25599939f, 0.13944843f, 0.19580603f, 
    -0.00458819f, -0.00388376f, -0.12230324f, -0.28828159f, -0.18407355f, -0.45046708f, 0.09219103f, 0.19907306f, 
    -0.04267941f, 0.17036678f, 0.01040437f, -0.04686949f, 0.31501502f, 0.06948033f, 0.14530978f, 0.10317135f, 
    0.04555484f, -0.01112151f, -0.04513905f, 0.05369481f, 0.03846641f, -0.10955159f, 0.02020508f, -0.19114962f, 
    0.11059197f, -0.07993213f, -0.10473505f, 0.26692319f, -0.09971538f, -0.10113462f, 0.03784132f, 0.15291585f, 
    0.26072824f, -0.07142416f, -0.09741735f, -0.13346399f, 0.09334218f, -0.12609957f, 0.20034173f, -0.27788493f, 
    0.05276423f, 0.26611462f, 0.07939976f, 0.06593131f, 0.01417848f, -0.07125108f, -0.00295963f, -0.06010784f, 
    -0.09852947f, -0.00743093f, -0.03801440f, 0.16393717f, 0.13904126f, 0.08495104f, -0.01174188f, -0.07873654f, 
    0.07111250f, 0.07161443f, 0.05180500f, 0.36235929f, -0.16171360f, -0.11786710f, 0.04144008f, -0.03801362f, 
    -0.01409699f, -0.00198397f, -0.03848602f, -0.07195144f, 0.40820694f, 0.07801661f, -0.14729142f, -0.12140051f, 
    0.00924805f, 0.13119292f, 0.14212768f, 0.20679593f, -0.15512556f, -0.13270009f, -0.05620498f, 0.04010911f, 
    0.07237167f, 0.02643327f, 0.03110733f, 0.15771435f, 0.13264753f, 0.12428868f, 0.19727665f, 0.07618476f, 
    -0.00922971f, -0.13514425f, 0.01857474f, -0.02735302f, -0.07604687f, 0.12700638f, 0.06523769f, 0.00511202f, 
    0.05221597f, -0.06305179f, -0.14713289f, -0.17179489f, 0.06606421f, -0.00011023f, -0.24462654f, -0.12902294f, 
    0.13378584f, 0.10713430f, 0.03656056f, -0.05924764f, 0.08833938f, -0.02081134f, 0.11741447f, 0.31707072f, 
    0.26623046f, 0.11670166f, 0.04272134f, -0.08382741f, 0.12672295f, -0.06544124f, 0.18240990f, 0.12241732f, 
    -0.20443064f, 0.13832086f, 0.00294464f, -0.02369652f, 0.11628247f, -0.00103690f, 0.08534006f, -0.16124924f, 
    -0.08582193f, 0.28076309f, -0.20822352f, 0.19352672f, -0.01316217f, -0.01821228f, 0.03038180f, -0.01203809f, 
    -0.09335095f, 0.04893483f, -0.01390091f, 0.01951386f, -0.01673059f, 0.25155827f, -0.08876143f, -0.04463828f, 
    -0.04631931f, -0.10224199f, 0.03776770f, -0.21968518f, -0.22548088f, -0.26560023f, 0.04820503f, 0.12196265f, 
    0.00971000f, -0.03263581f, -0.13225737f, 0.11480923f, -0.06442096f, 0.25577593f, -0.06569066f, 0.03323780f, 
    -0.13132748f, 0.07007219f, -0.06755816f, 0.01648113f, 0.12457069f, -0.11611404f, -0.08772348f, -0.02683399f, 
    -0.10286044f, 0.01977462f, -0.15022828f, 0.04259581f, -0.00259577f, 0.03986162f, 0.36739087f, 0.19326757f, 
    0.02959891f, 0.02041635f, -0.01032952f, -0.10875031f, -0.06769764f, -0.02751607f, 0.01317121f, 0.03338449f, 
    0.09261782f, 0.05436151f, 0.04161392f, -0.04649673f, 0.06686617f, 0.03672972f, -0.18871747f, 0.01703328f, 
    -0.01897667f, 0.02258998f, -0.04591636f, -0.00858774f, 0.04491662f, 0.01001034f, -0.00763668f, 0.03446461f, 
    0.01172558f, -0.05399873f, -0.05547034f, 0.04476117f, 0.03139056f, -0.04395701f, -0.05696937f, 0.00308265f, 
    0.03165117f, -0.04561863f, 0.03895370f, -0.03893751f, -0.05454287f, -0.05471641f, 0.03953305f, -0.03035346f, 
    -0.02994442f, -0.02691536f, -0.04621688f, -0.05058220f, -0.04649871f, 0.04261350f, 0.01391605f, 0.01143551f, 
    0.03365407f, 0.03012586f, 0.03046648f, -0.04068124f, -0.03676113f, 0.01651007f, 0.02907170f, 0.01877352f, 
    0.03265334f, -0.01321474f, -0.00695444f, 0.02216275f, 0.03755802f, -0.03401058f, -0.03158826f, 0.02794293f, 
    -0.02960256f, 0.01637597f, -0.01496216f, -0.01737360f, -0.00780301f, -0.01686778f, 0.02383700f, 0.01548587f, 
    -0.00321533f, -0.06597548f, -0.05021025f, 0.00490912f, -0.03994617f, -0.05002553f, -0.01920497f, -0.00122893f, 
    0.01779685f, -0.07053325f, -0.02660337f, -0.06113493f, 0.02901119f, -0.00912126f, 0.00399055f, -0.06338776f, 
    -0.02958037f, 0.00786278f, 0.01896010f, -0.01039083f, -0.01200181f, -0.01400019f, -0.04807298f, -0.01581085f, 
    -0.03016799f, 0.01272065f, 0.03009286f, 0.03461783f, 0.02870554f, -0.02692756f, -0.01750660f, -0.00514998f, 
    0.00825575f, -0.04621864f, 0.00147611f, -0.06717315f, -0.03548250f, 0.00685932f, -0.02718727f, -0.05692377f, 
    -0.05580721f, 0.02176160f, -0.01851611f, -0.05136025f, 0.01397143f, -0.01003658f, -0.01269773f, -0.00144562f, 
    -0.05580943f, 0.01973015f, -0.01933339f, -0.05264343f, 0.02612850f, 0.00202233f, 0.04492185f, 0.02174224f, 
    0.02266639f, -0.05984670f, 0.05111024f, -0.03115413f, -0.02826874f, 0.03607886f, -0.00331279f, -0.01810238f, 
    0.02787762f, 0.00773294f, -0.03065885f, -0.01944314f, -0.04492356f, 0.00476402f, 0.01953905f, 0.01810688f, 
    0.03288441f, -0.04584887f, 0.02666236f, -0.03583206f, -0.05912036f, -0.01547665f, -0.06239149f, -0.03235649f, 
    0.00718973f, 0.02768365f, 0.03463893f, -0.03758739f, -0.04165765f, -0.02769467f, -0.03514569f, 0.02794149f, 
    -0.00224591f, -0.00689367f, -0.03617850f, -0.00967798f, -0.00136394f, -0.04209394f, -0.00950246f, 0.01015187f, 
    0.04624037f, -0.04221602f, 0.04612818f, 0.00100461f, -0.01037102f, -0.00135927f, -0.00496806f, 0.04953592f, 
    -0.03182501f, -0.02016076f, 0.03788380f, -0.07002477f, 0.00008876f, -0.06046350f, 0.03206576f, 0.03663309f, 
    0.02452668f, 0.04615366f, 0.00305552f, 0.01807318f, 0.01008206f, -0.06457971f, 0.01621187f, -0.05104418f, 
    -0.00926102f, 0.00827718f, 0.01463459f, -0.04656198f, -0.04930715f, -0.03695895f, -0.01591147f, 0.00451686f, 
    -0.03602073f, -0.01280075f, 0.00180800f, -0.01798479f, -0.03473404f, 0.01838055f, -0.03344563f, -0.03761843f, 
    0.03031827f, 0.00013424f, -0.03388044f, -0.03192940f, 0.00789054f, -0.03446766f, -0.01470711f, -0.03836547f, 
    0.02588119f, -0.02778611f, 0.01650248f, -0.06348586f, 0.01077206f, 0.02023236f, -0.02289956f, -0.00274511f, 
    0.04321791f, 0.03818214f, -0.03512805f, 0.01708801f, 0.04257315f, 0.03308543f, -0.02167195f, -0.02147296f, 
    0.01035898f, -0.03385865f, -0.01340690f, -0.01330219f, 0.00944400f, -0.03399912f, -0.01552684f, -0.01211923f, 
    -0.01592606f, -0.02914617f, -0.05398587f, 0.02414479f, -0.03221146f, 0.03120731f, 0.01886443f, -0.06092671f, 
    -0.00981937f, 0.03773941f, 0.03736998f, 0.00700263f, -0.02639894f, 0.00722573f, 0.03774371f, -0.00106652f, 
    -0.00337329f, 0.02293718f, 0.03455507f, -0.03482314f, 0.02701052f, -0.04323129f, -0.05862632f, 0.04042257f, 
    -0.00348845f, -0.06503104f, -0.00593021f, 0.04263068f, -0.05082737f, 0.01823583f, -0.05201510f, 0.03638975f, 
    0.01244908f, -0.03579701f, -0.00165304f, 0.04931417f, 0.00160508f, -0.03323838f, -0.06785920f, 0.00748227f, 
    -0.03959303f, 0.01442337f, 0.02179361f, 0.02661297f, -0.04444169f, 0.01498973f, 0.02841010f, -0.05877665f, 
    -0.03196802f, -0.01449543f, -0.03248740f, -0.00862584f, -0.02269666f, -0.00642638f, 0.05324532f, -0.02050999f, 
    -0.05753160f, -0.03926891f, 0.01751285f, -0.02523681f, -0.04003376f, -0.01180674f, 0.04807796f, -0.04842552f, 
    -0.26666287f, 0.14062807f, -0.08014862f, -0.14197551f, -0.09383875f, 0.02990656f, 0.12076135f, 0.09367700f, 
    0.00012809f, -0.04935052f, 0.14219734f, 0.41617006f, 0.00615032f, 0.01549281f, -0.06060170f, -0.00512808f, 
    0.00232451f, -0.07562991f, 0.04256140f, 0.05826185f, 0.09838379f, 0.27865705f, 0.09472321f, 0.00209814f, 
    0.05037452f, 0.01587045f, 0.08764476f, -0.12933098f, -0.10391390f, 0.01996510f, -0.12137842f, -0.19700001f, 
    -0.04431210f, -0.07553805f, -0.00620074f, 0.09872252f, -0.14725325f, -0.12657525f, 0.05856624f, -0.08487960f, 
    0.15586646f, 0.08798599f, -0.16163763f, 0.03882661f, 0.03700471f, -0.10688670f, 0.00309405f, -0.19138244f, 
    -0.03424901f, -0.00827797f, 0.04581673f, -0.01038044f, 0.02390311f, 0.09014203f, 0.10790025f, -0.03878617f, 
    -0.31045675f, 0.07514668f, 0.06790464f, -0.03400033f, -0.02609012f, -0.00489395f, -0.07911694f, -0.39912906f, 
    -0.35802957f, -0.05835536f, 0.02998351f, -0.15822572f, 0.03113437f, 0.01906958f, -0.04456615f, -0.07960951f, 
    -0.11567486f, 0.11169660f, -0.15916684f, 0.14204800f, 0.05107136f, 0.16352360f, 0.14975059f, 0.05108856f, 
    0.00961833f, 0.13631609f, -0.07853523f, -0.26365131f, -0.02865935f, -0.08549704f, -0.07129234f, 0.12126652f, 
    -0.22322859f, 0.00464861f, -0.01451662f, 0.10014099f, 0.18759233f, -0.05317080f, -0.14531116f, -0.05529497f, 
    0.01023768f, -0.09721319f, -0.07122933f, 0.11418133f, 0.27209029f, -0.06944060f, 0.03455505f, -0.04209531f, 
    0.01645811f, -0.01550183f, -0.01612247f, 0.07086061f, 0.16408110f, 0.24263339f, 0.22063895f, 0.00866289f, 
    0.02319101f, 0.08613002f, -0.06790604f, 0.00299191f, 0.06899588f, -0.19926132f, 0.06055690f, 0.31156021f, 
    -0.04820245f, 0.11170788f, 0.10744648f, -0.06654297f, -0.02589818f, 0.12627074f, 0.06659161f, 0.09368720f, 
    -0.54946738f, 0.00844243f, -0.03100789f, -0.06177564f, -0.03345329f, 0.16035621f, 0.02718888f, 0.01557097f, 
    0.10651676f, -0.18275748f, 0.05414663f, 0.07582776f, 0.01087225f, -0.09709016f, -0.07487058f, -0.11782338f, 
    0.36228940f, 0.29806793f, 0.25944513f, 0.04528591f, 0.18566670f, -0.02874709f, 0.06071228f, 0.00263822f, 
    0.12611257f, -0.52483636f, -0.33104283f, -0.08594705f, -0.06358730f, 0.18420225f, 0.03546831f, 0.01098652f, 
    -0.15356459f, -0.12960251f, 0.06333426f, 0.03901289f, -0.25735694f, 0.11962598f, -0.04120053f, -0.07386086f, 
    0.07201712f, -0.00532618f, 0.00813522f, 0.01540984f, -0.23519361f, -0.24713722f, -0.01490159f, 0.09533184f, 
    0.09486605f, 0.04948405f, -0.04744321f, -0.21923812f, 0.33615777f, 0.01533663f, 0.20186637f, 0.12198036f, 
    0.14564127f, 0.27136040f, 0.12785359f, -0.00964777f, -0.09607873f, -0.16280466f, -0.11623913f, 0.14731480f, 
    0.06009907f, -0.06279436f, 0.01632764f, 0.09472546f, -0.09967742f, -0.05120672f, 0.28166601f, 0.24036849f, 
    0.09495739f, 0.09299342f, -0.00976324f, -0.03131492f, 0.05535562f, 0.04922273f, 0.06917703f, 0.05919174f, 
    -0.10382844f, 0.10042394f, 0.09591857f, 0.02354828f, 0.16890034f, 0.00670224f, -0.03893756f, 0.07031249f, 
    0.20160578f, 0.05972731f, -0.33299065f, -0.00792406f, 0.04147811f, 0.18828785f, -0.12022677f, 0.03095973f, 
    0.12489873f, -0.15180364f, -0.34346840f, -0.05397906f, 0.14500533f, -0.10167417f, -0.10464817f, 0.00619357f, 
    0.03397503f, -0.11905918f, 0.20510471f, 0.29773456f, 0.24244961f, 0.16094182f, 0.18932496f, -0.08782227f, 
    -0.02169098f, -0.06658810f, 0.12859121f, 0.14114599f, 0.08480094f, 0.08341384f, -0.08110398f, -0.08647808f, 
    0.08625821f, 0.06547040f, 0.00153241f, 0.01797915f, 0.01061032f, 0.10933951f, -0.25543526f, 0.08725872f, 
    0.03917917f, 0.04907954f, 0.03111891f, 0.01121042f, -0.08052579f, -0.05437137f, 0.16331987f, -0.14632903f, 
    0.08839387f, 0.04047542f, -0.01856685f, 0.08770854f, 0.13998781f, 0.00942432f, 0.00569535f, -0.27656204f, 
    0.17929830f, 0.01360040f, -0.04997431f, -0.12697707f, -0.06518025f, -0.00824053f, 0.02586352f, -0.28736979f, 
    -0.20578839f, -0.15340550f, 0.00075948f, -0.04883206f, 0.04331082f, -0.13738552f, 0.15178752f, -0.01222582f, 
    0.03696921f, -0.01466865f, 0.05409402f, 0.00762088f, 0.02657005f, -0.04043832f, -0.06257044f, 0.01651377f, 
    -0.04018585f, 0.03826945f, 0.03920444f, -0.04872662f, -0.04985185f, -0.04832350f, 0.03787817f, -0.02435404f, 
    0.05135400f, -0.01194906f, -0.05763901f, -0.05086833f, -0.01916092f, 0.00200237f, 0.05481537f, -0.00812570f, 
    0.02694754f, 0.02065382f, -0.03167263f, -0.02668184f, -0.05599683f, -0.03359113f, 0.01488100f, -0.02919612f, 
    -0.00968198f, -0.01082042f, -0.04757943f, 0.02723055f, -0.00093867f, 0.03006022f, -0.04978671f, -0.02533088f, 
    0.03019367f, -0.03312956f, 0.05117133f, 0.03491719f, 0.03999477f, 0.01640860f, -0.02092946f, 0.02571101f, 
    -0.01924217f, -0.04770679f, 0.02728466f, -0.06253743f, -0.05697396f, -0.02812511f, -0.03889963f, 0.00863546f, 
    -0.02407511f, 0.00756861f, 0.00633057f, -0.04744904f, -0.01160606f, -0.04801081f, -0.02161776f, -0.03532340f, 
    -0.01016830f, -0.01432113f, 0.04225497f, 0.01159145f, -0.00907862f, -0.06340313f, -0.01568046f, 0.01432936f, 
    -0.04347105f, -0.01249727f, 0.03824358f, -0.00434239f, -0.02749956f, -0.05369809f, 0.01544376f, 0.03710739f, 
    -0.06197100f, 0.05610000f, -0.03753233f, -0.03101938f, 0.00740084f, -0.04019086f, 0.04691015f, 0.00766331f, 
    -0.02096161f, -0.00919433f, -0.04902230f, -0.01843960f, 0.00491542f, 0.01562505f, 0.00029430f, -0.05213094f, 
    -0.00706672f, -0.05084233f, 0.03828737f, -0.00625338f, -0.03129908f, 0.04561092f, -0.03989138f, -0.02502340f, 
    -0.03516123f, -0.04597535f, -0.03613175f, 0.04827424f, 0.04974760f, 0.00854249f, 0.00171529f, 0.00666233f, 
    0.01561559f, -0.04868204f, 0.01987489f, -0.00836719f, 0.04369364f, 0.03461435f, -0.01576427f, 0.05021304f, 
    -0.01460583f, 0.03555813f, 0.01731734f, 0.00885852f, -0.02208658f, -0.03690255f, 0.00920881f, -0.06545030f, 
    0.02480771f, -0.03621465f, 0.01064686f, -0.03541670f, 0.01382047f, 0.00726252f, 0.01962309f, -0.00780519f, 
    -0.06207680f, -0.05229286f, 0.03341489f, 0.01527776f, -0.04801097f, -0.01601290f, -0.02769671f, 0.04988774f, 
    -0.03925982f, -0.03409924f, 0.00707288f, 0.00520484f, -0.05844834f, -0.01183888f, -0.06031000f, 0.01888358f, 
    -0.00939263f, 0.01794565f, -0.05332386f, -0.05847210f, -0.01969735f, -0.01379526f, 0.03334557f, -0.00013887f, 
    -0.02345004f, -0.04528305f, -0.05239875f, 0.00418020f, -0.00889749f, 0.01358731f, 0.05288059f, -0.00556762f, 
    0.02945227f, -0.03343471f, 0.03056713f, 0.00446606f, 0.01457522f, -0.02483506f, -0.00207970f, -0.04279990f, 
    -0.01993826f, 0.03902632f, 0.00370586f, 0.02069806f, 0.03334587f, -0.04807967f, -0.05797056f, -0.04160801f, 
    0.00656697f, 0.01891023f, 0.01230018f, 0.02073126f, 0.02378666f, -0.02315395f, -0.04210781f, -0.05047629f, 
    0.02244182f, -0.03226813f, 0.01165244f, -0.04634348f, -0.02593209f, 0.01308330f, 0.03416931f, -0.03104704f, 
    0.05134005f, 0.03146661f, 0.02340242f, -0.02133515f, -0.03356418f, -0.00980835f, 0.01863179f, -0.04350161f, 
    0.00911493f, 0.00889943f, 0.05330489f, -0.05928663f, -0.03389659f, 0.03528327f, -0.02451922f, -0.03775275f, 
    0.02822968f, -0.00862273f, 0.00327623f, -0.00974434f, -0.00644814f, 0.03780598f, -0.01467845f, -0.02215092f, 
    0.00387311f, -0.02847948f, 0.01659296f, 0.03742527f, -0.03408955f, -0.04598922f, 0.05587348f, 0.02183179f, 
    0.03975496f, 0.00746618f, 0.01161758f, -0.03889040f, -0.03773193f, -0.03023655f, -0.05317831f, 0.02746157f, 
    -0.01034534f, 0.03976657f, -0.02932394f, -0.03664554f, 0.04737347f, 0.01611234f, -0.05680275f, -0.00507502f, 
    -0.01448051f, -0.04254385f, 0.00580486f, -0.05414861f, 0.03078149f, -0.00953838f, -0.05528602f, 0.02852663f, 
    -0.01183818f, -0.03476668f, -0.04280076f, -0.05468681f, -0.00534214f, -0.00924885f, -0.03846075f, 0.05439709f, 
    0.02847778f, -0.04155672f, 0.03489839f, -0.02204975f, 0.04795778f, -0.01567065f, -0.01449251f, 0.02148960f, 
    -0.00521814f, 0.04995863f, -0.04439028f, 0.01174651f, 0.04277879f, 0.04434577f, -0.01611612f, -0.01390169f, 
    0.01935748f, 0.00198670f, -0.01195179f, -0.03100881f, -0.00349519f, -0.03214461f, -0.05072078f, 0.02993052f, 
    -0.02843874f, -0.06649186f, -0.02032034f, -0.05766980f, 0.03721599f, -0.03894709f, 0.03527841f, 0.00126516f, 
    -0.04297907f, -0.03193033f, 0.01260991f, 0.00541409f, 0.02487322f, -0.00991610f, -0.01791287f, -0.03240038f, 
    0.03239581f, 0.02357819f, 0.04288505f, 0.04030481f, 0.04962171f, 0.03663956f, -0.01823071f, -0.05526105f, 
    -0.01139039f, -0.03907506f, -0.04794582f, -0.00136884f, -0.03175290f, 0.02566509f, -0.05102801f, 0.01147789f, 
    0.03394335f, -0.06552815f, 0.02517691f, -0.06636577f, 0.04753051f, -0.03035326f, 0.02224177f, -0.06449779f, 
    0.01036737f, 0.03960942f, 0.01601348f, 0.03458141f, -0.04429186f, -0.03334994f, -0.03310532f, 0.02545545f, 
    -0.03202591f, 0.00144789f, -0.03456289f, 0.01755585f, 0.01912902f, -0.03601718f, -0.05188200f, 0.01086664f, 
    -0.02234584f, 0.04246011f, 0.01606924f, -0.05946548f, 0.00535180f, -0.03075633f, -0.01949416f, 0.02257894f, 
    -0.00513139f, -0.00376160f, -0.06491809f, 0.01753000f, -0.03071644f, -0.05200364f, -0.00594013f, 0.01222894f, 
    0.04637203f, 0.01947051f, 0.01163232f, 0.03542606f, 0.03503860f, -0.00749746f, -0.06498282f, 0.00415124f, 
    -0.02384051f, 0.01153200f, -0.02889642f, 0.00144790f, -0.05206551f, 0.02103608f, -0.05761997f, -0.04911365f, 
    0.03048110f, -0.06141958f, 0.05431905f, -0.04577678f, -0.03250637f, 0.01803090f, -0.04178618f, -0.02777077f, 
    0.04913148f, -0.04053201f, 0.04893542f, -0.06345672f, -0.06397057f, 0.02288968f, -0.05670261f, -0.01957846f, 
    0.03647564f, -0.05779937f, 0.03176663f, 0.00945600f, -0.01830305f, 0.04073939f, -0.03531764f, -0.00938272f, 
    0.04829263f, -0.02922016f, 0.01473554f, -0.05259331f, -0.04354978f, -0.02347992f, -0.02371985f, -0.00776168f, 
    -0.02187165f, -0.05097487f, -0.02159044f, 0.00379049f, 0.04337452f, -0.04915531f, -0.04229463f, 0.02337603f, 
    0.00338139f, -0.05565273f, 0.00220683f, -0.03193010f, -0.05449040f, -0.06460981f, 0.01818470f, -0.03516807f, 
    0.04587391f, -0.03105040f, 0.04276508f, -0.04332697f, -0.00351342f, -0.05629631f, -0.02732141f, -0.01880689f, 
    -0.05233846f, -0.04002002f, -0.02509610f, -0.02605152f, -0.02541258f, -0.03169935f, -0.04866007f, -0.02572202f, 
    0.03923335f, 0.01345562f, -0.00559001f, -0.03377445f, -0.02902317f, 0.01197904f, -0.06384251f, 0.02106682f, 
    0.04529634f, -0.04242486f, -0.02490046f, -0.01720049f, 0.00094039f, 0.02446259f, -0.03905889f, -0.01949563f, 
    -0.02790336f, 0.03705313f, -0.05329410f, 0.02669656f, -0.06141068f, -0.06445797f, 0.02006219f, -0.04812344f, 
    0.03183158f, 0.01179104f, -0.01337895f, 0.01513434f, 0.01789933f, -0.05032393f, -0.03854814f, -0.02949948f, 
    0.03979276f, 0.00044510f, -0.05001856f, -0.04287598f, 0.04679706f, -0.03828341f, -0.05079077f, -0.04268240f, 
    -0.01272534f, -0.00011113f, 0.00636637f, -0.01390803f, 0.03424597f, -0.00885777f, -0.01132506f, -0.00383533f, 
    -0.02155705f, -0.04427392f, -0.02519007f, -0.04000802f, -0.02699658f, -0.00505505f, 0.00587093f, -0.01755278f, 
    -0.00858505f, -0.06245372f, 0.00221385f, 0.01845362f, -0.02492486f, 0.02935155f, 0.05041024f, -0.06083466f, 
    0.04186069f, -0.05513097f, -0.01607524f, -0.03153887f, -0.03700840f, 0.04721285f, 0.02562773f, -0.03405864f, 
    -0.05054597f, -0.02845962f, -0.03311804f, 0.01375603f, -0.00612682f, 0.02100388f, -0.01154812f, -0.03809024f, 
    0.04385770f, -0.00604120f, 0.03297271f, -0.02248700f, 0.02034767f, 0.01748639f, -0.02335251f, -0.06488872f, 
    0.00196850f, -0.02023079f, 0.04010329f, -0.01435870f, 0.04947245f, -0.01461066f, -0.03645457f, -0.05270995f, 
    -0.00538326f, -0.01783131f, 0.00332727f, -0.03613561f, -0.00533763f, -0.04663928f, 0.03648965f, -0.05460977f, 
    0.01369317f, -0.00054271f, 0.00615672f, -0.04136947f, 0.01612203f, 0.05014049f, -0.03030719f, -0.05835894f, 
    0.03673894f, -0.03926520f, -0.01741638f, -0.04565717f, -0.02481730f, -0.06406128f, -0.05871757f, 0.01624030f, 
    0.04891476f, 0.01990565f, -0.00573104f, 0.00129392f, -0.04349119f, -0.00562905f, 0.04623253f, 0.04179583f, 
    0.02801465f, 0.02612319f, 0.00958033f, 0.03406937f, -0.06332583f, 0.02152844f, -0.00649786f, -0.03598453f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03753193f, 0.00922480f, 0.09182572f, -0.00893787f, 0.11495426f, -0.01472966f, 0.12337378f, -0.02855045f, 
    -0.01903921f, 0.07764792f, 0.02131328f, 0.16579600f, -0.04706106f, -0.06771693f, -0.01552148f, 0.15840417f, 
    -0.01890659f, 0.03310521f, -0.01937607f, 0.04421279f, -0.11789972f, -0.02949090f, -0.03391959f, -0.04981303f, 
    0.03042420f, -0.03455611f, -0.01129242f, 0.08305761f, 0.00895742f, 0.00588855f, 0.03120889f, -0.04136346f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02206674f, -0.50764269f, 0.03104148f, 0.15718316f, 0.38561526f, 0.29414779f, 0.40993455f, -0.04993853f, 
    0.00972909f, 0.02964235f, 0.05436653f, -0.08226990f, -0.15226062f, -0.20932829f, -0.14502184f, 0.22076905f, 
    -0.13384157f, 0.21707794f, -0.22060996f, 0.01920793f, -0.25437874f, 0.00385544f, 0.08878189f, 0.14389794f, 
    -0.64155638f, 0.05471060f, -0.07115842f, -0.12151212f, 0.04634010f, 0.14172366f, -0.00498370f, -0.00395538f, 
    0.08283503f, 0.36245084f, -0.09324484f, -0.09439585f, 0.02047166f, -0.38434115f, 0.20537612f, 0.37700707f, 
    0.07259841f, -0.27796218f, -0.13655679f, -0.08883476f, 0.24534895f, 0.29650271f, -0.02865269f, 0.24115850f, 
    0.15249774f, 0.28130865f, -0.04121585f, 0.05088433f, -0.41017908f, -0.01997647f, -0.06128887f, 0.16253175f, 
    0.18059196f, -0.16515177f, 0.13665365f, -0.14864311f, 0.07417164f, 0.02751994f, 0.03850353f, 0.02844358f, 
    -0.12262747f, 0.58018202f, -0.00265895f, -0.26681548f, -0.14383939f, -0.11539657f, 0.19620883f, 0.00226929f, 
    0.06020200f, -0.30877274f, -0.00088516f, 0.05033546f, 0.30563769f, 0.04371807f, 0.16558713f, 0.06507914f, 
    -0.03181219f, 0.18090770f, 0.13797881f, -0.13153595f, -0.10747425f, -0.12621622f, -0.08728468f, 0.07156655f, 
    0.40621713f, 0.18892685f, 0.17151803f, 0.37046435f, -0.06153062f, 0.22539008f, -0.05550464f, -0.01990773f, 
    -0.04498572f, 0.17316450f, 0.11914951f, 0.30210873f, 0.15593493f, 0.03156107f, -0.18112555f, -0.28166246f, 
    0.00945688f, -0.00450383f, -0.03992780f, -0.13215604f, 0.58190429f, 0.29865935f, -0.12274770f, 0.18400677f, 
    0.04172434f, -0.06732811f, 0.09026636f, 0.27558732f, -0.29350731f, -0.11651246f, -0.12857421f, 0.08970898f, 
    -0.50254750f, 0.06942202f, -0.16055001f, 0.16213277f, -0.10996103f, -0.30674651f, 0.16926450f, 0.14351192f, 
    0.10475030f, 0.32031000f, -0.07220145f, -0.21463789f, -0.26124224f, 0.20446365f, 0.17814888f, 0.46307239f, 
    0.10170389f, 0.14261876f, -0.16499132f, 0.04947743f, 0.02626674f, 0.20361111f, 0.09937000f, -0.07506651f, 
    0.16816808f, 0.15123966f, 0.08594495f, 0.15467764f, -0.48856437f, 0.09800364f, -0.03317766f, -0.06723184f, 
    0.42429954f, 0.15605843f, 0.13078605f, -0.20045979f, 0.04162179f, 0.00573253f, -0.11921812f, -0.15963027f, 
    0.08770384f, 0.39275235f, 0.09082687f, 0.16053566f, 0.10281400f, -0.19812334f, -0.32853785f, -0.22846051f, 
    0.03615316f, -0.01952184f, 0.13987961f, -0.21097937f, 0.40245247f, 0.11431625f, 0.16578621f, 0.29396099f, 
    0.14111194f, -0.14296888f, -0.08046020f, 0.37069947f, 0.31841296f, -0.10864672f, 0.15531379f, 0.14058211f, 
    -0.03660258f, -0.04473373f, -0.01245822f, -0.08339211f, -0.02158929f, -0.26990506f, -0.09603342f, 0.14488940f, 
    -0.02512990f, -0.12101004f, 0.16684838f, 0.01863212f, 0.05036716f, 0.07012434f, -0.13353792f, 0.32182732f, 
    -0.17497039f, 0.03542595f, -0.05027194f, -0.08403474f, -0.23380296f, -0.07663657f, 0.09515125f, 0.25435719f, 
    0.02199545f, 0.46070215f, 0.14234789f, 0.03060373f, 0.38853344f, 0.10353993f, 0.05215550f, -0.10764290f, 
    -0.57004219f, -0.56762099f, -0.06190716f, -0.03747884f, 0.08949200f, 0.23167570f, -0.00324843f, -0.09671361f, 
    -0.11875378f, 0.12632960f, 0.04711168f, -0.23001951f, -0.19901177f, -0.22723064f, 0.28136805f, 0.36047706f, 
    -0.01532832f, 0.08315005f, -0.05854121f, 0.06791248f, -0.38473704f, -0.23498061f, 0.17628498f, 0.07336628f, 
    -0.07389282f, 0.43087724f, 0.16883971f, -0.03785561f, -0.12293860f, -0.13992625f, -0.09565245f, 0.07598887f, 
    0.41503403f, -0.04591804f, -0.11805914f, 0.04167010f, 0.03624435f, 0.42035374f, -0.01611811f, 0.14067669f, 
    0.16788942f, -0.57558578f, 0.26550350f, 0.25992143f, 0.11958198f, 0.48587143f, -0.04280430f, -0.30563915f, 
    0.12472662f, 0.37007132f, 0.17218114f, 0.35241953f, -0.23541802f, -0.10891435f, 0.00700991f, 0.03114651f, 
    0.14417961f, -0.03228179f, -0.10095881f, 0.08591881f, -0.16523711f, -0.09699080f, 0.01107008f, -0.15312590f, 
    -0.12718640f, 0.19123194f, 0.00016873f, 0.09390462f, 0.07494342f, -0.08126675f, 0.14183426f, 0.11411214f, 
    -0.13884276f, -0.00625999f, -0.20391800f, -0.16755232f, -0.16894160f, -0.01120417f, 0.11656073f, -0.04160473f, 
    0.07375228f, 0.09497120f, -0.07394569f, 0.04502583f, -0.09786350f, -0.01436644f, -0.17677791f, -0.03671942f, 
    -0.11049447f, -0.14892322f, 0.00658508f, -0.06794354f, 0.16077718f, 0.01012737f, -0.05627331f, -0.03660978f, 
    -0.03158720f, -0.00024911f, 0.07999478f, -0.16211486f, -0.10657599f, 0.11014903f, -0.15066217f, -0.02817392f, 
    0.08126073f, 0.05743969f, 0.13749282f, 0.04407770f, -0.25390664f, 0.27922061f, -0.61177558f, 0.24910823f, 
    0.13656372f, 0.28709653f, -0.06150497f, 0.14636889f, 0.00957177f, 0.26264870f, -0.03799439f, 0.23842935f, 
    -0.14348260f, 0.10475053f, 0.30544066f, -0.23009826f, 0.27323800f, -0.08895188f, 0.02417751f, -0.14989281f, 
    0.15754817f, -0.30776384f, 0.02268759f, -0.45913029f, -0.03539665f, -0.04671321f, -0.08617431f, -0.14310928f, 
    -0.17330907f, 0.14533360f, 0.22618316f, -0.02074732f, 0.02452745f, 0.37515062f, 0.15966687f, -0.11339317f, 
    -0.02475654f, 0.00012112f, -0.16497406f, -0.06103271f, 0.33431706f, 0.20259315f, 0.15877059f, -0.20044802f, 
    -0.01390727f, -0.27942997f, -0.10101498f, 0.22070205f, -0.45108378f, -0.18319836f, 0.13465047f, 0.15355462f, 
    0.05639764f, 0.51783127f, 0.04108986f, 0.26988572f, -0.16142201f, -0.30480212f, -0.06564594f, 0.06864417f, 
    0.08452295f, 0.08626689f, 0.16048811f, 0.33796629f, -0.09999316f, 0.27619860f, 0.14957736f, 0.03513500f, 
    0.06100091f, -0.09830140f, 0.10014890f, 0.30269870f, -0.43725207f, -0.22706199f, 0.04686643f, -0.10246709f, 
    0.00540129f, -0.00501421f, 0.05507392f, -0.24553329f, 0.21375912f, -0.12102422f, -0.17661315f, -0.08831425f, 
    -0.13628438f, 0.43201888f, -0.04300877f, 0.26484948f, 0.02646090f, 0.17928058f, 0.17206241f, -0.12302015f, 
    0.03805455f, -0.43312979f, 0.09805118f, 0.11340007f, 0.39182875f, 0.19089650f, 0.04509639f, -0.02960980f, 
    0.00587958f, 0.15135337f, -0.09036478f, -0.06758051f, -0.06032323f, 0.02068811f, 0.03542391f, 0.44416142f, 
    -0.17353834f, -0.04687305f, -0.27887991f, 0.30441013f, -0.13880943f, -0.13928628f, 0.00743212f, -0.04061650f, 
    -0.65232074f, -0.25902623f, 0.13049556f, -0.24793449f, -0.10936317f, 0.07867063f, -0.16239488f, -0.11902885f, 
    0.13107350f, 0.22891754f, 0.09862160f, 0.00209705f, 0.14091451f, 0.16018704f, -0.03296158f, -0.17801650f, 
    -0.16079661f, -0.08855038f, -0.06484404f, -0.03739240f, -0.32089826f, 0.16251382f, -0.04469291f, 0.22490831f, 
    -0.16225161f, -0.13989118f, -0.28998995f, -0.11545544f, 0.21167022f, -0.00167569f, 0.16200002f, 0.12727579f, 
    0.77735025f, -0.02906971f, 0.09849498f, -0.77666801f, -0.05508915f, 0.37595543f, 0.16187680f, 0.03738572f, 
    -0.10148077f, -0.08848908f, 0.13131653f, -0.25898221f, -0.27800158f, 0.13709192f, 0.29810175f, 0.28366679f, 
    -0.13757189f, 0.42340103f, 0.13296559f, 0.27672902f, 0.00610755f, -0.06873449f, 0.13245362f, -0.10717318f, 
    -0.07710595f, -0.20416693f, 0.23425156f, -0.08480173f, 0.08434962f, 0.05012351f, -0.08887959f, 0.09711167f, 
    0.30554843f, -0.12274171f, 0.16505778f, 0.14748779f, -0.06552107f, -0.10226375f, -0.07528120f, 0.11646362f, 
    0.16049190f, 0.55359697f, 0.03198741f, -0.13345189f, -0.36538833f, -0.04212760f, 0.20297380f, 0.29077032f, 
    0.12361763f, 0.09738447f, 0.03406268f, 0.30339786f, 0.36585161f, 0.16336249f, 0.16200437f, -0.07139703f, 
    0.07913168f, 0.44351417f, 0.38870299f, -0.21252353f, -0.47782719f, 0.16271476f, -0.01019767f, -0.06682729f, 
    -0.07801861f, -0.25595304f, 0.06835172f, 0.20618069f, -0.12705392f, -0.04230203f, 0.09090079f, 0.07677927f, 
    -0.03775658f, 0.27028635f, 0.25313568f, 0.21582714f, 0.03484993f, -0.11677110f, -0.34597951f, -0.39344180f, 
    0.11727484f, 0.13167970f, 0.11262529f, 0.05511274f, 0.35171336f, 0.27524579f, -0.04002655f, 0.16710263f, 
    0.05635384f, -0.10905083f, 0.22096831f, 0.00130196f, 0.08395486f, -0.03070756f, -0.14944696f, -0.00685022f, 
    -0.29642224f, -0.10076748f, -0.04510075f, 0.31477132f, -0.16559623f, -0.38937572f, 0.15143672f, -0.11581843f, 
    0.05312629f, 0.48405004f, 0.03860417f, -0.04859185f, 0.14780557f, -0.22363816f, 0.07129151f, -0.13263996f, 
    -0.10641055f, -0.38454911f, -0.11081079f, 0.32359812f, -0.01363976f, -0.13387781f, -0.09366250f, 0.23043594f, 
    0.09411952f, -0.00855205f, -0.01089111f, -0.01375067f, -0.39092690f, 0.13783656f, 0.13416861f, -0.02895590f, 
    0.08113214f, -0.52929670f, 0.06169564f, 0.35271734f, -0.15987973f, -0.19366409f, -0.07443363f, 0.13141537f, 
    -0.10612121f, 0.32232231f, -0.44092360f, 0.10143916f, 0.13073595f, 0.01339659f, -0.09677890f, 0.11725765f, 
    -0.12637676f, 0.24115671f, -0.13125525f, 0.02285580f, 0.19858570f, 0.12474351f, 0.08225197f, 0.38929540f, 
    0.15397830f, 0.31512633f, -0.26620713f, 0.22019538f, -0.09434032f, 0.10822303f, 0.13020250f, 0.11503714f, 
    -0.25818124f, -0.54333866f, 0.16992243f, -0.11800995f, -0.02644681f, -0.14811878f, 0.01140211f, 0.01721851f, 
    -0.04167711f, 0.09693857f, -0.00876632f, 0.40955502f, 0.06657776f, 0.41459864f, -0.33803985f, -0.01123858f, 
    -0.14384812f, 0.18853877f, 0.01639624f, 0.03829126f, -0.16926414f, -0.15926439f, -0.10309719f, 0.31746233f, 
    -0.15606190f, 0.08120814f, -0.16046944f, 0.04766896f, 0.50146621f, -0.02617977f, 0.15369003f, 0.16248016f, 
    -0.06433850f, -0.10664286f, -0.11444258f, 0.08825637f, 0.13234182f, 0.03356135f, 0.14476329f, 0.16714454f, 
    0.15849198f, -0.32506660f, 0.29123586f, 0.11893749f, 0.47872999f, -0.26914954f, 0.39949125f, -0.10408091f, 
    -0.00390533f, -0.09137411f, -0.13171402f, 0.07349661f, -0.23308885f, 0.17984349f, -0.00866301f, -0.09168234f, 
    0.03307018f, -0.20231119f, -0.12549902f, -0.09002072f, 0.11684553f, 0.03880860f, -0.05173029f, -0.10609115f, 
    0.24657506f, -0.05788537f, 0.14930449f, -0.05961509f, -0.04401588f, 0.32246235f, -0.16764027f, -0.06791856f, 
    -0.12559099f, -0.05294888f, 0.35990158f, -0.01916345f, -0.12087730f, 0.17433557f, -0.20141208f, -0.17243493f, 
    0.03490449f, 0.32512316f, -0.11781370f, 0.30646080f, -0.05782134f, 0.10372770f, -0.13035899f, -0.31330794f, 
    -0.10469477f, -0.17993593f, 0.37271416f, 0.02473020f, -0.17813413f, 0.02481058f, 0.16011140f, -0.08384624f, 
    0.00591744f, 0.30115825f, 0.11851896f, -0.19120751f, -0.15225436f, 0.05005096f, -0.00647748f, -0.02973065f, 
    0.07437408f, -0.02847608f, 0.26567388f, 0.02933936f, 0.33398342f, 0.00661538f, -0.12910634f, -0.39023048f, 
    0.07611090f, -0.18295422f, -0.01204220f, 0.23855746f, 0.32833737f, 0.45864406f, -0.12507161f, 0.01053230f, 
    0.05250385f, -0.30515766f, -0.26846042f, -0.01276836f, -0.29791930f, 0.10059796f, -0.04075725f, 0.11483851f, 
    0.43404987f, 0.21751995f, 0.04736945f, -0.39791709f, 0.09857071f, 0.01284733f, -0.14494859f, -0.02164446f, 
    -0.01392046f, -0.16611625f, 0.11958311f, 0.11021362f, -0.15916552f, -0.39864606f, 0.44597113f, -0.02675046f, 
    -0.09093793f, 0.42121816f, -0.05100761f, 0.06442180f, -0.24607003f, -0.23016189f, 0.16790590f, -0.06779513f, 
    0.15930411f, 0.27638999f, 0.27906835f, -0.08905702f, 0.62233496f, -0.05840426f, -0.08410410f, -0.05936190f, 
    -0.09019440f, -0.19397260f, -0.16364856f, 0.35787487f, 0.06988632f, 0.38435301f, -0.08242537f, 0.08773318f, 
    -0.01708988f, -0.00473492f, -0.04792082f, 0.41096687f, 0.21953499f, 0.31664065f, -0.34938669f, -0.16589288f, 
    -0.11477053f, -0.03198650f, -0.02292970f, -0.07628845f, -0.00422266f, -0.08519786f, -0.07583962f, 0.27546889f, 
    0.13483106f, 0.01960186f, -0.35587549f, 0.12501457f, 0.54238814f, 0.11110050f, -0.16672795f, -0.00799640f, 
    -0.18870158f, -0.10136024f, 0.00831820f, 0.31771445f, 0.15472876f, -0.02625847f, 0.12411066f, 0.06340420f, 
    -0.04999704f, 0.15293637f, 0.35156801f, -0.02593716f, -0.19079761f, 0.06379590f, 0.00939373f, -0.17812584f, 
    0.10351007f, -0.12329070f, -0.14720216f, 0.31364682f, -0.32748950f, 0.33999974f, 0.05299218f, -0.34993535f, 
    0.03652275f, -0.17560928f, 0.06394122f, -0.15675707f, 0.38910630f, -0.14919934f, -0.16420951f, -0.04921778f, 
    0.19695267f, 0.18796439f, 0.01892901f, -0.15103412f, -0.12802708f, 0.24345432f, 0.05005697f, 0.12728949f, 
    -0.09011371f, 0.07725956f, 0.00248789f, -0.16379690f, -0.06881334f, 0.09331137f, -0.18037252f, -0.13981169f, 
    -0.04225007f, 0.12421919f, -0.15675732f, -0.05469725f, -0.13076851f, -0.08559550f, -0.08721519f, -0.04779782f, 
    -0.01981884f, -0.02216621f, -0.09818962f, -0.02522262f, -0.14816739f, 0.16308379f, -0.08549745f, 0.11010692f, 
    -0.03088223f, -0.09443552f, 0.06743769f, 0.15931535f, 0.13241558f, -0.14457200f, 0.17475531f, 0.05169480f, 
    -0.02025595f, -0.17545104f, -0.10179061f, -0.12508272f, -0.11837062f, -0.13890935f, -0.16232410f, 0.11108589f, 
    0.13528571f, -0.11839201f, 0.17373466f, 0.10616080f, 0.09819872f, -0.03466497f, 0.03323062f, -0.03672309f, 
    -0.01821892f, 0.03298644f, -0.02887459f, -0.13858037f, -0.07985890f, -0.01754885f, 0.15443435f, -0.15857075f, 
    -0.19178168f, 0.05618608f, 0.16100039f, -0.05011116f, -0.04110726f, 0.02132727f, -0.10159154f, 0.02144663f, 
    0.03027800f, 0.35968363f, 0.32068145f, -0.31722176f, 0.14345129f, -0.44073543f, 0.37687120f, -0.14038438f, 
    -0.02331133f, -0.34193644f, 0.17486423f, 0.04525786f, -0.20286134f, 0.03181492f, 0.08730408f, -0.04201159f, 
    -0.12887521f, 0.06451348f, 0.17021962f, -0.12300861f, 0.34533152f, -0.06605838f, 0.12894672f, 0.00919250f, 
    0.52994782f, 0.05043643f, 0.07738561f, 0.06210320f, 0.11232994f, 0.42464072f, -0.14095555f, -0.04993742f, 
    -0.02680004f, -0.08549422f, -0.13947175f, -0.15221170f, -0.00858975f, 0.00521645f, 0.56470442f, 0.34278798f, 
    -0.05040075f, -0.00226372f, -0.06327317f, 0.14985794f, 0.11797573f, 0.17535026f, -0.15671891f, -0.10461263f, 
    -0.14474669f, 0.12159483f, 0.05289152f, 0.11313668f, -0.51735228f, 0.09739901f, 0.11465158f, -0.07785933f, 
    0.15756604f, -0.10423243f, 0.09497921f, 0.04561897f, 0.10198165f, 0.06399228f, -0.06871000f, -0.14334281f, 
    -0.11346093f, 0.35378942f, -0.20552750f, 0.11644910f, 0.08544779f, -0.19628941f, -0.25874144f, -0.09126756f, 
    -0.07606322f, 0.15735272f, 0.14277479f, 0.06121705f, 0.32871711f, -0.33850610f, -0.13442677f, 0.31479368f, 
    -0.13997898f, -0.08436395f, -0.14918427f, 0.38312602f, 0.29333493f, 0.07148360f, 0.07198888f, -0.08520468f, 
    0.38932365f, 0.27688950f, 0.07438149f, 0.24460195f, 0.14650507f, -0.20716436f, -0.07342342f, 0.10601134f, 
    0.13928071f, -0.25320688f, -0.13459231f, -0.06093858f, 0.32300088f, 0.51033151f, 0.09272645f, -0.06922618f, 
    0.16767676f, 0.02435944f, 0.05249763f, 0.27031758f, -0.13473932f, -0.31598967f, 0.17537299f, 0.32712710f, 
    0.09898447f, -0.15155943f, -0.38544777f, 0.44371358f, -0.03231075f, 0.04350701f, -0.01441064f, 0.05452710f, 
    0.27987769f, -0.07369736f, 0.06443071f, 0.09723913f, 0.06393459f, 0.25138152f, 0.01217831f, 0.08442108f, 
    0.06550431f, -0.27926099f, 0.26158059f, 0.23487940f, -0.03152808f, 0.13555115f, 0.10292289f, 0.13405438f, 
    0.05517260f, 0.01851810f, 0.04367231f, 0.05047741f, -0.35166177f, 0.13084382f, 0.03453083f, -0.29847366f, 
    0.12660918f, 0.33848688f, 0.23584490f, -0.26944017f, 0.29722732f, 0.05396241f, -0.01925268f, 0.15669456f, 
    -0.28803855f, 0.06275710f, 0.09683289f, -0.22443603f, -0.06552012f, 0.41851023f, 0.10012330f, 0.16416405f, 
    -0.13560811f, 0.56776750f, -0.11787821f, 0.19937877f, -0.11420310f, 0.05074840f, 0.04111165f, 0.43682134f, 
    0.07882262f, -0.41834778f, -0.17594588f, 0.08286627f, 0.10593629f, 0.05795093f, -0.12956469f, 0.05256143f, 
    0.05163787f, 0.14611910f, -0.11496001f, -0.12679765f, 0.08427747f, -0.11485504f, 0.17682904f, 0.06094457f, 
    0.36212879f, -0.07705944f, -0.15614805f, -0.02241047f, -0.10434721f, 0.41525787f, 0.05210679f, -0.13275452f, 
    0.13784036f, -0.16715394f, -0.10164607f, -0.02156436f, -0.07869115f, -0.17108461f, -0.08709753f, 0.07074148f, 
    -0.10092429f, -0.09818789f, -0.15870669f, -0.13690719f, -0.15941072f, 0.10791253f, -0.16534615f, -0.17583281f, 
    0.02943626f, -0.15310846f, 0.02036898f, -0.02042703f, 0.02025701f, -0.14053483f, -0.14124155f, 0.10203762f, 
    0.04127744f, 0.00252973f, -0.16314659f, 0.11145215f, -0.12657069f, -0.17473558f, -0.17177840f, 0.01895038f, 
    0.07795341f, -0.26256090f, 0.34494108f, -0.08979665f, 0.33483130f, -0.00753882f, 0.28179008f, -0.15959606f, 
    -0.12401092f, -0.25358689f, 0.04171247f, 0.28796187f, -0.02330695f, 0.38134223f, -0.16980481f, -0.29008234f, 
    0.12788941f, -0.07576152f, 0.13022421f, -0.01122418f, -0.31548190f, -0.17156301f, 0.02886147f, -0.09658071f, 
    0.08940415f, 0.06955263f, 0.08765388f, -0.32493040f, 0.11131059f, -0.10358540f, -0.01639775f, 0.09222746f, 
    -0.05614805f, -0.01858590f, -0.07979549f, -0.09116442f, -0.15572067f, -0.06329959f, -0.04790527f, -0.00761506f, 
    0.12676792f, -0.14511128f, -0.11543687f, -0.03911770f, -0.17814824f, -0.05731331f, 0.07687564f, 0.10680659f, 
    0.17320582f, -0.17804958f, -0.04922039f, 0.03623728f, 0.05990355f, -0.01311357f, 0.14927556f, -0.11062850f, 
    -0.15210006f, -0.17822698f, -0.15796569f, -0.16026880f, -0.04773733f, 0.09983418f, -0.06545199f, -0.04877143f, 
    0.03675052f, -0.28610945f, 0.25886065f, -0.17571215f, 0.05352024f, 0.17724477f, 0.02652688f, -0.05684552f, 
    0.08660675f, 0.43001768f, 0.03301971f, 0.18800591f, 0.05918883f, 0.10925528f, -0.06873339f, -0.25291282f, 
    0.17615283f, -0.13345811f, 0.34444514f, -0.09576854f, -0.27812952f, -0.12187743f, -0.13920155f, -0.00722062f, 
    -0.39750192f, 0.29136151f, -0.10327120f, -0.22101082f, 0.13996008f, 0.14350738f, -0.13320495f, 0.13135159f, 
    -0.11403250f, 0.36662799f, 0.16413219f, 0.16815886f, -0.25490165f, 0.29947799f, -0.40034363f, 0.07484293f, 
    0.12338942f, 0.14828098f, -0.01979957f, 0.00920430f, 0.12405863f, 0.20842448f, 0.15665592f, 0.05274996f, 
    0.03263936f, 0.02611209f, 0.21366826f, 0.08206242f, 0.32800364f, -0.04079341f, 0.04652096f, -0.15848550f, 
    -0.08072442f, -0.00827099f, 0.02370138f, 0.19594018f, 0.13075331f, -0.22379334f, 0.14809477f, -0.12469128f, 
    0.17725016f, 0.08063646f, 0.22213021f, 0.20301522f, 0.05639651f, -0.06701836f, -0.05860680f, -0.14118563f, 
    0.09518819f, 0.08152161f, 0.16440518f, 0.36579812f, -0.07846865f, -0.11553576f, -0.01253778f, 0.05800929f, 
    -0.15931576f, 0.24115543f, 0.26106632f, -0.30441111f, 0.14212479f, -0.14728776f, 0.14399460f, -0.06257547f, 
    -0.56201184f, -0.17120473f, -0.09575951f, 0.02416853f, 0.05902999f, -0.13790628f, -0.12146348f, 0.15922184f, 
    -0.16329908f, 0.48220381f, -0.06234837f, 0.05901009f, -0.12242769f, 0.32118741f, -0.04371390f, -0.01236603f, 
    -0.15477756f, -0.28622535f, -0.02674744f, 0.28568068f, -0.00529095f, 0.11510430f, 0.14698811f, 0.08925183f, 
    0.01906907f, -0.14744598f, -0.11862099f, -0.02940428f, -0.02593138f, -0.00360994f, -0.05257940f, 0.05360725f, 
    0.59141195f, 0.11165201f, 0.11120369f, -0.32682902f, -0.09910101f, -0.07558473f, -0.02280845f, -0.09611683f, 
    -0.11090061f, 0.22043280f, -0.20658895f, 0.02065743f, 0.23990321f, -0.29542974f, 0.19027466f, 0.05026545f, 
    -0.05646704f, -0.25496116f, 0.12873892f, 0.15583478f, 0.23215473f, -0.26580772f, -0.08003459f, 0.42460904f, 
    -0.02103091f, 0.17945655f, -0.12825128f, 0.25865254f, 0.04566247f, -0.15803751f, 0.12640712f, 0.02703965f, 
    0.25587082f, -0.22505638f, -0.01824689f, 0.17413016f, 0.10844846f, 0.10682438f, -0.15801224f, -0.16627793f, 
    -0.09161533f, -0.14551167f, -0.23900957f, -0.00817631f, -0.08430206f, -0.04373138f, -0.05783248f, 0.03138434f, 
    0.03652598f, -0.17882952f, -0.12958741f, -0.01221943f, 0.05201880f, -0.04872140f, 0.12024499f, 0.02003514f, 
    -0.13460872f, -0.20438482f, 0.09783799f, -0.12636437f, -0.05712364f, -0.16410156f, -0.09832201f, 0.02046813f, 
    -0.08987080f, 0.01309608f, -0.02446768f, 0.03290806f, -0.04908454f, -0.11402883f, -0.03128239f, 0.02267458f, 
    -0.04611346f, -0.09221177f, -0.15044971f, 0.05621137f, -0.00690547f, 0.11466366f, -0.04223004f, -0.08030140f, 
    -0.03315016f, -0.05586473f, 0.09643812f, -0.18791172f, 0.06095602f, -0.00524682f, 0.12106802f, 0.05515340f, 
    0.02103262f, -0.14056827f, 0.13408108f, -0.18553303f, 0.05301570f, 0.15797623f, 0.11038230f, -0.13670106f, 
    -0.11546537f, 0.02487579f, 0.12133410f, -0.04392162f, -0.10065105f, -0.16899179f, -0.05178060f, 0.13687740f, 
    0.00370756f, 0.00646886f, -0.07651602f, -0.03202652f, -0.00939323f, 0.01538715f, 0.01049443f, -0.14686655f, 
    -0.03334998f, -0.12953445f, 0.04879724f, -0.16420227f, -0.12758455f, 0.09202079f, 0.05133695f, -0.00909490f, 
    -0.13636146f, 0.05437069f, -0.11837094f, -0.13404207f, 0.02553303f, -0.07055045f, 0.16097039f, -0.11088239f, 
    0.01336226f, -0.14752948f, -0.06278778f, -0.19571160f, -0.06741074f, -0.08021499f, -0.06148070f, 0.01363613f, 
    -0.10038730f, -0.61616933f, -0.13244154f, 0.42852551f, -0.17386052f, 0.26919743f, 0.29262003f, 0.29393521f, 
    0.15380138f, 0.24939430f, -0.01403871f, -0.19727996f, -0.07765684f, 0.25322634f, -0.13734603f, -0.43279576f, 
    0.11574307f, -0.04872160f, -0.11393651f, 0.35665998f, -0.28822893f, 0.03736152f, 0.16375814f, 0.12277497f, 
    0.08869892f, 0.56258643f, -0.16751692f, 0.06827758f, -0.13279693f, -0.18507640f, -0.00056356f, 0.05953821f, 
    -0.13619193f, -0.16050953f, -0.12936412f, -0.20015013f, -0.11364708f, 0.04451426f, -0.10407047f, -0.02349309f, 
    0.02244050f, -0.11434662f, -0.10762627f, 0.02543070f, -0.05297462f, -0.00535751f, -0.13580216f, -0.04360451f, 
    0.04720540f, -0.15935193f, -0.10522325f, 0.03289802f, -0.15120032f, 0.16988210f, -0.13169223f, -0.16325869f, 
    0.05271556f, 0.14020593f, -0.12610210f, 0.02840496f, -0.10409875f, 0.03779293f, -0.05470692f, 0.08485457f, 
    -0.01277612f, -0.48233739f, 0.14301789f, 0.17492129f, -0.30546242f, -0.33800930f, 0.03873368f, 0.18727557f, 
    0.09508863f, 0.23290995f, -0.05854449f, -0.19297808f, 0.12183788f, 0.13886377f, 0.04249706f, -0.35466310f, 
    -0.06764042f, -0.03465767f, 0.08389433f, 0.43193308f, 0.46735579f, -0.10364671f, -0.13788731f, -0.04363425f, 
    -0.30319750f, 0.03570757f, -0.10696496f, 0.14382015f, 0.07756586f, -0.03243164f, 0.00359554f, -0.11948920f, 
    0.15986463f, -0.17397656f, -0.01577896f, -0.20600830f, -0.00654262f, -0.01772123f, -0.12474480f, -0.01596992f, 
    0.11069670f, -0.20267056f, 0.12540026f, -0.07091168f, -0.00514910f, -0.07759846f, 0.16457742f, -0.06333821f, 
    0.07627536f, -0.02329446f, 0.05515361f, -0.03682812f, 0.06307820f, 0.02378424f, -0.05981636f, -0.06733932f, 
    -0.09740742f, 0.01057524f, -0.08233543f, -0.08367197f, 0.01782752f, -0.15604772f, -0.15029912f, 0.09850992f, 
    -0.06791313f, 0.47630310f, 0.13448320f, -0.02205275f, 0.12185574f, 0.13223280f, -0.14743984f, -0.00568790f, 
    0.15336372f, -0.05219928f, -0.10298090f, -0.24820328f, 0.39033651f, 0.38351804f, 0.12587117f, -0.07858316f, 
    -0.08388104f, -0.00952419f, 0.40052825f, -0.18477239f, -0.44349250f, -0.01048831f, -0.09713966f, -0.04916766f, 
    -0.39416561f, -0.00079550f, -0.05774164f, 0.05189048f, -0.16254102f, -0.02608835f, -0.06264131f, 0.09075158f, 
    -0.01632834f, -0.20725077f, 0.11096083f, 0.09637406f, -0.17420942f, 0.11106296f, -0.35982519f, -0.42816335f, 
    0.10595299f, 0.26674321f, -0.10930357f, 0.26111552f, 0.00663441f, 0.28774619f, 0.03835059f, 0.03446049f, 
    0.02414224f, -0.35691348f, 0.19069831f, 0.15607156f, 0.29424244f, -0.10978301f, -0.16286293f, 0.01284602f, 
    0.34284428f, 0.11360966f, -0.00492889f, -0.32748663f, -0.11861039f, -0.06861274f, 0.11447427f, -0.13320722f, 
    0.07441861f, -0.34027442f, 0.04542879f, 0.23488030f, 0.00044599f, -0.52616942f, 0.29969117f, -0.44622165f, 
    -0.11927425f, 0.24937898f, -0.05790208f, 0.37051654f, 0.01271872f, 0.03758538f, 0.07389572f, 0.11919432f, 
    0.13521431f, -0.05382586f, -0.00981384f, 0.17369165f, 0.05540957f, 0.09560421f, 0.01370645f, -0.04239966f, 
    -0.05149051f, -0.07264971f, -0.13818115f, 0.21676238f, 0.13490486f, -0.29711547f, 0.05451118f, 0.09913084f, 
    0.15468329f, 0.09914904f, 0.09163080f, 0.43599761f, -0.61878854f, 0.46976191f, -0.48136088f, 0.65041071f, 
    -0.15919812f, -0.20716538f, -0.03753470f, -0.01618682f, -0.00927082f, -0.06898770f, 0.00571029f, -0.12005479f, 
    0.06540569f, 0.19834358f, 0.12978707f, 0.03004041f, 0.24339463f, 0.16369134f, -0.06260932f, 0.07182786f, 
    -0.30071458f, 0.39496347f, -0.16175431f, 0.23863417f, -0.01134383f, -0.15165854f, 0.13781950f, 0.11552843f, 
    0.03867419f, -0.20138016f, 0.12814514f, -0.03849325f, 0.23620650f, 0.35897869f, 0.09027980f, 0.01724685f, 
    -0.02285542f, -0.05813957f, 0.03222929f, -0.00915110f, 0.05028601f, 0.41701820f, -0.13069691f, 0.13222344f, 
    -0.06585930f, -0.02543363f, -0.19631548f, 0.15812397f, -0.51258940f, 0.16242097f, 0.00007760f, -0.04353895f, 
    0.08466811f, 0.11545853f, -0.06922060f, -0.40618607f, 0.09921233f, 0.16548747f, -0.11848012f, -0.08714753f, 
    0.04170029f, -0.04134250f, -0.18370843f, -0.17763422f, -0.05493494f, -0.32446378f, 0.41231561f, 0.27581209f, 
    -0.09834581f, 0.23088327f, -0.05475461f, 0.30481434f, -0.12657891f, -0.06703661f, 0.09191550f, -0.14870261f, 
    -0.04221667f, 0.40826899f, 0.02920148f, 0.13858740f, -0.09686687f, -0.06153354f, 0.13205612f, 0.03471286f, 
    -0.13755891f, -0.41432488f, 0.08491879f, 0.40996954f, 0.04189522f, 0.14484921f, 0.07731206f, 0.06724361f, 
    -0.17176124f, -0.16445802f, -0.09241948f, 0.03322057f, -0.20553859f, 0.26491514f, -0.00078844f, 0.04817971f, 
    -0.15354268f, 0.41298628f, 0.16516940f, 0.01448897f, 0.14232846f, -0.43090284f, -0.08908067f, 0.21825005f, 
    -0.02698283f, 0.11865569f, 0.18571253f, 0.15524934f, -0.20177680f, -0.01000178f, 0.14493798f, 0.10762033f, 
    -0.26706362f, 0.10177958f, 0.17736973f, 0.51584119f, 0.16309676f, 0.03958145f, -0.14740920f, 0.11545893f, 
    0.12369194f, 0.11927477f, -0.08615479f, -0.00398523f, 0.35807592f, -0.17733471f, -0.17579019f, 0.13086747f, 
    -0.03442093f, -0.22799787f, -0.07673036f, -0.00927290f, -0.02663845f, -0.00384895f, 0.00861359f, 0.26177624f, 
    0.06019309f, 0.17005697f, -0.01504275f, 0.07018091f, 0.38324854f, -0.03932567f, -0.07393660f, -0.11010185f, 
    0.29609761f, -0.23275569f, 0.01280761f, -0.45432469f, 0.14964634f, 0.43591166f, -0.00901339f, -0.01784449f, 
    0.04495172f, -0.06523087f, -0.25557125f, 0.00127470f, -0.27395830f, 0.00334169f, -0.20027956f, -0.14820026f, 
    0.11131995f, 0.03883385f, -0.08193904f, 0.00145926f, -0.23331819f, -0.15933730f, 0.00821313f, -0.05843322f, 
    0.04012269f, -0.22817758f, 0.02685186f, 0.09431156f, 0.17404515f, 0.07097971f, -0.13731654f, -0.10428789f, 
    0.13748874f, -0.03183703f, 0.05614679f, -0.18039778f, 0.16362424f, 0.06421646f, 0.15939017f, 0.03296360f, 
    -0.03111746f, 0.19538985f, 0.03966822f, -0.18843171f, -0.36444616f, -0.16235511f, -0.08246424f, 0.46940777f, 
    0.02552149f, 0.28453711f, 0.11445022f, 0.10408443f, 0.10176317f, 0.11063226f, 0.16128992f, 0.00090455f, 
    -0.01985881f, 0.28430060f, 0.44840026f, 0.09331053f, 0.23180917f, -0.12922063f, -0.06131379f, -0.13704289f, 
    0.04490511f, -0.12518989f, 0.07827645f, 0.22152638f, -0.13669829f, -0.17458016f, 0.12179397f, -0.01110363f, 
    -0.13303682f, 0.36219504f, -0.00766778f, 0.15280113f, -0.14635623f, 0.05344642f, -0.36599886f, 0.41015181f, 
    -0.16110259f, 0.29441997f, 0.00798999f, -0.24186482f, 0.30868536f, 0.22785144f, 0.16601838f, 0.06511095f, 
    -0.03722010f, 0.17695898f, 0.35393709f, -0.03331944f, 0.17956202f, 0.10061954f, -0.05054827f, -0.05968723f, 
    -0.28711921f, -0.29247415f, -0.04522281f, 0.17592357f, 0.16688475f, 0.07286702f, -0.04598441f, 0.05705342f, 
    -0.03900589f, -0.28749475f, 0.14403617f, -0.10906839f, -0.12784690f, 0.17635715f, 0.28685987f, 0.10954119f, 
    0.00843394f, 0.38923448f, -0.03554957f, 0.15540650f, -0.06751058f, -0.23942058f, -0.13345914f, -0.00161228f, 
    0.12422519f, -0.11811344f, 0.11041071f, 0.32875365f, -0.40831503f, 0.12754855f, -0.02247101f, 0.01647207f, 
    0.04174586f, 0.30806914f, 0.16467108f, 0.56636482f, -0.06832273f, -0.21501684f, -0.01496510f, 0.10587988f, 
    -0.02730324f, 0.16479836f, -0.28336889f, 0.25501722f, 0.32573855f, -0.10494304f, 0.09905039f, -0.00978109f, 
    -0.04756809f, -0.19998844f, -0.04953972f, -0.03077274f, 0.39834681f, -0.06563660f, -0.13072982f, 0.42388746f, 
    0.04614707f, -0.05471146f, -0.22005531f, 0.31961575f, -0.22815736f, 0.05681233f, -0.01547798f, -0.01551508f, 
    -0.20205370f, 0.01654633f, 0.07738886f, -0.04172675f, -0.16293728f, -0.14847772f, 0.07111263f, 0.08499038f, 
    -0.10295309f, -0.41123167f, 0.38372827f, -0.21198948f, 0.25473440f, -0.02441367f, -0.14686082f, -0.44791019f, 
    0.10634840f, 0.04087355f, 0.13839710f, 0.31986409f, -0.47638354f, 0.17075104f, -0.05656032f, 0.01651536f, 
    -0.15038702f, -0.23891373f, 0.04630218f, 0.10008264f, 0.31581166f, -0.02577422f, -0.03674641f, -0.15543622f, 
    0.17252302f, -0.05701237f, -0.00868447f, -0.38249430f, -0.00922911f, 0.29233289f, 0.00169890f, -0.11666864f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10523114f, 0.13691075f, -0.12656908f, -0.02991630f, 0.10907806f, -0.11965184f, 0.00434759f, 0.03035340f, 
    0.06844471f, -0.02526509f, 0.16365969f, 0.12491711f, -0.22878376f, 0.27174190f, 0.22589010f, 0.06951241f, 
    0.24582414f, 0.13045296f, 0.00810167f, 0.22026850f, -0.08819320f, 0.10406160f, 0.11187126f, 0.26373935f, 
    -0.03423446f, 0.09497840f, -0.15286198f, -0.09804035f, 0.07721873f, 0.11638992f, 0.11250558f, -0.10872587f, 
    0.12099960f, 0.04428486f, 0.12808372f, -0.05644305f, 0.29000360f, -0.01567844f, 0.10012481f, 0.06252142f, 
    0.22459935f, -0.05817123f, 0.32428014f, 0.00545266f, -0.03219534f, -0.03997852f, -0.24844928f, -0.01391070f, 
    -0.21286622f, 0.01115179f, 0.11932251f, -0.06808650f, 0.26579276f, -0.13565961f, 0.10807221f, 0.18053702f, 
    0.13067129f, 0.16463383f, -0.03060373f, 0.10058174f, -0.16221228f, 0.08737433f, -0.07805446f, 0.23259085f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02618536f, -0.03260172f, -0.17268415f, 0.37491927f, -0.02747266f, 0.35898900f, -0.42815998f, -0.46692505f, 
    0.20056476f, 0.07034072f, 0.12413292f, 0.30344319f, -0.29351339f, 0.26404119f, 0.01028039f, -0.04263705f, 
    -0.05555031f, 0.34316403f, -0.09456774f, 0.12685497f, -0.09974805f, -0.20388015f, 0.21574911f, 0.37098464f, 
    -0.62981349f, 0.06955129f, -0.26297104f, 0.00153445f, -0.04771532f, -0.60979092f, -0.16698030f, 0.16780566f, 
    0.10457564f, -0.49798065f, -0.32809970f, 0.04125856f, 0.11801206f, -0.13521600f, 0.09215059f, 0.05137977f, 
    0.10722136f, 0.14908510f, -0.00066993f, -0.10124497f, -0.05589984f, -0.03231776f, -0.37556911f, 0.04096203f, 
    -0.97233725f, -0.11077061f, 0.18523195f, 0.31878302f, 0.17620456f, -0.68534482f, 0.13230070f, -0.46518055f, 
    0.03529414f, -0.14006588f, -0.01658965f, -0.17607896f, -0.13414359f, -0.00561674f, 0.18626945f, 0.06047798f, 
    -0.26954374f, 0.28238651f, 0.11942469f, 0.17280276f, 0.14521106f, 0.32974082f, -0.00995054f, -0.12053390f, 
    -0.53405607f, -0.09982347f, -0.02125375f, -0.00965567f, -0.65107286f, -0.04560855f, 0.04367035f, -0.12930602f, 
    0.12409649f, 0.05847407f, 0.23488043f, 0.40098488f, -0.17681740f, -0.15904613f, -0.47783485f, 0.08407085f, 
    -0.32733446f, 0.07145426f, -0.29317728f, -0.14055455f, 0.02499944f, 0.06146047f, 0.16330086f, 0.15610997f, 
    0.09064649f, -0.68651551f, 0.19515096f, 0.05366905f, -0.09559680f, 0.06332842f, -0.38962537f, -0.05827291f, 
    -0.29133934f, 0.05658453f, 0.22185798f, 0.04570091f, -0.08591563f, 0.07105026f, -0.06769366f, -0.06207713f, 
    0.52687383f, 0.05388560f, 0.12574427f, -0.11832266f, -0.21353126f, 0.24222368f, 0.05243216f, 0.06734217f, 
    -0.12593482f, 0.13572890f, 0.11214939f, 0.09527732f, 0.14225508f, -0.17883638f, 0.30759498f, -0.21647432f, 
    -0.35707039f, 0.25349545f, 0.21103287f, 0.16458091f, 0.07531387f, 0.02163032f, -0.05583263f, 0.05053964f, 
    -0.71882671f, 0.09212243f, 0.05267435f, 0.14046119f, 0.05816910f, -0.67596972f, -0.11434861f, -0.28938198f, 
    0.40093675f, 0.15532346f, -0.05648328f, -0.22914451f, -0.48262033f, -0.03776504f, 0.05263656f, 0.10149563f, 
    0.08784119f, -0.22943363f, 0.32513765f, -0.12010679f, 0.02182136f, 0.18734404f, -0.02212790f, -0.31256732f, 
    -1.00744152f, 0.28675076f, 0.25506178f, 0.11387303f, 0.03021198f, 0.07068504f, 0.05229403f, 0.10219381f, 
    0.19266975f, 0.14808054f, -0.11458565f, 0.02320148f, -0.06691950f, -0.00634858f, -0.51047713f, 0.09359637f, 
    -0.85855359f, 0.04496553f, 0.52792066f, -0.07776952f, -0.11814176f, -0.30831382f, -0.12700555f, -0.09243462f, 
    -0.57761925f, 0.00556927f, 0.11744241f, 0.13473715f, 0.21862245f, -0.71456712f, -0.24025086f, -0.23581848f, 
    0.04267379f, -0.28915843f, -0.15150562f, -0.11980226f, 0.09867797f, -0.61567587f, 0.02805731f, -0.04593274f, 
    0.20896874f, -0.07103773f, 0.21332788f, 0.15620272f, 0.35817173f, -0.15885384f, -0.17116009f, 0.08060367f, 
    0.12384318f, -0.00747114f, -0.11384258f, -0.24227175f, 0.05148635f, -0.24042170f, 0.22132491f, -0.19406661f, 
    -0.31363177f, 0.03938055f, 0.20816334f, 0.08498873f, 0.10713384f, -0.68439060f, 0.06866809f, -0.56811333f, 
    -0.01650767f, 0.35115701f, 0.11459551f, 0.02006496f, 0.14949897f, 0.00289659f, 0.11042259f, 0.11151524f, 
    0.08563822f, 0.30024081f, -0.47991589f, 0.04754373f, 0.07621223f, 0.06531463f, 0.04400842f, 0.08580545f, 
    -0.38670358f, 0.10534401f, 0.23700632f, 0.02390904f, -0.51455569f, 0.26327479f, 0.04623672f, -0.15100737f, 
    -0.01537689f, -0.25998369f, -0.04595912f, 0.04720412f, 0.04400137f, -0.08288877f, -0.59495324f, -0.09473730f, 
    0.26759696f, -0.17760584f, -0.03457044f, 0.03832053f, -0.03110005f, -0.29760367f, -0.07046730f, -0.03333103f, 
    0.15439944f, -0.09003101f, -0.40286654f, 0.20361172f, 0.02521507f, 0.18854439f, -0.59160060f, 0.11181071f, 
    0.01634130f, 0.04403526f, -0.28879398f, -0.29715049f, -0.53176421f, 0.18421817f, 0.13488075f, -0.01153994f, 
    0.20671907f, -0.34107804f, 0.04911264f, -0.14961660f, 0.01870868f, 0.04164480f, 0.25275776f, -0.34065378f, 
    0.01099260f, 0.16963835f, -0.34139219f, 0.03140173f, 0.26496032f, -0.03253493f, 0.29882616f, -0.27455562f, 
    0.11412628f, -0.53891414f, -0.12288327f, -0.08464587f, -0.05239571f, -0.13284148f, 0.16736743f, -0.03812043f, 
    0.03853473f, -0.11819069f, 0.11120228f, -0.06249748f, 0.24687518f, -1.01825058f, 0.03285822f, 0.19436486f, 
    -0.02388610f, -0.20994295f, 0.03805498f, -0.00155886f, -0.17928784f, 0.24038345f, -0.22136292f, 0.18277980f, 
    0.42189902f, 0.04642645f, -0.17161357f, -0.04125401f, -0.25488418f, -0.14564826f, 0.13379408f, -0.03773087f, 
    0.14448580f, -0.14594579f, -0.20093352f, -0.20952418f, -0.00721791f, 0.34944448f, 0.24137212f, -0.93859953f, 
    -0.35086888f, -0.24885871f, 0.23632815f, 0.28088185f, 0.08568098f, 0.16520785f, -0.44091910f, 0.08952436f, 
    -0.07031821f, 0.27847746f, -0.35532039f, 0.03722240f, 0.02960550f, -0.09167977f, 0.09219398f, -0.10207930f, 
    0.32099280f, -0.02337007f, 0.08478080f, -0.04827108f, 0.04598635f, -0.10508938f, -0.25527239f, -0.39389727f, 
    0.19520563f, 0.02641783f, 0.21471830f, 0.04245439f, 0.05480094f, 0.06599128f, 0.50753605f, -0.09821260f, 
    0.27625388f, -0.07154024f, -0.28209797f, -0.20607573f, 0.08098581f, 0.22638530f, 0.14047663f, 0.05844127f, 
    -0.18878551f, 0.16779816f, 0.08690399f, -0.55798596f, -0.32641274f, -0.24427551f, 0.31215438f, 0.00893504f, 
    0.13429171f, 0.01807554f, -0.01369992f, -0.49511907f, 0.07299179f, -0.28865814f, 0.01303998f, 0.29228440f, 
    -0.08889724f, 0.04754172f, 0.05725976f, -0.37210295f, -0.00515511f, 0.07560481f, 0.54389334f, 0.02224496f, 
    -0.46703771f, -0.52143282f, -1.02290237f, -0.37706763f, -0.14658314f, 0.24665289f, 0.10924173f, 0.09633912f, 
    0.12722549f, -0.25945729f, 0.26222757f, -0.06924814f, 0.11066165f, 0.35484225f, -0.02812522f, -0.16231634f, 
    0.20171908f, 0.29022023f, 0.16261718f, -0.09542374f, 0.03812888f, -0.06457986f, 0.18092832f, -0.43986696f, 
    -0.41616327f, -0.01422056f, -0.06578711f, 0.04896798f, -0.00838282f, 0.01316610f, -0.88051826f, 0.10762536f, 
    -0.85010469f, -0.12103476f, -0.18051718f, 0.17876109f, -0.40179339f, -0.35184470f, 0.25392762f, -0.16303797f, 
    -0.16746484f, 0.31470001f, -0.12932356f, -0.23501958f, -0.06105674f, -0.37296450f, -0.32639766f, 0.35608193f, 
    -0.11859095f, -0.21728136f, -0.16874141f, 0.27058914f, 0.05886731f, 0.15322034f, -0.63244629f, -0.43240634f, 
    0.08443938f, 0.09017668f, -0.26528236f, 0.36050239f, 0.11603865f, -0.04061444f, -0.33281139f, -0.17741498f, 
    -0.54382735f, 0.04387888f, -0.17416465f, -0.26007873f, 0.03664950f, -0.13228796f, 0.09225456f, -0.07983866f, 
    -0.31719813f, 0.16037883f, -0.32664850f, -0.11769191f, -0.08959271f, -0.02777214f, -0.05515644f, 0.22118467f, 
    0.00890629f, -0.21349119f, -0.34466046f, -0.02116307f, -0.14947797f, -0.02713980f, 0.09447423f, 0.11278002f, 
    -0.75706750f, -0.00324342f, -0.24034786f, -0.07473941f, 0.08669557f, -0.02830154f, 0.30448902f, 0.03442080f, 
    0.13686426f, -0.07434861f, 0.00567284f, 0.15632342f, -0.13967574f, 0.21921696f, 0.09931055f, -0.43255374f, 
    0.09965603f, -0.31866267f, -0.09191943f, -0.10820448f, 0.12305282f, 0.25921914f, 0.17255278f, -0.42204234f, 
    0.18026985f, -0.13640024f, 0.18152931f, -0.04494977f, -0.28388152f, 0.07599949f, -0.00288516f, 0.17918557f, 
    -0.05931588f, -0.06954783f, -0.48912019f, -0.04848710f, 0.35896614f, -0.10956135f, -0.44000790f, -0.27232379f, 
    0.09576452f, 0.06618495f, 0.12601298f, -0.12705433f, 0.18733267f, -0.24218215f, -0.38114759f, -0.53484911f, 
    0.31965971f, 0.33540243f, -0.23761505f, 0.02575917f, -0.00331556f, -0.06399880f, -0.20855586f, 0.43817306f, 
    0.21669695f, -0.27425918f, 0.18816361f, -0.08309662f, -0.69996232f, -0.07786237f, -0.41746289f, -0.02051923f, 
    0.11810485f, -0.17951381f, 0.24027608f, -0.03269629f, -0.00245677f, 0.05479289f, -0.25030246f, 0.07329305f, 
    -0.61795986f, 0.09755421f, -0.15591085f, -0.37914920f, 0.03418068f, 0.16742843f, -0.57203543f, 0.09944918f, 
    0.44066700f, -0.06965461f, -0.01883042f, 0.01205690f, -0.04286066f, 0.17857648f, 0.06345523f, -0.30971444f, 
    -0.66684377f, -0.00043405f, 0.16042078f, -0.51572275f, 0.28516597f, -0.36021572f, -0.76911086f, 0.21939979f, 
    0.04546528f, -0.03596295f, -0.12045416f, 0.02284061f, 0.13447917f, -0.74706197f, 0.26396358f, 0.39134881f, 
    0.12806977f, -0.17163645f, 0.45863941f, -0.41672212f, -0.41895017f, -0.01469009f, 0.15554346f, 0.19732225f, 
    -0.04756704f, -0.40140778f, 0.23393099f, 0.03726902f, -0.02912498f, 0.14361948f, 0.23275696f, 0.10923415f, 
    0.17702866f, -0.27321956f, 0.05295581f, -0.06073059f, 0.08826505f, 0.05168813f, -0.07725021f, -0.16839838f, 
    -0.02089055f, 0.46389377f, 0.12923691f, -0.02478052f, 0.07836282f, -0.06119260f, 0.40286085f, 0.06745873f, 
    -0.27834472f, 0.05761291f, -0.82092059f, 0.20243362f, 0.23686728f, -0.18614037f, -0.09313089f, 0.15843283f, 
    -0.22236861f, -0.11866778f, 0.07687444f, 0.03519882f, -0.69431835f, 0.19435063f, -0.34011987f, 0.13994062f, 
    0.01217183f, 0.08201768f, -0.15923157f, -0.18048739f, 0.15917867f, -0.31894532f, 0.29914570f, 0.23875670f, 
    -0.07413789f, -0.14558759f, 0.25048292f, -0.37221977f, -0.18321662f, 0.09313168f, -0.44789025f, 0.20412390f, 
    0.35528439f, -0.17374517f, -0.43109918f, 0.36959696f, -0.01634988f, -0.61921191f, 0.00787685f, -0.84899402f, 
    0.26783195f, -0.23029156f, -0.64269686f, -0.13761827f, 0.06515010f, -0.59655297f, 0.15299276f, -0.12468337f, 
    -0.14107689f, 0.07301275f, -0.13413218f, -0.08191880f, -0.28515968f, 0.01839926f, 0.10001753f, -0.00170889f, 
    0.06000907f, -0.46790373f, -0.02887264f, -0.12260109f, 0.06496348f, -0.05288056f, -0.12539530f, 0.02799807f, 
    -0.02221217f, -0.06448054f, -0.10350890f, -0.13159916f, -0.00222937f, 0.08759120f, -0.12361607f, 0.31843099f, 
    0.31160384f, -0.09939439f, -0.04900658f, 0.32146475f, 0.26296434f, 0.05691827f, -0.19166873f, -0.32185677f, 
    -0.28577173f, -0.62666792f, -0.29092386f, -0.10296219f, -0.51483506f, 0.24880081f, 0.29126722f, -0.23068483f, 
    0.12298771f, -0.01748379f, 0.30366120f, -0.40705630f, 0.00857037f, 0.05792773f, 0.16690730f, -0.06701493f, 
    -0.27891228f, 0.24051256f, -0.11766147f, 0.03540658f, 0.32420304f, -0.03819428f, 0.07743292f, -0.19685362f, 
    0.29087910f, 0.37139472f, 0.23992421f, 0.03359823f, -0.10353691f, -0.15129127f, -0.66016906f, 0.01439130f, 
    -0.03680490f, 0.19191106f, -0.20145048f, -0.04611024f, -0.06890449f, -0.14473149f, -0.03748870f, 0.25902912f, 
    0.28860462f, -0.21224107f, -0.13358977f, 0.05797905f, -0.09450378f, -0.09757394f, -0.64278746f, -0.12227739f, 
    0.11773030f, 0.10350595f, -0.27693734f, 0.30925190f, 0.20663548f, -0.07392871f, -0.32845703f, -0.09627263f, 
    -0.16901422f, 0.01633597f, 0.15935190f, 0.16507699f, 0.15638199f, -0.29599926f, -0.33633202f, 0.27892670f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01293517f, -0.03040631f, -0.17570134f, -0.17008311f, 0.17841299f, 0.11156371f, 0.01053371f, -0.16341251f, 
    -0.16862859f, 0.10749368f, 0.08460371f, -0.01544494f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
