#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.58544600f, -0.82549393f, -0.46875116f, 0.62611675f, 0.57719618f, 0.14310564f, 0.16755471f, 0.19344039f, 
    -0.18636498f, -0.69967967f, -0.66510797f, 0.44949749f, 0.02722942f, -0.41353405f, 0.61230379f, -0.16560276f, 
    0.26387250f, 0.50151974f, -0.34312615f, 0.73130572f, -0.45761311f, 0.59555656f, 0.29124683f, -0.16667823f, 
    -0.22748479f, 0.24600603f, -0.16172980f, 0.62010676f, 0.20806253f, 0.65800142f, 0.37808543f, 0.02496690f, 
    -0.03291271f, 0.23083243f, 0.07106367f, -0.17553489f, -0.89061010f, -0.58214378f, -0.86382711f, -0.15459150f, 
    -0.40908876f, 0.48018983f, 0.15104066f, 0.11812567f, -0.10341471f, -0.56475616f, 0.52224708f, -0.48815158f, 
    -0.12525846f, -0.39494625f, 0.01869867f, 0.13108663f, -0.18125358f, -0.38506979f, -0.72898066f, 0.63434857f, 
    -0.13592722f, 0.15731025f, 0.01233346f, -0.42652854f, 0.28782272f, -0.16972162f, 0.08855955f, 0.42494643f, 
    -0.21259074f, 0.26425886f, 0.33836287f, 0.25749391f, 0.07773873f, -0.02256504f, -0.22885484f, -0.55342293f, 
    -0.05170719f, -0.24190126f, 0.42521822f, -0.98527807f, 0.45639676f, -0.41425389f, 0.32039887f, -0.04919726f, 
    0.06287508f, 0.47467959f, -0.28928849f, 0.69502878f, 0.63205421f, 0.09861632f, -0.14975324f, -0.10652608f, 
    -0.35022545f, 0.32504779f, 0.42891482f, 0.57409763f, -0.28689608f, -0.32541075f, -0.14766809f, 0.28059983f, 
    0.15738787f, 0.53474617f, -0.07549318f, -0.00407836f, -0.06054927f, 0.09834559f, -0.48010516f, 0.46769342f, 
    0.71900052f, -0.26273409f, -0.22297844f, -0.65927422f, -0.59905249f, -0.17085367f, -0.41260210f, 0.10397314f, 
    0.84088784f, -0.30908954f, -0.14386688f, -0.26394698f, -0.18644015f, 0.46702355f, 0.44570732f, 0.28091678f, 
    -0.77058321f, -0.96054339f, -0.61691749f, -0.02906707f, -0.33333674f, -0.10851265f, -0.74833137f, 0.60245365f, 
    0.28323978f, 0.07380747f, -0.35557082f, -0.50519407f, -0.36987385f, -0.24747872f, -0.38346919f, 0.07066128f, 
    -0.29051080f, -0.59607226f, 0.37484899f, -0.69528913f, -0.35133374f, -0.60860103f, -0.27185914f, 0.23616107f, 
    0.80768782f, 0.43729436f, 0.69499630f, 0.16885394f, -0.55608302f, 0.02878141f, 0.16681653f, 0.32680893f, 
    0.07224183f, 0.57755965f, -0.44192499f, -0.26480561f, 0.67302263f, -0.78247106f, 0.26078644f, 0.07672077f, 
    0.11231229f, 0.09086137f, 0.39272735f, 0.65083009f, -0.32031536f, -0.54513645f, -0.05374371f, -0.66488761f, 
    0.04903691f, 0.02446194f, 0.38419011f, -0.67458516f, 0.41238773f, 0.72368675f, 0.50851953f, 0.58712369f, 
    -0.14574656f, -0.26209047f, -0.12747285f, -0.11876809f, 0.42122853f, -0.68093759f, -0.45520169f, -0.62198883f, 
    0.31475672f, 0.38373497f, -0.12460311f, 0.41877076f, 0.14973779f, 0.37805790f, 0.26181579f, -0.17975940f, 
    -0.41536498f, 0.18242356f, 0.14768520f, -0.53493130f, -0.47783086f, 0.27454570f, 0.44172609f, 0.28515643f, 
    0.21425170f, -0.48626697f, 0.66680193f, 0.50633645f, 0.35915649f, -0.25961116f, -0.32579896f, -0.04072370f, 
    -0.77058077f, 0.05209503f, -0.64284527f, -0.44281191f, -0.51795495f, 0.01143635f, -0.26195067f, -0.13564833f, 
    0.38296738f, -0.19379444f, 0.47538510f, -0.56008351f, 0.54388064f, -0.55304444f, -0.32890487f, 0.25401151f, 
    -0.24373673f, -0.21751618f, 0.16169034f, 0.63994306f, 0.10705221f, -0.06663133f, -0.63699996f, 0.24661134f, 
    0.30265197f, 0.42819977f, 0.56230044f, 0.39975837f, -0.02780119f, 0.41567683f, 0.26379493f, -0.02768972f, 
    0.41044375f, 0.51937801f, -0.23715439f, 0.46778125f, 0.13914706f, 0.33287367f, 0.46869609f, 0.40828162f, 
    0.56383353f, -0.49469957f, 0.34456465f, 0.07735302f, 0.71550924f, 0.93277359f, -0.52025354f, 0.11650445f, 
    -0.23698078f, -0.23006511f, 0.24700409f, -0.22954004f, -0.19043997f, -0.84309924f, -0.60476094f, 0.15821984f, 
    0.74605536f, 0.65372825f, 0.54679596f, 0.12014872f, -0.36911413f, 0.17618239f, 0.22493453f, 0.69700897f, 
    0.65455961f, -0.12210446f, -0.08423461f, 0.42663842f, -0.14732955f, -0.22992122f, 0.01567080f, 0.45276707f, 
    -0.23481591f, 0.18928139f, 0.60588193f, 0.25270343f, 0.05980662f, -0.44626755f, -0.14685328f, -0.32108778f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04258006f, -0.22072098f, 0.03381654f, 0.25661081f, 0.30409542f, 0.01763001f, 0.02084642f, -0.10009549f, 
    0.11386363f, -0.16922447f, -0.09244736f, -0.23706096f, -0.12241820f, 0.18388230f, 0.18464603f, -0.13511804f, 
    -0.28648043f, -0.25484514f, 0.09829120f, -0.02031966f, -0.06816788f, -0.02389166f, -0.27890369f, 0.15340370f, 
    0.15293173f, -0.09556430f, -0.02814517f, -0.05273132f, -0.38325068f, -0.03093111f, 0.27523920f, -0.17466497f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04820606f, -0.04115017f, 0.00374397f, -0.06488898f, -0.05612158f, -0.03453526f, 0.04680915f, -0.02838253f, 
    0.01404829f, 0.04213480f, -0.01093899f, -0.05691558f, 0.04686604f, 0.01766085f, 0.02837817f, -0.00282149f, 
    -0.01904438f, -0.01139369f, 0.05097237f, 0.00673953f, -0.05249222f, -0.02566773f, -0.05011438f, -0.00314197f, 
    0.04596939f, 0.01893129f, -0.06170293f, -0.06022719f, 0.01987308f, -0.01127836f, 0.00552091f, -0.00094482f, 
    -0.05310845f, 0.03503191f, -0.03250406f, -0.03273544f, 0.02382057f, -0.04753106f, -0.05269504f, -0.05186477f, 
    0.04427488f, -0.03350727f, 0.02236624f, 0.02888185f, -0.04721157f, -0.04089237f, -0.02097882f, 0.01088158f, 
    -0.04997623f, -0.04672462f, -0.01468801f, -0.01949420f, 0.03065892f, 0.00894469f, 0.05017643f, -0.04847653f, 
    0.04098182f, -0.04243549f, 0.04099948f, -0.06328570f, -0.05966929f, -0.03679062f, -0.04416254f, 0.02695903f, 
    -0.05322736f, -0.05749767f, -0.04158410f, 0.02539831f, -0.01443829f, -0.06387522f, 0.04845645f, -0.03987981f, 
    -0.02006129f, 0.03226433f, -0.01777739f, 0.01717531f, -0.04478970f, -0.02247572f, 0.00030459f, -0.06249324f, 
    -0.02751029f, -0.03848173f, -0.05717329f, -0.01841625f, -0.01813147f, 0.03480521f, -0.04550346f, 0.01730727f, 
    -0.01943935f, 0.02545513f, -0.03228473f, -0.04747266f, 0.01668239f, -0.04755678f, 0.03274720f, 0.03088575f, 
    -0.00246536f, -0.05200585f, -0.06454532f, 0.04608050f, -0.00444748f, -0.02415963f, -0.00032501f, 0.02443435f, 
    -0.06461237f, -0.01713731f, -0.00492877f, 0.00134781f, 0.00454466f, 0.00070060f, -0.04059762f, -0.00440866f, 
    -0.05892119f, -0.03960695f, 0.04661804f, -0.05256747f, -0.00630215f, 0.03122781f, -0.04848727f, 0.00714451f, 
    0.01594860f, 0.02288946f, 0.05041847f, -0.04565572f, 0.02594667f, -0.05136514f, 0.00210809f, 0.01416003f, 
    0.02844927f, 0.03813207f, -0.00375953f, 0.02875900f, -0.00691565f, 0.01493585f, 0.00251754f, 0.03038649f, 
    0.01146807f, 0.00569209f, -0.01251962f, 0.03054628f, 0.04837726f, 0.01882444f, -0.05174394f, 0.02096670f, 
    -0.03700253f, 0.01660775f, 0.03803073f, -0.00596266f, -0.01799850f, 0.03327404f, 0.03159237f, -0.04510233f, 
    -0.00087613f, 0.03558300f, 0.03599296f, -0.02506728f, -0.04752078f, 0.00964352f, -0.01938700f, -0.03890886f, 
    -0.05813394f, 0.04295602f, -0.03610079f, 0.01674901f, -0.02213530f, -0.01142856f, 0.00617607f, -0.01437232f, 
    0.05139604f, -0.00315820f, -0.00480689f, 0.05069108f, -0.04358226f, 0.04550399f, -0.00195861f, 0.02997613f, 
    -0.00433273f, 0.01223326f, 0.01231126f, -0.04793649f, -0.02293188f, 0.03645306f, -0.05839884f, 0.00808852f, 
    0.03820186f, -0.03236594f, -0.03943712f, 0.00679111f, -0.03517279f, -0.05563024f, 0.03784791f, -0.05438606f, 
    0.01162595f, -0.00463871f, -0.05432880f, 0.00537712f, -0.04139369f, -0.01152838f, 0.04622406f, -0.05092445f, 
    -0.04254720f, 0.04022853f, -0.06356752f, 0.01143659f, -0.04923841f, 0.01676284f, 0.00098443f, 0.00167834f, 
    0.02556183f, -0.00766317f, -0.05607407f, -0.06232670f, 0.02899924f, -0.05723396f, -0.05552044f, 0.00193823f, 
    -0.03307049f, -0.00954623f, 0.02170191f, 0.02590080f, -0.01149944f, -0.06323174f, 0.04823323f, 0.01778117f, 
    -0.05614324f, -0.05416488f, -0.06019155f, -0.02014674f, 0.03425094f, -0.02271263f, -0.05796589f, -0.06321754f, 
    0.01989280f, 0.01343176f, 0.02635267f, -0.02289191f, 0.05177344f, 0.00615497f, -0.04013963f, 0.03937254f, 
    -0.03595497f, 0.04283940f, 0.01053941f, 0.03792357f, -0.02687715f, -0.06095995f, 0.03621055f, 0.02327055f, 
    0.00574781f, -0.02199333f, 0.02707327f, -0.02985410f, -0.00851280f, -0.04475190f, -0.02507380f, 0.02755804f, 
    -0.02546195f, 0.00648235f, 0.03295580f, -0.05877265f, 0.01522277f, 0.00666812f, -0.04574612f, -0.01834459f, 
    0.03517309f, 0.00446429f, -0.06594597f, 0.00421946f, 0.04485381f, -0.04882280f, -0.02988121f, -0.04611811f, 
    -0.00390100f, 0.02083117f, -0.05263047f, -0.02295856f, -0.02480814f, 0.04102768f, -0.00214627f, 0.03165412f, 
    -0.04895248f, -0.04550489f, 0.04121777f, -0.02687235f, 0.04754318f, -0.05765689f, -0.01413875f, 0.00989258f, 
    0.01827414f, 0.04770412f, -0.02074943f, -0.04111450f, -0.04606970f, -0.04260244f, -0.00408886f, 0.02341126f, 
    0.03813475f, -0.03362953f, -0.04424741f, 0.01261247f, -0.01290186f, -0.00983059f, 0.02018271f, -0.03779997f, 
    0.04100514f, -0.01484604f, -0.06705398f, 0.01167652f, 0.04917951f, 0.00864555f, 0.02513548f, -0.04273196f, 
    -0.06085489f, 0.05224521f, 0.00056116f, 0.04533916f, -0.02502997f, -0.05216857f, -0.02222570f, -0.05045540f, 
    0.00074396f, -0.06071899f, 0.03934913f, 0.04784013f, -0.02302634f, -0.05922587f, 0.02625974f, -0.04019428f, 
    0.04500436f, -0.05559115f, -0.01981864f, 0.00644623f, -0.03421689f, 0.00464231f, 0.04182071f, 0.00726996f, 
    0.00017845f, 0.05066808f, 0.03288260f, -0.02666746f, 0.03704360f, 0.03819073f, -0.00890104f, 0.00684902f, 
    -0.01737643f, 0.02866292f, 0.03174341f, -0.05180512f, 0.02045471f, 0.01389432f, 0.04086502f, 0.03234634f, 
    -0.05449701f, 0.01193772f, -0.03827546f, 0.00798992f, -0.03311682f, -0.02394070f, 0.00295495f, -0.04444557f, 
    0.04500057f, -0.02728553f, 0.02136238f, -0.05293245f, -0.06728181f, 0.00680948f, 0.00089240f, -0.03278429f, 
    -0.02501770f, 0.02912110f, -0.05007192f, -0.03281887f, -0.03253237f, -0.00444575f, -0.00219001f, 0.00016538f, 
    0.00852600f, -0.02438465f, -0.00758073f, -0.05485425f, -0.02348860f, -0.06080687f, 0.04188287f, 0.02896360f, 
    0.03039282f, -0.04614690f, -0.05585667f, -0.02707926f, -0.01447393f, 0.02058599f, -0.05604007f, -0.02322581f, 
    -0.01328820f, -0.01436473f, 0.02941746f, 0.00780571f, -0.02939969f, 0.00404164f, -0.02496531f, 0.01223554f, 
    -0.04284444f, 0.04563558f, -0.01139929f, 0.00983985f, -0.01319606f, 0.01667928f, -0.01905271f, -0.02083286f, 
    -0.03214205f, 0.04058308f, 0.04286592f, 0.01885820f, -0.02463851f, 0.05704366f, 0.00004464f, -0.04497893f, 
    0.01387625f, -0.03049492f, -0.01189059f, -0.04030469f, 0.01270908f, -0.03520867f, -0.04896165f, -0.00223910f, 
    0.04903980f, -0.01738807f, 0.02048053f, -0.02978461f, 0.02685317f, -0.05392540f, -0.03070497f, 0.02292441f, 
    0.01668325f, 0.02848086f, 0.03051936f, 0.04485523f, -0.04243373f, 0.00924167f, 0.04039164f, -0.01588169f, 
    0.01423451f, -0.02548317f, 0.01622363f, 0.01589767f, -0.02148784f, -0.05034243f, 0.01925431f, 0.03953267f, 
    0.05620070f, -0.03366002f, -0.04060805f, -0.01750236f, -0.03463833f, 0.01134711f, 0.03444402f, 0.00514081f, 
    -0.01240886f, -0.05145960f, 0.03448872f, 0.02138383f, 0.00548082f, -0.00271264f, 0.03227798f, 0.03809898f, 
    0.03962952f, 0.01512213f, 0.05035660f, -0.00492580f, 0.04367002f, -0.00496932f, -0.03564276f, 0.02153518f, 
    0.03506438f, 0.04799369f, -0.06236457f, -0.06528088f, 0.01095388f, 0.00615476f, 0.01646935f, 0.01023120f, 
    -0.05707767f, 0.01801812f, -0.03806751f, 0.01883261f, 0.03209958f, -0.04897527f, 0.00071105f, 0.01420566f, 
    -0.04213601f, -0.04821069f, 0.03687092f, 0.03239036f, -0.04570101f, -0.02281322f, -0.05822353f, 0.01509345f, 
    -0.02588148f, -0.05761124f, -0.01640295f, -0.01693031f, 0.02926706f, -0.03995742f, 0.04120839f, -0.03255776f, 
    -0.02818218f, 0.03215868f, 0.02123145f, -0.04794458f, -0.03629337f, 0.03683463f, -0.01499317f, -0.06225071f, 
    -0.03243091f, 0.00040905f, 0.02393831f, 0.03995357f, -0.01435592f, -0.01186781f, 0.04226896f, 0.01162951f, 
    -0.03567762f, 0.01671268f, -0.04372163f, -0.01710983f, -0.02150921f, -0.02439523f, -0.02348170f, 0.05144512f, 
    -0.01519584f, 0.04689180f, -0.00714675f, -0.06281660f, -0.05588878f, 0.00458265f, -0.05662988f, 0.03882938f, 
    -0.03556116f, -0.02101888f, -0.03049430f, 0.00551945f, -0.05729035f, -0.00084079f, -0.05444655f, 0.05139519f, 
    -0.01956210f, -0.04530764f, -0.01388037f, -0.00855030f, 0.02995311f, -0.01663480f, -0.03931225f, 0.04177438f, 
    0.01879020f, -0.04603544f, -0.00226702f, -0.00604833f, -0.06383730f, -0.04150079f, 0.00411270f, -0.02709937f, 
    0.01361687f, -0.04594342f, -0.06469148f, -0.05176155f, -0.02862613f, -0.06220630f, 0.02333509f, 0.00267711f, 
    0.00749696f, 0.04248607f, -0.03195043f, -0.05352365f, -0.05317048f, -0.05214123f, 0.03522314f, -0.06444395f, 
    -0.06867824f, -0.00811164f, 0.01467786f, 0.04461559f, -0.05166091f, 0.04577365f, 0.03013897f, 0.00167713f, 
    -0.04170822f, -0.01829145f, -0.04784159f, 0.02275207f, 0.02658010f, 0.02588771f, 0.01390998f, 0.03595491f, 
    -0.04108093f, 0.04262266f, -0.03734225f, -0.05315721f, -0.03455876f, -0.00499635f, -0.02756703f, -0.02760413f, 
    -0.00015838f, 0.02481279f, -0.07378534f, 0.01504492f, 0.00203175f, -0.04679750f, 0.03868441f, 0.02160029f, 
    0.02061501f, 0.00016068f, -0.06892002f, -0.05617903f, -0.05627485f, -0.02956006f, 0.05120675f, 0.01203203f, 
    -0.02654047f, -0.00551998f, -0.00945698f, -0.06567343f, -0.00826896f, -0.01895497f, -0.03984735f, 0.04665829f, 
    -0.01788609f, -0.02053288f, -0.07528088f, -0.06406638f, -0.05364665f, -0.06288950f, 0.00766349f, 0.01351815f, 
    0.03479112f, 0.03434179f, -0.05485339f, -0.03086333f, 0.01974812f, -0.04106199f, -0.03022765f, 0.03391754f, 
    0.02478498f, 0.00569496f, -0.04609445f, -0.06092092f, 0.04112765f, -0.03856327f, 0.03434905f, -0.05298237f, 
    0.01088821f, -0.05627548f, -0.04266272f, 0.04201880f, 0.00718573f, -0.04962049f, -0.02341944f, 0.00490834f, 
    -0.05059526f, 0.00064439f, -0.06120938f, -0.06238271f, 0.03207771f, 0.02797267f, -0.02756002f, 0.00699336f, 
    -0.06864162f, 0.02381957f, 0.01242149f, -0.00507843f, -0.04112314f, -0.02009586f, 0.03486451f, -0.06610938f, 
    -0.04804521f, -0.07438826f, -0.06265230f, -0.07022350f, -0.01620631f, 0.01003104f, -0.05156990f, 0.04011322f, 
    0.01436918f, 0.00949874f, 0.03928883f, -0.00965330f, -0.04432789f, -0.04469261f, -0.05764384f, -0.06145549f, 
    0.02905762f, 0.01817942f, -0.04378023f, 0.01627305f, 0.02150563f, 0.02398582f, 0.04317864f, -0.02845052f, 
    -0.01639413f, 0.01338050f, 0.01432286f, -0.06180143f, -0.02159360f, -0.02426742f, 0.04644156f, -0.05423451f, 
    -0.01129092f, -0.06191270f, -0.02232343f, -0.05819857f, -0.05748751f, -0.02221470f, 0.03054776f, -0.05042242f, 
    0.01104188f, 0.04373002f, 0.02651689f, -0.04702087f, 0.00597031f, -0.00842830f, 0.00978960f, 0.03408339f, 
    -0.01583236f, -0.03974023f, -0.01257212f, 0.00702336f, -0.02221304f, 0.04188309f, -0.02387536f, 0.00966820f, 
    -0.00417403f, -0.04662690f, -0.03028469f, -0.06447788f, -0.01083874f, -0.00453906f, -0.05640446f, -0.00465818f, 
    -0.04006171f, 0.02864699f, -0.01335734f, 0.03941385f, -0.05087381f, 0.02576635f, 0.00225749f, 0.03205989f, 
    -0.03089859f, -0.02500775f, 0.02773647f, -0.00259430f, -0.06103627f, -0.07716651f, 0.01607828f, 0.04307034f, 
    0.05491920f, -0.02237497f, -0.05386690f, -0.02793722f, 0.00448594f, 0.00126362f, 0.03416959f, 0.00082732f, 
    0.00848126f, -0.03115011f, 0.02274451f, -0.04355208f, 0.03527207f, -0.01228092f, -0.05173561f, 0.01367452f, 
    -0.04913075f, -0.00821071f, 0.01594004f, -0.01796195f, -0.04280329f, 0.03913373f, -0.06495671f, 0.00954331f, 
    -0.00354942f, 0.02904936f, 0.02137564f, -0.05691865f, -0.00173997f, -0.07280320f, -0.04130885f, -0.04638226f, 
    -0.07131729f, -0.05313444f, 0.03113022f, -0.00252399f, -0.04415256f, 0.04281411f, 0.03914144f, -0.02407230f, 
    0.04001450f, -0.04148583f, -0.06498950f, -0.00530277f, 0.04635344f, 0.04999553f, 0.02294672f, -0.03999504f, 
    -0.02372498f, -0.01506051f, 0.01968618f, -0.06464185f, -0.02768155f, -0.03510001f, 0.03207262f, -0.00458649f, 
    -0.05948403f, 0.00197694f, -0.04268408f, -0.06253003f, -0.05375650f, 0.02014089f, -0.07379158f, -0.04849462f, 
    -0.03422286f, -0.01066981f, -0.05520032f, -0.01661239f, 0.03823929f, -0.04883314f, -0.01049310f, 0.02285568f, 
    0.04218281f, -0.06906486f, 0.00712567f, -0.00165289f, 0.04923189f, -0.00320415f, 0.01669615f, -0.05193695f, 
    0.04008699f, -0.06379388f, 0.05086977f, -0.06324996f, 0.00239232f, -0.06794842f, 0.01321987f, 0.02294513f, 
    -0.00316565f, -0.03417090f, -0.03565731f, 0.01091058f, -0.01144743f, -0.06116259f, -0.02528463f, -0.07677906f, 
    -0.03444597f, -0.05667275f, -0.03813598f, 0.03484610f, -0.00218958f, 0.00096483f, 0.01683359f, 0.04335740f, 
    -0.01323979f, -0.04392639f, -0.02829948f, -0.05568675f, -0.04194943f, -0.04461364f, -0.04610363f, -0.00824251f, 
    0.21535480f, 0.05677689f, 0.30527809f, -0.08744944f, 0.01511818f, -0.07145633f, 0.02792865f, 0.06250501f, 
    0.00665340f, -0.01706041f, 0.10248536f, -0.02490362f, -0.21171260f, -0.09599067f, -0.11024287f, 0.04257446f, 
    0.01896589f, 0.14707519f, 0.16014956f, -0.20281363f, 0.00898953f, -0.07690482f, -0.05709248f, -0.03899540f, 
    -0.00563488f, 0.08711971f, 0.11041449f, -0.13332027f, 0.03646800f, 0.03160953f, -0.04227985f, 0.04912782f, 
    0.06281114f, -0.05294446f, -0.03268633f, 0.08032214f, 0.13008386f, -0.01975348f, 0.09902675f, -0.09421230f, 
    -0.03861308f, -0.02917256f, 0.09323607f, -0.04128292f, -0.01374948f, -0.03046316f, -0.29271692f, -0.34945130f, 
    -0.17576644f, 0.16322163f, 0.02576301f, -0.00763952f, 0.07997997f, -0.01086814f, 0.06470530f, 0.03585074f, 
    -0.06823386f, 0.06301571f, -0.09939915f, -0.05209628f, 0.07452150f, -0.00853058f, 0.07445695f, -0.17461461f, 
    0.07931066f, -0.04419345f, 0.08752058f, -0.06677886f, -0.06472756f, -0.03772778f, 0.02707944f, 0.13425720f, 
    0.10052267f, 0.04932225f, -0.12514971f, 0.02859112f, 0.04082607f, 0.03115355f, -0.11114923f, 0.03823901f, 
    -0.01167924f, -0.26198143f, -0.14656670f, 0.04285982f, -0.08671037f, -0.05324575f, -0.06976144f, 0.04906757f, 
    -0.00034712f, 0.01457280f, -0.04618212f, 0.06078397f, 0.13319260f, -0.01281985f, -0.12409826f, 0.14629163f, 
    -0.03593453f, -0.00368649f, 0.04949185f, -0.18806724f, 0.13088866f, -0.08578425f, -0.03353345f, -0.07118919f, 
    0.08579902f, -0.06480721f, 0.05197339f, 0.04028732f, 0.07056183f, -0.00697460f, -0.11125419f, 0.02553755f, 
    -0.04010180f, 0.01670803f, 0.08810220f, -0.02804695f, 0.03847462f, -0.37377700f, -0.00346063f, 0.10098336f, 
    0.08156862f, 0.05501598f, 0.02111732f, -0.12100357f, -0.02709385f, 0.05475219f, 0.15646423f, -0.13439497f, 
    -0.04970691f, -0.02569078f, 0.02682014f, 0.02122465f, -0.04534272f, 0.03629154f, 0.01165280f, -0.49415952f, 
    -0.15280205f, 0.09294515f, -0.08834586f, 0.11290763f, -0.08174372f, -0.08563863f, 0.22211729f, 0.01338200f, 
    -0.45514628f, 0.03159954f, -0.04684048f, 0.06331868f, 0.19843125f, 0.01751328f, -0.14448522f, 0.05186120f, 
    -0.02471967f, -0.22044389f, -0.12678950f, 0.10941532f, -0.10794259f, -0.06920559f, -0.04762483f, -0.07333140f, 
    0.03283150f, -0.19312954f, -0.01469236f, 0.08623535f, -0.12414484f, 0.16338255f, 0.14169195f, 0.08045697f, 
    -0.03446969f, -0.02869442f, -0.11965211f, -0.00504351f, -0.09158470f, -0.20537440f, -0.07868807f, 0.05441443f, 
    0.10049979f, 0.01568644f, 0.22388291f, 0.01990472f, 0.38641810f, -0.01156272f, 0.06899139f, 0.04767576f, 
    -0.05548981f, 0.08761138f, -0.08777881f, -0.06932819f, -0.04880306f, -0.00025628f, -0.11238697f, -0.15551983f, 
    -0.01972027f, -0.02856765f, -0.07750607f, 0.07566766f, -0.02515373f, -0.07005910f, -0.09249470f, 0.11547362f, 
    0.05500708f, 0.01619173f, -0.18373322f, 0.01597691f, -0.02110737f, -0.00518216f, 0.14087516f, -0.24155208f, 
    -0.25071746f, -0.12045286f, 0.10230018f, 0.01823751f, 0.02142556f, -0.03189092f, -0.04501618f, 0.22563542f, 
    -0.02165182f, 0.14984445f, -0.04645579f, 0.11972222f, 0.03754783f, 0.01500294f, -0.00878333f, -0.07655453f, 
    -0.06980617f, 0.23253506f, 0.07588404f, -0.24787082f, 0.02986992f, 0.06231133f, -0.06390528f, 0.01855733f, 
    -0.04624806f, -0.00119020f, 0.09168185f, -0.13160205f, 0.04830713f, 0.01764595f, -0.00218256f, 0.10996011f, 
    -0.02891446f, 0.03801415f, -0.03257525f, 0.03153671f, 0.18232824f, 0.13564524f, -0.10847020f, -0.06016352f, 
    0.06479695f, 0.05479284f, 0.06800795f, 0.17548215f, 0.26044568f, -0.38111660f, -0.05280851f, -0.12471221f, 
    0.01492486f, -0.00230848f, 0.08183675f, 0.15334176f, 0.04246033f, 0.20345920f, 0.20989498f, 0.09539752f, 
    -0.11458550f, -0.05336767f, -0.18918233f, 0.00048705f, 0.05245095f, 0.01730188f, -0.05778362f, 0.19615199f, 
    -0.09597843f, 0.09057584f, 0.16257145f, 0.09869387f, -0.10458039f, -0.10237559f, 0.04037362f, 0.03035354f, 
    0.06830537f, 0.08702081f, 0.07162971f, -0.08300391f, -0.07534234f, 0.07747924f, 0.10406807f, 0.08570161f, 
    0.01923219f, -0.02882130f, 0.00605867f, 0.00519366f, 0.02194263f, -0.04835338f, 0.03100473f, -0.05160581f, 
    0.03478407f, 0.03741836f, 0.01745379f, 0.03059336f, -0.05208354f, -0.05841544f, 0.04489760f, -0.01747694f, 
    -0.05360946f, -0.04413202f, 0.04526338f, -0.05290931f, 0.02775780f, -0.04527857f, -0.04581714f, -0.06182141f, 
    -0.00062509f, -0.01976971f, 0.02222301f, 0.05434712f, 0.03872526f, -0.04943740f, -0.02208102f, 0.04796556f, 
    -0.05280703f, 0.01656899f, 0.01317247f, -0.04243584f, -0.02425944f, 0.03427203f, 0.01047335f, -0.05411463f, 
    -0.04574592f, -0.02984774f, -0.04188604f, -0.00340132f, -0.04577858f, 0.02451565f, -0.05460061f, -0.02769950f, 
    -0.01052514f, -0.01090094f, 0.00342966f, 0.02721469f, -0.03438180f, 0.03750769f, 0.00775718f, -0.02770971f, 
    -0.00411203f, -0.04450050f, 0.05074682f, -0.03658492f, 0.02431534f, 0.00255314f, -0.03902679f, -0.05372684f, 
    -0.01394678f, -0.01020884f, -0.01865287f, -0.04029540f, -0.05095027f, 0.04176565f, -0.01173679f, -0.03836197f, 
    0.01415481f, 0.02048260f, -0.02701086f, 0.02116157f, 0.01784057f, 0.02870964f, 0.01601486f, -0.01518926f, 
    0.02980478f, 0.05194502f, -0.01658786f, -0.02268406f, -0.04803939f, -0.02308455f, 0.04468427f, -0.02613113f, 
    -0.04951652f, -0.04456982f, 0.02490859f, -0.02577706f, -0.05246091f, 0.01756287f, -0.00515613f, 0.03753087f, 
    -0.02947983f, 0.01969754f, -0.03848384f, 0.05715057f, -0.04683395f, -0.05805121f, -0.03002244f, -0.00852522f, 
    -0.04017727f, -0.03191299f, 0.01991541f, 0.00506633f, -0.02473154f, -0.02070705f, -0.03140175f, 0.03272918f, 
    0.04614783f, 0.03494679f, 0.02954156f, -0.02754728f, -0.05462658f, 0.01017194f, -0.04971885f, -0.05884994f, 
    0.00338097f, -0.00830267f, 0.01726379f, -0.03978629f, -0.04101241f, 0.03161384f, -0.05211442f, 0.00763032f, 
    -0.04872359f, 0.05099547f, -0.00108477f, 0.05339051f, 0.01386685f, 0.01808062f, -0.05397801f, -0.01240666f, 
    0.01458856f, -0.01948671f, -0.03822359f, -0.04776914f, -0.05307293f, -0.01956831f, 0.04398710f, 0.01940374f, 
    0.02205554f, -0.03307325f, -0.02354064f, -0.02231618f, 0.04036770f, -0.01295908f, 0.05050432f, -0.01451835f, 
    -0.06027786f, 0.03942130f, -0.00560429f, 0.03025332f, -0.05118973f, 0.00759541f, 0.00721201f, -0.04299349f, 
    0.03082425f, -0.05454455f, 0.02954609f, -0.00187635f, 0.02153144f, 0.05383522f, -0.01487141f, -0.01628870f, 
    -0.01048155f, 0.04208585f, -0.03443200f, 0.01395188f, -0.00921626f, 0.00582517f, -0.01479740f, -0.05738893f, 
    0.04129362f, -0.02896445f, -0.04280313f, -0.02659029f, -0.04601831f, -0.05645458f, 0.04247319f, -0.01617721f, 
    0.02495735f, -0.02672133f, 0.04509286f, 0.00367356f, -0.05440739f, 0.04192274f, -0.01667551f, 0.01492290f, 
    0.01189332f, -0.03748314f, -0.02612828f, -0.02254791f, 0.01784492f, -0.04648290f, -0.02443804f, 0.00645940f, 
    -0.02125873f, -0.00529702f, 0.02749806f, -0.02638783f, 0.02332065f, 0.04327229f, -0.01088504f, 0.02340046f, 
    -0.01423352f, 0.02337624f, -0.05715618f, -0.03910309f, -0.01979500f, -0.03577553f, 0.03441245f, -0.01592588f, 
    0.05197495f, -0.04835565f, -0.00576436f, -0.05811312f, -0.00258810f, 0.04872211f, -0.03584442f, -0.05233901f, 
    -0.05927343f, -0.00667585f, -0.02466252f, -0.03163355f, -0.01782406f, -0.05911053f, -0.04822646f, 0.01420213f, 
    -0.02623247f, 0.04452028f, 0.04604604f, 0.01230389f, -0.02927019f, -0.04688196f, -0.02955523f, 0.01885944f, 
    0.03540590f, -0.05733665f, 0.04497434f, 0.00052661f, -0.01669458f, -0.00039113f, 0.04595903f, 0.01196994f, 
    0.00159032f, 0.03487715f, -0.01991251f, 0.03557733f, 0.02745589f, 0.06252974f, 0.01046781f, 0.00210279f, 
    -0.04185294f, -0.04058861f, -0.04885859f, -0.04205134f, 0.01427331f, -0.03416525f, -0.00227843f, -0.03138718f, 
    -0.03301469f, -0.05639049f, 0.05210558f, 0.00050268f, 0.01879522f, -0.04544647f, -0.05392674f, 0.03672410f, 
    -0.04223643f, -0.05682250f, 0.00107625f, 0.00048226f, -0.04586602f, 0.04102601f, 0.05155328f, 0.03738226f, 
    -0.02955628f, -0.06195730f, -0.04518452f, 0.03278957f, 0.00977427f, 0.03965513f, -0.03630328f, -0.02288222f, 
    0.02900563f, -0.04408169f, 0.02885464f, 0.02865761f, 0.03061238f, 0.03201921f, -0.05059457f, 0.00336526f, 
    -0.01989052f, -0.02725583f, -0.04869979f, -0.03816303f, -0.04651812f, 0.01184675f, 0.03449217f, -0.01682094f, 
    -0.00929669f, -0.05263212f, -0.04145782f, 0.00849948f, -0.00657192f, 0.02208391f, 0.04599499f, -0.00085632f, 
    -0.00035679f, -0.06213674f, 0.00490361f, 0.03862568f, -0.00658674f, -0.05498213f, 0.00572537f, 0.01021730f, 
    -0.02675795f, 0.03871180f, -0.05369615f, -0.01184411f, 0.02867291f, -0.02269311f, -0.04546469f, -0.06438645f, 
    -0.05994254f, 0.03627021f, 0.02644890f, 0.04241473f, 0.02028020f, 0.02980677f, 0.05121611f, -0.01274011f, 
    -0.05041321f, 0.01900395f, -0.03980051f, -0.01392872f, 0.00294784f, -0.02646005f, -0.01111311f, -0.06115652f, 
    -0.05634205f, 0.00344024f, -0.01885184f, -0.01685134f, -0.02978924f, -0.01868089f, -0.03057497f, -0.04600190f, 
    0.03736930f, 0.03258222f, 0.03112693f, -0.02325588f, -0.03994812f, -0.05201130f, -0.01034535f, -0.01249040f, 
    -0.06324290f, -0.01868037f, -0.01110975f, 0.00787145f, -0.00203362f, 0.03741405f, 0.02769201f, -0.01060929f, 
    -0.03135096f, -0.02580097f, -0.03414275f, 0.00995155f, -0.00677376f, 0.01064240f, -0.03759763f, 0.03102450f, 
    0.02112259f, -0.00024300f, -0.05047141f, -0.04667392f, -0.00314225f, -0.01609391f, 0.03053683f, -0.02099077f, 
    -0.06191195f, -0.05929352f, -0.03124133f, 0.04807540f, -0.01499369f, -0.00695863f, -0.06197517f, -0.02709199f, 
    0.03776240f, -0.00184780f, -0.00556983f, -0.00446444f, 0.00446138f, -0.02338290f, 0.01985474f, 0.05190145f, 
    0.00643185f, -0.01845529f, -0.03021453f, -0.05330900f, -0.03832557f, 0.04397218f, 0.02349984f, 0.03783641f, 
    -0.00368108f, 0.02994819f, -0.02306818f, -0.04369038f, 0.00081605f, -0.04627791f, -0.05653858f, -0.04168011f, 
    -0.01287055f, -0.01014249f, 0.04380226f, 0.04328303f, -0.05018799f, 0.01762756f, 0.03569321f, 0.03805595f, 
    -0.00031860f, -0.03959727f, -0.04903056f, 0.01166803f, 0.01978132f, -0.03735007f, 0.01369626f, 0.01933993f, 
    -0.04303196f, -0.06328303f, -0.01383055f, -0.05600505f, -0.01169006f, -0.04119713f, 0.03645899f, 0.00287903f, 
    -0.03340094f, -0.00730188f, -0.05390489f, 0.01574162f, 0.02299744f, -0.03131041f, -0.02495592f, 0.05107220f, 
    0.03640688f, 0.02011357f, 0.02853374f, 0.03596940f, -0.04377971f, -0.06000811f, 0.01022088f, -0.03296277f, 
    0.04270944f, -0.03983357f, -0.06021222f, 0.03192982f, -0.03290962f, -0.03807097f, -0.04048936f, 0.01610736f, 
    0.00288930f, 0.04148648f, -0.03033003f, -0.04051667f, 0.03159777f, 0.00626265f, -0.03514143f, 0.04752080f, 
    0.02235622f, 0.01236658f, 0.00628402f, -0.00628242f, 0.04447111f, 0.00984940f, -0.00033012f, -0.00523740f, 
    -0.06112752f, 0.00441732f, -0.02480345f, -0.00080655f, -0.03385173f, -0.05306327f, -0.04456092f, -0.04082049f, 
    -0.01992774f, 0.03898691f, 0.00724428f, -0.04219726f, -0.05270593f, -0.03609038f, 0.04672508f, -0.05225126f, 
    -0.03415700f, -0.03228927f, 0.05137947f, -0.02913451f, -0.00017995f, -0.00800018f, -0.03240615f, -0.02416904f, 
    -0.01783017f, -0.02667338f, -0.04669625f, -0.00516395f, 0.02081661f, -0.01010842f, -0.04589522f, 0.02432910f, 
    -0.03303969f, -0.03212660f, -0.03789203f, -0.04908572f, -0.01157369f, -0.01284216f, 0.01761362f, -0.04142824f, 
    -0.00566616f, -0.03459362f, -0.00640779f, -0.05496662f, 0.05308814f, -0.03764511f, 0.02153450f, -0.00570642f, 
    -0.04914240f, 0.02553653f, -0.05454751f, 0.00335571f, 0.01623932f, 0.03457465f, -0.04985347f, -0.03156179f, 
    0.04235143f, -0.05967523f, -0.03629694f, 0.04144311f, -0.04000053f, -0.05240496f, 0.00524402f, 0.05435422f, 
    -0.00925642f, -0.02790503f, 0.03827357f, -0.03389772f, 0.04825879f, -0.06193250f, -0.05754863f, -0.03194168f, 
    -0.00285410f, 0.03857433f, -0.00813939f, -0.03189448f, -0.04882923f, 0.04827700f, -0.02115803f, -0.03435388f, 
    0.00886689f, 0.02033667f, 0.04918069f, -0.03212365f, -0.04307775f, 0.04797946f, 0.03547871f, 0.01283887f, 
    0.05278681f, -0.02644229f, 0.00815069f, -0.03800560f, 0.01605043f, -0.01106821f, -0.04634895f, -0.02589887f, 
    -0.15662576f, 0.05708546f, -0.03794650f, -0.09279046f, 0.05217967f, -0.06769232f, -0.01138022f, 0.05746116f, 
    -0.13395265f, -0.28459921f, -0.34880790f, -0.07102686f, 0.17014287f, 0.08090693f, -0.06126424f, 0.05252474f, 
    -0.03600409f, 0.10340940f, 0.03966378f, -0.13972902f, 0.20788023f, 0.11772043f, -0.03181625f, 0.04524911f, 
    -0.08428319f, 0.01660003f, -0.03227522f, 0.04166180f, 0.17934254f, 0.16321672f, 0.16733010f, -0.07094591f, 
    0.03803204f, -0.05233711f, 0.08271194f, 0.08263945f, -0.39243266f, -0.17068970f, -0.07264501f, 0.11471596f, 
    0.16068400f, -0.00663080f, 0.12242600f, 0.13420731f, -0.04283172f, -0.23810856f, -0.17687640f, -0.02621311f, 
    0.00992998f, 0.08413131f, -0.16024603f, 0.12438187f, -0.02333297f, -0.01214193f, -0.23392045f, -0.12033999f, 
    0.19844434f, 0.10135533f, 0.02215838f, 0.02967039f, 0.04591462f, 0.01746879f, -0.18565860f, 0.06894055f, 
    0.05243403f, -0.09501507f, -0.11680290f, -0.06792773f, -0.04141463f, 0.11384646f, 0.11040927f, 0.13763647f, 
    -0.02327528f, 0.05994036f, 0.14804792f, -0.08188464f, 0.12518372f, -0.05816492f, 0.11722484f, -0.14021903f, 
    -0.00867522f, 0.06280422f, -0.03880142f, -0.22517583f, 0.00603009f, 0.10487072f, -0.04377452f, -0.06960212f, 
    -0.04278264f, 0.12125611f, 0.03003511f, 0.14493418f, -0.13243778f, -0.16029665f, -0.19351086f, -0.00331383f, 
    -0.00606225f, -0.00798290f, 0.11839892f, 0.04311868f, 0.03812147f, -0.15994455f, -0.02097210f, 0.09969380f, 
    -0.09962010f, -0.02693993f, -0.07556608f, 0.03191767f, -0.57438159f, -0.23133451f, -0.01711878f, -0.14715128f, 
    0.11428075f, 0.03622562f, -0.04215291f, -0.16421138f, -0.20416199f, 0.02769029f, 0.07587739f, 0.11013735f, 
    -0.04541140f, -0.04456971f, 0.08627684f, 0.04085154f, 0.04748181f, 0.05220833f, 0.04180676f, -0.10600182f, 
    0.09535045f, 0.08094913f, 0.14821288f, -0.02081910f, 0.01979291f, 0.01036108f, 0.09286579f, -0.25310713f, 
    0.01973299f, 0.12335592f, 0.18699235f, -0.11047497f, 0.01626153f, 0.12277301f, 0.09180886f, -0.02506953f, 
    0.01669994f, 0.16811214f, 0.29401577f, 0.11898559f, -0.00833126f, 0.16938144f, 0.01464874f, 0.03949083f, 
    -0.05285770f, -0.49784562f, 0.01053679f, -0.06921951f, 0.08606303f, -0.06684177f, 0.06948675f, 0.11996746f, 
    -0.01529073f, -0.04470542f, 0.00086517f, 0.03256043f, 0.05613615f, -0.08826762f, -0.10538041f, 0.11924057f, 
    0.10905884f, -0.02498266f, 0.11667474f, 0.06264322f, -0.13785556f, -0.06400009f, 0.03596674f, 0.01382663f, 
    -0.02417064f, -0.04355925f, 0.02587714f, 0.04302439f, -0.09438420f, 0.05831519f, -0.07135684f, -0.04199270f, 
    0.00084410f, -0.04292804f, -0.07016827f, -0.06374344f, 0.11051835f, 0.10068039f, -0.07359710f, -0.02908545f, 
    0.08959736f, 0.07522698f, 0.05268661f, 0.04982221f, -0.03351083f, -0.08794357f, 0.14394908f, -0.00036487f, 
    0.04327333f, -0.06588490f, -0.00033394f, -0.05826491f, 0.02572527f, 0.10550891f, 0.03566084f, 0.04797975f, 
    -0.03250405f, -0.05187071f, -0.01755977f, 0.06781127f, 0.12323092f, 0.06912509f, 0.07110515f, 0.03307770f, 
    -0.01264572f, -0.00034419f, 0.14509250f, 0.12453113f, 0.15051597f, 0.08643802f, -0.05282014f, 0.13573252f, 
    -0.07776491f, 0.09731574f, -0.05287944f, -0.00350106f, 0.02164080f, 0.04163374f, 0.12143745f, 0.01927522f, 
    0.08287199f, 0.10938960f, -0.06625599f, 0.04852831f, -0.00319688f, 0.04614997f, -0.07949273f, -0.19361709f, 
    0.09413212f, 0.01498044f, 0.07988025f, -0.12305582f, 0.09942131f, 0.03082656f, -0.10596868f, -0.14025544f, 
    -0.09910959f, 0.00071685f, 0.12380449f, 0.14517151f, 0.00420869f, -0.24760191f, -0.01747360f, 0.15377322f, 
    -0.15460828f, -0.14761485f, -0.14922738f, -0.15252611f, -0.07604060f, -0.21051231f, -0.22415133f, -0.21460783f, 
    -0.11998939f, 0.04430737f, 0.01282047f, 0.11229861f, 0.00181246f, 0.06732791f, 0.02832724f, 0.06893829f, 
    0.07781544f, 0.09953672f, 0.04455386f, 0.07609633f, 0.02141869f, 0.08258472f, 0.06971522f, -0.06119328f, 
    0.16605777f, -0.02206949f, -0.22464021f, -0.09026033f, -0.22648820f, -0.00862020f, 0.07178117f, 0.02824480f, 
    0.29235303f, -0.25546643f, -0.08295882f, 0.02533326f, -0.06467864f, -0.00880944f, 0.07198605f, 0.07765332f, 
    0.00650858f, -0.30561242f, -0.18253163f, 0.07522092f, 0.07725275f, 0.01114228f, 0.02686339f, 0.05037592f, 
    -0.13739990f, 0.02554764f, -0.09913471f, -0.15418141f, -0.06613405f, 0.04487168f, 0.05393158f, 0.00370091f, 
    0.15951437f, 0.09695008f, 0.00706338f, -0.06425288f, -0.03503612f, 0.20326014f, 0.04337685f, 0.08031060f, 
    0.04577545f, 0.03150631f, 0.08167903f, -0.08960976f, 0.36566192f, -0.06140449f, 0.06276663f, 0.08055446f, 
    0.03818132f, 0.15467346f, -0.06978838f, -0.00070968f, 0.04796146f, 0.16072328f, -0.01703574f, -0.68454975f, 
    0.07669432f, 0.07828440f, 0.07144911f, 0.01212292f, 0.05149076f, 0.03545814f, -0.01624266f, 0.01191364f, 
    -0.09847423f, 0.15414622f, -0.05730163f, 0.13836285f, -0.03385058f, -0.14008422f, -0.03984596f, 0.09562498f, 
    -0.08628321f, 0.07277578f, 0.04484660f, 0.17254117f, -0.03674563f, -0.05771714f, 0.08385164f, 0.04641443f, 
    -0.02835998f, 0.06043724f, -0.16820253f, 0.05004705f, -0.06560371f, 0.12928276f, 0.08654727f, -0.06207892f, 
    -0.04583421f, -0.25929314f, -0.11985860f, 0.13412920f, 0.06363112f, 0.01572997f, -0.02932675f, 0.05706291f, 
    0.05337233f, 0.00061223f, -0.03965747f, 0.10514273f, 0.02826828f, 0.10030393f, -0.17349036f, -0.03938822f, 
    -0.01352898f, -0.05244223f, 0.04248589f, -0.11416348f, 0.14174916f, -0.29629257f, 0.09939370f, -0.00870151f, 
    -0.00839292f, 0.20762755f, 0.06297777f, -0.13579956f, 0.05583380f, -0.24438584f, -0.23486350f, 0.03830697f, 
    0.03771131f, 0.03902314f, 0.05341886f, 0.08472636f, -0.08964446f, -0.14849117f, 0.08533181f, -0.06500279f, 
    0.08235647f, -0.06548961f, 0.02073020f, 0.00867129f, 0.08587805f, 0.15810800f, 0.14237735f, -0.05596396f, 
    -0.27794856f, 0.05812506f, 0.04219171f, -0.02960784f, 0.02454409f, -0.03809871f, -0.02086379f, -0.19114459f, 
    -0.04143145f, -0.20118071f, -0.10750055f, 0.09976257f, 0.14519250f, -0.03470667f, -0.02308982f, 0.00231025f, 
    -0.22352922f, 0.11723960f, 0.20179425f, -0.10367302f, -0.02803037f, -0.09192271f, 0.14074396f, -0.11872032f, 
    0.10188159f, -0.46489003f, 0.00910387f, -0.09258838f, -0.14721884f, 0.03601844f, 0.03619798f, 0.01630890f, 
    -0.09469422f, 0.01881854f, 0.16103375f, -0.10188866f, -0.01971415f, -0.15699244f, -0.01922718f, 0.07626331f, 
    -0.00789189f, -0.03902371f, 0.13691686f, -0.40987211f, 0.08868157f, 0.11770219f, -0.04221067f, 0.11775743f, 
    -0.10007611f, -0.02050957f, 0.04535999f, 0.00262078f, -0.39245039f, -0.13781592f, 0.06629899f, -0.04448284f, 
    0.00431099f, 0.02899103f, 0.12463235f, -0.02304386f, -0.04673236f, -0.01705959f, -0.17140125f, -0.02977499f, 
    -0.12716478f, -0.10773995f, 0.03343993f, -0.17022844f, 0.01570036f, 0.16917905f, 0.13476585f, 0.09590516f, 
    -0.15956046f, 0.02566257f, -0.02453065f, -0.04552872f, 0.10922267f, -0.08751649f, 0.05380453f, -0.28847960f, 
    -0.03133635f, 0.07469919f, 0.10449667f, 0.05093641f, 0.09566057f, 0.03226193f, 0.05327019f, 0.09175158f, 
    0.08258228f, -0.08475290f, -0.07103675f, -0.13759054f, 0.18049107f, -0.01945431f, -0.02509957f, 0.06798506f, 
    -0.03897391f, -0.28745291f, -0.07437138f, 0.03696736f, -0.08452208f, -0.01839572f, 0.05171432f, 0.01026868f, 
    -0.08307581f, 0.04800715f, 0.06746020f, -0.20056079f, 0.03712354f, -0.06951807f, -0.04788626f, -0.21938093f, 
    -0.02814770f, -0.05999582f, 0.07808933f, 0.18768328f, 0.24206157f, 0.12902530f, -0.04104438f, -0.06975289f, 
    -0.08957058f, 0.01542466f, -0.11555358f, 0.10714759f, -0.14046726f, -0.50794256f, 0.00534838f, -0.10181472f, 
    -0.08126622f, -0.06080571f, -0.11781425f, -0.03126775f, -0.00066655f, 0.04914025f, 0.30971918f, -0.10366946f, 
    0.14734240f, 0.13220112f, -0.04105843f, 0.07378468f, 0.01423438f, -0.03066711f, -0.04957947f, 0.10758962f, 
    -0.17348111f, -0.00767591f, 0.10637303f, -0.01814860f, -0.04117907f, 0.02512243f, -0.07784707f, 0.23705702f, 
    -0.05189531f, 0.08384082f, 0.06014991f, 0.09727398f, -0.11915678f, 0.09793766f, 0.01034732f, -0.07798688f, 
    -0.02803042f, 0.01686899f, -0.05672919f, 0.01387621f, -0.05117147f, -0.06520002f, -0.05270787f, 0.03292869f, 
    0.04592799f, -0.04569925f, 0.02548172f, -0.03623130f, 0.02863209f, 0.03011115f, -0.02070895f, 0.03878962f, 
    -0.05069086f, -0.02667515f, 0.04423271f, 0.03218805f, -0.06433980f, -0.01097474f, 0.01037800f, 0.02814756f, 
    -0.04676299f, -0.00785502f, 0.03441223f, -0.05491221f, -0.03984308f, 0.00555155f, -0.00549048f, 0.05293343f, 
    0.02086006f, 0.01750746f, -0.06393334f, -0.01602695f, -0.02628258f, 0.02560407f, -0.05203640f, -0.02500918f, 
    -0.06139580f, 0.00412016f, 0.03450885f, -0.03632640f, 0.03034041f, 0.04489167f, -0.05125236f, -0.03679417f, 
    0.03717374f, -0.00441565f, 0.04562546f, -0.03963022f, 0.02072198f, -0.05651907f, -0.01643031f, -0.01588593f, 
    -0.03893592f, -0.04301785f, 0.01998436f, 0.04901717f, -0.02362242f, -0.03468313f, 0.02270811f, -0.00157338f, 
    0.01212812f, 0.03710088f, -0.05315497f, 0.04320746f, -0.02173598f, -0.00810873f, -0.02481416f, 0.03763246f, 
    -0.02191436f, -0.04437460f, 0.04711422f, -0.01653202f, -0.01413837f, 0.04574476f, 0.00504735f, -0.03576089f, 
    -0.04319008f, -0.03949541f, -0.02019017f, -0.01414568f, -0.04587545f, -0.04382093f, 0.02775567f, 0.03013424f, 
    -0.01615214f, -0.04865948f, -0.05391954f, -0.02308355f, -0.02517798f, -0.01737676f, 0.03588198f, -0.01475215f, 
    -0.03068449f, 0.04801575f, -0.03359693f, 0.03791404f, -0.04663122f, 0.01935583f, -0.06032459f, 0.02917537f, 
    0.03529420f, -0.04158688f, 0.00771002f, 0.00528081f, 0.04767802f, -0.04020933f, 0.01249457f, 0.02227979f, 
    -0.03428838f, -0.04433055f, 0.02561682f, -0.02442551f, 0.01201204f, -0.04441245f, 0.02984867f, -0.01997743f, 
    -0.02306907f, -0.06101391f, -0.00904441f, -0.01687150f, 0.03704261f, -0.01163094f, 0.03643310f, -0.03818978f, 
    0.02051035f, -0.01675124f, -0.00458880f, -0.00501130f, 0.03060972f, 0.01254227f, -0.05051342f, -0.04669144f, 
    -0.01539851f, -0.05169073f, -0.06082999f, 0.01683121f, -0.05807524f, -0.01499276f, -0.03042590f, 0.00842607f, 
    0.00348239f, 0.04632697f, 0.04813418f, 0.03500982f, 0.05745444f, -0.05739410f, -0.05799243f, -0.02475727f, 
    -0.03117351f, 0.04924684f, 0.06285112f, 0.00158633f, 0.02793292f, 0.00454256f, 0.01511891f, -0.01427011f, 
    0.04424928f, -0.05207732f, -0.05467387f, 0.00656250f, -0.04862646f, -0.05515865f, -0.02847021f, -0.03372277f, 
    0.02804913f, 0.01840130f, 0.00060479f, -0.05814654f, 0.04228962f, -0.03919275f, 0.03310205f, -0.01184859f, 
    0.02798328f, -0.00432636f, -0.03447825f, 0.04546059f, -0.01321249f, -0.01533468f, 0.04556299f, 0.02899446f, 
    -0.01110802f, 0.02293110f, 0.02785585f, -0.00339591f, -0.01633401f, 0.02014389f, -0.05445062f, 0.01112793f, 
    -0.05612201f, -0.01592658f, -0.01286254f, -0.01903397f, -0.03828942f, -0.05754638f, 0.03832439f, -0.02691806f, 
    0.00258262f, -0.04903343f, 0.01492484f, -0.00840755f, -0.03876542f, -0.00846047f, -0.06105055f, 0.05226718f, 
    -0.01117693f, -0.03229546f, -0.02556978f, -0.05127485f, -0.06686725f, 0.00572190f, -0.00094046f, 0.02717985f, 
    -0.02657058f, 0.03347670f, 0.02309882f, -0.05718745f, -0.04272339f, 0.02152485f, -0.02518662f, -0.00348373f, 
    0.02368752f, -0.02171342f, -0.00513287f, -0.02058588f, -0.05422039f, 0.04444009f, 0.04985587f, 0.04953054f, 
    0.00832192f, -0.05701531f, -0.02832537f, 0.01909729f, 0.02560303f, -0.01762007f, 0.04874182f, 0.03230122f, 
    0.02647100f, 0.01950896f, -0.03771441f, -0.03290170f, 0.03376283f, 0.04349097f, -0.01800890f, -0.01781221f, 
    0.03025579f, -0.00769897f, -0.00292031f, 0.03529265f, -0.05335147f, -0.00099249f, -0.01124862f, -0.05273731f, 
    0.04527267f, -0.01316949f, -0.04297395f, 0.04210790f, -0.00705552f, 0.00642058f, 0.02198117f, 0.05270006f, 
    -0.02110121f, -0.04244801f, 0.04049074f, 0.01244066f, 0.03444966f, -0.04703883f, -0.05977807f, -0.00191935f, 
    -0.01601986f, 0.03200596f, -0.03987812f, -0.06238215f, 0.00811285f, -0.06313014f, 0.03337327f, -0.06514949f, 
    -0.06460194f, -0.06376189f, -0.05697949f, 0.02097707f, -0.01832931f, -0.06091481f, -0.03365659f, -0.05331567f, 
    0.04896152f, -0.01368487f, -0.05323542f, 0.01775302f, 0.02334927f, 0.03083824f, -0.05982301f, -0.01551051f, 
    0.02543752f, -0.06130961f, -0.05000003f, -0.05171456f, 0.00959348f, -0.06765087f, -0.06408627f, -0.01771787f, 
    -0.05938816f, -0.00714619f, -0.02997751f, -0.05122177f, -0.06347949f, -0.06672801f, -0.03967833f, 0.00336748f, 
    -0.03894671f, -0.00484762f, -0.04160540f, 0.00409435f, -0.04484724f, -0.02552040f, -0.02608421f, -0.03830995f, 
    -0.03890051f, -0.03737966f, -0.06145058f, -0.04807084f, -0.06717546f, -0.06630222f, -0.00150847f, 0.03480074f, 
    -0.05310358f, 0.01426621f, 0.01635574f, 0.03053264f, -0.01368158f, 0.00812714f, 0.00183479f, -0.05948317f, 
    -0.06737093f, 0.03883441f, -0.04631162f, -0.03314097f, -0.05708237f, 0.03386094f, -0.02890384f, 0.02302807f, 
    -0.06424182f, 0.00908342f, -0.01210402f, 0.00348635f, 0.03527470f, 0.00083029f, -0.01837578f, -0.05578246f, 
    -0.03709980f, -0.00236746f, -0.02482324f, 0.02806610f, 0.04780595f, 0.01200494f, 0.04672301f, 0.02572283f, 
    -0.02120662f, -0.00586197f, -0.04115854f, 0.00338763f, -0.01017537f, 0.01658703f, 0.01073405f, -0.01462503f, 
    -0.02589832f, 0.01029519f, -0.02228137f, 0.00405441f, 0.04540931f, -0.02197991f, -0.05175588f, -0.06372609f, 
    0.02354507f, 0.03168915f, -0.01597069f, 0.02217693f, 0.00682892f, -0.06295069f, 0.03789677f, -0.00465956f, 
    0.00878514f, 0.02105490f, 0.00649909f, -0.03108617f, -0.04495836f, 0.03987556f, 0.03326747f, -0.01271248f, 
    -0.05780833f, 0.01697769f, -0.04761290f, -0.03052961f, -0.06743180f, 0.03411474f, 0.02337253f, 0.02044744f, 
    -0.06790867f, -0.05043323f, -0.04413886f, -0.06603573f, -0.03067687f, 0.00639390f, -0.05419954f, -0.05429056f, 
    0.04785803f, -0.03614207f, -0.03713063f, -0.02469671f, 0.03819302f, 0.00055289f, 0.03074987f, 0.00064637f, 
    0.03798446f, -0.04686131f, -0.02775095f, -0.04544776f, -0.03797329f, 0.04574069f, 0.04315741f, -0.01499037f, 
    0.02166521f, -0.02514034f, -0.01647968f, -0.06129745f, -0.03935983f, 0.01521921f, -0.05315252f, -0.05840673f, 
    0.02912249f, 0.03960150f, 0.01245586f, -0.02975237f, -0.04699929f, -0.06183735f, 0.03774689f, -0.00637056f, 
    -0.04569485f, -0.03526944f, -0.04017724f, 0.02797624f, -0.00255279f, -0.06076080f, 0.04076137f, 0.04164939f, 
    0.00125617f, -0.00856252f, 0.03415577f, -0.01992607f, -0.04487053f, -0.04080187f, -0.05535649f, -0.03434313f, 
    0.01394470f, -0.05591210f, -0.04398360f, -0.03929108f, -0.06144562f, -0.02005955f, 0.03052672f, -0.05223780f, 
    0.01493101f, -0.02082148f, -0.05481761f, -0.03110227f, 0.02457077f, -0.02574416f, -0.03867770f, -0.03845395f, 
    -0.02324529f, -0.00638001f, -0.02574189f, -0.03580115f, 0.00428737f, 0.00256156f, 0.04992479f, 0.00427641f, 
    -0.01117791f, -0.03729322f, -0.04996327f, -0.00794296f, 0.01812972f, -0.04287647f, -0.03721145f, -0.04229584f, 
    -0.02987466f, 0.02891453f, -0.04323191f, -0.03356868f, -0.02315658f, 0.01954227f, -0.01166540f, -0.00020197f, 
    0.03429838f, 0.03489959f, -0.02917206f, -0.01992290f, -0.00959216f, 0.04328933f, 0.04740166f, 0.02491623f, 
    -0.04366628f, -0.00864965f, -0.04969742f, 0.02215328f, -0.06132303f, -0.05105023f, 0.00509277f, -0.02741515f, 
    -0.00587942f, -0.05189983f, -0.05232617f, 0.00504923f, 0.00454457f, 0.03976234f, 0.03996391f, -0.04476794f, 
    0.02143994f, -0.03456514f, 0.01193591f, 0.03286372f, -0.03113715f, 0.01112213f, -0.04424146f, -0.02195239f, 
    -0.04032846f, 0.04815131f, -0.00130126f, -0.01436613f, -0.04226246f, 0.02228502f, -0.01950137f, 0.01634142f, 
    0.03790914f, -0.05259237f, 0.01555214f, -0.00766550f, -0.04974341f, -0.04788087f, 0.04956983f, 0.04043240f, 
    -0.02585691f, 0.02242032f, 0.02709676f, 0.03936026f, 0.01466758f, 0.03619924f, 0.03820181f, -0.03580634f, 
    -0.00557347f, 0.00391162f, -0.00105471f, 0.04930400f, -0.00783028f, -0.05341693f, 0.04424790f, -0.00284185f, 
    -0.03753925f, 0.03250577f, 0.01098773f, -0.02847899f, -0.00608598f, 0.02862046f, -0.02191041f, -0.06216182f, 
    -0.00515235f, -0.01642681f, 0.02978921f, -0.02082303f, -0.03884864f, 0.00278381f, 0.02395677f, -0.05560350f, 
    0.01491106f, -0.02682480f, -0.06223093f, 0.01702757f, 0.02151740f, -0.01414609f, -0.03501895f, -0.01382100f, 
    0.00692147f, 0.03914177f, -0.03726937f, -0.05130937f, -0.02792159f, -0.00070654f, -0.04411933f, -0.01257337f, 
    0.04371680f, -0.03049351f, -0.00673342f, 0.00023130f, 0.02599159f, -0.04809495f, -0.01174589f, 0.02075230f, 
    0.05014801f, 0.03440722f, 0.00010704f, -0.01284673f, 0.02326778f, 0.01714594f, 0.02135950f, 0.02045943f, 
    0.00973545f, -0.04244188f, -0.05329243f, 0.03531227f, -0.00010865f, -0.04059407f, 0.01567465f, -0.06187295f, 
    0.01176670f, -0.06264304f, 0.03748422f, -0.06374217f, -0.04849143f, -0.00648854f, -0.01814806f, 0.02892011f, 
    0.01689450f, 0.02703184f, -0.05624493f, -0.04110149f, -0.06321796f, 0.03404641f, -0.02169768f, -0.00455200f, 
    -0.05330268f, -0.05630375f, -0.05138636f, 0.01702634f, 0.02843701f, 0.01679725f, 0.02091976f, -0.00215382f, 
    -0.03589343f, -0.00852852f, -0.03765895f, -0.01140131f, 0.03644607f, 0.00625149f, -0.06594294f, 0.01769313f, 
    0.03874229f, 0.02250893f, -0.05818071f, 0.01053997f, 0.04779802f, -0.01913718f, 0.02892985f, -0.02956712f, 
    -0.06545677f, -0.00783676f, 0.03953443f, -0.03812178f, 0.03847470f, -0.02809669f, 0.05130593f, -0.03056050f, 
    -0.02774899f, -0.02555873f, 0.00279602f, 0.01713135f, -0.05653143f, 0.02381577f, -0.02944922f, -0.06082650f, 
    -0.02390948f, -0.05735369f, -0.02828307f, -0.03139900f, -0.03352619f, -0.01010558f, 0.00500777f, -0.02585779f, 
    -0.04753872f, -0.02738834f, 0.03238042f, -0.06007181f, 0.01905289f, -0.05806261f, -0.04063114f, 0.04264411f, 
    0.04755344f, 0.00192416f, -0.03718800f, -0.00050551f, -0.01489569f, 0.01713159f, 0.04936845f, -0.05909632f, 
    0.00317417f, 0.00166202f, 0.04294878f, -0.02363685f, -0.03471331f, 0.02746394f, -0.05606706f, -0.05573086f, 
    -0.05984698f, -0.04065462f, 0.02220475f, 0.02824165f, -0.03837238f, -0.02731163f, -0.02997346f, -0.01321215f, 
    -0.05442027f, -0.02757902f, -0.03951713f, -0.05589164f, -0.06685168f, 0.02651558f, -0.00359484f, 0.04378636f, 
    -0.02578702f, -0.03366045f, 0.03449992f, -0.01081174f, 0.03813738f, -0.03317618f, -0.03304785f, 0.02601023f, 
    -0.04362585f, -0.04019890f, 0.02471410f, 0.04701313f, -0.06171317f, -0.04841030f, 0.03952816f, -0.05786900f, 
    -0.04074656f, -0.02870495f, 0.00184297f, -0.01722306f, 0.04183263f, -0.00629463f, -0.03625119f, 0.03372050f, 
    -0.05008253f, -0.04929863f, -0.06069547f, -0.03542811f, 0.00418279f, -0.02882508f, -0.02935417f, 0.01026554f, 
    0.01897322f, -0.03757693f, -0.03252051f, 0.04460433f, 0.01671950f, 0.02846019f, 0.01568613f, -0.06424707f, 
    0.04152536f, 0.00908247f, -0.06561144f, 0.03753180f, 0.02242294f, 0.01245954f, 0.02010098f, -0.04485271f, 
    -0.03612227f, 0.04346917f, -0.03808114f, 0.04173303f, -0.06002653f, 0.04949112f, 0.03783311f, 0.01704183f, 
    0.03073533f, -0.06314348f, -0.05227342f, 0.02658513f, -0.05529502f, -0.00588966f, -0.01211873f, 0.02100219f, 
    -0.04772612f, 0.01395783f, 0.02334902f, -0.01930568f, -0.03295026f, -0.01944425f, -0.04492635f, 0.01352893f, 
    -0.03362466f, 0.00521935f, -0.04488455f, 0.04264236f, -0.04450966f, -0.02116103f, 0.03646229f, 0.01956699f, 
    -0.00725792f, -0.02488751f, -0.04146210f, -0.00541337f, -0.03706475f, -0.05307102f, -0.01504871f, -0.02655758f, 
    -0.04106362f, -0.04973048f, -0.03510014f, -0.05987206f, 0.03277154f, -0.06529292f, 0.04316690f, -0.04954857f, 
    -0.00893926f, -0.03464181f, 0.01423352f, -0.02336520f, -0.01737790f, -0.02149186f, 0.02189472f, -0.05504104f, 
    -0.06634484f, -0.05742035f, -0.06227710f, 0.04759801f, 0.03687498f, 0.00874709f, 0.03924287f, 0.03418763f, 
    0.01322612f, 0.01829834f, 0.02328299f, 0.04417545f, -0.01436882f, -0.02156485f, -0.02274042f, -0.05173991f, 
    0.01984201f, 0.01457783f, -0.00373667f, -0.01641656f, 0.02978386f, 0.00985074f, -0.01263449f, 0.03928353f, 
    0.04634239f, -0.05460763f, 0.02349601f, -0.04610495f, 0.01260116f, -0.03578473f, -0.04812881f, 0.04878090f, 
    0.03544070f, -0.04195065f, 0.00287297f, 0.01709202f, 0.04478203f, -0.05534687f, 0.03948558f, 0.04510856f, 
    -0.06185156f, 0.02102794f, 0.00868541f, -0.01740119f, -0.03986363f, -0.06364112f, -0.00503803f, 0.03358699f, 
    -0.04221758f, -0.04268757f, -0.02966633f, -0.01128666f, -0.03080685f, -0.02328862f, 0.01442258f, 0.05187957f, 
    0.04427799f, 0.01325371f, 0.04544731f, -0.00460785f, -0.00993073f, -0.02617843f, -0.01356386f, -0.04652412f, 
    0.01040518f, -0.02538449f, -0.00523684f, -0.02882155f, -0.03333363f, -0.02375306f, 0.05330063f, 0.03664548f, 
    -0.03657082f, -0.02665534f, -0.00306317f, 0.03297044f, -0.02468305f, 0.05070296f, -0.05870423f, 0.04049142f, 
    -0.06432125f, 0.00394803f, 0.04824329f, -0.04324184f, 0.04279123f, -0.06330120f, -0.02435448f, -0.02156392f, 
    0.05151044f, -0.05702025f, -0.06146682f, -0.01538948f, -0.03533516f, 0.03052548f, -0.04922859f, -0.01300325f, 
    -0.01765098f, 0.00855491f, 0.04674527f, 0.04495208f, 0.01744864f, 0.00998400f, -0.04742132f, 0.03566272f, 
    0.03461561f, -0.01266152f, -0.03748208f, -0.05462423f, 0.03128860f, -0.02235818f, -0.05018683f, -0.03014111f, 
    -0.03282847f, 0.02312714f, 0.02533091f, 0.03389396f, 0.03740715f, -0.05360244f, -0.05941469f, 0.02222985f, 
    -0.03956882f, -0.05290194f, 0.02717671f, 0.02425775f, 0.01315375f, -0.00376465f, 0.01984944f, -0.06092870f, 
    -0.06084532f, 0.01522739f, -0.02371153f, -0.05457057f, -0.05675909f, -0.03996612f, 0.00528769f, 0.01439773f, 
    0.03419914f, -0.06024679f, 0.04951863f, -0.01080884f, 0.01033014f, -0.05017457f, -0.05265668f, -0.03879678f, 
    0.00710501f, -0.00027292f, 0.00932425f, -0.00052466f, -0.03409125f, 0.01690776f, -0.00801009f, -0.00644452f, 
    0.01773639f, 0.04845674f, 0.00095485f, 0.00455984f, -0.00233588f, 0.00480723f, -0.04154683f, 0.00004175f, 
    -0.04878675f, 0.01464560f, 0.00852074f, 0.04869911f, -0.03029859f, 0.01393628f, -0.02362381f, -0.01549051f, 
    -0.04600053f, -0.05373210f, -0.04434530f, -0.01010043f, 0.01216864f, -0.03562069f, 0.03784050f, 0.03990068f, 
    -0.04210418f, -0.00925675f, 0.05214322f, -0.00995561f, 0.02391716f, -0.04049713f, -0.05749537f, 0.02623776f, 
    -0.02435411f, 0.01239370f, -0.01739199f, -0.04467713f, -0.03894749f, -0.01462737f, -0.03396810f, 0.00481262f, 
    -0.02866317f, 0.01673739f, 0.04198304f, -0.01708871f, -0.00705491f, -0.05700909f, 0.04266455f, 0.00958833f, 
    -0.03965150f, 0.03553503f, -0.06372224f, -0.00262816f, -0.01612793f, -0.00214566f, 0.00492010f, -0.03479237f, 
    -0.01474042f, -0.00279888f, 0.01528595f, -0.02758445f, 0.04974816f, -0.02365113f, 0.01345361f, 0.01815638f, 
    -0.00237763f, -0.06310209f, 0.03666681f, -0.06078218f, -0.00879837f, 0.03648872f, 0.05231478f, -0.02402248f, 
    -0.04731259f, -0.04592273f, -0.03691247f, 0.01350195f, -0.05347622f, 0.00405839f, -0.00994842f, -0.01991282f, 
    -0.05990430f, -0.02194619f, 0.02207481f, -0.04075485f, -0.03627913f, -0.06261934f, 0.03073540f, 0.02995697f, 
    -0.01183692f, -0.04012062f, -0.05909967f, -0.05449039f, -0.01575527f, -0.03783806f, 0.01461376f, -0.04263830f, 
    0.03798907f, 0.02108927f, -0.05549079f, -0.05873301f, 0.05141700f, -0.03187666f, -0.04299306f, -0.00865731f, 
    0.05022661f, -0.00576568f, -0.01264768f, -0.06029315f, 0.01435129f, -0.03412158f, -0.04000292f, 0.05277440f, 
    -0.01791483f, -0.01300419f, -0.00152064f, 0.00792484f, -0.01255852f, -0.06209150f, -0.00045915f, -0.06376521f, 
    0.03037407f, -0.03956953f, -0.05522874f, -0.01698812f, 0.00176771f, -0.01851718f, -0.06370676f, -0.02618315f, 
    -0.01295307f, -0.01595314f, -0.03412296f, 0.01492352f, 0.02686628f, 0.00776282f, 0.05237981f, 0.04909544f, 
    -0.01643222f, -0.04994800f, -0.04024375f, 0.00750408f, 0.03727088f, -0.05268359f, 0.04534793f, -0.02250845f, 
    -0.04378825f, 0.03366333f, 0.02074631f, -0.01908721f, 0.02605792f, 0.00535148f, 0.04802943f, -0.01446325f, 
    0.05345200f, 0.02889869f, -0.01867276f, -0.02893347f, 0.00576048f, -0.02462422f, 0.01634938f, -0.00003186f, 
    -0.04476721f, -0.02846110f, -0.01213541f, -0.00550253f, -0.00278831f, -0.03948801f, -0.03295999f, -0.04753133f, 
    0.01203583f, -0.05074651f, -0.05320898f, 0.04257594f, 0.00668279f, 0.03018609f, 0.01553330f, 0.01392970f, 
    0.01950506f, 0.03940021f, -0.03814654f, -0.02544838f, 0.03896060f, 0.00339574f, -0.05049689f, 0.04245706f, 
    -0.03574451f, 0.00228356f, 0.00552633f, -0.03774415f, 0.00053277f, 0.00423690f, -0.04526966f, -0.00958298f, 
    -0.01844993f, -0.00547343f, -0.01735358f, -0.00760894f, 0.02116194f, -0.00020307f, -0.04688331f, -0.05051560f, 
    0.01124756f, 0.03785466f, 0.00833094f, 0.04073634f, -0.00734687f, 0.02228774f, 0.00457508f, -0.01763719f, 
    -0.02677558f, -0.05457514f, -0.02790540f, -0.02934470f, -0.06187821f, 0.04111085f, -0.02610139f, -0.00998854f, 
    0.00610713f, -0.04697374f, -0.06647409f, 0.00572564f, 0.03619218f, 0.03713089f, 0.00909599f, -0.06266086f, 
    -0.02094392f, -0.00905025f, -0.02784661f, 0.01883359f, 0.04317620f, -0.04073022f, 0.00154921f, 0.00230991f, 
    -0.03922509f, 0.03393018f, 0.01128518f, -0.06602618f, -0.00459465f, -0.03423803f, -0.01510034f, 0.01347764f, 
    0.04089523f, -0.00900689f, -0.02876870f, 0.00578914f, 0.00996709f, -0.03743569f, 0.04597714f, 0.04331321f, 
    -0.03896832f, -0.05131604f, -0.06576668f, -0.02901186f, 0.03725125f, 0.00472304f, -0.01499414f, 0.02872827f, 
    -0.03391177f, -0.05968348f, -0.05429749f, -0.03117213f, -0.01823074f, 0.05086496f, -0.01038487f, -0.04492658f, 
    -0.03057740f, -0.03013790f, -0.02348611f, 0.05123934f, 0.05151635f, -0.04242108f, -0.02000649f, 0.01291503f, 
    0.01132250f, -0.04450614f, 0.02234942f, 0.02841221f, -0.01755166f, 0.05159874f, -0.02999255f, -0.00008422f, 
    -0.00033326f, 0.00922682f, 0.02192119f, 0.00224021f, 0.05062276f, -0.02052579f, 0.00809105f, 0.03469995f, 
    -0.02715099f, -0.06461569f, -0.04763907f, 0.02725970f, -0.05235213f, -0.05041924f, 0.04898034f, -0.05973668f, 
    -0.03500542f, 0.00164801f, -0.04423726f, -0.02048991f, -0.02005709f, 0.03378146f, -0.02328760f, 0.03664178f, 
    0.04694352f, 0.01415796f, 0.01697524f, 0.03824684f, -0.06396468f, -0.01771096f, 0.03714449f, 0.01873759f, 
    -0.04281129f, 0.00571482f, 0.04558645f, 0.02360036f, 0.01617113f, 0.02973375f, -0.01174708f, 0.02028419f, 
    -0.02290327f, 0.02923791f, -0.02213561f, -0.06561744f, -0.02193258f, -0.01071931f, 0.03840479f, -0.01066931f, 
    -0.06666136f, -0.00627633f, -0.01156398f, -0.01966341f, -0.05986395f, -0.04133033f, 0.06346584f, -0.04270069f, 
    -0.03702286f, 0.03846114f, -0.04264333f, -0.03720300f, 0.02808036f, -0.03392757f, 0.03955931f, -0.05544312f, 
    -0.03489896f, 0.00410891f, 0.04798897f, 0.04694779f, 0.03176796f, -0.06598885f, 0.02835457f, 0.04430835f, 
    0.03999464f, -0.03969403f, 0.04114095f, -0.02057058f, 0.01499370f, 0.00456911f, 0.00847737f, -0.05692503f, 
    -0.01315930f, 0.00285352f, 0.04825149f, -0.03192207f, -0.00995432f, -0.04889761f, 0.01191160f, 0.00924870f, 
    -0.03105519f, 0.02011222f, 0.02552024f, -0.03097284f, -0.00324599f, -0.02017359f, 0.04557686f, -0.02306958f, 
    -0.06258898f, -0.05199895f, -0.02873378f, 0.04871199f, 0.02063363f, -0.01355308f, 0.01233934f, -0.01674762f, 
    0.00700647f, -0.02020698f, -0.04521228f, -0.04057158f, 0.02201637f, 0.01487607f, 0.03933159f, -0.04484335f, 
    -0.01994970f, -0.01852855f, -0.04848382f, 0.03522846f, -0.03030848f, -0.05438485f, -0.06221816f, 0.03262907f, 
    -0.04346558f, 0.04505413f, 0.02164185f, 0.01923850f, 0.02034398f, 0.03764700f, -0.01462553f, -0.02434868f, 
    0.02650896f, 0.00308433f, -0.01454987f, -0.05710141f, -0.00171299f, -0.02350688f, 0.05254697f, 0.00986276f, 
    0.00046348f, 0.01874059f, -0.03946078f, 0.02483767f, -0.03037308f, 0.00635921f, 0.01094883f, -0.02840572f, 
    -0.00766953f, 0.03130420f, -0.02477368f, 0.01953251f, -0.06880533f, -0.06139621f, 0.02965117f, -0.04483725f, 
    0.00565935f, 0.03684371f, -0.02384974f, -0.02681819f, 0.02143116f, -0.04648504f, -0.04830115f, -0.05658474f, 
    -0.02237194f, -0.03587427f, 0.05130849f, -0.01974826f, -0.05958251f, -0.05952465f, -0.04401585f, -0.03783101f, 
    -0.01455464f, -0.02243647f, -0.00823244f, 0.04447666f, -0.03047956f, -0.00772694f, 0.03929234f, -0.01361141f, 
    0.03726853f, 0.01350849f, 0.01748016f, 0.01683553f, -0.04111601f, 0.00647200f, -0.05319930f, -0.00974599f, 
    0.05911990f, -0.01627693f, 0.07628325f, 0.03457492f, 0.03653562f, 0.03968302f, -0.00087050f, 0.03502734f, 
    -0.07113503f, 0.12827611f, -0.19979894f, 0.03091715f, -0.11330531f, 0.10463601f, -0.05439738f, -0.10197909f, 
    -0.08746734f, -0.04865142f, 0.38250682f, 0.05191879f, 0.11646631f, -0.04661470f, -0.09206085f, 0.00615677f, 
    -0.00084731f, -0.00107997f, 0.07994395f, -0.16122957f, -0.20528902f, 0.10713414f, -0.03006667f, -0.01708363f, 
    0.01613277f, -0.05956471f, 0.00494479f, -0.18596040f, 0.20018865f, -0.04969082f, -0.00932685f, -0.10512973f, 
    -0.03663897f, -0.13089906f, -0.06009825f, 0.13387525f, 0.10206559f, 0.18827744f, 0.15168361f, -0.06797897f, 
    -0.05768702f, -0.05688919f, -0.00425260f, -0.00880870f, 0.03188826f, 0.03937675f, 0.44755715f, 0.15900406f, 
    0.01677459f, 0.08130962f, 0.01526709f, 0.03266881f, -0.00943637f, 0.04811507f, -0.10925898f, 0.04304071f, 
    -0.08799316f, -0.07657576f, -0.08351807f, 0.02449888f, -0.03420550f, -0.03073822f, 0.00152068f, 0.00799449f, 
    -0.25323418f, 0.18158437f, 0.15513933f, -0.00243361f, 0.05527795f, -0.09008540f, -0.04405453f, 0.06803313f, 
    0.02680950f, 0.02693544f, -0.16136858f, -0.17541744f, -0.11063496f, -0.04482926f, 0.07009067f, 0.00292539f, 
    0.06666566f, -0.11680225f, -0.00782567f, -0.08717148f, -0.02493143f, -0.04772370f, 0.10129040f, 0.06966518f, 
    -0.05949610f, 0.00345185f, 0.03214766f, -0.08635476f, -0.01462781f, 0.03736540f, 0.08984925f, 0.04948802f, 
    0.09433674f, 0.07320080f, -0.08412149f, 0.08572136f, 0.01620260f, 0.22931373f, 0.06085751f, -0.03655099f, 
    -0.02114856f, 0.12586360f, 0.07642816f, 0.00824753f, 0.20895040f, -0.10560940f, -0.21023315f, 0.08522141f, 
    -0.06211540f, 0.03285898f, -0.06548615f, 0.04312351f, 0.08594075f, -0.07891854f, 0.30604866f, 0.14634198f, 
    0.04265445f, 0.03966861f, -0.04389633f, 0.02268371f, -0.02758810f, 0.01379600f, -0.03857399f, 0.17136243f, 
    0.00434526f, 0.12174051f, -0.08296378f, -0.03071773f, 0.17847940f, -0.01019055f, 0.03291646f, 0.01680941f, 
    -0.19860829f, -0.34188685f, 0.08029629f, 0.10221221f, 0.12835591f, 0.05922365f, -0.04605082f, 0.11549106f, 
    -0.23076856f, 0.19550227f, -0.00163236f, -0.12199209f, -0.04038525f, -0.27191100f, 0.12706655f, -0.01127265f, 
    -0.00326266f, -0.27215937f, 0.10287039f, 0.02302814f, -0.02734183f, 0.11872727f, -0.07516538f, -0.20129696f, 
    -0.04556442f, -0.05404216f, 0.09227952f, 0.12163316f, 0.05308144f, 0.12730303f, 0.06755648f, -0.10142647f, 
    0.21495077f, 0.06470986f, -0.04443738f, -0.09761425f, -0.09056550f, -0.00734337f, -0.00591298f, 0.06350654f, 
    0.06014168f, -0.03689595f, 0.04093167f, -0.01670481f, -0.03671066f, 0.03111582f, -0.12695070f, -0.29417968f, 
    0.03792408f, -0.05058316f, 0.00963750f, -0.05275076f, -0.08272835f, -0.19316357f, -0.23217963f, 0.08316301f, 
    -0.02944743f, -0.00782991f, -0.04478073f, -0.04783969f, -0.03979238f, 0.00989086f, -0.00263777f, -0.08346904f, 
    -0.02372899f, 0.19791360f, 0.06490390f, 0.10252933f, -0.01829173f, -0.00067192f, 0.02038485f, 0.01134783f, 
    -0.12775823f, 0.04416445f, 0.06439810f, 0.11221316f, -0.15446289f, 0.02949328f, 0.05358974f, -0.14394672f, 
    -0.04785978f, 0.06634650f, 0.10054741f, 0.15362345f, 0.05006352f, -0.01857964f, -0.03725106f, 0.01626262f, 
    -0.15948802f, -0.02135809f, -0.08371899f, 0.05904866f, 0.05938898f, -0.12095407f, -0.08172014f, -0.04620117f, 
    -0.40755337f, -0.04429740f, -0.12929206f, -0.00551997f, -0.07191626f, 0.02396765f, 0.02829907f, 0.04290796f, 
    -0.00668641f, -0.15086469f, -0.00031407f, -0.13621555f, 0.20858727f, 0.10309431f, 0.03583102f, 0.12422309f, 
    0.02959425f, -0.11736885f, -0.13372193f, 0.01013316f, -0.03677907f, 0.08019511f, 0.02178470f, 0.12145503f, 
    0.00715940f, 0.01709912f, 0.02049616f, -0.10258186f, 0.03607502f, -0.04489783f, -0.14508480f, -0.08726360f, 
    0.13212574f, -0.01819446f, 0.07448526f, 0.22060518f, 0.12748133f, 0.07616518f, -0.02250158f, -0.21357197f, 
    -0.02299920f, -0.12625149f, -0.08397130f, 0.04743091f, 0.05257743f, -0.12461751f, -0.04815149f, 0.03907533f, 
    0.03388935f, -0.03583664f, -0.02649083f, 0.02253436f, 0.01769879f, 0.02790307f, -0.05686771f, 0.00050251f, 
    -0.04739519f, -0.06216744f, 0.02404846f, 0.03310451f, -0.03612369f, -0.03529328f, -0.02601144f, 0.00607289f, 
    0.01476917f, -0.04413789f, 0.02397943f, -0.03710407f, 0.02349912f, -0.03280939f, -0.01778912f, 0.04042576f, 
    -0.05695533f, -0.00272266f, 0.02344265f, 0.02954961f, -0.03776297f, 0.01196335f, -0.05584641f, 0.02715176f, 
    0.04879179f, 0.03221057f, -0.02917856f, -0.04343469f, 0.02632203f, 0.04550299f, -0.05829950f, -0.01753975f, 
    -0.05271087f, 0.04991083f, -0.01137338f, -0.01878828f, 0.04475069f, -0.00039871f, -0.01565246f, -0.01829275f, 
    0.05262983f, -0.01651978f, 0.04322884f, -0.04012975f, -0.05303064f, 0.03682972f, 0.03632771f, -0.01900640f, 
    -0.00735827f, 0.00095529f, -0.03791329f, -0.02579261f, -0.05940203f, 0.02470486f, -0.03275151f, 0.03538320f, 
    -0.04905852f, -0.01896853f, -0.02279244f, 0.00676938f, 0.00255085f, -0.00243611f, 0.02426083f, -0.01469954f, 
    0.00813000f, 0.00099757f, 0.03390178f, 0.00324905f, -0.05779239f, 0.01286422f, -0.05646392f, -0.02808389f, 
    -0.00527956f, 0.04441141f, 0.03540462f, 0.04546031f, -0.05264587f, -0.05348789f, 0.05158505f, 0.01409762f, 
    -0.02888504f, -0.04809502f, -0.04934726f, 0.04870983f, -0.06409901f, -0.01905762f, -0.03918391f, -0.04893852f, 
    -0.00858360f, 0.05648314f, 0.00895543f, -0.04087475f, -0.00406613f, -0.01956604f, -0.01542315f, 0.02843568f, 
    -0.03227884f, -0.02063355f, 0.01229635f, -0.01397606f, -0.06403321f, 0.04272911f, -0.05350854f, 0.04999370f, 
    0.02271211f, -0.03444683f, 0.03992137f, -0.04347829f, 0.01831132f, -0.06372573f, 0.05108251f, -0.02358232f, 
    0.02017191f, -0.00363690f, 0.02114938f, -0.04571977f, -0.01755816f, -0.02992410f, 0.03402857f, 0.03901009f, 
    -0.04368432f, -0.01619406f, -0.05112761f, -0.04050273f, 0.01206366f, -0.03993500f, -0.01956015f, -0.05802560f, 
    0.01974305f, -0.01279001f, -0.01231733f, 0.01586614f, -0.01624673f, -0.02316479f, -0.02147728f, 0.03679179f, 
    -0.04782402f, -0.01956528f, 0.02306966f, -0.03014733f, 0.04769891f, -0.03551686f, -0.02831634f, -0.03349045f, 
    0.01278945f, -0.05577587f, -0.00733141f, -0.05021601f, -0.02764655f, 0.04218409f, 0.04758058f, -0.02201359f, 
    0.03850119f, -0.05056780f, -0.01895041f, -0.05212981f, 0.04324319f, -0.04585860f, 0.02531748f, -0.03775922f, 
    -0.02635374f, -0.02154458f, -0.05732470f, 0.04500650f, -0.05569736f, -0.05959157f, 0.01893054f, -0.02049205f, 
    -0.02448178f, 0.00210771f, -0.00989840f, -0.05748162f, -0.05395712f, 0.01110569f, -0.01805722f, 0.03743332f, 
    0.01788846f, 0.02222315f, -0.06428266f, 0.02106576f, 0.00088855f, -0.01086020f, -0.01720012f, -0.01039854f, 
    -0.05593599f, -0.00204929f, 0.04884402f, -0.05154827f, -0.03318109f, -0.01129935f, -0.03928118f, 0.02765146f, 
    -0.00437657f, -0.05820764f, -0.02923401f, 0.04292744f, 0.04153761f, 0.00171383f, -0.03257083f, 0.04441580f, 
    -0.01273651f, -0.00133519f, 0.02646587f, -0.06113078f, -0.02086978f, 0.04527269f, 0.05395342f, -0.06051407f, 
    -0.01319982f, 0.03716393f, 0.02201661f, -0.02665155f, 0.01904760f, -0.00092961f, 0.02599741f, 0.04665468f, 
    -0.01037851f, 0.04107847f, -0.05031810f, -0.02361311f, -0.04254475f, -0.03331267f, 0.05046077f, 0.02115724f, 
    -0.00336549f, -0.05146136f, -0.01106733f, -0.05478321f, -0.01691480f, -0.05944885f, 0.02503461f, -0.00252858f, 
    -0.02452762f, 0.00110549f, -0.05948338f, -0.06095977f, 0.01292150f, 0.00599408f, 0.04742733f, 0.00242880f, 
    0.00892460f, -0.01450882f, 0.03786367f, -0.00312503f, -0.02220288f, 0.01702976f, 0.00175212f, -0.01615549f, 
    -0.04424770f, 0.03991346f, -0.00920288f, -0.05981524f, 0.04308847f, 0.02892349f, 0.03059264f, -0.02783321f, 
    -0.03534344f, -0.03538004f, -0.00433660f, 0.00164733f, -0.02162441f, -0.00562183f, 0.04048808f, -0.03356146f, 
    0.00095238f, 0.00535218f, -0.00212929f, 0.03109707f, 0.01663356f, -0.05401029f, -0.04759304f, -0.00889077f, 
    0.00143571f, -0.03624066f, -0.04495055f, 0.02814340f, -0.01402919f, 0.00419514f, 0.03016415f, 0.02800610f, 
    0.03216266f, 0.07768668f, -0.01455941f, -0.03992495f, -0.01704338f, 0.00043273f, -0.04526377f, 0.04947748f, 
    0.00689309f, 0.01132248f, 0.02814899f, -0.07210085f, -0.14640199f, 0.01972376f, 0.13287659f, -0.11391199f, 
    0.02073519f, 0.05787580f, 0.20849174f, -0.09653817f, 0.07950589f, 0.03556399f, 0.06824775f, -0.17894033f, 
    -0.00126703f, 0.01087074f, 0.04907374f, -0.12058054f, -0.32321069f, -0.05976503f, 0.11957787f, 0.17461772f, 
    0.07892326f, 0.18508796f, 0.06704230f, 0.09590685f, 0.04197413f, -0.00485044f, -0.25334650f, 0.05780143f, 
    -0.00243077f, -0.16506536f, -0.01852383f, 0.09334026f, 0.05658779f, -0.09988664f, -0.01395792f, -0.11350200f, 
    0.07494958f, 0.02263538f, 0.05742513f, -0.00573854f, 0.05742487f, -0.03013330f, 0.04666766f, -0.15536232f, 
    -0.00815231f, 0.09882736f, -0.01580338f, -0.06759689f, -0.02203603f, -0.01005169f, 0.03384324f, -0.32302058f, 
    -0.11954538f, -0.07927887f, -0.01728966f, 0.16289818f, -0.14562519f, 0.03184408f, 0.17294399f, -0.00795339f, 
    -0.00261966f, 0.06692573f, -0.07620071f, -0.10393388f, -0.08415332f, 0.01234187f, 0.04094244f, 0.06052882f, 
    0.01999284f, -0.38972571f, -0.03619075f, -0.07074744f, -0.02560542f, 0.00786850f, 0.14628188f, 0.13704197f, 
    0.02142070f, 0.07255274f, -0.11694151f, -0.06768541f, 0.03685737f, -0.04838496f, 0.09204973f, -0.03527728f, 
    -0.13768850f, -0.08953059f, -0.04850711f, 0.08773002f, -0.19484355f, -0.19212314f, -0.07227447f, -0.04855393f, 
    -0.06957585f, 0.08055546f, -0.07194209f, -0.12588163f, -0.16327827f, 0.06491341f, 0.23236172f, -0.05034762f, 
    0.04011911f, -0.08333262f, -0.20620485f, 0.10470212f, 0.01098019f, 0.43055621f, 0.02164955f, -0.07768677f, 
    0.01039130f, -0.03966200f, 0.08952887f, 0.09594174f, 0.07053629f, 0.06790479f, -0.18828379f, -0.09907101f, 
    0.05248054f, 0.10106912f, -0.08836081f, 0.18293014f, -0.12239482f, 0.04805186f, -0.10730298f, 0.21091095f, 
    -0.15352651f, -0.03487545f, -0.09814951f, 0.11306030f, 0.10181565f, 0.17704564f, 0.03586556f, 0.02414641f, 
    -0.07342915f, -0.38122717f, 0.03345544f, 0.08368809f, 0.08918189f, 0.16075680f, 0.11709402f, 0.20785786f, 
    0.18951701f, 0.00831591f, -0.37883404f, -0.16182512f, -0.12029038f, 0.04841825f, 0.08622226f, 0.05529633f, 
    0.04299716f, -0.08738127f, 0.17950463f, -0.03085634f, 0.14396551f, 0.01248740f, -0.07197656f, -0.08201355f, 
    -0.02171674f, -0.05028107f, 0.03664860f, -0.18338341f, 0.17215003f, 0.07911565f, -0.03619097f, -0.05296274f, 
    0.00505083f, -0.27021989f, 0.05701207f, 0.14466792f, -0.27761963f, 0.02293788f, -0.01518046f, -0.01088796f, 
    -0.18472922f, -0.02821082f, 0.14982350f, 0.20922153f, 0.06894827f, 0.14465457f, -0.10793529f, -0.05603272f, 
    0.06576519f, 0.04499358f, 0.02088097f, -0.01682701f, -0.03132355f, -0.07459110f, 0.08076759f, -0.28643879f, 
    -0.19229250f, 0.13014203f, -0.04243753f, -0.07111139f, 0.27421159f, -0.15785070f, -0.04273893f, 0.01502259f, 
    0.16818891f, -0.12695158f, -0.12428287f, 0.04584162f, 0.09803013f, 0.03176333f, 0.10919244f, -0.04683675f, 
    0.01233977f, -0.01025430f, -0.05084805f, -0.00897117f, 0.11217658f, 0.10774136f, -0.00890623f, -0.10902302f, 
    -0.11178301f, 0.15199982f, 0.03034617f, 0.15675659f, -0.02875324f, 0.03046788f, 0.05820587f, 0.05689676f, 
    -0.16472781f, 0.16767874f, -0.00804421f, -0.20542359f, -0.13929470f, -0.06860135f, 0.11175074f, -0.05203524f, 
    0.17061694f, 0.02312048f, -0.02305487f, -0.07184788f, 0.03931021f, 0.04807607f, 0.09655496f, 0.07201864f, 
    0.04520444f, 0.03854673f, 0.13706677f, 0.11989693f, 0.54101932f, -0.07180981f, -0.03646690f, 0.13085413f, 
    0.02177527f, -0.15411703f, -0.08493259f, -0.01644552f, 0.00804939f, -0.20223619f, 0.15335625f, 0.10390647f, 
    0.03743524f, -0.01872826f, -0.01075309f, -0.08829673f, 0.09787944f, -0.01076244f, -0.01100579f, -0.27701601f, 
    0.01114691f, 0.06995017f, -0.02660087f, 0.12057950f, 0.02149264f, 0.09150251f, 0.06132675f, -0.33043203f, 
    -0.06251359f, -0.11494223f, -0.03227713f, 0.18028159f, -0.00370136f, -0.08309435f, 0.06355374f, 0.02530722f, 
    -0.05259764f, 0.03312760f, -0.03783892f, -0.05819941f, -0.01562028f, 0.02072188f, -0.05234366f, -0.00216835f, 
    0.02790838f, 0.04454690f, -0.03737435f, -0.00234877f, 0.04439423f, 0.01993413f, -0.00948276f, -0.01130887f, 
    -0.01883587f, 0.04212170f, -0.02671124f, -0.00657572f, -0.06206844f, 0.00471718f, 0.04762972f, 0.02986324f, 
    0.03946721f, 0.02798694f, 0.01166893f, -0.04064235f, -0.05408192f, 0.03221872f, 0.03288420f, -0.05957695f, 
    0.00435377f, 0.00431561f, 0.05035158f, -0.00255361f, 0.02644047f, -0.03124912f, -0.04306992f, 0.01787479f, 
    -0.03055469f, -0.04229196f, 0.02941998f, -0.01577515f, -0.03879088f, 0.01070751f, 0.02558947f, -0.06155570f, 
    -0.03381127f, -0.03607365f, 0.02501556f, -0.01641097f, 0.02744030f, -0.01040596f, -0.04325676f, 0.03889315f, 
    -0.04362734f, -0.02515259f, 0.03449110f, 0.01349663f, -0.05027316f, -0.02463369f, -0.00820806f, 0.03598832f, 
    0.02679261f, 0.03373134f, -0.00406908f, -0.02904310f, 0.01292372f, -0.04417300f, -0.05186879f, 0.03937045f, 
    0.04392888f, -0.06054209f, -0.01902923f, 0.05068349f, -0.03556452f, -0.01499705f, 0.05189898f, -0.03443161f, 
    0.00521752f, -0.03347396f, -0.03185777f, -0.02991526f, 0.03660015f, 0.01832129f, 0.01928779f, 0.00401994f, 
    0.03343719f, -0.02782725f, 0.01414008f, -0.01904802f, 0.04059551f, -0.05267016f, -0.01288690f, 0.02033859f, 
    0.03784290f, -0.01940463f, 0.00460085f, 0.00397185f, -0.03388910f, 0.02751753f, 0.01173456f, -0.00149960f, 
    -0.01182045f, -0.04566799f, -0.01910871f, -0.00990410f, -0.02032002f, -0.03289132f, 0.03567015f, -0.02670873f, 
    -0.06129345f, -0.00874223f, 0.04699732f, 0.01982762f, -0.00823455f, -0.02729702f, -0.03603853f, 0.02276449f, 
    -0.04491344f, -0.06411223f, -0.03561577f, -0.00320331f, 0.02809124f, -0.04619493f, -0.00944593f, -0.05525925f, 
    0.04058132f, -0.04270436f, 0.04298734f, 0.04346061f, -0.01369385f, 0.01830112f, -0.04866629f, -0.00416762f, 
    -0.05861389f, 0.00098935f, 0.04176397f, 0.04615874f, -0.01998025f, -0.03925334f, -0.00394450f, -0.05250287f, 
    0.01851219f, -0.06023334f, -0.01391849f, 0.01516285f, -0.00587644f, -0.05486599f, 0.01910095f, 0.00078306f, 
    -0.01319842f, 0.04925669f, -0.00390763f, -0.03799444f, -0.03660978f, -0.06601663f, 0.04399237f, -0.01583877f, 
    0.02477380f, -0.00385876f, 0.04139700f, -0.00902928f, 0.04427527f, -0.02627156f, -0.00896432f, -0.00013036f, 
    -0.02952702f, -0.03455743f, -0.00622162f, -0.03805047f, -0.05289612f, -0.01019445f, 0.03031939f, 0.00711192f, 
    0.03829370f, -0.04721706f, 0.01402731f, -0.05016180f, 0.02451218f, -0.03022102f, -0.04299702f, -0.02223006f, 
    -0.06058935f, -0.05914137f, 0.02861782f, 0.04893476f, -0.06549338f, -0.06201446f, 0.03878989f, -0.02261504f, 
    0.00233112f, -0.00790038f, -0.04842580f, 0.00814550f, -0.04596089f, 0.02174475f, 0.03261691f, -0.04489503f, 
    0.03146457f, -0.06332626f, -0.04075509f, -0.06547579f, 0.02908394f, 0.04421692f, 0.02124917f, -0.05327475f, 
    0.02356281f, 0.03871269f, 0.01903897f, -0.02957106f, 0.03557688f, 0.00653458f, -0.03798902f, 0.00775872f, 
    0.03662024f, 0.02847676f, -0.01931707f, -0.02803552f, -0.04121749f, 0.01476900f, -0.01717428f, -0.01851484f, 
    -0.04176224f, 0.02705610f, -0.02051662f, 0.01876935f, 0.03594585f, -0.00601677f, -0.01315543f, 0.04299447f, 
    -0.06245292f, -0.00854395f, -0.06249334f, -0.01874931f, 0.04252430f, 0.03184677f, -0.03318103f, 0.05334560f, 
    -0.04549351f, -0.05177054f, -0.05804302f, -0.04116957f, -0.06015093f, 0.00474952f, 0.01580651f, -0.03360868f, 
    -0.00465709f, 0.02755447f, -0.00763768f, 0.04004492f, -0.05534362f, -0.02276167f, -0.03692256f, -0.06213668f, 
    0.01439212f, 0.03334244f, 0.04742130f, -0.02214293f, 0.05027740f, -0.04475439f, -0.03830408f, 0.00798516f, 
    -0.04255864f, 0.00578087f, -0.04094135f, -0.03144267f, 0.02370915f, -0.03964546f, -0.02411991f, -0.05687226f, 
    -0.03804747f, -0.06457073f, -0.05261350f, 0.04745865f, -0.02650300f, -0.03800614f, -0.03180443f, -0.03357085f, 
    0.00550931f, -0.05552706f, -0.05627642f, -0.05615738f, 0.03782433f, -0.02501775f, 0.02129713f, -0.06289187f, 
    0.05777017f, 0.00152033f, 0.08996071f, 0.03814871f, -0.04765077f, 0.05245151f, -0.02714267f, -0.01899148f, 
    0.17707637f, 0.34832272f, -0.32102469f, -0.14877230f, 0.05631192f, 0.04417890f, -0.18774951f, -0.00577441f, 
    0.04983997f, -0.15257952f, 0.17715383f, 0.02587144f, -0.00051750f, 0.00224631f, -0.02654023f, -0.02387960f, 
    0.07086934f, -0.05423420f, 0.07817953f, -0.21011874f, 0.00007281f, -0.07342096f, 0.04996745f, 0.02839181f, 
    0.08216476f, -0.01064804f, -0.09469596f, 0.23090552f, -0.15187044f, -0.10947005f, 0.03336548f, -0.01821136f, 
    -0.08837868f, 0.00759844f, -0.16670123f, 0.05219346f, 0.25503594f, -0.01360385f, -0.03826543f, -0.08569226f, 
    -0.05843408f, 0.03914303f, -0.08446443f, -0.03768280f, 0.01432987f, -0.10952406f, 0.17809600f, 0.09262541f, 
    -0.04643996f, 0.17919433f, -0.02514846f, 0.06149375f, 0.01951257f, 0.05264244f, 0.07781444f, 0.04443776f, 
    0.10323124f, -0.10140941f, 0.01817598f, 0.04174928f, 0.07899206f, -0.03918444f, -0.21240377f, 0.06344454f, 
    -0.25747433f, 0.23830955f, 0.07188773f, 0.15511231f, -0.05397136f, -0.02446529f, -0.11802181f, -0.03649743f, 
    0.09533076f, -0.09353636f, -0.04294322f, -0.12430342f, -0.06077483f, -0.00022012f, 0.06071198f, 0.00174706f, 
    0.07417303f, -0.10824557f, -0.31434450f, -0.39612114f, -0.16113546f, 0.14276133f, 0.09753733f, -0.06220936f, 
    0.05172567f, 0.17124529f, -0.04203141f, -0.12003978f, 0.07963863f, 0.00125329f, -0.06966357f, 0.10571920f, 
    -0.00623903f, 0.14156777f, -0.03140779f, -0.10004194f, -0.09894402f, 0.02781032f, -0.31025589f, -0.06786152f, 
    -0.12244657f, 0.08211239f, 0.01018445f, 0.03009281f, 0.14368206f, 0.04375730f, 0.22520179f, 0.24663383f, 
    0.20281449f, -0.00217439f, -0.04232651f, 0.11367320f, -0.12599955f, 0.04683150f, 0.25228420f, 0.10419471f, 
    -0.16874836f, -0.00267360f, -0.02613699f, -0.13132668f, -0.04052693f, 0.01544352f, 0.07700117f, -0.09799811f, 
    -0.01481312f, 0.01237535f, -0.09014007f, 0.06223360f, 0.13124868f, 0.02512629f, 0.03763586f, 0.03526874f, 
    -0.22501238f, -0.25057685f, -0.01606745f, 0.06515713f, -0.00816803f, 0.13961913f, -0.11182889f, 0.04681297f, 
    -0.07259109f, 0.05949810f, 0.13555886f, 0.02525203f, 0.05466569f, 0.06720712f, 0.00725086f, -0.09477755f, 
    0.17993148f, -0.04825883f, -0.04507433f, 0.01467751f, 0.15950719f, 0.04002244f, -0.03926821f, -0.05588329f, 
    0.08633765f, 0.22236301f, 0.11419314f, -0.02976524f, 0.06788080f, -0.23175669f, 0.04476661f, -0.07845481f, 
    0.09565311f, 0.07462304f, -0.07294389f, -0.06449720f, 0.04259519f, -0.13509274f, 0.15015051f, -0.00164578f, 
    0.01168345f, 0.16357258f, 0.05428292f, 0.10436396f, -0.06820478f, -0.09651652f, -0.19607930f, 0.15110090f, 
    0.09999995f, 0.11229480f, 0.04903074f, 0.18454839f, 0.15663928f, -0.24965510f, -0.62641817f, -0.01098644f, 
    -0.07220107f, -0.07558127f, -0.08938766f, -0.05713386f, -0.02958249f, -0.13839266f, -0.00344644f, 0.14418529f, 
    0.01078133f, 0.32925615f, -0.06090364f, -0.01704579f, -0.08472560f, 0.05065559f, -0.10448790f, 0.12170583f, 
    -0.18820694f, 0.17078449f, -0.03237814f, 0.06735666f, 0.20793815f, 0.01439792f, 0.20009831f, 0.07203632f, 
    0.06771957f, 0.07860567f, -0.07775694f, -0.08400434f, 0.18536448f, -0.10903608f, 0.07571492f, -0.02629768f, 
    -0.03908828f, 0.15453549f, -0.28569949f, -0.11268028f, -0.18611012f, -0.04285639f, -0.07269868f, 0.08904409f, 
    0.07813284f, 0.05114320f, 0.11154957f, -0.20638002f, -0.01712528f, 0.07408447f, -0.05908911f, 0.10853784f, 
    0.00514000f, 0.12761526f, 0.03943644f, -0.16862570f, -0.05207031f, 0.11638759f, -0.16375898f, 0.15904525f, 
    0.06353221f, 0.07231192f, -0.00510595f, 0.08506810f, 0.00521501f, 0.35774136f, -0.18246998f, -0.03305668f, 
    -0.03540515f, -0.13028157f, 0.01823455f, 0.08915775f, -0.03248621f, -0.11559717f, -0.15337761f, 0.04644129f, 
    0.04692101f, 0.11006380f, -0.01131184f, -0.02060406f, -0.03652982f, -0.04624524f, -0.18078353f, 0.06666518f, 
    0.10403924f, -0.08710089f, 0.01698022f, -0.03629413f, 0.09484010f, -0.04884892f, -0.09008114f, 0.02210086f, 
    -0.05676755f, -0.04258190f, 0.02488951f, -0.00120253f, -0.06132397f, -0.00728660f, 0.03845461f, 0.03649086f, 
    -0.05929278f, -0.02371574f, 0.01687766f, -0.01182456f, -0.01617466f, -0.05024566f, -0.02398110f, 0.00260856f, 
    0.00591667f, -0.04967474f, -0.00891251f, 0.00863330f, -0.02681757f, 0.00385509f, -0.03968637f, -0.05054020f, 
    -0.01672905f, 0.00373052f, -0.00032635f, 0.01985506f, -0.05401518f, 0.00335957f, -0.04910753f, -0.00603394f, 
    -0.02563379f, 0.01449863f, 0.02983802f, 0.00441521f, -0.00957117f, 0.03466653f, -0.00741319f, 0.02024800f, 
    -0.00441262f, 0.02950113f, 0.03100763f, 0.05090211f, 0.01067769f, -0.03539037f, -0.02738963f, -0.05854287f, 
    0.02601012f, 0.03333038f, -0.03997136f, 0.02858038f, -0.03594597f, -0.02534014f, -0.03585257f, 0.04997993f, 
    0.04064876f, -0.03295675f, 0.01856595f, 0.01926478f, -0.05495760f, -0.03493434f, 0.01369079f, 0.00734356f, 
    -0.05206857f, 0.00838798f, 0.03475541f, -0.02957777f, 0.04638927f, -0.06373826f, -0.03944479f, 0.01517538f, 
    -0.04777092f, -0.02889545f, -0.03375947f, 0.01641501f, -0.04214506f, -0.05450168f, 0.00323838f, 0.00790758f, 
    -0.00708317f, 0.00508834f, 0.00928749f, -0.05043190f, 0.03110875f, -0.01465538f, 0.01209341f, 0.02047163f, 
    -0.06241126f, 0.02465987f, -0.03071741f, -0.04571066f, -0.01283525f, -0.02241857f, 0.02081564f, -0.03894361f, 
    -0.01163604f, -0.06169844f, -0.02412624f, 0.01727994f, -0.06074747f, 0.03264348f, 0.01967399f, -0.05845714f, 
    -0.06338065f, -0.04318053f, -0.04312447f, 0.04930921f, -0.06121880f, -0.00565105f, -0.00039720f, 0.03500684f, 
    0.01963071f, 0.04621064f, -0.03411351f, -0.03813294f, -0.03946733f, 0.00540239f, 0.02805961f, 0.05139995f, 
    -0.00090308f, 0.02198994f, -0.05954452f, -0.03843742f, -0.00950982f, 0.00219815f, -0.01545004f, 0.04644177f, 
    -0.01695937f, -0.00315253f, 0.04532614f, 0.02087999f, 0.01672652f, -0.05242966f, 0.03465696f, 0.01642152f, 
    -0.04869841f, -0.02170399f, -0.06239800f, -0.00014818f, -0.06306939f, -0.02951464f, 0.05227366f, -0.01970545f, 
    0.00199675f, 0.01619746f, -0.02776828f, -0.06279580f, -0.03309586f, 0.01734165f, 0.00935277f, -0.06113013f, 
    0.00708039f, 0.00456457f, 0.04161631f, 0.03316515f, 0.03957485f, -0.06068954f, 0.03978962f, -0.02337361f, 
    -0.04754434f, -0.06396955f, -0.00503921f, 0.00405541f, -0.00014218f, 0.01435543f, 0.04888548f, -0.05374168f, 
    -0.04064454f, 0.03206076f, 0.04793455f, 0.01901814f, -0.02698231f, -0.00148901f, 0.01380571f, 0.00644316f, 
    -0.01423808f, 0.04187737f, 0.02828812f, -0.03485356f, -0.00106213f, -0.01864600f, -0.01178347f, -0.02483849f, 
    -0.06232193f, 0.01742698f, -0.03116252f, -0.05807307f, -0.00103998f, -0.02248894f, -0.06356647f, -0.04466807f, 
    -0.03481248f, -0.04394792f, 0.03652666f, -0.02846877f, -0.04321400f, 0.04452732f, -0.00950439f, 0.00585117f, 
    -0.05995824f, -0.03541760f, 0.00085730f, -0.05460604f, 0.00421496f, 0.04973182f, 0.02782013f, -0.05185622f, 
    -0.01714956f, -0.00813562f, 0.04332057f, -0.03992428f, -0.05887613f, -0.02773441f, 0.03087444f, -0.03426221f, 
    -0.04340666f, 0.02043314f, -0.00238054f, -0.05346450f, 0.04457075f, 0.04960750f, -0.04881938f, -0.04960662f, 
    0.04102825f, -0.06288866f, -0.00254553f, 0.03022981f, 0.02866921f, -0.02604455f, -0.01364571f, 0.01104482f, 
    -0.04103039f, 0.04283609f, -0.03786101f, -0.05653650f, 0.02643856f, -0.03045021f, -0.01628151f, 0.00315474f, 
    -0.00128894f, -0.06069541f, -0.04809450f, 0.02200162f, -0.02536306f, 0.03522355f, 0.00954224f, -0.06434426f, 
    -0.06281981f, 0.01655562f, 0.04393164f, -0.05964267f, -0.02813247f, 0.03942953f, -0.04245693f, -0.01062038f, 
    -0.03075165f, 0.01824561f, 0.00684715f, 0.00807284f, -0.01252338f, 0.03591124f, 0.00544450f, -0.02683212f, 
    0.00676481f, -0.00605178f, -0.00473326f, 0.02496340f, -0.02259307f, -0.06281941f, -0.01143016f, 0.02837169f, 
    0.05344610f, -0.05172747f, -0.01486093f, 0.02588798f, 0.04712650f, 0.03001145f, 0.00864187f, -0.06281032f, 
    -0.01684123f, 0.03251384f, 0.04156003f, -0.05605316f, 0.03531663f, 0.03931868f, 0.01807485f, 0.03117001f, 
    0.05553291f, 0.02627290f, -0.22258455f, 0.17514710f, 0.12541850f, 0.14084958f, 0.09590878f, 0.05803979f, 
    0.03441675f, 0.01428497f, -0.14449714f, 0.14973408f, 0.15113916f, -0.04612146f, -0.13056077f, 0.08981929f, 
    -0.01635506f, -0.06480734f, -0.10369761f, -0.16993098f, -0.17714287f, -0.06152687f, -0.00425191f, 0.04121963f, 
    0.05060857f, -0.10355480f, 0.06348625f, 0.18016498f, 0.00569541f, -0.05885072f, -0.14492621f, 0.12877089f, 
    0.11004832f, 0.08242198f, 0.02597531f, 0.09475143f, 0.08067606f, -0.08890670f, -0.11193617f, 0.15614548f, 
    0.00062493f, 0.02063563f, -0.00831672f, 0.05455093f, 0.00071707f, -0.13322720f, 0.03221335f, 0.05234441f, 
    0.00563431f, 0.02382455f, 0.01256516f, -0.12987091f, -0.08980744f, -0.05832956f, -0.14354025f, 0.09623361f, 
    -0.08615771f, -0.04317431f, 0.12259602f, 0.14693500f, 0.14461927f, -0.09709993f, -0.11807561f, 0.01125927f, 
    -0.13204414f, -0.06158461f, 0.04236234f, 0.01840409f, 0.05873427f, 0.03614613f, -0.07741792f, 0.13481927f, 
    -0.19921200f, -0.25277478f, 0.03328913f, -0.01415257f, -0.04015785f, 0.01977731f, 0.02016537f, 0.11034413f, 
    0.00273946f, -0.00856869f, -0.00585713f, 0.01107188f, -0.22830065f, 0.17840378f, -0.03575223f, -0.00850898f, 
    0.01189754f, 0.02653394f, -0.12522262f, -0.00205038f, -0.06798839f, -0.08315772f, -0.12778518f, -0.10183275f, 
    -0.13602741f, -0.18879043f, 0.08489016f, 0.19456141f, -0.21588290f, -0.04394928f, 0.00382689f, -0.07787662f, 
    -0.13627703f, 0.15970689f, 0.15766114f, -0.07357425f, 0.30891037f, -0.08522177f, -0.01731214f, 0.14690940f, 
    0.08045033f, 0.00673953f, -0.08257855f, -0.06468566f, 0.04585087f, 0.04036508f, 0.04562685f, 0.19911103f, 
    -0.05360319f, 0.01509984f, -0.00044838f, 0.12737064f, 0.13351971f, 0.07199097f, -0.12829244f, 0.06354390f, 
    -0.04667461f, -0.04716072f, -0.01085533f, -0.06920040f, 0.10886333f, -0.02489347f, 0.04574751f, -0.23552063f, 
    -0.00481401f, 0.07297628f, 0.08788627f, -0.04140802f, -0.02792387f, -0.01875466f, 0.06518223f, -0.03657366f, 
    0.14950213f, 0.06684272f, -0.06754612f, -0.26321521f, -0.03541700f, -0.12846160f, -0.04303643f, -0.09385576f, 
    0.05993882f, -0.12976085f, -0.06115799f, -0.19815260f, 0.02959987f, 0.06014474f, -0.07337313f, -0.10839795f, 
    0.02135037f, 0.03295324f, -0.16393575f, -0.00311339f, 0.11730454f, -0.09117485f, -0.13227573f, 0.09427042f, 
    -0.11779238f, -0.02676785f, -0.03502107f, -0.06730127f, 0.39432457f, 0.33135679f, -0.04635954f, 0.07346793f, 
    -0.00936671f, 0.12154045f, 0.08045476f, 0.01639698f, -0.11864515f, -0.37115103f, -0.18692730f, -0.03834060f, 
    0.08117178f, 0.02261663f, 0.04407863f, -0.00389673f, -0.08852138f, 0.08911499f, -0.10416604f, -0.05108593f, 
    -0.06074074f, -0.03374574f, -0.09759660f, 0.00769771f, 0.22559389f, 0.02235941f, -0.13002381f, -0.20160484f, 
    -0.23239303f, -0.28309128f, -0.21239147f, 0.00689025f, -0.12193853f, -0.01165344f, 0.03399921f, -0.06023541f, 
    -0.13085590f, 0.26831487f, 0.18772455f, 0.03366884f, 0.04509902f, -0.09333200f, 0.17636809f, 0.17640007f, 
    -0.07379367f, -0.11774413f, 0.01375888f, 0.07929626f, 0.01527024f, 0.18937524f, -0.03421554f, -0.03092025f, 
    -0.07983625f, -0.19558457f, 0.27594945f, 0.06858648f, -0.04904965f, -0.12255820f, -0.08044355f, 0.09680704f, 
    0.03289501f, 0.10295860f, 0.07322931f, 0.15854898f, -0.09711887f, -0.01050731f, 0.01994139f, 0.24498373f, 
    0.15503389f, -0.00672177f, -0.00067922f, 0.17701201f, 0.01298948f, -0.28306177f, -0.04425692f, 0.02477254f, 
    -0.13325755f, 0.03335160f, 0.04760223f, 0.08267087f, -0.00769349f, 0.30905220f, 0.13778864f, -0.08876842f, 
    -0.28380275f, 0.00634739f, -0.15371330f, 0.12525947f, 0.02381760f, 0.27842113f, 0.36126181f, -0.07088680f, 
    0.07920759f, 0.08356739f, -0.05252772f, -0.04176100f, -0.01977593f, 0.01546922f, 0.10513950f, 0.02958420f, 
    0.13379017f, -0.17354600f, -0.10296325f, 0.02323655f, -0.00812517f, -0.03189946f, -0.04447085f, 0.23128363f, 
    0.00564520f, 0.02173695f, -0.18825582f, -0.09197988f, -0.05353799f, 0.09653980f, 0.05984949f, 0.17829789f, 
    0.10145078f, 0.05284090f, -0.08084442f, -0.18060952f, -0.07764711f, -0.02279716f, -0.00391747f, -0.04751726f, 
    -0.10918830f, -0.29874507f, 0.13649613f, 0.07971592f, -0.03396881f, 0.16647428f, -0.00804468f, 0.09454609f, 
    -0.02216163f, 0.07770859f, -0.15075694f, -0.13396642f, -0.18552145f, -0.09431165f, -0.04024152f, -0.17665604f, 
    -0.03432647f, 0.02214720f, 0.09671813f, 0.10443102f, 0.05791330f, 0.09142680f, -0.01347451f, -0.09808227f, 
    0.01157909f, 0.05179248f, 0.14448294f, 0.06770383f, 0.09181187f, 0.27125609f, -0.25914487f, -0.08022638f, 
    -0.10275570f, 0.05437971f, 0.02984963f, 0.05778150f, 0.03671287f, 0.03357087f, -0.08538548f, -0.23165421f, 
    0.30947450f, -0.06839930f, 0.09740193f, -0.02475206f, 0.00283868f, -0.16058065f, -0.15005693f, -0.21554859f, 
    0.00454893f, -0.05630360f, 0.03656530f, 0.09271450f, 0.07966588f, -0.03034529f, -0.11867020f, 0.07588744f, 
    0.04836275f, 0.07220966f, -0.04739997f, 0.08305454f, -0.18658116f, 0.06047756f, 0.06200130f, 0.07323056f, 
    0.19448839f, -0.16296723f, -0.09076406f, 0.06771607f, 0.00350553f, 0.13163485f, -0.02547431f, -0.07322883f, 
    0.04293801f, 0.00767926f, -0.00359166f, 0.21546066f, -0.03910450f, -0.04277668f, -0.01458458f, 0.04158384f, 
    0.14202423f, 0.06569929f, 0.21094510f, 0.21892063f, -0.13152185f, 0.03656981f, -0.00216408f, -0.01537412f, 
    0.08885117f, -0.05415624f, 0.23524548f, -0.08603226f, 0.22703864f, -0.10076734f, 0.05980361f, -0.07523762f, 
    0.05701759f, 0.07990418f, 0.03090258f, -0.22092894f, 0.16002782f, -0.12921040f, -0.11958338f, -0.01198878f, 
    0.08388989f, -0.03937278f, 0.07260700f, -0.09170678f, -0.18099117f, 0.22407059f, 0.01315087f, -0.05205530f, 
    0.03250499f, 0.00458227f, 0.19719467f, 0.03512206f, -0.07352205f, -0.02711579f, -0.14327709f, -0.08585472f, 
    -0.08447634f, 0.16089019f, -0.05025989f, 0.13233051f, -0.01534289f, -0.07045908f, 0.02714423f, -0.10046092f, 
    -0.07527124f, -0.04804919f, -0.06581868f, 0.07908641f, -0.06864208f, -0.02365592f, 0.10663894f, -0.10051200f, 
    0.19410172f, 0.03206552f, -0.11120307f, 0.04523427f, -0.06113840f, -0.00289751f, -0.04412833f, -0.05213059f, 
    0.23828468f, 0.21292587f, -0.10232556f, 0.22254527f, 0.10984262f, 0.05477292f, 0.09994873f, 0.04477136f, 
    0.13776627f, -0.02516222f, 0.20347773f, -0.09306192f, -0.03449709f, 0.12905666f, 0.08641612f, 0.03198668f, 
    -0.11598378f, -0.06953336f, 0.07169939f, -0.01139545f, 0.07005982f, 0.11044580f, 0.08416522f, 0.07716126f, 
    -0.12336325f, -0.07849912f, -0.03750844f, 0.15810992f, -0.12426908f, 0.00509198f, 0.01340246f, 0.23148173f, 
    -0.10054214f, 0.22830747f, 0.09866822f, -0.04681827f, 0.07754793f, 0.12308585f, -0.01579041f, 0.07304938f, 
    0.13921709f, -0.04574464f, -0.17654823f, 0.07173942f, 0.05330174f, 0.10210271f, 0.01481523f, -0.05581144f, 
    -0.19315259f, 0.03525769f, -0.16966918f, 0.06859725f, -0.02701357f, -0.01972186f, 0.10779160f, 0.06762683f, 
    -0.08587729f, 0.11538069f, -0.04696309f, 0.17486076f, 0.11115773f, -0.00937232f, -0.11438936f, -0.04362946f, 
    0.04644317f, -0.08990238f, 0.04664624f, 0.05184814f, -0.09203012f, -0.05514168f, 0.13350531f, -0.01333560f, 
    0.00656188f, -0.11055477f, -0.10734332f, -0.09992908f, -0.04814335f, 0.13319314f, 0.09095442f, 0.15940288f, 
    0.12221880f, 0.11536377f, 0.15366900f, 0.04125376f, -0.05637311f, 0.03526613f, 0.11964234f, -0.07473221f, 
    -0.00512115f, 0.10153529f, 0.15193962f, 0.14577672f, 0.10235195f, -0.01564203f, -0.11421771f, -0.15634786f, 
    -0.16398051f, -0.16093953f, 0.04037646f, 0.12105752f, 0.27651879f, -0.18583995f, -0.05925386f, 0.05236597f, 
    -0.04855735f, 0.00551950f, 0.02800016f, -0.07305527f, -0.07346661f, -0.12903024f, 0.25409198f, 0.04518220f, 
    -0.05396761f, 0.01307372f, -0.17666470f, -0.08030763f, -0.01087930f, -0.13973661f, 0.24142011f, 0.03019946f, 
    -0.03565402f, 0.12196980f, -0.22880131f, -0.07663642f, 0.08378242f, 0.07524028f, 0.02740547f, 0.13696344f, 
    0.02773407f, 0.08820456f, -0.09036341f, 0.09535909f, -0.16621797f, 0.03702841f, 0.08577237f, -0.08850949f, 
    0.15380773f, 0.13183260f, 0.21904543f, -0.05451028f, -0.00929111f, -0.08953273f, 0.06171105f, -0.04327451f, 
    0.11277276f, 0.10532257f, -0.06535652f, 0.21308830f, -0.09022401f, -0.07415422f, 0.02233072f, 0.04391977f, 
    -0.03223660f, 0.01594479f, -0.10953300f, -0.06087938f, -0.32455376f, 0.09411455f, -0.14210606f, 0.06003705f, 
    0.01519681f, 0.05382407f, 0.02654432f, 0.11947595f, 0.12616827f, 0.09140415f, 0.13270162f, -0.09605464f, 
    -0.11952364f, -0.01858719f, 0.01715160f, 0.00958034f, 0.19700383f, 0.14015201f, 0.29431057f, 0.07392293f, 
    0.05201730f, -0.10962288f, -0.03191198f, 0.16358881f, 0.03737573f, -0.05596639f, 0.06790246f, -0.07595319f, 
    0.04395279f, -0.03357354f, 0.01821701f, 0.08480495f, 0.09343098f, 0.01799899f, -0.12091197f, 0.04387401f, 
    0.03804776f, 0.03934642f, 0.01794094f, 0.01176675f, 0.08462451f, 0.03167940f, 0.03929730f, 0.00691487f, 
    0.11156965f, 0.01311592f, 0.00625535f, 0.09935730f, 0.04033988f, 0.19259723f, -0.07311124f, -0.01760538f, 
    -0.12467016f, -0.31721663f, -0.16110738f, -0.00864130f, 0.17290977f, 0.00081562f, 0.07947587f, -0.05532584f, 
    -0.06165604f, 0.18844491f, 0.08647160f, 0.06438331f, -0.05089337f, -0.09906729f, -0.18170933f, -0.06400359f, 
    0.11098360f, -0.05366892f, -0.00468246f, 0.12518057f, -0.08163709f, -0.02645153f, -0.09176333f, -0.01667940f, 
    0.06358387f, -0.09414494f, 0.02966229f, -0.17875412f, 0.04712921f, 0.12260568f, 0.01002546f, -0.01375383f, 
    0.02358406f, 0.03018613f, -0.02968128f, -0.03035842f, 0.05917254f, 0.01072502f, 0.00095072f, 0.00302943f, 
    -0.10719865f, 0.11177891f, 0.10139115f, -0.13303182f, -0.07556392f, -0.52984971f, -0.26809016f, -0.23125295f, 
    0.04640746f, -0.02864348f, -0.02770346f, 0.02410278f, 0.02254330f, -0.05027215f, -0.38907450f, -0.01762170f, 
    0.01680920f, 0.10426208f, -0.02346816f, 0.00854124f, 0.07787549f, -0.01023890f, -0.07748935f, -0.03631790f, 
    0.05003195f, -0.11558270f, -0.00921523f, 0.14584877f, 0.10950742f, 0.00433597f, -0.07540376f, 0.10104369f, 
    -0.09110957f, 0.11740983f, 0.07489309f, 0.12664728f, -0.12596574f, -0.08241440f, 0.04228843f, 0.11600561f, 
    -0.05296575f, -0.04183678f, 0.16690536f, -0.16514990f, 0.04342034f, 0.07288567f, 0.00454704f, 0.07360300f, 
    0.09017026f, -0.05220756f, -0.10850890f, 0.00941588f, -0.28616503f, 0.14740857f, -0.07413871f, 0.02601708f, 
    0.18271257f, -0.10897677f, -0.08427848f, 0.06398236f, -0.23366976f, -0.06208700f, -0.09143642f, -0.00222997f, 
    0.05475346f, 0.05366381f, 0.02646743f, 0.04149310f, -0.01068537f, 0.34361839f, -0.01990382f, 0.11197073f, 
    0.04974451f, -0.13732465f, 0.01302435f, -0.15270744f, 0.06911048f, -0.07965264f, -0.11135329f, -0.10685284f, 
    0.00946191f, -0.02499902f, 0.02307978f, -0.08840092f, 0.10047369f, -0.08164941f, -0.07127076f, 0.01428950f, 
    -0.05501900f, 0.14091705f, -0.02762474f, 0.05046207f, -0.05121665f, -0.05463646f, 0.10492713f, -0.37131056f, 
    -0.10475256f, -0.04407497f, 0.02089723f, 0.14259914f, 0.13519481f, 0.01507873f, 0.03621731f, 0.04006560f, 
    0.02708887f, 0.03613497f, -0.02963678f, -0.01870309f, 0.00495616f, -0.09973785f, 0.01054050f, -0.10249402f, 
    -0.16378231f, -0.05371997f, -0.08459951f, -0.03245682f, -0.18163733f, 0.02892097f, -0.07776415f, 0.06903455f, 
    -0.16993247f, 0.17834124f, 0.01349828f, -0.01354470f, -0.00191441f, -0.02354437f, -0.18383917f, 0.05019081f, 
    0.06817516f, -0.13109691f, -0.03196709f, 0.12770329f, 0.02222964f, 0.11136251f, 0.14704587f, 0.07874668f, 
    -0.16268806f, -0.00243262f, 0.04269176f, -0.00043130f, -0.19707814f, -0.09739576f, 0.14405748f, 0.08059878f, 
    -0.02523358f, -0.16635114f, 0.13892700f, -0.04745255f, 0.03982254f, 0.21860158f, -0.03685544f, 0.28675160f, 
    -0.00784459f, 0.07483475f, -0.07877368f, -0.01653371f, 0.06048653f, 0.04846534f, -0.01053370f, -0.01488735f, 
    0.10561341f, 0.11097509f, 0.03034422f, -0.08152729f, -0.10979449f, 0.11709860f, -0.05296510f, 0.10630098f, 
    -0.04217070f, 0.09907895f, -0.14387497f, 0.04219669f, -0.04340164f, 0.06437740f, -0.00202004f, -0.08064965f, 
    -0.04916608f, -0.04393052f, 0.01511903f, 0.02628631f, 0.02995590f, 0.03713663f, -0.03227484f, 0.04328331f, 
    -0.04211447f, -0.00131262f, 0.03365381f, -0.03186209f, -0.05273505f, 0.01494656f, 0.01209928f, 0.03967249f, 
    -0.03423862f, 0.02548498f, -0.03443009f, -0.00603369f, -0.04896504f, -0.00758284f, -0.00620006f, 0.00380806f, 
    -0.03949867f, 0.01246474f, -0.05239822f, -0.02072185f, -0.00206535f, 0.03496576f, -0.01849742f, 0.03676429f, 
    0.01599554f, -0.06183831f, 0.03195321f, -0.03183036f, 0.02196901f, 0.02336285f, -0.03935748f, -0.01316516f, 
    0.02316521f, 0.03882109f, -0.04283442f, 0.02887545f, -0.01635306f, 0.02029074f, -0.06573395f, -0.01789611f, 
    -0.04261096f, -0.00725988f, -0.04566226f, -0.00018762f, 0.00838403f, -0.03853462f, -0.00670295f, -0.06552614f, 
    0.00235173f, -0.03528330f, 0.01410600f, 0.02344765f, -0.03969773f, -0.00000097f, 0.01229539f, 0.02632380f, 
    0.03672029f, -0.02063759f, -0.02543036f, 0.02687310f, 0.02206787f, -0.05485870f, 0.02261420f, -0.04701269f, 
    -0.04732603f, 0.00797286f, 0.00695915f, -0.02238473f, -0.01200867f, -0.00351257f, -0.06388994f, -0.03837778f, 
    0.01747512f, -0.00447235f, -0.05430403f, -0.04921363f, 0.00189499f, 0.04746619f, -0.01845115f, 0.03030139f, 
    0.02797731f, 0.01948286f, -0.01704013f, 0.00272012f, -0.01564398f, -0.05302676f, -0.05561479f, 0.01284223f, 
    0.01872970f, -0.05957633f, -0.03887789f, 0.04038231f, -0.06427483f, -0.01325083f, -0.04034146f, 0.02776596f, 
    -0.00879754f, -0.00610516f, -0.02517185f, -0.02558611f, -0.03785782f, 0.02905179f, 0.00339584f, -0.04291296f, 
    -0.02151448f, 0.03762916f, 0.01083005f, -0.04263012f, -0.00062978f, 0.00225235f, 0.02450795f, -0.01019995f, 
    0.01208173f, -0.05390999f, 0.04805387f, -0.02347687f, -0.00603314f, 0.04201993f, -0.00347762f, 0.01503269f, 
    0.03564136f, -0.02037183f, 0.04391882f, -0.05978566f, 0.03054628f, 0.01570364f, -0.03037873f, -0.02562019f, 
    0.00324623f, -0.02148654f, 0.01194756f, 0.00032501f, 0.03711805f, -0.00976838f, -0.00958041f, 0.00064615f, 
    -0.02313956f, -0.00977897f, -0.03505369f, 0.04770892f, -0.00131776f, -0.02753007f, -0.05415677f, -0.01863321f, 
    0.05652689f, 0.01190856f, 0.00842484f, 0.03850802f, 0.04805534f, 0.00508553f, -0.00935591f, 0.03925675f, 
    0.01193596f, 0.03476574f, 0.04314825f, 0.00576816f, 0.03010290f, 0.03115344f, -0.05047071f, 0.04151073f, 
    -0.03954619f, 0.00923460f, -0.00806120f, -0.02700451f, 0.04698848f, -0.03939028f, -0.06091265f, -0.01799780f, 
    -0.02382991f, 0.00615862f, 0.01502885f, -0.00291370f, 0.00297586f, 0.02706056f, 0.01625126f, 0.00531814f, 
    -0.00601449f, -0.06366163f, 0.04452997f, 0.02247051f, -0.03853620f, -0.05407673f, -0.06638874f, 0.02893198f, 
    0.03605043f, -0.04701268f, -0.04772774f, -0.02306501f, -0.01366066f, -0.00097895f, 0.04378067f, 0.01501247f, 
    -0.06052228f, 0.01404770f, -0.06709640f, -0.03910700f, -0.01124587f, 0.01314025f, 0.02541854f, -0.05825221f, 
    -0.02291213f, 0.01801947f, -0.00196772f, 0.02267474f, -0.06460688f, 0.03711471f, -0.00185456f, -0.00261946f, 
    -0.05157143f, -0.06505053f, 0.01307225f, 0.00015616f, 0.02276095f, 0.03226114f, 0.04276551f, 0.04440467f, 
    -0.05174054f, -0.04360145f, -0.01419719f, -0.04286508f, -0.05540024f, -0.02137205f, -0.03956338f, -0.03029774f, 
    0.01896830f, 0.01986268f, 0.05822396f, 0.00319629f, -0.04617622f, -0.05784616f, -0.01432311f, -0.00830849f, 
    -0.00287609f, -0.05289404f, -0.05386288f, -0.02247738f, -0.01633218f, 0.01709678f, -0.04600075f, 0.00755136f, 
    0.04324371f, -0.01713700f, -0.06088775f, -0.04510893f, -0.04940318f, 0.00264538f, -0.01583344f, 0.00577900f, 
    -0.03912432f, -0.03543189f, 0.05431961f, 0.01502390f, 0.03771893f, 0.01829510f, -0.01630801f, 0.03133424f, 
    -0.03743490f, -0.00056188f, -0.01806944f, 0.01241777f, -0.03587440f, 0.04313625f, -0.01360126f, 0.03807228f, 
    -0.02375101f, -0.06196072f, 0.02733312f, 0.05348513f, 0.03610268f, 0.05225048f, 0.03591668f, -0.04115239f, 
    -0.03228456f, -0.01746492f, -0.03498856f, -0.07091290f, -0.00511454f, -0.05902895f, 0.03731648f, 0.00286076f, 
    -0.15959086f, -0.09636479f, -0.16487481f, 0.10644910f, 0.05622071f, 0.00991681f, 0.16459996f, -0.04761177f, 
    -0.07478506f, -0.10055159f, -0.06043426f, -0.01732596f, 0.03157055f, -0.05908807f, -0.05260976f, -0.10876202f, 
    0.01672050f, -0.16161232f, 0.13423002f, 0.11513010f, -0.07717342f, -0.02765744f, -0.07615931f, 0.08677467f, 
    0.10956007f, 0.01395163f, 0.13448575f, -0.03388815f, 0.22350974f, 0.16675766f, -0.00955152f, 0.08559840f, 
    0.10314024f, 0.07743351f, 0.12452714f, 0.00066387f, 0.00901017f, -0.05841974f, -0.04592801f, 0.12380559f, 
    0.12857836f, -0.01304122f, 0.05330464f, -0.10217914f, 0.04642519f, 0.17165731f, -0.18085617f, -0.06110968f, 
    -0.19582751f, 0.04801648f, -0.13502946f, -0.02999038f, 0.10593435f, 0.14396837f, 0.21938072f, 0.14195405f, 
    0.02568839f, 0.01611666f, 0.07410795f, -0.07171217f, 0.07154105f, 0.10523324f, 0.09525108f, -0.05668608f, 
    0.13430348f, 0.11319739f, 0.04659374f, 0.07037076f, 0.17269960f, 0.16889836f, -0.04206256f, 0.00395741f, 
    -0.19381917f, 0.02773093f, 0.00736251f, 0.02470046f, -0.12234159f, 0.18406571f, -0.16562684f, -0.06518911f, 
    -0.02297866f, -0.19617036f, 0.08322982f, -0.16755997f, 0.07244854f, 0.08396930f, -0.07350325f, 0.06794527f, 
    0.21867767f, -0.10159792f, -0.07836578f, -0.09310570f, -0.02120074f, -0.10084004f, -0.09040772f, 0.04659007f, 
    -0.11330818f, 0.00348302f, -0.16654114f, -0.12925386f, -0.16628039f, 0.09252766f, 0.06435836f, -0.00836940f, 
    0.03022449f, -0.03184137f, -0.05585454f, 0.18228181f, -0.15897134f, -0.02791722f, 0.04087837f, 0.05265958f, 
    0.02958749f, -0.04000475f, 0.03162408f, -0.02072286f, 0.10978354f, -0.08449268f, -0.16771272f, 0.15855314f, 
    -0.01529933f, 0.07480902f, -0.26537842f, -0.08014288f, -0.04888465f, 0.04157232f, 0.22539283f, 0.10368194f, 
    -0.05998698f, 0.07086064f, 0.04048577f, 0.01434727f, 0.10387019f, 0.09045397f, 0.03326434f, -0.02896016f, 
    -0.08489183f, -0.09043096f, -0.12191858f, -0.09624884f, 0.18769950f, 0.10193477f, -0.02489313f, 0.14199367f, 
    -0.16989726f, 0.11818863f, 0.20322792f, -0.10259458f, 0.17673630f, 0.01618855f, 0.10215156f, 0.11722285f, 
    -0.07132585f, -0.09090714f, -0.32557470f, -0.23678879f, -0.04875324f, -0.05214654f, -0.00031559f, -0.13205560f, 
    -0.06125642f, -0.37400740f, -0.12136648f, -0.00399279f, -0.03408942f, -0.00175693f, 0.00346673f, -0.06003675f, 
    -0.01943395f, -0.00898681f, 0.00013902f, 0.16089809f, 0.09300442f, -0.06546939f, -0.07377820f, 0.03496953f, 
    0.26882181f, 0.05170318f, 0.05959534f, -0.11456634f, -0.05264613f, 0.10824107f, -0.06252716f, -0.04883876f, 
    -0.05082519f, -0.04067598f, -0.05360242f, -0.05698380f, -0.01407686f, 0.03791029f, 0.06768988f, -0.05829309f, 
    0.10862892f, -0.06886861f, -0.13155013f, 0.05588419f, 0.05283265f, -0.08319099f, -0.23462029f, 0.15723966f, 
    0.14667425f, 0.09809337f, 0.08098265f, 0.13019925f, 0.12426935f, -0.13732825f, -0.00526621f, 0.02814496f, 
    -0.06294647f, 0.10116687f, -0.09245760f, 0.08546241f, -0.16210437f, 0.07995524f, 0.03231415f, -0.07506771f, 
    0.04403407f, 0.15452543f, 0.03754179f, -0.02790031f, -0.09410297f, -0.02148787f, -0.01918854f, -0.02462116f, 
    0.02130489f, -0.26688677f, -0.02853591f, 0.10705110f, -0.02752914f, -0.05389499f, -0.18630025f, -0.00406045f, 
    -0.02905959f, -0.18439130f, -0.09490544f, -0.06537045f, 0.03347114f, -0.09023985f, 0.02254357f, -0.07246375f, 
    -0.05133936f, -0.09354004f, -0.10956593f, -0.24712811f, 0.11950193f, 0.23885447f, 0.15268378f, 0.08098017f, 
    -0.07651695f, 0.00295270f, -0.07140261f, -0.09099210f, 0.10409269f, -0.09646484f, 0.04773087f, -0.20331644f, 
    -0.02484020f, -0.03452777f, 0.11601464f, 0.11681587f, 0.03804577f, -0.10065461f, 0.02252268f, -0.27350125f, 
    0.10593200f, 0.03129945f, 0.08108939f, -0.02189024f, 0.02253311f, -0.02882490f, 0.16735438f, 0.16441531f, 
    0.20443544f, 0.16097581f, 0.17485842f, -0.02811155f, 0.23146646f, 0.00710743f, -0.04548504f, -0.16236581f, 
    0.11239266f, -0.02401196f, 0.18658757f, -0.02944613f, 0.20489205f, 0.05723325f, 0.04845060f, -0.20148018f, 
    -0.07753757f, 0.11142905f, 0.25499386f, 0.04486877f, 0.00241119f, 0.15149942f, 0.05803863f, 0.09328520f, 
    0.19889547f, 0.20495363f, -0.43149132f, -0.06909438f, -0.04195917f, -0.04213859f, 0.03050125f, 0.02441943f, 
    0.07975689f, -0.02915990f, -0.14026110f, 0.20113476f, 0.17539170f, -0.04379420f, -0.06652051f, 0.06497091f, 
    0.02116370f, 0.03037486f, 0.04983271f, 0.13014282f, 0.08436473f, -0.16990872f, 0.06949830f, 0.07092357f, 
    0.08594920f, 0.09339743f, -0.05322826f, -0.09487507f, 0.14142326f, -0.01206367f, 0.13210554f, 0.21051195f, 
    0.09613093f, 0.07338462f, 0.21354541f, -0.06936750f, 0.19650061f, -0.14672586f, -0.16526003f, 0.19526637f, 
    -0.01381403f, -0.00225307f, -0.02771962f, 0.08019176f, 0.14956203f, -0.05599636f, -0.05793394f, 0.04956567f, 
    0.06472253f, 0.19899614f, 0.09081205f, 0.09404899f, -0.03716655f, -0.00109299f, 0.08813032f, 0.03997064f, 
    0.25141561f, -0.16202950f, 0.04081678f, -0.13735273f, 0.03680255f, 0.11819101f, -0.06380879f, -0.05331283f, 
    0.22731875f, -0.05268880f, 0.18666852f, -0.01490271f, 0.02332643f, 0.03569413f, -0.10573363f, 0.10442638f, 
    -0.03299757f, 0.11126281f, -0.16395962f, -0.29587293f, 0.00398738f, -0.07618365f, 0.02955808f, -0.07634836f, 
    -0.10217287f, -0.05850389f, -0.35196343f, 0.05859508f, -0.10196555f, -0.08210154f, -0.10128354f, -0.18171732f, 
    0.04191512f, -0.11306700f, -0.11471200f, 0.32122526f, -0.15915266f, -0.02708636f, -0.02830424f, -0.10348610f, 
    -0.02964858f, 0.04521038f, -0.05293372f, 0.04070464f, -0.22812253f, 0.24671088f, 0.13766465f, 0.04964522f, 
    0.03835386f, 0.19049945f, -0.13416137f, 0.01325653f, -0.12240905f, 0.06847545f, 0.02672456f, -0.07428151f, 
    -0.03227793f, -0.07017979f, -0.08355922f, -0.08525953f, 0.00079113f, 0.17520647f, 0.00617474f, 0.04400786f, 
    0.00807726f, 0.23591313f, -0.08601218f, 0.12282044f, -0.13529144f, 0.04013430f, 0.07722152f, 0.41228265f, 
    0.27870345f, 0.04220626f, 0.01530872f, 0.15278265f, 0.19410202f, -0.05394636f, 0.04323681f, 0.02983051f, 
    -0.10684750f, 0.12518056f, -0.02700018f, -0.03164716f, 0.05798988f, 0.01040209f, -0.17167902f, -0.02963351f, 
    -0.01435289f, -0.11262623f, -0.01412369f, -0.18799679f, -0.05127072f, -0.00710275f, -0.10722532f, -0.07249833f, 
    -0.09160300f, -0.09372549f, -0.19850232f, 0.18219979f, 0.17749946f, -0.04226390f, -0.10021798f, -0.16083215f, 
    -0.03820812f, 0.09145033f, 0.01974952f, 0.19229400f, 0.14886974f, -0.02592732f, 0.09018533f, 0.15244393f, 
    0.01691009f, 0.04921051f, -0.02453137f, 0.00319135f, 0.16750105f, -0.06796814f, -0.05643485f, -0.11453611f, 
    0.09397156f, 0.10329264f, 0.06853972f, 0.19136803f, -0.00137144f, 0.11530683f, -0.04450396f, 0.00257845f, 
    0.05493779f, 0.04640130f, 0.05958432f, -0.14804564f, 0.17853020f, -0.12533571f, 0.09955644f, 0.05180506f, 
    -0.14097914f, -0.06730694f, 0.04528917f, 0.00325249f, 0.04899460f, 0.08082349f, 0.05625025f, 0.16934143f, 
    -0.09520372f, 0.07989289f, -0.06185482f, 0.00421596f, -0.01696208f, 0.18908508f, -0.08791730f, 0.10154558f, 
    0.19717614f, -0.18074198f, -0.07310163f, -0.11677191f, 0.03788947f, 0.12567635f, 0.06634318f, -0.13076030f, 
    -0.00493074f, 0.12022089f, 0.08889605f, -0.13722272f, -0.02560787f, -0.22659959f, -0.08226298f, 0.04567579f, 
    0.02194995f, 0.07880405f, -0.27620953f, 0.11597136f, -0.06788454f, 0.05495898f, 0.01258834f, 0.03443367f, 
    0.17878485f, 0.07747278f, -0.00226152f, 0.08605785f, -0.08559922f, -0.06205102f, 0.11583465f, 0.08380044f, 
    0.07179771f, 0.05683590f, -0.04869325f, 0.07126313f, -0.27491602f, 0.14575197f, 0.28082785f, -0.27630487f, 
    0.03875653f, -0.01519500f, 0.02515486f, -0.00223426f, 0.03503769f, -0.00858738f, 0.15189813f, 0.11023498f, 
    -0.08448301f, 0.11494835f, 0.00403747f, 0.03878969f, -0.02493582f, 0.11123431f, -0.08568092f, -0.27139032f, 
    -0.10025368f, -0.09157395f, -0.02837927f, -0.03562921f, -0.06642349f, 0.00934704f, 0.07153533f, 0.08729361f, 
    0.05047030f, -0.19036309f, -0.06723557f, -0.05806947f, 0.03245238f, 0.17179884f, 0.00876819f, -0.18159799f, 
    -0.04340736f, -0.02869286f, -0.06161395f, 0.02341423f, 0.03026979f, -0.00590738f, 0.04325151f, 0.04130220f, 
    -0.00635431f, 0.04430296f, 0.01630044f, 0.02670384f, -0.05833451f, 0.01868972f, -0.00425329f, -0.05609500f, 
    0.01993006f, 0.02873221f, -0.00395898f, -0.02335478f, 0.00478523f, -0.04142147f, 0.04032448f, -0.02139484f, 
    0.02867149f, 0.02748139f, -0.01380317f, 0.00842183f, -0.05785348f, 0.01029934f, -0.04001228f, -0.06072283f, 
    0.02528253f, 0.02550851f, 0.02555079f, 0.04339042f, -0.02795059f, -0.06439058f, 0.02494299f, -0.04171214f, 
    -0.00875860f, -0.00280696f, -0.01058521f, -0.03124286f, 0.03282135f, -0.03909091f, -0.02664768f, -0.02541996f, 
    -0.02882877f, 0.00316436f, -0.03110797f, 0.01466401f, -0.02549776f, -0.01842225f, -0.05238375f, -0.03891776f, 
    -0.01753718f, -0.00700695f, -0.02262164f, 0.00804991f, -0.01861912f, -0.02019133f, -0.01100323f, 0.01962885f, 
    -0.00726486f, -0.05018234f, -0.02923559f, 0.02567646f, 0.04269710f, -0.01745797f, -0.00431364f, 0.04269807f, 
    -0.04762802f, -0.05907161f, -0.02141459f, -0.02554981f, -0.03625547f, -0.03021037f, -0.04921068f, -0.00050637f, 
    -0.06124001f, -0.04038706f, 0.04947213f, 0.02459212f, -0.04447465f, -0.00052037f, -0.01905950f, -0.02814843f, 
    0.00494872f, 0.00797806f, -0.04495068f, 0.05058680f, -0.06302869f, -0.00251518f, -0.03212189f, 0.04186087f, 
    -0.06468676f, -0.03671063f, 0.03000955f, 0.04105498f, -0.02857837f, 0.03913964f, 0.04611631f, -0.02949882f, 
    -0.03466146f, 0.04728018f, 0.03870939f, 0.01449552f, 0.00604535f, 0.04036651f, -0.00317299f, 0.03456591f, 
    -0.02608467f, -0.02295896f, -0.06488504f, -0.02449049f, 0.02676309f, -0.01458059f, -0.04037505f, -0.00568217f, 
    -0.00608414f, 0.05106767f, -0.01684738f, -0.03651669f, -0.05921402f, 0.03146861f, 0.01389845f, 0.03217172f, 
    -0.03888750f, 0.04715734f, -0.03879263f, 0.01454429f, -0.02228016f, 0.01533663f, 0.01350221f, 0.00390863f, 
    -0.03047348f, 0.00747798f, -0.03467304f, 0.02716365f, -0.02593739f, 0.04957801f, -0.03450827f, 0.01056022f, 
    -0.01238265f, 0.02220641f, 0.00346650f, 0.02883757f, -0.04035186f, 0.04642492f, 0.05133990f, -0.00231516f, 
    -0.00765468f, -0.03257746f, -0.02596021f, -0.01661678f, -0.00790621f, -0.01234507f, 0.02690187f, 0.03621206f, 
    0.01948278f, -0.05040850f, -0.04835834f, 0.00258827f, 0.00483611f, 0.01325393f, 0.00931726f, -0.01391087f, 
    -0.04328260f, -0.05699872f, -0.04892685f, 0.00922058f, 0.03959467f, -0.03450459f, -0.04059647f, 0.00973767f, 
    0.03220515f, 0.00694243f, 0.01919683f, -0.00233250f, -0.01172061f, 0.01636032f, 0.01494690f, -0.06138379f, 
    0.00345962f, -0.01261206f, -0.01580109f, -0.04830904f, -0.00984501f, -0.00875361f, 0.05272322f, -0.03493049f, 
    0.04443068f, -0.00492310f, 0.03751617f, -0.06282812f, -0.03823953f, 0.02452992f, -0.01201965f, -0.04626150f, 
    0.00489539f, 0.04290406f, 0.00257866f, -0.01322295f, 0.03356089f, 0.05046700f, -0.04419033f, -0.01517026f, 
    -0.05378737f, -0.04168775f, -0.01700745f, 0.01801779f, -0.01022661f, -0.02567968f, -0.06267617f, -0.05412533f, 
    -0.00664144f, 0.02712800f, 0.00871698f, -0.04174999f, 0.02919357f, -0.06139765f, -0.01138247f, -0.02035653f, 
    -0.03115521f, -0.02337228f, -0.06459781f, 0.04853730f, 0.00010052f, -0.02415374f, -0.03911197f, 0.04734154f, 
    -0.04413091f, 0.01431338f, 0.01245407f, 0.01686528f, -0.02867360f, -0.00056780f, -0.04573835f, 0.00758747f, 
    -0.04703733f, -0.00391939f, -0.00839498f, 0.03783175f, -0.02086293f, -0.02812647f, -0.00161895f, -0.01071239f, 
    -0.04769287f, -0.03671668f, -0.00878181f, -0.06286732f, -0.05721265f, -0.01818850f, 0.02699334f, -0.00872784f, 
    -0.00769164f, -0.03113352f, -0.00765290f, 0.00662220f, 0.00586338f, 0.04032216f, -0.01405700f, 0.01965175f, 
    0.02775329f, -0.04192096f, 0.06163195f, 0.01142653f, 0.00887831f, 0.03995821f, -0.00961988f, -0.06275170f, 
    0.02290576f, -0.04235046f, -0.03602404f, -0.00506327f, -0.02136434f, -0.00965281f, -0.02988585f, 0.01582892f, 
    -0.03710812f, -0.01408597f, 0.04492936f, -0.03032696f, 0.02480592f, -0.05906758f, 0.02296718f, -0.00895996f, 
    -0.07285129f, -0.01203377f, 0.27805775f, -0.10380665f, -0.06282072f, 0.00514291f, -0.04310004f, -0.03998843f, 
    0.15003447f, -0.06564962f, 0.15154459f, 0.10368325f, -0.12005449f, 0.02184831f, 0.03205563f, -0.03208471f, 
    -0.04894228f, 0.02292624f, -0.06660073f, 0.00029647f, -0.26353878f, 0.11868625f, -0.21077868f, -0.03460708f, 
    -0.00124056f, -0.05418027f, 0.06190392f, 0.13561183f, 0.04053096f, -0.06527564f, 0.05868860f, -0.02042034f, 
    -0.04998894f, 0.14482348f, -0.01725782f, 0.12990707f, -0.25829133f, -0.00335087f, 0.25978857f, 0.04879142f, 
    0.01609037f, 0.02721938f, -0.10277023f, 0.06167744f, -0.04551591f, -0.44605875f, -0.17069063f, -0.24724808f, 
    0.10483936f, 0.14326458f, 0.03213296f, -0.04659674f, -0.02132783f, 0.02294327f, 0.01052005f, -0.13023975f, 
    -0.21009713f, 0.05399067f, -0.11147587f, 0.05584366f, 0.02534313f, -0.02643334f, 0.15914708f, 0.06613342f, 
    -0.01531017f, -0.07900503f, 0.02359032f, -0.00844299f, 0.06374800f, 0.05150506f, 0.06323028f, 0.05025117f, 
    -0.11081819f, 0.00458290f, -0.32661974f, 0.13912092f, 0.04951194f, -0.04700541f, 0.05287442f, -0.12639913f, 
    0.11919495f, -0.00270970f, 0.07946486f, -0.35682926f, 0.21013527f, -0.08868654f, 0.18827209f, -0.12246219f, 
    -0.08853590f, 0.03168309f, -0.07653421f, 0.03142109f, 0.05710984f, 0.07613184f, -0.03299947f, 0.01146898f, 
    -0.02621293f, 0.07623151f, -0.21032949f, -0.24511354f, 0.01436615f, 0.15110998f, -0.11528049f, 0.09842831f, 
    -0.02088183f, -0.13283882f, 0.08081696f, 0.09567773f, -0.15990773f, -0.07095822f, 0.11293572f, -0.12899277f, 
    -0.14124084f, 0.13317643f, -0.07465561f, 0.03002755f, 0.20067813f, 0.09282611f, 0.24383615f, -0.13961747f, 
    0.13740569f, 0.08092544f, -0.17061289f, 0.17957167f, -0.01143021f, -0.16457206f, 0.06747821f, -0.14257245f, 
    -0.23615079f, -0.09728523f, 0.08605599f, 0.02390548f, 0.02741528f, 0.03842673f, 0.03274713f, 0.19224276f, 
    -0.05984740f, -0.13904849f, -0.00876748f, -0.08506623f, 0.05777232f, 0.02068337f, -0.09726036f, 0.15545548f, 
    0.10060788f, 0.05520258f, -0.15428343f, 0.18978564f, 0.19602039f, 0.01456789f, 0.18323077f, -0.19465931f, 
    -0.19386396f, 0.08533249f, 0.09126380f, 0.09800381f, -0.02564511f, 0.22618236f, -0.02002081f, -0.06087010f, 
    0.09118398f, 0.14856765f, 0.26245892f, 0.03715331f, -0.37161073f, 0.11927300f, 0.03758201f, -0.09103075f, 
    -0.04288746f, 0.07309142f, -0.06390594f, 0.09142099f, -0.11385222f, -0.28795135f, 0.02704937f, -0.13197710f, 
    -0.06705495f, 0.05719744f, 0.01428556f, 0.07188766f, 0.18970110f, 0.05393701f, 0.12627304f, 0.08700983f, 
    0.10203775f, -0.05816600f, 0.04211345f, 0.02227371f, 0.02519516f, 0.14566100f, 0.01765439f, -0.18064292f, 
    -0.00658244f, -0.05430419f, -0.01782938f, 0.03474303f, -0.04536060f, -0.03762396f, -0.08376494f, -0.13752919f, 
    -0.26651001f, 0.00947779f, 0.04962604f, 0.00295290f, -0.04256106f, -0.06351237f, -0.05798824f, -0.18411222f, 
    0.03022863f, -0.08117791f, 0.20629960f, 0.01130689f, -0.09195334f, 0.00243041f, 0.05795034f, 0.13482951f, 
    0.08999036f, 0.00903703f, -0.16553438f, -0.07852579f, 0.06787028f, 0.01196086f, 0.04560349f, -0.05964980f, 
    0.09880885f, 0.16200384f, 0.02989911f, -0.19734719f, 0.08536205f, 0.01577320f, 0.12009347f, 0.04775575f, 
    -0.17190029f, -0.00224766f, 0.14754024f, 0.02988538f, -0.06174615f, -0.13135915f, -0.00716291f, 0.11933192f, 
    0.01884339f, 0.09849196f, -0.08408948f, 0.07574780f, -0.22363937f, 0.14164001f, 0.09967756f, 0.11693911f, 
    0.03248060f, -0.02176553f, -0.00056343f, 0.13151301f, 0.05845485f, 0.24512342f, -0.15115088f, 0.13838290f, 
    -0.03067417f, -0.07672227f, -0.20674989f, -0.01941285f, 0.08845883f, 0.07656761f, -0.01731782f, 0.20056485f, 
    -0.02428882f, -0.03963042f, 0.01263250f, -0.05466421f, -0.05465319f, 0.12501806f, 0.10219786f, 0.00067114f, 
    0.04186826f, 0.20117618f, 0.06764056f, -0.07718472f, -0.04440365f, 0.00183231f, 0.11501300f, 0.21174617f, 
    -0.14844206f, 0.14313054f, -0.02036054f, -0.03502382f, -0.03359336f, 0.07364836f, 0.01610568f, -0.09571297f, 
    -0.24169953f, -0.12246531f, 0.17656840f, 0.03924237f, 0.07628971f, 0.07570221f, -0.13896918f, -0.08069417f, 
    -0.05524667f, -0.06728692f, -0.35093591f, 0.05065424f, -0.00600873f, 0.00318044f, -0.03167997f, -0.05078131f, 
    0.04369883f, -0.02721228f, -0.06602851f, 0.05238226f, -0.23391302f, -0.00856028f, -0.01600447f, -0.11804965f, 
    -0.05969765f, 0.00713310f, -0.02675650f, -0.05139984f, 0.15220514f, 0.05007322f, -0.06714994f, 0.11343643f, 
    0.06862226f, 0.05345020f, -0.00181029f, 0.01834942f, -0.38228187f, -0.06309487f, 0.32006174f, 0.04122823f, 
    0.09350037f, -0.06132348f, -0.04094848f, 0.04715633f, 0.05761450f, -0.30811512f, 0.09923912f, 0.08783049f, 
    0.07133067f, -0.03384509f, 0.11628290f, -0.07882141f, 0.09841375f, -0.02099197f, -0.52984834f, -0.00816916f, 
    -0.03731605f, 0.03718030f, -0.02409955f, -0.05136112f, -0.05990690f, -0.02674170f, 0.00481872f, 0.08409059f, 
    -0.04540089f, 0.00755591f, -0.09843989f, 0.02240002f, -0.04844668f, 0.17312232f, -0.00953187f, 0.00021791f, 
    -0.26830539f, 0.02775896f, -0.23617797f, 0.08738840f, 0.05603507f, -0.04081734f, -0.01193344f, -0.00093217f, 
    -0.02705587f, -0.21845962f, 0.01437885f, -0.04012051f, -0.06383682f, -0.06488118f, -0.03377023f, 0.01939516f, 
    0.04660742f, 0.16010702f, 0.07890799f, 0.07880476f, -0.06408956f, -0.00650285f, -0.02900442f, -0.05286267f, 
    0.08345016f, 0.04400486f, -0.05835330f, 0.01295333f, -0.06937367f, 0.05531175f, -0.00794417f, 0.11021752f, 
    -0.16386543f, 0.04554795f, -0.02049161f, -0.00578881f, -0.36861438f, -0.12140331f, 0.10196882f, 0.13441122f, 
    -0.04040018f, -0.09592965f, 0.07078972f, 0.10656563f, -0.02677944f, -0.13464727f, 0.06085195f, -0.37720639f, 
    0.09636733f, 0.04307659f, -0.00031311f, 0.08343214f, 0.10133544f, -0.01217088f, -0.39323553f, -0.01857527f, 
    -0.02280397f, 0.05320963f, 0.01814301f, -0.03469173f, 0.14273141f, 0.10656461f, 0.09546991f, 0.11390268f, 
    -0.03295138f, -0.11716895f, 0.02572040f, -0.04798204f, 0.03653381f, 0.03817532f, -0.02052474f, -0.05828450f, 
    -0.23208004f, 0.17930564f, -0.09089778f, 0.12823391f, -0.02039880f, 0.01959982f, -0.05329097f, 0.06107592f, 
    -0.08821032f, -0.02961013f, -0.02524651f, 0.15454574f, 0.04519514f, 0.06305484f, 0.05314031f, 0.02939744f, 
    0.00259701f, 0.00101064f, 0.02387999f, 0.16121455f, -0.10918885f, -0.02754506f, -0.03279523f, -0.05612165f, 
    0.04431783f, 0.03117948f, -0.03595134f, -0.21708286f, 0.06569093f, -0.28157583f, 0.08472434f, -0.00243581f, 
    -0.03643738f, 0.08689270f, -0.02601472f, 0.11404314f, 0.01274986f, -0.04843643f, 0.05805384f, -0.02616067f, 
    -0.01897154f, 0.14935187f, 0.02724434f, -0.13579524f, 0.05168533f, 0.13637625f, -0.15568615f, -0.07589725f, 
    -0.05209077f, -0.10588896f, -0.02176503f, 0.13600525f, -0.01120162f, 0.14424965f, -0.11007757f, -0.14385116f, 
    0.00643494f, 0.03220935f, -0.02781542f, -0.13879171f, -0.11138903f, 0.02231547f, 0.03993109f, 0.07125759f, 
    0.00500511f, -0.10484572f, 0.18268359f, 0.11042751f, 0.05208253f, -0.04572697f, -0.03915204f, 0.20190413f, 
    -0.07247301f, 0.03808795f, -0.22536838f, 0.00019024f, 0.09579324f, 0.10635661f, -0.05373991f, -0.07630650f, 
    0.18108267f, 0.31062600f, -0.10492463f, -0.15787482f, 0.00511793f, 0.03060407f, 0.01754169f, -0.04896373f, 
    0.00759882f, 0.13754518f, 0.29224500f, 0.15634115f, 0.14077096f, 0.04377894f, -0.13102700f, 0.02757229f, 
    0.08861172f, 0.00210774f, -0.06160314f, 0.09206086f, 0.06851513f, 0.12665133f, 0.06033703f, -0.07509944f, 
    -0.03389364f, 0.05552797f, 0.03425156f, -0.05525877f, 0.04638941f, 0.30141225f, -0.11955116f, -0.19075701f, 
    -0.04900280f, -0.11468537f, -0.16072904f, -0.01377210f, 0.05968626f, 0.11926375f, -0.06295503f, 0.03818451f, 
    -0.15810950f, -0.10180674f, 0.01741000f, -0.00739564f, 0.06575519f, 0.02019625f, -0.20797744f, 0.17638904f, 
    0.15547872f, 0.12422577f, 0.02793966f, 0.00318996f, 0.06169912f, 0.12842695f, 0.07802425f, 0.19859271f, 
    -0.04710008f, 0.08222758f, -0.07565139f, -0.17411073f, -0.01765479f, -0.04026099f, 0.03446446f, 0.05395472f, 
    -0.07347485f, -0.06451601f, -0.55036432f, 0.07019327f, 0.11678511f, 0.09453691f, 0.05852273f, 0.00888983f, 
    -0.21851419f, -0.39875403f, -0.10920854f, -0.03272593f, 0.15694372f, 0.04408879f, 0.09043870f, -0.10886009f, 
    0.04266590f, -0.12996006f, 0.05283017f, -0.08942275f, 0.18110533f, -0.04887937f, 0.13938378f, -0.00215823f, 
    -0.02624740f, -0.01932517f, -0.04101976f, 0.11737111f, 0.11589706f, 0.16165124f, -0.05804909f, -0.04405946f, 
    0.22238579f, 0.16109383f, 0.01214302f, -0.00277152f, -0.29609537f, 0.08301064f, -0.38846847f, 0.06596457f, 
    0.16507317f, 0.02244510f, 0.00533988f, 0.04056158f, -0.13000491f, -0.17419969f, 0.00048123f, 0.13837732f, 
    -0.02521391f, -0.04953609f, -0.00859487f, -0.02651954f, 0.03471364f, -0.06432462f, -0.12907395f, -0.29977384f, 
    0.03480444f, -0.13917074f, -0.09858445f, 0.01980323f, 0.13186440f, -0.05191844f, 0.04571955f, 0.19105111f, 
    -0.04568055f, 0.02924759f, -0.09274837f, -0.00738331f, 0.08555530f, 0.06594236f, 0.09797675f, 0.00950383f, 
    0.22214760f, 0.00863725f, 0.00662835f, 0.01176346f, 0.07508575f, 0.08893447f, 0.05952039f, -0.18943778f, 
    0.05989053f, -0.06801939f, -0.06312070f, 0.09118716f, -0.01932038f, 0.07287121f, 0.06612944f, 0.00820831f, 
    0.08674130f, 0.06931821f, 0.28321388f, 0.27348521f, 0.09221801f, 0.01164831f, -0.10306055f, -0.25560287f, 
    0.04275328f, -0.01980078f, 0.09042718f, 0.06948072f, 0.00130161f, -0.01747465f, -0.01733132f, 0.23065008f, 
    -0.10663412f, 0.01093434f, 0.02607591f, 0.08704996f, 0.09936680f, -0.23071229f, -0.15442440f, 0.19209446f, 
    0.23757590f, 0.01521082f, -0.02665728f, -0.05974321f, -0.07782617f, 0.21424383f, 0.20586550f, -0.21380910f, 
    -0.06607753f, 0.11229792f, 0.08427487f, -0.05816247f, 0.08183759f, 0.12587067f, -0.07466033f, 0.02662585f, 
    -0.01380071f, -0.10450760f, 0.16100729f, -0.14028743f, -0.00516899f, 0.06464352f, 0.07651687f, 0.08424345f, 
    -0.05264694f, -0.17788382f, -0.01393476f, 0.02689634f, 0.04996926f, -0.08132813f, 0.09001298f, 0.14984815f, 
    0.37995902f, 0.41951555f, -0.00575530f, -0.14173219f, -0.17231642f, 0.14116946f, 0.11457640f, -0.09776762f, 
    0.03797082f, -0.16309839f, -0.09088904f, -0.07966377f, 0.09037396f, 0.19053292f, 0.00101883f, 0.02410051f, 
    0.05700755f, -0.01883494f, 0.20033222f, 0.03110790f, 0.00720182f, -0.10607352f, -0.15384352f, 0.03819527f, 
    0.13969880f, -0.08868604f, 0.09906122f, 0.01069263f, -0.10180715f, 0.27695164f, 0.02145725f, -0.04306433f, 
    -0.06099910f, 0.05551286f, -0.10914075f, -0.11843489f, -0.04332371f, -0.23999208f, 0.02731828f, -0.03100685f, 
    0.00423908f, -0.14604780f, 0.12662733f, 0.05849194f, -0.17145358f, 0.01813620f, 0.14643469f, 0.10352064f, 
    -0.03304253f, 0.08067188f, 0.07030842f, -0.04340683f, 0.05045794f, 0.07983840f, -0.03229774f, 0.15434450f, 
    0.02578646f, 0.02214441f, -0.02754849f, -0.00063166f, 0.01352782f, 0.01147664f, 0.07371749f, 0.03454207f, 
    0.08352236f, -0.13244480f, -0.03993084f, -0.03167246f, 0.20510265f, -0.02719754f, 0.05737220f, 0.06014633f, 
    0.07748047f, -0.09207667f, -0.04259173f, 0.04571981f, 0.07196424f, 0.04874280f, 0.02861317f, 0.03283292f, 
    0.09872328f, 0.17353161f, -0.11567422f, -0.01837188f, 0.01234221f, -0.09578485f, 0.04046184f, 0.03260072f, 
    -0.11816891f, -0.05522026f, 0.19686738f, 0.23944443f, 0.19049057f, 0.14968820f, 0.10638919f, -0.04708265f, 
    -0.03299349f, 0.08450621f, -0.10703479f, -0.08474118f, -0.10325378f, 0.26636818f, 0.19550943f, 0.18041213f, 
    -0.02469398f, -0.00145424f, -0.29142737f, -0.11982897f, 0.00239362f, 0.12655094f, 0.13614136f, 0.05697096f, 
    0.00691241f, -0.07998684f, 0.04402309f, -0.02488608f, 0.04233836f, -0.11897334f, -0.34056780f, -0.05167792f, 
    0.11367954f, 0.16999389f, 0.18539177f, -0.07662319f, -0.17155939f, -0.04249362f, 0.20669524f, 0.24283503f, 
    0.21099445f, 0.07763433f, 0.00829385f, 0.05550957f, 0.07842318f, 0.03084036f, 0.04550176f, 0.02800374f, 
    0.01238560f, 0.03791592f, -0.02031470f, 0.09876699f, 0.09237009f, 0.11204624f, 0.02383910f, 0.06400097f, 
    0.27709177f, 0.25098655f, 0.13334039f, -0.00142092f, -0.02807152f, 0.02069980f, 0.02404105f, 0.05736749f, 
    0.12458046f, -0.06269547f, 0.07487334f, 0.10974735f, -0.08398119f, 0.09066623f, -0.00352008f, 0.00208206f, 
    0.09336402f, 0.13096325f, 0.09759988f, 0.01044870f, -0.06207315f, 0.01720385f, 0.11597854f, -0.02599750f, 
    0.04450893f, 0.05143844f, -0.03740063f, -0.24491705f, -0.12770647f, 0.05733949f, 0.05522271f, 0.04778121f, 
    -0.04609869f, -0.02432869f, -0.00047414f, 0.10922140f, 0.06220654f, 0.17341785f, 0.17463246f, -0.00277984f, 
    -0.09238877f, 0.08730835f, -0.01029740f, 0.07426275f, -0.02733242f, 0.22218147f, -0.10633633f, 0.02970328f, 
    0.05284194f, 0.02251768f, 0.13822673f, -0.02318658f, 0.04841033f, 0.02115963f, 0.04885346f, 0.00196402f, 
    0.01145761f, 0.12073127f, -0.13960859f, 0.02661724f, -0.09529600f, 0.00893897f, -0.05609581f, 0.00204039f, 
    -0.04646377f, -0.09847926f, -0.11583778f, 0.05661494f, -0.09453085f, -0.08446033f, -0.01279406f, 0.09807658f, 
    -0.10325231f, -0.01372182f, 0.04050982f, 0.04238952f, -0.06979058f, -0.06464811f, -0.09414716f, 0.03321746f, 
    -0.08966485f, -0.27201208f, -0.18653268f, -0.17750272f, 0.07424971f, -0.06877985f, -0.13670579f, 0.02397013f, 
    0.00840076f, 0.05198755f, -0.19587184f, -0.22258602f, -0.12004038f, -0.01347928f, -0.04657372f, -0.13071433f, 
    0.04333980f, -0.11787343f, -0.02915873f, 0.29058918f, -0.02556017f, -0.04476366f, 0.05246452f, 0.09780424f, 
    -0.12112934f, 0.16497116f, -0.00940737f, -0.01669387f, 0.19349319f, 0.19877282f, 0.07836559f, 0.04742556f, 
    -0.05088399f, 0.18413079f, 0.10236394f, -0.02792165f, -0.22176614f, 0.01723373f, -0.13648134f, 0.01319302f, 
    -0.01603948f, -0.05116813f, 0.07109778f, -0.15100703f, 0.09598653f, 0.03512272f, -0.06415556f, -0.03333231f, 
    -0.06306571f, 0.03541553f, -0.06212220f, 0.03103076f, -0.20720528f, -0.04183876f, -0.10358392f, 0.25569764f, 
    0.20585096f, -0.08260117f, -0.01135776f, -0.17718169f, 0.07817171f, -0.03815989f, 0.05752061f, -0.08871217f, 
    -0.13802393f, -0.17803189f, -0.03747050f, 0.12674986f, 0.01087918f, 0.14532229f, -0.11074062f, 0.05494873f, 
    -0.02232050f, 0.01312327f, -0.06247371f, -0.08921943f, 0.13526802f, 0.01876641f, 0.21354003f, 0.03099682f, 
    0.06701396f, -0.11829176f, -0.12820289f, -0.20470634f, 0.10297131f, 0.13130182f, 0.02610977f, 0.07947196f, 
    -0.16176331f, -0.03387153f, -0.09529524f, -0.23442411f, 0.05746732f, -0.27035311f, -0.03172749f, -0.01728000f, 
    0.02920705f, 0.02107742f, 0.04877917f, 0.10118072f, -0.11339256f, 0.18410930f, -0.00078964f, 0.02445253f, 
    -0.03421875f, -0.03871737f, 0.02762841f, 0.05962149f, 0.04627476f, -0.18041055f, -0.02321720f, 0.02524594f, 
    -0.17114678f, 0.07869073f, -0.04891583f, 0.01475484f, 0.06462812f, -0.03302212f, 0.05029412f, -0.11739321f, 
    -0.16739574f, 0.03727255f, -0.02104108f, -0.09057465f, 0.02199657f, 0.03133148f, 0.14049585f, 0.18475755f, 
    0.09307789f, 0.01638554f, -0.10216627f, -0.12679376f, -0.01579477f, -0.03923914f, 0.05058649f, -0.26847455f, 
    -0.25758079f, -0.11983505f, 0.00652573f, -0.00509253f, 0.00989346f, 0.18891434f, -0.09881616f, -0.04836999f, 
    -0.01382201f, 0.11338703f, -0.03579799f, -0.16237734f, -0.00099266f, -0.03119905f, 0.05594312f, -0.03906955f, 
    0.08354558f, -0.00036107f, 0.01158692f, -0.18827851f, -0.02104601f, -0.01888098f, -0.07114103f, -0.10128759f, 
    0.15616927f, 0.12931114f, 0.07393354f, -0.09271032f, -0.12641513f, 0.15029344f, 0.02617919f, -0.02256124f, 
    -0.05759064f, 0.05947256f, -0.04192274f, 0.14907676f, -0.32409436f, 0.26516420f, 0.01119496f, -0.05168983f, 
    -0.05361646f, -0.14161271f, 0.00967826f, 0.02826113f, -0.22315736f, 0.32792547f, 0.22269189f, 0.15368457f, 
    0.10265521f, 0.09957720f, -0.00104011f, 0.01290848f, 0.10107281f, 0.09554096f, -0.29388005f, -0.17500740f, 
    -0.09555347f, 0.06951897f, -0.02246423f, 0.04692275f, -0.16097225f, -0.00589133f, -0.00454457f, -0.10011870f, 
    -0.10476222f, -0.11479651f, -0.02233581f, 0.06982647f, -0.08975810f, -0.08916108f, 0.01994560f, 0.03080213f, 
    0.23546800f, -0.10637842f, 0.02744620f, -0.18412130f, -0.05758882f, 0.05179096f, 0.00286035f, 0.08505592f, 
    -0.02746733f, 0.05301113f, 0.03411068f, -0.04382249f, 0.00043208f, -0.06850389f, 0.10311100f, -0.03451584f, 
    0.02251525f, -0.11760986f, -0.05882681f, -0.12620497f, 0.09443861f, 0.01664525f, -0.07334220f, -0.11779048f, 
    0.09899969f, 0.04711926f, -0.04863764f, -0.30567047f, -0.01988312f, -0.02984730f, 0.01942556f, 0.01980351f, 
    0.16327861f, -0.05803535f, -0.10657342f, -0.03496734f, 0.06180884f, 0.05034409f, -0.00805191f, -0.04825420f, 
    -0.01332917f, -0.07255977f, -0.00586100f, 0.12343157f, -0.00352810f, 0.01273215f, -0.12188641f, 0.05145515f, 
    0.08184900f, -0.02604239f, 0.06185035f, -0.00251692f, 0.00366214f, -0.04886201f, -0.04948719f, -0.13870071f, 
    0.12132239f, -0.13358131f, -0.05542834f, -0.05238767f, -0.07458084f, -0.03184722f, 0.01054138f, -0.07692482f, 
    -0.16811858f, -0.03710708f, 0.02803644f, 0.05886271f, 0.17034438f, 0.02918730f, -0.00251682f, -0.12318765f, 
    0.39716268f, 0.15940735f, -0.14716554f, 0.09047884f, -0.00846784f, -0.00427970f, -0.05876916f, 0.03698831f, 
    -0.04691646f, -0.31726220f, -0.06891019f, 0.15856501f, -0.11390524f, 0.02103097f, -0.12786599f, -0.03640656f, 
    -0.09548002f, -0.00386802f, -0.11458762f, 0.24911809f, 0.05179065f, 0.11144022f, -0.12840758f, -0.07396581f, 
    -0.02260855f, -0.01479510f, -0.03811193f, 0.16796482f, -0.12423041f, -0.08244563f, 0.06349632f, -0.07641265f, 
    -0.06574778f, -0.19291802f, -0.06018496f, 0.04402610f, 0.14129764f, -0.18663406f, -0.17030719f, -0.01117498f, 
    0.01431564f, -0.14053258f, 0.05962174f, 0.04298947f, -0.03247081f, 0.14794347f, 0.22733186f, -0.01466287f, 
    -0.04031430f, -0.09842330f, -0.00777492f, 0.00172154f, 0.19282030f, -0.00158042f, 0.16262572f, -0.23650259f, 
    0.03487860f, -0.01915538f, 0.09917747f, -0.01498491f, 0.02537098f, -0.09865061f, -0.10072120f, -0.12757106f, 
    -0.15870982f, -0.08910824f, -0.05451384f, 0.04954201f, 0.06904126f, 0.00753918f, 0.09067557f, 0.13868701f, 
    -0.28799057f, 0.17717001f, -0.04988826f, -0.00652641f, 0.06615826f, 0.04981862f, -0.09710208f, -0.08177018f, 
    -0.13927361f, -0.38849360f, 0.13202251f, -0.16772306f, -0.04264432f, 0.19066194f, 0.15518384f, -0.10897788f, 
    -0.09835491f, -0.07382175f, 0.16856244f, 0.03362055f, 0.05817354f, 0.15429498f, 0.09241116f, 0.10388722f, 
    -0.01352275f, 0.12165033f, -0.01178638f, 0.17177717f, -0.19102773f, -0.14162084f, 0.05367120f, -0.07378287f, 
    -0.08832908f, -0.03742908f, -0.00294671f, 0.01589403f, 0.21890758f, -0.12067147f, -0.15904988f, 0.07155535f, 
    0.13635233f, 0.17321634f, -0.00257424f, -0.07707546f, 0.06382075f, -0.02467231f, 0.09349564f, 0.05120693f, 
    0.08050554f, 0.01776217f, 0.03140056f, 0.04389163f, 0.06242247f, -0.04695600f, 0.13433237f, 0.15097551f, 
    -0.06805102f, 0.10187244f, -0.18186863f, -0.00357748f, -0.03671972f, 0.05114392f, 0.16451520f, -0.11068343f, 
    -0.01836791f, -0.07036032f, 0.01325479f, 0.06593844f, 0.10882889f, -0.06522916f, -0.01262939f, 0.04887586f, 
    0.12889928f, 0.04083376f, 0.03260667f, 0.11428238f, 0.06034353f, 0.09834804f, 0.00909606f, -0.02352567f, 
    0.00264183f, 0.34438270f, -0.11814965f, 0.03717491f, -0.04987435f, -0.15009232f, -0.09994132f, -0.00572658f, 
    -0.01392912f, -0.01550946f, -0.22648677f, -0.14781676f, 0.08976588f, 0.06465603f, -0.02279459f, 0.00902367f, 
    -0.08843233f, 0.07660244f, -0.09149981f, -0.26566511f, 0.10039494f, 0.09591854f, 0.07147498f, -0.01180189f, 
    -0.15601410f, -0.03228395f, 0.06322364f, 0.13549146f, 0.27426958f, -0.26530901f, 0.08213985f, 0.07577950f, 
    -0.00526925f, 0.05541440f, -0.02101894f, -0.00690033f, 0.04623094f, 0.34241056f, 0.00956150f, -0.03096422f, 
    -0.15596834f, -0.04005750f, 0.05806550f, -0.01191230f, -0.05249601f, 0.01636723f, 0.13831201f, 0.26311907f, 
    -0.27122355f, 0.16976205f, 0.04824479f, 0.11252794f, -0.08439480f, 0.01375371f, -0.00956910f, -0.18604076f, 
    -0.16866530f, -0.05259952f, 0.02023487f, 0.04964304f, 0.03549886f, 0.01159030f, 0.01995253f, -0.02345573f, 
    0.03982778f, -0.06986074f, -0.05336613f, -0.06560803f, -0.05926844f, -0.04730502f, -0.02643803f, -0.04054919f, 
    0.00079209f, -0.02600056f, -0.00288089f, 0.01282065f, 0.02162655f, -0.02142720f, -0.04760149f, -0.06199700f, 
    0.02342279f, -0.04211979f, -0.02426003f, -0.01248528f, -0.03685364f, -0.00450093f, -0.01366655f, -0.03402328f, 
    0.03753340f, -0.03263317f, -0.04182318f, 0.00479312f, -0.00832536f, 0.01850059f, -0.05058133f, 0.01754180f, 
    -0.06161108f, 0.03065041f, 0.03296559f, -0.02998914f, 0.04319518f, 0.02397014f, -0.04048926f, -0.06740922f, 
    -0.02080199f, 0.00885559f, 0.04274155f, -0.02489399f, -0.03040617f, -0.04749308f, 0.01716637f, 0.03307127f, 
    -0.06652030f, -0.05016469f, 0.02077476f, 0.01312528f, -0.06035348f, -0.03506693f, -0.05488903f, 0.03514571f, 
    0.03781119f, -0.02308129f, 0.02002238f, -0.01848312f, 0.00115820f, -0.02825329f, 0.00064516f, 0.04986120f, 
    0.03764619f, 0.02528016f, -0.03481066f, -0.05747132f, 0.01141089f, -0.04613215f, -0.00902351f, 0.02226489f, 
    0.00621120f, 0.00469264f, -0.07056422f, 0.02592142f, 0.00424976f, 0.01098974f, -0.01338016f, -0.00775602f, 
    -0.06471861f, -0.02187524f, 0.01525336f, -0.00366738f, -0.06380921f, -0.01421109f, 0.01300372f, 0.02656070f, 
    -0.00021349f, 0.03465632f, 0.02872398f, 0.02387042f, -0.06035668f, 0.00947617f, 0.00624226f, 0.03958204f, 
    -0.07165586f, 0.03212355f, 0.01908675f, -0.01493650f, 0.00375505f, -0.03047066f, -0.05967347f, 0.02223583f, 
    0.02074712f, -0.06349988f, -0.05975191f, 0.02029543f, 0.04017454f, 0.04660391f, 0.03418893f, 0.00071468f, 
    0.00956971f, -0.05641855f, 0.03119077f, -0.01463057f, -0.00208235f, 0.03426003f, -0.05826208f, -0.02605639f, 
    0.04410405f, 0.03294879f, 0.03797013f, 0.00460749f, -0.00388359f, -0.02929341f, -0.01459424f, -0.04493007f, 
    0.02332931f, 0.00662394f, 0.01260884f, 0.00381236f, 0.02875436f, 0.04440896f, -0.00894681f, -0.03404678f, 
    -0.05828886f, -0.05277037f, -0.06786813f, -0.02643124f, -0.02700904f, 0.03530460f, -0.00815810f, -0.03152389f, 
    -0.03479438f, 0.01918078f, -0.06804159f, -0.06672084f, -0.04221346f, -0.02312681f, -0.05333000f, 0.04587299f, 
    0.03460234f, -0.03139718f, -0.01070238f, -0.03191674f, -0.02864581f, -0.00342336f, -0.04999182f, -0.06146904f, 
    0.01648933f, -0.06252483f, 0.03931239f, -0.00674519f, -0.01132151f, 0.04188164f, -0.03160907f, -0.00105728f, 
    -0.04606708f, 0.01193847f, 0.00431687f, -0.06378138f, 0.03259793f, -0.01686080f, 0.03866678f, -0.01154040f, 
    -0.01539645f, -0.06507668f, -0.01263114f, -0.00571321f, 0.03082789f, -0.01293563f, -0.01343270f, -0.01481496f, 
    0.00552607f, -0.05306604f, -0.04323113f, -0.01224789f, 0.04429175f, -0.03017631f, 0.01298309f, 0.00433180f, 
    0.02674870f, 0.01092504f, 0.01032791f, -0.05506913f, 0.02870572f, 0.04414978f, -0.06984661f, -0.01436554f, 
    0.03163220f, -0.02250128f, -0.03540326f, -0.04444576f, -0.02258258f, 0.02466963f, 0.00687127f, 0.00447202f, 
    -0.01721918f, -0.03470549f, 0.02635708f, 0.01146177f, -0.04782409f, 0.04930700f, 0.03200279f, -0.04459438f, 
    0.01487476f, 0.04096347f, 0.03655130f, 0.00772234f, -0.05539767f, -0.05081708f, -0.04613162f, -0.06621356f, 
    -0.02924903f, 0.02341020f, 0.04062421f, -0.04493949f, -0.05269021f, 0.03986626f, 0.05107902f, -0.02082275f, 
    0.03648338f, -0.03631073f, -0.04787970f, -0.05133044f, -0.00291584f, 0.02655897f, 0.02515308f, 0.00813700f, 
    0.02223976f, -0.04540679f, -0.00540121f, -0.05722395f, 0.02136051f, -0.05584526f, -0.02299320f, -0.03059068f, 
    -0.05831541f, 0.02318194f, -0.04223404f, 0.04104946f, 0.03053233f, 0.04649661f, 0.01761566f, -0.00943663f, 
    0.02950131f, 0.00835013f, -0.03065570f, 0.04162430f, -0.01880852f, 0.01473136f, -0.01655560f, -0.00698084f, 
    -0.04879071f, 0.02949917f, -0.02113597f, 0.01722535f, 0.00331078f, 0.01919294f, 0.03357398f, 0.03765340f, 
    -0.02881001f, -0.05493028f, -0.01547137f, 0.03724945f, -0.04215967f, 0.03974091f, 0.01762203f, 0.04694886f, 
    -0.00728671f, -0.03945791f, -0.06943422f, -0.05829595f, -0.05500213f, -0.01729270f, -0.05601858f, 0.04413356f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.01292811f, 0.02434559f, 0.00449871f, -0.02214239f, -0.03017149f, 0.00510910f, 0.14697291f, 0.13639994f, 
    -0.05361807f, -0.01495676f, -0.02769782f, -0.03089789f, -0.01180324f, -0.05814568f, 0.00621538f, 0.02926488f, 
    -0.01228216f, 0.13778786f, -0.01579317f, -0.01988430f, 0.05448685f, -0.03000576f, 0.05359359f, 0.06373350f, 
    -0.02393718f, -0.00770005f, 0.11774106f, 0.03699829f, 0.04836076f, 0.02625230f, 0.06998648f, -0.00564044f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03631888f, -0.11994960f, 0.17395779f, -0.24253930f, -0.08306651f, 0.02025211f, 0.04497353f, 0.36858448f, 
    0.02805528f, -0.15309489f, 0.04264824f, -0.02227946f, -0.03728652f, -0.15017553f, -0.15194145f, -0.12946451f, 
    0.02871340f, -0.31594607f, -0.12804511f, 0.49047205f, 0.05888379f, 0.39323038f, 0.17199640f, -0.17033456f, 
    0.27475333f, -0.00453125f, -0.18702894f, 0.31970698f, 0.14756092f, 0.18938126f, -0.37465009f, -0.05665462f, 
    -0.16921332f, 0.17541532f, 0.08291937f, 0.09879414f, 0.04154065f, -0.10386398f, 0.02587639f, 0.71269208f, 
    -0.11647955f, 0.17237215f, -0.11529520f, -0.06992549f, -0.13787325f, 0.01430078f, 0.01448472f, 0.14797510f, 
    0.04770672f, 0.20390064f, -0.07023688f, -0.23485833f, 0.32425752f, 0.03280787f, -0.12191168f, 0.02640290f, 
    -0.18861848f, -0.06620825f, -0.06205995f, -0.46021634f, 0.10614736f, -0.00541939f, 0.23624901f, -0.14314745f, 
    0.11210016f, -0.08727206f, -0.13964202f, 0.09710447f, 0.01350206f, 0.12955226f, -0.17010690f, 0.24097806f, 
    0.17167616f, 0.13079266f, -0.02959939f, -0.08964632f, -0.16821945f, 0.25214615f, 0.00050467f, 0.21137154f, 
    0.00798249f, -0.09854987f, -0.15953931f, 0.14361826f, -0.35444173f, 0.21802074f, -0.03298282f, -0.03218729f, 
    0.32491031f, -0.00068729f, -0.53875536f, -0.47300121f, -0.06769589f, 0.65441126f, 0.08704503f, 0.02564847f, 
    0.02794757f, 0.02937517f, 0.15316480f, 0.03471458f, 0.04447335f, -0.03244157f, 0.30275562f, -0.42387187f, 
    0.01496019f, 0.14846382f, -0.17410912f, -0.13918415f, -0.13131094f, 0.38646737f, -0.07289814f, 0.14633518f, 
    0.05818540f, 0.41147932f, -0.03523374f, 0.05779646f, -0.34568065f, -0.03698562f, 0.00517121f, 0.31693241f, 
    0.24062817f, 0.02163975f, 0.06536933f, -0.06873064f, -0.12254651f, 0.03399764f, -0.34042343f, 0.06968386f, 
    -0.00003531f, -0.11244629f, 0.10483227f, -0.03733078f, -0.16221684f, -0.09874558f, 0.42034769f, 0.17391187f, 
    0.05404478f, 0.05665121f, -0.16697875f, -0.10729741f, 0.14335890f, -0.31243327f, 0.00179252f, -0.16941108f, 
    -0.13472204f, -0.00964247f, -0.08165301f, -0.13142557f, 0.15830083f, -0.26713210f, 0.15485020f, -0.19957040f, 
    -0.14197986f, 0.08653937f, 0.11184397f, 0.23177935f, 0.19094782f, 0.30388907f, 0.39176697f, 0.04200062f, 
    0.02330886f, 0.14801966f, 0.13866508f, 0.36373848f, 0.10931537f, -0.13921188f, -0.17560594f, 0.30698505f, 
    -0.10666704f, -0.16290988f, -0.09785435f, 0.02611629f, -0.11633073f, 0.01601633f, -0.05758380f, -0.06008223f, 
    0.15772022f, -0.06712301f, 0.13462983f, 0.18329845f, 0.33084011f, 0.23717652f, -0.00201540f, 0.02847463f, 
    -0.06660779f, 0.16192189f, 0.34659997f, -0.20672278f, -0.02927109f, -0.69203079f, 0.09217735f, -0.02505497f, 
    -0.06997863f, 0.14353038f, 0.13880067f, 0.16338652f, 0.08009132f, 0.01442630f, -0.08658603f, -0.28118762f, 
    0.08330248f, -0.15078923f, 0.01106922f, -0.00848745f, 0.13971563f, -0.03643823f, 0.12725668f, 0.42490917f, 
    0.06981814f, 0.15514064f, -0.11378392f, -0.55855924f, 0.11211260f, -0.18101586f, 0.13120304f, 0.12264169f, 
    -0.08558068f, 0.09362177f, 0.27096036f, -0.34943950f, 0.15826277f, -0.17167120f, 0.58280903f, -0.13821413f, 
    -0.12441110f, 0.03259782f, -0.02218239f, 0.17169534f, 0.13457659f, 0.09615279f, -0.00754779f, 0.08421443f, 
    0.08817809f, -0.13254808f, 0.02666734f, 0.16858171f, 0.12420742f, -0.00794818f, -0.08340107f, 0.21945237f, 
    0.16360751f, 0.41881880f, -0.05527894f, 0.00557206f, 0.24351549f, -0.33064675f, -0.00208737f, 0.10273320f, 
    0.08946909f, -0.01312641f, -0.15671842f, -0.59262824f, -0.01735272f, -0.13329473f, 0.29611474f, 0.04929027f, 
    -0.11914020f, -0.07485239f, -0.10608710f, 0.25778067f, -0.16150129f, -0.03060536f, -0.05948780f, 0.17961615f, 
    -0.14227210f, -0.04240726f, 0.12123632f, 0.05148719f, -0.01319910f, 0.22532943f, 0.07825663f, 0.06975243f, 
    -0.06924850f, 0.29564637f, 0.05021603f, -0.15655413f, -0.10226720f, -0.17732346f, 0.14592403f, 0.13469200f, 
    0.03874769f, 0.04811353f, 0.25618559f, -0.48892829f, -0.01378697f, 0.07138599f, 0.47895622f, 0.14212030f, 
    -0.07028607f, -0.11486259f, 0.02455541f, -0.16258962f, -0.08047673f, 0.06292769f, -0.10995818f, 0.10480094f, 
    0.11234991f, -0.14552301f, 0.00958801f, -0.11570361f, 0.02031331f, -0.16035463f, 0.00987077f, -0.00288332f, 
    0.10505700f, 0.08699614f, 0.03440772f, 0.01898112f, -0.10226380f, -0.00504573f, 0.04086251f, -0.12764627f, 
    0.06749384f, 0.15176319f, 0.00527172f, 0.04270405f, -0.15904616f, -0.10224099f, -0.10468093f, -0.04413542f, 
    0.14296339f, -0.09485200f, -0.04239789f, -0.00209461f, 0.02215310f, -0.15444472f, -0.18681780f, 0.17489949f, 
    -0.01774414f, 0.07920156f, -0.03399213f, -0.09732137f, -0.10935110f, 0.44495955f, 0.17637187f, 0.40140375f, 
    -0.06063195f, 0.12006750f, -0.13666108f, -0.16321792f, -0.02937123f, -0.15871328f, -0.08734605f, 0.27224869f, 
    0.19338928f, 0.04169689f, -0.14582996f, -0.25537381f, -0.01519439f, 0.09550880f, -0.13682522f, -0.11270440f, 
    0.10844602f, 0.12387802f, 0.02022640f, -0.13036446f, -0.10073981f, -0.03039598f, 0.35392338f, 0.29922265f, 
    -0.03215863f, 0.09148818f, -0.04949645f, -0.07962525f, -0.14424047f, -0.42215079f, -0.13254522f, -0.22516584f, 
    0.17254928f, 0.03257025f, -0.18191843f, 0.31087542f, 0.18953107f, 0.03720690f, 0.03515639f, -0.12601049f, 
    0.06781576f, -0.00987682f, -0.22993691f, 0.38313243f, 0.29784283f, 0.04046080f, 0.09076753f, 0.17383142f, 
    0.07383987f, 0.11717075f, -0.13153407f, -0.36464795f, -0.01439456f, 0.06346453f, 0.02683264f, 0.04287952f, 
    0.10858264f, -0.05035042f, 0.12160085f, 0.03591990f, 0.02272115f, -0.44081587f, 0.03841599f, 0.11024123f, 
    -0.02451586f, 0.29626879f, 0.05160537f, 0.33942604f, 0.14734156f, -0.11775574f, -0.01297701f, 0.26033604f, 
    0.07351284f, 0.15305564f, -0.37040070f, -0.00381145f, 0.22723396f, 0.01737556f, -0.20717590f, 0.00940212f, 
    -0.01267217f, 0.14120919f, -0.06532094f, -0.39459324f, 0.05163825f, 0.10183968f, 0.00016243f, 0.54710704f, 
    0.07985778f, -0.16713156f, 0.15928468f, 0.11042114f, -0.09730168f, 0.05305776f, 0.02252273f, -0.13100474f, 
    0.16940211f, -0.24634597f, 0.11924399f, 0.18081149f, 0.05149873f, 0.29072937f, -0.09888715f, 0.29178053f, 
    0.00937252f, -0.15332882f, 0.02176220f, 0.49026075f, 0.21243195f, 0.10273261f, -0.24219102f, -0.11628252f, 
    0.08947675f, -0.05818412f, -0.10001326f, 0.03469553f, 0.10647000f, 0.05523176f, -0.35036692f, 0.37810293f, 
    0.15131578f, -0.04819006f, -0.16202173f, -0.13316210f, -0.09603869f, 0.25156745f, -0.02568046f, 0.18065988f, 
    0.15578513f, 0.24952580f, 0.01011547f, 0.14049110f, 0.23146419f, -0.08165186f, 0.13375896f, -0.12279004f, 
    -0.27664566f, -0.11975966f, 0.10410723f, 0.13543864f, 0.18338768f, -0.14473733f, 0.18111594f, 0.05173361f, 
    0.12477005f, -0.16670579f, -0.05041289f, -0.13590938f, 0.06570346f, 0.08414172f, 0.16408680f, -0.40247193f, 
    0.05047631f, 0.13510720f, -0.09076210f, 0.06893437f, -0.04991283f, -0.23794796f, 0.00619533f, 0.06344592f, 
    0.11557861f, 0.31375635f, 0.10308961f, 0.11069073f, -0.10946313f, -0.23360969f, -0.13941956f, 0.08627477f, 
    0.27076626f, 0.06945246f, -0.20496702f, 0.47073171f, 0.01607543f, 0.44031146f, -0.06240016f, -0.07499266f, 
    -0.06819946f, 0.08611245f, 0.15480544f, 0.03937051f, 0.15628369f, 0.02330179f, 0.01466804f, 0.06998567f, 
    0.05702156f, -0.13552228f, -0.05084941f, -0.09486213f, 0.02114823f, -0.43820205f, -0.14032964f, 0.07692026f, 
    -0.02237747f, 0.10519888f, 0.01280211f, -0.11592639f, -0.08593596f, 0.35037765f, -0.13990600f, -0.03537798f, 
    0.14247373f, -0.06004215f, -0.35305068f, -0.17789172f, 0.03372976f, -0.22740278f, -0.10530485f, 0.04877400f, 
    0.05171205f, 0.16871460f, 0.05534758f, 0.34926602f, 0.06507912f, -0.10182495f, -0.24147519f, 0.22766879f, 
    -0.09220768f, 0.13136268f, 0.03044965f, 0.04826144f, 0.05976882f, 0.00178236f, -0.16504751f, -0.12289096f, 
    -0.13842084f, 0.41219598f, -0.05491057f, 0.10459463f, 0.12222255f, -0.16941035f, 0.01648721f, 0.21297804f, 
    -0.00847090f, 0.06669205f, 0.01768396f, -0.48315659f, -0.01304651f, -0.08239207f, 0.25481245f, -0.17700613f, 
    0.10180771f, -0.12104732f, -0.04179028f, 0.21213910f, 0.07942960f, 0.08905939f, 0.02898729f, 0.00413581f, 
    0.10648263f, 0.02411211f, -0.08026865f, 0.00247335f, 0.10564955f, -0.23992881f, -0.01409440f, -0.39787707f, 
    -0.08404546f, 0.22143807f, 0.06046834f, -0.00966652f, -0.15728623f, -0.40077713f, 0.16284056f, 0.14267440f, 
    0.11172909f, 0.09624527f, 0.26147911f, 0.19348322f, 0.28192350f, -0.51476997f, 0.40588781f, 0.12336165f, 
    0.05155759f, -0.08365954f, -0.13704617f, 0.19885984f, -0.10737614f, -0.17241228f, 0.18963401f, 0.25876501f, 
    0.09225633f, 0.02916571f, -0.10516781f, -0.14879458f, 0.15198068f, -0.37325889f, -0.13369352f, -0.07067781f, 
    0.00875876f, -0.00560084f, -0.14829245f, 0.00560914f, 0.16735898f, 0.41088945f, 0.12341940f, -0.01646655f, 
    0.11138365f, -0.10801272f, 0.19589508f, 0.20236669f, -0.11585149f, -0.10375565f, 0.00176493f, 0.02909198f, 
    -0.10462900f, 0.14156263f, 0.11469416f, -0.17406492f, -0.08696751f, 0.06005220f, 0.05528626f, -0.14219315f, 
    0.14972940f, -0.03645442f, -0.02482369f, -0.14705804f, -0.12115283f, 0.41793677f, 0.03191233f, 0.05823489f, 
    0.00628455f, 0.17493764f, -0.07817280f, 0.11870142f, 0.01232885f, -0.07565260f, -0.04331160f, 0.47210559f, 
    0.20440058f, 0.04061071f, -0.27724895f, -0.20946452f, 0.01641991f, 0.02127216f, -0.20620987f, -0.08069990f, 
    0.16589345f, 0.15878163f, 0.16294903f, 0.08402250f, -0.02126654f, -0.17673364f, 0.11202469f, -0.07965204f, 
    -0.14753692f, 0.00387416f, 0.00861823f, 0.12854779f, 0.02999152f, -0.02457939f, -0.15430941f, -0.08242247f, 
    -0.09378809f, -0.09780224f, 0.16784333f, 0.00743051f, -0.20367953f, -0.05034060f, -0.08228921f, -0.01098735f, 
    -0.10704640f, -0.14126532f, 0.00560274f, 0.11487291f, -0.01246378f, -0.18734010f, -0.10251188f, 0.16488595f, 
    -0.14079821f, 0.03903319f, -0.03521739f, -0.10164407f, 0.08031373f, 0.15866503f, 0.37072796f, 0.01588954f, 
    -0.07389948f, 0.16053426f, 0.04325303f, 0.11309791f, 0.10673881f, -0.50631207f, 0.15350713f, 0.31953356f, 
    0.05893499f, -0.59248197f, 0.15391231f, -0.06937240f, 0.20535736f, 0.01675624f, 0.10953607f, -0.18804936f, 
    0.11869606f, -0.11522550f, 0.22214898f, 0.25969785f, 0.04101497f, -0.18447210f, -0.18613923f, -0.12932684f, 
    -0.12510958f, 0.15702172f, -0.06539720f, -0.49391016f, -0.16320677f, 0.16632673f, -0.55721873f, -0.42527023f, 
    0.18071759f, 0.03538457f, -0.17052679f, -0.10179462f, 0.05032893f, 0.23776315f, -0.04066202f, 0.16242719f, 
    -0.16292155f, 0.13015857f, -0.15859264f, 0.22758211f, -0.08643386f, -0.11428829f, 0.06126879f, -0.11762305f, 
    0.20377930f, -0.04665639f, 0.30146459f, 0.05589117f, 0.09613384f, -0.06561544f, -0.02909456f, 0.11844707f, 
    -0.06283218f, -0.06066733f, -0.03897692f, 0.04530656f, -0.05777848f, 0.02309009f, -0.09164415f, -0.02310823f, 
    -0.05645452f, -0.08156538f, 0.06008408f, -0.12673980f, 0.16284916f, 0.11898637f, 0.17567255f, -0.09313297f, 
    -0.11938348f, -0.05545130f, 0.03947434f, 0.06930453f, -0.07116632f, 0.06744623f, 0.04027287f, -0.15851811f, 
    -0.05244545f, -0.13444813f, -0.14275703f, -0.07143060f, -0.10059150f, 0.00344032f, -0.04161445f, -0.12397150f, 
    -0.13431646f, -0.17139156f, -0.01049729f, 0.17284566f, 0.04728819f, 0.12689622f, 0.03890333f, 0.40012184f, 
    -0.12605369f, -0.13651082f, -0.03160935f, -0.07465440f, 0.16879323f, 0.49482152f, 0.11715913f, 0.31564686f, 
    0.10006887f, 0.09046479f, 0.11757761f, -0.24920790f, -0.04685637f, 0.12265521f, 0.05540131f, 0.27264604f, 
    0.05177610f, 0.04899294f, 0.39109141f, -0.09805515f, -0.28264257f, 0.19843222f, -0.10864838f, -0.02034917f, 
    0.14582083f, -0.12891956f, 0.05560743f, -0.07736693f, 0.09209348f, 0.17647099f, 0.06900780f, -0.07374693f, 
    0.11436988f, 0.13268946f, -0.05354485f, -0.15638472f, -0.16949953f, 0.13073997f, -0.04304059f, -0.18249848f, 
    0.00758728f, -0.13015829f, 0.07447848f, -0.07461188f, 0.10345566f, -0.06498581f, 0.10543491f, 0.04848010f, 
    -0.10617030f, -0.04980484f, -0.13292627f, -0.00393121f, -0.11090949f, 0.06637331f, -0.17972466f, -0.15706858f, 
    0.09715194f, -0.00262567f, 0.16793925f, -0.09456104f, 0.00680157f, -0.16275755f, 0.38560912f, 0.13397931f, 
    0.14933132f, 0.14353044f, -0.15925497f, 0.07702567f, 0.15413910f, -0.03037826f, 0.03046238f, 0.16665323f, 
    0.13005030f, 0.16706036f, -0.03825713f, -0.05971998f, 0.20012026f, 0.34207034f, -0.03883391f, 0.05082421f, 
    -0.14655335f, 0.00948904f, 0.12901710f, 0.37196022f, -0.18586263f, 0.24037084f, -0.27037096f, 0.10019048f, 
    -0.13402028f, -0.09540164f, 0.12382273f, -0.26075613f, 0.13794801f, 0.03029118f, -0.60813105f, -0.12393754f, 
    0.09273504f, 0.05605187f, -0.12635393f, -0.10885528f, 0.14054631f, 0.36199957f, -0.00863326f, 0.04988458f, 
    -0.16665123f, 0.16149357f, 0.13581453f, -0.33387890f, -0.16654648f, 0.29481128f, 0.13944453f, -0.32527369f, 
    0.40671080f, -0.12240265f, 0.03686666f, -0.00948263f, -0.20625672f, 0.31569299f, 0.28174153f, -0.11070985f, 
    0.06797734f, 0.00000319f, -0.03544886f, 0.52356267f, -0.10358247f, -0.10993936f, -0.09819614f, 0.24891031f, 
    -0.14293897f, 0.13135260f, 0.12783407f, 0.09837972f, -0.04471543f, 0.41525733f, 0.13779812f, 0.16450864f, 
    -0.03057339f, 0.20941333f, -0.01113568f, -0.36275065f, 0.03624874f, -0.23734376f, 0.16959071f, 0.24285282f, 
    -0.13290940f, 0.13137175f, 0.08816041f, -0.37255105f, 0.02242515f, 0.02716329f, 0.46931937f, -0.10092882f, 
    -0.17811927f, 0.05112052f, 0.05174894f, -0.24633881f, -0.07711586f, 0.15754066f, -0.00679880f, 0.31085312f, 
    -0.11831654f, -0.12478548f, -0.03866310f, -0.06414854f, -0.00360434f, -0.08697909f, 0.03675700f, -0.18109006f, 
    -0.11818410f, 0.27989104f, -0.15279177f, 0.08011024f, 0.37544727f, 0.15449792f, 0.12622778f, -0.07871787f, 
    -0.03668283f, 0.12190130f, 0.29779258f, -0.21747999f, -0.22767444f, 0.20865549f, 0.13489753f, -0.01637338f, 
    0.00892451f, -0.13340858f, 0.10359855f, 0.26676324f, -0.03663999f, 0.14232510f, -0.34000263f, -0.55796403f, 
    -0.07842593f, 0.09877227f, 0.11991124f, -0.16210969f, 0.06236596f, -0.09131800f, -0.16557655f, -0.22618857f, 
    -0.04422115f, -0.01697320f, 0.08052135f, 0.33943638f, -0.13862485f, -0.10543917f, -0.02763409f, -0.07334065f, 
    0.28937590f, 0.05844731f, 0.29697821f, 0.32236713f, 0.15354709f, 0.00295462f, -0.13051437f, 0.16275890f, 
    -0.05523033f, -0.10558129f, -0.09141462f, 0.27714276f, 0.04149793f, -0.14999910f, -0.55671692f, -0.11845995f, 
    -0.05419886f, 0.13302626f, -0.04192962f, 0.06578021f, -0.02678342f, 0.11503046f, 0.16093031f, 0.15371275f, 
    0.17229404f, -0.21126918f, 0.15632372f, -0.24305071f, 0.09316648f, 0.37248307f, 0.07831769f, 0.10891524f, 
    -0.04897239f, 0.15258542f, 0.08875043f, -0.17566884f, 0.13415116f, 0.10486026f, -0.19622667f, 0.02870346f, 
    -0.08010960f, -0.12017788f, 0.00950359f, -0.26964322f, 0.06832234f, -0.02484995f, 0.09940635f, -0.28211123f, 
    -0.17479774f, -0.17631359f, -0.16497658f, 0.13697182f, -0.17060888f, -0.24099904f, -0.15883878f, -0.01166169f, 
    0.01744037f, -0.23340009f, -0.06367371f, 0.31893203f, 0.32176679f, -0.00389230f, -0.08172478f, -0.24223448f, 
    0.13203487f, 0.09991848f, -0.02815795f, 0.26474309f, 0.35636407f, -0.02011478f, 0.00861915f, 0.16243412f, 
    -0.17638488f, 0.14597164f, 0.00698242f, -0.45990336f, -0.03280061f, 0.00702990f, 0.25725895f, 0.03386390f, 
    -0.09975029f, -0.14719981f, -0.05249856f, -0.07967845f, 0.14480978f, 0.25347343f, -0.13792129f, -0.15490356f, 
    0.16639496f, 0.08576858f, -0.02924198f, 0.28619340f, -0.12366869f, -0.33178020f, -0.11085778f, 0.55285370f, 
    0.00456114f, 0.11272998f, 0.07287210f, -0.15667668f, 0.24744496f, -0.47883159f, 0.19459330f, -0.17182703f, 
    0.13319315f, 0.14901738f, 0.13283257f, -0.37672943f, -0.09535836f, -0.11312858f, 0.34621081f, 0.34108630f, 
    0.16891679f, 0.15768558f, 0.17138261f, -0.14275169f, 0.02550886f, -0.22836810f, 0.05539341f, 0.25022939f, 
    -0.12710223f, 0.07766094f, 0.14074969f, -0.26005355f, 0.09773418f, -0.41602364f, -0.01709267f, 0.24520618f, 
    -0.00885241f, -0.15246716f, -0.38989300f, -0.22699632f, 0.29397175f, 0.25873157f, 0.31532276f, 0.04998087f, 
    -0.06373644f, 0.02043523f, 0.12093016f, -0.43101159f, -0.05864863f, -0.15009284f, -0.36887193f, -0.28346619f, 
    -0.11478243f, -0.09281675f, 0.15663047f, 0.04705836f, 0.01747325f, 0.20776682f, 0.12445827f, 0.38245055f, 
    0.03776335f, 0.20864527f, -0.00425518f, 0.10288141f, 0.11864103f, 0.04323533f, 0.11537928f, 0.29972994f, 
    0.21747282f, 0.16109855f, 0.21323167f, -0.50360125f, -0.14387909f, -0.21301483f, -0.09731304f, 0.06764947f, 
    -0.16254495f, -0.01704406f, -0.13474785f, -0.32453576f, 0.00994368f, 0.03051494f, 0.24102661f, -0.10010900f, 
    -0.08979656f, -0.14848815f, -0.08909336f, -0.00238525f, 0.03305928f, 0.05778008f, -0.16627072f, -0.06571193f, 
    0.04897179f, 0.28099903f, -0.06392145f, 0.39155370f, 0.03346693f, -0.40569937f, 0.03752303f, 0.37965173f, 
    0.00702175f, 0.11182737f, -0.32100767f, -0.07342363f, 0.33949602f, -0.27190349f, -0.15145011f, -0.11088791f, 
    0.03356906f, -0.13526128f, -0.02952631f, -0.00561095f, 0.13426781f, 0.01888097f, 0.05617050f, 0.26168370f, 
    0.15321904f, -0.01704077f, 0.06132579f, 0.14902042f, -0.06231768f, -0.11731435f, 0.06518305f, -0.45534179f, 
    -0.04685585f, -0.10534886f, 0.05342619f, -0.09023993f, 0.11459152f, 0.28386194f, -0.11113679f, 0.43183446f, 
    0.00358650f, -0.01941092f, -0.13524979f, -0.16184776f, 0.14049116f, 0.00989819f, 0.18959805f, -0.16787821f, 
    -0.04778017f, 0.03312241f, 0.03741688f, 0.11991319f, 0.11053301f, -0.11410782f, -0.01920226f, -0.12267413f, 
    -0.14936155f, -0.02511779f, 0.11785703f, 0.12450074f, -0.03300387f, 0.45739496f, -0.11979235f, 0.00429898f, 
    0.01646699f, -0.21923104f, -0.06756502f, -0.05496342f, 0.29200092f, 0.48731357f, 0.11306845f, -0.06073853f, 
    -0.34366003f, 0.10933848f, 0.30173019f, 0.27313137f, -0.12182499f, 0.29918960f, -0.22888467f, 0.00590410f, 
    0.16790602f, 0.08058424f, 0.02284390f, 0.15269284f, 0.12697300f, 0.11290281f, 0.16178741f, 0.58884269f, 
    0.10118005f, -0.11801516f, -0.12128255f, -0.12966581f, 0.14331715f, 0.05626462f, -0.06193774f, -0.16356386f, 
    0.14296193f, -0.31476489f, 0.02895958f, 0.07808449f, 0.28178930f, 0.41602886f, 0.06424335f, -0.13883802f, 
    0.31156340f, -0.04829540f, 0.23451954f, -0.30667216f, -0.22343741f, 0.12575459f, 0.06819886f, 0.02422117f, 
    0.00724494f, 0.04875170f, 0.12984984f, -0.07292596f, 0.09275272f, -0.17359081f, 0.05760418f, -0.03124886f, 
    -0.14397146f, 0.15364021f, 0.07880276f, -0.13868909f, -0.09029486f, -0.07135398f, -0.01769967f, -0.06318460f, 
    -0.17239645f, -0.08479300f, -0.05311890f, -0.05303132f, 0.30711734f, 0.05331994f, -0.18294445f, -0.13649487f, 
    -0.04452721f, 0.05936942f, 0.09951028f, 0.05713888f, 0.32220325f, -0.31175396f, 0.30292729f, -0.00827012f, 
    -0.14746839f, 0.09914920f, 0.02714546f, -0.00619311f, -0.00540059f, -0.07015010f, -0.16620405f, 0.09608894f, 
    0.15945575f, -0.01469349f, 0.10422399f, 0.11756714f, -0.04217060f, -0.16668171f, -0.16590026f, -0.11927101f, 
    -0.05614040f, -0.02555612f, 0.14647850f, -0.12516938f, 0.05050999f, -0.16328475f, 0.05600595f, -0.12424665f, 
    0.07552489f, -0.01396024f, -0.03516966f, -0.01616648f, -0.16401757f, -0.05663759f, -0.00710628f, -0.07801902f, 
    -0.16526344f, -0.04021496f, 0.06066304f, 0.01209322f, 0.06535687f, 0.13245736f, -0.24116114f, 0.07935873f, 
    -0.13093387f, 0.07402597f, -0.05438649f, 0.12754330f, 0.07131326f, 0.06970469f, 0.14192793f, 0.20706899f, 
    -0.05061070f, -0.10835753f, -0.01033884f, 0.40019411f, 0.30926353f, 0.38398534f, 0.07094412f, 0.00886006f, 
    -0.01114249f, -0.12403735f, 0.19265933f, 0.05705751f, -0.16377282f, 0.19813414f, -0.01291853f, -0.00563290f, 
    0.06742899f, 0.17405891f, -0.07870176f, 0.26576647f, 0.09812391f, 0.11375171f, -0.47379869f, 0.03342017f, 
    -0.12050997f, 0.09621541f, 0.16015758f, 0.14609516f, 0.02454386f, 0.16581617f, -0.14415330f, 0.42460522f, 
    -0.15579335f, 0.21389180f, -0.16423734f, -0.23901288f, -0.33035710f, -0.16570023f, 0.14009103f, 0.02381276f, 
    0.15426469f, -0.15617129f, 0.27000836f, -0.40400138f, -0.05121837f, 0.29919842f, 0.20904963f, 0.00169209f, 
    -0.03970643f, 0.01390558f, 0.07529810f, 0.48365518f, -0.14652695f, 0.11926357f, 0.00837993f, -0.17536993f, 
    -0.13260385f, -0.04969608f, 0.00589987f, 0.12403341f, 0.06448229f, -0.01321525f, 0.16795151f, -0.59707808f, 
    -0.12198779f, 0.14915900f, -0.11508375f, -0.11254295f, -0.13701572f, -0.08622140f, 0.07874281f, 0.16315959f, 
    0.04345727f, -0.05648468f, 0.53778529f, 0.31387538f, -0.05847923f, -0.01561570f, 0.22198354f, 0.08646561f, 
    0.14007185f, 0.05557219f, 0.06947809f, 0.09855138f, 0.13480686f, -0.12375245f, 0.22843032f, -0.27591076f, 
    0.09463070f, 0.12263450f, -0.02197149f, 0.01519859f, 0.04534031f, -0.01722738f, 0.03385441f, -0.23860672f, 
    -0.02573934f, -0.20683634f, -0.11019640f, 0.04637719f, -0.17100641f, -0.00202418f, 0.13506044f, -0.09380608f, 
    0.07114657f, 0.17464577f, 0.27304888f, 0.52713645f, 0.38021836f, -0.26059365f, 0.12376631f, -0.17814575f, 
    -0.11034816f, -0.14009787f, -0.09795509f, -0.03709458f, -0.14255884f, -0.13263331f, -0.14473270f, 0.05106274f, 
    -0.17328331f, 0.07182699f, -0.12702671f, -0.09674505f, 0.00453123f, 0.09318476f, 0.16532539f, -0.09529099f, 
    0.04484903f, -0.17433321f, 0.13687037f, -0.07105029f, -0.02694362f, 0.06709626f, 0.09994449f, 0.00457919f, 
    -0.05741313f, -0.06493765f, -0.11799465f, -0.07407026f, -0.07279930f, -0.02530855f, 0.09414168f, 0.01632208f, 
    -0.09353951f, -0.00378657f, -0.10715052f, -0.18770193f, 0.02138305f, 0.14924204f, 0.29218653f, -0.02085873f, 
    -0.06516585f, 0.01351208f, 0.06548204f, 0.03564272f, -0.12700744f, 0.08990211f, -0.17026907f, 0.44754696f, 
    0.13096599f, -0.45646721f, 0.03162983f, -0.22159208f, 0.06090550f, 0.44066456f, 0.02206265f, -0.01079336f, 
    0.23117632f, -0.13763054f, 0.27334270f, 0.00881328f, -0.05548205f, 0.04068213f, -0.22066277f, -0.17794767f, 
    0.05926179f, -0.00519098f, -0.12043846f, 0.13693780f, 0.17205243f, -0.05435333f, -0.25655708f, 0.03237381f, 
    0.06757383f, 0.04329097f, -0.02995293f, -0.15475976f, 0.08608792f, 0.20189004f, 0.06943588f, 0.39464056f, 
    -0.05271839f, 0.50849360f, 0.09817917f, -0.17940404f, 0.26205578f, -0.19064310f, -0.16232814f, 0.04710244f, 
    -0.15579712f, 0.09177382f, 0.03458657f, -0.59320444f, 0.07462171f, -0.12629174f, 0.14144689f, 0.04352223f, 
    -0.17741413f, 0.04990825f, -0.00674126f, 0.29502404f, 0.15911683f, -0.15557306f, 0.50914109f, 0.34441856f, 
    0.00680512f, 0.06204164f, 0.09960326f, -0.04928968f, -0.07682081f, -0.05448796f, -0.14599103f, -0.20881428f, 
    -0.05411340f, 0.02768192f, 0.10545149f, -0.24958028f, 0.18475436f, 0.30049661f, 0.01809795f, 0.29541966f, 
    -0.12181765f, -0.07683861f, -0.02968510f, -0.27089176f, 0.00702205f, 0.09407269f, -0.07862823f, 0.10222592f, 
    0.11248035f, -0.09284790f, 0.12887977f, -0.22688122f, 0.11555341f, 0.13536201f, 0.23715450f, -0.35763747f, 
    -0.01609057f, 0.07847901f, 0.12002844f, -0.05180153f, 0.13490307f, -0.34678236f, -0.01005520f, 0.12106815f, 
    0.04350547f, -0.25093061f, -0.00122094f, -0.20280837f, 0.10535917f, 0.28697050f, 0.05147954f, -0.01019291f, 
    0.22936818f, -0.07241600f, 0.17418887f, 0.09061196f, 0.16461943f, 0.00479922f, 0.07034183f, 0.09004000f, 
    -0.13097687f, 0.13085996f, 0.16871788f, -0.05469676f, 0.15890618f, -0.16683395f, 0.11713628f, 0.01595446f, 
    -0.02574927f, -0.13344552f, 0.10117189f, -0.13349257f, 0.11821771f, -0.13789150f, 0.02032994f, 0.19365153f, 
    0.04143307f, -0.33601689f, 0.14680368f, 0.15089385f, 0.26295024f, 0.03541326f, -0.12955810f, -0.17610203f, 
    -0.05610934f, -0.01569372f, -0.25193802f, -0.03937413f, 0.30147070f, -0.00280816f, 0.12824991f, 0.14699052f, 
    -0.10344719f, 0.05244501f, -0.14935738f, 0.03547490f, 0.10588953f, -0.08241247f, 0.51964480f, 0.03134633f, 
    0.00456065f, 0.01352117f, 0.15543602f, 0.08423113f, -0.04481860f, 0.13525805f, 0.01212262f, -0.16433872f, 
    0.05011265f, 0.27869603f, 0.15342452f, -0.04987396f, -0.32299742f, 0.02842423f, -0.03980300f, 0.43758705f, 
    0.32852226f, 0.11290952f, -0.22076373f, 0.25735399f, -0.12972115f, 0.31632578f, -0.14002144f, -0.11943449f, 
    -0.02826778f, 0.00357464f, 0.10079529f, -0.37132832f, 0.10033181f, 0.10350463f, 0.17608273f, 0.19477071f, 
    0.10827743f, -0.06715552f, -0.13146047f, 0.05301242f, -0.05812557f, -0.36105791f, -0.02776190f, -0.23674943f, 
    0.04426156f, 0.14132532f, 0.09691594f, 0.42861697f, 0.11426004f, 0.05426525f, -0.05938822f, 0.25551882f, 
    0.08001105f, -0.09532666f, -0.11146361f, 0.29244813f, 0.23628496f, -0.14383179f, -0.09863684f, 0.06374400f, 
    0.06996668f, 0.13653086f, -0.12506951f, -0.06161439f, -0.00125693f, -0.16134144f, -0.30926836f, 0.16463262f, 
    -0.11783390f, 0.10438923f, 0.09597029f, 0.09768711f, -0.16468181f, -0.03738938f, 0.05637610f, -0.30385476f, 
    -0.01853688f, 0.07889974f, -0.09779131f, 0.40549153f, 0.32312372f, 0.12522654f, -0.15234847f, -0.25415269f, 
    -0.15009256f, 0.11806189f, -0.01077103f, 0.49380216f, 0.28835741f, -0.13231790f, -0.00821387f, 0.18431111f, 
    0.01161615f, -0.15239945f, -0.16034134f, -0.19490756f, -0.07552869f, -0.09442302f, 0.40416801f, 0.48100573f, 
    0.13118006f, 0.05934925f, -0.09721135f, 0.00046303f, 0.05793582f, -0.27035478f, -0.00857982f, -0.00742964f, 
    -0.14421980f, -0.31385046f, 0.15794015f, 0.22718737f, 0.00980388f, 0.22247268f, -0.06879849f, 0.23999386f, 
    0.31743407f, -0.10715323f, -0.19461015f, 0.09139038f, -0.17495963f, 0.28292200f, -0.02826525f, -0.17525141f, 
    -0.09679150f, -0.14218251f, 0.03799592f, 0.00262001f, -0.08749247f, -0.13333362f, 0.28419158f, -0.31559923f, 
    -0.16405518f, -0.07435239f, 0.16242656f, -0.02043037f, 0.02484811f, 0.11092156f, -0.09614427f, 0.04463036f, 
    -0.18455689f, 0.13763151f, 0.13158487f, 0.02785461f, -0.36974987f, 0.12404003f, -0.10328384f, 0.09363026f, 
    0.19866860f, -0.13069353f, 0.09840945f, 0.60865778f, 0.11642770f, 0.34892315f, -0.42396924f, -0.12838513f, 
    0.14827707f, 0.14779451f, -0.03441799f, 0.18337549f, -0.08690521f, -0.03815537f, -0.19289374f, 0.27921119f, 
    0.03624546f, -0.09645420f, -0.13142283f, 0.18062982f, -0.09065466f, 0.10741466f, -0.05904191f, 0.04918876f, 
    0.09042346f, -0.20766939f, 0.12767528f, -0.03995913f, 0.05968115f, -0.35361335f, -0.02487804f, 0.16355595f, 
    0.12634219f, 0.06999233f, -0.07882298f, -0.25711271f, 0.21726112f, -0.09159460f, 0.32073835f, 0.02192004f, 
    -0.01664914f, 0.08765636f, 0.02086589f, 0.02068308f, -0.15201628f, 0.12657626f, 0.13855916f, 0.06102009f, 
    -0.06077664f, 0.02323613f, 0.07431054f, 0.03856194f, 0.02689040f, -0.03924857f, 0.01426469f, -0.04492936f, 
    -0.02265690f, -0.18146047f, -0.05732728f, 0.11942393f, -0.06813921f, 0.02606992f, -0.02580040f, 0.00851783f, 
    -0.16003586f, 0.01831474f, -0.12515359f, 0.10485270f, -0.19250607f, 0.00417378f, -0.04914261f, -0.11819576f, 
    -0.02623032f, 0.01802281f, 0.12425783f, 0.11149176f, 0.01011767f, -0.00987134f, -0.14305437f, -0.03198157f, 
    0.09292468f, -0.08747757f, -0.06658614f, -0.06686407f, -0.11218918f, -0.03895892f, 0.14398898f, -0.18932715f, 
    -0.06604188f, -0.26702186f, -0.10392474f, 0.43319106f, 0.02462124f, 0.19389161f, -0.07076173f, 0.27913886f, 
    0.32225862f, -0.14379294f, 0.20442571f, 0.36485547f, 0.00669037f, -0.25830340f, -0.13474134f, -0.13605626f, 
    -0.03265679f, -0.16266258f, -0.06570926f, -0.16134889f, -0.15808702f, 0.15909675f, -0.43780205f, -0.06822281f, 
    -0.06687849f, -0.00813466f, -0.09397046f, -0.01350383f, -0.09370300f, 0.07212628f, 0.15015917f, -0.22722816f, 
    0.12372664f, 0.21761167f, 0.00755775f, 0.54344964f, 0.03438558f, 0.07764756f, 0.02810211f, -0.17028211f, 
    0.32318142f, -0.16990073f, -0.11540937f, -0.50231194f, -0.10736112f, 0.30598664f, -0.12373315f, -0.04136949f, 
    -0.15321776f, -0.09017299f, -0.07147570f, -0.13508207f, 0.09926467f, 0.16101967f, 0.04777045f, -0.17538440f, 
    -0.07224825f, -0.16414872f, -0.02587406f, -0.04993560f, 0.03292432f, -0.15591034f, 0.15036348f, 0.12058728f, 
    -0.09109822f, -0.14560235f, -0.00603048f, -0.18139701f, 0.15821752f, -0.17386389f, 0.07754865f, -0.10860676f, 
    -0.03310042f, -0.07072454f, -0.10281181f, 0.08507548f, 0.36275005f, -0.21137677f, 0.41804299f, -0.01185972f, 
    -0.01574360f, -0.01180065f, 0.12844394f, 0.10974855f, -0.13678536f, 0.06146308f, -0.06058377f, -0.10497191f, 
    -0.02026292f, -0.02038487f, -0.06285436f, 0.01569254f, 0.00116451f, 0.16514018f, -0.11447090f, -0.02603253f, 
    -0.09450813f, -0.08752151f, -0.14190686f, -0.00147420f, 0.07141691f, -0.14813487f, -0.02499866f, -0.15939899f, 
    -0.05872850f, 0.11317436f, -0.03823481f, 0.10415205f, -0.13726705f, -0.12150089f, -0.13093892f, 0.08014586f, 
    -0.04920365f, -0.02343644f, -0.03007787f, 0.10972679f, 0.17235434f, -0.10719330f, -0.08571727f, 0.09718712f, 
    -0.17153318f, -0.09643618f, -0.10137817f, 0.03548282f, -0.09740097f, 0.00669369f, 0.11286769f, -0.15493329f, 
    -0.04411478f, 0.06591386f, -0.04758469f, -0.07044993f, -0.06574260f, -0.14153636f, 0.10492803f, -0.18106782f, 
    -0.16020465f, -0.10556287f, 0.04356237f, 0.10298560f, -0.10346109f, -0.00593967f, -0.01538229f, 0.13024889f, 
    0.15845440f, 0.03698346f, 0.03009446f, 0.24136737f, -0.06515093f, 0.06415814f, 0.14899848f, -0.04289396f, 
    -0.14483941f, -0.04716165f, 0.01164355f, 0.09849805f, -0.01015802f, 0.08257274f, 0.09937000f, 0.20998919f, 
    0.17555523f, 0.35346851f, -0.13786793f, -0.46920148f, -0.18262714f, -0.36318374f, -0.00561624f, 0.36386761f, 
    0.03660696f, -0.06363386f, 0.01794269f, -0.29269862f, 0.19236164f, 0.21819414f, 0.22113162f, -0.12855552f, 
    -0.15309928f, 0.15706056f, -0.06475123f, -0.12344401f, -0.13898744f, -0.11478663f, -0.23415166f, -0.55526501f, 
    0.10705196f, -0.04598833f, 0.00724414f, 0.10004511f, -0.12452123f, 0.26466641f, 0.00001300f, 0.01499934f, 
    -0.12251231f, 0.37719849f, -0.11230754f, 0.28341615f, -0.30231786f, -0.26863629f, -0.06228909f, 0.46582961f, 
    0.09756573f, 0.09522741f, 0.10076770f, -0.00837838f, 0.23946096f, -0.29834247f, -0.06514892f, 0.06697918f, 
    0.16037835f, -0.15479335f, 0.10844804f, -0.12970272f, 0.13253228f, -0.14462215f, 0.34397307f, 0.20709372f, 
    -0.00913829f, -0.04161908f, -0.03889935f, 0.14968766f, 0.12008815f, -0.09848209f, -0.14308168f, -0.13560674f, 
    0.04607704f, 0.13323677f, 0.08801352f, -0.00863862f, 0.01558701f, -0.11931874f, -0.18115507f, 0.37768626f, 
    0.20081203f, 0.07699203f, -0.25066879f, -0.32733178f, 0.12889276f, -0.14624879f, -0.06126935f, -0.03717238f, 
    -0.11991836f, -0.05778192f, -0.14782381f, -0.17045271f, -0.17190939f, -0.15218358f, 0.34434533f, 0.28592068f, 
    0.12749772f, 0.16744299f, 0.11459620f, -0.07586268f, 0.04614158f, -0.34655055f, 0.12378240f, -0.15539093f, 
    -0.11759457f, -0.14707115f, -0.02614516f, 0.01916020f, 0.06757337f, 0.27614450f, -0.03016635f, -0.15310170f, 
    0.06323930f, -0.13951826f, 0.25825179f, 0.63925517f, 0.10325056f, 0.36292985f, 0.03288790f, -0.13753013f, 
    -0.11501653f, -0.06727199f, 0.01168419f, -0.42501664f, -0.08207683f, -0.05738335f, -0.03639655f, -0.52582926f, 
    -0.11486651f, -0.02880350f, 0.06841641f, 0.10734846f, 0.01617630f, 0.03626726f, -0.02622809f, -0.16245818f, 
    0.15250959f, 0.40873173f, -0.06030053f, 0.16139065f, -0.22528654f, 0.09609611f, -0.18710558f, 0.18908876f, 
    0.19377075f, 0.06055406f, 0.03345018f, -0.00753864f, 0.15831418f, 0.21736373f, 0.00646532f, -0.05687999f, 
    0.05355802f, 0.13385771f, -0.01530154f, 0.02800050f, -0.06638565f, 0.13470396f, 0.04544174f, -0.47265068f, 
    0.09839272f, 0.05753060f, 0.12919691f, 0.15688251f, -0.12808223f, 0.19202718f, -0.07519756f, 0.46628684f, 
    -0.00766590f, 0.09579067f, -0.01682270f, 0.00115927f, -0.18374719f, -0.17327182f, -0.02184790f, -0.09901948f, 
    0.11106626f, 0.14004527f, -0.10691994f, 0.22027604f, 0.24026391f, 0.35906771f, -0.03865238f, -0.04941467f, 
    -0.14818390f, -0.09882846f, 0.06129612f, 0.10887568f, -0.09907470f, -0.06875739f, -0.04122501f, 0.20417173f, 
    -0.12825888f, -0.06690053f, 0.09966110f, -0.13090633f, -0.03421037f, -0.27104357f, -0.02003742f, 0.04997912f, 
    0.09318703f, 0.07740324f, -0.03348132f, -0.02167621f, 0.39382708f, 0.26182204f, -0.03011557f, -0.13848561f, 
    -0.15612242f, -0.11069048f, -0.10346383f, -0.14368506f, 0.15508904f, -0.10807858f, 0.47913271f, 0.09351332f, 
    -0.03571705f, -0.13568750f, -0.05988536f, -0.23126203f, 0.09513083f, -0.06513937f, 0.33583030f, -0.34611928f, 
    -0.14583544f, 0.12248415f, 0.11789226f, -0.08019789f, -0.05493576f, 0.04506312f, -0.00172541f, -0.26689273f, 
    -0.10236612f, -0.12298679f, 0.05845313f, -0.22367118f, -0.08224698f, -0.46689600f, -0.09271707f, 0.28025204f, 
    0.07233097f, -0.12303562f, 0.14574693f, 0.29111671f, 0.28747007f, -0.38776398f, 0.33007905f, 0.15141599f, 
    -0.07924061f, -0.11231592f, -0.07543699f, 0.28810203f, -0.10519894f, -0.11322171f, 0.05073042f, 0.60573876f, 
    -0.07275625f, -0.11551861f, 0.13837808f, 0.04562506f, 0.11823032f, 0.00447294f, 0.07391059f, -0.40328145f, 
    0.04488561f, -0.15001512f, -0.05800416f, 0.17406967f, 0.11681376f, 0.06016179f, -0.06563498f, 0.19105849f, 
    0.15363587f, 0.05895092f, 0.02158847f, 0.28468487f, -0.07034931f, 0.11403490f, -0.06806939f, 0.05916708f, 
    0.16920806f, -0.06115745f, -0.05460959f, 0.07453740f, -0.11059014f, 0.03404555f, 0.25557667f, 0.74298269f, 
    0.06712714f, -0.09804358f, -0.07309321f, -0.01401994f, 0.03925283f, 0.11218224f, 0.08937936f, 0.04523956f, 
    0.07792270f, -0.10827759f, -0.07369020f, 0.11151889f, 0.32817739f, -0.09533001f, -0.14993758f, 0.07271279f, 
    0.11442676f, 0.05431632f, -0.33771965f, -0.59834105f, 0.00986458f, -0.21881661f, 0.03495980f, 0.08115412f, 
    0.16115190f, -0.06257602f, -0.00582339f, -0.03788810f, 0.12535231f, -0.00674887f, 0.12242466f, -0.07451529f, 
    -0.10776226f, -0.17544475f, -0.04918518f, 0.11431824f, -0.13206117f, -0.14022237f, 0.01753381f, 0.02518087f, 
    -0.03980285f, -0.16547495f, 0.06509549f, -0.13184477f, -0.15142827f, -0.03692416f, -0.04929957f, 0.09591679f, 
    -0.09668177f, -0.12942654f, 0.06538392f, 0.11534878f, -0.13914014f, -0.02602018f, 0.12488033f, -0.10626988f, 
    0.04699506f, 0.13855486f, 0.11621486f, 0.03242871f, 0.05609193f, -0.04243077f, -0.14598735f, -0.02747417f, 
    -0.05538081f, -0.13826603f, 0.07690154f, 0.09104709f, -0.00931205f, -0.16380270f, -0.04851943f, -0.19955939f, 
    0.14282511f, -0.12327969f, -0.00974863f, -0.04826290f, -0.01349897f, -0.12604883f, -0.16750616f, 0.05730806f, 
    -0.12021084f, 0.08858203f, -0.02539261f, -0.16494776f, -0.02141113f, 0.13368411f, -0.17907770f, -0.07935215f, 
    -0.02434815f, -0.11432391f, -0.07367355f, 0.20274821f, 0.02741381f, 0.08512302f, 0.15542701f, -0.27456984f, 
    -0.02967261f, 0.07388359f, -0.02060276f, 0.00835713f, 0.07415327f, 0.14620297f, -0.12678942f, 0.33867788f, 
    -0.15798894f, 0.14645842f, 0.14951159f, -0.51715082f, -0.04009845f, 0.38523313f, 0.11336177f, -0.17474869f, 
    0.19572407f, -0.06339383f, 0.20524569f, -0.07271460f, -0.22167644f, 0.31121191f, 0.25211346f, 0.02633603f, 
    -0.01830015f, -0.12903003f, 0.09502697f, -0.55683351f, 0.04551598f, 0.04897984f, -0.10921560f, -0.39770675f, 
    -0.05576967f, 0.09507704f, 0.11848465f, -0.00696207f, -0.11738046f, 0.35414690f, 0.02874422f, 0.23613317f, 
    0.08353327f, 0.24243163f, 0.03217794f, -0.25714415f, -0.26961258f, 0.15396200f, -0.01150196f, 0.27607843f, 
    0.23194233f, -0.10857426f, 0.32449687f, -0.07079388f, -0.01174269f, -0.26316279f, 0.13617815f, 0.12297343f, 
    0.09238098f, 0.13596976f, 0.06257094f, 0.32353526f, -0.12947895f, -0.13097982f, -0.41730347f, -0.15121326f, 
    -0.03389595f, 0.08912490f, -0.02078885f, 0.13060176f, 0.12706067f, -0.07776545f, 0.02100240f, -0.46169943f, 
    0.07424273f, 0.14688084f, 0.17594400f, 0.30156660f, 0.00237583f, -0.01543513f, 0.14454234f, -0.17765096f, 
    0.05963527f, -0.16642766f, 0.31299746f, 0.26964432f, 0.08187434f, -0.43369332f, 0.22209387f, -0.08737106f, 
    0.04194104f, 0.07079478f, 0.08503906f, 0.14875539f, 0.06003622f, -0.09703062f, -0.06794780f, -0.12460381f, 
    0.10468904f, -0.05953933f, 0.14748946f, 0.11530212f, -0.10365754f, 0.12698372f, 0.13424022f, -0.13405696f, 
    0.12407275f, -0.18244730f, 0.17617635f, -0.06865812f, -0.16177130f, 0.08881962f, -0.03191252f, -0.18680842f, 
    -0.01927247f, -0.00050684f, -0.13007201f, 0.12218644f, -0.18721448f, -0.08708552f, -0.12543777f, -0.01383717f, 
    -0.06798966f, -0.09804565f, 0.14908676f, 0.25067684f, 0.14022708f, -0.13750607f, -0.27039188f, 0.35034683f, 
    -0.05211371f, 0.04979192f, 0.01136826f, -0.12048538f, 0.10801371f, -0.05872094f, -0.03624912f, -0.43528342f, 
    0.02906515f, -0.11965469f, 0.05151138f, 0.47056684f, 0.28454331f, 0.21070939f, -0.04481550f, 0.00898736f, 
    0.27134269f, 0.01692099f, -0.14339072f, -0.14705354f, -0.17279530f, 0.17498040f, 0.01223193f, 0.00519749f, 
    0.16790482f, 0.05800648f, 0.06626394f, -0.23802342f, 0.17045526f, 0.01800559f, -0.00729624f, -0.21644972f, 
    -0.09289660f, -0.15323749f, 0.03094411f, 0.01654337f, -0.00574067f, 0.20151217f, -0.14929333f, 0.31250086f, 
    0.12290092f, 0.33530411f, 0.15163438f, -0.14743452f, -0.00689570f, 0.29506695f, -0.16790442f, -0.04425278f, 
    -0.27814612f, 0.11250260f, 0.35656977f, 0.53370726f, 0.03497950f, 0.24944957f, -0.33854800f, 0.14176778f, 
    -0.14302208f, 0.03782512f, 0.08889136f, 0.53201234f, 0.00748239f, -0.08824604f, -0.10324584f, 0.40445593f, 
    -0.06917828f, -0.05439600f, -0.13167472f, -0.05149388f, -0.01813592f, 0.26928106f, 0.06000888f, 0.09880523f, 
    0.12575266f, 0.20927273f, -0.05432107f, -0.17434618f, 0.05728620f, 0.24782155f, -0.07446948f, 0.12160089f, 
    0.21519321f, 0.12754083f, 0.14328253f, -0.46046373f, -0.32096842f, 0.08375294f, 0.26274100f, -0.17143536f, 
    -0.13816810f, 0.14099970f, 0.07548311f, -0.11432552f, -0.00614935f, -0.10559874f, 0.02516405f, -0.02699568f, 
    0.13293150f, 0.06225464f, -0.00074731f, 0.03826504f, 0.08576991f, -0.17888282f, 0.06167165f, -0.08704012f, 
    -0.03045660f, -0.08832014f, 0.06023617f, -0.16096719f, -0.02380097f, 0.10540471f, -0.11783945f, -0.16891260f, 
    -0.00588905f, 0.05050773f, -0.11043769f, 0.11283754f, -0.17833830f, -0.10213096f, 0.10657608f, 0.01008930f, 
    0.00334897f, -0.02743427f, 0.09274421f, 0.60505325f, -0.07522038f, 0.04645632f, 0.23362321f, 0.62287599f, 
    0.13188119f, 0.13232832f, 0.10806789f, 0.10808397f, -0.01572633f, -0.01519456f, 0.03544249f, -0.13129833f, 
    -0.15211259f, -0.09871149f, -0.09607983f, 0.04050213f, 0.20096840f, -0.06727194f, -0.01221567f, -0.02490968f, 
    -0.21280038f, 0.01078742f, -0.06755497f, -0.03107867f, -0.11119133f, -0.01847723f, 0.38133600f, 0.06091712f, 
    -0.17542292f, -0.13024530f, -0.08318666f, 0.10878789f, 0.12703562f, 0.08263801f, 0.37611327f, 0.07605883f, 
    -0.06584287f, -0.15123758f, -0.17382276f, 0.06371719f, -0.14852764f, -0.18187943f, 0.15125245f, -0.15003212f, 
    0.00253199f, 0.33125824f, -0.13255920f, 0.23072702f, 0.21513389f, -0.16302092f, 0.13648592f, 0.21934825f, 
    -0.00454954f, -0.14228398f, -0.12431267f, -0.23283698f, 0.00640920f, -0.20122011f, 0.10883304f, -0.06399820f, 
    -0.08661512f, -0.13073647f, -0.05242901f, -0.10827652f, -0.03768001f, 0.08469462f, 0.39369029f, 0.27760899f, 
    -0.04424412f, 0.04997495f, -0.14792611f, 0.15194026f, 0.13473037f, -0.06397303f, 0.12763427f, -0.42676347f, 
    0.01968818f, 0.06629794f, -0.02364735f, 0.07246841f, -0.11722276f, 0.27615559f, 0.03138784f, 0.16457175f, 
    0.13716549f, -0.13215284f, 0.22150733f, 0.70450187f, 0.08000179f, -0.00782788f, -0.25763509f, -0.04447906f, 
    0.16494325f, -0.03906415f, -0.02112650f, -0.43499196f, -0.11839311f, 0.13215011f, -0.36895356f, -0.18915866f, 
    -0.05024784f, 0.12413976f, -0.14137976f, -0.12012615f, -0.13865738f, -0.24075827f, -0.10280258f, 0.15510228f, 
    -0.14386387f, 0.29515612f, -0.14251105f, 0.18679537f, 0.35124439f, 0.03476922f, -0.05893817f, -0.24648915f, 
    -0.21426883f, -0.16956981f, 0.21619201f, -0.07755130f, 0.22554937f, 0.15238521f, 0.20703924f, -0.13406858f, 
    0.16783774f, -0.09211348f, -0.00635402f, 0.32536992f, -0.11581148f, -0.08438540f, -0.10844896f, 0.08434272f, 
    -0.15049483f, -0.05375651f, 0.00656981f, 0.04236353f, -0.07837252f, 0.02648014f, -0.06621392f, -0.33024126f, 
    0.03546819f, -0.00983250f, 0.16980946f, 0.25669771f, 0.28164345f, 0.20848574f, -0.09517419f, -0.32400703f, 
    0.19423795f, 0.09638111f, 0.29522362f, 0.38864839f, -0.10250571f, -0.14331068f, -0.05047626f, -0.10439263f, 
    -0.04571982f, -0.04314213f, 0.10204770f, 0.14098378f, 0.17873226f, 0.03507704f, -0.20153359f, 0.33083853f, 
    0.15682609f, 0.17143233f, -0.05061282f, 0.15349148f, 0.12660635f, 0.33628297f, -0.05710794f, 0.20951660f, 
    -0.11123101f, -0.03326192f, 0.06165838f, 0.07918345f, 0.33680847f, 0.04232563f, -0.13502924f, -0.18799599f, 
    -0.28368047f, 0.12053017f, 0.35195613f, -0.15176249f, 0.25806612f, -0.25115854f, 0.19669849f, -0.11205563f, 
    0.03533991f, -0.01775919f, -0.07714152f, 0.12698971f, 0.03707471f, 0.11292706f, -0.11640492f, -0.45202515f, 
    -0.17366891f, -0.02492693f, -0.07576928f, 0.14111316f, 0.15317120f, 0.01223199f, -0.08815560f, 0.19458090f, 
    0.06010000f, -0.00427228f, 0.15328591f, 0.11252807f, -0.07757912f, -0.05556685f, -0.02869016f, -0.02096768f, 
    -0.01034390f, 0.11848141f, 0.43686166f, 0.26984975f, 0.08840587f, -0.36392784f, 0.06091171f, 0.10053282f, 
    0.10023046f, -0.09124914f, -0.15922949f, 0.13011327f, 0.11408304f, 0.12978363f, 0.43733492f, -0.13857460f, 
    -0.04632795f, 0.02021180f, -0.17911197f, 0.14926696f, -0.07592593f, -0.07306336f, -0.14601336f, 0.19304132f, 
    -0.08232071f, 0.32392448f, -0.05714317f, -0.23161392f, 0.03728181f, 0.04951541f, 0.05130582f, 0.11309039f, 
    0.00667104f, 0.13995673f, 0.10888774f, -0.17672758f, -0.25235680f, 0.50242740f, -0.06232926f, 0.10743514f, 
    -0.11248937f, -0.01510184f, -0.08751127f, -0.25668076f, 0.15357807f, -0.13205752f, -0.47556233f, 0.44938436f, 
    -0.05561756f, -0.00869298f, 0.07954016f, -0.01977372f, -0.13980833f, 0.04516497f, -0.14551128f, 0.20384644f, 
    0.09856259f, 0.27632052f, -0.11425495f, 0.22290443f, 0.27692178f, -0.16276012f, -0.15265505f, -0.44210649f, 
    0.14769946f, 0.12852357f, 0.13942663f, -0.33249560f, -0.10925074f, 0.46608883f, 0.11664810f, 0.14984848f, 
    0.14644124f, -0.09569920f, -0.00243629f, -0.04117861f, -0.11198711f, 0.16174480f, -0.20796569f, -0.32560816f, 
    0.05998293f, 0.12928550f, 0.15579402f, 0.06169593f, 0.04497392f, 0.06052411f, 0.06486256f, 0.42622936f, 
    -0.01361079f, -0.16374791f, -0.00722732f, -0.33118078f, 0.12284336f, -0.02405065f, 0.06367605f, -0.16372797f, 
    -0.08762171f, -0.01106067f, 0.38737682f, 0.47353548f, 0.19744262f, 0.00290082f, 0.13007234f, -0.04100791f, 
    -0.05752676f, -0.07517011f, -0.05242796f, -0.12125104f, -0.00484111f, 0.02730568f, 0.14946064f, 0.05731078f, 
    0.13950984f, 0.01052287f, 0.08386941f, 0.07322264f, -0.14243537f, 0.12554894f, 0.04118752f, -0.13405636f, 
    0.03678680f, -0.10487638f, -0.02649500f, 0.11029380f, -0.10830341f, -0.06650288f, 0.02145473f, -0.15681365f, 
    -0.06687076f, 0.11429349f, 0.00970831f, -0.11860023f, -0.09136084f, 0.07366904f, -0.14566982f, -0.07741798f, 
    0.16947117f, -0.04686211f, -0.10712176f, 0.13625716f, 0.16415910f, -0.01950928f, 0.28960204f, -0.47462326f, 
    0.06482651f, 0.04995577f, 0.03549512f, 0.02658726f, 0.04015668f, 0.16028024f, 0.01203312f, 0.40422812f, 
    -0.13907678f, 0.20641524f, 0.04695816f, -0.28083244f, -0.16627736f, -0.02413290f, -0.15164249f, 0.01371173f, 
    -0.05434078f, 0.12711301f, 0.14173095f, -0.28748059f, 0.14986442f, -0.21230075f, 0.42986289f, -0.10703813f, 
    -0.06821743f, -0.01513582f, 0.01317063f, 0.04958661f, 0.16618979f, -0.06999732f, 0.06105082f, -0.67103803f, 
    0.17904268f, -0.03887944f, -0.13613465f, 0.07966308f, -0.08131555f, -0.22066040f, -0.00784187f, 0.09957042f, 
    0.17916760f, 0.23943406f, 0.11029980f, -0.17429493f, -0.12957884f, -0.22210190f, -0.09292899f, 0.05181902f, 
    0.28397211f, 0.02999163f, -0.14342639f, -0.24277224f, 0.28013238f, -0.06770133f, 0.23450328f, 0.14719084f, 
    -0.15190390f, 0.01457703f, 0.07191540f, -0.09527059f, -0.10234142f, -0.12012281f, 0.17080785f, -0.18510848f, 
    -0.10978483f, -0.13710080f, -0.17604020f, -0.00650627f, 0.08737174f, -0.21431462f, 0.15591325f, 0.34761548f, 
    -0.17045201f, -0.24834967f, 0.13566788f, -0.23455322f, 0.18938869f, -0.08319519f, -0.11386381f, -0.22613883f, 
    0.18135393f, -0.01044298f, -0.31848046f, -0.19924669f, 0.26212811f, 0.39071023f, 0.27906591f, -0.00728323f, 
    0.00261632f, -0.16717063f, 0.13781150f, 0.31319809f, 0.04152187f, 0.07051281f, 0.36092237f, -0.19239266f, 
    -0.12139862f, -0.00414490f, -0.17453316f, -0.07839365f, -0.15502505f, 0.06123372f, -0.10235120f, -0.21731521f, 
    -0.10810804f, 0.55582362f, 0.11472915f, 0.15405683f, -0.04181126f, -0.18361500f, -0.12323747f, 0.06990021f, 
    -0.03581561f, -0.13615061f, 0.04823046f, 0.20494208f, -0.03290823f, 0.05543665f, -0.09165224f, 0.02042731f, 
    0.08989629f, -0.12589386f, -0.17548667f, 0.35456198f, 0.17485456f, -0.03981085f, -0.28050891f, 0.18370509f, 
    -0.07393336f, 0.15561470f, -0.05114118f, 0.02261339f, 0.05474944f, -0.29155853f, -0.10138907f, -0.13172166f, 
    0.05323808f, 0.07077370f, 0.06800428f, 0.14846879f, 0.25768515f, 0.06708106f, 0.05856369f, -0.15153143f, 
    0.02511419f, -0.17141372f, 0.27474666f, 0.24321806f, -0.01517450f, -0.01063651f, 0.00016864f, 0.10899115f, 
    -0.06863119f, 0.15809305f, 0.04420476f, -0.38820574f, -0.12053788f, 0.02368782f, -0.27379358f, -0.28887987f, 
    -0.15752704f, 0.15354653f, -0.02814087f, 0.17542021f, -0.14754143f, 0.24787837f, 0.15554556f, 0.28020161f, 
    0.00414464f, -0.07866918f, 0.04662766f, 0.04922354f, 0.00697999f, 0.24697073f, -0.07739769f, 0.02128371f, 
    -0.13235015f, 0.08130220f, 0.29866406f, -0.00901237f, 0.26127729f, -0.31730425f, 0.13376626f, -0.11471999f, 
    -0.06060694f, -0.02231228f, 0.07190306f, -0.65768582f, 0.06464279f, -0.08935408f, -0.24356274f, -0.24387644f, 
    -0.05828188f, -0.04304206f, 0.07580818f, -0.09153935f, 0.16534637f, 0.23046497f, 0.01479333f, 0.16949536f, 
    0.03569064f, -0.06064233f, 0.06954939f, 0.21524070f, -0.07252601f, -0.26513186f, 0.01258408f, 0.06512293f, 
    -0.00615250f, -0.01084078f, 0.09090332f, 0.39580536f, 0.33706680f, -0.05879762f, -0.00693386f, 0.06465903f, 
    -0.00117166f, 0.04279123f, -0.07737765f, -0.03273152f, 0.17012209f, 0.05870514f, -0.18873887f, 0.17579798f, 
    0.00611972f, 0.05206752f, 0.13401955f, 0.01965187f, 0.02384881f, 0.01584857f, 0.09975801f, -0.11233907f, 
    0.05427169f, -0.00276421f, 0.15226650f, -0.09683884f, -0.14587219f, 0.19873194f, 0.15043095f, -0.20908149f, 
    0.16005702f, -0.17467003f, -0.46600145f, 0.13091686f, 0.20469512f, 0.42065451f, -0.16532409f, -0.13124016f, 
    0.00541343f, -0.13139200f, 0.13418587f, -0.04691261f, 0.05315430f, 0.15165164f, 0.20436481f, 0.33390391f, 
    0.13023442f, 0.04101273f, -0.00662371f, -0.11712145f, -0.06368168f, -0.26043764f, -0.03528281f, -0.28624254f, 
    0.09877664f, 0.03635408f, 0.05961284f, -0.01693867f, 0.20033666f, -0.17123128f, -0.06241109f, -0.31859288f, 
    0.01224196f, 0.12561400f, -0.06926538f, 0.04737078f, 0.29563996f, 0.02245547f, 0.28342012f, 0.01393283f, 
    0.01624902f, -0.00644099f, 0.14921935f, 0.22804850f, -0.00177615f, 0.17373306f, 0.24930222f, 0.14891258f, 
    0.04885382f, 0.04840325f, 0.08417463f, 0.03715084f, 0.13665192f, -0.28830558f, 0.15982468f, 0.07827491f, 
    0.05853396f, -0.28328666f, -0.02882141f, -0.42731252f, 0.09437428f, -0.06376452f, -0.12420776f, -0.05781481f, 
    -0.16421615f, 0.01962631f, -0.01621435f, 0.12268238f, 0.18016610f, 0.29523516f, -0.02761417f, -0.09700095f, 
    -0.13006361f, 0.14808273f, 0.02061249f, 0.50616312f, 0.05720651f, 0.06848817f, 0.17355725f, 0.08457857f, 
    0.09406867f, -0.07867128f, -0.05831354f, 0.02013608f, 0.00318215f, 0.19962114f, -0.02035996f, 0.14272751f, 
    0.11710400f, 0.19133049f, -0.04445399f, -0.07043022f, -0.12506254f, -0.05539111f, -0.17233467f, -0.03211070f, 
    -0.24375832f, 0.00555460f, -0.05092908f, 0.55935621f, 0.00818523f, 0.28952983f, 0.06156258f, 0.07025424f, 
    0.03850907f, -0.14632688f, -0.10699699f, 0.43907422f, -0.09333826f, -0.04942201f, -0.44269022f, 0.24794242f, 
    -0.05576036f, -0.05331490f, 0.14432614f, 0.16252354f, 0.11693951f, 0.16775085f, 0.12218780f, -0.14338951f, 
    0.05821843f, -0.32578859f, -0.16387153f, 0.13618314f, 0.30823028f, -0.01829308f, 0.08598198f, -0.14156844f, 
    0.18458556f, -0.12962995f, 0.08364963f, -0.30166033f, 0.04448333f, -0.18452777f, 0.01514196f, -0.05607727f, 
    -0.12194486f, 0.09563500f, 0.17880382f, -0.20708385f, -0.12181817f, -0.07813157f, 0.04471977f, 0.46966392f, 
    -0.08236434f, -0.09105519f, -0.01915122f, -0.09555715f, 0.14430891f, -0.35079694f, 0.01400387f, -0.23928219f, 
    0.09470741f, -0.16334321f, 0.15592216f, 0.31085506f, 0.13736436f, 0.21629475f, 0.08867329f, -0.30836162f, 
    0.01334949f, 0.01808149f, 0.04631594f, 0.50485951f, 0.25196028f, 0.30122098f, -0.04355455f, 0.06691378f, 
    0.05849489f, -0.00984443f, -0.08183059f, 0.02683558f, 0.10815876f, -0.09358377f, -0.25801960f, -0.49725264f, 
    -0.17299753f, -0.12207438f, -0.12518315f, -0.02283204f, -0.11811657f, 0.17086689f, 0.16679899f, 0.09098947f, 
    -0.10451017f, 0.03250377f, -0.06954582f, -0.11566325f, -0.12764445f, -0.06355941f, -0.05910711f, 0.28988522f, 
    0.27780417f, -0.13076587f, 0.09262659f, -0.29245052f, 0.29444295f, -0.29377946f, 0.05837782f, -0.01143794f, 
    0.14091223f, -0.02211784f, -0.07617073f, -0.02820574f, -0.07096069f, -0.02948105f, -0.12830590f, -0.42148808f, 
    0.02977613f, -0.14003712f, 0.06653490f, 0.10405091f, -0.06101272f, 0.31454954f, -0.15753374f, -0.18467091f, 
    0.09696284f, 0.43171084f, -0.09000000f, 0.06343917f, -0.31117237f, -0.28630081f, 0.11584014f, 0.09975160f, 
    0.17934629f, -0.15683545f, 0.17868114f, 0.13917544f, 0.23554955f, -0.10711998f, 0.01874381f, -0.00793360f, 
    -0.09548923f, 0.02721007f, -0.08313255f, -0.19491820f, -0.15464243f, 0.09973999f, 0.22323757f, 0.07332537f, 
    -0.05376403f, 0.12318988f, 0.15195994f, -0.04647113f, -0.04817173f, 0.44904655f, -0.13886684f, 0.18684711f, 
    0.08517738f, -0.26084560f, 0.08660132f, 0.36504081f, -0.04955008f, -0.07980956f, -0.07939830f, 0.35334304f, 
    0.18186690f, 0.12823725f, -0.18346539f, -0.08026946f, 0.22212341f, -0.19462140f, -0.41503203f, 0.16352956f, 
    0.15628695f, 0.00018207f, -0.02678119f, -0.09726680f, -0.01583238f, -0.15217791f, 0.03885590f, -0.07992309f, 
    -0.12022176f, 0.01736609f, -0.02793664f, 0.14570297f, 0.16672447f, -0.34177488f, -0.14896592f, -0.28405103f, 
    -0.13508220f, 0.36514533f, 0.14496313f, 0.33617762f, 0.10383388f, -0.03994075f, -0.00289100f, -0.17946286f, 
    -0.10062456f, -0.16433220f, 0.06472281f, 0.52207476f, 0.26487041f, 0.31354237f, -0.26735398f, -0.16119115f, 
    -0.12884726f, -0.02652532f, 0.08430931f, 0.06759011f, -0.00718462f, -0.02124560f, -0.17871606f, 0.64708132f, 
    -0.14443555f, -0.10314779f, -0.04739857f, -0.14475025f, -0.11263443f, -0.08419953f, -0.14903007f, 0.08390427f, 
    0.17771676f, 0.02388106f, 0.08458441f, 0.07060330f, 0.45888340f, 0.08260009f, 0.14991847f, -0.20865181f, 
    -0.17222628f, 0.06195356f, -0.17518266f, -0.45872024f, 0.17151105f, -0.14084117f, 0.47137004f, -0.15358797f, 
    -0.06697606f, -0.07135180f, -0.00979232f, -0.15625298f, -0.04604830f, -0.00884903f, -0.02231071f, 0.01682311f, 
    0.06541560f, -0.07128958f, -0.16231591f, 0.12660559f, -0.14721963f, -0.03900782f, -0.06296923f, -0.18508729f, 
    0.16694055f, 0.02001141f, 0.09829142f, -0.00019057f, 0.13094436f, -0.13406210f, 0.04665629f, -0.04115644f, 
    -0.12495701f, -0.04580905f, 0.00858827f, -0.06105614f, -0.14677985f, -0.13754697f, -0.05378752f, 0.04985025f, 
    0.08597313f, 0.03708075f, -0.09482754f, -0.15120368f, -0.09355935f, -0.15251701f, 0.19583853f, -0.22687013f, 
    -0.10848679f, 0.15548468f, 0.13647412f, -0.01503104f, 0.11085695f, 0.07086641f, -0.02065403f, 0.10715685f, 
    0.00474656f, -0.05993617f, -0.03668159f, 0.41612571f, -0.21903692f, -0.03498537f, 0.10220022f, 0.29765499f, 
    0.28278759f, 0.08498274f, -0.19878830f, -0.04142020f, 0.19328088f, -0.26908836f, -0.34258962f, 0.13647595f, 
    -0.03733100f, 0.15316354f, 0.15576714f, -0.17322131f, 0.17023784f, -0.09176785f, 0.06074035f, -0.14949432f, 
    0.15088443f, 0.16922840f, -0.02026172f, 0.08483730f, -0.14074032f, 0.13927907f, -0.17488445f, -0.03431872f, 
    0.12528951f, -0.10557410f, -0.13618220f, -0.07919304f, -0.02106552f, 0.04162547f, 0.17554152f, 0.06812762f, 
    0.03032057f, 0.16264233f, -0.16091791f, -0.10004266f, -0.14221899f, -0.12504749f, -0.14561909f, -0.08407179f, 
    -0.14610797f, 0.14025483f, -0.15082480f, 0.06365796f, 0.01565368f, -0.10849509f, 0.06969222f, -0.02819499f, 
    0.04937550f, -0.06596967f, -0.10967682f, -0.05816529f, -0.03000438f, 0.15988253f, -0.00138235f, 0.48624170f, 
    0.02705575f, -0.09988574f, -0.08561186f, -0.38309571f, -0.19684009f, 0.21385418f, -0.08142354f, 0.04493498f, 
    0.38247499f, -0.04173018f, 0.29156592f, -0.37155870f, -0.26419538f, 0.18256103f, 0.15584801f, -0.14156598f, 
    0.18055849f, -0.14587988f, -0.03512027f, -0.22853801f, -0.08035202f, 0.00100833f, 0.19987139f, 0.55302185f, 
    0.08040570f, -0.17217432f, 0.03708307f, -0.00857255f, 0.03840329f, 0.01900790f, 0.02463846f, 0.04579603f, 
    0.12466190f, 0.13125549f, 0.15034918f, 0.21714427f, 0.08477703f, -0.14799958f, -0.13303016f, 0.00996003f, 
    0.28511626f, -0.11638225f, -0.21423925f, 0.31418663f, -0.02548948f, 0.49527279f, -0.38337746f, -0.00268286f, 
    -0.15363279f, 0.10468208f, 0.03691087f, -0.13261907f, 0.10122635f, -0.08803525f, -0.08894143f, 0.61845887f, 
    0.11023068f, 0.10951605f, -0.03104952f, -0.08870144f, -0.00840707f, 0.17563073f, -0.08906136f, 0.15689884f, 
    0.14728738f, -0.15707545f, -0.00926296f, 0.01581351f, 0.27982095f, -0.29342222f, -0.09327386f, 0.10076450f, 
    0.11693022f, -0.15950722f, -0.30946636f, -0.24373327f, 0.16218781f, 0.11043855f, 0.04383186f, 0.05316287f, 
    0.06612132f, 0.04457977f, -0.11597226f, -0.26874775f, 0.07309926f, 0.09607127f, 0.02173326f, -0.67700946f, 
    0.14490966f, 0.02554619f, 0.10014156f, -0.04689857f, 0.12465937f, -0.00455168f, -0.03475117f, 0.00818071f, 
    -0.01559092f, 0.35165742f, -0.01842380f, -0.21126814f, -0.33946344f, 0.16217235f, 0.04035142f, 0.20430769f, 
    0.12866445f, -0.06388570f, 0.33262354f, 0.26727942f, 0.23462412f, -0.09224331f, 0.23240755f, 0.13996610f, 
    -0.09264514f, -0.12851200f, 0.04475011f, 0.12716186f, 0.08494978f, -0.01804800f, 0.00462108f, 0.10700990f, 
    -0.08081892f, -0.02444418f, 0.07620668f, 0.07883711f, 0.01156370f, -0.38167331f, -0.07490928f, 0.08153614f, 
    0.03099138f, -0.37714532f, -0.01707712f, -0.07178090f, 0.15868461f, 0.47562781f, 0.13961801f, -0.10536282f, 
    0.28765202f, 0.10449921f, -0.02661097f, -0.01964793f, 0.00080390f, 0.20093773f, -0.18406367f, 0.00670894f, 
    0.09753556f, -0.16194515f, -0.07537110f, 0.09328248f, 0.05445160f, -0.06200162f, -0.12508170f, -0.30812442f, 
    0.11717365f, -0.01067565f, -0.02740274f, -0.05417191f, -0.11595552f, 0.18816243f, 0.15287659f, -0.15589929f, 
    -0.15342692f, 0.37417480f, 0.05033777f, 0.26881191f, -0.29256177f, -0.00489672f, 0.00998804f, 0.11674252f, 
    0.29988360f, 0.05660317f, 0.44188094f, -0.16315530f, -0.20412999f, -0.09355810f, -0.00313004f, -0.07938100f, 
    0.02632958f, 0.01551335f, 0.07900269f, -0.27425188f, 0.14906801f, 0.08883926f, 0.21549669f, -0.36706266f, 
    0.08081254f, 0.10457533f, -0.14658025f, -0.09114500f, 0.13273896f, 0.03684062f, -0.02651500f, -0.10646585f, 
    0.04712572f, -0.04086462f, -0.05517874f, 0.47215343f, -0.21798353f, 0.38090441f, -0.03486629f, 0.35237589f, 
    0.32943073f, -0.13647994f, 0.27640837f, 0.47344172f, 0.00999084f, -0.28310210f, -0.43361008f, -0.06357171f, 
    0.16352600f, 0.01734134f, 0.01229528f, -0.07364976f, -0.02231682f, 0.14558458f, -0.02357929f, 0.53909868f, 
    -0.03159557f, 0.13292623f, 0.00958318f, -0.03188188f, -0.14621577f, -0.31049782f, 0.10941274f, -0.10100680f, 
    -0.15047154f, -0.03375454f, 0.15397079f, 0.30908108f, 0.12166090f, 0.35853192f, 0.12971297f, -0.28893998f, 
    0.05722699f, -0.02327702f, 0.03020618f, 0.35480526f, 0.02954053f, 0.14641525f, -0.15102953f, 0.02689006f, 
    0.01030374f, 0.04329013f, 0.06521473f, -0.24680777f, 0.11758994f, 0.10531271f, -0.14586064f, -0.14386842f, 
    -0.00922598f, 0.17332023f, -0.17687657f, -0.08009810f, -0.10735998f, 0.39587072f, 0.03954929f, 0.24059151f, 
    0.00895208f, -0.00917342f, -0.12171076f, 0.35774219f, 0.09097502f, -0.02326571f, 0.08705200f, 0.12841378f, 
    -0.06522247f, 0.04562904f, 0.11837601f, 0.33417737f, 0.24359019f, -0.23235412f, -0.48217431f, 0.14774528f, 
    -0.10412037f, -0.17155863f, 0.04589126f, -0.12969577f, -0.15068391f, -0.16202319f, 0.45417914f, 0.47577304f, 
    -0.04595935f, -0.09414496f, 0.02757472f, -0.01101851f, 0.12047257f, -0.22147383f, -0.02751504f, -0.00920132f, 
    0.05710070f, -0.01827609f, -0.14082228f, 0.00330157f, 0.02791505f, 0.53624988f, -0.09085624f, 0.04157097f, 
    0.06650029f, -0.07435627f, 0.26469737f, 0.21235462f, -0.14359777f, 0.30979434f, -0.24709181f, -0.14581349f, 
    -0.11633930f, 0.09836183f, 0.12927464f, 0.39351389f, -0.16534673f, -0.06706757f, -0.35504332f, -0.29197189f, 
    0.00692070f, 0.03543093f, 0.01651733f, -0.03825385f, -0.06884402f, -0.21561323f, -0.16455959f, 0.33504567f, 
    -0.05999241f, 0.23190792f, -0.08017631f, 0.14125729f, 0.17326632f, -0.18024875f, -0.04442096f, -0.42712501f, 
    -0.08049453f, 0.08383907f, 0.10422566f, -0.52160126f, 0.20671174f, 0.07690934f, 0.46207020f, -0.16211466f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.16418611f, 0.12433864f, -0.26021931f, 0.06573755f, 0.09825034f, 0.10411898f, -0.07789979f, 0.24570964f, 
    0.01837871f, -0.17254429f, 0.00507886f, 0.05829713f, 0.29822001f, -0.01134980f, 0.21794103f, 0.29009134f, 
    0.08235748f, 0.15292396f, 0.12745181f, 0.21516678f, -0.06280987f, -0.21801381f, 0.17382756f, 0.23617265f, 
    -0.13179453f, 0.11858939f, -0.15605171f, 0.31937486f, 0.14000541f, 0.19292146f, 0.05569904f, -0.19296651f, 
    -0.10310045f, 0.01560357f, 0.41207349f, 0.15166315f, 0.11030003f, 0.00501661f, -0.13736211f, 0.05256205f, 
    -0.11705168f, 0.22961135f, 0.15427819f, 0.17691568f, -0.09994236f, -0.04537285f, -0.13682960f, -0.11810447f, 
    0.04714216f, 0.04009868f, -0.16952527f, 0.03997226f, -0.16157918f, -0.03831597f, 0.28845766f, 0.06382027f, 
    0.12686895f, -0.22034790f, -0.11660208f, -0.17576748f, -0.14557154f, 0.07369706f, 0.09593500f, 0.14443365f, 
    0.14695705f, 0.05942708f, 0.20777446f, 0.03901443f, 0.38639444f, -0.07416102f, 0.11068651f, 0.05213845f, 
    0.14937092f, -0.09757900f, 0.02692786f, -0.11653502f, 0.12760094f, 0.11199149f, 0.08292063f, 0.05222474f, 
    -0.17941625f, 0.09524843f, -0.00753251f, 0.02337518f, -0.19228187f, -0.05217410f, 0.23293562f, 0.00610605f, 
    0.16932854f, 0.06070733f, -0.05509009f, 0.11730745f, 0.20608632f, -0.04388350f, 0.23116873f, 0.08640262f, 
    0.19924712f, 0.01986271f, -0.08319465f, 0.13274072f, 0.13888928f, 0.17314710f, 0.03038247f, 0.13232440f, 
    0.03712758f, -0.11630771f, -0.26040980f, -0.21004015f, 0.27379429f, -0.14389968f, -0.01630702f, -0.02665150f, 
    0.20319355f, 0.36618340f, 0.14530043f, -0.02011175f, -0.10653511f, 0.10711376f, -0.02008935f, -0.10381377f, 
    0.11661141f, 0.20267387f, 0.03171727f, 0.03400003f, 0.20686111f, -0.02382011f, -0.01740073f, 0.17970788f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.19128175f, -0.07625201f, -0.38104063f, -0.04933428f, -0.56443107f, 0.10573618f, -0.37257180f, 0.11620333f, 
    -0.12522472f, 0.03597967f, 0.00671928f, 0.01871938f, 0.20042343f, -0.05180256f, 0.10355480f, -0.00828326f, 
    -0.18491761f, 0.18311407f, -0.09666987f, -0.06857130f, 0.13591228f, -0.02864596f, -0.47410738f, 0.29714864f, 
    -0.06134299f, -0.42406067f, -0.12320777f, -0.18532230f, -0.52650023f, -0.26968616f, 0.15908732f, 0.27440119f, 
    -0.35640773f, 0.10313349f, 0.02160865f, -0.21689846f, 0.25329718f, 0.24205370f, -0.09283715f, -0.55052173f, 
    -0.07193634f, -0.09479000f, 0.08728331f, 0.17155284f, -0.55124778f, -0.18698956f, -0.12423503f, 0.08265782f, 
    -0.41945496f, 0.09519657f, -0.38753745f, -0.25802046f, -0.03600563f, -0.10115479f, 0.17466591f, 0.26829973f, 
    -0.04514996f, -0.07555768f, -0.04130339f, 0.00607981f, 0.20827867f, 0.51597911f, -0.24156311f, 0.07346695f, 
    -0.00993226f, -0.30336982f, 0.18334143f, 0.00464201f, -0.30934966f, 0.06070445f, -0.04511384f, -0.05064979f, 
    -0.48976257f, -0.01494370f, 0.07975940f, -0.05564380f, -0.06075495f, -0.72168452f, -0.25610021f, 0.36536038f, 
    -0.07598542f, 0.24297544f, -0.11739440f, -0.14236109f, 0.01418435f, 0.10883955f, 0.08463033f, -0.15835609f, 
    0.26341319f, 0.12148948f, -0.02059076f, -0.06492843f, -0.21379195f, 0.19041812f, -0.55222505f, 0.06302147f, 
    -0.45067528f, -0.03404011f, -0.24194543f, 0.04489300f, 0.15119632f, -0.03771677f, 0.11716857f, -0.54691505f, 
    -0.06803233f, 0.09142016f, -0.07668209f, 0.20784886f, 0.02751292f, -0.09864786f, 0.07278517f, 0.14093688f, 
    0.17923863f, 0.08066819f, -0.03852902f, 0.26441276f, 0.08180147f, -0.72577441f, 0.07118806f, 0.00585929f, 
    -0.26405445f, -0.14475359f, 0.11709663f, 0.10732319f, 0.08885895f, 0.19363716f, -0.26823631f, 0.15621901f, 
    0.13999550f, 0.29110515f, -0.14784357f, -0.58637971f, 0.12552428f, 0.13816620f, -0.19162752f, -0.03802310f, 
    0.02891122f, 0.05346355f, -0.05244771f, 0.11152919f, -0.03668868f, 0.22726460f, 0.16719699f, -0.47729379f, 
    -0.17699455f, 0.14980260f, 0.06165175f, 0.12284508f, -0.10988475f, -0.05305412f, -0.19383255f, -0.32774994f, 
    0.02987471f, 0.11134023f, -0.05449745f, 0.04465905f, 0.27057660f, 0.06212835f, 0.31287313f, -0.29838324f, 
    0.22670151f, -0.08758836f, 0.10610491f, 0.03795230f, -0.12961338f, -0.04106913f, 0.18371084f, 0.48751917f, 
    0.26413679f, 0.04663228f, -0.01314814f, 0.04028443f, -0.34241512f, -0.01155842f, -0.08686516f, -0.04273300f, 
    -0.13110442f, -0.04201755f, 0.09403619f, -0.21856740f, -0.13249397f, -0.05061315f, 0.13755079f, 0.19740804f, 
    0.16915728f, -0.27282038f, 0.10442215f, -0.04063694f, 0.01512626f, 0.00438391f, -0.10724469f, 0.02426076f, 
    0.05140759f, -0.16351981f, -0.39783370f, 0.06224464f, 0.13118553f, -0.47396353f, -0.48517007f, 0.12580517f, 
    -0.05004654f, 0.33793777f, 0.23268642f, -0.06029940f, -0.08151355f, -0.16858687f, -0.38373935f, -0.12990807f, 
    -0.08710013f, 0.17153981f, -0.12423111f, 0.06278202f, -0.00542011f, 0.25625390f, 0.03536038f, 0.11032302f, 
    -0.06938806f, 0.08162035f, 0.15477367f, -0.21410747f, -0.11279461f, 0.29288599f, -0.33169237f, 0.05206191f, 
    -0.49053109f, -0.76233798f, -0.30308479f, -0.06865755f, 0.09081012f, -0.18530491f, -0.10829843f, 0.04196678f, 
    0.14711528f, -0.04765600f, -0.04427000f, 0.13179778f, 0.22213343f, -0.46869060f, -0.41385856f, -0.07418999f, 
    0.02530098f, 0.28965241f, -0.00072309f, -0.22839169f, 0.07056363f, -0.24564563f, 0.12781005f, 0.17681018f, 
    -0.98201233f, 0.05123074f, -0.36994636f, -0.18070601f, 0.25458220f, -0.10623742f, 0.13525401f, -0.20602092f, 
    -0.25409642f, 0.03158214f, -0.56062490f, -0.41932279f, 0.19001086f, 0.17179848f, 0.28914562f, 0.07352193f, 
    0.16672800f, -0.06388748f, -0.30820036f, -0.04879078f, -0.44463786f, -0.45943731f, -0.01345008f, -0.35583988f, 
    0.01064432f, 0.21738440f, 0.34037998f, 0.07509749f, -0.45231092f, 0.01077356f, -0.17878975f, -0.33651605f, 
    0.02279879f, -0.17046990f, 0.05507641f, -0.43437254f, -0.43571460f, 0.33137104f, -0.23384811f, 0.35162035f, 
    0.08459641f, -0.04378626f, -0.17859194f, -0.32783294f, -0.48082098f, -0.26866093f, -0.03912793f, -0.35938561f, 
    0.08187068f, 0.07024676f, -0.02592560f, -0.16407432f, 0.10868111f, 0.49152508f, 0.21398206f, 0.03945650f, 
    -0.31415138f, 0.03085000f, 0.01566434f, 0.02240174f, -0.13948470f, -0.21738856f, -0.21231143f, 0.02416800f, 
    -0.34948671f, -0.06012810f, 0.18053475f, 0.05730305f, 0.06828339f, -0.58629352f, 0.13057037f, 0.01189311f, 
    -0.03985413f, 0.03519314f, -0.03131861f, -0.27211726f, -0.09111048f, -0.34981206f, -0.12326829f, 0.12483590f, 
    0.24640658f, 0.03647675f, -0.18549477f, 0.02895933f, -0.04993659f, 0.04182013f, -0.36516547f, 0.49703518f, 
    0.08032617f, 0.03880388f, -0.41527304f, 0.18955338f, -0.07065281f, 0.23395035f, -0.01192700f, -0.06701728f, 
    -0.11600518f, 0.26203677f, 0.13297448f, 0.18510377f, -0.09491366f, -0.26803866f, 0.01901762f, 0.05569012f, 
    0.19634835f, 0.14093229f, -0.15023138f, 0.10405213f, 0.24329565f, -0.12066595f, -0.25733271f, -0.03590055f, 
    0.06390198f, 0.27660039f, 0.14373502f, 0.28064814f, -0.09173000f, 0.03609537f, 0.12276914f, -0.40596819f, 
    -0.04396535f, 0.06656978f, 0.04032916f, -0.37962323f, -0.07630917f, -0.16764404f, -0.80334425f, -0.33948332f, 
    0.04229083f, -0.03041793f, 0.15515189f, -0.29481804f, -0.19329162f, -0.27359185f, -0.39712456f, 0.28537583f, 
    -0.62573457f, 0.13606952f, -0.00290004f, 0.23976207f, -0.17454389f, -0.53382331f, 0.17818764f, 0.04926174f, 
    0.20353366f, -0.00778733f, 0.32261980f, -0.54168797f, -0.15068839f, -0.20876512f, 0.21999298f, 0.06408430f, 
    -0.02732746f, 0.13520153f, -0.23049790f, -0.59179670f, 0.21746849f, -0.06761584f, -1.14265335f, 0.18482488f, 
    -0.01654142f, 0.38338396f, 0.06697418f, 0.05567310f, 0.18391639f, 0.32609195f, -0.11181754f, -0.24732973f, 
    -0.04224339f, -0.53574955f, -0.17848042f, 0.03206206f, 0.17629966f, 0.04571227f, -0.33254907f, 0.28905138f, 
    -0.40373746f, -0.34009159f, -0.04319535f, -0.06856434f, 0.38935408f, -0.12043240f, -0.32782030f, 0.08319924f, 
    -0.10298111f, 0.37833843f, -0.12756360f, -0.50129050f, -0.00130441f, 0.09462584f, -0.45381987f, -0.45159286f, 
    -0.46704969f, 0.17214423f, 0.03114445f, 0.03267176f, -0.61508161f, -0.10031165f, -0.39221570f, -0.04043990f, 
    0.05161588f, 0.25631160f, 0.20123950f, -0.11907110f, -0.56332916f, 0.01510618f, 0.25409588f, -0.27630234f, 
    -0.41739607f, -0.23125142f, -0.09130801f, -0.05126930f, -0.04314720f, 0.10390480f, 0.21126813f, -0.18808226f, 
    0.01066300f, -0.39468342f, 0.37348482f, 0.18719839f, 0.01294710f, 0.21030296f, -0.18953855f, -0.25396001f, 
    -0.04489158f, -0.37226403f, 0.11682244f, -0.06888726f, 0.18681072f, 0.11349311f, 0.14406417f, 0.02378029f, 
    0.16021271f, -0.15873170f, -0.14638543f, 0.12727566f, -0.26658848f, 0.00171359f, 0.14070107f, -0.24418247f, 
    -0.49855819f, -0.00530666f, 0.48763385f, -0.18867612f, -0.54491854f, -0.05282743f, 0.26288721f, 0.00036688f, 
    -0.18775654f, -0.14758871f, 0.02120890f, -0.15976867f, -0.05406361f, 0.06507140f, 0.08137724f, 0.11252077f, 
    0.02104180f, -0.73840648f, 0.15818979f, -0.42648774f, -0.51305860f, 0.14696434f, -0.30439001f, -0.03007162f, 
    -0.08525221f, -0.09910462f, -0.03228392f, 0.32052028f, -0.64350617f, 0.03936363f, -0.00719246f, 0.02669124f, 
    0.08553485f, 0.01983232f, 0.03843661f, -0.12898633f, -0.00060867f, -0.08247378f, -0.25857368f, 0.04402852f, 
    -0.30609274f, 0.03970500f, -0.04797335f, 0.10734295f, 0.20003894f, 0.02869091f, -0.42391312f, -0.21270268f, 
    -0.04292114f, 0.24614608f, -0.01359346f, 0.21306022f, -0.51446742f, 0.02716075f, -0.01331740f, -0.05889388f, 
    -0.38861650f, -0.23312761f, 0.15163261f, -0.14950940f, 0.19098210f, 0.06577822f, 0.01108849f, -0.21979222f, 
    0.07602178f, -0.19166759f, -0.00483105f, -0.03538313f, -0.11304972f, 0.23283352f, -0.06680412f, 0.03941661f, 
    0.17843921f, -0.05573600f, 0.19871815f, 0.02793097f, -0.61542654f, 0.35265362f, 0.07918049f, -0.49247265f, 
    0.17252333f, 0.17877977f, -0.11895461f, 0.02453061f, 0.11657210f, -0.04579752f, -0.52140158f, -0.01670505f, 
    0.00538751f, 0.04742383f, 0.19170946f, 0.18475576f, -0.14214993f, 0.02624182f, -0.05716402f, -0.22168769f, 
    -0.05402724f, 0.00785160f, 0.02092991f, -0.03062941f, 0.04024249f, 0.05924776f, 0.16648990f, -0.15397492f, 
    -0.01582475f, -0.06068302f, 0.03316414f, 0.18251315f, -0.08006863f, -0.18915768f, 0.10586905f, 0.09184468f, 
    -0.45396623f, -0.13979766f, -0.22129846f, -0.00936330f, 0.29780680f, -0.39303237f, -0.32204717f, 0.01254109f, 
    0.10861395f, 0.03785983f, -0.42399129f, 0.11673527f, -0.21708964f, -0.06626419f, -0.25739735f, -0.25163677f, 
    -0.43074164f, 0.10787092f, -0.08753417f, -0.31651035f, -0.34547094f, -0.00963507f, 0.07381930f, 0.13029169f, 
    -0.14355232f, -0.37424204f, 0.00195588f, 0.22588061f, 0.07078137f, 0.19933622f, 0.01891492f, -0.27024069f, 
    0.18908006f, -0.05303675f, 0.33596954f, 0.35426617f, -0.16387230f, -0.01193104f, 0.20601827f, -0.38354734f, 
    0.22268835f, 0.05431798f, 0.62807226f, -0.31129152f, 0.24834728f, -0.26070121f, -0.07453636f, -0.02204744f, 
    -0.19657098f, 0.06972836f, -0.03153494f, 0.17394072f, 0.17009574f, 0.13948077f, -0.16754377f, 0.15370493f, 
    0.32673258f, -0.16777876f, -0.03843763f, -0.04092691f, 0.04524529f, 0.03457418f, 0.82600892f, -0.33096212f, 
    0.03517779f, -0.29611447f, -0.06684988f, -0.03897203f, 0.33229923f, -0.25661570f, -0.44725198f, -0.14454088f, 
    0.15258002f, 0.17421867f, -0.00889748f, 0.25462765f, -0.41115564f, 0.16718645f, 0.01911465f, -0.58082795f, 
    -0.02723889f, -0.02670577f, 0.01472356f, -0.15444829f, -0.01621692f, -0.32216811f, 0.06056668f, -0.01250044f, 
    0.10820196f, -0.28683361f, 0.03447183f, 0.16289680f, 0.23658648f, 0.12703656f, 0.15831754f, -0.09381232f, 
    0.30374211f, 0.09610558f, 0.04464828f, -0.01756885f, -0.08729887f, 0.14884241f, 0.09492439f, 0.00294475f, 
    0.02880928f, -0.05102284f, -0.14714627f, 0.18509585f, 0.16366246f, -0.11977187f, 0.09866064f, -0.05014797f, 
    0.19525477f, 0.05897949f, 0.14056623f, -0.02785259f, 0.03329142f, -0.38758618f, -0.61383194f, -0.62179869f, 
    -0.03950007f, -0.08557150f, -0.40508425f, -0.31638709f, 0.04538613f, -0.34379819f, -0.02862686f, 0.01136878f, 
    -0.15801193f, -0.21834706f, -0.14447914f, -0.09810758f, -0.14462999f, -0.05375176f, 0.04927455f, -0.07181314f, 
    -0.16024052f, 0.02563172f, 0.36524862f, -0.11417550f, -0.15034401f, -0.13639973f, 0.03207665f, 0.29316199f, 
    0.11452493f, -0.03985711f, -0.10303029f, -0.07931690f, 0.14886871f, -0.22369121f, -0.18792307f, 0.18871830f, 
    0.11553545f, 0.00415412f, 0.02510073f, 0.17500609f, 0.04356848f, -0.22611970f, 0.21828060f, 0.15559323f, 
    -0.31667605f, 0.21965237f, -0.56823659f, -0.05776795f, 0.04600456f, -0.03400462f, 0.06388037f, -0.06411449f, 
    -0.20694147f, 0.01888840f, -0.81117910f, -0.11344292f, 0.10357291f, -0.14863142f, 0.18404935f, 0.10894784f, 
    0.08098014f, -0.01240725f, 0.03474683f, 0.10564694f, 0.10558259f, -0.05964218f, 0.01855066f, 0.03179211f, 
    -0.39328051f, 0.04359628f, 0.19732124f, -0.19691624f, 0.18040757f, -0.08415786f, -0.97031897f, -0.20142248f, 
    -0.00612781f, -0.36996695f, -0.04513891f, -0.25159845f, -0.53256232f, 0.02559018f, -0.13887686f, -0.11402354f, 
    0.03427833f, 0.12669018f, 0.34097922f, 0.27133188f, -0.00583727f, 0.31306061f, 0.27669004f, 0.09151894f, 
    -0.41154519f, 0.10442679f, -0.03556954f, -0.46152851f, -0.65446478f, -0.29223555f, 0.11058640f, -0.04833182f, 
    -0.22908114f, 0.11599875f, 0.03136707f, 0.01870298f, -0.01420711f, 0.04211030f, 0.12905486f, -0.03105643f, 
    -0.13845243f, -0.01985872f, 0.14647621f, -0.10327067f, -0.17804022f, -1.08345783f, 0.27835545f, 0.05034842f, 
    0.08318245f, 0.16120830f, 0.15197547f, 0.18973540f, -0.15149322f, 0.10642856f, 0.08505770f, 0.08223691f, 
    0.34887582f, -0.34816393f, 0.00080321f, 0.06820370f, -0.01242512f, -0.24521019f, 0.14688224f, -0.39694279f, 
    0.07964189f, -0.30859831f, -0.02889350f, -0.32550842f, 0.00232169f, -0.31863642f, 0.10031120f, -0.03125534f, 
    0.05899882f, -0.41224644f, 0.02320519f, -0.08703066f, -0.09841835f, -0.54536790f, -0.13237225f, 0.01678419f, 
    0.29032338f, 0.33060232f, 0.11299204f, 0.07110215f, -0.32661602f, 0.13583528f, 0.17421345f, -0.19016622f, 
    0.08499488f, -0.52162468f, -0.09117867f, -0.20197792f, -0.14402963f, 0.12412036f, 0.24101697f, 0.11971132f, 
    -0.03811922f, 0.04946244f, -0.01180512f, 0.20218651f, 0.06871401f, -0.50217700f, -0.16807519f, 0.06602303f, 
    0.24292928f, -0.46021223f, -0.39505485f, -0.08846201f, -0.36514294f, -0.00323386f, -0.35394776f, -0.01752267f, 
    0.12574898f, -0.35372040f, 0.42080024f, 0.10529317f, -0.35631508f, -0.11616781f, -0.26800856f, -0.20298073f, 
    -0.00541015f, -0.01767469f, 0.17564189f, -0.33251458f, -0.35612631f, -0.02124654f, -0.41473946f, 0.04935465f, 
    0.00717258f, -0.13358217f, -0.41602156f, -0.06503319f, 0.16019623f, -0.08283029f, 0.20670354f, 0.18873654f, 
    -0.04524466f, 0.09306578f, -0.03799729f, -0.23869482f, 0.52789146f, -0.12408131f, -0.06612661f, 0.19673350f, 
    0.06589555f, -0.21948341f, -0.51391602f, -0.28382438f, 0.13532826f, -0.47248530f, 0.08778617f, -0.08360424f, 
    0.35359985f, -0.39347598f, -0.10101048f, 0.05018773f, 0.16018656f, 0.01103550f, -0.02578175f, 0.03574577f, 
    0.26180646f, -0.34317437f, 0.17111932f, 0.10891243f, -0.09566293f, 0.22139864f, -0.45966992f, -0.41569421f, 
    0.28062624f, 0.17573313f, 0.07290580f, 0.08571168f, 0.19031602f, 0.27717865f, -0.18541814f, 0.07496183f, 
    -0.04679010f, -0.13326234f, -0.19181749f, -0.01420226f, -0.12040742f, 0.08745454f, 0.10471968f, -0.36354226f, 
    -0.04335619f, 0.10738674f, -0.02595091f, 0.03250677f, -0.05899562f, 0.31869191f, 0.24935415f, -0.41768235f, 
    -0.01780697f, 0.12670331f, -0.32021084f, 0.24099797f, 0.01654813f, 0.31677014f, -0.38085774f, -0.02380924f, 
    -0.35610673f, 0.02965392f, -0.34444156f, -0.34643024f, 0.01572939f, 0.09534126f, -0.29015326f, 0.02459862f, 
    -0.29435191f, -0.03701243f, 0.19065592f, -0.31690368f, -0.21947420f, -0.33953393f, 0.01090637f, -0.03852037f, 
    -0.32417914f, 0.17936194f, 0.23079115f, 0.14905091f, -0.17414548f, 0.04484141f, 0.01232418f, 0.10665308f, 
    -0.60144919f, -0.45835960f, -0.05706219f, 0.13117081f, -0.06388245f, 0.35021719f, 0.11335949f, 0.02583798f, 
    -0.06754527f, 0.21820973f, 0.10161783f, 0.07757044f, -0.07633592f, -0.27223718f, 0.06331275f, -0.25326478f, 
    0.18377350f, -0.07826154f, -0.45249203f, -0.52513236f, 0.17126989f, 0.03337692f, -0.05472819f, -0.54544419f, 
    -0.38496643f, 0.02333993f, -0.47821864f, 0.12846519f, -0.16687219f, 0.20605724f, 0.06212512f, -0.29269564f, 
    0.02736946f, -0.46313757f, -0.33559826f, 0.22941847f, -0.37335083f, -0.05669444f, 0.16414377f, -0.21731292f, 
    -0.03668883f, 0.01818047f, -0.00548527f, 0.35215962f, -0.01494735f, -0.28863198f, 0.14056994f, -0.02323098f, 
    0.01339753f, 0.21302155f, -0.62576568f, -0.44847247f, -0.32336611f, -0.40690640f, 0.01507982f, 0.41567296f, 
    0.15608162f, 0.04122540f, -0.03046567f, 0.22416691f, -0.55655819f, -0.12547797f, 0.08936269f, -0.01175888f, 
    0.34462959f, -0.37714157f, 0.05112314f, 0.13890530f, 0.03447540f, -0.31685507f, 0.00075783f, 0.18101463f, 
    0.01232820f, 0.13926339f, -0.35987771f, -0.04722925f, 0.03429817f, -0.84181923f, -0.01861688f, -0.02221201f, 
    0.04995487f, -0.59502220f, -0.69022751f, -0.52336502f, 0.27897206f, -0.25490874f, -0.03790759f, 0.18434222f, 
    -0.40967834f, -0.09619109f, -0.23266932f, 0.00647025f, 0.00815865f, 0.16870458f, -0.16606808f, -0.05016385f, 
    0.01157561f, -0.08597269f, 0.44384411f, -0.17669210f, -0.00834071f, -0.06584563f, -0.12840791f, 0.19741623f, 
    0.10103632f, 0.22126129f, 0.15080942f, 0.02338746f, 0.10472362f, -0.38310811f, 0.21400997f, -0.06053201f, 
    -0.08166509f, -0.40178949f, -0.09668641f, -0.10445640f, 0.15162392f, 0.23016076f, -0.06918665f, -0.12158065f, 
    -0.07895802f, -0.16023484f, 0.13922539f, -0.18330362f, 0.21216999f, -0.43362707f, -0.46437207f, -0.05080872f, 
    0.17448288f, -0.02376757f, 0.02111439f, -0.17230497f, 0.00658489f, -0.20906273f, -0.05092285f, -0.32309744f, 
    0.09222979f, 0.23358627f, -0.63341463f, 0.17316651f, 0.24057603f, 0.15769750f, 0.40184918f, -0.21191359f, 
    0.11496364f, -0.51645374f, 0.12379966f, 0.00634998f, 0.00892534f, -0.16557254f, -0.19242755f, -0.36899641f, 
    -0.19419263f, 0.03336611f, -0.17217635f, 0.02445379f, 0.05832049f, 0.10532250f, 0.01205934f, 0.32585883f, 
    -0.02511911f, -0.20342317f, 0.19093756f, -0.06733232f, -0.11470605f, -0.01645431f, -0.40001667f, 0.27945271f, 
    -0.01503549f, -0.30362576f, -0.01229588f, -0.02173986f, 0.09562854f, -0.53134298f, -0.31967801f, 0.41643387f, 
    -0.16768585f, 0.09457336f, 0.07222360f, -0.12238719f, -0.08803350f, 0.09364122f, -0.25476140f, -0.08763032f, 
    -0.44194901f, 0.00198274f, 0.04164144f, -0.05280498f, -0.20210324f, 0.44605681f, 0.22382045f, 0.04465660f, 
    -0.11814556f, -0.42553079f, -0.51566797f, 0.02315786f, -0.29341304f, 0.03932331f, 0.20806187f, 0.25630251f, 
    -0.12989393f, 0.26399684f, -0.08594944f, 0.01755316f, 0.12952928f, -0.13802816f, 0.01117273f, 0.00288137f, 
    -0.06378891f, -0.16659638f, 0.27012783f, -0.17652278f, 0.19375581f, 0.18763009f, 0.19512348f, -0.27887595f, 
    0.24920233f, -0.08925284f, -0.73098516f, -0.05952979f, -0.10780974f, -0.38619134f, 0.00947982f, 0.35565498f, 
    0.01939471f, -0.15983160f, 0.17141448f, -0.58826137f, 0.00961899f, -0.78111845f, -0.14744920f, 0.17097281f, 
    0.09487333f, 0.07818960f, -0.09672412f, 0.22182234f, -0.45995465f, -0.30302238f, 0.18337843f, -0.03740067f, 
    -0.16910578f, 0.02231497f, -0.28970358f, 0.04952142f, 0.05447414f, 0.12040634f, 0.36822200f, 0.65108162f, 
    -0.00647308f, -0.29614621f, -0.06350208f, -0.26610646f, 0.21603401f, -0.00491866f, 0.28455126f, -0.03864506f, 
    0.34204552f, -0.51566482f, -0.04020203f, 0.14503759f, 0.01076995f, -0.40379757f, 0.02938616f, -0.31590962f, 
    0.38335952f, -0.19095519f, 0.04580164f, 0.29321617f, 0.08721057f, 0.14233032f, -0.08766367f, -0.20426300f, 
    -0.22359072f, 0.11678776f, -0.13437164f, -0.13750088f, 0.36261874f, -0.26067221f, 0.15316708f, 0.18438748f, 
    0.14928517f, -0.07765745f, -0.11744673f, 0.09973498f, 0.10626842f, -0.68789309f, 0.03547749f, 0.31331620f, 
    -0.08969478f, 0.17198808f, -0.18324499f, 0.16371870f, -0.18005578f, 0.00025732f, -0.24398507f, -0.11921120f, 
    0.04837667f, -0.10794534f, 0.00864645f, 0.19416305f, 0.22041830f, 0.01261635f, 0.27449664f, -0.20336425f, 
    -0.45304948f, -0.09385297f, -0.50446117f, 0.17869258f, -0.10010257f, -0.16566573f, -0.49800271f, -0.29181245f, 
    -0.05720386f, -0.09808344f, 0.01881101f, 0.07959747f, 0.08712589f, -0.02747859f, -0.25718063f, 0.00491225f, 
    -0.13478197f, 0.20070390f, -0.01309204f, -0.05332850f, -0.14250924f, -0.02091260f, -0.06175523f, -0.07061074f, 
    0.05103710f, -0.08308855f, -0.12056976f, 0.06805427f, -0.80920720f, -0.01385237f, -0.01408342f, 0.00612699f, 
    0.04497204f, 0.12797567f, -0.23814517f, -0.06093686f, 0.14279757f, 0.05282336f, 0.11643373f, 0.15834813f, 
    -0.62952924f, -0.28428811f, -0.07309899f, 0.03748954f, 0.02010061f, 0.32559001f, -0.20146945f, -0.41132969f, 
    0.01244057f, -0.01525203f, 0.03783018f, 0.10310361f, 0.00504417f, 0.35286853f, 0.08323071f, -0.23971491f, 
    0.22389032f, -0.07431428f, -0.13376257f, -0.22061351f, 0.40106967f, 0.25492498f, -0.04922555f, -0.02632389f, 
    0.12628476f, 0.16504192f, 0.22242413f, 0.17221238f, 0.11919115f, -0.34920704f, -0.41640130f, 0.01443589f, 
    0.19558109f, -0.02299135f, 0.15824489f, -0.39986646f, 0.07017930f, -0.35923949f, -0.10522772f, -0.92095637f, 
    0.23779933f, 0.13891934f, -0.05667265f, -0.55206972f, 0.08669713f, 0.08400790f, 0.00912181f, -0.14337707f, 
    -0.02813180f, 0.05911814f, 0.01803051f, -0.70574784f, 0.14198594f, -0.55185759f, 0.12385541f, 0.29819801f, 
    -0.08700529f, 0.12106632f, -0.33487824f, -0.30811176f, -0.21820448f, 0.16078754f, 0.34686568f, 0.09644141f, 
    0.10722561f, 0.05705895f, 0.13114291f, -0.26791951f, -0.06538849f, -0.20482078f, 0.12459911f, -0.39039835f, 
    -0.21228282f, -0.03244654f, -0.05361914f, -0.06906071f, -0.11193594f, 0.00439850f, 0.19989641f, 0.22691903f, 
    -0.07772484f, 0.01647869f, -0.04704210f, -0.20215036f, -0.16158296f, 0.07609409f, 0.00729130f, -0.02039515f, 
    0.23377278f, 0.08201448f, 0.08219091f, 0.04992071f, 0.33189180f, -0.04604541f, -0.81408238f, 0.00220578f, 
    0.01988567f, 0.13994022f, -0.05723280f, 0.16180226f, 0.13528749f, -0.58625865f, -0.09517659f, -0.05383766f, 
    0.30224121f, 0.30634716f, -0.41510075f, 0.16410078f, 0.22632685f, -0.69280046f, -0.16440205f, -0.09567126f, 
    -0.24167708f, -0.35349181f, 0.13325170f, 0.04082833f, -0.20159565f, -0.19117250f, 0.24605140f, -0.03992752f, 
    0.01475684f, -0.01002106f, 0.03856463f, -0.10545176f, -0.23806843f, -0.19504331f, 0.10019783f, 0.10829259f, 
    -0.04732039f, -0.72468603f, 0.06746110f, -0.07983759f, -0.01816510f, 0.05054228f, 0.16408169f, -0.16141810f, 
    -0.07440543f, -0.24776259f, -0.05120365f, 0.02402554f, 0.04715967f, -0.58663195f, -0.18519300f, -0.57426941f, 
    0.20991783f, -0.14568068f, 0.18547955f, 0.17863941f, -0.31286830f, 0.10391210f, 0.31066543f, -0.07763448f, 
    0.26178572f, 0.10347717f, 0.20736900f, -0.48433173f, -0.03677343f, 0.39540961f, 0.17754857f, -0.28261596f, 
    -0.07054184f, -0.43528637f, -0.51724160f, 0.12579373f, -0.12989062f, 0.23590955f, -0.12471639f, 0.01941324f, 
    -0.39717501f, 0.22913103f, -0.01523916f, -0.09056240f, 0.05404346f, 0.15532190f, -0.32217944f, 0.09022959f, 
    0.02354592f, 0.13334171f, -0.18838088f, -0.27949476f, -0.13043813f, 0.08244734f, -0.25140935f, 0.28891852f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09581611f, 0.14024492f, -0.08506069f, -0.09875003f, 0.04992846f, 0.03991000f, 0.03543358f, -0.31795636f, 
    -0.11214645f, 0.11328173f, 0.14035457f, 0.06890859f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
