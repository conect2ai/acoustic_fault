#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.44542307f, 0.50564915f, 0.17128669f, -0.45684633f, -0.48330876f, 0.12225868f, -0.01014886f, -0.10550084f, 
    0.39910966f, 0.19714558f, -0.29260546f, 0.00706415f, 0.23429149f, -0.35913211f, -0.03602370f, -0.24055119f, 
    -0.06797629f, -0.18511137f, 0.30203703f, -0.11554895f, 0.06639515f, 0.28800920f, 0.16220970f, -0.30322868f, 
    0.00277872f, 0.68240857f, -0.44707823f, -0.76261884f, -0.39685360f, -0.03340407f, 0.67280763f, 0.17119005f, 
    0.09862865f, -0.30709210f, 0.23414633f, 0.33202451f, -0.02143772f, 0.12116729f, -0.16565013f, -0.24969210f, 
    -0.21339191f, -0.27120855f, 0.01536443f, -0.07236890f, -0.12726538f, 0.16873027f, 0.10510281f, 0.01747530f, 
    0.11700752f, 0.45438245f, 0.73598659f, 0.56073761f, 0.28398412f, -0.13774678f, -0.11466427f, -0.38497338f, 
    0.16604154f, -0.49269402f, -0.78630608f, -0.95547229f, -0.12798390f, 0.30644900f, -0.21812785f, -0.23136103f, 
    0.01929819f, -0.13328129f, -0.06677945f, 0.32156280f, 0.08333003f, 0.35761210f, -0.00728987f, 0.02661424f, 
    0.20902330f, -0.08856266f, -0.24124490f, 0.77884090f, 0.76927036f, 0.36254492f, -0.10824105f, -0.55359364f, 
    -0.31262395f, -0.10686716f, 0.08414893f, -0.12324639f, 0.24854136f, -0.01732577f, 0.21218874f, 0.00032562f, 
    -0.11905431f, -0.40921858f, 0.11087277f, 0.02144991f, -0.16516881f, 0.13320154f, -0.18204650f, -0.04604150f, 
    0.07840021f, -0.14145835f, -0.09110138f, 0.13920175f, 0.32125127f, 0.01509505f, -0.06173993f, -0.15429185f, 
    0.12283895f, 0.05250135f, -0.19918816f, -0.17071550f, 0.27018544f, 0.18714070f, 0.00184240f, 0.46103489f, 
    -0.33724031f, -0.10368195f, 0.04028800f, -0.33666658f, -0.14447038f, 0.00722764f, 0.04747570f, 0.05366660f, 
    -0.03055424f, 0.01135283f, 0.24445635f, 0.07835859f, -0.20603095f, -0.83566874f, -0.94362897f, 0.16094466f, 
    0.08011618f, 0.38098013f, 0.60507751f, 0.47883937f, -0.40579435f, -0.09045570f, 0.41174755f, 0.10468644f, 
    0.11387342f, -0.11642835f, 0.11118941f, -0.47349721f, -0.10218361f, 0.07347722f, -0.13512625f, -0.02650660f, 
    -0.06979980f, -0.18834321f, -0.28447172f, -0.17153701f, 0.21614070f, -0.06875367f, 0.01701662f, -0.16157290f, 
    0.08785361f, 0.47740966f, -0.25422636f, -0.31355041f, -0.59477150f, -0.13860965f, 0.21033205f, 0.42329597f, 
    -0.28789642f, -0.22851683f, -0.28213823f, 0.20601150f, 0.15571935f, 0.05108098f, -0.05084344f, -0.16935575f, 
    0.27170420f, -0.41367123f, -0.10955955f, -0.32062039f, -0.49488443f, -0.49744213f, -0.76330489f, -0.63814104f, 
    -0.20842576f, -0.23283274f, 0.31504190f, -0.14608428f, 0.19397579f, 0.51098686f, -0.17184958f, -0.36300781f, 
    0.21994595f, -0.09767623f, 0.36035943f, -0.33756357f, -0.13336912f, -0.48263261f, 0.08050788f, 0.43991584f, 
    -0.17866310f, -0.07246566f, 0.06296001f, -0.40023306f, -0.17132047f, -0.18421386f, 0.01672662f, -0.30984348f, 
    0.35897684f, -0.35155517f, -0.29660761f, 0.02648435f, 0.54487723f, -0.45325157f, -0.04711231f, 0.64420706f, 
    0.02212135f, -0.12108608f, -0.41845784f, -0.37132043f, 0.39738715f, -0.12739977f, -0.03054170f, 0.04567749f, 
    -0.14757675f, -0.04184226f, 0.04897084f, -0.13335724f, 0.08104595f, 0.03437641f, -0.15283687f, 0.08309422f, 
    -0.01949241f, -0.11975694f, 0.48741394f, 0.14150155f, -0.41572559f, -0.57171494f, -0.60129201f, -0.34529936f, 
    0.13524783f, 0.20766056f, 0.09292721f, 0.34350127f, 0.38788640f, 0.32498434f, 0.18867214f, -0.23382179f, 
    0.14025140f, 0.07007489f, 0.11252563f, -0.30525178f, -0.32348439f, -0.06665961f, -0.14432842f, 0.06900839f, 
    -0.15885575f, 0.14084879f, 0.60265714f, -0.13926619f, -0.18399394f, -0.32746339f, 0.05446161f, 0.33348688f, 
    0.09867711f, 0.09457710f, -0.16517380f, 0.07612985f, -0.06810617f, 0.59826577f, -0.33961183f, -0.28546873f, 
    0.30731881f, 0.09179997f, -0.20756297f, -0.06028165f, 0.01466342f, -0.16915211f, 0.21021791f, -0.22421230f, 
    0.06334084f, 0.03339557f, -0.00162259f, 0.01038151f, 0.22216466f, 0.38604167f, -0.09486900f, -0.15515091f, 
    -0.61651653f, 0.01832787f, 0.18226396f, 0.06536466f, -0.05097040f, 0.06508742f, -0.06337010f, -0.20253743f, 
    0.06461248f, -0.21079586f, 0.14577834f, -0.26509669f, 0.14969440f, 0.32802990f, -0.11934946f, -0.17876668f, 
    -0.00151383f, 0.02719876f, -0.00047883f, 0.09713636f, 0.53754401f, 0.61684161f, 0.83044785f, -0.48940760f, 
    -0.21474805f, -0.56141639f, -0.08045456f, 0.04509058f, -0.28848043f, -0.50450283f, 0.18129949f, -0.23513182f, 
    -0.21691665f, -0.00156170f, 0.38931730f, 0.30556950f, 0.08886938f, -0.16594096f, -0.04939615f, 0.12663260f, 
    -0.20821935f, 0.06984346f, -0.14072382f, -0.19946381f, -0.05927933f, -0.58549005f, -0.03067869f, -0.52770019f, 
    -0.40144953f, -0.18524189f, -0.37560469f, -0.26498994f, -0.00677246f, -0.32410011f, -0.54561669f, 0.37613994f, 
    -0.24854819f, 0.11084142f, -0.36307651f, -0.11589730f, 0.20285989f, 0.08516745f, 0.25611550f, -0.00803537f, 
    0.04054075f, -0.21997330f, 0.29595023f, 0.31980711f, -0.06133394f, 0.19782503f, 0.21124876f, 0.03703185f, 
    0.18086091f, 0.36064127f, -0.14272609f, 0.14928217f, 0.15236390f, -0.05509015f, 0.06133736f, 0.13500902f, 
    0.04718697f, 0.06313404f, 0.03843115f, 0.04345361f, 0.15677178f, -0.03434207f, -0.20960641f, 0.00507217f, 
    0.14818279f, -0.27353233f, -0.15566984f, 0.08805770f, 0.09135085f, 0.12579912f, 0.25821221f, -0.50670564f, 
    -0.15914883f, -0.58904994f, -0.36452436f, -0.42889944f, 0.24443012f, 0.42274877f, -0.07146025f, -0.07969607f, 
    0.20154573f, -0.29725960f, 0.11137065f, -0.12838066f, -0.07486808f, 0.12344135f, 0.19223590f, 0.00348409f, 
    0.07212918f, 0.12971161f, 0.21352899f, 0.19594076f, -0.40359339f, -0.42744255f, -0.23887073f, -0.20970693f, 
    -0.92801124f, -0.57242918f, -0.70531714f, -0.70300817f, -0.77857226f, 0.73062694f, 0.42015442f, -0.08960491f, 
    0.09376649f, 0.49392003f, -0.10691687f, -0.29107934f, -0.13645159f, 0.21307653f, -0.10794440f, -0.24626733f, 
    -0.08720170f, -0.11596479f, -0.05045391f, -0.37095037f, -0.23688795f, -0.16682652f, 0.13869710f, 0.00995040f, 
    0.00899883f, -0.81053513f, -0.46414363f, -0.55344766f, -0.78431118f, -0.58513349f, 0.41292828f, -0.04229060f, 
    -0.29512319f, -0.30132529f, -0.13899459f, -0.11662737f, -0.33271646f, -0.01907770f, -0.34157011f, -0.25847858f, 
    0.12835389f, -0.14153127f, -0.21840353f, 0.01502846f, 0.15495078f, -0.17544580f, 0.07272558f, 0.16759717f, 
    -0.24138217f, -0.06730960f, 0.76629859f, -0.64746654f, -0.38489866f, -0.02083701f, 0.34519514f, 0.28775656f, 
    0.32277673f, 0.29686081f, -0.13541637f, -0.13319869f, -0.16636097f, -0.10824218f, 0.02522131f, -0.51541680f, 
    0.01858804f, 0.24182692f, 0.13536355f, 0.02070454f, -0.02726045f, -0.30838382f, -0.22182618f, -0.32802612f, 
    -0.27271369f, -0.13618812f, -0.36846596f, -0.22100577f, 0.32633433f, 0.39832646f, -0.57373405f, -0.20671894f, 
    -0.02645599f, 0.22813198f, 0.13526584f, 0.05514393f, 0.12955199f, -0.05518518f, -0.25255322f, -0.39378512f, 
    -0.07694343f, 0.18027711f, 0.70810068f, -0.21448493f, -0.08026064f, -0.20637417f, -0.28135341f, -0.28928748f, 
    0.07422093f, -0.16165029f, 0.23040845f, -0.19023018f, -0.30055365f, 0.11856008f, -0.11801571f, 0.04749342f, 
    0.10251128f, 0.30615526f, -0.31504369f, -0.25915253f, 0.08636118f, 0.27315021f, -0.04934721f, -0.09828762f, 
    0.10118880f, 0.18260290f, -0.27375898f, -0.24609308f, 0.11804733f, -0.02547984f, 0.12813127f, -0.16570465f, 
    0.14346500f, 0.25240803f, -0.00751876f, 0.09803080f, 0.12944120f, 0.40464988f, 0.03013918f, -0.09972315f, 
    -0.29458180f, 0.10301061f, -0.02346120f, -0.12839255f, 0.08001046f, 0.00741053f, 0.04377242f, -0.09817023f, 
    -0.24136785f, -0.09871463f, 0.07870149f, 0.14629638f, -0.32270589f, 0.14428660f, 0.22361457f, -0.14904243f, 
    -0.42879155f, 0.22127737f, 0.04952651f, 0.18897943f, 0.09843970f, 0.17932506f, -0.75188774f, -0.65304458f, 
    -0.16704889f, 0.60697460f, 0.51180798f, -0.37136143f, -0.00166605f, 0.17928419f, 0.41309378f, -0.01386225f, 
    0.18759845f, -0.08396507f, 0.11133222f, 0.18844208f, 0.14035301f, -0.25224510f, 0.19421399f, -0.18733712f, 
    -0.33625367f, -0.28013048f, 0.06745285f, 0.09856109f, 0.12637602f, 0.28005370f, 0.20443054f, -0.94485009f, 
    -0.47523955f, 0.11950072f, -0.32202327f, 0.00752790f, 0.16905689f, 0.32458827f, 0.19870357f, 0.08005983f, 
    0.25445268f, 0.19042860f, 0.12314364f, 0.11913722f, -0.20547888f, -0.02481189f, 0.06888253f, -0.01857283f, 
    -0.21596442f, 0.18873604f, 0.25325671f, 0.08658331f, -0.05912260f, -0.07320292f, -0.10076966f, -0.23302853f, 
    0.47631267f, 0.14028673f, 0.34070274f, -0.31846514f, 0.12753142f, 0.17812142f, -0.21339104f, 0.11039851f, 
    -0.10761337f, 0.04163989f, -0.16080752f, -0.22325209f, 0.06904054f, 0.04259111f, 0.14297609f, 0.12784369f, 
    -0.01171032f, -0.05320304f, -0.00071799f, -0.19137654f, 0.10494733f, -0.27702987f, -0.31246701f, 0.09385435f, 
    -0.11588872f, 0.38811138f, 0.37982965f, -0.08533701f, 0.16900511f, -0.52998066f, 0.16992645f, -0.37583518f, 
    -0.26716328f, 0.07062040f, 0.10436588f, 0.45567313f, -0.44310996f, -0.06120232f, 0.20341499f, 0.00271130f, 
    -0.25738657f, 0.04872380f, -0.11451554f, 0.12215245f, 0.00601434f, 0.06134741f, 0.04326889f, -0.17447276f, 
    0.17842218f, -0.09879158f, -0.54702228f, 0.20638445f, 0.03806811f, 0.25837767f, 0.45353788f, 0.20037021f, 
    0.54343361f, -0.16836251f, -0.13293774f, 0.17360428f, 0.13690728f, 0.33990863f, -0.08993344f, -0.25537419f, 
    -0.20565163f, -0.16755891f, 0.17424379f, -0.09009147f, -0.18490410f, -0.09525638f, 0.23773223f, 0.14965841f, 
    -0.31961128f, 0.15132987f, -0.24078277f, 0.23634380f, 0.14199366f, -0.37958798f, 0.02333289f, -0.33106273f, 
    -0.22260691f, 0.29720700f, 0.32331577f, -0.12924197f, 0.07259530f, -0.04082453f, -0.26244360f, -0.28428733f, 
    0.45778370f, -0.31794426f, -0.07271177f, 0.16091600f, 0.02375198f, 0.17162429f, 0.01367466f, -0.00648268f, 
    0.10583312f, 0.20164941f, -0.08981893f, -0.30905399f, -0.17661676f, -0.51277095f, -0.20851474f, -0.59247071f, 
    -0.70484847f, -0.55315399f, -0.55840498f, -0.79064333f, -0.60318154f, -0.45030138f, -0.18448196f, 0.18343203f, 
    -0.09074917f, -0.13949277f, -0.26765326f, -0.25366706f, -0.11540939f, -0.10649189f, -0.19318047f, -0.33058435f, 
    -0.03552922f, 0.31933922f, 0.14177987f, 0.11913889f, -0.04476043f, 0.59423882f, -0.32651719f, -0.03211714f, 
    0.36576933f, 0.06303369f, 0.10436602f, 0.20647366f, 0.23017083f, -0.11258566f, -0.24975425f, -0.22294827f, 
    -0.01657950f, 0.12513778f, 0.08929808f, -0.16305843f, 0.12098107f, -0.03431579f, 0.14830768f, -0.19932529f, 
    -0.03658756f, -0.14031371f, -0.13542901f, -0.05977077f, -0.12821893f, -0.33249649f, 0.18081689f, 0.07577972f, 
    -0.00643782f, 0.19644459f, 0.12672569f, -0.35046092f, -0.18138093f, -0.42831668f, -0.48672128f, -0.19149162f, 
    0.07713950f, 0.05949558f, 0.18349391f, 0.34755477f, 0.11656597f, 0.26961938f, 0.00257162f, -0.07519515f, 
    -0.06697130f, -0.37995017f, 0.12749329f, 0.21259706f, 0.22333944f, 0.18566790f, -0.04543537f, 0.35683054f, 
    0.31823856f, 0.30654305f, 0.08262786f, 0.25545317f, -0.04182325f, 0.31253764f, -0.07860927f, 0.11975972f, 
    -0.18946320f, 0.15849340f, 0.08172165f, -0.19751054f, 0.12397105f, -0.03565605f, -0.04679037f, 0.09868240f, 
    -0.03751842f, -0.09983583f, 0.04486937f, 0.10692244f, 0.03431428f, 0.02952958f, -0.09501772f, -0.24729705f, 
    -0.84176904f, -0.74074650f, 0.09334600f, 0.65671510f, 0.74149853f, -0.06331848f, -0.44939253f, -0.30177987f, 
    0.16453159f, 0.10633584f, -0.33998761f, 0.01864229f, -0.18068300f, 0.62071180f, -0.35967678f, 0.21755831f, 
    0.07777181f, -0.16470785f, 0.17416292f, 0.10653655f, 0.10115464f, -0.09387081f, -0.28528425f, 0.02250944f, 
    -0.09133232f, -0.66685373f, -0.10537921f, 0.25399646f, 1.02295768f, 0.52098763f, 0.01763363f, 0.25658560f, 
    -0.58731824f, -0.58372837f, -0.09609052f, 0.07900309f, -0.00158162f, -0.06201167f, 0.19173032f, 0.34740290f, 
    0.06697517f, -0.20109032f, -0.20450550f, 0.16901760f, -0.08688811f, -0.17299162f, -0.05483154f, 0.18116218f, 
    0.11522587f, -0.29856429f, -0.54116946f, 0.09613368f, 0.09839824f, 0.50487339f, 0.07403475f, -0.26524234f, 
    -0.71937066f, -0.33235720f, 0.29891631f, 0.59923458f, 0.10553348f, -0.07129787f, -0.03546301f, 0.45970953f, 
    0.17924877f, -0.44966945f, -0.08015159f, 0.26017955f, -0.18928066f, -0.06611555f, 0.07229085f, 0.17465584f, 
    -0.22378699f, 0.05668996f, -0.08119983f, -0.81447601f, -0.45784345f, 0.16206785f, 0.26897523f, -0.16916686f, 
    -0.08590385f, -0.44644168f, -0.26504236f, 0.58858693f, -0.22984187f, 0.12380933f, -0.19314140f, -0.09631270f, 
    -0.15883130f, -0.32009679f, -0.06336474f, -0.09017303f, 0.11342260f, -0.23197356f, 0.11735454f, 0.38872892f, 
    -0.03232688f, 0.04259171f, -0.06848096f, 0.39073232f, 0.65373409f, -0.29885036f, -0.49297470f, 0.13347587f, 
    0.73338497f, 0.46834490f, -0.47374621f, -0.53681827f, -0.33785245f, -0.15544508f, -0.08264562f, 0.15024731f, 
    0.07374140f, 0.09522513f, 0.08780324f, 0.05857666f, 0.22553065f, -0.26443970f, 0.08124278f, -0.20733933f, 
    -0.23940399f, 0.10904977f, -0.07915264f, -0.01314022f, -0.05570043f, -1.14407980f, 0.65639019f, -0.40085891f, 
    -0.04312607f, 0.09828043f, -0.65349942f, 0.44472879f, 0.42296559f, 0.30697605f, 0.05122015f, 0.17863700f, 
    -0.08744438f, -0.25775990f, -0.07711464f, 0.04007371f, -0.00208857f, -0.22312599f, -0.04755545f, -0.14734647f, 
    -0.02069687f, -0.23634006f, 0.19862960f, 0.30866128f, -0.09345180f, 0.17574522f, -0.99632722f, 0.15939015f, 
    0.88223761f, -0.62481230f, -0.22606257f, 0.32421604f, 0.35378751f, -0.10443204f, 0.19319020f, -0.26884136f, 
    -0.21735702f, 0.01605952f, -0.19426166f, 0.50148100f, -0.15483806f, 0.24019808f, 0.03059583f, -0.25273004f, 
    -0.26085299f, 0.10174806f, 0.05196219f, 0.28411889f, 0.22570272f, -0.14550561f, -0.05782358f, 0.34932575f, 
    -0.34535155f, 0.29693133f, 0.12925886f, 0.50813282f, 0.18365538f, 0.13887846f, -0.34338307f, -0.28810772f, 
    -0.13338691f, 0.18295678f, -0.12384542f, 0.36184937f, 0.00483773f, -0.28421649f, -0.04716550f, -0.24706693f, 
    0.12972057f, -0.05864136f, -0.05173685f, 0.19348733f, -0.25803426f, -0.02308212f, 0.25514290f, -0.05996197f, 
    -0.25173381f, -0.14222229f, 0.24441825f, 0.31920207f, -0.15077965f, 0.27412567f, 0.30698559f, 0.11006479f, 
    -0.19635028f, -0.36969745f, 0.16949028f, 0.33977020f, 0.07821727f, -0.20513521f, -0.25363606f, 0.01380308f, 
    0.18575709f, 0.15883060f, -0.06703538f, -0.01905402f, -0.30888155f, 0.17264563f, -0.08640647f, 0.13705203f, 
    0.32245380f, 0.73207068f, 0.30203143f, -0.69304615f, -0.68832731f, -0.20298651f, 0.36962420f, -0.20336823f, 
    0.27980319f, 0.36918378f, -0.13278960f, 0.19327833f, -0.20672521f, 0.11647599f, -0.05233327f, -0.24227153f, 
    0.04159101f, -0.03739180f, 0.17607868f, -0.38347271f, 0.31722799f, -0.27206889f, -0.14259472f, 0.01599581f, 
    0.41136789f, -0.01354393f, -0.05329573f, 0.15832472f, 0.16564412f, -0.31985676f, -0.31518239f, 0.27057976f, 
    -0.32551271f, -0.64780152f, -0.62957621f, 0.11575007f, 0.07089869f, -0.13506430f, -0.35147378f, -0.25355053f, 
    -0.19605929f, 0.21547888f, 0.19639753f, -0.21390535f, -0.12647930f, -0.36037740f, 0.16972949f, -0.40353271f, 
    -0.26976541f, -0.18393846f, -0.32638311f, -0.31801632f, -0.46064392f, -0.16397336f, 0.64071643f, 0.49061275f, 
    -0.44474941f, -0.16862790f, -0.27491763f, 0.13295630f, -0.28179994f, 0.18338473f, -0.33063033f, 0.25534579f, 
    0.09105559f, 0.16055617f, 0.01494276f, 0.12898487f, -0.20768824f, 0.11923442f, 0.05099727f, 0.13553636f, 
    -0.33381456f, 0.09271620f, 0.14553648f, 0.05634509f, -0.68405753f, -0.33872902f, -0.06129814f, -0.09915489f, 
    0.18889789f, 0.13258165f, -0.06756364f, 0.06890558f, 0.55051327f, 0.57838255f, -0.05835309f, 0.17704767f, 
    0.15574260f, 0.08140764f, -0.13850667f, -0.29077014f, -0.18258953f, 0.25382182f, -0.30869994f, 0.34300351f, 
    -0.16000919f, 0.00071007f, -0.02692525f, 0.22291736f, -0.30342826f, 0.35287970f, 0.26185438f, -0.10818976f, 
    -0.17053284f, 0.15352170f, -0.29092577f, -0.25247252f, -0.13407895f, 0.13958736f, -0.19530810f, -0.09114531f, 
    0.12067528f, -0.19958302f, -0.18183646f, -0.08398514f, 0.26968741f, -0.02075921f, 0.04185272f, 0.09600030f, 
    -0.24235405f, -0.00375036f, 0.12951843f, 0.02866712f, 0.04422190f, 0.41505453f, 0.14471693f, -0.59108752f, 
    -0.25176471f, -0.40793687f, -0.28663936f, -0.53394860f, -0.75045526f, -0.68889534f, -0.55091411f, -0.61348319f, 
    0.23262104f, 0.54765046f, 0.20718797f, 0.17569210f, 0.09218042f, 0.11575542f, -0.21018507f, 0.18095054f, 
    -0.10817745f, 0.04112044f, -0.33938503f, 0.08734015f, -0.01746613f, 0.17577593f, 0.01939330f, -0.98663867f, 
    -0.60198629f, 0.40969464f, 0.09514512f, -0.26951095f, 0.02744007f, 0.08016954f, 0.38667765f, -0.00571216f, 
    -0.15064052f, 0.45275360f, 0.22904234f, 0.12101316f, 0.51607752f, -0.64291072f, -0.36076403f, -0.32435170f, 
    -0.12783049f, -0.07272378f, -0.30515045f, -0.01439080f, 0.05386325f, 0.31388989f, 0.02858788f, -0.33691183f, 
    0.30133468f, -0.56477475f, 0.18651079f, -0.05997694f, 0.15321550f, -0.24041383f, -0.08687128f, -0.15016782f, 
    0.27082995f, 0.27940601f, -0.22796357f, 0.25229126f, -0.38302499f, -0.45501259f, 0.43699235f, 0.06118683f, 
    0.15940300f, -0.11073203f, -0.12782629f, -0.15934761f, 0.07302561f, 0.22830904f, 0.03603436f, -0.18295600f, 
    0.31885481f, -0.30077660f, -0.24397086f, 0.41476977f, -0.18181886f, -0.12535213f, -0.52814609f, -0.50376576f, 
    0.92109531f, 0.24975345f, 0.01826973f, -0.20271592f, -0.19582623f, 0.02708699f, -0.38304949f, -0.16501398f, 
    -0.10685328f, -0.21834309f, -0.46684307f, 0.23091628f, 0.41552904f, -0.25475696f, -0.18471193f, 0.02115399f, 
    -0.02510165f, 0.36601418f, 0.73813391f, 0.31235859f, -0.60456073f, -0.42893738f, 0.06705135f, 0.28408375f, 
    0.19196419f, 0.50749320f, 0.16924231f, -0.15782796f, -0.32769033f, 0.03435991f, -0.26512486f, -0.08625972f, 
    -0.19501710f, 0.13047552f, -0.31561029f, 0.01529265f, -0.09858932f, -0.09066679f, -0.07413218f, 0.20093682f, 
    0.04387032f, -0.08930077f, 0.07818408f, -0.87435406f, -0.22920413f, -0.45642883f, -0.27780604f, -0.29522225f, 
    0.39480361f, -0.00849678f, 0.07443304f, 0.09208579f, 0.30909100f, 0.28891376f, 0.08862642f, 0.21350917f, 
    0.13246723f, 0.03851037f, 0.22000861f, -0.15217954f, -0.14595859f, -0.09656142f, -0.40466192f, -0.10804182f, 
    -0.04061507f, -0.03940250f, -0.23075816f, -0.34568119f, -0.27525523f, -0.04394755f, -0.28389412f, 0.00406657f, 
    -0.19128212f, -0.29717413f, -0.30665681f, 0.00375224f, 0.08526837f, 0.02581455f, 0.41463640f, 0.41020325f, 
    0.21409915f, -0.13048208f, 0.21806750f, -0.19901322f, 0.31031287f, 0.11517017f, -0.11739414f, 0.10931265f, 
    -0.02143635f, 0.02436375f, -0.18189792f, -0.24241166f, -0.33475199f, 0.06728049f, -0.15397778f, 0.23747310f, 
    0.15788369f, 0.03691669f, 0.24786428f, 0.14123212f, 0.03534259f, -0.03498701f, -0.22526753f, -0.29684505f, 
    0.33060151f, 0.22923359f, 0.14017965f, -0.21094286f, -0.35184738f, 0.17147242f, 0.01802542f, 0.00285384f, 
    -0.09210511f, -0.11653540f, 0.21409811f, 0.12922849f, -0.20607913f, 0.10052086f, -0.51329505f, -0.24564111f, 
    -0.52163750f, 0.36304796f, 0.49049175f, -0.45777500f, 0.72044611f, -0.39490914f, -0.67798489f, -0.81629938f, 
    -0.31884086f, -0.28303200f, 0.04610067f, 0.06605131f, -0.48653218f, -0.10832756f, -0.33554876f, -0.07861599f, 
    0.10113835f, 0.00895863f, -0.00377403f, -0.01651761f, -0.10416680f, 0.04669954f, 0.09463222f, -0.91903442f, 
    -0.46146396f, -0.53845805f, -0.57691836f, -0.64820987f, 0.65234256f, 0.09872659f, 0.28855973f, 0.38522518f, 
    0.02846201f, 0.13023117f, -0.22213611f, -0.12175875f, 0.00657225f, -0.46643952f, 0.07176597f, 0.04452433f, 
    -0.04403237f, 0.16515858f, 0.18837361f, -0.07107372f, 0.19975916f, 0.19786017f, 0.12264042f, 0.07525602f, 
    0.35643381f, -0.66248471f, -0.45925599f, -0.28297043f, 0.07080345f, -0.37700707f, -0.01519634f, 0.27911744f, 
    -0.20600419f, 0.38912719f, -0.25561434f, 0.28759271f, -0.12538441f, -0.30315796f, -0.38992691f, -0.16912585f, 
    0.24641711f, 0.23806073f, 0.10986522f, 0.08476143f, 0.10184865f, 0.21616179f, -0.20997319f, -0.11372864f, 
    0.34806922f, -0.59251440f, -0.55720538f, -0.34689575f, -0.26204920f, 0.36444876f, -0.47754359f, -0.77563739f, 
    -0.51572531f, -0.06877403f, -0.14825609f, 0.54814917f, -0.14242959f, -0.25635672f, -0.01684683f, -0.18620485f, 
    -0.35862982f, 0.03603109f, -0.40558603f, -0.25209180f, -0.40687308f, -0.49686718f, 0.09479268f, 0.41615030f, 
    -0.12051419f, 0.01912754f, -1.02367902f, -0.75614935f, -0.17264122f, -0.63423371f, -0.29362705f, 0.50668848f, 
    -0.31536925f, -0.62958890f, 0.39273068f, 0.30344364f, -0.08172896f, -0.39498085f, -0.18985157f, 0.16389000f, 
    -0.08007905f, 0.04168607f, 0.11128923f, -0.20265706f, -0.35602039f, -0.42021945f, -0.10940883f, 0.10062031f, 
    0.23408327f, 0.01078090f, 0.05939495f, -0.16356775f, -0.27495879f, 0.62440252f, 0.47077873f, -0.57492417f, 
    0.27023014f, -0.01892286f, -0.06734453f, -0.20132260f, -0.44167539f, -0.01086671f, -0.23938978f, -0.08418838f, 
    0.41293964f, 0.00525505f, -0.22274540f, -0.05877781f, -0.17349409f, -0.35946870f, -0.31567341f, -0.26062009f, 
    -0.64674979f, -0.24337654f, -0.28633988f, -0.52982163f, -0.04670604f, -0.22569479f, 0.21588242f, 0.20189297f, 
    0.19041926f, -0.12569711f, -0.43863001f, -0.00882208f, 0.33140397f, -0.04539668f, 0.04139080f, 0.22121392f, 
    -0.07181236f, -0.34232637f, 0.03907015f, 0.10174188f, 0.19885206f, 0.16079189f, 0.17252958f, -0.47824416f, 
    -0.03252321f, -0.14039019f, -0.36874938f, -0.24873510f, 0.21820638f, -0.62631506f, 0.18061979f, 0.07759767f, 
    0.46722156f, -0.01721202f, 0.32187074f, -0.12171283f, 0.08784425f, -0.13532263f, 0.10122438f, -0.18832687f, 
    -0.19944416f, 0.13443434f, 0.30312383f, -0.05605204f, -0.30926201f, 0.02126768f, -0.02009806f, -0.12624192f, 
    0.30940244f, 0.09358451f, -0.21513188f, 0.12906568f, 0.23259065f, -0.24311233f, 0.05601769f, -0.67467982f, 
    -0.23900338f, -0.62379521f, 0.25022104f, 0.30002603f, 0.40652657f, 0.04713954f, -0.18739639f, 0.13702001f, 
    -0.05156071f, -0.32975850f, -0.33639938f, -0.06606025f, 0.19864053f, 0.21030255f, 0.16869871f, -0.23524740f, 
    -0.06603905f, -0.37213629f, -0.36360273f, -0.27250111f, -0.51943356f, -0.32732084f, -0.19729108f, -0.48111552f, 
    -0.71465236f, -0.68349922f, 0.07679564f, 0.34465817f, 0.12645644f, -0.57988089f, -0.67338324f, -0.59333849f, 
    -0.72540575f, -0.00101414f, 0.22199325f, -0.09232257f, 0.50065023f, -0.38731787f, -0.11294301f, -0.04133197f, 
    -0.24267177f, 0.02851583f, -0.18882543f, -0.24889272f, 0.01836194f, -0.04590274f, -0.16639188f, -0.33367798f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24531460f, 0.17154726f, 0.06301600f, 0.44410041f, 0.33035320f, 0.36341810f, -0.01459437f, 0.03431319f, 
    0.38978755f, 0.34448993f, 0.32137406f, 0.15175806f, 0.06422617f, 0.07536378f, -0.00857172f, 0.14106904f, 
    -0.17427006f, -0.14141576f, -0.01620000f, 0.20464432f, 0.20864771f, 0.06602477f, 0.34694493f, 0.17161062f, 
    0.21878046f, 0.29708949f, 0.10929664f, 0.09693280f, -0.20279187f, 0.11782102f, 0.07602283f, -0.13226621f, 
    0.08997434f, -0.03306406f, 0.26602775f, -0.03382802f, 0.12008361f, 0.19504638f, 0.10275688f, 0.11698068f, 
    -0.01572789f, 0.34133235f, -0.24494569f, 0.30076885f, 0.21543677f, 0.22232667f, 0.02046575f, -0.03189816f, 
    0.09198967f, 0.28904402f, 0.37973008f, 0.03550052f, -0.00695814f, 0.08634564f, 0.23841001f, 0.01105099f, 
    0.10761777f, -0.12958293f, -0.12651576f, -0.12458892f, 0.22949983f, 0.31844690f, 0.08711346f, -0.12925245f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.51625305f, -0.66423994f, -0.27555948f, 0.11590676f, 0.06203715f, -0.00093205f, 0.02678834f, 0.04559035f, 
    -0.06268295f, -0.00491233f, -0.06296045f, 0.00949213f, -0.01374580f, 0.09600496f, -0.64360231f, 0.04361439f, 
    0.03715336f, 0.04165795f, -0.04577579f, -0.20714568f, -0.00212438f, -0.15536198f, -0.31626844f, -0.05567459f, 
    -0.00290209f, -0.08253592f, -0.21689588f, -0.01322019f, 0.04593295f, -0.01645863f, 0.05162615f, 0.03817549f, 
    0.02291466f, 0.05424876f, 0.05200978f, -0.02640648f, -0.65042794f, -0.32256946f, -0.34936330f, 0.02490340f, 
    0.00698143f, 0.01008178f, -0.01489263f, 0.00344382f, -0.05615972f, -0.02947557f, -0.00942115f, 0.03272277f, 
    -0.26551601f, -0.26078546f, -0.13079642f, -0.12350585f, 0.00822419f, -0.03629179f, -0.00994494f, 0.04260079f, 
    -0.08902068f, 0.00335330f, 0.02414015f, -0.19074234f, 0.37292224f, 0.06522968f, -0.20940231f, -0.06935205f, 
    0.03402406f, -0.00678450f, 0.03267330f, 0.01210787f, 0.03015281f, -0.01428621f, -0.08904245f, -0.11254711f, 
    -0.22655877f, 0.03687857f, 0.19776395f, -0.12658177f, 0.00396065f, -0.05461321f, -0.00034307f, 0.01001120f, 
    -0.07489606f, -0.15776892f, -0.02159621f, 0.14611425f, 0.09924965f, -0.04714224f, -0.22782385f, -0.05530986f, 
    0.03372574f, -0.00412976f, -0.03849462f, -0.05131916f, -0.00094643f, 0.04373186f, 0.06402636f, 0.01730052f, 
    -0.19835986f, -0.20891131f, 0.11676756f, 0.05710010f, -0.03890587f, 0.04833076f, -0.04062993f, 0.00006734f, 
    0.03169167f, -0.05589247f, -0.03399088f, -0.05944765f, 0.13674773f, -0.07154368f, 0.08646241f, -0.04805137f, 
    -0.09561177f, -0.07978816f, 0.00941330f, 0.02231866f, -0.17994253f, -0.04111172f, -0.03201468f, -0.00368503f, 
    -0.21319631f, -0.03543524f, -0.24727950f, 0.09841213f, 0.00729402f, -0.00136793f, -0.01529032f, -0.07886963f, 
    -0.17100185f, -0.19537413f, -0.26857635f, -0.25871387f, -0.21287528f, 0.04901613f, 0.13774209f, -0.11770679f, 
    -0.12462454f, -0.02737811f, -0.06624907f, -0.02252360f, -0.01905014f, -0.00221475f, -0.04344321f, 0.00450467f, 
    -0.03426103f, -0.13896009f, 0.04876671f, -0.15391871f, -0.00872982f, 0.09067983f, -0.15324067f, -0.15744479f, 
    0.00781116f, 0.05212650f, 0.03905711f, -0.03588809f, 0.19585337f, 0.13064435f, -0.08800898f, -0.21449375f, 
    0.12871197f, 0.14676961f, 0.03758691f, 0.01934113f, -0.01253182f, 0.04056566f, 0.00239651f, -0.00349771f, 
    0.01528483f, -0.00573369f, 0.02573821f, 0.00975117f, -0.00929156f, 0.03977011f, 0.05366052f, -0.01599316f, 
    -0.09563234f, -0.03117424f, 0.00139005f, -0.07683553f, 0.11690074f, 0.13663696f, 0.00061020f, -0.00906495f, 
    0.14048740f, 0.14518251f, 0.02386554f, -0.05801092f, -0.03171587f, 0.02588720f, 0.07220995f, 0.02634420f, 
    0.17955649f, 0.02225429f, -0.09514707f, -0.01787366f, 0.15306571f, 0.20846529f, -0.15877487f, -0.06772632f, 
    -0.03050474f, 0.00805603f, -0.03963862f, -0.01664452f, 0.30490455f, 0.19631155f, -0.15964508f, -0.20803666f, 
    0.10405117f, 0.19805172f, 0.11919575f, 0.09220167f, -0.01932329f, 0.02985425f, 0.02888649f, 0.02949060f, 
    -0.09289772f, -0.29088342f, -0.24650913f, 0.12903896f, 0.03476672f, 0.01660383f, 0.10803889f, -0.10402672f, 
    0.01520892f, 0.14367856f, 0.02969470f, 0.12257832f, -0.42692223f, -0.10448907f, 0.09873289f, 0.01388793f, 
    -0.03845947f, -0.01835276f, 0.01268651f, -0.00506964f, -0.01557974f, -0.03580004f, -0.02711328f, 0.00337727f, 
    0.01916998f, 0.04626118f, 0.04447272f, -0.01007973f, -0.12082264f, -0.11080599f, -0.01902610f, 0.02195584f, 
    -0.02255228f, -0.09152877f, -0.03139484f, -0.04055902f, -0.05634627f, -0.01301568f, -0.07325417f, 0.04021832f, 
    0.00592974f, 0.00136883f, -0.02438630f, 0.03395661f, -0.02366583f, -0.01697998f, 0.02919200f, 0.01772906f, 
    -0.06779469f, 0.20916295f, 0.18569677f, -0.12817670f, 0.03348682f, 0.05240640f, 0.09924143f, -0.05209111f, 
    0.04605630f, -0.19414733f, -0.19937687f, -0.17482655f, 0.10938102f, 0.04253518f, 0.01930970f, 0.00292664f, 
    0.06091185f, 0.09627391f, 0.00526737f, -0.00104135f, -0.04008704f, -0.00464227f, 0.03809072f, -0.00010161f, 
    -0.42521498f, -0.28049025f, -0.11429086f, 0.23455594f, 0.03584747f, 0.03436955f, -0.01984069f, -0.01873874f, 
    -0.00243589f, -0.06933903f, 0.01491953f, 0.06630277f, -0.20846106f, -0.22102973f, -0.02309357f, -0.10016589f, 
    -0.02401300f, -0.00475784f, -0.10958386f, -0.01953427f, -0.06096285f, -0.05955048f, 0.01688123f, -0.03040419f, 
    -0.29763925f, 0.05407772f, 0.02591138f, -0.06506567f, -0.00085589f, 0.04211428f, 0.05103399f, 0.00191535f, 
    -0.09811424f, 0.05168406f, -0.02718788f, -0.03449145f, 0.04586295f, -0.08756429f, 0.03059199f, 0.04808487f, 
    -0.00275561f, -0.01297214f, -0.13478054f, -0.01519251f, 0.06295626f, 0.06512696f, -0.02492876f, -0.06011501f, 
    0.24816854f, 0.14147960f, -0.08485219f, -0.23681371f, 0.09897940f, 0.13338517f, 0.00451381f, -0.00969408f, 
    -0.05919731f, -0.05465053f, -0.00098480f, -0.00845915f, -0.05977489f, -0.12877114f, 0.00640905f, 0.04135729f, 
    -0.00641324f, 0.00815945f, 0.04328513f, -0.02328693f, 0.02240765f, 0.04333191f, -0.09969397f, -0.01692041f, 
    0.06372303f, 0.13722332f, -0.05964253f, -0.04737153f, 0.02208984f, -0.07842901f, -0.05544228f, -0.17062367f, 
    -0.02215948f, 0.03335434f, -0.06427653f, -0.05914061f, -0.02700889f, -0.05035902f, 0.00819324f, 0.06392518f, 
    0.06977510f, 0.03421327f, 0.01953167f, 0.03388274f, -0.01729129f, 0.08004089f, 0.00606947f, 0.06285217f, 
    0.61495161f, 0.21501282f, 0.00159780f, -0.42551389f, 0.09659453f, -0.05596640f, 0.08516603f, -0.13020259f, 
    -0.04895348f, -0.04305128f, -0.14785931f, -0.13290212f, 0.01425778f, -0.00067948f, 0.04627889f, -0.20452273f, 
    0.00891819f, 0.02189169f, 0.02429314f, -0.02991330f, -0.01897268f, 0.04697561f, 0.04043442f, 0.04475867f, 
    -0.30358341f, 0.13031590f, 0.22598334f, -0.27583209f, -0.06037034f, 0.06601696f, -0.01096635f, 0.06491116f, 
    -0.06396636f, -0.08104277f, -0.03007656f, -0.05243857f, 0.33631495f, 0.25584438f, 0.28289995f, -0.31290337f, 
    0.07015390f, 0.10682961f, 0.06053746f, 0.14164804f, 0.02878036f, -0.02959079f, -0.01549184f, -0.12683898f, 
    0.04215030f, 0.00268124f, -0.28126556f, 0.13924721f, -0.09632754f, -0.08391056f, -0.00077750f, -0.14037821f, 
    -0.00515197f, -0.02468666f, 0.02439700f, -0.00193516f, -0.38084760f, -0.04004676f, 0.28802368f, -0.11240871f, 
    -0.08154383f, 0.01262027f, -0.01240091f, 0.00184935f, -0.09046987f, -0.07968911f, -0.21863860f, 0.01508645f, 
    0.03284337f, -0.07922397f, -0.12250072f, -0.11397007f, -0.16796105f, 0.10732862f, -0.11707284f, 0.00657664f, 
    -0.18846108f, -0.02207825f, -0.07734831f, 0.00655446f, -0.11988574f, -0.17127217f, 0.10319781f, 0.08104971f, 
    0.02232320f, -0.00584086f, -0.03125866f, -0.01830111f, 0.00778483f, -0.01051031f, -0.04022669f, 0.10058217f, 
    0.00342703f, 0.03746693f, 0.03909998f, 0.03650696f, -0.22522435f, -0.12872051f, 0.04507963f, -0.03418950f, 
    -0.01019526f, -0.15198804f, 0.02720062f, -0.07542805f, -0.00795439f, -0.33695549f, -0.49881291f, 0.04565605f, 
    0.05705484f, 0.04499149f, -0.05103992f, -0.04437929f, -0.08184585f, -0.10577635f, -0.11768261f, -0.20092006f, 
    0.12450425f, 0.22675715f, -0.22268750f, -0.06804959f, -0.11119255f, -0.08800010f, -0.12648903f, -0.01296184f, 
    -0.19168599f, -0.06756151f, 0.04329058f, -0.05539395f, 0.16884936f, 0.04651123f, 0.18452416f, -0.11376453f, 
    0.01825011f, -0.06326384f, -0.07816335f, -0.04555446f, 0.01900304f, -0.03390243f, -0.07130773f, -0.07932807f, 
    0.05048951f, 0.03146628f, 0.11533812f, -0.03620268f, 0.04112225f, 0.03995374f, 0.03074452f, 0.03158831f, 
    -0.08031493f, -0.00981049f, -0.02589650f, -0.03453199f, 0.02161442f, 0.03186108f, -0.08317181f, -0.00503827f, 
    -0.12916204f, -0.13841930f, -0.09944363f, -0.05884022f, -0.05239992f, 0.01048125f, -0.05343519f, -0.01029148f, 
    0.35913152f, 0.20251015f, -0.16276529f, -0.23532191f, -0.10854071f, -0.12169044f, -0.02378824f, 0.05181978f, 
    -0.00807859f, 0.03994635f, 0.00433933f, -0.02997236f, 0.11032857f, 0.01253339f, 0.13941579f, -0.08384828f, 
    -0.01510412f, 0.05941653f, -0.00135553f, 0.03330858f, -0.09528330f, -0.09312059f, -0.14865598f, -0.00671526f, 
    0.03604041f, 0.10948710f, 0.02054660f, -0.15505551f, -0.03902221f, -0.11226410f, 0.03098489f, 0.01653200f, 
    -0.07043298f, -0.02976338f, -0.00894894f, -0.06377161f, -0.11747584f, 0.02243802f, 0.21004848f, -0.15192991f, 
    -0.06146712f, -0.02935802f, 0.01587555f, 0.07047078f, -0.02300887f, -0.04303120f, 0.02736930f, -0.03713110f, 
    -0.23283026f, -0.39976618f, -0.84198272f, 0.23021887f, -0.02825136f, 0.00538590f, -0.01705269f, 0.00378352f, 
    -0.00111396f, -0.07181254f, -0.00735364f, -0.06522591f, 0.04345813f, 0.09162553f, -0.00047984f, 0.03704459f, 
    0.04546050f, 0.10639703f, 0.02096267f, 0.00332065f, -0.02115758f, 0.08927103f, -0.00721725f, 0.09091455f, 
    0.11611754f, 0.10525936f, 0.07873420f, -0.00297834f, -0.03334965f, -0.05348447f, -0.01027789f, -0.03347693f, 
    0.03396790f, 0.13150692f, 0.00090267f, 0.05233838f, -0.06083016f, -0.06229505f, 0.03125534f, 0.06787915f, 
    0.02633228f, -0.01624999f, 0.00503589f, -0.00157039f, -0.03346381f, -0.03601835f, -0.00277820f, -0.13135189f, 
    0.34577394f, -0.00371841f, 0.01034195f, -0.04722553f, 0.09315509f, -0.03580911f, 0.04227257f, 0.02971077f, 
    -0.04705179f, -0.02271456f, -0.01702655f, -0.04840226f, 0.24188949f, 0.05445341f, -0.05927384f, -0.12712923f, 
    -0.00139329f, 0.23881586f, 0.04588318f, 0.08753834f, -0.00615331f, 0.01425591f, -0.04565465f, 0.00842284f, 
    0.19387454f, 0.21781987f, -0.17827666f, -0.15113795f, 0.12511085f, 0.02315329f, 0.16869734f, -0.00059224f, 
    0.00049590f, 0.04887686f, 0.04470576f, -0.04670188f, 0.29704756f, 0.25055754f, 0.09617424f, -0.27623352f, 
    0.14265421f, 0.18262744f, -0.16892168f, 0.00103904f, -0.05101095f, -0.04693535f, -0.11224577f, -0.11276114f, 
    0.27917853f, 0.15960117f, 0.13015106f, -0.19382301f, 0.05837727f, 0.27678177f, -0.00701641f, -0.08505266f, 
    -0.05300742f, -0.00648584f, -0.03483519f, -0.06095211f, 0.05645619f, -0.17898147f, -0.02243470f, -0.21505040f, 
    -0.05727778f, -0.06668705f, -0.02836121f, 0.00177281f, -0.11515588f, -0.12473560f, 0.12101422f, 0.25888270f, 
    -0.09878749f, 0.04362386f, 0.06285901f, -0.04749025f, -0.00517623f, -0.01079486f, 0.05504794f, -0.01433289f, 
    0.00398252f, -0.14427681f, 0.07688956f, -0.01441461f, 0.00944497f, -0.40493110f, 0.02396227f, -0.08431076f, 
    -0.00499157f, -0.05092251f, -0.04765920f, 0.02965041f, -0.10546885f, -0.08722899f, -0.08382012f, -0.15461877f, 
    0.14297487f, -0.20198736f, -0.20511879f, 0.00651430f, -0.01585835f, 0.09644492f, -0.05280149f, -0.10330299f, 
    0.00565197f, 0.07254031f, 0.06269806f, 0.08062195f, 0.40022936f, 0.10784076f, -0.10658167f, -0.15677492f, 
    0.07043137f, -0.00153277f, 0.21469386f, 0.08248552f, -0.00475469f, -0.06124424f, -0.01952529f, -0.05132508f, 
    0.21440850f, 0.19039269f, 0.10643457f, -0.06618931f, -0.06696082f, 0.06124944f, 0.00971781f, 0.04065910f, 
    -0.11710501f, 0.05987144f, -0.03441131f, -0.17606777f, 0.37322733f, -0.02024924f, -0.16713801f, -0.28437647f, 
    -0.03995455f, -0.01732078f, 0.03562699f, 0.00842412f, 0.04341367f, 0.06276867f, 0.09589486f, -0.01357013f, 
    0.28579071f, -0.16808705f, -0.35354292f, -0.58631188f, -0.22435156f, -0.27332693f, -0.19390780f, 0.05158134f, 
    -0.08256324f, -0.01185550f, -0.00719199f, 0.05731376f, 0.32184172f, 0.01933482f, 0.39538741f, -0.07766532f, 
    0.00103563f, -0.03064949f, 0.00160242f, -0.01325558f, -0.04226657f, -0.04410589f, 0.03772080f, -0.00657197f, 
    0.25629437f, 0.20568135f, -0.02642680f, 0.11872911f, 0.01326576f, -0.00470684f, 0.00449924f, 0.08575072f, 
    0.06138427f, -0.00040735f, -0.08726622f, -0.00243205f, 0.59469867f, -0.19454275f, -0.18335514f, -0.03060701f, 
    -0.08740400f, -0.03043499f, 0.05567564f, -0.00781241f, 0.07781041f, -0.13161415f, -0.12497010f, -0.05722199f, 
    -0.17028236f, 0.08477001f, -0.02962964f, -0.03041994f, 0.02134966f, 0.00889907f, 0.00490176f, -0.03653810f, 
    -0.37901247f, -0.04640912f, -0.09357715f, -0.36240146f, 0.23124245f, -0.07470290f, -0.11466831f, -0.01475716f, 
    -0.03800931f, 0.03646360f, -0.01937459f, -0.05543846f, 0.16815011f, -0.40536422f, -0.19445762f, -0.11336120f, 
    0.09322254f, 0.25534022f, 0.17554638f, 0.30661198f, -0.09076214f, 0.03555670f, 0.00375321f, -0.04709273f, 
    0.00343341f, 0.02721711f, -0.00119163f, 0.08143483f, -0.29171705f, -0.31975344f, 0.04811312f, -0.16242379f, 
    0.07358214f, 0.18792495f, -0.04741561f, 0.07999481f, 0.32612938f, 0.09669784f, 0.02572051f, 0.09975335f, 
    0.47242936f, -0.03903389f, -0.09133203f, 0.03171262f, -0.03354853f, -0.01932552f, -0.03512089f, 0.04088524f, 
    0.09509206f, 0.01910362f, -0.07957941f, -0.06843514f, 0.04023236f, -0.07768040f, 0.05920111f, -0.09066761f, 
    0.03550189f, -0.01033541f, 0.03333222f, -0.19596137f, 0.01808334f, -0.04858363f, 0.03037661f, -0.05167546f, 
    0.18648718f, -0.09109644f, 0.01720170f, -0.16667679f, -0.02697814f, -0.03928784f, -0.15375015f, 0.13521050f, 
    -0.04874378f, 0.05286821f, -0.00435144f, -0.04825605f, -0.02491820f, 0.08881686f, 0.03680423f, -0.02263867f, 
    -0.07789057f, 0.01023760f, 0.05285458f, -0.26702520f, -0.06785864f, 0.02940543f, -0.10801761f, -0.00800549f, 
    0.06763917f, 0.05451128f, 0.03307564f, 0.07372362f, -0.01053182f, 0.00652678f, -0.03319132f, -0.01807647f, 
    -0.02928160f, 0.06703449f, 0.06227945f, -0.09903566f, -0.01623992f, -0.07161005f, -0.04108763f, -0.02417705f, 
    0.02016839f, 0.02274748f, -0.24189349f, -0.20103392f, 0.14860819f, -0.10000188f, 0.00706460f, -0.11479495f, 
    0.35502216f, 0.14525536f, 0.10219336f, -0.10692354f, 0.00992590f, 0.03508398f, 0.08697195f, -0.14449984f, 
    0.16093406f, -0.04777810f, -0.00668570f, -0.09861100f, 0.19555147f, 0.28001142f, 0.17172074f, 0.09448897f, 
    -0.05635443f, 0.05567122f, -0.08161154f, -0.14794540f, -0.01513380f, -0.01882589f, -0.02736750f, 0.00538144f, 
    0.39222929f, -0.14078365f, 0.18178047f, -0.02228654f, -0.00895727f, -0.01315131f, -0.05562181f, -0.08254585f, 
    0.04099543f, -0.27495903f, -0.07262342f, 0.01619483f, 0.09097020f, 0.06529693f, 0.28487620f, -0.01052475f, 
    0.08849927f, -0.02525386f, 0.05485461f, 0.00227945f, -0.11916138f, -0.00263449f, -0.12451193f, -0.14672191f, 
    -0.04647436f, 0.04156712f, -0.04116923f, 0.03200380f, 0.09835585f, 0.06511354f, 0.02568694f, 0.00722674f, 
    -0.08700758f, -0.02040707f, 0.05350490f, 0.02653528f, 0.10666768f, 0.11010958f, 0.06141175f, -0.01357115f, 
    -0.04717528f, 0.03517137f, 0.05318226f, 0.03834090f, -0.00101328f, 0.04754463f, -0.02075391f, -0.06088993f, 
    -0.34449476f, 0.06995407f, -0.01321785f, -0.02643326f, -0.08613143f, 0.00857558f, 0.11004993f, -0.02559766f, 
    0.03543305f, 0.02418169f, 0.04684682f, 0.09580811f, 0.06738105f, -0.04233771f, -0.11766397f, -0.05400154f, 
    -0.07609198f, 0.00477993f, 0.06189378f, -0.01134851f, -0.12030240f, 0.06916589f, 0.12780160f, 0.01934706f, 
    0.22244288f, 0.04029973f, -0.00226320f, 0.11649831f, 0.06480678f, -0.01184516f, -0.03153620f, -0.08395265f, 
    0.11129768f, 0.05387677f, 0.00222049f, 0.01154540f, -0.03384854f, 0.11088467f, 0.03361668f, -0.14758900f, 
    -0.04500408f, -0.07052352f, -0.02351863f, 0.01866725f, 0.04632282f, -0.05885951f, 0.07338546f, 0.02915130f, 
    0.19334148f, -0.01564835f, 0.09859960f, 0.16726859f, -0.05572844f, -0.03120208f, -0.02109426f, -0.03301511f, 
    0.05210619f, 0.02555442f, -0.04842034f, 0.11340386f, -0.01927963f, -0.12645933f, 0.08086529f, -0.02549201f, 
    0.00390284f, -0.04289951f, 0.07314392f, -0.03485980f, -0.06982313f, -0.09648705f, 0.11077389f, 0.03745694f, 
    0.07840728f, 0.15449516f, 0.06332975f, 0.25746727f, -0.17460479f, 0.00655322f, -0.24118741f, 0.14198267f, 
    -0.02401690f, 0.01402673f, -0.00069076f, 0.05978320f, 0.23779494f, 0.04611124f, 0.11048043f, 0.07617874f, 
    -0.00060693f, 0.05039435f, -0.07427426f, 0.00751648f, -0.11606594f, -0.03681883f, 0.20024854f, 0.15834954f, 
    -0.05314993f, -0.05454573f, -0.06039228f, -0.04159676f, -0.08982933f, -0.06579781f, 0.09692410f, 0.04886154f, 
    -0.09699007f, -0.00809126f, 0.13461891f, 0.10367682f, 0.13660924f, 0.12148590f, 0.13112293f, 0.16690446f, 
    0.00296065f, -0.02548628f, -0.04729869f, 0.00376184f, -0.02754886f, 0.03840534f, 0.02212613f, 0.05121231f, 
    -0.60917509f, -0.02138601f, -0.11298277f, 0.08074782f, 0.01401968f, -0.15003128f, 0.13500798f, 0.04851703f, 
    0.16237539f, -0.22772357f, 0.06194622f, 0.02910446f, -0.00315344f, 0.05134928f, -0.05171959f, 0.03708012f, 
    -0.10060626f, -0.01558218f, -0.02273357f, 0.04919170f, -0.05215836f, 0.08059792f, 0.11786383f, -0.10727583f, 
    -0.33135343f, 0.23574568f, 0.01889060f, -0.10420449f, -0.03532147f, -0.02165969f, 0.01805631f, 0.09009576f, 
    0.07867342f, -0.07191765f, 0.06413801f, 0.08274359f, -0.30303288f, 0.19121948f, -0.24241932f, -0.08248418f, 
    0.06851203f, 0.01759662f, 0.03183322f, 0.15701026f, -0.00783554f, -0.00053846f, -0.08372615f, -0.00871690f, 
    0.04737807f, 0.03731060f, -0.38365662f, 0.10167864f, 0.06991811f, -0.14090726f, 0.13046651f, 0.14215989f, 
    -0.07075144f, 0.07657027f, 0.01503159f, 0.03326089f, -0.46893632f, -0.32390177f, 0.04250861f, -0.34006181f, 
    0.10866021f, 0.02720116f, 0.02885938f, -0.17759447f, -0.01456584f, 0.08265620f, -0.00209617f, 0.10446497f, 
    -0.15210962f, -0.36081681f, 0.03620991f, 0.06786129f, 0.08916444f, -0.27840275f, -0.03693733f, 0.12051643f, 
    -0.01805337f, -0.08113722f, 0.18142158f, 0.00380360f, 0.10058115f, 0.13911793f, 0.02254625f, 0.08454300f, 
    -0.02461377f, -0.06193502f, -0.04749817f, -0.08056809f, -0.01354374f, -0.03828296f, 0.04960946f, -0.02120260f, 
    0.02190987f, -0.05852453f, 0.02690184f, 0.05690029f, 0.03817692f, 0.06645860f, -0.06417236f, 0.01017566f, 
    0.06651809f, 0.06333785f, -0.02043942f, 0.04644483f, 0.28629074f, -0.01951608f, 0.19283956f, -0.12537836f, 
    -0.07682288f, -0.07798894f, 0.17314653f, 0.01970938f, 0.10018944f, 0.16378023f, -0.11993647f, -0.09797629f, 
    0.19458051f, -0.13535020f, 0.00920370f, -0.20370431f, 0.20467110f, -0.21001357f, -0.11310294f, 0.05195518f, 
    0.08919829f, 0.04582808f, 0.00609097f, 0.12319873f, -0.44650838f, 0.16797704f, -0.10076381f, 0.05321218f, 
    -0.05095894f, -0.10527088f, 0.10571884f, -0.03565092f, 0.04545758f, 0.02034240f, 0.07192949f, 0.04654003f, 
    0.07195118f, 0.05714863f, -0.03708211f, -0.08987018f, -0.00155746f, -0.04469806f, -0.02303658f, 0.03399276f, 
    0.09126154f, 0.05238625f, -0.19951068f, 0.09712668f, 0.09301832f, 0.03228802f, 0.00277777f, -0.01530055f, 
    -0.05731226f, 0.08185655f, 0.06248371f, -0.15738866f, -0.09279553f, -0.01321392f, -0.04373213f, 0.02449888f, 
    0.01689669f, 0.00559860f, -0.06742203f, 0.11363290f, -0.08723707f, 0.10086850f, -0.05819723f, 0.09066439f, 
    0.01521576f, -0.00477247f, -0.00196830f, 0.11041533f, -0.46323544f, -0.46518123f, -0.47217903f, -0.32307479f, 
    -0.12742893f, 0.01411648f, 0.08979990f, 0.01374039f, -0.22185531f, -0.07618888f, -0.13760529f, 0.07667981f, 
    -0.09139390f, 0.16139625f, -0.07540383f, 0.02615055f, 0.13979079f, 0.12446995f, -0.10751474f, 0.02361624f, 
    -0.13770093f, 0.09339295f, -0.26725048f, 0.05704962f, -0.23873807f, 0.11125005f, -0.33347026f, -0.17883818f, 
    -0.00129223f, 0.06535543f, 0.09750145f, -0.08060058f, 0.11062034f, 0.03788965f, 0.00132227f, -0.03705904f, 
    0.52346557f, 0.30590436f, 0.19867142f, 0.24832736f, -0.07592252f, -0.07471095f, 0.04074701f, 0.00415977f, 
    -0.05206190f, 0.06173767f, -0.17186055f, 0.05658924f, -0.18272795f, -0.08285447f, -0.08266384f, -0.03634360f, 
    -0.00267804f, -0.00675870f, -0.01922794f, 0.07579128f, -0.21519661f, 0.04336417f, 0.12194183f, 0.03077616f, 
    -0.20793170f, -0.05707454f, 0.00555660f, -0.06036458f, -0.02486165f, 0.07789849f, 0.07718138f, 0.09820743f, 
    0.05870411f, 0.08474108f, -0.05685027f, 0.10072947f, 0.09708794f, 0.04076055f, 0.11825263f, 0.00347286f, 
    -0.02274712f, 0.00166722f, -0.01633844f, -0.06832404f, -0.01322130f, 0.04450876f, -0.08822971f, 0.10524365f, 
    -0.18099658f, -0.35644054f, 0.17090032f, -0.15101846f, -0.03348894f, -0.08503343f, 0.09285146f, -0.17152253f, 
    0.04918616f, 0.02131794f, 0.00558501f, -0.01202971f, 0.07758684f, 0.26488045f, -0.09783205f, -0.22529370f, 
    -0.06037613f, -0.03116067f, 0.07911608f, -0.09118925f, -0.07208735f, 0.01068363f, -0.06428898f, -0.02057062f, 
    0.19699104f, 0.17351294f, -0.11928604f, -0.10457870f, 0.00158780f, 0.14391336f, -0.11494969f, -0.23390611f, 
    -0.04615473f, -0.05676297f, -0.10122240f, -0.04094068f, -0.08155317f, 0.12178326f, -0.11271139f, 0.13225789f, 
    0.18959463f, 0.03555724f, 0.17076378f, 0.20045325f, 0.06239066f, 0.04017856f, -0.01643718f, 0.00940128f, 
    0.19356190f, 0.21555820f, 0.10276793f, 0.01617589f, 0.22680905f, -0.08170789f, 0.00735846f, 0.32431015f, 
    -0.01746986f, 0.02434109f, 0.06923294f, -0.27241987f, -0.01651474f, -0.13696721f, 0.06440543f, -0.22865856f, 
    0.02266639f, -0.03031446f, -0.00062944f, -0.02705525f, -0.11262884f, -0.29172915f, -0.26893550f, -0.46373674f, 
    -0.05959715f, 0.04098038f, 0.07442582f, -0.06747672f, -0.00111736f, 0.08197942f, 0.02504743f, -0.05511545f, 
    0.03837333f, -0.02239408f, -0.05677861f, -0.05218115f, -0.09223329f, 0.09811620f, -0.03625758f, -0.02378791f, 
    0.02347594f, -0.06487643f, -0.01464247f, -0.04990422f, 0.05624116f, 0.09284901f, 0.12467261f, -0.04473044f, 
    0.06670771f, -0.11496067f, -0.06653298f, 0.08356990f, 0.13580769f, 0.02292256f, -0.07482449f, -0.14076377f, 
    -0.14617234f, 0.09955455f, -0.28990769f, -0.30020559f, -0.04075466f, -0.17077647f, -0.02484594f, 0.23620260f, 
    -0.14752321f, -0.05310205f, 0.22775488f, 0.00941855f, -0.02290566f, -0.01505418f, -0.02110506f, 0.04094576f, 
    -0.20830390f, 0.08593847f, 0.31727609f, -0.10701468f, -0.01725004f, 0.02898370f, -0.11417029f, 0.11288805f, 
    0.05691342f, -0.09497222f, 0.02862664f, -0.02225185f, -0.22051233f, 0.10393451f, 0.11283498f, -0.22246127f, 
    0.06457117f, 0.01523889f, -0.27305418f, -0.00854988f, -0.01257897f, -0.05047838f, -0.03198918f, -0.10972537f, 
    -0.33062363f, 0.01287098f, 0.08502129f, -0.60288882f, -0.06826837f, -0.06169122f, -0.13739337f, -0.14561562f, 
    0.03055613f, 0.00194923f, 0.01045551f, -0.03107435f, -0.32090580f, -0.10312212f, 0.36879238f, -0.43915334f, 
    -0.05586960f, 0.00717328f, -0.08353367f, 0.10461352f, 0.01263225f, -0.04743645f, -0.04033116f, 0.02613717f, 
    -0.11182493f, 0.11581805f, 0.04978788f, 0.12750214f, 0.01573235f, -0.04973174f, 0.03529030f, -0.00351274f, 
    0.10071847f, 0.00174378f, -0.05508087f, -0.00239272f, -0.04969845f, -0.06720845f, 0.13883068f, 0.09290852f, 
    -0.01498427f, -0.00358930f, -0.00683004f, 0.05355171f, 0.04735536f, -0.09498550f, 0.05585146f, -0.03308438f, 
    -0.05277900f, 0.03060405f, -0.10769023f, 0.08663675f, 0.00532482f, 0.03384062f, -0.03186919f, -0.04814588f, 
    0.07024886f, 0.02169757f, 0.06514042f, 0.12265427f, 0.13877228f, -0.13569307f, 0.07128996f, -0.07806509f, 
    -0.01329201f, -0.04193550f, 0.09286787f, -0.06488586f, -0.03338148f, 0.10701210f, -0.13588366f, 0.24257433f, 
    0.12827636f, 0.09360892f, -0.16164024f, 0.35693908f, -0.04878467f, 0.01680853f, 0.07039066f, -0.00724318f, 
    -0.03948798f, -0.03399527f, 0.10452036f, -0.06699922f, 0.14086297f, 0.11785275f, -0.12471470f, 0.04063304f, 
    0.00003918f, 0.03616184f, -0.06895378f, -0.30219039f, 0.01597762f, -0.05613859f, -0.03940815f, 0.12473366f, 
    -0.05613209f, -0.09648708f, 0.09517329f, -0.06575715f, -0.01223634f, 0.04551720f, -0.02158999f, 0.02968681f, 
    0.11285181f, 0.09972896f, -0.38584447f, 0.19086389f, 0.00399907f, -0.00260693f, 0.01732917f, -0.09115154f, 
    -0.04542662f, 0.08432645f, 0.01835841f, 0.02379197f, -0.00220069f, -0.06613955f, 0.05569543f, -0.00178333f, 
    -0.05968618f, -0.19185673f, 0.12149185f, -0.18744549f, -0.02136032f, -0.09018701f, -0.33768222f, -0.32474217f, 
    0.08987347f, 0.04683391f, -0.09710076f, 0.07318670f, -0.40092811f, 0.10747952f, 0.00551120f, -0.11059240f, 
    0.02529161f, -0.01367252f, 0.04251288f, -0.03210224f, -0.01510120f, -0.04002022f, 0.03102851f, -0.00126713f, 
    -0.22510061f, -0.03351673f, -0.07225861f, 0.02124691f, 0.00827716f, -0.01806561f, -0.03809819f, 0.01477923f, 
    -0.08063485f, -0.11244661f, 0.07878148f, -0.09024735f, 0.10522385f, -0.01136281f, 0.17412770f, 0.08997727f, 
    0.01675845f, 0.00286696f, -0.06779037f, 0.05990487f, 0.10262503f, 0.07837683f, 0.09688354f, 0.02009971f, 
    0.02610602f, 0.34090534f, 0.67011154f, 0.38785419f, -0.09322467f, 0.01172006f, 0.10163973f, 0.01134817f, 
    0.00854378f, -0.16196559f, 0.04394688f, -0.05735403f, -0.52811927f, 0.17217161f, 0.28509554f, 0.46851549f, 
    -0.07147488f, -0.12704398f, 0.04653617f, 0.04199997f, -0.03575230f, 0.01597998f, -0.02380885f, 0.02465594f, 
    -0.03797211f, -0.02141112f, 0.09855516f, 0.06577889f, -0.01065386f, -0.00652779f, 0.00197297f, -0.05748969f, 
    0.09891873f, 0.16094935f, 0.11834385f, 0.08900861f, 0.22190709f, -0.06542657f, 0.18583095f, -0.00278893f, 
    0.00802840f, -0.02011131f, 0.02513451f, 0.05629585f, -0.05656454f, -0.08042217f, -0.00384037f, 0.17581120f, 
    -0.03381431f, -0.08333969f, 0.04330062f, -0.00394206f, 0.13635392f, 0.13458470f, -0.10061195f, 0.07538077f, 
    -0.04719347f, 0.00649172f, 0.03825080f, -0.04774229f, -0.25902858f, -0.05283034f, 0.04919682f, 0.06670505f, 
    0.08293644f, 0.07579999f, 0.02205864f, -0.00829305f, -0.01312959f, -0.01913705f, -0.01633567f, 0.01227887f, 
    -0.02931493f, -0.08635024f, -0.17994922f, 0.20465747f, 0.00228440f, 0.05434130f, 0.05411504f, 0.00108143f, 
    -0.09913661f, 0.04643541f, -0.07444301f, 0.07232774f, 0.12208614f, 0.01606372f, 0.08395144f, 0.13404229f, 
    0.03150939f, 0.00362349f, 0.05930422f, 0.01242266f, 0.07720798f, 0.07178856f, 0.08467225f, 0.03328639f, 
    -0.08754876f, 0.02829432f, 0.07810870f, -0.02589879f, 0.00468269f, -0.04075292f, 0.00949475f, 0.01743334f, 
    0.01498265f, 0.07143691f, 0.03617355f, -0.13637899f, -0.25178051f, 0.18600765f, 0.08791076f, -0.31210664f, 
    -0.00535569f, 0.06771893f, -0.07310199f, 0.03894809f, 0.01842376f, -0.02084265f, 0.02940298f, 0.10311344f, 
    0.04964938f, -0.42378506f, -0.26716948f, -0.16125780f, 0.10497214f, -0.09504193f, 0.08223468f, 0.09644458f, 
    -0.06792781f, -0.13741772f, -0.00589510f, 0.00660209f, -0.02546026f, -0.02890879f, 0.06064671f, -0.03006436f, 
    0.02869049f, -0.00685851f, 0.00808949f, -0.07502866f, 0.04001123f, -0.08425138f, 0.08726460f, 0.07587341f, 
    -0.68294662f, -0.34416935f, -0.29153845f, -0.47090614f, -0.09926620f, 0.05911150f, 0.01116404f, -0.04769519f, 
    -0.02605795f, -0.04828054f, -0.02274017f, -0.00354142f, -0.00850369f, -0.03665980f, -0.03963798f, -0.00473137f, 
    -0.01864707f, -0.00593859f, 0.02881792f, 0.01829636f, 0.00134996f, -0.03152103f, 0.22205062f, -0.01216223f, 
    -0.23726708f, -0.19384013f, 0.00494635f, 0.06298085f, 0.03313121f, -0.10864617f, -0.14775947f, -0.23674868f, 
    0.02507094f, -0.04521275f, -0.04490227f, 0.02288486f, -0.04843407f, -0.10843790f, -0.11519692f, -0.08893856f, 
    -0.03885486f, -0.09445204f, 0.03495099f, 0.01343786f, 0.00404287f, -0.01555493f, -0.04434165f, 0.10622153f, 
    -0.02713302f, 0.06450334f, -0.38543278f, 0.26471269f, -0.18329152f, -0.10591599f, -0.05551902f, 0.22189470f, 
    0.01201797f, -0.02712925f, 0.06465983f, -0.08919042f, -0.04402316f, 0.13859411f, -0.10611142f, 0.05899545f, 
    0.03840463f, -0.16202736f, -0.02158293f, 0.04206750f, -0.07286019f, -0.03698834f, 0.06317578f, -0.00513967f, 
    0.03463628f, -0.01957978f, -0.04479083f, 0.16642441f, 0.07034044f, 0.01518266f, -0.04758124f, 0.05114660f, 
    -0.03935422f, -0.04785632f, 0.09224561f, 0.03324340f, -0.24226452f, -0.06380910f, -0.44004560f, -0.04289220f, 
    0.07188796f, 0.03829630f, -0.00398024f, 0.22811364f, -0.02662665f, 0.00220499f, -0.11243539f, -0.03885981f, 
    -0.18288830f, 0.05107316f, -0.02006312f, 0.04856551f, -0.14057337f, -0.16819941f, -0.17587942f, 0.04440659f, 
    0.03823823f, 0.01144523f, -0.03004167f, -0.02329433f, 0.10901220f, 0.08326929f, -0.13540038f, -0.03402038f, 
    0.03433486f, 0.19639842f, -0.06307811f, -0.07676743f, -0.09355170f, -0.00701123f, -0.00855744f, 0.05232422f, 
    0.38064834f, -0.28364187f, -0.09726530f, 0.12001587f, 0.16029347f, -0.06332091f, -0.01489734f, 0.02362943f, 
    0.05895189f, -0.07325079f, 0.01667626f, 0.03056289f, -0.13489459f, 0.11158927f, -0.22634518f, -0.12409518f, 
    0.04558808f, -0.13104884f, 0.06077549f, 0.11745813f, -0.04501273f, 0.01803065f, 0.08624012f, -0.09638382f, 
    -0.01938352f, 0.01067248f, -0.07665786f, -0.04052502f, 0.01540630f, -0.09105214f, -0.08646403f, 0.13736491f, 
    0.01258748f, 0.06625675f, 0.09607752f, -0.04660068f, -0.32860601f, 0.39487949f, 0.03452003f, 0.07387829f, 
    -0.00539988f, -0.19962439f, 0.11188680f, -0.06039641f, 0.00630866f, 0.11020504f, -0.04361557f, -0.03244837f, 
    -0.12509786f, -0.19406581f, 0.13950835f, -0.27471715f, 0.07094630f, 0.02289594f, -0.22500695f, -0.12440686f, 
    -0.03052880f, 0.07527480f, -0.04611564f, -0.01860668f, -0.03816622f, 0.05422547f, -0.05653903f, 0.11998940f, 
    0.00260212f, -0.10919842f, 0.01811017f, 0.03601569f, -0.08381944f, 0.07619007f, -0.01472909f, -0.06086342f, 
    0.00551694f, 0.10833593f, 0.00568129f, 0.25109413f, 0.03115200f, -0.01060018f, 0.05469809f, 0.03903377f, 
    0.02476584f, 0.01148249f, 0.06155059f, -0.07718013f, -0.06217990f, -0.09286580f, 0.08387560f, -0.04176262f, 
    -0.08015898f, 0.09779786f, -0.00460767f, 0.04109168f, 0.00885910f, -0.00839519f, 0.00611866f, 0.00568721f, 
    -0.43172073f, -0.39682722f, -0.39022326f, -0.22169152f, -0.06013783f, 0.00893598f, 0.00097717f, -0.08444985f, 
    0.03299825f, 0.04119185f, -0.04000693f, -0.00724713f, 0.51373690f, 0.15422179f, -0.02117431f, -0.08625332f, 
    0.01532544f, -0.05762153f, -0.00566912f, -0.01354924f, -0.15405595f, -0.17129843f, 0.15683284f, -0.11149902f, 
    -0.07083462f, -0.11090168f, -0.06123326f, 0.19358863f, -0.13820092f, 0.05489556f, -0.11044957f, -0.00644550f, 
    0.00127981f, -0.04757415f, -0.12115972f, 0.06418953f, 0.20124991f, 0.33933485f, -0.25763053f, 0.06768304f, 
    0.03229487f, 0.02449225f, -0.02853432f, -0.01038156f, -0.06024829f, -0.00763418f, 0.03274334f, -0.06524783f, 
    -0.03630413f, 0.06351665f, 0.18033049f, -0.07174862f, -0.01985217f, 0.01443026f, -0.01789786f, 0.02891247f, 
    0.02217658f, 0.00182527f, -0.04573868f, -0.06105494f, 0.19711494f, 0.03884252f, 0.14995353f, 0.16148913f, 
    -0.01238321f, -0.02060854f, 0.03093105f, -0.06764691f, -0.00639236f, -0.15441671f, 0.04644149f, 0.12016240f, 
    -0.00043058f, 0.00652746f, -0.03933542f, 0.08151894f, 0.02892713f, -0.04377232f, -0.09114078f, -0.09938412f, 
    0.13273685f, -0.03914198f, -0.03412379f, 0.09117343f, 0.06091596f, 0.16517879f, -0.20292044f, -0.07526351f, 
    -0.05432942f, -0.04302155f, 0.03396839f, 0.05316252f, 0.02750186f, -0.05040067f, 0.00409488f, -0.07039665f, 
    -0.04578533f, 0.14589970f, -0.24744199f, -0.09193876f, 0.00248042f, -0.03380234f, 0.16393051f, -0.05532274f, 
    0.00547070f, 0.00650291f, 0.02552696f, -0.09657727f, -0.13657178f, 0.31590956f, 0.39930543f, 0.25857094f, 
    -0.05445463f, -0.13502960f, 0.04032473f, 0.11374796f, 0.03116553f, 0.05133354f, -0.01970112f, 0.01345034f, 
    -0.04102306f, 0.16101469f, 0.05567247f, 0.01500861f, -0.14541984f, 0.23393039f, -0.20193203f, 0.03727571f, 
    0.02547641f, 0.01186361f, 0.03420381f, -0.00788285f, -0.37376484f, -0.01241113f, -0.26521394f, -0.05542009f, 
    -0.07420497f, 0.00555890f, -0.04144052f, -0.00695809f, 0.00034692f, -0.06460235f, -0.05325976f, 0.09035040f, 
    -0.02402533f, 0.15054059f, 0.50165737f, 0.53110552f, -0.08873335f, 0.02618238f, -0.15232374f, 0.05246951f, 
    -0.01720511f, -0.09562125f, -0.04599603f, 0.08874551f, 0.05324655f, -0.00205107f, 0.02439020f, -0.14979804f, 
    -0.04798125f, -0.03626294f, -0.08636486f, -0.00523866f, -0.02030798f, 0.06555288f, 0.15901211f, -0.07469164f, 
    -0.07690606f, 0.01670690f, -0.08377248f, 0.01223155f, -0.04039464f, 0.05468507f, -0.11179250f, 0.15961044f, 
    0.07175872f, -0.09514052f, 0.06117185f, -0.08732047f, 0.00290518f, 0.12997328f, -0.17844732f, 0.03646993f, 
    0.08017576f, -0.02851062f, 0.05981658f, 0.03588403f, 0.08805818f, 0.16228832f, 0.06937142f, -0.12632488f, 
    0.08628187f, 0.01239995f, 0.28593856f, 0.02280595f, -0.04422157f, 0.01188420f, -0.00642123f, 0.04694268f, 
    0.16857433f, 0.07303020f, -0.05004748f, 0.02753468f, -0.49922678f, -0.40847367f, -0.13631479f, -0.24608876f, 
    0.05848791f, -0.14670059f, 0.04049291f, -0.03147743f, 0.02645144f, -0.00923916f, -0.01290693f, -0.07427688f, 
    0.12443250f, 0.08822335f, -0.06450668f, 0.18084419f, -0.16527654f, 0.12320449f, -0.33952260f, 0.14198506f, 
    -0.04372735f, -0.18647337f, -0.21234225f, -0.01244982f, -0.21155244f, 0.13782836f, -0.05369801f, 0.36487639f, 
    0.26464829f, -0.01099738f, -0.19108425f, -0.21270970f, -0.01231668f, 0.18221278f, 0.28629491f, -0.00685773f, 
    -0.08088075f, -0.04183354f, 0.30193877f, 0.31787986f, -0.12471076f, 0.04272518f, 0.03789322f, 0.07996751f, 
    0.07852568f, -0.06952778f, -0.09516225f, 0.09655527f, -0.65874141f, 0.13253884f, 0.02668792f, -0.18505874f, 
    -0.16908984f, -0.09051391f, -0.29371831f, -0.02223262f, -0.05369030f, 0.04668872f, -0.04344366f, 0.01880037f, 
    -0.49007168f, -0.00737201f, -0.19021580f, -0.16589135f, -0.09375017f, -0.24498968f, -0.04197304f, -0.18745822f, 
    0.03673033f, -0.00105666f, -0.09782228f, 0.13673367f, -0.74291152f, 0.27673420f, -0.34255791f, -0.19319770f, 
    0.23890790f, 0.15642172f, 0.04076294f, -0.04960803f, -0.25211707f, -0.00325335f, -0.09342503f, -0.09576359f, 
    0.01882144f, -0.05650762f, -0.13058960f, 0.12373310f, -0.10175832f, 0.00592514f, -0.07143043f, -0.06173300f, 
    0.04924405f, 0.02075689f, 0.10839731f, 0.00118443f, -0.03893029f, 0.19259417f, -0.12954563f, -0.06376529f, 
    0.03533593f, 0.05113721f, 0.10920803f, -0.05277973f, -0.06732704f, -0.03429027f, -0.14122057f, 0.06679387f, 
    0.16200787f, 0.56410527f, -0.45111194f, -0.02254667f, 0.03619966f, -0.11251462f, -0.10103645f, -0.02988084f, 
    -0.06580456f, 0.05115556f, 0.04444062f, -0.27123934f, 0.19295105f, -0.00734439f, -0.00346422f, 0.10488970f, 
    0.03648426f, 0.01368371f, -0.07825658f, -0.05666463f, 0.04444013f, 0.11063912f, 0.02289294f, -0.03069542f, 
    -0.75204301f, 0.12734966f, -0.40614074f, 0.22511689f, 0.03236693f, -0.07459159f, 0.10773688f, -0.10252284f, 
    -0.04427590f, 0.03858484f, 0.16137739f, -0.00678562f, 0.34839365f, -0.01622581f, 0.20187578f, 0.00795303f, 
    -0.13563582f, 0.05176859f, -0.13815649f, -0.11696028f, -0.18827946f, -0.13299304f, 0.19612169f, -0.13034661f, 
    0.08804452f, -0.23451509f, 0.47808665f, 0.21233393f, 0.00597423f, 0.02960768f, -0.01419578f, 0.13188356f, 
    -0.03524991f, 0.00215390f, 0.05512341f, 0.04150909f, 0.10795724f, -0.22181717f, -0.07434430f, 0.10136955f, 
    0.04091747f, -0.01812100f, -0.03854983f, -0.04672381f, 0.15192932f, -0.00292921f, 0.04376752f, 0.00910044f, 
    -0.35907125f, -0.14974935f, -0.01752143f, -0.03065705f, 0.13189931f, -0.16554935f, -0.07490540f, 0.10616036f, 
    -0.14363156f, -0.13892266f, 0.04535531f, -0.18000180f, 0.16402359f, -0.11627338f, -0.04212245f, 0.22343950f, 
    0.05429675f, -0.04083023f, 0.14566748f, -0.10484312f, -0.14933743f, 0.01360210f, -0.01702917f, 0.09277590f, 
    0.12933156f, -0.23204251f, 0.00784498f, 0.24381264f, 0.17344810f, 0.10736614f, 0.01896984f, -0.04753917f, 
    -0.03514103f, 0.04208460f, 0.05302271f, 0.02729065f, 0.03159583f, -0.19400384f, -0.07207689f, 0.21744147f, 
    -0.00705474f, -0.04670122f, -0.02118107f, -0.09715617f, 0.06879269f, 0.00822316f, -0.00975798f, 0.03430219f, 
    -0.22717519f, 0.93062365f, -0.32701916f, 0.04765436f, 0.18151012f, 0.08951900f, 0.23207237f, -0.15119526f, 
    -0.02353452f, 0.16449749f, -0.12374811f, 0.04110867f, 0.54790509f, -0.04146387f, 0.01173976f, 0.04659941f, 
    -0.11356387f, 0.05631699f, 0.06541846f, -0.07220708f, -0.15689641f, -0.07848179f, 0.16483741f, -0.06462117f, 
    0.08321483f, -0.12917355f, -0.00783905f, -0.11854170f, -0.03060158f, 0.00589450f, -0.20043038f, -0.17394561f, 
    -0.02071023f, 0.12605821f, 0.02433996f, -0.07230801f, -0.16528583f, 0.02268979f, 0.09683932f, 0.15539671f, 
    -0.10783403f, -0.15416874f, 0.04170691f, -0.10321071f, -0.00626613f, -0.09422191f, -0.10857039f, 0.03704558f, 
    0.13423929f, 0.12213784f, -0.01781925f, -0.46696246f, -0.08822623f, 0.02793796f, -0.03831461f, 0.10888240f, 
    -0.11069508f, 0.09237405f, 0.04890423f, 0.03782426f, 0.11756825f, 0.03474346f, 0.03382767f, -0.05031022f, 
    0.13506566f, -0.00080657f, -0.05537339f, -0.10578518f, -0.00096538f, -0.02329469f, -0.03863399f, 0.02412941f, 
    -0.50033087f, -0.08877491f, 0.08163694f, -0.19733611f, -0.17775622f, -0.10577906f, 0.07196502f, -0.02621554f, 
    -0.03384638f, 0.05711688f, 0.05064554f, -0.00625252f, -0.41163883f, -0.17446584f, 0.14795513f, -0.11502775f, 
    -0.38906038f, 0.02140509f, -0.02966604f, -0.14054997f, 0.05968074f, -0.02329068f, -0.00380559f, 0.10874507f, 
    0.08803567f, 0.10715638f, -0.27096933f, -0.57037884f, 0.19653712f, 0.02789952f, -0.03594289f, -0.06302425f, 
    -0.06218848f, 0.06046031f, -0.12415656f, 0.16523287f, 0.03722993f, -0.05719186f, -0.01338846f, 0.01780254f, 
    -0.04497924f, -0.00667460f, 0.01882096f, -0.10410029f, -0.15516834f, -0.07973643f, -0.04685624f, -0.00809227f, 
    -0.04356880f, -0.04896569f, -0.01288194f, 0.23576188f, -0.05312994f, 0.04967409f, 0.12374200f, 0.00681936f, 
    -0.06819917f, 0.05504504f, -0.16166289f, -0.03096453f, -0.18602675f, 0.36222625f, -0.06468695f, 0.14006019f, 
    -0.02134801f, -0.00218792f, 0.14098856f, 0.05197280f, -0.12081657f, 0.11744264f, 0.00231544f, -0.01716415f, 
    0.09584481f, -0.11874445f, 0.07910518f, 0.20025274f, 0.00925714f, -0.00297407f, -0.04142232f, 0.27027041f, 
    -0.05205954f, -0.10197097f, 0.10369579f, 0.00763435f, -0.10299757f, -0.31107798f, -0.40974897f, -0.01177956f, 
    -0.29965934f, -0.17512046f, -0.01497044f, 0.07637133f, 0.05750728f, -0.00761450f, 0.07269032f, 0.02253291f, 
    -0.26926640f, 0.50463444f, -0.37650645f, -0.31750703f, -0.23048601f, -0.05338122f, -0.04431893f, -0.01839797f, 
    -0.21462047f, -0.03584911f, -0.02348781f, 0.10503728f, 0.07093327f, 0.74224728f, -0.23308648f, 0.38587224f, 
    -0.01828564f, 0.12870841f, 0.09534796f, -0.03048369f, 0.07678450f, -0.11889149f, 0.01829112f, 0.25817776f, 
    0.27615145f, 0.04785400f, -0.12113111f, -0.54891616f, -0.03123330f, -0.06414040f, -0.09679979f, -0.03688880f, 
    -0.00057014f, -0.05301522f, -0.10495336f, -0.03111866f, 0.02115740f, -0.21074314f, 0.06403019f, -0.07649052f, 
    0.01631210f, -0.02019140f, 0.01025946f, 0.01264197f, -0.13625008f, 0.34840798f, -0.05997897f, -0.02551509f, 
    -0.04659761f, 0.11124205f, -0.01966962f, 0.39819935f, -0.07383109f, -0.13192770f, -0.19071433f, -0.12332229f, 
    0.02194691f, 0.09850451f, -0.01846612f, 0.09255031f, 0.88648009f, 0.11717599f, -0.08095795f, -0.06083832f, 
    0.20939434f, -0.01172313f, 0.03056426f, -0.18372412f, -0.17347516f, -0.00287906f, 0.17246808f, -0.05452316f, 
    0.58976525f, 0.51221454f, 0.11040003f, 0.18893734f, -0.17995964f, 0.16095516f, -0.21214476f, 0.07462992f, 
    -0.18169391f, 0.23016766f, -0.06368063f, -0.12506340f, -0.32497412f, 0.29584655f, -0.28677353f, 0.01946027f, 
    -0.03129098f, 0.02629309f, 0.09010031f, -0.23243684f, -0.05612256f, 0.01865982f, 0.18245955f, -0.13629943f, 
    0.15043902f, 0.09661349f, -0.03173347f, 0.08715934f, 0.08123287f, -0.35128421f, -0.05902924f, -0.00069497f, 
    -0.18279421f, 0.12436920f, -0.08582635f, -0.02052873f, -0.07381702f, -0.17837767f, -0.03209498f, 0.15351857f, 
    -0.00319822f, -0.05470644f, -0.07881115f, -0.13663213f, -0.11085810f, 0.10705794f, 0.04834291f, 0.04648119f, 
    -0.09718420f, -0.06717306f, 0.11458933f, 0.26631033f, -0.04661912f, -0.01159789f, 0.14289896f, -0.00920892f, 
    -0.08906341f, 0.08746465f, -0.06984132f, 0.13214885f, 0.05263221f, 0.22125530f, -0.37871540f, -0.03410476f, 
    -0.04998975f, -0.03232158f, -0.01410151f, -0.01135225f, 0.01099262f, -0.08939463f, 0.08970596f, -0.05251114f, 
    0.07580233f, -0.19416599f, -0.11196774f, -0.35021928f, 0.22554708f, 0.09146708f, -0.00469996f, -0.02334883f, 
    0.07387327f, 0.07342463f, -0.15527818f, -0.00991198f, 0.03329249f, -0.02159111f, 0.18655562f, 0.00128077f, 
    -0.12668075f, 0.06014009f, -0.18851499f, -0.10138285f, -0.13793091f, -0.07893685f, 0.01167851f, -0.18931715f, 
    -0.16103660f, -0.23477133f, -0.04043271f, 0.23021783f, 0.14689983f, 0.12004378f, 0.14120217f, 0.00626113f, 
    0.08407267f, 0.03460209f, 0.05975276f, -0.12752470f, -0.10716438f, -0.01546906f, 0.17274225f, -0.00147242f, 
    0.06767012f, 0.03311921f, -0.09309314f, 0.03829096f, -0.02691588f, 0.13099007f, -0.06595158f, -0.03954918f, 
    -0.30117401f, 0.00298354f, -0.01321938f, -0.50851613f, -0.14013468f, -0.00634373f, -0.07314235f, -0.08873934f, 
    0.11729936f, 0.17468387f, -0.13928460f, -0.07936522f, 0.22975890f, -0.03243237f, -0.06956898f, -0.22023001f, 
    0.01325928f, -0.03909025f, -0.14249140f, 0.01633210f, -0.15820800f, -0.11367506f, -0.00360980f, -0.14725418f, 
    0.30089232f, 0.02300509f, 0.14168122f, 0.13067941f, 0.15883867f, 0.08644995f, -0.13180161f, 0.12714359f, 
    -0.14419553f, 0.02353237f, 0.12749785f, 0.01790581f, 0.00826400f, -0.06072038f, 0.00136553f, 0.08129085f, 
    0.15052137f, 0.06819978f, 0.08175743f, -0.09997112f, -0.15613911f, -0.09656250f, 0.04061862f, 0.00994548f, 
    0.04522332f, -0.16880204f, -0.16361591f, 0.04898302f, 0.15138826f, 0.18630163f, 0.06474322f, 0.06970216f, 
    0.06361567f, -0.01804829f, -0.23634993f, 0.11109461f, -0.16706528f, -0.07344281f, -0.01262386f, -0.31940317f, 
    0.00979589f, 0.06399701f, -0.03423097f, 0.10063407f, -0.17268285f, 0.06182989f, -0.10834136f, 0.01285792f, 
    0.02551895f, 0.02658609f, -0.25966725f, 0.12982252f, 0.10172608f, -0.03044958f, 0.05655957f, -0.01645580f, 
    -0.06172553f, -0.12862428f, -0.05034858f, 0.10382501f, 0.14918666f, -0.23392415f, 0.01609981f, 0.03444595f, 
    0.14845747f, 0.01596338f, 0.03858611f, 0.06319539f, 0.06093342f, 0.00726309f, 0.13525406f, 0.08800281f, 
    -0.04548058f, -0.02124882f, -0.15483363f, 0.08070115f, -0.13222151f, -0.00741007f, 0.06057578f, -0.11407757f, 
    0.03009330f, -0.02335690f, -0.12592515f, -0.01477295f, 0.02796059f, -0.11577326f, -0.13436724f, 0.06603405f, 
    0.07192461f, 0.09091125f, 0.02018346f, -0.05477144f, -0.09661993f, 0.01251506f, 0.04124349f, 0.00295626f, 
    0.13246544f, -0.12969004f, -0.04278674f, 0.10492621f, -0.03270917f, 0.07678350f, -0.07005700f, -0.02484195f, 
    0.03008577f, 0.10584901f, -0.03325989f, 0.12648192f, -0.04127987f, 0.21094908f, 0.13531032f, 0.38069430f, 
    -0.03054236f, -0.03023096f, 0.03515550f, 0.00236383f, -0.09165614f, -0.03567316f, 0.00664346f, -0.08263519f, 
    -0.07588338f, -0.01626278f, -0.06991024f, -0.03235201f, -0.21404251f, -0.17374602f, 0.00421358f, 0.01192813f, 
    0.03026413f, 0.10642730f, -0.17431973f, -0.00652965f, -0.25096747f, 0.65288132f, -0.04569529f, -0.52942628f, 
    0.20468867f, 0.09110639f, -0.02591835f, -0.08826230f, -0.17993748f, -0.05865411f, -0.01786475f, 0.04326331f, 
    -0.12305139f, 0.13326308f, -0.23444223f, 0.12922172f, 0.06828780f, 0.04584895f, -0.01855336f, -0.02503805f, 
    -0.14200491f, 0.01816296f, -0.12715103f, 0.00525049f, -0.06973977f, -0.08005668f, -0.24823765f, 0.17627695f, 
    -0.03611120f, 0.05565382f, -0.11590056f, 0.07808971f, -0.02784257f, -0.03839858f, 0.06411981f, -0.00033125f, 
    0.17152236f, 0.03176664f, -0.12253287f, -0.37027556f, 0.06950069f, 0.07068712f, 0.01237987f, -0.00378611f, 
    -0.01963370f, -0.05037702f, -0.00794681f, -0.06077686f, 0.00789580f, -0.04131553f, 0.09103812f, 0.05421362f, 
    -0.08286291f, 0.00394643f, -0.23811555f, 0.08518384f, -0.11611383f, -0.22425301f, -0.09097042f, -0.01305072f, 
    0.21012752f, 0.42711660f, 0.06834739f, 0.31184977f, 0.34952411f, 0.15484376f, 0.07398872f, 0.00241846f, 
    -0.00832615f, -0.04665394f, 0.05026392f, -0.06190517f, 0.20349307f, -0.19063951f, -0.49388713f, 0.03893178f, 
    0.04431399f, -0.01433961f, 0.09473075f, 0.01658743f, 0.11627896f, -0.00510085f, 0.00851906f, -0.03220341f, 
    -0.15266488f, 0.11382464f, -0.13745846f, -0.24612565f, 0.02582709f, 0.08665755f, -0.03755850f, -0.10375803f, 
    -0.06763650f, -0.05963690f, -0.00860571f, -0.07970619f, -0.09113909f, -0.30785006f, -0.01888820f, -0.03282077f, 
    -0.07966852f, -0.08531315f, 0.03617196f, 0.01938375f, -0.13302128f, 0.05859797f, 0.14062695f, -0.10670908f, 
    -0.01642814f, -0.03430595f, -0.10780948f, -0.01870720f, -0.01411393f, 0.08676651f, -0.00062610f, -0.06818209f, 
    0.07227080f, 0.20733914f, 0.01916723f, 0.42344034f, 0.00025438f, -0.22296719f, 0.06334721f, -0.01269220f, 
    -0.05458594f, -0.08314676f, 0.09702361f, -0.02655281f, -0.11839417f, 0.15198584f, 0.17952582f, 0.00546618f, 
    -0.43951327f, -0.57618725f, 0.01104946f, -0.79678613f, -0.02459432f, 0.04094185f, -0.02623956f, 0.06114925f, 
    -0.01586112f, -0.12557703f, -0.01097566f, -0.03852664f, -0.04001746f, 0.04245333f, -0.01406337f, 0.19911073f, 
    -0.01941808f, 0.03297516f, -0.15692781f, -0.15511331f, -0.01419527f, -0.03835375f, 0.09313963f, -0.20422065f, 
    0.17484337f, -0.03339380f, 0.01100611f, -0.10108879f, 0.00244430f, 0.01144499f, 0.02459257f, -0.00565048f, 
    -0.15693267f, -0.02989251f, -0.21595170f, -0.05769181f, -0.01977502f, -0.00903131f, -0.09837595f, 0.04504837f, 
    -0.03393358f, -0.05947645f, -0.06321219f, 0.08110428f, 0.13273443f, 0.04581709f, -0.02057183f, -0.01659135f, 
    0.06196978f, 0.44922966f, -0.17247635f, 0.30389071f, 0.00974199f, 0.19020557f, 0.01578546f, -0.13650511f, 
    0.08081678f, -0.02172754f, -0.02385947f, -0.02240422f, -0.00098176f, 0.05397070f, 0.17284602f, 0.11951728f, 
    -0.08786007f, -0.07111994f, -0.16318993f, 0.05034542f, 0.06826223f, 0.02465137f, 0.03513421f, -0.05031203f, 
    0.13601226f, -0.00312328f, 0.01911083f, 0.02680792f, 0.09968526f, 0.03100657f, 0.06367791f, 0.04611140f, 
    0.05064834f, -0.03684568f, -0.07447655f, -0.06240257f, -0.12422237f, -0.12279622f, 0.09438061f, 0.02913514f, 
    -0.12664932f, -0.06600410f, -0.15923107f, -0.05735472f, -0.11311322f, 0.00201162f, -0.07495721f, 0.11127337f, 
    -0.05085316f, 0.19765908f, 0.15124685f, 0.22312960f, -0.11873915f, -0.19273922f, 0.05919939f, 0.03331479f, 
    -0.16931011f, -0.01951668f, 0.00281203f, 0.10700256f, -0.14355060f, -0.11388410f, 0.09550420f, 0.14247601f, 
    -0.08589547f, -0.03048158f, -0.07582818f, -0.01323384f, 0.02539202f, -0.03105521f, 0.02788977f, 0.00566896f, 
    0.08723097f, -0.27179450f, -0.00033396f, -0.19803704f, 0.00588865f, 0.07430948f, -0.06838300f, 0.03278869f, 
    0.12688714f, 0.04913338f, 0.06574912f, 0.20219971f, -0.19539657f, -0.00310108f, -0.34153062f, -0.06271200f, 
    0.06483837f, 0.07635172f, -0.02601667f, -0.03080513f, -0.09326117f, -0.04510733f, -0.04638186f, -0.02306958f, 
    0.00703926f, 0.08491915f, -0.04664448f, 0.00549304f, -0.06804792f, -0.02804030f, 0.05486180f, 0.00015519f, 
    0.03822339f, -0.05640161f, -0.05452530f, -0.14885885f, -0.01475724f, -0.03507190f, 0.01932820f, 0.06451260f, 
    0.04027799f, 0.01693763f, 0.01169835f, 0.07362351f, -0.02679764f, 0.02320201f, -0.06762562f, -0.05553427f, 
    0.20308979f, -0.19078310f, 0.08045051f, 0.08471623f, -0.02329976f, -0.11932977f, -0.09116556f, 0.00115038f, 
    -0.18533583f, -0.09142680f, -0.14068003f, -0.11030795f, -0.05955503f, -0.01657837f, -0.01391848f, 0.10833661f, 
    -0.11620852f, -0.08825184f, 0.01731982f, 0.01223048f, -0.09563079f, -0.01054893f, -0.15046708f, 0.07751623f, 
    0.13296048f, -0.00541582f, -0.07501075f, 0.06906629f, -0.01052590f, 0.07430876f, -0.06711185f, -0.08273001f, 
    -0.03021126f, 0.10491867f, -0.11488527f, 0.08105365f, -0.09051602f, -0.04963319f, -0.11131016f, 0.17934528f, 
    0.09466568f, -0.00554089f, -0.16558620f, 0.03551224f, 0.01026337f, 0.01956213f, -0.13809633f, -0.05926158f, 
    0.06187125f, -0.08091450f, -0.08267947f, 0.03906092f, 0.05474555f, 0.00471630f, -0.00084983f, 0.02021622f, 
    -0.07538683f, 0.01771060f, -0.08615624f, 0.00447124f, -0.18832287f, 0.13730834f, -0.07580265f, -0.02458908f, 
    0.02553420f, -0.02413940f, -0.01985554f, -0.12666811f, -0.00439845f, -0.02581011f, -0.14455470f, 0.09449293f, 
    0.01676503f, 0.11802187f, 0.14621246f, 0.12938757f, 0.04014874f, 0.00518003f, 0.00775411f, 0.04931789f, 
    0.01819408f, -0.01350953f, 0.03212296f, -0.01483042f, 0.02835289f, -0.05211953f, 0.06737138f, -0.06288565f, 
    0.01687547f, 0.03147685f, 0.03236904f, -0.03344428f, 0.01955347f, -0.08194167f, 0.02033234f, 0.23511776f, 
    0.11362833f, 0.09090776f, 0.14789018f, 0.17918354f, -0.16272260f, 0.08341063f, 0.06379501f, 0.19087048f, 
    0.04890548f, -0.06910995f, -0.03120706f, -0.00107622f, -0.00280085f, -0.01064191f, -0.02437940f, 0.00498951f, 
    0.12462796f, 0.02513614f, 0.03007530f, 0.04301634f, 0.15877682f, 0.05701662f, 0.06232585f, 0.09164260f, 
    -0.14892669f, -0.50182992f, 0.47876680f, 0.05448881f, -0.32020953f, 0.09808028f, -0.31906816f, -0.10746204f, 
    -0.18040180f, 0.15552808f, -0.12564653f, 0.03296893f, -0.01234739f, -0.11118414f, 0.12888236f, 0.26163614f, 
    0.05735516f, -0.15639132f, -0.06031466f, -0.00547047f, -0.07816456f, 0.01353028f, -0.07362790f, 0.11416356f, 
    -0.44123578f, -0.05491965f, -0.14868329f, 0.23297493f, 0.03204716f, -0.04333944f, -0.01964667f, -0.06909668f, 
    -0.10595358f, -0.00246394f, -0.10244928f, 0.05841651f, 0.04295779f, -0.00007632f, -0.03302267f, 0.10730293f, 
    -0.07853012f, 0.02794227f, -0.05132066f, -0.13763013f, 0.01662442f, -0.05681413f, -0.00456024f, 0.02893322f, 
    0.24817872f, -0.02666465f, 0.34864101f, -0.19252922f, 0.06724375f, 0.04303782f, -0.03433932f, 0.04045743f, 
    0.08058689f, -0.06793685f, -0.00899757f, 0.00683556f, 0.14082912f, -0.13203658f, -0.11115769f, -0.01998413f, 
    -0.00937915f, -0.17105952f, -0.03642317f, 0.13825418f, 0.09184636f, -0.19225442f, -0.10404346f, -0.04443403f, 
    0.09824370f, -0.27191037f, -0.09812218f, -0.12255275f, -0.02556028f, -0.16313441f, 0.00447415f, -0.24442130f, 
    0.11368590f, -0.07195516f, 0.03688244f, -0.12295094f, 0.05001033f, 0.05755517f, 0.07287534f, 0.04899350f, 
    0.06267685f, 0.05965361f, -0.00136292f, -0.02872953f, 0.01582962f, 0.01605971f, -0.09051166f, 0.00057541f, 
    0.07378904f, 0.03419387f, 0.04892149f, 0.05046639f, -0.00346893f, 0.14832604f, 0.10419223f, -0.05684482f, 
    -0.12546796f, 0.03793046f, -0.00838534f, -0.17211795f, -0.32969809f, -0.21744588f, 0.01504566f, 0.06071621f, 
    0.00851817f, 0.00545846f, -0.14131546f, 0.04354711f, -0.10561310f, -0.25867239f, -0.07840831f, -0.03183557f, 
    0.27293125f, 0.02216576f, -0.12219230f, 0.12156585f, 0.14004263f, 0.03854632f, -0.10519160f, -0.04709207f, 
    0.03205653f, -0.01868334f, -0.01301226f, -0.00808846f, 0.06597187f, -0.15490519f, 0.15881684f, 0.02634200f, 
    -0.10605203f, -0.07163034f, -0.11202572f, 0.12023117f, -0.12707210f, -0.04685544f, -0.04183552f, 0.00852594f, 
    0.00026428f, 0.02371571f, -0.09491743f, 0.02058695f, 0.01393341f, -0.08549612f, 0.07101288f, 0.01458116f, 
    -0.08677944f, -0.04263597f, -0.18523037f, -0.14675802f, 0.03722723f, 0.00366670f, 0.01480541f, 0.03231027f, 
    0.04251364f, -0.19551644f, 0.05679626f, 0.14555283f, 0.01529326f, 0.01995436f, -0.09150950f, -0.08008137f, 
    0.16199137f, 0.23509802f, 0.39083499f, 0.18811920f, -0.11940755f, -0.03719371f, 0.10392082f, 0.08356982f, 
    0.00595844f, 0.00058910f, -0.02232655f, -0.04306872f, 0.20722421f, 0.13046372f, -0.03104851f, 0.13729607f, 
    0.00490898f, 0.03830701f, 0.04420534f, -0.10230536f, -0.10524411f, -0.06165928f, 0.04205689f, 0.09701779f, 
    -0.05122285f, -0.07479291f, -0.00333659f, -0.13670732f, -0.19606623f, 0.06129957f, 0.10140380f, 0.06195435f, 
    -0.04999601f, 0.00362686f, -0.05772992f, -0.07859258f, -0.26142278f, 0.01648123f, -0.11913119f, -0.16196026f, 
    -0.08135545f, -0.10582982f, -0.00799400f, 0.14266296f, 0.04902456f, -0.08638004f, -0.08055016f, -0.13023095f, 
    -0.56450152f, -0.07515007f, -0.42804933f, -0.07961097f, 0.08956677f, 0.03647929f, -0.01334576f, 0.08184213f, 
    0.04223086f, -0.03571074f, 0.01543101f, -0.00453623f, 0.16953643f, 0.01567757f, 0.03386523f, 0.13654448f, 
    -0.04521289f, -0.04088015f, 0.00826159f, -0.01565922f, 0.21425998f, -0.02020301f, -0.06600492f, 0.03049636f, 
    0.06023651f, 0.06376534f, 0.11356695f, 0.10367738f, 0.12616798f, -0.02115608f, -0.05104993f, -0.04393124f, 
    0.06349771f, -0.13620825f, 0.15982625f, 0.04158108f, 0.11121391f, -0.07878523f, -0.11513565f, 0.00871223f, 
    0.10844886f, 0.03776681f, 0.06116976f, -0.02944801f, -0.02407305f, -0.07097860f, 0.05688079f, -0.12057854f, 
    -0.13615668f, -0.02696575f, 0.06378943f, -0.05961817f, -0.06489756f, 0.18871772f, -0.12874806f, -0.08555201f, 
    -0.06351861f, -0.08507323f, -0.03155718f, -0.06689712f, -0.09030248f, 0.04917007f, 0.12708625f, 0.21096084f, 
    -0.03440207f, -0.07062227f, -0.08841775f, -0.01801113f, 0.05675165f, 0.01336869f, -0.01140929f, 0.06136323f, 
    -0.20406871f, -0.17810374f, 0.23417795f, -0.06615772f, -0.00789979f, 0.09847900f, -0.01927206f, -0.03763203f, 
    0.06046315f, -0.08204236f, -0.02889913f, -0.14536920f, 0.04827931f, 0.13863260f, 0.16537301f, 0.18263523f, 
    -0.04148635f, -0.11661167f, -0.10114159f, -0.03433296f, 0.10429394f, -0.04404042f, 0.05458825f, -0.02075189f, 
    -0.04340910f, 0.06877695f, 0.01808737f, 0.11745382f, -0.02362835f, -0.07564908f, -0.01504302f, -0.20702662f, 
    0.02457380f, -0.03475251f, 0.04987744f, -0.01372731f, -0.00093626f, 0.05623759f, -0.00384724f, 0.03771873f, 
    -0.01449422f, -0.11261085f, 0.02340822f, -0.01474947f, 0.18523993f, 0.26682287f, 0.05034039f, 0.27275220f, 
    0.10348079f, 0.07325661f, -0.10099999f, 0.02627278f, -0.11160830f, -0.07971901f, 0.07933182f, -0.07765084f, 
    -0.09550554f, -0.00184840f, 0.08047898f, -0.02559232f, 0.07082944f, -0.31713271f, -0.04864912f, -0.04222846f, 
    -0.01063682f, -0.01828294f, -0.03926698f, -0.03692689f, 0.05688243f, 0.03557169f, -0.17088664f, 0.10538607f, 
    -0.12457240f, 0.03993675f, 0.00078784f, -0.07486062f, -0.04982025f, -0.06241360f, -0.04814022f, 0.00879385f, 
    0.10944083f, 0.01765192f, 0.03338022f, 0.19145676f, 0.09170616f, 0.08162521f, 0.31078285f, 0.02256844f, 
    -0.01756761f, 0.00597768f, -0.14422636f, 0.00845864f, 0.01139520f, 0.05265085f, -0.02889122f, 0.07871982f, 
    0.10716674f, -0.22545610f, -0.43996468f, 0.17334667f, 0.02363705f, -0.02632295f, -0.03302265f, -0.01272469f, 
    0.23281305f, -0.03133918f, 0.01547855f, 0.16601007f, -0.23444198f, -0.08765514f, -0.03719430f, -0.08364531f, 
    -0.09017777f, 0.16336338f, -0.05136297f, -0.02410124f, 0.11936233f, 0.01286554f, -0.05492571f, 0.08880366f, 
    -0.08550909f, 0.00780503f, -0.17528877f, -0.06922232f, 0.18253693f, 0.01186052f, 0.17918211f, 0.15229985f, 
    0.00013461f, 0.02396091f, 0.00094511f, -0.07731204f, 0.21160670f, -0.02150559f, -0.51655173f, 0.54950720f, 
    0.04016115f, -0.06778894f, -0.01882511f, -0.01031030f, 0.07785337f, 0.02623708f, 0.01256991f, 0.00596944f, 
    -0.00524047f, -0.14628282f, -0.02361452f, -0.21802986f, -0.00420300f, -0.01184902f, -0.06279313f, -0.00761349f, 
    0.04560806f, 0.00354524f, 0.14427616f, 0.00292887f, -0.46209291f, -0.06307074f, 0.23303692f, -0.12858029f, 
    0.00326510f, 0.00311880f, 0.02694833f, 0.06591558f, 0.13795221f, 0.04281106f, -0.02861476f, 0.19314690f, 
    0.00081423f, -0.21776412f, 0.17489058f, 0.06142015f, 0.02483457f, -0.03166953f, -0.01377788f, 0.11543057f, 
    0.01145735f, -0.26517805f, -0.19711751f, -0.59873128f, -0.22299843f, 0.06111272f, 0.02486744f, 0.05354190f, 
    0.06263214f, -0.11319328f, -0.06362098f, 0.03019948f, -0.18948264f, -0.06201438f, -0.00735032f, -0.15489759f, 
    0.09671637f, -0.10054644f, 0.17807683f, -0.01097992f, 0.08806372f, -0.03622501f, -0.08550251f, -0.03644237f, 
    0.03226465f, 0.05521588f, 0.04460485f, 0.04080344f, -0.01596602f, 0.16922826f, -0.12530497f, 0.15219411f, 
    -0.04646783f, -0.10214282f, 0.04344460f, 0.06895402f, -0.18374391f, -0.07317998f, -0.12497698f, -0.05868854f, 
    -0.12838711f, 0.05908395f, -0.10410506f, -0.22873282f, 0.04411223f, -0.03365358f, -0.04903554f, 0.07579627f, 
    0.10962694f, 0.02544830f, 0.30078036f, 0.12240163f, -0.12781820f, 0.07783601f, -0.15508807f, 0.33940214f, 
    0.14920171f, -0.14099538f, -0.09418263f, 0.14312413f, -0.03427636f, 0.12185630f, -0.10597185f, 0.10514752f, 
    -0.32345033f, -0.07176964f, -0.32091630f, 0.09999359f, 0.19868432f, -0.10824146f, 0.04929230f, -0.00245257f, 
    0.00259887f, -0.02524372f, 0.05558848f, -0.01524838f, 0.03783197f, 0.17276755f, 0.06694087f, 0.03100940f, 
    0.11029761f, 0.15417272f, 0.27554202f, 0.13124853f, 0.05500233f, -0.01640558f, 0.08194581f, 0.06828072f, 
    -0.11434808f, -0.05635410f, -0.03377137f, 0.01959484f, -0.01322423f, -0.09225620f, -0.09008963f, -0.04336748f, 
    0.11450820f, 0.09516812f, -0.12981813f, 0.27350372f, -0.11942143f, 0.16461548f, -0.08527394f, -0.12876603f, 
    0.03282324f, -0.05789519f, 0.06311125f, 0.16552211f, -0.05962089f, -0.01842979f, 0.03170115f, -0.02080465f, 
    -0.45696625f, -0.18035010f, -0.26584369f, -0.46690169f, -0.02544197f, -0.00576903f, -0.03969713f, 0.00915378f, 
    -0.01537287f, -0.06567594f, -0.13932535f, -0.11504919f, -0.10808926f, 0.12032763f, 0.00654117f, -0.18758889f, 
    0.08082613f, 0.04675242f, 0.10105249f, 0.04391774f, 0.03717260f, 0.03589047f, 0.03505024f, 0.04856443f, 
    -0.03478148f, -0.10060935f, -0.05934034f, 0.03369721f, -0.08824283f, -0.03167829f, 0.06076534f, 0.00761246f, 
    -0.18706863f, -0.45290396f, -0.12865664f, -0.37328953f, -0.12847358f, -0.05677443f, -0.16054653f, 0.00318520f, 
    -0.03557876f, -0.04300665f, -0.01234662f, -0.01972873f, 0.27347243f, -0.03075988f, -0.11745424f, 0.03608732f, 
    -0.02038448f, 0.01507577f, 0.05839775f, -0.07175072f, -0.08532808f, -0.04054174f, -0.06456170f, -0.02433423f, 
    0.06646244f, 0.06985931f, 0.00078501f, 0.08188480f, 0.02771063f, -0.21920989f, -0.09730184f, 0.05060290f, 
    0.03342473f, -0.02379533f, -0.07995452f, 0.00889561f, -0.01543023f, 0.03938209f, 0.05355372f, 0.06455091f, 
    0.17999500f, -0.15692990f, 0.12057909f, 0.10073524f, -0.04476688f, -0.04122676f, -0.03535828f, 0.02137753f, 
    0.07560953f, -0.03351908f, 0.00548700f, -0.01009031f, -0.20914398f, 0.00479861f, -0.10104894f, -0.05158410f, 
    0.09033685f, 0.02202786f, -0.02751498f, 0.15779908f, 0.10309748f, 0.01323288f, -0.06148739f, -0.09939598f, 
    -0.25246620f, -0.14201988f, -0.01092973f, -0.06400294f, -0.04139949f, 0.03070724f, -0.06575803f, 0.08247715f, 
    -0.03461393f, -0.06958371f, 0.06412457f, -0.02738420f, 0.29451191f, -0.03027319f, -0.15609132f, 0.05460592f, 
    0.17096864f, 0.04220642f, 0.03982554f, 0.03212247f, -0.01321950f, 0.05366410f, -0.01391633f, -0.08549761f, 
    -0.21342303f, 0.18914269f, -0.05480108f, 0.04626352f, -0.00506509f, -0.07080066f, -0.16300862f, 0.05044108f, 
    0.10892693f, -0.17054200f, 0.24351312f, -0.12969448f, 0.20494017f, 0.04276030f, -0.16667184f, 0.03768829f, 
    0.00177561f, -0.00569566f, -0.10727978f, 0.08648498f, 0.03762817f, 0.15989378f, -0.01345172f, -0.12898411f, 
    0.15322827f, 0.16603346f, 0.13272269f, -0.08255555f, 0.24469775f, 0.07838073f, 0.17166181f, -0.02351785f, 
    0.08477158f, 0.06152419f, 0.05561697f, -0.00259934f, -0.05547864f, -0.12448526f, -0.09373150f, 0.05820263f, 
    0.01519343f, 0.01540972f, 0.01256067f, -0.08685131f, 0.02598313f, 0.01152726f, -0.20727988f, -0.40871328f, 
    -0.05132468f, 0.01911658f, -0.00725739f, -0.15968767f, 0.17378302f, 0.04178961f, 0.02400476f, 0.05223724f, 
    -0.06382433f, -0.02932393f, -0.01861584f, -0.01725763f, -0.09732930f, -0.12571055f, -0.08992641f, 0.03352461f, 
    0.08178397f, 0.06580489f, -0.13563310f, -0.05736434f, -0.08145003f, -0.04798648f, -0.06526218f, -0.11268794f, 
    0.02454199f, -0.22101067f, 0.34333089f, -0.03188769f, 0.03715458f, -0.05184584f, -0.01982214f, -0.04308974f, 
    -0.04147848f, 0.10869521f, 0.08724564f, -0.04849952f, -0.09634184f, -0.05911103f, 0.24540180f, -0.16200112f, 
    0.08062706f, -0.14208496f, -0.01493821f, -0.02997270f, 0.05475420f, -0.09017827f, -0.15956296f, 0.02794990f, 
    0.14037363f, -0.25524089f, 0.20862503f, 0.16166545f, -0.13299204f, -0.02050419f, -0.04520673f, -0.01368679f, 
    -0.05873570f, 0.13975416f, -0.01612308f, -0.17772615f, 0.11351708f, -0.17092529f, 0.22527461f, 0.20627701f, 
    0.02057023f, 0.17216705f, 0.10529779f, -0.03216816f, 0.04218039f, 0.00562016f, 0.07637265f, 0.08629958f, 
    -0.08277766f, 0.08637886f, 0.16479911f, -0.45858449f, -0.02599912f, 0.11167163f, 0.05659944f, -0.22658144f, 
    -0.01450933f, -0.02434970f, 0.00314566f, 0.05568741f, -0.23144037f, 0.31771588f, -0.06614129f, 0.41003180f, 
    -0.31610197f, -0.08075996f, 0.01945843f, 0.06441438f, 0.14695193f, 0.03370160f, -0.10998583f, -0.03090984f, 
    -0.38044330f, 0.10995192f, -0.02810925f, 0.03656630f, 0.16681282f, -0.02939448f, 0.11657370f, -0.02448881f, 
    0.08402135f, 0.08234674f, -0.16980633f, -0.01869597f, 0.08460768f, -0.10352247f, -0.04087127f, -0.19838986f, 
    -0.11295731f, -0.04034547f, -0.00182842f, 0.10395431f, 0.04878956f, -0.04437697f, 0.02484590f, 0.04637554f, 
    0.00254309f, -0.06823146f, -0.10506272f, -0.01524974f, 0.14602442f, -0.09006076f, 0.08165003f, -0.01558587f, 
    0.09917809f, -0.19279566f, -0.04335307f, 0.10579585f, 0.22044806f, 0.01858535f, -0.33167464f, -0.14820592f, 
    -0.00612082f, 0.16011448f, -0.14442283f, 0.01383374f, 0.10960842f, -0.22034664f, 0.09907400f, 0.19434953f, 
    -0.22091392f, 0.12543230f, 0.18340121f, -0.13985907f, -0.13206451f, -0.13542342f, 0.02979983f, 0.13352843f, 
    -0.00252957f, -0.18489052f, -0.00644625f, -0.06957961f, 0.20252350f, -0.10516646f, 0.11108730f, -0.05275236f, 
    0.08055563f, 0.14655620f, 0.12586753f, 0.00157361f, 0.03047507f, 0.01657336f, -0.03499798f, 0.09416237f, 
    -0.20264943f, -0.36534205f, 0.02631839f, 0.08551059f, -0.09404369f, 0.04967111f, -0.10411045f, -0.00404771f, 
    -0.08199627f, -0.09053749f, 0.36144230f, -0.00047984f, -0.00548499f, 0.01201906f, -0.00212343f, -0.00268326f, 
    0.19391984f, 0.10082351f, -0.12200017f, 0.05188650f, 0.08024187f, 0.01749669f, 0.04144551f, 0.05016879f, 
    0.04951658f, 0.16824205f, 0.03230872f, -0.15119818f, 0.27322525f, 0.04630659f, -0.05622141f, -0.29655412f, 
    -0.04067670f, -0.02672706f, 0.02450518f, 0.00499459f, -0.07175685f, -0.03530013f, 0.01079659f, 0.20502861f, 
    0.05143418f, -0.07276883f, -0.05942234f, -0.00082931f, 0.31070137f, 0.03860350f, 0.16210890f, -0.24931720f, 
    0.06912818f, -0.20483826f, 0.18396430f, 0.19432637f, -0.02147296f, -0.08597036f, -0.15895060f, 0.07811071f, 
    0.14085631f, -0.21599182f, 0.27657944f, 0.03881785f, 0.23119794f, -0.21307361f, 0.14239322f, 0.34438249f, 
    0.10930804f, 0.00451684f, -0.05000636f, -0.06746923f, -0.05822353f, 0.03564523f, -0.13041526f, 0.14457618f, 
    0.22840372f, -0.03535729f, -0.30167502f, -0.33582962f, 0.00627240f, 0.03800121f, -0.04844543f, -0.04783185f, 
    0.16320850f, -0.11077674f, -0.03456784f, -0.02191301f, -0.21078101f, 0.00010598f, -0.06330292f, -0.25937492f, 
    -0.00049234f, 0.02569357f, 0.03604464f, 0.00621603f, 0.07661424f, -0.07334493f, 0.02093344f, -0.10084634f, 
    0.06217606f, 0.00039789f, -0.02337063f, -0.03391604f, -0.06769430f, -0.09711687f, -0.03728664f, 0.09940105f, 
    -0.14328378f, -0.07529959f, 0.20813920f, -0.16462517f, 0.03254113f, -0.18329483f, -0.15995273f, 0.14396177f, 
    -0.08057754f, -0.10504340f, 0.03620731f, -0.03676998f, 0.18460219f, 0.04899656f, 0.09077805f, 0.00189816f, 
    0.11290379f, 0.40842748f, -0.04700951f, -0.02718559f, 0.02499862f, -0.01989470f, 0.02073450f, 0.11917826f, 
    0.03650781f, 0.02160278f, -0.03050665f, 0.10974824f, -0.25695798f, -0.14317589f, -0.29744434f, -0.08375698f, 
    -0.01473922f, 0.06347254f, -0.01478576f, -0.12232074f, 0.05452326f, -0.04230502f, 0.02268775f, 0.02109337f, 
    -0.00016058f, -0.18580934f, 0.14633770f, 0.09037273f, 0.05059138f, -0.11825524f, -0.12823020f, 0.20848458f, 
    0.01715459f, 0.12490557f, 0.16848321f, 0.17322491f, 0.02446331f, -0.00349442f, 0.29150677f, -0.03954260f, 
    -0.14309154f, 0.02128477f, 0.21088463f, -0.10676163f, 0.12578185f, 0.03924643f, 0.00762662f, -0.01483989f, 
    -0.24953613f, -0.16391468f, -0.00746028f, -0.19370195f, -0.03609517f, 0.00492489f, 0.09319077f, -0.09992956f, 
    0.05764430f, -0.07530487f, -0.02781150f, 0.10282157f, 0.02262090f, -0.04387566f, -0.15159985f, 0.11387066f, 
    0.03669768f, 0.11208922f, -0.04008624f, 0.00165924f, -0.14116682f, -0.13193145f, -0.20368938f, -0.39423743f, 
    -0.00990212f, -0.14970939f, 0.03437107f, 0.21418615f, 0.13193652f, 0.00679507f, -0.09285086f, 0.03561278f, 
    -0.00632794f, -0.01686470f, 0.19698343f, 0.23910947f, 0.00893065f, -0.24766727f, 0.10800349f, 0.37823090f, 
    -0.09002793f, -0.00036600f, -0.06617934f, 0.06500743f, -0.00150209f, -0.04667846f, 0.00132485f, -0.18403268f, 
    0.02281047f, 0.00800387f, 0.00798792f, -0.22100939f, -0.04200054f, -0.03839783f, 0.11083685f, 0.05660410f, 
    0.07433326f, -0.29677945f, -0.06381743f, -0.08757545f, 0.03246622f, 0.33502087f, 0.14783038f, -0.22357194f, 
    0.15168974f, -0.14540234f, -0.04938622f, -0.14912343f, 0.01763606f, 0.02897281f, 0.03727755f, -0.00772278f, 
    0.27965778f, 0.02108630f, -0.25008491f, -0.08397365f, -0.04450847f, -0.05664520f, -0.00652844f, 0.01194063f, 
    -0.00981907f, -0.04571099f, 0.03221091f, -0.00867239f, -0.20141865f, 0.12530784f, 0.39547107f, 0.09808095f, 
    0.06337990f, -0.20853040f, 0.07251560f, 0.15334594f, -0.02132317f, 0.11439949f, -0.15075164f, -0.12496889f, 
    -0.41417873f, -0.91517711f, 0.10371758f, -0.00340265f, 0.16239275f, 0.19838683f, 0.18555988f, -0.37902558f, 
    -0.02169366f, 0.00675803f, -0.01329631f, 0.14082682f, 0.29353330f, -0.07039372f, -0.40600890f, -0.33392909f, 
    -0.05113204f, 0.03523682f, 0.11393077f, -0.09770475f, -0.00413358f, 0.08368632f, -0.09673734f, -0.07145856f, 
    0.01709153f, 0.00296126f, -0.07240678f, 0.16486377f, 0.02503121f, 0.01827529f, 0.00534730f, 0.04121301f, 
    -0.00410042f, -0.04075819f, 0.05369353f, -0.08371751f, -0.04593631f, 0.09367249f, 0.33100420f, 0.01002016f, 
    0.00806661f, -0.03111478f, 0.02627792f, 0.09141910f, 0.05540868f, 0.12404441f, 0.11611824f, 0.00572193f, 
    0.11978203f, 0.02646634f, -0.15471072f, 0.06291345f, -0.10969305f, 0.01947081f, 0.06743493f, 0.02909691f, 
    0.11952832f, 0.13138621f, 0.11812533f, 0.14747956f, -0.09954012f, -0.02192315f, 0.23629415f, 0.16080110f, 
    -0.02650411f, -0.02236664f, 0.00800188f, 0.05524988f, -0.05901045f, 0.16878016f, 0.22554940f, 0.12569180f, 
    -0.00266730f, 0.10500003f, -0.16238038f, -0.18279536f, 0.01238611f, -0.07464136f, -0.04124903f, 0.09891769f, 
    -0.07013088f, 0.02513404f, 0.03251547f, 0.02375359f, 0.32736933f, 0.07841630f, -0.04549107f, -0.12527598f, 
    -0.03994844f, -0.07592311f, 0.00543373f, 0.07459314f, 0.07527192f, 0.05881541f, -0.08375531f, -0.10587534f, 
    0.28251100f, 0.05110708f, 0.02059384f, -0.00782225f, 0.13000794f, -0.03848502f, 0.17306438f, 0.05077524f, 
    0.09391885f, -0.14700489f, 0.19627807f, -0.02116821f, 0.07972342f, 0.02954494f, -0.21099785f, -0.06934437f, 
    0.05575831f, 0.04726675f, 0.02418690f, 0.05004283f, -0.03055956f, 0.05394107f, 0.00712691f, 0.02535979f, 
    0.18941087f, -0.18270873f, -0.19122379f, -0.18825954f, -0.02992078f, 0.11991169f, 0.30202669f, -0.33416671f, 
    -0.00326300f, -0.03486730f, 0.12923856f, 0.01313878f, -0.41200697f, -0.62609971f, -0.07274981f, -0.01848318f, 
    -0.31478885f, -0.21143845f, -0.11984058f, -0.03115778f, 0.01250576f, 0.00421007f, -0.02066523f, -0.07795362f, 
    0.00216981f, -0.00680800f, -0.01345560f, 0.02994373f, 0.01246703f, -0.01354666f, 0.05877135f, 0.03468516f, 
    -0.05130726f, -0.09650052f, -0.18138042f, -0.14080907f, -0.04958212f, -0.00216231f, 0.06047412f, 0.12688044f, 
    -0.05809716f, 0.01011385f, 0.31185201f, -0.01117031f, 0.06967114f, 0.04701926f, -0.00874014f, 0.02407077f, 
    -0.50402248f, 0.23521195f, 0.36935833f, 0.02552979f, -0.04339955f, -0.09874731f, 0.00900352f, 0.12631416f, 
    -0.08348857f, 0.08568785f, 0.07274815f, 0.10428586f, -0.41682339f, -0.73821276f, 0.19771791f, 0.06771575f, 
    0.02838346f, -0.01808009f, -0.13271485f, -0.16315156f, -0.04169981f, -0.03593450f, 0.00146946f, -0.00617160f, 
    -0.05094831f, 0.11514908f, -0.10528038f, -0.05054410f, 0.01567106f, 0.05823338f, 0.03597956f, 0.18323793f, 
    0.11017556f, 0.09867550f, 0.20758551f, -0.10171127f, 0.20860840f, -0.01141481f, 0.12923692f, -0.01489478f, 
    -0.07301705f, 0.06385212f, -0.06120469f, 0.08494855f, 0.00698878f, 0.18155827f, 0.25300047f, 0.00847801f, 
    -0.00453869f, -0.05223011f, -0.05190419f, -0.00556119f, -0.01041678f, -0.14786577f, 0.04488603f, 0.04173853f, 
    -0.00378388f, -0.00226996f, -0.06243524f, 0.00601567f, -0.06945959f, -0.01610705f, -0.09026769f, -0.27360249f, 
    0.02096347f, 0.00260875f, 0.08880547f, 0.01647728f, 0.01859693f, -0.02270313f, -0.09778716f, 0.07840990f, 
    -0.27135697f, -0.00737865f, 0.09355068f, -0.12515461f, -0.06792220f, -0.00061658f, -0.13820067f, 0.11595999f, 
    -0.06935053f, 0.00183590f, 0.14365792f, -0.06354573f, -0.15725274f, 0.17950264f, 0.18241756f, -0.00639076f, 
    -0.08130314f, 0.04877422f, 0.00081241f, -0.05823367f, 0.07584330f, 0.06130350f, -0.00862551f, 0.03143881f, 
    0.14341143f, 0.07581349f, 0.03638675f, -0.09487129f, 0.00231162f, 0.09403308f, 0.10024719f, 0.10985925f, 
    -0.07364922f, 0.05755334f, -0.03387221f, 0.12547079f, 0.38657406f, -0.01707498f, -0.05388789f, -0.11996192f, 
    0.06348833f, -0.01964597f, 0.14964725f, -0.00562010f, 0.08565111f, -0.03023362f, 0.11320299f, -0.03372379f, 
    0.03837722f, -0.15721811f, 0.08066739f, 0.04393110f, 0.05865404f, 0.01546253f, -0.00715834f, 0.01577996f, 
    0.09439141f, -0.04258040f, 0.12772867f, 0.09149506f, -0.00384940f, 0.14626226f, -0.00551911f, -0.08299154f, 
    -0.09719577f, 0.01959237f, 0.06022126f, 0.10585662f, 0.08089126f, -0.09449609f, -0.08962960f, -0.04033247f, 
    -0.39515880f, -0.55215514f, -0.36613744f, -0.27409288f, -0.03083119f, -0.06382244f, -0.21374488f, -0.41507754f, 
    -0.04538428f, -0.03703710f, -0.02867228f, -0.06565433f, -0.10949051f, 0.07050441f, 0.01573043f, -0.07047704f, 
    -0.01667320f, 0.06705872f, 0.05864597f, 0.04183526f, 0.07504592f, 0.06590936f, -0.00586191f, 0.00847591f, 
    -0.05437752f, -0.30818120f, -0.15968391f, -0.01285810f, -0.06213393f, -0.02776365f, -0.02244805f, -0.09290672f, 
    0.02432995f, -0.04373849f, -0.07807343f, -0.02538849f, -0.02594939f, -0.14055339f, -0.00827079f, 0.00343175f, 
    0.04245468f, 0.01376759f, -0.00175619f, -0.02814828f, -0.02359388f, -0.09682830f, -0.03159151f, -0.10611881f, 
    0.16996069f, -0.26247582f, -0.21370728f, 0.14629076f, -0.05373091f, -0.04507858f, -0.00517481f, 0.05464628f, 
    -0.02439517f, 0.02329724f, 0.06884161f, 0.02455449f, -0.31711084f, -0.30199027f, -0.23204580f, 0.22137704f, 
    0.08055631f, 0.15825878f, 0.10381267f, 0.06194103f, 0.06320279f, -0.05291974f, 0.09310771f, -0.05049141f, 
    -0.09894335f, -0.27302217f, -0.11706976f, 0.21981217f, -0.08180009f, 0.07314140f, 0.04210718f, 0.13019998f, 
    0.03115441f, 0.03289920f, -0.14033298f, 0.12529480f, -0.33302367f, -0.31710082f, -0.27582219f, 0.29774827f, 
    -0.29527235f, -0.36248916f, 0.01189183f, -0.35444400f, -0.06136502f, -0.02603572f, -0.03726273f, -0.07755589f, 
    -0.26094797f, -0.22780769f, 0.13011739f, 0.07830497f, 0.12306725f, 0.07954182f, 0.04579015f, -0.04220710f, 
    0.06256170f, -0.06539861f, 0.02895748f, 0.00130334f, -0.18608019f, 0.14556402f, 0.06022174f, 0.10112396f, 
    -0.23671196f, -0.11038356f, 0.05929402f, 0.24492979f, -0.03773040f, -0.07013214f, 0.33132395f, -0.28203335f, 
    -0.09565460f, -0.06154439f, 0.33981454f, -0.17886642f, 0.08201668f, 0.08710663f, -0.19302186f, -0.05483522f, 
    0.01938713f, -0.01079187f, 0.12591784f, 0.05293450f, -0.07830068f, -0.09303249f, -0.07972473f, 0.04484566f, 
    0.10383464f, 0.02607599f, -0.06575575f, 0.00634197f, -0.00945204f, 0.05479126f, -0.13377616f, 0.05214315f, 
    -0.06564678f, -0.14932063f, 0.16714418f, -0.06867483f, -0.17484067f, -0.00612448f, 0.01505180f, -0.13432617f, 
    -0.21398182f, -0.10757103f, -0.06312436f, 0.01699777f, 0.25024953f, 0.26269686f, -0.01965598f, 0.13738084f, 
    -0.02394976f, 0.03718176f, -0.06397546f, 0.23062430f, 0.21083622f, 0.03875806f, 0.01712496f, -0.11192574f, 
    -0.04078345f, -0.62135112f, -0.20433988f, 0.09126097f, 0.05479882f, 0.16693513f, -0.03912091f, -0.01019777f, 
    -0.01216262f, -0.00331965f, 0.05082574f, -0.04974600f, -0.27487844f, -0.18338871f, -0.12686098f, 0.17588013f, 
    0.00623506f, 0.05550165f, -0.10658197f, -0.05846671f, -0.02582663f, -0.05024777f, 0.02953878f, 0.04324986f, 
    -0.16144459f, 0.15465428f, 0.17152430f, 0.14876975f, 0.04312061f, 0.01027501f, -0.05589891f, 0.12427741f, 
    0.03530082f, 0.10535109f, 0.10195037f, 0.05382428f, -0.06831934f, -0.16171861f, -0.20835415f, -0.20792122f, 
    -0.09460767f, -0.02103843f, 0.14565103f, 0.01627090f, -0.01797051f, -0.00158035f, -0.04116594f, -0.09511525f, 
    -0.76708174f, -0.39628589f, -0.68907928f, -0.25318596f, -0.18551075f, -0.20501697f, -0.33338636f, -0.38001585f, 
    -0.01307680f, -0.09759319f, -0.02691805f, 0.05078829f, -0.39122215f, 0.03787297f, 0.85720897f, -0.40607518f, 
    -0.03500599f, 0.05217675f, -0.07791188f, -0.03704012f, 0.07310635f, 0.12356193f, -0.00968190f, 0.12796701f, 
    0.09447467f, -0.14274074f, -0.19497053f, 0.01398552f, -0.10812686f, -0.02168107f, 0.07768913f, 0.08186125f, 
    0.03217763f, -0.10498495f, 0.15699483f, -0.06504502f, 0.14781483f, 0.25514981f, -0.08857135f, 0.33010849f, 
    -0.01237286f, 0.02084162f, 0.03182054f, 0.02393518f, 0.00113105f, -0.04320874f, 0.08610160f, -0.00990674f, 
    -0.11758766f, 0.00356574f, 0.11040187f, -0.29548556f, 0.01144619f, 0.00453720f, -0.05084854f, -0.00201947f, 
    0.02608888f, 0.01777191f, 0.01161501f, -0.03407302f, -0.15814890f, 0.23904838f, 0.21528165f, -0.09223489f, 
    -0.03651086f, 0.02061669f, -0.00891706f, 0.09345483f, 0.06075865f, 0.03073636f, -0.06051954f, 0.00496717f, 
    -0.04244120f, 0.00917910f, -0.01563388f, -0.08590461f, -0.20719928f, 0.06988509f, -0.04470209f, -0.20137466f, 
    -0.05162986f, -0.02059608f, -0.01643838f, 0.03830110f, -0.11215111f, 0.03775827f, 0.10604795f, -0.08289742f, 
    0.07862217f, 0.06486414f, 0.02361804f, -0.03013732f, -0.05579642f, -0.09076782f, -0.13215250f, 0.19625229f, 
    -0.25891680f, -0.70905691f, -0.35791421f, 0.31804410f, 0.05725985f, -0.07725874f, 0.07727061f, -0.16502441f, 
    -0.05022432f, 0.04249413f, 0.02692031f, 0.06172645f, -0.28212616f, -0.04822230f, 0.44047144f, 0.25592437f, 
    -0.17902371f, -0.21120834f, 0.06006321f, -0.13806978f, -0.05452546f, 0.00974837f, 0.00345407f, -0.09134961f, 
    -0.29498816f, -0.19907871f, -0.28519654f, 0.45210427f, -0.12578881f, -0.06308163f, 0.13804890f, 0.07258806f, 
    0.04494632f, -0.01506272f, -0.11525884f, -0.02697490f, -0.56846076f, -0.61200243f, -0.49482834f, -0.42861462f, 
    -0.21482669f, -0.07092643f, -0.27521795f, 0.02799827f, -0.09955198f, 0.01334563f, 0.05823243f, -0.15201683f, 
    -0.52954376f, -0.35744119f, -0.27921751f, -0.32537177f, -0.07712802f, -0.22269335f, 0.04333769f, 0.04063850f, 
    -0.04175121f, 0.07917479f, 0.07001107f, -0.06410904f, -0.16565581f, -0.12353854f, 0.06422087f, -0.15069471f, 
    0.01428172f, 0.03672400f, 0.02752278f, -0.00671363f, 0.07947153f, 0.05504926f, 0.11089681f, 0.11968483f, 
    0.02703836f, -0.02097522f, -0.03960801f, -0.09733987f, 0.04945800f, 0.00476277f, 0.06005717f, 0.03764539f, 
    0.09137702f, 0.08314634f, 0.04626249f, 0.03179260f, -0.09783309f, -0.01192649f, 0.07478520f, 0.07057697f, 
    -0.07576810f, 0.06031651f, 0.03811351f, 0.04472691f, -0.03251500f, 0.03445897f, 0.03592899f, 0.24698217f, 
    0.01823046f, 0.16324791f, -0.04125195f, -0.00333537f, -0.01852800f, -0.03246303f, 0.09733392f, 0.11333899f, 
    -0.01892578f, 0.06105563f, 0.15962121f, 0.07891679f, -0.43939891f, -0.60077840f, -0.04119950f, 0.21446656f, 
    -0.06472757f, 0.00791595f, -0.25495675f, -0.31528383f, -0.00362145f, 0.04364387f, 0.00677316f, 0.02965345f, 
    -0.20707144f, -0.00899943f, 0.04836483f, -0.06811296f, 0.01084861f, 0.09550279f, 0.07350378f, 0.03056860f, 
    0.09440292f, 0.04061397f, 0.06896452f, -0.01150142f, -0.00656473f, -0.07092567f, 0.26682955f, -0.11513359f, 
    -0.08395262f, -0.00752156f, 0.21360943f, -0.06832279f, 0.02990800f, 0.04626471f, -0.06239139f, 0.09083915f, 
    -0.55413586f, 0.46936619f, -0.01433663f, -0.01862872f, 0.03674558f, -0.12691993f, -0.09362402f, 0.08917098f, 
    0.01635752f, 0.01417742f, 0.06296161f, 0.03158174f, -0.13690688f, 0.00101377f, -0.05686790f, -0.02411550f, 
    0.06917188f, 0.04455505f, -0.01763119f, -0.04194290f, 0.07313325f, 0.03399244f, 0.03306627f, 0.00876629f, 
    -0.04300657f, -0.19223471f, 0.12613276f, -0.14003295f, 0.01428632f, -0.03266855f, -0.03539462f, -0.05878006f, 
    0.06954011f, 0.00616374f, 0.00300537f, -0.15852998f, 0.08076732f, 0.06914251f, 0.02108214f, -0.30401900f, 
    0.00897512f, 0.02345880f, -0.08323731f, -0.01278117f, -0.02289816f, 0.08008716f, -0.05019594f, -0.10300322f, 
    0.01245755f, -0.33675995f, 0.07381356f, -0.08337001f, -0.03008033f, -0.04023301f, -0.02512822f, -0.03900412f, 
    0.09484940f, -0.03443171f, -0.02582251f, 0.15839086f, 0.15393263f, 0.00328623f, -0.00973369f, 0.05128422f, 
    0.00424708f, -0.04270375f, -0.06355377f, 0.08489179f, -0.01771771f, 0.07315956f, 0.00468682f, -0.08452728f, 
    -0.12906194f, -0.16907190f, -0.32094479f, 0.04144703f, 0.06188934f, -0.04710346f, 0.03865753f, -0.09438040f, 
    0.03215772f, 0.02478142f, -0.01353270f, -0.03407508f, -0.17623450f, -0.22969425f, -0.28982988f, 0.25218755f, 
    0.00276828f, -0.00967446f, 0.10106239f, 0.00568712f, -0.03626211f, -0.10413600f, 0.15033117f, 0.08290169f, 
    -0.15165175f, -0.03562041f, 0.13498168f, 0.01022909f, 0.02404252f, -0.06037736f, 0.05026972f, -0.07047196f, 
    -0.06280486f, -0.20025627f, -0.10393759f, -0.11277235f, -0.10552876f, 0.10715643f, -0.03619451f, 0.02684146f, 
    -0.06246807f, 0.01678398f, -0.06521889f, -0.19323605f, -0.07330867f, 0.05448370f, 0.05888253f, 0.01394841f, 
    -0.06915656f, 0.26870844f, -0.15354596f, 0.05799913f, -0.14230387f, 0.06004221f, -0.03042794f, 0.05113864f, 
    0.00168040f, 0.03889242f, -0.01810350f, 0.00155623f, -0.26851639f, -0.26157928f, -0.24124616f, -0.09747946f, 
    0.13337792f, -0.06905306f, -0.07737780f, 0.05858786f, 0.02092373f, 0.02127111f, -0.04405967f, -0.05263034f, 
    0.06363990f, -0.02519314f, 0.04592629f, -0.11605783f, 0.00831418f, 0.00898122f, -0.00791290f, -0.01956061f, 
    -0.00556043f, -0.05112946f, -0.03370576f, -0.00209204f, -0.15707600f, -0.26915041f, -0.17540248f, -0.15423097f, 
    0.01081314f, -0.02202669f, 0.09754567f, 0.04353818f, -0.05965858f, -0.11941545f, 0.00176605f, -0.04343698f, 
    0.26048076f, -0.59414220f, -0.61760783f, -0.65623838f, 0.01453146f, -0.08201590f, -0.10575174f, 0.14521620f, 
    0.05382705f, 0.08693751f, 0.06741232f, 0.08264440f, -0.26929611f, -0.24403624f, -0.24518730f, -0.24705979f, 
    0.07645357f, 0.00230695f, -0.02701886f, 0.21307266f, 0.00941364f, -0.05926085f, -0.03399365f, 0.01644919f, 
    -0.07979672f, 0.08473302f, 0.03363510f, 0.10773375f, 0.04625918f, -0.10810345f, 0.02305389f, -0.09676307f, 
    -0.02136309f, 0.09778148f, 0.17388460f, -0.20935485f, -0.19070734f, 0.06483779f, 0.00111163f, 0.14386171f, 
    -0.02124012f, 0.07120563f, -0.06365407f, 0.03385329f, -0.04818963f, -0.11004061f, -0.06954677f, -0.04212818f, 
    0.16332062f, -0.07677630f, 0.09788790f, -0.08758407f, -0.15592054f, -0.02363134f, 0.07061163f, 0.05640568f, 
    -0.00540529f, 0.01858832f, -0.02428672f, 0.00170263f, 0.06270401f, 0.06454676f, 0.06126769f, 0.01545949f, 
    -0.03168285f, 0.02898884f, 0.06414432f, -0.01781374f, 0.03275187f, -0.00261859f, 0.01881848f, -0.02805221f, 
    0.27201977f, -0.04781759f, -0.06978831f, -0.04385548f, 0.07588703f, 0.09113088f, -0.00127348f, -0.06156738f, 
    -0.02794494f, 0.12908781f, 0.08736742f, 0.00562742f, 0.25505087f, -0.03424809f, -0.06185545f, -0.08141712f, 
    0.04813093f, -0.08011294f, -0.11918229f, -0.02164503f, -0.00977868f, -0.13774689f, 0.05081611f, -0.02595554f, 
    -0.01197983f, 0.00475647f, -0.02665912f, 0.00134559f, 0.01172864f, 0.02563863f, -0.07361088f, -0.06689599f, 
    -0.04224918f, -0.02051919f, -0.01672618f, -0.05640589f, -0.01800618f, 0.01925970f, 0.18359761f, -0.16415928f, 
    -0.15832268f, -0.01982987f, -0.03410517f, 0.08907122f, 0.01720814f, 0.03216152f, 0.08090317f, -0.04779335f, 
    0.14390770f, 0.13226514f, 0.03469924f, -0.11664616f, 0.01548077f, 0.04327446f, 0.00935404f, -0.06028752f, 
    -0.04367251f, -0.00609376f, -0.06442686f, -0.27092347f, -0.06557910f, 0.03600007f, -0.03950087f, 0.09831150f, 
    -0.06447273f, -0.00180722f, 0.18452333f, -0.09824044f, -0.06541048f, 0.00911317f, 0.02286664f, -0.00342224f, 
    -0.27835631f, -0.41860256f, -0.17461894f, 0.32406497f, -0.01820322f, 0.05265820f, 0.02380689f, -0.01659814f, 
    0.04487903f, -0.04207081f, -0.02354569f, -0.03392500f, 0.06698906f, 0.09239776f, 0.02007642f, 0.05229476f, 
    -0.02099456f, -0.05460602f, 0.01959588f, -0.02396167f, -0.00218710f, 0.01928172f, -0.01907282f, -0.05095815f, 
    -0.27276480f, 0.16225661f, 0.12156882f, 0.03547668f, -0.16288720f, -0.13376459f, -0.05069289f, -0.17118677f, 
    0.05947120f, 0.00788240f, -0.02543327f, 0.01651528f, 0.07713284f, 0.03962719f, 0.03060520f, -0.02462266f, 
    -0.04921627f, -0.02820917f, 0.01412915f, -0.01140259f, 0.05569352f, 0.04161227f, 0.04497419f, 0.02829689f, 
    0.39035961f, -0.16002268f, 0.10768949f, -0.26648864f, -0.04796573f, 0.15170059f, -0.05771202f, 0.00293749f, 
    -0.15000524f, 0.12198184f, -0.08518260f, 0.03606670f, 0.13008282f, -0.14312750f, -0.02992545f, -0.18059506f, 
    -0.02732781f, 0.02241623f, 0.06559584f, -0.02728444f, 0.02018028f, 0.06354890f, -0.03079658f, -0.03941184f, 
    0.16604058f, -0.24603578f, 0.00641527f, -0.08039396f, 0.03449726f, 0.02222485f, -0.03604604f, -0.05022600f, 
    -0.03681177f, 0.03018696f, -0.03434087f, -0.13600555f, 0.22525123f, -0.46669459f, 0.14670260f, 0.18753855f, 
    -0.14722277f, 0.06455497f, -0.30246598f, 0.10310646f, 0.00910522f, 0.02902601f, -0.06123193f, 0.01935886f, 
    -0.15895005f, -0.16495770f, 0.22179903f, -0.28820303f, -0.04426039f, 0.11273067f, 0.08141657f, -0.00326728f, 
    -0.00938255f, -0.00362438f, 0.04169895f, -0.05794758f, 0.43698394f, 0.05815399f, -0.13493657f, -0.01285821f, 
    0.05197410f, -0.02240440f, 0.03081813f, -0.14167099f, -0.16833220f, 0.07031234f, 0.05864587f, 0.03663701f, 
    0.08991941f, 0.41137493f, -0.25025874f, -0.03111154f, -0.12569249f, 0.25191438f, -0.17322555f, 0.02003598f, 
    0.00723578f, 0.13243221f, 0.00384695f, -0.03464549f, -0.00525613f, 0.08758033f, 0.04755812f, -0.08457179f, 
    0.03506273f, 0.01048660f, 0.00270078f, 0.00623474f, 0.05920505f, -0.01017253f, 0.04096820f, -0.05793068f, 
    0.03032488f, 0.09883460f, -0.03966012f, -0.02008729f, -0.17823039f, 0.06711156f, 0.06974217f, -0.00069884f, 
    -0.03909082f, 0.01620486f, 0.05074749f, 0.01419649f, -0.26256055f, 0.08930664f, -0.07239392f, 0.02752381f, 
    -0.02707409f, 0.10753269f, 0.07398755f, -0.09630270f, -0.07292273f, 0.05211057f, 0.03070224f, -0.10647550f, 
    -0.17129251f, -0.24577059f, 0.19224130f, -0.00199006f, -0.15762605f, 0.08001339f, 0.06604499f, 0.07806505f, 
    -0.07788952f, -0.06270058f, 0.15246940f, 0.08795782f, 0.12939331f, -0.34805414f, 0.02100799f, -0.12674096f, 
    0.04247373f, -0.05274624f, -0.02413778f, -0.13551380f, -0.06758672f, 0.03377242f, 0.05203387f, 0.00313598f, 
    0.27779052f, -0.05120637f, -0.09231980f, -0.28979266f, -0.03511932f, -0.00186874f, -0.08211403f, -0.01368263f, 
    -0.04941441f, -0.10390777f, -0.02195154f, -0.17892073f, -0.09441067f, 0.03120166f, -0.00286806f, 0.04633912f, 
    0.08313591f, -0.16927704f, -0.03519887f, -0.05702112f, -0.00855230f, 0.01337174f, -0.02187172f, 0.00003137f, 
    -0.44635713f, -0.34273928f, 0.05463476f, 0.26944622f, 0.05126958f, 0.06839544f, 0.09396103f, 0.03229573f, 
    -0.03645543f, 0.04883733f, 0.02104579f, -0.00526313f, 0.27272263f, 0.22018477f, -0.35008743f, -0.06054359f, 
    0.06873722f, -0.00744729f, -0.05988756f, 0.08725552f, 0.13052839f, 0.05641406f, -0.03801163f, 0.00996247f, 
    0.06032622f, -0.13749750f, 0.08294878f, -0.15869115f, 0.05304259f, 0.03570230f, -0.01022458f, -0.03900224f, 
    0.05535273f, 0.05248920f, 0.07426254f, 0.04440258f, -0.15593466f, 0.06452695f, -0.14019252f, 0.10590554f, 
    0.02134279f, 0.05627983f, -0.02490972f, -0.12312840f, -0.03140984f, 0.05820930f, -0.04369683f, 0.04004923f, 
    -0.20602234f, 0.03264978f, -0.06915899f, -0.01650309f, 0.04516342f, 0.00343575f, 0.14948128f, -0.05806078f, 
    0.03918215f, -0.02564817f, 0.02129442f, -0.03950998f, 0.48100942f, -0.45266035f, -0.18400912f, -0.26764691f, 
    -0.05485851f, 0.06457160f, 0.02930629f, -0.02667290f, 0.19997226f, -0.08585312f, -0.02581607f, 0.00303319f, 
    0.10282165f, -0.07264474f, -0.09400146f, -0.02195508f, 0.13101166f, 0.07575712f, 0.07046002f, 0.01786677f, 
    0.04211192f, -0.04443729f, 0.13977958f, 0.05976379f, 0.02555097f, 0.06737665f, 0.00952398f, -0.03841721f, 
    -0.06678215f, 0.00690686f, 0.01863081f, 0.01631552f, -0.00125167f, -0.01841836f, 0.04688939f, -0.11082148f, 
    -0.43904272f, 0.05211717f, 0.46216750f, 0.00184552f, 0.14041831f, -0.21421665f, -0.00234360f, 0.10812862f, 
    -0.04513893f, -0.02892875f, -0.06147111f, -0.03044659f, 0.12559085f, -0.67373461f, -0.40161896f, -0.35707042f, 
    -0.09808575f, -0.20501134f, -0.14569594f, 0.18841219f, 0.07443294f, 0.04494985f, -0.03959790f, 0.03425676f, 
    -0.36244932f, -0.41668341f, -0.30666056f, -0.37120008f, 0.02893614f, -0.16010609f, 0.21529111f, -0.08970826f, 
    0.00278493f, 0.05116404f, 0.03130512f, -0.01552510f, 0.10235875f, -0.62213057f, -0.04744641f, 0.48433021f, 
    -0.18509464f, 0.02347666f, -0.10971139f, -0.04330346f, -0.01901525f, -0.06034762f, -0.03759509f, -0.06586795f, 
    0.31781849f, -0.40378547f, -0.16597888f, -0.28997985f, -0.15524264f, 0.10913541f, -0.16564968f, 0.13543227f, 
    0.06292658f, 0.04670375f, 0.01353425f, 0.08613660f, 0.12878020f, 0.05038311f, -0.06511975f, 0.04844904f, 
    -0.08866852f, -0.02813494f, 0.00801835f, 0.03290299f, 0.09362599f, 0.16773513f, 0.13263424f, 0.14145108f, 
    0.10087979f, -0.03734556f, 0.05971773f, 0.00007435f, -0.02185370f, -0.05099210f, 0.01353769f, -0.10970630f, 
    -0.18738648f, -0.17411500f, -0.09341706f, 0.07539707f, 0.15297593f, 0.05021110f, -0.15024696f, -0.23505552f, 
    -0.00356640f, 0.01079163f, -0.10511123f, -0.02813875f, -0.13712589f, 0.09641127f, 0.03122597f, -0.15003787f, 
    0.02230554f, -0.18449478f, -0.08776488f, 0.12871215f, -0.02068391f, -0.09946840f, 0.01089249f, -0.08838070f, 
    0.10045139f, 0.14017567f, 0.03816972f, 0.00243493f, -0.29509506f, -0.47907063f, 0.41115996f, -0.24292780f, 
    0.10043848f, 0.14833069f, 0.07992812f, 0.19105788f, -0.07166205f, -0.00802957f, -0.04700441f, -0.04927632f, 
    -0.41965717f, 0.14016463f, 0.04541762f, 0.35730422f, 0.02833012f, -0.13991149f, -0.07601890f, -0.07548368f, 
    -0.04525259f, 0.13402723f, -0.03105220f, 0.14207165f, -0.19453400f, -0.32429221f, -0.05601388f, 0.09357272f, 
    0.05787499f, 0.06292649f, 0.15297118f, -0.02088668f, 0.03215282f, 0.09961088f, 0.13694735f, 0.09271926f, 
    -0.43711966f, 0.01122757f, 0.07336454f, 0.10532355f, 0.01388104f, 0.04287207f, -0.17617072f, -0.27219808f, 
    -0.08136878f, -0.03474445f, -0.07535419f, -0.03796682f, -0.47654539f, 0.23277128f, 0.16560908f, 0.19701211f, 
    -0.05064696f, -0.05685602f, -0.13380779f, -0.01452053f, -0.06869235f, 0.01667131f, -0.05659974f, 0.04460106f, 
    -0.01392311f, 0.08136681f, 0.07089979f, 0.03331095f, 0.04070361f, -0.00261376f, 0.06982878f, 0.04388530f, 
    -0.05850583f, 0.02652779f, 0.03719719f, 0.08483499f, 0.08233807f, -0.07972044f, -0.30639911f, -0.01482657f, 
    -0.11494606f, 0.01771619f, 0.00684005f, -0.00399195f, 0.04855750f, -0.17133884f, 0.09712536f, 0.01261225f, 
    0.03060888f, 0.05112297f, -0.04552517f, -0.03477284f, 0.03789245f, -0.03632829f, 0.11339232f, 0.09806959f, 
    -0.00059029f, 0.04607974f, -0.16119879f, -0.47181717f, -0.11646832f, 0.05233072f, -0.00889577f, 0.06400984f, 
    0.00658287f, 0.05439020f, 0.03560545f, 0.03591368f, -0.07478774f, -0.12807555f, -0.11316559f, -0.19850540f, 
    0.31361327f, -0.03303359f, -0.06790826f, 0.10752285f, 0.06033558f, -0.06250869f, 0.08082352f, -0.12733439f, 
    0.06214373f, -0.00723540f, 0.03706385f, 0.09992325f, 0.11595178f, 0.03132483f, -0.07653660f, 0.05311150f, 
    0.10016152f, -0.08233318f, -0.01768427f, 0.12417950f, -0.08883414f, -0.06458551f, 0.05869759f, 0.04950826f, 
    -0.28399980f, -0.16388655f, 0.20747395f, -0.03532688f, 0.01704312f, 0.02077825f, 0.00561447f, 0.00587615f, 
    0.04085625f, 0.00508661f, 0.07631890f, 0.09503859f, 0.02536866f, 0.10837185f, 0.06283309f, -0.00556811f, 
    0.03948968f, 0.06820720f, 0.07324260f, 0.13999707f, 0.07437241f, -0.00152494f, 0.08373279f, -0.00388050f, 
    -0.47152102f, -0.06200092f, 0.19902749f, 0.09348044f, 0.24423863f, -0.15412122f, -0.13968317f, -0.06477785f, 
    -0.11490957f, -0.10231611f, -0.01865271f, -0.07505421f, 0.01588996f, -0.22921015f, -0.28105003f, -0.08124910f, 
    -0.02035294f, 0.04718688f, -0.12115254f, 0.06167324f, -0.05199492f, -0.02729888f, -0.00890364f, 0.03829954f, 
    -0.07691836f, -0.01280500f, -0.00857122f, -0.00795168f, -0.04752567f, -0.01873707f, 0.01634221f, 0.00412483f, 
    0.08083627f, 0.03343594f, 0.06940204f, 0.13079786f, 0.06727152f, -0.15169275f, -0.08736302f, 0.08825424f, 
    0.10595372f, 0.26324096f, 0.11729780f, 0.15779717f, -0.11921158f, -0.04154282f, -0.04285403f, -0.25543341f, 
    -0.55249792f, -0.49885830f, -0.31262100f, 0.16007869f, 0.02336163f, 0.17133629f, 0.11956342f, 0.00507426f, 
    -0.07508791f, 0.03706238f, 0.05966226f, 0.01483090f, 0.19703561f, -0.37667292f, -0.41318139f, -0.15076777f, 
    -0.04232140f, -0.02954556f, 0.10472175f, -0.08136255f, -0.08320377f, -0.05188727f, 0.00232736f, 0.00628763f, 
    -0.10115254f, -0.21799377f, -0.10776564f, -0.00308058f, -0.07200364f, 0.03500235f, -0.01579394f, -0.04920314f, 
    0.03121870f, -0.21380004f, -0.05418227f, -0.18350922f, -0.11588414f, -0.01838238f, 0.10020489f, 0.11800131f, 
    0.01430147f, -0.07525734f, -0.13853489f, 0.03284425f, 0.09687023f, 0.17162958f, 0.06737363f, -0.12179667f, 
    0.04580100f, -0.05468769f, -0.03510552f, -0.02118526f, 0.08247555f, -0.06980460f, 0.09668768f, -0.00355030f, 
    -0.02335772f, 0.13109289f, 0.04345284f, 0.17280121f, -0.25221080f, 0.06159639f, 0.09406030f, 0.06448819f, 
    0.08127691f, -0.05652678f, -0.09492964f, -0.01597827f, 0.09927807f, 0.06981792f, 0.08350834f, 0.14625463f, 
    0.11775103f, -0.10686557f, -0.30197236f, -0.35273921f, 0.11939067f, 0.06702948f, 0.07325266f, 0.01699004f, 
    0.19360451f, 0.08362059f, 0.12288587f, 0.11105576f, -0.11191728f, -0.09598015f, -0.18039790f, -0.03806878f, 
    -0.08092495f, 0.03874171f, 0.07048981f, 0.13400270f, 0.12896700f, -0.03872599f, 0.02770465f, -0.18438162f, 
    -0.21050571f, -0.16311060f, 0.12990528f, 0.06753773f, 0.02676671f, -0.10117716f, -0.10283625f, -0.02196890f, 
    -0.05262526f, -0.19186452f, -0.03367466f, -0.13744727f, -0.24099992f, 0.10323424f, 0.04037656f, 0.06017928f, 
    0.17959811f, 0.00345515f, -0.03872935f, 0.02351357f, -0.05324707f, 0.03590757f, 0.08337586f, -0.10777370f, 
    0.06419142f, 0.04252908f, 0.05152159f, -0.15336411f, -0.10872922f, -0.05269577f, 0.00919097f, -0.00231970f, 
    -0.00353282f, 0.04706884f, 0.02478318f, 0.09816273f, -0.12317913f, -0.03558625f, 0.13872048f, 0.06505606f, 
    0.06890072f, 0.10956757f, -0.06747406f, 0.07456194f, 0.02069866f, -0.03931950f, -0.07586789f, 0.02162926f, 
    -0.31243697f, -0.58050478f, -0.46133348f, -0.04120180f, -0.08645194f, 0.05199313f, -0.08930935f, -0.04856805f, 
    -0.00799719f, 0.02949755f, 0.07358852f, 0.07685372f, -0.20817211f, -0.09956080f, -0.05400078f, -0.05067109f, 
    -0.08276331f, -0.07067357f, -0.01522651f, -0.14005151f, 0.03680627f, -0.22688706f, -0.13334076f, -0.05277461f, 
    -0.05512496f, -0.01180318f, 0.02108806f, -0.07234112f, 0.00093382f, -0.07202135f, -0.14999089f, -0.14470826f, 
    0.06263097f, 0.21555436f, 0.06633521f, 0.01604223f, -0.25109875f, 0.05861662f, 0.02002544f, -0.15071265f, 
    -0.03490882f, -0.06735472f, -0.01946455f, -0.08356028f, -0.14691949f, -0.05625530f, -0.05127789f, -0.03195781f, 
    0.55799198f, 0.22401297f, -0.24559627f, -0.35236594f, 0.11165112f, -0.01116079f, 0.22628468f, -0.16523582f, 
    0.07601234f, -0.06311274f, 0.08828694f, 0.10214923f, 0.32096666f, 0.11026523f, 0.04052321f, -0.33868259f, 
    -0.18453185f, -0.06933698f, 0.00568506f, -0.14983882f, 0.03313442f, 0.00260037f, -0.13347735f, -0.03563423f, 
    0.43414220f, -0.08807663f, -0.05545043f, -0.22068651f, 0.14874291f, -0.06014285f, 0.00112926f, -0.08929598f, 
    -0.10191520f, 0.08831152f, 0.06761467f, 0.09655177f, 0.12514135f, 0.03862993f, -0.34563467f, 0.00195507f, 
    0.18904106f, -0.09210569f, -0.00247897f, -0.13724509f, 0.00159159f, -0.08303150f, 0.06261865f, 0.14094295f, 
    -0.01438389f, -0.01235593f, -0.07997679f, -0.01347833f, -0.02176469f, -0.03500558f, 0.03666822f, -0.16618279f, 
    0.08692265f, 0.08846293f, -0.06539793f, -0.03179011f, 0.22200008f, -0.01079181f, -0.22586869f, -0.21248859f, 
    -0.07997596f, 0.15931575f, -0.04479855f, 0.11812456f, 0.10227945f, 0.06042088f, 0.01199418f, 0.12970079f, 
    -0.08800755f, -0.12991832f, -0.09071626f, -0.12563455f, -0.12916228f, -0.08686243f, -0.04741443f, 0.27444553f, 
    0.01262742f, 0.12955579f, 0.01052336f, 0.09656002f, 0.08853868f, -0.09472125f, 0.03589807f, -0.00880775f, 
    -0.10669754f, 0.00328419f, -0.01892273f, -0.07697659f, 0.07718331f, 0.04947546f, -0.00641047f, 0.03070729f, 
    -0.02903926f, 0.05708881f, -0.05400539f, -0.00222705f, 0.00724033f, 0.00802988f, 0.05023232f, 0.06427428f, 
    0.09035014f, 0.09714879f, 0.08586685f, 0.06154536f, -0.42490637f, -0.02762141f, 0.15607977f, 0.12638971f, 
    0.00109796f, -0.03698179f, 0.04926255f, -0.06028392f, 0.16050291f, -0.00996130f, 0.04377471f, 0.04317620f, 
    -0.17367722f, -0.05096916f, 0.13986425f, -0.24666204f, 0.02420720f, 0.06195447f, -0.10321292f, -0.14794567f, 
    -0.08527918f, -0.05061200f, -0.13597955f, -0.07239466f, 0.31309083f, 0.12979481f, -0.08668309f, -0.10403554f, 
    -0.00141831f, 0.10747118f, 0.09154561f, -0.21723258f, 0.12817554f, 0.11100422f, 0.06452110f, -0.00276360f, 
    -0.01024218f, -0.11256383f, -0.19873215f, -0.03644281f, 0.07081255f, 0.03009396f, 0.03455820f, -0.01418844f, 
    0.10613073f, -0.02106563f, -0.05795857f, 0.02742305f, -0.13414565f, 0.05535290f, 0.07049644f, 0.10612980f, 
    0.10715507f, 0.00821584f, -0.00439311f, 0.01879432f, 0.10504927f, 0.06360012f, 0.11633691f, 0.08994903f, 
    0.03926834f, -0.31968141f, -0.20057006f, -0.04697305f, 0.01843889f, 0.02471939f, -0.05113092f, 0.20444582f, 
    0.01515855f, 0.02910679f, -0.03546422f, 0.03821408f, 0.08146986f, -0.19034718f, -0.44311264f, -0.30984378f, 
    -0.04107169f, 0.08593424f, 0.01850523f, 0.01190248f, 0.10113570f, 0.17196789f, 0.06250598f, -0.08993039f, 
    0.28371793f, -0.03299187f, 0.05088617f, -0.02711394f, 0.11963271f, -0.05518631f, -0.11358308f, -0.07585236f, 
    0.04921649f, 0.10004300f, 0.03663361f, 0.16794494f, 0.34912327f, 0.23207514f, 0.07734571f, 0.20042190f, 
    -0.03384085f, -0.02842998f, 0.02758138f, 0.13550051f, 0.05341440f, -0.08527255f, 0.17795773f, 0.06006014f, 
    -0.47465736f, -0.00674969f, 0.23482153f, 0.05423825f, -0.14968725f, -0.09765504f, -0.07289433f, -0.11389380f, 
    -0.00428138f, 0.09535823f, 0.04014275f, 0.09117647f, -0.18542781f, -0.12864172f, -0.13903382f, -0.05491773f, 
    0.02734119f, 0.07583486f, 0.01510263f, 0.04498195f, -0.28789890f, 0.07113644f, -0.23222037f, -0.34580454f, 
    -0.12820138f, -0.05541231f, -0.15082003f, -0.04560776f, -0.01939740f, -0.04915482f, -0.00679833f, 0.05263720f, 
    -0.30067337f, -0.17915238f, -0.29241472f, -0.19229558f, -0.10813376f, 0.04628716f, 0.04813485f, 0.01297222f, 
    -0.09992658f, 0.02290712f, -0.04198230f, -0.01476846f, 0.00855407f, 0.02401067f, -0.03326698f, 0.14656515f, 
    0.45508361f, 0.21161962f, -0.05607075f, 0.03523044f, -0.19137257f, 0.03621915f, 0.06404550f, 0.01050040f, 
    0.02541077f, 0.06604899f, 0.05088340f, 0.08407183f, 0.02800571f, -0.44096416f, -0.31078443f, 0.14817683f, 
    -0.00797249f, 0.06571955f, 0.13483179f, 0.01093050f, 0.01634482f, 0.01233191f, 0.05013882f, 0.06345211f, 
    0.34028023f, -0.16407470f, -0.28958166f, 0.29034218f, 0.10124175f, 0.02316892f, 0.18362978f, -0.05562080f, 
    0.00697646f, 0.02101824f, 0.02624491f, 0.10330819f, -0.03453720f, -0.48541990f, -0.50421739f, -0.41029063f, 
    -0.04443406f, -0.08784593f, 0.02105013f, 0.10158875f, 0.04419344f, 0.09816092f, 0.08863692f, 0.13060634f, 
    -0.58180946f, -0.62480849f, -0.44331846f, -0.18358295f, 0.07774141f, 0.13441789f, 0.17357606f, 0.21453027f, 
    0.05139849f, 0.02924019f, -0.05812410f, 0.06817056f, 0.01856879f, 0.04656119f, -0.12214420f, -0.05032804f, 
    0.01559772f, -0.03699119f, 0.04176167f, 0.03946145f, 0.02107976f, -0.01213813f, -0.19953167f, -0.51877594f, 
    0.09052014f, 0.04213237f, -0.07133207f, -0.12190931f, 0.02661853f, -0.07012028f, 0.02208666f, -0.00573064f, 
    -0.08682047f, 0.04397528f, -0.03545515f, -0.03828177f, 0.26433665f, 0.08477050f, -0.08305741f, -0.13674283f, 
    0.02119737f, -0.10861029f, 0.08936897f, 0.05200076f, 0.07329147f, 0.00080379f, -0.01359987f, 0.15723269f, 
    0.05759120f, -0.18167177f, 0.16177838f, 0.02459489f, -0.01390841f, 0.03703076f, 0.01797072f, 0.06062743f, 
    -0.17718382f, -0.16665891f, 0.02838087f, -0.38925812f, 0.32830614f, -0.13450608f, -0.46221140f, -0.14440814f, 
    -0.18104619f, 0.03715261f, 0.05288757f, -0.09017067f, 0.07151514f, -0.04939782f, 0.02083012f, 0.04591877f, 
    -0.02067660f, -0.01279661f, -0.45006835f, -0.28677496f, -0.05668012f, -0.11983851f, 0.15640360f, -0.08401772f, 
    -0.01299886f, 0.03811303f, -0.15529053f, 0.13792740f, 0.37587276f, 0.02565505f, 0.42392230f, -0.57881957f, 
    0.04856165f, -0.22467498f, 0.02618860f, 0.07349099f, -0.26211327f, 0.05083838f, -0.08250052f, 0.09422041f, 
    0.22807111f, -0.24552178f, -0.07914855f, -0.14962417f, -0.05639209f, 0.09189045f, 0.04729044f, 0.16722900f, 
    0.03280575f, 0.03158861f, -0.05165854f, -0.01733230f, -0.31165591f, 0.09182329f, -0.25907677f, 0.05901382f, 
    0.02556929f, 0.11155434f, 0.19280854f, -0.03010212f, 0.08483527f, -0.01561669f, -0.05203810f, 0.02191673f, 
    0.12608331f, -0.19143724f, 0.01624204f, -0.19357674f, 0.00689032f, 0.08986998f, 0.06330416f, -0.11569136f, 
    0.12541932f, 0.06907521f, -0.03277345f, 0.02371148f, 0.16386828f, -0.02246747f, 0.11704086f, 0.31821650f, 
    0.05511953f, 0.03849612f, -0.16605297f, -0.07064310f, 0.01674711f, 0.10508389f, -0.02105273f, 0.07542092f, 
    0.17344840f, -0.01159384f, -0.01537788f, 0.05275313f, 0.04759008f, 0.05904479f, 0.02805803f, -0.01291433f, 
    0.09335236f, 0.07398871f, 0.20232098f, 0.12247057f, -0.12930025f, -0.12571192f, 0.01629289f, -0.04840708f, 
    0.00726743f, 0.14058641f, -0.09576777f, 0.01856164f, 0.27974477f, 0.08712932f, -0.04073691f, 0.02714646f, 
    -0.27710474f, -0.11564705f, -0.20684426f, -0.02736572f, 0.22056660f, -0.15786852f, 0.16200699f, 0.00182959f, 
    0.01038272f, 0.00176463f, -0.09666776f, -0.03736080f, -0.19780371f, 0.41669831f, 0.07425614f, -0.14526992f, 
    -0.03050198f, -0.15093118f, 0.01792027f, 0.11021636f, 0.04267368f, 0.07571504f, 0.09962664f, -0.01260721f, 
    -0.05323600f, -0.04466159f, 0.24997193f, -0.51312846f, 0.06011629f, -0.09284997f, -0.13841140f, -0.05355010f, 
    -0.06688454f, 0.06738331f, -0.05130358f, -0.06409217f, -0.31940818f, 0.01215279f, -0.58584565f, -0.03166098f, 
    -0.07545176f, 0.06604813f, 0.09668624f, 0.03193651f, -0.00657083f, -0.08833220f, -0.05210292f, 0.03053254f, 
    -0.16615666f, 0.11295560f, -0.48163539f, -0.15168469f, -0.05290287f, 0.09628647f, 0.08079005f, 0.27109322f, 
    -0.06230817f, -0.06552891f, -0.07611938f, 0.09501007f, -0.15102358f, 0.00730384f, 0.05936576f, -0.18406621f, 
    0.08607057f, -0.02445036f, -0.01845996f, 0.15227355f, 0.04251844f, -0.00744295f, -0.01782788f, 0.02002353f, 
    0.07851600f, -0.04750168f, 0.05270201f, -0.07403768f, 0.03044660f, 0.06702258f, -0.01756605f, -0.01965036f, 
    -0.02551697f, 0.01178621f, -0.03580991f, 0.03148437f, -0.05940552f, 0.06647683f, 0.04973790f, -0.15541218f, 
    -0.19622518f, -0.10875729f, -0.16936907f, -0.03281470f, 0.09412671f, -0.00630565f, 0.03683824f, 0.05634117f, 
    0.31369472f, -0.21357256f, -0.14682925f, -0.05272168f, -0.08868804f, -0.04342639f, -0.10240266f, -0.12193136f, 
    -0.02301007f, 0.03260853f, 0.01479698f, -0.05696200f, -0.30287862f, 0.03046625f, 0.02084597f, -0.43892327f, 
    -0.20278293f, 0.02342394f, -0.02639589f, 0.16799955f, 0.10243747f, -0.00096270f, 0.09674033f, 0.00588710f, 
    0.03778350f, -0.18879433f, 0.22380978f, -0.03440131f, 0.09707083f, -0.03739825f, 0.07365394f, 0.02111250f, 
    0.01424130f, 0.12604363f, 0.00997870f, 0.25389940f, -0.19127585f, 0.05593174f, -0.24964491f, 0.11396351f, 
    -0.04586618f, -0.03982327f, 0.05969314f, -0.08778414f, 0.16103053f, 0.05207251f, 0.09472600f, -0.05166055f, 
    0.03343472f, -0.07197952f, -0.02279961f, 0.05711122f, -0.06490821f, 0.12931216f, 0.09639471f, -0.11533507f, 
    0.03778196f, -0.10588481f, -0.14565590f, -0.06366128f, 0.17744792f, -0.15093632f, -0.15019102f, -0.08384065f, 
    -0.01805768f, -0.14119984f, 0.14175701f, -0.10683735f, -0.00452973f, -0.05220132f, -0.15502015f, -0.14815126f, 
    0.24908151f, 0.19552568f, 0.28884980f, 0.42290238f, 0.16554686f, -0.15349692f, -0.16930719f, -0.08412510f, 
    -0.08505145f, -0.15519437f, -0.04484000f, -0.04393418f, -0.17259787f, 0.05129034f, 0.24827635f, 0.17128830f, 
    -0.00014178f, 0.02343317f, -0.22645184f, -0.11186592f, 0.06998547f, -0.12094724f, 0.08294754f, 0.03548452f, 
    -0.03015008f, -0.01896824f, -0.18166375f, 0.03857541f, 0.09487846f, -0.07026263f, 0.13733828f, -0.09446716f, 
    0.03128412f, -0.06251045f, -0.04088912f, 0.01678544f, -0.05866916f, 0.11294655f, -0.46075842f, -0.00499516f, 
    -0.11041089f, 0.10240729f, 0.11086954f, -0.07108143f, -0.03292625f, -0.04816170f, -0.13934173f, 0.06385955f, 
    -0.23060527f, -0.16471584f, 0.24797118f, 0.14469343f, -0.02204340f, 0.09609605f, -0.14902250f, -0.15264063f, 
    -0.04244892f, 0.18872455f, -0.10238266f, -0.08794546f, -0.06384283f, -0.11322635f, -0.30366680f, -0.14313783f, 
    0.01773386f, 0.03212611f, -0.02932563f, 0.05131778f, 0.08977059f, 0.01373558f, -0.13884094f, 0.12871252f, 
    -0.06181243f, 0.09356905f, 0.19721244f, -0.20482101f, -0.13652387f, -0.09505624f, 0.01866889f, 0.21650036f, 
    0.01166681f, 0.08885173f, 0.04048347f, -0.05275206f, -0.01954052f, -0.05683829f, 0.07058375f, 0.05356484f, 
    0.10296158f, -0.01127622f, 0.05071117f, -0.03388838f, 0.16514127f, 0.03597752f, -0.01566726f, 0.11601686f, 
    0.29543936f, 0.05780898f, 0.02702010f, -0.07115763f, 0.10898992f, 0.06887732f, 0.06682073f, -0.02651347f, 
    0.05369253f, -0.06926519f, -0.10236682f, -0.10541105f, -0.08300605f, -0.05771008f, -0.18115383f, -0.10900231f, 
    0.13551614f, 0.19188941f, 0.18900397f, 0.07410196f, 0.17496772f, 0.05452520f, 0.04043768f, -0.00869345f, 
    -0.42059946f, -0.38052303f, -0.27296346f, 0.22807688f, 0.10462427f, 0.04820330f, 0.03049733f, 0.01999081f, 
    0.06325535f, 0.00121541f, -0.12479995f, 0.02989454f, 0.25932816f, -0.55710596f, 0.20595501f, -0.13616420f, 
    0.14063564f, 0.19100966f, -0.10052104f, -0.04748807f, -0.09390370f, -0.04215736f, -0.02016306f, -0.05842854f, 
    0.11861081f, 0.09006373f, 0.07307289f, 0.04010592f, -0.01658633f, 0.03202086f, -0.04104333f, -0.18895534f, 
    0.09713129f, 0.02064800f, -0.09825341f, 0.12093215f, -0.38476425f, 0.04038653f, 0.02591239f, -0.00471053f, 
    -0.06514576f, -0.24450810f, -0.18888162f, -0.06775923f, 0.05463526f, -0.04221903f, -0.00475025f, 0.03216508f, 
    0.25554496f, -0.49134767f, -0.07712213f, -0.08767968f, 0.09948298f, -0.09561388f, 0.05806791f, 0.10023886f, 
    0.06759165f, 0.01317970f, -0.01749468f, -0.10587262f, -0.46219245f, 0.26944917f, 0.30179915f, 0.22292601f, 
    0.37633401f, -0.22320962f, -0.14600611f, -0.27112541f, -0.07283901f, -0.17815603f, -0.04420956f, -0.05644081f, 
    -0.62099451f, 0.30053276f, -0.56508797f, 0.08910470f, -0.31904691f, 0.07935615f, -0.14003584f, -0.04366544f, 
    0.04985919f, -0.19626498f, -0.02688564f, -0.08063803f, -0.14932640f, -0.63435090f, 0.26949757f, 0.06908547f, 
    0.12456884f, 0.14513330f, -0.07651104f, 0.06458162f, -0.03908315f, 0.03943271f, -0.13229544f, -0.09422237f, 
    -0.14502780f, -0.05400850f, 0.06555115f, 0.04008816f, 0.13681670f, 0.08682783f, -0.18457364f, 0.21172866f, 
    0.19562894f, -0.05083400f, -0.12490797f, -0.00566378f, 0.01565449f, 0.02331531f, 0.30099255f, -0.49776444f, 
    0.20882502f, -0.19508797f, 0.15485552f, -0.10085696f, -0.22012265f, 0.11958796f, 0.10101129f, -0.04000781f, 
    -0.16375324f, -0.12252486f, 0.10878550f, -0.08699650f, -0.01015496f, 0.09533961f, 0.14709538f, 0.02701857f, 
    0.18498743f, 0.13578644f, -0.01177730f, 0.03195418f, -0.07444797f, -0.27631354f, -0.08224145f, -0.01649341f, 
    0.01213471f, -0.05630626f, -0.03209813f, 0.04226430f, -0.00923053f, -0.00421576f, -0.12622184f, -0.08906789f, 
    0.09420601f, 0.10550498f, 0.31205180f, 0.17628324f, -0.05499623f, -0.09447559f, -0.04708702f, -0.16418609f, 
    0.04905381f, -0.07787737f, -0.14424513f, 0.24082720f, -0.00620637f, -0.10170379f, -0.26179183f, -0.02070891f, 
    0.00448226f, -0.06671076f, 0.15687501f, 0.03604512f, -0.03790155f, -0.04239063f, -0.04836231f, -0.12236026f, 
    0.12933150f, 0.08826805f, 0.23707488f, -0.22080785f, -0.01591304f, -0.14668857f, 0.22651426f, 0.14647081f, 
    -0.03870502f, 0.03307193f, 0.02689181f, -0.04481689f, 0.00031645f, 0.14829652f, -0.33357751f, 0.41732809f, 
    -0.04616939f, -0.04085885f, -0.13725460f, 0.03658400f, -0.04525717f, -0.03040319f, -0.05159853f, 0.09412242f, 
    0.05696692f, 0.09705118f, 0.06920316f, -0.30973843f, 0.14338493f, -0.06273449f, 0.02097468f, -0.13435490f, 
    0.05223350f, -0.13010806f, -0.05878995f, -0.16883911f, -0.53110242f, -0.08273240f, -0.32793051f, -0.02283900f, 
    0.03368949f, -0.03857396f, 0.06444784f, 0.04103572f, -0.17217505f, 0.01871790f, 0.09581003f, 0.05320809f, 
    -0.04966137f, -0.14967714f, 0.08015864f, -0.17397706f, 0.07167976f, -0.13718817f, 0.16557401f, 0.03913422f, 
    -0.03794646f, 0.11904369f, 0.07279404f, -0.17228630f, 0.15873164f, 0.15784040f, 0.21206552f, 0.22085297f, 
    -0.08399906f, -0.01407923f, -0.10651687f, -0.18307464f, 0.07166473f, 0.12751128f, -0.00506771f, 0.06216028f, 
    -0.04741997f, 0.18584493f, 0.21472448f, -0.02844720f, 0.15918978f, -0.08799868f, -0.04838780f, -0.00901763f, 
    0.07774306f, 0.08629322f, -0.00840249f, 0.02942979f, -0.14250860f, -0.24191438f, 0.07183346f, 0.08594202f, 
    0.16253236f, -0.00552973f, -0.08518099f, -0.05496901f, 0.11427900f, -0.01304341f, -0.02926105f, -0.10447671f, 
    -0.77652526f, -0.38998908f, 0.23161778f, -0.53718865f, 0.10781640f, 0.02599684f, -0.21051158f, 0.15330948f, 
    0.01027967f, -0.03825180f, -0.00687850f, -0.04934509f, -0.00914754f, -0.04212567f, 0.00434637f, -0.13758092f, 
    -0.04974936f, 0.06209533f, -0.14769636f, 0.03243015f, 0.00661680f, -0.09791749f, 0.05569336f, 0.08789325f, 
    0.15746707f, -0.22535390f, 0.51414371f, -0.36068732f, -0.02379524f, -0.20746852f, -0.01173297f, -0.07142699f, 
    -0.04018381f, -0.01040065f, -0.09260590f, 0.02924634f, -0.06487541f, -0.39943081f, 0.34707621f, 0.04832332f, 
    0.14283779f, -0.23787883f, -0.00834513f, 0.12099922f, -0.04754534f, 0.01549673f, -0.01880421f, 0.01135083f, 
    0.07372700f, 0.05425080f, -0.08140995f, 0.18664701f, -0.26720154f, 0.08217826f, -0.06110350f, -0.00457355f, 
    0.10666683f, -0.06896058f, 0.02515528f, -0.01028911f, 0.06662572f, 0.02944726f, -0.13974504f, -0.02667101f, 
    -0.03860898f, 0.05091019f, 0.08434951f, 0.05793390f, -0.05744475f, 0.05324539f, 0.11912497f, 0.20511998f, 
    0.02421819f, -0.10996687f, 0.02813622f, 0.17790520f, 0.09189991f, 0.09544516f, 0.03838507f, -0.12708987f, 
    0.16073301f, -0.01384266f, -0.02471793f, -0.10749817f, -0.08328890f, -0.09389572f, 0.09850552f, 0.11946719f, 
    -0.00150971f, 0.00728484f, -0.10130930f, -0.05527864f, 0.05011632f, -0.21637176f, -0.01706724f, 0.08288171f, 
    0.11781019f, -0.04191521f, 0.16302070f, 0.21317708f, 0.00625223f, 0.05197620f, -0.07959519f, -0.04789465f, 
    0.03853175f, 0.05771851f, 0.11898012f, 0.10309757f, -0.39744055f, -0.35429266f, -0.08142039f, -0.01839836f, 
    -0.09400009f, 0.08222416f, -0.07902127f, 0.24365968f, 0.00628940f, 0.04629018f, 0.04006854f, -0.00950286f, 
    0.01065409f, 0.15639538f, 0.24663427f, 0.05702223f, -0.06370164f, -0.15274209f, 0.00754744f, -0.04266565f, 
    -0.04016551f, 0.10054865f, 0.03498475f, 0.07886393f, 0.13037989f, 0.10269095f, -0.04420820f, 0.38639772f, 
    -0.11208852f, -0.05775244f, 0.10074267f, 0.01413943f, 0.09637108f, -0.05294821f, 0.08296729f, 0.14113148f, 
    -0.00697720f, -0.08355270f, 0.22309777f, 0.04931393f, 0.01069114f, -0.14156115f, -0.11775457f, -0.03170375f, 
    0.02534809f, -0.03571573f, 0.00314284f, -0.05143323f, -0.03618795f, 0.06650844f, -0.07289828f, -0.08942307f, 
    -0.16001205f, -0.03330727f, 0.05798848f, 0.06506618f, -0.09233758f, 0.06131932f, 0.02204536f, 0.07195508f, 
    -0.10884866f, 0.16561902f, 0.24835846f, -0.02515556f, -0.05862035f, -0.01139734f, 0.03669626f, 0.12604365f, 
    -0.04612804f, 0.01851740f, 0.09792821f, 0.08332516f, -0.28736544f, 0.21583618f, 0.03300814f, 0.02390749f, 
    0.13324063f, -0.05789166f, -0.05342118f, -0.10881178f, -0.09579761f, 0.00387954f, -0.17131040f, -0.08623146f, 
    -0.07373428f, 0.20017585f, 0.13272175f, -0.23357707f, -0.10556971f, -0.02469509f, 0.01214328f, 0.01378364f, 
    0.00023000f, -0.13893957f, -0.36826080f, -0.30135986f, 0.00500681f, 0.06070401f, 0.24314286f, 0.02860189f, 
    0.08068115f, 0.08160681f, -0.15617222f, 0.01684112f, -0.19480850f, -0.09805229f, -0.00849576f, -0.23871703f, 
    -0.37464389f, 0.02509720f, 0.16955128f, -0.10367618f, -0.24448875f, 0.10292464f, -0.10232301f, 0.15352292f, 
    0.04916884f, -0.06252529f, -0.01070765f, 0.11351552f, 0.05099169f, -0.05823993f, 0.09728751f, -0.07123809f, 
    -0.07023407f, -0.10217945f, -0.00303503f, -0.04379421f, -0.09939209f, -0.07074828f, -0.08983767f, 0.01864403f, 
    -0.21481332f, 0.24476331f, 0.18697038f, 0.06831530f, -0.01569309f, 0.06228207f, -0.02725591f, 0.05710422f, 
    -0.10974284f, -0.02906755f, 0.12287006f, 0.02323332f, -0.00110634f, -0.10563007f, 0.05269530f, -0.26981115f, 
    0.06249787f, 0.07613751f, 0.02924649f, 0.09476954f, -0.08000987f, 0.07531454f, -0.07110295f, 0.02533789f, 
    0.06798269f, -0.38862118f, 0.10734244f, -0.15667993f, -0.09104073f, -0.24606180f, 0.23469308f, 0.18477836f, 
    -0.19427057f, 0.02260086f, -0.23399243f, -0.05115451f, -0.08192775f, -0.38480371f, -0.08289517f, 0.27071124f, 
    0.00552204f, -0.04541081f, -0.06218119f, 0.22080679f, 0.00917506f, 0.01113767f, 0.05259781f, 0.13528234f, 
    -0.09414364f, -0.13334604f, -0.10559154f, -0.34683934f, 0.02375116f, 0.01848551f, -0.07306924f, -0.16647235f, 
    -0.02365711f, 0.11896815f, 0.10255311f, 0.12004502f, 0.05136506f, -0.02637754f, 0.04180241f, -0.02147163f, 
    0.09246238f, -0.08574428f, -0.10225711f, 0.04408300f, -0.21234092f, -0.02834724f, -0.08237077f, -0.25462556f, 
    0.04099394f, 0.06481257f, -0.13263674f, -0.06993333f, 0.00312692f, -0.16765882f, 0.02886043f, 0.00914000f, 
    0.07046802f, 0.19126655f, -0.15332179f, -0.20070334f, -0.05015519f, -0.46255618f, -0.08136658f, 0.12234105f, 
    0.07796761f, -0.11265299f, -0.05709643f, 0.04834388f, -0.05821408f, 0.04057236f, 0.00602321f, -0.10111095f, 
    -0.29456925f, 0.26375046f, -0.17099766f, -0.03152373f, 0.05653295f, -0.10714714f, -0.29311603f, 0.11857761f, 
    -0.04901675f, -0.17423673f, -0.05983959f, -0.13641760f, 0.29652756f, -0.09353868f, 0.12766169f, -0.13354224f, 
    -0.18195452f, 0.08200277f, 0.04158230f, 0.05718828f, -0.14668471f, -0.03971289f, -0.32434416f, 0.04979096f, 
    -0.00591351f, 0.13614097f, -0.19495001f, 0.07866655f, -0.01280179f, 0.05106882f, 0.07897535f, -0.08560011f, 
    0.02223503f, 0.29234442f, 0.11746386f, 0.13627024f, -0.15574159f, 0.12096772f, -0.17459908f, -0.01014268f, 
    0.03161176f, 0.09130953f, -0.03613793f, 0.08384886f, 0.03576087f, 0.04581243f, 0.03909792f, 0.12859397f, 
    -0.26422375f, 0.29134971f, -0.02034917f, -0.03506083f, -0.02633637f, 0.08042557f, -0.00497281f, -0.10823151f, 
    0.15418349f, 0.04482195f, 0.06499411f, 0.18514599f, 0.12569764f, -0.19246000f, 0.13685670f, -0.22629268f, 
    0.02594665f, -0.00826471f, -0.06094870f, 0.00607426f, -0.20143038f, 0.04350595f, -0.09025966f, -0.16896069f, 
    -0.07701541f, 0.11067804f, -0.14265198f, 0.08517446f, -0.14931051f, 0.08313271f, 0.06136635f, 0.08877558f, 
    -0.08012974f, -0.17304505f, -0.22655919f, -0.01124705f, 0.13513727f, -0.05055599f, -0.27209738f, 0.17951521f, 
    -0.09713107f, 0.07400638f, 0.24262634f, -0.29303172f, -0.03493997f, 0.05370201f, -0.20232116f, -0.02018826f, 
    -0.10203671f, -0.25698301f, 0.17247179f, -0.12560782f, -0.13847545f, 0.02902174f, 0.05578703f, -0.04450899f, 
    0.06570511f, -0.06655016f, -0.10248213f, 0.01410461f, -0.00556252f, -0.06714568f, 0.08076334f, 0.02948666f, 
    0.02152481f, -0.07390993f, 0.06125215f, -0.03378418f, 0.02182188f, 0.12653767f, -0.07082009f, 0.00103450f, 
    -0.21760873f, -0.32938328f, 0.01402492f, 0.00038103f, -0.06458052f, -0.17796665f, -0.06827179f, 0.01531967f, 
    0.04435687f, 0.07584166f, 0.03347897f, 0.02196834f, -0.30023670f, 0.01028782f, -0.01875018f, -0.13309225f, 
    -0.09234602f, -0.10620815f, -0.24777316f, 0.09866477f, -0.08597542f, -0.21481571f, -0.01240074f, -0.02333797f, 
    -0.28937528f, -0.16548365f, -0.04947728f, 0.01902389f, 0.00122200f, 0.06874503f, -0.05594953f, -0.06894337f, 
    -0.02058111f, 0.19019248f, 0.05856873f, 0.05025563f, -0.11904952f, -0.13772582f, 0.03518319f, -0.40597856f, 
    -0.19092685f, -0.26053599f, -0.01605839f, -0.05283898f, -0.20265308f, -0.04946067f, -0.04470027f, -0.16051458f, 
    -0.71363282f, 0.58794171f, -0.32962421f, 0.22329102f, 0.00997086f, 0.18250290f, -0.03749096f, 0.01106291f, 
    -0.03080400f, -0.02180586f, -0.08636127f, -0.09852498f, -0.42678815f, -0.31484503f, 0.16494828f, -0.18118159f, 
    -0.11840792f, 0.19306920f, -0.02078454f, 0.02386976f, 0.12147389f, 0.05988078f, -0.17131507f, -0.10855052f, 
    -0.33731887f, 0.10182104f, -0.31269181f, -0.27254474f, -0.11707713f, 0.09453680f, 0.22824323f, -0.05843438f, 
    -0.06438161f, 0.09320118f, -0.01212471f, 0.09367962f, -0.17414808f, 0.28358284f, -0.16896489f, -0.11365093f, 
    -0.13531391f, -0.02878915f, -0.05217522f, -0.06149416f, -0.06927421f, -0.04293909f, 0.06953205f, 0.07390650f, 
    -0.34005326f, 0.18400009f, -0.32125178f, 0.10574299f, 0.04161030f, 0.05935094f, -0.15547146f, 0.19116785f, 
    -0.01015670f, -0.05369744f, 0.12726578f, 0.06171715f, 0.41830641f, -0.05012228f, 0.31522551f, -0.00018479f, 
    -0.25018480f, 0.10584830f, 0.23979305f, 0.23442744f, 0.04545876f, -0.05855044f, -0.06335982f, 0.03840988f, 
    0.70872080f, 0.43792871f, 0.21606371f, 0.00408929f, 0.03697412f, 0.03862916f, 0.16077626f, 0.13444218f, 
    -0.12770143f, 0.18393858f, 0.08603410f, 0.24571206f, -0.26576561f, -0.17506681f, -0.32802522f, 0.12906919f, 
    -0.18405940f, 0.18954563f, -0.08759581f, 0.21801281f, 0.14107822f, 0.02822837f, -0.03524325f, 0.10742664f, 
    0.16020095f, -0.02804355f, 0.16503933f, 0.05489702f, -0.21585913f, 0.03471651f, -0.04069410f, -0.04814027f, 
    -0.07788586f, -0.02514278f, 0.08707365f, 0.12351632f, 0.09260242f, -0.06403555f, -0.15903361f, 0.22800711f, 
    -0.08880912f, -0.00586884f, -0.10381046f, -0.06014400f, 0.10125552f, 0.09937690f, -0.01408745f, 0.05565199f, 
    0.13613948f, -0.04817196f, -0.12270568f, 0.06311197f, 0.08436737f, -0.08208680f, 0.04687262f, -0.03957135f, 
    0.03870021f, -0.18597795f, -0.09925473f, -0.11658891f, -0.44164237f, 0.06762676f, 0.02792483f, 0.04884995f, 
    -0.00648690f, 0.22741142f, -0.09073686f, -0.06906357f, -0.02842539f, 0.02155813f, 0.00585843f, -0.00851546f, 
    -0.15108970f, 0.17875171f, -0.03472966f, -0.19727613f, -0.05444550f, -0.05170782f, 0.01519963f, -0.03473813f, 
    0.00455516f, 0.02285558f, 0.16408651f, -0.04032565f, 0.00288670f, 0.02001789f, 0.04738121f, -0.00739214f, 
    -0.01456393f, 0.06401790f, 0.18182282f, 0.07440387f, 0.00124050f, 0.13379756f, 0.10670328f, 0.10932600f, 
    -0.39547107f, -0.14150968f, 0.01106349f, 0.07889720f, -0.02233948f, -0.07591368f, 0.07870734f, 0.08435432f, 
    0.02103477f, 0.15894522f, -0.02343476f, 0.00151225f, 0.09729006f, 0.42318740f, 0.14049406f, -0.33949721f, 
    0.05288373f, -0.08692891f, 0.01109202f, 0.01650768f, -0.04555250f, -0.12903355f, -0.12928428f, 0.02754707f, 
    -0.36826119f, 0.20808373f, 0.03023885f, 0.15574588f, -0.13025779f, -0.11322197f, 0.31613535f, -0.13309221f, 
    -0.08238834f, 0.00230855f, 0.31639680f, 0.10025486f, -0.04343465f, -0.25342527f, 0.30163059f, -0.04909256f, 
    -0.00266720f, -0.04684518f, 0.03305524f, 0.09101391f, 0.12120782f, -0.03643288f, 0.08825044f, -0.02334159f, 
    -0.09160200f, -0.03050073f, 0.03279267f, 0.11385018f, -0.02983075f, 0.03299459f, 0.06275066f, -0.04852669f, 
    0.15687305f, 0.13832735f, -0.04145783f, 0.08835732f, 0.09567173f, -0.08847822f, -0.11016835f, -0.04720335f, 
    0.03898368f, -0.06794200f, -0.07373945f, 0.03296648f, -0.17217007f, -0.06731302f, -0.12927386f, -0.14905304f, 
    -0.11137792f, -0.04979068f, 0.00988214f, -0.07875782f, -0.18363269f, -0.04747190f, -0.03423109f, 0.08780159f, 
    -0.08136854f, 0.01161040f, -0.31263331f, -0.01730727f, -0.17320029f, 0.07415874f, -0.11462934f, 0.14647864f, 
    -0.13376825f, -0.15079126f, -0.01886753f, 0.09180339f, -0.08443286f, 0.04037456f, 0.08575854f, 0.05821203f, 
    -0.05916691f, 0.04141914f, 0.02158659f, 0.34078282f, -0.13669907f, 0.19364908f, -0.06713919f, 0.13327646f, 
    0.05715246f, 0.03108913f, 0.05627706f, 0.00333416f, 0.09823282f, 0.08533790f, 0.04937407f, 0.15855189f, 
    -0.07066386f, -0.07600790f, -0.02840000f, -0.06483763f, -0.04601237f, 0.12954789f, -0.00475139f, -0.05177958f, 
    -0.48595402f, 0.12177140f, 0.11835930f, 0.27717590f, 0.01126564f, 0.07302789f, 0.12190261f, 0.08836471f, 
    0.06824635f, -0.03848640f, 0.03776128f, 0.07930157f, -0.25524372f, 0.10273339f, -0.38306081f, 0.06477426f, 
    -0.04458984f, -0.10972821f, 0.02709085f, 0.06163184f, -0.06346373f, 0.15401669f, 0.02973975f, 0.05559215f, 
    -0.02637816f, 0.21447490f, -0.43750978f, -0.05834891f, -0.01314910f, -0.10943173f, 0.05380973f, -0.09128663f, 
    -0.16229290f, 0.13818975f, -0.08679951f, 0.00957573f, 0.05093845f, 0.17084081f, -0.01893405f, -0.04935983f, 
    -0.01996781f, 0.05723267f, -0.00414913f, 0.11008672f, -0.11174542f, -0.20924747f, -0.39684576f, -0.42906779f, 
    -0.15855512f, 0.13878858f, -0.16190645f, -0.14334998f, 0.04760073f, 0.03178281f, 0.01800190f, 0.04518039f, 
    -0.10532449f, -0.16779909f, -0.15073799f, -0.13815260f, -0.12040880f, 0.19645141f, 0.21907867f, 0.12282511f, 
    -0.01523050f, 0.13363579f, 0.17562407f, 0.09252827f, 0.00645967f, 0.12287311f, -0.04042368f, 0.00502629f, 
    -0.04744111f, 0.22852330f, 0.08444031f, 0.02190558f, -0.03699097f, -0.07646482f, -0.09754066f, 0.02663830f, 
    -0.11581098f, -0.12975538f, -0.08487261f, -0.25187838f, -0.26526344f, 0.24022667f, -0.14074773f, 0.15145433f, 
    0.02354602f, 0.06732564f, 0.06484137f, 0.01615273f, 0.07693280f, 0.10923605f, 0.00121785f, -0.08331957f, 
    0.09316779f, -0.27892926f, 0.58379453f, 0.04157632f, 0.07019398f, 0.06614761f, -0.03051841f, -0.08411103f, 
    -0.07752419f, -0.11884049f, 0.19438970f, -0.19395474f, -0.62623888f, 0.09880569f, -0.21135530f, 0.05128660f, 
    -0.01821617f, -0.04720538f, -0.02010724f, 0.22250202f, -0.21887717f, -0.03813121f, -0.04496606f, -0.18928261f, 
    0.22706111f, 0.13988818f, 0.15391319f, 0.07787357f, -0.31154844f, -0.00049263f, -0.17941345f, -0.09124980f, 
    -0.00084552f, 0.08688559f, -0.02923015f, 0.01533214f, 0.17685072f, 0.00236796f, 0.38330632f, 0.02904113f, 
    -0.03351123f, 0.01911221f, -0.10247456f, -0.03428346f, -0.18226282f, -0.02589558f, 0.09153096f, -0.09959334f, 
    0.23735422f, 0.02676588f, -0.03745776f, 0.33815160f, -0.03024599f, 0.12063053f, 0.00791074f, -0.02374047f, 
    -0.16920911f, 0.04436930f, -0.00820588f, 0.11916355f, -0.47065791f, 0.15739554f, -0.40462571f, 0.18339132f, 
    0.15110661f, -0.01277712f, 0.08655408f, -0.05431872f, -0.08596779f, -0.08102694f, 0.03967583f, 0.21266675f, 
    0.14369567f, -0.01479349f, -0.04954295f, 0.04074125f, 0.16871111f, -0.06129894f, 0.05358534f, 0.14233001f, 
    0.12028929f, 0.16741249f, 0.06124374f, 0.09756384f, -0.17561015f, 0.22794780f, -0.33027872f, -0.06265709f, 
    0.09189399f, 0.13490726f, 0.09741655f, -0.03573597f, 0.17892617f, 0.08611453f, 0.15844417f, 0.10374133f, 
    0.26661864f, -0.15789016f, 0.24280651f, -0.05421054f, -0.12725167f, 0.17382182f, -0.09039751f, 0.12854500f, 
    -0.03650007f, -0.04961049f, 0.03072566f, -0.01636217f, 0.03386792f, -0.28191814f, 0.23095015f, -0.21052238f, 
    0.08844435f, 0.06945419f, 0.18749200f, -0.04583953f, -0.07587573f, 0.11803447f, 0.12522094f, -0.08666689f, 
    -0.17460363f, 0.08241990f, -0.25219095f, 0.45954108f, -0.04470289f, 0.13030282f, -0.00509746f, 0.01200813f, 
    -0.24166848f, 0.02710216f, -0.03986383f, 0.10256370f, 0.27539814f, -0.10544828f, 0.18446326f, 0.10539174f, 
    -0.00141443f, -0.07059478f, 0.05200889f, 0.05265707f, -0.10539134f, -0.09572702f, -0.02530473f, -0.02261956f, 
    0.36384588f, 0.22378419f, 0.38713199f, -0.10454500f, -0.13846897f, 0.03682858f, -0.16632776f, 0.07974772f, 
    0.06653298f, -0.05075594f, 0.07096473f, -0.00755283f, 0.00082812f, -0.09133504f, 0.28922430f, -0.02491938f, 
    -0.12789820f, -0.00358199f, -0.19953974f, -0.17050132f, 0.02108419f, -0.01906536f, -0.05155824f, -0.17064779f, 
    -0.00798317f, 0.12929432f, -0.17106013f, -0.00050486f, 0.05174234f, 0.02552926f, 0.11398045f, 0.01700152f, 
    -0.15643677f, -0.02789972f, -0.09662871f, -0.13618031f, 0.04311307f, 0.17023976f, -0.12628360f, -0.04166306f, 
    -0.06500454f, -0.05157726f, 0.11186001f, 0.05087506f, 0.01780711f, 0.01556316f, -0.02850373f, 0.03497209f, 
    -0.31751794f, 0.18640864f, -0.40291011f, -0.27649897f, -0.10410191f, -0.14415151f, -0.02416732f, 0.01405136f, 
    -0.09950674f, 0.02132705f, 0.03726369f, 0.07050811f, 0.06469166f, -0.06002735f, 0.01161292f, -0.26974139f, 
    -0.06049578f, -0.07074804f, 0.08107676f, -0.11472649f, 0.00790350f, 0.03889016f, 0.00864108f, -0.11556509f, 
    -0.23912470f, 0.12403192f, -0.09481268f, 0.01690273f, -0.04270760f, 0.02694937f, 0.02299532f, 0.15046972f, 
    -0.08742186f, 0.18993267f, -0.02015982f, 0.10270873f, 0.09471953f, 0.00969387f, -0.05804732f, -0.15485223f, 
    -0.04508271f, -0.07011292f, 0.10434636f, 0.08171304f, -0.02050214f, 0.06500207f, 0.12368384f, 0.17286584f, 
    -0.09940796f, -0.01170761f, -0.07013644f, 0.14153671f, 0.07654439f, -0.00422360f, -0.02556996f, 0.05858183f, 
    0.04641894f, -0.16084075f, -0.12748176f, -0.12771150f, 0.14468575f, -0.02053333f, -0.00564035f, -0.16289833f, 
    -0.00356284f, 0.00549799f, -0.13569775f, -0.08202028f, -0.08843315f, -0.03842456f, 0.00226148f, -0.11967444f, 
    -0.15361375f, -0.23571086f, -0.18270999f, 0.11147643f, 0.19226022f, 0.02977192f, -0.01482892f, 0.00014782f, 
    0.03303069f, 0.03843876f, 0.02911374f, -0.06935839f, -0.15290286f, -0.12494777f, -0.23641592f, -0.14798808f, 
    0.02676228f, -0.12259556f, 0.05866376f, -0.20777707f, -0.03052678f, 0.07518058f, 0.01204729f, -0.05345896f, 
    0.23537715f, 0.09154925f, 0.09971042f, -0.12705217f, -0.04132454f, -0.01154645f, 0.12994905f, 0.01493559f, 
    -0.05249930f, 0.04912203f, 0.12090770f, -0.03028807f, 0.06966166f, -0.00538450f, 0.31166366f, 0.38073418f, 
    0.01436600f, -0.04775437f, 0.02188209f, -0.01580949f, -0.01939140f, 0.00072644f, 0.02089490f, 0.05951313f, 
    -0.26364765f, 0.16532771f, -0.38582629f, 0.04587473f, 0.01907464f, 0.08080801f, 0.08874864f, 0.06172669f, 
    0.04767038f, 0.06263201f, 0.01590039f, -0.04531997f, 0.10491204f, 0.00760861f, 0.16300759f, 0.21269518f, 
    0.01557892f, 0.04815014f, -0.00444524f, 0.08539997f, -0.14755517f, -0.04824045f, -0.02324441f, -0.11389595f, 
    -0.23985963f, -0.31126577f, -0.22230943f, -0.08069695f, -0.18166329f, -0.20780531f, 0.01395796f, -0.10905962f, 
    0.02635870f, 0.02684867f, -0.10571299f, -0.05276555f, 0.01441130f, 0.10734103f, -0.08537716f, -0.02034509f, 
    0.00644087f, -0.03965965f, 0.01605557f, 0.16415073f, -0.02574806f, 0.13896684f, 0.00036513f, 0.00112351f, 
    0.23471205f, 0.17568710f, 0.02072006f, -0.06602388f, -0.05511584f, 0.02040651f, -0.00501292f, -0.02571538f, 
    -0.02442072f, -0.03602502f, 0.05335912f, -0.03888641f, 0.21323475f, 0.14341347f, 0.08856896f, -0.10668097f, 
    -0.06470563f, 0.09130861f, 0.01908042f, 0.04582907f, -0.07182788f, -0.10339641f, -0.04635440f, -0.07620759f, 
    -0.10697863f, -0.27366093f, -0.11077822f, 0.10084989f, 0.23990265f, 0.01795190f, 0.02917668f, -0.07064465f, 
    0.08486594f, 0.06312150f, 0.18151172f, 0.05749322f, -0.12475256f, 0.33904397f, -0.31388858f, -0.01490551f, 
    -0.01487212f, -0.18502602f, -0.01040211f, -0.08975180f, -0.00812500f, 0.02704823f, 0.08398357f, 0.07077067f, 
    0.13698387f, 0.04441174f, -0.04287575f, 0.17657593f, 0.10775997f, -0.09483407f, 0.01670616f, 0.03514941f, 
    0.20123641f, -0.02034417f, 0.06682590f, -0.12080287f, 0.05545747f, -0.46905559f, 0.30591545f, 0.09190159f, 
    0.23740672f, -0.30294630f, 0.07412086f, 0.04480213f, 0.04485005f, 0.02515744f, 0.14199477f, -0.19467756f, 
    0.05144822f, 0.23862348f, 0.00548117f, 0.13178362f, -0.03182501f, 0.12460577f, -0.17439079f, 0.17872626f, 
    -0.08579135f, -0.01342130f, 0.09969894f, 0.02747490f, 0.00661047f, -0.27821854f, -0.13938643f, 0.13493827f, 
    0.09238153f, 0.12535772f, -0.13770552f, 0.13118473f, -0.07416559f, 0.05462427f, -0.00222015f, -0.18035859f, 
    -0.48046631f, -0.54254049f, 0.43191960f, 0.00632435f, 0.14607826f, 0.09684113f, 0.29324991f, -0.29245624f, 
    0.01143894f, -0.20011948f, -0.13326582f, 0.03443027f, 0.08167825f, 0.26611379f, 0.05127882f, -0.08016118f, 
    -0.00416073f, -0.00931325f, 0.13596572f, -0.06886166f, -0.12247054f, -0.06522264f, -0.06555425f, 0.05994595f, 
    -0.20325562f, 0.09537808f, -0.02219567f, -0.02803450f, 0.07202003f, 0.01600940f, 0.10032425f, 0.00308480f, 
    -0.09145138f, 0.16294478f, 0.03822808f, -0.12246824f, -0.06986061f, -0.23338774f, 0.29783830f, -0.04906508f, 
    -0.05585022f, 0.02782178f, -0.08991215f, 0.16428085f, -0.09997853f, 0.14026020f, -0.07498449f, 0.07920375f, 
    -0.30861440f, 0.25063926f, -0.17193568f, 0.08399298f, -0.11997178f, -0.04909192f, 0.07982031f, -0.08583789f, 
    0.01214450f, 0.12701885f, 0.04282121f, -0.03999108f, 0.09985017f, -0.09053528f, 0.01058543f, 0.06310834f, 
    -0.03297749f, -0.06177230f, 0.02209821f, 0.04362706f, 0.05292343f, -0.05910903f, -0.03840791f, -0.00774453f, 
    -0.13758898f, -0.29625040f, -0.14543918f, -0.10733666f, -0.03881671f, 0.06584491f, 0.08378694f, -0.09262356f, 
    0.13065726f, 0.11260144f, 0.04871243f, -0.16911614f, 0.21179876f, -0.07513680f, 0.06524861f, 0.16386491f, 
    -0.06348079f, 0.03361463f, -0.21604158f, -0.03864778f, -0.17351773f, -0.07133568f, -0.08458678f, -0.07278324f, 
    -0.20224430f, -0.40440151f, -0.01453522f, 0.06573023f, -0.21718763f, -0.14242020f, -0.15549196f, -0.07972638f, 
    -0.05649583f, 0.05912387f, -0.06659997f, -0.09831644f, -0.25761300f, -0.48104441f, -0.20609047f, 0.36479086f, 
    0.02731912f, -0.02894578f, 0.05818184f, -0.02188961f, -0.07332132f, 0.01714954f, -0.01756934f, 0.12784384f, 
    -0.05195775f, 0.12340883f, -0.06917671f, 0.25249860f, 0.05558812f, 0.08167861f, 0.10199989f, -0.09050853f, 
    -0.19915658f, -0.04207366f, -0.02870426f, -0.12311652f, 0.27442771f, -0.38310283f, 0.48389137f, -0.31429967f, 
    0.12703921f, 0.11302093f, -0.01181409f, -0.01672389f, -0.00007142f, 0.06619595f, 0.00259896f, 0.04853714f, 
    -0.09692381f, -0.19540571f, -0.00136944f, 0.07595006f, -0.00882789f, 0.12173549f, -0.18660308f, 0.04229097f, 
    -0.11607713f, -0.05303372f, 0.11302294f, 0.08004159f, -0.18893565f, -0.03271983f, -0.19023122f, -0.03231804f, 
    -0.09965574f, -0.09851702f, -0.09379016f, -0.05139295f, -0.13031866f, -0.02264279f, 0.06647352f, -0.02434103f, 
    0.11249351f, -0.04507918f, -0.09312914f, -0.03223616f, -0.06090913f, -0.07451869f, -0.03520938f, -0.13829176f, 
    0.04953134f, -0.02881772f, -0.06452034f, -0.11195534f, -0.05600271f, 0.11627182f, -0.10546478f, -0.04871012f, 
    -0.03252944f, 0.08779483f, 0.07297615f, 0.07335782f, -0.07988515f, -0.00363758f, 0.02447748f, -0.10381765f, 
    -0.03501591f, -0.05287560f, -0.00639989f, 0.35923663f, -0.20880492f, -0.05881640f, -0.18221524f, -0.06928968f, 
    0.06148739f, -0.00487147f, 0.02226062f, -0.00045452f, 0.07067619f, -0.08306942f, 0.16849145f, -0.11056861f, 
    0.15941182f, 0.01597216f, -0.11075068f, -0.04031521f, -0.04916019f, -0.08174939f, 0.02041230f, -0.05895176f, 
    -0.09691034f, 0.31753874f, 0.03676593f, 0.10185210f, -0.07517467f, 0.02666633f, -0.05026474f, 0.07497050f, 
    -0.07863539f, 0.00536006f, 0.04944253f, -0.14310786f, -0.13315544f, -0.42213145f, -0.21420141f, 0.23888671f, 
    -0.14298397f, -0.08903144f, -0.20882201f, -0.10231673f, 0.01059393f, 0.01788999f, 0.05299275f, 0.04484813f, 
    -0.20170021f, -0.01092058f, 0.10288917f, 0.01809631f, -0.08764455f, -0.27941120f, -0.00011105f, -0.11755101f, 
    0.02903441f, 0.05736100f, 0.02154747f, -0.02062115f, -0.30347919f, -0.02610172f, 0.13730191f, 0.09630985f, 
    0.16384082f, -0.03625187f, 0.05570505f, 0.00407119f, 0.21386139f, 0.15822814f, 0.08315097f, 0.21065846f, 
    0.08604863f, 0.07543156f, -0.03034174f, 0.10267523f, 0.00229170f, -0.00580793f, -0.00330196f, -0.00627242f, 
    -0.00851342f, 0.11203949f, -0.06089272f, -0.00548797f, -0.14735995f, -0.11649194f, -0.06228120f, 0.00124999f, 
    0.13693090f, -0.01458440f, 0.10667695f, 0.04946134f, -0.03639268f, -0.04282647f, 0.05373590f, 0.07674654f, 
    -0.26399493f, 0.17917123f, -0.07649234f, -0.06062239f, 0.02100044f, 0.01197920f, 0.02603352f, 0.01307186f, 
    -0.03998334f, 0.05578263f, 0.18285580f, 0.16404350f, -0.22236252f, -0.38335285f, 0.00032625f, 0.25491753f, 
    -0.01458869f, 0.00781698f, -0.27076480f, -0.14777860f, -0.05117053f, -0.01897026f, -0.02939658f, 0.00735323f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15057074f, 0.07592194f, 0.05251329f, -0.10089722f, -0.05296872f, 0.06597089f, 0.02196169f, -0.13890687f, 
    0.03935692f, 0.02384407f, 0.01048773f, -0.03342634f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
