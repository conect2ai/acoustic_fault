#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.83957857f, 0.80120426f, -0.03750026f, -0.19123724f, 0.15298849f, -1.00879359f, 0.31876069f, 0.52969074f, 
    0.13044050f, -0.70131099f, 0.63281733f, -0.72196001f, -0.32551420f, 0.48672450f, -1.14145827f, -0.30548275f, 
    0.73919410f, -0.03064024f, -1.11912143f, 0.74012291f, 0.81551296f, 0.24827905f, -0.25563878f, -0.06165754f, 
    0.03914022f, -0.50332898f, -0.18481073f, -1.38791382f, -0.26925144f, -0.15598127f, 1.19012809f, -0.36510542f, 
    -1.11889398f, -0.03456447f, -0.53177202f, 0.12542611f, -0.06084869f, -0.17184661f, -0.04150579f, -0.80488169f, 
    -0.43617865f, 0.22261874f, 0.20451389f, -0.16931263f, 1.23321354f, -1.11820412f, -0.90910590f, -0.54334772f, 
    -0.65034914f, 0.47089675f, 0.65558970f, 0.24068455f, 0.57113039f, -0.44584483f, -0.28820208f, -0.50379574f, 
    -0.42752966f, 0.09441991f, -0.00580435f, 0.72804523f, 0.63787222f, -0.30778757f, 0.40934926f, 0.66376054f, 
    0.52949750f, 0.36929181f, -0.21363920f, 0.61960584f, 0.91342640f, 0.20380993f, -0.38530707f, -0.57895839f, 
    0.08919814f, -0.28567308f, -0.61417568f, -0.86562413f, -1.12374747f, -0.98022240f, 0.29330394f, 0.87717336f, 
    0.61532962f, 0.11082638f, 0.22526903f, 0.33781987f, 0.65166408f, 0.09482903f, -0.29876477f, 0.71169698f, 
    -0.81223369f, -0.41127211f, 0.73081219f, -0.02477466f, -0.47045079f, 0.13720325f, -0.07509387f, 0.64176661f, 
    0.29019785f, -0.75546914f, -0.08023787f, -1.70528972f, 1.34084094f, -0.24309725f, -0.94256151f, -0.14779155f, 
    -0.17891878f, -0.28569859f, -0.53012967f, -0.36404350f, -0.70100230f, -0.53252226f, 0.05015829f, -0.38753399f, 
    -0.67784119f, -1.00776315f, -0.23958819f, 0.67891043f, -0.35842702f, -0.04125018f, 0.98782557f, -0.14372973f, 
    -0.37913844f, -0.33099490f, 0.48570544f, -0.40532857f, -0.14921312f, 0.87583870f, -0.54720110f, -1.05724287f, 
    -1.00025666f, -0.02170035f, 0.51465243f, 0.11341233f, -0.20104550f, 0.56562746f, -0.02714588f, -0.06546234f, 
    0.35256878f, 0.01923203f, -0.39867356f, 0.46123070f, 0.40205851f, 0.34092489f, 0.56002599f, 0.15064344f, 
    -0.99929291f, -0.93570572f, -0.67676151f, 1.23707426f, 0.10419176f, 0.62171400f, -0.15370066f, -0.31724015f, 
    -0.41257599f, 0.17481844f, 0.44261718f, 0.05354143f, 0.67093533f, 0.54862070f, 0.73686594f, 0.09061127f, 
    0.62609661f, -0.19236980f, -0.98056644f, 1.02585053f, 0.06372196f, -0.56056130f, 0.09618511f, 0.42439511f, 
    0.53945589f, 0.29875565f, 0.36119935f, 0.21541762f, 0.16866376f, 0.13931926f, -0.47612759f, 0.71113670f, 
    -0.48138833f, -0.36127257f, -1.03219652f, 0.93488050f, 0.27276185f, -0.09996197f, 0.91751730f, 0.61262786f, 
    0.16608675f, -0.14029738f, -0.55816644f, -0.10200310f, -0.47051704f, -0.86210555f, -0.69791466f, -0.70094818f, 
    1.00585306f, -0.04214810f, -0.12629172f, -0.44160613f, -0.72569984f, -0.77089626f, 0.73656613f, -0.67390734f, 
    -0.81115496f, -0.08948544f, 1.49838054f, -0.64726138f, -0.36985302f, -0.28549561f, -0.32347229f, -0.29704762f, 
    -0.31151542f, -0.31976756f, -0.39431190f, 0.16712862f, 0.10862061f, 0.51959556f, 0.68825442f, 0.63417941f, 
    0.85255736f, -0.26578125f, -0.34401277f, 0.62820607f, 0.17704095f, 0.17295159f, -0.25732735f, 0.63497937f, 
    -0.09511094f, -0.04674815f, -1.03188157f, -1.71128511f, 0.61870778f, 0.57895029f, 0.22024544f, 0.40672788f, 
    0.29898942f, -0.13909601f, 0.66258776f, 1.24553037f, -0.14264144f, -0.56488091f, 0.07215524f, -0.25762686f, 
    -0.03565755f, 0.34307089f, -0.36360303f, 0.86541224f, 0.38955802f, -0.05494704f, -0.56370628f, 0.57335204f, 
    -0.73981422f, -0.23978001f, 0.54680121f, 0.46076751f, -0.26191291f, 1.23710382f, 0.93935585f, -0.65853357f, 
    -1.08601379f, -0.28395873f, 0.09207468f, -0.29061949f, -0.39372650f, -0.76080137f, 0.25803256f, 0.35865501f, 
    0.54207510f, -0.46581247f, -0.86549276f, 0.78123361f, 0.22742090f, 0.71592826f, 1.03814089f, -0.74767983f, 
    -0.45286688f, -0.37019423f, -0.12809840f, 0.46591499f, -0.57953787f, 1.00133276f, -1.05591416f, 0.33112970f, 
    -0.66685104f, -1.11935806f, 0.48683223f, -0.94891816f, -0.89677846f, -0.31268522f, -0.33383492f, -0.61013639f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.51026958f, 0.55055624f, -0.10452578f, 0.61466241f, 0.16521509f, -0.20329461f, -0.03808798f, -0.12403899f, 
    -0.04606579f, 0.58692110f, 0.52109450f, 0.04597563f, -0.34537354f, 0.52461225f, 0.75933367f, 0.50733250f, 
    0.07924203f, 0.27281654f, 0.05395757f, 0.25258294f, 0.37382868f, -0.05640142f, 0.14651272f, 0.13891628f, 
    0.64325374f, 0.27587211f, 0.32165116f, 0.26010814f, 0.01757553f, -0.09589029f, -0.16930027f, 0.47624028f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01746780f, -0.02674671f, -0.05183323f, -0.04361778f, -0.05102776f, 0.03570340f, -0.02522535f, -0.04722748f, 
    -0.02768393f, 0.03911964f, -0.04725421f, -0.05943256f, -0.03742094f, 0.03888863f, -0.00921788f, 0.02925901f, 
    0.00773184f, 0.05408025f, -0.01201169f, -0.04274748f, -0.03184968f, -0.00504384f, -0.05588031f, 0.04295539f, 
    0.05622374f, 0.04741589f, -0.02690082f, -0.04581423f, 0.04935330f, 0.00794170f, -0.05892344f, -0.01010283f, 
    -0.02698227f, -0.05745320f, 0.00215849f, 0.03635018f, -0.01198226f, -0.03278923f, 0.04842937f, -0.01401284f, 
    -0.04302987f, 0.05185650f, -0.00797661f, 0.01370221f, -0.05218955f, 0.02288133f, 0.01959685f, 0.02800088f, 
    0.00167687f, 0.04348003f, 0.04942582f, -0.01859562f, 0.04971024f, 0.03379663f, 0.00755427f, 0.01633240f, 
    0.02962969f, -0.05937658f, 0.01768188f, -0.05546461f, 0.03479785f, -0.03460580f, 0.02259232f, -0.01049417f, 
    0.00564872f, -0.03248530f, -0.06296748f, -0.05765901f, -0.03615383f, -0.00111445f, 0.01409589f, 0.00235893f, 
    0.02986447f, -0.03402078f, -0.03374472f, 0.03883902f, -0.01934397f, -0.02077181f, -0.01838712f, -0.06437965f, 
    -0.04839268f, -0.05037021f, 0.01959941f, -0.01589258f, 0.02789947f, 0.00645673f, 0.04660221f, -0.05108859f, 
    -0.03329340f, -0.00133466f, 0.01023646f, -0.05524471f, -0.00056899f, 0.00559924f, -0.04498025f, 0.00619850f, 
    0.01336189f, 0.00588323f, -0.00692854f, 0.04887815f, 0.01623783f, 0.04998737f, 0.04992879f, -0.03385722f, 
    0.03500818f, -0.03793507f, -0.05114625f, 0.03464241f, 0.06210580f, -0.05536133f, 0.05224004f, 0.03037102f, 
    -0.06282880f, -0.03532956f, 0.02449433f, -0.05693435f, 0.04069459f, -0.06324235f, -0.05527668f, -0.02093938f, 
    0.01498537f, 0.05203465f, -0.00520748f, -0.00076764f, -0.03407197f, -0.04344506f, 0.01459513f, -0.04780457f, 
    -0.02869343f, -0.06058524f, 0.03614480f, 0.03562311f, 0.02868159f, -0.02850305f, 0.03185707f, -0.02131430f, 
    0.03225766f, -0.05031939f, -0.01392035f, 0.03520903f, 0.02524370f, -0.01945972f, 0.00881438f, -0.04371981f, 
    -0.02694480f, 0.04541622f, 0.00122041f, 0.02060198f, -0.01286977f, 0.01811947f, 0.03013819f, 0.00481107f, 
    -0.05295702f, 0.03277593f, 0.02289967f, 0.02063834f, 0.00729675f, -0.00091825f, -0.00881138f, -0.02479518f, 
    -0.01459743f, -0.05923143f, -0.00099438f, 0.04931698f, 0.00668942f, 0.00318863f, -0.01051307f, -0.04547554f, 
    -0.02817996f, 0.02118786f, 0.04611379f, -0.02039635f, 0.04624426f, 0.03884754f, 0.03580856f, 0.03503691f, 
    -0.03714909f, 0.03213304f, -0.03544604f, -0.04620015f, 0.02347291f, -0.04878768f, 0.01491522f, 0.04389022f, 
    0.00144663f, 0.04343043f, -0.04640316f, -0.02483649f, 0.03540855f, -0.04085453f, 0.02151228f, -0.01221908f, 
    -0.03541009f, 0.02817538f, -0.02056568f, -0.03802638f, -0.01542370f, -0.04445957f, 0.02873645f, -0.04717348f, 
    0.02456071f, -0.04082179f, -0.05564732f, -0.04794410f, 0.02000733f, -0.04863964f, -0.00708531f, -0.06531325f, 
    -0.00406376f, 0.00281342f, -0.06466228f, 0.04190697f, -0.05959134f, -0.05813413f, -0.05310765f, -0.02837221f, 
    -0.05392912f, -0.01696192f, -0.06277391f, -0.01772509f, -0.03346233f, 0.02846968f, 0.04059133f, 0.05293379f, 
    -0.01811725f, 0.03603384f, -0.05671787f, -0.00638463f, -0.03941064f, 0.01588797f, -0.02193102f, -0.00044274f, 
    -0.05099320f, -0.02972590f, 0.00695634f, 0.02212599f, 0.02363871f, 0.03883264f, -0.00360329f, 0.01956387f, 
    0.05345574f, 0.03591425f, -0.04286860f, 0.03895093f, 0.04187982f, -0.04121044f, -0.01443396f, 0.00867587f, 
    -0.03594512f, -0.03776686f, 0.01004104f, 0.01095820f, 0.02278358f, 0.02972266f, -0.04714393f, -0.01135769f, 
    -0.02374307f, 0.01164478f, 0.01995924f, -0.05524032f, -0.03081054f, -0.04744837f, -0.04365707f, -0.01505363f, 
    0.04056309f, -0.01556233f, -0.04737142f, 0.05326067f, 0.00014903f, 0.04565378f, 0.03908114f, -0.04767933f, 
    0.00750398f, -0.04267615f, 0.01753931f, 0.00423278f, 0.00163009f, 0.01895333f, -0.03604728f, 0.04042192f, 
    0.05337053f, -0.02726928f, 0.01428975f, -0.00316397f, 0.00661165f, 0.01503330f, -0.04081581f, -0.03061601f, 
    0.28121507f, -0.22512607f, 0.08731027f, -0.08867847f, -0.01020821f, -0.26563808f, -0.02520496f, 0.02884337f, 
    0.03337499f, -0.09866080f, -0.04810462f, 0.55850512f, 0.32634938f, 0.09709308f, -0.02257232f, 0.17886764f, 
    -0.12767464f, 0.16192421f, 0.00241833f, -0.03885417f, -0.09163499f, -0.10403676f, -0.00645886f, -0.24232191f, 
    -0.03481591f, 0.03703687f, -0.05891299f, -0.40523282f, 0.22418946f, 0.52032292f, 0.08150943f, -0.03217352f, 
    -0.06121520f, 0.10994433f, 0.22114669f, 0.16332416f, 0.12607828f, -0.26249292f, -0.21322523f, -0.06020553f, 
    0.02549392f, -0.01395253f, 0.17104639f, 0.21989334f, -0.04740086f, -0.40849766f, 0.28162444f, 0.47233939f, 
    -0.07385228f, 0.15279670f, -0.19623518f, -0.02271016f, 0.06630019f, -0.03603112f, -0.30072087f, 0.11665092f, 
    0.22880132f, -0.21103805f, 0.00378461f, -0.06081018f, 0.04289370f, -0.00523634f, -0.10617140f, 0.00539762f, 
    -0.05467509f, -0.17504416f, -0.22250707f, -0.29883772f, -0.29449758f, 0.16251443f, -0.01385754f, 0.16675043f, 
    -0.53611344f, -0.25962874f, -0.31000382f, -0.24035601f, -0.12088845f, -0.38775921f, 0.09625287f, -0.01706582f, 
    -0.00434324f, -0.00686256f, -0.01384192f, 0.03297845f, 0.06009629f, -0.14179558f, -0.19034295f, 0.26603919f, 
    0.27562824f, 0.25044161f, 0.19599126f, 0.19586988f, 0.05293718f, -0.05291336f, -0.04812180f, -0.15049425f, 
    0.02573909f, 0.20537245f, 0.17716029f, -0.05682535f, -0.11089339f, -0.25472924f, -0.16385995f, -0.10110155f, 
    0.12221238f, -0.08758924f, -0.04572066f, 0.18600997f, -0.23387860f, -0.39361131f, 0.06375168f, -0.06252112f, 
    -0.12236670f, -0.39162052f, -0.05334747f, -0.08203103f, 0.32839897f, 0.45278350f, -0.15588672f, -0.09506442f, 
    -0.00292730f, 0.10612228f, 0.19216624f, 0.15548922f, 0.01128387f, -0.00367617f, -0.20903662f, 0.44771698f, 
    0.75240278f, 0.08492520f, 0.25316665f, 0.04027910f, 0.09306785f, 0.02757494f, 0.09172065f, 0.03496326f, 
    -0.12068443f, -0.10466879f, -0.02359818f, 0.05314352f, 0.06510216f, 0.16827835f, 0.14048229f, 0.07558728f, 
    -0.72912097f, 0.21149601f, 0.11516972f, -0.03717965f, -0.01374492f, 0.08466910f, -0.09047189f, 0.06071040f, 
    0.22741468f, 0.02222385f, 0.04383901f, -0.09540843f, -0.12119591f, 0.02613291f, -0.06945591f, -0.02342903f, 
    0.08396133f, 0.13393928f, 0.04006499f, -0.19514969f, -0.35205287f, -0.13734698f, 0.00884001f, -0.01484181f, 
    0.03365428f, 0.04544107f, -0.01849821f, 0.00829258f, -0.30747417f, 0.04094658f, -0.13793646f, -0.09220673f, 
    -0.09050875f, 0.13121073f, 0.30536750f, 0.14497386f, -0.01121277f, 0.01309318f, -0.06983203f, 0.00014423f, 
    0.03135157f, -0.03292014f, 0.04081566f, -0.02374151f, 0.14885344f, -0.58228999f, 0.04354214f, 0.27920681f, 
    0.04130859f, 0.07798556f, -0.01182681f, -0.08940709f, 0.07813053f, 0.36142027f, -0.06797013f, 0.05556184f, 
    0.54854727f, 0.07926857f, -0.05356633f, -0.02100058f, 0.16050012f, -0.15246904f, 0.18855119f, -0.26285934f, 
    0.07494023f, -0.17493312f, -0.27739975f, 0.04505164f, -0.17731938f, 0.13490821f, 0.11049529f, -0.07749940f, 
    -0.03676423f, 0.17226857f, 0.00735505f, 0.04968360f, 0.09126794f, 0.35794783f, 0.05192663f, 0.01896189f, 
    0.13778614f, -0.47325552f, 0.34948850f, 0.50537133f, -0.03291177f, 0.26582617f, 0.04947799f, 0.08125992f, 
    0.11127385f, 0.13505536f, 0.31641886f, -0.28621560f, 0.00744569f, -0.05815038f, -0.03262952f, -0.09472734f, 
    -0.17857680f, 0.13415930f, 0.19726609f, 0.14170833f, -0.25531253f, 0.09827223f, -0.06648882f, -0.04705999f, 
    -0.08056041f, -0.09500904f, 0.13978815f, -0.20906067f, 0.08879977f, -0.99333650f, -0.31404373f, -0.17234637f, 
    0.00365704f, -0.21153356f, 0.06954241f, 0.04278209f, 0.13761830f, -0.32699162f, -0.21048896f, -0.06149633f, 
    -0.32849091f, -0.22675012f, -0.23590295f, 0.11782309f, 0.09919301f, -0.10967470f, 0.27299505f, -0.24716468f, 
    0.01515491f, 0.13916887f, -0.06364645f, 0.10489115f, -0.18723926f, -0.20333204f, 0.29924026f, -0.23146039f, 
    0.02114721f, 0.11975364f, 0.00705878f, -0.01538602f, -0.12873937f, -0.04877085f, 0.21516167f, 0.09009818f, 
    -0.05374747f, 0.04360169f, -0.04842296f, -0.05442427f, 0.00357852f, -0.03924999f, -0.04906886f, -0.02125835f, 
    -0.00527932f, -0.06115757f, -0.03948560f, 0.01847169f, 0.01756252f, -0.02312401f, -0.03240739f, 0.03547389f, 
    -0.05195493f, 0.04287357f, -0.04818793f, -0.03335304f, -0.04642328f, -0.07078073f, -0.05490082f, 0.00817012f, 
    0.01826318f, 0.00238107f, -0.03875925f, -0.04119156f, 0.01251136f, 0.01525283f, -0.04964971f, -0.03101263f, 
    -0.04425033f, 0.00915671f, -0.04681864f, -0.00200057f, 0.04501414f, -0.05722117f, 0.03040441f, 0.01975526f, 
    0.03156642f, 0.02501683f, -0.02478997f, 0.03490453f, -0.01910317f, -0.00540387f, 0.01273729f, -0.05707886f, 
    -0.03577436f, -0.02884559f, 0.03110211f, 0.00085913f, 0.05199861f, 0.01367440f, -0.00719602f, -0.06209720f, 
    -0.01524875f, 0.01971745f, -0.04307685f, -0.01105757f, -0.01313959f, 0.06091556f, 0.04216084f, -0.04631053f, 
    0.02012457f, -0.06077947f, 0.00448828f, 0.01483102f, 0.05308134f, -0.02266081f, -0.03604770f, 0.06376003f, 
    0.00940169f, 0.04668912f, -0.02556539f, -0.02143086f, -0.03314235f, 0.04594159f, -0.02726254f, 0.03410705f, 
    0.00279956f, 0.04557460f, -0.00196340f, -0.05684847f, 0.04461810f, -0.03301607f, -0.01484012f, -0.05440881f, 
    -0.01438167f, 0.01209546f, -0.02408544f, -0.05512989f, -0.02908477f, 0.02115681f, 0.00206685f, -0.03106475f, 
    0.03698581f, 0.04328097f, 0.01650195f, 0.01203284f, 0.00860812f, 0.02386002f, -0.04216554f, -0.05638203f, 
    -0.01456232f, -0.05604848f, -0.00911120f, 0.03048182f, -0.00521586f, 0.04095032f, 0.02460728f, 0.01018125f, 
    -0.06069470f, -0.03481982f, 0.04884816f, -0.01760809f, 0.01973766f, -0.02807223f, 0.04903816f, -0.02302700f, 
    0.04245861f, -0.01812775f, 0.02615900f, 0.04854907f, 0.03119916f, 0.05297098f, -0.03154375f, 0.00434207f, 
    -0.06105761f, -0.00319747f, 0.05597806f, 0.00455921f, 0.03471466f, -0.04912418f, -0.02069101f, 0.01229409f, 
    -0.00204829f, -0.05179359f, -0.05044478f, 0.01441037f, 0.02362199f, 0.02532817f, -0.04456032f, -0.03988939f, 
    0.00415322f, -0.03977912f, 0.05678746f, -0.01012084f, -0.03252298f, 0.00745449f, -0.03237759f, -0.00482794f, 
    0.01939050f, 0.00002329f, -0.04766986f, -0.04400903f, -0.05687623f, 0.04380266f, 0.05430555f, -0.00271985f, 
    -0.02806522f, -0.04611130f, 0.05144999f, 0.02155940f, 0.03383513f, -0.03602914f, -0.05574310f, 0.04567766f, 
    0.02075733f, -0.01898278f, -0.02358428f, -0.02588261f, -0.02697734f, -0.01630835f, 0.03042697f, -0.01405307f, 
    0.03518714f, 0.01028221f, 0.03943675f, 0.00778813f, 0.04196392f, -0.01913319f, 0.01420722f, -0.06843220f, 
    -0.02383568f, -0.06667862f, 0.01442319f, 0.02170311f, 0.04069311f, -0.03489426f, -0.05454444f, 0.02245962f, 
    0.04557276f, 0.02821741f, 0.00183278f, -0.04468545f, 0.03944369f, -0.03051584f, -0.00011203f, 0.04460179f, 
    0.00028182f, -0.02601950f, -0.05791492f, 0.01307680f, -0.00079026f, -0.06539231f, 0.03459558f, -0.03884009f, 
    0.03519780f, -0.06319916f, -0.00471124f, -0.03302430f, 0.05902894f, -0.05383015f, 0.03128916f, -0.00824971f, 
    -0.04042570f, -0.00273182f, -0.00306004f, -0.05521115f, -0.05027069f, -0.03559997f, -0.03052633f, -0.01976459f, 
    0.00767740f, 0.00165670f, -0.03958827f, -0.03361522f, -0.01890638f, -0.00441557f, -0.02473279f, 0.02140838f, 
    -0.06108330f, -0.02295361f, 0.02165547f, -0.02736317f, 0.04153932f, 0.02498307f, 0.02117996f, -0.02607729f, 
    0.04670521f, -0.01782471f, -0.02521654f, -0.00224962f, -0.01112067f, -0.05837806f, 0.02787468f, 0.05811035f, 
    0.01885848f, -0.03514394f, 0.01783801f, -0.00357452f, -0.02148206f, -0.01152804f, 0.01911659f, -0.02318724f, 
    -0.03881748f, -0.05794602f, 0.02393099f, -0.04948599f, -0.06302872f, -0.01712331f, 0.02125498f, 0.00754437f, 
    -0.03862762f, -0.05544609f, 0.02591529f, -0.04691769f, -0.05364065f, 0.02283040f, -0.06117574f, -0.04556857f, 
    -0.00286596f, 0.01621134f, -0.05305503f, -0.03375445f, 0.04868716f, 0.04538283f, 0.02484770f, -0.03752095f, 
    -0.01948132f, -0.01470235f, -0.00997752f, -0.05333529f, -0.01899752f, 0.00377197f, 0.03530681f, -0.04124537f, 
    -0.02555885f, -0.03079214f, -0.02346586f, -0.02009933f, -0.04560405f, -0.03349904f, 0.01651342f, -0.00885724f, 
    0.01473110f, 0.05726817f, 0.02286278f, -0.00307361f, 0.00403884f, 0.03647725f, 0.02316515f, -0.04386229f, 
    -0.04636302f, -0.05272087f, 0.04896560f, -0.00823870f, 0.02746741f, 0.02457978f, -0.05559990f, 0.01742527f, 
    0.00979001f, 0.00607870f, -0.03023883f, 0.05786220f, 0.01157882f, -0.03521428f, -0.06213481f, 0.03021265f, 
    0.05293822f, -0.06427232f, -0.01646790f, 0.03957651f, 0.04842940f, -0.02021019f, 0.01810066f, -0.02323707f, 
    0.01191904f, -0.06433359f, 0.04414635f, 0.02696575f, -0.04662861f, 0.04999093f, -0.01656188f, -0.02819007f, 
    0.03377929f, -0.05075636f, 0.00890445f, 0.02253444f, -0.06671969f, -0.01797770f, -0.05339454f, 0.01806947f, 
    -0.02371250f, 0.03428947f, 0.00018442f, -0.01110458f, -0.02256114f, 0.03072898f, -0.05515556f, -0.02768585f, 
    0.03054984f, -0.05066650f, -0.02982832f, -0.02719410f, 0.03078623f, -0.04494203f, 0.00821786f, 0.01902897f, 
    0.02279337f, 0.03563860f, -0.01213452f, -0.03663646f, -0.00370017f, -0.00048838f, -0.00136142f, 0.00782184f, 
    0.04479880f, 0.03561872f, 0.02468605f, 0.01302847f, -0.04800855f, 0.02179305f, 0.01332352f, 0.04777677f, 
    0.02138314f, -0.05115360f, 0.01728832f, 0.04985864f, 0.00946326f, 0.01166341f, 0.01082839f, 0.05466210f, 
    -0.04409470f, 0.03073721f, -0.04288793f, -0.04577135f, -0.04160867f, 0.04401669f, -0.03438953f, -0.04139963f, 
    0.04175187f, 0.02164594f, -0.06062451f, -0.01315689f, -0.02498539f, -0.03375232f, 0.01122288f, -0.05725507f, 
    0.03187903f, -0.04574584f, -0.00595464f, -0.05684199f, -0.03926758f, 0.04481935f, -0.03559105f, -0.04437833f, 
    -0.01961450f, -0.02144081f, -0.03619315f, 0.04380275f, 0.02708574f, -0.01205598f, 0.05123970f, -0.03525717f, 
    0.04570042f, -0.05235181f, 0.03042627f, -0.04844337f, -0.04914274f, 0.04201170f, -0.05940678f, 0.00140332f, 
    0.03816906f, 0.04822358f, -0.01586591f, -0.01080461f, -0.01618183f, -0.00097499f, 0.02733311f, -0.00718868f, 
    -0.03241598f, 0.03151034f, -0.01977889f, 0.00590056f, 0.02488924f, -0.00209244f, -0.04030067f, 0.00527282f, 
    0.02408105f, -0.06396004f, -0.04130553f, -0.00672272f, 0.00693485f, -0.02995265f, 0.04187181f, -0.02848759f, 
    -0.00795015f, 0.04097777f, -0.01756615f, -0.06192788f, 0.00690725f, -0.01187154f, 0.04713457f, -0.03434788f, 
    0.03771694f, -0.04761729f, -0.06358344f, -0.04476022f, -0.03308561f, -0.03525602f, 0.01266746f, -0.01709498f, 
    -0.02370461f, 0.03883080f, -0.06143553f, 0.00096552f, 0.04415261f, 0.00844979f, -0.03911101f, -0.01135066f, 
    -0.02920046f, -0.00270983f, -0.04843057f, -0.00542409f, 0.03495386f, -0.04554691f, 0.03098641f, -0.05052484f, 
    0.01434151f, -0.00677128f, -0.03334669f, -0.03579922f, -0.03272523f, 0.05280716f, 0.02762065f, 0.03615164f, 
    -0.02802559f, -0.04515729f, -0.03413333f, -0.00208191f, -0.02423208f, 0.00142076f, -0.06015850f, -0.02534613f, 
    0.00330083f, -0.04821343f, -0.06589282f, 0.03150639f, 0.04485138f, -0.04004842f, -0.05430054f, -0.02087835f, 
    0.04526933f, -0.01662278f, 0.02459153f, 0.01208838f, 0.02338810f, 0.00239672f, 0.03107710f, -0.03336446f, 
    0.00252627f, -0.02927623f, 0.04742502f, -0.00964880f, -0.03211380f, 0.00611106f, -0.06693906f, -0.00324879f, 
    0.00856695f, -0.06029905f, 0.00061959f, -0.00008565f, -0.03340910f, -0.04435177f, -0.01244806f, -0.04526326f, 
    -0.02256852f, -0.00214760f, -0.03642277f, 0.04996552f, -0.01636542f, -0.05811936f, -0.05253178f, -0.00240014f, 
    -0.03268536f, -0.01964737f, -0.02182526f, 0.02200421f, 0.03024120f, -0.02645795f, -0.03127891f, -0.02186861f, 
    -0.01910041f, 0.05052839f, -0.06676465f, 0.01401935f, -0.03837322f, 0.00915225f, -0.01916089f, -0.00082508f, 
    -0.00782521f, -0.00237834f, 0.01708874f, 0.01848678f, 0.02144426f, -0.02641627f, -0.03568468f, -0.03661126f, 
    0.04361692f, -0.03317322f, 0.00791536f, 0.00669567f, 0.02262846f, -0.05135470f, -0.03481263f, 0.02210447f, 
    0.05491870f, -0.04527903f, 0.01380482f, -0.01681313f, 0.04226182f, -0.03881238f, 0.06424900f, -0.04711202f, 
    -0.76994377f, 0.09916335f, -0.24492520f, -0.22964463f, -0.22962317f, -0.14016561f, 0.11001466f, 0.10848995f, 
    0.05894010f, -0.28481311f, 0.13523528f, 0.05948268f, -0.09495881f, 0.08784805f, -0.06301998f, 0.15449916f, 
    0.06132574f, -0.00155236f, -0.32157972f, 0.11520868f, -0.32949328f, 0.13056760f, -0.23998566f, 0.29367995f, 
    -0.00781472f, -0.08588909f, 0.02674592f, 0.36437923f, 0.38277784f, 0.20293732f, 0.00869748f, -0.09539083f, 
    0.10263812f, 0.18011022f, 0.11347637f, 0.13489708f, -0.23322076f, -0.06400187f, 0.24674292f, 0.02893525f, 
    0.04196977f, -0.40897056f, -0.03516823f, 0.35145354f, 0.04285974f, 0.12953876f, 0.25193360f, 0.00431418f, 
    0.10440186f, 0.01295834f, -0.02932478f, 0.02267242f, -0.05718957f, 0.10699660f, -0.23515327f, -0.22038452f, 
    -0.00556772f, -0.08515245f, -0.00139680f, -0.14879285f, -0.05532476f, 0.26541692f, 0.11117474f, -0.63106561f, 
    -0.17059186f, 0.25614047f, -0.11786170f, -0.31935793f, -0.51863885f, -0.04170623f, -0.13968444f, 0.13237479f, 
    0.09228400f, -0.13196649f, -0.23379955f, 0.04491441f, -0.03750121f, -0.17815410f, 0.09607653f, 0.03573412f, 
    0.03818954f, -0.11863150f, 0.00629287f, 0.02326785f, -0.10059582f, -0.02760902f, 0.11388881f, 0.21922635f, 
    -0.01615133f, 0.31521848f, 0.34692603f, -0.00906676f, 0.32391685f, -0.01103543f, -0.04505201f, -0.15499264f, 
    0.13460582f, 0.08099575f, -0.01234800f, -0.28060988f, 0.04047999f, -0.02715761f, -0.00091873f, -0.16568875f, 
    0.21028982f, -0.11690973f, 0.11739685f, -0.16187021f, 0.09547220f, 0.06618910f, -0.23837903f, 0.03911399f, 
    -0.22114483f, -0.04286643f, 0.04017137f, 0.06853904f, 0.21069780f, -0.21196510f, -0.12931807f, 0.27479100f, 
    0.15688731f, 0.22543609f, -0.07605556f, 0.09781615f, 0.09935918f, -0.00583088f, 0.23953372f, 0.14617635f, 
    -0.05891145f, 0.20636901f, 0.04179534f, 0.20307805f, 0.12754589f, -0.03577499f, 0.02330487f, 0.04463369f, 
    -0.03418209f, 0.24551195f, 0.03174969f, 0.05810438f, -0.04579241f, 0.10772786f, 0.22512043f, 0.12817411f, 
    0.10125936f, 0.25450420f, -0.03631198f, -0.20065163f, -0.01767869f, -0.08302783f, -0.01314787f, 0.06833104f, 
    -0.25537038f, -0.27951282f, 0.01340662f, -0.07771341f, -0.27238151f, -0.00811953f, -0.55807948f, 0.08695768f, 
    0.08587733f, 0.03459952f, 0.06349277f, -0.29476014f, 0.10878547f, -0.21433225f, 0.10935965f, -0.03374008f, 
    0.08257026f, 0.23399408f, 0.16506244f, -0.28999293f, -0.01799059f, -0.02526154f, -0.08795733f, -0.13159789f, 
    -0.04849523f, 0.23992908f, 0.26236370f, -0.11976734f, -0.10637886f, -0.23569149f, -0.08142523f, -0.04259488f, 
    -0.00485222f, -0.16589603f, 0.14080465f, -0.21016456f, -0.06205243f, 0.11136765f, 0.48606542f, 0.08081601f, 
    -0.08899350f, -0.12483351f, -0.17511082f, 0.09341434f, -0.09814259f, -0.36516446f, 0.34692019f, -0.26630735f, 
    0.12344699f, 0.00803662f, -0.01258489f, -0.24701224f, 0.02126913f, -0.16005842f, -0.19743812f, -0.23588821f, 
    -0.22742969f, 0.05704979f, 0.05992464f, 0.06573107f, 0.02050069f, 0.02333238f, 0.27006665f, -0.03402706f, 
    0.35143578f, -0.01318195f, 0.15128545f, 0.31424823f, 0.00810782f, 0.05442837f, 0.01243348f, 0.15188439f, 
    0.00561171f, 0.12171612f, 0.31549931f, -0.36602882f, -0.10656017f, 0.08612014f, 0.11370440f, 0.08066072f, 
    0.05653862f, -0.00184238f, -0.67675155f, -0.17019925f, -0.17863145f, 0.04520698f, -0.32420710f, -0.12918553f, 
    0.12189782f, 0.03309135f, -0.00834084f, -0.68083930f, 0.19767684f, -0.12578598f, -0.15320134f, -0.12816106f, 
    -0.12203398f, 0.21236694f, 0.10281045f, 0.10485005f, -0.78210461f, 0.06249348f, -0.28406173f, -0.05262752f, 
    -0.16966787f, 0.04895965f, -0.15391055f, 0.16162075f, 0.26471689f, -0.17281698f, -0.38856012f, 0.23841994f, 
    -0.45193726f, -0.01511089f, 0.18662813f, 0.10039959f, 0.05883283f, 0.16054365f, 0.30444506f, -0.19232723f, 
    0.01352451f, 0.01436967f, 0.14783692f, -0.33460209f, 0.21909936f, -0.11462265f, 0.38613495f, 0.24697673f, 
    0.19097772f, -0.26345524f, -0.12659423f, 0.03267397f, 0.13138270f, 0.00227911f, 0.23739126f, -0.03958458f, 
    0.51421702f, 0.18968759f, -0.06344928f, 0.05628590f, 0.02952042f, -0.01135917f, 0.17336057f, -0.01971459f, 
    -0.13402070f, -0.26339656f, -0.15826975f, -0.32781500f, -0.19688328f, -0.08021662f, -0.03417575f, -0.05162232f, 
    -0.21607099f, 0.11107478f, -0.27140352f, 0.23068888f, 0.58292788f, 0.04669795f, -0.03405681f, -0.03869598f, 
    0.03754371f, 0.07319596f, 0.00575446f, -0.36680022f, -0.08196220f, 0.13154452f, 0.10575067f, -0.11335196f, 
    -0.13172443f, 0.08167721f, -0.01725701f, 0.11244957f, -0.01765577f, 0.16397844f, -0.09824762f, 0.06690441f, 
    -0.25397789f, -0.47708401f, -0.06628405f, 0.11274134f, -0.18780854f, -0.04778304f, 0.06460494f, -0.18290101f, 
    0.11698595f, -0.17013098f, 0.02355254f, -0.02376569f, -0.02704774f, -0.06269202f, -0.19487190f, -0.05838090f, 
    -0.02008071f, -0.03344098f, 0.14481725f, -0.07335416f, -0.20452847f, 0.11975197f, -0.24696219f, 0.39018536f, 
    0.21128520f, 0.26265854f, 0.05092353f, -0.02545545f, -0.09584118f, 0.03988717f, 0.05539368f, -0.01937910f, 
    0.15822630f, 0.08848990f, 0.01635866f, -0.04827474f, -0.03033279f, -0.21041285f, 0.01730192f, -0.14255965f, 
    -0.08906815f, 0.29234332f, 0.22940692f, 0.01041390f, 0.14977245f, 0.03444680f, 0.08768635f, -0.03695494f, 
    0.08606917f, 0.16747895f, 0.31421509f, 0.04591466f, -0.09937239f, 0.02992398f, -0.02249650f, 0.10472143f, 
    -0.01526904f, 0.17086384f, 0.12627093f, -0.32540178f, -0.02079363f, 0.02877291f, 0.18755786f, 0.07375789f, 
    0.08905752f, 0.05015015f, 0.07000850f, 0.02810286f, -0.17688540f, 0.02905784f, 0.31119969f, -0.01195221f, 
    0.04533176f, -0.25357315f, -0.10090346f, -0.13762495f, 0.14699876f, 0.21142894f, -0.15515839f, -0.32648712f, 
    0.05421246f, -0.06458915f, -0.10556740f, 0.17011300f, -0.01075954f, -0.15795398f, -0.03412756f, -0.09844700f, 
    0.03518845f, 0.18339673f, -0.08400992f, 0.03725518f, -0.04744609f, 0.06886749f, 0.04344618f, 0.05194983f, 
    -0.06054829f, -0.06739314f, 0.08532257f, -0.07431366f, -0.00839903f, 0.15655601f, 0.00317234f, -0.14654036f, 
    0.01211138f, 0.22339879f, -0.08499362f, -0.15068217f, -0.18918744f, -0.18583737f, -0.07518273f, -0.19604205f, 
    0.03839328f, 0.26361585f, 0.11880475f, 0.02001361f, 0.10357418f, -0.04800451f, -0.09129067f, 0.05258569f, 
    -0.09810345f, -0.13293822f, -0.04779802f, 0.10274544f, -0.10584971f, 0.09565760f, -0.10158323f, 0.06338247f, 
    0.15219222f, 0.07479416f, -0.25375223f, 0.43918252f, 0.32156098f, -0.34789228f, 0.05723299f, -0.05407515f, 
    0.02536524f, -0.27405632f, 0.09662884f, 0.12905283f, 0.30567515f, 0.11149891f, -0.02079944f, 0.11970275f, 
    -0.01533096f, -0.17080806f, 0.04819677f, 0.10540146f, 0.01681837f, -0.21472405f, 0.19143283f, 0.00303709f, 
    -0.01534234f, -0.12990277f, 0.03952685f, -0.07043251f, -0.02664248f, 0.24474433f, 0.13460107f, -0.19104208f, 
    -0.28183374f, -0.37446418f, -0.09329674f, 0.02896978f, -0.12250448f, 0.01896991f, 0.03911274f, 0.14765659f, 
    -0.06234706f, -0.11806945f, 0.18451297f, -0.03404647f, -0.05200639f, -0.01313111f, 0.00542678f, -0.28035012f, 
    0.29426974f, -0.02514887f, -0.00206961f, 0.02305110f, 0.03314560f, 0.04987430f, -0.01582987f, -0.11688127f, 
    0.06004644f, 0.01813567f, -0.00734919f, -0.13803121f, -0.12684788f, -0.10828472f, 0.15922804f, 0.02687519f, 
    0.23843917f, 0.00859800f, 0.57514030f, 0.02272329f, 0.03539660f, 0.02769956f, -0.01144945f, -0.17056459f, 
    0.14060162f, -0.01308788f, 0.12794854f, 0.31992874f, 0.11193176f, -0.07243555f, 0.12982769f, 0.11464553f, 
    0.11165343f, 0.06504838f, -0.16538081f, -0.03904450f, 0.17823118f, 0.21532938f, 0.51777685f, -0.11518840f, 
    -0.23211390f, -0.24231046f, -0.06774049f, 0.10832065f, 0.10938030f, 0.17862311f, 0.01410895f, -0.17205791f, 
    -0.10115744f, 0.16172348f, -0.17728570f, 0.12836643f, 0.02094623f, -0.17843872f, 0.20907044f, -0.31080472f, 
    0.06959201f, 0.08594251f, -0.26263916f, 0.06923824f, -0.07252674f, -0.24097116f, 0.14645141f, -0.00193273f, 
    0.55364811f, 0.26962358f, 0.04515041f, -0.01878144f, 0.20484999f, -0.06308915f, 0.04441437f, -0.01448728f, 
    0.02121293f, 0.00970709f, -0.01277423f, 0.02205792f, -0.01712660f, 0.02713468f, 0.03988509f, 0.02886605f, 
    0.03067377f, -0.04549146f, -0.03805970f, 0.01454306f, -0.01314439f, -0.04330141f, -0.01255513f, -0.03271036f, 
    -0.00974195f, -0.05846432f, 0.04446036f, -0.03736320f, -0.04210774f, 0.03389038f, -0.01791871f, -0.06247001f, 
    0.00205268f, 0.02776858f, 0.02468933f, -0.04646549f, -0.01210623f, -0.02044595f, -0.05705067f, -0.00547439f, 
    0.02799058f, 0.00391246f, -0.02888628f, -0.03438652f, 0.04665876f, -0.05770849f, -0.05402211f, 0.03107511f, 
    -0.05725797f, -0.03692848f, 0.03398514f, -0.04122280f, 0.02825072f, -0.00354370f, -0.06757043f, 0.04297294f, 
    -0.02103113f, 0.03342836f, -0.02566911f, -0.03310207f, 0.03406348f, -0.01191876f, 0.02140873f, 0.04408345f, 
    -0.02344256f, -0.02998943f, 0.01151260f, -0.06133455f, 0.01516828f, -0.00811251f, -0.05874590f, 0.01911178f, 
    0.00734106f, -0.00235657f, -0.05616883f, 0.01949862f, -0.00597845f, -0.02890283f, 0.00827904f, -0.04569839f, 
    -0.00259578f, -0.03705630f, -0.00425025f, -0.02513372f, -0.00467241f, -0.02485554f, 0.01415349f, 0.05187792f, 
    -0.03495927f, 0.03022847f, -0.03669349f, -0.01376212f, 0.01611493f, -0.03596715f, -0.00211472f, -0.06842522f, 
    -0.06111681f, 0.01143664f, 0.00980233f, -0.05644444f, 0.01259708f, 0.01562443f, 0.00836275f, -0.01058595f, 
    0.02572853f, 0.00798580f, -0.06203157f, -0.04265083f, -0.04327830f, 0.02710689f, 0.04576257f, 0.03372819f, 
    -0.05995280f, 0.04847545f, 0.01788942f, -0.05656622f, -0.05611646f, 0.00810592f, -0.05373118f, 0.01196293f, 
    0.04569648f, -0.03907848f, -0.00865832f, -0.05484581f, 0.02133110f, -0.03302896f, 0.02875953f, 0.04084475f, 
    0.01502995f, 0.03296504f, -0.03064025f, -0.06703568f, -0.01707986f, 0.02167777f, -0.05768406f, -0.06896287f, 
    0.01461411f, 0.04209173f, 0.01802430f, 0.04533482f, 0.00683778f, -0.00180310f, -0.00717621f, -0.06135480f, 
    -0.04010950f, -0.02253170f, -0.00162194f, 0.01181007f, -0.04274923f, 0.00983597f, -0.01490539f, -0.03658945f, 
    0.04622988f, -0.04746225f, -0.01147265f, -0.00968325f, 0.03701283f, 0.04765664f, -0.05416071f, 0.00173165f, 
    0.04253519f, -0.04529445f, 0.04567936f, -0.01785527f, -0.05254158f, -0.02878183f, 0.01417801f, 0.03326618f, 
    0.01405819f, 0.04445661f, 0.01997337f, -0.03396701f, 0.01774466f, -0.00555101f, 0.01784809f, -0.01814994f, 
    0.03264680f, -0.02131257f, -0.05810447f, 0.01417885f, 0.01791112f, -0.06056755f, 0.01814183f, 0.00788242f, 
    -0.00534936f, 0.00958699f, -0.00421751f, -0.00187526f, 0.01147311f, 0.01494715f, -0.03404688f, -0.05577818f, 
    -0.04460904f, -0.02008054f, 0.02819224f, -0.06510448f, 0.02845183f, 0.04797651f, -0.03035878f, 0.03740596f, 
    -0.06034023f, 0.01044202f, -0.02625904f, -0.01302251f, 0.00071450f, -0.03143331f, -0.00080151f, -0.00397745f, 
    0.01264267f, -0.01624462f, 0.02168415f, -0.01928615f, -0.01769553f, 0.01933329f, -0.04441789f, -0.00602422f, 
    0.04241822f, -0.02774544f, 0.02166260f, -0.04978704f, 0.02005076f, -0.04946521f, 0.02192506f, -0.00073076f, 
    -0.06689658f, -0.05355846f, 0.01026873f, -0.06327265f, -0.01367594f, 0.04468061f, 0.03255461f, -0.00657652f, 
    -0.03482191f, -0.06013660f, 0.00273940f, -0.01861897f, -0.02338538f, 0.04241142f, -0.03897271f, -0.05331152f, 
    -0.01035633f, 0.00248972f, -0.00123560f, -0.00377568f, -0.04541811f, 0.02725021f, 0.02334348f, 0.01957666f, 
    -0.00097261f, -0.00391249f, -0.04808453f, -0.00282437f, -0.00041202f, -0.06159929f, -0.00526161f, -0.04202959f, 
    0.04313400f, -0.00389819f, -0.03068299f, -0.06478538f, -0.03440259f, -0.05064449f, 0.00183737f, -0.00267460f, 
    0.00295140f, -0.01686714f, -0.06451041f, -0.04456069f, 0.01927757f, 0.00781146f, 0.01233733f, 0.00030068f, 
    0.04052997f, -0.05335318f, 0.01447101f, -0.04438021f, -0.00086651f, -0.06126321f, 0.04637906f, 0.03751219f, 
    -0.06012655f, 0.01778084f, -0.02112761f, -0.05463056f, 0.04204088f, -0.05782345f, -0.00256769f, -0.05887369f, 
    -0.03805255f, -0.03838500f, -0.04446670f, 0.04428478f, 0.05060571f, -0.03848526f, -0.03546034f, 0.01223082f, 
    -0.37469107f, 0.13702881f, -0.13123174f, 0.00588981f, 0.05622212f, -0.09343416f, -0.02025856f, 0.08138054f, 
    -0.08939583f, -0.07828131f, 0.13898171f, -0.29543689f, 0.11395829f, 0.15201755f, 0.03709541f, 0.08763386f, 
    0.10924829f, 0.06371187f, 0.46972179f, 0.12692274f, -0.63701749f, -0.11034705f, 0.02830353f, -0.02991444f, 
    0.03292048f, -0.09260411f, 0.22036703f, 0.02021804f, -0.01341031f, -0.02953096f, 0.00591246f, 0.13990822f, 
    0.05944080f, 0.11274996f, 0.07839200f, 0.00824691f, 0.05645690f, 0.01601771f, -0.15629096f, 0.28430590f, 
    0.13434593f, -0.07096878f, -0.13922732f, -0.08400734f, 0.07542045f, -0.20946170f, -0.49120358f, -0.15131824f, 
    -0.11250956f, -0.13549209f, 0.11860542f, -0.03169952f, -0.14676349f, -0.20730589f, -0.20452298f, -0.16032317f, 
    -0.15318763f, 0.10068148f, 0.04876859f, -0.01863820f, 0.04276257f, 0.16516931f, -0.32992154f, -0.30125952f, 
    0.41953063f, -0.07229826f, -0.02536776f, 0.05031197f, -0.15099914f, -0.08977774f, -0.06355578f, -0.14555663f, 
    -0.36590415f, -0.07535373f, 0.17482568f, -0.08948621f, -0.07034083f, 0.03487158f, -0.14726804f, -0.15336606f, 
    0.03380975f, -0.16311546f, 0.25245866f, -0.03881686f, -0.13606963f, -0.11708614f, -0.06147141f, 0.07348485f, 
    0.14833315f, 0.18243487f, -0.27657712f, 0.36899385f, -0.01854996f, 0.05108327f, -0.07840937f, 0.03697517f, 
    -0.17554222f, 0.26469147f, -0.15243118f, 0.43354324f, -0.40840948f, -0.47338536f, -0.02837276f, 0.10528319f, 
    -0.01889052f, 0.20606461f, 0.06707456f, 0.22459538f, -0.16633886f, -0.26998171f, 0.19826873f, -0.01354947f, 
    0.00069651f, 0.12394371f, 0.01981594f, -0.02048152f, 0.00107317f, 0.01796295f, 0.02099243f, -0.02342539f, 
    0.08739793f, 0.08422258f, 0.01855358f, -0.00353112f, 0.01143528f, 0.07333969f, -0.02357838f, -0.23425221f, 
    0.06492776f, 0.06138714f, 0.16564436f, 0.22346766f, 0.03357862f, -0.13317046f, -0.04646676f, -0.03340328f, 
    0.06988481f, -0.11873095f, 0.01540487f, -0.00567806f, -0.09606864f, 0.14822824f, -0.05538022f, -0.02910725f, 
    0.09188105f, -0.46608052f, -0.10346878f, -0.06757078f, 0.20233701f, 0.23644905f, 0.22775796f, 0.11371830f, 
    -0.14629973f, -0.17062055f, 0.18512057f, 0.14492653f, -0.02541288f, 0.01039905f, -0.06900286f, 0.20925282f, 
    0.03655618f, -0.05916727f, 0.09268676f, -0.04866489f, -0.32514596f, -0.01190752f, 0.05109070f, -0.10125415f, 
    0.08510688f, -0.28279781f, -0.15207765f, 0.12162822f, 0.17107265f, 0.22925095f, 0.18799965f, -0.14623865f, 
    -0.17388594f, 0.22781785f, 0.03963082f, -0.15244600f, -0.18829057f, 0.26194215f, -0.20912933f, -0.08218990f, 
    0.02128774f, -0.10767509f, 0.07450171f, -0.02575070f, 0.01399556f, 0.10696118f, -0.33233640f, -0.00895655f, 
    0.01663498f, 0.09832554f, 0.03773395f, 0.07818539f, 0.21697751f, 0.00546261f, -0.15180518f, 0.27515569f, 
    0.15937211f, 0.13627051f, 0.34165376f, 0.20134614f, 0.09722698f, 0.18219958f, 0.01130695f, -0.11409705f, 
    -0.01927845f, 0.01360105f, -0.04661849f, 0.09159496f, -0.10765184f, -0.01717202f, -0.07054483f, 0.00720341f, 
    -0.13734904f, 0.16155218f, 0.20155789f, -0.04210769f, 0.06417437f, 0.12276952f, 0.12311723f, 0.05500335f, 
    0.08741166f, 0.09413766f, -0.24680303f, 0.25842586f, 0.12007949f, 0.20923193f, 0.14785931f, -0.10074249f, 
    -0.16137518f, -0.02419379f, -0.36134452f, 0.28884199f, -0.06005726f, -0.10485527f, 0.09959044f, 0.01540403f, 
    0.01088127f, 0.08303964f, -0.13185832f, -0.10124028f, 0.21588537f, -0.05159879f, -0.00326899f, 0.05858273f, 
    -0.12388475f, 0.09920679f, 0.09278520f, -0.07765833f, 0.20258316f, 0.16625707f, -0.03063808f, 0.02871583f, 
    0.11480805f, 0.16891563f, 0.01679581f, -0.11775436f, -0.11433528f, -0.16249055f, -0.09589238f, -0.16683926f, 
    0.01006261f, 0.01285859f, -0.19183624f, -0.15762699f, -0.15600088f, -0.18547939f, -0.10583510f, 0.20865089f, 
    -0.28173593f, 0.12003531f, 0.22798198f, -0.02328586f, 0.12892824f, -0.03218134f, -0.09327080f, -0.09672306f, 
    -0.34525758f, 0.21632347f, -0.05307249f, -0.02729954f, 0.11748201f, 0.16696556f, 0.09689640f, 0.03786160f, 
    -0.13611391f, -0.10761274f, -0.00093570f, 0.07261343f, -0.02185959f, 0.11398036f, -0.04385174f, -0.02402084f, 
    0.15701729f, 0.06433865f, 0.05470479f, -0.11364580f, 0.12218467f, 0.04368280f, 0.12761302f, 0.10886078f, 
    -0.19151452f, 0.11269701f, -0.23700789f, 0.14090315f, -0.00540332f, -0.10879610f, 0.06026391f, -0.02704624f, 
    -0.01822157f, -0.03412104f, 0.06528197f, 0.16047701f, 0.26006958f, 0.14407703f, 0.02545619f, 0.21413724f, 
    -0.00980186f, -0.04231392f, 0.34559292f, -0.02249979f, 0.12505867f, 0.12436379f, -0.21673088f, 0.03553871f, 
    0.38404107f, -0.07543413f, 0.03031481f, -0.03292207f, 0.03228694f, -0.27947843f, -0.06739859f, -0.15388229f, 
    0.05079621f, -0.29124793f, -0.03480854f, 0.12715003f, -0.04925370f, 0.10474371f, -0.50324512f, -0.02679208f, 
    0.02213113f, -0.03724596f, 0.31170422f, -0.14925547f, -0.03927319f, 0.05418478f, -0.07495634f, -0.15001406f, 
    0.09965571f, 0.14927533f, -0.12964313f, -0.18017402f, -0.18220700f, -0.12187293f, -0.40422446f, 0.05192545f, 
    0.29243100f, -0.41364464f, -0.00466151f, 0.01905874f, 0.06050464f, 0.12667027f, -0.00752429f, -0.05612057f, 
    -0.12260751f, -0.06927054f, 0.16450661f, 0.16896091f, -0.08486158f, 0.12629955f, -0.09427023f, 0.03125327f, 
    0.14126903f, 0.14344880f, 0.06320553f, 0.17050043f, 0.10766888f, -0.19681285f, 0.14609005f, 0.00545982f, 
    -0.12749098f, 0.01701442f, 0.20228590f, 0.12242074f, -0.17437908f, -0.20558944f, 0.13714096f, 0.08305491f, 
    0.17008108f, 0.15638180f, 0.12027877f, -0.33034635f, 0.00892180f, -0.47510397f, 0.07865623f, 0.03701740f, 
    -0.00218802f, 0.20053896f, 0.12852377f, 0.12133179f, -0.12221278f, 0.01382031f, 0.30186188f, -0.01705726f, 
    -0.00830343f, 0.16270010f, -0.04180173f, 0.33368334f, 0.06844766f, 0.08149819f, -0.26512969f, -0.03376418f, 
    0.19388658f, 0.03606582f, -0.13376394f, 0.03832257f, 0.06140237f, -0.12844488f, 0.09889632f, -0.04094257f, 
    -0.05647055f, 0.10640049f, 0.18330288f, -0.04697648f, 0.13122138f, 0.11828665f, -0.08294839f, 0.09817742f, 
    0.02293355f, -0.06514056f, 0.13313267f, -0.16118294f, -0.00411503f, -0.13002713f, -0.11759226f, 0.04354139f, 
    -0.00732492f, 0.00254663f, 0.07673257f, 0.12922598f, 0.15433942f, 0.04899273f, -0.02459926f, -0.13259923f, 
    -0.15784130f, 0.00033595f, -0.05675263f, -0.02481946f, 0.00407961f, 0.16819979f, 0.07849938f, 0.11801817f, 
    0.04546098f, -0.03794467f, 0.14274576f, -0.02836713f, 0.29218554f, 0.30596331f, -0.09869394f, 0.15894040f, 
    -0.15114433f, 0.19111495f, 0.24051498f, -0.01955413f, -0.12443209f, 0.08215127f, 0.06331360f, 0.01006104f, 
    -0.01615508f, -0.01537183f, 0.19119923f, 0.16821566f, -0.13006960f, 0.20733440f, 0.15225121f, 0.54385859f, 
    -0.05519298f, 0.25389153f, 0.01496170f, -0.04729604f, -0.13496266f, -0.00563603f, 0.09817471f, -0.03066275f, 
    0.27172211f, -0.14018576f, 0.24174118f, -0.03789526f, -0.08515556f, -0.27295297f, -0.01439578f, -0.16413257f, 
    -0.01563222f, -0.02185691f, 0.06455997f, -0.14002977f, 0.06929120f, 0.15847328f, -0.07306869f, 0.01985012f, 
    -0.00480525f, 0.11902143f, 0.16353899f, -0.01222487f, 0.05521198f, 0.09820191f, -0.14666767f, 0.10018140f, 
    0.32247239f, -0.22256607f, -0.00270683f, 0.04439415f, -0.16413686f, -0.02384896f, -0.11310847f, -0.07252692f, 
    -0.06149299f, -0.01646500f, -0.23742346f, -0.10457347f, 0.25914159f, -0.07489891f, -0.01580416f, -0.04953324f, 
    0.17713548f, -0.26453501f, 0.23400237f, 0.04468143f, -0.11773822f, 0.10770110f, 0.06930265f, 0.12112994f, 
    0.16437919f, 0.07654925f, -0.18088017f, 0.15533324f, -0.57205665f, -0.04892393f, -0.05577493f, -0.13572310f, 
    0.05828632f, -0.04083116f, -0.05446476f, -0.14318793f, 0.03492295f, -0.03250103f, -0.04515697f, 0.08534694f, 
    -0.09701602f, 0.12045144f, 0.07330370f, -0.12805542f, 0.26883778f, -0.09039859f, 0.46422383f, 0.14986560f, 
    0.57519454f, -0.02872411f, -0.04246571f, 0.16773623f, -0.18743253f, 0.34128204f, 0.00534772f, -0.04707278f, 
    -0.02605218f, 0.29766032f, 0.03141441f, 0.22660132f, 0.14198676f, 0.06202427f, 0.07093152f, -0.01554329f, 
    0.40754244f, -0.15048347f, 0.13805734f, 0.05277279f, 0.17491421f, 0.18386677f, 0.04110138f, -0.13794532f, 
    -0.01876041f, -0.55491114f, -0.23759037f, 0.28491953f, 0.15937306f, -0.09871245f, 0.00645337f, 0.05713693f, 
    -0.04308745f, 0.07824177f, -0.03633095f, 0.05387691f, 0.23284580f, -0.10767496f, 0.01886923f, -0.23464932f, 
    0.26657304f, -0.04039649f, 0.07820677f, -0.06011532f, -0.29794389f, 0.01192590f, -0.01580835f, -0.02376215f, 
    -0.02576733f, 0.08356946f, 0.07347023f, 0.02986349f, -0.05250391f, 0.30590162f, -0.27224219f, 0.10218959f, 
    0.03186706f, 0.26272911f, 0.00264719f, -0.00422468f, -0.18533200f, -0.18512005f, 0.22552197f, 0.15126607f, 
    -0.16243748f, 0.04740803f, -0.06968170f, 0.12200781f, -0.08075837f, -0.02297379f, -0.18939525f, 0.03319850f, 
    -0.05382869f, 0.01747112f, 0.19606879f, -0.21631685f, 0.01983695f, 0.04516578f, -0.18685737f, 0.09639125f, 
    0.07199890f, -0.01402574f, -0.11779863f, -0.17084250f, -0.18708462f, -0.02873914f, -0.05941001f, 0.10267980f, 
    -0.48966715f, -0.58551288f, -1.00930047f, -0.02123346f, 0.00473862f, 0.02402958f, -0.00886062f, -0.17563717f, 
    0.00185016f, 0.19262841f, 0.07407553f, 0.13359848f, 0.11651752f, 0.17237493f, -0.35430250f, 0.20724173f, 
    -0.11686770f, 0.26569358f, 0.24262902f, 0.21256594f, 0.20738083f, -0.01752347f, -0.00348537f, -0.06503400f, 
    0.06220123f, 0.08142289f, 0.09528812f, -0.14452301f, -0.53065449f, 0.19749264f, 0.00012596f, -0.08905699f, 
    0.01161337f, 0.00480177f, 0.14172079f, -0.08190034f, 0.05963577f, 0.30008367f, -0.09842283f, -0.06607604f, 
    0.00680022f, -0.07289932f, 0.04850642f, 0.01115947f, -0.05987884f, 0.06794219f, 0.11479247f, 0.16667275f, 
    0.02486266f, -0.01398286f, 0.39436564f, 0.04766164f, 0.12029834f, -0.14823388f, -0.19610070f, 0.47716334f, 
    0.08474062f, 0.03775959f, -0.06359283f, -0.12639517f, 0.01569973f, -0.07170594f, -0.03926948f, 0.07063983f, 
    0.10118881f, 0.19521379f, -0.05949541f, -0.01121411f, 0.00305832f, 0.13339433f, -0.02373791f, -0.07074799f, 
    -0.10862455f, -0.22850530f, -0.27007332f, 0.03042441f, -0.08361803f, -0.01619492f, 0.01817743f, 0.12241720f, 
    -0.01603761f, 0.03724549f, 0.04494944f, 0.11950430f, -0.13791794f, 0.00121701f, -0.12352374f, -0.11082486f, 
    -0.22525814f, -0.11882295f, -0.07833638f, 0.02423048f, 0.20565501f, -0.06234456f, -0.03275244f, 0.04847402f, 
    0.05726265f, -0.07345820f, 0.01531515f, 0.12960547f, 0.16106445f, 0.11794515f, -0.04637709f, 0.16504724f, 
    0.04004813f, -0.00037206f, 0.12741128f, 0.12128051f, 0.06133353f, -0.01465250f, 0.03355156f, 0.04998659f, 
    0.11700243f, -0.01351309f, 0.25851849f, -0.11769889f, 0.28989697f, -0.06253543f, -0.04535953f, -0.49600396f, 
    -0.04734040f, -0.02839620f, 0.01912697f, 0.07771058f, -0.01997421f, -0.11668625f, -0.15240018f, 0.14633740f, 
    0.31625572f, 0.14734335f, 0.13763808f, 0.08933996f, 0.07111600f, -0.18111627f, 0.06920525f, -0.19204509f, 
    0.19996811f, -0.01039112f, -0.20244354f, -0.08910823f, -0.08657565f, 0.11424103f, 0.06078342f, 0.00758617f, 
    0.28732869f, 0.10693812f, 0.22613907f, 0.24773332f, -0.11723430f, 0.01976948f, -0.08490825f, 0.17382315f, 
    0.02279206f, -0.18161866f, 0.27692184f, -0.23109819f, 0.07884916f, 0.17017476f, -0.03778862f, 0.09716744f, 
    -0.09821387f, 0.01405473f, 0.28140655f, -0.09648203f, 0.21278635f, -0.05003107f, 0.05389567f, 0.11649155f, 
    -0.02563339f, 0.15557055f, 0.05214427f, 0.25859928f, -0.04127111f, 0.19775006f, -0.01981532f, 0.14099963f, 
    0.13985965f, 0.03788348f, 0.08458214f, -0.00123026f, -0.21558115f, -0.68551219f, -0.42706963f, -0.01491213f, 
    0.07321145f, 0.12180672f, 0.13731310f, -0.03730394f, -0.05813395f, -0.17814462f, -0.01303794f, 0.20695393f, 
    -0.02164534f, 0.06262001f, 0.18139252f, -0.03534038f, -0.09348246f, 0.17724551f, 0.10688930f, 0.47937888f, 
    -0.40389287f, 0.19661507f, -0.12288462f, 0.42875209f, 0.08331405f, 0.04436333f, 0.39301983f, -0.07796110f, 
    -0.25556421f, -1.00254011f, 0.00620104f, -0.01904835f, -0.32652858f, 0.15936156f, 0.01558234f, 0.07184903f, 
    -0.16806081f, 0.28177792f, 0.17250036f, 0.02280002f, 0.05437174f, -0.08641369f, 0.02042629f, -0.06879883f, 
    -0.01203632f, 0.02000464f, 0.13429639f, 0.07618572f, -0.08848241f, 0.01839153f, -0.12472884f, -0.04903760f, 
    -0.07503041f, -0.06321835f, 0.26429424f, 0.32627970f, 0.00945649f, -0.14975084f, -0.03479268f, -0.16523285f, 
    -0.03837780f, 0.12815654f, -0.17726634f, 0.08690785f, -0.17701557f, 0.08295842f, -0.15432407f, 0.11586116f, 
    -0.19689678f, 0.03475121f, 0.05159625f, -0.09538709f, -0.17957093f, 0.39115292f, -0.07636414f, 0.05029411f, 
    -0.14578375f, 0.11745953f, -0.21374658f, 0.06638321f, -0.23847601f, 0.08727113f, 0.21763454f, -0.03121774f, 
    -0.02599778f, -0.15887165f, -0.04200739f, 0.09221303f, 0.01182676f, 0.04571598f, -0.18869260f, 0.26217195f, 
    0.57964486f, 0.05575158f, -0.05344410f, 0.09726986f, 0.00315736f, 0.06940093f, 0.14094636f, -0.26897061f, 
    -0.10896188f, 0.06304467f, 0.08688334f, -0.24907932f, 0.04025144f, 0.05076190f, 0.12128992f, 0.03516038f, 
    0.13447466f, 0.02673666f, 0.49110892f, 0.01681970f, 0.16273014f, 0.01931740f, 0.06308454f, -0.27338731f, 
    -0.14466485f, -0.10335793f, 0.16950911f, 0.08228206f, 0.05038951f, -0.10136244f, -0.12641171f, -0.00023513f, 
    0.00287618f, 0.07438298f, -0.28532714f, -0.04393181f, 0.07076343f, 0.02890231f, -0.12629811f, 0.16072381f, 
    -0.02335788f, 0.24368608f, 0.11549620f, 0.26492110f, -0.57612252f, 0.02133108f, 0.08993719f, 0.22828273f, 
    0.03648822f, 0.13986883f, -0.21468960f, 0.06820032f, 0.17705056f, 0.11906943f, 0.63118863f, -0.04819830f, 
    0.01699919f, 0.01823845f, 0.03229836f, -0.14761846f, 0.08384916f, -0.42763004f, 0.28153929f, -0.57866830f, 
    -0.02054329f, -0.02843088f, 0.12299659f, -0.05289200f, 0.13036001f, -0.02976308f, 0.00511716f, -0.02596227f, 
    0.20123374f, -0.00223300f, 0.00206073f, -0.16457285f, 0.03103574f, 0.03827768f, 0.06775682f, -0.05605081f, 
    -0.03427299f, -0.23747393f, -0.26031220f, -0.09767569f, 0.19388835f, 0.07015216f, -0.09654661f, -0.09518641f, 
    0.11707365f, 0.04951537f, 0.23874187f, 0.01357675f, 0.02802362f, 0.04109475f, 0.16626857f, -0.15454859f, 
    -0.13940783f, -0.08030500f, 0.12863526f, 0.20203412f, -0.01215432f, -0.08397561f, -0.01463752f, -0.02335888f, 
    -0.04711051f, 0.02477453f, 0.05007130f, 0.14314629f, -0.35281539f, -0.19019276f, -0.09223623f, 0.17085008f, 
    0.07620003f, -0.09917498f, -0.23047891f, 0.09521309f, 0.37091976f, -0.00485755f, 0.06624769f, -0.05090170f, 
    0.19949974f, -0.29912588f, 0.12821078f, -0.19385986f, 0.00417974f, 0.04216059f, 0.19334280f, 0.12331598f, 
    0.15046127f, -0.15844433f, 0.16345753f, -0.13749851f, 0.24282299f, 0.15052798f, -0.40770748f, 0.20753326f, 
    -0.06838496f, 0.13881806f, 0.19120586f, 0.22767878f, -0.03545824f, -0.07043210f, 0.33791596f, -0.02314115f, 
    0.12688309f, 0.06735460f, -0.29385599f, 0.08496340f, -0.25869253f, 0.00913741f, -0.00775121f, 0.21587510f, 
    0.17085163f, 0.01561580f, 0.10196158f, -0.01206242f, 0.01880603f, 0.15254331f, -0.26738304f, -0.07238708f, 
    -0.10510248f, -0.07745308f, 0.24399899f, -0.24545303f, -0.23343417f, -0.05202114f, -0.09406935f, -0.01071324f, 
    0.24816340f, 0.19563608f, -0.18857615f, 0.43650341f, 0.06744270f, -0.19097303f, -0.11013507f, -0.02281438f, 
    0.07398947f, 0.13663070f, -0.39027461f, 0.26178256f, 0.16215755f, -0.06444880f, 0.00174253f, -0.11909950f, 
    -0.12169480f, 0.04136514f, 0.07452150f, -0.36277926f, 0.29608753f, 0.17444071f, -0.04120434f, -0.05758906f, 
    0.11053253f, -0.17270561f, -0.12188827f, 0.01796952f, -0.14167790f, 0.05826940f, 0.25445089f, -0.06826095f, 
    0.05976777f, -0.06926617f, -0.19718820f, -0.03357546f, -0.10048530f, 0.28288308f, -0.05193683f, -0.04526499f, 
    -0.03670061f, 0.03310411f, -0.02521702f, -0.05168617f, -0.35428056f, 0.01601607f, -0.28991121f, 0.50974298f, 
    0.15310867f, -0.02741859f, -0.05867550f, 0.06265747f, 0.05381901f, 0.35850012f, 0.16071145f, -0.02997079f, 
    0.01120232f, 0.25675952f, -0.07772205f, 0.04362877f, -0.07601396f, 0.12371925f, -0.04352061f, -0.02199682f, 
    -0.17928715f, 0.22907321f, 0.05372355f, -0.05589084f, 0.03581252f, 0.02050094f, 0.15660422f, 0.05258679f, 
    0.16007850f, 0.51226830f, -0.67693752f, -0.34990236f, -0.07801830f, 0.07297099f, 0.06470863f, 0.07887478f, 
    -0.15535925f, 0.03270030f, 0.29855224f, 0.13820687f, 0.19413428f, -0.14477731f, 0.06574135f, -0.20179814f, 
    -0.03291608f, 0.19829786f, 0.06906749f, 0.40992829f, -0.94937456f, 0.11690430f, -0.07913455f, 0.12429718f, 
    -0.23439570f, 0.07856257f, 0.19437100f, 0.10872258f, -0.07662811f, -0.17624772f, -0.22031604f, 0.30973741f, 
    0.12183107f, -0.06922959f, -0.13362680f, -0.12779483f, 0.17143352f, 0.98893046f, -0.60405356f, -0.68475997f, 
    -0.04222456f, -0.13912603f, -0.00202683f, 0.04119706f, -0.16362761f, -0.18096709f, 0.18726064f, -0.29703522f, 
    -0.38840720f, 0.34681085f, 0.14111888f, 0.09726122f, 0.11005319f, 0.07611004f, -0.05258927f, 0.03444206f, 
    0.09295724f, 0.20047857f, 0.02246993f, -0.00885841f, 0.12169070f, 0.04291051f, -0.32829699f, 0.11475824f, 
    0.18102634f, -0.18427105f, -0.23299809f, 0.11860577f, -0.03357611f, 0.05068761f, -0.08308075f, -0.07075652f, 
    0.16599251f, 0.06865066f, 0.16804536f, 0.24082910f, -0.04439050f, 0.08538263f, -0.01144387f, 0.00322416f, 
    -0.13210335f, -0.05653739f, 0.07175851f, 0.14789779f, 0.09858181f, 0.20617037f, -0.28040844f, -0.01241660f, 
    -0.12333386f, -0.04922450f, 0.17357565f, 1.03697169f, -0.31756198f, -0.40099087f, -0.04370208f, -0.05346438f, 
    -0.19171625f, 0.21816126f, 0.29137087f, -0.09863205f, 0.50986642f, -0.04820313f, 0.13379177f, -0.11901762f, 
    -0.13238899f, -0.09505594f, 0.03456562f, -0.00718241f, -0.13246228f, -0.03426095f, 0.12827452f, -0.24185377f, 
    0.14868735f, 0.04700311f, 0.07126281f, -0.03500931f, -0.15323977f, -0.02034586f, 0.63969767f, -0.90619975f, 
    -0.96966648f, -0.03589546f, 0.14322872f, 0.11854432f, 0.10829283f, -0.10427796f, -0.05876549f, 0.05201179f, 
    0.11297911f, 0.06789548f, -0.04990329f, -0.01419572f, -0.00208049f, 0.21875589f, -0.13252258f, 0.04767588f, 
    0.74969560f, -0.56393808f, -0.48117918f, -0.08367805f, 0.02743472f, -0.21232767f, 0.01113320f, 0.06047465f, 
    -0.13198720f, 0.08678851f, 0.15059257f, 0.13361585f, -0.26367331f, -0.25054613f, -0.22243530f, 0.12338995f, 
    -0.19132030f, 0.02947561f, 0.43986115f, 0.17319457f, -0.03873875f, 0.00364239f, 0.04745466f, -0.09400035f, 
    0.14432137f, -0.06336936f, 0.05651770f, 0.09909152f, -0.17160603f, -0.00920521f, 0.24388978f, 0.16191074f, 
    -0.09119119f, -0.05913500f, 0.18357633f, -0.20654529f, 0.21585226f, 0.14219807f, 0.03694559f, -0.03851969f, 
    0.06547170f, -0.07348537f, 0.05924182f, 0.00395467f, -0.03539320f, 0.34139350f, -0.55031210f, -0.12760706f, 
    -0.08463583f, -0.04673820f, -0.20953947f, -0.11066121f, -0.00466104f, -0.05761209f, -0.25438875f, -0.37985986f, 
    0.38390464f, -0.13969770f, -0.02465081f, 0.08407718f, 0.03015289f, -0.10082593f, 0.21476719f, 0.24818948f, 
    -0.11595154f, -0.12930267f, 0.14606979f, -0.11288819f, 0.02853568f, 0.17618044f, -0.02582404f, 0.01457255f, 
    0.05702657f, 0.09649808f, 0.19970846f, -0.09438110f, -0.17955324f, -0.27873793f, 0.15134427f, 0.05766492f, 
    0.09995497f, 0.24628595f, -0.82526058f, -0.67170173f, -0.26324743f, 0.12878734f, 0.21594433f, 0.14988890f, 
    -0.00641953f, -0.05848681f, -0.21323834f, 0.20490810f, 0.06647883f, 0.12374278f, 0.07118489f, 0.06889266f, 
    0.04681689f, -0.17995806f, 0.02592422f, -0.33691928f, 0.26389676f, 0.17866819f, -0.03175593f, 0.01363539f, 
    -0.01563291f, 0.25235960f, 0.01751838f, 0.09814519f, -0.29695562f, 0.10346863f, 0.11391987f, -0.00455982f, 
    0.00837818f, -0.01691252f, -0.10747939f, -0.03979607f, 0.07223050f, 0.42078266f, -0.10385010f, 0.05375452f, 
    -0.02106836f, -0.08066735f, -0.01829395f, 0.13749734f, 0.19373748f, 0.03492758f, -0.15039511f, -0.07469606f, 
    0.08171754f, 0.05502636f, -0.12624058f, 0.06985904f, 0.05409829f, 0.01834813f, 0.08397516f, 0.10902623f, 
    -0.70310438f, -0.05883495f, -0.11388360f, -0.06816415f, -0.02865589f, -0.10983159f, 0.02424769f, 0.34893811f, 
    0.01923740f, -0.06590939f, 0.01352881f, 0.02331292f, -0.02317565f, -0.04890606f, 0.04878935f, -0.01690569f, 
    -0.00857759f, 0.00819939f, 0.00426083f, 0.00101766f, -0.01269267f, 0.02729115f, 0.00052358f, 0.02795957f, 
    -0.03614789f, -0.04032635f, 0.03876698f, -0.01068299f, 0.05005300f, 0.00716610f, -0.01861793f, 0.03174266f, 
    -0.01942687f, -0.04355269f, 0.01774977f, 0.03590211f, 0.02649097f, -0.03023166f, -0.00165214f, -0.04715133f, 
    -0.04187643f, -0.01290174f, 0.04349588f, -0.04052263f, -0.03441227f, -0.02966314f, -0.06652112f, -0.02422913f, 
    0.01217659f, 0.00591834f, 0.00501492f, -0.03415298f, 0.01631442f, -0.06451569f, 0.01977662f, -0.04004342f, 
    -0.03400233f, 0.00705648f, 0.01060877f, -0.05578907f, -0.06828198f, -0.05022123f, 0.02077655f, 0.02568538f, 
    0.04237896f, 0.02923141f, -0.03196227f, -0.00347959f, 0.01218116f, -0.05898403f, -0.06194432f, -0.02939189f, 
    0.04053454f, 0.00069182f, 0.05603684f, -0.05455678f, -0.00103058f, 0.04283205f, -0.03173069f, -0.03234490f, 
    -0.05861567f, 0.00018449f, 0.03158875f, 0.00073209f, 0.00320160f, 0.05425132f, -0.01994909f, -0.00274841f, 
    0.04693051f, -0.03639909f, 0.00029704f, 0.02426533f, -0.05211774f, -0.01871210f, 0.01540380f, -0.00676044f, 
    -0.00915928f, 0.04904603f, -0.00492129f, -0.03298471f, -0.03118344f, -0.00571257f, -0.03216575f, 0.02927320f, 
    -0.02720658f, 0.04639386f, -0.05415590f, 0.01977874f, -0.00562234f, -0.02306154f, -0.06080212f, 0.02940393f, 
    0.00244749f, -0.05104594f, -0.02091958f, 0.01176414f, 0.04473451f, -0.02669956f, -0.04571057f, -0.02084684f, 
    0.00129671f, -0.02547572f, 0.02531530f, -0.00688682f, -0.01595123f, 0.02681581f, 0.03107789f, 0.02784361f, 
    0.03159471f, 0.03346178f, 0.00255395f, 0.01061893f, 0.03458202f, 0.03857646f, -0.03916643f, -0.00819740f, 
    0.00807845f, 0.01956938f, 0.02544406f, -0.01420891f, -0.03592024f, 0.02788242f, -0.01597405f, -0.03184774f, 
    0.03826658f, 0.01843122f, -0.05168299f, -0.00911163f, -0.06160217f, 0.01476138f, -0.05884279f, -0.02710816f, 
    -0.02684287f, -0.03161909f, -0.05401247f, 0.01982582f, -0.00175520f, -0.05022458f, -0.04273100f, 0.00699912f, 
    -0.02809898f, -0.02812031f, -0.05839317f, 0.04459039f, 0.04582892f, -0.03255039f, 0.02289069f, -0.00358535f, 
    -0.03364606f, -0.06454589f, -0.02634217f, 0.00702440f, -0.04884795f, 0.01473732f, -0.04711595f, -0.01864890f, 
    -0.05144600f, -0.00385853f, -0.05310178f, -0.00985910f, -0.02499456f, -0.04410937f, 0.05720172f, -0.02192589f, 
    -0.05354915f, -0.02583504f, 0.02604124f, 0.04156293f, -0.01759746f, -0.05400298f, -0.00727350f, 0.01253741f, 
    0.03399047f, -0.01092752f, -0.06790966f, -0.02861715f, -0.03994389f, 0.04452236f, -0.03038955f, 0.02480816f, 
    -0.02015953f, 0.02721844f, -0.04784266f, 0.02478986f, -0.04342154f, -0.00791545f, -0.00120736f, -0.00822461f, 
    -0.02752796f, -0.02385999f, 0.04657665f, 0.02556149f, -0.06366774f, 0.02301953f, -0.06325388f, -0.01814415f, 
    0.04087951f, 0.00944601f, 0.01918979f, -0.03315606f, -0.02459429f, 0.02688840f, 0.01499561f, 0.01918041f, 
    -0.02765845f, 0.04924522f, 0.01798172f, 0.04611065f, -0.02907522f, -0.00268622f, -0.03971592f, -0.04394963f, 
    0.00344632f, 0.04823956f, 0.00213841f, 0.03858764f, 0.03359291f, 0.03872257f, -0.02779115f, -0.05039915f, 
    0.03141017f, -0.01919902f, -0.04838672f, 0.01035699f, -0.04522298f, 0.03257493f, 0.00769238f, -0.05339916f, 
    0.02435814f, 0.03774194f, -0.01973068f, -0.00680248f, 0.02918393f, -0.04917883f, -0.04173764f, -0.02460082f, 
    -0.02094109f, 0.02915070f, 0.04615498f, -0.03249024f, 0.05514828f, 0.04173354f, 0.04632052f, -0.04474001f, 
    -0.01027000f, 0.02349513f, -0.04606002f, 0.02416910f, -0.02543087f, -0.01468809f, -0.00802318f, 0.00499485f, 
    0.03576859f, 0.04575347f, -0.00490488f, -0.00634339f, 0.05176173f, -0.02981625f, 0.01785997f, 0.01562297f, 
    -0.05887788f, -0.00434416f, -0.05698697f, 0.00576771f, -0.01236960f, 0.02041155f, -0.03546778f, -0.01617469f, 
    -0.02996365f, -0.05399494f, -0.01091192f, 0.03062159f, -0.03490702f, 0.02283463f, 0.00858348f, -0.00132183f, 
    0.07050474f, -0.12626868f, -0.22320680f, -0.11389457f, -0.08934934f, 0.05538655f, -0.17717892f, -0.05244118f, 
    -0.08659296f, -0.32506883f, 0.19165389f, 0.25436708f, -0.08978567f, 0.19956620f, 0.27068838f, -0.01117639f, 
    0.07628933f, -0.03853855f, -0.69668996f, 0.64168000f, -0.00879537f, -0.26664394f, -0.16319434f, -0.02250339f, 
    0.11323226f, 0.24395403f, 0.13401742f, -0.07724330f, 0.22522920f, -0.08301371f, 0.22193776f, -0.09726329f, 
    0.02770441f, 0.09392110f, 0.01867360f, -0.09276365f, 0.09801277f, 0.10419577f, -0.03883173f, -0.11770214f, 
    -0.01799503f, -0.18056147f, -0.10820790f, -0.14469714f, -0.22456774f, -0.38339084f, -0.13861831f, 0.06890659f, 
    -0.00091705f, 0.11311059f, 0.11486378f, 0.16950223f, -0.13544822f, 0.28217325f, -0.29205003f, -0.16566424f, 
    -0.22571288f, -0.06518365f, 0.07579847f, 0.10958571f, -0.06447122f, 0.21652272f, 0.02794128f, 0.07183395f, 
    -0.10881551f, -0.07085337f, 0.30962622f, -0.04511970f, 0.00534758f, -0.06863014f, 0.09760339f, 0.17468396f, 
    0.44121090f, 0.41612509f, 0.23370813f, -0.07091951f, -0.11973362f, -0.04373198f, -0.01269918f, 0.14106634f, 
    -0.05996419f, -0.06557167f, 0.06146202f, -0.21280484f, 0.09446067f, -0.05177830f, -0.00048049f, -0.00491699f, 
    -0.00055637f, 0.22168568f, 0.06230187f, -0.04568249f, -0.42924628f, 0.23646358f, -0.03641555f, 0.02984255f, 
    0.14380443f, 0.15952423f, 0.01230958f, -0.07063236f, 0.62663883f, 0.26050314f, -0.31557232f, -0.25673044f, 
    0.30301902f, -0.02576004f, 0.07125013f, 0.05755440f, 0.20238440f, 0.20910510f, 0.44140282f, 0.13035168f, 
    0.01439647f, -0.03104566f, 0.02203524f, -0.09932038f, -0.01935894f, -0.19596428f, 0.02148851f, -0.56098932f, 
    -0.00239247f, 0.14813562f, -0.09416296f, 0.24029168f, 0.11538863f, -0.01320187f, -0.18792072f, -0.06760143f, 
    -0.13824444f, 0.19309002f, 0.25811583f, 0.21923018f, 0.21078549f, 0.02435026f, 0.14897774f, 0.07090480f, 
    -0.01615134f, 0.00169211f, -0.04793364f, 0.02839062f, 0.06837212f, -0.28720024f, -0.14437303f, -0.20287317f, 
    -0.32455152f, 0.11889148f, -0.22501531f, 0.20280215f, 0.07219180f, 0.09011957f, 0.16963823f, 0.10201641f, 
    0.24736211f, -0.01092227f, -0.06536747f, -0.09902000f, 0.07500518f, -0.01510341f, -0.10091666f, -0.09860939f, 
    -0.00653025f, 0.04170668f, 0.07675277f, 0.00336228f, -0.08953627f, -0.02906134f, -0.01834471f, 0.07147363f, 
    -0.13950777f, -0.11059207f, 0.03657097f, -0.16745161f, -0.00299249f, -0.37476623f, 0.35023546f, -0.08136688f, 
    -0.02498816f, 0.04506496f, 0.03867953f, 0.03940592f, -0.07672095f, -0.09580846f, -0.26839063f, 0.08852976f, 
    -0.02658127f, -0.02396124f, 0.13528724f, 0.11569957f, 0.22828732f, -0.19134346f, 0.21706903f, 0.15976058f, 
    0.10666674f, 0.06053871f, -0.01869339f, 0.05906530f, -0.04323093f, 0.02703304f, 0.12956984f, -0.02758275f, 
    -0.00101633f, -0.08629032f, 0.03843972f, 0.03127958f, 0.20316871f, 0.30515566f, 0.01678675f, 0.15694883f, 
    0.03647012f, 0.17196596f, -0.10714102f, -0.08307700f, 0.17367274f, -0.21816257f, -0.26095381f, -0.03316968f, 
    -0.09802509f, 0.04515966f, -0.35970607f, 0.20435837f, 0.09346383f, -0.02714313f, 0.08510868f, -0.10258474f, 
    0.11182906f, -0.45272496f, -0.18812771f, -0.39422399f, 0.13193382f, 0.27385262f, 0.02787039f, 0.10849074f, 
    0.18620059f, 0.11675058f, 0.09445459f, -0.23756751f, -0.42891750f, 0.23396866f, -0.03650229f, 0.08486156f, 
    -0.03867008f, -0.00501836f, 0.12775390f, -0.32007429f, 0.00104884f, -0.26803932f, -0.29640594f, -0.09270018f, 
    0.12771273f, -0.11237041f, -0.01428673f, -0.18691033f, -0.21741654f, -0.18973380f, -0.32626551f, 0.00076348f, 
    -0.22673732f, -0.29251611f, 0.07982331f, 0.20574650f, 0.26061293f, 0.08153415f, 0.07194414f, 0.13926235f, 
    0.01865765f, -0.17648001f, 0.10042100f, -0.18472487f, -0.20489669f, -0.22199227f, -0.18689795f, 0.20158830f, 
    -0.23352048f, 0.13190487f, -0.07303967f, -0.19735387f, 0.25518793f, -0.11404880f, -0.14102764f, 0.24283071f, 
    0.43189245f, 0.12300222f, 0.16572234f, 0.16948237f, 0.13820092f, -0.02285697f, -0.00791897f, -0.01243605f, 
    -0.02727944f, -0.01532603f, 0.01882077f, -0.00895998f, -0.00283840f, -0.04930569f, -0.01604812f, -0.01686153f, 
    -0.06427433f, 0.03379211f, 0.02554667f, -0.01916191f, 0.02596168f, -0.00895838f, 0.00958906f, -0.02265685f, 
    0.03377714f, -0.05640306f, -0.05461899f, 0.02022013f, 0.04600954f, -0.04272702f, -0.04018508f, -0.05448600f, 
    0.03007133f, 0.02755378f, 0.02323625f, -0.03037638f, -0.04348250f, 0.04370584f, -0.03648504f, -0.02338449f, 
    0.02651644f, -0.02940117f, -0.05846615f, 0.03087651f, 0.00214205f, -0.03509788f, -0.06527701f, -0.04354000f, 
    -0.05914226f, -0.02095296f, -0.02193031f, -0.04033685f, -0.00012829f, 0.00024722f, 0.04956462f, 0.00155746f, 
    0.03957650f, 0.02472975f, 0.02354873f, 0.01294279f, -0.03222590f, -0.06212062f, 0.04462857f, 0.00338334f, 
    -0.06513716f, -0.03178440f, 0.04895014f, 0.01682413f, 0.04950250f, 0.03548009f, 0.00135551f, 0.00605101f, 
    -0.02805382f, -0.04502294f, -0.05854620f, -0.02140243f, -0.03379827f, 0.03216645f, -0.04886552f, 0.04244697f, 
    -0.03213339f, -0.06468321f, -0.03461639f, -0.03142109f, -0.02306471f, 0.04352032f, -0.01940326f, 0.04363366f, 
    -0.06527051f, 0.02278528f, -0.02306419f, 0.04800368f, 0.02165726f, 0.01017341f, -0.03899927f, -0.00419350f, 
    -0.06015807f, -0.02774224f, 0.03505038f, -0.03947102f, 0.02743291f, 0.02339154f, 0.03132825f, 0.04215124f, 
    0.03258085f, -0.05745594f, -0.01991400f, -0.02971716f, -0.06078364f, 0.02266406f, 0.03705842f, 0.04674035f, 
    0.03729791f, -0.02072465f, 0.03295806f, -0.04168684f, -0.06306837f, -0.05156163f, 0.03759543f, -0.03325323f, 
    0.04198361f, -0.02411318f, 0.02314005f, -0.05541623f, 0.04799997f, 0.00467315f, -0.03112763f, -0.04972722f, 
    0.02381878f, 0.04441961f, -0.06370141f, 0.01456564f, -0.00801624f, 0.04733505f, 0.04097538f, -0.04646179f, 
    -0.00493971f, 0.01657896f, -0.00217018f, -0.00574813f, -0.03244198f, -0.05501319f, -0.05493229f, -0.05281064f, 
    0.00029386f, -0.05320299f, -0.01469310f, 0.01781222f, -0.01372310f, -0.04121171f, 0.02109914f, -0.05762582f, 
    -0.01456584f, -0.04433170f, 0.04236218f, 0.01272767f, 0.00691461f, -0.04424644f, 0.00868845f, -0.06179672f, 
    0.00407298f, 0.04268276f, -0.06323136f, -0.03959066f, -0.06338028f, 0.02911475f, -0.01501697f, -0.05420196f, 
    -0.02093268f, 0.02197322f, -0.00308013f, -0.01018044f, -0.06223423f, -0.03183934f, 0.00491306f, -0.05549879f, 
    0.02260853f, -0.06460488f, 0.03737155f, -0.04081680f, 0.03778658f, -0.02860733f, -0.06006819f, 0.04883125f, 
    0.03934112f, 0.01286946f, -0.05016242f, 0.02002027f, -0.05551670f, -0.01283885f, -0.04718957f, -0.05457486f, 
    -0.02953324f, -0.01572346f, -0.05605476f, 0.03694051f, 0.00114362f, 0.00434509f, 0.02683044f, -0.00344431f, 
    -0.02843097f, 0.00985957f, -0.04816554f, -0.05359028f, 0.01490594f, -0.05326003f, 0.02294632f, 0.04552421f, 
    -0.02496026f, -0.06274313f, 0.02532878f, -0.00484736f, -0.01258883f, -0.05208370f, 0.02675776f, -0.03366285f, 
    0.02111638f, 0.03887786f, 0.03221006f, -0.03455509f, -0.05410754f, -0.02415987f, 0.00410984f, 0.00333236f, 
    -0.00180553f, 0.00725061f, -0.01290050f, 0.04503104f, 0.01382113f, -0.06410815f, -0.01468302f, 0.03640726f, 
    -0.03234062f, 0.02877020f, 0.01890775f, 0.00838211f, 0.00169079f, -0.06346016f, -0.01529822f, 0.03949813f, 
    -0.05116686f, -0.04787802f, -0.02065117f, -0.01599520f, -0.01532409f, -0.05604728f, -0.02255850f, -0.06748828f, 
    0.03146974f, -0.01599921f, 0.02489983f, 0.04609426f, 0.00482617f, 0.04549116f, 0.00210656f, -0.06717169f, 
    -0.04535873f, 0.05212365f, -0.00258540f, -0.05496911f, -0.03780032f, -0.01683018f, 0.03629525f, 0.00298150f, 
    0.00484634f, -0.04454283f, -0.03220040f, 0.01625010f, 0.00950988f, -0.01046112f, -0.01395987f, -0.01158192f, 
    0.02999830f, -0.02941689f, -0.04697730f, -0.04921476f, 0.04191278f, -0.02851496f, 0.00596762f, 0.00518214f, 
    0.01845402f, 0.02001446f, -0.00285343f, -0.03221355f, 0.02398444f, -0.02216279f, -0.04666058f, -0.02157660f, 
    -0.03402854f, 0.04865797f, 0.04717355f, 0.03603646f, 0.01225377f, 0.04294808f, -0.02604699f, -0.03204637f, 
    -0.23414761f, -0.10136693f, -0.21246211f, -0.08060344f, -0.12277810f, -0.04992240f, -0.04951210f, 0.12695034f, 
    0.16674641f, -0.11623373f, -0.01944167f, 0.21855691f, 0.08901368f, -0.20171648f, 0.06097842f, -0.10064064f, 
    -0.08655475f, -0.00987466f, -0.74452811f, -0.43823794f, -0.30899537f, 0.01994180f, -0.06196220f, 0.01175738f, 
    0.10147764f, -0.02015861f, -0.00699795f, 0.51530939f, 0.39454234f, 0.19247557f, -0.18074657f, 0.11564095f, 
    0.08699767f, -0.06661360f, 0.12827623f, 0.01219216f, 0.04870279f, 0.34260452f, 0.31851584f, 0.02149676f, 
    -0.18596804f, -0.26769337f, 0.12441044f, -0.05042867f, -0.01894136f, 0.39721128f, -0.11358526f, 0.07637458f, 
    0.13482563f, 0.14441836f, 0.02667587f, 0.03973418f, 0.01999006f, -0.04640149f, -0.09071488f, -0.23708366f, 
    0.09035973f, 0.11980426f, 0.27796507f, -0.08227417f, 0.00733163f, 0.18367846f, -0.18283080f, 0.04018493f, 
    -0.12380363f, -0.23937310f, 0.17061770f, -0.03803004f, -0.11397135f, -0.08206091f, 0.21242477f, 0.20065902f, 
    0.19227548f, 0.35714570f, 0.48074412f, -0.04340693f, -0.21334824f, -0.12892954f, 0.06979910f, 0.04445429f, 
    0.14436358f, -0.12781167f, -0.20488925f, -0.09318193f, 0.02318727f, -0.08039638f, -0.17134243f, -0.02785539f, 
    0.10986023f, -0.23414271f, -0.47330165f, 0.07632818f, 0.06469095f, -0.05508219f, -0.12850909f, -0.11120815f, 
    -0.14910308f, 0.17853245f, -0.35588896f, -0.41899613f, -0.02065466f, 0.16582476f, -0.00745368f, -0.05783527f, 
    0.01831439f, 0.07095803f, -0.16297108f, -0.00809257f, 0.44320974f, 0.35401917f, 0.47677267f, 0.09512093f, 
    -0.08006512f, 0.12591749f, 0.02931574f, 0.08314248f, 0.12157570f, -0.37782127f, -0.21790387f, -0.11850516f, 
    0.15890265f, -0.10881076f, -0.02094480f, -0.00899019f, 0.05518380f, -0.06556183f, 0.14694923f, 0.01530726f, 
    -0.27333140f, 0.14215204f, -0.06483885f, 0.08719130f, -0.12094548f, -0.08635487f, -0.03272166f, -0.06663902f, 
    -0.26135683f, -0.13437332f, 0.12565652f, -0.06306582f, 0.18064047f, -0.08998729f, -0.19839495f, -0.02644181f, 
    0.47940123f, 0.06288525f, 0.24505357f, -0.13208696f, 0.10405739f, -0.17283146f, 0.05826727f, 0.05076740f, 
    -0.08759125f, -0.11881323f, -0.17557465f, -0.24506420f, 0.08321413f, -0.10093743f, -0.06348321f, -0.04338940f, 
    -0.12342487f, 0.00941793f, 0.08513531f, -0.12917647f, 0.03658243f, 0.20326908f, -0.02617718f, 0.33656839f, 
    0.02555289f, -0.11992598f, -0.01459429f, -0.41210371f, 0.03168981f, 0.46258727f, -0.15585801f, -0.04108039f, 
    -0.04117234f, -0.09448919f, 0.11041560f, -0.18539843f, -0.18819918f, -0.30169088f, -0.11244178f, -0.03253515f, 
    0.05953221f, -0.03221452f, 0.00505027f, -0.06887636f, -0.05947331f, 0.59870225f, 0.25152248f, 0.19460873f, 
    0.09630659f, 0.19958939f, 0.05614576f, -0.05049976f, 0.05779912f, -0.22966658f, 0.01965464f, -0.07498817f, 
    0.25470433f, 0.08807097f, -0.03333910f, 0.24528714f, -0.03896826f, 0.12978429f, 0.06905812f, 0.14246583f, 
    0.00038424f, 0.00252355f, 0.12154292f, 0.00310534f, 0.03590898f, -0.00583135f, -0.00906106f, 0.00227617f, 
    -0.20674971f, -0.36734951f, -0.09706338f, -0.03479292f, -0.02213003f, -0.07944340f, 0.02272984f, -0.04283571f, 
    0.19914846f, 0.25627083f, -0.11980280f, -0.48136982f, 0.15947954f, 0.20511740f, 0.17259085f, -0.04857209f, 
    0.16761425f, 0.04137099f, -0.41254359f, -0.35294497f, -0.33984920f, -0.02048079f, -0.12480318f, 0.00251128f, 
    -0.08767042f, 0.01599829f, 0.03598933f, -0.09108292f, -0.31438392f, -0.19591179f, -0.01012703f, -0.14864303f, 
    0.10683745f, -0.02390564f, 0.19580165f, 0.05556350f, -0.76251709f, 0.17291693f, -0.15572061f, -0.42886052f, 
    -0.20209599f, -0.10217239f, 0.00184430f, 0.08826028f, 0.12316030f, 0.05922649f, 0.27150685f, 0.04454334f, 
    -0.13546082f, 0.20698105f, 0.10820276f, -0.14061467f, 0.19338119f, 0.25903913f, 0.25875190f, -0.06403137f, 
    0.49931651f, -0.13225716f, 0.20402491f, -0.05614648f, 0.14582705f, -0.10409851f, 0.06809481f, 0.15431528f, 
    0.13789213f, -0.00089573f, 0.08110562f, 0.16782449f, -0.02348196f, -0.01354184f, -0.04059619f, -0.07902171f, 
    -0.09908573f, -0.27830335f, -0.05863406f, -0.07761962f, 0.05774706f, 0.09672074f, -0.02903990f, -0.07416829f, 
    0.14749885f, -0.03544630f, 0.34430608f, 0.36745557f, -0.03749801f, 0.10685769f, 0.20202851f, 0.07987924f, 
    -0.03713701f, 0.16390292f, -0.40680397f, -0.27162075f, -0.04337400f, 0.26791647f, 0.05381383f, 0.17861561f, 
    -0.15184106f, -0.26701730f, -0.65708894f, 0.09892213f, 0.12828358f, 0.11471830f, 0.07776467f, 0.10294829f, 
    0.14527418f, 0.03259240f, -0.15127213f, -0.00574075f, -0.05538049f, 0.37898028f, 0.63411212f, 0.08652692f, 
    0.10149279f, -0.15249814f, -0.04271686f, -0.05580953f, 0.04490582f, 0.16648941f, 0.18414663f, 0.21830718f, 
    0.25757718f, -0.20582612f, -0.01582043f, 0.07156715f, 0.17699914f, 0.09762421f, 0.15446293f, 0.12549852f, 
    0.04148343f, -0.10618854f, -0.19279286f, -0.17910844f, -0.04020443f, 0.08878213f, 0.10961877f, 0.02994006f, 
    -0.13916668f, 0.00474682f, 0.12400994f, 0.05964450f, -0.05381691f, -0.26293489f, -0.24939808f, -0.26006615f, 
    0.17493451f, 0.44591200f, 0.23343232f, 0.01987454f, 0.09626276f, 0.01367597f, 0.06280834f, -0.00965877f, 
    -0.05041146f, -0.07969131f, -0.26604494f, -0.00836594f, 0.07311732f, 0.16211376f, -0.02111106f, -0.48806325f, 
    -0.29393065f, -0.42771146f, -0.05855010f, -0.17493816f, -0.02851952f, 0.16579573f, 0.07535710f, -0.09549578f, 
    -0.35616201f, -0.29060155f, -0.22464831f, -0.22525124f, 0.42197579f, 0.56204510f, 0.19973700f, 0.12582943f, 
    0.27379599f, 0.28200969f, -0.08234890f, -0.28548369f, 0.13538273f, 0.46462461f, 0.31785342f, 0.09424957f, 
    0.05960613f, 0.10615787f, 0.13980293f, -0.10059681f, -0.15283437f, 0.18713917f, -0.26573205f, 0.03896017f, 
    0.01820430f, 0.38700667f, 0.02457839f, -0.29190862f, -0.18487743f, 0.17343590f, 0.25276482f, 0.10354085f, 
    -0.25814870f, 0.12011304f, -0.02305803f, -0.02496209f, -0.00871620f, 0.14036079f, 0.12998948f, -0.08051671f, 
    0.09758908f, 0.07755753f, 0.04156080f, -0.08050454f, -0.14509369f, -0.09175454f, 0.12309603f, 0.02835743f, 
    -0.04606171f, -0.24582632f, -0.21072814f, 0.17741697f, -0.00586057f, -0.06644174f, -0.13312264f, -0.11909157f, 
    0.02470769f, -0.02428587f, -0.11498343f, -0.07673322f, 0.10365291f, 0.08450625f, -0.02355603f, -0.18144611f, 
    -0.05090652f, -0.01882445f, -0.13006915f, 0.15546380f, 0.07328151f, 0.01398300f, -0.05152668f, -0.06009017f, 
    -0.04889156f, 0.15441002f, 0.10440371f, 0.23493862f, -0.15084267f, 0.22642429f, -0.09877867f, 0.20826589f, 
    -0.12436821f, -0.05957596f, -0.16082695f, 0.31064230f, 0.01309069f, -0.17744403f, -0.13030785f, 0.00830864f, 
    0.09170049f, 0.16179687f, -0.20545797f, -0.54226297f, -0.41649771f, -0.00918936f, -0.09694339f, -0.13252898f, 
    0.13544495f, 0.09227792f, -0.02910390f, -0.20844299f, -0.48551869f, -0.22385105f, 0.07119099f, -0.07638778f, 
    -0.02256519f, 0.03941226f, -0.08967485f, 0.10540850f, 0.01967536f, -0.22304635f, -0.02829332f, 0.05081297f, 
    0.27219319f, 0.14632013f, -0.17275101f, -0.33060235f, -0.18220395f, 0.08215560f, 0.12422160f, 0.09493749f, 
    -0.08350426f, -0.11651102f, -0.06274499f, -0.00528265f, 0.17295766f, -0.23037980f, -0.06624119f, -0.20229647f, 
    0.04553048f, 0.37416443f, -0.01425092f, -0.52403086f, 0.15381780f, -0.08033432f, -0.07511890f, -0.01041735f, 
    -0.02305005f, 0.01887160f, -0.03520527f, -0.24261908f, -0.11449907f, -0.01922439f, 0.15505336f, 0.11887109f, 
    -0.22157042f, 0.00426880f, -0.08844052f, -0.07031336f, -0.27680796f, 0.02520384f, -0.16012317f, 0.15354000f, 
    0.17634048f, -0.02913798f, -0.24492221f, 0.19719535f, -0.34864563f, -0.62756348f, -0.37233588f, 0.12964252f, 
    0.16143763f, 0.13260004f, -0.27567583f, 0.05653699f, -0.40373915f, -0.04040928f, 0.17031707f, 0.22432111f, 
    -0.09250757f, -0.35576639f, 0.03995899f, -0.06184914f, 0.09853416f, -0.02095889f, 0.28175768f, 0.07031496f, 
    0.12841943f, 0.09879778f, -0.08431698f, -0.02662849f, -0.25951108f, -0.18958919f, -0.06283635f, 0.17539130f, 
    0.20799488f, 0.07054312f, 0.10166584f, 0.09614356f, 0.15658575f, 0.09383134f, -0.12307652f, 0.02472624f, 
    -0.20946464f, 0.16354863f, 0.38052785f, -0.00277993f, 0.09364361f, -0.09732655f, 0.06847569f, 0.16377454f, 
    -0.01340620f, 0.30561042f, 0.33536789f, 0.09450987f, -0.04439683f, 0.23379004f, -0.04146140f, 0.05373872f, 
    -0.00097306f, 0.10758009f, -0.13542287f, 0.55633682f, -0.04004792f, -0.08830172f, -0.05985373f, 0.21521369f, 
    -0.32489809f, 0.12123805f, -0.44066727f, 0.14162202f, 0.22173247f, -0.40885499f, 0.06719229f, -0.10256126f, 
    -0.05026364f, -0.18666163f, -0.28286880f, 0.16989331f, 0.32769132f, 0.22226711f, 0.31342548f, -0.05996208f, 
    0.03428748f, -0.20542030f, 0.17170300f, 0.04061922f, 0.11424767f, 0.43108425f, -0.44088066f, 0.11449518f, 
    0.02387007f, -0.01167596f, -0.12590095f, -0.03343562f, 0.06795882f, 0.05520802f, 0.07559052f, -0.20380929f, 
    0.07019574f, -0.06921230f, -0.05515124f, -0.09745239f, -0.00167970f, 0.05901907f, 0.05890895f, -0.14402047f, 
    0.04815336f, -0.09012093f, -0.04328561f, 0.06312455f, -0.03033880f, -0.00062389f, 0.04397293f, -0.12091442f, 
    0.18804963f, 0.15285370f, -0.02508697f, -0.13109493f, 0.11269499f, 0.01173213f, 0.07054948f, -0.12075365f, 
    0.24812171f, -0.41163227f, -0.10605899f, 0.06174619f, -0.25807601f, 0.13043776f, 0.04065284f, -0.15473408f, 
    -0.00981976f, -0.22213981f, -0.18822564f, -0.16868962f, 0.09181362f, 0.12141559f, -0.01854992f, -0.11956277f, 
    0.08286080f, 0.09168028f, -0.03090217f, 0.52281976f, 0.49239612f, 0.31953081f, -0.01339805f, 0.10364749f, 
    0.34657681f, -0.32252657f, 0.01433740f, -0.07818165f, 0.42451173f, 0.34657004f, -0.17821495f, 0.18965395f, 
    0.08388080f, -0.05641527f, -0.00560197f, -0.16898252f, 0.05102021f, 0.16499965f, -0.01881970f, 0.06230407f, 
    -0.03869131f, 0.24066332f, -0.10143921f, 0.16061006f, 0.16703935f, -0.00331593f, 0.20245109f, -0.17067632f, 
    -0.15636227f, -0.14451179f, 0.03877506f, -0.06421046f, -0.01835614f, -0.00228197f, 0.08467078f, 0.00957761f, 
    0.01060233f, -0.06385033f, -0.15364589f, -0.06025010f, -0.22677416f, 0.00662763f, 0.05632589f, 0.02366312f, 
    0.37466717f, -0.04613342f, 0.12139630f, -0.01540685f, -0.01873549f, -0.15190108f, -0.09818040f, -0.04054439f, 
    0.03370713f, -0.18006703f, -0.07204613f, -0.04701963f, -0.08203433f, -0.08355604f, -0.20021558f, 0.01755869f, 
    0.04563495f, 0.05459922f, -0.01705608f, 0.14945038f, -0.04052180f, -0.06326684f, 0.08208748f, -0.22184461f, 
    0.05840122f, 0.16875584f, -0.02168093f, 0.07527742f, -0.27145678f, 0.16108502f, -0.07659353f, 0.01854101f, 
    -0.23716822f, 0.13229750f, 0.26910284f, 0.10494538f, -0.36785468f, 0.00416782f, -0.03629556f, -0.09104647f, 
    0.17957661f, 0.03549190f, -0.30462480f, -0.25476721f, -0.19558905f, 0.18676382f, 0.00792552f, -0.15743956f, 
    0.08524590f, -0.10282643f, -0.02902453f, -0.05496666f, -0.16468661f, 0.10666465f, 0.24927792f, 0.09237543f, 
    0.16111381f, 0.17159660f, 0.06284443f, -0.11652073f, -0.03749364f, 0.05020737f, -0.06324068f, -0.05889913f, 
    0.11180802f, -0.04676544f, -0.08083616f, -0.07491068f, 0.02094617f, 0.07353117f, 0.00183985f, 0.13246782f, 
    -0.28884917f, -0.06195535f, 0.18918090f, -0.06393956f, 0.04563335f, -0.16145466f, -0.20542522f, 0.11655816f, 
    0.04454920f, -0.06192507f, -0.35830986f, -0.13119924f, -0.04024153f, 0.05020157f, -0.05316139f, -0.01533142f, 
    0.11389473f, -0.00428310f, -0.37162992f, -0.01481645f, 0.03918448f, -0.03382687f, 0.08169644f, -0.05471484f, 
    0.18131077f, 0.03437487f, -0.09060447f, -0.10504378f, 0.04868479f, 0.65180814f, -0.04175840f, 0.07042242f, 
    -0.12539758f, 0.13842468f, 0.18770544f, 0.16730557f, -0.28928840f, 0.34583133f, 0.10448305f, 0.07886725f, 
    -0.06519121f, 0.00313208f, 0.04403448f, 0.03899981f, -0.26726884f, -0.10988039f, 0.15633032f, -0.05638624f, 
    0.13160849f, -0.02169800f, -0.04672628f, 0.06488328f, 0.03009615f, -0.02576828f, -0.36332789f, 0.03516355f, 
    0.33312032f, -0.20005302f, 0.33605158f, 0.06672994f, -0.35411143f, 0.09550094f, 0.23115321f, -0.01169822f, 
    0.16507034f, -0.20843218f, -0.05075355f, -0.15291750f, 0.06488363f, -0.07281233f, -0.09710949f, -0.07640973f, 
    -0.06117961f, -0.04831648f, 0.09591292f, 0.13573812f, -0.01828697f, -0.01429001f, 0.19885321f, 0.12824745f, 
    0.04314147f, 0.28741014f, 0.41303256f, 0.19412287f, 0.10566291f, 0.10204567f, 0.04770138f, 0.26490510f, 
    0.17669709f, 0.30413634f, -0.00739768f, -0.07237726f, 0.13500343f, 0.05633419f, -0.05711605f, 0.02737896f, 
    0.01034082f, -0.07471289f, -0.22196239f, -0.13985506f, 0.01015471f, 0.00591694f, 0.10802703f, -0.08670605f, 
    -0.12472127f, 0.18596037f, -0.02266082f, 0.12278321f, 0.08894188f, -0.05538967f, -0.07565520f, -0.02955725f, 
    -0.08373082f, -0.25833258f, 0.06767434f, 0.10980247f, 0.11491550f, -0.12425864f, 0.02980784f, 0.08080845f, 
    -0.00156480f, 0.02495401f, 0.11616512f, -0.09583983f, -0.01144742f, 0.02813371f, 0.08866905f, 0.04638449f, 
    0.13091286f, 0.12025870f, -0.25572094f, -0.16451542f, -0.05471232f, 0.13187307f, 0.00934911f, -0.05465107f, 
    -0.10966940f, -0.00549159f, -0.10393056f, -0.15472206f, -0.02646409f, 0.05638282f, -0.01763696f, -0.25751510f, 
    -0.07302482f, -0.02217988f, 0.25831956f, 0.03153604f, 0.04425854f, -0.07126127f, 0.18853371f, -0.02683066f, 
    0.14480615f, 0.02863197f, -0.01064697f, 0.11946411f, -0.04951727f, 0.04521713f, 0.08786125f, 0.03749701f, 
    0.02894004f, -0.05047004f, 0.01547143f, -0.05575794f, -0.01330584f, 0.16178641f, -0.06417534f, 0.08076820f, 
    0.22256204f, 0.17361881f, -0.13401009f, 0.07528535f, 0.17615888f, 0.29853579f, 0.09974040f, 0.14205888f, 
    0.19379902f, 0.05923863f, -0.01040599f, 0.18709478f, -0.15185414f, -0.28588700f, -0.05566350f, -0.03155028f, 
    -0.00430089f, 0.16861814f, 0.16610488f, 0.05897617f, 0.21144745f, 0.04504794f, 0.31534126f, 0.04505326f, 
    0.11889552f, 0.12191056f, 0.02331519f, 0.16006216f, 0.17477883f, 0.13637000f, 0.19154720f, 0.27070469f, 
    0.15992855f, -0.07771903f, 0.08003760f, 0.11567192f, 0.09577540f, -0.08434733f, 0.19018997f, -0.03369281f, 
    -0.01617518f, 0.04198625f, 0.10569519f, 0.13555808f, 0.18676147f, 0.12134916f, 0.26485795f, 0.11276284f, 
    -0.10158465f, 0.13773417f, 0.09516154f, 0.04429262f, -0.01873068f, 0.15480638f, -0.18732998f, -0.05192646f, 
    0.02704242f, -0.08939292f, 0.00051988f, -0.00526687f, 0.24937430f, 0.27220809f, 0.18063962f, 0.09709471f, 
    0.19966854f, 0.13625866f, -0.07692832f, -0.08816509f, -0.09263605f, 0.04305753f, -0.01546104f, -0.10853593f, 
    0.08719575f, 0.17765942f, -0.04406767f, 0.00659725f, 0.10729620f, -0.00184984f, 0.28381917f, -0.10724672f, 
    0.11350634f, 0.01728501f, 0.14753884f, -0.11596042f, -0.01783510f, 0.01192130f, 0.13401040f, -0.02732038f, 
    -0.00663800f, 0.06610981f, -0.05749894f, -0.30726439f, -0.20976490f, -0.05648085f, -0.13207263f, -0.01029155f, 
    0.03739742f, -0.08842236f, 0.01756245f, -0.17065015f, 0.00572677f, -0.16391487f, 0.14167614f, 0.18523569f, 
    -0.25058889f, 0.04519987f, -0.05124854f, 0.05813240f, 0.07655715f, 0.15662862f, -0.07294897f, -0.05748761f, 
    -0.05446633f, 0.04942484f, -0.02067762f, -0.00983776f, -0.16924758f, 0.18685716f, 0.09276203f, 0.20888567f, 
    0.10306866f, 0.12121395f, 0.02014502f, 0.31205148f, 0.15260604f, 0.12954666f, 0.25410813f, 0.01715049f, 
    0.07893509f, 0.09239686f, 0.26144806f, 0.10040054f, 0.16358794f, 0.03164979f, 0.02626606f, 0.00278920f, 
    0.08679496f, 0.22376451f, 0.04710916f, 0.02499012f, 0.13873266f, 0.07213458f, -0.01923500f, -0.02621002f, 
    -0.09185622f, 0.23229995f, -0.01635859f, -0.00191104f, -0.02741711f, -0.04421927f, 0.26264495f, 0.00277655f, 
    0.10323958f, 0.18203411f, 0.14441833f, 0.11634544f, 0.04152333f, -0.12524500f, 0.13939442f, 0.11747590f, 
    -0.03920070f, -0.14535116f, -0.23060896f, -0.05804570f, 0.20980115f, -0.22403070f, -0.16322774f, -0.23670392f, 
    0.07974917f, -0.20615225f, -0.31383011f, 0.19016080f, 0.05268602f, 0.10646661f, 0.27422088f, -0.28892836f, 
    0.04647686f, 0.13048443f, 0.10874906f, 0.05994302f, -0.04964542f, 0.15235774f, -0.08459717f, -0.17422993f, 
    -0.22060236f, 0.35243189f, -0.05420034f, 0.02634909f, 0.08235631f, 0.15032300f, 0.05028095f, -0.01736214f, 
    0.05828184f, -0.14928325f, -0.02519419f, -0.02687111f, -0.08118407f, -0.07258531f, 0.07262711f, 0.11400066f, 
    0.12312093f, -0.37857488f, 0.34407601f, -0.22547959f, 0.02135455f, 0.01038233f, 0.25976923f, -0.17829837f, 
    0.01829032f, 0.22603504f, -0.61024195f, -0.36864594f, 0.05614756f, 0.10418638f, -0.06454474f, -0.23245074f, 
    -0.27199340f, -0.16695786f, 0.00161786f, -0.26216316f, 0.12489969f, -0.20000900f, 0.09325911f, 0.16997343f, 
    0.02840756f, 0.15097129f, -0.03230875f, -0.20507745f, -0.03038874f, 0.13880783f, -0.09524954f, 0.17615901f, 
    0.05233284f, -0.08202530f, -0.04049866f, -0.09868253f, -0.13329279f, -0.24679738f, 0.00963675f, 0.64073694f, 
    0.17259733f, -0.22877489f, 0.05567505f, 0.03242928f, 0.05253758f, 0.04101673f, -0.13580272f, 0.15388842f, 
    -0.12105287f, -0.21457188f, -0.11694991f, -0.04541771f, -0.07518755f, -0.04165144f, -0.09400441f, 0.08363724f, 
    0.17355953f, -0.02413205f, -0.03371125f, 0.00445012f, -0.25129098f, 0.13310432f, 0.09532878f, 0.10599064f, 
    0.16793616f, 0.16489404f, -0.00138122f, -0.01415724f, -0.02360771f, -0.09791670f, -0.14071645f, -0.12875098f, 
    -0.12276719f, -0.08696099f, 0.18251902f, 0.14098252f, 0.15486792f, 0.03312774f, -0.27348900f, -0.00586604f, 
    0.00343219f, 0.04299445f, 0.15194826f, 0.06622474f, 0.03550810f, -0.07108376f, 0.06035769f, -0.06294954f, 
    -0.09541142f, 0.00603752f, -0.17090423f, -0.42642251f, 0.03270813f, -0.14595550f, 0.01522064f, 0.06197293f, 
    0.15375668f, 0.21263449f, 0.02280020f, -0.21923073f, 0.07853158f, 0.33647409f, 0.50995141f, -0.19214664f, 
    -0.05089995f, -0.04528413f, 0.01639877f, 0.07813274f, -0.15856330f, -0.06578164f, -0.27738059f, 0.11562322f, 
    -0.00316152f, 0.19816887f, -0.04170616f, -0.03944575f, -0.03859436f, 0.11386430f, 0.13557619f, 0.10320787f, 
    0.01414568f, 0.07137211f, 0.08198158f, 0.16779961f, 0.06910022f, 0.12788080f, 0.22274803f, 0.00375883f, 
    0.08982200f, 0.03927553f, 0.08800898f, 0.02985265f, -0.03764392f, 0.08974234f, 0.18207113f, 0.13104337f, 
    0.12132532f, -0.19907521f, -0.12459376f, -0.08899356f, -0.07130907f, -0.01278439f, 0.06334926f, 0.03891376f, 
    -0.02517669f, 0.11660171f, 0.21530457f, 0.04323009f, -0.18396971f, -0.32127610f, -0.37157348f, 0.05280759f, 
    0.05328981f, -0.07919886f, -0.04701488f, -0.06398719f, -0.05986722f, -0.06921566f, 0.04583099f, 0.01955959f, 
    0.02126348f, -0.00934871f, 0.13480270f, -0.14925438f, 0.36973602f, 0.06177877f, -0.11749619f, -0.02012208f, 
    -0.01862611f, -0.09761182f, 0.15307269f, 0.09286430f, 0.06248955f, 0.11819042f, -0.02104089f, -0.04761691f, 
    0.00610913f, -0.13999201f, 0.04529210f, 0.07459822f, 0.01032187f, -0.06138353f, -0.20349588f, -0.17712775f, 
    -0.15578213f, -0.06222688f, 0.04828082f, 0.18863539f, 0.04891931f, -0.21695332f, 0.05085526f, 0.04896393f, 
    -0.08315643f, -0.02673797f, 0.14165802f, 0.12394323f, -0.01875643f, -0.15673678f, 0.00471412f, -0.02824159f, 
    0.20325431f, -0.16547626f, 0.04421309f, 0.14732264f, 0.04212176f, 0.01702190f, 0.04751941f, 0.14965090f, 
    0.27961600f, 0.10391864f, 0.02021504f, -0.13147745f, -0.02455739f, -0.24389961f, 0.10307185f, -0.05511492f, 
    -0.02770139f, 0.08139431f, 0.02455908f, -0.42369530f, -0.09736487f, -0.02713099f, 0.03647153f, 0.15454303f, 
    0.06650434f, 0.09441134f, -0.01607733f, -0.14421190f, 0.01113001f, -0.05883043f, 0.12983629f, -0.03790059f, 
    0.08581978f, 0.14009717f, 0.19495341f, 0.02277038f, -0.07186761f, -0.06779794f, -0.07769721f, -0.02277628f, 
    0.05625819f, 0.04534629f, -0.17722012f, 0.07459838f, -0.38014394f, -0.72809684f, 0.32321948f, 0.10180192f, 
    -0.02104534f, -0.24105948f, -0.00576963f, 0.10308705f, 0.11189733f, -0.24984756f, -0.12401169f, -0.08626640f, 
    0.19961068f, -0.16382025f, 0.00098489f, -0.03742107f, 0.03287143f, 0.12849870f, 0.16632356f, 0.65629035f, 
    -0.41058221f, -0.11352881f, -0.01986813f, -0.01144452f, -0.09456868f, 0.19718237f, -0.16756192f, 0.07380991f, 
    0.04189640f, -0.31896806f, 0.01201867f, 0.25928915f, -0.09282044f, 0.07289942f, 0.01821639f, -0.09896035f, 
    0.04394313f, -0.02601648f, 0.04240948f, 0.06345028f, 0.11277941f, -0.11940313f, 0.00790616f, -0.14868724f, 
    -0.16316067f, -0.24134812f, -0.23594850f, -0.50348240f, 0.21989083f, -0.02514821f, 0.05048141f, 0.09484347f, 
    0.04107520f, -0.00411925f, -0.54030269f, -0.17708604f, 0.24085951f, -0.17810395f, 0.20452198f, -0.02786801f, 
    -0.16882586f, 0.05500864f, 0.23306856f, -0.27745005f, -0.00282535f, 0.06206266f, 0.23858060f, -0.00744121f, 
    0.05263894f, 0.18443197f, 0.13711387f, -0.02823554f, -0.07161229f, -0.10047747f, -0.30976292f, -0.39493579f, 
    0.33854020f, 0.01523354f, 0.11538932f, 0.06307054f, 0.04826970f, -0.62125361f, 0.47382167f, 0.46532154f, 
    -0.26504293f, -0.09527985f, -0.06295183f, 0.08999764f, -0.05975259f, -0.18759249f, -0.29278043f, 0.13908786f, 
    0.03734332f, -0.29593092f, 0.01026224f, 0.07901035f, -0.12623189f, -0.21119666f, -0.28795981f, 0.15223078f, 
    0.11675575f, -0.04369345f, -0.08161351f, 0.00537242f, -0.03758940f, 0.06420174f, 0.12744734f, 0.06778684f, 
    0.05784964f, 0.08008161f, -0.33066657f, -0.48093545f, 0.02251292f, -0.07209336f, 0.07210629f, -0.18581496f, 
    0.01420973f, -0.12131555f, 0.21000761f, 0.10090061f, 0.03466256f, 0.05714525f, 0.06391571f, 0.10540329f, 
    0.21489406f, 0.02404660f, 0.38791928f, 0.18076962f, -0.07118804f, -0.07559128f, 0.03076867f, 0.09098471f, 
    0.20072158f, 0.13613640f, 0.00245876f, -0.35615593f, -0.40367901f, -0.46154964f, -0.04817654f, -0.07246796f, 
    -0.13278863f, -0.00149757f, 0.01974240f, 0.06500147f, -0.33263406f, -0.15332425f, -0.40908012f, -0.05541467f, 
    -0.00669447f, -0.24659696f, -0.00480120f, 0.03332093f, -0.06862924f, 0.27923712f, -0.24411044f, 0.26797044f, 
    -0.09197570f, 0.07815358f, -0.01647010f, -0.08648568f, -0.03037423f, -0.07646846f, -0.28792122f, 0.40102845f, 
    0.09842265f, 0.12736548f, 0.00800268f, 0.19230777f, 0.05114116f, 0.06940334f, 0.13625528f, 0.11142213f, 
    0.09839924f, -0.01821501f, -0.00284999f, 0.01539779f, -0.12226322f, -0.00471751f, 0.09780572f, -0.13796858f, 
    -0.34401920f, 0.14628616f, 0.27877647f, 0.01987124f, -0.02009594f, 0.12363068f, 0.14909905f, 0.17123578f, 
    -0.10106818f, 0.06982619f, 0.03451404f, 0.03110457f, 0.00668754f, -0.07686260f, -0.09665394f, 0.13183512f, 
    0.06010785f, 0.01301889f, 0.13102815f, -0.19596928f, -0.13199240f, -0.10519072f, 0.00905999f, -0.05880002f, 
    -0.16730750f, -0.26887327f, -0.11052448f, 0.24029469f, 0.21095283f, 0.09305628f, -0.15950325f, -0.03213018f, 
    0.03128125f, 0.08762735f, 0.25714296f, 0.12853731f, 0.15776204f, 0.15706447f, 0.07688656f, 0.02336162f, 
    -0.01494574f, -0.00520784f, 0.18339975f, 0.13582808f, 0.14574502f, -0.20625517f, 0.19399138f, 0.25897610f, 
    0.21695212f, -0.06364951f, 0.16135396f, 0.25164741f, 0.11651714f, 0.08640418f, 0.12868607f, -0.29680866f, 
    -0.48686779f, -0.00029535f, 0.33862314f, 0.00322149f, 0.14995444f, 0.08593754f, 0.21973194f, -0.10139649f, 
    0.13402869f, -0.18987361f, -0.25545460f, 0.09013018f, 0.09336255f, -0.26761052f, -0.10266200f, -0.00288424f, 
    0.41100115f, 0.19126061f, -0.16187841f, -0.00429111f, 0.09568763f, 0.07273269f, -0.09401490f, 0.07728712f, 
    0.04596588f, -0.18566260f, 0.34001499f, 0.20538259f, 0.07392952f, 0.07561760f, 0.12108217f, 0.06133122f, 
    -0.06709527f, -0.01629300f, 0.15257558f, -0.32647851f, 0.18518689f, -0.04452355f, 0.14664502f, -0.15680943f, 
    -0.08378675f, 0.07920030f, 0.09374302f, 0.02097099f, 0.00109908f, -0.23572320f, 0.01188310f, 0.17153241f, 
    0.15175396f, -0.10843139f, -0.17558578f, -0.03579571f, 0.13832939f, -0.57533073f, 0.50241977f, -0.01697754f, 
    0.20389342f, -0.14774235f, -0.03889102f, 0.03768131f, 0.05082986f, -0.01102396f, -0.34231445f, -0.03376275f, 
    -0.05620678f, -0.06788061f, -0.06287014f, -0.34806740f, -0.41503677f, -0.03874197f, 0.61872631f, -0.08862292f, 
    -0.62477201f, -0.49868709f, 0.12207421f, -0.04005348f, -0.03908895f, 0.01017330f, -0.50513148f, 0.02058944f, 
    0.37179339f, -0.16193207f, 0.04960643f, -0.17596820f, 0.24297646f, 0.02990185f, 0.09422660f, 0.00253409f, 
    0.02334854f, -0.00257250f, -0.04838156f, 0.00882182f, -0.05917069f, 0.01437290f, -0.06267168f, -0.02182980f, 
    -0.05189442f, -0.04249192f, -0.02494478f, 0.01725632f, -0.03102768f, -0.03543600f, 0.03052648f, 0.00484694f, 
    -0.00963086f, 0.02914586f, 0.03744832f, -0.03372142f, -0.03338768f, 0.03226391f, -0.03227283f, -0.02804449f, 
    0.04694660f, 0.03668577f, 0.01013172f, -0.02222749f, 0.00473645f, -0.05639191f, -0.01161465f, -0.03586006f, 
    -0.04918393f, -0.03544452f, -0.02143682f, 0.02004348f, 0.01706071f, 0.03646037f, 0.02186869f, 0.00239172f, 
    -0.06146006f, 0.02085973f, -0.01185171f, 0.04652932f, 0.02901195f, 0.03788891f, -0.00944388f, -0.03031698f, 
    0.02565258f, -0.05851363f, -0.03682280f, 0.02652641f, 0.03063964f, -0.03526153f, -0.01711247f, -0.04403413f, 
    -0.01718249f, 0.01023679f, -0.05255897f, 0.02294884f, -0.05687740f, -0.04069811f, -0.02031320f, -0.06531483f, 
    0.00086852f, -0.04200649f, 0.01931830f, -0.06304567f, -0.03115884f, -0.04326915f, -0.05766299f, -0.04375300f, 
    -0.04499301f, -0.04272473f, -0.05150940f, -0.01003208f, 0.04297510f, 0.03637715f, 0.00897032f, -0.04292227f, 
    -0.00340064f, 0.01799720f, 0.04679230f, 0.04521461f, 0.04286686f, -0.01077289f, 0.01673399f, -0.00893075f, 
    -0.00766703f, 0.04331450f, -0.06045076f, -0.01954555f, -0.04728308f, -0.01766365f, 0.00456227f, 0.04789396f, 
    -0.04869188f, -0.03122323f, -0.02321888f, -0.04076092f, -0.06522704f, -0.02491955f, -0.06217908f, 0.01729867f, 
    0.05123691f, 0.01807617f, -0.01151823f, -0.05369593f, 0.02970082f, 0.03767481f, -0.01487810f, -0.03822996f, 
    -0.00747545f, -0.00989007f, -0.02535293f, 0.02070408f, -0.03965532f, -0.01526459f, -0.05527083f, 0.00007357f, 
    -0.00168800f, 0.02980864f, -0.03863549f, -0.06024398f, 0.03629457f, 0.01425610f, -0.01535717f, -0.01761215f, 
    0.00883909f, 0.04502733f, 0.01211230f, -0.06262911f, 0.03354347f, 0.00870375f, -0.04889085f, 0.00241027f, 
    0.02015531f, 0.02451157f, 0.04208215f, 0.03997134f, -0.05708412f, 0.01850341f, -0.06531648f, 0.02669736f, 
    0.01583301f, 0.00120659f, -0.06262109f, -0.05938935f, 0.04530155f, 0.03648696f, -0.05738637f, -0.02733661f, 
    -0.04105560f, -0.00808868f, -0.02841456f, -0.03401563f, 0.00917418f, -0.02397900f, 0.01760158f, -0.02933436f, 
    -0.00174119f, -0.02259218f, -0.01821394f, -0.00264665f, -0.05787192f, -0.00837036f, -0.02045199f, -0.04318223f, 
    -0.05175523f, 0.02720022f, -0.02139563f, -0.02786730f, -0.00720875f, -0.04033031f, -0.05766130f, 0.04325370f, 
    0.02478739f, -0.02529408f, 0.01338528f, -0.00938683f, 0.03373569f, 0.00855781f, 0.00680596f, 0.02279735f, 
    -0.02283164f, 0.00793382f, 0.03038637f, -0.02534067f, 0.00049600f, -0.01790967f, 0.04185859f, -0.06476077f, 
    0.03985552f, -0.00653017f, -0.04342498f, -0.01617904f, 0.00085683f, -0.01052818f, -0.06233989f, -0.00390941f, 
    0.01309032f, 0.02445810f, -0.00381650f, 0.00784704f, 0.03629349f, -0.02440961f, -0.06079565f, -0.03517808f, 
    -0.00552846f, -0.01393377f, -0.03992608f, -0.03227479f, -0.04454003f, 0.01967058f, -0.05706491f, -0.03762473f, 
    0.04202438f, 0.01728089f, -0.05516167f, -0.02902472f, -0.01850037f, -0.00566273f, -0.02735307f, -0.05082337f, 
    0.00314387f, 0.05014240f, 0.04243620f, 0.01973052f, -0.03392177f, -0.05104934f, -0.00006330f, 0.01917480f, 
    -0.04475568f, 0.03085128f, -0.04160161f, -0.00980638f, -0.01135824f, -0.03968362f, -0.02159386f, -0.01914867f, 
    0.02883767f, 0.02821346f, 0.04113797f, 0.00186075f, -0.02674955f, 0.02391984f, 0.03018540f, 0.03146988f, 
    -0.05500391f, -0.00842673f, -0.00433652f, 0.02800740f, -0.04833913f, -0.05436920f, 0.04973006f, -0.00232114f, 
    0.02523466f, 0.03130658f, -0.05013636f, -0.05337461f, -0.01222591f, 0.04354105f, 0.02571830f, -0.04829432f, 
    0.03987126f, -0.03794958f, 0.05358982f, -0.06170035f, 0.03544618f, -0.05065989f, 0.00225372f, -0.01660245f, 
    0.02091813f, -0.04563527f, 0.03073873f, -0.03705767f, -0.05149715f, -0.03891668f, -0.05270067f, -0.03276208f, 
    -0.04413864f, -0.05440112f, 0.02991312f, -0.06260494f, 0.01225615f, -0.04439064f, -0.03982030f, -0.01256283f, 
    0.16108957f, 0.08538213f, 0.24105714f, 0.02127013f, -0.14521790f, -0.07963811f, -0.02360221f, 0.23955871f, 
    0.08666809f, -0.36454815f, 0.27370581f, 0.08928937f, -0.05541793f, 0.17205873f, 0.15566614f, 0.04579395f, 
    0.09308362f, 0.00342738f, -0.21379298f, 0.07586631f, 0.18769304f, 0.04874679f, 0.00183457f, 0.21032141f, 
    0.07849666f, -0.08761429f, 0.08854662f, -0.17525224f, 0.27488348f, -0.16612150f, -0.02250191f, -0.04301399f, 
    0.13436885f, 0.09873153f, -0.17343421f, 0.17201422f, 0.16310982f, -0.22608218f, 0.63571531f, 0.18951041f, 
    -0.12365722f, -0.19266689f, 0.03107907f, 0.02127469f, -0.07157950f, -0.03465561f, -0.12003733f, 0.02012279f, 
    -0.06681766f, 0.18559510f, -0.01934582f, 0.03058573f, 0.09275535f, 0.00807340f, 0.03043868f, -0.22721604f, 
    0.23565103f, -0.14215778f, 0.10482692f, 0.16960610f, 0.10391695f, -0.03071342f, 0.01572469f, -0.02970241f, 
    -0.11305273f, -0.00055116f, -0.20355490f, 0.08874074f, -0.00344808f, 0.00000211f, -0.21328093f, 0.02933571f, 
    -0.09801134f, -0.10681856f, 0.00374243f, -0.03170758f, -0.14809532f, -0.07929263f, 0.10005783f, 0.15358886f, 
    -0.10798255f, 0.00825452f, 0.14777805f, -0.04154884f, 0.03404516f, -0.03153935f, -0.00459888f, -0.25863928f, 
    -0.19895160f, 0.14524001f, -0.05033857f, -0.12822667f, 0.14769284f, -0.00239839f, 0.26176417f, -0.06738333f, 
    0.20788619f, -0.15079074f, 0.15904424f, -0.48425433f, -0.00613997f, 0.33712095f, -0.14204586f, 0.02452546f, 
    0.33179751f, -0.07072401f, 0.06222437f, 0.03228388f, -0.27319795f, 0.07592037f, -0.23019633f, -0.06227498f, 
    -0.04130967f, 0.00437076f, 0.05340031f, -0.05553558f, 0.08189133f, 0.17884028f, -0.06785002f, 0.30238771f, 
    0.10283894f, 0.03410281f, -0.14912508f, 0.06085169f, 0.07114662f, -0.02735034f, -0.18627939f, -0.05549477f, 
    -0.30898574f, 0.10146365f, 0.19692276f, 0.16009641f, 0.14598359f, 0.09446684f, 0.03715062f, 0.02713134f, 
    0.00689718f, 0.00332633f, -0.12523153f, 0.03084853f, -0.07983298f, 0.06625832f, 0.13678372f, 0.00814755f, 
    -0.07486624f, -0.18551399f, -0.14340600f, -0.08608865f, -0.05230263f, 0.05120479f, -0.08389657f, 0.04977565f, 
    -0.09929260f, -0.04446647f, -0.03543077f, -0.14908381f, -0.32803759f, -0.03840553f, -0.20244642f, 0.07073589f, 
    0.21500011f, 0.11583550f, 0.01041621f, -0.10575614f, 0.04391897f, -0.08302118f, 0.04448609f, -0.12063926f, 
    0.25975761f, 0.11274707f, -0.03965130f, 0.02405201f, 0.17861804f, 0.21283823f, 0.07367241f, -0.10976019f, 
    -0.05183994f, 0.08991203f, 0.00913229f, -0.00134444f, 0.03374422f, 0.03668468f, -0.01353840f, 0.05463671f, 
    -0.06653992f, 0.12199149f, -0.00775183f, -0.09089230f, -0.17673139f, -0.29350936f, -0.11821353f, -0.34508884f, 
    -0.07368459f, 0.07516566f, -0.01127373f, -0.11627444f, -0.01255824f, 0.11579110f, -0.55522549f, 0.28530979f, 
    -0.25213051f, 0.00715404f, 0.31561017f, -0.18590538f, 0.12077011f, 0.06873888f, -0.04464132f, 0.11827543f, 
    -0.08988968f, 0.09703938f, -0.13305590f, -0.09361798f, 0.09192228f, 0.06175924f, 0.04480369f, -0.09183399f, 
    -0.15395761f, -0.05119780f, -0.03740462f, -0.27227268f, 0.12904404f, 0.09794443f, 0.01080849f, 0.15786083f, 
    -0.23210132f, -0.52013332f, -0.33623022f, -0.42471772f, 0.07077140f, 0.17011023f, 0.14970969f, 0.02312995f, 
    0.00288075f, -0.09227764f, 0.16159073f, -0.17843793f, 0.12883481f, 0.06927133f, 0.05491362f, -0.10384810f, 
    0.08313982f, 0.15216321f, 0.10695957f, 0.04087988f, 0.25217098f, 0.29733533f, -0.00885755f, -0.07124544f, 
    -0.06620143f, 0.06049556f, 0.28383285f, -0.15184106f, 0.15880346f, -0.36579600f, 0.46768498f, 0.08187366f, 
    0.00842216f, -0.09466012f, 0.00720451f, 0.12342616f, 0.12833297f, -0.16292055f, -0.05806370f, 0.14789596f, 
    -0.32310206f, -0.11199217f, -0.13074370f, 0.19107017f, -0.01977914f, -0.05788395f, -0.27801135f, -0.26763192f, 
    0.17971939f, -0.10805005f, 0.14414476f, 0.17337501f, 0.05986905f, -0.01244333f, 0.06883994f, -0.02958766f, 
    0.42658699f, -0.20250294f, 0.06714828f, 0.13284802f, -0.06649807f, 0.12649503f, -0.09795646f, -0.00169523f, 
    0.18219928f, 0.08099125f, -0.07154986f, 0.05231354f, 0.01686398f, -0.03026393f, -0.08867484f, 0.05234048f, 
    -0.13404535f, 0.07912152f, -0.15766563f, -0.20338845f, 0.01943452f, 0.15293269f, 0.02895730f, -0.01091548f, 
    0.06615335f, 0.05335481f, 0.38693962f, 0.50791645f, -0.33669975f, 0.09582063f, 0.05004153f, 0.21196261f, 
    0.05394484f, 0.02264767f, 0.05429637f, 0.20810004f, -0.16998160f, -0.09981173f, -0.10130559f, 0.03369234f, 
    0.15848148f, 0.04711910f, 0.04933513f, 0.03716774f, -0.12802826f, 0.05455432f, -0.00063481f, 0.03986945f, 
    0.09235270f, -0.20444301f, -0.35257727f, -0.41471758f, -0.39825511f, 0.27216744f, -0.19830222f, -0.08687709f, 
    0.06979116f, 0.09821101f, 0.21071573f, 0.06510947f, -0.04461534f, 0.18864602f, 0.24330534f, 0.01137778f, 
    0.05972874f, 0.21874212f, 0.12939970f, 0.09214597f, 0.19743493f, -0.04518805f, -0.31946760f, -0.06647198f, 
    0.08965398f, -0.13812678f, 0.13849114f, 0.15775381f, 0.13533792f, 0.17406368f, -0.09981377f, -0.07564092f, 
    -0.15348326f, -0.18822309f, 0.02457939f, 0.16924524f, 0.12713499f, -0.00336823f, -0.16301143f, -0.19010876f, 
    -0.19928035f, -0.03465157f, 0.08694907f, 0.03286365f, 0.00039808f, 0.19942932f, 0.05628775f, 0.06286791f, 
    0.01038775f, -0.20846727f, -0.40990666f, -0.09278626f, -0.03533343f, 0.05461761f, 0.07306214f, 0.06894868f, 
    0.06062140f, -0.01318932f, -0.09565756f, 0.38801119f, 0.08851217f, -0.03211727f, 0.04030291f, -0.01253477f, 
    0.09488750f, -0.01978720f, 0.10559212f, 0.30525622f, 0.02245277f, -0.17251904f, -0.03871414f, 0.21931589f, 
    0.02715459f, 0.41525009f, -0.04850268f, -0.08402591f, 0.00296225f, -0.08305800f, -0.07197316f, 0.00854443f, 
    -0.02067058f, -0.03859241f, -0.13792789f, 0.14334856f, -0.02266884f, -0.33160332f, 0.04616203f, -0.13174237f, 
    0.14748065f, -0.15053077f, -0.05260141f, -0.11009360f, 0.11883147f, 0.06016461f, 0.15836734f, -0.07248963f, 
    -0.03676401f, -0.00026181f, 0.01921674f, 0.00358841f, 0.05528318f, -0.40318313f, -0.57422233f, -0.38547465f, 
    0.15852231f, 0.02748041f, -0.06693103f, 0.05807541f, 0.15567958f, 0.24597135f, 0.22217527f, 0.11957715f, 
    0.18334998f, -0.03876277f, -0.08589076f, -0.11646214f, 0.00001337f, 0.16813152f, 0.09933045f, -0.29052001f, 
    -0.37184641f, -0.39724946f, -0.05644359f, 0.03793296f, -0.01504327f, 0.09432977f, 0.08846255f, 0.06615847f, 
    -0.33322406f, -0.46146792f, -0.33361155f, -0.03815114f, -0.01304712f, -0.09604567f, 0.25890949f, 0.07058392f, 
    -0.01632517f, 0.14339040f, -0.00522510f, -0.12863350f, 0.01762092f, 0.06605641f, -0.11780591f, 0.10872909f, 
    0.13772230f, 0.03723220f, 0.09569970f, 0.05543280f, -0.00893542f, 0.06638782f, 0.00328123f, -0.09811513f, 
    0.04309865f, 0.16510898f, 0.35149601f, 0.08499686f, 0.09987493f, 0.22741809f, -0.14079420f, 0.11817854f, 
    0.16524470f, 0.12641104f, 0.19212522f, 0.26107427f, 0.08982146f, 0.18553656f, 0.09128536f, 0.00152469f, 
    -0.00765863f, 0.09324338f, 0.04242371f, 0.09766804f, -0.08885460f, -0.35219058f, -0.15024967f, -0.19249803f, 
    -0.24729280f, -0.09230791f, 0.05536321f, -0.02503632f, 0.01871167f, 0.13155682f, -0.02219874f, -0.05088744f, 
    -0.19106714f, 0.12922677f, -0.23292199f, 0.29782444f, -0.08750171f, 0.09701583f, -0.01102430f, 0.00089527f, 
    0.10619064f, 0.09630403f, 0.07257789f, 0.38845873f, -0.12699683f, -0.13798356f, -0.00518189f, 0.05001015f, 
    0.10498528f, 0.05271330f, 0.02262568f, 0.11839541f, 0.09785152f, -0.05671640f, 0.09505679f, 0.03267855f, 
    -0.05743457f, -0.06391358f, -0.06510825f, -0.25010648f, 0.47842920f, 0.66245127f, 0.01704944f, -0.13273272f, 
    -0.17890221f, 0.14333072f, 0.04775325f, 0.03448012f, -0.12741105f, 0.06776401f, -0.01601233f, -0.09044521f, 
    0.02867058f, -0.04215742f, 0.07838363f, -0.62952971f, -0.24470261f, -0.42094514f, -0.57074893f, 0.32832402f, 
    -0.22845525f, -0.11001419f, 0.17577411f, 0.35398212f, 0.17369582f, 0.17425077f, 0.39858481f, -0.03880358f, 
    -0.08108129f, 0.17421666f, -0.01543920f, -0.05033271f, 0.09881192f, -0.07728361f, 0.06550769f, 0.06033481f, 
    0.20879225f, -0.14551285f, -0.09460370f, -0.02461675f, 0.24693237f, 0.16530864f, 0.01224389f, 0.15051533f, 
    -0.02747036f, -0.39080706f, 0.12391458f, 0.12754185f, 0.09233436f, 0.26252782f, -0.01146558f, -0.02553131f, 
    0.13610710f, -0.07083248f, -1.20322764f, -0.90617287f, -0.36985835f, -0.19870768f, -0.19804078f, -0.04613814f, 
    -0.12314761f, -0.05021858f, 0.11613800f, -0.44603136f, -0.25540766f, -0.29789865f, -0.40401533f, 0.38880727f, 
    0.01103395f, 0.18698069f, 0.16040477f, 0.17853343f, -0.29233310f, 0.17506306f, 0.23309331f, 0.00872681f, 
    0.00667520f, -0.13700433f, 0.06258593f, -0.00183319f, 0.04053640f, -0.71385372f, -0.34307256f, 0.24186172f, 
    0.15022339f, -0.28474104f, -0.09112108f, 0.00257737f, -0.00563244f, -0.05987392f, -0.02704330f, -0.03157657f, 
    0.37680954f, 0.13258630f, -0.32836941f, -0.28460363f, -0.06683339f, -0.06097020f, -0.23158582f, -0.10854174f, 
    -0.12218904f, -0.04582126f, -0.17477675f, -0.13703357f, -0.10602930f, -0.11091879f, 0.07713971f, 0.11714140f, 
    -0.02723339f, 0.23217268f, 0.20065895f, -0.02504176f, -0.13742611f, 0.03492727f, -0.14173415f, 0.02122524f, 
    0.06832940f, 0.09159478f, -0.26183292f, 0.30372858f, -0.05210045f, 0.00710138f, -0.03990376f, 0.06014590f, 
    -0.06910942f, 0.27332851f, 0.25800803f, -0.10742406f, 0.07642876f, 0.07058112f, -0.20824970f, 0.06997733f, 
    0.11176070f, 0.15809238f, 0.14519812f, -0.62562698f, -0.20937259f, -0.37511256f, 0.11540964f, -0.03824096f, 
    0.05293106f, 0.21751292f, 0.10534900f, 0.04761261f, -0.39745677f, 0.36351028f, 0.28630045f, -0.40752709f, 
    -0.44805518f, -0.05347844f, 0.01972562f, -0.00059406f, 0.05041394f, -0.42398697f, -0.03043872f, -0.19061173f, 
    0.02096928f, -0.00713081f, 0.15464702f, -0.02881231f, 0.02711098f, -0.11598305f, 0.26960400f, -0.09879225f, 
    0.24438129f, 0.14638701f, 0.03034268f, 0.00877753f, 0.02494516f, 0.21827880f, -0.02044123f, -0.20466846f, 
    0.17438781f, 0.05567450f, 0.00928104f, 0.02873810f, 0.01705742f, 0.14460924f, 0.16893673f, 0.01818436f, 
    0.19930904f, 0.09147447f, 0.33954415f, -0.17137797f, 0.00080896f, 0.07088550f, 0.12011030f, -0.20745441f, 
    0.10140879f, 0.02203483f, 0.18778315f, 0.19707337f, -0.09826738f, -0.06500596f, -0.05243510f, 0.12642097f, 
    0.18069467f, 0.18769097f, -0.31952509f, 0.14563513f, -0.20481706f, -0.04339840f, -0.09341771f, -0.13263814f, 
    0.22373059f, 0.14337738f, -0.05608366f, -0.06099661f, -0.23801725f, 0.28664690f, 0.18757060f, 0.11028970f, 
    0.02622162f, 0.26929915f, 0.09138682f, -0.05862220f, -0.14612205f, -0.16984989f, 0.26489782f, -0.03860793f, 
    -0.07052562f, -0.05548292f, 0.07273413f, 0.08402149f, 0.30800256f, 0.18753560f, 0.02490053f, -0.04333394f, 
    -0.04913791f, -0.11788573f, -0.14257587f, 0.21858406f, -0.04628737f, 0.17413008f, 0.47722057f, -0.43819803f, 
    -0.17999595f, -0.08984417f, 0.15042259f, 0.11605126f, 0.15873928f, -0.06737235f, -0.09020337f, -0.20671503f, 
    -0.00045165f, 0.19687143f, 0.06617442f, -0.08899418f, -0.22455160f, 0.11281607f, 0.09491152f, 0.01153224f, 
    0.52841222f, -0.02950695f, 0.26284039f, 0.03529039f, -0.07116926f, -0.13466337f, 0.05443761f, 0.08507653f, 
    -0.02306925f, 0.62986290f, -0.34671339f, 0.30018353f, 0.15614344f, -0.06071940f, -0.17981055f, -0.02136168f, 
    0.01605142f, 0.08587676f, 0.09902115f, -0.11445956f, -0.21977817f, -0.03218060f, 0.17217891f, 0.00757094f, 
    0.05874181f, 0.04460888f, 0.00391561f, 0.03275062f, -0.02299334f, -0.00222076f, 0.20788531f, 0.22085355f, 
    0.11536519f, 0.01829339f, -0.01072462f, -0.16242987f, -0.12034348f, -0.32252756f, -0.73598206f, -0.09417825f, 
    -0.00881528f, -0.00932425f, -0.00385124f, 0.09208651f, -0.00552822f, 0.02358112f, -0.33543554f, -0.33989638f, 
    -0.30628619f, 0.08897973f, -0.11403017f, 0.02805690f, 0.16309541f, 0.02317814f, 0.27672893f, -0.12136093f, 
    -0.01899083f, -0.08537871f, -0.17774996f, -0.35148686f, -0.07574503f, 0.07671164f, 0.03668459f, 0.36548665f, 
    -0.24791163f, -0.09461274f, -0.27097464f, 0.03095094f, -0.08541752f, 0.11904114f, -0.03900532f, -0.10571567f, 
    -0.04332535f, 0.38727763f, 0.18417479f, -0.11969636f, 0.07028450f, -0.05684153f, 0.12803054f, 0.20527725f, 
    0.00998929f, -0.29466629f, -0.19615568f, -0.05285176f, 0.20851305f, 0.20455144f, -0.01028089f, 0.15582058f, 
    0.10872702f, 0.02476554f, 0.18604645f, 0.11343649f, -0.21560735f, 0.05592504f, -0.25692061f, -0.04061371f, 
    0.06530034f, 0.16056408f, 0.11917935f, -0.43725052f, 0.11039075f, -0.19949773f, 0.14686358f, 0.02140846f, 
    0.32239565f, 0.11771568f, 0.12051638f, 0.09257860f, 0.13382681f, -0.42728713f, 0.24591944f, 0.10845001f, 
    -0.17294854f, -0.03535346f, -0.12647133f, 0.17842528f, 0.19097407f, 0.39886636f, -0.33126906f, -0.45099473f, 
    0.19430082f, -0.07303148f, -0.23343703f, -0.16553262f, -0.11809563f, -0.14610949f, 0.00320755f, -0.46840769f, 
    -0.19075814f, 0.10914560f, -0.05061175f, -0.06554613f, 0.17332521f, -0.24003688f, -0.02630423f, -0.16716895f, 
    0.10221991f, 0.22489068f, -0.26573440f, -0.00119163f, -0.24824640f, -0.14348102f, -0.13991891f, 0.16854657f, 
    -0.31559747f, -0.63016665f, -0.06070706f, -0.36688283f, -0.07234551f, -0.07342903f, 0.06375934f, 0.10094320f, 
    0.12020367f, -0.25107232f, 0.12550184f, 0.18204005f, 0.00639681f, 0.00374855f, -0.18488659f, 0.17975119f, 
    0.13732740f, 0.21782370f, -0.18249673f, -0.07974917f, 0.17388147f, -0.04182583f, 0.15090068f, -0.08180188f, 
    -0.05677442f, -0.00126257f, 0.18426472f, -0.04654932f, -0.73578465f, -0.76115102f, -0.01715939f, -0.09510202f, 
    0.09667896f, 0.29307532f, 0.11299749f, -0.00375237f, 0.27602565f, -0.25260979f, 0.33997047f, -0.10875318f, 
    -0.17468350f, -0.28135914f, -0.01473679f, 0.07370646f, 0.14824042f, 0.39554566f, -0.00824706f, 0.27876565f, 
    0.21322496f, 0.16078678f, 0.05310247f, 0.14576031f, 0.14549628f, -0.00430175f, 0.32549357f, -0.29590398f, 
    -0.32521328f, 0.04099983f, 0.19095102f, 0.06629861f, 0.04310201f, 0.04942509f, -0.04817543f, 0.02232908f, 
    0.12121203f, -0.07793177f, 0.03334830f, 0.14730756f, 0.01006566f, 0.09301683f, 0.07541294f, -0.01247472f, 
    0.04805070f, -0.40973878f, -0.52808243f, -0.18478449f, -0.13010468f, -0.06304096f, -0.06365748f, -0.28336006f, 
    0.14902593f, -0.20370348f, 0.11097012f, -0.05147714f, -0.07758211f, 0.05035791f, -0.06948734f, 0.18346438f, 
    -0.00962783f, 0.07016725f, 0.12926559f, -0.00195228f, -0.27828664f, 0.05826833f, 0.11570410f, -0.01815152f, 
    0.12061740f, -0.02199477f, -0.02864349f, -0.19628753f, 0.18914682f, 0.30085835f, 0.01845671f, -0.18989147f, 
    -0.09183639f, -0.02438438f, -0.02715175f, -0.08110830f, -0.18856208f, -0.02945831f, 0.08822444f, -0.05694768f, 
    -0.13822061f, 0.02016076f, -0.04347553f, -0.03160070f, 0.09839194f, 0.12442738f, -0.08814833f, -0.79334873f, 
    -0.10296912f, 0.09964208f, 0.31653720f, -0.02854063f, 0.08397519f, 0.11938445f, -0.75871909f, -0.47190693f, 
    -0.47706518f, -0.21956392f, 0.25313658f, -0.00036690f, -0.01263609f, -0.07653280f, -0.09916408f, -0.02136944f, 
    -0.21254936f, -0.15515973f, 0.02372707f, 0.04916112f, 0.08151725f, 0.06308735f, 0.12584230f, 0.00720118f, 
    -0.19546957f, -0.00239885f, 0.02243869f, -0.09174469f, 0.13438055f, 0.00164775f, 0.13853206f, 0.08726113f, 
    -0.05643754f, -0.30086824f, -0.45730132f, -0.54497772f, -0.27811253f, 0.15862429f, 0.13212918f, -0.00472572f, 
    -0.03932730f, -0.01921350f, 0.04039950f, 0.37518549f, 0.34070170f, -0.07127266f, 0.04867656f, -0.17391306f, 
    -0.05764746f, 0.18825324f, 0.02885084f, 0.24159358f, 0.25612691f, 0.15655051f, -0.11645292f, 0.07463157f, 
    -0.05372067f, 0.05646196f, 0.20506310f, 0.02949777f, 1.01441014f, 0.17468914f, 0.41931701f, -0.02999967f, 
    -0.29574838f, -0.25869048f, 0.04332671f, 0.09929321f, 0.23902771f, -0.18448798f, -0.09572264f, -0.19483027f, 
    -0.12042428f, 0.11309104f, -0.14296888f, 0.38228038f, 0.06873799f, -0.08815683f, 0.17343228f, -0.59916234f, 
    0.06751881f, 0.24396266f, -0.00609374f, -0.23556909f, 0.09086391f, -0.04369476f, 0.08224007f, 0.18955944f, 
    0.09379812f, -0.27599832f, -0.13780509f, 0.01543229f, 0.29321229f, 0.18057372f, 0.02422924f, 0.02255141f, 
    -0.01545107f, -0.80679613f, -0.32695174f, 0.02591790f, -0.10676569f, -0.33001786f, 0.11790793f, 0.20303431f, 
    -0.00792886f, 0.17661256f, -0.09636372f, 0.06020402f, -0.04943814f, -0.19385082f, 0.04746017f, 0.15487161f, 
    0.05138654f, -0.07158668f, -0.36202031f, 0.10124548f, -0.32077187f, 0.01387598f, 0.01316797f, -0.06658703f, 
    0.47641879f, -0.12009411f, -0.05296857f, 0.26786250f, 0.14281245f, -0.10070245f, -0.25374678f, 0.03259585f, 
    0.04545645f, 0.13880020f, 0.02173596f, 0.08714623f, 0.03217217f, 0.38305545f, 0.22839150f, -0.21705528f, 
    -0.02926288f, -0.18132995f, 0.14029950f, -0.08813918f, -0.10650647f, 0.37825018f, -0.24673857f, 0.21989594f, 
    0.10298796f, 0.12428462f, 0.17791039f, 0.13040036f, 0.13101146f, 0.03502295f, 0.35029268f, 0.10988542f, 
    0.05133949f, -0.24350308f, 0.07148264f, 0.01511073f, -0.05107636f, 0.19243544f, 0.11610836f, 0.10219684f, 
    -0.38215050f, -0.43116233f, -0.18498671f, -0.39564252f, 0.04572206f, 0.23084208f, -0.10026614f, 0.28368846f, 
    0.42859581f, 0.50650245f, 0.56914002f, -0.14288513f, -0.02829809f, 0.00683782f, 0.17715783f, 0.17472681f, 
    -0.03076469f, 0.04804125f, -0.03401678f, -0.33361587f, -0.01297835f, -0.28145686f, -0.04926585f, 0.03865623f, 
    0.01195878f, -0.14671944f, -0.19345362f, -0.35453147f, -0.53941417f, -0.34517464f, -0.20578730f, -0.14209005f, 
    -0.03062008f, 0.14515932f, -0.12840980f, -0.01708281f, -0.01297676f, 0.08675054f, 0.01884881f, -0.03439703f, 
    -0.07464530f, 0.15755950f, 0.07953180f, 0.11956500f, 0.34524605f, 0.37823305f, 0.62492412f, 0.17158464f, 
    0.10541037f, 0.06165883f, 0.14853203f, 0.10199060f, 0.17141266f, -0.09757633f, -0.75758767f, -0.25670564f, 
    0.01132824f, -0.11625615f, 0.03480716f, 0.29815054f, 0.03026508f, -0.24702078f, 0.13937481f, -0.09179908f, 
    0.03248360f, 0.13416189f, 0.04971756f, 0.11129627f, 0.02990844f, -0.05821086f, 0.12800635f, -0.05791239f, 
    -0.30781436f, -0.38522735f, -0.03742514f, 0.00786099f, -0.02915831f, 0.19166565f, 0.00749917f, 0.03683771f, 
    0.24639407f, -0.34496668f, -0.03416432f, -0.13682912f, 0.05794910f, 0.08883770f, 0.08824852f, 0.01391023f, 
    0.00967622f, 0.39958343f, 0.11654848f, -0.65312320f, -0.08962613f, -0.22599077f, 0.03389223f, 0.28936577f, 
    0.01290445f, 0.25112286f, 0.01844740f, -0.18066403f, -0.09676550f, 0.03086358f, 0.15013403f, -0.14446895f, 
    0.18505532f, 0.16368680f, 0.17315303f, -0.37219676f, -0.39948100f, 0.41785637f, -0.21228360f, 0.03715845f, 
    -0.26483947f, 0.11428541f, 0.05974204f, -0.37181115f, 0.23475504f, -0.20910330f, -0.56012702f, -0.09396011f, 
    -0.06144528f, -0.03357350f, 0.31690601f, -0.07002497f, -0.10690577f, 0.26204368f, -0.17007749f, -0.00040229f, 
    0.01560518f, 0.02309722f, 0.03182772f, 0.15690804f, 0.01942964f, 0.03421316f, 0.21835518f, -0.70038229f, 
    -0.11017561f, 0.09596672f, 0.00118200f, -0.05022345f, 0.03832601f, 0.07722964f, 0.11275301f, 0.17955856f, 
    0.35248992f, -0.13442212f, -0.08907265f, -0.01389933f, 0.05264527f, 0.20324455f, -0.04496836f, -0.09855749f, 
    -0.06564022f, -0.31084093f, -0.64936984f, -0.19221750f, -0.26797611f, -0.16030812f, 0.14194617f, 0.09733679f, 
    0.05541553f, 0.32719621f, -0.27972400f, -0.24226575f, 0.11225575f, 0.01375653f, 0.18234737f, 0.16018909f, 
    -0.03958961f, 0.04506589f, 0.11160799f, -0.78861761f, -0.61919338f, 0.00486323f, -0.17954625f, -0.22165044f, 
    -0.04123367f, 0.04869757f, 0.07999013f, -0.19166467f, -0.88212883f, -0.29322073f, -0.14099909f, -0.13626894f, 
    0.09907117f, 0.12996161f, 0.17854531f, -0.24121062f, 0.13012768f, 0.41916823f, 0.29342940f, -0.17079207f, 
    0.03342813f, -0.11701107f, -0.19536257f, -0.25758985f, 0.01388096f, -0.13461624f, 0.04741269f, -0.03694376f, 
    -0.10001760f, -0.20806700f, -0.12783818f, -0.00388078f, 0.12800770f, -0.02849167f, -0.22272022f, -0.36480042f, 
    0.12836257f, -0.13634002f, 0.23517962f, 0.01727854f, 0.06592516f, 0.12789828f, 0.05844031f, 0.19129969f, 
    0.11532994f, 0.33424255f, 0.13878879f, 0.02080058f, 0.03797404f, 0.12560202f, 0.03165305f, 0.17253552f, 
    -0.15841374f, -0.09915105f, -0.05799747f, -0.04144770f, -0.07432513f, -0.08804554f, 0.02724568f, 0.20602939f, 
    -0.06740494f, 0.04573411f, 0.27431461f, 0.24639954f, -0.08814374f, 0.05620240f, 0.04786674f, -0.03232073f, 
    0.23988044f, -0.07270016f, -1.17255902f, -0.94062060f, 0.00529635f, -0.11183991f, 0.15201531f, -0.23497963f, 
    -0.17079026f, -0.03272989f, 0.15390167f, -0.17292237f, -0.07482875f, 0.22190897f, -0.08946107f, 0.19239216f, 
    0.01359372f, 0.01930083f, 0.02269951f, 0.05937574f, -0.21142209f, 0.29986700f, 0.26781714f, 0.12907235f, 
    -0.02324907f, -0.12465364f, 0.06902232f, -0.15889673f, 0.06584729f, 0.12819509f, 0.47013482f, -0.26074415f, 
    -0.27910241f, -0.28950247f, 0.05776229f, 0.15010877f, 0.02070888f, 0.04184613f, -0.10397459f, 0.50091463f, 
    0.12231637f, -0.05293421f, -0.28444919f, -0.01177001f, 0.10358007f, -0.13144086f, 0.13986640f, -0.52307397f, 
    0.07654800f, 0.14638351f, -0.00188122f, -0.20032993f, -0.33971673f, 0.26868948f, -0.08389567f, 0.19195570f, 
    0.08183465f, 0.27685890f, 0.05864929f, 0.01530354f, -0.28157932f, -0.17675881f, 0.13605508f, 0.07481012f, 
    0.03601523f, -0.42773941f, -0.41849986f, 0.20001298f, -0.03407247f, -0.19370984f, -0.14809845f, -0.00495666f, 
    -0.02515290f, 0.06961638f, -0.48626783f, -0.18203805f, -0.17597343f, 0.22938910f, -0.06971758f, 0.04189048f, 
    0.10331124f, -0.01351612f, 0.08589129f, -0.29453760f, -0.34136885f, 0.41455665f, 0.04317018f, 0.31811720f, 
    0.39243102f, 0.11000882f, -0.03302912f, 0.02216507f, 0.02089218f, 0.42476222f, 0.39834782f, -0.26702511f, 
    0.05977704f, -0.36862621f, 0.06023610f, 0.23947005f, -0.04157936f, -0.23606807f, -0.10436200f, -0.15952286f, 
    -0.04984008f, 0.14993504f, 0.00599564f, -0.03139789f, -0.25322282f, 0.01189217f, 0.05454782f, 0.30279610f, 
    -0.05089601f, 0.01437900f, -0.11841841f, -0.01271176f, 0.06722132f, 0.00069537f, 0.10411783f, -0.37948254f, 
    0.13996758f, -0.16818881f, -0.02183474f, 0.14065634f, 0.19236705f, -0.08321953f, 0.00652635f, 0.10620304f, 
    -0.45222104f, 0.09763262f, 0.37032467f, -0.09748854f, 0.10578024f, -0.11504543f, 0.07924996f, -0.14988717f, 
    -0.02987298f, -0.25827190f, 0.04561856f, 0.01472013f, -0.01868574f, -0.07600956f, -0.20519388f, 0.00409601f, 
    -0.00834096f, -0.01766821f, -0.17757197f, -0.03716024f, -0.17751466f, 0.05174579f, 0.27179724f, 0.09106007f, 
    -0.29554781f, -0.00692653f, 0.06118287f, -0.18393275f, 0.23698635f, 0.40811402f, 0.10290148f, 0.07622144f, 
    -0.13722542f, -0.19818006f, 0.05120223f, 0.19126870f, -0.79197925f, -0.06628434f, 0.10662340f, -0.13445795f, 
    -0.08360764f, -0.14353326f, 0.23318505f, 0.16141655f, 0.07622579f, -0.31101289f, -0.38332111f, 0.29755914f, 
    -0.03972594f, 0.01622973f, 0.01645839f, 0.09148644f, -0.01845660f, 0.04451894f, -0.16288608f, 0.29370192f, 
    0.09524298f, 0.22073306f, -0.31247866f, 0.11393151f, -0.02193279f, -0.01416281f, 0.10605684f, -0.12847282f, 
    0.04151398f, 0.04805415f, 0.11589899f, -0.05058136f, 0.04354902f, 0.14270464f, -0.02913486f, 0.21109048f, 
    -0.56080002f, -0.11843708f, -0.01972407f, -0.12804088f, -0.06071699f, 0.00113420f, -0.01060981f, -0.03598066f, 
    0.03946896f, -0.14275116f, 0.02360900f, -0.06123351f, 0.09630034f, -0.08985872f, -0.04563961f, 0.04930953f, 
    0.05099009f, 0.08828473f, 0.40425351f, -0.10925505f, 0.22498052f, -0.16654100f, 0.19997096f, -0.08539142f, 
    0.06941070f, 0.15581669f, 0.01657209f, -0.55092329f, 0.03325029f, -0.11753462f, -0.11783566f, -0.19196151f, 
    -0.09211812f, -0.17305531f, 0.02477126f, -0.04060835f, 0.02884003f, -0.53212363f, 0.47954872f, -0.15432632f, 
    0.04382945f, -0.33428812f, 0.01065315f, 0.09538066f, 0.06927729f, 0.24159876f, -0.28177330f, -0.14562090f, 
    -0.13095707f, 0.11457866f, -0.21765517f, 0.27490389f, 0.26857069f, -0.04694590f, -0.06837987f, 0.39074552f, 
    0.08524603f, 0.03128063f, -0.21976869f, -0.01570332f, -0.08873410f, 0.27368677f, -0.05766979f, 0.17881832f, 
    0.13936388f, 0.16318664f, 0.09428959f, -0.10741500f, 0.06125210f, -0.00116212f, -0.14918610f, 0.12885354f, 
    0.04222422f, -0.02053345f, -0.03690026f, -0.01610180f, 0.03768386f, -0.02869625f, 0.02114788f, 0.03565331f, 
    -0.03689223f, 0.03195135f, -0.03261974f, 0.03897925f, -0.06027360f, -0.03578281f, -0.03169408f, 0.03461805f, 
    0.02499666f, 0.03989357f, -0.00802832f, -0.00349853f, -0.03706645f, -0.04532924f, 0.01347360f, -0.04669905f, 
    0.03354318f, 0.04408588f, -0.05764899f, 0.01523708f, -0.00286803f, 0.04734644f, -0.03407212f, -0.04317578f, 
    0.00465586f, 0.00239984f, 0.04135753f, 0.01312119f, 0.05174224f, -0.00898155f, 0.02471239f, 0.02388779f, 
    0.01592159f, 0.02877449f, -0.05684062f, 0.01863416f, 0.00294466f, 0.01340029f, 0.02987013f, -0.02207442f, 
    0.03778524f, -0.02215035f, 0.02015705f, -0.02550620f, 0.02886863f, -0.05308574f, 0.00622711f, -0.02512904f, 
    0.03397050f, -0.00846090f, 0.03060942f, -0.01892828f, 0.04104750f, -0.00727609f, -0.05505177f, -0.05592070f, 
    0.02064547f, 0.04707736f, -0.06387112f, -0.02011679f, 0.03031535f, 0.02626467f, -0.03560340f, -0.02624558f, 
    0.00084955f, -0.05124222f, 0.05083002f, 0.05450964f, 0.00736513f, 0.02789019f, -0.01186696f, 0.03708921f, 
    -0.03328167f, -0.03211341f, 0.04061192f, -0.02881822f, -0.06233114f, -0.02058046f, -0.05724114f, -0.04576163f, 
    -0.05286571f, -0.02383721f, -0.05446739f, 0.02780926f, 0.04206878f, 0.03802663f, 0.02150792f, -0.03767018f, 
    0.03841003f, -0.00465129f, -0.00798162f, -0.05287591f, -0.05011465f, 0.03148084f, -0.06147969f, 0.02714266f, 
    -0.02012486f, -0.01273749f, -0.01322270f, -0.05740437f, -0.03002145f, -0.02533680f, 0.04853372f, -0.00535279f, 
    -0.05072627f, 0.05678748f, -0.02088572f, -0.05709255f, 0.05708065f, 0.01032981f, 0.01139725f, -0.01010565f, 
    -0.05603586f, -0.02831438f, -0.00816959f, -0.02246016f, 0.03388036f, -0.00882430f, 0.05278869f, -0.03137419f, 
    -0.03150852f, 0.04107765f, -0.04875240f, 0.00927708f, 0.04399974f, 0.03244213f, -0.00025973f, 0.04919299f, 
    -0.04673751f, -0.05891072f, 0.01441702f, 0.04358636f, 0.01610202f, -0.00390450f, 0.00057402f, -0.03992917f, 
    -0.05339910f, -0.01738193f, -0.02890010f, -0.03457684f, 0.02346264f, -0.02210850f, -0.03701937f, -0.02580916f, 
    -0.06303874f, 0.04533144f, -0.01947856f, -0.02462387f, 0.01578289f, 0.00624414f, -0.00711255f, 0.03892127f, 
    -0.00728165f, -0.02837331f, -0.00091560f, -0.06193418f, 0.04050794f, -0.02961799f, -0.02123576f, -0.03614900f, 
    -0.03167194f, 0.04776262f, 0.03418252f, -0.01755526f, -0.03953659f, -0.00453046f, -0.00581530f, -0.00379166f, 
    -0.01270648f, -0.05046401f, -0.06365862f, -0.03877287f, -0.01139538f, 0.00517086f, 0.02499368f, 0.04299012f, 
    -0.02247062f, 0.00940641f, -0.00953344f, -0.06168687f, -0.02831270f, -0.00490439f, 0.02404488f, -0.02819822f, 
    0.05287423f, -0.04935047f, 0.00355567f, -0.05716572f, 0.00126409f, 0.02533263f, -0.04171495f, -0.02808695f, 
    -0.04581393f, 0.01616606f, -0.02050483f, -0.03946963f, -0.03353157f, -0.01937853f, -0.02103496f, 0.05300557f, 
    -0.01600167f, -0.01244397f, -0.00848359f, 0.00014745f, -0.01544734f, 0.03681960f, -0.00639057f, 0.05166373f, 
    -0.02976223f, 0.02167955f, 0.02802285f, 0.02466276f, -0.06361290f, 0.02384003f, -0.01400904f, -0.05949870f, 
    0.04219840f, 0.04194412f, 0.04741922f, -0.05373570f, -0.01390273f, -0.06403439f, 0.01053419f, -0.02239898f, 
    0.03480611f, 0.02009268f, -0.00517576f, 0.04998648f, -0.03514172f, -0.02721585f, -0.04730874f, -0.03664478f, 
    -0.05659539f, 0.05113183f, 0.01136718f, -0.03912695f, -0.00861770f, -0.04441617f, 0.04498699f, -0.01634731f, 
    0.00235774f, 0.00124068f, -0.05981234f, 0.01050440f, 0.03971383f, 0.01371981f, 0.01433378f, 0.01636118f, 
    -0.05670583f, -0.04596398f, -0.02279438f, -0.02149375f, -0.02605892f, -0.03903542f, -0.04242961f, 0.01350421f, 
    -0.04841987f, -0.05631245f, 0.01566272f, -0.04762816f, -0.05592454f, -0.04741172f, -0.04140933f, -0.01729474f, 
    -0.04360353f, -0.01985238f, -0.04185605f, -0.00917756f, -0.06211645f, 0.04499890f, -0.05084104f, 0.00924476f, 
    -0.06352795f, 0.00988035f, -0.03717736f, 0.00349074f, -0.01636353f, -0.04293171f, 0.00182745f, 0.00077071f, 
    -0.51854509f, -0.32055014f, -0.10673355f, -0.25284505f, -0.35062829f, 0.02185006f, 0.13607930f, -0.09764983f, 
    0.18116038f, -0.15607597f, -0.03002930f, 0.29825199f, -0.16373546f, -0.16214870f, -0.08119636f, 0.05471962f, 
    -0.09997457f, -0.01092850f, 0.15826377f, -0.30463490f, -0.09400226f, 0.08798093f, -0.15140054f, -0.02131961f, 
    -0.03044179f, -0.02878043f, 0.14690940f, 0.08554433f, 0.12790158f, 0.32816535f, -0.00566395f, 0.07285437f, 
    -0.05796655f, -0.08637838f, 0.10566032f, -0.22632973f, 0.04960503f, -0.05194869f, -0.17529361f, 0.10537352f, 
    0.04465651f, -0.00552559f, 0.18812998f, 0.14360027f, 0.07593656f, -0.17417307f, 0.06997263f, 0.30362156f, 
    0.22714971f, -0.08916847f, 0.04063440f, 0.18030837f, -0.14862503f, 0.05016392f, -0.12607940f, -0.23463613f, 
    -0.31808615f, 0.00656650f, 0.29689220f, -0.00065706f, 0.27967158f, 0.24749605f, 0.06379505f, -0.18786451f, 
    0.13076590f, 0.02709625f, 0.01107781f, 0.03069463f, 0.00130253f, -0.12384593f, 0.10317616f, -0.06561121f, 
    -0.02271259f, -0.09025465f, 0.51788390f, 0.08891314f, -0.08435920f, 0.02910306f, 0.07241481f, 0.15297498f, 
    0.17578675f, 0.05920698f, -0.19841592f, -0.08585452f, -0.09142722f, -0.14943431f, 0.06867171f, -0.17133915f, 
    -0.01583852f, -0.22013538f, 0.13868807f, 0.22579613f, -0.10700724f, 0.06502177f, -0.13754529f, -0.00217510f, 
    0.03143450f, -0.14975739f, -0.18825294f, 0.11753146f, -0.35869223f, 0.00673306f, 0.01978751f, -0.10796105f, 
    -0.10578608f, 0.04506013f, -0.15394206f, 0.01447389f, -0.06536660f, -0.04739171f, 0.45411438f, -0.13470918f, 
    -0.09040958f, -0.01500937f, 0.07898319f, -0.04717454f, 0.18369220f, -0.25024128f, 0.14737849f, -0.23460399f, 
    -0.08033467f, -0.09186237f, -0.04194770f, -0.06350291f, 0.02111498f, -0.07538347f, -0.08047197f, 0.28140634f, 
    0.21662350f, 0.19060855f, 0.00591391f, -0.04060375f, -0.00991946f, 0.03788358f, 0.09420907f, -0.34017065f, 
    -0.09258502f, -0.18029366f, 0.03232326f, 0.08119856f, 0.00368673f, -0.04373981f, 0.07652291f, -0.04582670f, 
    0.30522394f, 0.31273440f, 0.35286632f, 0.03692738f, 0.11344761f, 0.11740869f, 0.17830923f, -0.07713544f, 
    -0.08977787f, -0.20089860f, -0.09802423f, -0.13858740f, -0.14940941f, 0.06736119f, 0.02331598f, -0.07706273f, 
    0.05168791f, -0.10433231f, -0.07895846f, -0.14493057f, -0.30150771f, 0.19842623f, -0.07245188f, -0.02801597f, 
    -0.10307644f, 0.10790987f, 0.21139833f, -0.05971161f, 0.33308095f, -0.38464761f, -0.21896002f, 0.15638147f, 
    0.07751832f, -0.07674649f, -0.00263513f, -0.22972508f, -0.08831594f, -0.20231116f, -0.04709297f, -0.01645800f, 
    -0.05847967f, -0.04664539f, -0.08375806f, 0.22379735f, -0.26462466f, 0.21063945f, 0.19744755f, 0.34353852f, 
    0.00663257f, -0.01684821f, -0.15406160f, 0.10176187f, 0.00352799f, -0.07925827f, -0.10073829f, 0.49546543f, 
    0.10123368f, -0.06769070f, -0.17587741f, 0.03883119f, -0.09689672f, 0.00845564f, -0.04542982f, -0.24544163f, 
    -0.24770442f, 0.04324189f, 0.13451292f, 0.27254459f, 0.02711450f, -0.00004029f, 0.18663390f, 0.21142282f, 
    -0.02555840f, -0.06156692f, -0.18712252f, -0.02826721f, 0.05600074f, -0.09091819f, -0.06369783f, -0.00721650f, 
    -0.01536898f, -0.02729576f, 0.54958218f, 0.32639572f, 0.13724200f, 0.04571613f, 0.11407394f, -0.08020790f, 
    0.07776485f, 0.04311189f, -0.53509593f, -0.04867886f, -0.24733983f, -0.22846492f, -0.17038484f, 0.02611907f, 
    -0.04527598f, 0.05741891f, -0.06900451f, -0.41566274f, -0.33363771f, -0.15710235f, -0.23704025f, -0.13018529f, 
    0.09508152f, 0.22998582f, -0.12754917f, 0.13995130f, -0.01681963f, -0.24549043f, -0.42755258f, 0.04078266f, 
    -0.18869838f, 0.15187120f, -0.00058168f, -0.11583786f, 0.20641090f, 0.19950059f, 0.03411740f, 0.08705789f, 
    0.02857053f, 0.07968867f, 0.06553062f, 0.06436674f, 0.05571430f, 0.46659648f, 0.32546419f, 0.44634429f, 
    -0.30926740f, 0.09743971f, 0.19683564f, -0.25455260f, -0.04723906f, 0.08943317f, -0.11005899f, 0.21760681f, 
    0.18210544f, 0.18083140f, -0.00484389f, 0.04705580f, -0.24509649f, -0.01629143f, -0.02948907f, -0.07589884f, 
    -0.01322517f, -0.02118816f, 0.00901839f, -0.06683815f, 0.00614457f, -0.02384681f, -0.05236446f, 0.03041726f, 
    -0.00163217f, -0.04673899f, 0.03618352f, 0.02253611f, 0.03696677f, 0.01985406f, -0.03791139f, -0.00330660f, 
    0.02526026f, -0.02720914f, 0.00762903f, -0.02074565f, 0.03146776f, 0.01396857f, -0.04294949f, -0.02579886f, 
    -0.06160391f, -0.03039604f, -0.03608836f, -0.03993890f, -0.04060059f, -0.05398184f, 0.00002636f, -0.06448910f, 
    -0.03272165f, 0.02241472f, -0.06351392f, -0.00237262f, 0.02680115f, 0.04533642f, -0.06248644f, -0.03360186f, 
    -0.00381357f, -0.01177036f, -0.03984244f, -0.00164421f, 0.00050467f, -0.04886427f, 0.02737457f, 0.01711104f, 
    -0.00969461f, -0.00667164f, 0.04418498f, -0.03501231f, 0.00429214f, 0.00683907f, 0.00044751f, -0.00081735f, 
    -0.03421492f, 0.02924605f, 0.00080390f, -0.01085119f, -0.05308621f, -0.05925908f, 0.00702423f, 0.03373304f, 
    0.04260126f, 0.02926664f, 0.01070147f, 0.00016541f, -0.05395030f, -0.02887573f, -0.02772748f, 0.01406169f, 
    0.04306924f, 0.01231953f, -0.04400278f, 0.04045143f, -0.04829447f, -0.03283796f, 0.00696485f, -0.06028531f, 
    -0.05244922f, -0.02629575f, -0.03394286f, 0.01984718f, 0.01462952f, -0.02705943f, -0.01525270f, 0.03607485f, 
    -0.04480156f, -0.05468847f, -0.05334285f, 0.00269646f, -0.01599157f, -0.01493456f, -0.05728020f, -0.04465098f, 
    0.03195748f, 0.02393552f, -0.06334306f, 0.03712928f, 0.00345585f, -0.01984472f, -0.06110325f, -0.04947866f, 
    0.04175274f, -0.03565946f, -0.04915861f, 0.04807618f, 0.01102879f, 0.01629061f, 0.04036719f, -0.02647928f, 
    0.02363912f, 0.01234652f, -0.05246383f, -0.03418329f, 0.02584175f, 0.04768309f, -0.01485679f, -0.04328510f, 
    0.02725109f, -0.03890413f, 0.00978797f, 0.00161726f, -0.05961972f, -0.02911109f, -0.02130399f, 0.04234313f, 
    -0.04830159f, 0.04387720f, 0.03597070f, 0.04266033f, -0.04810432f, -0.00756257f, 0.01074716f, -0.04240970f, 
    0.00713045f, 0.00579228f, -0.03215824f, 0.04690266f, 0.01361918f, -0.04805687f, 0.00924194f, -0.02715019f, 
    -0.01274596f, 0.01679756f, -0.05724232f, -0.02630876f, -0.01492176f, -0.04794830f, -0.03150902f, 0.04694978f, 
    0.01751342f, -0.03813437f, 0.04523206f, -0.01605359f, 0.03163578f, -0.02500344f, -0.05583166f, 0.04049005f, 
    -0.03046225f, -0.04657540f, 0.03784115f, -0.01978990f, -0.01518165f, -0.03401799f, 0.02100127f, 0.00584146f, 
    -0.01223515f, -0.00745787f, 0.01907403f, 0.03518505f, -0.04657749f, -0.02858257f, -0.06048190f, 0.02771595f, 
    -0.02258453f, -0.03006539f, 0.02151298f, -0.02812972f, 0.02894290f, 0.03410175f, 0.02263677f, -0.01608023f, 
    -0.02676250f, 0.02146323f, -0.01013358f, -0.00441992f, -0.04713625f, 0.02267483f, 0.05027838f, 0.01344395f, 
    -0.01550198f, 0.01006962f, 0.00820594f, -0.05029634f, -0.03411209f, -0.00474371f, -0.06486972f, -0.05358673f, 
    -0.01907881f, -0.04727892f, 0.02420345f, -0.00953315f, 0.02115249f, -0.05014039f, 0.02424377f, -0.05871936f, 
    0.04449817f, 0.03587854f, 0.03386036f, -0.04977550f, -0.04261987f, -0.04864671f, 0.01521744f, 0.02431818f, 
    -0.04866995f, -0.05542297f, -0.01698318f, 0.02628044f, -0.04356392f, 0.02121405f, -0.03848586f, 0.04805631f, 
    0.00183055f, 0.01205863f, -0.01613562f, -0.04024567f, 0.01690963f, -0.04243101f, 0.04400304f, -0.03836661f, 
    -0.02885433f, 0.00451169f, -0.01911702f, 0.04051623f, -0.03215429f, 0.00709852f, 0.03761644f, -0.03764614f, 
    -0.00412886f, -0.04846839f, 0.01772872f, -0.03555298f, -0.01210283f, -0.05287972f, 0.03212516f, -0.06695201f, 
    -0.02012885f, -0.00873104f, 0.02143737f, 0.03716418f, 0.03242764f, -0.04724793f, -0.00660543f, 0.04121052f, 
    0.00174864f, -0.01925023f, -0.00676770f, -0.04307075f, 0.00849194f, 0.04269473f, 0.04062428f, -0.03987527f, 
    0.00415376f, 0.03456631f, -0.04291382f, 0.02603813f, -0.05724663f, -0.00540948f, 0.05035840f, 0.02032928f, 
    0.00060118f, -0.01331280f, -0.01424291f, -0.05418516f, 0.00472987f, -0.03958729f, 0.00073786f, 0.02229668f, 
    0.02457739f, 0.03483009f, -0.05933966f, -0.02312658f, 0.02355743f, 0.04433400f, -0.03281794f, 0.03582998f, 
    0.06337176f, -0.02140852f, -0.18142387f, 0.02185681f, -0.05283302f, 0.01847247f, 0.05542437f, -0.00412825f, 
    -0.08792962f, -0.00975410f, -0.21433038f, -0.18022619f, 0.19406293f, -0.01699678f, -0.02285881f, 0.00478299f, 
    0.03294477f, 0.09203406f, 0.32860145f, -0.02984421f, -0.17374669f, 0.09196722f, 0.12056608f, 0.09101908f, 
    0.02831126f, -0.02938787f, -0.09312528f, 0.03545213f, -0.15607415f, 0.11925799f, 0.04550208f, 0.00770845f, 
    0.14145185f, 0.08153994f, 0.06348988f, 0.15908214f, -0.16052146f, -0.15191354f, 0.06330805f, -0.12678149f, 
    0.05837379f, -0.19056851f, 0.02055329f, -0.03300095f, -0.40622166f, 0.10725012f, -0.21991827f, 0.12635392f, 
    -0.04974166f, -0.15290847f, 0.01931240f, 0.10977937f, 0.10130536f, 0.24698320f, 0.26274681f, 0.01243588f, 
    0.31831208f, 0.23550403f, 0.12989005f, 0.00768778f, 0.08529846f, -0.12758869f, -0.33871281f, -0.14782603f, 
    -0.13889503f, -0.05323485f, 0.17274486f, 0.12688291f, 0.09150627f, 0.14342631f, 0.08315491f, -0.06138154f, 
    -0.21659553f, -0.04017742f, -0.22213681f, 0.08292395f, 0.14713654f, -0.07554322f, -0.04087200f, -0.12995155f, 
    -0.20296896f, -0.10358116f, -0.02266861f, -0.19119617f, 0.20192614f, 0.10071654f, 0.12394983f, 0.16476931f, 
    0.00621919f, -0.02166330f, -0.24224983f, -0.16072413f, 0.02015431f, 0.14107242f, 0.21624677f, 0.07566703f, 
    0.09836006f, -0.01396036f, -0.03329455f, 0.31333828f, -0.01508510f, 0.20980483f, -0.12368712f, 0.06811223f, 
    -0.07603893f, -0.13873002f, 0.01511422f, 0.26919395f, -0.02441776f, 0.08764242f, 0.14147879f, 0.17439015f, 
    0.07732194f, 0.12513769f, 0.01712723f, -0.00263931f, -0.06917315f, 0.02977634f, -0.08837558f, 0.02320803f, 
    -0.12853441f, 0.15697929f, -0.27635032f, 0.19833821f, -0.02298287f, -0.06123579f, 0.01776695f, 0.00729830f, 
    0.21776086f, -0.18232280f, -0.15383919f, -0.20027940f, -0.01547411f, 0.12335197f, 0.09385282f, -0.01588274f, 
    -0.02684325f, -0.01386049f, -0.03906109f, 0.09050965f, 0.12318833f, -0.15487415f, -0.34206733f, -0.00947494f, 
    0.07364258f, 0.12001441f, 0.08587845f, 0.07468660f, 0.20605446f, 0.18335418f, 0.04784446f, 0.15663125f, 
    -0.00227483f, 0.10494971f, 0.05755400f, 0.02218020f, 0.13102944f, 0.10683957f, 0.15790062f, -0.06787243f, 
    -0.17190164f, 0.00362778f, 0.03966052f, -0.12696011f, 0.03188014f, 0.03079811f, 0.03434391f, 0.10614154f, 
    0.24593367f, -0.29771486f, -0.21393661f, -0.18125919f, -0.21913700f, -0.23848729f, 0.12572040f, 0.18015486f, 
    -0.24733554f, 0.15007080f, -0.07466917f, 0.20101927f, -0.00549433f, -0.05777437f, -0.27700675f, 0.10302159f, 
    0.13799660f, 0.05648901f, 0.12402763f, 0.10358201f, 0.06827065f, -0.11391185f, 0.14417151f, 0.02014647f, 
    0.22471541f, 0.28676200f, 0.04236897f, 0.01003272f, 0.13980432f, 0.10480868f, -0.02046940f, 0.23646656f, 
    0.24708079f, 0.22406842f, 0.08798869f, -0.22905099f, 0.06059810f, 0.24471536f, 0.09863686f, -0.08218858f, 
    0.06351628f, 0.08118485f, 0.22778268f, 0.08741707f, -0.02648013f, 0.15823951f, -0.50802839f, -0.12989232f, 
    -0.07205679f, 0.04416656f, 0.20132403f, 0.07391573f, 0.07024129f, 0.24538854f, 0.14055370f, -0.12025449f, 
    -0.03727514f, -0.06409534f, -0.01978316f, 0.36738530f, -0.10092383f, 0.07507171f, -0.00533200f, -0.03547828f, 
    0.07487348f, 0.02897055f, 0.02505151f, -0.23062992f, -0.10021393f, -0.15496612f, -0.03422251f, 0.04049341f, 
    0.16158369f, 0.04904387f, 0.06200434f, -0.08557259f, -0.01743086f, 0.02628274f, 0.06467834f, 0.02233759f, 
    -0.03945934f, 0.15787843f, -0.18007356f, 0.10547819f, 0.12613478f, -0.33053449f, -0.02774000f, -0.59034973f, 
    0.04856408f, 0.05576500f, 0.05739104f, 0.07030282f, -0.08887352f, 0.02527683f, -0.12804513f, 0.06877832f, 
    0.25230676f, 0.02786826f, 0.20523041f, -0.04688168f, -0.44862303f, -0.39151368f, -0.39817548f, -0.11562441f, 
    0.08269289f, -0.13742700f, -0.14917012f, 0.46452713f, 0.02485066f, 0.19458847f, 0.35540757f, -0.06155504f, 
    0.05203558f, 0.28673705f, -0.04590794f, 0.17809393f, -0.26986957f, -0.02056058f, 0.12785999f, 0.10269120f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05326689f, 0.26462001f, -0.00083504f, -0.03020620f, 0.20291668f, 0.14838900f, -0.01860331f, 0.19102862f, 
    0.22353187f, 0.11797047f, -0.06365024f, 0.17893758f, -0.04115326f, 0.13600467f, 0.02607405f, -0.21545827f, 
    0.09945666f, -0.14643787f, 0.27975217f, 0.28573543f, 0.28798822f, 0.04015303f, -0.01525916f, -0.11634031f, 
    0.37585753f, 0.22461131f, -0.08861975f, 0.08977968f, -0.02191205f, -0.00047129f, -0.04833953f, -0.09901584f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17148125f, -0.64068842f, 0.09140570f, 0.08363504f, 0.24428307f, 0.02506412f, -0.17064390f, -0.48837566f, 
    -0.23944113f, 0.30628866f, -0.09257136f, 0.31828713f, -0.14124128f, 0.09181082f, -0.14992973f, 0.58182752f, 
    0.18180959f, 0.41860038f, -0.27456686f, -0.01144539f, -0.08301228f, 0.13626936f, -0.05026467f, 0.15239346f, 
    -0.22298092f, -0.41803968f, 0.54516268f, -0.33942455f, 0.04469026f, -0.49853384f, -0.10769210f, -0.15928143f, 
    0.08737448f, -0.15436859f, -0.04346724f, -0.10715023f, 0.28194603f, 0.13610516f, -0.06818863f, 0.01572282f, 
    0.36275548f, 0.32161906f, -0.41467541f, 0.13972111f, -0.09580436f, 0.10457822f, 0.15523487f, 0.43937352f, 
    0.11181540f, -0.34074786f, -0.18215242f, 0.22754401f, 0.21845420f, 0.00055076f, -0.27876079f, -0.43024716f, 
    0.03193796f, 0.00453971f, -0.10916650f, -0.40488923f, 0.13654105f, 0.52742290f, -0.08477622f, -0.35913312f, 
    0.15879171f, 0.37704927f, 0.18366641f, -0.05393869f, 0.82389659f, -0.06042686f, 0.07292102f, -0.12741661f, 
    0.19694218f, -0.17115633f, 0.08506940f, 0.12592956f, 0.02287805f, 0.23087974f, -0.07168539f, -0.49998087f, 
    -0.37767228f, -0.71178299f, -0.06143688f, -0.16225559f, 0.22357891f, 0.13086332f, -0.17641281f, -0.04532717f, 
    -0.33580002f, -0.70846337f, -0.88531357f, -0.46032605f, 0.00423562f, 0.11933887f, -0.03348995f, 0.30902341f, 
    0.01054649f, -0.36753196f, -0.01936982f, 0.15453926f, -0.13446075f, -0.07007792f, -0.00150749f, 0.07823659f, 
    0.21360070f, -0.59028792f, 0.53897262f, 0.17589995f, 0.13662831f, 0.15838565f, 0.03159936f, -0.16787061f, 
    -0.31783724f, 0.44236934f, 0.15989931f, -0.83176607f, -0.74320430f, -0.17515235f, -0.69392908f, 0.24677341f, 
    -0.39617243f, -0.21544966f, -0.02218990f, -0.75208241f, 0.12821689f, 0.16349261f, -0.12606108f, 0.36469528f, 
    -0.11255459f, -0.30967298f, -0.08594775f, 0.12853496f, -0.69988632f, 0.37656751f, 0.04842900f, -0.13974771f, 
    -0.22356410f, 0.06238005f, 0.29740822f, 0.02382484f, 0.01793359f, -0.18773340f, -0.03750763f, 0.14061944f, 
    0.02598225f, -0.21576080f, -0.07986969f, 0.03382021f, -0.12461380f, 0.00580479f, -0.19927631f, 0.16238444f, 
    0.12912937f, -0.23055786f, 0.42807323f, 0.68789351f, 0.05111874f, 0.13897143f, -0.06948283f, 0.07624098f, 
    0.15560976f, 0.10345104f, -0.08997219f, 0.03471952f, 0.20549637f, 0.33535233f, -0.11382079f, -0.59996581f, 
    -0.18183374f, -0.18900104f, -0.41906631f, -0.28212607f, -0.12366266f, 0.44994044f, -0.05458932f, -0.12150709f, 
    0.30975014f, 0.31938201f, 0.16210343f, 0.18754669f, -0.13465159f, -0.14674300f, 0.38878319f, -0.40603811f, 
    -0.29122970f, -0.02066666f, -0.01575373f, 0.05008330f, -0.11019473f, -0.11713101f, -0.00721482f, -0.23935349f, 
    -0.15066978f, 0.64906430f, 0.05439246f, 0.10548413f, -0.51724309f, -0.18351939f, 0.12057788f, 0.24642688f, 
    -0.20009145f, 0.43324474f, -0.52235210f, -0.46561748f, -0.08813713f, -0.09026071f, 0.13735223f, -0.84210724f, 
    -0.57342941f, -0.05515597f, 0.01788640f, 0.12392987f, 0.11073572f, -0.10575953f, 0.00463302f, 0.31176427f, 
    -0.03980729f, -0.53230017f, -0.78675026f, -0.54284626f, -0.16990945f, -0.83997625f, -0.15981933f, 0.19062434f, 
    -0.01389173f, -0.19846748f, -0.09948007f, 0.04855367f, -0.91007948f, -0.05632943f, 0.00144041f, 0.22992788f, 
    -0.18584487f, -0.06572267f, 0.11464519f, 0.50730640f, 0.02922289f, -0.06863170f, -0.12117659f, 0.10008908f, 
    -0.16405496f, 0.24646768f, -0.35973218f, 0.11021513f, -0.10100854f, -0.16761550f, 0.34323180f, 0.03611158f, 
    -0.43297470f, 0.22576663f, -0.48792094f, 0.16850971f, 0.13344465f, 0.68149304f, -0.07156324f, 0.06098222f, 
    -0.06495956f, -0.05909189f, 0.11886494f, 0.16099049f, 0.19714242f, -0.45016649f, 0.10940110f, 0.64937526f, 
    0.05656313f, -0.21946584f, -0.59984291f, 0.22302173f, 0.01822326f, -0.44854325f, -0.04953366f, -0.09224549f, 
    0.19095719f, -0.08861712f, 0.32624239f, -0.21448743f, -0.30231044f, -0.01426919f, -0.06834980f, -0.25309938f, 
    -0.33844787f, 0.58098227f, -0.69631577f, 0.00879216f, -0.16568986f, 0.47432637f, 0.03577037f, -0.29629353f, 
    0.04200530f, -0.33750576f, -0.07058480f, 0.07539239f, -0.36161315f, 0.23377356f, 0.09211411f, 0.34397852f, 
    -0.16454971f, -0.65973485f, 0.02362463f, -0.35372499f, 0.04008718f, -0.01397892f, -0.18162981f, -0.60800409f, 
    -0.58939171f, -0.18020837f, 0.01554463f, 0.42667335f, 0.46949574f, 0.03767444f, -0.02044942f, 0.34806609f, 
    1.11581886f, -0.30203339f, 0.06761716f, 0.06922306f, 0.01430948f, -0.15462574f, -0.12682253f, -0.11793835f, 
    -0.14310932f, -0.18860009f, -0.08337499f, -0.06057638f, -0.07451156f, -0.87747747f, 0.05900339f, 0.01819290f, 
    0.09537817f, 0.37741730f, 0.53561121f, -0.61142123f, -0.05681583f, -0.45768782f, -0.03754760f, 0.07601331f, 
    0.21227300f, 0.42660588f, 0.17383854f, 0.42707562f, -0.59732616f, 0.07583714f, 0.18736392f, -0.30779955f, 
    0.22781129f, -0.33481199f, -0.97719246f, 0.70057803f, -0.12577049f, -0.20030409f, 0.11255414f, -0.24246171f, 
    0.00998404f, 0.23780875f, 0.08158574f, -0.01351420f, -0.51257420f, 0.14030731f, 0.06077229f, -0.11733650f, 
    0.30379429f, -0.09414756f, 0.47657850f, -0.68903661f, 0.13247542f, -0.44962367f, -0.04187372f, -0.03683999f, 
    -0.47189912f, -0.09941589f, 0.04746305f, -0.93471098f, -0.08149645f, 0.09550459f, 0.27395517f, 0.02200061f, 
    -0.60979450f, 0.61626428f, -0.14451261f, -0.00569492f, 0.03878155f, -0.84403217f, 0.10132311f, 0.26358947f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.42365727f, 0.13826784f, 0.03802243f, 0.13745812f, -0.24207021f, 0.16235398f, 0.09253944f, -0.47409993f, 
    -0.03593650f, 0.20479222f, -0.07877094f, 0.14684181f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
