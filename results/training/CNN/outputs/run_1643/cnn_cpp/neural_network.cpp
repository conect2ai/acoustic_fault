#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.02737457f, 0.30999038f, 0.50289309f, 0.76354873f, 0.78600341f, 0.20785899f, 0.39973569f, 0.01593426f, 
    0.11369841f, 0.54531199f, 0.12308411f, 0.41958311f, 0.02858639f, -0.05353693f, 0.66292161f, 0.11698539f, 
    -0.25872916f, 0.01228323f, 0.22329545f, -0.24451832f, 0.15964645f, 0.08921283f, 0.04068833f, 0.01704450f, 
    -0.05264033f, -1.62295377f, 0.89925182f, 0.06885391f, -1.72398782f, -0.36053333f, 0.00519753f, 0.05210524f, 
    0.12182471f, 0.33978105f, 0.67474318f, -0.14303640f, -0.40856919f, -0.27727270f, -0.23046537f, 0.37589526f, 
    0.15143517f, -0.17854941f, -0.14952326f, 0.00001983f, 0.03877933f, 0.01241084f, -0.26262137f, -0.68444443f, 
    -0.45893937f, -0.84923220f, -1.04341316f, 0.00906915f, -0.94646347f, -0.68548989f, -0.52426320f, 0.07309988f, 
    0.42219996f, 0.48512700f, 0.75836813f, 0.92698538f, 0.20006801f, 0.39924869f, 0.09170841f, 0.25257343f, 
    -0.02619078f, 0.08397408f, -0.35867673f, -0.36057043f, -0.22910848f, -0.36941272f, -0.25342619f, 0.09765960f, 
    0.11056369f, -0.19872788f, -0.13448994f, -1.40600324f, 0.01987639f, -0.31031859f, -1.25619090f, 0.04024308f, 
    -0.06680696f, -0.32065025f, -0.27594557f, -0.40798497f, -0.85200870f, -0.10484155f, 0.89984107f, 0.00419322f, 
    0.98076475f, -0.75662875f, -0.51556265f, -0.82689375f, -0.48205465f, -0.24487345f, -0.44025040f, -0.06588485f, 
    0.34214246f, -0.32551757f, 0.26198426f, -0.07920997f, -1.59795988f, -0.46635473f, -0.94499230f, -1.33237016f, 
    -1.27337933f, 1.11192417f, 0.25351104f, -0.22124380f, -0.14312141f, 0.30913323f, -0.50358927f, -0.06874563f, 
    -0.41243285f, -0.75915766f, -0.39137316f, 0.36379403f, 0.16756292f, 0.17919271f, 0.18048833f, 0.10393452f, 
    -0.05494408f, 0.20260289f, 0.22779873f, 0.05602520f, 0.27680692f, 1.11211848f, 0.84114403f, 0.61638039f, 
    0.30541915f, 0.04379195f, -0.92141426f, -0.65533048f, -0.05110658f, -0.14309672f, -0.03491496f, -0.23784396f, 
    -0.38896114f, 0.10187633f, -0.17194140f, -0.67061973f, -0.05039395f, 0.07140287f, -0.21446997f, 0.41065472f, 
    -0.17089152f, -0.20700057f, -0.07226375f, 0.08938255f, 0.06904513f, 0.23012100f, 0.08949971f, 0.49261907f, 
    0.36985582f, -0.05525984f, -0.86631298f, 0.33649212f, 0.11124064f, -0.24125797f, -0.33645472f, -0.03421222f, 
    0.47103226f, -0.47681090f, 0.33778158f, -0.36341003f, 0.14135826f, 0.05080724f, -0.02733054f, 0.06383802f, 
    0.52329135f, -0.76640344f, -0.48016122f, 0.10719977f, 0.38608065f, 0.35401335f, 0.74361861f, -0.95261538f, 
    -0.09956682f, -0.29143983f, -0.36509418f, -1.09373188f, -0.41038328f, 0.98584241f, -1.51880336f, -1.13477707f, 
    0.60811150f, 0.19296606f, -0.15963949f, 0.64618421f, 0.19841981f, -0.07750046f, -0.08659317f, 0.10046430f, 
    0.15167007f, 0.16135770f, 0.05063313f, 0.38499790f, 0.43490770f, 0.01172584f, -0.20644081f, -0.27615941f, 
    -0.33470553f, -0.21340661f, 0.27597949f, 0.20695491f, -0.43852574f, -0.67398006f, -0.69158447f, -0.92330164f, 
    0.30998364f, 0.70363283f, 0.00747478f, -0.53252828f, -0.69199514f, -0.33518085f, 0.28885362f, -0.76836956f, 
    -0.22955742f, -0.69375074f, -0.71020603f, -0.66836262f, -0.57726306f, -0.42019063f, -0.08204766f, -0.38421014f, 
    -0.48181450f, 0.09503379f, -0.39872187f, 0.02254806f, 1.48545730f, 0.80208379f, -0.03648121f, -0.18156072f, 
    -0.94490767f, -0.77618647f, -0.17299810f, -0.31388912f, 0.64634621f, -0.35324246f, -0.20800218f, -0.02645994f, 
    0.08592232f, 0.25485680f, -0.14934605f, 0.58192360f, 0.36474338f, -0.02779927f, -0.30487683f, 0.05413567f, 
    -0.23807378f, -0.57289809f, 0.54378128f, 0.95133543f, -0.24701978f, -0.49981549f, -0.43808302f, 0.41363969f, 
    0.73476678f, -0.46030974f, -0.30672720f, -0.10685611f, 0.22512709f, 0.12128592f, 0.00622509f, -0.12055036f, 
    -0.07916231f, 0.01897806f, -0.04323756f, 0.41863704f, -0.14518410f, -0.21820626f, -0.17523465f, -0.01927672f, 
    -0.12327129f, 0.01603368f, 0.26397532f, -0.66619521f, 0.02285613f, 0.26170707f, 0.69655442f, 0.19915169f, 
    -0.07111061f, -0.36553234f, -0.22998896f, 0.60250258f, 0.06474672f, -0.42162415f, -0.07331973f, -0.04608307f, 
    -0.42254731f, 0.64749205f, 0.01222492f, 0.37340572f, 0.06892726f, -0.10969438f, -0.65381181f, 0.20783950f, 
    0.09456725f, 0.11131313f, 0.12820336f, -0.20422003f, 1.62212479f, 0.16769935f, 0.02434544f, -0.23520735f, 
    -0.93953848f, 0.35953584f, 0.70595837f, 0.60733664f, -0.01629221f, 0.02773712f, -0.10285347f, 0.24327673f, 
    -0.57979751f, -0.86641186f, 0.04094376f, 0.18338731f, -0.13990770f, -0.01188177f, -0.24410048f, -0.15430838f, 
    0.14771777f, -0.07794517f, -0.17676805f, -0.23849308f, 0.06725877f, -0.11033575f, 0.48639950f, 0.34871057f, 
    -0.98412526f, -0.26819313f, -0.16446285f, -0.05105871f, 0.01416374f, 0.51781720f, 0.32016522f, -0.09012980f, 
    -0.79166347f, 0.61149383f, 0.06607943f, 0.10816889f, -0.22692576f, -0.52605665f, -0.04317005f, -0.05982406f, 
    0.77443630f, -0.14805870f, 0.25078577f, 0.05676851f, -0.21213652f, 0.37973690f, -1.05204821f, -0.94760346f, 
    -0.67294759f, -0.39255971f, -0.43549228f, -0.96181804f, -1.00800943f, -1.12429345f, -1.19659483f, -1.00626624f, 
    0.40821046f, -0.03584535f, -0.13118498f, -0.32924542f, -0.17926440f, -0.06891360f, 0.01741418f, 0.12935124f, 
    0.04352913f, -0.21486457f, -0.37153703f, -0.43901405f, 0.05764869f, 0.12641802f, -0.12041873f, -1.24264991f, 
    -1.48421705f, -0.16325702f, 0.69378668f, 0.65882355f, 0.65267396f, 0.39310220f, -0.00203494f, 0.58935767f, 
    0.88729924f, -0.00839764f, 0.13577984f, -0.23549244f, 0.09561101f, -0.41271955f, -0.20444860f, -0.48048329f, 
    0.08893774f, 0.15855980f, -0.46714404f, -0.03530917f, 0.33343300f, 0.14471564f, 0.39297897f, 0.32911098f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09397548f, 0.18542069f, 0.18558331f, 0.55259490f, -0.44674766f, 0.76632756f, 0.76910031f, 0.55017900f, 
    0.15575030f, 0.43256348f, 0.55508333f, 0.30372977f, 0.60996753f, 0.61751240f, -0.51219445f, 0.44734591f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15286879f, 0.02247777f, 0.08129627f, 0.12879044f, -0.05955532f, 0.10053546f, 0.06977496f, 0.02876293f, 
    -0.17377143f, 0.04149891f, -0.05578325f, 0.01179336f, -0.42856210f, 0.12843889f, 0.11802493f, -0.09228589f, 
    0.12151902f, 0.50323629f, 0.01084038f, 0.17320247f, 0.20520213f, 0.03443508f, 0.08186130f, 0.01364284f, 
    -0.15235355f, -0.22828758f, 0.14676157f, 0.06982135f, 0.09072084f, 0.14504710f, 0.00365999f, 0.00196994f, 
    -0.11577059f, 0.13075948f, -0.19251432f, 0.21283819f, 0.36479440f, 0.22076271f, -0.30839425f, -0.19013225f, 
    0.01652557f, 0.05625292f, -0.11551183f, 0.10495181f, 0.04919323f, -0.19243686f, -0.20007402f, -0.06130459f, 
    0.52379960f, 0.25035515f, -0.34798235f, -0.30686882f, 0.10038496f, 0.38055947f, -0.07801306f, 0.15059981f, 
    -0.01889795f, 0.01627934f, 0.05939225f, -0.01643186f, -1.10346699f, 0.29127547f, 0.18339634f, -0.15124834f, 
    -0.00010295f, -0.10911524f, -0.10612968f, 0.07837941f, -0.06811420f, -0.01037200f, -0.08165053f, 0.00696041f, 
    0.08800741f, -0.21152245f, -0.05231927f, 0.03620582f, -0.07758219f, -0.18136741f, -0.13206722f, -0.15942861f, 
    -0.19211838f, -0.25322813f, -0.10120700f, -0.01833010f, 0.41858959f, 0.32528409f, -0.21659312f, -0.20139849f, 
    -0.01485789f, -0.22981231f, -0.04779353f, -0.17244697f, 0.01664094f, 0.00581073f, 0.01932506f, 0.04753894f, 
    0.15584667f, 0.39249152f, 0.15807347f, -0.41723150f, -0.05773640f, -0.22099043f, -0.23403580f, -0.33535972f, 
    -0.12455951f, -0.17434058f, -0.05791353f, 0.14464523f, 0.13075158f, 0.18754160f, -0.05380423f, -0.23039144f, 
    -0.19774857f, -0.11879977f, -0.09222529f, -0.23600437f, -0.03200405f, -0.05643532f, 0.04635091f, 0.04299111f, 
    -0.09556215f, -0.31416833f, -0.47019199f, 0.18427902f, -0.12749650f, 0.06328714f, -0.05118030f, -0.01255762f, 
    -0.37163997f, -0.23480292f, -0.22711018f, 0.04389625f, -0.06983132f, 0.28073609f, 0.20652939f, -0.31847227f, 
    -0.04055408f, -0.33645469f, 0.00636384f, 0.09831920f, 0.02759225f, -0.01573737f, -0.00929190f, -0.05289933f, 
    -0.66858965f, -0.91601491f, -0.74299014f, -0.02072829f, 0.05320504f, 0.00786795f, 0.02114422f, 0.05679819f, 
    -0.07484800f, 0.07324373f, 0.21495774f, -0.12926139f, -0.38695821f, -0.12313879f, -0.00111805f, -0.09345677f, 
    -0.19912696f, -0.25980574f, -0.14905162f, -0.05407559f, -0.18300387f, -0.21037693f, -0.01947005f, -0.24152468f, 
    0.77060860f, 0.41460568f, -0.07295474f, -0.27487490f, 0.23716225f, 0.07506540f, -0.02311677f, 0.08836945f, 
    -0.00698143f, -0.08268847f, -0.03633535f, -0.01445722f, 0.29606012f, 0.35915372f, 0.00042885f, -0.24373303f, 
    0.08442252f, -0.02426825f, 0.24607180f, -0.08481817f, -0.05910194f, -0.08321180f, -0.19458821f, -0.38452768f, 
    0.09056427f, 0.14198191f, 0.20384881f, 0.23458058f, -0.16352032f, -0.10299583f, -0.09751771f, 0.02944470f, 
    -0.00651799f, 0.02795569f, 0.12879188f, -0.07132167f, 0.02904041f, -0.01633175f, 0.06691869f, -0.15567867f, 
    0.17840169f, 0.07453806f, -0.49514836f, -0.09820847f, -0.29247430f, 0.03831267f, -0.23097385f, -0.13972534f, 
    -0.90750688f, -0.22388816f, -0.34853584f, -0.38836345f, 0.03340141f, -0.02715589f, -0.00870620f, -0.06641422f, 
    0.06190710f, -0.12487195f, -0.05842166f, 0.09389081f, -0.29656965f, -0.55474341f, -0.19651359f, 0.39574006f, 
    -0.02395089f, 0.13070838f, 0.17428818f, 0.40885794f, 0.01264062f, -0.19783686f, 0.07746580f, 0.18741859f, 
    0.46310478f, 0.76942265f, 0.16044024f, -0.09235203f, -0.20114800f, 0.12011051f, -0.15172198f, 0.03214340f, 
    -0.04113419f, 0.05224588f, -0.17997947f, -0.09561336f, 0.29098681f, 0.12354150f, -0.05106158f, -0.14684404f, 
    -0.04885056f, -0.12126014f, 0.08751450f, -0.12683770f, -0.03765999f, -0.06524041f, 0.02275519f, 0.00722777f, 
    0.11469671f, 0.01400492f, 0.15526567f, -0.22073123f, 0.09105178f, 0.08860827f, 0.04324638f, 0.00369975f, 
    0.03937060f, 0.18231134f, -0.01912197f, -0.07889514f, -0.05623247f, -0.16588907f, -0.06708776f, -0.26808175f, 
    0.04301516f, 0.03509829f, -0.10400689f, 0.14426762f, -0.13340001f, -0.08402930f, 0.18089466f, 0.01353491f, 
    0.11984649f, 0.38149312f, 0.09298777f, -0.58088559f, 0.14537652f, 0.01449521f, -0.16612196f, 0.15719049f, 
    -0.01289732f, -0.08928395f, -0.22135624f, -0.36856091f, -0.08008108f, 0.17576712f, -0.22707570f, -0.35729307f, 
    0.03322676f, -0.22313671f, -0.14019620f, 0.20471030f, 0.06234925f, 0.06856446f, -0.00610580f, -0.09610897f, 
    0.19314831f, -0.24178550f, -0.06584477f, 0.04517654f, -0.06674416f, -0.05872130f, -0.11182436f, 0.00808424f, 
    0.27717984f, 0.24214911f, -0.16711706f, 0.14824753f, -0.58194005f, 0.06474373f, 0.14429739f, 0.03958670f, 
    -0.07897534f, 0.16350974f, 0.19740786f, 0.09797701f, -0.00248001f, 0.04510805f, -0.22892545f, -0.11855561f, 
    1.30088413f, -0.03122387f, 0.21253647f, -0.07111113f, -0.15657142f, 0.03502966f, 0.00560447f, 0.05254639f, 
    -0.14078400f, 0.02836804f, -0.20730297f, 0.07024170f, 0.03103440f, 0.01160839f, -0.09106065f, -0.00483740f, 
    0.09865355f, 0.04984435f, -0.02924441f, 0.08833209f, -0.11969751f, 0.20328106f, 0.02838879f, -0.12027356f, 
    0.10370222f, 0.04498128f, 0.19688572f, -0.10981618f, -0.18153855f, -0.16472094f, -0.10745862f, 0.00532720f, 
    -0.00452558f, 0.04357516f, 0.01181362f, 0.09300195f, 0.03120639f, 0.13579103f, -0.16642161f, 0.05519418f, 
    -0.15580997f, 0.04477621f, 0.05992783f, -0.06382822f, -0.07513802f, 0.07184687f, -0.05321640f, 0.08149879f, 
    -0.10119952f, -0.05209051f, 0.06146606f, 0.15515657f, -0.05140437f, -0.05795711f, 0.03037931f, 0.10808866f, 
    -0.10900319f, -0.11109594f, -0.08403790f, -0.08041198f, 0.43431720f, 0.27045551f, 0.11851865f, 0.49907279f, 
    -0.02819602f, -0.04338003f, -0.06299204f, -0.15625106f, -0.16359574f, 0.20783003f, 0.01119616f, 0.07005157f, 
    0.33855712f, 0.63247764f, 0.14770234f, 0.31823075f, -0.08194716f, 0.08947822f, 0.07253700f, -0.17256497f, 
    -0.06912383f, -0.10043979f, 0.05625948f, 0.04063037f, 0.31910977f, -0.06578708f, -0.21000092f, 0.18970294f, 
    0.19347614f, -0.06087633f, 0.14910373f, -0.03182413f, -0.17528483f, -0.31065518f, -0.05583958f, -0.09534962f, 
    -0.58644640f, 0.31500864f, 0.76274544f, 0.83734244f, -0.05564548f, 0.01896693f, -0.02294529f, 0.06369464f, 
    0.01257307f, -0.07363278f, -0.13761576f, 0.00265611f, -0.83504021f, 0.01790737f, 0.67839324f, -0.20509493f, 
    0.03091978f, -0.00317881f, 0.07558276f, 0.02691810f, 0.01985794f, -0.04752485f, -0.01223211f, -0.04712103f, 
    -0.15249160f, 0.09005430f, 0.06582961f, -0.26575211f, 0.02595259f, 0.13692327f, -0.05237276f, 0.00060502f, 
    -0.10263795f, -0.12954322f, 0.14674787f, -0.02046249f, 0.22147292f, -0.85915107f, 0.24284533f, 0.12671895f, 
    0.30094016f, 0.04463352f, -0.04597236f, 0.05637139f, 0.08233242f, -0.02778736f, 0.15798821f, 0.01023698f, 
    0.02739126f, -0.19093710f, 0.41822162f, 0.08914722f, 0.01353654f, -0.11121687f, -0.01822882f, -0.01723633f, 
    -0.04851062f, 0.04834591f, 0.01877039f, 0.12129378f, -0.23485298f, 0.04713702f, -0.25943717f, -0.39539224f, 
    0.13454023f, -0.08154547f, -0.22586793f, 0.06250083f, 0.10106788f, 0.03999199f, -0.12856840f, 0.07098354f, 
    0.08650758f, -0.09991995f, 0.24587013f, -0.42639741f, 0.13993974f, -0.07469038f, -0.05088881f, 0.03586160f, 
    0.01440370f, -0.00709192f, 0.29182073f, -0.19076791f, -0.30553174f, -0.00061736f, -0.32701603f, 0.34725833f, 
    0.15439130f, 0.08269068f, 0.08171387f, -0.06427855f, -0.01425847f, -0.27077243f, 0.04254520f, -0.03247792f, 
    -0.52594954f, 0.13921203f, -0.04087488f, -0.37622944f, -0.01166021f, -0.07274367f, -0.00191815f, -0.01907389f, 
    0.12588905f, 0.04583042f, -0.21960910f, 0.22383076f, 0.01744479f, 0.13643314f, -0.08926010f, 0.19674028f, 
    0.17176755f, 0.15210487f, -0.15864664f, 0.21689494f, -0.15325180f, 0.02090352f, 0.03699859f, -0.16248730f, 
    -1.70261979f, -0.71567541f, -0.20229855f, -0.56151271f, 0.03101783f, 0.04350632f, -0.25386596f, -0.27062127f, 
    -0.08146959f, 0.04910605f, 0.02324155f, -0.11612935f, -0.33769554f, -0.22102508f, 0.15143183f, 0.26716283f, 
    0.00474330f, 0.02742603f, 0.01697011f, -0.02515028f, -0.00448323f, -0.25879827f, -0.13373815f, -0.28574750f, 
    -0.53082055f, -0.11698271f, 0.00081438f, -0.32622850f, 0.13953824f, -0.04905332f, -0.35697198f, -0.19290751f, 
    0.16195206f, -0.06429034f, -0.01970022f, 0.08684034f, 1.17731690f, -0.46357068f, 0.04259767f, 0.34441155f, 
    0.11733058f, 0.01668243f, 0.05991541f, -0.13385417f, -0.16175421f, -0.01163663f, 0.04055455f, 0.11332448f, 
    0.65974450f, -0.26441044f, 0.06770200f, 0.31175044f, 0.09085784f, 0.14182025f, 0.01054298f, -0.15149266f, 
    -0.15431131f, -0.09013078f, -0.02475277f, -0.06340396f, 0.05587379f, -0.23413414f, -0.20454195f, 0.18344636f, 
    0.09234276f, -0.17898846f, 0.04174235f, 0.02554028f, -0.16471462f, -0.03371580f, 0.04574939f, -0.12368368f, 
    0.21436839f, -0.38351479f, 0.00278604f, 0.48941961f, 0.20354079f, 0.00223003f, -0.14562957f, -0.12299727f, 
    -0.20195159f, 0.07436571f, 0.07976580f, 0.11518356f, -0.46815801f, -0.20479316f, 0.35622177f, 0.29090852f, 
    -0.41824099f, -0.13210693f, -0.37133288f, -0.25456151f, 0.06597467f, 0.02142142f, 0.14610666f, 0.02948375f, 
    -0.13577881f, -0.00738341f, 0.46154147f, 0.00631211f, -0.14721282f, -0.01945440f, -0.32350066f, -0.25501692f, 
    -0.02174153f, -0.10865150f, 0.08463386f, -0.33057645f, -0.06040186f, -0.27056348f, 0.02173648f, 0.08410848f, 
    0.12680179f, 0.05609933f, -0.09547397f, -0.26352656f, 0.01830595f, -0.24433060f, -0.14455602f, 0.22084905f, 
    0.14687142f, -0.10988079f, 0.18385629f, 0.15694746f, -0.19372141f, -0.00293526f, -0.29465041f, -0.11164822f, 
    0.01630020f, 0.14643441f, 0.05441077f, -0.13177434f, -0.06325538f, 0.76957893f, -0.35838336f, 0.49489909f, 
    0.04434928f, 0.01877661f, 0.15277010f, -0.07675206f, 0.22162153f, -0.09004840f, 0.03180626f, 0.37885371f, 
    -1.20141792f, 0.16222310f, -0.50676250f, 0.17130621f, 0.04688808f, -0.23607776f, -0.50495780f, -0.25789076f, 
    -0.09038777f, 0.07266477f, -0.07513183f, -0.17531696f, 0.59088808f, 0.32796830f, -0.33062309f, -0.62865770f, 
    -0.30796638f, -0.30816948f, 0.06657313f, 0.07870711f, -0.17980275f, 0.25731748f, -0.38154033f, -0.01094167f, 
    -0.72871572f, -0.24259378f, 0.14989468f, 0.32485726f, 0.23664150f, 0.33283386f, -0.00656766f, 0.03250511f, 
    -0.19281045f, 0.24659726f, 0.06099698f, 0.01820891f, 0.94480568f, -0.11305092f, -0.21556853f, 0.40331128f, 
    -0.12868612f, 0.03022836f, -0.40787953f, 0.03929462f, 0.16540581f, -0.13729335f, 0.06067782f, -0.61200517f, 
    -0.17927939f, -0.27317560f, -0.07409273f, 0.39140430f, 0.13880548f, 0.27210337f, 0.13054493f, 0.15319008f, 
    -0.00720134f, 0.02102336f, -0.16966456f, -0.15027919f, -0.42312029f, 0.23517184f, -0.16802926f, -0.68405664f, 
    0.47636357f, 0.12080545f, 0.25779477f, -0.09874035f, -0.24487603f, -0.10894545f, 0.15968250f, -0.01026211f, 
    -0.05366090f, -0.07112123f, -0.03556769f, -0.04620725f, 0.26123199f, 0.01928105f, -0.00218884f, 0.02287892f, 
    0.10846066f, 0.01601854f, -0.05016828f, 0.21187355f, -0.20299809f, -0.14795320f, -0.18848708f, 0.00989203f, 
    -0.08740999f, -0.17843288f, 0.01460024f, -0.09117151f, 0.27332699f, -0.01445736f, 0.26916540f, 0.20233704f, 
    0.14826930f, 0.23949951f, 0.02999246f, 0.04825164f, -0.06578398f, -0.03111943f, 0.01419776f, 0.04075951f, 
    0.13499144f, -0.24299446f, 0.04613325f, 0.00342320f, 0.29853055f, 0.07867488f, 0.27269554f, 0.13153881f, 
    -0.04127139f, -0.23030958f, -0.10375060f, -0.37845871f, 0.09874856f, -0.10221446f, 0.04892841f, -0.04031523f, 
    -0.13638543f, -0.12117094f, 0.18547541f, 0.20021495f, -0.14187998f, -0.24982034f, 0.03780381f, -0.21301186f, 
    0.09463976f, 0.01813415f, 0.11032040f, 0.02676448f, 0.25853825f, -0.16156532f, -0.14359891f, -0.01009663f, 
    -0.10675815f, 0.06492493f, 0.11757152f, 0.04884912f, 0.11666447f, 0.01583757f, -0.02497338f, -0.14213863f, 
    -0.10996249f, 0.22197235f, -0.22092114f, 0.26530197f, 0.08547169f, -0.04590207f, 0.04800672f, 0.16373079f, 
    -0.47298348f, -0.29546350f, -0.25067481f, -0.27407190f, -0.03737113f, 0.45095184f, 0.02952555f, 0.30948231f, 
    -0.25259596f, -0.06745553f, 0.10015414f, -0.07543886f, 0.10784616f, 0.09552281f, -0.10520940f, -0.06910107f, 
    0.00693032f, 0.17134021f, -0.30526796f, 0.09278503f, 0.10929774f, -0.01272387f, 0.13164543f, -0.16789947f, 
    -0.11116701f, -0.00494272f, 0.02279854f, 0.21631497f, 0.29209590f, -0.39781296f, 0.53348529f, 0.50631517f, 
    -0.36122456f, -0.13380301f, -0.17872591f, -0.14658642f, -0.14178471f, 0.05190241f, -0.05057715f, -0.02028152f, 
    0.10611024f, -0.02112635f, -0.29083997f, -0.02093017f, 0.24670494f, 0.02684292f, 0.04677892f, -0.07967091f, 
    -0.08481511f, -0.08180548f, 0.17022955f, 0.06335107f, 0.23591535f, -0.33957857f, 0.02542198f, 0.04777661f, 
    0.10927314f, -0.02327887f, -0.05308602f, -0.16964926f, -0.05496021f, -0.19956246f, 0.05663579f, -0.02223735f, 
    -0.31245530f, 0.39552298f, -0.81857616f, -0.50812203f, 0.19550793f, -0.01793922f, -0.05149940f, 0.06826943f, 
    0.11093169f, 0.17456768f, -0.09128539f, -0.05175698f, -0.28720519f, 0.11827414f, -0.18593550f, -0.22321704f, 
    -0.28470129f, -0.03038642f, -0.04434599f, -0.16777924f, -0.16717595f, -0.29690480f, -0.23887403f, -0.16391456f, 
    0.06852929f, 0.16119623f, 0.20225577f, 0.17622317f, -0.14900306f, 0.06025811f, 0.01245890f, 0.29910192f, 
    -0.07569053f, -0.00044209f, -0.11665035f, 0.05831265f, 0.32151058f, -0.11509031f, -0.09054802f, 0.01538586f, 
    -0.22202976f, 0.12862989f, -0.04434097f, 0.01751985f, 0.00079863f, 0.01239202f, -0.32932505f, -0.09288647f, 
    -0.14833370f, -0.17354339f, -0.05754203f, -0.05057871f, 0.04887436f, -0.16463916f, -0.07541814f, -0.03577573f, 
    0.21502326f, 0.01944301f, -0.03775427f, 0.10517429f, -1.01335597f, 0.33504629f, 0.11935914f, -0.33551669f, 
    -0.23866297f, -0.19900863f, 0.10283597f, 0.17621869f, -0.01997433f, -0.18480800f, -0.31072053f, -0.30834445f, 
    -0.60401976f, -0.61548591f, -0.24987753f, -0.00149569f, 0.02708580f, -0.03544487f, 0.01611061f, 0.08036787f, 
    0.02839356f, -0.02594415f, -0.09573688f, -0.10571303f, -0.02433815f, 0.37278563f, -0.00149555f, -0.46718961f, 
    0.09657474f, 0.28067639f, -0.13356699f, -0.25862485f, 0.03399432f, 0.17140810f, -0.01602549f, -0.11696689f, 
    -0.35554761f, -0.00043037f, -0.20551424f, -0.42884776f, 0.23798758f, -0.09795318f, 0.07389674f, -0.01510009f, 
    -0.01090856f, -0.06391025f, 0.03048364f, 0.05976013f, 0.20652092f, -0.22696562f, -0.42831713f, 0.41136277f, 
    0.17278318f, 0.04533376f, 0.02188182f, 0.05958607f, 0.02556016f, 0.03748002f, -0.08825611f, 0.01974282f, 
    0.15281923f, -0.06138169f, -0.50771582f, 0.06784448f, 0.08365507f, -0.00394806f, -0.02200201f, -0.11372142f, 
    0.26671645f, 0.03519234f, 0.20890261f, 0.30248550f, -0.09411702f, 0.14824243f, 0.30064151f, -0.37860379f, 
    0.18884091f, -0.08345669f, 0.14732668f, 0.52071822f, -0.05188959f, 0.07621461f, 0.07163750f, -0.13787210f, 
    -0.00676106f, -0.23875861f, 0.33599791f, 0.33318099f, 0.09055518f, -0.05415143f, 0.10047310f, 0.14033447f, 
    0.15602295f, 0.06473875f, -0.29363692f, -0.18348809f, 0.04273724f, -0.10339629f, 0.29559475f, -0.10851362f, 
    -0.01126610f, -0.17480019f, 0.10766308f, 0.09785679f, 0.04161027f, 0.04383256f, 0.03684075f, -0.17062671f, 
    -0.08756545f, 0.26588175f, -0.56134236f, -0.17300418f, -0.06011432f, 0.19529083f, 0.00164738f, -0.09232345f, 
    0.23623432f, -0.17247349f, -0.10934381f, 0.02655868f, -0.02780174f, -0.19372854f, 0.24493121f, 0.42823476f, 
    -0.01603503f, 0.15928511f, -0.02370583f, 0.01701940f, 0.03069104f, 0.13092205f, 0.35769734f, 0.15559846f, 
    -0.21542171f, -0.22555596f, -0.72539860f, 0.25647295f, 0.06071921f, -0.02900681f, 0.00463348f, 0.08384652f, 
    0.19317606f, -0.30571914f, -0.15730000f, 0.10464005f, -0.28674266f, -0.09177514f, 0.04256745f, 0.22577973f, 
    0.19409637f, 0.00864534f, 0.03896340f, -0.11800389f, 0.25088066f, 0.00539669f, -0.01542034f, 0.41732699f, 
    0.09268649f, 0.30586305f, 0.28875226f, -0.03016965f, 0.20731245f, 0.13252462f, 0.02826301f, -0.36000162f, 
    0.06257311f, -0.08709642f, 0.06954684f, 0.03670283f, -0.38938478f, -0.61996335f, 0.28440541f, -0.02890222f, 
    -0.15500006f, -0.15978345f, -0.12063313f, -0.15349999f, 0.35731250f, -0.10514659f, -0.03240039f, 0.11860649f, 
    -0.02046404f, -0.24043950f, -0.20099366f, -0.11281397f, 0.13394995f, -0.01791036f, 0.04244823f, 0.06456303f, 
    0.04661420f, -0.46297848f, -0.21356185f, -0.31832346f, 0.31668857f, -0.21305482f, 0.10452714f, 0.14859037f, 
    -0.15092295f, 0.05406821f, 0.00030426f, 0.09064227f, 0.07085501f, -0.01394779f, 0.05153877f, 0.15586902f, 
    -0.12664615f, 0.76324958f, 0.63026297f, 0.12732390f, -0.08009488f, -0.11236892f, -0.15563516f, 0.25593308f, 
    -0.05744316f, 0.31093869f, 0.31792173f, 0.05966335f, -1.60267222f, 0.04769703f, 1.07751131f, -0.35467848f, 
    -0.11975843f, -0.20881048f, -0.29124790f, -0.30784935f, -0.21355920f, 0.09510843f, -0.07577247f, 0.07317194f, 
    -1.08821309f, -1.09147370f, 0.34376121f, 0.18913871f, 0.11643830f, -0.35673836f, -0.10004161f, -0.15327607f, 
    -0.10679386f, 0.04436719f, -0.00234998f, -0.18877181f, 0.03456100f, -0.30196881f, -0.35826522f, -0.35573861f, 
    0.05013178f, 0.19259410f, 0.17566276f, -0.10930683f, -0.10256108f, 0.02392039f, -0.11976642f, 0.01765047f, 
    0.32417136f, -0.09393731f, 0.09385497f, -0.06043009f, 0.05128461f, -0.08027033f, 0.24671076f, 0.10713166f, 
    0.04478849f, 0.13643335f, -0.24245371f, -0.26297143f, -0.86048001f, -0.81685275f, -0.08001473f, -0.38877836f, 
    -0.14896320f, 0.00745875f, 0.05169364f, -0.35403386f, 0.10378801f, 0.11479292f, -0.17641909f, -0.01378925f, 
    -0.00424756f, -0.05923491f, -0.73994154f, -0.17143360f, -0.07799453f, 0.03230609f, 0.10764610f, 0.28843683f, 
    -0.11664538f, 0.16938415f, 0.27023181f, 0.02643629f, -0.47628546f, -0.55502307f, -0.27339339f, 0.43648228f, 
    0.19375454f, 0.38614932f, 0.14759375f, -0.05341775f, 0.13412453f, 0.02139054f, 0.31419262f, 0.09220283f, 
    0.45555478f, -0.11432739f, 0.25386727f, -0.02610297f, 0.23731774f, 0.07223260f, 0.23373899f, -0.03728299f, 
    0.09169365f, -0.08954398f, -0.08045773f, 0.13134356f, 0.03764959f, -0.31460679f, -0.09465373f, -0.16951294f, 
    -0.06679083f, 0.27465823f, -0.33521867f, -0.13765685f, 0.04920055f, -0.00989497f, -0.02783448f, -0.09364494f, 
    0.16369133f, 0.32226163f, -0.25490457f, 0.24127115f, 0.07736795f, -0.17015116f, 0.03199564f, -0.13125625f, 
    0.00806391f, -0.06078228f, 0.36838001f, -0.15291227f, 0.41000465f, -0.06731118f, 0.01557679f, 0.64044803f, 
    0.06085761f, -0.09444450f, 0.05566367f, 0.18362743f, -0.07088888f, -0.26199165f, 0.09077045f, 0.21168403f, 
    -0.76085639f, -1.00306416f, -1.05951846f, -0.13030617f, -0.47348079f, -0.02830656f, 0.06262539f, -0.43586037f, 
    -0.03487683f, -0.00473872f, 0.03257064f, 0.05853999f, -0.33575410f, -0.12988006f, 0.37225747f, 0.06164071f, 
    -0.02542252f, -0.26193064f, -0.11795133f, 0.19351916f, -0.16165516f, 0.13385668f, 0.14322275f, -0.03103384f, 
    0.18785182f, 0.00118793f, 0.11272564f, -0.20046520f, 0.06495127f, -0.04389039f, -0.05568408f, -0.17719746f, 
    -0.00047614f, 0.00746405f, -0.09175133f, -0.07794329f, 0.42090118f, -0.24034187f, -0.40120742f, -0.39516926f, 
    -0.08550478f, -0.13400933f, 0.14740184f, 0.08986206f, 0.03956134f, -0.11504717f, -0.11448029f, 0.20214552f, 
    1.19633412f, -1.20943689f, -0.48286039f, -0.40845156f, -0.17480496f, -0.01075057f, -0.00666782f, -0.11046444f, 
    0.28196225f, 0.04699912f, 0.04879932f, 0.02177254f, -0.70619297f, 0.23325211f, -0.48991179f, 0.83193201f, 
    0.19671597f, -0.00132870f, -0.13491789f, 0.06862387f, -0.09695143f, 0.13797970f, 0.15012211f, 0.13204713f, 
    -0.83223557f, -0.77673203f, -1.08965087f, -0.97045141f, -0.08882559f, -0.05868790f, -0.27508292f, 0.37070361f, 
    0.11218493f, 0.04324544f, -0.03729345f, -0.01934895f, -0.33729291f, -0.09271359f, -0.15969053f, -0.12637590f, 
    0.01937929f, -0.04929027f, -0.10759886f, -0.12826513f, 0.10648490f, 0.12090449f, -0.02442408f, 0.01965128f, 
    0.01233531f, 0.22223265f, -0.03076669f, -0.19599096f, -0.54308408f, 0.13263580f, 0.07240751f, 0.01499387f, 
    -0.13747591f, -0.08180410f, 0.07329828f, -0.06276488f, -0.47210389f, -0.78322482f, 0.37506256f, -0.44274431f, 
    0.28152281f, -0.14696445f, -0.14828496f, -0.21993302f, 0.03106403f, -0.01646689f, 0.00912539f, -0.03179581f, 
    0.15297025f, -1.03772700f, 0.01784352f, 0.34027821f, -0.14633614f, -0.08011229f, -0.31819469f, 0.13576077f, 
    0.24259873f, -0.18483260f, 0.09999888f, 0.00249601f, -0.00779162f, -0.05347724f, 0.02212212f, -0.22767149f, 
    -0.09961058f, -0.06138864f, 0.06524891f, -0.28295407f, -0.15452193f, 0.03574568f, 0.15215504f, 0.02255557f, 
    0.01307609f, 0.14324641f, 0.10711747f, 0.06198897f, -0.07504659f, -0.08273440f, 0.02535789f, 0.00797241f, 
    0.12137217f, -0.42569000f, 0.18379602f, -0.07073555f, 0.50216383f, -0.23114632f, -0.01161121f, -0.30775815f, 
    -0.03730835f, -0.18182255f, -0.10833243f, 0.10606784f, -0.08475712f, 0.09053976f, 0.09234378f, 0.02899526f, 
    -0.02520804f, -0.00052231f, 0.34881631f, 0.10044555f, 0.09569748f, 0.00186571f, 0.03301397f, -0.03101105f, 
    -0.04639547f, -0.00375122f, 0.13006146f, -0.08418710f, -0.12305252f, -0.11126041f, -0.17540781f, -0.06764774f, 
    -0.10297979f, 0.18999727f, -0.02247060f, -0.10075185f, -0.12518181f, -0.02145310f, 0.11995387f, -0.04501674f, 
    -0.58950675f, -0.56185526f, 0.26937741f, -0.07610506f, -0.02206352f, 0.04850393f, 0.14264560f, 0.33073881f, 
    -0.01010067f, -0.01197034f, -0.16641808f, -0.02103418f, 0.56227803f, 0.03863290f, -0.05467138f, -0.44470698f, 
    0.13469887f, 0.15049802f, 0.05064791f, 0.07447266f, -0.09563076f, 0.03394133f, 0.01931124f, -0.23705366f, 
    -0.00911437f, 0.07276049f, 0.06408468f, -0.22040515f, -0.16815530f, -0.07019629f, 0.02224637f, 0.00497504f, 
    -0.09965491f, 0.02497692f, 0.07316878f, 0.02988163f, -0.30753514f, -0.41011465f, 0.01192545f, 0.28314933f, 
    0.17077591f, 0.09305912f, 0.00245912f, 0.18651386f, -0.40360317f, -0.08761064f, -0.17970285f, -0.77279425f, 
    -0.65587848f, -0.32669666f, -0.25949574f, -0.04998858f, -0.00796718f, 0.30986083f, 0.05460925f, 0.16238482f, 
    -0.06157885f, 0.04969398f, -0.38895950f, -0.20600179f, 0.01860828f, -0.76488471f, -0.81759441f, 0.12847003f, 
    -0.14240751f, 0.32805499f, 0.24232797f, 0.25667617f, 0.10584382f, 0.27209178f, 0.00772660f, -0.01757216f, 
    -0.17740299f, -1.15375257f, -0.60937887f, 0.60581779f, 0.31664073f, 0.20873353f, 0.20037869f, -0.07589962f, 
    -0.14577599f, -0.02046134f, -0.02871895f, -0.01455894f, -0.22183017f, 0.32995445f, 0.28559086f, 0.30621353f, 
    0.05200695f, -0.19931090f, -0.09335022f, -0.13910097f, -0.01934355f, -0.05103216f, 0.01469710f, 0.03567252f, 
    -0.20788735f, -0.02512514f, -0.05574952f, 0.18616255f, -0.02987006f, -0.05717609f, -0.14408073f, 0.23533863f, 
    0.46703571f, 0.17434019f, 0.26872689f, 0.25661218f, 0.04901677f, -0.60289109f, 0.01661636f, 0.16380788f, 
    0.08451205f, 0.32131994f, 0.17008351f, 0.12766632f, -0.30106431f, 0.00578489f, 0.03063306f, 0.08365565f, 
    0.26141652f, -0.13847815f, 0.03095451f, -0.49767852f, 0.23514497f, 0.04213084f, 0.05741924f, 0.12971167f, 
    0.15758573f, -0.09925099f, -0.06196189f, -0.36793154f, 0.03554713f, 0.14750399f, 0.18219391f, -0.29600158f, 
    0.07851756f, 0.07997951f, 0.02015984f, -0.46050510f, -0.16574037f, -0.02395790f, -0.28561476f, -0.32575479f, 
    -0.69367361f, -0.05042423f, 0.19066900f, 0.26179802f, -0.05997584f, 0.12576123f, 0.15950240f, 0.08000682f, 
    0.01202579f, 0.05820681f, 0.15609667f, -0.06909053f, 0.25910822f, 0.04341807f, -0.12464514f, -0.25410360f, 
    0.29097223f, -0.09491860f, -0.04699875f, -0.05414454f, 0.11833159f, 0.12662287f, -0.02729499f, 0.21133596f, 
    -1.49337423f, 0.07281651f, 0.34121069f, 0.03661681f, -0.21462682f, 0.03636650f, -0.24222420f, -0.11689217f, 
    -0.06897706f, 0.07680562f, 0.06065123f, 0.32015598f, 0.00269265f, 0.08744993f, -0.18251078f, 0.01456290f, 
    0.14528397f, 0.00283162f, 0.21058533f, 0.26020867f, -0.09100797f, 0.29436457f, 0.14060980f, 0.31302670f, 
    -0.15502821f, -0.33275738f, -0.40372479f, -0.86777902f, -0.03782048f, -0.24034588f, -0.01101757f, -0.24840529f, 
    0.04358757f, 0.06976059f, -0.05443191f, -0.02572222f, 0.03878091f, -0.12074818f, -0.36242011f, -0.11926306f, 
    -0.20874594f, -0.20066878f, -0.00490406f, -0.04390242f, 0.25472602f, 0.17245488f, 0.18338665f, 0.25009796f, 
    -0.01179473f, -0.37247971f, 0.05895019f, 0.00404982f, 0.03033063f, 0.27014413f, -0.01435870f, -0.16568916f, 
    0.03339203f, 0.04335447f, 0.08964323f, -0.14420490f, -0.39354664f, 0.18896224f, 0.14872341f, -0.00288050f, 
    -0.27810442f, -0.18055630f, -0.08310983f, -0.36146361f, 0.08175086f, 0.05710906f, 0.10029335f, 0.21703711f, 
    0.20580147f, 0.21751250f, 0.36041114f, 0.05899761f, -0.10676882f, -0.37807423f, -0.14004950f, -0.34439445f, 
    -0.08929843f, 0.16763583f, -0.08022285f, 0.15711948f, -0.61768752f, 0.52542222f, 0.16517363f, -0.20326619f, 
    -0.11062065f, -0.19111992f, -0.13246892f, 0.01854807f, 0.03419609f, -0.06912693f, 0.09790602f, 0.05124411f, 
    -0.36116356f, -0.04091449f, 0.11617086f, -1.12090158f, -0.20308837f, 0.03870183f, 0.00665205f, 0.07613613f, 
    0.19213249f, -0.12147962f, 0.01136656f, -0.01563206f, -0.23262332f, -0.28047165f, -0.81468880f, 0.43553731f, 
    0.30648121f, 0.22148176f, 0.18382852f, -0.04373217f, 0.00914552f, -0.04031698f, 0.02189417f, 0.14124127f, 
    0.15474086f, -0.06343874f, -0.14508177f, -0.42872080f, -0.25610968f, 0.14249909f, 0.17431423f, 0.42283508f, 
    0.05608496f, -0.24076913f, -0.46825695f, -0.08047109f, 0.30857223f, 0.58732164f, -0.15333606f, -0.40954465f, 
    -0.29717776f, 0.18797626f, -0.22369225f, -0.05356457f, 0.08793510f, -0.20316376f, -0.22777283f, 0.08127908f, 
    -0.06298362f, -0.30867526f, -0.07004820f, 0.06929674f, -0.16190825f, 0.12483411f, 0.13549417f, 0.06052408f, 
    0.04685099f, 0.16705279f, 0.24595106f, 0.09171274f, 0.66138059f, -1.14574564f, 0.02493611f, -0.53214222f, 
    0.05865496f, 0.22564781f, -0.08804310f, 0.16372465f, -0.06495007f, -0.06344907f, 0.06207532f, -0.02257422f, 
    -0.09795254f, 0.23150180f, -0.11394393f, -0.17629930f, -0.23792151f, -0.14639103f, 0.17727083f, 0.30319655f, 
    0.14304666f, 0.31555489f, -0.22130473f, -0.03679892f, 0.22594842f, 0.04227871f, -0.75807214f, 0.33887824f, 
    -0.14939658f, -0.21449465f, -0.09719791f, 0.08694729f, 0.01162287f, -0.33885366f, -0.06525808f, 0.00143370f, 
    -0.11566348f, -0.12608497f, -0.13343354f, -0.53098446f, -0.08537916f, 0.18541121f, 0.18685371f, 0.14990021f, 
    0.03218616f, -0.00162695f, 0.19990158f, 0.01026765f, -0.38543627f, 0.66168237f, -0.31856692f, -0.86090291f, 
    0.06287739f, -0.03708468f, 0.05120791f, -0.11437243f, 0.15157157f, -0.09039347f, -0.27824467f, -0.16546348f, 
    -0.28843191f, -0.13949592f, 0.42709029f, 0.06339167f, -0.01003655f, -0.17993179f, 0.17928308f, 0.40855843f, 
    0.08573674f, 0.13600643f, 0.08511858f, -0.12008061f, 0.36882800f, -0.07678877f, 0.60453475f, 0.75145972f, 
    0.24041378f, 0.14312612f, -0.22833939f, -0.02307425f, -0.19768539f, -0.16580698f, -0.09143665f, 0.10325594f, 
    -0.43204847f, -0.09485440f, -0.01424732f, -0.48065615f, -0.11969841f, 0.11777841f, 0.07867909f, -0.10791036f, 
    0.00554454f, 0.07961193f, -0.00655404f, -0.02771332f, 0.58148748f, -0.12944661f, -0.14510113f, -0.26229385f, 
    0.04711376f, -0.37312293f, 0.00985100f, 0.08815164f, 0.04145980f, -0.00747846f, -0.23920757f, -0.65862674f, 
    -0.15486488f, 0.11217029f, 0.21011007f, -0.60073638f, 0.15592967f, -0.44222626f, 0.09536742f, -0.05894785f, 
    -0.27342233f, -0.07571116f, -0.37436596f, -0.18484113f, 0.36024117f, 0.35035765f, 0.74174583f, -0.19864370f, 
    -0.05165219f, 0.10599078f, 0.04803301f, -0.01742550f, 0.04836619f, 0.22842102f, 0.23619996f, -0.13554752f, 
    0.22386912f, -0.56616938f, 0.20208322f, 0.14945562f, -0.10393378f, -0.12635040f, 0.20538123f, 0.20877025f, 
    -0.18712965f, 0.10985658f, 0.11290644f, -0.17235389f, 0.09301985f, -0.14413032f, -0.42813006f, -0.18793967f, 
    -0.40601635f, -0.11713549f, -0.21893553f, 0.18047184f, 0.13263775f, 0.24050529f, 0.20399415f, -0.05230083f, 
    0.46315017f, -0.64479727f, 0.17282639f, 0.49657235f, -0.07732834f, 0.01850131f, 0.03687198f, -0.34893158f, 
    0.17921804f, 0.20876475f, 0.17686959f, 0.47320977f, -0.19708785f, -0.19933216f, 0.42269164f, 0.15999904f, 
    -0.08569060f, -0.10007773f, 0.13031997f, -0.08537196f, -0.24604024f, 0.07783687f, 0.03140366f, 0.12726468f, 
    -0.49291861f, 0.29332680f, -0.26157367f, -0.09231355f, 0.10157195f, 0.08962696f, 0.48139176f, 0.00612059f, 
    -0.27772477f, -0.12044003f, -0.27931958f, -0.25484112f, -0.46358159f, 0.06709383f, 0.10534302f, -0.22471158f, 
    -0.25713360f, 0.06607216f, -0.26790157f, 0.17628746f, -0.13876246f, -0.19527358f, -0.03647352f, -0.34105426f, 
    0.44138131f, -0.10036732f, 0.56474501f, 0.29312009f, -0.16988148f, -0.32307836f, 0.29214677f, 0.00999284f, 
    -0.27095711f, -0.03297622f, 0.00675763f, -0.00663516f, -0.39667335f, 0.25895366f, -0.07364967f, -0.23086378f, 
    -0.13994898f, 0.18071017f, 0.07656939f, 0.28935060f, -0.06145678f, -0.10984392f, 0.06001687f, -0.12357096f, 
    -0.15327488f, 0.02567579f, 0.36108369f, -0.16554138f, 0.06356011f, -0.24271905f, -0.21675414f, 0.03979727f, 
    -0.11962490f, -0.30155596f, -0.02625098f, -0.16544783f, 0.22771247f, -0.10645940f, 0.55713207f, 0.12068280f, 
    -0.20000148f, -0.03813950f, 0.29448265f, -0.11955287f, 0.26274103f, 0.06106538f, 0.12721524f, 0.23279548f, 
    -0.30041793f, -0.42359620f, -0.88144475f, 0.00497129f, 0.07885937f, -0.16820274f, -0.33148187f, -0.05654100f, 
    0.10247877f, 0.24435353f, -0.07366335f, -0.13111696f, -0.48486260f, 0.34588698f, -0.05721060f, -0.12224536f, 
    -0.11635330f, -0.00824065f, -0.00937579f, -0.24471173f, 0.14565212f, 0.12593296f, 0.20296927f, 0.21972801f, 
    0.07075348f, 0.61025912f, -0.58885306f, -0.08655148f, 0.10827044f, 0.06997789f, 0.01371330f, 0.02171300f, 
    -0.01287254f, -0.01302856f, -0.21392180f, -0.12361513f, 0.09602257f, 0.02473414f, 0.04804572f, -0.49868131f, 
    -0.03368628f, -0.22219403f, 0.25604910f, 0.13850863f, 0.09864200f, 0.22804053f, 0.36993903f, 0.02558355f, 
    -0.52303511f, -0.12739833f, -0.34130800f, -0.17568080f, 0.04513702f, 0.02376071f, -0.15942222f, 0.15444082f, 
    0.06435798f, 0.04307276f, 0.03673563f, -0.23532969f, -0.60870945f, -0.81927598f, 0.14848547f, -0.05609871f, 
    -0.05280408f, -0.26790297f, 0.10887498f, -0.04204125f, 0.00709961f, -0.10267489f, 0.00802858f, 0.08300351f, 
    -0.45709869f, 0.50915468f, 0.02277345f, -0.26272434f, -0.04183825f, 0.06081510f, 0.06499365f, -0.01919413f, 
    -0.01984414f, -0.02846475f, -0.04445390f, -0.09321174f, 0.89146376f, 0.22300373f, 0.71821511f, -0.28124705f, 
    -0.11181483f, -0.03241199f, -0.15847459f, 0.17651406f, -0.27428547f, 0.03382324f, 0.09117315f, -0.13638234f, 
    -0.18365671f, 0.13176394f, 0.36816028f, 0.16905287f, 0.09592647f, 0.00063627f, 0.21742895f, -0.01188125f, 
    -0.06875250f, -0.06067677f, 0.04299498f, -0.26865640f, -0.21298572f, 0.71774918f, -0.52285016f, 0.90902936f, 
    -0.06060162f, 0.10982447f, 0.09506674f, -0.51333946f, 0.03839743f, -0.12773731f, -0.16656354f, -0.06539112f, 
    -0.26892039f, -0.35578138f, -0.65547067f, 0.15694620f, -0.02792745f, 0.03765452f, 0.03936100f, -0.27490732f, 
    0.27556437f, 0.13104750f, 0.22501451f, 0.27547902f, -0.11574883f, 0.50239521f, -0.57200378f, 0.14331047f, 
    -0.07816524f, -0.14389253f, 0.22330672f, 0.01521189f, 0.02942563f, 0.01741682f, -0.23171194f, 0.19274142f, 
    -0.00392142f, 0.19958504f, 0.18279913f, 0.10131139f, 0.05224674f, 0.28455958f, -0.13947782f, 0.18334314f, 
    -0.30839443f, 0.30711579f, 0.03911231f, -0.09946924f, -0.04685998f, 0.34526977f, 0.19961031f, -0.01581999f, 
    0.28092864f, -0.14180407f, 0.02255579f, -0.15498331f, 0.03578557f, 0.08010677f, -0.03090277f, -0.20419389f, 
    -0.19900982f, -0.20765854f, -0.28232658f, 0.01201991f, -0.14505583f, 0.03645058f, 0.08837219f, 0.01052800f, 
    -0.06976604f, 0.00517871f, 0.09483464f, -0.04349273f, 0.39510658f, -0.35610977f, 0.74253160f, -0.24312629f, 
    -0.08824959f, 0.15276951f, 0.15954778f, -0.03275090f, 0.16301273f, -0.06797095f, -0.14513978f, -0.17611074f, 
    0.04797989f, -0.64186096f, -0.27452168f, 0.12818564f, -0.06962214f, -0.02849922f, -0.00356121f, -0.23917568f, 
    -0.00360950f, 0.06457317f, -0.07041176f, 0.02168570f, -0.79431409f, 0.21357737f, -0.75199574f, 0.51652914f, 
    0.39650652f, 0.06664169f, -0.24140322f, -0.11371955f, -0.15283586f, -0.07100490f, -0.05638387f, -0.04189456f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21286131f, 0.16752097f, 0.17557403f, -0.10441464f, -0.24867266f, 0.05110778f, 0.12060475f, -0.21457179f, 
    0.15339103f, 0.14088170f, -0.03010833f, -0.09850880f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
