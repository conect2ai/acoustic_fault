#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.26163420f, 0.41269150f, -0.22017641f, -0.08966616f, 0.33099899f, 0.00430743f, 0.07213314f, 0.05288676f, 
    0.33723438f, 0.28227171f, -0.15080912f, -0.27446604f, 0.04065805f, 0.28897449f, 0.20130265f, -0.11434820f, 
    -0.02617884f, -0.21663088f, 0.01202040f, 0.08948038f, 0.07853158f, 0.23357168f, -0.15337102f, -0.21461107f, 
    0.05899327f, 0.70446914f, 0.44469854f, -0.15352243f, 0.48758107f, -0.38295001f, 0.27208757f, -0.15928133f, 
    -0.06138124f, -0.27750143f, 0.07991061f, 0.23881422f, -0.03582325f, 0.16466714f, -0.22727656f, -0.24256189f, 
    -0.09889742f, 0.03774382f, -0.13706003f, -0.05639794f, 0.05732707f, 0.05000481f, -0.04157135f, -0.04761434f, 
    -0.04948257f, -0.01121729f, -0.19295447f, 0.49215218f, 0.13690346f, -0.42700216f, 0.09015995f, -0.39406911f, 
    -0.30138803f, -0.09591048f, -0.40848505f, -0.41977951f, -0.21858078f, -0.25860003f, -0.24416469f, -0.14033331f, 
    -0.24146712f, -0.09898266f, -0.43302962f, -0.24703546f, -0.01213508f, -0.43928802f, -0.16734985f, -0.11090958f, 
    -0.29524115f, -0.37284032f, -0.43687820f, -0.49549416f, 0.26209688f, -0.17559285f, -0.97793001f, -0.78216714f, 
    0.07474408f, 0.47853953f, 0.33567902f, 0.13829671f, 0.13903311f, -0.17334929f, -0.23049393f, 0.09909956f, 
    -0.20583302f, 0.18944433f, 0.16971086f, 0.24718010f, 0.06916177f, -0.10891495f, -0.06295441f, -0.22720636f, 
    -0.23452012f, -0.09016722f, -0.25514334f, -0.38591462f, -1.01029837f, -0.40461490f, 0.47059163f, 0.56093663f, 
    0.56729847f, 0.15758687f, 0.35529473f, 0.02468573f, 0.11251539f, 0.10716446f, -0.11362493f, -0.29068828f, 
    -0.12720697f, 0.38582683f, -0.41726199f, 0.02551118f, -0.04562597f, -0.11896665f, -0.05135920f, -0.20940234f, 
    -0.40947461f, -0.20009230f, 0.13396335f, 0.06394894f, -0.19963369f, 0.00019706f, -0.43788064f, 0.26698393f, 
    0.28395683f, -0.41430882f, 0.07234553f, -0.40782639f, -0.58833092f, -0.72547805f, -0.46237016f, 0.69444996f, 
    -0.13033490f, 0.24509901f, -0.15441851f, 0.57956862f, -0.28639945f, -0.23957659f, -0.14732958f, 0.18780878f, 
    -0.10931492f, -0.02949915f, 0.08423312f, 0.04106484f, -0.27131411f, 0.09075973f, 0.83042580f, 0.03205977f, 
    0.27569094f, 0.26960728f, 0.41253945f, -0.45470396f, -0.01123111f, -0.38536409f, -0.36486217f, -0.30198339f, 
    -0.12889157f, 0.24151218f, -0.02281624f, 0.08912132f, -0.05050217f, -0.15958905f, 0.08869408f, 0.11271738f, 
    0.09823370f, -0.15480900f, 0.09195902f, -0.18750970f, 0.11531199f, 0.32551143f, -0.22325094f, 0.31705046f, 
    0.17567559f, 0.30063972f, 0.21486042f, -0.10563542f, 0.04118028f, -0.15094720f, -0.19778435f, -0.00112371f, 
    -0.19502546f, 0.46101043f, -0.45779377f, 0.06340001f, 0.03447948f, -0.02605690f, -0.17552902f, 0.16844225f, 
    0.25949770f, 0.09778727f, -0.20199691f, -0.16855179f, -0.30195165f, -0.34494525f, -0.25626606f, -0.37573519f, 
    -1.12426496f, -0.31199357f, -0.67952728f, -0.28918141f, 0.42284036f, 0.21842386f, -0.06709902f, 0.21266577f, 
    0.60011536f, 0.32769212f, 0.15548030f, -0.04194205f, -0.03109491f, 0.01470197f, 0.28388280f, -0.03555328f, 
    -0.02488662f, 0.08320671f, 0.26800019f, -0.19925046f, -0.15545474f, 0.21873575f, -0.04509267f, -0.04718073f, 
    -0.10495842f, 0.03544957f, -0.39871550f, -0.06757364f, 0.08597413f, -0.52647114f, -0.57704377f, -0.49063808f, 
    -0.52205718f, -0.46717665f, -0.18909772f, 0.43594426f, -0.17425252f, -0.08514172f, 0.03120129f, -0.17400216f, 
    0.04770060f, 0.33192244f, 0.17788248f, -0.16363440f, -0.12726493f, 0.30875516f, -0.17050467f, 0.17417745f, 
    0.01612631f, 0.29071450f, -0.57730037f, -0.37815478f, -0.17944731f, -0.30841947f, -0.35093680f, 0.35295314f, 
    0.01536043f, -0.09077581f, 0.08586460f, 0.43327308f, 0.19972853f, 0.43691355f, -0.29837245f, -0.32393935f, 
    0.30068633f, -0.59627187f, 0.26062578f, -0.36556488f, -0.14049074f, 0.02082808f, 0.35290408f, 0.26879665f, 
    0.08460003f, 0.02738640f, 0.32826072f, -0.88601202f, -0.95598090f, 0.12302942f, 0.23516399f, 0.24567524f, 
    0.73958063f, 0.08015160f, -0.19453762f, -0.29732350f, 0.22533014f, -0.33010346f, -0.29274541f, -0.21899892f, 
    0.01919950f, 0.01348409f, 0.22194053f, 0.16933048f, -0.05822140f, 0.19103229f, -0.14542942f, 0.06843807f, 
    -0.01054735f, 0.00931060f, 0.14079268f, 0.01708320f, 0.07939181f, 0.44602191f, 0.10206586f, -0.49438971f, 
    -0.03661951f, -0.11317278f, 0.01465487f, 0.06974985f, 0.26570281f, 0.11584646f, -0.02088029f, -0.19573025f, 
    -0.05837943f, 0.16759631f, 0.05761820f, 0.16285299f, -0.05683535f, -0.56960565f, 0.20496763f, 0.28364196f, 
    -0.19156705f, -0.08799302f, 0.08923903f, 0.18445104f, 0.34792188f, 0.43911004f, -0.97150314f, -0.47419277f, 
    0.12284654f, -0.55778289f, 0.62563592f, 0.01094466f, -0.59916580f, -0.53374964f, 0.19445895f, -0.27960363f, 
    -0.20523407f, -0.30347231f, -0.11516263f, -0.29849848f, 0.05284660f, -0.17301019f, 0.03345812f, 0.02975458f, 
    -0.30239242f, -0.19216946f, -0.15728152f, -0.14031835f, -0.11480051f, -0.30373424f, -0.77411443f, -0.23996544f, 
    0.30644533f, 0.37116614f, 0.48188713f, 0.01681116f, -0.95388740f, -0.30149913f, 0.29574892f, 0.57771719f, 
    0.15850280f, 0.08534447f, -0.05362443f, 0.06766798f, 0.15371083f, -0.08202446f, -0.13098626f, -0.04297433f, 
    0.17187710f, -0.37964988f, 0.23116902f, -0.36005253f, 0.37851226f, -0.03985794f, 0.03175281f, -0.62689954f, 
    0.12495534f, -0.22760844f, -0.44934109f, -0.65712041f, 0.21765800f, 0.46789607f, 0.40276790f, 0.18756513f, 
    -0.40223473f, -0.01879727f, 0.07632095f, -0.14208338f, -0.14394817f, 0.04837693f, 0.11384659f, -0.20613594f, 
    -0.38840324f, -0.20141132f, -0.32278138f, -0.00768143f, 0.15078628f, 0.57067978f, -0.02773686f, -0.09371793f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10876372f, 0.40032253f, -0.36497557f, 0.01775381f, 0.16316666f, 0.06228065f, 0.23861863f, 0.01314569f, 
    0.09862532f, 0.20080246f, 0.00347388f, 0.15542741f, 0.26482901f, 0.37105426f, 0.15221387f, 0.14909565f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.17932294f, -0.02508179f, 0.08621473f, -0.01131063f, 0.11468619f, 0.00134730f, -0.03095342f, 0.03370390f, 
    -0.03170230f, 0.04365343f, 0.00634156f, 0.03686912f, -0.38954097f, -0.00847402f, -0.09830473f, 0.15207195f, 
    -0.10559715f, 0.01859254f, -0.03278846f, 0.01050100f, -0.02798235f, -0.02474379f, 0.04850202f, 0.10588204f, 
    0.02728291f, 0.25626954f, 0.13608240f, 0.00557658f, -0.01922654f, -0.00389031f, -0.00741560f, 0.23057342f, 
    -0.00225852f, -0.11909753f, 0.12620544f, 0.00606690f, -0.04494102f, -0.29015452f, -0.01846863f, 0.14356440f, 
    0.16328762f, 0.22457878f, 0.03500503f, 0.13524430f, 0.03139295f, 0.05207894f, 0.10041271f, -0.17366908f, 
    0.28243515f, 0.04355577f, -0.10445766f, -0.24498408f, -0.06867387f, -0.12089711f, 0.07719164f, -0.04934235f, 
    0.19372746f, -0.22741213f, -0.01090624f, -0.00349011f, 0.24213536f, -0.04538578f, -0.21969527f, -0.23123275f, 
    -0.05986335f, -0.03059621f, -0.09328593f, 0.20581436f, 0.01722560f, 0.15691832f, 0.03748330f, -0.02848113f, 
    -0.20506129f, 0.20054156f, -0.00548246f, 0.01305153f, -0.20693976f, -0.08351894f, -0.06168955f, -0.02660975f, 
    0.03682814f, 0.01095385f, 0.00042967f, 0.10888907f, -0.19952822f, -0.04090083f, 0.07666951f, -0.04621778f, 
    -0.01946011f, 0.05856898f, 0.01439708f, 0.00513317f, -0.14933683f, -0.06247227f, -0.07371914f, 0.00598259f, 
    0.16911833f, 0.04877589f, -0.14300555f, -0.02271936f, -0.02635175f, 0.09184519f, 0.10094403f, 0.02092868f, 
    0.04936810f, -0.04127864f, -0.08055803f, 0.02170432f, 0.25340363f, 0.09640277f, -0.10292282f, -0.26251149f, 
    0.07029127f, 0.13999264f, -0.09487572f, 0.03186843f, -0.04926313f, 0.01934974f, 0.01809981f, 0.02282025f, 
    -0.10906825f, -0.15009636f, -0.08895127f, 0.02157156f, 0.04130993f, 0.14622808f, 0.10812506f, -0.09202063f, 
    -0.00660930f, -0.09823932f, -0.07190464f, -0.08500248f, 0.31048137f, 0.13329239f, 0.01492488f, -0.13970543f, 
    0.04093337f, -0.08108221f, -0.06276713f, 0.19842120f, 0.01407784f, 0.03289999f, -0.02637683f, -0.07086634f, 
    -0.07631177f, 0.07417192f, 0.09608913f, -0.01098582f, 0.02552776f, -0.06753369f, 0.01784299f, 0.00409465f, 
    0.03904777f, -0.01209911f, 0.04926518f, 0.10099751f, 0.33466217f, 0.15454595f, -0.04724529f, -0.17815499f, 
    0.06962651f, -0.07832830f, 0.10237963f, -0.07345400f, 0.07728491f, -0.13461494f, 0.07772841f, 0.10064799f, 
    0.44666159f, 0.26798677f, 0.43081650f, -0.48407957f, -0.09517926f, 0.04306192f, -0.01308773f, -0.05622665f, 
    0.00978899f, -0.13917504f, 0.07975355f, 0.02266649f, -0.02137803f, -0.11525838f, -0.09046707f, -0.04858922f, 
    0.00904953f, 0.12003107f, -0.08487400f, -0.05538834f, 0.00650319f, 0.13721780f, 0.07231063f, 0.12970144f, 
    0.03067905f, -0.06601010f, 0.04140733f, 0.04942879f, 0.03381075f, -0.00702887f, 0.00229177f, 0.00084161f, 
    -0.03349604f, -0.03450824f, -0.06826071f, -0.07385325f, -0.00253270f, -0.01035092f, -0.07051026f, 0.03296891f, 
    -0.05016743f, -0.06171822f, -0.06735475f, -0.01741621f, -0.07111149f, 0.06605144f, -0.06135433f, -0.02290220f, 
    -0.02569964f, -0.01087372f, -0.03225892f, -0.06720511f, -0.06612832f, 0.06124157f, 0.05512977f, -0.06194231f, 
    -0.03347264f, 0.01074511f, -0.01782531f, 0.04265310f, -0.03897041f, 0.03048021f, -0.03823742f, -0.00921847f, 
    -0.06483746f, -0.05948636f, -0.00492668f, 0.03033793f, 0.05206715f, -0.01105155f, -0.07196212f, 0.02821105f, 
    -0.00278134f, -0.06029086f, 0.05836035f, -0.01568799f, 0.03173881f, -0.06146211f, -0.07720818f, 0.03051786f, 
    -0.04658435f, 0.05301212f, -0.04772227f, 0.04798461f, -0.00624774f, 0.01928838f, -0.07152997f, -0.05545758f, 
    0.03455880f, -0.03035530f, -0.07229720f, -0.05306796f, 0.03559382f, -0.00979399f, 0.05401258f, 0.00278642f, 
    -0.07489184f, -0.07061894f, 0.02485309f, 0.01617716f, -0.00532663f, 0.02369044f, -0.06020581f, -0.06993159f, 
    -0.06895807f, -0.04529553f, -0.00536709f, -0.07205827f, -0.02565960f, 0.04722035f, -0.04875847f, -0.06886164f, 
    0.05261191f, -0.05037393f, -0.05085152f, 0.04250382f, -0.02837267f, 0.01542593f, 0.06349686f, -0.01552644f, 
    -0.00742386f, -0.04364906f, -0.01155477f, -0.06870542f, -0.06419628f, -0.03543357f, 0.05595392f, 0.01118811f, 
    0.03404663f, -0.06302201f, -0.06537510f, -0.07344108f, 0.04500294f, -0.07415406f, 0.03156475f, -0.02694533f, 
    -0.00106775f, -0.01978789f, 0.03350513f, -0.01082608f, 0.03172048f, 0.02570603f, -0.03374651f, 0.05473948f, 
    -0.04985487f, 0.02219797f, -0.07098676f, -0.00287066f, 0.00317895f, -0.07163528f, -0.03731306f, 0.01339984f, 
    -0.07227210f, -0.06312705f, 0.01872054f, -0.07690145f, -0.04689990f, -0.05590177f, 0.00126581f, -0.02028619f, 
    0.02977499f, -0.00007739f, 0.02844225f, -0.05410523f, 0.02238183f, 0.03869772f, 0.01849113f, -0.06830944f, 
    -0.04819016f, -0.06267186f, 0.04881101f, 0.03971163f, -0.00891878f, -0.04549157f, -0.01747449f, 0.01410678f, 
    -0.02195686f, 0.02747368f, -0.06691878f, 0.05255139f, -0.00471634f, -0.00804362f, -0.03979499f, -0.01608964f, 
    0.02986472f, 0.05553686f, 0.05927944f, -0.04468786f, 0.01899715f, -0.02081039f, -0.04314505f, 0.05887673f, 
    0.03989614f, 0.04165567f, 0.00280251f, 0.04805610f, -0.00965727f, -0.05403654f, -0.07641727f, -0.06724594f, 
    -0.02642997f, 0.03366805f, 0.06201729f, -0.07245901f, -0.06342782f, -0.06572296f, 0.04161764f, -0.06246261f, 
    0.05112742f, -0.06822751f, -0.00740030f, -0.07717728f, -0.00908130f, 0.03834141f, -0.02841712f, 0.07023760f, 
    -0.05460624f, 0.01542416f, -0.01868115f, -0.05106780f, -0.02534957f, -0.05502493f, -0.02113712f, 0.03567183f, 
    0.05122994f, -0.04138627f, -0.02350000f, -0.06081345f, -0.07356232f, -0.01194132f, 0.04125584f, -0.06076630f, 
    0.00928422f, 0.04710692f, -0.08046943f, -0.01851012f, 0.06284064f, 0.03901134f, 0.01091944f, 0.00316241f, 
    0.04540566f, -0.01990458f, 0.07431957f, 0.02708916f, -0.00870619f, 0.05268739f, -0.01351074f, -0.02313678f, 
    -0.06614482f, -0.00372833f, -0.02253739f, 0.01043079f, -0.01793716f, -0.00883531f, -0.06410088f, -0.06365665f, 
    -0.02150178f, -0.01008852f, 0.00519315f, 0.04890116f, 0.05474434f, -0.01565828f, -0.07354137f, 0.00726917f, 
    -0.07662882f, 0.00188099f, -0.07129718f, -0.05699259f, -0.01968320f, -0.02384004f, 0.06510551f, -0.05338245f, 
    0.03368340f, 0.05603705f, 0.05500488f, -0.03205072f, -0.01558209f, -0.02748191f, 0.05575355f, -0.06863589f, 
    0.00997743f, -0.06963076f, -0.03904413f, -0.00861257f, -0.02502308f, -0.01228178f, 0.04130343f, -0.07087447f, 
    0.03350986f, -0.01890386f, -0.00737951f, -0.07889885f, -0.03468650f, 0.03068995f, -0.01364139f, -0.03681873f, 
    0.04153538f, 0.04788852f, -0.06127898f, -0.05214141f, 0.05050821f, 0.01057305f, -0.04021641f, 0.00472327f, 
    0.04272920f, -0.00169971f, 0.00906582f, -0.06541780f, 0.03431270f, -0.06576157f, 0.04670829f, -0.03773040f, 
    -0.04617970f, 0.04935524f, -0.01876754f, -0.02577739f, -0.02699575f, -0.02522014f, 0.03835829f, 0.00495972f, 
    -0.05479840f, 0.04877614f, -0.01419187f, 0.05599851f, -0.04553098f, -0.06324257f, 0.05308475f, 0.05058893f, 
    -0.03540175f, -0.00307204f, -0.02425244f, -0.02444033f, 0.05769084f, -0.07949688f, -0.02100107f, -0.04938371f, 
    0.01324716f, 0.05149972f, 0.05656511f, -0.05932799f, 0.04888770f, -0.06990990f, 0.03064726f, 0.03678799f, 
    -0.00773821f, -0.03359002f, -0.00230916f, -0.00590085f, 0.03831409f, -0.02113777f, 0.03967078f, 0.01791280f, 
    -0.06169418f, -0.02717331f, 0.00774526f, -0.05621554f, 0.00257103f, -0.01562119f, -0.02627176f, -0.07337890f, 
    0.04535675f, 0.05295648f, -0.05442457f, -0.05906406f, -0.04050741f, 0.05037111f, -0.00380648f, -0.03305031f, 
    -0.02148987f, -0.00490350f, -0.04069870f, -0.02344470f, 0.02476209f, 0.05826993f, -0.02990954f, -0.07969400f, 
    -0.06799547f, -0.03185307f, 0.03821651f, -0.05443974f, -0.06746557f, -0.05391450f, -0.07060143f, 0.05271956f, 
    -0.00248242f, 0.01235518f, 0.00539839f, 0.06122370f, 0.03987590f, -0.02012330f, 0.04361143f, -0.05815079f, 
    0.03949663f, -0.01889986f, 0.02595735f, -0.00058451f, -0.06909613f, -0.04733416f, -0.05271517f, -0.00917238f, 
    0.01744838f, 0.00949513f, 0.05616922f, 0.05499499f, -0.01642280f, 0.01171067f, 0.05852748f, -0.00524242f, 
    0.14636311f, 0.03604834f, -0.01149733f, 0.03792473f, -0.05893427f, 0.11112564f, -0.03783032f, 0.12766972f, 
    0.00368197f, 0.11875793f, 0.04997848f, -0.01771934f, 0.16977701f, -0.00296389f, 0.10447898f, -0.15516236f, 
    -0.07576705f, 0.02396757f, 0.14427419f, 0.09282055f, -0.05959266f, 0.02398518f, -0.00368958f, 0.02112207f, 
    0.08239724f, -0.00984133f, -0.09168136f, -0.06102277f, -0.00950131f, -0.09919567f, -0.10739767f, -0.05625810f, 
    0.01835982f, 0.03013097f, -0.03978536f, 0.05706523f, -0.11002322f, 0.06294684f, 0.18877056f, -0.11256998f, 
    -0.04434624f, -0.05318750f, -0.06026682f, -0.04631645f, 0.06124182f, 0.15326826f, -0.15339467f, -0.13574755f, 
    0.04119151f, -0.03005139f, -0.00364310f, 0.06439773f, -0.10161071f, 0.01116708f, 0.08244861f, -0.03142727f, 
    0.02063064f, 0.14700092f, -0.05723445f, 0.09972528f, -0.40136009f, 0.28259853f, 0.12677293f, 0.14586361f, 
    -0.08602981f, -0.02638017f, 0.07867286f, -0.23637606f, 0.08777557f, 0.05213153f, 0.07650799f, 0.08905716f, 
    0.37815145f, 0.32461378f, 0.12879591f, -0.14880960f, -0.01916339f, 0.04618147f, -0.11641687f, 0.20365465f, 
    -0.01161660f, 0.08576267f, 0.11158544f, -0.11291630f, 0.09675500f, 0.00027195f, -0.06355075f, 0.10063385f, 
    -0.02313837f, -0.06497810f, -0.04802170f, 0.08828260f, 0.06521363f, -0.02123555f, -0.06565382f, -0.08400168f, 
    -0.21954176f, 0.13755266f, -0.15964620f, -0.03944000f, -0.02925593f, 0.16187814f, -0.13493688f, -0.05127258f, 
    0.04910753f, -0.01269572f, 0.19049573f, -0.14154510f, -0.20929834f, 0.01460944f, -0.00192441f, 0.00626609f, 
    -0.18889359f, -0.18116169f, 0.07361937f, -0.10197078f, 0.02023575f, -0.06776660f, -0.05002346f, -0.01176053f, 
    0.14766756f, 0.32005957f, -0.12189516f, -0.13546979f, -0.04631548f, 0.05137920f, 0.01932016f, 0.12990879f, 
    -0.18967094f, -0.00048338f, -0.07121077f, -0.15638791f, 0.06321521f, -0.10553683f, -0.05086273f, 0.18504854f, 
    -0.01093228f, 0.02267904f, 0.22525905f, 0.11444144f, -0.02280828f, -0.06008154f, -0.00788905f, -0.09339118f, 
    0.22065815f, -0.01078946f, 0.08683999f, -0.12201611f, -0.04608016f, 0.16507705f, 0.17605187f, -0.01945765f, 
    -0.02257769f, 0.16190173f, -0.01068039f, -0.05957888f, 0.08393909f, 0.07802789f, -0.19494174f, 0.26666471f, 
    -0.03582790f, 0.07321616f, 0.01889499f, 0.11985927f, 0.03517235f, -0.08013473f, 0.04374062f, 0.08135101f, 
    -0.38393945f, 0.22348833f, -0.37788266f, 0.26629034f, 0.10073362f, 0.19772822f, 0.01592669f, 0.08611965f, 
    -0.02242092f, 0.08482371f, 0.08228457f, -0.11017342f, -0.00887350f, -0.13176055f, 0.10114422f, -0.06680454f, 
    -0.06135053f, -0.10789214f, 0.18611401f, 0.06883240f, -0.09958836f, -0.11750384f, -0.03910626f, 0.06800614f, 
    -0.07502939f, -0.08938131f, -0.01729446f, 0.08933002f, 0.01469946f, -0.02226011f, 0.00538908f, -0.04201743f, 
    0.06111097f, 0.09080741f, -0.05342248f, 0.11621280f, 0.22321986f, -0.35379478f, -0.26831567f, 0.20463502f, 
    0.05597072f, 0.13387176f, -0.04569446f, 0.01290273f, 0.00398950f, 0.04532838f, 0.09230679f, 0.04408759f, 
    0.01928629f, 0.24210191f, -0.08219277f, 0.12839749f, 0.01109681f, -0.02918239f, -0.06115445f, -0.08386967f, 
    0.02882666f, 0.03975298f, 0.02102155f, 0.02021666f, -0.11574451f, 0.12335172f, 0.00838515f, -0.15399927f, 
    -0.00775067f, -0.09556410f, -0.14534889f, 0.08950616f, 0.07764080f, 0.03126976f, -0.00903569f, -0.02726841f, 
    -0.10299525f, -0.01540128f, 0.31392366f, -0.02849209f, -0.02758450f, 0.02265404f, 0.08492173f, 0.03462659f, 
    0.12821636f, 0.04933031f, -0.04730143f, 0.01143614f, 0.40416548f, 0.32968059f, 0.05260985f, -0.06149034f, 
    -0.10191637f, -0.07344896f, 0.13813917f, 0.16758958f, 0.00514522f, 0.13822885f, 0.00748616f, -0.02713778f, 
    0.05429546f, -0.32316411f, -0.04345777f, -0.04067184f, -0.01369210f, 0.10288918f, -0.23318803f, 0.04871347f, 
    0.04766622f, 0.14006688f, 0.05382093f, -0.08738130f, -0.06640106f, -0.05026684f, -0.08959118f, 0.06558066f, 
    -0.01388632f, 0.06895076f, 0.16337268f, -0.00095176f, -0.04883827f, -0.00717321f, -0.05982459f, 0.06601775f, 
    -0.09966083f, 0.17121778f, 0.05337619f, 0.00582113f, 0.00076140f, -0.00894755f, 0.10491782f, -0.01165473f, 
    0.09598787f, -0.14076544f, 0.01223372f, 0.00963687f, 0.24318556f, 0.25894725f, 0.20549574f, 0.03934226f, 
    0.10068549f, 0.14593819f, 0.05158015f, 0.22190832f, -0.03969675f, 0.05282845f, 0.02984810f, -0.06875858f, 
    0.04913067f, 0.23812525f, 0.13644738f, -0.20246208f, -0.04640995f, -0.01990018f, 0.05433435f, -0.23987128f, 
    0.07600209f, -0.04064881f, 0.15161511f, -0.05626271f, 0.19670676f, -0.11726215f, -0.09351267f, -0.09170648f, 
    -0.10640101f, 0.02564996f, 0.04726398f, 0.03225760f, 0.06216170f, -0.04557636f, 0.03982999f, 0.01582757f, 
    -0.04230861f, -0.01280590f, 0.03076794f, 0.02377253f, 0.10312498f, 0.01504596f, -0.01719036f, 0.04394882f, 
    -0.08612978f, 0.05249092f, -0.11215162f, 0.16241519f, 0.27839616f, -0.01097127f, -0.04513673f, -0.08122163f, 
    -0.11314350f, -0.04190924f, -0.06664119f, 0.12896164f, -0.05377020f, -0.14964744f, -0.06586231f, 0.04333078f, 
    -0.36948338f, 0.21195138f, 0.27020797f, -0.03691437f, -0.19064309f, 0.11064721f, 0.09290837f, -0.08312410f, 
    0.03079608f, 0.01457010f, -0.13805568f, -0.01357951f, 0.10830951f, 0.03766085f, -0.08757269f, 0.05039397f, 
    0.06905080f, -0.02567995f, -0.07348176f, -0.20009226f, -0.00951294f, -0.06714477f, -0.17249765f, -0.09464255f, 
    -0.13240448f, -0.21718007f, -0.08406033f, -0.03860016f, -0.03645195f, -0.03157242f, 0.01439084f, -0.01264634f, 
    0.04048352f, 0.06629198f, 0.05612653f, -0.08957005f, -0.20342492f, -0.06679595f, -0.13035204f, 0.09191478f, 
    -0.13024090f, -0.03831176f, -0.05914073f, 0.10526108f, -0.07194176f, -0.00642801f, 0.04003237f, 0.02027106f, 
    0.15218571f, 0.20519958f, 0.31374329f, -0.04237397f, -0.08670872f, -0.02032103f, -0.16511351f, 0.21261729f, 
    -0.01036627f, -0.07262374f, -0.06200800f, -0.07162789f, 0.11380060f, -0.09625846f, 0.08017055f, 0.04522364f, 
    0.13950138f, -0.00928014f, -0.09057143f, 0.07048681f, 0.07602633f, -0.02961143f, -0.06101374f, 0.08081904f, 
    -0.29911175f, -0.04594815f, -0.12386663f, -0.05031075f, 0.05117268f, -0.01272222f, 0.03269994f, -0.11604954f, 
    -0.06574126f, 0.03257815f, 0.03365400f, -0.04350407f, 0.18522385f, 0.34604701f, -0.18669426f, -0.04964111f, 
    -0.03049112f, 0.13324636f, 0.24813297f, 0.23752461f, 0.04614515f, -0.03902014f, -0.00348046f, -0.01184372f, 
    -0.04459488f, 0.02868799f, 0.05680994f, 0.02402120f, -0.18614508f, -0.11478884f, -0.07512258f, 0.06946249f, 
    -0.08887946f, 0.04620874f, 0.06129035f, 0.05673916f, -0.08516938f, -0.07635214f, 0.05675780f, -0.02179069f, 
    -0.04636139f, -0.04844930f, -0.03222016f, 0.05734477f, 0.16690487f, 0.10650449f, 0.10499559f, 0.12012702f, 
    0.09272728f, 0.11535706f, -0.00823822f, 0.02231564f, 0.12367576f, -0.01203477f, 0.05778180f, 0.05883111f, 
    -0.01026481f, -0.06085705f, 0.14602311f, -0.16629639f, 0.32046443f, 0.32302311f, 0.19190060f, 0.09565163f, 
    0.01882278f, 0.14682357f, 0.12331069f, 0.16205359f, -0.02817066f, -0.02346232f, -0.06512186f, -0.02311825f, 
    0.05154268f, 0.21295559f, 0.01087706f, 0.02709731f, 0.02433435f, 0.09724957f, -0.00495215f, -0.13775451f, 
    0.04003645f, 0.09362928f, -0.04534743f, -0.00951496f, -0.03435841f, 0.34255588f, 0.13935778f, -0.07479200f, 
    0.11215146f, 0.03261655f, 0.19362311f, -0.03986603f, -0.13303085f, 0.00269190f, -0.03231306f, 0.05362780f, 
    -0.01355949f, -0.10542513f, -0.05443121f, -0.11940926f, 0.03328833f, 0.07882486f, -0.05786367f, 0.05631358f, 
    0.05707446f, 0.07650293f, -0.09466442f, 0.05406639f, 0.09107206f, 0.26927048f, -0.11421472f, 0.17661032f, 
    -0.08121674f, -0.03766048f, 0.12086292f, 0.25084791f, -0.06185944f, -0.07094992f, 0.07668876f, 0.09442457f, 
    -0.19137147f, 0.55446762f, 0.47758859f, -0.36888736f, -0.06291205f, -0.02869678f, -0.07298141f, -0.09230082f, 
    0.12856665f, -0.03738448f, -0.03607619f, 0.12604076f, 0.31292138f, -0.00574348f, 0.11649846f, 0.18652275f, 
    0.02259285f, -0.07495001f, -0.19254017f, -0.12713082f, -0.07613949f, 0.02894557f, -0.02311450f, 0.02621197f, 
    0.04760924f, 0.07603767f, -0.06240953f, 0.07978838f, 0.01595154f, 0.03183926f, 0.09809519f, 0.12673047f, 
    0.08049361f, -0.04030008f, -0.05160372f, -0.10848959f, -0.17861801f, -0.04750478f, 0.15170568f, 0.02014478f, 
    -0.08182792f, -0.06250733f, 0.02510812f, 0.01030170f, -0.08244576f, 0.04205190f, -0.01603913f, 0.02409559f, 
    0.18450992f, -0.10951100f, -0.06102040f, -0.11591373f, -0.05877246f, -0.03770072f, -0.13074587f, 0.04213274f, 
    -0.05152689f, -0.00131795f, -0.05804998f, 0.13799512f, 0.32073885f, -0.04280755f, 0.24911979f, 0.00896919f, 
    0.08734186f, 0.02786878f, -0.17175178f, -0.00508846f, 0.02537998f, 0.29167464f, -0.13289621f, 0.00563466f, 
    -0.11161891f, 0.46234852f, -0.07363280f, -0.01115184f, -0.01727420f, 0.08307409f, 0.08055960f, -0.06844245f, 
    -0.10865273f, 0.14486690f, 0.08743317f, 0.09467012f, -0.11768942f, 0.05247492f, 0.00635469f, -0.01841312f, 
    -0.10721312f, 0.01449647f, 0.08371259f, 0.06338344f, -0.01576227f, -0.02236448f, 0.11367258f, 0.03584752f, 
    0.12654184f, 0.04039593f, 0.01639989f, -0.05662166f, -0.11497603f, -0.02998570f, -0.04290533f, -0.01089717f, 
    -0.08137556f, -0.00902300f, 0.02191887f, -0.02492804f, -0.01782072f, 0.01307692f, 0.00010032f, 0.09024964f, 
    -0.06209237f, -0.02607918f, 0.03258952f, 0.08487330f, -0.05508032f, 0.18985882f, 0.05897536f, 0.21063621f, 
    0.10628892f, 0.33708170f, 0.01377848f, 0.14558481f, 0.10951553f, 0.07716109f, -0.02966971f, -0.01512312f, 
    -0.08007034f, 0.00832997f, 0.04954789f, -0.00436569f, -0.09562317f, -0.06863227f, -0.23126432f, -0.15944518f, 
    -0.02808551f, -0.15798117f, 0.14040005f, -0.00268913f, -0.03807166f, -0.12091289f, -0.10035779f, -0.05212275f, 
    0.14134513f, 0.44762021f, 0.27239892f, -0.06332529f, 0.02355934f, -0.01556503f, 0.07972813f, 0.03749598f, 
    -0.26902112f, 0.14386407f, -0.11274529f, -0.12710154f, 0.00935121f, 0.19847104f, -0.07537793f, 0.08891921f, 
    0.13957845f, 0.09028274f, 0.13421459f, -0.00068747f, -0.13907537f, -0.00243431f, 0.12339786f, -0.05947858f, 
    0.21622255f, -0.00747803f, 0.06733482f, -0.04177056f, -0.06290485f, 0.03152921f, 0.15072837f, 0.05778797f, 
    -0.07341164f, 0.00883442f, -0.06987740f, -0.07290969f, 0.03501472f, 0.09825962f, -0.29426709f, 0.31274927f, 
    0.08416610f, 0.01494071f, 0.07262638f, 0.04606855f, 0.03128572f, -0.01296588f, 0.00678872f, 0.18202373f, 
    -0.40688470f, 0.26394084f, -0.18568885f, -0.12437316f, -0.06038205f, 0.16333970f, 0.13625522f, 0.03900412f, 
    0.04432252f, -0.00972459f, -0.04452968f, 0.00978347f, 0.20004041f, -0.12194125f, 0.27459210f, 0.10110358f, 
    -0.06168186f, 0.00140556f, -0.15529166f, -0.05320412f, -0.21635579f, -0.04766984f, -0.03543021f, 0.07473344f, 
    0.17472264f, 0.01165566f, -0.19038215f, 0.08570505f, 0.05296393f, 0.10977766f, 0.00197994f, -0.04275730f, 
    0.00804879f, -0.11788806f, 0.00837245f, -0.10477630f, 0.14641491f, 0.17485970f, 0.21225750f, -0.06667891f, 
    -0.04848979f, -0.11057403f, -0.07663713f, -0.06697725f, -0.29991981f, -0.06066658f, -0.05070025f, -0.04747844f, 
    0.28770238f, 0.10158534f, 0.10745931f, 0.18785691f, -0.01498963f, 0.05980781f, 0.11519571f, -0.05028601f, 
    -0.02283670f, -0.00400629f, 0.13609843f, 0.25398412f, 0.12410911f, -0.17051351f, 0.03510490f, 0.01835562f, 
    0.09527709f, 0.11411180f, -0.05717693f, -0.09682321f, 0.04940393f, 0.28588948f, 0.18182342f, 0.26065859f, 
    0.19477844f, 0.35135788f, -0.10539316f, 0.24890363f, 0.05815779f, -0.06418488f, -0.01339748f, 0.00236711f, 
    0.05443029f, 0.13568535f, 0.17645618f, 0.12862171f, 0.17262527f, 0.04706653f, 0.05982739f, -0.08787056f, 
    -0.05676097f, 0.01747523f, 0.02694985f, 0.02646471f, -0.06970024f, -0.15178047f, -0.04739755f, -0.18909094f, 
    0.52525800f, 0.34442869f, 0.06291755f, 0.02628288f, -0.04003618f, 0.11611047f, 0.09789627f, -0.15899669f, 
    -0.20620176f, -0.44576705f, -0.41712961f, -0.13821571f, 0.21412610f, 0.02561417f, 0.30197510f, -0.05509694f, 
    -0.18484442f, 0.03900762f, 0.12184064f, -0.00331309f, 0.00832906f, 0.33271578f, 0.01769867f, 0.14418589f, 
    0.60552269f, -0.06687406f, 0.09006447f, 0.20884003f, -0.06489256f, -0.12047985f, -0.18288435f, -0.01752133f, 
    0.04386404f, -0.03777986f, 0.04017362f, 0.11150884f, 0.02113579f, 0.03019333f, -0.03714949f, -0.02070765f, 
    -0.11354394f, -0.05783556f, 0.16891395f, -0.08448496f, -0.04396580f, -0.09546931f, -0.16341549f, -0.34887937f, 
    0.00936690f, 0.07480790f, 0.12281548f, -0.14106835f, -0.01866639f, -0.04232256f, -0.14443286f, -0.06714340f, 
    -0.05951892f, -0.08728455f, -0.03722796f, -0.06343777f, 0.14536080f, 0.14095627f, -0.42825681f, -0.23005721f, 
    0.05353432f, 0.05499539f, 0.09172760f, 0.18368392f, -0.20755336f, -0.21360385f, 0.06671087f, -0.11791880f, 
    -0.01352921f, -0.11860269f, -0.16197459f, -0.09826807f, -0.03564120f, -0.16140425f, -0.00810808f, 0.07863936f, 
    -0.31403559f, -0.24919458f, 0.10103282f, -0.25677615f, -0.00409147f, 0.00152422f, 0.02781544f, 0.24358776f, 
    0.02627552f, 0.07827813f, 0.23872714f, -0.08562495f, 0.11439104f, 0.07616793f, 0.18526235f, 0.21468921f, 
    0.01790433f, -0.06285571f, 0.10979632f, 0.11870542f, 0.05665180f, -0.11848404f, -0.03112723f, -0.05189721f, 
    -0.03853392f, 0.09921028f, 0.15446204f, -0.04371598f, -0.11047956f, -0.07719371f, 0.10156647f, 0.10399488f, 
    0.07478474f, 0.03879575f, -0.15028927f, -0.11057308f, -0.21383074f, 0.03831626f, 0.21414392f, -0.07320759f, 
    0.02692667f, 0.00661172f, -0.00103771f, 0.01086732f, -0.01563912f, 0.06455708f, -0.01937208f, -0.00594664f, 
    0.01368136f, -0.04394070f, -0.01386274f, -0.07709348f, 0.03832527f, -0.03389546f, -0.06311443f, -0.01534122f, 
    0.03712485f, 0.02599928f, -0.06144742f, -0.03837295f, -0.03233944f, 0.00043045f, -0.02838043f, -0.01923578f, 
    0.00169024f, -0.00394969f, -0.05946021f, -0.05348421f, -0.04515140f, -0.02919670f, 0.03964444f, 0.03287164f, 
    0.02302090f, -0.02790853f, -0.06225011f, -0.02487236f, 0.02544528f, -0.06028460f, -0.06462356f, -0.07515138f, 
    0.03596516f, 0.06085451f, 0.00884498f, 0.05716235f, -0.00632414f, -0.05162206f, 0.01853447f, -0.01308431f, 
    -0.05949541f, 0.04049294f, -0.05353926f, -0.02158278f, 0.01586915f, -0.05564709f, -0.06358735f, 0.00315290f, 
    -0.01801191f, -0.05455836f, -0.01582808f, 0.06431156f, 0.01591789f, -0.05666891f, -0.01742105f, -0.03610086f, 
    -0.01144643f, 0.02790208f, 0.02143965f, 0.02088840f, -0.06842945f, 0.01658420f, 0.05524183f, -0.07522967f, 
    0.02934027f, -0.03998309f, -0.05166448f, -0.01298309f, -0.01763403f, -0.05137821f, 0.02322504f, -0.03553650f, 
    0.04141556f, -0.06069149f, -0.00583009f, -0.04646107f, -0.07166082f, 0.05502239f, -0.00180272f, 0.03846585f, 
    0.01923218f, 0.00184174f, -0.03112213f, -0.03024141f, -0.01044869f, 0.05349377f, 0.01793740f, 0.02193216f, 
    0.03414455f, -0.03103661f, -0.02367183f, 0.03977217f, -0.00170136f, 0.03981682f, -0.03364897f, -0.01871816f, 
    -0.02434248f, 0.05036576f, 0.01796509f, -0.02602411f, -0.05039299f, -0.02144734f, 0.06349847f, -0.01197532f, 
    -0.07082994f, -0.02823348f, -0.05357436f, -0.02352319f, -0.01753655f, -0.07326240f, -0.02739504f, -0.07083101f, 
    0.02599909f, 0.01774144f, -0.00935359f, -0.05020358f, 0.05470497f, 0.02951419f, 0.04785989f, 0.05175963f, 
    0.00506982f, 0.05492873f, -0.07535750f, 0.02415141f, -0.01509444f, -0.06393091f, -0.04752306f, 0.04282318f, 
    -0.01891024f, 0.02962507f, -0.04745391f, 0.05018213f, 0.05812421f, 0.05331837f, 0.04748780f, 0.06160330f, 
    -0.07543538f, 0.01453719f, -0.07681286f, -0.04611578f, -0.03907421f, 0.02732573f, 0.01116247f, 0.02486853f, 
    0.01701062f, 0.01661945f, 0.00177047f, -0.00320175f, -0.03041513f, 0.04849083f, 0.03881617f, 0.02289977f, 
    0.01183885f, 0.01231406f, -0.03646469f, -0.01144084f, -0.02319651f, 0.05783607f, 0.03564159f, 0.01245213f, 
    -0.07547866f, 0.01966146f, 0.01086622f, -0.01069112f, -0.07264830f, 0.03002169f, -0.01420944f, 0.03991495f, 
    -0.02320355f, 0.00772643f, -0.06098447f, -0.02345955f, -0.07250674f, -0.07922249f, -0.04844480f, -0.05512718f, 
    -0.07381682f, -0.06166889f, -0.06434915f, 0.03164621f, 0.05356518f, 0.05529235f, 0.01432605f, 0.04526342f, 
    -0.02664887f, -0.07522124f, 0.13169338f, -0.05923137f, -0.09339267f, -0.07408560f, -0.07554498f, -0.15544151f, 
    -0.03742693f, 0.11657479f, 0.12106270f, 0.00758652f, 0.51468605f, 0.20981531f, -0.13914812f, 0.10190185f, 
    -0.09018058f, -0.06084396f, 0.01532073f, 0.03810903f, 0.08864541f, -0.09877586f, 0.09029594f, 0.00740990f, 
    -0.05498029f, -0.02740034f, -0.02886724f, 0.04325842f, 0.18529406f, -0.04870332f, 0.02081667f, 0.00423009f, 
    0.05555516f, 0.13089789f, -0.11403061f, -0.08325905f, -0.25165626f, -0.03798289f, -0.15910420f, -0.14380176f, 
    -0.07357871f, -0.06964534f, -0.03187836f, 0.01591045f, 0.07361887f, -0.13532552f, -0.03003458f, -0.17881678f, 
    0.02313432f, -0.12558608f, 0.18451612f, -0.00230826f, -0.06552841f, -0.06057189f, 0.09902491f, -0.15931989f, 
    0.08969224f, -0.01833769f, -0.16058466f, 0.05338422f, -0.12813848f, 0.16701502f, 0.24736245f, 0.35054719f, 
    -0.01595912f, 0.05495029f, 0.08140822f, 0.08672678f, -0.05892006f, 0.11320635f, 0.04400442f, 0.05366196f, 
    0.20745271f, 0.27201402f, 0.13888286f, -0.03800847f, -0.02561796f, 0.01214016f, -0.19744708f, 0.10235875f, 
    -0.02398583f, 0.06908328f, 0.10610502f, 0.00410508f, 0.07800031f, 0.09668986f, -0.06981954f, 0.05735460f, 
    -0.11176143f, -0.10268246f, -0.08356985f, -0.07356784f, -0.15457258f, -0.22049278f, -0.03574805f, -0.14630581f, 
    -0.19220287f, -0.30168054f, -0.26910806f, -0.28796232f, -0.05161217f, -0.11209989f, -0.10491468f, -0.09909814f, 
    -0.06887536f, 0.04489454f, -0.01902294f, -0.05926888f, 0.06399739f, 0.14657319f, 0.24787614f, 0.34164789f, 
    0.03385290f, 0.13201910f, -0.02771997f, 0.15501793f, -0.05373627f, -0.04285814f, 0.06361943f, 0.10664603f, 
    -0.13108175f, 0.04562167f, -0.21521333f, 0.04445287f, -0.10783092f, -0.07263400f, 0.04402858f, 0.07531866f, 
    0.12093899f, 0.03990339f, 0.11300791f, 0.01133814f, -0.10100068f, -0.11220212f, -0.06726411f, 0.10856684f, 
    0.16006501f, 0.11705724f, 0.05546789f, -0.00406861f, 0.05543174f, 0.02346037f, 0.05011849f, 0.15761119f, 
    -0.11338169f, -0.05986694f, 0.11467682f, -0.14567256f, -0.02225694f, 0.02329439f, -0.13183074f, -0.05100986f, 
    0.10338535f, 0.14398415f, -0.04668426f, 0.17754650f, 0.04030385f, 0.05602399f, 0.14778374f, 0.10891096f, 
    -0.03380104f, -0.00109823f, -0.06047530f, 0.11424697f, 0.05707112f, -0.03876865f, -0.02181382f, -0.10507166f, 
    0.03720608f, -0.01230664f, -0.04022835f, 0.13503136f, -0.00113457f, -0.16449040f, 0.09579821f, 0.04181161f, 
    -0.03669427f, 0.28450745f, 0.09796523f, 0.04139871f, -0.06325847f, 0.08300550f, -0.17285676f, -0.00320197f, 
    0.07434027f, 0.00734035f, 0.25917974f, -0.03222195f, 0.14891064f, 0.14712617f, -0.06141960f, 0.16028206f, 
    0.01764576f, 0.03846477f, -0.05109407f, 0.01182840f, -0.00756978f, -0.03286175f, 0.02767351f, -0.07535145f, 
    -0.02557077f, 0.05478988f, -0.03781002f, -0.05869371f, -0.05369528f, -0.04477622f, -0.05518247f, 0.06191662f, 
    -0.07353236f, -0.04979907f, 0.01214627f, -0.05778867f, -0.08128852f, -0.01238919f, -0.01682353f, -0.00238858f, 
    0.06001379f, -0.02484478f, -0.03199200f, 0.02506704f, -0.04007025f, 0.03129374f, -0.03967245f, 0.00046069f, 
    -0.06330162f, 0.06846450f, -0.05950311f, 0.03233260f, -0.03370358f, 0.01043244f, 0.04518976f, -0.03045756f, 
    0.05431489f, 0.04943145f, 0.03054610f, -0.00890130f, -0.01932249f, 0.03376067f, -0.05852533f, -0.00543725f, 
    -0.00355847f, 0.06031660f, -0.01789739f, -0.03888119f, 0.01076558f, 0.06176952f, 0.05418675f, 0.02707834f, 
    -0.01667851f, 0.03316551f, -0.06636304f, 0.02258716f, 0.02003793f, -0.04522889f, -0.03846735f, 0.00007832f, 
    -0.00252873f, -0.00800878f, -0.06939981f, -0.06913589f, -0.05687926f, -0.00875106f, 0.06007747f, -0.03033219f, 
    -0.02903673f, -0.03430698f, -0.01127161f, -0.00729532f, -0.04773910f, -0.02124515f, 0.05969146f, 0.02273893f, 
    -0.06697419f, 0.01688159f, -0.00646879f, -0.00887333f, 0.00526600f, -0.05042894f, 0.04200263f, -0.03797792f, 
    -0.02797497f, 0.03983526f, 0.01390923f, -0.08227504f, -0.07703034f, -0.02875483f, -0.07842159f, -0.01772023f, 
    -0.01884223f, 0.02794368f, 0.02639163f, -0.03929913f, 0.01122756f, -0.02412931f, 0.04367150f, -0.01928872f, 
    0.03366566f, -0.07557122f, -0.04873044f, 0.00558432f, 0.06917935f, -0.06001823f, -0.01586149f, 0.03765656f, 
    -0.03660823f, -0.06084903f, -0.05989383f, 0.03223423f, -0.03839185f, -0.03012167f, -0.05055195f, -0.01110345f, 
    -0.05180855f, -0.06783459f, 0.03604797f, 0.01360262f, -0.05844020f, 0.03280236f, -0.04928875f, -0.05763841f, 
    0.04624445f, -0.03811791f, -0.03335244f, 0.02671297f, 0.01638957f, 0.02356726f, 0.02478509f, -0.06727152f, 
    0.02659288f, -0.05582597f, 0.04480202f, -0.04139221f, 0.03635178f, 0.00308140f, 0.01297871f, 0.06145481f, 
    0.05478910f, -0.01912016f, 0.00618889f, 0.05746295f, 0.00672830f, 0.00097345f, 0.02770447f, 0.03143677f, 
    -0.08354682f, -0.08245654f, 0.05151535f, 0.02869046f, -0.07177369f, 0.06363235f, 0.06565600f, -0.01979974f, 
    -0.03369491f, -0.07009325f, -0.02073580f, 0.03074438f, 0.00464873f, -0.01541243f, -0.06191698f, -0.00107685f, 
    -0.06610340f, 0.03498697f, 0.06167357f, -0.03855972f, 0.02032405f, 0.00003078f, 0.05477227f, 0.05267662f, 
    0.02306279f, -0.00740899f, 0.01822473f, -0.01668908f, 0.05678007f, 0.02974864f, 0.03224772f, -0.03876476f, 
    -0.01237226f, -0.00318443f, 0.03282624f, -0.04248757f, -0.00052043f, -0.00405902f, -0.01378280f, 0.03394121f, 
    0.25488168f, -0.14045720f, 0.04764166f, 0.06917353f, 0.07776242f, 0.03828469f, -0.08881285f, 0.10940377f, 
    0.16058408f, -0.06162117f, 0.00997366f, -0.17919002f, 0.15818058f, -0.09750723f, 0.07295174f, -0.15412612f, 
    0.06709459f, -0.13998409f, 0.16384347f, 0.09057365f, -0.17535889f, -0.06053713f, -0.15752660f, -0.08238546f, 
    -0.02015716f, 0.31950793f, 0.27527910f, -0.06109871f, 0.07542287f, -0.01410109f, -0.04248567f, -0.03553391f, 
    0.10368506f, -0.03461446f, 0.15434791f, 0.05118016f, -0.07867559f, 0.05084215f, -0.19350383f, -0.09575470f, 
    -0.00976095f, 0.09037029f, -0.02253877f, 0.13700998f, 0.22482966f, -0.01021872f, 0.16121700f, 0.17710991f, 
    -0.02193426f, -0.34178111f, -0.08740862f, -0.01826768f, 0.19668674f, -0.03540113f, -0.03170973f, -0.06574603f, 
    -0.06054721f, 0.14460880f, 0.01566117f, 0.06238559f, 0.25947791f, 0.18484873f, -0.00436694f, 0.24401797f, 
    -0.18372490f, -0.05186129f, 0.02368015f, -0.10800655f, 0.11248010f, 0.02207338f, -0.01156317f, 0.10986750f, 
    0.47265306f, -0.06872921f, -0.10998405f, -0.02028516f, 0.03070184f, 0.06818463f, 0.24056473f, 0.09949759f, 
    -0.16343056f, -0.01095098f, -0.26049238f, 0.01582799f, 0.19533491f, -0.17726341f, 0.10258630f, 0.12163609f, 
    0.06951587f, 0.10713527f, -0.06518417f, 0.15099795f, 0.26255786f, 0.14802071f, 0.17139226f, 0.17197557f, 
    0.11999299f, -0.02023862f, 0.06083148f, -0.08340009f, 0.15571232f, 0.05564633f, -0.02612949f, 0.05706227f, 
    0.13809717f, -0.12038855f, 0.09830371f, -0.15597118f, 0.32320401f, 0.28842944f, 0.26481423f, 0.21498361f, 
    0.01261717f, 0.06775043f, 0.13023865f, -0.01660759f, -0.06374504f, -0.02469180f, 0.01115295f, -0.21126248f, 
    0.07200153f, -0.11657925f, -0.21992898f, 0.05666075f, 0.06679907f, 0.06770897f, -0.04642265f, 0.04771531f, 
    0.08246500f, -0.20890944f, -0.12849179f, -0.02017023f, -0.08370696f, 0.11724842f, -0.17654750f, -0.30104256f, 
    0.15490942f, -0.05240714f, 0.08604539f, -0.15310171f, -0.16372196f, -0.05805261f, -0.14455694f, 0.07129224f, 
    0.09309861f, -0.08811193f, -0.09492257f, 0.06896137f, 0.09615409f, 0.00884589f, -0.19396982f, 0.01296680f, 
    -0.05612557f, -0.15169130f, 0.00319989f, -0.05262741f, -0.03118733f, 0.13891540f, -0.15646388f, -0.10706238f, 
    0.05885325f, -0.11844872f, -0.01215853f, 0.08325705f, -0.11184413f, 0.07956157f, 0.08249432f, 0.13532086f, 
    -0.08189111f, 0.26735529f, 0.41294891f, 0.11896547f, 0.18753536f, 0.02515517f, -0.13878666f, -0.11853452f, 
    0.12964441f, -0.06566685f, -0.04785710f, 0.04936988f, -0.02560703f, -0.07573931f, -0.08290863f, -0.10384665f, 
    0.07470639f, -0.06707839f, -0.04272147f, -0.09853080f, -0.02974308f, -0.10874378f, 0.18583231f, -0.07059858f, 
    -0.06076841f, 0.02281219f, -0.04939325f, 0.04806011f, 0.02829321f, -0.02043411f, 0.03571041f, 0.01206333f, 
    -0.02598747f, 0.02065724f, -0.06780642f, -0.00733486f, 0.02308038f, -0.02298228f, -0.03260766f, -0.00869021f, 
    0.04901876f, 0.00185713f, 0.00433510f, 0.05452050f, 0.01811514f, 0.04714630f, 0.01343676f, 0.02204548f, 
    0.02323898f, -0.01293819f, -0.00778700f, 0.02306621f, -0.01913451f, -0.02489194f, -0.00445505f, 0.01526546f, 
    -0.06882674f, -0.04192660f, -0.03650887f, -0.02178490f, 0.01461826f, 0.01755423f, -0.01246585f, 0.04246236f, 
    -0.02462970f, 0.04971378f, -0.05109338f, -0.07240314f, 0.06362750f, -0.07226310f, 0.03572559f, 0.05088609f, 
    -0.01355472f, -0.01814522f, 0.01760272f, 0.02262911f, -0.06386841f, -0.01840835f, -0.04217112f, -0.04501563f, 
    -0.04268850f, -0.02425526f, -0.02175808f, -0.03126433f, -0.01230325f, -0.04157813f, 0.00238663f, 0.02220390f, 
    -0.03571853f, 0.05409408f, -0.06772026f, 0.02244267f, -0.02482798f, -0.06925929f, -0.03018062f, -0.04045013f, 
    0.05625558f, 0.06264614f, 0.01700678f, -0.02155130f, -0.06727887f, 0.04174226f, -0.05832820f, -0.06750500f, 
    -0.03575341f, 0.00096803f, -0.01153049f, -0.06061091f, 0.00304338f, -0.02671545f, -0.06631450f, 0.04335725f, 
    -0.03752358f, 0.03252088f, 0.04613534f, -0.07834579f, -0.04417698f, 0.06113321f, 0.00920963f, -0.03458490f, 
    -0.00420829f, -0.02248500f, 0.03957078f, 0.04618463f, 0.04822497f, -0.06720272f, -0.02265545f, 0.01147681f, 
    -0.00294344f, 0.02606011f, -0.06335037f, 0.02473639f, 0.00054867f, -0.01828412f, 0.05300347f, 0.03951766f, 
    -0.00398460f, -0.06470259f, -0.06142495f, -0.01730308f, 0.01329029f, 0.04207167f, 0.04856653f, 0.04335983f, 
    -0.00856286f, -0.08168233f, 0.03048166f, -0.05526466f, -0.00647724f, 0.00070380f, -0.02687600f, 0.02626063f, 
    -0.02388296f, 0.01215356f, -0.01875629f, -0.01431426f, -0.04411926f, 0.02502015f, 0.00738183f, -0.06266203f, 
    -0.05723898f, 0.02874696f, 0.00080672f, -0.00265418f, 0.04353990f, -0.07075847f, -0.01210522f, 0.00097174f, 
    -0.00717859f, 0.01942281f, -0.02302566f, 0.03996164f, 0.03008374f, 0.00332672f, 0.04368401f, -0.06049610f, 
    -0.04760800f, 0.00573525f, -0.03497920f, -0.05609623f, -0.02488863f, 0.03138224f, -0.01528762f, -0.06345693f, 
    -0.04141137f, 0.00355163f, -0.05266627f, -0.02953867f, -0.06198007f, -0.07336481f, -0.04385201f, 0.04665703f, 
    0.04760856f, -0.05197728f, -0.01298869f, -0.04639162f, 0.01149112f, -0.03710667f, 0.05723962f, -0.08025799f, 
    -0.04878065f, 0.06160721f, -0.04601678f, -0.02149205f, -0.06019795f, 0.03632660f, 0.00890962f, -0.05580831f, 
    0.02284786f, -0.06752968f, -0.06109012f, -0.07418615f, 0.02479516f, -0.03131124f, 0.01801408f, 0.06049638f, 
    0.05287317f, 0.03774328f, 0.06393748f, 0.10402644f, -0.05956265f, -0.15269046f, -0.01238974f, -0.02126423f, 
    0.01503132f, -0.06049245f, 0.07828207f, 0.07684297f, 0.20046134f, 0.02218407f, -0.00108676f, -0.00117290f, 
    0.09598822f, -0.02325549f, -0.00873202f, -0.06942167f, 0.16616902f, -0.02878669f, -0.08539464f, -0.02981710f, 
    -0.13103992f, -0.04845488f, -0.04236505f, -0.05830965f, -0.04184863f, 0.13753289f, -0.04143121f, -0.02277251f, 
    -0.06888167f, -0.10446794f, -0.09530566f, -0.03713384f, 0.05981968f, 0.11133125f, -0.00125285f, 0.09658420f, 
    0.08348250f, 0.02888773f, -0.01465346f, 0.02113729f, 0.07248159f, -0.13069670f, -0.02470075f, 0.14117458f, 
    0.08819538f, -0.11712753f, 0.19507489f, 0.06499244f, -0.09793205f, 0.03767692f, -0.09932218f, 0.10872716f, 
    -0.04832951f, 0.00129063f, 0.00101903f, -0.09604608f, -0.37380683f, -0.41974661f, -0.14924109f, -0.19758858f, 
    0.23128752f, 0.11057568f, -0.22943670f, -0.14687812f, 0.05676741f, -0.07203226f, 0.02737215f, 0.03291910f, 
    -0.32768294f, -0.32495463f, -0.21656552f, -0.01008510f, 0.07987420f, -0.17091712f, 0.04685850f, -0.13532761f, 
    -0.00189071f, -0.18489517f, -0.00599489f, 0.14871101f, 0.04091894f, -0.03009920f, -0.04908692f, -0.21067858f, 
    0.00097304f, 0.10028557f, -0.02681271f, 0.05185016f, 0.24579518f, 0.15451592f, 0.01872079f, 0.08549377f, 
    -0.30505431f, 0.08364899f, 0.22869688f, 0.06369353f, 0.01195126f, -0.05125483f, 0.02935077f, 0.08583470f, 
    -0.12040973f, 0.05865604f, 0.12618648f, 0.11047573f, -0.01968904f, -0.23848028f, -0.16791981f, -0.18955138f, 
    0.26736471f, 0.18542561f, 0.06205036f, -0.04675447f, -0.09207930f, -0.05974802f, 0.02261151f, -0.01158205f, 
    -0.26023209f, -0.21233135f, 0.18283658f, 0.14353535f, 0.14240645f, 0.00986064f, -0.17551787f, 0.18603641f, 
    0.02631680f, -0.05188569f, 0.02327004f, 0.04206686f, -0.04064558f, -0.08331217f, 0.33216158f, 0.09384464f, 
    0.04393838f, 0.02922203f, -0.20991357f, -0.00599323f, -0.07704452f, 0.00219202f, 0.01627793f, 0.12342373f, 
    -0.02831559f, 0.02903525f, 0.04127729f, 0.18622009f, 0.01327673f, -0.05098520f, -0.00647162f, 0.00158866f, 
    0.08124005f, -0.06445550f, 0.14829502f, -0.05008657f, 0.06631915f, 0.08019952f, 0.31706786f, -0.09908827f, 
    -0.12277764f, -0.04300031f, 0.07998554f, 0.05125816f, 0.03697991f, 0.09675546f, -0.04649120f, -0.03344835f, 
    -0.06761067f, -0.31606850f, 0.30573571f, 0.04760440f, -0.12545705f, 0.03083515f, 0.05496662f, 0.39706922f, 
    0.06064125f, -0.06407113f, 0.23892199f, 0.02312816f, -0.03100289f, 0.26501971f, 0.13752206f, -0.17021681f, 
    0.04675476f, 0.07768433f, 0.02140402f, 0.27817476f, 0.10493445f, 0.07108030f, 0.16311255f, 0.06268231f, 
    -0.02710144f, -0.02195609f, 0.00902031f, -0.01809791f, -0.05816842f, -0.02933292f, -0.01718956f, 0.06803294f, 
    -0.01913853f, 0.01513300f, -0.01051801f, -0.01620007f, 0.04926840f, -0.03499466f, -0.05327660f, 0.00089037f, 
    -0.07115001f, -0.07036664f, 0.03934914f, 0.00600022f, -0.02560061f, -0.05038533f, 0.03603609f, 0.03711941f, 
    0.00200742f, 0.06236313f, 0.05472022f, -0.04322263f, 0.01624610f, -0.06973118f, 0.01907289f, -0.06610050f, 
    -0.06954970f, 0.03416606f, -0.01803247f, 0.02478245f, 0.02257333f, 0.02562509f, 0.03795489f, -0.05458888f, 
    -0.00231890f, 0.00459346f, -0.00357408f, 0.04171693f, 0.04058999f, -0.06298739f, -0.07449479f, 0.05732617f, 
    0.04045179f, -0.05433895f, 0.01668045f, -0.00418825f, -0.03351928f, -0.06374451f, 0.05173828f, -0.05271055f, 
    -0.02314374f, 0.06019017f, -0.02996236f, -0.00663618f, -0.02433753f, 0.03466061f, -0.06620639f, -0.01288989f, 
    0.03195825f, 0.06293269f, -0.00274840f, 0.01135312f, -0.07618114f, -0.05595185f, -0.03263246f, -0.04287289f, 
    0.00166714f, 0.01850485f, 0.03154984f, 0.06544302f, -0.02847776f, 0.04811062f, 0.06602339f, 0.02693264f, 
    0.03880899f, 0.01755258f, -0.00264036f, -0.01632081f, 0.06164667f, -0.03160239f, -0.01822801f, -0.02567380f, 
    -0.04633325f, 0.02037810f, -0.06171149f, -0.04126391f, 0.03835165f, -0.00833041f, 0.01283907f, -0.06924848f, 
    -0.00513215f, -0.02389868f, -0.05668851f, 0.01143659f, 0.05921482f, 0.05901381f, -0.02654728f, -0.00285950f, 
    -0.00206877f, 0.03098795f, -0.06741037f, -0.02365363f, -0.06243821f, 0.04536464f, 0.01590946f, -0.02572425f, 
    -0.04869587f, 0.00313549f, 0.06545129f, 0.02717341f, 0.00276379f, 0.01847119f, -0.00534282f, -0.05333418f, 
    0.03763774f, -0.01983067f, -0.03185123f, 0.06378732f, -0.03038091f, -0.04724668f, -0.01574568f, -0.06692508f, 
    0.02655073f, 0.03220278f, 0.06455428f, 0.03251014f, 0.05378111f, -0.07356501f, -0.06776612f, -0.05495529f, 
    0.00589923f, 0.02260737f, -0.05709283f, 0.02497297f, -0.04911153f, 0.00790361f, -0.00768218f, -0.06519439f, 
    0.04151595f, -0.04905175f, 0.04892788f, 0.00777982f, -0.00197858f, 0.04047883f, 0.00529144f, -0.04427937f, 
    -0.06673241f, -0.07080412f, -0.04397535f, -0.04522583f, 0.01606197f, -0.07590140f, -0.04192827f, 0.01040627f, 
    0.03516019f, 0.03035519f, 0.03988270f, 0.01905376f, -0.03725989f, -0.04896332f, 0.00746468f, -0.05571187f, 
    -0.02566241f, -0.04486137f, 0.01690864f, -0.06696665f, -0.07535328f, -0.03532730f, -0.07146924f, -0.06754072f, 
    0.00641060f, 0.04691233f, -0.04242947f, -0.04457667f, -0.03805555f, 0.02370575f, -0.05853729f, 0.04800282f, 
    -0.06038629f, -0.06440863f, 0.01331809f, -0.07590490f, -0.07572161f, 0.01708906f, -0.05978098f, 0.00131435f, 
    -0.03565820f, 0.11884661f, -0.00566850f, -0.09034798f, 0.02702974f, -0.06685968f, -0.02883824f, 0.00469043f, 
    0.08882017f, 0.04652403f, 0.03962190f, 0.06790113f, -0.12122065f, -0.11758856f, -0.02296106f, -0.17237364f, 
    -0.02749258f, 0.10068797f, -0.07192036f, -0.11348251f, 0.02615045f, 0.11442068f, -0.01105564f, 0.05439292f, 
    -0.15847397f, 0.04641283f, -0.30910030f, 0.20462030f, 0.04881562f, -0.10636448f, 0.16481602f, 0.15258636f, 
    -0.00948288f, 0.00071428f, 0.04908274f, 0.06679662f, -0.07468709f, -0.01274169f, 0.20191216f, 0.02571575f, 
    -0.05680351f, 0.04846669f, -0.01614872f, -0.00708707f, 0.08560260f, 0.17309202f, 0.18372349f, 0.02996525f, 
    0.25946614f, 0.10860400f, 0.05929752f, 0.22922301f, 0.05838124f, 0.03879643f, -0.07286786f, -0.09310817f, 
    -0.00396908f, 0.02805877f, 0.05761895f, -0.08170055f, 0.25327447f, -0.20568813f, 0.05547130f, -0.28908449f, 
    0.05893951f, -0.00910282f, -0.02258299f, 0.22122107f, 0.02146978f, 0.08171226f, -0.04586890f, -0.03063854f, 
    0.03638667f, 0.01488197f, -0.13697837f, -0.05341778f, -0.01073803f, -0.11909573f, 0.01926289f, -0.22325404f, 
    0.05029061f, 0.02543477f, -0.12020791f, 0.01451722f, -0.02743392f, -0.09473532f, 0.09353149f, -0.06740062f, 
    0.06213065f, 0.07941002f, 0.10887747f, -0.03641945f, 0.03602561f, 0.12020303f, 0.01663001f, 0.15686806f, 
    0.49868476f, 0.12961879f, 0.24261594f, 0.12207758f, -0.12516470f, -0.05467303f, -0.16280663f, -0.18846072f, 
    0.08278481f, -0.05885272f, -0.01019908f, 0.19241232f, -0.06958313f, 0.00774351f, -0.10026187f, -0.00566478f, 
    -0.06416120f, -0.07566141f, -0.06334546f, 0.01391831f, 0.01666664f, 0.01049893f, -0.03481653f, 0.01262383f, 
    0.29042119f, 0.10590582f, 0.08152956f, -0.07499163f, 0.10125150f, 0.08255767f, -0.11984527f, 0.06846070f, 
    -0.16519487f, -0.04174934f, 0.10707721f, 0.10293372f, 0.49602553f, -0.13240878f, -0.00651496f, 0.05786023f, 
    -0.13312697f, -0.00237231f, -0.10990452f, 0.25238836f, 0.20412527f, 0.03064012f, -0.03201222f, -0.21368080f, 
    -0.06592769f, 0.06581352f, -0.01559478f, -0.01334222f, -0.06608357f, -0.01085929f, 0.26754090f, -0.09398323f, 
    -0.16275847f, -0.06048480f, 0.03792026f, -0.16079478f, 0.29378578f, -0.25785428f, 0.04514106f, -0.03829837f, 
    0.08784256f, 0.05005940f, 0.00135993f, 0.00356498f, 0.03134789f, -0.02854396f, 0.08654193f, 0.06951864f, 
    0.14942566f, -0.26488543f, -0.08533318f, 0.25549734f, -0.01546558f, 0.31259608f, -0.16586632f, -0.23014575f, 
    -0.12104536f, -0.12094931f, 0.05576888f, -0.24883272f, -0.23998174f, 0.15298235f, 0.06439441f, 0.05526220f, 
    0.01532699f, 0.06839063f, 0.06777149f, 0.08738638f, -0.00780364f, 0.04729460f, 0.18944483f, 0.06239133f, 
    0.03859393f, -0.05259275f, -0.14847228f, -0.06613082f, -0.07523809f, 0.01476761f, 0.03895453f, 0.01865513f, 
    0.02005237f, 0.04498747f, 0.04575797f, 0.14230596f, 0.15799104f, 0.00648201f, 0.07614709f, -0.16438462f, 
    -0.02335733f, -0.06561675f, 0.12253080f, 0.04683510f, 0.02914875f, 0.06115206f, 0.06486809f, -0.00500681f, 
    -0.00143338f, -0.11949478f, -0.18386108f, -0.04563011f, 0.10754548f, 0.03622533f, 0.12284235f, -0.06681907f, 
    -0.03742515f, 0.08237614f, -0.03361631f, 0.06281503f, -0.05239305f, 0.13803335f, 0.07262770f, -0.13306621f, 
    -0.03847731f, -0.21326080f, 0.05434270f, -0.08919143f, -0.01744508f, 0.09872713f, 0.01277822f, 0.04530616f, 
    -0.04851453f, -0.23684338f, 0.04557036f, 0.30559945f, -0.06292053f, -0.00176223f, -0.02022916f, -0.02305379f, 
    0.06117739f, 0.14343907f, 0.04333314f, 0.06619099f, -0.01158695f, 0.19779627f, 0.12585758f, -0.00684495f, 
    -0.10703681f, -0.02966644f, -0.02634780f, 0.02833405f, -0.03052521f, 0.03194728f, -0.04210168f, -0.01098089f, 
    0.52371830f, 0.34179035f, -0.01960035f, -0.02113560f, 0.12681098f, 0.05539677f, -0.05956370f, 0.05471256f, 
    -0.03489259f, 0.01224469f, -0.06432953f, -0.10704608f, 0.02786780f, 0.07708728f, -0.09797038f, 0.00924616f, 
    0.03712539f, -0.08158193f, -0.05276978f, -0.11159392f, -0.07008392f, -0.01293881f, -0.00235218f, 0.04303214f, 
    -0.25103012f, 0.09757154f, 0.08104325f, 0.26576394f, -0.01364336f, -0.00065000f, -0.08909960f, -0.04072140f, 
    0.00204869f, 0.06753562f, -0.01251731f, 0.07762282f, -0.25005552f, 0.01940882f, 0.02500211f, 0.05058206f, 
    -0.05213693f, -0.19411886f, 0.01356305f, 0.12424371f, -0.08931937f, -0.11977680f, -0.02701850f, 0.05477158f, 
    0.19624346f, 0.38839883f, 0.02684265f, 0.05292707f, 0.04545053f, 0.07076698f, -0.00017374f, 0.09862281f, 
    -0.16562653f, -0.12813395f, -0.08303618f, 0.03702218f, -0.11777697f, -0.22048829f, 0.03482353f, 0.35427237f, 
    -0.00923049f, 0.03306209f, 0.06549807f, -0.01948208f, 0.10776028f, -0.08852476f, 0.09322096f, -0.07430589f, 
    0.09507530f, -0.10569371f, 0.06079484f, -0.03011942f, -0.00668175f, 0.06188861f, 0.07098825f, 0.07083387f, 
    -0.06654342f, 0.19275901f, 0.00852998f, -0.01133781f, 0.00629667f, -0.07445515f, -0.00242773f, 0.16634846f, 
    -0.01453715f, 0.01494602f, -0.07505634f, 0.05430209f, 0.10989013f, 0.03855165f, 0.02817905f, 0.06399084f, 
    -0.19297570f, -0.07157947f, -0.45710301f, 0.42151740f, 0.08589405f, -0.11793960f, 0.10973318f, -0.07762609f, 
    -0.10255630f, 0.04382800f, 0.18995957f, -0.01500733f, -0.06958617f, 0.07270354f, 0.16426924f, -0.06860712f, 
    -0.04683107f, 0.00907177f, 0.22737209f, 0.09539486f, 0.01728202f, -0.06816288f, -0.00033270f, 0.02696288f, 
    -0.17230001f, -0.17646283f, -0.05514789f, 0.01206767f, -0.02930127f, 0.07906190f, -0.12167399f, 0.11506211f, 
    0.06855418f, 0.10933133f, -0.00102147f, 0.00919805f, -0.22024614f, -0.06239362f, -0.28094855f, -0.30222711f, 
    -0.03856767f, -0.10523207f, -0.03782224f, 0.00154774f, -0.02570791f, 0.01353464f, -0.00878044f, 0.12032862f, 
    0.00838503f, 0.09651229f, 0.00016501f, -0.03481176f, -0.00046795f, -0.00746781f, -0.20118485f, 0.08671567f, 
    -0.08295038f, -0.08814923f, 0.03400416f, -0.02221955f, 0.09137185f, 0.06454528f, 0.23995359f, 0.01224418f, 
    0.15933034f, 0.08203402f, -0.03161037f, -0.08628735f, 0.03726315f, 0.11011184f, -0.12679276f, 0.08316690f, 
    -0.07586759f, -0.36040422f, 0.04239684f, -0.23805502f, 0.04803337f, 0.06304040f, 0.12669832f, 0.01280479f, 
    -0.15018366f, -0.01233785f, -0.02079939f, -0.26156846f, -0.11048225f, 0.27595335f, 0.13383138f, -0.20833835f, 
    -0.00253648f, -0.04931802f, -0.05807558f, 0.17013393f, 0.00094791f, 0.04600642f, 0.02361896f, -0.01011337f, 
    -0.20295925f, 0.32442465f, -0.15831190f, -0.02597260f, -0.05154230f, -0.23565763f, -0.08317559f, -0.03649913f, 
    0.07854857f, -0.01847222f, -0.00955926f, 0.02268753f, -0.11148123f, 0.02911978f, -0.04969140f, -0.21705544f, 
    -0.01419702f, -0.13389224f, -0.14996722f, 0.07417554f, -0.00767512f, 0.10259134f, -0.04516268f, 0.14298183f, 
    -0.17370206f, 0.08395413f, 0.04177870f, 0.18264472f, 0.08548693f, 0.12906408f, 0.07604486f, 0.10125637f, 
    0.06494267f, -0.02322165f, 0.01736935f, -0.10328613f, -0.01961484f, 0.08468097f, 0.25967541f, 0.10039449f, 
    0.00528174f, -0.18703917f, -0.01895972f, 0.03292504f, -0.00067154f, 0.00029534f, -0.03545948f, 0.09442768f, 
    0.21551482f, 0.35779566f, 0.17033544f, 0.13648589f, 0.03336583f, 0.21165420f, 0.00191782f, 0.02740270f, 
    -0.08164370f, 0.07133317f, -0.24232346f, -0.04819222f, 0.06304915f, 0.00346284f, 0.45333734f, 0.20110629f, 
    0.01561554f, 0.07789660f, 0.16291060f, -0.03755406f, 0.02959856f, 0.00189229f, -0.05640544f, -0.07772969f, 
    -0.05147352f, -0.13248052f, 0.02729343f, -0.04551710f, 0.05897865f, 0.07669485f, -0.05091353f, 0.03500712f, 
    -0.06600977f, 0.08334308f, -0.10048818f, -0.01420560f, 0.35175031f, 0.22488956f, 0.22727856f, 0.08695309f, 
    -0.03702042f, -0.12011658f, -0.06795431f, 0.06141609f, 0.00598575f, -0.07549804f, 0.08585778f, 0.26148286f, 
    -0.25704372f, 0.39865774f, 0.11161685f, -0.02701130f, -0.00873391f, -0.10306591f, -0.03937295f, 0.05460337f, 
    -0.04531944f, -0.05259383f, 0.06413691f, 0.00217156f, 0.20581500f, 0.16903883f, 0.34919876f, 0.12753604f, 
    -0.11591862f, -0.06963796f, 0.13203889f, -0.10306165f, -0.12459691f, 0.02867170f, -0.02035120f, 0.02640684f, 
    -0.19424152f, -0.14332217f, -0.11173359f, -0.13637920f, -0.06192764f, -0.01988532f, -0.18642908f, 0.02228854f, 
    0.02949177f, 0.02914060f, -0.00842541f, -0.04008108f, -0.35041323f, -0.06292874f, -0.09300339f, 0.19379134f, 
    -0.08757940f, -0.03285572f, -0.02562693f, 0.02934674f, 0.02162660f, -0.07850181f, -0.04137021f, -0.06915271f, 
    0.28448412f, 0.00137276f, 0.16299038f, 0.08938764f, 0.12818860f, 0.00302823f, -0.05038952f, 0.09995694f, 
    0.01397137f, 0.08343481f, -0.05059373f, -0.02941517f, 0.10630567f, -0.15874603f, 0.20019139f, 0.19516225f, 
    0.24680410f, -0.01297214f, -0.04302157f, -0.16386519f, 0.04307026f, 0.07633913f, -0.07571470f, 0.00521296f, 
    -0.16335164f, 0.00661460f, 0.03891694f, -0.18946964f, 0.01145959f, 0.01613609f, 0.09510829f, -0.01771262f, 
    -0.02976847f, -0.04123306f, -0.18911380f, 0.04491632f, -0.11394893f, 0.36132362f, 0.19764560f, 0.25339803f, 
    0.11393365f, 0.10469212f, 0.05941274f, 0.17816228f, -0.03277522f, 0.00283137f, 0.07294992f, -0.02770942f, 
    -0.05269166f, 0.44252536f, 0.27152488f, 0.21226782f, -0.20029289f, -0.10299321f, 0.00768841f, 0.17210498f, 
    0.04960402f, -0.00960975f, 0.07809182f, -0.08261675f, -0.14188050f, 0.11886457f, -0.12402220f, 0.13820148f, 
    -0.02814789f, -0.19899771f, -0.21119921f, -0.12998836f, -0.15267794f, 0.01872215f, -0.03914291f, -0.14728577f, 
    -0.02385044f, 0.04936437f, -0.26265374f, -0.05611982f, 0.09606017f, 0.09584398f, 0.08824620f, -0.01166369f, 
    -0.05245573f, 0.13860767f, 0.05840864f, -0.07367124f, 0.21592216f, 0.17960691f, 0.35004461f, 0.40622759f, 
    0.00585169f, 0.13409777f, 0.06609450f, 0.18781051f, -0.04446385f, 0.06240904f, 0.01513329f, 0.05883969f, 
    0.22938147f, 0.13017924f, 0.01476406f, 0.05329448f, 0.17065725f, 0.09696008f, 0.12453386f, 0.05041311f, 
    0.06768299f, 0.12791619f, 0.06471586f, 0.02079105f, -0.10246814f, 0.21446003f, 0.19503616f, 0.05142054f, 
    0.03890948f, -0.11846271f, 0.20358115f, -0.07672805f, -0.06520864f, 0.06081874f, 0.01167603f, 0.11466427f, 
    -0.05496489f, -0.22465219f, -0.09558437f, -0.16475028f, -0.01322246f, 0.00837744f, -0.13156986f, 0.10112207f, 
    0.13319935f, -0.00629732f, -0.05499636f, 0.18932295f, -0.08631288f, 0.09803598f, -0.03964394f, 0.10611799f, 
    0.10965982f, 0.12247054f, -0.06547806f, -0.05810004f, -0.00466948f, -0.10329427f, 0.04274533f, -0.02931785f, 
    -0.00990776f, 0.60483313f, -0.23653406f, -0.16915999f, 0.10959551f, -0.24868701f, -0.02693527f, -0.05028456f, 
    0.01825303f, 0.07875677f, 0.02292876f, 0.27499434f, 0.43485004f, -0.19175099f, 0.13669832f, 0.24391216f, 
    0.10528953f, 0.04748207f, 0.02843772f, -0.00461108f, 0.08039939f, 0.06520265f, -0.21175726f, 0.07738500f, 
    0.15269567f, -0.04732836f, 0.13968067f, 0.09485929f, 0.09816744f, -0.23191343f, -0.28649184f, -0.21126318f, 
    0.08906086f, 0.00884083f, -0.21071430f, -0.03356109f, 0.03057816f, 0.23899302f, 0.03510817f, -0.14242251f, 
    -0.08179181f, -0.00837321f, -0.33800524f, 0.07245254f, -0.08668635f, -0.03187070f, -0.02519470f, 0.02598487f, 
    -0.04843216f, 0.25017127f, 0.12063037f, 0.10706800f, 0.01224202f, 0.07705336f, -0.04304315f, 0.17530379f, 
    0.01460275f, 0.06901947f, -0.09264824f, -0.01171891f, -0.07975692f, -0.08175465f, 0.04644177f, -0.07903194f, 
    0.11904085f, 0.05365996f, -0.05705182f, -0.22403978f, 0.23544371f, 0.15199469f, 0.01439473f, 0.15957963f, 
    0.13413531f, 0.10095982f, -0.09254175f, 0.47855914f, -0.06592910f, -0.04194766f, -0.14755088f, -0.18743457f, 
    -0.03619613f, -0.07074574f, 0.02084358f, -0.02955954f, 0.19773202f, -0.00478428f, -0.06957508f, -0.36667439f, 
    0.12480563f, 0.07024711f, 0.11845553f, 0.29155302f, 0.08917980f, -0.01320627f, 0.04826177f, -0.11466473f, 
    0.10696638f, 0.39204744f, 0.08182558f, -0.02969784f, -0.13956399f, -0.12176555f, 0.00938640f, 0.03776258f, 
    0.06260390f, -0.13001220f, -0.12345003f, -0.22056068f, 0.18026686f, -0.00674704f, 0.31724980f, -0.11146241f, 
    -0.20165275f, 0.15220636f, 0.10923689f, -0.03443438f, -0.06597442f, 0.08663061f, 0.09134334f, 0.12190793f, 
    0.56628406f, -0.14495862f, 0.00158046f, 0.26324883f, 0.19087410f, -0.27252346f, -0.07252908f, -0.20528625f, 
    0.15205246f, -0.03694740f, 0.01733651f, 0.10512067f, 0.02510317f, 0.16278963f, 0.07050120f, 0.15131113f, 
    0.10342513f, 0.02347861f, 0.05961877f, 0.11311905f, -0.05504699f, 0.04688377f, 0.06440962f, -0.04881116f, 
    0.24364464f, 0.00862503f, -0.02684078f, -0.25308099f, 0.15588956f, 0.09276287f, -0.16460107f, 0.13382749f, 
    0.12209325f, 0.08119394f, -0.16230656f, -0.01631866f, 0.19751528f, 0.07958146f, 0.16776264f, -0.05094943f, 
    0.05359210f, 0.12765598f, -0.17372072f, 0.14134446f, 0.14555643f, -0.11912289f, 0.09078494f, -0.00594271f, 
    -0.18782948f, -0.11561194f, -0.12285262f, -0.40876761f, -0.08038644f, -0.06948719f, 0.04716570f, -0.25198394f, 
    -0.10358638f, 0.03405747f, -0.38843998f, -0.05851860f, 0.29920983f, 0.11720675f, 0.14634252f, -0.18648361f, 
    -0.06721754f, -0.07374239f, -0.03684945f, -0.02701741f, 0.08338105f, -0.05329374f, -0.08141378f, 0.11181910f, 
    0.21903056f, 0.05108795f, 0.42844456f, 0.09525747f, -0.06166565f, -0.00798340f, -0.10646632f, -0.16471133f, 
    -0.12935199f, -0.00705079f, -0.05064573f, -0.04794210f, -0.10713952f, 0.18412475f, 0.00707746f, 0.07230929f, 
    0.23329102f, 0.09625316f, 0.11881783f, -0.17490324f, -0.02769730f, -0.02124267f, -0.02740380f, 0.07104591f, 
    0.00407354f, -0.07094920f, 0.03433809f, 0.02164573f, -0.00610933f, -0.02679216f, -0.07786616f, -0.07498638f, 
    -0.02976468f, -0.00951537f, -0.02468210f, 0.00393603f, -0.02656120f, -0.01991043f, -0.07107423f, 0.00902842f, 
    0.05587475f, 0.04750902f, 0.03634535f, -0.07558619f, -0.04510738f, 0.05162314f, -0.06475157f, 0.01915845f, 
    0.05335328f, -0.00038362f, -0.02653593f, -0.03936291f, 0.04684750f, -0.04554143f, -0.06013888f, -0.02367930f, 
    0.02746059f, -0.02856761f, 0.02841138f, -0.05361150f, -0.06701713f, 0.01534218f, -0.00985492f, 0.05444174f, 
    -0.05109953f, 0.05547608f, 0.04783822f, -0.00184797f, -0.05584159f, 0.00422775f, 0.01605317f, -0.05986032f, 
    0.04847869f, -0.00363916f, -0.06396814f, -0.02539362f, -0.00734937f, 0.02798518f, -0.06426260f, -0.01352640f, 
    0.02570699f, -0.04739778f, -0.01120445f, -0.08083807f, 0.07265447f, 0.02985854f, 0.01242588f, -0.02830195f, 
    0.05872552f, 0.06010055f, 0.01705382f, -0.04497865f, -0.01445128f, -0.06689277f, 0.03667626f, -0.07795928f, 
    0.03143412f, 0.04265069f, 0.04142783f, 0.02985446f, 0.02558091f, -0.04155792f, -0.05534224f, -0.02320600f, 
    0.03524840f, -0.05115416f, 0.00006936f, -0.03561983f, -0.00490571f, 0.04672664f, -0.01759194f, 0.02986971f, 
    0.01051161f, -0.02584971f, 0.00161178f, -0.08063348f, -0.01158904f, 0.04114458f, 0.06255710f, -0.01927614f, 
    0.02084700f, -0.00220016f, 0.05703961f, -0.00733386f, -0.05104114f, -0.04079995f, 0.00934711f, -0.04960047f, 
    0.05312662f, 0.03088770f, -0.06221741f, 0.00797328f, -0.00000349f, -0.06373963f, -0.06547768f, -0.02485217f, 
    -0.02422330f, 0.06015552f, 0.04979668f, 0.02761779f, 0.02100825f, -0.00612638f, -0.03766333f, -0.05820392f, 
    -0.00665762f, -0.04828544f, 0.03140246f, -0.06814545f, 0.01101199f, 0.00370518f, -0.08401305f, -0.04793680f, 
    0.04206351f, -0.06501575f, 0.02815676f, 0.04754968f, -0.07927252f, -0.03779061f, -0.06913187f, -0.06765233f, 
    -0.05251443f, -0.04352341f, 0.05022601f, 0.05832852f, -0.04446200f, 0.05075345f, 0.00331614f, -0.07436860f, 
    -0.04372548f, -0.00022011f, 0.04263885f, -0.00781792f, -0.07448918f, -0.02575911f, -0.03295830f, -0.06958144f, 
    0.00485498f, 0.03744518f, -0.06794000f, -0.00196865f, -0.03406770f, 0.05062111f, -0.00989346f, -0.06730351f, 
    -0.03756994f, -0.04920267f, -0.06654964f, -0.03955311f, 0.05720630f, 0.03860074f, 0.01361940f, -0.08046561f, 
    -0.04496095f, 0.03114281f, -0.03298043f, -0.02164547f, -0.04442480f, -0.04778722f, 0.03604778f, 0.01364555f, 
    -0.04197191f, -0.08199662f, -0.02571371f, 0.02580059f, -0.01926069f, -0.01541124f, -0.02219590f, -0.02413570f, 
    -0.07258660f, -0.01031264f, 0.02226317f, 0.03302591f, 0.00176989f, 0.04933069f, 0.01516342f, -0.03881778f, 
    0.06034998f, 0.10298202f, -0.03878710f, -0.11664321f, -0.07910552f, -0.11232135f, 0.07391033f, -0.12738410f, 
    0.01644430f, 0.16455962f, 0.09333032f, 0.03064829f, 0.12511085f, 0.08709189f, -0.10292843f, 0.25870240f, 
    -0.00747873f, 0.13420698f, -0.09605123f, -0.02228014f, 0.16029510f, 0.06264070f, -0.02140320f, -0.02913113f, 
    0.02562477f, -0.08176556f, -0.07896464f, 0.27432811f, -0.08112105f, -0.01872766f, 0.26215702f, -0.02815508f, 
    0.10291471f, -0.01109323f, -0.21791306f, 0.01398587f, -0.02669941f, -0.08897755f, -0.21857215f, -0.06683772f, 
    -0.09264837f, -0.07839768f, 0.10478426f, 0.16060983f, -0.00234787f, -0.07443870f, 0.01424647f, -0.13529633f, 
    0.00515576f, 0.37059262f, -0.03328455f, -0.12816460f, -0.00226055f, 0.04735902f, -0.06651623f, 0.00981035f, 
    0.12810794f, -0.08197408f, -0.01594354f, 0.04101393f, 0.22108100f, -0.04552599f, 0.22141667f, 0.33847040f, 
    0.18817317f, 0.12632430f, 0.05581245f, 0.16281533f, -0.04412753f, 0.06480534f, -0.12546761f, 0.00120865f, 
    -0.35161287f, -0.34063864f, 0.20259479f, 0.00964675f, 0.04452340f, 0.09595907f, -0.06002505f, 0.04395023f, 
    0.11525586f, 0.11236934f, 0.02445431f, 0.05131859f, -0.04867301f, -0.08812511f, -0.08831432f, 0.05705781f, 
    -0.14286965f, 0.06630144f, 0.04532266f, -0.10006917f, -0.02096666f, -0.15143441f, 0.05673291f, -0.22727628f, 
    0.50229239f, -0.22230634f, -0.07096472f, -0.17756537f, 0.02099071f, -0.26009202f, 0.08662417f, -0.08378438f, 
    -0.13074650f, 0.08163494f, -0.13254045f, 0.03748746f, -0.04292060f, -0.05802654f, -0.06404574f, 0.24502447f, 
    0.06106180f, 0.13180251f, -0.00050441f, 0.11553912f, 0.03889359f, 0.07469499f, -0.02758297f, 0.06116053f, 
    0.15531158f, -0.20095150f, 0.04907247f, -0.06020702f, -0.01609363f, -0.19295116f, 0.03124280f, 0.06094978f, 
    0.05005689f, 0.16619179f, 0.28991094f, 0.03569045f, 0.03886160f, -0.01302878f, -0.22715664f, 0.04273978f, 
    -0.07675485f, 0.09473886f, -0.13469167f, 0.05387849f, 0.03374500f, 0.02306360f, 0.03527458f, -0.02323223f, 
    -0.02953152f, 0.07810768f, 0.00460262f, -0.08637973f, 0.01480692f, 0.02920464f, 0.08847058f, -0.10064884f, 
    0.15100047f, 0.14335224f, 0.03523801f, 0.09327707f, -0.19055113f, -0.08616208f, 0.05685386f, 0.03017954f, 
    0.07319032f, 0.03028737f, 0.06966271f, 0.08525182f, -0.04208839f, -0.14151824f, -0.19653061f, -0.21740542f, 
    0.30501503f, -0.25375524f, 0.16233517f, 0.00326256f, 0.16662727f, -0.00591366f, 0.08041174f, -0.03244730f, 
    0.00791062f, 0.08243344f, -0.13222022f, 0.10607633f, 0.11311363f, 0.15348415f, -0.18225184f, 0.06135316f, 
    -0.03844583f, 0.00416241f, 0.08153656f, -0.01509236f, 0.03087352f, 0.06155705f, 0.03015117f, 0.08441769f, 
    -0.04250669f, 0.05441832f, 0.06483183f, 0.04310223f, 0.04502907f, -0.00387708f, -0.04080685f, 0.01195246f, 
    0.07199921f, -0.02243041f, -0.05536253f, -0.03608745f, 0.00312550f, -0.02213707f, 0.04780335f, -0.03911922f, 
    -0.06860978f, -0.00176759f, 0.00686975f, -0.04839843f, -0.02284431f, 0.00413447f, -0.01778298f, -0.04898677f, 
    -0.02381859f, -0.06523726f, 0.01173264f, -0.00972259f, 0.01790865f, 0.03494062f, 0.03824665f, 0.05046936f, 
    -0.04979122f, -0.03625331f, 0.06972708f, 0.01596224f, -0.01650845f, 0.06226221f, 0.04193272f, -0.00155417f, 
    0.03228693f, -0.02209492f, 0.00762571f, 0.01826795f, -0.00949426f, 0.06551360f, -0.05476301f, -0.03557772f, 
    -0.04530238f, 0.03816795f, 0.05248060f, -0.03557541f, 0.00013311f, 0.05104287f, -0.04159733f, -0.01572703f, 
    -0.01923645f, -0.04191619f, 0.05246254f, -0.00008061f, 0.04329989f, -0.01780812f, 0.05871923f, -0.06416875f, 
    0.03143531f, 0.06317844f, -0.06261117f, -0.06757589f, -0.04864957f, -0.06494225f, -0.03125883f, -0.06660549f, 
    0.06506344f, -0.05977168f, -0.06114127f, 0.05855226f, 0.05931746f, -0.02439853f, -0.06463359f, -0.04909154f, 
    -0.04510631f, -0.03214179f, 0.03763578f, 0.01600084f, -0.01364379f, -0.04243061f, -0.00430462f, 0.00555391f, 
    -0.05244945f, -0.01684864f, -0.06547382f, 0.06511454f, -0.00427482f, -0.06089660f, 0.06355011f, -0.06395091f, 
    -0.01413448f, -0.06112247f, -0.06818169f, 0.01067384f, 0.03397812f, -0.05892474f, 0.03247844f, -0.06020078f, 
    0.06163155f, -0.03789208f, 0.07071630f, -0.05678722f, 0.00836837f, 0.01326975f, 0.05492320f, -0.04616281f, 
    -0.04970592f, -0.01739777f, -0.06978777f, -0.03128306f, -0.06082407f, -0.05023489f, 0.05206345f, -0.05669682f, 
    -0.05376546f, -0.03935296f, -0.02593655f, -0.02846061f, -0.06321593f, 0.04186956f, -0.04727179f, -0.06860472f, 
    -0.03410932f, -0.01634853f, -0.06560899f, -0.03489240f, 0.03549586f, 0.01996158f, 0.00260416f, -0.06234294f, 
    -0.06928708f, 0.00154125f, -0.02420544f, 0.01733072f, -0.05984013f, 0.06307368f, -0.05689285f, -0.04874964f, 
    -0.04525020f, 0.04546542f, 0.04116770f, -0.03123333f, -0.05163597f, -0.04874229f, 0.06280615f, 0.04316559f, 
    0.03068531f, -0.03844952f, -0.04439732f, -0.05413761f, 0.06629966f, -0.03347123f, 0.04838879f, -0.06821276f, 
    -0.02447736f, -0.06956279f, 0.01949515f, -0.04256053f, -0.03073455f, -0.04993624f, -0.01012514f, 0.01355234f, 
    -0.01189338f, -0.00280923f, 0.00491646f, 0.06305329f, -0.04707868f, -0.06285652f, 0.07191446f, -0.05816458f, 
    -0.03785497f, 0.06264164f, 0.00455547f, -0.05511142f, -0.05093605f, -0.00391160f, 0.05992293f, -0.02416556f, 
    -0.06672604f, -0.05086928f, 0.02805184f, -0.06070932f, 0.04406033f, 0.04412302f, -0.02814834f, 0.00275805f, 
    -0.04195217f, -0.03416821f, -0.03939268f, -0.01580812f, 0.04236139f, -0.04646043f, 0.06384146f, -0.02789128f, 
    -0.08496701f, -0.03193252f, -0.08687855f, 0.05569292f, 0.02653648f, 0.03041496f, 0.05998307f, -0.06321390f, 
    -0.08822440f, 0.00233286f, -0.07659175f, -0.02760462f, -0.07630714f, 0.01306754f, -0.04200678f, 0.02394019f, 
    -0.01616035f, 0.01458857f, 0.02476220f, 0.02289301f, 0.00568346f, 0.03221646f, 0.00295069f, 0.00583750f, 
    -0.05110666f, 0.06078896f, -0.07505094f, -0.07796414f, -0.00670122f, 0.04468207f, -0.05756243f, -0.06106699f, 
    -0.01135114f, 0.06690644f, 0.04891720f, -0.06399006f, 0.05521835f, 0.03162164f, -0.03339508f, -0.04929953f, 
    -0.04070526f, 0.02879917f, -0.03054203f, -0.00646785f, -0.04012955f, -0.03749283f, -0.04228554f, 0.05380449f, 
    -0.03925060f, 0.00531601f, -0.02370274f, -0.06470806f, 0.00020216f, 0.03946161f, 0.04301697f, -0.02277095f, 
    0.04077549f, -0.05320225f, -0.06332254f, -0.04456759f, -0.06892017f, 0.01218495f, 0.05309603f, 0.03366034f, 
    -0.02310210f, -0.02739771f, -0.02968883f, -0.05777665f, -0.08076017f, 0.00014747f, 0.01961001f, 0.02741377f, 
    -0.03920316f, -0.07666785f, -0.06526305f, 0.03108279f, -0.04455098f, -0.06193916f, -0.04594169f, 0.01952992f, 
    0.03448619f, -0.06407145f, 0.02782777f, 0.04916684f, -0.08267698f, 0.02518468f, 0.02815893f, -0.04338463f, 
    -0.02466801f, 0.04232832f, -0.02062524f, -0.06361444f, -0.07180452f, 0.01608294f, -0.05526176f, -0.04333654f, 
    0.00090211f, -0.08265281f, -0.03248579f, 0.00414059f, -0.04605717f, -0.01334010f, -0.05579586f, -0.00467265f, 
    0.00765059f, -0.02724915f, -0.01468388f, 0.00270774f, 0.01784539f, 0.01589221f, 0.06840701f, -0.05169319f, 
    -0.02421678f, 0.00481093f, 0.01048903f, 0.02555904f, -0.04981063f, 0.05944331f, -0.08105628f, -0.04746057f, 
    0.05007091f, -0.01205174f, -0.02888971f, -0.00669786f, -0.03771488f, -0.00918388f, -0.08095512f, -0.02048960f, 
    -0.04197570f, 0.03652526f, -0.04773957f, -0.00827955f, -0.03387617f, 0.04268848f, -0.06615727f, -0.06915642f, 
    -0.06858362f, 0.04107837f, 0.01092273f, -0.03970680f, -0.00140439f, -0.06523375f, -0.05736624f, 0.05557722f, 
    -0.09332704f, -0.00871500f, -0.00935011f, -0.03667694f, 0.03248800f, 0.01787717f, 0.01315604f, -0.00037553f, 
    0.02501886f, -0.06112944f, -0.02672636f, -0.03620029f, 0.04632477f, 0.01672029f, 0.02045273f, -0.01247261f, 
    0.02032771f, -0.04641343f, 0.06001294f, 0.06783608f, -0.03527451f, 0.03493608f, -0.01735367f, 0.05406598f, 
    -0.00203469f, -0.08338328f, -0.08581030f, -0.05391395f, -0.04469880f, 0.00451619f, 0.00260533f, -0.07377241f, 
    -0.06795389f, -0.05899920f, -0.02965184f, -0.03906367f, 0.06269609f, -0.06603380f, 0.06163227f, -0.03393924f, 
    -0.15974635f, 0.09404093f, 0.06542048f, -0.09373673f, -0.02214010f, -0.07200453f, 0.09590533f, -0.10342487f, 
    0.03245309f, 0.11488523f, 0.11934264f, 0.12670349f, 0.21161687f, -0.11866450f, -0.07347019f, 0.17709196f, 
    0.06927460f, 0.08607774f, 0.08470894f, 0.09428337f, 0.05233918f, 0.12024496f, 0.01750988f, 0.00292513f, 
    -0.18769458f, -0.09893976f, 0.10921843f, -0.08353259f, -0.06638165f, -0.03650804f, 0.16141233f, 0.06488889f, 
    0.04494192f, 0.06673565f, -0.02632263f, 0.02044526f, -0.23945476f, 0.21217427f, -0.26587689f, -0.28765789f, 
    -0.20724288f, -0.22322389f, -0.06864917f, 0.18086298f, -0.01322582f, -0.06630362f, 0.08137549f, -0.09037547f, 
    -0.18772373f, 0.06394753f, -0.12365551f, 0.32414195f, -0.03604961f, -0.00508267f, -0.22507368f, -0.07079668f, 
    0.07761040f, 0.01525369f, 0.06484348f, 0.00616447f, 0.31549996f, 0.01472946f, -0.11024740f, 0.07162928f, 
    -0.03452505f, 0.06795380f, 0.03670086f, 0.06720138f, 0.02716348f, -0.02571554f, -0.19393252f, 0.02967561f, 
    0.18375534f, -0.29705092f, 0.07610075f, -0.06856500f, 0.24871148f, 0.20257746f, 0.08409146f, 0.22173804f, 
    0.06223821f, 0.01995243f, -0.03546951f, 0.02587752f, -0.07274253f, -0.16478956f, -0.27639979f, 0.02006073f, 
    -0.04822772f, 0.02777147f, 0.05271132f, 0.02801041f, -0.07142492f, -0.03200211f, 0.02602038f, -0.18527831f, 
    -0.21160448f, -0.17582218f, 0.15163480f, 0.25936505f, 0.12721406f, -0.11852892f, 0.03760620f, 0.05988434f, 
    -0.04686807f, 0.07143521f, -0.03562244f, 0.06052314f, 0.04886912f, 0.18803775f, 0.09853803f, 0.22408283f, 
    0.04070437f, 0.09772485f, -0.02660242f, 0.15976499f, -0.07389027f, -0.06296091f, -0.00300720f, -0.03556731f, 
    -0.27554065f, -0.07111812f, 0.06073115f, 0.08585089f, -0.15386575f, -0.06814522f, -0.01861064f, -0.05804119f, 
    0.11101929f, -0.00691679f, 0.15598075f, 0.01435407f, -0.30901149f, 0.04384008f, -0.18706343f, 0.20741124f, 
    0.00845059f, 0.05615260f, 0.05133756f, 0.06030625f, -0.00031392f, -0.04718845f, -0.03246345f, 0.10678177f, 
    -0.18610540f, 0.11816141f, 0.04061025f, -0.12703495f, 0.12905422f, -0.08204146f, -0.15830430f, -0.04784085f, 
    0.23956980f, 0.16715138f, 0.17685635f, 0.31652385f, -0.03281071f, -0.07105003f, 0.15959966f, 0.05018586f, 
    -0.11789081f, 0.13293794f, 0.11332584f, 0.18081227f, 0.02227361f, -0.04756037f, -0.10192954f, -0.01626646f, 
    0.24654247f, -0.32448015f, 0.03851479f, 0.20526080f, 0.18315606f, -0.12433188f, 0.15523575f, -0.10409026f, 
    0.06061302f, 0.07123641f, 0.07072828f, 0.03609109f, -0.21956027f, 0.20341302f, -0.12071230f, -0.04121938f, 
    -0.07929519f, 0.04482463f, 0.04285896f, 0.02809705f, 0.12334821f, 0.11325955f, 0.00292456f, -0.04431553f, 
    -0.04415579f, 0.06349280f, -0.02564833f, -0.07612667f, 0.01985248f, 0.00574197f, 0.05416724f, -0.01592339f, 
    -0.01476731f, -0.04947128f, 0.03308739f, 0.00103178f, -0.04644585f, -0.00032598f, 0.04685877f, 0.03356087f, 
    -0.07523341f, -0.03586891f, -0.02901146f, 0.03148991f, -0.04704642f, -0.04653039f, -0.02369684f, -0.03942829f, 
    -0.08113538f, -0.04864456f, -0.07317709f, -0.01189181f, -0.08319563f, 0.03606750f, -0.06620483f, 0.02959035f, 
    0.04766629f, -0.02623085f, 0.02298072f, 0.01910708f, 0.04307901f, -0.07078712f, -0.01406458f, -0.04318862f, 
    0.04050626f, -0.00022365f, -0.07019575f, 0.05547111f, -0.03929310f, 0.01281411f, 0.02949489f, -0.03322519f, 
    0.00404626f, 0.00702276f, 0.03406741f, 0.04861935f, 0.00614538f, -0.04986102f, -0.07677791f, -0.00727107f, 
    -0.04953587f, 0.02269834f, -0.07216837f, -0.00549096f, 0.05052558f, 0.04277046f, 0.03649954f, -0.07620470f, 
    -0.05270636f, -0.06953644f, -0.06345936f, -0.07669206f, 0.05014710f, -0.03973645f, -0.03672702f, -0.05465313f, 
    0.03144971f, -0.02567782f, 0.06677827f, -0.07387710f, -0.03463211f, -0.06989156f, 0.02901907f, 0.01015658f, 
    0.01839982f, 0.00509180f, -0.06758004f, -0.04261395f, 0.00914930f, 0.04198256f, -0.03246187f, -0.03658832f, 
    -0.07403497f, 0.06788534f, -0.08519560f, -0.01690137f, -0.08268384f, 0.02913909f, -0.05582319f, -0.06066462f, 
    -0.07502620f, -0.07428154f, -0.02942463f, 0.03837634f, -0.00843741f, -0.02498990f, -0.04236373f, -0.01915844f, 
    -0.00501822f, 0.01165339f, -0.03423020f, -0.05061873f, -0.02236200f, -0.01348799f, 0.01332944f, 0.03574482f, 
    0.01323724f, 0.00119908f, 0.02544154f, 0.01163866f, 0.01135458f, -0.03532157f, 0.01645049f, 0.04417480f, 
    -0.03241304f, -0.00916245f, -0.06550338f, 0.02924611f, -0.00552573f, -0.04088822f, -0.03164789f, -0.04620032f, 
    0.02926755f, 0.01565815f, -0.01938852f, -0.02949935f, 0.01610433f, -0.07305297f, -0.05005141f, -0.04337895f, 
    -0.01685951f, 0.05735404f, -0.02165388f, -0.05677268f, -0.04949758f, 0.05632618f, -0.03437711f, 0.02189859f, 
    -0.00689607f, -0.02233598f, -0.05446623f, -0.03176161f, -0.00053752f, -0.01112595f, 0.06591316f, -0.03032480f, 
    0.05203024f, 0.04985908f, 0.00689718f, -0.02806071f, -0.04009597f, -0.03658919f, 0.06494640f, 0.01118819f, 
    -0.05746901f, 0.03265556f, 0.00356120f, -0.05962762f, -0.05763794f, 0.04078876f, 0.02785963f, -0.01359388f, 
    0.04420662f, -0.00754812f, 0.04295915f, -0.07912748f, 0.01361513f, -0.04553359f, 0.00417455f, 0.03659479f, 
    -0.04669551f, -0.02423605f, -0.03814275f, -0.00498152f, 0.02423563f, -0.05184887f, -0.03540414f, 0.04843347f, 
    -0.04513611f, -0.00607233f, 0.01103222f, -0.00142170f, 0.04214723f, 0.05482490f, -0.03412175f, -0.00694935f, 
    -0.05481849f, -0.36593211f, -0.26771578f, -0.05424138f, -0.05490432f, 0.02948556f, -0.19156812f, -0.12048030f, 
    -0.12284528f, -0.06539430f, -0.10435008f, 0.00117085f, -0.34823957f, -0.10288359f, 0.03932459f, -0.13501947f, 
    -0.04901100f, 0.03459413f, -0.36704949f, -0.18527122f, -0.22790588f, 0.00824894f, -0.04115755f, 0.13140810f, 
    0.03759222f, -0.06604405f, -0.11425908f, 0.03467458f, 0.08319253f, 0.11836306f, 0.04123094f, 0.00846856f, 
    -0.08207384f, 0.00944128f, 0.10791121f, 0.22380351f, 0.19798370f, 0.04872572f, 0.21654855f, 0.24332976f, 
    0.07019731f, 0.19257896f, -0.00857730f, -0.13139677f, 0.05781960f, 0.21807252f, 0.19326812f, 0.34126094f, 
    -0.06504719f, 0.05298368f, -0.05119568f, 0.09738077f, -0.09796826f, -0.02940873f, -0.00724979f, -0.02446259f, 
    -0.00287653f, 0.07423636f, 0.30096582f, 0.13169828f, 0.08213037f, 0.00399588f, 0.02868404f, -0.36305097f, 
    0.16909191f, -0.00001884f, 0.00986119f, 0.08821092f, 0.02920967f, 0.10829069f, 0.03620293f, -0.02149462f, 
    -0.04556231f, 0.15888773f, -0.16788007f, 0.17327791f, 0.00699758f, -0.01401299f, -0.07901932f, -0.42016563f, 
    -0.09552320f, -0.25584549f, -0.23362422f, -0.19793297f, -0.16448125f, -0.06424964f, -0.04180964f, -0.13759613f, 
    0.08285435f, -0.11966489f, -0.00000264f, -0.05270524f, 0.06763701f, 0.36722690f, 0.12810530f, 0.38604644f, 
    0.21806601f, 0.19395593f, 0.27408421f, 0.45908391f, -0.03741697f, -0.08211041f, -0.01663020f, -0.04734858f, 
    0.09168141f, 0.08402250f, 0.04555342f, 0.12156593f, -0.16882168f, -0.02002306f, 0.05123819f, -0.00546508f, 
    0.06350768f, -0.15223502f, 0.02821025f, 0.08302499f, 0.10197561f, -0.00868850f, -0.10221688f, -0.03399808f, 
    0.27537063f, 0.32518068f, 0.40265235f, 0.18807878f, 0.08116044f, -0.04220470f, -0.03862005f, -0.09778025f, 
    -0.02063608f, -0.00879165f, -0.25537124f, -0.00204851f, 0.01551654f, 0.07792620f, 0.03575075f, 0.04501110f, 
    0.04845617f, -0.00540781f, 0.08879267f, 0.02465308f, 0.07218567f, -0.02052851f, -0.01980438f, -0.31209031f, 
    -0.19438109f, -0.25309008f, -0.13776819f, -0.07688511f, -0.06477352f, -0.11928194f, -0.05215233f, -0.06652717f, 
    -0.44291288f, -0.16377050f, -0.07416207f, -0.35452622f, 0.04506325f, -0.08251188f, 0.04927126f, 0.06465504f, 
    -0.05801567f, 0.04601851f, -0.00559718f, -0.12515868f, 0.21720859f, 0.09141999f, 0.08512088f, 0.28684556f, 
    0.08576053f, 0.01085757f, -0.10542329f, 0.16297285f, -0.03118384f, -0.07754580f, 0.06834121f, -0.24664493f, 
    -0.09405851f, 0.12044967f, 0.11888386f, -0.03466365f, 0.10898016f, 0.10395975f, 0.36902782f, 0.29181319f, 
    0.15206006f, -0.01220017f, -0.05401924f, -0.06239364f, -0.06322884f, 0.03338346f, 0.04156746f, 0.08208839f, 
    0.15993975f, 0.08719323f, 0.00677908f, 0.03712513f, -0.05394201f, -0.04755737f, -0.04720246f, -0.04288037f, 
    -0.07525372f, -0.10447447f, 0.00120374f, 0.04019775f, 0.39457908f, 0.00040855f, 0.22971992f, -0.09143735f, 
    0.01604175f, -0.00555030f, 0.09042558f, 0.08124804f, 0.03340450f, -0.04477470f, -0.00000211f, 0.04573412f, 
    -0.19747452f, -0.14295989f, -0.20196843f, -0.27515486f, 0.09479238f, 0.18865375f, -0.05878289f, -0.01998125f, 
    -0.06886601f, 0.01524857f, -0.07899132f, -0.07732859f, -0.08934875f, 0.16666821f, -0.05141897f, -0.06521214f, 
    -0.14109798f, -0.01254874f, 0.03535422f, -0.04463432f, 0.06471778f, 0.05345203f, -0.00319239f, -0.00519586f, 
    0.26159307f, -0.01000374f, 0.04310595f, 0.55858052f, -0.04792191f, -0.02362341f, -0.03521232f, -0.08974228f, 
    0.09434498f, 0.08459058f, 0.12702629f, 0.08606329f, -0.15126614f, -0.09714810f, -0.20390046f, -0.29010963f, 
    0.00663841f, 0.05344935f, 0.01925434f, -0.21065742f, 0.15567999f, -0.03242888f, -0.08630811f, 0.03406153f, 
    0.01341575f, -0.09671614f, -0.24011222f, -0.20482200f, 0.15104528f, 0.10449083f, 0.10951912f, 0.05932610f, 
    -0.10642014f, -0.03603769f, -0.07394674f, 0.03468448f, 0.02686906f, -0.09052855f, -0.06305095f, -0.14290155f, 
    0.00625173f, 0.05275374f, 0.06525804f, 0.09977728f, -0.05435199f, 0.16202678f, -0.05049042f, 0.05447344f, 
    -0.31122434f, 0.26097164f, 0.30716750f, 0.13784312f, 0.04010833f, 0.02036767f, -0.04830027f, -0.08826271f, 
    -0.10013310f, 0.17486429f, 0.23513989f, 0.22974844f, -0.20132551f, -0.11880851f, -0.28140554f, -0.38039497f, 
    0.12484493f, -0.04347220f, 0.03679768f, 0.01471245f, -0.06255022f, -0.07236857f, 0.07334555f, 0.02459671f, 
    -0.30334866f, 0.00338799f, 0.03691105f, -0.02616813f, -0.01450352f, -0.04903729f, -0.28937328f, 0.32060093f, 
    -0.13229950f, -0.14073497f, -0.16330048f, 0.01100759f, 0.09452830f, -0.12914492f, 0.07731873f, 0.30725572f, 
    0.16445833f, 0.00906347f, 0.16508538f, 0.30859533f, 0.07692674f, -0.02661045f, -0.03818079f, -0.03948801f, 
    -0.00207944f, -0.00517403f, 0.10885274f, -0.02819320f, -0.04310087f, 0.05438127f, 0.09771577f, -0.01580802f, 
    0.05586440f, 0.05509595f, 0.09714660f, -0.02895208f, 0.34349194f, 0.05875274f, 0.14022759f, 0.12782960f, 
    0.13146493f, 0.10777447f, -0.05088803f, 0.23687132f, 0.03678856f, 0.08449314f, -0.03651117f, 0.11113822f, 
    -0.07678101f, -0.10218677f, 0.04807358f, 0.42677498f, 0.16943312f, 0.11023436f, 0.06270515f, 0.28785753f, 
    0.07626411f, 0.05674743f, 0.39375469f, 0.00689793f, -0.29619732f, 0.24018955f, 0.12336881f, -0.17853762f, 
    -0.10161205f, 0.10584373f, 0.15991202f, 0.28001481f, 0.02278346f, -0.06231663f, 0.14486605f, 0.07302543f, 
    0.04243466f, -0.06768581f, 0.15660578f, 0.13640398f, -0.01707195f, 0.10084015f, -0.04829052f, -0.02024614f, 
    -0.08368687f, 0.13619876f, 0.10480327f, -0.11408610f, 0.18410508f, 0.17502651f, 0.00298327f, -0.01940078f, 
    -0.08579474f, -0.00466140f, -0.07794188f, -0.04744653f, -0.00736629f, -0.11046366f, 0.06682422f, 0.04070363f, 
    -0.04499109f, 0.19645801f, 0.19105273f, -0.10793899f, 0.09400294f, -0.08470955f, -0.25468257f, 0.18459913f, 
    -0.01160784f, 0.07229879f, 0.06790660f, -0.07457928f, -0.18393667f, -0.20312715f, -0.09340704f, -0.05721587f, 
    0.08771850f, 0.24800251f, -0.10262119f, -0.02675618f, 0.07311923f, 0.03144028f, -0.05220645f, -0.06565478f, 
    0.33076441f, -0.07412673f, -0.00685797f, -0.04020645f, 0.00397356f, -0.07710784f, -0.01689839f, -0.10218130f, 
    0.09794866f, -0.10809772f, -0.11902183f, -0.00957979f, 0.14315052f, 0.13795708f, -0.30179864f, -0.25319812f, 
    -0.16668695f, -0.03198423f, 0.17723401f, 0.07598308f, 0.05474215f, 0.03352549f, 0.04774573f, -0.03978736f, 
    0.08327432f, 0.28707853f, -0.05313023f, -0.13024728f, -0.03064079f, -0.13327877f, -0.13765833f, -0.00690146f, 
    -0.04378174f, 0.03027053f, 0.05915117f, -0.01449426f, -0.09026023f, 0.00567274f, 0.08314999f, -0.06081405f, 
    0.11161596f, -0.03800523f, 0.01958907f, 0.03837172f, 0.14007635f, 0.05676868f, 0.02416107f, 0.20168459f, 
    0.04114203f, 0.14452121f, -0.19341493f, -0.14624622f, -0.04850795f, 0.05419808f, -0.04843846f, -0.01327573f, 
    -0.08909654f, -0.06243395f, 0.04814465f, -0.10848304f, 0.23153464f, 0.28984699f, 0.02991901f, -0.16861151f, 
    0.11002373f, 0.03137987f, 0.10885715f, 0.18373674f, 0.02392642f, -0.01685258f, -0.02229706f, 0.02452954f, 
    -0.17133473f, 0.00853354f, -0.29228622f, -0.02309903f, 0.00511245f, 0.01177685f, 0.03256391f, 0.05390707f, 
    -0.02647681f, 0.04350414f, -0.08741539f, -0.07798786f, 0.13877845f, 0.15151314f, 0.09751368f, -0.08573376f, 
    0.20394406f, 0.03443027f, 0.16853368f, 0.15640132f, 0.00867077f, -0.06411851f, -0.14043301f, -0.05336643f, 
    -0.07981411f, -0.00706775f, 0.12836671f, -0.08050238f, 0.04363505f, 0.03046419f, -0.05486701f, -0.08292913f, 
    -0.08442194f, -0.05235133f, -0.02790656f, -0.04950323f, 0.45412654f, 0.25833353f, -0.04047726f, -0.14973520f, 
    -0.01863070f, -0.07125001f, -0.04563714f, 0.05848163f, 0.09560848f, -0.00432907f, 0.06731894f, 0.15857595f, 
    0.02657850f, 0.30737114f, 0.59817511f, -0.20000474f, -0.09683295f, 0.07251501f, 0.03306714f, 0.13145973f, 
    0.08963111f, -0.02051977f, 0.16018306f, -0.11030693f, -0.13747880f, -0.00160869f, -0.04081658f, -0.11264539f, 
    0.06376047f, 0.13575153f, 0.09373798f, -0.09346864f, -0.06506053f, 0.03036069f, 0.10274876f, 0.10827846f, 
    -0.08175676f, -0.14797023f, 0.22290991f, 0.04248396f, -0.03044472f, 0.02446743f, -0.06213557f, 0.03313379f, 
    -0.11797757f, 0.07671573f, 0.00332085f, 0.22488530f, 0.16235508f, -0.16786195f, -0.05468952f, -0.14778653f, 
    0.11388926f, 0.00396563f, -0.01203167f, 0.07368790f, -0.03205044f, 0.00309770f, -0.06923155f, -0.06490214f, 
    -0.15978567f, 0.15217654f, -0.04652879f, -0.06130828f, -0.02478562f, -0.05284979f, 0.03839650f, -0.05459289f, 
    0.00733910f, -0.00395052f, 0.00221239f, -0.05003065f, -0.33676726f, 0.20657751f, -0.13756852f, -0.06497394f, 
    -0.04216819f, 0.06073749f, 0.12440830f, 0.08831460f, 0.01420634f, -0.13837898f, 0.09727580f, 0.04320895f, 
    0.20387606f, -0.59365398f, 0.12537126f, 0.28449422f, 0.07668328f, -0.04984031f, 0.00752005f, -0.00729356f, 
    0.23313990f, 0.09142818f, 0.17004707f, 0.14494532f, 0.15067063f, 0.13682657f, -0.22305602f, -0.27809697f, 
    -0.04169210f, -0.07344715f, 0.05930164f, -0.14396173f, 0.07514337f, 0.14896299f, -0.12152068f, -0.00237417f, 
    0.16728355f, 0.07872604f, -0.11100388f, -0.01807081f, 0.09095632f, 0.05703370f, -0.04361922f, 0.00930740f, 
    -0.02055945f, -0.09251733f, -0.07538957f, -0.09580454f, -0.01830096f, -0.01922158f, -0.06524321f, 0.00086419f, 
    0.05201013f, -0.10045928f, -0.09002608f, 0.11163609f, 0.10284270f, -0.04313663f, 0.05848202f, 0.00715342f, 
    -0.30421308f, -0.00878808f, 0.25492391f, 0.22930899f, -0.00639792f, 0.00061255f, 0.06921795f, 0.02081090f, 
    0.24246973f, -0.06756199f, -0.02109030f, 0.17499296f, 0.04463027f, 0.15684915f, 0.09039538f, -0.16851987f, 
    0.13269344f, 0.01867617f, 0.00172274f, 0.07288504f, -0.01065008f, -0.03058551f, 0.07045900f, 0.03681111f, 
    -0.05412737f, -0.08393219f, -0.12138308f, -0.08912616f, 0.04601436f, 0.04723456f, -0.03958228f, -0.09876618f, 
    0.28352419f, -0.17420238f, -0.05633892f, -0.00246444f, 0.21133691f, -0.22370315f, 0.08571035f, 0.09028503f, 
    -0.11185206f, -0.02342823f, 0.05057205f, 0.00051192f, 0.09751487f, 0.00205015f, -0.11636645f, 0.06624436f, 
    -0.02845864f, -0.01982115f, -0.04851295f, 0.01428121f, 0.16928490f, -0.03196378f, -0.11898697f, 0.04296400f, 
    -0.04530908f, 0.02600298f, -0.02463005f, 0.13426502f, 0.30055171f, 0.08147209f, 0.20870219f, -0.19416320f, 
    0.02304780f, 0.02232735f, 0.01861861f, 0.10455010f, -0.07352380f, -0.01082494f, 0.02691834f, 0.10051011f, 
    0.21322179f, -0.05905705f, 0.29803184f, 0.14516087f, 0.07642051f, 0.00328855f, -0.01082641f, 0.10678958f, 
    0.06343035f, -0.01257521f, 0.09767994f, 0.01829838f, -0.21815965f, 0.09456823f, -0.08144647f, -0.17096031f, 
    0.06424846f, 0.04503890f, -0.01183888f, -0.05831946f, 0.17406276f, -0.01369532f, 0.02831790f, -0.00080589f, 
    0.04011904f, -0.05440474f, -0.04996170f, -0.11549109f, -0.05746792f, 0.05467577f, -0.08908785f, 0.02102355f, 
    -0.00014026f, -0.05296681f, 0.02484439f, 0.05758824f, -0.11081890f, -0.10648368f, 0.20019785f, 0.09271502f, 
    -0.03144350f, -0.03692332f, 0.15288246f, -0.00823715f, -0.10604326f, -0.06735630f, -0.10125734f, -0.03533877f, 
    0.08393241f, -0.29146141f, 0.29151997f, -0.30679432f, -0.00804020f, 0.08024576f, 0.00416176f, -0.11867982f, 
    0.04855431f, 0.06160789f, 0.06492987f, 0.06012743f, 0.13775457f, 0.05936959f, -0.01056119f, 0.09125527f, 
    -0.06040013f, -0.15698278f, 0.10861121f, 0.16309379f, -0.16609472f, -0.02502911f, 0.07892586f, 0.06222999f, 
    -0.15867464f, -0.05481876f, -0.06100897f, -0.07176668f, 0.00457546f, 0.01617538f, 0.03777619f, 0.05978585f, 
    -0.02969980f, 0.13253179f, 0.13313910f, 0.29205120f, -0.19448744f, 0.16534556f, -0.08306905f, 0.34448916f, 
    0.00102373f, 0.04409226f, 0.04801536f, -0.30427021f, 0.05563025f, 0.00113852f, -0.04591272f, 0.06347591f, 
    0.18576232f, -0.03477142f, 0.02581603f, 0.16432922f, 0.11318972f, 0.15546842f, -0.02766808f, 0.16160332f, 
    -0.07182833f, 0.03440398f, -0.10846294f, -0.07203297f, -0.11163259f, -0.02022508f, -0.15661135f, 0.20069315f, 
    0.02339044f, -0.06735903f, -0.02395502f, 0.06130157f, 0.08085485f, 0.06840857f, 0.04988750f, -0.15242520f, 
    -0.54331291f, 0.02257056f, 0.00750115f, -0.01499653f, 0.02791916f, -0.05038952f, 0.02017881f, 0.17776118f, 
    -0.04191921f, 0.01197590f, 0.05393448f, -0.03340298f, 0.13008700f, -0.02779561f, -0.11598556f, 0.01827978f, 
    -0.05089940f, 0.16070111f, 0.10916295f, -0.05192527f, -0.01584377f, 0.03681244f, 0.01396259f, 0.05005917f, 
    -0.37756887f, 0.04176616f, 0.05413044f, 0.24689339f, -0.14450805f, -0.04071376f, 0.26116347f, -0.15252644f, 
    0.13891241f, -0.05304118f, -0.09263460f, 0.04658706f, -0.42802620f, 0.18556732f, -0.04733990f, 0.00001959f, 
    0.18607697f, -0.02416799f, 0.28081110f, -0.14273329f, -0.14624332f, -0.00699328f, 0.00777384f, 0.20124978f, 
    0.02535202f, -0.12779537f, 0.01409113f, -0.01011784f, 0.10620228f, -0.09089807f, -0.11809607f, 0.02842331f, 
    0.10808442f, 0.04396807f, 0.08179770f, 0.04952142f, -0.51456499f, 0.09345506f, -0.20871800f, 0.21709238f, 
    0.07027729f, 0.05303532f, 0.10064197f, 0.01998474f, -0.07288770f, 0.04618465f, 0.11539175f, -0.02196589f, 
    -0.13559659f, 0.33630595f, -0.31003886f, -0.05475940f, 0.10058760f, -0.21296351f, 0.22264284f, 0.06233630f, 
    0.08704665f, 0.10542170f, -0.06650220f, 0.16324335f, 0.21307671f, -0.18915997f, 0.09706258f, 0.00546749f, 
    -0.01182263f, 0.08453856f, -0.13645901f, -0.03620113f, 0.19150467f, 0.03706151f, -0.05263216f, -0.02370168f, 
    -0.01670356f, -0.15958986f, 0.01304565f, -0.22383723f, -0.03591272f, -0.01949270f, -0.04786846f, -0.04358686f, 
    -0.07109121f, -0.03819226f, -0.10464495f, 0.05434863f, -0.28397083f, 0.12686336f, 0.13330658f, 0.04381374f, 
    -0.08250663f, 0.04031122f, -0.02685005f, 0.09949706f, -0.09969769f, 0.03242986f, -0.08012948f, -0.15056244f, 
    -0.05070878f, 0.05348296f, 0.14650747f, 0.12554961f, -0.03471705f, -0.08950029f, -0.02098169f, -0.06533761f, 
    0.13519630f, -0.00764274f, -0.03902802f, -0.01497516f, 0.00295212f, 0.02101589f, -0.04975384f, 0.09965156f, 
    -0.08005998f, -0.07202380f, 0.16381441f, 0.15298142f, -0.00104684f, 0.00738200f, 0.00282805f, 0.02881187f, 
    -0.10728689f, 0.14702454f, -0.27981195f, 0.01916460f, 0.05402264f, 0.04912731f, -0.02341875f, 0.07196726f, 
    0.20845632f, 0.05403499f, 0.13648400f, -0.03614632f, 0.10375668f, -0.06422873f, -0.07945483f, 0.16516213f, 
    -0.01510904f, 0.01884982f, 0.04917307f, -0.04860769f, 0.07571942f, 0.07331444f, -0.01065157f, 0.02157051f, 
    -0.09409863f, 0.17244487f, 0.23200709f, 0.09584049f, -0.01585592f, -0.06395993f, -0.00922357f, 0.12182796f, 
    -0.04483585f, 0.09927011f, 0.04906564f, -0.03701757f, -0.07199988f, 0.03211273f, 0.14258365f, -0.00429312f, 
    -0.03448262f, 0.00663355f, -0.06297465f, -0.01885471f, 0.18873793f, 0.09989490f, 0.08409040f, 0.05092868f, 
    0.40060446f, -0.37401018f, -0.00937016f, 0.11820907f, 0.15741861f, -0.08390785f, 0.03796993f, -0.07948635f, 
    -0.16457061f, -0.09917057f, -0.04582149f, 0.01718204f, 0.08384179f, -0.07147523f, 0.13759953f, 0.18729877f, 
    -0.04047752f, 0.11691700f, 0.08000354f, 0.00756522f, -0.02440223f, 0.03773110f, -0.01274039f, -0.02431237f, 
    -0.01807319f, -0.27368364f, -0.09373897f, 0.05185940f, -0.12307467f, 0.08840348f, 0.06985264f, -0.07448745f, 
    0.15550965f, 0.07484760f, -0.04721309f, 0.04067932f, -0.21404926f, 0.18689694f, -0.21000198f, 0.06746752f, 
    -0.01493391f, 0.14269198f, 0.04122700f, 0.05851863f, -0.18659492f, -0.05264537f, -0.14853266f, 0.07985881f, 
    -0.16401623f, -0.08066557f, -0.09808460f, -0.18278524f, 0.01915761f, -0.07241730f, -0.17207024f, -0.13720571f, 
    0.07465281f, 0.02876669f, 0.08681905f, 0.10315999f, -0.21574295f, 0.05478037f, 0.13041902f, 0.04545550f, 
    -0.02933904f, -0.00248092f, 0.14109762f, 0.09843235f, 0.02135868f, -0.00793716f, -0.07427346f, 0.00788235f, 
    0.85124391f, -0.23816268f, 0.16373391f, -0.01562879f, 0.36069643f, -0.09209184f, 0.03628501f, -0.09547877f, 
    0.02530827f, -0.00273827f, 0.04506910f, 0.06951840f, -0.14861199f, 0.01323709f, -0.11894452f, 0.04415830f, 
    -0.03268463f, 0.05414081f, 0.06396157f, -0.04642594f, 0.03178091f, 0.11270479f, 0.03007557f, -0.01905042f, 
    -0.21585518f, 0.08295850f, -0.02654101f, -0.07210085f, -0.08462116f, -0.09633755f, 0.12340948f, -0.09250769f, 
    -0.02675022f, 0.18016131f, 0.20442386f, 0.08364187f, 0.01710194f, -0.04225891f, -0.03345543f, 0.35386595f, 
    0.05538403f, 0.15677336f, -0.11811630f, -0.04376412f, 0.17473689f, 0.19188882f, 0.05243518f, -0.01699697f, 
    -0.03081424f, -0.03660621f, -0.04425454f, -0.00630232f, -0.12294863f, -0.18492979f, 0.20240498f, 0.04363185f, 
    0.12932146f, 0.06052435f, 0.14027920f, -0.00822396f, -0.14015487f, -0.13664563f, -0.41967350f, -0.11440650f, 
    -0.07822129f, -0.02290618f, -0.10543308f, 0.23154369f, -0.11158085f, -0.03961197f, 0.09905975f, -0.05130262f, 
    -0.04134075f, 0.20892367f, 0.05869091f, 0.11927027f, -0.08176304f, -0.05115017f, -0.09269554f, 0.06232268f, 
    0.23099509f, -0.08869458f, 0.19849868f, 0.15780915f, 0.44816130f, -0.07917270f, 0.09478355f, 0.26641801f, 
    0.06383439f, 0.07758503f, 0.06436738f, 0.14563307f, -0.04287247f, -0.00269040f, -0.25166926f, 0.00141899f, 
    0.00615978f, -0.14738847f, 0.09538373f, 0.16537262f, 0.19901069f, 0.16978183f, 0.11356917f, -0.00964899f, 
    0.11248220f, 0.11981462f, -0.10926589f, 0.07392469f, -0.13764122f, -0.21746710f, -0.22664405f, 0.06630158f, 
    0.06179516f, 0.05265888f, -0.00922411f, -0.12813082f, -0.19367835f, -0.13592570f, 0.03830744f, -0.10256719f, 
    -0.17260179f, -0.10170279f, 0.06883404f, -0.06948108f, -0.06770118f, -0.11879907f, 0.06280015f, 0.20272976f, 
    -0.00963598f, 0.12103631f, -0.02006592f, 0.04365751f, 0.12389356f, 0.15059611f, 0.03485865f, 0.21935445f, 
    -0.00684306f, 0.16050945f, -0.07693917f, 0.16166586f, -0.16368978f, -0.02046863f, -0.06496183f, -0.05679181f, 
    -0.11465544f, -0.02548949f, 0.08764002f, -0.04339471f, -0.11394773f, 0.05094911f, 0.20390522f, 0.03524809f, 
    -0.07862526f, -0.16922535f, 0.15898931f, -0.05579042f, -0.03461535f, -0.05211743f, -0.00988308f, 0.10667856f, 
    -0.02263205f, 0.07356956f, -0.03507550f, 0.01440437f, 0.01758966f, -0.05898876f, 0.00456998f, -0.01394151f, 
    -0.11460572f, 0.15773341f, -0.04261276f, 0.01991797f, 0.03663483f, -0.04435412f, 0.09203253f, -0.03989058f, 
    0.17487590f, 0.06229911f, 0.27103311f, 0.18726707f, -0.14823349f, -0.21425208f, -0.12008619f, -0.17535007f, 
    -0.10810859f, 0.07738681f, -0.15748857f, -0.13640411f, -0.06411546f, -0.16068850f, 0.01191266f, -0.21410175f, 
    0.10017100f, -0.12911700f, -0.04879482f, 0.03920440f, 0.02693338f, -0.12312278f, 0.10922246f, -0.06314915f, 
    -0.05620550f, -0.01597888f, 0.09792235f, 0.02091425f, -0.05278805f, 0.22661112f, -0.20812726f, 0.07087865f, 
    0.04196348f, 0.12483095f, 0.08497477f, 0.09842571f, 0.01164498f, 0.26244888f, -0.06738114f, 0.07069442f, 
    0.05650097f, -0.07871464f, -0.03059270f, 0.01615630f, -0.03080154f, 0.06249110f, -0.08199696f, 0.13154985f, 
    0.04833080f, -0.03466631f, 0.15593415f, 0.03741023f, -0.00330876f, 0.23410940f, 0.29211351f, -0.08101819f, 
    -0.15945850f, -0.14825642f, 0.04522047f, -0.00965188f, -0.07811490f, -0.02058614f, 0.03316690f, -0.09312806f, 
    0.08412639f, -0.27816522f, -0.09204116f, -0.11383604f, 0.10881984f, 0.08715748f, -0.11433540f, 0.02077270f, 
    -0.06952030f, 0.06532769f, 0.03455978f, 0.05082372f, 0.34356603f, -0.14227581f, 0.25103903f, 0.16538221f, 
    0.13510539f, 0.13055713f, -0.00992043f, -0.04411618f, -0.04890160f, 0.08995125f, -0.13676336f, 0.03455297f, 
    -0.00463150f, 0.09428441f, -0.00860619f, -0.21759756f, -0.06633202f, 0.06122772f, -0.04352210f, 0.05331652f, 
    -0.05657303f, 0.06427953f, 0.05677268f, -0.02760669f, -0.39701167f, -0.08387832f, -0.03902502f, 0.17571558f, 
    0.04841237f, 0.10761666f, -0.10182983f, -0.13057116f, -0.03231055f, -0.12280600f, 0.12000886f, 0.04524367f, 
    0.20390473f, 0.27571362f, -0.01051664f, 0.18681857f, -0.06346560f, -0.14394976f, 0.12759848f, -0.15586941f, 
    -0.01672260f, -0.01515836f, -0.08754198f, -0.05026281f, -0.02276360f, 0.02996596f, 0.01886648f, -0.06172859f, 
    0.00725353f, -0.06584645f, -0.04493133f, -0.01573520f, 0.14621100f, 0.13790299f, 0.09948956f, 0.13858144f, 
    -0.22964038f, 0.12241594f, -0.15020820f, -0.03099465f, 0.00235890f, 0.02818245f, -0.09919638f, 0.06009323f, 
    0.01537562f, 0.04138126f, 0.05532832f, 0.08054227f, -0.13866217f, -0.20032446f, -0.12106781f, 0.04160656f, 
    -0.02402413f, -0.17944674f, 0.02134645f, -0.12121382f, 0.05383277f, -0.05009392f, -0.14711687f, -0.04799200f, 
    -0.03335350f, 0.21554346f, 0.15369286f, 0.26224872f, 0.06198093f, 0.08050042f, 0.12577400f, 0.09532680f, 
    -0.04897426f, 0.03752329f, -0.09776061f, 0.01906946f, -0.13600640f, 0.21395865f, 0.14597017f, 0.09681033f, 
    0.13344894f, 0.00808525f, 0.19016464f, 0.02964327f, -0.16973990f, 0.03177572f, -0.01528735f, -0.11428990f, 
    0.24453673f, 0.02102040f, -0.04524310f, 0.09777621f, 0.06230868f, 0.09373625f, -0.02780781f, 0.09643979f, 
    0.00280019f, -0.06089703f, 0.01396330f, -0.15673254f, -0.21210054f, 0.07130121f, -0.12455475f, 0.27728745f, 
    0.18560413f, 0.09014592f, 0.01838240f, -0.07056320f, 0.08701145f, 0.08223014f, 0.19298014f, 0.06554192f, 
    0.04859149f, 0.02161940f, -0.47713014f, 0.05138335f, 0.05880060f, -0.07053606f, 0.04207594f, 0.11861422f, 
    -0.02887495f, 0.00566693f, 0.07638020f, -0.00179234f, 0.08563571f, -0.10878122f, 0.32938135f, 0.10770388f, 
    -0.00379635f, 0.05654508f, 0.07845136f, 0.07021654f, 0.02096124f, 0.10018844f, 0.12571856f, -0.00556562f, 
    0.19137514f, 0.18637083f, 0.05248047f, 0.10796613f, 0.02814367f, 0.07372659f, -0.01427377f, 0.03590298f, 
    0.03561232f, 0.14561705f, 0.03859227f, 0.00609020f, 0.37974930f, 0.29631692f, 0.18348956f, 0.20113942f, 
    0.03715881f, -0.02182986f, -0.00905793f, 0.07661839f, 0.06668274f, 0.11260518f, 0.01938374f, 0.02626191f, 
    -0.12387776f, -0.04001216f, -0.11407161f, 0.13096154f, -0.00948831f, 0.03288579f, 0.08649296f, 0.13246186f, 
    0.03156490f, 0.05904094f, 0.08836531f, -0.05217575f, -0.43204418f, -0.33920872f, -0.38034949f, -0.42193154f, 
    -0.11911236f, -0.02991441f, 0.06526335f, -0.12075487f, 0.21903712f, 0.03437179f, -0.06559353f, -0.16791353f, 
    0.23465055f, 0.17078187f, 0.05992452f, 0.15967469f, -0.03285494f, 0.04526160f, -0.03197952f, -0.03469953f, 
    0.00401276f, 0.05466186f, -0.01328685f, 0.00704477f, 0.19077301f, 0.02354161f, 0.01434638f, 0.05230205f, 
    -0.02230240f, 0.12018560f, 0.12202234f, 0.33586261f, -0.03477916f, 0.08411790f, -0.01239403f, -0.02688724f, 
    0.53110719f, 0.28217682f, 0.31589025f, 0.07622816f, 0.06215651f, 0.04975840f, -0.00742708f, 0.10403610f, 
    0.00074148f, 0.02905252f, -0.03805592f, 0.05676063f, 0.10099880f, 0.08547471f, 0.20537463f, 0.13592167f, 
    -0.04142131f, 0.12699868f, 0.05365928f, -0.05352328f, 0.21541883f, 0.19428386f, 0.14888774f, 0.19905066f, 
    0.30714971f, -0.24306969f, -0.16931792f, -0.13244155f, -0.03173498f, -0.07396822f, -0.02925321f, 0.05809318f, 
    0.03635814f, -0.02437354f, -0.08351570f, -0.17333010f, -0.06148327f, 0.19198044f, 0.06428679f, 0.14834459f, 
    0.02369736f, 0.08421635f, -0.04048602f, 0.18231197f, -0.01871562f, 0.02592187f, 0.04189804f, -0.08222028f, 
    -0.05277392f, 0.05693239f, -0.08023426f, -0.27414000f, -0.09957238f, -0.11087305f, -0.05543187f, 0.15489621f, 
    -0.17062667f, 0.01904987f, -0.02439718f, -0.08821577f, 0.02899046f, -0.05487925f, -0.23495935f, -0.09303083f, 
    0.06875250f, 0.12535872f, 0.03251311f, 0.10239418f, -0.05186592f, -0.05210358f, -0.07807200f, -0.01251082f, 
    0.08973078f, 0.05520738f, 0.11700436f, -0.01299238f, -0.09684594f, -0.08485453f, 0.02763010f, -0.07945028f, 
    0.05557059f, 0.05884552f, -0.05072351f, -0.09004022f, -0.21829803f, -0.28265342f, -0.43317559f, -0.22675994f, 
    -0.09297416f, -0.09307048f, -0.06631801f, 0.08928592f, 0.03792588f, 0.03383901f, 0.00893229f, 0.06539646f, 
    -0.09124134f, 0.03216596f, 0.14674214f, 0.01974713f, -0.03649675f, -0.02667340f, -0.05328406f, -0.03378089f, 
    -0.10521486f, 0.00917863f, 0.10254431f, -0.09932344f, -0.06907830f, -0.06453646f, -0.22654705f, -0.08986914f, 
    -0.02420409f, -0.13948248f, 0.11216289f, -0.02295024f, -0.11158690f, -0.04178198f, 0.05645229f, 0.03477831f, 
    0.00125876f, -0.10864838f, -0.15497611f, -0.08285104f, -0.10471247f, 0.01159027f, 0.06183187f, -0.15002529f, 
    0.06400590f, -0.16319337f, -0.04067133f, 0.07169644f, -0.21738200f, 0.19080560f, 0.19505949f, -0.00872790f, 
    0.14510745f, 0.05167785f, 0.03394115f, -0.00853922f, 0.13076575f, 0.05200952f, -0.08772884f, -0.17904197f, 
    0.05636691f, -0.06364148f, 0.05368285f, 0.16234075f, -0.07822557f, 0.02698062f, 0.01049238f, -0.16692989f, 
    0.00994319f, -0.13215701f, 0.11743707f, 0.18976930f, 0.31481448f, -0.11746046f, 0.00262955f, 0.36281762f, 
    -0.07656930f, 0.19896978f, 0.29391846f, 0.04828837f, 0.01537115f, 0.03957186f, 0.04651699f, 0.34571096f, 
    0.00955581f, 0.22032218f, -0.09386428f, -0.47410816f, -0.25444430f, 0.13431868f, -0.20049538f, 0.29268554f, 
    -0.03343439f, 0.16038865f, 0.17521293f, 0.04494821f, -0.16876352f, -0.25180411f, 0.24967630f, 0.33344820f, 
    0.24401993f, 0.12025043f, 0.04077989f, -0.04315051f, 0.00288947f, 0.02651138f, 0.00894178f, -0.12220532f, 
    -0.27279702f, -0.19909339f, 0.08504637f, 0.23908763f, 0.11664167f, -0.10624566f, 0.12849173f, -0.23300862f, 
    -0.10945828f, -0.08779064f, -0.15460859f, 0.09061695f, -0.14431125f, -0.05146074f, 0.11981802f, -0.13971418f, 
    0.01085603f, 0.12826797f, 0.03201529f, -0.00769099f, 0.30632684f, 0.33545125f, 0.18555959f, 0.26545039f, 
    0.31871197f, -0.00585664f, 0.26380962f, 0.08163968f, -0.07314605f, 0.10422219f, -0.00967018f, 0.21442132f, 
    -0.11453186f, -0.01690787f, 0.07977801f, 0.03660355f, 0.02598104f, -0.23013115f, -0.06013099f, 0.08000319f, 
    0.09562728f, 0.10748353f, 0.01417058f, -0.10134763f, -0.05165739f, 0.06559998f, -0.16947083f, -0.24357493f, 
    0.14991082f, -0.10119008f, 0.14953165f, 0.38634294f, 0.06828421f, -0.08875006f, 0.06195289f, -0.12617666f, 
    -0.06906064f, 0.03458739f, -0.01212946f, -0.10978537f, -0.18629760f, 0.04568490f, 0.03733590f, -0.11047547f, 
    0.00353891f, 0.09139586f, -0.18960604f, 0.02442607f, -0.33526936f, -0.11025058f, 0.00380509f, 0.04902215f, 
    -0.05011580f, 0.20671520f, -0.19657055f, 0.26168448f, 0.08619590f, -0.05117069f, -0.06889351f, 0.01639356f, 
    -0.23368545f, -0.33509341f, 0.13395755f, -0.18624265f, -0.35216618f, -0.14751144f, 0.07691756f, 0.05323593f, 
    -0.11203442f, 0.06649269f, 0.23860091f, -0.06411827f, 0.13747245f, 0.21603592f, 0.12324097f, 0.00893766f, 
    0.49038473f, -0.25164810f, 0.03768419f, 0.08712842f, 0.07998489f, 0.09499109f, -0.03726203f, -0.04523588f, 
    0.13498557f, -0.01825609f, 0.15077534f, 0.05023949f, 0.14404631f, 0.05354279f, 0.05721805f, 0.13158366f, 
    -0.02837054f, 0.07237366f, -0.09107575f, -0.08830426f, 0.05815062f, 0.05544907f, 0.16257036f, -0.04874406f, 
    0.04285906f, -0.01505795f, 0.08818168f, 0.00206012f, -0.12647888f, -0.10259673f, -0.12984350f, -0.03122465f, 
    -0.04336764f, 0.07289722f, -0.00039737f, -0.07602060f, 0.28693807f, 0.25595954f, -0.07257997f, 0.03327755f, 
    -0.07698900f, -0.08702557f, -0.10811811f, 0.00330993f, 0.08112438f, -0.09605584f, 0.07043343f, 0.07444660f, 
    -0.03742225f, 0.00891208f, -0.09222218f, 0.05410531f, 0.07471384f, -0.00049219f, -0.04971801f, 0.15699674f, 
    -0.02152171f, 0.08819783f, -0.13750748f, -0.02709861f, -0.20004348f, -0.04355663f, 0.03388072f, -0.20802221f, 
    0.01035521f, -0.07215973f, -0.11776342f, -0.14620732f, 0.05141480f, -0.00131642f, -0.13721272f, -0.18379626f, 
    0.13233459f, -0.09442417f, 0.16617049f, 0.01755235f, -0.06550951f, -0.02735246f, 0.04024855f, -0.07388659f, 
    0.03372114f, -0.08809238f, -0.15037571f, -0.09127001f, -0.36660177f, 0.05199979f, 0.09530666f, -0.10535794f, 
    -0.00170460f, -0.02041428f, 0.03134689f, 0.07572797f, -0.06791025f, 0.09653232f, 0.02487456f, 0.06390768f, 
    -0.08078934f, 0.27658302f, 0.05667294f, -0.13956890f, -0.12196380f, -0.27055299f, -0.18232810f, 0.01865658f, 
    -0.00059022f, -0.05035382f, -0.02695464f, 0.00221210f, 0.06832557f, 0.02318928f, -0.03193271f, -0.00915113f, 
    0.00807658f, -0.11081631f, -0.01911652f, -0.05627940f, -0.01612702f, -0.21430375f, -0.04710608f, -0.03297537f, 
    -0.15989995f, -0.08462498f, -0.29743785f, -0.30038315f, -0.14218096f, -0.05268340f, -0.07160289f, -0.08472104f, 
    -0.03968617f, -0.01927839f, -0.10653977f, -0.13310993f, -0.12829007f, 0.07288929f, 0.09106728f, 0.03202751f, 
    0.10241986f, -0.03623534f, -0.10652170f, 0.15160869f, -0.07196232f, -0.03311400f, 0.00103281f, 0.06430683f, 
    0.05373636f, 0.01278221f, -0.15941343f, -0.11298495f, -0.08388922f, 0.06448203f, -0.13081065f, 0.21637155f, 
    -0.13081750f, 0.06653025f, 0.00921221f, -0.05225354f, -0.02817804f, -0.24302836f, 0.13360213f, 0.12164173f, 
    0.00373106f, -0.00988216f, 0.03586465f, 0.11730624f, 0.06465889f, 0.00634468f, -0.08246802f, -0.00324428f, 
    0.02831919f, 0.03662179f, 0.03400942f, -0.08967040f, 0.01023574f, -0.02113484f, -0.02664050f, -0.11861074f, 
    0.00980652f, 0.07098328f, -0.06533293f, 0.05840622f, 0.25075763f, 0.07122092f, 0.14002205f, 0.01387081f, 
    0.08971941f, -0.05233696f, -0.10713871f, 0.07582252f, 0.00363595f, -0.12793405f, -0.02400794f, 0.04992602f, 
    -0.20374097f, 0.02279569f, 0.06988595f, 0.01062033f, -0.01175858f, 0.01147142f, -0.04319966f, 0.14118730f, 
    -0.05411361f, -0.04940536f, 0.09491377f, -0.01446628f, -0.00338614f, 0.17731372f, -0.05484252f, -0.12664777f, 
    -0.01177858f, -0.05743045f, 0.15248078f, 0.01778363f, -0.02222713f, 0.06144049f, -0.10713106f, 0.11069565f, 
    -0.21134792f, -0.02455526f, 0.06532058f, 0.10186574f, -0.02993968f, -0.04034507f, -0.02646386f, 0.04375900f, 
    -0.13982639f, 0.11535280f, 0.05767931f, 0.08319814f, -0.02859303f, -0.07575712f, -0.25135896f, 0.24486043f, 
    -0.02159702f, -0.03747376f, -0.00655879f, -0.06035362f, -0.00606909f, -0.08562814f, 0.12960368f, 0.06985460f, 
    0.08448054f, 0.18467921f, 0.08690776f, 0.08926892f, 0.09352494f, -0.05554512f, 0.10023937f, 0.17261080f, 
    -0.00191809f, 0.03740289f, 0.14009707f, -0.07400846f, -0.13070998f, -0.12069522f, 0.06625777f, 0.04181373f, 
    0.08838569f, 0.08760507f, 0.06100968f, 0.13644819f, -0.04080022f, -0.04433918f, -0.07154272f, -0.10860730f, 
    0.11705902f, -0.16732644f, 0.16515563f, -0.38898161f, -0.09027431f, 0.00712070f, 0.17072219f, 0.06318669f, 
    0.18192334f, 0.10924134f, -0.14018875f, 0.06688628f, 0.22005104f, 0.39621961f, 0.07195342f, 0.02139234f, 
    0.01500521f, -0.11678260f, 0.09515659f, 0.10247835f, -0.10223721f, 0.17050125f, -0.02128878f, -0.03006228f, 
    -0.15052308f, -0.00152537f, 0.12102483f, 0.04072906f, -0.18650706f, -0.00587500f, -0.22596064f, 0.00978757f, 
    -0.04151872f, 0.10393007f, 0.02565551f, -0.05656268f, -0.02776781f, -0.02653660f, -0.02886526f, 0.01111200f, 
    0.00917555f, -0.10316798f, -0.05630103f, -0.05197909f, -0.20671387f, -0.16070415f, -0.16311374f, -0.07697098f, 
    -0.20865005f, 0.13366161f, -0.15497884f, -0.10070375f, -0.01957370f, 0.16581124f, 0.09012688f, 0.16698456f, 
    0.09381463f, -0.02355177f, -0.23549294f, -0.07211031f, 0.26084358f, 0.25854582f, 0.22195427f, 0.08191138f, 
    0.19216146f, 0.15680715f, -0.03202659f, 0.19294976f, -0.05490387f, 0.10168673f, 0.11278313f, 0.16904867f, 
    -0.07945463f, -0.00561400f, -0.07960002f, -0.07710316f, -0.19682230f, 0.10273119f, 0.29209986f, -0.13639453f, 
    0.05750476f, -0.05334564f, 0.11123402f, 0.01284470f, 0.09479345f, 0.00658903f, 0.03281756f, -0.05501094f, 
    -0.13273832f, -0.14547555f, -0.03829313f, -0.06067775f, 0.03350076f, 0.01466872f, 0.03733577f, -0.02558408f, 
    -0.10307658f, 0.05365052f, 0.09656766f, 0.02399107f, -0.04536669f, -0.02577322f, -0.08882137f, -0.05708502f, 
    0.05581718f, 0.03460370f, 0.03303239f, 0.12620917f, 0.22542565f, 0.09485741f, -0.04242766f, -0.12787038f, 
    -0.09409866f, 0.07567851f, 0.00828121f, 0.03340925f, 0.01206664f, -0.07245366f, 0.08480451f, 0.00751787f, 
    -0.19090734f, 0.50066018f, 0.16648217f, -0.25143534f, -0.18901396f, -0.17331012f, 0.15619618f, 0.04833674f, 
    0.04082725f, -0.03306032f, -0.10135546f, 0.18169791f, 0.31765956f, -0.03779988f, -0.08363270f, -0.00128750f, 
    -0.03712404f, -0.03350892f, 0.00292865f, -0.05631198f, 0.20589666f, 0.17018852f, -0.26128122f, -0.01344710f, 
    0.12060772f, -0.05297972f, 0.19298920f, 0.08720869f, 0.05766436f, 0.16875221f, -0.05106222f, 0.16782345f, 
    0.07036623f, 0.05159191f, -0.01451431f, -0.06009986f, -0.41713563f, 0.12459523f, 0.20256355f, 0.01602207f, 
    0.03323882f, -0.01121363f, 0.05926458f, 0.18347660f, -0.02519246f, -0.02648161f, 0.06026010f, 0.07905270f, 
    0.09217715f, 0.21950497f, 0.10782161f, 0.00617031f, -0.19579013f, -0.14590375f, -0.18271957f, 0.10986489f, 
    -0.12264170f, -0.10647320f, 0.07215373f, 0.02836714f, 0.02249429f, -0.19111846f, 0.03638718f, 0.08874883f, 
    0.03781065f, 0.09413587f, -0.00835056f, 0.09791086f, 0.00538505f, 0.15943579f, -0.01795114f, 0.16265292f, 
    0.19789515f, 0.08722988f, -0.16640647f, -0.25930980f, -0.00005595f, -0.00270172f, 0.10291100f, -0.12670039f, 
    0.10449751f, 0.04253370f, 0.11202929f, 0.02651727f, -0.15312168f, 0.05001206f, -0.27737594f, -0.14248186f, 
    -0.04202635f, -0.10707901f, 0.06086393f, -0.02760579f, 0.06384236f, 0.01817314f, 0.01494312f, -0.06154913f, 
    -0.05772305f, 0.36207286f, 0.28138599f, 0.03564154f, -0.15156811f, -0.07845992f, 0.10487060f, 0.12156193f, 
    0.00795683f, 0.03988686f, -0.01110907f, -0.01010336f, -0.10819537f, 0.00869101f, 0.14773336f, -0.08119152f, 
    -0.01228845f, -0.06719990f, -0.12531447f, -0.00095176f, 0.17440206f, 0.10698466f, 0.08035722f, 0.18410933f, 
    0.57840115f, -0.07610506f, -0.15328537f, -0.07993938f, 0.15278479f, 0.02818666f, 0.07610901f, -0.02523232f, 
    0.06632895f, 0.09750449f, 0.04804492f, -0.00149470f, 0.03014455f, -0.15112089f, -0.00454459f, -0.12341566f, 
    -0.03918754f, 0.01858608f, 0.01447668f, -0.07266954f, -0.03956239f, -0.00094519f, -0.15410049f, -0.00519878f, 
    0.24329990f, -0.04222528f, -0.22367951f, 0.05908250f, 0.17825854f, 0.06297293f, 0.16774569f, -0.13662140f, 
    0.03926734f, -0.08302890f, -0.19852088f, -0.08158907f, 0.33314827f, 0.20447594f, 0.00892752f, -0.12468637f, 
    0.14361455f, -0.10016184f, 0.11201958f, 0.04423007f, -0.05686603f, -0.00200809f, -0.02870584f, 0.05319936f, 
    0.12333395f, 0.05003393f, 0.04616310f, -0.05984390f, 0.00033849f, 0.16871169f, -0.08420652f, 0.00332891f, 
    -0.07409285f, 0.05143216f, -0.01121671f, 0.01223328f, 0.12255568f, 0.15906605f, -0.02929899f, 0.06360544f, 
    0.05107760f, 0.15363942f, 0.12031203f, -0.13232060f, -0.09680451f, -0.04127344f, 0.07254597f, 0.17213929f, 
    0.67604595f, 0.41887859f, 0.10295257f, -0.23725316f, 0.10937110f, 0.13741790f, -0.07402231f, -0.12435985f, 
    -0.09468487f, 0.01606152f, 0.02756800f, -0.07511342f, 0.12834647f, -0.39732116f, -0.00596951f, 0.03011798f, 
    0.10521495f, 0.01220485f, -0.10476065f, -0.25635901f, -0.11882523f, -0.05367419f, -0.02839662f, 0.14882909f, 
    -0.34164119f, -0.31736076f, -0.17693286f, 0.05649906f, -0.15812905f, -0.31304073f, 0.04681865f, -0.24572815f, 
    0.11189753f, -0.14888737f, 0.07547022f, -0.07014062f, -0.00358390f, -0.33559906f, -0.36297947f, 0.17039272f, 
    -0.04342970f, -0.04244949f, -0.02657277f, -0.04675164f, 0.08836358f, -0.12138386f, -0.12311468f, -0.12942821f, 
    0.15410952f, 0.29535678f, 0.43435049f, 0.22187552f, 0.11648169f, 0.06349959f, 0.23650849f, -0.04800270f, 
    0.11547765f, -0.16546243f, 0.02025701f, 0.00310404f, -0.04448341f, 0.02334075f, -0.10261464f, 0.02031294f, 
    0.05576206f, -0.03421648f, 0.13804656f, 0.14159487f, -0.06240080f, -0.03445496f, 0.30115363f, 0.29837885f, 
    -0.12676197f, -0.26877773f, 0.00924116f, -0.27519774f, 0.06992039f, 0.04326991f, -0.03770118f, 0.05174402f, 
    0.00191254f, -0.02977046f, 0.08042927f, 0.19199000f, 0.34412009f, 0.05535543f, 0.01961062f, 0.23531345f, 
    0.07122687f, 0.00011360f, 0.08797578f, 0.09155528f, 0.12649623f, 0.05262038f, -0.19732293f, -0.03477317f, 
    -0.10106740f, -0.47341883f, 0.16295157f, 0.09367444f, -0.10058828f, -0.01348599f, -0.08037598f, -0.14081226f, 
    -0.12622572f, 0.11085703f, -0.11916325f, 0.12774326f, -0.06113209f, -0.43435636f, -0.14840806f, 0.24931625f, 
    -0.13764699f, -0.00335656f, -0.10446964f, 0.07320727f, 0.16607858f, 0.05937117f, 0.02982309f, 0.10870769f, 
    0.04815041f, -0.10992336f, 0.02315104f, -0.11306944f, -0.07727689f, -0.00149933f, 0.07467264f, 0.09979965f, 
    0.08568221f, -0.10557444f, 0.01071444f, -0.02999704f, 0.42538282f, 0.25808206f, 0.15418345f, 0.22976243f, 
    0.11221231f, 0.28666547f, -0.01597261f, 0.04999603f, -0.09085900f, 0.11439373f, 0.07774362f, -0.22424132f, 
    0.06276556f, -0.22586925f, -0.07647235f, 0.12365428f, 0.05590082f, -0.00937331f, 0.12447213f, -0.06000166f, 
    0.14352570f, -0.15767065f, 0.03917694f, 0.08044209f, -0.26704681f, 0.06105153f, -0.21237618f, -0.40654254f, 
    0.07001548f, 0.14962482f, 0.01269643f, -0.18483438f, -0.07227258f, 0.02008411f, -0.07363526f, 0.12010486f, 
    -0.52320695f, -0.10850066f, -0.18702799f, -0.03352063f, 0.10934673f, -0.22690022f, -0.36857083f, -0.03132061f, 
    0.12499039f, -0.05210773f, -0.02228956f, 0.03235262f, -0.03314673f, 0.06459022f, 0.03079812f, -0.08483178f, 
    0.00622154f, 0.04500930f, 0.11016466f, 0.02359395f, 0.03011923f, 0.02433085f, 0.00215254f, -0.01619831f, 
    0.11562016f, 0.24830575f, 0.33932263f, -0.14686048f, 0.11484651f, -0.01236072f, -0.03187462f, 0.07924070f, 
    0.08027125f, -0.02682095f, 0.08969021f, 0.00413290f, 0.04835492f, -0.11947478f, -0.15962400f, 0.01448069f, 
    0.05195342f, 0.08384559f, -0.04479009f, -0.00702341f, 0.21277353f, -0.07077014f, -0.01990306f, -0.13200791f, 
    0.03545374f, 0.04781314f, -0.02588452f, 0.05718356f, 0.01817800f, -0.06006049f, -0.00593957f, 0.03859562f, 
    -0.03132638f, -0.06585392f, -0.01500641f, -0.03196270f, 0.02170602f, -0.07566662f, -0.01991487f, 0.00827976f, 
    -0.03120637f, -0.06912417f, 0.00868328f, -0.07726692f, 0.03359392f, 0.05780337f, 0.00264287f, -0.02370392f, 
    -0.06622251f, -0.01653266f, 0.05642196f, -0.04876973f, -0.05545447f, -0.02305896f, -0.06734087f, -0.06714579f, 
    -0.05537804f, 0.03298081f, -0.04701086f, -0.03540992f, 0.06274374f, -0.04402503f, 0.06337792f, 0.05444811f, 
    0.03858186f, -0.06243642f, -0.07029311f, -0.01023664f, -0.05389896f, 0.00497337f, -0.06740879f, -0.04152868f, 
    -0.03318537f, -0.01390832f, -0.03365203f, 0.01364371f, 0.05570735f, -0.01118197f, 0.05186701f, -0.01284868f, 
    0.03944756f, 0.01469974f, -0.02774001f, -0.03719534f, -0.06590987f, 0.03463219f, 0.04756300f, -0.00626150f, 
    -0.07437387f, -0.06100803f, 0.05271014f, -0.03277054f, -0.04094740f, 0.00614390f, 0.02572897f, -0.02384179f, 
    0.05450571f, 0.03802801f, 0.03215440f, -0.02143152f, -0.02246747f, 0.02922531f, 0.02721174f, -0.02734366f, 
    0.04809962f, 0.05508062f, -0.06219617f, -0.03125793f, 0.06010541f, 0.05843395f, 0.00272676f, -0.03504824f, 
    -0.08232848f, -0.01525578f, -0.03173652f, -0.01886500f, 0.03900228f, -0.03018438f, -0.05028916f, -0.02346884f, 
    -0.07717674f, -0.07967205f, -0.05083301f, 0.03218004f, -0.00362084f, -0.07730594f, 0.02953201f, -0.05678455f, 
    -0.01206223f, 0.04624222f, -0.03028385f, -0.02748734f, -0.01936807f, 0.07351945f, -0.00841847f, 0.02167493f, 
    0.01990937f, 0.05543049f, 0.03841981f, -0.03287171f, 0.04723341f, -0.02427823f, -0.02169244f, 0.03931524f, 
    0.05901426f, -0.03104663f, -0.00984051f, -0.07990594f, -0.05021637f, -0.01734073f, -0.02535568f, -0.07363176f, 
    -0.07759236f, -0.00752798f, 0.02300674f, 0.00666586f, -0.07051007f, -0.04769139f, -0.03948753f, 0.02167968f, 
    0.03737520f, 0.04063683f, 0.04243606f, -0.06020817f, -0.06030662f, -0.05731089f, 0.02377732f, -0.00343080f, 
    0.02876223f, 0.04451183f, -0.04972262f, -0.06817209f, 0.03398757f, -0.03041442f, -0.00556463f, 0.05913805f, 
    -0.04012481f, -0.03078302f, -0.01331246f, -0.05364479f, -0.06650816f, -0.01672182f, 0.04745117f, -0.03685258f, 
    0.02222545f, 0.00377062f, -0.02466060f, -0.04149091f, -0.07382791f, 0.04650420f, 0.00695677f, -0.06947129f, 
    -0.07883673f, 0.06108855f, 0.00288877f, -0.06793012f, 0.04697696f, 0.05138240f, -0.02175355f, -0.04602217f, 
    -0.04145677f, -0.06353434f, 0.03543723f, -0.06804424f, -0.05073423f, 0.03992797f, 0.01408630f, -0.04362096f, 
    -0.07803591f, -0.05313341f, -0.07965899f, -0.00333612f, 0.00615780f, 0.01733625f, -0.08019137f, -0.07809834f, 
    -0.01682781f, -0.07513693f, -0.07765652f, -0.03129197f, 0.01000849f, -0.01807021f, 0.01954087f, -0.00170180f, 
    -0.03772014f, -0.05207004f, 0.02115286f, 0.05803139f, -0.02611978f, -0.05454329f, 0.01956843f, 0.00244505f, 
    -0.03681407f, 0.01022296f, -0.01474305f, 0.01174634f, -0.07699356f, -0.01914495f, 0.03520862f, 0.05252050f, 
    -0.05097220f, -0.06748424f, 0.02007533f, -0.06486415f, -0.00402038f, -0.07123025f, -0.04884530f, -0.01121295f, 
    0.00972106f, 0.04802241f, -0.02932448f, 0.01355005f, -0.02718218f, -0.03607694f, -0.07139650f, -0.00290868f, 
    0.06068825f, -0.02770226f, -0.01182239f, 0.02623849f, -0.04207733f, -0.01438180f, 0.01263755f, 0.05253127f, 
    0.05338181f, -0.06209433f, -0.01455162f, 0.06216746f, -0.06741063f, -0.06919470f, 0.04139544f, -0.05874174f, 
    -0.04903466f, 0.06408729f, -0.02055185f, -0.01731983f, -0.00265773f, -0.02760457f, -0.05962440f, -0.04690856f, 
    -0.01409461f, 0.02245177f, 0.02262840f, 0.04856458f, -0.07559647f, -0.02985978f, 0.00952723f, 0.06170452f, 
    -0.07043244f, -0.05907764f, -0.07587942f, -0.05663450f, -0.06670480f, 0.00608580f, -0.02412573f, 0.04542983f, 
    0.02822693f, -0.01176242f, -0.05065590f, -0.03664825f, 0.06105058f, -0.07369612f, -0.04393546f, -0.00523259f, 
    -0.06634295f, -0.03116834f, -0.02008699f, -0.05628360f, -0.03394773f, -0.03478387f, 0.00477848f, -0.03509473f, 
    0.05788444f, -0.05103371f, -0.03186736f, 0.05136940f, 0.03305924f, 0.03765084f, 0.04540624f, -0.00624088f, 
    -0.03419629f, -0.01048615f, 0.02323153f, 0.03628394f, -0.03059632f, -0.04539246f, 0.06400629f, 0.01616942f, 
    -0.04655547f, 0.03959233f, -0.06184229f, 0.03874264f, 0.03320390f, 0.06058601f, -0.02252922f, 0.01022110f, 
    0.03852614f, 0.02792491f, 0.05300090f, 0.05992383f, 0.02381786f, 0.02178051f, -0.07016195f, -0.01771736f, 
    0.03995631f, 0.04867834f, 0.04753491f, -0.04281799f, 0.03566388f, -0.05764369f, -0.01947330f, -0.01511495f, 
    0.01376070f, -0.00477425f, 0.02704631f, 0.03031024f, 0.01782572f, -0.06587091f, 0.05009585f, -0.00305932f, 
    0.00774703f, -0.04009687f, -0.04602351f, -0.04979400f, 0.01370719f, -0.06557045f, -0.04828537f, -0.04343417f, 
    0.02101975f, 0.04782273f, -0.04102832f, 0.02334202f, 0.02336430f, 0.04377389f, -0.02449774f, 0.03643971f, 
    0.02371495f, -0.07615180f, 0.00427071f, -0.05351114f, 0.04052697f, 0.03363924f, 0.04847060f, 0.02302763f, 
    0.05201152f, -0.00025093f, 0.00334425f, -0.00418975f, -0.06879257f, 0.02848618f, -0.04747421f, -0.06742445f, 
    -0.01459621f, -0.05596599f, 0.04904908f, -0.04918133f, -0.07006873f, -0.05825043f, -0.01515352f, -0.03839216f, 
    0.04154487f, 0.05105425f, -0.00795336f, -0.05487352f, -0.07033490f, -0.06774621f, 0.03700256f, -0.05798573f, 
    0.04926065f, -0.01376500f, -0.03473184f, -0.05397695f, 0.00042304f, -0.01800808f, 0.03881687f, 0.06658623f, 
    -0.02686593f, -0.06983694f, 0.00381535f, 0.03312713f, -0.05624750f, 0.00878989f, -0.06171061f, 0.06177954f, 
    0.05098737f, -0.04845091f, 0.02942465f, 0.00379290f, 0.06191171f, -0.03731200f, 0.03328810f, -0.05247295f, 
    0.05134202f, -0.01380456f, -0.01467150f, 0.05743955f, 0.01043689f, 0.03043244f, 0.00610748f, -0.03188119f, 
    0.04525144f, 0.02363003f, -0.05533702f, 0.00528498f, -0.02658198f, -0.00575948f, -0.03448327f, 0.00109068f, 
    0.01657920f, -0.03163806f, -0.04437841f, 0.04264874f, -0.01318830f, -0.04199363f, -0.07371179f, 0.05002034f, 
    0.01435825f, -0.04805304f, -0.04486344f, 0.06120140f, 0.04954625f, -0.03124344f, 0.00385177f, -0.01474024f, 
    0.00329504f, 0.03440934f, 0.02795976f, -0.01175566f, 0.05695913f, 0.00124215f, -0.07608192f, 0.06065425f, 
    -0.05162760f, -0.00065325f, 0.03121057f, -0.04371423f, -0.03858642f, -0.04583954f, -0.00495551f, -0.03651895f, 
    0.01231665f, -0.04439906f, 0.02430234f, 0.05516671f, -0.06024648f, 0.05292033f, -0.07156727f, -0.05095246f, 
    0.02347780f, -0.03502247f, 0.01349827f, -0.06809126f, 0.06555303f, -0.06126029f, -0.03594458f, -0.01158066f, 
    0.05197111f, -0.05594575f, -0.05999095f, 0.04979767f, -0.02328583f, 0.04562542f, -0.07433951f, -0.03381503f, 
    -0.00922779f, 0.00562011f, 0.01366516f, 0.00179737f, -0.04343615f, -0.07798918f, 0.04045261f, 0.03335565f, 
    -0.02357887f, 0.02880728f, 0.00119644f, -0.06387656f, 0.06192589f, 0.04749068f, -0.02067612f, 0.00334667f, 
    -0.06733988f, 0.00330472f, -0.01099762f, 0.05106887f, 0.03748437f, -0.00196221f, -0.07380129f, 0.00738231f, 
    0.04024214f, -0.00423354f, -0.02747276f, 0.01653031f, -0.03489807f, 0.01534930f, 0.01566759f, -0.03510511f, 
    -0.04925792f, -0.04375726f, -0.02105446f, -0.00509944f, 0.06820212f, -0.03111798f, -0.04287880f, 0.03148647f, 
    -0.05917190f, 0.05539557f, -0.04773287f, 0.01158280f, -0.00394162f, -0.07634252f, -0.05547510f, 0.04812561f, 
    -0.07142104f, -0.06297281f, -0.07427908f, -0.02353463f, 0.03626775f, -0.07518397f, -0.01274203f, 0.05374842f, 
    0.02501057f, 0.04299555f, -0.07045590f, -0.02346535f, 0.02436972f, -0.06791221f, 0.03278600f, 0.05930685f, 
    -0.00077262f, -0.01416018f, -0.06194139f, 0.03635609f, -0.07262865f, -0.04979508f, -0.07665380f, -0.05896900f, 
    0.04404521f, 0.01002693f, -0.06272742f, -0.01624848f, 0.05907633f, -0.01299418f, 0.03071695f, -0.03544369f, 
    -0.03260782f, 0.00366255f, -0.05358381f, 0.00181118f, -0.03806146f, -0.03851632f, 0.06051267f, -0.03158220f, 
    0.00140785f, 0.00155835f, -0.03064684f, -0.00545205f, 0.03034176f, -0.03597508f, -0.03099400f, -0.02342075f, 
    0.16494186f, -0.08095787f, -0.09615537f, 0.18529801f, -0.19621567f, -0.28912765f, 0.19104560f, -0.20681444f, 
    -0.02214381f, -0.09714367f, -0.06986303f, -0.10679927f, -0.30840707f, -0.13753310f, -0.03258156f, 0.41867504f, 
    -0.07110367f, 0.05173920f, -0.06879767f, 0.03826272f, -0.04882163f, -0.24094990f, -0.10128357f, 0.09166609f, 
    0.22532327f, 0.02558376f, 0.24362984f, 0.22712901f, 0.05602469f, 0.04880039f, 0.09202611f, -0.10759376f, 
    0.11187502f, -0.17906952f, -0.02300703f, 0.01761546f, 0.18847634f, 0.10797910f, 0.06586954f, 0.09924280f, 
    0.07232126f, -0.21050015f, 0.09394579f, 0.22189355f, 0.08068962f, 0.05146120f, 0.23971769f, 0.18314078f, 
    0.01882125f, 0.25016522f, 0.49914673f, -0.23859252f, -0.09263720f, 0.05171332f, 0.06102178f, -0.13159738f, 
    0.07357752f, 0.20100784f, -0.05669970f, 0.21669084f, 0.13845924f, 0.08490870f, -0.01943901f, 0.14530711f, 
    0.18046468f, 0.04652968f, -0.03850134f, 0.07429251f, 0.09769771f, 0.20773017f, -0.07572477f, 0.05091641f, 
    -0.66337115f, -0.47393224f, 0.27935567f, 0.38312858f, -0.03484507f, 0.25775284f, -0.03516183f, -0.03692736f, 
    -0.24107556f, -0.13088742f, -0.00508041f, -0.18382198f, -0.21556653f, -0.28546104f, -0.17410509f, 0.26722887f, 
    -0.00688338f, -0.09183667f, -0.08443200f, -0.00959832f, 0.24963284f, 0.04026928f, 0.08089562f, 0.13492523f, 
    0.03011076f, 0.27342293f, 0.16216162f, 0.04558396f, -0.12802595f, -0.11014027f, 0.08000650f, -0.04845506f, 
    0.09076402f, 0.11684882f, 0.07600180f, 0.02142759f, 0.01797994f, 0.03336439f, -0.03710078f, -0.01222792f, 
    0.22493216f, 0.18724436f, 0.17298029f, 0.12486339f, -0.03959156f, 0.00500663f, -0.03228784f, 0.06391750f, 
    0.24545789f, 0.00871547f, 0.08447687f, -0.01635079f, -0.13696162f, -0.09404509f, 0.16311656f, -0.14664355f, 
    -0.02995674f, -0.09267618f, -0.09963603f, -0.07603513f, -0.11817206f, 0.12114659f, -0.14830005f, -0.13399431f, 
    -0.18387166f, 0.02454330f, -0.03100247f, -0.22357720f, -0.09005179f, 0.03773142f, -0.11248337f, -0.05047012f, 
    -0.01824206f, -0.13215965f, -0.16542196f, 0.10362918f, -0.00427531f, -0.01427309f, -0.26013747f, -0.06108170f, 
    -0.08520324f, 0.10023754f, -0.19439253f, -0.19076499f, -0.15665361f, -0.02424948f, -0.12350374f, -0.01718990f, 
    0.16564988f, 0.08421484f, -0.02630131f, 0.03466899f, 0.15034334f, 0.01027350f, -0.15504646f, -0.01575445f, 
    -0.14691438f, 0.43671709f, 0.09788252f, -0.25283551f, 0.22084078f, 0.05162177f, 0.04826619f, -0.07280578f, 
    0.12622067f, -0.04840777f, -0.14022629f, 0.19026929f, 0.47115406f, -0.07500976f, -0.01679303f, 0.05142994f, 
    -0.02336380f, -0.14573431f, 0.08141426f, 0.05082892f, 0.09089659f, -0.23856644f, -0.07886184f, 0.02210170f, 
    0.02770852f, 0.02173254f, -0.04206259f, -0.04008370f, -0.05949637f, 0.00973209f, -0.05179013f, 0.06035371f, 
    0.04148647f, -0.03557080f, -0.07856042f, -0.05508509f, -0.01519855f, -0.07536697f, 0.02701740f, -0.00406855f, 
    -0.02001682f, -0.04316161f, -0.05360490f, -0.02019081f, -0.05720641f, -0.03287476f, 0.00503957f, 0.00173324f, 
    -0.05262880f, -0.03763128f, 0.03366393f, -0.05476301f, 0.04504228f, 0.05289906f, -0.06533441f, -0.08569907f, 
    0.00141816f, -0.06184695f, -0.01903353f, -0.01482929f, -0.00700889f, -0.02669497f, -0.01065776f, 0.00246631f, 
    0.04823050f, 0.00324096f, 0.01322527f, -0.03078020f, -0.01045934f, 0.01030191f, 0.00500924f, -0.04595336f, 
    -0.04994914f, -0.00172924f, 0.05593059f, -0.00351553f, 0.03388553f, -0.03383813f, 0.02461235f, -0.02779691f, 
    0.03550981f, 0.06063474f, -0.06120102f, 0.01693221f, 0.00837345f, -0.07411168f, -0.01903186f, -0.04506645f, 
    -0.04692224f, 0.03432944f, -0.01005701f, -0.00412220f, 0.00155020f, 0.01133258f, -0.06130280f, -0.04744961f, 
    0.05067523f, 0.05555305f, 0.04865812f, 0.04591176f, -0.07022784f, -0.01084430f, -0.04448303f, -0.03579303f, 
    0.02347026f, -0.03202180f, 0.03002700f, 0.05516858f, 0.04541685f, -0.06330700f, 0.01751571f, -0.00092999f, 
    -0.00092721f, 0.05883905f, -0.05497378f, 0.01967204f, 0.00342863f, -0.05611293f, -0.03175664f, -0.01164036f, 
    -0.07250653f, -0.06271922f, -0.07905773f, -0.02772863f, 0.04965901f, 0.05628157f, -0.07359652f, 0.01880809f, 
    -0.00420935f, 0.06681591f, 0.00602687f, 0.05410139f, 0.05063595f, 0.05164256f, 0.00609852f, -0.03378357f, 
    -0.00760821f, -0.06582455f, -0.00674973f, -0.00954744f, -0.05707417f, -0.03786037f, 0.01924775f, -0.03768340f, 
    0.03060907f, 0.03227653f, -0.06469196f, 0.02351628f, 0.04601159f, -0.04983053f, -0.03412353f, 0.04456409f, 
    0.04928971f, -0.04545914f, -0.04445272f, 0.00776280f, -0.04832292f, 0.00780299f, -0.03775264f, -0.00724111f, 
    0.04253322f, 0.02334791f, -0.01304816f, 0.00634993f, -0.01397256f, 0.05311765f, 0.02203431f, -0.05209460f, 
    -0.03668326f, 0.05982324f, -0.08328369f, 0.00535763f, -0.07019579f, -0.07831943f, 0.05905451f, -0.05174519f, 
    0.03958759f, -0.00087145f, 0.01860833f, -0.00033673f, -0.01999310f, -0.05884774f, -0.02905723f, -0.02824798f, 
    -0.06368248f, -0.00940167f, -0.05625086f, 0.03247071f, -0.04375525f, 0.03425142f, -0.08402728f, 0.00963991f, 
    0.02443150f, -0.04839921f, 0.02062063f, -0.07980559f, -0.03505398f, -0.06199344f, 0.06238240f, -0.03415640f, 
    0.03991156f, 0.00706853f, -0.03853278f, -0.07046302f, -0.01557264f, -0.04608568f, 0.02599867f, -0.03458173f, 
    0.01761950f, 0.05635961f, 0.00158897f, -0.01077356f, -0.05853470f, -0.00769057f, -0.00515244f, -0.05320001f, 
    0.00498526f, 0.02727566f, -0.06004020f, 0.00206521f, 0.05368786f, 0.02678628f, 0.04215844f, -0.06468750f, 
    0.01517524f, 0.02825394f, 0.02454845f, 0.03431249f, -0.04079445f, -0.03345679f, -0.01389400f, 0.03893286f, 
    0.05983819f, -0.03896883f, -0.07306861f, -0.07749347f, 0.01645380f, -0.06150820f, 0.04542339f, 0.01121731f, 
    -0.05911869f, -0.02827587f, 0.01767422f, 0.00555850f, 0.01912635f, -0.03277935f, -0.05869097f, 0.02616330f, 
    -0.04337943f, -0.06749859f, -0.00182100f, -0.02539123f, 0.02903057f, 0.05943829f, -0.06078286f, 0.00634204f, 
    -0.04222490f, -0.05589195f, 0.03454068f, 0.02025216f, -0.04513551f, -0.02839491f, 0.02283675f, -0.04187860f, 
    0.06204615f, -0.03694215f, 0.00038455f, 0.02005918f, -0.06692369f, -0.00328285f, -0.05045653f, 0.01233303f, 
    -0.00284104f, 0.05604066f, 0.01625410f, 0.00020422f, -0.02938375f, -0.00521292f, 0.01750298f, -0.04564913f, 
    -0.07672677f, 0.05451860f, 0.03856538f, -0.00221824f, -0.05872960f, -0.01337253f, 0.04789102f, 0.04494298f, 
    -0.02926885f, -0.03010834f, 0.04500582f, 0.04254233f, 0.00036102f, -0.06752323f, -0.05547536f, 0.04866462f, 
    -0.05484821f, -0.03354834f, 0.04962925f, 0.04528049f, 0.04819514f, -0.07626022f, -0.04344774f, 0.04409806f, 
    -0.01908658f, -0.02360866f, -0.02616868f, 0.03226890f, 0.01771359f, 0.04365433f, -0.05331725f, 0.00248305f, 
    0.03413328f, -0.02838267f, -0.04000611f, -0.05129502f, 0.04243419f, 0.06176750f, -0.05117348f, -0.06191912f, 
    -0.03954961f, -0.01606259f, 0.01150603f, -0.00055172f, -0.07082095f, 0.04641302f, 0.01088333f, -0.02302911f, 
    -0.06814884f, -0.03238252f, 0.01636312f, 0.03817257f, -0.01055700f, 0.03516495f, -0.07572691f, 0.05945940f, 
    -0.03686897f, 0.01606692f, 0.05170969f, -0.04536463f, 0.05502220f, -0.06276397f, 0.04010011f, -0.02672429f, 
    0.04253987f, -0.02231828f, 0.00721262f, 0.04093377f, 0.05109779f, -0.02932912f, 0.03542667f, -0.07217584f, 
    -0.05129809f, -0.05672206f, -0.04448614f, -0.04920140f, -0.02184726f, 0.06469440f, -0.02638048f, -0.04058839f, 
    -0.07815638f, -0.00267066f, 0.00444554f, -0.05473120f, -0.02061547f, -0.00102219f, -0.06788003f, 0.01862000f, 
    -0.04072286f, -0.07076801f, -0.02566241f, -0.05420455f, 0.03682828f, -0.03915111f, -0.06595099f, -0.03469077f, 
    -0.05609543f, -0.04980493f, -0.02857343f, 0.03271418f, -0.05606299f, 0.01120083f, 0.04963752f, 0.05091456f, 
    -0.05529604f, 0.06040001f, -0.00824923f, -0.07670850f, 0.05398811f, 0.04368320f, 0.01276802f, -0.04629667f, 
    -0.04059232f, 0.01558127f, -0.07279284f, -0.02777042f, 0.01270297f, -0.06660857f, -0.07024559f, -0.06734831f, 
    0.02258619f, -0.04583884f, -0.01851390f, -0.03654191f, -0.02358888f, -0.05885682f, 0.05378801f, -0.07667053f, 
    -0.05293560f, 0.04516724f, -0.01710625f, -0.14124198f, 0.08328104f, 0.00518993f, -0.01338942f, -0.14986457f, 
    0.07688445f, 0.11922321f, 0.13097422f, 0.09286244f, -0.14764453f, 0.21791536f, -0.06872811f, 0.06609231f, 
    -0.09179011f, -0.00562004f, -0.12557983f, -0.11754943f, 0.06102502f, 0.06082501f, -0.00495084f, 0.03466118f, 
    -0.02776769f, -0.03602415f, 0.00189509f, 0.17738040f, 0.08035553f, 0.02008254f, 0.02890966f, 0.19603467f, 
    0.10261951f, 0.11244453f, -0.11836366f, 0.03428906f, 0.02836422f, -0.26179117f, -0.15766382f, 0.10253718f, 
    0.03338053f, 0.04466075f, -0.05856325f, -0.03037728f, -0.05939037f, 0.01285907f, -0.05807433f, -0.03991451f, 
    -0.01426605f, 0.30144510f, -0.26855096f, -0.15450262f, -0.07631673f, 0.02724388f, -0.10036113f, -0.07021795f, 
    0.10624660f, -0.13960946f, 0.08300656f, -0.07058283f, 0.30666545f, -0.24967085f, 0.10003144f, 0.09512659f, 
    0.06650805f, 0.05293805f, -0.01674887f, 0.19767231f, -0.12717105f, -0.05092584f, -0.02589139f, 0.01412413f, 
    -0.07595593f, 0.10557584f, 0.14834690f, 0.08166459f, -0.06997593f, -0.09983573f, 0.05622913f, -0.08143605f, 
    0.12771796f, 0.10031554f, -0.04226668f, -0.00798018f, 0.03528873f, -0.03268102f, 0.03195383f, -0.14126138f, 
    -0.13357481f, -0.01708291f, 0.00131029f, -0.09005815f, -0.04640763f, -0.09174588f, 0.07340071f, -0.06233186f, 
    0.49924174f, -0.20331246f, -0.25300539f, -0.16092911f, -0.00907875f, -0.14458178f, 0.07212508f, -0.02550260f, 
    -0.11176411f, 0.05892878f, -0.15756124f, -0.10313645f, 0.00894778f, -0.05298425f, 0.02201713f, 0.33356649f, 
    -0.00691749f, 0.03499225f, -0.02671841f, 0.13423827f, 0.01608478f, -0.03859809f, -0.00664139f, 0.02944582f, 
    0.10479760f, -0.19092619f, -0.11411591f, 0.02956804f, 0.03696457f, 0.00799757f, 0.11914409f, 0.10083843f, 
    0.02978821f, 0.11354176f, 0.12329701f, 0.08561344f, 0.02495587f, 0.15199828f, -0.17435129f, -0.16354491f, 
    0.11543457f, 0.03108857f, -0.23492187f, 0.16338620f, 0.00535418f, 0.07164075f, 0.03247276f, 0.02749094f, 
    -0.09071570f, 0.11166989f, 0.03607159f, -0.01927050f, 0.05868870f, -0.02790573f, 0.01377203f, -0.09005322f, 
    0.13737746f, -0.00220271f, 0.27274334f, 0.01161455f, -0.09911689f, -0.11524076f, 0.03166256f, 0.02548705f, 
    -0.03096984f, 0.00314156f, 0.04673454f, 0.07369237f, 0.02880215f, -0.06191686f, 0.01184045f, 0.00040706f, 
    0.42945918f, -0.19687334f, 0.21874805f, -0.15118825f, 0.00901229f, -0.07091523f, -0.15977205f, -0.22461133f, 
    0.01486681f, 0.03730806f, -0.00450790f, 0.00641053f, 0.01771057f, 0.09987184f, -0.03658568f, 0.09359868f, 
    -0.04705596f, 0.01886286f, 0.01137534f, 0.05877692f, 0.10236789f, 0.21548384f, 0.07008417f, 0.03931530f, 
    -0.13468307f, 0.04970236f, -0.01130454f, -0.16806380f, -0.00970171f, -0.03535435f, -0.08966494f, -0.01485054f, 
    0.05830349f, -0.02295798f, 0.06167686f, -0.03942224f, 0.12220197f, 0.27702504f, 0.25693309f, 0.16287924f, 
    -0.12001863f, -0.18980898f, 0.03117703f, -0.07346978f, -0.05325344f, -0.09512994f, 0.04536311f, 0.06556559f, 
    0.00531247f, -0.35413945f, -0.00915071f, -0.15117703f, 0.04922133f, 0.12143366f, -0.11039769f, 0.05198158f, 
    -0.12409762f, 0.12435676f, -0.18407579f, -0.10834613f, 0.15939584f, -0.05355813f, 0.09595826f, -0.04486336f, 
    0.08987334f, -0.04993735f, -0.15001082f, -0.06469256f, -0.08715301f, 0.09165269f, -0.13432351f, -0.24885850f, 
    -0.15597409f, 0.55416626f, -0.09693584f, 0.21529557f, -0.04497689f, -0.02465311f, 0.07845276f, -0.06641705f, 
    0.02691646f, -0.12715481f, -0.03154954f, 0.08698000f, -0.19070086f, -0.03953217f, 0.03881832f, 0.06612317f, 
    -0.10600311f, 0.15602301f, 0.12753497f, 0.02812688f, -0.11448723f, -0.09908944f, 0.05766397f, 0.01005368f, 
    0.24065164f, 0.40250751f, 0.11273038f, 0.00121127f, -0.02592224f, -0.03447607f, -0.14467750f, 0.01506695f, 
    0.02392811f, 0.07835643f, 0.13431260f, -0.05569675f, 0.01298227f, 0.14292157f, -0.00364154f, -0.04123298f, 
    -0.15058525f, -0.11080137f, -0.08310945f, -0.12541834f, -0.10542378f, -0.17303009f, -0.10259771f, -0.29593056f, 
    -0.19136785f, 0.02672764f, -0.27180046f, -0.08092944f, 0.05688285f, -0.08126931f, 0.00499465f, -0.09249030f, 
    -0.16913345f, 0.14386931f, 0.09619024f, 0.02108890f, -0.08671226f, 0.01171400f, -0.03155434f, 0.18089171f, 
    0.03327380f, -0.16424100f, 0.06084722f, 0.11627969f, -0.08534948f, -0.03210474f, -0.03941262f, 0.13098510f, 
    -0.29802108f, 0.20348936f, -0.02721264f, 0.01388055f, 0.05560804f, -0.01924645f, 0.17592493f, 0.16697793f, 
    -0.10077757f, 0.10564120f, -0.05516013f, -0.02294961f, -0.25816196f, 0.26897845f, -0.00317241f, 0.21257693f, 
    0.31953964f, 0.11166237f, 0.15754029f, 0.15393132f, -0.02535211f, -0.18476495f, 0.06211817f, 0.00646119f, 
    0.16189909f, -0.02180873f, 0.21166824f, -0.17272012f, -0.04920030f, 0.06994857f, 0.02204468f, -0.01409703f, 
    0.21864836f, 0.23172395f, 0.09272813f, 0.05800505f, -0.05015581f, 0.14152065f, -0.13273464f, 0.29743305f, 
    0.09005534f, 0.12505619f, 0.04448639f, 0.11757139f, -0.05415547f, -0.00538696f, -0.10128006f, 0.03753994f, 
    -0.00097765f, 0.10511730f, -0.31595957f, -0.06464083f, 0.04658037f, -0.11518520f, 0.17861550f, -0.00138389f, 
    -0.00016292f, 0.12363521f, 0.14613296f, 0.23623714f, 0.16604745f, 0.05786236f, 0.12108746f, 0.11478677f, 
    -0.00587266f, 0.03968122f, -0.00666193f, 0.14607236f, 0.03136984f, 0.00941224f, -0.04765089f, 0.06765218f, 
    -0.06112921f, 0.09436606f, 0.02704770f, 0.03416016f, -0.08428746f, 0.01109508f, -0.23597896f, -0.02122425f, 
    -0.00293504f, 0.02875073f, 0.09349107f, 0.01423026f, 0.04598409f, 0.37172365f, 0.29412383f, -0.12137430f, 
    -0.04260940f, -0.08655247f, -0.02273660f, -0.15826929f, -0.06965114f, -0.06275474f, -0.04772790f, 0.03991807f, 
    0.03227386f, -0.31464121f, -0.03252780f, -0.18321723f, 0.01273026f, -0.02193281f, -0.19161227f, 0.15705058f, 
    -0.17627501f, 0.07818273f, 0.01162119f, 0.09641899f, 0.21667184f, -0.13418579f, 0.31809199f, 0.20913108f, 
    0.17250247f, 0.21307063f, 0.02543319f, -0.04727567f, -0.06595579f, -0.00632301f, -0.03056580f, 0.01761609f, 
    0.20827015f, 0.14963616f, -0.11048729f, -0.19043578f, -0.12394186f, -0.14578024f, 0.02093633f, -0.01378023f, 
    0.00678633f, -0.07262856f, 0.10741787f, 0.01813578f, -0.46626979f, -0.32828492f, -0.00996076f, -0.14964403f, 
    -0.01833761f, 0.04375235f, -0.06903520f, -0.06792381f, -0.01555929f, -0.06161791f, 0.16244659f, -0.03571017f, 
    -0.00624210f, 0.45338961f, 0.00570880f, 0.16071372f, -0.16020173f, -0.12610804f, -0.02925209f, -0.18967451f, 
    -0.07925749f, -0.18705498f, -0.06024664f, 0.02112312f, -0.09885044f, 0.10138621f, 0.07045859f, -0.19007252f, 
    0.05326379f, -0.00899155f, -0.05384162f, -0.09511612f, 0.02524196f, -0.01088000f, 0.05056982f, -0.07579766f, 
    -0.13067061f, 0.20709525f, -0.09439343f, -0.16393800f, -0.01856584f, 0.04309206f, -0.08525532f, 0.01950418f, 
    0.03261609f, 0.12160294f, 0.01321931f, 0.18640894f, -0.17868538f, -0.22383453f, -0.07787630f, -0.18100932f, 
    -0.01630095f, -0.12357660f, -0.02225517f, -0.09663908f, 0.03728378f, 0.03551964f, -0.08846536f, -0.00568656f, 
    -0.03519106f, 0.07091656f, 0.01119173f, 0.15731788f, 0.16554902f, 0.05638499f, 0.04331816f, 0.22112252f, 
    -0.04111110f, 0.13318400f, -0.08550916f, 0.00576252f, 0.13097505f, 0.11872414f, 0.23080169f, 0.05180414f, 
    0.23701800f, 0.01290727f, 0.06761625f, 0.12817496f, -0.03905073f, 0.06022446f, 0.08059021f, -0.09240818f, 
    0.11611507f, 0.06957313f, 0.15753478f, 0.12579709f, -0.01300615f, 0.02964575f, 0.07584295f, -0.02564414f, 
    0.04323842f, -0.07011630f, 0.11956258f, -0.14429784f, 0.08498016f, 0.04499511f, 0.02913478f, 0.12869778f, 
    0.14148653f, 0.08009782f, -0.01389972f, -0.14855909f, 0.03450289f, 0.05643939f, 0.17016323f, 0.12007234f, 
    0.13710551f, 0.04011118f, -0.25922000f, -0.04946414f, -0.06455117f, 0.07846184f, -0.06760239f, 0.10404709f, 
    0.01388905f, 0.01528510f, 0.11227447f, -0.03438403f, -0.03415275f, -0.01678043f, 0.34354594f, 0.00620134f, 
    0.06307485f, 0.07581250f, 0.10365312f, 0.24695700f, -0.04017214f, 0.14279811f, 0.08385044f, 0.05658178f, 
    0.15913016f, -0.06570984f, -0.02114343f, 0.01087478f, -0.06787276f, -0.01196958f, 0.08797511f, -0.10217984f, 
    -0.07389268f, -0.07793675f, -0.07946238f, 0.16215232f, 0.21569064f, 0.08179700f, 0.02730148f, -0.06988100f, 
    0.09981723f, -0.01671387f, -0.01079353f, 0.09242032f, 0.02713274f, -0.03176256f, 0.00032564f, -0.04050684f, 
    -0.19415224f, 0.01102094f, 0.08828194f, -0.03807468f, -0.07068098f, 0.17097080f, 0.13038313f, -0.16038410f, 
    -0.03438017f, -0.01928882f, -0.06561679f, -0.01990040f, -0.07218928f, 0.28631264f, -0.20631215f, -0.05258877f, 
    -0.06557907f, 0.01639939f, 0.16079935f, 0.02474017f, 0.09575464f, -0.11541166f, 0.21157272f, 0.15432224f, 
    0.03633860f, -0.11601047f, 0.12305482f, 0.29642153f, -0.04554768f, -0.03887386f, -0.14127445f, 0.07272463f, 
    0.18633705f, 0.04049952f, 0.19787425f, -0.02765380f, 0.03596133f, -0.27918220f, -0.00657797f, -0.13984153f, 
    0.08438113f, 0.10277145f, -0.08750831f, -0.24620794f, 0.14719583f, -0.10147969f, -0.05271705f, -0.02348579f, 
    -0.26846951f, -0.49321851f, -0.11814266f, -0.04682945f, 0.24964644f, 0.22987056f, 0.18994178f, 0.06628549f, 
    -0.05090066f, -0.08046326f, -0.00083320f, -0.02429939f, 0.11614823f, 0.02399555f, 0.02572744f, -0.05581387f, 
    -0.03396481f, 0.02038680f, 0.08303979f, 0.09875685f, 0.15549734f, 0.11521962f, 0.01582745f, -0.09956074f, 
    -0.04110735f, -0.17142008f, 0.33591482f, 0.13835533f, -0.02396416f, -0.20012389f, 0.02740319f, -0.07647873f, 
    0.08586519f, 0.07332531f, 0.16945086f, 0.15266021f, -0.09430748f, -0.09673816f, -0.07921386f, -0.25060329f, 
    0.19053130f, 0.20617382f, 0.09829324f, -0.03586347f, 0.02581133f, 0.09598372f, -0.03279788f, 0.05971603f, 
    -0.16042115f, -0.45249704f, 0.07135177f, 0.03582547f, 0.07989819f, 0.01871416f, -0.11365656f, 0.00610540f, 
    0.33048317f, -0.10325996f, 0.14692301f, 0.11279514f, -0.08137146f, -0.09354296f, 0.06414495f, 0.18498196f, 
    -0.02240202f, 0.18112764f, -0.12987277f, 0.12641256f, 0.08139926f, -0.02573479f, 0.06667463f, 0.16507903f, 
    -0.03911784f, 0.01129706f, -0.01779812f, 0.08867121f, -0.03970435f, 0.00482083f, -0.06526926f, -0.06808319f, 
    -0.03477606f, 0.04802732f, 0.07853512f, 0.05771760f, -0.18040638f, 0.03957487f, 0.24763113f, -0.22321530f, 
    -0.11555158f, 0.00185688f, 0.11078496f, 0.13260032f, -0.01657979f, 0.06497900f, -0.10793563f, -0.00216837f, 
    0.16440754f, -0.52874911f, 0.32775775f, 0.15911895f, 0.03602972f, 0.07024585f, -0.06805466f, 0.20113529f, 
    0.04834271f, 0.12352536f, 0.07722348f, 0.11943013f, -0.28058991f, 0.29107314f, -0.12439614f, -0.20073186f, 
    0.06805062f, 0.09724246f, -0.09142624f, 0.04559804f, 0.23612435f, -0.03154819f, 0.14684261f, -0.03059855f, 
    0.00096151f, -0.00278177f, -0.03950753f, 0.04302283f, -0.01278546f, -0.03028869f, 0.05943590f, -0.04343539f, 
    0.01870486f, 0.01748467f, 0.02967796f, -0.01299016f, -0.03262414f, 0.03742499f, 0.01335020f, -0.08094798f, 
    -0.07813403f, -0.06122297f, -0.04869913f, -0.06326368f, 0.04437338f, -0.04379683f, -0.07078450f, -0.05739286f, 
    -0.02999688f, -0.07842170f, -0.03966992f, 0.00360663f, -0.03214204f, 0.06132329f, 0.03742153f, 0.05961531f, 
    0.02566492f, -0.03850130f, 0.03288430f, 0.02364991f, -0.01533169f, -0.05760906f, 0.02107946f, 0.03874877f, 
    0.03712835f, 0.01625247f, 0.05049813f, 0.02056930f, -0.05698389f, -0.04973079f, 0.04266142f, -0.07682373f, 
    0.05488648f, 0.02672612f, -0.03992794f, 0.05598575f, -0.00512078f, 0.02015324f, 0.03078567f, 0.02108922f, 
    0.01319172f, -0.06651549f, 0.06599700f, -0.07649565f, 0.04353089f, 0.05700989f, 0.02502462f, -0.00904435f, 
    -0.02627310f, 0.06043802f, -0.01821443f, 0.05478108f, -0.03766701f, 0.00199685f, 0.00005149f, -0.07916515f, 
    -0.05664134f, 0.04091620f, -0.06695241f, -0.01256362f, 0.01161302f, 0.03793005f, -0.02964201f, 0.01051911f, 
    -0.01399543f, -0.07799096f, 0.05404499f, 0.04837841f, 0.01765588f, -0.01638483f, -0.07177224f, -0.04979507f, 
    -0.00138955f, -0.06872502f, -0.07593304f, -0.01620176f, 0.01261493f, 0.03604627f, -0.07158640f, 0.05458646f, 
    -0.00268975f, 0.03863004f, 0.03429630f, -0.04896264f, -0.05889682f, 0.04503680f, 0.04303833f, 0.02305533f, 
    -0.02060108f, -0.07938194f, 0.00252326f, 0.02374456f, 0.03000792f, -0.07646666f, -0.07657252f, -0.02704451f, 
    -0.07125738f, -0.04713972f, -0.06129555f, -0.01446130f, -0.03567770f, 0.04489327f, -0.00198975f, -0.01029840f, 
    -0.04434040f, 0.01027796f, 0.04313739f, 0.03483722f, -0.03610780f, -0.03008031f, -0.07232130f, -0.04303713f, 
    0.01294433f, -0.04174578f, 0.03385794f, 0.02294651f, -0.06957623f, -0.05692618f, 0.00132695f, 0.06090215f, 
    0.01147591f, -0.00878294f, -0.06867906f, -0.01393542f, 0.04484689f, 0.04085018f, 0.01900061f, -0.03514712f, 
    0.02090108f, 0.04118086f, -0.01978733f, 0.03876261f, 0.01912911f, 0.01324698f, 0.00074727f, -0.06537604f, 
    0.02458769f, -0.00853738f, -0.06323042f, -0.04680593f, -0.05649900f, -0.05955085f, -0.02072665f, 0.02011891f, 
    0.06397698f, 0.00832175f, -0.05068059f, -0.07753733f, 0.02664051f, -0.05320913f, -0.04454844f, -0.04619985f, 
    -0.04226480f, 0.04787047f, 0.00234352f, -0.06789640f, -0.04770836f, -0.07652367f, 0.04941218f, 0.06349195f, 
    0.05108529f, -0.08010548f, -0.07685687f, -0.02394795f, 0.03345218f, -0.07776555f, -0.03683602f, 0.04227665f, 
    0.03251296f, 0.02832652f, -0.06967781f, 0.02565423f, 0.00317312f, 0.04747302f, -0.01115093f, -0.02772326f, 
    0.02028211f, -0.11424125f, -0.01846519f, -0.09642605f, -0.12596478f, -0.11489571f, -0.11565039f, -0.07512187f, 
    0.14680408f, -0.01839371f, 0.01254433f, -0.05930033f, 0.39207438f, 0.20690756f, 0.12087856f, 0.02572713f, 
    -0.17049593f, -0.06655029f, -0.11581728f, 0.02443378f, 0.00782671f, -0.05530829f, 0.10903092f, 0.11154887f, 
    -0.14962289f, -0.32869613f, -0.04002876f, -0.20871983f, -0.06316632f, 0.15177929f, -0.09723139f, 0.03485315f, 
    -0.07751250f, 0.04311621f, -0.15221892f, -0.19006406f, 0.16263713f, 0.19153063f, 0.16032767f, -0.23109113f, 
    0.02596179f, -0.11549925f, -0.05532216f, -0.12253381f, 0.06105651f, 0.06431714f, -0.17153619f, -0.16885045f, 
    -0.18816584f, 0.24353948f, -0.09983991f, 0.52602321f, 0.00255258f, -0.05339221f, 0.04159973f, -0.21417750f, 
    -0.07039168f, 0.01605509f, 0.01512961f, 0.01273853f, -0.24890357f, 0.11092575f, -0.05674283f, -0.04014803f, 
    -0.11646739f, 0.13863517f, 0.01396907f, -0.05295779f, 0.07446987f, -0.10770018f, 0.01599078f, -0.08830406f, 
    0.23715450f, 0.16979040f, 0.05190274f, -0.07956631f, -0.10692286f, -0.08000997f, -0.10422391f, 0.01443301f, 
    -0.11527353f, -0.15039891f, 0.09127835f, -0.06767799f, -0.04533787f, -0.00382968f, 0.02134433f, -0.07853834f, 
    -0.15170377f, -0.12049816f, 0.01096115f, -0.01767194f, 0.02507042f, -0.03025969f, 0.02637534f, -0.08039092f, 
    -0.13968761f, 0.11624085f, 0.01350462f, 0.15167275f, 0.14220378f, -0.09750806f, -0.02882515f, -0.05863752f, 
    -0.11378898f, 0.04831393f, 0.11640941f, 0.06426871f, -0.17915207f, 0.13917132f, -0.06875416f, -0.05596364f, 
    -0.06737147f, -0.17757143f, 0.12591349f, 0.11177004f, 0.00232281f, -0.01870033f, 0.02920927f, 0.09464843f, 
    -0.09929671f, 0.12807752f, 0.13506813f, -0.14979817f, 0.07098103f, -0.03477922f, -0.06325427f, 0.13945422f, 
    0.04895272f, 0.10241124f, -0.18875030f, 0.01908398f, -0.09025225f, 0.19034684f, 0.16399506f, 0.33161101f, 
    0.16026138f, 0.17210841f, 0.16224928f, 0.17288989f, 0.07985969f, -0.15306172f, 0.07535587f, -0.01798576f, 
    0.03408522f, -0.13673371f, 0.11465237f, -0.13499671f, 0.10173683f, -0.05731740f, -0.00275096f, 0.01219308f, 
    0.11775820f, 0.25909793f, -0.12713513f, 0.02588404f, 0.08519357f, 0.31076145f, 0.08013112f, 0.23474444f, 
    0.07753430f, -0.04169154f, -0.07858881f, 0.12510136f, 0.06111309f, 0.02014275f, -0.12312759f, -0.06901987f, 
    -0.35481122f, 0.12493970f, -0.00018934f, 0.02974773f, 0.02466042f, 0.05290315f, 0.06245878f, 0.03060958f, 
    0.05306916f, -0.02568275f, -0.10184625f, 0.16237602f, 0.07825330f, 0.32618091f, 0.28569341f, -0.03305976f, 
    0.02967623f, -0.08386225f, 0.12375368f, -0.02264513f, -0.18856250f, -0.08681066f, -0.13978773f, -0.07025480f, 
    -0.15606007f, -0.08658475f, -0.16905618f, -0.20863281f, -0.04472899f, -0.03090307f, 0.03450882f, 0.02462354f, 
    -0.13659698f, 0.00240687f, 0.00502635f, -0.06959853f, 0.05449024f, -0.59376705f, -0.44255757f, -0.13683441f, 
    -0.12164146f, -0.03818455f, 0.00580068f, -0.09837800f, -0.12734433f, -0.03289468f, -0.02684320f, 0.07732739f, 
    0.22099569f, 0.24872196f, -0.09026191f, 0.17214136f, 0.04356489f, 0.02265475f, 0.06399889f, 0.08153827f, 
    0.04305933f, -0.00517697f, 0.05281974f, 0.01440342f, -0.00898908f, 0.03003072f, 0.03028676f, -0.06381717f, 
    0.09439535f, 0.09852487f, -0.05890051f, 0.16390251f, 0.04222580f, 0.04573141f, -0.05874600f, -0.04899181f, 
    0.01183254f, -0.10305528f, 0.29801401f, -0.00418026f, 0.04298101f, -0.03242680f, 0.04236155f, -0.02622822f, 
    0.10552211f, 0.00234443f, -0.07528977f, 0.05309409f, 0.41604984f, 0.32119456f, 0.29442659f, 0.11896556f, 
    -0.03333431f, 0.01807518f, 0.14719470f, 0.18324916f, -0.02340484f, 0.01010160f, -0.01124216f, -0.04958064f, 
    0.17873767f, -0.10995147f, -0.43923524f, -0.25790739f, -0.03905824f, -0.04139557f, -0.06971721f, 0.03038112f, 
    0.04751370f, -0.02236529f, -0.02483839f, -0.01615483f, -0.01348790f, -0.06500464f, -0.07301545f, -0.01811651f, 
    -0.09231158f, -0.05346442f, -0.02752021f, -0.08584009f, -0.24420285f, -0.09986085f, -0.17184725f, 0.08880199f, 
    0.05514144f, 0.15743695f, -0.03110619f, -0.13281064f, -0.04929951f, 0.09877504f, -0.05157969f, -0.09085178f, 
    0.12805216f, 0.00776618f, 0.02340142f, -0.03412643f, 0.16893439f, 0.33079863f, 0.26773158f, 0.14119333f, 
    -0.06853554f, -0.17277844f, 0.01017749f, 0.13742882f, -0.06328893f, -0.06168468f, 0.07264709f, -0.04064614f, 
    0.20084375f, 0.26864463f, 0.01923200f, -0.09603504f, 0.03645852f, 0.02425775f, 0.24053538f, 0.14978682f, 
    -0.04680276f, 0.03908983f, 0.21652357f, -0.12996668f, 0.16390620f, 0.06884318f, 0.09792133f, -0.07477325f, 
    -0.08475722f, 0.01847692f, 0.14441992f, 0.07014032f, 0.07167118f, 0.03445450f, 0.02656055f, -0.13852322f, 
    -0.11390992f, -0.20122930f, -0.05879680f, -0.14167818f, -0.06958584f, 0.08950966f, 0.01353094f, -0.02732552f, 
    0.02364172f, -0.04618039f, -0.01427948f, -0.06174494f, 0.50154823f, 0.05525741f, -0.06068062f, 0.02752744f, 
    0.03818378f, -0.02376557f, -0.12421437f, 0.10964596f, 0.01673634f, -0.11412923f, -0.04973598f, -0.00070285f, 
    -0.38020894f, 0.28181061f, 0.32728419f, 0.10560425f, 0.04794109f, 0.11445910f, 0.00777345f, -0.01000418f, 
    -0.06716456f, 0.05703426f, -0.07182427f, -0.10741832f, 0.13143097f, 0.07384234f, 0.02551132f, 0.03979943f, 
    0.06522521f, 0.07310054f, -0.01596140f, 0.04632664f, -0.10823629f, 0.02305248f, 0.09739178f, 0.05597913f, 
    0.20236018f, -0.14400451f, -0.14925922f, -0.10072393f, 0.06844120f, 0.03323563f, -0.07195713f, -0.06072452f, 
    0.01538790f, 0.01551198f, -0.09584903f, -0.00815516f, 0.07319569f, 0.00970447f, 0.11892334f, -0.11397475f, 
    0.11429095f, -0.01864626f, 0.15968221f, -0.09871045f, -0.19447181f, 0.02014456f, 0.01201501f, -0.07557514f, 
    0.15946342f, 0.23394853f, -0.04455224f, 0.29917127f, 0.05625999f, -0.09271807f, 0.10970937f, -0.17440709f, 
    0.02190686f, -0.04254435f, 0.21447752f, 0.29792333f, -0.08575243f, -0.04471903f, -0.14993568f, -0.05311213f, 
    -0.14416194f, 0.00151586f, 0.14083561f, 0.11937109f, 0.11944443f, 0.02577676f, 0.12884614f, 0.28888214f, 
    0.03974942f, -0.17287350f, 0.11394253f, 0.03025302f, -0.07156822f, -0.01817624f, 0.02096036f, -0.05666799f, 
    0.02356330f, 0.23502508f, 0.11617006f, 0.16947292f, 0.15339597f, 0.24194928f, 0.33018407f, 0.26218191f, 
    -0.03580292f, 0.09521072f, 0.15131474f, 0.18335903f, 0.01862729f, 0.10820609f, -0.05002860f, 0.05866775f, 
    0.61429006f, 0.11720181f, 0.10687031f, 0.04804165f, 0.18833344f, 0.23459284f, -0.01356110f, -0.15522505f, 
    -0.25777704f, 0.07281834f, -0.41902661f, -0.09222719f, 0.26837459f, 0.03553045f, -0.01417804f, 0.25961411f, 
    0.06722516f, -0.02277179f, -0.11921496f, -0.07716665f, 0.12336654f, 0.27797079f, 0.15265037f, 0.29879889f, 
    0.20752910f, -0.07285587f, 0.03131088f, -0.00039653f, -0.10680424f, -0.03406672f, -0.26545420f, -0.00243805f, 
    0.11592738f, -0.04205651f, 0.08794159f, -0.05652433f, -0.03788334f, 0.04064911f, 0.08381265f, 0.17237312f, 
    -0.12860572f, -0.00528274f, 0.08999977f, 0.08398374f, -0.23394509f, -0.08712593f, -0.00100011f, -0.29069781f, 
    0.15137011f, 0.30071092f, 0.02623489f, 0.05553567f, -0.01399556f, -0.03140424f, 0.00899459f, -0.07467511f, 
    -0.14241254f, -0.11692997f, -0.05555238f, -0.06423617f, -0.23319609f, -0.22395727f, -0.40992910f, -0.08842652f, 
    -0.13494711f, 0.08699547f, 0.00360748f, -0.11238108f, -0.01983460f, -0.15848559f, -0.05045803f, -0.09601347f, 
    -0.10668991f, -0.19015317f, -0.24558695f, -0.12947665f, -0.00827970f, -0.00602077f, -0.33903646f, -0.07617050f, 
    -0.35342437f, -0.25841618f, -0.14320303f, -0.31710178f, -0.11209203f, -0.20976762f, -0.06552321f, 0.02373814f, 
    -0.08667456f, 0.01360157f, 0.19160038f, 0.09633948f, 0.04350184f, 0.06070411f, 0.04361505f, 0.27108613f, 
    -0.00155996f, -0.07565542f, -0.14017947f, 0.26407138f, -0.05366750f, -0.01822373f, -0.06742740f, -0.18880543f, 
    -0.09889484f, 0.17875144f, 0.02345480f, 0.15007360f, 0.00687272f, -0.00208058f, 0.06124441f, 0.04672416f, 
    -0.04734080f, -0.02551630f, 0.12539829f, -0.00805317f, -0.10239219f, -0.01249751f, 0.16947955f, 0.05963973f, 
    -0.06011986f, 0.12047245f, -0.04410298f, -0.17570035f, 0.01218854f, -0.03618352f, -0.07822015f, -0.03514825f, 
    -0.00058294f, -0.04080052f, 0.00504715f, 0.01639006f, 0.05580575f, 0.26537243f, 0.11690174f, 0.03166068f, 
    -0.14174064f, -0.16920690f, -0.05069704f, -0.04576065f, -0.15505393f, -0.06739823f, 0.10445248f, 0.12627313f, 
    -0.02003974f, -0.02086298f, -0.04003070f, -0.08694273f, -0.00761992f, -0.03201130f, -0.11238478f, 0.21885385f, 
    -0.14745742f, -0.01510214f, 0.12405880f, -0.01235961f, 0.06911357f, -0.17966409f, -0.03460492f, -0.00869211f, 
    0.16783223f, 0.19389191f, -0.02768227f, 0.04299580f, -0.09564643f, 0.04018878f, -0.20577925f, -0.25665659f, 
    0.20376033f, 0.19491489f, -0.21098641f, -0.11718535f, -0.03923048f, -0.16673349f, -0.03396529f, -0.19850028f, 
    0.11655940f, -0.11703575f, -0.01096023f, -0.00099537f, 0.00228983f, -0.04426063f, -0.07729795f, -0.08179630f, 
    -0.09936927f, 0.15178755f, 0.09922030f, 0.08713631f, -0.02507261f, -0.00637284f, 0.07617393f, 0.00804729f, 
    0.28382647f, 0.32413584f, -0.04154544f, -0.03012465f, -0.12005606f, -0.12542926f, -0.13076106f, -0.01556632f, 
    -0.04357917f, 0.04127951f, -0.04792697f, 0.02762725f, -0.00474927f, 0.09498509f, 0.08774746f, -0.16473696f, 
    -0.00995401f, 0.01444990f, 0.05027524f, -0.10875940f, -0.12321236f, -0.13142863f, -0.12306403f, -0.14991108f, 
    0.00778588f, 0.10221134f, -0.19139466f, -0.32550579f, 0.05301834f, 0.06821228f, -0.02035647f, -0.19391321f, 
    0.06521707f, 0.09439621f, 0.03833896f, 0.08360339f, 0.07985597f, 0.00189576f, -0.02000019f, -0.04536179f, 
    -0.04158852f, -0.13503160f, 0.06668215f, -0.00561980f, -0.00061268f, 0.02138963f, 0.01892936f, 0.00342593f, 
    -0.26526034f, -0.03643411f, -0.10787920f, -0.10772610f, 0.07298464f, 0.13161314f, 0.09342399f, 0.19693670f, 
    0.03423568f, 0.16014639f, 0.07421722f, -0.07167778f, 0.13889386f, 0.19242683f, 0.00634390f, -0.24926543f, 
    0.27517641f, 0.01454102f, 0.15699390f, 0.30697572f, 0.06104621f, -0.11143611f, -0.04666791f, -0.11959837f, 
    0.10276872f, -0.06079823f, 0.16437672f, -0.05618124f, -0.13422623f, -0.01558567f, 0.08819392f, -0.02401739f, 
    0.11487959f, -0.08594086f, 0.15513365f, -0.01071384f, 0.31427777f, 0.07507178f, -0.07372416f, 0.11754541f, 
    0.07126775f, -0.00077307f, 0.11554344f, -0.01327763f, 0.00223838f, -0.04051279f, 0.00088126f, 0.04592730f, 
    0.09714346f, 0.17889839f, 0.14023848f, -0.15748167f, -0.03444230f, 0.10923552f, -0.06072775f, -0.02180376f, 
    0.01916079f, 0.11877926f, 0.19213922f, -0.07244089f, -0.04172771f, -0.08364244f, -0.00790457f, 0.04920283f, 
    0.06667281f, 0.23754373f, 0.07300551f, 0.22354953f, -0.01927965f, 0.13665858f, 0.15365992f, 0.09179483f, 
    0.01880710f, 0.10965243f, 0.17631020f, 0.10204503f, -0.00220285f, 0.00132585f, 0.04037404f, -0.00219412f, 
    0.03237838f, -0.02796740f, 0.11044706f, 0.03584482f, 0.17967169f, 0.19288437f, -0.00061970f, 0.23614104f, 
    0.01822848f, 0.00127400f, 0.03382865f, 0.12603733f, 0.14042631f, 0.07802062f, 0.04340705f, 0.09319872f, 
    0.32887083f, 0.01318595f, 0.26978445f, 0.14971744f, 0.09441140f, 0.11374972f, 0.05528244f, 0.16272050f, 
    -0.14648214f, -0.05615825f, -0.12008113f, -0.11329976f, -0.56724054f, -0.17554229f, -0.11910205f, -0.22818926f, 
    0.00217711f, -0.14477126f, -0.29352802f, -0.12207418f, 0.17787842f, -0.07109729f, -0.03961835f, 0.07535988f, 
    0.36313042f, 0.10396855f, -0.06106389f, 0.02645653f, -0.10198710f, 0.14220023f, 0.05662945f, 0.06091022f, 
    -0.12876700f, 0.07950681f, -0.13443662f, 0.24749561f, -0.36164132f, -0.30128923f, -0.41717228f, -0.25176910f, 
    0.16799723f, -0.05025101f, 0.03208727f, 0.50902981f, 0.00268085f, 0.15306430f, -0.09247876f, -0.12434183f, 
    0.05832453f, 0.22398323f, 0.14564161f, 0.04799244f, 0.03036690f, -0.01788433f, 0.07554508f, 0.09397552f, 
    -0.05550439f, -0.00935157f, -0.03235720f, 0.08705930f, 0.01952312f, -0.07493300f, 0.08060625f, 0.08767800f, 
    0.01567871f, 0.11221432f, -0.05341014f, -0.03952466f, 0.22510207f, 0.26677719f, -0.04562950f, -0.02002997f, 
    0.04075672f, 0.12060671f, 0.01001171f, -0.06786568f, -0.06754325f, 0.04431368f, -0.05185727f, 0.08082416f, 
    -0.12349689f, -0.26170895f, 0.06367725f, 0.01006974f, -0.38521555f, -0.37519866f, -0.73325396f, 0.01196696f, 
    0.30583495f, 0.18374446f, 0.09380072f, 0.21494313f, -0.05000475f, 0.01542547f, 0.00798352f, -0.01146134f, 
    -0.27212638f, 0.15846111f, -0.41628093f, -0.50535387f, 0.02823679f, -0.15532137f, -0.01007666f, -0.09088617f, 
    -0.15816388f, -0.10747563f, -0.15494132f, 0.06614276f, -0.01921145f, -0.08852357f, -0.20647433f, -0.02254307f, 
    0.03101488f, 0.04387176f, -0.21009931f, 0.08727524f, -0.01571344f, -0.07273097f, -0.08025049f, 0.05462584f, 
    0.05262856f, 0.14316519f, 0.11225701f, -0.00452886f, -0.02842741f, -0.08758494f, 0.02059351f, 0.05499310f, 
    0.01521739f, 0.09938526f, 0.08591315f, 0.01598759f, 0.01314473f, -0.31142884f, -0.20533526f, -0.04877999f, 
    0.09213531f, 0.03833262f, -0.03313316f, 0.09645751f, 0.05341633f, 0.00314511f, -0.01358610f, 0.14778279f, 
    -0.19208825f, 0.29654261f, -0.16752125f, -0.40309846f, -0.01143166f, 0.07053151f, -0.04448048f, 0.13434394f, 
    -0.05617862f, -0.13851084f, 0.35333470f, 0.08677845f, -0.12931034f, -0.35908976f, -0.08064254f, -0.14283033f, 
    -0.22961360f, -0.21820354f, 0.07338452f, -0.02173083f, 0.17985934f, -0.06733961f, -0.36938620f, -0.05446570f, 
    -0.08111352f, 0.04461129f, 0.18872534f, 0.03310567f, -0.08795816f, -0.07025010f, -0.16169782f, -0.10853008f, 
    -0.07170373f, 0.12411477f, 0.05620478f, 0.07674508f, 0.31766787f, 0.34212527f, -0.09141609f, 0.06883243f, 
    -0.00600732f, -0.06982451f, -0.15126172f, -0.11105122f, -0.00398652f, -0.00258217f, 0.00799130f, 0.03288843f, 
    0.04419293f, 0.13712698f, 0.02293113f, 0.04795721f, 0.16039219f, -0.03391499f, -0.11259972f, 0.16597894f, 
    0.06156729f, 0.15706757f, -0.03311405f, -0.05770391f, -0.25098121f, -0.13827966f, -0.19506353f, -0.14941381f, 
    0.14405029f, -0.03082612f, -0.05389950f, -0.06948050f, 0.07921536f, -0.17466584f, -0.08413409f, -0.25196281f, 
    0.24953598f, -0.08240550f, 0.02777628f, -0.05503894f, -0.02393813f, -0.03920358f, 0.04313063f, -0.03534791f, 
    0.12846071f, -0.01271456f, -0.06758735f, -0.02605133f, -0.02600257f, 0.04177168f, 0.17762333f, 0.00089743f, 
    -0.02895502f, 0.03629581f, 0.03082270f, 0.17529805f, -0.05491959f, 0.08962600f, 0.07211097f, -0.05308086f, 
    0.04460364f, 0.33538708f, 0.10769245f, 0.06281118f, 0.03191609f, -0.14119624f, -0.06735897f, -0.03333243f, 
    -0.05455539f, -0.00877022f, 0.08320583f, -0.01513972f, 0.03562922f, 0.12542126f, -0.01213251f, 0.01660752f, 
    0.00497801f, -0.00178673f, 0.00937141f, -0.05083587f, -0.14377053f, -0.19459806f, -0.05803001f, -0.09430245f, 
    0.03581135f, -0.20903224f, -0.36375389f, -0.26746169f, -0.06971173f, -0.01463901f, 0.02762707f, 0.04409010f, 
    -0.00046268f, 0.02143926f, -0.09223130f, -0.11360843f, 0.06065707f, 0.07230330f, 0.21674301f, 0.34551981f, 
    0.18425156f, 0.10806180f, -0.12949812f, 0.16744277f, 0.06028211f, 0.00059155f, 0.07864722f, 0.10303573f, 
    -0.12301172f, -0.20878907f, -0.22323400f, -0.01334696f, -0.05325005f, 0.01036647f, -0.06975337f, 0.20608278f, 
    -0.00002027f, 0.07490043f, 0.01874113f, 0.01470289f, -0.08474924f, -0.07995086f, 0.07695818f, -0.10402270f, 
    0.09191621f, -0.02827505f, 0.03950435f, 0.02539571f, 0.08563387f, 0.06329449f, -0.08225016f, -0.00904872f, 
    0.01960815f, 0.08257987f, 0.04741423f, -0.06694944f, 0.04440721f, -0.00609795f, 0.01169453f, -0.05022656f, 
    0.15382463f, 0.03217241f, -0.01793627f, 0.07133993f, 0.26909125f, 0.23059058f, 0.26168993f, -0.16468431f, 
    0.03824321f, -0.11145356f, -0.00583350f, 0.05951610f, -0.00051511f, -0.10499860f, -0.01168471f, 0.04271820f, 
    0.07884638f, 0.04965780f, 0.21439746f, -0.12018242f, -0.00460559f, -0.19346404f, 0.02614783f, 0.08386637f, 
    0.07850944f, 0.11176240f, 0.18616179f, -0.02111558f, -0.04753269f, 0.16017877f, -0.07802998f, 0.03108500f, 
    0.04783292f, 0.06702954f, 0.25313985f, 0.00274767f, 0.09706129f, 0.15063450f, -0.06693588f, 0.15630811f, 
    -0.01716223f, -0.03153270f, -0.02653723f, -0.07550636f, -0.02519076f, -0.04882950f, 0.03775181f, 0.01425295f, 
    -0.07452977f, 0.01120022f, 0.03156197f, 0.01705975f, -0.03007124f, -0.02225907f, 0.04032352f, 0.00936194f, 
    -0.01498526f, -0.01332373f, -0.05953617f, -0.00646746f, -0.03686607f, -0.06323662f, -0.04058766f, 0.01712731f, 
    -0.04591832f, -0.03470170f, -0.05837223f, 0.03826580f, 0.01823271f, -0.00771049f, 0.05391718f, 0.05684330f, 
    -0.04886797f, -0.01727211f, -0.06339254f, 0.06381895f, 0.03783206f, -0.00172030f, -0.01423040f, 0.03183169f, 
    0.06173373f, 0.01836713f, 0.06254125f, -0.07044502f, 0.02814093f, 0.05984883f, -0.03764044f, -0.01979693f, 
    -0.02272107f, -0.01741279f, -0.05454465f, -0.03046548f, -0.00223677f, -0.03768794f, -0.06785861f, -0.03348040f, 
    0.03268540f, -0.04692281f, -0.01882619f, -0.00721425f, -0.05989856f, 0.02980963f, 0.06247218f, 0.00110000f, 
    0.00733096f, 0.04029129f, -0.03902377f, -0.02955542f, 0.01838033f, 0.00373635f, -0.05424275f, 0.04652125f, 
    0.02136805f, -0.06018943f, 0.02526683f, -0.01455337f, 0.00807409f, -0.07462484f, 0.03332734f, -0.07479272f, 
    -0.03353573f, -0.01242307f, -0.01172673f, -0.06672896f, 0.01394384f, -0.02509876f, -0.01815120f, 0.06467652f, 
    -0.01980452f, 0.02036922f, -0.00377832f, 0.02630801f, -0.06452496f, 0.03334959f, 0.04630962f, -0.00613414f, 
    -0.07258417f, -0.02058940f, 0.05639401f, 0.00225891f, 0.03567691f, -0.03307299f, -0.07161661f, 0.05223273f, 
    0.05374368f, 0.05638900f, -0.06368605f, -0.01092313f, -0.07258841f, -0.03902670f, -0.03151349f, -0.02624470f, 
    0.05819613f, -0.05350165f, 0.03289811f, -0.02294171f, -0.00928778f, -0.00473494f, 0.03192843f, 0.01384719f, 
    -0.06716646f, 0.06479293f, 0.06798459f, -0.06989926f, 0.05860938f, 0.06406371f, -0.05016480f, 0.02919716f, 
    0.03309933f, 0.02904772f, 0.04940364f, 0.06202200f, 0.01756775f, -0.01451847f, 0.03679666f, -0.03660156f, 
    -0.07326566f, 0.03164715f, -0.01929591f, -0.07242142f, -0.03376996f, -0.07492310f, -0.02172930f, 0.00669797f, 
    0.03711727f, -0.03907186f, 0.00247331f, -0.00953386f, -0.07204458f, -0.07351520f, 0.04418043f, 0.00333137f, 
    0.00502106f, 0.05531382f, -0.02751266f, 0.06275028f, 0.01400798f, 0.02222747f, -0.02054405f, 0.00584180f, 
    0.02111864f, -0.06922246f, -0.00807235f, 0.02339014f, -0.02312496f, -0.01105399f, -0.00723556f, 0.01211708f, 
    0.01804443f, -0.06593519f, -0.06054875f, -0.01710119f, -0.01620813f, 0.00834728f, -0.03028752f, 0.03760572f, 
    -0.05222212f, -0.07577001f, -0.02690338f, 0.01907621f, -0.02009603f, -0.03970520f, -0.02391615f, 0.05735207f, 
    -0.03636219f, 0.01701056f, -0.06312389f, 0.05357577f, -0.04986221f, 0.02114057f, -0.00483535f, -0.01117121f, 
    -0.20719722f, 0.16816834f, -0.09208037f, -0.10281447f, -0.14668620f, -0.11146521f, -0.13411599f, -0.05374537f, 
    0.15506227f, 0.05996882f, 0.08315450f, 0.05721591f, 0.19524324f, 0.26715788f, 0.10183869f, 0.23023297f, 
    -0.21485819f, -0.01325637f, -0.04959682f, -0.14450614f, 0.12812515f, 0.02183456f, 0.04064030f, 0.11796217f, 
    -0.06676901f, -0.29609647f, 0.01048853f, -0.28058791f, -0.00387383f, 0.15523812f, 0.05540113f, 0.28230134f, 
    -0.03543281f, 0.10377212f, -0.01682162f, -0.02351445f, 0.22802603f, -0.04426505f, 0.08462086f, -0.04409282f, 
    0.10724480f, 0.02659679f, -0.16101484f, -0.01792017f, -0.08300281f, 0.01900502f, -0.08703808f, -0.24730672f, 
    -0.07563207f, 0.36603037f, -0.06464260f, 0.12329407f, -0.07715439f, 0.00193397f, 0.02353497f, -0.09202338f, 
    0.03574010f, -0.10306131f, -0.05741614f, -0.08709747f, -0.12402935f, -0.21115652f, -0.01108909f, -0.02891919f, 
    -0.00085161f, 0.12405577f, -0.05642941f, 0.08661936f, -0.17096366f, -0.12410098f, 0.06916887f, -0.01578034f, 
    -0.02028504f, 0.09547915f, -0.00751094f, 0.02528616f, -0.13709253f, -0.13367385f, 0.02813830f, 0.03541730f, 
    -0.04030128f, -0.09816828f, 0.12028529f, 0.05254943f, -0.06945779f, 0.04201687f, -0.06935233f, -0.10800099f, 
    -0.01823570f, -0.08693834f, 0.05204928f, -0.05408844f, -0.02442689f, -0.13115239f, 0.01915917f, -0.27689111f, 
    -0.40701440f, 0.23542947f, -0.16516976f, -0.12417226f, 0.10340146f, -0.09629391f, 0.05554132f, -0.02464963f, 
    -0.19367537f, 0.14177367f, -0.01083701f, 0.08562927f, -0.12842424f, -0.02466038f, -0.07434834f, 0.00762167f, 
    0.15198222f, -0.03938649f, 0.11598141f, 0.05491672f, -0.04584529f, 0.00205454f, -0.05290994f, 0.14093392f, 
    -0.39620331f, 0.07552935f, 0.07945997f, 0.03683285f, 0.02109414f, 0.03303107f, 0.05965908f, 0.19048108f, 
    -0.00462552f, 0.05272518f, 0.04838871f, -0.02348530f, -0.14431278f, 0.25654671f, 0.10938949f, 0.09076650f, 
    0.28524110f, 0.08574911f, 0.16594742f, 0.14069453f, 0.02538797f, -0.07817521f, 0.03769062f, -0.07571330f, 
    0.05168135f, 0.02881187f, 0.06360794f, 0.07192574f, -0.04668044f, -0.05876306f, -0.03519846f, 0.04834165f, 
    0.31700760f, 0.13886490f, 0.01574054f, 0.10243066f, 0.05529997f, 0.16478227f, -0.06654676f, 0.18824537f, 
    0.08879147f, -0.02564216f, -0.05461176f, 0.13778612f, -0.02823485f, 0.01882028f, -0.01419822f, 0.01383543f, 
    -0.16745046f, -0.00572598f, -0.15492414f, -0.13670711f, -0.00991340f, -0.06237331f, 0.03025679f, 0.13885020f, 
    0.14448774f, 0.07053746f, 0.09834290f, 0.14770585f, 0.10322118f, 0.20302562f, 0.26009032f, 0.02157146f, 
    -0.02420626f, 0.01279386f, -0.02444255f, 0.24879093f, -0.01368747f, 0.13352783f, -0.04648015f, 0.05173771f, 
    0.01973314f, 0.01868619f, 0.00121894f, -0.00065425f, -0.05306262f, -0.05827203f, 0.00096982f, -0.05057899f, 
    0.02981266f, -0.03954602f, -0.04015500f, 0.03434949f, -0.06541715f, -0.03508588f, -0.03230962f, -0.06562617f, 
    0.00322393f, -0.02543516f, -0.05337972f, -0.06708159f, 0.01536681f, -0.00232522f, 0.01506679f, -0.02322447f, 
    -0.02710348f, -0.00438813f, -0.02174072f, -0.06089910f, 0.01838341f, 0.04892376f, 0.01472918f, -0.04019000f, 
    0.06093848f, -0.02434478f, 0.00812214f, 0.00346814f, -0.01248566f, -0.03927694f, -0.06482382f, -0.07022770f, 
    -0.04212300f, -0.04343658f, 0.04545980f, -0.06537616f, 0.04784131f, 0.00680854f, 0.04834485f, 0.07167379f, 
    -0.02637212f, 0.00296672f, 0.02511960f, -0.04059437f, -0.00859324f, -0.02721473f, -0.06474081f, -0.02238509f, 
    -0.05198702f, -0.02675600f, -0.05687847f, -0.07136017f, 0.00557217f, -0.03836150f, -0.03109224f, -0.03951962f, 
    -0.01491788f, 0.04319554f, -0.03612320f, -0.05414649f, -0.00817632f, -0.00217361f, 0.03860630f, -0.01234920f, 
    -0.05203471f, -0.06488820f, -0.00897294f, 0.03865880f, -0.01763591f, -0.06546321f, -0.06671725f, -0.06279432f, 
    -0.04859998f, 0.04564766f, 0.05895542f, -0.05370963f, 0.06125857f, 0.03936207f, 0.02059880f, -0.00599882f, 
    -0.06055425f, -0.04765030f, 0.03955119f, 0.03880400f, -0.04898126f, 0.00081706f, -0.07141579f, 0.06737234f, 
    -0.03346701f, 0.01620376f, -0.06964634f, 0.01330996f, -0.00364594f, -0.02428326f, -0.07174157f, -0.00602259f, 
    -0.04740204f, -0.00054820f, -0.02454345f, -0.05608622f, 0.03045532f, 0.03431087f, 0.06852485f, 0.06087208f, 
    -0.02432927f, -0.00788496f, 0.05051674f, 0.01709319f, 0.05157208f, 0.00930029f, -0.01468212f, 0.01474795f, 
    -0.03561475f, 0.01459966f, -0.02338835f, -0.05911412f, -0.01653981f, 0.03484442f, -0.01741855f, 0.04684253f, 
    0.03058604f, -0.05781735f, 0.03140365f, -0.05986750f, 0.01367238f, 0.01809678f, -0.02344806f, -0.06046686f, 
    -0.01827165f, 0.04353307f, -0.03879292f, -0.02424420f, -0.05348650f, 0.01454668f, -0.04908758f, 0.06653876f, 
    -0.06111248f, -0.00755434f, -0.04417095f, 0.00905324f, 0.06268594f, -0.01747525f, -0.03450048f, 0.04893992f, 
    0.06704247f, -0.01397031f, 0.02978258f, -0.04897581f, -0.03380819f, -0.06923005f, 0.04253751f, 0.01358288f, 
    -0.00853949f, 0.00209013f, -0.00797662f, -0.03832375f, -0.05799454f, 0.04844772f, -0.03778619f, -0.06444513f, 
    -0.03171191f, -0.03329802f, 0.04682578f, -0.04768775f, 0.05329375f, 0.05651617f, 0.02304552f, 0.06410997f, 
    -0.05568420f, 0.01582830f, -0.05932290f, -0.04273303f, 0.01732331f, 0.01074598f, -0.01468992f, 0.04785956f, 
    -0.06453028f, -0.04104141f, 0.07160498f, 0.06460480f, 0.05643172f, -0.04291723f, 0.05687140f, -0.05313594f, 
    -0.08265454f, 0.07262796f, 0.00587490f, -0.02022351f, -0.13319160f, -0.27417949f, 0.15253890f, -0.29721731f, 
    0.13454387f, -0.10221756f, 0.07892501f, 0.00409319f, 0.36465859f, -0.01129819f, -0.06074609f, 0.08227684f, 
    0.00495326f, 0.07183033f, 0.02091924f, 0.06370117f, -0.04404563f, 0.03003615f, -0.01579908f, 0.01474478f, 
    -0.21553451f, 0.03129425f, -0.01094239f, -0.07601739f, -0.06174114f, 0.09399496f, 0.19110753f, 0.09683000f, 
    0.03234384f, 0.01804434f, 0.01231529f, 0.16913666f, -0.16755843f, 0.06974263f, -0.16462263f, -0.21004736f, 
    -0.15315145f, -0.01960851f, 0.17522870f, 0.23788041f, 0.13363348f, -0.12087402f, 0.08543144f, 0.02551498f, 
    -0.06611809f, 0.26184663f, -0.02893612f, 0.28840086f, 0.04767410f, 0.03690691f, -0.26196149f, 0.00477084f, 
    0.23628081f, 0.00320195f, 0.04208808f, 0.00052087f, 0.35818222f, -0.25823838f, 0.01254700f, 0.09691031f, 
    0.12874576f, 0.11997387f, 0.03693192f, -0.10252599f, 0.05763286f, -0.03784287f, -0.22399645f, -0.00326581f, 
    -0.12690760f, -0.61924970f, -0.11296643f, -0.32567406f, 0.19218509f, 0.19460158f, 0.12713645f, 0.11084143f, 
    0.03357657f, 0.02735718f, 0.01515390f, 0.02791479f, 0.08308111f, -0.27723333f, 0.00540275f, -0.12747446f, 
    -0.02690650f, 0.11426317f, 0.27033690f, 0.13959388f, 0.08497812f, 0.05920417f, 0.07677343f, -0.03128603f, 
    0.04425014f, 0.02667287f, 0.23839062f, 0.16021271f, 0.03102540f, -0.20356447f, -0.00555476f, -0.05702278f, 
    0.06076911f, 0.01791112f, -0.04411894f, 0.02835204f, 0.06274934f, 0.05943956f, -0.10553476f, -0.06252180f, 
    0.06808390f, 0.11740025f, 0.12568969f, -0.03285769f, -0.00239606f, 0.09365185f, -0.04486889f, 0.00282316f, 
    -0.31991515f, -0.23950413f, 0.15810043f, -0.10295697f, -0.05010195f, -0.13923778f, -0.13773425f, -0.01442903f, 
    0.03036890f, -0.01124723f, 0.18819527f, 0.14765471f, -0.06921153f, -0.00735828f, -0.08744017f, 0.08634827f, 
    -0.05442633f, 0.11341380f, -0.19630317f, 0.06804153f, -0.02205446f, -0.07114325f, 0.00383600f, 0.10405058f, 
    -0.23128095f, 0.14999507f, -0.11544684f, -0.04715414f, 0.09047727f, -0.11716609f, -0.11698293f, -0.19524993f, 
    0.16879277f, 0.00884447f, 0.17508161f, 0.18284412f, -0.03795772f, -0.01884442f, 0.13495465f, -0.18027323f, 
    -0.07334387f, -0.02890507f, 0.09542805f, 0.32306573f, -0.04273680f, 0.01721497f, 0.04697414f, 0.05522006f, 
    -0.03283092f, -0.51970685f, 0.42775032f, 0.16803992f, 0.09495739f, 0.24021831f, 0.08397669f, 0.18228132f, 
    0.13806958f, 0.05821704f, -0.11081041f, -0.01280858f, -0.25291064f, 0.25482303f, -0.24191533f, -0.14561436f, 
    0.02373064f, -0.16733596f, 0.00684650f, -0.01828459f, 0.11962545f, 0.05829350f, 0.07923380f, -0.08060523f, 
    -0.02786152f, 0.01307253f, -0.04852965f, -0.01215097f, -0.04623681f, 0.05836790f, -0.07052507f, 0.00944110f, 
    -0.00502511f, -0.02814982f, 0.05259800f, -0.03193835f, -0.01035817f, -0.00308021f, -0.01313374f, -0.01533784f, 
    0.05969677f, -0.05829818f, -0.05889517f, 0.03075183f, 0.02940963f, 0.00856432f, 0.05007672f, -0.04604116f, 
    0.01068797f, -0.00885505f, -0.04093533f, 0.03472406f, -0.06704805f, -0.04970340f, -0.05197448f, 0.03017162f, 
    0.05850539f, 0.01826313f, -0.03338466f, -0.01522066f, -0.00619917f, -0.05513158f, -0.04584504f, -0.04522425f, 
    -0.05583675f, 0.01837438f, 0.03081895f, -0.00968784f, -0.02882913f, 0.04095549f, 0.02147414f, -0.06191453f, 
    -0.05992016f, -0.03039706f, -0.03199005f, -0.01448109f, -0.02784334f, 0.00008936f, 0.04266820f, 0.01264282f, 
    0.03294377f, -0.02686840f, 0.00089607f, 0.03357731f, 0.01137920f, -0.02036919f, 0.00087345f, -0.05507047f, 
    0.03259895f, -0.04122484f, -0.00503859f, 0.03323227f, -0.03299494f, -0.07864173f, -0.05544228f, -0.06216238f, 
    -0.06921899f, -0.06411938f, 0.04917273f, -0.06858066f, 0.04502456f, -0.08169489f, -0.05225401f, -0.02634709f, 
    -0.06916269f, 0.03220053f, -0.06947087f, 0.01343014f, -0.07609262f, -0.07121456f, 0.01198943f, -0.01714840f, 
    -0.01974120f, -0.06990632f, -0.07294045f, -0.01788924f, 0.04895045f, -0.02981973f, 0.04870740f, -0.04322027f, 
    0.05048810f, -0.00547363f, -0.06600820f, -0.02302742f, 0.01245378f, -0.06677164f, 0.00428705f, -0.02952738f, 
    -0.04875443f, 0.02841373f, -0.05048392f, -0.01156051f, 0.03051138f, -0.03833161f, -0.01199103f, -0.00129910f, 
    -0.07099351f, -0.04676036f, -0.03301536f, -0.07817698f, -0.02740275f, -0.01415379f, 0.04155570f, -0.07753206f, 
    0.06199279f, 0.05616068f, 0.00929144f, -0.03954871f, -0.06111576f, -0.04709625f, 0.01675704f, -0.05621153f, 
    -0.00586000f, 0.01719581f, -0.00929847f, 0.04530229f, 0.04469148f, -0.05625916f, 0.03321130f, 0.06161785f, 
    0.04075236f, -0.01464688f, 0.03467303f, -0.00209260f, -0.05527753f, -0.02490485f, 0.04986633f, -0.00086269f, 
    0.06229252f, 0.03949019f, -0.01741248f, -0.06346605f, 0.03413045f, -0.01170564f, -0.05939816f, 0.02464276f, 
    -0.06191229f, -0.02052226f, -0.07021229f, 0.05315492f, 0.02496560f, -0.00304336f, 0.05270199f, 0.03096374f, 
    -0.02741144f, -0.01322893f, -0.07577565f, -0.02390348f, -0.07195416f, 0.00515990f, -0.00342590f, 0.05232486f, 
    -0.05237533f, -0.03842865f, -0.06262673f, -0.04992194f, 0.01837102f, 0.00702650f, -0.03179501f, -0.05796213f, 
    0.00245540f, -0.02274247f, 0.03261195f, 0.00460692f, -0.01582368f, -0.03040700f, 0.04341440f, -0.04294085f, 
    0.05764322f, -0.01514358f, 0.02276279f, -0.02112596f, -0.03582426f, -0.02767296f, 0.01925686f, 0.00328351f, 
    0.09667084f, 0.05849377f, -0.07829904f, 0.05794278f, 0.04766200f, 0.00231078f, -0.07492267f, 0.02700537f, 
    0.06545810f, -0.07860564f, 0.01011364f, 0.03345842f, 0.13118941f, -0.05388435f, 0.18912959f, -0.27444106f, 
    0.03140211f, -0.01508925f, 0.08507525f, 0.05510874f, 0.00392564f, 0.03103012f, 0.00515152f, 0.05588664f, 
    -0.09188116f, -0.23987983f, -0.13018423f, -0.15071809f, 0.04367314f, 0.16580376f, -0.13805154f, -0.08576223f, 
    -0.04673630f, -0.02552084f, -0.00457234f, 0.03028530f, 0.15013362f, 0.24370568f, 0.13930885f, -0.09514214f, 
    0.01508343f, -0.02302011f, -0.12033366f, -0.12235980f, 0.13553430f, 0.21243472f, 0.07655409f, 0.10824811f, 
    -0.03787051f, -0.05978201f, 0.05149319f, 0.50425005f, 0.03308438f, -0.00990513f, -0.11521664f, -0.05120633f, 
    -0.08709820f, -0.05358867f, 0.18932413f, -0.06124572f, -0.02331192f, -0.14354558f, -0.19013609f, -0.47147271f, 
    -0.13651119f, -0.02105224f, -0.08805438f, -0.03767212f, 0.01211558f, -0.07473449f, 0.06508219f, 0.04606836f, 
    0.27745846f, 0.06233120f, -0.23461947f, -0.05420627f, 0.11025427f, -0.05462531f, 0.24204315f, -0.10905222f, 
    -0.02045559f, -0.19054586f, -0.12663770f, 0.05177068f, -0.00003528f, -0.02739877f, -0.03940495f, -0.02069534f, 
    0.02811009f, 0.06935255f, -0.02945641f, 0.06484485f, 0.09550758f, 0.32705605f, 0.01067374f, 0.22247176f, 
    -0.23874153f, 0.23896974f, 0.30054659f, 0.35592592f, 0.04484945f, 0.03202889f, -0.13415450f, 0.03597083f, 
    -0.00145754f, -0.04047764f, 0.23894557f, 0.21043333f, -0.29693514f, -0.04477446f, -0.16209090f, -0.33065444f, 
    -0.00929697f, -0.20530295f, 0.11813649f, -0.11930531f, -0.06810970f, -0.00702887f, -0.08763171f, 0.01748054f, 
    -0.09460676f, 0.34215799f, 0.30818367f, 0.03672952f, 0.15713266f, 0.00004383f, -0.21665466f, 0.30118340f, 
    -0.08374068f, 0.00500953f, -0.23831007f, 0.09304821f, -0.07853860f, 0.03084966f, 0.14137316f, 0.29877594f, 
    0.07523605f, 0.16817506f, 0.06382398f, 0.11779145f, 0.10695621f, -0.13806362f, 0.06824342f, -0.03333368f, 
    0.02206190f, 0.02574614f, 0.04184671f, 0.05897807f, 0.01513896f, 0.04642961f, 0.12227165f, 0.08498643f, 
    -0.02974840f, 0.06210795f, -0.02012197f, -0.14764611f, 0.19188340f, 0.04603869f, -0.02245297f, 0.10954697f, 
    -0.02736019f, -0.03210993f, -0.04488882f, 0.08220952f, 0.04246249f, 0.09274599f, 0.05133449f, 0.10488341f, 
    -0.34487826f, -0.09467180f, -0.05809530f, 0.34646350f, 0.04897021f, 0.08377811f, -0.10694015f, 0.04901074f, 
    0.00924463f, -0.00903169f, 0.21178895f, -0.11767510f, -0.19741815f, 0.23587379f, 0.21921311f, -0.04841726f, 
    -0.11354931f, -0.07211400f, 0.00790270f, 0.17031923f, -0.21130098f, -0.13532808f, 0.02231983f, -0.09349900f, 
    -0.11921925f, -0.00738822f, -0.06910582f, -0.02483323f, 0.01891977f, -0.01920334f, 0.05125100f, 0.08417302f, 
    0.07348039f, -0.09729844f, 0.10540758f, 0.01696729f, -0.43967327f, -0.18905966f, 0.11314975f, -0.02394796f, 
    -0.06907588f, -0.04317211f, -0.00193039f, -0.02931251f, 0.00368412f, -0.00250054f, -0.06708022f, -0.06060632f, 
    0.25042650f, -0.20852320f, -0.08775969f, -0.01921756f, -0.14587282f, -0.03777642f, 0.12772247f, -0.03541450f, 
    -0.16207902f, -0.12367983f, 0.05463086f, 0.20262647f, 0.30668330f, -0.09552354f, 0.22278529f, 0.21608374f, 
    0.16275057f, 0.07401171f, 0.04534035f, 0.11007527f, -0.09538924f, 0.12324718f, -0.00665430f, 0.22041404f, 
    0.03435238f, 0.09392559f, 0.00004747f, -0.33053812f, -0.13017558f, -0.02965740f, 0.09123175f, 0.15732582f, 
    -0.03635720f, 0.15687190f, 0.15655933f, 0.12789534f, -0.36718026f, -0.06261209f, 0.02894919f, 0.14808144f, 
    0.05706219f, -0.03391960f, -0.04369282f, -0.08463054f, 0.06591988f, -0.05818728f, 0.10860541f, -0.00211431f, 
    -0.16844775f, 0.14419901f, -0.02818826f, 0.17544019f, -0.11001317f, 0.07228608f, 0.07405964f, 0.02225841f, 
    -0.09107228f, 0.01855666f, -0.09016000f, 0.04650026f, -0.14052996f, 0.02669362f, -0.14890863f, 0.04630057f, 
    0.03018556f, -0.04049393f, -0.03080840f, -0.03241985f, -0.03296083f, 0.11663426f, -0.01549922f, 0.12837169f, 
    -0.08752022f, 0.22250243f, 0.05283291f, -0.06286976f, 0.00434163f, 0.12663384f, 0.04869996f, 0.09573399f, 
    0.08539147f, 0.00954344f, 0.02454019f, -0.00121833f, -0.02268161f, -0.13818818f, -0.16809180f, -0.08571808f, 
    -0.03354233f, -0.09996203f, 0.04740182f, -0.12771071f, -0.01021157f, -0.02200812f, -0.12315718f, -0.02655499f, 
    0.21104170f, 0.27940860f, 0.16450791f, 0.14821622f, 0.16190115f, 0.15720379f, 0.17377758f, 0.00005329f, 
    -0.14840187f, 0.01245778f, -0.06899931f, -0.09250299f, 0.12620597f, 0.11507355f, 0.16665152f, 0.00127650f, 
    -0.00590263f, -0.15263154f, 0.03737516f, -0.06637813f, -0.08066938f, -0.02685004f, -0.01548907f, -0.05312013f, 
    0.18646470f, 0.02196346f, 0.01450390f, 0.10297086f, -0.10359681f, 0.04797522f, 0.11299084f, 0.04569393f, 
    -0.10504327f, -0.01389242f, -0.03356818f, -0.16377434f, -0.16561599f, -0.02233337f, -0.13054307f, 0.18952776f, 
    0.11829028f, 0.09847081f, 0.14335661f, -0.20296301f, -0.03751322f, 0.01462645f, 0.24898857f, 0.05927784f, 
    0.12645574f, 0.30993405f, -0.40747306f, -0.03061706f, -0.04491257f, 0.06400899f, -0.03395395f, -0.02313115f, 
    -0.04579124f, -0.02426599f, -0.06686700f, 0.01611213f, 0.26987752f, -0.21157765f, 0.26145807f, 0.22961920f, 
    -0.02973741f, 0.12599714f, -0.11987716f, 0.08339909f, 0.00975325f, -0.03317256f, 0.05643200f, 0.08755051f, 
    -0.04613975f, 0.02816584f, 0.11738960f, 0.03199521f, -0.04957194f, -0.05391996f, -0.11622115f, -0.17796861f, 
    -0.09455486f, 0.08278438f, 0.11239196f, 0.06227238f, 0.22753181f, 0.18358500f, -0.05564318f, 0.19161916f, 
    -0.03129405f, 0.03049208f, -0.14410661f, -0.06171803f, 0.01671042f, -0.10817932f, -0.00674171f, 0.04962787f, 
    -0.06407760f, 0.26665181f, 0.01992932f, -0.04397773f, 0.04347510f, -0.04593481f, -0.08783734f, 0.21297167f, 
    0.03042176f, -0.00587268f, -0.03229473f, -0.16718036f, -0.18490659f, -0.12237069f, -0.16961855f, -0.10756182f, 
    0.02815315f, 0.16828799f, -0.04231318f, 0.10996091f, -0.01160926f, -0.04847361f, -0.16166031f, -0.31532300f, 
    0.38867658f, -0.06845021f, 0.06295835f, -0.08035672f, -0.06322716f, -0.18133388f, -0.00419199f, -0.09164373f, 
    0.15104799f, -0.03483438f, -0.15989371f, -0.05929032f, 0.14811903f, 0.04076732f, -0.12523001f, -0.19063008f, 
    -0.04984615f, 0.05911766f, 0.02941823f, 0.04563291f, 0.05839005f, 0.07247621f, 0.02137680f, 0.00981652f, 
    -0.19183616f, 0.06484272f, 0.03506345f, 0.00177410f, 0.01229487f, -0.14753239f, -0.15020563f, 0.11299978f, 
    0.01316890f, -0.02141198f, 0.12061510f, 0.04775299f, 0.04346314f, 0.04265828f, 0.04351353f, -0.12478737f, 
    0.01143745f, 0.05702286f, -0.05094573f, -0.02496015f, -0.07228104f, -0.23363370f, -0.20126978f, -0.24220738f, 
    -0.05264391f, -0.08847615f, -0.21365029f, -0.25514296f, -0.08109717f, -0.03196809f, 0.11124537f, -0.03826088f, 
    0.04939663f, 0.01229912f, -0.00523489f, -0.06201767f, 0.26940984f, 0.15816574f, 0.18541999f, -0.05934662f, 
    0.19969298f, 0.10474409f, 0.00996077f, 0.19474883f, -0.02267541f, 0.03305453f, 0.02251745f, 0.12601259f, 
    -0.24359599f, -0.29517928f, -0.14006613f, -0.13161156f, -0.05050017f, 0.12662040f, -0.00975763f, 0.03395980f, 
    0.09584243f, 0.10162432f, 0.18592311f, 0.00569553f, 0.24057117f, -0.01074814f, 0.00409836f, -0.28039208f, 
    0.09336995f, -0.08750610f, 0.09393433f, 0.12459823f, -0.02237229f, 0.04317639f, 0.00582928f, 0.07870826f, 
    -0.12235613f, -0.01691573f, 0.15353352f, -0.01116408f, -0.02245232f, 0.04944078f, -0.07324392f, -0.16902833f, 
    0.14268890f, 0.09192929f, 0.09310878f, 0.15571515f, 0.38400626f, 0.21796981f, 0.06208791f, -0.22044259f, 
    0.09025424f, 0.00662372f, 0.11566925f, 0.16569678f, -0.01994982f, -0.01560732f, -0.05119312f, -0.05142181f, 
    0.28543708f, 0.09365785f, 0.51881456f, -0.15813264f, -0.00294330f, 0.13248888f, 0.00371529f, 0.23343152f, 
    0.06495553f, 0.11207733f, 0.09601943f, -0.10340268f, -0.15400240f, 0.09996866f, -0.21100254f, -0.09395070f, 
    0.05054446f, 0.16841333f, 0.10188176f, 0.04741912f, 0.07160721f, 0.23401669f, 0.04717997f, 0.10561546f, 
    0.03180395f, 0.03425439f, -0.02509924f, 0.06580492f, -0.03884473f, -0.02540571f, 0.05761016f, -0.05285646f, 
    0.04221775f, -0.00407019f, -0.06804491f, -0.00843043f, -0.05812166f, -0.02274904f, 0.05740548f, -0.03001119f, 
    -0.01943629f, -0.01298974f, 0.01062762f, 0.03099904f, 0.01966774f, 0.02861947f, -0.02783189f, -0.06385580f, 
    -0.04112883f, 0.06552664f, -0.01625180f, 0.02275738f, -0.03954398f, 0.00148299f, -0.05699649f, -0.00061045f, 
    -0.07005477f, -0.00021197f, 0.00223659f, 0.01982894f, -0.00435632f, 0.04051335f, -0.01148037f, -0.03939421f, 
    0.03392286f, 0.05138064f, -0.03881186f, 0.01194598f, 0.01693494f, -0.06099550f, -0.00613278f, -0.01391133f, 
    -0.07140024f, -0.00004969f, 0.01216995f, 0.01285309f, 0.04864712f, -0.01582934f, -0.07214493f, -0.03214752f, 
    -0.05589388f, 0.00363478f, 0.04776578f, 0.02916678f, -0.02102606f, -0.06068029f, -0.07625504f, -0.02674636f, 
    -0.05885803f, -0.02589501f, 0.00760364f, -0.03205783f, -0.06670783f, 0.04758592f, 0.00662483f, -0.01619000f, 
    0.03851154f, -0.06280327f, 0.05357361f, 0.00704798f, 0.01905699f, -0.04748325f, -0.05588260f, -0.04761152f, 
    -0.06589784f, 0.01180859f, 0.01081813f, -0.04744221f, 0.05203180f, -0.04009912f, -0.06797756f, -0.02579744f, 
    -0.04734835f, 0.05415234f, -0.00818136f, -0.02437104f, 0.02898272f, -0.05536901f, -0.03129900f, -0.06641269f, 
    -0.04012468f, -0.06348969f, -0.01098500f, 0.00123979f, 0.00654948f, -0.07680450f, -0.00631844f, -0.05317254f, 
    -0.00446229f, 0.02763159f, 0.05926293f, 0.01271375f, -0.06812309f, 0.02544864f, -0.02430221f, -0.06321382f, 
    0.05077924f, -0.07259504f, 0.02798587f, -0.06921480f, 0.00091858f, -0.02645480f, -0.05883380f, -0.05562884f, 
    -0.07714322f, 0.05342166f, 0.01745036f, -0.02819536f, -0.07034863f, -0.01146230f, -0.02033634f, 0.01228024f, 
    0.05862468f, 0.03993611f, 0.01803144f, -0.05888531f, -0.00541058f, -0.01148396f, -0.01356626f, -0.04350599f, 
    -0.05923703f, 0.00351298f, -0.06180011f, -0.03074169f, 0.01288999f, -0.00928404f, 0.06559260f, 0.00920240f, 
    -0.06459639f, -0.04084323f, -0.07698396f, 0.04637604f, 0.05846516f, 0.00494221f, 0.00289130f, 0.00680763f, 
    -0.00759943f, 0.05509369f, 0.05589809f, -0.07648155f, -0.04106735f, -0.06956705f, 0.04409362f, -0.00538110f, 
    0.05950567f, -0.05538170f, 0.04656764f, -0.03452147f, 0.03200757f, -0.07646957f, -0.04892076f, -0.03393008f, 
    0.04676649f, -0.05003398f, -0.05214269f, -0.07295176f, -0.06044208f, 0.03561552f, 0.02240441f, 0.03765795f, 
    0.02045012f, 0.00216700f, -0.05852215f, 0.05781304f, -0.02108989f, -0.05673242f, 0.03805844f, 0.03286092f, 
    0.00474945f, 0.06032013f, -0.00440045f, 0.04654589f, -0.01311275f, -0.00843307f, 0.06575800f, 0.01995651f, 
    0.12184912f, -0.13725576f, -0.11883722f, -0.02230027f, -0.25032133f, -0.34407800f, 0.31175077f, -0.30428180f, 
    0.13912895f, -0.02009000f, -0.05518876f, 0.02494611f, 0.11138076f, -0.00320801f, -0.19128177f, 0.34803674f, 
    0.14080353f, 0.10387654f, -0.00232622f, 0.21406472f, 0.06605968f, -0.04628542f, -0.04769681f, 0.04910023f, 
    0.03311984f, 0.04281017f, 0.24314536f, 0.23568536f, -0.06835946f, 0.09056436f, 0.14280650f, -0.08046251f, 
    0.10403157f, -0.01780190f, -0.14002015f, -0.11848178f, 0.12671767f, 0.16460977f, -0.08198786f, -0.11456104f, 
    -0.18330435f, -0.23855339f, 0.10944489f, 0.25763470f, 0.01356209f, -0.07909658f, 0.09999765f, 0.14578141f, 
    -0.20350201f, 0.37084004f, 0.06891473f, 0.04720458f, -0.04924447f, 0.18436947f, -0.11624616f, 0.01869979f, 
    -0.06900471f, 0.14159204f, -0.12209110f, 0.06262660f, 0.24878724f, 0.09034378f, 0.08735304f, 0.40845227f, 
    0.21215628f, 0.01083832f, 0.11462259f, 0.04426019f, 0.15071668f, 0.12434147f, -0.25235662f, -0.08386629f, 
    -0.43707255f, -0.60114133f, 0.36853048f, -0.08051170f, 0.13565542f, 0.26284665f, 0.00268964f, 0.17920414f, 
    -0.06430575f, -0.00221950f, 0.11510040f, -0.04106504f, 0.03900397f, -0.26513645f, -0.07472859f, 0.21165685f, 
    -0.14697336f, 0.05562529f, 0.05019544f, 0.09033352f, 0.08591678f, 0.02163105f, 0.14333874f, 0.08057781f, 
    0.25961149f, -0.11269596f, 0.04893591f, 0.07535332f, 0.08891276f, -0.18554638f, 0.08968789f, 0.04382427f, 
    -0.10902548f, -0.02538554f, -0.02337957f, -0.10093019f, 0.10577787f, 0.03264375f, 0.04618490f, 0.23397535f, 
    0.03841345f, 0.26819348f, 0.10513706f, 0.19706203f, -0.01509242f, 0.04182349f, -0.03165586f, 0.05332795f, 
    0.16316652f, -0.21804042f, -0.02952900f, 0.02125830f, -0.19103752f, -0.09552896f, -0.06418681f, -0.11232293f, 
    0.07313193f, -0.00124415f, 0.11207688f, -0.00858018f, -0.44586861f, 0.01529683f, -0.08819173f, -0.02389096f, 
    -0.07813373f, 0.04026373f, -0.16360775f, -0.02555124f, -0.24545126f, 0.03509280f, -0.00488610f, 0.21160147f, 
    -0.18428887f, 0.00125134f, -0.15747005f, -0.11717819f, -0.03619030f, -0.09702206f, -0.14025466f, -0.15427247f, 
    0.04091438f, 0.01724367f, -0.00734374f, 0.19688337f, -0.25550470f, -0.02664097f, 0.09057017f, -0.07557192f, 
    -0.06521674f, 0.07820687f, 0.08684423f, 0.23225352f, -0.04455396f, -0.02271043f, -0.10254591f, -0.08381525f, 
    -0.07132529f, 0.02933086f, 0.35679939f, 0.02046888f, 0.25595313f, 0.07584945f, 0.11075513f, 0.09001135f, 
    0.02972005f, 0.02620013f, -0.14713043f, 0.06394037f, 0.12286922f, 0.12901928f, -0.10667904f, 0.04922858f, 
    0.08444994f, -0.09797534f, -0.05819799f, -0.14706922f, 0.15677018f, -0.16890928f, -0.09882513f, 0.06586365f, 
    -0.06904507f, 0.03565553f, -0.07402514f, -0.01747505f, -0.04362364f, -0.05751841f, -0.06793276f, -0.01656186f, 
    -0.05340550f, 0.04177299f, 0.00519656f, -0.08378073f, -0.06542171f, -0.05162578f, -0.02898182f, -0.03926517f, 
    -0.06363595f, -0.02059523f, 0.00334550f, -0.05549067f, 0.00367819f, -0.00999940f, -0.03540990f, 0.01376805f, 
    -0.07488399f, 0.04957693f, -0.00401184f, 0.00878569f, -0.00723664f, 0.03727396f, -0.02268816f, -0.00840710f, 
    -0.06063531f, -0.06984379f, 0.01631261f, -0.01214634f, -0.00868114f, 0.01068273f, -0.03372844f, 0.00356069f, 
    -0.09340589f, -0.07402229f, 0.03906440f, -0.05000985f, -0.07766066f, -0.06965107f, -0.06440973f, -0.00241465f, 
    -0.04122455f, -0.07940280f, -0.05170415f, -0.01962669f, -0.06319964f, -0.05606038f, -0.02796469f, 0.05668928f, 
    -0.06641506f, 0.03794171f, -0.08918785f, 0.00696801f, -0.03056080f, -0.04796701f, -0.04027778f, 0.00663752f, 
    -0.04114277f, 0.04442834f, -0.05722844f, -0.01086355f, 0.00296030f, 0.03215801f, -0.06114075f, -0.04950742f, 
    -0.01397568f, 0.04800031f, -0.08052898f, -0.03695649f, 0.04255923f, -0.01392702f, 0.03385776f, -0.03218854f, 
    0.03444291f, 0.03696764f, 0.00149595f, 0.03793381f, -0.04423470f, -0.06232353f, -0.06971733f, -0.06419195f, 
    -0.05797576f, -0.04938595f, -0.10243977f, -0.03545098f, -0.04082400f, -0.05844840f, -0.00204343f, -0.01833058f, 
    -0.10252427f, -0.03547166f, -0.07817441f, 0.01779325f, -0.05750744f, -0.00158618f, 0.01240608f, -0.04904600f, 
    0.00587271f, -0.06017095f, -0.03699323f, -0.02320678f, 0.00662646f, 0.02829019f, -0.00781759f, 0.04150812f, 
    -0.03644105f, -0.05201156f, 0.02480576f, 0.01332000f, 0.03835567f, -0.03461139f, -0.06724487f, -0.06644755f, 
    -0.00579164f, -0.04434441f, -0.06508330f, -0.10028539f, -0.01707341f, -0.06401781f, 0.01466311f, 0.04382423f, 
    -0.09306005f, 0.02486145f, 0.00266051f, -0.00596115f, -0.01599606f, 0.01453839f, 0.02118572f, 0.06494644f, 
    -0.07472987f, -0.02164700f, 0.03761187f, -0.04894443f, -0.04165320f, 0.00904359f, -0.05838602f, -0.00740831f, 
    0.01691166f, 0.01205160f, -0.09894195f, -0.02803536f, -0.04415515f, -0.03273481f, -0.00821330f, -0.06755406f, 
    -0.00390847f, -0.03740877f, 0.05007510f, -0.06034154f, 0.01318714f, -0.06618743f, 0.02181774f, -0.03858369f, 
    0.02285124f, -0.02446311f, -0.03652318f, 0.02419352f, 0.01354173f, -0.01255169f, -0.02474587f, -0.07602194f, 
    -0.01750007f, 0.03908141f, -0.02623166f, -0.04325603f, -0.07988573f, -0.00769141f, 0.02053244f, -0.07100630f, 
    0.04697488f, 0.04150029f, 0.03084639f, -0.06662721f, 0.04037211f, 0.00912070f, -0.07490537f, 0.05121937f, 
    0.00795078f, 0.05090067f, 0.03537898f, -0.09736066f, -0.02966416f, -0.03304052f, -0.07944249f, 0.01493618f, 
    0.13724989f, -0.01364111f, 0.13149127f, 0.05653185f, -0.16598132f, 0.06292600f, -0.16673858f, 0.12552238f, 
    -0.13944404f, 0.08829933f, -0.06386756f, -0.01710101f, 0.18701555f, 0.11005742f, 0.19094761f, -0.19502647f, 
    -0.07731133f, -0.06162058f, 0.07770022f, 0.12178358f, -0.07041740f, -0.06541015f, 0.02768292f, -0.05073062f, 
    0.01743991f, 0.06917832f, -0.03166026f, -0.06746567f, 0.02892230f, -0.01661756f, -0.16379195f, -0.07150611f, 
    -0.09366232f, 0.00744205f, -0.02097640f, -0.04102430f, -0.18462572f, 0.09131835f, 0.09606813f, -0.08441391f, 
    -0.01727966f, 0.07326164f, 0.00213278f, 0.05515236f, 0.10019401f, -0.03999322f, -0.01199770f, 0.04216023f, 
    0.26706460f, -0.28139964f, 0.06346840f, -0.03530722f, -0.08054699f, -0.04338860f, 0.13299567f, -0.05449425f, 
    0.12327136f, 0.15370786f, 0.04208700f, 0.08683412f, -0.55946386f, 0.23629247f, -0.04350745f, -0.03050348f, 
    0.08984710f, -0.02697548f, 0.02958671f, -0.05169481f, 0.08614997f, 0.04957592f, 0.15313411f, 0.12192857f, 
    0.21929008f, 0.45562738f, 0.03922687f, -0.11733566f, -0.07318527f, -0.19192961f, -0.23445736f, 0.11532316f, 
    -0.16029312f, 0.02510280f, 0.01112872f, -0.14330839f, 0.01490901f, 0.12616305f, -0.03394953f, -0.04785440f, 
    0.07326263f, -0.21594810f, -0.12793069f, -0.01502963f, -0.00974577f, 0.01743765f, -0.01109743f, 0.08220772f, 
    -0.15691036f, 0.02763349f, -0.20462018f, -0.10369150f, -0.10208318f, 0.08908822f, -0.07715542f, 0.04056511f, 
    0.06034506f, -0.07322799f, -0.01900252f, 0.07201667f, -0.06586691f, -0.10382581f, 0.01557020f, -0.07554708f, 
    0.04677755f, -0.04060496f, -0.10474715f, 0.02560139f, 0.04772248f, -0.09854127f, 0.03480931f, 0.01034159f, 
    0.16311815f, 0.15021020f, -0.23363334f, 0.06953664f, 0.05276699f, 0.09847457f, -0.10006823f, 0.11345919f, 
    -0.07805676f, -0.12172470f, -0.18754886f, -0.03428696f, 0.30521774f, -0.30933496f, 0.16076267f, 0.19367042f, 
    0.03034137f, 0.00934431f, 0.23878455f, 0.06581661f, 0.08549198f, 0.08983465f, -0.03078933f, -0.07201858f, 
    0.16972202f, -0.03469322f, 0.15496551f, -0.13477793f, -0.03336618f, 0.09391593f, 0.06205080f, 0.03207418f, 
    -0.04858774f, 0.12892920f, -0.18384866f, -0.03416619f, 0.12628642f, 0.10800540f, 0.11954767f, 0.04180433f, 
    0.11492861f, 0.12327637f, 0.10632378f, 0.05749403f, 0.01157015f, -0.00523512f, 0.02117943f, 0.15192480f, 
    0.09337653f, 0.24523078f, -0.20091151f, 0.15126449f, 0.06447646f, 0.17413519f, 0.10738764f, 0.03064941f, 
    -0.15733524f, 0.01639334f, 0.17669836f, -0.14230706f, -0.07242449f, -0.15554148f, 0.05663945f, -0.11365122f, 
    0.01283085f, 0.06580713f, 0.22587556f, 0.06084972f, -0.01862105f, -0.08963300f, -0.02268477f, 0.14415437f, 
    -0.02656963f, 0.00096179f, -0.01183741f, 0.04016114f, -0.02578177f, -0.03428819f, -0.00965453f, 0.05512452f, 
    -0.02982877f, 0.03651287f, -0.02273845f, 0.06031307f, 0.05566318f, -0.01548630f, -0.05280180f, 0.02228618f, 
    0.02418449f, -0.07178662f, -0.05327175f, 0.02440657f, -0.00275963f, 0.02015496f, -0.06242895f, 0.02208140f, 
    0.01929439f, 0.02438685f, 0.04304206f, -0.06585722f, -0.05187233f, -0.04276640f, -0.04323544f, 0.03361480f, 
    0.01422180f, -0.02271955f, -0.01739008f, 0.05613546f, 0.01887698f, 0.00385578f, -0.00085748f, -0.02259418f, 
    0.01067672f, 0.00810874f, -0.05033867f, -0.07099517f, -0.00578823f, -0.06931169f, -0.04877682f, 0.05337762f, 
    -0.06357670f, -0.05326343f, -0.04654785f, 0.01394001f, -0.06139712f, -0.00258057f, 0.00019816f, -0.04677125f, 
    0.00411739f, 0.04904576f, -0.03342743f, 0.00190995f, 0.03238400f, 0.00260574f, -0.07384486f, -0.07526409f, 
    -0.05464519f, 0.05629512f, -0.07550170f, 0.03242592f, 0.04591538f, -0.01872351f, -0.01913600f, -0.02819788f, 
    -0.06972004f, 0.01093175f, 0.06345139f, -0.05501121f, 0.01144032f, -0.02678176f, 0.03326841f, -0.06317344f, 
    0.04503958f, 0.05489938f, 0.03607430f, -0.00875938f, 0.02585598f, 0.03691787f, -0.01960810f, -0.00707104f, 
    -0.04167623f, -0.00967432f, 0.04362524f, -0.05386309f, -0.02699757f, 0.04870301f, -0.05740459f, 0.00335506f, 
    -0.07880459f, -0.04367590f, -0.01975857f, -0.08347193f, 0.01730763f, -0.05186288f, -0.01126339f, 0.05474652f, 
    0.04206830f, 0.05808954f, 0.04466437f, -0.02323688f, -0.03771951f, -0.08095646f, -0.03274898f, -0.00124428f, 
    -0.03688708f, 0.06024595f, 0.00278316f, 0.05985876f, 0.05900308f, 0.00415800f, -0.05941214f, -0.07174447f, 
    -0.01093588f, -0.00486951f, 0.00051281f, -0.05478255f, -0.02895399f, 0.05639583f, -0.05037407f, 0.03973450f, 
    -0.05523170f, -0.01593003f, 0.00301628f, 0.03669998f, 0.00828096f, -0.04263087f, -0.02790117f, 0.02542111f, 
    0.03457886f, 0.05027391f, 0.05063799f, -0.07431779f, -0.06899356f, 0.04511201f, -0.03374869f, -0.07024144f, 
    -0.05253532f, -0.03837812f, 0.02979285f, 0.02045243f, -0.06363492f, -0.03785414f, -0.05613537f, -0.05280563f, 
    -0.00286515f, -0.04985743f, -0.00327876f, 0.05965545f, 0.06370832f, -0.07700782f, -0.00210977f, -0.03153362f, 
    -0.02581804f, 0.02755159f, 0.04629613f, -0.02300873f, -0.07673325f, -0.01560975f, 0.06169846f, -0.03721261f, 
    -0.07460928f, -0.07595381f, 0.00335089f, -0.04314719f, -0.04882253f, -0.07820769f, 0.06158839f, 0.05130965f, 
    -0.03205353f, -0.03293769f, 0.01423409f, -0.01698430f, 0.01862077f, 0.02148292f, 0.02835753f, 0.06893535f, 
    -0.02275347f, -0.00010363f, -0.01691128f, -0.00580355f, -0.06529680f, 0.04095792f, 0.05824897f, -0.04372887f, 
    0.02098725f, -0.07299349f, 0.04011652f, -0.04195331f, -0.00749195f, -0.04638209f, -0.06415901f, 0.02422710f, 
    0.03202431f, -0.02521283f, 0.01252829f, 0.04317113f, 0.05439280f, -0.01763907f, -0.05769801f, -0.07833963f, 
    -0.03358133f, -0.07323905f, -0.04774785f, 0.03266608f, -0.02395321f, -0.03009782f, 0.04396352f, -0.03022889f, 
    -0.02177322f, 0.01202916f, -0.00127424f, -0.06889259f, -0.05018589f, -0.00653690f, -0.01292528f, 0.05578476f, 
    -0.02269933f, -0.02664275f, -0.05885103f, -0.04585101f, -0.01018884f, -0.00693572f, 0.01864246f, -0.04494007f, 
    0.03192870f, 0.01330309f, 0.01503383f, -0.06031409f, -0.06584182f, -0.04302144f, -0.03129613f, 0.01115851f, 
    -0.00557385f, 0.04165186f, -0.07228562f, -0.01411214f, -0.01621070f, 0.00472124f, -0.01728087f, -0.05021866f, 
    -0.03821024f, 0.03157247f, 0.05241769f, -0.07907403f, -0.05414431f, -0.04943111f, 0.01160175f, 0.01983512f, 
    0.00079499f, -0.04550311f, 0.06150592f, -0.07512012f, -0.03522345f, 0.05711450f, 0.05186061f, -0.05412526f, 
    -0.01192489f, -0.00619837f, 0.02695515f, 0.03962461f, -0.01014603f, -0.07082523f, 0.02875911f, 0.02089782f, 
    -0.03265906f, -0.06289203f, -0.05663069f, -0.01413394f, 0.04729069f, -0.00084309f, 0.03820011f, -0.02944423f, 
    -0.07733289f, -0.02288317f, 0.01407183f, 0.02837286f, -0.00791445f, -0.07518673f, -0.05358332f, -0.00418302f, 
    0.01771301f, -0.02793406f, 0.04192006f, 0.03579423f, -0.03453192f, -0.06163224f, -0.01812847f, 0.01765967f, 
    0.03597402f, 0.02753487f, 0.00167482f, -0.04343912f, 0.02383314f, -0.00556366f, 0.02546846f, -0.00299667f, 
    0.00446426f, -0.06129789f, -0.00905922f, 0.06075062f, -0.02050273f, 0.00663977f, 0.01533987f, -0.02472349f, 
    -0.04687642f, -0.00388242f, 0.02469144f, -0.07661182f, -0.04118887f, 0.05806947f, -0.03833361f, 0.04383819f, 
    -0.02055359f, 0.02539035f, 0.05479513f, -0.05922017f, -0.06876148f, -0.04929985f, -0.02863682f, -0.04406636f, 
    -0.06402044f, -0.05699379f, -0.02682024f, -0.02213422f, 0.04674999f, 0.00261039f, 0.02545226f, -0.00282466f, 
    -0.02317354f, 0.01403426f, 0.00448504f, -0.03110902f, -0.05927135f, -0.04292565f, -0.02941524f, -0.05328014f, 
    -0.06300401f, 0.06235652f, 0.05980394f, -0.05261537f, -0.04177421f, -0.05384063f, 0.03103868f, 0.00378042f, 
    -0.06283776f, -0.07617299f, 0.02997559f, 0.03880471f, 0.00890928f, -0.01586117f, -0.01998973f, -0.00628812f, 
    -0.00538152f, -0.05546810f, -0.02801039f, 0.00170719f, -0.05033967f, -0.01627329f, 0.04564707f, -0.02965392f, 
    0.02653087f, -0.07547999f, -0.00843555f, -0.03964398f, -0.01177931f, -0.06482150f, 0.06166438f, 0.01490623f, 
    -0.04952516f, 0.00261022f, 0.01495501f, -0.01054140f, 0.03411972f, -0.03650875f, -0.06131976f, -0.03917402f, 
    0.13023844f, 0.17619121f, 0.07685605f, 0.14956468f, 0.04691800f, -0.01722947f, -0.07377950f, -0.02421480f, 
    0.21749470f, 0.06330799f, -0.07369496f, -0.10405707f, 0.51764041f, 0.30486128f, 0.03471736f, 0.17272206f, 
    0.06508262f, -0.04080133f, -0.02847737f, 0.01627188f, 0.22030322f, 0.05683121f, 0.03168964f, 0.09913325f, 
    0.18906453f, -0.08167725f, -0.25426126f, 0.11178340f, -0.12121782f, -0.11539789f, 0.10922562f, 0.08561843f, 
    -0.14004542f, -0.05618836f, -0.16968335f, 0.02366200f, -0.29592636f, -0.19134015f, -0.15722311f, -0.30072376f, 
    -0.05294110f, -0.20323455f, 0.03743935f, -0.15248546f, 0.12798236f, -0.11466221f, -0.06939307f, 0.03190113f, 
    0.37576038f, 0.31777698f, 0.10050184f, 0.05749641f, -0.00086201f, 0.17763840f, -0.00471952f, 0.02319560f, 
    -0.04903273f, 0.04044326f, -0.18468948f, -0.12752873f, -0.31985658f, -0.24545304f, 0.32645175f, 0.29850098f, 
    0.27208322f, 0.15894811f, 0.00868675f, 0.26685065f, -0.11939029f, -0.10234032f, -0.04991575f, -0.06640770f, 
    0.36834311f, 0.19502763f, 0.28923112f, 0.10167339f, -0.15033284f, -0.14448600f, 0.00823035f, -0.01491933f, 
    0.08338376f, -0.03782566f, 0.00228133f, -0.02351945f, 0.06287466f, 0.05331542f, 0.06101092f, 0.07123326f, 
    -0.02756575f, 0.06321364f, 0.13446401f, 0.09672730f, 0.37164050f, 0.21929851f, 0.19660726f, 0.15031362f, 
    0.19863504f, -0.04663957f, -0.16324085f, -0.19999912f, -0.04716281f, -0.02440661f, -0.09014828f, 0.01775561f, 
    -0.04603725f, -0.19673276f, 0.04855311f, -0.07510988f, -0.16574878f, 0.02676797f, -0.12516674f, -0.15984640f, 
    0.12758771f, 0.10214117f, -0.00304582f, 0.03491445f, 0.01355216f, 0.02873793f, 0.02483727f, -0.04853703f, 
    0.14667639f, -0.05603272f, -0.18992388f, -0.47857702f, -0.05468081f, -0.15892003f, -0.01259388f, 0.39296201f, 
    -0.06073339f, 0.13237721f, 0.21399264f, 0.02078331f, 0.09995155f, -0.15896040f, -0.02262023f, -0.12077823f, 
    0.09952813f, 0.41233057f, -0.04271430f, 0.17340782f, -0.08715906f, -0.03891452f, 0.02714111f, -0.05147408f, 
    0.05276069f, 0.04345001f, 0.00011901f, 0.13755929f, 0.01545681f, 0.07578697f, 0.05177314f, 0.00860136f, 
    0.01089977f, 0.16010650f, 0.00407350f, -0.08073676f, -0.16470183f, -0.42291048f, -0.46424556f, -0.29519239f, 
    -0.09453833f, -0.22336809f, -0.20245089f, 0.01799116f, -0.09627534f, -0.04684012f, -0.06767780f, -0.09910094f, 
    -0.34400544f, -0.07443172f, 0.11747777f, 0.05465131f, -0.05858529f, 0.20224786f, -0.08476789f, 0.16282785f, 
    -0.03046368f, -0.26275119f, -0.04931945f, -0.14033665f, 0.01750525f, -0.24538092f, -0.45175633f, -0.18476774f, 
    -0.15792727f, -0.18979360f, 0.24366963f, 0.08645109f, 0.07719477f, 0.08811134f, 0.08810580f, 0.00688856f, 
    0.21914215f, -0.05401748f, -0.02028405f, 0.03366763f, -0.07374971f, -0.11523265f, -0.14488682f, 0.00697178f, 
    -0.02463972f, -0.13271910f, 0.01274164f, -0.03924080f, 0.62692368f, 0.09864245f, 0.01204223f, -0.07899898f, 
    0.07836775f, -0.01301963f, -0.00023957f, -0.10593512f, -0.00302716f, 0.02242250f, 0.01832294f, -0.01675836f, 
    -0.05784796f, -0.05798154f, 0.00419681f, 0.00606933f, 0.10124301f, -0.04065613f, 0.01288565f, -0.14912716f, 
    0.06209674f, 0.01817634f, 0.03164436f, -0.08199133f, -0.12613614f, 0.13411921f, -0.18957111f, -0.10543313f, 
    -0.07344557f, -0.04900107f, 0.06774148f, -0.01984175f, 0.12342553f, -0.08604677f, -0.06214371f, 0.03738253f, 
    -0.05279772f, -0.36187348f, 0.31268415f, 0.06353918f, 0.00728306f, 0.01293517f, 0.02216494f, 0.09256466f, 
    0.02650868f, 0.25286624f, -0.09409709f, 0.12689798f, -0.25939649f, 0.25338793f, 0.34135464f, 0.26710296f, 
    0.11175118f, 0.03249991f, -0.03150226f, -0.15097487f, -0.05676687f, 0.01113457f, 0.14865716f, 0.02589723f, 
    0.29413375f, -0.11609463f, -0.16711301f, 0.03719796f, 0.17456688f, -0.07896563f, -0.18101153f, 0.03536321f, 
    -0.11672730f, -0.08742689f, 0.00436275f, 0.00279283f, 0.07057587f, 0.09903869f, -0.15687761f, -0.02837163f, 
    0.08287836f, -0.05827672f, -0.05308516f, 0.04886907f, 0.05624754f, -0.09316295f, 0.06312588f, -0.03390896f, 
    -0.57420337f, -0.11656383f, -0.14197807f, -0.10325629f, -0.08066393f, -0.04791087f, -0.11383490f, 0.16002283f, 
    0.11666910f, 0.00498170f, 0.01560182f, -0.12284629f, -0.17884037f, -0.05973839f, 0.23251328f, 0.16276996f, 
    0.02051212f, 0.08644181f, 0.04122610f, 0.06197135f, 0.00960771f, -0.10086206f, 0.06708433f, -0.03923156f, 
    -0.02247868f, 0.01574944f, -0.01620365f, 0.10100196f, -0.08403546f, -0.14779858f, -0.09610477f, 0.03553003f, 
    0.02447199f, 0.05337869f, 0.13605821f, -0.03266554f, -0.21967731f, -0.21799989f, 0.15098801f, 0.00409541f, 
    0.00345048f, 0.04443295f, 0.10561523f, -0.10765374f, -0.05343188f, 0.12649445f, 0.02482715f, 0.02701024f, 
    0.07976105f, -0.08339361f, 0.03307496f, 0.16447535f, 0.05285672f, 0.04762117f, -0.04597350f, -0.04239853f, 
    -0.04532561f, -0.06038580f, -0.14123669f, -0.00902607f, -0.03080632f, 0.11791962f, 0.19955213f, -0.11745819f, 
    -0.08205169f, -0.05296170f, 0.04716158f, 0.11410879f, -0.00689048f, 0.07583439f, 0.12214322f, 0.03914337f, 
    -0.41600612f, -0.14779013f, -0.02219702f, 0.32054466f, 0.01117205f, -0.22055073f, 0.08987300f, 0.27016285f, 
    0.03194756f, 0.26530328f, 0.02831612f, 0.00533319f, -0.02875391f, 0.13578816f, -0.00691013f, -0.08838977f, 
    -0.04014948f, 0.00898019f, 0.09248089f, -0.02645075f, 0.15196891f, 0.13858831f, 0.06605875f, 0.01362060f, 
    0.02138889f, 0.03130257f, -0.05214231f, -0.00419428f, -0.05845743f, -0.00541589f, -0.03040050f, -0.04606073f, 
    0.05990136f, -0.01052576f, -0.04058946f, -0.01049447f, -0.02416953f, 0.03520965f, 0.03922985f, -0.04675859f, 
    0.05071756f, 0.00145800f, -0.04161602f, -0.04256214f, -0.07252271f, 0.03325880f, 0.00418911f, -0.06495474f, 
    -0.04695850f, -0.03742915f, 0.00423138f, -0.05575725f, -0.02558471f, -0.07678201f, -0.03107549f, 0.05605619f, 
    0.04671276f, 0.04004758f, 0.03247952f, -0.02785352f, -0.07273342f, 0.03586749f, 0.00579964f, -0.02791882f, 
    -0.02783169f, 0.01420799f, 0.04849290f, -0.02419610f, -0.03680910f, 0.03684934f, -0.06589694f, 0.01045428f, 
    -0.05973437f, -0.03074161f, 0.03207387f, 0.05413477f, 0.04567829f, 0.04040829f, -0.01169943f, 0.05197982f, 
    -0.03040192f, -0.01073251f, -0.02829379f, 0.00438390f, -0.03115376f, -0.01127264f, 0.03051240f, 0.00413301f, 
    0.00137552f, -0.02821753f, -0.00587500f, -0.02457730f, -0.05889118f, -0.01630777f, -0.00918169f, -0.06091292f, 
    -0.00582862f, -0.06335200f, -0.02457231f, -0.07127450f, -0.00467641f, -0.05492287f, -0.05689685f, 0.01872771f, 
    -0.04515909f, 0.05634464f, 0.04750714f, -0.06460205f, -0.04725728f, -0.06428283f, -0.03170609f, -0.03362469f, 
    0.06483842f, -0.06654548f, -0.02373122f, -0.03921704f, 0.01831437f, -0.04368874f, -0.02770083f, -0.01924042f, 
    -0.00515286f, -0.05445933f, -0.01129181f, -0.00772534f, 0.02467207f, 0.04248315f, 0.02896397f, -0.06533232f, 
    0.00358815f, -0.02298076f, 0.02491775f, -0.07275669f, -0.04091681f, 0.05189999f, -0.07113903f, 0.03143292f, 
    0.05582872f, -0.06239247f, -0.00842232f, -0.01014329f, 0.02928770f, -0.06707118f, -0.06140984f, -0.00035070f, 
    -0.03987183f, 0.06344938f, -0.04911983f, -0.03062139f, -0.04440206f, 0.03842253f, -0.00433835f, -0.00675765f, 
    -0.05537109f, -0.02452297f, -0.04062433f, 0.02541379f, 0.05167002f, 0.06044159f, -0.07043620f, -0.00019406f, 
    -0.04466293f, -0.00990609f, -0.02084681f, -0.03547870f, 0.04704071f, 0.02159128f, 0.02781669f, 0.02213163f, 
    0.04660500f, -0.00041948f, -0.00323832f, 0.02758774f, -0.01192884f, 0.04656051f, -0.07041851f, -0.04862458f, 
    -0.04564396f, -0.02606254f, 0.04158825f, 0.04132567f, -0.06777357f, -0.02542571f, -0.03328071f, -0.05961947f, 
    -0.00759935f, -0.06024713f, 0.03442384f, -0.02415560f, 0.02467903f, -0.07270463f, 0.00664034f, -0.00706504f, 
    0.06800546f, -0.01831092f, -0.02900841f, 0.06523216f, 0.00402441f, 0.02265290f, 0.05702589f, -0.02048616f, 
    -0.00969724f, 0.01173384f, 0.03664485f, 0.02797533f, -0.01943304f, -0.05372501f, -0.06597440f, 0.01573488f, 
    0.00218220f, -0.01666290f, -0.02429062f, 0.05913919f, 0.04033040f, 0.04981549f, 0.00362171f, -0.01393062f, 
    0.10034428f, -0.28199521f, -0.00082161f, -0.05175371f, -0.13191181f, 0.05424364f, -0.05464315f, 0.10236620f, 
    -0.00414022f, 0.04909866f, -0.11378010f, -0.06135425f, -0.04940232f, 0.32785982f, 0.12958501f, -0.19921619f, 
    0.07711329f, -0.08868805f, 0.09684020f, 0.01834678f, -0.03997432f, 0.10202607f, -0.04774630f, -0.03596137f, 
    -0.08655296f, -0.08021821f, 0.02931547f, 0.16026707f, 0.10450400f, -0.09922949f, -0.10293535f, -0.08664756f, 
    0.13521367f, 0.06819019f, -0.06814452f, 0.13172977f, 0.01093133f, 0.08616088f, 0.00951271f, 0.15417412f, 
    -0.03156798f, -0.24310699f, 0.19948845f, -0.15539378f, 0.05079446f, 0.09796096f, 0.11971451f, 0.24052787f, 
    -0.15471120f, -0.01925607f, -0.17099875f, 0.13688676f, 0.00961957f, 0.08708105f, -0.03590465f, -0.02423529f, 
    0.04311359f, 0.25252709f, 0.26655594f, 0.09128898f, -0.06579586f, 0.05658434f, 0.23393004f, 0.21395262f, 
    0.01044362f, 0.07427021f, -0.03179546f, 0.18408450f, 0.06371421f, 0.07704690f, -0.15216088f, -0.14532095f, 
    0.11528014f, 0.32585913f, 0.32447609f, 0.15090694f, 0.05656286f, -0.07096112f, 0.07212880f, 0.04041776f, 
    -0.11804158f, -0.10939959f, -0.08221822f, -0.01337513f, 0.03883527f, 0.13126270f, 0.00356061f, -0.03486572f, 
    -0.06551824f, 0.03369879f, -0.22253941f, -0.13980147f, 0.22126046f, 0.13031347f, 0.11566681f, 0.17651375f, 
    0.26305589f, -0.27642462f, 0.07696620f, 0.24673311f, 0.00560608f, -0.15882553f, -0.23086098f, -0.01573517f, 
    0.03745417f, -0.06414759f, -0.02162630f, -0.01890141f, -0.20872612f, -0.15878083f, 0.07692423f, 0.31260607f, 
    0.00624129f, 0.01258574f, -0.07972793f, 0.12708010f, 0.08353898f, -0.04895968f, -0.07071326f, 0.01408777f, 
    0.23938230f, -0.00578374f, 0.02147034f, 0.20088331f, -0.10439558f, -0.17335014f, -0.08605181f, -0.12889214f, 
    -0.13345376f, 0.01373960f, -0.24565347f, -0.00086445f, -0.37197703f, -0.14640778f, -0.00511330f, 0.30382103f, 
    -0.04131628f, 0.12973364f, -0.10426671f, -0.11520486f, -0.00561144f, -0.08164533f, 0.05396274f, 0.03912396f, 
    -0.04497179f, -0.00838357f, -0.25046444f, -0.13383377f, -0.01018298f, -0.03525862f, -0.22118129f, -0.07926838f, 
    -0.16447984f, 0.05404893f, -0.14568818f, -0.10512483f, -0.35838532f, -0.02189665f, 0.25933802f, 0.06071663f, 
    0.00843387f, -0.03212769f, 0.05496281f, 0.06544157f, 0.07629986f, 0.12552129f, 0.08261444f, 0.16131799f, 
    0.47721225f, -0.25941971f, -0.31314975f, 0.19088288f, 0.04264740f, -0.07347503f, 0.04289226f, -0.27016234f, 
    -0.03878825f, 0.08060500f, 0.08172185f, -0.03592942f, -0.03300424f, 0.03403742f, 0.16342771f, 0.12156326f, 
    -0.05574295f, -0.08279929f, 0.09075150f, -0.23905322f, -0.05610940f, -0.08684231f, 0.00032122f, 0.08935557f, 
    -0.33282703f, -0.40423000f, -0.03988514f, 0.05713593f, 0.00427696f, -0.09479640f, -0.07712433f, -0.01679629f, 
    0.04157364f, 0.03185881f, -0.09224886f, 0.08781897f, -0.24196890f, -0.05420537f, -0.23603702f, -0.11679154f, 
    0.07579714f, -0.03133494f, -0.10679869f, 0.14218153f, 0.01325903f, 0.08333571f, -0.02364650f, -0.12769873f, 
    -0.00318328f, 0.27685449f, 0.36205694f, 0.14014328f, 0.11911543f, 0.05870724f, 0.05931927f, 0.00512267f, 
    0.16964102f, -0.04236835f, -0.14265484f, -0.04090490f, -0.08438391f, 0.12224051f, 0.11034586f, 0.05041021f, 
    0.13531840f, 0.02758627f, 0.17825188f, 0.06690744f, -0.06942620f, 0.02106516f, 0.14380270f, 0.22200365f, 
    -0.34304500f, -0.27353206f, -0.09850746f, 0.21429379f, 0.12669130f, 0.07106512f, -0.12776285f, -0.01709552f, 
    -0.03755419f, 0.01087264f, 0.08169904f, 0.04760520f, 0.26355606f, 0.10630633f, 0.02648484f, -0.13148414f, 
    0.10231651f, -0.07479701f, -0.00193053f, 0.06530487f, 0.05460742f, -0.06333120f, -0.13771170f, -0.05541965f, 
    -0.18162246f, -0.04604008f, 0.17887799f, 0.01770359f, -0.07011351f, -0.10886097f, 0.10777362f, -0.03565586f, 
    -0.09333003f, 0.00711075f, -0.12365006f, -0.12600538f, -0.16524047f, -0.12088196f, 0.10399973f, -0.12533799f, 
    -0.03250036f, 0.03197146f, -0.07912947f, 0.06544165f, 0.21277347f, 0.20040870f, 0.22759323f, 0.13734771f, 
    -0.00879902f, -0.28537348f, 0.33697996f, 0.44227257f, 0.10121650f, -0.14173624f, -0.09718130f, 0.11949987f, 
    -0.07655307f, -0.09810694f, 0.13369024f, 0.03525462f, 0.27371496f, 0.21183479f, 0.25056443f, 0.23407046f, 
    0.14088431f, 0.22312336f, 0.00669782f, 0.04256812f, 0.02426309f, 0.13147841f, 0.08167599f, -0.01585494f, 
    0.28121930f, -0.20032644f, 0.04036248f, 0.00437510f, 0.04249046f, 0.00326960f, -0.02587249f, -0.00964105f, 
    -0.02001631f, 0.00489239f, -0.16269208f, 0.03343532f, -0.31474644f, 0.05438923f, 0.26083568f, 0.08986102f, 
    -0.05910840f, 0.13359497f, -0.00105888f, 0.05003474f, 0.05814397f, -0.16501996f, -0.06258652f, 0.04514493f, 
    -0.31934312f, -0.28655899f, -0.36315930f, -0.20128381f, 0.27007264f, -0.10756239f, -0.28922683f, -0.02314507f, 
    0.05207649f, 0.00970193f, -0.15459098f, 0.01726240f, -0.10103091f, -0.00969168f, 0.35423753f, -0.15754157f, 
    -0.09497850f, 0.00872119f, 0.08167302f, 0.01278472f, 0.03262747f, 0.09933829f, 0.07868432f, 0.00878229f, 
    0.12463582f, -0.11305698f, 0.38314193f, 0.06744221f, 0.05986049f, -0.09724008f, -0.02306080f, -0.18306406f, 
    0.06481803f, -0.13708305f, 0.04780894f, 0.11891407f, 0.00028211f, 0.12488359f, -0.03526732f, 0.13564005f, 
    0.05652085f, -0.04145311f, -0.00461083f, -0.14026211f, 0.14237294f, -0.04217668f, -0.01410714f, -0.11118624f, 
    0.00191267f, -0.00665850f, -0.18480889f, -0.17702971f, -0.04036072f, -0.20796669f, 0.19184290f, -0.26894277f, 
    0.03440959f, -0.05378955f, -0.12451877f, -0.02915583f, -0.12346352f, 0.01293912f, 0.07246202f, 0.02308403f, 
    0.04782404f, -0.02555941f, 0.02084007f, -0.08361914f, -0.06305220f, 0.06760294f, -0.03972773f, -0.03786317f, 
    0.09246907f, -0.01618884f, 0.00085839f, 0.19933204f, -0.05551862f, -0.01076655f, 0.07244830f, -0.08704528f, 
    0.03062106f, -0.00181080f, 0.07302973f, 0.17953929f, 0.33597988f, -0.17688467f, -0.12171976f, 0.26073873f, 
    0.03556284f, 0.12522601f, 0.25137186f, 0.20537783f, 0.03424929f, 0.08127599f, 0.03132747f, 0.20784010f, 
    -0.01636101f, 0.31672174f, -0.11426467f, -0.31273949f, -0.10616621f, 0.06702134f, -0.20535471f, 0.09388300f, 
    0.05934526f, 0.06477983f, 0.23563747f, -0.00549962f, 0.17001131f, -0.24765240f, 0.20144230f, 0.36436996f, 
    0.13561492f, 0.10822701f, 0.13361034f, 0.00585384f, 0.00636378f, 0.06174716f, -0.07589719f, 0.06018061f, 
    -0.25160941f, -0.40363058f, 0.01227163f, 0.05654396f, 0.08832598f, 0.05677713f, 0.16261296f, -0.09094757f, 
    -0.01852873f, 0.00919259f, -0.09631640f, 0.14141630f, -0.08418751f, -0.19662994f, 0.07480731f, -0.03103086f, 
    -0.08795307f, 0.18592310f, 0.10100754f, 0.05718764f, 0.16346091f, 0.14342947f, -0.00669814f, 0.13779311f, 
    0.41560090f, -0.02059384f, 0.18207170f, 0.06784605f, 0.08309436f, 0.01921977f, -0.00007664f, 0.14372784f, 
    0.04241926f, -0.01025749f, -0.07233599f, 0.02557482f, 0.02263263f, -0.11906108f, -0.16286780f, 0.18966253f, 
    -0.03547062f, 0.03439419f, 0.03506694f, -0.13544956f, -0.04213951f, -0.04162646f, -0.13457485f, -0.17002757f, 
    0.02811735f, -0.11761037f, 0.14589503f, 0.16051522f, 0.07420805f, -0.06375360f, 0.12566335f, -0.04294827f, 
    -0.00632520f, 0.05421048f, 0.08585531f, -0.00831788f, -0.02762203f, 0.17591803f, -0.25719908f, -0.22558726f, 
    0.07542307f, 0.11592904f, -0.08011073f, 0.00975356f, -0.27845791f, -0.13193350f, -0.10259867f, 0.03658115f, 
    -0.06916433f, 0.12205708f, -0.20929532f, 0.13437045f, -0.03738436f, -0.20015995f, -0.13895425f, -0.02141127f, 
    -0.08646633f, -0.27826172f, 0.17202777f, -0.17372951f, -0.32750517f, -0.16781527f, -0.10922142f, 0.10573263f, 
    0.08342292f, -0.04178379f, 0.11723781f, -0.03236385f, 0.06652900f, 0.12359707f, 0.02496960f, 0.01803222f, 
    0.39751440f, -0.14137435f, 0.15010232f, 0.00238270f, 0.04592615f, 0.26835421f, -0.03253941f, -0.00779223f, 
    0.11487902f, 0.07718353f, -0.07111961f, 0.09037244f, 0.15720512f, -0.02781597f, -0.07188030f, 0.22861639f, 
    -0.02335713f, -0.01216363f, -0.02203305f, 0.01570776f, -0.06119404f, 0.09359463f, 0.19264188f, -0.18196672f, 
    -0.23997603f, -0.26425713f, -0.16091031f, -0.00239367f, 0.07005426f, -0.23899660f, -0.09700969f, -0.34996185f, 
    0.08467752f, -0.07268503f, 0.03316487f, -0.05767975f, -0.23597187f, -0.31925321f, -0.30664974f, 0.04657850f, 
    -0.07005309f, 0.05566598f, -0.09375773f, -0.03184262f, -0.05537862f, -0.08469320f, 0.05542440f, 0.06403483f, 
    0.03641300f, 0.13979505f, 0.18391711f, 0.07591227f, 0.07841487f, 0.12889482f, 0.02184158f, 0.28141245f, 
    0.01530779f, -0.07029907f, -0.07346611f, -0.16215055f, -0.07841861f, 0.08849460f, -0.04417000f, -0.23105565f, 
    -0.00839317f, 0.05933301f, -0.01969416f, 0.17636095f, 0.01122159f, 0.08212054f, 0.05223715f, -0.06064374f, 
    -0.08159019f, 0.11716751f, -0.01157437f, 0.43199393f, 0.21978544f, -0.04423547f, -0.19597250f, -0.12742077f, 
    -0.01496804f, -0.03115689f, -0.05585088f, -0.04303481f, 0.42514506f, 0.08036146f, -0.23479952f, -0.22247069f, 
    0.04530725f, 0.09869868f, 0.16538286f, 0.20480725f, -0.02365489f, 0.04683227f, 0.02108881f, 0.02721514f, 
    -0.22804442f, -0.39920002f, -0.17190789f, -0.22015309f, 0.06134133f, 0.01071627f, -0.03959437f, 0.16712762f, 
    -0.01507468f, -0.00226028f, -0.05889108f, -0.05616655f, -0.15544531f, -0.21937990f, 0.09086767f, -0.13894804f, 
    -0.06273899f, 0.14654957f, 0.05469249f, 0.11964118f, -0.04321972f, -0.06689660f, 0.01368215f, 0.05655878f, 
    0.06174611f, 0.06752201f, 0.12221088f, 0.13771486f, 0.09334186f, -0.07267858f, 0.09727602f, -0.02309211f, 
    -0.02720412f, 0.08167969f, 0.06662037f, 0.01990277f, 0.30799884f, 0.31170380f, 0.19163780f, -0.17039485f, 
    0.15734202f, 0.11491064f, 0.07170784f, 0.22768480f, -0.12317695f, -0.06167217f, 0.07534298f, -0.03589907f, 
    -0.00383132f, -0.09429139f, 0.11334550f, -0.20787388f, -0.01523609f, 0.09703598f, 0.06512367f, 0.07119511f, 
    0.17425014f, -0.03609676f, 0.10029367f, 0.03664804f, 0.17270492f, 0.21966285f, 0.04017576f, -0.15767565f, 
    0.02107833f, 0.00032771f, 0.00955784f, 0.18222430f, 0.17259663f, -0.03460833f, -0.06694274f, 0.05971196f, 
    -0.27022180f, -0.19830018f, -0.25077969f, -0.17260566f, 0.02120317f, -0.08037154f, 0.00888441f, -0.07440274f, 
    0.09638053f, 0.08106960f, 0.01269433f, 0.15833239f, 0.28442395f, 0.18599461f, 0.07564618f, -0.15398079f, 
    0.05326928f, -0.02688758f, -0.00819317f, 0.10478298f, 0.02430876f, 0.01935810f, -0.07868859f, 0.01105885f, 
    -0.01691039f, 0.23287414f, 0.63190889f, -0.03054591f, 0.14194626f, 0.08866883f, -0.13832048f, 0.06538288f, 
    0.01967023f, 0.07195207f, 0.03908579f, -0.04338761f, 0.10494747f, 0.14638424f, -0.07566047f, 0.03195254f, 
    -0.04507757f, 0.01338713f, -0.05305337f, 0.11258808f, -0.12309185f, 0.09976992f, -0.01779627f, 0.00131641f, 
    -0.02755885f, -0.01775380f, -0.01862900f, 0.02568917f, -0.01570061f, -0.06964560f, -0.05157996f, 0.00563263f, 
    0.00503703f, -0.03166644f, -0.03636223f, 0.02328257f, 0.03835385f, 0.00460459f, -0.06765226f, -0.06200347f, 
    -0.01676684f, 0.02469313f, -0.02201165f, 0.01880960f, -0.01139112f, -0.07888510f, -0.02628593f, -0.06540322f, 
    -0.04020057f, -0.02924122f, -0.05820503f, 0.07269216f, -0.04302998f, 0.04264200f, -0.07807712f, 0.01356603f, 
    -0.06491703f, -0.05189007f, 0.03330494f, -0.01401280f, 0.00405080f, 0.06004482f, -0.06090879f, 0.02656974f, 
    -0.07132212f, -0.04509344f, -0.05105334f, -0.03971944f, 0.06363744f, -0.03248383f, -0.04087627f, -0.01600082f, 
    0.01550310f, 0.01021461f, -0.05588352f, 0.03975834f, -0.00484555f, 0.04613153f, 0.04650972f, -0.00498878f, 
    0.05805327f, -0.05446667f, 0.00977682f, 0.02991010f, -0.05314020f, -0.01810536f, 0.02571948f, -0.03848140f, 
    -0.04224742f, -0.02670862f, 0.03555984f, 0.01192349f, -0.07169339f, 0.05240289f, -0.01209528f, -0.06363918f, 
    -0.08521353f, -0.07326501f, -0.07734846f, -0.03831271f, 0.00897356f, 0.01326602f, -0.03649578f, -0.02557407f, 
    0.04981559f, 0.03068560f, -0.04605161f, 0.00400712f, 0.01536230f, -0.07819878f, -0.02842867f, -0.04809661f, 
    0.02605993f, 0.03416630f, -0.02064987f, -0.01439844f, -0.02461709f, 0.05734468f, -0.04950517f, -0.01976445f, 
    -0.01656383f, 0.02176701f, -0.07155152f, -0.02158719f, 0.01514807f, -0.00271150f, -0.00708255f, 0.04533077f, 
    0.06875981f, -0.04679478f, 0.03712657f, 0.04840992f, 0.06440974f, 0.07161222f, -0.01495558f, 0.01652732f, 
    -0.00189983f, -0.03613955f, -0.00337536f, -0.06045146f, 0.05045832f, 0.02561680f, 0.00344598f, 0.00356783f, 
    -0.04403642f, -0.00300544f, 0.02169035f, 0.02140539f, 0.05693243f, -0.02778046f, 0.01667853f, 0.05411514f, 
    0.02030874f, -0.06730026f, -0.05454071f, -0.01082043f, -0.07599881f, 0.01946476f, 0.02062118f, 0.03899188f, 
    -0.08200803f, 0.01297854f, -0.04131883f, -0.04825530f, 0.01764019f, -0.07926967f, 0.03858186f, -0.04983983f, 
    0.04656927f, 0.03644464f, 0.04575838f, -0.02397836f, 0.03735856f, 0.00279215f, -0.02121802f, 0.00141251f, 
    -0.02395400f, -0.00555632f, 0.00212283f, 0.05791983f, -0.04440582f, 0.01527638f, -0.02485244f, 0.06561524f, 
    -0.01665200f, 0.04251248f, -0.00527869f, -0.00022279f, -0.03548521f, -0.01279623f, -0.05540786f, 0.06937119f, 
    -0.02616974f, -0.03949042f, -0.05179745f, -0.01579765f, 0.06007572f, 0.05148343f, -0.07038950f, -0.05131555f, 
    -0.05581818f, -0.04156997f, 0.04826110f, -0.01285269f, 0.04333967f, -0.02581144f, 0.03184577f, -0.07218825f, 
    -0.04371720f, -0.04317155f, -0.02945478f, -0.06663892f, -0.01739030f, 0.04332828f, 0.03908063f, -0.05295837f, 
    -0.36016607f, 0.04571055f, -0.19057904f, -0.19489817f, -0.25025675f, -0.05002908f, 0.08482695f, -0.25566542f, 
    -0.11572531f, 0.03258931f, 0.06724738f, 0.20003822f, -0.10976322f, -0.11317375f, 0.06154923f, 0.40444753f, 
    0.01407293f, 0.02902122f, 0.00656295f, -0.04032428f, 0.16296674f, 0.00039578f, 0.09363181f, 0.07891138f, 
    -0.06078527f, -0.26023042f, -0.11551246f, -0.02852476f, -0.11507519f, 0.02679674f, 0.15951402f, -0.05100423f, 
    -0.07252561f, 0.09144865f, -0.00075781f, 0.07187517f, -0.00563049f, 0.16449644f, 0.05999917f, 0.00598411f, 
    -0.07146630f, -0.16745543f, 0.04902454f, 0.27595294f, -0.10108072f, 0.03682901f, 0.07029577f, -0.03409739f, 
    0.04804121f, 0.13985924f, 0.34770083f, -0.05103629f, -0.20504619f, -0.04999996f, -0.02328588f, 0.00529971f, 
    0.17684396f, 0.11395354f, 0.05643869f, 0.22453679f, -0.14132690f, 0.03819134f, -0.09086046f, 0.01416664f, 
    0.14899772f, -0.01485200f, -0.05462724f, -0.02511627f, 0.04356777f, 0.13662763f, -0.12756938f, 0.11653877f, 
    -0.47098705f, -0.29928800f, 0.09471494f, 0.01336640f, -0.04109835f, 0.13511793f, -0.15921515f, -0.05367590f, 
    -0.03301917f, 0.01539227f, -0.00498331f, -0.11554767f, -0.23270534f, -0.09028157f, -0.29183298f, 0.05794996f, 
    0.04329744f, -0.13477522f, 0.02233987f, -0.02009717f, 0.04895262f, -0.09515456f, -0.00853754f, -0.10775326f, 
    -0.30848727f, 0.23510551f, 0.15902020f, 0.17615068f, -0.14869855f, 0.05215172f, 0.03865430f, 0.00408047f, 
    -0.02920035f, 0.13232735f, -0.00943041f, 0.15405120f, -0.19803241f, -0.19179311f, -0.24140657f, -0.22402158f, 
    0.11960000f, 0.06264605f, -0.01702095f, 0.15930977f, 0.00776992f, 0.02598876f, 0.05194378f, 0.15178846f, 
    0.07829831f, 0.14404707f, 0.31996301f, 0.17837662f, -0.16683646f, -0.10392722f, 0.09073195f, -0.01956083f, 
    -0.20243622f, -0.09323280f, 0.07129660f, -0.06682535f, 0.05022234f, -0.09706533f, 0.09488906f, 0.39657402f, 
    -0.02563129f, -0.02855073f, 0.05028693f, 0.03606714f, -0.05263116f, 0.01145377f, -0.08651599f, -0.02468074f, 
    -0.07656972f, 0.11803608f, 0.08897029f, 0.09098776f, -0.04219947f, -0.09397070f, -0.02873404f, -0.00949510f, 
    -0.00197876f, 0.21597524f, 0.10805585f, 0.12023336f, -0.11090721f, -0.15065689f, 0.03993868f, 0.00949394f, 
    0.08655845f, 0.21155979f, 0.03114140f, 0.07620016f, 0.14543989f, -0.05601953f, 0.04328118f, -0.04495694f, 
    0.07850320f, 0.09289873f, -0.44628298f, 0.00908890f, 0.01750484f, 0.04059318f, 0.15879744f, 0.12845904f, 
    -0.05320973f, 0.04457295f, 0.08002409f, 0.02584111f, 0.11143573f, -0.01239008f, 0.17026360f, 0.08100508f, 
    -0.00158886f, 0.08736932f, 0.02754495f, 0.26655766f, 0.19510522f, 0.00151435f, -0.05686804f, 0.13412623f, 
    0.10548598f, 0.22819987f, -0.17266408f, 0.08975263f, 0.00513973f, -0.03004252f, 0.23230176f, -0.16153033f, 
    0.02639087f, 0.00329765f, -0.05653834f, -0.01438528f, -0.26831421f, -0.34832239f, -0.07284084f, 0.17901374f, 
    0.20483661f, 0.19414921f, 0.00164091f, -0.05921748f, -0.02208595f, -0.00777493f, -0.13822220f, -0.00331534f, 
    0.10313331f, 0.19119565f, 0.15707472f, 0.17286749f, 0.00297224f, 0.05846571f, 0.16296269f, -0.05056695f, 
    0.05146842f, -0.08209287f, 0.05551483f, 0.15840040f, 0.13269405f, 0.14701979f, -0.21161623f, -0.06924610f, 
    -0.15874147f, -0.16669622f, 0.13518751f, 0.05798177f, 0.11980534f, 0.06390948f, 0.21922489f, 0.10598141f, 
    -0.00146184f, 0.04394529f, 0.39167324f, 0.09503628f, 0.17949924f, -0.00069344f, -0.17020503f, -0.13851598f, 
    0.11395887f, 0.04090623f, 0.18348269f, 0.08994976f, 0.53928250f, 0.00010160f, -0.12977755f, 0.06166251f, 
    -0.07960909f, -0.07721442f, -0.06823307f, 0.13594308f, 0.09854585f, 0.09451687f, -0.09241758f, 0.15992221f, 
    -0.18355338f, -0.69504058f, -0.03797870f, 0.14852549f, 0.27211332f, 0.36083186f, 0.26014489f, -0.22310029f, 
    -0.36262560f, 0.03343014f, -0.25160879f, 0.05320256f, 0.02519769f, -0.33728859f, -0.27874005f, 0.05378585f, 
    0.14565374f, 0.05593617f, -0.03465370f, 0.02007639f, 0.23355412f, 0.16069964f, 0.15450959f, 0.26348725f, 
    -0.08436704f, 0.39106569f, 0.30768508f, 0.31523395f, -0.28907999f, -0.08020680f, -0.16708794f, -0.05299848f, 
    0.02441151f, 0.04609535f, 0.10575632f, 0.05027216f, 0.17550917f, 0.18794936f, -0.16482790f, -0.03613114f, 
    0.11952270f, 0.05951338f, 0.00181948f, 0.04336567f, -0.12449561f, -0.07005182f, -0.00576426f, -0.08887871f, 
    0.21745512f, 0.12864791f, 0.25859523f, 0.08513340f, -0.02691905f, -0.04213246f, -0.03123215f, -0.09196948f, 
    0.02591135f, -0.06046208f, -0.00405051f, 0.00825407f, -0.13735764f, -0.04043798f, -0.23264353f, -0.21145189f, 
    -0.08860607f, 0.22960642f, -0.00627592f, -0.25800401f, -0.06903031f, -0.11089352f, -0.13727373f, -0.22070447f, 
    -0.12245601f, 0.15675870f, -0.10365665f, 0.16169953f, 0.01138707f, -0.16454618f, -0.00140019f, -0.05118830f, 
    -0.12037664f, -0.22870384f, -0.15387999f, -0.30893695f, 0.03924515f, -0.06439296f, -0.12043567f, -0.13435106f, 
    0.03001314f, 0.09369230f, -0.01335321f, 0.07980656f, 0.10513689f, 0.18008463f, -0.03534536f, 0.14765969f, 
    -0.16438474f, 0.06570370f, 0.10641735f, -0.00340189f, -0.10712559f, 0.17336138f, -0.05987545f, -0.13297543f, 
    -0.01277779f, 0.03366520f, -0.07872761f, 0.02176681f, 0.30283386f, 0.09253784f, 0.05361460f, 0.13161245f, 
    0.07047006f, -0.22908139f, -0.01945034f, 0.00144140f, -0.03064863f, -0.28309071f, 0.06019020f, -0.07262067f, 
    -0.11182071f, 0.01591631f, -0.11190078f, -0.21220107f, -0.07865168f, -0.01151861f, 0.04275475f, -0.04262730f, 
    0.05348066f, 0.08925696f, 0.10875854f, 0.14202920f, -0.08822803f, 0.06382462f, 0.13948216f, 0.24000554f, 
    -0.05754718f, -0.04365457f, 0.08425426f, 0.03396923f, -0.16033405f, -0.04185335f, -0.09441581f, -0.01282860f, 
    0.00416311f, -0.23043430f, 0.09721807f, -0.05242427f, 0.11225030f, 0.13646178f, 0.01336302f, 0.05020165f, 
    0.06196755f, 0.20640332f, 0.13642301f, 0.14452754f, 0.20445192f, -0.12129097f, -0.08449503f, 0.01010710f, 
    -0.09359723f, 0.03601805f, -0.08159142f, 0.17700815f, -0.07066122f, 0.01104731f, -0.04050317f, -0.15009162f, 
    -0.31518549f, 0.41941094f, -0.25178561f, 0.08900383f, 0.06712570f, 0.01831810f, -0.05533062f, -0.10685116f, 
    0.06049396f, -0.03468501f, 0.19173165f, 0.05608677f, 0.22777377f, -0.10988692f, -0.09460363f, 0.22803669f, 
    -0.17853475f, 0.09673598f, 0.15213551f, -0.06907146f, -0.03121888f, -0.00718117f, 0.06602463f, 0.11428963f, 
    0.38084698f, 0.02312082f, 0.13146077f, 0.07462509f, 0.01332077f, 0.20051993f, -0.00522004f, 0.05273332f, 
    -0.02497137f, 0.07472344f, -0.10325798f, -0.02058158f, -0.02995446f, -0.11986768f, 0.01231551f, 0.03975800f, 
    -0.06778301f, 0.09065145f, 0.06350037f, -0.03014206f, -0.06183876f, -0.06139440f, 0.02577490f, -0.04414553f, 
    0.04139143f, -0.06112356f, -0.15067418f, -0.14239824f, 0.05990120f, -0.01932910f, 0.03918884f, -0.03274475f, 
    -0.00969281f, 0.10162423f, -0.01967039f, 0.03517656f, 0.06934815f, -0.03815096f, -0.06425138f, 0.23170979f, 
    -0.10621835f, -0.10444833f, 0.01502395f, -0.05132699f, 0.02708032f, 0.00753664f, 0.02147651f, -0.13424954f, 
    -0.36491066f, 0.11138898f, -0.04018537f, 0.15396610f, -0.02976800f, -0.07443304f, 0.15686128f, -0.00105825f, 
    -0.04016396f, 0.07715369f, 0.04274478f, 0.03124165f, -0.34397289f, 0.29540107f, -0.35006437f, -0.12929159f, 
    0.21929394f, 0.04917500f, 0.16617201f, 0.04164328f, 0.02446172f, -0.07605395f, 0.00743955f, 0.05379116f, 
    -0.01881206f, 0.00402576f, -0.04450503f, -0.05661629f, -0.01992027f, 0.04086383f, -0.14627296f, -0.00099060f, 
    0.21506830f, -0.03526380f, 0.25643900f, 0.09871752f, -0.26317731f, -0.13109386f, -0.23200406f, 0.17314231f, 
    0.07602080f, 0.00667047f, 0.09985047f, 0.01122475f, 0.00924400f, 0.05408728f, 0.11831030f, -0.00477145f, 
    0.22447585f, -0.01592788f, -0.16537370f, -0.07017307f, 0.14683394f, -0.17025584f, -0.04414656f, -0.25917757f, 
    0.06225763f, 0.20269358f, -0.03717341f, 0.06746334f, -0.12682243f, -0.01855072f, 0.04927447f, 0.05289731f, 
    -0.07479369f, 0.00969623f, -0.11087105f, 0.00270017f, 0.07313410f, 0.10695434f, 0.06033499f, 0.02156632f, 
    -0.03362365f, -0.00071803f, 0.06986950f, 0.19721946f, -0.00888041f, 0.06881159f, 0.05115867f, -0.00325827f, 
    0.01208011f, 0.01131784f, -0.00764605f, -0.06666125f, 0.25917003f, 0.22219761f, -0.00464092f, 0.21899021f, 
    0.08624171f, 0.07677745f, 0.03195745f, 0.05624716f, 0.01898935f, -0.08611739f, 0.00803824f, 0.04924726f, 
    0.11674272f, -0.11104916f, 0.20968364f, 0.07937905f, -0.00587607f, -0.08675232f, 0.00897201f, 0.13762604f, 
    0.06094394f, 0.11767356f, 0.07071649f, -0.08366168f, -0.22482049f, -0.14665867f, -0.12229526f, -0.14869766f, 
    0.01341807f, -0.04254571f, -0.00622082f, -0.13537815f, 0.02488008f, -0.06578597f, -0.24321245f, 0.03090773f, 
    0.17946829f, 0.03559624f, 0.27067128f, 0.02949331f, -0.00248574f, 0.02908746f, 0.13265349f, -0.00587578f, 
    0.06148748f, -0.14849222f, -0.17673200f, -0.03123066f, 0.13175869f, 0.27411044f, -0.19847400f, 0.00745008f, 
    0.02759222f, -0.08777704f, 0.10940711f, 0.16412616f, -0.12558736f, -0.00391725f, 0.08661060f, -0.03603468f, 
    0.29941469f, 0.19186582f, 0.15689833f, 0.26898724f, -0.02293725f, -0.00155184f, -0.12712140f, 0.02152807f, 
    0.01866895f, 0.00502440f, -0.02184761f, -0.01336776f, 0.01214538f, 0.07286667f, 0.03792376f, 0.10278246f, 
    0.11427980f, 0.02946243f, -0.03097976f, 0.04345352f, 0.17890471f, 0.17762801f, 0.15698980f, 0.08891208f, 
    -0.45227781f, -0.01767176f, -0.07673254f, -0.11952592f, -0.06743646f, -0.05212491f, -0.02017819f, 0.12082161f, 
    0.02317685f, -0.23217335f, -0.05143088f, -0.18798371f, 0.24262834f, 0.22432198f, 0.06714039f, -0.10105035f, 
    0.05704612f, 0.13572556f, 0.05882916f, 0.32036322f, -0.05487189f, 0.01638971f, -0.00422662f, 0.01479439f, 
    -0.32039431f, 0.09119392f, -0.05378998f, -0.36308879f, -0.10148498f, 0.04775883f, -0.11901177f, -0.04011261f, 
    0.17664133f, 0.02659112f, 0.01544728f, -0.10452922f, -0.14661865f, -0.04296387f, -0.04032520f, -0.11806353f, 
    0.22795659f, 0.03916162f, 0.09635026f, -0.08518569f, -0.00630581f, -0.07113106f, -0.00815491f, -0.07085267f, 
    0.02832955f, 0.08960867f, 0.13918732f, 0.06253169f, 0.02286942f, -0.06828950f, -0.02101581f, 0.02623068f, 
    -0.00128328f, -0.10749301f, -0.02664977f, -0.02232446f, 0.07265058f, -0.01689546f, -0.36008990f, -0.21549848f, 
    -0.14823388f, -0.12930484f, -0.09388128f, 0.13496943f, 0.09867635f, -0.05441540f, 0.10772679f, 0.14150667f, 
    -0.66787982f, 0.28527012f, 0.29591569f, -0.24898626f, -0.16520040f, -0.32116038f, 0.09873945f, 0.08311549f, 
    0.16046163f, -0.05514430f, 0.03636720f, 0.03805519f, -0.07239686f, -0.28263864f, -0.15676454f, -0.08481742f, 
    -0.07294121f, -0.09162311f, 0.03087258f, -0.08247663f, 0.11168746f, -0.02520356f, -0.23979993f, -0.08526640f, 
    0.02160463f, -0.03673894f, 0.03210806f, -0.12141418f, -0.02824546f, -0.01427448f, -0.00369987f, 0.01086811f, 
    -0.00036345f, -0.01939586f, 0.05953316f, 0.15654005f, 0.19322808f, 0.06687405f, 0.25958344f, 0.07482807f, 
    0.05019643f, -0.03376179f, 0.06385209f, -0.01145070f, -0.06850692f, 0.01245802f, 0.07677439f, -0.09448209f, 
    -0.26290378f, -0.05671982f, -0.16420290f, -0.19753182f, -0.05908153f, -0.17632267f, -0.02453051f, -0.05671735f, 
    -0.02305733f, 0.06591411f, 0.05865368f, 0.04574118f, -0.15873817f, 0.00160938f, -0.13661768f, -0.04221078f, 
    -0.08743104f, 0.06280406f, 0.05658950f, 0.34131074f, -0.05505805f, -0.00457220f, -0.03005610f, 0.07810114f, 
    0.03682936f, -0.01336664f, -0.03810269f, -0.23387741f, 0.00942437f, -0.13809185f, -0.05190483f, 0.02911390f, 
    0.23590438f, 0.10197225f, 0.05026349f, 0.33977729f, -0.22671039f, 0.06484765f, 0.18961665f, 0.48170453f, 
    -0.06260404f, 0.02190647f, 0.16024210f, -0.15847243f, -0.10591090f, -0.03223282f, 0.07684500f, 0.00708515f, 
    0.31965634f, 0.06919247f, 0.00111388f, 0.10608860f, 0.00054761f, 0.01095084f, 0.01122151f, 0.11385377f, 
    0.02458039f, 0.10577395f, -0.02541098f, 0.02365999f, 0.02242387f, -0.04227781f, -0.10245559f, 0.10673910f, 
    0.06132507f, -0.05265229f, 0.00101466f, 0.00410510f, -0.08021981f, 0.02281863f, 0.04405918f, -0.04913810f, 
    -0.05453856f, -0.15190780f, -0.14231522f, -0.19118229f, -0.06516253f, 0.04989227f, -0.02303775f, 0.09886163f, 
    0.14340509f, -0.04761986f, 0.02563842f, 0.02359935f, 0.18983328f, 0.03620717f, 0.11249937f, 0.07408129f, 
    -0.18174335f, -0.05536370f, 0.10571116f, -0.24468245f, 0.00947286f, -0.00572908f, -0.03519668f, -0.12622803f, 
    -0.12270817f, -0.18523571f, -0.12192320f, 0.21614575f, 0.01006688f, -0.05181414f, 0.12715851f, -0.06319005f, 
    0.11239293f, -0.17347704f, 0.04164631f, -0.16528633f, 0.07677919f, 0.04668853f, -0.06402098f, -0.16391578f, 
    0.05110167f, -0.12610018f, 0.36078095f, -0.09197553f, 0.00308863f, 0.05550440f, -0.05591441f, 0.01140494f, 
    0.05208851f, 0.01812056f, 0.00739962f, 0.11465438f, 0.09311378f, 0.03394081f, -0.02047616f, 0.11611133f, 
    0.14153229f, -0.08790907f, 0.06184909f, 0.13916340f, -0.33638105f, -0.08603213f, -0.17639852f, 0.00190596f, 
    0.00439336f, 0.06457260f, 0.11507988f, -0.17162968f, -0.01390957f, 0.03912948f, 0.12275055f, -0.01147768f, 
    0.25360516f, -0.18770634f, -0.15277943f, 0.25988823f, 0.06383328f, -0.11114887f, 0.05261481f, -0.01303446f, 
    0.04491198f, 0.12981009f, -0.06608607f, -0.02657679f, -0.27505764f, -0.13807893f, -0.11637846f, -0.13674942f, 
    -0.02893220f, 0.07716365f, 0.01527724f, 0.06165980f, -0.08224215f, 0.11545856f, 0.17614537f, 0.03035524f, 
    0.09138736f, 0.14306375f, -0.14476700f, 0.00855208f, -0.20857286f, -0.17408869f, 0.17284121f, -0.06991535f, 
    -0.10270339f, -0.01459064f, 0.07123264f, -0.01208446f, 0.38363755f, -0.19827615f, -0.23085670f, 0.10883443f, 
    0.13373375f, 0.06345538f, 0.06014572f, 0.03196139f, 0.02573515f, -0.00680833f, -0.01862962f, 0.02376102f, 
    -0.04041606f, 0.09511052f, -0.16249150f, 0.09103540f, 0.01668802f, 0.08006136f, 0.20515607f, -0.13068233f, 
    -0.01417154f, -0.05860858f, -0.04784882f, 0.07443999f, -0.20125306f, 0.14853579f, -0.04749349f, -0.09844434f, 
    -0.06467255f, -0.18902494f, 0.10485572f, 0.20715800f, 0.09539578f, 0.00378474f, 0.03313569f, -0.05739149f, 
    -0.08887266f, -0.24558692f, 0.46020254f, -0.05086440f, -0.08831719f, -0.01366702f, 0.00474893f, 0.01981088f, 
    0.18131877f, 0.21402411f, -0.12152739f, 0.07176261f, -0.06687932f, 0.17864780f, 0.22382180f, 0.15534510f, 
    0.11655116f, 0.06023376f, 0.01986101f, -0.01377178f, 0.01491202f, 0.05102100f, -0.14581083f, 0.08481359f, 
    -0.29265758f, -0.38473147f, -0.03324831f, -0.22354051f, 0.15898761f, 0.17211451f, -0.08627136f, 0.18518452f, 
    -0.14552571f, -0.06438305f, 0.12192117f, -0.09530392f, -0.03102666f, -0.00639880f, -0.28413045f, 0.12062265f, 
    0.09141839f, -0.06357932f, -0.03177473f, 0.06722593f, -0.06664057f, -0.05502030f, -0.03018956f, -0.07039072f, 
    -0.31312644f, 0.10791430f, 0.02135611f, -0.06087388f, -0.11840680f, -0.11193553f, -0.02333282f, 0.04683982f, 
    0.09745092f, -0.01082683f, -0.04391111f, -0.08033296f, -0.14178455f, 0.05560378f, 0.02539383f, 0.04765309f, 
    0.12302061f, 0.14191663f, 0.00763253f, 0.13571650f, -0.03915650f, -0.03176981f, 0.05871943f, 0.11891024f, 
    0.09646876f, -0.00867792f, 0.14399415f, 0.10021386f, -0.18904172f, -0.03652401f, 0.00763437f, -0.05327687f, 
    -0.16595925f, -0.01902323f, 0.27266255f, 0.05791873f, -0.24862584f, -0.35162067f, 0.16037865f, 0.14344248f, 
    -0.17687137f, 0.01747344f, -0.01424333f, -0.07357530f, -0.04221374f, 0.18910258f, -0.02769337f, 0.02201261f, 
    0.01188255f, 0.08040319f, -0.09410806f, 0.02708207f, 0.00032439f, 0.02117609f, -0.00430038f, -0.00692121f, 
    0.10490188f, 0.11891593f, -0.11107226f, 0.14484538f, -0.07451130f, 0.02244769f, 0.05278270f, -0.09203549f, 
    0.04116212f, 0.10084382f, 0.03768309f, 0.01913344f, -0.03907033f, 0.00138962f, -0.07979465f, 0.01159191f, 
    -0.30692595f, -0.08959083f, -0.01473012f, 0.14105384f, 0.04487063f, 0.08796239f, 0.10631290f, 0.21636838f, 
    0.04868798f, 0.04954164f, -0.05173801f, 0.10992739f, 0.08832248f, 0.10449008f, 0.02070387f, -0.10224077f, 
    0.02879832f, -0.09843343f, 0.06517868f, -0.04383087f, 0.18189165f, -0.07720786f, -0.07953195f, 0.10661779f, 
    0.00078057f, 0.00315191f, 0.06461548f, -0.13251369f, -0.04519409f, -0.09688126f, -0.09498252f, -0.16725676f, 
    -0.03200152f, 0.00544124f, 0.10176418f, 0.14786735f, 0.37229452f, -0.09774216f, 0.03799674f, 0.06097332f, 
    -0.14844592f, -0.02217419f, 0.01236242f, -0.09192276f, -0.01674961f, -0.05665713f, 0.06786199f, -0.01069832f, 
    -0.15745717f, 0.06645886f, -0.07636857f, -0.14755453f, 0.04681077f, 0.03277536f, -0.08026228f, 0.01015786f, 
    -0.01950448f, -0.01552518f, 0.10366742f, -0.03900420f, -0.31904629f, 0.10749456f, -0.07804979f, -0.09998653f, 
    0.00138353f, 0.22046337f, -0.03389001f, 0.18323809f, 0.02200883f, -0.04254860f, -0.00877192f, -0.15348199f, 
    0.33105454f, -0.18382628f, 0.02909880f, -0.00989890f, -0.06016735f, -0.19490823f, -0.04852074f, -0.12732774f, 
    0.23196781f, 0.01146214f, 0.02073570f, 0.12265564f, 0.07913281f, 0.10943340f, -0.04131997f, -0.07045779f, 
    -0.11695799f, -0.02868934f, 0.12103438f, -0.21567912f, 0.04203078f, -0.03932420f, 0.07122038f, 0.09873777f, 
    0.04551744f, -0.13222785f, -0.05757607f, -0.12606913f, 0.03419554f, 0.08279888f, -0.03445897f, 0.01660790f, 
    -0.13124490f, 0.03806640f, -0.07176366f, -0.00019425f, -0.03505688f, -0.07729722f, -0.08848249f, -0.12993491f, 
    0.03918268f, 0.03846607f, 0.03149711f, 0.10026331f, -0.06916045f, -0.15199731f, -0.01605405f, -0.19752270f, 
    -0.34937137f, 0.14077903f, 0.04059356f, -0.30469072f, -0.09324314f, 0.06416120f, 0.06204409f, -0.03117459f, 
    0.09177282f, 0.04111803f, 0.04877216f, 0.15271595f, 0.20479275f, 0.14107691f, 0.07940975f, -0.14916144f, 
    0.12164297f, 0.04486120f, 0.04573321f, -0.02378044f, 0.01915482f, -0.07720190f, 0.02595247f, -0.06634995f, 
    -0.35534197f, -0.16334529f, -0.06045242f, 0.03208206f, 0.00997532f, 0.09252455f, 0.00703879f, -0.05320054f, 
    0.06404869f, -0.02721166f, 0.12950975f, -0.03664816f, 0.24687800f, -0.09323642f, -0.05918641f, -0.12455389f, 
    0.04993297f, -0.06196164f, 0.07917579f, 0.21592234f, 0.00097024f, 0.01742324f, -0.07455669f, 0.04550929f, 
    0.02235453f, 0.04717805f, 0.04459064f, -0.00861216f, -0.05556935f, -0.02070590f, -0.00155125f, -0.02461516f, 
    0.14788482f, -0.04616925f, 0.13398029f, 0.08804144f, 0.31130478f, 0.14836000f, 0.06642620f, -0.11386483f, 
    0.07043289f, 0.00559194f, 0.07045096f, 0.06304608f, -0.01105654f, 0.07652660f, 0.05912652f, -0.00790546f, 
    0.12445167f, -0.06771854f, 0.40090504f, 0.11923895f, -0.04115650f, 0.26223817f, 0.04764896f, 0.17789230f, 
    0.02762581f, 0.06544204f, 0.18348184f, -0.03112286f, -0.23587592f, 0.07743052f, -0.14140478f, -0.17799726f, 
    -0.01027249f, 0.17174807f, 0.01480140f, 0.06902175f, 0.14127184f, 0.17474379f, 0.13359153f, 0.12038681f, 
    0.03732077f, 0.12977383f, -0.04852329f, 0.07455003f, -0.13868551f, -0.10987867f, -0.10720491f, -0.07597338f, 
    0.02226084f, -0.04485572f, 0.10648354f, 0.12328055f, 0.53014016f, 0.02974526f, -0.03387646f, -0.04157187f, 
    -0.04271754f, -0.07858776f, -0.08018270f, -0.06707918f, 0.13079917f, -0.00342630f, 0.00971222f, 0.07975234f, 
    -0.17880848f, -0.04433296f, -0.13555142f, -0.15071742f, 0.01322742f, 0.12907319f, -0.00476310f, 0.15299340f, 
    -0.05138103f, 0.02541606f, -0.11195297f, 0.00125098f, -0.08426053f, 0.12593713f, -0.11510042f, -0.04717635f, 
    0.01545969f, 0.00949912f, 0.01934008f, 0.09836567f, 0.00914710f, -0.07951077f, 0.02632699f, -0.13872935f, 
    0.14574911f, 0.00774813f, 0.13476014f, 0.20346709f, -0.05521609f, -0.05718479f, -0.14403318f, 0.02809332f, 
    0.11303443f, 0.05027614f, -0.15242597f, -0.05764770f, -0.13295823f, -0.26054716f, 0.08869604f, -0.10530552f, 
    0.17350771f, 0.14451218f, -0.14159961f, -0.11942615f, 0.06785733f, -0.11717092f, 0.06829254f, 0.03475621f, 
    -0.19287883f, -0.28491256f, -0.21260600f, -0.09512711f, 0.03996775f, -0.11701100f, -0.01413950f, -0.02898439f, 
    0.00981346f, -0.10546751f, -0.03084465f, -0.02431417f, -0.08411547f, -0.03912995f, -0.04431043f, -0.22293058f, 
    0.03626878f, -0.02051582f, 0.00127752f, 0.06382171f, 0.10869270f, -0.05171002f, -0.04044162f, -0.09103666f, 
    -0.40566668f, 0.22079936f, 0.10658389f, -0.03750101f, -0.01602247f, -0.02945256f, -0.05387462f, -0.04810837f, 
    -0.16040638f, 0.08029584f, 0.06394713f, 0.02657680f, -0.09989434f, 0.00233527f, -0.08520172f, -0.08261867f, 
    0.13766341f, 0.08740526f, 0.05173142f, 0.01821783f, -0.08391748f, -0.04631481f, -0.02396752f, 0.02242202f, 
    -0.30474904f, -0.25318435f, 0.10401038f, -0.02620650f, 0.02937856f, -0.15355054f, -0.21958698f, 0.23209697f, 
    0.00991656f, 0.03310649f, 0.14018005f, -0.01025088f, -0.08311968f, -0.03391603f, 0.27574334f, 0.11646948f, 
    0.15232715f, 0.06659006f, -0.02026680f, 0.20494227f, -0.00812407f, 0.01532942f, -0.08644232f, 0.06025029f, 
    -0.00971369f, -0.03479442f, 0.06253708f, 0.08982620f, 0.04286180f, 0.00665207f, 0.11433457f, -0.02728419f, 
    0.08395728f, 0.02296145f, 0.13883021f, 0.10032711f, 0.14593945f, 0.13631624f, 0.18619782f, -0.04170347f, 
    0.02308865f, 0.01368450f, 0.05486725f, 0.10637915f, 0.05370742f, 0.03477719f, 0.01426683f, -0.00155360f, 
    -0.26750270f, -0.31244278f, 0.30204773f, 0.14320372f, -0.06049528f, 0.10853445f, 0.06889855f, 0.37013090f, 
    0.16144080f, 0.10119420f, 0.10302058f, -0.08213744f, -0.12937582f, 0.39297920f, -0.03780951f, -0.23709118f, 
    -0.11897533f, 0.01254023f, 0.11418832f, 0.24682336f, 0.11768854f, 0.00088674f, 0.11344159f, -0.10876311f, 
    0.01029300f, 0.10739651f, 0.13382909f, 0.05888129f, -0.02180486f, 0.03597245f, -0.11178437f, 0.00694259f, 
    -0.14225328f, -0.01892931f, 0.03775287f, -0.00606892f, 0.34601483f, 0.20289670f, 0.26629236f, 0.31391621f, 
    -0.10736527f, -0.05933376f, 0.13125578f, -0.02010342f, 0.00949521f, 0.06061757f, -0.00681349f, 0.05002725f, 
    0.00279763f, -0.51603705f, 0.02923121f, -0.37720147f, 0.06944267f, -0.06082346f, -0.11021443f, -0.03717080f, 
    -0.02228604f, -0.01638986f, 0.22496994f, 0.03430531f, -0.10541498f, -0.26093659f, -0.28498971f, -0.13540971f, 
    0.03450051f, 0.01583944f, 0.02447310f, 0.16286738f, 0.10052707f, -0.03100866f, -0.01047954f, 0.06101101f, 
    0.27882552f, -0.05697370f, 0.00312718f, -0.06013371f, 0.06810398f, 0.01318363f, 0.02661839f, -0.10116851f, 
    -0.00928396f, 0.02823313f, 0.17746079f, 0.21569537f, -0.45372492f, 0.00869856f, -0.32165316f, 0.32049224f, 
    -0.14784598f, 0.12983634f, 0.06671529f, 0.00872591f, -0.05614844f, -0.13531384f, -0.00762077f, -0.09676714f, 
    0.48521742f, 0.33046010f, 0.11405823f, 0.25504816f, 0.04231586f, 0.07561643f, 0.04258731f, 0.17837770f, 
    -0.08641158f, -0.03599343f, -0.09523598f, 0.08193189f, -0.02959239f, 0.01714296f, 0.00619362f, 0.18379891f, 
    -0.05118591f, -0.00894386f, 0.03146984f, -0.10254816f, 0.23216334f, 0.16248769f, 0.12499011f, 0.05040904f, 
    -0.25463477f, -0.07781526f, -0.30212501f, -0.46919277f, -0.08145756f, 0.05428624f, -0.02419081f, -0.01603002f, 
    -0.04840521f, 0.00509227f, 0.09727450f, 0.15535744f, 0.05433550f, 0.10111874f, -0.18405208f, -0.12779830f, 
    0.03979738f, 0.04755623f, -0.09137081f, -0.09734610f, -0.02643033f, -0.00882553f, 0.01125634f, -0.08648486f, 
    -0.46487269f, 0.15046664f, -0.38246438f, 0.25992948f, -0.06521751f, -0.14837003f, 0.19851042f, 0.04673850f, 
    -0.05864862f, 0.00272950f, -0.04747579f, -0.02651440f, -0.19144684f, -0.08627126f, -0.40896249f, -0.28042531f, 
    0.37483960f, 0.04172676f, 0.23511812f, -0.02580623f, -0.16231360f, -0.07856662f, -0.14378592f, 0.13539617f, 
    0.16847898f, 0.06604665f, 0.08370185f, 0.05870954f, 0.03914446f, 0.00518336f, -0.17437398f, 0.05342134f, 
    0.04964468f, -0.05833373f, 0.14043134f, -0.03817374f, -0.18599162f, -0.02313469f, -0.62214488f, 0.07888415f, 
    0.06026769f, 0.06606009f, -0.09553400f, -0.00188900f, 0.06218677f, 0.11890090f, 0.21253888f, 0.04935426f, 
    0.16877471f, 0.46748516f, -0.24622926f, -0.00922703f, 0.07495396f, -0.06139845f, 0.11093330f, -0.09947509f, 
    0.00448513f, 0.10066870f, 0.28185579f, 0.02195758f, -0.40257832f, -0.55297792f, 0.02132596f, 0.05630118f, 
    -0.04373309f, -0.03541557f, 0.09084093f, 0.12108841f, 0.09990814f, 0.07370266f, 0.18788484f, 0.11867992f, 
    -0.02697930f, 0.06984653f, -0.01575230f, -0.06794993f, -0.04036178f, -0.03506192f, -0.03784255f, -0.04362017f, 
    -0.06182015f, -0.04679254f, -0.04863304f, -0.01829882f, 0.06389713f, 0.04333314f, 0.02742816f, -0.06570084f, 
    0.03294517f, 0.02370747f, -0.01451863f, 0.03186099f, -0.10050833f, -0.06653255f, 0.05143009f, -0.06465851f, 
    -0.05268481f, -0.08123062f, 0.00339947f, 0.02395645f, -0.00436787f, -0.08251052f, 0.00691100f, -0.07733031f, 
    -0.08161340f, 0.01634643f, -0.02740826f, -0.07089291f, -0.02169705f, -0.00372794f, 0.03457495f, 0.02036528f, 
    0.02261318f, -0.00304278f, -0.00578812f, -0.02012277f, 0.00800015f, -0.03207937f, 0.00440069f, 0.03995711f, 
    0.04742550f, -0.01696241f, -0.01506348f, -0.05186360f, -0.06561949f, 0.06724619f, -0.03034810f, -0.01201199f, 
    -0.02051302f, -0.00437323f, -0.05400598f, 0.02693102f, -0.01378992f, -0.03128309f, -0.03610072f, 0.05484497f, 
    -0.02919205f, 0.01123156f, 0.05453369f, -0.00961159f, -0.04217119f, -0.06678265f, -0.03203459f, -0.00615682f, 
    -0.00827482f, 0.03570197f, -0.04093133f, -0.02398245f, 0.04199157f, -0.02447563f, -0.00085058f, 0.00866645f, 
    0.06729057f, -0.06416874f, -0.02300935f, 0.07076948f, 0.02721801f, -0.02018620f, 0.01493814f, 0.06437010f, 
    -0.00680161f, -0.09946634f, -0.01246934f, -0.01497810f, -0.02193554f, 0.00535414f, -0.04500405f, -0.06518715f, 
    -0.00648797f, 0.01394183f, 0.01676026f, -0.06941818f, -0.09327309f, 0.03219606f, 0.00100459f, -0.01511915f, 
    0.00646793f, -0.05949276f, -0.08495236f, 0.03968482f, -0.09097954f, -0.05203357f, -0.07479723f, 0.06523774f, 
    -0.00774080f, 0.03469392f, 0.01761551f, -0.05255195f, -0.05923957f, -0.08365680f, -0.06793882f, 0.04957344f, 
    -0.04604498f, 0.04441510f, -0.05305552f, -0.07644185f, 0.02324843f, 0.01509086f, -0.00526296f, 0.08709621f, 
    -0.03521692f, 0.02127799f, -0.06542113f, -0.08657557f, -0.01373016f, 0.05159773f, 0.06180135f, 0.06200607f, 
    -0.02416359f, 0.01383496f, 0.04654174f, -0.05272333f, 0.03372403f, -0.04151117f, -0.00490221f, -0.01166531f, 
    0.04013079f, -0.06091779f, 0.00164895f, -0.06931030f, 0.07698517f, -0.01442677f, 0.00372576f, 0.03452063f, 
    0.03311900f, -0.00159329f, -0.07166288f, 0.05860313f, 0.02028975f, -0.03547590f, 0.03803247f, -0.05659319f, 
    -0.06959216f, -0.00209166f, -0.09994373f, -0.09011915f, 0.00692885f, -0.05427607f, -0.03828922f, 0.03364982f, 
    0.04740248f, 0.03798286f, 0.03633774f, 0.03752446f, 0.04337294f, 0.00412714f, 0.02751776f, 0.00752021f, 
    0.00038096f, -0.10777199f, 0.00413539f, -0.08369096f, -0.03802199f, -0.08283515f, -0.03430824f, 0.02620174f, 
    -0.02184929f, -0.06762266f, -0.02270968f, -0.08898222f, -0.05790396f, 0.01457551f, 0.00487937f, 0.02358599f, 
    -0.06612635f, 0.03141059f, -0.02432026f, -0.04798470f, -0.05591822f, -0.04060035f, -0.00513287f, -0.02208240f, 
    -0.04442134f, -0.07070509f, -0.01198101f, 0.03007700f, -0.01412579f, 0.04832339f, 0.05024763f, 0.06421179f, 
    -0.04318351f, -0.01550585f, 0.03895077f, 0.04311598f, -0.00614498f, -0.06550352f, 0.00471770f, 0.02871367f, 
    -0.02604497f, -0.04112919f, -0.01050906f, -0.03713395f, 0.05630638f, 0.05923485f, 0.04075025f, 0.06386976f, 
    0.00045350f, 0.03288222f, -0.01549662f, -0.03663575f, 0.02452096f, -0.05498734f, -0.04906082f, 0.03027687f, 
    -0.03539785f, 0.00590615f, -0.02287608f, 0.00269398f, -0.02793016f, 0.05128352f, -0.00443410f, -0.02738391f, 
    -0.00365878f, 0.03528563f, -0.05739516f, -0.07688583f, -0.02706754f, -0.03204640f, -0.07510052f, -0.07202286f, 
    -0.03666706f, -0.00783356f, 0.02328110f, -0.01587709f, 0.01114937f, 0.05267950f, -0.05969442f, -0.03350081f, 
    -0.05026247f, -0.07732157f, 0.02649998f, -0.00358268f, 0.01453163f, -0.06466782f, 0.00878472f, -0.03287682f, 
    0.06411588f, -0.04478249f, 0.03742664f, -0.05990342f, -0.06232104f, 0.00666194f, -0.07570111f, 0.02213295f, 
    0.06131420f, -0.06924590f, -0.00003442f, 0.00954502f, 0.05164932f, 0.04847421f, -0.03560929f, 0.01393506f, 
    0.00790655f, -0.06883211f, -0.05536501f, 0.01187465f, 0.05532117f, -0.05834914f, 0.02184774f, -0.00318381f, 
    0.00145434f, -0.06070151f, -0.06570251f, 0.02090128f, 0.04076478f, -0.03565535f, -0.04861766f, -0.07421927f, 
    -0.02913921f, -0.00199276f, -0.01497139f, 0.05306523f, -0.03151115f, 0.07189330f, 0.04561186f, 0.00918377f, 
    0.06222080f, 0.05162861f, -0.01673104f, -0.03643302f, -0.07021589f, -0.06700522f, -0.06480647f, 0.01900235f, 
    0.01208638f, 0.02169104f, 0.01406520f, -0.06783553f, 0.00075957f, 0.06056420f, 0.02213285f, -0.02304462f, 
    0.03518096f, -0.02050817f, -0.04640226f, -0.01742672f, 0.02227560f, -0.04550862f, 0.02599633f, -0.03069800f, 
    0.01517380f, 0.05642094f, 0.03166725f, -0.02678020f, -0.02152773f, -0.06309935f, 0.00157656f, -0.02537977f, 
    0.04009132f, -0.00693054f, -0.05335584f, -0.07394101f, 0.01531461f, -0.01256694f, 0.05184369f, -0.06723824f, 
    -0.05284014f, -0.05199682f, -0.06741234f, -0.01843066f, 0.02386415f, -0.06741167f, -0.05225946f, 0.01594413f, 
    0.03159842f, -0.03538810f, 0.04986857f, -0.06052405f, -0.04955237f, -0.01312056f, -0.03985727f, 0.05495646f, 
    0.01072828f, -0.05263487f, 0.04913461f, -0.06046093f, -0.05703558f, 0.01343651f, -0.00951333f, -0.07147015f, 
    -0.00937485f, -0.05430710f, -0.03970007f, 0.00688765f, 0.00088507f, 0.04722322f, 0.01286290f, -0.05278888f, 
    -0.04309521f, 0.01506919f, -0.04122715f, 0.00030871f, -0.07581823f, 0.02951433f, 0.01891291f, 0.01282920f, 
    0.02716210f, -0.07023899f, -0.06948616f, -0.01368269f, -0.06586329f, 0.03026943f, -0.00222727f, -0.04525790f, 
    -0.03915279f, 0.02043125f, 0.01643852f, -0.06599115f, -0.06580708f, -0.07047541f, 0.03445799f, 0.05831062f, 
    -0.06660321f, -0.01619926f, -0.08142085f, 0.05468634f, 0.04014659f, 0.01088150f, -0.03916996f, 0.03346965f, 
    -0.05893027f, -0.02520082f, -0.01339488f, 0.00540546f, -0.05372294f, -0.01073585f, -0.01016779f, -0.04228071f, 
    -0.05013442f, 0.02569811f, 0.00511823f, 0.04310726f, -0.07473543f, 0.00890295f, -0.01598549f, -0.08151093f, 
    -0.07414225f, -0.03228549f, -0.07413171f, 0.04400437f, -0.00654737f, -0.00017284f, -0.05515584f, -0.03297573f, 
    0.03916948f, -0.00413701f, 0.05157703f, 0.01305983f, -0.06654099f, 0.04696979f, 0.05281861f, -0.00548143f, 
    -0.05724720f, -0.04821996f, -0.02342638f, -0.02392689f, 0.05360742f, -0.07489010f, 0.05272670f, 0.03093522f, 
    -0.03282415f, -0.07255735f, -0.01615797f, 0.05604766f, 0.05081322f, -0.02373105f, 0.00938754f, -0.07459301f, 
    0.01458075f, -0.05946042f, -0.06306720f, -0.02200841f, 0.01954009f, -0.01622658f, -0.03978341f, -0.04444842f, 
    -0.03843573f, -0.04095009f, -0.03389590f, -0.04245884f, 0.02471777f, 0.03884023f, -0.00472715f, 0.02767865f, 
    -0.03675862f, -0.02794174f, 0.00151372f, 0.03831674f, -0.06125093f, -0.05751701f, -0.01045540f, 0.00666463f, 
    0.05562449f, -0.01109713f, -0.05238657f, -0.04609495f, -0.02049110f, 0.01088453f, 0.03421142f, 0.01160280f, 
    -0.03760524f, 0.05994761f, 0.04443140f, -0.04683488f, -0.05203658f, 0.03495307f, -0.04680946f, -0.03113256f, 
    -0.07441933f, -0.04195205f, -0.03520219f, -0.04802831f, -0.00257785f, -0.07088080f, -0.06104350f, 0.04260967f, 
    -0.06468047f, -0.00695687f, -0.02036452f, 0.02022178f, 0.01028736f, -0.00365995f, 0.06004448f, -0.02790240f, 
    0.02747744f, 0.04529793f, 0.00584337f, -0.01380094f, -0.06740453f, 0.04969490f, 0.03897329f, 0.03201811f, 
    -0.04825239f, -0.05355723f, -0.05781524f, 0.00108127f, -0.04786142f, 0.05782260f, -0.08363177f, 0.00073112f, 
    -0.03020722f, -0.02273974f, -0.05564300f, 0.02445590f, -0.06776203f, -0.06252416f, 0.04585385f, -0.05631784f, 
    0.01575088f, 0.00596226f, 0.00020375f, -0.02287110f, -0.06298696f, -0.01953279f, 0.00837587f, 0.02782410f, 
    -0.07087467f, -0.06066522f, -0.06044148f, -0.02108519f, 0.00933492f, 0.06928948f, -0.02574816f, -0.04767194f, 
    -0.03713020f, -0.05963981f, -0.00338832f, 0.04406497f, -0.00547687f, -0.06933612f, 0.05245636f, 0.00006449f, 
    -0.02749735f, -0.07169918f, -0.03209837f, -0.00339535f, -0.06336182f, 0.01093029f, -0.05555897f, -0.06033709f, 
    -0.07004724f, -0.06467368f, -0.01693338f, 0.03451893f, -0.01351485f, -0.00245852f, -0.05383789f, 0.00591623f, 
    -0.08762219f, 0.02321975f, 0.17006032f, -0.02820786f, -0.00397965f, 0.03225565f, -0.03221730f, -0.05024858f, 
    -0.01498529f, -0.00842440f, 0.09028324f, -0.00572559f, -0.39980638f, 0.18384154f, 0.10730232f, 0.10848329f, 
    -0.12276256f, -0.05842430f, -0.15212648f, 0.01659251f, -0.03817984f, -0.10374615f, -0.04445316f, 0.07710114f, 
    0.05173182f, -0.07086438f, 0.08596630f, 0.04972332f, -0.13449192f, -0.04058477f, -0.01045150f, 0.23064008f, 
    -0.11692042f, -0.18047410f, -0.04807056f, 0.04229247f, 0.15706860f, -0.31548947f, 0.13465881f, 0.30709574f, 
    0.17206033f, 0.26316616f, -0.00606679f, 0.00129252f, -0.00828792f, -0.02932914f, 0.00460944f, 0.05989986f, 
    0.27123851f, 0.33888727f, -0.12810817f, -0.40430075f, -0.07884994f, -0.00255570f, -0.05881722f, 0.13342649f, 
    0.03590027f, -0.03799042f, 0.03177394f, 0.02963044f, -0.32386908f, -0.22021316f, -0.09974387f, 0.02528476f, 
    0.13344786f, 0.15081766f, 0.03644317f, 0.10958038f, -0.08351281f, 0.01244110f, 0.00695380f, 0.05629197f, 
    -0.50942963f, 0.15292738f, 0.09026852f, 0.14915594f, -0.18031245f, -0.11089085f, 0.12290243f, -0.10937425f, 
    0.06950404f, -0.00557994f, 0.04093493f, 0.14404906f, -0.13813010f, 0.10418776f, 0.10772716f, -0.07941440f, 
    -0.01308306f, 0.01296356f, -0.08416891f, -0.05207983f, 0.02370188f, 0.04046044f, 0.02822617f, 0.01804352f, 
    0.44698068f, 0.06537062f, -0.12451689f, -0.30759689f, 0.07848632f, 0.08080161f, 0.14458296f, 0.00592820f, 
    -0.10007434f, 0.14898521f, -0.07506136f, 0.02071020f, 0.03573975f, -0.23340125f, -0.26269862f, -0.07489145f, 
    0.12815282f, 0.13071628f, 0.07334393f, -0.00463619f, 0.00041989f, 0.02836150f, -0.00695594f, -0.02699347f, 
    0.07108622f, -0.21003465f, 0.02761919f, 0.03905980f, 0.10411901f, 0.09065145f, 0.14015172f, 0.12743284f, 
    -0.07436150f, 0.02327360f, 0.00820662f, -0.08278809f, 0.27213427f, 0.25836208f, 0.09752953f, -0.17312500f, 
    0.03071507f, -0.11562514f, -0.06402043f, 0.06237432f, -0.13532884f, 0.11372879f, -0.06547248f, 0.00381290f, 
    0.03786303f, 0.05689155f, 0.08312640f, 0.01463006f, -0.01839283f, 0.01192009f, 0.07778899f, 0.01171913f, 
    0.10232052f, -0.00352180f, 0.02027791f, -0.11939047f, -0.02833012f, 0.05574416f, 0.01697305f, 0.06233997f, 
    0.05328993f, 0.03996620f, 0.10811580f, -0.06720538f, 0.00110109f, -0.06871683f, -0.01339551f, -0.09796242f, 
    0.46035314f, 0.04295107f, 0.10990907f, -0.42265579f, 0.00221438f, 0.11139245f, -0.09256448f, 0.19223377f, 
    0.06996720f, -0.02042925f, 0.13032661f, 0.05888220f, 0.22642700f, -0.15602954f, 0.02799328f, 0.09486570f, 
    0.05896468f, 0.20126905f, -0.04622480f, 0.05712800f, -0.15591256f, 0.07220387f, 0.12672471f, 0.11240870f, 
    0.30233017f, 0.14630418f, -0.00255029f, -0.03004303f, -0.06467499f, -0.02428396f, -0.05961835f, -0.01915605f, 
    0.13876064f, -0.09293519f, -0.05021528f, -0.22419696f, 0.46375811f, 0.19375654f, 0.13465115f, -0.05561467f, 
    0.15943849f, 0.00285995f, 0.15146068f, 0.00343383f, -0.00797973f, 0.05082659f, -0.06694183f, -0.04900297f, 
    -0.03309890f, -0.17075881f, -0.06555108f, 0.12855747f, -0.00178467f, -0.11908384f, 0.05216781f, -0.13501163f, 
    -0.00052030f, 0.02893097f, -0.06603359f, 0.05771661f, 0.19974118f, -0.03093855f, -0.19827858f, -0.06470685f, 
    -0.05676022f, -0.06379654f, -0.01621936f, -0.07244549f, 0.15154697f, -0.02249193f, 0.04451543f, 0.11889450f, 
    -0.14972375f, 0.07412200f, 0.14554124f, 0.22224922f, 0.05834526f, 0.00812088f, 0.01335082f, -0.08100617f, 
    -0.03381646f, 0.19073544f, 0.05027131f, -0.05787718f, -0.16737315f, -0.00823969f, 0.26100606f, 0.42003930f, 
    0.02267740f, 0.11546072f, 0.03280178f, -0.04353677f, -0.01663486f, -0.14492904f, 0.08760209f, 0.01497905f, 
    0.36630237f, -0.13238743f, 0.06501877f, 0.09405281f, 0.14770012f, -0.01328430f, 0.02062102f, 0.04779216f, 
    -0.01779958f, 0.02643728f, -0.00871239f, -0.04886340f, 0.23915128f, 0.03820531f, 0.06211742f, 0.05857513f, 
    -0.04987565f, 0.02739072f, 0.09168182f, 0.08823586f, 0.14072971f, 0.05358509f, 0.24777664f, 0.09927675f, 
    -0.01630419f, -0.14931689f, 0.04029070f, -0.00760714f, 0.02269335f, -0.16167766f, -0.12071078f, -0.14153357f, 
    -0.02417795f, -0.01628652f, 0.21784317f, -0.11574098f, -0.17189012f, -0.05161711f, 0.11304395f, 0.27386206f, 
    -0.16153900f, -0.05739034f, 0.11708052f, -0.06368036f, 0.03195311f, 0.06507463f, -0.02691785f, -0.05001724f, 
    0.09646858f, 0.11060381f, 0.09444788f, 0.03772099f, 0.04571274f, -0.24325041f, -0.14848328f, 0.13035579f, 
    0.02355330f, 0.06531401f, 0.08488038f, 0.07673801f, -0.23623480f, -0.09135873f, -0.09614397f, -0.05394041f, 
    0.08716848f, 0.07377426f, -0.01504941f, -0.17692088f, -0.10736510f, 0.09188173f, 0.09737606f, -0.01944442f, 
    0.15623778f, -0.05676355f, -0.09340760f, 0.04383406f, 0.07075980f, 0.11147451f, -0.00758775f, -0.02189201f, 
    -0.07557812f, -0.04258393f, -0.08357345f, -0.17625993f, -0.22645503f, 0.00181386f, 0.06174526f, 0.20636125f, 
    -0.05924072f, -0.01740321f, -0.07433068f, 0.06980065f, -0.08844007f, 0.07335836f, 0.09764048f, 0.01658292f, 
    -0.25742716f, -0.31663889f, -0.11358421f, 0.31357682f, 0.06215208f, -0.09778025f, -0.03140173f, -0.06477992f, 
    0.03922708f, 0.25104675f, -0.16092673f, 0.08411653f, 0.04371250f, 0.24892084f, 0.03869970f, 0.13991989f, 
    0.03923859f, -0.08154017f, 0.10992216f, -0.05344138f, 0.02093150f, -0.00048063f, 0.22880176f, -0.01897912f, 
    0.11209035f, -0.11589745f, -0.06450120f, 0.02533497f, -0.05296283f, -0.05622195f, 0.06853139f, 0.05081527f, 
    0.12469784f, -0.03797179f, -0.13423944f, 0.09224830f, 0.06463822f, 0.06609098f, 0.14123601f, -0.19999950f, 
    0.14302985f, 0.11902247f, 0.09576001f, 0.12942891f, 0.07171438f, 0.11178887f, -0.01121645f, -0.05035047f, 
    -0.19286610f, -0.02965626f, 0.18405496f, 0.13840121f, -0.12518157f, -0.08409505f, 0.17652918f, -0.16435681f, 
    -0.01483325f, -0.08027736f, 0.03261246f, 0.03361193f, -0.02913700f, 0.25194693f, -0.16825074f, 0.08140175f, 
    -0.13530239f, -0.22198482f, 0.20343871f, -0.01354555f, -0.07104860f, 0.02050851f, 0.23450777f, 0.31162876f, 
    -0.17390901f, -0.17039479f, -0.01656980f, 0.20619702f, 0.03909502f, -0.04655034f, -0.00426137f, -0.02494571f, 
    0.03147373f, 0.10345708f, 0.18934588f, 0.00963710f, 0.02705331f, -0.08610501f, 0.09238276f, 0.08041491f, 
    0.13255486f, 0.05956718f, -0.06170448f, -0.02483409f, 0.09310338f, -0.03253213f, -0.09414560f, -0.01441731f, 
    0.15047246f, -0.10545220f, 0.04231124f, 0.08051678f, 0.11976741f, 0.22647500f, 0.25088614f, 0.15982173f, 
    0.08307455f, -0.01378191f, -0.11557335f, -0.05161882f, 0.14157565f, 0.09431794f, 0.06164335f, 0.06739480f, 
    0.03148824f, 0.04256860f, 0.04482047f, -0.04036510f, 0.22968978f, 0.03634146f, 0.19316319f, 0.10833543f, 
    0.24802125f, -0.23080797f, 0.19804804f, 0.25577533f, 0.08852624f, -0.09477719f, -0.04486631f, -0.00751944f, 
    0.23169297f, -0.02427466f, 0.11759798f, 0.13666137f, -0.04087756f, -0.08958304f, 0.04267355f, 0.16128755f, 
    -0.11126113f, 0.15435944f, 0.03869603f, -0.05432918f, -0.00273379f, 0.03694087f, -0.08605390f, -0.00580535f, 
    0.15352923f, -0.29720241f, 0.07869174f, 0.09245216f, 0.08198342f, -0.08958758f, -0.04010937f, -0.14322744f, 
    0.31660163f, -0.10181601f, -0.03456022f, 0.11740883f, -0.17901179f, -0.04589695f, -0.07095542f, 0.16795573f, 
    -0.08073984f, 0.06840792f, -0.01538573f, -0.13220465f, -0.03119266f, -0.04251448f, 0.02081821f, 0.08308338f, 
    0.00763072f, 0.02633709f, -0.15656205f, -0.01949993f, 0.12993443f, -0.00051713f, -0.11413968f, 0.11078276f, 
    -0.03125397f, 0.01526289f, -0.18340415f, 0.03213498f, -0.41916433f, -0.13747935f, 0.26245570f, -0.09972920f, 
    0.02464655f, 0.04736021f, 0.02030741f, 0.08774788f, -0.12417822f, 0.11740950f, 0.01471287f, -0.01376615f, 
    0.17216673f, -0.25699830f, -0.07191903f, 0.34075916f, 0.15575823f, -0.04119836f, -0.00977925f, -0.21513435f, 
    0.01670359f, 0.05049342f, -0.01684927f, 0.19761597f, 0.00555412f, 0.14228451f, 0.04254030f, -0.01820964f, 
    0.08867103f, -0.02530874f, 0.02830458f, -0.13417388f, 0.05056723f, -0.01746570f, 0.09215730f, 0.00729496f, 
    0.02598270f, 0.05024768f, -0.05005197f, 0.04248460f, -0.02344909f, 0.04738896f, 0.05826085f, 0.03388968f, 
    -0.05758989f, 0.01741372f, -0.03600166f, 0.05742432f, 0.04124889f, 0.03798544f, -0.03439859f, -0.01930828f, 
    -0.00749071f, -0.02216050f, -0.01961194f, -0.03095150f, -0.05626746f, -0.01386981f, -0.03017788f, -0.05109599f, 
    0.02155208f, -0.00363460f, -0.03902481f, -0.04888756f, 0.00623846f, 0.00460954f, 0.03829360f, -0.05070692f, 
    -0.03283999f, 0.02831746f, -0.02878372f, 0.04045724f, -0.02452614f, 0.06364204f, -0.00060835f, -0.00372194f, 
    0.06543803f, -0.02892851f, -0.05749043f, 0.00165061f, -0.05287085f, -0.03041413f, 0.02727812f, 0.05594449f, 
    -0.04805525f, -0.05353188f, -0.03009189f, -0.00609267f, 0.00812712f, -0.06707911f, -0.05317314f, 0.04387928f, 
    0.05435238f, -0.07641467f, 0.03927745f, -0.02525255f, -0.03797786f, -0.04454834f, 0.00616812f, -0.07602130f, 
    -0.04582184f, -0.05608570f, 0.04364066f, 0.04871086f, -0.00972471f, 0.02285237f, -0.04811001f, -0.01808925f, 
    -0.05652833f, -0.03898431f, 0.00669496f, -0.00726417f, -0.06212504f, 0.01131774f, -0.05886834f, 0.03955700f, 
    -0.01373268f, 0.05537256f, -0.06193483f, -0.03815979f, 0.01154906f, -0.00678855f, -0.03505812f, 0.05070058f, 
    0.04827724f, 0.04537428f, 0.03994680f, 0.05898765f, 0.05891732f, -0.03793634f, -0.02811181f, -0.07231092f, 
    -0.03634075f, -0.07050700f, -0.04502415f, 0.01183392f, -0.01590910f, 0.01062140f, 0.04981078f, -0.05623704f, 
    -0.07237978f, 0.04510032f, 0.00340867f, -0.00463010f, -0.04854292f, 0.05551640f, 0.00862394f, -0.06145123f, 
    0.03536108f, 0.07250510f, -0.05263194f, -0.00666514f, -0.05647861f, -0.05412214f, -0.04341087f, -0.05098903f, 
    -0.05937269f, 0.03242415f, -0.03312390f, 0.05736490f, 0.03180739f, -0.02617840f, -0.00124217f, 0.01461546f, 
    -0.02832521f, 0.01482502f, 0.03245423f, -0.01876398f, 0.02375323f, 0.01640569f, -0.00461627f, -0.02923315f, 
    0.02663440f, -0.00304278f, -0.06070760f, -0.07542323f, -0.07205848f, 0.00539277f, 0.05354446f, -0.01546781f, 
    -0.03166612f, 0.02868561f, 0.03541663f, -0.04931539f, -0.01495692f, -0.06340823f, 0.01801462f, 0.00243922f, 
    -0.07473953f, -0.04406408f, -0.08222146f, 0.02415910f, -0.01046796f, 0.03217603f, 0.03432005f, -0.04099188f, 
    -0.05778867f, -0.02756782f, 0.03429427f, 0.04793283f, -0.01733549f, 0.05673963f, -0.02997847f, 0.06624277f, 
    -0.02244621f, 0.02736258f, -0.00398482f, 0.00417352f, 0.00412237f, -0.01463063f, 0.01674511f, 0.04477021f, 
    0.03973731f, -0.05422109f, 0.04675523f, 0.04381532f, 0.02030085f, -0.06587657f, -0.04333269f, -0.00974635f, 
    -0.02726717f, -0.00858190f, 0.00246953f, -0.00083266f, 0.05865673f, -0.01885595f, 0.05033177f, -0.00744473f, 
    -0.25443965f, 0.00417212f, -0.12553884f, -0.22372134f, -0.07937294f, -0.03192924f, -0.09334927f, -0.06195061f, 
    -0.04182495f, 0.07219811f, 0.04680824f, 0.04298244f, -0.33380663f, 0.15962499f, 0.13076192f, 0.15664604f, 
    -0.13849498f, -0.11048850f, -0.07926005f, -0.05364111f, -0.01775653f, -0.06119278f, -0.00721619f, -0.02461983f, 
    -0.03085689f, -0.26205695f, 0.08712580f, 0.04360993f, 0.14864075f, 0.15566036f, -0.01666753f, 0.02115389f, 
    0.12821405f, 0.17956696f, -0.09915409f, -0.04688098f, 0.17149697f, -0.08785160f, -0.01890671f, 0.05521384f, 
    0.06660632f, 0.00634710f, 0.08098882f, 0.12241249f, -0.17605060f, 0.01354446f, -0.11936910f, -0.13802430f, 
    -0.17668761f, 0.50247526f, -0.26645604f, -0.09895913f, -0.07141825f, 0.06455452f, 0.00550585f, 0.04458730f, 
    0.01370217f, -0.07616887f, 0.06905596f, -0.02599225f, -0.07329448f, -0.08719002f, 0.17508544f, 0.18311220f, 
    0.10554505f, 0.13501969f, 0.04713722f, 0.13998957f, -0.09558212f, -0.05559269f, -0.03326021f, 0.00876162f, 
    -0.24982749f, 0.02598528f, 0.20021553f, 0.04691360f, -0.12178616f, 0.00130227f, 0.03730398f, 0.00726604f, 
    0.04403345f, 0.03910155f, -0.00662458f, 0.00382389f, -0.01573129f, -0.02500756f, -0.03359425f, -0.09521355f, 
    -0.15776815f, -0.11218611f, -0.09028964f, -0.09875515f, -0.07484269f, 0.00781085f, -0.05611684f, -0.24244496f, 
    0.02006828f, -0.20997542f, -0.19899394f, -0.03097039f, 0.08982856f, -0.06245530f, -0.03178547f, 0.06905355f, 
    -0.14597940f, 0.02776013f, -0.12467248f, 0.01669661f, -0.01071938f, -0.15742829f, -0.01334599f, 0.37765348f, 
    -0.03347109f, 0.06408376f, 0.05038665f, 0.02849379f, -0.04457299f, 0.06608794f, 0.00444014f, 0.07642022f, 
    -0.07929295f, 0.05482224f, -0.02356463f, 0.24737713f, 0.02109109f, 0.04357858f, 0.10318482f, 0.12358080f, 
    0.03461818f, -0.00184732f, -0.00194814f, 0.02353060f, -0.27808204f, 0.16182846f, -0.05501293f, 0.12724040f, 
    0.14896844f, 0.00178972f, -0.02190022f, -0.00599162f, -0.01318218f, 0.03045776f, -0.02509788f, 0.10102190f, 
    0.04696256f, 0.04423152f, -0.00463902f, -0.08172163f, -0.00115854f, -0.07647643f, -0.06647033f, 0.03870472f, 
    0.18004766f, 0.09790116f, 0.11564191f, 0.09800303f, -0.26211435f, -0.07774410f, -0.01031623f, 0.15924557f, 
    0.08642715f, 0.02520119f, 0.02185468f, -0.01571807f, 0.11658682f, 0.03342196f, -0.08680189f, -0.00045402f, 
    0.47743317f, -0.00108842f, -0.37364838f, -0.16328542f, 0.07583545f, -0.23829086f, 0.03594461f, -0.15594134f, 
    0.06465618f, 0.10346421f, 0.06163009f, 0.14985158f, 0.11174728f, 0.12728122f, 0.20316474f, 0.21482107f, 
    -0.01074578f, 0.04783015f, 0.11596812f, 0.15143272f, 0.08282755f, 0.15619041f, 0.03506522f, 0.04376006f, 
    -0.43203282f, -0.13610370f, -0.12630016f, -0.19797552f, 0.02978869f, 0.01156770f, 0.02668264f, -0.10328560f, 
    -0.02149725f, -0.03742579f, 0.02091374f, 0.06614579f, -0.52747065f, -0.29904750f, -0.11584313f, 0.34437954f, 
    -0.08797733f, 0.14062133f, -0.09284951f, -0.01443157f, -0.00892315f, -0.06410322f, 0.04116082f, 0.01982961f, 
    0.18343931f, 0.06181064f, 0.03169266f, 0.27148825f, -0.06434750f, 0.03233016f, 0.29267299f, 0.13613629f, 
    0.02676870f, 0.03373221f, 0.08225875f, 0.05510511f, 0.15398675f, -0.25080445f, 0.04639523f, 0.12178416f, 
    0.08235335f, 0.10947712f, 0.04167222f, 0.29265225f, -0.07946001f, -0.01644287f, -0.01562807f, -0.18895923f, 
    -0.01830142f, 0.47058609f, -0.01640996f, -0.24031438f, 0.01520693f, 0.05869637f, 0.08175506f, 0.10481726f, 
    0.22970474f, -0.02164377f, -0.00027653f, 0.08061680f, 0.63485992f, -0.08357653f, -0.06427249f, 0.05133484f, 
    0.01595838f, 0.02091361f, -0.00179555f, 0.23161723f, -0.03413144f, 0.09602086f, -0.02168126f, -0.01347323f, 
    -0.24377608f, -0.14809918f, 0.15256608f, 0.07248795f, -0.07177096f, 0.15025185f, 0.07126504f, -0.11612572f, 
    -0.05717153f, -0.01423191f, 0.00539156f, -0.01515283f, -0.13240725f, -0.14307725f, -0.01229810f, 0.00949222f, 
    0.03944534f, 0.03140991f, 0.12292647f, -0.04602080f, -0.15931223f, -0.03776101f, -0.07125775f, -0.07885737f, 
    0.25512353f, 0.09731803f, -0.06109437f, -0.02734859f, 0.11124242f, 0.11299385f, 0.10669542f, 0.00856234f, 
    -0.02513846f, -0.01507648f, -0.15523791f, 0.06248858f, 0.12495730f, 0.11210829f, -0.04898594f, 0.11080153f, 
    0.01969993f, 0.12995681f, 0.03697061f, 0.17576227f, 0.00344691f, -0.01670726f, 0.00514956f, 0.09451529f, 
    0.09015729f, 0.14030476f, 0.12796322f, 0.12641110f, -0.01707104f, -0.01028884f, 0.23454951f, -0.11046901f, 
    -0.01902967f, -0.00603209f, 0.28049913f, 0.06747245f, 0.17574748f, 0.13517666f, -0.20895860f, -0.17642750f, 
    -0.05729025f, -0.01878871f, -0.09525974f, 0.18070151f, 0.10505371f, -0.01087142f, -0.05777297f, 0.00088352f, 
    -0.24734905f, -0.00807018f, -0.11165438f, -0.16340572f, -0.07069423f, -0.21237640f, -0.10093676f, -0.01889855f, 
    0.06818671f, 0.03951810f, 0.11547176f, 0.08209772f, -0.08750060f, -0.18654145f, -0.18402770f, 0.03108969f, 
    0.04315480f, 0.02801317f, 0.08269940f, -0.13613716f, 0.14912954f, -0.20332505f, -0.00903233f, 0.02971675f, 
    0.37905720f, 0.25294173f, 0.04916617f, -0.25486696f, -0.00366687f, 0.02882375f, 0.03144447f, -0.19804725f, 
    0.10492910f, -0.00391157f, -0.12224106f, 0.12086744f, 0.19188561f, -0.09527802f, 0.02196186f, 0.13979773f, 
    -0.00257237f, 0.01845487f, -0.02092874f, 0.05809884f, 0.03312286f, 0.23408784f, -0.02525674f, 0.06981896f, 
    -0.00562877f, 0.07308708f, -0.04069360f, -0.10316259f, 0.02421561f, 0.06999368f, 0.08987431f, -0.03648759f, 
    -0.02211838f, 0.08879323f, 0.03560528f, 0.18443689f, 0.03876607f, 0.07566568f, 0.17284170f, 0.11591059f, 
    -0.03531661f, -0.09856830f, 0.06468774f, 0.00750434f, -0.19982712f, 0.08570425f, 0.04129245f, 0.01005798f, 
    -0.07617154f, 0.01715256f, -0.15056142f, -0.01208995f, -0.09341872f, -0.10279803f, -0.00355538f, 0.04434424f, 
    -0.07832996f, 0.08029906f, 0.13868980f, 0.13495123f, -0.25614655f, -0.01790478f, -0.19661498f, -0.11092225f, 
    -0.19229770f, 0.05972648f, -0.09038125f, 0.07421738f, 0.02800825f, -0.05395819f, 0.01008459f, -0.10231550f, 
    0.03172663f, 0.10124870f, -0.23957708f, 0.03392264f, -0.17582725f, -0.28514105f, -0.14320733f, -0.09455637f, 
    0.18766043f, 0.02401879f, 0.12673226f, 0.13276245f, 0.17034435f, 0.10045293f, -0.03753263f, 0.12128592f, 
    -0.09760001f, 0.03183408f, 0.08810645f, 0.01501602f, 0.06692317f, 0.04522872f, 0.06162715f, 0.08018694f, 
    0.33474195f, 0.06790224f, 0.13087906f, -0.03486171f, 0.16005272f, 0.18006665f, 0.03752106f, 0.13140273f, 
    -0.02458842f, 0.06974898f, -0.09942351f, 0.03111984f, -0.03648297f, -0.13100027f, -0.05706592f, -0.04296286f, 
    -0.03427565f, -0.08146239f, -0.09253667f, -0.09314003f, -0.07780234f, -0.08606260f, -0.13323264f, -0.06031778f, 
    0.06487258f, -0.01348617f, -0.03481216f, 0.00772081f, -0.04094194f, 0.05020386f, -0.14647552f, -0.05587400f, 
    0.16922139f, -0.05924123f, -0.00642642f, 0.06430534f, 0.08318902f, 0.16181478f, -0.13791873f, -0.10180744f, 
    -0.07176381f, -0.10752629f, 0.06145972f, -0.02793952f, -0.13240382f, -0.11347260f, -0.08699306f, -0.07109566f, 
    -0.23651035f, 0.14329979f, -0.13581118f, -0.06249086f, 0.04312462f, -0.01568356f, 0.07769829f, -0.01964941f, 
    0.02450004f, -0.11948784f, 0.05290966f, -0.12064171f, 0.01062775f, 0.11522460f, -0.42595679f, -0.05716372f, 
    0.00765125f, 0.09252411f, 0.17225195f, 0.21628276f, -0.01062274f, -0.06787363f, -0.01297888f, -0.07049865f, 
    0.00931942f, 0.01152657f, 0.08008325f, -0.11744860f, 0.00231929f, -0.02783365f, -0.02441078f, -0.05467802f, 
    0.04363687f, -0.05395479f, 0.23010644f, 0.13557056f, 0.25244758f, 0.00180370f, -0.22633299f, 0.19893257f, 
    0.04427570f, 0.19316959f, 0.17321286f, 0.22735876f, -0.05766057f, -0.03262058f, 0.11160100f, 0.12085448f, 
    0.31857795f, -0.10937955f, 0.00758065f, 0.25610530f, 0.13458219f, 0.12761268f, -0.03573057f, -0.19885710f, 
    -0.02354053f, 0.15305065f, 0.14792950f, -0.07686203f, -0.26156774f, -0.07158483f, -0.14689657f, -0.02729328f, 
    -0.18078330f, 0.16063841f, 0.00517264f, 0.08621816f, -0.06035053f, 0.09740148f, 0.21278748f, -0.05860708f, 
    -0.08714807f, 0.18700610f, 0.12028857f, 0.13614385f, 0.01820555f, -0.11058038f, -0.05903220f, -0.02262178f, 
    -0.04200660f, 0.01268646f, -0.04792361f, 0.15431489f, 0.10597222f, 0.16249183f, 0.03219516f, 0.37641555f, 
    -0.09306381f, 0.06410028f, -0.08939958f, 0.01472641f, 0.11580881f, 0.03376994f, 0.03986629f, 0.02302658f, 
    -0.00748479f, -0.31384444f, 0.05018331f, 0.01401333f, 0.05360955f, 0.07250075f, 0.11803444f, 0.31953669f, 
    -0.06838717f, -0.04426032f, -0.06437722f, -0.16013537f, -0.90134650f, -0.15819810f, -0.09484779f, -0.55407101f, 
    0.01842664f, -0.25655082f, -0.25415727f, -0.21081382f, 0.06145794f, 0.06483924f, 0.02942333f, 0.05796271f, 
    0.22742689f, 0.16930397f, 0.20204732f, 0.45533621f, 0.02124223f, 0.07773110f, -0.00944022f, 0.04503233f, 
    0.06506632f, -0.10769415f, -0.01605677f, -0.08155819f, 0.37801927f, -0.09759935f, -0.12580703f, 0.00080017f, 
    0.01202011f, 0.07698631f, 0.06127812f, 0.31682876f, 0.00973390f, 0.03004819f, -0.03880638f, -0.33275956f, 
    0.23982902f, 0.08057789f, 0.27209100f, 0.20972602f, 0.00840267f, 0.15134098f, 0.08137771f, 0.11142054f, 
    0.04580347f, 0.03778459f, -0.00201792f, -0.02210314f, 0.05501291f, 0.06931707f, 0.06504654f, 0.11394578f, 
    -0.01633401f, -0.00077727f, 0.06511508f, -0.13322046f, 0.21315566f, 0.04887601f, 0.00367427f, 0.02293800f, 
    0.09342322f, -0.06124906f, 0.11832403f, 0.16801095f, -0.05564911f, -0.10809638f, -0.03751335f, -0.17704715f, 
    0.01570884f, 0.04110098f, 0.16618361f, 0.13802604f, -0.01252534f, 0.14476803f, -0.20123021f, -0.02935627f, 
    0.21900919f, 0.00171099f, -0.03558593f, 0.27530223f, -0.20554237f, -0.16694504f, 0.02004627f, -0.15512753f, 
    -0.10574035f, 0.25433934f, -0.06227356f, -0.25070181f, 0.08063545f, -0.08872430f, -0.16020229f, 0.06632896f, 
    -0.13404562f, 0.06014397f, 0.04773258f, 0.01041756f, -0.26793873f, 0.04029129f, -0.21379940f, -0.12643996f, 
    0.11607391f, 0.25714400f, -0.13762239f, 0.08139422f, -0.08300699f, -0.18318769f, -0.12667121f, -0.05301837f, 
    -0.02770492f, 0.01665776f, 0.06942430f, -0.01699115f, 0.03844581f, -0.07337767f, -0.00879208f, -0.04214411f, 
    0.10464916f, 0.20203367f, -0.05349848f, -0.06819906f, -0.05813822f, -0.44877592f, -0.47491130f, -0.07978438f, 
    0.06027282f, -0.00511228f, -0.16478859f, 0.12844765f, 0.07109337f, -0.12029186f, 0.01207802f, 0.04450377f, 
    -0.04977763f, 0.23968033f, 0.00973949f, -0.19331117f, -0.08562647f, -0.13729255f, 0.01814176f, -0.12489986f, 
    -0.20686060f, -0.00665420f, 0.10860856f, -0.06839638f, -0.18214366f, -0.02957173f, -0.01189369f, 0.00712260f, 
    0.05928619f, 0.01362683f, -0.18885085f, -0.03805872f, 0.12145420f, 0.02106064f, -0.09765004f, -0.03383507f, 
    -0.05142595f, 0.02206235f, 0.02905933f, -0.11015140f, -0.00427326f, -0.05124304f, 0.01125927f, -0.09293883f, 
    0.07940902f, 0.04669277f, 0.06258282f, 0.07095780f, -0.07942564f, 0.41002160f, 0.15468061f, -0.05398363f, 
    -0.02561052f, -0.08206284f, -0.12732141f, -0.09526498f, 0.06043994f, 0.01995881f, -0.02377481f, 0.07770562f, 
    -0.11943218f, -0.12481482f, -0.00137361f, 0.08249333f, -0.02200592f, 0.08815527f, -0.08065236f, 0.12838052f, 
    -0.00627550f, 0.12333898f, -0.07951526f, -0.05493695f, 0.17139240f, -0.13677953f, 0.06248893f, 0.06456695f, 
    0.10709928f, 0.08548089f, 0.01098676f, -0.19195057f, 0.00159383f, 0.04142264f, -0.06126012f, -0.16724469f, 
    0.08061564f, 0.46456525f, -0.23654979f, 0.05184347f, -0.05325611f, 0.00994174f, -0.10686194f, -0.12822813f, 
    -0.04057172f, -0.16714156f, 0.07455364f, -0.11732002f, -0.05107586f, -0.17680839f, -0.03727346f, -0.10215297f, 
    0.11770657f, 0.05857791f, -0.03305547f, 0.14862098f, -0.11798044f, -0.00442574f, 0.01686249f, -0.08184658f, 
    -0.07906773f, 0.40939388f, 0.07469881f, -0.04127474f, -0.11997355f, -0.27778506f, 0.04938167f, -0.05652650f, 
    0.08482316f, -0.09302624f, 0.03904376f, 0.06330305f, 0.00556536f, 0.09988816f, 0.12799619f, -0.27564672f, 
    -0.03746959f, 0.00729359f, -0.04216302f, -0.15238616f, -0.01191583f, -0.03303162f, -0.02975705f, -0.02401703f, 
    0.47045884f, -0.03726751f, -0.14706454f, -0.00974276f, 0.05811803f, -0.10269939f, -0.01804406f, -0.18796955f, 
    -0.22138691f, 0.04935251f, -0.01321216f, 0.13109599f, -0.15005709f, -0.15669364f, -0.02358036f, 0.04181058f, 
    0.03094139f, -0.05065200f, 0.05143102f, 0.03203725f, -0.02723744f, 0.10779385f, 0.05274623f, 0.12698916f, 
    0.05766299f, -0.03251350f, -0.06582717f, 0.01011163f, 0.06330105f, 0.12684882f, 0.00439815f, 0.29804879f, 
    -0.12450511f, 0.11926310f, -0.07626624f, 0.08997974f, 0.14725374f, 0.05638856f, 0.16576876f, 0.13049541f, 
    0.09171907f, -0.02222143f, -0.04757630f, 0.32057390f, 0.10398327f, -0.08107203f, 0.01522759f, -0.01422665f, 
    -0.08328594f, 0.12322332f, 0.04655778f, -0.05478095f, -0.08549013f, -0.04167899f, 0.18293230f, -0.00845927f, 
    0.07934489f, 0.11733015f, 0.15689725f, -0.02393971f, 0.01834073f, 0.03561384f, 0.13030580f, 0.08763776f, 
    0.02238678f, 0.02071113f, 0.05938818f, 0.01591404f, 0.10316910f, -0.01132936f, -0.04335519f, -0.04318437f, 
    0.42679259f, -0.25510800f, 0.00288090f, -0.05434228f, 0.02020209f, -0.04578446f, -0.02002653f, -0.00247644f, 
    -0.06995417f, -0.12774971f, 0.16256899f, -0.03001685f, -0.03477973f, 0.21276748f, 0.18518645f, 0.11807151f, 
    0.05167888f, 0.09643471f, 0.09625164f, 0.09177303f, -0.08660423f, 0.01003420f, 0.02690149f, 0.14305624f, 
    -0.03337042f, -0.01459652f, -0.10086298f, -0.09454561f, -0.06427129f, -0.03747334f, 0.06298822f, -0.09216395f, 
    0.04440204f, -0.04582530f, 0.02811098f, 0.20013800f, 0.30837008f, -0.09923092f, 0.09281466f, 0.14417511f, 
    0.00596709f, -0.01659434f, 0.18785755f, 0.09213591f, 0.04187312f, 0.07051358f, -0.07338621f, -0.12484216f, 
    -0.12992448f, -0.06332273f, 0.04397127f, -0.03474860f, 0.09774903f, 0.08682226f, 0.15937974f, -0.16140091f, 
    0.13874124f, 0.07695754f, 0.12120630f, -0.01831974f, -0.17067237f, 0.23787433f, -0.12978147f, -0.09374113f, 
    -0.04610952f, -0.16026822f, 0.14014904f, 0.18267378f, -0.03669956f, -0.16957349f, 0.04555227f, 0.05141431f, 
    -0.14787099f, -0.35795218f, 0.15009153f, 0.07866945f, 0.01921456f, -0.05498362f, -0.12169808f, 0.06647066f, 
    0.18062799f, 0.12451463f, 0.16419218f, 0.20553069f, 0.06796861f, 0.13210247f, 0.20477533f, 0.33078337f, 
    -0.00394944f, -0.07995079f, 0.05744401f, -0.22406422f, 0.09303048f, 0.07707248f, 0.04308047f, 0.04105491f, 
    0.30951935f, -0.11606725f, 0.04113532f, 0.17294009f, 0.17205831f, 0.27660516f, 0.00655883f, 0.18850631f, 
    -0.02049351f, 0.02816724f, -0.04867322f, -0.03920919f, 0.10602238f, -0.05288834f, -0.21670349f, 0.07266569f, 
    0.09480882f, 0.01761360f, -0.00597424f, 0.07086819f, -0.04487185f, -0.05061814f, -0.08730736f, -0.24378778f, 
    -0.66608685f, -0.11769468f, -0.03721730f, -0.01007653f, -0.06130059f, -0.07973597f, -0.00110067f, 0.16834472f, 
    0.11814595f, 0.10172107f, -0.02594886f, 0.09889247f, 0.01546926f, 0.08934271f, 0.05087045f, 0.24019635f, 
    -0.04978214f, 0.02386629f, 0.06103685f, 0.06104542f, -0.03851607f, 0.05523035f, 0.04814985f, 0.01273365f, 
    -0.20425175f, -0.10689541f, -0.10160394f, 0.11806517f, -0.12433951f, -0.10122916f, 0.15728752f, -0.12509580f, 
    0.21141544f, -0.11452221f, 0.16280195f, 0.00513910f, -0.29931843f, -0.26509899f, -0.02437135f, 0.10155582f, 
    -0.01165859f, 0.02617748f, 0.07371122f, -0.10953377f, 0.04520983f, 0.07897808f, -0.02445536f, 0.21927758f, 
    -0.00064509f, 0.01936393f, -0.10512236f, 0.11272988f, 0.17044170f, 0.00258849f, -0.14104760f, 0.11211795f, 
    0.12014730f, -0.00038211f, 0.01714131f, 0.15776344f, -0.21139096f, -0.07885168f, 0.05424061f, -0.01881676f, 
    -0.01883942f, 0.08389524f, 0.05664290f, 0.10265222f, 0.06826046f, 0.17386551f, 0.08217469f, -0.10996611f, 
    -0.01397827f, -0.17183189f, -0.20671697f, 0.38273022f, 0.08647175f, -0.21848565f, 0.16298711f, 0.00273288f, 
    -0.04604013f, 0.15559143f, 0.00805487f, 0.13724925f, -0.15205054f, 0.09080843f, -0.02696207f, -0.06706164f, 
    -0.00926519f, 0.01985932f, 0.06738055f, 0.04712898f, 0.28898746f, 0.08564892f, 0.01661172f, 0.01874297f, 
    -0.11369052f, 0.04025998f, -0.00654999f, -0.03958538f, 0.06343047f, -0.02740988f, 0.04667579f, 0.00251755f, 
    0.08331499f, -0.09365834f, 0.00926311f, 0.21819817f, -0.09072248f, -0.05824588f, 0.02965576f, -0.12404186f, 
    0.16939838f, 0.04007183f, 0.11060535f, -0.03194394f, 0.04122601f, 0.13828473f, -0.08204393f, -0.12309634f, 
    0.04967732f, -0.03264291f, 0.02807031f, 0.12216130f, 0.13070053f, -0.05837784f, 0.29390258f, -0.05820667f, 
    0.02145796f, -0.03704239f, 0.06774569f, 0.02896061f, 0.02806266f, 0.04237930f, -0.06611377f, 0.10133915f, 
    -0.11404051f, -0.18883267f, 0.14166559f, 0.06982906f, -0.08732770f, -0.14014465f, 0.09834671f, 0.17611390f, 
    -0.19472486f, -0.18779613f, -0.06703456f, 0.13978878f, 0.01827566f, 0.09386450f, -0.11356197f, 0.03594675f, 
    0.12840836f, -0.01810320f, 0.18046369f, -0.11230100f, 0.10553467f, -0.08617669f, 0.12947547f, 0.26234630f, 
    0.01953295f, 0.05233142f, -0.08574329f, -0.05431228f, -0.07643131f, -0.04820810f, -0.02035227f, -0.02085200f, 
    0.09166010f, -0.11265044f, 0.03006652f, 0.26532021f, 0.21190210f, 0.06289821f, 0.27007604f, 0.02311544f, 
    0.12644453f, -0.06524132f, -0.07916111f, -0.01752766f, 0.09546672f, -0.03743919f, -0.02680380f, -0.04353409f, 
    0.03928832f, 0.07189328f, 0.00686267f, -0.05373977f, 0.07334662f, 0.02204921f, -0.02376209f, -0.12161418f, 
    -0.03936726f, -0.21199939f, 0.06555941f, 0.23057565f, 0.08599067f, -0.11230484f, -0.10597813f, 0.01531044f, 
    0.06915423f, 0.02309558f, -0.13973002f, 0.20410305f, -0.01673731f, -0.00410230f, 0.13907155f, 0.29589024f, 
    -0.05229167f, 0.05799591f, -0.07495239f, -0.04438309f, -0.00914942f, 0.02055519f, 0.00266578f, -0.04271658f, 
    0.03671508f, -0.18574005f, 0.08590074f, 0.16275473f, 0.01553245f, -0.01366680f, -0.04486715f, -0.12382988f, 
    0.16023308f, -0.06782761f, 0.03671083f, 0.25934520f, -0.21608764f, -0.13025548f, -0.04325404f, 0.01146917f, 
    -0.05666703f, 0.11504132f, -0.16109753f, -0.10260128f, 0.10058475f, -0.03076540f, -0.04652983f, 0.06542663f, 
    -0.05460849f, 0.06490882f, -0.13387868f, 0.15079607f, 0.06340999f, -0.02098516f, -0.09570027f, 0.18358365f, 
    0.11253083f, -0.05466345f, 0.09928833f, 0.05930311f, -0.30303219f, -0.15988910f, 0.14599662f, 0.02997493f, 
    0.04875438f, 0.08698312f, 0.02743892f, -0.05452721f, -0.00302899f, 0.13451456f, 0.04331920f, -0.06323612f, 
    0.21225338f, -0.34013689f, -0.33457947f, 0.15185976f, 0.14535773f, -0.20996340f, -0.06852654f, -0.24289356f, 
    -0.05062824f, -0.01086604f, -0.10305457f, 0.08268128f, -0.08898418f, 0.07320994f, 0.05440042f, 0.14448865f, 
    0.01809087f, 0.00357837f, 0.03608220f, -0.04020159f, 0.22106270f, 0.12663388f, 0.06408025f, -0.10846552f, 
    -0.04504495f, 0.01037453f, -0.04452603f, 0.00863921f, -0.00525439f, -0.03126109f, -0.06384598f, 0.03685365f, 
    -0.01276945f, -0.00303381f, 0.02895899f, 0.06613442f, -0.03832212f, 0.05606170f, 0.04128332f, 0.04183146f, 
    -0.05127722f, 0.00309065f, 0.00993282f, 0.01625714f, -0.00296165f, -0.06791040f, -0.05268969f, 0.02083193f, 
    0.05035000f, 0.05642312f, -0.00302473f, -0.07893693f, 0.01144585f, -0.05368380f, -0.01452513f, -0.05279347f, 
    0.05021504f, 0.02767514f, 0.05853487f, -0.00309716f, -0.00047605f, -0.00071009f, 0.04701426f, 0.01294254f, 
    0.03914157f, -0.05873268f, -0.02640915f, -0.02122159f, -0.02381242f, 0.06578964f, -0.00330635f, 0.01966060f, 
    0.01738958f, 0.02309909f, -0.02282360f, -0.03831333f, -0.01346200f, 0.00660631f, -0.00652835f, -0.04170287f, 
    -0.06057820f, -0.06398883f, 0.04353814f, 0.00328427f, 0.04180025f, 0.02585599f, 0.00069071f, 0.03498344f, 
    0.05444503f, 0.04464771f, -0.04311508f, -0.06733790f, -0.03304030f, 0.05720711f, -0.07286211f, -0.06632253f, 
    -0.03354728f, -0.04877845f, 0.04032016f, -0.02808666f, -0.01870319f, -0.03300058f, -0.06232134f, -0.01910723f, 
    -0.00007510f, -0.07229220f, 0.02624039f, -0.03906221f, 0.03436919f, -0.00591493f, -0.06406591f, -0.06012871f, 
    0.01397417f, -0.04626960f, -0.01783727f, -0.02689249f, 0.06463513f, 0.00381924f, -0.05684255f, -0.02460792f, 
    -0.01626780f, -0.00628422f, -0.02378412f, 0.04832230f, 0.00703749f, 0.00667487f, -0.03486573f, 0.02332369f, 
    -0.07910394f, -0.05304594f, -0.03822140f, 0.05634573f, -0.01097893f, 0.00344223f, -0.06680784f, -0.06508240f, 
    -0.01669730f, -0.07450156f, -0.07167859f, 0.00121590f, -0.08204123f, 0.05571131f, 0.01583217f, 0.04966596f, 
    -0.00908168f, 0.02140851f, 0.03101433f, -0.05283332f, -0.00080030f, 0.02786142f, -0.01574744f, -0.00594017f, 
    0.01991906f, -0.03705729f, -0.03858836f, -0.05052110f, 0.03505540f, 0.02369083f, -0.03433640f, 0.05991180f, 
    0.00363073f, 0.04172403f, -0.03844495f, -0.03418053f, -0.04198391f, -0.02802267f, 0.00381662f, -0.00289372f, 
    -0.05895051f, 0.03610286f, -0.07748953f, 0.00333797f, -0.02034910f, -0.04295159f, 0.00021050f, -0.00043662f, 
    -0.05296769f, 0.03659107f, 0.02496125f, 0.00139248f, -0.04107296f, -0.06661264f, 0.02588881f, -0.05766560f, 
    -0.00098150f, -0.02675710f, -0.02855511f, -0.01705859f, 0.05313127f, 0.03225179f, -0.04077813f, 0.03597309f, 
    -0.06349725f, -0.00371955f, -0.00394433f, 0.05879582f, -0.02085584f, 0.03128348f, -0.05325260f, -0.00983434f, 
    0.04841881f, -0.05862476f, 0.06200265f, -0.07215080f, -0.07380482f, -0.00798891f, -0.01746467f, 0.03883534f, 
    0.02369769f, 0.02912698f, -0.05031765f, 0.03815719f, -0.05901784f, -0.03208200f, 0.01206795f, -0.07926953f, 
    -0.13224263f, -0.00671704f, 0.06042303f, -0.07745905f, -0.03994545f, -0.04976182f, -0.04228139f, -0.01312346f, 
    0.14964062f, 0.05085267f, 0.12884289f, 0.05726043f, -0.02687919f, 0.40499741f, 0.35033873f, -0.04037715f, 
    -0.17822322f, -0.19645132f, -0.02408775f, -0.00859690f, 0.02287099f, 0.02759381f, 0.04240832f, 0.06744964f, 
    0.00690098f, -0.30715442f, -0.00674209f, -0.18482247f, 0.00297175f, 0.01068379f, -0.11419925f, 0.11798953f, 
    -0.04813684f, 0.12991631f, -0.04573666f, 0.04953337f, 0.25040191f, -0.07841782f, 0.12490781f, 0.12762180f, 
    0.03178125f, 0.13898012f, 0.03623095f, 0.02840405f, -0.02508793f, 0.08658014f, -0.07249048f, 0.03610068f, 
    -0.09124785f, 0.44799128f, -0.28327963f, -0.16530299f, -0.06582892f, 0.06047480f, -0.02375101f, -0.12357122f, 
    0.10397763f, 0.00531252f, 0.11450712f, -0.05039587f, -0.37904689f, -0.18361586f, -0.01151071f, 0.10645267f, 
    0.05307697f, 0.11779761f, 0.02040257f, -0.05036256f, 0.00079472f, -0.07233092f, 0.10005275f, 0.02981840f, 
    0.01466122f, 0.32285425f, 0.12773871f, 0.12378792f, -0.13779922f, -0.21217713f, 0.04241907f, 0.01556327f, 
    0.00276802f, -0.09718855f, 0.15139201f, 0.09680564f, -0.23670001f, 0.05562738f, 0.02843900f, -0.19286723f, 
    -0.20033836f, 0.04986890f, -0.15450542f, -0.06409331f, 0.10615083f, 0.05408202f, 0.02331455f, -0.18146676f, 
    -0.09240984f, 0.06194519f, -0.12955901f, -0.15371250f, 0.07324084f, -0.04448854f, 0.05260279f, 0.00605223f, 
    -0.22891501f, 0.10880402f, 0.05504655f, 0.07443772f, -0.05812703f, -0.16237774f, -0.16001679f, 0.02829675f, 
    0.00852796f, -0.11615292f, 0.11985872f, -0.03158737f, -0.08708211f, 0.03461099f, -0.13725066f, 0.02585758f, 
    -0.23189719f, 0.00445825f, -0.01187640f, 0.07166494f, -0.02506957f, 0.06887085f, 0.10452743f, 0.10884935f, 
    -0.02332135f, 0.12723909f, -0.07851437f, -0.00058121f, -0.23872456f, 0.31285208f, 0.06609364f, 0.17801060f, 
    0.23736960f, 0.09805821f, 0.09362762f, 0.06318705f, -0.13839820f, -0.10895831f, 0.07429762f, 0.11884919f, 
    0.20917122f, 0.10298381f, 0.05350922f, -0.01755685f, 0.03101581f, 0.00442640f, -0.03986658f, 0.01160298f, 
    0.14401118f, 0.16374430f, 0.24321313f, 0.10238232f, -0.22949840f, -0.00356614f, -0.01742518f, 0.17490807f, 
    0.02892612f, 0.09667848f, 0.09458341f, 0.09040820f, 0.03170197f, 0.01071823f, 0.09586868f, 0.03953620f, 
    0.24417107f, -0.00671057f, -0.30420458f, -0.17342728f, 0.15083040f, 0.04004281f, 0.02699690f, -0.02082475f, 
    0.05929841f, 0.03193913f, 0.25908884f, 0.16381593f, -0.02704157f, 0.05009225f, 0.22678222f, 0.09829788f, 
    -0.08986083f, 0.06697115f, 0.08095364f, 0.02891576f, 0.08723482f, 0.11248410f, 0.04963332f, 0.12271030f, 
    -0.03932337f, -0.05679752f, -0.03575182f, -0.14355761f, 0.05163449f, 0.02622579f, 0.00311294f, -0.08246293f, 
    0.00681833f, 0.08529501f, -0.05094745f, 0.03571960f, -0.11335228f, -0.21362095f, 0.00047494f, 0.17864694f, 
    -0.00588020f, 0.00373699f, 0.09665909f, 0.02401507f, -0.06160990f, 0.00567635f, 0.05903859f, -0.05248793f, 
    -0.03410094f, 0.12000672f, 0.10926191f, -0.14303842f, 0.00793100f, 0.04421809f, 0.04482228f, -0.01006938f, 
    0.15153608f, 0.07032903f, 0.10907371f, -0.05873696f, -0.22975081f, 0.08574749f, -0.17616922f, -0.11624538f, 
    -0.02875597f, 0.08779454f, 0.04621559f, 0.25967011f, 0.01566766f, -0.06997036f, 0.09299295f, -0.01373000f, 
    -0.05841105f, -0.16619252f, -0.05014024f, -0.00567663f, 0.10427192f, -0.09417719f, -0.10008993f, 0.06721453f, 
    0.15101242f, 0.08678681f, 0.20090981f, 0.23375277f, 0.50573766f, 0.19820262f, -0.30050501f, -0.06089481f, 
    -0.20469356f, 0.03700840f, 0.15659156f, -0.10607193f, 0.03638415f, 0.06449395f, -0.10382205f, 0.03516910f, 
    0.24566771f, -0.17515832f, 0.08412396f, 0.00383132f, 0.07173119f, 0.24199647f, -0.03223002f, 0.04795960f, 
    -0.00107304f, 0.11359829f, -0.01522427f, 0.07848534f, -0.05551507f, -0.12740327f, -0.08118157f, 0.03793676f, 
    0.09245899f, 0.09200868f, 0.09938954f, -0.04476550f, -0.00436768f, 0.04780978f, -0.05550638f, -0.07927480f, 
    -0.15886910f, -0.13151629f, 0.02415682f, -0.05397990f, -0.10259531f, 0.02448253f, 0.04008500f, 0.06970520f, 
    0.08568498f, -0.00030046f, -0.06041630f, -0.03204921f, 0.37928978f, 0.17952830f, 0.06415877f, -0.10948534f, 
    -0.01829205f, 0.14695600f, 0.01675546f, 0.05279408f, 0.02494122f, -0.00584980f, -0.00590528f, -0.05851404f, 
    -0.33500379f, -0.08034933f, -0.04963933f, -0.03963178f, -0.15547487f, -0.01632840f, 0.11885063f, -0.24987569f, 
    0.19633473f, -0.08068929f, 0.06546209f, -0.03720926f, -0.07411283f, 0.17663343f, -0.33458138f, -0.22495893f, 
    0.05346255f, -0.06798465f, 0.16481757f, 0.01859273f, -0.01462673f, -0.07183827f, -0.02555452f, 0.05640919f, 
    -0.03230217f, -0.00387558f, -0.01576305f, -0.12864855f, -0.01603033f, -0.01790193f, -0.14151219f, -0.03663021f, 
    0.06468456f, 0.01127776f, 0.16669106f, 0.12663239f, 0.10303532f, 0.07922575f, -0.17387471f, -0.06830799f, 
    0.04193607f, 0.02882040f, 0.05115109f, 0.17466104f, -0.02906647f, -0.04377209f, -0.02260765f, 0.06407285f, 
    0.27306411f, 0.16196182f, 0.25690088f, -0.12735221f, 0.04806136f, -0.01931491f, 0.07720096f, -0.04829226f, 
    0.06939334f, 0.02900293f, 0.05012672f, -0.07533397f, -0.22762212f, -0.05536606f, -0.16453379f, -0.10520762f, 
    0.02144577f, 0.09846847f, -0.15288846f, 0.01459043f, 0.11635856f, -0.01143398f, 0.10730727f, -0.08072159f, 
    -0.00390434f, 0.20399320f, -0.08719517f, -0.11660001f, -0.11813614f, -0.08536776f, 0.13413796f, -0.15510830f, 
    0.03605589f, 0.05903222f, -0.05167424f, -0.00807728f, 0.31250706f, -0.11160433f, -0.02467942f, 0.03720646f, 
    0.13795203f, 0.11396479f, -0.07541904f, -0.04095229f, 0.13161181f, 0.06066192f, -0.01547273f, -0.10916680f, 
    -0.11918701f, 0.02525988f, -0.19501628f, 0.18025947f, 0.01213685f, -0.08751775f, 0.15681906f, -0.09164992f, 
    0.07447109f, 0.03402583f, -0.02695161f, 0.02496829f, -0.07946121f, 0.16165866f, -0.03490061f, 0.00070004f, 
    -0.12446061f, -0.12440712f, 0.03747707f, -0.06596711f, 0.13611484f, -0.06247390f, 0.08925627f, 0.06268995f, 
    0.05124331f, -0.02921112f, 0.31448674f, 0.27064598f, -0.07736731f, 0.09459606f, -0.14710501f, -0.01561458f, 
    0.07283901f, 0.05919138f, -0.09286514f, 0.01243784f, 0.11894550f, -0.01005319f, 0.39045528f, 0.14460760f, 
    0.11404674f, -0.01920394f, -0.00836649f, 0.12898621f, 0.06863236f, 0.00969543f, -0.06874867f, -0.04411596f, 
    0.08387412f, -0.18360469f, 0.02942516f, -0.04937115f, 0.10370865f, -0.00856116f, -0.06216609f, -0.01498208f, 
    0.12022533f, 0.03892614f, -0.08256710f, -0.14381966f, 0.05858291f, -0.05736743f, -0.05229712f, 0.02846821f, 
    0.00348931f, 0.01312901f, 0.15065460f, -0.02135411f, -0.08673846f, -0.11210579f, -0.04912579f, 0.02322633f, 
    0.10658317f, -0.00277803f, 0.04083576f, -0.07601698f, -0.18160120f, -0.05427082f, -0.14695124f, -0.09382282f, 
    0.07150070f, -0.05785144f, 0.05628318f, 0.09850688f, -0.13637643f, 0.03002529f, 0.06081074f, 0.14828511f, 
    0.04698734f, -0.01993660f, -0.08482432f, 0.09973659f, -0.01606126f, -0.03588621f, 0.08679301f, 0.07405692f, 
    0.27652696f, 0.04316077f, 0.15022974f, -0.04004136f, 0.03103740f, -0.14954734f, -0.05913352f, 0.05907456f, 
    -0.08563902f, 0.02256989f, 0.28644410f, 0.02384328f, -0.02935516f, -0.34414655f, -0.07339621f, 0.20132537f, 
    -0.15892614f, 0.01305038f, -0.13688342f, 0.04922798f, 0.18817568f, 0.10927903f, 0.05995988f, -0.13294953f, 
    -0.03761001f, 0.06889482f, -0.07815577f, -0.08678175f, -0.03713816f, -0.05459515f, 0.20853831f, -0.08434170f, 
    -0.11391960f, 0.09836304f, -0.05609446f, -0.05864717f, -0.05570074f, -0.23307706f, 0.10595659f, -0.10550468f, 
    -0.04747502f, 0.06653991f, -0.06305027f, 0.09084836f, 0.07864751f, -0.00816475f, -0.08437864f, 0.03975897f, 
    -0.13557220f, -0.29339322f, -0.14407952f, 0.36603194f, 0.02912920f, 0.13305859f, -0.08377898f, 0.01105816f, 
    -0.04519329f, 0.02162266f, -0.00067011f, -0.02868445f, -0.03040578f, 0.27827045f, -0.10743709f, -0.01787955f, 
    -0.04159188f, -0.03375000f, 0.06305794f, 0.16033429f, 0.13128862f, 0.14100647f, 0.07948693f, -0.01367950f, 
    -0.04174465f, -0.04231929f, 0.07319916f, -0.14397499f, -0.04558349f, 0.05428262f, -0.15322931f, 0.03539598f, 
    0.13101985f, 0.03967869f, 0.07861304f, -0.07857879f, -0.03231477f, 0.36312586f, 0.24300675f, 0.02698803f, 
    -0.10439894f, -0.16401282f, 0.04493313f, 0.05134631f, 0.03342269f, -0.01578070f, 0.00968293f, -0.03973836f, 
    -0.12151457f, -0.13702048f, 0.23945835f, -0.12874030f, 0.08347960f, -0.08415387f, -0.09101303f, -0.01835351f, 
    0.03953736f, 0.02094962f, -0.03991035f, -0.08392901f, 0.20103312f, -0.10238606f, 0.03082039f, 0.15748212f, 
    0.01966813f, 0.03256193f, 0.13154048f, 0.07889993f, -0.00180108f, 0.05338597f, -0.03770401f, 0.08662179f, 
    -0.03126200f, 0.30558282f, -0.27217340f, -0.22384645f, -0.05387263f, -0.04678811f, -0.07911229f, -0.08881374f, 
    0.08251092f, 0.04300360f, 0.16734606f, -0.00144297f, -0.36383605f, -0.16619140f, -0.03115206f, 0.20149559f, 
    0.13690588f, 0.14960907f, -0.01791985f, -0.03520686f, 0.06228497f, -0.12285510f, 0.08893059f, -0.00041016f, 
    -0.15959793f, 0.13438168f, 0.22905889f, 0.06866919f, -0.18152307f, -0.05789945f, 0.11623589f, 0.03426409f, 
    0.00828528f, -0.01933103f, 0.07467970f, 0.11518066f, -0.15892641f, 0.08346196f, 0.01046018f, -0.21609828f, 
    -0.08856041f, -0.03435149f, -0.04792575f, 0.00999680f, 0.08642682f, 0.04349824f, 0.05450874f, -0.04506338f, 
    0.10811856f, -0.08125808f, -0.10955895f, -0.13222998f, 0.03411849f, -0.14869259f, 0.01183918f, 0.07250441f, 
    -0.03964856f, -0.00159451f, 0.00559474f, 0.04478867f, -0.07888677f, -0.21990786f, -0.04075190f, 0.03405134f, 
    0.09346305f, 0.07256798f, 0.01103886f, -0.12241381f, 0.00618634f, -0.05857132f, -0.09023229f, -0.06856038f, 
    -0.19101582f, -0.26399097f, -0.08307124f, 0.12065313f, -0.00216849f, -0.00109086f, 0.05623280f, -0.05561535f, 
    0.09916391f, 0.06513999f, -0.11857244f, 0.02647217f, -0.12574282f, 0.19903518f, 0.03468806f, -0.11038930f, 
    0.25729769f, -0.04632180f, 0.00723683f, 0.02370288f, -0.19146524f, -0.05810707f, -0.09072492f, 0.07561123f, 
    0.09696972f, 0.03977449f, 0.02610818f, 0.01428923f, -0.00307617f, -0.01768557f, -0.16366535f, -0.03208731f, 
    0.16407090f, -0.00423251f, 0.07560360f, 0.14901534f, -0.16916539f, 0.08036235f, 0.14373866f, 0.14031540f, 
    0.06077898f, 0.08805126f, 0.19287336f, 0.11340306f, -0.06085007f, 0.09588382f, 0.07982482f, -0.08744729f, 
    0.56104761f, -0.02874040f, 0.05393232f, -0.17501795f, 0.09434087f, 0.06577659f, 0.09198827f, -0.04597636f, 
    0.08616988f, 0.00466131f, 0.12445333f, 0.10459893f, 0.05655361f, -0.03900151f, 0.01923082f, 0.13624606f, 
    -0.04231691f, -0.02951402f, 0.07062201f, -0.09525444f, 0.10421817f, 0.13925235f, 0.13940760f, 0.09380300f, 
    0.00421267f, -0.09061317f, -0.04892981f, 0.00961976f, -0.08115585f, -0.01381511f, -0.09478245f, 0.00965275f, 
    0.12602255f, 0.06011636f, 0.03055876f, -0.14892721f, 0.05831348f, 0.33768687f, -0.04815693f, 0.16486442f, 
    0.04998969f, -0.04702454f, -0.08878179f, -0.00259809f, 0.22538456f, -0.04100101f, 0.01303772f, 0.03559758f, 
    0.09949029f, -0.14091837f, 0.04592270f, 0.14797154f, -0.00118602f, 0.01851580f, 0.03709710f, -0.02454506f, 
    0.04272638f, -0.00988333f, -0.09603353f, 0.00878943f, 0.26327676f, -0.00201617f, 0.06153295f, 0.08801655f, 
    0.05076687f, -0.22059309f, 0.06353440f, -0.03423116f, -0.03118960f, -0.02769403f, 0.00370934f, 0.07004054f, 
    -0.04729858f, 0.33378708f, 0.14377792f, -0.27102745f, -0.16285485f, -0.00866772f, 0.11011957f, -0.03588772f, 
    -0.09133002f, 0.06876619f, -0.07078021f, 0.01494368f, -0.37037185f, -0.04180850f, 0.25704420f, 0.31613851f, 
    0.26215750f, 0.04693671f, 0.02570952f, 0.09871908f, 0.01260031f, 0.04351740f, -0.04683916f, -0.09129196f, 
    -0.54578167f, 0.00901455f, 0.29414043f, 0.18927220f, -0.01449912f, -0.00344761f, 0.05767738f, 0.18067384f, 
    0.06017360f, -0.07191721f, 0.06887297f, 0.00289148f, 0.01021445f, 0.09535713f, -0.15171988f, 0.06213625f, 
    -0.16080359f, -0.00229748f, -0.15576714f, -0.12656668f, 0.04977362f, -0.00045558f, 0.13694943f, -0.13675246f, 
    0.18683939f, -0.10679062f, -0.26714268f, -0.21709752f, 0.01834736f, -0.13763285f, 0.02952031f, -0.02229248f, 
    -0.16078003f, -0.00622833f, -0.12885435f, -0.11001237f, -0.04499784f, -0.18189490f, 0.01081541f, 0.24808428f, 
    0.07739284f, 0.16587253f, 0.08192226f, 0.10884880f, -0.06993382f, -0.05638963f, -0.03306373f, 0.13128830f, 
    0.23035857f, -0.07399228f, 0.09119616f, 0.19118303f, -0.02447350f, -0.16449568f, 0.07148744f, 0.01412391f, 
    0.01894801f, 0.16675362f, 0.01946977f, 0.08171745f, -0.27732775f, -0.05804303f, 0.19619220f, 0.10229542f, 
    0.05597356f, 0.03060039f, -0.04154714f, -0.14336282f, -0.14069267f, 0.01585193f, -0.01633165f, 0.06029052f, 
    0.00080659f, 0.03235880f, 0.00472113f, 0.02539630f, 0.05598928f, 0.13779072f, 0.01722689f, -0.03661469f, 
    0.15467662f, 0.14949800f, -0.06209794f, 0.05508275f, -0.29836529f, -0.00051010f, 0.15570965f, 0.07858831f, 
    0.04328573f, -0.04672482f, 0.06667877f, 0.06715219f, 0.03395605f, -0.00059628f, -0.09075601f, -0.01017665f, 
    0.09339631f, 0.10442428f, -0.18147594f, -0.07258047f, 0.06257232f, -0.19200778f, 0.08552915f, 0.06134377f, 
    -0.02170533f, -0.00326014f, -0.17937183f, 0.17871991f, 0.27793115f, 0.07087366f, 0.12772427f, 0.09841873f, 
    -0.02030917f, -0.04120071f, 0.16892746f, -0.07984806f, 0.16285813f, 0.03437197f, -0.08673662f, 0.05979924f, 
    -0.05669220f, 0.01766399f, -0.14784113f, 0.02542720f, -0.00734304f, -0.13524835f, 0.10644238f, -0.06529864f, 
    -0.04463153f, -0.00655253f, -0.02363177f, 0.09765080f, 0.16713326f, -0.15335670f, 0.03307350f, -0.31988505f, 
    -0.00914001f, -0.02191817f, 0.02692510f, 0.04273684f, 0.01131463f, 0.04820761f, 0.05888505f, 0.11055863f, 
    -0.17148609f, -0.21688128f, -0.33264211f, -0.05245373f, 0.04910452f, 0.10022688f, 0.11537261f, -0.04457079f, 
    -0.08284844f, 0.03967461f, 0.04210096f, 0.06195283f, -0.03101580f, 0.25632989f, 0.26981154f, -0.09586466f, 
    -0.07349365f, -0.11806893f, -0.01555341f, -0.04410750f, 0.09311555f, 0.17224631f, -0.05053465f, -0.05724735f, 
    0.01517841f, -0.14869082f, 0.21843189f, 0.43067467f, -0.06373616f, -0.05265020f, -0.00821972f, -0.08996201f, 
    0.01964848f, 0.15826525f, 0.10003856f, -0.05535660f, -0.07453473f, 0.07172810f, -0.00979121f, -0.12266912f, 
    -0.04723654f, -0.06537309f, -0.09332585f, 0.01916517f, -0.02562050f, -0.01173175f, -0.01069250f, -0.04507046f, 
    0.08870333f, 0.05118686f, -0.25436458f, -0.24769017f, 0.14870413f, -0.02946211f, 0.03747261f, 0.01349465f, 
    -0.02856364f, -0.14026272f, 0.01406695f, -0.02850994f, -0.01306738f, -0.03509787f, -0.07439786f, -0.10165551f, 
    0.03391565f, -0.00684206f, -0.05232904f, 0.10054944f, -0.12816800f, -0.01422682f, -0.03000022f, 0.15914272f, 
    -0.21161002f, 0.24840589f, 0.22739679f, 0.28533655f, -0.08670034f, 0.00662335f, -0.02438427f, -0.00219745f, 
    0.12287111f, 0.11103974f, 0.00456252f, 0.05019161f, -0.27664533f, 0.00563002f, -0.04797704f, -0.06230846f, 
    0.02248337f, -0.27590489f, 0.00700325f, 0.05080086f, -0.00369899f, 0.04532982f, 0.00249452f, 0.10963462f, 
    0.11998046f, 0.37942323f, 0.20283556f, -0.02522775f, 0.08149503f, 0.09109132f, -0.07915318f, 0.28283644f, 
    -0.17722908f, -0.00236895f, -0.18314879f, -0.00279744f, 0.15728636f, -0.25060365f, 0.19974263f, 0.43453288f, 
    -0.06926341f, 0.14883901f, 0.02110314f, 0.17441106f, 0.16040060f, -0.08921376f, 0.04446738f, -0.09932957f, 
    0.01869521f, 0.01301882f, -0.00052223f, -0.06560601f, -0.09068941f, 0.04080940f, 0.18246219f, 0.00681010f, 
    -0.09871235f, 0.16522740f, -0.05478366f, -0.04928104f, 0.11671681f, 0.00210530f, 0.08348411f, 0.08407046f, 
    -0.03939045f, -0.02850494f, -0.06750118f, 0.00852767f, 0.08449372f, -0.03819421f, -0.06096862f, 0.07801652f, 
    -0.34267488f, -0.19633736f, -0.32331431f, 0.48335597f, -0.01170878f, 0.00067192f, -0.01195275f, 0.09498543f, 
    -0.17815597f, -0.04275180f, 0.21265092f, -0.04390849f, -0.16798976f, 0.22165886f, 0.25191936f, 0.00075689f, 
    -0.12232847f, -0.09168534f, 0.21911219f, 0.18791482f, 0.01062924f, -0.08503482f, -0.04457323f, 0.06747048f, 
    0.04826680f, 0.11610201f, -0.00259651f, 0.14212438f, 0.00778596f, -0.05156687f, -0.08126099f, 0.04064235f, 
    0.06395283f, -0.05374096f, 0.12394500f, -0.02300046f, 0.35306311f, 0.03850699f, 0.11716377f, 0.19129965f, 
    0.02469867f, 0.02794491f, -0.04795073f, -0.09553800f, 0.05318763f, 0.03506524f, 0.04131495f, 0.02390801f, 
    0.10933067f, -0.58717179f, -0.09257235f, -0.14205839f, -0.03258222f, 0.18369159f, 0.17627740f, 0.10732304f, 
    -0.07717302f, -0.02568016f, 0.05802765f, 0.16524212f, 0.04575968f, -0.14478923f, -0.02795069f, 0.05966746f, 
    0.10768637f, -0.02066603f, -0.02547572f, 0.03836047f, 0.06303509f, -0.04105942f, 0.02673098f, 0.17209610f, 
    0.31264621f, 0.03536760f, 0.23689602f, -0.09996597f, -0.16836078f, 0.10052629f, 0.04987382f, 0.12914696f, 
    -0.19730377f, 0.14348064f, 0.00378444f, 0.17884745f, -0.37853959f, -0.32974356f, -0.33253890f, 0.12465895f, 
    0.16037245f, 0.10316478f, -0.13254578f, 0.05415557f, -0.04248787f, -0.02228285f, -0.02475677f, -0.13290128f, 
    0.12477081f, -0.03316241f, 0.03295011f, 0.17630708f, 0.11231845f, 0.03296225f, 0.01653668f, -0.16869748f, 
    -0.05221582f, -0.09217991f, -0.02455853f, 0.03573386f, -0.01992331f, 0.05468205f, 0.03113772f, 0.11105088f, 
    0.11577334f, 0.03363761f, 0.06557346f, -0.02732809f, 0.28581718f, 0.31086120f, 0.15113784f, 0.19747488f, 
    -0.28650281f, 0.42518324f, 0.05550451f, -0.14016353f, -0.12573710f, 0.13425167f, 0.02095095f, 0.10316683f, 
    -0.10065396f, -0.07694716f, 0.13297866f, 0.06808612f, -0.27856776f, -0.39494103f, -0.71760786f, -0.71441275f, 
    0.11234649f, 0.10156854f, -0.05345769f, -0.00541992f, -0.16926229f, -0.11576182f, -0.09480947f, -0.03686303f, 
    -0.36700299f, 0.24553876f, 0.10777111f, 0.00398177f, 0.05130855f, -0.25070605f, -0.13939697f, 0.02704542f, 
    -0.13181181f, -0.02655115f, -0.02576360f, -0.00277672f, -0.10965256f, -0.15907112f, 0.04841504f, -0.21221818f, 
    0.14643119f, 0.09590141f, -0.09335015f, -0.01027906f, -0.22173125f, -0.06623078f, -0.04482738f, 0.03846331f, 
    0.01826133f, 0.09954679f, 0.08889610f, 0.04334621f, 0.02479934f, -0.04922385f, 0.00853228f, -0.04990668f, 
    -0.00923639f, -0.04221347f, 0.13813065f, -0.09582886f, -0.25213850f, -0.38362128f, -0.37481326f, 0.00912728f, 
    -0.04461241f, -0.01912553f, -0.01752401f, 0.04703420f, -0.00374376f, 0.07184212f, 0.14615849f, 0.11898097f, 
    -0.41948071f, 0.19533421f, 0.00735794f, -0.06503104f, -0.06803417f, 0.22158405f, -0.07010521f, 0.31484255f, 
    0.16052151f, -0.02437947f, 0.20073102f, 0.09217580f, -0.11869202f, -0.30086845f, 0.02835209f, 0.00913476f, 
    -0.03478270f, -0.12403315f, -0.00515777f, 0.11502153f, 0.28461179f, 0.05325451f, 0.13308957f, 0.05856824f, 
    -0.05232804f, -0.06895674f, 0.03540442f, -0.06154822f, 0.00227207f, -0.03487328f, -0.07570899f, -0.01927154f, 
    -0.02740260f, -0.00047261f, -0.06823871f, -0.01288457f, 0.02098064f, -0.04210751f, -0.02720128f, -0.01259492f, 
    0.03294021f, -0.04353448f, 0.00660708f, 0.00831360f, 0.00965792f, 0.02803852f, -0.05828158f, 0.02010836f, 
    -0.06630310f, 0.04514745f, 0.05902841f, 0.05251243f, 0.06744922f, -0.05751605f, 0.01938973f, -0.00026283f, 
    -0.01241580f, 0.00705370f, 0.00851419f, -0.05120445f, -0.02991616f, 0.04240479f, 0.02213334f, -0.04882350f, 
    -0.06158096f, -0.00246953f, -0.01978508f, -0.00118366f, -0.04705012f, 0.00886050f, -0.04489654f, 0.05413466f, 
    -0.01951197f, 0.01754806f, -0.06750917f, -0.07116362f, 0.02113373f, 0.01388317f, 0.02933813f, -0.00623102f, 
    0.03414391f, -0.00206730f, -0.06470460f, 0.04439184f, -0.02406381f, 0.00643096f, -0.06519728f, 0.01524044f, 
    -0.06997666f, -0.01488545f, -0.02155396f, 0.04934833f, -0.02877278f, -0.04446600f, -0.02751485f, -0.00538696f, 
    -0.03712365f, 0.04117368f, -0.04638075f, 0.00501321f, 0.05804374f, 0.04550691f, 0.01851583f, 0.04489248f, 
    0.02496040f, 0.00532235f, -0.00985543f, -0.07938227f, -0.04332246f, 0.01169942f, 0.00257556f, 0.00616366f, 
    0.05507704f, -0.04523720f, -0.03925356f, -0.03945977f, 0.01974982f, 0.03263382f, -0.02589182f, -0.03684960f, 
    -0.02057716f, 0.03406715f, 0.04301775f, 0.00201265f, -0.00901309f, -0.06375148f, -0.01133925f, 0.00907571f, 
    -0.07731501f, 0.01747376f, -0.00170377f, -0.05688595f, 0.02166193f, -0.01134674f, -0.06626368f, -0.01499299f, 
    -0.06403225f, -0.00217064f, -0.02886681f, -0.04227132f, -0.07104223f, 0.01213882f, -0.03649922f, 0.03758456f, 
    0.03623751f, -0.03413265f, -0.02070514f, 0.01313632f, -0.05870610f, -0.03680936f, 0.02515453f, -0.00060646f, 
    0.02567118f, -0.04499857f, 0.02997269f, -0.07973170f, -0.02244930f, -0.02662145f, -0.06111994f, -0.06542537f, 
    -0.03669822f, 0.02528020f, -0.05543903f, -0.06464106f, 0.00431796f, -0.04775498f, -0.00732231f, -0.01350075f, 
    0.00809723f, 0.04440978f, -0.02279632f, -0.02207400f, 0.04167639f, 0.01807948f, -0.05403959f, -0.02777460f, 
    0.02832866f, -0.02614385f, -0.06161619f, -0.03504514f, 0.00390660f, -0.05702702f, -0.05196996f, -0.02450397f, 
    -0.02390941f, 0.02079780f, -0.06191742f, -0.04149058f, -0.02735882f, -0.06694489f, -0.02981077f, -0.02270225f, 
    0.05393206f, 0.01225973f, 0.03209389f, -0.00914172f, 0.03144258f, 0.05848211f, 0.03003668f, 0.03971979f, 
    0.04369196f, 0.02317814f, 0.04615943f, -0.02204240f, -0.00725015f, 0.02781093f, -0.03548663f, 0.00008404f, 
    0.00797962f, -0.06979208f, -0.04093062f, -0.03880283f, -0.02887136f, -0.05907679f, -0.04207063f, -0.03822329f, 
    0.32916880f, -0.17897496f, -0.01285919f, -0.05021637f, -0.18980597f, 0.17357713f, -0.03928614f, 0.24042600f, 
    -0.06144952f, 0.00834780f, -0.00304541f, 0.03341727f, 0.07680243f, 0.15114060f, 0.23745200f, -0.25816181f, 
    0.22550680f, -0.06414821f, 0.23078595f, 0.04567337f, -0.07792050f, 0.08628900f, 0.00020832f, -0.13835064f, 
    -0.15012431f, -0.02515347f, -0.09617662f, 0.06806453f, -0.02188986f, -0.10420094f, 0.03231123f, -0.13049226f, 
    0.01090470f, -0.03042843f, -0.02538329f, 0.14153102f, -0.06489566f, 0.14398348f, -0.05180138f, 0.06245626f, 
    -0.15189382f, -0.13815576f, 0.15300773f, 0.08919798f, 0.05635288f, -0.02344965f, 0.15238672f, 0.26539722f, 
    0.02625089f, -0.27386591f, 0.01946150f, 0.09964535f, -0.04082159f, 0.01892446f, -0.02696804f, 0.14048484f, 
    0.08004306f, 0.20537677f, 0.28670254f, 0.15212101f, -0.15242186f, 0.11504786f, 0.16764767f, 0.10293999f, 
    0.08875722f, -0.02643040f, 0.01077446f, 0.05955382f, 0.19798842f, 0.07137132f, 0.00459954f, 0.04839954f, 
    0.33415365f, 0.20118161f, 0.05890984f, 0.00317943f, 0.23748192f, 0.02964260f, -0.06426352f, -0.02917395f, 
    -0.25348270f, -0.11199140f, -0.23803358f, -0.17008273f, -0.06593920f, 0.09390803f, -0.17347372f, -0.04310565f, 
    0.08640532f, -0.13790618f, -0.12112299f, 0.02522289f, 0.31527174f, 0.33336133f, 0.22468583f, 0.27214232f, 
    0.05653202f, 0.00930383f, 0.15761405f, 0.27244616f, -0.02451408f, -0.09069698f, -0.36092880f, 0.18665266f, 
    0.16218404f, -0.12902457f, -0.00761322f, 0.03929871f, -0.15063530f, -0.15023001f, -0.03353370f, 0.12621711f, 
    -0.05526360f, -0.06408853f, -0.06447832f, -0.05112909f, -0.01641753f, -0.11160520f, -0.14758186f, -0.02240235f, 
    0.24329379f, 0.22964002f, 0.12971132f, 0.22448775f, -0.11312846f, -0.06831552f, -0.04993046f, -0.08286250f, 
    -0.14195579f, -0.25273889f, -0.22163045f, -0.10904866f, -0.27930146f, -0.44455361f, 0.02975722f, 0.31357586f, 
    -0.06543494f, 0.03942613f, -0.01522889f, -0.11538933f, -0.02708772f, -0.13606161f, 0.09188157f, 0.00650874f, 
    0.00124818f, -0.01047766f, -0.12410498f, 0.05323838f, 0.10686537f, 0.09939898f, -0.14433120f, 0.07965264f, 
    -0.24998413f, -0.02591837f, 0.00655445f, -0.19300310f, -0.22560099f, -0.07971293f, 0.14403674f, 0.05601077f, 
    -0.09535840f, 0.06558393f, 0.07753199f, 0.04991697f, 0.08565668f, 0.10788886f, 0.19234119f, 0.18626429f, 
    0.15640488f, -0.16530263f, -0.43676287f, 0.40554270f, 0.04193554f, -0.04387857f, 0.05287928f, -0.07740512f, 
    -0.00289580f, 0.10999829f, 0.11025656f, 0.05545303f, -0.03832117f, 0.13951150f, 0.16549094f, 0.03373017f, 
    -0.04520667f, -0.11929106f, 0.11411870f, -0.08080956f, 0.01397415f, -0.05108639f, 0.04944846f, 0.03719213f, 
    0.17494422f, -0.18089482f, 0.01354389f, 0.01439345f, -0.01606419f, 0.08108745f, -0.16954666f, 0.12233208f, 
    -0.03165983f, -0.06749679f, -0.11332628f, -0.01117207f, 0.23849541f, 0.05316808f, 0.07613414f, -0.15174776f, 
    0.10062581f, -0.09321852f, 0.16458945f, 0.11792271f, -0.02439241f, 0.03109563f, -0.05193533f, -0.16783792f, 
    -0.15334213f, 0.13481349f, 0.13334537f, -0.03787060f, 0.13333698f, -0.14572226f, -0.03897678f, -0.12506822f, 
    0.03737327f, 0.08612625f, 0.07387733f, 0.04854302f, -0.22695118f, 0.14373280f, -0.21304667f, -0.17318399f, 
    -0.08373903f, -0.07261302f, 0.19207190f, -0.00159106f, -0.02052045f, -0.16478905f, 0.02650324f, 0.21137254f, 
    -0.07342646f, -0.42518380f, -0.08115482f, 0.04749369f, 0.18111216f, -0.01513694f, 0.04316672f, -0.06045214f, 
    -0.03058213f, 0.07991665f, -0.00290417f, 0.07098966f, -0.04303287f, 0.29816797f, 0.13325946f, 0.16045077f, 
    -0.07424571f, -0.17740649f, 0.16606747f, -0.11937772f, -0.06756669f, -0.02050180f, 0.06749417f, 0.05382268f, 
    0.48303768f, 0.34608287f, 0.15349174f, 0.03212459f, 0.00543430f, 0.05358358f, -0.06828418f, 0.09805558f, 
    0.05622458f, -0.04047811f, -0.07334578f, -0.08486847f, 0.17746472f, 0.09259984f, 0.10024679f, 0.06664331f, 
    -0.04586950f, -0.06343459f, -0.07199664f, -0.01528336f, 0.20273256f, 0.07470279f, 0.13130972f, 0.13111490f, 
    -0.04942169f, -0.41161188f, -0.00400785f, 0.07664820f, 0.14816603f, 0.03135072f, -0.08935693f, 0.07360328f, 
    0.12039962f, -0.10970166f, 0.01760984f, -0.02108476f, 0.13199535f, 0.19844192f, 0.43819365f, 0.36148623f, 
    -0.18753660f, -0.06579707f, 0.00797672f, 0.02413609f, 0.06482024f, 0.00120511f, -0.09571145f, -0.12575278f, 
    0.24661799f, -0.00014949f, -0.26747313f, 0.09229387f, 0.03117956f, 0.04503250f, 0.07383217f, -0.04489415f, 
    0.21730541f, -0.01415570f, -0.12058113f, 0.02814425f, -0.15637705f, -0.17734250f, 0.00719231f, 0.02865358f, 
    0.03759644f, 0.06690067f, 0.22999138f, -0.20853493f, -0.12427194f, -0.09407528f, -0.03485405f, 0.03896445f, 
    0.00861912f, -0.09637049f, -0.02322676f, -0.07297355f, 0.13402650f, 0.03927310f, -0.13053121f, 0.06721810f, 
    0.08140007f, 0.03798063f, -0.10689928f, 0.06677496f, -0.05333447f, -0.01718215f, 0.11870919f, -0.14378858f, 
    -0.08593241f, -0.01465392f, 0.01518867f, -0.00894781f, -0.03671570f, 0.01373634f, 0.05707549f, 0.15974037f, 
    0.01398902f, 0.02643393f, -0.10785030f, 0.23262101f, 0.16247874f, -0.24872300f, -0.00374254f, -0.20498341f, 
    -0.06172404f, 0.08130904f, -0.08190610f, -0.06054860f, -0.20872597f, 0.07158580f, -0.01289880f, 0.00752734f, 
    0.03396549f, -0.00520814f, 0.14763187f, -0.21937907f, 0.06309672f, -0.02902032f, 0.05277686f, -0.06081439f, 
    -0.05885001f, -0.30384198f, -0.08900086f, 0.00031231f, 0.03753021f, 0.08711818f, -0.14167273f, 0.08473662f, 
    0.00497848f, 0.00636403f, -0.01108310f, -0.02333096f, -0.34664893f, -0.21771565f, -0.28505936f, -0.33696657f, 
    -0.13942257f, -0.06572343f, -0.09152645f, -0.10323814f, -0.11943907f, -0.02465043f, 0.10800627f, 0.11371592f, 
    0.04126706f, 0.06274249f, -0.06956443f, 0.05670830f, 0.00006246f, -0.02292444f, -0.19822285f, 0.09746989f, 
    -0.11870890f, -0.06622119f, -0.00746687f, 0.04300957f, -0.00836015f, 0.13786781f, 0.29957661f, 0.10069662f, 
    0.12198885f, 0.25978351f, -0.08317694f, -0.11731894f, 0.04154071f, 0.18034782f, -0.07508688f, 0.03329764f, 
    -0.00043703f, -0.50271487f, 0.13765086f, -0.12549949f, 0.03195829f, -0.13786815f, 0.04078157f, -0.04825212f, 
    -0.04744527f, 0.04828013f, -0.16992916f, -0.07749263f, -0.07468694f, 0.26859429f, -0.01940150f, -0.30450657f, 
    -0.07789993f, -0.04636416f, 0.04504463f, -0.01839811f, -0.01911537f, 0.07606543f, 0.11495599f, -0.04105251f, 
    -0.24572478f, 0.25992784f, -0.25832987f, -0.04246227f, -0.17187224f, -0.26800099f, -0.06703638f, -0.12952441f, 
    0.02590283f, -0.01247701f, 0.08994931f, 0.06390814f, -0.13313729f, -0.04093330f, -0.07801636f, -0.23399070f, 
    -0.01506839f, -0.16768798f, -0.10022987f, 0.00098096f, -0.00736594f, -0.01941319f, 0.00625844f, 0.13949689f, 
    -0.20882204f, 0.25470641f, 0.02092806f, 0.06901634f, -0.01851698f, 0.14244698f, 0.01724876f, 0.09092602f, 
    0.04754791f, -0.08300710f, 0.02606210f, -0.03905698f, 0.13887505f, 0.05790339f, 0.12538785f, -0.09240119f, 
    0.03592613f, -0.16066788f, -0.01289827f, 0.08433361f, 0.05428626f, -0.01530019f, -0.03626397f, 0.02048721f, 
    0.28590152f, 0.30218330f, 0.16457179f, 0.09486580f, 0.11434264f, 0.17453887f, -0.04075599f, 0.04500871f, 
    0.00007940f, 0.01897109f, -0.13513608f, -0.11397447f, 0.35365501f, 0.01812794f, 0.52333474f, 0.10873391f, 
    -0.03459114f, -0.01788943f, 0.11116753f, 0.10442869f, 0.11958288f, 0.04959716f, 0.02191853f, -0.07612514f, 
    0.04375518f, -0.22852378f, -0.07549818f, -0.01638519f, -0.01094865f, 0.12309054f, 0.06283654f, 0.05607826f, 
    -0.11123379f, -0.00475939f, -0.09816629f, 0.05755561f, 0.45045161f, 0.22671157f, 0.12677537f, -0.02579056f, 
    -0.02334150f, -0.04059728f, -0.03023426f, -0.02982255f, 0.02049826f, -0.00128892f, 0.07511063f, 0.10119271f, 
    -0.02800861f, 0.25245062f, 0.11000258f, 0.05229926f, -0.05790978f, 0.02691725f, -0.00070612f, 0.22239597f, 
    0.04640737f, 0.00176112f, -0.01980734f, -0.03768458f, 0.10520446f, 0.16617139f, 0.16736950f, 0.07893573f, 
    0.04594918f, 0.04250374f, -0.09587146f, -0.03716395f, -0.01014541f, 0.02558567f, -0.02939461f, 0.07036562f, 
    0.03735715f, -0.05493740f, -0.01324340f, 0.01056340f, 0.05636526f, 0.00970701f, -0.03531733f, 0.04615881f, 
    -0.01695368f, 0.01449827f, -0.00996651f, -0.01193113f, -0.04211686f, -0.02027074f, -0.03994092f, -0.03087819f, 
    -0.01337607f, -0.07198016f, 0.02120035f, -0.01051392f, -0.03487016f, -0.01182017f, 0.05664486f, 0.02153064f, 
    -0.05184338f, -0.01569272f, -0.04696511f, -0.05626388f, -0.01611738f, 0.00369231f, 0.02505061f, -0.04464824f, 
    -0.07263058f, 0.03424883f, -0.05607838f, 0.04797555f, 0.03017282f, 0.01304454f, -0.04470766f, -0.03162969f, 
    0.03147735f, -0.07697285f, -0.03602710f, 0.05468867f, -0.07399841f, -0.00901982f, -0.03091413f, 0.04179905f, 
    -0.01733524f, -0.05542812f, 0.02417268f, -0.05933596f, -0.02266278f, 0.01453431f, -0.03910489f, 0.06208718f, 
    -0.01770682f, 0.04402551f, 0.01996572f, 0.00201874f, -0.06419727f, 0.01406142f, 0.01077764f, -0.08019871f, 
    -0.05773236f, 0.05986740f, 0.00951290f, -0.05906466f, 0.02395231f, -0.05680562f, 0.04516831f, -0.05923195f, 
    0.04471716f, -0.06915118f, -0.04516809f, 0.04305848f, -0.05078043f, 0.00279077f, 0.04624456f, 0.00718439f, 
    -0.07268400f, -0.03484803f, -0.04000081f, 0.04256975f, 0.04148599f, -0.07037520f, -0.02958749f, 0.06149112f, 
    0.01364546f, 0.01509924f, -0.06034643f, -0.00441773f, -0.03142851f, 0.05336047f, -0.05041592f, -0.05926471f, 
    0.04462251f, -0.00334129f, -0.01644668f, 0.04814050f, 0.03800929f, -0.03897594f, 0.04182438f, -0.05850936f, 
    -0.06065419f, 0.03389687f, -0.01082603f, 0.05603698f, 0.05044394f, 0.02611187f, -0.06678511f, 0.05064959f, 
    -0.06987408f, 0.05536465f, -0.06691755f, -0.04227399f, -0.02058979f, -0.03945010f, -0.03245015f, -0.07644945f, 
    0.03507127f, 0.02398155f, -0.02548963f, 0.02392682f, -0.07357966f, 0.05913887f, -0.04048333f, -0.03956382f, 
    0.06575149f, -0.04894698f, -0.07410404f, -0.03477630f, 0.05067134f, -0.03516607f, 0.05671349f, -0.04840898f, 
    -0.00353673f, 0.05551133f, -0.07479950f, 0.00907353f, -0.00989483f, 0.00196185f, 0.05976595f, -0.07034987f, 
    -0.01657668f, -0.04907830f, -0.01553411f, 0.01159482f, -0.04735577f, 0.01017940f, -0.03398405f, -0.01128281f, 
    -0.07360835f, -0.05468061f, 0.01274700f, -0.06481852f, 0.04498976f, -0.01043128f, 0.01608486f, 0.03618865f, 
    -0.06248059f, 0.05111501f, 0.06182906f, 0.03114143f, 0.00599943f, -0.01117846f, -0.03413146f, 0.04294611f, 
    0.04152382f, -0.05833337f, -0.04682700f, -0.05928981f, 0.01311201f, 0.05333746f, 0.03692058f, 0.02370211f, 
    -0.03052300f, -0.02663078f, -0.03610176f, 0.00896967f, -0.01457687f, -0.06859624f, -0.00843788f, -0.02577948f, 
    0.00161016f, -0.02547465f, 0.05155712f, -0.05893862f, 0.03473886f, -0.02854876f, -0.03596232f, -0.03208044f, 
    -0.26006350f, -0.54733896f, -0.21153653f, -0.10652229f, -0.04634316f, -0.05889611f, -0.28602222f, -0.14410555f, 
    0.04184127f, -0.03679246f, -0.06525359f, 0.16521206f, -0.30243883f, -0.23830938f, -0.28569269f, -0.28283426f, 
    0.01876033f, -0.07572219f, -0.33466062f, 0.01384072f, -0.16011544f, 0.09009840f, -0.03964299f, -0.04108459f, 
    -0.06147976f, 0.18853241f, 0.00595395f, 0.09240183f, 0.15244131f, 0.11521620f, 0.01461686f, 0.04032481f, 
    0.03022852f, -0.06821964f, -0.11974076f, -0.01570110f, -0.11108822f, 0.28672069f, 0.23056720f, 0.06976673f, 
    0.15288942f, 0.05722983f, 0.11822012f, 0.00010546f, 0.10747939f, 0.05735037f, 0.15680715f, 0.19979700f, 
    -0.14345913f, -0.41451675f, 0.03741886f, 0.20977281f, 0.07041655f, -0.00115845f, -0.12567864f, -0.11200831f, 
    0.09076235f, 0.03934665f, 0.06060223f, 0.03863322f, 0.14937884f, 0.11899691f, -0.01415302f, -0.29200232f, 
    0.04452167f, -0.15738475f, 0.03229148f, 0.11547004f, 0.12725756f, 0.10147657f, -0.00208363f, 0.01079924f, 
    -0.29123282f, -0.07125379f, -0.14664190f, -0.19452223f, 0.02422074f, -0.08853080f, 0.00550279f, -0.05590551f, 
    -0.16488947f, -0.18246624f, -0.03276993f, -0.14618057f, -0.16136986f, -0.12081682f, -0.15401246f, -0.29619497f, 
    0.07729524f, -0.13981894f, -0.18453778f, 0.05606200f, -0.01291266f, 0.05928304f, 0.07459425f, 0.11950174f, 
    -0.16115932f, 0.15904051f, 0.29693055f, 0.32549742f, -0.02449038f, -0.03193961f, 0.02593216f, 0.02410232f, 
    0.14448066f, -0.03135929f, 0.03058303f, 0.17016980f, 0.11351626f, 0.17734571f, 0.23984498f, 0.00030393f, 
    0.07796623f, -0.00327877f, 0.00494078f, 0.14704767f, 0.06502782f, 0.00064958f, 0.12424774f, 0.12361956f, 
    0.30455732f, 0.04044398f, 0.04078082f, 0.01986406f, 0.00920846f, 0.08713924f, -0.10858613f, -0.03255155f, 
    -0.06739572f, -0.04681046f, -0.28496695f, 0.01685805f, 0.06896133f, -0.10732076f, 0.48823214f, 0.16439742f, 
    -0.16488473f, 0.13764930f, 0.04609496f, -0.00404304f, 0.24735968f, 0.05408521f, -0.05947724f, -0.07085983f, 
    -0.37384567f, -0.24339248f, -0.30555883f, -0.12447957f, 0.09205267f, 0.02258861f, -0.04493822f, -0.01647449f, 
    -0.08770265f, 0.10390093f, -0.15236178f, 0.06339410f, 0.31177792f, 0.07634111f, 0.36892474f, -0.07163259f, 
    -0.03212708f, 0.05297884f, -0.07950445f, 0.12288202f, 0.01426651f, 0.02008138f, 0.01034367f, 0.09422611f, 
    -0.01456044f, 0.06197495f, 0.36933166f, 0.17888927f, -0.11534745f, 0.10370363f, -0.02170479f, -0.02427621f, 
    -0.11202149f, 0.01013409f, 0.12532073f, 0.02538672f, 0.02776763f, 0.33130923f, 0.07554293f, 0.16189310f, 
    0.13009024f, -0.03156779f, -0.04772598f, -0.05647749f, 0.06666247f, -0.01924847f, 0.06410889f, 0.07882141f, 
    -0.08480570f, 0.00753072f, 0.03349310f, -0.03689593f, 0.00301254f, -0.04100754f, 0.03652943f, 0.04414411f, 
    -0.02740730f, 0.03861126f, -0.07670237f, 0.02941363f, 0.02521382f, 0.00602505f, 0.01111403f, -0.05333772f, 
    0.03355778f, -0.00733803f, 0.02332343f, 0.00461544f, -0.02551980f, -0.04825576f, 0.02290243f, -0.06255941f, 
    0.00054948f, 0.05066111f, 0.02058478f, 0.02562260f, -0.03956069f, 0.01715395f, 0.04554284f, -0.07683185f, 
    -0.02778047f, 0.02078420f, 0.01882865f, -0.01090125f, 0.00309585f, 0.05454176f, 0.06393515f, -0.02792345f, 
    0.03516373f, -0.02822647f, 0.02924462f, -0.00409591f, 0.05512504f, -0.02368747f, -0.04213596f, 0.04553556f, 
    -0.04101244f, -0.07713263f, -0.04193697f, -0.02342835f, 0.01644707f, 0.03059737f, -0.02400116f, -0.05325508f, 
    -0.00141986f, -0.01480004f, 0.00466804f, -0.04361358f, 0.02180231f, -0.00049948f, 0.03362063f, -0.03025829f, 
    -0.00076594f, 0.02725289f, 0.02790121f, -0.00626621f, -0.04278696f, 0.03738261f, -0.04238801f, 0.00019570f, 
    -0.03839657f, 0.00432931f, 0.03287530f, 0.02982628f, -0.02592905f, 0.02691920f, -0.07858806f, -0.03546017f, 
    -0.04400857f, -0.01856209f, -0.03010402f, 0.03548462f, 0.03930536f, 0.03680529f, 0.03935964f, -0.07937378f, 
    -0.04357144f, -0.00954519f, 0.03454445f, -0.04660554f, -0.05587297f, 0.04957414f, -0.03480560f, 0.04020687f, 
    -0.06897524f, -0.03071874f, -0.04645194f, -0.02873056f, -0.03705399f, 0.00805075f, -0.01980647f, 0.01109840f, 
    -0.06559737f, -0.06116396f, 0.03424855f, 0.03436778f, -0.01837080f, -0.04981001f, -0.06779741f, -0.04828157f, 
    -0.03836698f, -0.06759939f, 0.05788663f, -0.07354964f, -0.04336108f, -0.02640101f, -0.08106229f, -0.04660110f, 
    0.01556612f, -0.05063506f, -0.00855947f, 0.04275677f, -0.01503614f, 0.01726748f, 0.05407179f, 0.04982340f, 
    -0.03525124f, 0.05327128f, 0.03839166f, 0.05555385f, -0.00145038f, -0.06945029f, -0.00870222f, -0.02896982f, 
    -0.07069091f, -0.00590789f, 0.01968392f, 0.02139832f, 0.03929477f, -0.05226969f, -0.02049619f, 0.05245189f, 
    -0.08419921f, 0.04219278f, -0.02265197f, -0.02658580f, 0.00458567f, 0.01267663f, -0.04282595f, -0.07749250f, 
    -0.01631505f, -0.06501835f, -0.05780757f, -0.00862121f, 0.02529418f, 0.04603808f, -0.07588249f, 0.03712756f, 
    -0.02412019f, 0.03746564f, 0.05059161f, 0.02370227f, -0.00410618f, -0.01912379f, -0.04150480f, 0.04932138f, 
    -0.00147260f, -0.01042629f, 0.03298703f, -0.04362855f, -0.08498672f, -0.07707581f, -0.05647874f, -0.03846822f, 
    -0.03102993f, -0.02281687f, -0.01329504f, -0.01556275f, 0.01221515f, -0.03660514f, -0.05702705f, 0.06325895f, 
    0.01375241f, -0.03913780f, -0.06361393f, 0.03701131f, 0.02797569f, -0.00665334f, -0.04406477f, 0.01515796f, 
    -0.39047667f, -0.31237823f, -0.39346844f, -0.34662804f, 0.01418504f, -0.02309143f, -0.09793220f, -0.06275155f, 
    -0.02788339f, 0.04859030f, 0.08319100f, -0.00949660f, -0.24342482f, -0.53780437f, -0.36614776f, -0.27262151f, 
    -0.13506661f, -0.02782655f, -0.07343312f, -0.14285211f, -0.08517179f, -0.15378913f, -0.02191674f, 0.00347501f, 
    0.22761382f, 0.29603902f, 0.02576078f, 0.14425106f, -0.06296948f, -0.01654285f, 0.00007095f, 0.06424672f, 
    0.00198511f, -0.04628881f, -0.10051627f, -0.02627271f, 0.07277887f, -0.04730816f, 0.00889326f, 0.07217562f, 
    0.18751556f, -0.02499464f, -0.05861636f, 0.26231229f, 0.04667799f, 0.00443043f, 0.00148536f, 0.05147034f, 
    -0.21253255f, -0.08358672f, -0.07933470f, -0.15118404f, 0.01556388f, 0.04214802f, 0.01901813f, -0.05080960f, 
    -0.13074066f, -0.06508436f, -0.06102636f, 0.03790874f, 0.24552676f, 0.09088537f, 0.37313694f, 0.20346396f, 
    -0.05465285f, 0.08922410f, 0.06561574f, 0.14266078f, -0.07791733f, 0.00978537f, 0.10171466f, -0.01102013f, 
    0.01366922f, -0.10441909f, -0.47551373f, -0.37039113f, -0.15956242f, -0.17261043f, -0.16331226f, -0.16834818f, 
    0.05433986f, 0.03699470f, 0.01249773f, 0.04140932f, -0.08486591f, -0.14431860f, -0.07590584f, -0.15850832f, 
    -0.12590459f, -0.01886437f, -0.14398827f, -0.11601682f, -0.16517462f, -0.07750123f, -0.22752091f, 0.02645439f, 
    0.18869023f, 0.12521815f, -0.20144011f, -0.14041823f, -0.02449690f, 0.03343722f, 0.03608056f, 0.01510305f, 
    -0.01633025f, 0.03458039f, -0.00751528f, 0.02296103f, 0.28433195f, 0.23825964f, 0.34131628f, 0.32787684f, 
    -0.11899414f, -0.09837786f, 0.07560958f, 0.06208160f, 0.02763462f, -0.03534307f, -0.00101418f, -0.04403923f, 
    0.32743064f, 0.30314299f, 0.05047470f, 0.00977766f, 0.05577407f, 0.05466620f, 0.13460407f, 0.17071189f, 
    -0.05870310f, 0.11808138f, 0.07418853f, -0.09249129f, 0.09292513f, 0.05192966f, 0.17068118f, -0.05546603f, 
    0.06576942f, 0.12412927f, 0.10957051f, -0.02518461f, 0.08705039f, 0.05010280f, 0.01676101f, -0.02360645f, 
    -0.22811793f, -0.20846164f, -0.25905028f, -0.04806132f, -0.04055443f, -0.04103196f, 0.04917905f, -0.10850569f, 
    -0.07726259f, -0.16367972f, -0.06981396f, -0.00948808f, 0.46059999f, 0.14891566f, 0.13650775f, 0.14139053f, 
    0.07891914f, 0.04540312f, -0.04361187f, 0.03110068f, -0.07139930f, -0.01380036f, -0.05136999f, -0.07558424f, 
    -0.08785725f, 0.20545846f, 0.22051285f, -0.02673513f, 0.01404770f, -0.12105206f, -0.16115049f, 0.07866360f, 
    -0.06496371f, 0.06409325f, -0.02160763f, 0.11265036f, 0.40753537f, 0.18469945f, 0.04800427f, 0.25640950f, 
    0.11946789f, 0.04736011f, 0.08685825f, 0.00628848f, 0.06288181f, 0.13910520f, -0.00572240f, 0.14322174f, 
    0.11129995f, -0.06924627f, 0.05923771f, -0.10867274f, -0.12259331f, 0.01989030f, -0.10204533f, -0.03900515f, 
    0.10692763f, -0.09309261f, 0.15651697f, -0.00501953f, 0.09129502f, 0.15172756f, 0.24982348f, 0.17067392f, 
    -0.01899860f, -0.07851391f, 0.08066596f, -0.08165877f, 0.06941366f, -0.03976577f, -0.01106335f, 0.03222691f, 
    0.08549933f, -0.00406811f, 0.10699160f, -0.08781574f, 0.04979792f, 0.12222949f, -0.18642029f, 0.04368328f, 
    0.03433996f, 0.06989036f, 0.02885769f, -0.05999135f, 0.10436625f, -0.20676912f, -0.15294391f, 0.02231191f, 
    0.11091051f, 0.11546754f, -0.07912941f, 0.21118778f, -0.06234786f, 0.05145005f, -0.06709668f, -0.12594667f, 
    -0.06032005f, 0.31149974f, -0.09699076f, -0.35913375f, -0.05810062f, -0.00146423f, 0.00135150f, -0.07403414f, 
    0.15339470f, -0.03325864f, -0.04028130f, 0.04948495f, -0.20765848f, -0.15392579f, -0.02027422f, 0.21144386f, 
    0.01622297f, 0.10338524f, 0.10447478f, -0.06559188f, -0.02155031f, -0.10327911f, 0.11635488f, 0.10474349f, 
    -0.12142057f, -0.03186875f, 0.09294771f, 0.05718079f, -0.15664591f, -0.03807594f, -0.00141805f, 0.09433537f, 
    -0.00182473f, -0.01201935f, 0.01715381f, 0.10491119f, -0.09825294f, 0.03990790f, 0.07587434f, -0.07407707f, 
    -0.01539078f, 0.07584358f, 0.02473761f, 0.08254357f, 0.05522050f, -0.02849350f, -0.01780671f, -0.05811489f, 
    -0.01384098f, -0.04842731f, -0.23891084f, -0.39490730f, 0.10977270f, -0.07079285f, 0.11597551f, -0.02346633f, 
    -0.11150219f, 0.18665308f, 0.09033322f, 0.01441202f, 0.13125627f, 0.00310143f, -0.04010485f, 0.03072156f, 
    0.01301633f, 0.11457440f, 0.10125414f, -0.05170327f, -0.01910348f, 0.07480397f, 0.03116207f, -0.06439044f, 
    -0.21954492f, -0.19214246f, -0.06268588f, 0.02436592f, -0.00657847f, -0.05566012f, 0.08434978f, -0.05505028f, 
    0.05760020f, 0.03924355f, 0.12777373f, -0.06699099f, -0.21897766f, 0.39205199f, -0.02053017f, -0.33885756f, 
    0.22646925f, 0.02600663f, 0.04788781f, 0.04029200f, -0.20403077f, 0.03772740f, -0.06220810f, 0.12174568f, 
    0.02010626f, 0.04235040f, 0.06072280f, 0.08549523f, -0.05657651f, 0.07099431f, -0.16007347f, -0.01744344f, 
    0.09053607f, -0.10406054f, 0.13898280f, 0.05663437f, -0.17712645f, 0.08294233f, -0.07799596f, 0.14260048f, 
    0.05013863f, 0.00011425f, 0.11173537f, 0.11840748f, 0.01368562f, 0.03810753f, -0.03832350f, -0.05859920f, 
    0.22223094f, 0.14353012f, 0.25535131f, -0.18354572f, 0.10076467f, -0.03149248f, 0.14736368f, 0.18380740f, 
    0.20370452f, 0.23407093f, 0.10696557f, 0.04764009f, 0.07535025f, -0.03249391f, -0.12280004f, 0.07218360f, 
    0.07557163f, 0.16156751f, -0.12867965f, 0.06658593f, 0.07127075f, 0.19650127f, 0.23090230f, 0.11443984f, 
    -0.05304004f, 0.01550794f, -0.01109512f, -0.04357414f, -0.08070940f, -0.04124677f, 0.01581536f, -0.05129605f, 
    0.02489474f, 0.05504994f, 0.00676501f, -0.04468268f, -0.02509438f, 0.04256677f, 0.01146280f, 0.02370006f, 
    -0.03078208f, 0.01680776f, 0.05352052f, -0.02583778f, 0.01191226f, 0.05754254f, -0.02678082f, 0.01648501f, 
    0.03134078f, 0.00775681f, 0.04383944f, -0.06291735f, -0.05816620f, -0.04512923f, -0.00401369f, -0.02918531f, 
    0.01143651f, 0.01020770f, -0.00882033f, -0.04080071f, -0.01896646f, 0.01164391f, -0.06644249f, 0.00083333f, 
    -0.02363660f, -0.03962648f, -0.07092970f, 0.02291827f, 0.01710068f, 0.04055944f, -0.00127607f, 0.01902647f, 
    -0.07127930f, 0.04271438f, -0.02402387f, 0.00534100f, -0.00610848f, -0.03478899f, 0.04128598f, -0.05556262f, 
    0.05797555f, -0.00608146f, -0.02773977f, 0.00751737f, 0.02015999f, 0.02697222f, -0.00730544f, -0.03069613f, 
    0.01964731f, 0.00902526f, -0.06473573f, -0.05417325f, 0.05714271f, -0.06162623f, -0.03648802f, -0.02767782f, 
    0.04613394f, -0.03561088f, 0.03771476f, -0.03734144f, -0.01234551f, -0.02618259f, -0.05244517f, 0.04912233f, 
    -0.06025009f, -0.06583814f, -0.02385707f, -0.04150921f, -0.06640188f, 0.04869809f, 0.01798344f, -0.06865216f, 
    -0.03937708f, -0.05439268f, -0.05586940f, -0.02138272f, -0.06468493f, -0.07981561f, -0.06372716f, -0.03249552f, 
    0.02400132f, -0.03290910f, 0.03604816f, -0.06178814f, 0.01443393f, 0.00986419f, -0.05623456f, 0.02259342f, 
    0.05184669f, 0.06246790f, 0.05391603f, 0.01296132f, -0.05969959f, 0.03623058f, -0.00941172f, -0.00719499f, 
    -0.01364970f, 0.00710382f, -0.04402266f, 0.03245934f, -0.00801151f, 0.02804495f, 0.01399204f, -0.02808697f, 
    0.03084671f, 0.04997305f, -0.07661335f, -0.06025108f, 0.00397988f, 0.02979050f, -0.00254398f, 0.03543380f, 
    0.03161120f, -0.02664049f, -0.03861387f, -0.06765936f, -0.06559897f, -0.03511075f, -0.06003403f, 0.04242004f, 
    0.04884091f, -0.02635406f, -0.05114365f, 0.00708338f, 0.01540085f, 0.06024989f, 0.04481053f, -0.07611342f, 
    0.00723163f, -0.03728940f, 0.00910448f, -0.05093798f, -0.06811158f, -0.04357224f, 0.05356148f, 0.00816546f, 
    0.00634812f, -0.00483667f, 0.00376558f, -0.04100932f, -0.04398077f, -0.03985481f, 0.00397709f, -0.06009527f, 
    0.00206517f, 0.04736993f, -0.05791757f, -0.02713665f, 0.00722940f, -0.01024625f, -0.00485913f, -0.05664669f, 
    -0.02255816f, -0.05793213f, -0.05737220f, 0.05145423f, 0.03360382f, 0.02678570f, 0.01700503f, 0.05308425f, 
    -0.05269666f, 0.00663149f, -0.03657388f, -0.04163976f, 0.00770414f, -0.03096641f, -0.01133377f, 0.01851109f, 
    0.00664734f, -0.02970238f, 0.01330702f, 0.05086614f, 0.06797889f, -0.03992637f, -0.07622340f, 0.01906060f, 
    0.04179342f, -0.03376545f, -0.07556564f, -0.07347923f, -0.06093249f, -0.03449338f, 0.05724103f, -0.00753825f, 
    -0.04821982f, 0.02188612f, -0.02196771f, 0.00520503f, 0.05811852f, -0.07355449f, 0.03452027f, 0.03814387f, 
    -0.01143945f, -0.02561095f, -0.07177934f, 0.03113035f, 0.00589991f, -0.07416763f, -0.04115424f, -0.03987430f, 
    -0.03405597f, -0.06783962f, 0.05723618f, -0.05859460f, -0.01878704f, 0.01702156f, -0.03947581f, -0.05151336f, 
    -0.06913599f, -0.00514040f, 0.06206489f, -0.05163142f, -0.01612506f, 0.00344019f, 0.02186615f, -0.03405704f, 
    0.01171030f, -0.06027277f, -0.00356623f, -0.01144931f, -0.00854532f, 0.05641527f, 0.02770879f, -0.01057375f, 
    0.03219623f, 0.03348567f, -0.01481112f, -0.02532050f, -0.00669259f, 0.00572735f, 0.02116690f, 0.03210831f, 
    -0.05073375f, 0.06053477f, -0.02185326f, 0.03973904f, 0.03008413f, 0.04617467f, 0.02132971f, 0.00272991f, 
    0.03117632f, -0.01334928f, 0.02613341f, -0.03206093f, -0.06860910f, 0.00482169f, 0.04376856f, -0.06545103f, 
    0.00196349f, 0.00138176f, -0.04749041f, 0.03517566f, 0.05495248f, -0.01862928f, -0.05551787f, 0.02585648f, 
    0.00363431f, -0.06027904f, -0.02130086f, -0.06430765f, 0.02640244f, -0.01885703f, 0.04970401f, 0.03330431f, 
    0.06347969f, 0.05139292f, -0.07239646f, -0.06644439f, -0.05449465f, 0.06895573f, 0.06196596f, 0.01323918f, 
    -0.07836849f, -0.05338767f, -0.00508535f, -0.06007949f, -0.00925172f, 0.03869388f, -0.00758729f, 0.03420284f, 
    -0.04877830f, 0.02109894f, -0.00688832f, -0.00071936f, -0.03379809f, 0.02899317f, -0.07551119f, -0.03054449f, 
    -0.05370773f, -0.03962983f, 0.06511495f, 0.02569349f, -0.00929230f, 0.02362843f, -0.04512089f, -0.02075664f, 
    0.01700019f, -0.01357822f, 0.04088634f, -0.01858469f, -0.00669741f, -0.05730755f, -0.04481129f, -0.06288948f, 
    0.03833928f, -0.05291029f, -0.04596235f, -0.01062806f, 0.06477415f, 0.06253733f, -0.03360335f, 0.02188538f, 
    -0.01588801f, -0.04969950f, 0.03151119f, -0.05877550f, 0.06827732f, -0.03435366f, -0.01385481f, 0.04001069f, 
    0.04085429f, -0.01245357f, 0.01181625f, -0.06945603f, -0.04084074f, -0.07152431f, -0.03477477f, 0.04712512f, 
    -0.05995182f, -0.06766574f, 0.06803762f, 0.01687041f, 0.01019731f, -0.04098298f, -0.06685476f, 0.00849958f, 
    -0.06434982f, -0.01726834f, -0.02398651f, -0.06356552f, -0.00885751f, 0.00059045f, -0.06981612f, 0.00109007f, 
    0.00122840f, 0.05672881f, -0.02552055f, -0.06253287f, -0.08016873f, 0.04995050f, -0.01804015f, -0.03498820f, 
    0.04772105f, 0.00247841f, -0.04762429f, -0.07676168f, 0.00475590f, 0.02846625f, 0.01534183f, -0.04560602f, 
    0.05502959f, -0.01961236f, -0.07909995f, -0.03007584f, 0.03237562f, -0.06491651f, -0.02747575f, 0.04434445f, 
    -0.09877674f, -0.06193366f, -0.03920061f, -0.02346334f, 0.02283678f, 0.03390473f, -0.05535362f, -0.04316806f, 
    0.07625660f, 0.13789132f, 0.14564170f, 0.01551042f, -0.05656397f, -0.15335366f, -0.26001757f, -0.36380953f, 
    0.01385818f, -0.01541651f, -0.02485617f, -0.14827657f, 0.04249436f, 0.05447038f, 0.11215462f, 0.18608747f, 
    -0.00285804f, 0.10452765f, -0.17839271f, -0.03290805f, 0.06107356f, -0.03113869f, -0.48306543f, -0.05163100f, 
    -0.04469591f, -0.02760061f, -0.09597180f, -0.27465767f, 0.03365418f, 0.04012493f, 0.15350622f, 0.01952310f, 
    0.13637845f, 0.11517743f, -0.18707381f, -0.10848358f, 0.16637990f, 0.08091249f, -0.27478519f, -0.16851422f, 
    -0.04848825f, 0.06604506f, 0.01872650f, -0.17885040f, 0.02376216f, -0.03161474f, 0.02352921f, 0.07543822f, 
    0.00605197f, 0.07983296f, -0.06650950f, -0.12437055f, 0.01611825f, 0.08777000f, 0.22638041f, -0.16856122f, 
    -0.04896228f, 0.19128120f, 0.11586301f, 0.04015364f, -0.02613907f, 0.06351442f, 0.06345884f, 0.03444901f, 
    -0.24061960f, -0.14467154f, -0.34047288f, -0.22653009f, -0.11318383f, -0.16445529f, -0.20614789f, -0.00513807f, 
    0.00652997f, 0.02988923f, 0.05570590f, 0.09548071f, -0.16191645f, -0.01833514f, -0.16905683f, -0.13540806f, 
    -0.02267655f, -0.00033190f, 0.03218057f, 0.10579655f, -0.25745475f, -0.12106764f, -0.25998515f, -0.08781766f, 
    -0.29461965f, 0.26084545f, -0.02302175f, 0.07178650f, -0.02562796f, 0.03092537f, 0.06462971f, 0.18526886f, 
    -0.06629021f, -0.09453531f, -0.10085796f, -0.16700125f, 0.15127061f, 0.25651419f, 0.12089080f, -0.07560348f, 
    0.05312449f, -0.25184804f, 0.11666258f, 0.24815534f, 0.05090823f, 0.05799469f, -0.05594129f, 0.04597467f, 
    0.15551959f, 0.36837289f, 0.18133444f, -0.03721208f, -0.15038130f, -0.04636370f, -0.00594197f, 0.12281524f, 
    -0.10142457f, 0.07374232f, -0.03078119f, -0.00348001f, 0.04472749f, 0.13374990f, 0.24455144f, 0.05315843f, 
    -0.00346464f, 0.10088174f, 0.13004194f, 0.19874062f, 0.11803088f, 0.09677950f, 0.07489890f, -0.12048990f, 
    -0.05277932f, -0.03155802f, 0.04911579f, -0.03293779f, -0.02931126f, -0.00802325f, 0.04756411f, -0.00150613f, 
    0.00231606f, 0.04294077f, 0.12860399f, 0.16262300f, 0.45512259f, 0.26895231f, 0.25928265f, 0.11910997f, 
    -0.11611456f, -0.20206256f, -0.07581485f, 0.09985200f, -0.00207533f, -0.03904062f, -0.06247701f, -0.17989169f, 
    -0.31785670f, -0.02842911f, 0.31267726f, 0.03724715f, -0.08224882f, 0.02297250f, 0.07642428f, 0.21278545f, 
    0.13818830f, 0.14099479f, 0.00317999f, -0.19423142f, 0.19373208f, 0.41852117f, 0.11143766f, 0.21660537f, 
    -0.07184630f, -0.08717725f, -0.04837386f, 0.05534270f, -0.13807271f, 0.01969183f, -0.09173831f, -0.16497049f, 
    0.06119472f, 0.21554255f, -0.10582621f, -0.00700875f, -0.08841816f, -0.22550115f, 0.13342406f, -0.14152341f, 
    -0.06929366f, 0.11747576f, 0.02252702f, 0.10894657f, 0.37486607f, -0.35837394f, -0.25164595f, 0.11939758f, 
    0.04005458f, 0.24228528f, -0.05507416f, -0.03852456f, 0.08356994f, -0.00337403f, -0.02567237f, 0.00768435f, 
    -0.04009053f, 0.07920156f, -0.13534467f, 0.14616011f, -0.00400534f, 0.00432155f, 0.18676902f, -0.10431707f, 
    -0.01303814f, -0.04809977f, 0.00177050f, 0.01044364f, -0.28027654f, 0.20493072f, -0.12803119f, -0.19927853f, 
    -0.09415973f, -0.20683798f, -0.02169016f, 0.06864750f, 0.14277028f, 0.01470209f, 0.06171733f, -0.01508714f, 
    0.16614214f, -0.03883072f, 0.50745279f, 0.47858405f, -0.06766687f, 0.01393823f, -0.08522449f, -0.03695597f, 
    0.19896258f, 0.14671685f, -0.01683015f, 0.05185115f, 0.22080736f, 0.17989329f, 0.08171460f, -0.07560437f, 
    0.07443893f, 0.04160621f, 0.06225387f, -0.00562719f, 0.09378146f, 0.16157429f, -0.09111527f, -0.04006924f, 
    0.02845916f, -0.47947660f, -0.13674484f, -0.21127628f, 0.12792183f, 0.22220072f, -0.10129586f, 0.10313109f, 
    -0.00185224f, -0.03964186f, -0.03021607f, -0.18862286f, 0.07023881f, -0.22021073f, -0.11038929f, 0.11884701f, 
    0.04715168f, 0.06760881f, 0.07299905f, -0.00905351f, -0.06162430f, -0.04680459f, -0.02881999f, 0.06113661f, 
    -0.03567257f, 0.12437459f, 0.24454923f, 0.03485534f, -0.15997459f, 0.01011006f, -0.04184252f, -0.06265474f, 
    0.15879841f, 0.01130454f, 0.03188170f, 0.07254558f, 0.09129383f, 0.21383703f, 0.14246431f, -0.03968167f, 
    0.09023108f, 0.02171430f, 0.04247431f, 0.14619629f, -0.03170728f, 0.03457794f, 0.10940405f, -0.05114245f, 
    0.11106019f, 0.22021557f, 0.06916804f, -0.10242783f, -0.12474135f, -0.05933550f, -0.08751871f, -0.03526055f, 
    -0.04982651f, -0.08230409f, 0.29846349f, -0.00002395f, 0.05002080f, -0.27975762f, -0.02913982f, 0.19571252f, 
    -0.09030415f, 0.05325061f, -0.05561496f, 0.12681097f, 0.24968643f, 0.09814121f, -0.04667518f, -0.04996431f, 
    -0.11269229f, -0.02020741f, -0.04640324f, -0.05387155f, 0.01669090f, -0.01557185f, 0.13872755f, -0.07575471f, 
    -0.06247985f, 0.12078660f, -0.16822852f, 0.03940638f, 0.25571138f, -0.11531913f, 0.08924070f, -0.07131241f, 
    0.00682542f, -0.02022836f, -0.08117725f, 0.09468713f, 0.09308570f, 0.00347774f, -0.00654884f, 0.01741588f, 
    -0.35988355f, -0.06055241f, 0.27626497f, 0.29683772f, 0.02226258f, 0.16718940f, -0.00718368f, 0.04008562f, 
    -0.01883350f, -0.02372420f, -0.05009212f, -0.09599033f, -0.03832788f, 0.23676114f, -0.05865010f, -0.12732619f, 
    -0.03991153f, -0.11431665f, 0.11853538f, 0.06172473f, 0.05035868f, -0.08407652f, -0.00218867f, -0.10026359f, 
    -0.11306763f, -0.13661835f, -0.06940754f, -0.04424698f, -0.01786058f, -0.02340345f, -0.04488765f, 0.10946497f, 
    -0.11568461f, 0.14933594f, -0.00103587f, 0.02764246f, -0.27573490f, -0.40286440f, -0.17842880f, -0.30891958f, 
    -0.01073490f, 0.04702464f, -0.14767112f, -0.09987407f, -0.09554284f, -0.04531758f, 0.05805722f, 0.00889289f, 
    -0.01250137f, 0.17951219f, -0.16142745f, 0.05938237f, 0.03697989f, -0.04695925f, -0.00310097f, 0.08892103f, 
    -0.06226683f, -0.08469703f, 0.11562064f, 0.05688530f, -0.02645849f, 0.11635776f, 0.14667027f, -0.03399308f, 
    0.03555717f, -0.03456165f, -0.01409405f, -0.01073880f, 0.05390571f, 0.08188238f, 0.04711699f, -0.01072585f, 
    0.09521709f, -0.60727751f, 0.17226583f, -0.08232202f, 0.00810348f, -0.08507750f, 0.05692338f, 0.00617456f, 
    0.02979605f, 0.04542967f, -0.03088597f, 0.05564265f, -0.03738273f, 0.27329355f, 0.01961457f, -0.11643166f, 
    -0.07868356f, -0.07959218f, -0.02839178f, -0.00062205f, -0.01667177f, 0.14174402f, 0.00020899f, 0.00455099f, 
    0.04299319f, 0.35234299f, -0.09003463f, -0.07815412f, -0.02392985f, -0.03903630f, -0.03110396f, -0.01427387f, 
    -0.09955440f, -0.05140821f, -0.06140743f, -0.11052019f, -0.14277729f, 0.01000539f, -0.09214336f, -0.06060017f, 
    0.07805109f, -0.17782679f, -0.07947487f, -0.04346812f, -0.09687440f, 0.08470455f, -0.03393687f, 0.12708531f, 
    0.01807025f, 0.20860046f, 0.06992581f, 0.15014260f, -0.04006282f, 0.14759240f, -0.07936583f, 0.05492300f, 
    0.19942501f, 0.02003476f, -0.03165209f, -0.04030413f, 0.01001033f, 0.10421612f, 0.16692771f, -0.10584655f, 
    -0.05580310f, -0.13563591f, -0.09210362f, 0.14707625f, -0.04223601f, -0.03610602f, -0.06270546f, 0.06713297f, 
    0.34888750f, 0.20745131f, 0.06280051f, -0.00184094f, 0.04852881f, 0.21809638f, -0.00259685f, 0.05588639f, 
    -0.15260924f, -0.13317780f, -0.12827106f, -0.14049292f, 0.32503858f, -0.20744576f, 0.20290785f, 0.09713840f, 
    -0.12963988f, -0.07655775f, 0.15227546f, -0.01511327f, 0.06656133f, -0.02308986f, 0.03180123f, -0.14596324f, 
    0.02767355f, -0.14550136f, -0.01550954f, -0.10799407f, 0.00928908f, 0.07162793f, 0.06660159f, 0.01847461f, 
    -0.15584557f, -0.06175929f, -0.17472406f, -0.05307800f, 0.32456723f, 0.05136266f, 0.04296428f, 0.00588578f, 
    0.01383671f, 0.00838647f, -0.07500200f, -0.03006766f, -0.05538291f, -0.09173949f, 0.07025454f, 0.17590585f, 
    -0.13285591f, 0.25220573f, -0.07485437f, 0.15332057f, -0.01348167f, -0.06397536f, 0.02132606f, -0.03723029f, 
    -0.08118725f, -0.00597487f, 0.02179343f, -0.07853042f, 0.05538724f, -0.04952702f, 0.06641698f, -0.01052919f, 
    0.09323592f, 0.03596401f, 0.13244507f, -0.03595974f, -0.01341888f, -0.04802766f, -0.01144620f, 0.05181954f, 
    0.02362670f, 0.04101921f, -0.02152663f, 0.05976298f, -0.01166156f, 0.01072349f, 0.05683159f, 0.01127538f, 
    -0.18442096f, 0.01720834f, -0.11331266f, -0.04213722f, -0.08834279f, -0.08527885f, -0.08524586f, -0.06048241f, 
    0.01131941f, 0.04129749f, 0.03473640f, -0.01361440f, 0.02875307f, 0.00555784f, -0.07765582f, 0.02679572f, 
    -0.09178381f, -0.07309136f, -0.06132248f, -0.00324526f, 0.09981185f, -0.01347510f, 0.03596056f, -0.08612309f, 
    -0.02707252f, -0.02047639f, -0.05128179f, -0.12041894f, -0.08058940f, -0.05319590f, 0.03367876f, -0.01239333f, 
    -0.05153295f, -0.05545744f, -0.04287133f, -0.08366821f, -0.01373021f, -0.04472533f, 0.01448129f, -0.07442844f, 
    -0.04102729f, 0.05053641f, -0.11377887f, -0.01388568f, -0.05055239f, 0.07063077f, -0.06567134f, -0.07128844f, 
    -0.09361199f, 0.01165456f, 0.00303407f, -0.17182796f, -0.01181547f, -0.04236604f, -0.14437577f, -0.18493016f, 
    -0.07312732f, -0.09711473f, -0.05322101f, -0.10839875f, 0.03886031f, 0.06988160f, 0.06653014f, 0.00424373f, 
    0.04227905f, -0.06114831f, 0.01943685f, -0.07093490f, -0.05296172f, -0.05985567f, 0.08821317f, 0.02145933f, 
    0.06056027f, -0.01704917f, 0.00428178f, 0.02653601f, -0.05774588f, 0.01626183f, -0.03433452f, -0.03874554f, 
    0.02597367f, 0.03945698f, -0.00596810f, -0.08495712f, -0.11115547f, -0.00202917f, -0.08913370f, -0.11123353f, 
    0.08519615f, 0.04324137f, -0.07996008f, -0.06406483f, 0.01716845f, 0.02643403f, -0.05615992f, -0.08036875f, 
    -0.08553820f, -0.09352168f, -0.04001592f, -0.04109897f, 0.01679038f, -0.11525201f, -0.09662098f, -0.12815528f, 
    0.00463558f, -0.16110955f, -0.04358202f, 0.00374357f, 0.05792265f, -0.02782776f, 0.02796998f, 0.04467925f, 
    -0.05265022f, -0.01634684f, -0.09894518f, -0.06212362f, -0.04583210f, -0.06109098f, 0.00906353f, -0.02672203f, 
    0.04040365f, 0.02147444f, 0.01922452f, 0.03776854f, 0.00249658f, -0.04007240f, -0.06389564f, -0.01464052f, 
    -0.07604258f, -0.19924942f, -0.09707911f, -0.03781419f, 0.05821888f, -0.05665891f, -0.06951187f, -0.04213417f, 
    -0.03371450f, -0.02243263f, -0.03919665f, -0.09227933f, -0.09125519f, -0.06602811f, 0.00008909f, -0.03467740f, 
    -0.02582764f, 0.01867712f, -0.08068563f, -0.06327269f, -0.10414190f, -0.11898039f, -0.14525101f, -0.13311689f, 
    -0.07430014f, -0.01600618f, -0.02957393f, -0.04022793f, 0.03341039f, 0.00269895f, -0.02956135f, -0.11287919f, 
    -0.05027109f, 0.01014081f, -0.02929130f, -0.01793444f, -0.00139893f, 0.00089786f, -0.02181433f, -0.09026177f, 
    -0.02253344f, 0.00961815f, -0.02297080f, 0.02137178f, -0.11381209f, -0.06391098f, -0.02758309f, -0.05342818f, 
    -0.03283652f, -0.04515414f, -0.02150223f, -0.02761340f, 0.01062096f, 0.00146019f, 0.04120255f, -0.04522665f, 
    0.05497865f, -0.06176200f, -0.01232028f, 0.05367571f, -0.03904953f, -0.07254666f, -0.06492499f, 0.01849390f, 
    -0.02830422f, -0.04016849f, -0.04329597f, 0.01180463f, -0.07304179f, -0.04595017f, -0.07200616f, -0.04250061f, 
    -0.01500446f, -0.00722758f, -0.05282210f, -0.02094086f, -0.06011513f, -0.05629685f, 0.05573513f, -0.06513013f, 
    0.04624213f, 0.02217198f, 0.00581553f, 0.04729432f, -0.05785222f, -0.05444789f, -0.01567313f, 0.01026259f, 
    0.05611569f, 0.05354484f, -0.01842476f, -0.07716045f, -0.03410588f, 0.00163963f, 0.02045071f, -0.04926316f, 
    -0.02110801f, 0.00240814f, 0.04720890f, -0.06667405f, 0.04852932f, -0.04980445f, 0.05490454f, 0.01296896f, 
    0.00549778f, 0.03844226f, -0.02696086f, -0.02043271f, 0.00816896f, -0.05485601f, -0.04779345f, -0.00007510f, 
    -0.01630404f, 0.01873339f, 0.03309982f, 0.01307081f, -0.08007824f, -0.05164374f, 0.02232015f, -0.02852738f, 
    -0.07589448f, -0.02148803f, -0.00047127f, -0.05917488f, -0.04117481f, 0.01068105f, 0.05099478f, 0.05640080f, 
    -0.00171734f, -0.01316344f, -0.00967936f, 0.02887959f, 0.05467463f, 0.00246493f, 0.00267028f, -0.01807966f, 
    -0.00979009f, -0.01070202f, -0.03575209f, -0.02720504f, 0.02526954f, -0.02294937f, -0.06639715f, -0.05605485f, 
    -0.02873020f, -0.05976819f, -0.08256753f, 0.02344811f, -0.00876760f, -0.00643451f, -0.05209391f, 0.03364713f, 
    0.02637923f, -0.07112829f, -0.08613954f, -0.04129530f, 0.04780399f, 0.04266091f, 0.03969881f, -0.04057644f, 
    -0.04291710f, -0.02068789f, -0.01535667f, -0.02514049f, 0.00499452f, -0.01551705f, 0.00829787f, 0.01337831f, 
    -0.00928617f, 0.05531811f, 0.00956101f, -0.05303356f, -0.01880860f, 0.00394251f, -0.05025659f, -0.06625075f, 
    -0.00835384f, -0.04307636f, 0.00586723f, -0.06610692f, 0.04093281f, -0.01893978f, 0.01698824f, -0.01597947f, 
    0.01025409f, -0.06850657f, -0.01873442f, 0.01271348f, 0.03662449f, -0.06547374f, 0.01311050f, -0.05044045f, 
    0.01396433f, -0.04195939f, 0.01326602f, -0.08208580f, 0.04299588f, -0.02961660f, 0.00314290f, -0.01771159f, 
    0.01204318f, -0.01197913f, -0.02061135f, 0.01526169f, -0.07626294f, 0.00057894f, 0.06116635f, -0.02362373f, 
    -0.05819103f, -0.06816863f, 0.05775362f, 0.04363253f, 0.03022359f, 0.04462656f, -0.06923807f, -0.07277801f, 
    0.00177186f, -0.06870466f, -0.07083385f, -0.01163283f, -0.02112741f, -0.07907416f, 0.04156112f, 0.02971026f, 
    0.04304788f, -0.00240528f, 0.03219947f, -0.00118495f, -0.04315014f, 0.04297569f, -0.02489056f, 0.02860596f, 
    -0.07390989f, -0.00377907f, -0.01918880f, -0.02628826f, -0.04406948f, 0.04317773f, -0.07771787f, 0.00985087f, 
    -0.04704462f, -0.02845468f, -0.07069436f, 0.05220700f, -0.07395698f, 0.02854360f, 0.01512654f, -0.01996600f, 
    -0.05855383f, -0.02988751f, -0.05795657f, -0.05956769f, 0.01909140f, -0.11197270f, -0.01630734f, 0.04210125f, 
    0.00809889f, -0.06324376f, 0.00945741f, 0.06968882f, 0.15202995f, 0.03521439f, 0.02058448f, -0.05362409f, 
    -0.09942861f, -0.02415630f, -0.07888946f, -0.01042257f, 0.00998168f, -0.02108550f, 0.01354318f, -0.00903337f, 
    0.07957079f, -0.23265781f, -0.09890988f, -0.04048913f, 0.07611413f, 0.01528516f, 0.04172650f, 0.05674134f, 
    -0.02035243f, 0.12158700f, 0.04196150f, 0.03316207f, 0.22703123f, 0.10901277f, 0.19910572f, 0.00462379f, 
    0.00654986f, -0.07319802f, 0.00910060f, -0.11822874f, 0.00522912f, 0.19812937f, 0.04941420f, 0.13905109f, 
    -0.09021037f, 0.05530814f, 0.11623205f, 0.31932783f, -0.03294433f, -0.00165179f, -0.06814659f, -0.06867456f, 
    -0.13571678f, -0.03496677f, 0.16166918f, -0.01128826f, 0.04540072f, -0.09156931f, 0.04326160f, -0.00908167f, 
    -0.05185392f, 0.15643033f, -0.08966880f, 0.09014834f, -0.03093128f, -0.03749434f, 0.04871015f, 0.00125951f, 
    0.32857895f, 0.09472711f, -0.15824267f, 0.02533118f, 0.09231595f, 0.05957006f, 0.10063518f, -0.11578321f, 
    -0.03263891f, -0.11019078f, -0.06288999f, -0.01329978f, -0.08186627f, -0.03584867f, 0.02900464f, -0.02512277f, 
    -0.03914368f, -0.02428655f, -0.06154432f, -0.05332220f, 0.01782621f, 0.19765569f, 0.10137440f, 0.06296661f, 
    -0.10544090f, 0.19670469f, 0.13880518f, 0.28090867f, 0.06030283f, -0.09411296f, -0.09554964f, -0.04397298f, 
    -0.02257537f, -0.01852459f, -0.05124182f, 0.01133847f, -0.20906988f, -0.02626689f, -0.01629350f, 0.04273766f, 
    -0.16540122f, -0.27393439f, 0.06324862f, -0.06183768f, -0.07612115f, 0.01374667f, -0.03951472f, -0.08107290f, 
    0.03018489f, 0.37034211f, 0.24314801f, 0.08721326f, 0.04076366f, -0.00799470f, -0.03015647f, 0.21964806f, 
    -0.18489735f, 0.03147611f, -0.17873138f, 0.01511791f, -0.18445611f, -0.06147726f, 0.04836477f, 0.29954135f, 
    0.16505976f, 0.07056577f, 0.00556172f, -0.03831925f, 0.09354950f, -0.04252087f, 0.03386468f, -0.10321824f, 
    0.10721955f, -0.03972457f, 0.04655512f, 0.00815352f, -0.00214320f, -0.01335984f, -0.00647725f, 0.05242971f, 
    -0.01462465f, 0.03691323f, -0.03092598f, -0.07356305f, -0.02704680f, -0.05854504f, -0.06262979f, 0.26551211f, 
    -0.01451368f, -0.02182397f, -0.13943732f, -0.05936702f, 0.15862428f, 0.11333825f, 0.12325460f, 0.16885440f, 
    -0.35423562f, -0.06531978f, -0.34828323f, 0.28600430f, -0.09597778f, -0.06042172f, 0.00745413f, -0.08463887f, 
    -0.07424860f, -0.03986083f, 0.15162410f, 0.11427976f, 0.10692018f, 0.15598620f, 0.24843706f, 0.10575150f, 
    0.02962174f, -0.00883006f, -0.03620623f, 0.12562111f, -0.08590176f, 0.04152326f, -0.02194573f, -0.05389762f, 
    0.16901919f, -0.06420568f, -0.13731353f, -0.04727541f, -0.09679872f, 0.05484252f, -0.12209579f, 0.13844171f, 
    -0.04813847f, 0.00775472f, -0.02889102f, -0.17522457f, 0.04706505f, 0.05483688f, 0.12358426f, 0.01715022f, 
    0.02923547f, -0.02074343f, 0.07581157f, -0.01405630f, -0.03634590f, 0.00773373f, -0.09127799f, 0.00533290f, 
    0.07520086f, -0.20233518f, -0.06140376f, 0.00214007f, -0.00635473f, 0.08985463f, -0.05629781f, -0.05215426f, 
    0.06457521f, 0.06854775f, 0.07228196f, 0.06336229f, 0.30616397f, 0.08296300f, 0.13673395f, 0.10176052f, 
    -0.04124938f, -0.16971286f, 0.07733480f, -0.04474853f, -0.01951221f, 0.13707212f, -0.03855657f, 0.23532718f, 
    -0.33530918f, 0.10642947f, 0.01945751f, -0.04688372f, 0.05309580f, 0.05459834f, 0.14303678f, -0.08766727f, 
    -0.01015512f, 0.05653979f, 0.08693229f, 0.01409734f, -0.27339816f, 0.19271746f, 0.19814433f, 0.24226558f, 
    0.03043170f, -0.00953009f, -0.03004271f, 0.00119793f, -0.00016322f, -0.00699385f, 0.12948805f, 0.07794669f, 
    0.24656968f, 0.25327700f, -0.02324142f, 0.02740294f, -0.05508067f, 0.04120847f, -0.03196264f, 0.04468855f, 
    -0.05867729f, 0.04347090f, -0.03100045f, -0.12407631f, -0.03704580f, 0.12400392f, -0.11939183f, 0.07061053f, 
    -0.04987103f, -0.09148315f, -0.10930256f, -0.02667772f, 0.09649476f, 0.13891509f, 0.04167244f, 0.00582814f, 
    -0.12120160f, 0.11340600f, -0.01121365f, 0.07598699f, 0.06745487f, -0.04524818f, -0.09718887f, -0.03785705f, 
    -0.00734432f, 0.04091982f, 0.12027401f, -0.10150322f, -0.25683129f, -0.02419957f, -0.01284090f, 0.22634971f, 
    -0.10764052f, -0.11733785f, -0.05044260f, -0.09787656f, 0.00439090f, -0.02123836f, -0.00482872f, -0.05959316f, 
    0.19263984f, 0.29010722f, 0.03729443f, 0.16122958f, -0.08427688f, -0.14757168f, 0.11251465f, -0.06498475f, 
    -0.16671808f, 0.04611932f, -0.09961177f, -0.08162339f, -0.33095396f, -0.01763189f, 0.03676948f, 0.29453394f, 
    0.00169830f, 0.07099625f, 0.13004158f, -0.16463290f, -0.08569896f, -0.01894934f, 0.12308240f, 0.00428689f, 
    0.26028064f, -0.14420076f, -0.05921282f, -0.13159031f, -0.02998696f, 0.13238598f, -0.07426572f, 0.13476653f, 
    -0.08904577f, 0.00115836f, -0.09990171f, -0.05160950f, -0.26281998f, 0.02018454f, -0.07036496f, 0.34512347f, 
    -0.00392804f, 0.12718819f, 0.03186369f, 0.05370299f, 0.10655528f, -0.03376031f, 0.11331987f, 0.11156424f, 
    -0.28082463f, 0.19712096f, -0.49509141f, 0.24586298f, 0.23837487f, -0.14883195f, 0.15701720f, -0.08398326f, 
    -0.04712584f, 0.16307539f, 0.00023649f, 0.17110641f, 0.18629494f, -0.00111287f, 0.30135304f, 0.04778927f, 
    -0.03088205f, -0.08701789f, 0.00423998f, 0.00219496f, -0.10218701f, -0.05869629f, -0.10402049f, 0.07712850f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07880726f, 0.05321398f, -0.01307435f, -0.06511364f, -0.10221225f, -0.03502870f, -0.01676009f, -0.05572318f, 
    0.05120654f, 0.07140317f, -0.07568344f, -0.24938172f, 0.05912412f, 0.28285176f, -0.02876562f, -0.02837402f, 
    0.06917534f, 0.03234600f, 0.04883058f, -0.13777497f, 0.00515243f, 0.03103335f, -0.00653269f, 0.01846671f, 
    0.20814660f, -0.00012778f, 0.02547309f, 0.26018596f, -0.04847121f, 0.05162637f, 0.13760248f, 0.06801426f, 
    0.22577840f, 0.11476429f, 0.02905755f, 0.00293154f, 0.04565680f, 0.09293969f, -0.17734440f, -0.01349126f, 
    0.00356504f, -0.07266378f, -0.07210217f, -0.04122352f, 0.05300838f, 0.05036761f, 0.03073571f, 0.19080983f, 
    0.14408323f, 0.12057039f, 0.01166262f, 0.20695379f, -0.12548162f, -0.12050071f, 0.11964505f, 0.24467912f, 
    0.06586790f, -0.01574305f, 0.30988145f, 0.06403688f, 0.15618862f, 0.01583106f, 0.16287085f, 0.02317174f, 
    0.11298398f, -0.05692368f, -0.03625372f, -0.01113321f, 0.02355199f, -0.05430405f, -0.06739151f, 0.12021431f, 
    0.15311854f, 0.00322634f, 0.05651988f, 0.03791649f, 0.01941366f, -0.04711309f, -0.05207638f, 0.28987220f, 
    -0.13043089f, -0.05633203f, 0.05791657f, -0.06253595f, 0.19621539f, 0.16715638f, 0.33276793f, 0.21358845f, 
    -0.05998889f, -0.05457317f, 0.02463774f, 0.05022616f, -0.10418929f, -0.08281864f, -0.06978676f, 0.17354645f, 
    0.00383339f, 0.03641446f, 0.25045109f, 0.03520068f, 0.17966238f, -0.03892070f, 0.04445004f, 0.19819026f, 
    -0.02032202f, 0.08439700f, 0.11573299f, 0.08812232f, 0.20749255f, 0.23598671f, -0.03758862f, 0.02208499f, 
    -0.05708142f, 0.00016872f, 0.02350239f, 0.03967854f, -0.01215583f, -0.17047904f, 0.01014000f, 0.01342330f, 
    0.05151377f, 0.06820589f, 0.14576246f, -0.07734461f, -0.00497549f, -0.06475631f, 0.12968427f, 0.04871091f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.21261674f, 0.01253187f, 0.02275764f, 0.03147383f, 0.16515945f, 0.12536299f, 0.10768633f, 0.22931018f, 
    0.05590113f, -0.34397483f, -0.08186214f, 0.13321565f, 0.02760171f, -0.02977001f, -0.02178513f, 0.04918074f, 
    -0.27667627f, 0.10854159f, -0.00029271f, 0.14346576f, -0.01252340f, -0.30803528f, 0.04591006f, -0.00000074f, 
    -0.51691556f, 0.05459024f, 0.13495557f, -0.11421846f, 0.25183466f, 0.06774695f, -0.05018609f, -0.14649737f, 
    -0.46178854f, -0.16480675f, -0.13211618f, -0.08205278f, -0.15049164f, 0.13261311f, 0.24159110f, 0.18963552f, 
    0.02111093f, 0.03601031f, -0.03403026f, 0.15392038f, -0.01209096f, 0.06009682f, -0.17968632f, -0.33106396f, 
    -0.02791253f, -0.21185748f, 0.00663517f, -0.18640798f, 0.19146557f, 0.03486821f, 0.16293073f, -0.20667909f, 
    -0.11650031f, 0.04501140f, -0.24423535f, 0.07965138f, -0.29695490f, 0.04349232f, -0.02240195f, 0.12868825f, 
    0.15857781f, -0.06380387f, -0.07278753f, -0.07844053f, -0.03272498f, 0.07895125f, -0.04056772f, -0.10400230f, 
    -0.37132344f, 0.04594554f, -0.67235935f, 0.03056091f, 0.00311528f, 0.20942628f, -0.02330154f, -0.07597764f, 
    0.19432361f, -0.29258379f, 0.08869240f, -0.11031916f, -0.14228913f, 0.07702000f, -0.27843907f, -0.17354384f, 
    -0.03715893f, -0.06580952f, -0.09266859f, 0.16044192f, -0.43620878f, -0.17099981f, 0.04938968f, -0.46090233f, 
    0.04542500f, -0.03726017f, -0.17833354f, -0.19405724f, -0.38156626f, -0.30449530f, 0.01118685f, -0.35709164f, 
    0.13474788f, -0.28022191f, -0.31604296f, -0.28473330f, -0.09725797f, -0.18543604f, 0.06604512f, -0.48568368f, 
    -0.18177979f, 0.20707527f, -0.06266010f, 0.11477347f, 0.08038867f, 0.13661772f, -0.06978901f, 0.01316995f, 
    0.05370408f, 0.10644488f, 0.03908569f, 0.14828640f, -0.06324439f, -0.03449225f, -0.13010156f, -0.22432353f, 
    0.05338416f, -0.03746320f, -0.02794231f, 0.01898827f, -0.00816281f, 0.00070306f, 0.03715030f, 0.21802682f, 
    0.00632302f, 0.11201437f, 0.01929989f, -0.16038473f, -0.07771842f, 0.03755445f, 0.07316206f, 0.01730517f, 
    0.08924550f, 0.17683959f, 0.06185501f, 0.13377318f, 0.03664410f, -0.13205367f, -0.07526074f, -0.07506636f, 
    -0.19661689f, 0.03875852f, 0.04321543f, 0.07920570f, 0.18223640f, 0.02939049f, -0.09819623f, -0.34771675f, 
    -0.06681911f, 0.10572515f, 0.17164952f, -0.53367519f, 0.21497759f, 0.04306717f, -0.11636268f, -0.36922908f, 
    -0.02814414f, -0.00451695f, -0.04899569f, -0.32935101f, 0.04196465f, -0.03950397f, -0.05897960f, 0.16861241f, 
    0.32052538f, -0.15253368f, -0.06809843f, 0.27863583f, 0.20173280f, -0.43550986f, 0.21907045f, 0.34177151f, 
    0.15476777f, 0.00009197f, 0.19958648f, -0.07535607f, -0.33664882f, 0.06547406f, 0.11986509f, -0.06654841f, 
    0.11017171f, 0.00301314f, -0.42993733f, -0.07980446f, 0.14116870f, -0.03502782f, 0.00544205f, 0.18900801f, 
    0.04868196f, -0.04511111f, -0.31050870f, -0.08990351f, -0.59705538f, 0.03909185f, -0.06551065f, -0.09682757f, 
    -0.57611060f, -0.15209365f, 0.11585025f, -0.12016542f, -0.06611735f, 0.04936116f, 0.14793155f, 0.38795096f, 
    0.00594278f, 0.05231251f, -0.02500549f, -0.03559022f, -0.04951259f, -0.24251145f, -0.00219910f, -0.08887085f, 
    -0.13087225f, -0.11162842f, 0.39316604f, 0.12406453f, -0.13187726f, -0.18934686f, 0.06268825f, 0.06728270f, 
    -0.18258485f, -0.05895878f, -0.11370410f, -0.04837048f, 0.15504174f, 0.41920516f, 0.05938926f, -0.33299452f, 
    -0.08004706f, 0.23105843f, 0.01044645f, 0.14765543f, 0.03770924f, 0.22787438f, -0.03886455f, -0.06716403f, 
    -0.08871296f, 0.23428008f, 0.06434650f, 0.20582697f, -0.05875671f, -0.01383278f, 0.08233365f, 0.00985669f, 
    -0.02921832f, 0.01088581f, -0.06388990f, -0.05384875f, -0.15571120f, -0.10169182f, -0.00923867f, -0.18314658f, 
    0.02742391f, -0.22009102f, -0.00183483f, -0.41132659f, 0.07941034f, 0.10055759f, -0.04762392f, -0.00445404f, 
    0.11464188f, 0.09424223f, -0.06270205f, 0.13448834f, -0.00205173f, -0.18076041f, -0.05931958f, -0.04170934f, 
    -0.04826187f, 0.04910496f, 0.25218472f, 0.16472657f, -0.06297413f, 0.09962830f, -0.00669819f, 0.15524723f, 
    -0.28598768f, 0.08749677f, -0.62340498f, 0.15824449f, 0.04038028f, -0.03369349f, 0.17883618f, -0.54068154f, 
    0.02561487f, -0.00106805f, -0.02908012f, 0.07253160f, 0.05026211f, 0.05835038f, -0.14917387f, -0.03011332f, 
    0.34385172f, 0.16478701f, -0.04094367f, 0.24636838f, -0.50336200f, -0.45974326f, -0.30259660f, 0.11754166f, 
    -0.08530024f, -0.08505158f, 0.08490936f, -0.03142121f, -0.12368795f, 0.07240994f, 0.16608241f, 0.01183105f, 
    -0.18371150f, 0.00352567f, 0.04880553f, 0.01130353f, 0.19406079f, 0.00675956f, 0.01414927f, -0.23849045f, 
    -0.03199552f, -0.07142914f, 0.36085820f, 0.16388173f, -0.18400297f, -0.21666706f, 0.06346846f, 0.26538786f, 
    -0.25115868f, -0.27479562f, 0.00742851f, -0.17583184f, -0.01620278f, -0.17692086f, 0.06661370f, -0.63837713f, 
    0.01721206f, -0.03177241f, 0.02439869f, 0.00616412f, -0.13645710f, 0.12327438f, -0.07090212f, 0.00367181f, 
    -0.13613692f, -0.25871757f, -0.39890361f, 0.18404403f, -0.01836976f, 0.01407162f, -0.04831149f, 0.23611337f, 
    -0.29500055f, 0.00027853f, 0.24676590f, 0.20760246f, 0.21406494f, -0.14302024f, -0.05503302f, 0.32341763f, 
    -0.04974861f, 0.06964032f, -0.04735846f, 0.17597137f, -0.01420469f, -0.62355644f, -0.18161339f, 0.06201421f, 
    -0.01011310f, -0.00484282f, -0.11179078f, 0.04586308f, -0.01017107f, 0.00664789f, 0.07691121f, 0.06590165f, 
    0.00567784f, -0.04449557f, -0.04643415f, -0.39293370f, -0.16938189f, 0.10309371f, 0.09496877f, 0.22031671f, 
    -0.07505266f, -0.14110142f, -0.09470633f, 0.07076471f, -0.09556334f, -0.00817616f, -0.09251372f, -0.21174972f, 
    -0.30949774f, 0.01399206f, 0.18340585f, 0.04525470f, -0.06418572f, 0.04290488f, -0.02526398f, -0.04681673f, 
    -0.23063637f, 0.03833401f, 0.11039266f, -0.38047183f, -0.11877239f, -0.50477523f, 0.09696538f, 0.15798016f, 
    -0.13679896f, 0.24288139f, -0.26380947f, 0.21491140f, -0.23199522f, -0.02313597f, 0.09820838f, 0.12904532f, 
    -0.07344378f, -0.07275788f, 0.03968413f, 0.08088288f, -0.05199705f, -0.05991968f, 0.24338460f, 0.06127860f, 
    0.13814902f, -0.21340749f, 0.04293532f, -0.04839204f, -0.06508329f, 0.02372177f, -0.05658438f, -0.23559958f, 
    -0.05058096f, 0.05919259f, 0.02943255f, -0.07552890f, -0.24315085f, -0.02428987f, -0.16586336f, 0.13803717f, 
    -0.28533489f, -0.07430112f, 0.10083245f, 0.05795670f, -0.38768888f, -0.09280435f, 0.02277527f, -0.06864930f, 
    -0.22297171f, 0.00401389f, 0.17210829f, 0.10813061f, 0.24282147f, -0.05773380f, -0.02684481f, -0.18037790f, 
    0.04167740f, 0.19962572f, -0.12866889f, -0.32207590f, -0.37064043f, -0.39641243f, -0.27571234f, -0.42148009f, 
    -0.02443087f, -0.00477119f, -0.03994514f, 0.25692731f, 0.11345398f, 0.07274373f, -0.04350219f, 0.23979987f, 
    0.10662147f, -0.22891071f, -0.47066873f, 0.08234096f, -0.19420829f, 0.16258740f, -0.04936857f, 0.22505920f, 
    -0.11955389f, -0.29051238f, 0.24126796f, 0.20555972f, -0.54365623f, -0.33984029f, 0.07324791f, -0.11664627f, 
    -0.06312159f, -0.07248718f, -0.07046819f, -0.05869394f, 0.04987575f, 0.10711405f, 0.23395477f, -0.03720801f, 
    0.07555089f, -0.03833555f, -0.52109230f, -0.22864822f, -0.02682620f, 0.02450149f, 0.06344879f, 0.16465163f, 
    -0.06345472f, -0.02098983f, -0.01478820f, -0.01508831f, 0.07846499f, -0.03593218f, -0.10388118f, 0.04060467f, 
    0.00940452f, -0.00341260f, 0.03365337f, 0.07917149f, -0.07298174f, -0.27246699f, 0.01631495f, 0.00776163f, 
    0.17924936f, 0.05718085f, 0.15114026f, -0.02159701f, 0.05214623f, -0.00817196f, -0.03398174f, -0.00351515f, 
    -0.09181935f, -0.01916516f, 0.13744360f, -0.26098692f, -0.11316235f, 0.04682530f, 0.03641235f, -0.05924698f, 
    0.15053023f, -0.03284252f, 0.10335419f, -0.00621682f, -0.06291066f, 0.08581880f, -0.05524377f, 0.14142777f, 
    0.00007289f, -0.07763986f, -0.08645508f, 0.08753446f, 0.03705003f, 0.04276456f, -0.06165531f, -0.29716083f, 
    -0.28096777f, -0.14457551f, -0.05742485f, -0.33243048f, 0.10669319f, 0.30387852f, -0.33420151f, 0.07050516f, 
    0.00487755f, -0.08366515f, -0.32553664f, 0.06491051f, -0.54419273f, 0.06511573f, -0.13801786f, 0.03584355f, 
    -0.25335535f, 0.03397821f, 0.01865092f, 0.08083253f, 0.02288884f, 0.00820366f, 0.03227237f, 0.18554476f, 
    0.10953362f, 0.04623285f, 0.18564296f, 0.13917442f, -0.10754954f, -0.10549540f, 0.04646621f, -0.04638462f, 
    0.16207013f, -0.12002222f, 0.12966748f, 0.11637609f, 0.12019915f, -0.27861425f, -0.37455985f, -0.41717732f, 
    -0.01129877f, 0.07731738f, -0.05545789f, -0.17902759f, 0.07703610f, 0.15024492f, -0.07384100f, -0.11321373f, 
    0.02429836f, -0.22218360f, -0.09409633f, -0.27300143f, 0.20832121f, 0.19504119f, -0.00287150f, -0.38058391f, 
    -0.04312774f, 0.12065600f, -0.31642127f, 0.03800299f, -0.02225218f, -0.21860549f, -0.08951531f, 0.27382728f, 
    0.18560781f, 0.05900762f, 0.04135824f, 0.10919510f, 0.02656248f, 0.11237255f, -0.17075028f, -0.02394060f, 
    -0.09522802f, -0.06898074f, 0.08601819f, 0.17679416f, -0.11743031f, -0.07378365f, 0.05206622f, 0.14416784f, 
    0.04956242f, -0.02362493f, -0.02957032f, -0.27080810f, 0.10073287f, 0.07004511f, -0.26680848f, -0.71006006f, 
    0.06432621f, 0.18339746f, 0.06201759f, 0.13925666f, -0.01274523f, 0.09065724f, 0.04918848f, -0.18129556f, 
    -0.22436111f, -0.03910790f, 0.00981787f, -0.03455611f, -0.07382204f, 0.08915138f, -0.04241585f, -0.00071897f, 
    0.23878762f, -0.00910445f, -0.33681434f, -0.02261754f, 0.13864680f, 0.17588891f, 0.05659212f, 0.07216880f, 
    0.15831894f, -0.31061807f, -0.02561466f, -0.28927213f, 0.05632298f, 0.09989642f, -0.22190647f, 0.21351458f, 
    0.03619510f, -0.00019778f, -0.01742340f, 0.08226538f, 0.05707778f, -0.09027025f, -0.01568542f, -0.06720727f, 
    -0.38648152f, 0.17327955f, -0.02477344f, 0.02141966f, 0.04413156f, -0.46260762f, -0.09929814f, -0.31080234f, 
    0.12679213f, 0.07076175f, 0.02353950f, -0.02617556f, 0.37034371f, -0.05619105f, -0.16027071f, -0.30432686f, 
    0.23528779f, 0.02290961f, 0.31423903f, 0.06754839f, -0.16699979f, -0.04791171f, 0.06994314f, -0.20320454f, 
    0.13727444f, -0.05050292f, -0.32569987f, 0.11043090f, -0.20440556f, 0.16951397f, 0.07330390f, -0.04540977f, 
    0.16854207f, 0.02812739f, 0.17387225f, 0.05712164f, 0.22461258f, 0.13629563f, 0.17957252f, -0.15695271f, 
    0.06910313f, -0.09304889f, -0.04593457f, -0.09445547f, 0.01364926f, 0.02607467f, -0.00814130f, -0.11162283f, 
    -0.06774951f, -0.11242617f, -0.22472481f, -0.17460197f, 0.21205047f, 0.01232725f, 0.00178424f, -0.12898602f, 
    0.21281509f, 0.01093195f, 0.00468053f, 0.02199559f, -0.22507799f, -0.04023493f, 0.04120240f, -0.34229401f, 
    0.05946069f, -0.00621920f, -0.03775676f, 0.08824620f, -0.07832343f, 0.08211938f, 0.14049430f, 0.01983469f, 
    -0.07283190f, 0.08342700f, 0.18475078f, -0.19078748f, -0.06828114f, 0.08418415f, -0.16339689f, -0.22562358f, 
    -0.25779322f, -0.05546288f, -0.08524883f, -0.03901730f, -0.15137887f, -0.57821184f, 0.05965572f, 0.10489741f, 
    0.01071407f, -0.25412723f, 0.07532463f, -0.05633089f, 0.00184889f, 0.23659684f, 0.07749522f, 0.07187934f, 
    0.05522160f, -0.36199087f, -0.69956523f, -0.73526168f, 0.00531086f, -0.04374480f, 0.02955786f, -0.01315827f, 
    -0.07393471f, 0.08450247f, 0.03946016f, 0.19609834f, -0.25615352f, 0.01587828f, 0.11127476f, -0.22853345f, 
    0.06385139f, 0.26655272f, -0.31850639f, 0.36256519f, -0.32523414f, -0.26047078f, -0.26312682f, -0.40815508f, 
    0.00489451f, -0.08330277f, 0.06038916f, -0.06982895f, -0.00725021f, -0.06879585f, -0.18391055f, -0.22850086f, 
    0.28882876f, 0.20465009f, -0.06984070f, -0.09981887f, -0.28173953f, 0.09848551f, -0.10537899f, -0.40612704f, 
    -0.42950696f, 0.02234471f, 0.03610636f, -0.08759176f, 0.15357803f, -0.03667677f, 0.20933351f, 0.13381904f, 
    -0.32884747f, -0.04672418f, -0.19393539f, -0.04017277f, -0.06279942f, -0.02897117f, 0.04047677f, -0.11877700f, 
    0.11432572f, 0.03634913f, -0.09074143f, -0.73804295f, 0.34445104f, -0.84420139f, -0.07380018f, 0.21383837f, 
    0.12762393f, 0.04418501f, -0.17593502f, 0.14483890f, 0.09720119f, 0.08123498f, 0.24063289f, 0.00065242f, 
    -0.02100073f, -0.08162583f, -0.06255646f, -0.01303512f, 0.17618348f, 0.10203996f, 0.01868160f, -0.16855475f, 
    -0.25055352f, 0.03826105f, -0.52499026f, -0.18645991f, 0.20580855f, 0.13236004f, 0.05591596f, 0.12939194f, 
    -0.06601472f, 0.13157962f, 0.08085656f, -0.09027949f, 0.13721743f, 0.31374091f, 0.00297129f, 0.22739728f, 
    -0.21709585f, -0.34607741f, 0.07834082f, -0.67586637f, 0.02725013f, -0.18499725f, 0.09940290f, 0.01929176f, 
    -0.06121041f, -0.10619737f, 0.04003110f, -0.15601093f, -0.03334983f, -0.03176120f, 0.08387556f, 0.08521454f, 
    -0.02960188f, 0.03753302f, -0.06184061f, 0.01217958f, -0.10868275f, -0.29986438f, -0.16034859f, 0.17410082f, 
    -0.04413583f, 0.14732572f, 0.04583242f, 0.00475484f, 0.06346612f, -0.06842485f, -0.09266997f, 0.22449672f, 
    -0.23353814f, -0.08838331f, -0.32365140f, 0.41226113f, -0.07343097f, 0.24528939f, -0.01381532f, 0.03832757f, 
    -0.24728617f, -0.08099826f, -0.56518692f, -0.01183108f, 0.06995403f, -0.04138236f, -0.42039487f, 0.17974199f, 
    -0.10251427f, -0.17860743f, 0.18817648f, 0.26095057f, 0.17743605f, -0.26967591f, 0.21375167f, 0.04642688f, 
    -0.04558361f, 0.04112384f, -0.01683438f, -0.34413227f, 0.02545203f, -0.08285414f, 0.19703189f, -0.31959087f, 
    -0.10077024f, 0.03768925f, -0.04894075f, -0.25284311f, -0.13038704f, 0.23071691f, 0.06179091f, -0.06823926f, 
    0.11286596f, 0.00585879f, -0.44482738f, -0.01812785f, 0.12678494f, 0.00143876f, -0.15535857f, -0.12172572f, 
    0.20129322f, 0.06214259f, 0.25563601f, -0.09949051f, 0.13372709f, 0.06812380f, 0.00118962f, 0.17358306f, 
    -0.01801006f, -0.08689015f, 0.17911087f, 0.00632044f, 0.30206323f, -0.33759990f, -0.02884677f, -0.51555532f, 
    -0.44645816f, -0.14720665f, -0.09890189f, 0.05607191f, 0.14917727f, 0.04366463f, 0.02737097f, -0.28824943f, 
    -0.04073322f, -0.05336864f, -0.08118205f, 0.17921805f, 0.15228167f, 0.09688064f, 0.04622109f, -0.11200684f, 
    -0.23084699f, 0.03902055f, -0.22058991f, 0.23058385f, -0.26551735f, -0.08976138f, 0.00401183f, -0.06327821f, 
    -0.25744677f, 0.19037192f, 0.12017017f, 0.12484007f, -0.14682163f, -0.25459203f, -0.05739008f, 0.05027595f, 
    0.06660851f, -0.25651288f, 0.07417823f, -0.43475312f, 0.00053599f, -0.06111427f, 0.05939355f, -0.05081581f, 
    -0.09595390f, -0.28611708f, 0.04866440f, -0.10359924f, -0.09281237f, 0.03375715f, -0.40851608f, -0.37705719f, 
    0.27270383f, 0.08055180f, -0.04661487f, -0.11858395f, -0.24747637f, -0.28859308f, -0.27343622f, -0.35149214f, 
    0.02597075f, 0.09419857f, -0.02136116f, -0.60944241f, 0.01118130f, -0.08929778f, -0.04984993f, 0.10913350f, 
    -0.04964622f, -0.29776776f, 0.04364279f, -0.32201234f, -0.07560299f, 0.10535913f, 0.03360043f, 0.07196318f, 
    0.15067893f, 0.00707230f, -0.36690754f, 0.03915850f, 0.05940665f, 0.09847412f, -0.01511405f, 0.21880743f, 
    0.28801185f, 0.02279670f, -0.04061917f, -0.01525783f, -0.03078642f, 0.08172849f, 0.08532968f, -0.35915765f, 
    0.06453124f, 0.02481407f, 0.02163499f, -0.55790490f, 0.01237986f, -0.02124487f, 0.22923799f, 0.10698658f, 
    0.17419189f, -0.11237890f, -0.02363684f, -0.41975138f, -0.30365762f, -0.25809216f, 0.24941778f, -0.01631564f, 
    0.14322944f, -0.07020862f, 0.02333654f, 0.08674784f, -0.09523943f, 0.06233957f, -0.24554929f, 0.04466567f, 
    0.23356181f, 0.04179025f, -0.43719634f, -0.01790019f, 0.02068889f, 0.03406439f, 0.00332157f, -0.33647993f, 
    -0.20902041f, 0.05099046f, -0.08277681f, -0.43751511f, -0.03785940f, -0.12380125f, -0.04665352f, 0.20601593f, 
    -0.40941247f, 0.21780656f, -0.19878930f, 0.10070293f, -0.28771371f, 0.18706848f, -0.03169479f, 0.19139475f, 
    -0.06165892f, -0.03368629f, 0.07083312f, 0.22046413f, -0.33262849f, -0.22723003f, 0.07269426f, 0.22567482f, 
    0.34629419f, 0.22705920f, 0.07481507f, 0.19862483f, 0.11375071f, 0.07143720f, -0.05622137f, 0.15691848f, 
    0.22241619f, -0.03014849f, 0.15105547f, -0.10469621f, -0.22008914f, -0.21326305f, -0.04969517f, -0.27935764f, 
    -0.20576787f, -0.30900046f, -0.01146250f, -0.48464000f, 0.02246794f, -0.19855091f, 0.11917677f, 0.00935677f, 
    0.06253599f, -0.25661972f, -0.19483399f, -0.06828385f, 0.07527756f, -0.04529494f, -0.18049893f, -0.34629852f, 
    -0.18239881f, -0.06055924f, -0.05951915f, -0.19476767f, 0.14092459f, -0.20012958f, 0.02150507f, 0.30733678f, 
    -0.06388388f, -0.17506728f, 0.05848368f, -0.08150312f, -0.02189803f, -0.11481897f, 0.07124686f, 0.30966955f, 
    0.22992374f, -0.29573831f, -0.45271081f, 0.24953300f, 0.05933373f, 0.10293073f, 0.01835717f, -0.02750905f, 
    0.34442756f, 0.02826366f, 0.16723153f, 0.12391494f, -0.21529336f, 0.08313916f, -0.15949710f, 0.12231377f, 
    0.20552090f, -0.29440454f, 0.16301203f, -0.10975948f, -0.26061723f, -0.21407771f, -0.36611465f, 0.01550497f, 
    -0.04718686f, -0.06508883f, 0.02526167f, -0.19741178f, 0.02299764f, 0.04538937f, 0.06990948f, -0.05054333f, 
    -0.38145396f, 0.15223716f, -0.07801621f, 0.21621105f, 0.03338872f, 0.22024639f, -0.11800780f, 0.01552526f, 
    -0.28917545f, 0.05221841f, -0.08582053f, 0.01846485f, 0.35140765f, 0.04628885f, 0.26203948f, -0.38393664f, 
    -0.36493468f, 0.04199172f, 0.08122654f, -0.00983812f, -0.31602412f, -0.05712544f, 0.04012198f, -0.12176399f, 
    -0.23271340f, 0.00877627f, 0.11210503f, 0.16771518f, 0.08368585f, 0.10393926f, 0.06217714f, -0.05351910f, 
    0.16471426f, 0.13557553f, -0.09809562f, -0.25197241f, -0.15309677f, -0.09976371f, 0.02123212f, -0.48280489f, 
    -0.07026878f, 0.02403567f, 0.03811972f, -0.51204473f, 0.03932012f, 0.14997226f, 0.05667990f, -0.08582537f, 
    0.07269002f, 0.12851411f, 0.39183530f, 0.08315317f, 0.01781830f, 0.14929655f, 0.06451058f, -0.13715068f, 
    0.18246351f, 0.24539134f, -0.32949451f, -0.41753337f, 0.25608426f, -0.27825221f, 0.07120705f, 0.09613064f, 
    -0.11380123f, -0.35756174f, -0.06304691f, 0.03914914f, 0.06388368f, -0.17994234f, -0.40283757f, 0.06372298f, 
    0.04632237f, -0.11116146f, 0.33873716f, -0.21138257f, 0.00711237f, 0.04166611f, 0.19208759f, -0.10148061f, 
    -0.16640340f, -0.06574131f, -0.08118176f, 0.22708663f, 0.16026744f, 0.00672617f, 0.33644494f, -0.45931152f, 
    -0.02673065f, 0.16658500f, 0.04782825f, -0.58819824f, -0.06343701f, -0.34947613f, 0.08278520f, -0.35517225f, 
    0.12753296f, -0.13375945f, 0.21490391f, -0.57030183f, 0.03667348f, 0.38837302f, 0.04258802f, -0.07953496f, 
    0.06887481f, -0.07414803f, -0.25758398f, -0.06226256f, -0.45003554f, -0.60799074f, 0.16598573f, -0.09794977f, 
    0.17118001f, 0.00772118f, -0.25460786f, -0.33737004f, 0.12376662f, 0.17339648f, -0.22383265f, -0.27187127f, 
    0.04820383f, 0.05235181f, -0.05469557f, 0.25357273f, -0.01201222f, 0.05319985f, -0.01886406f, 0.35968152f, 
    -0.17365439f, -0.21342486f, -0.01785390f, 0.26123139f, 0.08084519f, -0.24308060f, -0.05939257f, -0.46225548f, 
    -0.06261937f, 0.01408397f, 0.24078500f, 0.02510595f, -0.02680495f, 0.04311977f, -0.30356809f, 0.12632394f, 
    -0.06548275f, -0.00857389f, 0.36502957f, -0.00666510f, -0.07199433f, 0.01550136f, -0.09234849f, -0.23576897f, 
    -0.00754042f, -0.06677669f, -0.13424444f, -0.50687605f, -0.01070097f, -0.14736545f, -0.08065934f, 0.39129916f, 
    -0.15438271f, 0.13426806f, -0.47111842f, -0.24774820f, 0.41517723f, -0.16715248f, -0.00999016f, -0.32770029f, 
    0.01823905f, 0.01336095f, -0.06707031f, 0.03999560f, 0.04852507f, -0.22740816f, 0.01945799f, 0.24583246f, 
    0.16856931f, -0.08363820f, -0.02661054f, -0.02983970f, 0.09428827f, -0.26246849f, -0.03692587f, 0.13790230f, 
    -0.10519090f, 0.18373358f, -0.05955122f, 0.35445794f, 0.11453594f, -0.20177533f, -0.05083945f, -0.33357188f, 
    -0.68438876f, -0.21323870f, 0.02775818f, -0.39517081f, 0.06981031f, -0.00017453f, 0.13418141f, -0.01741455f, 
    0.03813130f, 0.06121800f, 0.16271105f, -0.07960257f, -0.09601266f, 0.04801791f, 0.00901533f, 0.29123488f, 
    -0.24614280f, 0.04386827f, 0.04815086f, 0.34717986f, -0.15531327f, 0.17231792f, 0.20206848f, 0.15858209f, 
    0.08036691f, 0.08743379f, -0.02119410f, 0.33149076f, -0.02924695f, -0.31343624f, 0.03978860f, -0.33466730f, 
    0.23476852f, -0.04897887f, -0.03635279f, -0.16167818f, 0.03408428f, -0.34845585f, 0.08794298f, -0.05295034f, 
    0.03204658f, 0.05618842f, -0.32396594f, 0.07224359f, 0.05385962f, 0.08585111f, 0.25848413f, 0.14006500f, 
    -0.20828776f, 0.23287682f, 0.00220610f, -0.21867473f, -0.09425646f, -0.31721318f, 0.18340743f, -0.27038649f, 
    -0.02077617f, 0.05889795f, -0.03369877f, -0.28580335f, -0.00713091f, -0.03243883f, -0.28557077f, 0.27811205f, 
    0.04617893f, -0.15026797f, -0.05710629f, 0.21071047f, -0.10763624f, 0.28823644f, 0.10378738f, -0.22343402f, 
    -0.13375373f, 0.03173974f, -0.06378480f, 0.01316783f, -0.26907855f, 0.06212939f, 0.05927224f, 0.00633871f, 
    -0.19957137f, -0.07879972f, -0.23734072f, 0.06604775f, 0.21714248f, -0.02726098f, -0.03599048f, -0.26553208f, 
    0.07028734f, 0.03708006f, 0.10987550f, -0.04661766f, -0.16264778f, -0.40588424f, -0.03024065f, -0.28447804f, 
    -0.24024710f, 0.21954694f, -0.12975556f, 0.16987596f, -0.21413343f, 0.07057802f, -0.17841603f, 0.35833824f, 
    -0.08393909f, 0.05958634f, 0.06826737f, -0.34251961f, 0.10161794f, 0.06327837f, -0.07692074f, -0.05964397f, 
    -0.45877376f, 0.24068484f, -0.18350708f, -0.21390648f, 0.17061348f, -0.10675884f, -0.07374000f, 0.18908656f, 
    0.23221290f, -0.31555662f, 0.20695320f, -0.16271879f, -0.07356131f, -0.16048880f, 0.03054896f, 0.22754996f, 
    0.35746738f, -0.08188727f, -0.02746410f, -0.39066252f, 0.04236158f, -0.43052635f, 0.14378093f, -0.03120504f, 
    -0.06577412f, -0.43846998f, -0.31722996f, 0.00749522f, -0.01415901f, -0.02840602f, 0.00126492f, 0.36958832f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11583623f, -0.04293919f, 0.05727525f, -0.14377660f, 0.03577895f, 0.11954241f, 0.15331377f, -0.13182920f, 
    0.07235165f, 0.00506125f, 0.04878527f, -0.09879973f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
