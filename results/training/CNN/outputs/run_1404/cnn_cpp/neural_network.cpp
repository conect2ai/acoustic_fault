#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.25404340f, 0.10550562f, 1.16829836f, 0.69808614f, -0.85831714f, -0.85262519f, 0.06008194f, -0.33421066f, 
    0.44545725f, -0.84557045f, -0.84868324f, -1.07435107f, 0.86085451f, 0.95539820f, 0.41857395f, 0.38808298f, 
    0.40840974f, 0.45177972f, 0.45821121f, -0.04279219f, 0.01981614f, -0.63132757f, -0.05766671f, -0.19125226f, 
    0.61422002f, 0.02196610f, 1.04832733f, -0.76359469f, -0.24490757f, 0.87043399f, 0.44769889f, 0.98448026f, 
    1.18260121f, -0.12586558f, -0.19888052f, 0.31601700f, -0.70982009f, -0.13047287f, 0.37513414f, -0.85511112f, 
    0.27247241f, 1.25777900f, -0.06568745f, -0.35730121f, 0.33765358f, -0.82833296f, -0.36114863f, -0.58608544f, 
    -0.10001076f, -0.25846937f, 0.50632781f, 0.90125918f, 0.77976596f, 0.79070604f, -0.62437803f, 1.64847720f, 
    -1.12076879f, -0.52857059f, 0.05810300f, -0.11382358f, 0.05645439f, 0.43235430f, 0.17842817f, 1.53434837f, 
    0.56776720f, 0.53741485f, -0.07990339f, -0.55286717f, -0.56132734f, 0.19784659f, 0.57990879f, 0.06564270f, 
    0.40738207f, 0.51380140f, 0.21937774f, 0.42126453f, 0.64621067f, 0.32932481f, 0.25842920f, 0.01928917f, 
    0.92655718f, 1.43874907f, 0.35332832f, -0.74551040f, 0.91154712f, 0.80712354f, -0.06828672f, 0.08801978f, 
    0.12555274f, -0.00817844f, 0.27101284f, 0.83874869f, 0.23246332f, 0.35595807f, -0.05708360f, -0.39612827f, 
    -0.03720274f, -1.11338139f, -0.41697556f, 0.77830255f, 0.69085467f, 1.01008701f, -0.81510419f, -0.62000048f, 
    0.92093796f, 0.07802305f, -0.04653472f, -0.36221781f, -0.80809814f, -0.16465105f, 0.75917011f, -0.53009909f, 
    -1.25299370f, -0.99015588f, -0.00693004f, 1.17582953f, -0.31661254f, -0.70015073f, -0.46342784f, -0.44279733f, 
    -0.54306006f, -1.12698567f, -1.30348265f, -0.32706997f, -0.51640618f, 0.15610337f, -1.52616274f, -1.74518669f, 
    -0.50087190f, 1.47092807f, -0.03989432f, -0.40642336f, -0.37458974f, -0.91627151f, -0.63332647f, -1.24953687f, 
    -0.27868280f, 0.35872993f, -0.14766458f, -0.49899122f, -0.94453537f, -0.32019094f, -0.76378798f, -1.09015763f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01365166f, 0.11039373f, -0.21955331f, -0.11762422f, 0.72912514f, 0.60986477f, 0.92507535f, 0.87079215f, 
    0.87929201f, 0.37508249f, 0.53317457f, 0.44270840f, 0.14007859f, -0.91917408f, 0.40049949f, -0.16168599f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.20828633f, -0.77825451f, -0.54440373f, 0.22972283f, -0.07476301f, -0.08861326f, 0.33888328f, 0.16275360f, 
    -0.30566975f, -0.29508081f, 0.57638675f, 0.24785514f, -0.04282657f, 0.03090389f, 0.03445695f, 0.19978559f, 
    0.11714155f, 0.11388256f, -0.36788541f, -0.29424939f, -0.50456458f, -0.02526315f, -0.32968125f, -0.22567208f, 
    0.05031512f, 0.26312298f, 0.19747561f, -0.25630826f, -0.14679180f, -0.31815794f, 0.09137187f, 0.22789243f, 
    -0.14229231f, -0.08452663f, -0.05756229f, 0.00805177f, 0.00223463f, 0.00569410f, 0.08662452f, 0.41134533f, 
    0.42296937f, 0.06177476f, 0.17780271f, -0.00907689f, 0.15553187f, 0.04166865f, 0.08034156f, -0.19590117f, 
    0.12753640f, -0.15518335f, -0.02608148f, 0.38627949f, 0.38117215f, 0.13135751f, 0.26230606f, -0.11891107f, 
    -0.16996674f, 0.16649234f, -0.06664527f, 0.07430727f, 0.25212026f, 0.24937522f, -0.08039188f, 0.28220400f, 
    -0.09289116f, -0.27187863f, 0.03955376f, -0.10305449f, -0.00472283f, 0.15350530f, 0.04339381f, 0.40137190f, 
    -0.02817011f, -0.00285556f, 0.03924706f, 0.01805884f, 0.04952900f, 0.18369906f, 0.05600507f, 0.14570160f, 
    0.21133338f, 0.24759105f, 0.03449377f, -0.14892195f, 0.03595430f, 0.04910320f, -0.08279876f, 0.02099109f, 
    -0.21859872f, -0.25567979f, 0.30857119f, -0.23051555f, -0.20489627f, 0.15846173f, 0.02690274f, 0.10124869f, 
    -0.09062465f, -0.09490865f, -0.15732276f, 0.23845354f, 0.15693623f, 0.12543242f, 0.00046576f, 0.13660127f, 
    0.06229110f, -0.24406484f, -0.09194906f, -0.23304884f, -0.05482035f, -0.13697410f, 0.34074974f, 0.01003815f, 
    -0.05361573f, -0.09142429f, 0.12071119f, 0.11654797f, 0.16690882f, 0.13941872f, 0.22251825f, -0.04822490f, 
    -0.00709325f, -0.02867405f, 0.08703700f, 0.03612227f, 0.11450614f, 0.03698169f, -0.55468720f, 0.33273017f, 
    0.34713566f, -0.08848193f, 0.02332595f, 0.30642244f, -0.16328830f, -0.22085132f, -0.28441113f, -0.50976354f, 
    -0.16252832f, 0.20292306f, -0.04546341f, -0.04773704f, 0.29929504f, 0.00136502f, 0.30751324f, 0.00111127f, 
    0.01603634f, 0.02727104f, 0.05380790f, -0.06894878f, 0.03832121f, 0.06657708f, 0.02394755f, -0.03566512f, 
    -0.00130553f, -0.04212285f, 0.01636443f, -0.04670889f, 0.00161872f, -0.04827899f, -0.07389036f, 0.04771915f, 
    -0.04502154f, -0.02310109f, 0.01689844f, -0.03379466f, 0.05484411f, -0.02869268f, 0.05273166f, 0.02731411f, 
    0.04375482f, -0.00858810f, 0.04357786f, -0.06715926f, -0.05665335f, -0.04725156f, -0.07849563f, -0.07699603f, 
    0.04976377f, 0.06158071f, -0.06019795f, -0.03639972f, 0.02940953f, -0.04509455f, -0.01214835f, 0.06114869f, 
    0.04764650f, -0.03215158f, 0.06458383f, -0.06023367f, -0.03870356f, -0.07194921f, 0.02627638f, 0.00030187f, 
    -0.07988063f, -0.07525854f, -0.06777249f, 0.04690982f, 0.01499580f, -0.06788310f, -0.07064353f, -0.01478044f, 
    0.04418669f, -0.07979396f, -0.08788382f, -0.01971099f, -0.08961149f, -0.00024459f, -0.06902630f, 0.07233592f, 
    0.06910454f, 0.05584613f, -0.08404285f, -0.02178706f, -0.01356097f, 0.00622011f, -0.06195628f, 0.06217511f, 
    0.03425482f, -0.08133562f, -0.06507467f, 0.04111032f, -0.05615675f, -0.02886226f, 0.04195673f, -0.02807754f, 
    -0.02189773f, -0.00477383f, -0.07026353f, 0.06211053f, 0.03377240f, 0.02618551f, -0.08686108f, 0.05072057f, 
    0.00364098f, -0.06470486f, -0.07534953f, -0.03373861f, 0.02388395f, 0.02878672f, -0.04218664f, 0.03713784f, 
    0.04151872f, -0.00131406f, -0.03823955f, -0.06474625f, -0.03814144f, -0.06380217f, 0.02869348f, 0.04042969f, 
    0.00522286f, -0.06003449f, -0.03142605f, -0.08817838f, -0.08714481f, 0.01869762f, 0.00851792f, 0.01696027f, 
    0.02754984f, 0.02708205f, 0.06434606f, 0.06518870f, 0.02597867f, 0.05276886f, -0.04221725f, -0.02008068f, 
    -0.07884926f, -0.09202069f, 0.01473890f, 0.05850136f, 0.01084838f, 0.03621572f, -0.08627346f, -0.02361381f, 
    -0.08836064f, -0.04769576f, -0.07640915f, 0.00805738f, 0.06390938f, -0.06889764f, 0.05949468f, 0.01853203f, 
    -0.05413269f, 0.06302226f, 0.06485952f, -0.06805061f, -0.04427366f, 0.01899904f, -0.08683766f, -0.06584205f, 
    -0.72434425f, 0.06169933f, 0.23697788f, 0.02812462f, 0.19411469f, -0.00304770f, -0.02751768f, 0.13245107f, 
    0.00328114f, 0.00052738f, 0.06968937f, 0.49623656f, -0.03424792f, -0.08627391f, -0.25446752f, 0.07546316f, 
    -0.10654465f, 0.00847947f, -0.06124284f, 0.62015527f, 0.12614715f, 0.32505092f, 0.05374514f, 0.26347131f, 
    0.12231121f, 0.19355591f, 0.48484749f, 0.19622438f, 0.37248206f, 0.10638373f, -0.07670499f, 0.01449209f, 
    -0.20842618f, -0.03656806f, -0.13862354f, -0.19735907f, -0.00905090f, 0.46554184f, -0.57429838f, -0.00820879f, 
    -0.27488047f, -0.15990883f, 0.10873730f, -0.26914731f, 0.03288441f, 0.11877707f, 0.21181247f, 0.24978183f, 
    0.08577798f, -0.01444082f, -0.02014905f, 0.40913188f, 0.27170080f, 0.40176052f, 0.48132417f, 0.32511118f, 
    0.06075064f, -0.09197962f, 0.41440025f, -0.08621000f, -0.11658226f, 0.21034907f, -0.12093794f, -0.73521245f, 
    -0.08624454f, -0.04837918f, 0.08778378f, 0.19720942f, 0.03938374f, 0.07796399f, 0.13871634f, 0.06418012f, 
    -0.12786910f, 0.14085566f, 0.15881331f, -0.02230475f, 0.08865438f, 0.06344068f, -0.01810956f, 0.14214855f, 
    0.16791038f, -0.12925127f, 0.13647223f, -0.00972426f, 0.02985292f, -0.11194412f, -0.01732441f, -0.07330432f, 
    0.09902781f, 0.19810171f, -0.21534227f, -0.08341652f, 0.13910525f, 0.19709831f, -0.18220164f, -0.14775218f, 
    0.03178790f, 0.04598051f, -0.16222037f, -0.66760147f, -0.12599134f, -0.28766635f, 0.00914480f, -0.03477456f, 
    -0.04957899f, -0.27840632f, 0.06176930f, 0.11228930f, 0.72564942f, 0.31638330f, 0.33139530f, -0.17110722f, 
    0.40053269f, 0.07245422f, 0.01825760f, 0.20834644f, -0.08978286f, -0.28839606f, 0.24258238f, 0.95929110f, 
    0.00815208f, -0.09482034f, -0.03763265f, -0.00836257f, 0.04964212f, -0.03854427f, 0.21436153f, -0.44491497f, 
    0.48558253f, -0.16896211f, -0.08171629f, -0.13668583f, -0.02447009f, -0.20904478f, -0.13549471f, 0.19766413f, 
    0.09694371f, 0.41795111f, 0.00096071f, -0.00852522f, 0.05448388f, 0.09508517f, 0.33758900f, -0.00623082f, 
    -0.03143894f, 0.27276388f, 0.35934937f, 0.03972731f, -0.18643434f, -0.14063966f, 0.19760038f, 0.11208901f, 
    0.13074078f, -0.31741679f, -0.25728536f, -0.48723856f, -0.30009940f, 0.00735725f, 0.02213288f, 0.14839043f, 
    -0.21372506f, -0.10603473f, -0.17903188f, -0.13919102f, 0.10890510f, -0.28412846f, -0.05222688f, -0.07229966f, 
    0.17327487f, 0.16540469f, 0.28520811f, -0.10194448f, -0.37997583f, -0.53561801f, -0.02161319f, -0.08369584f, 
    -0.05538363f, -0.09238707f, -0.07238756f, 0.10415185f, 0.42865935f, -0.05313832f, 0.27077878f, 0.03654859f, 
    0.15656705f, 0.14503595f, -0.01536169f, 0.27322075f, 0.07012483f, 0.01726045f, -0.33111703f, -0.04748632f, 
    -0.00272199f, 0.11262014f, 0.09747215f, 0.28136435f, -0.01312987f, -0.08413183f, -0.11749330f, -0.82644206f, 
    -0.42383021f, -0.05499802f, 0.10710733f, 0.04033715f, 0.49778223f, 0.24910031f, -0.01950109f, 0.36848381f, 
    0.31380388f, 0.17739253f, 0.05677604f, 0.06693450f, -0.15046799f, 0.18988152f, 0.09292524f, 0.23246762f, 
    0.35239536f, 0.37378713f, 0.23602943f, -0.00668458f, -0.03508024f, 0.06942869f, -0.05431538f, -0.21608654f, 
    -0.03663575f, 0.13473420f, 0.35826397f, -0.09656287f, -0.30422857f, -0.02729830f, -0.10715176f, -0.21675402f, 
    0.13122864f, 0.20673391f, 0.17806211f, 0.03505722f, 0.13385439f, 0.04318260f, 0.08955661f, -0.10080823f, 
    -0.02702284f, -0.02290918f, 0.17394337f, 0.69078040f, 0.09940020f, 0.46980217f, 0.02875988f, 0.16734517f, 
    -0.04013468f, 0.02981364f, 0.03568354f, 0.20186625f, -0.58997083f, -0.18274611f, 0.07224447f, 0.09239117f, 
    -0.40271646f, -0.13183163f, 0.18454348f, 0.10580049f, 0.09837846f, -0.40727410f, 0.29305828f, -0.33697939f, 
    -0.25890943f, -0.08871379f, -0.59248030f, 0.02663323f, -0.14743841f, 0.02281299f, -0.16784865f, -0.55239427f, 
    -0.06017124f, -0.24312522f, 0.17590587f, -0.04659832f, -0.08171938f, -0.25874731f, -0.11159767f, 0.16343880f, 
    -0.13248500f, -0.59714055f, -0.58375329f, -0.25157449f, 0.24709174f, 0.13388838f, -0.11095355f, -0.00202477f, 
    -0.64248580f, -0.56000191f, -0.60818976f, -0.25083008f, 0.05635703f, -0.09852505f, 0.14694583f, 0.14687152f, 
    -0.08455394f, 0.03786860f, -0.69815278f, -0.11771417f, -0.06426261f, 0.00330098f, 0.10256716f, 0.03306911f, 
    0.13035135f, 0.12515816f, -0.10256564f, 0.32900968f, 0.46827787f, -0.51062411f, -0.19260676f, -0.34061423f, 
    -0.31818163f, -0.37886694f, 0.27974918f, -0.30319259f, -0.31370780f, -0.36905167f, -0.10767835f, -0.26639247f, 
    -0.14516795f, 0.09752951f, 0.05017632f, 0.08661808f, -0.72664660f, -0.27768147f, 0.06499479f, 0.14056501f, 
    -0.29003820f, 0.16775279f, 0.55905908f, 0.18802252f, -0.13591659f, 0.29729339f, 0.22922270f, 0.38071778f, 
    -0.09557760f, 0.09784277f, 0.14233850f, 0.10697231f, -0.03364992f, -0.03021633f, 0.16655035f, 0.04694890f, 
    0.01837320f, 0.06961966f, 0.56399792f, 0.74869943f, 0.04019589f, 0.26578766f, -0.08957618f, -0.32402784f, 
    -0.61571467f, -0.10179418f, -0.07717813f, 0.34595883f, -0.00299214f, 0.00313177f, -0.01145023f, 0.33536610f, 
    -0.07428605f, -0.42932341f, -0.04059887f, -0.13783592f, 0.16739084f, -0.02089739f, 0.20670499f, -0.06172232f, 
    0.19130287f, 0.23560373f, -0.70825046f, -0.28795359f, -0.15795998f, -0.42882043f, -0.30673203f, 0.17865275f, 
    0.06492605f, 0.07965890f, 0.63618219f, -0.05898965f, -0.01934667f, 0.16366352f, -0.10028411f, -0.00057663f, 
    0.15323472f, -0.26429969f, -0.29330498f, -0.11572184f, -0.36530152f, -0.04187260f, -0.03124780f, -0.35891348f, 
    0.05635074f, -0.35540909f, 0.16703211f, 0.10002553f, -0.18942066f, 0.30401868f, 0.89965820f, 0.06825933f, 
    -0.04726591f, -0.08211437f, -0.05599612f, -0.10542390f, 0.14721115f, 0.08370622f, 0.33484134f, 0.45888770f, 
    -0.22222222f, 0.13924061f, -0.21711569f, 0.15072520f, -0.19355097f, -0.11822791f, 0.04382558f, 0.08779614f, 
    -0.18212943f, 0.00140708f, 0.15302813f, -0.17047061f, 0.31991777f, 0.03239664f, -0.01677543f, -0.10278077f, 
    0.05728187f, 0.12134391f, -0.15217344f, 0.11775926f, 0.03177795f, 0.17329685f, 0.04054770f, 0.07896847f, 
    -0.30630940f, 0.07120800f, 0.30284578f, 0.03936912f, 0.11009501f, 0.03822383f, 0.21917231f, 0.29077429f, 
    -0.16826145f, 0.55394125f, -0.19245632f, -0.28083953f, -0.18072334f, -0.18040401f, 0.08956451f, 0.24090567f, 
    0.02688778f, 0.05991596f, -0.04482482f, 0.21224868f, 0.13949285f, -0.08035328f, -0.04660197f, 0.08702414f, 
    -0.04092795f, -0.04063023f, 0.21013018f, 0.10724970f, 0.36744037f, -0.06918135f, -0.62101841f, -0.16221242f, 
    -0.26211831f, -0.02268565f, 0.13866735f, 0.09614000f, -0.18243197f, 0.19500189f, -0.09145693f, -0.00454192f, 
    -0.34251672f, -0.13168861f, -0.19844407f, -0.22501373f, -0.17180611f, 0.58081537f, 0.06398260f, 0.02303719f, 
    -0.04285349f, -0.03479093f, 0.11149254f, 0.12173749f, -0.04825988f, 0.12653345f, 0.36865318f, 0.62154984f, 
    -0.40544507f, -0.21591967f, 0.34020597f, -0.12801528f, 0.14505814f, -0.08740901f, -0.25980574f, -0.16325486f, 
    0.16840240f, 0.08334461f, 0.10031980f, 0.04732543f, 0.08571488f, -0.10958919f, -0.07132604f, 0.13700889f, 
    0.09105492f, 0.20440133f, -0.05035556f, -0.34755835f, -0.45398104f, -0.45364362f, 0.08485803f, 0.09138718f, 
    0.22828144f, 0.22335434f, 0.09866298f, 0.08329792f, 0.10955530f, -0.38582790f, -0.14445087f, 0.01553378f, 
    0.17692500f, 0.04604013f, -0.09153193f, -0.08589974f, 0.10218074f, 0.07244699f, -0.05116891f, -0.01958699f, 
    -0.23601149f, -0.11384815f, 0.07159223f, -0.02671420f, 0.05576185f, 0.10480434f, 0.21119656f, 0.06026040f, 
    0.10141360f, 0.02712478f, 0.02492888f, 0.00981924f, 0.24441998f, 0.41240871f, -0.02159457f, 0.07460295f, 
    0.16481340f, -0.10449155f, 0.24310586f, -0.11093412f, 0.23648642f, 0.43173486f, 0.23292288f, 0.31151581f, 
    -0.05519167f, -0.03731100f, -0.00772730f, -0.14554028f, -0.17172456f, 0.16895631f, 0.74716306f, -1.05794919f, 
    -0.48756212f, -0.16002670f, -0.06911865f, -0.22637394f, 0.10197947f, -0.05196109f, -0.14427418f, 0.82913017f, 
    -0.24736492f, -0.26171494f, 0.02039303f, -0.20449364f, -0.32066649f, 0.18774477f, -0.02352164f, 0.15683365f, 
    0.46635133f, -0.97724456f, 0.40266347f, 0.06914454f, 0.15698822f, 0.11566966f, 0.00957670f, -0.02899965f, 
    0.25420064f, -0.21472770f, 0.20728526f, -0.17408763f, -0.31071523f, -0.10947045f, -0.00520189f, 0.14101107f, 
    0.03571071f, -0.06376573f, 0.13112763f, 0.04755885f, 0.05910178f, 0.18977332f, 0.04699880f, -0.09709267f, 
    -0.17694995f, -0.00664430f, -0.10907200f, -0.32318169f, -0.04233858f, -0.07380302f, -0.18523344f, -0.11303956f, 
    -0.00621184f, -0.04076954f, -0.19244824f, 0.08104698f, 0.05808570f, 0.25284663f, 0.37250629f, 0.13670611f, 
    0.25398758f, 0.13613847f, 0.28245777f, 0.05903328f, 0.08113932f, -0.03974402f, 0.25569117f, -0.01245944f, 
    -0.14435194f, -0.07145426f, -0.07207753f, -0.00716691f, 0.07099850f, 0.02185185f, -0.21107075f, -0.23466007f, 
    0.16260169f, 0.21051374f, 0.21262981f, 0.10223799f, 0.08384444f, 0.21265252f, -0.11181245f, 0.42975250f, 
    -0.07415035f, 0.28508490f, 0.03760634f, 0.16913733f, -0.06361069f, 0.08205089f, 0.04813583f, -0.11655579f, 
    0.03226113f, -0.09930937f, 0.14558367f, -0.03355512f, 0.07222687f, -0.00512598f, -0.12217589f, 0.03278938f, 
    -0.03857399f, 0.25507945f, 0.05657922f, -0.04931506f, -0.09773464f, -0.14303373f, -0.30483344f, -0.07736314f, 
    -0.05587969f, -0.18529657f, 0.26871946f, -0.16381963f, -0.13432166f, 0.12203191f, -0.00889819f, 0.05982179f, 
    0.23031999f, 0.07393453f, 0.31067508f, 0.50787771f, 0.03097487f, 0.01859518f, 0.03833452f, -0.03378008f, 
    0.15314461f, -0.01956822f, 0.10832492f, -0.02745358f, -1.34015095f, -0.95032537f, -0.85583478f, 0.21083833f, 
    -0.07683144f, -0.01046673f, -0.07235849f, -0.14883597f, 0.07011508f, 0.73866951f, 0.90733546f, -0.06865044f, 
    0.13160755f, -0.16635366f, -0.08054623f, 0.09076881f, 0.09717070f, 0.05656821f, -0.09295508f, -0.11615600f, 
    -0.11445263f, 0.10353179f, -0.25243938f, -0.20338567f, 0.02381936f, -0.18138207f, -0.06079302f, 0.32023904f, 
    -0.60662317f, -0.50634605f, -0.08090506f, -0.09151100f, 0.09671894f, -0.26711419f, -0.03533475f, -0.11109440f, 
    0.08787860f, -0.90991861f, -0.21613996f, -0.10887840f, 0.04828079f, -0.22276913f, -0.10569498f, 0.11236730f, 
    -0.28151840f, 0.37249470f, -0.05545894f, 0.09825259f, 0.13214453f, -0.23125632f, 0.12055742f, 0.08313115f, 
    0.04890155f, 0.22869210f, 0.47786742f, 0.24673791f, -0.09214278f, 0.01611403f, 0.08305274f, -0.03034322f, 
    0.17062466f, 0.26124951f, 0.06149594f, 0.39267910f, 0.28923902f, 0.44475108f, -0.35350102f, -0.15323021f, 
    -0.19182383f, 0.10074571f, -0.15326943f, 0.04306694f, -0.49490207f, -0.15066414f, 0.19120668f, -0.30846220f, 
    -0.18983062f, -0.08946503f, 0.21028325f, -0.09498616f, -0.03350706f, -0.03680405f, 0.07873651f, 0.26848248f, 
    -0.01548336f, -0.03722491f, -0.10123801f, 0.04314653f, 0.22584954f, 0.21432914f, -0.12553880f, -0.13858961f, 
    -0.65507412f, -0.25248733f, -0.33902371f, -0.00279012f, 0.20621842f, -0.08241104f, -0.01306010f, 0.07130491f, 
    -0.64279246f, -0.64099354f, -0.10434555f, -0.04398781f, 0.10196961f, 0.03230160f, 0.07729453f, 0.09378020f, 
    0.11207119f, 0.09075359f, -0.01184403f, -0.06853860f, -0.16743760f, -0.26085305f, -0.02685248f, 0.12607253f, 
    -0.25792557f, 0.08110249f, 0.29338643f, -0.25745583f, -0.20660810f, 0.11532462f, 0.11898194f, 0.02380826f, 
    0.10047584f, 0.11677915f, -0.31521079f, -0.34191748f, 0.06695292f, -0.02722886f, 0.04707183f, 0.05353904f, 
    0.16640462f, -0.19798338f, -0.14448324f, -0.25179106f, -0.38957968f, -0.50546974f, 0.11512361f, -0.07906261f, 
    -0.21018180f, 0.09726015f, -0.01244993f, 0.13565753f, 0.38300228f, 0.46896487f, 0.62856722f, -0.37184578f, 
    0.18681937f, -0.12495967f, 0.02929248f, 0.14312673f, 0.13629986f, 0.57571781f, 0.63304448f, 0.45806265f, 
    -0.28994963f, -0.01259715f, -0.09928703f, 0.14685091f, 0.05375637f, 0.10302554f, 0.59844011f, 0.26276442f, 
    0.12668990f, -0.08158690f, -0.07445848f, 0.17327558f, 0.00919184f, 0.12782435f, -0.14740181f, 0.32579407f, 
    0.16268726f, 0.08860558f, -0.15890828f, -0.05474171f, -0.10498343f, 0.02837725f, 0.04417855f, -0.03218460f, 
    0.27969396f, 0.70765066f, -0.05030192f, -0.15257183f, 0.09275687f, -0.05200864f, -0.02400502f, 0.02143109f, 
    -0.08007576f, 0.26125100f, -0.11914479f, 0.47842073f, -0.33371228f, -0.12775145f, -0.01245137f, 0.24715377f, 
    -0.11212988f, -0.14173117f, -0.29802272f, 0.01637253f, 0.01355506f, 0.11963720f, -0.08326288f, -0.18126641f, 
    -0.26555440f, -0.35749120f, -0.19842879f, -0.07569529f, -0.11122841f, -0.22556522f, 0.28480074f, 0.15383340f, 
    0.06481674f, 0.07745108f, 0.01634597f, -0.69848531f, 0.11746386f, 0.09240365f, 0.00900288f, 0.25841933f, 
    0.30685055f, 0.28611174f, -0.10598584f, 0.22500557f, -0.36776036f, 0.14960420f, 0.06098067f, 0.06664473f, 
    0.09559297f, 0.16547377f, -0.27118003f, -0.21659672f, -0.26238859f, -0.53270715f, 0.25308454f, 0.18178998f, 
    0.34188634f, 0.50291616f, -0.25647962f, -0.11916233f, -0.15449385f, -0.35717875f, 0.10258789f, 0.00783080f, 
    0.33088386f, 0.29500380f, -0.01787485f, -0.12747781f, -0.06561864f, -0.00399029f, -0.03283279f, -0.20769633f, 
    0.03614163f, 0.01267353f, -0.17387779f, 0.09788150f, 0.07993285f, 0.16497070f, -0.04308861f, 0.27958030f, 
    -0.14120272f, 0.01532317f, -0.08685510f, 0.46194372f, 0.30511409f, -0.00410327f, 0.27232769f, -0.02476085f, 
    0.16792600f, 0.07350703f, -0.04553663f, 0.10861243f, 0.25759840f, 0.15977541f, 0.24243143f, 0.16858712f, 
    0.23037001f, 0.12870343f, 0.00103404f, 0.20106801f, 0.25705278f, -0.25994772f, -0.08913322f, -0.02119037f, 
    0.02406037f, 0.20698792f, -0.08326516f, -0.22781019f, -0.49389187f, 0.26871225f, -0.11780328f, 0.17933474f, 
    -0.07150184f, 0.01947461f, -0.19364403f, -0.26792899f, -0.19199437f, 0.05847697f, 0.05453436f, 0.46577924f, 
    0.16831200f, 0.22956121f, -0.21035106f, -0.16651033f, -0.15403813f, -0.01948343f, -0.13738453f, 0.04561231f, 
    0.15027308f, -0.15184839f, 0.29412794f, 0.32423240f, 0.21859519f, 0.40615433f, 0.50193399f, 0.12005738f, 
    0.37668720f, 0.18740954f, -0.05546120f, 0.19082071f, 0.16798083f, -0.01179826f, 0.04180761f, 0.33928007f, 
    -0.23332168f, 0.35748819f, 0.07516286f, -0.03391537f, -0.18867223f, -0.09108518f, 0.04027097f, 0.00097410f, 
    -0.03919199f, -0.03484539f, -0.29074961f, -0.22009298f, 0.01806734f, -0.01421380f, 0.12346772f, -0.11521645f, 
    0.16212991f, 0.01182425f, 0.00690590f, -0.31783047f, -0.24871688f, -0.01836860f, 0.05801896f, 0.23882705f, 
    -0.17139919f, -0.05926456f, 0.21649800f, 0.48739555f, -0.20801613f, 0.30738458f, 0.04840667f, -0.56645107f, 
    -0.33636752f, 0.14785282f, -0.11843299f, -0.11630160f, 0.13754627f, 0.02919494f, 0.45699021f, -0.33871505f, 
    0.25430959f, -0.49155873f, 0.11381937f, 0.28583553f, 0.11850309f, -0.14992790f, -0.02608282f, -0.11664108f, 
    -0.13239670f, -0.12509488f, 0.00570149f, -0.24506420f, 0.01955523f, -0.03462091f, -0.10580597f, 0.25310647f, 
    -0.01425582f, -0.08399799f, 0.46520603f, 0.04196027f, -0.03581692f, 0.04886813f, -0.06775377f, -0.11973432f, 
    -0.21729408f, 0.09868342f, -0.15559615f, -0.00167513f, -0.16893744f, 0.06295709f, 0.20283607f, 0.17166036f, 
    0.23653215f, 0.00911891f, 0.02555798f, -0.11479536f, -0.38498479f, -0.11393039f, 0.07883643f, 0.01337582f, 
    0.09852157f, 0.03888864f, 0.11883935f, -0.01991509f, -0.46239802f, 0.39661056f, -0.48866770f, 0.11647873f, 
    0.02439884f, 0.08217621f, -0.12150646f, 0.04589141f, -0.00407917f, 0.02837695f, 0.37801766f, -0.14913936f, 
    -0.00960503f, 0.05156824f, -0.01292744f, -0.25806177f, -0.44741803f, 0.49262762f, 0.14579539f, 0.12574284f, 
    -0.16838565f, 0.02379648f, 0.11067121f, -0.09001667f, -0.54966009f, 0.03316952f, 0.76676369f, -0.01920209f, 
    0.13353790f, 0.07234721f, -0.07272243f, -0.04692432f, 0.10819352f, -0.01298002f, 0.46477893f, -0.41234961f, 
    -0.18628541f, -0.19695191f, -0.26121059f, 0.07774898f, 0.03250126f, 0.20075111f, 0.03262845f, -0.04060198f, 
    -0.10362825f, 0.01832641f, -0.01819904f, 0.14230955f, 0.09414043f, 0.11373498f, -0.29174966f, -0.57180405f, 
    -0.05556531f, -0.05630623f, -0.05718267f, -0.17019318f, 0.29792386f, 0.03535625f, 0.14736710f, -0.04599106f, 
    -0.04169267f, -0.04979637f, 0.03284486f, 0.03314161f, -0.00140506f, -0.01275218f, -0.00684412f, 0.00632260f, 
    -0.06794789f, -0.04845352f, -0.05202751f, 0.06591230f, -0.04978630f, -0.06707732f, -0.06566799f, -0.07069072f, 
    -0.02579090f, -0.08608180f, 0.05229178f, 0.05791711f, -0.05906496f, 0.05223499f, 0.00612090f, -0.05208670f, 
    0.01149381f, -0.06040540f, 0.07150171f, -0.03330882f, -0.01025747f, -0.03512700f, 0.05420737f, 0.05186106f, 
    0.00195820f, 0.06736738f, 0.02807100f, -0.04878445f, 0.02904110f, -0.00260219f, -0.06091274f, -0.06426112f, 
    0.04342210f, -0.00164805f, -0.00004148f, -0.03631170f, -0.08077888f, -0.07618648f, 0.02877922f, 0.00166385f, 
    -0.06718660f, -0.08933833f, 0.05415624f, -0.02371752f, -0.02563792f, 0.01342675f, 0.03348188f, -0.01151538f, 
    -0.01857701f, -0.03419010f, -0.08596078f, 0.00063026f, -0.07025579f, 0.00802385f, 0.00280334f, 0.04409507f, 
    -0.06536841f, -0.00143279f, 0.03484337f, -0.06536519f, -0.04272055f, -0.08240312f, 0.01932478f, -0.09438097f, 
    0.03710214f, -0.03649884f, -0.04760124f, -0.01715651f, 0.00131181f, 0.03982325f, 0.03206832f, -0.05054140f, 
    -0.04276120f, -0.08858742f, 0.07325927f, -0.07318127f, 0.07110313f, 0.06624907f, -0.07538082f, 0.07679286f, 
    -0.06825408f, 0.07064138f, -0.04239601f, 0.05241721f, 0.05890756f, 0.02752760f, -0.01270296f, -0.00612791f, 
    -0.07675448f, -0.04800208f, -0.03730047f, 0.05345922f, 0.03686357f, 0.05520646f, -0.05298205f, 0.01597015f, 
    -0.00842575f, -0.03510714f, -0.08520109f, -0.02678376f, 0.00682828f, 0.06570996f, 0.06111963f, -0.07199828f, 
    -0.02994169f, 0.03693053f, 0.07883976f, -0.00588520f, -0.01489140f, 0.02494274f, -0.06634126f, 0.00420193f, 
    -0.06089109f, 0.01578477f, -0.02664615f, 0.02633544f, -0.03975983f, -0.05632944f, -0.01287084f, -0.01426034f, 
    -0.02978928f, 0.06767892f, 0.02092496f, -0.01664336f, -0.02275514f, 0.05691166f, -0.01112897f, 0.06522272f, 
    0.05717799f, -0.09391387f, -0.00420229f, -0.06421366f, -0.04884909f, 0.01350542f, 0.01465576f, -0.09704007f, 
    -0.12592892f, -0.55281878f, -0.20950867f, 0.04769448f, -0.00289504f, -0.32592690f, 0.09292214f, -0.38778573f, 
    -0.08955125f, -0.04739004f, 0.51610273f, 0.67993021f, -0.26735973f, -0.54671705f, 0.07281543f, -0.04648813f, 
    0.02173694f, 0.01552980f, -0.12274871f, -0.44521430f, -0.29702979f, -0.18683758f, -0.11616281f, 0.14462458f, 
    0.12025347f, 0.05963343f, 0.17316581f, -0.05656944f, 0.02021774f, 0.00190195f, -0.66106790f, -0.53138381f, 
    -0.47848520f, 0.14684843f, 0.09330641f, 0.09165850f, 0.03515346f, 0.01962626f, -0.03458282f, 0.18784998f, 
    0.06815746f, 0.05797657f, 0.04419011f, 0.08194374f, 0.12824884f, -0.02886367f, 0.41986880f, 0.10682284f, 
    -0.14884558f, -0.17799535f, 0.05409172f, 0.03064905f, -0.08403458f, 0.00347332f, 0.52063996f, -0.13272783f, 
    -0.61511922f, 0.06802161f, -0.18230557f, -0.09056450f, 0.21625373f, 0.03725547f, -0.04813515f, -0.13298488f, 
    0.08704468f, 0.14747071f, 0.13857499f, 0.19653307f, -0.10938649f, 0.21273492f, -0.09767233f, -0.02853446f, 
    0.13095626f, 0.03055938f, 0.04335230f, -0.25903112f, 0.13629881f, 0.41726643f, 0.07400381f, 0.19593403f, 
    0.30244198f, -0.03911269f, 0.01827602f, -0.39531565f, -0.51762575f, -0.33081761f, -0.15949638f, 0.11988048f, 
    0.26309702f, -0.11097079f, -0.03583943f, 0.00846879f, -0.02172754f, 0.11990688f, 0.10043494f, -0.02450879f, 
    0.35906562f, 0.36375555f, 0.57257080f, -0.25746682f, -0.33841306f, 0.00056513f, 0.19206776f, 0.21757355f, 
    -0.29164043f, 0.24688563f, 0.10517221f, -0.20236956f, 0.22219715f, -0.60703087f, -0.49534589f, -0.26263005f, 
    -0.09381253f, -0.22541854f, 0.16910203f, -0.03600297f, 0.06822159f, -0.97740221f, -0.71447927f, -0.18571544f, 
    -0.31388366f, -0.25444978f, -0.10965072f, -0.01020758f, 0.01541755f, -0.07516959f, -0.29750296f, 0.32112283f, 
    0.71413058f, 0.00888885f, -0.01530088f, 0.02354239f, -0.10170816f, 0.18017481f, 0.22060952f, -0.46870536f, 
    0.09902970f, 0.00341312f, -0.13794352f, -0.03148939f, -0.03466557f, 0.00652857f, 0.01410045f, -0.05775680f, 
    -0.20541959f, -0.97019768f, -0.03811175f, -0.00522432f, 0.31285527f, 0.03537234f, 0.33737662f, 0.14258657f, 
    -0.08074556f, -0.12306312f, 0.07959253f, 0.30012283f, -0.01896089f, 0.12970112f, -0.44088265f, -0.14735632f, 
    0.00799413f, -0.12654537f, 0.01024932f, -0.27809221f, -0.32895219f, -0.02834256f, 0.37649459f, 0.25975657f, 
    0.22470333f, 0.24535686f, 0.15187003f, -0.11003167f, 0.01120576f, 0.16245958f, -0.17400661f, -0.21841520f, 
    -0.11739121f, 0.15821978f, -0.07166794f, 0.01076540f, -0.09278665f, -0.29303291f, -0.11177844f, 0.10125177f, 
    0.11874676f, 0.16027842f, 0.44477767f, 0.32435694f, 0.27411196f, -0.24883525f, 0.28135613f, 0.25065109f, 
    -0.23017256f, 0.03798414f, 0.01423176f, 0.13172416f, 0.30093277f, 0.18072976f, -0.17404510f, 0.56680655f, 
    -0.11573700f, 0.58541918f, 0.41422111f, 0.53313029f, 0.40886402f, 0.15954892f, 0.30133411f, 0.46849778f, 
    -0.69228745f, 0.15496092f, 0.12508970f, 0.30749902f, 0.19389839f, 0.14356926f, 0.10007266f, 0.16067339f, 
    0.17572555f, -0.05494352f, 0.26129824f, 0.09889558f, 0.00125517f, 0.20301968f, 0.11035527f, 0.16688555f, 
    -0.00751190f, 0.24947464f, 0.00862709f, 0.12741186f, -0.03320609f, -0.12912337f, 0.03256026f, -0.16256292f, 
    -0.02324849f, 0.05824101f, -0.45381859f, -0.21951903f, 0.05768055f, 0.05261264f, 0.09968530f, 0.02596578f, 
    -0.08820428f, -0.26662275f, 0.12846066f, 0.04433759f, -0.36157879f, -0.03850202f, 0.17993490f, 0.14520474f, 
    0.11276756f, -0.03433305f, 0.24038592f, 0.40180674f, -0.33252221f, -0.49563122f, -0.71605557f, -0.14518705f, 
    -0.12177217f, 0.19121543f, -0.04391414f, -0.00196570f, -0.01926482f, 0.12858485f, -0.10580303f, -0.09617630f, 
    -0.06025158f, -0.08447581f, -0.07379695f, 0.22438495f, 0.18038693f, 0.16114235f, -0.01025182f, -0.05821938f, 
    -0.36527365f, -0.07017775f, -0.30612138f, -0.26800016f, 0.03803427f, -0.11994873f, -0.07790744f, -0.37047216f, 
    -0.15377577f, -0.50663573f, -0.00022407f, 0.00057597f, 0.21531726f, -0.12383627f, 0.05216799f, -0.04163947f, 
    0.43604803f, -0.22810948f, -0.32023910f, -0.10300943f, -0.02525597f, 0.10598441f, 0.31405848f, 0.06893814f, 
    0.13943262f, -0.43922728f, -0.10200915f, -1.30080545f, 0.42516273f, -0.15248218f, 0.21166657f, -0.12928841f, 
    0.12785368f, 0.09003876f, 0.21759848f, 0.42063722f, -0.10973299f, -0.33086845f, -0.03859710f, 0.13516386f, 
    -0.10892110f, 0.11210075f, -0.19603714f, -0.39148802f, -0.04011741f, -0.30510032f, 0.13573173f, 0.03043444f, 
    -0.15297517f, 0.11417554f, 0.16904514f, -0.00163352f, 0.29157165f, -0.64287043f, 0.13192010f, 0.28270245f, 
    -0.09938303f, -0.07150979f, 0.30621570f, 0.40747046f, -0.06315902f, -0.05268013f, -0.07310922f, 0.36741987f, 
    0.25290519f, -0.39557973f, -0.01183903f, -0.01169878f, -0.08982822f, -0.02724032f, 0.24903844f, -0.02501270f, 
    -0.48463419f, -0.24466772f, -0.23540810f, -0.22068702f, 0.05688376f, 0.07085624f, 0.05202794f, -0.37934723f, 
    -0.81030679f, 0.03947950f, -0.20000671f, 0.23621398f, 0.04680837f, -0.01941781f, 0.04999986f, 0.28291577f, 
    -0.00026758f, 0.15172350f, -0.40017381f, 0.00211059f, 0.19767261f, 0.18936543f, 0.04506446f, 0.14546224f, 
    -0.16619548f, 0.44216591f, 0.01266806f, -1.35918736f, 0.01619903f, -0.36811978f, 0.15821128f, 0.01795748f, 
    0.09560657f, -0.24741222f, 0.04883023f, -0.09395391f, 0.26302996f, -0.11426543f, -0.07255165f, -0.05221355f, 
    0.04190081f, -0.02960666f, 0.28578094f, -0.10978109f, -0.91929418f, 0.08935941f, 0.07187787f, 0.00159284f, 
    -0.04502874f, -0.16842061f, 0.07702896f, 0.03201960f, 0.49183297f, 0.39583972f, 0.05801237f, 0.03236360f, 
    -0.04552684f, -0.19123384f, 0.16072577f, -0.03464710f, 0.06773646f, 0.53617454f, 0.24008301f, 0.02196749f, 
    0.02918410f, 0.06047557f, -0.13541627f, -0.02954448f, -0.28149778f, 0.10183754f, 0.37252310f, 0.34107313f, 
    -0.21464476f, 0.08855228f, -0.04787644f, 0.09269447f, 0.05952350f, -0.02133851f, -0.01682652f, 0.46861285f, 
    0.55052960f, -0.13451862f, -0.15710874f, -0.11804681f, 0.23134007f, 0.15899943f, -0.04755814f, -0.08241840f, 
    0.30839419f, -0.04588367f, -0.27126393f, 0.04389666f, 0.05113807f, 0.00630261f, -0.05273762f, -0.03517948f, 
    -0.11524175f, 0.06859094f, -0.09031236f, -0.15914264f, -0.02664752f, 0.08110300f, 0.29968953f, 0.31781948f, 
    0.20851342f, -0.01895572f, 0.29661343f, 0.10685115f, 0.02055234f, 0.01566230f, 0.06869595f, -0.13185182f, 
    -0.04957663f, -0.20269655f, -0.37604657f, 0.40681204f, 0.07369331f, 0.56065273f, -0.22789277f, 0.05914463f, 
    -0.00820511f, 0.15177093f, -0.00116650f, -0.23405863f, -0.16461670f, -0.24354027f, 0.32216045f, -0.34131962f, 
    0.10261453f, -0.21460697f, -0.13867666f, -0.01324683f, -0.36559829f, 0.17969315f, -0.10361386f, -0.02351266f, 
    -0.03810881f, -0.08084247f, 0.20299743f, -0.04012050f, -0.05756436f, -0.32559699f, 0.09486917f, -0.05514697f, 
    -0.34287748f, -0.26184183f, 0.10578244f, -0.32811269f, 0.01530303f, -0.20273204f, -0.09488261f, 0.33057982f, 
    0.19297047f, -0.00860472f, 0.24670808f, -0.01270260f, 0.00679769f, 0.03006840f, 0.05178756f, -0.09545997f, 
    0.22901978f, 0.12569948f, 0.27552345f, 0.14413618f, -0.07702607f, -0.06290314f, 0.04860321f, 0.04500607f, 
    -0.19101371f, 0.24850130f, 0.05271924f, -0.17187534f, 0.20209271f, 0.17821696f, -0.13505994f, 0.11461437f, 
    -0.12656493f, -0.20172857f, 0.45664895f, 0.34412023f, 0.34030756f, 0.21085748f, 0.05701629f, 0.13210155f, 
    0.20374604f, -0.08197483f, 0.20898962f, -0.04110616f, -0.15333244f, 0.49216342f, 0.25829864f, -0.05762528f, 
    0.01280495f, -0.04681774f, 0.09643321f, -0.07739602f, 0.41143778f, -0.09241356f, -0.06743079f, -0.04674326f, 
    -0.12563866f, -0.35483482f, -0.09800368f, -0.07482801f, 0.09478875f, -0.40236437f, -0.01172269f, 0.12095713f, 
    -0.28916916f, -0.22683869f, -0.03352234f, -0.03192093f, 0.07998656f, 0.28415290f, -0.25454813f, 0.32955304f, 
    0.00348233f, 0.18942313f, -0.37397984f, -0.36819687f, -0.00577516f, -0.13821560f, 0.05172391f, -0.48127759f, 
    -0.09384172f, 0.63426125f, 0.15503100f, -0.29320320f, -0.10026363f, 0.04281396f, 0.05553605f, -0.10879916f, 
    -0.19234893f, -0.22139145f, 0.51330292f, -0.09350082f, -0.09790316f, -0.06599331f, 0.14294267f, -0.42203933f, 
    -0.11244123f, -0.02291915f, -0.48126265f, -0.29492196f, 0.02613866f, 0.11993901f, -0.14032502f, 0.03503674f, 
    0.22167599f, 0.08919516f, 0.25646508f, -0.15443401f, -0.35187662f, -0.11364467f, -0.19102481f, -0.11531850f, 
    0.09391820f, 0.09425484f, 0.10137932f, -0.13579805f, -0.23363215f, -0.27300420f, 0.00225699f, -0.19846058f, 
    0.08201607f, -0.05804031f, 0.00134585f, 0.05220085f, 0.82030880f, -0.22772416f, -0.04560504f, 0.01327371f, 
    0.02166996f, 0.04661537f, 0.08037303f, -0.03294481f, -0.14574578f, 0.14492118f, -0.37702912f, 0.08697459f, 
    0.09751646f, -0.13309883f, 0.13098632f, 0.07468069f, -0.13572033f, 0.14140597f, 0.28066143f, 0.16537873f, 
    -0.07511707f, 0.07474565f, 0.00544613f, 0.17434907f, -0.00715340f, 0.14896952f, -0.08714888f, 0.00379224f, 
    -0.02277861f, 0.19156513f, -0.12306850f, 0.18793279f, 0.09395908f, 0.12902458f, -0.06813758f, -0.09679963f, 
    -0.22891527f, 0.27083987f, 0.24560799f, 0.00780479f, -0.15619281f, -0.03602880f, 0.07073671f, 0.10898428f, 
    0.33588478f, -0.84940583f, 0.02696588f, 0.34697592f, -0.18994355f, 0.25273627f, -0.09315629f, 0.15488575f, 
    -0.00913617f, -0.06555460f, -0.02970693f, -0.04406850f, 0.18120243f, -0.33508179f, -0.06370231f, -0.03662130f, 
    0.06548557f, -0.01694502f, 0.15531100f, -0.01736425f, 0.15349919f, 0.11787952f, -0.07313018f, 0.09541574f, 
    -0.38634032f, -0.10469059f, 0.22163267f, -0.17068599f, 0.36110055f, -0.22752456f, 0.03749524f, -0.07805300f, 
    -0.14136182f, -0.17904274f, 0.21482718f, -0.06549420f, 0.15379824f, -0.22543846f, 0.10833568f, 0.30047873f, 
    0.35223252f, -0.31603104f, -0.16919290f, 0.01020469f, 0.22111487f, -0.04217275f, -0.49348846f, 0.24806319f, 
    -0.43876475f, 0.06386470f, -0.17763847f, 0.14084592f, -0.20382902f, 0.03304637f, 0.25509217f, -0.05562976f, 
    0.28427815f, 0.34051010f, 0.13269623f, -0.09830857f, 0.07637434f, 0.08976383f, 0.16270249f, -0.02200769f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.25731766f, 0.03332307f, 0.00986405f, 0.26258385f, 0.33692652f, -0.24864224f, 0.16786185f, -0.08033920f, 
    -0.02427117f, 0.30390552f, 0.04399804f, 0.33383045f, 0.61700493f, 0.13126251f, 0.06286779f, 0.22779390f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.49800491f, -0.16619258f, -0.21648775f, -0.44623077f, 0.05732920f, 0.59734440f, 0.37666944f, 0.63070917f, 
    -0.20863366f, -0.31774750f, 0.12634930f, 0.03752316f, -0.25339344f, 0.65248293f, 0.15573488f, -0.74968928f, 
    0.15100786f, -0.16833211f, -0.11705665f, 0.04755921f, 0.33807099f, -0.27304140f, 0.49326253f, 0.25237566f, 
    -0.42902833f, 0.35009235f, 0.04922497f, -0.59116358f, 0.30429065f, 0.17908980f, 0.11497939f, -0.53582621f, 
    0.34857851f, 0.04691654f, 0.06740247f, -0.29073751f, 0.07243183f, -0.22859474f, -0.26336923f, -1.07930708f, 
    0.06016894f, -0.40332165f, -0.15115896f, 1.07044017f, -0.16182619f, -0.18151145f, -0.06975646f, -0.58104151f, 
    -0.48803443f, -0.24754593f, 0.48193103f, -0.51653975f, -0.35298628f, 0.40804675f, -0.58014911f, -0.25937682f, 
    0.12450732f, -0.91675907f, 0.05990477f, -0.11948465f, -0.24734741f, 0.39867970f, -0.04824944f, 0.73539740f, 
    -0.03208846f, 0.19176252f, 0.37139288f, -0.11195505f, 0.41786858f, -0.08801886f, 0.22421373f, 0.20650886f, 
    -0.05269648f, -0.85387176f, 0.09927378f, -0.04665892f, -0.57590902f, -0.26006863f, 0.42287442f, -0.53471589f, 
    0.38557410f, -0.05936046f, 0.02555922f, 0.03962701f, 0.43172485f, -0.12327824f, -0.00245915f, -0.26300967f, 
    -0.50476897f, 0.01907881f, 0.03896796f, -0.19562629f, -0.11458362f, 0.39538077f, 0.34571463f, 0.27112553f, 
    0.26592395f, 0.17461559f, -0.98131871f, -0.44689831f, -1.05651248f, -0.38621837f, 0.67171544f, -0.88110793f, 
    0.41012675f, -0.09024514f, -0.08813936f, 0.48604432f, 0.62900317f, -0.41086319f, -0.48847342f, -0.45832077f, 
    -0.13233553f, -0.05382993f, -0.01683614f, 0.44616064f, -0.42596558f, 0.56699431f, -0.14997949f, 0.16768360f, 
    -0.02188890f, 0.84609550f, -0.15011743f, -0.39572817f, -0.33684292f, 0.07133178f, -0.27995774f, -0.29582497f, 
    0.60731655f, 0.01136887f, 0.17275606f, 0.65411562f, -0.45309028f, -0.14493036f, -0.35306516f, -0.23293246f, 
    -0.35843986f, -0.52137828f, 0.21945013f, -0.69312328f, 0.01636338f, -0.41866285f, -0.47886777f, 0.70588851f, 
    -0.51100957f, -0.14213361f, -0.34431547f, -0.44894814f, -0.33896568f, -0.27841723f, -0.24134272f, 0.50977111f, 
    0.28829613f, 0.30683845f, -0.05116754f, 0.49988702f, 0.40405697f, -0.46300170f, 0.17797180f, 0.53797913f, 
    -0.39885324f, 0.21224312f, 0.65462852f, -0.54542279f, 0.55129224f, 0.46168527f, -0.54478717f, -0.63774985f, 
    -0.40521556f, 0.53427380f, -0.14516914f, -0.54679602f, 0.30696157f, -0.85459429f, -0.63235801f, 0.30015680f, 
    -0.03138437f, 0.08467217f, 0.22573870f, 0.54890251f, -0.67734689f, -0.78427148f, 0.49843600f, -0.41617408f, 
    0.47534499f, -0.77365685f, -0.07972784f, -0.55895346f, -0.23024572f, -0.25926295f, -0.39115238f, 0.24206990f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.72655070f, 0.52395797f, 0.69557440f, 0.23975703f, -0.12777953f, -0.30854860f, 0.08174425f, -0.64387548f, 
    0.15190358f, -0.22860603f, 0.08144730f, 0.29328474f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
