#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.86798310f, 0.45808837f, 0.39595836f, -0.42648610f, 0.32132646f, -0.22728275f, -0.09888668f, 0.07540949f, 
    0.25441074f, -0.14667615f, 0.11811177f, 0.21863206f, 0.47811919f, -0.40759116f, 0.49244142f, 0.57239157f, 
    0.17884381f, 0.34662044f, 0.14140977f, 0.36353219f, 0.43441311f, -0.45227498f, 0.06729397f, -0.93119287f, 
    -0.06395920f, 0.39765981f, 0.03597675f, 0.44256663f, -0.70338267f, -0.20655115f, -0.65767473f, -0.40072727f, 
    -0.01939206f, 0.02414583f, 0.23064378f, 0.30393428f, 0.34354505f, 0.52438176f, 0.17776453f, 0.58475065f, 
    0.68856186f, -0.39279139f, -0.22829318f, -0.31751007f, -0.13018708f, 0.77734470f, 0.54575163f, 0.45600688f, 
    0.39720294f, 0.37965155f, 0.55244195f, -0.07011775f, 0.03096477f, 0.16563025f, 0.03170329f, 0.22837564f, 
    -0.76931852f, -0.09066946f, -0.82590580f, -0.50011945f, -0.22743204f, -0.08291523f, 0.29132563f, -0.51955760f, 
    -0.30608425f, -0.60556471f, -0.05052124f, 0.87604135f, 0.70272809f, -0.26171148f, -0.34174973f, -0.23332325f, 
    0.52739668f, -0.32298899f, -0.34686515f, 0.81185293f, -0.02206854f, -0.37340868f, -0.08101084f, -0.08777826f, 
    0.00987671f, 0.59635592f, -0.49512526f, -0.77539140f, -0.17991970f, 0.44089705f, -0.19221085f, 0.04949811f, 
    -0.11948109f, 0.18458635f, -0.47587442f, -0.08698902f, -0.19476461f, -0.58169103f, 0.63168371f, -0.17911607f, 
    0.46432289f, 0.22161788f, -0.23923440f, -0.53908426f, 0.32582572f, 0.84331429f, 0.02741804f, 0.23937763f, 
    0.28679970f, 0.32353163f, 0.04169510f, 0.38934377f, 0.31978059f, 0.80837542f, 0.30945468f, -0.37291095f, 
    -0.64323896f, 0.27564821f, 0.35084522f, -0.00161670f, -0.15075403f, -0.78706688f, -0.81122887f, -0.81418884f, 
    0.04641722f, 0.06858101f, 0.08969611f, 0.29700261f, 0.03223053f, 0.05720196f, -0.74220574f, 0.05244800f, 
    0.15930000f, 0.59042698f, -0.32267669f, -0.25855720f, -0.01989472f, 0.15531608f, -0.41224754f, -0.63080794f, 
    0.73306918f, 0.57619888f, 0.17194691f, -0.36828098f, -0.42594987f, -0.14671601f, 0.02671674f, 0.05186274f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18739972f, -0.28426403f, -0.22770384f, -0.01292258f, 0.22101979f, -0.01005456f, 0.22580163f, -0.11829213f, 
    -0.07303213f, 0.06936997f, -0.29539055f, -0.45557868f, 0.26328501f, 0.04076686f, -0.19064702f, 0.13012598f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02940999f, -0.01027585f, 0.02027101f, -0.04236034f, 0.06223415f, -0.03974249f, -0.07168258f, 0.04768407f, 
    -0.00120297f, 0.04356015f, -0.02658654f, 0.05833218f, -0.03338388f, 0.04458764f, -0.08683056f, -0.03624261f, 
    0.01674508f, -0.03347431f, -0.00403745f, 0.06702854f, -0.04386257f, 0.04467057f, 0.06839589f, -0.05401738f, 
    -0.06573936f, -0.00797358f, -0.07227969f, 0.01106909f, 0.06527649f, 0.03452917f, 0.02360987f, -0.09001074f, 
    0.05313808f, -0.05908352f, 0.02352997f, 0.05664496f, 0.00996736f, -0.01879881f, -0.06957095f, -0.06029534f, 
    -0.08111763f, -0.02147404f, -0.08060890f, 0.04550708f, 0.02080400f, -0.02355793f, -0.01909272f, -0.00859569f, 
    0.00660791f, -0.05804595f, -0.06515794f, -0.07063628f, 0.07256541f, 0.02684390f, -0.05369832f, -0.07914177f, 
    -0.09236224f, -0.00203796f, 0.01061776f, -0.05713234f, 0.00386753f, 0.06319647f, -0.03176961f, 0.01441612f, 
    0.04915201f, -0.02872417f, -0.01780587f, 0.04012482f, 0.01231541f, 0.03312066f, -0.06647300f, 0.03493271f, 
    -0.06336999f, -0.04776431f, 0.06921992f, -0.01861432f, 0.00979783f, 0.01836808f, -0.00233497f, 0.06578902f, 
    -0.04562980f, -0.02517838f, -0.06825353f, -0.00531783f, -0.00563966f, -0.07224168f, 0.04252692f, -0.04223596f, 
    -0.07324260f, 0.02262236f, -0.07137267f, 0.03633533f, 0.02643982f, 0.03431444f, 0.01228440f, -0.00486330f, 
    -0.01077742f, 0.02768180f, -0.08281396f, 0.05236235f, -0.05336088f, -0.05924257f, 0.03384621f, 0.02991423f, 
    -0.04969024f, -0.06422006f, -0.04561550f, -0.05543894f, -0.03937882f, -0.04053526f, -0.01307578f, -0.02948171f, 
    -0.08068407f, 0.02358282f, -0.08132815f, 0.07305837f, 0.06498702f, 0.00533183f, -0.00608539f, 0.02693892f, 
    -0.05772963f, 0.06648472f, -0.04413471f, -0.02888428f, 0.00520776f, 0.06117631f, 0.03754120f, 0.05431359f, 
    -0.00088919f, 0.03463266f, 0.02822292f, -0.09457029f, -0.00822674f, 0.07309141f, -0.02125316f, -0.07122467f, 
    -0.05268000f, -0.08588160f, -0.03341414f, -0.06992256f, -0.00869677f, 0.01083250f, 0.03511531f, 0.04851007f, 
    -0.31981826f, -0.10925467f, -0.07188339f, -0.19696979f, -0.13456520f, -0.13965076f, -0.12744968f, -0.09691310f, 
    -0.03427264f, 0.01405780f, 0.10661305f, -0.16554172f, 0.26568767f, -0.07760108f, 0.04354045f, 0.01551353f, 
    -0.10884687f, 0.04450359f, -0.02417762f, -0.16086036f, -0.15404058f, 0.03378946f, 0.11003178f, -0.00933747f, 
    0.05261927f, -0.02448272f, -0.21134791f, 0.32906651f, 0.20283929f, 0.07617605f, -0.32308269f, -0.00905688f, 
    -0.15799624f, -0.18337637f, -0.06770914f, -0.09578372f, -0.01762241f, 0.22224791f, -0.01122676f, -0.17670770f, 
    -0.27654827f, -0.02967333f, 0.04471542f, 0.04952362f, 0.01836487f, -0.22565475f, 0.19724852f, 0.22833364f, 
    -0.03594228f, -0.04949868f, -0.01160278f, 0.05336369f, 0.10034756f, -0.14256255f, 0.10745949f, 0.05394835f, 
    -0.07474699f, -0.02018057f, 0.00679020f, -0.20137155f, 0.02919207f, -0.00186889f, 0.02993455f, 0.27344581f, 
    -0.09536662f, 0.14715581f, 0.20287938f, 0.09662428f, -0.04717730f, -0.00833159f, 0.05464282f, 0.16243996f, 
    0.16426335f, 0.20373017f, 0.00941957f, -0.06889921f, 0.00404491f, -0.06463065f, -0.11109784f, -0.03435978f, 
    0.12609740f, 0.01515433f, -0.01759189f, 0.30446833f, -0.10177360f, 0.05335559f, -0.00831545f, -0.21118607f, 
    0.34556675f, -0.12467810f, 0.06457551f, 0.21052226f, 0.30928397f, 0.06146456f, -0.12227702f, 0.19332194f, 
    -0.02962627f, -0.06413784f, -0.03733684f, 0.04005541f, -0.49794906f, 0.15840262f, -0.12519240f, -0.07610097f, 
    -0.00037361f, 0.07402612f, 0.00753127f, -0.07013028f, -0.53052437f, -0.03890643f, -0.04225797f, 0.04336540f, 
    -0.05483572f, -0.30212632f, 0.12248869f, -0.04316368f, 0.05035883f, -0.04848228f, -0.04380260f, 0.55474913f, 
    0.12114003f, -0.07319794f, 0.15701455f, 0.11388886f, 0.14700992f, 0.15967277f, 0.12702227f, 0.08428158f, 
    -0.06369425f, 0.22437587f, -0.14255726f, 0.27719527f, 0.05689444f, -0.14164948f, -0.03667427f, 0.40237471f, 
    -0.09719804f, -0.36823592f, 0.02269289f, -0.19732149f, -0.15554293f, -0.01341233f, 0.21908987f, 0.04554352f, 
    0.04767855f, -0.07785202f, -0.01389308f, 0.04254175f, 0.02326668f, 0.04726847f, 0.04331062f, -0.02045408f, 
    -0.05114026f, -0.01856554f, 0.01157726f, 0.03433301f, -0.07729642f, -0.03630864f, 0.03365878f, 0.01869589f, 
    -0.03196867f, -0.08628934f, 0.00559470f, -0.05065776f, 0.06033148f, -0.00255909f, 0.04802909f, -0.03386932f, 
    -0.06159386f, -0.00024951f, -0.02415687f, 0.10698708f, -0.03493463f, -0.07466126f, 0.05583020f, -0.02426760f, 
    -0.05050069f, 0.04095277f, 0.01511218f, -0.00856332f, -0.06504380f, -0.09826794f, -0.02737402f, -0.02378958f, 
    0.07417648f, -0.01382231f, -0.03334379f, 0.06794792f, -0.09881236f, 0.03878645f, 0.00348133f, -0.03445393f, 
    -0.01356085f, 0.06197052f, -0.03126077f, -0.01633123f, -0.07033139f, -0.05355786f, -0.03864529f, -0.08028345f, 
    0.03306242f, 0.05602382f, -0.00075667f, -0.09223967f, 0.03468804f, -0.03214670f, -0.03289059f, 0.01611501f, 
    0.05937373f, 0.06531835f, 0.01141396f, -0.01040107f, 0.06677020f, 0.01840659f, 0.04979357f, -0.02698406f, 
    -0.06287957f, -0.06607493f, 0.01796767f, 0.02395908f, -0.08437166f, -0.07237612f, -0.05213907f, -0.03788869f, 
    -0.02536826f, -0.03857432f, 0.04942261f, -0.03423786f, -0.06952230f, -0.01086291f, 0.01646099f, -0.02423420f, 
    -0.00163284f, 0.03231937f, 0.01742570f, -0.00001399f, -0.08521809f, -0.07658304f, 0.08603724f, 0.05897023f, 
    -0.00425436f, -0.07233357f, -0.09739055f, -0.04761529f, 0.01346698f, 0.01352272f, -0.09315373f, 0.00053508f, 
    -0.06247198f, -0.04389910f, 0.04476505f, 0.01939175f, -0.04733418f, -0.04510294f, -0.02643956f, -0.01340900f, 
    -0.03410621f, 0.01829460f, 0.00948922f, 0.00217099f, -0.01328208f, 0.02906342f, 0.00961256f, -0.07055249f, 
    0.00853127f, 0.05388986f, -0.06109418f, -0.04178539f, -0.07411593f, -0.03288142f, -0.03850731f, -0.05232161f, 
    -0.02628474f, -0.08785462f, 0.01311714f, 0.02540960f, 0.04868882f, -0.02434154f, 0.06262587f, -0.01515637f, 
    -0.02495189f, 0.01456703f, 0.04640422f, -0.00913905f, -0.07262654f, -0.03315883f, 0.03707738f, -0.04548903f, 
    -0.03884789f, 0.00734232f, 0.04857569f, -0.09017051f, -0.00200712f, -0.02284415f, 0.03839218f, 0.02454012f, 
    -0.05305256f, -0.06076277f, 0.05523018f, -0.06739090f, 0.02183644f, -0.03486720f, 0.07161376f, -0.05268203f, 
    0.00396247f, -0.03319120f, -0.07979598f, -0.06638280f, 0.02702763f, -0.06633958f, 0.03017972f, -0.00229011f, 
    -0.05827402f, 0.00350536f, 0.05279113f, -0.06470127f, -0.01058020f, -0.08178062f, 0.00838540f, -0.03242208f, 
    0.04633811f, 0.02814770f, 0.00742644f, -0.08553997f, 0.05764205f, -0.04049212f, -0.01224391f, -0.08169299f, 
    -0.01525056f, -0.00580428f, 0.01628470f, 0.04120488f, -0.06003567f, 0.06949467f, -0.06484070f, 0.00553475f, 
    0.03982569f, 0.01419841f, -0.00720879f, -0.07630301f, -0.02828582f, -0.08791755f, -0.04196192f, 0.05828967f, 
    0.00605643f, 0.00350215f, -0.06112036f, 0.03739073f, 0.05616214f, -0.07391056f, -0.00748159f, -0.00075707f, 
    -0.04699219f, 0.03956595f, 0.02257200f, -0.00470844f, -0.00981969f, -0.06989627f, -0.01087782f, 0.05930416f, 
    0.03855358f, -0.00012931f, -0.07294383f, -0.04673220f, -0.05753511f, 0.01126221f, 0.01274192f, -0.06800754f, 
    -0.00052681f, 0.01594120f, 0.04273035f, -0.03695772f, 0.05508458f, -0.01762143f, 0.02490789f, 0.04875425f, 
    -0.05683319f, 0.03391232f, 0.07597917f, -0.02484586f, -0.08555720f, -0.01604692f, -0.09186002f, 0.00452501f, 
    -0.03733138f, -0.04410080f, -0.06544346f, -0.02052244f, 0.04203546f, -0.05522183f, -0.04432154f, -0.08159015f, 
    -0.05025042f, 0.06169722f, -0.05621189f, -0.03399791f, -0.02420386f, -0.05562274f, -0.05512063f, 0.00008463f, 
    0.07608522f, -0.08309808f, 0.00888991f, -0.03403797f, 0.00712113f, -0.05317151f, 0.03166639f, -0.04049864f, 
    -0.03145863f, 0.04073694f, -0.06327841f, 0.06849488f, -0.06193405f, -0.03534565f, 0.02702303f, 0.06798510f, 
    -0.03980809f, -0.03463282f, 0.06391028f, -0.06949614f, 0.04155444f, -0.00157914f, 0.00427543f, 0.04081979f, 
    0.05599561f, -0.06377801f, -0.06195908f, -0.02462946f, 0.07325320f, 0.00971525f, -0.07887099f, 0.01172373f, 
    0.19513376f, 0.07075665f, 0.16120425f, 0.05089969f, 0.01723555f, 0.02178445f, -0.10862133f, -0.05329417f, 
    -0.16801336f, -0.30842009f, 0.01389315f, -0.26841128f, -0.03385171f, -0.11697719f, 0.08028126f, -0.01326478f, 
    0.03513853f, -0.38689446f, -0.00020397f, 0.28032872f, 0.02781054f, -0.07942684f, 0.26071420f, -0.02589319f, 
    -0.15442790f, 0.13163170f, 0.15149525f, -0.12402564f, -0.23795021f, -0.06931286f, 0.00564782f, 0.18131328f, 
    -0.04017287f, -0.13330407f, 0.11855219f, 0.02013626f, 0.11778095f, 0.23073635f, 0.12219374f, -0.32987955f, 
    -0.07051997f, -0.02271712f, 0.20130812f, 0.11090020f, 0.14203613f, -0.02580503f, 0.04793030f, 0.07939348f, 
    -0.04080185f, 0.04532621f, -0.00038012f, 0.14265597f, 0.08077087f, -0.07269327f, -0.13075775f, 0.08085509f, 
    0.01732902f, 0.07792373f, 0.06971303f, -0.00172479f, 0.07310852f, 0.08504894f, 0.28445956f, 0.21845765f, 
    0.15736289f, -0.45180780f, 0.05792253f, -0.12404539f, 0.01407756f, -0.06227643f, -0.01960581f, 0.01242039f, 
    0.04153951f, -0.25539881f, -0.06352149f, 0.03894122f, -0.17339960f, 0.11198871f, 0.09580334f, 0.22807391f, 
    0.02682787f, -0.35770613f, -0.14273898f, -0.07042662f, -0.08744788f, 0.03800207f, -0.09879851f, -0.27732307f, 
    0.03174783f, -0.13785602f, -0.08149936f, -0.41548026f, 0.02383134f, -0.00701718f, -0.09368345f, 0.08794198f, 
    -0.26884204f, -0.14298251f, -0.02025615f, 0.03710306f, -0.41964534f, -0.02543418f, -0.08672940f, -0.15959468f, 
    -0.13070883f, -0.09471568f, -0.10619903f, -0.15538912f, 0.15408894f, 0.13377704f, 0.23640700f, -0.22158463f, 
    -0.07598934f, 0.22478090f, 0.06196520f, 0.17409861f, 0.02250963f, -0.39067337f, 0.11433448f, -0.22601852f, 
    -0.07730093f, 0.17715564f, 0.14398880f, 0.30390581f, 0.07764796f, -0.10316010f, -0.41696173f, -0.22077550f, 
    0.02456514f, 0.00678764f, 0.08371709f, -0.17017752f, 0.36337179f, -0.06280790f, 0.10217451f, 0.00936449f, 
    -0.07046723f, 0.18748209f, -0.04567244f, -0.05201596f, -0.00263207f, -0.11330666f, 0.09183725f, 0.18102358f, 
    -0.01310101f, 0.05413336f, 0.04527499f, -0.00205606f, 0.00273241f, 0.03524287f, -0.00691058f, 0.03427394f, 
    -0.08639417f, 0.06808703f, -0.04873502f, 0.01220204f, -0.02401506f, 0.00749369f, 0.06087060f, 0.00114476f, 
    0.06677451f, -0.07078911f, -0.06099077f, -0.09928711f, -0.04602780f, -0.02145195f, 0.02696293f, -0.04121080f, 
    0.03600102f, -0.01418280f, -0.01953686f, -0.09016257f, -0.04924817f, -0.07694017f, -0.00581924f, -0.04669620f, 
    -0.06638505f, -0.02303195f, -0.04397911f, -0.00227327f, 0.06382450f, -0.03600352f, -0.01569825f, 0.01551264f, 
    0.03971631f, -0.07655033f, -0.08828533f, 0.01788228f, -0.02524212f, -0.04113771f, -0.00245259f, 0.01644815f, 
    -0.04595161f, -0.08391424f, -0.02288914f, 0.05883811f, 0.01455466f, 0.03645968f, -0.00869942f, -0.03492565f, 
    -0.00777470f, -0.08120168f, -0.08889550f, -0.06649514f, 0.03277573f, -0.02168592f, 0.06413170f, 0.00905777f, 
    -0.00402483f, -0.07021544f, -0.03626161f, -0.06963699f, -0.02672555f, -0.08115765f, 0.03953811f, -0.07755991f, 
    -0.05506159f, 0.05906687f, -0.01840846f, -0.03326131f, 0.06869703f, 0.01749486f, 0.07194667f, 0.03960387f, 
    0.02598861f, -0.06717113f, 0.02948722f, 0.06530538f, -0.00590935f, -0.07095330f, -0.06182924f, 0.03648192f, 
    0.02495086f, 0.02702503f, -0.00227679f, 0.01134539f, -0.02253785f, 0.06846151f, 0.05969251f, -0.01659461f, 
    0.02643601f, -0.09042418f, -0.00340230f, -0.08262525f, -0.06980965f, 0.03899428f, -0.06619655f, -0.01089442f, 
    -0.01124099f, 0.03210444f, -0.07914814f, -0.01354341f, -0.00923650f, -0.08762752f, 0.03354163f, 0.05561469f, 
    -0.04291485f, -0.09172419f, -0.00565678f, -0.01119193f, -0.00443556f, -0.02175399f, -0.03769600f, 0.07802059f, 
    0.00126218f, -0.09646053f, -0.00358067f, -0.05961439f, 0.04160753f, 0.03116118f, 0.04419985f, -0.06726656f, 
    0.00247015f, -0.05878607f, -0.06135062f, -0.03867834f, 0.04310232f, -0.06300174f, -0.07993879f, -0.06925607f, 
    0.03623142f, -0.06861113f, -0.08605117f, 0.00145613f, 0.05380912f, -0.03696792f, -0.10114636f, -0.08775127f, 
    0.23266397f, 0.12168283f, -0.10740197f, -0.04491093f, -0.01817971f, -0.00975361f, 0.05961998f, -0.00663773f, 
    -0.01870732f, -0.04000077f, -0.14900368f, -0.14354566f, -0.01443678f, 0.06848720f, -0.21341869f, -0.24490941f, 
    0.05977547f, -0.24111444f, 0.32406154f, 0.04615920f, -0.02366328f, -0.05857361f, -0.06471868f, -0.22214313f, 
    -0.04209951f, 0.00684978f, -0.00847095f, -0.13879763f, -0.16458799f, -0.14615700f, -0.05043009f, 0.12612373f, 
    -0.17493211f, 0.11605970f, 0.18753552f, -0.05032806f, -0.02534227f, -0.12286398f, -0.04175884f, 0.27942798f, 
    0.04788241f, 0.24995859f, 0.01901873f, 0.15002069f, -0.01547048f, -0.28662953f, -0.30330002f, -0.31781664f, 
    0.17220600f, 0.29317737f, 0.13300142f, -0.02241117f, -0.14014354f, -0.25038308f, 0.27064562f, 0.11157282f, 
    0.00394092f, 0.02590233f, 0.20705475f, 0.03463181f, -0.04694399f, 0.20732029f, 0.04992811f, -0.43721944f, 
    0.09527138f, 0.20469944f, -0.11519321f, 0.14950323f, 0.19759184f, -0.20174232f, 0.07253458f, 0.13820961f, 
    0.15735184f, -0.16457634f, 0.16493990f, -0.06059007f, -0.24706580f, 0.15961768f, -0.32681784f, 0.18819247f, 
    -0.09835739f, -0.08970802f, 0.21348172f, 0.22230303f, -0.14982136f, 0.07998254f, -0.12061386f, 0.05931823f, 
    0.14625300f, 0.05789699f, 0.08210394f, 0.10228088f, 0.06746959f, -0.17999269f, -0.17532177f, 0.10644867f, 
    -0.21001771f, 0.21847929f, -0.08787809f, -0.04623395f, 0.09679334f, 0.05621326f, -0.01180133f, -0.05555215f, 
    0.16672868f, 0.04962594f, -0.07385833f, -0.32747790f, 0.13319187f, -0.11428737f, -0.08564325f, 0.23564275f, 
    0.16679648f, -0.03515038f, 0.13858233f, 0.07488767f, -0.27636251f, 0.09499942f, -0.04819039f, 0.09199149f, 
    0.15345275f, -0.01177143f, 0.08419350f, -0.08622207f, -0.00558368f, 0.03783742f, 0.08938422f, -0.32144779f, 
    0.01636344f, -0.14372702f, -0.08773337f, 0.17270213f, -0.09026950f, 0.04091276f, -0.01289745f, 0.26206720f, 
    0.22024843f, -0.11771099f, 0.01585315f, 0.02477395f, 0.19349216f, 0.04478826f, -0.23008612f, -0.17656666f, 
    0.32464930f, -0.10664415f, -0.00582961f, -0.04989484f, -0.18293005f, 0.07256877f, -0.06026856f, -0.01837992f, 
    0.02286871f, -0.19072311f, 0.14628781f, -0.00196159f, 0.00465406f, 0.01957629f, 0.00033942f, 0.14999513f, 
    -0.21482456f, 0.06465296f, -0.22254299f, -0.14709733f, -0.23801807f, -0.05946446f, 0.04205175f, 0.01945616f, 
    -0.16650002f, -0.07176067f, 0.32006809f, -0.70022619f, -0.08467069f, 0.17534278f, -0.02871831f, 0.08684491f, 
    0.02645938f, 0.04184578f, 0.03291097f, 0.17217731f, 0.14485849f, -0.02003893f, 0.06586225f, -0.00834033f, 
    -0.02098855f, -0.00812071f, -0.09796019f, 0.18506217f, -0.10680430f, -0.20987041f, 0.28217155f, 0.01498441f, 
    0.10217205f, 0.04403719f, -0.00858749f, 0.09611757f, -0.02694402f, 0.17498168f, -0.06974041f, -0.35576212f, 
    -0.02408982f, -0.12425040f, 0.19575173f, 0.16916126f, -0.01863556f, 0.01246968f, -0.14965245f, 0.26035127f, 
    0.24350037f, 0.01625177f, 0.14898181f, 0.05270430f, -0.13092016f, 0.09094744f, -0.04444239f, 0.02558609f, 
    -0.25838789f, -0.19041283f, -0.22978403f, 0.08662348f, 0.00276832f, -0.13513111f, -0.01700779f, -0.00251576f, 
    0.03730791f, -0.15708688f, -0.69747430f, 0.02501433f, 0.00897423f, -0.04162946f, 0.28320488f, 0.03842682f, 
    -0.07702855f, -0.01596644f, 0.24768764f, -0.05457297f, -0.06113213f, 0.15262640f, -0.04585697f, 0.05574863f, 
    0.15630780f, -0.13174114f, -0.25260413f, -0.36814126f, 0.36364585f, -0.01751827f, -0.09962486f, -0.00662764f, 
    -0.30454862f, -0.05208163f, 0.06517926f, -0.02281862f, -0.12263620f, 0.06731423f, -0.05274393f, 0.03841481f, 
    -0.17210867f, 0.08478547f, -0.08492137f, 0.05529259f, -0.01637760f, 0.42633620f, 0.35522228f, 0.11987678f, 
    0.01839135f, -0.01372158f, -0.10504266f, 0.05981218f, 0.06965460f, 0.08342780f, 0.10614137f, 0.04818572f, 
    -0.21067569f, -0.04610572f, 0.10582095f, -0.05443415f, -0.02824388f, 0.02149154f, -0.04917177f, -0.17752603f, 
    0.00242336f, 0.13002692f, 0.00177476f, 0.05275087f, 0.05983154f, -0.04254924f, -0.02119935f, 0.19226715f, 
    -0.01732081f, -0.07493925f, 0.02549715f, -0.04656233f, 0.01204517f, -0.02626750f, -0.04660226f, 0.01617760f, 
    -0.06001786f, -0.05365723f, 0.04701382f, -0.02995018f, 0.05065424f, -0.05494432f, 0.01942456f, -0.06441864f, 
    0.06131047f, -0.06066266f, -0.08974764f, -0.07868421f, 0.03996843f, 0.05933940f, -0.05437765f, -0.03477611f, 
    0.00665912f, -0.04175046f, 0.04167674f, 0.04504078f, -0.08555650f, -0.06973460f, 0.03159490f, 0.06787212f, 
    -0.07337202f, 0.03804278f, -0.08859725f, -0.01033126f, 0.05511454f, 0.02299428f, -0.06379499f, 0.01380607f, 
    -0.06040085f, -0.02975564f, -0.09458591f, 0.02529334f, 0.01060634f, -0.00149919f, 0.04925169f, -0.00006681f, 
    0.03684963f, -0.01167843f, 0.03755284f, -0.02199572f, -0.02069122f, 0.03604361f, -0.00637663f, -0.07575624f, 
    0.05268437f, 0.01543013f, 0.01532483f, -0.03675088f, 0.06441028f, -0.07425915f, -0.08345442f, -0.00615052f, 
    0.05465735f, -0.06065659f, -0.00524263f, 0.04310977f, -0.04641118f, -0.01773827f, -0.07763437f, -0.02978649f, 
    0.01746447f, 0.06432890f, -0.05390575f, 0.00368359f, 0.02590244f, -0.05268789f, 0.00007901f, 0.05372232f, 
    -0.08372358f, 0.00251681f, 0.06242277f, 0.06210590f, 0.06143617f, -0.05146228f, 0.06650872f, 0.03791266f, 
    -0.06480005f, -0.04356193f, -0.08129576f, -0.02935569f, 0.00291788f, -0.04712250f, -0.03077160f, 0.03173573f, 
    -0.00088046f, -0.03888758f, 0.02996129f, -0.03529325f, -0.01899293f, 0.00787340f, 0.02176910f, -0.05039643f, 
    0.06161321f, -0.03321562f, -0.08280918f, 0.04015443f, -0.04827715f, -0.07735502f, 0.01200506f, 0.04953803f, 
    0.04618588f, -0.06525195f, 0.05576892f, 0.06674033f, 0.06769731f, 0.03408113f, 0.04218345f, -0.08179663f, 
    0.01079284f, -0.05009082f, -0.04781846f, 0.04736332f, 0.04714502f, 0.00618239f, -0.06160735f, -0.07315951f, 
    -0.06224604f, -0.07351352f, 0.02456334f, 0.02823284f, -0.00680279f, -0.09947397f, -0.09426706f, 0.05216258f, 
    -0.03339213f, 0.01218525f, -0.07990051f, -0.04027687f, 0.01990202f, -0.00668774f, -0.02014984f, -0.04592287f, 
    0.28795755f, 0.36083400f, -0.01366088f, 0.00872037f, -0.04580681f, 0.09457600f, 0.03061933f, -0.01087491f, 
    -0.27242380f, -0.15969430f, 0.27144793f, -0.13067938f, 0.04170887f, 0.00051291f, 0.04106591f, 0.08192752f, 
    0.02126667f, -0.01832804f, 0.08878313f, 0.15087357f, -0.13810112f, 0.13448699f, 0.12730648f, -0.06982918f, 
    0.07268238f, -0.07528678f, 0.01005377f, 0.38431221f, 0.06108139f, -0.05410831f, 0.01742562f, 0.17984575f, 
    -0.04932998f, 0.08600838f, 0.00507613f, -0.02030171f, 0.28716424f, -0.27077284f, 0.14211437f, 0.01785112f, 
    -0.02642586f, -0.00227088f, -0.03221452f, 0.09802858f, 0.07733721f, -0.22034486f, 0.10079011f, 0.10316871f, 
    0.08900344f, -0.07266760f, 0.03956636f, -0.23980990f, 0.00381698f, 0.00227751f, -0.48230734f, -0.03173530f, 
    -0.04273825f, 0.02943034f, 0.06889594f, 0.06401910f, -0.14323373f, 0.07097610f, 0.03932674f, 0.33769178f, 
    -0.03610707f, -0.15697455f, -0.08684610f, -0.22484328f, -0.03062273f, 0.00273038f, -0.02771261f, 0.11186216f, 
    -0.43380144f, -0.79422539f, -0.05930383f, 0.00480363f, 0.02326746f, -0.05586624f, -0.06405917f, -0.01827469f, 
    -0.04829523f, 0.13371402f, -0.32368952f, -0.14090364f, -0.19410989f, 0.07558443f, 0.10421254f, -0.03610525f, 
    -0.00786364f, 0.07591029f, 0.20117894f, -0.05633439f, -0.19796273f, -0.00756683f, 0.16577241f, 0.03374089f, 
    -0.33123028f, -0.02023065f, 0.19220014f, 0.34144962f, 0.14735034f, -0.14531071f, -0.16814479f, 0.25779617f, 
    0.04474196f, -0.11040282f, -0.03898266f, -0.09018189f, -0.25959665f, 0.07312282f, -0.13535097f, 0.23309302f, 
    0.14041801f, 0.03800958f, -0.08638454f, 0.15178795f, 0.02469234f, 0.07921392f, -0.11476585f, 0.24324206f, 
    -0.18431486f, -0.00560734f, -0.13711047f, 0.00830236f, 0.07858229f, -0.10002682f, 0.23175186f, -0.10954975f, 
    -0.15112865f, -0.14438601f, -0.07442285f, 0.00506753f, 0.04614509f, 0.07176243f, -0.12143847f, 0.41567677f, 
    0.23575801f, -0.04130741f, -0.12046621f, 0.08127274f, -0.12422062f, 0.06816785f, -0.03783936f, 0.07062731f, 
    0.09111346f, 0.46464097f, 0.38542217f, -0.10149875f, 0.06692417f, 0.03205721f, 0.02182484f, -0.06675655f, 
    -0.08963359f, -0.03118730f, -0.52756542f, -0.14698499f, 0.03660750f, -0.21290791f, 0.27172330f, -0.08110600f, 
    -0.00476275f, -0.16471054f, 0.34442952f, -0.07183288f, -0.18901719f, 0.00109161f, 0.06781507f, 0.14294085f, 
    -0.17077352f, 0.04473865f, 0.01979417f, 0.00048371f, 0.01084004f, -0.42142284f, -0.10212178f, -0.27588338f, 
    0.01633451f, 0.05697858f, -0.00368555f, -0.01369178f, -0.16773781f, -0.13413922f, 0.01632833f, 0.17679179f, 
    0.03254287f, 0.13160074f, 0.09360027f, 0.09962087f, 0.03278578f, -0.48139009f, 0.32287830f, 0.27284402f, 
    0.09695680f, 0.31461051f, 0.23512664f, 0.03947284f, -0.18082160f, 0.04855149f, 0.06302392f, 0.01459951f, 
    0.12696244f, 0.10067225f, 0.10463583f, -0.01239455f, 0.09708405f, -0.05017530f, 0.06880998f, -0.19047949f, 
    -0.34698385f, -0.01804897f, 0.13458635f, 0.17411843f, 0.11691038f, -0.17460573f, -0.01909094f, -0.12016074f, 
    -0.17759950f, -0.08215521f, -0.10510981f, 0.10205612f, 0.07586548f, -0.17264815f, 0.04604180f, -0.11303144f, 
    0.11583053f, -0.13569550f, -0.28954914f, 0.13505024f, -0.02898291f, -0.00263498f, -0.01039690f, -0.10346282f, 
    0.08223392f, -0.00781781f, -0.24022192f, -0.01413904f, 0.00082200f, 0.04380057f, 0.20606345f, -0.05919306f, 
    0.15806639f, -0.12283494f, 0.00472206f, 0.26334363f, -0.33301160f, -0.08003031f, -0.00050544f, -0.09387897f, 
    -0.08747169f, 0.13906847f, -0.12958714f, -0.05132722f, -0.09292647f, 0.04140757f, 0.21697381f, -0.09407347f, 
    -0.02186508f, -0.00445842f, 0.03301203f, 0.05619016f, 0.00963179f, -0.49729902f, 0.17331181f, -0.11628186f, 
    0.15028110f, 0.02914501f, -0.00955444f, 0.08705869f, -0.10902177f, 0.10262987f, -0.03591963f, -0.09414684f, 
    -0.22677100f, 0.04190313f, -0.00823234f, 0.18202066f, -0.05345886f, 0.06903389f, -0.31337646f, 0.21016771f, 
    0.03516654f, 0.09020822f, 0.04937986f, -0.10608514f, 0.16217718f, 0.00190244f, 0.09025080f, 0.23607421f, 
    -0.01089567f, 0.02093670f, -0.06787062f, 0.06412896f, 0.06371704f, -0.01390345f, 0.02453170f, -0.13864025f, 
    -0.08145981f, 0.16160516f, 0.25051239f, -0.06507581f, 0.02481778f, -0.02591095f, 0.03165051f, -0.21071239f, 
    -0.13574231f, 0.18048954f, 0.01107316f, -0.03270450f, -0.53605241f, 0.12975450f, -0.02903430f, 0.12452440f, 
    0.06632574f, 0.08550190f, 0.02533425f, 0.17291147f, 0.25517434f, 0.07492851f, 0.10179565f, -0.04818378f, 
    0.08354113f, -0.02676130f, -0.13815983f, 0.02160522f, 0.31774673f, -0.10974261f, -0.16193448f, 0.08525018f, 
    -0.06359247f, 0.01409562f, -0.15819475f, 0.03534824f, 0.22846061f, -0.03482527f, 0.27528647f, 0.10481031f, 
    0.16484201f, 0.02504693f, -0.09208520f, 0.21232164f, -0.08815514f, -0.00840312f, -0.30987871f, -0.02846646f, 
    -0.39015937f, 0.12454800f, 0.06481614f, -0.10933755f, 0.09001684f, -0.05490078f, 0.11630241f, 0.02399190f, 
    0.00888323f, 0.38172346f, -0.19405775f, -0.07826859f, 0.01361296f, -0.09718555f, 0.15889117f, -0.02502323f, 
    0.10930467f, 0.18417297f, 0.15474530f, -0.24869664f, 0.05797406f, 0.01364218f, -0.07888749f, 0.14573959f, 
    -0.17239690f, 0.32181627f, 0.02678498f, -0.06897411f, -0.05390463f, 0.12672263f, -0.18971641f, -0.03794848f, 
    -0.06036780f, -0.13043101f, -0.41765699f, -0.18273650f, -0.10863288f, 0.07807590f, 0.01301156f, 0.05117508f, 
    0.10669041f, 0.11003016f, -0.17214438f, 0.11915829f, -0.03749156f, 0.35679469f, -0.16017210f, 0.01611581f, 
    -0.02874122f, -0.16790232f, 0.05037117f, 0.12442422f, -0.13575897f, 0.12447475f, -0.01898378f, 0.09600765f, 
    0.10298939f, -0.19011277f, 0.01065364f, 0.06844613f, -0.11907032f, -0.34080425f, -0.16563238f, 0.65148056f, 
    0.02351045f, -0.03611414f, -0.05821694f, -0.06305987f, 0.05877177f, 0.14455314f, -0.36490712f, -0.56450123f, 
    -0.12119913f, -0.20633864f, -0.00906195f, 0.13668419f, 0.16221148f, 0.18520097f, -0.03491956f, -0.13185886f, 
    -0.05056869f, -0.08063553f, -0.05194958f, -0.05470132f, -0.03000285f, 0.00742106f, -0.10775797f, 0.09881964f, 
    -0.30865410f, -0.53032780f, 0.24471791f, 0.24689455f, 0.24089335f, -0.05795364f, 0.13677865f, 0.01326615f, 
    -0.00861217f, 0.06694755f, -0.12491605f, -0.08432188f, 0.25649726f, -0.01416124f, -0.07933141f, -0.13209963f, 
    0.03731427f, 0.08670174f, 0.24444689f, -0.05884364f, -0.03384923f, -0.01677751f, 0.05542817f, 0.13961910f, 
    -0.04150716f, 0.13248010f, 0.00017721f, 0.14966910f, 0.15022300f, -0.07824973f, -0.17910716f, -0.20310555f, 
    0.10797828f, 0.18237329f, 0.02604093f, 0.06403638f, 0.07833621f, -0.27361956f, -0.21988328f, -0.05435575f, 
    0.13852599f, -0.00450080f, -0.11358142f, 0.09484184f, 0.11901449f, -0.26475045f, -0.32087350f, 0.08532698f, 
    0.02208974f, 0.02173552f, 0.05799308f, -0.00844876f, 0.07854154f, 0.12400723f, 0.48667920f, -0.00638670f, 
    0.13996097f, 0.08688463f, 0.21449019f, 0.04155174f, -0.12010985f, 0.13660094f, -0.09190760f, 0.02407244f, 
    0.06078299f, 0.03672465f, -0.07781013f, -0.00382315f, -0.09457891f, 0.10262761f, -0.03610204f, 0.02815997f, 
    0.07602856f, 0.11973318f, -0.13153686f, -0.10698988f, -0.10175426f, -0.17437655f, 0.11144696f, -0.02575088f, 
    0.17098823f, 0.16289131f, 0.14819674f, -0.26414093f, 0.11563358f, -0.10480988f, 0.00267864f, -0.11814200f, 
    0.10608555f, -0.05578238f, -0.19708966f, 0.10762487f, -0.14232396f, -0.00930031f, -0.06711292f, -0.18300223f, 
    -0.18874846f, -0.10181964f, -0.23978749f, -0.18352692f, 0.02307048f, 0.11763039f, -0.04126450f, -0.05649643f, 
    0.05579704f, -0.07336703f, 0.12832355f, -0.05135820f, -0.09103597f, -0.44502309f, -0.03136625f, 0.24855095f, 
    0.15031053f, 0.07877809f, 0.07712851f, -0.11579248f, -0.18925892f, 0.06226920f, 0.14872722f, 0.03117477f, 
    -0.18457720f, -0.00696794f, -0.00088006f, 0.04712972f, 0.18185833f, 0.02759161f, 0.15786049f, -0.06312527f, 
    0.02943597f, -0.19609098f, -0.15277819f, -0.18606791f, 0.08328910f, 0.12150317f, 0.21179673f, 0.35338062f, 
    -0.24463630f, 0.14247087f, 0.17757310f, -0.12137027f, -0.01370556f, 0.01381484f, -0.22710995f, 0.05598070f, 
    -0.60797226f, 0.03656933f, 0.15690726f, 0.35612676f, 0.23989949f, 0.00300334f, 0.09290165f, -0.19225299f, 
    0.11139509f, -0.33316937f, 0.11291647f, 0.05742637f, -0.17177747f, 0.07202014f, 0.16426118f, 0.20696682f, 
    -0.08256137f, 0.21024683f, -0.01071480f, 0.18922810f, -0.16854112f, 0.08675194f, 0.01767239f, 0.15982801f, 
    -0.28738993f, 0.24658856f, -0.03059322f, 0.15007083f, -0.22593479f, 0.00614669f, 0.00859034f, -0.25714883f, 
    0.09953958f, 0.08371205f, 0.02455607f, -0.01193942f, 0.00886928f, -0.26580217f, -0.13066387f, 0.26535296f, 
    -0.06733766f, 0.04229652f, 0.09285652f, 0.14287318f, 0.05989238f, -0.25530437f, -0.38093725f, -0.18388087f, 
    0.14987707f, -0.01127935f, 0.02334134f, -0.13263012f, -0.18610539f, -0.02430634f, 0.16423556f, -0.00275071f, 
    0.14603570f, 0.00762193f, 0.10121752f, 0.02959453f, -0.20323370f, 0.13015862f, 0.05453410f, 0.29424202f, 
    0.00732134f, -0.00391451f, -0.17453328f, -0.11597192f, -0.31780514f, -0.01152062f, -0.05727147f, 0.00194452f, 
    -0.16273172f, 0.07960449f, 0.22978875f, 0.15141788f, -0.04415207f, 0.08477233f, 0.20455548f, -0.14999877f, 
    -0.02944841f, 0.11231644f, -0.42140231f, -0.05934770f, -0.14606036f, 0.00025604f, 0.03612976f, 0.04786986f, 
    0.05561418f, -0.15996920f, -0.14473425f, -0.39061725f, -0.15303862f, 0.08861331f, 0.09640534f, 0.11046729f, 
    0.06349602f, 0.11638480f, -0.12513179f, -0.02196518f, 0.05800620f, -0.18501282f, -0.26331577f, 0.13551077f, 
    -0.13763481f, 0.02504043f, -0.00166623f, 0.09954263f, 0.16190964f, 0.09735762f, -0.00802187f, 0.09830306f, 
    0.00424469f, 0.24326479f, -0.11698483f, -0.00269812f, -0.04696652f, 0.11047706f, -0.01590562f, 0.18930347f, 
    -0.36761281f, 0.06161892f, 0.03236058f, -0.13094488f, 0.19282478f, 0.04588225f, -0.42647070f, -0.04453595f, 
    -0.07431944f, -0.19021313f, 0.03335405f, 0.02479976f, 0.03570520f, -0.05593715f, 0.08850850f, 0.21398841f, 
    -0.04955310f, -0.41086140f, 0.15652865f, 0.08082104f, -0.02540105f, -0.02959575f, -0.03890501f, 0.03836899f, 
    0.14292866f, 0.15501374f, -0.01234177f, 0.06254350f, 0.03327110f, -0.04362675f, 0.18018667f, 0.06462502f, 
    0.16793962f, -0.10024086f, 0.07796786f, 0.30335155f, 0.00058278f, -0.13547404f, -0.12797672f, 0.09734744f, 
    0.01367143f, 0.15647417f, 0.29448092f, -0.12306020f, -0.51638305f, 0.09663910f, 0.08467804f, 0.20595168f, 
    0.07585461f, -0.11727021f, 0.15251715f, -0.12831709f, 0.10669766f, 0.04126566f, 0.18835409f, -0.25879478f, 
    0.06885802f, 0.07498703f, -0.02873329f, 0.06258765f, 0.10156004f, -0.05552975f, -0.08260886f, 0.13099463f, 
    -0.00601047f, -0.23604079f, -0.08901847f, -0.11294297f, 0.25822875f, 0.04491290f, 0.07435310f, -0.07967912f, 
    0.12360270f, 0.04189372f, -0.19290330f, -0.02099713f, -0.01642755f, -0.13487034f, -0.03466905f, 0.20334621f, 
    -0.17631787f, 0.30642489f, 0.18196799f, 0.10436610f, -0.14252937f, 0.06102820f, -0.20739974f, -0.40924782f, 
    -0.25654322f, -0.06818122f, -0.12623909f, -0.02941942f, -0.22069851f, -0.11577199f, -0.07059506f, -0.18256095f, 
    0.13148795f, -0.09959972f, -0.16550402f, 0.13369149f, -0.00308845f, 0.00670820f, 0.00532018f, -0.16102687f, 
    0.06735034f, -0.00472162f, -0.07232728f, -0.18523103f, 0.32945743f, -0.11235363f, -0.04394887f, -0.00395520f, 
    -0.05859547f, -0.19765146f, -0.18161280f, -0.13563873f, -0.17805962f, -0.18657212f, 0.05150434f, 0.00663065f, 
    0.04268884f, -0.02122346f, 0.05420284f, 0.20931904f, 0.06015197f, -0.05236690f, -0.09626293f, -0.03654785f, 
    -0.13136308f, 0.01723710f, 0.30669111f, 0.02616521f, 0.55625755f, 0.27007002f, -0.02845830f, 0.10066900f, 
    0.07569516f, 0.09043448f, 0.19030045f, -0.04082574f, 0.22384726f, 0.06959175f, 0.30937916f, -0.13678493f, 
    0.01046990f, 0.04468849f, -0.02325996f, -0.06977694f, -0.07288992f, -0.01340239f, -0.33654749f, -0.25951770f, 
    0.00377729f, 0.03010072f, 0.06577081f, 0.17822337f, 0.07480269f, -0.13354768f, 0.11279605f, -0.07728191f, 
    -0.31905153f, 0.01648363f, 0.05220484f, 0.02291205f, -0.02526945f, 0.09391530f, -0.05229888f, -0.03597931f, 
    0.09250724f, 0.13889602f, -0.13919988f, 0.10330303f, 0.05124969f, 0.20278072f, -0.16702776f, -0.10380609f, 
    -0.09729499f, -0.01127036f, -0.12674017f, -0.23171954f, 0.04178505f, 0.13954784f, -0.04883447f, -0.00901913f, 
    0.05399913f, -0.10910930f, -0.39578348f, 0.05387979f, 0.02922382f, -0.05101742f, -0.03409895f, -0.10000084f, 
    -0.06686479f, 0.00561298f, 0.06568438f, -0.34983760f, -0.01298615f, -0.00453948f, -0.04381226f, -0.07431049f, 
    -0.21220648f, 0.05047590f, -0.01240611f, -0.15808198f, -0.07406740f, 0.19166379f, -0.05191047f, 0.10915693f, 
    0.06449919f, 0.02304403f, 0.05954853f, 0.11784545f, 0.16231893f, 0.07741325f, 0.02511608f, -0.44073081f, 
    -0.02993980f, -0.04584219f, -0.23100230f, -0.08808372f, 0.20403984f, 0.17889892f, -0.55492407f, 0.17970642f, 
    -0.10496254f, -0.03413308f, 0.10448336f, 0.11939096f, -0.04470032f, 0.09439404f, 0.03539415f, 0.64711505f, 
    0.05272911f, -0.21613160f, 0.07373239f, -0.05128874f, -0.10987561f, -0.02361886f, 0.00777283f, 0.05930358f, 
    -0.12630203f, -0.05604665f, 0.00868001f, 0.17265807f, -0.01706384f, 0.07096813f, 0.05943370f, -0.02272050f, 
    0.01576611f, 0.03282335f, 0.00733990f, 0.13996327f, -0.04122496f, 0.08843240f, -0.10286097f, -0.05676432f, 
    0.00694993f, -0.10316306f, -0.16461349f, -0.12424114f, -0.03839603f, 0.13809502f, -0.05531607f, 0.01655902f, 
    -0.03640467f, -0.12620457f, -0.21236318f, -0.02273032f, 0.30536568f, 0.20776960f, 0.06722754f, 0.03116331f, 
    -0.02344181f, -0.04917036f, 0.09396452f, 0.18221916f, 0.19059335f, 0.09535498f, -0.08585284f, -0.14631824f, 
    -0.00605280f, -0.09479943f, 0.04642267f, 0.18172410f, 0.03155051f, 0.22533272f, -0.12656705f, -0.14671224f, 
    0.12179655f, -0.07622425f, 0.17767651f, 0.04701458f, -0.03563470f, 0.09729657f, -0.17096318f, -0.05160654f, 
    0.10296299f, 0.08940930f, -0.12934686f, 0.08920832f, -0.05870464f, -0.01834884f, 0.04345568f, -0.16351512f, 
    0.21235947f, -0.02337570f, 0.10106304f, -0.05299328f, -0.04865187f, 0.06994669f, 0.00816923f, 0.00549515f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00740145f, -0.02498342f, -0.06220039f, -0.00607697f, 0.31715328f, 0.01273538f, 0.17140365f, 0.14379326f, 
    -0.04963664f, -0.08821255f, 0.15015942f, 0.07505674f, -0.03170036f, 0.16573380f, 0.25744793f, 0.22656401f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19378392f, -0.45961407f, -0.14203773f, -0.07595127f, -0.06209213f, -0.06144134f, -0.08475938f, 0.57596803f, 
    0.24878000f, 0.21877493f, -0.29070544f, 0.26722434f, 0.20611328f, 0.08365067f, 0.16678847f, 0.06065484f, 
    0.01429164f, -0.38631901f, -0.15197366f, -0.10923605f, -0.07362878f, -0.23858321f, 0.19840255f, -0.00870278f, 
    0.12675928f, 0.38068914f, -0.28449205f, -0.08525971f, -0.15523015f, 0.65184015f, 0.32129151f, 0.05906577f, 
    -0.21636075f, -0.07047658f, 0.08917421f, -0.24695362f, 0.26623756f, -0.22945589f, 0.20815882f, -0.66333240f, 
    -0.16025583f, -0.03448097f, 0.12248787f, 0.40804055f, -0.24542561f, 0.06469811f, 0.05059241f, -0.24309172f, 
    0.21421754f, 0.60896510f, 0.07459553f, -0.08321519f, -0.42840815f, -0.21842898f, 0.00091323f, 0.13121702f, 
    -0.09931825f, -0.14180790f, 0.10890416f, 0.37221235f, 0.12307562f, 0.26447520f, -0.22660398f, -0.16944921f, 
    -0.17296791f, -0.56493258f, 0.06756674f, -0.04552892f, -0.30304021f, -0.11549646f, 0.49879164f, -0.00445115f, 
    0.00222585f, 0.00349614f, 0.04570475f, -0.18246785f, 0.27255666f, -0.01130831f, 0.29451832f, -0.38934752f, 
    0.18731190f, -0.30308202f, 0.24218708f, -0.05641014f, -0.14954181f, -0.23711099f, 0.22514084f, 0.03207224f, 
    0.03519536f, -0.16468449f, 0.05466060f, 0.35879990f, 0.13758577f, 0.28460851f, 0.52870262f, -0.25482345f, 
    0.14765806f, 0.20615511f, 0.22365169f, -0.12423513f, 0.25002304f, 0.13165446f, 0.09768307f, 0.11711438f, 
    0.06757819f, 0.26924425f, 0.04860279f, 0.23059356f, -0.26984710f, -0.04127362f, -0.27533492f, 0.15961501f, 
    -0.15424845f, 0.53184080f, 0.13630614f, 0.04359405f, -0.16223893f, 0.18830198f, 0.07411512f, -0.38842848f, 
    0.16965358f, 0.27405655f, 0.22831573f, 0.44213110f, -0.21872132f, -0.23450153f, -0.40826359f, 0.07062671f, 
    -0.05146006f, -0.27526796f, -0.07873049f, -0.00221348f, -0.05283444f, -0.20646855f, 0.02635305f, -0.23983753f, 
    -0.09611139f, -0.19530979f, 0.12132023f, -0.02424522f, -0.04766638f, 0.05154258f, 0.01220574f, -0.26154605f, 
    -0.24189588f, 0.01649928f, -0.13415129f, 0.01910495f, 0.16518864f, 0.06122793f, -0.01383161f, -0.44647482f, 
    -0.13144544f, 0.29884845f, 0.27204767f, 0.07586438f, -0.14330973f, -0.46651953f, 0.26860094f, -0.15930054f, 
    0.01327984f, -0.09899855f, -0.20603199f, 0.10008594f, -0.08257923f, 0.09696681f, -0.08898423f, -0.26765364f, 
    -0.17154466f, 0.37530556f, 0.31012356f, -0.40684384f, -0.28408051f, 0.18953599f, 0.38557649f, 0.03717982f, 
    -0.16249527f, 0.12092219f, 0.08878335f, -0.21087033f, -0.14457873f, -0.23953854f, 0.39142323f, -0.13550214f, 
    -0.22924034f, -0.01784197f, 0.21400551f, -0.10568175f, 0.28109547f, -0.65013576f, -0.19064815f, 0.21664286f, 
    -0.07616482f, -0.22238097f, 0.19263321f, 0.05639650f, -0.03014179f, 0.01035597f, 0.09053642f, 0.28707880f, 
    -0.20608769f, 0.30189312f, -0.12946495f, 0.00641702f, -0.08781890f, 0.00783261f, 0.19291358f, 0.13115114f, 
    -0.14688703f, 0.62467009f, 0.18992896f, 0.03423498f, -0.06687132f, 0.11032455f, -0.08578683f, 0.26258302f, 
    -0.12946852f, -0.12238870f, -0.11557282f, 0.72894204f, -0.11561854f, 0.05066219f, 0.16483989f, -0.21189913f, 
    0.19144662f, -0.23562336f, -0.19362451f, 0.21301463f, 0.28622270f, 0.17633080f, 0.17915091f, -0.22073092f, 
    -0.09994157f, 0.03885641f, 0.37161791f, 0.13177283f, -0.31944874f, -0.26607564f, 0.23110764f, 0.09014425f, 
    0.04222562f, -0.19686760f, -0.13632810f, 0.03612415f, -0.24196275f, -0.06924345f, -0.14870085f, 0.49984866f, 
    -0.01451927f, -0.03508789f, 0.06355222f, -0.42593151f, 0.13695993f, 0.10019192f, 0.35191208f, 0.05837923f, 
    -0.07522772f, 0.33700296f, -0.25247970f, -0.07084023f, 0.36334068f, -0.10647457f, 0.29979649f, 0.42503333f, 
    0.09919956f, -0.28371412f, 0.33913434f, -0.31492442f, -0.14961472f, -0.61343378f, -0.28206342f, 0.13691512f, 
    -0.19794831f, 0.40935224f, 0.19958615f, -0.08118410f, 0.39238939f, 0.12241672f, 0.11148951f, -0.03014638f, 
    0.16176307f, 0.38108549f, -0.44125152f, -0.16812044f, 0.27435848f, -0.12183631f, -0.13325092f, 0.14302780f, 
    0.22405970f, 0.40264943f, 0.06068329f, -0.21275041f, 0.09001444f, 0.14779751f, -0.07614622f, -0.04579955f, 
    0.24807848f, 0.00046453f, 0.23118657f, 0.52212715f, 0.15533496f, -0.34866169f, 0.18687469f, -0.37962058f, 
    0.04653390f, 0.09431532f, -0.17464153f, 0.03719645f, -0.20082499f, -0.13023134f, 0.47741610f, 0.25245062f, 
    -0.01803953f, 0.06356896f, -0.34577918f, 0.11966088f, 0.24176016f, -0.00664030f, 0.32886782f, -0.25242051f, 
    0.15975639f, 0.14719822f, -0.20491308f, 0.10592300f, -0.19856869f, 0.12500679f, -0.07408845f, 0.01344625f, 
    0.20427710f, -0.05308123f, -0.07981326f, -0.11859579f, -0.24504651f, -0.09241312f, 0.14382127f, -0.18604451f, 
    0.00141202f, 0.69511890f, 0.05318186f, -0.11294711f, 0.10647637f, 0.04913244f, 0.10838998f, -0.07570312f, 
    0.16671228f, -0.21084762f, 0.10514635f, 0.03873921f, 0.28080085f, 0.31870687f, -0.63798022f, 0.04009806f, 
    0.00240531f, 0.17897190f, -0.10904343f, 0.06046014f, -0.44900525f, -0.02559714f, 0.43167576f, -0.25133666f, 
    0.13900839f, -0.24044468f, 0.10392503f, -0.05831450f, 0.03930996f, -0.13812611f, -0.05027257f, 0.20222498f, 
    0.16440003f, -0.02428926f, 0.22916478f, -0.02112705f, -0.09911081f, 0.09764741f, -0.25104016f, 0.12597592f, 
    0.01956115f, 0.22585805f, 0.48150027f, -0.73414320f, -0.03518818f, -0.11953437f, 0.48330832f, -0.44734818f, 
    0.13772401f, 0.39448854f, 0.20153229f, -0.23052894f, 0.06426626f, -0.05452513f, -0.10656361f, -0.18214105f, 
    0.05917891f, -0.15970267f, -0.09215733f, 0.47361901f, 0.15594253f, 0.07568775f, -0.02631773f, 0.03471220f, 
    -0.15029064f, 0.23549257f, 0.07977560f, 0.01719753f, -0.23700662f, 0.21129769f, 0.07370272f, 0.32752711f, 
    -0.01773737f, 0.16825080f, -0.30696213f, 0.22303937f, 0.16092946f, 0.14978333f, -0.19448757f, 0.15071599f, 
    -0.17463890f, -0.19421184f, -0.09595440f, -0.01017777f, 0.25927994f, 0.05339056f, 0.02346096f, -0.24394085f, 
    0.13892986f, -0.45089993f, 0.26013172f, 0.14961617f, 0.22890931f, -0.47833410f, 0.34033304f, -0.22936809f, 
    0.04355049f, 0.03637230f, -0.15315428f, -0.14316997f, -0.05660304f, -0.14414014f, 0.08311880f, 0.11152769f, 
    0.14805144f, -0.11311620f, -0.31838599f, 0.17941055f, -0.50394070f, -0.44380209f, 0.05061754f, 0.59538054f, 
    0.20230684f, 0.56766337f, -0.03407956f, 0.19966124f, 0.10335969f, 0.21139908f, 0.31585106f, -0.25278330f, 
    0.15662979f, -0.31978935f, -0.37553495f, 0.08178954f, -0.20230246f, -0.23296846f, 0.00515712f, 0.50980181f, 
    -0.08517511f, 0.40764603f, -0.12678136f, 0.15271649f, 0.00193583f, -0.05837071f, 0.27728328f, -0.29508531f, 
    0.15903345f, 0.08670321f, -0.12487316f, -0.92652732f, 0.49913359f, -0.48177600f, -0.46420702f, 0.12073451f, 
    0.20134631f, 0.18109499f, 0.03942497f, -0.18541194f, -0.18103939f, -0.09989118f, -0.10666456f, 0.13547526f, 
    -0.12295346f, 0.32125843f, 0.14354502f, -0.53148633f, 0.11627010f, -0.07897203f, 0.29757807f, -0.03327395f, 
    -0.18709072f, -0.08621699f, -0.06059105f, -0.09710425f, 0.27340531f, -0.01535153f, -0.16201654f, -0.37571102f, 
    -0.13479494f, -0.05949423f, 0.02222824f, 0.17812046f, -0.18614334f, 0.20427847f, 0.05094802f, -0.04237822f, 
    -0.12800734f, 0.02781815f, 0.16812453f, 0.16900326f, -0.46126115f, -0.12917012f, 0.26542842f, -0.21956329f, 
    -0.12752979f, 0.52453446f, 0.07593793f, -0.31489062f, 0.23079562f, -0.25573951f, -0.00963155f, -0.06182890f, 
    -0.14090008f, 0.98500431f, -0.02550728f, 0.17902091f, -0.30021971f, 0.12912944f, -0.04445726f, 0.62503016f, 
    -0.19102071f, -0.16874857f, 0.12819679f, 0.01560658f, 0.20830661f, -0.02968694f, -0.51705223f, -0.12433044f, 
    -0.12150364f, 0.63164115f, -0.17821476f, 0.10300527f, 0.27824146f, 0.14158878f, 0.24582244f, -0.41136575f, 
    -0.05880813f, -0.23803440f, 0.21665725f, -0.08693235f, -0.37021872f, -0.04373334f, -0.33723173f, 0.22603926f, 
    -0.22414923f, 0.01769656f, -0.07429850f, -0.02909418f, 0.39825684f, -0.06715562f, -0.02747143f, -0.02562142f, 
    0.03143360f, 0.31871185f, 0.47516495f, 0.00773875f, -0.28653583f, -0.37273318f, -0.12464137f, 0.02829165f, 
    0.07961359f, 0.25001749f, -0.14133947f, -0.01555284f, 0.22116868f, 0.20116305f, -0.31418210f, 0.50491887f, 
    -0.18247847f, 0.03605146f, 0.21387443f, -0.66835487f, -0.04525576f, -0.04772469f, 0.02748386f, 0.14610521f, 
    0.09134196f, -0.23232034f, -0.01604205f, 0.15935798f, 0.31627771f, -0.19730364f, -0.01423269f, 0.08748606f, 
    -0.00922577f, -0.29297239f, -0.15478493f, 0.41547137f, -0.32603827f, -0.09516790f, 0.12915713f, 0.45620963f, 
    0.22778188f, -0.47050112f, 0.14846228f, -0.24459618f, 0.44158602f, 0.04533610f, 0.37923557f, -0.11909235f, 
    0.02778073f, 0.09869058f, -0.00710522f, -0.12653726f, 0.01550145f, -0.37092888f, 0.02997004f, 0.07298300f, 
    -0.10026242f, 0.30085418f, -0.12511595f, -0.15907533f, 0.57124937f, 0.12573589f, -0.34726793f, 0.35376331f, 
    -0.04542500f, 0.26056752f, 0.10163219f, 0.43231863f, -0.13616937f, -0.36691865f, 0.09422681f, 0.13420601f, 
    0.02968701f, -0.25582764f, -0.17328493f, 0.20241411f, 0.30091611f, 0.20918080f, 0.35328117f, -0.29115796f, 
    0.01323539f, 0.17851844f, 0.30741718f, -0.39768219f, -0.34145519f, 0.03042705f, 0.22235829f, 0.15759122f, 
    -0.10707213f, -0.36086690f, 0.10681667f, 0.17795040f, -0.08859988f, 0.09527344f, 0.44121826f, 0.21579848f, 
    -0.11963744f, 0.32384667f, -0.18844631f, -0.43452471f, 0.31391671f, -0.13175179f, 0.08141151f, -0.19422548f, 
    0.00284243f, -0.77773863f, -0.01230822f, -0.03228506f, 0.06265800f, -0.01081001f, 0.10906122f, 0.27417678f, 
    -0.18805683f, -0.23075974f, 0.09105905f, 0.65404379f, 0.01450213f, 0.35168576f, -0.42640191f, -0.23755626f, 
    -0.20745414f, 0.18241526f, -0.10180271f, -0.20870210f, 0.15268108f, 0.18895990f, -0.11408380f, -0.11537994f, 
    0.03895110f, -0.47680274f, -0.01477393f, -0.44758499f, 0.07395133f, 0.57859039f, 0.04064248f, 0.34737605f, 
    0.20877106f, 0.60282552f, -0.11182279f, -0.15458161f, 0.07423028f, -0.01176594f, -0.36870715f, 0.56669390f, 
    0.04172122f, 0.30276152f, -0.29549024f, 0.40709686f, -0.24466580f, -0.33307937f, -0.00895507f, 0.11321521f, 
    0.20008512f, 0.08966776f, -0.14501354f, -0.05827557f, 0.28865463f, -0.22305749f, 0.20270957f, -0.32519740f, 
    0.16331156f, -0.10870926f, 0.35089034f, -0.13030760f, -0.43043697f, -0.13812076f, 0.20034935f, -0.36056775f, 
    0.14389168f, -0.25042996f, -0.08452027f, -0.22339247f, 0.15664344f, -0.19419426f, -0.14735627f, -0.06974411f, 
    0.13746969f, -0.01855317f, -0.34158355f, -0.29923940f, 0.06676559f, -0.02910313f, 0.10947888f, -0.19715829f, 
    -0.17453200f, 0.20495464f, 0.24608874f, 0.10681406f, 0.36222669f, 0.23571059f, 0.00137841f, -0.23740824f, 
    -0.01647261f, 0.29270634f, -0.29982650f, 0.70334643f, -0.24890819f, 0.02609081f, 0.06764126f, -0.27496967f, 
    0.03769911f, -0.23368207f, 0.22691379f, -0.14300492f, -0.26567939f, -0.23619525f, 0.45231688f, -0.28468761f, 
    0.12617931f, 0.19296612f, 0.26151401f, -0.03074930f, 0.18896757f, -0.28818232f, 0.09305692f, -0.44747800f, 
    0.09149062f, 0.31542033f, -0.11108975f, -0.11337319f, 0.23400487f, -0.12288868f, 0.05535499f, 0.26873419f, 
    0.14580671f, 0.28584349f, -0.32155314f, -0.81939596f, -0.18384364f, -0.36414742f, 0.22644360f, 0.16143610f, 
    0.23806968f, -0.18677907f, 0.04084972f, -0.00044391f, 0.12150840f, 0.20331955f, -0.41363469f, -0.00017659f, 
    -0.05502844f, 0.11480415f, 0.53204322f, 0.32931530f, -0.35671186f, -0.56135416f, -0.05142749f, 0.09508216f, 
    0.20587175f, -0.09159204f, 0.23377867f, -0.17443962f, -0.21347952f, 0.08700880f, -0.24257454f, -0.08990435f, 
    -0.14076784f, -0.21729340f, -0.32773960f, 0.13888046f, -0.25825545f, 0.02520833f, 0.07924122f, 0.17124680f, 
    -0.00581062f, 0.45259520f, 0.16446120f, 0.08913049f, -0.23301737f, 0.15614006f, -0.20891452f, -0.23642834f, 
    0.04051676f, 0.16345194f, 0.33825129f, 0.24898824f, -0.07446393f, 0.18334486f, -0.01701376f, -0.30789435f, 
    -0.24249226f, -0.06200475f, -0.04093549f, 0.04298142f, -0.28332937f, 0.09095740f, 0.44824654f, 0.31539530f, 
    0.02183765f, 0.27496874f, -0.28170472f, -0.21991567f, -0.02087362f, 0.24610299f, 0.34928620f, -0.23422712f, 
    0.07060164f, 0.16691396f, -0.03279405f, 0.17215787f, -0.24297166f, 0.12828146f, 0.30263305f, -0.47422180f, 
    0.21901812f, -0.24155667f, -0.47899646f, 0.22405198f, 0.13982137f, 0.38433674f, 0.23910503f, 0.22088355f, 
    -0.13566004f, 0.27654395f, 0.13885477f, -0.21373092f, -0.15844865f, -0.08988991f, -0.01741849f, 0.23333450f, 
    -0.20804353f, 0.59490913f, -0.18538538f, 0.48266783f, -0.19243063f, -0.16541235f, -0.31500417f, 0.21600237f, 
    0.01866753f, 0.58438265f, 0.12966368f, 0.21946900f, 0.36777067f, 0.01448716f, -0.41134179f, 0.16576916f, 
    0.05504370f, 0.28643179f, 0.16243860f, -0.52176261f, 0.00102337f, -0.64192730f, 0.15518527f, -0.04819766f, 
    0.04641491f, -0.04023800f, -0.22521558f, 0.20798314f, -0.21155433f, 0.23065329f, 0.16027051f, -0.36774263f, 
    -0.23011827f, -0.12894526f, -0.36173892f, 0.38914457f, -0.06013434f, 0.05640230f, 0.35250175f, -0.33260542f, 
    0.05569006f, -0.51018924f, 0.10341805f, -0.02768522f, -0.06921361f, -0.17690763f, -0.29332766f, 0.60047293f, 
    0.22159281f, 0.39807343f, -0.32116413f, 0.58112019f, 0.21511135f, 0.17930698f, 0.03301587f, 0.17306885f, 
    0.20625460f, 0.12268919f, -0.10555994f, -0.12879977f, 0.14689192f, -0.13656922f, 0.02867286f, 0.47159916f, 
    -0.18685187f, -0.09287490f, 0.35378858f, -0.17248975f, -0.40240273f, -0.00853480f, 0.19069089f, 0.38848108f, 
    -0.17273614f, 0.21607272f, 0.18626207f, -0.21555287f, -0.74614710f, -0.20105395f, 0.20645311f, 0.04613796f, 
    -0.09619142f, -0.24387765f, -0.41242427f, 0.58387381f, 0.27018568f, -0.09790610f, 0.42171592f, -0.21661229f, 
    0.08259092f, -0.12042338f, -0.01819824f, -0.09834722f, 0.30618018f, -0.06601430f, -0.05964801f, -0.38711622f, 
    0.03281076f, 0.41923311f, -0.14630871f, 0.14971061f, -0.31849742f, 0.52748579f, 0.22020416f, 0.24648561f, 
    0.07328497f, 0.20181407f, -0.15937681f, 0.00271260f, 0.20930709f, -0.16553119f, -0.19589366f, 0.12652859f, 
    0.12746997f, -0.11207211f, -0.18542767f, 0.42510498f, -0.04892704f, 0.07005805f, 0.07630894f, 0.43787566f, 
    -0.06703773f, -0.09095644f, -0.20164819f, 0.23788145f, -0.09267093f, 0.22781432f, 0.00823617f, -0.38778600f, 
    0.00350335f, 0.29344609f, 0.24911223f, 0.06736591f, -0.29747877f, 0.70983571f, 0.14695066f, -0.00022091f, 
    0.00154749f, -0.32175770f, 0.05368851f, -0.09773384f, -0.39202842f, -0.05211356f, 0.08054529f, 0.09682471f, 
    -0.23472361f, 0.28630990f, 0.02899462f, -0.00993275f, -0.13130803f, 0.63759154f, 0.39646363f, -0.00992556f, 
    0.03917561f, -0.10350259f, 0.10136696f, 0.03840819f, 0.32924253f, -0.18881351f, -0.00623617f, -0.29261348f, 
    0.00117039f, -0.54957265f, 0.16175385f, 0.30449891f, -0.05591052f, -0.13336706f, 0.43763959f, -0.25136960f, 
    0.19097340f, -0.26127699f, -0.01731822f, -0.22872749f, 0.05809910f, 0.15150936f, 0.26887062f, -0.22722206f, 
    -0.15617016f, 0.33173046f, 0.25378740f, -0.15697654f, -0.38496861f, -0.30994868f, 0.44753733f, 0.07621793f, 
    -0.07034364f, -0.03501413f, -0.05928320f, -0.15327522f, -0.03486229f, -0.17608811f, 0.55932474f, -0.20366295f, 
    0.17075855f, -0.31376475f, 0.44951802f, -0.21685515f, 0.07142304f, -0.27361795f, -0.04891341f, -0.19770813f, 
    -0.01167761f, -0.33371213f, -0.02944704f, 0.09810658f, -0.18725389f, -0.09557772f, 0.13303013f, 0.44203264f, 
    0.14342961f, -0.34482643f, -0.08884872f, 0.02512351f, 0.18918326f, -0.08279738f, 0.51092249f, 0.23922385f, 
    -0.01634771f, -0.15774448f, -0.13378875f, -0.23101693f, -0.34752437f, 0.20797151f, 0.14937210f, -0.13691898f, 
    -0.04829546f, 0.15245959f, 0.35634953f, -0.33114231f, 0.38430369f, 0.03676879f, 0.02923537f, -0.26049587f, 
    0.11052057f, -0.18891102f, -0.15112780f, 0.21976027f, 0.57206178f, 0.14464267f, 0.33599630f, -0.52420992f, 
    -0.17268099f, 0.21391079f, 0.15650560f, 0.20567212f, -0.42514917f, -0.25622955f, 0.06896733f, -0.00621118f, 
    -0.05201287f, -0.23248120f, 0.14983803f, 0.22750375f, -0.08236004f, 0.16792668f, 0.37316549f, 0.00306693f, 
    0.15067898f, 0.34681109f, 0.31059411f, -0.26538500f, -0.13468911f, 0.12459721f, -0.36837369f, 0.27131155f, 
    0.13871101f, -0.08664461f, -0.22671062f, -0.00826617f, 0.20020343f, 0.01982502f, -0.26728529f, -0.05928606f, 
    0.03342463f, -0.40950975f, 0.04445565f, 0.08594201f, 0.20310509f, 0.34394082f, 0.06610458f, 0.35178021f, 
    -0.14495531f, 0.11155877f, 0.18349871f, 0.07197689f, -0.31309882f, 0.09750823f, 0.13992700f, 0.18665725f, 
    0.16321208f, -0.44108951f, 0.27918091f, -0.39917895f, -0.61172044f, 0.48472390f, 0.39786872f, 0.00374025f, 
    0.04771128f, 0.21649835f, 0.02932181f, -0.02140200f, -0.66066593f, 0.12705216f, -0.02937410f, -0.04155431f, 
    0.01393960f, -0.37382242f, -0.22768515f, 0.39407334f, -0.00471123f, 0.71139926f, 0.29814181f, 0.11759855f, 
    0.15020022f, -0.07319341f, -0.10394472f, -0.13155487f, -0.14095122f, 0.12737149f, -0.19208874f, -0.19487627f, 
    0.21110532f, -0.23094480f, 0.18648957f, -0.02998510f, -0.02233421f, -0.20502974f, -0.18307979f, -0.07884774f, 
    0.15115635f, -0.25314373f, 0.16888535f, 0.21258445f, -0.15498477f, 0.19058220f, 0.27280816f, 0.25338545f, 
    0.11237153f, 0.11071214f, 0.24801244f, -0.46067524f, 0.02123977f, 0.24785838f, 0.31818473f, -0.32352799f, 
    0.14855266f, -0.07479384f, 0.00164866f, -0.10215470f, -0.42109242f, -0.00882268f, 0.02065606f, 0.02847319f, 
    -0.00860143f, 0.08583517f, 0.18035771f, 0.57938343f, -0.18336092f, 0.09466765f, -0.14468743f, 0.31734511f, 
    0.21977434f, -0.09383368f, -0.24784064f, -0.03868002f, 0.03806178f, 0.15531760f, 0.50210869f, -0.41825220f, 
    -0.10954357f, -0.27895388f, 0.02516513f, 0.36226410f, 0.19885510f, 0.28495124f, -0.28655645f, -0.39175451f, 
    -0.18652871f, 0.34865198f, -0.19856468f, -0.23334609f, -0.31203806f, -0.21512461f, 0.21684200f, 0.14990689f, 
    -0.05855725f, -0.22863732f, -0.12341225f, 0.33235323f, -0.20132905f, -0.39746270f, 0.34635636f, -0.46698114f, 
    0.01480165f, 0.43642515f, 0.23715696f, 0.06879950f, -0.06640851f, 0.23444507f, 0.03650377f, 0.36663187f, 
    -0.10252166f, 0.19283082f, 0.05163683f, -0.11118936f, -0.31305054f, -0.19637570f, -0.21058111f, -0.04695245f, 
    0.04744580f, 0.80933619f, -0.15715626f, -0.22729057f, 0.22978839f, -0.16044091f, 0.14512829f, -0.09150270f, 
    -0.00095162f, -0.15800358f, 0.25161377f, -0.77786994f, 0.28605041f, -0.17264433f, -0.70953393f, 0.12760402f, 
    -0.20706841f, -0.44581747f, 0.02839108f, 0.17076246f, 0.19999228f, 0.11529286f, -0.26756856f, 0.52137280f, 
    -0.06468979f, 0.01252059f, -0.35795599f, 0.15345922f, 0.27768695f, -0.09115756f, 0.11860975f, 0.34218764f, 
    0.24213973f, -0.20626345f, -0.18501341f, 0.01499661f, -0.05964619f, -0.06205762f, 0.29861489f, 0.00046151f, 
    0.04547231f, -0.37165356f, -0.17389311f, 0.41668442f, 0.26044506f, -0.36380276f, 0.44007748f, -0.05831651f, 
    -0.17703438f, 0.13234839f, 0.07304789f, -0.22643387f, -0.09252427f, 0.14195029f, 0.08062321f, 0.28030425f, 
    0.00231728f, -0.03370244f, -0.24309593f, 0.24250782f, 0.02581274f, 0.08261932f, 0.22372557f, 0.10843417f, 
    -0.05737446f, 0.43568543f, -0.07415928f, -0.08045682f, -0.42006287f, -0.18654159f, 0.36491159f, -0.35023025f, 
    0.02710901f, 0.08428498f, 0.18750381f, 0.26610368f, 0.21908362f, 0.31749395f, 0.10305012f, -0.34854370f, 
    0.20901060f, 0.08895745f, -0.13894928f, -0.21381038f, 0.15141509f, -0.24958694f, 0.17443377f, -0.35490566f, 
    0.09203757f, -0.37178802f, -0.09913731f, 0.10604968f, -0.40066305f, 0.24401128f, 0.23643050f, 0.24420705f, 
    0.06932712f, -0.25630516f, 0.09311248f, -0.21149302f, -0.49082062f, -0.12070742f, -0.06427424f, 0.59796172f, 
    -0.20293717f, 0.01548998f, -0.19295226f, -0.04929491f, 0.27692887f, 0.39879936f, 0.45411599f, 0.00818979f, 
    0.02214798f, 0.12501487f, -0.10453600f, -0.07558958f, 0.22924538f, 0.23457615f, -0.46879709f, 0.38784671f, 
    0.09104690f, -0.33281046f, -0.07278204f, 0.25784326f, 0.47787943f, 0.50071001f, 0.08112083f, -0.18344784f, 
    -0.15686065f, -0.03651029f, 0.14001660f, 0.09581056f, 0.57928741f, 0.09408605f, -0.20748204f, 0.20399444f, 
    -0.13649978f, -0.49772117f, 0.23129107f, 0.09977502f, -0.23211187f, -0.28874147f, 0.18197806f, 0.15702087f, 
    -0.21900874f, -0.03541003f, -0.08128718f, 0.20956463f, 0.39705858f, 0.08785946f, -0.19378260f, -0.21148176f, 
    -0.10257210f, 0.11747794f, 0.19005001f, 0.03935785f, -0.18847074f, -0.02272514f, 0.31510696f, 0.31219319f, 
    0.20059933f, -0.10880399f, 0.16229934f, 0.09901614f, 0.29600137f, 0.20066352f, -0.29902470f, -0.01522715f, 
    -0.23654424f, -0.52464831f, 0.11174289f, -0.05316129f, 0.31391513f, 0.43873960f, 0.29029971f, 0.20072687f, 
    0.15320644f, -0.34557900f, 0.11629840f, 0.08917251f, 0.16714005f, -0.10436302f, -0.03541615f, -0.14473598f, 
    0.08069234f, 0.54945141f, -0.02431011f, -0.14466482f, 0.25846475f, 0.35445872f, -0.12658262f, 0.12874500f, 
    0.10295548f, 0.59836662f, 0.00361595f, 0.09446768f, -0.24489892f, 0.08199555f, 0.42205191f, 0.11978895f, 
    0.04034211f, -0.16754623f, -0.13385087f, 0.32346937f, -0.06397476f, 0.56238097f, -0.15362434f, -0.16782676f, 
    -0.01516488f, -0.30036378f, 0.01101431f, 0.08584791f, -0.01820653f, -0.22257236f, 0.18402746f, 0.61389881f, 
    -0.23432444f, -0.14330921f, -0.21944055f, 0.54063904f, -0.32252440f, -0.20136455f, 0.21154173f, 0.18891296f, 
    0.21366897f, -0.22540486f, 0.11867511f, 0.09272477f, -0.13953993f, -0.07108673f, 0.09265021f, 0.05604460f, 
    -0.10305005f, 0.05972365f, -0.25138947f, -0.20923981f, -0.05519303f, -0.14312804f, 0.05403470f, -0.23620984f, 
    0.24860744f, -0.15055011f, 0.09477317f, -0.21100132f, 0.30741644f, 0.03276059f, -0.01119947f, 0.53923684f, 
    -0.04037720f, -0.04500829f, 0.26108330f, -0.53113598f, -0.06936776f, -0.48624215f, 0.38155758f, -0.10619146f, 
    -0.20168105f, 0.41741025f, -0.02656911f, 0.17551696f, -0.36995116f, -0.18562271f, -0.09660874f, -0.20826094f, 
    0.17877333f, -0.08969154f, -0.09067252f, 0.52468741f, 0.26961911f, 0.37289223f, 0.19748412f, 0.38033134f, 
    0.16675262f, 0.13752286f, -0.22051196f, 0.06015321f, -1.09912074f, 0.23234272f, 0.26905671f, 0.03541305f, 
    0.05504521f, 0.35210508f, -0.17427365f, -0.29270381f, 0.43753690f, 0.51804125f, -0.12293282f, 0.03087784f, 
    -0.18908849f, -0.12275239f, 0.22086973f, 0.01118989f, -0.45516175f, 0.16264996f, 0.46180043f, 0.05949968f, 
    0.18987945f, 0.25981671f, -0.18164690f, -0.08685493f, 0.39500797f, 0.75640374f, -0.11167020f, 0.02763868f, 
    -0.01274021f, -0.27964440f, 0.24624586f, 0.22526976f, 0.35932246f, 0.05241514f, -0.20610070f, 0.25740117f, 
    -0.13257246f, -0.37493548f, 0.06972089f, 0.05488186f, 0.20043129f, -0.04931182f, 0.46709993f, 0.20909227f, 
    -0.20342249f, 0.41894484f, -0.10631334f, -0.19807753f, 0.06002886f, -0.11545719f, -0.06734743f, 0.29753739f, 
    0.15234555f, 0.10845631f, -0.02104359f, -0.08277664f, -0.15466154f, 0.39990720f, -0.20044143f, 0.17758906f, 
    -0.16154714f, 0.51814562f, 0.08468856f, -0.11992787f, 0.03824666f, 0.12465884f, 0.02674374f, 0.16662107f, 
    0.05414965f, -0.28563190f, 0.23290956f, -0.22045785f, 0.15229404f, 0.05866431f, -0.12341435f, -0.36114657f, 
    0.05163237f, 0.15147801f, -0.19611336f, -0.12112600f, -0.44753578f, -0.12940699f, 0.38462138f, -0.49692130f, 
    0.23540740f, 0.30113748f, 0.30459973f, 0.31039578f, -0.09300107f, -0.22303309f, 0.36535516f, -0.41235909f, 
    0.05562591f, 0.36132625f, 0.18485110f, 0.01917156f, 0.08549633f, 0.18217494f, -0.00671930f, 0.31569803f, 
    0.08942147f, 0.29907069f, -0.21250705f, -0.16618310f, 0.08206400f, 0.39955664f, -0.12040352f, 0.03497654f, 
    -0.01913896f, 0.30097875f, 0.03347598f, 0.04985984f, -0.25433740f, -0.08777627f, 0.34080192f, -0.61849433f, 
    0.02993761f, -0.07407808f, -0.31239390f, 0.12392726f, 0.07490093f, 0.45093572f, 0.15987912f, 0.18801908f, 
    -0.13737820f, -0.04449571f, 0.17095409f, -0.08121061f, -0.14829527f, -0.14135107f, -0.04105258f, -0.57376146f, 
    0.13288051f, 0.43108517f, 0.17196435f, 0.12268216f, 0.24101457f, 0.57315022f, -0.13409585f, -0.00806610f, 
    0.03419630f, 0.17964421f, 0.00180395f, -0.16644675f, 0.60679317f, -0.07838647f, -0.00605794f, 0.37664941f, 
    -0.14550070f, -0.42854232f, 0.26017907f, -0.23003398f, -0.12836336f, -0.54912752f, 0.08798099f, 0.19920114f, 
    -0.17342557f, 0.26740897f, 0.00603059f, -0.00851993f, -0.18394437f, -0.16189332f, -0.07738588f, 0.41865149f, 
    -0.19080575f, -0.23281285f, 0.07056599f, -0.46293435f, 0.53269565f, 0.39628419f, -0.27667385f, 0.46627626f, 
    0.10213153f, -0.23538046f, -0.19279841f, -0.07018162f, 0.14941570f, -0.20658140f, 0.16843238f, 0.12724842f, 
    -0.08049852f, 0.23449856f, 0.03923437f, -0.47534215f, -0.09841155f, 0.12878722f, 0.16397546f, 0.11507262f, 
    0.02243692f, -0.25056922f, 0.20312749f, -0.23855591f, -0.12740800f, -0.24661425f, 0.18736392f, -0.20367847f, 
    0.05684390f, -0.25361952f, 0.47546315f, -0.14173461f, 0.16813120f, 0.03634853f, 0.08471671f, 0.03408368f, 
    0.23702101f, 0.31187537f, -0.23421326f, -0.05175711f, -0.08132447f, -0.18807329f, -0.02702949f, -0.31721249f, 
    0.07851440f, 0.44107473f, 0.00411086f, 0.20602120f, -0.40417570f, -0.03719333f, -0.26420814f, 0.42475924f, 
    0.16119200f, -0.10813069f, -0.12678036f, -0.19900602f, -0.34910169f, -0.03620463f, 0.33273926f, 0.12407906f, 
    -0.11566304f, 0.38577753f, 0.14556228f, -0.42333502f, 0.30190212f, 0.37704521f, -0.18674357f, -0.23318820f, 
    0.19787458f, -0.21912034f, 0.01883284f, 0.18902311f, -0.20831265f, -0.11250684f, -0.18207553f, 0.07019794f, 
    0.12579849f, 0.04758721f, -0.22497511f, 0.00305112f, -0.06425768f, 0.12219241f, -0.05493329f, 0.02404821f, 
    0.13984033f, 0.16550301f, 0.09996402f, -0.20740773f, 0.04188282f, -0.17193058f, 0.42836803f, -0.21905135f, 
    -0.08833123f, -0.03280162f, 0.27070278f, -0.06969418f, 0.07978440f, -0.48606640f, -0.26568463f, 0.10786132f, 
    -0.05735715f, -0.29220143f, 0.07012201f, -0.18302372f, -0.60574245f, 0.14829619f, 0.07326541f, 0.00800522f, 
    0.06466876f, 0.04188989f, -0.04865493f, 0.42945117f, 0.24380459f, 0.09801697f, 0.34923711f, 0.06011475f, 
    -0.10672144f, 0.46581492f, 0.20837297f, -0.02300893f, 0.09522884f, 0.03547194f, -0.28702116f, -0.53425771f, 
    0.17499170f, 0.57948154f, 0.24467503f, -0.30551216f, 0.19587763f, -0.07454390f, -0.21274257f, 0.16942486f, 
    -0.25179416f, -0.19269422f, 0.02471323f, -0.18372004f, 0.16777900f, -0.09960803f, 0.31710550f, 0.23140329f, 
    -0.23467723f, 0.25694087f, 0.00639579f, -0.52068549f, -0.18139979f, 0.36271131f, 0.06175281f, -0.26867485f, 
    -0.18788277f, -0.41036582f, 0.16906406f, 0.22853544f, -0.27402350f, -0.08739574f, 0.17192474f, -0.10025717f, 
    0.19473380f, 0.54364550f, 0.27469411f, -0.22276749f, -0.15015140f, 0.58817792f, -0.05596412f, -0.00162062f, 
    0.17920896f, -0.93342775f, 0.09326322f, -0.17737740f, -0.20653725f, 0.01081324f, 0.26472116f, -0.13556781f, 
    0.17040832f, 0.01313687f, -0.22618943f, 0.63522160f, -0.28726560f, 0.12721951f, 0.38187897f, 0.03425460f, 
    0.18229331f, -0.23888808f, 0.14134069f, -0.12675032f, -0.55158436f, -0.07543477f, 0.59333342f, -0.13349900f, 
    -0.06496996f, -0.01550702f, 0.31897676f, -0.22176778f, 0.13293253f, 0.09098649f, 0.18188354f, -0.49929598f, 
    0.24204272f, 0.20626915f, -0.19594030f, 0.15043062f, 0.39788282f, 0.09405261f, -0.08978350f, 0.27356794f, 
    -0.16208927f, -0.26876917f, 0.25638509f, -0.42750162f, 0.26454061f, -0.15204680f, -0.02795516f, 0.17866312f, 
    0.02953139f, -0.19054522f, -0.18835640f, -0.23563454f, -0.16693071f, -0.03231964f, 0.01525124f, 0.04666950f, 
    -0.22212261f, 0.11895726f, -0.24106541f, -0.11238730f, -0.15961725f, 0.18580490f, -0.25716642f, -0.17900553f, 
    0.10726465f, -0.24146795f, 0.02333328f, -0.00027856f, -0.13039695f, 0.16207235f, 0.24776840f, -0.21242583f, 
    -0.12787907f, 0.09018344f, 0.40647554f, -0.10923732f, 0.33120304f, -0.31993967f, 0.05719657f, -0.22930485f, 
    -0.23804782f, 0.54161018f, -0.19480744f, 0.05614358f, -0.08785371f, 0.12326193f, 0.30568832f, -0.54372287f, 
    0.13346200f, 0.25094196f, 0.27484643f, 0.63495624f, -0.10246422f, -0.16050296f, -0.37786317f, -0.38200450f, 
    0.08557069f, -0.15211238f, -0.06445745f, -0.16263263f, -0.06196799f, -0.06570987f, 0.00485453f, 0.30591732f, 
    -0.17998961f, -0.00976913f, 0.23045328f, -0.25047639f, -0.03202223f, -0.23343860f, 0.29865628f, -0.02588501f, 
    -0.04344094f, -0.08456515f, 0.15122679f, 0.23434876f, -0.05950359f, 0.06296055f, 0.29305670f, -0.49643961f, 
    0.01674078f, 0.44000879f, 0.28323746f, -0.14373158f, -0.55763853f, 0.13899161f, -0.21571966f, 0.38740692f, 
    0.23613101f, -0.22874373f, 0.13812989f, 0.09442466f, -0.19452693f, 0.17501751f, -0.07622427f, 0.05512707f, 
    -0.22514321f, 0.08670697f, -0.18237105f, -0.25077230f, -0.17476276f, -0.19297522f, -0.02091711f, 0.12343344f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16848670f, -0.17091918f, 0.14314491f, 0.11185461f, 0.04061875f, 0.13681090f, 0.17658049f, 0.06982449f, 
    -0.28002110f, 0.15073869f, -0.00246963f, 0.23479070f, 0.12596101f, -0.20591085f, 0.43825671f, 0.61458838f, 
    0.50045997f, -0.14107125f, 0.10674667f, 0.09385243f, -0.15654638f, -0.17776221f, 0.41130054f, 0.38199779f, 
    0.19790865f, 0.34622133f, -0.12383745f, 0.41349497f, 0.32162100f, 0.04610299f, -0.14050114f, 0.24554288f, 
    -0.38887215f, -0.38796848f, 0.24199279f, 0.34653872f, 0.19814382f, 0.49466926f, 0.33270049f, -0.19002874f, 
    0.57104188f, 0.36235285f, -0.35282394f, 0.48958260f, 0.12536396f, -0.06603330f, -0.27640021f, -0.25429311f, 
    -0.09030064f, 0.54500252f, 0.00243264f, -0.03308281f, 0.04836395f, -0.35550526f, 0.20132297f, -0.01824194f, 
    -0.07602150f, -0.01317198f, 0.17031971f, 0.11487808f, -0.43694487f, -0.41000786f, 0.24868916f, 0.25240231f, 
    -0.14141981f, 0.01934688f, 0.40907091f, 0.50328797f, 0.27941078f, 0.07807323f, 0.47901246f, 0.13074058f, 
    -0.03082725f, 0.18315196f, 0.14285997f, -0.14999889f, 0.27813277f, 0.16962647f, 0.15210748f, -0.03611248f, 
    -0.11497337f, -0.01518812f, 0.11480177f, -0.35701433f, -0.34200603f, -0.23278095f, 0.57698303f, 0.05069338f, 
    0.18880835f, -0.09776514f, 0.40148878f, 0.07016938f, -0.36873728f, 0.22839710f, -0.08044141f, -0.19070624f, 
    0.23999064f, -0.07603634f, -0.07583136f, -0.20650941f, 0.09310254f, 0.20241423f, 0.10405958f, -0.03995448f, 
    0.06234401f, 0.07172756f, -0.45375133f, 0.26503980f, 0.16792296f, 0.60220706f, 0.19953704f, 0.24239878f, 
    0.36002839f, -0.09672926f, 0.36424243f, 0.33973861f, -0.36069795f, 0.56047171f, -0.23395213f, 0.52844715f, 
    0.26792130f, 0.06617304f, -0.04602800f, 0.20267256f, -0.23733865f, -0.23414691f, 0.15444283f, -0.07313970f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04642324f, -0.14108527f, -0.08101427f, -0.31570461f, -0.07873306f, -0.32724005f, 0.11592226f, -0.00942934f, 
    0.02878501f, -0.40323603f, -0.36220893f, 0.13403578f, 0.02026485f, -0.54674667f, -0.09899214f, 0.04136789f, 
    0.21132089f, 0.36188099f, -0.16924885f, -0.06858618f, 0.02148836f, 0.01151532f, -0.06978986f, -0.71849161f, 
    0.07736853f, 0.13202927f, -0.07560872f, 0.50598758f, 0.50246638f, 0.28497782f, 0.00410595f, -0.46438619f, 
    -0.63027060f, -1.01304924f, 0.21091011f, 0.01858015f, 0.17569342f, 0.24408950f, 0.14769398f, 0.04331702f, 
    0.08346161f, 0.04545081f, 0.77453095f, 0.22638316f, 0.28241661f, -0.24817649f, -0.04136734f, -1.19402325f, 
    -0.27057856f, 0.63038594f, 0.10254226f, -0.05356730f, 0.56187814f, -0.38319343f, 0.13639076f, 0.09175259f, 
    0.36457148f, -0.72659230f, -0.01953769f, 0.02360956f, 0.19188376f, -0.26712298f, 0.24190922f, -0.20531555f, 
    -0.11492591f, -0.33158478f, -0.51222128f, 0.07372977f, -0.03999307f, -0.28336075f, 0.01166116f, 0.06418264f, 
    0.14740433f, -0.13187686f, -0.42447171f, -0.10224655f, -0.07309565f, 0.26135826f, -0.12616503f, -0.00661991f, 
    -0.08062835f, 0.00733425f, 0.16159225f, -0.10378701f, -0.02108800f, -0.45607832f, 0.23816976f, -0.09044360f, 
    -0.00916982f, 0.07519506f, 0.07374965f, 0.06389163f, 0.00870678f, -0.14046493f, 0.13340837f, 0.04132810f, 
    0.05230072f, -0.02299522f, -0.61775100f, -0.22168590f, 0.04367863f, 0.13568848f, -0.12426133f, -0.44459602f, 
    0.13740066f, 0.10412828f, -0.18137170f, 0.24010356f, 0.06441306f, 0.05360838f, -0.22659376f, 0.24312733f, 
    -0.13152488f, 0.01759258f, 0.13725035f, -0.02995985f, 0.27107731f, -0.01661201f, -0.16837065f, -0.07872091f, 
    -0.44186869f, 0.09901527f, -0.05193578f, -0.25086945f, -0.21300018f, -0.06890534f, 0.20657609f, -0.06184465f, 
    0.18668583f, 0.03146753f, -0.22714812f, 0.04037955f, -0.70137244f, 0.00817011f, 0.03989257f, -0.15161200f, 
    -0.05209043f, 0.16345942f, 0.13811648f, -0.25450495f, 0.05664540f, 0.14403242f, 0.10445780f, 0.14286681f, 
    0.10087413f, 0.15424670f, 0.02185608f, 0.11571735f, -0.05083545f, 0.02012593f, -0.17423615f, 0.50242168f, 
    0.01904830f, 0.04217192f, -0.18757857f, 0.19059142f, 0.13251109f, -0.30934158f, 0.28219008f, -0.32972535f, 
    -0.33747497f, 0.31785122f, -0.49709809f, 0.10578488f, 0.26723620f, -0.03551278f, 0.05571971f, 0.23661752f, 
    -0.02412321f, 0.03180964f, -0.01337602f, -0.42523599f, 0.30986106f, -0.37631208f, -0.07075796f, -0.30614001f, 
    -0.47337088f, 0.18508439f, 0.20606758f, 0.05022275f, 0.11694801f, 0.00751396f, -0.03936111f, 0.04353580f, 
    0.36252281f, -0.56051415f, 0.07872516f, 0.18618295f, -0.00157035f, 0.02469693f, -0.04068379f, -0.13639799f, 
    -0.01289034f, 0.02862947f, 0.29517737f, -0.68299955f, -0.01199301f, -0.10068725f, 0.10232610f, -0.07871920f, 
    -0.04032112f, -0.41001442f, 0.71195436f, 0.05564495f, 0.12177228f, -0.31763184f, 0.72213441f, 0.22798072f, 
    -0.02192068f, -0.48953563f, 0.06919192f, -0.08701079f, 0.11039507f, -0.28267959f, -0.19862141f, 0.08696295f, 
    0.14962631f, 0.12364994f, 0.00660875f, -0.06794828f, -0.09959877f, 0.35525674f, 0.08768371f, -0.04917233f, 
    0.21326588f, -0.25353503f, -0.34384391f, -0.12188848f, 0.11197089f, 0.09451410f, 0.00488287f, -0.33717623f, 
    0.07784651f, -0.11586013f, -0.30256993f, 0.15642832f, -0.23469640f, 0.07185113f, -0.31852534f, -0.21548244f, 
    -0.04705591f, 0.04890939f, -0.14416210f, -0.53464681f, 0.08246172f, 0.12024078f, -0.12487691f, -0.25711504f, 
    -0.63908309f, 0.04836280f, -0.01521718f, -0.26004085f, -0.25505817f, 0.13128161f, -0.16697708f, 0.03520399f, 
    -0.01487262f, 0.31480294f, -0.12433624f, -0.55059212f, -0.03162596f, -0.07981888f, 0.14708945f, 0.26438174f, 
    -0.01499921f, 0.11666492f, 0.22992611f, -0.35078576f, 0.16861616f, -0.07355481f, -0.02757834f, -0.50604582f, 
    -0.65773010f, 0.22815442f, -0.22834373f, -0.02426276f, -0.06597596f, -0.65546954f, -0.36450645f, -0.24036093f, 
    -0.23296691f, -0.08193628f, -0.63593096f, -0.27089775f, -0.32273063f, -0.51687241f, 0.09139771f, 0.07397508f, 
    0.22984004f, -1.49358428f, -0.20200235f, 0.15331717f, -0.95375198f, -0.26532164f, -0.01839887f, 0.05607524f, 
    0.13823979f, 0.15033801f, 0.19474244f, -0.55420166f, 0.03245888f, -0.30784935f, 0.02092741f, -0.01383914f, 
    0.09074704f, 0.09740247f, 0.27040586f, -0.01984124f, 0.30266240f, 0.56646925f, -0.41635197f, 0.42764449f, 
    -0.45175835f, -1.07796180f, 0.07093533f, -0.27606469f, -1.31535482f, 0.37690225f, -0.12607545f, 0.38046786f, 
    0.22388498f, -0.44577506f, 0.07024889f, -0.50016296f, -0.57082701f, -0.05477631f, 0.14843141f, 0.20442832f, 
    -0.19771056f, -0.75490844f, -0.72321731f, -0.08021398f, 0.08383382f, 0.11744261f, -0.16829605f, -1.28380108f, 
    0.00078464f, -0.99926203f, -0.30012056f, -0.93743992f, 0.06958869f, 0.08528962f, -0.43139166f, -0.17219728f, 
    -0.59378660f, -0.39407986f, 0.07546088f, -0.46368736f, 0.49329844f, 0.04142919f, -0.17281491f, 0.02896477f, 
    -0.35270354f, -0.17066894f, 0.05825126f, 0.28239554f, -0.37913886f, 0.04070051f, -0.60014540f, 0.16655758f, 
    0.08152974f, -0.03292640f, 0.31137809f, -0.75982332f, -0.89023036f, 0.09566102f, -0.34010801f, 0.33991203f, 
    0.08766283f, 0.03258373f, -0.28814360f, -0.22177623f, 0.21912922f, 0.23993334f, 0.44850066f, -0.17461354f, 
    0.04987395f, -0.95223421f, 0.03557485f, -0.20286365f, 0.20332110f, -0.09696147f, 0.41463152f, -0.03371732f, 
    0.26506248f, -0.07887722f, -0.06736527f, -0.00770643f, 0.25395975f, 0.02250431f, -0.23049922f, -0.18687755f, 
    -0.11438343f, -0.47635156f, -0.42002362f, 0.14228269f, -0.10728959f, -0.27063006f, -0.68927443f, 0.01481787f, 
    -0.08701697f, 0.03289708f, -0.05528480f, 0.10959203f, 0.01563528f, 0.16965003f, 0.21758033f, -0.16154914f, 
    0.03088714f, 0.11416013f, -0.00362307f, -0.49948245f, 0.04751479f, 0.48546872f, 0.03022454f, -0.33004272f, 
    0.17362522f, -0.47591406f, 0.01047480f, -0.46308815f, -0.35529548f, 0.03705911f, -0.01889830f, -0.40182894f, 
    -0.22018021f, 0.22770281f, 0.15848756f, -0.01386084f, -0.70929521f, -0.51642942f, 0.05934968f, 0.33337617f, 
    0.21247342f, -0.67878729f, -1.36332202f, -0.07374846f, -0.32202324f, -0.10297620f, 0.11684462f, -0.52614653f, 
    -0.83390266f, -0.07782865f, 0.15016820f, -0.92987871f, 0.03957493f, 0.11053612f, -0.28626159f, -0.18004248f, 
    -0.02013186f, -0.64844322f, -1.45960593f, 0.20816478f, -0.08442692f, 0.34540069f, -0.68496156f, -0.03867956f, 
    -0.02671614f, -1.01660323f, -0.42806119f, -0.06128598f, 0.00562181f, -1.01139271f, 0.27346897f, -0.00469469f, 
    -0.19580440f, 0.25876766f, 0.11472368f, 0.13446134f, -0.12161721f, 0.21674955f, -0.23917060f, 0.18942775f, 
    -0.03023495f, -0.46408543f, -0.39692977f, 0.00930313f, 0.29525843f, -0.00808944f, 0.52645606f, 0.07909224f, 
    -0.40745357f, 0.13622332f, 0.27351919f, 0.30826265f, -0.18585496f, -0.16668545f, 0.12070399f, -0.04096232f, 
    0.04283514f, 0.06035402f, 0.23092060f, -0.23051992f, 0.24223134f, -0.13976866f, 0.23729302f, -0.45547539f, 
    0.20448814f, 0.01360681f, 0.11178944f, 0.06837954f, 0.04085188f, -0.19106391f, -0.05549778f, -0.25673881f, 
    0.20164329f, 0.02354886f, -0.04381398f, 0.23160931f, -0.01290667f, -0.03225670f, -1.02849984f, -0.09037060f, 
    0.19936647f, -0.24809983f, 0.13524798f, 0.21007062f, -0.18133868f, -0.05573374f, 0.13354497f, 0.27845916f, 
    -0.02843069f, -0.02810401f, -0.33323786f, 0.07669811f, 0.02806306f, 0.11731331f, 0.01832639f, 0.13164511f, 
    0.10192376f, -0.23600480f, 0.05611141f, -0.03246691f, 0.02322763f, 0.27871218f, 0.17510051f, 0.04750037f, 
    -0.02849274f, 0.03537743f, -0.22071765f, 0.31227508f, 0.10561552f, 0.01545826f, -0.25354105f, -0.10552759f, 
    -0.14795953f, -0.19424878f, 0.30744687f, 0.00327886f, 0.23725748f, 0.09017536f, 0.03596843f, -0.14983641f, 
    0.04008452f, 0.03412152f, -0.27696866f, 0.08994378f, -0.16683418f, 0.09210794f, -0.04231654f, 0.01641098f, 
    0.12194669f, 0.00640190f, -0.77220505f, 0.03597606f, 0.17864035f, -0.32965291f, -0.18876319f, 0.28213748f, 
    -0.34709615f, -0.50435895f, 0.33704451f, 0.04900424f, -0.78092450f, -0.34639019f, -0.04344815f, 0.00154037f, 
    -0.06898096f, -0.21953955f, -0.02719729f, 0.14406545f, -0.04867144f, 0.14997552f, 0.11323828f, 0.07159186f, 
    -0.19691610f, 0.18354571f, -0.49402845f, -0.03868465f, 0.00161023f, 0.26627740f, 0.26044652f, -0.86382329f, 
    -0.61254811f, 0.40722120f, 0.25588980f, -0.23937753f, -0.13576445f, 0.04390571f, 0.09763391f, -0.16863157f, 
    -0.13396899f, -0.21961427f, -0.15427418f, -0.11449055f, -0.40162459f, 0.10970409f, -0.01865449f, -0.01976607f, 
    -0.01095052f, -0.06817041f, -0.48767543f, -0.24671216f, -0.16971363f, 0.08208460f, 0.17355911f, 0.12136479f, 
    -0.06250263f, -0.10286193f, -0.16385004f, 0.07929308f, 0.02019026f, 0.04627739f, 0.05250070f, 0.15757926f, 
    0.10167858f, -0.00206259f, 0.12581255f, -0.07150781f, -0.24043813f, 0.17253394f, -0.20364247f, 0.32244787f, 
    0.25596872f, -0.06310363f, 0.04665459f, -0.00575323f, 0.20911740f, -0.02524562f, 0.05914570f, 0.06689902f, 
    -0.04036509f, -0.18462218f, 0.21766293f, -0.19344001f, -0.71061707f, -0.17774904f, 0.00284418f, -0.22993042f, 
    -0.10464431f, 0.06809213f, 0.11609060f, 0.03069265f, 0.02361634f, -0.42865050f, 0.03642438f, 0.10406192f, 
    0.09745588f, -0.08265506f, -0.13682280f, -0.30147445f, 0.05900160f, -0.03157070f, -0.38988590f, 0.21573916f, 
    -0.16309056f, -0.13064866f, 0.19392025f, -0.82097590f, -0.45121711f, 0.66727358f, -0.06381089f, 0.21064927f, 
    0.17378820f, 0.57777780f, -0.03861397f, 0.12949213f, 0.16274679f, 0.16584332f, 0.00969370f, 0.11244600f, 
    0.15049841f, -0.16130129f, 0.04976122f, 0.14789014f, -0.41825277f, 0.29111326f, -0.03381990f, -0.09028058f, 
    -0.24272963f, 0.06010661f, -0.17083974f, 0.02672614f, -0.56855571f, -0.54455644f, -0.83571607f, -0.48826760f, 
    0.27482215f, -1.97915375f, 0.06634489f, 0.18483514f, -0.55939060f, 0.01488925f, -0.03332502f, 0.01775768f, 
    -0.00152362f, 0.26700488f, 0.05647621f, -0.09719273f, -0.01177307f, -0.17959094f, 0.02294979f, -0.01821185f, 
    0.11131813f, 0.50099814f, -0.91437298f, -0.00575678f, 0.06888042f, 0.09695224f, -0.88486791f, 0.44665965f, 
    0.43604431f, 0.42351606f, 0.02101092f, 0.20167926f, -0.04991097f, -0.57231939f, 0.01824440f, 0.01241679f, 
    -0.06247137f, 0.30424085f, 0.14987603f, 0.16709490f, -0.16769835f, -0.55914581f, 0.03830233f, 0.03625763f, 
    0.21361344f, -0.20684969f, 0.80452895f, -0.30134672f, 0.08530117f, 0.04880136f, 0.04076413f, -0.36769742f, 
    -0.06714895f, -0.74445504f, -0.08796429f, 0.19789235f, 0.12682524f, 0.15239370f, 0.12095091f, -0.06992609f, 
    -0.07551055f, -0.03616249f, -0.03176408f, 0.48472795f, 0.23336537f, 0.05679327f, -0.06746849f, 0.55011737f, 
    -0.54064375f, 0.19769412f, -0.05051186f, -0.09154058f, -0.56213874f, 0.06876511f, 0.05646820f, 0.06112026f, 
    -0.37554070f, -0.09214074f, 0.20012213f, -0.63655651f, -0.02853307f, 0.00135160f, 0.02619108f, 0.11852839f, 
    -0.04665329f, 0.32236803f, 0.18712315f, 0.10514537f, -0.05804486f, -0.07015201f, 0.16769378f, -0.13274792f, 
    0.13537566f, -0.14467852f, 0.29682988f, -0.17347693f, 0.03029033f, -0.60663581f, -0.46406984f, 0.37032777f, 
    0.17197064f, -0.46896943f, 0.25172850f, -0.32319352f, -0.65904790f, -0.52579719f, -0.02422539f, 0.05530006f, 
    0.25482506f, -1.07647347f, 0.08818734f, 0.19359277f, 0.01341152f, -0.56154400f, 0.07398108f, -0.05077172f, 
    0.20119835f, 0.05219914f, -0.12862392f, -0.17696033f, -0.37617254f, 0.39227483f, 0.06745458f, -0.01967754f, 
    0.35544363f, -0.05623855f, -0.17180343f, -0.02039019f, -0.20589030f, -0.26553854f, -0.26124054f, -0.19128287f, 
    0.08078403f, 0.40137920f, -0.68904257f, -0.09040283f, 0.64263177f, -0.14028873f, -0.38915664f, 0.05442548f, 
    -0.00186558f, 0.07772481f, 0.17329954f, 0.26183552f, -0.24080575f, 0.26956010f, 0.16842930f, 0.11314003f, 
    -0.02415959f, -0.35151780f, -0.39477345f, -0.02203299f, 0.16502476f, -0.38975507f, -0.21061617f, 0.41820502f, 
    0.05285386f, -0.33090115f, -0.83538514f, -0.19040379f, -0.35221922f, 0.08660109f, -0.15870744f, -0.33740038f, 
    -0.08854849f, -0.01580151f, 0.07773863f, -0.05959383f, -0.02651174f, -0.52333438f, -0.57907146f, -0.10197068f, 
    0.19594671f, -0.27788788f, -0.87302268f, -0.37973824f, -0.00495426f, -0.09882585f, 0.08899885f, 0.28934157f, 
    -0.18677254f, -0.26910049f, 0.12137862f, 0.11318669f, -0.43395898f, 0.04840946f, 0.20982751f, -0.18632588f, 
    0.01928248f, -0.00688632f, 0.14348598f, -0.41959977f, 0.12594861f, 0.12027582f, 0.19807796f, -1.14408195f, 
    0.22228749f, 0.03908703f, 0.03438508f, 0.33195338f, 0.23864694f, 0.07196655f, 0.17902736f, -0.03943427f, 
    -0.32638726f, -0.49542153f, -0.35104951f, 0.16149181f, -0.66195071f, -0.53905690f, -0.01717401f, 0.40650287f, 
    -0.03624621f, -0.02408925f, -0.45921656f, 0.04347562f, -0.26873881f, 0.32150450f, -0.29998904f, -0.54375374f, 
    -0.00682796f, 0.32094648f, 0.07808431f, -0.05924042f, 0.01522711f, 0.35213342f, 0.18001592f, -0.71578932f, 
    0.06471325f, 0.16491939f, -0.17000997f, 0.49887267f, 0.24440132f, 0.32563969f, -0.05114577f, -0.32838252f, 
    0.35404906f, 0.45026734f, 0.30937707f, -0.17817311f, -0.08267874f, -0.03612984f, -0.77200371f, 0.12905723f, 
    -0.89034951f, -0.66852063f, -0.77647191f, -0.27465025f, 0.31691834f, -0.02040384f, 0.08100131f, 0.34032148f, 
    -0.30869386f, -0.19292748f, 0.03510371f, 0.04778710f, -0.07172272f, -0.09974342f, 0.01497103f, 0.37787610f, 
    0.28793424f, -1.12924945f, -0.10778940f, 0.01782097f, 0.06121320f, 0.06324454f, 0.07365832f, -0.53189850f, 
    -0.38505760f, -0.18188694f, -0.19096358f, -0.23314023f, -0.66791582f, -0.19265662f, -0.73277754f, -0.25825530f, 
    0.03737538f, 0.32642987f, 0.01916254f, 0.02322775f, -0.70833802f, 0.03742334f, -0.39622152f, 0.18827716f, 
    0.30987480f, 0.23879527f, -0.12232666f, 0.06861456f, 0.08859985f, 0.15405829f, -0.45969000f, -0.34490022f, 
    -0.15314980f, 0.09501731f, -0.21114440f, -0.30122128f, 0.05393036f, 0.19607535f, 0.51540500f, 0.08810637f, 
    -0.61371642f, 0.30361924f, 0.04324901f, 0.00885201f, -0.29552329f, 0.12618332f, 0.10884301f, 0.01680081f, 
    0.22809632f, 0.13792297f, 0.12666923f, -0.16947109f, 0.09353326f, -0.85924190f, -0.72114027f, 0.22329187f, 
    -0.20356923f, 0.06926835f, 0.02319268f, -0.30024597f, 0.45391405f, -0.77340430f, -0.05276228f, -0.54815805f, 
    -0.48311129f, -0.03211727f, -0.00979568f, -0.42522934f, 0.40284881f, -0.34345371f, -0.41028464f, -0.07521442f, 
    0.26648727f, 0.04062631f, 0.02875771f, -0.07299551f, 0.09191300f, 0.20483245f, -0.03504515f, -0.26740885f, 
    -0.08911134f, -0.02998707f, -0.05886682f, -0.46934944f, 0.11157704f, 0.30132625f, 0.02077106f, -0.24338059f, 
    -0.54566014f, -0.16849214f, 0.20259489f, 0.14382213f, 0.05795674f, -0.94873768f, -0.15628420f, -0.56884116f, 
    0.19619784f, -0.01052855f, 0.17611235f, -0.67007756f, -0.37674502f, -0.53485084f, -0.11277819f, 0.11777446f, 
    -0.55107874f, -0.30126032f, -0.92930782f, -0.08791592f, 0.03392800f, 0.24341448f, 0.00444151f, 0.24328765f, 
    -0.19651683f, -0.33095649f, -0.17489821f, -0.10332827f, 0.22583847f, -0.26837707f, 0.02484985f, 0.41369787f, 
    -0.21950512f, -1.08533478f, 0.08047634f, -0.00986626f, -0.44899788f, -0.25687626f, 0.09690067f, 0.01616878f, 
    0.20400716f, 0.45759687f, 0.29628542f, -0.21341239f, 0.19476801f, 0.14160588f, 0.37088746f, -0.10237607f, 
    0.07183181f, 0.32992586f, -0.14389019f, -0.31188932f, 0.23775913f, -0.60797626f, -0.00847411f, -0.87714815f, 
    0.15301585f, -0.70126009f, 0.09070373f, 0.01898393f, -0.23704457f, 0.06032143f, 0.21265456f, 0.07921821f, 
    -0.28332946f, -0.60382897f, 0.32720301f, 0.21706881f, 0.18636799f, -0.27154619f, 0.03670239f, -0.08146688f, 
    0.26657790f, 0.16528080f, 0.14520247f, 0.22742976f, -0.15328480f, -0.33907011f, 0.10427049f, 0.05802458f, 
    0.04590280f, 0.27853665f, -0.17665195f, -0.33745947f, 0.29421017f, -0.23861247f, -0.40187755f, -0.00453322f, 
    -0.26045123f, -0.07428667f, -0.18087524f, -0.03488281f, 0.05307097f, -0.18088035f, -0.32487434f, -0.18481569f, 
    -0.67033160f, -0.00526292f, -0.59664118f, 0.21542194f, -0.20002761f, -0.33501056f, -0.82486349f, 0.18364571f, 
    -0.11608081f, -0.04001512f, 0.02957168f, -0.25295398f, -0.39889768f, 0.02501120f, -0.80763245f, -0.04272005f, 
    -0.65292329f, 0.19908628f, 0.14375022f, 0.07482988f, -0.16122708f, 0.07372008f, 0.07708970f, 0.08109513f, 
    0.00638940f, 0.07790223f, 0.00748808f, 0.13385502f, -0.03405128f, 0.07431943f, 0.13618517f, -0.36774358f, 
    0.05115284f, -0.15294451f, 0.06894825f, -0.12573113f, 0.00617869f, 0.08703950f, 0.07332377f, -0.72889853f, 
    0.15809166f, -0.19386604f, 0.22227797f, 0.14758912f, 0.11649763f, -0.75930059f, -0.55271798f, -0.12584238f, 
    -0.22935140f, 0.67129534f, 0.20896946f, 0.07407969f, -0.25499621f, 0.20828946f, 0.00607226f, -0.03016515f, 
    0.12726189f, -0.27891916f, -1.57121670f, 0.23597242f, 0.02774041f, 0.02415622f, 0.02897126f, 0.05705465f, 
    -0.09559175f, -0.82991260f, 0.30976897f, -0.06701921f, -0.37315974f, -0.20802233f, 0.15088658f, -0.22293751f, 
    -0.29148066f, 0.18278687f, -0.63721651f, 0.14059533f, -1.13478816f, 0.23198663f, 0.17766643f, 0.14225215f, 
    0.06340762f, 0.19920465f, 0.16750591f, 0.13363481f, -0.00267341f, -0.22121124f, 0.18494472f, -0.02542819f, 
    0.14302699f, 0.40408903f, -0.56703335f, -0.02317272f, -0.02178402f, -0.01730904f, -0.22794339f, -0.33510008f, 
    -0.00706678f, -0.04740166f, -0.43436068f, 0.05432591f, -0.08300875f, 0.05108240f, 0.28807774f, -0.79206377f, 
    0.16175449f, 0.10405657f, 0.10168244f, 0.07349639f, -0.12527555f, -0.04470176f, -0.22138563f, 0.05875561f, 
    -0.13008292f, 0.19977501f, -0.44598600f, -0.23044376f, 0.02673924f, 0.04627329f, 0.12559009f, 0.05644366f, 
    -0.23524578f, 0.22694714f, -0.09950033f, 0.15095510f, 0.03920158f, -0.02011534f, 0.09567264f, 0.16483636f, 
    -0.18099216f, 0.06309915f, 0.08962910f, -0.24076469f, -0.27649650f, -0.18319896f, 0.13592483f, 0.16980934f, 
    0.08227526f, 0.02408288f, 0.07720415f, -0.08310802f, 0.04195793f, -0.05354411f, 0.26140764f, -0.00916314f, 
    0.18420130f, 0.22506523f, -0.32505468f, 0.16307220f, -0.11435362f, 0.21504147f, -0.23631218f, -0.42555514f, 
    -0.06747738f, -0.23409924f, 0.15404403f, -0.14968848f, -0.05302958f, -0.12041720f, -0.40171576f, 0.32567406f, 
    -0.13987246f, -0.22425124f, -0.20076331f, 0.09411418f, 0.03591665f, -0.01830464f, 0.08727545f, 0.02372116f, 
    -0.01965124f, 0.06834562f, -0.27197206f, -0.10175329f, 0.14175342f, -0.38465819f, 0.12422713f, 0.31210929f, 
    -0.20868073f, -0.74037713f, -0.02751171f, -0.52356613f, -0.20452003f, -0.53970909f, -0.42173639f, -0.62498504f, 
    -0.12024507f, -0.04926240f, 0.21754766f, 0.26744011f, -0.81596482f, -0.27093786f, -0.02843081f, -1.14541960f, 
    -0.30140242f, 0.15083201f, 0.02124960f, 0.02006516f, -0.17447197f, 0.11140259f, 0.22324786f, -0.29592374f, 
    -0.81651795f, -0.12739372f, 0.24168804f, -0.32893860f, -0.29895121f, -0.12227956f, 0.05650382f, 0.25245589f, 
    0.25169158f, -0.15962611f, -0.54573220f, -0.21801926f, 0.12720188f, 0.06459326f, -0.93225980f, -0.24953316f, 
    0.17777455f, 0.36190870f, 0.48665676f, 0.02478239f, 0.11051044f, -0.42272788f, -0.10697389f, 0.43888998f, 
    -0.38380289f, -0.15573379f, 0.23298612f, -0.08063634f, 0.11500968f, 0.03786786f, 0.08343086f, 0.38657326f, 
    0.26228338f, -0.42243791f, -0.17573422f, 0.24483827f, 0.12957188f, 0.21699688f, -1.32572496f, -0.05239283f, 
    -0.36016840f, 0.27451110f, 0.38356373f, 0.36422610f, 0.09260070f, 0.10912815f, 0.11261115f, -0.25134581f, 
    0.13989380f, 0.16553020f, 0.10641883f, -0.24665092f, 0.21540678f, 0.01050200f, -0.00387149f, -0.39223689f, 
    0.13471606f, -0.02657593f, -0.29265559f, 0.21247280f, -0.32408512f, 0.02681006f, 0.11659364f, -0.51077956f, 
    0.10550505f, -0.09709210f, 0.03164514f, -0.25316402f, -0.51847571f, -0.16876507f, -0.59485859f, -0.04663661f, 
    0.06068908f, 0.15270583f, -0.16139658f, -0.22295584f, 0.49914950f, 0.20884454f, -0.16246970f, -0.40799674f, 
    -0.07826285f, -0.10100429f, 0.08403232f, 0.13817371f, 0.12670222f, -0.21759754f, 0.05904185f, 0.18902469f, 
    -0.09635274f, -0.32609600f, -0.20282760f, 0.31241247f, 0.01070586f, -0.46796530f, 0.15630673f, 0.08288281f, 
    -0.28546286f, -0.05987600f, 0.05717985f, -0.86659575f, -0.26387000f, -0.28022355f, 0.03792706f, -0.07159010f, 
    0.14035830f, -0.96370381f, -0.52064389f, -0.14354470f, -0.33575106f, -0.52777189f, 0.09485501f, -0.37361386f, 
    0.09585325f, 0.42969662f, 0.37772250f, -0.16825102f, -0.09264275f, -0.16764668f, 0.07031149f, -0.29730949f, 
    0.36979201f, 0.16229703f, -1.72038794f, 0.04965311f, -0.23251767f, 0.48190698f, -0.05250671f, -0.11234083f, 
    -0.36551073f, 0.01795688f, -0.31694210f, -0.05320473f, 0.22372302f, -0.36029714f, -0.35548508f, -0.12336705f, 
    0.13824111f, -0.04437786f, 0.20398733f, 0.18740790f, 0.35639113f, 0.16527402f, -0.10643346f, 0.02667296f, 
    -0.37722760f, 0.28914985f, -0.23408361f, -0.03134799f, 0.20728113f, -0.42761621f, -0.12421652f, 0.04414894f, 
    -0.13443731f, -0.73625845f, -0.14067881f, 0.30088609f, 0.09950382f, -0.01224013f, -0.14052033f, 0.22104448f, 
    -0.57304716f, -0.36329725f, -0.13790509f, -0.24530780f, -0.27108932f, -0.07776316f, 0.12289524f, -0.05078331f, 
    0.21254027f, -0.12558375f, 0.16478898f, 0.12870458f, -0.00316662f, -0.29395550f, -0.14112349f, 0.23329961f, 
    -0.20762268f, -0.00261464f, -0.32240358f, -0.17376152f, -0.18339854f, 0.12687306f, 0.16774730f, -0.67208344f, 
    0.06118399f, 0.06173498f, 0.02149167f, 0.28724790f, -0.86430401f, 0.07877160f, 0.07950330f, -0.04249832f, 
    0.46684569f, -0.16313165f, 0.02601442f, 0.19545522f, -0.32160053f, 0.22652782f, -0.30941147f, -0.08755121f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.15881607f, -0.05160617f, -0.17781737f, 0.02388461f, 0.15630417f, 0.03134556f, -0.06805558f, -0.36198997f, 
    -0.14205867f, 0.05402745f, 0.10734344f, -0.11504890f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
