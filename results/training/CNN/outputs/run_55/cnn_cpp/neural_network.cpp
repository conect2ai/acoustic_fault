#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.56325895f, -0.93758810f, 1.39213121f, 0.05361231f, -0.42359605f, 0.67126811f, -0.14634120f, 0.81428939f, 
    -0.15697093f, -0.52379990f, -0.06230821f, -0.30694404f, -0.41708335f, -0.24263509f, -0.26336032f, 0.00751543f, 
    0.22562651f, -0.08824736f, -0.37175822f, 0.05634405f, -0.25208884f, 0.15532528f, 0.26815540f, -0.16256975f, 
    -0.35469526f, -0.68976617f, 0.27136385f, -1.32138395f, -0.53720486f, 0.25221637f, -0.91919786f, 0.60543638f, 
    0.45347226f, -0.48792189f, -0.03191966f, 0.96905607f, -0.18208861f, -0.06657258f, -0.33796722f, 0.35950479f, 
    -0.01456905f, 0.30180418f, 0.04686120f, 0.26024494f, -0.01674202f, 0.19925998f, 0.04909644f, -0.00153642f, 
    -0.05226885f, 0.06910365f, 0.52441502f, -0.29838187f, 0.25277042f, -0.05600003f, 0.58472103f, -1.20317817f, 
    -0.80637479f, -0.17521918f, -0.57066548f, -0.76145983f, 0.30355197f, 0.65753639f, -0.13513452f, 0.43612239f, 
    -0.05827619f, -0.39464235f, -0.11037073f, -0.28985831f, 0.09799962f, 0.28369680f, -0.05762570f, 0.23263022f, 
    0.16934840f, 0.06604274f, -0.36042103f, -0.95389670f, -0.28550941f, -0.58984375f, -0.50330544f, -0.79009098f, 
    0.43392628f, -0.14551158f, -0.43457320f, -0.19105814f, 0.58033973f, 0.21014690f, -0.51147056f, 0.17908281f, 
    0.22133598f, 0.16659483f, -0.18465857f, 0.06896830f, -0.07183864f, -0.17093657f, 0.44692564f, -0.23311180f, 
    0.24732548f, -0.03319934f, -0.05912338f, 0.29078898f, 0.11927479f, 0.71896780f, 0.49106610f, -0.39292926f, 
    -0.70931685f, -0.40800399f, -0.30074561f, -0.91185522f, -0.96744847f, -0.54856163f, 0.01937004f, 0.61629987f, 
    -0.10047188f, -0.08616924f, 0.14222120f, 0.00830803f, -0.10234518f, -0.27473801f, 0.17013182f, -0.10237599f, 
    0.27344844f, 0.02949697f, 0.12190237f, 0.00299704f, 0.49600813f, 0.04033254f, -0.93262047f, -0.70922154f, 
    -0.49619326f, -0.16574925f, -0.03320140f, -0.57482898f, -0.61416757f, 0.14702098f, 0.25582471f, 0.08976596f, 
    0.24551415f, 0.06327973f, 0.23146494f, 0.41869542f, -0.03253235f, -0.06719194f, 0.26479346f, 0.19753800f, 
    0.18597350f, 0.50376439f, 0.35097045f, -0.40524215f, 0.66364151f, -0.37795362f, -0.69998908f, -0.39973265f, 
    -0.91578412f, -0.84834313f, -0.46704900f, 0.06961866f, -0.51985568f, -0.09216136f, 0.28473604f, 0.10761068f, 
    -0.76913810f, -0.07455841f, -0.36984733f, -0.36139908f, -0.80372381f, -0.08380620f, -0.06361404f, 0.30766767f, 
    -0.19637959f, 0.14899945f, -0.16644777f, 0.05449574f, -0.46769622f, -0.11817779f, 0.10113133f, 0.52195364f, 
    0.59157062f, 0.92921442f, 1.13694549f, -0.19046812f, 0.32429385f, -0.24040101f, 0.20177373f, -0.66288048f, 
    0.08483907f, -0.59206182f, -0.49682051f, -0.46156073f, -0.16042395f, 0.45541328f, 0.01387834f, -0.07423947f, 
    0.02320841f, -0.01227000f, 0.17257659f, 0.54062521f, -0.17069115f, 0.08465420f, 0.49946380f, 0.05058952f, 
    0.87043089f, 0.56657904f, 1.14778733f, 0.87047356f, 0.71777326f, 0.58425140f, -0.27575395f, -0.17163967f, 
    -0.31934667f, 0.00856362f, 0.38828290f, 0.52002031f, -0.01222499f, 0.02669416f, -0.25559485f, -0.12839203f, 
    0.18888000f, 0.61751974f, 0.08811715f, -0.15303220f, -0.05922199f, -0.00089122f, -0.10363081f, -0.01716143f, 
    0.39191872f, -1.03132677f, -0.10726018f, -0.05698607f, 0.30027199f, 0.32857072f, -1.08504677f, 0.06060072f, 
    0.75978822f, -0.58799583f, 0.35325411f, 0.40500745f, 0.05260801f, 0.40299115f, -0.03228844f, 0.38920698f, 
    0.27813986f, 0.45754170f, 0.66250587f, 0.22096948f, -0.31013677f, -0.07501369f, -0.03048463f, -0.26472795f, 
    0.03741969f, 0.17402615f, -0.79842836f, -1.29961967f, 0.45039871f, 1.12325239f, 0.32666668f, 0.56780553f, 
    1.27986085f, 0.39245594f, 0.29534540f, -0.16888371f, -0.45064148f, 0.11199834f, 0.18578155f, 0.43438658f, 
    -0.06908167f, -0.30441421f, -0.12530930f, -0.02047120f, -0.03717960f, -0.16825020f, 0.16092782f, 0.15208948f, 
    -0.15054630f, 0.08054809f, -0.09181859f, 0.82595772f, 0.76303846f, 0.97677749f, -0.01456148f, 0.77213925f, 
    0.68879545f, 0.62086791f, 0.68038553f, 0.24115911f, 0.28052860f, -0.58217877f, -0.43360636f, -0.47785383f, 
    -0.46296293f, 0.14697418f, -0.04305454f, 0.06961100f, -0.27114293f, 0.17754252f, 0.06340834f, -0.14631934f, 
    -0.24035524f, 0.12628467f, -0.16408277f, -0.04083655f, 1.12040257f, -0.15924972f, -1.12880754f, -1.22281921f, 
    -0.45466340f, 0.47300997f, 0.09100104f, 0.50698149f, 0.58604133f, 0.23852886f, -0.33319834f, 0.08915686f, 
    -0.49687564f, 0.06547216f, -0.01201118f, -0.12449906f, -0.08746686f, -0.42676809f, 0.26983714f, 0.10545863f, 
    -0.16032098f, 0.18361764f, -0.17665485f, 0.01379484f, 0.08980929f, -0.22796038f, 0.25217131f, 0.03963514f, 
    0.73634773f, -0.35944411f, -0.79924184f, -0.83097106f, 0.26831034f, -0.04538734f, 0.15486501f, 0.02422969f, 
    -0.11448506f, 0.31655684f, -0.13306436f, -0.55838835f, 0.14758658f, 0.45884946f, -0.00390152f, 0.28467071f, 
    0.12204153f, -0.05045110f, -0.19055884f, 0.05335908f, -0.43988991f, -0.62139881f, -0.44177404f, -0.67692626f, 
    -0.00800813f, 0.41586435f, -0.19946919f, -0.74815899f, 0.18622130f, -0.66770416f, -0.22206806f, -0.29656914f, 
    -0.16570443f, 0.54874331f, 0.50966787f, 0.37994555f, -0.41441268f, -0.42168590f, -0.22794738f, 0.55390757f, 
    0.27342853f, -0.49685192f, -0.07148592f, 0.07696864f, -0.07660614f, -0.05401658f, -0.07887183f, 0.96055424f, 
    0.18854746f, 0.42536849f, 1.11455107f, 1.07780457f, 0.65127486f, 0.50376260f, -0.00774721f, -0.72390968f, 
    0.45853373f, -0.07765169f, -0.09047016f, 0.13014136f, 0.47936666f, -0.11773621f, -0.21703671f, -0.30556363f, 
    0.01304759f, 0.02891915f, -0.33613041f, 0.15691271f, 0.23648760f, 0.06178778f, -0.30801517f, -0.19429150f, 
    -0.81013173f, -0.67165154f, -0.72954905f, 0.26868203f, -0.01727509f, -0.03651981f, -0.60486174f, -0.46178180f, 
    -0.51427424f, -0.55587411f, 0.20799902f, 0.46804485f, 0.12991390f, -0.06005507f, 0.35878438f, 0.26708931f, 
    0.37788567f, -0.27567631f, -0.69059139f, 0.18781970f, -0.19272931f, -0.06136604f, 0.58134168f, -0.14846373f, 
    -0.15199538f, -0.86246574f, -0.43423545f, -0.82716316f, -0.71355623f, -0.52623361f, 0.35618168f, 1.26881289f, 
    0.41107729f, -0.06572585f, 0.47526741f, -0.07807345f, -0.31063682f, 0.11986995f, -0.52822477f, 0.22652963f, 
    0.04815632f, 0.20328839f, 0.02385294f, 0.12570480f, -0.21372788f, -0.27049157f, -0.35212699f, 0.01167621f, 
    -0.32296970f, 0.13385184f, -0.60919130f, -0.64964831f, -0.54160941f, -0.01847696f, -0.11453549f, 0.80870056f, 
    0.94375515f, 0.46989685f, -0.08819182f, 0.87855631f, -0.08048730f, -0.39915019f, -0.45811048f, -0.26427859f, 
    -0.39393944f, -0.46719149f, -0.21898358f, 0.06232285f, -0.29420173f, -0.06793816f, -0.13100243f, -0.29795122f, 
    0.27946466f, 0.01929980f, 0.17082189f, 0.28925988f, 0.73721761f, 0.77998298f, 0.52698749f, 0.79898524f, 
    0.01254014f, -0.84304965f, -0.65536195f, -0.20840785f, -0.36879173f, 0.61035067f, 0.18288124f, 0.01031375f, 
    0.35989931f, -0.12264802f, 0.50019079f, -0.11320531f, 0.10031946f, -0.34249583f, 0.54822427f, -0.22607599f, 
    0.15739527f, 0.43340504f, -0.41510126f, -0.16684283f, -0.27575430f, -0.19712186f, -0.81404400f, 1.47305787f, 
    1.23142171f, 0.57008117f, 0.46115223f, -0.27384534f, 0.71370840f, 0.08257329f, -0.04157438f, -0.15219459f, 
    -0.46698809f, 0.02890682f, -0.16176058f, -0.04898547f, 0.11431088f, 0.04392533f, -0.04464642f, -0.20529515f, 
    -0.09848782f, -0.14199112f, -0.25791654f, -0.19348055f, -0.18915252f, 0.21339792f, -0.40280843f, -1.18264318f, 
    -0.56195170f, 0.24164517f, -0.44097605f, -0.04956072f, -0.23349822f, 0.31592917f, 0.60295570f, 0.02014386f, 
    -0.52579910f, 0.48776883f, -0.20196794f, -0.05606892f, -0.27430290f, 0.40300262f, -0.24853823f, -0.31142157f, 
    -0.20215195f, -0.12504424f, -0.22031236f, 0.24568304f, 0.14443184f, 0.08336702f, 1.25183022f, 0.73198742f, 
    0.43383023f, -0.20700948f, 0.08280709f, -0.76270479f, -0.03632715f, -0.26238811f, 0.51785052f, 0.73699200f, 
    0.06730962f, 0.09305411f, -0.15419020f, -0.23045397f, -0.17831914f, -0.08428058f, -0.13734892f, 0.19245809f, 
    0.07614549f, 0.17064041f, 0.32491282f, 0.11036380f, -0.03710619f, 0.33361760f, 0.40829787f, -0.19294776f, 
    0.97587186f, -1.17661119f, -0.18766384f, -0.41621730f, 0.83932990f, -0.28760239f, -1.13652086f, -0.52928549f, 
    -0.73262179f, -0.10137729f, 0.34625939f, -0.24644992f, 0.11837116f, 0.04075009f, -0.15796146f, 0.00932517f, 
    0.02018997f, -0.26819462f, -0.30348855f, 0.11281889f, -0.36907035f, 0.24210888f, -0.17810544f, 0.12287261f, 
    0.69570124f, -0.37866026f, 0.20143124f, 1.29878080f, 0.10789328f, -0.32522860f, -0.91832787f, -0.50930977f, 
    1.03143358f, 0.17681026f, -0.43789956f, -0.26134765f, -0.40247184f, 0.28811684f, -0.29292426f, -0.20143424f, 
    0.01734140f, 0.23153369f, -0.03393896f, -0.01987614f, 0.56369346f, 0.48306093f, -0.12273082f, 0.07180560f, 
    -0.05877339f, -0.04000177f, 0.92096227f, 0.86287391f, 0.80360502f, -0.62830752f, -1.47919142f, 0.57218289f, 
    -0.40313020f, -0.10118709f, -0.08148274f, 0.55088824f, 0.01279143f, -0.67170757f, -0.00401142f, 0.15995610f, 
    0.03041369f, 0.15136585f, 0.17086481f, -0.19997458f, -0.32824761f, -0.33366555f, -0.04274694f, 0.32458475f, 
    -0.03677633f, -0.32892159f, 0.63003522f, 0.74219978f, 0.11640108f, -0.90302610f, -0.68616557f, 0.27186558f, 
    -0.72547448f, -0.17407005f, -0.13212481f, 0.02655423f, 0.48562101f, 0.47348627f, 0.38518494f, 0.41543704f, 
    0.16435072f, 0.31002840f, 0.30794740f, 0.59922034f, 0.27394831f, -0.49621290f, -0.14539848f, 0.13578337f, 
    0.19973949f, -0.27958643f, -0.03792409f, 0.58020514f, 0.43910170f, 0.69338429f, -0.23142375f, -0.70639062f, 
    0.52004755f, 0.22527453f, 0.21087910f, 0.24652648f, 0.57001406f, 0.63948423f, 0.48237032f, 0.03924865f, 
    0.56213319f, 0.61022401f, 0.08315939f, -0.37069827f, -0.24921690f, -0.15054365f, 0.07957663f, 0.36354852f, 
    0.36983296f, 0.08037139f, -0.04401249f, 0.31677541f, 1.66736794f, 0.83262092f, -1.16698599f, 0.67802441f, 
    0.35830921f, -0.12393952f, 0.32554057f, -0.42143232f, 0.42453122f, -0.13979734f, -0.08908332f, 0.08572474f, 
    0.39412296f, 0.17615706f, -0.01994162f, 0.17782386f, -0.33954564f, -0.16424686f, -0.35395247f, 0.07298993f, 
    -0.17837313f, 0.07242936f, -0.05009435f, 0.10433678f, 0.17127441f, -0.80418664f, 0.10968713f, -0.19467656f, 
    -0.81461293f, -0.65547192f, 0.61673218f, -0.30435926f, 0.17281547f, 0.62827551f, 0.47543526f, 0.38962418f, 
    0.25685236f, -0.12677430f, 0.02213555f, -0.26491794f, 0.11041734f, 0.38357365f, 0.28177375f, 0.11541031f, 
    0.45359588f, 0.38682929f, 0.04452161f, 0.23361127f, 0.09241814f, -0.02453917f, 1.16504943f, 0.21334295f, 
    -0.96093529f, 0.41498831f, -0.85638475f, -0.56549799f, 0.05141653f, 0.73479801f, -0.20505105f, -0.14644761f, 
    0.17647476f, -0.46783552f, 0.59484547f, -0.54955637f, 0.48835722f, 0.07334244f, -0.43848079f, 0.02364925f, 
    -0.36534965f, -0.09785929f, 0.28694630f, 0.03589952f, 0.00738334f, -0.09269857f, -0.39995632f, 0.53641343f, 
    -1.39254212f, -0.59304434f, 1.04649854f, 0.19437048f, -1.37431121f, 0.60013855f, 0.69355679f, -0.07818611f, 
    -0.29230371f, 0.10386985f, 0.01604421f, -0.29464179f, -0.05201134f, 0.13278431f, -0.59521186f, -0.07141192f, 
    -0.38990840f, -0.10275234f, -0.38061062f, 0.07007924f, -0.07881752f, -0.14453517f, 0.36525983f, 0.06288154f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07381378f, 0.42058927f, 0.26647550f, 0.10860637f, 0.11731750f, 0.31157461f, -0.07569111f, 0.12223524f, 
    0.11956891f, 0.26136744f, 0.20056063f, 0.17004037f, 0.36237735f, 0.21244752f, 0.04972076f, 0.16810414f, 
    0.07082662f, 0.26660964f, 0.08413835f, 0.10649031f, 0.23554599f, 0.32601658f, 0.09348156f, 0.45507029f, 
    0.22740875f, 0.23651487f, 0.13738923f, 0.01343381f, 0.39265165f, 0.31717151f, 0.11207224f, 0.07799280f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.41888729f, 0.05346971f, 0.29504672f, 0.18036498f, -0.08589841f, 0.00237871f, 0.10171431f, -0.11497568f, 
    -0.13925499f, 0.01348005f, 0.08148656f, -0.13699058f, -0.48922101f, 0.16963746f, 0.18709733f, 0.14152563f, 
    -0.09271920f, -0.09983609f, -0.01590596f, 0.00997969f, -0.09860366f, -0.10887747f, 0.01173033f, 0.05178565f, 
    0.35994068f, 0.07795081f, -0.04464101f, 0.00509221f, -0.02304618f, 0.02652137f, -0.02104704f, -0.06290983f, 
    -0.03805636f, -0.19671702f, -0.04023370f, -0.13280976f, 0.37185425f, -0.36922428f, -0.15073159f, -0.15495035f, 
    -0.00702693f, 0.04049233f, 0.04899447f, 0.05949496f, -0.16434897f, 0.00067613f, 0.02012107f, 0.17011733f, 
    -0.72610945f, 0.26795113f, 0.31055230f, -0.06723147f, 0.02441665f, 0.19281289f, 0.11852725f, 0.07486295f, 
    -0.13515042f, -0.12644942f, -0.04239558f, -0.03833241f, -0.11197470f, -0.55109775f, 0.08780618f, -0.23686221f, 
    0.04268712f, 0.08198370f, 0.18416676f, -0.09401149f, -0.11668292f, -0.21502766f, -0.03302881f, 0.04613053f, 
    0.00600953f, -0.22374868f, -0.15936840f, -0.18315952f, 0.09208619f, -0.12155445f, 0.10387677f, 0.05821019f, 
    -0.06543342f, -0.05761465f, -0.05213688f, -0.10142044f, 0.02414713f, 0.17721590f, -0.28605938f, 0.30355167f, 
    0.10222854f, -0.04554862f, 0.11975031f, -0.04151474f, -0.10803393f, -0.16212626f, -0.04734743f, -0.06043933f, 
    0.08574668f, -0.13830602f, -0.16122708f, 0.05693159f, -0.24053524f, -0.09916644f, 0.08001641f, 0.05667657f, 
    0.01667849f, 0.08238081f, -0.13289110f, 0.03723298f, -0.49625355f, 0.11463227f, -0.20841260f, 0.18011668f, 
    -0.07645952f, -0.14754525f, 0.01617768f, 0.02609440f, -0.05726906f, 0.06890438f, -0.09151205f, 0.09485930f, 
    -0.33709112f, 0.24002476f, -0.09127970f, 0.22145836f, -0.10140194f, 0.11230324f, 0.06993970f, 0.06436144f, 
    0.03858927f, -0.11025899f, -0.02671773f, 0.00417188f, 0.05665869f, -0.13088210f, 0.10345232f, -0.07439576f, 
    -0.17879285f, -0.06344806f, 0.03723942f, 0.08708645f, 0.03477913f, -0.01693247f, 0.02256331f, 0.06668252f, 
    0.33830541f, -0.19176151f, -0.02966164f, -0.76257908f, 0.04468604f, -0.24521936f, 0.11631557f, -0.19394666f, 
    -0.10920064f, 0.01593411f, 0.01851283f, 0.11243351f, 0.07612698f, 0.00295790f, -0.13817085f, 0.07181244f, 
    -0.08521825f, 0.16258936f, 0.02226430f, -0.00495736f, 0.10202538f, -0.02826452f, -0.04824678f, -0.09254314f, 
    -0.16152133f, -0.27232197f, -0.04596717f, 0.09098034f, -0.00292606f, -0.03753347f, 0.10162721f, 0.07643811f, 
    -0.02080672f, 0.14357685f, -0.30890480f, 0.07952131f, 0.29414833f, 0.05619682f, 0.07708794f, 0.19645193f, 
    -0.25490037f, -0.00265025f, -0.00045024f, -0.01152762f, -0.10534493f, 0.17312460f, -0.01369288f, -0.05326682f, 
    -0.30172789f, -0.42516068f, -0.06352251f, 0.26157925f, 0.06273069f, 0.07921353f, 0.03507243f, 0.03236667f, 
    0.02589720f, 0.04756644f, 0.11049205f, -0.11933843f, 0.43928584f, 0.27897805f, 0.29910263f, -0.43218911f, 
    0.12740794f, 0.06920137f, -0.08704434f, 0.09413542f, 0.11374562f, -0.03365488f, -0.09763829f, 0.09534267f, 
    0.16937394f, 0.20030718f, 0.17369823f, -0.12376840f, 0.18726851f, 0.02650079f, -0.03621149f, 0.11572988f, 
    -0.07960506f, 0.19123870f, -0.05719448f, 0.07343901f, 0.12271009f, -0.04182951f, -0.02841285f, -0.04052570f, 
    -0.18371791f, 0.11100277f, -0.17168084f, 0.09004601f, 0.21562719f, -0.02769850f, -0.16104653f, -0.05858755f, 
    -0.10012143f, 0.14412858f, 0.07512262f, 0.36555955f, -0.05167226f, 0.10585750f, 0.00191072f, -0.06868664f, 
    0.00867998f, -0.02087220f, -0.12328829f, -0.01792142f, -0.23281682f, -0.01322993f, 0.32576093f, -0.20130086f, 
    -0.07418491f, -0.01393640f, 0.05291411f, -0.11659474f, -0.07661752f, 0.12411981f, 0.09864380f, -0.09564721f, 
    0.22571591f, -0.12404875f, 0.00551695f, -0.05188362f, -0.05113783f, -0.20645881f, -0.04312689f, 0.14844577f, 
    0.11795427f, 0.06735019f, -0.01243769f, -0.13969831f, -0.01363723f, -0.07986635f, 0.12146939f, -0.24816714f, 
    -0.10074028f, -0.07329670f, 0.05610250f, -0.10493373f, -0.04340977f, -0.07123373f, 0.02233903f, -0.02583918f, 
    0.30903932f, -0.13568798f, -0.16951434f, 0.39408994f, 0.07602162f, 0.10567356f, -0.06884830f, -0.13731949f, 
    0.00236269f, 0.03765976f, 0.07214440f, 0.19378069f, -0.05059772f, 0.03965052f, -0.41840005f, 0.25972778f, 
    -0.11813831f, -0.10303281f, -0.00201169f, -0.09999810f, 0.02599030f, 0.06970899f, 0.12281169f, -0.07486305f, 
    -0.19015571f, 0.15000342f, 0.15901211f, -0.28280103f, -0.01445787f, 0.09339526f, 0.05137176f, -0.30588904f, 
    0.07642029f, 0.10952931f, -0.17223893f, -0.09275565f, -0.19834085f, -0.22506106f, -0.08995174f, -0.07116378f, 
    -0.10273716f, 0.17091796f, 0.01282474f, -0.13844757f, 0.19380040f, 0.00933842f, 0.17374963f, 0.28833842f, 
    0.09636112f, 0.09601205f, 0.01494345f, -0.01182003f, -0.36717361f, -0.09204302f, -0.00587288f, 0.22847226f, 
    0.03456923f, 0.09773760f, -0.01189448f, -0.18700629f, 0.25691697f, -0.19948195f, -0.33827037f, -0.24243620f, 
    0.00342160f, -0.03721111f, 0.00718747f, -0.05306507f, -0.16457377f, -0.05032551f, 0.00194030f, -0.11556695f, 
    -0.53579456f, -0.00671503f, 0.10549926f, -0.13173667f, -0.13368869f, -0.04081727f, -0.15319756f, -0.10889427f, 
    -0.06642408f, 0.09425335f, 0.19524862f, 0.12050490f, -0.11753928f, 0.17905895f, -0.23197593f, 0.38677439f, 
    -0.03917786f, 0.06502772f, -0.11259080f, -0.16432476f, 0.10236670f, -0.11011387f, 0.10231235f, 0.10395351f, 
    -0.55400085f, 0.09425434f, -0.19440737f, -0.00774383f, -0.12087482f, 0.11709734f, 0.01506605f, -0.14750616f, 
    0.05578877f, 0.11158420f, -0.13720873f, -0.11355945f, 0.61200821f, -0.02897588f, -0.44256407f, -0.28446263f, 
    0.05474355f, 0.23950811f, 0.00655655f, 0.09375653f, 0.14935938f, -0.08140635f, 0.11785737f, 0.05389666f, 
    -0.24480423f, -0.15606335f, 0.14124657f, 0.15039641f, 0.11798085f, -0.09216563f, 0.06957380f, 0.03590218f, 
    0.06532843f, 0.16219477f, -0.03971233f, 0.03254754f, -0.31078315f, 0.03843192f, 0.15935606f, 0.05363192f, 
    -0.00930263f, -0.04831669f, 0.10465068f, 0.11665330f, -0.05748081f, -0.06381472f, -0.02018195f, -0.05182675f, 
    -0.19963798f, -0.02749408f, -0.51569110f, -0.22479329f, 0.03875529f, -0.02678629f, 0.03753746f, 0.07130190f, 
    0.09458726f, 0.09506951f, 0.04223352f, 0.06342644f, 0.21951550f, -0.02438945f, 0.09166612f, 0.02924524f, 
    -0.15057179f, -0.03484913f, 0.02060685f, 0.06860540f, -0.06271859f, 0.12834746f, 0.02020932f, 0.18590236f, 
    -0.19965246f, 0.04386012f, 0.20743544f, -0.27828026f, 0.07671192f, 0.09546552f, 0.01520057f, -0.02588620f, 
    0.20286506f, -0.14887995f, 0.11752948f, -0.14027141f, 0.24221817f, 0.18429437f, -0.01305385f, 0.47717139f, 
    -0.30671355f, 0.04343578f, 0.09727485f, 0.06622636f, -0.00636826f, -0.01561949f, 0.07934028f, 0.15308611f, 
    0.19277188f, 0.07180996f, 0.20845899f, 0.26559308f, -0.24756934f, -0.05243199f, 0.01862214f, -0.00012423f, 
    -0.07002427f, -0.09753865f, 0.16886568f, -0.11303816f, 0.07923176f, 0.00601920f, -0.07312841f, 0.12196671f, 
    -0.01524745f, 0.00982235f, -0.26489344f, 0.11669886f, -0.12541604f, 0.02174998f, 0.14464995f, 0.06360693f, 
    0.31191665f, 0.00199684f, -0.18779846f, 0.17130627f, -0.08440893f, 0.03648201f, -0.08140604f, -0.10111676f, 
    -0.16454613f, 0.08564996f, -0.01528532f, -0.07568696f, 0.28521687f, 0.15846062f, 0.09120549f, 0.20171155f, 
    -0.01304047f, -0.02980430f, 0.03069589f, 0.02891281f, 0.00347610f, 0.04499207f, -0.08068192f, -0.13917868f, 
    0.32991302f, -0.61469322f, 0.14726670f, -0.44153985f, 0.14974937f, 0.00951668f, -0.02159561f, 0.02340872f, 
    -0.19321272f, 0.01406929f, 0.10894505f, -0.08255731f, -0.21016090f, -0.16365959f, -0.13249767f, -0.04724585f, 
    0.03407356f, -0.18912663f, -0.11568901f, -0.10853239f, -0.10953636f, -0.30294293f, -0.11506063f, 0.03470823f, 
    -0.14141266f, -0.18079466f, -0.21716943f, 0.02475347f, -0.19913904f, -0.15012029f, -0.25446999f, 0.01220238f, 
    0.19574571f, -0.21690297f, 0.09141023f, -0.07916610f, 0.16759112f, 0.09949650f, 0.07877352f, 0.21053378f, 
    -0.11002526f, 0.05697387f, 0.03630256f, 0.10936766f, -0.02531492f, -0.06004766f, -0.03076338f, -0.04675761f, 
    -0.00680042f, 0.17111820f, -0.05605035f, -0.04168145f, 0.06377213f, -0.00084990f, 0.02250854f, -0.08332925f, 
    0.05384335f, -0.08949745f, 0.03438895f, 0.09413626f, 0.16640240f, -0.09964962f, -0.13502437f, -0.19389194f, 
    0.10344974f, -0.01408828f, -0.00478083f, -0.06432162f, -0.03694839f, 0.04794981f, 0.10678700f, -0.11012331f, 
    0.08436988f, -0.15850613f, -0.00502787f, 0.05723312f, -0.11385249f, -0.06168711f, -0.21936117f, -0.19212182f, 
    0.19273295f, 0.06237075f, -0.09589888f, 0.03466168f, -0.04638364f, 0.04006013f, 0.21439165f, -0.07589182f, 
    0.00327742f, -0.15989032f, 0.15045509f, -0.03383988f, -0.02502875f, 0.08369007f, 0.08133714f, 0.09717290f, 
    0.34316009f, -0.07479098f, -0.47750801f, 0.00557313f, 0.24991077f, 0.12511218f, -0.23484962f, 0.10973676f, 
    -0.11228839f, 0.19978230f, -0.05036522f, -0.23821662f, 0.33441210f, -0.14749494f, -0.07922307f, -0.23344967f, 
    0.15787788f, 0.00918805f, -0.04219575f, 0.09032340f, -0.11488198f, -0.15201622f, -0.16979629f, -0.07497121f, 
    0.44599003f, 0.08101759f, -0.06455029f, 0.12651800f, -0.07720973f, -0.01294351f, 0.11368725f, 0.09655078f, 
    -0.03043710f, -0.11761966f, -0.21742330f, 0.12490436f, -0.24590716f, -0.14677900f, -0.32809323f, -0.36607605f, 
    -0.05955907f, -0.07115352f, 0.13996617f, 0.09539705f, -0.06573349f, 0.02952288f, -0.09378891f, -0.06910013f, 
    -0.08397084f, 0.04843240f, -0.06758022f, 0.12813911f, -0.14608294f, -0.09350330f, 0.02240730f, 0.14135705f, 
    0.13150629f, -0.14970075f, 0.06670456f, -0.20222071f, -0.08457064f, -0.04862572f, -0.31343189f, -0.03922337f, 
    -0.08887094f, -0.06486613f, 0.13345830f, -0.00776081f, 0.09380965f, -0.07790241f, -0.00475969f, 0.18184198f, 
    0.11757592f, -0.01539898f, 0.06062178f, -0.14603889f, 0.07153399f, -0.09429092f, 0.00731785f, 0.07602288f, 
    0.14284490f, 0.02860625f, 0.20026252f, 0.13141805f, 0.01083839f, 0.00330146f, 0.08058979f, -0.02205840f, 
    -0.12844676f, -0.04929736f, 0.01534290f, 0.00492866f, -0.39099532f, 0.00446381f, -0.24737722f, -0.16200423f, 
    0.56188536f, -0.39590451f, 0.14665149f, -0.00344188f, -0.04037284f, -0.11631301f, -0.14495684f, 0.04649879f, 
    -0.07475773f, 0.08964922f, -0.08664872f, 0.07030929f, -0.37733340f, -0.26363462f, -0.02388843f, -0.14743114f, 
    -0.00108864f, -0.01015271f, 0.12503070f, 0.14102426f, 0.30462694f, 0.02869471f, -0.02584402f, 0.06120581f, 
    0.29574898f, -0.53530043f, 0.10842325f, 0.14523456f, -0.10164062f, 0.02346963f, 0.10638401f, 0.11952659f, 
    -0.05858806f, 0.03169367f, -0.22011322f, 0.01776572f, -0.21608309f, -0.62831855f, 0.10221740f, 0.29339877f, 
    -0.18877329f, 0.01754732f, -0.10825294f, 0.00127879f, 0.00878709f, -0.03571994f, -0.20572786f, -0.07429801f, 
    -0.16299005f, -0.13176158f, -0.08210569f, -0.23767902f, -0.14379196f, -0.06465588f, -0.01977241f, 0.09971661f, 
    0.17557004f, -0.03295537f, -0.05550200f, -0.23194526f, 0.31344762f, -0.14510348f, -0.21864530f, 0.04375707f, 
    0.01423359f, 0.01266777f, -0.11741490f, -0.09673053f, -0.14407571f, 0.04439628f, 0.02283894f, -0.00255835f, 
    -0.14858909f, 0.17709990f, -0.11106239f, -0.25027317f, 0.06593751f, 0.09757142f, 0.11013856f, -0.05633590f, 
    -0.04122805f, 0.01491904f, 0.01820035f, -0.12089294f, 0.11981340f, 0.13955247f, 0.26903555f, -0.21118698f, 
    0.09142062f, -0.12338760f, -0.21756846f, -0.10304641f, 0.00937229f, -0.00974649f, 0.05924028f, -0.06306453f, 
    -0.31870487f, 0.14846268f, -0.12317957f, -0.55885208f, 0.01755262f, 0.13889152f, 0.00710036f, -0.02936999f, 
    -0.06137064f, -0.00690928f, -0.03673154f, -0.28665081f, -0.16942173f, -0.30327734f, 0.19156320f, -0.15214992f, 
    -0.13365474f, 0.04246388f, 0.05660199f, 0.12428395f, 0.02135713f, -0.17993468f, -0.13896957f, 0.09202973f, 
    -0.35311300f, -0.06358875f, -0.29437175f, 0.11900449f, -0.02425383f, -0.19491680f, 0.02258953f, -0.00807345f, 
    -0.05871532f, 0.27010167f, -0.04716162f, 0.05769809f, -0.36464238f, 0.07997666f, -0.21371643f, -0.26520178f, 
    -0.03623714f, 0.14119408f, -0.04152830f, -0.09628651f, 0.03594287f, 0.00288704f, -0.07373902f, -0.10096631f, 
    0.02018687f, 0.04420294f, 0.07152895f, 0.11730991f, 0.08161940f, 0.09403145f, 0.00494755f, 0.04461040f, 
    -0.15420152f, 0.04776808f, -0.14152090f, -0.11018218f, 0.53378123f, -0.06593090f, -0.29363802f, 0.20457575f, 
    0.03760721f, 0.10662226f, -0.03859156f, -0.08832575f, -0.25292137f, 0.02496043f, -0.04623676f, -0.10792705f, 
    0.24499828f, -0.14249912f, 0.16054989f, -0.09409990f, -0.21695462f, 0.06319925f, 0.04870246f, -0.05161861f, 
    0.12122820f, -0.01767969f, -0.10911470f, 0.06635828f, 0.00292311f, 0.04762708f, 0.09555244f, -0.10319496f, 
    0.19531204f, -0.02454105f, 0.03014434f, 0.03858029f, -0.03398166f, -0.04238262f, 0.02374795f, 0.03340887f, 
    -0.40616819f, 0.13861375f, -0.01775988f, 0.31253979f, -0.02094591f, -0.20543219f, 0.20992528f, 0.11144109f, 
    -0.22405393f, -0.08557227f, 0.02840996f, 0.04996366f, -0.17669961f, -0.00851731f, -0.05740551f, 0.02532225f, 
    -0.05098638f, 0.10637667f, -0.09638155f, -0.06461892f, -0.01366408f, 0.04200908f, 0.11137319f, -0.04844527f, 
    0.32924357f, -0.00370184f, -0.07387195f, -0.16002637f, -0.33101222f, 0.16220349f, 0.03666366f, -0.05340209f, 
    0.00801377f, 0.11515817f, -0.15778106f, -0.09054949f, 0.03882885f, -0.07900395f, 0.20106944f, -0.05518226f, 
    0.20589881f, 0.08623520f, -0.07604827f, -0.02646825f, 0.07165625f, 0.07472332f, -0.06175795f, 0.14220157f, 
    0.17152122f, -0.39971161f, -0.15066443f, -0.23080544f, -0.12815423f, 0.03106724f, -0.15036917f, -0.03282369f, 
    -0.00969538f, -0.01702335f, 0.05199713f, -0.18552984f, 0.32977787f, 0.18673986f, 0.09416546f, 0.26123175f, 
    0.03162781f, -0.22936594f, -0.03944085f, 0.30035999f, 0.03189867f, -0.00987368f, -0.00477522f, -0.06793965f, 
    0.40591773f, 0.11090451f, 0.19043961f, 0.24299385f, -0.09046358f, -0.17941041f, -0.10939744f, 0.13886845f, 
    0.01728926f, 0.09508687f, 0.08729382f, 0.06490064f, 0.11812345f, 0.09445278f, -0.24126041f, 0.16441998f, 
    0.06397930f, 0.12789889f, -0.01187013f, -0.28443488f, -0.05480713f, 0.01087096f, -0.15638517f, -0.01864418f, 
    -0.03098210f, -0.52145392f, 0.09089517f, -0.05210203f, -0.06756582f, -0.00492297f, -0.00809214f, -0.06916557f, 
    -0.01770521f, 0.04008824f, -0.22049712f, 0.18484916f, -0.03886643f, -0.17916650f, 0.06541371f, 0.00670070f, 
    0.03318515f, -0.00798326f, -0.02231770f, 0.03785897f, -0.04471388f, 0.06825066f, -0.06895918f, 0.00940007f, 
    0.08278746f, 0.24877080f, 0.12775569f, -0.15722716f, 0.00970422f, 0.02374517f, 0.06659501f, 0.00790394f, 
    0.04296661f, -0.07070997f, 0.06181334f, -0.00274378f, -0.24382018f, -0.29512578f, -0.17353565f, -0.61177105f, 
    0.02543397f, -0.17977384f, 0.04076254f, 0.00248034f, -0.00974047f, 0.02767970f, -0.10591311f, -0.14641741f, 
    -0.48502544f, 0.02460762f, -0.14494304f, 0.02824275f, 0.10652898f, 0.00875917f, -0.11721250f, 0.04643904f, 
    0.00751278f, 0.00087193f, -0.00710962f, -0.04108632f, 0.20939118f, 0.12283667f, -0.30207643f, -0.04995056f, 
    0.04204777f, 0.08593908f, -0.09856676f, -0.02105240f, -0.08730712f, -0.02149503f, -0.01402902f, -0.05682989f, 
    -0.51437974f, -0.07188509f, -0.00393331f, -0.19914867f, -0.04359857f, -0.00414470f, 0.15064335f, -0.04337509f, 
    -0.12589405f, -0.16313052f, -0.09259591f, -0.07141783f, 0.17549017f, 0.12738249f, 0.16220824f, -0.25568891f, 
    -0.09747119f, 0.01029059f, 0.08730520f, -0.00542365f, 0.01422495f, -0.15120769f, 0.04322711f, -0.12833829f, 
    0.23967753f, -0.14342207f, -0.12034979f, -0.26978794f, 0.18588822f, -0.16839439f, 0.14148951f, -0.02250881f, 
    -0.13554829f, 0.15486401f, 0.03010806f, -0.19186336f, 0.22717126f, 0.19994992f, 0.22131343f, 0.08458746f, 
    -0.14731784f, -0.12579969f, 0.05960195f, -0.02106761f, -0.08679884f, 0.00490872f, 0.02879283f, -0.11528999f, 
    0.34055731f, -0.03312443f, -0.16348219f, 0.12794822f, -0.07956412f, 0.02419319f, 0.16308723f, 0.08745053f, 
    0.00264487f, -0.00187234f, -0.00946325f, -0.01305523f, 0.87295789f, -0.05892669f, -0.18166308f, -0.06561541f, 
    0.03882612f, 0.05879657f, 0.02923223f, 0.00117157f, 0.08302574f, 0.08384519f, 0.09845269f, 0.00054467f, 
    0.33038387f, -0.19702893f, 0.14770952f, -0.17055218f, 0.00910360f, -0.16144325f, -0.03324552f, 0.14785655f, 
    0.12726067f, 0.04546122f, 0.08683756f, -0.01188094f, -0.23501147f, 0.05516575f, 0.24526051f, -0.06000905f, 
    -0.01642190f, -0.11726872f, 0.14022931f, -0.04482339f, -0.12780297f, -0.00357441f, -0.35013041f, -0.05164367f, 
    -0.06579553f, 0.23931310f, 0.30891421f, 0.20614643f, -0.03109279f, 0.19508137f, -0.05872744f, 0.12175416f, 
    -0.02442169f, -0.06295557f, 0.06212174f, -0.12096642f, 0.12124295f, 0.08038645f, -0.08256844f, -0.24397111f, 
    0.01377747f, 0.04081872f, -0.05978797f, 0.07135416f, 0.08040560f, -0.22877634f, 0.00791577f, 0.06967722f, 
    0.02121115f, 0.16082262f, 0.03996255f, 0.20073268f, 0.01827653f, -0.14302669f, 0.06967804f, 0.06501494f, 
    -0.07039510f, 0.01543461f, -0.26947507f, -0.08458137f, 0.03501788f, 0.04759171f, -0.11963340f, 0.06496198f, 
    -0.23840030f, -0.03900763f, 0.05103365f, -0.00615814f, -0.13247545f, 0.00416626f, -0.02075242f, -0.00673671f, 
    0.02322817f, -0.01869445f, 0.01686639f, -0.07471976f, -0.15961696f, -0.07797915f, 0.07237077f, 0.04978916f, 
    -0.21219577f, 0.07727952f, 0.05182485f, 0.07616273f, -0.20153292f, -0.79061598f, -0.19880179f, 0.10953233f, 
    -0.15949556f, -0.16105093f, 0.11270045f, -0.02174024f, -0.04264998f, -0.15794729f, 0.13427307f, -0.04382993f, 
    -0.32555670f, -0.47218281f, -0.18588667f, 0.28365642f, 0.03084449f, -0.03923489f, -0.04487410f, -0.17208740f, 
    0.04389040f, -0.07269268f, -0.06153943f, -0.02978862f, -0.25666213f, -0.00711779f, 0.28413197f, -0.00051679f, 
    0.02803435f, -0.12953159f, 0.06825545f, -0.08168369f, 0.02910697f, -0.09927379f, -0.12720190f, -0.06243474f, 
    -0.19358568f, 0.08588107f, -0.18899667f, -0.09858344f, -0.00060882f, -0.05317141f, 0.03914834f, 0.05680650f, 
    -0.07976481f, -0.09655963f, 0.00973878f, 0.02672205f, -0.67589390f, -0.61836737f, -0.25425062f, -0.19460203f, 
    -0.02057621f, -0.16801274f, -0.01661305f, -0.04310083f, -0.02678056f, -0.11473374f, 0.11077116f, -0.02253919f, 
    -0.04656779f, -0.16889282f, 0.04900068f, 0.24198610f, -0.13578475f, 0.06962879f, 0.03829098f, 0.06621978f, 
    -0.05746872f, 0.15034425f, 0.05167770f, 0.03838962f, 0.24209230f, 0.11451163f, -0.14050730f, 0.30043963f, 
    0.02748292f, 0.19582900f, 0.27176511f, -0.06125351f, -0.06261636f, 0.14701252f, -0.04170170f, 0.04938727f, 
    -0.13916491f, 0.25208911f, 0.19672498f, 0.12454130f, 0.04968884f, -0.03186030f, 0.02490015f, -0.03320016f, 
    0.01764177f, 0.14789999f, -0.09605187f, 0.15177029f, -0.82587969f, -0.52947617f, 0.15971452f, 0.18102154f, 
    -0.14587314f, 0.03517069f, -0.10240491f, -0.12828261f, 0.06538696f, -0.13703543f, 0.00779836f, 0.03339642f, 
    0.22094302f, 0.09958427f, -0.02960869f, 0.12257139f, 0.04743939f, -0.03539153f, -0.13322335f, -0.00056597f, 
    0.01663066f, 0.03839740f, 0.04670294f, -0.19909059f, -0.21850725f, -0.08444666f, -0.07949123f, -0.17004143f, 
    -0.10693633f, -0.14343603f, 0.00934933f, -0.03807455f, -0.00164041f, -0.03839136f, 0.01638270f, 0.00553050f, 
    -0.06543524f, -0.01748745f, 0.02284087f, -0.24486604f, -0.04443331f, -0.10739904f, 0.08179466f, -0.08438390f, 
    -0.05378795f, -0.10213338f, 0.07039888f, -0.13329586f, 0.26081309f, -0.17027302f, -0.01073072f, 0.41641495f, 
    0.00249258f, 0.14902756f, 0.03100033f, 0.06775450f, -0.06033277f, 0.03859099f, 0.02534690f, -0.30891865f, 
    0.24868336f, 0.15358339f, -0.14766949f, 0.16163847f, -0.11380635f, -0.02163334f, 0.13864069f, 0.04744139f, 
    0.23977517f, 0.01929060f, 0.24486516f, -0.05897610f, 0.15632176f, 0.17762476f, 0.01455703f, 0.01669834f, 
    -0.08751866f, -0.06759428f, -0.19354798f, -0.14208579f, -0.05842420f, 0.01002910f, 0.02914584f, 0.10291765f, 
    -0.37249881f, -0.29560253f, -0.32795030f, 0.04210087f, 0.12436439f, 0.14679502f, -0.02801091f, -0.01876414f, 
    -0.07357656f, -0.00159347f, -0.10934230f, 0.07485028f, 0.67113280f, 0.19824059f, 0.03588045f, 0.12409173f, 
    -0.00115269f, -0.05130272f, -0.03951231f, 0.08294377f, -0.18256369f, -0.01370409f, 0.00497618f, 0.01036404f, 
    0.34387499f, -0.02355730f, 0.03761065f, 0.03664294f, 0.10874730f, 0.08019124f, -0.01302635f, -0.08697192f, 
    0.13476220f, 0.13665351f, -0.04038566f, 0.00590273f, -0.86913896f, 0.20398949f, -0.12831302f, 0.07359003f, 
    0.01788061f, 0.13947159f, -0.00769471f, 0.11990863f, -0.04473938f, -0.14392786f, -0.04876778f, -0.17272007f, 
    -0.00823622f, -0.18381689f, -0.00637523f, 0.14530899f, -0.18027443f, 0.08241257f, -0.01929188f, 0.02307273f, 
    0.14407034f, 0.08055063f, -0.10024668f, -0.12000246f, -0.24316931f, -0.10841561f, 0.05354661f, -0.23936141f, 
    0.02833156f, -0.13983761f, -0.04822590f, -0.04464681f, -0.02844101f, 0.06334691f, 0.07505444f, -0.14355232f, 
    0.28886977f, -0.20130228f, -0.28838718f, -0.24868302f, -0.05914944f, -0.14442708f, 0.01097503f, 0.09481956f, 
    -0.01643403f, -0.10106889f, 0.05807994f, -0.06467879f, -0.15538000f, 0.04759553f, -0.09335881f, -0.29943699f, 
    -0.11957850f, -0.01991728f, 0.02643166f, 0.03884336f, -0.04193476f, -0.11237220f, -0.00164013f, 0.01039244f, 
    0.42538488f, -0.23413949f, -0.07729658f, 0.00282872f, 0.07547345f, 0.08052699f, -0.01907064f, 0.01938936f, 
    -0.00762527f, -0.05820950f, 0.06372236f, -0.00350976f, 0.18726565f, 0.14159386f, 0.36496201f, 0.05102002f, 
    0.02185092f, -0.06142138f, 0.18758442f, 0.01323974f, -0.01299633f, 0.05350174f, 0.12244325f, -0.05415851f, 
    0.10967801f, 0.18934114f, -0.16736811f, -0.55910003f, 0.03861709f, 0.15887380f, -0.05099310f, 0.04037326f, 
    0.07669672f, 0.01101248f, -0.00188488f, 0.17145300f, -0.08070453f, 0.09979966f, -0.16334657f, -0.07556710f, 
    -0.05401403f, 0.01769482f, 0.09112089f, 0.00641583f, 0.10106658f, -0.03183876f, -0.10076350f, -0.05565999f, 
    -0.26555580f, -0.31188580f, 0.10466406f, 0.08951241f, 0.11815687f, -0.11664821f, -0.15965508f, -0.30476427f, 
    -0.05469960f, 0.00797772f, 0.08870474f, -0.14861800f, 0.13769516f, -0.31874868f, -0.04070503f, 0.20538777f, 
    0.11583959f, 0.10658459f, 0.05806065f, 0.16399592f, -0.11396693f, 0.06832488f, 0.02939989f, 0.01290665f, 
    -0.07169598f, -0.21345709f, 0.29686382f, 0.04588591f, -0.17815925f, 0.08819581f, -0.04298435f, -0.15123972f, 
    0.16321394f, -0.06479159f, 0.07522658f, -0.13549171f, -0.04451605f, 0.10046331f, 0.06168815f, 0.10251603f, 
    0.17560710f, 0.17685577f, 0.02212624f, 0.16652235f, -0.02492146f, -0.12622833f, -0.00404259f, -0.13944188f, 
    -0.01614204f, -0.18759468f, -0.12503645f, 0.24158978f, 0.09143966f, -0.16310073f, 0.07275420f, 0.32001895f, 
    -0.11147860f, -0.00532344f, 0.18515000f, 0.13471831f, 0.15661448f, 0.17561312f, 0.29272911f, -0.12204005f, 
    -0.01900142f, 0.16844402f, -0.04225472f, -0.06951330f, 0.05209183f, 0.12701899f, 0.13761441f, 0.06813518f, 
    -0.27758104f, 0.04865725f, 0.00419053f, -0.08370236f, 0.06512186f, -0.06687557f, -0.04698848f, 0.14426139f, 
    0.04487932f, -0.12580782f, -0.12718394f, -0.01541510f, -0.02673563f, -0.02924356f, 0.12683922f, 0.10153045f, 
    0.08709197f, -0.15158656f, 0.06080823f, 0.04973534f, 0.13784565f, 0.11047789f, -0.19745688f, -0.12669003f, 
    -0.67759502f, 0.24629557f, -0.16130278f, -0.15094860f, -0.00391757f, 0.03905259f, 0.10496106f, 0.10156507f, 
    0.02995399f, 0.02561803f, -0.01122011f, -0.00844040f, 0.15672673f, 0.14789896f, -0.14325489f, -0.06952694f, 
    0.05405620f, 0.07645641f, 0.01238693f, 0.11606112f, 0.04818645f, -0.08169628f, 0.12342643f, 0.02021625f, 
    -0.39284825f, -0.00567004f, -0.07676156f, 0.17739342f, -0.07651668f, 0.14363717f, 0.00980543f, -0.01060017f, 
    0.07965214f, 0.02476957f, 0.02510881f, 0.09805444f, 0.08714696f, -0.34019116f, 0.08491305f, 0.07280382f, 
    -0.05513659f, 0.19662124f, 0.01016788f, -0.03070911f, -0.04939178f, 0.01692779f, -0.04066185f, 0.08754322f, 
    -0.13338521f, -0.12995549f, 0.28631431f, 0.08340020f, 0.17258818f, 0.05181385f, -0.07013465f, -0.08750197f, 
    0.01759025f, 0.11329032f, -0.09295231f, 0.08930231f, -0.06589690f, 0.19136028f, -0.05111013f, 0.09664672f, 
    0.04346631f, -0.03119572f, 0.07969853f, 0.04522192f, -0.11648812f, 0.02362789f, 0.00367839f, 0.08176769f, 
    -0.18415478f, 0.07818883f, 0.09289430f, -0.10590807f, 0.05445810f, -0.09237659f, -0.00953642f, 0.07578433f, 
    0.09639304f, -0.19522493f, 0.04440809f, -0.01115311f, -0.64383709f, -0.18472677f, 0.15951903f, 0.37801495f, 
    -0.05328460f, -0.07203592f, 0.20025621f, 0.07283685f, 0.02193357f, 0.02728816f, 0.06509651f, 0.18452561f, 
    -0.65126705f, -0.08394891f, -0.15052436f, 0.24742112f, 0.10810939f, 0.06080741f, -0.00299883f, -0.05687966f, 
    -0.19635701f, -0.11766856f, 0.04095413f, 0.06027193f, -0.43206266f, 0.06178711f, 0.12272763f, 0.08491375f, 
    -0.17321183f, -0.07720024f, -0.13669613f, -0.00217838f, -0.07441569f, -0.02477130f, 0.04455814f, -0.12166940f, 
    0.31811309f, -0.05094118f, -0.12943171f, -0.15068206f, -0.08792780f, 0.10889985f, 0.07486661f, -0.00786865f, 
    0.02284293f, -0.09221742f, 0.03276416f, 0.00677440f, 0.20733003f, -0.04782973f, -0.08251511f, 0.21829899f, 
    0.04758603f, -0.17172207f, 0.06166906f, 0.11479402f, 0.04669478f, 0.02001259f, 0.01036312f, -0.03696741f, 
    -0.35923532f, -0.26890990f, 0.09295937f, 0.01381163f, -0.16142282f, -0.03518041f, -0.10053643f, -0.08925620f, 
    0.03343654f, 0.15070431f, -0.07024182f, -0.13749169f, -0.14538270f, 0.15282319f, -0.01883821f, -0.18928365f, 
    0.05043582f, 0.15447429f, 0.07392459f, 0.13611835f, 0.01292698f, -0.04727944f, 0.09667810f, 0.02506712f, 
    0.17607798f, 0.21251948f, 0.09871951f, 0.22594737f, -0.23904054f, 0.14703777f, 0.00093453f, -0.15937866f, 
    0.09641326f, -0.21564272f, -0.18841280f, 0.02289934f, -0.49100834f, -0.28544602f, 0.31376323f, 0.00567404f, 
    0.00736823f, 0.27387083f, -0.04485503f, 0.02030556f, 0.10591078f, 0.12746571f, -0.05891515f, -0.01199611f, 
    0.09654655f, -0.18400101f, -0.03420605f, 0.09591427f, -0.18051854f, 0.07263000f, 0.02630587f, -0.02559482f, 
    -0.03759525f, -0.03808017f, 0.10418873f, 0.07458328f, -0.20329306f, -0.26232776f, -0.09358080f, -0.16898233f, 
    0.11214318f, -0.10567831f, -0.17757963f, -0.10371259f, -0.11194191f, -0.08639910f, -0.02467859f, -0.00930011f, 
    0.56938779f, -0.08019064f, -0.12206707f, 0.06604628f, -0.23277721f, -0.08699538f, 0.02317346f, -0.04894749f, 
    -0.07412112f, -0.14071752f, -0.04528997f, -0.01956046f, 0.31178445f, 0.29128230f, 0.05838474f, 0.10323808f, 
    0.03224652f, -0.01484250f, -0.08457487f, 0.03553031f, 0.06978519f, -0.04910164f, 0.01595175f, -0.10506312f, 
    0.27090454f, 0.06594835f, -0.05760444f, -0.24970809f, -0.08626395f, -0.07358543f, -0.17631710f, -0.45520383f, 
    -0.05114876f, 0.07898764f, -0.07456385f, -0.05321492f, -0.36977544f, 0.22233322f, -0.16477111f, -0.04867909f, 
    0.07022978f, -0.08706155f, -0.04658410f, 0.06916572f, -0.18913673f, -0.18746971f, -0.01272052f, -0.00603791f, 
    -0.52775443f, -0.08696216f, -0.05947308f, 0.30681866f, 0.16268218f, -0.17756401f, 0.10602209f, -0.22809894f, 
    0.11590070f, -0.02410441f, -0.07547612f, -0.09598977f, -0.52197301f, -0.16022667f, 0.20828049f, -0.05934379f, 
    0.00973312f, -0.13761470f, -0.16764556f, 0.07072902f, 0.14378980f, 0.14244044f, -0.08078265f, 0.23699106f, 
    0.01119589f, 0.04508698f, 0.10826652f, 0.11624928f, -0.19936995f, -0.20081630f, -0.02001486f, 0.21948430f, 
    -0.16328976f, -0.15971157f, 0.03566488f, 0.28745160f, -0.46341467f, -0.12657624f, -0.18565327f, 0.14897278f, 
    0.18905409f, 0.00238792f, -0.13846776f, -0.17311242f, 0.02735674f, -0.09999835f, 0.06918618f, -0.09345473f, 
    -0.09849641f, 0.11715703f, 0.12960456f, 0.31904224f, -0.09360626f, -0.17317836f, -0.07869975f, 0.07749931f, 
    -0.13850632f, 0.02503682f, 0.01533823f, 0.12337355f, -0.41673642f, -0.23212332f, -0.35968128f, 0.12861493f, 
    0.06246705f, -0.13299043f, -0.10716081f, 0.03787187f, 0.06981019f, 0.19115268f, 0.04223662f, -0.07515903f, 
    0.39964557f, -0.03083028f, -0.05273735f, 0.21628155f, 0.16664605f, 0.37454057f, -0.05385287f, -0.03736943f, 
    -0.07628511f, -0.07659827f, -0.02218086f, -0.12889557f, 0.04621416f, -0.04013123f, 0.01099345f, -0.08790804f, 
    -0.15538715f, 0.01402534f, -0.05392888f, 0.26010954f, -0.05107599f, 0.17477632f, -0.13644508f, -0.13524641f, 
    0.14143279f, -0.05649146f, 0.21938920f, 0.13757467f, -0.00661914f, 0.13704291f, 0.11166547f, -0.03097404f, 
    -0.04301475f, 0.02075667f, 0.16683975f, 0.28934225f, 0.01498492f, 0.01119039f, -0.14824933f, -0.23183966f, 
    0.16586296f, 0.15559904f, -0.08205701f, -0.12280293f, 0.19853206f, -0.20343526f, 0.09861102f, 0.08130533f, 
    -0.73563379f, 0.20481570f, 0.10922341f, -0.07772841f, 0.18204677f, -0.02668312f, -0.11585788f, 0.05021502f, 
    -0.00688226f, 0.00430105f, 0.03368020f, -0.20009229f, 0.16634053f, 0.05237610f, 0.33147731f, 0.00364224f, 
    0.02661779f, -0.05974915f, -0.05394446f, -0.21965468f, -0.04731216f, 0.01891318f, 0.00194606f, 0.05177415f, 
    0.02663625f, -0.13813309f, -0.11643697f, -0.12622854f, -0.02492956f, 0.02422919f, -0.09154513f, -0.05090978f, 
    0.04915278f, -0.11172764f, -0.08363958f, 0.00535154f, 0.11895206f, -0.09052951f, 0.05621296f, -0.23407750f, 
    0.01208419f, -0.20967796f, -0.12033391f, 0.05712432f, 0.05593660f, 0.06998105f, 0.13287303f, -0.01488677f, 
    0.05759591f, 0.10916714f, -0.23856422f, 0.09570962f, 0.16950488f, 0.00369063f, -0.04459207f, -0.00850764f, 
    -0.12459318f, -0.05453641f, 0.34379333f, -0.04685313f, 0.01096131f, 0.04151157f, 0.38259795f, -0.09921408f, 
    0.09304603f, 0.01105831f, 0.03325802f, -0.02050047f, 0.16126668f, -0.19172812f, 0.00894891f, -0.07011890f, 
    -0.15155564f, -0.22712924f, 0.22219187f, -0.13498800f, 0.03238771f, 0.10239487f, 0.03605287f, 0.01891456f, 
    0.07291014f, 0.14635134f, -0.06422475f, 0.32382542f, -0.46783313f, 0.07974435f, -0.35184526f, -0.14641398f, 
    0.12671089f, 0.16856036f, -0.05512614f, -0.21110061f, 0.07746898f, -0.05427656f, 0.03173906f, -0.11211748f, 
    0.03676046f, 0.18719511f, -0.16837029f, -0.17543557f, 0.03097465f, 0.07257012f, 0.09292355f, -0.07734603f, 
    -0.05736705f, -0.15167561f, 0.02083644f, -0.42947587f, 0.15308574f, 0.02098446f, -0.10092659f, 0.18699954f, 
    -0.03240849f, 0.06418213f, 0.05864228f, 0.04828282f, -0.04260811f, 0.09093763f, 0.03237050f, 0.35482049f, 
    -0.27670747f, 0.28574690f, 0.35868466f, -0.46226430f, -0.01354830f, -0.12206206f, 0.10035603f, -0.15076752f, 
    -0.00854334f, -0.00328076f, -0.07736041f, 0.01545884f, -0.29805911f, -0.06351451f, -0.14317918f, -0.18876250f, 
    -0.13429029f, 0.27711782f, -0.11668171f, -0.02153489f, 0.01955144f, -0.21580526f, -0.00857049f, 0.07693338f, 
    0.19273286f, -0.12748151f, 0.01121676f, -0.20122388f, -0.12192673f, 0.07389142f, -0.01666692f, -0.02985726f, 
    0.03049998f, -0.02181020f, 0.23878033f, 0.04646908f, -0.19124755f, -0.08345953f, 0.28867957f, 0.07165981f, 
    -0.11797561f, 0.19219309f, -0.10577268f, 0.05830824f, 0.07511301f, 0.05196192f, 0.16690682f, -0.09383658f, 
    -0.06346145f, -0.17368352f, -0.10738019f, -0.14142936f, 0.04686902f, -0.14267729f, -0.17232142f, 0.13278572f, 
    0.13322242f, 0.20865948f, 0.06349982f, 0.05171625f, 0.21134505f, 0.06756291f, 0.13327000f, -0.05379646f, 
    -0.02764923f, -0.14622611f, -0.04728533f, 0.10203125f, -0.08372996f, -0.00253117f, -0.04852034f, 0.09445751f, 
    -0.10865457f, 0.07239451f, -0.09009185f, -0.09936189f, 0.04619579f, -0.20792130f, 0.11200752f, 0.11707936f, 
    0.07415270f, -0.11075833f, 0.09455946f, 0.14900269f, 0.08775940f, 0.18127182f, -0.13966286f, 0.06633500f, 
    -0.14227378f, -0.02985625f, -0.03807204f, 0.11033892f, 0.21376203f, 0.12969851f, 0.10925326f, 0.02413594f, 
    -0.12044398f, 0.09304506f, 0.19369037f, 0.00843507f, -0.17258471f, 0.04648555f, 0.17131014f, -0.23117620f, 
    -0.04962514f, -0.14941624f, 0.05761080f, 0.06400222f, -0.10298399f, -0.19229847f, -0.15598461f, 0.04309261f, 
    0.07386596f, -0.05642417f, 0.00799199f, -0.15565415f, 0.12313198f, 0.03914740f, -0.03925439f, 0.18766031f, 
    0.10691494f, 0.18012081f, 0.01030312f, 0.15813474f, 0.04376382f, -0.14236742f, -0.07738432f, 0.12582296f, 
    -0.12006236f, -0.08476429f, -0.13355616f, -0.28358442f, -0.58154994f, 0.19261979f, 0.00951054f, -0.45653021f, 
    -0.02367458f, 0.01116661f, -0.04143041f, 0.06178501f, -0.06505448f, -0.00753243f, -0.09061784f, -0.12704597f, 
    0.01867407f, -0.63434875f, -0.14709075f, 0.28687373f, -0.04662787f, 0.23930812f, 0.04898803f, 0.05199491f, 
    -0.18627506f, -0.00260388f, 0.13176136f, 0.15832730f, -0.31849709f, -0.10578439f, -0.13157351f, 0.29512611f, 
    0.06166432f, 0.07427666f, 0.11265681f, 0.02550955f, -0.04857800f, -0.12265258f, -0.01011313f, -0.16735010f, 
    0.15421344f, 0.10328482f, -0.07166636f, -0.25019708f, 0.08783413f, 0.20730713f, -0.06916506f, -0.02102037f, 
    0.00708863f, -0.12783979f, -0.06094113f, 0.05859850f, 0.11145720f, 0.06800948f, -0.09553919f, -0.22636913f, 
    -0.30801141f, 0.03727117f, 0.03957889f, -0.03510961f, -0.11505377f, 0.08807205f, -0.12578483f, 0.05993137f, 
    -0.11590802f, -0.37310889f, -0.07720152f, -0.02859685f, 0.12262973f, -0.03638165f, 0.03539225f, 0.11240902f, 
    -0.09506590f, 0.02393523f, -0.15150630f, -0.02023159f, -0.16303076f, 0.14071073f, -0.13671102f, -0.14381628f, 
    -0.03503642f, 0.00103133f, 0.12595983f, -0.12342574f, -0.13870575f, -0.03752422f, 0.04322945f, -0.03926026f, 
    -0.44579455f, -0.00735508f, -0.24585462f, -0.40499803f, -0.28796864f, -0.26567647f, 0.11468729f, -0.09837292f, 
    0.12653053f, 0.16795400f, -0.11854582f, 0.07214043f, 0.02075069f, 0.15435974f, 0.12716392f, -0.35910156f, 
    0.14257272f, 0.04618549f, -0.17624454f, 0.08921658f, -0.09417934f, 0.01344572f, -0.04189988f, -0.01550594f, 
    0.10119020f, 0.24848197f, 0.11017156f, -0.36011428f, -0.06144400f, -0.14840418f, 0.03812674f, 0.06224672f, 
    0.21830463f, 0.08995946f, -0.19923475f, -0.14175016f, -0.13799162f, -0.05496116f, 0.04918461f, -0.07433616f, 
    -0.08652753f, 0.08264207f, 0.10414737f, 0.02349786f, 0.08177759f, -0.09469933f, -0.32128060f, -0.10009931f, 
    0.40764657f, -0.64470154f, 0.01836704f, 0.02689974f, 0.07383828f, 0.04304980f, -0.04986605f, 0.00531752f, 
    -0.00354228f, 0.05840011f, 0.06772213f, 0.05108862f, -0.41957402f, 0.09518164f, 0.10451601f, 0.23669480f, 
    -0.11468183f, -0.00024277f, -0.07065659f, 0.14047098f, 0.00293724f, 0.07449153f, -0.13720629f, 0.17985582f, 
    -0.21143739f, 0.01961063f, -0.38804856f, 0.03573024f, 0.01973991f, 0.00360737f, 0.13457347f, -0.03533612f, 
    0.06060572f, -0.03069814f, 0.01070289f, -0.02259938f, -0.00933746f, 0.22199011f, 0.13689733f, -0.10898944f, 
    0.05412994f, 0.06740194f, 0.11090996f, 0.04661497f, -0.06191147f, 0.17657407f, -0.13527717f, -0.05843635f, 
    0.01723601f, -0.05665781f, 0.01376936f, -0.22210813f, 0.07163928f, 0.09618915f, 0.13681115f, -0.04096344f, 
    0.02338707f, -0.00193705f, -0.12571436f, -0.01381006f, 0.27247503f, -0.06103957f, 0.22352816f, -0.33636475f, 
    -0.13312434f, -0.04322681f, 0.05472567f, 0.01542149f, -0.05836415f, 0.15376312f, 0.00262395f, 0.01431464f, 
    0.11539716f, 0.12184713f, -0.16797701f, -0.15880759f, -0.07275403f, -0.12233347f, -0.17915672f, -0.02081045f, 
    -0.02197967f, 0.07213415f, -0.01542517f, -0.04725888f, -0.12656988f, -0.31996396f, -0.33816603f, -0.04484140f, 
    0.00004035f, 0.01216091f, -0.06080278f, -0.02776068f, -0.00370454f, 0.03185134f, -0.03753107f, 0.17280199f, 
    0.10314867f, -0.26385123f, -0.00806390f, -0.23859935f, -0.08250531f, 0.04711515f, 0.02270508f, -0.05405560f, 
    -0.08714271f, -0.00922572f, 0.11522943f, 0.40312380f, 0.16768992f, 0.24872284f, 0.11193351f, -0.41746312f, 
    -0.08876039f, 0.02188901f, 0.07154964f, -0.03158208f, -0.03314995f, -0.05814648f, -0.07792721f, -0.19847989f, 
    -0.08957898f, -0.30502576f, -0.19271542f, -0.04899599f, -0.03195368f, 0.19047052f, -0.00677650f, 0.18310355f, 
    0.08690879f, -0.15021028f, 0.01083344f, -0.00602075f, -0.28955302f, -0.05454388f, 0.12908570f, -0.33583689f, 
    0.03342990f, -0.00584061f, 0.02478210f, -0.21058790f, 0.04401153f, 0.01230628f, 0.14183165f, 0.03784346f, 
    -0.63494146f, 0.29884559f, 0.21213537f, 0.22564356f, 0.04438758f, -0.05605273f, -0.01308846f, -0.10919481f, 
    -0.04667565f, -0.08403495f, -0.08272875f, -0.13885595f, 0.27479038f, -0.19307789f, 0.10502463f, 0.41504672f, 
    -0.06117868f, -0.05981757f, -0.05557988f, 0.04841168f, -0.02841636f, -0.12647887f, -0.18793525f, 0.17360295f, 
    -0.02376850f, 0.23492061f, 0.00493319f, -0.30310240f, 0.02138895f, 0.25515980f, 0.16748436f, -0.12404649f, 
    -0.25494239f, 0.02852371f, 0.08489612f, -0.00120382f, 0.09542821f, 0.09116864f, 0.14830254f, -0.15693973f, 
    0.11313892f, 0.16941153f, 0.15851048f, 0.00004462f, -0.12553483f, 0.17844817f, 0.00780921f, -0.02989739f, 
    0.09748168f, -0.00188106f, -0.19799027f, 0.48363826f, -0.01470323f, 0.00954570f, 0.00339692f, 0.02838066f, 
    -0.10921434f, 0.10756279f, -0.17256296f, -0.10524193f, -0.57674539f, 0.11324180f, -0.15460573f, 0.40244859f, 
    0.07104121f, 0.00795383f, -0.02383118f, 0.04316300f, -0.10756209f, -0.11589129f, -0.05416101f, -0.31235889f, 
    -0.44334126f, 0.33508992f, -0.10674356f, 0.16713800f, 0.10994065f, 0.07074924f, -0.11711910f, 0.07947183f, 
    0.04954025f, -0.02792704f, -0.02262097f, -0.04355717f, -0.08263461f, -0.00413715f, -0.28539672f, 0.19026166f, 
    -0.12909168f, 0.08981422f, 0.04015486f, -0.12636118f, -0.08627812f, 0.06937993f, -0.05432592f, -0.05184098f, 
    -0.39239058f, -0.05271265f, 0.12391177f, 0.12688255f, 0.04028665f, -0.12796803f, 0.05083866f, 0.01505757f, 
    0.03870178f, 0.00468565f, 0.26912284f, 0.25017700f, 0.71666819f, -0.06136482f, 0.15459120f, -0.23761678f, 
    0.07991487f, 0.07348488f, 0.27131188f, -0.11950535f, 0.07024759f, -0.00612238f, 0.09539983f, 0.08209588f, 
    0.20860490f, 0.13046032f, 0.13411708f, 0.27590555f, 0.17920628f, -0.07037842f, -0.09551910f, 0.13960716f, 
    -0.04978532f, -0.11639049f, 0.08512732f, -0.18900876f, 0.25192815f, 0.00649299f, 0.27035812f, 0.10828783f, 
    -0.02818192f, -0.10622203f, -0.02440416f, -0.07664218f, -0.04006467f, -0.08511319f, -0.07261930f, -0.09039640f, 
    0.09834193f, -0.20653188f, -0.24510367f, 0.11883073f, -0.18879619f, -0.01004210f, -0.15535462f, -0.12112390f, 
    -0.17880110f, -0.02078575f, 0.01060767f, -0.01327993f, 0.03488749f, 0.23050213f, 0.07797730f, 0.34616226f, 
    0.11870986f, 0.02497849f, 0.02795086f, -0.03767165f, -0.09811275f, 0.03096225f, 0.01747427f, -0.12030245f, 
    0.07012685f, -0.32142314f, -0.06969240f, 0.34308526f, 0.01240382f, -0.32182208f, -0.08409166f, -0.08302842f, 
    -0.03789762f, -0.06820970f, 0.00671450f, -0.08200935f, 0.05345326f, 0.21341102f, 0.17166197f, 0.09842286f, 
    -0.10333750f, 0.01130845f, -0.09284285f, -0.05400135f, -0.14925891f, -0.08687457f, -0.13428128f, -0.08184484f, 
    0.20753777f, 0.29374352f, 0.05101435f, 0.32912576f, 0.17001149f, 0.07212539f, 0.06925661f, -0.01650612f, 
    0.02911981f, 0.06274565f, -0.10070081f, -0.10516135f, -0.09816066f, -0.09123996f, -0.02036196f, -0.14064261f, 
    0.10629898f, -0.18476570f, 0.00016494f, -0.04420942f, 0.02448285f, 0.00415309f, 0.07686303f, 0.04604847f, 
    -0.46243232f, 0.06612673f, -0.22365986f, -0.24790196f, 0.13910164f, 0.00851280f, 0.03831274f, -0.12132393f, 
    -0.09449031f, 0.01093608f, -0.12862493f, -0.04578762f, 0.22360526f, -0.38717669f, 0.07223809f, -0.20511466f, 
    -0.01413066f, -0.10767977f, -0.07960688f, -0.11214291f, 0.07200413f, -0.00640279f, -0.06200057f, 0.02328901f, 
    -0.08648714f, -0.21844298f, 0.11066934f, -0.19309783f, -0.06035891f, -0.03596847f, -0.08732311f, -0.15819928f, 
    -0.02592054f, 0.03984422f, -0.06930738f, -0.05860895f, 0.25553864f, 0.00101770f, -0.10687125f, -0.11409304f, 
    -0.18601710f, -0.05159270f, 0.00533402f, -0.10256275f, 0.07858574f, 0.01744888f, -0.05324157f, 0.04616291f, 
    0.14183132f, 0.22761677f, -0.13646635f, 0.10537300f, -0.02806387f, 0.15797928f, -0.01336544f, -0.03473014f, 
    0.01626907f, 0.06237861f, -0.01991917f, -0.10490223f, 0.11992116f, -0.05592017f, -0.09067196f, 0.13946624f, 
    0.04807283f, 0.03857391f, -0.15956143f, -0.01758671f, 0.02122536f, -0.01540740f, 0.03153988f, -0.14070606f, 
    0.22485723f, -0.11904129f, 0.15816635f, -0.10764740f, -0.07594813f, 0.02320550f, -0.03478678f, -0.12409052f, 
    -0.05705663f, 0.06133678f, -0.15133907f, -0.17432506f, -0.01497397f, -0.08637077f, -0.16119163f, -0.18749365f, 
    -0.11361180f, -0.06919821f, 0.03938590f, -0.09699532f, -0.06303477f, -0.04176292f, -0.01072042f, -0.20836625f, 
    0.05163606f, 0.03014839f, 0.14301194f, 0.06031980f, -0.03351469f, -0.04618590f, 0.00512236f, -0.02406279f, 
    -0.00973576f, 0.11229574f, -0.09890395f, -0.07700448f, 0.11565438f, 0.20276329f, 0.20457461f, 0.17853655f, 
    0.13829131f, 0.05909040f, 0.06965827f, 0.02479161f, -0.07589916f, -0.00324638f, -0.05937728f, 0.01618365f, 
    -0.05987015f, 0.18703461f, 0.05447513f, -0.00460694f, -0.02309001f, 0.03879536f, 0.05850456f, 0.04649674f, 
    -0.12600589f, 0.10781011f, 0.09244766f, -0.01648798f, -0.37382489f, -0.18860401f, -0.17518198f, 0.07642142f, 
    -0.10054018f, -0.01824915f, -0.09636497f, -0.11204894f, -0.16963136f, 0.02274864f, 0.08209226f, -0.06896480f, 
    -0.56540549f, 0.30823338f, 0.27528581f, -0.32343701f, -0.18386121f, 0.00052096f, -0.01110378f, -0.13478124f, 
    -0.02332677f, -0.18252569f, 0.08014949f, -0.04402944f, -0.07841304f, 0.18522888f, 0.11475075f, 0.15612176f, 
    -0.03508336f, 0.04344600f, 0.02467010f, -0.02436735f, -0.05312725f, -0.02666954f, 0.07428636f, -0.09316821f, 
    -0.31053448f, -0.05123569f, -0.17446558f, -0.26630396f, 0.07947409f, -0.04522566f, -0.07859534f, -0.02221993f, 
    -0.00327747f, 0.02956375f, 0.09712788f, -0.06632088f, -0.08777183f, 0.19935323f, -0.03933465f, 0.16436912f, 
    -0.30224320f, -0.21788456f, -0.01360600f, 0.03315103f, 0.00758533f, 0.03065710f, -0.00461420f, -0.07101106f, 
    0.12900686f, 0.23530738f, -0.18060951f, -0.04768568f, -0.03850329f, 0.05549707f, -0.07032314f, -0.21376340f, 
    -0.07241821f, 0.00914838f, -0.08044989f, -0.02591563f, 0.21801384f, -0.31100807f, 0.08125328f, -0.18658003f, 
    0.06079777f, -0.10241957f, -0.06026947f, 0.03422689f, -0.11663409f, -0.01023997f, 0.03200853f, -0.01896300f, 
    -0.27745318f, 0.10544583f, -0.08023927f, 0.05027582f, 0.04241268f, 0.00441445f, -0.08108144f, 0.00403056f, 
    -0.03076197f, 0.00280939f, -0.01695712f, -0.12573740f, 0.05124529f, -0.00634199f, -0.05909234f, -0.14520013f, 
    -0.02041675f, 0.11339094f, -0.00282590f, -0.13089015f, 0.13948214f, 0.02969525f, 0.00075451f, 0.00179398f, 
    -0.42330351f, 0.35971507f, 0.01018996f, -0.19902825f, 0.00305486f, 0.14183806f, -0.17789622f, -0.01525707f, 
    -0.08803476f, 0.04493817f, -0.01845865f, -0.11960714f, 0.05878431f, 0.32165644f, 0.08328594f, 0.25551990f, 
    0.10264152f, -0.00935972f, 0.02801350f, -0.06580917f, 0.02209554f, -0.01663657f, -0.04209979f, -0.13450935f, 
    0.00022197f, 0.27978459f, 0.10418309f, -0.22798030f, -0.19079068f, 0.13073984f, 0.03686633f, -0.06668129f, 
    -0.07673053f, -0.04914589f, 0.03512648f, -0.10538245f, 0.52385032f, 0.11205435f, 0.06084379f, -0.31379172f, 
    -0.08285894f, -0.00113426f, -0.05916103f, -0.05963270f, 0.04560989f, 0.02801930f, 0.00122554f, 0.03764659f, 
    0.07934525f, 0.26350409f, 0.08379097f, -0.25528881f, -0.03426400f, -0.31993297f, -0.11689913f, -0.23215236f, 
    0.02883383f, -0.05189496f, -0.18257232f, 0.15118127f, -0.16022202f, 0.12926844f, -0.13384961f, -0.12689604f, 
    0.05711102f, 0.01957804f, -0.07707391f, -0.19102409f, -0.04268754f, 0.14169510f, 0.08738550f, 0.17838988f, 
    -0.27151245f, -0.20109537f, -0.27040479f, -0.44346154f, -0.10871314f, 0.07389501f, 0.04166358f, 0.00519911f, 
    0.12114326f, 0.10352316f, 0.09787872f, 0.10924265f, -0.18025960f, -0.01199236f, 0.32779145f, -0.27967539f, 
    -0.00895336f, -0.06215668f, -0.06529616f, -0.03119397f, -0.08042283f, 0.07406413f, 0.10838714f, -0.02151171f, 
    0.34126598f, -0.00034331f, -0.29115188f, -0.32808435f, -0.03759273f, -0.16932772f, 0.13448294f, -0.08000364f, 
    0.10359772f, 0.08204572f, 0.00751824f, 0.09681829f, -0.25280982f, 0.28795609f, 0.02398447f, -0.10510256f, 
    -0.10296930f, -0.10761993f, -0.07333710f, 0.12206203f, -0.00514705f, 0.03107484f, -0.01385522f, 0.02952080f, 
    -0.29871753f, -0.02211580f, 0.20342301f, -0.15159382f, 0.11869688f, 0.14354776f, -0.25226110f, 0.06666432f, 
    -0.00468802f, -0.21782705f, -0.09902275f, -0.09372641f, -0.00441540f, -0.13073280f, 0.03926881f, 0.04267132f, 
    0.04294073f, -0.17920615f, -0.01650291f, -0.03861238f, 0.06484880f, 0.12704162f, 0.05887381f, -0.08225293f, 
    -0.00351326f, 0.02091469f, 0.11299441f, 0.22550309f, 0.14327367f, 0.02519441f, -0.09085222f, -0.08877686f, 
    -0.00784679f, -0.12420163f, 0.15070017f, 0.11145647f, 0.15691328f, -0.15869313f, 0.10323402f, -0.06424145f, 
    -0.00659811f, -0.02759332f, -0.06929088f, -0.18149959f, -0.03509579f, 0.05273306f, 0.20255470f, 0.06043319f, 
    0.22474214f, -0.13672875f, 0.12729557f, 0.05600280f, -0.05666864f, -0.06814209f, -0.06209441f, -0.01811161f, 
    0.01713143f, -0.10384278f, -0.00576183f, -0.19931297f, 0.37000296f, 0.22450799f, -0.07869644f, 0.13929869f, 
    0.06930079f, -0.01072485f, -0.05718024f, -0.11846760f, -0.16677679f, 0.03904785f, 0.04151482f, -0.13177818f, 
    -0.10937191f, 0.40258041f, -0.02753200f, 0.06424079f, -0.13395935f, 0.03623356f, -0.22059879f, 0.08062278f, 
    0.09094374f, -0.00527104f, -0.05576653f, -0.09659190f, -0.16467111f, -0.01723301f, -0.02420937f, -0.34986183f, 
    0.15175234f, -0.22852522f, -0.08599570f, 0.11174068f, 0.00794559f, 0.09255899f, -0.05202436f, 0.09066154f, 
    0.04987447f, -0.32079801f, -0.06639656f, -0.16117027f, -0.04018066f, 0.03952031f, 0.05856391f, 0.07002373f, 
    -0.03863301f, -0.14353338f, 0.13833663f, 0.04353651f, 0.15795927f, -0.00577607f, -0.05191633f, 0.24841392f, 
    0.12889022f, -0.11899906f, 0.00878244f, -0.00419116f, 0.13353612f, -0.06478631f, 0.05951158f, -0.22419885f, 
    -0.37989202f, -0.16384794f, -0.19770378f, -0.36878127f, -0.11994933f, -0.09051529f, 0.09814091f, -0.09038529f, 
    0.02840296f, 0.16221021f, -0.10289782f, 0.09224727f, -0.17611051f, -0.01906031f, 0.06458721f, 0.14361182f, 
    -0.28155282f, -0.06683597f, -0.10008106f, -0.04361844f, -0.01997702f, -0.02381849f, -0.00191849f, -0.11473741f, 
    0.12065279f, -0.06783069f, 0.16214149f, 0.19667797f, -0.13163389f, -0.10048437f, -0.01078525f, -0.20161295f, 
    -0.09658794f, 0.04174060f, -0.09603556f, -0.14485608f, -0.09016249f, -0.18278961f, -0.02845498f, 0.10213939f, 
    0.18550061f, 0.07019810f, -0.00270757f, 0.08141097f, 0.00657636f, 0.20428826f, 0.06058942f, 0.00000996f, 
    0.13785282f, -0.08392353f, 0.16326226f, 0.24919412f, -0.09235719f, -0.13005157f, -0.11356221f, -0.17575796f, 
    0.05442207f, -0.13614835f, -0.05221777f, 0.00283533f, -0.35700604f, 0.21115777f, 0.13048318f, 0.03404705f, 
    -0.03281203f, -0.05006274f, -0.10406193f, -0.06290640f, 0.00016527f, 0.11576907f, -0.12802795f, 0.05519018f, 
    0.06986633f, -0.08932137f, -0.20001857f, 0.03816473f, 0.13598843f, 0.02150996f, 0.00304399f, -0.07062169f, 
    0.08416458f, -0.05868525f, 0.12817433f, 0.06862801f, -0.00267854f, 0.08586158f, -0.36202478f, -0.27907720f, 
    0.06439036f, -0.13915810f, -0.18398124f, -0.10360725f, 0.09911320f, 0.00578595f, 0.04509420f, -0.02892984f, 
    -0.16066967f, -0.29460758f, 0.23326968f, 0.13524103f, 0.00322980f, -0.16306370f, -0.05784146f, 0.12648627f, 
    0.12382530f, 0.03656841f, 0.09342422f, -0.20315032f, 0.08952979f, -0.28808093f, -0.31394234f, 0.06880553f, 
    0.12327890f, -0.17770253f, -0.02612808f, -0.00823966f, 0.10628653f, -0.06170694f, -0.11055250f, 0.03212864f, 
    0.14929655f, 0.40856054f, -0.24856637f, -0.14582784f, 0.07556299f, -0.03518381f, 0.03487502f, 0.03055776f, 
    0.03151540f, 0.00268526f, 0.22208782f, 0.15105240f, 0.19533360f, 0.12464380f, -0.02334878f, -0.01363559f, 
    0.03101366f, -0.01153350f, 0.06661912f, 0.00763988f, 0.14548680f, 0.05765981f, 0.15477274f, 0.07641511f, 
    0.02333226f, -0.08929469f, -0.14493203f, 0.03258223f, 0.06706721f, -0.00043256f, -0.07298303f, -0.11464736f, 
    0.11381766f, -0.13633986f, -0.10163843f, -0.04172982f, -0.01326502f, 0.13504060f, 0.13223137f, 0.12827568f, 
    -0.24734804f, -0.04249791f, 0.09186307f, 0.02812951f, 0.07954115f, -0.09533782f, 0.11453370f, 0.13656950f, 
    -0.00349670f, 0.10312075f, -0.28539321f, -0.35371634f, 0.09524914f, -0.16621763f, -0.04080479f, 0.06964923f, 
    0.09899291f, -0.07534785f, 0.06657561f, -0.09244721f, -0.23086996f, 0.08871111f, 0.05082741f, -0.30875701f, 
    0.19214460f, -0.10428976f, -0.05123627f, 0.08144469f, -0.05843922f, -0.09512192f, -0.13756438f, -0.03386866f, 
    0.88575417f, 0.10561859f, -0.05997981f, -0.12458578f, 0.21259493f, -0.05071409f, -0.00954634f, 0.23872432f, 
    0.00477100f, 0.12424758f, 0.04069849f, 0.11094642f, 0.24047045f, -0.72231150f, -0.06264865f, 0.05364582f, 
    -0.13820112f, 0.04160869f, -0.06550677f, 0.11957438f, -0.10922238f, -0.02104101f, 0.15397862f, -0.10069165f, 
    -0.10852636f, -0.06071869f, -0.03615031f, -0.16525196f, -0.16218501f, 0.00118840f, 0.07241043f, -0.02415894f, 
    0.09812463f, 0.07651632f, 0.06524322f, 0.04948560f, -0.33541203f, -0.05035309f, 0.11262680f, -0.26895672f, 
    0.01850954f, -0.15640216f, -0.04255749f, -0.16313311f, 0.05890568f, -0.11503949f, -0.03333836f, 0.05395296f, 
    -0.06397420f, 0.04628338f, 0.15376362f, -0.34511855f, 0.01827632f, 0.05887062f, -0.12179065f, -0.07612595f, 
    -0.15508755f, 0.05212129f, -0.00380649f, 0.02614749f, -0.07887828f, -0.14793755f, -0.10192730f, 0.03117236f, 
    -0.02117489f, -0.02118469f, 0.01622487f, -0.22065207f, 0.23803441f, -0.06508244f, -0.07209855f, -0.06455763f, 
    -0.04517765f, -0.15936616f, 0.19004072f, -0.07780278f, 0.03517325f, -0.03587510f, -0.04936434f, -0.03386362f, 
    -0.06348913f, -0.00203272f, 0.00958022f, 0.19416733f, -0.08878997f, 0.00417319f, -0.07145368f, -0.17860098f, 
    0.24500899f, 0.00368799f, -0.05662981f, -0.09445173f, -0.10187334f, -0.20872745f, -0.13569249f, -0.06423777f, 
    -0.18961686f, 0.28438506f, -0.28290403f, -0.38682908f, 0.23137826f, -0.11204003f, -0.07133356f, 0.01739306f, 
    -0.06977147f, 0.15378311f, -0.10132865f, -0.23501986f, 0.25442961f, -0.30218303f, -0.06706980f, -0.15073064f, 
    -0.01519122f, 0.01789680f, -0.01317689f, -0.06254035f, -0.05678341f, -0.03846939f, 0.09354564f, -0.10995638f, 
    0.45429027f, -0.01070540f, 0.09465257f, 0.09376610f, 0.12574810f, 0.00071462f, 0.05566741f, -0.13204652f, 
    -0.01271246f, -0.00782944f, -0.13787968f, 0.17010346f, -0.15307651f, -0.03434025f, -0.07925316f, 0.05830767f, 
    0.16748345f, 0.05059252f, 0.02786680f, -0.00339908f, -0.01505496f, -0.04029625f, -0.01749553f, -0.03811337f, 
    -0.07296991f, 0.42850676f, 0.28035200f, 0.35312968f, -0.00475563f, 0.00609115f, -0.08961037f, 0.36374089f, 
    0.07815646f, -0.00271031f, -0.03376464f, 0.06913667f, -0.04477243f, 0.05804771f, 0.02334032f, 0.08709554f, 
    0.10138513f, -0.04576895f, 0.07769264f, 0.18529804f, 0.09586293f, -0.00578249f, -0.03630196f, 0.09454379f, 
    -0.17406544f, -0.00951864f, -0.18036295f, -0.04843178f, -0.11616294f, -0.02533368f, 0.18585403f, 0.04076308f, 
    -0.02869361f, 0.09595121f, -0.21915574f, 0.11262179f, -0.58202171f, 0.40087762f, -0.59719765f, -0.36400142f, 
    0.00294796f, 0.13197568f, -0.01077492f, -0.00713397f, -0.16227336f, 0.02829526f, -0.05787617f, -0.01294206f, 
    -0.22374578f, -0.04154935f, -0.06265107f, 0.52348936f, 0.04541699f, 0.15210146f, 0.03856493f, 0.09152291f, 
    0.00426592f, 0.00590678f, -0.17080420f, -0.26936224f, 0.04982417f, -0.42029372f, -0.00748172f, 0.04539146f, 
    0.14944787f, 0.01518827f, -0.02555383f, 0.12205089f, -0.07784056f, -0.00602684f, -0.01129254f, 0.05915511f, 
    -0.09943658f, 0.09835266f, -0.07799558f, -0.14194699f, 0.06723496f, 0.06264986f, -0.05401101f, 0.04638477f, 
    0.16947156f, 0.17275855f, 0.10420789f, 0.08901874f, -0.27098313f, 0.11426947f, 0.04920967f, -0.52649707f, 
    0.06724344f, 0.09832595f, -0.03813237f, 0.00233873f, 0.06412695f, -0.06518973f, -0.20942637f, -0.11372551f, 
    -0.48611346f, 0.29502839f, -0.08796670f, 0.07297369f, 0.02648230f, -0.10983115f, -0.05111339f, 0.02369341f, 
    -0.06869569f, 0.13191091f, 0.12571897f, 0.09722700f, -0.14796582f, -0.00262398f, -0.03400020f, 0.20697962f, 
    -0.05651159f, -0.02120808f, -0.03464512f, 0.13024685f, 0.02195463f, 0.09300124f, 0.02423085f, 0.07182527f, 
    0.08747495f, -0.00499050f, 0.28809267f, -0.00415072f, -0.05178100f, 0.15717427f, -0.03579078f, -0.09783234f, 
    -0.15326194f, -0.08029241f, -0.00129192f, -0.00109044f, -0.66373158f, 0.04530709f, 0.22121333f, 0.02201077f, 
    0.12635790f, 0.06088180f, -0.10022493f, -0.00013192f, -0.11466700f, -0.00697839f, -0.05170888f, -0.02174292f, 
    -0.11532471f, 0.18420307f, 0.06630803f, -0.23857546f, 0.01028962f, -0.05275533f, 0.06204161f, -0.19781995f, 
    -0.06283548f, 0.04145930f, -0.03601317f, 0.07041591f, -0.09018420f, 0.06603634f, 0.24290977f, 0.04038481f, 
    -0.08600649f, 0.08800261f, -0.18849440f, -0.11368284f, 0.06492335f, -0.12712853f, 0.15835620f, -0.26608771f, 
    0.09723368f, -0.08107197f, 0.38754684f, -0.14681397f, -0.03771969f, 0.24688101f, -0.04430199f, 0.08807687f, 
    -0.04178679f, 0.00309664f, -0.13796656f, -0.27283955f, 0.31405738f, 0.09355952f, 0.29904705f, -0.06522791f, 
    0.06937546f, 0.08992441f, 0.15868631f, -0.25504687f, 0.17136480f, 0.12470515f, -0.10264391f, 0.09017821f, 
    -0.90903050f, 0.27591661f, 0.13988239f, -0.04032288f, 0.06232802f, 0.05727592f, -0.00179256f, 0.13941306f, 
    -0.00591756f, -0.01647210f, 0.04067589f, 0.04184614f, -0.43397582f, -0.53941560f, 0.04982999f, -0.28178993f, 
    0.16899267f, 0.08398037f, -0.00906846f, 0.06375530f, -0.22416300f, -0.24684887f, -0.01631039f, -0.04401501f, 
    -0.44220480f, 0.20189093f, -0.07885917f, -0.00563307f, 0.01647024f, 0.07081798f, 0.02900220f, 0.11272422f, 
    -0.00313478f, -0.00177439f, 0.04202152f, 0.13613743f, -0.45188680f, -0.19256802f, -0.15705046f, 0.04782685f, 
    -0.01324350f, -0.01309391f, -0.01127513f, -0.00675125f, 0.00581735f, 0.14226387f, 0.13877317f, 0.07227363f, 
    -0.25639763f, 0.04028128f, 0.00018531f, 0.06567821f, -0.12209103f, 0.04075994f, 0.01206454f, -0.18635702f, 
    0.00263889f, -0.02769043f, -0.16307998f, -0.01035462f, 0.17018440f, 0.09818392f, 0.06421424f, -0.04413952f, 
    0.02259545f, 0.10612036f, -0.08883164f, 0.03526391f, 0.07299828f, 0.15614650f, 0.00973032f, 0.17325781f, 
    0.29724279f, 0.21218513f, 0.10554423f, -0.13882916f, 0.19608267f, 0.01680025f, 0.05663407f, 0.09738639f, 
    0.01888239f, 0.24406229f, -0.03459644f, 0.10662437f, 0.10360742f, 0.04697591f, -0.12769771f, 0.11966636f, 
    -0.09703692f, -0.07107964f, 0.08328025f, -0.03470054f, -0.03669466f, 0.05911643f, 0.03005610f, 0.00170957f, 
    -0.05040890f, 0.13719840f, 0.11568741f, -0.09097620f, 0.17177914f, 0.18846378f, -0.02675474f, 0.06984232f, 
    0.08432378f, -0.03499308f, 0.01615634f, 0.01650456f, 0.14116479f, -0.00391832f, -0.03254285f, 0.01259474f, 
    0.08259766f, -0.00107356f, -0.03081181f, 0.02250322f, 0.04031440f, 0.14059673f, 0.10848013f, 0.11622638f, 
    0.04262872f, 0.13391486f, -0.03645745f, -0.02836122f, -0.04084238f, 0.03880394f, -0.05764119f, -0.11466704f, 
    0.01583941f, -0.18229707f, -0.07085833f, -0.26124239f, -0.53281915f, 0.01406765f, -0.07290041f, -0.10670842f, 
    0.11967923f, -0.07803553f, -0.07560600f, -0.00865041f, 0.04881351f, 0.06669421f, -0.03021261f, 0.19795284f, 
    -0.72732592f, -0.30931911f, -0.20104592f, -0.35684934f, -0.06805650f, 0.08545034f, -0.06512553f, -0.01360907f, 
    -0.06354388f, 0.00639889f, 0.24268126f, 0.12642014f, -0.21853815f, 0.21985166f, -0.16230768f, -0.08705314f, 
    0.01181411f, 0.30633768f, -0.00080251f, 0.14662854f, -0.12805581f, 0.11112843f, 0.27415302f, 0.08980657f, 
    0.49279892f, 0.01556053f, -0.22725426f, -0.06721640f, -0.14262743f, -0.14283714f, -0.09121326f, 0.03108484f, 
    -0.01911659f, -0.06670924f, 0.00571787f, -0.27122188f, -0.62446147f, -0.07951912f, -0.20011443f, -0.36233443f, 
    -0.01372052f, 0.11719319f, -0.12599087f, -0.02709983f, 0.02145165f, -0.06208894f, -0.19105528f, 0.01300977f, 
    -0.02405696f, -0.24854885f, 0.06721116f, -0.00982752f, -0.08414767f, 0.08666839f, -0.00912765f, -0.11445309f, 
    0.15845636f, -0.10614510f, -0.14003737f, -0.16260257f, 0.05877289f, 0.18140057f, 0.12344266f, -0.11138633f, 
    0.14885163f, -0.19748698f, -0.00274946f, -0.05712998f, 0.15264304f, -0.04856591f, 0.10280337f, 0.01746352f, 
    0.36867303f, 0.16047738f, -0.02689749f, -0.00986952f, 0.02762680f, 0.16683218f, -0.03151660f, 0.10599083f, 
    -0.10811295f, -0.11190717f, 0.16202325f, -0.05637483f, -0.50681692f, -0.25430599f, -0.30623168f, -0.14233570f, 
    0.11073203f, -0.16860570f, -0.10380124f, 0.05752616f, 0.03880233f, -0.01265477f, -0.06565961f, 0.00806696f, 
    0.48261520f, -0.01708761f, -0.08782100f, 0.02166623f, 0.02304952f, -0.09195627f, 0.17210041f, -0.11093143f, 
    -0.09555274f, 0.00022961f, -0.05906350f, 0.11473096f, 0.33005610f, 0.18366660f, -0.01403933f, -0.05851259f, 
    -0.20794944f, -0.06991157f, -0.01825994f, -0.10251086f, -0.08902509f, -0.08818277f, -0.16265506f, -0.10752541f, 
    0.28808990f, 0.15004694f, -0.14478678f, -0.09005453f, -0.18111841f, -0.15245607f, 0.03240859f, 0.12191028f, 
    0.07593180f, 0.00375550f, -0.16612381f, 0.01346479f, -0.14445125f, -0.01601413f, -0.06506154f, -0.36177585f, 
    0.13175155f, -0.21673496f, -0.03064638f, 0.07165369f, 0.01834854f, -0.00845472f, 0.11466125f, 0.21653026f, 
    0.20416422f, -0.07334705f, -0.12302276f, 0.12056588f, 0.00699064f, -0.20934153f, -0.12420767f, 0.07609081f, 
    -0.01554875f, -0.04612191f, -0.24673790f, 0.07075318f, 0.06149764f, -0.15813504f, -0.04663989f, 0.09859679f, 
    0.00069506f, 0.03675869f, 0.14631298f, 0.00662616f, -0.00996190f, -0.06004222f, -0.07508376f, -0.03879203f, 
    -0.74332237f, -0.36786553f, 0.12999895f, 0.10207438f, 0.04516649f, 0.08374505f, 0.03170326f, 0.01270084f, 
    0.25539011f, 0.19736448f, 0.03646538f, 0.14609967f, 0.01966916f, -0.09397297f, -0.04168933f, 0.09147322f, 
    0.09427509f, 0.04768556f, 0.03327663f, -0.12243014f, 0.11873452f, 0.06019349f, 0.06680351f, -0.17261773f, 
    -0.33943829f, -0.24005726f, 0.19148800f, -0.05129359f, -0.01612874f, -0.18908983f, 0.01196070f, 0.09722556f, 
    0.02388054f, 0.09074567f, 0.18363775f, 0.01561005f, -0.49660182f, 0.09696097f, 0.10249691f, 0.06092289f, 
    0.08627694f, 0.05960650f, 0.12397262f, -0.16516584f, -0.10246099f, -0.13770588f, -0.01039616f, 0.02109175f, 
    -0.04325464f, 0.13595444f, 0.02676710f, 0.02143345f, 0.19426587f, -0.10366269f, -0.03292955f, -0.05272684f, 
    -0.12051928f, 0.02469326f, 0.19716763f, 0.01040129f, -0.29609525f, -0.06804561f, -0.03237230f, 0.24595413f, 
    0.04104385f, 0.03239498f, 0.02323537f, 0.10046024f, -0.04143046f, 0.05351774f, -0.08576805f, 0.19745509f, 
    -0.95443869f, -0.98970461f, 0.06859613f, 0.03235798f, 0.08241109f, 0.08775327f, 0.02849996f, 0.06343309f, 
    0.20869327f, 0.06642176f, 0.12081026f, 0.01169646f, 0.08088280f, 0.11198554f, 0.02266523f, 0.05581800f, 
    -0.03637328f, -0.15432608f, 0.07112148f, -0.02408024f, 0.01097267f, 0.21062072f, 0.11616997f, 0.17770708f, 
    -0.58605182f, -0.20158322f, 0.17544918f, 0.00001041f, 0.07190702f, 0.21102686f, 0.07561006f, -0.06260220f, 
    0.00695868f, -0.14504570f, -0.06801616f, 0.07087605f, -0.05773302f, -0.19252507f, -0.18038316f, 0.17433298f, 
    -0.02717500f, 0.01954522f, -0.12347023f, 0.00740169f, -0.07405236f, -0.03441464f, -0.24965383f, 0.00632621f, 
    -0.54827476f, -0.17138553f, 0.16562138f, -0.15915376f, -0.08708213f, -0.01286066f, -0.09776745f, 0.12353018f, 
    -0.04043704f, 0.04792359f, 0.09611787f, -0.10655553f, 0.04549764f, 0.25385001f, -0.03270187f, 0.11591870f, 
    0.02958862f, 0.17160664f, 0.12185317f, -0.24241017f, -0.27421698f, 0.02509582f, -0.11094093f, -0.23259081f, 
    -0.19638771f, -0.01016684f, -0.24586122f, 0.15947436f, 0.14915752f, -0.03819023f, 0.11651224f, 0.09341074f, 
    0.16259930f, 0.03657195f, -0.12752318f, -0.28400171f, 0.23837455f, -0.15757573f, -0.10539725f, 0.08715326f, 
    -0.21818671f, -0.00550276f, -0.05207929f, -0.07072987f, 0.17360635f, -0.08343142f, -0.08825269f, -0.02084442f, 
    0.49503076f, -0.07899987f, -0.19717303f, 0.25671256f, -0.14415815f, -0.00304625f, -0.02722623f, -0.02086432f, 
    0.10355556f, 0.10682657f, 0.11450055f, -0.02202338f, 0.24990194f, 0.07230021f, -0.01976878f, -0.02919674f, 
    0.11374221f, -0.05116554f, -0.11498100f, -0.03220794f, -0.04264033f, 0.05645384f, -0.13422590f, -0.03966353f, 
    0.11404759f, 0.09646616f, -0.27301207f, 0.01925485f, -0.22893450f, -0.01181304f, -0.06633248f, -0.29126522f, 
    0.05253234f, 0.06583842f, -0.12616982f, -0.11239222f, 0.27063861f, -0.33955899f, 0.04368386f, -0.11470918f, 
    -0.00687170f, -0.07029302f, -0.00566842f, -0.12610114f, 0.07176660f, -0.19158182f, 0.07227590f, -0.08954363f, 
    0.38230765f, -0.30551389f, -0.23881248f, -0.11834921f, -0.06350996f, 0.00178248f, -0.00671378f, 0.02726386f, 
    0.06465621f, -0.03932079f, -0.14881863f, -0.03072678f, -0.44791296f, 0.20995389f, -0.04027167f, -0.01238965f, 
    -0.16150028f, 0.04000598f, 0.01197456f, -0.01362097f, -0.09378953f, -0.06243250f, -0.22427997f, -0.20885061f, 
    -0.27003539f, -0.13953216f, 0.19303927f, -0.21550441f, 0.02251924f, 0.08146657f, -0.06076759f, -0.07189123f, 
    0.09944356f, 0.10436757f, 0.16593431f, 0.17598209f, -0.15343845f, -0.41239610f, -0.40156692f, -0.25881091f, 
    -0.07661509f, 0.06836860f, 0.13342415f, 0.05695970f, -0.04445320f, 0.03093064f, 0.09002244f, -0.07319222f, 
    -0.12554905f, 0.08705172f, 0.00425103f, 0.10211384f, 0.09519403f, -0.13837683f, 0.03629621f, -0.14983232f, 
    -0.01661924f, 0.07052604f, 0.02362182f, -0.01919995f, -0.17186838f, 0.24936160f, -0.00100707f, -0.15038212f, 
    0.02707857f, 0.13138479f, -0.14274924f, -0.01190263f, 0.03578911f, -0.04180895f, 0.06790596f, -0.00199522f, 
    -0.34582701f, 0.25003368f, -0.04900647f, 0.01698177f, 0.14323871f, -0.06200248f, -0.04447796f, -0.05816381f, 
    0.10145872f, -0.05545961f, -0.11713291f, -0.19203076f, 0.25310624f, -0.24253774f, -0.29365972f, -0.10297278f, 
    -0.01236160f, -0.04117299f, 0.02659800f, -0.09985089f, 0.02433554f, -0.00581376f, -0.05604817f, -0.02328861f, 
    0.01245063f, 0.12853442f, -0.05029048f, -0.10556328f, -0.13734102f, -0.03886721f, 0.06534585f, 0.06053295f, 
    -0.16595793f, -0.12580729f, 0.12016828f, 0.06004482f, 0.06882441f, -0.07828209f, 0.06238081f, 0.16211481f, 
    -0.06819465f, 0.01375959f, -0.04914056f, 0.06025637f, -0.14943120f, 0.01026302f, 0.11799434f, -0.14634016f, 
    -0.30564570f, -0.23079214f, -0.13232002f, -0.02730333f, 0.00532313f, 0.08327378f, 0.14462529f, 0.21277095f, 
    -0.08592682f, -0.00839748f, -0.08141088f, -0.13752317f, 0.30133507f, -0.33920500f, -0.03096882f, 0.17239153f, 
    0.00621527f, -0.14591455f, 0.01703229f, 0.03920222f, 0.00376886f, -0.11304513f, 0.14531496f, 0.02984843f, 
    0.22310507f, -0.16133438f, 0.09936849f, -0.18202989f, -0.10853137f, -0.14426322f, 0.14168082f, -0.01060558f, 
    -0.20393707f, 0.07975949f, 0.07442515f, 0.01544143f, 0.42329085f, 0.15229627f, 0.01901258f, 0.03990319f, 
    -0.01734609f, -0.11797540f, 0.07715701f, 0.06125485f, 0.15940791f, 0.18585795f, 0.10601126f, 0.08433589f, 
    0.52121985f, 0.42799994f, -0.36649212f, -0.14345101f, 0.09143784f, -0.05998801f, -0.08158928f, 0.19802493f, 
    -0.00693921f, 0.01841833f, -0.03253359f, 0.04691741f, 0.03641346f, -0.11010174f, -0.17298223f, 0.23146372f, 
    0.12454397f, 0.05716219f, -0.10723331f, -0.21928509f, 0.11028616f, 0.00170433f, 0.06919827f, 0.08833595f, 
    0.14002509f, -0.08293028f, -0.04802929f, -0.52615976f, 0.19149223f, 0.10958242f, 0.08487377f, 0.16987866f, 
    -0.04795999f, -0.03756493f, -0.06433665f, 0.02924181f, 0.63446587f, 0.05755877f, 0.02400351f, -0.04461055f, 
    -0.04022178f, -0.09201961f, -0.05810705f, 0.01975069f, 0.02425860f, 0.05411886f, -0.04541703f, 0.09006146f, 
    0.25853390f, -0.28173158f, -0.14120395f, 0.08160478f, 0.04489646f, 0.03779441f, -0.17930517f, -0.11284495f, 
    0.01410814f, -0.04657099f, -0.24847187f, -0.00194378f, 0.16300465f, -0.43357411f, 0.02501976f, -0.08769520f, 
    -0.00978045f, -0.02213928f, -0.05730304f, 0.12984031f, -0.02579043f, -0.09496307f, 0.06320416f, -0.00244927f, 
    -0.04938123f, 0.04432131f, 0.03788228f, 0.06048280f, 0.25368527f, 0.10224170f, -0.03625663f, -0.04199625f, 
    0.07033533f, 0.14863464f, -0.07287997f, 0.03974831f, 0.16010875f, -0.11558453f, -0.08459075f, 0.00182357f, 
    -0.10160363f, 0.14554468f, -0.11799016f, 0.05305595f, -0.24221842f, -0.06180748f, -0.23270749f, -0.18450993f, 
    -0.55348241f, 0.06533587f, 0.06697883f, 0.11149129f, 0.27395865f, 0.01833926f, 0.05811081f, 0.10260457f, 
    0.11982834f, 0.04239447f, 0.07408319f, 0.00234460f, -0.44397280f, 0.16086039f, -0.07817431f, -0.05067695f, 
    0.19719428f, -0.11593314f, 0.09394661f, 0.01077757f, 0.10825387f, 0.07112875f, -0.00722308f, 0.13907474f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09129550f, -0.01459053f, -0.10344228f, -0.02687433f, 0.05652727f, -0.01214155f, 0.04209213f, -0.07804162f, 
    -0.01911349f, 0.03474249f, 0.11569436f, 0.02451218f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
