#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.30946463f, -0.60722101f, -0.69924897f, -0.52829999f, -0.24777232f, -0.00413196f, 0.79699481f, 0.25320730f, 
    -0.34920576f, 0.59394777f, -0.67913115f, -0.05241942f, -0.33514312f, -0.31835207f, -0.40483576f, -0.80661452f, 
    -0.10497743f, 0.10673694f, 0.04198043f, -0.23448591f, 0.18329911f, -0.27731001f, 0.16937368f, -0.06969207f, 
    0.10690448f, 0.82752502f, 0.53976333f, 0.47520798f, 0.33278751f, -0.50693184f, -0.21331546f, -0.40140322f, 
    0.39222533f, 0.13720535f, 0.07302166f, -0.37996760f, -0.49850270f, -0.31090614f, 0.07082506f, 0.25060609f, 
    -0.63975567f, -0.38011181f, -0.33896738f, -0.60000181f, -0.11426987f, -0.11145328f, 0.13443181f, -0.42642665f, 
    0.39824772f, -0.00132856f, 0.06582013f, -0.91886413f, 0.61712211f, 0.84407777f, 0.49118811f, 0.68431312f, 
    0.84635222f, 0.47058052f, -0.08657274f, -0.70929962f, -0.31966710f, -0.47002384f, -0.52300209f, -0.16007580f, 
    -0.50958955f, -0.12199948f, -0.24631830f, 0.13402876f, -0.19804031f, -0.15829347f, -0.47504702f, -0.21492793f, 
    -0.22606485f, -0.06820208f, -0.32304338f, 1.01668167f, 0.13536400f, 0.92473525f, 0.08072419f, -0.86321712f, 
    -0.62052649f, 0.18458247f, -0.94083846f, -0.19194169f, -0.68451732f, 0.31372726f, 0.37420836f, -0.08636624f, 
    0.09061353f, -0.07969803f, 0.13777089f, -0.53559852f, 0.09774169f, 0.22671250f, 0.17126362f, -0.02994747f, 
    0.38401371f, 0.11160455f, 0.02710023f, 0.34947354f, 0.27112216f, -1.58227146f, -0.24173597f, 0.95912319f, 
    0.06450181f, -1.13043833f, 0.07158067f, 0.43078542f, -0.08276781f, -0.45668122f, 0.18394551f, 0.21533343f, 
    0.10648482f, -0.20620753f, 0.16750875f, -0.05525991f, 0.12760450f, -0.47851399f, -0.19857985f, -0.07294856f, 
    -0.07133287f, -0.03980544f, 0.09783808f, -0.13195439f, 0.49415776f, 0.14437610f, 0.67257500f, 0.79526228f, 
    0.97490448f, -0.94782501f, -0.26595795f, -0.04585799f, 0.13075861f, -0.28591177f, 0.47504976f, 0.23141232f, 
    0.33068612f, 0.10537931f, 0.41477460f, 0.56684119f, 0.08356015f, -0.13738328f, -0.07968821f, 0.04891007f, 
    -0.24782145f, 0.01575797f, 0.31190702f, -0.07724754f, 0.32955763f, -0.16123143f, -0.18519956f, -0.10495967f, 
    -0.67267728f, -0.51102126f, -0.38275638f, 0.65637404f, 0.91863275f, -1.05161953f, 0.00154280f, 0.32822448f, 
    -0.32308152f, 0.20700680f, 0.08406134f, -0.21814382f, 0.66162950f, -0.04167876f, -0.15927617f, -0.02956584f, 
    0.18758065f, -0.04387844f, 0.03632797f, 0.13036852f, 0.20014136f, 0.12279776f, 0.00050067f, -1.20210254f, 
    1.04649568f, -0.04036249f, -0.72381568f, 0.42093274f, 0.20283380f, 0.48453248f, -0.88545704f, -0.22346371f, 
    -0.60380310f, 0.26516172f, 0.25834242f, -0.06580150f, 0.20662791f, -0.00340924f, -0.45399579f, 0.05256902f, 
    -0.41574994f, -0.45985362f, -0.06645270f, 0.19899799f, 0.05680712f, 0.22587004f, 0.13029887f, -0.09956186f, 
    -1.00329947f, 1.45327187f, 0.23248783f, -0.67176259f, -0.07991743f, -0.66007829f, 0.87140888f, -0.04913751f, 
    0.24089138f, 0.09215652f, -0.21212956f, 0.31609306f, -0.02221218f, -0.18190344f, 0.10875876f, 0.36298329f, 
    -0.07477544f, 0.32227936f, 0.09500359f, -0.01714951f, 0.25601685f, 0.31531075f, 0.20286420f, 0.29365498f, 
    0.35879487f, 1.03864324f, 0.13220349f, 1.20944846f, -0.25494733f, -0.70080614f, 0.46356317f, -0.90415627f, 
    0.55805773f, 0.00252634f, 0.32011732f, 0.68342990f, 0.29481703f, 0.34312710f, 0.01647638f, -0.23511140f, 
    -0.14834878f, 0.28510487f, 0.27205518f, -0.01268660f, -0.04317442f, -0.11099432f, 0.37610736f, 0.38959488f, 
    0.31904402f, 0.11076078f, -0.47952676f, -0.25036409f, -0.33322433f, -0.60782081f, -0.79627275f, 0.20495713f, 
    -0.07304394f, 0.05603911f, -0.59580660f, -0.82336318f, 0.31423342f, 0.37095800f, 0.41668147f, 0.39382800f, 
    -0.14949954f, 0.31510067f, 0.23943220f, 0.02272838f, -0.36389095f, 0.32091025f, -0.11932265f, -0.33099458f, 
    0.11205885f, 0.05569226f, -0.59019852f, 0.62619805f, -0.59239978f, -0.97949892f, -1.01517057f, -0.02503419f, 
    0.94150829f, 0.80619705f, 0.30975789f, 0.24287172f, 0.36807489f, -0.16033062f, 0.09549811f, -0.26166511f, 
    0.00718891f, -0.27799225f, -0.33127186f, 0.34255296f, 0.08390764f, 0.05312797f, -0.11514239f, -0.25411713f, 
    -0.12460095f, -0.41281158f, -0.28254062f, 0.07108331f, 1.07112777f, 1.19119799f, -0.00035622f, -0.37108949f, 
    -0.00017305f, -0.25657815f, -0.96945620f, -0.07036900f, 0.23226945f, 0.26507843f, -0.03211414f, -0.20192881f, 
    0.05376181f, 0.09040608f, -0.13235444f, -0.01681480f, 0.16932411f, -0.39137915f, 0.01794735f, 0.10245480f, 
    -0.28343260f, 0.01810897f, -0.05006603f, -0.51956826f, 0.25072220f, -1.45207834f, 0.28972372f, 0.84493017f, 
    -0.60577321f, -1.01042962f, 0.37832549f, 0.42867690f, 0.08656617f, 0.33050621f, 0.13562362f, -0.51012641f, 
    -0.07671233f, -0.04354878f, -0.10219749f, 0.09352808f, -0.15750098f, 0.04458708f, -0.04217508f, -0.31146112f, 
    -0.40135339f, 0.34384245f, 0.27322921f, 0.10818165f, 0.26398468f, 0.29514825f, 0.07065766f, 0.11225518f, 
    -0.43167499f, -0.17361423f, 1.14735770f, -0.36533546f, -1.34692824f, -1.03618193f, -0.79160452f, 0.21494406f, 
    -0.41746038f, 0.69458818f, 0.21955578f, 0.19501005f, 0.27650914f, -0.29384860f, 0.07234840f, -0.37039420f, 
    -0.39441887f, -0.29540685f, 0.17177714f, 0.17077662f, 0.13120577f, -0.14569207f, -0.15811530f, 1.28018427f, 
    -0.09280559f, -0.86576027f, 1.16385663f, 0.63756943f, -0.19001417f, 0.35431865f, 0.19586423f, 0.01538204f, 
    0.16255882f, 0.06756344f, 0.15309422f, -0.04480619f, -0.04062530f, -0.34897098f, -0.01945463f, -0.10089448f, 
    0.26402444f, -0.03360087f, -0.35259032f, 0.19579740f, -0.12278748f, 0.22636022f, -0.04017125f, -0.27419430f, 
    0.55392545f, 0.28853533f, -0.11505120f, 0.87979525f, 0.73901361f, 0.93071449f, 0.48241058f, 0.22697090f, 
    0.58472431f, 0.65890336f, -0.18222505f, -0.15233730f, -0.21934795f, -0.14488471f, 0.24143057f, -0.26117134f, 
    -0.17518869f, 0.13831574f, -0.21730398f, 0.05521929f, 0.02987474f, -0.03591091f, 0.28810102f, 0.30712649f, 
    0.36254284f, -0.88801628f, 0.02612989f, -0.76126724f, -0.61197644f, 0.05191050f, -0.44907102f, 0.93481243f, 
    0.04042998f, -0.33898887f, 0.27633503f, 0.06171129f, -0.27519974f, -0.02378572f, 0.04003376f, 0.46449515f, 
    0.44221669f, 0.17582147f, -0.21794651f, 0.45402917f, -0.32825649f, 0.02745430f, 0.15765968f, 0.39757150f, 
    -0.16534665f, 0.10151142f, 0.34618291f, 0.76119596f, 0.45910907f, 0.41598779f, 0.80529964f, -0.28669161f, 
    1.10702407f, 0.66317618f, -0.27382201f, 0.55444527f, -0.52859628f, -0.13856873f, 0.09618525f, -0.12781784f, 
    -0.14991190f, 0.06841125f, 0.26647115f, 0.36943784f, 0.16340929f, -0.29723927f, 0.07817890f, 0.04996870f, 
    -0.09400638f, -0.46043134f, 0.10668425f, -0.75228143f, -1.25859237f, 0.27291211f, -0.41627273f, -0.70611334f, 
    0.00730034f, -0.73833859f, 0.25641340f, 0.06130021f, -0.30020508f, -0.02826994f, -0.10252988f, -0.21369916f, 
    0.39999339f, -0.44767082f, 0.07432220f, 0.16410294f, -0.14531830f, 0.14232330f, 0.24472359f, -0.05654582f, 
    -0.20364803f, 0.04062078f, -0.20367110f, 0.17832623f, -0.15686589f, -0.53569311f, -0.89105797f, -0.47370133f, 
    -0.30111003f, -0.50401509f, -0.68693864f, -0.11437745f, 0.04483546f, 0.33368370f, -0.60401928f, 0.41356573f, 
    -0.08038028f, -0.02418407f, -0.11791918f, 0.31243381f, -0.01475240f, 0.17958792f, -0.16983533f, 0.13398172f, 
    -0.27827317f, 0.15748826f, -0.30390468f, 0.02639130f, -0.27242851f, -0.58437556f, -1.09668422f, -0.91139233f, 
    -0.19860709f, -0.41666660f, -0.27851740f, 0.20436555f, 0.06746747f, 0.37034363f, 0.74750239f, 0.52826208f, 
    0.05953345f, -0.06761904f, -0.07577098f, -0.26789752f, 0.01577988f, 0.12324302f, 0.33381435f, 0.23338374f, 
    -0.14762253f, 0.13004279f, -0.10412027f, -0.10761192f, -0.01645188f, 0.39806372f, 0.99167937f, 0.76192468f, 
    -0.61275196f, -0.21704739f, 0.77356261f, -0.15290886f, -0.02988676f, 0.36974347f, 0.20610340f, 0.32692459f, 
    -0.31655774f, -0.00968065f, -0.14424020f, -0.58538491f, 0.05885023f, 0.01707764f, -0.35705453f, -0.12936938f, 
    -0.16848734f, -0.07841708f, 0.45141143f, 0.15007512f, -0.07478063f, 0.27376148f, -0.15316011f, 0.74736840f, 
    -0.19486693f, 0.35258269f, -1.16854823f, -0.35276181f, -0.44334090f, 0.43819302f, -0.25526878f, -0.23600550f, 
    -0.85908341f, -0.20648931f, 0.05223224f, 0.20177795f, 0.26776075f, -0.39359617f, -0.17679429f, -0.02433512f, 
    0.26854119f, 0.25388873f, -0.13243435f, 0.17657457f, -0.09088236f, -0.35590702f, -0.20966248f, 0.16010103f, 
    1.31613708f, -0.58297002f, 0.25634569f, 0.69439578f, 0.82679313f, -0.35814860f, 0.17462705f, -0.39816222f, 
    0.03889931f, 0.19193448f, -0.32830968f, -0.22874805f, -0.46550339f, -0.04795830f, -0.11853684f, -0.00645008f, 
    0.01581660f, 0.16065113f, 0.39076173f, 0.25531742f, -0.23621604f, 0.16726574f, -0.38755384f, -0.38495731f, 
    -0.06302035f, 0.66014218f, -0.09120320f, 0.99833721f, 1.11166501f, 0.78184158f, -0.29290438f, -0.37699896f, 
    -0.60098159f, -0.05505919f, 0.04305218f, 0.06251406f, 0.17906363f, 0.15034015f, 0.15878704f, 0.27425662f, 
    -0.53747380f, 0.49800852f, -0.13186061f, -0.28407466f, 0.20343558f, 0.05066755f, -0.02119010f, -0.05838106f, 
    0.00685899f, 0.15204291f, -0.72821254f, -1.06029201f, -0.29312763f, 0.63939607f, 0.45425087f, 0.26989573f, 
    1.20830011f, 0.94596004f, -0.67758292f, 0.00593239f, -0.07131618f, -0.20542003f, 0.40729910f, -0.23357457f, 
    0.33246014f, -0.52754295f, -0.10526352f, -0.18690202f, -0.14944229f, -0.05001149f, 0.38926467f, -0.02088292f, 
    -0.19184037f, 0.24575244f, -0.33789968f, -0.80106032f, 1.04094779f, -0.28901207f, -0.94329840f, -0.59706587f, 
    1.35633695f, 0.21801364f, 0.04737989f, 0.80270445f, 0.52322245f, 0.30651852f, -0.21249829f, -0.30548421f, 
    0.02645927f, -0.21074985f, 0.28011131f, 0.06221358f, -0.01902387f, 0.14625499f, 0.20230417f, -0.02399444f, 
    -0.24859199f, -0.16757572f, -0.07580273f, 0.01903493f, 0.25537729f, -0.15607049f, -0.63065028f, -0.60721719f, 
    0.09229491f, 0.43324777f, -0.56550378f, -0.47041124f, 0.27764434f, -0.43022394f, -0.54639673f, -0.48244745f, 
    0.03768167f, -0.43935406f, -0.62458456f, -0.39565346f, -0.33914334f, 0.12623835f, 0.06572986f, -0.75527984f, 
    -0.68580139f, 0.42174181f, 0.33355224f, 0.33905438f, -0.02431354f, -1.39001834f, -0.54068798f, -0.15879454f, 
    0.82099932f, -0.21426296f, 0.81297374f, 0.82949394f, -0.04664823f, 0.57906777f, 0.28776130f, 0.09463008f, 
    -0.30313289f, 0.41344830f, 0.24036549f, -0.20010653f, -0.07059693f, -0.09621249f, 0.00185805f, -0.26585552f, 
    -0.13630779f, -0.05844530f, -0.01700148f, -0.23498081f, 0.05608658f, -0.16976325f, 1.01605332f, 0.88635689f, 
    0.53107625f, 0.78653127f, 0.90526533f, 0.16054557f, 0.33850905f, 0.10706032f, 0.18310729f, -0.14329445f, 
    -0.04936760f, -0.39925751f, -0.15912889f, -0.01127904f, -0.11155155f, 0.48744732f, 0.34872422f, -0.42571223f, 
    -0.26709294f, 0.43361366f, 0.21211043f, 0.13238730f, 0.83564067f, 0.54689831f, 0.16029586f, 0.58243364f, 
    1.21570551f, 0.68583906f, 0.56537843f, 0.15510856f, -0.15709342f, -0.09817959f, -1.13170898f, -0.67600268f, 
    -0.44393083f, 0.39235863f, 0.26768455f, -0.02042158f, -0.02697779f, -0.35600770f, 0.33108106f, -0.03631745f, 
    0.38212642f, 0.11770425f, -0.02758263f, 0.02340557f, 0.11856452f, -0.02641105f, 0.25331143f, 0.18312284f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02107850f, 0.39123845f, -0.19410203f, 0.23891421f, 0.08213454f, 0.01240962f, 0.36945713f, 0.21932387f, 
    0.19274406f, 0.19581600f, 0.28585842f, 0.20726481f, 0.16402060f, 0.15723772f, 0.37977624f, 0.13070245f, 
    0.20254229f, 0.30196199f, 0.16799320f, 0.15415578f, 0.36121827f, 0.14127888f, 0.33375838f, 0.28763694f, 
    0.03474586f, 0.08025046f, 0.28675765f, 0.07697036f, 0.17373511f, 0.08401546f, 0.36571944f, 0.25018120f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15729791f, -0.04192180f, 0.06749637f, -0.48134926f, 0.08135415f, 0.09502442f, 0.04989095f, 0.17533585f, 
    -0.02622285f, 0.08224586f, -0.01426612f, 0.15008400f, 0.16806683f, -0.09114408f, -0.05456976f, 0.15783782f, 
    -0.15332969f, -0.14436731f, -0.14247660f, -0.08948745f, -0.10989475f, -0.13346556f, 0.02530619f, 0.02384379f, 
    -0.17510355f, 0.25588375f, 0.02739853f, 0.21683398f, -0.18346046f, 0.08691504f, 0.19731879f, 0.03885127f, 
    -0.04739726f, -0.16747777f, 0.09934378f, -0.06036151f, 0.04792145f, 0.15208043f, 0.11100016f, 0.19520354f, 
    -0.13490166f, 0.10245717f, -0.21879028f, 0.07319877f, 0.00315265f, -0.00471629f, -0.07199065f, -0.03870035f, 
    0.07509703f, -0.32538638f, -0.18442482f, 0.36489028f, 0.03915635f, 0.03288662f, 0.04286376f, -0.21521564f, 
    0.07572065f, 0.03446305f, -0.05681612f, 0.04663594f, -0.12131040f, 0.11478915f, -0.36106807f, 0.16980968f, 
    -0.14447817f, -0.04365284f, -0.04024249f, -0.07200553f, -0.07704227f, 0.08827928f, 0.03517899f, 0.02482055f, 
    0.32126886f, -0.04931858f, 0.14640938f, -0.23881693f, -0.13828255f, -0.08657216f, 0.05911215f, -0.07628766f, 
    0.03741009f, 0.01719406f, 0.06271185f, 0.07794049f, -0.16148014f, -0.10166933f, 0.02907247f, -0.05174401f, 
    0.00265337f, 0.04575204f, -0.03162533f, -0.00555500f, 0.03961099f, -0.17342034f, 0.01097703f, 0.05722024f, 
    0.23094766f, -0.11423316f, 0.08974978f, -0.35289419f, 0.17159002f, 0.07391416f, -0.00606265f, 0.00261742f, 
    -0.10017522f, -0.03780985f, 0.05921170f, -0.03713070f, -0.02376560f, -0.11139702f, -0.07086553f, -0.06767812f, 
    -0.17125674f, -0.03244771f, 0.03819162f, -0.13942266f, -0.18508816f, 0.06730447f, -0.05861678f, 0.06715664f, 
    -0.43575898f, 0.02947569f, 0.04630773f, -0.01389229f, -0.09762319f, 0.18114378f, -0.08898650f, -0.08004542f, 
    -0.00946249f, 0.00990140f, -0.12324373f, -0.06789600f, 0.05566598f, 0.27329007f, 0.00642545f, -0.42882431f, 
    0.11314257f, 0.07078113f, 0.05558897f, -0.01672827f, -0.08020765f, 0.07850111f, -0.03841748f, 0.08792420f, 
    0.03010128f, -0.12520406f, 0.05814632f, -0.28565910f, -0.10805248f, -0.05290533f, 0.02792414f, 0.19679007f, 
    -0.00635110f, -0.05561253f, 0.08650426f, -0.13243145f, 0.36862823f, 0.27735403f, 0.20307979f, 0.05255292f, 
    -0.06718387f, 0.07248209f, -0.15574601f, 0.11539628f, 0.05926764f, 0.00711261f, -0.07191195f, -0.00503416f, 
    0.13720845f, -0.12467656f, 0.26230520f, -0.08951728f, -0.03638019f, 0.03431513f, 0.04143428f, -0.13957244f, 
    -0.23453909f, 0.03667377f, 0.03533111f, -0.12751241f, 0.18488523f, 0.07623580f, -0.01594155f, 0.48671117f, 
    -0.23469712f, 0.10413671f, -0.15473267f, 0.12070958f, -0.18168738f, 0.13910109f, -0.15726361f, -0.02677292f, 
    0.12054536f, -0.07001673f, 0.08530614f, 0.25425482f, -0.10499448f, 0.07905646f, -0.07838382f, -0.03776815f, 
    -0.15991472f, 0.04307814f, -0.03767931f, -0.01538750f, 0.14175564f, 0.10340619f, 0.17350578f, -0.31201330f, 
    0.06202433f, 0.02123384f, -0.01599688f, 0.01789673f, -0.04306822f, -0.01365295f, -0.21355583f, 0.02990751f, 
    -0.08901773f, -0.02767893f, 0.10515431f, -0.01806087f, -0.27370799f, 0.03545867f, 0.02241265f, -0.04059912f, 
    0.03714033f, 0.04583652f, 0.00061352f, -0.02764235f, -0.36498559f, -0.18352027f, -0.15521042f, 0.07881426f, 
    -0.04966275f, -0.03573101f, -0.02684701f, 0.02540525f, 0.00862100f, 0.09246238f, -0.10477877f, -0.01433249f, 
    0.12147728f, -0.51463187f, 0.02491595f, -0.23855250f, -0.14169186f, -0.12893492f, 0.10425268f, -0.12561084f, 
    -0.05989689f, -0.06675234f, -0.11362120f, 0.00205196f, -0.13315636f, 0.09374108f, -0.36042807f, -0.27170891f, 
    0.16272169f, -0.07580309f, -0.00545167f, 0.09900323f, 0.07680961f, 0.01548049f, -0.12067296f, 0.09209321f, 
    0.24988660f, -0.01527721f, 0.08449472f, -0.18322943f, -0.10260264f, -0.09146381f, -0.02324110f, 0.07904594f, 
    -0.11264130f, -0.05388943f, 0.10046943f, 0.05923595f, -0.47845453f, 0.20218736f, 0.08045743f, -0.22093405f, 
    -0.04234847f, 0.06776731f, -0.03214995f, -0.00624797f, -0.06203216f, 0.01948456f, -0.10927795f, -0.02746768f, 
    0.35735112f, -0.50053537f, -0.15362760f, 0.27619833f, -0.16424040f, 0.05962970f, -0.03966347f, 0.10102847f, 
    -0.13744083f, 0.02393896f, -0.02395434f, -0.01560547f, 0.26250157f, -0.12028727f, -0.31716982f, 0.21944720f, 
    -0.20169601f, -0.18118832f, 0.08701103f, -0.11722396f, -0.10388666f, 0.08646554f, -0.06148079f, 0.03140819f, 
    -0.66971999f, 0.30557799f, -0.02147250f, 0.05033385f, -0.02982089f, 0.04590961f, -0.13605228f, -0.11141172f, 
    0.03889498f, -0.07992645f, -0.03131966f, -0.01704397f, 0.55772543f, -0.00669697f, -0.00892706f, -0.18426767f, 
    -0.09567845f, -0.04289329f, 0.19543238f, -0.16171144f, -0.01046096f, 0.10738646f, 0.01386116f, -0.01192166f, 
    0.09561812f, -0.08102542f, 0.24448733f, -0.13810253f, 0.15616624f, -0.03880823f, 0.07626421f, -0.02496033f, 
    -0.02351707f, -0.08024089f, 0.08204480f, -0.07330508f, 0.26829982f, 0.14855373f, -0.12667881f, 0.09869985f, 
    0.07004576f, 0.14461769f, -0.03140090f, 0.00061505f, 0.10829113f, -0.11343014f, 0.04224786f, -0.06416815f, 
    0.14426310f, 0.01177632f, -0.08652849f, 0.06859040f, -0.16569208f, 0.00395927f, -0.04811501f, 0.07385394f, 
    -0.03488762f, -0.03738470f, 0.02254831f, -0.18540506f, -0.00151694f, 0.28560552f, 0.11359300f, 0.01327215f, 
    -0.20755586f, -0.11683888f, 0.07208284f, 0.08018991f, -0.08320889f, 0.02253554f, -0.11956739f, -0.02432700f, 
    0.17574728f, -0.06686208f, 0.03972514f, -0.18883966f, 0.00524037f, -0.18181452f, -0.13654931f, 0.04203565f, 
    0.10288087f, -0.09208241f, -0.07755557f, -0.11893255f, -0.03964388f, 0.15021852f, -0.04990180f, 0.19141993f, 
    -0.04965378f, 0.01130376f, 0.15298511f, 0.08752030f, -0.03507348f, 0.05251957f, -0.08851765f, -0.12204511f, 
    0.05437218f, -0.11557131f, -0.05108960f, 0.10058396f, -0.00411716f, 0.12204385f, -0.00399114f, 0.07909285f, 
    -0.03340208f, 0.06765182f, -0.11366751f, -0.11979737f, 0.20466958f, -0.28525099f, -0.33224827f, -0.19541903f, 
    -0.06090402f, -0.12748845f, 0.10040890f, 0.11414617f, 0.12626946f, 0.12261792f, -0.05144945f, -0.01733335f, 
    -0.29884654f, -0.16296904f, -0.01003183f, 0.15201403f, -0.17168564f, 0.07525551f, -0.14902973f, 0.09723396f, 
    -0.13918005f, 0.08574490f, 0.19755350f, -0.00076073f, -0.28766131f, 0.11596196f, -0.09013715f, 0.17652467f, 
    -0.11586725f, -0.00817188f, 0.00967106f, -0.02183106f, 0.03571102f, 0.00623730f, -0.13866785f, 0.16193824f, 
    -0.02749286f, -0.12391388f, -0.04978795f, -0.13775407f, 0.04219880f, -0.22201982f, -0.01637344f, 0.01530913f, 
    -0.08793048f, -0.00720648f, -0.17380868f, 0.05596051f, -0.38167420f, -0.04562718f, -0.04732678f, -0.32896009f, 
    -0.20091411f, 0.05292304f, 0.11154129f, -0.16377746f, 0.01080763f, 0.04519895f, -0.08598490f, -0.13712744f, 
    -0.57401395f, 0.14139980f, -0.34863219f, -0.50917763f, -0.07806756f, -0.01539374f, -0.03192907f, 0.16331765f, 
    0.18492222f, -0.08021107f, 0.08816339f, 0.11475780f, -0.30164772f, 0.30288485f, 0.05070923f, 0.04667326f, 
    -0.08746853f, -0.13825484f, -0.12588364f, 0.00601263f, 0.08287343f, -0.07372890f, 0.20684832f, -0.12279896f, 
    0.07119580f, -0.13127109f, 0.01192437f, -0.03571941f, -0.11124155f, -0.00595016f, 0.22707613f, -0.07264981f, 
    0.03740135f, 0.08434793f, -0.02690577f, 0.04603501f, 0.42322543f, -0.45986012f, 0.11356312f, -0.23548244f, 
    0.08302733f, 0.04599437f, -0.22768787f, -0.03201832f, -0.06012670f, -0.10452969f, 0.12381318f, -0.05289814f, 
    0.16532117f, -0.06311349f, 0.05491283f, 0.00717664f, 0.04192690f, -0.21236224f, 0.06293689f, -0.00138953f, 
    -0.18175855f, -0.04010464f, -0.12434505f, -0.01344238f, -0.81523055f, 0.04427391f, -0.16304991f, 0.04254564f, 
    0.03051719f, -0.07361278f, 0.00218411f, 0.07551950f, 0.13004196f, -0.09399423f, -0.05230083f, -0.10052353f, 
    -0.13919470f, -0.20041740f, 0.04414799f, -0.38680726f, 0.10372993f, -0.18346351f, 0.12824740f, 0.10629486f, 
    0.10495789f, -0.11491852f, -0.07860585f, -0.09339966f, 0.47155195f, -0.40563533f, 0.06649203f, 0.08208375f, 
    -0.15257311f, -0.09178117f, -0.15003598f, 0.04385930f, 0.08809327f, -0.06340559f, -0.04166505f, 0.05114370f, 
    0.31543267f, 0.02457803f, 0.07615742f, 0.10703289f, -0.08160708f, -0.01511500f, 0.00031242f, -0.12521492f, 
    0.09621148f, 0.10361239f, 0.05248416f, 0.11698870f, 0.28828672f, 0.08016463f, -0.21657839f, -0.30190662f, 
    -0.16787507f, 0.09308373f, -0.03158760f, 0.11127350f, 0.07343345f, 0.12106399f, -0.08947305f, -0.07361479f, 
    0.40878922f, 0.36752602f, -0.01825093f, 0.08445985f, 0.05568787f, 0.04537691f, 0.01823893f, 0.10156447f, 
    0.07035653f, 0.09228607f, 0.01617352f, -0.17440644f, -0.05688091f, 0.04438536f, 0.29462734f, 0.14953080f, 
    -0.02689893f, 0.02735309f, 0.21776721f, 0.13955785f, -0.02622849f, 0.13020402f, 0.04349466f, 0.24029094f, 
    -0.11151529f, -0.00243411f, 0.07655728f, -0.27357566f, -0.02340547f, 0.09249900f, -0.04531200f, 0.03519630f, 
    -0.03064734f, -0.08853787f, 0.09021648f, 0.07181560f, 0.38985670f, -0.05540353f, -0.21225671f, 0.11793762f, 
    -0.09516338f, -0.00137621f, 0.03832735f, 0.10801155f, 0.03852433f, -0.13711520f, 0.03229817f, 0.09442197f, 
    0.31050175f, 0.02005114f, 0.12450781f, 0.10899599f, 0.01235754f, -0.02265383f, 0.04254283f, 0.05325943f, 
    0.17727803f, -0.04656643f, -0.29718956f, 0.15967718f, 0.22346571f, -0.11984041f, -0.02683961f, -0.13678443f, 
    0.07491022f, -0.13995406f, -0.18364343f, 0.22097585f, 0.02083115f, -0.07470403f, 0.11624239f, 0.00747498f, 
    0.48940119f, -0.31040579f, 0.00886958f, 0.20186178f, 0.18830828f, 0.04600250f, -0.00165272f, -0.00247785f, 
    0.08379825f, -0.01927148f, -0.03232836f, -0.13915005f, 0.00791702f, 0.11208880f, 0.19944099f, 0.23714927f, 
    0.01217952f, 0.20892604f, -0.00584456f, 0.00991349f, -0.07493102f, -0.09319983f, 0.15915811f, -0.17784046f, 
    0.39259708f, 0.10785718f, -0.12933126f, 0.16347252f, -0.02229785f, 0.05521902f, -0.03656673f, -0.00613174f, 
    0.02451232f, -0.07957452f, -0.03501059f, -0.03924616f, -0.62538487f, -0.17208524f, 0.03970739f, -0.21807927f, 
    0.03545018f, -0.16392502f, -0.16852921f, -0.00284057f, 0.07897017f, 0.13078697f, -0.15168378f, -0.00981462f, 
    -0.15332617f, -0.51402181f, -0.05339324f, -0.44269416f, 0.12339264f, -0.18214042f, -0.09708685f, -0.03361722f, 
    0.09471858f, -0.15825029f, -0.18983799f, -0.13068908f, -0.28666016f, 0.25955850f, -0.17463894f, 0.07785656f, 
    0.03009607f, -0.03835408f, -0.10348176f, 0.05575358f, -0.12072234f, 0.05800452f, 0.03810940f, 0.01681022f, 
    0.37134904f, 0.10645315f, 0.23342375f, 0.25532871f, -0.16029303f, -0.01944741f, 0.03342655f, -0.10314696f, 
    -0.17355536f, -0.03058853f, 0.03384296f, 0.28375304f, 0.17145310f, -0.35705957f, 0.03454329f, 0.07124841f, 
    -0.06394462f, 0.05962114f, -0.02746619f, -0.03146739f, 0.01092199f, 0.08902825f, 0.11684570f, 0.04655594f, 
    0.36672807f, 0.08567575f, 0.06410751f, 0.29810485f, -0.04768788f, -0.09785958f, -0.07339869f, -0.09256946f, 
    0.01751265f, -0.02170013f, 0.01006613f, 0.06500167f, -0.20617482f, 0.10201750f, -0.12052830f, -0.07673550f, 
    -0.06364130f, -0.13905390f, 0.02425110f, 0.02240385f, -0.15533431f, 0.14102127f, 0.07306006f, 0.07025393f, 
    -0.36046448f, -0.21558248f, 0.08722828f, -0.09704915f, 0.08179401f, 0.08973891f, -0.04928940f, 0.14185242f, 
    0.09892475f, -0.04275622f, 0.00894136f, -0.03653214f, -0.35115653f, 0.28334966f, -0.07867854f, -0.33661970f, 
    -0.09225345f, 0.09276104f, 0.03490681f, 0.13051555f, -0.01517091f, -0.08887780f, -0.06638974f, -0.03237023f, 
    0.88842565f, -0.28719857f, -0.32654205f, -0.15450940f, -0.05338700f, 0.09290496f, 0.06061599f, -0.04206146f, 
    0.00127760f, 0.03098261f, 0.12591484f, -0.11359060f, 0.00869146f, 0.10769980f, -0.03802402f, -0.25279421f, 
    -0.11879800f, 0.11772384f, -0.09290027f, 0.01859934f, -0.00084372f, 0.12419159f, -0.12756625f, -0.11521327f, 
    0.24122156f, -0.08348869f, 0.15679860f, -0.28779262f, -0.03631628f, 0.04988987f, -0.10227928f, 0.11484577f, 
    0.00566919f, -0.17146151f, 0.01552644f, 0.03065774f, 0.26896322f, -0.00186395f, -0.31194556f, -0.32748681f, 
    0.10378569f, 0.04704551f, -0.09777568f, -0.15642275f, -0.02685919f, 0.00083000f, 0.00131683f, -0.00401419f, 
    0.19609036f, 0.00535331f, -0.28144431f, -0.15912601f, 0.03466544f, 0.09986171f, -0.07943418f, -0.00033559f, 
    -0.11444872f, -0.17803767f, 0.06936770f, -0.02596695f, -0.45572954f, 0.20390213f, 0.13263997f, -0.09503855f, 
    -0.10903663f, 0.09893372f, -0.07019506f, 0.04600847f, -0.22895184f, 0.05667647f, -0.04276012f, 0.05317459f, 
    -0.19316113f, 0.11804969f, 0.02972399f, -0.28665733f, -0.11994421f, 0.06825893f, 0.04218693f, 0.10409733f, 
    -0.03339102f, 0.04150149f, 0.00243809f, -0.23986529f, 0.04016704f, 0.11251136f, 0.28954545f, 0.17431429f, 
    -0.03790117f, -0.18612327f, 0.02864404f, 0.06543477f, -0.05900708f, -0.08650804f, -0.07381772f, -0.09542044f, 
    -0.18359855f, 0.17732018f, -0.14260441f, -0.01228404f, 0.14874519f, 0.02913831f, 0.15316235f, -0.10336034f, 
    -0.10358030f, -0.01711799f, 0.00317771f, -0.11599285f, 0.41300201f, -0.09273493f, -0.11641382f, -0.04013438f, 
    -0.22078772f, -0.03354584f, 0.17479022f, 0.05909682f, 0.06111893f, 0.11407061f, 0.03689403f, 0.00745132f, 
    -0.23394142f, -0.29273751f, 0.13478138f, -0.42760795f, 0.13963184f, 0.11342037f, -0.07835045f, -0.03060026f, 
    0.00171116f, 0.05626900f, 0.08086569f, -0.21280771f, 0.20252211f, 0.00442478f, -0.00469103f, -0.04935861f, 
    0.06282550f, 0.03268569f, 0.00363910f, 0.05570660f, -0.16206120f, -0.07770246f, -0.04551609f, -0.08584829f, 
    0.13874790f, 0.04877240f, 0.04685691f, -0.09476367f, 0.05131276f, -0.00335041f, -0.02048861f, 0.06676985f, 
    0.02190351f, 0.01833033f, -0.01972252f, 0.02569098f, 0.19009119f, 0.13011079f, -0.02441967f, 0.14009370f, 
    0.00121342f, -0.11392774f, -0.00575724f, -0.13224500f, -0.05362657f, -0.04509233f, -0.04950227f, 0.04241845f, 
    0.00392747f, -0.18243265f, 0.04009137f, -0.06264710f, 0.15147249f, 0.04097264f, 0.04185095f, -0.15086788f, 
    -0.05917896f, -0.04717683f, -0.07595518f, 0.18904454f, -0.42839661f, -0.10994425f, -0.43992910f, -0.16518798f, 
    0.09993090f, -0.02506988f, -0.23644952f, -0.07045461f, 0.05849159f, -0.00803853f, 0.01764049f, -0.03015986f, 
    -0.13353616f, -0.31107751f, 0.11063030f, 0.14068495f, -0.09543267f, 0.04854464f, -0.04130704f, 0.06473885f, 
    0.08997438f, -0.01307410f, -0.08774698f, 0.01221538f, 0.24853028f, -0.34479955f, 0.32998031f, 0.30251151f, 
    -0.22690283f, -0.16717555f, 0.01596069f, 0.09398741f, 0.01116526f, 0.05467212f, -0.01891974f, -0.08472870f, 
    0.12293027f, 0.01798699f, -0.01397409f, -0.13176326f, 0.11754443f, -0.11213499f, 0.09444895f, -0.09889048f, 
    -0.05674284f, -0.04875985f, 0.09814006f, 0.13150190f, -0.59075117f, 0.08565266f, -0.39717260f, -0.19729193f, 
    0.02325238f, -0.17356864f, 0.09812184f, -0.09137913f, -0.09876423f, 0.03430216f, -0.09420834f, 0.06194653f, 
    -0.21058106f, 0.01642975f, 0.02711156f, -0.22513781f, 0.20558219f, 0.05737147f, -0.09480290f, 0.04468210f, 
    0.03755790f, -0.09292784f, -0.03115404f, -0.06887900f, 0.01934877f, 0.19569339f, -0.16837743f, 0.20537901f, 
    0.03650734f, 0.07669740f, -0.09825636f, -0.12629433f, 0.01413652f, 0.03786708f, -0.06466331f, -0.00526780f, 
    0.30543649f, -0.13870092f, 0.16594715f, 0.12848733f, -0.06464865f, -0.08127233f, -0.07575475f, 0.05047169f, 
    0.14263859f, -0.08555914f, 0.08816322f, -0.01690739f, 0.30730623f, 0.22329427f, 0.02591981f, 0.24374658f, 
    0.06355937f, -0.06829647f, 0.07794472f, 0.02222268f, -0.16872367f, -0.05978435f, -0.07335807f, 0.00116017f, 
    -0.36405632f, -0.30974466f, -0.13822405f, -0.10509408f, -0.05355158f, 0.16312712f, -0.18179603f, -0.26575032f, 
    -0.15304628f, 0.19958441f, 0.05040015f, 0.09201602f, 0.39864841f, 0.06237793f, 0.20130557f, 0.01229934f, 
    -0.05306960f, -0.17185019f, -0.16480005f, -0.04903481f, 0.07769861f, 0.17124924f, -0.14053600f, -0.10746277f, 
    0.00712245f, -0.00013980f, -0.04806550f, 0.02219813f, 0.11202893f, -0.03987883f, 0.01168206f, -0.05587160f, 
    0.03549800f, 0.01902498f, 0.03318609f, -0.13752557f, 0.15391454f, 0.00995012f, -0.14235497f, -0.02872086f, 
    0.14571081f, -0.02863334f, 0.02397070f, -0.09654318f, -0.13247554f, -0.07405696f, -0.04700062f, -0.10642553f, 
    -0.10376014f, -0.06532284f, -0.02117537f, -0.07039573f, -0.02862279f, 0.05108967f, 0.13887703f, -0.09351882f, 
    -0.10020630f, 0.17842910f, 0.04304003f, 0.09910277f, 0.16277044f, -0.50906122f, -0.20360740f, -0.14732699f, 
    -0.07861708f, -0.07567357f, 0.09653520f, 0.01109115f, -0.07869013f, -0.00179982f, 0.08351852f, 0.13417436f, 
    -0.36418292f, -0.46221140f, 0.17627452f, 0.26846677f, -0.07395799f, -0.03980393f, -0.06071538f, 0.06187629f, 
    0.08405177f, 0.02139266f, 0.15425521f, -0.05636539f, -0.32254931f, 0.29063284f, -0.33475950f, 0.10382997f, 
    0.09335675f, 0.03475107f, -0.04053319f, 0.09725159f, 0.00348720f, 0.02247378f, 0.07703003f, -0.10823711f, 
    0.19858155f, 0.17133245f, 0.30296069f, 0.05354517f, -0.06842032f, -0.08988447f, 0.06351769f, 0.04319532f, 
    0.00255805f, 0.00983631f, -0.12632057f, -0.04407134f, -0.55559379f, -0.40916446f, 0.13077715f, -0.02653866f, 
    -0.09220114f, -0.05537974f, 0.14459339f, 0.05096859f, 0.01473381f, -0.25332350f, 0.00908657f, 0.00737675f, 
    0.21967858f, 0.03651029f, 0.05546061f, 0.19006287f, -0.05877443f, 0.00060649f, -0.05975842f, -0.17549138f, 
    -0.03345994f, -0.11497485f, 0.03359110f, 0.12789623f, 0.65168333f, 0.35590929f, 0.34067157f, -0.04297477f, 
    -0.02203520f, -0.04763277f, 0.01042269f, 0.04394137f, 0.08345097f, 0.05685541f, 0.07545955f, -0.05248575f, 
    -0.30262321f, 0.38721260f, 0.19970639f, -0.20032473f, -0.08317682f, 0.18504500f, 0.03794832f, 0.08311843f, 
    -0.00711128f, -0.13626400f, -0.07330214f, 0.14974016f, 0.09850282f, -0.52783930f, -0.29508668f, 0.13300231f, 
    0.07589366f, 0.04811386f, 0.17148077f, 0.14104578f, -0.07963749f, -0.00586469f, -0.07275864f, -0.06712829f, 
    0.07912299f, -0.19236740f, -0.13771740f, -0.18603712f, -0.01641309f, -0.12180641f, 0.08486073f, 0.06998271f, 
    0.09525225f, 0.04167680f, -0.06320361f, -0.07642902f, -0.12704527f, -0.07960211f, -0.14299645f, 0.01759708f, 
    -0.11046541f, -0.08072031f, 0.02504022f, 0.01418828f, -0.07095864f, -0.02756539f, -0.03210985f, 0.14890598f, 
    0.24963351f, -0.13324267f, -0.40381840f, -0.03900746f, -0.11929357f, 0.00286957f, 0.00245040f, 0.01882491f, 
    0.21803364f, -0.08150434f, -0.06572098f, 0.03373938f, -0.09239208f, 0.11867628f, 0.21456823f, -0.42370054f, 
    -0.04530443f, -0.03674747f, -0.05325142f, 0.02734663f, -0.05718896f, 0.03529336f, -0.07067087f, -0.03266980f, 
    0.38100365f, 0.26078820f, 0.00500599f, 0.42735282f, -0.09011389f, 0.14238277f, -0.18174659f, -0.18527417f, 
    0.04051160f, 0.07011297f, -0.11125645f, -0.09031497f, 0.30606925f, -0.28171700f, 0.17532733f, -0.16725297f, 
    0.06326117f, 0.20045218f, 0.00717929f, -0.01619847f, 0.04034265f, 0.14090572f, -0.02818009f, -0.00197039f, 
    -0.52633721f, -0.09321046f, -0.40366539f, -0.15663111f, -0.01834181f, -0.09640528f, -0.08772735f, -0.10475694f, 
    0.10896331f, -0.08918987f, 0.11504157f, -0.04215665f, -0.18085432f, 0.18541574f, 0.02192930f, 0.02029504f, 
    -0.03086880f, -0.16157678f, 0.04688448f, 0.08689657f, -0.02986923f, -0.02503939f, 0.05012261f, -0.00163274f, 
    -0.97547907f, -0.52322370f, 0.06873123f, -0.06846274f, -0.08583380f, -0.02602044f, -0.05638239f, 0.00100518f, 
    0.02895500f, -0.00746460f, 0.07853429f, 0.06601073f, 0.20621355f, -0.22110158f, 0.04211292f, -0.19463749f, 
    -0.12172409f, -0.00811801f, -0.05631683f, 0.10300320f, -0.02613188f, 0.00478466f, 0.12308909f, -0.05543730f, 
    0.11069205f, 0.04066299f, 0.02388234f, 0.10189701f, -0.07942741f, -0.10241038f, 0.02422793f, 0.04976061f, 
    -0.12057427f, 0.15759751f, 0.04549862f, 0.08671371f, 0.06928489f, 0.04887571f, -0.02633275f, -0.20155984f, 
    -0.14932075f, -0.09520742f, -0.13283594f, -0.12532322f, 0.04084800f, -0.14281793f, -0.07927039f, -0.01252733f, 
    -0.09914596f, -0.41953751f, -0.09036050f, -0.02580810f, 0.03533448f, -0.03296749f, -0.00834631f, -0.10832043f, 
    -0.16732310f, 0.02107309f, 0.13096184f, -0.05194639f, -0.02821908f, 0.28881279f, 0.15921099f, -0.06286695f, 
    0.05770884f, 0.00047946f, -0.06456107f, -0.09328051f, -0.06679875f, 0.13124141f, -0.01460361f, 0.15177572f, 
    -0.23849365f, -0.04993758f, 0.25555629f, -0.05624379f, 0.00873030f, 0.22735398f, 0.06303523f, -0.19571178f, 
    0.10243677f, -0.06620259f, 0.06618799f, 0.03387268f, -0.44613284f, -0.23041308f, -0.04330441f, 0.33308253f, 
    -0.00036281f, 0.06561440f, 0.05656514f, -0.17877838f, -0.00008270f, 0.05321761f, -0.03296779f, 0.10258766f, 
    0.08114130f, -0.03249152f, 0.08335479f, 0.08968058f, -0.00201514f, 0.02436968f, 0.11366598f, 0.02872963f, 
    -0.06168961f, 0.02554846f, -0.02021082f, 0.15208313f, -0.14623009f, 0.30149496f, 0.02487067f, -0.39121947f, 
    -0.03064696f, 0.03696464f, 0.00982070f, 0.11831333f, 0.02137738f, -0.19527219f, 0.03094737f, -0.03915556f, 
    0.13921884f, 0.11402189f, 0.10888963f, 0.07402297f, -0.18794265f, -0.06338970f, -0.03225128f, 0.11574765f, 
    0.02942618f, 0.06252651f, -0.04216073f, 0.11151683f, -0.08454579f, 0.22629985f, -0.14368343f, -0.07959788f, 
    0.12788489f, -0.11528821f, 0.07818555f, 0.13740438f, 0.09746186f, -0.13813809f, 0.15252039f, -0.09168048f, 
    -0.49530232f, -0.42437086f, -0.20620306f, -0.16612722f, -0.18463852f, -0.10858790f, -0.09593596f, 0.02144011f, 
    -0.04451048f, -0.21582226f, 0.02041024f, 0.00296735f, 0.00735584f, -0.22056806f, -0.10622627f, 0.32663757f, 
    0.07183036f, 0.04325835f, 0.00330934f, 0.01946571f, -0.14321357f, -0.02657847f, -0.00687733f, -0.24999799f, 
    -0.57387441f, 0.01406930f, 0.15178776f, 0.16342290f, 0.02656870f, -0.13327213f, -0.03430180f, -0.02357782f, 
    -0.12602633f, 0.01799691f, -0.01214142f, 0.05342630f, 0.18374081f, -0.11704331f, 0.27915847f, -0.00694175f, 
    -0.03522287f, 0.02400168f, 0.06428376f, -0.12207950f, 0.06001478f, 0.11630955f, 0.10899216f, 0.17356546f, 
    0.01987163f, 0.13684672f, -0.26799920f, -0.23779139f, 0.08955650f, -0.07644070f, 0.04951116f, 0.05698633f, 
    -0.01533472f, 0.12059405f, 0.14702998f, 0.20775206f, -0.37980095f, -0.06047949f, 0.27542546f, -0.06656519f, 
    -0.01280307f, 0.01457669f, 0.02143338f, -0.13917914f, 0.07086136f, -0.11559258f, 0.00266605f, -0.16367555f, 
    -0.61104304f, 0.27092120f, -0.14223316f, -0.11057311f, 0.01088984f, -0.10939261f, -0.02671717f, 0.08055307f, 
    -0.11173076f, -0.03626912f, -0.26741779f, -0.10161065f, -0.51108503f, -0.39057988f, 0.06001426f, -0.09075953f, 
    -0.14093901f, -0.13053313f, -0.09781338f, 0.05288697f, 0.04715777f, -0.11812621f, 0.04643841f, 0.01940130f, 
    -0.59506541f, 0.04814033f, 0.03189652f, 0.00989674f, 0.05656361f, -0.10486238f, -0.16933222f, 0.03604493f, 
    -0.04331258f, 0.07926553f, -0.13921593f, 0.01072439f, -0.06644797f, 0.31337714f, 0.01142620f, -0.25172502f, 
    0.06261759f, -0.03991430f, -0.00137180f, -0.03287093f, -0.00273220f, 0.12004142f, 0.02685243f, -0.01825952f, 
    0.08324048f, 0.31088969f, 0.19267978f, 0.06825674f, 0.06803235f, -0.10392244f, 0.13859567f, -0.08674729f, 
    0.05633048f, 0.14003921f, -0.24386877f, -0.00247525f, 0.02436484f, -0.12820800f, -0.02551427f, -0.31344792f, 
    -0.10051303f, 0.16843218f, -0.19945379f, -0.01463193f, 0.08583087f, 0.03983788f, -0.07246992f, 0.04349064f, 
    0.15616480f, 0.19879945f, -0.00433962f, 0.09802172f, 0.08973976f, -0.12222617f, 0.20135887f, 0.21514748f, 
    -0.11300999f, 0.14674765f, 0.05506652f, 0.09443672f, -0.57033211f, -0.07357915f, -0.00428175f, 0.32484502f, 
    -0.02915008f, -0.06669427f, 0.18306477f, -0.09511677f, 0.08362573f, 0.08408725f, 0.08691374f, -0.00914082f, 
    -0.14810765f, -0.41986474f, 0.11153541f, 0.13644706f, -0.30785778f, 0.08226635f, 0.03388600f, -0.07507878f, 
    -0.08765522f, 0.01243402f, 0.07320032f, -0.02610030f, 0.43070906f, -0.24655445f, -0.14172204f, -0.29959139f, 
    -0.03148662f, -0.07526722f, 0.09137903f, -0.00438719f, -0.01551807f, -0.02231102f, -0.20150299f, -0.01732669f, 
    -0.21685110f, -0.19472516f, 0.14542888f, 0.23111694f, -0.03934084f, -0.02313579f, -0.12323482f, -0.03380072f, 
    0.06242560f, -0.03803380f, -0.07508377f, 0.07531451f, 0.22037801f, -0.01773972f, -0.08243840f, -0.12338914f, 
    0.02216365f, 0.13691437f, 0.08502534f, -0.20773105f, -0.10385643f, 0.06574267f, -0.01146529f, 0.00796321f, 
    0.03244938f, -0.07477131f, -0.08709573f, 0.15166964f, 0.02151630f, -0.07665751f, 0.06077753f, 0.03571188f, 
    -0.11044648f, -0.17346336f, -0.03134705f, -0.08133508f, -0.21494190f, -0.09881096f, 0.03137190f, 0.10226988f, 
    -0.01620889f, -0.14475858f, 0.15104382f, -0.05463457f, -0.00390447f, -0.11051156f, 0.08766612f, -0.01022108f, 
    -0.03434656f, 0.08086723f, 0.07205451f, 0.18220071f, -0.20221026f, -0.02944953f, 0.11216704f, 0.14449064f, 
    -0.11182872f, -0.09399704f, -0.06492793f, -0.00321748f, 0.22963408f, -0.00888424f, -0.08174418f, -0.06246057f, 
    0.01086372f, 0.00840806f, -0.06231538f, -0.00496391f, 0.05771089f, -0.11384843f, 0.05982104f, 0.02808472f, 
    0.13571782f, 0.05187859f, 0.09099914f, 0.38094318f, 0.08175004f, 0.05744868f, 0.14525333f, 0.19902633f, 
    0.13413107f, 0.02024036f, 0.06898945f, -0.05635272f, -0.23577590f, 0.05973222f, 0.01562804f, 0.24406147f, 
    0.12052247f, 0.04646640f, -0.03438490f, 0.20118888f, -0.06944466f, 0.04583989f, 0.19407266f, -0.08559669f, 
    0.29036400f, -0.38993311f, 0.03048409f, 0.16487919f, -0.25250009f, -0.01383459f, 0.04057323f, -0.20674857f, 
    -0.10262650f, 0.00802862f, -0.06114592f, -0.05367146f, 0.08022531f, -0.15623459f, 0.31533146f, -0.16380851f, 
    -0.07423968f, 0.13781156f, -0.00632021f, -0.04437148f, 0.07941294f, -0.20066133f, -0.13431157f, -0.06012642f, 
    0.03781677f, 0.23941378f, -0.00420405f, -0.02026812f, 0.12524170f, 0.00044972f, 0.11787934f, -0.00563458f, 
    0.09848402f, 0.00749330f, 0.03882225f, -0.03002378f, -0.16879341f, -0.02279738f, 0.19106033f, 0.14681628f, 
    0.12085727f, 0.05386510f, -0.08092645f, -0.04267885f, 0.00456699f, 0.10567999f, -0.24936698f, -0.00486232f, 
    -0.47073996f, 0.04779899f, -0.09144519f, -0.11341711f, -0.11512379f, 0.01979101f, 0.11403725f, 0.05979417f, 
    -0.07428552f, -0.07513779f, 0.00948431f, 0.08511352f, 0.36233082f, 0.18154888f, -0.01981475f, 0.27980247f, 
    0.04930516f, -0.04666666f, 0.03248250f, 0.12999544f, -0.00385574f, -0.06595586f, 0.16341197f, 0.04175668f, 
    0.01738767f, 0.05217248f, -0.39477777f, 0.11723718f, -0.19229093f, -0.06430701f, 0.04093224f, 0.08515602f, 
    -0.14603211f, -0.03938303f, -0.01513489f, 0.14159013f, -0.63147050f, 0.06947250f, -0.12492926f, -0.13149403f, 
    0.06424281f, 0.18488023f, 0.01043684f, 0.08195045f, 0.09346305f, -0.05044343f, -0.00285667f, 0.00448914f, 
    0.27653253f, 0.12858836f, -0.00693572f, 0.01456687f, 0.01065346f, -0.05959083f, -0.07288205f, 0.14251511f, 
    0.00722678f, 0.08610828f, 0.04654219f, -0.06407612f, -0.42478892f, 0.00329934f, 0.20800000f, 0.04952816f, 
    -0.13165461f, -0.04998062f, -0.02843195f, -0.03173728f, 0.12532145f, -0.07681003f, -0.11143294f, -0.04200403f, 
    0.24436897f, 0.05545435f, -0.58035833f, -0.27843288f, 0.10684909f, 0.19973056f, 0.15824582f, 0.09383283f, 
    0.14131919f, -0.20184976f, 0.09716763f, -0.42300919f, 0.14878023f, -0.00518432f, -0.13388102f, -0.01854794f, 
    -0.02374144f, 0.10391524f, -0.12349857f, 0.10835950f, -0.17291915f, -0.05354548f, -0.00957485f, -0.47256860f, 
    -0.34372139f, 0.25453335f, 0.17227936f, 0.11899713f, 0.13326205f, -0.17002316f, -0.05397253f, -0.22906768f, 
    0.04484814f, 0.09149112f, -0.09129880f, -0.15143131f, -0.19857021f, 0.07192763f, -0.04025663f, 0.29548493f, 
    -0.19394106f, 0.02829739f, 0.08603573f, -0.01684251f, -0.13967305f, -0.06795080f, 0.12871173f, 0.01980516f, 
    -0.38884166f, -0.12053131f, -0.06831888f, -0.07483932f, -0.09395929f, 0.10522432f, 0.06887387f, -0.06018844f, 
    0.07257783f, -0.07309669f, -0.19206770f, 0.08252658f, 0.41359222f, 0.09940246f, -0.07919209f, -0.30989540f, 
    0.05365667f, 0.01909368f, -0.02209449f, 0.19497409f, -0.12528245f, 0.01611771f, 0.05699801f, -0.01503590f, 
    -0.50078410f, -0.11292361f, -0.08894470f, -0.10604838f, -0.09545964f, 0.14903128f, 0.13061118f, 0.00656615f, 
    0.07205010f, 0.09947490f, 0.09166580f, -0.14417842f, -0.27298641f, -0.19326077f, 0.29025722f, 0.32403618f, 
    -0.01810175f, 0.02443774f, 0.09238368f, 0.18090725f, -0.04733334f, 0.05038124f, -0.07738329f, -0.04057360f, 
    -0.20286922f, -0.30199522f, 0.10908383f, 0.19699112f, -0.12744313f, 0.06441212f, -0.02542218f, -0.08512088f, 
    0.27296263f, 0.13116972f, 0.11679030f, 0.03134944f, 0.16537920f, 0.04176133f, -0.05079482f, 0.21787900f, 
    -0.12163597f, -0.04381655f, 0.14888850f, 0.07904203f, 0.22766967f, -0.36532715f, 0.02993942f, 0.01613293f, 
    -0.40231574f, -0.39437512f, 0.10911375f, 0.16080430f, 0.06390301f, -0.15207504f, -0.24013050f, 0.02688395f, 
    0.16213085f, 0.05426586f, 0.19885071f, 0.21711686f, 0.10301691f, 0.01954463f, -0.16942523f, -0.05996442f, 
    0.02060199f, -0.00798645f, -0.20659295f, -0.09171684f, 0.16406730f, -0.04304755f, -0.08137901f, 0.03133633f, 
    0.07110307f, 0.11228724f, 0.13881667f, 0.20882839f, 0.13753363f, -0.15953311f, -0.08427715f, -0.18775755f, 
    -0.04629882f, 0.01293392f, -0.09927127f, 0.14578508f, -0.42948022f, -0.25256634f, -0.01901141f, 0.21536928f, 
    0.07535362f, -0.06917019f, 0.01135466f, 0.01214531f, 0.02940762f, -0.07269660f, 0.00568811f, -0.06039269f, 
    0.04334020f, 0.17975381f, 0.03575129f, 0.21026546f, -0.04482795f, -0.07161500f, 0.10901544f, 0.14945371f, 
    -0.14250268f, 0.08269789f, 0.05179137f, -0.06380198f, -0.34609586f, 0.09530846f, 0.24002241f, -0.29401770f, 
    -0.01736830f, -0.07344341f, -0.03784023f, -0.09142528f, 0.11567217f, -0.21522711f, 0.08445749f, 0.11262835f, 
    0.11468557f, 0.09555148f, 0.20121840f, -0.27969512f, 0.04328330f, 0.11566397f, 0.14521313f, -0.00566854f, 
    0.08386356f, -0.02768283f, -0.08287277f, -0.10402774f, -0.45520964f, -0.27078697f, -0.20500496f, -0.24456123f, 
    0.09001914f, 0.10282399f, 0.07894597f, -0.05034362f, 0.16718458f, 0.01659951f, 0.08158726f, 0.16775100f, 
    0.07653933f, 0.08479057f, 0.22708958f, -0.12040547f, -0.06036932f, -0.00705489f, 0.00343817f, -0.10698179f, 
    -0.00523692f, -0.02505848f, 0.05359415f, 0.07849734f, -0.25911582f, -0.08755577f, -0.26778805f, 0.26708549f, 
    0.14757505f, -0.12385404f, 0.04638573f, -0.18890831f, 0.06069778f, 0.00183209f, -0.05943952f, 0.03864080f, 
    -0.15854940f, -0.04852515f, -0.12711066f, 0.12266513f, 0.12217535f, 0.07276712f, -0.05263815f, -0.02958079f, 
    0.06775077f, -0.03635195f, 0.13819419f, -0.15348747f, -0.39187878f, -0.16986866f, -0.27256730f, 0.02608252f, 
    0.16247618f, 0.07650423f, -0.01836891f, -0.06102718f, 0.13525550f, -0.14267531f, -0.04348234f, 0.15290833f, 
    -0.13428394f, -0.11095382f, 0.11395676f, -0.21198313f, -0.04481999f, 0.04566197f, -0.13161376f, 0.01940712f, 
    -0.08616360f, -0.03553422f, -0.00895363f, -0.30620342f, 0.21534066f, -0.05888912f, -0.00761879f, 0.20148945f, 
    -0.00283355f, 0.03805038f, 0.15436082f, 0.09944554f, 0.04448868f, 0.08254054f, 0.14628206f, 0.08085258f, 
    -0.22580212f, 0.00199815f, 0.02149293f, -0.08430033f, -0.15534678f, -0.07812760f, -0.11837137f, 0.00578228f, 
    0.13131949f, 0.15677619f, 0.17747222f, 0.02224475f, 0.02723494f, 0.00159618f, 0.16549782f, -0.14995554f, 
    -0.15070347f, -0.07109752f, 0.01708235f, 0.13598594f, -0.15031189f, -0.01542902f, 0.08884839f, 0.13588154f, 
    -0.59904504f, 0.21897446f, 0.12658660f, -0.40303761f, 0.22290485f, 0.08120843f, 0.08106578f, 0.16038668f, 
    -0.03409538f, 0.04154750f, 0.05860277f, -0.33024126f, 0.12358467f, 0.06497786f, -0.01756369f, -0.03095038f, 
    0.18444017f, 0.02792945f, -0.15544750f, -0.31861258f, 0.06370505f, -0.14040382f, 0.09926096f, 0.04058714f, 
    0.29286993f, 0.00741473f, -0.03621908f, 0.00456759f, 0.00838224f, 0.04871239f, 0.13196956f, 0.17565033f, 
    -0.02669829f, -0.26209068f, -0.01947762f, -0.19325887f, -0.68784648f, -0.21852516f, 0.04767724f, -0.23867068f, 
    -0.00699234f, -0.02978286f, 0.10421439f, -0.21497717f, -0.13482897f, -0.08825820f, 0.01828246f, -0.16584198f, 
    0.03455609f, 0.11207887f, 0.08211918f, 0.09196370f, -0.00715777f, -0.01172655f, 0.13060176f, 0.00843563f, 
    0.35755491f, 0.07115225f, -0.14419827f, 0.09741706f, 0.05273150f, -0.02522787f, 0.08530203f, 0.27427170f, 
    -0.16154009f, 0.01572475f, 0.02102831f, -0.06301633f, -0.04774515f, -0.07521390f, 0.10212909f, 0.25576964f, 
    -0.10561214f, -0.03404389f, -0.18893164f, -0.14425366f, -0.08448804f, -0.05458836f, -0.10405300f, -0.26832727f, 
    -0.06637628f, 0.00157844f, 0.01039781f, 0.39456731f, -0.48102418f, 0.22919422f, 0.09897294f, -0.02349987f, 
    0.03416625f, -0.14769365f, -0.04274275f, 0.04412564f, 0.06771746f, 0.00810372f, -0.07178710f, 0.10781717f, 
    0.33545926f, -0.57007313f, -0.00263606f, -0.23743030f, 0.03768330f, 0.07475223f, 0.06046273f, 0.11215525f, 
    0.05612042f, 0.01172972f, 0.06590778f, 0.08000270f, -0.27236915f, -0.06855809f, 0.08717477f, -0.06420058f, 
    0.32418630f, -0.00678947f, 0.05976474f, -0.06178891f, -0.10934880f, -0.02883361f, 0.03709019f, -0.04798881f, 
    0.42493084f, 0.03172670f, 0.26967877f, -0.30189055f, 0.09294074f, -0.09134129f, 0.17116712f, -0.21857335f, 
    0.09743539f, -0.03130107f, 0.20810178f, -0.24368602f, -0.02475402f, 0.07518943f, 0.30768254f, -0.06059509f, 
    0.17239687f, -0.07125027f, -0.02108890f, 0.08202428f, 0.10944389f, 0.12992901f, -0.13793032f, -0.19027990f, 
    0.21090259f, -0.05649917f, -0.09433154f, 0.00647159f, 0.00659467f, 0.25524598f, -0.01102351f, 0.00250837f, 
    -0.03661878f, 0.07108083f, -0.03791566f, -0.03136843f, 0.04621172f, -0.29529926f, -0.00921960f, 0.21643513f, 
    0.01934633f, -0.09877354f, -0.15929045f, 0.11056118f, -0.04240138f, -0.05776134f, -0.04041279f, 0.11339960f, 
    -0.05278086f, -0.36721697f, -0.05354698f, 0.30936071f, 0.03014784f, -0.12631984f, 0.04812110f, -0.07956719f, 
    -0.26056498f, -0.02071857f, -0.32218304f, -0.17583333f, -0.40707174f, 0.06472986f, 0.11668440f, 0.36709431f, 
    0.10510205f, -0.10025871f, -0.03075487f, -0.08849166f, -0.16360569f, 0.12194578f, -0.26281524f, -0.30568269f, 
    0.09585742f, 0.15329388f, -0.10197851f, 0.04808331f, -0.06775952f, 0.14950766f, -0.02618685f, -0.04696973f, 
    -0.09170700f, -0.09737916f, -0.04416795f, 0.05534559f, -0.24237846f, -0.27374086f, -0.34906533f, -0.00364339f, 
    -0.08717451f, -0.05460178f, 0.03059047f, -0.05333766f, -0.02910764f, 0.04114804f, 0.01653410f, 0.15560579f, 
    -0.32249165f, 0.31476957f, -0.21503964f, 0.10333144f, -0.09686354f, 0.25462112f, 0.00397013f, 0.09357839f, 
    0.18114537f, 0.05477351f, 0.00270128f, -0.08902181f, 0.42807055f, -0.12918103f, 0.06654918f, 0.07476974f, 
    -0.06025505f, -0.03193362f, -0.14798616f, -0.06923121f, -0.33229661f, 0.04445092f, 0.16873474f, 0.05134801f, 
    0.11469915f, 0.10257312f, -0.29494497f, -0.22141866f, 0.09922238f, -0.02475759f, -0.09223147f, -0.03262167f, 
    -0.08795244f, -0.09680323f, 0.08586168f, 0.16585940f, 0.28095588f, 0.13532792f, 0.00239532f, -0.06282147f, 
    -0.06430932f, 0.17498685f, 0.08796176f, 0.24525335f, 0.01591899f, 0.18314195f, -0.10699507f, -0.14193083f, 
    -0.17148621f, 0.02672182f, 0.09423626f, -0.12920381f, -0.11964365f, -0.08147162f, 0.01173185f, 0.16972923f, 
    -0.06794839f, -0.08920993f, -0.03038489f, 0.05469568f, -0.22915773f, -0.02842423f, -0.06868721f, 0.07182313f, 
    -0.02813668f, 0.03934951f, 0.11364143f, 0.00287561f, 0.10924427f, 0.01949546f, 0.04964598f, -0.12535982f, 
    -0.26318398f, -0.00013905f, 0.11738491f, -0.01963452f, 0.12643711f, 0.07498172f, -0.00231553f, 0.13405095f, 
    0.02031178f, -0.09549052f, -0.06602726f, 0.19837829f, -0.45593727f, 0.10872997f, -0.21103235f, -0.48405340f, 
    -0.01171835f, -0.01052255f, 0.11708789f, -0.01549104f, 0.00111653f, -0.02582122f, -0.12150968f, 0.10675927f, 
    -0.12845479f, 0.06763563f, -0.16752985f, 0.04540972f, 0.03587390f, -0.11625662f, -0.08408320f, 0.14477421f, 
    0.12748955f, -0.04018532f, 0.08353318f, -0.01764876f, -0.37064084f, -0.10493653f, -0.20457542f, -0.48734155f, 
    -0.09099655f, -0.00241725f, -0.09989905f, -0.16808698f, -0.10681298f, 0.03590913f, -0.08712377f, -0.03117122f, 
    -0.53111631f, 0.19595332f, 0.11044184f, 0.03065721f, -0.13696644f, -0.08053996f, 0.04840695f, 0.02148393f, 
    0.03134345f, -0.09238490f, 0.07557888f, 0.18165013f, 0.11779790f, -0.18654175f, -0.18520877f, 0.23822908f, 
    -0.00516167f, 0.00792045f, 0.04203244f, -0.00055404f, 0.04261967f, -0.11944217f, 0.05847294f, 0.01545036f, 
    0.35259080f, 0.36091879f, 0.13836125f, -0.28082690f, -0.19176781f, 0.14488897f, 0.00310788f, 0.08482007f, 
    -0.13832565f, -0.12323503f, -0.14503899f, 0.11438555f, 0.33676833f, 0.31947079f, 0.17529720f, -0.46038792f, 
    -0.17348371f, -0.07948901f, -0.02273697f, -0.03278014f, 0.20725921f, -0.05537363f, -0.04267093f, -0.11321274f, 
    0.19973925f, -0.70977491f, 0.12187276f, 0.01907194f, -0.03136867f, -0.04395502f, 0.01611251f, -0.06020309f, 
    0.13392466f, -0.03380843f, 0.03535493f, 0.25105375f, -0.15485604f, -0.31261396f, -0.27793041f, 0.36897162f, 
    -0.13287482f, 0.14386481f, 0.09279427f, 0.06574894f, -0.02194045f, 0.14972746f, -0.06243028f, 0.09409742f, 
    0.02267639f, -0.16215174f, -0.22774115f, -0.04827220f, -0.06031127f, 0.08605408f, 0.04804312f, 0.04101215f, 
    0.00632855f, 0.37948585f, 0.00943739f, 0.20016086f, 0.50160599f, -0.57805628f, 0.10807095f, -0.08379439f, 
    -0.13485320f, 0.09489202f, -0.00867607f, 0.03432345f, -0.03270707f, 0.09250732f, -0.01959218f, 0.16237293f, 
    -0.26763064f, 0.12725587f, 0.23397115f, -0.29467434f, -0.07576512f, -0.06404740f, -0.01826509f, 0.02427883f, 
    -0.14854518f, 0.13758615f, 0.18550386f, -0.14068198f, 0.06190537f, 0.09055468f, 0.07112213f, -0.20734017f, 
    0.10662962f, 0.05386607f, 0.02626576f, 0.12020262f, 0.18106365f, 0.02986709f, -0.07024165f, -0.09439725f, 
    0.18149643f, 0.12699655f, 0.28952858f, 0.19487861f, -0.02000370f, 0.05629812f, 0.08107994f, -0.01249947f, 
    -0.07664819f, 0.01351871f, 0.01852330f, 0.01153909f, -0.00777162f, -0.07454209f, -0.29863247f, -0.23135869f, 
    0.00715201f, 0.09911990f, -0.01723304f, -0.18003744f, -0.02082697f, 0.04546481f, 0.08224803f, 0.00707064f, 
    0.09122982f, 0.05226438f, 0.17509407f, -0.14562750f, -0.09531573f, -0.00097724f, -0.03373524f, -0.08941872f, 
    0.05985986f, 0.08175531f, 0.08757962f, 0.00116576f, 0.14011250f, -0.38602367f, -0.23065965f, 0.25840658f, 
    -0.15225270f, -0.10961374f, -0.00208394f, 0.00119683f, 0.02619553f, -0.16131172f, -0.10604946f, 0.07965623f, 
    0.51663846f, 0.22914799f, 0.08143041f, -0.19659156f, -0.21405189f, 0.03068907f, -0.07094327f, -0.04194328f, 
    -0.04540468f, 0.03824773f, -0.10018744f, 0.00482437f, 0.36070427f, 0.00840483f, -0.13315301f, -0.18393466f, 
    0.12408359f, 0.10197850f, 0.13375768f, -0.02461868f, 0.02252021f, 0.00565538f, 0.01750717f, -0.07403244f, 
    -0.23276775f, 0.15675457f, 0.03876421f, 0.01193563f, -0.00341823f, 0.00039755f, -0.08725642f, 0.02827905f, 
    0.03712703f, -0.02130335f, 0.01913096f, -0.03621127f, 0.04641008f, 0.14038150f, 0.11167438f, 0.15341590f, 
    0.03487233f, -0.11775754f, -0.08208673f, -0.05967153f, -0.23620725f, 0.04109400f, -0.05806015f, -0.10969068f, 
    0.28807861f, -0.05583401f, 0.14994644f, 0.19995639f, 0.18688126f, -0.08741983f, -0.03849865f, -0.10914522f, 
    -0.04823607f, -0.05844904f, 0.02203249f, -0.09497309f, -0.42651755f, -0.08021404f, 0.01781231f, -0.34833676f, 
    0.12159301f, -0.15572935f, -0.04905616f, -0.03528380f, -0.12190594f, 0.05746390f, -0.13090385f, -0.13921423f, 
    0.11972237f, 0.03448422f, 0.05687221f, 0.17300609f, -0.00468130f, -0.05344462f, -0.16259821f, -0.07479520f, 
    -0.05901742f, -0.02791328f, -0.08909687f, -0.05628617f, -0.15756689f, 0.14599404f, 0.02103371f, -0.00892630f, 
    -0.00608146f, 0.14972635f, 0.04516726f, 0.02911144f, -0.10695649f, 0.17723916f, -0.06032621f, -0.10527784f, 
    -0.05535380f, -0.04416166f, -0.25959215f, 0.12834240f, -0.02192214f, -0.04984800f, -0.09943182f, 0.04693994f, 
    -0.03606442f, 0.05594649f, 0.05673384f, -0.00497978f, 0.22972548f, 0.08593777f, 0.01243684f, 0.33290488f, 
    0.28947562f, 0.03344486f, 0.05912205f, 0.00800850f, -0.04516621f, -0.08222431f, 0.06508023f, -0.03926799f, 
    -0.20915258f, 0.01978314f, -0.15913309f, 0.07979265f, -0.14632317f, -0.17046098f, -0.06759611f, -0.07844056f, 
    -0.08488435f, -0.03496332f, 0.02768230f, -0.00640181f, -0.29681259f, 0.32018048f, -0.05705829f, -0.03864422f, 
    0.04276264f, 0.06881535f, -0.11627430f, -0.11045870f, -0.14642853f, -0.03154551f, -0.11235861f, -0.16884115f, 
    -0.37261808f, 0.14759703f, -0.03872418f, -0.10865360f, -0.03310956f, 0.04517028f, -0.03304655f, -0.04505343f, 
    -0.08187000f, -0.05986298f, -0.02417606f, -0.11491384f, 0.00348050f, 0.10341358f, 0.21598315f, 0.04072059f, 
    0.11948518f, -0.05980117f, -0.01630664f, -0.03827303f, -0.12739179f, -0.09405671f, 0.05251636f, -0.04693203f, 
    0.24005643f, -0.09887119f, -0.01892710f, -0.10283685f, -0.06304650f, -0.04446673f, -0.03991606f, -0.11467972f, 
    -0.06474412f, 0.00041433f, -0.08871946f, 0.05015182f, 0.07522861f, 0.17456892f, 0.11302955f, 0.38659102f, 
    0.20978044f, 0.06308915f, 0.02399531f, -0.00544928f, 0.01439225f, 0.01198681f, -0.16129149f, -0.02344088f, 
    0.10815688f, 0.05161526f, 0.14448197f, 0.03693226f, -0.01718071f, 0.02423323f, -0.14149688f, -0.03296790f, 
    -0.00691402f, 0.00881151f, -0.12644385f, -0.13364875f, 0.00658927f, 0.32267922f, 0.24891391f, 0.13137902f, 
    0.12063216f, 0.17596819f, 0.08005181f, -0.15457712f, -0.04665888f, 0.09717763f, 0.07391358f, -0.20013767f, 
    -0.19862074f, 0.02280205f, -0.25016096f, -0.10810166f, 0.03690176f, -0.05710547f, -0.11092465f, -0.11166348f, 
    -0.12757167f, 0.02567035f, -0.07016590f, -0.09981792f, 0.05659577f, -0.07455648f, 0.04359351f, 0.18280759f, 
    -0.13954502f, -0.15990613f, 0.06629668f, 0.03374793f, 0.02575304f, -0.11950237f, -0.05828607f, -0.07212004f, 
    -0.00409467f, 0.03561689f, -0.12292449f, 0.03170120f, -0.04679189f, 0.00382856f, 0.02054576f, -0.07683431f, 
    -0.08305613f, -0.07465079f, -0.03263265f, -0.09245882f, -0.04888398f, -0.06262168f, -0.36447906f, -0.24188066f, 
    0.00248966f, 0.04252847f, -0.01629911f, -0.02502506f, -0.03105350f, -0.00234674f, -0.01558724f, -0.09572916f, 
    0.13805284f, -0.36093205f, 0.06774827f, -0.23269527f, -0.05623332f, 0.06422587f, 0.11874703f, 0.00960615f, 
    -0.05891154f, 0.11668637f, -0.08597913f, -0.04804733f, -0.33371028f, 0.30098188f, -0.00877546f, 0.03721106f, 
    0.15734284f, -0.06973827f, -0.01147890f, 0.10109714f, 0.01161406f, -0.01724472f, 0.17438185f, -0.05857552f, 
    0.25589064f, 0.27229309f, -0.00507210f, 0.16783476f, -0.00045768f, -0.01041757f, 0.08599399f, -0.05820808f, 
    -0.10146284f, 0.18623839f, 0.02598394f, 0.02153609f, -0.27356133f, 0.08843250f, 0.20899378f, -0.04108721f, 
    0.15566418f, 0.01929842f, -0.05702577f, -0.05885832f, -0.11996065f, 0.03992282f, 0.00693951f, -0.13183130f, 
    -0.36881220f, -0.07605720f, -0.13465093f, -0.20775686f, -0.06754924f, 0.04383055f, -0.04811377f, -0.09790572f, 
    0.02632152f, 0.01869959f, -0.02611916f, -0.01319142f, -0.34191290f, -0.26964408f, -0.16333762f, 0.09717572f, 
    -0.19362873f, -0.20517021f, -0.01666375f, -0.07309959f, 0.00629022f, -0.02838090f, -0.05606877f, -0.00023029f, 
    -0.08494224f, -0.02593721f, 0.06162455f, 0.09398882f, -0.00174457f, -0.06246242f, 0.08939490f, 0.06332188f, 
    -0.05082574f, -0.03284525f, -0.04313806f, -0.20017779f, -0.03946998f, -0.24509053f, 0.01048193f, -0.04133715f, 
    0.10060667f, 0.05005356f, -0.04598774f, 0.05460870f, 0.00826271f, -0.08126089f, -0.06147316f, -0.30597156f, 
    0.26435694f, 0.12160945f, 0.19265983f, 0.10323959f, -0.10526012f, -0.18203950f, 0.05489360f, -0.24541295f, 
    0.17809166f, -0.04450638f, -0.06126112f, -0.08391687f, 0.31748611f, -0.28856647f, -0.29700485f, -0.26099810f, 
    -0.07327328f, -0.00764790f, 0.03675615f, -0.15798759f, 0.04297101f, 0.06273731f, 0.10125320f, 0.10667741f, 
    -0.30129150f, -0.18571931f, 0.16461679f, -0.31543419f, 0.12206630f, -0.04877403f, -0.00378863f, 0.08859653f, 
    -0.03115729f, -0.03075539f, -0.13618444f, 0.02185710f, 0.29188845f, -0.32394984f, -0.11870171f, -0.01751921f, 
    0.05938236f, -0.16689515f, 0.02535664f, -0.04964459f, 0.10611926f, 0.13403973f, 0.11593240f, -0.08473241f, 
    0.12574720f, 0.11266124f, -0.14025922f, -0.06870153f, -0.13805199f, -0.08832791f, 0.12588561f, 0.02780008f, 
    -0.05949726f, -0.01800507f, 0.08790333f, 0.02220881f, 0.07166506f, 0.03777998f, -0.18989916f, -0.09790334f, 
    0.14091009f, -0.08865783f, -0.03156719f, 0.03980599f, 0.05099648f, 0.07197243f, -0.09492786f, 0.11638182f, 
    0.09785697f, 0.20209524f, -0.24493921f, -0.00366719f, -0.06662305f, -0.05630173f, 0.09568623f, -0.04428031f, 
    0.06703190f, -0.06909253f, 0.07987726f, 0.11059189f, 0.32950014f, 0.25004688f, -0.17579234f, -0.08095223f, 
    0.15314251f, -0.12604797f, 0.00751192f, -0.12910759f, 0.04867978f, 0.00625190f, 0.07261444f, 0.15181069f, 
    0.11672556f, 0.18139428f, -0.05015215f, -0.23142773f, 0.05498657f, -0.14370628f, 0.14154091f, -0.08698068f, 
    0.03326814f, -0.00366030f, 0.12482893f, 0.04891920f, 0.00054804f, 0.30123854f, 0.11006270f, 0.02078739f, 
    -0.27523354f, -0.00126543f, -0.19012709f, -0.06381479f, 0.05394980f, -0.12494227f, -0.03071548f, 0.06758235f, 
    -0.25564197f, -0.03302152f, -0.20514584f, -0.10639369f, 0.02908244f, 0.02241649f, -0.34205550f, 0.00875459f, 
    0.08432634f, -0.03605736f, 0.04520513f, 0.01783649f, 0.09283262f, -0.11820544f, 0.08733487f, -0.14178866f, 
    -0.00492220f, 0.13029912f, 0.15579438f, 0.02690624f, 0.03345067f, -0.06966702f, 0.02154041f, -0.12028752f, 
    -0.37140420f, 0.01673658f, -0.32352170f, -0.18035486f, -0.12017689f, -0.01219222f, -0.16895965f, -0.05650283f, 
    0.19710484f, 0.15542053f, 0.02538328f, -0.11782318f, 0.00474356f, -0.01699310f, 0.01414058f, 0.10230840f, 
    0.01688367f, -0.16566645f, 0.06323474f, 0.01885840f, 0.10650907f, -0.14028732f, 0.11283938f, 0.06694944f, 
    0.27682531f, 0.02787280f, 0.03481748f, 0.12761229f, 0.06418485f, 0.01517264f, -0.01487095f, -0.07612117f, 
    -0.06894206f, 0.00646552f, -0.10691431f, -0.13393044f, -0.02538825f, 0.07907166f, 0.07976802f, 0.04279880f, 
    0.04850755f, -0.11670722f, 0.00397084f, -0.21181314f, 0.02355465f, 0.03906596f, 0.09655014f, -0.04934528f, 
    0.38056290f, 0.12585628f, -0.06824204f, 0.16023055f, 0.03729551f, -0.09020675f, -0.06999467f, -0.07913739f, 
    -0.00500245f, -0.02117380f, 0.09726439f, -0.06175974f, -0.43802691f, -0.09748673f, 0.34232086f, -0.27497965f, 
    -0.16893962f, 0.12084437f, -0.07122951f, -0.06949858f, -0.05045694f, -0.02168423f, 0.08533874f, -0.07346706f, 
    -0.36788440f, 0.22451504f, -0.07072220f, -0.22917762f, 0.08438190f, -0.12638587f, -0.20516361f, -0.05876317f, 
    0.12994139f, 0.02076093f, -0.15135881f, -0.01189064f, -0.27041838f, -0.09744703f, 0.40524027f, 0.11625334f, 
    -0.17316067f, 0.07474943f, -0.19032870f, -0.16243470f, 0.05562288f, -0.01403056f, 0.04469647f, 0.07463960f, 
    -0.06001741f, -0.04802242f, -0.17080246f, -0.02366515f, -0.08334629f, -0.10459252f, -0.19258450f, 0.09092527f, 
    -0.05703789f, 0.06442771f, -0.18794404f, -0.11472246f, 0.05779661f, -0.25392696f, -0.35581562f, -0.30163956f, 
    0.00893241f, 0.15895839f, -0.11713663f, -0.19228145f, 0.15158010f, 0.11108077f, 0.12041137f, -0.16798452f, 
    -0.23084804f, 0.09718336f, 0.07533854f, 0.27145571f, 0.02621668f, -0.11085001f, -0.13877717f, -0.06229375f, 
    0.13231492f, 0.10327748f, 0.13331603f, -0.06975313f, -0.24773008f, -0.31604055f, 0.05914223f, 0.12043446f, 
    0.09083172f, -0.07517583f, 0.00476477f, -0.02370602f, 0.12161972f, 0.19243872f, -0.04128375f, -0.03865612f, 
    0.23349392f, -0.05372932f, 0.13883336f, 0.08244038f, -0.00471309f, -0.13059762f, 0.06197174f, -0.03481902f, 
    0.05084467f, 0.02231708f, -0.07506710f, -0.20301586f, 0.04159470f, 0.31013814f, 0.01474904f, 0.19625765f, 
    -0.13139060f, -0.17410333f, -0.24758321f, -0.08479908f, -0.03458243f, -0.13501766f, -0.02564113f, 0.11465681f, 
    -0.23586182f, 0.03648655f, 0.03338188f, -0.13339551f, -0.01167241f, 0.06858675f, -0.03921399f, 0.18521512f, 
    0.12979254f, -0.21753044f, 0.04405599f, -0.29795131f, 0.12219469f, -0.50462502f, 0.23686095f, 0.06842981f, 
    -0.10706080f, -0.03368262f, -0.15775956f, 0.03825675f, -0.03948263f, -0.04649844f, 0.02393571f, -0.09080571f, 
    0.10817902f, -0.06884206f, 0.06063917f, 0.27162167f, 0.04489364f, 0.02535666f, -0.01944611f, -0.08438504f, 
    -0.04311012f, 0.05886322f, -0.17944893f, 0.14970046f, -0.01597161f, -0.19300614f, -0.31322744f, 0.03858869f, 
    0.17139742f, -0.03277549f, 0.06758481f, -0.07047813f, -0.07952195f, -0.02894345f, 0.17038332f, 0.14655070f, 
    -0.19160889f, -0.24416687f, 0.08404914f, 0.00747555f, -0.00762039f, -0.00749610f, -0.05964970f, 0.01899527f, 
    -0.00151327f, 0.20335789f, 0.02480721f, 0.09247506f, 0.00123940f, 0.03369255f, 0.26466027f, 0.06454051f, 
    0.08837190f, -0.00004989f, 0.02029095f, -0.08811133f, 0.14119071f, 0.04409539f, -0.00505055f, 0.10463212f, 
    0.44377181f, 0.16081622f, -0.25254565f, 0.08503097f, 0.08266748f, -0.07786933f, -0.04799716f, 0.04203979f, 
    -0.02385921f, -0.13585062f, 0.04358323f, 0.09327982f, 0.17654346f, 0.20657104f, 0.12678970f, -0.29707655f, 
    -0.10174831f, -0.06323081f, -0.02452810f, -0.05677568f, -0.03316107f, 0.03017052f, -0.03098008f, 0.10477524f, 
    -0.04119411f, 0.01485599f, -0.10708887f, 0.23137176f, 0.01951418f, -0.09651285f, -0.01592952f, 0.11066028f, 
    -0.05148206f, -0.06302536f, 0.15656281f, 0.07278741f, -0.07014559f, 0.33599943f, 0.04825788f, -0.09523123f, 
    0.00817991f, 0.20007527f, 0.01884282f, -0.15743732f, 0.08630133f, -0.13777378f, 0.06147848f, -0.04165404f, 
    -0.35738620f, 0.06139115f, 0.26822037f, 0.17331463f, 0.11380799f, -0.00121472f, 0.00244688f, -0.05361379f, 
    0.13409625f, -0.11338793f, 0.01384601f, -0.00224765f, -0.06675061f, -0.46371460f, -0.19259724f, 0.03740616f, 
    -0.09882607f, 0.03393467f, -0.05439815f, 0.06351595f, 0.05283179f, -0.04383346f, 0.17246817f, -0.10719651f, 
    0.43819961f, -0.70741028f, 0.25307941f, 0.16107555f, 0.18404230f, 0.00592798f, -0.03386165f, 0.06723256f, 
    -0.11397091f, -0.12043884f, 0.06011744f, -0.01183271f, 0.66599518f, 0.16597475f, 0.21340662f, -0.24995238f, 
    0.00144811f, 0.08461560f, 0.17542179f, 0.04732910f, -0.09427058f, 0.00433210f, -0.02609841f, -0.02490878f, 
    -0.12853734f, 0.05330097f, 0.15164690f, 0.24526247f, 0.06756897f, 0.05711097f, -0.24050216f, 0.07063234f, 
    0.09251823f, -0.06630714f, -0.15835972f, -0.17257154f, -0.10943813f, 0.25062203f, 0.09407036f, 0.25616571f, 
    0.20545635f, 0.15150930f, -0.03118527f, 0.22138552f, 0.00984474f, 0.08108068f, 0.04034279f, 0.04911076f, 
    -0.09502387f, -0.02317163f, 0.19404304f, -0.16697833f, -0.08527917f, 0.03299050f, -0.02549236f, -0.05081595f, 
    0.03265961f, -0.06817531f, -0.11323372f, -0.04973024f, -0.08294452f, 0.12065168f, 0.13289815f, -0.08346982f, 
    0.20889512f, -0.08050610f, 0.02400486f, -0.13806319f, 0.02949645f, 0.12544914f, 0.15177423f, 0.17492966f, 
    -0.36359623f, 0.17051889f, -0.05140139f, -0.19207734f, -0.06399965f, 0.24239804f, -0.02849982f, -0.12134492f, 
    0.01468622f, -0.14810126f, 0.06589259f, 0.03247659f, -0.81122279f, 0.28238970f, -0.09839287f, -0.17861836f, 
    0.12795410f, -0.10798495f, 0.02420202f, -0.00549119f, -0.03629760f, 0.06826495f, 0.14985704f, 0.04595751f, 
    -0.37126178f, 0.24740443f, -0.14092807f, -0.23171285f, 0.18910754f, 0.11103734f, -0.14736961f, -0.17126405f, 
    0.00912332f, 0.03368930f, -0.00163811f, -0.11187906f, 0.17336842f, -0.69331545f, -0.05799908f, 0.19531095f, 
    -0.11488358f, -0.02393379f, -0.18480735f, 0.07282528f, -0.15617552f, -0.10525849f, -0.01927785f, -0.10052486f, 
    0.21653935f, -0.19158298f, -0.16659985f, 0.03980631f, 0.16247189f, -0.12121956f, -0.01229042f, -0.07470272f, 
    -0.08699316f, 0.15072387f, -0.00512959f, -0.02796858f, 0.70901406f, -0.18546723f, -0.23191401f, -0.11143215f, 
    -0.06198977f, -0.07604653f, -0.02945322f, 0.04915842f, -0.11267057f, -0.10059198f, 0.12916489f, 0.01810722f, 
    -0.31349388f, -0.22062181f, -0.04245098f, -0.05926564f, -0.11003619f, 0.10246958f, 0.00264566f, -0.01637995f, 
    -0.14207861f, 0.01828808f, -0.12712471f, 0.17487843f, -0.18240243f, -0.64071620f, -0.13778548f, -0.11245301f, 
    0.01915530f, 0.04580434f, 0.06472065f, -0.06066711f, -0.04560198f, 0.14101772f, -0.06211428f, -0.11076275f, 
    0.01053917f, 0.35343266f, -0.12125549f, 0.10611945f, 0.10691719f, 0.04286623f, -0.10661365f, 0.06359714f, 
    0.00986281f, 0.13097432f, 0.21536224f, 0.03407323f, -0.11894222f, -0.04116189f, -0.19621542f, -0.07661673f, 
    0.10569281f, -0.07243765f, 0.07367738f, -0.03628461f, -0.14883575f, 0.14518122f, 0.03220381f, 0.18507874f, 
    -0.30026007f, 0.19731162f, -0.20729065f, -0.07224335f, 0.01430537f, -0.10137077f, 0.14885902f, 0.03462708f, 
    -0.15232375f, -0.03032888f, -0.02583011f, 0.14733703f, -0.31883490f, 0.08489955f, -0.14072300f, -0.51035231f, 
    0.10559921f, -0.07433036f, 0.01719652f, -0.02072268f, -0.06540848f, -0.09724259f, -0.00590845f, 0.02587363f, 
    0.35346577f, 0.01451350f, -0.13463074f, 0.12536408f, 0.14049052f, 0.04676910f, -0.11974485f, -0.14592643f, 
    -0.07194694f, 0.18001518f, -0.09403151f, 0.08457265f, -0.53712833f, -0.40056446f, 0.28347355f, -0.28521517f, 
    -0.05470078f, -0.01311676f, 0.10700704f, 0.25984555f, 0.03282451f, -0.18686476f, 0.02758278f, -0.13840359f, 
    -0.38863453f, 0.32455057f, 0.07049060f, 0.03919542f, 0.12154370f, 0.01096208f, -0.13061415f, -0.08879295f, 
    0.09538116f, 0.13305351f, 0.02628298f, 0.15548673f, 0.13677561f, -0.08894092f, -0.11014315f, 0.10353827f, 
    -0.01177973f, -0.00336933f, -0.11427965f, 0.03052813f, 0.01896658f, 0.16666220f, -0.12195185f, 0.14926331f, 
    -0.20268323f, 0.02594636f, -0.16029346f, -0.11692209f, 0.12481735f, 0.31520522f, -0.15537262f, -0.18393870f, 
    -0.06857395f, -0.36603588f, -0.04868764f, -0.17522277f, -0.30955124f, 0.25758690f, 0.03750833f, -0.51257712f, 
    0.05632536f, -0.08771837f, -0.17106101f, 0.16173719f, -0.09353957f, 0.06917188f, -0.19385418f, -0.29188854f, 
    0.30151710f, 0.01826826f, -0.13333394f, 0.03320222f, -0.35183945f, -0.03177005f, 0.06455220f, 0.01911360f, 
    0.18675606f, -0.00192470f, -0.01902661f, -0.31949845f, -0.50381571f, -0.05406846f, 0.09136489f, 0.11189187f, 
    0.05753295f, 0.18415180f, -0.07011063f, -0.11447459f, 0.15859920f, 0.01620007f, -0.25272274f, -0.18972957f, 
    0.16716036f, 0.08905146f, -0.18607676f, -0.25362304f, -0.07816341f, -0.04348678f, -0.17972077f, -0.01887848f, 
    -0.21228315f, -0.08769578f, -0.29213312f, -0.21473452f, -0.39438507f, -0.04372822f, 0.43412521f, -0.13876857f, 
    0.16865991f, 0.00313596f, 0.05901380f, 0.00676464f, 0.01524866f, 0.26557919f, 0.00463267f, 0.22285895f, 
    -0.03216835f, -0.07638998f, -0.05999584f, 0.09026033f, 0.14650798f, -0.01933328f, 0.00511355f, 0.00219926f, 
    0.07132331f, 0.07022625f, -0.06294838f, 0.16800588f, -0.61038929f, -0.14975943f, -0.05873408f, 0.31732044f, 
    0.13706948f, -0.04198548f, -0.10119770f, -0.09632522f, -0.06886500f, 0.15954387f, 0.06256853f, 0.10769177f, 
    0.13076872f, 0.10784856f, -0.35786593f, 0.20245591f, 0.19594254f, -0.06985995f, 0.20260002f, 0.05477147f, 
    0.11930688f, 0.05907566f, 0.18815057f, -0.06035733f, -0.11972241f, -0.08021075f, -0.37688613f, 0.02547678f, 
    0.09123135f, -0.15053160f, 0.01574644f, -0.05391491f, 0.06234386f, 0.00681699f, -0.14698990f, -0.10781453f, 
    -0.35977545f, 0.07404214f, -0.11237801f, 0.02742967f, 0.10359966f, -0.00101688f, -0.00568874f, -0.07944776f, 
    0.04659459f, 0.27526873f, 0.06047491f, 0.03405344f, -0.72091097f, -0.26821062f, 0.20454121f, 0.19801973f, 
    0.18887386f, 0.02582072f, 0.01749954f, -0.07156908f, 0.04783527f, 0.19654979f, 0.10943189f, 0.21778409f, 
    0.22149755f, -0.01417838f, -0.01060435f, -0.01052163f, -0.01630969f, -0.01902661f, 0.17865370f, -0.16445598f, 
    -0.14959730f, -0.00625672f, 0.18250871f, 0.15477081f, 0.10956520f, 0.08571244f, -0.10509795f, -0.05479758f, 
    -0.20736645f, 0.01088400f, 0.01525735f, -0.04877518f, 0.02850897f, -0.08316915f, -0.08050094f, -0.16848172f, 
    -0.59948236f, -0.11240929f, 0.07488222f, -0.08635787f, 0.28777573f, 0.02667432f, -0.00797164f, -0.10860828f, 
    -0.06540058f, 0.03839073f, -0.04496077f, 0.06840639f, -0.10758266f, 0.23561379f, -0.15839696f, 0.12134950f, 
    -0.07196801f, 0.06909636f, -0.05295320f, 0.03040939f, 0.05700571f, 0.04339325f, 0.06660978f, -0.18196173f, 
    0.62707293f, -0.01981580f, -0.02758097f, -0.04665478f, 0.14458443f, 0.07617155f, 0.13656054f, 0.09064312f, 
    -0.03405779f, -0.02675545f, -0.00143102f, 0.00624040f, -0.55651498f, -0.49686056f, -0.42626241f, 0.03084202f, 
    0.09287229f, -0.19929011f, -0.03751327f, -0.03804591f, 0.08758042f, -0.04226296f, 0.06741964f, 0.08116829f, 
    -0.19580285f, -0.13356529f, -0.14557457f, -0.01505234f, 0.01436788f, 0.17945716f, 0.10915446f, 0.03269229f, 
    0.10176815f, 0.06341661f, 0.03079768f, 0.09833515f, 0.32555878f, -0.10003080f, 0.02499324f, 0.03287890f, 
    -0.04934923f, 0.12035105f, 0.03736304f, 0.02700354f, 0.05262027f, 0.13783520f, -0.07698907f, 0.15024000f, 
    -0.34639528f, -0.31464410f, -0.45334053f, -0.23171175f, -0.00097531f, 0.01866721f, -0.25033814f, -0.06759698f, 
    -0.02955390f, -0.04811007f, 0.01664436f, -0.04645326f, 0.15271191f, -0.01566708f, 0.08258492f, -0.20787230f, 
    0.02502682f, 0.04474949f, 0.05565254f, -0.01813841f, 0.01115228f, 0.10770442f, -0.02317580f, -0.07698909f, 
    0.29981712f, 0.05715201f, -0.03826269f, -0.11824229f, 0.13743249f, 0.09243134f, 0.07112715f, -0.22703674f, 
    -0.01255167f, -0.15136306f, 0.05782345f, -0.07769494f, 0.22329581f, 0.08344965f, 0.08636581f, -0.07282411f, 
    0.02673815f, -0.07494922f, 0.07899823f, 0.11599784f, -0.08873193f, -0.00352311f, 0.08132846f, 0.14650999f, 
    -0.34039253f, -0.19467796f, -0.01537261f, 0.09598384f, 0.00115361f, 0.04069300f, 0.03402963f, -0.01110388f, 
    0.22663526f, 0.08163976f, -0.09244960f, 0.14589691f, 0.00270783f, -0.09753571f, 0.15385558f, -0.09572664f, 
    -0.01349868f, 0.23457679f, -0.01820917f, 0.02992407f, -0.13638948f, -0.11449990f, 0.18412521f, -0.25516844f, 
    -0.63419408f, -0.66863883f, -0.11223511f, -0.17930582f, -0.10584917f, -0.15674454f, -0.04132628f, 0.04122392f, 
    -0.04382490f, 0.19592306f, 0.02435036f, -0.13403387f, -0.24388680f, -0.06141219f, -0.13604237f, -0.29513630f, 
    0.04932055f, -0.03874068f, -0.08347613f, 0.08588450f, 0.04157034f, 0.13816147f, 0.15868939f, -0.03520896f, 
    0.42108104f, 0.03229942f, -0.24097058f, 0.23929369f, -0.11562171f, -0.13538067f, -0.03363617f, 0.10637590f, 
    -0.06460959f, -0.04364193f, -0.08477888f, -0.07007255f, -0.05229741f, -0.20879291f, -0.05479011f, -0.12495895f, 
    -0.02348327f, 0.00634127f, 0.01245747f, -0.10562611f, 0.01378441f, 0.06639526f, -0.09609735f, 0.05402980f, 
    -0.12317753f, 0.04920580f, 0.26393634f, 0.11074495f, 0.02186858f, 0.09222258f, 0.13864405f, -0.11436962f, 
    0.03806888f, -0.04298588f, 0.01649384f, -0.12554243f, 0.47365382f, 0.21999256f, -0.06634072f, 0.09151093f, 
    -0.14386855f, -0.15866975f, -0.03215685f, 0.02546028f, -0.14304210f, -0.12940586f, -0.01500351f, 0.03182510f, 
    -0.50742406f, -0.37485856f, -0.24527140f, -0.28963551f, 0.01570336f, 0.02885957f, 0.17484321f, -0.01681338f, 
    0.18215518f, 0.20355414f, 0.02082554f, 0.19393292f, -0.23520537f, -0.00383621f, 0.00319047f, -0.42587823f, 
    -0.00731711f, 0.07516856f, 0.03750684f, 0.01882660f, 0.11706687f, 0.11054605f, 0.08643920f, 0.20717575f, 
    -0.13409600f, 0.09533983f, -0.06790134f, 0.09741109f, -0.02735270f, 0.04702794f, 0.03681516f, -0.04080721f, 
    0.02822506f, -0.08600551f, -0.12141559f, 0.14456114f, 0.16789499f, 0.18007271f, 0.02028008f, -0.19297658f, 
    -0.04221412f, -0.14029451f, -0.09645160f, 0.17005029f, 0.06574621f, -0.08060904f, 0.05899751f, 0.11286907f, 
    -0.38182083f, -0.31099069f, -0.04721925f, -0.32578504f, 0.08175336f, 0.01221120f, 0.04845737f, -0.00115304f, 
    -0.20351298f, 0.07250283f, -0.04734426f, 0.12454975f, 0.62371469f, -0.00406271f, -0.06250905f, 0.07884232f, 
    0.14378084f, -0.07817507f, -0.24033546f, 0.05868349f, 0.01964023f, -0.03876591f, 0.01693970f, -0.01927547f, 
    -0.59644747f, 0.21912415f, -0.07461587f, -0.17721434f, 0.25789559f, -0.26678458f, -0.12739384f, 0.09878000f, 
    0.09868798f, 0.01915703f, 0.01907991f, 0.00512641f, 0.52776998f, -0.04824001f, 0.10285693f, 0.09100173f, 
    0.01068311f, -0.11479156f, 0.02222523f, -0.04596866f, -0.00806378f, 0.00475629f, 0.02796915f, -0.01225077f, 
    0.34712690f, -0.20384331f, 0.03081902f, 0.26605663f, -0.04551552f, 0.09241433f, -0.05064785f, 0.07802459f, 
    0.01170674f, -0.03621821f, 0.01835537f, -0.10487166f, -0.05542520f, -0.04482571f, -0.02062269f, 0.41154280f, 
    -0.05304200f, 0.13840488f, -0.04310041f, -0.06152639f, 0.00935046f, -0.04297297f, 0.15566227f, 0.18429679f, 
    0.02771297f, 0.14564551f, -0.12823226f, 0.09680333f, -0.19633883f, -0.01457196f, 0.04419702f, 0.08332364f, 
    -0.11071619f, -0.04535441f, 0.12901558f, -0.17927779f, 0.29103416f, -0.31864166f, -0.23704308f, -0.19584565f, 
    0.08696093f, -0.17114069f, -0.14240389f, 0.02680012f, -0.04736955f, 0.11469572f, 0.09031183f, 0.01427509f, 
    -0.02005749f, -0.18693991f, -0.03906892f, -0.09487229f, 0.06087434f, -0.00805525f, -0.14228106f, -0.15008022f, 
    0.00173467f, -0.13351206f, -0.12096521f, -0.21928495f, -0.02989022f, -0.40204534f, -0.07199974f, 0.01334849f, 
    0.00294172f, 0.06701973f, 0.21099910f, -0.04675502f, -0.05242606f, 0.01413608f, 0.03520221f, -0.10970594f, 
    0.54853028f, 0.19974427f, -0.12075916f, 0.18206310f, 0.04469347f, 0.14697418f, -0.09290113f, 0.04879098f, 
    0.15412256f, 0.11915962f, 0.03274607f, 0.04442250f, -0.46420473f, -0.09685432f, 0.01179710f, 0.00351528f, 
    -0.25464913f, 0.10246217f, -0.03346511f, 0.02467255f, -0.02067194f, 0.15279025f, 0.07011589f, -0.07960770f, 
    0.06421375f, -0.05925466f, -0.29292089f, 0.22808251f, 0.15016121f, -0.14942841f, 0.13834783f, 0.28399333f, 
    0.06303461f, 0.09611981f, -0.01484747f, 0.04298991f, -0.45105025f, 0.01015977f, -0.08622024f, 0.01844511f, 
    0.20282809f, 0.09041582f, 0.07272288f, -0.03343775f, 0.11049957f, -0.00032904f, 0.08862808f, -0.08028781f, 
    -0.06878107f, -0.52244806f, -0.04107896f, -0.13671859f, 0.02122072f, -0.04971387f, 0.04544739f, 0.16165714f, 
    -0.08934826f, 0.02781220f, -0.08074632f, -0.05307612f, -0.00713177f, 0.10481945f, -0.01559822f, 0.15674922f, 
    0.05227243f, -0.06169155f, 0.06092503f, -0.04140053f, -0.26256660f, 0.10303315f, -0.04782690f, -0.19079818f, 
    -0.43810827f, 0.04317348f, -0.34175247f, -0.33988440f, 0.10026142f, 0.01428582f, 0.17587660f, 0.03776976f, 
    0.03688613f, -0.05783755f, -0.07808881f, -0.06823280f, -0.11452788f, 0.26165804f, -0.16086927f, -0.07061367f, 
    -0.24163689f, 0.04606048f, -0.16711110f, -0.01580885f, -0.04931754f, -0.26204935f, 0.06683944f, -0.24742261f, 
    0.27395719f, 0.06136830f, -0.27299991f, -0.06558432f, -0.08223638f, -0.15670674f, 0.04920777f, -0.28716367f, 
    0.00537078f, 0.20992045f, -0.02217139f, 0.05993405f, 0.13939036f, 0.18885085f, -0.11682233f, -0.05807908f, 
    -0.16674793f, -0.02022394f, 0.08353148f, -0.09797301f, 0.02632292f, 0.05052302f, -0.11741840f, -0.20365290f, 
    -0.05219143f, 0.40955141f, -0.14758195f, 0.23540375f, 0.12699479f, 0.14333051f, 0.06364584f, 0.02443890f, 
    0.26183748f, 0.04804345f, 0.03627114f, 0.10286581f, -0.06634319f, 0.09729499f, -0.09925191f, 0.18188952f, 
    -0.07951684f, -0.03221090f, 0.03566931f, -0.04080762f, -0.00207677f, 0.11018040f, -0.03697705f, 0.03954615f, 
    -0.26810524f, -0.12775271f, -0.16035625f, -0.05578479f, 0.07074112f, 0.09847628f, -0.05042548f, -0.05936966f, 
    -0.08785807f, -0.09455067f, -0.15261325f, 0.00915508f, 0.25074029f, -0.01408273f, -0.28998107f, -0.02287523f, 
    0.04773345f, -0.14902902f, 0.07827705f, 0.18123576f, 0.10551690f, 0.02699611f, -0.03500858f, 0.04676371f, 
    -0.52464557f, -0.09231787f, 0.19343597f, 0.14163677f, -0.00400766f, -0.04942680f, 0.13286605f, -0.20372619f, 
    0.02818061f, -0.05062876f, 0.15071428f, 0.19210266f, -0.18647544f, -0.37254867f, -0.09751905f, 0.10992629f, 
    -0.16065814f, 0.09292797f, -0.00854119f, 0.09848689f, 0.01071973f, 0.07407715f, -0.16588028f, -0.07526629f, 
    0.08880676f, -0.04004249f, -0.10341831f, 0.22984263f, 0.01579035f, 0.04827383f, -0.04437175f, -0.15172707f, 
    0.05433000f, -0.03775067f, 0.09139151f, 0.02334162f, 0.04413873f, 0.01547098f, 0.07035880f, -0.14899841f, 
    0.00225853f, -0.00070335f, 0.12662782f, -0.05234965f, 0.00743010f, 0.03539072f, -0.12709464f, 0.07757614f, 
    0.11888514f, -0.11190143f, -0.09606710f, -0.07842230f, -0.01064907f, -0.03266330f, -0.06756843f, -0.00290169f, 
    -0.11499903f, -0.09205931f, -0.06498096f, -0.24380751f, 0.58012706f, -0.11551794f, -0.39632773f, 0.06535985f, 
    -0.01544995f, -0.03265811f, -0.02854606f, -0.10310692f, -0.05287854f, -0.09149291f, -0.01022947f, 0.04036001f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10396236f, 0.08252169f, -0.08410741f, -0.02038616f, -0.03818500f, -0.00604041f, 0.01270968f, -0.05127274f, 
    0.00376877f, 0.04804501f, 0.13186626f, 0.05004962f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
