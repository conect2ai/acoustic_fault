#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.52204931f, 0.25575987f, 0.73288018f, 0.39729816f, 0.27214542f, 0.33417025f, -0.65878195f, 0.21767987f, 
    -0.29499695f, 0.37566996f, 0.34764990f, -0.18805307f, 0.09700212f, 0.12051775f, -0.19523498f, -0.15919220f, 
    0.25949621f, 0.06696408f, -0.11004776f, 0.27477890f, -0.10307951f, -0.05993185f, 0.55417424f, -0.12641959f, 
    -0.39627397f, -0.32197553f, 0.39440170f, -0.57728291f, 0.88155931f, -0.67164695f, 0.11612660f, -0.67644662f, 
    -0.39939076f, 0.11959445f, -0.28827429f, -0.20636106f, 0.29363483f, -0.01341056f, -0.27502608f, -0.20357645f, 
    0.47051683f, 0.18563740f, 0.18762508f, 0.18439078f, 0.17878075f, -0.13548900f, -0.02322602f, 0.36642906f, 
    -0.41933021f, -0.28230840f, 0.46557304f, 0.88544852f, 0.08516362f, -0.69047213f, -0.60167128f, -0.29385960f, 
    -0.20977557f, -0.28469002f, -0.72045958f, -0.00644184f, 0.35744080f, 0.30407450f, 0.16352510f, 0.35328385f, 
    -0.29855368f, 0.03760044f, -0.44032463f, -0.13086912f, -0.32802618f, -0.06033927f, -0.02925646f, 0.38370281f, 
    0.10605507f, -0.21295552f, 0.12977564f, 0.63479942f, 0.77296263f, 0.33889744f, 0.99592805f, 0.24472071f, 
    -0.10302912f, -0.12683889f, -0.44721705f, -0.05605121f, 0.21353808f, 0.19223423f, -0.06118769f, 0.03834454f, 
    0.41909969f, -0.55265892f, 0.10616200f, 0.06867789f, 0.13311927f, -0.23187383f, 0.00131151f, 0.01896337f, 
    -0.04610724f, -0.16864243f, -0.08129589f, 0.01351658f, -0.70600927f, -0.42251506f, 0.05930547f, -0.35439312f, 
    -0.45118788f, 0.06670159f, 0.54686892f, 0.22614805f, 0.20528610f, 0.24106011f, 0.23388998f, -0.18708508f, 
    -0.26709500f, -0.01285015f, 0.03675232f, 0.34454989f, -0.36137971f, 0.01173732f, -0.26993856f, -0.13248207f, 
    -0.12638587f, -0.08966415f, 0.65519989f, -0.03073279f, 0.47719440f, -0.08707839f, -0.45809180f, -0.66907775f, 
    -0.66478235f, -0.32652545f, 0.15337156f, -0.64527935f, 0.08067421f, 0.46847737f, -0.25419784f, -0.28438407f, 
    -0.16503420f, -0.03043369f, -0.10993025f, -0.44558248f, 0.24211389f, 0.29954708f, -0.05127415f, 0.07230020f, 
    0.12708767f, 0.27014536f, 0.30652830f, 0.07349717f, 0.32098052f, -0.15768565f, -0.69409245f, 0.02035758f, 
    0.52207756f, -0.01904071f, 0.05432752f, -0.05307398f, 0.10283923f, 0.34017980f, -0.21311001f, -0.64356703f, 
    0.31533325f, -0.03381305f, -0.01770028f, -0.48754472f, 0.14772120f, 0.09846495f, 0.38993764f, 0.42346889f, 
    0.64322716f, 0.29305375f, -0.29708412f, -0.08602937f, -0.36793721f, -0.11781119f, 0.09926607f, -0.90858567f, 
    -0.61514407f, -0.18221587f, 0.02794513f, -0.45133808f, -0.61766660f, -0.44245565f, 0.17028567f, 0.36659622f, 
    -0.19151436f, 0.33925334f, 0.25459635f, 0.10211959f, 0.38419631f, -0.12106954f, 0.16550495f, -0.16008633f, 
    0.10806926f, 0.01422283f, 0.19215250f, 0.18812484f, 0.06413880f, -0.11128062f, -0.01885820f, 0.22685181f, 
    -0.83782887f, -0.26332667f, -0.70785964f, -0.60887039f, -0.28264847f, 0.11440517f, 0.92940152f, 0.58488202f, 
    0.40361843f, 0.83470857f, 0.08935703f, -0.36581337f, 0.16822207f, -0.40755647f, 0.31779248f, 0.02942398f, 
    -0.29751119f, -0.06648493f, 0.14662032f, -0.31374508f, -0.28385252f, -0.14387828f, 0.03309189f, 0.06237966f, 
    0.20175824f, -0.19851035f, 0.25456369f, 0.24783647f, 0.05271272f, 0.34177548f, 0.56676608f, 0.34882873f, 
    0.48651916f, 0.19434981f, -0.00438206f, -0.38391602f, -0.31313041f, -0.14824857f, 0.16613510f, 0.07953399f, 
    0.06451672f, 0.09849323f, 0.25502047f, 0.43291920f, -0.12383235f, 0.13000225f, -0.33654085f, 0.52185076f, 
    0.35816288f, 0.31541792f, 0.22211015f, -0.21614423f, -0.39196622f, -0.64194775f, -0.04969409f, -0.48770431f, 
    -0.23765917f, 0.18451375f, 0.11034384f, 0.00414302f, -0.38183522f, -0.28292561f, -0.05104838f, -0.34386268f, 
    0.12191594f, 0.22676849f, 0.07999356f, -0.50986511f, -0.51860785f, -0.22691022f, 0.18927857f, -0.07044483f, 
    0.42047673f, 0.14192124f, -0.26809630f, -0.66571510f, -0.94162637f, -0.35272828f, 0.54632950f, 0.38667691f, 
    -0.50720251f, 0.61090219f, 0.57216108f, -0.40040016f, -0.61983478f, 0.32817003f, -0.07574794f, 0.04635035f, 
    -0.10807969f, -0.08821206f, -0.07103021f, -0.11708611f, -0.25895467f, -0.20877123f, 0.14483048f, -0.19509305f, 
    0.07037949f, -0.10929065f, 0.04241189f, 0.16264419f, -0.28689015f, -0.63344961f, -0.55360448f, 0.36213005f, 
    0.23946948f, 0.80979347f, 0.51056898f, -0.48875511f, 0.58823693f, 0.50502223f, 0.31791037f, -0.04917767f, 
    -0.03741819f, -0.17191079f, -0.21609579f, -0.24844664f, -0.03453454f, -0.01890980f, -0.12884222f, -0.11677779f, 
    -0.15214086f, -0.29739708f, 0.10172284f, -0.23299062f, -0.35180303f, 0.43768099f, -0.80649334f, 0.16391644f, 
    -0.65791225f, 0.89603227f, 0.59753335f, 0.22630899f, 0.43183285f, -0.16587426f, 0.07126247f, -0.47468138f, 
    -0.08762292f, -0.75155872f, 0.05709585f, 0.27100495f, -0.19776568f, 0.12255345f, 0.09659585f, 0.02400248f, 
    0.15766396f, -0.20983687f, -0.29871780f, 0.11189975f, 0.03720608f, -0.38060644f, -0.12303184f, -0.07145993f, 
    -0.66415977f, -0.24911703f, 0.05934960f, -0.00892337f, -0.70534027f, -0.46348906f, -0.28493121f, 0.11858004f, 
    -0.68422687f, 0.38886872f, 0.53032422f, -0.03711523f, 0.13872322f, 0.14796329f, 0.21380234f, 0.09429128f, 
    -0.07502308f, -0.07652330f, 0.23595060f, 0.23926745f, 0.06120649f, -0.35615346f, -0.01182956f, -0.46667653f, 
    0.70337361f, 0.76548904f, -0.68869561f, -0.08193562f, -0.87205398f, 0.47957534f, 0.00430097f, -0.00392348f, 
    -0.64292753f, -0.22905357f, -0.25458151f, 0.21987371f, 0.15363368f, 0.26929909f, 0.12487276f, -0.45564219f, 
    -0.03050641f, -0.05946175f, 0.04817861f, 0.24148735f, 0.13904159f, -0.26170230f, -0.12317136f, 0.11473455f, 
    1.03636634f, 0.69161850f, -0.17960660f, 0.72216398f, 0.81710851f, -0.12091615f, 0.02006743f, 0.23569727f, 
    0.26163021f, 0.34940976f, -0.12066782f, -0.16609664f, 0.15948050f, -0.20403785f, 0.26236516f, 0.38351351f, 
    -0.00051675f, -0.20898941f, -0.37802160f, 0.25977141f, -0.08672898f, -0.21342725f, 0.30466908f, 0.02278539f, 
    0.19048695f, 0.88167119f, -0.28172487f, -0.29192588f, -0.18144783f, -0.48957777f, 0.10118867f, -0.89864939f, 
    -0.29373494f, -0.32918304f, -0.39435455f, 0.11755263f, -0.05894734f, 0.44138601f, -0.18991670f, 0.07720197f, 
    -0.02834908f, -0.20976929f, -0.06304160f, -0.06718449f, -0.01993419f, 0.09085520f, 0.15030065f, 0.28854990f, 
    0.06923379f, -0.22845890f, 1.10698986f, 0.04948481f, -1.11427939f, -0.15255263f, -0.58187181f, -0.47088918f, 
    0.36966285f, -0.41829070f, -0.06864487f, 0.17085154f, -0.30084786f, 0.32220784f, -0.02680416f, -0.17582855f, 
    -0.12763572f, -0.20778857f, -0.25432181f, -0.31197506f, -0.06239448f, -0.19402361f, -0.09839202f, 0.08900350f, 
    -0.04536580f, 0.06509877f, 0.01052030f, -0.43730754f, -0.03265464f, -0.36003053f, -0.45634326f, 0.21629170f, 
    -0.21605957f, -0.10744805f, -0.51918125f, -0.26802707f, -0.08947386f, -0.29295298f, -0.29581904f, 0.30412212f, 
    -0.28956604f, -0.31807542f, 0.26271224f, -0.04617549f, 0.27578467f, -0.29903436f, -0.40620083f, -0.35891810f, 
    -0.11586303f, -0.26153412f, 0.12517896f, -0.00390688f, -1.22035336f, 0.24999790f, 0.43965125f, 0.15899636f, 
    -0.19493167f, 0.46772200f, 0.63023317f, -0.01959766f, -0.25435767f, 0.14955667f, -0.36658147f, -0.16117683f, 
    0.16501537f, -0.25660777f, -0.29892877f, -0.43973836f, -0.20580733f, -0.17431785f, -0.22690944f, -0.35211599f, 
    0.15437780f, 0.07306150f, 0.14204149f, 0.04951826f, -0.08363637f, 0.86667621f, 0.40633208f, 0.86062562f, 
    -0.20665544f, 0.21241289f, 0.07430890f, -0.49045184f, -0.57230866f, 0.18581167f, 0.07102028f, -0.00954390f, 
    0.43062919f, 0.27135807f, 0.10116366f, 0.11665617f, -0.26298347f, 0.24793525f, 0.22973850f, 0.07489172f, 
    0.40515807f, 0.34061262f, 0.14212728f, -0.27235657f, 0.05797858f, 0.59437054f, 0.02507667f, -0.68161625f, 
    -0.25968018f, 0.49904248f, 0.06717715f, 0.21186738f, 0.54184204f, 0.20048739f, -0.27259171f, 0.30273700f, 
    -0.15337376f, 0.14678371f, 0.35937378f, -0.30048001f, 0.51827466f, -0.46917048f, 0.32335660f, 0.19548476f, 
    -0.01075670f, 0.30717263f, -0.21290170f, 0.31963933f, -0.00317167f, 0.19451404f, 0.19057110f, -0.13640770f, 
    -0.53856003f, 0.28297591f, 0.85443324f, 0.45922276f, -0.47251910f, -0.17414401f, -0.57108647f, -0.38853124f, 
    0.46482646f, -0.37310001f, -0.05812737f, 0.08391305f, 0.54993623f, -0.31191763f, -0.39464104f, -0.02874994f, 
    0.19888581f, -0.04827885f, -0.11941035f, -0.23966345f, 0.00326500f, -0.32452935f, -0.01660885f, -0.21164145f, 
    0.40922049f, 0.74642283f, 0.55974400f, 0.40126359f, -0.42984667f, -0.35399443f, 0.71695578f, -0.52712744f, 
    0.04242361f, -0.24387890f, 0.01716624f, -0.06848489f, -0.34537041f, 0.09080353f, 0.38618737f, -0.05359538f, 
    -0.21707606f, 0.00666637f, -0.08323510f, 0.22974873f, 0.22948143f, 0.14624272f, 0.19894558f, 0.07373626f, 
    0.29416063f, 0.39187992f, 0.31130952f, -0.07062918f, 1.32472873f, -0.24526821f, 0.17260343f, -0.07409835f, 
    -0.16855769f, 0.39898422f, 0.18807690f, 0.02010499f, 0.07017530f, 0.19641258f, 0.07743394f, -0.44312200f, 
    -0.22335801f, 0.09508336f, 0.11330164f, -0.00605106f, -0.25606370f, 0.23249511f, 0.02463237f, -0.36134857f, 
    0.03683055f, -0.18591338f, 0.16875881f, 0.62764490f, -0.58868343f, -0.73407692f, -0.95216042f, 0.30477062f, 
    -0.28883201f, -0.42787510f, -0.66011351f, -0.13026281f, 0.31090713f, 0.11084795f, 0.06221928f, 0.30980986f, 
    0.30251980f, -0.07820328f, -0.08305904f, 0.24429715f, -0.01785271f, -0.25087491f, -0.03553997f, 0.19553633f, 
    -0.16760802f, -0.07559911f, 0.20020878f, 0.02456748f, -1.03935242f, -0.78177077f, 0.19772270f, -0.23381500f, 
    0.46941367f, 0.89017659f, 0.33355138f, 0.60601956f, 0.01583120f, -0.05541313f, 0.19575429f, -0.28314027f, 
    0.27193326f, 0.12679990f, 0.20829688f, -0.22286463f, -0.10893330f, 0.08844407f, 0.00129119f, 0.05879518f, 
    -0.17310789f, 0.19918385f, 0.12776272f, -0.25172827f, 0.95696002f, 0.42949143f, -0.15217778f, 0.02299790f, 
    0.13856082f, 0.63597548f, 0.39786169f, 0.34663758f, 0.57975775f, 0.33911270f, -0.30579749f, 0.52347744f, 
    -0.24858156f, 0.21091706f, -0.30871230f, 0.17190149f, -0.26024219f, 0.00060286f, 0.28593728f, 0.17465845f, 
    0.05449395f, 0.06745420f, -0.08165041f, -0.33570391f, 0.16554821f, 0.00224502f, 0.04300842f, 0.21264642f, 
    0.99792260f, 0.42726567f, 0.36911622f, 0.66967463f, -0.35302287f, 0.38360679f, -0.27821594f, 0.19418736f, 
    0.15619788f, 0.20783345f, -0.45867974f, -0.33466020f, -0.01278296f, 0.30441606f, 0.02859292f, -0.19565551f, 
    0.05124695f, -0.20092866f, -0.34198219f, -0.46021605f, -0.27086192f, -0.30911335f, 0.00765071f, -0.29511428f, 
    -0.21406147f, -0.84663713f, -0.22234672f, -0.34765497f, 0.23116106f, 0.65251845f, 0.63735616f, -0.31223258f, 
    -0.51950651f, -0.09581960f, 0.03455326f, -0.26175579f, 0.06783942f, 0.29313496f, -0.11433894f, -0.01389749f, 
    -0.03007742f, -0.17187533f, -0.31156337f, -0.12847067f, -0.18395738f, -0.32735097f, 0.23628256f, -0.02212728f, 
    0.56178242f, 0.04623320f, 0.58940446f, 0.25812235f, 0.02246397f, 0.34387556f, 0.71406519f, -0.25599888f, 
    0.47648710f, -0.32945445f, -0.43367758f, -0.47800311f, -0.13164133f, -0.00329979f, 0.10709603f, 0.30032298f, 
    0.22272274f, 0.30976790f, 0.04131669f, 0.04204725f, 0.02951946f, 0.04843285f, -0.02721480f, -0.30930763f, 
    -0.52895981f, 0.77598554f, -0.27242628f, -0.57412767f, -0.39997041f, 0.69934708f, 0.49437302f, -0.67499292f, 
    0.17551723f, -0.39316830f, 0.17912640f, 0.38287953f, 0.07413856f, 0.23699579f, -0.16096811f, 0.15950046f, 
    -0.04905271f, -0.01273249f, -0.07575511f, -0.00116031f, 0.30450714f, -0.53700614f, -0.10901039f, -0.04136703f, 
    0.00688708f, 0.95499253f, 0.30801165f, 0.38809294f, 0.78543788f, 0.93966168f, 0.37893745f, 0.10006049f, 
    -0.33819956f, 0.02069397f, -0.42268676f, -0.21077450f, -0.01117592f, -0.07846049f, 0.06442977f, 0.00479323f, 
    0.16594350f, 0.08075155f, 0.08871595f, 0.11488815f, 0.12997678f, 0.17768613f, 0.24260631f, 0.00041915f, 
    -0.17109634f, 0.09484468f, -0.01794383f, 1.05058873f, 0.18489914f, 0.34230992f, -0.38829345f, 0.38411015f, 
    0.08697277f, -0.59871364f, 0.18781234f, -0.48521838f, -0.20738967f, -0.17668620f, -0.01370434f, 0.29453734f, 
    -0.17239480f, -0.04292953f, -0.35540226f, 0.29743716f, 0.53525609f, 0.07330454f, -0.25220585f, -0.12327517f, 
    -0.36776310f, -0.05607744f, 0.36434314f, -0.09302058f, -0.45782256f, -0.75585133f, -0.51261687f, -0.60324794f, 
    0.34417123f, 0.19480681f, 0.24345690f, -0.07858866f, -0.03958216f, 0.15521896f, -0.36006957f, -0.13286018f, 
    0.45810917f, 0.26263592f, -0.41347092f, -0.04340942f, 0.00306031f, -0.15677984f, -0.00690408f, 0.13733973f, 
    -0.38382569f, 0.24253033f, 0.21633247f, 0.04515560f, 0.79274392f, -0.27313268f, -0.48843947f, 0.56826848f, 
    0.33441699f, -0.29214820f, -0.93583715f, -0.29333013f, -0.48625791f, -0.35062110f, 0.05145418f, 0.35323912f, 
    -0.00422795f, 0.10572394f, 0.23413660f, 0.26580024f, 0.04807404f, -0.13163161f, -0.14499779f, 0.56358564f, 
    0.12185413f, 0.01603780f, -0.14442143f, -0.06267535f, 0.20722254f, 0.73088980f, 0.00877437f, -0.25908470f, 
    0.47024208f, -0.13365074f, -0.47441062f, -0.49435887f, 0.65204114f, 0.58549511f, -0.01485812f, -0.59077549f, 
    -0.38279393f, 0.27196178f, -0.35231093f, -0.35924616f, -0.36592573f, 0.22655305f, 0.23732841f, -0.06390606f, 
    -0.07654376f, 0.43743601f, -0.02318178f, -0.24951813f, -0.30758637f, -0.23945595f, -0.01386021f, 0.82016587f, 
    -0.11564388f, -0.30537012f, 0.58160704f, -0.11804210f, 0.13612877f, 0.35606965f, -0.43493891f, 0.12543386f, 
    -0.15860000f, -0.27108347f, 0.26335502f, -0.04507498f, 0.02579511f, 0.32753870f, 0.12899365f, 0.40308326f, 
    0.41264570f, -0.19338425f, 0.32590470f, 0.01318197f, -0.39172798f, -0.34736875f, 0.05235248f, -0.02825819f, 
    -0.46702692f, -0.94727355f, -0.73728168f, 0.35338813f, 0.67753285f, -0.39819968f, 0.18918924f, 0.08689246f, 
    0.32740095f, -0.34729254f, -0.15193772f, -0.11884721f, 0.07656743f, 0.11119311f, 0.20948677f, -0.01392418f, 
    0.17742445f, 0.16396579f, 0.22275257f, -0.17589153f, -0.34564844f, -0.29115403f, -0.40262771f, 0.22788210f, 
    0.03352461f, -0.19755694f, 0.12310003f, -0.66963607f, -0.70636874f, -0.18920349f, -0.15561868f, -0.24607719f, 
    -0.46669477f, 0.16049235f, 0.13997452f, -0.21110265f, -0.34714493f, -0.29701290f, 0.06753965f, -0.11101092f, 
    0.02766170f, 0.04127896f, -0.23203126f, 0.23664959f, 0.15221286f, -0.06703793f, -0.15999913f, 0.35701144f, 
    0.03215045f, -0.40080875f, -0.54454911f, 0.51671582f, -0.05339987f, -0.66697001f, 0.43955085f, -0.71738553f, 
    0.26448610f, -0.47210181f, -0.27759773f, -0.17009653f, -0.10004215f, -0.00782743f, 0.51358569f, -0.21859783f, 
    -0.22486532f, 0.10372096f, 0.22015500f, -0.01734665f, -0.24221985f, 0.06531410f, 0.25145796f, 0.31597203f, 
    0.22210279f, -0.16792759f, 0.63947517f, 0.27688065f, 0.30694646f, 0.47583705f, 0.78868991f, 0.61281222f, 
    -0.07736420f, -0.12437585f, -0.26190701f, 0.38644123f, -0.49318221f, -0.00048560f, -0.35219383f, -0.22690311f, 
    -0.14191638f, -0.25881588f, -0.27850556f, -0.14449590f, -0.26196939f, -0.13431723f, 0.29353094f, 0.12769364f, 
    0.08447858f, 0.09005217f, 0.35794869f, -0.35790545f, -1.40738332f, -0.56341088f, 0.43937495f, 0.55193251f, 
    -0.76857668f, 0.64378488f, 0.21522023f, -0.46467641f, 0.49629039f, 0.02980932f, 0.09277789f, 0.05144860f, 
    0.00213104f, 0.21119542f, -0.16265278f, 0.44175100f, 0.03454333f, 0.10314348f, -0.08886819f, 0.25920781f, 
    0.00546338f, -0.12274296f, -0.05426643f, 0.07409651f, -0.52404100f, 0.88130981f, -0.37359336f, -0.81641722f, 
    0.88731915f, 0.16368766f, -0.77150369f, -0.36221331f, 0.27803603f, 0.30698434f, -0.09127177f, -0.19685565f, 
    -0.19805238f, 0.39400461f, -0.02412198f, -0.02926830f, 0.15498281f, -0.36309579f, 0.10564470f, 0.05975597f, 
    -0.05283257f, 0.38995120f, 0.12312099f, 0.02601808f, -0.17464344f, 0.38272938f, 0.47841099f, 0.57574850f, 
    0.74454498f, 0.32603636f, 0.36512098f, -0.21403864f, -0.21767592f, 0.25117639f, 0.35283577f, 0.10586739f, 
    0.31687444f, 0.28675014f, -0.37068903f, -0.28049722f, 0.00054465f, -0.30666840f, -0.05474780f, 0.05001504f, 
    0.15531690f, -0.19190831f, -0.23436610f, 0.21619779f, -0.28716391f, -0.00519386f, -0.20534366f, -0.46436822f, 
    -0.04303733f, 0.02790850f, -0.19192755f, -0.41670403f, -0.19561990f, 0.79590338f, 0.07200988f, -0.64592302f, 
    -0.09872692f, -0.10609258f, -0.60873473f, -0.27047455f, 0.33087018f, 0.36228403f, 0.59320104f, -0.10889272f, 
    -0.03973322f, -0.01891932f, 0.18795536f, 0.10909662f, 0.32446006f, 0.37988979f, -0.14432350f, -0.86025459f, 
    -0.19707145f, -0.03288455f, -0.26722786f, -0.43657464f, 0.22203484f, 0.42225945f, -0.05293718f, -0.14509073f, 
    0.10036270f, -0.50266647f, 0.23089826f, -0.09596145f, -0.02874001f, 0.23054524f, -0.42955634f, 0.01962613f, 
    0.22194533f, 0.02222718f, -0.31400520f, 0.56576318f, -0.29127818f, -0.05409486f, -0.22436242f, 0.12382034f, 
    -1.01754105f, 0.68305093f, -0.12551199f, -0.32598159f, -0.02148735f, -0.31547162f, 0.57580638f, -0.02728590f, 
    0.31082276f, -0.24879414f, 0.26520035f, 0.01776088f, 0.10626708f, -0.45121837f, -0.04937861f, -0.04194494f, 
    0.05065544f, 0.03378452f, 0.14212172f, -0.16179660f, -0.13228521f, -0.13159187f, -0.17356558f, 0.27447268f, 
    -0.13675746f, -0.38062346f, -0.96117204f, -0.38443622f, 0.16192894f, -0.23767774f, -0.77875221f, 0.34579977f, 
    0.05234278f, -0.10883243f, -0.14191666f, 0.23953001f, 0.34824583f, 0.01620838f, 0.20153624f, 0.18213679f, 
    -0.28109509f, 0.07860772f, -0.15361381f, 0.30723062f, -0.00422631f, -0.19867295f, -0.31521899f, -0.35994497f, 
    -0.23562627f, -0.01173097f, -0.13515776f, -0.66910237f, 0.08359639f, 0.07444905f, 0.02121546f, 0.94644177f, 
    -0.68323636f, -0.02138592f, -0.24957702f, 0.19258703f, 0.12717770f, -0.25186276f, 0.15007445f, 0.17043132f, 
    0.24711423f, 0.25834584f, 0.33588287f, -0.17858751f, -0.00092050f, 0.40526500f, 0.54292917f, -0.18731108f, 
    0.13730200f, 0.27826795f, -0.11437429f, 1.07880759f, -0.31195530f, -0.01440040f, 0.55174112f, 0.51721644f, 
    -0.52079099f, 0.37073219f, -0.05901915f, -0.30045420f, 0.10918815f, 0.33418441f, 0.08694641f, -0.28972498f, 
    -0.24575253f, -0.03043665f, 0.00089667f, 0.23313862f, 0.10637703f, 0.34911102f, 0.32619226f, -0.27525350f, 
    -0.14248486f, 0.14306252f, 0.17470525f, 0.01919370f, -0.59569514f, 0.92592359f, 0.05175543f, 0.16722849f, 
    0.55160427f, -0.19213904f, 0.76422215f, 0.53281760f, -0.07564788f, 0.42310619f, -0.48074120f, 0.29449081f, 
    0.30977041f, -0.46873176f, -0.03700896f, 0.04531850f, -0.03561914f, -0.21958461f, -0.04675726f, -0.11946106f, 
    0.12532493f, 0.01712567f, 0.07247973f, 0.15076315f, -0.04048489f, 0.17402335f, -0.49909428f, -0.62636304f, 
    -0.70327425f, -0.28053302f, 0.13453028f, 0.59651792f, 0.09063259f, -0.13198839f, 0.30918387f, -0.29804933f, 
    0.01548563f, -0.39099213f, -0.04635483f, -0.50665236f, -0.29061013f, 0.11503552f, 0.21548733f, 0.37204409f, 
    -0.00039823f, -0.16207547f, 0.23010327f, -0.40700379f, -0.26577598f, 0.49815434f, -0.46489054f, -1.24166453f, 
    -0.20236146f, 0.16612163f, 0.42765853f, -0.27710131f, 0.88707072f, 0.21949710f, -0.51453596f, -0.02532475f, 
    0.36215848f, -0.16325966f, -0.05509762f, -0.14846569f, 0.26518637f, -0.40146908f, -0.34888726f, -0.06156676f, 
    -0.17711486f, -0.11486586f, 0.03716196f, 0.03039758f, 0.12106657f, -0.12141842f, -0.11122383f, 0.46546239f, 
    0.64956754f, -1.10716367f, 0.41869760f, -0.21596967f, 0.00698449f, -0.11484049f, 0.00551833f, 0.08816585f, 
    0.13005969f, -0.02738087f, 0.24275456f, -0.25596914f, 0.03146837f, 0.32516178f, -0.09629425f, -0.51076335f, 
    0.14129712f, -0.02130971f, 0.25897998f, 0.48138741f, 0.14200123f, -0.00062977f, 0.14506015f, -0.11522338f, 
    1.24031579f, 0.04765157f, 0.03028443f, 0.83284968f, 0.47137120f, 0.26692128f, 0.31973276f, -0.17285016f, 
    0.04128533f, -0.08823687f, 0.00590980f, 0.03592660f, -0.05289987f, -0.18388668f, -0.07633872f, -0.06797895f, 
    -0.00798787f, 0.14557393f, -0.00260704f, -0.26475734f, -0.11953088f, -0.13247886f, 0.05822211f, -0.13811772f, 
    0.11544632f, 0.74463367f, 0.93125772f, 0.47390726f, -0.57875323f, -0.67889053f, -0.14185658f, -0.30141339f, 
    0.13347045f, 0.35596636f, 0.27705911f, 0.35403594f, -0.00468080f, -0.13871217f, 0.24669316f, 0.17314953f, 
    0.22709541f, 0.15580605f, 0.43518013f, 0.07109129f, -0.35876474f, -0.20842396f, -0.23134382f, 0.26556638f, 
    -0.37341565f, -0.17875706f, 0.48316047f, 0.52681029f, 0.52007121f, 0.00318457f, -0.51351118f, -0.56741589f, 
    -0.93000382f, -0.50439888f, -0.03155174f, -0.36553937f, 0.49320093f, 0.18857425f, 0.32526636f, 0.16765578f, 
    -0.36232573f, 0.13167281f, 0.28791299f, -0.12877172f, -0.00666952f, -0.21362340f, 0.03971553f, 0.03998994f, 
    0.32843360f, 0.21655440f, 0.24955168f, 0.11755847f, -0.58178556f, -0.08149981f, 0.71892065f, -0.12241386f, 
    -0.03805882f, -0.62574196f, -0.63021398f, 0.46629989f, -0.20942807f, 0.31115732f, 0.41658595f, -0.29673991f, 
    0.15659745f, -0.04039873f, -0.16994467f, 0.01619291f, 0.45309344f, 0.09972363f, 0.00238649f, 0.24560758f, 
    0.21981752f, -0.43459201f, -0.02315203f, 0.22401899f, 0.60384119f, 0.57268065f, 0.77287346f, 0.35127094f, 
    0.07770178f, -0.35494313f, 0.25560609f, -0.05222463f, 0.22882701f, 0.34406680f, -0.17410612f, -0.15558560f, 
    -0.04629367f, 0.25018737f, -0.22167400f, -0.43910733f, -0.34280053f, -0.17199683f, 0.05370942f, -0.22648862f, 
    0.25875056f, 0.35869306f, 0.25650609f, 0.01113303f, -0.32883525f, 0.09025639f, -0.63769227f, 0.24037223f, 
    0.19876081f, -0.13145901f, 0.23905811f, -0.25387472f, -0.07083309f, -0.61925745f, -0.48106030f, -0.12876086f, 
    -0.37217897f, -0.47792530f, 0.14227104f, -0.32176757f, 0.38929012f, -0.41270256f, -0.32549652f, -0.15250522f, 
    -0.09731008f, -0.48098776f, -0.03094638f, 0.13261160f, 0.20656432f, 0.32121509f, 0.55326962f, 0.26814380f, 
    -0.74581140f, -0.65195215f, 0.39638120f, -0.49529010f, -0.64062041f, 0.48366037f, -0.11792538f, 0.09829362f, 
    0.12155328f, -0.10669027f, 0.13270156f, -0.23047240f, -0.49260342f, 0.18507683f, -0.04330416f, 0.18701597f, 
    0.38089457f, 0.27892345f, 0.36039484f, 0.04751508f, -0.23956414f, -0.18893723f, -0.22861786f, 0.01625234f, 
    0.70610613f, 0.07815794f, 0.17791007f, 0.73857385f, 0.43661499f, -0.57828420f, -1.01335609f, -0.51436412f, 
    -0.34899762f, 0.30829722f, -0.14447202f, -0.06874013f, 0.02769217f, -0.54910040f, 0.08455365f, 0.02032406f, 
    -0.02925608f, -0.26387385f, -0.13570735f, 0.07817890f, 0.05047472f, 0.26147798f, -0.08795638f, -0.23438554f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23981167f, 0.10812031f, 0.16035868f, 0.06303229f, -0.07006206f, 0.13101181f, 0.24438527f, 0.35175735f, 
    0.11054248f, 0.14963530f, 0.14116044f, 0.21926118f, 0.02636955f, 0.04024255f, 0.17414299f, 0.21685281f, 
    0.20591451f, 0.09260792f, 0.10381889f, 0.20751193f, 0.04712673f, 0.30248898f, 0.25756574f, 0.16302243f, 
    0.22492939f, 0.16045059f, 0.22003628f, 0.13219388f, 0.04982850f, 0.11627989f, 0.15847719f, 0.15887833f, 
    0.33154076f, 0.18605545f, 0.13268661f, 0.27731097f, 0.22444084f, 0.00245191f, 0.20035137f, 0.06304073f, 
    -0.03588492f, 0.12492051f, 0.13584048f, 0.26857862f, 0.26706448f, -0.05704800f, 0.19669050f, -0.02534849f, 
    -0.01614675f, -0.02101532f, 0.20704284f, 0.13780606f, 0.12324816f, -0.06508370f, 0.04327331f, 0.18715321f, 
    0.10664157f, 0.16855823f, 0.13722412f, 0.12141359f, 0.19675069f, 0.04138833f, 0.24264456f, 0.04432984f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00981031f, -0.02599403f, -0.02876481f, 0.01199526f, -0.00227444f, -0.00606571f, 0.01829519f, -0.01071989f, 
    -0.01943602f, -0.01823193f, -0.00167428f, 0.01107335f, -0.01922037f, -0.00094193f, -0.00092044f, -0.04040715f, 
    -0.02414600f, -0.00800314f, 0.00999871f, -0.00051852f, 0.03513344f, -0.00213827f, -0.03128551f, -0.00818646f, 
    -0.00214367f, 0.01644310f, 0.02034258f, -0.03352497f, -0.03279759f, 0.01119311f, 0.02161754f, -0.03502177f, 
    -0.03144819f, 0.02074647f, -0.04208555f, -0.02600980f, -0.00646571f, -0.02396141f, -0.02984690f, 0.01646074f, 
    -0.03541659f, -0.03580165f, -0.02164114f, -0.01919709f, -0.03678388f, 0.02911114f, 0.00339320f, -0.03519962f, 
    -0.03766618f, 0.02574361f, -0.01265406f, -0.01802496f, -0.01874368f, -0.03256300f, -0.01933454f, -0.02651753f, 
    0.00047329f, -0.02577792f, 0.02097593f, 0.02705554f, -0.02066168f, -0.03526655f, -0.01559076f, -0.01569955f, 
    0.00905839f, 0.02171292f, -0.00131468f, -0.04156012f, 0.01490329f, -0.02798005f, 0.02776972f, 0.00838938f, 
    -0.01416093f, 0.02248650f, 0.00367410f, -0.00123097f, 0.00183879f, 0.00429727f, -0.00217628f, -0.03698016f, 
    -0.01342150f, -0.03588482f, -0.03342979f, -0.00842366f, 0.00712304f, 0.01025853f, 0.00670275f, -0.00735288f, 
    -0.01359439f, 0.02167064f, 0.02664527f, 0.01946249f, -0.00704498f, -0.01143382f, -0.00629983f, 0.00784842f, 
    0.02258327f, -0.02616427f, -0.01417439f, -0.01122444f, -0.03979604f, -0.02459056f, -0.01196243f, 0.01206611f, 
    -0.00807933f, 0.00670137f, -0.00422592f, 0.01222119f, -0.02609861f, -0.02605228f, -0.01293149f, -0.00852201f, 
    -0.02435599f, 0.02116586f, -0.01620679f, -0.02411603f, 0.00450403f, -0.01440846f, -0.01593453f, -0.01744081f, 
    -0.00859556f, 0.00134039f, -0.02534448f, -0.02413285f, -0.00215784f, -0.03074546f, 0.01820937f, -0.00248734f, 
    -0.01469100f, -0.02569543f, -0.01002938f, 0.02987617f, 0.01653733f, -0.00592289f, 0.02388498f, -0.03061706f, 
    -0.01633155f, 0.02144233f, 0.02707419f, 0.00971518f, 0.02514676f, -0.01532820f, -0.01438876f, -0.00119508f, 
    -0.00076633f, -0.01789179f, -0.01089305f, -0.01911321f, -0.02329606f, 0.00545534f, -0.03094963f, 0.02004856f, 
    -0.01338237f, 0.01200430f, 0.01915959f, 0.02022267f, -0.02240995f, 0.01928422f, -0.02790594f, -0.02903439f, 
    -0.01384927f, 0.00164199f, -0.00052466f, 0.00079281f, 0.02344534f, -0.02225603f, -0.01714537f, 0.00869779f, 
    -0.03541520f, -0.03269987f, 0.01422944f, -0.00461329f, 0.00043780f, 0.02274685f, 0.02836891f, 0.00639668f, 
    -0.01370691f, -0.01224665f, 0.00353333f, -0.03793137f, 0.02618700f, -0.02042282f, 0.00091580f, -0.02565832f, 
    0.00193160f, 0.00521995f, -0.02779697f, -0.01119629f, 0.00237191f, 0.00291191f, 0.01297966f, 0.00384281f, 
    0.02030127f, 0.00493477f, -0.03322721f, -0.02786833f, -0.01879677f, 0.02014714f, -0.02579494f, 0.01744518f, 
    0.01669267f, -0.00502659f, -0.01474600f, -0.00700880f, -0.03844943f, -0.01867304f, 0.00860935f, 0.02298181f, 
    0.00954675f, -0.04166609f, 0.01080183f, 0.00955034f, 0.01133288f, -0.01774382f, 0.02754749f, -0.01618560f, 
    0.02929814f, 0.01717123f, -0.02873279f, -0.03510928f, 0.00374286f, -0.03014291f, -0.01567389f, 0.00913586f, 
    -0.01208622f, 0.01069296f, -0.01354309f, 0.02980891f, 0.01205690f, -0.03496974f, -0.00382645f, -0.02209840f, 
    -0.01672013f, 0.02743666f, -0.00114871f, -0.03647124f, -0.02700394f, -0.00970493f, -0.03204796f, 0.00904436f, 
    -0.03587683f, -0.01330785f, 0.02395175f, 0.02727173f, -0.00680368f, 0.00506210f, -0.02604541f, -0.03035058f, 
    0.02661701f, -0.03114831f, -0.01956801f, -0.02087948f, 0.01031050f, -0.03953462f, 0.00123823f, -0.04159132f, 
    -0.01766327f, -0.01913398f, -0.01623025f, -0.00690517f, -0.02889606f, 0.00828449f, -0.03550386f, -0.00961211f, 
    -0.02198133f, -0.01570528f, -0.01448974f, -0.02670613f, 0.01204012f, -0.01575476f, -0.02766984f, 0.00209733f, 
    -0.01050755f, 0.02117753f, -0.01378207f, 0.00570777f, -0.00065983f, -0.02874705f, -0.02685325f, 0.02112155f, 
    0.00943879f, 0.01104072f, 0.00067261f, -0.01516411f, 0.02309954f, -0.00499071f, -0.02604052f, 0.02215951f, 
    0.02317614f, -0.03773918f, -0.02185736f, -0.00151256f, -0.02217379f, 0.00368176f, -0.02155089f, 0.00765618f, 
    0.02479331f, 0.01222607f, 0.02185867f, -0.01574898f, -0.00381115f, -0.00680894f, 0.01151440f, -0.02689849f, 
    0.00565798f, -0.01363971f, -0.01959474f, 0.00756550f, -0.03859769f, -0.00170259f, 0.01743085f, -0.02175932f, 
    -0.00971219f, 0.02778124f, -0.01549361f, -0.02751740f, -0.03182556f, -0.02973133f, -0.01045866f, -0.01708734f, 
    0.02853843f, -0.01432404f, -0.00633122f, 0.01025424f, -0.02868280f, -0.03385686f, 0.02534951f, -0.00566911f, 
    0.00857452f, -0.01215675f, 0.01709248f, -0.02105749f, 0.00045660f, -0.00978611f, 0.01003683f, -0.03270520f, 
    -0.02672724f, 0.01444811f, -0.03160844f, 0.01173821f, -0.00782452f, -0.01301917f, 0.00991558f, 0.01172128f, 
    0.00849843f, -0.01499172f, -0.03832701f, 0.02783331f, -0.01369181f, -0.02280274f, 0.02057337f, -0.00403635f, 
    0.03002372f, 0.00399659f, 0.02476896f, -0.04181830f, 0.02725655f, 0.00846822f, 0.02074963f, -0.01242552f, 
    0.02827706f, -0.02407488f, -0.01947715f, -0.00799887f, -0.04176279f, -0.00393793f, -0.01392335f, 0.00796743f, 
    -0.02451650f, -0.00450708f, 0.01054259f, 0.00612076f, -0.03765898f, -0.00753500f, 0.00827892f, -0.00940154f, 
    0.02483175f, -0.00617678f, -0.01668035f, -0.02395990f, -0.03569137f, 0.01540015f, -0.01444020f, -0.02326193f, 
    -0.01570178f, 0.02363469f, -0.00426970f, 0.01547398f, -0.00868528f, -0.02513237f, 0.02536090f, -0.02724733f, 
    -0.01507730f, -0.02920118f, -0.03157434f, -0.01344068f, -0.00986006f, -0.00667826f, 0.02050114f, 0.02515099f, 
    0.00835617f, -0.00328426f, -0.02069845f, -0.03767087f, -0.01535742f, -0.03876875f, -0.03945766f, -0.03178949f, 
    -0.02342904f, 0.01794695f, -0.01979630f, -0.00924383f, -0.03672655f, -0.01653663f, -0.00530505f, -0.01275683f, 
    0.00517688f, 0.01758807f, 0.00570600f, 0.00705441f, -0.03345907f, 0.01438997f, -0.00619852f, -0.02735468f, 
    0.00384134f, 0.02705285f, -0.00682821f, 0.02973470f, -0.03710865f, 0.01229697f, -0.03730797f, 0.00798341f, 
    0.00667785f, 0.00436128f, -0.03186606f, 0.02600886f, 0.00655811f, 0.00657304f, -0.01882969f, -0.02161150f, 
    0.00110359f, -0.02755106f, 0.00400595f, -0.00171341f, -0.02467968f, 0.02367772f, -0.03941885f, -0.00081319f, 
    -0.03664007f, -0.03922053f, 0.02173467f, -0.03532657f, -0.01631631f, -0.02840413f, -0.00582103f, -0.02677687f, 
    -0.02508544f, -0.02603576f, -0.01193183f, -0.01585604f, 0.01625862f, -0.02259069f, -0.03149152f, 0.02024518f, 
    0.01447586f, -0.03537244f, 0.02068515f, 0.01537706f, 0.00098509f, 0.00821338f, 0.02378625f, 0.00941118f, 
    -0.00283200f, -0.02609502f, -0.04031826f, 0.00357653f, -0.02316281f, -0.02895171f, -0.01527797f, 0.00482116f, 
    -0.01352525f, 0.00348718f, -0.01089455f, 0.01136396f, 0.01911276f, 0.00124606f, 0.00078420f, 0.01466467f, 
    0.02075950f, -0.03795410f, 0.02630540f, 0.00792777f, 0.03005094f, -0.00649732f, -0.02597502f, -0.00637593f, 
    0.00351507f, -0.03851260f, 0.00138255f, -0.01259190f, -0.03732583f, -0.00641075f, 0.02251895f, 0.01389145f, 
    0.00670883f, 0.00417831f, -0.02027936f, -0.00075758f, 0.00767563f, -0.00259088f, -0.01152900f, -0.00436799f, 
    -0.00415629f, -0.03478182f, 0.02342069f, 0.02126036f, -0.03577142f, -0.01735131f, -0.02913183f, -0.02045382f, 
    -0.03629399f, -0.02933712f, -0.00743968f, 0.02924729f, 0.02341895f, -0.01412282f, -0.00818687f, -0.02701568f, 
    -0.03843668f, -0.03358843f, -0.01630282f, -0.02342265f, -0.01369522f, 0.02441333f, -0.00643176f, -0.03474325f, 
    -0.01785751f, 0.02286819f, 0.01004362f, -0.03725581f, 0.02205068f, -0.02218710f, 0.03503792f, 0.02162741f, 
    -0.02643088f, -0.02695731f, -0.03229595f, 0.01009531f, -0.01005822f, -0.00379407f, -0.03199954f, -0.01702018f, 
    -0.00063145f, -0.02448245f, -0.03741729f, -0.00123402f, 0.01161106f, -0.00518498f, -0.00543061f, -0.03422409f, 
    -0.02060100f, -0.00487906f, 0.02887249f, 0.01263473f, -0.00583914f, -0.03827855f, -0.02126534f, -0.01577014f, 
    0.00218217f, 0.02678373f, 0.01101523f, -0.03640341f, -0.04163438f, -0.03428867f, 0.00304061f, 0.01289150f, 
    -0.00523259f, -0.01068173f, -0.03151486f, -0.00336903f, -0.02507231f, -0.01087481f, 0.02163522f, 0.01903451f, 
    -0.00114498f, -0.03796425f, 0.01138851f, -0.02402373f, -0.03139242f, -0.03818399f, 0.01349602f, -0.03823103f, 
    -0.02168005f, -0.01592362f, 0.00593235f, 0.02000985f, 0.01590509f, 0.01220307f, 0.03149670f, -0.02507461f, 
    -0.02251710f, -0.02935090f, 0.00274706f, 0.02716341f, -0.02020099f, 0.00560370f, -0.03765031f, 0.00654247f, 
    0.01789636f, -0.01037948f, -0.02589737f, 0.02579223f, -0.01758125f, -0.00656801f, 0.02458017f, 0.00611796f, 
    0.01213890f, -0.03065320f, -0.02197738f, 0.02367964f, 0.02830151f, -0.01967449f, 0.00710966f, -0.02516309f, 
    0.02729141f, -0.02493314f, -0.02930735f, 0.00970479f, 0.00235989f, -0.03331482f, -0.00513125f, 0.02280303f, 
    -0.01750082f, 0.02098627f, -0.00951578f, 0.00758014f, -0.03183266f, -0.02164993f, -0.01996541f, -0.02922157f, 
    0.01725959f, -0.00704395f, 0.00254613f, -0.01478305f, 0.00089390f, -0.03301327f, -0.00229921f, -0.03387237f, 
    -0.00073588f, -0.01289350f, 0.01007220f, -0.02825829f, -0.02185303f, 0.00897688f, 0.03542885f, 0.01340257f, 
    -0.01314857f, -0.01586539f, 0.01669577f, 0.00587405f, 0.02159739f, -0.00439956f, -0.00557607f, -0.04187056f, 
    0.00051409f, -0.02169450f, -0.01225235f, 0.02757697f, -0.02060485f, 0.02722219f, -0.01206185f, -0.00883464f, 
    -0.00079572f, -0.01518820f, -0.03663167f, -0.01158389f, 0.01767296f, -0.01571568f, -0.02299835f, -0.04177051f, 
    0.02979386f, 0.02008093f, 0.01170953f, 0.02820594f, 0.00339698f, -0.01388740f, -0.02615152f, 0.02480804f, 
    -0.00072268f, -0.02942567f, 0.00897670f, -0.03589462f, 0.02825118f, 0.01934139f, -0.02375483f, -0.04028955f, 
    0.02733287f, -0.01998127f, -0.02499741f, 0.02812833f, -0.01928637f, 0.02288458f, 0.02499762f, -0.02880946f, 
    0.01852001f, 0.00856111f, -0.01523892f, -0.02402114f, 0.00505202f, 0.01725229f, -0.01440616f, 0.01888629f, 
    -0.02534614f, -0.01443624f, -0.01883930f, -0.02618228f, -0.00316903f, 0.01781366f, 0.01954728f, 0.02847560f, 
    0.01511223f, -0.03084307f, -0.02994966f, -0.03852773f, 0.00117919f, -0.03803531f, 0.02520908f, -0.00150955f, 
    0.00028077f, 0.02438707f, 0.02628722f, -0.01094806f, 0.02716284f, -0.02781969f, 0.00430444f, -0.01997862f, 
    0.02525537f, -0.01654001f, 0.02977294f, -0.03295072f, 0.00339055f, -0.03260098f, -0.00278678f, 0.02035694f, 
    -0.01073297f, -0.00615888f, -0.01781334f, 0.02016357f, -0.02163882f, -0.03106994f, -0.00993574f, 0.01368023f, 
    -0.03505838f, 0.02760728f, -0.03699270f, 0.02855937f, 0.01844905f, 0.01145970f, -0.01796448f, -0.01564643f, 
    -0.01493138f, -0.00203171f, -0.01004504f, -0.02482635f, -0.03021413f, -0.00506069f, 0.01746389f, 0.02627912f, 
    -0.01318667f, 0.02262817f, -0.02210331f, 0.01297367f, 0.02242380f, 0.00985872f, 0.02257243f, 0.00171720f, 
    0.00581901f, -0.03293159f, -0.02205165f, -0.00588593f, 0.02208368f, 0.01573747f, 0.02802483f, 0.00212552f, 
    -0.01365796f, -0.01525805f, -0.04226466f, 0.02514822f, -0.00271108f, 0.01256248f, -0.02490213f, 0.00200462f, 
    0.02747476f, 0.00711722f, -0.02043532f, -0.00781252f, 0.00005398f, 0.02417537f, -0.03682506f, 0.00090606f, 
    0.02049337f, -0.01423856f, -0.03873970f, -0.02334785f, 0.00577123f, -0.04608611f, -0.02549146f, 0.00938356f, 
    0.00848931f, -0.03928046f, 0.00005315f, -0.04440633f, -0.00799547f, -0.04177053f, -0.03025043f, -0.01769413f, 
    -0.01039951f, 0.02828626f, 0.02710383f, 0.01384688f, 0.01107406f, 0.00985643f, -0.02577833f, 0.00703621f, 
    -0.00432761f, 0.01130719f, -0.02351706f, 0.02178187f, -0.02344591f, 0.00546371f, 0.02216985f, -0.04255714f, 
    0.01819956f, -0.00007236f, 0.02189616f, -0.02456224f, -0.03477534f, 0.02415438f, 0.01770560f, -0.00204922f, 
    0.00254450f, 0.02846986f, 0.02197109f, -0.02155520f, -0.01820080f, 0.02892064f, -0.00457887f, -0.02217933f, 
    -0.00729434f, -0.00164175f, -0.02093151f, 0.02121405f, 0.03017552f, 0.03528784f, 0.00912739f, -0.02118230f, 
    -0.00878327f, -0.01630264f, -0.01565636f, 0.00217703f, -0.03411971f, -0.00236293f, 0.02105201f, -0.01809207f, 
    -0.03447045f, 0.03273500f, 0.00648200f, 0.00754737f, -0.02527368f, -0.00858140f, 0.01288784f, -0.01901734f, 
    -0.00427095f, 0.02062562f, -0.01018771f, 0.02688903f, -0.04304653f, 0.02141455f, -0.02289122f, 0.00883613f, 
    -0.00560410f, -0.00797683f, 0.00256460f, 0.03298661f, -0.00017514f, -0.00720537f, -0.00867424f, 0.00577617f, 
    0.02133094f, -0.00734348f, 0.02032251f, -0.04188911f, -0.03019406f, -0.01664006f, 0.00419909f, -0.00929909f, 
    0.01422047f, -0.02568068f, 0.01805866f, -0.00396994f, -0.02878767f, -0.00008017f, -0.03276977f, -0.01066997f, 
    -0.02113025f, -0.01939548f, -0.01353005f, -0.00814492f, 0.00425695f, 0.02505360f, 0.01803614f, -0.02791316f, 
    0.02280847f, 0.01516978f, -0.02008625f, -0.02763264f, -0.03744579f, -0.01577861f, -0.01191017f, -0.03901900f, 
    -0.03038950f, -0.01912964f, 0.01074346f, -0.00419256f, -0.01456286f, -0.02717982f, -0.02257942f, -0.01904639f, 
    0.00875897f, -0.03119106f, 0.01049760f, 0.03125294f, 0.01231537f, -0.01434902f, -0.02226419f, 0.01261122f, 
    0.01535378f, 0.01042272f, 0.00116479f, -0.02376151f, -0.02222405f, -0.02000608f, 0.00595170f, -0.03542769f, 
    -0.03473813f, -0.02004420f, -0.02964472f, -0.01200195f, -0.03115066f, 0.02724006f, 0.02206884f, -0.02716422f, 
    0.02839548f, 0.02232663f, -0.00852772f, -0.00880061f, -0.00140349f, -0.00584234f, -0.01388455f, -0.02188583f, 
    -0.02324776f, 0.01108492f, -0.01098474f, 0.02470057f, 0.03051389f, 0.02484942f, 0.02457082f, -0.01052125f, 
    0.03392938f, -0.01005712f, 0.02064124f, 0.00402643f, -0.00897264f, 0.01629966f, 0.01210226f, 0.00717008f, 
    0.02321380f, 0.02135887f, -0.00362723f, 0.03067240f, -0.00394278f, 0.00734699f, -0.02714238f, -0.03163732f, 
    0.00003812f, -0.01737885f, -0.01450018f, 0.02198458f, 0.01621241f, -0.03187189f, -0.00017278f, -0.01976640f, 
    0.00771546f, -0.00249321f, 0.01687125f, -0.03505196f, 0.02780880f, 0.02905822f, 0.00167549f, -0.00287190f, 
    -0.00865371f, -0.03335027f, 0.01620625f, -0.00840061f, -0.01010702f, 0.00841253f, -0.00372179f, 0.00296827f, 
    0.00727642f, 0.01358853f, -0.00720849f, 0.02531336f, -0.02557554f, 0.02749771f, 0.01583930f, -0.01832181f, 
    -0.00046998f, -0.01682458f, 0.00317101f, 0.02837660f, 0.00801246f, -0.00222667f, -0.03621762f, 0.00084626f, 
    0.02076374f, 0.01371107f, -0.03940826f, 0.00547631f, 0.01372330f, -0.00664585f, 0.00269883f, -0.04083437f, 
    0.01460244f, -0.02473470f, -0.00954762f, 0.00690195f, 0.02323525f, 0.00931110f, -0.01613559f, 0.02270097f, 
    0.01348572f, -0.02322733f, 0.02414047f, -0.01955764f, -0.04242172f, 0.02538103f, -0.02283622f, -0.01617748f, 
    -0.04735085f, -0.00479039f, 0.00435862f, 0.02567702f, -0.00599015f, -0.02011585f, 0.03343183f, -0.01301123f, 
    -0.01003347f, 0.01691906f, 0.00197658f, -0.02572242f, 0.01579479f, -0.00602489f, 0.00338110f, -0.02466674f, 
    -0.02406015f, -0.02269954f, 0.02076167f, -0.02416305f, -0.00497395f, -0.01019161f, 0.02830680f, -0.01470987f, 
    -0.00099154f, 0.00327167f, 0.00734611f, 0.00345984f, -0.00643029f, -0.02228355f, 0.00797756f, -0.03520037f, 
    0.02135226f, 0.03333220f, 0.01750648f, -0.02456790f, -0.03101220f, -0.02537039f, 0.02330033f, 0.02545202f, 
    0.00080396f, 0.00496552f, -0.02238766f, -0.03058458f, -0.02624312f, 0.03868302f, 0.03286445f, -0.02525007f, 
    0.02636051f, -0.02201062f, 0.01112015f, 0.02185168f, -0.00464656f, -0.01541596f, 0.01081464f, 0.01939319f, 
    -0.02213101f, -0.02938755f, 0.01221118f, -0.02928261f, -0.01756104f, 0.00030224f, -0.03369554f, 0.01611249f, 
    0.02328332f, -0.03804047f, -0.02454791f, 0.00230886f, 0.01776238f, 0.00291711f, 0.00695125f, -0.03288123f, 
    0.00003221f, -0.00587961f, -0.00813134f, -0.00092879f, -0.03876615f, 0.01648632f, 0.02619230f, -0.02672748f, 
    -0.00239680f, -0.03894380f, -0.02912749f, 0.00526081f, -0.01772464f, 0.01218085f, -0.02832110f, -0.02368162f, 
    0.00380410f, 0.01173579f, 0.02530640f, 0.00543974f, -0.01186166f, 0.02184108f, -0.03953668f, 0.01245048f, 
    0.00230296f, 0.01602448f, -0.02426005f, -0.01958402f, 0.01354453f, -0.00063145f, 0.02339025f, -0.03452978f, 
    0.02794090f, 0.01916371f, -0.01900063f, 0.01280264f, -0.02166441f, 0.01426475f, 0.02784999f, -0.03082049f, 
    0.01410949f, 0.03069873f, 0.01112142f, -0.04266112f, -0.01088237f, 0.01863922f, -0.02291663f, 0.00082055f, 
    -0.01997519f, -0.00672461f, 0.02288723f, -0.00202425f, 0.00261446f, -0.02557832f, -0.02080425f, 0.01180238f, 
    0.01680647f, -0.00646101f, 0.01264329f, -0.02510151f, 0.02621151f, -0.02480336f, -0.00828800f, 0.00657881f, 
    -0.01688323f, -0.03363214f, -0.01793035f, -0.03961586f, -0.00040272f, 0.01000821f, -0.02420944f, 0.03237166f, 
    0.01589092f, -0.00663904f, -0.01335195f, -0.03388692f, -0.00459255f, -0.03255329f, 0.02917496f, -0.01719865f, 
    0.03542253f, -0.01400885f, 0.02085958f, 0.02173951f, 0.01953945f, -0.04152635f, 0.02048122f, 0.02162778f, 
    -0.01953037f, 0.00160392f, -0.00367706f, 0.00137521f, 0.01039849f, -0.00390229f, -0.02009984f, -0.02804729f, 
    0.01579061f, -0.03271819f, -0.02824736f, 0.02244046f, 0.02120611f, -0.01154263f, 0.00880879f, 0.01096665f, 
    0.01216434f, 0.00578249f, 0.01272033f, 0.00791734f, -0.01350105f, 0.01916571f, -0.02276987f, 0.00165239f, 
    0.00741799f, 0.00505294f, 0.01979033f, -0.01309925f, -0.01804190f, -0.03191521f, -0.03659966f, 0.02998110f, 
    -0.00732282f, -0.03386110f, 0.01486146f, 0.01984471f, -0.00617411f, -0.02024261f, -0.00569754f, -0.03645784f, 
    -0.01395188f, -0.01786430f, -0.02569652f, -0.02382850f, -0.00904876f, -0.02968968f, -0.00475125f, 0.02211129f, 
    0.00238477f, -0.00395378f, 0.00478934f, 0.03096727f, -0.01058305f, -0.00379234f, -0.00892617f, 0.01880283f, 
    -0.02767653f, 0.03112625f, 0.00765236f, 0.02019500f, -0.02788392f, 0.01264120f, -0.03198447f, 0.00387821f, 
    -0.02891539f, 0.01349193f, -0.00076034f, 0.00550503f, -0.03190636f, 0.00744091f, -0.01078430f, 0.00471847f, 
    0.01599742f, -0.01763369f, -0.03874409f, -0.01632936f, -0.00089279f, -0.01201960f, 0.00744197f, 0.00081040f, 
    0.01514950f, 0.01612651f, 0.01814435f, 0.02350111f, 0.02969391f, -0.01274427f, -0.00054685f, -0.01767156f, 
    -0.01723961f, 0.01960817f, -0.01160038f, -0.03427803f, 0.01510029f, -0.01439128f, -0.03984174f, -0.00709634f, 
    0.02740005f, -0.04042059f, 0.02966658f, -0.02980028f, 0.02283212f, -0.00167531f, -0.02471339f, -0.00398216f, 
    -0.02492509f, 0.01537102f, 0.02884374f, -0.04002780f, 0.01614516f, -0.02376845f, 0.01358830f, -0.01700129f, 
    0.00242271f, -0.00490475f, -0.01630386f, 0.00546511f, -0.00591777f, 0.01761120f, 0.01024358f, -0.03548158f, 
    -0.04082375f, -0.00089834f, 0.00367533f, 0.02189265f, -0.01817196f, -0.00514979f, -0.03100835f, 0.00349109f, 
    -0.01682939f, 0.00564517f, -0.00411491f, -0.02744424f, -0.01271154f, -0.01581786f, 0.01019804f, -0.01573518f, 
    -0.03371866f, -0.02704294f, -0.03035186f, -0.01660667f, -0.00741700f, -0.03323362f, 0.02974337f, -0.01321627f, 
    -0.01821391f, 0.03535280f, 0.00436298f, 0.01203814f, 0.00214074f, -0.03257747f, 0.02980566f, 0.01515867f, 
    0.03096813f, -0.02487491f, -0.01205923f, 0.00091486f, 0.00529087f, -0.03811794f, 0.03183709f, -0.02568644f, 
    0.01030989f, -0.00210449f, -0.03811329f, -0.00427221f, -0.03089013f, 0.02634903f, -0.02876871f, 0.00239896f, 
    0.01965657f, -0.01387381f, -0.03516121f, -0.03012231f, 0.00329081f, -0.02404890f, -0.01788053f, 0.02096620f, 
    -0.01748949f, 0.01572693f, -0.02709827f, 0.00052952f, 0.03019857f, -0.03218446f, -0.02904151f, -0.01388107f, 
    -0.02390332f, 0.02094373f, 0.01705989f, 0.02647051f, 0.02067804f, 0.03492668f, -0.04626325f, -0.02550213f, 
    -0.00047953f, -0.03228912f, -0.00542548f, -0.02341400f, -0.03005283f, 0.02526732f, -0.01864869f, -0.01861789f, 
    0.02674463f, 0.02430906f, 0.01624165f, 0.01390503f, 0.02872395f, -0.01041190f, -0.03214257f, -0.04023022f, 
    0.01929708f, -0.02358386f, 0.01386425f, 0.03114384f, -0.01350166f, -0.00689185f, 0.00736242f, 0.00321006f, 
    0.00166878f, -0.01487674f, 0.02763504f, 0.01467448f, -0.03813908f, -0.01094761f, 0.03029929f, -0.01628347f, 
    0.00222713f, -0.03872829f, 0.02369290f, 0.00879489f, -0.02874311f, -0.03948621f, -0.02096540f, 0.02662458f, 
    0.00833816f, -0.02664512f, -0.03957998f, -0.03223611f, 0.04189116f, -0.02426006f, 0.02894062f, -0.00136805f, 
    -0.01230818f, 0.00708488f, 0.02812381f, 0.03099812f, 0.01833744f, -0.02430907f, 0.01002243f, -0.00062424f, 
    -0.02993180f, 0.01783136f, -0.00405052f, 0.01083689f, -0.01279257f, -0.00529485f, -0.01640978f, -0.01627919f, 
    -0.01077205f, -0.03641169f, 0.00748382f, 0.00676414f, -0.00468498f, -0.01791215f, -0.02020118f, -0.00998744f, 
    -0.01325004f, -0.00731748f, 0.03818256f, -0.01133860f, 0.00416228f, 0.01553867f, 0.01750845f, -0.00481390f, 
    0.02422538f, 0.00886755f, -0.02412356f, -0.03493837f, 0.00416937f, -0.01059616f, -0.01699544f, -0.04026521f, 
    -0.01619744f, -0.02266219f, -0.00362319f, -0.01558884f, 0.00475575f, -0.00563385f, -0.02341008f, 0.01040159f, 
    0.01816074f, 0.02987814f, 0.00993996f, -0.03337066f, 0.00272565f, -0.02094486f, -0.00324970f, -0.00265361f, 
    0.01225779f, -0.03570568f, -0.01610523f, 0.00276554f, 0.00908748f, -0.03450922f, 0.03151724f, 0.02112370f, 
    -0.00784008f, 0.01820959f, 0.00392318f, -0.01897207f, 0.01085080f, -0.01196672f, -0.00888363f, 0.01662907f, 
    -0.00573008f, -0.01038863f, -0.03461633f, -0.03965475f, -0.01020729f, -0.00963705f, 0.02459648f, 0.01165558f, 
    -0.03819019f, -0.00104196f, 0.00379969f, -0.00732115f, 0.02203504f, -0.02064813f, -0.02400081f, -0.03959234f, 
    -0.02470786f, -0.03648734f, -0.04191992f, -0.03393317f, 0.00713051f, -0.04340720f, -0.03044823f, -0.02859128f, 
    -0.03488780f, -0.03637189f, 0.02432632f, -0.03386224f, 0.01286544f, -0.03759290f, 0.01525741f, 0.00846401f, 
    -0.02577805f, -0.03923883f, -0.02789456f, 0.02044869f, 0.01312360f, 0.00664560f, -0.01677211f, -0.00526542f, 
    -0.02101064f, 0.02119195f, -0.03540130f, -0.03974789f, -0.03765945f, -0.03592823f, -0.00051239f, -0.02879246f, 
    0.00114623f, -0.02944697f, 0.01037400f, -0.01607178f, -0.04207473f, 0.00944336f, -0.04116150f, -0.02155179f, 
    0.02333705f, 0.03391875f, -0.03051122f, -0.01130205f, -0.01857187f, 0.02591240f, 0.00870904f, 0.01194150f, 
    -0.01449944f, -0.01712602f, -0.01891986f, -0.01851360f, -0.01210645f, -0.04159149f, 0.01816499f, 0.00432437f, 
    0.01600219f, 0.02689290f, 0.03606894f, 0.02409227f, -0.00800865f, -0.02882960f, 0.01375333f, -0.00708083f, 
    0.01684647f, -0.01520895f, -0.01364268f, 0.01623895f, 0.02647952f, -0.00908120f, 0.01507170f, -0.02597463f, 
    0.01125462f, -0.03188638f, -0.00131497f, -0.02939382f, -0.02518196f, -0.03274540f, -0.02433391f, 0.01850859f, 
    0.00791134f, 0.00551517f, 0.02242504f, 0.01967180f, -0.00892702f, 0.01144131f, -0.01782519f, -0.00927735f, 
    -0.03155928f, -0.03525459f, -0.03810155f, 0.02433604f, -0.01786597f, -0.03959280f, 0.02464858f, -0.03403492f, 
    -0.03674967f, 0.01942448f, -0.00070296f, 0.02648334f, -0.00908174f, -0.03940292f, -0.03312812f, 0.00974630f, 
    -0.01975273f, -0.00625767f, -0.01604746f, -0.00990617f, -0.04003455f, -0.01602902f, 0.01418324f, -0.00460459f, 
    -0.01087014f, 0.00202757f, -0.03828398f, -0.00847451f, -0.02188020f, -0.03666437f, 0.00954238f, 0.00802838f, 
    0.00958069f, 0.01151641f, -0.00052131f, 0.02386582f, 0.02392283f, 0.00523112f, -0.01937623f, -0.02467920f, 
    -0.00896568f, -0.00275371f, -0.04233733f, 0.00564791f, -0.00669896f, 0.00594832f, -0.02043550f, -0.03647053f, 
    -0.00041836f, 0.01699268f, -0.03641464f, -0.03392334f, 0.02362281f, -0.00975304f, 0.02659740f, -0.00984334f, 
    -0.03120379f, 0.02186467f, -0.03540798f, -0.02787238f, -0.01426292f, 0.00170631f, -0.01299863f, -0.01351777f, 
    0.01665522f, 0.02270439f, -0.03559764f, 0.00816571f, 0.01642461f, 0.02407482f, -0.00298440f, -0.00086289f, 
    -0.04142002f, 0.01092186f, -0.02821887f, -0.02346315f, -0.03173960f, 0.02054967f, 0.01413832f, 0.02132438f, 
    0.00349020f, -0.00037353f, 0.02062415f, 0.02046235f, 0.02465857f, -0.02986810f, 0.02770966f, 0.00967081f, 
    -0.00935884f, -0.03244667f, 0.03217659f, -0.03599180f, 0.00575372f, 0.00383781f, -0.03059410f, 0.02556352f, 
    -0.04209128f, -0.01347869f, 0.01082659f, -0.02263819f, -0.01091142f, -0.04171700f, -0.02872865f, -0.04028710f, 
    -0.00432676f, 0.02629498f, -0.02461469f, -0.02025268f, -0.03246506f, -0.03139813f, -0.00447647f, -0.00585827f, 
    0.01547229f, 0.00202779f, -0.00934161f, 0.01548117f, 0.00598533f, 0.01051088f, -0.00745067f, -0.03345072f, 
    0.00656449f, 0.00463911f, 0.00198043f, -0.00912643f, -0.00128690f, -0.00897445f, 0.00992878f, 0.02163204f, 
    0.02699357f, 0.00023517f, -0.03678884f, 0.01336512f, -0.03700998f, -0.02431067f, -0.00932402f, -0.00454381f, 
    -0.03221768f, -0.03537413f, -0.01671528f, 0.02465329f, 0.02216674f, 0.00879439f, -0.04338358f, 0.01189178f, 
    -0.00765997f, -0.02430831f, 0.01179161f, 0.00511814f, 0.00505165f, 0.01180846f, 0.00654128f, -0.03811822f, 
    -0.00278196f, -0.00391757f, 0.01021297f, -0.00586168f, 0.00282266f, 0.01476227f, -0.01965033f, -0.03788207f, 
    -0.03694079f, -0.01875942f, 0.01686156f, 0.02631212f, -0.02696026f, 0.00782737f, 0.02205458f, 0.02413817f, 
    0.00263395f, -0.02073642f, -0.02068543f, -0.00723921f, -0.01243448f, -0.04296673f, -0.03054394f, 0.01241463f, 
    -0.03868517f, 0.00185337f, 0.00190283f, -0.03738775f, 0.00944381f, -0.04096164f, -0.03515393f, -0.01715933f, 
    -0.02416708f, -0.01405229f, 0.00124783f, -0.01111079f, 0.01511545f, -0.00357541f, -0.03071084f, 0.01241305f, 
    -0.01298381f, -0.00858353f, -0.01033179f, -0.00211259f, 0.01699892f, 0.02504157f, 0.02064246f, -0.02305065f, 
    0.01551477f, -0.01391844f, -0.03049346f, -0.02835212f, -0.03498022f, -0.01954422f, 0.00898172f, -0.00591262f, 
    -0.02759735f, 0.00454154f, 0.02229826f, 0.00901893f, -0.01505996f, 0.00544654f, -0.03719488f, -0.03445015f, 
    -0.00613418f, 0.02404907f, -0.04069366f, 0.00061372f, 0.02749400f, 0.01148673f, 0.00503393f, 0.02400947f, 
    -0.00108611f, -0.04294331f, -0.02734809f, -0.02221773f, 0.01640111f, 0.01657163f, 0.00879549f, -0.04197852f, 
    -0.04213768f, -0.00019469f, -0.01972868f, 0.00243394f, -0.03387290f, -0.02240556f, 0.02292361f, -0.02239451f, 
    -0.01663953f, -0.01993020f, -0.02324561f, 0.02338671f, 0.01440007f, 0.02449229f, -0.03879922f, 0.03779849f, 
    -0.03454255f, -0.03532905f, -0.01598675f, -0.00988534f, -0.02614599f, 0.00609204f, 0.00544796f, 0.03087541f, 
    0.00536878f, 0.01350082f, 0.00573064f, -0.01432685f, 0.00766592f, -0.02053425f, 0.00755840f, -0.00671335f, 
    -0.01273936f, 0.00250695f, 0.02276355f, -0.01721666f, 0.00026653f, -0.01965755f, 0.02702023f, 0.00661706f, 
    -0.03188608f, 0.02502756f, -0.00586014f, -0.01152578f, 0.01125654f, 0.00281923f, -0.03954130f, -0.00219014f, 
    -0.02417634f, 0.00843695f, -0.03261168f, -0.04389526f, 0.00495083f, 0.00782386f, -0.00649216f, 0.01778013f, 
    -0.01360909f, 0.02164287f, 0.01911045f, 0.02045066f, -0.00636096f, -0.00591601f, 0.00409708f, 0.01444147f, 
    0.02191166f, -0.03346412f, -0.00578849f, -0.03474711f, 0.02152326f, -0.03425135f, 0.00877028f, 0.00629428f, 
    0.00942328f, -0.01925898f, -0.00260429f, 0.02588950f, -0.00802775f, -0.04109779f, -0.03778435f, -0.03771820f, 
    0.02478971f, -0.04352759f, -0.00842424f, 0.02221891f, 0.02623483f, 0.01916255f, 0.01362353f, -0.02423289f, 
    -0.01211655f, -0.01508238f, -0.01649467f, -0.00268273f, -0.02786286f, -0.00214269f, -0.01999684f, -0.01105159f, 
    0.02674482f, 0.02814291f, 0.00698927f, 0.01483518f, -0.01520000f, -0.01450000f, -0.01438537f, -0.00488442f, 
    0.02029472f, -0.02322363f, -0.00316077f, -0.04328556f, 0.00771838f, 0.01315655f, -0.03292739f, 0.01250422f, 
    -0.02591228f, -0.00825290f, -0.04436350f, -0.02883329f, 0.02553414f, 0.01852474f, 0.02483668f, -0.00376963f, 
    -0.01662865f, -0.02619186f, 0.00339436f, -0.01707022f, 0.01936459f, 0.01802553f, -0.02002048f, -0.03486644f, 
    -0.02584415f, 0.01741964f, 0.01323976f, -0.00805598f, 0.00639478f, 0.01938836f, -0.00951056f, 0.00958295f, 
    -0.03272694f, -0.00308440f, -0.03442272f, -0.01940417f, -0.01403424f, 0.02751604f, 0.00829139f, -0.02229652f, 
    0.00812063f, 0.02562187f, -0.04303740f, 0.01354922f, -0.03979626f, 0.02598280f, 0.00073852f, -0.00449713f, 
    -0.01341296f, -0.01643326f, -0.01585709f, -0.01022527f, 0.01146106f, -0.00134240f, -0.00435611f, 0.02283254f, 
    0.00713930f, -0.03634709f, 0.01319510f, -0.02086755f, 0.01387614f, -0.03612000f, -0.01703184f, -0.02400584f, 
    -0.01124912f, 0.01207782f, -0.02808236f, 0.00252081f, -0.00115122f, -0.00671514f, 0.01760950f, -0.03747629f, 
    -0.00588967f, -0.01387324f, 0.00091961f, 0.00482991f, 0.00849334f, -0.00246718f, 0.00352919f, 0.01505341f, 
    0.02900518f, -0.03025866f, -0.01655899f, 0.00495351f, -0.02321172f, -0.00192256f, -0.00330352f, -0.03073542f, 
    -0.01915121f, -0.00457622f, -0.01274834f, 0.02613876f, -0.02733027f, -0.03910866f, -0.00580074f, -0.03491157f, 
    -0.00734596f, 0.00426589f, -0.02301028f, -0.01463819f, -0.01841612f, -0.01737858f, 0.02273792f, 0.02572860f, 
    0.02254175f, 0.01370388f, 0.01837043f, 0.00088794f, -0.03040641f, 0.00146064f, -0.00102190f, -0.03825259f, 
    -0.02337448f, -0.01078180f, 0.00945465f, 0.01360642f, 0.04023794f, -0.04174700f, 0.01175137f, 0.00345365f, 
    -0.01367741f, -0.02025421f, 0.01117786f, -0.03103612f, -0.01763070f, 0.02676353f, -0.02908324f, 0.01041507f, 
    0.01822886f, 0.02466379f, -0.02231336f, -0.02332469f, -0.02946470f, -0.03776481f, -0.01577677f, 0.02029731f, 
    -0.03949637f, 0.02467759f, -0.03021876f, -0.01271484f, 0.00283196f, 0.01335032f, -0.03627263f, 0.01777940f, 
    -0.03882069f, 0.02191271f, -0.01343810f, -0.03101981f, 0.01211835f, 0.01296068f, -0.01552393f, 0.02345626f, 
    -0.02919829f, -0.01233134f, 0.02638813f, -0.02549566f, 0.02600385f, -0.03811740f, -0.02676904f, 0.02389655f, 
    0.00162222f, 0.00432638f, -0.00412626f, 0.00190573f, 0.02088690f, -0.02179710f, 0.01986349f, -0.03446328f, 
    0.00295950f, -0.02634459f, -0.00199108f, 0.00555084f, 0.00068809f, -0.03381062f, -0.02615122f, -0.03068536f, 
    0.00019917f, -0.02677701f, -0.00408997f, -0.02562419f, -0.01936946f, -0.00838889f, 0.00138474f, 0.02660957f, 
    -0.00886587f, -0.03449208f, -0.03109572f, -0.01802675f, -0.03253763f, -0.03482598f, -0.02897600f, 0.00964505f, 
    -0.04405207f, -0.00912280f, 0.02781530f, 0.01124925f, 0.01583614f, -0.00766590f, 0.01233527f, 0.00542514f, 
    0.00222486f, 0.02254425f, 0.00836359f, -0.03155163f, 0.02469515f, 0.00923642f, -0.04298532f, 0.02159097f, 
    0.01006481f, 0.00196958f, 0.02643179f, 0.02597507f, -0.02925372f, -0.03069837f, -0.00784538f, 0.02645539f, 
    -0.00447549f, 0.02575815f, 0.02473495f, -0.02121626f, 0.02441052f, 0.01575493f, -0.00247047f, -0.02750021f, 
    0.01950163f, 0.01489236f, -0.02481976f, 0.01731229f, -0.03504939f, -0.01782339f, 0.02282978f, -0.00122933f, 
    -0.03585807f, -0.01788372f, 0.02515173f, 0.02578985f, 0.02109223f, 0.01242050f, -0.01553029f, -0.01390544f, 
    -0.00039557f, -0.04112412f, -0.01124311f, 0.00139616f, -0.02717762f, -0.03306372f, 0.01329252f, -0.03651410f, 
    -0.04031812f, 0.01254870f, -0.02018537f, 0.00364391f, -0.02377769f, -0.02334224f, -0.02168732f, -0.03774137f, 
    -0.03179046f, -0.02321367f, -0.01690698f, 0.01202799f, -0.04242350f, -0.01754523f, 0.02399069f, 0.02731449f, 
    -0.02002446f, -0.00646278f, -0.03425590f, -0.02490181f, -0.00426221f, 0.00955286f, -0.03676619f, 0.01749221f, 
    -0.02512736f, -0.03662059f, -0.04297534f, -0.00826509f, -0.00623282f, -0.02257772f, 0.02816153f, -0.00522097f, 
    -0.03819023f, 0.01403578f, -0.00915867f, 0.03047960f, -0.01858797f, 0.01196104f, 0.01630868f, 0.01112724f, 
    0.00757394f, 0.01697812f, -0.02621598f, -0.03705118f, -0.04356759f, -0.00220273f, 0.00267563f, -0.02968193f, 
    -0.01556314f, -0.02588295f, 0.02269278f, 0.01949063f, -0.01759564f, -0.03156253f, 0.01228926f, -0.03946193f, 
    -0.00032904f, -0.02898899f, -0.01415685f, -0.04044895f, 0.02875424f, 0.00633209f, 0.00621698f, -0.03652659f, 
    -0.03835068f, 0.02712594f, -0.02987030f, -0.00540597f, -0.02454424f, 0.00599804f, -0.03271020f, -0.03465028f, 
    -0.01692762f, -0.01243926f, -0.03912564f, 0.00246255f, 0.00701818f, 0.02672112f, -0.04059847f, 0.01018164f, 
    0.01319553f, -0.02805324f, -0.04267611f, -0.03319233f, -0.01714976f, 0.02192209f, 0.02278892f, 0.00008581f, 
    -0.02394465f, 0.02090869f, 0.01783258f, 0.02128082f, -0.02806100f, 0.00248841f, -0.00157179f, -0.03888032f, 
    -0.01938000f, 0.02019602f, 0.00937424f, -0.00169583f, 0.01570052f, 0.01459435f, -0.04107665f, -0.02904303f, 
    -0.03030367f, 0.00657562f, -0.01800840f, -0.03593490f, 0.03656910f, -0.02652496f, 0.02165978f, 0.03063634f, 
    0.00568570f, 0.02549744f, -0.03326214f, -0.01515056f, 0.02241958f, 0.02896090f, 0.02408823f, -0.02307995f, 
    -0.01224280f, -0.01525317f, 0.00000761f, -0.01147105f, 0.00272891f, -0.00020082f, 0.02749830f, 0.00982275f, 
    -0.02390635f, -0.01744434f, 0.02245067f, -0.01656782f, 0.00047511f, 0.00118485f, -0.02560300f, -0.00497575f, 
    0.00019429f, -0.03169825f, 0.03147098f, 0.02647604f, -0.00977187f, 0.01074934f, 0.02343270f, 0.00565165f, 
    -0.01645963f, 0.00073548f, -0.02990011f, -0.02245754f, 0.02591133f, 0.00311480f, 0.00775866f, 0.00455200f, 
    0.01661520f, -0.02226167f, -0.00473036f, 0.02862114f, -0.00053803f, 0.03567265f, 0.01730108f, 0.00102162f, 
    -0.00124459f, -0.00636852f, 0.01882976f, 0.01569712f, -0.00352708f, -0.02936844f, -0.01537373f, 0.00122848f, 
    0.01215323f, 0.00826275f, 0.01683970f, -0.01498883f, 0.01826522f, -0.02397747f, -0.02143656f, -0.00823985f, 
    0.02118533f, -0.01950118f, -0.03672534f, 0.01540891f, 0.03117299f, 0.01928389f, 0.01093161f, -0.03556412f, 
    -0.01759552f, -0.01496346f, -0.01893862f, -0.03748218f, -0.03039233f, -0.01583062f, -0.01728863f, 0.00661567f, 
    -0.00939648f, 0.01854979f, -0.00239973f, -0.00739188f, -0.02109258f, -0.02035372f, 0.00632222f, -0.02125733f, 
    0.02114936f, -0.02799623f, -0.01932068f, -0.02243729f, 0.00574445f, -0.01517157f, -0.02707101f, 0.01316449f, 
    0.01918669f, -0.02560120f, -0.01750095f, 0.00380920f, -0.03042979f, 0.00035169f, 0.00785926f, -0.03674568f, 
    0.01632547f, 0.02835059f, 0.02499362f, 0.03278710f, -0.02856306f, -0.02394792f, -0.02639369f, -0.03055936f, 
    -0.02810933f, -0.01336105f, -0.01329140f, 0.00064329f, 0.00392213f, -0.02917219f, 0.02288105f, -0.00391026f, 
    -0.01165114f, -0.02195329f, -0.00286548f, 0.02903587f, -0.01731520f, 0.00697513f, 0.01243967f, -0.03456379f, 
    -0.01879408f, -0.02758436f, -0.01529075f, -0.03824059f, 0.00544155f, -0.00698018f, -0.00060969f, 0.00453856f, 
    0.01342629f, 0.00165633f, 0.00342133f, -0.03383945f, 0.00069454f, -0.00672255f, 0.00654620f, -0.01988148f, 
    0.02355487f, 0.00586665f, -0.04244146f, -0.00878659f, 0.02191150f, -0.01306884f, -0.01205840f, -0.01700120f, 
    0.02045583f, 0.00694869f, -0.00738974f, 0.00317816f, -0.02135867f, -0.02625494f, 0.02855628f, 0.03047489f, 
    0.02210871f, 0.00908827f, -0.01839392f, 0.02016152f, -0.03016263f, -0.02660133f, -0.04038914f, -0.01753782f, 
    0.01621937f, 0.01942743f, -0.04303029f, -0.00989205f, 0.01581079f, -0.03006537f, 0.01974522f, -0.02488227f, 
    -0.02758963f, 0.01366339f, 0.01427729f, 0.00560550f, -0.00036632f, -0.00084920f, 0.01821746f, -0.01261091f, 
    -0.02617839f, -0.03456410f, -0.00004935f, -0.03189987f, 0.01460498f, -0.02431943f, -0.03137859f, -0.00856203f, 
    0.02105468f, 0.01107833f, -0.01850403f, -0.03496042f, -0.00486763f, 0.00052011f, 0.01604149f, 0.02198725f, 
    -0.01595133f, 0.01989037f, 0.00704310f, -0.03824541f, -0.01090220f, -0.02005698f, -0.00216458f, 0.01138075f, 
    0.00435598f, 0.00661765f, 0.01623333f, -0.03362900f, 0.03325872f, 0.02150189f, 0.02120507f, 0.01256701f, 
    -0.00416618f, -0.03364765f, -0.02546071f, -0.01911707f, 0.00027391f, -0.01236220f, -0.01495146f, -0.01401306f, 
    -0.01570912f, 0.02899856f, -0.02239528f, 0.00256490f, -0.00328013f, -0.01625704f, 0.02821933f, 0.01113382f, 
    -0.01669795f, -0.00845668f, 0.01136978f, -0.03524835f, -0.04084436f, -0.02193251f, 0.00543160f, -0.01178963f, 
    -0.01038508f, 0.01272439f, -0.00525126f, -0.02765654f, 0.02674344f, -0.01237720f, 0.01260151f, -0.02860751f, 
    -0.03748054f, 0.02298776f, -0.04187259f, -0.01547713f, -0.00126403f, 0.02406683f, 0.01153571f, 0.02714978f, 
    0.03011870f, -0.01426190f, -0.03028385f, -0.01609519f, 0.01124780f, -0.00622223f, -0.00643783f, 0.01791209f, 
    -0.03333647f, -0.02298654f, -0.00097892f, 0.00594156f, 0.02595673f, -0.02427456f, -0.00381548f, 0.03555918f, 
    0.01083178f, 0.00589186f, -0.01924827f, -0.00735918f, -0.01707540f, -0.00265844f, -0.00345715f, 0.00931294f, 
    0.01102996f, -0.01313229f, 0.02408947f, 0.01851300f, 0.01830516f, 0.03107103f, -0.00990431f, -0.00603725f, 
    -0.01772343f, -0.03976063f, 0.00580182f, -0.02994735f, 0.00109094f, -0.01888402f, 0.01071631f, 0.01374430f, 
    -0.00821961f, 0.02415782f, -0.01372001f, 0.02655157f, -0.02754248f, 0.02863974f, -0.02385935f, 0.02546093f, 
    -0.00901442f, -0.00603136f, -0.02776049f, 0.00989815f, 0.02153374f, 0.01381340f, 0.01273678f, -0.03294095f, 
    -0.01994061f, -0.03909701f, -0.03965130f, -0.04210220f, -0.01599844f, -0.02491141f, -0.02701186f, -0.00907828f, 
    -0.00684774f, -0.01821456f, -0.00668497f, -0.00608879f, 0.01547189f, -0.02441601f, 0.03060507f, -0.01125538f, 
    -0.03451470f, -0.03459238f, 0.01314455f, 0.01256555f, -0.03985958f, -0.00124400f, -0.00225147f, -0.00500180f, 
    -0.03156123f, -0.02101158f, -0.02894819f, -0.00365045f, 0.02440921f, 0.00017092f, -0.00629886f, 0.01109219f, 
    0.00262784f, -0.02688013f, 0.02206177f, 0.00374810f, -0.01237982f, -0.01422119f, 0.03125602f, 0.03267151f, 
    -0.01477623f, -0.01523442f, -0.04024824f, -0.02003713f, -0.01361142f, -0.01883954f, -0.00364867f, -0.03468493f, 
    -0.02611461f, 0.01028629f, -0.01175458f, -0.02595566f, 0.00598665f, 0.02637895f, -0.02956695f, -0.00174318f, 
    0.01691567f, -0.03806014f, 0.02586200f, -0.02137474f, -0.01931184f, 0.01335650f, 0.01098973f, -0.01193017f, 
    0.01092031f, 0.02458507f, -0.03185067f, -0.00026055f, 0.02730090f, -0.03519976f, -0.03027379f, 0.02881968f, 
    0.00348346f, -0.02685664f, 0.01513672f, 0.01414449f, 0.01853363f, -0.03213426f, 0.03200313f, -0.03488676f, 
    0.00070196f, 0.01270614f, -0.02676534f, -0.01513349f, -0.01575681f, 0.02894071f, -0.01456569f, 0.01639977f, 
    -0.01533725f, -0.03078526f, 0.01855575f, -0.03293045f, 0.00193321f, 0.01262790f, -0.00619100f, -0.00654665f, 
    0.01144909f, -0.01643575f, 0.03111349f, -0.00114200f, -0.01437111f, 0.01479255f, 0.01476759f, -0.02319880f, 
    0.01771674f, -0.03030711f, 0.01965933f, 0.03598122f, -0.01355901f, -0.04008019f, 0.00316286f, 0.03405049f, 
    -0.03153073f, 0.02787267f, -0.02974800f, 0.02459565f, 0.02435662f, 0.02108050f, -0.00662958f, 0.00246016f, 
    0.00343268f, 0.01835890f, -0.01176923f, -0.03779319f, 0.03048478f, -0.02751343f, -0.02807250f, 0.00237271f, 
    0.01712748f, 0.02372500f, 0.00002662f, 0.00507976f, -0.03584582f, 0.01023460f, -0.03115711f, -0.00327334f, 
    0.02388375f, -0.01541029f, -0.03730404f, -0.02715978f, -0.03186708f, -0.00647737f, -0.02159118f, -0.00369075f, 
    -0.03083321f, 0.02307724f, -0.00326031f, -0.01406755f, -0.02338029f, 0.00650540f, -0.00984264f, -0.00178105f, 
    0.04225931f, -0.01302085f, -0.02332756f, -0.03211951f, -0.03330220f, -0.01335445f, 0.01242611f, -0.02918109f, 
    -0.00620845f, -0.01914334f, 0.02883060f, 0.01093059f, -0.02884202f, -0.02054756f, 0.00932235f, -0.00504592f, 
    0.02011190f, 0.01723108f, -0.02832274f, -0.03095278f, 0.02482897f, -0.01776268f, 0.03530456f, 0.00291569f, 
    -0.01784229f, -0.01883607f, -0.03632753f, -0.03029626f, -0.04165235f, -0.03503140f, -0.00638191f, 0.00801497f, 
    0.01859777f, 0.02313332f, -0.01765843f, -0.03956128f, -0.01328336f, 0.01778018f, 0.03368757f, -0.03889898f, 
    -0.00813005f, -0.03586120f, -0.00731346f, 0.03263921f, -0.02895176f, -0.03775534f, -0.03986324f, -0.02518402f, 
    -0.03302317f, -0.02813822f, 0.02516767f, 0.01485082f, 0.01551489f, 0.01320389f, 0.00421079f, -0.03215250f, 
    0.00154037f, -0.01660998f, -0.02184594f, 0.01989013f, -0.02460442f, -0.01163109f, 0.01123926f, -0.02807448f, 
    -0.02921477f, 0.03727524f, -0.02189125f, -0.02979901f, 0.03362092f, 0.01393844f, 0.00033207f, -0.02330593f, 
    0.01969557f, -0.00246527f, -0.00140268f, 0.03739448f, -0.00455322f, 0.02946729f, -0.00949024f, 0.00863891f, 
    -0.01265488f, -0.00859772f, 0.00754581f, -0.01584277f, -0.02445413f, 0.02053454f, -0.02692210f, -0.00311323f, 
    -0.01798550f, 0.00650832f, -0.03598652f, -0.02514764f, 0.02187084f, -0.00388235f, -0.00219764f, 0.00907741f, 
    0.03445764f, 0.02500405f, 0.00270368f, -0.01394000f, 0.02704580f, 0.01599061f, -0.01511364f, 0.02722210f, 
    0.01481020f, 0.02145328f, 0.02582606f, 0.03469438f, 0.01306926f, 0.01119117f, -0.02061387f, -0.01539826f, 
    -0.01013945f, 0.01823969f, -0.01046526f, 0.03049987f, 0.02949534f, 0.00659246f, -0.00844012f, 0.00945470f, 
    -0.00171912f, -0.01575677f, 0.00085287f, -0.01929693f, -0.02583806f, -0.04080298f, -0.01460993f, -0.01879355f, 
    -0.01632108f, -0.04095135f, 0.02614949f, 0.02259460f, -0.01146436f, 0.02120895f, -0.01625697f, 0.03101426f, 
    -0.03531571f, -0.02598478f, 0.02480617f, -0.00007368f, -0.01912614f, -0.03071136f, 0.00166148f, 0.03057258f, 
    0.03050295f, -0.00408665f, 0.01061895f, -0.03412868f, 0.00328133f, -0.00302656f, -0.03558809f, -0.03260009f, 
    -0.03828335f, 0.02429218f, -0.02657892f, 0.02809709f, 0.03303121f, -0.01447173f, 0.02829931f, -0.02234164f, 
    0.01583325f, 0.00503574f, -0.02066280f, 0.00405805f, -0.03570339f, 0.00651075f, -0.02580571f, 0.03235437f, 
    0.02893833f, -0.00545904f, -0.03562635f, -0.01911586f, 0.03748151f, -0.02858116f, -0.00170879f, 0.03807413f, 
    -0.01609771f, -0.01741474f, -0.02160752f, 0.03402564f, 0.02329293f, -0.01179239f, 0.00027233f, 0.00070436f, 
    -0.03627270f, -0.00320748f, -0.00576730f, 0.02896892f, 0.00622248f, -0.02396642f, -0.03371126f, 0.03510533f, 
    0.00795990f, 0.02801749f, -0.01551365f, 0.02769127f, 0.01124646f, -0.01331675f, -0.02015228f, -0.00527795f, 
    0.02373093f, -0.02931907f, 0.00326927f, -0.00196603f, -0.02705137f, 0.02342309f, 0.00391178f, 0.03088615f, 
    0.02457791f, 0.01836288f, -0.01397393f, 0.02115971f, 0.00183546f, 0.01529440f, -0.03919927f, 0.00312080f, 
    0.02625561f, -0.01834630f, -0.00205629f, -0.00443760f, -0.01516946f, -0.04272915f, 0.00027848f, -0.01297367f, 
    0.00755332f, -0.02470673f, -0.03237755f, -0.00241987f, -0.01218767f, -0.03543210f, -0.02147548f, 0.01165482f, 
    -0.02162766f, -0.02678382f, -0.03450379f, 0.01213980f, -0.01366184f, 0.02328235f, 0.00178072f, -0.02162055f, 
    0.02955181f, 0.01695557f, -0.02233009f, -0.01529371f, 0.02805754f, -0.01055661f, -0.03722394f, -0.02240868f, 
    -0.04568144f, -0.01716616f, 0.00610985f, -0.01200334f, 0.02735209f, -0.02742769f, -0.03537549f, -0.02857680f, 
    0.01209431f, 0.01480698f, 0.01974904f, 0.01317228f, 0.00069726f, 0.00813064f, -0.00569450f, -0.03160496f, 
    0.01377927f, -0.03052487f, -0.01129630f, 0.00815720f, -0.01985081f, -0.00895975f, -0.04082355f, -0.02248913f, 
    0.01349566f, -0.02349769f, -0.02775611f, -0.00368716f, 0.00282324f, -0.02583202f, -0.01449999f, -0.01436166f, 
    0.03090906f, 0.02340710f, 0.00494140f, -0.00871150f, 0.02026146f, -0.01437589f, -0.00539685f, 0.02005211f, 
    0.03907175f, -0.01473660f, -0.12603004f, -0.09535236f, 0.04283606f, 0.12075333f, 0.02887395f, -0.06449928f, 
    0.05606459f, 0.00181643f, -0.22937754f, 0.04639888f, 0.16011913f, 0.25723937f, 0.20014383f, -0.02512576f, 
    -0.19531903f, 0.27119339f, -0.04937500f, 0.14916654f, -0.04627529f, -0.01178055f, -0.03134928f, -0.05436226f, 
    -0.19897549f, -0.13697234f, 0.08202156f, 0.33059236f, -0.10888663f, 0.01548883f, -0.05902939f, -0.04188666f, 
    -0.19008511f, -0.03004796f, -0.01485093f, 0.00910213f, -0.27987286f, 0.25803328f, 0.17360461f, -0.08907516f, 
    -0.17022356f, 0.02274457f, 0.03626645f, 0.06069741f, -0.06632408f, 0.02815463f, -0.07549620f, 0.10479093f, 
    0.12001646f, 0.12471738f, 0.06715536f, 0.09536950f, 0.00533700f, 0.18324168f, 0.09008827f, 0.03013437f, 
    0.01417041f, -0.10937454f, -0.02334844f, 0.05060684f, 0.15393160f, 0.12519768f, -0.06417478f, 0.13304669f, 
    0.13555355f, 0.10338113f, 0.05785418f, 0.10395974f, -0.05186341f, 0.03900650f, 0.01006583f, -0.01691708f, 
    0.25174305f, -0.08465941f, -0.04823418f, 0.03522817f, 0.15158722f, -0.01917308f, 0.14299932f, 0.03758845f, 
    0.21514496f, -0.05186482f, 0.01657548f, -0.02654354f, 0.04946604f, -0.18152513f, -0.10092718f, 0.22674103f, 
    0.04541965f, -0.05378130f, 0.04697581f, -0.12895682f, 0.07108964f, 0.07855447f, 0.02326627f, -0.08468628f, 
    -0.36554885f, -0.11734975f, -0.06363221f, -0.12253999f, 0.20057036f, 0.04295323f, 0.06683721f, -0.06418064f, 
    0.10757992f, 0.01821932f, 0.04346120f, 0.11107228f, 0.09639315f, 0.06017166f, -0.01197714f, 0.01109570f, 
    0.07694653f, -0.01031029f, 0.07555519f, -0.03943121f, 0.05320263f, -0.01080845f, 0.02400343f, 0.14144276f, 
    0.16202508f, 0.02111099f, -0.09516309f, 0.20982949f, 0.15625399f, 0.17165323f, 0.01146533f, 0.02228396f, 
    0.04890225f, 0.05532473f, 0.22731799f, -0.08836368f, -0.10187855f, -0.11945838f, -0.09698811f, -0.06024174f, 
    0.04034199f, -0.00053257f, 0.00574286f, 0.12567808f, 0.01414238f, 0.03984128f, 0.00928840f, 0.11066236f, 
    -0.50163972f, 0.19166194f, -0.04378748f, -0.03196112f, 0.00909514f, 0.19029507f, 0.07450187f, -0.10490531f, 
    -0.05915328f, 0.11954688f, 0.03635136f, -0.05364519f, -0.03692653f, 0.09966289f, -0.19607568f, -0.02068943f, 
    -0.06623361f, 0.00028967f, -0.05757969f, -0.10599998f, 0.02828639f, -0.11820240f, 0.12740710f, 0.02520406f, 
    -0.01172625f, -0.09294195f, 0.20275983f, 0.16043998f, 0.02200678f, 0.01929812f, 0.01801090f, 0.06027756f, 
    -0.04704518f, 0.03656251f, -0.03425568f, 0.05385922f, 0.42937255f, -0.12125512f, 0.17265990f, 0.22003551f, 
    0.11191612f, 0.01246303f, -0.04209644f, -0.15552497f, 0.03471146f, 0.00840924f, 0.03573365f, -0.14446637f, 
    -0.06207062f, 0.25698555f, 0.16947328f, -0.11847308f, -0.09579273f, 0.06177995f, -0.03202099f, 0.02842939f, 
    -0.02872605f, -0.12046833f, 0.09238715f, -0.01479403f, 0.13192335f, 0.07557345f, -0.09601264f, 0.26504990f, 
    -0.02886993f, 0.00587847f, -0.05961862f, -0.04912477f, -0.15392824f, -0.18974286f, -0.02594837f, 0.07690680f, 
    -0.13250960f, 0.09629869f, 0.07035572f, 0.20227757f, -0.06828461f, 0.03133554f, 0.00436622f, -0.02650714f, 
    0.00372016f, 0.11232913f, 0.10957035f, -0.03269248f, -0.06849913f, 0.01952952f, 0.18232580f, 0.25343305f, 
    0.10497568f, 0.01197437f, 0.08850742f, 0.19464090f, 0.11878387f, 0.21489908f, 0.03462734f, -0.00123596f, 
    0.23573706f, -0.04085572f, 0.13003236f, 0.11963791f, 0.13328673f, 0.01221455f, 0.07454488f, 0.04181968f, 
    0.01597652f, 0.04321911f, -0.04110598f, 0.25114474f, 0.04513296f, 0.04074915f, 0.04754819f, -0.03540072f, 
    -0.02789528f, -0.11868732f, 0.03315417f, -0.07606706f, -0.11749966f, 0.01870805f, -0.14558493f, 0.07078522f, 
    -0.21379337f, 0.14018635f, -0.02696999f, -0.15447561f, -0.05962006f, -0.05808998f, 0.05063067f, -0.09050758f, 
    -0.12937155f, 0.02860707f, -0.14644665f, -0.00772110f, -0.00431840f, 0.06998213f, 0.15753743f, -0.06286126f, 
    0.04396679f, 0.05813108f, -0.00901258f, -0.09772488f, -0.03406467f, 0.15435065f, -0.00854504f, 0.14148901f, 
    -0.13041484f, 0.04120106f, 0.18417540f, 0.07217149f, 0.08215384f, 0.08640139f, -0.03028069f, -0.08740842f, 
    0.01150271f, -0.02780982f, -0.08863655f, -0.09974716f, -0.02482571f, 0.41277838f, 0.20647717f, 0.00942844f, 
    0.02615453f, 0.11481769f, 0.08748418f, 0.01620437f, -0.06063849f, 0.05066586f, -0.03137481f, 0.04094485f, 
    -0.21471903f, 0.15003608f, 0.25942704f, 0.33165869f, 0.14197883f, 0.03202887f, 0.08925217f, -0.08311562f, 
    0.00068775f, -0.02852325f, -0.07408077f, 0.00650420f, -0.46338093f, 0.15430400f, -0.05979218f, -0.05285966f, 
    0.11853228f, 0.11835965f, -0.09970248f, -0.05744399f, 0.06343531f, 0.00992176f, -0.00185062f, -0.04530244f, 
    -0.14017692f, 0.23653148f, 0.06496157f, -0.01075658f, -0.06437911f, 0.00700255f, 0.09329554f, 0.06058606f, 
    0.02231126f, 0.05572911f, -0.06186483f, 0.01447877f, -0.34049585f, 0.42258641f, -0.03170904f, -0.06474874f, 
    -0.00876866f, -0.01353483f, 0.09041750f, 0.08930104f, 0.17694804f, 0.16751985f, -0.03668253f, 0.04818454f, 
    0.25251076f, -0.12668838f, 0.11871702f, 0.17932945f, 0.02936881f, 0.04448895f, -0.01836914f, 0.00033984f, 
    0.09425782f, -0.06114344f, 0.09524973f, 0.08407169f, 0.20215417f, 0.15554304f, 0.22190444f, -0.09404602f, 
    -0.08256796f, 0.10372268f, 0.14980645f, 0.00027827f, 0.04580009f, -0.01264820f, 0.06235190f, 0.07366417f, 
    -0.02023304f, 0.12514250f, 0.07966147f, 0.16136158f, 0.11904845f, 0.08477208f, 0.07652599f, 0.01041101f, 
    0.03759987f, -0.00226107f, 0.00139630f, 0.06441598f, 0.16072471f, 0.38207978f, -0.11995709f, -0.17279646f, 
    -0.02208999f, 0.01203847f, 0.05482474f, 0.00868746f, -0.03485571f, -0.06744467f, -0.04739610f, -0.00480662f, 
    -0.16285247f, 0.42453161f, 0.20173743f, 0.00480599f, -0.03993607f, -0.07532325f, 0.18927364f, -0.02373213f, 
    0.03061810f, 0.07050215f, -0.13804306f, 0.02440137f, -0.20372139f, 0.08844791f, -0.07793611f, 0.06848685f, 
    0.05659911f, -0.00763776f, 0.08838164f, -0.04706550f, 0.10715080f, 0.09681091f, -0.07873225f, -0.01301163f, 
    0.04082926f, 0.24779734f, 0.05626162f, 0.13931039f, -0.11619752f, 0.03570058f, 0.03949786f, -0.13479117f, 
    -0.09505956f, -0.18128677f, -0.00012152f, 0.04290923f, 0.38031405f, 0.05052239f, 0.20233303f, 0.02758981f, 
    0.07695312f, 0.21242163f, 0.07793113f, -0.18242677f, -0.11451173f, 0.24327664f, 0.05373887f, -0.00184789f, 
    -0.01543690f, -0.04179379f, 0.22931232f, 0.07282512f, -0.11771736f, -0.16319899f, 0.12719683f, 0.02448713f, 
    0.03408499f, -0.00546965f, -0.18695277f, -0.00241639f, 0.05937443f, -0.01162357f, -0.01056170f, 0.06590130f, 
    0.12072470f, -0.02671959f, 0.20512515f, 0.01126959f, 0.15217073f, -0.09788901f, -0.02673862f, 0.08792979f, 
    0.04318966f, 0.03322490f, -0.02187883f, 0.29234233f, 0.10396424f, 0.07737783f, 0.02292421f, 0.06131759f, 
    -0.06599864f, 0.06175097f, -0.06869922f, -0.11157843f, 0.40508825f, -0.07705870f, 0.05092109f, 0.10351147f, 
    0.08939766f, 0.11622706f, -0.10147994f, -0.02352381f, -0.02748681f, 0.03832936f, -0.02101063f, 0.13820021f, 
    -0.08857156f, 0.25896898f, 0.00598882f, -0.01402119f, -0.01557217f, -0.08142505f, -0.02627125f, 0.02719292f, 
    -0.15395135f, -0.05778420f, -0.04799593f, -0.02827215f, -0.50054055f, 0.05099720f, 0.10465427f, -0.24253204f, 
    0.13537520f, 0.04230371f, -0.10197334f, -0.01050238f, -0.02810056f, 0.06631435f, -0.00876694f, -0.11449339f, 
    -0.00418820f, -0.02321191f, 0.16198243f, 0.02641114f, -0.14712426f, -0.03442164f, -0.06496449f, -0.09630270f, 
    -0.14662157f, -0.05111636f, -0.00799581f, -0.01645553f, -0.24556312f, 0.29078224f, -0.08232160f, -0.10228944f, 
    -0.10835607f, 0.03055448f, -0.00189312f, 0.08086014f, -0.05771981f, 0.04887327f, -0.05737000f, -0.04556331f, 
    0.28704920f, 0.00206138f, -0.00460378f, 0.13846970f, 0.13099141f, 0.10981919f, -0.00289189f, 0.01474799f, 
    -0.03825027f, -0.00683351f, 0.13302921f, -0.11575715f, -0.00863002f, -0.07213846f, 0.20848502f, 0.06524231f, 
    0.28964350f, 0.03128105f, 0.02534121f, -0.06370263f, 0.01624069f, -0.04907978f, -0.06512939f, 0.14668293f, 
    0.10304175f, -0.04063194f, 0.26759708f, 0.38653284f, 0.17790622f, -0.08320583f, 0.16810101f, 0.04344225f, 
    0.11694480f, 0.08217720f, -0.04016374f, 0.05450809f, -0.23961625f, -0.02729642f, 0.04390049f, -0.01426333f, 
    0.08998138f, 0.17073816f, 0.10243738f, 0.10843639f, 0.08755374f, 0.07517070f, -0.06877481f, -0.03135160f, 
    -0.15786085f, -0.03113781f, -0.14188419f, -0.09574916f, 0.03758775f, 0.01650148f, -0.08120983f, 0.04027755f, 
    -0.01300998f, 0.10393760f, 0.05044956f, -0.13022275f, -0.06164993f, 0.20154504f, 0.20333983f, -0.14134775f, 
    -0.10934755f, -0.02411281f, 0.01906987f, 0.00707325f, 0.07906672f, -0.05093973f, 0.01880402f, -0.09642159f, 
    0.02477050f, -0.09934416f, 0.12935102f, 0.05530368f, -0.09861825f, -0.04309719f, 0.07408439f, 0.02511462f, 
    -0.07698782f, -0.00505979f, -0.15783711f, 0.03920029f, -0.16552715f, 0.05127769f, 0.16602057f, 0.08823159f, 
    0.06804549f, 0.09629223f, 0.10040192f, 0.02018173f, -0.01551685f, 0.08026928f, -0.13141374f, 0.20597288f, 
    -0.48268557f, 0.06405453f, 0.05012970f, -0.15345834f, 0.10648412f, 0.03173514f, -0.06939398f, 0.03533959f, 
    -0.02398383f, 0.04033214f, 0.08117475f, 0.11018936f, -0.15044338f, 0.20472540f, 0.13843518f, -0.08994075f, 
    -0.09451766f, -0.01983469f, -0.09914010f, -0.12150357f, -0.07512399f, -0.15641268f, 0.11068742f, -0.08562683f, 
    0.05280110f, 0.43498766f, -0.04023210f, -0.03328374f, -0.13882110f, -0.09390842f, 0.14463618f, 0.01333605f, 
    -0.08727287f, -0.00848221f, -0.02659562f, 0.04272648f, 0.04810351f, -0.03891822f, -0.00257967f, 0.06162419f, 
    -0.05441066f, 0.07925470f, 0.05394154f, 0.09802418f, -0.00363907f, 0.09870055f, 0.00511100f, -0.06063337f, 
    -0.10784614f, 0.04203175f, 0.18757074f, 0.14479043f, -0.23074822f, -0.07037662f, -0.09186073f, -0.03876953f, 
    -0.00679657f, -0.03154683f, -0.08753755f, 0.03726146f, -0.00251690f, 0.20385921f, -0.21560809f, 0.13759287f, 
    0.04509588f, -0.00517960f, 0.16700202f, -0.22031048f, 0.01717302f, -0.01890084f, -0.10330124f, -0.00497291f, 
    -0.00824890f, 0.06025921f, 0.21872357f, -0.08266482f, 0.01005555f, 0.00098408f, -0.01193603f, 0.02360332f, 
    -0.03017751f, 0.03350135f, -0.02863623f, 0.10226820f, 0.21261431f, 0.15018807f, 0.18162349f, -0.06000942f, 
    -0.17350616f, -0.02640050f, 0.13516319f, 0.06392656f, 0.11191349f, 0.01343357f, 0.20467764f, 0.14876744f, 
    0.19844280f, -0.11923271f, 0.08982808f, 0.12823243f, -0.05642255f, 0.07821793f, -0.04416568f, -0.04418429f, 
    -0.20372531f, 0.00230260f, -0.01940996f, -0.12329535f, -0.45668980f, 0.24737327f, 0.27644268f, 0.04504780f, 
    -0.19881231f, 0.07951201f, -0.03413343f, 0.05941239f, -0.01595591f, -0.00505934f, 0.00382047f, 0.16364633f, 
    -0.03118800f, 0.00931574f, -0.02547720f, 0.01552725f, -0.01956295f, 0.02244584f, 0.00425999f, 0.02230178f, 
    -0.02955566f, 0.02141644f, 0.01939479f, -0.03982018f, -0.03311372f, -0.03066231f, -0.03388105f, -0.03632927f, 
    0.02010041f, -0.03227055f, 0.02448646f, 0.02524665f, -0.04382305f, -0.03448424f, 0.00778333f, 0.02325874f, 
    -0.03767649f, 0.01355916f, -0.02212674f, 0.00826497f, -0.00088365f, 0.01799933f, -0.00549201f, 0.00649797f, 
    -0.03936257f, 0.02798376f, -0.03920065f, 0.00567338f, 0.01528444f, -0.01049623f, -0.04070546f, -0.00570634f, 
    -0.02204409f, 0.02074787f, 0.00461719f, 0.02067886f, 0.00437221f, 0.02737346f, -0.03985886f, -0.02164682f, 
    -0.03269255f, 0.03223824f, 0.02083066f, -0.04198096f, 0.02423433f, -0.02192089f, -0.01951428f, -0.00748305f, 
    -0.04839477f, -0.02481314f, 0.02190017f, -0.01157104f, 0.01611650f, 0.03439591f, 0.02431837f, 0.02251938f, 
    -0.00066124f, -0.03578278f, 0.00796037f, -0.01712947f, 0.00216866f, -0.00534628f, -0.03008586f, -0.02871360f, 
    -0.01234997f, -0.02051405f, 0.00361752f, 0.00127881f, 0.01415867f, 0.00596916f, -0.01058486f, 0.00359911f, 
    0.01342173f, -0.03374239f, -0.03388605f, 0.01498335f, 0.02021335f, 0.03176050f, -0.03931916f, -0.01216308f, 
    0.02781631f, 0.01048295f, -0.02398507f, -0.03588453f, -0.00355318f, -0.01222586f, -0.00240632f, -0.02855021f, 
    0.02997040f, 0.00868729f, -0.01439384f, -0.01918408f, -0.03077050f, -0.01572447f, 0.01041574f, 0.02912840f, 
    -0.01008362f, -0.03865806f, 0.01145152f, -0.03688776f, -0.01269210f, 0.02670935f, 0.01165036f, -0.00156720f, 
    0.01655393f, -0.04108504f, -0.02726606f, -0.03477529f, 0.00631235f, -0.01625360f, -0.00452084f, 0.02135391f, 
    0.01191408f, -0.01697038f, 0.02434410f, 0.02430822f, -0.03278525f, -0.02896709f, 0.02185725f, 0.00371562f, 
    0.00958958f, 0.01820859f, -0.01340777f, -0.00254857f, -0.00086753f, -0.01708000f, -0.03163118f, 0.01567549f, 
    -0.00267729f, -0.03383154f, -0.02171888f, -0.02819788f, 0.00864215f, 0.01544908f, -0.00569338f, -0.04293475f, 
    -0.00630889f, -0.03284369f, 0.02917927f, -0.03031931f, 0.01417264f, -0.03606712f, 0.02432803f, -0.00098636f, 
    0.02643421f, -0.03022836f, 0.00217526f, -0.04225176f, -0.00688764f, 0.01896909f, -0.00521858f, 0.00256368f, 
    0.00389827f, -0.04006217f, -0.00607986f, 0.03336142f, 0.02249378f, -0.00964346f, 0.00367290f, -0.01121087f, 
    -0.01344975f, 0.01568962f, 0.01384462f, -0.03630006f, 0.01579390f, -0.01827610f, -0.03608788f, 0.00222574f, 
    0.02389907f, -0.04295738f, 0.00091851f, -0.02483781f, -0.01337412f, 0.00312525f, -0.03222693f, 0.00717733f, 
    0.01562344f, 0.02845694f, 0.02605598f, 0.01300241f, 0.00120186f, -0.00100999f, 0.02653501f, -0.02784725f, 
    -0.04231776f, -0.05029535f, -0.03692819f, 0.01744955f, 0.01012658f, -0.00096424f, 0.01684453f, 0.01647682f, 
    -0.03014142f, -0.03786973f, -0.00859144f, 0.00159639f, 0.02233039f, 0.03222012f, -0.00358126f, -0.01151077f, 
    0.01251730f, -0.03911726f, 0.00624323f, -0.03244684f, -0.00660353f, 0.01399377f, 0.01084379f, 0.00913829f, 
    0.01273941f, -0.01843860f, 0.01933861f, 0.01073280f, -0.00771576f, -0.03567783f, -0.03680414f, -0.03762694f, 
    -0.03804957f, -0.01102646f, 0.01784069f, -0.03299830f, 0.02497314f, 0.00612261f, 0.01631041f, 0.02319415f, 
    -0.00875224f, 0.01409092f, -0.03803172f, -0.02457927f, -0.03281991f, -0.01931136f, -0.02583277f, 0.02132597f, 
    0.02398088f, -0.01327092f, -0.00755612f, 0.01835303f, 0.02233501f, -0.02708829f, -0.02389470f, -0.00305269f, 
    0.02197932f, -0.01508170f, -0.00488246f, 0.00846949f, 0.00300852f, -0.01719905f, -0.03858432f, -0.01106292f, 
    -0.02996838f, -0.04097852f, 0.00124288f, 0.01004572f, 0.00915756f, -0.02713443f, 0.01227657f, 0.02614331f, 
    0.01229941f, -0.00794797f, 0.01670347f, 0.02360562f, 0.00565400f, 0.00373306f, 0.02279070f, 0.00378610f, 
    -0.01776278f, -0.02342004f, -0.01566727f, -0.03551320f, -0.03756236f, -0.00122554f, -0.02871063f, -0.01615834f, 
    0.00205824f, -0.03096622f, 0.02374803f, 0.02145780f, -0.02641315f, 0.00975929f, -0.02640959f, 0.00293379f, 
    -0.01820624f, 0.00515153f, 0.00288326f, 0.00226793f, 0.02674338f, 0.01793879f, -0.01630784f, -0.01092244f, 
    -0.00145715f, 0.02030598f, 0.01736380f, 0.02142555f, -0.01844339f, -0.01713789f, -0.02678262f, -0.01349752f, 
    -0.00538494f, 0.00218620f, 0.00523212f, 0.01077520f, 0.02078486f, 0.00459273f, -0.01563882f, -0.01032402f, 
    -0.02341138f, 0.02833515f, 0.01057139f, 0.02089425f, 0.00365338f, -0.01238502f, 0.02430743f, -0.01154752f, 
    0.01633820f, 0.01296469f, -0.03334794f, -0.01759105f, -0.01985958f, 0.02958666f, -0.00236360f, -0.04181581f, 
    -0.00353933f, 0.02462435f, 0.02235324f, -0.04230306f, -0.00436445f, -0.00389146f, -0.02779775f, 0.01103424f, 
    -0.04300846f, -0.02887547f, -0.03107938f, -0.04044859f, -0.02357664f, -0.03833093f, 0.00268106f, -0.03735891f, 
    -0.01815773f, 0.02054631f, -0.00641694f, -0.00092146f, -0.03320777f, 0.01051192f, -0.04074544f, -0.00683894f, 
    -0.00891707f, -0.04381077f, -0.03001405f, -0.02139239f, 0.01098801f, -0.01265178f, -0.04326163f, -0.00209820f, 
    0.01882278f, 0.00587523f, 0.02287704f, 0.02324990f, -0.02876296f, -0.03640036f, -0.03311405f, -0.01245607f, 
    0.00027491f, -0.04195009f, 0.03133073f, -0.00535048f, -0.03926813f, 0.00540774f, 0.00696358f, 0.02721627f, 
    0.00090297f, 0.01838608f, -0.01725997f, 0.00882183f, -0.02629503f, -0.04078491f, -0.02308707f, 0.02447841f, 
    -0.01665190f, 0.00660101f, 0.03052661f, -0.00828702f, 0.01693375f, -0.01761884f, -0.01868620f, -0.00057160f, 
    0.02564342f, -0.00184550f, 0.00459912f, -0.03878528f, 0.02601353f, -0.01652930f, 0.01281695f, 0.02312679f, 
    -0.01076981f, -0.04685931f, -0.01696801f, -0.02291505f, 0.00229827f, 0.01352743f, -0.01513254f, 0.02377439f, 
    -0.01527314f, 0.00196304f, -0.00287264f, 0.00432092f, 0.02490121f, 0.01164986f, -0.01312812f, -0.01322420f, 
    -0.03695485f, 0.00177098f, 0.01386203f, -0.02319319f, 0.02127067f, 0.01710433f, -0.01930913f, -0.02231574f, 
    -0.00694030f, -0.04124678f, -0.02830922f, -0.02685188f, 0.02291252f, -0.01880854f, -0.03724231f, -0.01738940f, 
    -0.03465511f, -0.02287099f, -0.03245446f, 0.01144559f, -0.00001238f, 0.02470717f, -0.03719216f, -0.04329387f, 
    -0.03572620f, -0.03194751f, 0.01933353f, -0.03276286f, 0.00136388f, -0.01894525f, -0.00141041f, -0.01313885f, 
    0.01474225f, 0.00166923f, -0.02912699f, -0.02020380f, 0.00488688f, -0.01907489f, -0.00898021f, -0.02608736f, 
    0.00282666f, -0.01406212f, 0.02040239f, 0.00089536f, -0.01112624f, -0.00194995f, 0.02340413f, -0.03734080f, 
    -0.02343576f, -0.02680454f, -0.03316401f, -0.00558856f, -0.02323743f, -0.03388204f, 0.00998465f, 0.01433158f, 
    0.01744031f, -0.02995983f, 0.02524845f, -0.01059782f, -0.02977656f, -0.00849980f, -0.00807387f, -0.00878012f, 
    -0.02433597f, -0.03528852f, -0.02422969f, 0.02115810f, 0.02578545f, -0.00174101f, -0.00578651f, -0.03164143f, 
    -0.01033776f, -0.02499893f, 0.02310535f, -0.02512858f, 0.02500651f, 0.00815739f, -0.03971631f, -0.02047178f, 
    0.02372604f, -0.03069910f, -0.03265654f, 0.02197233f, 0.01620366f, -0.01692075f, -0.03309336f, -0.00978500f, 
    -0.02027765f, -0.04652025f, 0.00343494f, 0.02134842f, -0.01831946f, -0.02076246f, 0.00948531f, -0.04103709f, 
    -0.01791413f, -0.00264018f, -0.02737877f, 0.00441007f, -0.04106248f, -0.02591067f, -0.02473668f, -0.02403853f, 
    0.01906622f, 0.01105082f, 0.01722494f, 0.02802243f, -0.04326914f, 0.00207792f, -0.04013536f, -0.01301336f, 
    -0.02961584f, 0.02465422f, 0.01798035f, -0.01119933f, 0.00701969f, -0.00918273f, 0.02307354f, 0.00926164f, 
    -0.03467742f, -0.00705486f, -0.03641645f, 0.02022957f, 0.02052142f, -0.02071705f, 0.02429584f, 0.00718509f, 
    -0.04408140f, 0.01744984f, 0.01643252f, 0.02068843f, -0.00638691f, -0.03723284f, -0.01292623f, -0.02171825f, 
    0.03333692f, -0.02361038f, -0.01262944f, -0.01284810f, 0.02406384f, -0.01323743f, 0.02064897f, -0.03552035f, 
    -0.03861187f, -0.01843142f, 0.00283224f, -0.00827715f, -0.00166385f, 0.02925531f, 0.02579354f, 0.00660850f, 
    0.01780509f, 0.00954644f, -0.03767762f, 0.02365750f, 0.01242992f, -0.03762435f, -0.03585110f, 0.00441575f, 
    -0.01031629f, -0.01235769f, 0.02462653f, -0.01227816f, -0.03722304f, -0.03717576f, 0.02973304f, -0.03904684f, 
    -0.00955824f, 0.02835014f, -0.03061913f, 0.02253522f, -0.01787254f, -0.00134953f, -0.03998894f, -0.00015307f, 
    0.00374695f, -0.03200871f, 0.01604109f, 0.02178062f, 0.01247239f, -0.02741392f, -0.01563487f, -0.00625351f, 
    0.00840333f, -0.03960541f, -0.00636304f, -0.00779059f, -0.03474350f, 0.02349187f, -0.01365181f, 0.01402952f, 
    -0.00292527f, -0.02388409f, 0.00298813f, -0.00675436f, -0.01315463f, 0.02172897f, -0.01196409f, -0.00443185f, 
    0.01448844f, -0.04243268f, -0.00225637f, -0.04056926f, -0.03836526f, -0.03159579f, 0.00336600f, 0.02147834f, 
    -0.00902483f, 0.00145598f, 0.02502034f, 0.00313753f, -0.02469185f, 0.00936625f, 0.01737343f, -0.00179350f, 
    -0.00284384f, -0.02649944f, 0.00499976f, -0.01282312f, -0.03096671f, -0.02413958f, -0.02789234f, 0.02039769f, 
    -0.00255498f, -0.03393564f, 0.01874087f, 0.02676714f, 0.02410745f, 0.00162328f, -0.00845052f, -0.00071408f, 
    -0.02501083f, 0.01485135f, -0.02033900f, 0.01643861f, 0.00423377f, -0.00280495f, -0.03239534f, 0.02648846f, 
    -0.03307464f, -0.01558889f, -0.02739715f, 0.00147294f, 0.00803901f, -0.01623475f, -0.02474028f, 0.01002979f, 
    -0.00449721f, 0.01895254f, 0.01185491f, 0.02157852f, 0.00434146f, 0.00577254f, -0.00155299f, -0.02991323f, 
    -0.01625031f, 0.01894893f, -0.01188731f, 0.02848906f, 0.00772780f, -0.03233939f, -0.01496217f, 0.02349471f, 
    -0.00859180f, 0.02417292f, 0.01535238f, -0.03062931f, 0.01225661f, -0.02308118f, 0.00970864f, -0.02713311f, 
    0.02138613f, 0.02852667f, -0.00613580f, 0.02733249f, -0.00417436f, -0.02871075f, -0.01379370f, -0.00790291f, 
    -0.01022313f, -0.02802288f, -0.01483594f, -0.00445053f, 0.02373000f, -0.00233366f, -0.03577237f, 0.01765328f, 
    -0.04432369f, 0.01797942f, -0.00784101f, 0.01753817f, 0.01411190f, 0.00128729f, -0.00452780f, 0.00508036f, 
    0.00694387f, -0.04309855f, 0.02302409f, 0.02528044f, 0.02267318f, 0.02754285f, -0.01414799f, 0.01954507f, 
    -0.00899741f, -0.00903268f, -0.03283872f, -0.03068609f, -0.03583455f, -0.00922010f, 0.00778115f, -0.00714526f, 
    -0.01110006f, -0.04523075f, 0.02355960f, -0.00014331f, -0.01347496f, -0.02341561f, 0.02725509f, -0.01696774f, 
    -0.02408392f, -0.03601735f, -0.03355694f, 0.00204551f, -0.00867059f, -0.02969345f, 0.01125597f, -0.00765763f, 
    -0.01157012f, -0.01199292f, 0.03168461f, -0.01575750f, -0.02821078f, 0.02223604f, -0.03617087f, -0.01871370f, 
    -0.03733339f, -0.01181895f, 0.00839108f, -0.03458392f, -0.00428264f, 0.01529568f, 0.01144495f, -0.03629920f, 
    -0.02354497f, 0.01544130f, -0.03232827f, -0.03660209f, -0.01215083f, 0.01027545f, -0.01391765f, -0.02090621f, 
    0.01665603f, -0.00321340f, 0.00560674f, 0.02960917f, 0.01078030f, -0.00270187f, 0.01495866f, -0.02570865f, 
    -0.02037382f, -0.01943066f, 0.01366004f, -0.01725689f, -0.01871614f, -0.02037205f, -0.02332691f, 0.00663989f, 
    -0.01808474f, -0.02460998f, 0.00799544f, 0.00322648f, -0.01464419f, 0.02706693f, 0.02755456f, -0.02132658f, 
    0.03637854f, 0.01622722f, 0.00587180f, 0.02258742f, 0.00440536f, -0.03359209f, 0.02644373f, -0.00034643f, 
    -0.02919957f, -0.00175072f, -0.03988693f, -0.00527380f, -0.03275726f, -0.03214547f, -0.02719469f, -0.01197119f, 
    -0.02303424f, 0.02615569f, 0.02560839f, -0.02901792f, -0.00329384f, -0.03277357f, 0.00605485f, -0.01332549f, 
    -0.03701829f, -0.01702865f, 0.02220913f, 0.01897269f, 0.01813783f, -0.00698159f, -0.02114218f, 0.01142916f, 
    0.01366128f, 0.00547638f, -0.01420956f, -0.01299631f, -0.03127483f, 0.00408495f, 0.02851628f, -0.00206570f, 
    -0.03864244f, -0.01884820f, 0.02916362f, 0.01136942f, 0.03892678f, 0.01088246f, -0.03818639f, 0.00832928f, 
    -0.00940572f, 0.01499091f, -0.02489422f, -0.02836249f, 0.02794134f, -0.02866308f, -0.03133373f, -0.02993950f, 
    -0.03592363f, 0.03168534f, -0.02727242f, -0.03256421f, 0.01333389f, -0.00373520f, -0.01017198f, -0.02988221f, 
    -0.03436622f, 0.01868746f, -0.00282755f, -0.02079605f, -0.00624239f, 0.02307401f, -0.02388806f, 0.03923463f, 
    -0.02096416f, -0.02317737f, 0.02468646f, 0.02323817f, -0.01729428f, 0.00546532f, 0.02623978f, 0.02647289f, 
    0.02990815f, -0.02689226f, -0.01321956f, -0.03471937f, -0.03473641f, -0.02211603f, -0.02173897f, -0.01913481f, 
    0.02753912f, 0.01985049f, -0.02195737f, 0.02632782f, -0.02936649f, 0.03301888f, -0.00405187f, 0.01383703f, 
    -0.01348019f, -0.02741387f, 0.02357463f, 0.00891346f, -0.00474629f, 0.02401078f, -0.02284478f, 0.02282233f, 
    0.02365786f, -0.01769892f, 0.00441075f, -0.01418839f, -0.01050490f, 0.00517804f, -0.01809714f, 0.00003933f, 
    -0.01220028f, -0.02001385f, -0.01681392f, 0.00920109f, 0.03047175f, 0.03409378f, -0.01894721f, -0.00775321f, 
    0.00022768f, -0.01474542f, 0.02449623f, 0.02706422f, 0.02537669f, -0.02336741f, -0.01676591f, -0.00022381f, 
    -0.03665470f, -0.03224569f, -0.00697486f, -0.03972276f, -0.04048942f, -0.00833918f, -0.00803114f, 0.02453857f, 
    -0.03461539f, -0.03315981f, -0.02639871f, -0.02726289f, -0.02633667f, -0.00578022f, 0.03468107f, -0.02108373f, 
    -0.00775935f, 0.04602205f, -0.00272225f, -0.01799176f, 0.01376100f, 0.03311267f, -0.00822907f, -0.01421020f, 
    0.02310716f, -0.03123676f, -0.01130793f, 0.00836831f, 0.00448659f, 0.00236518f, -0.01217206f, -0.00250317f, 
    -0.00892831f, -0.02035755f, -0.03732673f, 0.02662726f, 0.00492884f, 0.02105503f, 0.00858854f, 0.03322728f, 
    -0.02385691f, 0.00011058f, 0.00330614f, -0.03295168f, 0.00427459f, 0.00571189f, -0.01297348f, -0.01544205f, 
    -0.02743863f, -0.02810152f, -0.03682586f, -0.01307031f, -0.02437148f, 0.00280279f, 0.01839374f, -0.03811037f, 
    0.01423016f, -0.01770597f, 0.00989346f, -0.02904275f, -0.01353487f, 0.02883273f, 0.00815028f, -0.02127160f, 
    0.01661777f, -0.01681249f, -0.02832866f, -0.00209554f, 0.00474390f, -0.03540385f, 0.01891910f, -0.02618117f, 
    0.03059723f, -0.01375695f, 0.01195459f, -0.04084285f, 0.01559562f, 0.01627802f, -0.01153119f, -0.00017233f, 
    -0.02912929f, 0.00173235f, 0.01003064f, -0.01018583f, 0.01688814f, -0.03393678f, 0.00975585f, 0.02636367f, 
    0.00647061f, -0.00453113f, 0.02910624f, -0.01700557f, -0.02859074f, -0.01881667f, -0.02552635f, 0.01400812f, 
    0.02430401f, 0.00352303f, -0.01258192f, -0.01890108f, 0.01786772f, 0.02174848f, 0.00155332f, -0.02680755f, 
    -0.01343314f, 0.01363966f, 0.02865700f, 0.02126019f, 0.02769619f, -0.01860403f, -0.02650001f, -0.02531531f, 
    0.01308348f, -0.01993071f, -0.02024442f, -0.01326574f, 0.03145276f, -0.02550490f, 0.03141259f, -0.00752047f, 
    0.01595310f, -0.02841556f, -0.01465318f, 0.01323299f, -0.03682370f, -0.01261569f, 0.00263176f, 0.00931517f, 
    -0.02701227f, -0.03567342f, 0.02531387f, -0.03149662f, 0.01807340f, -0.01030268f, 0.01823312f, -0.00805917f, 
    0.01906070f, -0.02989355f, 0.02926387f, 0.01679067f, 0.04114347f, 0.02516310f, 0.01386406f, 0.01253269f, 
    -0.01579353f, -0.01711308f, -0.04153673f, 0.00906615f, -0.02446550f, 0.01803557f, 0.02891138f, -0.01696808f, 
    0.00831541f, 0.02816988f, -0.03568318f, 0.00210347f, 0.01127857f, -0.03439625f, -0.03361599f, -0.02876417f, 
    0.02233418f, 0.02113136f, -0.01062642f, 0.01048600f, -0.01729939f, -0.00010655f, 0.01677479f, 0.01180436f, 
    -0.01507253f, -0.02618246f, -0.03262059f, 0.00152611f, 0.01928554f, 0.01547100f, 0.01995987f, -0.02465247f, 
    -0.01756806f, 0.00831942f, -0.00957568f, -0.03270585f, -0.01687985f, -0.01836129f, 0.02788167f, 0.02888142f, 
    0.00057871f, -0.01847785f, -0.01542575f, -0.03747104f, 0.00485523f, 0.02800718f, -0.01445952f, 0.01586182f, 
    0.03363772f, -0.01678186f, -0.01639559f, 0.02906699f, 0.01043021f, 0.02390165f, 0.02278041f, -0.02936865f, 
    0.00489957f, -0.00632722f, 0.00060188f, -0.02079995f, 0.01199864f, 0.01677995f, -0.02450796f, -0.03869320f, 
    -0.00360749f, -0.02533942f, -0.01719573f, 0.02649182f, 0.02258851f, 0.02280837f, -0.02754175f, -0.03943628f, 
    0.01720293f, 0.00914288f, -0.03905974f, -0.00331966f, 0.02290015f, -0.02096307f, 0.00446764f, -0.03012590f, 
    0.03042863f, -0.03507011f, 0.01500458f, -0.01130814f, 0.01965400f, -0.01871755f, -0.03180612f, -0.00640458f, 
    0.00998166f, -0.03132034f, -0.02829022f, -0.03401717f, -0.02922272f, 0.02596344f, 0.02156961f, -0.01699872f, 
    0.02531575f, -0.02652748f, 0.00762619f, 0.01166870f, -0.01225556f, -0.02851519f, -0.02166450f, -0.03802429f, 
    0.00334128f, 0.02060580f, -0.00324168f, 0.00391059f, -0.03539935f, 0.01740193f, 0.02817762f, -0.02989783f, 
    0.00764506f, 0.01023289f, -0.01780401f, 0.03702635f, 0.00263916f, -0.03559075f, -0.02631341f, -0.00499168f, 
    0.03215484f, 0.00218809f, -0.02895126f, 0.02976041f, -0.01568588f, -0.04439794f, -0.00107423f, -0.02673161f, 
    -0.02296538f, -0.02624499f, -0.02959669f, -0.01856835f, -0.01975261f, -0.03370391f, 0.03076083f, 0.00529695f, 
    -0.01326501f, 0.02762328f, 0.02203127f, 0.00596457f, 0.01821985f, -0.02758525f, -0.02029704f, -0.01175765f, 
    0.02036799f, -0.01363173f, -0.01428471f, 0.02619028f, -0.02334017f, 0.01442110f, -0.02171257f, -0.04162042f, 
    0.03635837f, 0.00497571f, 0.01222590f, 0.00737449f, 0.00442944f, -0.02026289f, 0.00247379f, 0.01535906f, 
    -0.03930900f, -0.00883090f, 0.00463772f, -0.00752688f, 0.01165784f, 0.02988826f, 0.01510751f, 0.01420272f, 
    0.00600688f, -0.04103233f, 0.00407447f, -0.00308563f, -0.02674937f, -0.02017988f, 0.02464911f, -0.02265438f, 
    0.01578185f, -0.03266088f, 0.00267713f, 0.00789965f, -0.00071045f, -0.00583952f, -0.01880744f, -0.01264880f, 
    0.01641179f, 0.02171902f, -0.02609202f, -0.00972599f, 0.02677659f, 0.03469435f, 0.02453892f, -0.01278748f, 
    -0.00156386f, 0.02340992f, -0.02471191f, 0.01328168f, -0.02321960f, -0.02403333f, 0.02661916f, -0.00863515f, 
    -0.01722465f, 0.01137081f, 0.00853270f, 0.03076472f, -0.02881311f, -0.01047072f, 0.01656401f, -0.03828959f, 
    -0.02423697f, 0.00340024f, -0.03583133f, -0.01898004f, -0.02886039f, -0.03971650f, 0.03194069f, 0.03402657f, 
    -0.03714571f, 0.02242373f, -0.03126083f, 0.00951213f, -0.04150544f, 0.00065714f, -0.02834690f, -0.00835263f, 
    0.01113987f, -0.03611765f, -0.00325745f, 0.00144495f, 0.01340672f, 0.02367534f, 0.02426696f, 0.03480647f, 
    0.01353529f, 0.03465868f, -0.03022401f, -0.01174335f, -0.03330763f, -0.00734441f, -0.02230375f, -0.01781326f, 
    -0.00390942f, -0.01795778f, 0.00366957f, -0.02806359f, -0.03190413f, 0.02533513f, -0.02994192f, -0.01979960f, 
    -0.01954160f, -0.00819535f, -0.00512356f, -0.01467717f, -0.02898041f, -0.01149580f, 0.00749920f, 0.03159077f, 
    -0.00166832f, -0.03177847f, -0.02533587f, 0.01195252f, 0.01313879f, -0.03990130f, -0.03285297f, 0.01586095f, 
    -0.03633169f, -0.00357505f, -0.03810556f, 0.04177302f, -0.02050972f, -0.04181009f, 0.01434107f, -0.02145662f, 
    -0.01743168f, 0.01295036f, -0.00584067f, 0.00900648f, 0.01399487f, -0.02544644f, 0.00368823f, 0.00002974f, 
    0.02443450f, 0.02158779f, 0.00272760f, 0.02535142f, -0.03324450f, -0.02067593f, 0.00666621f, 0.01954126f, 
    0.00411534f, -0.02264484f, 0.01128551f, -0.00421221f, -0.01874811f, -0.01473068f, -0.02434006f, -0.02913675f, 
    0.00336811f, -0.01299938f, 0.00579170f, -0.01515345f, -0.02362153f, 0.01013502f, -0.00725676f, 0.01956301f, 
    -0.00284902f, -0.03623641f, 0.01223116f, 0.00866586f, -0.00660527f, -0.00492466f, -0.02022067f, -0.01451216f, 
    0.02282663f, 0.00121895f, -0.02514756f, -0.02363672f, 0.01300634f, 0.00584906f, -0.03326893f, -0.02194799f, 
    -0.01121672f, 0.00354620f, -0.03117269f, -0.02725100f, -0.03281937f, -0.02152112f, -0.03006821f, 0.02542054f, 
    0.01792931f, 0.01863855f, -0.01903350f, -0.04005909f, -0.02952598f, 0.00705297f, 0.02262976f, 0.00077927f, 
    0.01082894f, -0.04113442f, 0.02548221f, 0.03435791f, -0.04002554f, -0.01990028f, -0.02674711f, -0.00106278f, 
    -0.01992490f, -0.02969229f, -0.04071315f, 0.01430088f, -0.00518151f, -0.00640018f, -0.00801689f, -0.00092802f, 
    -0.04592354f, 0.01388842f, 0.03179121f, 0.00796942f, -0.01699274f, -0.03231262f, -0.00801430f, 0.00097515f, 
    0.01347530f, -0.01635522f, 0.02339192f, 0.01303601f, -0.03824088f, 0.01831907f, -0.03952626f, -0.01703943f, 
    0.01433499f, -0.02944280f, 0.01777586f, 0.00680658f, 0.00650452f, 0.04168450f, -0.00442888f, 0.02587009f, 
    0.00985728f, -0.00759259f, -0.01891033f, 0.03545930f, 0.00360369f, -0.01243112f, -0.02592544f, -0.01779384f, 
    -0.01526102f, -0.03471709f, 0.02011617f, -0.00435456f, -0.00710184f, -0.00679926f, -0.03209082f, -0.00224860f, 
    0.02316460f, -0.02423153f, -0.02446079f, -0.01288862f, -0.01472321f, 0.02233222f, 0.01130874f, -0.00130646f, 
    -0.01574211f, 0.02470220f, -0.00541067f, 0.01390419f, 0.00688449f, -0.01481800f, -0.01239026f, 0.02143926f, 
    -0.01731590f, -0.03505751f, 0.02488362f, 0.02983060f, -0.03661202f, 0.01217096f, -0.02081267f, 0.01450428f, 
    0.00544326f, -0.01141554f, 0.00865199f, 0.00694685f, -0.02359320f, -0.00547400f, -0.01223642f, -0.00202050f, 
    0.00876730f, 0.02965551f, 0.02598724f, 0.01815391f, 0.03674138f, 0.02246066f, 0.01155839f, 0.00136602f, 
    -0.00314161f, 0.01372141f, 0.02092884f, 0.02542538f, 0.01611663f, -0.03232115f, 0.02501240f, -0.02589025f, 
    0.02589099f, 0.02588349f, -0.02409696f, -0.03055310f, -0.02643110f, 0.02808560f, -0.03087405f, 0.00153992f, 
    -0.03724749f, -0.02907557f, -0.01415109f, -0.00943687f, 0.01347954f, -0.00967039f, 0.01958083f, -0.01156800f, 
    0.00661574f, -0.00023430f, 0.01010915f, 0.01071723f, 0.01881547f, 0.02776684f, -0.01604241f, 0.00720506f, 
    -0.03124495f, 0.03382492f, 0.04102166f, 0.01066145f, 0.01433943f, -0.01827086f, -0.03008874f, -0.03285627f, 
    0.04764352f, 0.04885370f, 0.13876349f, 0.10128709f, 0.06208726f, -0.08606550f, 0.03699505f, 0.01342875f, 
    -0.09360055f, -0.07937665f, 0.14144436f, 0.02739815f, -0.01998318f, -0.00546657f, 0.08201718f, -0.10043028f, 
    0.05217644f, -0.05588352f, -0.02086278f, -0.05989124f, 0.07454158f, 0.01475558f, -0.00245856f, 0.05186569f, 
    0.26049402f, 0.05940796f, -0.26715279f, 0.23887581f, 0.00494687f, -0.03156952f, 0.12636565f, 0.06066869f, 
    0.13842319f, 0.04543413f, 0.04212615f, -0.10728288f, 0.36491632f, 0.00296620f, 0.07688467f, -0.00406183f, 
    0.03776042f, 0.04730695f, 0.02797992f, -0.01084196f, -0.01952304f, -0.07655004f, 0.09746782f, 0.04776407f, 
    -0.36433041f, 0.12125380f, -0.15641657f, 0.04627729f, 0.03366915f, -0.00945041f, -0.00470231f, -0.07719904f, 
    -0.19215944f, -0.26539832f, 0.03008438f, 0.02526144f, 0.14846395f, 0.21909209f, -0.03941717f, 0.08964283f, 
    -0.04585830f, -0.05117604f, -0.02488521f, -0.14364058f, 0.03225419f, -0.11909464f, -0.15056501f, -0.09194811f, 
    0.04502224f, -0.26534146f, 0.10878003f, -0.09250325f, -0.09704453f, 0.06723826f, -0.00258256f, -0.04537851f, 
    0.04131811f, 0.08236478f, -0.12410324f, 0.00982337f, -0.08141866f, 0.22835541f, 0.02490160f, -0.13000540f, 
    0.16289257f, 0.06899957f, -0.01591325f, -0.03564031f, 0.09151994f, -0.02951907f, 0.01903532f, 0.02383872f, 
    -0.45231721f, -0.12925568f, -0.10343204f, 0.09235653f, -0.12022347f, 0.15333536f, 0.04655009f, -0.17361379f, 
    -0.09053957f, -0.02643699f, 0.05312839f, 0.08840902f, 0.00031518f, -0.07252529f, 0.06565258f, -0.01861482f, 
    -0.18016802f, 0.05072745f, 0.08141793f, 0.07526205f, 0.04747342f, -0.07748693f, -0.13335554f, -0.04730622f, 
    0.05012079f, 0.13349032f, 0.09917207f, -0.08686859f, 0.03877308f, -0.11529060f, 0.00901031f, 0.00756775f, 
    -0.00450876f, 0.02716877f, -0.16716464f, -0.01636503f, 0.00924623f, -0.22723025f, 0.21194197f, -0.21583970f, 
    0.11168188f, 0.00114301f, 0.04414436f, -0.08567768f, 0.05786845f, -0.01115014f, 0.02150459f, -0.08334126f, 
    0.10575926f, -0.32644531f, 0.00147925f, -0.13361776f, -0.12078214f, -0.03931635f, 0.08272737f, -0.04239701f, 
    0.01665831f, -0.09028988f, -0.03948200f, 0.04725738f, -0.22067977f, -0.17735353f, 0.18387869f, 0.20042361f, 
    -0.02019556f, -0.10172753f, 0.00011497f, 0.01294477f, -0.09558375f, 0.25080928f, -0.18477167f, 0.13780282f, 
    0.01722805f, 0.21139523f, 0.00940248f, 0.08885783f, 0.08548050f, 0.04461242f, -0.07032033f, 0.01868737f, 
    -0.01226598f, 0.04703256f, 0.23998384f, 0.01351899f, 0.03150271f, 0.08088182f, 0.01654491f, 0.08749499f, 
    0.04633756f, 0.00553198f, -0.08450724f, 0.03219837f, 0.03840730f, -0.05350179f, -0.00255085f, -0.08666913f, 
    -0.02632382f, 0.27091807f, 0.21633388f, -0.00673724f, 0.09879495f, -0.00650302f, 0.10586773f, 0.04136416f, 
    -0.00603433f, 0.13892582f, -0.09621425f, 0.05351621f, 0.00464293f, 0.11397903f, -0.33249158f, 0.07577969f, 
    0.09253149f, -0.10223913f, -0.05451680f, 0.06744518f, 0.18029104f, 0.03921794f, 0.03742767f, 0.00777884f, 
    0.64242679f, -0.08809191f, -0.15493520f, 0.05654249f, 0.12892377f, 0.05883727f, -0.00507327f, 0.01646774f, 
    -0.06462266f, -0.18538773f, -0.11876702f, -0.09950403f, 0.01610864f, 0.17781627f, -0.06533396f, -0.03353728f, 
    -0.00704670f, 0.03993331f, -0.02649429f, -0.03126824f, -0.08005198f, -0.13094793f, -0.02207333f, 0.09552802f, 
    -0.36440030f, -0.26926428f, -0.13309950f, -0.03964552f, -0.08069474f, 0.01158104f, 0.04664820f, 0.05327853f, 
    0.02357879f, 0.00206532f, -0.07163700f, -0.08719456f, -0.10840460f, 0.06153815f, -0.03256230f, 0.43556634f, 
    -0.06106621f, -0.04314556f, -0.04637366f, 0.08359622f, 0.15009661f, -0.05173197f, 0.18170755f, -0.17162392f, 
    0.08246034f, -0.18913954f, 0.15346776f, 0.02319178f, -0.05660414f, 0.08411688f, -0.14102378f, 0.20582139f, 
    0.04824675f, 0.05455704f, 0.04159790f, -0.04881476f, 0.13920440f, -0.01011297f, -0.13703226f, -0.07033899f, 
    0.24856052f, 0.09700779f, -0.01059025f, -0.00008140f, 0.09584463f, -0.07729568f, 0.08986033f, -0.09426881f, 
    0.34116492f, 0.02861810f, -0.01375368f, 0.01298900f, 0.08199729f, -0.10792120f, 0.02698843f, 0.17114390f, 
    -0.06935614f, 0.04674798f, 0.16244106f, -0.06404823f, 0.32339752f, -0.00571020f, 0.33346614f, -0.17867629f, 
    -0.06876789f, -0.05234275f, -0.04486225f, 0.14796929f, 0.03113129f, 0.06151685f, 0.05167944f, -0.01127941f, 
    0.42142507f, -0.04708142f, -0.31637573f, 0.26370111f, 0.05018709f, -0.04359023f, -0.07968245f, 0.17379327f, 
    0.08823369f, 0.07223146f, 0.13675751f, 0.04461871f, -0.08882512f, -0.26640925f, 0.05298931f, -0.10292565f, 
    -0.06059175f, -0.14517449f, 0.04248725f, 0.00752573f, -0.05505253f, 0.11145735f, -0.09187686f, 0.09680743f, 
    -0.02313801f, -0.07866341f, 0.09116035f, 0.05940611f, -0.08800639f, -0.01873918f, -0.06758696f, -0.06269534f, 
    -0.00273703f, -0.08039668f, -0.03332440f, -0.00845967f, 0.29273510f, -0.13222368f, 0.20190093f, -0.22728296f, 
    -0.09122285f, 0.00053513f, -0.05525183f, -0.07605378f, -0.03739194f, -0.17937544f, 0.27419999f, -0.14257291f, 
    -0.22375049f, -0.09053399f, -0.06908640f, 0.05040706f, -0.02469992f, 0.08097318f, 0.03297671f, -0.21680629f, 
    -0.02646956f, 0.00021864f, 0.05744699f, 0.04733960f, 0.08495861f, 0.08567729f, 0.17167258f, -0.15245251f, 
    0.00240214f, -0.08628223f, 0.01098167f, 0.14424238f, -0.04706546f, 0.09521226f, -0.11911760f, -0.03262904f, 
    -0.06329601f, -0.26130438f, -0.18617924f, 0.22291775f, -0.04258630f, 0.10278179f, 0.00901990f, -0.02833681f, 
    -0.02593268f, -0.00658317f, -0.09612724f, 0.03174086f, 0.14423268f, 0.00849440f, 0.40150514f, 0.09787694f, 
    -0.03320705f, 0.12563013f, -0.05289870f, -0.01245330f, 0.08743273f, 0.12369399f, 0.07541885f, 0.03597909f, 
    0.26637679f, 0.00358691f, -0.13090932f, 0.06745430f, 0.00887912f, -0.00775145f, 0.00433896f, 0.02700307f, 
    0.10193715f, -0.00460099f, 0.05920637f, 0.07610939f, 0.03419273f, -0.03970718f, -0.12787393f, 0.05826838f, 
    0.02860228f, 0.00524379f, -0.05444369f, -0.06159656f, 0.00527124f, 0.02026844f, 0.20419730f, 0.00993777f, 
    -0.11188997f, 0.04182564f, -0.01392224f, 0.13412678f, -0.04319079f, -0.05216525f, -0.05407291f, -0.04644939f, 
    0.09313777f, -0.09722995f, 0.01523704f, 0.02196919f, -0.05598088f, 0.02797603f, 0.12629761f, -0.31902480f, 
    -0.03052141f, -0.10928549f, 0.04734277f, 0.05905230f, -0.03294462f, -0.10030360f, 0.06329594f, -0.02570274f, 
    -0.11425903f, 0.23769362f, -0.00830991f, 0.14139834f, 0.05942871f, 0.14302331f, 0.00190588f, 0.07836271f, 
    0.05456851f, -0.17112336f, 0.04323383f, -0.04932757f, -0.16825904f, -0.00017069f, -0.00670580f, 0.02057036f, 
    -0.00828511f, -0.01323119f, -0.06331270f, 0.00453532f, -0.04421217f, 0.00979713f, 0.09781107f, -0.10364711f, 
    0.01961298f, 0.11348900f, -0.19291323f, 0.12000711f, -0.00107625f, -0.07418142f, 0.13891701f, 0.05050117f, 
    0.17707372f, -0.06044349f, 0.06766397f, -0.09049425f, -0.30907395f, -0.05201505f, 0.05310030f, 0.07424437f, 
    -0.10864147f, -0.05212611f, 0.19688800f, 0.02248032f, 0.00903739f, -0.14197682f, 0.01817486f, -0.02832246f, 
    0.13545407f, -0.08280701f, 0.23777662f, 0.02394550f, -0.09213155f, 0.05367903f, 0.16317053f, 0.15951554f, 
    0.10062196f, 0.02719414f, -0.06230546f, 0.04363647f, 0.09357642f, 0.14397711f, 0.04173233f, -0.06475683f, 
    0.05632881f, 0.03637672f, 0.15980352f, 0.00167849f, 0.14112817f, -0.03055761f, 0.02169358f, 0.11976623f, 
    -0.05672277f, 0.10689384f, -0.04428995f, 0.38715962f, 0.15502438f, -0.07457099f, 0.07586968f, 0.03252105f, 
    -0.02662668f, 0.09171528f, -0.06633893f, 0.01977934f, 0.14224990f, -0.06454185f, 0.31767240f, -0.14597912f, 
    -0.00468128f, -0.03258052f, 0.12448644f, -0.05895041f, 0.04140253f, 0.00702366f, -0.01092595f, 0.22334173f, 
    -0.23620968f, -0.04281754f, 0.05537494f, -0.26315251f, 0.10420227f, -0.15775901f, 0.04939376f, -0.08996174f, 
    0.10672143f, 0.10670967f, -0.15095568f, 0.13688089f, -0.11493433f, 0.01840836f, -0.22517975f, 0.01639673f, 
    -0.08693070f, 0.05852143f, -0.15531577f, -0.00112099f, -0.06726179f, 0.09008600f, 0.00566993f, -0.07326322f, 
    -0.34856424f, 0.11254088f, -0.08656068f, 0.00383828f, -0.11091726f, -0.03097031f, 0.13404134f, -0.08824570f, 
    0.04383454f, 0.11027686f, -0.05128897f, 0.16937864f, 0.07316650f, 0.16336422f, 0.08160306f, -0.02211581f, 
    -0.00565297f, -0.06943282f, -0.03202413f, 0.04076150f, -0.02691114f, 0.04393097f, 0.08775192f, -0.01765550f, 
    -0.17388393f, -0.12018916f, 0.04731144f, -0.00561599f, -0.16847993f, -0.00221784f, 0.18304846f, 0.02898096f, 
    0.16609985f, -0.02966052f, -0.05643363f, -0.04038418f, 0.23267469f, 0.11753063f, 0.09961428f, -0.12904356f, 
    0.09447230f, 0.07475533f, 0.04154390f, 0.03165777f, -0.02126565f, 0.16053760f, -0.10673334f, 0.00582234f, 
    -0.35814425f, 0.22233298f, -0.00193851f, 0.03805983f, -0.03918999f, 0.08479652f, 0.05646874f, 0.08191445f, 
    -0.04286388f, 0.02221362f, 0.06052139f, -0.01129119f, 0.03650459f, 0.00400913f, -0.29705787f, 0.15325265f, 
    -0.06550689f, 0.02149110f, -0.01203354f, -0.05400877f, 0.17267375f, -0.09763556f, 0.13229142f, -0.03608472f, 
    0.24962980f, 0.07503717f, -0.02949005f, -0.22395398f, 0.06660551f, 0.07189655f, 0.18010226f, 0.11128215f, 
    0.00591650f, -0.05776171f, 0.05901325f, -0.07119116f, -0.00949852f, 0.09647286f, -0.17130320f, 0.16018854f, 
    -0.02926816f, 0.05383718f, -0.12287689f, 0.17392097f, 0.07073129f, -0.07439646f, -0.09195832f, -0.08012053f, 
    0.21774718f, -0.06655752f, 0.39505094f, -0.13976170f, 0.05750844f, 0.08378912f, -0.02059747f, -0.03060259f, 
    0.11891130f, 0.06214374f, -0.00183291f, 0.02812160f, 0.15661626f, 0.07984617f, -0.16011105f, 0.16957898f, 
    0.12507805f, 0.10799690f, -0.05630309f, -0.10667929f, 0.02305220f, 0.05468706f, -0.01374928f, 0.11748852f, 
    -0.04580564f, -0.12595738f, -0.18831567f, 0.08762073f, 0.01544621f, 0.04686897f, -0.00849550f, -0.04910740f, 
    0.05988040f, 0.08707277f, -0.09036419f, 0.16022530f, 0.06951638f, 0.06650539f, 0.16376960f, -0.29122993f, 
    0.10114559f, 0.03387425f, -0.06019623f, 0.22790010f, -0.00859404f, -0.15510677f, -0.01938050f, -0.01973645f, 
    0.09127893f, 0.30705914f, 0.00598827f, 0.06938770f, 0.01209671f, -0.09517522f, 0.05102000f, 0.16721261f, 
    0.04653341f, -0.09556128f, 0.13078792f, -0.07704204f, -0.28348801f, 0.00762020f, -0.08601132f, -0.08023969f, 
    0.07819487f, 0.02551917f, 0.22862208f, -0.10855084f, -0.06130657f, 0.03291663f, -0.03264335f, 0.04210840f, 
    0.02249956f, 0.11245394f, -0.27828911f, 0.09178682f, 0.08715464f, -0.16166377f, -0.02875675f, -0.12224151f, 
    0.21092205f, -0.04091485f, 0.07827613f, -0.05522459f, 0.19162986f, -0.20035736f, -0.11600471f, 0.42576838f, 
    0.07574531f, 0.06132164f, 0.20548654f, -0.03653709f, -0.01731288f, 0.00122075f, 0.04310085f, 0.13505863f, 
    0.10445245f, 0.22898687f, 0.22663707f, -0.12312600f, -0.11947530f, -0.04885203f, 0.00255966f, 0.02204543f, 
    -0.04834266f, -0.06176672f, 0.16247141f, -0.05368795f, -0.30284774f, -0.02846718f, 0.09677026f, 0.17548084f, 
    0.09643877f, -0.06779326f, 0.08048039f, -0.04896156f, -0.07220883f, -0.09021789f, 0.07680994f, -0.05055093f, 
    0.16689414f, 0.10505497f, -0.14766778f, -0.14826600f, 0.16555628f, 0.12322193f, 0.04638976f, -0.02384504f, 
    0.11991702f, 0.04058883f, -0.01834189f, -0.00397088f, -0.00519103f, 0.12387285f, -0.00015805f, -0.26170179f, 
    0.20890582f, -0.05419410f, -0.04324246f, -0.02405700f, 0.08091495f, 0.04532137f, -0.12134656f, -0.06234250f, 
    0.14242734f, 0.03866109f, -0.03853557f, 0.03670287f, 0.06196845f, -0.10180928f, -0.13703060f, -0.07220694f, 
    -0.00404533f, 0.14802621f, 0.15532869f, -0.05647903f, -0.06906211f, 0.25005430f, 0.12729871f, -0.03256229f, 
    -0.09658206f, -0.09812280f, -0.09650473f, -0.00572535f, -0.00010318f, -0.01895790f, 0.04690522f, 0.04074385f, 
    0.07365685f, -0.00850725f, -0.01569775f, 0.17298871f, -0.11774804f, 0.14023428f, 0.02173575f, -0.07054895f, 
    -0.08991710f, -0.04590951f, -0.12802102f, -0.03869774f, -0.04862881f, 0.10629875f, 0.18538247f, -0.11669613f, 
    -0.04285078f, 0.06490372f, -0.02194685f, 0.03222485f, -0.10084816f, -0.00026738f, -0.05960693f, 0.04445302f, 
    0.40499046f, 0.00595251f, 0.06962552f, 0.04356692f, -0.09257200f, 0.00772032f, -0.06158542f, 0.07437439f, 
    -0.04014570f, 0.06301019f, -0.03708417f, -0.05794674f, -0.03228546f, -0.07438561f, 0.00306102f, 0.04191268f, 
    0.05043978f, 0.05508385f, -0.12485200f, -0.01857179f, -0.03297361f, 0.11336285f, -0.13159274f, -0.08625764f, 
    -0.17476162f, 0.26227742f, 0.00151932f, -0.12009720f, -0.13815074f, -0.09264681f, -0.10453326f, -0.03229837f, 
    0.02988469f, -0.08513350f, 0.09674873f, 0.13113692f, 0.48970053f, 0.05864901f, -0.00291937f, 0.27691391f, 
    -0.11761636f, 0.09449836f, -0.04574947f, 0.00158051f, 0.01031913f, 0.01289482f, 0.13028300f, -0.03869959f, 
    0.26786759f, -0.33406967f, 0.15389942f, 0.09874555f, 0.01741192f, -0.05950940f, -0.15438902f, 0.12532738f, 
    0.07165247f, 0.06845681f, -0.03337992f, 0.20325989f, 0.23487093f, -0.05538155f, 0.10894054f, 0.19111085f, 
    -0.03748009f, 0.03712558f, -0.02626127f, 0.16818047f, 0.01845517f, 0.16616879f, -0.17905945f, 0.09378022f, 
    -0.01091593f, 0.13482577f, -0.06420669f, -0.23191884f, 0.02557252f, -0.05120694f, -0.03248982f, 0.03853288f, 
    -0.07864513f, -0.02850107f, -0.06001342f, -0.04053807f, 0.17354511f, -0.29246235f, -0.10943755f, -0.07241212f, 
    -0.03508149f, 0.04974482f, -0.00321420f, 0.16847633f, 0.01267632f, -0.08652639f, -0.11355553f, 0.07742176f, 
    -0.21985221f, 0.16337350f, 0.07950456f, 0.07414115f, 0.05320650f, 0.08191250f, -0.00855850f, 0.01192017f, 
    -0.00902851f, 0.01230232f, 0.16096534f, 0.02942822f, -0.18669103f, 0.01794600f, -0.03944094f, -0.19833490f, 
    0.04594177f, -0.01814168f, 0.12174968f, 0.00971375f, 0.04845198f, 0.17216891f, 0.07382171f, 0.04740192f, 
    -0.04931287f, 0.27126059f, -0.02711554f, -0.09244824f, 0.14148103f, 0.00099028f, 0.03430781f, 0.15458816f, 
    0.02682738f, -0.03597489f, 0.01100744f, 0.15105991f, 0.11497852f, 0.01227274f, -0.16981098f, -0.14230791f, 
    -0.03584559f, 0.09842847f, -0.06889894f, -0.00031589f, -0.05777763f, -0.11911812f, -0.04907822f, 0.03148479f, 
    0.26495624f, -0.29418215f, -0.05221515f, 0.07204873f, 0.03582191f, 0.07347931f, -0.09906133f, -0.10515124f, 
    0.03658056f, 0.12316424f, 0.11740883f, 0.14852034f, 0.08995910f, 0.29086202f, -0.00411730f, -0.04928442f, 
    -0.02523718f, 0.05550976f, -0.09714442f, -0.04999244f, 0.06503362f, -0.05579483f, 0.03787535f, -0.11406948f, 
    0.36049026f, -0.23177926f, 0.07515132f, 0.12747349f, 0.22313549f, 0.03752752f, -0.02207710f, -0.05807877f, 
    0.07423996f, 0.03319851f, 0.07438097f, 0.02584101f, 0.09303199f, -0.17112558f, -0.22115973f, -0.13012494f, 
    -0.00936296f, -0.07754602f, 0.04583486f, 0.06723646f, 0.03147911f, 0.04692976f, -0.07749943f, -0.06629551f, 
    0.27245361f, -0.06241353f, -0.04092646f, -0.11788778f, 0.01962856f, -0.06811540f, 0.08606494f, 0.11844701f, 
    0.01321752f, -0.06347653f, -0.03438850f, 0.12418140f, -0.14755252f, 0.00608392f, -0.01810989f, -0.09929968f, 
    -0.01213663f, -0.00589932f, -0.15212171f, -0.01552418f, 0.03607935f, 0.03507749f, -0.01993472f, -0.11001742f, 
    0.05340105f, 0.03132009f, -0.07245824f, -0.12452467f, -0.05304040f, 0.01039200f, 0.02560241f, 0.04766173f, 
    -0.00788030f, 0.00335752f, -0.01355277f, 0.01681950f, 0.55198830f, -0.17325278f, 0.09346930f, 0.01134024f, 
    -0.08778457f, -0.00861361f, 0.11469558f, 0.08500107f, -0.03421799f, 0.03206829f, -0.04735182f, 0.07099306f, 
    0.06206440f, 0.15799136f, 0.15359262f, 0.15453586f, 0.14800036f, -0.00559386f, 0.06024518f, -0.00374840f, 
    0.09874030f, -0.05082968f, 0.00159259f, 0.04876177f, 0.20893776f, -0.24609423f, 0.00711179f, 0.02878712f, 
    -0.01475244f, -0.03448260f, -0.07309914f, -0.07046834f, -0.12525257f, -0.15388095f, 0.08449664f, 0.05207836f, 
    -0.08124982f, 0.17808375f, -0.19268987f, -0.09697430f, 0.09619565f, -0.02412908f, 0.01869793f, 0.20850556f, 
    0.04498743f, 0.02192757f, 0.01128832f, -0.06524780f, -0.00933682f, -0.13512731f, -0.18971048f, 0.01262862f, 
    0.11171797f, -0.05453260f, -0.13662004f, -0.00698175f, -0.05806677f, -0.02455781f, -0.06540773f, -0.02751266f, 
    -0.22872202f, -0.20741969f, -0.03917889f, 0.10324795f, -0.00396615f, -0.14010784f, -0.04256357f, 0.06027801f, 
    -0.02232837f, 0.02038665f, 0.02831030f, -0.03371722f, -0.25094834f, 0.00748293f, 0.00379040f, -0.06477446f, 
    0.00834741f, 0.01813060f, -0.00844201f, -0.03974071f, 0.00766620f, 0.03641826f, -0.00472981f, -0.04479779f, 
    -0.05189802f, -0.28970867f, 0.05056614f, 0.02688646f, 0.01176976f, 0.03671897f, -0.00781846f, -0.00123977f, 
    0.04942830f, 0.05718899f, -0.00916487f, -0.00214995f, 0.23316328f, 0.10133091f, 0.19431499f, 0.04406303f, 
    -0.05428266f, 0.12179054f, -0.05488852f, -0.06868973f, -0.03608974f, -0.03443950f, -0.04422803f, -0.02428479f, 
    -0.15866205f, -0.05550041f, -0.09690989f, -0.29687694f, 0.10980193f, 0.01046319f, -0.00158269f, 0.11459918f, 
    0.00812413f, 0.20088901f, -0.03053373f, -0.03099192f, -0.27642915f, 0.21819739f, -0.14075342f, -0.01017775f, 
    -0.08396039f, -0.13859569f, 0.13520506f, 0.19004983f, 0.09540238f, -0.05075213f, 0.01313422f, -0.04754590f, 
    0.09358452f, 0.01054356f, -0.04926588f, -0.06247783f, 0.15648577f, 0.12102383f, -0.07318473f, -0.04286430f, 
    0.03269083f, -0.00692659f, 0.02711207f, 0.02429198f, 0.08890349f, 0.16341498f, 0.02068110f, -0.17578262f, 
    -0.03045963f, 0.11047832f, -0.10159153f, 0.08150125f, -0.14040932f, 0.00231061f, -0.04753996f, 0.06114630f, 
    -0.04906683f, 0.15729685f, -0.06377502f, -0.16895078f, -0.01701072f, 0.06998263f, -0.00743515f, -0.05919294f, 
    -0.07523204f, 0.02055377f, 0.14822187f, 0.06772463f, -0.19242695f, 0.13871428f, -0.03809599f, 0.10723059f, 
    0.04867143f, -0.10373317f, 0.09305795f, -0.05657388f, 0.06274169f, 0.04966274f, -0.01766935f, -0.03384663f, 
    0.00020665f, 0.14769284f, 0.04059978f, -0.26153487f, 0.05979542f, 0.09138174f, 0.02534603f, -0.01884218f, 
    -0.00235521f, 0.02262503f, 0.13957511f, 0.08860069f, 0.78225070f, -0.25041926f, -0.03899169f, 0.08592781f, 
    -0.09395521f, 0.02753107f, 0.07957970f, 0.03515387f, 0.00377531f, -0.01928029f, 0.07561962f, 0.07164210f, 
    -0.42609388f, -0.00443898f, -0.04375909f, 0.03488081f, 0.18403015f, 0.10572094f, 0.08819091f, 0.13738500f, 
    0.09716644f, 0.02207292f, 0.00542992f, -0.04381182f, 0.21812841f, 0.02140881f, 0.09267887f, -0.17115758f, 
    -0.00770921f, -0.02660173f, -0.00243217f, -0.12338346f, -0.00231053f, -0.00693046f, 0.07948682f, -0.02146954f, 
    -0.00622655f, 0.19310942f, 0.05321749f, -0.08111058f, -0.12021895f, 0.02531954f, -0.07096384f, -0.10346775f, 
    0.03286370f, -0.03154928f, 0.02960271f, -0.02025878f, 0.34035879f, 0.05205690f, -0.14289859f, 0.19331314f, 
    -0.08255149f, -0.02547289f, 0.13187893f, -0.07403553f, -0.02148858f, 0.03584287f, 0.02206796f, -0.04527733f, 
    0.21764570f, -0.25580692f, -0.21421541f, -0.12142592f, -0.02800465f, 0.08133351f, -0.06160080f, 0.03085322f, 
    -0.16292627f, -0.07921470f, 0.14215097f, -0.07319216f, 0.44809031f, 0.00931888f, 0.08704675f, 0.03816448f, 
    -0.08899357f, -0.09304886f, -0.00070267f, -0.07080108f, -0.00049980f, -0.07062693f, 0.00013419f, 0.02604378f, 
    0.22510144f, 0.11604472f, 0.22838700f, -0.03647744f, -0.08753665f, 0.02311892f, 0.06242601f, 0.01664725f, 
    -0.12894890f, -0.09303090f, -0.00877052f, 0.04639555f, 0.31320435f, 0.10206975f, -0.25956917f, 0.08683529f, 
    0.09635364f, -0.05832038f, -0.04151688f, 0.05959918f, -0.10836411f, 0.09173326f, -0.06451026f, 0.10307878f, 
    0.33336383f, -0.05631233f, -0.16271143f, -0.10518212f, 0.12256910f, 0.05113740f, -0.02552501f, -0.10578249f, 
    0.01312259f, 0.03239044f, 0.20426902f, 0.09311935f, 0.35395306f, 0.10568897f, -0.10044556f, -0.10922351f, 
    0.02027434f, -0.02627998f, 0.00985069f, -0.05729326f, -0.03844165f, 0.04725963f, 0.05178444f, -0.07677056f, 
    0.83526027f, -0.24869882f, 0.00794650f, 0.30638406f, -0.07306497f, 0.00872059f, -0.01017925f, -0.02332117f, 
    0.04830113f, 0.02253364f, 0.02707233f, -0.02315643f, -0.16523090f, 0.05191609f, 0.08094780f, 0.21667957f, 
    0.13563609f, 0.01955159f, 0.13821536f, 0.12330627f, 0.10865169f, 0.16031054f, -0.07170133f, 0.16943993f, 
    -0.18996091f, 0.02482282f, 0.01029515f, -0.14218260f, 0.12812662f, -0.00744829f, -0.06854991f, 0.02579038f, 
    -0.01760208f, 0.06421664f, 0.00334279f, -0.06238700f, 0.05295831f, 0.12018142f, 0.16134451f, 0.19385597f, 
    0.24368358f, -0.02625536f, -0.11229690f, -0.05187375f, 0.05351859f, -0.04015483f, -0.00769851f, -0.04814868f, 
    0.18129849f, 0.09119871f, 0.00386211f, -0.29909724f, 0.21528311f, 0.05904583f, -0.03434972f, 0.08744726f, 
    -0.05812370f, 0.07639833f, 0.03039132f, -0.07542973f, 0.00774509f, -0.00300313f, 0.11113999f, -0.13732751f, 
    0.03971162f, 0.08401764f, 0.05824142f, 0.09029137f, -0.10398812f, 0.11307139f, 0.04170379f, -0.01742220f, 
    0.20715435f, 0.08701760f, -0.04670772f, -0.05127507f, 0.06987184f, 0.08190083f, 0.03029193f, -0.03144276f, 
    -0.11759627f, -0.02981292f, -0.04829658f, 0.08179981f, 0.07276843f, -0.07370809f, -0.23881266f, 0.00858159f, 
    0.06077369f, 0.08212028f, -0.11723438f, -0.05143650f, -0.13286841f, 0.02823400f, -0.05849529f, 0.00984770f, 
    -0.19480355f, 0.19251481f, 0.08018414f, -0.02548124f, 0.06360243f, 0.02492278f, 0.02743196f, 0.06184286f, 
    0.11210094f, 0.00196035f, 0.04422285f, 0.09557504f, 0.00389022f, -0.19164233f, -0.41040856f, -0.16026023f, 
    0.22482780f, -0.07502264f, 0.01756836f, -0.09263203f, -0.01576023f, -0.01083081f, 0.04543863f, -0.15828757f, 
    0.01413666f, 0.02061293f, -0.02128620f, -0.01072018f, 0.01369837f, 0.02067104f, -0.03567661f, -0.00348368f, 
    -0.02338695f, 0.02202452f, -0.02377078f, -0.03570888f, 0.02466958f, 0.02107371f, -0.04025341f, 0.01953821f, 
    -0.01335184f, -0.03707406f, 0.00750388f, -0.03139327f, -0.03956211f, 0.00682150f, 0.00500957f, 0.01293933f, 
    -0.01386420f, -0.02274301f, -0.01452632f, 0.00742070f, -0.02883278f, 0.00434626f, 0.00045001f, -0.00423315f, 
    0.01099638f, 0.01361572f, -0.01746858f, -0.04186266f, -0.00743624f, -0.02698487f, -0.04413841f, -0.00189869f, 
    0.01066749f, -0.02815033f, -0.01894759f, 0.00464431f, 0.00406167f, -0.02335784f, -0.01524253f, 0.00294209f, 
    -0.00460406f, 0.00672318f, -0.01196921f, -0.02449371f, -0.00414341f, -0.04084391f, 0.00690304f, 0.00370401f, 
    0.03135812f, -0.03527232f, 0.01053086f, 0.02502567f, -0.00783084f, -0.02778977f, -0.03651553f, -0.01543677f, 
    -0.03499378f, -0.00372427f, 0.01734822f, 0.00644543f, 0.02868547f, -0.01738157f, 0.02275983f, 0.00801870f, 
    0.02087932f, 0.01505054f, -0.02223017f, 0.00800948f, -0.02129314f, -0.02889572f, -0.02500145f, -0.02270694f, 
    0.01275384f, -0.03649056f, 0.01845603f, 0.01715855f, -0.03697246f, 0.00590484f, -0.04282696f, -0.00414719f, 
    0.00487946f, 0.01345617f, -0.01014017f, 0.01075554f, -0.00088540f, 0.01183002f, -0.01296406f, 0.02088462f, 
    0.00037081f, -0.02362267f, 0.01984193f, -0.02520288f, 0.00275465f, 0.00958192f, -0.00546431f, 0.00455360f, 
    -0.03956960f, -0.00877973f, -0.01079848f, -0.04083521f, 0.00710428f, -0.00313777f, -0.02701590f, -0.00311838f, 
    -0.03724399f, -0.00770296f, -0.02423388f, -0.01265163f, -0.03401686f, -0.00928382f, -0.02887288f, -0.00814123f, 
    -0.03318615f, -0.01807483f, -0.03597932f, -0.02017153f, 0.01420237f, -0.03306055f, -0.00237693f, -0.00766850f, 
    -0.02357387f, -0.00085398f, -0.03350774f, 0.00799381f, 0.01117448f, 0.02604074f, -0.00885756f, 0.02397017f, 
    -0.02693341f, -0.01956984f, -0.03928203f, -0.01612822f, -0.01133457f, 0.02494518f, -0.04036736f, 0.02396310f, 
    0.00593114f, -0.03029696f, -0.03477954f, 0.01994609f, -0.02242537f, -0.00521391f, 0.00106375f, 0.00456656f, 
    -0.03837366f, -0.03930489f, 0.00899252f, -0.03605916f, 0.00770766f, -0.04133125f, 0.01250322f, 0.02514940f, 
    -0.00360508f, 0.00115837f, -0.03240244f, 0.01670720f, -0.01972601f, 0.02059549f, -0.01096382f, -0.00346686f, 
    0.02032119f, 0.01553423f, -0.00294036f, 0.00713234f, -0.02106967f, 0.01797444f, -0.02860701f, -0.04097220f, 
    -0.03183727f, 0.00723332f, -0.01249890f, 0.00557538f, -0.03887102f, -0.00748949f, 0.01574682f, 0.02607835f, 
    -0.04142316f, 0.02545987f, 0.01156642f, -0.03730030f, -0.00821203f, -0.00832822f, -0.00243749f, 0.00381378f, 
    0.00091597f, 0.01243526f, 0.00588947f, 0.01553084f, -0.04026830f, -0.03098772f, -0.02063387f, -0.01063736f, 
    -0.03168436f, -0.03629179f, 0.00650946f, -0.01796329f, -0.03225632f, -0.01837246f, 0.01617469f, 0.02444286f, 
    -0.02469914f, 0.02610522f, -0.02354458f, -0.03837527f, 0.04000054f, -0.02533310f, -0.01948817f, 0.02562825f, 
    0.01800014f, -0.00628798f, -0.01471622f, -0.01619700f, 0.00542910f, -0.02552556f, -0.01932661f, -0.02220701f, 
    -0.00464339f, 0.00473289f, 0.01887614f, 0.01876632f, 0.01785952f, -0.03234462f, -0.02482878f, -0.00292934f, 
    0.01188091f, -0.04168881f, 0.01794466f, -0.03426164f, -0.03525459f, 0.01781903f, -0.02857070f, -0.04223657f, 
    0.01861217f, -0.02036900f, -0.01103638f, -0.00050755f, 0.02345734f, 0.00186103f, -0.02412969f, 0.00054326f, 
    0.01555796f, -0.04146590f, -0.02491449f, -0.03932885f, -0.03009241f, 0.02278945f, -0.01508276f, 0.00908320f, 
    0.00889378f, 0.01127216f, 0.00313961f, -0.03179525f, -0.02913346f, -0.02916097f, 0.00867469f, -0.03108843f, 
    0.00253481f, 0.01956844f, -0.02582369f, 0.02255691f, 0.00150810f, -0.04105176f, -0.03693333f, -0.02432434f, 
    -0.03389750f, -0.00273911f, 0.00583407f, 0.00945380f, 0.02516189f, -0.02484884f, 0.00125238f, -0.00141778f, 
    -0.01105034f, -0.02090846f, 0.00258161f, -0.03279863f, -0.00576527f, -0.01020751f, -0.01328725f, 0.02798338f, 
    -0.03092473f, 0.01550871f, 0.00953307f, -0.03734312f, -0.00610046f, -0.02402990f, 0.00579312f, -0.00086901f, 
    -0.01809977f, 0.00704557f, -0.00317794f, -0.02006270f, -0.01351710f, -0.00624180f, 0.02646846f, -0.02831458f, 
    0.02313569f, -0.01416429f, -0.03728746f, 0.00426905f, -0.02146377f, -0.01979697f, 0.01581787f, 0.01810279f, 
    -0.01244807f, -0.03699523f, -0.01528101f, -0.03725133f, 0.02352722f, -0.02711560f, 0.00073488f, 0.00501604f, 
    0.00896684f, 0.02644549f, -0.01302380f, -0.01206741f, 0.02695049f, -0.00001378f, -0.01724188f, -0.03143232f, 
    0.02432235f, 0.01429374f, 0.00476454f, -0.01653730f, -0.00034727f, 0.02604738f, 0.01821023f, 0.00011690f, 
    -0.00124808f, 0.00801895f, 0.01829375f, 0.01218643f, 0.00773491f, -0.03804399f, -0.02236474f, 0.00650776f, 
    -0.02400777f, -0.03950657f, 0.01319143f, 0.02409005f, -0.00475590f, 0.02132139f, 0.02673471f, -0.03576498f, 
    -0.01955220f, 0.00436238f, 0.02144757f, 0.00208029f, 0.00419592f, 0.00092671f, -0.00927401f, 0.00982980f, 
    -0.00352361f, 0.02733926f, 0.01120705f, 0.02460476f, -0.03566189f, 0.02053003f, -0.01143515f, -0.03335991f, 
    -0.01115312f, -0.01018836f, -0.02753012f, 0.00750067f, 0.02361351f, 0.02554410f, -0.01844306f, -0.00548865f, 
    0.01540834f, -0.00550134f, -0.00219275f, -0.02675709f, -0.01757287f, -0.03610269f, 0.00036272f, 0.00273181f, 
    -0.01561486f, -0.02143288f, -0.02074165f, -0.00892395f, -0.02719081f, 0.02474584f, -0.03176298f, 0.00759270f, 
    -0.00995613f, -0.00336021f, -0.01897573f, -0.01682080f, -0.02713306f, 0.00138602f, 0.02047610f, -0.01094755f, 
    -0.00170091f, -0.00715902f, -0.04215216f, -0.04143719f, -0.02219215f, 0.01083448f, 0.01999922f, 0.00078379f, 
    -0.00825870f, 0.02561409f, -0.01789909f, 0.02356857f, -0.01721874f, -0.01193502f, -0.02608586f, -0.02702972f, 
    -0.01521486f, -0.02130329f, -0.01953065f, -0.00539383f, -0.02722559f, -0.03629930f, 0.01215766f, -0.01337480f, 
    0.01089927f, -0.01399544f, 0.00960016f, 0.02685156f, 0.00515456f, 0.01434345f, -0.02150882f, 0.01632289f, 
    -0.00250966f, 0.01607245f, -0.03480018f, 0.02666289f, -0.03167268f, 0.01443682f, -0.03068816f, -0.03737798f, 
    -0.00491062f, -0.02990201f, -0.02643144f, -0.00521409f, -0.02123845f, 0.01780699f, -0.02954349f, -0.01260515f, 
    0.02225138f, -0.01378685f, 0.02364164f, -0.01911353f, -0.01789821f, -0.02507650f, -0.01948000f, -0.00908396f, 
    0.00795093f, -0.00715148f, 0.01669757f, 0.01267952f, -0.04408597f, -0.02839939f, -0.01393202f, -0.00223383f, 
    0.01505847f, -0.03780594f, 0.00887859f, -0.00758385f, 0.01827437f, -0.02606893f, -0.03599951f, -0.02059868f, 
    0.01987451f, -0.01395359f, -0.02589782f, -0.03587382f, 0.00490062f, -0.04286271f, -0.02740038f, -0.02170058f, 
    0.01603012f, -0.03578882f, 0.01743902f, 0.00046186f, 0.01244507f, -0.02485982f, -0.00575643f, 0.02180677f, 
    -0.01793895f, -0.01232305f, 0.00293504f, -0.00483829f, -0.04320749f, 0.02085485f, -0.00506104f, -0.02159562f, 
    -0.03768802f, 0.02742992f, -0.01395122f, -0.03419890f, 0.00104715f, 0.01215126f, -0.02729269f, 0.00773683f, 
    -0.01245004f, 0.01484437f, -0.02186015f, -0.01199583f, -0.02900203f, -0.00907214f, -0.00483604f, 0.01011480f, 
    0.00421763f, -0.00797267f, -0.00307536f, -0.02866234f, -0.03792180f, -0.04442623f, -0.04012502f, -0.03646650f, 
    -0.04169973f, -0.03409580f, 0.00925790f, -0.03747552f, 0.00130803f, -0.03123893f, -0.04057143f, -0.03923436f, 
    0.01859345f, -0.01966695f, -0.00246864f, 0.02633539f, 0.00208082f, 0.02097947f, -0.03490796f, 0.01280772f, 
    -0.01689506f, -0.01532987f, 0.02321692f, 0.00904344f, -0.00398377f, 0.01520793f, -0.02898233f, 0.01027298f, 
    0.01934573f, 0.00995966f, 0.01736598f, -0.01234374f, -0.01901539f, 0.02584630f, 0.01113730f, 0.01970889f, 
    0.01540499f, 0.00851250f, -0.04126559f, -0.03954677f, 0.01040885f, -0.01001931f, -0.04063344f, 0.01541148f, 
    -0.00156287f, 0.01099685f, -0.02322403f, -0.00150369f, -0.02918899f, -0.01233217f, -0.01061733f, -0.00014684f, 
    -0.02047740f, 0.02844876f, -0.00392195f, -0.04376220f, -0.01821584f, 0.02210937f, 0.01251953f, -0.00958318f, 
    0.02431788f, 0.00013031f, -0.01867708f, 0.01289643f, -0.01367525f, -0.02447551f, -0.04295398f, 0.00327315f, 
    0.01428958f, -0.01178988f, -0.00693252f, -0.01001368f, 0.00114089f, -0.03624563f, -0.02624690f, -0.04110366f, 
    0.02065284f, 0.02556530f, -0.04230243f, -0.00310303f, -0.02473348f, -0.02369981f, 0.01499088f, 0.00136314f, 
    0.01568252f, 0.02732713f, 0.01376540f, -0.01406856f, 0.00914255f, 0.00260169f, 0.02751046f, -0.02309087f, 
    0.01366195f, -0.02278198f, 0.01457649f, 0.01397112f, -0.01566645f, -0.03169822f, -0.04047780f, 0.02794906f, 
    0.00031869f, -0.03114194f, 0.01405624f, 0.01677660f, -0.00765523f, 0.01454221f, -0.02497089f, -0.00771843f, 
    0.00311058f, 0.01201817f, -0.02939925f, 0.01107469f, -0.01102166f, 0.01477521f, -0.01125525f, -0.04037965f, 
    -0.04065957f, -0.02834324f, -0.02817136f, -0.00731239f, -0.04150144f, -0.03753413f, 0.01018885f, 0.02292161f, 
    -0.01073846f, -0.03834083f, -0.02611567f, -0.01257662f, 0.01204714f, -0.02844669f, -0.00388206f, 0.02411363f, 
    -0.00551149f, -0.02089582f, 0.01947431f, 0.02405096f, 0.01512203f, 0.01986748f, -0.03800027f, -0.00384554f, 
    -0.04388441f, 0.02241415f, -0.02253739f, -0.01116811f, 0.01217523f, 0.02523905f, -0.01295637f, 0.01671278f, 
    -0.04047892f, 0.00453410f, -0.01757098f, 0.01219898f, -0.03321596f, 0.00889426f, 0.01473374f, 0.01603424f, 
    -0.00805081f, -0.00290698f, -0.01052077f, -0.02401063f, 0.00855480f, 0.01951020f, -0.03568014f, 0.01420313f, 
    -0.02378978f, -0.04106772f, -0.01637292f, -0.02390492f, 0.02618330f, 0.00346437f, 0.00909249f, -0.00137151f, 
    0.01139666f, 0.02285425f, -0.02836202f, -0.04012815f, 0.01104920f, 0.00887701f, 0.00682992f, -0.00159162f, 
    -0.03368989f, -0.01061855f, -0.02506602f, 0.01862768f, -0.02527356f, -0.01283690f, 0.00780171f, -0.00926682f, 
    0.01559713f, -0.02469806f, 0.02350148f, -0.00821763f, 0.00904320f, -0.01913328f, 0.02422006f, 0.01313806f, 
    0.00424883f, 0.02831350f, -0.02092802f, -0.02728322f, -0.02072091f, -0.01415463f, -0.01488867f, -0.02740864f, 
    0.02108188f, 0.02029377f, -0.02601755f, -0.02936619f, -0.03753307f, -0.03565349f, -0.01215137f, 0.01953040f, 
    -0.02339716f, -0.02433308f, -0.00374564f, -0.00554814f, 0.01864121f, -0.02563534f, -0.03262422f, 0.00079976f, 
    -0.02940763f, -0.01646693f, 0.01251926f, 0.01569572f, 0.00921323f, -0.00264429f, 0.02849636f, 0.00877891f, 
    0.01629077f, 0.02030908f, -0.00338669f, 0.01437861f, 0.03592805f, 0.01067119f, -0.02154059f, -0.03053094f, 
    -0.00666855f, -0.03645162f, -0.03508947f, 0.01412826f, -0.03037220f, 0.01308391f, 0.01638833f, 0.02018244f, 
    -0.03127936f, -0.02775464f, 0.02283426f, -0.00614587f, -0.00567064f, -0.01087183f, -0.03959312f, -0.04043370f, 
    0.17013721f, 0.05611268f, -0.06748594f, -0.22390381f, 0.01202655f, 0.09740386f, -0.08417156f, 0.02975538f, 
    0.09519547f, 0.04149409f, -0.14001183f, 0.07821070f, -0.01646939f, 0.13221291f, 0.19553298f, -0.10348892f, 
    -0.15502198f, 0.24671648f, 0.05864028f, 0.04972976f, -0.08203301f, -0.13312657f, -0.03686821f, -0.13397473f, 
    0.22830857f, -0.31827611f, 0.09140699f, 0.16789933f, 0.15195611f, 0.03405654f, -0.02592575f, -0.16772482f, 
    0.06824341f, 0.07390358f, 0.02451101f, -0.03332443f, -0.20014757f, 0.06964155f, 0.09542648f, -0.32323951f, 
    0.16429974f, 0.08472458f, 0.00866390f, 0.00169578f, 0.04990789f, 0.10162108f, -0.10260045f, 0.06748324f, 
    0.02408654f, 0.01682291f, 0.05716207f, 0.21854223f, -0.02822117f, 0.06174717f, -0.03665137f, -0.00898240f, 
    -0.16109020f, 0.00723736f, 0.20894361f, -0.11807279f, 0.15954910f, 0.19853726f, -0.11702054f, 0.25980434f, 
    0.03296237f, -0.05168157f, -0.17356268f, 0.06431091f, -0.19308910f, -0.02318764f, 0.05090088f, -0.01699766f, 
    0.17210382f, -0.01794764f, -0.04496533f, 0.06932393f, -0.03893025f, -0.05074170f, 0.17337199f, 0.11305124f, 
    0.07305084f, 0.00984669f, -0.12648319f, -0.07711332f, 0.20392546f, 0.10922112f, 0.02811878f, -0.06292374f, 
    0.09503514f, 0.04234383f, 0.02598681f, -0.12776712f, 0.08666213f, 0.03545385f, -0.05788930f, -0.14916019f, 
    -0.34808421f, -0.27507004f, 0.03230784f, 0.27376401f, 0.04041645f, -0.05218944f, -0.02340135f, 0.17966756f, 
    -0.05634576f, 0.08337399f, 0.08010144f, -0.11509383f, -0.13771853f, -0.21172701f, -0.14541095f, -0.07737930f, 
    0.11433288f, 0.01354901f, -0.03731697f, 0.04242351f, -0.24734466f, -0.02989529f, 0.01449341f, -0.01964565f, 
    0.10698713f, 0.26319903f, -0.10175646f, 0.36101004f, 0.02867926f, 0.02845144f, -0.01728060f, 0.13019441f, 
    0.06522328f, 0.01391834f, 0.29258829f, 0.16593246f, 0.07980297f, -0.00351380f, -0.10353557f, 0.10196132f, 
    0.04601892f, -0.03446141f, 0.03150913f, 0.14817116f, 0.01846977f, -0.00324780f, 0.06545309f, 0.05980562f, 
    -0.17456363f, -0.09953212f, 0.03718227f, 0.01491584f, -0.11462785f, 0.11094739f, 0.17732485f, 0.07438196f, 
    0.02361765f, -0.02601997f, 0.03744081f, 0.06969075f, -0.26754653f, -0.18934141f, -0.44503042f, 0.17256175f, 
    -0.02309264f, 0.02263579f, 0.11951970f, 0.06915738f, 0.01230908f, -0.03545282f, 0.14265318f, 0.05026597f, 
    0.27275473f, 0.10054699f, -0.17976923f, 0.18401472f, -0.02045039f, 0.16429052f, 0.00584420f, 0.09891525f, 
    0.11902264f, 0.05889187f, -0.19915725f, -0.01977032f, 0.41256633f, -0.16176224f, 0.03191112f, 0.11961462f, 
    0.00960487f, -0.04196171f, 0.03643832f, -0.09510276f, 0.05005578f, -0.01270498f, 0.03066054f, 0.05073339f, 
    -0.21043570f, 0.11676913f, -0.14242195f, -0.23811118f, 0.17554481f, 0.05550433f, -0.02348299f, -0.03114083f, 
    0.11381534f, -0.02279439f, 0.16096579f, 0.03632861f, -0.05081317f, 0.19474196f, -0.06002529f, 0.06582357f, 
    0.01500448f, -0.02941555f, -0.02543317f, -0.08165526f, -0.01726231f, -0.04501319f, 0.16680986f, 0.14029588f, 
    -0.40018767f, 0.38524771f, -0.01563728f, 0.21254934f, 0.01730146f, 0.11906074f, 0.07043508f, -0.00468386f, 
    0.18216102f, 0.05724122f, 0.09604561f, 0.17181259f, 0.09356849f, -0.05522531f, -0.09036446f, 0.14274533f, 
    -0.08664817f, 0.05294251f, 0.04259833f, 0.17742787f, 0.04895704f, 0.11120250f, 0.09657663f, 0.07792286f, 
    0.18977590f, -0.16535628f, -0.07428607f, -0.14997624f, 0.00467881f, 0.14172618f, -0.07535866f, -0.00030831f, 
    0.03689169f, 0.12364004f, -0.05654756f, 0.34749627f, 0.03800613f, 0.07331850f, -0.11650062f, 0.02229409f, 
    0.10347228f, 0.03215894f, -0.04705551f, 0.00624922f, -0.07025962f, 0.03566993f, -0.08270101f, -0.06076414f, 
    -0.07158000f, -0.13189855f, 0.02636357f, -0.00531056f, 0.09359010f, -0.06926139f, 0.13227531f, -0.07480910f, 
    -0.02667862f, -0.00351457f, -0.24864012f, -0.04034417f, -0.19830516f, 0.21768236f, 0.04428346f, -0.23159665f, 
    0.13992152f, 0.02578401f, 0.10859908f, -0.00797638f, 0.05389795f, 0.23249340f, -0.22937007f, 0.31165043f, 
    0.15403074f, -0.02768913f, 0.21225776f, -0.06272378f, 0.20077124f, -0.02445471f, -0.08386970f, -0.10316695f, 
    0.01709562f, -0.01392781f, -0.10809707f, -0.04423824f, -0.07883570f, 0.16595843f, 0.20536047f, -0.33759132f, 
    0.06874421f, 0.11414219f, 0.01757527f, -0.01037606f, -0.01054566f, 0.11256848f, 0.03424458f, 0.06277623f, 
    -0.02426238f, -0.22998784f, 0.21038356f, 0.28359926f, 0.16926195f, 0.01315392f, 0.00813651f, -0.09340725f, 
    0.18465883f, -0.03210716f, 0.03313119f, -0.08185762f, -0.34342128f, -0.01539577f, 0.14453888f, 0.20472090f, 
    0.06291942f, 0.04280055f, -0.03470240f, 0.03635602f, 0.05982761f, -0.10165104f, 0.01063954f, -0.01388302f, 
    -0.69360226f, 0.15222545f, 0.05255874f, 0.00513918f, -0.11082113f, 0.09830905f, 0.16008344f, 0.05127914f, 
    0.00244411f, 0.08259713f, -0.04481740f, -0.04244940f, -0.23595774f, 0.07755132f, -0.05562414f, -0.23183277f, 
    -0.01404586f, -0.05732003f, 0.05184357f, 0.11724260f, 0.10661295f, 0.08802951f, 0.01870761f, 0.10251822f, 
    0.06177594f, 0.12868203f, 0.00598393f, 0.30638865f, -0.10829549f, -0.11216491f, 0.01361295f, 0.17730056f, 
    0.02587098f, 0.01412983f, 0.05770497f, 0.03485038f, -0.10093795f, -0.14860553f, -0.23312393f, -0.17398110f, 
    0.05982338f, 0.07935866f, 0.08972416f, -0.01438031f, -0.09205065f, -0.04714741f, -0.05749059f, 0.04347368f, 
    -0.06272661f, -0.09057711f, -0.04782348f, 0.25741515f, 0.13684645f, 0.05942056f, -0.01423425f, 0.00523460f, 
    0.02989195f, 0.06477665f, 0.02268579f, 0.02243379f, -0.13347337f, 0.19759037f, -0.23969048f, -0.33054149f, 
    0.22385299f, 0.07098642f, 0.11114056f, -0.01466007f, 0.00633231f, -0.10642793f, 0.01824112f, 0.01389503f, 
    -0.13860217f, 0.12243120f, 0.13054389f, -0.07182049f, 0.13807084f, -0.06520349f, 0.01660578f, -0.03737717f, 
    0.16391206f, 0.08297689f, -0.19265825f, -0.11710391f, -0.05285754f, 0.01790882f, 0.14131017f, 0.21704920f, 
    0.00380070f, -0.09634953f, -0.00205598f, -0.04617418f, 0.04994376f, -0.03201263f, -0.01944308f, -0.00101439f, 
    -0.22013085f, 0.26549342f, -0.06971518f, -0.03737732f, 0.17952979f, -0.04012083f, 0.15820803f, -0.03487676f, 
    0.08504887f, -0.11693944f, 0.01813609f, -0.06837211f, -0.09581126f, 0.39564946f, 0.02610521f, 0.07827847f, 
    0.02002739f, 0.09575927f, 0.10478335f, 0.07660562f, 0.01257058f, 0.20965166f, 0.12566005f, 0.00794484f, 
    0.00377998f, -0.06833950f, -0.10259817f, 0.28055391f, 0.05325305f, -0.05906924f, 0.16078624f, 0.03862881f, 
    -0.11291650f, 0.01252600f, -0.15402910f, -0.13559705f, 0.10418250f, -0.06609025f, -0.25117838f, 0.24933282f, 
    -0.15300712f, -0.03750557f, 0.27012128f, 0.04826568f, -0.04507509f, -0.15917175f, -0.03270753f, 0.03433958f, 
    0.14216821f, -0.13348569f, 0.10804380f, 0.05566850f, 0.00212760f, -0.00679366f, 0.00797688f, -0.03603510f, 
    0.00705358f, 0.10899693f, 0.05179741f, 0.10560011f, 0.35736683f, -0.01969054f, -0.05070528f, -0.20911242f, 
    -0.01438492f, 0.14556932f, -0.15884908f, 0.07406633f, -0.10199922f, -0.07558952f, -0.06709845f, 0.12125648f, 
    -0.14333951f, 0.20994875f, -0.19924003f, -0.14521399f, 0.24868722f, 0.00561383f, -0.03751435f, -0.08025040f, 
    0.05726465f, -0.01115181f, 0.16070072f, 0.09046576f, 0.06489045f, 0.15071249f, -0.02401852f, -0.04571598f, 
    0.06097634f, -0.08400417f, 0.10736633f, -0.09352330f, -0.02698486f, -0.03640405f, 0.08809506f, -0.08881249f, 
    0.28911299f, -0.03344914f, -0.18086542f, 0.35874674f, 0.01816504f, 0.14640141f, -0.07401005f, 0.20768251f, 
    -0.01838077f, -0.00094995f, -0.00605248f, 0.18149042f, -0.13014080f, 0.08851144f, -0.12189664f, -0.40878648f, 
    0.05399416f, -0.03780577f, -0.00753343f, 0.11955327f, 0.02029769f, -0.12030576f, -0.00422419f, -0.02571417f, 
    0.33000603f, 0.20728865f, -0.06225507f, -0.02471546f, 0.03125399f, -0.06047709f, 0.02461593f, 0.01504856f, 
    -0.12787828f, -0.12774320f, 0.21471325f, -0.04302603f, -0.02772537f, -0.14621437f, 0.08451591f, 0.10381464f, 
    -0.11458237f, 0.03563910f, -0.01833453f, -0.23286086f, 0.00754488f, 0.00010873f, 0.00873769f, 0.23373695f, 
    0.00437248f, -0.24130547f, -0.01803148f, 0.18672392f, 0.02805566f, -0.03635669f, 0.10596159f, 0.11713418f, 
    -0.05523991f, 0.16975714f, 0.07603581f, -0.07672439f, 0.04020615f, 0.11321441f, 0.02561898f, -0.07324512f, 
    0.14248516f, 0.11699751f, 0.05450481f, 0.16261488f, 0.04024261f, 0.07435271f, -0.04585312f, -0.12575594f, 
    0.27288496f, -0.03657410f, -0.01075131f, -0.13834444f, -0.05144828f, 0.05031688f, -0.08095679f, 0.20108604f, 
    -0.07846459f, -0.19304840f, -0.03631365f, -0.11222266f, -0.29459459f, 0.15508409f, -0.02025975f, -0.05984416f, 
    0.21711378f, -0.03336778f, 0.04619985f, -0.03150113f, 0.07897499f, -0.04978077f, 0.04687902f, -0.04086940f, 
    0.12390021f, -0.21460688f, -0.11464866f, -0.04400931f, 0.04522541f, -0.08864682f, 0.07956620f, 0.13806963f, 
    -0.00202205f, 0.01104209f, -0.04728664f, 0.02763290f, -0.20118617f, -0.19489302f, 0.10879151f, 0.34925744f, 
    -0.10191249f, 0.00901281f, -0.01264790f, -0.03301999f, -0.02613116f, 0.12870333f, -0.05229359f, 0.09226678f, 
    -0.10021905f, -0.03859763f, -0.14102389f, 0.02069026f, -0.01164038f, -0.00420702f, -0.01235856f, 0.05864305f, 
    0.02592014f, 0.03004830f, 0.13258508f, 0.13593508f, -0.13731685f, 0.11473579f, 0.22061741f, 0.00620689f, 
    0.15109095f, 0.14160074f, 0.15788807f, -0.13490577f, -0.05526280f, -0.11302564f, 0.14961234f, -0.00888357f, 
    -0.26404208f, 0.24263719f, -0.23015355f, -0.49120513f, 0.23528506f, -0.08731756f, 0.10419013f, 0.04520480f, 
    -0.08381431f, 0.03528981f, 0.07058313f, 0.00722136f, 0.17924315f, -0.12164677f, 0.29050934f, 0.16017932f, 
    -0.03156592f, 0.11181002f, 0.00440982f, 0.09849166f, 0.05969777f, 0.06129617f, -0.02111607f, 0.06547967f, 
    0.34534806f, 0.01999987f, 0.02667072f, -0.07278148f, -0.02286082f, 0.06334885f, -0.04480121f, -0.06858274f, 
    0.02806829f, 0.07670663f, -0.12475701f, -0.06885197f, 0.12118032f, 0.18726066f, 0.01686256f, -0.13751002f, 
    0.10599909f, 0.01635795f, 0.04080146f, -0.07152059f, 0.06065377f, -0.03177037f, -0.17642254f, 0.00806425f, 
    -0.03663599f, 0.13340794f, 0.07499650f, -0.19563258f, 0.09937815f, 0.09873006f, -0.03182041f, -0.02192553f, 
    -0.10931768f, 0.02051507f, -0.02970826f, 0.14978091f, 0.24193995f, 0.08526233f, 0.13504560f, -0.04537785f, 
    0.15483305f, -0.05760936f, 0.05149278f, 0.04620162f, 0.06104918f, 0.07547302f, 0.24826124f, 0.13022655f, 
    -0.02916831f, 0.19175880f, -0.17766196f, 0.54770344f, -0.00303361f, 0.03298965f, 0.04139308f, -0.13663998f, 
    -0.08079630f, 0.00791174f, 0.02139530f, -0.15232767f, -0.18439797f, 0.14221403f, -0.16937350f, 0.12715323f, 
    0.04902644f, 0.06783944f, -0.05450391f, 0.00533070f, -0.05388791f, 0.00702155f, 0.07138781f, 0.04740811f, 
    -0.04535604f, -0.00487148f, -0.15609685f, 0.07590381f, -0.03154129f, 0.07329781f, -0.07389185f, 0.03413311f, 
    -0.07265101f, 0.05174463f, -0.06022638f, -0.04533963f, 0.03416385f, -0.33110794f, -0.23104431f, -0.34876278f, 
    0.15015113f, -0.02702686f, -0.09847128f, 0.08034787f, 0.09567053f, -0.05271438f, 0.03091397f, 0.02722135f, 
    0.22221571f, 0.03595046f, 0.09761680f, -0.27348045f, 0.10207520f, -0.05814711f, 0.05616020f, -0.08746396f, 
    0.09426422f, 0.02651639f, 0.07462987f, 0.02271761f, 0.15085886f, -0.21879131f, 0.01799569f, 0.40737680f, 
    0.11266156f, 0.03793206f, -0.02638347f, -0.05797333f, -0.01421625f, 0.01363932f, 0.13283314f, -0.02946402f, 
    -0.27963418f, -0.08061153f, 0.23051830f, 0.14996199f, 0.13145126f, 0.15367182f, 0.00089483f, 0.09775311f, 
    -0.10580963f, -0.03664485f, -0.07916243f, 0.04654690f, 0.00914794f, 0.04430993f, 0.09038540f, 0.17464934f, 
    0.05670960f, 0.04045882f, 0.00918477f, 0.18137699f, -0.00444792f, -0.11484308f, 0.07837620f, 0.07132336f, 
    -0.10850254f, 0.07363476f, 0.06829738f, -0.10232759f, 0.08889698f, -0.10269239f, -0.06302349f, 0.03256758f, 
    -0.15622671f, 0.17345777f, 0.13311660f, -0.02808355f, 0.15685131f, 0.04839533f, 0.08036845f, 0.08568973f, 
    0.03664789f, 0.07854240f, -0.08869169f, 0.16579677f, 0.06442431f, -0.15216239f, 0.00313471f, 0.00430087f, 
    -0.03754767f, 0.11500690f, 0.26515496f, 0.37230617f, -0.07183442f, -0.06057790f, 0.01344052f, 0.15391880f, 
    -0.05459698f, -0.05881219f, 0.05041646f, -0.13305165f, 0.14608605f, 0.01745238f, -0.09116868f, -0.03267923f, 
    -0.00764552f, -0.09324753f, -0.00472427f, 0.03010171f, -0.13974953f, -0.15302646f, 0.02809084f, 0.03743671f, 
    0.13650216f, 0.04061908f, 0.01557920f, 0.05176874f, 0.09281515f, -0.01436758f, 0.07745558f, 0.11491288f, 
    -0.05619552f, 0.04313212f, -0.14298213f, 0.07787076f, -0.31235480f, -0.00315197f, 0.08725267f, -0.23488060f, 
    0.02820721f, -0.07713804f, 0.00535972f, 0.00614062f, -0.08769413f, -0.02980901f, -0.04511834f, 0.05180530f, 
    0.17719536f, 0.17467773f, 0.23559695f, 0.18937890f, -0.04158157f, -0.01401986f, 0.10446434f, 0.08658497f, 
    -0.02339062f, 0.01480909f, 0.02896155f, -0.03203762f, -0.15192094f, -0.03038495f, -0.25352377f, -0.15818976f, 
    0.03109209f, 0.00024984f, 0.19120641f, -0.10803545f, -0.04661849f, -0.02966202f, 0.09128698f, -0.07016061f, 
    -0.14148559f, 0.08764733f, -0.01424268f, 0.18780985f, -0.05448994f, 0.00175696f, -0.01108040f, -0.02678986f, 
    0.25931498f, -0.01046013f, -0.08650143f, -0.01435034f, -0.27093869f, 0.29141763f, -0.03941878f, -0.11785260f, 
    0.00075930f, 0.02201548f, 0.09293639f, -0.14537655f, 0.04232215f, 0.02330518f, 0.06196363f, 0.03209294f, 
    0.57833219f, -0.27446181f, -0.11698578f, 0.18165663f, 0.15194668f, -0.09485799f, -0.06138958f, 0.00996562f, 
    -0.00418883f, 0.15142471f, -0.08387014f, -0.01594914f, 0.01559038f, 0.32133403f, 0.08871578f, -0.16971782f, 
    -0.10627962f, 0.05441836f, -0.01087264f, -0.02172339f, 0.13712478f, 0.11107627f, 0.10401805f, -0.07895351f, 
    0.26311022f, 0.23277719f, -0.08915692f, -0.18832624f, 0.00528713f, -0.09221245f, -0.07117540f, -0.00680427f, 
    -0.09274911f, 0.06391094f, 0.01644166f, -0.04263909f, -0.12221431f, -0.01800752f, 0.16531022f, -0.01844850f, 
    0.12914193f, 0.03197658f, -0.00504936f, 0.01333482f, -0.03871206f, -0.05809387f, 0.08824188f, 0.01673812f, 
    -0.16790079f, 0.34043285f, -0.02532751f, -0.25668097f, -0.03293731f, 0.08106140f, 0.01732404f, 0.04982257f, 
    0.05994589f, 0.02297445f, -0.00996662f, -0.11863401f, 0.05569600f, -0.13806055f, -0.10222244f, -0.01392048f, 
    0.09470414f, 0.09902357f, -0.01308571f, 0.05667943f, 0.06561675f, 0.11025310f, -0.00669914f, 0.03302654f, 
    -0.09175551f, 0.13144669f, -0.01679287f, 0.06081093f, -0.13440171f, -0.11771722f, 0.09934299f, -0.00705450f, 
    0.08731063f, -0.00223325f, -0.08035524f, -0.09945676f, -0.40654340f, 0.04931451f, -0.02078577f, 0.19857565f, 
    -0.04882300f, 0.04244037f, -0.02603194f, 0.01049110f, 0.09249191f, -0.02589112f, -0.07321328f, 0.00510404f, 
    0.23565884f, 0.00805050f, -0.15516178f, -0.00644229f, -0.09944563f, -0.04967674f, -0.03424837f, -0.13944930f, 
    -0.03070487f, 0.01427323f, -0.01730334f, 0.07190874f, 0.14263333f, -0.16654120f, -0.11762200f, 0.08258526f, 
    -0.08259200f, -0.05071650f, 0.03452750f, 0.00579393f, -0.03769107f, -0.01501661f, 0.02376938f, -0.03777120f, 
    0.03459037f, 0.08663284f, -0.07814729f, -0.34632728f, 0.06439072f, -0.04036263f, -0.02254737f, -0.06168422f, 
    0.11317317f, -0.02771554f, 0.11620134f, 0.03746978f, -0.03263984f, 0.23064202f, 0.26451734f, 0.30059877f, 
    -0.09267658f, -0.09620854f, -0.01717776f, 0.04171364f, -0.06283723f, 0.01227865f, 0.06721739f, -0.00232748f, 
    0.29846478f, -0.10750096f, -0.09825202f, 0.04891356f, -0.04639478f, 0.04029416f, 0.04387632f, 0.00108556f, 
    -0.08415511f, 0.12201127f, 0.04195890f, -0.09300417f, 0.11645821f, -0.20467563f, 0.06820385f, 0.15459882f, 
    0.01235958f, 0.02236592f, 0.01623924f, -0.04037288f, -0.01819977f, 0.13971342f, 0.01174415f, 0.03537875f, 
    -0.26942936f, 0.15793052f, 0.16155405f, 0.14721987f, -0.10904645f, -0.02981718f, -0.10806511f, 0.04235000f, 
    -0.12563913f, 0.02897418f, -0.08172631f, 0.06203958f, 0.15203547f, -0.07927388f, -0.08382461f, 0.24917647f, 
    0.00213346f, -0.01253113f, 0.01827319f, -0.05090097f, 0.06150739f, 0.14458467f, 0.04733570f, -0.06738950f, 
    0.11783811f, 0.30153146f, 0.02477606f, -0.26944020f, 0.03107852f, -0.03867363f, 0.02878033f, -0.05204563f, 
    0.04310250f, 0.03441770f, -0.07466695f, -0.00742643f, 0.28540111f, -0.06735767f, 0.10096436f, 0.50620252f, 
    0.06828234f, 0.08096214f, 0.00052809f, 0.04912652f, 0.01090323f, 0.01102164f, 0.03575732f, 0.03447220f, 
    0.31876385f, 0.12726198f, -0.17503589f, -0.14618859f, 0.12104293f, 0.01527404f, -0.07178538f, 0.07445741f, 
    -0.05714313f, 0.05590863f, 0.10289054f, -0.03291905f, -0.05669183f, 0.00698998f, 0.12957346f, 0.02998477f, 
    0.00969957f, -0.09987342f, 0.05197035f, 0.16421282f, -0.10060511f, -0.07751914f, 0.09020162f, 0.06640790f, 
    -0.31189004f, -0.00787231f, 0.03039160f, 0.15912022f, 0.10099851f, 0.03347847f, -0.00336120f, 0.08594765f, 
    0.09237563f, 0.08310203f, 0.03989349f, -0.09888785f, 0.10841488f, 0.14589158f, -0.07269885f, 0.08349581f, 
    -0.01798700f, -0.02848870f, -0.05003264f, -0.00373825f, 0.02304871f, -0.08808574f, 0.05205278f, 0.05435131f, 
    0.04813330f, 0.00563856f, -0.24494897f, 0.23138483f, 0.02353223f, -0.04626809f, 0.02544680f, -0.05966602f, 
    -0.05633508f, -0.03832666f, 0.03213671f, -0.10646987f, -0.14881688f, 0.02373813f, 0.13861184f, 0.46972123f, 
    -0.03593567f, -0.07628893f, -0.03450900f, -0.06142259f, -0.03100503f, 0.00934312f, 0.05255663f, -0.20479150f, 
    0.24206580f, -0.01613629f, 0.17768066f, -0.06664158f, -0.08950538f, -0.08370097f, 0.04840950f, 0.01415306f, 
    0.18023168f, -0.03684778f, 0.01839931f, 0.18220738f, -0.08699086f, 0.15393165f, 0.04640061f, -0.32759076f, 
    -0.07853107f, 0.05165264f, -0.03206193f, 0.04018077f, -0.04579895f, -0.02532440f, -0.01282205f, 0.02447023f, 
    0.21304724f, -0.08724296f, -0.08339479f, 0.30167302f, 0.15035380f, 0.00128092f, -0.04606599f, -0.10473602f, 
    0.13700965f, 0.15473166f, -0.04494541f, 0.05532348f, -0.16129439f, 0.18766062f, 0.12190685f, 0.08705692f, 
    0.04034948f, -0.00277586f, -0.00514608f, -0.08261812f, -0.00607758f, -0.03728610f, 0.04514317f, -0.03099584f, 
    0.55055279f, -0.03059883f, -0.25921801f, 0.11375520f, 0.03515972f, -0.01056288f, -0.09918298f, 0.08054484f, 
    0.02546822f, -0.00873704f, -0.01853852f, 0.07566001f, 0.10736670f, -0.14186405f, -0.01765675f, 0.20007795f, 
    0.15570576f, -0.02530002f, 0.02716441f, 0.11050482f, -0.04448816f, 0.04098402f, 0.06314325f, 0.06601360f, 
    -0.12791799f, 0.11772240f, 0.10152163f, -0.00207193f, -0.03383490f, -0.10385298f, 0.08021698f, 0.22329189f, 
    -0.09221926f, -0.06281082f, -0.00673708f, 0.25136721f, -0.11383693f, 0.05196576f, 0.16263156f, -0.03316940f, 
    -0.06943159f, 0.13311332f, 0.01895031f, 0.18671657f, 0.02117359f, -0.05154904f, -0.04641016f, -0.05031741f, 
    0.06753311f, 0.26048654f, 0.02123296f, -0.35683230f, -0.03318785f, 0.08265464f, -0.02733585f, 0.06992687f, 
    0.05167679f, -0.00396442f, 0.08546836f, -0.06655202f, 0.12719001f, 0.05946940f, 0.09502000f, -0.06061795f, 
    0.15891077f, 0.04206155f, -0.03066281f, 0.04753277f, -0.09571213f, 0.06349642f, -0.01075729f, -0.03380506f, 
    -0.04314843f, -0.02765856f, 0.09758009f, 0.08810221f, -0.12613164f, -0.06383181f, -0.05234861f, -0.02279873f, 
    0.05249777f, -0.15341210f, -0.10884525f, 0.02482804f, -0.09578559f, -0.00076411f, 0.02125179f, 0.19250438f, 
    0.15172641f, 0.04663120f, 0.03509451f, -0.05016278f, 0.03942434f, -0.03211827f, 0.03165806f, -0.03390540f, 
    0.16020289f, 0.19739261f, 0.13282412f, 0.16748515f, 0.07831350f, -0.01466284f, -0.03172573f, 0.02570149f, 
    0.08225656f, -0.08076594f, -0.02065390f, -0.10252868f, -0.29953820f, 0.08752695f, 0.40661117f, 0.30039290f, 
    0.07145292f, -0.02214856f, -0.04451328f, 0.09432708f, 0.00416996f, 0.04417917f, 0.07251201f, -0.05485783f, 
    -0.44933775f, 0.08531024f, -0.03017715f, -0.10090414f, 0.02071748f, 0.07040721f, 0.06703066f, 0.00695814f, 
    -0.02218889f, 0.03896229f, 0.04654300f, 0.01182584f, 0.26548135f, -0.13924095f, -0.12800966f, -0.15994403f, 
    0.07383029f, -0.05744366f, 0.04710181f, -0.02216015f, -0.07902950f, -0.00035730f, 0.08663623f, -0.00235593f, 
    0.40624359f, -0.03653277f, 0.11893485f, 0.17208067f, 0.11312602f, 0.03361879f, -0.03828861f, -0.02220454f, 
    -0.04960873f, -0.01987131f, 0.02419608f, -0.02347111f, 0.09731244f, -0.02407913f, -0.00464122f, -0.44132388f, 
    -0.10401621f, -0.00596087f, 0.01548876f, 0.10649984f, 0.06124954f, -0.01663560f, 0.05972520f, -0.03998699f, 
    0.01637307f, -0.15944663f, -0.22144859f, 0.04854074f, -0.01678381f, 0.08021487f, 0.06425282f, -0.04143637f, 
    0.09304670f, 0.14530493f, 0.01292169f, -0.05657546f, -0.05293974f, -0.10753816f, 0.19296612f, 0.11114626f, 
    -0.09472247f, -0.03245454f, -0.20213556f, 0.11759142f, 0.07182411f, -0.04271777f, -0.05541524f, 0.05451604f, 
    0.18500564f, 0.06975116f, -0.18198197f, 0.16117515f, 0.01829722f, -0.00541086f, 0.07244284f, 0.01642574f, 
    0.07222190f, -0.06622091f, 0.08235157f, -0.11030541f, -0.32956615f, 0.01122652f, 0.22407272f, 0.06082414f, 
    0.16909908f, 0.00540923f, -0.02803895f, -0.11295611f, 0.08393481f, -0.00499078f, -0.01468635f, 0.04436422f, 
    -0.02662805f, 0.22948496f, -0.26338050f, 0.11985014f, -0.00198325f, -0.02909702f, 0.06921228f, -0.06653306f, 
    0.11723093f, 0.07569312f, 0.10769592f, -0.11272387f, -0.07908309f, -0.01765633f, 0.17040448f, 0.22383198f, 
    -0.07125144f, 0.05502562f, -0.10978980f, -0.08034899f, -0.03786316f, 0.08570075f, 0.05165650f, -0.03365315f, 
    -0.24400012f, 0.15170051f, 0.23311563f, 0.01893803f, -0.08246510f, -0.00941526f, -0.04867865f, -0.03333831f, 
    0.10788476f, 0.01356499f, -0.00885266f, 0.07104006f, -0.41427410f, -0.09146632f, 0.16652322f, -0.21823396f, 
    0.09556951f, -0.07583575f, 0.02584163f, -0.06052253f, 0.07652935f, 0.10912798f, -0.00435164f, 0.09250116f, 
    -0.31484592f, 0.26851723f, 0.15643501f, -0.24626362f, 0.10387961f, 0.09108042f, 0.15514499f, -0.03534489f, 
    -0.08919609f, -0.01595866f, -0.02067918f, 0.04192643f, -0.17915639f, 0.07671531f, 0.29310641f, 0.00434285f, 
    0.13901532f, -0.06361542f, -0.11904403f, -0.01574243f, -0.02327631f, 0.00079572f, -0.02774316f, 0.11157170f, 
    0.12270347f, -0.26266620f, -0.06381469f, 0.04919934f, 0.02298628f, -0.03154747f, 0.13880916f, -0.09693857f, 
    0.09986135f, 0.03079301f, -0.04060816f, 0.17909791f, -0.24671076f, -0.14264086f, -0.02764923f, 0.11882706f, 
    0.23957251f, 0.10386312f, 0.00220548f, 0.06187386f, 0.17111477f, 0.02894897f, 0.13570800f, 0.12994175f, 
    0.04433933f, 0.09308968f, -0.16547787f, -0.08523161f, -0.00568321f, 0.00502368f, -0.06739078f, 0.12556186f, 
    0.02218280f, 0.02446221f, 0.09633882f, 0.05292633f, 0.07482339f, -0.19037785f, -0.06537998f, 0.11597747f, 
    0.15876850f, 0.09582369f, 0.06627205f, 0.15939261f, 0.02538145f, 0.23781721f, 0.13893934f, 0.23760538f, 
    0.22892874f, -0.07753393f, -0.00484038f, 0.16711113f, 0.00121404f, -0.04228425f, -0.02355984f, 0.14250630f, 
    0.04171088f, 0.09179144f, 0.01752408f, 0.05097865f, 0.33889756f, 0.25147536f, 0.14613090f, 0.21808432f, 
    0.14402825f, 0.13237485f, 0.00440592f, -0.05760489f, 0.14204670f, 0.15718549f, 0.03860005f, -0.03173204f, 
    -0.03105954f, -0.12526175f, -0.08743616f, -0.02696061f, 0.07866939f, 0.13497183f, 0.20423973f, -0.01840315f, 
    0.06786535f, -0.11984190f, -0.08909148f, 0.05848531f, 0.09898305f, 0.18840219f, -0.39153498f, -0.11337743f, 
    0.04704298f, 0.14548799f, -0.05631696f, -0.04726988f, -0.01693858f, 0.05525134f, 0.02876662f, 0.11089489f, 
    -0.11276404f, -0.00049224f, 0.20173150f, 0.12589790f, -0.04374890f, 0.01333852f, -0.08736417f, 0.01465391f, 
    -0.05949218f, -0.05544307f, -0.11522502f, 0.04298702f, 0.18147174f, 0.48747724f, 0.20751320f, -0.11695279f, 
    -0.03864121f, -0.11110133f, -0.11744728f, 0.01305310f, 0.05344212f, -0.04795413f, -0.07280134f, -0.02467744f, 
    -0.28584149f, -0.22571512f, 0.01438273f, -0.13076550f, 0.13710067f, -0.00503759f, 0.10422083f, 0.01872768f, 
    -0.05281418f, 0.07682349f, 0.07520740f, 0.01451729f, 0.07488479f, -0.24839009f, -0.12047950f, -0.13350518f, 
    -0.01983264f, 0.03183692f, -0.02357414f, 0.06220389f, 0.04496928f, 0.23716329f, -0.06459010f, 0.03348768f, 
    0.25169063f, -0.18198816f, 0.12458392f, 0.18014115f, 0.10676324f, -0.01958353f, 0.08320591f, -0.05105613f, 
    0.09398018f, 0.04066003f, 0.02411363f, 0.11589758f, -0.32996914f, -0.16340101f, 0.15235700f, -0.00880183f, 
    0.03727172f, 0.00856552f, 0.13058279f, -0.10839942f, 0.05407194f, 0.04906243f, 0.08486734f, -0.11692005f, 
    -0.30137751f, 0.02768261f, 0.08689360f, -0.17674661f, 0.00659035f, 0.02205283f, 0.13302973f, -0.03913539f, 
    0.07478786f, -0.13046150f, -0.03168132f, -0.13755257f, -0.05615850f, -0.15457138f, 0.05721952f, -0.09160243f, 
    0.21241431f, 0.03268989f, 0.07714033f, -0.09065720f, 0.04498722f, -0.01518160f, -0.02554767f, -0.10030840f, 
    0.32605559f, 0.03875096f, 0.12074202f, 0.03129258f, 0.07025711f, -0.02959642f, 0.07234294f, -0.00945937f, 
    -0.03685544f, -0.08250714f, -0.04353308f, -0.17512421f, 0.00620000f, 0.10499711f, 0.31086791f, -0.18512805f, 
    0.01566186f, 0.16052893f, 0.01729019f, -0.00694926f, -0.03308010f, 0.07655886f, 0.22295175f, 0.22466023f, 
    0.00536047f, 0.21746553f, 0.03979111f, -0.02272806f, 0.14612016f, 0.00700074f, 0.06567533f, 0.01315349f, 
    -0.02697694f, 0.07874666f, 0.15602136f, 0.11730821f, 0.38735911f, 0.06286034f, -0.09560940f, -0.11922587f, 
    -0.11354166f, -0.16312407f, -0.20098345f, 0.03253800f, -0.06211144f, 0.10136911f, 0.21902846f, -0.10572959f, 
    -0.21063395f, -0.00337872f, 0.27536717f, 0.11512611f, 0.03049799f, 0.23991175f, 0.07151223f, -0.01742948f, 
    0.04278536f, 0.29238436f, -0.05991170f, 0.03654511f, -0.27565902f, -0.13867538f, 0.37941584f, -0.05608860f, 
    0.06506700f, -0.08327682f, -0.13864571f, 0.11712763f, 0.02848197f, -0.03336241f, 0.16706780f, 0.13612688f, 
    -0.34318584f, -0.00485725f, 0.18235716f, -0.27935493f, 0.17507304f, 0.12977500f, 0.16857991f, 0.04494062f, 
    -0.00461350f, -0.10429926f, 0.06244528f, 0.01722703f, -0.12964524f, 0.31528556f, 0.06442802f, 0.10527447f, 
    -0.04881286f, -0.00140008f, -0.01054852f, 0.18524115f, 0.11052103f, -0.05997721f, -0.02142258f, 0.08100919f, 
    0.36941636f, 0.18873757f, 0.10662077f, 0.10914671f, 0.13367504f, -0.00739021f, 0.04765106f, 0.05604808f, 
    -0.00431542f, -0.11333825f, 0.07294868f, 0.17851718f, 0.01841911f, 0.08981489f, 0.12529044f, 0.04287192f, 
    0.04669289f, -0.08546320f, -0.14011604f, 0.07834458f, 0.01207554f, -0.18560697f, -0.08686645f, 0.13068007f, 
    0.14356054f, 0.03752829f, -0.20249008f, -0.06518506f, -0.02704849f, 0.16043960f, -0.06860910f, 0.10872563f, 
    -0.02867627f, -0.04827506f, -0.14204271f, 0.05077635f, 0.21388875f, 0.28556576f, -0.13769491f, -0.03227916f, 
    0.21122010f, -0.05269763f, -0.02123035f, 0.04714682f, 0.06231865f, 0.08390019f, -0.04937916f, 0.04543163f, 
    -0.15825574f, 0.00150417f, 0.04634180f, -0.24826105f, -0.01717778f, 0.10176943f, -0.09250211f, 0.01540182f, 
    0.14166093f, 0.10462849f, 0.22418334f, -0.02214868f, 0.02055265f, 0.26877135f, -0.02784809f, 0.03774624f, 
    0.22168604f, -0.04225153f, 0.00796315f, 0.04439385f, 0.14011794f, 0.19485846f, 0.06575773f, 0.12678492f, 
    -0.40312621f, -0.10619419f, 0.28710783f, -0.12045001f, 0.06059475f, 0.07964566f, 0.01531965f, -0.22087577f, 
    0.06664799f, 0.01151514f, 0.08923127f, -0.16065711f, -0.17237496f, 0.10016973f, 0.10478183f, -0.06074854f, 
    0.12442203f, 0.02458700f, 0.10679463f, 0.16647831f, 0.04433894f, 0.06843109f, -0.00688891f, -0.09968144f, 
    -0.10224212f, -0.19069679f, -0.01366173f, -0.14703141f, -0.00083129f, -0.01568614f, 0.04930007f, 0.06497128f, 
    0.03136008f, 0.20909302f, 0.09569170f, 0.18878716f, -0.08450356f, -0.28873709f, 0.00164055f, 0.26189134f, 
    0.01815561f, -0.07567956f, -0.01360716f, 0.15234157f, 0.09254862f, -0.12708692f, 0.12291325f, -0.09987846f, 
    0.12735771f, 0.02904115f, 0.19146980f, -0.08300880f, 0.03740545f, -0.03880316f, -0.03879618f, 0.00113560f, 
    0.01248453f, 0.21705776f, 0.12834314f, 0.07301731f, -0.07980713f, 0.05727959f, 0.18627930f, -0.02149107f, 
    0.05703528f, 0.03856160f, -0.07906785f, 0.11115629f, -0.03041009f, 0.05490568f, -0.04586754f, 0.17614494f, 
    -0.24608985f, -0.17283414f, 0.12130891f, -0.15368520f, 0.22199598f, 0.01437130f, 0.18344474f, 0.11362254f, 
    -0.01222270f, 0.05038738f, -0.02292263f, 0.02057536f, -0.15539327f, 0.00696164f, -0.07076084f, -0.09256445f, 
    0.07800830f, 0.02081832f, 0.07719873f, -0.04219110f, 0.06640746f, 0.18888021f, 0.14671113f, -0.11226404f, 
    0.16544184f, 0.18231799f, 0.39343518f, 0.04595152f, 0.12551001f, 0.02843487f, 0.07111187f, 0.09862757f, 
    -0.00116786f, 0.12368476f, 0.02943229f, -0.08064384f, 0.29890779f, -0.09026890f, -0.13471495f, -0.06411939f, 
    0.00700255f, 0.05323026f, -0.11840727f, 0.13433912f, -0.01344843f, 0.03093831f, 0.06676356f, 0.04925445f, 
    -0.33893931f, -0.17293563f, 0.18075614f, -0.19737209f, 0.07002386f, 0.02895531f, 0.20223881f, -0.02822639f, 
    -0.09172589f, 0.01094858f, 0.06137153f, 0.07464192f, 0.07516205f, -0.05001269f, 0.07040719f, 0.05548037f, 
    -0.10788346f, 0.03413161f, -0.04926214f, -0.07868416f, -0.06384368f, 0.03437105f, 0.06387051f, -0.14376561f, 
    -0.15715183f, 0.05540554f, -0.33017352f, -0.05392827f, 0.17393658f, 0.12913056f, 0.10466889f, 0.13710167f, 
    0.13142954f, 0.13985595f, 0.05648934f, 0.01951922f, 0.03319725f, -0.08795097f, -0.19517767f, -0.03709455f, 
    0.04990667f, 0.02200326f, 0.10730106f, 0.09831222f, 0.11536898f, -0.02054156f, -0.00728497f, -0.20575123f, 
    0.09479358f, -0.36429203f, -0.19062164f, -0.02242896f, 0.06382840f, -0.04660985f, -0.01091140f, -0.18864954f, 
    0.13866255f, -0.04044837f, 0.14474416f, -0.21591991f, 0.10617482f, -0.21352711f, -0.13647282f, 0.12082146f, 
    0.05728821f, 0.14679855f, -0.03971680f, 0.02950737f, -0.12921552f, -0.02170663f, 0.08133056f, -0.01747870f, 
    -0.09876683f, -0.08631653f, 0.18533526f, -0.08821121f, 0.06684357f, -0.06410374f, -0.09248813f, -0.09251269f, 
    0.15117820f, 0.13133414f, 0.09334713f, 0.11859602f, 0.08605266f, 0.02659534f, -0.01425516f, -0.00493104f, 
    0.03598158f, -0.10483691f, 0.03616478f, 0.03361234f, 0.07511432f, 0.02524548f, 0.07553469f, 0.07582376f, 
    0.47588369f, -0.06895591f, 0.17136745f, 0.09825704f, 0.04023171f, 0.07543400f, 0.01520839f, -0.08302455f, 
    -0.00046236f, -0.05158208f, 0.07258336f, 0.08127465f, 0.02730546f, 0.03477673f, -0.02399843f, 0.00318388f, 
    0.12430526f, 0.10724703f, -0.14245775f, 0.06293535f, -0.01757465f, -0.03744976f, 0.00528551f, -0.09594484f, 
    -0.03762558f, -0.04167470f, -0.17615031f, -0.17826538f, 0.02933854f, -0.04200470f, -0.09022660f, 0.02212214f, 
    0.01539589f, -0.08916603f, -0.04944447f, -0.08654732f, -0.02942041f, -0.23407182f, 0.31955403f, 0.06527358f, 
    -0.05344521f, -0.08627917f, 0.07548076f, 0.03228144f, 0.10866378f, 0.15283716f, -0.03898831f, 0.06973494f, 
    -0.01581058f, 0.21660885f, 0.10403757f, 0.17535464f, 0.07232548f, -0.02781177f, 0.09841155f, -0.00773898f, 
    0.05269778f, 0.07171158f, 0.04533619f, 0.02748872f, 0.04639024f, 0.26242015f, 0.05694930f, 0.01736402f, 
    0.10405909f, -0.00544007f, 0.18514705f, -0.10947536f, -0.18786052f, -0.02565268f, 0.10891889f, 0.04556627f, 
    -0.14551172f, 0.45796999f, 0.44822881f, -0.22363320f, 0.03003060f, 0.01861079f, 0.05413577f, -0.09148567f, 
    0.01666656f, -0.14858626f, 0.17962617f, 0.27860966f, -0.28864080f, -0.09815340f, -0.12671420f, 0.07448128f, 
    -0.02712141f, 0.05637388f, -0.06905427f, 0.07939989f, 0.12129326f, 0.02839557f, 0.24690108f, 0.26276883f, 
    -0.02170529f, 0.04991896f, 0.18455793f, 0.10919563f, 0.01104213f, -0.00992152f, 0.03626540f, 0.06748099f, 
    -0.00593574f, 0.20271125f, -0.13373101f, -0.13681842f, -0.08016425f, 0.13232255f, -0.12605248f, -0.24234469f, 
    -0.00373182f, 0.06089551f, 0.06729824f, -0.07139380f, 0.07378676f, 0.02449655f, -0.05042048f, -0.03971653f, 
    -0.19215576f, -0.38304025f, 0.28847623f, -0.20902596f, -0.03780573f, -0.10967998f, 0.08507022f, 0.14520165f, 
    0.06586292f, -0.04275909f, 0.14442170f, 0.10519692f, -0.42436144f, -0.04126458f, 0.13656567f, -0.38251844f, 
    0.02442159f, -0.10829922f, 0.17748737f, -0.04296297f, 0.02527020f, 0.07960763f, -0.10801612f, 0.06728068f, 
    -0.03104472f, -0.02971871f, -0.02657821f, -0.04502507f, -0.00273658f, 0.02989248f, -0.04004902f, 0.02298766f, 
    -0.00643538f, -0.00259555f, 0.00698907f, 0.00238547f, 0.02353043f, -0.00050084f, -0.02781904f, 0.01198841f, 
    0.02382651f, 0.00962673f, 0.02524885f, 0.02125738f, -0.04757169f, -0.03649833f, -0.02321190f, 0.00792974f, 
    -0.02226542f, -0.04109059f, 0.02292555f, -0.01998097f, 0.00510709f, -0.03330857f, 0.02538163f, 0.00578332f, 
    -0.02608049f, -0.02002524f, 0.02247059f, -0.03734246f, -0.00474041f, -0.03936875f, -0.03053858f, 0.01712011f, 
    0.00846294f, -0.01795562f, -0.01943390f, 0.02798398f, 0.00304622f, -0.01714838f, 0.00613148f, 0.02265658f, 
    -0.04501494f, 0.00396708f, -0.00373780f, 0.00076153f, 0.02264791f, 0.03270467f, 0.00926108f, -0.02720922f, 
    0.02235296f, -0.03618966f, 0.00297709f, 0.00716949f, 0.02110441f, 0.00628317f, -0.01699435f, -0.03791688f, 
    0.00152476f, 0.01782620f, 0.00664057f, -0.03429929f, -0.00664617f, -0.01301507f, -0.02964065f, -0.02339905f, 
    -0.01752399f, -0.03333136f, 0.00346090f, 0.02025143f, 0.02284285f, 0.01671602f, -0.01575724f, -0.02732153f, 
    0.00820927f, -0.03895989f, -0.03839834f, 0.02136951f, -0.00078824f, -0.01852365f, 0.01298646f, 0.00824752f, 
    0.00836449f, -0.00206832f, -0.00580334f, 0.03143243f, -0.02164346f, -0.01201931f, 0.00174541f, 0.01698177f, 
    -0.04372862f, 0.02329362f, -0.03057944f, -0.01049237f, 0.00039855f, -0.02665938f, -0.04249506f, -0.03348895f, 
    0.02426466f, -0.02142919f, 0.00609320f, 0.02556564f, -0.01490599f, -0.00188857f, -0.00006388f, 0.00104390f, 
    0.01789412f, 0.01895490f, -0.00423872f, 0.00404601f, -0.01323278f, 0.00941698f, 0.00931515f, -0.03220315f, 
    -0.01976460f, 0.00762528f, -0.03365712f, -0.00870793f, -0.03389436f, -0.03830939f, -0.00895808f, 0.03330958f, 
    0.00280356f, 0.00912472f, 0.01050475f, -0.04227630f, 0.02936397f, 0.01920462f, 0.00532482f, 0.00968497f, 
    0.00196729f, 0.01876518f, 0.01326767f, 0.00113368f, -0.03418620f, -0.00010211f, -0.04090609f, 0.02484814f, 
    -0.02420729f, -0.04272415f, -0.03242274f, 0.02799564f, 0.02765479f, 0.00833884f, 0.00968519f, -0.02026493f, 
    -0.01664821f, -0.02346563f, 0.03185172f, -0.02721682f, -0.00403223f, 0.02197928f, -0.01429482f, -0.02639254f, 
    -0.01756128f, -0.02432378f, -0.00761569f, 0.01048441f, 0.00955180f, 0.00711925f, -0.00336282f, -0.02978502f, 
    0.01289385f, 0.02304587f, -0.03399152f, 0.00198886f, -0.00603286f, -0.02285229f, -0.01344614f, -0.02404527f, 
    0.00949851f, 0.00952242f, -0.00353513f, -0.02655221f, -0.03273089f, -0.01530394f, -0.00312626f, -0.00224028f, 
    -0.02772008f, -0.02451458f, -0.03076568f, -0.02022236f, -0.00879705f, 0.01128570f, -0.01704357f, 0.01158648f, 
    0.02336617f, -0.01851426f, 0.00756596f, -0.00867234f, -0.02060952f, -0.03051192f, -0.04054431f, 0.02748235f, 
    -0.02093955f, 0.00930092f, 0.03076963f, 0.02405757f, 0.00112676f, -0.02322284f, -0.02119569f, 0.02380899f, 
    -0.02360876f, -0.03857243f, -0.00959672f, 0.00717799f, -0.03184196f, -0.00178593f, -0.03459311f, -0.00008559f, 
    -0.03643974f, -0.03092454f, -0.00112878f, 0.00433976f, -0.01431620f, 0.00460061f, -0.02121276f, 0.02754029f, 
    -0.04504501f, -0.03409109f, 0.00826348f, -0.04384139f, 0.01306663f, -0.02993472f, 0.01758625f, -0.00428325f, 
    -0.01408193f, -0.03860566f, -0.03176750f, 0.03719222f, -0.02880097f, -0.02411484f, -0.03724719f, 0.02293362f, 
    -0.01385232f, 0.01764238f, 0.01136630f, -0.01800470f, 0.02582376f, 0.00769755f, -0.01212248f, -0.02337979f, 
    0.01231234f, 0.00261031f, -0.02818637f, 0.01584076f, -0.03890649f, -0.02349786f, -0.00021950f, 0.02324817f, 
    -0.02517242f, 0.00430609f, -0.00255481f, 0.02411087f, -0.01761510f, 0.00379774f, -0.02827349f, -0.02944246f, 
    -0.02402173f, -0.04096003f, -0.00579807f, -0.02074943f, -0.00640857f, -0.03548219f, 0.00199292f, -0.01330243f, 
    0.00623120f, 0.03219391f, 0.01401897f, 0.01638695f, -0.00868168f, -0.00567955f, -0.03603416f, 0.00013650f, 
    0.00604285f, 0.00534565f, 0.02016666f, 0.02932142f, 0.02897649f, -0.04437574f, -0.00143848f, -0.00308511f, 
    -0.03745203f, -0.00633256f, -0.02895267f, -0.01355112f, -0.00639279f, -0.03512094f, 0.00015656f, -0.03325849f, 
    -0.02529703f, 0.01643945f, -0.02165858f, 0.00676854f, 0.01814344f, 0.01500834f, 0.00788278f, 0.01710197f, 
    0.01581888f, -0.03409534f, 0.03072546f, -0.02247659f, -0.02807661f, -0.00878876f, 0.01567497f, 0.00525106f, 
    0.02142310f, 0.01011206f, 0.00689230f, -0.02087648f, 0.00774220f, -0.03522258f, 0.02974963f, 0.00163058f, 
    -0.00451681f, -0.00318928f, -0.00080493f, -0.03157529f, -0.01385597f, -0.02347045f, 0.02485579f, -0.03643221f, 
    -0.01954805f, -0.00522919f, -0.02446370f, -0.02708074f, 0.00420117f, -0.01542918f, 0.01224099f, 0.01754578f, 
    0.01907882f, -0.01879259f, -0.00968617f, -0.01524005f, 0.02128455f, -0.04139455f, -0.02162595f, -0.02376581f, 
    0.00879320f, 0.00636617f, 0.01513568f, 0.01266670f, 0.02358128f, 0.02748518f, -0.03085984f, 0.02609266f, 
    0.02396680f, 0.01778526f, 0.00909107f, 0.02629562f, 0.00470535f, 0.00672657f, 0.01469263f, 0.02838397f, 
    0.02716698f, 0.01532748f, -0.03039473f, 0.03004913f, -0.03714974f, 0.00798257f, -0.03137332f, -0.01772366f, 
    -0.01347818f, -0.02737131f, -0.03125057f, 0.03100677f, 0.02987263f, 0.02933847f, -0.02363024f, -0.02437294f, 
    0.01956328f, -0.01392891f, 0.00393597f, 0.02125401f, 0.01924390f, -0.00557549f, 0.00077826f, -0.01162990f, 
    0.01140762f, 0.00706635f, -0.04187286f, 0.00462799f, -0.04277158f, 0.03037683f, -0.02421767f, -0.02686081f, 
    -0.03746569f, -0.02549728f, 0.00884702f, 0.03462090f, -0.01037276f, -0.03046340f, -0.02368254f, -0.01856066f, 
    0.02284201f, 0.00261197f, -0.01574985f, -0.00916864f, -0.02315986f, -0.02809161f, 0.02387550f, 0.00801797f, 
    -0.00971982f, 0.01631503f, -0.03120510f, 0.00857288f, 0.01670251f, 0.00532936f, -0.01186969f, -0.00608663f, 
    -0.00882504f, -0.03536692f, 0.00158033f, 0.00227181f, -0.03354967f, 0.01893925f, -0.00950486f, 0.00267516f, 
    -0.02947614f, -0.02844674f, -0.01063466f, -0.03527139f, -0.01410471f, 0.02516613f, 0.01486577f, 0.00609266f, 
    0.00332001f, -0.02234971f, -0.03588135f, -0.02213370f, -0.03098984f, 0.01231781f, -0.03797830f, 0.01054292f, 
    -0.02802545f, -0.02949777f, 0.00321444f, -0.02073264f, -0.02336857f, -0.02820516f, -0.01236931f, 0.02366364f, 
    0.02632826f, -0.00694629f, 0.02308279f, 0.01681959f, -0.02029045f, -0.00547151f, 0.01319868f, -0.04506661f, 
    -0.03309843f, -0.01004660f, 0.01213029f, 0.00247197f, -0.00470084f, 0.00870388f, -0.02425015f, 0.03067722f, 
    0.03116619f, -0.03318185f, -0.00736907f, 0.01475519f, -0.02417176f, 0.00644751f, -0.00436165f, -0.01043997f, 
    0.02464727f, -0.00524049f, 0.01166618f, -0.01441549f, 0.02414968f, -0.03304162f, 0.01504830f, -0.01978255f, 
    0.01682592f, -0.04315083f, 0.01874285f, -0.03089505f, -0.02477914f, 0.01136093f, -0.00291409f, -0.03208338f, 
    -0.02395524f, -0.02648320f, -0.03132217f, -0.03051974f, -0.02040315f, -0.01279568f, 0.00804643f, 0.00609272f, 
    -0.00532244f, 0.00659223f, -0.00720902f, -0.03778991f, 0.01498549f, 0.02359481f, -0.01548674f, -0.03989556f, 
    0.01810479f, -0.00304964f, -0.01962214f, 0.00873626f, -0.02323849f, -0.03727048f, 0.00231771f, -0.02615072f, 
    0.00814863f, 0.00081705f, -0.01775106f, -0.02263889f, 0.01391540f, 0.01982195f, -0.03956613f, -0.02942936f, 
    -0.00840510f, -0.04250997f, -0.01274631f, -0.01625067f, -0.00639192f, 0.00458002f, -0.00263656f, -0.01056139f, 
    0.01384214f, 0.01359626f, -0.02626782f, 0.00415177f, -0.03705318f, -0.03789042f, -0.03626097f, -0.03974518f, 
    -0.03246641f, -0.00428619f, -0.03269702f, -0.00557544f, -0.01188962f, 0.02646316f, 0.02105653f, -0.00869676f, 
    -0.01518391f, 0.00833049f, -0.02773196f, -0.01239299f, 0.03212340f, 0.02914526f, -0.02206747f, 0.00761328f, 
    -0.02014919f, 0.01412564f, 0.01420066f, -0.01490799f, 0.02606761f, -0.00849914f, 0.02710294f, -0.03735018f, 
    0.00890778f, -0.03024423f, 0.00011249f, -0.00510332f, 0.00157927f, 0.02368681f, 0.02363673f, -0.00644056f, 
    0.02547167f, 0.01776338f, -0.03749464f, -0.00083712f, 0.02620231f, -0.02521653f, 0.02410559f, -0.01758051f, 
    -0.00553209f, -0.01163695f, -0.00288952f, -0.02478247f, 0.01064123f, 0.02799069f, 0.01911688f, 0.00704310f, 
    0.01211527f, 0.02720431f, -0.03133337f, 0.02940787f, -0.03581800f, -0.04350648f, -0.01937538f, 0.01960298f, 
    -0.00305654f, -0.02590212f, -0.01337661f, -0.01717883f, 0.00348747f, 0.02373617f, -0.01335925f, -0.00814504f, 
    0.01675353f, -0.00313706f, 0.02465731f, -0.00687766f, 0.01483821f, 0.02492324f, -0.00234927f, 0.02646878f, 
    0.01028417f, 0.00437786f, -0.01334194f, -0.01714359f, -0.03874492f, -0.02418082f, 0.01638265f, 0.01249930f, 
    0.03820005f, -0.02196931f, 0.02288599f, -0.03738477f, 0.00596728f, -0.02243741f, -0.01445076f, 0.00060821f, 
    0.01772332f, -0.02190241f, -0.03418301f, -0.01182343f, -0.01129472f, 0.01261474f, 0.00893122f, -0.02157470f, 
    -0.00379701f, -0.00978568f, 0.01021514f, -0.03034201f, -0.01251629f, -0.03454784f, -0.01656518f, 0.01938056f, 
    -0.03313341f, 0.00660253f, 0.00890776f, -0.01493810f, -0.01673352f, -0.01151162f, -0.02179334f, 0.02026494f, 
    0.01795405f, 0.01350154f, -0.02396233f, -0.01559031f, 0.01566599f, -0.00126722f, 0.01739448f, -0.00450450f, 
    -0.02010661f, -0.00395183f, 0.02712640f, -0.01119363f, 0.01113808f, 0.02734440f, -0.02068040f, -0.02411488f, 
    -0.02469405f, 0.03286041f, -0.01029764f, -0.00214091f, -0.02653020f, 0.00412779f, 0.03655005f, 0.01433322f, 
    0.00853423f, -0.02272661f, -0.03303447f, -0.04263553f, -0.01931442f, 0.02607079f, -0.01630079f, 0.02429853f, 
    0.00903485f, 0.02214404f, -0.02170724f, -0.00883021f, -0.02362416f, 0.01729622f, -0.00217513f, -0.02887405f, 
    0.03178192f, 0.00265716f, -0.00107480f, 0.00890802f, -0.01254668f, 0.02097805f, -0.02287434f, -0.01963197f, 
    0.00736861f, 0.00611996f, 0.01298732f, 0.01920181f, 0.02801381f, -0.02909124f, 0.02912459f, -0.00899960f, 
    -0.01709697f, -0.03922758f, 0.02902541f, -0.00607975f, -0.02340990f, 0.02848066f, -0.01443856f, -0.02886874f, 
    -0.03603272f, 0.00305506f, 0.03227543f, -0.03515499f, -0.03824708f, -0.00297288f, -0.03362995f, -0.04176974f, 
    -0.01996825f, -0.01890821f, -0.03521076f, -0.03547415f, -0.01976443f, -0.03031975f, -0.03073249f, -0.03161862f, 
    0.03344536f, 0.02601872f, -0.01447464f, -0.03350467f, -0.01071281f, 0.01712644f, 0.02162584f, 0.02583325f, 
    -0.00184991f, 0.02308424f, -0.00727174f, -0.01544203f, 0.01258502f, 0.02959873f, -0.03130395f, -0.02385776f, 
    -0.01389445f, -0.00317856f, 0.00516227f, -0.01223984f, -0.03326147f, 0.01721434f, 0.03636990f, -0.01385817f, 
    0.00562839f, -0.00315527f, -0.03320566f, -0.01195080f, -0.03724670f, 0.02674932f, 0.01060125f, 0.01840089f, 
    0.01383029f, -0.02648575f, 0.01948575f, 0.00374602f, -0.02428592f, 0.02666963f, -0.00702202f, -0.03741613f, 
    0.35398921f, 0.06251337f, 0.13379091f, 0.14199963f, -0.02693699f, -0.00511064f, 0.17318358f, 0.09935248f, 
    -0.01494572f, -0.05889347f, 0.02191753f, -0.02255311f, 0.09441785f, 0.07454560f, -0.10098775f, 0.08981122f, 
    -0.01649760f, 0.13657744f, 0.02090051f, 0.06474020f, 0.03622153f, -0.09339003f, 0.00764669f, 0.07145244f, 
    -0.14262554f, -0.04953527f, 0.00911903f, -0.13984586f, -0.09389445f, 0.07101908f, 0.09650203f, 0.14769900f, 
    -0.01065587f, 0.07770425f, -0.08032337f, 0.01107836f, 0.53007871f, 0.23163967f, -0.00582364f, 0.16377819f, 
    -0.22670342f, -0.01341135f, 0.08035243f, 0.03363604f, 0.15340947f, 0.13901973f, 0.00179187f, -0.01586865f, 
    -0.09959313f, -0.10147833f, -0.25674185f, -0.24081883f, -0.08258791f, -0.04784967f, -0.07783648f, 0.15219592f, 
    0.13823977f, 0.06522927f, -0.08495191f, -0.02826931f, -0.10501470f, -0.29370406f, -0.06898782f, -0.43857050f, 
    -0.09379213f, -0.03693150f, 0.07315720f, -0.01814130f, 0.06394960f, 0.11393237f, 0.01799752f, 0.07376248f, 
    -0.06095579f, 0.07695875f, -0.06363077f, 0.04164499f, 0.00909018f, 0.13406168f, 0.12673227f, -0.06306523f, 
    0.02833278f, 0.03028173f, -0.00643997f, 0.03642498f, -0.32918164f, 0.03951067f, -0.18012051f, 0.02990809f, 
    -0.14696585f, -0.01312748f, -0.06341828f, 0.15840416f, 0.05641483f, -0.03589952f, -0.04413214f, 0.02527269f, 
    0.06635118f, -0.03359047f, -0.18152513f, -0.32224840f, 0.21436472f, 0.05348599f, -0.11945181f, 0.15340483f, 
    0.07317922f, -0.01099322f, -0.01293874f, 0.16512001f, -0.07524905f, 0.02350226f, 0.05447430f, 0.02354513f, 
    -0.00565201f, 0.00179744f, -0.02044328f, 0.06414875f, 0.07637847f, -0.06555970f, -0.13067701f, 0.11844730f, 
    -0.01580140f, -0.12799864f, 0.01046913f, -0.27507636f, 0.01658469f, -0.14808331f, -0.00724590f, -0.00553583f, 
    -0.00799017f, 0.05649097f, 0.20402445f, -0.02047581f, -0.24519034f, 0.32027286f, -0.19060995f, 0.17103921f, 
    -0.06830145f, 0.00050318f, 0.02474008f, -0.05271677f, 0.07940441f, -0.01038363f, 0.24367052f, -0.02507141f, 
    0.15673593f, -0.17446539f, -0.26791528f, -0.05120898f, 0.23682967f, 0.15028070f, -0.00970827f, -0.00774041f, 
    0.04128351f, 0.14083686f, 0.06986842f, 0.07991050f, 0.16242756f, -0.22259794f, 0.24552849f, -0.01864990f, 
    0.24943541f, 0.12129790f, 0.06272935f, 0.17039090f, 0.02466116f, 0.02749278f, -0.05994739f, 0.09930113f, 
    -0.19658326f, -0.21027003f, 0.06945489f, -0.11833017f, -0.00939367f, -0.00898645f, 0.17362662f, 0.06225177f, 
    0.07656991f, -0.05701757f, 0.05049152f, 0.10238495f, -0.37331080f, 0.21398148f, -0.11332037f, -0.07495860f, 
    -0.02014355f, 0.00651866f, 0.09306767f, 0.05504713f, -0.01750785f, -0.00626811f, -0.04681711f, -0.07914229f, 
    0.35843292f, 0.16143878f, 0.21625544f, 0.15477315f, -0.26053602f, -0.02101099f, 0.10801225f, 0.09703933f, 
    0.02075642f, 0.02787691f, 0.00528637f, -0.01365016f, 0.08697854f, -0.28940365f, 0.03693878f, 0.04897917f, 
    0.14266726f, -0.00849803f, 0.06257176f, 0.10170458f, 0.00655297f, -0.01687704f, -0.01441933f, 0.02629547f, 
    0.30309027f, -0.25688720f, 0.02989651f, -0.06672309f, 0.11993515f, -0.10985154f, 0.03334912f, -0.05192751f, 
    -0.20824082f, 0.10565744f, 0.07864419f, 0.12969635f, 0.02760155f, -0.02504789f, 0.02279115f, -0.16101150f, 
    -0.07420140f, 0.09101437f, 0.09648600f, 0.04754799f, 0.08375815f, 0.04173140f, -0.00027562f, 0.05917622f, 
    0.04547780f, 0.04715593f, 0.05673646f, 0.13360006f, 0.01662694f, 0.17918299f, 0.04439673f, 0.04391991f, 
    -0.03360847f, 0.06835174f, 0.08435877f, 0.18282385f, 0.37481719f, 0.14368571f, 0.23129174f, 0.09562006f, 
    -0.20489746f, -0.07990258f, 0.04309772f, 0.01334712f, 0.10738757f, -0.09703454f, -0.12087657f, -0.04018505f, 
    -0.07634662f, -0.00848818f, -0.07023832f, 0.07447427f, 0.15943038f, 0.00983911f, -0.12764859f, -0.05396622f, 
    0.04026262f, -0.14480200f, 0.10800058f, 0.03355096f, -0.09035342f, 0.07738151f, -0.05954506f, 0.25036922f, 
    0.00988366f, 0.10355595f, 0.11904235f, 0.06618074f, -0.05213391f, 0.08057340f, 0.05582702f, 0.14226800f, 
    0.20081952f, 0.31120211f, 0.13073637f, -0.02722376f, -0.11381145f, -0.14137439f, 0.06828196f, -0.00609378f, 
    -0.09131203f, -0.10188781f, 0.04647353f, -0.07468223f, 0.17108274f, 0.11197995f, -0.24004066f, 0.33670157f, 
    -0.04232066f, 0.04556994f, 0.08090831f, -0.00297021f, 0.19241785f, 0.07957053f, -0.11667345f, 0.04582167f, 
    0.12088504f, -0.19061998f, 0.16264595f, -0.03981126f, -0.08244910f, 0.08874690f, 0.16682707f, 0.04041233f, 
    0.00124980f, 0.07354797f, -0.04398345f, -0.03910468f, 0.03970859f, -0.19187346f, -0.26779920f, -0.15476879f, 
    0.23376147f, 0.11466904f, 0.05814227f, -0.00528281f, 0.07176794f, 0.05016942f, 0.09457123f, 0.02576054f, 
    0.41938004f, -0.10840088f, 0.15777238f, -0.08708753f, 0.13130061f, -0.09087577f, -0.04878934f, 0.09471002f, 
    0.07787379f, 0.00789730f, -0.11223872f, -0.01589131f, 0.21591875f, -0.02744606f, -0.20552897f, 0.10109549f, 
    0.04206150f, 0.17787206f, 0.15069196f, 0.02295324f, -0.06529497f, 0.16235390f, 0.00855200f, 0.04242148f, 
    -0.21603999f, -0.07890144f, -0.11494315f, -0.15208735f, 0.20380613f, -0.08982487f, 0.07179332f, 0.05012921f, 
    0.05392805f, 0.08016112f, 0.19953436f, 0.11627062f, 0.05265884f, 0.17392066f, 0.15886702f, 0.22778231f, 
    -0.09537971f, 0.03325982f, 0.00670885f, 0.05656045f, 0.15415281f, 0.05154964f, 0.00090611f, -0.02713453f, 
    -0.08132029f, -0.25356090f, 0.26040468f, -0.06929813f, -0.01219602f, 0.15414862f, 0.04292472f, -0.02929083f, 
    0.05488554f, 0.09279775f, -0.13738024f, 0.08194772f, 0.49588510f, -0.01414873f, 0.12320144f, 0.07641909f, 
    -0.12239973f, -0.00385904f, -0.01711850f, 0.07217182f, 0.03361760f, 0.02683667f, -0.02317814f, -0.02753277f, 
    0.35262981f, 0.10567256f, 0.10213692f, 0.04865718f, -0.21769612f, 0.03270896f, 0.09152564f, 0.18431854f, 
    -0.04257505f, -0.00802030f, -0.00866367f, 0.11208426f, -0.01558442f, -0.12761417f, -0.16484378f, -0.12647870f, 
    0.11210468f, 0.12580922f, 0.03522682f, 0.07816024f, -0.02307880f, -0.06354678f, 0.00825461f, 0.07634310f, 
    0.27831176f, -0.09791860f, 0.08285908f, 0.06517749f, 0.08372890f, -0.00814842f, -0.09664182f, -0.04386440f, 
    -0.01193409f, -0.04365188f, 0.00745688f, -0.02792743f, -0.11983000f, -0.14339581f, -0.02638577f, 0.22155724f, 
    0.04731681f, 0.06720501f, 0.01065164f, -0.05967217f, 0.11973670f, 0.01838981f, -0.09425659f, 0.06793883f, 
    0.08674233f, 0.06306679f, 0.06532996f, -0.32503763f, -0.12009632f, 0.11704818f, 0.06113823f, -0.01306626f, 
    0.10669322f, -0.10020522f, -0.15172257f, -0.02528832f, 0.14973827f, -0.26016325f, -0.02948456f, -0.21191622f, 
    0.16975430f, -0.02938207f, 0.06506359f, 0.10415187f, 0.13724847f, 0.07974733f, 0.04302001f, 0.02702308f, 
    -0.13490066f, -0.08238119f, -0.04226665f, -0.04566165f, -0.13520843f, 0.04674470f, -0.01671719f, 0.02932492f, 
    -0.07028104f, 0.02255911f, 0.15653169f, -0.05042906f, -0.17960025f, -0.08009792f, -0.03562716f, -0.10341621f, 
    -0.05153876f, 0.03325647f, -0.00170004f, 0.00593980f, 0.15282315f, -0.00555695f, -0.07357022f, 0.18161349f, 
    0.31335998f, -0.00425072f, 0.18793333f, 0.18383746f, -0.21597597f, -0.01807641f, 0.06189239f, 0.12483777f, 
    -0.06382453f, -0.04611982f, 0.13424291f, 0.13835666f, -0.12855268f, 0.09737629f, -0.17381822f, 0.17678966f, 
    0.06768137f, 0.05614581f, -0.01025038f, 0.04510887f, 0.03457240f, -0.05789125f, -0.01885646f, 0.00503928f, 
    0.01949346f, -0.17683017f, 0.23382825f, -0.38552231f, -0.19068918f, -0.01154435f, 0.16450609f, -0.02121498f, 
    0.03410009f, -0.01298746f, 0.06146467f, -0.02379653f, 0.29655784f, 0.21500398f, 0.12799692f, 0.32738629f, 
    -0.14959218f, 0.03331928f, 0.08223823f, 0.09315194f, 0.17764571f, 0.13284680f, 0.03152415f, 0.05964917f, 
    -0.15327442f, -0.04967451f, -0.10943756f, 0.08874062f, -0.03368353f, -0.04452370f, -0.07842610f, -0.19207658f, 
    0.15360935f, 0.04371035f, -0.06428222f, -0.07284930f, -0.17952220f, 0.08935870f, -0.01669671f, -0.17713216f, 
    0.02663933f, -0.06606253f, -0.02420381f, 0.04868649f, 0.05571791f, 0.04502137f, -0.03443106f, 0.06575970f, 
    0.11087452f, 0.00707678f, -0.07484592f, -0.11861123f, -0.04721629f, 0.18767010f, 0.08156219f, 0.01280341f, 
    0.13560948f, 0.08254593f, -0.08405549f, 0.05805808f, -0.24965928f, 0.04152120f, -0.18321244f, 0.20054677f, 
    -0.01279645f, 0.00289222f, 0.23280564f, 0.02478294f, 0.17511635f, 0.06549761f, 0.08047231f, 0.01247224f, 
    0.09166311f, -0.06255053f, 0.03040331f, -0.13877371f, 0.20596477f, 0.21485224f, 0.14756913f, -0.02543788f, 
    -0.02162750f, 0.04161678f, -0.02149414f, 0.03690664f, 0.55837005f, 0.10236830f, 0.24075602f, 0.11920336f, 
    -0.10359347f, -0.04770919f, -0.05973796f, 0.09835108f, 0.06358860f, -0.00340157f, -0.02397935f, -0.05118546f, 
    -0.06208195f, 0.13026530f, 0.02732517f, 0.05153198f, 0.01237460f, 0.06721866f, 0.14355801f, 0.03154269f, 
    0.06517636f, 0.11029971f, 0.06227336f, -0.08244858f, -0.07007863f, -0.18138994f, -0.09293813f, -0.27911076f, 
    0.13369755f, -0.10118015f, 0.16038670f, 0.06586044f, -0.06258254f, 0.04393063f, 0.04943790f, 0.09682965f, 
    -0.03187124f, 0.07684419f, -0.15462062f, 0.12676096f, 0.07694677f, 0.11018223f, -0.06951105f, 0.03712225f, 
    0.00879384f, -0.07389304f, 0.20245236f, 0.06365159f, 0.31096527f, -0.05167897f, -0.02635942f, 0.03029481f, 
    -0.05480880f, 0.09217673f, 0.01484593f, -0.08657362f, -0.07622038f, -0.14955534f, -0.10526993f, -0.03398884f, 
    0.61530870f, -0.05349392f, 0.09882335f, 0.15239318f, -0.18402824f, -0.02038529f, -0.06831820f, 0.12221360f, 
    0.07844351f, 0.10186189f, 0.01088621f, 0.11919241f, 0.16696239f, -0.01254630f, -0.01041741f, 0.00101641f, 
    -0.18181843f, -0.02514145f, 0.09443513f, 0.06279728f, 0.01934491f, 0.09881201f, -0.02691980f, -0.16167402f, 
    -0.05948017f, -0.05583346f, 0.12901564f, 0.13188832f, -0.03163642f, 0.04095153f, 0.07081989f, 0.06807792f, 
    0.06267259f, 0.03127855f, -0.01928890f, -0.14893867f, -0.15498044f, -0.09592972f, -0.28884068f, 0.11640967f, 
    0.08703293f, 0.00910653f, -0.01324402f, -0.03740527f, 0.02584180f, 0.03753325f, -0.12120599f, 0.00982501f, 
    0.11838208f, 0.18136345f, 0.20646586f, 0.13523051f, -0.15507768f, -0.06223456f, -0.01473535f, 0.06622473f, 
    0.04017179f, -0.03858735f, -0.07256440f, 0.19098260f, -0.11746983f, -0.11486748f, -0.18322425f, -0.00574291f, 
    -0.06727116f, -0.00748869f, 0.11606318f, 0.17102338f, -0.10355955f, -0.06577754f, -0.01089607f, -0.04861403f, 
    0.18673185f, -0.19868387f, 0.19665061f, -0.27687758f, -0.02034016f, 0.12375669f, 0.18989839f, 0.11555003f, 
    -0.02100193f, -0.04974801f, -0.03668774f, 0.09237262f, 0.49773088f, -0.09727278f, 0.13742402f, -0.21035090f, 
    -0.05087046f, 0.09709559f, -0.00233388f, 0.07887187f, 0.03762820f, 0.00320940f, -0.02703652f, 0.12164457f, 
    -0.02096137f, 0.00093529f, -0.03440855f, 0.01476435f, 0.01637210f, 0.01976131f, 0.00295903f, -0.00560325f, 
    -0.02773576f, 0.02587618f, 0.01726368f, -0.00074768f, -0.00626161f, 0.02171658f, 0.02255631f, 0.01991323f, 
    -0.01566668f, 0.00780394f, -0.02513900f, 0.00088898f, 0.01275092f, -0.01012818f, -0.01344443f, 0.01555707f, 
    -0.04101637f, 0.02087451f, -0.01241886f, -0.01061622f, 0.02670852f, 0.02649604f, 0.03675563f, -0.01820122f, 
    -0.00712219f, 0.01703669f, 0.03098373f, 0.02996306f, -0.02112706f, -0.00184587f, 0.01787168f, 0.01671417f, 
    -0.03419492f, -0.03160097f, 0.01179643f, -0.00393718f, -0.03068087f, -0.03306357f, 0.02318965f, -0.00669168f, 
    0.02399134f, -0.02900989f, -0.01824930f, -0.01472738f, -0.00891437f, 0.02067992f, -0.02562977f, -0.01864045f, 
    0.03464406f, -0.01542603f, 0.00425023f, -0.01120299f, -0.03403935f, -0.02727826f, -0.02054709f, 0.01645789f, 
    0.00772110f, -0.02635253f, 0.02105941f, -0.00050871f, -0.01749582f, -0.00058459f, 0.02951204f, -0.02041425f, 
    -0.00905105f, 0.01917471f, 0.00749322f, -0.01891215f, -0.01852366f, 0.00429204f, 0.01487275f, -0.01956072f, 
    -0.02518941f, -0.00488220f, 0.02412719f, -0.00375296f, 0.00874996f, -0.01439096f, -0.04218696f, -0.01285638f, 
    0.00582914f, -0.00175432f, -0.02727349f, -0.00583856f, -0.02020994f, 0.01417155f, 0.00554166f, -0.01494013f, 
    -0.00143818f, -0.00760060f, -0.01953915f, -0.00756831f, 0.01488683f, 0.00250163f, 0.00840926f, 0.00896072f, 
    0.00046947f, 0.03469683f, 0.00134247f, 0.02861048f, -0.02387131f, -0.03916224f, -0.01366748f, -0.03167441f, 
    -0.02488017f, 0.02782151f, -0.00225400f, -0.03958390f, 0.02028921f, 0.03273436f, -0.00565619f, -0.00334795f, 
    0.02893429f, 0.02371193f, -0.01686788f, 0.01871197f, 0.01236786f, -0.02713209f, 0.01130953f, 0.00194319f, 
    -0.00122094f, -0.03096315f, -0.01407176f, 0.03355807f, -0.00074947f, 0.02016621f, -0.04151715f, 0.00314043f, 
    0.00124576f, 0.00390506f, -0.03816691f, 0.02758886f, 0.01977933f, -0.00068109f, -0.03586739f, 0.00719328f, 
    0.00429007f, 0.02981735f, -0.04080056f, -0.01810678f, -0.03114639f, 0.01910106f, 0.01414893f, 0.02295153f, 
    -0.00405877f, 0.02440852f, 0.01085860f, 0.02623483f, -0.03523665f, -0.01162697f, 0.02222514f, 0.02343554f, 
    -0.01379338f, 0.01490927f, 0.01819499f, 0.02757686f, -0.01946908f, 0.00019191f, 0.01315452f, -0.02081649f, 
    -0.01318028f, 0.01945163f, 0.01078965f, 0.03083706f, 0.00757092f, 0.02135931f, 0.02049102f, 0.01587542f, 
    -0.00000737f, -0.01958384f, -0.03903698f, 0.00552114f, 0.00668753f, -0.02063338f, -0.02500017f, 0.00033437f, 
    -0.02151559f, 0.01060148f, -0.01310879f, 0.02351344f, 0.02912762f, -0.01286484f, 0.03202755f, -0.03406443f, 
    -0.02634296f, -0.02013899f, -0.03854691f, 0.01256259f, 0.02584363f, -0.04424921f, 0.01900237f, 0.00979024f, 
    0.01359429f, -0.01549513f, -0.00637476f, -0.04437178f, 0.01008392f, -0.00754254f, -0.00656272f, -0.00822196f, 
    -0.02351872f, -0.00697810f, -0.01034276f, 0.01386183f, -0.01976673f, 0.00236139f, -0.01456570f, 0.00033126f, 
    -0.00567285f, 0.01682539f, 0.01449757f, -0.01500775f, -0.01628353f, 0.02536909f, 0.00222056f, 0.02494267f, 
    0.01640052f, -0.02967804f, 0.00886374f, -0.00813854f, -0.01220340f, 0.00577105f, 0.01540963f, -0.02194697f, 
    0.03550411f, -0.01060060f, 0.02090271f, 0.01538880f, 0.00450895f, -0.00421374f, -0.00982090f, 0.03202152f, 
    0.01844260f, -0.01627624f, 0.02323755f, -0.01131509f, -0.02137271f, -0.00885808f, 0.00193823f, -0.01616320f, 
    -0.02494483f, 0.01379064f, 0.02254593f, -0.03440236f, 0.00951815f, 0.01622598f, -0.03059439f, -0.00520944f, 
    0.00574282f, 0.02517738f, -0.00083004f, 0.01972600f, 0.01278854f, 0.00429529f, 0.02105606f, -0.02932624f, 
    -0.01496909f, -0.02374201f, -0.00682161f, -0.04438433f, -0.00103803f, 0.03385227f, 0.03037096f, 0.00670698f, 
    -0.00898564f, -0.02465676f, 0.02436732f, -0.03511946f, 0.00502080f, 0.03263405f, 0.01644003f, 0.00207357f, 
    -0.02204445f, -0.02020163f, -0.03546701f, 0.01759348f, -0.03540999f, 0.02486042f, -0.00533665f, 0.02431594f, 
    0.02915288f, -0.02467522f, -0.03921204f, -0.03902888f, -0.03826058f, 0.00679523f, -0.02353193f, -0.02017440f, 
    0.01563854f, -0.03593675f, -0.01666982f, -0.04242671f, -0.02026755f, -0.02625879f, -0.02890401f, 0.00973346f, 
    0.01917060f, 0.01646790f, -0.02667175f, -0.00030735f, -0.00780970f, 0.00414372f, -0.00305902f, 0.01294366f, 
    -0.03588134f, -0.01288243f, -0.01142528f, 0.02407598f, -0.00640414f, -0.00540402f, 0.01250983f, -0.03054456f, 
    -0.03964642f, -0.00104313f, -0.02525578f, 0.00707895f, -0.00861022f, -0.01539659f, 0.01978374f, -0.01274970f, 
    0.01996518f, 0.00877774f, -0.03420414f, -0.03833232f, 0.02563025f, -0.02801955f, 0.00572409f, -0.02796970f, 
    0.02591589f, -0.01279313f, 0.00765455f, -0.03556581f, -0.02747205f, -0.01226023f, 0.00963772f, -0.01694889f, 
    0.00480254f, -0.01362659f, -0.00741165f, -0.01558142f, 0.01255161f, 0.00883077f, 0.02617598f, -0.00149019f, 
    -0.01203436f, -0.03495659f, -0.02956339f, 0.00725299f, 0.02109291f, -0.00441591f, 0.01433063f, 0.00397290f, 
    0.02400696f, -0.02176556f, 0.01410826f, -0.01899423f, -0.02592492f, 0.02814225f, -0.03280353f, -0.01579077f, 
    0.01019063f, 0.01054939f, -0.00761824f, 0.02607544f, -0.03219741f, 0.01513194f, -0.03112333f, -0.02845619f, 
    -0.03645696f, 0.00094829f, -0.01093885f, 0.00972687f, -0.00850309f, 0.01388696f, -0.01107840f, -0.02092542f, 
    0.00124337f, -0.03802868f, -0.00879062f, 0.01965396f, 0.01291579f, 0.02476702f, -0.00814697f, 0.00259285f, 
    -0.00248262f, -0.01207443f, 0.02093415f, 0.02676761f, -0.02626775f, -0.02252194f, -0.03149963f, -0.00439248f, 
    0.00529711f, -0.03071022f, -0.01883532f, -0.00724481f, 0.02494166f, 0.01170065f, -0.03198153f, -0.02773853f, 
    0.02146656f, 0.01154115f, 0.01285512f, 0.00091867f, -0.02909651f, 0.02345044f, -0.01331792f, 0.03091936f, 
    0.01172994f, 0.01799087f, -0.01322086f, -0.01809276f, 0.02494762f, -0.01618043f, -0.02162991f, -0.03121158f, 
    0.02051081f, 0.00991652f, 0.00516580f, 0.02026363f, -0.00265014f, -0.02511525f, -0.01755930f, 0.02494531f, 
    0.02889909f, -0.01152280f, -0.02315143f, -0.01296636f, 0.00158035f, 0.00103562f, 0.00007463f, -0.01598466f, 
    -0.02237232f, 0.00879149f, 0.01884817f, -0.01283503f, -0.02020317f, -0.04350784f, 0.02372308f, 0.01769914f, 
    0.00783893f, 0.03304388f, 0.02121077f, 0.01517367f, -0.03778791f, -0.00108326f, -0.01614572f, -0.00581571f, 
    -0.00513020f, -0.01196304f, 0.00313124f, 0.03255210f, -0.01742899f, -0.00063935f, -0.02819929f, -0.03647161f, 
    -0.03650918f, 0.02494669f, -0.01248457f, -0.00942975f, -0.02085004f, -0.03118435f, 0.00233780f, -0.01466242f, 
    -0.02124225f, -0.03257022f, -0.01121471f, -0.03111329f, -0.02797784f, -0.00071125f, -0.03528190f, -0.00811610f, 
    0.01408442f, -0.03846011f, 0.00649479f, 0.01251652f, 0.03197247f, 0.03269213f, 0.02073925f, -0.03300520f, 
    -0.02836046f, 0.01411202f, -0.03065892f, 0.00339929f, -0.00270702f, 0.02628503f, 0.01687626f, -0.00646420f, 
    0.01932474f, -0.02667398f, 0.02987373f, 0.00442059f, -0.04006020f, 0.00277909f, -0.01730411f, -0.02101022f, 
    0.01109525f, -0.02259426f, 0.02550986f, -0.03762879f, -0.03842678f, -0.01191328f, -0.01372458f, 0.01706458f, 
    -0.03605854f, 0.00479707f, -0.00179426f, -0.01327441f, -0.02062560f, 0.01358258f, 0.00933811f, 0.00836519f, 
    0.01786253f, 0.02673766f, -0.01777826f, 0.00614021f, 0.00372054f, -0.00449580f, -0.03379782f, -0.01993085f, 
    -0.03496661f, -0.04425028f, -0.01389248f, -0.02243469f, -0.02099796f, -0.00769295f, -0.01848387f, -0.01909927f, 
    -0.01888285f, -0.04232382f, 0.01333172f, -0.03518500f, -0.01409644f, 0.03487266f, -0.00795394f, -0.01464365f, 
    0.00569381f, 0.01428270f, 0.01233403f, 0.01049204f, 0.00128055f, 0.00616670f, 0.03018610f, -0.04267787f, 
    -0.03833996f, 0.01747961f, -0.01698583f, -0.01524849f, 0.01520186f, -0.01697126f, -0.01481283f, 0.00018268f, 
    -0.02812095f, -0.03754600f, 0.00441464f, 0.02319548f, -0.01103407f, -0.03542557f, -0.02347944f, 0.00436550f, 
    -0.02345417f, -0.02546135f, 0.01374025f, -0.02475982f, -0.02454025f, 0.02300182f, 0.00509663f, 0.02419687f, 
    0.01504280f, -0.03918922f, -0.01542548f, -0.00047993f, 0.00039272f, 0.00834983f, -0.02301981f, 0.04191171f, 
    0.01666703f, -0.01240714f, -0.02004979f, -0.01227562f, -0.04228027f, -0.00968560f, 0.00189115f, -0.00024979f, 
    0.03317306f, -0.02828310f, 0.00554747f, -0.01768214f, 0.00521495f, -0.01475492f, -0.01668209f, 0.02890656f, 
    0.00441198f, -0.00806634f, -0.00445189f, 0.00482000f, -0.01659551f, -0.02062141f, 0.00696501f, 0.00740666f, 
    -0.01614311f, 0.00404925f, -0.03503843f, -0.02227489f, 0.02187980f, 0.00750012f, -0.03348505f, -0.01246822f, 
    -0.00503634f, 0.02456929f, 0.02485967f, -0.00515332f, -0.01608153f, 0.00047589f, 0.01346257f, 0.01433230f, 
    -0.01791420f, -0.01346399f, 0.01405026f, 0.00880428f, -0.00339989f, 0.02110666f, -0.00356404f, -0.03301449f, 
    -0.01981509f, 0.01712979f, 0.00488553f, -0.02689776f, 0.00519470f, -0.01770188f, 0.02228674f, 0.00543368f, 
    0.01479869f, -0.01388114f, 0.02669711f, 0.03483158f, 0.01144343f, 0.01389852f, -0.03238794f, -0.01854531f, 
    0.01578881f, 0.01503290f, -0.04254694f, -0.03566492f, 0.02940397f, 0.01597473f, -0.02207604f, -0.02503381f, 
    -0.01453120f, -0.03479597f, -0.01901541f, -0.02216662f, -0.02276221f, 0.02030402f, 0.02639074f, 0.01821858f, 
    0.02971124f, 0.02205054f, 0.01987253f, -0.03289209f, -0.03028299f, -0.02787245f, -0.01688362f, -0.01762121f, 
    0.02437986f, -0.03104752f, -0.02199470f, 0.00870629f, -0.03215419f, -0.01042487f, 0.02442909f, 0.02412228f, 
    -0.01430600f, -0.03045641f, 0.00720050f, -0.00621188f, 0.02247521f, -0.03007319f, 0.02589482f, -0.01204122f, 
    -0.01159537f, -0.02637705f, 0.02605868f, 0.01151758f, -0.02318488f, 0.00534922f, -0.01884661f, -0.02242701f, 
    0.00377385f, 0.01623864f, -0.01712275f, 0.02914270f, 0.02671507f, -0.01382114f, -0.01308101f, -0.01690591f, 
    -0.01293353f, 0.00245605f, 0.00077180f, 0.02001362f, -0.02376449f, -0.02040198f, -0.03543841f, -0.01529962f, 
    -0.00290777f, -0.00286444f, 0.00483281f, -0.01991608f, -0.00434502f, 0.02221647f, -0.03266503f, -0.03234576f, 
    -0.01400543f, 0.01531652f, 0.02750372f, -0.02885107f, 0.00468694f, 0.02683230f, 0.01279307f, -0.01780093f, 
    0.02515883f, 0.00117000f, 0.01273672f, 0.02036288f, -0.01161192f, 0.00539677f, 0.00611839f, 0.02935943f, 
    -0.01444082f, -0.00314355f, 0.01454198f, 0.01721463f, -0.02694380f, -0.02009778f, 0.00304808f, -0.03507286f, 
    -0.01241253f, -0.00040777f, -0.03134654f, 0.03149690f, 0.02899750f, 0.01760895f, 0.02959340f, -0.03020151f, 
    -0.01374326f, 0.03217347f, 0.00872767f, 0.02268508f, -0.03738748f, -0.02378134f, 0.00124793f, -0.01449981f, 
    -0.03099807f, 0.01081765f, -0.02026529f, -0.03231448f, 0.00693339f, 0.02482583f, -0.03531976f, -0.03802015f, 
    -0.02412095f, 0.01144604f, 0.01909466f, -0.00420870f, 0.01760241f, -0.03732301f, -0.01927025f, -0.02113400f, 
    0.01483155f, -0.00750407f, -0.01783706f, -0.01976584f, -0.00995336f, 0.00685631f, -0.02065236f, -0.03230380f, 
    -0.01630495f, -0.02930818f, 0.01981005f, -0.00766024f, 0.01479543f, -0.00532021f, -0.02398006f, 0.03232512f, 
    0.01119407f, 0.01777343f, -0.00713086f, -0.01930312f, 0.00626708f, 0.02552702f, 0.01636489f, 0.00527532f, 
    -0.03154439f, 0.02127738f, -0.03926333f, -0.00305688f, 0.02174604f, -0.00839716f, -0.04032687f, 0.03704427f, 
    -0.01595385f, -0.02402416f, 0.02683497f, 0.02631952f, 0.00171013f, 0.02726363f, 0.00135813f, -0.02520790f, 
    -0.02429481f, -0.02231002f, -0.01592576f, 0.00472991f, 0.00632003f, 0.01898347f, -0.00102836f, 0.00186893f, 
    -0.03993265f, -0.01493893f, -0.02712635f, 0.00459699f, 0.02274073f, -0.01657131f, -0.00498077f, -0.02511567f, 
    0.00867583f, 0.02745456f, -0.02890003f, -0.00203763f, 0.01902702f, 0.00522366f, -0.00021286f, 0.00696414f, 
    0.01242866f, -0.02317825f, 0.02561820f, -0.01562432f, -0.02429904f, -0.02131771f, 0.01208624f, -0.00011815f, 
    0.00291977f, 0.03091748f, 0.01782888f, -0.00056100f, 0.00350479f, 0.01469821f, -0.00349157f, -0.01027030f, 
    0.02555546f, 0.00279366f, 0.01603925f, -0.01861775f, -0.02417258f, 0.00413510f, -0.03355718f, -0.01729072f, 
    -0.03668965f, -0.02053704f, -0.01231311f, -0.01617852f, -0.00447251f, -0.03815041f, 0.00397102f, 0.00633834f, 
    0.02440048f, -0.00096297f, -0.01649231f, -0.00649369f, -0.01240873f, 0.02943959f, 0.01349698f, 0.01263213f, 
    -0.00231749f, -0.02352872f, -0.02740303f, 0.03715829f, -0.03484408f, 0.02124450f, -0.00416100f, 0.00641855f, 
    -0.02699960f, -0.04212198f, -0.00088121f, -0.01812694f, -0.00839466f, 0.02985274f, -0.00474299f, 0.00259765f, 
    0.00048619f, 0.00929763f, -0.00042033f, 0.00547071f, 0.03125099f, 0.02876279f, 0.02543047f, -0.00119552f, 
    0.00002572f, -0.00604483f, -0.03019649f, -0.03900377f, 0.01230108f, -0.01826135f, 0.01984370f, -0.02308761f, 
    -0.01795684f, -0.02399250f, 0.03081676f, -0.00793183f, -0.01796344f, 0.02822352f, -0.03320598f, 0.02070469f, 
    0.01915884f, 0.02865411f, -0.03250035f, 0.01101297f, -0.00144226f, -0.00105567f, 0.02256585f, 0.00283508f, 
    -0.02739387f, 0.00081931f, -0.01316923f, -0.02147434f, -0.00599039f, -0.03539153f, -0.01198607f, 0.01939597f, 
    0.03694566f, -0.03207887f, -0.02566416f, -0.01333640f, 0.02507070f, 0.00350709f, 0.01218463f, 0.00744559f, 
    -0.03509284f, -0.00759326f, 0.03845772f, 0.02118089f, -0.02657438f, -0.01798688f, -0.01665131f, -0.02215529f, 
    0.01600187f, -0.02561625f, -0.04097640f, 0.01850607f, -0.03083286f, -0.03202158f, -0.03924226f, -0.03155845f, 
    0.01006749f, -0.02997714f, -0.00184568f, -0.02426094f, 0.01390329f, -0.03015055f, -0.02629859f, -0.01122002f, 
    0.01781374f, -0.01763988f, -0.01746757f, -0.01865820f, 0.02144250f, 0.00071102f, 0.00087908f, -0.00665540f, 
    -0.01944762f, -0.01231400f, 0.01994908f, 0.00636107f, -0.02306418f, 0.01244934f, 0.00263142f, 0.02942225f, 
    0.02284314f, -0.01178015f, -0.00648475f, -0.00326626f, 0.02849225f, 0.03419500f, -0.00550526f, 0.00252849f, 
    0.01271519f, 0.00592627f, 0.02652282f, 0.00282020f, -0.02716829f, 0.01962842f, 0.01836612f, 0.02803214f, 
    -0.02768393f, 0.00000066f, -0.01980955f, 0.00786937f, -0.02252064f, 0.00014928f, 0.01579691f, 0.03074796f, 
    0.00129902f, -0.00493005f, -0.00216723f, 0.00893957f, -0.01260794f, 0.00709994f, 0.02367159f, -0.02223669f, 
    0.01408718f, -0.01060391f, 0.01681560f, 0.03502131f, 0.01656792f, 0.00101281f, -0.00077721f, 0.03057097f, 
    -0.02707475f, -0.02374371f, 0.00304310f, 0.03230540f, -0.00122252f, -0.03066473f, 0.03506600f, 0.01411447f, 
    -0.03779196f, -0.03497013f, 0.01151243f, 0.01112376f, 0.02589528f, -0.02813595f, 0.02329773f, 0.01470073f, 
    0.01548199f, -0.02001058f, -0.01284721f, -0.02329872f, -0.01658172f, 0.02125531f, -0.03007098f, 0.02965606f, 
    -0.01127307f, -0.02208478f, 0.01052853f, -0.03697061f, -0.00842161f, -0.03835168f, -0.03726212f, 0.00366148f, 
    -0.01863680f, -0.00525616f, -0.00064473f, -0.00998161f, -0.03250023f, -0.02312380f, 0.00503326f, 0.01535939f, 
    0.01639935f, 0.02379843f, -0.02259431f, -0.03455474f, -0.00728792f, -0.00882693f, -0.03966713f, -0.00772149f, 
    0.02038386f, 0.01265298f, -0.00354158f, -0.00672389f, -0.00781283f, 0.00959783f, -0.01979790f, -0.01722183f, 
    0.01790190f, -0.00703210f, 0.02362317f, -0.01053537f, -0.02289002f, 0.00700189f, -0.03839745f, 0.01261047f, 
    -0.00230327f, 0.01820978f, 0.01733810f, 0.02048540f, 0.00470315f, -0.02192471f, -0.02529524f, -0.03317125f, 
    0.00338817f, -0.02899234f, -0.01753576f, 0.03791266f, -0.02870227f, 0.00086843f, 0.01261783f, 0.00004099f, 
    0.01507157f, 0.02214490f, -0.00068872f, 0.03547200f, -0.00914880f, -0.01961646f, 0.02471862f, -0.01719837f, 
    0.02095086f, 0.00607602f, 0.01694640f, -0.02040918f, 0.02322312f, 0.02408634f, 0.01429475f, 0.02685345f, 
    -0.00116087f, 0.02028604f, -0.00772263f, 0.00098471f, -0.02088049f, -0.01914252f, -0.01948006f, -0.03992585f, 
    -0.03744502f, -0.03676913f, -0.01125652f, -0.01095248f, 0.00666588f, 0.02083555f, 0.01271229f, 0.00314061f, 
    0.01480438f, -0.00644350f, 0.01987655f, -0.01217320f, 0.02604701f, 0.00757563f, 0.03038356f, -0.02807653f, 
    0.01157623f, 0.01586532f, 0.02768392f, 0.03437945f, -0.02673481f, 0.01891424f, 0.01904877f, 0.02271287f, 
    -0.01041579f, -0.03130610f, -0.00372324f, -0.03436535f, 0.01326908f, 0.00419091f, 0.01799804f, 0.00573722f, 
    0.02288480f, 0.00046930f, 0.00669210f, 0.03268819f, -0.00458783f, 0.00227373f, -0.01016858f, -0.00685989f, 
    0.00749222f, -0.03058451f, -0.00468460f, -0.02725502f, -0.03243092f, 0.02167021f, -0.02439184f, 0.03185549f, 
    -0.04139407f, -0.01510964f, -0.01982996f, 0.00512241f, -0.00404370f, 0.02880850f, 0.02750567f, 0.01149589f, 
    0.01357412f, 0.00659999f, -0.00718450f, -0.00281466f, 0.02201693f, 0.00296089f, 0.00801831f, 0.01613994f, 
    -0.02328316f, 0.02771198f, -0.00205969f, 0.00889455f, -0.00234075f, 0.01232947f, -0.03226024f, -0.02123013f, 
    0.00130100f, 0.02534611f, 0.02530199f, -0.01367122f, -0.02273046f, -0.02278144f, -0.02277292f, 0.01420470f, 
    0.02194151f, 0.02473191f, -0.02676569f, 0.02786889f, -0.01096263f, 0.01600899f, 0.01689852f, 0.00181804f, 
    0.00817986f, -0.01590008f, 0.02481996f, -0.00613382f, -0.01980390f, -0.01983863f, -0.03167343f, -0.03510411f, 
    0.02125984f, 0.02892982f, 0.02216528f, 0.00224932f, 0.02581250f, 0.00979379f, -0.04199022f, 0.02651022f, 
    0.03232211f, 0.02967266f, -0.03040414f, 0.03181012f, -0.02029246f, 0.00289714f, -0.02525607f, -0.03949525f, 
    -0.00645124f, -0.01516939f, -0.03130209f, -0.01858704f, 0.01611271f, 0.01933731f, -0.02962955f, -0.03566213f, 
    -0.03432816f, 0.00576562f, -0.01202480f, 0.01018947f, -0.01468580f, 0.00381574f, 0.02615028f, 0.02818826f, 
    -0.00225393f, 0.01532446f, 0.03348093f, 0.00430544f, -0.03742803f, -0.00688390f, 0.02915673f, 0.01329830f, 
    0.00950423f, 0.02920111f, 0.02336870f, -0.03069783f, -0.01730289f, 0.00725432f, 0.02659718f, 0.02377985f, 
    -0.01172598f, -0.00407732f, 0.01207372f, 0.00220624f, 0.00843381f, -0.02014938f, 0.02722791f, -0.00719401f, 
    0.02104917f, -0.02840403f, -0.00420227f, 0.00250712f, 0.01066503f, -0.02854161f, 0.00473110f, -0.03061831f, 
    0.02467071f, 0.01724315f, 0.01041204f, -0.04045743f, 0.01610761f, -0.01347442f, -0.02660951f, 0.02162635f, 
    0.02735086f, 0.01627289f, -0.02738935f, 0.02369340f, -0.00735410f, 0.00009131f, -0.02680685f, 0.01620277f, 
    -0.02200610f, -0.03429141f, 0.01888872f, 0.01046726f, -0.00613135f, 0.02613240f, -0.01752378f, -0.01311417f, 
    0.02937704f, 0.00409224f, 0.01083215f, -0.02821837f, -0.01215715f, -0.02131888f, -0.01046793f, 0.02495738f, 
    -0.02373631f, -0.03037412f, 0.02817547f, -0.00221366f, 0.00269742f, 0.01200393f, -0.02434764f, 0.02270055f, 
    0.02517940f, -0.01209994f, 0.03615518f, -0.03184526f, 0.01740419f, -0.01332110f, -0.02270253f, -0.02938284f, 
    -0.03962756f, -0.02010976f, 0.01605733f, -0.03641597f, -0.03066977f, 0.00050396f, 0.01606556f, -0.01628362f, 
    0.01768324f, 0.00927499f, 0.02356627f, 0.01677277f, 0.01782243f, 0.02670304f, -0.02399198f, 0.02359174f, 
    -0.00662407f, 0.00042415f, 0.03644145f, 0.01181255f, -0.03332903f, -0.02758386f, -0.01923498f, -0.03277368f, 
    0.01377114f, -0.03247783f, -0.02084658f, -0.00293792f, 0.02038487f, 0.00318915f, 0.02101778f, -0.00981682f, 
    -0.01583177f, -0.01513491f, 0.03113908f, 0.02946956f, -0.02652337f, -0.02758459f, -0.00678539f, -0.01269436f, 
    0.00663954f, -0.01252419f, 0.02762281f, -0.00740192f, -0.01667336f, 0.00171902f, 0.02647440f, 0.01888800f, 
    -0.02832717f, 0.02131224f, -0.01925625f, -0.03026701f, 0.02938442f, -0.03209276f, -0.02760535f, 0.00686578f, 
    -0.02640394f, -0.00939309f, 0.02788883f, -0.03558544f, -0.02386040f, 0.00297539f, -0.01100164f, -0.00568904f, 
    0.02358685f, 0.01941473f, -0.00235514f, 0.00911891f, -0.02132755f, -0.03187267f, -0.00316190f, -0.00766744f, 
    0.01965567f, 0.02710174f, -0.03678328f, -0.02105319f, 0.04568257f, 0.02633230f, -0.01589594f, -0.01598496f, 
    0.01252897f, -0.02861061f, 0.01929698f, -0.00915628f, -0.03273892f, -0.02809889f, 0.00305287f, 0.01833940f, 
    -0.02798167f, -0.01269586f, 0.01224014f, 0.00860309f, -0.01420456f, 0.02450063f, -0.03163456f, -0.01917118f, 
    -0.04235441f, -0.03363831f, 0.02469472f, -0.00894984f, -0.02265199f, 0.01770205f, -0.00777996f, -0.02694478f, 
    -0.00113087f, 0.02055834f, 0.01789437f, 0.01791528f, 0.00735401f, 0.00265340f, -0.01108678f, 0.02567900f, 
    0.02142267f, 0.03441174f, -0.02671496f, 0.02634129f, 0.02742828f, 0.00092485f, -0.00318226f, -0.01963576f, 
    0.01351549f, -0.02195867f, 0.02402020f, -0.01528175f, -0.03626525f, -0.03356765f, 0.00484926f, 0.01348058f, 
    -0.01889736f, -0.04264889f, 0.02447765f, -0.03357767f, 0.01466960f, -0.01970620f, -0.01597855f, -0.01808366f, 
    0.00049726f, 0.01227520f, 0.03344168f, -0.02394275f, 0.02326017f, 0.00338162f, 0.02272163f, 0.03522648f, 
    0.01603698f, 0.00170167f, -0.03899655f, 0.02237134f, -0.02087286f, -0.03071089f, -0.01320764f, -0.02216115f, 
    -0.01734696f, 0.01219656f, 0.02408508f, -0.01691545f, -0.01477061f, 0.00402590f, 0.02287313f, -0.00899431f, 
    -0.02660848f, -0.01582412f, -0.00615604f, -0.04146632f, -0.02438074f, 0.02375870f, -0.00681299f, -0.00925391f, 
    0.02708978f, 0.00897416f, 0.02805812f, -0.02735281f, -0.02474069f, 0.01446068f, 0.00094060f, -0.01578999f, 
    -0.03783146f, 0.02190842f, -0.02434992f, -0.01202925f, -0.01439575f, -0.02826357f, 0.00833686f, 0.00075768f, 
    0.02118798f, 0.02436747f, -0.01581303f, 0.00183678f, 0.01475991f, -0.01927933f, 0.00635848f, -0.00526683f, 
    0.00505580f, -0.02547095f, -0.02479774f, 0.01347982f, -0.01279979f, -0.00262506f, -0.04131737f, 0.00742657f, 
    -0.22624643f, -0.01278456f, -0.03714005f, 0.08341367f, -0.04718607f, 0.09936299f, 0.10192585f, -0.06638510f, 
    -0.13898353f, 0.02257302f, -0.05437968f, -0.08516926f, 0.33320361f, 0.07826461f, 0.01682146f, 0.33408010f, 
    0.04588839f, 0.09172962f, -0.07205619f, -0.03673552f, 0.08089380f, -0.07600223f, 0.12269080f, 0.07795769f, 
    -0.44732976f, -0.15001164f, -0.03246651f, -0.03728003f, -0.13378005f, 0.15740623f, -0.05059754f, 0.08370131f, 
    -0.06936803f, -0.03609803f, -0.06713654f, -0.03213554f, -0.17828690f, 0.02466802f, -0.09364521f, 0.12015910f, 
    -0.06637667f, 0.09059678f, 0.06031512f, 0.03677106f, 0.00246221f, 0.15943259f, 0.01140489f, -0.10287749f, 
    0.41306463f, 0.28646156f, 0.06334578f, -0.04998250f, -0.06714608f, -0.07543328f, -0.16614498f, 0.23519854f, 
    -0.01236037f, 0.03494674f, 0.11408181f, 0.09856550f, -0.02020656f, 0.12089871f, 0.07142084f, -0.05232389f, 
    -0.10247284f, 0.00107040f, 0.13592552f, -0.00238702f, -0.09593270f, 0.17354077f, 0.15287650f, 0.02466730f, 
    -0.09047715f, 0.15888697f, 0.06738690f, 0.07593661f, -0.01475944f, 0.08836000f, 0.11568050f, 0.01109738f, 
    0.05541510f, 0.12110956f, 0.03740548f, -0.07169329f, 0.19899322f, 0.10025395f, 0.04850814f, -0.06248049f, 
    -0.06418012f, -0.09163595f, -0.01647475f, 0.04360775f, -0.04813710f, -0.10672797f, -0.00197414f, -0.08406851f, 
    0.32165506f, 0.26507100f, 0.10998483f, -0.12371103f, 0.01718852f, -0.05157688f, -0.07291497f, 0.03437996f, 
    0.02448286f, -0.05072412f, -0.04738833f, 0.12236769f, -0.13459051f, 0.00833268f, -0.17768495f, -0.02009627f, 
    -0.10707459f, -0.16026726f, -0.13274905f, 0.08743764f, -0.02073910f, 0.00021749f, -0.06542623f, 0.15700933f, 
    0.03036709f, -0.07568614f, 0.03068536f, -0.03806872f, -0.09407229f, -0.08791105f, -0.06687643f, -0.10998021f, 
    -0.10876979f, 0.09288982f, 0.20965630f, -0.03482399f, 0.34761152f, 0.06402274f, 0.08462078f, 0.26270995f, 
    -0.06049761f, 0.00268691f, 0.05866736f, 0.03681390f, 0.06005524f, -0.05769746f, -0.02762922f, -0.01405412f, 
    0.19236620f, 0.11360057f, -0.01683101f, 0.06331660f, 0.07545568f, 0.00351074f, -0.08319112f, 0.11907695f, 
    0.01455793f, 0.11937650f, 0.10396411f, 0.13857865f, -0.13710284f, -0.23595476f, 0.18302101f, -0.00255958f, 
    0.13163021f, 0.17008832f, -0.02146666f, 0.13413294f, 0.01222662f, -0.02439089f, -0.02246412f, 0.10265494f, 
    0.24242029f, -0.03665626f, 0.10298962f, -0.04509583f, 0.01424723f, -0.10959944f, -0.00733185f, 0.00796075f, 
    0.00907322f, 0.01191308f, -0.10275122f, 0.01971656f, -0.19609669f, 0.25102621f, -0.08384237f, -0.03558931f, 
    0.02784341f, 0.05455579f, 0.10285585f, -0.01857752f, -0.17114323f, -0.16537000f, -0.12584344f, -0.01605753f, 
    -0.06690798f, -0.08414891f, -0.01721010f, 0.04929276f, -0.14862911f, 0.06691197f, -0.01122428f, 0.14719559f, 
    -0.11351785f, 0.01325226f, 0.07809142f, -0.09609707f, 0.08315915f, -0.22477163f, 0.00375311f, -0.06201085f, 
    -0.06029749f, 0.13773260f, 0.06981428f, -0.02798585f, -0.17540744f, 0.01258748f, -0.04207814f, 0.16798416f, 
    0.13129355f, -0.26453793f, 0.01566755f, 0.06036019f, -0.08787147f, 0.07070472f, 0.02108288f, 0.05833093f, 
    -0.14102334f, 0.15915696f, 0.21002625f, 0.09521969f, 0.03612796f, 0.15262583f, 0.10871916f, -0.07492281f, 
    -0.03109732f, 0.00115172f, -0.07809497f, 0.03370397f, 0.09825984f, 0.07450804f, -0.07879525f, -0.05271999f, 
    0.47038448f, 0.18055299f, 0.02032477f, 0.06853686f, 0.00547420f, 0.04041069f, -0.06772372f, 0.04839998f, 
    0.01645215f, 0.09125835f, 0.07203117f, 0.18432406f, -0.42719650f, -0.11745887f, 0.00923110f, -0.05252407f, 
    0.00869801f, -0.06081109f, 0.01520152f, -0.00717737f, 0.17087883f, 0.02699543f, -0.07908860f, -0.08970921f, 
    0.17024514f, -0.04663960f, -0.02465269f, -0.03001328f, -0.08587281f, 0.00478591f, -0.05011758f, -0.02460458f, 
    0.07672980f, -0.02318112f, -0.04984742f, 0.09957732f, 0.02706966f, -0.13373853f, 0.14103034f, 0.24447091f, 
    -0.10453962f, 0.16117766f, 0.02686389f, 0.00812197f, -0.07625072f, -0.00386693f, -0.09774739f, 0.01700074f, 
    -0.43078971f, 0.09844048f, 0.02410629f, -0.09901056f, -0.03764817f, -0.15160115f, 0.06535823f, -0.07138568f, 
    -0.01915241f, -0.16948679f, 0.00294725f, -0.07191793f, -0.01665145f, 0.11913840f, -0.32201415f, 0.28673369f, 
    -0.05223724f, 0.14940399f, 0.02315219f, -0.13436560f, -0.01757857f, 0.06159311f, -0.08561460f, -0.02839608f, 
    -0.04564723f, -0.02881523f, -0.03226555f, 0.06298044f, -0.19784915f, 0.00082046f, 0.15753026f, 0.02717016f, 
    -0.00102567f, 0.05061153f, -0.15707386f, 0.00826389f, 0.30872390f, -0.12171631f, -0.02636445f, -0.07956065f, 
    -0.07745057f, 0.03290767f, 0.03716896f, 0.00522404f, 0.05615722f, -0.03279134f, 0.15387937f, 0.00816673f, 
    -0.08687061f, -0.22138983f, -0.07032258f, -0.03479984f, -0.10864383f, -0.07909789f, 0.14521389f, 0.07881216f, 
    0.07005381f, 0.02154037f, 0.02860279f, -0.09886726f, 0.02746634f, -0.12672235f, -0.22317630f, 0.09956470f, 
    0.00138377f, 0.10956927f, 0.08600318f, 0.00357738f, 0.02334104f, 0.05525653f, -0.06751453f, -0.02185953f, 
    -0.02170551f, 0.04397052f, 0.04518153f, 0.06087647f, -0.00133115f, -0.10578876f, 0.10648874f, -0.01058505f, 
    0.10032994f, -0.02510910f, 0.22335899f, -0.12785211f, -0.10898698f, -0.15710092f, 0.04198686f, 0.22411998f, 
    -0.19683100f, 0.17112237f, -0.04741480f, -0.00107995f, 0.04057754f, -0.12624629f, 0.07244723f, -0.00714168f, 
    0.12209343f, 0.15159971f, 0.03823986f, -0.11432125f, -0.00424520f, -0.05946787f, 0.15010989f, 0.05277137f, 
    -0.04885476f, 0.00459015f, -0.05232195f, -0.04402553f, -0.03787725f, -0.14419568f, -0.02034406f, -0.02189708f, 
    -0.01364689f, -0.04843174f, -0.03721561f, 0.03511672f, -0.01780521f, -0.15985660f, -0.04369728f, -0.10325871f, 
    -0.04569919f, 0.04733736f, -0.00725424f, -0.01357060f, -0.13443324f, -0.05663678f, 0.07185413f, 0.19418110f, 
    -0.04789128f, 0.08712431f, -0.10961322f, 0.11383360f, 0.19920202f, 0.13615179f, -0.08143757f, 0.07712352f, 
    -0.17474467f, 0.02761699f, 0.04142071f, -0.06136057f, -0.07127398f, -0.11114893f, -0.13723204f, 0.11180247f, 
    0.33606732f, 0.00376318f, 0.08622360f, 0.13187352f, 0.04703238f, -0.01904725f, -0.07198974f, 0.04878833f, 
    0.07420674f, -0.05095124f, 0.02440140f, -0.13150708f, 0.08016449f, 0.02340772f, 0.05070478f, 0.07605760f, 
    0.03206445f, 0.15513673f, 0.11902443f, -0.13072373f, 0.00946079f, 0.12629218f, -0.11631387f, 0.20267300f, 
    -0.08951741f, -0.06317938f, -0.03233175f, -0.11465991f, 0.01988599f, -0.05219401f, 0.10285428f, -0.02399067f, 
    0.06065083f, -0.13923861f, -0.21540833f, 0.07497673f, 0.01846815f, -0.08388630f, -0.04970894f, 0.04050776f, 
    0.00925131f, -0.00174629f, 0.14453951f, 0.07236194f, 0.02499667f, -0.02003632f, -0.05485664f, 0.10380520f, 
    -0.04077373f, 0.00489259f, 0.18032233f, 0.00280130f, -0.07310595f, 0.16695143f, -0.15911959f, -0.05420754f, 
    0.03949502f, -0.00108200f, 0.12707357f, 0.03326531f, 0.02222331f, 0.20915212f, 0.03232196f, -0.02544802f, 
    0.02609304f, 0.07205116f, -0.03250343f, -0.11297335f, 0.01497515f, 0.08403037f, -0.11948869f, 0.14580032f, 
    -0.04938279f, -0.09284589f, -0.04712256f, -0.00691857f, -0.02136378f, 0.02942074f, -0.08764415f, -0.01792969f, 
    -0.03358413f, -0.06856194f, 0.15786439f, 0.20007107f, 0.50093204f, -0.17411543f, 0.18102473f, 0.08828818f, 
    -0.05984666f, 0.05560317f, -0.07505409f, 0.05338279f, -0.02515259f, 0.04835979f, -0.02099283f, 0.04111388f, 
    0.34551853f, 0.14236388f, -0.04011295f, -0.21933337f, -0.00109086f, 0.05711810f, 0.02198190f, -0.06213064f, 
    0.18970208f, 0.06490928f, 0.00008061f, -0.11665085f, -0.29808006f, 0.21288690f, -0.06549509f, 0.21195370f, 
    -0.09811325f, 0.06491400f, -0.00688298f, 0.02923069f, 0.05850658f, 0.05942612f, -0.00582803f, 0.04356059f, 
    0.13139150f, -0.06919845f, 0.31519848f, 0.07422706f, -0.10645032f, 0.01926115f, -0.10228914f, -0.13946748f, 
    0.04373457f, 0.04670285f, 0.05051147f, -0.00867296f, 0.35418999f, 0.31447294f, 0.25862551f, -0.04934725f, 
    0.08884171f, -0.12467039f, -0.02887397f, 0.18991400f, -0.07742535f, -0.00037100f, -0.10628447f, 0.09293325f, 
    0.31205323f, 0.29461950f, 0.05191786f, -0.03135840f, 0.16241093f, 0.20980528f, 0.06281310f, -0.02104833f, 
    -0.03193220f, 0.08505397f, -0.24388392f, 0.12483252f, 0.43466046f, 0.15045965f, 0.09966801f, -0.02061445f, 
    -0.04007776f, -0.06616732f, 0.12522866f, 0.06274855f, 0.09641296f, 0.06125158f, -0.05456393f, 0.09533369f, 
    0.05720210f, 0.14610593f, 0.02672408f, 0.11470487f, 0.09569474f, 0.11794284f, -0.00324597f, -0.05641440f, 
    -0.08788907f, -0.08136930f, 0.03318531f, 0.02108060f, 0.37953159f, -0.01252906f, 0.07656767f, -0.07299730f, 
    -0.15101951f, 0.08145593f, -0.02447863f, 0.11901914f, 0.02964104f, 0.00312077f, 0.09800388f, -0.12868108f, 
    -0.12755442f, 0.09167356f, -0.12440214f, 0.10879248f, -0.01841815f, 0.06365804f, -0.01457866f, 0.01972914f, 
    0.01071320f, 0.08978145f, -0.07213790f, 0.05045586f, -0.07610650f, 0.09661352f, 0.23995788f, -0.11443447f, 
    0.00881177f, -0.03389819f, 0.26309934f, 0.01894384f, -0.08361972f, 0.09524894f, 0.06861514f, 0.09658586f, 
    0.58107507f, -0.04437251f, 0.17667247f, 0.21811830f, -0.05955609f, 0.01526730f, -0.12278998f, 0.04030937f, 
    -0.00243397f, 0.03458815f, 0.02165163f, 0.27261573f, 0.09539160f, -0.15672418f, -0.13017945f, 0.06874010f, 
    -0.09566386f, 0.00275818f, 0.11550385f, -0.13211544f, 0.04192838f, -0.13594761f, 0.04620085f, 0.03049459f, 
    0.10080177f, -0.08350989f, -0.03619833f, 0.02407539f, -0.20821863f, 0.04837379f, -0.04946966f, 0.16860808f, 
    -0.10577092f, 0.11232888f, 0.01084595f, 0.03281834f, -0.70915896f, -0.28247908f, -0.02059465f, 0.09238026f, 
    -0.18867150f, 0.01027107f, 0.09819102f, -0.00439167f, -0.00581583f, 0.08634336f, -0.05236558f, -0.13864307f, 
    -0.39149523f, -0.41647559f, 0.03465297f, 0.16416681f, -0.03001431f, 0.04302026f, 0.03186845f, 0.07353299f, 
    0.00344672f, 0.23430781f, 0.07802365f, -0.23065166f, 0.19923104f, 0.04377010f, 0.06758321f, 0.20409350f, 
    0.10030290f, -0.01248774f, 0.11153696f, -0.01953123f, 0.07131353f, 0.03895191f, -0.24325950f, 0.00635035f, 
    -0.28767484f, 0.00033275f, -0.07652567f, 0.01089961f, 0.02246331f, 0.08021121f, -0.06368066f, -0.08527436f, 
    -0.06521504f, 0.05663934f, 0.07927684f, 0.20848507f, -0.00392403f, -0.04988882f, 0.05316430f, 0.03202354f, 
    0.02260238f, -0.05604472f, -0.22761978f, 0.11791659f, -0.13572657f, -0.02604958f, -0.03320516f, -0.09561459f, 
    0.18333742f, -0.04279543f, 0.03978711f, -0.11421253f, -0.00449680f, 0.18939647f, 0.15917030f, -0.01815980f, 
    -0.01829015f, -0.00111156f, 0.04387252f, 0.06702074f, 0.20807651f, 0.08236591f, 0.15492083f, -0.19078231f, 
    -0.02247456f, 0.08439241f, -0.12090153f, 0.03414227f, 0.11517555f, -0.06078108f, 0.12843721f, -0.08338653f, 
    -0.01011515f, 0.00626803f, 0.01594499f, 0.02254930f, -0.02494275f, 0.00121243f, 0.01265673f, -0.02561735f, 
    0.01475472f, -0.00735583f, -0.04334118f, -0.02066474f, -0.02917672f, -0.00336552f, -0.03058089f, -0.00164083f, 
    -0.00249238f, -0.03103914f, 0.02537558f, -0.01234165f, 0.02390755f, -0.03679657f, -0.03425153f, -0.01771807f, 
    -0.00190912f, -0.03226478f, -0.03647803f, -0.00721626f, -0.02223331f, 0.03297813f, -0.01339054f, -0.01182435f, 
    0.00422312f, 0.01077393f, -0.01546225f, 0.00911864f, 0.02660220f, 0.03022593f, 0.01356744f, 0.01027778f, 
    -0.00597337f, 0.02439001f, 0.02902522f, -0.02522835f, 0.01794527f, -0.00511825f, 0.01287165f, 0.00836665f, 
    -0.02054538f, 0.01070657f, 0.01195512f, -0.00915453f, -0.04192980f, 0.00603020f, 0.01227694f, 0.01569213f, 
    -0.01948948f, -0.01293814f, -0.03423052f, -0.00776160f, -0.00096441f, -0.00453053f, -0.02468619f, 0.02484613f, 
    0.00394109f, -0.02318680f, -0.04324073f, -0.00635065f, 0.02118443f, 0.01741299f, -0.01919568f, -0.03380547f, 
    -0.00789642f, -0.00846036f, 0.01439162f, 0.00840258f, 0.00419680f, 0.02230410f, -0.03901096f, -0.02126520f, 
    0.00218353f, -0.01846564f, -0.03622711f, -0.01692416f, 0.01297230f, -0.02289258f, 0.00201426f, -0.01104778f, 
    0.00523508f, -0.02649929f, -0.02139197f, -0.03564434f, -0.01221711f, 0.02028061f, 0.00721517f, -0.00879763f, 
    0.01350517f, 0.01634940f, -0.01518546f, -0.00148670f, -0.01130328f, -0.03638583f, -0.00114068f, -0.01032426f, 
    0.00180118f, -0.03310985f, -0.01464119f, 0.01239634f, -0.03853745f, 0.00222271f, -0.03590263f, -0.00218530f, 
    -0.04192551f, -0.00584575f, 0.02080363f, -0.00989086f, 0.01987233f, 0.00756481f, -0.00894793f, -0.01379153f, 
    -0.02837856f, -0.00313597f, 0.01617125f, -0.00919464f, 0.02507101f, 0.03129421f, 0.00590572f, -0.04176399f, 
    -0.00899642f, 0.00175894f, 0.03279848f, 0.01780744f, 0.00648735f, 0.02406607f, -0.02465431f, -0.02401472f, 
    0.00511359f, -0.04490715f, -0.02103244f, 0.02248571f, -0.03071330f, -0.02171840f, -0.03237843f, -0.03478358f, 
    -0.04003928f, 0.00208434f, -0.01833270f, -0.01030439f, -0.03181926f, -0.01364029f, 0.02244755f, -0.00121551f, 
    0.00605223f, -0.00818288f, -0.02740412f, -0.00837680f, -0.01674755f, -0.02905953f, -0.01132537f, -0.00792948f, 
    0.01897357f, -0.00950766f, -0.04112686f, 0.02831821f, -0.03208249f, 0.00206318f, -0.00441686f, 0.03375395f, 
    0.03040966f, -0.02881496f, -0.00795021f, 0.03402493f, -0.01228510f, 0.01269292f, -0.02955383f, 0.00575344f, 
    -0.03590169f, 0.01033486f, 0.01719190f, 0.01964906f, -0.02355224f, -0.00919904f, -0.00531545f, -0.00295310f, 
    -0.01391209f, 0.00884071f, -0.00080958f, -0.00234413f, 0.02867363f, 0.02022330f, 0.00838724f, 0.02410893f, 
    -0.02516478f, 0.00496747f, -0.04331815f, -0.01756583f, -0.02873285f, -0.01798873f, -0.03910080f, 0.01514577f, 
    -0.01407015f, -0.01596352f, 0.00669674f, -0.02487598f, -0.00558596f, -0.03294280f, 0.01863930f, 0.02418657f, 
    0.03091138f, -0.00153030f, -0.02822104f, -0.02049706f, -0.03037332f, -0.03634702f, -0.01138254f, -0.02664302f, 
    0.00641974f, -0.00908701f, -0.02751784f, -0.01398580f, 0.02010428f, -0.02134061f, -0.01700788f, -0.00766253f, 
    0.02042533f, -0.03045578f, -0.00578440f, 0.00873911f, -0.00110124f, -0.03589910f, 0.00316371f, -0.01475871f, 
    -0.02067914f, -0.00898541f, 0.02391102f, 0.02129951f, 0.00862462f, 0.00772146f, -0.00201285f, -0.01332476f, 
    0.01322589f, 0.01736182f, -0.00219865f, -0.02033419f, -0.01201377f, -0.02708451f, -0.01133842f, -0.00317555f, 
    -0.02534315f, -0.01770902f, -0.01509721f, 0.01860142f, -0.01016776f, -0.03161316f, 0.00966894f, -0.03625518f, 
    -0.03590257f, -0.01069434f, -0.02461337f, 0.01069262f, -0.02700133f, 0.02869652f, -0.01532026f, 0.00861329f, 
    0.00145045f, 0.02162818f, -0.01832488f, 0.02616402f, -0.02094773f, 0.00543963f, -0.01708512f, -0.01775760f, 
    0.00306011f, -0.00895838f, 0.02380222f, -0.03561920f, -0.03138988f, 0.01151795f, -0.04293450f, 0.01463360f, 
    0.02043390f, -0.02882383f, 0.01370754f, -0.03003068f, 0.01595159f, -0.01312795f, -0.00827754f, 0.02246999f, 
    -0.00994991f, -0.03683487f, -0.02235403f, -0.02507089f, -0.00620632f, 0.02288133f, 0.02464344f, 0.00497213f, 
    -0.00636289f, -0.00434714f, -0.02780186f, -0.03919766f, 0.00086746f, 0.02539262f, 0.00689530f, -0.03039322f, 
    0.01143240f, -0.00860340f, -0.00395275f, 0.02384550f, 0.00293544f, 0.01597227f, 0.02796943f, 0.01330889f, 
    -0.00349556f, -0.02506269f, 0.02307792f, -0.00257592f, -0.04047526f, 0.00092789f, 0.00085869f, 0.00822662f, 
    -0.01376402f, -0.01034066f, 0.00564619f, 0.00432425f, 0.00753997f, -0.02968502f, 0.03179984f, 0.01246352f, 
    0.02054200f, -0.01582152f, 0.02746913f, -0.00972338f, -0.03563300f, -0.02791207f, -0.01768764f, -0.00483508f, 
    0.01285634f, -0.00190468f, -0.04435590f, -0.03185202f, 0.01265682f, -0.04200821f, 0.01547586f, 0.00907803f, 
    -0.00261834f, -0.00144518f, 0.02010367f, -0.01643375f, -0.02833023f, 0.02908074f, 0.02798398f, -0.02934556f, 
    -0.02986914f, -0.00779432f, 0.00225135f, 0.03929065f, 0.00036928f, -0.01886173f, 0.01870427f, 0.00543314f, 
    0.00966576f, 0.00145638f, -0.00154431f, -0.02439784f, 0.00922772f, -0.02473151f, -0.02348516f, -0.03051303f, 
    -0.03388231f, 0.01485935f, 0.01084662f, -0.02554515f, -0.03769524f, 0.03323441f, 0.00016433f, -0.03570016f, 
    0.01937070f, 0.00320627f, -0.04294103f, 0.03023116f, -0.00997439f, 0.02364019f, 0.00022073f, -0.00106202f, 
    0.02493174f, -0.02939868f, -0.01736879f, 0.01013551f, -0.03911968f, 0.02403086f, -0.02904610f, -0.04052854f, 
    -0.03518968f, -0.00445532f, 0.01167018f, 0.02639025f, -0.02838387f, -0.00087068f, -0.00401314f, 0.01059780f, 
    -0.01911263f, -0.03409358f, 0.02270711f, -0.01304124f, -0.01681273f, -0.03593484f, -0.02706644f, 0.02120263f, 
    -0.04089871f, 0.01060897f, 0.02847226f, 0.00494713f, 0.01399789f, -0.01084899f, 0.00697643f, -0.00912543f, 
    0.01623168f, -0.00318391f, -0.02528628f, -0.03294661f, -0.01840215f, -0.00815241f, 0.00285098f, 0.02388966f, 
    -0.03755445f, -0.01268118f, -0.02903761f, -0.01529266f, 0.00250662f, -0.01276613f, 0.00022822f, -0.00661696f, 
    -0.02897216f, 0.00112806f, -0.03533506f, -0.03914674f, 0.02565306f, 0.02249050f, -0.01880637f, -0.02368898f, 
    0.01511474f, 0.02555039f, 0.01857007f, -0.03796443f, 0.02187615f, -0.01436066f, 0.00146667f, 0.02298287f, 
    0.01473524f, -0.03591279f, -0.00780047f, -0.02057232f, 0.00799658f, 0.00928403f, 0.02442192f, -0.03203610f, 
    -0.00216892f, -0.03985650f, -0.02495642f, 0.00612933f, 0.01910796f, -0.00505723f, -0.03148828f, -0.00896801f, 
    0.01168259f, -0.03488297f, -0.02482910f, 0.02349648f, -0.01999101f, -0.00995404f, -0.00659627f, 0.00565995f, 
    -0.03075548f, -0.00498633f, -0.03087373f, -0.01837624f, -0.04013062f, -0.03823047f, -0.02985033f, 0.01711320f, 
    0.01437876f, -0.04295642f, -0.00815733f, -0.00164781f, -0.00343500f, -0.03842597f, -0.04121680f, 0.00518475f, 
    -0.01415785f, 0.01738559f, 0.02077076f, -0.01021029f, -0.03856412f, 0.02583743f, -0.01800962f, 0.02409634f, 
    0.00910373f, 0.02017387f, -0.03318519f, 0.01503946f, 0.00660082f, -0.00106776f, 0.00160496f, 0.01239313f, 
    -0.01524351f, -0.03161313f, -0.00447925f, -0.02169054f, 0.02551845f, 0.00962122f, 0.01727803f, 0.02745201f, 
    -0.03400477f, 0.00486826f, -0.00927773f, 0.02213651f, 0.03643375f, 0.02567766f, 0.01353009f, 0.00114080f, 
    -0.02484412f, -0.01346929f, -0.01463454f, -0.00953654f, -0.00591340f, -0.01923485f, -0.01146982f, 0.01630548f, 
    -0.03907940f, -0.02966911f, 0.02754661f, -0.02621596f, 0.01867767f, 0.03109286f, -0.00779727f, -0.02472302f, 
    -0.03790925f, 0.00456721f, -0.01438505f, 0.03064327f, -0.03256495f, 0.00190299f, 0.00808749f, 0.01488814f, 
    -0.01150003f, 0.00423277f, 0.00007018f, -0.04145474f, 0.01142834f, 0.00508836f, -0.01689724f, -0.00472455f, 
    0.01701167f, 0.01880234f, 0.00902305f, -0.02918124f, -0.02413559f, -0.00678281f, -0.02495861f, -0.03884809f, 
    -0.01300286f, 0.00790966f, -0.01951787f, -0.03031877f, -0.00118826f, -0.00935555f, 0.02124264f, -0.03664071f, 
    -0.01454604f, -0.02856780f, -0.01686430f, 0.00318088f, 0.02183074f, -0.00401308f, 0.01546517f, 0.00117260f, 
    -0.01457275f, 0.02321568f, -0.03323519f, -0.00106459f, -0.02641471f, -0.00541833f, 0.00822665f, 0.00341468f, 
    0.02887328f, -0.00871906f, 0.01510589f, 0.02119802f, -0.02579552f, 0.01314746f, 0.01619264f, -0.01347028f, 
    0.00146639f, -0.01091408f, 0.02025998f, -0.01213679f, -0.01691978f, -0.02592152f, 0.02193686f, 0.00349997f, 
    0.02281300f, 0.01123875f, -0.01961598f, -0.02776350f, 0.02595958f, -0.03626154f, -0.00685283f, 0.02047206f, 
    -0.04173135f, -0.00466170f, 0.00039579f, -0.03157510f, -0.04304590f, -0.02325243f, -0.01480100f, -0.01610901f, 
    0.00879706f, 0.01785851f, -0.03907210f, -0.03302753f, -0.00175387f, 0.02494380f, -0.02259887f, 0.00958855f, 
    -0.03475265f, -0.00076688f, 0.01776200f, 0.02268872f, 0.02628990f, 0.02986927f, 0.02385112f, -0.02929360f, 
    -0.01503901f, 0.02819671f, 0.01850799f, -0.00479317f, 0.02703664f, -0.01694907f, -0.00566372f, -0.00372650f, 
    -0.02727245f, -0.03472634f, -0.01787068f, -0.01322395f, -0.04299488f, 0.02036886f, -0.01372190f, -0.01960355f, 
    0.01674455f, 0.01833829f, -0.02094597f, 0.01652303f, 0.00135694f, -0.01440993f, -0.02818837f, 0.00571048f, 
    0.02052875f, -0.03068527f, -0.00857993f, -0.00022798f, -0.02507447f, -0.00056098f, -0.01494826f, -0.03522956f, 
    -0.03013902f, -0.00818835f, -0.02768273f, -0.01950784f, 0.02693770f, 0.00616084f, -0.01999724f, -0.02510454f, 
    0.01038786f, -0.02160070f, -0.01616251f, -0.00576585f, -0.00979416f, 0.00455945f, -0.02386398f, 0.01281207f, 
    -0.00105597f, 0.01747664f, 0.02835997f, 0.02809725f, 0.02188971f, 0.00801222f, 0.01435292f, -0.01041007f, 
    -0.03323241f, 0.02195645f, -0.01123784f, 0.00137417f, 0.02021496f, -0.03535765f, -0.02985818f, 0.00839391f, 
    0.01395354f, -0.02620668f, 0.01541682f, -0.00067537f, -0.00247167f, -0.01972132f, -0.00889170f, -0.03557913f, 
    -0.01608915f, 0.01272730f, 0.01942233f, 0.02541294f, -0.03801468f, -0.00089310f, -0.00274072f, -0.02087141f, 
    0.00926219f, -0.00967330f, 0.03733336f, -0.03932291f, 0.00862093f, 0.00190942f, 0.00031715f, 0.01343858f, 
    -0.03094272f, -0.02489648f, -0.04471800f, -0.03905217f, -0.02748423f, -0.02734158f, 0.02400944f, 0.01333229f, 
    -0.02448341f, -0.01278700f, -0.01516144f, 0.02680576f, -0.01618798f, 0.01265579f, -0.02215597f, -0.00507692f, 
    0.01894399f, -0.03424888f, 0.01912458f, -0.00716269f, -0.02899580f, -0.03585546f, 0.00176797f, -0.01748135f, 
    0.00211805f, -0.01709348f, 0.03402956f, 0.00137201f, 0.00898918f, -0.04012993f, 0.01018967f, -0.04276524f, 
    0.02466404f, -0.00564529f, 0.02520125f, 0.00476152f, -0.01003294f, 0.00284068f, 0.02012904f, -0.01441808f, 
    -0.00888723f, -0.00600088f, 0.02095814f, -0.02261940f, -0.00791350f, -0.00901411f, 0.02633317f, -0.02797244f, 
    -0.03581527f, -0.00592493f, -0.03232379f, 0.01387218f, -0.00068170f, 0.02235121f, -0.01394278f, 0.02361317f, 
    -0.01333427f, -0.00108152f, 0.00875812f, -0.00503362f, 0.01159877f, -0.01582334f, 0.00238098f, -0.03217121f, 
    0.00806058f, -0.01793485f, -0.03668426f, 0.02149423f, -0.01755915f, 0.01451832f, -0.01501116f, -0.01322733f, 
    0.02688014f, 0.00338908f, 0.02335309f, -0.00290753f, 0.02535027f, -0.00015094f, 0.02197838f, 0.01069332f, 
    0.02000997f, -0.03174379f, 0.03156506f, -0.01833760f, -0.00901414f, 0.02295991f, -0.00542445f, -0.00229155f, 
    -0.00051570f, -0.03789628f, 0.02077391f, 0.02745466f, -0.01969106f, 0.01747246f, 0.01635121f, -0.01198932f, 
    -0.02764981f, 0.02411649f, 0.00133271f, -0.02029478f, -0.03402520f, 0.02069281f, -0.01139337f, 0.02475770f, 
    0.02188923f, -0.00094466f, -0.02377391f, 0.00386691f, -0.00457280f, 0.01858944f, 0.02810403f, 0.02027481f, 
    0.01170604f, 0.02338683f, 0.01263494f, -0.03881676f, -0.02067101f, 0.01210414f, 0.02284174f, -0.00782597f, 
    -0.03056247f, 0.01071304f, -0.03327838f, 0.01197514f, 0.03211955f, -0.02745013f, 0.00981865f, 0.01327755f, 
    0.02012280f, 0.01764455f, -0.02629848f, 0.00150226f, -0.02043698f, 0.02692732f, -0.00210844f, -0.00066613f, 
    -0.04213447f, -0.00975296f, 0.00680242f, 0.00670464f, 0.02507725f, -0.02394823f, 0.02092255f, -0.03293357f, 
    -0.01561545f, -0.01843170f, 0.00618303f, -0.00605744f, -0.03229524f, -0.02281863f, 0.00721160f, 0.02917567f, 
    0.02049923f, 0.01590767f, -0.03692157f, -0.02372008f, 0.02197167f, -0.02369409f, 0.00445660f, -0.03459945f, 
    -0.00825141f, -0.01656276f, 0.01966716f, -0.01807821f, -0.00424816f, 0.00376034f, 0.01141775f, -0.00542994f, 
    -0.01779938f, -0.00181275f, -0.02116714f, -0.03636405f, 0.01075260f, 0.01813117f, 0.03964589f, 0.03289883f, 
    -0.03308897f, -0.02234719f, 0.02497977f, -0.02099328f, 0.01879369f, -0.00955455f, -0.00048035f, 0.01366035f, 
    0.00282517f, 0.02363035f, -0.02201400f, 0.02726248f, -0.01887533f, -0.03828587f, -0.02832724f, -0.01124143f, 
    0.02271351f, 0.03967638f, -0.00252888f, 0.00844507f, 0.03047759f, -0.01349118f, 0.01949054f, -0.01167697f, 
    -0.00537486f, 0.01138346f, -0.01065362f, -0.02400880f, 0.00641203f, 0.01413358f, 0.01870700f, 0.01852744f, 
    0.02232475f, 0.02732452f, 0.01004316f, 0.03077729f, 0.02581942f, 0.00072705f, -0.01003347f, 0.02410113f, 
    0.02156184f, 0.01367083f, -0.01967819f, -0.02261505f, 0.00481477f, 0.00706366f, 0.01613644f, 0.01472542f, 
    0.03884233f, 0.01399452f, 0.01708120f, -0.01237092f, 0.03883174f, -0.01459535f, 0.03578819f, 0.03721947f, 
    -0.03567964f, -0.02352615f, -0.00127181f, -0.02229635f, 0.01540410f, -0.02263637f, -0.03188473f, -0.02807002f, 
    0.02596825f, -0.00542817f, -0.02935909f, -0.00389387f, 0.02429106f, -0.01474623f, -0.02313868f, 0.01258952f, 
    0.00376784f, -0.04132583f, -0.00559362f, -0.00881381f, 0.01727209f, 0.01547993f, 0.01793956f, -0.02557323f, 
    -0.00050162f, -0.00216364f, -0.01884176f, -0.00298177f, -0.02445402f, -0.02739771f, 0.01031364f, 0.01894843f, 
    -0.01259992f, -0.02298586f, 0.00194300f, 0.00752527f, -0.04059821f, -0.00536654f, -0.01207898f, 0.02295033f, 
    -0.02377890f, 0.00705724f, -0.02014293f, -0.02560508f, -0.01259382f, -0.02981574f, -0.03994837f, -0.03913894f, 
    0.00473571f, -0.00720801f, 0.02880520f, -0.00476947f, -0.02300764f, 0.00030006f, -0.00579017f, 0.00951416f, 
    0.00107667f, 0.00963768f, -0.02376198f, 0.01084510f, 0.02260185f, 0.01153608f, -0.01267239f, 0.03605364f, 
    0.01818348f, 0.01654834f, 0.00804236f, -0.03846704f, -0.02839424f, 0.00639881f, -0.03285053f, 0.01630076f, 
    0.02784083f, -0.00746048f, 0.01004375f, 0.02490554f, -0.02235397f, 0.00394624f, -0.03256070f, 0.01497594f, 
    0.02184640f, 0.01136266f, 0.02261646f, 0.02707472f, 0.01998506f, -0.02438636f, 0.01602537f, 0.00350913f, 
    -0.00744994f, -0.01104957f, -0.01553416f, 0.00485682f, 0.01112653f, -0.00213417f, 0.01106278f, -0.01473208f, 
    -0.03718892f, -0.03965939f, 0.03795084f, 0.02470757f, 0.00334037f, -0.02093122f, 0.01429095f, 0.01367385f, 
    -0.03188232f, -0.03334160f, 0.00515965f, -0.02899252f, -0.01123353f, 0.00604577f, -0.02822189f, 0.02086011f, 
    0.02260968f, -0.03338564f, 0.00423432f, 0.03238002f, 0.02550073f, -0.02959360f, 0.02251268f, -0.02582677f, 
    0.02040677f, -0.00382356f, 0.00053806f, -0.03786288f, 0.00026530f, 0.00223607f, 0.01250394f, -0.00006153f, 
    -0.03406010f, -0.00051075f, -0.00066414f, 0.02584200f, 0.00315759f, -0.02431581f, 0.00154996f, 0.00096442f, 
    -0.00298179f, 0.02533495f, -0.02990123f, 0.02886413f, -0.00260747f, 0.02700327f, 0.02953909f, -0.01158938f, 
    0.01567263f, 0.01718866f, 0.00329954f, 0.01949447f, -0.02051977f, -0.03253621f, 0.00514896f, -0.03207373f, 
    -0.01124568f, -0.01106652f, -0.02096140f, -0.02025161f, 0.01316203f, 0.01167275f, -0.02071026f, 0.02753981f, 
    0.01027365f, -0.01898796f, 0.02729225f, -0.01878934f, -0.00303421f, -0.03528089f, 0.01607630f, 0.00873221f, 
    0.02452320f, 0.00824201f, 0.02489529f, 0.02031235f, 0.01324243f, 0.03083733f, -0.01569496f, 0.01158232f, 
    0.01143102f, -0.04076342f, 0.00975750f, -0.03495624f, 0.02492701f, 0.01351991f, 0.02041863f, -0.00288254f, 
    0.01340618f, -0.02590378f, 0.03801682f, -0.03400397f, 0.00127654f, -0.02758215f, 0.00821845f, -0.01498937f, 
    -0.01065015f, 0.00076930f, -0.01814913f, 0.01535165f, -0.03964340f, 0.02886624f, -0.02419323f, 0.01496714f, 
    0.02212078f, -0.01153403f, -0.01135889f, -0.03251383f, 0.00762843f, 0.02250511f, -0.02049187f, -0.02915195f, 
    0.01483319f, 0.02765063f, -0.00624746f, -0.03967634f, -0.03096348f, -0.02789051f, 0.03523935f, -0.02547313f, 
    -0.00006919f, -0.02696857f, -0.02122145f, -0.02367599f, 0.00495035f, -0.00138967f, 0.00260485f, -0.01508469f, 
    0.01428587f, -0.02216535f, 0.00633959f, -0.00640094f, 0.00253989f, 0.00818321f, 0.00804709f, -0.01826232f, 
    0.03716156f, -0.03766885f, 0.03944762f, -0.01569411f, -0.01059172f, 0.03079088f, 0.00396773f, -0.03452132f, 
    -0.01767132f, -0.00073542f, -0.01315834f, -0.02177847f, -0.00139164f, 0.00025947f, -0.00904233f, -0.03602398f, 
    0.03132606f, -0.03300554f, -0.03380801f, 0.00486867f, -0.01061071f, 0.02296520f, 0.01963432f, 0.02614398f, 
    -0.02515159f, -0.00672428f, -0.02203602f, -0.02536134f, -0.03592103f, 0.02230616f, -0.02424996f, 0.01356258f, 
    0.01177158f, 0.01881908f, -0.00694367f, -0.00684199f, 0.01828569f, -0.00979912f, -0.00476075f, 0.00031643f, 
    -0.03576754f, -0.01957766f, -0.00714066f, -0.01730320f, 0.02823163f, 0.03645977f, -0.00631831f, 0.00247319f, 
    -0.03111017f, -0.03313569f, 0.01120175f, 0.02675248f, -0.02360181f, 0.02384378f, 0.03093392f, -0.02661551f, 
    -0.00439540f, -0.01147008f, -0.00924569f, 0.02927233f, 0.03128496f, -0.03111572f, -0.02495871f, 0.00894456f, 
    0.00201144f, -0.00711809f, 0.02543638f, 0.03322306f, 0.01954838f, 0.00337301f, -0.03121574f, -0.03218871f, 
    0.02614557f, 0.01251899f, -0.01299444f, 0.00140230f, -0.00686455f, 0.01328780f, 0.00770054f, 0.03596411f, 
    0.02432892f, 0.02829679f, -0.03027808f, 0.01966668f, -0.02287503f, 0.01359496f, -0.00182678f, -0.00011840f, 
    -0.00234369f, -0.00289084f, -0.02636909f, 0.01307082f, 0.02870578f, 0.01282977f, -0.01832233f, -0.00323901f, 
    -0.00690773f, 0.00746242f, 0.01968116f, -0.02520620f, 0.02567308f, 0.03476734f, 0.01038500f, 0.01384769f, 
    -0.03777019f, -0.03256118f, 0.01834654f, 0.01372392f, -0.02978551f, -0.03581764f, 0.00561642f, -0.02613775f, 
    0.00137365f, 0.01569565f, 0.00963302f, 0.01384779f, 0.02331971f, 0.01113761f, 0.01812023f, 0.01765993f, 
    -0.03412404f, -0.00847866f, 0.00041767f, 0.01684603f, -0.02009255f, 0.03137305f, 0.01605728f, -0.03711468f, 
    -0.01918717f, -0.03566341f, 0.03356445f, -0.02250993f, 0.02631096f, -0.02460355f, -0.00837776f, 0.03345273f, 
    0.02983663f, 0.01238013f, -0.00478039f, -0.02618109f, -0.02717572f, -0.03280699f, -0.00698292f, -0.01021705f, 
    0.03675557f, -0.01263237f, -0.00009895f, -0.01267501f, 0.00990461f, -0.03154276f, -0.01641653f, -0.01806447f, 
    -0.00326213f, 0.00668323f, -0.01733741f, 0.00694838f, -0.01646876f, -0.00155125f, -0.03909553f, -0.02432282f, 
    0.03378174f, -0.00374459f, 0.00837687f, -0.03200842f, -0.02398022f, -0.04182355f, 0.02953754f, -0.03740609f, 
    -0.02022831f, 0.00360539f, 0.01906910f, 0.02949809f, -0.01941439f, -0.00119994f, 0.02612766f, -0.00344760f, 
    0.01833284f, -0.00488260f, -0.01424754f, -0.03375436f, -0.02292938f, 0.01181749f, 0.03949147f, -0.03088460f, 
    -0.03524990f, -0.01438059f, -0.03648232f, -0.00569093f, -0.00933727f, -0.02244236f, 0.01352411f, 0.00980068f, 
    0.03004968f, 0.00702225f, -0.02261599f, -0.00438581f, -0.02324613f, -0.00987456f, -0.02848876f, -0.04213841f, 
    0.02254194f, 0.01968057f, -0.01572306f, -0.01249811f, -0.00799435f, -0.03098683f, 0.00349945f, 0.01968046f, 
    0.02819918f, 0.02723307f, -0.02745328f, -0.02526563f, -0.01454679f, 0.02571766f, 0.02233434f, 0.01551109f, 
    0.00605582f, -0.00418746f, -0.00498733f, -0.00774146f, -0.00624077f, -0.03221777f, -0.03207852f, -0.00349834f, 
    0.01838811f, -0.02766741f, 0.00797063f, -0.03702255f, 0.00372377f, 0.00612370f, -0.01630131f, 0.02685372f, 
    -0.01944868f, 0.02612821f, -0.01680805f, 0.01333597f, 0.01964371f, -0.03612212f, 0.01946528f, -0.02434903f, 
    0.02977767f, 0.02278970f, -0.02988977f, 0.02375893f, -0.00790460f, -0.01357941f, -0.01902327f, 0.01290785f, 
    -0.00696061f, -0.04111106f, -0.04247637f, 0.00220859f, 0.00204473f, -0.03543750f, -0.03061867f, 0.00970544f, 
    -0.02279133f, 0.00073129f, 0.02806296f, -0.00730725f, -0.00507223f, -0.02460757f, -0.00201848f, -0.02942288f, 
    0.00354170f, -0.02536280f, -0.00113308f, -0.03776076f, 0.00026207f, -0.02861841f, 0.01822875f, -0.02315059f, 
    -0.04220218f, -0.00604563f, -0.02537522f, -0.02805766f, -0.02870986f, 0.03762033f, -0.03998714f, -0.00244788f, 
    0.00583428f, 0.01458753f, 0.01735167f, -0.02048671f, -0.00585674f, -0.00859415f, -0.02090652f, 0.01280866f, 
    -0.01517074f, -0.01397366f, 0.01171293f, -0.00620525f, -0.02065035f, 0.01358205f, -0.03873355f, 0.02499867f, 
    -0.02327831f, 0.02546900f, 0.01661015f, -0.01561830f, -0.02152474f, -0.00705328f, -0.02199589f, -0.01240799f, 
    -0.02457784f, -0.00140183f, -0.02013624f, 0.01717134f, -0.02498143f, 0.02203237f, -0.00766019f, 0.03181642f, 
    -0.01181284f, -0.01870108f, -0.03797369f, -0.03320752f, -0.01712024f, 0.02421802f, -0.02268619f, -0.02134016f, 
    -0.00649063f, -0.02188492f, -0.00444843f, -0.01189732f, -0.03533729f, -0.02273993f, 0.00324319f, -0.02058383f, 
    -0.02142905f, -0.00979921f, 0.02442316f, -0.00812712f, -0.00625583f, -0.02330877f, 0.01413548f, -0.03984291f, 
    -0.03855691f, -0.03992491f, -0.04048601f, -0.00643078f, -0.04048828f, 0.00704644f, -0.02202644f, -0.03936807f, 
    0.00532110f, -0.01249948f, 0.00438777f, 0.00327313f, 0.00879569f, -0.02874013f, -0.03093920f, -0.00346954f, 
    -0.02452594f, 0.02611567f, -0.01493580f, -0.03330246f, -0.02473288f, -0.00508004f, -0.03348026f, -0.03879344f, 
    -0.03609437f, -0.02660928f, 0.00553163f, 0.01059452f, -0.00677823f, 0.02368170f, -0.01261869f, -0.02590362f, 
    -0.02324802f, 0.02398609f, -0.01294635f, -0.03430393f, -0.00756811f, 0.00863354f, 0.01669463f, -0.01743018f, 
    -0.02460456f, -0.00571989f, 0.00116802f, 0.00779179f, 0.01666523f, 0.02223479f, -0.02298359f, -0.03441701f, 
    0.01690824f, 0.00051666f, -0.02075075f, 0.00803982f, 0.02609132f, 0.01465727f, 0.01540492f, -0.03263481f, 
    -0.00105989f, 0.00232757f, -0.00495387f, 0.01599907f, 0.00344099f, -0.02480445f, 0.02588133f, -0.03611590f, 
    -0.01974725f, 0.01451993f, 0.00443705f, -0.01315398f, -0.03812638f, -0.01676320f, -0.02591465f, 0.02415347f, 
    -0.03001005f, -0.01400192f, -0.00682356f, 0.01998716f, -0.02538422f, -0.01877196f, 0.02584443f, -0.00622507f, 
    0.00524015f, -0.03001843f, -0.02673247f, 0.02371467f, 0.02553370f, -0.00955925f, -0.00296447f, -0.03523987f, 
    0.02869989f, 0.03159793f, 0.00738868f, -0.03590155f, -0.03626487f, 0.02908600f, -0.01473138f, 0.00132683f, 
    -0.03476653f, -0.03563761f, -0.02951088f, -0.02999866f, -0.01293884f, -0.03408986f, 0.02790105f, -0.03624077f, 
    -0.03376548f, -0.00136337f, -0.00762923f, 0.02782261f, -0.02876798f, 0.01364288f, -0.00939784f, -0.02215621f, 
    -0.02825030f, 0.02194808f, -0.00645535f, -0.00255705f, 0.00273244f, 0.02830590f, -0.01891820f, -0.03310580f, 
    0.00088429f, -0.00539747f, -0.02872684f, -0.03063029f, 0.01549534f, -0.03786029f, 0.00461884f, -0.02958303f, 
    0.02499100f, 0.01817702f, 0.00562928f, -0.01414496f, -0.02793733f, -0.01838126f, -0.03887844f, 0.00179924f, 
    -0.02911530f, -0.03434550f, 0.01053838f, -0.00059292f, -0.04242657f, 0.00697631f, 0.01935296f, 0.00732470f, 
    -0.03591151f, 0.00290863f, -0.03391053f, -0.03758861f, 0.01631717f, 0.01017230f, -0.00748598f, 0.01714960f, 
    0.02269048f, 0.01002279f, -0.02837579f, -0.03006469f, 0.02973435f, -0.01629839f, 0.02004599f, -0.00320046f, 
    -0.01064095f, 0.00123640f, -0.03842742f, 0.01449115f, 0.03106093f, -0.02978236f, 0.00064767f, -0.01192288f, 
    0.02684445f, 0.00099217f, 0.00757645f, 0.02134985f, 0.02082545f, 0.01324809f, 0.00111085f, -0.02416917f, 
    0.02955480f, 0.00138511f, -0.01468244f, -0.00164034f, 0.01108380f, 0.00892137f, -0.03977124f, -0.02497846f, 
    -0.03262836f, -0.03148266f, 0.02889445f, 0.00684835f, -0.02950160f, -0.01357815f, 0.01424187f, -0.03999020f, 
    0.01925267f, -0.02799012f, -0.01764878f, 0.00346081f, -0.02069863f, -0.03558566f, 0.00541518f, -0.02403690f, 
    -0.02141958f, -0.02821155f, -0.03585738f, 0.00215672f, -0.02877489f, -0.02662488f, -0.03107439f, 0.02947546f, 
    0.03089831f, -0.01095032f, -0.01434604f, 0.00756281f, 0.00222083f, -0.00066401f, -0.01595625f, 0.00497961f, 
    0.00460111f, 0.00502559f, 0.02900474f, -0.00752315f, -0.03971148f, -0.02662335f, 0.02372305f, 0.00254100f, 
    -0.00122021f, 0.00542865f, 0.03038967f, 0.02604213f, 0.01107798f, -0.01468568f, -0.01443106f, -0.03054385f, 
    0.00157143f, -0.02894313f, -0.04361014f, -0.04042230f, 0.02272896f, 0.00061339f, 0.02862174f, -0.01997625f, 
    0.03274470f, -0.03904454f, -0.03956793f, 0.00396836f, -0.00019067f, -0.04145560f, 0.01705314f, -0.04426842f, 
    -0.04272088f, -0.02045903f, 0.03090570f, -0.02879983f, -0.03464857f, 0.02400328f, -0.03479614f, -0.00043511f, 
    -0.03979397f, 0.00981031f, -0.02639475f, 0.03178018f, 0.00541590f, 0.01105955f, -0.02083622f, 0.02687751f, 
    0.01910655f, 0.01622223f, 0.02275942f, -0.02047671f, -0.01093485f, -0.00781740f, 0.00438731f, 0.01473518f, 
    -0.03338456f, 0.01424035f, -0.01891858f, -0.02454045f, 0.00971778f, -0.00517729f, 0.00811465f, -0.03712013f, 
    -0.02437000f, -0.02719862f, -0.02254653f, -0.00570907f, 0.00995635f, 0.02650668f, -0.00198161f, 0.03046444f, 
    -0.02933355f, -0.02713721f, -0.03610826f, -0.03740193f, -0.01658672f, -0.02614316f, 0.01845523f, 0.03494919f, 
    -0.02042577f, -0.02516188f, -0.03736835f, 0.02193791f, 0.01314863f, 0.00276575f, -0.03691656f, -0.02484389f, 
    0.01205990f, 0.03288499f, -0.01485274f, 0.00112717f, -0.02657220f, -0.03266823f, 0.02449972f, 0.01974024f, 
    -0.01390694f, -0.00470300f, 0.01150981f, 0.02446172f, -0.02717697f, 0.02950136f, 0.01346308f, 0.02417843f, 
    0.03515144f, -0.01115994f, 0.00915599f, 0.01355848f, 0.00010770f, -0.01191571f, 0.00350578f, -0.01129697f, 
    -0.01181652f, 0.02562401f, -0.02918879f, 0.02309502f, 0.01022876f, -0.01818613f, -0.03697746f, -0.00612987f, 
    -0.02065976f, -0.01117221f, -0.00139468f, -0.03187534f, -0.00013992f, -0.00768554f, 0.01436599f, 0.00228243f, 
    0.00378214f, -0.03603440f, -0.02458787f, -0.00107565f, -0.01960916f, 0.00329561f, -0.02448575f, 0.00878769f, 
    -0.00759343f, -0.00684872f, -0.02835386f, -0.00762146f, -0.02701783f, -0.02498762f, -0.03029442f, 0.01016341f, 
    -0.00799078f, 0.03268941f, 0.02345519f, -0.02124167f, -0.01190750f, 0.01291276f, -0.02702124f, -0.00376643f, 
    0.02427345f, 0.01076594f, 0.00846748f, -0.02145300f, -0.01079863f, -0.01751987f, -0.04157547f, 0.02535425f, 
    -0.00486698f, -0.04050669f, 0.00919216f, 0.00556168f, -0.00502712f, -0.03503906f, -0.04213352f, -0.00386553f, 
    0.03320048f, -0.02945010f, 0.03438180f, -0.02854651f, 0.01769676f, 0.02065361f, 0.01330521f, 0.01834942f, 
    -0.03144554f, 0.01899746f, -0.03285950f, 0.00851130f, -0.00017127f, -0.01509419f, 0.02364764f, 0.01863851f, 
    -0.02508368f, -0.00373322f, -0.02328627f, 0.00869218f, 0.00544531f, -0.00855830f, -0.02395966f, 0.00900056f, 
    -0.03958201f, -0.02077272f, 0.01927441f, -0.03418041f, -0.00126652f, -0.01295336f, -0.03617423f, 0.01596733f, 
    -0.01874799f, -0.02611464f, -0.01137111f, 0.00875403f, 0.02269364f, -0.01032212f, -0.02519729f, -0.01363285f, 
    -0.00012105f, 0.02206630f, 0.01015470f, 0.01557406f, -0.01833750f, 0.01939885f, -0.03377522f, -0.01079150f, 
    0.00427112f, -0.02479059f, -0.02957106f, -0.00163942f, 0.00260738f, 0.02192524f, 0.01015709f, -0.03107345f, 
    -0.01971379f, -0.00675720f, -0.00209716f, 0.02422723f, -0.00995827f, 0.00479145f, 0.02203421f, -0.03276127f, 
    -0.03260590f, -0.00410598f, -0.03204156f, -0.01997678f, -0.02608471f, 0.00375730f, 0.00484039f, -0.01966103f, 
    -0.01518873f, 0.00554398f, 0.02540642f, 0.01802270f, 0.02354081f, -0.04024464f, 0.01238506f, 0.03118833f, 
    0.00201097f, -0.02347628f, -0.00470586f, 0.01848425f, 0.00514563f, -0.01497895f, -0.02187756f, 0.01273102f, 
    0.00672652f, -0.02687723f, -0.03776132f, 0.00938745f, 0.01738964f, 0.02518849f, 0.02837927f, -0.02975475f, 
    0.00333540f, -0.00994649f, 0.03368798f, 0.01671873f, -0.03162970f, -0.00486657f, -0.01354787f, 0.00857441f, 
    0.01972176f, 0.02714571f, 0.01403565f, -0.00905001f, 0.01682994f, -0.00872191f, 0.03024369f, -0.02115449f, 
    0.00061007f, -0.00228686f, 0.02949744f, -0.03578878f, -0.04020119f, -0.03627671f, -0.03901818f, 0.02134158f, 
    0.01026832f, -0.03885119f, 0.03253467f, 0.00648829f, -0.02292730f, 0.01274488f, 0.02111811f, 0.00774886f, 
    0.02296728f, 0.00150203f, -0.01783719f, 0.01240037f, 0.00056963f, -0.01351229f, -0.00610457f, -0.01140228f, 
    -0.01436878f, -0.02377944f, 0.00804342f, -0.02625804f, 0.02817515f, -0.00362590f, 0.00395090f, 0.02693523f, 
    -0.02264225f, 0.01146019f, 0.02200212f, -0.00436177f, 0.00685466f, 0.02583341f, 0.01996084f, -0.02199711f, 
    -0.00543466f, -0.02487246f, -0.00125144f, 0.02281649f, 0.01471146f, 0.00258203f, 0.00288757f, 0.02958404f, 
    0.02380090f, -0.02937291f, 0.02906886f, 0.02665236f, -0.02604378f, 0.00444469f, 0.00568871f, 0.01879295f, 
    0.01086912f, 0.01898439f, 0.03213102f, -0.02827494f, -0.00254738f, -0.03867117f, -0.01362868f, -0.01682363f, 
    -0.02541906f, 0.01965108f, 0.01886013f, 0.01206303f, 0.02750832f, 0.03273544f, -0.00293143f, -0.02094045f, 
    -0.03145614f, -0.03537270f, -0.00615155f, -0.01474640f, 0.02151949f, -0.00184603f, -0.01298768f, 0.01414066f, 
    0.01666606f, -0.03004469f, 0.02058584f, 0.03159887f, -0.00183132f, 0.01456908f, -0.01393770f, -0.00860836f, 
    -0.00124410f, -0.02657849f, 0.02832853f, -0.00629802f, -0.03334453f, -0.00716489f, -0.02500782f, 0.00044685f, 
    0.00679208f, -0.00716941f, 0.01503534f, -0.00437117f, 0.00997956f, -0.03496580f, 0.00974523f, 0.01250923f, 
    -0.02275161f, -0.03399710f, 0.01681904f, -0.02399688f, 0.02419319f, -0.02064338f, 0.01918162f, -0.02502988f, 
    -0.00371657f, 0.02636978f, -0.03378928f, 0.01808676f, -0.03537154f, -0.01503363f, -0.02680759f, -0.02629956f, 
    0.01201644f, -0.03424739f, -0.00407602f, 0.00081596f, 0.03362195f, 0.02948450f, 0.01924697f, 0.00769084f, 
    -0.00757880f, -0.03151107f, 0.00832739f, 0.01638940f, -0.02302285f, -0.02656808f, -0.00811002f, -0.02316049f, 
    -0.02644888f, -0.01350586f, 0.02703657f, -0.01320275f, -0.03162985f, -0.02282355f, 0.01192838f, 0.00642999f, 
    -0.00995184f, 0.01223828f, -0.02399852f, -0.01464052f, -0.00803980f, 0.00447776f, 0.01291443f, -0.02132614f, 
    0.02553551f, 0.02877831f, 0.01511878f, -0.00768347f, 0.01160224f, 0.00093730f, -0.01698825f, 0.01723778f, 
    -0.02705932f, 0.02256907f, 0.02518757f, -0.00548697f, -0.01542419f, 0.00262451f, 0.01452777f, -0.02812203f, 
    -0.01861935f, 0.02739619f, 0.02923727f, -0.02763855f, -0.00509121f, -0.01934010f, -0.03006066f, -0.02757296f, 
    -0.00270127f, 0.00986226f, -0.04163894f, -0.01343978f, -0.03090293f, -0.03161937f, -0.00098520f, 0.00450222f, 
    -0.03305867f, -0.01362745f, -0.00217775f, -0.00186129f, 0.02148284f, 0.00580061f, 0.00054391f, 0.02081159f, 
    0.00957546f, 0.02670270f, 0.01942506f, -0.00031127f, 0.03262938f, -0.01618104f, -0.00309449f, -0.00736810f, 
    -0.03921524f, 0.00146829f, 0.02100621f, -0.03064009f, 0.01015185f, 0.01303823f, -0.02728832f, -0.02835058f, 
    0.03203037f, 0.01988654f, 0.03010041f, 0.00876230f, 0.02435292f, -0.00379347f, 0.01066547f, 0.03792699f, 
    -0.03549609f, -0.01328314f, 0.00836007f, 0.00799288f, -0.04147934f, -0.03244314f, -0.02891359f, 0.03423844f, 
    0.00653596f, -0.02486216f, 0.02222182f, 0.02624797f, -0.03478120f, -0.01638032f, 0.03018705f, -0.01176912f, 
    -0.03592317f, -0.02441224f, 0.02856862f, 0.00159818f, -0.02916713f, 0.00572532f, -0.03706409f, -0.00965422f, 
    0.00547586f, -0.01313742f, -0.02995740f, 0.02271752f, 0.01647536f, -0.01053236f, 0.00355810f, 0.02563332f, 
    -0.00796991f, 0.02468012f, -0.01842996f, 0.01637338f, 0.00552130f, -0.00499097f, -0.01890292f, -0.01579949f, 
    -0.03622048f, -0.01561993f, 0.02700217f, -0.01213791f, -0.01535348f, -0.04224859f, 0.02431651f, -0.00314951f, 
    -0.02595709f, 0.00872114f, 0.01663409f, -0.03860286f, 0.02243290f, 0.00253336f, -0.04202544f, -0.02318688f, 
    -0.02714238f, 0.02739098f, -0.01789010f, 0.00869504f, 0.00086988f, -0.03968902f, 0.00316911f, -0.02555376f, 
    -0.00988308f, -0.00581478f, -0.00745610f, 0.03734491f, -0.00275720f, 0.00172197f, 0.01202244f, -0.00258642f, 
    -0.00867098f, -0.18490914f, -0.02802047f, 0.07839067f, 0.11086665f, -0.02175661f, 0.00738030f, 0.17716095f, 
    -0.00262275f, 0.11391975f, -0.01907844f, 0.10768259f, 0.40269402f, 0.20682985f, -0.02229398f, -0.01928156f, 
    0.02790694f, -0.12142835f, -0.08697356f, -0.12614447f, 0.04540166f, 0.16689278f, 0.06252591f, -0.02125262f, 
    0.03275661f, -0.00120607f, 0.02152357f, 0.12201571f, 0.00287418f, 0.05324398f, -0.13583770f, 0.12649137f, 
    0.07035164f, 0.01275235f, 0.07487022f, 0.00869650f, 0.38998961f, -0.15295918f, -0.19642520f, 0.05594655f, 
    -0.01320015f, 0.06908668f, -0.00465877f, 0.02811549f, -0.02011760f, 0.10389394f, 0.11945843f, 0.10313033f, 
    0.09274778f, 0.06700689f, 0.13270862f, -0.29576373f, -0.14726056f, 0.14972875f, -0.00389491f, 0.03338249f, 
    0.08472931f, 0.11260679f, -0.08152047f, -0.09606769f, 0.14009789f, 0.00613709f, -0.15826194f, -0.16061932f, 
    -0.05389037f, 0.02664825f, 0.07981174f, -0.16784666f, -0.15321375f, 0.04823167f, 0.01875504f, -0.05190701f, 
    -0.36043698f, 0.10990441f, 0.26828194f, -0.00415629f, -0.13002282f, -0.06891335f, -0.01480422f, 0.17421548f, 
    0.05950427f, 0.11195810f, 0.12003412f, 0.03586654f, 0.11089820f, 0.21227644f, -0.06427053f, -0.23956974f, 
    -0.05906494f, 0.03714326f, 0.06588789f, -0.01965814f, 0.10656439f, 0.01289193f, 0.13382933f, -0.09039798f, 
    0.00838554f, 0.27190456f, 0.02640188f, -0.06950565f, -0.10400211f, -0.02893783f, 0.00562376f, -0.05870165f, 
    -0.07104274f, -0.01642232f, 0.00145700f, -0.01393473f, -0.17825522f, -0.03472396f, 0.07222021f, -0.06750587f, 
    -0.05144853f, 0.10382861f, 0.06085331f, 0.06185041f, -0.06097256f, -0.04009873f, 0.11931491f, -0.07030235f, 
    -0.17935799f, 0.00204407f, 0.12371624f, -0.01550484f, 0.03189296f, 0.02604250f, 0.04911103f, -0.04141351f, 
    0.01128476f, 0.09546015f, 0.01432664f, -0.03789763f, -0.42528236f, 0.18490596f, 0.20082672f, -0.03246236f, 
    0.16192918f, 0.03424576f, 0.15753852f, -0.03564516f, 0.15350437f, -0.08430915f, -0.07160398f, 0.01317022f, 
    0.34487247f, 0.20862752f, -0.07218763f, -0.11024964f, -0.11750759f, -0.06711197f, 0.25489143f, 0.12042414f, 
    -0.02242720f, -0.09275971f, -0.01802577f, -0.01404915f, -0.21491545f, 0.02605830f, 0.21814707f, -0.12271429f, 
    -0.09046485f, 0.05862024f, 0.11067235f, -0.08291294f, -0.09800692f, -0.10914721f, 0.12215328f, -0.01297853f, 
    0.42536220f, 0.02069240f, -0.16467185f, 0.06870925f, 0.05531102f, 0.10883778f, 0.17748749f, -0.04074977f, 
    -0.01262708f, 0.04515428f, 0.08180796f, 0.01736793f, -0.20153137f, 0.41438642f, -0.01770034f, 0.18989037f, 
    -0.10125466f, 0.03023208f, 0.07249994f, 0.12221912f, -0.01004667f, 0.06018750f, 0.15810658f, -0.01974394f, 
    -0.07633385f, -0.20393455f, -0.17634697f, -0.05815290f, 0.00269958f, -0.05148776f, -0.01267206f, 0.09103370f, 
    0.06236082f, 0.05059933f, -0.01864571f, -0.10116980f, 0.12477337f, -0.11399893f, 0.20483012f, 0.05088689f, 
    0.11186665f, 0.04291716f, -0.05353836f, 0.04900746f, 0.03157554f, -0.00239627f, -0.01842336f, 0.09512652f, 
    -0.33877233f, -0.15012789f, 0.01372176f, 0.17151053f, 0.03780439f, 0.00784403f, 0.01455118f, -0.04521214f, 
    0.20477998f, -0.00834623f, 0.07880618f, -0.10013261f, 0.08616443f, 0.02544119f, -0.07743494f, 0.14792490f, 
    -0.11812268f, -0.24490243f, 0.07731654f, -0.04210253f, -0.04589682f, 0.02463507f, 0.03363322f, 0.08217068f, 
    -0.02562698f, 0.26504803f, 0.06689692f, -0.09623659f, -0.16328652f, -0.01909724f, -0.02315761f, 0.06234220f, 
    0.09359596f, -0.15562950f, 0.02010515f, -0.17758569f, 0.01648412f, -0.06490096f, -0.00541534f, 0.00422738f, 
    0.13100174f, -0.05594754f, 0.10187025f, 0.07200677f, 0.09189942f, 0.23560695f, -0.03077449f, 0.08321314f, 
    -0.20585230f, 0.11740318f, -0.08252189f, 0.10978527f, -0.08954359f, 0.02615067f, 0.16194172f, 0.12123720f, 
    0.12315278f, 0.06697048f, 0.05375933f, 0.01383721f, 0.31401953f, 0.15985315f, 0.03226913f, 0.27068862f, 
    0.02560677f, -0.07498381f, 0.04572818f, 0.02055521f, 0.03461247f, -0.13035733f, -0.06255965f, 0.11648586f, 
    0.08877982f, 0.14341766f, 0.04454148f, 0.07759766f, -0.08753788f, 0.08064639f, -0.11621745f, 0.00162169f, 
    0.05794319f, 0.14283481f, -0.00094702f, -0.15812267f, 0.29310971f, -0.19766526f, -0.06469715f, -0.01855690f, 
    0.01861217f, -0.00929196f, 0.05748412f, 0.03910096f, -0.02287772f, -0.04390649f, -0.00220849f, 0.22020143f, 
    0.02916277f, -0.15883137f, -0.19843607f, 0.07153478f, -0.07107599f, 0.03221312f, 0.02594615f, -0.03051388f, 
    0.05642001f, 0.06394732f, -0.00533512f, 0.06572055f, 0.03519617f, 0.19115978f, -0.01500703f, -0.14811991f, 
    0.05103735f, -0.02413057f, 0.02183046f, 0.05551587f, 0.02632601f, -0.13250695f, 0.13681446f, -0.09747479f, 
    -0.43665388f, -0.36666298f, -0.35370404f, -0.20789734f, 0.01584923f, 0.09300849f, -0.07793402f, -0.07408798f, 
    0.03531652f, 0.04942437f, 0.01024708f, -0.07935600f, -0.00849830f, -0.00525648f, -0.00386521f, -0.07213698f, 
    -0.06675112f, -0.03949935f, 0.07686305f, -0.00102926f, 0.22082321f, 0.14749230f, -0.14501238f, 0.09134782f, 
    0.05863874f, 0.19733730f, 0.12949736f, -0.14288883f, -0.11598121f, 0.08093215f, 0.08318452f, -0.15168908f, 
    0.09130716f, 0.02842359f, 0.05062935f, -0.00405535f, -0.38128731f, 0.04245751f, 0.08640275f, -0.13744779f, 
    -0.01812421f, -0.03413176f, 0.03840961f, -0.00478667f, -0.05377791f, -0.03643165f, 0.04168675f, -0.06086928f, 
    0.59175420f, 0.02082601f, -0.18210417f, -0.08953178f, -0.12566432f, 0.12431031f, 0.06689243f, -0.07517394f, 
    0.03320801f, -0.02093003f, 0.04448223f, 0.08808798f, 0.13948175f, -0.30737883f, -0.10474915f, -0.05848462f, 
    -0.05000779f, 0.01393641f, 0.02452550f, -0.00268809f, 0.07017379f, -0.05451077f, 0.07432399f, 0.04427788f, 
    0.17668709f, -0.05791935f, -0.20964916f, 0.06465905f, -0.02272929f, -0.02255495f, -0.07161878f, 0.05514471f, 
    0.11090524f, -0.02053071f, -0.03275584f, 0.12359034f, 0.17183433f, -0.06268471f, -0.09140773f, -0.24526875f, 
    0.01918738f, -0.06347808f, 0.03356783f, 0.00261651f, -0.02471031f, 0.16734874f, 0.06081431f, 0.07729435f, 
    0.41189775f, -0.09617137f, 0.11312625f, 0.22527958f, 0.06992222f, 0.01496847f, 0.10837914f, 0.09494448f, 
    0.05199480f, -0.17193735f, 0.07821832f, 0.03602114f, -0.27937135f, 0.00314886f, 0.00560713f, 0.03720885f, 
    0.12499685f, 0.06133814f, -0.06476580f, 0.00814356f, 0.06303982f, 0.02049013f, 0.17865749f, 0.14779490f, 
    -0.26254007f, 0.18405497f, -0.05161015f, 0.02483783f, 0.00503151f, 0.03643322f, 0.03104345f, -0.01069377f, 
    -0.02793830f, 0.02261271f, 0.15508193f, 0.03433755f, 0.21631311f, -0.06301536f, -0.06583494f, 0.03419246f, 
    -0.02672791f, -0.09382334f, 0.08362630f, -0.09543062f, 0.07848523f, -0.03398991f, -0.14214595f, -0.07794020f, 
    -0.07559793f, -0.03150673f, 0.06512427f, -0.02434313f, 0.00018138f, -0.05173413f, -0.14195429f, -0.10368795f, 
    -0.02215178f, 0.07462237f, -0.06612325f, -0.07692736f, -0.10277928f, -0.01257084f, 0.08222300f, 0.02006076f, 
    -0.02693953f, 0.15396549f, -0.02771019f, 0.03570467f, -0.16269778f, -0.01800909f, 0.01816899f, -0.14402230f, 
    0.14429881f, -0.31195498f, 0.00775435f, 0.09885479f, -0.01241021f, -0.15941156f, 0.00351091f, 0.07060909f, 
    0.06345296f, 0.03380456f, -0.08557350f, 0.03453369f, -0.49562225f, 0.31752741f, -0.07632518f, 0.09994077f, 
    0.02547643f, 0.01076419f, 0.02390977f, 0.03360571f, -0.08338569f, -0.04021461f, -0.06921954f, 0.06202184f, 
    0.37594533f, 0.04396207f, 0.05807141f, 0.09488879f, 0.20675656f, 0.02356004f, -0.07467680f, 0.04392786f, 
    0.15274823f, 0.11659511f, -0.02216692f, 0.04190636f, -0.06715849f, -0.19304320f, -0.14511979f, -0.04630761f, 
    0.07560182f, -0.00542826f, -0.13927203f, 0.10372809f, 0.05725404f, 0.04591775f, -0.03298487f, 0.07863668f, 
    -0.01139675f, 0.01854382f, 0.19721074f, 0.01052431f, -0.02544586f, 0.12035852f, 0.02418154f, -0.02567029f, 
    -0.05124459f, -0.03485212f, 0.05362137f, -0.05998868f, 0.03272292f, -0.03090973f, 0.01004943f, -0.14699353f, 
    -0.20121880f, 0.15362139f, -0.08430902f, -0.01001701f, 0.11176729f, -0.02091151f, 0.11237848f, -0.04416204f, 
    0.07964620f, 0.20044443f, 0.15459545f, 0.00227640f, -0.06097244f, -0.05253813f, 0.01311562f, -0.10813057f, 
    0.05072040f, 0.01498970f, -0.26578802f, 0.04746409f, -0.31674010f, 0.13653775f, -0.15440662f, -0.21151122f, 
    0.06833912f, 0.02404071f, 0.06186824f, -0.01037931f, 0.11995975f, 0.00503910f, -0.02653829f, 0.08044153f, 
    0.10510897f, -0.21866977f, 0.02802605f, 0.28731066f, 0.16683117f, -0.12067179f, 0.08648309f, 0.19677556f, 
    0.12157311f, -0.01481375f, 0.00206538f, 0.04142434f, -0.12120007f, -0.25181442f, 0.08759633f, 0.16829331f, 
    -0.01956446f, 0.10913855f, 0.07557230f, -0.05365828f, 0.04700301f, 0.01962586f, 0.08666847f, -0.00099214f, 
    -0.45593920f, 0.04596786f, -0.00674267f, -0.02639915f, 0.02171380f, -0.12760241f, -0.09585561f, 0.08237088f, 
    0.06807551f, -0.04030866f, -0.18912619f, -0.04025201f, 0.03715653f, -0.09331353f, -0.16438827f, -0.20224239f, 
    -0.15242878f, -0.09127830f, 0.09554833f, -0.18076694f, 0.11558435f, -0.18291147f, -0.04559764f, -0.07199622f, 
    -0.42772615f, 0.22427076f, 0.08667025f, 0.10125379f, 0.03722684f, -0.09965271f, 0.13264561f, -0.02786471f, 
    0.03633806f, 0.07841402f, 0.03069117f, 0.09950482f, 0.02822837f, 0.09995010f, -0.08376733f, 0.01244597f, 
    0.04828558f, 0.03522337f, -0.15746650f, -0.04596601f, 0.04633689f, 0.01230893f, 0.10057133f, -0.09247231f, 
    -0.13362423f, -0.50731874f, -0.12728669f, 0.03668850f, -0.07817165f, 0.08891859f, 0.00643388f, 0.01044760f, 
    0.07210695f, 0.05245457f, 0.02482283f, 0.00076168f, -0.18251613f, 0.09037995f, 0.05279094f, 0.01537786f, 
    -0.05579023f, -0.04130885f, 0.09879091f, -0.11171716f, 0.09224571f, 0.07908943f, -0.08445729f, 0.15233831f, 
    0.33430487f, 0.12596901f, 0.00077300f, 0.11911565f, 0.05832800f, -0.05413048f, 0.01514803f, 0.01230953f, 
    0.00942313f, 0.02217657f, 0.01602817f, 0.04887410f, 0.18409792f, -0.18909538f, 0.23068668f, -0.01332481f, 
    0.10235022f, -0.13415162f, -0.00069397f, 0.03893802f, 0.08507228f, 0.05665711f, -0.09466241f, 0.11278737f, 
    -0.03170374f, -0.06348787f, -0.17318928f, -0.04534324f, 0.15260510f, -0.12861952f, -0.08449291f, -0.00236976f, 
    0.11086676f, 0.10175000f, 0.06498472f, -0.02939409f, 0.16285770f, -0.05977635f, 0.19442768f, 0.23351641f, 
    0.16951491f, -0.08424548f, -0.08515894f, 0.02303630f, 0.04672725f, -0.10537687f, 0.09463984f, -0.00257791f, 
    -0.05673552f, 0.27125436f, -0.09222225f, 0.00167192f, 0.10403962f, 0.03460944f, 0.00431890f, -0.08288891f, 
    0.02395749f, -0.04909306f, 0.00585776f, -0.00356462f, 0.59776103f, 0.09322473f, 0.18018433f, 0.08569405f, 
    -0.02559861f, -0.08792460f, 0.09684612f, 0.12149131f, 0.16031472f, 0.06511445f, 0.01680905f, 0.03863394f, 
    -0.02981683f, -0.03529604f, -0.02835524f, -0.03613992f, 0.01628263f, -0.00031722f, -0.01321622f, 0.01554513f, 
    0.00832030f, -0.01222559f, -0.02155825f, 0.01121813f, 0.00588715f, 0.00640343f, 0.00626213f, -0.00317717f, 
    -0.03713001f, -0.02505202f, -0.00661543f, -0.02216271f, -0.00697023f, -0.00925872f, 0.02846819f, -0.00934938f, 
    -0.01884396f, -0.00975723f, -0.02846518f, 0.01589984f, 0.00366971f, 0.02565077f, 0.01846078f, -0.02336754f, 
    -0.00208540f, -0.03202182f, 0.01671166f, -0.03911582f, -0.04150319f, -0.03096982f, 0.01919540f, -0.02414625f, 
    0.02608306f, -0.02349010f, 0.02174440f, -0.00371614f, -0.03023232f, -0.02432604f, 0.01985939f, -0.00391754f, 
    0.01258885f, 0.02416137f, -0.01272702f, 0.01978017f, 0.02003789f, 0.02585448f, 0.00262230f, 0.02384363f, 
    -0.02885290f, 0.02028915f, -0.00872823f, -0.01651515f, -0.00557848f, 0.02803493f, 0.01470856f, 0.02308443f, 
    -0.01467787f, -0.00948530f, -0.01234039f, 0.02784857f, -0.00490633f, -0.00945642f, 0.00639267f, -0.01397732f, 
    0.00513955f, 0.02571874f, -0.03265849f, -0.00784791f, -0.03623436f, 0.01661372f, -0.04015429f, 0.02529639f, 
    0.00568749f, 0.02870734f, 0.01929478f, 0.01222471f, 0.00330603f, 0.01720309f, -0.03431186f, -0.01325755f, 
    -0.03799551f, 0.02465984f, 0.01779294f, 0.00557542f, 0.02448081f, 0.00108262f, 0.01429407f, 0.00033885f, 
    -0.00002156f, -0.04235058f, 0.00575507f, -0.03986463f, -0.01639976f, -0.02681682f, -0.02131302f, -0.01535195f, 
    -0.03137198f, -0.01891017f, -0.00685088f, 0.00323722f, -0.02692424f, -0.02602098f, 0.00318317f, 0.00782392f, 
    0.00729770f, 0.01795861f, -0.03236829f, 0.01750156f, 0.01280958f, -0.01601908f, 0.02821770f, 0.01157631f, 
    -0.02053925f, 0.02333294f, -0.01713934f, -0.00491091f, 0.00086994f, 0.00926692f, -0.02514669f, 0.01561997f, 
    0.01605535f, 0.02654975f, -0.01975731f, -0.04151624f, -0.03314703f, -0.03393770f, -0.02070485f, -0.00430283f, 
    0.00049521f, 0.00385506f, -0.04122587f, 0.02440847f, 0.00722430f, 0.00141358f, -0.04062584f, 0.00294498f, 
    -0.03304023f, -0.01582282f, 0.02120273f, -0.02452694f, 0.00465409f, 0.00643767f, -0.02533572f, -0.01879591f, 
    -0.03975581f, 0.00744442f, 0.02395208f, -0.00891255f, -0.01028590f, -0.00339088f, -0.00495065f, -0.02930005f, 
    -0.00986812f, -0.03756115f, -0.02211870f, 0.00724229f, 0.00725763f, -0.02688379f, -0.04203975f, -0.01110234f, 
    -0.03119443f, 0.00035562f, -0.01631285f, -0.04081473f, -0.03600936f, 0.01518097f, -0.02394583f, -0.01872066f, 
    0.00708764f, -0.01118275f, -0.03426238f, -0.00855590f, 0.02424110f, -0.03482985f, 0.02567779f, 0.00776576f, 
    -0.00912743f, 0.01238784f, 0.00984843f, -0.00449007f, -0.02872584f, 0.00879170f, 0.02687657f, 0.00241932f, 
    0.01480004f, -0.02889030f, -0.01939424f, 0.02111560f, -0.02188853f, 0.01394505f, -0.00865969f, -0.04015712f, 
    -0.02925472f, 0.01307711f, 0.00589139f, -0.01698244f, -0.03602378f, -0.03916677f, -0.03125007f, 0.02513439f, 
    0.01541887f, 0.02517926f, -0.02077734f, -0.02102956f, -0.04038594f, 0.02241715f, 0.01016122f, -0.02737164f, 
    -0.01970069f, -0.03228830f, -0.00238681f, -0.03215928f, 0.02770339f, -0.00178294f, 0.02257070f, -0.04181670f, 
    0.01165944f, 0.02480610f, -0.03427459f, -0.04290204f, 0.01178492f, 0.02370170f, -0.01151583f, -0.00408431f, 
    -0.04269285f, -0.03376966f, -0.02198601f, 0.00665427f, -0.01896244f, -0.01253116f, -0.04065719f, -0.00111581f, 
    -0.01253450f, -0.00240081f, 0.02182622f, -0.01778344f, -0.02832267f, 0.01269796f, 0.00890720f, 0.00322115f, 
    -0.01957642f, 0.00720361f, -0.01277105f, -0.03662455f, -0.04163517f, -0.03993386f, -0.00884577f, -0.01830722f, 
    0.00212079f, -0.00264910f, 0.02099982f, 0.01404583f, -0.03081551f, -0.02433193f, 0.00204308f, -0.03375242f, 
    0.02619001f, -0.03708758f, 0.00806371f, 0.01824892f, 0.02555339f, 0.02308381f, 0.00801401f, -0.02123804f, 
    -0.00420759f, -0.04111136f, 0.02400013f, 0.02316041f, 0.03025670f, -0.03649252f, -0.00140469f, -0.01915565f, 
    -0.02895914f, -0.00765070f, 0.00681602f, -0.03956460f, 0.01712142f, 0.00660402f, 0.01355865f, -0.00998366f, 
    -0.02767930f, -0.02438045f, 0.00881375f, -0.02916099f, -0.01004355f, 0.00616607f, 0.02378386f, 0.00695170f, 
    0.02844982f, 0.02153011f, -0.01661942f, -0.02655828f, 0.00043458f, -0.02410764f, -0.01728645f, 0.02169521f, 
    -0.02797084f, -0.00770797f, -0.00062405f, 0.02020406f, 0.00656123f, 0.01814031f, -0.03947926f, -0.00804236f, 
    0.01638339f, -0.02165713f, 0.01891646f, -0.03804457f, 0.00237818f, 0.01248734f, 0.00491276f, 0.00487880f, 
    -0.03431675f, -0.03569674f, 0.00392854f, 0.02141584f, -0.00416609f, 0.00743504f, -0.00594319f, 0.00594852f, 
    -0.03275633f, 0.02721628f, -0.02517606f, -0.04153399f, -0.00466659f, -0.04157070f, -0.04270376f, 0.00183062f, 
    0.00242539f, -0.00010736f, -0.02129178f, 0.02159190f, -0.01561758f, 0.02785624f, -0.01948923f, -0.02604742f, 
    -0.01591149f, -0.02080308f, -0.00663139f, 0.01022029f, 0.02127910f, -0.04328844f, -0.00067877f, -0.03041993f, 
    -0.01339837f, 0.02094760f, 0.01066464f, -0.01478314f, -0.03064267f, -0.00748424f, -0.01856159f, -0.04276061f, 
    -0.03440081f, 0.00252464f, -0.03115710f, -0.00327648f, 0.01713941f, 0.01274164f, 0.02751325f, -0.03455786f, 
    0.02865796f, -0.00377891f, 0.02221491f, -0.04294014f, 0.02084839f, -0.04325747f, -0.00151381f, -0.04198542f, 
    0.01605786f, 0.01680698f, -0.01822675f, -0.00861873f, -0.02375332f, -0.02985308f, 0.00906676f, -0.01131563f, 
    -0.02789461f, -0.02843956f, -0.03853924f, -0.02459325f, 0.00718340f, -0.02395360f, -0.03187201f, 0.01706755f, 
    0.00836706f, -0.01216587f, 0.00142617f, 0.02468337f, -0.00093846f, 0.02457387f, 0.01980759f, -0.00269875f, 
    0.00532761f, -0.02541117f, -0.02666103f, 0.02292447f, 0.00455566f, -0.00952925f, -0.02296740f, 0.00704412f, 
    0.02504081f, -0.02869576f, -0.03043390f, -0.02695359f, 0.01009077f, -0.00986228f, -0.01821118f, 0.00244115f, 
    -0.03701471f, 0.02112223f, 0.03025859f, -0.02917219f, -0.02937298f, 0.00809938f, 0.00672050f, 0.00974523f, 
    -0.00013347f, 0.00932703f, -0.01970277f, 0.02217678f, 0.00010675f, -0.01089272f, 0.01476323f, -0.03687138f, 
    0.01340474f, -0.00598366f, -0.01933365f, 0.00336131f, -0.00253559f, -0.03402821f, -0.03931151f, 0.00259862f, 
    -0.02138647f, 0.02649623f, 0.01584869f, 0.00788057f, -0.03173464f, 0.02821878f, -0.03728415f, 0.01211837f, 
    0.00944742f, -0.00839410f, 0.01426237f, -0.02284092f, 0.02026478f, -0.01798707f, 0.01110750f, -0.01994823f, 
    -0.03218865f, 0.02322762f, 0.00830828f, -0.02407212f, -0.02053115f, -0.03430091f, 0.00092861f, 0.01077388f, 
    -0.04014495f, 0.02348321f, 0.00426181f, -0.01039442f, -0.02212090f, 0.02459288f, 0.01900346f, 0.02672185f, 
    0.00550506f, 0.01718114f, -0.00972571f, 0.01819874f, 0.01223845f, 0.00665412f, 0.00836002f, -0.02889570f, 
    0.01896833f, -0.02106166f, -0.02359452f, -0.01473331f, -0.01598185f, 0.01807286f, -0.03540719f, -0.03876917f, 
    0.02013083f, -0.02206545f, -0.01857415f, 0.00849626f, -0.02084204f, -0.01177907f, -0.01631507f, 0.01676068f, 
    -0.01606293f, -0.01858205f, -0.00939636f, -0.03225548f, 0.01571636f, 0.01376380f, -0.02855168f, 0.02449669f, 
    0.00869968f, -0.01946026f, -0.02517554f, 0.01446112f, -0.02651944f, 0.01876082f, 0.01955242f, 0.00438173f, 
    -0.00923144f, -0.03835003f, -0.00973934f, 0.00122768f, -0.03900594f, -0.03248573f, 0.00274262f, -0.03068773f, 
    -0.01387081f, 0.00238549f, 0.03045400f, 0.00878148f, -0.02333332f, 0.02647120f, -0.03539378f, -0.01110793f, 
    -0.04077971f, 0.02113970f, -0.01940345f, 0.02693929f, -0.00591216f, -0.01030715f, 0.00312734f, 0.02559636f, 
    -0.01780481f, -0.00719472f, 0.02462922f, -0.00760638f, -0.00037877f, -0.03983729f, 0.01524827f, -0.03180895f, 
    0.00093483f, -0.02531325f, -0.02720100f, -0.00144979f, -0.00992355f, 0.02085506f, 0.01377458f, -0.04054680f, 
    -0.00604350f, -0.04338811f, 0.01071820f, 0.00020586f, -0.01361599f, -0.04255787f, -0.03767203f, -0.00945119f, 
    -0.01114874f, -0.02481599f, 0.02076403f, -0.01380038f, 0.02202642f, -0.02726588f, -0.04247752f, 0.00568105f, 
    -0.03575771f, -0.00103321f, -0.01402729f, -0.00042366f, -0.01085906f, 0.02629805f, 0.02279068f, 0.02633872f, 
    0.01714256f, 0.00610380f, 0.02132584f, -0.01697763f, 0.01341409f, -0.01814864f, -0.03367288f, -0.02471696f, 
    -0.02091318f, -0.04094659f, -0.00967878f, 0.01768677f, -0.03487315f, -0.01772820f, 0.01897586f, 0.01741096f, 
    -0.01015952f, 0.01207953f, 0.02393231f, -0.01960346f, -0.00361895f, 0.00244845f, -0.00896191f, -0.03182040f, 
    -0.02312570f, 0.00036366f, -0.00577127f, -0.01795298f, -0.03557375f, -0.01432187f, -0.03637115f, -0.01300515f, 
    -0.03392315f, 0.00131156f, 0.00421509f, 0.01211104f, -0.02836744f, -0.01721939f, 0.02383319f, 0.02096125f, 
    0.02964303f, -0.04276997f, -0.01498464f, -0.02795872f, 0.01949611f, 0.01054536f, 0.00222337f, -0.01314626f, 
    -0.00140467f, 0.02161915f, -0.00341957f, -0.00848525f, 0.02065010f, -0.03888086f, -0.02906215f, -0.02893917f, 
    0.00185275f, -0.00036686f, -0.01559192f, -0.00123883f, 0.01766112f, 0.01898800f, -0.01381409f, -0.00400079f, 
    0.02369361f, -0.03647096f, -0.00551329f, 0.01164971f, 0.02350299f, -0.01989067f, 0.00598167f, 0.01607728f, 
    -0.03636982f, 0.01278585f, 0.01156896f, -0.04420426f, -0.02527993f, -0.01676802f, 0.00199256f, -0.00556933f, 
    0.01199293f, -0.03719882f, 0.01317016f, -0.01410121f, -0.00856895f, 0.00499693f, -0.00660191f, -0.00632278f, 
    -0.01590695f, -0.02432185f, -0.01423448f, -0.00794922f, -0.01397620f, -0.02827909f, 0.02444720f, 0.02087960f, 
    0.00840181f, -0.02091201f, -0.01127065f, 0.00169534f, 0.01868175f, 0.01776062f, -0.01130075f, -0.03082427f, 
    -0.01958182f, 0.01776916f, 0.00358988f, -0.01065292f, -0.00114920f, -0.00417594f, -0.04437778f, 0.01488223f, 
    0.02276893f, -0.00491800f, 0.02403313f, 0.02258563f, -0.02153647f, -0.01174058f, -0.02211269f, 0.01537431f, 
    -0.00545170f, -0.01227714f, -0.00409259f, -0.02524034f, -0.04105465f, -0.02232771f, 0.00599386f, 0.02740171f, 
    0.02016594f, -0.02704456f, -0.00126248f, -0.02388824f, -0.01775478f, -0.00299969f, -0.00452102f, -0.04005717f, 
    0.02920168f, -0.00251689f, 0.01884050f, -0.01981240f, -0.00056074f, -0.01900944f, -0.03714214f, -0.04053235f, 
    0.01191561f, 0.00254272f, -0.00250866f, -0.00622090f, -0.02297773f, -0.01805956f, 0.02844124f, 0.00508892f, 
    -0.04146113f, -0.02781383f, -0.00504074f, -0.01318445f, -0.03469049f, 0.00398744f, 0.02142100f, 0.00603356f, 
    0.00495657f, -0.03514523f, -0.03285998f, -0.00247077f, -0.04185045f, 0.00912323f, 0.01060526f, -0.00622117f, 
    -0.00094663f, -0.01368958f, 0.00927239f, 0.01746431f, -0.01624254f, 0.00693008f, 0.00388906f, -0.00753015f, 
    0.02025156f, -0.03259866f, -0.00830862f, -0.03055562f, 0.01049472f, 0.01145884f, -0.03032106f, -0.02539728f, 
    -0.00874866f, 0.02317405f, 0.01883285f, -0.02216431f, -0.03896369f, -0.03579682f, -0.03883585f, 0.00207256f, 
    -0.02418782f, -0.03268139f, -0.01742829f, 0.00412002f, -0.01510429f, -0.03075672f, -0.01473300f, 0.01011927f, 
    0.00176103f, -0.03533633f, -0.02652803f, 0.02953299f, 0.02377268f, 0.00137005f, 0.03219318f, 0.02167614f, 
    -0.01886260f, -0.03281930f, -0.01092392f, 0.01331938f, 0.01429023f, -0.01231079f, -0.01501702f, 0.01092230f, 
    -0.03195252f, 0.02438683f, -0.02335803f, 0.01771421f, -0.02738060f, 0.00746331f, 0.02119708f, -0.01497139f, 
    0.03220946f, 0.01663180f, -0.00643804f, -0.03539559f, -0.02903316f, 0.01398324f, 0.02224641f, 0.02598202f, 
    -0.03311646f, -0.01459721f, -0.03307949f, -0.01088920f, -0.01937246f, -0.03116586f, -0.00554945f, -0.00695049f, 
    -0.03162614f, 0.02864283f, -0.00319296f, -0.02413740f, -0.03160479f, -0.03298742f, 0.01641581f, -0.03456172f, 
    -0.02056767f, -0.01805792f, 0.01000840f, 0.00105819f, -0.01715576f, 0.01497241f, -0.00542825f, 0.02531171f, 
    -0.01717317f, 0.00751676f, -0.00068508f, 0.00412178f, 0.03206272f, -0.00556661f, -0.01495546f, 0.03263015f, 
    0.01565913f, 0.00523468f, 0.01449835f, 0.01434373f, 0.00554794f, -0.02270541f, 0.01741279f, 0.00285916f, 
    -0.02441894f, -0.02495041f, -0.01474353f, 0.03118626f, -0.00216103f, 0.02372366f, -0.01057070f, 0.01195170f, 
    -0.02720939f, -0.01478371f, 0.02364164f, -0.00613523f, -0.01778846f, 0.00039515f, -0.00179155f, 0.01507727f, 
    -0.03021268f, -0.00462626f, -0.01735708f, 0.03014994f, -0.00739316f, -0.01918830f, -0.00167970f, -0.02477531f, 
    0.03275017f, -0.02734132f, -0.01614989f, -0.00990758f, -0.02512517f, -0.02112047f, -0.03335469f, -0.00530184f, 
    0.03009292f, -0.00843210f, -0.01893669f, 0.01558877f, -0.01689940f, -0.02623851f, -0.00439012f, 0.01464832f, 
    -0.01622604f, 0.00594781f, 0.00227856f, 0.02916267f, -0.01206510f, -0.02079535f, -0.02884176f, -0.02562805f, 
    -0.01143631f, 0.01825159f, -0.02111119f, 0.01783815f, 0.01459982f, 0.01921297f, 0.01918734f, -0.01434149f, 
    0.01049144f, 0.01397264f, 0.01028682f, -0.01017007f, -0.02586491f, 0.01336807f, -0.03418770f, 0.03178854f, 
    -0.02453532f, 0.00965024f, 0.00391941f, -0.03403437f, -0.02620141f, 0.01757812f, 0.01393840f, -0.02988419f, 
    0.02898159f, -0.00661661f, -0.01216078f, -0.00893104f, -0.03228054f, -0.01698492f, 0.00192351f, 0.02990807f, 
    0.01067134f, -0.00473905f, -0.03011340f, 0.01006479f, -0.01706849f, -0.02239277f, -0.01260310f, 0.03424749f, 
    -0.02196943f, 0.03054440f, -0.02143895f, 0.00792630f, -0.01090646f, 0.01819637f, 0.03339949f, 0.03410189f, 
    0.00390568f, 0.00147554f, 0.01799304f, -0.03550425f, 0.03419478f, 0.01569219f, -0.01692341f, -0.01927877f, 
    -0.02110112f, -0.02435939f, -0.03272560f, 0.02252681f, 0.03328270f, -0.00399481f, -0.01077675f, -0.01318889f, 
    0.00471859f, -0.01494021f, 0.02680858f, -0.03350245f, -0.00607009f, 0.00822204f, 0.01890089f, -0.03230383f, 
    0.02351296f, -0.01734797f, 0.01596642f, 0.00066376f, 0.01133159f, 0.03015490f, 0.00013384f, -0.03362698f, 
    -0.01701873f, -0.00276720f, 0.02059365f, -0.02043664f, -0.02778566f, -0.01264989f, 0.01165388f, 0.00126445f, 
    0.01099309f, -0.00278259f, 0.00291846f, -0.03605141f, -0.00465101f, -0.00222507f, 0.00994450f, 0.00573743f, 
    0.01147745f, 0.00738513f, 0.02438852f, 0.00792953f, 0.01498104f, -0.02942033f, 0.03339614f, 0.00224638f, 
    0.03512436f, 0.01192222f, 0.02189657f, -0.01662085f, -0.00742376f, -0.01397010f, -0.01027180f, 0.03535605f, 
    -0.02154990f, 0.00951564f, 0.03085474f, 0.00867288f, -0.01039820f, -0.03113097f, 0.01286504f, 0.01162726f, 
    -0.03098600f, 0.01283086f, 0.01102645f, 0.02115720f, -0.01869426f, 0.02227743f, -0.01787308f, 0.00272546f, 
    0.03260938f, 0.03455705f, -0.00003710f, -0.02320042f, -0.01259838f, -0.01452814f, 0.02438330f, 0.03051433f, 
    -0.03444910f, -0.00674360f, 0.01052282f, -0.03575223f, 0.01128185f, 0.02786797f, -0.01950977f, -0.01026371f, 
    0.02827901f, -0.00661451f, -0.01923353f, -0.00139114f, 0.00356383f, -0.02499346f, -0.00392724f, -0.01976300f, 
    -0.00166060f, 0.02871336f, -0.02726271f, -0.03076510f, 0.00328907f, 0.01051028f, 0.02601424f, -0.01453676f, 
    -0.01692786f, 0.02751717f, 0.02902648f, 0.00052212f, -0.00590963f, -0.01354968f, 0.00423781f, -0.02906760f, 
    0.01258359f, 0.02126814f, 0.00723901f, -0.01690622f, 0.00271334f, -0.03385682f, 0.00912690f, 0.03439524f, 
    -0.03326479f, 0.02300851f, 0.02427997f, 0.00695184f, 0.02803471f, -0.02426756f, -0.02705438f, -0.01803176f, 
    -0.02490689f, 0.02527879f, -0.01735507f, -0.00565813f, 0.00315059f, 0.01305448f, -0.03277509f, -0.01255568f, 
    0.02212824f, -0.00712513f, 0.02058331f, 0.01706594f, -0.00103984f, 0.02089062f, 0.01386923f, -0.02462340f, 
    -0.01661575f, -0.03577376f, 0.02146796f, 0.02356911f, 0.02355903f, -0.01567782f, -0.03025875f, -0.02992579f, 
    -0.02631808f, 0.01625663f, -0.01545364f, 0.00277921f, -0.02489152f, 0.02393255f, 0.01961423f, -0.00745767f, 
    -0.01408891f, 0.03177807f, -0.03275818f, -0.01866506f, -0.01884715f, -0.00533364f, 0.02914999f, 0.02533893f, 
    -0.02595935f, -0.03098256f, 0.00664733f, -0.00068502f, 0.02064461f, -0.01835342f, -0.03114677f, 0.02223881f, 
    0.03130475f, -0.02555669f, 0.02591571f, 0.02864943f, 0.02651969f, 0.02031858f, 0.02607843f, -0.03517368f, 
    0.00710776f, 0.03052452f, -0.03244303f, -0.01354867f, -0.03493873f, 0.02891455f, 0.00885140f, 0.01615399f, 
    0.02257506f, -0.03085800f, 0.01668432f, 0.00735172f, 0.00705562f, 0.02986378f, -0.01790138f, 0.02359284f, 
    0.00817125f, -0.00891561f, -0.02001163f, 0.02175331f, 0.01723781f, 0.00170904f, 0.02276483f, -0.02856852f, 
    -0.01303097f, 0.00169785f, 0.02506934f, 0.01532480f, -0.03547430f, -0.01049524f, -0.00635978f, 0.01841024f, 
    -0.02181445f, -0.00859554f, 0.02608068f, 0.00316281f, -0.01645687f, -0.02702614f, 0.01671892f, 0.01396667f, 
    0.01796941f, -0.01344614f, -0.02666363f, 0.03317732f, -0.03066122f, 0.02192220f, -0.02374553f, -0.02009311f, 
    -0.00811630f, 0.03508362f, -0.02099643f, 0.00294779f, 0.00430057f, 0.00163669f, 0.02101174f, -0.01940477f, 
    0.00121968f, 0.00641213f, -0.02708246f, -0.03418019f, 0.01850999f, 0.02967837f, 0.03119985f, 0.01884643f, 
    -0.01045082f, -0.02445268f, -0.02513788f, -0.00751221f, -0.01133801f, -0.02816281f, -0.01553102f, 0.00123028f, 
    0.02615874f, -0.03595370f, -0.00781561f, -0.00838669f, 0.00074851f, 0.03293859f, -0.02114879f, 0.02422297f, 
    0.02445654f, 0.01809859f, 0.03236575f, -0.01716613f, -0.01146463f, 0.03416660f, 0.03311706f, -0.02735541f, 
    0.01825102f, 0.02157244f, -0.00367952f, 0.02982763f, 0.02800522f, -0.01553310f, 0.00989537f, 0.01247887f, 
    -0.00076853f, 0.00351454f, 0.02434695f, -0.00628412f, 0.01592143f, -0.01029345f, -0.03005496f, -0.02304856f, 
    -0.02009752f, 0.03369185f, -0.02211581f, 0.00227577f, 0.02568610f, -0.02799856f, -0.03087199f, -0.02658138f, 
    0.02563312f, -0.03296034f, 0.02046322f, -0.01340168f, -0.03156399f, 0.03386077f, -0.00835693f, -0.00397498f, 
    -0.00478188f, -0.02921149f, 0.02478187f, 0.01988637f, -0.01790708f, -0.00699350f, -0.03524147f, 0.01256888f, 
    0.00244875f, -0.03492673f, -0.03308493f, 0.00914622f, 0.00522582f, 0.01852319f, -0.02585232f, -0.01307880f, 
    0.03481933f, -0.02253581f, -0.03316843f, 0.03446837f, 0.00257047f, 0.03027810f, 0.00130912f, -0.01612381f, 
    0.02495913f, 0.02499430f, 0.03523678f, 0.00705114f, -0.02012085f, 0.01444537f, -0.02579367f, 0.02490291f, 
    -0.03466258f, -0.00345824f, -0.00681444f, 0.02512224f, 0.00775319f, -0.01651228f, -0.00384638f, 0.03499103f, 
    -0.02029821f, -0.02558232f, 0.01986210f, 0.03461875f, -0.02009240f, -0.02862635f, -0.00657037f, 0.01105452f, 
    -0.01565313f, 0.03225219f, 0.00188073f, -0.00380895f, -0.01675582f, -0.00162021f, 0.02509939f, -0.00833451f, 
    0.02092051f, 0.02192152f, -0.01314803f, 0.00328478f, 0.01110525f, -0.02289089f, -0.02049872f, -0.02333917f, 
    -0.00351908f, -0.01184080f, -0.03564300f, 0.02612883f, -0.01251826f, -0.01050014f, -0.00728857f, 0.00404763f, 
    0.01584978f, -0.03053342f, 0.01711277f, -0.01522299f, 0.02580560f, 0.01092026f, -0.03107820f, 0.01196074f, 
    0.01322176f, -0.01014308f, 0.00897480f, -0.00593617f, -0.01093012f, -0.02448668f, 0.00118174f, -0.00422281f, 
    -0.00610253f, -0.02440955f, -0.01210294f, 0.02547286f, 0.01789276f, -0.01436424f, -0.02303252f, -0.02138541f, 
    0.02967236f, -0.00395799f, 0.01726742f, 0.03257602f, 0.01196848f, 0.02746332f, 0.02493641f, -0.02765385f, 
    -0.01879796f, 0.03019011f, -0.00011453f, -0.03599564f, 0.01927979f, -0.01705831f, 0.03062832f, 0.00013984f, 
    -0.01609597f, -0.01711367f, 0.01892634f, 0.01652335f, -0.01379225f, -0.03556584f, -0.00432220f, -0.02482908f, 
    0.03311869f, 0.02701642f, 0.00886273f, -0.01289783f, 0.00792942f, -0.01969920f, -0.00177776f, -0.03165777f, 
    -0.02315356f, -0.01249595f, 0.02697346f, -0.02243587f, 0.02514159f, -0.03065507f, 0.00732313f, -0.03343492f, 
    -0.00568329f, -0.01709885f, 0.02515311f, 0.02631927f, 0.01887565f, 0.03336257f, -0.02864970f, 0.02325155f, 
    0.02713230f, 0.03095916f, -0.00767008f, -0.01547288f, -0.01817728f, 0.00145599f, 0.02330893f, -0.00422833f, 
    -0.02767256f, -0.00500304f, -0.03143651f, -0.01173234f, -0.02189946f, 0.03167960f, 0.03311227f, -0.01360670f, 
    0.00757381f, -0.02638452f, -0.02504308f, -0.02201646f, -0.03241242f, -0.01600606f, -0.01113374f, -0.03238810f, 
    -0.01896068f, -0.02144436f, 0.01262957f, 0.01227303f, 0.01516606f, 0.03276711f, -0.02256585f, -0.00700882f, 
    -0.02889825f, -0.01630976f, -0.02465799f, 0.00459246f, 0.00937369f, -0.03574447f, -0.01898838f, 0.00829526f, 
    0.01955270f, -0.00029041f, 0.00517111f, -0.02477513f, 0.02194800f, 0.00126381f, -0.02484487f, 0.00168419f, 
    -0.02131310f, 0.00429023f, 0.00952337f, 0.01282908f, -0.02160580f, -0.02593013f, -0.01899796f, 0.02163590f, 
    -0.00213649f, -0.01784062f, -0.02133019f, 0.02967075f, -0.03189917f, 0.01536375f, -0.01039458f, 0.02318192f, 
    0.01533152f, -0.02588174f, 0.01189338f, -0.00940835f, 0.02629448f, -0.03169078f, -0.01728055f, 0.00799004f, 
    -0.03062151f, -0.01687293f, -0.02238854f, -0.01382703f, -0.02107645f, 0.01485292f, -0.03409035f, 0.02525363f, 
    0.03497657f, -0.00427631f, -0.00026560f, 0.01392554f, 0.00680264f, -0.00970972f, -0.03577123f, 0.03175209f, 
    0.00894816f, 0.01086896f, -0.00920605f, 0.01347186f, -0.01839740f, -0.01177627f, 0.01942125f, -0.02633126f, 
    -0.01626328f, -0.03375094f, 0.01794069f, 0.03182087f, 0.03559056f, 0.00476751f, -0.03569262f, 0.01992242f, 
    -0.00540947f, -0.00671364f, 0.00437850f, -0.00068897f, -0.02699418f, 0.01939298f, -0.01732592f, -0.01596791f, 
    -0.03134816f, -0.01929873f, -0.02448748f, -0.01046798f, 0.01853775f, -0.03175060f, -0.01391547f, 0.01822563f, 
    0.03606334f, -0.00903333f, -0.03320064f, 0.02858842f, 0.02944880f, -0.01444879f, -0.00825550f, -0.02680220f, 
    -0.02121203f, 0.01912145f, -0.00896159f, -0.02175512f, 0.01200438f, 0.03530182f, -0.01515130f, -0.01050062f, 
    -0.00946636f, -0.01432903f, -0.02014798f, 0.01118598f, -0.00947423f, -0.00942251f, -0.03330595f, -0.00616234f, 
    0.01160649f, -0.03608937f, 0.01365124f, -0.03255682f, 0.00590353f, 0.02191557f, -0.04055595f, -0.01153987f, 
    0.01693221f, -0.01006158f, -0.00890122f, -0.00328859f, -0.00510711f, -0.00464214f, -0.00893803f, -0.00868384f, 
    -0.03050634f, 0.01336059f, -0.02167086f, 0.00125931f, 0.01521162f, -0.04259153f, 0.02618790f, -0.01244205f, 
    -0.00882178f, 0.00020261f, -0.03678847f, 0.00744304f, 0.00036881f, -0.02821301f, -0.01776624f, 0.01726991f, 
    0.00676053f, -0.01544124f, -0.01971066f, -0.03398360f, -0.03311947f, 0.00582600f, -0.03899381f, 0.02398527f, 
    0.02049945f, -0.01952444f, -0.01426357f, 0.00596910f, 0.01564708f, 0.01020493f, 0.00447866f, 0.00703230f, 
    -0.02273157f, -0.02675498f, -0.01587189f, -0.02270920f, 0.01446727f, -0.01293735f, -0.00227705f, -0.01917819f, 
    -0.02742631f, -0.03448651f, -0.04407637f, 0.02633105f, -0.01499510f, -0.04021285f, -0.03513631f, 0.02396626f, 
    -0.01528354f, -0.03668633f, 0.01942725f, -0.04414187f, 0.02549115f, 0.01964272f, 0.02213345f, 0.00328328f, 
    -0.00562779f, -0.02974017f, -0.04419284f, -0.02987725f, 0.00082470f, -0.03263839f, -0.03926895f, 0.01306478f, 
    0.02541066f, 0.01067555f, 0.00590453f, -0.01734287f, -0.00710292f, -0.01096418f, -0.02891968f, -0.01918715f, 
    0.01816943f, -0.01486946f, 0.00411425f, 0.00542422f, -0.03834264f, -0.00098793f, 0.02854778f, -0.03694139f, 
    -0.04047704f, -0.03386028f, -0.00663145f, 0.01216528f, -0.00114156f, 0.01731884f, -0.00767148f, 0.00112505f, 
    -0.02108634f, 0.01504052f, 0.01906919f, 0.01451109f, -0.01051254f, 0.01109150f, 0.00816707f, -0.00084286f, 
    -0.01862512f, 0.02096393f, 0.01586161f, 0.00148316f, 0.01411550f, -0.00823044f, 0.01241481f, 0.01532862f, 
    -0.00557858f, 0.01764764f, -0.02832915f, -0.03835548f, 0.00732457f, -0.00673132f, 0.00381227f, -0.00736287f, 
    0.00259439f, -0.04004106f, -0.04464880f, -0.03949535f, -0.03910336f, 0.00041663f, 0.01683572f, 0.00053287f, 
    -0.02891535f, -0.01763811f, 0.01794850f, 0.00660092f, -0.00208694f, 0.00868883f, 0.02611199f, -0.00938844f, 
    0.00558893f, 0.00081888f, -0.00259684f, -0.03213309f, 0.00523869f, 0.01125642f, 0.01559968f, 0.01542177f, 
    0.01011347f, -0.01493228f, -0.02074641f, -0.03015324f, -0.00194582f, -0.02249556f, -0.00366485f, 0.01158568f, 
    0.02419018f, 0.00530419f, -0.01639102f, 0.00055975f, -0.04143516f, -0.02163590f, -0.03237355f, -0.01988684f, 
    0.00436672f, 0.01157862f, -0.03084276f, -0.00184309f, -0.02212198f, 0.02562173f, -0.03160153f, 0.00948501f, 
    -0.01493858f, 0.00259458f, 0.02321147f, -0.02770271f, -0.00603457f, 0.00324888f, -0.03347819f, 0.01892239f, 
    -0.01286068f, -0.00377063f, -0.02646238f, 0.01932570f, -0.00801530f, -0.02018598f, -0.01598015f, -0.00626872f, 
    -0.01181029f, 0.01159923f, -0.04195002f, 0.00809244f, 0.01077397f, 0.00935739f, -0.00128302f, -0.00408715f, 
    -0.03214694f, 0.00124308f, -0.01483988f, -0.03626541f, 0.00118921f, -0.01017593f, -0.00798808f, 0.00946629f, 
    0.03078911f, -0.00550919f, 0.00122117f, -0.03576631f, -0.01858979f, 0.00085927f, -0.02056870f, 0.02649368f, 
    -0.04158381f, 0.01684178f, 0.01297197f, -0.00486935f, -0.02094669f, 0.03284540f, -0.00406505f, -0.01389730f, 
    0.02393138f, -0.04411323f, -0.02888864f, -0.04097126f, 0.01244435f, 0.00503349f, -0.03825707f, 0.01487095f, 
    0.02671302f, 0.02286158f, -0.02632532f, -0.01535195f, -0.04207224f, -0.02935408f, 0.02806487f, -0.03649476f, 
    0.00625030f, -0.00083776f, -0.02125707f, -0.01184389f, 0.01437310f, -0.03115233f, 0.01889942f, -0.00326758f, 
    0.01223574f, 0.00764986f, -0.02093946f, -0.03280048f, 0.00044630f, 0.02139685f, -0.00531135f, -0.00604914f, 
    0.02725618f, 0.00403418f, 0.01092900f, -0.01147056f, -0.02694076f, 0.02374568f, -0.02542039f, 0.00449127f, 
    -0.00441227f, 0.00034598f, -0.03372503f, -0.02720472f, 0.01721832f, 0.02589415f, -0.01606369f, -0.04386514f, 
    0.00501052f, 0.01246400f, -0.00798435f, 0.00050925f, -0.00742931f, -0.03621830f, 0.00062382f, -0.03892051f, 
    0.02254830f, -0.03917384f, -0.00232681f, -0.01532017f, 0.02068367f, -0.01303227f, 0.00787712f, -0.01708945f, 
    -0.02519480f, -0.01972709f, 0.00045505f, -0.04128964f, -0.03837561f, 0.00812976f, -0.01614302f, -0.02290580f, 
    -0.01008515f, -0.03620165f, 0.00330246f, 0.01511750f, 0.01945715f, 0.01338081f, -0.01143539f, 0.01020852f, 
    0.00206472f, 0.01704349f, -0.00225058f, 0.00813700f, -0.03914653f, -0.02885081f, 0.01268894f, -0.00132900f, 
    0.01863555f, -0.02908365f, -0.02249429f, -0.03455998f, 0.02609181f, 0.00798064f, 0.02007041f, -0.00629926f, 
    -0.00662284f, -0.03764055f, 0.00282883f, 0.00087432f, 0.02215772f, -0.03373531f, -0.01625003f, 0.00261130f, 
    0.02347844f, -0.00233663f, -0.01633747f, -0.02598624f, -0.00570035f, 0.02459702f, -0.02538852f, 0.02601961f, 
    0.00147147f, -0.00453328f, -0.04382829f, -0.00285753f, 0.02546586f, -0.01869829f, -0.04354380f, -0.00541983f, 
    0.00683044f, -0.00674851f, -0.03282085f, 0.01121608f, 0.02829150f, 0.01156566f, 0.02091607f, -0.03711609f, 
    -0.00645788f, -0.00500134f, -0.03927995f, -0.02644902f, 0.00103527f, -0.01950463f, -0.02116358f, -0.02957790f, 
    0.01341427f, 0.00551378f, 0.01340910f, -0.02554465f, -0.04148373f, -0.02165246f, 0.02333611f, -0.04238008f, 
    -0.03081190f, -0.00094327f, 0.01532653f, -0.03969944f, 0.01987451f, -0.02894656f, 0.01006490f, -0.00486453f, 
    -0.03799769f, -0.04188817f, -0.01866847f, -0.01961014f, -0.00042906f, -0.00270672f, -0.03170904f, -0.00257744f, 
    0.00627608f, -0.01244289f, -0.01695723f, -0.03522604f, -0.00315714f, -0.03607707f, 0.02602225f, -0.03317872f, 
    0.02483936f, -0.03423128f, -0.03278536f, -0.03789921f, -0.03916461f, -0.04020822f, 0.02585813f, 0.01389629f, 
    -0.03354292f, -0.01599995f, -0.02518377f, -0.03317595f, -0.02112442f, -0.04123504f, -0.02887605f, 0.01564012f, 
    -0.02920861f, 0.01603912f, -0.04256444f, 0.02425443f, -0.02144385f, -0.04205893f, -0.02204246f, 0.00801219f, 
    -0.01860225f, -0.04035867f, -0.02142983f, -0.01368736f, -0.01350269f, 0.02141966f, 0.00705652f, -0.01798933f, 
    -0.03518470f, -0.01103363f, -0.00155042f, 0.01617663f, 0.01885631f, -0.01795820f, -0.00758007f, -0.01008436f, 
    -0.00512315f, -0.02085396f, -0.03525922f, 0.02931466f, -0.03009011f, -0.02032644f, -0.01114912f, 0.00040672f, 
    -0.03777104f, 0.00588639f, -0.00186313f, -0.00271417f, 0.02343803f, 0.01931203f, -0.01265629f, 0.02579310f, 
    -0.02512645f, 0.02570447f, 0.00415599f, 0.00016037f, -0.03996620f, 0.01329553f, 0.01377085f, 0.02362867f, 
    -0.02172021f, -0.01927775f, -0.01246727f, -0.01753442f, -0.00096433f, -0.03200332f, 0.00355691f, 0.02063739f, 
    0.02064101f, 0.01686683f, -0.03660524f, 0.02040764f, 0.01499959f, 0.00705731f, -0.04091434f, 0.02202101f, 
    -0.04209781f, 0.02632172f, -0.00774461f, 0.01776244f, -0.00132437f, -0.01216422f, -0.01105610f, 0.00434081f, 
    -0.00398355f, -0.03828825f, 0.00361930f, -0.04463801f, -0.01253334f, -0.03920748f, -0.01201559f, 0.00210810f, 
    -0.03349431f, -0.01169815f, -0.00665050f, -0.01041654f, -0.00808367f, 0.02423604f, -0.00844451f, -0.03149417f, 
    -0.03655998f, 0.02701399f, 0.01907030f, 0.02988220f, 0.01508956f, -0.00906585f, -0.02888080f, 0.02051814f, 
    0.00579273f, -0.00692358f, 0.01749389f, -0.03749415f, -0.00948156f, -0.03144827f, 0.00327290f, -0.02162806f, 
    -0.00759646f, 0.00516628f, -0.00767360f, -0.01722082f, -0.01519616f, 0.00308185f, 0.01247864f, -0.01568353f, 
    0.01693444f, 0.01666927f, -0.02632016f, 0.00534030f, -0.01906848f, -0.02926942f, 0.00280692f, -0.03671393f, 
    -0.00787415f, 0.00009079f, 0.02651628f, -0.04371386f, 0.01491415f, -0.00826224f, 0.02425807f, -0.02151849f, 
    0.00492407f, 0.01977993f, -0.03596494f, 0.02611557f, 0.01258029f, 0.00548903f, -0.01395576f, -0.03368719f, 
    -0.00832588f, -0.02865623f, -0.01950089f, 0.01691360f, -0.03931541f, -0.01654745f, -0.03938542f, -0.02857560f, 
    -0.03501743f, -0.02330399f, 0.01247139f, 0.02753751f, 0.02072248f, -0.00686826f, 0.01458955f, 0.01835708f, 
    -0.00607596f, -0.01432903f, -0.02941894f, 0.02396130f, -0.04026253f, -0.00146546f, 0.01786032f, 0.02198216f, 
    0.02272842f, 0.00682036f, 0.02672289f, 0.01817457f, -0.02300026f, -0.04150983f, 0.02414709f, -0.03671807f, 
    0.01634190f, -0.01725306f, 0.00294326f, -0.02562507f, 0.02761116f, -0.01410079f, -0.00734287f, -0.00391267f, 
    -0.03615184f, -0.03088126f, -0.00420938f, 0.01270465f, 0.01335930f, -0.01811842f, -0.02676137f, -0.00354422f, 
    -0.03194470f, -0.04100079f, -0.02288242f, -0.00291338f, 0.02337012f, 0.01652218f, -0.02172773f, -0.02804085f, 
    -0.01191571f, 0.01823039f, -0.04073349f, 0.02322140f, -0.02102163f, 0.01526806f, -0.03050502f, 0.01395670f, 
    0.01690493f, 0.00504575f, 0.01090963f, -0.02696993f, 0.02314738f, -0.03132218f, -0.02296059f, 0.00626068f, 
    -0.01768911f, -0.02759153f, 0.01709289f, -0.01682021f, -0.04360167f, -0.03702812f, -0.00843991f, 0.01791245f, 
    0.01332860f, 0.00905119f, 0.01764714f, 0.00843191f, 0.01143397f, -0.02298442f, -0.01872359f, -0.03825162f, 
    -0.03043099f, 0.00145667f, 0.00074420f, 0.02545460f, -0.00711545f, 0.02058727f, -0.04033933f, 0.00291807f, 
    0.00137292f, 0.02423888f, -0.01094568f, 0.00628701f, 0.01646435f, 0.01247471f, -0.02304384f, -0.00220529f, 
    -0.00653871f, -0.03033979f, 0.02292068f, 0.00424050f, 0.02328411f, -0.03540905f, 0.00474498f, 0.00454213f, 
    -0.01175531f, 0.00733186f, -0.01753117f, -0.01242069f, -0.02356928f, -0.03130835f, 0.01433697f, -0.02200675f, 
    -0.00665863f, 0.01813516f, -0.04423941f, 0.01323435f, -0.01321025f, -0.03338590f, -0.02514113f, -0.03421944f, 
    -0.01283962f, 0.01030858f, 0.00994583f, -0.01308276f, -0.04120903f, 0.00108096f, -0.01534017f, -0.01154551f, 
    0.02166838f, 0.01534501f, -0.01163176f, -0.00288256f, 0.01560696f, -0.04462420f, -0.01972578f, 0.01798431f, 
    -0.00383006f, -0.04180088f, -0.00274976f, -0.02507146f, -0.01272357f, -0.00045912f, 0.00265156f, -0.01016782f, 
    -0.04166720f, -0.03221191f, 0.00665615f, 0.01642143f, -0.01249814f, 0.00753082f, -0.01237032f, -0.00694508f, 
    0.00482317f, -0.01670438f, -0.01001844f, -0.02037003f, -0.03231739f, 0.02268777f, 0.01416765f, 0.00207606f, 
    0.01229417f, 0.02220820f, -0.02098102f, 0.00155243f, -0.00056128f, -0.03241922f, 0.01412023f, -0.00169811f, 
    -0.04154633f, -0.02129029f, 0.01374505f, 0.01621065f, -0.00491059f, 0.01900552f, 0.02263184f, -0.00001820f, 
    -0.01371978f, -0.01872542f, 0.01870997f, -0.03386055f, 0.01790779f, -0.02245703f, -0.01259198f, 0.00644014f, 
    0.00322406f, -0.00202986f, -0.03551767f, 0.00626772f, -0.01727891f, -0.03363268f, 0.02498421f, 0.02120561f, 
    0.00115907f, 0.02712996f, 0.01982448f, 0.01363907f, 0.01869064f, -0.00027810f, -0.01733165f, -0.00397780f, 
    -0.01739776f, -0.02190015f, 0.01666210f, 0.00807177f, -0.01562770f, -0.03588821f, -0.02632016f, 0.02321650f, 
    0.00401725f, 0.01396195f, -0.02408440f, 0.02204350f, 0.02199003f, -0.02850543f, 0.02594797f, -0.01264245f, 
    -0.01167193f, -0.03989632f, -0.00535572f, 0.01780783f, -0.03998090f, -0.02729341f, -0.03971071f, 0.00584494f, 
    -0.01796349f, -0.03086084f, 0.02735466f, -0.00250090f, 0.01281893f, -0.01291361f, 0.02021618f, 0.02439578f, 
    -0.03428745f, -0.03479599f, 0.02945426f, 0.02061487f, 0.01347778f, -0.02587930f, -0.01951277f, 0.00372876f, 
    0.01658137f, 0.01486520f, -0.02538190f, -0.03373576f, -0.02244711f, -0.03790121f, 0.03395661f, 0.01742154f, 
    0.00891322f, -0.00350084f, -0.01495638f, 0.01407172f, -0.03463813f, -0.01611046f, -0.02361696f, -0.03501984f, 
    -0.00367157f, 0.00539526f, -0.04032046f, 0.00847013f, 0.02252899f, 0.02235353f, 0.01253417f, 0.02981723f, 
    0.01242813f, -0.04067706f, -0.01332331f, 0.01882365f, -0.00121208f, -0.00575492f, -0.03196233f, -0.01686650f, 
    -0.04377479f, 0.03105412f, 0.01542129f, 0.01264316f, -0.01596740f, 0.00594215f, -0.03027674f, -0.04498791f, 
    0.02238341f, -0.03034966f, 0.00826745f, 0.00481405f, 0.02358523f, 0.00261817f, -0.00740729f, 0.02203493f, 
    -0.02769371f, 0.02234455f, 0.00678106f, -0.02123161f, -0.00085410f, 0.02849928f, 0.00429876f, -0.00709845f, 
    -0.03650716f, -0.00650353f, -0.04383968f, -0.02642832f, -0.03503849f, -0.03791900f, 0.01209641f, -0.00233353f, 
    0.01715882f, 0.00358259f, -0.00129675f, 0.00266296f, 0.01760619f, -0.01064884f, -0.00576840f, -0.02463035f, 
    -0.01892222f, -0.02749459f, -0.01036753f, 0.01429366f, 0.02321643f, -0.03381332f, 0.00018884f, -0.02202048f, 
    -0.03332081f, 0.01328199f, -0.04350245f, -0.00160075f, -0.00883546f, 0.00276526f, 0.01419426f, -0.03338395f, 
    -0.03178892f, -0.01234977f, -0.00161032f, -0.02728065f, -0.00260647f, -0.01295441f, 0.00663622f, -0.00344375f, 
    -0.02896935f, 0.02317505f, -0.00966737f, 0.01962638f, 0.00662425f, 0.02000458f, -0.00371149f, 0.02725118f, 
    0.01953964f, -0.00990727f, 0.02124284f, -0.02991030f, -0.00590068f, -0.04189396f, -0.00086088f, 0.02120731f, 
    -0.04014358f, -0.02099639f, -0.02408008f, -0.01380421f, -0.02256491f, -0.02996862f, 0.01740423f, -0.03095120f, 
    -0.00761298f, 0.02112604f, -0.04398704f, 0.02452285f, -0.00706059f, 0.00391825f, 0.03369493f, -0.01390021f, 
    -0.02847404f, 0.00402637f, 0.00084390f, -0.02073034f, 0.02530523f, 0.02821358f, 0.00057721f, 0.02522150f, 
    0.00627662f, 0.01073494f, -0.02053215f, 0.02465987f, -0.02535457f, -0.03958147f, -0.00746011f, 0.02702714f, 
    -0.00366297f, 0.02931261f, 0.01005940f, -0.00714058f, -0.00703292f, -0.04593046f, -0.03660379f, -0.02123396f, 
    -0.01567584f, 0.02518744f, -0.03216410f, 0.02896631f, 0.02312409f, 0.02176629f, -0.04523047f, -0.01930120f, 
    -0.04394794f, -0.02993094f, -0.00089173f, -0.01664758f, -0.04060337f, -0.02410359f, -0.01943938f, 0.00776551f, 
    0.00437137f, -0.02948989f, -0.03092161f, -0.00396288f, -0.03717834f, -0.02731859f, -0.03485566f, 0.01155949f, 
    0.02990043f, 0.00329786f, -0.01963674f, -0.03858648f, -0.01992374f, 0.04237986f, -0.03262457f, -0.04277285f, 
    -0.03295272f, -0.03481129f, -0.02449150f, -0.01371673f, 0.01042770f, 0.01226953f, 0.02306463f, 0.02586922f, 
    -0.00168950f, 0.00534778f, 0.01104552f, 0.00025760f, -0.00258620f, 0.02520300f, -0.03723334f, 0.03360289f, 
    0.01292451f, -0.01935393f, 0.02946024f, 0.01926724f, -0.01023580f, 0.00409252f, -0.01440360f, 0.00392282f, 
    0.01120635f, 0.02055207f, -0.03223889f, 0.02964316f, -0.00231618f, -0.02979262f, 0.03488933f, 0.02067451f, 
    -0.04371865f, -0.04089423f, 0.01950461f, -0.01320630f, 0.01914888f, -0.01722496f, -0.03652051f, -0.03027407f, 
    -0.00864220f, 0.02480737f, 0.01500531f, -0.04274723f, 0.00735853f, -0.02219153f, -0.01573656f, -0.02296129f, 
    -0.01344402f, -0.00677555f, 0.00923663f, -0.00848972f, -0.03261719f, -0.03268212f, -0.01181915f, -0.03041655f, 
    -0.02556970f, -0.00994905f, -0.00156010f, 0.02856046f, 0.02812690f, 0.02066074f, -0.02923193f, -0.01308564f, 
    0.00128536f, -0.02109707f, -0.02602199f, -0.02030615f, -0.00582547f, 0.00066281f, -0.04430001f, -0.00676987f, 
    -0.00229345f, -0.02216426f, 0.00357850f, -0.03889241f, -0.01598852f, 0.03475543f, 0.01112754f, 0.00411231f, 
    0.02541045f, 0.03520378f, 0.02024991f, -0.02507492f, 0.01592579f, -0.00862975f, -0.02771431f, 0.01907472f, 
    -0.01675253f, -0.01111935f, 0.00940351f, 0.02020331f, -0.02444405f, -0.04073157f, -0.03682715f, -0.02364736f, 
    -0.00210717f, -0.03898658f, -0.02180933f, 0.02686258f, 0.01938277f, -0.00562523f, -0.01168270f, -0.00502762f, 
    0.01507282f, 0.00786295f, -0.02221370f, 0.01046441f, -0.00167810f, 0.01748038f, -0.02461023f, 0.00318728f, 
    0.00217255f, -0.03339893f, 0.01372846f, 0.02543938f, -0.02609949f, 0.00776620f, -0.00059328f, 0.00310772f, 
    -0.03216657f, 0.00260273f, 0.01991371f, -0.01613255f, 0.01485069f, 0.00048910f, 0.00229633f, 0.01464929f, 
    -0.00398578f, 0.01598826f, -0.00834584f, 0.01726621f, 0.00595394f, -0.00940303f, -0.02445375f, -0.03813504f, 
    0.02246288f, 0.01055236f, 0.00541400f, -0.00943107f, -0.01742245f, -0.01256944f, -0.03632548f, 0.00873566f, 
    0.00997588f, -0.03526623f, -0.03796106f, 0.01017997f, -0.01971508f, 0.01581656f, -0.02719580f, -0.01888238f, 
    -0.00573994f, -0.01455477f, 0.02452009f, 0.01504619f, -0.03317691f, 0.02229437f, -0.03098018f, -0.02126137f, 
    -0.03094933f, -0.04017806f, -0.02268050f, -0.00971193f, 0.01791722f, -0.02465072f, -0.03148314f, -0.01215491f, 
    -0.04237477f, -0.02889539f, -0.01834693f, 0.00684483f, 0.01281519f, 0.02812698f, 0.02071371f, 0.03040505f, 
    -0.03916989f, -0.02107605f, -0.00562661f, -0.02775095f, 0.00092670f, 0.02391535f, -0.00421389f, -0.00448710f, 
    0.00149647f, 0.00336147f, -0.03980539f, -0.01263730f, -0.01052465f, 0.02343247f, 0.00626874f, -0.02219014f, 
    0.01445590f, 0.01811319f, -0.00073679f, 0.03293055f, 0.02651946f, -0.00113475f, 0.02389010f, 0.02357152f, 
    -0.00624675f, 0.00528436f, -0.02658487f, -0.04279619f, 0.02668360f, -0.04431651f, 0.01627946f, 0.03377865f, 
    -0.01234644f, 0.00127619f, -0.02222684f, -0.00508913f, 0.00673248f, -0.03800838f, -0.00196580f, 0.00488287f, 
    -0.03677986f, 0.01095313f, -0.00476250f, -0.00803631f, 0.00809398f, -0.02659381f, -0.01884439f, 0.00681123f, 
    -0.03347224f, 0.02620728f, 0.01287097f, -0.02910129f, -0.01743615f, -0.02826554f, 0.03186043f, -0.02646304f, 
    0.00163221f, -0.00662622f, -0.03232450f, -0.02138012f, 0.03052257f, 0.00509641f, -0.00663493f, -0.02478246f, 
    0.01332714f, 0.00350173f, -0.03039881f, 0.02389341f, 0.01401725f, -0.03957092f, -0.02480014f, -0.00903084f, 
    0.00118731f, -0.01684554f, -0.01064879f, 0.02155431f, -0.03157771f, -0.03497648f, 0.00955683f, -0.03930073f, 
    -0.02447196f, 0.00154249f, -0.01664569f, 0.02421805f, -0.01230804f, -0.02217668f, -0.03330081f, 0.00055941f, 
    0.00206933f, -0.01068626f, -0.01754204f, -0.02291381f, 0.00410097f, -0.02680029f, 0.00710998f, -0.00213710f, 
    0.00304051f, -0.02434815f, -0.00068371f, 0.00938457f, 0.02502286f, 0.00817872f, -0.03469989f, -0.01455177f, 
    -0.01931290f, -0.01191790f, 0.00258008f, 0.01442397f, -0.02583936f, -0.04197232f, -0.03352436f, 0.01222279f, 
    0.02179084f, 0.00505304f, -0.01653210f, 0.00872767f, -0.00019513f, -0.00785969f, -0.01713750f, -0.02712508f, 
    0.00542288f, 0.01312271f, 0.02266036f, 0.00050897f, -0.02590007f, 0.00176585f, -0.03425725f, 0.00829360f, 
    0.00171660f, -0.01252493f, 0.01526353f, -0.04013206f, 0.01607401f, 0.01605615f, 0.01521346f, -0.01245781f, 
    -0.04157584f, -0.00907710f, 0.00302998f, -0.03035581f, -0.03086427f, 0.02100095f, -0.01941711f, -0.01375838f, 
    -0.00810444f, -0.00495903f, -0.01930379f, 0.00456830f, 0.01286120f, -0.03585037f, -0.02298704f, 0.00300522f, 
    0.00420006f, -0.02969864f, -0.00224439f, 0.01868551f, -0.01540756f, -0.04618657f, -0.02143255f, -0.03135676f, 
    0.02373700f, 0.02256302f, -0.01458389f, -0.03189776f, -0.04345872f, 0.02947873f, -0.02539033f, 0.01323646f, 
    -0.01304663f, 0.00501179f, -0.00226730f, -0.02510788f, 0.01302539f, 0.02016456f, -0.01458449f, -0.02018666f, 
    -0.03012090f, -0.00842382f, 0.00379287f, -0.00365647f, -0.00649078f, -0.01832066f, -0.02346137f, -0.00809852f, 
    0.01927125f, -0.02218852f, -0.00819010f, 0.00319393f, -0.00792678f, -0.04117791f, 0.03082306f, -0.00947276f, 
    0.02551814f, 0.02633491f, -0.00464248f, -0.02301872f, 0.02748556f, -0.03556280f, -0.01526087f, -0.00381445f, 
    -0.02176289f, -0.01594938f, 0.02139877f, -0.02754914f, 0.00429637f, 0.01382634f, -0.00250979f, -0.01191135f, 
    -0.01008080f, 0.02385660f, -0.02785133f, 0.00332109f, -0.00358754f, 0.01860886f, -0.03634105f, 0.01831951f, 
    -0.02679627f, -0.03944235f, -0.02917244f, 0.00667316f, 0.00508295f, 0.00540771f, 0.02607248f, -0.02073465f, 
    -0.00534576f, -0.01511759f, 0.02157032f, 0.00348485f, -0.01396312f, 0.00930183f, -0.01100952f, 0.01308098f, 
    0.02204597f, 0.00928243f, 0.01370290f, -0.01447976f, -0.01368566f, 0.00623436f, -0.03917915f, 0.02823314f, 
    0.02868758f, -0.01886479f, -0.02798361f, -0.03652760f, -0.03321527f, -0.01678454f, 0.01869135f, 0.00210848f, 
    0.01977528f, 0.01959321f, -0.02738297f, -0.02707798f, -0.01973217f, 0.00195802f, -0.01145285f, 0.03088214f, 
    0.01461015f, 0.00580072f, -0.03848380f, -0.00846098f, 0.00591638f, -0.02336896f, 0.01242435f, -0.02800132f, 
    0.02572279f, 0.01382946f, 0.00253448f, 0.00406785f, 0.01687928f, -0.01249670f, 0.03528421f, -0.02218909f, 
    -0.00636125f, 0.00820057f, -0.00699380f, -0.00789859f, -0.00465747f, -0.02799066f, -0.03544558f, 0.01195155f, 
    0.01993497f, -0.00467099f, 0.00221339f, 0.02832748f, -0.00103971f, 0.00373337f, 0.00945658f, -0.01124385f, 
    0.00031366f, -0.02297110f, 0.03144210f, 0.02349909f, 0.00982111f, -0.03660057f, -0.00509835f, 0.00326775f, 
    -0.01567543f, -0.04010680f, -0.01752635f, -0.01363261f, -0.02793827f, -0.00024608f, -0.00202621f, 0.01106828f, 
    0.00525849f, 0.00728631f, -0.01190867f, -0.03779094f, -0.00466825f, -0.01488072f, 0.03811938f, -0.00688897f, 
    0.01210627f, 0.01260339f, -0.03372659f, -0.04383795f, -0.00597346f, -0.02803258f, -0.02335183f, 0.01017820f, 
    -0.03033655f, -0.00491726f, 0.00866572f, -0.00637088f, 0.01261520f, -0.03649862f, -0.02608351f, 0.02575633f, 
    0.00023766f, -0.04235060f, -0.00265734f, -0.03075166f, -0.02045547f, -0.00777110f, -0.02655789f, -0.01875945f, 
    0.02514279f, -0.00295560f, -0.00230804f, 0.01742654f, -0.02139232f, 0.02603328f, 0.00034821f, 0.00939695f, 
    -0.01297600f, 0.01485872f, -0.00638808f, -0.01505667f, -0.01495859f, -0.02126074f, -0.01496773f, -0.01787656f, 
    -0.03344738f, -0.00889367f, -0.02068687f, -0.03804606f, 0.01921902f, -0.01688748f, 0.01061549f, -0.00575418f, 
    -0.01651680f, 0.02442023f, 0.03297121f, 0.02645973f, 0.01147330f, -0.00741509f, 0.02174505f, -0.01037001f, 
    -0.04327546f, -0.01904118f, -0.03429940f, -0.00723542f, 0.00613404f, -0.02878141f, -0.00085054f, 0.02896288f, 
    -0.04554250f, -0.14399455f, 0.00692918f, 0.09007297f, 0.20781633f, -0.09844604f, 0.03917070f, -0.05750882f, 
    0.16309877f, -0.05264662f, 0.19298747f, 0.12374365f, 0.08443797f, 0.09587643f, -0.15855874f, 0.07512943f, 
    0.08041000f, -0.13256280f, 0.19719577f, 0.01571086f, -0.04574151f, 0.20441037f, 0.09019150f, 0.11556757f, 
    0.27694416f, 0.02366072f, 0.18460652f, 0.21193080f, -0.07809992f, -0.10968748f, 0.00105887f, 0.07723832f, 
    -0.03184468f, 0.04658160f, 0.08299857f, 0.08240090f, -0.06077947f, -0.26738513f, -0.01688356f, 0.01390570f, 
    0.00363391f, -0.07614408f, 0.04022193f, -0.08669067f, 0.00826560f, -0.21127416f, 0.11850168f, 0.07422759f, 
    -0.24480477f, -0.00327247f, -0.04715230f, 0.02926314f, 0.10051437f, -0.11143775f, 0.06382485f, -0.04773481f, 
    0.08292518f, 0.07072198f, -0.07474962f, 0.05647212f, 0.20763452f, -0.16979364f, 0.16737726f, -0.12317978f, 
    0.03065602f, 0.10170388f, 0.07747063f, -0.05450694f, 0.23164427f, 0.05943527f, -0.14359640f, -0.06382060f, 
    -0.07014041f, 0.02463299f, 0.08622873f, 0.07698289f, 0.14351834f, 0.04020398f, -0.23857793f, -0.02721452f, 
    0.02210470f, -0.03387071f, 0.04535460f, 0.23906857f, 0.01286839f, 0.10268261f, 0.07270640f, 0.13958152f, 
    0.04047012f, 0.04739613f, 0.04969868f, 0.02165877f, -0.05772408f, 0.12884407f, 0.11100221f, 0.22735476f, 
    0.06917660f, -0.01151864f, -0.10553978f, -0.29301706f, 0.08656656f, 0.01969898f, 0.15678401f, -0.19992517f, 
    0.11191399f, 0.02738826f, -0.01287605f, 0.04748364f, 0.01008284f, 0.18236426f, 0.08432831f, -0.05022747f, 
    -0.01625817f, 0.00834347f, 0.09569298f, -0.11698260f, 0.31591955f, 0.07987051f, 0.17762873f, 0.01654482f, 
    0.10689679f, -0.07830924f, 0.20021228f, 0.02766119f, 0.06719150f, 0.08793604f, 0.08429286f, 0.02307394f, 
    -0.04218486f, -0.02846840f, -0.26166248f, -0.06549305f, -0.09855378f, -0.05183863f, 0.11597922f, -0.08352094f, 
    0.11553498f, 0.02738104f, -0.02478934f, 0.10767917f, -0.08921538f, 0.12839860f, -0.11611767f, 0.01261818f, 
    -0.01366824f, 0.24867116f, -0.16610669f, -0.07203402f, 0.11626055f, -0.19212222f, 0.01500870f, -0.08173503f, 
    0.08681969f, -0.13247794f, 0.00303487f, -0.20796584f, 0.34794229f, 0.11581165f, 0.06310774f, 0.06797992f, 
    -0.06544537f, -0.04731490f, -0.06404147f, -0.04656379f, 0.07908527f, 0.04673400f, 0.15427558f, -0.12629251f, 
    0.22871378f, 0.26563731f, -0.01707743f, 0.05628829f, 0.00364889f, 0.06635346f, 0.08078600f, -0.01527740f, 
    -0.15939608f, -0.00262851f, 0.34368294f, 0.04345062f, -0.10310363f, 0.11446434f, 0.18848322f, 0.14928041f, 
    0.08316226f, 0.07829533f, -0.00851653f, 0.11604946f, 0.12710550f, 0.16353457f, 0.20181896f, 0.18116133f, 
    -0.12694606f, -0.05782334f, -0.09650823f, -0.08036975f, -0.01422869f, -0.05646332f, -0.00793711f, -0.10995372f, 
    0.08074216f, -0.08536394f, -0.15651251f, 0.20698144f, 0.40096006f, 0.01993537f, 0.16393884f, 0.27297762f, 
    0.07521822f, -0.01360266f, -0.00326420f, 0.10821506f, 0.07169237f, 0.03445967f, -0.08590110f, -0.09546511f, 
    0.24803999f, -0.38796046f, 0.24514203f, 0.12281454f, 0.06131540f, 0.01687479f, 0.07187263f, 0.05666970f, 
    0.08955922f, -0.14730169f, -0.21141259f, -0.19251765f, 0.17372090f, 0.18458292f, -0.00442233f, 0.19792877f, 
    0.11639214f, 0.05145002f, 0.08923036f, -0.01883472f, -0.01677625f, -0.02346956f, 0.06364126f, 0.00581508f, 
    -0.76512927f, 0.14097440f, -0.10888721f, 0.13331737f, 0.05019327f, -0.07711346f, 0.09579013f, 0.03372687f, 
    -0.03236084f, -0.03768891f, -0.00360831f, -0.38219598f, 0.06751681f, -0.21225297f, -0.00525890f, 0.14033999f, 
    -0.03940409f, -0.00098278f, 0.08172319f, 0.08772165f, -0.15846336f, 0.08505507f, 0.12034811f, 0.21066019f, 
    0.07037862f, 0.07522231f, -0.08907624f, 0.07421563f, 0.04383212f, 0.13730846f, 0.02144584f, 0.10416996f, 
    0.07384491f, 0.15480040f, 0.25900826f, -0.01535876f, 0.04681385f, 0.07505254f, -0.00092359f, -0.01592310f, 
    0.09165319f, -0.04084077f, -0.06918389f, 0.11838990f, 0.08096065f, -0.16547024f, 0.29066953f, -0.11032768f, 
    -0.26383713f, -0.16486046f, -0.13163517f, 0.14672123f, -0.02935679f, 0.11341365f, 0.04142484f, 0.17742214f, 
    0.06107063f, 0.06965846f, 0.15520100f, 0.14509499f, -0.03234260f, -0.14288639f, 0.04977050f, -0.06789005f, 
    0.05014131f, -0.11777076f, 0.03125075f, 0.05995212f, 0.09335695f, -0.18109933f, -0.02694482f, 0.06044655f, 
    0.12383969f, 0.09158781f, 0.02497125f, 0.03967938f, -0.00212994f, 0.05942974f, -0.08696201f, 0.04738658f, 
    -0.03635710f, 0.08873840f, 0.18252191f, 0.09387942f, 0.24584827f, -0.04143269f, -0.12975715f, -0.14301576f, 
    0.04953493f, -0.04112725f, 0.04670729f, -0.11605274f, 0.04652467f, 0.15200979f, -0.10908846f, 0.08709366f, 
    0.11360329f, 0.10756422f, 0.09143756f, -0.10290869f, 0.06214624f, 0.04732661f, -0.23584706f, -0.16042493f, 
    0.02058350f, -0.02028233f, -0.03291666f, 0.12106685f, -0.12957087f, 0.25971618f, 0.23170476f, -0.00323978f, 
    0.11344761f, -0.03142032f, -0.13326807f, -0.01711538f, -0.02207234f, -0.09201363f, 0.08611245f, -0.16978638f, 
    0.28227609f, -0.31304476f, 0.20713453f, -0.10655522f, 0.04180440f, 0.19647655f, 0.03764553f, -0.02715675f, 
    -0.10971138f, 0.07100215f, -0.06982399f, 0.06351292f, -0.05823397f, 0.05642755f, 0.09187265f, -0.12774414f, 
    0.02271699f, -0.04309591f, -0.10556168f, -0.02418201f, -0.01734329f, -0.00023266f, 0.04328163f, 0.11668218f, 
    -0.25306180f, 0.00801112f, 0.15812169f, 0.01756099f, -0.04390673f, 0.02816144f, -0.03708327f, 0.01694714f, 
    0.04148685f, -0.06266218f, 0.14025865f, 0.00504177f, -0.24830778f, -0.19897664f, 0.09582102f, 0.07107040f, 
    -0.15633768f, 0.01825610f, 0.00915131f, -0.06054628f, 0.00651151f, 0.12105572f, 0.09359097f, 0.18768653f, 
    -0.23158041f, -0.16170862f, 0.01852620f, 0.08149794f, 0.06154246f, 0.01960884f, -0.10097882f, -0.02575580f, 
    -0.09303988f, -0.02186010f, 0.24529476f, 0.05398620f, 0.20644552f, -0.17151691f, 0.04018997f, 0.02776130f, 
    0.01631616f, 0.07493383f, 0.00095311f, 0.08925515f, 0.09640762f, 0.19090050f, 0.15402710f, 0.06679566f, 
    0.16562052f, -0.16813451f, 0.02940160f, 0.07322702f, -0.02539004f, 0.01490167f, 0.07645800f, 0.07772632f, 
    -0.06412054f, 0.15536915f, 0.07874592f, 0.25553638f, 0.24691182f, -0.21917817f, -0.13697532f, -0.14946304f, 
    -0.05918715f, -0.12144090f, -0.18354070f, -0.01155807f, -0.06664050f, -0.18143596f, -0.01568336f, -0.03291593f, 
    0.08289964f, 0.03005895f, 0.18442132f, -0.02390468f, 0.00953540f, 0.10860175f, -0.13060963f, 0.11290221f, 
    0.08073501f, 0.23470624f, 0.29503191f, 0.14781590f, 0.14850570f, 0.18720891f, 0.16432092f, -0.22277749f, 
    0.07336009f, 0.09483169f, -0.06431685f, -0.06465524f, 0.09229640f, 0.11494572f, 0.02369442f, -0.04903330f, 
    0.20788224f, 0.22624063f, -0.12678933f, 0.28380173f, 0.16189988f, -0.00492397f, 0.06079727f, 0.06981201f, 
    0.02114891f, 0.03322088f, -0.15568863f, 0.07367660f, 0.17043476f, -0.03687470f, 0.00811528f, 0.58774495f, 
    0.16135606f, -0.11878936f, 0.14825439f, 0.13331315f, 0.14646649f, 0.08754854f, 0.16854499f, -0.05824314f, 
    -0.10718900f, -0.09878118f, -0.02411538f, -0.05623932f, -0.11408059f, 0.09113933f, 0.06948614f, 0.04761103f, 
    0.03929787f, -0.04551499f, -0.09359393f, -0.09191708f, -0.29305568f, -0.08165938f, -0.14679722f, -0.06177551f, 
    0.04271408f, 0.08297122f, -0.04876634f, 0.11214791f, 0.08650612f, 0.05349584f, -0.03727305f, 0.08868322f, 
    -0.10849618f, 0.07640990f, 0.05213786f, 0.05511527f, 0.07326305f, -0.20294440f, 0.01375682f, -0.10456028f, 
    -0.00339501f, 0.01824098f, -0.01142336f, 0.01818720f, -0.02004093f, -0.15715751f, 0.13517782f, -0.10440534f, 
    0.18498661f, -0.01900001f, -0.03025391f, -0.12042322f, -0.01850463f, -0.00656061f, -0.02040982f, 0.03348713f, 
    0.00791617f, -0.19437511f, 0.02216566f, 0.08091753f, 0.07600583f, 0.18079241f, 0.07178263f, 0.11160455f, 
    0.01445947f, 0.08218918f, -0.15122776f, 0.07054965f, -0.24511574f, -0.02113991f, -0.15971901f, 0.16846713f, 
    0.11217757f, 0.06296719f, 0.01996673f, 0.04579869f, 0.07923185f, 0.11999954f, 0.10237847f, -0.09611136f, 
    -0.44075394f, 0.15868288f, 0.14554177f, 0.09216739f, -0.08517241f, -0.11585883f, -0.11521406f, 0.07402365f, 
    0.00748536f, -0.08480655f, 0.04943281f, 0.18024082f, -0.21767347f, -0.04000013f, 0.01725759f, 0.05038643f, 
    -0.07517751f, -0.02447099f, -0.19663534f, 0.00974756f, -0.01737765f, -0.03103251f, 0.05084502f, 0.15206075f, 
    0.01423956f, 0.12167273f, -0.28277209f, 0.36126679f, 0.09969983f, -0.08043668f, 0.15529495f, -0.05619511f, 
    0.07266171f, 0.23957324f, 0.12016955f, 0.14489830f, -0.47093698f, -0.32201114f, -0.02138817f, 0.06577802f, 
    -0.04874360f, 0.02288468f, 0.05239573f, -0.12880687f, 0.07192402f, 0.06112543f, -0.00331166f, 0.13831508f, 
    -0.23939852f, 0.16171792f, 0.01781034f, -0.29051945f, 0.07439881f, 0.07187440f, -0.12719569f, 0.01696379f, 
    0.02615463f, 0.01766552f, 0.05541321f, 0.01278075f, 0.31892911f, 0.01824134f, -0.22445175f, -0.15092435f, 
    -0.00419401f, 0.08833484f, -0.11178744f, 0.05688451f, 0.12964286f, -0.11531470f, 0.06796299f, -0.18882607f, 
    -0.00036491f, 0.02410153f, 0.02612921f, 0.05887904f, -0.03712931f, 0.03316003f, 0.15050440f, 0.07923802f, 
    0.01170299f, 0.06037140f, -0.15397376f, -0.21550839f, -0.13286091f, -0.09329171f, 0.00517034f, -0.00129405f, 
    0.08769933f, -0.06816098f, -0.12916729f, 0.21747229f, 0.00469072f, 0.22854060f, -0.06148466f, 0.07365142f, 
    -0.30779916f, -0.33647302f, 0.12788865f, 0.17342758f, -0.13291143f, 0.00923647f, 0.05178215f, -0.20013373f, 
    0.18512587f, -0.14185743f, -0.05148675f, -0.01346833f, 0.11369665f, -0.04071999f, 0.01411174f, -0.12502353f, 
    0.15178978f, -0.06128579f, -0.10597425f, -0.14203376f, -0.02173745f, -0.15658648f, 0.13528143f, 0.11449118f, 
    0.05151413f, 0.01253736f, -0.02110764f, 0.02964770f, 0.15826951f, -0.05045766f, 0.00067066f, 0.07481017f, 
    -0.02974875f, -0.08615804f, 0.05362019f, 0.29041359f, 0.09829028f, 0.10726256f, -0.05115480f, 0.01672558f, 
    -0.02558298f, 0.05489046f, -0.04672493f, 0.13463946f, -0.04051301f, 0.12928805f, 0.41452804f, 0.00380073f, 
    -0.01520245f, -0.27233830f, -0.02670779f, 0.03616156f, -0.06112267f, -0.01370929f, 0.08394752f, 0.00849058f, 
    0.16870067f, -0.02711216f, 0.01213017f, -0.18625185f, 0.16333036f, 0.06800522f, 0.08668084f, 0.23455521f, 
    -0.12465729f, 0.21381763f, 0.14323154f, 0.13502516f, 0.12687057f, 0.03511528f, -0.13026211f, 0.03864266f, 
    0.16631742f, -0.10972077f, 0.17722884f, -0.03979797f, 0.14747018f, -0.14740740f, -0.13451505f, 0.13172428f, 
    0.04761480f, 0.18334164f, -0.05710942f, 0.05409769f, 0.11396294f, -0.12288162f, 0.03861268f, 0.23368743f, 
    0.03565793f, -0.05994229f, 0.11064402f, 0.06907216f, -0.00974580f, -0.01397146f, 0.01628834f, 0.08285999f, 
    -0.03759109f, -0.00555626f, -0.02139210f, 0.01473955f, -0.03033289f, 0.00190619f, -0.01762719f, -0.02005404f, 
    -0.01436277f, 0.02309000f, -0.00965035f, 0.02938403f, -0.01468650f, -0.03634232f, 0.01100797f, 0.02576581f, 
    -0.02473550f, -0.04123143f, -0.01319077f, -0.03204324f, 0.00521145f, -0.02292529f, 0.00779886f, 0.01220869f, 
    0.03036876f, -0.02017878f, 0.00184041f, -0.03105611f, 0.00304616f, 0.02021345f, -0.00866551f, -0.03036231f, 
    0.01508123f, 0.02521730f, -0.01290885f, 0.01949958f, 0.00644455f, 0.02724549f, 0.00103521f, 0.01884226f, 
    -0.02322194f, -0.03735709f, -0.01978052f, 0.01362814f, -0.03374597f, 0.01767687f, 0.00491991f, -0.02858515f, 
    -0.01937803f, 0.03427057f, 0.02343353f, -0.00680553f, 0.00083998f, -0.01763266f, 0.00458682f, -0.02950342f, 
    -0.01474889f, -0.02870844f, -0.03709624f, -0.01790600f, -0.01072556f, 0.03006016f, -0.00098891f, -0.00653392f, 
    -0.01450104f, -0.00952886f, 0.02678414f, -0.01539287f, -0.03347264f, 0.02072808f, 0.01643808f, 0.02254030f, 
    -0.02144681f, -0.04186661f, 0.01911782f, -0.01941562f, 0.01143997f, 0.01392087f, -0.01340542f, 0.01375935f, 
    0.01694629f, -0.01088471f, -0.00131130f, -0.01431639f, -0.00850270f, -0.03194306f, -0.01876986f, -0.02265707f, 
    0.02521406f, 0.03273908f, -0.00349894f, -0.02867826f, 0.00574974f, 0.03106993f, -0.02362375f, 0.00028805f, 
    -0.00866739f, 0.00050412f, 0.01727509f, 0.02863063f, -0.02960040f, -0.01229923f, -0.02741149f, -0.03507977f, 
    -0.03172312f, -0.02837149f, -0.00996096f, -0.03555390f, 0.00482747f, -0.02787289f, -0.01612458f, 0.02846657f, 
    -0.02520647f, -0.03065622f, -0.01080267f, 0.00600407f, -0.03931818f, 0.01488531f, -0.01079455f, -0.02934360f, 
    0.00604736f, -0.03132769f, -0.02239661f, -0.00468243f, -0.02700038f, -0.00183790f, -0.03428147f, -0.03275519f, 
    -0.04322817f, 0.00249152f, -0.03727641f, -0.04138702f, 0.00276808f, -0.01355607f, -0.01060000f, 0.03640707f, 
    -0.00660029f, 0.01760972f, 0.00309713f, 0.02321177f, -0.01906781f, -0.01423114f, -0.03196780f, -0.03597939f, 
    0.02138546f, -0.00121283f, 0.04110382f, -0.03018149f, -0.02204725f, 0.02242782f, -0.01975618f, -0.03248176f, 
    -0.03765764f, -0.02906945f, 0.01503487f, -0.00449044f, -0.01006012f, 0.02637541f, 0.02573529f, 0.03042600f, 
    -0.01108396f, 0.03054528f, 0.01616675f, -0.01176051f, -0.03357950f, -0.01244477f, -0.03685037f, 0.01017093f, 
    0.03223725f, -0.00064810f, -0.03323857f, -0.01337191f, 0.02175692f, -0.02616423f, -0.03295903f, -0.02149868f, 
    0.02593713f, 0.02370321f, -0.00658880f, -0.01548165f, -0.00414145f, -0.03763321f, -0.03772207f, -0.03599774f, 
    -0.02854653f, -0.00404315f, -0.00759298f, 0.00228276f, -0.01175289f, -0.01370444f, -0.02092170f, -0.01751247f, 
    0.00157818f, -0.03398402f, -0.00120963f, -0.00779026f, 0.03951982f, -0.02183083f, -0.01278271f, 0.01329240f, 
    0.00155365f, -0.00366783f, -0.03576873f, 0.03935874f, -0.00396930f, 0.02014515f, -0.01920467f, -0.01264907f, 
    0.00961466f, -0.04272630f, -0.02374867f, 0.04385714f, 0.02789876f, -0.00525002f, 0.01274914f, -0.00122594f, 
    0.01888585f, 0.02066704f, 0.02185597f, 0.02420819f, 0.01749523f, -0.00148268f, -0.03753306f, -0.02293389f, 
    -0.03065161f, 0.01986282f, -0.02867494f, -0.00110051f, 0.00770965f, -0.00436405f, -0.00886364f, -0.02077289f, 
    -0.01159219f, 0.02244585f, 0.02262405f, -0.02729806f, 0.01008255f, 0.00943094f, -0.00220032f, 0.01594125f, 
    -0.04032693f, -0.03708177f, -0.00497235f, 0.02124899f, -0.01237274f, 0.02768900f, -0.03338021f, -0.02451170f, 
    0.02399853f, 0.01123952f, -0.03544907f, -0.04392769f, -0.00024200f, -0.03452954f, -0.03351799f, -0.01521808f, 
    -0.02141126f, -0.02857047f, -0.00463765f, 0.01400209f, -0.03624806f, -0.00782429f, 0.03704004f, -0.02731178f, 
    -0.02707498f, -0.02003985f, 0.02471549f, 0.02847051f, -0.00193988f, 0.02371813f, 0.02727568f, 0.00216973f, 
    -0.02250917f, 0.02790572f, -0.03212235f, 0.02748831f, 0.03007539f, -0.00536456f, 0.02990801f, 0.01598864f, 
    0.00087288f, 0.00229851f, -0.02231659f, 0.00426090f, 0.02866994f, -0.01901961f, 0.01640058f, -0.00070395f, 
    0.01344870f, 0.01135428f, -0.01853603f, 0.00915124f, 0.02094902f, 0.00605927f, -0.02241931f, 0.02272297f, 
    0.01978890f, -0.01358460f, -0.03214739f, -0.02728040f, -0.00012756f, 0.00435827f, -0.01624038f, -0.03447836f, 
    -0.02985904f, 0.02292703f, -0.02002202f, -0.02010370f, 0.02231631f, -0.00047614f, -0.03523578f, -0.01355949f, 
    0.03556092f, 0.02565696f, -0.01022277f, 0.01086533f, -0.00981615f, 0.02259007f, -0.02636842f, -0.03889765f, 
    -0.01153472f, 0.03400851f, 0.01372312f, 0.00627514f, 0.03374099f, 0.03272454f, 0.01640403f, 0.00872335f, 
    0.01730639f, -0.02986915f, -0.01793071f, 0.02460678f, -0.03188707f, -0.00774100f, -0.01633592f, -0.03210530f, 
    0.01527684f, -0.00577942f, 0.02955589f, -0.02666204f, 0.02515575f, 0.02655951f, -0.02846909f, -0.01215941f, 
    0.02226101f, 0.00425759f, -0.01528188f, -0.00968808f, 0.01123757f, -0.01074115f, -0.03043919f, -0.01568268f, 
    0.02277457f, 0.01452186f, 0.00641548f, -0.02224344f, -0.03782639f, -0.02245698f, -0.02866800f, 0.00938285f, 
    0.00149601f, -0.01510100f, -0.00105502f, -0.03830074f, -0.03639920f, -0.00037738f, -0.00162832f, -0.00769194f, 
    -0.00526084f, 0.02177234f, 0.02853298f, -0.00733999f, -0.03593555f, -0.03719774f, 0.02304846f, 0.00811118f, 
    -0.01042574f, -0.02879012f, -0.01867078f, 0.02544460f, -0.03242054f, -0.01683143f, 0.01294313f, 0.01339465f, 
    0.00990731f, 0.02118495f, 0.01876183f, -0.00588269f, 0.02841015f, -0.01389923f, -0.03618700f, 0.02905995f, 
    0.02257326f, -0.00921901f, -0.02371638f, -0.00264748f, 0.00400852f, -0.03210747f, -0.01611894f, -0.00353371f, 
    -0.01956760f, -0.02255700f, 0.02577207f, -0.03405804f, -0.02529887f, 0.02741877f, 0.00318600f, -0.02643225f, 
    0.03203546f, -0.02398728f, 0.02866694f, 0.03033430f, 0.01868953f, -0.00222893f, 0.01212614f, -0.01990672f, 
    -0.01993717f, 0.02642358f, -0.02051680f, 0.01724637f, -0.02088961f, 0.01135897f, 0.01659358f, 0.01891935f, 
    -0.02911982f, 0.03349943f, -0.01161234f, -0.00313427f, -0.01922785f, 0.00877161f, -0.01515744f, -0.00738526f, 
    -0.02674932f, -0.01312341f, 0.02875694f, 0.01631725f, 0.01925444f, -0.02957389f, 0.01778014f, -0.00113102f, 
    -0.02978477f, 0.01361973f, -0.02565412f, 0.01699263f, -0.00102648f, -0.00207216f, -0.02537369f, -0.00684894f, 
    -0.00217237f, -0.00978118f, 0.01686108f, -0.00501912f, 0.01137868f, -0.01158938f, 0.01136902f, 0.01572050f, 
    0.00192591f, -0.01553190f, -0.04039920f, -0.01126066f, 0.01105881f, -0.01739014f, -0.03763963f, -0.02240502f, 
    0.01284675f, 0.00364879f, -0.02381879f, 0.01589857f, -0.02945044f, 0.02978258f, -0.00159547f, 0.00510159f, 
    -0.00409803f, -0.00111838f, -0.01627647f, -0.04028787f, -0.02545330f, -0.02410565f, 0.01957632f, 0.01621619f, 
    0.01432900f, 0.01406321f, -0.01239237f, -0.00902695f, 0.01752168f, 0.01993863f, 0.00329688f, 0.00693074f, 
    0.00916684f, -0.00145497f, 0.03110372f, -0.02937931f, 0.02278461f, 0.02042375f, -0.01636112f, 0.02727842f, 
    -0.03862738f, -0.01734145f, 0.01902214f, 0.00786923f, -0.01288042f, 0.01746059f, 0.03302461f, 0.00871697f, 
    -0.00026257f, 0.01326890f, -0.00648603f, 0.01859777f, -0.02930513f, 0.02000779f, 0.02753212f, -0.01122995f, 
    0.00538122f, -0.00508423f, -0.03324056f, 0.02280486f, 0.02197848f, 0.00619339f, -0.00205070f, -0.03513186f, 
    -0.02999585f, -0.00732063f, -0.02863399f, 0.00496909f, -0.01190718f, 0.03418890f, 0.01369732f, -0.00383618f, 
    0.01233490f, -0.03062498f, -0.02985461f, 0.00667895f, 0.01610217f, -0.00667412f, -0.02527996f, -0.00507113f, 
    -0.02690941f, -0.00445329f, 0.02000393f, -0.03946422f, 0.00378118f, -0.03681067f, -0.01790033f, 0.02703965f, 
    -0.01362644f, -0.01351956f, -0.01645251f, -0.00729044f, -0.04516616f, 0.02669683f, -0.04238371f, 0.01455131f, 
    -0.03373578f, 0.00173114f, -0.01763732f, -0.01677396f, -0.02411438f, -0.03276798f, -0.03022041f, -0.02928523f, 
    0.01979061f, -0.00936000f, -0.02982133f, -0.00380119f, 0.03076235f, 0.00036141f, 0.01331772f, 0.02555621f, 
    0.02783431f, 0.00025993f, 0.00426720f, 0.01593807f, 0.01889000f, -0.02879554f, 0.01242633f, 0.02538276f, 
    -0.03242846f, -0.01468569f, -0.00957122f, -0.00264431f, 0.00886412f, -0.03413328f, 0.00835708f, -0.00433905f, 
    -0.01192882f, -0.01514434f, -0.00193937f, 0.00517286f, -0.00042774f, -0.01626726f, -0.02011369f, -0.03275865f, 
    0.02731070f, -0.03073090f, 0.01404992f, 0.00291978f, 0.00092559f, -0.02950495f, -0.01001412f, -0.03262768f, 
    0.02568076f, -0.01735419f, -0.03243602f, -0.00596331f, 0.01521118f, -0.00005719f, -0.02697615f, -0.02767765f, 
    -0.00163935f, -0.02102573f, 0.00648646f, 0.03257180f, -0.00969244f, -0.01365984f, -0.00624098f, -0.03142312f, 
    0.00322891f, 0.02325938f, -0.00148920f, -0.01398026f, -0.03878708f, -0.01817132f, 0.00696159f, -0.02948933f, 
    0.02174325f, 0.01957924f, 0.02869027f, -0.02237627f, -0.03828032f, -0.03548873f, 0.00754352f, -0.03561050f, 
    0.03580293f, -0.01608562f, 0.02518482f, 0.03990141f, -0.00963996f, 0.02037191f, 0.00092258f, 0.00115819f, 
    0.01950810f, -0.01726715f, 0.00834067f, 0.01092721f, -0.01688223f, 0.00211230f, 0.00812248f, -0.02821667f, 
    -0.00053316f, -0.00656502f, -0.01290336f, -0.02586022f, -0.02636388f, 0.01122608f, 0.02095850f, 0.00224599f, 
    -0.03571203f, -0.00083775f, -0.02197030f, 0.01372829f, -0.03233144f, -0.03287921f, -0.03446100f, 0.02390755f, 
    0.03528392f, -0.03865154f, 0.02681622f, -0.00148150f, -0.03909214f, 0.03896912f, -0.03080138f, -0.00772160f, 
    -0.04417565f, -0.01442400f, -0.02035155f, 0.02474679f, -0.00118265f, -0.03053218f, 0.01550773f, -0.03603154f, 
    0.04096708f, 0.02617730f, -0.00267212f, -0.00026403f, -0.02519999f, 0.00060549f, 0.02531554f, -0.00019809f, 
    -0.02105477f, -0.01159320f, -0.00154909f, 0.01891133f, 0.02253215f, -0.00310488f, 0.03199983f, -0.01594197f, 
    -0.00437008f, -0.01455292f, -0.00965716f, -0.02089303f, -0.01385671f, 0.01177873f, -0.03879612f, 0.01722573f, 
    0.00793461f, -0.00791455f, -0.01057435f, -0.00918222f, -0.00651260f, 0.00808494f, -0.00192643f, -0.03078533f, 
    0.02198176f, -0.01655328f, -0.00949583f, 0.01552957f, -0.01687560f, 0.02550450f, 0.03424351f, -0.00046555f, 
    -0.00705308f, -0.01314979f, 0.01061677f, -0.02983307f, 0.00877813f, -0.01717984f, 0.00982502f, -0.00436619f, 
    0.01278232f, -0.00038003f, 0.00258799f, -0.02156263f, -0.03911915f, -0.02630489f, -0.03958648f, -0.04037483f, 
    0.01597814f, 0.02184381f, -0.02413163f, -0.03074791f, -0.00461365f, -0.01853669f, 0.00138872f, 0.00811672f, 
    0.02180066f, -0.02079247f, -0.02868244f, 0.01540490f, 0.02477704f, -0.03375571f, 0.02695227f, 0.01984688f, 
    0.02420881f, 0.03826499f, -0.02532318f, -0.00783600f, -0.01714718f, -0.02531153f, 0.01901701f, 0.00031409f, 
    0.00323199f, 0.02082887f, -0.00732417f, -0.02148192f, 0.01353581f, 0.02308403f, 0.00124311f, -0.01799194f, 
    -0.00927882f, 0.00353582f, -0.02257811f, 0.01553664f, -0.01000859f, 0.01697856f, 0.01619217f, 0.01480987f, 
    -0.01276670f, 0.01768463f, 0.02073892f, 0.02069723f, 0.01008240f, -0.00765357f, -0.03898854f, -0.00609112f, 
    -0.00145336f, 0.00038476f, 0.00855507f, 0.00245671f, 0.02717789f, 0.03276103f, 0.01895934f, 0.02178496f, 
    -0.03549789f, -0.02666233f, -0.03219120f, -0.04438410f, -0.02605506f, 0.02171369f, -0.03241637f, -0.02239338f, 
    0.01244090f, -0.03232219f, 0.00869058f, 0.01967817f, -0.02104635f, -0.04300231f, -0.02480684f, 0.02743338f, 
    0.02815531f, 0.01762089f, -0.03261724f, -0.01139515f, -0.02765700f, 0.01019984f, -0.04350756f, -0.03445616f, 
    -0.01824571f, -0.00978456f, -0.03760565f, -0.01160573f, -0.04390882f, -0.00666909f, -0.01894090f, -0.03820750f, 
    0.00193501f, 0.01175296f, -0.00274254f, -0.01297321f, 0.02192265f, 0.00947548f, 0.02563152f, -0.01084636f, 
    -0.04369309f, -0.01463821f, 0.00076615f, 0.01354426f, -0.03417747f, 0.00674276f, -0.02095284f, 0.00069355f, 
    -0.02635437f, -0.00883792f, 0.02364892f, -0.03569949f, 0.02113902f, -0.00228317f, 0.02864712f, -0.02966540f, 
    0.01704093f, 0.03344380f, -0.01549874f, -0.04195279f, 0.01031076f, -0.01358930f, -0.01095503f, -0.00726782f, 
    -0.00916134f, -0.00478525f, -0.01198830f, -0.02849243f, -0.01180283f, 0.01035962f, -0.02723813f, -0.03385466f, 
    -0.02301527f, 0.00125726f, 0.02482419f, -0.01431897f, 0.01578434f, -0.00101779f, 0.02800506f, -0.03811292f, 
    0.00554283f, -0.00048881f, -0.00914041f, 0.01866940f, 0.01634114f, -0.02381661f, 0.01970092f, 0.00118528f, 
    0.02225254f, 0.00516769f, 0.00650960f, 0.02919480f, -0.00695170f, -0.02816631f, 0.02261661f, -0.02437248f, 
    -0.00416266f, -0.04141923f, 0.02244898f, 0.01057265f, 0.02660532f, -0.03631383f, 0.02497167f, -0.00897243f, 
    -0.02164399f, -0.01561657f, -0.00850441f, 0.03628639f, -0.00827400f, 0.00455969f, -0.00015003f, 0.00527756f, 
    -0.01867059f, -0.00053077f, 0.02668164f, -0.02652589f, -0.00612406f, -0.02161271f, -0.02333772f, -0.03445945f, 
    -0.04274296f, -0.01900729f, -0.01919973f, 0.00854745f, 0.01153264f, -0.03997409f, -0.04134222f, 0.02826823f, 
    0.02940241f, 0.02022314f, -0.00881045f, -0.01939957f, 0.02927814f, -0.01542209f, 0.00699158f, -0.02761203f, 
    -0.02099655f, 0.01064013f, 0.01381891f, -0.02355785f, -0.03138351f, -0.02582526f, 0.02417930f, -0.01989621f, 
    0.01724623f, -0.00311310f, -0.02079455f, -0.00120279f, -0.01301434f, 0.02783035f, -0.01022787f, -0.01114479f, 
    -0.00418705f, -0.00239422f, -0.03039606f, -0.03736112f, -0.02471651f, -0.01629071f, -0.04027696f, 0.01906421f, 
    -0.03029719f, 0.02099488f, 0.01271981f, -0.01431566f, 0.01860404f, 0.01518793f, -0.03792541f, 0.00199999f, 
    -0.01350937f, 0.01037127f, -0.02030632f, -0.03398087f, -0.00434209f, 0.02350593f, 0.01696087f, -0.00659906f, 
    -0.00614096f, -0.01499088f, -0.03005702f, -0.01063754f, -0.01830698f, 0.02403680f, 0.00008081f, -0.04142193f, 
    -0.02059063f, -0.03148272f, 0.03784546f, -0.00635649f, 0.00364009f, -0.03526763f, -0.02959364f, 0.01807671f, 
    -0.00299569f, -0.03696331f, -0.02077596f, -0.03060447f, -0.00283008f, 0.00179179f, 0.00519553f, -0.00272584f, 
    -0.02938261f, -0.01813903f, 0.00920486f, -0.01176927f, -0.01427707f, 0.01080658f, -0.03659112f, -0.01258064f, 
    -0.03474505f, -0.02646529f, -0.02371093f, -0.02545187f, -0.02416029f, -0.02181989f, -0.03430110f, -0.00974199f, 
    -0.01474085f, -0.01254370f, -0.01860829f, -0.02647302f, 0.02771745f, 0.02769020f, 0.02392942f, -0.02414478f, 
    -0.03838952f, 0.01561736f, 0.01153357f, -0.02654628f, 0.00772856f, -0.01991562f, -0.04349476f, -0.01079714f, 
    0.01944914f, 0.02341283f, -0.00668745f, -0.03039721f, -0.00356410f, 0.00440344f, 0.01617225f, 0.01509620f, 
    -0.01395537f, -0.00580887f, -0.01329565f, -0.02961360f, 0.02661782f, -0.01817240f, 0.02261264f, -0.00508885f, 
    -0.01239337f, 0.01341076f, -0.01820879f, 0.02487682f, -0.04223481f, -0.03273283f, -0.01030573f, -0.04846819f, 
    -0.02692126f, 0.00162765f, -0.03489030f, -0.01845375f, 0.00728644f, -0.02694804f, -0.04006564f, -0.04392221f, 
    0.00549512f, -0.00265616f, -0.03347043f, 0.02218761f, 0.00263218f, -0.01219742f, 0.01968263f, 0.01527262f, 
    -0.02413780f, -0.03933433f, -0.01404103f, -0.00869699f, -0.02644599f, 0.02038833f, 0.00198049f, -0.02279828f, 
    0.01751715f, 0.02212537f, -0.00250649f, 0.03004827f, -0.00243534f, -0.02876877f, -0.01123766f, -0.01362369f, 
    -0.02674542f, 0.00567200f, -0.01161359f, -0.03808634f, 0.02421533f, 0.02159872f, -0.00733299f, 0.02741360f, 
    0.01457692f, 0.00166021f, -0.03003752f, -0.02617172f, 0.03263912f, 0.00194556f, 0.02717470f, 0.01715688f, 
    0.00850914f, -0.00312979f, 0.03093462f, -0.00589794f, 0.00805038f, 0.02391127f, 0.01047654f, -0.04119738f, 
    0.03068723f, -0.01376286f, 0.00086296f, 0.03492124f, -0.00897923f, -0.03014659f, -0.01207792f, -0.00038715f, 
    -0.01873584f, 0.00439884f, -0.01866304f, -0.02186223f, -0.03496464f, -0.03502644f, 0.03555148f, -0.02587359f, 
    0.02679925f, -0.04172387f, -0.04365315f, 0.02077506f, 0.02219432f, -0.02688692f, -0.00343779f, -0.02900321f, 
    -0.02795773f, -0.02306759f, 0.02166097f, 0.00686550f, -0.03146598f, -0.03617769f, -0.04025312f, -0.00998177f, 
    0.01849557f, -0.03131508f, -0.00188121f, -0.01246157f, 0.00752484f, -0.02069091f, 0.00764054f, -0.01648987f, 
    0.00747172f, -0.02786011f, 0.02285665f, -0.01450167f, 0.00457131f, -0.01553430f, -0.01598664f, -0.01032277f, 
    -0.02809065f, 0.03297703f, -0.02064932f, 0.00504387f, -0.01449529f, -0.04597292f, -0.00091117f, -0.03902182f, 
    0.00374843f, -0.03892761f, 0.02102000f, -0.00353042f, -0.00596531f, 0.01995459f, 0.00291879f, -0.01727561f, 
    0.02420741f, 0.00349410f, 0.02463428f, -0.02086753f, 0.01763648f, 0.00969031f, 0.02936480f, -0.00315809f, 
    -0.00723413f, -0.00592541f, 0.02376513f, -0.03519202f, 0.01748580f, 0.01159004f, 0.02009166f, 0.03282296f, 
    -0.02965225f, -0.02069368f, -0.00030743f, 0.00675510f, -0.00840494f, -0.02313984f, -0.00794859f, -0.03731320f, 
    -0.02326724f, 0.01922573f, -0.01833534f, 0.01715492f, -0.00463502f, -0.00237481f, 0.01639419f, -0.01280191f, 
    0.02623275f, -0.02789715f, -0.02147609f, -0.01967669f, 0.01167217f, 0.01265151f, -0.01575659f, -0.00666761f, 
    0.00921907f, -0.02867552f, -0.00320337f, 0.02428365f, -0.00563405f, -0.03475661f, -0.03220564f, -0.03094637f, 
    -0.03937500f, -0.03001614f, 0.01552151f, 0.00655684f, -0.03137897f, -0.00802864f, -0.00593694f, -0.00229499f, 
    -0.00151990f, -0.01607988f, -0.03724160f, -0.02960343f, -0.03763584f, 0.03264783f, -0.01504428f, 0.02379969f, 
    -0.00304214f, 0.02509376f, 0.02858688f, -0.03080243f, -0.03856276f, -0.01242104f, 0.02108757f, -0.01179654f, 
    -0.03994588f, 0.00893155f, 0.01150569f, -0.00861239f, 0.01267390f, -0.02822164f, 0.00790616f, -0.01807362f, 
    0.00583911f, -0.02774684f, -0.03820988f, 0.01189670f, 0.00991790f, 0.02608652f, -0.00561289f, 0.01141222f, 
    -0.02374520f, 0.00497239f, 0.00347010f, -0.03413691f, 0.00446726f, 0.00978468f, 0.02564459f, -0.00006118f, 
    0.02501475f, -0.00315418f, 0.01491843f, 0.01668377f, -0.01012485f, -0.03275688f, -0.00350429f, 0.01241354f, 
    0.00618061f, -0.01092746f, -0.04365762f, -0.02875730f, 0.03411639f, -0.03028594f, 0.01326077f, -0.04383671f, 
    -0.01473914f, -0.01022724f, 0.02253633f, 0.00211068f, 0.02612070f, 0.01119585f, 0.01584521f, -0.00492063f, 
    -0.00257436f, 0.00290660f, -0.03220101f, 0.01764691f, -0.00813925f, 0.00969400f, 0.00759652f, 0.01265629f, 
    -0.04340879f, -0.01421105f, -0.03277114f, 0.00238579f, -0.03685215f, -0.01032685f, -0.03499056f, 0.01949640f, 
    -0.02271444f, -0.01220102f, 0.02536315f, -0.00846561f, -0.02800632f, 0.02962063f, -0.02066257f, 0.01684233f, 
    0.01784461f, 0.03498052f, -0.02495579f, 0.00046083f, -0.03209703f, 0.02588851f, 0.01411922f, -0.03442476f, 
    -0.02313668f, -0.00517898f, -0.02676769f, -0.03596404f, -0.00253217f, -0.02572062f, 0.02732023f, -0.03000838f, 
    -0.00305737f, -0.02553348f, -0.03992465f, -0.00697077f, 0.03609677f, -0.03497434f, -0.01138136f, 0.01090373f, 
    0.00119410f, -0.00352876f, 0.02379508f, -0.03907649f, -0.02682934f, -0.03047089f, 0.01007560f, 0.00010036f, 
    0.03635602f, 0.01681325f, -0.01042841f, -0.00405946f, -0.00385116f, 0.00887546f, -0.00017886f, -0.01893759f, 
    -0.04135773f, 0.03249999f, 0.00723739f, -0.03263965f, 0.00184434f, -0.01717139f, -0.02579135f, -0.01755937f, 
    0.01786215f, 0.02021320f, -0.02373053f, -0.02277604f, -0.03216800f, 0.00826808f, -0.01015598f, -0.00613565f, 
    -0.01764368f, 0.02616111f, -0.03359433f, 0.01483123f, 0.00818654f, -0.02561683f, -0.03319815f, 0.01496182f, 
    -0.03693704f, 0.02550690f, -0.01106929f, -0.01298095f, 0.01697510f, -0.03377232f, -0.00951801f, -0.01159789f, 
    -0.02836247f, 0.02201086f, 0.00812669f, 0.02168348f, -0.03433529f, -0.01220359f, -0.01442420f, -0.01724285f, 
    -0.03172051f, 0.01781258f, 0.00836472f, -0.01184092f, 0.03069929f, -0.00749067f, -0.04085950f, 0.00836147f, 
    -0.01138124f, -0.03361940f, -0.03386468f, 0.00899848f, 0.00848318f, -0.01615983f, -0.01688624f, -0.01019293f, 
    0.02656495f, 0.00490489f, 0.01007056f, -0.02049349f, 0.02304976f, -0.02226471f, 0.00960919f, -0.00808722f, 
    -0.03043048f, -0.02300630f, -0.00462681f, -0.03043604f, 0.02129183f, -0.00608863f, 0.01045383f, -0.02826196f, 
    -0.00495255f, 0.02792265f, 0.02404764f, -0.03766879f, -0.03254921f, 0.00166806f, -0.01978685f, 0.03211177f, 
    0.01602296f, -0.00909709f, 0.01945277f, 0.00933094f, 0.02499986f, -0.01571172f, 0.00191440f, 0.00009573f, 
    0.01773940f, -0.02923629f, 0.03132302f, 0.02863361f, 0.01843661f, 0.00764236f, 0.02600322f, 0.00531758f, 
    -0.02870111f, -0.04517207f, -0.03483706f, -0.00042825f, 0.01794809f, 0.02769445f, 0.00631530f, 0.01133894f, 
    -0.01620028f, 0.00877325f, 0.01425028f, 0.01567714f, -0.00752793f, -0.00593748f, -0.02803149f, -0.04760239f, 
    0.02134809f, -0.03041643f, 0.00371226f, 0.00253233f, -0.02796048f, -0.00744579f, 0.00405834f, 0.01626855f, 
    0.00063391f, 0.00881539f, 0.00139881f, -0.02524329f, -0.03429773f, 0.00065313f, 0.02507125f, -0.02564473f, 
    0.01845346f, 0.01110678f, 0.02766914f, 0.01850723f, 0.02193047f, 0.00882646f, -0.00738961f, -0.01169615f, 
    0.00535125f, -0.03314747f, -0.03099866f, -0.02388064f, -0.04107534f, 0.01148726f, -0.01738901f, 0.00293846f, 
    -0.02163332f, 0.01665071f, 0.03564666f, -0.03193346f, 0.02107794f, -0.01142972f, -0.02676132f, -0.03622593f, 
    0.01091640f, 0.01512143f, -0.01381536f, -0.02668276f, -0.03462092f, 0.01391765f, -0.00557523f, 0.03454021f, 
    0.01870698f, 0.00953595f, -0.01954707f, -0.02192571f, -0.00494475f, 0.02046229f, -0.00890765f, -0.00670991f, 
    -0.01309108f, 0.02905208f, -0.02486295f, -0.03407870f, -0.02916596f, 0.00765879f, 0.00976857f, 0.00103604f, 
    -0.01815094f, 0.02198580f, 0.02774580f, 0.00365461f, -0.04131462f, -0.02194171f, 0.00020431f, 0.01008646f, 
    0.02132785f, 0.02264423f, 0.02310024f, -0.02546832f, 0.00478235f, 0.01410194f, -0.02118153f, -0.00842663f, 
    0.00505258f, -0.00288286f, -0.03000272f, 0.01520710f, -0.03199316f, -0.00366421f, 0.02039646f, -0.01745260f, 
    -0.00624127f, -0.01557503f, -0.04177381f, 0.01348177f, 0.02420901f, 0.02025246f, -0.03615930f, -0.00228577f, 
    0.00708231f, -0.03906716f, -0.03246012f, -0.01577481f, 0.02652343f, -0.00515145f, -0.02745086f, 0.00141114f, 
    -0.00839629f, -0.02175546f, -0.03421175f, 0.00604545f, 0.00071048f, 0.02828374f, 0.01754159f, -0.03867265f, 
    -0.00307260f, 0.02645589f, -0.02294440f, 0.01658040f, 0.00924878f, -0.00701088f, -0.03515463f, 0.01359902f, 
    -0.00136385f, -0.02066345f, 0.01702263f, 0.00497557f, -0.04049525f, -0.03685156f, -0.03994590f, -0.03349413f, 
    -0.00019985f, -0.02586065f, -0.03038465f, -0.01246251f, -0.01933246f, 0.02764831f, -0.01089174f, 0.00691205f, 
    0.00234490f, -0.01495409f, -0.01744868f, 0.01021208f, 0.00076758f, 0.01842673f, -0.03073675f, -0.00981558f, 
    0.01795416f, 0.01866091f, -0.00915334f, -0.02219044f, -0.02218690f, -0.00987761f, 0.02019639f, -0.03868090f, 
    0.02923248f, 0.00130845f, -0.00223001f, -0.03231128f, -0.04126360f, 0.01557777f, 0.01745938f, 0.01809840f, 
    -0.03087918f, -0.01322613f, -0.02253301f, -0.02022688f, 0.01154345f, 0.01651619f, -0.02983599f, -0.00258315f, 
    0.02285368f, 0.02165454f, -0.02829734f, -0.00930858f, -0.02984473f, 0.00627917f, 0.02662644f, -0.00206377f, 
    0.01018649f, -0.02355017f, 0.00887868f, -0.03115707f, -0.01373203f, -0.01380133f, 0.01377130f, -0.03505830f, 
    -0.01783614f, 0.00943143f, -0.03655190f, 0.02093801f, -0.01710372f, -0.00110501f, -0.04079280f, -0.02033979f, 
    -0.02574120f, -0.01036602f, -0.02898952f, -0.00364367f, 0.01650779f, 0.01006427f, -0.00249265f, 0.00270157f, 
    -0.01388619f, -0.00354561f, -0.00888246f, 0.01112341f, -0.02661826f, 0.00269681f, -0.00934107f, -0.02067584f, 
    0.01949225f, -0.00876655f, -0.02474336f, -0.03663526f, 0.00619279f, 0.00185986f, 0.01097200f, 0.02790053f, 
    0.00288539f, -0.00916918f, 0.02062465f, -0.03983396f, 0.01598302f, -0.03111691f, 0.01074042f, 0.01679494f, 
    0.02178186f, -0.00482056f, 0.00081539f, -0.00477948f, -0.01288787f, -0.02305683f, -0.02902259f, -0.00552156f, 
    0.00539327f, -0.02095306f, 0.00557569f, -0.03793111f, -0.02817560f, -0.02555746f, 0.00088612f, 0.01438397f, 
    -0.01488024f, 0.02889346f, 0.01600877f, -0.01628093f, 0.02002048f, -0.01202805f, -0.01595160f, 0.02754318f, 
    0.01764571f, 0.01112316f, -0.00757706f, -0.02826475f, -0.03362932f, 0.02425938f, -0.01957167f, 0.01255161f, 
    0.00075205f, -0.00872436f, 0.00534033f, -0.00402387f, -0.03978329f, 0.02118949f, 0.01842547f, -0.04175662f, 
    0.01780639f, -0.02927762f, -0.03624142f, -0.02421494f, 0.02394854f, 0.02314982f, -0.03396663f, 0.00774196f, 
    -0.00599878f, -0.00405700f, -0.02133919f, -0.02600407f, -0.04027460f, 0.01123259f, -0.00646197f, -0.00615355f, 
    -0.01134062f, 0.00529570f, -0.01383645f, 0.00410637f, -0.01409167f, 0.01373542f, 0.01414929f, -0.02601473f, 
    -0.01425176f, -0.04039106f, 0.01975622f, -0.01337087f, -0.04168086f, 0.02991564f, 0.02648447f, 0.02976111f, 
    -0.01129865f, 0.02792118f, -0.01202001f, -0.03354863f, -0.02362479f, -0.04035962f, 0.01029516f, -0.03385875f, 
    -0.02693067f, -0.04019998f, 0.00118723f, -0.00483149f, -0.00880033f, -0.00469017f, -0.03696129f, -0.03444588f, 
    -0.03688901f, 0.00727732f, -0.01128441f, -0.03988795f, -0.03936326f, -0.03774128f, 0.02348294f, -0.03686161f, 
    -0.00968324f, -0.04187940f, -0.01650839f, -0.00542867f, -0.02957425f, -0.02900611f, -0.02427523f, -0.01028272f, 
    -0.03106064f, 0.01645403f, -0.01356359f, 0.02033661f, -0.03949732f, 0.01922965f, -0.01842833f, -0.02544018f, 
    0.01463597f, -0.03713292f, -0.01873757f, 0.00443325f, -0.02824421f, -0.00495971f, -0.03992580f, -0.03381214f, 
    0.02379095f, 0.01974240f, -0.00518793f, -0.03309884f, 0.00491413f, 0.01472724f, -0.03852639f, 0.01527517f, 
    0.00504071f, 0.02082572f, -0.01003561f, -0.01382485f, 0.00838137f, 0.02315485f, -0.02927658f, -0.04076391f, 
    0.02336725f, -0.01568222f, -0.00221824f, 0.01920074f, -0.00805293f, -0.02420814f, -0.01049451f, 0.00815359f, 
    -0.00898852f, 0.01956191f, -0.02455164f, -0.01277592f, -0.01275120f, 0.01907531f, -0.02623133f, 0.01049058f, 
    0.01434388f, 0.00958394f, 0.01517392f, 0.02771646f, -0.01650057f, 0.01431036f, 0.02950668f, 0.02664784f, 
    -0.02328010f, -0.00988593f, -0.03448631f, -0.01631826f, 0.00530053f, -0.02951165f, -0.01187203f, 0.00669897f, 
    -0.03116269f, -0.00523928f, -0.00203706f, 0.00200602f, -0.01405576f, -0.01873808f, -0.00182136f, -0.00131810f, 
    -0.01766318f, 0.01334692f, 0.02085415f, 0.02930522f, 0.00937598f, 0.02409653f, 0.01837702f, -0.02109317f, 
    0.01470351f, 0.02651812f, -0.01928219f, -0.01935795f, -0.02434889f, 0.00471070f, 0.02307742f, -0.01234626f, 
    0.01250647f, -0.00994285f, -0.01231180f, 0.02856187f, -0.00247211f, -0.03096969f, -0.02167831f, 0.02072874f, 
    0.01120248f, -0.01284755f, -0.02210474f, 0.01410940f, 0.00896417f, 0.02567171f, -0.02030832f, -0.01259469f, 
    -0.03846697f, -0.01882348f, 0.00110840f, -0.02294898f, 0.01052991f, -0.01483793f, 0.00319096f, -0.00670009f, 
    -0.02419832f, -0.02422361f, 0.00756821f, -0.01231837f, -0.00515000f, -0.04073041f, -0.00335750f, 0.02171635f, 
    -0.03652581f, -0.00193780f, -0.03769461f, -0.03086677f, -0.01766142f, 0.00523603f, 0.02146852f, 0.02747254f, 
    -0.01991818f, 0.01831818f, 0.02298169f, -0.01626787f, -0.00938777f, -0.00041712f, -0.03082808f, 0.00828611f, 
    0.00345674f, -0.02798570f, -0.02026125f, 0.00089511f, -0.01880531f, 0.01610480f, 0.00165440f, 0.02370229f, 
    -0.02332615f, 0.01936101f, 0.00006139f, 0.01127738f, -0.03424406f, 0.02122589f, 0.01101494f, 0.00354728f, 
    -0.03129605f, -0.01969323f, -0.00224700f, -0.02726660f, -0.03409010f, -0.01429334f, -0.01678391f, 0.02871824f, 
    0.00095935f, -0.02339269f, -0.00862304f, -0.02619492f, 0.02228764f, -0.02842697f, -0.03912238f, -0.02245387f, 
    -0.02338541f, -0.00056617f, -0.03269929f, 0.01346109f, -0.04132774f, 0.00448771f, -0.00892318f, -0.02711445f, 
    -0.01019589f, 0.01719266f, -0.04179546f, -0.03238823f, 0.00094749f, -0.02259960f, -0.02365305f, -0.02397493f, 
    0.00977942f, 0.00083614f, -0.01125083f, 0.01718404f, -0.02037770f, -0.03625876f, -0.02916046f, -0.02098325f, 
    -0.04110854f, -0.00872310f, -0.00659445f, -0.00574723f, 0.01404183f, 0.02559467f, -0.00321963f, 0.00877267f, 
    -0.00915021f, 0.02638672f, -0.00822514f, -0.03086936f, -0.02250551f, 0.01945077f, 0.02368419f, -0.01426994f, 
    -0.01468189f, -0.04115414f, 0.01891519f, -0.02552724f, -0.03604758f, 0.01466662f, -0.02846949f, 0.02485950f, 
    -0.04192981f, -0.00287911f, -0.02838194f, -0.02614355f, 0.02798721f, -0.02482715f, 0.01015243f, -0.02630624f, 
    0.01472329f, -0.03047283f, 0.01170989f, 0.00707204f, 0.02876898f, 0.00138630f, -0.00492197f, 0.02647653f, 
    0.02549144f, 0.00880436f, 0.01353235f, 0.00980150f, -0.02632722f, 0.00185362f, 0.00522427f, 0.01587468f, 
    -0.00100421f, 0.02872543f, 0.01488650f, -0.02116965f, 0.00864753f, 0.00384219f, -0.02692600f, -0.02865603f, 
    -0.02851043f, 0.02087296f, 0.01381287f, -0.03741001f, 0.00955079f, 0.01871612f, -0.01625608f, -0.00250216f, 
    -0.02397847f, -0.00609591f, -0.02925175f, -0.02465624f, -0.02285073f, -0.03919823f, -0.01838115f, 0.00439701f, 
    0.01992039f, -0.00498571f, 0.02484939f, 0.02186311f, 0.01707811f, -0.00048777f, 0.00480190f, 0.00088923f, 
    0.01114193f, -0.00407846f, -0.03386294f, 0.01726395f, -0.01420560f, -0.03033981f, 0.02668078f, -0.01823357f, 
    -0.02124370f, -0.01926771f, 0.00954567f, -0.03301663f, 0.01656509f, 0.02809740f, -0.01373882f, -0.00405333f, 
    -0.00400608f, 0.01229373f, 0.00100649f, 0.02544645f, 0.02739085f, 0.02131349f, -0.03859576f, 0.02196308f, 
    0.00699864f, -0.00270246f, 0.00845772f, 0.01563836f, -0.02640649f, 0.01694159f, 0.00972943f, -0.01718413f, 
    0.01807239f, 0.02355385f, -0.01527727f, 0.02007624f, -0.02562872f, -0.01802020f, 0.00161414f, 0.01871895f, 
    -0.02538283f, -0.00701919f, 0.00651952f, 0.00664180f, -0.01688537f, 0.00455259f, 0.00653227f, 0.02095939f, 
    -0.02507682f, 0.00061802f, 0.01309365f, -0.00287185f, -0.03320445f, -0.02825806f, -0.00996790f, 0.02477035f, 
    -0.03611174f, -0.00037177f, -0.00037392f, 0.01165855f, 0.02022643f, 0.00818065f, 0.01104592f, -0.04007715f, 
    -0.02230299f, -0.00844238f, -0.02487393f, -0.00818653f, 0.02254757f, 0.00705420f, 0.00189653f, -0.03374140f, 
    0.00792277f, 0.01138378f, -0.00386598f, 0.00548716f, -0.03793563f, -0.02023783f, -0.00134334f, 0.00207963f, 
    -0.02931382f, -0.02145009f, 0.02559406f, 0.00214835f, -0.02540334f, 0.01160060f, -0.03671772f, -0.00206320f, 
    0.02199266f, -0.02958431f, -0.03247954f, 0.00523343f, 0.00091707f, -0.01618190f, -0.02793487f, -0.00529098f, 
    0.01265425f, 0.02828571f, -0.00477519f, -0.00278410f, -0.03829871f, -0.02878735f, -0.01059629f, 0.02690316f, 
    -0.02430766f, 0.01879848f, -0.03817112f, 0.00138300f, -0.03730005f, -0.00634609f, -0.03483332f, -0.01121252f, 
    -0.02757410f, 0.03949866f, -0.01212630f, -0.01456907f, 0.01321458f, 0.00323886f, -0.00975842f, -0.03281249f, 
    -0.01605569f, -0.00605518f, -0.03968080f, -0.02625172f, 0.02312442f, -0.01720985f, 0.00852938f, -0.04195714f, 
    0.01798392f, 0.00960036f, -0.03595455f, 0.01652235f, 0.01486054f, -0.00997861f, 0.00960101f, 0.02307094f, 
    -0.00817585f, -0.03631883f, -0.03847075f, -0.01941814f, -0.01181265f, 0.01674048f, -0.00031114f, -0.00584609f, 
    -0.03298137f, 0.02165110f, -0.00193032f, -0.02518638f, 0.00719123f, -0.02806101f, 0.02035118f, -0.01752240f, 
    -0.02360559f, 0.02064466f, 0.01042527f, -0.00817374f, -0.01519045f, -0.04086696f, 0.00646151f, -0.00615064f, 
    -0.01691788f, -0.01308314f, 0.00491820f, 0.02017105f, -0.00435547f, 0.01367525f, -0.01025822f, -0.03548189f, 
    0.00507564f, -0.00314327f, 0.02695731f, 0.01271964f, -0.03576558f, 0.00350778f, -0.01943456f, -0.02764970f, 
    0.01665858f, -0.03559086f, -0.00099579f, -0.03392499f, 0.01312165f, 0.02499499f, -0.03092162f, -0.03438747f, 
    0.02950744f, -0.01318378f, 0.00732610f, 0.00615528f, -0.01195633f, 0.01984412f, -0.00458215f, -0.00503779f, 
    -0.00107707f, -0.01053224f, 0.00296231f, 0.01686474f, -0.00260645f, -0.01502928f, 0.01933109f, -0.01017557f, 
    -0.02000662f, 0.01631469f, -0.01179955f, -0.01316021f, -0.02572025f, 0.01686581f, -0.00504993f, -0.03794817f, 
    -0.01890280f, 0.02208723f, 0.02315347f, -0.02638824f, -0.00641973f, -0.00271804f, -0.02600683f, 0.01007582f, 
    0.00669482f, -0.02802043f, -0.02644922f, -0.02948269f, -0.03987504f, -0.00473726f, -0.01003198f, 0.01605971f, 
    0.02564611f, 0.02992544f, -0.01288128f, -0.01336914f, -0.01122256f, -0.02610363f, 0.00608049f, 0.02545340f, 
    0.00058712f, 0.00424387f, -0.02066733f, 0.02320493f, -0.03997156f, -0.03973502f, 0.02598190f, 0.02967825f, 
    0.01058208f, 0.03199939f, -0.03279267f, -0.03113441f, 0.02407405f, -0.03679037f, -0.01062115f, 0.03131344f, 
    -0.00225849f, 0.01766279f, -0.02944192f, -0.03253815f, -0.02653973f, 0.00362449f, 0.01495686f, 0.01040086f, 
    0.00326273f, -0.00256811f, -0.00500418f, 0.02240864f, 0.00155352f, -0.01914083f, -0.02821578f, 0.00486340f, 
    0.02963747f, -0.03127535f, -0.03118346f, 0.01412587f, 0.02384191f, -0.00923322f, -0.02509517f, 0.00797575f, 
    -0.03002522f, 0.03171470f, -0.00543853f, 0.00498193f, -0.02140774f, 0.00846718f, -0.01374620f, -0.03924869f, 
    0.02977297f, 0.01331398f, -0.03429237f, 0.01517204f, -0.01128649f, -0.00898503f, -0.02605508f, 0.01970717f, 
    -0.01647930f, 0.02296171f, 0.01055546f, 0.01110411f, -0.00655501f, -0.02638729f, -0.00301466f, 0.02073288f, 
    0.02347395f, -0.02434708f, 0.00312701f, 0.02519861f, -0.02146274f, 0.01756347f, -0.01795491f, 0.03039527f, 
    0.03100732f, 0.02235572f, -0.01212154f, -0.01135858f, 0.02123941f, -0.01317965f, 0.00263127f, 0.01478261f, 
    -0.01795642f, 0.02420816f, 0.02825076f, -0.02037988f, -0.00282314f, 0.02635242f, -0.01998428f, -0.03693983f, 
    -0.02922878f, 0.01285453f, -0.02303563f, 0.02168211f, 0.01622145f, -0.02350019f, 0.00188603f, -0.03676363f, 
    0.03071626f, 0.00381728f, -0.00611244f, -0.03205999f, 0.01341401f, 0.01720748f, -0.02097658f, 0.00616910f, 
    0.00796646f, -0.00777707f, -0.03982877f, -0.02999404f, -0.02553259f, -0.00846898f, -0.00337593f, 0.00309073f, 
    -0.02628643f, 0.02324150f, -0.02251391f, 0.01222212f, -0.02202898f, -0.01958481f, -0.03251367f, -0.02865622f, 
    0.02152585f, -0.00382081f, 0.00906480f, -0.03426225f, 0.02244736f, -0.01953884f, -0.01376760f, -0.02430801f, 
    -0.02743459f, 0.01317292f, 0.02746616f, -0.03371147f, -0.00543996f, -0.00531253f, 0.00177314f, -0.03751282f, 
    0.00760238f, -0.03393150f, -0.02024738f, 0.00084783f, 0.00493711f, -0.02729822f, -0.03064657f, -0.00142094f, 
    0.00828949f, -0.03121934f, 0.00729783f, -0.02607520f, -0.04049131f, -0.01475550f, -0.03878235f, 0.01907683f, 
    0.01291538f, 0.02144216f, 0.01843032f, -0.01578356f, -0.00613888f, -0.03870681f, -0.03677085f, -0.02382467f, 
    -0.00389894f, -0.01098822f, -0.02490289f, 0.01050675f, -0.00930609f, 0.00784335f, 0.00077862f, -0.03672167f, 
    0.00840406f, -0.00567341f, -0.02744747f, -0.02396987f, -0.01270196f, -0.00401397f, 0.00535809f, 0.02335040f, 
    0.02190321f, 0.02575308f, -0.00633361f, 0.00291978f, -0.04138248f, 0.02480685f, -0.03498258f, -0.01764163f, 
    0.01940828f, -0.00242329f, -0.02600366f, 0.02528665f, -0.01417010f, 0.01196096f, -0.01939663f, -0.02298294f, 
    0.00377483f, 0.01804192f, -0.03061451f, -0.02951330f, 0.01485862f, 0.00598090f, 0.00207654f, -0.02229459f, 
    0.00839230f, -0.00376598f, -0.01950670f, -0.01865580f, -0.02212171f, 0.00668792f, -0.02067079f, -0.00139938f, 
    -0.01791096f, -0.01896120f, 0.01868404f, 0.01889539f, 0.00821825f, -0.03464472f, 0.01052871f, 0.02484579f, 
    -0.00046378f, 0.03006100f, -0.03232573f, -0.03435129f, 0.02991315f, -0.03274967f, -0.02258168f, -0.00572295f, 
    -0.01135962f, -0.03488400f, -0.02655031f, 0.02711428f, 0.01537088f, -0.03017250f, 0.00049852f, 0.01182735f, 
    0.01796740f, 0.03006705f, 0.01431480f, 0.01122564f, -0.03897645f, -0.03582404f, 0.01876156f, -0.00832094f, 
    -0.03855004f, -0.00325857f, -0.03356866f, -0.00487276f, -0.00052088f, -0.00759040f, 0.02713355f, -0.00941022f, 
    -0.01416481f, 0.02933171f, -0.00430835f, -0.00581487f, -0.03155875f, -0.03657974f, -0.00856676f, -0.01056717f, 
    -0.02753629f, 0.01379377f, -0.03841197f, 0.02992282f, -0.01934484f, 0.02280351f, 0.02450210f, -0.01412800f, 
    -0.02486802f, 0.02376180f, 0.03035508f, -0.00581077f, 0.03174800f, 0.02101768f, -0.02234055f, 0.01492118f, 
    0.00601286f, 0.02352393f, 0.02941332f, 0.00440876f, -0.02865948f, -0.00963111f, 0.02885057f, -0.02085101f, 
    -0.03340796f, 0.02869149f, -0.02599118f, -0.03648108f, 0.00954179f, -0.03327669f, -0.03109930f, -0.00262076f, 
    0.00603172f, -0.01606660f, 0.02908488f, -0.02921800f, -0.02645789f, 0.01751520f, 0.02504242f, 0.01093495f, 
    -0.02803101f, 0.01160899f, -0.02569870f, 0.01554295f, 0.01249448f, -0.01855327f, -0.01230560f, 0.02919189f, 
    0.01502968f, -0.02376447f, -0.01499440f, -0.01981558f, 0.02512521f, -0.03662003f, -0.01076730f, -0.02376915f, 
    -0.00547575f, -0.02098528f, -0.02427909f, -0.03471037f, -0.00240768f, -0.00942469f, 0.02131821f, 0.02649059f, 
    -0.02540913f, -0.01873282f, 0.00626617f, -0.04110766f, 0.01753527f, 0.00814799f, -0.00540532f, -0.01991469f, 
    -0.02607610f, 0.00716036f, 0.02070081f, -0.03861464f, 0.02585438f, -0.01362257f, -0.02506552f, 0.00178747f, 
    0.01437269f, -0.02918533f, -0.02104492f, 0.01508288f, 0.01592025f, 0.01324005f, -0.02306203f, -0.00558481f, 
    -0.01402914f, 0.03535821f, 0.00535623f, 0.02448014f, -0.01615800f, 0.01847363f, 0.00100590f, 0.02721187f, 
    0.00227340f, -0.02253491f, -0.03393203f, -0.00211003f, 0.00681772f, -0.00120680f, -0.02575121f, 0.02776593f, 
    -0.02659090f, -0.03651817f, -0.01781934f, -0.01229165f, -0.03028401f, 0.01235826f, -0.01297336f, 0.01162903f, 
    0.02884883f, -0.01184920f, -0.00832634f, 0.01857749f, -0.04144168f, 0.01129959f, 0.03084327f, 0.02615331f, 
    -0.00718083f, -0.01146513f, -0.02456829f, 0.02920125f, 0.02690651f, -0.01369064f, 0.01002835f, 0.03031481f, 
    0.02702174f, 0.00122357f, -0.00371653f, 0.02628549f, 0.00867803f, 0.02413142f, 0.02548365f, 0.01477143f, 
    0.01478120f, 0.02387215f, -0.01796466f, -0.01044745f, -0.01596238f, 0.02156997f, -0.03609418f, 0.00382605f, 
    0.03766000f, 0.02709494f, -0.03874981f, 0.00657185f, -0.01305106f, -0.03257049f, -0.01815541f, -0.01450353f, 
    0.00178587f, 0.00573263f, 0.02144990f, 0.00116312f, -0.03173850f, 0.02656635f, -0.02879838f, -0.00486991f, 
    -0.03752517f, 0.00812460f, 0.01064022f, 0.00807258f, 0.01116374f, -0.02885612f, -0.01785254f, 0.02643532f, 
    -0.03557741f, -0.02077067f, 0.02846373f, -0.00409444f, -0.00314475f, 0.02030896f, 0.01036084f, 0.02354641f, 
    -0.03450372f, -0.02048528f, -0.01183979f, 0.01122799f, -0.01669917f, -0.03615140f, -0.01090558f, -0.02970254f, 
    0.00948263f, -0.03246512f, -0.02499533f, -0.02909419f, -0.01398717f, 0.02961611f, -0.01287008f, 0.00165800f, 
    0.00098251f, 0.01970238f, -0.02566332f, 0.00906040f, -0.02346270f, 0.00200411f, 0.00744503f, -0.01641469f, 
    -0.02586007f, -0.01730663f, 0.01545185f, -0.01635647f, -0.00494983f, -0.04031913f, 0.03037323f, 0.00936580f, 
    0.00643476f, -0.03375211f, 0.03418461f, -0.00620164f, -0.02354698f, 0.03076597f, -0.01453250f, -0.00723493f, 
    -0.03903422f, 0.00880160f, 0.00436497f, -0.00777488f, -0.03275102f, -0.00791453f, 0.00352363f, -0.01544014f, 
    -0.02776099f, -0.00927864f, -0.02909976f, -0.02048626f, 0.02373194f, -0.02550804f, -0.02372074f, 0.02586548f, 
    -0.01301104f, 0.02869946f, -0.01736010f, -0.01344368f, -0.00637735f, -0.02737029f, 0.00936000f, 0.00621479f, 
    -0.00312105f, 0.02682138f, 0.03196141f, 0.00126036f, -0.03466432f, 0.02339606f, 0.02473860f, 0.02178977f, 
    -0.00994270f, -0.02044474f, -0.01241712f, 0.02845225f, -0.02159848f, 0.03005624f, 0.01675914f, -0.03311160f, 
    -0.03317247f, 0.01558783f, 0.01656593f, -0.02518080f, -0.00320124f, 0.03011283f, -0.02179498f, 0.01320225f, 
    0.00571909f, 0.01494702f, 0.02224394f, -0.03918057f, -0.00094075f, -0.01180496f, 0.00392567f, 0.01262146f, 
    0.02591343f, -0.00216786f, 0.02254273f, -0.01496729f, -0.01811481f, 0.00584858f, 0.01110264f, -0.03710826f, 
    0.02824138f, 0.00181890f, -0.00020119f, 0.00220717f, 0.01468686f, -0.01597086f, -0.00696776f, 0.02128109f, 
    0.00073233f, 0.00681300f, 0.00081268f, -0.01036334f, -0.01417919f, -0.00244714f, -0.02855163f, -0.00207936f, 
    -0.00332573f, -0.02419165f, 0.00130306f, 0.00034943f, -0.01897401f, 0.02658227f, 0.00976618f, -0.00468263f, 
    -0.02049237f, -0.02164623f, 0.02814380f, -0.04080967f, -0.03186105f, 0.03388942f, 0.03308554f, 0.02198872f, 
    -0.01222744f, -0.00136232f, 0.00133892f, -0.03627266f, -0.02105903f, -0.02941443f, -0.03507715f, 0.02872722f, 
    -0.00803699f, -0.00616833f, 0.02979528f, 0.00033540f, 0.00563758f, 0.01753844f, 0.01734898f, -0.00899399f, 
    -0.04088418f, -0.02482711f, 0.00258841f, -0.03444673f, 0.01952469f, -0.03813852f, 0.01992637f, -0.02142249f, 
    0.02840777f, 0.01502337f, -0.01772016f, -0.03355972f, 0.01005860f, 0.02294992f, 0.00357077f, -0.00353116f, 
    -0.01048709f, 0.01679233f, -0.02238703f, -0.02129438f, 0.03291152f, 0.03249560f, 0.02249242f, 0.01031969f, 
    0.01781080f, 0.00565406f, -0.00465428f, 0.01040445f, -0.00442628f, -0.01384383f, -0.03808729f, 0.02786009f, 
    -0.02653069f, 0.02177234f, -0.02840637f, -0.03820248f, 0.00326130f, 0.01494414f, 0.02766877f, -0.03362232f, 
    -0.00643431f, 0.02458859f, -0.03569457f, 0.00665656f, -0.00342379f, 0.03048250f, -0.02225458f, -0.00281993f, 
    0.03175814f, -0.03533886f, 0.00889588f, -0.00324286f, -0.02892284f, 0.02404474f, -0.02797359f, 0.00237685f, 
    -0.00932577f, 0.02929758f, -0.03687178f, 0.03445074f, -0.01977407f, -0.00926062f, -0.03319140f, 0.02936573f, 
    -0.02246993f, 0.02461896f, -0.01507483f, 0.02670595f, -0.02938763f, 0.01486259f, -0.02290729f, 0.02900319f, 
    -0.03425455f, -0.03954041f, -0.00253133f, 0.01881834f, -0.03045552f, -0.00016535f, 0.01084095f, -0.03866686f, 
    0.03021580f, 0.00677877f, -0.02525541f, -0.03169297f, -0.00166875f, 0.00720093f, -0.03079611f, 0.00428517f, 
    -0.01300690f, 0.01879205f, -0.00701127f, -0.02538463f, -0.03425587f, 0.00267367f, -0.00515522f, 0.01194054f, 
    -0.03482227f, 0.03564027f, -0.03489023f, 0.01352417f, 0.01135661f, -0.04062742f, -0.01131207f, 0.02845660f, 
    -0.01738329f, -0.00688178f, -0.01124327f, 0.02873376f, -0.02614241f, -0.01223452f, -0.03717972f, -0.03811033f, 
    0.02227284f, -0.01866375f, -0.01010793f, -0.03577418f, 0.00732740f, -0.03274974f, -0.01346562f, 0.01418267f, 
    0.01849547f, -0.00780629f, -0.01137129f, 0.02085789f, 0.02775008f, 0.00089356f, 0.01925894f, 0.02336152f, 
    -0.00120092f, -0.01123094f, -0.02135010f, 0.03006325f, -0.02195748f, 0.02462296f, 0.01380625f, 0.02638263f, 
    0.02666617f, -0.03620871f, 0.01128210f, 0.03250385f, -0.04060837f, 0.01051781f, -0.00873530f, -0.03299146f, 
    0.02165083f, 0.00767797f, -0.02530860f, 0.01695299f, -0.03002601f, 0.02610443f, -0.03131227f, 0.02685871f, 
    -0.03884329f, -0.01134176f, 0.03487673f, 0.03106554f, 0.02247960f, -0.00274450f, -0.00990308f, -0.03832456f, 
    -0.02238396f, 0.02330331f, 0.01738075f, 0.02520155f, 0.00266551f, 0.00200505f, -0.00106838f, -0.03889332f, 
    0.02456003f, 0.02299492f, -0.03471953f, 0.00865949f, -0.01867366f, 0.00073857f, -0.02146243f, -0.03378005f, 
    -0.03571656f, -0.02125772f, -0.02434143f, -0.01385971f, 0.02350150f, -0.01472085f, -0.04121497f, -0.00183928f, 
    0.00469946f, 0.03076812f, 0.00752965f, 0.01881887f, 0.02914079f, 0.01043468f, 0.00686945f, -0.02582178f, 
    -0.02606137f, -0.02703974f, -0.03428390f, 0.00714773f, 0.01674420f, 0.02153621f, 0.02856533f, 0.01665769f, 
    0.00321539f, -0.01226513f, -0.00227496f, -0.00774833f, -0.01235178f, -0.01268532f, -0.02821282f, 0.00251499f, 
    -0.02753042f, -0.03504645f, 0.01535084f, -0.01117303f, -0.01489960f, 0.02653888f, 0.00014362f, -0.02121220f, 
    -0.03148149f, -0.03327635f, -0.02552561f, 0.00945355f, 0.01900659f, -0.00223465f, -0.04056380f, 0.01541072f, 
    -0.03625554f, 0.02846208f, -0.03594860f, -0.02813069f, 0.02927192f, -0.01555761f, -0.01197637f, 0.02675779f, 
    0.03278424f, 0.02734357f, -0.04045228f, -0.03418598f, 0.01746890f, 0.01891615f, -0.00975062f, 0.02507526f, 
    -0.04146109f, 0.02970551f, 0.00230813f, -0.03611807f, -0.02391929f, -0.02165720f, -0.04146224f, 0.03572384f, 
    0.00852226f, -0.03928043f, 0.00138700f, 0.01105176f, -0.00786688f, -0.01367785f, 0.01409623f, 0.01668686f, 
    -0.00551913f, -0.00578814f, 0.00987243f, -0.03920843f, -0.01326921f, -0.02535153f, 0.02161333f, 0.02276961f, 
    0.00035525f, -0.02526798f, 0.00888824f, 0.02117080f, -0.00532272f, -0.00717517f, 0.00652831f, -0.03597489f, 
    0.02987202f, -0.00828952f, -0.00200536f, 0.01783575f, 0.02012903f, 0.01950656f, 0.02383047f, 0.01026717f, 
    0.03013610f, -0.01341327f, -0.00631272f, 0.01993178f, 0.01751346f, 0.02087004f, -0.02899398f, 0.01038678f, 
    0.01484167f, 0.02602711f, -0.03312672f, 0.02658840f, -0.00571491f, -0.02511565f, -0.02627576f, 0.01120469f, 
    -0.03015917f, -0.01167193f, 0.00517051f, -0.01557508f, -0.01826883f, -0.01200440f, -0.00236936f, -0.03513315f, 
    -0.03242598f, -0.02655442f, -0.03942659f, -0.01190867f, 0.01000462f, 0.00917132f, 0.00843781f, -0.00707407f, 
    0.00426965f, -0.01701556f, -0.03147474f, -0.03826566f, -0.00860272f, -0.01481400f, -0.01664003f, 0.00628728f, 
    -0.00053865f, 0.00363458f, 0.02054009f, -0.01972214f, 0.00178442f, -0.00628150f, -0.01013528f, -0.03669254f, 
    -0.00097444f, -0.02145758f, -0.00504432f, 0.02586760f, 0.02265712f, -0.03498726f, -0.02636231f, -0.01657558f, 
    -0.00358889f, -0.00490572f, -0.00114288f, -0.00667679f, -0.00689587f, -0.02143444f, -0.03715194f, -0.03091341f, 
    -0.00550180f, -0.01583778f, -0.00291083f, 0.03141110f, -0.03415356f, -0.01076100f, 0.02835909f, -0.01865626f, 
    -0.00162919f, -0.03532063f, 0.02248822f, 0.02276382f, -0.00607737f, -0.04153799f, 0.02814608f, 0.01259191f, 
    0.02260061f, 0.00859861f, 0.02831591f, 0.00635050f, -0.02738569f, 0.00844525f, -0.03336518f, 0.01156712f, 
    0.01275898f, -0.00796234f, 0.01940056f, -0.01706958f, 0.00149667f, 0.03019183f, 0.00862686f, -0.00473881f, 
    0.00488749f, -0.00020061f, 0.01251837f, -0.01895601f, 0.00122673f, 0.02204576f, -0.03854896f, 0.00616464f, 
    -0.03304283f, -0.01235040f, -0.02146360f, -0.02860600f, 0.00294867f, -0.00522037f, 0.02192691f, -0.03779364f, 
    -0.00085182f, -0.01328722f, -0.00783086f, -0.01663396f, 0.01441119f, 0.00349020f, -0.00026391f, 0.02805086f, 
    -0.03852731f, 0.00078092f, -0.01600425f, -0.00963070f, 0.02801187f, -0.02335658f, -0.03137907f, 0.00076044f, 
    -0.01435118f, -0.01123762f, 0.00787805f, 0.00057280f, -0.01129057f, 0.00780873f, -0.02496414f, -0.00031034f, 
    -0.01490293f, -0.03267984f, -0.03022129f, -0.00287540f, -0.01503855f, -0.00809542f, -0.03863751f, 0.02187141f, 
    -0.02579029f, -0.01618102f, -0.01294537f, 0.00983915f, 0.03001669f, 0.00105903f, -0.00736378f, 0.01126358f, 
    -0.00306727f, -0.01758542f, 0.01724066f, -0.02479478f, -0.04049165f, 0.00660942f, -0.02525545f, -0.02724976f, 
    -0.04033198f, -0.02458039f, 0.00412811f, -0.04084682f, 0.01208135f, -0.03589215f, 0.01484735f, 0.00304317f, 
    -0.03468152f, 0.00960368f, 0.00785549f, -0.01671945f, 0.02374690f, 0.01346777f, -0.01245319f, -0.04061440f, 
    0.01161400f, -0.01112465f, 0.00032461f, -0.00987670f, -0.03642174f, 0.00063355f, -0.01169887f, -0.02134873f, 
    -0.02534025f, -0.03457268f, -0.01947121f, -0.02304768f, -0.03443896f, -0.02733886f, -0.03905009f, -0.01663378f, 
    -0.04124702f, -0.00518913f, -0.03213136f, -0.01927699f, 0.02737085f, -0.01214136f, 0.03138405f, -0.04055114f, 
    -0.02469336f, 0.01652295f, -0.03405408f, 0.02183839f, -0.01009077f, -0.01909666f, -0.03675400f, -0.00843133f, 
    0.01374515f, 0.00206411f, -0.03600259f, -0.00235152f, -0.03868251f, 0.00369148f, 0.01645567f, -0.02655283f, 
    -0.03019104f, 0.02029564f, -0.01474563f, -0.01808549f, -0.01931349f, -0.00074509f, 0.01282771f, 0.01685973f, 
    -0.01496787f, -0.02530638f, -0.01228485f, -0.02846263f, -0.03591761f, -0.03491890f, -0.02763273f, 0.01606765f, 
    0.00172187f, 0.02285627f, 0.00311380f, 0.02976705f, -0.02295388f, -0.02248603f, -0.02075902f, -0.01529131f, 
    -0.03411465f, -0.02073671f, -0.00529872f, -0.01138474f, 0.02205455f, 0.00055581f, 0.02030388f, -0.01715818f, 
    -0.03162888f, 0.00388998f, -0.02261837f, -0.03138433f, 0.02130501f, -0.00913121f, -0.04143633f, -0.01899714f, 
    0.01198815f, -0.03994924f, 0.00146217f, 0.02976657f, -0.02795432f, -0.03928073f, 0.02794498f, 0.02784458f, 
    -0.01289830f, 0.00222262f, -0.01869227f, -0.00008265f, -0.02565698f, -0.02028525f, -0.03045654f, 0.02584012f, 
    0.02720050f, -0.02393563f, -0.00585107f, 0.00296397f, -0.02874028f, 0.00794407f, -0.02373318f, 0.02271508f, 
    -0.02986393f, -0.01397667f, -0.02248447f, 0.00708762f, -0.01608609f, -0.03784193f, 0.00301511f, -0.02425271f, 
    -0.00712703f, -0.03562006f, -0.01129548f, -0.02283612f, -0.00316484f, -0.01709020f, 0.01667724f, -0.03227801f, 
    -0.00031612f, -0.02726234f, -0.00310752f, -0.02520464f, -0.02006584f, -0.04162810f, 0.00988272f, -0.00128402f, 
    0.02871239f, 0.00268172f, -0.01539132f, -0.01329857f, 0.03049387f, -0.00343689f, 0.00109570f, -0.01892992f, 
    -0.02209206f, 0.00939924f, 0.01363588f, -0.03465937f, 0.02546242f, -0.01607588f, -0.00262127f, 0.00732682f, 
    -0.00724151f, -0.00695237f, 0.02667450f, -0.01073336f, 0.01574767f, 0.02127113f, 0.01347815f, -0.00190441f, 
    -0.03677032f, 0.00364585f, -0.02958036f, -0.03611416f, -0.03109139f, 0.01202546f, 0.02014766f, -0.02428681f, 
    -0.02820283f, 0.01869901f, 0.02188415f, -0.02522563f, -0.02061101f, 0.01523330f, -0.02026217f, -0.00234434f, 
    -0.01036406f, -0.00583135f, 0.02608295f, -0.00954645f, -0.03389374f, -0.00844971f, -0.03132106f, -0.01433872f, 
    0.02857662f, -0.02737642f, -0.03476625f, 0.00752097f, -0.01899160f, 0.00322155f, 0.00501269f, -0.02199270f, 
    -0.03696527f, -0.02240445f, 0.02623272f, -0.01334194f, -0.00307597f, 0.01504012f, 0.01953581f, 0.00407228f, 
    -0.03584475f, -0.02644596f, 0.02920754f, 0.01961437f, -0.03441534f, -0.02411866f, -0.01790852f, 0.01105050f, 
    -0.00266676f, -0.02254635f, -0.00703406f, -0.00300680f, 0.00109010f, 0.02957847f, -0.02669357f, -0.03045106f, 
    -0.00433391f, 0.02954342f, -0.01476179f, 0.02642824f, -0.02757290f, -0.00668036f, -0.00760837f, -0.03367930f, 
    0.02551623f, -0.03956028f, 0.02830553f, 0.02555436f, -0.02549693f, -0.03906431f, 0.02407166f, -0.03615863f, 
    0.01341821f, -0.01889650f, -0.00172509f, -0.03045060f, 0.02482194f, -0.02464470f, 0.00977999f, 0.01020265f, 
    -0.01918949f, 0.01110297f, 0.00265316f, 0.01165247f, 0.00314619f, -0.01668676f, -0.00429718f, -0.03053516f, 
    0.01518459f, -0.01967228f, -0.02134383f, -0.01205851f, 0.02685575f, 0.01224037f, 0.01690043f, 0.01030808f, 
    0.01994575f, -0.03071299f, -0.00058564f, -0.00366901f, -0.03119112f, -0.02102289f, -0.00871728f, 0.02500730f, 
    0.01609471f, -0.02316503f, 0.00291686f, -0.02633232f, 0.00027140f, -0.01695991f, 0.00819158f, -0.00034851f, 
    0.00956757f, -0.02019330f, -0.03090566f, 0.01776776f, -0.00154489f, -0.02860829f, -0.03099155f, -0.00365819f, 
    -0.00398890f, -0.00390021f, -0.03142354f, -0.01263423f, -0.02344018f, -0.02255431f, -0.01479063f, -0.03332846f, 
    -0.02452403f, 0.01734120f, -0.02205962f, 0.00889083f, -0.02512117f, 0.02784779f, -0.02421467f, -0.02941076f, 
    0.00239504f, -0.01911199f, -0.03172908f, -0.03873181f, 0.01149602f, -0.02590367f, 0.02259708f, -0.03575719f, 
    -0.01058961f, -0.02026195f, 0.02617559f, -0.02225505f, 0.02201005f, -0.00846556f, -0.02271625f, -0.00395612f, 
    -0.03013923f, 0.00151626f, -0.00694594f, -0.01456872f, 0.00780145f, 0.00342527f, -0.00137380f, -0.03744346f, 
    -0.00098817f, -0.00463600f, -0.01901091f, -0.03526932f, -0.01461257f, 0.02692541f, 0.01430265f, -0.01249560f, 
    0.02235222f, -0.01327272f, -0.03072590f, 0.01455253f, 0.01733408f, -0.00906675f, -0.01552964f, -0.01682291f, 
    0.00223861f, 0.03048132f, 0.00353582f, -0.02292060f, -0.03038101f, -0.03108217f, -0.03855477f, 0.02111196f, 
    0.00392597f, -0.00380781f, -0.01327692f, -0.03124211f, 0.01448289f, 0.02434698f, 0.00886356f, -0.01676661f, 
    -0.00262694f, 0.00047546f, 0.01145423f, 0.02154198f, 0.00793481f, -0.03974469f, 0.02380057f, 0.01047754f, 
    0.02848670f, 0.01903177f, -0.00775919f, 0.03031863f, 0.00436766f, 0.02508423f, 0.00944119f, -0.03593934f, 
    -0.03306922f, 0.00807615f, -0.02861582f, -0.03133013f, -0.01786822f, -0.03679197f, -0.04115999f, -0.04005916f, 
    -0.02580707f, 0.01361245f, 0.00907702f, -0.03101522f, -0.02201256f, 0.02788348f, 0.01065809f, 0.02220371f, 
    -0.03372387f, 0.00513195f, 0.03257914f, -0.02485141f, -0.02204583f, 0.00414198f, -0.02500276f, -0.01356415f, 
    0.00094137f, -0.01261592f, 0.00459568f, 0.02675273f, -0.00600023f, -0.02644840f, -0.04011133f, 0.00659080f, 
    -0.02543386f, -0.03206708f, -0.03678897f, 0.00012203f, -0.03140111f, 0.01042410f, 0.00680020f, 0.02870029f, 
    0.02360865f, -0.01475585f, 0.01836946f, 0.02041603f, -0.03667841f, -0.03835825f, -0.00185115f, -0.01346963f, 
    -0.04008734f, -0.02862311f, 0.02011386f, 0.02375670f, 0.02467241f, -0.00448920f, -0.02360535f, 0.02959670f, 
    -0.01899751f, -0.02615499f, 0.00552932f, 0.01679426f, 0.00201723f, 0.01054336f, -0.01354773f, -0.02407137f, 
    0.00163932f, 0.01915062f, 0.02971569f, 0.02990973f, -0.02666997f, 0.02064396f, 0.00356822f, -0.00701977f, 
    -0.01541046f, -0.02807353f, 0.02510615f, 0.00364352f, 0.00742129f, -0.00623730f, 0.01956032f, -0.03615269f, 
    0.02247866f, 0.02820113f, 0.01673970f, -0.02774149f, 0.01965262f, -0.02099702f, -0.00110026f, 0.01967532f, 
    -0.00068757f, -0.00335562f, 0.00578410f, 0.01955198f, -0.02261571f, -0.00331076f, -0.02514448f, -0.02123763f, 
    -0.02469191f, 0.01641972f, 0.01537802f, -0.02427650f, 0.00118549f, 0.01313757f, 0.00068677f, -0.02423208f, 
    0.00829834f, 0.01178672f, 0.00428284f, -0.02735602f, -0.01015436f, 0.01347378f, -0.03984595f, -0.00034369f, 
    -0.00593158f, 0.02746033f, -0.01558099f, 0.00656641f, -0.03243783f, -0.03552715f, -0.00299422f, -0.02205777f, 
    -0.04056993f, -0.00621053f, 0.00147994f, -0.01097026f, 0.01435403f, -0.00500136f, -0.01756848f, 0.02106676f, 
    -0.03502474f, 0.02499127f, -0.02609891f, -0.01814339f, 0.02028560f, -0.01035612f, -0.01446958f, -0.02766429f, 
    0.00937948f, 0.01868747f, -0.01753687f, 0.02062595f, 0.00463182f, -0.00604268f, 0.03216346f, -0.01874155f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01659918f, -0.01680410f, -0.02016521f, 0.00649210f, -0.04747808f, -0.01346564f, 0.03177257f, 0.05046153f, 
    0.06262956f, -0.02213578f, 0.05337065f, -0.01711171f, 0.06700414f, 0.02621945f, -0.01014653f, 0.00110245f, 
    -0.03902695f, -0.01222317f, 0.00010965f, -0.03609195f, -0.01568271f, 0.05705729f, -0.02467761f, 0.00644363f, 
    -0.04088375f, 0.02312915f, 0.04745870f, 0.01048901f, 0.02987895f, -0.02519281f, 0.00804565f, -0.03496232f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.18188056f, -0.14244583f, 0.05369829f, -0.13206412f, 0.15903103f, -0.03253973f, -0.15893672f, -0.55070364f, 
    -0.23575899f, 0.02400100f, -0.64189875f, -0.16816986f, 0.08553693f, -0.11204323f, 0.33365059f, 0.04153502f, 
    -0.15786527f, 0.31146261f, -0.09658815f, -0.08050447f, 0.16664745f, 0.27199087f, -0.02882652f, -0.13912685f, 
    -0.00231226f, -0.01502747f, -0.17005233f, 0.06056276f, -0.10493387f, -0.09552049f, 0.01420346f, -0.11275575f, 
    0.08273900f, -0.14949104f, 0.10315144f, 0.12454263f, -0.26186451f, 0.16872336f, -0.12493447f, 0.22761172f, 
    0.23698519f, 0.01153739f, -0.72199571f, -0.07186471f, 0.01822171f, 0.10589742f, 0.28560457f, 0.10451283f, 
    0.12408239f, 0.05748675f, -0.04172362f, -0.01430155f, 0.05644725f, -0.41438624f, 0.03535346f, -0.06534237f, 
    -0.16303222f, 0.00955125f, 0.23012838f, -0.07576617f, -0.03242694f, -0.11958844f, 0.03445151f, 0.05566909f, 
    -0.12837288f, -0.12007016f, -0.16940032f, 0.08897681f, -0.28505814f, -0.12099423f, -0.07694936f, -0.17410059f, 
    0.49124855f, 0.17004615f, -0.03659838f, 0.02263103f, 0.28642681f, -0.12528250f, -0.06913000f, -0.14098549f, 
    -0.03763451f, 0.34193444f, -0.06562430f, 0.04112765f, 0.15075253f, -0.33509621f, 0.09298534f, -0.15404780f, 
    0.03423633f, 0.11610477f, -0.56138098f, 0.03028720f, 0.11830191f, -0.15428825f, 0.04550559f, -0.01475634f, 
    -0.11070230f, -0.02730579f, -0.07298662f, 0.15131520f, -0.01837485f, 0.16125540f, 0.11166964f, -0.06492282f, 
    -0.45184708f, -0.17989841f, -0.15420476f, 0.08437715f, -0.66052198f, -0.06706309f, 0.01090520f, 0.09233746f, 
    0.02881281f, 0.41567442f, 0.13399468f, -0.02915734f, 0.01309445f, 0.28679115f, -0.15213576f, 0.13912573f, 
    0.09564168f, 0.01888280f, 0.27630505f, -0.06388224f, -0.16223480f, -0.15515949f, -0.14051735f, 0.02317552f, 
    -0.10675469f, -0.05657654f, -0.02845556f, 0.05720653f, 0.25611085f, -0.02158747f, -0.07950790f, -0.03050268f, 
    -0.80046922f, -0.14160852f, 0.24455617f, 0.28541973f, 0.02474364f, 0.10864741f, -0.01396553f, 0.13722958f, 
    0.06888304f, 0.01980664f, -0.13310346f, -0.16255511f, -0.05592588f, -0.04357125f, 0.03744515f, 0.09711700f, 
    -0.12137623f, -0.08684320f, -0.23696835f, -0.10509068f, 0.05093044f, 0.03022456f, -0.04898389f, -0.12320462f, 
    0.15184352f, -0.14263177f, -0.14264300f, -0.17684767f, 0.23976190f, -0.08482565f, 0.10197631f, 0.19826779f, 
    -0.47368863f, -0.10717145f, -0.24548021f, -0.35793889f, 0.22238471f, 0.03823332f, 0.00876258f, 0.09593010f, 
    -0.12542848f, -0.60796797f, -0.06252012f, 0.02634466f, -0.15798303f, -0.01084039f, -0.08007894f, -0.11794865f, 
    0.09493182f, 0.17164573f, 0.38788965f, 0.01838247f, -0.15035333f, 0.00257636f, -0.18048391f, 0.11364238f, 
    -0.16431601f, -0.13693093f, 0.13383260f, -0.13320440f, 0.17471446f, -0.07885334f, 0.07553953f, 0.42146450f, 
    0.25554597f, 0.00566439f, 0.09543046f, -0.88063216f, -0.09226623f, 0.05576664f, 0.13987842f, -0.02357414f, 
    0.10307610f, 0.15786366f, -0.08842264f, 0.09722801f, 0.15972456f, -0.15084411f, 0.11979179f, -0.02956427f, 
    0.04595720f, -0.14273389f, -0.23359625f, -0.14227638f, -0.07028890f, -0.06766984f, 0.05868969f, 0.05399195f, 
    -0.03383736f, -0.16271554f, 0.14939116f, 0.12431768f, 0.37294742f, 0.12392189f, -0.12216318f, 0.05342005f, 
    0.20257477f, -0.10033654f, 0.13401523f, -0.09988202f, -0.35316417f, 0.04114797f, -0.65777367f, -0.10825524f, 
    -0.07127623f, 0.25400096f, 0.15347457f, 0.04293350f, -0.06438425f, -0.38201946f, 0.11145889f, 0.02098433f, 
    0.08197959f, -0.02602353f, 0.18871103f, 0.02033480f, 0.07073381f, 0.02918011f, -0.14294788f, -0.07785629f, 
    -0.08133768f, -0.00069823f, -0.00086397f, -0.11717482f, -0.27776566f, -0.08161487f, 0.12750413f, 0.32015041f, 
    0.15386061f, 0.08309563f, -0.44305539f, 0.55935067f, 0.17876968f, -0.16856900f, -0.35990617f, -0.03250198f, 
    0.00218841f, -0.57478738f, -0.16001970f, 0.16345410f, -0.00707705f, -0.03846360f, 0.01566266f, -0.14631255f, 
    -0.08069342f, -0.08382288f, 0.09743295f, 0.10741191f, 0.08786473f, -0.00993770f, 0.08105039f, 0.09901248f, 
    0.01241357f, -0.02472710f, -0.11694393f, 0.04379695f, 0.23163062f, 0.08168393f, 0.07338553f, -0.72435248f, 
    0.25356561f, 0.00011465f, 0.44873405f, -0.31433019f, 0.13668995f, 0.12979920f, -0.01746584f, 0.04296542f, 
    -0.13402373f, -0.26587212f, -0.12520438f, 0.01423846f, -0.02271821f, -0.50623798f, 0.00057239f, 0.12737104f, 
    -0.15911077f, 0.06711392f, -0.03113983f, -0.04091593f, 0.07671322f, 0.00965422f, 0.12010531f, -0.05619394f, 
    0.10660390f, 0.16043574f, -0.07681957f, -0.03416182f, -0.23566619f, 0.11684720f, 0.09466270f, -0.17042059f, 
    0.25245139f, -0.13091014f, -0.03029139f, -0.47674048f, 0.13902336f, 0.08625455f, -0.39319354f, -0.12754804f, 
    0.14765050f, 0.06754684f, 0.16302489f, 0.03153101f, 0.13521370f, 0.30765647f, 0.14142977f, 0.11151685f, 
    -0.00510884f, 0.16390443f, 0.40619570f, 0.13023505f, 0.12671262f, 0.15018953f, 0.11025716f, -0.17121717f, 
    0.04670374f, 0.12629944f, -0.00529488f, -0.08156840f, -0.23520473f, 0.05955109f, 0.12693559f, 0.37145439f, 
    0.14444935f, -0.04376452f, 0.35094059f, 0.17643158f, -0.39270741f, 0.00720410f, -0.00703625f, -0.14201359f, 
    -0.16587739f, -0.38929981f, 0.13758539f, 0.00290755f, -0.04613631f, 0.32433423f, 0.02300547f, 0.08454306f, 
    -0.06440946f, -0.17656706f, -0.08040410f, 0.08305895f, 0.07434259f, 0.13729574f, -0.07653558f, 0.07933328f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.20922774f, 0.11334605f, -0.22088321f, 0.09735053f, 0.11877730f, 0.12632984f, -0.03029793f, -0.08240771f, 
    0.09433510f, 0.17444056f, 0.03193870f, -0.19391066f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
