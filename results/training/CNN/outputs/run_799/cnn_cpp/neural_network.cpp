#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.82003510f, 0.79137433f, 0.56192428f, -0.56376058f, -0.65019280f, 0.69032001f, 0.10762377f, 0.42348659f, 
    0.29325387f, 0.37935552f, 0.95336652f, -0.95931220f, 0.14903481f, 0.23767647f, 0.43624574f, 0.58370715f, 
    -0.09407803f, 0.57147539f, -1.13951981f, 0.93295199f, 0.19519046f, -0.48626521f, -0.41834092f, -1.06947076f, 
    -0.05710277f, 0.44434583f, 0.02524799f, -0.19016099f, -0.78806955f, 0.20111103f, 0.51932418f, -0.15909334f, 
    -0.71633607f, 0.64962173f, -0.60191941f, -0.58674276f, 0.61567450f, 0.19310533f, -0.39592007f, -0.90870488f, 
    0.72063386f, 0.59238982f, -0.45419043f, -0.09731267f, 0.28370214f, 0.78833544f, 0.57041532f, 0.32021824f, 
    0.45434195f, 0.52536076f, 0.46921411f, -0.82722032f, -0.14715852f, -0.62670016f, 0.66654569f, 0.32531139f, 
    0.72992176f, 0.40523231f, 0.52609509f, 0.09386718f, -0.43791428f, 0.28198323f, 0.56840909f, -0.75960529f, 
    0.17131287f, -0.11440595f, -0.36384970f, 0.57606113f, -0.82161522f, -0.68139994f, 0.43707058f, 0.60386086f, 
    -0.44262648f, -0.40180126f, -0.84248984f, 0.53568649f, 0.18121485f, 0.67428452f, 0.09286886f, -0.04403382f, 
    -0.48735529f, -0.77820784f, -0.08525737f, -0.49369347f, 0.93967289f, -0.78882527f, 0.08129257f, 0.41102821f, 
    -0.16556156f, 0.49155772f, 0.24434108f, -0.47486690f, 0.52448648f, -0.59580028f, -0.41758129f, -0.85920870f, 
    -0.22548586f, -0.54933321f, -0.19170986f, -0.55800909f, -0.92728782f, -0.74649346f, -0.85675389f, 0.16956696f, 
    0.39958519f, 0.14142564f, 0.20163046f, 0.15940195f, -0.47585806f, -0.54022294f, -0.54275525f, -0.14450891f, 
    0.59373665f, -0.37386301f, -0.34369192f, -0.05706020f, -0.77976030f, -0.66615671f, -0.75601429f, -0.71546429f, 
    0.54961360f, 0.71818668f, -0.04707224f, -0.17843017f, -0.10264725f, 0.36488113f, -0.75006253f, -0.49088967f, 
    -0.00807877f, -0.38211536f, -0.35524303f, 0.05175927f, -0.55088955f, -0.42132419f, -0.51980805f, -0.49603570f, 
    0.47021329f, 1.00002921f, 0.34048280f, 0.97042078f, -0.61822242f, 0.10256918f, 0.14630164f, -0.09390470f, 
    -0.22942613f, -0.74258643f, -0.66008949f, 0.55714208f, -0.67407691f, 0.67096013f, -0.44845048f, -0.07742371f, 
    -0.10821366f, 1.03821123f, 0.52759385f, 0.26012248f, 0.05171973f, 0.59729165f, 0.46116447f, -0.02270323f, 
    -0.28632867f, 0.38336542f, 0.84875399f, -0.23107584f, -0.71158510f, 0.81873673f, -0.15408449f, -0.34430137f, 
    -0.22899561f, -0.36005405f, 0.08996671f, 0.43381262f, -0.97128439f, 0.88776058f, 0.11393100f, -0.69600528f, 
    0.74890524f, -0.28083208f, -0.45517653f, -0.19260810f, 0.44637764f, 0.75490898f, -0.15167834f, -0.98495388f, 
    -0.68289721f, -1.12133932f, 0.34021157f, -0.75055248f, -0.03665056f, -0.93067807f, -0.93915719f, 0.46590492f, 
    -0.41197112f, -0.22150162f, 0.65821391f, 0.54460227f, -0.17905483f, 0.16103630f, 0.96289903f, 0.93957794f, 
    -0.34551871f, 0.07741950f, 0.56833643f, -0.64730990f, -0.06336579f, 0.11177634f, -0.32597926f, 0.28095645f, 
    0.17985164f, 0.64423168f, 0.12968728f, -0.91348958f, -0.40936172f, 0.52346873f, 0.02638401f, 0.49871442f, 
    0.10403278f, -0.72401160f, 0.18918440f, 0.95413148f, 0.49276569f, 0.59702212f, -0.12008926f, -0.63705122f, 
    0.10524793f, 0.09104833f, -1.02562726f, 0.19712843f, -0.27654326f, -0.82897508f, 0.02247076f, -0.29152563f, 
    0.71269697f, 0.13693739f, 0.11301272f, -0.49621239f, 0.06624819f, -0.91585761f, 0.07077642f, 0.36939746f, 
    0.39598754f, 0.25863653f, 0.48497534f, 0.05749248f, 0.63755882f, 0.87443107f, -0.92663145f, 0.62600762f, 
    0.00185767f, 0.11432379f, 0.36925220f, 0.37437055f, -1.15706718f, 0.12180050f, 0.01797057f, 0.45393237f, 
    1.09922111f, 0.84228122f, -0.02420182f, -0.20576729f, -0.49193275f, 0.70248026f, 0.24428205f, 0.80458903f, 
    0.49136475f, -0.04098391f, -0.30008340f, 0.34588546f, 0.50222635f, 0.01589043f, 0.41101572f, 0.10223705f, 
    0.20694830f, 0.77544242f, 0.25676286f, 0.42370796f, -0.67430937f, 0.46290851f, 0.12678173f, 0.98495078f, 
    0.80067235f, 0.84827107f, -0.01382410f, -0.41222769f, -0.20638230f, -0.56728882f, 0.07902713f, -0.27170879f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07019063f, -0.39363870f, 0.27277386f, -0.17982620f, 0.08662977f, -0.06761949f, -0.12170108f, 0.23996165f, 
    -0.04171754f, 0.01466448f, 0.23026752f, 0.18662612f, -0.22203030f, -0.03838086f, -0.33882061f, 0.08085562f, 
    -0.22062646f, -0.42820716f, 0.04817754f, 0.11532278f, 0.07413674f, -0.03126624f, -0.15932706f, -0.13735734f, 
    0.05136248f, -0.12279943f, 0.13969730f, -0.12834769f, 0.01869679f, 0.31873065f, 0.29317874f, 0.11053369f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.33950296f, 0.05326254f, 0.09458795f, -0.17414580f, 0.04305190f, 0.12348238f, -0.10821164f, -0.07590424f, 
    0.07922564f, -0.30887344f, -0.20924793f, -0.35886663f, -0.12726079f, -0.14432363f, 0.00312263f, -0.12968239f, 
    -0.07511571f, -0.31688762f, -0.06188987f, -0.02264603f, -0.01753050f, 0.04203061f, 0.06735843f, 0.09927163f, 
    -0.08866341f, 0.06956360f, 0.14470734f, -0.10979231f, -0.15464368f, -0.18212429f, 0.06310530f, -0.06630756f, 
    -0.09647781f, 0.09573264f, 0.08102158f, 0.21717653f, 0.20605047f, -0.11686995f, -0.09939220f, -0.26164541f, 
    0.05921663f, -0.07069771f, 0.08852645f, -0.10420279f, 0.02881198f, 0.18215442f, 0.22610421f, 0.20238695f, 
    0.18586621f, 0.08811277f, -0.12589401f, 0.09914882f, 0.13717073f, -0.00334269f, -0.26553193f, -0.09602175f, 
    -0.03291966f, -0.04190338f, 0.15921196f, -0.11962360f, 0.18873017f, -0.07850858f, -0.05301408f, 0.07121141f, 
    -0.26960674f, 0.03334360f, 0.15441394f, -0.09450141f, 0.11335422f, 0.11626595f, 0.02857701f, 0.09387343f, 
    -0.09822140f, 0.16834672f, -0.09449998f, 0.14843307f, 0.14093024f, -0.02706494f, 0.00974008f, 0.07767910f, 
    -0.04598321f, -0.60281760f, -0.25791353f, 0.05781607f, 0.11964582f, 0.07050212f, 0.15709771f, -0.01729761f, 
    -0.06740510f, 0.06670051f, 0.08121393f, 0.12078070f, 0.13359395f, -0.01720936f, 0.15863527f, 0.03891743f, 
    -0.09269460f, 0.12673347f, 0.15985398f, -0.33927763f, -0.20069842f, 0.08923439f, 0.18446465f, 0.13302217f, 
    0.13757128f, -0.06602959f, -0.15953194f, 0.11458837f, -0.09652346f, 0.07311516f, 0.10077209f, 0.09391176f, 
    0.14429365f, 0.22167112f, -0.14327054f, -0.05765784f, -0.10171340f, -0.52570927f, -0.12822199f, -0.28106481f, 
    0.27459162f, -0.05888585f, -0.00634938f, -0.14411324f, 0.04961187f, -0.01947405f, 0.18423054f, 0.05217571f, 
    0.04220385f, 0.16527840f, -0.06566115f, -0.02287552f, -0.08016849f, 0.08686562f, 0.00718020f, -0.23543809f, 
    -0.21548185f, 0.19205107f, 0.00086337f, -0.03368878f, -0.12572482f, 0.18987206f, -0.06713221f, -0.07863797f, 
    0.00379601f, -0.14964999f, 0.00522722f, 0.11814131f, -0.04667706f, -0.00038914f, -0.20354246f, 0.03293717f, 
    0.03669927f, -0.26969796f, -0.06587909f, -0.06460091f, -0.02280229f, 0.03732754f, -0.09142797f, 0.01542767f, 
    -0.12975182f, -0.11105718f, 0.18946114f, -0.01245522f, -0.03488798f, 0.12849797f, -0.23064159f, -0.13413371f, 
    -0.00032898f, 0.00165065f, 0.07646585f, 0.23352291f, -0.11487070f, 0.05223637f, -0.06886367f, -0.07181396f, 
    0.10101981f, -0.09329876f, -0.17979337f, -0.00587485f, 0.09607814f, 0.22602332f, 0.26815981f, -0.17407405f, 
    0.00845515f, 0.06911565f, 0.02419920f, 0.07866549f, 0.19640166f, -0.18921824f, -0.21388924f, -0.16185991f, 
    0.16026892f, 0.04406726f, 0.03298601f, 0.10675657f, 0.04267412f, -0.00293007f, -0.31252778f, 0.15689214f, 
    -0.02738238f, -0.14249155f, -0.06664957f, -0.08318060f, -0.00672921f, -0.08217569f, -0.16147114f, 0.00325112f, 
    -0.01464799f, 0.03072062f, -0.02284812f, 0.01963940f, -0.25922769f, 0.04302231f, -0.20728076f, -0.23853266f, 
    0.32719034f, -0.01483912f, -0.28860044f, 0.05624745f, -0.03974997f, -0.11416596f, 0.03718187f, 0.03527163f, 
    -0.09328447f, 0.05363034f, -0.46184909f, 0.05996276f, 0.06624664f, -0.01728205f, 0.03056369f, 0.18698283f, 
    0.01186770f, 0.05232770f, -0.12259385f, 0.07357945f, -0.20233068f, -0.20102660f, -0.14666447f, 0.18805465f, 
    0.09577978f, -0.18988208f, 0.08741691f, -0.14918926f, -0.02387262f, -0.08345480f, -0.13448982f, 0.12186507f, 
    0.08797463f, 0.01411193f, -0.02484716f, 0.06736711f, -0.04821444f, 0.06807667f, -0.18826519f, -0.04711887f, 
    0.21089271f, 0.16498390f, 0.05075963f, 0.01595705f, 0.11873801f, 0.05001257f, 0.11874531f, 0.26860926f, 
    -0.12272403f, 0.21450195f, -0.03728400f, 0.13075541f, -0.00554649f, -0.04475729f, -0.09206382f, 0.03465049f, 
    -0.00080337f, 0.03754775f, -0.03578830f, 0.15835553f, 0.10178566f, -0.04666198f, -0.09187339f, 0.13969865f, 
    0.22197247f, 0.33126640f, -0.08027904f, 0.13871244f, -0.04232979f, -0.13450490f, 0.20249972f, -0.04873824f, 
    -0.23153752f, 0.03404403f, -0.06073596f, -0.05663295f, -0.14177984f, 0.04062979f, -0.12277335f, -0.06734727f, 
    0.18489924f, 0.35712156f, -0.25853756f, -0.05927898f, 0.16404802f, -0.11991361f, -0.16518766f, -0.01231503f, 
    -0.13205490f, -0.19655386f, -0.37463364f, -0.05187533f, -0.55586439f, 0.08446214f, -0.05711269f, 0.17749633f, 
    0.06740861f, -0.00435133f, 0.06254927f, -0.25568643f, -0.42359492f, 0.00377700f, 0.03030466f, 0.04250341f, 
    0.09512647f, -0.10611490f, 0.18006191f, -0.28819934f, -0.03574875f, -0.00622718f, -0.14347836f, 0.08052351f, 
    -0.30494958f, 0.06071523f, 0.06038572f, 0.06975194f, 0.01724864f, 0.20948116f, 0.22415240f, -0.04821301f, 
    -0.06019647f, -0.02177905f, 0.07953360f, -0.00586913f, 0.23181872f, -0.06089642f, 0.10819888f, 0.26399955f, 
    -0.00658277f, 0.02235319f, -0.01657790f, -0.05753015f, 0.14069030f, -0.01654318f, 0.13362511f, -0.15907837f, 
    0.03303132f, -0.37868881f, 0.09039120f, 0.33581507f, 0.05855662f, 0.12665334f, 0.04271592f, -0.00806611f, 
    0.36538377f, -0.02595232f, -0.13580568f, 0.15394309f, 0.07354578f, -0.10095304f, 0.09295980f, -0.04117687f, 
    0.04625966f, 0.04258358f, 0.35712829f, -0.31544822f, 0.24136086f, 0.10704842f, -0.08030422f, 0.04460663f, 
    0.01108395f, -0.20466545f, -0.20364578f, -0.17236511f, -0.27833349f, 0.12839147f, 0.05385928f, 0.01177069f, 
    0.18548305f, -0.05559867f, 0.28392148f, 0.40193865f, -0.23737530f, 0.18325476f, -0.08433712f, 0.02377786f, 
    0.06068880f, 0.06374384f, 0.04425267f, 0.01506308f, 0.21722820f, -0.37110358f, -0.02603711f, 0.14349988f, 
    -0.00076727f, 0.12636703f, -0.08477187f, -0.03105563f, -0.03730261f, 0.31423694f, 0.04718671f, -0.10518183f, 
    0.05221821f, 0.01132099f, -0.09038959f, 0.00700191f, 0.06148930f, 0.00500823f, -0.05456193f, -0.31337062f, 
    -0.31507567f, -0.05254548f, 0.05157951f, 0.21640421f, 0.06523731f, 0.17608544f, -0.18345663f, -0.45045575f, 
    0.00465141f, 0.27714148f, -0.16891000f, 0.17458411f, 0.09910583f, -0.04114055f, -0.02716704f, -0.06700991f, 
    0.04267859f, 0.03359858f, -0.01039226f, -0.02447216f, -0.01432511f, 0.09960295f, -0.01719350f, -0.03606923f, 
    0.22552662f, -0.10327223f, 0.06269810f, -0.13413261f, -0.08823933f, -0.00459986f, 0.06008289f, 0.02961001f, 
    0.04195780f, 0.08795913f, -0.36456808f, -0.72165424f, -0.03825074f, 0.02577664f, 0.08079308f, -0.10743356f, 
    -0.20667043f, 0.05737232f, -0.17910190f, -0.41077513f, 0.08142396f, -0.07507394f, 0.19590349f, 0.25427100f, 
    -0.08947504f, 0.12750112f, -0.00405262f, 0.04803949f, -0.12011329f, 0.03682413f, -0.19669676f, -0.08108470f, 
    -0.05476949f, 0.08367945f, -0.02418654f, 0.16586725f, 0.20561704f, -0.06139996f, 0.11008295f, 0.15378259f, 
    0.07001594f, -0.17019095f, -0.14663260f, 0.00573993f, -0.10637204f, -0.07064078f, 0.14019684f, -0.33418497f, 
    0.14728387f, -0.26551354f, 0.02937470f, 0.09073650f, -0.03652762f, 0.02156102f, -0.06957547f, -0.14597017f, 
    0.17198817f, 0.22696780f, -0.14210920f, -0.09539098f, -0.11563521f, -0.01450094f, -0.06773323f, -0.03061402f, 
    -0.09513254f, 0.34863332f, 0.19412822f, 0.15558363f, 0.17423688f, -0.01460788f, 0.06987161f, 0.06354445f, 
    -0.10135707f, -0.02616706f, -0.16595270f, 0.19053553f, 0.01390239f, 0.16243653f, 0.25099674f, -0.23095883f, 
    -0.01620819f, 0.03756346f, -0.14556861f, -0.21855718f, -0.03149160f, -0.04767685f, 0.13594422f, 0.03320096f, 
    0.06981391f, -0.02289694f, -0.10448783f, -0.00992195f, 0.18844754f, -0.21812193f, -0.09191427f, -0.10755838f, 
    -0.00252547f, -0.19208805f, -0.02376050f, -0.17043427f, 0.06871429f, 0.12659602f, -0.22451411f, 0.09259041f, 
    0.09244612f, 0.04472237f, 0.16816792f, 0.10512341f, -0.03728125f, -0.13625084f, -0.01960342f, 0.18039314f, 
    0.03001755f, 0.03296053f, -0.03676424f, -0.01735620f, -0.10678222f, 0.04086135f, 0.31658214f, 0.17174122f, 
    -0.04312963f, -0.09937073f, 0.14022592f, -0.06734725f, 0.07237022f, 0.02748382f, 0.18230227f, 0.01488191f, 
    -0.09270050f, 0.07299057f, 0.00919884f, -0.03807373f, 0.02264194f, -0.10593817f, -0.21364747f, -0.06557872f, 
    0.00598034f, -0.01300531f, -0.05035175f, 0.00648281f, 0.00405722f, -0.03937628f, -0.03585980f, -0.05581437f, 
    0.02785551f, 0.03607761f, -0.00003037f, -0.05375056f, 0.01542929f, -0.03584085f, 0.00922113f, 0.02829508f, 
    -0.05142454f, -0.05121561f, -0.04919820f, 0.04212062f, -0.06371787f, -0.04480134f, -0.03482759f, 0.01609349f, 
    -0.02405565f, -0.00097028f, -0.00529979f, 0.04604411f, 0.02813040f, -0.05356596f, -0.04407208f, -0.00594742f, 
    -0.02078477f, 0.03861282f, 0.03890258f, 0.00031023f, -0.02972522f, 0.01427592f, -0.01289814f, 0.00467664f, 
    -0.03718656f, -0.06331465f, 0.04987677f, -0.01529679f, -0.04416135f, 0.01376585f, 0.03135257f, 0.01326244f, 
    0.03058965f, -0.03652504f, 0.04811079f, 0.01271821f, -0.00720745f, 0.02928642f, -0.01779558f, -0.00978175f, 
    -0.01267010f, -0.03141447f, 0.01961979f, -0.01962870f, -0.00276090f, 0.02319637f, 0.02200641f, 0.03515893f, 
    -0.04429901f, -0.03440053f, -0.04943496f, -0.02331012f, -0.02661723f, -0.04131124f, 0.05281957f, -0.00807864f, 
    -0.06399016f, -0.03254521f, -0.03286242f, 0.05438486f, -0.01319516f, -0.01695445f, -0.00794625f, -0.00951127f, 
    0.02170061f, -0.05168049f, -0.03224349f, 0.04747735f, -0.03549012f, -0.05367414f, 0.00760596f, 0.04316033f, 
    0.01109620f, 0.01389639f, -0.05542461f, -0.02310501f, 0.01914983f, 0.00891934f, 0.03141534f, -0.00729960f, 
    -0.02670220f, -0.00296810f, -0.01836357f, 0.02612897f, -0.01861982f, -0.01099550f, 0.01418766f, -0.05283904f, 
    0.01108976f, -0.05320732f, -0.02853626f, -0.00394752f, -0.04725012f, 0.05176663f, -0.03838522f, 0.01594439f, 
    -0.04669265f, 0.02615564f, 0.00671515f, 0.03302128f, 0.01025291f, -0.03349013f, 0.00198162f, 0.03119097f, 
    0.02864644f, -0.02861461f, 0.04436154f, -0.00300263f, 0.05280828f, 0.01903711f, -0.01310373f, 0.03882167f, 
    -0.01510271f, -0.01901020f, 0.04067177f, 0.04928574f, 0.00739744f, -0.05967845f, -0.02125639f, 0.04085402f, 
    0.04650471f, -0.05854698f, 0.00410391f, -0.03702908f, -0.06632984f, 0.02502133f, -0.02459199f, -0.05002858f, 
    0.02576267f, 0.05749454f, -0.02374340f, -0.04429197f, -0.04721257f, -0.00803623f, 0.03383583f, -0.01342099f, 
    -0.06079202f, 0.04385196f, -0.03841863f, 0.01292777f, 0.02630471f, 0.03961762f, 0.03655267f, -0.03323405f, 
    -0.06013897f, 0.00330155f, -0.00061248f, -0.05929316f, 0.03178906f, 0.01450658f, -0.02360363f, -0.03700269f, 
    0.04583580f, -0.02923513f, -0.01224540f, 0.01818591f, -0.03297046f, -0.03733673f, -0.01713006f, 0.00599810f, 
    -0.04805852f, 0.02172186f, 0.04119597f, -0.06162811f, 0.01203295f, -0.01136213f, 0.03229921f, 0.00691025f, 
    -0.03327746f, -0.01280645f, 0.00144190f, 0.02971583f, -0.03607129f, 0.03551783f, -0.05000095f, -0.05437247f, 
    -0.03047272f, -0.01154526f, 0.04893248f, -0.04665626f, 0.04754746f, 0.02517997f, 0.01579960f, -0.01527932f, 
    -0.02988983f, -0.02316534f, -0.01635698f, 0.00243016f, -0.03377773f, -0.04144980f, 0.04516266f, -0.02930630f, 
    0.03072724f, -0.00873731f, -0.06637386f, -0.02150925f, 0.04943074f, -0.03232259f, 0.05436543f, -0.05588982f, 
    0.00070279f, 0.01100821f, -0.00773416f, -0.02796665f, 0.04717156f, -0.01139020f, 0.01209250f, -0.05904716f, 
    -0.06015179f, 0.03484690f, -0.02033712f, -0.03301731f, -0.04330119f, 0.01189286f, -0.00913408f, 0.00579147f, 
    -0.00816289f, 0.03423922f, -0.06312368f, 0.00697460f, -0.02461937f, 0.04655654f, 0.00507144f, 0.05458922f, 
    0.03553507f, -0.02504819f, -0.03719880f, 0.03858683f, 0.02487062f, 0.01724494f, -0.04621461f, -0.01819852f, 
    -0.03245124f, 0.04850888f, 0.03069009f, 0.02162296f, 0.00088468f, -0.00013445f, -0.00658091f, -0.01700139f, 
    0.02699112f, -0.05864303f, -0.01226361f, 0.00498588f, 0.03084870f, -0.03765718f, 0.00760833f, -0.01579703f, 
    0.00927837f, -0.03239598f, -0.01880656f, 0.00731691f, 0.00472514f, 0.02887962f, -0.00690770f, -0.02287101f, 
    0.01017950f, -0.03217661f, 0.02771950f, 0.03231737f, -0.04594311f, 0.03992680f, -0.04154318f, -0.06465305f, 
    0.01554246f, 0.01115083f, 0.03284575f, -0.04788497f, 0.00057410f, -0.03870069f, -0.05418766f, -0.04439188f, 
    -0.02215248f, 0.08155663f, -0.21200353f, 0.28149870f, -0.15592098f, 0.05191995f, 0.08049285f, -0.06570539f, 
    -0.06107862f, -0.04157885f, 0.35551348f, -0.10929275f, 0.05727752f, -0.10360932f, 0.11978602f, -0.09632883f, 
    -0.00256595f, 0.06338049f, -0.12254041f, 0.04243448f, -0.03862250f, -0.05411394f, -0.00333520f, -0.16083391f, 
    0.14631280f, -0.08742297f, 0.09015379f, -0.12337740f, -0.09768835f, 0.27165425f, 0.16926789f, -0.20253137f, 
    -0.11878749f, 0.10958437f, 0.13242634f, -0.02228930f, 0.05171299f, -0.07965158f, 0.06482608f, 0.16967617f, 
    -0.04775357f, 0.12141770f, -0.05862898f, 0.02309792f, 0.10502914f, -0.02418667f, -0.20018087f, 0.00669147f, 
    0.15709174f, 0.18831863f, 0.07032796f, 0.08679593f, 0.18261212f, -0.10512289f, 0.10443439f, -0.15080960f, 
    -0.05735699f, 0.08572292f, 0.02688584f, 0.04784713f, -0.17688744f, 0.18849424f, 0.01244815f, -0.18126477f, 
    -0.13225856f, 0.02784070f, 0.00236078f, -0.04300680f, 0.19693317f, 0.01950419f, -0.00232290f, -0.18773407f, 
    0.02471959f, 0.01819599f, 0.22827177f, -0.11771532f, 0.13826391f, -0.28798899f, 0.06732278f, -0.04877440f, 
    0.03536618f, -0.27266786f, 0.02905950f, -0.02951383f, 0.05524713f, -0.13895169f, -0.11785818f, 0.11083183f, 
    -0.12252351f, -0.06505683f, -0.17159505f, -0.31959891f, -0.14967243f, -0.04271021f, -0.01850613f, -0.08735326f, 
    -0.06479005f, 0.14538106f, 0.07146844f, -0.17421763f, 0.14142376f, 0.42448342f, -0.23003668f, 0.11535707f, 
    -0.10128981f, 0.01156521f, 0.08163109f, 0.04799784f, -0.04808037f, -0.01702216f, 0.23688555f, -0.19537680f, 
    0.04454094f, 0.09932940f, -0.11541328f, 0.14278139f, -0.24285409f, -0.01091060f, -0.03547697f, 0.21630296f, 
    -0.00516834f, -0.23970102f, 0.05703001f, -0.24384980f, 0.04157795f, -0.06472633f, 0.21353053f, -0.29793265f, 
    0.10240591f, 0.11450245f, -0.03945116f, -0.17928293f, -0.01261612f, 0.09928186f, 0.09961178f, 0.04714773f, 
    0.16345447f, -0.24400496f, 0.17824529f, 0.00629619f, 0.10288329f, 0.11846207f, -0.03989911f, 0.13533089f, 
    0.04329059f, -0.14696249f, 0.26529509f, 0.11269455f, 0.02309055f, -0.08586177f, -0.05957368f, -0.05270410f, 
    0.00373903f, -0.09542077f, -0.25868574f, -0.03488174f, 0.08962469f, 0.02111141f, 0.07723594f, 0.04564310f, 
    -0.08445547f, -0.20686731f, 0.16829142f, 0.20461412f, 0.27967480f, -0.29511815f, 0.20392935f, -0.10514699f, 
    0.03618925f, 0.00459437f, 0.04977235f, 0.00036433f, -0.02793261f, -0.35365108f, 0.03594871f, 0.06425907f, 
    0.22498658f, 0.07224744f, 0.23347996f, -0.17682183f, -0.20892024f, -0.10640568f, -0.41288742f, 0.13174698f, 
    -0.08661778f, 0.03433988f, -0.02605716f, 0.15843667f, -0.03078442f, -0.10470682f, -0.08130120f, 0.20078662f, 
    0.22550015f, 0.16243120f, 0.10143466f, 0.08019376f, -0.02053289f, 0.07481506f, -0.17616810f, -0.05469153f, 
    0.16175735f, 0.21797317f, 0.11564613f, -0.09498620f, -0.03051361f, 0.00459196f, -0.03647428f, 0.26630828f, 
    -0.05942796f, -0.16466439f, 0.15778798f, -0.02219042f, 0.01859898f, 0.05276152f, -0.18511103f, 0.01749620f, 
    0.11951539f, -0.08357166f, 0.01582225f, -0.08730546f, 0.06606356f, -0.00818833f, 0.16876602f, 0.09558727f, 
    0.06826919f, 0.00875721f, -0.16422366f, -0.06321516f, 0.05930047f, -0.18311955f, -0.18247823f, 0.07354780f, 
    -0.00998024f, -0.04590512f, -0.03840936f, 0.18463147f, -0.11626441f, -0.26932895f, -0.04661736f, 0.09496525f, 
    0.05955406f, -0.12645017f, 0.20753574f, -0.04267180f, -0.15781774f, -0.03064466f, 0.00137691f, 0.12705643f, 
    0.11582100f, -0.09536287f, 0.03070870f, 0.06577465f, 0.05100393f, 0.07328717f, 0.08225113f, -0.21945137f, 
    -0.24254705f, -0.03532434f, -0.03872326f, 0.19000049f, -0.04630079f, 0.13857880f, -0.10014318f, -0.06055038f, 
    0.04576647f, 0.04401269f, 0.06889597f, -0.06020717f, 0.08038527f, -0.00380482f, 0.13181777f, -0.03424093f, 
    0.00373463f, 0.14896633f, -0.12386756f, 0.24682671f, 0.07726417f, 0.27396998f, -0.15188280f, -0.20590340f, 
    -0.06177360f, -0.11289526f, 0.10738127f, 0.11949392f, 0.03892820f, 0.03127730f, 0.06006350f, -0.07072346f, 
    -0.06667592f, 0.05648603f, 0.10463721f, -0.04485919f, 0.14649263f, 0.02278343f, 0.02526239f, 0.07962976f, 
    -0.20208447f, -0.08858614f, -0.15333200f, 0.09247976f, 0.09086531f, 0.05695036f, 0.11102889f, -0.11411980f, 
    -0.15679103f, 0.09320427f, 0.47718909f, 0.51350075f, 0.04972947f, -0.05041287f, 0.02246444f, -0.06721351f, 
    -0.02195366f, -0.00017529f, 0.06588693f, -0.09675092f, -0.26451433f, 0.16016027f, 0.04504507f, 0.01722176f, 
    -0.07960670f, 0.09555008f, 0.11025113f, 0.05535543f, -0.15284364f, 0.14783868f, -0.03873700f, -0.08025496f, 
    0.07806270f, 0.14536837f, 0.21123977f, -0.12357532f, -0.14652944f, -0.21596064f, -0.13311969f, -0.10684209f, 
    0.02229868f, 0.12908188f, 0.13831709f, -0.00110423f, -0.07381176f, -0.16624610f, -0.37572658f, -0.20432575f, 
    -0.07181225f, 0.02605108f, 0.20235658f, 0.03294532f, -0.05442662f, 0.03949792f, -0.28552631f, -0.01024744f, 
    0.14235485f, 0.17693618f, 0.02008147f, -0.23994058f, -0.17508453f, 0.18054186f, -0.02267975f, -0.10061037f, 
    -0.17144397f, 0.05329802f, 0.18677609f, -0.01012229f, 0.01428838f, 0.14945017f, -0.09093024f, -0.10046503f, 
    0.12112366f, 0.06457023f, 0.06490605f, -0.03172821f, -0.04697257f, -0.03096140f, -0.20042780f, -0.17706968f, 
    0.16094866f, -0.09830519f, 0.18324733f, 0.05869914f, 0.14051613f, 0.32679987f, 0.02152664f, 0.00799645f, 
    0.04502605f, 0.25628701f, 0.06053732f, 0.00498790f, -0.07838327f, 0.18526046f, -0.13170607f, 0.02955497f, 
    -0.15567604f, 0.00085165f, -0.02398224f, 0.15341584f, -0.29160959f, -0.03696378f, -0.05266099f, -0.07990651f, 
    -0.18193638f, -0.00110169f, 0.08771458f, -0.06169103f, 0.44117501f, -0.00541642f, -0.23652150f, 0.30556527f, 
    -0.01113277f, -0.13096319f, -0.13981754f, 0.09419110f, 0.05662044f, 0.06256394f, -0.11481808f, -0.05405902f, 
    0.14573251f, -0.04948937f, 0.03477436f, 0.13663770f, 0.06300376f, -0.11120354f, 0.10499381f, 0.23759191f, 
    0.12460055f, 0.02516101f, 0.01174747f, 0.07909562f, 0.20077904f, -0.06033732f, -0.21241619f, -0.15881391f, 
    -0.11539498f, -0.06478658f, 0.29994881f, -0.09161481f, -0.03388251f, 0.12212049f, 0.04413497f, -0.10327912f, 
    0.10054702f, -0.07637381f, 0.03833910f, -0.10623642f, 0.15965840f, -0.07612178f, 0.23319520f, -0.07730378f, 
    -0.02490230f, -0.36298051f, 0.28782779f, -0.00827335f, 0.27086619f, -0.12761323f, 0.00923149f, 0.05082604f, 
    -0.12583330f, 0.16335721f, -0.08614726f, 0.32074347f, 0.02422928f, -0.09692454f, -0.04683209f, 0.10479671f, 
    0.16068120f, 0.11472782f, 0.07522468f, -0.19137570f, 0.10016613f, 0.02557613f, 0.03062578f, 0.42406765f, 
    0.22032374f, -0.19230160f, 0.08191419f, 0.02766535f, 0.08026063f, 0.24506763f, 0.05194798f, -0.05803639f, 
    -0.09898810f, -0.01634673f, -0.30573854f, 0.26569608f, -0.01615051f, 0.03521833f, 0.30639261f, 0.07891060f, 
    -0.01050525f, 0.14830916f, -0.09748504f, 0.05730061f, -0.02125891f, -0.16514951f, -0.16113740f, 0.04002720f, 
    0.03213339f, 0.05735353f, 0.02339851f, -0.03584523f, -0.30793625f, -0.05238827f, -0.00344518f, -0.18929093f, 
    -0.15291005f, -0.11925905f, -0.01502173f, -0.04259453f, 0.10677334f, -0.03208404f, -0.01038617f, -0.10741062f, 
    -0.04720846f, 0.31775996f, -0.04832992f, -0.07019597f, -0.03557836f, -0.23765200f, -0.11319043f, 0.11088858f, 
    -0.03002220f, 0.16427857f, 0.04214864f, -0.02676417f, 0.04114886f, -0.08500300f, 0.07107939f, -0.03315091f, 
    0.00492555f, 0.15519804f, -0.02225944f, -0.01680265f, 0.16802581f, 0.23660931f, -0.00020218f, 0.05660981f, 
    0.09539753f, 0.01563856f, -0.09460387f, -0.22890471f, -0.17965482f, -0.04192811f, -0.07401671f, -0.11409067f, 
    -0.04081450f, 0.23829205f, -0.05528086f, -0.13024618f, 0.14136313f, -0.11056715f, -0.08984525f, 0.00645973f, 
    -0.06835096f, 0.06207862f, 0.00152026f, -0.02634667f, -0.01371228f, -0.16742687f, -0.20259127f, -0.16003670f, 
    0.10480341f, 0.12521970f, 0.15958844f, -0.00674676f, -0.11904138f, -0.06869381f, -0.04249674f, -0.00465019f, 
    -0.06398933f, -0.01131107f, 0.17708628f, 0.21045561f, 0.04568662f, -0.01085866f, 0.16095929f, -0.26796418f, 
    0.02409726f, 0.00456190f, -0.00079995f, -0.00336785f, 0.04547571f, 0.00774004f, -0.03463615f, -0.03122608f, 
    0.05055433f, -0.04486137f, 0.04092605f, 0.00850914f, 0.02386861f, -0.01525645f, 0.00550011f, -0.05794586f, 
    0.01418150f, -0.01581109f, -0.06092514f, -0.05064343f, -0.02254542f, -0.05288546f, -0.02800893f, -0.00374795f, 
    -0.02695189f, 0.02736231f, -0.04282023f, -0.02049702f, -0.05404288f, 0.01994954f, 0.02736347f, 0.00146080f, 
    0.02750963f, 0.03649987f, -0.05554333f, 0.03651692f, 0.00249347f, -0.02479178f, 0.03272831f, -0.04433707f, 
    -0.01060715f, -0.02913224f, -0.03261605f, -0.00941179f, 0.05162729f, -0.04519853f, 0.01976657f, -0.03821164f, 
    0.02417111f, -0.04619598f, -0.04367964f, 0.00335952f, -0.01889016f, 0.04072762f, 0.00672907f, 0.01832041f, 
    0.01170947f, 0.01324492f, 0.01812911f, 0.01039144f, 0.03399886f, -0.06103973f, 0.06161601f, 0.01491329f, 
    -0.02296487f, 0.00913852f, 0.00191278f, -0.05866394f, 0.00691485f, 0.04385313f, 0.05041770f, -0.04920627f, 
    -0.02909363f, -0.04745282f, -0.03254643f, -0.00336049f, 0.04607581f, 0.04846173f, -0.02280301f, 0.04115501f, 
    -0.02304913f, 0.05444755f, -0.03839656f, 0.01647107f, 0.00890971f, 0.01321415f, 0.02936115f, 0.02120748f, 
    -0.04902132f, -0.04263479f, -0.02884035f, 0.03887552f, 0.00171041f, -0.03130441f, -0.02840015f, -0.03433941f, 
    -0.02304862f, -0.01813268f, 0.02066868f, 0.03976852f, -0.01491893f, -0.01563648f, 0.01835012f, 0.02387430f, 
    -0.03854708f, -0.02490480f, 0.03329984f, 0.04131429f, 0.04330783f, 0.01688824f, -0.01321348f, 0.01982172f, 
    0.00738386f, -0.04273185f, -0.05883041f, 0.00193141f, -0.06535537f, -0.00613931f, 0.00044880f, 0.04839111f, 
    -0.04623196f, 0.00275457f, -0.04055056f, 0.01972397f, 0.01145520f, -0.01301083f, -0.03633625f, -0.03690604f, 
    -0.00228867f, -0.02110300f, -0.03210419f, 0.04709190f, -0.05958893f, 0.02500493f, -0.00438364f, 0.02540586f, 
    0.01746601f, -0.03448460f, -0.05088801f, 0.00902539f, -0.00963163f, -0.01099193f, -0.06270938f, -0.02026641f, 
    -0.04387441f, 0.03367021f, -0.06735829f, -0.00877566f, 0.00949522f, -0.05875516f, -0.00627112f, -0.03603220f, 
    -0.06786854f, -0.05436430f, -0.02633532f, 0.03139390f, -0.02009496f, -0.03061973f, 0.03666131f, 0.02003422f, 
    -0.03010713f, 0.01455131f, 0.00709218f, 0.03692545f, -0.02397496f, -0.06091751f, -0.00372175f, 0.03717807f, 
    0.00574022f, -0.05186392f, 0.01052982f, -0.05029401f, -0.05398003f, 0.00333763f, -0.05959940f, 0.05102808f, 
    0.03831066f, -0.02905672f, -0.05959573f, -0.01533607f, -0.05870925f, -0.05083964f, -0.01815899f, 0.02725002f, 
    0.03028695f, 0.02091183f, -0.05894566f, -0.04721377f, -0.03636989f, 0.03851469f, -0.03921450f, 0.00312831f, 
    0.00624789f, -0.04193220f, 0.02158350f, 0.00775887f, 0.00386736f, 0.01910231f, 0.03765951f, -0.00437042f, 
    -0.04059360f, 0.05031539f, -0.02596142f, 0.05758819f, -0.02039381f, -0.00810213f, -0.03864834f, 0.03135656f, 
    -0.00627379f, 0.01337207f, 0.02277480f, -0.04014085f, -0.03234003f, -0.05706358f, -0.00349868f, 0.05367617f, 
    -0.03301292f, -0.05432846f, 0.03938539f, -0.00779877f, -0.06361600f, 0.04856852f, -0.04016010f, -0.04271122f, 
    -0.05194497f, -0.02484081f, 0.00191644f, 0.03029912f, 0.03530084f, 0.04829728f, 0.01107239f, -0.06040956f, 
    -0.04636912f, -0.04222643f, -0.03865984f, -0.04856182f, 0.03330599f, 0.04700024f, -0.04151710f, 0.03509156f, 
    0.00286442f, -0.05874131f, -0.05066834f, 0.03157802f, 0.03198484f, 0.05227180f, -0.04323990f, 0.01017841f, 
    0.03303470f, 0.02676152f, 0.03565064f, -0.04253406f, -0.06009725f, 0.03352625f, -0.00670790f, -0.06475448f, 
    -0.00346401f, 0.00684340f, -0.05152697f, 0.01943663f, 0.03424358f, 0.02038538f, -0.00022039f, -0.04144371f, 
    0.02142529f, 0.04792988f, 0.04998926f, -0.03094839f, -0.04436634f, -0.02613007f, -0.06308995f, 0.04374940f, 
    0.00521998f, 0.03411455f, -0.06136817f, 0.04528147f, -0.04262354f, 0.00715164f, 0.00038562f, -0.01452374f, 
    0.02433355f, -0.02827502f, -0.03811098f, 0.04751315f, -0.04039576f, 0.01164492f, -0.05334991f, 0.00591954f, 
    0.00841720f, -0.08358330f, -0.04275117f, 0.01029209f, 0.05555021f, -0.07019518f, -0.03387189f, -0.04641918f, 
    -0.05639448f, -0.03075423f, -0.00494899f, 0.02729144f, -0.09164523f, 0.03466022f, -0.03049074f, 0.05677093f, 
    0.01364534f, -0.06404296f, 0.00166584f, -0.03422824f, 0.04063265f, -0.05535101f, -0.09049494f, -0.02735704f, 
    -0.06148836f, 0.01219990f, -0.05092135f, 0.04936856f, 0.02111805f, 0.00516551f, -0.03374034f, 0.02155944f, 
    -0.08680491f, -0.06404793f, -0.00623820f, -0.04329361f, -0.05593191f, -0.05276936f, 0.02416958f, -0.05247777f, 
    0.05076771f, -0.00691972f, -0.06143562f, 0.01368113f, -0.00132908f, -0.01993301f, 0.03347432f, -0.01016186f, 
    0.04595158f, -0.00389283f, -0.05159092f, 0.01939662f, -0.07758319f, 0.04616693f, 0.00417337f, -0.02906291f, 
    0.01162365f, 0.01369809f, -0.02398971f, -0.02534621f, 0.00687221f, -0.03181671f, -0.04375232f, -0.00461839f, 
    -0.07461940f, 0.00300568f, -0.02008996f, 0.04479502f, -0.05728562f, 0.01184876f, -0.07012054f, -0.03623725f, 
    -0.00923997f, -0.00236091f, 0.03063639f, 0.01546517f, -0.06818194f, -0.02294488f, -0.03497926f, 0.04175625f, 
    -0.05212465f, 0.05567064f, -0.04090888f, -0.01552373f, -0.04606757f, 0.01982415f, 0.01130261f, 0.01516079f, 
    -0.02609573f, -0.05470502f, 0.02566797f, -0.04496690f, 0.00057490f, -0.03522350f, -0.03584752f, -0.02673542f, 
    -0.00837176f, -0.07298929f, -0.01056289f, 0.04981419f, 0.04748570f, 0.01303343f, 0.06675087f, -0.00365981f, 
    0.04478911f, 0.00041963f, 0.04098592f, -0.04360618f, -0.01389153f, 0.02720737f, -0.04046043f, -0.07626000f, 
    -0.08060155f, -0.00774621f, -0.05515248f, 0.02994737f, -0.02159572f, -0.04347865f, -0.01697047f, 0.00542565f, 
    0.03342449f, -0.03576480f, -0.06795438f, -0.03737441f, -0.07701173f, -0.00406119f, 0.01726236f, 0.00762296f, 
    0.06304149f, 0.04867187f, 0.03495384f, -0.06863200f, -0.08829519f, 0.04122132f, 0.00566313f, -0.07516941f, 
    -0.05488905f, 0.01827473f, 0.00285623f, 0.02220566f, -0.05824302f, 0.01641846f, -0.00431970f, 0.02391241f, 
    -0.02334850f, 0.01283309f, 0.06087011f, 0.01093804f, 0.00907568f, -0.02627622f, -0.05157742f, -0.00641333f, 
    -0.01985998f, -0.02318860f, 0.02442459f, -0.02523598f, 0.01721466f, -0.05877297f, 0.03246068f, -0.05858671f, 
    0.00320035f, 0.02267073f, 0.03033289f, -0.03669595f, -0.05560821f, -0.06257916f, 0.03252682f, -0.08190917f, 
    -0.06603088f, -0.08590648f, -0.06217669f, -0.02064120f, -0.03534202f, -0.04217285f, 0.00147816f, 0.01201536f, 
    -0.02283823f, -0.02797337f, -0.02600605f, -0.01479087f, 0.02782230f, 0.04309631f, -0.02497183f, 0.03059215f, 
    0.04922288f, -0.06574664f, 0.01551124f, -0.05308545f, -0.02601630f, -0.03327882f, 0.05481647f, 0.01682834f, 
    -0.00693611f, 0.02085139f, -0.05798713f, -0.04288103f, 0.02986643f, -0.07636955f, -0.01078666f, -0.02439644f, 
    0.01454716f, -0.03210298f, -0.02767596f, -0.03388534f, -0.05176434f, -0.07157603f, -0.02952566f, -0.04928209f, 
    -0.06322665f, 0.04309592f, -0.05583170f, -0.03789944f, 0.02350656f, -0.04300727f, 0.00196728f, -0.00184034f, 
    -0.06404434f, -0.05700951f, -0.03586173f, -0.07265326f, 0.01318940f, 0.00132828f, -0.06238521f, 0.01640618f, 
    0.02249503f, 0.07478245f, 0.03244071f, 0.01265167f, 0.01680708f, 0.00346135f, 0.02347884f, -0.05374758f, 
    -0.00885725f, -0.02135845f, 0.01127151f, 0.05165585f, 0.02173553f, 0.03351346f, 0.02695320f, -0.01956036f, 
    -0.05129374f, -0.06117747f, 0.02063966f, -0.03803061f, -0.04215436f, -0.02597435f, 0.03136456f, 0.03487789f, 
    -0.00865712f, 0.01377161f, 0.00945829f, -0.02056941f, -0.04892062f, 0.02202016f, -0.01470230f, 0.03878953f, 
    0.03170209f, -0.05154142f, -0.03684191f, 0.06541633f, 0.01172464f, -0.03403389f, -0.07789064f, -0.05725837f, 
    -0.05336013f, 0.03573531f, -0.05330218f, 0.01092564f, -0.04952929f, -0.05174020f, -0.03595760f, -0.02508713f, 
    -0.00425464f, -0.05181086f, 0.03300184f, -0.00062774f, -0.05404956f, -0.00334550f, -0.02085316f, 0.00137440f, 
    0.03109006f, 0.00760423f, -0.03668461f, 0.00151726f, -0.08125369f, 0.03079117f, -0.02901385f, -0.00103340f, 
    -0.05203355f, 0.03357316f, 0.00383794f, 0.04733900f, -0.02310205f, 0.03329437f, -0.01567913f, -0.06219001f, 
    -0.05768838f, 0.02412416f, 0.05163559f, 0.00791789f, -0.01653319f, 0.04991024f, -0.02816083f, 0.02730373f, 
    0.01622440f, 0.00406768f, -0.04948706f, -0.01517004f, -0.06663366f, -0.00693115f, 0.01121023f, 0.01772939f, 
    0.00947428f, 0.00853566f, 0.04495469f, 0.01754427f, 0.04250696f, -0.02631091f, -0.05060163f, 0.05445471f, 
    0.04350443f, -0.02008412f, 0.02340256f, -0.02761508f, -0.01080292f, 0.00860830f, 0.04870077f, 0.00933724f, 
    -0.01521196f, 0.01420983f, 0.00843602f, 0.04290842f, -0.05472669f, 0.00006043f, -0.02199990f, -0.02324102f, 
    -0.06281668f, -0.04555846f, 0.02783091f, -0.01885464f, 0.03946437f, -0.01515573f, 0.01752538f, -0.06139475f, 
    -0.01499583f, 0.04522243f, 0.01353764f, 0.02302878f, -0.04787770f, 0.00518902f, 0.02869230f, 0.00597775f, 
    0.00191976f, 0.02409037f, -0.02325472f, -0.04453955f, -0.01375934f, 0.03669919f, -0.03903944f, 0.00144446f, 
    -0.04762526f, 0.01045894f, 0.00264504f, -0.00879045f, -0.04635768f, 0.00897832f, -0.01617945f, 0.04635986f, 
    -0.01095728f, -0.04724446f, 0.02583185f, 0.01632855f, -0.01005887f, -0.01965443f, 0.02907444f, 0.03759229f, 
    -0.05436512f, -0.02958941f, 0.03762148f, -0.03167325f, 0.02146110f, -0.00322515f, 0.02713859f, -0.05628010f, 
    -0.04398934f, 0.03894189f, -0.01912278f, -0.05234091f, -0.02618443f, 0.02259402f, 0.03222245f, -0.06007028f, 
    -0.05543635f, -0.06598632f, -0.00062122f, 0.02238414f, 0.00896846f, -0.04856751f, -0.05645437f, -0.05995938f, 
    -0.03341663f, -0.01931025f, 0.02659889f, -0.04996788f, -0.02578530f, -0.01529910f, -0.02548331f, 0.04301536f, 
    0.00494524f, 0.00380166f, 0.00211493f, -0.03908987f, -0.05707493f, 0.04805660f, -0.00642355f, 0.00349050f, 
    -0.03726672f, 0.03662189f, 0.00173996f, 0.01071333f, -0.00961728f, 0.03861492f, 0.00325095f, -0.03052419f, 
    0.01581854f, 0.00318574f, -0.01221948f, -0.03977196f, -0.03143201f, -0.02485496f, -0.03499229f, -0.03970945f, 
    -0.01062646f, 0.00418634f, -0.05257836f, -0.03181500f, -0.02729648f, 0.03658349f, -0.04791186f, -0.01050296f, 
    -0.05111855f, 0.03979585f, -0.01575288f, 0.00551107f, -0.05763450f, 0.04793652f, -0.01036363f, 0.03476410f, 
    0.04009387f, 0.00505081f, 0.02460461f, -0.01155124f, -0.00231533f, 0.00533230f, 0.02372809f, -0.06526814f, 
    -0.02138573f, 0.03445020f, -0.03099032f, 0.04830037f, 0.02317072f, -0.01921027f, 0.00185679f, 0.02196943f, 
    0.01319887f, 0.04008848f, 0.04323984f, -0.03964020f, -0.04464325f, 0.03979006f, 0.03463178f, 0.03322990f, 
    -0.01697519f, 0.01371566f, -0.00146901f, 0.03681540f, 0.00247947f, 0.05219931f, -0.05542686f, 0.02229131f, 
    0.04463706f, 0.01226316f, -0.05609940f, -0.00682917f, -0.01395037f, -0.02077445f, 0.02369610f, 0.03512828f, 
    -0.01377775f, -0.00119824f, 0.01285390f, -0.02612334f, 0.01229393f, -0.03952340f, -0.03964227f, -0.04430332f, 
    -0.03615572f, 0.03179084f, 0.04697747f, -0.01592153f, 0.02886250f, 0.00960052f, -0.01467620f, -0.01728529f, 
    -0.02619491f, -0.07099265f, 0.03501865f, -0.02423600f, -0.00308350f, -0.05815599f, -0.04986227f, 0.04814105f, 
    -0.02952393f, -0.02019044f, -0.01797733f, 0.01047994f, 0.04781834f, -0.03547012f, -0.02228673f, -0.06572792f, 
    -0.02232252f, 0.01988922f, -0.00161684f, 0.02826986f, -0.00535711f, -0.04306750f, 0.01882990f, 0.01716504f, 
    -0.01689242f, -0.00972723f, -0.05387279f, -0.05788432f, -0.01463368f, -0.01818711f, -0.01808336f, -0.05552665f, 
    -0.01364290f, -0.04203039f, -0.03398767f, 0.04504861f, -0.05064356f, -0.02259944f, -0.05946792f, 0.01522608f, 
    -0.02027035f, 0.03730953f, -0.02464342f, 0.02741327f, -0.04212188f, -0.00285044f, 0.04942227f, -0.03600669f, 
    -0.00622855f, -0.05335208f, -0.04195976f, 0.05078988f, -0.00678581f, -0.03671786f, -0.02533294f, 0.05258018f, 
    0.00226820f, 0.03663720f, -0.00544003f, 0.01881356f, -0.02998186f, -0.01534161f, 0.00124727f, 0.00585227f, 
    -0.04461439f, 0.05198195f, 0.00321999f, -0.02470508f, 0.03811406f, -0.04679000f, -0.04965601f, 0.04467559f, 
    0.20751831f, -0.03367332f, 0.07667580f, 0.27146548f, -0.01395080f, 0.00441611f, 0.03994501f, 0.08713062f, 
    0.07539178f, 0.19076695f, -0.30514327f, -0.03045170f, -0.02701142f, 0.02353676f, -0.00410449f, 0.28653559f, 
    -0.13884327f, 0.17246439f, -0.20784140f, -0.09228638f, -0.02407615f, -0.05336175f, 0.10524096f, 0.14439081f, 
    0.08407949f, -0.11594982f, -0.00311324f, 0.40216583f, -0.01611653f, 0.01636754f, -0.13568689f, 0.03556629f, 
    -0.03304586f, 0.06441052f, 0.02980603f, 0.02633881f, 0.31158221f, 0.08254815f, 0.07338141f, 0.17722858f, 
    0.13710816f, -0.23973623f, -0.05166392f, -0.05773559f, 0.22464617f, 0.09206332f, -0.03298651f, -0.07351475f, 
    0.10450400f, 0.06906651f, -0.29603058f, 0.03555771f, 0.11324820f, -0.02185190f, -0.01122728f, -0.04869253f, 
    0.00267758f, 0.26176271f, -0.13628609f, 0.03306974f, 0.12962244f, -0.09156112f, 0.31426159f, -0.10458973f, 
    0.14029443f, -0.15266283f, 0.13141048f, 0.01345022f, 0.19802952f, -0.00136160f, -0.20093960f, 0.10314853f, 
    -0.18888336f, 0.15677187f, 0.11299692f, 0.12249193f, -0.14668560f, -0.09094399f, 0.00521239f, 0.08735701f, 
    -0.13224643f, -0.10173040f, 0.23043314f, 0.04809746f, 0.07869507f, -0.00374648f, 0.03792254f, 0.05132346f, 
    0.19650085f, 0.02270619f, -0.08060472f, -0.00314381f, -0.15952644f, 0.11901999f, 0.04536816f, 0.14278437f, 
    -0.16611813f, -0.00320430f, -0.10550924f, 0.00582138f, 0.20523940f, 0.11336703f, 0.15769731f, -0.04081132f, 
    0.00042967f, -0.00645177f, 0.04991829f, -0.09289926f, -0.08382356f, -0.13220546f, 0.15248708f, -0.02306736f, 
    -0.10854053f, 0.01573973f, -0.09240201f, -0.10214940f, 0.17299832f, -0.17802940f, -0.00287307f, 0.20780574f, 
    -0.11125046f, -0.08088718f, -0.00168697f, -0.26845226f, -0.10575286f, 0.03241564f, 0.29556888f, 0.16350822f, 
    -0.00320690f, 0.06992155f, 0.10195809f, 0.06474941f, -0.24273263f, 0.04216358f, 0.33994806f, -0.02157150f, 
    -0.12193261f, -0.24718991f, 0.02018486f, -0.08470745f, -0.04670351f, 0.17224763f, -0.05276143f, 0.04150200f, 
    -0.21672513f, 0.01748441f, -0.08369172f, 0.07321020f, -0.25155959f, -0.04737646f, 0.08035296f, 0.16302972f, 
    -0.18726088f, 0.16173761f, -0.15206844f, -0.11748687f, 0.30116373f, -0.11145801f, -0.09178594f, -0.09542970f, 
    -0.05535276f, 0.20384626f, -0.03653897f, -0.06470370f, 0.04120857f, 0.20075098f, 0.04113759f, -0.01654902f, 
    -0.20913997f, -0.01235392f, -0.03240850f, 0.14743502f, 0.02491519f, -0.27672824f, -0.09614045f, -0.18180588f, 
    0.12771805f, 0.13752127f, 0.04271662f, -0.05943445f, 0.20034254f, -0.18393749f, -0.11438349f, 0.11096293f, 
    0.21738090f, 0.19702180f, -0.12418319f, 0.03647155f, -0.21870740f, 0.14901805f, 0.17389204f, 0.09311885f, 
    0.09215750f, 0.02193871f, 0.23796701f, 0.05666713f, 0.15747821f, -0.05651524f, 0.13784346f, -0.11154860f, 
    -0.18774498f, 0.13180315f, 0.15766202f, -0.23188603f, -0.01613888f, 0.06144811f, 0.12815501f, 0.13975236f, 
    -0.13764863f, 0.20253167f, 0.04506195f, 0.06016527f, 0.13560733f, 0.30757999f, -0.20686576f, 0.00754049f, 
    -0.03000190f, -0.00384673f, 0.20837976f, -0.14249435f, -0.14787090f, -0.24046357f, -0.19387026f, -0.04712971f, 
    0.04228135f, 0.19168496f, -0.21006773f, -0.31796283f, 0.03578133f, -0.00230736f, 0.20057982f, -0.04187092f, 
    0.00094560f, -0.07507822f, 0.37300006f, 0.17743494f, 0.00178763f, 0.17798300f, -0.03389820f, 0.13346024f, 
    0.09505006f, -0.02892320f, -0.06429774f, 0.23236851f, 0.16381414f, -0.05084165f, 0.13374297f, 0.02231495f, 
    -0.01537392f, -0.01913825f, 0.09134758f, 0.12256197f, 0.05360870f, -0.17687917f, 0.04046340f, 0.14183031f, 
    0.14303398f, -0.11503673f, -0.12317000f, 0.04393624f, 0.00709138f, 0.18997824f, 0.04935798f, 0.18060957f, 
    0.33168301f, 0.08261152f, 0.04424436f, 0.06476710f, -0.05432386f, 0.16131563f, 0.10940438f, 0.26908827f, 
    0.18274720f, 0.09271769f, -0.08517896f, 0.04639227f, 0.00199695f, 0.04564561f, 0.15893057f, 0.02414151f, 
    0.07664952f, -0.01801160f, 0.20810911f, 0.19558084f, -0.04596975f, 0.00801776f, -0.03329382f, 0.02796304f, 
    -0.00673938f, 0.03586562f, -0.07194491f, -0.02538896f, 0.03867270f, 0.00262693f, -0.04763474f, -0.04075179f, 
    -0.01658351f, 0.01978381f, -0.04979526f, -0.07636150f, 0.00924700f, -0.04336603f, -0.04076682f, -0.05812167f, 
    0.03893967f, -0.05689624f, 0.03535916f, -0.03984620f, -0.02843632f, 0.01751019f, -0.05057395f, -0.04069627f, 
    0.04047565f, -0.01220087f, 0.01187791f, 0.00610479f, -0.02371772f, -0.02676570f, -0.05973552f, -0.02943722f, 
    0.00156952f, -0.00706948f, -0.01319665f, -0.01449233f, -0.03330673f, -0.03050569f, 0.01496164f, 0.00304717f, 
    -0.02735011f, 0.03531725f, 0.01067235f, 0.02333478f, -0.01592956f, -0.06165773f, 0.02867799f, -0.00346737f, 
    -0.04532743f, -0.01904481f, 0.02857789f, 0.04815344f, 0.01760872f, 0.03718122f, -0.06385642f, -0.01726744f, 
    0.02815848f, 0.04206501f, 0.04409002f, -0.06753832f, 0.04774171f, 0.01121486f, 0.03455702f, 0.01942252f, 
    -0.03744589f, -0.07090012f, -0.00962696f, -0.02654510f, 0.03243583f, -0.00148802f, 0.01345460f, 0.03188817f, 
    0.03723286f, -0.06281630f, 0.00984943f, 0.03273351f, 0.01071787f, 0.05652968f, 0.00481291f, 0.03885056f, 
    -0.03987132f, 0.01453416f, -0.04113426f, -0.03129831f, 0.01159302f, 0.04153336f, 0.04703569f, -0.01025314f, 
    0.04044697f, -0.05380549f, 0.03851166f, 0.04014111f, 0.03403828f, -0.06421778f, 0.01865977f, -0.05083154f, 
    0.01035124f, 0.02654870f, -0.01234913f, -0.06788548f, 0.02160093f, -0.02675819f, -0.02783389f, -0.05826248f, 
    0.01097788f, -0.05319571f, -0.02220106f, 0.05031969f, -0.04504663f, 0.00794199f, 0.02273960f, 0.03800392f, 
    -0.04463742f, -0.00316242f, 0.00272566f, -0.04381080f, -0.02746608f, -0.00063636f, 0.03740690f, -0.03613587f, 
    -0.02974829f, -0.02463877f, 0.01192840f, 0.01622347f, -0.01639570f, -0.06384952f, 0.01080061f, -0.03367650f, 
    -0.01823621f, -0.02494537f, -0.02060379f, 0.02217852f, -0.01865382f, 0.03074533f, 0.02040003f, -0.06560814f, 
    0.02160078f, -0.03025354f, 0.02826400f, 0.02031619f, 0.03162361f, 0.04537858f, -0.00625982f, -0.07373289f, 
    0.00492286f, -0.02244496f, -0.00177275f, -0.06835847f, 0.02915319f, 0.01862964f, -0.02669428f, 0.02523163f, 
    -0.02726877f, 0.02608027f, -0.04707019f, -0.06162858f, 0.04618972f, 0.03906426f, 0.01818969f, 0.04880670f, 
    -0.02405331f, -0.06992774f, -0.06414542f, 0.04648590f, -0.02336334f, -0.00717642f, -0.02439992f, 0.04818869f, 
    -0.01551386f, 0.04874983f, -0.01705452f, -0.03535682f, 0.03033577f, -0.00489368f, 0.02913994f, -0.02175435f, 
    0.03340581f, -0.04939373f, -0.02728624f, -0.04362014f, -0.02247657f, -0.00508629f, 0.04174658f, -0.00221324f, 
    -0.02741686f, 0.01801910f, 0.04577653f, 0.04010740f, -0.05085677f, -0.02288185f, 0.01507251f, 0.02200291f, 
    -0.01182764f, -0.01292132f, -0.03397568f, -0.01972666f, 0.01285534f, -0.03163422f, -0.02762214f, 0.03222826f, 
    0.01599883f, -0.02521800f, -0.00733267f, 0.04189128f, 0.03715106f, 0.03930130f, -0.00949100f, -0.03207873f, 
    -0.06062884f, 0.00990288f, -0.04807112f, -0.02415607f, 0.02045377f, 0.02701017f, -0.01647981f, 0.02110504f, 
    -0.03433916f, -0.05810076f, 0.00111738f, 0.03133198f, 0.04235351f, -0.05115287f, -0.05602885f, -0.04247908f, 
    0.03494427f, 0.00309997f, -0.04290945f, 0.02211525f, 0.05192813f, -0.01418322f, -0.01664694f, 0.02489005f, 
    -0.03357705f, -0.05243126f, 0.01014697f, -0.03492188f, -0.02401478f, 0.00828262f, 0.03756196f, 0.02635958f, 
    -0.01758260f, 0.01898706f, 0.03276571f, 0.02708839f, 0.02871134f, -0.00445192f, 0.04380304f, -0.05336181f, 
    -0.06256364f, -0.05895290f, -0.03468743f, -0.05718566f, -0.03129441f, 0.01189795f, -0.04211849f, 0.03274683f, 
    -0.01202216f, -0.02248544f, -0.02186075f, -0.06545513f, 0.01821155f, -0.00114020f, 0.01789961f, 0.01201783f, 
    -0.04555856f, -0.03047622f, -0.06650678f, -0.04658957f, -0.03487701f, -0.07588559f, -0.03010793f, -0.01120980f, 
    0.02002992f, 0.01655899f, 0.00721575f, -0.06608959f, 0.03965598f, -0.04938949f, 0.03145851f, 0.01735717f, 
    -0.05000470f, 0.01427571f, 0.00314444f, -0.05931343f, -0.03301448f, -0.05024276f, 0.02446746f, -0.01826901f, 
    -0.21639900f, -0.46223366f, 0.04219989f, 0.02736042f, -0.02198093f, -0.13231103f, -0.06517966f, 0.00726532f, 
    -0.11485161f, 0.12428273f, -0.22716756f, 0.05580740f, 0.17361227f, -0.08489667f, -0.10895099f, -0.24166289f, 
    0.14078841f, -0.07721916f, 0.45073518f, 0.18781781f, -0.17180017f, 0.12000760f, -0.05835148f, -0.17627338f, 
    -0.03552334f, 0.03612264f, 0.15092672f, 0.07882994f, -0.16859646f, 0.02523925f, -0.00723825f, -0.06717235f, 
    0.04229288f, -0.01931398f, -0.10585903f, 0.12700579f, -0.15338999f, -0.13695507f, 0.06423331f, 0.06788041f, 
    0.12234043f, -0.13247079f, 0.18901454f, 0.00982578f, 0.01205213f, -0.50122821f, 0.01888592f, 0.08644412f, 
    0.00780795f, -0.08044154f, 0.03289513f, 0.00023195f, -0.13421045f, 0.05459990f, -0.42984837f, -0.29525831f, 
    -0.02332312f, 0.09951687f, 0.01187485f, 0.06056030f, 0.27476168f, -0.01139123f, -0.02739161f, -0.07721987f, 
    0.05929456f, -0.05911940f, -0.01534304f, -0.09081168f, -0.04785362f, 0.05987079f, 0.09415634f, 0.19496940f, 
    0.04461661f, 0.04869482f, -0.13836659f, -0.03435216f, 0.20057566f, 0.04159276f, 0.01405950f, 0.04349338f, 
    -0.05644785f, 0.14430815f, -0.02297844f, -0.09274299f, 0.03811364f, -0.08510771f, 0.22081481f, -0.03152027f, 
    0.00354895f, 0.01840270f, 0.20159434f, 0.22445486f, 0.34307709f, 0.04106588f, 0.07123658f, -0.05104318f, 
    0.23674120f, 0.01327118f, 0.08288953f, -0.05273198f, -0.07363024f, 0.07107863f, 0.02366516f, -0.00725936f, 
    0.02143623f, -0.00195024f, 0.03074251f, -0.03789317f, 0.01967570f, -0.21255144f, -0.05957574f, -0.20885041f, 
    -0.03152419f, 0.11483629f, -0.07518627f, -0.03238395f, 0.13657659f, 0.06320528f, 0.00920277f, -0.02572223f, 
    -0.17413726f, 0.02133375f, -0.02976046f, -0.07466285f, 0.08870522f, 0.12004410f, -0.18432219f, -0.26219192f, 
    0.09476703f, -0.02308736f, -0.22704534f, 0.02677576f, -0.00728591f, -0.13567474f, 0.15166359f, -0.21900997f, 
    0.13651234f, 0.05723865f, 0.14489432f, 0.02705963f, 0.13250501f, 0.05612598f, 0.12088473f, -0.12144657f, 
    -0.00848684f, -0.01259924f, 0.19593315f, 0.03933314f, 0.14494434f, 0.04227334f, -0.02703009f, -0.06010798f, 
    -0.07430493f, -0.25498173f, 0.03522573f, -0.05712103f, 0.05580383f, 0.14760323f, -0.23537877f, 0.07276673f, 
    -0.09542394f, -0.06158474f, -0.15323223f, 0.23386464f, 0.07628350f, 0.31316033f, 0.02542851f, -0.11457327f, 
    0.02380244f, 0.14206620f, 0.24149889f, 0.16948229f, -0.11523541f, 0.16194282f, -0.01801788f, 0.02391043f, 
    0.14573513f, 0.14140759f, 0.15745662f, -0.14052257f, 0.04191062f, 0.14571123f, 0.10939796f, 0.07679191f, 
    0.17338102f, -0.16968594f, -0.11381516f, 0.22436830f, 0.03007334f, 0.19981493f, -0.22141801f, -0.01440858f, 
    -0.09410790f, -0.17608999f, -0.08576821f, -0.00286627f, 0.21045367f, 0.12541470f, -0.49402550f, -0.17313424f, 
    -0.08952385f, 0.13582212f, -0.09326935f, 0.01437961f, -0.07660089f, -0.08824704f, 0.22974943f, -0.05996110f, 
    -0.10134679f, 0.03088989f, 0.19160107f, 0.10240152f, -0.00816555f, -0.11290482f, 0.06170546f, 0.07731652f, 
    0.35856223f, -0.01952378f, -0.11369838f, -0.00499332f, 0.01600955f, 0.05043450f, -0.04059418f, 0.12743960f, 
    -0.03474984f, 0.26749781f, -0.05743621f, 0.12848069f, 0.03204664f, -0.07795944f, -0.02380678f, -0.22568938f, 
    0.12923893f, -0.12158493f, 0.03257059f, 0.04509871f, 0.04704913f, -0.01514498f, 0.06640555f, 0.04093351f, 
    0.03432880f, 0.07383916f, -0.09111394f, -0.63998532f, 0.10612343f, 0.07331958f, 0.06348677f, 0.03254293f, 
    -0.06690142f, 0.15378916f, 0.07329967f, -0.06629986f, 0.23161370f, 0.11129545f, -0.06912352f, -0.12371372f, 
    0.10545552f, -0.04082142f, 0.17192730f, 0.09033674f, -0.00312192f, -0.48357195f, -0.13725799f, -0.17730139f, 
    -0.02202246f, -0.11054606f, 0.03570402f, 0.11169995f, -0.04098729f, 0.01424750f, -0.11629169f, -0.10907673f, 
    0.08033329f, 0.16387857f, 0.20037311f, -0.04446066f, 0.25229460f, -0.00690207f, -0.02331998f, -0.62836325f, 
    -0.27242339f, 0.19567306f, 0.13995728f, 0.00821329f, 0.09453800f, 0.04306868f, -0.10509365f, -0.00955749f, 
    0.26715803f, 0.17219819f, -0.02908920f, -0.05993482f, -0.19189201f, -0.16471104f, -0.08617603f, 0.03558701f, 
    0.16775846f, -0.07313169f, 0.01143874f, -0.10118510f, -0.02816385f, 0.10245924f, 0.02860201f, -0.15851448f, 
    0.06040267f, 0.07682130f, -0.18458010f, -0.11413241f, 0.06309602f, 0.07949457f, 0.05493971f, 0.17839074f, 
    -0.00283252f, -0.00649528f, 0.01964777f, -0.08736036f, -0.23145831f, 0.11435542f, 0.18628696f, 0.11197419f, 
    -0.04386027f, 0.12815857f, 0.10481074f, 0.10504916f, -0.16779493f, -0.16485970f, 0.00138703f, -0.08897471f, 
    -0.18800306f, -0.04441801f, -0.06206411f, 0.11325562f, 0.15675808f, 0.22211714f, 0.05841805f, 0.04633813f, 
    -0.09136984f, -0.19055507f, -0.46444511f, 0.16543873f, 0.33430502f, -0.06103853f, -0.08050074f, -0.03060268f, 
    -0.05468777f, -0.09752463f, 0.11173501f, -0.18364082f, 0.19752751f, 0.06791180f, 0.05638047f, -0.18107596f, 
    -0.01974019f, 0.21043345f, 0.04802940f, -0.00280267f, 0.26266000f, 0.15992853f, 0.07330522f, -0.02773783f, 
    0.15607765f, 0.14166541f, -0.12403996f, 0.06190076f, -0.02611964f, 0.14493868f, 0.01486041f, -0.22506259f, 
    0.04021289f, -0.34332860f, -0.03985046f, 0.12556705f, 0.19315952f, 0.04163782f, -0.00968538f, 0.02477956f, 
    -0.23508133f, -0.10956428f, -0.05651525f, -0.17647792f, 0.09304230f, 0.03294288f, 0.03264623f, 0.08679955f, 
    0.08968634f, 0.12057829f, 0.10527030f, -0.32800859f, 0.10371047f, -0.17700931f, 0.15585743f, 0.11783627f, 
    0.05329659f, 0.09899262f, -0.07607056f, -0.20397221f, 0.06630766f, -0.01933167f, -0.12275635f, 0.15671518f, 
    -0.12955926f, 0.13455628f, -0.05306879f, -0.05383236f, -0.25925440f, 0.16096932f, 0.04078184f, 0.07618757f, 
    -0.05071310f, 0.14145586f, 0.09229834f, -0.12273128f, -0.06676643f, -0.03486061f, -0.05388075f, -0.00585456f, 
    -0.06234970f, -0.01606174f, -0.06710946f, -0.12202235f, 0.19681969f, 0.17540514f, -0.33657888f, -0.17690463f, 
    0.11793192f, 0.23369615f, -0.06666086f, 0.16887289f, -0.08009139f, -0.09940700f, 0.07780830f, 0.27177787f, 
    -0.02933208f, 0.09929083f, -0.08159455f, 0.02869284f, 0.01640583f, 0.04071965f, -0.03866575f, -0.13912782f, 
    -0.05568896f, -0.00113190f, 0.00564933f, -0.20978612f, -0.04488366f, -0.04836429f, -0.19671062f, -0.00269189f, 
    0.03101620f, -0.01724963f, 0.11640541f, -0.16047904f, 0.01979619f, 0.11294014f, -0.00109828f, 0.11921477f, 
    -0.00386711f, -0.12070478f, 0.05415432f, 0.05361860f, -0.06588373f, 0.19924645f, 0.08914425f, 0.04002400f, 
    0.01080319f, 0.15698196f, 0.02177346f, -0.09662347f, 0.10104718f, -0.03759025f, 0.22977689f, -0.01713513f, 
    -0.02552693f, 0.30641845f, -0.00492233f, 0.04582620f, 0.10192847f, -0.26596078f, 0.03931044f, 0.11239626f, 
    -0.04332500f, -0.04277344f, -0.07251531f, 0.07974645f, -0.00533644f, 0.06875142f, 0.01488985f, 0.08009232f, 
    0.07692109f, -0.14653739f, -0.01596233f, -0.07004341f, -0.25739667f, -0.06926593f, 0.03197786f, -0.35721445f, 
    0.12680662f, -0.30140057f, 0.02832535f, -0.09984440f, 0.06690327f, -0.12127715f, -0.05948598f, 0.22605604f, 
    0.21140699f, 0.25457239f, -0.18636918f, 0.03603221f, -0.01144727f, -0.07738376f, 0.14150819f, 0.02396551f, 
    -0.06737279f, -0.45926315f, -0.06574906f, 0.08476747f, -0.02978659f, 0.12350816f, 0.04358746f, -0.01640486f, 
    -0.01928531f, -0.16118093f, -0.09754091f, -0.30439693f, -0.12635973f, 0.07565324f, 0.02770820f, 0.00615906f, 
    0.05576462f, 0.04574293f, 0.15691996f, 0.09158150f, -0.11691234f, -0.29394993f, 0.01673107f, -0.14125545f, 
    -0.01982439f, -0.11653179f, 0.16556513f, 0.10115913f, 0.50238997f, 0.13917609f, -0.31016833f, -0.15367971f, 
    0.03497220f, -0.16700749f, 0.00868145f, -0.08416925f, 0.06982987f, 0.12012309f, 0.13568708f, 0.13749495f, 
    -0.04747310f, 0.05503853f, 0.08569020f, 0.10851734f, -0.08888737f, 0.11184720f, 0.25502959f, 0.03566702f, 
    0.03728132f, -0.04201168f, 0.00166275f, -0.17427388f, -0.01957613f, 0.26357287f, 0.03641170f, 0.17829479f, 
    -0.02677900f, 0.10445011f, -0.17399548f, -0.26516542f, -0.10745904f, -0.00508401f, 0.08730484f, 0.15612662f, 
    -0.02640099f, -0.14197493f, -0.06795894f, 0.15959546f, 0.07437906f, -0.04891545f, 0.01234370f, -0.01757510f, 
    -0.10173289f, 0.24424353f, -0.15027732f, 0.09360747f, 0.24276896f, 0.11930830f, 0.16594851f, -0.16589071f, 
    0.01039878f, -0.19163468f, -0.54570895f, -0.02239399f, 0.03165448f, 0.05066207f, 0.10600446f, 0.01551748f, 
    -0.01294992f, -0.06068614f, 0.05655288f, 0.04464096f, 0.22001241f, -0.34108362f, 0.11982789f, -0.01023613f, 
    0.10699814f, -0.05894688f, 0.05109928f, 0.29341757f, 0.12902802f, -0.14075337f, 0.02324213f, -0.10230611f, 
    -0.05658237f, 0.13311346f, 0.02859902f, -0.13607748f, -0.05709912f, 0.13902195f, -0.01351565f, 0.10796579f, 
    0.12040074f, 0.10018174f, -0.10778669f, 0.17604004f, 0.03496730f, 0.13271482f, -0.00370297f, -0.12331278f, 
    0.16791266f, -0.02802330f, 0.00431592f, -0.04864076f, 0.06828856f, 0.03553360f, 0.00093187f, -0.15832576f, 
    0.06346580f, -0.13428533f, -0.03480278f, -0.05685316f, -0.11315366f, -0.02126751f, 0.15051566f, 0.09423336f, 
    -0.07696801f, 0.02371350f, -0.01367326f, -0.07897338f, -0.08727636f, 0.09083077f, -0.16429205f, -0.05889064f, 
    0.15161213f, -0.12330842f, 0.13952816f, 0.07167750f, -0.13569801f, 0.21040814f, -0.08297779f, -0.10415134f, 
    0.04844888f, 0.12790942f, -0.14289296f, -0.05257041f, -0.17264825f, -0.02051816f, -0.03258039f, -0.05412139f, 
    0.14137033f, 0.10060182f, 0.12607573f, 0.08691565f, 0.45236650f, 0.24268645f, 0.09500965f, 0.04252172f, 
    -0.25961444f, -0.05003439f, 0.04263590f, 0.03638099f, 0.09777979f, -0.13115770f, -0.18603630f, 0.14442010f, 
    -0.05678531f, -0.04040046f, 0.01158234f, 0.08968614f, 0.17720844f, -0.27739081f, 0.08284001f, 0.12480149f, 
    0.00793126f, -0.06381391f, -0.10938081f, -0.14293958f, -0.03425738f, 0.14408857f, 0.01611688f, 0.16831641f, 
    -0.10789209f, -0.06330919f, -0.10006464f, -0.11031020f, 0.09660368f, 0.13714592f, -0.03931253f, -0.20603848f, 
    -0.35977739f, 0.07653444f, 0.11395806f, -0.07670866f, 0.06014661f, -0.06326916f, 0.00939423f, -0.21106340f, 
    -0.08954345f, -0.03316112f, -0.07696491f, -0.03930897f, 0.07498349f, 0.10762160f, -0.02695845f, -0.05932564f, 
    0.12320378f, -0.01044199f, -0.21335945f, 0.09721797f, 0.19436698f, 0.02629906f, 0.03249877f, 0.07188915f, 
    -0.00806633f, -0.31489667f, 0.13427442f, 0.10198566f, 0.10157084f, -0.10182574f, 0.05955409f, 0.16795290f, 
    -0.17674978f, 0.03306630f, 0.28326914f, 0.30809990f, 0.02692656f, -0.13843460f, -0.16997990f, -0.02177890f, 
    -0.05802075f, 0.25926927f, 0.12850977f, 0.00488251f, -0.18145300f, -0.16153373f, -0.04824521f, 0.03566414f, 
    -0.05800484f, -0.06013912f, 0.28074798f, -0.08398533f, -0.07271555f, -0.12651163f, 0.48317283f, 0.21148655f, 
    0.00358882f, -0.17640056f, -0.09550423f, 0.09865319f, 0.00578166f, 0.01937739f, 0.20340016f, 0.02662591f, 
    0.30882752f, 0.24750821f, -0.20706381f, 0.04080813f, 0.11447212f, -0.01610108f, -0.02655284f, 0.08149975f, 
    -0.05457552f, 0.11596382f, -0.12801009f, 0.09909004f, -0.01763853f, -0.01839897f, -0.03137912f, -0.22501941f, 
    0.11804984f, 0.14915219f, 0.00346616f, -0.17249009f, 0.09336562f, -0.03322970f, -0.01526992f, 0.01049179f, 
    -0.11614555f, 0.03327977f, 0.13611257f, 0.01040607f, -0.10653932f, 0.17395169f, -0.09640764f, -0.27216417f, 
    0.03410072f, 0.08274094f, 0.15974104f, 0.05596472f, 0.05034631f, 0.00489049f, 0.02378516f, -0.07390212f, 
    -0.01446723f, 0.02066941f, 0.02751800f, -0.34753633f, -0.08390830f, 0.09685080f, 0.02102712f, 0.08399055f, 
    0.06208475f, 0.10471185f, -0.09599680f, -0.19960076f, -0.05826148f, -0.08726934f, 0.09002049f, -0.20733960f, 
    -0.03161353f, 0.08746631f, -0.13313197f, 0.02751162f, 0.04566325f, 0.16157970f, -0.02037408f, 0.03079422f, 
    0.09665344f, 0.01799843f, 0.01176881f, -0.02585994f, -0.00236113f, 0.07754339f, 0.09413431f, -0.07792310f, 
    0.13678862f, 0.13348335f, 0.02909269f, 0.01819315f, -0.09055448f, -0.01341677f, -0.14733808f, -0.10951771f, 
    0.10551057f, 0.17106496f, 0.10767235f, -0.05165903f, -0.10028393f, 0.02799281f, 0.12907580f, 0.17074192f, 
    0.22497970f, -0.03141446f, -0.11180532f, -0.09375907f, -0.21921209f, -0.04302436f, -0.05616776f, -0.07750420f, 
    0.07476841f, -0.21713886f, 0.23127532f, -0.40486756f, -0.06066578f, 0.10859384f, -0.04649842f, -0.12260380f, 
    0.01730250f, 0.05187554f, -0.17460969f, 0.15091521f, 0.00074226f, 0.24111143f, -0.01250931f, 0.00794603f, 
    -0.00182659f, 0.09682959f, -0.00491448f, -0.20422933f, -0.36825573f, 0.10780100f, 0.15165807f, 0.01907716f, 
    -0.14216335f, -0.02216549f, 0.17697647f, 0.04862450f, -0.18183266f, -0.11086836f, -0.18664296f, 0.12161222f, 
    -0.05859302f, 0.02522718f, 0.09374098f, 0.04728677f, 0.17266983f, 0.21829663f, 0.00652994f, -0.22662199f, 
    0.01676580f, 0.04530270f, -0.11004317f, 0.16502193f, -0.00081214f, 0.17282367f, 0.26049444f, -0.10664393f, 
    0.20812753f, 0.21300587f, -0.12679365f, 0.10363138f, 0.14789684f, 0.05859701f, 0.21304351f, 0.19400613f, 
    -0.02177129f, -0.06076187f, -0.01487515f, 0.02819704f, 0.24015710f, 0.01538264f, -0.10499460f, -0.08934323f, 
    0.05594239f, 0.09950055f, -0.30474272f, 0.07350287f, 0.01241310f, -0.03926761f, -0.08639941f, -0.06153178f, 
    0.14689507f, -0.30594108f, -0.10731374f, -0.31573850f, 0.20305048f, 0.02122703f, -0.21034984f, -0.08303946f, 
    0.00041325f, 0.10995805f, -0.06679668f, -0.01010616f, 0.16770086f, 0.02534328f, -0.03779361f, 0.10910802f, 
    -0.04490480f, 0.06780532f, 0.09708992f, 0.20249435f, -0.12844588f, 0.05269657f, 0.04180892f, 0.00762587f, 
    0.06956366f, -0.03082813f, 0.03823936f, 0.08299898f, 0.19309510f, -0.06800949f, -0.38945881f, -0.02249774f, 
    0.00310184f, 0.07106358f, -0.09820660f, -0.09020395f, -0.11239565f, 0.43614060f, 0.03094868f, -0.19719574f, 
    0.02120563f, 0.06739926f, -0.00079391f, 0.00011105f, 0.01079317f, 0.01524584f, -0.16642599f, -0.26814356f, 
    0.09037551f, -0.10000053f, -0.09133489f, -0.19258083f, 0.07553620f, 0.00019133f, -0.01702164f, -0.12262756f, 
    0.44351706f, 0.21135552f, 0.00356318f, -0.02368072f, 0.02485610f, -0.11090298f, 0.13720176f, 0.13832895f, 
    0.07357063f, -0.13268456f, -0.39788792f, 0.21799023f, 0.06467359f, -0.02034262f, -0.08915611f, 0.04445728f, 
    0.13105859f, 0.16843197f, 0.03606143f, -0.37370938f, 0.07880282f, 0.04064944f, 0.00450721f, 0.00554222f, 
    0.13944937f, 0.14386408f, -0.19488753f, -0.13191383f, 0.19425902f, -0.23001423f, 0.00219531f, -0.02318235f, 
    -0.01501314f, 0.29699492f, 0.07399859f, -0.13069928f, -0.18318813f, 0.25574759f, 0.18548574f, 0.15539506f, 
    -0.25605986f, -0.00535681f, -0.01568401f, -0.14379647f, 0.06296311f, 0.15937009f, 0.19469824f, -0.01950672f, 
    0.26613903f, 0.03384499f, -0.05469166f, 0.31094062f, -0.00865852f, -0.11837274f, -0.14692977f, 0.34609243f, 
    -0.03806368f, 0.08225447f, -0.08955085f, -0.03232246f, 0.04816264f, 0.18232577f, -0.07636567f, 0.16355684f, 
    -0.13032606f, 0.04427332f, -0.01018865f, -0.10696933f, -0.01854275f, 0.01090627f, 0.12526093f, -0.02185995f, 
    -0.02905318f, 0.02073311f, -0.01120417f, -0.05987358f, -0.16880766f, -0.36431038f, 0.12154238f, -0.03854842f, 
    0.02708981f, 0.06560548f, -0.13241880f, 0.11209117f, 0.03691647f, 0.00721525f, -0.22422479f, 0.01461315f, 
    -0.06736804f, -0.41230682f, -0.46768001f, 0.45464766f, -0.15060240f, 0.07886278f, -0.14861712f, -0.13763797f, 
    0.11030819f, -0.04195214f, -0.13556106f, -0.34777346f, -0.04201527f, -0.09642400f, -0.04794623f, -0.06273670f, 
    0.12055571f, -0.03263258f, 0.12516850f, 0.07691216f, 0.03686643f, -0.05538309f, 0.19303116f, -0.07680745f, 
    -0.02113662f, 0.07287485f, 0.00278515f, 0.03377968f, 0.39261597f, 0.43737862f, 0.08565391f, -0.06064080f, 
    -0.07169110f, -0.00285083f, -0.02777566f, 0.07207202f, 0.03074248f, 0.11866552f, 0.08038877f, 0.10536123f, 
    0.08135840f, 0.06570137f, 0.07989305f, 0.15496121f, 0.05613387f, 0.05386255f, 0.15502837f, -0.04926152f, 
    -0.13332549f, -0.01577843f, -0.03996039f, 0.03984468f, -0.08888417f, -0.00505071f, 0.05791869f, 0.23984298f, 
    0.01596135f, 0.08994798f, -0.06202427f, -0.01208473f, -0.00356246f, -0.00694433f, 0.00902839f, 0.02080807f, 
    -0.02024304f, -0.02518058f, 0.03041903f, 0.04318465f, 0.03349912f, -0.06138274f, 0.01357367f, -0.03032664f, 
    -0.04565483f, -0.01127955f, 0.03725051f, 0.00236602f, 0.00943271f, -0.02518293f, -0.04903581f, 0.03375643f, 
    -0.05295439f, -0.04980538f, -0.01378018f, -0.00896321f, 0.02655196f, -0.04606932f, 0.00118127f, -0.06449032f, 
    -0.03647279f, 0.04681820f, -0.04200123f, -0.03489923f, 0.01767561f, -0.04326979f, -0.04949424f, -0.01739245f, 
    -0.00332046f, 0.03077942f, 0.03512530f, -0.00245236f, -0.03403745f, 0.00763031f, -0.02431777f, 0.02823138f, 
    0.02290700f, -0.02770510f, -0.06116843f, 0.04858157f, -0.04078337f, 0.01000627f, 0.02910134f, -0.03283444f, 
    0.03535518f, 0.00808590f, -0.03783892f, 0.03157044f, -0.00696713f, -0.01403704f, 0.01698642f, -0.02558906f, 
    -0.01876387f, -0.02462166f, -0.05743410f, 0.04695549f, -0.03139279f, -0.02545039f, -0.02473038f, -0.02549581f, 
    -0.01092301f, 0.04749285f, 0.02242439f, 0.02174376f, -0.01938624f, -0.05801294f, -0.04278941f, 0.01157127f, 
    -0.05640463f, -0.05943686f, 0.01858896f, 0.01501579f, 0.00837612f, -0.05445384f, 0.03705541f, 0.02224541f, 
    -0.03095813f, 0.03530590f, -0.04695148f, 0.01746061f, 0.04540458f, 0.02162404f, 0.03717465f, -0.06646290f, 
    -0.02569117f, 0.03815449f, 0.03514419f, -0.01973741f, -0.01089177f, -0.01973644f, -0.01203904f, 0.04917347f, 
    0.03313128f, -0.04560255f, 0.03960430f, -0.02327305f, -0.06386526f, 0.04316788f, 0.01596678f, -0.02456900f, 
    0.00056097f, -0.04855951f, -0.02408468f, -0.04055384f, -0.02637430f, -0.03272474f, -0.01512314f, 0.00027094f, 
    0.04026527f, -0.06464614f, 0.02928145f, -0.02714683f, -0.03532126f, 0.02951729f, -0.01609624f, -0.05326923f, 
    -0.04799423f, 0.03407810f, 0.00746317f, 0.01923678f, -0.05034285f, 0.00902163f, 0.01934454f, -0.02618220f, 
    -0.01887755f, 0.04066052f, -0.00038246f, -0.00745307f, 0.00234626f, 0.01364017f, -0.01889796f, 0.03769302f, 
    0.04980187f, 0.04004313f, -0.06634673f, -0.02016571f, -0.03878882f, -0.00766521f, -0.02093989f, 0.00680377f, 
    -0.03587347f, -0.00069655f, -0.04810891f, 0.01278330f, 0.00626053f, -0.01618457f, -0.00835455f, -0.02518436f, 
    -0.05008535f, -0.00903304f, -0.01358205f, -0.04613812f, 0.01190632f, -0.02629419f, -0.05896441f, -0.02130232f, 
    -0.02263483f, -0.04946969f, -0.00939733f, -0.06649227f, -0.05325265f, -0.03482224f, -0.01385819f, -0.01492581f, 
    -0.05375953f, 0.00837431f, -0.05660104f, 0.02875679f, 0.01322118f, 0.00277952f, 0.03694670f, -0.06445615f, 
    -0.06201521f, 0.03027493f, -0.02690870f, 0.01232958f, -0.04317576f, -0.00249888f, 0.02955168f, 0.00520317f, 
    -0.03495072f, 0.00967319f, 0.04682135f, 0.04206161f, -0.02727546f, -0.01362565f, -0.03725407f, 0.01451792f, 
    -0.02784816f, -0.03389791f, 0.02134796f, -0.00177132f, 0.02811841f, 0.00106625f, -0.04363369f, 0.01488223f, 
    0.00022981f, -0.01733799f, -0.00953514f, 0.00400650f, 0.02069280f, 0.00016456f, 0.01210789f, -0.00223142f, 
    0.01118740f, 0.02354034f, -0.02087320f, -0.04403786f, -0.05751422f, -0.05123992f, 0.01724791f, -0.04404753f, 
    -0.00469278f, -0.03482719f, -0.01773194f, -0.02371354f, 0.03337718f, -0.04506872f, 0.00670610f, 0.01828205f, 
    -0.04052583f, -0.03472172f, -0.04860757f, 0.00833962f, -0.02297218f, 0.00535576f, 0.02033952f, -0.02633716f, 
    -0.06027171f, -0.02454272f, 0.00785568f, -0.04107695f, -0.06181797f, -0.00959862f, -0.03189325f, 0.01919261f, 
    -0.05560990f, -0.01896493f, -0.03178680f, -0.03097402f, -0.02505378f, 0.02058171f, -0.00827214f, 0.04463599f, 
    -0.05212899f, 0.02005056f, 0.02338000f, -0.02055651f, -0.03633085f, 0.03223526f, -0.00453947f, 0.03756051f, 
    -0.03352394f, -0.00136461f, -0.04786481f, -0.06360050f, -0.01101907f, -0.06149844f, -0.04298880f, -0.01576040f, 
    0.03288413f, -0.05585036f, -0.05769762f, -0.05162771f, -0.04958671f, -0.01255047f, -0.01737196f, -0.03902151f, 
    -0.02420447f, -0.00826722f, 0.01072259f, 0.03895080f, 0.02119472f, 0.02331937f, -0.03345639f, -0.00124563f, 
    -0.02592090f, -0.03729501f, -0.05021972f, 0.01994525f, -0.04763680f, -0.04564743f, 0.00543467f, 0.03354519f, 
    -0.14758986f, 0.25057462f, -0.07789622f, 0.08059942f, 0.13748965f, -0.13140933f, 0.04795283f, 0.11031494f, 
    -0.05329489f, 0.07214271f, 0.18708983f, -0.09057332f, 0.03278113f, -0.01004554f, -0.03838395f, -0.04362259f, 
    0.02632446f, 0.10589574f, -0.10175543f, 0.22646087f, -0.30962941f, 0.03799420f, 0.09280261f, -0.05077277f, 
    0.01424149f, -0.05361809f, 0.00538134f, 0.03050578f, -0.04784127f, -0.13368733f, 0.09893250f, -0.08799792f, 
    0.00225427f, -0.03711558f, 0.10038493f, 0.07207300f, 0.26774722f, -0.12343511f, 0.09775395f, -0.04747215f, 
    0.02453703f, 0.08231515f, -0.11247126f, -0.03708170f, 0.06923123f, 0.10474636f, -0.01376193f, 0.10185602f, 
    -0.00564362f, -0.02506888f, 0.09060107f, -0.17768359f, 0.06059111f, 0.18306719f, 0.05669785f, -0.01922287f, 
    -0.16215919f, 0.04278546f, -0.12094032f, 0.04927465f, 0.00757072f, 0.16553409f, 0.25208017f, -0.18733254f, 
    -0.26156962f, 0.09302525f, 0.03183253f, 0.03098724f, 0.01681349f, 0.21774003f, -0.00311547f, 0.16796395f, 
    -0.18067236f, -0.32629094f, 0.46543553f, 0.11809823f, 0.02788179f, 0.07881866f, -0.00571966f, 0.05018242f, 
    -0.05122875f, -0.16738150f, 0.05205252f, -0.02741860f, 0.05040843f, 0.09838744f, 0.01988306f, -0.01929107f, 
    -0.13480964f, 0.22823977f, 0.01526287f, -0.11886759f, -0.14416568f, -0.07948247f, 0.02957868f, -0.00790093f, 
    0.14389022f, -0.01254388f, 0.08588299f, -0.13918860f, -0.30901462f, 0.46933901f, 0.02314211f, -0.00508269f, 
    0.01139397f, -0.06198994f, 0.01184232f, 0.09813338f, -0.10860656f, -0.17101471f, 0.37360835f, -0.04106713f, 
    -0.03295677f, 0.03935377f, -0.07387196f, -0.03743177f, 0.08265185f, -0.48070896f, -0.36338249f, 0.52736801f, 
    -0.11781333f, -0.09471413f, 0.03099769f, 0.03963622f, -0.13180509f, 0.24665646f, -0.23477975f, -0.05954906f, 
    0.02888519f, 0.04946349f, 0.03404932f, 0.04831827f, 0.27535263f, -0.01266374f, 0.07621187f, -0.13285848f, 
    -0.04367876f, -0.61366814f, 0.17851575f, -0.18198639f, 0.19660237f, 0.07525592f, 0.02645279f, -0.03349992f, 
    -0.09266836f, -0.22399396f, 0.32933038f, 0.14370339f, -0.02212945f, -0.04584052f, -0.15319180f, 0.01717605f, 
    -0.19175442f, -0.15687253f, 0.00698269f, 0.12650095f, 0.12456341f, -0.13924451f, 0.00400692f, 0.09339488f, 
    -0.00517852f, -0.20964614f, 0.58637011f, 0.15925701f, 0.35295525f, -0.33943799f, 0.06347135f, 0.04266341f, 
    -0.06764938f, 0.03279993f, 0.12902531f, 0.26623479f, 0.05060628f, -0.23428297f, -0.03905459f, 0.23200777f, 
    0.02640666f, -0.10108127f, -0.05004929f, -0.03533507f, -0.19493946f, 0.17024066f, -0.17614751f, 0.11417618f, 
    -0.05725963f, -0.07393001f, -0.16617075f, 0.03605215f, -0.17135778f, -0.03129542f, -0.17490527f, 0.05114128f, 
    -0.19355805f, 0.18495522f, -0.15993831f, 0.02137481f, 0.16768278f, -0.02635501f, -0.01161222f, 0.10149992f, 
    -0.09007277f, 0.04639390f, -0.06395683f, -0.13938962f, 0.05182590f, -0.02988538f, -0.14695835f, 0.33353812f, 
    0.20142291f, -0.34703708f, -0.03992989f, -0.02150228f, 0.03078027f, 0.07266438f, 0.00175295f, -0.15196997f, 
    0.16097769f, -0.13151789f, 0.22028613f, -0.22732224f, -0.06796925f, 0.07772383f, -0.14890923f, 0.04200353f, 
    0.22090641f, 0.12330712f, -0.25334111f, -0.14652526f, 0.16304614f, -0.00064591f, 0.03074433f, 0.07451616f, 
    -0.15594339f, -0.04607705f, 0.09651919f, -0.08856516f, 0.00130531f, -0.18801063f, -0.06541386f, 0.08843333f, 
    0.06418113f, 0.04479717f, -0.12071791f, -0.23653580f, 0.35476553f, -0.07038054f, -0.02588917f, -0.01110816f, 
    0.06651473f, 0.13496475f, -0.04357103f, -0.03581075f, -0.16737029f, -0.53546083f, 0.23604652f, 0.02565218f, 
    -0.10036766f, 0.01533731f, -0.07640159f, 0.10026772f, -0.12640007f, 0.19756146f, 0.05520805f, -0.33323228f, 
    0.10643116f, 0.02206962f, -0.03979732f, -0.00923848f, 0.09340347f, -0.00929889f, 0.26948887f, -0.05609968f, 
    -0.03503169f, -0.06668539f, 0.17115161f, 0.16107590f, 0.09953645f, 0.10148299f, 0.12058607f, 0.11485961f, 
    0.22744094f, 0.01387615f, 0.11526103f, 0.07084458f, -0.07203284f, -0.10109511f, -0.14280662f, -0.06869846f, 
    -0.53196657f, -0.00800369f, -0.19278495f, -0.14056462f, -0.02724824f, -0.10680274f, -0.01557073f, 0.03734098f, 
    -0.00560778f, -0.32464153f, 0.20428962f, 0.04125527f, 0.11303966f, 0.07055759f, 0.08840951f, -0.07800385f, 
    0.04625316f, 0.08917532f, 0.16626595f, -0.00814636f, -0.20506357f, 0.00885807f, -0.18234327f, -0.20767480f, 
    -0.09508575f, 0.11920782f, 0.04349718f, -0.26150227f, 0.23449448f, -0.08873269f, 0.17965832f, 0.09640047f, 
    -0.05883212f, -0.06134643f, 0.09061855f, -0.08204700f, -0.14401194f, -0.04063484f, -0.16733937f, -0.20116031f, 
    0.09210312f, 0.10655934f, 0.08795069f, 0.12460484f, -0.26733837f, 0.02289494f, 0.19157885f, -0.16510589f, 
    -0.08984388f, 0.11324754f, 0.17911462f, 0.19534163f, -0.07453275f, -0.25077105f, 0.05195147f, 0.00848539f, 
    -0.02387487f, -0.06193103f, 0.07166584f, 0.01114016f, 0.20227945f, 0.01807965f, -0.11760868f, 0.00429308f, 
    -0.10233881f, 0.08555421f, 0.09230983f, -0.07960010f, -0.05680744f, -0.02741761f, -0.07525937f, -0.07382008f, 
    0.20137776f, 0.28176001f, 0.34707877f, 0.05007378f, 0.16937473f, 0.17874545f, 0.09668986f, -0.03891256f, 
    0.04253392f, -0.11843157f, 0.12619850f, -0.16706172f, -0.08878066f, -0.09675456f, 0.09710944f, -0.10250420f, 
    -0.00241765f, -0.03382590f, 0.29078114f, -0.11025069f, -0.14666733f, -0.24064368f, -0.05550126f, -0.03762915f, 
    -0.01219300f, -0.12519160f, 0.10026237f, 0.21802464f, -0.00134826f, 0.10432553f, 0.06842423f, 0.16483246f, 
    0.06318886f, -0.02851623f, -0.02950720f, -0.03790285f, -0.15160638f, 0.15791121f, 0.39979780f, 0.17153524f, 
    0.00689510f, -0.07881599f, -0.01600778f, 0.03888213f, 0.18756592f, -0.02932068f, 0.01933414f, 0.16741611f, 
    -0.06306674f, 0.05631771f, 0.05218362f, 0.09581634f, 0.08060849f, 0.05876579f, 0.04602092f, 0.13500462f, 
    0.19778655f, 0.29924276f, 0.02687818f, -0.02366750f, 0.06115340f, 0.18832690f, -0.04474713f, -0.02664980f, 
    0.23271635f, -0.02447436f, 0.30566049f, 0.18527268f, -0.02279314f, 0.26328367f, 0.03464861f, -0.21698084f, 
    0.38511366f, 0.22238548f, 0.49835691f, 0.13175574f, 0.13245621f, 0.06207697f, 0.13186786f, -0.24058305f, 
    -0.00600463f, -0.02292021f, 0.25907129f, -0.01522017f, -0.03710078f, 0.09859353f, 0.23985158f, -0.04292971f, 
    0.24227342f, -0.08065619f, 0.26366770f, 0.21551044f, -0.09721067f, 0.02674965f, -0.11860032f, -0.00232662f, 
    0.01449123f, 0.03669287f, 0.14240515f, 0.13458937f, 0.20144558f, -0.05471017f, -0.18435974f, 0.04669739f, 
    -0.12611441f, 0.04900877f, 0.08020142f, -0.13883558f, -0.29952964f, -0.09284711f, -0.30706367f, 0.13653463f, 
    -0.12735805f, -0.13202010f, -0.13975422f, 0.03665680f, 0.08554705f, 0.10760330f, -0.02064905f, -0.03191689f, 
    -0.14277659f, -0.14463283f, -0.03822147f, 0.17047845f, -0.06053621f, -0.04386890f, -0.42560032f, 0.37612137f, 
    -0.00590894f, -0.11594613f, -0.06897078f, 0.03386456f, 0.27267721f, -0.05193378f, -0.22931285f, -0.22866605f, 
    0.14755981f, -0.48271030f, -0.15973555f, -0.20199366f, -0.32368991f, -0.14892229f, 0.08493712f, -0.05926078f, 
    0.06864216f, 0.11817360f, 0.11290987f, -0.05825431f, -0.17438178f, 0.03085531f, 0.09383906f, 0.06743240f, 
    -0.03304362f, 0.39098027f, -0.16060266f, 0.07199833f, 0.02759148f, -0.08503421f, 0.11719772f, -0.03324936f, 
    0.00562521f, 0.00823645f, 0.10593642f, 0.00734584f, -0.06848058f, -0.08629990f, -0.12472115f, -0.03217212f, 
    -0.23749773f, -0.04136133f, 0.09024937f, 0.13254827f, -0.00724173f, 0.04849348f, 0.02522836f, 0.05715695f, 
    -0.16113976f, 0.07030038f, 0.07930730f, 0.02273309f, 0.30549133f, 0.32733464f, -0.00975356f, -0.02071162f, 
    -0.04488621f, 0.21888813f, -0.05471842f, -0.10680606f, 0.10577794f, -0.16956195f, 0.01986996f, -0.06730495f, 
    -0.02448705f, -0.08651698f, -0.13049389f, 0.01061334f, -0.01803648f, -0.18107639f, 0.01538784f, -0.12225174f, 
    0.09596903f, -0.08492862f, -0.00644769f, 0.08508594f, 0.07512439f, -0.13283612f, -0.18924907f, -0.06208061f, 
    0.11681196f, -0.17424574f, -0.06638147f, 0.03243971f, 0.00533346f, 0.05927749f, -0.00981423f, 0.11733980f, 
    0.16980398f, -0.68368822f, 0.15821461f, -0.05460666f, -0.19051322f, 0.10606063f, -0.09565605f, 0.11986370f, 
    0.01838955f, 0.03962107f, 0.23462364f, 0.02120113f, -0.16878308f, -0.17987271f, -0.14162974f, -0.21634610f, 
    0.01029330f, -0.05675327f, 0.41596603f, -0.31217101f, 0.30531111f, 0.01241382f, -0.27480713f, 0.14554466f, 
    -0.03105794f, -0.12445507f, 0.06514163f, -0.03498255f, 0.12826861f, -0.00834290f, 0.00107952f, 0.23971990f, 
    0.03721318f, 0.10428464f, 0.14342475f, 0.10498203f, 0.06660126f, -0.16932967f, -0.00782203f, 0.04786260f, 
    0.00368640f, -0.07882921f, -0.08221848f, -0.04991825f, 0.13473971f, -0.03183034f, -0.08452170f, 0.06492347f, 
    0.06972529f, 0.21877825f, 0.00868936f, -0.12317403f, 0.01241267f, -0.00556816f, -0.21743926f, 0.27456680f, 
    0.22860952f, 0.05407596f, -0.00780541f, 0.16105351f, 0.08252753f, 0.18545189f, -0.04552839f, -0.15034387f, 
    0.07891487f, 0.07142793f, -0.03827192f, -0.10968225f, 0.05708271f, 0.07380184f, -0.18909745f, -0.12491833f, 
    0.22037265f, 0.09826838f, -0.10544866f, 0.04935064f, 0.10580634f, -0.11387438f, 0.09537672f, 0.13456102f, 
    0.09467609f, 0.07870971f, -0.04592031f, 0.20855579f, 0.10976581f, 0.02682940f, 0.07826175f, 0.11444999f, 
    0.10339863f, -0.12880190f, 0.23673160f, 0.11357158f, 0.17580831f, -0.14492171f, 0.12106398f, -0.02097464f, 
    -0.00451233f, -0.07976178f, -0.17142726f, -0.02130858f, 0.14389879f, 0.04558194f, 0.14416203f, -0.10995704f, 
    -0.21317935f, 0.06124349f, 0.07333314f, -0.09144069f, 0.06836756f, 0.27264199f, 0.27394879f, 0.05971092f, 
    0.07882641f, 0.04753534f, -0.05154573f, -0.02898119f, -0.22965194f, -0.01088136f, 0.30437753f, 0.04122972f, 
    0.02672207f, -0.07067854f, -0.00912681f, 0.01823756f, 0.20003186f, -0.16428457f, 0.15900575f, 0.32442522f, 
    0.29030037f, 0.18455607f, 0.03406758f, 0.06735276f, -0.12742467f, 0.05461419f, 0.01735649f, 0.11204078f, 
    0.36819637f, -0.02262293f, 0.01110165f, -0.09768802f, 0.10522556f, -0.13220699f, 0.11053737f, -0.00628887f, 
    0.42229912f, 0.29344344f, 0.18756525f, 0.10890532f, 0.06918799f, 0.02745842f, -0.05353193f, 0.04690972f, 
    0.10272530f, -0.29577047f, -0.24620248f, 0.24139343f, 0.10676790f, 0.12588319f, -0.02803809f, 0.03808054f, 
    0.19982654f, 0.13481568f, 0.25600666f, 0.11495496f, -0.16673379f, 0.01670755f, -0.01005962f, 0.02564654f, 
    -0.03798416f, -0.10585379f, -0.10460116f, 0.09466337f, -0.15737355f, -0.00904893f, 0.05719515f, 0.08591687f, 
    -0.08188629f, 0.03994875f, 0.02432716f, 0.11159183f, 0.01955743f, -0.23581295f, -0.04444104f, -0.11134956f, 
    -0.18372826f, 0.04186007f, -0.19325872f, -0.06262604f, -0.22952612f, 0.11472102f, 0.01299839f, 0.11301111f, 
    -0.05195528f, -0.22920059f, 0.01704916f, 0.03503024f, 0.09994914f, 0.20352830f, 0.05839806f, -0.18198040f, 
    -0.48891336f, -0.02977743f, -0.04463657f, -0.05995949f, -0.05426449f, 0.01791150f, 0.00891889f, -0.24641326f, 
    -0.44277924f, 0.06202909f, 0.03835871f, 0.08736666f, 0.24270627f, -0.07547796f, 0.10787151f, 0.06738911f, 
    0.06583558f, 0.04044577f, -0.22868116f, 0.13027810f, 0.13961264f, -0.16240850f, 0.08469892f, 0.05083979f, 
    0.07652549f, 0.31293795f, 0.29763758f, 0.23169564f, -0.29231212f, -0.10454637f, 0.19421217f, -0.07000682f, 
    -0.06484561f, -0.13049860f, -0.13437471f, 0.05050670f, 0.22058183f, -0.25728065f, -0.19030088f, -0.12622982f, 
    0.04147727f, 0.04733228f, -0.00364392f, -0.46015152f, 0.06033521f, 0.36234647f, 0.09594474f, -0.04155125f, 
    0.14839126f, -0.08100752f, 0.23919407f, 0.01582629f, -0.05984379f, 0.20942867f, 0.13091025f, 0.21019794f, 
    0.13662970f, -0.26691943f, 0.02539217f, 0.07631428f, 0.15143810f, -0.29597732f, -0.27569792f, 0.20845325f, 
    -0.01302139f, -0.15325272f, 0.13238296f, -0.18447268f, -0.00708504f, -0.04946481f, 0.01254788f, -0.09739458f, 
    -0.06702399f, -0.05073497f, -0.13946888f, -0.02422634f, 0.14596573f, 0.07566749f, -0.09365930f, 0.01111205f, 
    -0.72195971f, 0.20924516f, -0.23821622f, 0.03476027f, 0.11642767f, -0.20115225f, -0.10358890f, 0.10696970f, 
    -0.01004070f, -0.05359419f, 0.03878684f, 0.02511100f, -0.03783558f, -0.01113281f, 0.03378278f, 0.00495317f, 
    -0.00267309f, -0.01510473f, 0.04099800f, -0.03378912f, -0.00459896f, -0.04001233f, 0.02195604f, 0.03113782f, 
    -0.01540712f, 0.00279850f, -0.02307844f, -0.02033640f, -0.03238171f, -0.02661687f, 0.03463670f, -0.05944635f, 
    0.01581369f, 0.00196154f, -0.02875673f, -0.01740813f, 0.00455822f, -0.05665565f, -0.01361142f, -0.03691025f, 
    0.04999672f, -0.00665389f, -0.02806175f, 0.00278848f, -0.02609510f, 0.00475584f, 0.00044906f, -0.03579491f, 
    -0.00105086f, 0.01277318f, -0.04880032f, 0.04359421f, -0.00581975f, 0.01771891f, -0.04248495f, -0.01756710f, 
    0.04161368f, -0.06994473f, 0.02207165f, -0.03503276f, 0.00018803f, 0.04305352f, -0.03403255f, 0.02229042f, 
    -0.06273505f, 0.02382134f, -0.01370075f, 0.04965316f, 0.03493886f, -0.03983812f, -0.01797097f, -0.01716921f, 
    -0.01182335f, -0.03676920f, -0.06408969f, 0.00543608f, -0.00851972f, -0.03249818f, -0.03958166f, -0.04276124f, 
    -0.04162789f, 0.00485006f, -0.03986054f, -0.03343571f, -0.03889512f, 0.01040618f, 0.02211094f, 0.02603475f, 
    -0.02569964f, -0.06995559f, -0.03582758f, -0.03859536f, 0.04075063f, 0.00800827f, 0.03875940f, -0.04945398f, 
    -0.04480422f, -0.02626266f, -0.02145725f, -0.02578114f, -0.01678140f, -0.05191645f, -0.02200014f, 0.02528688f, 
    -0.05048831f, -0.03581166f, -0.03887957f, -0.05770355f, 0.03991777f, -0.06696913f, 0.04420906f, -0.01835639f, 
    -0.06936686f, 0.03861318f, -0.01002106f, 0.04663040f, 0.04426329f, 0.00503354f, -0.02310710f, -0.00536229f, 
    -0.00442027f, 0.00416996f, -0.03522944f, -0.01503177f, -0.02706087f, 0.04830560f, -0.01461962f, -0.01927524f, 
    0.05107747f, -0.03170029f, -0.04667887f, -0.01503156f, -0.01802335f, 0.02022508f, -0.02412290f, -0.06024396f, 
    0.01275085f, 0.01245493f, -0.05842919f, -0.04424760f, -0.00442159f, -0.05638698f, -0.01485618f, -0.05605492f, 
    0.01730633f, 0.02055391f, 0.03862545f, 0.00607926f, -0.01947103f, -0.03946055f, 0.01489092f, 0.02989247f, 
    -0.03155945f, 0.03072748f, -0.04440442f, -0.03634727f, -0.05514545f, 0.04374679f, -0.00506678f, -0.05620955f, 
    -0.01543600f, -0.01472843f, -0.00929057f, -0.00979003f, 0.04204690f, -0.03739627f, -0.05836451f, -0.04663386f, 
    -0.02834976f, -0.02225079f, -0.00382427f, 0.00989756f, -0.00814283f, 0.00388998f, 0.03361865f, -0.02379847f, 
    -0.04143666f, -0.05832388f, -0.03404251f, 0.00623089f, -0.00812424f, -0.01548174f, -0.00086554f, -0.01368192f, 
    0.01853350f, 0.02844731f, -0.01945643f, -0.03451178f, 0.02447716f, 0.02397910f, -0.01085501f, -0.01499751f, 
    -0.00606618f, -0.06034769f, -0.03008190f, 0.03997632f, 0.04061054f, -0.05498812f, 0.01282515f, 0.01531881f, 
    -0.04466435f, -0.06248838f, -0.05478972f, -0.04985977f, -0.02507927f, 0.02948748f, -0.02646440f, 0.00268101f, 
    0.02859375f, 0.00438563f, 0.03597375f, 0.03311011f, 0.01603056f, 0.03604124f, -0.02996030f, 0.02122734f, 
    -0.03238796f, -0.05889322f, -0.00430813f, 0.03747255f, -0.00933371f, 0.02997780f, 0.00825851f, 0.01353241f, 
    0.00529858f, -0.01586744f, -0.05147612f, 0.04546141f, 0.02932667f, 0.02854900f, -0.04861161f, 0.02114884f, 
    -0.02333044f, -0.03324503f, 0.00338618f, -0.00868588f, -0.01360291f, -0.02183014f, 0.01960486f, -0.01517293f, 
    0.02493406f, -0.00254025f, 0.00544357f, -0.06494783f, -0.06947928f, -0.01282413f, -0.03381616f, -0.00589833f, 
    0.02435214f, 0.00333014f, -0.00081197f, 0.05255247f, -0.04072845f, -0.03550342f, -0.03112050f, -0.00935893f, 
    -0.00769332f, 0.01927496f, -0.02043097f, -0.06206313f, 0.05358276f, -0.02923837f, 0.01119429f, -0.01589661f, 
    -0.05480920f, 0.00706116f, 0.00918505f, 0.00836430f, 0.02155613f, -0.04701042f, -0.02827430f, 0.02410610f, 
    -0.00809961f, 0.01941620f, -0.02002433f, 0.03419553f, 0.00207231f, -0.04771597f, -0.01830810f, 0.02603816f, 
    0.03157416f, -0.03607513f, -0.00628494f, 0.00043096f, 0.04352219f, -0.04152051f, -0.03119252f, 0.01372907f, 
    0.03411090f, 0.04139048f, 0.01431784f, -0.02375917f, -0.04394680f, -0.03622227f, -0.00618748f, 0.05244970f, 
    0.04847174f, -0.04230794f, 0.04793220f, -0.01796097f, 0.00866071f, -0.03452698f, -0.05928976f, 0.03314466f, 
    0.02723385f, -0.01517677f, -0.01520018f, -0.02864116f, -0.03615311f, 0.01293563f, -0.03403687f, 0.05275913f, 
    -0.00088692f, 0.01056719f, 0.01826798f, -0.03354749f, -0.05271468f, -0.05226918f, -0.00404965f, 0.00386365f, 
    -0.02810971f, -0.05320622f, -0.03813942f, -0.00449528f, 0.04647923f, -0.01703512f, 0.01484080f, 0.03485093f, 
    0.04702906f, 0.01706078f, 0.00739289f, 0.03034504f, 0.03432712f, 0.02575895f, -0.01161590f, -0.01137971f, 
    0.03721330f, 0.03661262f, -0.03601009f, -0.04726661f, -0.05672527f, 0.01158839f, -0.05198653f, 0.02578977f, 
    -0.01296992f, -0.04069943f, 0.00661578f, -0.02883396f, -0.02989664f, 0.02167422f, 0.05020867f, 0.00378408f, 
    -0.04960988f, 0.00782674f, -0.03873791f, -0.05511815f, -0.02013178f, 0.02008613f, -0.02334188f, -0.00255170f, 
    0.01035441f, 0.03598946f, 0.00625215f, 0.00447758f, 0.04010639f, -0.00077386f, -0.06483463f, -0.04951521f, 
    0.01577536f, 0.04401446f, 0.02375772f, 0.03188695f, -0.03246925f, -0.05989092f, 0.00623676f, 0.01287912f, 
    0.00629955f, -0.02961261f, -0.04127731f, -0.00207500f, -0.06103698f, 0.01063668f, 0.00987861f, 0.00754340f, 
    -0.04600991f, -0.02712670f, 0.00454718f, 0.06043079f, 0.03797658f, 0.02958022f, -0.01366468f, -0.00463347f, 
    -0.06431767f, 0.00071162f, 0.02101372f, 0.01177328f, -0.05355621f, -0.05187684f, -0.05167583f, -0.01455618f, 
    -0.01429518f, 0.03584793f, 0.03618847f, -0.05409563f, -0.05739348f, -0.03208616f, 0.01471546f, 0.03189004f, 
    -0.00232227f, 0.01019125f, -0.02516224f, -0.03423420f, 0.05064628f, 0.04195180f, -0.01173944f, -0.06156962f, 
    -0.03746845f, -0.04983712f, -0.00420143f, -0.03062629f, -0.03120371f, -0.04748985f, -0.01627313f, -0.01948267f, 
    0.01964268f, -0.01207580f, 0.03741096f, -0.03241782f, -0.06622327f, 0.01029216f, -0.02413397f, 0.02476686f, 
    -0.06467058f, 0.03772086f, -0.01572744f, 0.02616977f, 0.05471816f, -0.05441133f, -0.04334600f, -0.06231056f, 
    0.00560231f, -0.05024849f, 0.00066493f, -0.02058690f, 0.03938613f, -0.01700684f, 0.04810057f, -0.03905251f, 
    0.05555021f, -0.06426539f, -0.00115535f, 0.00736933f, -0.05109560f, 0.04215384f, 0.05272620f, 0.02383551f, 
    0.04602354f, -0.05224234f, -0.00547713f, 0.00212239f, -0.05822001f, -0.00703887f, 0.01988881f, -0.01859620f, 
    0.04823677f, -0.01539342f, -0.05043815f, 0.04731618f, 0.01292290f, -0.05807563f, 0.01132367f, 0.02324083f, 
    0.01877577f, -0.00322675f, -0.06072507f, -0.04457244f, 0.02690960f, 0.03915058f, -0.01682187f, -0.04952372f, 
    -0.05068894f, -0.01000141f, 0.02309815f, -0.02354246f, 0.04654318f, 0.02500974f, -0.05092668f, -0.01510015f, 
    0.03590937f, -0.02776529f, -0.04732800f, -0.06331421f, -0.02889433f, 0.01088173f, -0.04985329f, -0.01233621f, 
    -0.06878632f, -0.01509154f, -0.00027939f, 0.00516647f, -0.02402033f, 0.01487813f, -0.02245870f, -0.03670615f, 
    0.01898589f, 0.05745272f, -0.01052559f, -0.03381055f, 0.01174237f, 0.01857938f, -0.02627088f, 0.04243249f, 
    -0.03968280f, 0.03673168f, -0.01536726f, 0.01600779f, -0.05568442f, -0.05164368f, 0.03124151f, -0.00309513f, 
    0.00995227f, 0.03679778f, -0.05520730f, 0.04070078f, 0.03317142f, -0.01829741f, -0.00153202f, -0.03709853f, 
    0.05367308f, 0.01736915f, 0.01207219f, -0.00120785f, -0.02170971f, -0.04770977f, -0.03582554f, -0.00857754f, 
    -0.03216266f, -0.04505942f, -0.06064202f, -0.02696751f, 0.01941642f, 0.04877220f, 0.04508299f, 0.01278529f, 
    -0.05446553f, 0.04113972f, 0.03938112f, 0.01526062f, -0.06171623f, 0.02188590f, -0.00036700f, -0.00255682f, 
    0.02436575f, 0.01800816f, 0.02027776f, 0.04469091f, -0.00904162f, 0.02181820f, -0.01264023f, -0.05901081f, 
    -0.01405072f, -0.03714402f, -0.05165545f, 0.00840341f, 0.03852510f, 0.00132489f, 0.03797959f, 0.02053441f, 
    0.02416570f, -0.00955727f, 0.00694253f, 0.03728148f, 0.01873718f, 0.03695420f, 0.02348717f, 0.00213588f, 
    -0.05573970f, 0.03404250f, 0.03961510f, -0.01768249f, -0.04710444f, -0.03325136f, -0.06442218f, 0.03720217f, 
    -0.02070068f, -0.04693686f, -0.01341381f, 0.01129831f, 0.02734738f, -0.06098919f, -0.03648920f, -0.04859538f, 
    -0.04564441f, 0.01601443f, -0.04452293f, 0.04989539f, -0.00289405f, -0.02033182f, -0.06162086f, -0.02880082f, 
    0.02559324f, -0.02430161f, -0.04178198f, -0.00783631f, -0.02605523f, -0.05284129f, 0.04336105f, -0.01253146f, 
    -0.03569995f, -0.00246044f, 0.02706152f, 0.00348713f, -0.03070973f, -0.01183247f, -0.01309237f, 0.05887059f, 
    0.04148858f, 0.04316173f, 0.00171793f, -0.05707704f, 0.00858673f, -0.05648968f, 0.04922158f, -0.03367976f, 
    0.01951236f, -0.03858795f, -0.01921151f, -0.06343383f, 0.01581705f, 0.04327562f, 0.04721178f, -0.04639926f, 
    0.03674474f, -0.03050781f, -0.00591995f, -0.05072939f, -0.06420030f, 0.01247096f, -0.00309959f, 0.02469758f, 
    -0.05720657f, -0.02585466f, 0.01672730f, 0.04629086f, -0.02105906f, -0.03682801f, -0.03700970f, -0.03294978f, 
    0.04057935f, 0.00607308f, -0.04028122f, 0.02693162f, -0.00797518f, -0.03060329f, -0.05290863f, 0.02904241f, 
    0.02416863f, -0.05513525f, 0.03065084f, -0.03422278f, 0.02384461f, 0.02557511f, -0.04867112f, 0.02596954f, 
    -0.05271454f, 0.02361154f, 0.01878175f, 0.01669889f, -0.00428479f, 0.04314027f, 0.04720354f, 0.02191087f, 
    -0.03249073f, -0.01180464f, 0.03535764f, 0.03301593f, 0.05098218f, -0.02182653f, -0.00575321f, 0.04728743f, 
    0.01570341f, 0.00677619f, -0.04002690f, 0.00223277f, -0.01075768f, -0.01380919f, 0.00457675f, -0.06062547f, 
    0.01954525f, -0.06705569f, 0.00065170f, -0.05432725f, -0.03881607f, -0.05548107f, -0.04985764f, 0.03766898f, 
    -0.01942555f, -0.01896142f, -0.00849429f, 0.02596316f, -0.05809815f, 0.03046848f, -0.01764596f, -0.01206680f, 
    -0.01215906f, -0.00528528f, 0.05002995f, -0.03403206f, -0.03206743f, 0.03080539f, -0.02677094f, 0.02865169f, 
    -0.02925553f, -0.02665031f, -0.04691506f, 0.05676008f, -0.04068946f, -0.01726879f, -0.04268434f, -0.00781424f, 
    -0.01777693f, -0.03994146f, 0.00727054f, -0.04487832f, 0.01338830f, 0.03418150f, 0.01697164f, -0.02277298f, 
    -0.06083904f, 0.03255711f, 0.01895327f, -0.00901612f, -0.05527862f, -0.05178124f, -0.04478822f, 0.01325856f, 
    -0.02598266f, 0.03772340f, 0.00898918f, -0.01508456f, -0.01594920f, 0.03616016f, -0.02859753f, 0.03292300f, 
    -0.00415306f, 0.04951199f, -0.04484831f, -0.03750892f, -0.03001121f, -0.05172366f, -0.05299338f, 0.02987811f, 
    0.02940337f, -0.04619235f, -0.03859419f, -0.01876805f, 0.03243098f, 0.00792648f, 0.02311553f, -0.03501175f, 
    0.00536412f, 0.03302770f, 0.02036806f, -0.00767631f, -0.01574102f, -0.05115290f, -0.01217967f, -0.00012362f, 
    0.04614840f, 0.05929787f, -0.01292061f, 0.03972193f, 0.04675026f, 0.00635408f, -0.01067487f, 0.04576143f, 
    -0.06149444f, -0.01686889f, -0.05658037f, -0.04378795f, -0.02005757f, -0.03984543f, -0.01354824f, -0.05883899f, 
    0.04940267f, 0.00020605f, -0.04399285f, -0.01943805f, -0.06442155f, 0.00584837f, -0.00951476f, -0.06063475f, 
    0.02192944f, 0.01272000f, -0.04320621f, -0.00107800f, 0.04229520f, -0.06012110f, 0.00586135f, 0.00202461f, 
    -0.04074832f, 0.01249334f, -0.03672775f, -0.04543296f, -0.00240778f, 0.04791813f, -0.03167261f, 0.00522640f, 
    -0.03613565f, -0.00498531f, 0.02450930f, 0.00171914f, 0.02716956f, -0.04811369f, -0.03217861f, -0.02933962f, 
    -0.04809413f, 0.05298465f, 0.00057849f, -0.05802198f, 0.00056860f, 0.03843103f, -0.02003882f, 0.01013641f, 
    -0.00235742f, 0.02224794f, 0.00753184f, -0.05887623f, -0.04929015f, 0.03558939f, -0.02766322f, -0.03110025f, 
    0.00614279f, 0.04839475f, -0.01910701f, -0.01007171f, 0.03625360f, 0.04643337f, 0.03866465f, -0.01836202f, 
    0.02997757f, -0.01695425f, 0.02844075f, -0.01924898f, -0.03237683f, -0.05682024f, 0.02519150f, -0.03866785f, 
    -0.05456550f, -0.01873151f, -0.02822915f, -0.01056980f, -0.02856912f, -0.01212462f, -0.05214754f, 0.04741075f, 
    -0.00827085f, 0.02479219f, -0.00920181f, -0.04705786f, -0.03742122f, -0.03048634f, -0.05779788f, 0.02070666f, 
    0.03435536f, 0.03096880f, -0.02695349f, -0.01170238f, 0.05883316f, -0.01649118f, 0.03896044f, -0.00388512f, 
    -0.04614706f, -0.00596666f, -0.02704985f, 0.00699794f, 0.03696535f, -0.05748754f, 0.01150504f, -0.04548937f, 
    -0.06009592f, 0.02160764f, 0.01183271f, -0.03068960f, -0.05663572f, 0.03515667f, 0.04394251f, -0.02118474f, 
    -0.04289974f, -0.00229944f, -0.02379737f, 0.01642734f, -0.03517603f, -0.05596514f, 0.03016681f, -0.05330995f, 
    -0.03994586f, 0.05272364f, -0.05161374f, -0.02472526f, -0.01294642f, 0.01648462f, -0.04818374f, -0.01652483f, 
    -0.01295611f, -0.01920955f, -0.00438624f, -0.00734215f, 0.04754152f, 0.02508805f, -0.06706711f, 0.04657455f, 
    -0.04848790f, -0.06132422f, -0.05204977f, -0.03527728f, -0.02660630f, 0.03328837f, 0.02896645f, 0.02425852f, 
    0.05659644f, -0.01922868f, -0.04147469f, -0.06126981f, 0.03667287f, -0.05181815f, -0.01513834f, -0.06316587f, 
    -0.03244052f, 0.00870364f, -0.01395157f, -0.02079661f, -0.00558012f, -0.03018007f, 0.02798669f, -0.03909809f, 
    -0.02486780f, -0.03850468f, 0.02534255f, 0.04405735f, 0.04236617f, 0.02846914f, 0.02327721f, -0.05800592f, 
    -0.05221092f, -0.02735228f, -0.01075614f, 0.04678548f, 0.03289333f, 0.00711014f, -0.04141017f, -0.02144586f, 
    -0.01238646f, 0.04716967f, -0.03083042f, -0.00252865f, -0.04763601f, 0.02688829f, -0.00401478f, -0.03335590f, 
    0.02746707f, -0.00552944f, 0.03715276f, -0.00529931f, 0.00662327f, -0.05977479f, 0.00167964f, 0.01245124f, 
    -0.00799641f, -0.05550668f, 0.04747560f, 0.03783761f, -0.02564521f, 0.04578035f, -0.06545219f, -0.02776954f, 
    0.00665038f, -0.02603232f, -0.02540459f, -0.05530007f, 0.00734007f, 0.00488836f, -0.02977720f, -0.00954581f, 
    0.00702121f, -0.02898215f, -0.01342451f, -0.01510452f, -0.02665366f, -0.03337028f, -0.01369302f, 0.01194067f, 
    -0.03019365f, -0.03540829f, -0.05280575f, -0.02620112f, -0.04042786f, -0.01055833f, -0.00266075f, 0.01107017f, 
    -0.05831840f, 0.00964024f, -0.02139118f, -0.03885460f, -0.05974253f, 0.04319185f, 0.02376338f, -0.02523286f, 
    0.02215783f, -0.05171230f, -0.01493955f, 0.04917447f, 0.05286993f, -0.05625967f, -0.01670715f, 0.01543181f, 
    -0.04540092f, -0.01535338f, 0.02692522f, 0.02561073f, -0.05841960f, 0.00593086f, -0.03995397f, 0.03671349f, 
    0.02076675f, -0.03661164f, -0.03638531f, 0.05028787f, 0.02039760f, -0.04314378f, 0.02020531f, -0.05784927f, 
    0.04880505f, 0.01804302f, 0.01207242f, 0.03096588f, 0.02644680f, -0.02897909f, -0.02462807f, -0.05161093f, 
    -0.00636321f, -0.01063355f, -0.02790506f, -0.03034261f, 0.02849674f, 0.02703982f, -0.04298080f, -0.01406859f, 
    0.04364578f, -0.03301351f, -0.05125042f, -0.05169822f, 0.00169001f, -0.04033381f, -0.03077536f, -0.06118854f, 
    0.00106292f, 0.02373236f, 0.05189142f, 0.03423147f, -0.06265030f, 0.02921343f, -0.06351995f, 0.02725198f, 
    -0.06663080f, 0.04828637f, -0.02620670f, -0.02490702f, 0.02617962f, 0.00554271f, -0.04287717f, -0.00811649f, 
    0.03694247f, -0.05560927f, 0.03986023f, -0.04821742f, 0.04476412f, -0.05389846f, 0.00987674f, 0.04428066f, 
    -0.01131885f, -0.03712766f, -0.00963537f, -0.02649356f, 0.05345455f, 0.01942165f, -0.01364211f, -0.04309455f, 
    0.04742110f, -0.00782780f, -0.01726773f, 0.04465283f, 0.03718311f, -0.05172412f, -0.05567693f, -0.03028396f, 
    -0.04013760f, 0.00313486f, -0.01506785f, -0.03099486f, 0.00321334f, 0.04794666f, 0.03948034f, 0.03129351f, 
    -0.02250523f, -0.02288804f, 0.03833790f, 0.00800474f, -0.00651367f, 0.03780942f, -0.00769831f, -0.00354128f, 
    -0.04429869f, 0.01660343f, -0.04154436f, 0.04333693f, -0.00160134f, -0.00576499f, 0.00189138f, 0.02569393f, 
    0.00639767f, 0.03809546f, 0.05580198f, 0.02622358f, 0.00798298f, -0.04660282f, -0.05656593f, -0.05301441f, 
    0.02730263f, -0.06475052f, 0.03056950f, 0.03821887f, 0.04476933f, 0.04378083f, -0.00752339f, 0.00421739f, 
    0.02638895f, 0.00200891f, -0.02333042f, 0.01460177f, 0.04162690f, 0.02739546f, -0.02958011f, 0.03725155f, 
    -0.06300551f, 0.02193589f, -0.00354705f, -0.04262527f, -0.02480180f, 0.02014747f, 0.00853232f, 0.01376524f, 
    0.03396662f, -0.03183388f, -0.04801131f, -0.05226518f, 0.00629983f, -0.03227102f, 0.03339098f, -0.04319422f, 
    -0.02987280f, 0.04701364f, 0.01596954f, -0.03720757f, 0.03895066f, 0.03580790f, -0.04159238f, 0.00188256f, 
    -0.02826868f, -0.04126997f, 0.01665968f, 0.03463563f, 0.03674982f, 0.01124453f, -0.04127175f, 0.00429699f, 
    0.03739512f, 0.01955188f, 0.01789438f, -0.04082046f, -0.05777211f, -0.02332755f, 0.00136762f, -0.05916013f, 
    -0.04778520f, 0.02915181f, 0.01520845f, 0.02978526f, 0.03719189f, 0.03598198f, 0.02020993f, -0.06294325f, 
    0.02802130f, 0.01389697f, -0.04715430f, 0.02947314f, -0.05314208f, -0.04848103f, -0.02602199f, -0.01049656f, 
    0.03825603f, -0.03023411f, 0.01139288f, -0.06433187f, -0.03014901f, -0.02760803f, -0.03298369f, -0.01199076f, 
    0.02977482f, -0.03022143f, -0.03526091f, -0.05283016f, -0.01626576f, -0.03012774f, 0.02560571f, 0.03218203f, 
    -0.00190032f, 0.01222107f, -0.04773451f, -0.05190534f, -0.01464283f, -0.03526881f, -0.04478421f, 0.01608648f, 
    -0.02185941f, -0.05514203f, -0.05310291f, 0.04185558f, 0.04015436f, -0.00042295f, -0.00414802f, -0.03743151f, 
    -0.01879665f, -0.02881273f, -0.06665795f, -0.00469298f, 0.03306875f, 0.02943889f, -0.03695156f, -0.04561983f, 
    0.01033655f, -0.03595446f, -0.00114233f, 0.03858932f, -0.02634970f, 0.03931946f, 0.04472763f, 0.04743493f, 
    0.02416543f, -0.03511873f, 0.00295233f, 0.00984870f, 0.00450610f, -0.04408348f, 0.04156752f, 0.02225665f, 
    -0.00740251f, -0.01663296f, -0.03334105f, 0.00394966f, -0.04177344f, 0.00407642f, -0.04423720f, -0.05732375f, 
    -0.02273966f, -0.05209632f, 0.01202140f, -0.05419195f, 0.01807279f, -0.01733469f, 0.02844823f, -0.01184119f, 
    -0.06662255f, 0.04130380f, 0.02365485f, -0.03179307f, 0.00930728f, 0.03990996f, 0.01335421f, 0.03103180f, 
    -0.02749239f, 0.00272423f, -0.02654762f, -0.00582026f, -0.06282271f, -0.01886513f, -0.03214192f, -0.00240921f, 
    -0.03247006f, -0.05327634f, -0.04356021f, -0.02403427f, -0.05032781f, -0.00596394f, -0.00459512f, 0.03672574f, 
    -0.03886480f, -0.01128012f, -0.02306428f, -0.02770191f, -0.04974101f, 0.01892966f, -0.04459051f, -0.03826106f, 
    -0.02349038f, -0.00226004f, -0.01682913f, -0.03471487f, -0.00358140f, 0.05166965f, -0.03145152f, 0.03060020f, 
    -0.00500391f, 0.03931365f, 0.03822908f, -0.02568736f, 0.00778501f, 0.01622150f, 0.03643012f, -0.04612283f, 
    -0.04198058f, -0.05880828f, -0.05453019f, -0.04775747f, -0.05774137f, -0.03035115f, -0.06698053f, -0.04752428f, 
    -0.01362215f, 0.00707933f, -0.06665396f, 0.04082085f, -0.01911961f, -0.00021953f, -0.03069850f, -0.03240114f, 
    0.02375454f, -0.03863431f, 0.02098835f, 0.00356546f, -0.00266421f, 0.01525475f, -0.05961382f, 0.04684370f, 
    -0.04823650f, -0.05585462f, -0.05322720f, -0.04958756f, -0.02043143f, 0.02591904f, 0.03915485f, -0.02989679f, 
    0.01752511f, 0.04043864f, 0.01058875f, 0.01274391f, 0.00756159f, 0.02204768f, 0.04251429f, -0.04622178f, 
    -0.04246322f, 0.02482601f, -0.06922699f, 0.00429321f, -0.03299074f, -0.03672936f, 0.03780802f, 0.02452391f, 
    -0.02398178f, 0.01704751f, -0.05490795f, 0.02396101f, 0.03193696f, 0.00194503f, -0.06529404f, -0.05851765f, 
    -0.05742353f, -0.05492101f, 0.02471862f, -0.02807102f, 0.04770281f, -0.03373511f, -0.02412700f, -0.05898893f, 
    -0.03295843f, -0.03960998f, 0.03633354f, -0.04439774f, 0.01786486f, -0.03361246f, 0.01909385f, 0.02746454f, 
    -0.01781896f, -0.05427196f, 0.00988165f, -0.02048705f, 0.03024004f, 0.01178014f, -0.01742757f, 0.03526761f, 
    -0.04799928f, -0.05286917f, 0.00213051f, -0.00816412f, -0.02675725f, -0.01651027f, -0.00844971f, 0.02044747f, 
    0.05318563f, -0.06122512f, 0.03338858f, 0.03199790f, -0.06515069f, 0.01708854f, -0.01917815f, -0.02228955f, 
    -0.01961740f, 0.02776665f, 0.00372902f, -0.02760411f, -0.06199372f, 0.03310637f, 0.03640880f, 0.00278402f, 
    -0.00828188f, 0.03769114f, -0.06591260f, 0.00361486f, -0.03120788f, 0.04692263f, 0.03242864f, -0.03759558f, 
    0.02724830f, -0.01188975f, -0.01851417f, 0.00337613f, -0.03617135f, 0.03023061f, 0.05030650f, 0.01692119f, 
    -0.04970693f, 0.04354447f, 0.04689056f, -0.01501654f, 0.00613460f, 0.05047277f, -0.02746503f, -0.01235466f, 
    -0.02225927f, -0.02079634f, 0.06943585f, 0.27907172f, -0.09693038f, -0.02479008f, 0.12388036f, -0.02903370f, 
    0.01676306f, 0.07120346f, 0.31244904f, -0.25849983f, -0.00604945f, -0.14489670f, -0.15429872f, -0.03092182f, 
    0.09107582f, 0.03355458f, -0.18225363f, -0.18711820f, -0.51232928f, -0.00541300f, -0.00483607f, 0.02960183f, 
    0.05538677f, -0.06377282f, 0.01791543f, -0.14460869f, -0.11713576f, 0.03406477f, 0.21062529f, -0.09437586f, 
    -0.21859433f, 0.12095102f, 0.07174651f, 0.11583324f, -0.12821047f, -0.17691980f, -0.13903649f, 0.02574169f, 
    -0.10323720f, -0.12865734f, 0.14239068f, -0.08038320f, -0.06606544f, 0.10877136f, 0.09119576f, -0.05750840f, 
    0.01077966f, -0.06937550f, -0.03750924f, 0.01190498f, 0.21933667f, 0.00621921f, -0.04054776f, -0.22492272f, 
    0.10774691f, 0.02670813f, -0.07247000f, -0.11575405f, -0.00848441f, 0.01358217f, 0.14810733f, -0.17122282f, 
    -0.02700050f, -0.30404821f, -0.08885923f, -0.06366045f, -0.03798566f, -0.09614851f, -0.02685433f, 0.17346393f, 
    -0.07463928f, 0.20014840f, 0.14346337f, -0.00732930f, -0.04474312f, -0.20637272f, -0.02686433f, 0.08979430f, 
    -0.15911233f, -0.31941491f, 0.03289777f, 0.26736966f, -0.09654393f, -0.03758143f, -0.08937884f, 0.12843594f, 
    0.01494885f, 0.02651421f, -0.19392172f, -0.13670224f, -0.08022852f, 0.03156986f, -0.07990665f, -0.02360145f, 
    0.08944785f, 0.01639535f, -0.08537474f, -0.32624945f, 0.38825667f, 0.32015949f, 0.06424940f, 0.12642594f, 
    -0.03857598f, -0.00023239f, 0.07520559f, 0.11037286f, 0.13704599f, 0.04457882f, -0.38597190f, 0.15401961f, 
    0.04759855f, -0.05100776f, 0.14093298f, -0.12045999f, -0.06300630f, 0.05924907f, 0.12625240f, 0.11890989f, 
    -0.09410229f, 0.00849331f, 0.02945341f, -0.16263025f, 0.07586039f, 0.11643299f, -0.05107976f, -0.11202107f, 
    0.08947813f, 0.11707372f, 0.09171002f, 0.00899205f, 0.10244337f, 0.20979880f, 0.12638363f, -0.01253684f, 
    -0.07683050f, -0.17855372f, -0.04242974f, 0.06580775f, -0.04496681f, -0.01386221f, -0.11663204f, 0.04600311f, 
    -0.42646676f, 0.05300549f, 0.16123679f, -0.19517680f, -0.07700639f, -0.17600678f, 0.15849265f, 0.13256963f, 
    -0.11430822f, 0.01651137f, -0.26234913f, -0.08455597f, 0.13586533f, -0.01853964f, -0.00023721f, -0.10351598f, 
    0.01724431f, -0.06129448f, 0.13372463f, 0.11332497f, -0.09375500f, 0.00051023f, -0.03613239f, -0.11674925f, 
    0.20111391f, -0.12762432f, -0.00805115f, -0.19271480f, 0.02671844f, 0.10276873f, 0.03699472f, -0.01590624f, 
    -0.03835812f, 0.12118247f, 0.02853942f, -0.13606781f, -0.08622148f, -0.22330460f, -0.26980856f, 0.21314542f, 
    -0.01081299f, 0.25629869f, 0.13414972f, 0.07784248f, 0.05594033f, -0.05359121f, -0.05160687f, 0.46141845f, 
    0.00984839f, -0.10672423f, -0.15835449f, -0.04273730f, 0.07620135f, 0.05028697f, -0.00249082f, -0.05510529f, 
    -0.42903423f, 0.07833233f, -0.02992472f, -0.10876358f, -0.12171427f, -0.18874703f, -0.01123591f, -0.00863752f, 
    0.01547508f, -0.14590426f, 0.17392525f, 0.05966136f, 0.02706614f, 0.09668525f, 0.05730994f, 0.10118936f, 
    0.28518862f, 0.27515072f, 0.09499858f, -0.16675250f, -0.04297549f, -0.01792933f, -0.00345510f, 0.04594412f, 
    -0.17946424f, 0.01767057f, 0.11485089f, 0.00470065f, 0.03854829f, -0.09007698f, 0.07133181f, 0.01188729f, 
    -0.04398959f, 0.01800120f, 0.12306229f, -0.02105066f, 0.18817489f, 0.01484114f, -0.00710527f, 0.01166144f, 
    -0.01340990f, 0.09718804f, 0.22988558f, -0.03075624f, -0.27366942f, -0.01979992f, -0.08283191f, -0.11865276f, 
    -0.02501800f, 0.22144374f, -0.02681151f, 0.06201708f, 0.13459699f, -0.00824664f, -0.01481632f, -0.18272838f, 
    0.01989266f, -0.05258893f, 0.17396396f, -0.06436897f, -0.13487998f, 0.06260054f, -0.00597234f, 0.02575585f, 
    -0.08624566f, -0.00277857f, 0.01596652f, 0.10857382f, -0.05006084f, 0.11796901f, 0.06774333f, 0.16657233f, 
    0.00818971f, -0.04694394f, -0.00781245f, -0.06413815f, 0.12724523f, 0.12337201f, 0.16066578f, -0.47732928f, 
    -0.14378369f, 0.07094288f, 0.01882580f, 0.06105129f, 0.01139741f, 0.03536733f, 0.01878959f, 0.03290490f, 
    0.32652476f, 0.19003898f, 0.03555793f, 0.08766451f, -0.22831658f, 0.04455934f, -0.08623822f, -0.04537334f, 
    0.04549518f, -0.01512391f, -0.05833230f, 0.15017866f, 0.06215938f, -0.26843584f, -0.10389846f, -0.02254428f, 
    0.13564716f, 0.15918373f, 0.08147188f, -0.01599279f, -0.41395530f, 0.07518892f, 0.01970507f, 0.18916894f, 
    -0.03721691f, -0.04381802f, -0.15183555f, 0.10391045f, -0.05121175f, -0.00070984f, -0.17616610f, 0.00514697f, 
    0.19840553f, 0.19773149f, 0.16123594f, 0.05800161f, -0.03915553f, 0.22907270f, 0.13908063f, 0.19997638f, 
    -0.02305780f, -0.07669880f, -0.04857290f, 0.06103390f, 0.14009872f, 0.07110846f, 0.08216138f, 0.01988978f, 
    -0.09930875f, -0.06504995f, -0.14712387f, -0.11047874f, 0.33704278f, -0.06167177f, 0.09959670f, 0.05830056f, 
    0.15532720f, 0.15736768f, -0.15521815f, -0.01343157f, -0.05953824f, 0.08878853f, 0.09528473f, 0.13807866f, 
    0.13665110f, -0.11389935f, -0.02851729f, 0.17427787f, 0.05904404f, 0.13705075f, 0.11489192f, 0.16097826f, 
    -0.08357490f, -0.05153799f, -0.21530215f, 0.08943786f, -0.02759931f, -0.01240151f, -0.05711432f, 0.07123593f, 
    -0.28795290f, -0.03487728f, 0.22327490f, -0.20851487f, -0.11091560f, 0.20399199f, 0.00207443f, 0.05035363f, 
    0.14458814f, -0.00205450f, 0.02944234f, 0.06115702f, -0.13764258f, -0.08220351f, -0.06486217f, 0.23639722f, 
    -0.07946249f, -0.09556825f, 0.08723912f, 0.02526230f, -0.07143722f, 0.00473387f, 0.08815064f, 0.13946559f, 
    0.01616555f, -0.00158180f, 0.15941039f, -0.18258800f, 0.21403560f, -0.37816370f, -0.28723341f, 0.24717881f, 
    0.04472642f, -0.10176750f, -0.04086027f, 0.13092472f, -0.07601596f, -0.16133040f, -0.24340732f, -0.36410636f, 
    -0.12346967f, 0.17280011f, 0.06546298f, -0.06086719f, -0.17486690f, 0.02556729f, 0.04376801f, 0.11559009f, 
    0.07278620f, -0.00839794f, -0.07225554f, 0.09948704f, -0.31791109f, 0.12295644f, -0.12487821f, 0.00149096f, 
    -0.16486917f, 0.05713715f, -0.01943356f, -0.02816738f, -0.03733894f, 0.04392324f, -0.05871342f, 0.00420391f, 
    -0.03181942f, 0.07169900f, -0.29130521f, -0.05809119f, 0.00325525f, 0.00206053f, 0.01422063f, -0.03937355f, 
    0.00916637f, -0.02429149f, 0.15224503f, 0.18832617f, -0.01456993f, -0.21968979f, -0.14921673f, -0.29196367f, 
    0.10987802f, -0.07902575f, -0.30809256f, -0.04172596f, -0.12671326f, 0.00778062f, 0.06389387f, 0.06865016f, 
    0.08340678f, -0.16327828f, -0.22413152f, -0.51282144f, 0.24864505f, 0.07447165f, 0.06732169f, 0.01379592f, 
    0.20411357f, 0.03186152f, 0.11774619f, 0.00049041f, 0.23671512f, 0.01481072f, -0.43191180f, 0.01763578f, 
    -0.08223952f, 0.17745648f, -0.05692544f, -0.20779794f, -0.02288189f, -0.03895871f, 0.08651000f, 0.15195104f, 
    -0.07621390f, -0.13639382f, 0.06460387f, -0.01351585f, -0.00584557f, 0.05985402f, 0.09337571f, -0.22614519f, 
    -0.03646002f, -0.02585654f, 0.06892419f, 0.09138127f, -0.10801590f, -0.23080906f, 0.10080881f, 0.01807159f, 
    0.11662292f, 0.12688370f, -0.01619836f, -0.00318008f, 0.14241111f, 0.10972042f, -0.17113967f, -0.01045377f, 
    -0.10961498f, 0.02639317f, 0.21689703f, -0.17218645f, 0.02658790f, -0.13534465f, 0.08413154f, 0.09120020f, 
    -0.08736508f, -0.08278733f, 0.18983105f, -0.03165806f, 0.10599992f, 0.17470360f, 0.25122175f, -0.40545353f, 
    0.27303201f, -0.20621116f, 0.13243660f, 0.20745195f, 0.03700649f, 0.18786809f, 0.11546303f, -0.08071710f, 
    0.07265809f, -0.03352141f, 0.03270009f, 0.36137918f, 0.06257302f, 0.00759005f, -0.06465224f, -0.10977668f, 
    -0.13015127f, 0.25923002f, -0.04899174f, 0.09023657f, -0.41531935f, -0.10277045f, -0.12281972f, 0.05695709f, 
    0.03666313f, -0.20168991f, 0.06342067f, 0.00781358f, -0.08762642f, -0.02630157f, 0.06258482f, 0.18409647f, 
    -0.02263546f, -0.00427454f, 0.05661110f, 0.08911355f, -0.05112834f, 0.01361336f, 0.14675592f, 0.09342241f, 
    0.13661906f, -0.20092721f, 0.11813112f, 0.04419941f, -0.05188114f, -0.02871686f, 0.19561793f, 0.10020237f, 
    0.13797525f, -0.03921041f, -0.07073659f, 0.06033485f, 0.06898221f, -0.07956785f, 0.01707797f, 0.01997968f, 
    -0.07245129f, -0.01251807f, 0.02896952f, 0.04023520f, -0.01313621f, -0.03831519f, 0.01067965f, -0.01042678f, 
    0.00420465f, -0.03178381f, -0.02574858f, 0.01372276f, 0.02275833f, -0.05257080f, 0.03279780f, -0.04458768f, 
    -0.03201618f, -0.00336919f, -0.04527146f, 0.00354021f, -0.04233190f, -0.05437474f, 0.01681910f, -0.04599288f, 
    -0.04180412f, -0.01863990f, -0.06156788f, 0.03997301f, -0.05224379f, -0.04095730f, -0.02331336f, 0.01575935f, 
    -0.06500135f, -0.04648415f, 0.00401525f, -0.04955025f, 0.00106359f, -0.04147308f, 0.03320184f, -0.02171472f, 
    -0.05645853f, 0.00281321f, -0.01611043f, -0.04063024f, -0.05077186f, -0.06428370f, 0.00423680f, 0.03702231f, 
    0.01453434f, -0.05782127f, 0.01156543f, -0.00724208f, 0.04238213f, 0.00095794f, -0.06023854f, 0.03241221f, 
    0.03728829f, -0.01993321f, -0.04016412f, -0.01633006f, 0.01527489f, -0.03071999f, 0.03530761f, -0.02038600f, 
    -0.04407574f, 0.00350328f, 0.04015367f, -0.00041145f, -0.03909799f, -0.04985920f, 0.00702179f, 0.00249717f, 
    -0.04863042f, -0.05864299f, 0.00911298f, -0.03129698f, -0.01637581f, -0.02850892f, 0.01084400f, -0.04206372f, 
    0.04773699f, -0.06099536f, 0.03841508f, 0.02279058f, 0.03338570f, 0.02652444f, 0.04173699f, 0.03697521f, 
    -0.04996524f, -0.06036135f, -0.04066108f, 0.01414414f, -0.01560295f, -0.05927590f, -0.03711833f, -0.07410190f, 
    -0.00543318f, 0.05256198f, -0.04024176f, 0.00504304f, -0.00481831f, -0.06066519f, 0.03829844f, -0.01626702f, 
    -0.05340947f, -0.07775130f, -0.00891589f, -0.05351905f, 0.01752896f, -0.04971045f, 0.03720164f, -0.02874830f, 
    -0.00692834f, -0.06461799f, -0.02609130f, 0.01312615f, 0.04398233f, 0.04660841f, -0.04288950f, -0.05983301f, 
    -0.01921395f, 0.03309456f, 0.04352306f, -0.03853660f, 0.00453157f, -0.04377428f, 0.04005680f, 0.03071966f, 
    0.00368165f, 0.04604414f, -0.03926707f, -0.03202661f, 0.03478726f, -0.00353625f, -0.05667097f, -0.04742148f, 
    -0.04292518f, -0.05318503f, -0.05435918f, 0.04287047f, -0.04313600f, -0.01634313f, -0.00444520f, -0.03963917f, 
    0.00687582f, -0.03584415f, -0.04381576f, 0.00725074f, 0.02122034f, -0.04526464f, -0.03179264f, -0.07618984f, 
    -0.03920039f, 0.01816083f, -0.02291499f, -0.03961295f, -0.02024936f, 0.02969039f, 0.05302727f, -0.00061644f, 
    -0.03986479f, 0.02897609f, 0.01799160f, -0.00107827f, -0.01052956f, 0.00418563f, 0.05105643f, 0.04706797f, 
    -0.05257937f, 0.00901904f, -0.02317613f, 0.01359400f, 0.01732793f, 0.04814463f, -0.00899112f, -0.03656859f, 
    -0.00491334f, -0.00591945f, -0.05768637f, 0.03260405f, -0.05544541f, 0.00483252f, -0.05575112f, 0.03030812f, 
    -0.01761814f, -0.05785663f, -0.06345841f, -0.04512969f, -0.03206279f, 0.01422708f, -0.02685795f, -0.00876638f, 
    0.01904772f, -0.01378986f, 0.04038767f, -0.06671994f, 0.00474908f, 0.03956757f, -0.03753915f, -0.06644291f, 
    -0.05509641f, -0.01060406f, 0.04262505f, -0.03865744f, 0.06285630f, 0.00193761f, 0.05107986f, 0.02927652f, 
    -0.05634996f, 0.05304993f, 0.00968640f, 0.01005909f, -0.00082074f, 0.02437151f, -0.02922627f, 0.02790134f, 
    -0.05046041f, 0.01181390f, 0.00473100f, 0.01583496f, -0.01707958f, -0.05486955f, -0.02965043f, -0.04423641f, 
    -0.00298202f, 0.03369692f, 0.03581711f, 0.00653970f, -0.03549051f, 0.04698477f, -0.03131729f, -0.06225665f, 
    0.00153885f, -0.06796364f, -0.06481813f, -0.01283216f, -0.02298680f, 0.03348351f, -0.00160080f, 0.01969527f, 
    0.04545853f, 0.04108221f, -0.00330496f, 0.04131310f, 0.00561585f, 0.02576549f, -0.04816592f, -0.00756210f, 
    0.02304333f, -0.00146725f, -0.06434233f, 0.05189041f, -0.00331635f, -0.05284102f, -0.04639720f, -0.04165873f, 
    -0.03765910f, 0.05132831f, 0.04186962f, -0.01753766f, 0.00448889f, -0.03984256f, -0.00599426f, 0.01770137f, 
    0.04066924f, 0.04248866f, -0.03642453f, 0.03584202f, -0.04932937f, -0.01990378f, -0.00042170f, 0.02864609f, 
    -0.01820797f, 0.01752883f, -0.05151536f, 0.03770434f, 0.03754716f, -0.04628917f, 0.00863881f, -0.00631578f, 
    0.02804659f, -0.03935196f, 0.02642864f, -0.03174558f, -0.00192349f, -0.02401225f, -0.05524538f, -0.02109800f, 
    -0.25347003f, 0.14491077f, -0.02093740f, 0.12823977f, 0.02198479f, 0.21563508f, -0.15529497f, -0.14803246f, 
    -0.02687713f, 0.13575712f, 0.03616695f, -0.14600526f, 0.04345561f, -0.13356885f, 0.07005779f, 0.16163044f, 
    -0.00662142f, 0.10780350f, 0.11708110f, -0.18623382f, -0.48197955f, -0.16324235f, 0.08598252f, -0.08693945f, 
    -0.03568296f, -0.12297674f, 0.05129259f, -0.21796347f, -0.26646468f, 0.15858522f, 0.03166844f, 0.05564793f, 
    -0.07340887f, 0.24407110f, -0.03886847f, -0.06418046f, 0.21146111f, 0.16615517f, -0.03404368f, 0.09894039f, 
    0.09194227f, 0.08735194f, 0.00236049f, -0.04457936f, -0.03431939f, 0.03782368f, -0.08227795f, -0.01000312f, 
    0.15377530f, -0.06823450f, 0.04221989f, -0.13534701f, 0.15036082f, 0.15417327f, -0.13264413f, -0.09268187f, 
    0.16613862f, -0.02885179f, -0.07164745f, -0.01781569f, -0.03614791f, 0.06966191f, 0.23431477f, -0.03274924f, 
    -0.11408750f, -0.12703937f, 0.03679851f, -0.05620490f, -0.05969368f, -0.07544993f, -0.03495264f, 0.03820332f, 
    0.25789836f, 0.18286245f, 0.36995697f, 0.06176459f, 0.05951360f, 0.04976355f, 0.14538793f, -0.01439455f, 
    -0.01102940f, -0.03943156f, 0.10038175f, 0.06020861f, 0.04033974f, 0.00471422f, -0.17304185f, 0.03463446f, 
    0.01190614f, -0.05620857f, -0.11473877f, -0.16541319f, -0.05530557f, -0.01650397f, 0.01709835f, 0.01030099f, 
    -0.00524694f, -0.22111551f, 0.00692968f, 0.59068859f, -0.03866258f, -0.07711674f, 0.01669594f, -0.03942121f, 
    0.02741392f, -0.01428520f, -0.00288623f, 0.19679697f, -0.08310620f, -0.18549319f, -0.13990438f, -0.14670540f, 
    0.13227473f, -0.03407555f, -0.14524855f, 0.04185491f, -0.11438569f, 0.16247974f, 0.03648990f, 0.28765273f, 
    -0.11735369f, 0.01384490f, -0.15007013f, 0.08030819f, 0.02330311f, 0.11824888f, -0.32335410f, -0.38758066f, 
    -0.21280892f, -0.25810400f, 0.07526537f, 0.02835471f, -0.08357207f, 0.12260280f, 0.24727061f, 0.22913249f, 
    -0.15798710f, -0.30382779f, 0.06425674f, 0.17782468f, 0.14313857f, 0.06778779f, 0.04838760f, 0.06276260f, 
    -0.02989423f, 0.19147237f, 0.33354083f, 0.14087814f, 0.03323534f, -0.07252720f, 0.08801717f, -0.02680542f, 
    -0.15877964f, 0.00260963f, -0.02739174f, -0.03184802f, 0.13290632f, -0.05326714f, 0.13350290f, 0.01156246f, 
    -0.03270953f, 0.34752971f, 0.10695183f, -0.07618982f, 0.28362185f, -0.04613364f, 0.07075665f, 0.00829434f, 
    -0.12046301f, -0.16465913f, -0.10533079f, -0.32959157f, 0.26467949f, -0.16738181f, -0.06161291f, -0.09274497f, 
    0.00178510f, 0.05040465f, -0.00315882f, 0.01832690f, -0.27826685f, -0.07783132f, -0.22928210f, 0.03819185f, 
    0.09968912f, 0.02810930f, -0.08377706f, 0.07088868f, -0.12837292f, 0.22767016f, -0.06717102f, -0.00190275f, 
    -0.06807219f, -0.11214960f, -0.01555801f, -0.06230021f, 0.06160942f, 0.00517768f, 0.26034063f, 0.00119376f, 
    -0.12753604f, -0.09611047f, 0.01746500f, 0.07678070f, -0.19869331f, 0.04090498f, -0.11905196f, 0.07691276f, 
    0.04112617f, 0.01173043f, -0.01589169f, 0.06930126f, -0.00843618f, -0.11415939f, 0.08300442f, -0.08111783f, 
    0.08781362f, 0.21118532f, 0.25140885f, -0.14549199f, -0.18582581f, 0.02656192f, 0.17191638f, 0.10040533f, 
    0.08640888f, -0.33503929f, -0.09293546f, 0.03546920f, 0.05978722f, -0.01184911f, -0.24522902f, -0.21952222f, 
    0.10539004f, 0.01958737f, 0.58760589f, 0.09306392f, -0.24226147f, -0.23155560f, -0.06523015f, 0.15433091f, 
    -0.14530559f, -0.00217549f, 0.08602674f, 0.10285520f, 0.02262757f, 0.02935985f, -0.07608799f, 0.09694657f, 
    0.12687737f, -0.16405162f, 0.02882403f, -0.13768557f, 0.47847435f, 0.19662410f, -0.00959459f, -0.05732708f, 
    -0.14859712f, 0.02210134f, 0.03459655f, 0.08544649f, 0.00227532f, -0.05187627f, 0.09474491f, 0.12923020f, 
    -0.01083036f, 0.14060855f, 0.05151417f, 0.02821109f, 0.04026974f, -0.08180545f, 0.17100012f, 0.07713921f, 
    0.19310947f, 0.02290502f, 0.03828522f, 0.04115655f, 0.05678482f, 0.26985204f, -0.00814553f, -0.31587291f, 
    0.12965918f, -0.04968223f, 0.14027783f, 0.03890662f, 0.19302380f, -0.15221186f, 0.01046613f, 0.01058905f, 
    0.11089949f, 0.23296723f, 0.29704306f, -0.05831917f, -0.14908989f, -0.19240993f, 0.15213662f, -0.04960295f, 
    0.01881843f, -0.10744071f, -0.46722430f, -0.27497780f, -0.26051328f, 0.00981598f, -0.03398968f, 0.13452956f, 
    -0.08646055f, -0.06353166f, 0.30368331f, 0.08076521f, 0.01514187f, 0.14407733f, 0.07627910f, 0.07571503f, 
    -0.01084078f, 0.13510843f, -0.03519684f, -0.17433941f, -0.06605995f, -0.23175488f, -0.14092818f, 0.11175106f, 
    -0.01609599f, -0.04740955f, 0.12288520f, 0.10762368f, -0.11113086f, -0.05937598f, 0.19909118f, 0.03681463f, 
    0.01815324f, 0.06840395f, -0.13984330f, -0.12181629f, 0.06803193f, 0.03907837f, 0.17502318f, 0.11972907f, 
    0.07076371f, -0.03955226f, 0.13128689f, 0.10908201f, 0.09806727f, 0.00884769f, -0.21321744f, -0.04685038f, 
    0.10841831f, 0.05844894f, 0.06742056f, 0.19867934f, 0.15206085f, -0.00692822f, 0.17600229f, -0.15756664f, 
    0.26810786f, -0.21188560f, 0.05239455f, 0.05590987f, 0.12775096f, 0.04416494f, 0.21510112f, -0.04055593f, 
    -0.10259445f, -0.21812534f, -0.26073220f, 0.06829494f, -0.07775985f, 0.03628174f, -0.05402458f, -0.10992508f, 
    0.09057951f, 0.35973960f, 0.01617644f, -0.48789212f, -0.05333541f, 0.14092396f, -0.06797796f, -0.00739186f, 
    -0.15653318f, -0.27527043f, 0.11980880f, 0.12359189f, 0.29602402f, -0.02585004f, 0.10064898f, -0.10077369f, 
    0.03603382f, -0.08443265f, 0.03801434f, 0.09890121f, -0.01054883f, -0.11139658f, 0.11573576f, 0.05326331f, 
    0.14423425f, 0.13627131f, -0.13841575f, 0.18251082f, 0.11620114f, -0.15511291f, -0.08374832f, -0.02983091f, 
    0.06501027f, -0.09999353f, -0.05132210f, 0.03649123f, -0.17946933f, -0.25319082f, -0.03464504f, 0.02853489f, 
    -0.04719808f, -0.04497787f, 0.10545415f, 0.07336037f, 0.09948221f, -0.07365908f, -0.06274696f, -0.11220335f, 
    -0.05354697f, -0.18605012f, -0.00982620f, -0.29042161f, -0.01670868f, -0.19557074f, -0.15350702f, 0.18680182f, 
    0.01348102f, -0.08588685f, 0.06376876f, 0.24064845f, 0.13089237f, -0.05604094f, 0.06395673f, -0.01434742f, 
    -0.60333109f, -0.46954757f, -0.14389466f, -0.07309651f, 0.12628920f, 0.18714184f, -0.21651232f, -0.34426627f, 
    -0.05902389f, -0.02506636f, 0.18708768f, 0.10755549f, -0.11288438f, 0.22761911f, 0.05434079f, 0.11866640f, 
    -0.28415507f, 0.08999297f, -0.25819707f, -0.26795647f, -0.30206531f, -0.10829556f, 0.22621167f, -0.03635864f, 
    -0.11065546f, -0.11783297f, -0.04293170f, -0.34399733f, -0.09482875f, -0.00458531f, 0.08921656f, -0.17355600f, 
    -0.10464297f, -0.17330009f, -0.09374909f, -0.01833572f, 0.04700587f, 0.08742170f, 0.18440354f, 0.16105208f, 
    -0.10220841f, -0.02359044f, 0.19442345f, -0.08336900f, 0.04728495f, -0.15098265f, -0.37467048f, -0.09087408f, 
    0.06755080f, -0.21270758f, 0.03320205f, -0.10717555f, 0.17626914f, 0.18150689f, 0.24828279f, -0.02462173f, 
    0.12843338f, 0.11181659f, 0.01792065f, -0.02473578f, -0.03376224f, -0.00713081f, -0.05020944f, 0.24993281f, 
    0.04999011f, 0.37995625f, -0.03150748f, 0.03475991f, -0.04080682f, -0.18065704f, 0.10624439f, -0.08633824f, 
    -0.25142497f, -0.23772094f, -0.02492099f, 0.20426777f, -0.00363261f, 0.15152861f, -0.04492778f, 0.02540245f, 
    -0.04129365f, -0.33372283f, 0.13645582f, 0.17671932f, 0.13716327f, -0.03114675f, -0.12114870f, 0.08822991f, 
    0.02314692f, 0.01666036f, 0.07875862f, -0.18287469f, -0.04501534f, 0.19240108f, 0.17495953f, 0.07062521f, 
    0.16949715f, -0.02754791f, 0.04453526f, -0.10958292f, 0.34149474f, 0.09579088f, 0.05127159f, -0.05316390f, 
    0.00568884f, 0.07310541f, -0.04332984f, -0.01605791f, 0.22792354f, -0.45786563f, -0.29871038f, 0.21644323f, 
    0.07653053f, 0.10772801f, -0.07961608f, 0.02409960f, 0.16499606f, -0.09513442f, 0.27253163f, 0.32281253f, 
    -0.08178457f, -0.12757257f, -0.09822747f, 0.06082059f, 0.19561042f, 0.15763950f, -0.22967102f, -0.03419038f, 
    -0.02235912f, 0.08577172f, 0.07435362f, 0.12046142f, 0.10685126f, 0.05180924f, -0.09544946f, 0.04735060f, 
    0.34665143f, 0.42126396f, 0.01856196f, -0.09064369f, -0.17115657f, 0.28906861f, 0.07800159f, -0.05787029f, 
    -0.45100719f, -0.03256575f, -0.02196017f, 0.21038662f, 0.00073709f, -0.03265326f, 0.00726189f, -0.03541749f, 
    0.13607579f, -0.02108499f, -0.09487912f, -0.15181951f, -0.01532515f, -0.09405587f, -0.12701236f, -0.16210765f, 
    -0.09405448f, -0.07103866f, 0.12880847f, 0.02625758f, -0.15639183f, 0.04784007f, -0.21217269f, 0.16363190f, 
    -0.07960758f, 0.01129598f, -0.15670601f, -0.10565972f, -0.13986069f, 0.06277450f, -0.04466568f, -0.04959924f, 
    -0.05741571f, -0.04298449f, -0.05797150f, 0.02597949f, -0.02594596f, -0.27851388f, -0.09357451f, 0.05935096f, 
    -0.18473430f, 0.09976416f, -0.13443795f, 0.01102925f, 0.04351277f, -0.24255443f, -0.39450029f, -0.12358482f, 
    -0.12207519f, 0.05138161f, 0.12251865f, -0.15116958f, -0.00761009f, -0.07122146f, -0.62674838f, -0.40366408f, 
    -0.13119823f, 0.05644562f, -0.04735817f, 0.07948096f, 0.27630049f, -0.02663252f, 0.17150056f, -0.05776969f, 
    -0.05274920f, -0.04631003f, -0.00007837f, -0.11465497f, 0.00738056f, -0.00575732f, 0.25463530f, -0.08656847f, 
    0.28111622f, 0.09131108f, 0.21609820f, 0.13814567f, 0.11956105f, 0.03009375f, -0.00185886f, -0.03708863f, 
    -0.00314106f, 0.09768510f, -0.09147698f, 0.15218630f, 0.02782140f, -0.07260945f, 0.27355480f, 0.05977774f, 
    0.22271505f, -0.14132310f, -0.14196433f, 0.14193201f, 0.19163769f, -0.04946357f, 0.06455038f, 0.10423530f, 
    -0.27457145f, -0.10318565f, -0.04750581f, 0.00954943f, 0.12640949f, -0.13666439f, 0.02061550f, -0.03090088f, 
    -0.17418021f, -0.01844691f, 0.19345002f, -0.03882703f, 0.17759293f, -0.07905753f, -0.04004621f, -0.12812287f, 
    -0.01930882f, -0.07339320f, 0.10347704f, 0.05795422f, -0.05514201f, 0.24533860f, 0.28837770f, 0.08020274f, 
    -0.16397968f, -0.03250219f, -0.06764295f, 0.13907330f, 0.17458114f, 0.13211118f, -0.13638353f, 0.11547451f, 
    0.07220558f, -0.05252800f, -0.01082988f, -0.07965370f, -0.17772654f, 0.02851550f, -0.12813176f, -0.41743284f, 
    -0.08122317f, -0.51066417f, 0.10614174f, 0.01820457f, 0.12429288f, 0.22481105f, 0.16484407f, 0.07815664f, 
    0.14134796f, 0.22475703f, 0.26724830f, 0.18224613f, -0.11175644f, -0.27054188f, -0.15012775f, 0.05437746f, 
    0.03228923f, -0.51356632f, -0.28311813f, -0.08138454f, -0.01051380f, -0.07467953f, -0.11372217f, -0.10294209f, 
    0.01099685f, -0.07741428f, 0.03090439f, 0.05940811f, -0.01676664f, 0.06454446f, 0.03569537f, 0.04993834f, 
    0.12623706f, -0.16727194f, -0.05627246f, -0.27113736f, 0.01487636f, 0.21536377f, 0.10925322f, -0.01684999f, 
    -0.01988809f, 0.02671692f, -0.02091020f, 0.03391769f, 0.06936282f, 0.05959075f, 0.37270296f, 0.16348979f, 
    0.11662293f, 0.20434456f, -0.10225981f, -0.02271774f, -0.13737334f, -0.01450158f, 0.06319588f, -0.06317056f, 
    -0.04535976f, -0.10447779f, -0.07710724f, -0.09635140f, 0.10698491f, 0.13656746f, -0.52412456f, -0.31031829f, 
    0.00609045f, 0.06077060f, -0.02243018f, 0.01816674f, -0.01017527f, -0.02460521f, 0.09264819f, -0.12779827f, 
    0.20500542f, 0.01055856f, 0.07565940f, -0.03380577f, 0.08155340f, -0.05359385f, 0.00952147f, 0.01268970f, 
    0.24807853f, 0.12617856f, -0.06401877f, -0.06529378f, 0.12250562f, -0.12541850f, -0.08714847f, 0.21833134f, 
    0.12325963f, 0.21227385f, 0.18775636f, -0.14688823f, 0.02920146f, -0.17579749f, -0.16157170f, 0.17109327f, 
    0.09282562f, -0.02288177f, 0.02255700f, 0.13864297f, -0.02345368f, -0.12407308f, 0.03105577f, 0.01308978f, 
    0.05891960f, -0.09566051f, 0.05955293f, -0.67160767f, -0.07247274f, -0.15906897f, 0.05664465f, -0.10777491f, 
    0.05612727f, 0.00233527f, -0.00225098f, 0.07857418f, 0.29507136f, -0.06115667f, -0.02754216f, 0.11981288f, 
    0.29306236f, -0.11753730f, 0.08879521f, -0.01962935f, -0.08891694f, -0.23054253f, -0.28250840f, -0.08683545f, 
    0.19679020f, 0.01458267f, 0.03913537f, -0.01301778f, -0.00801628f, 0.09560221f, -0.24767184f, -0.03444815f, 
    0.01438849f, -0.02772381f, 0.10946433f, 0.08737567f, 0.12819333f, 0.15937111f, 0.24677557f, -0.37217900f, 
    -0.18740898f, 0.04624827f, 0.12631953f, 0.20003594f, 0.10783739f, -0.19873902f, -0.04330666f, -0.15072003f, 
    0.45455036f, 0.07122149f, -0.10559558f, 0.11286578f, 0.14424084f, -0.04996762f, 0.09086111f, 0.07903749f, 
    0.01421648f, -0.27066928f, -0.12957041f, 0.20517564f, 0.10931334f, 0.23851620f, -0.11548211f, -0.08776766f, 
    -0.00257467f, -0.07773500f, -0.07383907f, -0.14597175f, -0.09663428f, -0.18488191f, -0.06118190f, -0.10940622f, 
    0.03957259f, -0.23417233f, -0.10088956f, -0.14308582f, -0.34117949f, -0.29380187f, -0.08835519f, 0.08276180f, 
    -0.00564830f, -0.08670369f, 0.07135036f, -0.13041805f, -0.36206061f, 0.07419631f, -0.06236083f, 0.05518553f, 
    -0.07769842f, 0.17639898f, 0.17693990f, -0.08491168f, 0.13703384f, -0.43771347f, -0.04425611f, -0.10624380f, 
    0.14146659f, 0.13748419f, 0.11989621f, 0.20997122f, 0.01592516f, 0.19875443f, -0.06122462f, -0.03294346f, 
    -0.07487961f, -0.09205864f, 0.12366423f, -0.10596617f, 0.08568640f, 0.09612434f, -0.17123248f, -0.27620316f, 
    0.11987350f, -0.12553252f, -0.16742930f, -0.00057494f, -0.23040135f, 0.02073277f, -0.14384948f, -0.21411227f, 
    0.21425411f, 0.09862915f, 0.08934047f, 0.08064019f, 0.20435008f, 0.09872743f, -0.05018039f, 0.00663214f, 
    0.11695315f, 0.25350651f, -0.22227216f, -0.02293266f, 0.01482916f, 0.25167832f, -0.00440617f, -0.06059585f, 
    0.05490458f, -0.04177911f, -0.22234577f, 0.11054101f, 0.00158459f, 0.16489978f, -0.00692632f, 0.02130174f, 
    0.09457695f, -0.07920013f, 0.00254198f, -0.34724292f, 0.27095750f, -0.15742150f, 0.14147706f, -0.11742430f, 
    0.04638614f, -0.18228702f, 0.17434992f, 0.13566639f, -0.02363360f, 0.29888463f, -0.03293493f, -0.03460641f, 
    -0.11298251f, 0.00117606f, -0.26957881f, 0.23158254f, 0.10163307f, 0.31383657f, 0.03534604f, 0.23768462f, 
    0.07868913f, 0.22431324f, 0.09762677f, -0.00081336f, -0.02911338f, -0.09496332f, -0.22050387f, 0.16783264f, 
    -0.03971529f, -0.02030522f, -0.10269861f, 0.20828149f, -0.07761913f, -0.07743447f, 0.00410742f, 0.44969767f, 
    -0.00546363f, 0.24712460f, 0.00934409f, -0.08111760f, -0.08520827f, -0.13608485f, 0.09221974f, 0.14360416f, 
    0.35229036f, 0.18097888f, 0.02706998f, 0.07469163f, 0.02923708f, 0.09671027f, 0.00903975f, 0.24033728f, 
    0.27807173f, -0.26556969f, 0.09904917f, -0.11891539f, 0.19656920f, 0.08101064f, 0.25766715f, 0.06019141f, 
    0.14964764f, 0.01520114f, 0.10948195f, -0.30299574f, -0.15774648f, -0.00750215f, -0.07427476f, -0.06597501f, 
    0.00919672f, 0.02895985f, 0.08040560f, -0.23063529f, -0.19037092f, -0.23315777f, -0.08078960f, -0.03547128f, 
    0.22107242f, -0.05347018f, -0.03103674f, 0.02722746f, 0.51029497f, 0.10074193f, -0.31822476f, 0.09620366f, 
    0.11488514f, -0.22702417f, 0.11948485f, 0.18151304f, 0.02155809f, -0.54199958f, 0.17533910f, -0.01988002f, 
    -0.15160096f, 0.04576323f, -0.12349906f, 0.08557922f, 0.05659532f, 0.15557696f, 0.54725909f, -0.01867289f, 
    -0.11425249f, 0.10218083f, 0.16273394f, 0.14502385f, 0.05861508f, -0.01143482f, 0.22130209f, 0.22381689f, 
    -0.10532387f, -0.19053246f, 0.18833348f, -0.07117593f, -0.13842034f, -0.04889296f, 0.02016524f, -0.12356499f, 
    -0.21550031f, 0.00377381f, -0.09505061f, 0.05123906f, 0.07768194f, 0.19923674f, 0.00218161f, -0.14473468f, 
    0.04547772f, -0.02518831f, -0.07638941f, -0.28276566f, -0.02982080f, -0.07773939f, -0.21519427f, 0.03187310f, 
    -0.05133942f, -0.08178368f, -0.31782970f, -0.05036281f, -0.11218866f, -0.03178590f, -0.01748231f, 0.13744412f, 
    -0.00149442f, 0.14029564f, -0.19103003f, 0.42977098f, 0.06151034f, -0.14626189f, -0.07118872f, 0.04071389f, 
    -0.09047017f, -0.04287788f, -0.02817406f, -0.13081959f, -0.37819391f, 0.19564004f, 0.13273728f, 0.14324360f, 
    0.06155935f, 0.09627626f, -0.30367884f, 0.16424224f, 0.24352100f, 0.38919988f, -0.28572237f, -0.25064701f, 
    -0.03484845f, -0.11879800f, 0.02165361f, 0.05676131f, 0.08820937f, 0.07109571f, -0.24694778f, -0.20893757f, 
    -0.02146506f, 0.01905746f, 0.13737990f, 0.15666842f, 0.11697425f, -0.09000065f, -0.11795945f, 0.35374710f, 
    0.06204283f, 0.11681566f, -0.10810192f, -0.01521351f, -0.19619775f, 0.06210698f, 0.04055696f, 0.17285372f, 
    0.00555378f, 0.00671667f, 0.03969661f, 0.04147556f, 0.03953977f, 0.04751474f, -0.01665393f, -0.05541572f, 
    -0.06053944f, -0.01982797f, -0.01374728f, -0.03994806f, -0.05834226f, -0.02275523f, 0.00210601f, -0.01107137f, 
    0.05080672f, 0.01818690f, 0.00743671f, -0.05001403f, -0.00776111f, -0.00954746f, -0.03640244f, -0.01949282f, 
    0.01029466f, -0.00285989f, -0.00969258f, -0.03939383f, 0.02581256f, -0.01264195f, 0.01367155f, 0.01857297f, 
    -0.03035001f, 0.04937477f, -0.03911009f, -0.03817506f, -0.01377626f, 0.03701115f, 0.03138789f, -0.04002858f, 
    0.01706163f, 0.03329023f, -0.01510489f, -0.03017216f, -0.04247556f, 0.04429253f, 0.02882810f, 0.03353370f, 
    0.04169714f, 0.03225684f, -0.04529516f, 0.02710804f, -0.00759478f, 0.01757204f, -0.04859429f, -0.03161972f, 
    -0.04613093f, 0.03083554f, -0.03902207f, 0.01586686f, 0.03687119f, -0.00216533f, 0.03857879f, -0.01139802f, 
    0.05120438f, -0.04653164f, -0.02802593f, -0.02685588f, -0.01050405f, -0.05210456f, -0.03162375f, 0.01571986f, 
    -0.04068502f, -0.02124802f, -0.01507806f, -0.04814262f, 0.03735457f, 0.04701981f, -0.03272340f, -0.04471379f, 
    -0.01181753f, 0.04289496f, 0.03675433f, -0.06143463f, -0.00481469f, -0.00365509f, 0.02720283f, 0.02019551f, 
    0.00090191f, -0.04656297f, 0.00814784f, 0.00045574f, -0.02086926f, -0.06535721f, -0.02676055f, -0.05316484f, 
    -0.02044982f, -0.03205075f, 0.04194701f, -0.04792046f, -0.05740152f, 0.04440560f, -0.01934071f, -0.01124270f, 
    -0.04753705f, 0.02674431f, -0.01564549f, 0.00163436f, -0.02704937f, -0.02066172f, -0.03756136f, -0.03258292f, 
    -0.06164683f, 0.03279936f, -0.01832750f, -0.06559699f, -0.01842837f, 0.04123538f, 0.01992308f, -0.05069200f, 
    -0.00201542f, 0.04482644f, -0.03198471f, 0.02746190f, -0.04088345f, -0.04864890f, -0.01321029f, -0.00583107f, 
    0.01006472f, 0.01785897f, -0.00133242f, -0.02518555f, -0.05167060f, -0.00283242f, -0.02427185f, -0.03890050f, 
    -0.04842914f, -0.02306710f, 0.04371035f, -0.05386803f, -0.06020759f, -0.06474851f, 0.04283664f, -0.00240472f, 
    0.03604260f, 0.02275456f, -0.00012044f, 0.04438165f, -0.01892983f, 0.01974012f, 0.00578143f, 0.00651963f, 
    0.04446347f, -0.00988742f, -0.03174899f, -0.01229212f, 0.03119724f, -0.04517128f, -0.01526908f, 0.03099374f, 
    0.02146490f, -0.03253037f, -0.06067777f, -0.05868799f, 0.04915668f, -0.05102506f, -0.00672765f, -0.01412549f, 
    -0.06079619f, 0.00580973f, 0.03453733f, -0.05208679f, 0.04387238f, 0.03977931f, -0.05797821f, -0.04599000f, 
    -0.06738182f, -0.02241974f, 0.02118830f, 0.00533238f, 0.00307983f, 0.02489401f, -0.06469738f, 0.03939778f, 
    0.02188570f, -0.03807928f, 0.01074686f, 0.00616526f, 0.03132599f, -0.01729724f, 0.00520940f, 0.01618396f, 
    -0.02733753f, -0.01203175f, 0.00791842f, -0.02080358f, -0.06590622f, 0.02248445f, 0.04820129f, 0.02076649f, 
    0.02935663f, -0.05434270f, 0.01068327f, -0.04654973f, -0.05471791f, -0.05025169f, 0.01872568f, -0.06489620f, 
    0.02949805f, -0.06721797f, -0.03994341f, -0.03796407f, -0.05900234f, -0.06050549f, -0.06576767f, 0.03198862f, 
    -0.06428464f, -0.04995975f, -0.01196833f, 0.00644187f, 0.03783285f, -0.03084750f, 0.03272835f, 0.03893629f, 
    0.04946550f, 0.04929640f, -0.00639255f, -0.03191474f, -0.03422083f, 0.00052571f, 0.00880196f, 0.02076415f, 
    -0.06385428f, 0.02893505f, -0.05613333f, 0.03460041f, -0.06114387f, -0.02423020f, -0.06225447f, 0.04411924f, 
    0.01391868f, 0.02678703f, -0.06317120f, 0.02558801f, -0.00538766f, 0.04531407f, -0.00330108f, -0.01464198f, 
    0.02568325f, 0.04370281f, -0.01770488f, 0.01914255f, -0.00703782f, -0.00057088f, 0.04510440f, -0.04699836f, 
    -0.05732998f, -0.05870812f, -0.04989922f, -0.01043342f, 0.02299713f, -0.04511313f, 0.00573136f, 0.04941995f, 
    -0.05496745f, 0.02039916f, -0.01293558f, -0.06485834f, -0.00190267f, -0.00157360f, 0.02325101f, -0.01758876f, 
    -0.04862894f, -0.03291756f, -0.04863722f, -0.02199159f, -0.01702468f, 0.00370163f, -0.02020732f, 0.02198719f, 
    -0.05358065f, -0.05890434f, 0.02309438f, -0.01153393f, -0.03457668f, -0.03425761f, -0.03013959f, -0.00170218f, 
    -0.06262197f, 0.37459290f, 0.18330099f, -0.11445204f, 0.19605790f, -0.00115329f, -0.11073479f, 0.03877345f, 
    -0.00556441f, -0.51720363f, 0.08122868f, 0.40103450f, -0.16477212f, 0.05590914f, -0.06921402f, -0.11886239f, 
    0.01938029f, -0.35073820f, 0.15466200f, -0.10590319f, -0.08806244f, -0.01527292f, 0.02693154f, -0.00870680f, 
    0.06935026f, 0.09171290f, 0.24834339f, 0.10986733f, -0.29224658f, -0.37411714f, 0.01158609f, -0.14275943f, 
    0.06487208f, 0.26415917f, 0.25341532f, 0.01252118f, -0.36924574f, -0.09500298f, 0.12611286f, 0.01573000f, 
    0.15185137f, 0.06817815f, -0.02342837f, 0.09491110f, -0.10484973f, -0.09491297f, 0.05254525f, 0.07652268f, 
    0.07157531f, 0.16252151f, -0.06856669f, 0.28752324f, 0.20856586f, -0.05694291f, 0.00433877f, -0.06280862f, 
    0.13013811f, 0.18294807f, 0.18156071f, -0.01636030f, 0.08498344f, -0.01597755f, 0.07848959f, 0.13919905f, 
    -0.19083175f, -0.04912249f, 0.11957236f, -0.03529229f, -0.03647516f, -0.05965505f, -0.03466874f, 0.17096308f, 
    -0.18348561f, 0.18717788f, -0.22406042f, 0.09051767f, 0.13703664f, 0.05846808f, -0.02601562f, -0.07233392f, 
    -0.08927020f, -0.53882396f, -0.29553062f, -0.05499450f, 0.14346455f, -0.02677028f, 0.14060307f, 0.12138618f, 
    0.09907185f, -0.13228136f, 0.01544682f, 0.06533679f, -0.04431403f, -0.12443829f, 0.14688320f, -0.00833406f, 
    0.08470591f, 0.06584544f, 0.11478940f, -0.52626783f, -0.16807446f, -0.28334218f, 0.10077445f, 0.06847313f, 
    -0.08515662f, 0.01849711f, 0.06565020f, -0.07543055f, 0.00623960f, -0.21356519f, -0.22266221f, 0.19228290f, 
    -0.05456671f, 0.04938598f, 0.19735947f, 0.11398403f, -0.01562472f, -0.14490576f, -0.34635675f, -0.12498422f, 
    0.01029296f, -0.07218867f, 0.04853357f, 0.00234003f, -0.00453381f, -0.18016732f, -0.09881205f, 0.06352509f, 
    -0.07842167f, -0.26787537f, 0.02859178f, -0.08309262f, -0.05890608f, 0.16128238f, 0.03670834f, 0.12752311f, 
    -0.17201529f, 0.29427963f, 0.02288291f, 0.08680587f, 0.00197240f, 0.05787170f, 0.02404195f, -0.08555645f, 
    -0.34329537f, 0.14223085f, -0.37852988f, 0.01936766f, 0.04496914f, -0.02976756f, -0.16717125f, -0.17701663f, 
    0.02250853f, -0.45587775f, 0.05975711f, 0.14715460f, 0.15436958f, 0.17118220f, 0.14683281f, -0.17709938f, 
    -0.02928902f, -0.08737443f, -0.45809314f, 0.02263101f, -0.08384151f, 0.10179762f, 0.00294780f, -0.04796807f, 
    -0.08437239f, 0.05163864f, 0.12281433f, 0.38463402f, 0.03634748f, -0.09247259f, -0.02431999f, 0.07778047f, 
    0.13216399f, -0.06547383f, -0.06032202f, 0.14290744f, 0.05159025f, 0.13483402f, 0.02840283f, -0.11896385f, 
    0.01202308f, -0.13889088f, 0.13357764f, 0.14662361f, 0.08997795f, -0.12444772f, -0.06223217f, -0.28743261f, 
    0.01206127f, -0.14404799f, 0.21989857f, 0.06079173f, -0.08450457f, 0.02653863f, -0.28258532f, 0.16454586f, 
    0.15528451f, 0.18534394f, -0.03050060f, 0.04918615f, -0.13265133f, 0.08667696f, -0.05252735f, 0.19510636f, 
    0.22262660f, -0.33487651f, -0.09431172f, -0.00091402f, 0.08884454f, 0.34456027f, -0.07756879f, 0.05676429f, 
    0.39992812f, -0.18843322f, -0.26937288f, 0.05290466f, 0.20448454f, 0.02342908f, 0.03961170f, 0.04833544f, 
    -0.00016842f, -0.16782486f, 0.00686954f, -0.25886819f, -0.08402866f, -0.00955540f, -0.09089419f, -0.12416417f, 
    0.09124219f, -0.03360058f, -0.09005319f, -0.01761415f, -0.12164947f, 0.14839044f, 0.03417634f, -0.00622025f, 
    -0.04963776f, -0.08867040f, -0.12076911f, 0.27560356f, -0.04480838f, 0.10359401f, 0.18287200f, -0.05024620f, 
    0.04582226f, -0.03695193f, 0.10615583f, -0.04092195f, 0.20309269f, -0.13207485f, -0.31998891f, 0.01569768f, 
    0.11066423f, 0.08066110f, 0.00295237f, -0.06556048f, -0.00161262f, 0.28247169f, 0.32493868f, 0.19297124f, 
    -0.06359620f, 0.17320463f, 0.08468822f, 0.18721046f, 0.06848452f, 0.01286808f, -0.15036313f, 0.07639192f, 
    0.16137408f, 0.14611164f, 0.03457504f, 0.18406191f, 0.04212174f, -0.05568555f, -0.01312850f, 0.11180419f, 
    0.22995931f, 0.13224976f, 0.09057841f, 0.09893303f, -0.16826226f, 0.01120029f, 0.04288059f, 0.08134884f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09803992f, 0.09804810f, 0.00279088f, -0.01894311f, 0.05425101f, -0.05060690f, -0.05323257f, -0.00528404f, 
    0.11324418f, 0.04489487f, 0.02001215f, 0.07310615f, 0.05211499f, 0.01257553f, 0.04392760f, 0.09643055f, 
    -0.05153444f, -0.21536708f, -0.01342831f, -0.04594402f, -0.04998068f, 0.00370153f, 0.02420789f, 0.10359867f, 
    0.14887920f, -0.04357006f, 0.02231845f, 0.15646511f, 0.02966011f, -0.02110469f, -0.04566923f, 0.13255319f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21492612f, 0.05054999f, 0.05502552f, 0.20362787f, 0.08407997f, 0.08701013f, 0.16473575f, 0.16745234f, 
    0.29876271f, -0.10515285f, -0.09741776f, -0.31935471f, -0.23502897f, -0.17512682f, -0.03018871f, 0.52756715f, 
    -0.23645481f, -0.03143193f, -0.11113457f, 0.15462762f, 0.08444546f, 0.03099863f, -0.18002762f, -0.57961363f, 
    0.14078806f, 0.06074732f, 0.18797539f, -0.28878686f, 0.42697442f, 0.02771992f, 0.06005163f, 0.26247460f, 
    -0.35481060f, 0.42266750f, 0.11650754f, -0.06540955f, 0.35283938f, 0.08042144f, -0.09103843f, -0.01608505f, 
    0.06802744f, -0.12493208f, 0.53705889f, -0.21504860f, -0.15598989f, 0.09161660f, 0.10297850f, 0.64850426f, 
    0.20377731f, -0.15930693f, 0.00796459f, -0.04857871f, 0.06093368f, -0.14963210f, 0.03395363f, 0.21745913f, 
    -0.21156305f, 0.02916439f, 0.10624821f, 0.03836396f, 0.44095251f, -0.33225283f, -0.03300120f, -0.30729216f, 
    -0.40984869f, 0.73098797f, 0.10582670f, -0.06075450f, 0.27011025f, 0.01758707f, 0.12381647f, -0.09941980f, 
    0.11157983f, 0.07142065f, -0.06610494f, -0.03496003f, -0.33381227f, -0.19447103f, 0.02797880f, -0.02431830f, 
    -0.20020747f, 0.31954631f, 0.03865380f, 0.06285937f, -0.16122854f, -0.14478968f, 0.10620683f, -0.07512507f, 
    0.27332163f, 0.09802962f, 0.46623433f, -0.09191035f, 0.39548564f, 0.34444439f, 0.09082932f, -0.20890751f, 
    0.26552010f, -0.45165545f, -0.05458856f, 0.29276499f, 0.02519034f, -0.17552926f, 0.13838965f, -0.06513374f, 
    0.24194774f, -0.04250249f, -0.35062724f, 0.29237631f, -0.03855027f, -0.04048540f, 0.13574794f, 0.13024732f, 
    -0.20263577f, 0.19578622f, -0.06522081f, 0.13802621f, -0.07614810f, -0.09244026f, -0.08707123f, -0.22882043f, 
    0.09795015f, 0.16625251f, -0.39613199f, -0.30536029f, -0.22736594f, 0.44133979f, 0.06988118f, 0.41429940f, 
    0.05342666f, -0.67562026f, 0.12169472f, -0.21670809f, 0.35619059f, -0.10716908f, 0.07154904f, -0.14901948f, 
    0.21324207f, 0.02269845f, -0.10412130f, -0.11923140f, 0.42221799f, 0.06085715f, 0.11717325f, -0.32544139f, 
    -0.00627074f, -0.15330637f, -0.12406664f, -0.07707930f, 0.10492907f, -0.02211103f, -0.09026635f, 0.24019378f, 
    0.09383093f, 0.13073248f, 0.04802967f, 0.17583856f, -0.31121033f, 0.36688328f, 0.15651394f, -0.00386958f, 
    0.44063392f, 0.38921362f, -0.01308680f, -0.09503442f, -0.19442634f, 0.16737802f, 0.12910601f, -0.10833022f, 
    0.29615170f, -0.14515142f, -0.35322115f, 0.05580712f, 0.55371392f, -0.12856996f, -0.07656305f, 0.33582962f, 
    -0.17217042f, -0.17323694f, 0.07817006f, -0.03334674f, -0.03751530f, 0.05999990f, -0.09503362f, 0.62964904f, 
    0.27790764f, 0.08600361f, 0.09730946f, 0.45929822f, -0.14466347f, -0.21367165f, 0.16428889f, -0.20526302f, 
    0.06195857f, 0.22871454f, 0.03266893f, 0.26276746f, 0.20759596f, -0.13594484f, -0.06252892f, 0.17025052f, 
    -0.37444991f, 0.01715884f, 0.03398844f, 0.33530793f, 0.07362166f, 0.39021069f, 0.11653485f, 0.08980633f, 
    0.60665214f, -0.23238701f, -0.04966316f, -0.04311793f, 0.04740827f, 0.00534925f, -0.06505301f, -0.28858593f, 
    -0.54317909f, 0.09695655f, 0.18013905f, 0.08139914f, -0.41568643f, 0.02547182f, 0.13918139f, -0.26013106f, 
    -0.20819895f, -0.17490301f, 0.02389718f, -0.18202959f, 0.01057795f, -0.13022292f, -0.05189277f, 0.00434410f, 
    -0.01248742f, 0.09874821f, -0.08113226f, 0.03195764f, -0.11103687f, -0.02029773f, -0.09972618f, -0.01597283f, 
    -0.02040012f, 0.02895006f, -0.10127698f, 0.07828459f, -0.13724704f, 0.16596827f, -0.04885454f, 0.00393214f, 
    -0.06302683f, 0.14053686f, -0.11326826f, 0.02708795f, -0.06522796f, -0.13319923f, -0.15518938f, -0.09016091f, 
    0.53113812f, 0.13853908f, 0.15507837f, 0.50419974f, -0.32706106f, 0.10730518f, 0.00050784f, -0.02591823f, 
    0.19017065f, -0.08882727f, -0.51248932f, 0.29363966f, 0.15018092f, 0.12341672f, 0.06316860f, 0.00080336f, 
    0.30155981f, 0.32233483f, -0.13509375f, 0.11352609f, 0.16559137f, 0.16578315f, 0.08180177f, 0.13807046f, 
    -0.18573727f, 0.04538004f, 0.03608444f, -0.17323218f, -0.20358531f, -0.30624402f, -0.03238430f, 0.00463616f, 
    -0.16531391f, 0.04489002f, -0.09013373f, 0.03671532f, -0.11790672f, -0.17536549f, -0.17794193f, -0.02953146f, 
    -0.17266884f, 0.03593886f, 0.08008861f, 0.07977780f, -0.14855225f, -0.12022267f, -0.01807640f, 0.13334674f, 
    -0.10146095f, -0.11157816f, 0.06255428f, -0.16939807f, 0.14645557f, -0.09617626f, -0.14528927f, 0.00968376f, 
    0.04298298f, 0.10202458f, -0.03957167f, 0.02681585f, -0.00801563f, -0.08628575f, 0.11657713f, -0.06265062f, 
    -0.03281829f, -0.35885224f, -0.08320315f, 0.17251141f, 0.02658734f, 0.12438467f, 0.00478596f, -0.06447839f, 
    -0.00188704f, -0.07133788f, 0.65161270f, 0.21000975f, 0.06757824f, 0.43109992f, 0.08036820f, -0.07117585f, 
    -0.23260632f, 0.33671030f, -0.02252246f, 0.15616593f, 0.14780131f, 0.01425443f, -0.06277651f, -0.03737060f, 
    -0.06063781f, -0.15303682f, -0.25859839f, -0.16719908f, 0.25700414f, -0.26039109f, -0.01090158f, 0.30021068f, 
    0.31543517f, 0.00385519f, 0.14266092f, 0.43584755f, -0.32045451f, 0.07303475f, 0.01975350f, 0.14255235f, 
    -0.13568093f, -0.05760615f, 0.13170581f, 0.27432683f, -0.09048900f, 0.27695811f, -0.01244926f, 0.11029745f, 
    0.63353497f, 0.32102138f, -0.06820530f, -0.09900584f, -0.07592163f, 0.09252051f, 0.10813892f, -0.39163670f, 
    -0.35095200f, 0.15138502f, -0.23682836f, -0.23808078f, -0.02308545f, 0.06708613f, -0.07558113f, 0.03719185f, 
    0.27483660f, 0.62104779f, -0.12110364f, -0.17762814f, -0.13014196f, 0.08309130f, 0.09276959f, 0.00759514f, 
    0.11099130f, 0.17618108f, 0.04890977f, 0.52989703f, -0.09513620f, 0.26642460f, -0.15636142f, -0.31271365f, 
    -0.04001034f, 0.18028726f, 0.11294679f, -0.02883583f, 0.14609805f, 0.00026204f, -0.00509291f, -0.01149342f, 
    0.28512013f, -0.02859017f, -0.22215864f, 0.46423426f, 0.17186025f, -0.49172544f, 0.05791036f, 0.14847127f, 
    -0.53361762f, -0.15319443f, 0.04027399f, -0.17056926f, 0.36480352f, 0.03241133f, -0.09577135f, -0.10254260f, 
    -0.04573052f, -0.01818210f, 0.68688297f, -0.15805133f, 0.14023231f, -0.18989965f, -0.02683548f, 0.26108289f, 
    0.19918871f, -0.20680194f, 0.02305666f, -0.01313267f, 0.11909986f, 0.00527293f, -0.06287394f, 0.11374477f, 
    -0.12083113f, -0.10572489f, 0.17098907f, 0.33927831f, 0.55927223f, -0.01921351f, -0.01272651f, -0.19051374f, 
    0.26247671f, -0.58291554f, -0.12305129f, 0.05774327f, 0.44604465f, -0.00643565f, 0.05107437f, 0.03196452f, 
    -0.19309236f, 0.11797849f, 0.09318425f, -0.29922473f, -0.00581744f, 0.33735836f, -0.13517350f, -0.21922086f, 
    0.23893917f, 0.43401328f, 0.10394769f, 0.08955873f, -0.03148182f, 0.03016834f, -0.13248405f, -0.72348744f, 
    -0.22253773f, -0.04530132f, -0.25927183f, 0.10645664f, -0.43618160f, 0.46221483f, 0.07117704f, 0.42973846f, 
    0.02496057f, 0.01851066f, -0.14854218f, 0.08939763f, -0.06809396f, -0.09574946f, -0.02945088f, -0.06776085f, 
    -0.00840237f, 0.02260593f, -0.01897174f, -0.15806599f, 0.03756389f, -0.15815651f, -0.04748810f, -0.19996235f, 
    -0.19579718f, 0.01335133f, 0.09655622f, 0.10736485f, -0.09480744f, -0.15435009f, 0.03688714f, 0.07717650f, 
    -0.03368966f, 0.14065780f, -0.02672072f, -0.12588130f, 0.08301736f, -0.07886939f, -0.05842373f, -0.05953980f, 
    0.18170661f, 0.03134332f, -0.06101083f, 0.14308019f, -0.05217116f, 0.11967393f, -0.13036928f, -0.09426952f, 
    -0.01517687f, -0.01471140f, -0.00354115f, 0.35222846f, -0.16741715f, 0.45151925f, 0.16599026f, 0.30827782f, 
    -0.00518136f, -0.42162222f, 0.17688181f, -0.16162585f, 0.15073641f, 0.04371233f, 0.04661402f, 0.24828072f, 
    0.05567122f, -0.16755803f, 0.34746817f, -0.43277845f, 0.04618751f, 0.11545369f, -0.07106726f, 0.09210419f, 
    -0.17179698f, 0.05142836f, -0.16655485f, 0.15800887f, 0.45516950f, 0.09155274f, 0.06593515f, 0.10996472f, 
    -0.16457799f, -0.10277925f, 0.08513474f, -0.26105303f, 0.38068098f, -0.35345075f, 0.05979491f, 0.56465471f, 
    0.04498307f, 0.26494953f, 0.16566062f, 0.14935429f, 0.01282874f, -0.06435147f, -0.07498445f, -0.03536962f, 
    -0.21184272f, 0.02963758f, -0.42767951f, 0.42571104f, -0.21813050f, 0.44646135f, 0.00549511f, 0.02580759f, 
    0.08223639f, -0.14151736f, -0.16937031f, 0.11395864f, -0.05111081f, 0.03480323f, -0.02343293f, -0.13205707f, 
    0.06630173f, 0.13266550f, 0.12748037f, -0.00773913f, -0.09061451f, -0.08521862f, -0.11586103f, -0.01513607f, 
    -0.06908738f, -0.19397630f, 0.17148457f, 0.03770731f, -0.08289575f, -0.01505119f, 0.16484965f, 0.01046081f, 
    0.00469344f, -0.12522982f, -0.14246713f, -0.10011276f, -0.12746933f, 0.04324987f, -0.07600720f, -0.09039156f, 
    0.06366676f, 0.00187918f, 0.04092578f, -0.13662945f, -0.10310664f, 0.15157765f, -0.04916549f, 0.12761399f, 
    0.01870269f, 0.06141051f, 0.11387812f, 0.12777358f, -0.00353799f, -0.36436427f, 0.05935116f, -0.12060246f, 
    0.47284424f, 0.13197584f, -0.01883559f, -0.08194110f, -0.03547603f, -0.00141863f, -0.03759220f, -0.29333708f, 
    -0.32870051f, 0.07616218f, -0.10996945f, -0.48257169f, 0.41917592f, -0.01247861f, -0.15366481f, 0.06249492f, 
    0.28937012f, -0.29294619f, -0.01106689f, -0.10124015f, 0.36669987f, -0.13436921f, 0.03959050f, 0.12335899f, 
    0.10076789f, 0.16704698f, 0.17016403f, -0.29105276f, -0.15256080f, -0.09955587f, -0.02311967f, 0.36236084f, 
    0.34250998f, -0.12215355f, 0.05121322f, 0.01993742f, 0.11473648f, -0.15153681f, -0.02492145f, -0.70033783f, 
    -0.12490077f, 0.04599053f, 0.30356157f, 0.15731429f, -0.33138886f, -0.07726901f, 0.17572755f, 0.22707291f, 
    0.20323083f, -0.53037775f, 0.09638686f, 0.36257234f, -0.01304960f, 0.05815391f, 0.06873593f, 0.14120568f, 
    0.15707445f, -0.12186658f, -0.51961035f, 0.10874651f, 0.20853040f, 0.11170138f, 0.01009033f, 0.53662604f, 
    -0.08105664f, -0.32282379f, 0.13461456f, 0.06021245f, -0.00188484f, -0.06257375f, -0.02681234f, 0.31860560f, 
    0.25074342f, 0.12397632f, 0.22098801f, -0.37055400f, 0.26079690f, -0.34030914f, -0.16445997f, 0.26354700f, 
    0.10448970f, -0.16017248f, 0.16382675f, 0.23202473f, -0.01087479f, 0.01235040f, -0.20958310f, -0.03338565f, 
    -0.16862015f, -0.18256256f, 0.04800800f, -0.16593872f, 0.02419428f, -0.21185812f, 0.00040046f, 0.13118491f, 
    0.58562416f, 0.50745851f, 0.06612536f, 0.17348431f, -0.07245492f, 0.02015189f, -0.08116960f, 0.13767838f, 
    -0.29136059f, 0.09375766f, 0.02210354f, -0.28743947f, 0.18242887f, 0.01725299f, -0.13772511f, 0.04181882f, 
    0.25374258f, 0.58671415f, 0.05561609f, -0.18001097f, -0.20596200f, -0.01485101f, -0.16751690f, -0.01259518f, 
    0.23723826f, 0.08364929f, -0.11498227f, 0.17021434f, -0.16755946f, 0.19436921f, -0.00350335f, -0.51977074f, 
    -0.07592674f, -0.16262570f, 0.07117289f, 0.13346703f, -0.15732989f, -0.02324577f, -0.14414072f, -0.51170564f, 
    0.19166799f, -0.00303630f, 0.13189545f, -0.17915645f, 0.09185960f, 0.43606696f, -0.15381128f, 0.11623270f, 
    -0.23766759f, 0.41471744f, 0.00753952f, -0.00770493f, -0.17328961f, -0.06925958f, -0.01899337f, -0.13729478f, 
    0.26428592f, -0.02104332f, 0.15507372f, 0.47273421f, 0.45438662f, 0.13039194f, -0.17192058f, -0.37723383f, 
    -0.30664971f, 0.03502708f, -0.11653417f, 0.02910936f, 0.02115042f, 0.00992890f, 0.02505704f, 0.57308620f, 
    0.47905695f, 0.08158436f, -0.25687906f, 0.17911625f, -0.31722465f, 0.49641904f, 0.14659199f, 0.31182754f, 
    -0.09390331f, 0.07713923f, 0.12951368f, -0.19386090f, -0.14245442f, -0.08481005f, 0.03864790f, 0.01540884f, 
    -0.11534396f, -0.12307904f, -0.12829816f, 0.13660750f, 0.15282114f, -0.01073071f, -0.10418236f, -0.19150855f, 
    -0.09270664f, -0.00136602f, 0.16143940f, -0.01655428f, 0.11147291f, -0.02312308f, -0.16586743f, 0.00031647f, 
    -0.18341117f, -0.17857578f, 0.13879158f, -0.17535938f, 0.12095613f, 0.12237556f, -0.03871803f, -0.12310887f, 
    -0.12829004f, 0.52435875f, -0.02447708f, -0.52449411f, -0.14067562f, 0.09469292f, -0.05286022f, 0.07371608f, 
    -0.12649502f, -0.14926745f, -0.23745243f, 0.32794112f, -0.16487865f, 0.20493357f, 0.13150449f, -0.22999378f, 
    0.45842585f, -0.11441261f, 0.09963192f, -0.07642545f, 0.09378276f, -0.04488150f, -0.01433621f, -0.15594938f, 
    0.37368518f, 0.03805739f, 0.17497891f, 0.43237686f, -0.03396217f, -0.10657093f, 0.07335255f, 0.40664676f, 
    0.00233003f, 0.07656030f, -0.08554586f, 0.14806369f, -0.12999552f, 0.01856164f, 0.11893708f, -0.05680177f, 
    -0.17518270f, -0.04141973f, 0.03256948f, -0.11738483f, 0.07865874f, -0.07212996f, 0.04555105f, -0.17290321f, 
    0.00441309f, -0.06995243f, 0.12591504f, 0.02051407f, 0.12408807f, -0.09762491f, 0.09486798f, -0.13156559f, 
    0.01083711f, 0.09568321f, -0.07323076f, -0.10380779f, -0.04897114f, -0.04238437f, 0.11150804f, 0.05542660f, 
    -0.33780733f, -0.51535350f, 0.14951725f, 0.32647160f, 0.00133323f, 0.12484562f, 0.13499212f, -0.09619962f, 
    0.32517937f, 0.07952630f, 0.10443851f, -0.24391769f, -0.24972142f, -0.03758250f, -0.09242131f, -0.01161024f, 
    0.08976497f, 0.21437779f, -0.13060012f, 0.13402985f, -0.02469477f, 0.03042719f, 0.00828851f, -0.01084347f, 
    0.27587378f, -0.15657641f, 0.46983051f, -0.04497993f, 0.53271335f, 0.11091647f, 0.04650078f, -0.41131920f, 
    0.67799228f, -0.72883326f, -0.11747629f, -0.04545583f, 0.14115755f, -0.01588624f, 0.12102590f, 0.01258999f, 
    0.28564614f, 0.02588576f, -0.12598881f, 0.00813615f, 0.38429689f, -0.30595377f, 0.17038515f, 0.47750896f, 
    -0.08330369f, -0.40545434f, -0.02728917f, -0.01698511f, 0.06884307f, 0.15439694f, -0.15286121f, -0.33236566f, 
    -0.13678552f, 0.02184038f, -0.14364693f, 0.17411843f, -0.06645483f, -0.07998532f, -0.12924510f, 0.33257836f, 
    0.24637513f, 0.14862953f, -0.10939052f, 0.02644656f, 0.19932850f, 0.06719588f, 0.11509927f, 0.13971519f, 
    0.07372359f, -0.13003230f, 0.09908067f, -0.26888376f, 0.13840267f, 0.25597674f, 0.10700160f, 0.25757656f, 
    0.15730394f, 0.02628273f, 0.06929121f, -0.05697358f, 0.04940327f, 0.12076583f, 0.04171269f, -0.49979141f, 
    -0.41695485f, 0.16239937f, 0.34527147f, -0.07314126f, -0.12274326f, -0.25679043f, -0.04194012f, -0.22399876f, 
    0.02264493f, 0.18592119f, -0.02359469f, 0.30841419f, 0.24754013f, -0.09449454f, -0.01640337f, -0.12754390f, 
    0.13089687f, 0.14286771f, 0.03227555f, -0.10441181f, 0.13945769f, 0.01568431f, 0.13024847f, 0.15528412f, 
    0.16524711f, -0.00140881f, -0.16299915f, -0.15182513f, 0.10929845f, 0.08083171f, 0.09428838f, 0.37680903f, 
    -0.17036562f, -0.11468501f, 0.39967993f, -0.31517509f, 0.32401463f, 0.31717595f, -0.06136541f, -0.41560289f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.17496531f, 0.29640859f, 0.05472637f, -0.15307403f, 0.16334350f, 0.25362888f, -0.09942968f, 0.14071393f, 
    -0.25507581f, -0.05674881f, 0.16082786f, 0.05428789f, 0.39519215f, 0.20863330f, 0.10766342f, -0.14441289f, 
    0.03838339f, 0.05736186f, -0.12441804f, -0.37159923f, 0.00959842f, 0.16433173f, -0.01479430f, 0.08789998f, 
    0.34738356f, 0.06381562f, -0.08247861f, 0.00886595f, 0.01069814f, 0.14973748f, 0.08022875f, 0.12504436f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.81883883f, -0.11989116f, -0.51577866f, -0.26497743f, -0.02641261f, -0.45913777f, 0.87808442f, -0.16567369f, 
    0.13682516f, -0.14052546f, 0.26508254f, 0.54014605f, 0.10160767f, -0.09928199f, 0.30270094f, 0.00640661f, 
    0.34770367f, -0.46381462f, 0.17780793f, -0.40447307f, -0.14826563f, -0.35114324f, -0.48109210f, 0.10279013f, 
    0.17349118f, -0.13781683f, 0.15565185f, -0.09711586f, -0.41449434f, -0.73429650f, -0.04890000f, -0.00000467f, 
    0.02346266f, 0.15644136f, 0.37142697f, -0.22133061f, -0.36937404f, 0.36195657f, -0.13461471f, -0.03950274f, 
    0.05405511f, 0.01645168f, -0.28269556f, -0.16773842f, 0.35158217f, -0.15021326f, -0.61200964f, -0.07019886f, 
    0.03224504f, 0.06428859f, -0.06905229f, -0.49345013f, -0.33487481f, -0.24020854f, 0.15697619f, 0.36851376f, 
    0.26674083f, 0.10308284f, 0.30951285f, 0.01255451f, -0.59696633f, -0.55600798f, -0.24444568f, -0.11509680f, 
    0.37372077f, 0.21156310f, 0.42010856f, -0.68100500f, 0.11590301f, -0.00748536f, 0.16156721f, -0.06127875f, 
    -0.21405427f, 0.13786232f, -0.72588032f, -0.93098539f, -0.32290173f, 0.02974041f, -0.29790702f, 0.10346922f, 
    0.36509758f, -0.96767598f, 0.06788375f, -0.11743302f, 0.50874346f, 0.30780044f, -0.58535397f, 0.30277646f, 
    -0.41076878f, -0.02634227f, 0.18371253f, 0.09828198f, 0.10655084f, 0.01553326f, 0.30861962f, 0.27106813f, 
    0.17291275f, 0.34701568f, 0.31541219f, -0.33743736f, -0.16216847f, -0.77849543f, -0.23263399f, -0.07488358f, 
    -0.54413122f, 0.13905787f, 0.28466159f, -0.16007143f, -0.15310057f, 0.18500511f, 0.46989879f, 0.07130463f, 
    -0.31517407f, 0.46757013f, 0.15614723f, -0.71598703f, 0.16339304f, -0.69751400f, 0.05804156f, -0.84674132f, 
    -0.22382477f, -0.08977795f, -0.36602396f, 0.04178854f, -0.00206117f, -0.77178973f, 0.23515007f, 0.07014593f, 
    -0.00697217f, 0.24119547f, -0.40396801f, -0.54499996f, 0.07016736f, 0.32449391f, 0.54837412f, -0.06728554f, 
    0.09431115f, 0.12355161f, -0.20009118f, 0.06895871f, 0.08425967f, 0.20313202f, 0.05357037f, 0.10068533f, 
    -0.28992385f, 0.21407862f, 0.12327165f, -0.58944041f, 0.37809744f, -0.41842204f, -0.43211207f, -0.41564530f, 
    -0.32422963f, -0.03184874f, -0.28927168f, 0.15280034f, -0.14279667f, 0.41116241f, 0.43048513f, 0.12274614f, 
    0.12392373f, -1.03030193f, -0.16202323f, 0.31574631f, -0.06064206f, -0.02177271f, -0.72858226f, 0.13620536f, 
    0.31136978f, 0.15855509f, 0.20720351f, 0.24180941f, 0.36423582f, -0.81773877f, 0.22405231f, -0.11137575f, 
    -0.07749686f, -0.69196087f, -0.05169086f, -0.09825515f, 0.01378268f, 0.06959944f, 0.04066465f, 0.29848391f, 
    -0.03514634f, -0.02449252f, 0.11311273f, -0.05744691f, 0.04881890f, 0.15990044f, -0.20509352f, -0.45845872f, 
    -0.16692957f, -0.44639975f, -0.50875044f, -0.10584863f, 0.38333553f, 0.15625547f, -0.21541168f, 0.11267255f, 
    -0.52071297f, 0.05888110f, -0.08700298f, -0.40411204f, 0.12111431f, 0.29347986f, 0.26798528f, -0.08553910f, 
    -0.27075934f, 0.39981216f, 0.00815664f, -0.55200458f, 0.25998497f, -0.25063583f, -1.16485560f, -0.32512671f, 
    0.15268004f, -0.00179995f, 0.43376949f, 0.02176545f, -0.36912632f, 0.37947184f, -0.44820628f, -0.71232319f, 
    0.03116957f, -0.18246600f, 0.23960912f, -0.17692365f, -0.45868954f, -0.01613219f, 0.41698810f, -0.10917187f, 
    0.42072684f, 0.12115017f, -0.40391764f, 0.41252321f, -0.35708576f, -0.12061546f, 0.15407066f, -0.08909990f, 
    -0.42361650f, 0.13667472f, -0.02492215f, 0.77208680f, 0.09137250f, 0.12620519f, 0.74019223f, -0.39408478f, 
    -0.60728979f, -0.07114298f, -0.02799023f, 0.02777077f, 0.26672992f, -0.49845976f, 0.00460533f, 0.18211702f, 
    -0.11242077f, -0.45903888f, -0.31326383f, 0.05932472f, 0.33341920f, 0.50704646f, -0.46611381f, 0.05708534f, 
    0.48725918f, -0.07794598f, -0.07155768f, -0.17456864f, -0.15162401f, -0.36649367f, -0.65334195f, 0.12797302f, 
    0.15220046f, -0.28731886f, -0.13050735f, -0.25113383f, -0.85232002f, 0.55642545f, -0.35401887f, -0.54889095f, 
    0.04712670f, 0.10349561f, -0.42003357f, -0.01767226f, 0.23369272f, 0.15955725f, -0.22379014f, 0.34482563f, 
    0.52034563f, -0.28000727f, -0.91349262f, 0.57081109f, -0.19412237f, -0.20773530f, -0.10772750f, 0.02021393f, 
    0.11796937f, 0.05514125f, 0.02253350f, 0.36307880f, -0.32494795f, -0.48058158f, 0.20388296f, -0.09683843f, 
    0.30108711f, 0.08717719f, -0.15798707f, 0.09162196f, 0.23862985f, 0.59907663f, 0.16954552f, -0.22244835f, 
    -0.17840514f, -0.07411343f, -0.42129716f, -0.08469550f, -0.69558805f, 0.62212646f, -0.04622826f, -0.14658394f, 
    0.40403673f, 0.50395620f, 0.14977440f, -0.67149961f, -0.36059329f, -0.15917429f, -0.42431775f, 0.09309924f, 
    -0.49769008f, -0.07024135f, 0.18616630f, -0.24793756f, 0.06368027f, 0.50591004f, -0.72342873f, 0.12383986f, 
    0.05333780f, -0.47776154f, -0.07713610f, 0.09309050f, -0.27231497f, 0.02195052f, -0.30229864f, 0.00950984f, 
    -0.15318301f, -0.03023049f, -0.26259887f, 0.02261063f, 0.53669530f, -0.18280500f, -0.25668833f, 0.19324948f, 
    0.07435966f, -0.54101771f, 0.30852944f, 0.41132078f, 0.48860750f, -0.20629117f, -0.23325862f, 0.15166020f, 
    -0.38024601f, -0.01491619f, -0.31912458f, -0.28996414f, -0.52658725f, -0.10382297f, 0.38253123f, -0.00525154f, 
    -0.11768232f, 0.22790505f, 0.06036229f, -0.17220643f, -0.18973050f, -0.66962278f, -0.56225979f, 0.39211774f, 
    0.23370093f, -0.13132831f, -0.58480173f, -0.17093280f, 0.27137703f, -0.08605177f, -0.41385707f, 0.34178090f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12577902f, -0.01806962f, -0.01202495f, -0.00480645f, -0.01508184f, 0.08898043f, -0.01082301f, -0.43171218f, 
    -0.30115581f, -0.09456721f, -0.01059556f, 0.02418958f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
