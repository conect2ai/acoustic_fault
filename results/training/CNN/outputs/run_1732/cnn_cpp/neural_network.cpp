#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.75679421f, -1.12506855f, -0.57991415f, -0.60621375f, -0.42253816f, -0.81481284f, 0.29905325f, 0.16085510f, 
    -0.46558395f, 0.47655648f, 0.20113201f, -0.47666383f, -1.24463105f, -0.76294994f, -0.47434506f, -0.91892040f, 
    -0.89675575f, -0.74466997f, 2.10982013f, -0.13518025f, -0.84342504f, 0.09353828f, 0.08654393f, 0.14147960f, 
    0.28671384f, 0.40147120f, 0.23069884f, -0.46292409f, -0.39469153f, -0.88407278f, -0.53837681f, 0.58217686f, 
    -0.06732140f, -0.77070099f, 1.39469922f, -1.22022784f, -1.04764152f, -0.26509377f, 1.31557083f, 0.40666860f, 
    0.73290640f, -0.35747644f, -0.03701444f, -0.46759015f, 0.00015244f, 1.15945196f, -0.06137216f, -0.51544052f, 
    -0.05265131f, 1.10422540f, -0.65820724f, -0.15814383f, -0.49719855f, -0.12807426f, 0.77806228f, 0.60083151f, 
    0.69923240f, 0.21879892f, 0.22802134f, 0.30486828f, 0.28272635f, -1.07099164f, -0.88733816f, 0.66058743f, 
    -2.10193396f, -1.61160290f, -0.43273020f, -0.03216392f, 0.94434261f, 0.02524498f, -0.02978113f, -0.56091714f, 
    -0.34423816f, 0.47696701f, -0.07671465f, -0.20677823f, -0.94536459f, 1.03927946f, 0.41877961f, -0.76837510f, 
    0.28157285f, 0.39203992f, 0.14989620f, 0.31296939f, 0.28984970f, 1.10259056f, 1.04826903f, 0.15792252f, 
    -0.16053469f, -0.58608627f, 0.62039655f, 1.15336382f, 0.85903049f, 0.26234847f, 0.40087160f, 0.51133567f, 
    0.70448792f, 0.65240645f, -0.13024269f, 0.72877938f, 0.95325571f, -0.62431991f, -1.04574716f, -1.64566612f, 
    -0.90671110f, -0.39448646f, -0.11702708f, -0.26465708f, -0.51502287f, -0.66559511f, -0.05538815f, -0.52507639f, 
    -0.63707954f, 0.56519407f, 0.90279466f, 0.82370216f, 0.69106758f, -0.88765484f, 0.56488872f, -0.89729160f, 
    -0.54238290f, 1.07795846f, 0.57181454f, -0.63172418f, -0.55567992f, -0.56419706f, -1.75910366f, -1.11836672f, 
    -0.53541535f, 1.01028931f, 0.62553316f, 0.36861482f, -0.09827335f, 0.30184841f, 0.90955293f, -0.87594736f, 
    -0.51389802f, -0.68428391f, 0.34041616f, -1.59210467f, -1.26592219f, -0.63399220f, 0.18751264f, 0.14353490f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.19971091f, -0.33457771f, 0.56560123f, 0.27505904f, 0.19786805f, -0.21606101f, -0.02474395f, 0.29232845f, 
    0.88510084f, 0.35810938f, 0.21520777f, 0.42952725f, 1.11481690f, -0.61538357f, 0.34877872f, 0.31279346f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.46822295f, -0.57826746f, -0.47635567f, 0.00286616f, -0.11406752f, -0.14335537f, 0.11494983f, -0.15584107f, 
    -0.01734185f, 0.26654851f, -0.13849494f, 0.17041820f, -0.14541064f, -0.09785594f, -0.01984316f, -0.08697065f, 
    0.07984534f, 0.24780867f, -0.43494245f, -0.02133808f, -0.00916307f, -0.09026299f, -0.24350072f, -0.13827607f, 
    0.44109720f, 0.14003912f, -0.05507109f, 0.01124100f, -0.40574923f, -0.32720762f, 0.10696816f, -0.23197193f, 
    0.33028206f, 0.34073424f, 0.00023376f, 0.07501149f, 0.65133983f, -0.23354587f, -0.50464779f, -0.12510675f, 
    0.16699786f, -0.18212798f, 0.03919720f, 0.01588970f, -0.18901213f, -0.74932766f, -0.08784345f, 0.11338833f, 
    0.18860701f, 0.24682732f, -0.30084601f, -0.00607827f, -0.12725444f, -0.05990757f, -0.45141411f, 0.23828529f, 
    0.22967599f, -0.04461968f, -0.05578676f, -0.01273789f, 0.18390729f, 0.06676377f, 0.13810489f, 0.36946052f, 
    -0.95878392f, -0.41123861f, 0.12355623f, 0.32658571f, -0.03931510f, 0.08740106f, -0.07687584f, 0.02830473f, 
    0.53469831f, -0.07805118f, -0.19595918f, 0.24887802f, 0.47673059f, -0.06786800f, -0.00361187f, 0.02392117f, 
    -0.19682939f, -0.48422444f, 0.15255183f, 0.50126803f, 0.00170182f, 0.25641406f, -0.01434482f, 0.11406317f, 
    -0.20397691f, 0.07517630f, -0.30362424f, 0.18746075f, 0.12872885f, 0.07005598f, -0.00166820f, 0.09419633f, 
    0.05302865f, -0.14673273f, -0.09995616f, -0.12532198f, 0.06623138f, 0.35509029f, 0.11523774f, -0.11310293f, 
    -0.02004162f, -0.00013544f, 0.03690865f, -0.01463494f, 0.04918244f, -0.40201917f, -0.10127640f, 0.03469655f, 
    0.13393334f, -0.05876651f, 0.15130302f, -0.29478976f, -0.27010906f, 0.37449095f, -0.15477976f, -0.47683305f, 
    -0.06301588f, 0.25374922f, 0.07898370f, 0.10559430f, 0.27035171f, 0.06787425f, 0.63480085f, -0.58586681f, 
    -0.47660506f, 0.06354684f, 0.30651680f, 0.23870896f, 0.20975958f, -0.13331474f, 0.02735638f, 0.06663085f, 
    0.25717863f, -0.38188276f, 0.14158197f, -0.18073069f, 0.06997728f, 0.02024826f, 0.24317405f, 0.14433220f, 
    0.69143087f, 0.29953954f, -0.44238162f, 0.20119967f, 0.08819609f, -0.02585392f, 0.03679430f, 0.00989502f, 
    0.03428398f, 0.31095725f, 0.31485549f, -0.35915315f, -0.09611229f, -0.05811466f, -0.01530021f, -0.12620106f, 
    -0.01238934f, 0.01944968f, -0.31355238f, -0.24284919f, 0.10608353f, 0.07567643f, -0.14445284f, -0.02111757f, 
    0.15123196f, 0.01462489f, 0.11743313f, 0.11257643f, 0.00315337f, -0.12503432f, 0.18324853f, -0.07361437f, 
    -0.13715066f, 0.12148467f, -0.06514593f, 0.01006591f, 0.43132433f, -0.08824861f, -0.32218799f, 0.04003086f, 
    0.24794209f, 0.18576533f, 0.02695418f, 0.02564802f, -0.18967456f, -0.48920625f, -0.47687259f, 0.15837853f, 
    -0.19742779f, 0.40639997f, -0.11854839f, 0.09437314f, -0.18700962f, -0.19935262f, -0.45181286f, -0.15546153f, 
    -0.06841569f, 0.01786621f, 0.18487580f, -0.05663821f, -0.23028298f, -0.08100569f, -0.08353899f, 0.24131545f, 
    -0.04923882f, -0.10763591f, -0.05485665f, 0.04831296f, -0.24607922f, -0.05680291f, -0.10922243f, -0.20283268f, 
    -0.14495340f, 0.26319301f, -0.08110171f, -0.27279711f, -0.39671111f, 0.10751113f, -0.25911447f, 0.04755501f, 
    -0.22467731f, -0.06087730f, 0.14120331f, 0.12486612f, -0.36097395f, 0.00803485f, -0.42662737f, -0.08351116f, 
    0.24096885f, 0.14565265f, 0.09131019f, 0.21340172f, 0.20665416f, -0.09326000f, 0.00237390f, -0.23268622f, 
    0.05047457f, 0.10671733f, 0.02759022f, 0.06415489f, 0.04477023f, -0.13040881f, 0.03113669f, -0.06112534f, 
    0.04514352f, -0.08190416f, -0.04571027f, 0.17090575f, -0.00365810f, 0.13759513f, -0.25925297f, -0.15512468f, 
    0.01515676f, -0.10658256f, 0.01036268f, -0.00473851f, 0.02371227f, 0.07530212f, 0.40686646f, 0.02228586f, 
    0.05214765f, 0.23720333f, 0.19291750f, 0.08739552f, 0.15947881f, -0.26344427f, 0.49214146f, -0.34553894f, 
    -0.15389846f, 0.10635939f, 0.23216343f, -0.30271143f, 0.18748811f, -0.05638642f, 0.07910247f, 0.43797857f, 
    0.10382518f, -0.29087779f, -0.00402181f, 0.01774968f, -0.18110439f, -0.01899640f, 0.04047006f, -0.03416374f, 
    -0.86481106f, -0.09082936f, 0.47838259f, -0.15193243f, -0.11331638f, 0.07779992f, -0.20352499f, -0.10465188f, 
    -0.08178728f, -0.59566009f, -0.62786859f, -0.28373992f, -0.02341975f, 0.08326463f, -0.18826298f, 0.23376656f, 
    -0.01779845f, 0.15466933f, 0.47349355f, 0.68258417f, -0.63255906f, -0.22161813f, -0.34263679f, -0.24674307f, 
    0.09516741f, -0.12613977f, 0.04349884f, -0.00816018f, 0.36487234f, 0.93793356f, 0.18640028f, -0.17120112f, 
    0.07524190f, -0.14479811f, 0.37909538f, 0.34941274f, 0.06100149f, 0.29067835f, 0.00565248f, -0.13014838f, 
    -0.61099398f, -0.25481319f, 0.18518846f, -0.05365841f, 0.17813905f, -0.75880480f, -0.68688607f, -0.29281822f, 
    -0.27268359f, -0.36639956f, -0.34413218f, 0.08198541f, 0.26722440f, 0.08863582f, -0.07553585f, -0.12116571f, 
    -0.36640245f, -0.09712719f, -0.02094407f, -0.23954932f, 0.06935232f, 0.18144584f, 0.36688969f, 0.01063304f, 
    0.06703535f, 0.37949297f, 0.00088937f, 0.11616558f, 0.30904731f, 0.20096195f, -0.08612832f, 0.01821693f, 
    -0.03413628f, -0.25901210f, -0.06951169f, 0.40516937f, 0.48261011f, 0.17770080f, 0.10893784f, 0.21602556f, 
    0.13863796f, -0.13326637f, 0.04453083f, 0.09807380f, -0.24950543f, -0.29512700f, -0.41430083f, 0.12014421f, 
    0.18876848f, 0.31924358f, -0.19277857f, -0.16471078f, 0.01936889f, -0.23726059f, -0.03815706f, 0.02141919f, 
    0.19366452f, -0.00067639f, -0.13820323f, -0.63414925f, -0.72186875f, -0.24975850f, 0.07643016f, 0.25522456f, 
    0.09880951f, 0.22873539f, 0.01678437f, 0.03014892f, -0.06886350f, 0.35621324f, -0.00008933f, -0.10311399f, 
    0.16055650f, 0.08943450f, 0.15546136f, 0.07381121f, 0.03822731f, -0.34727710f, -0.77542448f, -0.68655920f, 
    -0.12661412f, -0.14366007f, -0.00506323f, 0.02649982f, -0.00503210f, -0.13635965f, -0.39915788f, 0.73145729f, 
    0.78151697f, -0.13498405f, 0.04977496f, -0.26499736f, 0.01306209f, 0.05733427f, 0.23581855f, -0.37235028f, 
    -1.00543892f, -0.56460083f, -0.10955413f, -0.19832256f, -0.15241502f, 0.15464561f, 0.14941722f, 0.06385777f, 
    0.19980648f, 0.02045285f, -0.43261802f, -0.09953325f, -0.01040534f, -0.05318091f, -0.06762816f, -0.15310386f, 
    -0.11715210f, -0.43095946f, -0.41315669f, -0.20239595f, -0.01050861f, -0.02676158f, -0.00594306f, 0.18753929f, 
    0.01501152f, -0.00782470f, 0.67979324f, 0.24802546f, -0.22290531f, -0.08592727f, -0.25042564f, 0.35833332f, 
    0.36770719f, 0.11983405f, 0.03355114f, -0.45332807f, -0.66821653f, -0.13684070f, 0.28833738f, 0.00367718f, 
    -0.14089788f, 0.29204410f, -0.16807812f, 0.17705725f, -0.06475379f, -0.51763391f, -0.27762899f, -0.32284141f, 
    0.03453816f, 0.00742947f, 0.22994550f, 0.04872338f, 0.19455476f, -0.06605688f, 0.08193512f, 0.30654284f, 
    0.05524820f, -0.01138531f, 0.33534023f, 0.22983941f, 0.24232402f, -0.04413887f, 0.14641646f, 0.17285317f, 
    0.13576244f, -0.09053133f, -0.03474724f, -0.20149386f, -0.09778236f, 0.38296223f, 0.29827330f, -0.86345601f, 
    -0.54799086f, -1.32371533f, -0.00856374f, 0.26208842f, 0.48060086f, -0.05549841f, 0.15307817f, 0.22162855f, 
    0.28610581f, 0.41528019f, 0.36296460f, 0.23334944f, 0.03432955f, -0.01864577f, 0.12578197f, 0.35683984f, 
    -0.17276806f, 0.14404289f, 0.21539268f, 0.01117763f, -0.53103036f, -0.30472264f, -0.02296631f, -0.03944917f, 
    -0.12463636f, 0.17888238f, 0.52063751f, 0.17440353f, -0.10602020f, -0.18572639f, -0.36540508f, -0.02713041f, 
    0.01517428f, -0.02698489f, -0.06502388f, -0.19222838f, -0.29650477f, -0.52676612f, -0.03969162f, 0.09153354f, 
    0.10953660f, 0.23537931f, 0.01798598f, 0.07532554f, -0.04362644f, -0.11422655f, 0.12016371f, 0.02331007f, 
    0.19032188f, 0.15092565f, 0.25303581f, 0.04951730f, -0.18417743f, -0.36803958f, -0.05166713f, -0.30693418f, 
    -0.20183694f, -0.31841221f, -0.32598582f, -0.16331902f, 0.18726523f, 0.32259604f, -0.41336405f, -0.39791933f, 
    -0.22015283f, 0.02342578f, 0.04035344f, -0.20238547f, 0.16201337f, -0.17903587f, -0.01873929f, -0.02399043f, 
    0.18148237f, 0.68222815f, -0.13640280f, -0.03554979f, -0.24298079f, 0.13351461f, 0.02222741f, 0.17018682f, 
    -0.31056249f, -0.15080036f, 0.02316196f, -0.07657337f, -0.03283814f, 0.03400754f, 0.11814849f, 0.05771692f, 
    0.21214682f, 0.01038197f, -0.24707727f, -0.07284170f, 0.17473504f, 0.06129183f, 0.08772461f, -0.05941159f, 
    0.06562778f, -0.16272286f, -0.24770540f, -0.33743879f, 0.64398301f, 0.09315258f, 0.12366181f, 0.28446895f, 
    0.01032830f, 0.25379738f, 0.17290705f, 0.50489324f, 0.52615076f, -0.24229585f, -0.12283999f, 0.45021027f, 
    0.29200265f, -0.20278054f, 0.27527228f, -0.18679984f, -0.29859382f, 0.28808424f, -0.12274511f, 0.28735468f, 
    -0.17482436f, 0.16606924f, -0.07249063f, -0.09422362f, -0.52255237f, -0.19417278f, 0.27160609f, 0.33088449f, 
    0.20743342f, 0.08164371f, 0.00369512f, 0.23285219f, 0.30025452f, -0.20505521f, -0.20729315f, 0.06617045f, 
    0.04594916f, -0.14798123f, -0.11097331f, 0.14519991f, -0.31923729f, -0.36700484f, -0.64088959f, 0.01877972f, 
    -0.49112719f, -0.15272871f, 0.03603749f, 0.22027101f, -0.24844672f, -0.04783442f, 0.00081862f, 0.12228089f, 
    0.24116263f, 0.15630856f, 0.28708920f, 0.08214366f, 0.14352411f, 0.37917939f, -0.24608755f, 0.10225498f, 
    -0.35262048f, -0.13538001f, -0.15002166f, -0.12076532f, -0.09655691f, -0.06080651f, 0.16821226f, 0.03047002f, 
    0.13425539f, -0.04845250f, -0.11605155f, 0.22539620f, -0.11581871f, 0.02657855f, 0.31197545f, 0.06432249f, 
    -0.06741944f, 0.26973751f, -0.00545489f, 0.35089400f, -0.30723369f, 0.01123453f, 0.08085613f, 0.05261658f, 
    -0.09798808f, 0.00725556f, 0.27373239f, -0.06184345f, 0.30005592f, 0.00579693f, -0.01126793f, -0.07537143f, 
    -0.43587530f, -0.14948465f, 0.31901175f, 0.15494850f, 0.18952011f, -0.28705996f, 0.34792536f, -0.10650474f, 
    0.12192553f, -0.08429919f, 0.25173467f, -0.21990573f, -0.06159684f, -0.61548930f, -0.28147605f, -0.27742863f, 
    -0.15880425f, 0.18860863f, -0.00755389f, -0.07549174f, 0.07365426f, -0.07397732f, 0.09751139f, 0.23252600f, 
    0.35664314f, -0.26795834f, 0.03361275f, -0.00398801f, -0.09938061f, 0.10639306f, -0.17334324f, 0.13398920f, 
    0.49675199f, 0.27836394f, 0.34847760f, 0.50000632f, -0.01809193f, 0.13826273f, 0.10975046f, 0.00063199f, 
    0.02688116f, -0.18868414f, 0.03283760f, 0.36471054f, 0.13803276f, -0.02201606f, -0.00001150f, -0.00609776f, 
    0.08489873f, 0.04265548f, -0.05215980f, -0.06656577f, 0.20812547f, 0.11230614f, -0.14954849f, 0.07887934f, 
    0.07709420f, 0.16320588f, -0.40566081f, -0.12369948f, -0.44814837f, -0.07624888f, -0.09881227f, -0.11418296f, 
    0.18965517f, 0.06074730f, 0.06555588f, 0.08144273f, 0.61351985f, -0.08000873f, -0.01089097f, 0.21958895f, 
    -0.14299871f, -0.02432008f, 0.07676077f, 0.18786794f, -0.02272271f, 0.50376290f, 0.16265289f, 0.39575526f, 
    -0.03941723f, 0.09748720f, 0.22427106f, -0.01415871f, 0.23431470f, 0.29784161f, 0.27715394f, 0.20934749f, 
    0.12033517f, 0.21226871f, 0.12553042f, 0.16172665f, -0.04941564f, 0.09633480f, 0.08007781f, 0.30205423f, 
    0.01703697f, 0.40890810f, 0.00492361f, -0.01602356f, -0.10155112f, 0.01220003f, 0.17405900f, -0.11126491f, 
    -0.64299494f, 0.43761525f, -0.12644550f, -0.16699187f, 0.11910806f, -0.10501799f, 0.05555215f, 0.03099810f, 
    -0.31445047f, 0.23970796f, 0.17119761f, 0.02595151f, -0.18901896f, 0.03628348f, -0.09724022f, -0.41491637f, 
    0.10123823f, -0.22669722f, 0.14051028f, 0.17654972f, -0.01484740f, 0.16851877f, -0.00530080f, -0.10195158f, 
    -0.01626483f, -0.18508472f, -0.14234918f, -0.14807390f, 0.04667750f, 0.13096033f, 0.00981119f, -0.13547254f, 
    -0.13070917f, 0.05416091f, 0.03658046f, -0.14146799f, 0.16108912f, 0.02885217f, 0.06908340f, -0.09534572f, 
    0.20723623f, -0.33981976f, -0.33435765f, -0.43120623f, -0.20802054f, 0.44636840f, 0.23551862f, 0.37001771f, 
    0.04126451f, 0.20909953f, 0.27908808f, 0.11425927f, 0.55692470f, 0.15588556f, 0.18771110f, -0.50255734f, 
    -0.31811124f, 0.06397616f, -0.04929733f, -0.02345414f, 0.03438574f, 0.01923092f, -0.09035037f, 0.34875554f, 
    0.28293884f, 0.32981679f, -0.05383613f, -0.13402052f, 0.10679011f, 0.04011524f, -0.11729101f, 0.06421772f, 
    -0.08988348f, -0.00079128f, 0.16203725f, -0.05263429f, 0.12085824f, 0.02043943f, 0.08547484f, 0.02002163f, 
    0.06081929f, 0.08753914f, -0.14219067f, 0.11580476f, 0.16345268f, 0.20922646f, 0.06620915f, 0.09367053f, 
    0.03032650f, -0.76457244f, -0.60708517f, -0.50973976f, -0.00006292f, 0.05484309f, -0.01967223f, 0.26992440f, 
    0.13409963f, 0.15627970f, 0.41832960f, -0.23360789f, -0.00427048f, 0.37277409f, 0.05794551f, -0.00546953f, 
    0.01410227f, 0.14614543f, 0.04214549f, 0.17787798f, -0.21144700f, 0.39179811f, 0.05087940f, 0.02630158f, 
    0.26879540f, -0.35330865f, -0.28541812f, 0.07071469f, -0.19813098f, -0.06128386f, -0.14962377f, 0.12733249f, 
    -0.06407373f, -0.14896253f, 0.11418702f, -0.12726650f, 0.02243165f, 0.18470274f, -0.40056986f, -0.19949488f, 
    -0.18105209f, 0.04742629f, -0.06451574f, 0.17700337f, -0.12466532f, -0.05340062f, -0.32059506f, -0.22064413f, 
    0.15848111f, 0.13094915f, -0.14252888f, -0.02475565f, -0.10820350f, -0.04990002f, 0.08022404f, 0.00563802f, 
    0.21033388f, 0.51815832f, -0.08154451f, 0.23629031f, -0.15111873f, 0.07807493f, 0.11220893f, 0.24613976f, 
    0.46003398f, -0.16698848f, -0.16801232f, -0.13549356f, 0.02213870f, -0.05943324f, -0.17487961f, -0.40269157f, 
    -0.17658441f, 0.02249913f, -0.33115059f, -0.21900365f, -0.18561836f, 0.07425310f, 0.07035051f, 0.13470896f, 
    0.12989846f, 0.02078632f, -0.08169089f, 0.02245504f, -0.19851260f, 0.43136379f, -0.01975861f, 0.09910022f, 
    0.08431391f, 0.18190257f, -0.03859560f, -0.02924633f, 0.10361117f, 0.14576031f, 0.28604767f, 0.32208395f, 
    -0.03062380f, 0.05044192f, 0.31659427f, 0.30109906f, -0.11254623f, -0.17179149f, 0.18254854f, 0.03022659f, 
    0.06508348f, -0.23245125f, 0.07608873f, -0.04495225f, -0.08288620f, -0.16853155f, -0.04890502f, 0.06467955f, 
    0.32816342f, 0.06791013f, 0.11227651f, -0.04671340f, 0.11872130f, 0.14461897f, 0.13678458f, 0.11709340f, 
    0.21567993f, 0.61386645f, 0.14502762f, 0.18691048f, 0.08646609f, 0.09202930f, -0.03409149f, -0.47802773f, 
    0.34582713f, -0.75272471f, -0.05582146f, 0.07810263f, 0.09975530f, -0.06970949f, -0.05055636f, 0.04791620f, 
    0.06963815f, -0.02812427f, -0.41257721f, -0.03502934f, 0.05135188f, -0.03652430f, -0.16075765f, 0.02722178f, 
    0.07202987f, -0.11293129f, -0.11239284f, -0.53137219f, 0.37398496f, -0.35396716f, -0.00242490f, 0.36467895f, 
    -0.13652115f, 0.14873590f, -0.02233361f, 0.03666520f, 0.80687523f, 0.70116526f, 0.26419780f, -0.34391874f, 
    -0.24274972f, 0.07433585f, 0.30598411f, 0.39626572f, -0.12202264f, 0.24033174f, -0.33190188f, 0.17838202f, 
    0.41423675f, -0.29612783f, -0.06534320f, -0.00674866f, 0.24031895f, -0.30597478f, 0.60567808f, 0.88987994f, 
    0.19586760f, -0.10686371f, -0.13054398f, 0.26691765f, -0.01142608f, 0.17578194f, -0.14730573f, 0.11031289f, 
    0.30417445f, 0.07964374f, -0.38539851f, -0.17768639f, 0.03942112f, 0.27489021f, 0.21311817f, 0.10456014f, 
    0.20716445f, -0.67891097f, -0.08086570f, -0.25351208f, 0.28588909f, 0.02881331f, 0.04636625f, -0.02209147f, 
    -0.45858639f, 0.43188602f, 0.21995270f, -0.02909020f, -0.06262622f, 0.19239153f, 0.00872033f, -0.01623919f, 
    -0.07669891f, -0.15114427f, 0.16415153f, -0.23385604f, 0.00537144f, -0.22612478f, -0.03440785f, -0.15796845f, 
    -0.05242191f, -0.00239991f, 0.05312778f, 0.04468177f, -0.29233739f, -0.14727354f, -0.06009863f, -0.15462655f, 
    -0.20430335f, 0.13910393f, -0.20647870f, -0.79877204f, -0.32937351f, 0.00464649f, -0.17235658f, -0.10824936f, 
    -0.23223072f, -0.10846443f, 0.06637710f, 0.03332813f, -0.20380645f, 0.21421000f, -0.11222194f, 0.15252869f, 
    0.15197927f, 0.08608910f, 0.17577763f, -0.04940111f, 0.17802976f, -0.84761471f, 0.25620976f, 0.05298951f, 
    0.11685669f, 0.35295436f, 0.10451896f, 0.01003099f, -0.12304813f, 0.15140462f, 0.28699213f, 0.34063727f, 
    -0.06848580f, 0.01105753f, 0.04282082f, 0.02946146f, 0.04089952f, 0.00408770f, -0.06438097f, 0.09513176f, 
    -0.35179162f, 0.36798969f, -0.10373636f, -0.14972992f, -0.28171542f, -0.02050848f, -0.01497215f, 0.08202264f, 
    -0.14707291f, -0.03606184f, 0.17505179f, 0.00813333f, -0.03795374f, 0.13714255f, -0.07909658f, -0.12180048f, 
    -0.07188420f, -0.04436023f, 0.19570924f, 0.32759508f, 0.13052388f, -0.05356956f, -0.09040128f, 0.24390100f, 
    0.07175798f, -0.10576555f, 0.51681346f, -0.16557021f, -0.44385961f, -0.18060541f, 0.18373017f, -0.49153331f, 
    0.13885897f, 0.03766908f, 0.10688109f, -0.55493051f, 0.31715959f, 0.13550800f, 0.11158992f, 0.32860807f, 
    0.26207682f, -0.07775676f, -0.05341984f, -0.00963354f, -0.13862699f, -0.23269184f, -0.21287437f, -0.15686731f, 
    -0.03558355f, 0.22906138f, 0.15530789f, -0.08918484f, -0.17299983f, 0.12624848f, -0.21394600f, -0.09425485f, 
    0.11777615f, 0.24525449f, -0.18259184f, -0.14245668f, -0.21775031f, -0.17415482f, 0.20573787f, 0.08231029f, 
    -0.07764212f, 0.22959238f, -0.01242945f, -0.22962287f, 0.06632827f, -0.36146274f, 0.04096110f, 0.58509624f, 
    0.14884585f, -0.77080846f, 0.06415917f, 0.26840523f, -0.09610438f, 0.07422378f, 0.16349663f, -0.03294597f, 
    0.24952133f, -0.18567437f, -0.05219607f, 0.35278168f, 0.19341761f, 0.09294045f, -0.19107661f, 0.16167627f, 
    -0.17997842f, 0.11329515f, 0.06574157f, -0.04034758f, -0.03133966f, 0.12633699f, -0.34703043f, 0.03913043f, 
    0.11144003f, -0.06711555f, 0.01250721f, 0.25189430f, -0.01476938f, -0.23394826f, -0.28366664f, 0.02535724f, 
    -0.17617524f, -0.15794584f, 0.00017313f, -0.18172444f, 0.31295651f, 0.01056062f, 0.02978477f, 0.06286558f, 
    -0.08138902f, -0.01334799f, -0.01154651f, 0.05616995f, 0.38994119f, -0.34008774f, 0.18157421f, 0.09070572f, 
    -0.28080502f, -0.21097061f, 0.07032380f, 0.11202423f, 0.07383735f, -0.37270400f, 0.18799973f, 0.02379610f, 
    -0.14354765f, 0.00641323f, 0.19944286f, -0.19074675f, 0.07543282f, -0.30918106f, -0.09105287f, 0.51164889f, 
    0.14851768f, -0.01124764f, 0.15449530f, -0.02143884f, 0.06992485f, 0.11403117f, 0.31324464f, -0.19449832f, 
    -0.00385408f, 0.12973753f, -0.07885016f, -0.19253762f, -0.05131003f, 0.03861029f, -0.08888914f, 0.10319200f, 
    -0.01751823f, -0.00415820f, 0.04341976f, 0.06271029f, 0.06109612f, -0.07428613f, -0.04048761f, -0.08301108f, 
    -0.08611839f, -0.00398193f, 0.03795284f, 0.03214740f, 0.06088036f, 0.01264224f, 0.04062913f, -0.09070669f, 
    -0.02861514f, -0.06644005f, -0.06164312f, -0.03238984f, 0.02933536f, -0.00908581f, -0.00064850f, 0.00747988f, 
    -0.09634180f, 0.01414989f, -0.02361552f, -0.02850745f, -0.00306146f, 0.06472325f, -0.00771085f, -0.05059972f, 
    0.04803027f, -0.01339726f, 0.07686080f, -0.00855638f, -0.06455038f, -0.01382396f, -0.00048752f, -0.03218102f, 
    0.06502511f, -0.05117186f, 0.00210965f, -0.06755055f, 0.00239478f, -0.03493951f, 0.01190458f, 0.06344684f, 
    -0.00845103f, 0.05966646f, 0.02349823f, -0.00679253f, -0.04267727f, 0.03588554f, -0.01800978f, 0.03890061f, 
    0.02547996f, 0.04048940f, -0.01106487f, 0.02836129f, -0.00294932f, 0.01373167f, 0.02368333f, -0.01207307f, 
    -0.03222824f, -0.06266907f, -0.04859371f, -0.00549252f, -0.06613341f, 0.04716174f, -0.07666162f, -0.07544816f, 
    -0.03816026f, 0.00244558f, -0.08784705f, 0.02059506f, -0.07211073f, 0.05895756f, -0.07910892f, 0.03907485f, 
    0.04155787f, 0.05095840f, 0.00784415f, -0.08195877f, 0.05991316f, -0.05631113f, -0.08958405f, 0.01897040f, 
    -0.00277665f, 0.02498186f, -0.00123641f, -0.01327290f, -0.03848924f, -0.03479139f, -0.02135341f, 0.01420836f, 
    0.03505400f, -0.05734885f, -0.07975958f, -0.00493421f, 0.00916719f, 0.02763507f, -0.05377966f, -0.04483707f, 
    0.01198510f, -0.06547084f, 0.04079538f, -0.01464496f, -0.05269346f, 0.01421699f, 0.04673183f, -0.06025548f, 
    0.05201908f, -0.06023366f, -0.03963017f, -0.03391811f, 0.05030298f, -0.05209645f, -0.08490366f, 0.06418043f, 
    -0.08292079f, -0.05846387f, -0.03908734f, 0.03628496f, -0.07773555f, 0.06116820f, 0.07116372f, 0.06760499f, 
    -0.08531485f, 0.00652993f, -0.05292903f, 0.05567111f, -0.00527684f, -0.02187622f, -0.08367413f, 0.00218579f, 
    0.06141966f, 0.01936371f, -0.00451632f, -0.05341020f, -0.05405070f, -0.02186557f, 0.02491067f, -0.06670487f, 
    -0.12627622f, 0.21428698f, -0.09119837f, 0.08828854f, -0.09691896f, 0.11289704f, 0.01743947f, 0.14820683f, 
    0.15917470f, 0.02841089f, -0.37064150f, -0.93338484f, 0.00040709f, 0.23020755f, -0.10554026f, 0.13748367f, 
    0.11052778f, 0.00026530f, 0.34652880f, 0.24258232f, -0.06391986f, 0.08193183f, 0.24285896f, -0.01875590f, 
    0.13742602f, -0.07639836f, -0.04509714f, -0.07193293f, 0.37147716f, 0.23368253f, 0.29017916f, 0.08968951f, 
    -0.44062281f, 0.12101973f, -0.07257632f, -0.07493936f, -0.14796552f, 0.34689742f, -0.09002277f, 0.04352778f, 
    0.26132995f, 0.00397700f, 0.00446342f, 0.27003616f, 0.26974052f, -0.17877476f, -0.20474340f, 0.21753807f, 
    -0.25729084f, 0.21984088f, -0.05870344f, 0.01018555f, -0.30957070f, -0.08263917f, 0.11454424f, 0.18048050f, 
    -0.08728562f, -0.11364728f, -0.08348086f, -0.09839235f, -0.00770833f, -0.10078886f, 0.17580558f, -0.17408732f, 
    0.21204123f, -0.26615000f, 0.00798578f, 0.08790559f, -0.39896026f, 0.10517909f, -0.16067035f, -0.11119600f, 
    0.19171531f, 0.37303036f, 0.07293666f, -0.00339514f, 0.37597683f, 0.28424305f, -0.10653124f, 0.07229760f, 
    -0.23504728f, -0.04526647f, 0.12666337f, 0.13654682f, 0.05337492f, -0.05204291f, 0.06764283f, 0.24509282f, 
    -0.12423561f, -0.15483622f, 0.14345202f, 0.20600806f, 0.06962511f, -0.14453897f, 0.00579778f, -0.17253099f, 
    -0.04788631f, -0.19082634f, -0.11599882f, 0.05995334f, -0.83466613f, -0.45682821f, -0.24761723f, 0.23106371f, 
    0.05750083f, 0.10716344f, 0.01448657f, -0.13499360f, -0.16180174f, 0.19719382f, -0.24994794f, 0.25528684f, 
    -0.11909331f, 0.30180401f, -0.10866629f, -0.14935610f, 0.02630613f, 0.23416486f, -0.17357387f, -0.18234198f, 
    -0.11268329f, 0.16090195f, 0.23122664f, 0.31864893f, 0.04938542f, -0.13158722f, -0.76991928f, 0.37082127f, 
    0.50035357f, 0.16858040f, 0.17591769f, -0.15436603f, -0.18556923f, 0.21469659f, -0.08810394f, -0.08816338f, 
    -0.10792655f, -0.27104026f, 0.01523144f, -0.27814645f, 0.16293235f, 0.18050966f, 0.04953213f, -0.01115889f, 
    -0.26938754f, -0.15366094f, -0.67497998f, 0.22463837f, 0.45075274f, 0.22762117f, -0.07073432f, -0.11557797f, 
    -0.08275027f, -0.14626600f, 0.01049067f, 0.23760068f, 0.22291330f, 0.13179007f, 0.09623493f, 0.04046255f, 
    0.11672143f, 0.08662156f, 0.11059929f, 0.28025350f, 0.30662557f, 0.08872851f, 0.05426362f, 0.07207409f, 
    0.04739722f, 0.22436318f, -0.15768984f, 0.04153255f, -0.42826363f, 0.25806510f, 0.23985696f, 0.25839266f, 
    0.14004607f, -0.00764432f, 0.08793935f, 0.08685710f, 0.07630875f, 0.40673167f, -0.74880493f, 0.10920548f, 
    0.22376540f, 0.12847452f, 0.12340347f, -0.12078676f, -0.01287777f, -0.56522375f, -0.14607126f, 0.28531748f, 
    0.10207242f, 0.13891530f, 0.02539114f, 0.11265256f, 0.26212165f, -0.02308089f, -0.36724159f, -0.00162591f, 
    -0.30556715f, 0.02481182f, 0.09984560f, -0.03276392f, 0.11804847f, -0.19537640f, -0.23820999f, -0.38244021f, 
    0.16047192f, 0.54764265f, -0.16989495f, 0.16778170f, 0.26716623f, -0.04346695f, 0.29596710f, 0.20173785f, 
    0.16614963f, -0.18337515f, 0.34926793f, -0.02076006f, 0.16990338f, -0.18438199f, 0.09700166f, 0.34409207f, 
    0.35178196f, 0.00423814f, 0.17953661f, -0.01183119f, 0.04431826f, -0.05166023f, 0.03845305f, -0.10208093f, 
    -0.26141033f, -0.19429114f, 0.24827731f, -0.17414524f, 0.14250043f, -0.00685683f, 0.03937734f, 0.05958432f, 
    -0.12081753f, 0.04245485f, -0.27464962f, 0.17253184f, -0.05895104f, 0.45722306f, 0.33605206f, 0.04815868f, 
    -0.22111776f, -0.00200930f, 0.27735215f, 0.10162191f, 0.04175862f, 0.36080581f, 0.16044171f, 0.17965613f, 
    0.13440345f, -0.48097497f, -0.29713553f, -0.46285492f, -0.43660766f, 0.36117139f, -0.35907021f, -0.02406880f, 
    -0.28431803f, -0.12927116f, 0.01577621f, 0.13648902f, 0.23944254f, 0.23634300f, -0.24908867f, 0.67617166f, 
    0.12252901f, -0.03941096f, -0.24214728f, -0.41568822f, -0.08122699f, -0.11106388f, -0.14803717f, 0.02182267f, 
    -0.19836499f, 0.01303482f, -0.31443048f, 0.14240028f, -0.13058993f, -0.06014630f, 0.01766928f, 0.08183306f, 
    -0.31569198f, 0.00744669f, 0.43765563f, -0.00156062f, -0.07426836f, -0.04280431f, 0.07807405f, 0.15889058f, 
    -0.11658464f, -0.61064178f, -0.59268224f, -0.58131295f, -0.03965547f, 0.04548683f, 0.04644920f, -0.03227448f, 
    0.07196884f, -0.24123101f, -0.03708662f, -0.02666581f, 0.23819552f, 0.09575301f, -0.04795898f, 0.38073260f, 
    -0.17569813f, 0.30767554f, 0.20321855f, 0.13109900f, 0.02112272f, 0.09726990f, 0.12169871f, -0.07759452f, 
    0.13622431f, 0.16978543f, -0.03441247f, 0.43105078f, -0.57271743f, -0.11279547f, 0.53666013f, 0.00459094f, 
    0.04474582f, -0.32212690f, 0.26057500f, -0.05049039f, 0.13163328f, -0.00983227f, -0.25080416f, -0.13031182f, 
    -0.32913110f, 0.09581820f, -0.11144475f, 0.02046994f, 0.26781762f, -0.19591728f, -0.05150963f, -0.11445605f, 
    -0.01616561f, -0.24505149f, 0.10703162f, 0.14653602f, -0.03075775f, 0.10841562f, 0.09206287f, 0.08752435f, 
    -0.42417482f, 0.65526825f, 0.02826487f, -0.03071107f, 0.05879218f, -0.17822340f, 0.20030235f, 0.06233132f, 
    0.04980123f, 0.41501456f, 0.37731424f, 0.39314991f, 0.21296327f, 0.44111815f, 0.60973775f, 0.50266004f, 
    0.40388793f, -0.15849738f, 0.05478153f, -0.10412076f, -0.28177321f, -0.07755651f, -0.07513142f, 0.00359477f, 
    -0.05392293f, 0.19265090f, -0.20949043f, -0.10443196f, -0.15484624f, -0.12070682f, 0.03954355f, -0.01694011f, 
    -0.16999869f, 0.17063665f, 0.09457090f, -0.22379506f, -0.36822912f, -1.04467404f, 0.21190536f, -0.06922102f, 
    0.03031094f, 0.06578490f, 0.22243123f, 0.17011315f, -0.02902031f, 0.01120862f, 0.28391302f, 0.32275990f, 
    -0.02956221f, 0.21701144f, 0.21549979f, 0.31560183f, 0.15764609f, -0.15541115f, -0.13474655f, -0.55451488f, 
    -0.15547547f, -0.15805815f, -0.15687351f, -0.23379028f, -0.24139710f, 0.18494301f, 0.08931507f, -0.28921181f, 
    -0.27926317f, -0.04098036f, -0.06143136f, -0.08044136f, -0.02973226f, -0.19307861f, -0.00388030f, 0.18817253f, 
    -0.14454095f, -0.21547514f, -0.09137195f, 0.19327129f, -0.06519728f, 0.14952120f, 0.20638230f, -0.07516626f, 
    0.82681155f, 0.11267309f, -0.22505566f, 0.17513287f, -0.09259684f, 0.11407251f, 0.09588078f, -0.07588401f, 
    -0.20272288f, -0.13639769f, 0.20688598f, -0.00481058f, -0.24777724f, -0.13519485f, -0.25043204f, -0.02275968f, 
    -0.09647962f, 0.16273762f, 0.32324493f, -0.00443162f, 0.35369143f, -0.25117892f, 0.04031688f, -0.08444145f, 
    0.07432780f, 0.06076431f, -0.08891760f, 0.14503632f, -0.10332590f, 0.11156416f, 0.22136408f, -0.03223095f, 
    0.22474116f, 0.23058343f, -0.45181739f, 0.16264200f, 0.57511544f, 0.29398507f, -0.49226359f, 0.08447544f, 
    0.21165474f, 0.11124633f, 0.36857933f, 0.10047629f, -0.09600585f, 0.02080460f, -0.49639285f, -0.84120798f, 
    -0.27921242f, 0.01180045f, -0.31843537f, -0.23076394f, -0.43899238f, -0.15818523f, 0.01170633f, -0.30941588f, 
    0.17594619f, 0.05851143f, 0.04968531f, -0.05084780f, 0.05508995f, -0.18352504f, 0.22777040f, 0.62498283f, 
    0.50691998f, 0.04786086f, -0.16418970f, -0.11675740f, -0.35587204f, 0.05822387f, 0.01380389f, 0.05872525f, 
    -0.27956235f, -0.29652652f, 0.28162658f, 0.24526425f, -0.20519243f, -0.07706950f, 0.35951585f, 0.38213557f, 
    0.32128596f, -0.04155245f, -0.12955534f, 0.13683626f, -0.03509062f, -0.07131945f, 0.14733069f, -0.20134127f, 
    -0.26098675f, 0.00658241f, 0.15732083f, 0.04954608f, 0.30932796f, -0.14380921f, -0.15751719f, 0.02775861f, 
    0.08999175f, 0.01306836f, -0.08321489f, -0.39486048f, -0.32632911f, -0.11902957f, -0.06163185f, -0.20162137f, 
    -0.22853655f, 0.03061776f, 0.04474615f, 0.17548290f, -0.11273929f, -0.20597208f, -0.23586489f, 0.19561993f, 
    0.14819756f, 0.11265103f, 0.18712455f, 0.23769450f, 0.01800650f, -0.34139854f, -0.34887958f, -0.44525728f, 
    -0.15205221f, -0.10008504f, 0.04437235f, 0.05225347f, -0.11279536f, 0.15374015f, -0.20051686f, -0.36631203f, 
    0.13467222f, 0.01049648f, 0.25325918f, -0.09470834f, -0.04945618f, 0.10345678f, 0.25219896f, 0.18431254f, 
    -0.22261409f, -0.04849827f, 0.08823755f, -0.06912638f, -0.23441720f, 0.04014513f, 0.08781820f, 0.10826257f, 
    0.21404582f, 0.17529410f, 0.29758832f, 0.34357381f, -0.16259786f, -0.08884624f, 0.06151384f, 0.11020184f, 
    -0.08038022f, 0.23014612f, 0.03397506f, 0.51399589f, -0.00402294f, -0.00065835f, 0.06204368f, -0.35420412f, 
    0.06818632f, 0.04710502f, -1.02724874f, -0.71597850f, -0.81198782f, -0.12041117f, 0.09020533f, -0.12355477f, 
    0.05245369f, -0.05521435f, -0.15113433f, 0.01011467f, -0.05335420f, 0.28304759f, -0.16308376f, 0.15318801f, 
    0.00963912f, 0.01372634f, 0.16823709f, 0.22325918f, 0.14500064f, 0.55194861f, -0.32449627f, 0.21490027f, 
    -0.29808113f, 0.12208739f, 0.02997418f, 0.08817879f, 0.15430602f, 0.06213681f, 0.01591340f, -0.57079118f, 
    0.26948562f, -0.10763659f, -0.26931968f, -0.05020418f, -0.39799300f, -0.09329335f, -0.56681949f, -0.65185237f, 
    -0.03679950f, -0.06309584f, -0.27749574f, -0.11829091f, 0.44312215f, 0.01251697f, 0.18243112f, -0.31334075f, 
    -0.19445421f, 0.03077947f, -0.03692190f, 0.05313259f, -0.02493004f, -0.01873985f, -0.06573087f, -0.12190762f, 
    0.35160586f, -0.08446425f, 0.01829725f, -0.22238979f, -0.19521016f, -0.15073909f, -0.09644713f, -0.06387238f, 
    0.10487677f, 0.57573807f, -0.45637068f, 0.47749600f, 0.04610846f, -0.21646427f, 0.06293686f, 0.07834524f, 
    -0.07280355f, 0.03318328f, -0.75865442f, -0.47628465f, 0.57264292f, 0.00312119f, -0.03888722f, -0.41238239f, 
    0.19159895f, 0.18966874f, 0.42925760f, 0.34693092f, 0.00847551f, 0.59754848f, -0.22006065f, 0.21943067f, 
    -0.07022420f, 0.08895440f, -0.11821941f, -0.17568201f, 0.60063261f, 0.55905032f, 0.29306510f, -0.00372371f, 
    -0.34593815f, 0.03658508f, 0.10209486f, -0.01965297f, 0.11635882f, 0.61341470f, -1.07584894f, -0.59516859f, 
    -0.28806141f, -0.11653966f, 0.34854570f, -0.14563562f, 0.21275473f, -0.18813528f, -0.61905569f, -0.08960955f, 
    -0.23857647f, 0.01914495f, -0.11873294f, -0.21775763f, -0.09297976f, 0.09201661f, -0.00699165f, -0.07184309f, 
    0.26349014f, 0.12810299f, -0.05897106f, -0.20429531f, 0.00725653f, 0.07190769f, -0.03572911f, 0.13682744f, 
    0.34542745f, 0.32850358f, 0.57442623f, -0.12856843f, -0.09663032f, -0.15137896f, -0.13625784f, -0.02552139f, 
    0.02325552f, 0.08589856f, 0.35178089f, -0.02707039f, -0.12665656f, -0.01980547f, -0.16194613f, 0.17075713f, 
    0.01168763f, 0.03858138f, -0.03242766f, -0.06240007f, -0.35039273f, -0.18190978f, -0.20027590f, -0.03086775f, 
    0.01935467f, -0.06129424f, 0.31978285f, -0.26823163f, 0.01555772f, 0.45661116f, 0.16088657f, 0.06718864f, 
    -0.40781668f, 0.13456155f, 0.07533818f, 0.22851785f, -0.25734356f, -0.91367453f, 0.11764539f, -0.54687172f, 
    -0.33370569f, 0.42416835f, 0.27682343f, -0.05327575f, -0.16372260f, 0.19004291f, -0.12084629f, 0.27651224f, 
    0.03693001f, -0.19421275f, -0.03994975f, 0.01677553f, -0.09921551f, -0.27297631f, 0.26107416f, -0.17144428f, 
    0.05334362f, 0.08393898f, 0.09666681f, -0.04275661f, -0.03388440f, -0.13340212f, -0.03933721f, 0.44610190f, 
    -0.11927815f, -0.12145472f, 0.21003431f, 0.00079167f, -0.20649549f, -0.01743128f, -0.01713878f, -0.00482966f, 
    -0.63601291f, -0.52249092f, 0.33111590f, -0.41049790f, 0.10531150f, 0.04041519f, 0.08050200f, 0.05438588f, 
    0.01726475f, 0.31684777f, 0.36591226f, 0.39153653f, -0.22933494f, -0.24050435f, -0.45703906f, 0.05562237f, 
    -0.09427796f, 0.15682732f, -0.09533972f, 0.28298116f, 0.26821005f, -0.13530435f, -0.00073726f, -0.09642345f, 
    0.09064506f, 0.03738740f, -0.00774381f, 0.02102084f, -0.04273504f, -0.49858022f, 0.00934067f, -0.01491200f, 
    -0.16445211f, -0.04233266f, -0.09860198f, 0.13108702f, 0.34385511f, -0.24097924f, 0.14068043f, -0.07402056f, 
    -0.00121406f, 0.07146890f, -0.13214079f, 0.11501767f, 0.02789421f, -0.70145142f, -0.02034184f, 0.08008381f, 
    -0.03420199f, -0.15742958f, 0.02865477f, 0.23364490f, 0.17671813f, -0.17180240f, 0.44693699f, -0.36361635f, 
    0.25202876f, -0.42265019f, -0.14492339f, 0.14545768f, 0.24204020f, 0.09019373f, 0.01445359f, 0.20753686f, 
    0.31235027f, 0.48336831f, -0.12733005f, 0.04529982f, -0.13622235f, -0.07879362f, 0.04262330f, 0.07345393f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.15807083f, -0.38230550f, 0.70763129f, 0.34739119f, -0.03924913f, -0.25399861f, 0.11162919f, 0.00766300f, 
    0.04313699f, -0.06853541f, 0.17903110f, 0.10371047f, 0.54509413f, 0.27356550f, -0.04573767f, 0.15178697f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06939349f, 1.31393254f, -0.25556934f, -0.36610666f, -0.29406750f, 0.27982855f, -0.45881480f, 0.19277467f, 
    0.29625952f, 0.15906204f, 0.26954296f, -0.29231101f, -0.34530711f, 0.12571377f, 0.09650274f, 0.37962577f, 
    -0.48318252f, -0.51918435f, -0.37555838f, 0.18917678f, -0.17424817f, 0.25737765f, 0.48536199f, -0.71443492f, 
    -0.12538999f, -0.15897255f, 0.31872568f, -0.63238406f, 0.26369730f, 0.36426514f, -0.78585565f, 0.25095913f, 
    0.02008389f, -0.68541795f, 0.83565426f, -0.50737077f, -0.57805026f, -0.16431086f, 0.05765861f, -0.32783720f, 
    0.33122298f, -0.05409781f, 0.01815772f, 0.24403465f, -0.27986792f, 0.45159200f, -1.13390887f, 0.40255958f, 
    0.55040944f, -0.12846665f, -0.33508080f, -1.05212176f, -0.16601954f, 0.32463461f, 0.15173008f, 0.08861264f, 
    -0.30039197f, -0.09695895f, -0.56946415f, 0.12411106f, -0.14763965f, 0.45907855f, 0.52300543f, -0.98495501f, 
    0.12744905f, -0.86884928f, -0.15255722f, -0.25527862f, -0.01379625f, -0.01937948f, 0.32894057f, -0.12807199f, 
    -0.18219733f, 0.13571048f, 0.38522667f, 0.05430644f, -0.62688994f, -0.28397128f, 0.42208099f, 0.69173187f, 
    -0.24854024f, -0.95621669f, -0.30393767f, -0.03247677f, 0.49134183f, 0.03248763f, 0.17721550f, -0.70595717f, 
    0.42133725f, 0.01334405f, -0.21287163f, -0.37352875f, 0.30922627f, -0.13900155f, 0.26103681f, -0.04893047f, 
    -0.15914695f, -0.34882113f, 1.13840604f, 0.09849576f, -0.36654690f, 0.00482630f, -1.06680036f, 0.31397870f, 
    0.25546277f, -0.15942253f, 0.53063661f, 0.37369388f, -0.17969733f, -0.19605470f, -1.15762234f, -0.68679273f, 
    0.38268805f, 0.89401704f, -0.86428708f, 0.74493080f, -0.01711454f, 0.14963360f, -0.32888767f, 0.65785319f, 
    -0.00915764f, -0.12127431f, -0.53410053f, -0.21608597f, 0.01745706f, -0.25708961f, -1.13673449f, 0.16984925f, 
    0.90829015f, -0.12785105f, -0.36495122f, 0.26941755f, 0.49034274f, -0.96611977f, 0.19904572f, -0.13148618f, 
    0.23177491f, 0.24005941f, 0.05970879f, -0.30329257f, 0.12628536f, -0.27749148f, -1.00718677f, -0.38064826f, 
    0.32152259f, -0.48279530f, 0.55126190f, -0.30374488f, -0.11650149f, 0.46729401f, -0.39991370f, -1.17772806f, 
    -0.52461994f, 0.06529404f, -0.10487773f, 0.17744441f, 0.65081984f, -0.82747597f, -0.28124067f, 0.26124370f, 
    -0.39598933f, 0.49802154f, 0.00380427f, -0.36091492f, 0.67058748f, -0.49998689f, 0.26526991f, 1.23836386f, 
    -0.25191262f, 0.14685035f, 0.18667065f, -0.24252188f, -0.21527569f, -0.45965770f, -0.52874804f, -0.03801121f, 
    -0.73246002f, -0.98309100f, -0.84658396f, 0.18624303f, 0.05816865f, -0.10009443f, -0.17595893f, 0.54514819f, 
    -0.48730966f, 0.14348605f, 0.04249395f, 0.70134354f, 0.24244256f, 0.55217880f, -0.65060461f, -1.16940284f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.74476123f, 0.14157218f, 0.32027835f, 0.18195091f, -0.09594573f, 0.21386395f, -0.18278688f, -0.34343088f, 
    0.12551792f, 0.26952377f, -0.01509076f, 0.26748607f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
