#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.15912859f, -0.37832576f, -0.23964196f, -0.43071210f, 0.49850413f, 0.31408578f, -0.20242193f, -0.12392709f, 
    0.32353058f, 0.37234446f, -0.20545560f, -0.15418413f, -0.54219621f, 0.19614212f, -0.42310297f, 0.07886153f, 
    0.29175413f, 0.12263809f, -0.15638825f, 0.07520242f, -0.39057481f, 0.31841430f, -0.25721851f, -0.27210283f, 
    -0.46119589f, -0.02316182f, -0.57294047f, -0.30180201f, -0.21693113f, -0.15375787f, 0.41800898f, 0.41143528f, 
    0.22203122f, 0.22474833f, -0.08639392f, 0.14480613f, 0.28880847f, 0.13512178f, -0.33910385f, 0.14507498f, 
    -0.43251443f, 0.02156837f, -0.29650638f, -0.17446893f, -0.11804028f, 0.17140721f, 0.12270364f, 0.05438520f, 
    0.22872244f, 0.28746042f, -0.88452452f, -0.71727026f, 0.18986221f, -0.76462209f, -0.35724503f, 0.58566821f, 
    0.60858476f, -0.11480282f, -0.11997661f, 0.81486344f, 0.16836540f, -0.10175803f, -0.15185224f, 0.12371831f, 
    -0.01258078f, 0.01005291f, 0.17593306f, -0.09851442f, 0.01722485f, 0.00571973f, -0.05366212f, 0.00056646f, 
    0.11465726f, -0.00465682f, -0.05248331f, -0.51745450f, -0.79102081f, -0.56390578f, 0.29522762f, 0.24583508f, 
    0.13576408f, 0.18935317f, -0.21921593f, -0.11952209f, 0.23751231f, 0.15731497f, 0.18947089f, 0.16006409f, 
    -0.23941848f, -0.06942556f, -0.02761141f, -0.21960342f, -0.26356506f, -0.06853588f, 0.03436865f, -0.21336630f, 
    -0.32366893f, -0.14270060f, -0.09794748f, -0.16209188f, -0.02060531f, -0.64522189f, -0.52458441f, -0.08916865f, 
    -0.45207539f, -0.48207584f, -0.53528094f, -0.30900839f, 0.05209715f, -0.20453794f, -0.01747303f, -0.06558225f, 
    0.17441845f, 0.14404076f, 0.08218872f, -0.07197736f, -0.08945427f, -0.16924919f, -0.13095565f, -0.41296279f, 
    -0.35094371f, -0.01600201f, 0.06245670f, -0.30830109f, -0.51285827f, 0.40347835f, 0.37437618f, 0.32127264f, 
    0.49456522f, -0.10711480f, -0.23652788f, 0.04759655f, -0.30182883f, -0.31937918f, -0.30402735f, 0.13435386f, 
    0.09384902f, 0.14206016f, -0.17701972f, -0.22840653f, -0.21705012f, 0.13479573f, 0.09287036f, -0.18291965f, 
    0.14130765f, 0.22808646f, -0.10672053f, 0.09014460f, 0.00392364f, -0.24080120f, 0.08669972f, 0.18414398f, 
    0.11865010f, 0.25510660f, -0.19990049f, -0.19173490f, 0.03277797f, -0.22471459f, -0.00574434f, 0.28561929f, 
    0.02209018f, -0.19200222f, 0.01659125f, 0.06375562f, 0.39532870f, -0.11875273f, -0.01402926f, -0.17171270f, 
    -0.06928842f, -0.00582074f, -0.10403261f, 0.14117071f, 0.34525371f, 0.05702902f, 0.18864156f, -0.79249102f, 
    0.35703477f, 0.88391542f, -1.00862753f, -0.61369920f, 0.05043450f, -0.17775252f, 0.34119284f, 0.61731565f, 
    0.21328977f, -0.22112130f, -0.21200009f, -0.10549372f, -0.23708676f, 0.04278234f, 0.22260174f, -0.18495405f, 
    -0.06124086f, -0.07084274f, 0.03572512f, -0.08027532f, -0.03111806f, 0.20986988f, -0.17213190f, -0.06038168f, 
    0.17408159f, 0.46351412f, -0.38753718f, 0.74152511f, -0.53483033f, 0.12205595f, 0.40535110f, -0.21708897f, 
    -0.32507095f, -0.32412654f, 0.06328097f, 0.06923839f, -0.04672576f, -0.16005121f, 0.29049057f, -0.11751499f, 
    -0.23680851f, -0.03867370f, 0.21457598f, -0.09716065f, 0.14738610f, 0.00170556f, 0.12676615f, 0.08532833f, 
    -0.30109209f, 0.39594629f, 0.40370852f, 0.30525032f, 0.31307402f, 0.04654544f, -0.23077032f, -0.43200299f, 
    -0.01136279f, 0.49882028f, -0.07416181f, 0.22266337f, -0.26548439f, -0.17042471f, 0.02682054f, -0.04120375f, 
    -0.15788534f, 0.18457448f, -0.06624332f, -0.04319608f, -0.06955108f, -0.21590477f, 0.08315412f, -0.12038412f, 
    -0.05429085f, -0.25353175f, -0.42290339f, -0.26658159f, -0.26717964f, -0.35157979f, -0.06063442f, -0.33127880f, 
    -0.28990313f, -0.02534957f, -0.44526285f, -0.17009979f, -0.33289447f, -0.16234760f, 0.17300126f, -0.14014311f, 
    0.00428059f, 0.06434517f, -0.05160271f, -0.05881058f, 0.16494998f, -0.14802474f, 0.18883921f, 0.35708866f, 
    0.19439135f, -0.03384413f, 0.32082632f, -0.66090399f, -0.96132195f, 0.33514404f, 0.97782665f, 0.45853990f, 
    0.07728751f, -0.44405293f, -0.79398310f, -0.71116453f, -0.29552451f, 0.34327176f, 0.04946646f, -0.27540666f, 
    0.17494641f, -0.17319854f, -0.04446808f, 0.05720491f, 0.19634768f, 0.11427361f, 0.21083993f, -0.08794846f, 
    -0.02500064f, -0.03041355f, -0.05922116f, -0.05413269f, -0.53501052f, 0.09344875f, 0.39892539f, -0.22706662f, 
    -0.53062052f, -0.29227057f, -0.28376964f, -0.21437950f, -0.63030386f, -0.68662012f, 0.43678391f, 0.25216511f, 
    -0.16307628f, -0.28945714f, 0.16385300f, 0.06597644f, -0.26086536f, -0.20709696f, -0.53184140f, -0.50254840f, 
    -0.03392018f, 0.12652260f, -0.04230306f, 0.15945312f, 0.13195981f, -0.11380807f, -0.17752798f, 0.22491132f, 
    0.28140104f, -0.12126856f, 0.01554517f, -0.05376717f, 0.06349242f, 0.22806488f, 0.22024353f, 0.31165719f, 
    -0.35820121f, 0.05455665f, -0.17223053f, -0.13508511f, -0.20765257f, 0.05575478f, 0.21176083f, 0.15598990f, 
    -0.21215537f, -0.12227794f, -0.15818626f, -0.38520503f, 0.01358317f, 0.64224362f, 0.06151113f, 0.03659505f, 
    -0.43708411f, -0.11458439f, 0.28253523f, -0.38282245f, 0.48061898f, -0.19715340f, 0.00326725f, -0.04442530f, 
    -0.35579690f, 0.78844237f, -0.35123235f, -0.37594041f, 0.21841174f, -0.05243582f, 0.18279453f, -0.04686118f, 
    -0.15067002f, -0.22128382f, 0.11230521f, -0.04559176f, -0.10188670f, -0.03111583f, 0.01870240f, -1.09881473f, 
    -0.26507238f, -0.27085534f, 0.72530496f, 0.74335378f, -0.42852348f, -0.60049301f, 0.23994961f, 0.34359342f, 
    0.67037535f, -0.07469868f, 0.05501695f, -0.02690773f, 0.10535549f, 0.06328075f, -0.07138953f, -0.12814474f, 
    0.14239174f, 0.06747093f, -0.18802583f, -0.05011153f, 0.06450728f, 0.15471096f, -0.03776012f, -0.09958065f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05541864f, 0.21378554f, -0.02004497f, 0.04915447f, -0.26971030f, 0.23131216f, 0.32968447f, 0.07045315f, 
    0.03358518f, -0.03363053f, 0.10226470f, 0.28384122f, 0.13642336f, 0.10481825f, 0.38735396f, 0.19528896f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05894208f, -0.00277331f, -0.05227017f, 0.01037789f, -0.03859412f, -0.06438042f, -0.04773154f, 0.02250260f, 
    0.02141790f, 0.05209442f, 0.01578006f, 0.00021993f, 0.00988855f, 0.04554890f, -0.01763082f, -0.00665789f, 
    -0.03526746f, 0.00077584f, -0.05541130f, 0.02295169f, 0.03131876f, -0.06462129f, -0.00174560f, -0.07881668f, 
    -0.05192744f, -0.00555687f, -0.00703651f, -0.00924772f, -0.07175281f, -0.02016610f, -0.01877001f, 0.00274972f, 
    0.04736985f, -0.05605190f, 0.05297689f, -0.01513681f, -0.07491079f, -0.01877232f, 0.04133934f, 0.02633571f, 
    -0.03405654f, 0.01638116f, 0.03958007f, 0.06876572f, -0.07048422f, -0.07336124f, -0.00980637f, -0.02591062f, 
    0.00702867f, 0.03773550f, -0.04467806f, 0.01801904f, 0.02984783f, -0.02921752f, 0.03819108f, 0.01946480f, 
    -0.04745272f, -0.01029570f, -0.01862765f, 0.06697512f, -0.04932067f, 0.06523767f, -0.05462592f, 0.00131664f, 
    0.00557782f, -0.05397917f, -0.02104108f, 0.05732626f, -0.01995001f, 0.02109221f, -0.00132608f, 0.03429564f, 
    -0.02167637f, 0.05049651f, 0.02850123f, -0.04997897f, 0.01108089f, 0.03427508f, 0.00135016f, 0.05240297f, 
    0.01443195f, 0.00563065f, -0.03358961f, 0.04960378f, -0.00214755f, 0.07581494f, 0.01805585f, -0.02667961f, 
    0.06475163f, -0.02404659f, -0.05564222f, -0.02310578f, 0.00656123f, -0.06105244f, 0.01803185f, 0.04983646f, 
    0.00064141f, -0.04149923f, -0.03544210f, 0.01933360f, -0.06990982f, -0.08035918f, 0.03858498f, 0.04886137f, 
    0.01124795f, -0.04320171f, -0.02511369f, 0.04928187f, -0.07170045f, -0.01769087f, -0.06806913f, 0.02614728f, 
    -0.03934197f, -0.06755888f, 0.03529979f, 0.01010125f, -0.00225335f, 0.05355715f, -0.03146940f, -0.07455250f, 
    0.02858440f, 0.04244351f, 0.04105613f, -0.01692829f, 0.04031215f, 0.05313059f, 0.01266783f, 0.05263894f, 
    -0.00132601f, -0.06722327f, -0.06149904f, 0.01341412f, 0.01705978f, -0.00570349f, -0.06218537f, 0.00591111f, 
    -0.03243595f, -0.03358497f, 0.03686189f, -0.04148946f, -0.00994759f, -0.05014792f, -0.04060547f, 0.01175718f, 
    -0.07006279f, -0.01156980f, -0.03924348f, -0.04405937f, 0.03933332f, -0.04910685f, -0.03067266f, 0.01862405f, 
    0.00896914f, 0.00475634f, 0.01353061f, -0.02898572f, -0.04933040f, 0.00957207f, 0.03055845f, -0.01912568f, 
    -0.03862984f, 0.05111493f, -0.02782801f, -0.06638576f, -0.01610873f, 0.00945718f, -0.07148164f, 0.03717157f, 
    0.02740756f, -0.03391901f, 0.02929250f, -0.07652201f, 0.04896968f, -0.07977320f, 0.01884311f, -0.00982172f, 
    -0.01120089f, -0.07800166f, -0.05715276f, 0.05151408f, 0.05293943f, -0.02249573f, 0.01509548f, -0.03500409f, 
    0.01936930f, -0.07003894f, 0.02057221f, 0.00497912f, -0.05353331f, -0.08490007f, -0.03280735f, 0.06065436f, 
    0.03737523f, -0.05215429f, -0.08050345f, 0.01524711f, -0.08152202f, -0.00864540f, -0.07377339f, 0.03061141f, 
    -0.02120467f, -0.07883517f, 0.01903021f, -0.00635431f, -0.04788331f, -0.05326770f, -0.03671531f, -0.02223942f, 
    -0.03589786f, -0.00130070f, -0.04143659f, -0.03600903f, -0.05448079f, -0.01812329f, -0.05401879f, -0.03752055f, 
    -0.05140089f, 0.03584914f, 0.00718492f, 0.00953896f, -0.02534876f, -0.05513587f, 0.00338256f, 0.03832384f, 
    0.01384279f, -0.05516458f, 0.00245207f, -0.08976477f, -0.06750038f, 0.03952155f, 0.00587495f, -0.06756126f, 
    -0.00990902f, 0.03809880f, -0.01528833f, 0.03066890f, 0.03887800f, 0.02446029f, -0.02538352f, -0.04168703f, 
    0.02466307f, -0.01956250f, -0.04439940f, -0.01398270f, -0.03601065f, -0.00199817f, -0.03777383f, 0.05427201f, 
    -0.01607061f, 0.02984786f, 0.02087939f, -0.06341182f, -0.08119981f, 0.04236695f, -0.02072498f, 0.01049138f, 
    0.04194729f, -0.07328162f, 0.00661762f, -0.07848644f, 0.04024434f, -0.01543212f, 0.02569558f, 0.01696192f, 
    -0.02664387f, 0.03003722f, -0.06859186f, -0.09200470f, -0.04114762f, -0.00474100f, 0.01227689f, -0.00222976f, 
    0.02592594f, 0.05837813f, 0.02855832f, -0.08829540f, -0.00835360f, 0.06583978f, 0.04194321f, 0.03731425f, 
    -0.06922010f, -0.01330305f, -0.00219178f, -0.04730297f, -0.02145595f, -0.08367775f, -0.02516578f, -0.08361490f, 
    -0.02554118f, 0.02894374f, -0.01091128f, 0.03958035f, -0.00411290f, -0.00783402f, 0.00619370f, -0.00636701f, 
    -0.00996946f, 0.02228787f, 0.04380142f, -0.05100619f, -0.08875462f, -0.03621973f, -0.09595603f, -0.00218022f, 
    -0.01516967f, -0.03418428f, -0.02156856f, -0.05677238f, 0.03215890f, -0.08815338f, 0.03643412f, -0.03148884f, 
    -0.04844375f, 0.00743928f, -0.07307819f, -0.02948209f, -0.03031687f, -0.04984085f, 0.02739549f, -0.00336934f, 
    0.04293216f, -0.04627438f, -0.07124598f, -0.01219144f, -0.03653037f, 0.00278581f, -0.00518187f, -0.05902949f, 
    0.06374037f, 0.03217422f, 0.01962380f, 0.01784782f, -0.02450772f, -0.04189684f, 0.02631652f, -0.06037249f, 
    0.06353796f, -0.01953342f, -0.07377796f, 0.03930379f, 0.01902404f, -0.04517851f, -0.02798506f, 0.02857197f, 
    -0.06631340f, 0.04943698f, 0.04121883f, -0.07796636f, -0.06637143f, 0.03111582f, 0.03012250f, 0.02587947f, 
    0.01723829f, -0.07283002f, -0.05454153f, -0.06790952f, 0.05978092f, 0.03276419f, -0.06861831f, -0.08788801f, 
    -0.05563856f, -0.07551807f, 0.02252291f, -0.02220364f, 0.01141882f, -0.05395784f, -0.06406938f, 0.02497104f, 
    0.06078051f, -0.05808102f, -0.02309465f, -0.02388141f, -0.03465261f, -0.05391429f, 0.00760456f, -0.05586714f, 
    -0.05180119f, 0.06689638f, 0.01915170f, 0.02452161f, -0.05724069f, 0.01803891f, 0.01987476f, 0.01503874f, 
    0.16670594f, -0.14334983f, -0.06111026f, 0.02933910f, 0.06671018f, 0.05860152f, 0.06928016f, 0.12146777f, 
    0.19584732f, 0.01142103f, 0.39337495f, 0.26974520f, -0.20270404f, 0.10808580f, -0.07066086f, -0.13106838f, 
    0.09003492f, -0.14708401f, -0.03166812f, -0.06641504f, -0.21519317f, 0.09155163f, 0.00186795f, -0.06616918f, 
    0.09728559f, -0.08937931f, 0.12468643f, 0.15780994f, 0.00239016f, 0.08607472f, -0.01246404f, 0.09583936f, 
    -0.00535209f, -0.11477148f, 0.01535851f, 0.20587547f, -0.10059972f, -0.04012860f, 0.05178494f, 0.00998076f, 
    0.05600289f, -0.01780254f, 0.00053237f, 0.10507232f, 0.06384742f, 0.13000901f, 0.30335882f, 0.13212609f, 
    -0.13068908f, -0.10094564f, -0.10188437f, 0.15732929f, -0.14205648f, -0.07442882f, 0.07261725f, 0.04421631f, 
    -0.04065467f, 0.06297563f, 0.22209333f, 0.20096974f, 0.02286968f, 0.25747088f, 0.27293327f, -0.04463807f, 
    -0.12081616f, 0.16166019f, 0.14753585f, 0.03452893f, 0.03138285f, 0.06718293f, -0.17775390f, -0.07334131f, 
    -0.02346546f, -0.03055864f, -0.20525350f, -0.09848446f, 0.11717599f, -0.17914522f, -0.21029548f, -0.09428412f, 
    -0.01946187f, -0.44738677f, -0.32720250f, -0.16413680f, 0.32676518f, 0.08992041f, -0.00537885f, 0.07976057f, 
    -0.09385578f, 0.40359634f, 0.04984318f, -0.10123839f, -0.09970720f, 0.15761375f, 0.11427131f, 0.28662801f, 
    -0.33341327f, 0.03972974f, -0.10228955f, 0.06273981f, 0.04659070f, -0.00495314f, 0.00161660f, -0.03553441f, 
    -0.04319467f, 0.02808412f, 0.07849922f, 0.10338290f, 0.11580104f, -0.06185094f, 0.22832330f, -0.00247908f, 
    -0.10865448f, -0.05786109f, -0.01740217f, 0.05674753f, -0.04182433f, -0.01306369f, -0.03526240f, -0.08654551f, 
    -0.00634981f, -0.10933033f, -0.24245253f, -0.08350895f, -0.14635040f, -0.10585596f, -0.05745550f, 0.04726255f, 
    -0.00394782f, -0.12463254f, -0.11586761f, -0.12291449f, -0.13644013f, 0.04807731f, -0.14622429f, 0.07340342f, 
    0.01843208f, 0.00996553f, 0.17193435f, 0.20829271f, 0.05216372f, 0.03637297f, -0.05046219f, -0.11935052f, 
    -0.03643432f, -0.02373542f, -0.01755754f, 0.06246090f, -0.06464104f, -0.09573147f, 0.13172852f, -0.04396259f, 
    -0.04652091f, -0.00900416f, -0.01330314f, -0.23606515f, -0.01269402f, -0.12401692f, -0.03279610f, -0.28629118f, 
    -0.04484056f, -0.11946674f, 0.05165954f, 0.02032898f, 0.09369680f, 0.12296501f, 0.10857331f, -0.18456212f, 
    0.12611003f, 0.07370016f, -0.10086067f, 0.00645416f, 0.01642848f, 0.00136443f, -0.02475430f, 0.02618076f, 
    -0.09237433f, 0.14106630f, -0.05974236f, 0.11044194f, 0.59081882f, -0.07524387f, -0.18242446f, 0.12331606f, 
    0.34527531f, -0.02790136f, -0.24769604f, -0.07163736f, 0.10322557f, -0.01768889f, 0.08614256f, 0.09040837f, 
    0.00055343f, -0.02822126f, 0.05216745f, 0.01325638f, -0.01535087f, 0.00782837f, 0.03343605f, -0.04127239f, 
    -0.04927345f, -0.06181855f, -0.05544973f, -0.00122113f, -0.00703749f, -0.02192533f, -0.04906004f, 0.02176775f, 
    -0.07016931f, 0.03484965f, 0.00436772f, -0.07597461f, 0.05472933f, 0.00768570f, 0.05094759f, -0.05084714f, 
    0.02681346f, 0.06057767f, 0.00563165f, 0.03917930f, -0.02711147f, 0.03248740f, 0.05506463f, 0.03624759f, 
    -0.00143782f, -0.00423497f, -0.03225912f, -0.03683823f, 0.01123885f, 0.06344863f, 0.00611939f, -0.07285540f, 
    -0.02042485f, -0.08023610f, 0.06062612f, 0.05721419f, -0.05813804f, -0.05601544f, -0.04442269f, -0.00078920f, 
    -0.07664240f, -0.04053084f, 0.03538445f, -0.00255717f, 0.05211456f, 0.04563741f, 0.02739787f, -0.01733883f, 
    -0.07103977f, -0.02771305f, 0.06300309f, 0.04557533f, -0.05796099f, -0.05034970f, 0.03289361f, -0.07062402f, 
    -0.00880496f, -0.03182092f, 0.04322035f, 0.04040163f, -0.05394930f, -0.02356139f, 0.00790707f, -0.04126390f, 
    0.05014472f, 0.04467499f, -0.07621474f, -0.06461391f, -0.02676149f, 0.04931912f, 0.04706615f, -0.00737503f, 
    0.00127790f, -0.03750325f, 0.02868112f, -0.07272950f, -0.01038900f, 0.01864037f, -0.02857904f, -0.04342064f, 
    0.05847355f, 0.00998105f, -0.04537007f, 0.02054275f, 0.06307033f, -0.02449021f, -0.07945362f, -0.05653045f, 
    0.01601471f, -0.01314005f, 0.00004806f, -0.00217031f, 0.01771092f, 0.01146364f, 0.02189509f, -0.07096781f, 
    -0.00943045f, -0.07506086f, 0.02820111f, 0.02550582f, -0.07716478f, 0.02286437f, -0.04513773f, -0.02085907f, 
    -0.04302687f, -0.02211372f, 0.01001856f, -0.05272610f, -0.01512515f, 0.04766628f, -0.04043769f, -0.07149491f, 
    -0.04848924f, -0.07313733f, -0.07313361f, 0.00300262f, 0.00092788f, -0.00614554f, -0.06119734f, 0.04111868f, 
    -0.01955041f, -0.01192126f, 0.01347242f, -0.01818085f, 0.04051273f, 0.04545609f, -0.02103684f, 0.00259355f, 
    0.01224309f, -0.02316054f, 0.00775234f, -0.07529628f, -0.06363313f, 0.05566114f, -0.06234501f, 0.03650088f, 
    0.00064534f, 0.03675077f, -0.00350865f, 0.03043484f, 0.04443242f, 0.00902307f, -0.06295409f, -0.02439433f, 
    0.00938819f, -0.03568347f, -0.03177647f, -0.03224248f, 0.00955379f, 0.01693427f, -0.00514325f, -0.04881151f, 
    -0.04891165f, 0.03848131f, 0.03245890f, 0.01056934f, -0.05102431f, -0.00618532f, -0.05206953f, 0.04185119f, 
    -0.00764874f, -0.05944427f, 0.01098137f, 0.05641017f, -0.03595261f, -0.01754101f, -0.05215018f, 0.03884955f, 
    -0.07757366f, -0.06190155f, 0.00833518f, 0.01827506f, 0.01834234f, -0.02441205f, -0.03918885f, 0.05403157f, 
    0.04182861f, -0.02427670f, -0.04965607f, -0.06684499f, 0.05805225f, -0.01394362f, 0.02135770f, -0.04268290f, 
    -0.02854005f, 0.01435621f, 0.00256027f, -0.02198208f, -0.03181768f, -0.00413231f, 0.03546592f, -0.01071195f, 
    0.02757604f, 0.01958858f, -0.05320944f, -0.02489849f, -0.01171352f, -0.06492496f, -0.04179345f, -0.01700260f, 
    -0.02158993f, -0.03465491f, -0.05595442f, 0.02189008f, -0.07268793f, 0.02699179f, -0.05616570f, -0.07409815f, 
    -0.07388303f, -0.01510624f, -0.04707151f, -0.06831515f, -0.10508275f, -0.06638777f, -0.01366898f, -0.05042910f, 
    -0.05381003f, -0.07854259f, -0.01018987f, 0.03853294f, -0.01258161f, 0.02324531f, -0.06034392f, -0.01501610f, 
    0.03279458f, -0.08921231f, -0.08146444f, -0.09173029f, -0.07510155f, -0.00343225f, -0.01728006f, -0.05883783f, 
    -0.02363314f, -0.00203269f, 0.02617917f, -0.06967060f, 0.01781177f, -0.06235513f, -0.04679530f, -0.01731075f, 
    0.00293719f, 0.05652206f, 0.03628451f, -0.02670508f, -0.04036066f, 0.00536426f, 0.03959307f, 0.01330633f, 
    -0.06306591f, -0.08398571f, -0.00092148f, -0.01762016f, 0.01335447f, 0.00214486f, 0.01875277f, -0.06451211f, 
    -0.00559487f, -0.08471885f, 0.01178135f, -0.09675317f, -0.03558935f, -0.01503306f, -0.04293022f, -0.04569107f, 
    -0.09924240f, 0.01703876f, 0.03016018f, 0.00684930f, 0.01059674f, 0.02881871f, -0.03440857f, 0.01735988f, 
    -0.09166050f, -0.05821821f, -0.03110774f, -0.04917538f, -0.03693557f, -0.05649326f, 0.06561638f, -0.00014657f, 
    0.02489810f, 0.00719507f, 0.03663727f, -0.00048555f, -0.05135157f, -0.08986390f, -0.10752681f, -0.02312874f, 
    -0.00753470f, 0.02546836f, -0.05749495f, 0.01939540f, -0.09305651f, -0.07050312f, -0.01130367f, -0.03246330f, 
    0.00663019f, -0.10967170f, 0.01933869f, -0.06051994f, -0.04544234f, 0.02322579f, -0.04393513f, -0.05972119f, 
    -0.00999953f, -0.02657516f, -0.04883091f, -0.04289597f, -0.07845552f, 0.05326457f, -0.06623080f, -0.00758104f, 
    0.01074184f, -0.01413427f, 0.00141273f, -0.11227679f, -0.03663421f, -0.06050605f, 0.05293575f, -0.05760136f, 
    0.00343860f, -0.00556310f, 0.01726835f, -0.01391936f, -0.01276704f, -0.00097595f, 0.03019613f, -0.09730645f, 
    0.00937665f, -0.07493921f, 0.05758229f, 0.01972363f, -0.00807281f, -0.00540362f, -0.02501156f, -0.06868532f, 
    0.03774407f, -0.03774400f, 0.04806327f, -0.02148007f, -0.07781965f, -0.00895534f, 0.01433522f, -0.02995943f, 
    -0.10701477f, -0.08185154f, 0.02349936f, -0.09969313f, -0.04148441f, -0.00336846f, -0.00051266f, 0.00308043f, 
    0.00910258f, -0.04533432f, 0.05841539f, -0.03607141f, -0.07222689f, -0.09606966f, -0.04114892f, 0.02018537f, 
    -0.07640845f, -0.00786919f, 0.04372617f, -0.00453066f, -0.04661890f, -0.03503264f, -0.07809648f, -0.08220003f, 
    -0.04146972f, -0.00647744f, 0.02126491f, -0.08483995f, -0.00375056f, 0.03900894f, 0.00441420f, -0.05966635f, 
    0.01908545f, -0.31188619f, 0.18133962f, -0.23021062f, -0.13093956f, -0.07220295f, 0.01918668f, -0.07701679f, 
    -0.05919923f, -0.16745873f, 0.07337329f, -0.01947967f, 0.38170165f, -0.05226044f, 0.06011703f, 0.02989342f, 
    0.02687068f, 0.03387120f, -0.05298385f, -0.03833872f, 0.15155995f, 0.07571749f, 0.15256549f, -0.04766924f, 
    -0.24109060f, -0.10423042f, -0.22654536f, -0.21071124f, -0.04084649f, -0.04761957f, -0.06340883f, 0.05781490f, 
    0.04011839f, -0.03546719f, -0.05900016f, -0.11040209f, -0.09157836f, -0.14945222f, -0.13900951f, -0.12810777f, 
    -0.06131197f, -0.05203912f, -0.02643921f, -0.00305060f, -0.09245291f, -0.02488993f, -0.18163840f, -0.01305176f, 
    0.15304610f, -0.03818381f, 0.14495201f, 0.10495891f, -0.08394980f, 0.08559553f, -0.05396649f, 0.04647376f, 
    0.17309408f, -0.06964446f, 0.02951632f, -0.14204478f, 0.24966148f, 0.00303924f, 0.00959622f, 0.32650682f, 
    0.10154900f, 0.02019993f, -0.05201618f, 0.06496730f, 0.08893289f, -0.02487979f, -0.02020362f, -0.00212238f, 
    0.07259940f, 0.05534442f, -0.03041182f, 0.05286442f, -0.02371383f, -0.00854440f, -0.11417950f, 0.01358874f, 
    0.10375662f, 0.01691716f, -0.03878844f, 0.04979388f, -0.02479611f, 0.01941414f, -0.29987571f, 0.05171487f, 
    0.10966001f, -0.09031852f, 0.02338183f, 0.07065287f, -0.07293802f, -0.05374257f, -0.04845691f, 0.08489721f, 
    0.22620976f, 0.19396180f, -0.00909206f, 0.07223468f, 0.03665455f, 0.12082030f, -0.12079318f, -0.03495700f, 
    0.14044572f, -0.13973948f, -0.09696718f, -0.10484724f, 0.10102683f, -0.17846467f, 0.16908941f, 0.24037336f, 
    0.09190483f, -0.02367726f, 0.03114160f, -0.04666676f, 0.15325540f, -0.04190546f, 0.03505384f, 0.02058584f, 
    -0.00029981f, 0.04548902f, 0.12400413f, 0.20711887f, 0.07354987f, 0.00167421f, 0.01760827f, 0.09773140f, 
    0.05830868f, 0.07665579f, 0.01111868f, 0.06235839f, 0.09531029f, -0.01315827f, 0.41934711f, 0.18568155f, 
    0.07308123f, 0.06987613f, 0.02645539f, 0.04021507f, -0.02713088f, -0.06595373f, -0.05350252f, 0.00955539f, 
    0.09657526f, 0.19436234f, 0.21084268f, 0.40616691f, 0.14213219f, -0.01782874f, 0.00314138f, 0.04569865f, 
    -0.13501891f, -0.12005309f, 0.04122847f, 0.03790599f, 0.29342741f, -0.06467441f, 0.03361774f, 0.01039906f, 
    -0.03848794f, -0.07154265f, -0.04392831f, -0.04780569f, -0.17208332f, -0.03256125f, 0.04526938f, 0.18187115f, 
    0.00636250f, -0.04676520f, -0.13136981f, -0.20359005f, 0.09599140f, -0.14924011f, 0.09461443f, 0.06423827f, 
    -0.13469325f, -0.08000319f, 0.11114147f, -0.08785798f, 0.42018864f, -0.44576392f, -0.01557661f, -0.09924455f, 
    -0.08743521f, -0.10625097f, -0.05364573f, -0.06732542f, -0.07765355f, 0.04903363f, 0.10214278f, 0.06818428f, 
    0.01819662f, 0.03723118f, -0.04827873f, -0.12266240f, -0.04984339f, 0.16091286f, 0.12123761f, 0.15707733f, 
    0.09399498f, 0.16324954f, -0.04525517f, 0.02249281f, -0.12504642f, -0.05407407f, -0.04735945f, 0.10647012f, 
    -0.04203932f, -0.01664902f, -0.06851608f, 0.01110778f, 0.18181792f, 0.04618305f, -0.00398166f, 0.04783884f, 
    -0.36537614f, -0.10670262f, -0.21877834f, -0.22642210f, 0.00052858f, 0.05252879f, 0.21951784f, -0.03325806f, 
    -0.05543360f, 0.05812284f, 0.04947929f, 0.05021073f, -0.18637861f, 0.33779007f, -0.10869415f, -0.17184980f, 
    -0.11479741f, 0.07517200f, 0.02960042f, -0.02911193f, 0.04728093f, 0.00205909f, 0.01255595f, -0.05248089f, 
    0.03993296f, -0.30661982f, -0.40070385f, -0.29635382f, -0.02081442f, 0.24153247f, -0.12099417f, 0.05027428f, 
    0.06015186f, 0.06573754f, 0.08336113f, 0.10194035f, 0.32742655f, 0.08892961f, 0.16446264f, 0.20943531f, 
    -0.07419880f, -0.07802486f, -0.08559337f, -0.10082627f, 0.00647945f, 0.05779379f, -0.00078793f, 0.03567480f, 
    0.08801636f, -0.06776077f, -0.06923635f, 0.09573343f, -0.10862748f, -0.04107954f, -0.11953691f, 0.00801704f, 
    -0.09700996f, -0.03156050f, 0.02399338f, -0.13375331f, -0.26085690f, -0.54743510f, 0.19229411f, 0.07055290f, 
    0.08874293f, -0.03276776f, 0.04049817f, -0.06147397f, 0.14849152f, 0.08448797f, 0.12509379f, -0.01011777f, 
    0.13767290f, -0.03640905f, -0.00264039f, 0.30922848f, 0.13117778f, 0.12655234f, 0.07056164f, -0.09982878f, 
    -0.00031204f, -0.06396446f, -0.02863737f, -0.04204861f, 0.26820096f, 0.17962632f, 0.08249204f, 0.03310598f, 
    -0.02215799f, 0.00782427f, -0.09224308f, -0.03928608f, -0.11174648f, 0.07839643f, -0.04020062f, -0.08097497f, 
    -0.10653540f, -0.37230161f, -0.11844429f, -0.29521972f, 0.07623012f, -0.19658925f, -0.11191707f, -0.18647447f, 
    -0.05376358f, 0.02575644f, -0.15788385f, -0.02375300f, -0.27880529f, -0.07692015f, 0.08684086f, 0.19766243f, 
    -0.01232948f, 0.11858276f, -0.02271348f, 0.02573255f, 0.01051160f, 0.02096051f, -0.04498703f, 0.05076939f, 
    -0.37826115f, -0.63596684f, -0.04426024f, -0.46029189f, 0.02438714f, -0.04978192f, -0.03693860f, 0.07135974f, 
    0.03249148f, -0.02669909f, 0.28031710f, -0.03392375f, -0.04179174f, 0.15767889f, 0.10865897f, 0.15401372f, 
    -0.11069027f, -0.04557006f, -0.02970535f, 0.00830434f, 0.09699637f, 0.00620008f, 0.02130931f, 0.13157667f, 
    -0.08752939f, 0.18197112f, 0.02489596f, 0.23202640f, 0.10697490f, 0.13229841f, 0.08565684f, 0.00209629f, 
    0.11416950f, 0.12557782f, 0.17364269f, 0.13528696f, 0.03137654f, 0.14157718f, -0.18046924f, -0.11214017f, 
    -0.09497590f, -0.01140641f, -0.03659796f, -0.01601958f, 0.10373398f, 0.15892701f, 0.06477151f, 0.02541273f, 
    0.19043671f, 0.28968605f, -0.07341439f, 0.02229138f, -0.03098969f, -0.01667474f, 0.04600695f, -0.22648866f, 
    -0.04683076f, 0.03239540f, -0.05754030f, 0.01909725f, 0.35918847f, 0.06263521f, -0.03142251f, -0.01057188f, 
    -0.06051590f, -0.12561053f, -0.09242532f, -0.08239304f, -0.02328945f, -0.00694493f, 0.07943146f, 0.08339287f, 
    0.17749746f, 0.14762481f, -0.27445585f, -0.29507914f, -0.02615657f, -0.29347408f, -0.03402875f, -0.01449251f, 
    0.18387647f, 0.08933666f, -0.03646738f, 0.01317184f, 0.03304409f, 0.12740967f, -0.20534895f, -0.03304217f, 
    0.11101073f, -0.07683345f, -0.26950777f, -0.12379022f, -0.01949676f, -0.10077599f, -0.04832120f, 0.02595791f, 
    0.29690644f, 0.28758770f, 0.21188165f, 0.14836891f, 0.26127711f, -0.12968300f, 0.16486740f, 0.17712927f, 
    0.10459898f, 0.10461622f, 0.01049781f, -0.06149092f, 0.05254622f, -0.21245641f, -0.01150713f, 0.01547978f, 
    -0.11575524f, 0.12432364f, 0.08086909f, 0.25366259f, 0.08669078f, -0.12648557f, -0.01683539f, -0.08742573f, 
    0.01771667f, 0.04668433f, 0.05662441f, -0.20663019f, 0.06333035f, 0.02456217f, 0.10465678f, 0.00141712f, 
    0.02202916f, 0.05891220f, -0.02759344f, 0.07995410f, 0.12715335f, -0.18513659f, 0.14696044f, -0.55866444f, 
    -0.02237808f, -0.06587999f, 0.15860435f, 0.01725800f, 0.11104380f, -0.11976004f, -0.10823182f, 0.11992917f, 
    0.22943668f, -0.06063911f, 0.15156487f, 0.04115656f, -0.26146394f, 0.11445467f, 0.02102349f, 0.30744940f, 
    0.02808748f, 0.02707821f, -0.16059016f, -0.14599827f, -0.00114478f, -0.08200876f, -0.17748141f, 0.17279859f, 
    -0.07960708f, 0.00586283f, 0.07432687f, 0.01489251f, -0.04623190f, -0.07730796f, -0.11986842f, 0.00250452f, 
    0.10727277f, 0.27448428f, 0.27143335f, 0.15439957f, 0.11615703f, 0.16788620f, 0.15769102f, 0.18676358f, 
    0.07745755f, 0.03455579f, 0.08285991f, 0.01771795f, 0.16537400f, 0.06987340f, -0.26474696f, -0.15473087f, 
    0.11319990f, 0.08792295f, 0.03980645f, 0.24427529f, 0.05341787f, -0.04186738f, 0.02200273f, -0.01623270f, 
    0.16335736f, 0.23377460f, 0.33832541f, 0.34637964f, 0.09458978f, 0.11572322f, 0.12578259f, 0.03999044f, 
    0.09597820f, -0.00879282f, 0.01075674f, 0.06363539f, -0.07695551f, -0.02510255f, -0.07035748f, 0.11493178f, 
    -0.08231051f, 0.06268574f, -0.15685339f, -0.23950012f, 0.01108833f, -0.03030186f, 0.02462084f, -0.00172006f, 
    -0.11820633f, 0.14863622f, 0.17765048f, -0.05985596f, -0.06963094f, -0.02922394f, 0.03871886f, -0.12259615f, 
    0.02676431f, -0.15571770f, -0.09336733f, -0.14840446f, -0.53857863f, 0.35949078f, 0.44630659f, -0.01930988f, 
    0.01381164f, 0.04273643f, -0.14201769f, -0.17822325f, -0.05363296f, -0.00270293f, -0.05187358f, 0.16720311f, 
    0.04687787f, -0.08011214f, 0.23816790f, 0.14711155f, -0.01284757f, -0.07531717f, -0.00046955f, -0.00690719f, 
    -0.02076826f, 0.00208291f, 0.01451308f, 0.11178064f, 0.36954132f, -0.05119831f, 0.18917322f, -0.03052513f, 
    0.05715422f, -0.05077615f, -0.02566130f, -0.04195663f, 0.11713099f, 0.04355085f, 0.00833227f, 0.04045454f, 
    -0.01085999f, 0.13105376f, 0.14952426f, -0.00485105f, -0.11089311f, -0.14983605f, -0.07793879f, -0.01137464f, 
    0.04378647f, 0.06386904f, -0.01332993f, 0.12460500f, 0.09218967f, -0.20222235f, 0.34630632f, 0.03243113f, 
    -0.06396679f, 0.00802739f, -0.13437086f, 0.06762373f, -0.04367629f, 0.11231641f, 0.02802476f, 0.12412594f, 
    0.14082216f, 0.14463870f, 0.21046378f, -0.03923054f, -0.05081834f, -0.08464903f, -0.03260005f, 0.00834699f, 
    -0.10954569f, -0.08365174f, -0.02521404f, -0.00331526f, 0.10921276f, -0.26736334f, -0.14178258f, 0.02825402f, 
    0.13768125f, 0.15387505f, -0.03905588f, 0.16111360f, 0.04898277f, -0.03038959f, 0.06048723f, 0.00830664f, 
    0.00304195f, -0.01829557f, -0.05531486f, 0.20317033f, 0.01198793f, 0.05725252f, 0.05235611f, 0.12862557f, 
    0.00052906f, 0.00390439f, -0.07662950f, -0.03762016f, -0.49731565f, 0.25544092f, -0.26790339f, -0.01059266f, 
    0.00397144f, -0.10829215f, 0.08094276f, 0.10825136f, 0.02209884f, -0.15825503f, 0.06365462f, -0.00102522f, 
    0.38174120f, -0.12860872f, -0.03823124f, -0.14186941f, 0.14393632f, -0.11875890f, -0.01282410f, 0.02116462f, 
    0.05889173f, -0.02075917f, -0.03872831f, -0.09934043f, -0.17881565f, -0.19975063f, -0.11146422f, 0.07595367f, 
    0.10727785f, 0.05059797f, 0.08191497f, -0.04030621f, 0.10859147f, -0.06972916f, 0.08354816f, 0.05879065f, 
    -0.02780878f, 0.13040616f, -0.02103748f, -0.05125918f, -0.00536128f, 0.05817159f, 0.08322161f, -0.01683461f, 
    0.03160676f, -0.06626661f, 0.10629846f, -0.07575419f, 0.21872577f, -0.34969601f, 0.23888521f, -0.08668494f, 
    0.02194045f, 0.05114580f, -0.04326018f, 0.03147562f, -0.03559481f, 0.00273943f, 0.00133355f, -0.07901918f, 
    -0.02949931f, 0.17063317f, 0.01769758f, 0.11426901f, -0.06312683f, -0.05014382f, -0.02930507f, -0.07225846f, 
    0.01556142f, -0.05844945f, -0.07398655f, 0.00167311f, 0.10306131f, -0.16265920f, 0.06712501f, 0.04579610f, 
    -0.00273640f, 0.13012221f, 0.04028888f, 0.10545833f, -0.01925910f, -0.10400071f, -0.05607641f, 0.02525565f, 
    0.01820453f, -0.10926837f, 0.16625261f, -0.27750024f, 0.01607092f, -0.11935645f, 0.00225446f, 0.10454325f, 
    0.06421555f, -0.03167482f, 0.06268440f, -0.07535584f, -0.35412085f, -0.23546498f, 0.36759797f, 0.49867222f, 
    -0.05603391f, 0.08728368f, -0.04404780f, -0.04324346f, -0.01751486f, -0.03491010f, -0.02474705f, -0.05500609f, 
    0.08796943f, 0.02849281f, 0.04284875f, -0.03751153f, 0.09365757f, -0.10472324f, -0.12276963f, -0.03969039f, 
    0.07035774f, -0.15806340f, 0.01491106f, 0.00463445f, -0.12396578f, -0.19260919f, -0.20180920f, -0.07725704f, 
    -0.00787919f, 0.05621409f, 0.00133491f, -0.03188435f, -0.00381882f, 0.09017970f, 0.05403996f, -0.08374068f, 
    0.18994564f, 0.19646937f, -0.13779947f, 0.05446814f, 0.09345274f, -0.00502844f, -0.05605391f, -0.05056482f, 
    -0.06115574f, -0.08771078f, -0.04426958f, -0.03977496f, 0.03782147f, -0.02107633f, -0.03415478f, 0.16398725f, 
    0.06817325f, -0.00243823f, -0.01900473f, 0.01534383f, -0.11392050f, -0.11927410f, 0.02326615f, 0.14524689f, 
    -0.03206512f, 0.05145959f, 0.19495974f, 0.12526332f, -0.03207912f, -0.11470872f, 0.00960987f, 0.12164230f, 
    0.24477296f, 0.23932429f, 0.15388806f, 0.11366282f, 0.09116116f, 0.06986034f, 0.05085952f, -0.09149078f, 
    -0.14002544f, -0.10486813f, -0.01119827f, -0.01993984f, 0.04186733f, 0.01827951f, 0.03440227f, -0.04449851f, 
    -0.10460516f, -0.02625281f, -0.18383110f, -0.18736157f, -0.04109840f, -0.06065069f, 0.02803443f, -0.01837641f, 
    0.06419603f, -0.04077142f, -0.00654864f, -0.00990374f, 0.24517997f, 0.32287002f, 0.13156612f, -0.34964246f, 
    0.10443829f, -0.22278282f, 0.06289141f, -0.15778708f, 0.01827550f, 0.04122590f, 0.06661522f, -0.04434836f, 
    -0.13902491f, 0.08098952f, -0.20501709f, -0.25266805f, -0.05979494f, -0.15811050f, -0.18337476f, -0.03663270f, 
    -0.00897507f, -0.02386019f, -0.05140268f, -0.14528419f, -0.22740306f, -0.33791035f, -0.09855113f, -0.12237754f, 
    -0.09271637f, -0.07931951f, -0.06058841f, -0.07224764f, 0.01901156f, -0.05025284f, -0.00565632f, 0.03002241f, 
    0.13485165f, 0.20771511f, 0.21731426f, 0.22327745f, -0.13912089f, -0.00501043f, 0.03387358f, 0.14154051f, 
    0.01539615f, 0.07206667f, 0.06194523f, -0.01134710f, 0.09136873f, 0.24931468f, 0.22693892f, 0.19683699f, 
    -0.06789832f, -0.08404071f, 0.01797676f, 0.07719832f, 0.07664711f, 0.03263373f, 0.11815991f, 0.03010889f, 
    0.10165755f, 0.09773003f, 0.19132520f, 0.22090541f, 0.15829234f, 0.09907753f, 0.10247973f, 0.08961318f, 
    0.05019103f, 0.03009837f, -0.01805685f, 0.04866437f, -0.34617272f, -0.19344972f, -0.17020375f, -0.18965936f, 
    -0.01240758f, -0.06754056f, -0.01728666f, -0.03606323f, 0.04134595f, 0.05061629f, 0.04552909f, 0.01231093f, 
    0.17945743f, -0.04831090f, -0.10175136f, 0.00222991f, -0.04915779f, 0.04728446f, 0.03397477f, 0.06095946f, 
    0.01175122f, 0.12759466f, -0.13447610f, -0.00154188f, -0.36085984f, -0.02482695f, -0.13068013f, -0.03132491f, 
    0.15801351f, 0.04479722f, 0.02350112f, -0.07169451f, 0.06326594f, 0.00498506f, 0.04696362f, 0.26565063f, 
    0.04344968f, -0.07926343f, 0.15596095f, -0.02120489f, -0.06404537f, -0.09210239f, -0.02662840f, 0.07100547f, 
    0.08977693f, -0.07140734f, 0.14168824f, 0.13675167f, 0.17006427f, -0.02996279f, 0.09768411f, -0.09015156f, 
    0.00128242f, -0.04732783f, -0.13274150f, -0.08513326f, 0.07980158f, -0.03680381f, 0.08256447f, 0.06918381f, 
    -0.22009477f, 0.20171045f, -0.03636142f, -0.03252166f, -0.13887160f, -0.17465416f, -0.07538485f, 0.09524394f, 
    0.04375365f, -0.09411844f, -0.03430452f, -0.05962501f, 0.00291785f, -0.00666287f, 0.28384301f, 0.03063630f, 
    -0.10410221f, -0.09779781f, -0.07923046f, -0.02406130f, 0.06172818f, 0.12126589f, -0.00569984f, 0.03117313f, 
    -0.00493350f, -0.06669285f, 0.02003299f, -0.07088654f, -0.00225855f, -0.06401630f, 0.01506334f, 0.11086996f, 
    0.17725536f, 0.10204712f, 0.07630287f, 0.05342285f, 0.31718409f, 0.01545929f, -0.12699921f, -0.01251243f, 
    -0.04348913f, 0.06250064f, 0.06492207f, 0.07488587f, -0.04147098f, 0.06022166f, -0.07682581f, -0.16813928f, 
    0.04227226f, 0.00301307f, -0.13571072f, -0.01685985f, -0.02117352f, 0.07096957f, -0.04220197f, 0.05338922f, 
    -0.05102512f, -0.03085406f, -0.12096187f, -0.01014862f, -0.53971756f, -0.02273677f, -0.20871937f, -0.02759478f, 
    0.00661236f, -0.14077666f, 0.19027054f, -0.06642097f, -0.00519875f, 0.10297165f, 0.19450814f, -0.04257492f, 
    0.10687266f, 0.09798670f, -0.01859562f, -0.06824376f, -0.00018480f, 0.10082860f, 0.12731759f, -0.00218438f, 
    0.01238099f, 0.00542030f, -0.13435668f, -0.03921486f, 0.31884295f, 0.04660577f, -0.16738681f, -0.02281016f, 
    0.05777538f, -0.00503832f, -0.06820413f, -0.03408672f, -0.01124456f, -0.08362967f, 0.05992980f, -0.09545472f, 
    -0.06745626f, -0.07796811f, 0.07542415f, 0.06824993f, -0.04415440f, -0.07235727f, -0.12523672f, -0.14921479f, 
    -0.02470004f, -0.01657844f, 0.02119009f, -0.01898693f, -0.04014823f, -0.33099633f, 0.27120706f, 0.20716612f, 
    -0.05665499f, 0.11232001f, 0.04672256f, -0.02933954f, -0.11786955f, 0.00274522f, -0.04662528f, 0.02288399f, 
    -0.24303441f, 0.11887382f, -0.00566302f, 0.20468958f, -0.05455201f, -0.13399093f, 0.05453266f, -0.07082807f, 
    0.01078938f, 0.07812495f, 0.14537437f, 0.02993740f, 0.07878996f, -0.11919731f, 0.05979580f, 0.05195849f, 
    -0.06361785f, -0.11008506f, -0.11039674f, -0.06219739f, -0.19244495f, 0.09679811f, -0.15164638f, 0.08885354f, 
    -0.02767930f, 0.04776181f, 0.10145428f, 0.08542374f, 0.17047425f, 0.03729618f, 0.06034531f, 0.17484462f, 
    0.09496256f, -0.03863803f, 0.24657965f, -0.15454264f, 0.34890002f, -0.34968856f, -0.08734394f, 0.33066741f, 
    0.14405701f, -0.06847890f, -0.07671544f, -0.11745393f, 0.20990939f, 0.18310927f, 0.15455465f, 0.04262683f, 
    0.03193092f, 0.02326829f, 0.03111927f, -0.01293333f, 0.04760280f, -0.05255730f, -0.05446693f, 0.03838131f, 
    -0.07811292f, 0.05356352f, 0.05517552f, 0.03618607f, 0.05266996f, 0.04182678f, -0.07020983f, 0.05114254f, 
    -0.05368827f, -0.03143281f, -0.06293253f, -0.03804297f, 0.05112328f, 0.03266572f, -0.05107407f, 0.01522633f, 
    0.05005547f, -0.08301650f, 0.05275361f, 0.02047751f, 0.01415664f, 0.00537913f, 0.04273158f, 0.02264783f, 
    -0.00356479f, -0.06654818f, -0.02112603f, -0.06493095f, -0.06955642f, -0.04953872f, -0.03589603f, -0.07526809f, 
    0.00590398f, -0.03299920f, 0.00135994f, -0.04055441f, -0.04338234f, -0.03253013f, -0.00908217f, 0.01506612f, 
    0.03008012f, 0.05924243f, -0.06885507f, 0.02930095f, -0.06596153f, -0.01914530f, -0.07362535f, 0.04350565f, 
    0.00217122f, 0.04085010f, 0.00711981f, -0.00126580f, 0.03773624f, -0.04629213f, 0.02373844f, -0.01023160f, 
    -0.07692005f, 0.01143594f, 0.02941246f, -0.00981727f, 0.01809809f, 0.00894644f, -0.01810747f, 0.04715334f, 
    -0.05955965f, -0.04042372f, 0.02471882f, -0.04563032f, -0.02800400f, -0.00584948f, 0.00063510f, 0.04859717f, 
    -0.05257266f, -0.07338248f, -0.04576349f, -0.00966913f, -0.00420665f, 0.04405606f, -0.07742894f, -0.06932116f, 
    0.00054768f, 0.01775914f, 0.01211559f, -0.03130838f, -0.00081702f, -0.02736484f, -0.01644208f, -0.03428100f, 
    0.00614993f, -0.07468118f, -0.06903672f, 0.00573614f, -0.02881302f, -0.05011325f, 0.05831954f, -0.02033781f, 
    0.01237441f, 0.01950585f, -0.02305594f, 0.02041842f, -0.03546439f, -0.02098157f, -0.07057052f, -0.00506136f, 
    0.02854583f, 0.00501029f, -0.07256573f, 0.00736301f, 0.05166126f, -0.07497942f, -0.01010693f, -0.04352432f, 
    0.00758562f, 0.00645923f, -0.06623707f, 0.04842165f, 0.01652396f, 0.00090822f, 0.04752099f, 0.02914246f, 
    0.00306544f, -0.04941990f, 0.04899320f, -0.08190530f, 0.00108857f, -0.03818483f, 0.00996532f, 0.01893576f, 
    -0.07891616f, 0.00429692f, 0.00445169f, 0.01076542f, -0.05264637f, -0.05925225f, 0.05256288f, -0.06709988f, 
    0.04514421f, -0.05062247f, 0.00568896f, 0.00898860f, 0.02282832f, -0.00112710f, -0.05257520f, -0.04745741f, 
    -0.01306270f, -0.06293362f, 0.04827588f, -0.01294566f, 0.05184961f, -0.00058024f, 0.04431491f, 0.07300718f, 
    -0.02301976f, 0.02716158f, -0.05859597f, -0.02985806f, 0.02842633f, -0.04868306f, -0.06315098f, 0.03954092f, 
    -0.06105754f, -0.07098553f, -0.05804851f, 0.01847755f, 0.00144990f, 0.01738820f, -0.06427100f, 0.00926440f, 
    0.00947224f, 0.02137376f, -0.03824538f, -0.02458704f, 0.02048645f, 0.02024593f, -0.01326825f, -0.06142071f, 
    -0.01191955f, 0.02989474f, 0.00192364f, 0.01770066f, 0.01224055f, 0.05056757f, 0.02789652f, -0.01155707f, 
    0.01314375f, 0.02357660f, -0.00250168f, -0.04796482f, 0.01743513f, 0.05930078f, -0.07842762f, 0.03484088f, 
    0.00726688f, 0.18865557f, -0.11057446f, -0.15264446f, 0.04494853f, -0.09495086f, -0.19739038f, 0.02901003f, 
    0.02235349f, 0.18877235f, 0.12911496f, 0.02115902f, 0.15209191f, -0.00815595f, 0.02250681f, 0.06568547f, 
    0.37002584f, 0.29420218f, -0.05997088f, 0.02431069f, 0.08199643f, 0.00309963f, 0.16048899f, -0.09587761f, 
    -0.05102183f, 0.03422529f, 0.09752741f, -0.06323390f, 0.15674828f, -0.00306919f, -0.06579055f, 0.11390319f, 
    0.09594426f, 0.02185996f, -0.06033461f, -0.07775822f, -0.18555182f, -0.01278917f, -0.15190592f, -0.05635799f, 
    0.16634388f, 0.24351734f, 0.29163185f, 0.10546853f, 0.21658057f, 0.16651733f, 0.08163961f, 0.06209081f, 
    0.09671304f, -0.11433129f, -0.03781329f, 0.01107216f, -0.24628577f, -0.14462546f, -0.28963679f, -0.11766841f, 
    -0.02167759f, -0.13793272f, 0.04566240f, -0.00590859f, -0.03305676f, -0.07453901f, -0.00724512f, 0.00584205f, 
    -0.22235754f, -0.27645579f, -0.03167958f, -0.08594692f, 0.05206313f, 0.12550022f, 0.00064832f, -0.00552738f, 
    0.02157986f, 0.07325165f, 0.07187498f, -0.02132458f, 0.05785948f, 0.18541454f, 0.08183078f, -0.08809290f, 
    0.20009547f, -0.02380428f, 0.02667044f, -0.01267253f, 0.03237528f, -0.09799129f, -0.01815596f, 0.03952802f, 
    -0.20906018f, -0.37709749f, -0.12493028f, -0.06552009f, 0.04838147f, -0.16572271f, -0.02993959f, 0.10113996f, 
    -0.12228789f, -0.00266436f, 0.05134090f, 0.00743891f, -0.40251878f, -0.41339740f, -0.13617899f, -0.35616952f, 
    -0.07204372f, -0.05509404f, -0.03204720f, -0.07419783f, -0.05924372f, -0.07452648f, 0.05783246f, 0.02582918f, 
    0.17989083f, 0.31449017f, 0.39673758f, 0.21970025f, 0.00068139f, 0.10212974f, -0.01606699f, 0.09627003f, 
    0.06638937f, 0.00586821f, 0.04633776f, -0.00116720f, 0.25209075f, 0.06984235f, 0.32705051f, 0.08900777f, 
    -0.07144815f, 0.05720640f, 0.00111651f, 0.07589617f, 0.08538783f, 0.01667098f, -0.06602574f, 0.06523008f, 
    0.15729275f, 0.22053996f, 0.33315903f, 0.33960447f, 0.02565875f, -0.05006029f, -0.02616050f, 0.03975112f, 
    -0.08656767f, -0.07388623f, 0.08779702f, -0.04884004f, -0.09833112f, -0.12895484f, -0.17236660f, -0.22419453f, 
    -0.04193540f, -0.02988179f, -0.01892122f, -0.01739916f, -0.04283791f, -0.02792430f, -0.06178384f, 0.15702866f, 
    -0.07381918f, -0.12350143f, -0.00678045f, -0.01617826f, -0.04783298f, -0.02989450f, -0.07759697f, -0.14515558f, 
    0.07096774f, -0.16496205f, 0.05361396f, -0.23300621f, -0.48621055f, 0.21101366f, 0.04254518f, -0.24380767f, 
    -0.04538899f, 0.05726273f, 0.05005224f, 0.10496021f, 0.01730299f, 0.15589365f, -0.04791114f, 0.04215392f, 
    -0.07021669f, 0.06272843f, 0.05500540f, 0.02341981f, -0.09524707f, 0.01889954f, 0.09920715f, 0.03332207f, 
    0.00952178f, 0.05200292f, 0.18139173f, 0.08813422f, -0.01964792f, -0.07801911f, -0.04732616f, -0.03946077f, 
    0.06040563f, 0.05881932f, 0.05480399f, -0.02270125f, -0.11144955f, -0.07996739f, -0.06274372f, -0.05400949f, 
    -0.17180982f, 0.45710787f, 0.12439521f, -0.04254881f, -0.05547757f, 0.01998037f, 0.18320613f, -0.01576622f, 
    -0.15740082f, 0.21160583f, -0.00450298f, 0.18018195f, -0.14061293f, 0.12078006f, 0.12232722f, -0.11299624f, 
    -0.01007805f, -0.02430678f, 0.02061232f, 0.07471871f, 0.14672928f, 0.12745368f, 0.14838718f, 0.01781911f, 
    0.16699797f, 0.06741087f, 0.04488736f, -0.01678809f, 0.03396020f, 0.07591444f, -0.03022139f, -0.04480239f, 
    -0.09994259f, -0.02839917f, -0.02809824f, 0.09661576f, 0.00932895f, 0.04410414f, 0.01375788f, -0.08931619f, 
    0.01027384f, -0.06837543f, 0.10842677f, 0.02182445f, 0.04307388f, 0.05797982f, 0.10273603f, -0.01898982f, 
    0.10128651f, 0.03233958f, -0.05392300f, 0.01928368f, 0.02165411f, 0.09431139f, -0.01109539f, 0.02687051f, 
    -0.03052671f, 0.03296880f, -0.09407859f, -0.05184670f, -0.26374525f, -0.37976050f, 0.02278743f, -0.09014912f, 
    0.01504437f, -0.10327292f, 0.13854381f, -0.07280320f, -0.00732888f, -0.07050700f, 0.11540728f, 0.08893438f, 
    -0.05534366f, 0.03819070f, -0.23557110f, 0.17346184f, 0.12345968f, -0.05187560f, 0.28034198f, -0.06339129f, 
    0.09091193f, 0.11745813f, 0.06027800f, -0.01652432f, 0.17508832f, -0.00500288f, -0.07241190f, 0.02272956f, 
    0.00188797f, -0.01977902f, -0.00780813f, 0.07281477f, 0.00712499f, 0.07302388f, 0.10107467f, -0.00911173f, 
    0.04932323f, 0.10350422f, 0.14857382f, 0.00278664f, -0.02107758f, -0.07138049f, -0.19497497f, -0.09332088f, 
    0.08355699f, -0.12973373f, -0.02238016f, -0.03291199f, 0.12574492f, -0.29687083f, 0.21199138f, 0.09644053f, 
    -0.02564802f, 0.04704988f, -0.00019114f, -0.12273955f, -0.12334568f, -0.01750329f, -0.06073968f, -0.00843767f, 
    -0.05892990f, 0.10605790f, 0.12493555f, 0.09055350f, -0.17272903f, -0.07371484f, 0.07366242f, -0.13016085f, 
    -0.05981129f, 0.00757370f, 0.03477027f, -0.10302990f, -0.02256687f, -0.12822296f, -0.05102338f, 0.09563848f, 
    -0.00676405f, -0.01415594f, 0.08268968f, 0.16890760f, -0.19505778f, -0.14418828f, -0.20640615f, -0.11204559f, 
    -0.09626297f, 0.04109737f, 0.08893752f, 0.25368190f, -0.06784311f, -0.00233158f, -0.06847947f, 0.07316966f, 
    -0.23568963f, -0.00855897f, 0.29783973f, -0.26227343f, -0.29587957f, 0.01550938f, 0.03013289f, 0.06158357f, 
    -0.08821046f, 0.14869547f, -0.11514550f, -0.00350131f, -0.05544068f, -0.00297564f, 0.00490286f, -0.13084096f, 
    -0.12832560f, -0.08206768f, 0.02029653f, -0.04493535f, 0.00562556f, 0.04233080f, -0.02226163f, -0.10227657f, 
    -0.06383605f, -0.27447975f, 0.04793489f, 0.10025165f, 0.00880386f, -0.23502880f, 0.01240939f, 0.00638331f, 
    -0.16942453f, 0.01225093f, -0.06672926f, 0.00086310f, 0.18389349f, -0.03069211f, 0.05218044f, -0.09519185f, 
    -0.52190238f, 0.14537169f, -0.18924443f, 0.02542867f, 0.04258905f, -0.22909468f, 0.06625418f, -0.08326325f, 
    0.07492038f, 0.00896604f, -0.07020721f, 0.05799425f, -0.03823176f, -0.19774577f, -0.13685702f, 0.05093212f, 
    0.01916251f, -0.01858351f, -0.02421504f, 0.13436110f, -0.07821854f, -0.11891042f, -0.13464680f, -0.07036947f, 
    -0.10061978f, -0.03852965f, 0.20445658f, 0.14959490f, -0.06267007f, -0.04288160f, -0.02822523f, 0.08374529f, 
    0.05061801f, -0.02526736f, 0.08166428f, -0.14937589f, 0.32109612f, 0.25839669f, 0.12230974f, -0.13071810f, 
    0.10776829f, -0.29297376f, -0.02441669f, 0.13182431f, -0.00027917f, -0.05023976f, -0.05104639f, -0.03402524f, 
    -0.17416500f, 0.08630197f, 0.04299148f, 0.09919856f, 0.00582119f, 0.05510585f, -0.01227360f, 0.00305540f, 
    -0.03479236f, 0.13967490f, -0.09807377f, 0.02681337f, 0.13903883f, -0.03214269f, 0.12882273f, -0.04316562f, 
    0.32217911f, -0.34569630f, 0.27276090f, -0.16589552f, -0.08707459f, 0.02285769f, -0.08221304f, 0.05965245f, 
    0.13969378f, 0.49905309f, -0.41670829f, 0.15591998f, -0.07906499f, -0.14863591f, 0.06096215f, -0.03594614f, 
    -0.01990388f, -0.00473471f, -0.03137772f, -0.12734868f, 0.09100479f, 0.07667517f, 0.16779761f, 0.08240622f, 
    0.02461345f, -0.13931596f, -0.14169653f, 0.03290244f, -0.01903627f, 0.05651572f, -0.08082984f, -0.04580812f, 
    -0.04456951f, 0.00300167f, 0.20570557f, 0.12692750f, 0.00388479f, 0.08003253f, 0.10615151f, 0.02855952f, 
    0.09505759f, 0.05846903f, -0.01880204f, -0.10204822f, -0.16225319f, 0.17968342f, 0.23835552f, 0.06724638f, 
    -0.02156366f, -0.00806212f, 0.20093687f, 0.04765138f, -0.04120931f, -0.00643544f, 0.02282277f, 0.02335270f, 
    -0.12430040f, 0.24202776f, 0.17055124f, 0.20529673f, 0.11773832f, -0.05971159f, 0.07046984f, 0.04757354f, 
    0.02377810f, -0.01164618f, -0.08746758f, 0.20445859f, -0.02655528f, 0.01089026f, -0.03361083f, 0.05987560f, 
    -0.08145345f, -0.04810677f, -0.16515876f, -0.03056928f, -0.11003907f, 0.14445798f, -0.06524290f, 0.12306397f, 
    0.27452320f, 0.09948180f, -0.10605328f, 0.30121437f, 0.11504468f, 0.08250981f, 0.16543329f, 0.17790611f, 
    0.12806779f, 0.03500371f, 0.00749334f, 0.20507263f, -0.22151904f, -0.35470682f, -0.23475742f, 0.11129191f, 
    -0.02886705f, -0.12087267f, 0.05523029f, 0.13265634f, -0.01376284f, 0.17749238f, 0.05501404f, -0.04017418f, 
    0.01099101f, 0.36120281f, -0.29802397f, -0.02361896f, -0.10160883f, -0.03760352f, 0.15363966f, 0.02893587f, 
    -0.02429570f, 0.15284498f, 0.01357002f, -0.12753448f, -0.25839120f, 0.06402740f, -0.19409227f, 0.01782049f, 
    -0.11310810f, -0.06911006f, 0.03533170f, 0.05469755f, -0.14260820f, 0.03716752f, 0.03168800f, 0.01349423f, 
    0.17151964f, 0.04206424f, -0.10753278f, -0.24817850f, 0.07272733f, -0.12263561f, 0.12599578f, -0.04407198f, 
    -0.12127483f, 0.11769152f, 0.11395344f, 0.02990892f, 0.01037183f, 0.37912410f, -0.12233285f, -0.01266949f, 
    0.10014462f, -0.01630157f, -0.02072729f, -0.14470269f, 0.07352642f, -0.00442945f, 0.07496884f, -0.04057461f, 
    0.20564431f, 0.18009284f, 0.05903940f, -0.05219214f, 0.25746387f, 0.00170829f, -0.04691254f, 0.09827736f, 
    -0.11049142f, -0.06498905f, -0.21775122f, 0.03685996f, 0.04405668f, 0.10383101f, 0.03542370f, 0.00064324f, 
    -0.16034041f, 0.01930885f, -0.05436704f, -0.02758769f, -0.15354693f, 0.02788133f, 0.01771421f, -0.02094457f, 
    0.06297039f, 0.04743319f, -0.02970047f, -0.03269302f, 0.07237275f, 0.07808634f, 0.11795908f, -0.10731897f, 
    -0.14854385f, 0.16318223f, 0.00605524f, 0.03930698f, 0.03143622f, -0.33774003f, 0.42659280f, -0.25918722f, 
    0.05160127f, -0.09395463f, 0.01745109f, 0.08890277f, 0.16490342f, 0.00448153f, -0.13408004f, 0.00045574f, 
    -0.05079842f, -0.02772985f, 0.08238719f, 0.28441623f, -0.02093601f, 0.09804950f, 0.40076733f, 0.17473660f, 
    -0.21078151f, -0.03464244f, 0.09938768f, -0.01796374f, 0.30870211f, 0.30898404f, 0.10063286f, 0.06418531f, 
    -0.01185571f, -0.02841851f, -0.16712162f, 0.02231650f, -0.19707502f, -0.01997584f, -0.16967693f, -0.12374408f, 
    0.15324748f, 0.10371313f, 0.24117433f, 0.04962892f, 0.09920248f, 0.08940441f, 0.06058636f, 0.03051637f, 
    -0.03139095f, -0.08774786f, -0.08035066f, -0.06332028f, -0.01251884f, 0.21685205f, -0.22928989f, 0.00358585f, 
    -0.01588438f, 0.04678385f, 0.05475939f, -0.08191252f, 0.11579560f, -0.02389766f, -0.05749860f, 0.01075431f, 
    0.12236883f, -0.00349953f, 0.05504982f, -0.25762004f, -0.16029088f, 0.13327557f, -0.09307038f, -0.01465423f, 
    -0.09421912f, -0.13572098f, 0.02766407f, -0.10324214f, -0.01456268f, 0.06429183f, 0.13196963f, 0.23998459f, 
    0.01763358f, -0.19836091f, -0.03456957f, -0.15742204f, 0.04631958f, 0.02605043f, -0.02380626f, 0.05540486f, 
    -0.08391513f, 0.23322973f, 0.12664698f, 0.41245893f, -0.01540022f, 0.18317285f, 0.03467590f, 0.00134851f, 
    0.04819306f, 0.08991949f, 0.14903548f, 0.00451605f, -0.41111773f, 0.39909428f, 0.17747125f, -0.21636893f, 
    -0.08067984f, 0.08827110f, -0.05333219f, -0.07981821f, 0.03241917f, -0.00821310f, 0.02747249f, 0.02790183f, 
    0.17486805f, -0.28701925f, 0.01935620f, 0.02310867f, 0.04243816f, -0.18622644f, -0.02528237f, -0.03624448f, 
    0.11307406f, 0.06609501f, 0.10402311f, 0.10916351f, 0.29470730f, 0.02452931f, 0.18252926f, 0.04433259f, 
    0.11864992f, 0.06738851f, -0.10434958f, 0.00909519f, -0.08998658f, -0.04624353f, -0.02045534f, 0.04895243f, 
    0.04855633f, 0.39055082f, -0.13751830f, 0.06116779f, -0.15082537f, -0.14719757f, 0.07969514f, -0.01903698f, 
    0.08270626f, -0.11095750f, -0.07654497f, 0.10476725f, 0.05621883f, -0.37650332f, -0.04251625f, 0.03435500f, 
    -0.03019551f, -0.08663633f, -0.22748670f, -0.08410554f, -0.07068220f, 0.01570676f, 0.06521133f, 0.05904312f, 
    0.05585428f, -0.10557808f, 0.04340278f, 0.04112651f, -0.01998330f, -0.20907056f, 0.06629510f, 0.19273528f, 
    0.12667851f, 0.22162725f, 0.17677894f, -0.05155057f, 0.28860545f, 0.22688806f, -0.01425311f, 0.01946506f, 
    0.02470039f, -0.10777509f, 0.08135126f, 0.12783279f, -0.00746670f, -0.04637292f, -0.04515458f, -0.04848877f, 
    0.07593212f, 0.06043533f, 0.00719793f, 0.03362852f, 0.16834037f, 0.07022899f, 0.00510250f, 0.00371592f, 
    0.15911001f, 0.03354799f, -0.18798397f, 0.02846912f, -0.14792246f, 0.12357218f, -0.18182495f, -0.22211641f, 
    0.15240383f, -0.24404193f, 0.20457208f, -0.00975497f, 0.05726765f, -0.05045321f, 0.22419675f, 0.05369446f, 
    -0.04416791f, 0.34758067f, -0.07290226f, -0.12881897f, -0.03573452f, 0.02969957f, -0.10341163f, 0.00286164f, 
    0.12159465f, 0.02629706f, -0.03535612f, 0.06447174f, 0.20447493f, -0.08893958f, -0.12889425f, 0.01252814f, 
    0.01054037f, 0.06178145f, 0.12970321f, 0.04703276f, 0.11054404f, -0.08339728f, -0.00371103f, 0.02098902f, 
    -0.03296759f, 0.01070924f, 0.12249022f, 0.05957980f, -0.08044759f, 0.01073014f, -0.12022700f, -0.03734799f, 
    0.03547609f, -0.05770535f, 0.09952437f, -0.08962816f, 0.08801875f, -0.26424620f, 0.36206582f, 0.09366535f, 
    -0.08133001f, -0.02298085f, -0.04291024f, 0.02999392f, -0.09370466f, -0.02011307f, 0.03625559f, -0.10872646f, 
    -0.12473962f, 0.26697937f, 0.04788531f, 0.28099686f, 0.00517227f, 0.02151320f, 0.05950895f, 0.12018325f, 
    -0.00660332f, 0.05503071f, -0.01901998f, 0.05968456f, 0.05943898f, -0.16977151f, -0.09296348f, 0.06762953f, 
    -0.06920161f, 0.07441901f, 0.00997141f, 0.02029021f, -0.24949539f, 0.11021431f, 0.00891861f, -0.02003384f, 
    -0.00632415f, -0.09381600f, -0.15619147f, -0.10427731f, -0.06507455f, -0.00577112f, 0.00375381f, 0.11904673f, 
    -0.10615730f, -0.03786844f, 0.01631368f, -0.23063265f, 0.37669009f, -0.19535966f, -0.09333019f, 0.16551776f, 
    0.30771425f, 0.10808231f, 0.04678360f, -0.13943407f, 0.12417328f, 0.07128645f, -0.10501601f, -0.02649261f, 
    -0.10327634f, -0.04548667f, -0.18422408f, -0.00372860f, 0.09411331f, -0.13812181f, -0.03638337f, -0.27367559f, 
    -0.11062007f, -0.09309703f, -0.24673773f, -0.09541928f, 0.24356893f, 0.05110219f, 0.10456830f, 0.07319269f, 
    -0.03282082f, 0.11190505f, 0.04253414f, 0.05745861f, 0.14375235f, 0.04994655f, 0.01544324f, 0.00173959f, 
    0.08234623f, 0.11352197f, -0.15587923f, -0.01974725f, 0.05130721f, -0.12667572f, 0.04080144f, -0.04768894f, 
    -0.08018740f, 0.01754483f, -0.11473981f, -0.26410091f, 0.07113878f, -0.24964528f, -0.36774647f, -0.00707516f, 
    -0.06987672f, -0.06739378f, -0.12588961f, -0.19121248f, -0.08018045f, -0.12052526f, -0.13645299f, -0.18290555f, 
    -0.14070334f, 0.04464379f, -0.01806339f, 0.05340745f, -0.02032396f, 0.01835693f, 0.11456677f, 0.18083739f, 
    0.07049493f, 0.14598586f, -0.09628511f, -0.16940923f, 0.16921532f, 0.53455037f, 0.07090843f, 0.25433794f, 
    -0.16555753f, -0.11159003f, 0.02371757f, -0.02597409f, 0.03273949f, 0.05272759f, 0.05416708f, -0.03020049f, 
    0.01541927f, 0.18533912f, 0.15412539f, -0.09310789f, 0.05661361f, 0.03825441f, -0.04930676f, 0.01281509f, 
    0.06404895f, 0.12474316f, 0.13900842f, 0.11932686f, 0.21148711f, 0.13751401f, 0.06867427f, -0.04528975f, 
    0.08278165f, -0.18096212f, 0.26284358f, -0.05720647f, -0.03037390f, -0.08356250f, 0.05904173f, -0.02634665f, 
    0.17271781f, 0.19189918f, 0.23479325f, 0.03438281f, -0.15059854f, 0.17951830f, -0.10399866f, -0.07489551f, 
    -0.03678398f, 0.03085744f, -0.12364741f, 0.03852175f, 0.04989048f, 0.20451035f, 0.15725192f, 0.01888978f, 
    -0.03504051f, -0.12006339f, 0.03604674f, 0.01989600f, 0.02817750f, 0.04299713f, -0.10852201f, 0.04433183f, 
    -0.05224730f, -0.08898509f, 0.12982671f, 0.25892299f, -0.05710040f, 0.07145946f, -0.01550460f, 0.15935940f, 
    0.06131091f, 0.01894605f, 0.04067332f, -0.01075487f, -0.14917979f, 0.13011841f, 0.07603481f, 0.02180319f, 
    0.01449475f, 0.02602038f, 0.03002198f, 0.05876447f, -0.01837677f, -0.00054873f, -0.03370439f, 0.01987745f, 
    -0.06869070f, -0.02296623f, 0.08569145f, 0.31422317f, 0.06302522f, 0.04627317f, 0.08568985f, 0.16014053f, 
    -0.00075690f, 0.01973403f, -0.01551379f, 0.16897912f, 0.11084440f, 0.14423424f, 0.00326787f, 0.03248170f, 
    -0.06845375f, -0.01294737f, -0.14677143f, -0.07271466f, 0.12699400f, -0.03186310f, 0.08810885f, 0.01521768f, 
    -0.03829048f, 0.09098969f, 0.12663729f, 0.05670052f, -0.09782198f, 0.19190535f, 0.03657292f, 0.01955681f, 
    0.03440021f, -0.06105381f, -0.08206911f, -0.20951584f, -0.02780680f, 0.08010018f, -0.29417968f, -0.22331299f, 
    0.17074442f, -0.03206385f, 0.08360974f, -0.04045989f, -0.01391857f, -0.01531936f, -0.01044105f, 0.27720594f, 
    -0.05226133f, -0.02350768f, 0.03670821f, 0.14503236f, 0.04483750f, -0.01182745f, 0.32226893f, 0.05818785f, 
    0.01504969f, 0.06321410f, 0.20311698f, -0.00357747f, -0.27008736f, -0.01270748f, 0.09442879f, -0.03990272f, 
    -0.11463425f, 0.04390604f, -0.09941169f, -0.15230851f, -0.02119032f, -0.07740404f, 0.06845956f, 0.13412359f, 
    -0.49352419f, 0.04312898f, 0.14832535f, 0.05717459f, -0.13116696f, 0.13006502f, 0.12232476f, 0.09881198f, 
    0.07489485f, -0.12387205f, -0.06443878f, 0.05471079f, -0.08759307f, 0.00323009f, 0.20847631f, 0.04201940f, 
    -0.01447202f, 0.01127153f, -0.05233832f, 0.00471055f, 0.05686729f, -0.14380869f, 0.08829010f, -0.05392359f, 
    -0.01650567f, -0.11607204f, -0.09584738f, -0.22496243f, 0.08734263f, -0.12620072f, -0.01276378f, 0.03806578f, 
    -0.14815491f, -0.05106273f, -0.07969916f, -0.02196791f, -0.04715079f, -0.17037435f, 0.03991906f, -0.07934596f, 
    -0.01427344f, 0.17808218f, -0.03071701f, 0.04872734f, -0.13448086f, 0.03888791f, -0.10412076f, -0.02487667f, 
    -0.04944339f, 0.03151196f, -0.07877576f, -0.06126049f, 0.09487271f, -0.01269411f, -0.09065276f, -0.01995698f, 
    -0.01857151f, 0.05540568f, 0.03613809f, 0.06825460f, -0.38075045f, -0.09252422f, 0.09234390f, -0.07945289f, 
    -0.10719067f, -0.16191964f, -0.01776186f, 0.05814822f, 0.04432141f, 0.02469804f, -0.05582614f, 0.07915626f, 
    -0.10693660f, -0.21217139f, -0.06763021f, -0.19540904f, -0.13653578f, 0.08577965f, 0.20380270f, 0.00061831f, 
    -0.06359815f, 0.04287631f, -0.02578182f, 0.17135425f, -0.01106834f, 0.05017581f, -0.22975622f, 0.01170587f, 
    0.06898252f, 0.01721322f, 0.04580699f, -0.00244941f, -0.14310376f, -0.11516213f, -0.08278143f, -0.03068208f, 
    -0.06523339f, -0.14040545f, -0.10503182f, -0.23457944f, -0.05817113f, -0.09189729f, 0.00945544f, -0.10111769f, 
    -0.01416696f, -0.05169062f, -0.06205213f, 0.04000880f, 0.10706050f, -0.07205582f, -0.10018504f, -0.18866526f, 
    0.08918602f, -0.00702970f, -0.03218646f, -0.21128282f, 0.01017131f, -0.02007954f, -0.02006419f, -0.09750643f, 
    0.02603187f, -0.07206181f, -0.19233601f, -0.32983935f, -0.07630030f, -0.03213716f, -0.14236148f, -0.02070399f, 
    0.17738515f, -0.03302042f, 0.07920719f, -0.07957312f, -0.03726719f, -0.18608424f, -0.21667601f, 0.08813021f, 
    0.01627140f, -0.22884755f, 0.04416192f, -0.03261866f, 0.04196877f, 0.17330320f, 0.10429740f, -0.02585307f, 
    0.10541679f, 0.28380227f, 0.22355105f, 0.29083249f, 0.15890123f, 0.13824338f, 0.09093878f, 0.07332219f, 
    -0.00261396f, 0.02206694f, 0.22967498f, 0.07540630f, -0.04459356f, -0.01936018f, 0.13400765f, 0.50097042f, 
    0.06342579f, -0.08354995f, -0.00331377f, 0.01496115f, 0.20643058f, 0.05372686f, 0.08866536f, -0.00403880f, 
    -0.03951177f, 0.20753950f, 0.04640680f, -0.01959689f, 0.07352784f, -0.08296710f, -0.03422511f, -0.04333649f, 
    -0.03199442f, -0.18430109f, 0.16252820f, -0.01441532f, -0.00103071f, -0.14323848f, -0.17174613f, 0.08842224f, 
    -0.09354819f, -0.02017670f, 0.01677683f, -0.01778517f, 0.22761481f, 0.13333997f, 0.12216412f, 0.17137107f, 
    -0.03735171f, 0.03253530f, -0.22881094f, -0.28362429f, 0.09792145f, -0.09987120f, 0.04444293f, -0.08408108f, 
    -0.02064711f, -0.10297941f, -0.02123183f, -0.03707022f, -0.10745897f, 0.05012368f, -0.02815825f, -0.00908111f, 
    -0.08417937f, -0.09978360f, -0.17803179f, 0.00964711f, -0.04712461f, -0.13267973f, -0.26572511f, -0.03061253f, 
    0.16581351f, 0.13587622f, 0.22880292f, 0.15616424f, 0.06309496f, 0.04447687f, 0.00045904f, 0.14168499f, 
    -0.20226362f, -0.11733919f, -0.10190573f, -0.18641776f, 0.11977266f, -0.25461197f, -0.22675638f, -0.13588606f, 
    -0.07667039f, -0.19540609f, -0.07094234f, -0.05805868f, -0.04699220f, -0.03536884f, 0.08455966f, 0.05845146f, 
    -0.09484120f, -0.10493829f, -0.11610441f, -0.10363109f, 0.01479893f, -0.01406288f, 0.02947251f, 0.08892340f, 
    0.11750837f, 0.25587526f, 0.07692314f, 0.09445781f, -0.31646714f, 0.14626795f, 0.24120629f, -0.26290074f, 
    0.15089278f, -0.05988092f, 0.04856487f, 0.08574137f, -0.00945220f, 0.16705182f, -0.25026369f, 0.05501611f, 
    0.27280009f, -0.06595215f, -0.32549208f, -0.00243607f, -0.07645857f, 0.04622327f, 0.00388471f, 0.16746546f, 
    0.08247473f, 0.09841574f, 0.16630122f, -0.20125380f, -0.08596494f, -0.19226007f, -0.17183945f, -0.23656020f, 
    -0.03985302f, -0.18153468f, -0.17254478f, -0.12208859f, -0.01846992f, 0.04952448f, 0.02394007f, -0.10597345f, 
    0.18116702f, 0.33972979f, 0.37597185f, 0.14418148f, 0.07493183f, 0.03279489f, 0.09834620f, 0.07335629f, 
    -0.08713335f, 0.05293864f, -0.04938982f, -0.09390015f, 0.25984749f, 0.12404209f, 0.23107061f, -0.06539047f, 
    -0.10858835f, 0.01848366f, 0.16219342f, 0.01766515f, 0.19427635f, -0.10435522f, 0.02576291f, 0.05030398f, 
    0.00111056f, 0.24610594f, 0.29587150f, 0.22031306f, 0.05704673f, 0.15785292f, 0.14501972f, 0.13866647f, 
    -0.10724085f, -0.03339655f, -0.00993973f, 0.01032356f, -0.09274153f, -0.18816793f, -0.16970490f, 0.06922863f, 
    -0.07802796f, 0.04786881f, -0.15466754f, -0.12823021f, 0.08975732f, -0.06106957f, 0.07143757f, 0.23371854f, 
    0.03362410f, 0.17417380f, 0.16577312f, 0.21542658f, 0.04223144f, -0.07129972f, 0.03011787f, 0.01146807f, 
    0.26988760f, -0.07700270f, 0.20075399f, 0.11499739f, -0.78878450f, -0.17700994f, 0.33877781f, 0.17868631f, 
    -0.11981045f, -0.08284820f, -0.02477795f, 0.09482455f, 0.13166253f, 0.09536227f, -0.04703576f, -0.01768052f, 
    0.20641920f, 0.04043415f, -0.05490233f, 0.16229759f, 0.02788739f, 0.12165856f, -0.20438091f, 0.04264142f, 
    0.21844813f, 0.10778460f, 0.03563748f, 0.17437023f, 0.04787870f, 0.29916829f, 0.18058965f, 0.19682010f, 
    0.11602469f, -0.01718224f, -0.08495898f, -0.01496727f, 0.00185966f, 0.10747622f, -0.07706057f, -0.05910240f, 
    0.29461026f, 0.24610648f, 0.29103372f, 0.27470154f, -0.12165101f, 0.00571297f, -0.17353907f, -0.17296749f, 
    0.02908742f, -0.14284115f, 0.16523270f, 0.07144661f, -0.04830176f, 0.05312980f, 0.07976216f, 0.28795269f, 
    -0.16525182f, -0.07319991f, -0.07954013f, -0.03304298f, 0.08042136f, 0.12943551f, 0.24917413f, 0.15640521f, 
    -0.02955032f, 0.07983329f, -0.01562118f, 0.00502720f, -0.14075065f, -0.17355095f, -0.12175998f, 0.01272298f, 
    0.00878761f, 0.15091597f, 0.21950349f, 0.12614399f, 0.12881622f, 0.01360944f, 0.03633907f, 0.08538777f, 
    0.12273923f, 0.14144418f, 0.09655281f, -0.08771443f, 0.00216665f, -0.05735127f, -0.05257173f, 0.13470681f, 
    0.18306959f, -0.11416326f, 0.01750553f, 0.05680709f, 0.13250433f, -0.02986384f, 0.01556534f, 0.07686443f, 
    0.08129807f, -0.16577391f, -0.06646231f, -0.15471400f, -0.02203917f, 0.31588176f, 0.02862119f, -0.02625834f, 
    -0.05550120f, -0.10921270f, -0.12131199f, -0.17082049f, 0.09450548f, -0.10406581f, 0.21634373f, 0.04488089f, 
    -0.00873398f, -0.22179571f, -0.06756181f, 0.09705497f, 0.22752301f, -0.24354276f, -0.15628929f, -0.16952156f, 
    -0.10137546f, -0.16640505f, 0.15537676f, 0.11000019f, 0.01944888f, -0.01795512f, -0.05632166f, 0.14591424f, 
    0.01504679f, 0.05719221f, 0.03108980f, 0.02228500f, 0.07061085f, 0.03335590f, -0.02695611f, 0.10776757f, 
    0.11559056f, 0.23110235f, -0.03026178f, 0.02351803f, -0.17068915f, -0.14043075f, 0.03827089f, -0.09832034f, 
    -0.08923374f, -0.04836264f, -0.11743422f, -0.06925836f, -0.10581253f, -0.22759850f, -0.17899086f, 0.03500569f, 
    -0.02592207f, -0.02903315f, -0.10177288f, -0.01485467f, -0.02310842f, 0.02190163f, 0.08366153f, -0.00279808f, 
    0.03172407f, -0.02778371f, -0.04240405f, -0.18500359f, -0.09728520f, -0.01269636f, -0.04825553f, -0.00572659f, 
    0.04785619f, 0.07408198f, -0.06944921f, -0.06126249f, -0.12570345f, 0.07778168f, 0.16122401f, -0.03804601f, 
    0.04897267f, -0.02122943f, 0.10574762f, 0.08644987f, 0.12653463f, 0.04020226f, -0.04960476f, -0.07534520f, 
    0.02685628f, -0.07448893f, -0.23024535f, -0.16058527f, 0.07551165f, 0.03916317f, -0.03320625f, -0.10511293f, 
    0.11402308f, 0.18371610f, -0.29547456f, -0.00735877f, -0.42218918f, 0.11192084f, -0.13118540f, 0.23470452f, 
    0.08049515f, 0.01907057f, -0.01212860f, 0.09586468f, 0.05199348f, -0.05288663f, -0.03431257f, 0.23451392f, 
    0.01790874f, 0.02993794f, 0.10096666f, 0.22007048f, 0.05863256f, -0.01860509f, 0.11236978f, 0.01211662f, 
    0.12703113f, 0.04875122f, 0.20647834f, 0.13566269f, 0.10982966f, 0.03926622f, 0.19879757f, -0.00448677f, 
    0.00734412f, -0.06923411f, -0.12487323f, 0.06757659f, 0.03445138f, -0.00417807f, -0.08696262f, -0.14206533f, 
    -0.18853904f, 0.20470253f, 0.20393030f, 0.11119625f, -0.07650647f, -0.08731177f, 0.01732600f, -0.09104077f, 
    0.19547455f, -0.07112667f, 0.01787104f, 0.10458854f, 0.08781020f, -0.02428103f, 0.34377882f, 0.04890855f, 
    -0.01313078f, -0.08358715f, -0.05075273f, 0.10723209f, 0.02547978f, 0.05397110f, 0.07285189f, 0.13510539f, 
    0.02373009f, 0.07496129f, 0.05916025f, -0.10271309f, -0.00769475f, -0.03892938f, 0.00751985f, -0.10521559f, 
    0.00926195f, -0.01564795f, 0.01609976f, -0.06528988f, 0.23906265f, -0.29675394f, -0.06121960f, -0.00389217f, 
    0.12237655f, 0.20896542f, -0.04768686f, 0.25091648f, 0.04011895f, -0.08020595f, -0.06374689f, 0.02311825f, 
    -0.03216560f, -0.06649102f, 0.00237259f, 0.13347113f, 0.00068084f, 0.06007964f, 0.10744988f, 0.11663559f, 
    0.02385910f, 0.09919940f, -0.12937006f, 0.06170020f, -0.42686668f, 0.08175983f, -0.00867567f, -0.24024165f, 
    -0.13946760f, -0.33392450f, 0.12826981f, 0.01356393f, 0.15727173f, 0.02587648f, -0.10159913f, 0.01012200f, 
    0.06895112f, -0.03990285f, -0.03976449f, -0.06666130f, 0.13471161f, -0.04705010f, 0.11748774f, -0.00502341f, 
    0.00273791f, 0.05527758f, -0.08149941f, 0.01923417f, -0.07343777f, -0.09979343f, -0.31331855f, 0.20210278f, 
    0.05791568f, 0.09830377f, 0.13767406f, 0.04457358f, 0.01786001f, -0.08385792f, -0.04454618f, 0.04199922f, 
    -0.05786553f, -0.02864086f, -0.01632231f, -0.06182049f, 0.02497691f, -0.07930914f, 0.09643687f, 0.01383030f, 
    -0.04902106f, -0.04165642f, 0.05673261f, 0.00106998f, 0.18141931f, -0.26219177f, 0.01966434f, -0.13933481f, 
    0.05757280f, -0.06927861f, 0.01066804f, 0.02885007f, 0.13500400f, 0.06306946f, -0.05207884f, -0.04734140f, 
    -0.02666088f, 0.05166558f, -0.02540737f, -0.20176935f, -0.13839635f, 0.06200812f, -0.04213729f, -0.16721369f, 
    0.07212428f, -0.06664206f, -0.13221993f, 0.08274259f, -0.12816826f, -0.10180176f, -0.07872009f, 0.03859426f, 
    -0.00028210f, -0.02535264f, 0.04605300f, -0.00421311f, 0.13029164f, 0.09336002f, -0.03765316f, 0.13503003f, 
    0.15112059f, 0.05322899f, 0.07067455f, 0.05271205f, 0.10912915f, 0.03369578f, -0.03713022f, 0.18120055f, 
    0.21049289f, 0.08123142f, 0.06777281f, 0.10331877f, -0.57583052f, -0.00253164f, 0.41908428f, 0.81163090f, 
    -0.05962231f, -0.06703115f, -0.04877260f, 0.17673928f, 0.02344700f, -0.00525914f, 0.10734981f, -0.03025000f, 
    -0.00559765f, -0.07921176f, 0.08562186f, 0.25493598f, -0.04747401f, -0.01332803f, -0.07732934f, -0.11282965f, 
    0.27019641f, 0.15258370f, 0.02678944f, 0.14840616f, 0.32823882f, 0.08988599f, -0.10634224f, -0.15167879f, 
    0.04649136f, -0.09764626f, -0.01281928f, -0.09289781f, 0.05536024f, -0.07211766f, -0.25064036f, -0.05568244f, 
    0.53251755f, 0.21442170f, 0.31917211f, 0.20515002f, -0.08383559f, -0.00217468f, -0.03679911f, 0.11263026f, 
    0.07416911f, -0.05344021f, 0.06435691f, 0.09392467f, 0.35954693f, -0.13043417f, 0.07041778f, 0.17740138f, 
    -0.10084081f, 0.00266349f, -0.02053507f, 0.07413317f, 0.05292517f, 0.06418637f, 0.14403643f, 0.22127169f, 
    0.00507881f, 0.01712381f, 0.08144664f, 0.10070951f, -0.02067990f, 0.02578484f, 0.15478294f, -0.06990379f, 
    0.07440343f, 0.08948580f, 0.11543557f, 0.21394908f, 0.03676746f, 0.29715192f, 0.06991960f, -0.09136474f, 
    0.11890346f, -0.08901819f, 0.05112500f, -0.00070742f, 0.02434967f, -0.12361848f, -0.05226447f, 0.02461179f, 
    -0.01076345f, -0.26725292f, 0.01687909f, -0.16627905f, -0.07928742f, -0.03143948f, -0.21880335f, -0.01665089f, 
    -0.11233311f, -0.36979035f, -0.11314601f, -0.22665374f, -0.24377772f, 0.48582610f, -0.14974087f, -0.02822239f, 
    -0.04683567f, 0.33904457f, 0.00333078f, -0.17453353f, 0.02564551f, -0.12066824f, 0.28540418f, 0.17332780f, 
    0.23407637f, 0.12564161f, 0.01500871f, -0.12531634f, 0.01416974f, -0.31449237f, -0.31387386f, -0.08003113f, 
    -0.06067163f, 0.00137812f, 0.14028171f, 0.25813648f, -0.08379744f, -0.02467324f, 0.30243361f, 0.23170453f, 
    -0.28542098f, -0.09689476f, -0.02037096f, -0.11148561f, -0.01681272f, -0.06796364f, -0.06659327f, 0.19439404f, 
    -0.00412890f, 0.10225340f, -0.05080513f, 0.10561847f, -0.03831437f, 0.06333078f, 0.11642420f, 0.13146582f, 
    -0.17493190f, -0.23404019f, -0.12451828f, -0.08491634f, 0.06768072f, -0.16630019f, 0.07386944f, -0.13863228f, 
    0.12743832f, 0.07967114f, 0.00805219f, 0.16046180f, -0.08156370f, 0.09705352f, 0.03685016f, -0.14013067f, 
    -0.07893879f, 0.25664228f, -0.06204039f, 0.23651730f, 0.08473100f, -0.00664228f, 0.05696442f, 0.01083079f, 
    -0.06792141f, 0.09502587f, -0.00485315f, 0.01035464f, 0.07426935f, 0.25603426f, 0.11748901f, -0.33443579f, 
    -0.18893158f, 0.12468032f, -0.16104425f, -0.01479931f, 0.15934835f, 0.09397378f, -0.23678963f, -0.18815850f, 
    0.06377168f, -0.19668685f, -0.02695242f, -0.10016772f, 0.04769974f, 0.06355862f, -0.13417421f, -0.10176507f, 
    0.12702078f, -0.02213288f, -0.02726763f, -0.01661161f, 0.03599263f, 0.21151525f, -0.03521110f, 0.15464529f, 
    -0.07487538f, 0.09306093f, -0.11426730f, -0.06596790f, -0.04156332f, -0.00786743f, -0.03454472f, 0.09599397f, 
    -0.06597474f, -0.03520003f, -0.03671537f, -0.00006051f, 0.04835620f, -0.04999320f, 0.03945101f, -0.06084125f, 
    -0.02827479f, 0.03518731f, 0.03708597f, -0.01968491f, -0.06802817f, -0.03101809f, -0.03828548f, -0.01461437f, 
    0.05321737f, 0.00945210f, -0.01289972f, 0.01056201f, -0.01201670f, 0.00956920f, -0.01259767f, 0.00408147f, 
    -0.07225639f, 0.04333684f, 0.02491214f, 0.01167578f, -0.07910140f, -0.02294358f, -0.07426716f, 0.04339059f, 
    0.01320127f, 0.02807014f, -0.06827736f, -0.02867835f, 0.03138019f, -0.00390497f, 0.02258832f, -0.06700563f, 
    -0.07920785f, -0.01197173f, 0.01881109f, -0.02592021f, -0.06577732f, 0.01280234f, -0.01845625f, -0.00261436f, 
    0.03982705f, -0.03791752f, 0.02459154f, 0.02767312f, -0.01999545f, 0.05271143f, -0.05344162f, -0.04426629f, 
    0.03707898f, -0.02205275f, -0.04196334f, -0.05147359f, 0.01739593f, -0.03608225f, -0.03262924f, -0.02005545f, 
    0.04967880f, -0.05491503f, -0.01528592f, -0.02050403f, 0.05107499f, -0.09008820f, -0.07382628f, -0.07686120f, 
    0.00603998f, -0.01289561f, 0.02814138f, -0.00840083f, -0.08540738f, -0.06912789f, 0.02075989f, -0.03882840f, 
    0.01871609f, -0.04872605f, 0.03029167f, -0.05614525f, -0.00304770f, 0.04723544f, -0.06274510f, -0.02636505f, 
    -0.05079889f, 0.03691493f, 0.00315183f, 0.05589665f, 0.02856330f, 0.00519426f, -0.01788144f, 0.01565882f, 
    0.05100244f, 0.03686682f, 0.04718015f, 0.07528434f, -0.01458344f, -0.01076603f, -0.07223705f, 0.03194711f, 
    0.04300213f, -0.04263981f, -0.08009688f, 0.07040431f, 0.00567822f, 0.00866078f, -0.02365549f, -0.03239945f, 
    0.06206383f, -0.00557148f, -0.04744620f, 0.02927968f, 0.03224393f, 0.01261231f, -0.01374282f, -0.03296410f, 
    -0.01195407f, 0.06391276f, 0.03170549f, -0.07146943f, 0.05906699f, 0.00540205f, -0.05824802f, -0.00838158f, 
    0.00148305f, -0.03884478f, -0.05598714f, 0.02750597f, 0.00751836f, -0.05546674f, 0.02705679f, -0.05750652f, 
    0.04343935f, 0.00302715f, -0.03750405f, 0.02570583f, 0.01283284f, -0.05453684f, -0.06957544f, -0.00909750f, 
    0.05699217f, 0.02701109f, -0.04813566f, 0.02350512f, -0.01648090f, -0.05441415f, 0.07559667f, -0.01514355f, 
    -0.04750293f, -0.03176200f, 0.00890442f, 0.06714080f, 0.03460874f, 0.00316124f, -0.02523667f, 0.00841823f, 
    -0.00616167f, -0.01647494f, -0.00778288f, 0.02586477f, -0.01748446f, -0.05483705f, 0.00824878f, -0.03217661f, 
    0.01757498f, 0.01156684f, 0.05441408f, -0.05476720f, -0.02399283f, 0.06103105f, -0.01272681f, 0.02763820f, 
    -0.06258377f, -0.02481444f, -0.05708094f, -0.02553724f, 0.05566928f, 0.07262001f, -0.00421245f, 0.03116502f, 
    -0.00934819f, -0.06154028f, -0.00678785f, -0.06966268f, -0.05292941f, 0.07198475f, 0.03845429f, -0.04525472f, 
    -0.06750248f, -0.13638194f, 0.19818167f, 0.01758971f, 0.01329305f, -0.08683443f, -0.08108448f, 0.10914788f, 
    0.14337111f, -0.02668554f, -0.00885012f, 0.08047777f, 0.15812339f, 0.03264026f, 0.18963389f, -0.00961277f, 
    -0.06425714f, -0.10722458f, -0.13665278f, -0.03474210f, 0.06813560f, 0.04406813f, 0.08230418f, 0.09192675f, 
    -0.21110456f, 0.24183960f, 0.10441178f, -0.00846253f, -0.10029408f, -0.06391415f, -0.03034776f, 0.00241338f, 
    -0.01250362f, -0.03439884f, -0.01857933f, -0.10841437f, 0.07939669f, 0.00050413f, 0.30370945f, 0.05839399f, 
    -0.00903745f, -0.03825668f, -0.07607625f, 0.11848514f, 0.05326768f, 0.04300831f, -0.04875155f, -0.08643912f, 
    0.02226209f, -0.03587582f, 0.07411482f, -0.09005244f, -0.06321347f, 0.00130470f, -0.12290075f, 0.05051441f, 
    0.16035414f, 0.01349842f, 0.03209661f, -0.00890952f, 0.34571210f, -0.21798865f, -0.26922002f, 0.02968016f, 
    0.12073427f, 0.12919392f, -0.05266658f, -0.04848797f, -0.00353325f, 0.02709061f, -0.02776756f, -0.15922588f, 
    0.12545206f, -0.04851016f, -0.05961298f, 0.02009039f, -0.00321845f, -0.00795744f, 0.02786857f, 0.10194340f, 
    -0.02044206f, 0.05348932f, 0.01372361f, 0.00827948f, -0.64302093f, 0.13258280f, -0.18182184f, -0.07141204f, 
    0.02866054f, -0.26395735f, 0.15189447f, 0.01199580f, 0.05862224f, -0.08574431f, 0.16481248f, -0.15378521f, 
    0.25874579f, -0.05736905f, -0.09738563f, -0.12015847f, 0.06762223f, 0.07105630f, -0.03099092f, -0.01395700f, 
    -0.06114474f, 0.01249004f, -0.09970661f, -0.13825999f, 0.23069097f, -0.04447652f, -0.32775557f, 0.15734969f, 
    -0.00342950f, 0.04492426f, -0.04450127f, -0.02425565f, 0.10641219f, -0.01009812f, -0.02418697f, 0.01667984f, 
    -0.07539165f, 0.08030341f, 0.14863148f, 0.00002344f, 0.05357730f, -0.09459875f, -0.01605404f, -0.03490586f, 
    -0.03982673f, 0.05031356f, -0.02003290f, 0.07071815f, 0.04771359f, -0.30249301f, 0.37872604f, 0.07019973f, 
    0.04731734f, -0.01881443f, -0.02187757f, -0.04982776f, 0.04331278f, -0.02154434f, -0.10106030f, 0.09870468f, 
    -0.11357910f, 0.19194746f, 0.07520233f, -0.00317979f, -0.10992634f, -0.01856022f, 0.11039941f, 0.07886206f, 
    0.00996850f, 0.04851892f, 0.19118074f, -0.02111069f, 0.03873522f, 0.00413244f, -0.00003404f, 0.14311185f, 
    -0.04230335f, -0.14787979f, 0.00879150f, 0.05748622f, 0.02750349f, 0.03120884f, -0.20801683f, 0.21396193f, 
    0.04822085f, -0.04393146f, 0.10029888f, 0.00957336f, 0.17540230f, 0.12771675f, 0.09863921f, 0.02613293f, 
    0.17186695f, 0.01581801f, 0.19044834f, 0.02835212f, -0.45303470f, -0.43875611f, -0.03235975f, 0.57225686f, 
    -0.11855845f, -0.12587786f, -0.10717397f, 0.09382947f, 0.31002650f, 0.05295114f, 0.05975198f, 0.16727068f, 
    0.21446475f, 0.02991134f, 0.04809519f, -0.02725039f, -0.01836517f, -0.09352517f, 0.00062277f, -0.02272817f, 
    -0.00544299f, -0.02334155f, 0.13959032f, 0.11171227f, 0.16947591f, 0.08304832f, 0.11381048f, 0.03012350f, 
    0.07321818f, -0.15428506f, -0.03649472f, -0.04880747f, -0.16474737f, 0.19145556f, 0.11014921f, 0.01162877f, 
    0.34721547f, 0.09917798f, 0.09460291f, 0.18010367f, -0.01708463f, -0.03558534f, -0.08244639f, -0.03137388f, 
    0.00194331f, 0.01268883f, 0.07811118f, 0.09592833f, 0.08239565f, -0.03265272f, -0.01722959f, 0.13050318f, 
    0.05914166f, 0.00025967f, -0.11224895f, -0.12514284f, -0.20111187f, -0.02381478f, 0.13742666f, 0.19192831f, 
    0.14815728f, 0.06925927f, 0.06727197f, 0.17159027f, -0.09844398f, -0.29210466f, 0.04332184f, 0.07420451f, 
    -0.00108949f, 0.05410257f, -0.01762392f, -0.09204828f, -0.18355107f, -0.29329607f, -0.03448813f, 0.11829397f, 
    0.04718614f, 0.08836661f, 0.00168450f, 0.10321340f, 0.06256371f, 0.00429541f, 0.00410318f, 0.05579955f, 
    -0.05511194f, -0.09308040f, -0.00881280f, -0.12068131f, 0.07380247f, -0.16727386f, 0.04585490f, 0.00304766f, 
    0.10312705f, -0.12912816f, -0.09864551f, 0.02402214f, 0.31682670f, 0.29911539f, -0.05975119f, -0.08354123f, 
    -0.09797809f, 0.00514394f, -0.05239681f, 0.05276171f, 0.06660575f, -0.09673074f, 0.00142260f, 0.18453568f, 
    -0.13225481f, -0.21127667f, 0.10931328f, -0.05823012f, 0.03082723f, -0.08278486f, -0.33350408f, -0.04905614f, 
    0.04128394f, -0.13584001f, 0.03672289f, 0.01299133f, -0.50131953f, -0.32986397f, -0.20515977f, -0.09950505f, 
    -0.10708466f, 0.04826293f, -0.02305772f, -0.09887998f, 0.03866287f, -0.00769340f, 0.06185155f, 0.05255612f, 
    0.19394632f, 0.23177834f, 0.08863117f, 0.08340541f, 0.01559580f, 0.13606603f, 0.05371391f, 0.22418110f, 
    0.02189977f, -0.10946193f, -0.00750895f, -0.07372018f, 0.31595868f, 0.15872987f, 0.01427986f, 0.02274947f, 
    0.01831677f, 0.08740498f, 0.01929108f, 0.15054892f, -0.02518796f, -0.03993892f, 0.03824676f, -0.03217631f, 
    0.26476189f, 0.18018591f, 0.06115957f, 0.12376729f, 0.06203428f, 0.06654920f, 0.12342007f, 0.10541619f, 
    -0.11017420f, -0.05587398f, -0.18252209f, -0.07898229f, -0.06180620f, -0.31783408f, -0.04036747f, -0.13088743f, 
    -0.06994005f, -0.00894432f, -0.15594181f, -0.06911639f, 0.09299655f, -0.02220691f, 0.09385710f, -0.07660937f, 
    0.09501950f, 0.04903893f, 0.06628465f, -0.30825928f, -0.11569922f, -0.10733385f, 0.04816035f, -0.02530001f, 
    -0.02209998f, 0.05673603f, -0.19440083f, -0.02429054f, -0.27621418f, 0.28922367f, 0.33631095f, 0.14942968f, 
    -0.03907901f, 0.05552713f, 0.04680900f, -0.13556895f, -0.05765493f, -0.12727571f, -0.05925186f, 0.09646408f, 
    0.04074801f, -0.21968986f, 0.01936139f, -0.20076104f, 0.00548018f, 0.11531489f, 0.10929900f, 0.21692587f, 
    -0.01215810f, -0.04041508f, 0.09334434f, 0.08924937f, -0.26372907f, 0.05960416f, 0.05162872f, 0.01101198f, 
    -0.03411246f, -0.19008866f, -0.11823332f, -0.03913675f, -0.02801127f, 0.02710514f, 0.20244426f, 0.10736499f, 
    -0.32473469f, -0.03388509f, 0.07277606f, 0.20454574f, -0.00079641f, 0.22677439f, -0.00357123f, 0.06032290f, 
    -0.06998760f, -0.00105858f, 0.06814980f, 0.11060318f, -0.09804371f, -0.07325329f, -0.05396232f, -0.07701928f, 
    0.07244279f, 0.02260601f, 0.10782075f, 0.07329040f, 0.04684382f, 0.14595300f, 0.05606905f, 0.06591722f, 
    -0.12632358f, -0.13182262f, -0.12166660f, 0.11717025f, -0.05261203f, 0.01343913f, 0.06948289f, 0.01227788f, 
    0.02947058f, 0.04793203f, 0.04678885f, -0.10035653f, 0.05983033f, -0.00164305f, 0.22739223f, 0.08204097f, 
    0.02651207f, 0.04595471f, 0.10506348f, -0.16749339f, -0.02440633f, 0.15194118f, -0.04482915f, 0.11223675f, 
    -0.05409375f, 0.02106899f, -0.16559508f, -0.04520287f, 0.09833288f, -0.25008866f, -0.21404001f, -0.10704393f, 
    -0.11883045f, -0.15692529f, -0.10225195f, -0.05680146f, 0.59136862f, -0.08245809f, -0.16135521f, 0.35846484f, 
    0.10870300f, 0.11277386f, -0.01408930f, -0.03080762f, -0.03719696f, 0.17999189f, 0.20040539f, 0.15662339f, 
    -0.25470167f, 0.12715234f, -0.06962503f, 0.15065300f, 0.05460666f, 0.19037598f, 0.04989653f, -0.19087251f, 
    0.10299912f, -0.01338348f, -0.11711024f, -0.05675520f, -0.03500265f, -0.16818844f, 0.00544652f, -0.26476490f, 
    -0.14439397f, -0.08518192f, -0.06048126f, -0.04320132f, -0.02500836f, 0.02458955f, -0.01942240f, 0.01409699f, 
    0.01811385f, -0.17480694f, -0.11954699f, 0.05559407f, 0.01990991f, -0.15709203f, -0.13250862f, -0.00506136f, 
    -0.00159219f, -0.07050309f, -0.00238776f, -0.04439102f, -0.15019807f, 0.05526382f, 0.07933632f, 0.45259556f, 
    -0.05320767f, 0.15015596f, 0.01158968f, -0.02967898f, -0.01333761f, 0.00123305f, 0.05144528f, 0.07576826f, 
    0.06985052f, -0.06438865f, -0.07440368f, 0.17538756f, 0.13125642f, -0.09559887f, 0.03132197f, 0.10239448f, 
    0.00329963f, 0.02761206f, 0.02143452f, -0.09571290f, 0.07147074f, -0.06464856f, -0.00482740f, -0.09943171f, 
    0.05656977f, -0.25674778f, 0.16565239f, 0.08940636f, -0.04565627f, 0.21526183f, 0.08824314f, -0.06290575f, 
    0.07749920f, 0.07749552f, -0.12039154f, 0.05307217f, 0.02673134f, -0.00730152f, 0.09958584f, 0.05952555f, 
    -0.14080635f, 0.04660338f, -0.01746488f, 0.03748994f, 0.80826318f, -0.19173150f, -0.37959012f, -0.34177986f, 
    0.20509107f, -0.04678724f, -0.04491729f, -0.06168720f, 0.23600678f, 0.03766969f, 0.02775206f, 0.10326033f, 
    0.12984680f, 0.04293822f, -0.18631047f, 0.00259707f, -0.03287481f, 0.05956687f, 0.18222998f, -0.07036142f, 
    0.01507890f, 0.00090987f, 0.23103511f, 0.06955761f, -0.03085345f, 0.09334660f, 0.16609298f, 0.07926191f, 
    0.04667195f, -0.09603473f, -0.09098136f, 0.00879264f, -0.02660149f, 0.07427322f, 0.15094016f, 0.04106303f, 
    -0.47743413f, 0.29294011f, -0.44772041f, -0.22787711f, 0.13709736f, -0.09666637f, 0.19144423f, -0.06707914f, 
    -0.04265020f, -0.00276921f, -0.13125664f, 0.12818560f, -0.18696059f, 0.05300357f, -0.28253537f, -0.05306482f, 
    0.06823973f, -0.10087851f, -0.21756290f, -0.02389926f, 0.01090552f, 0.05134057f, 0.00048170f, -0.00522821f, 
    0.33207783f, -0.01381880f, -0.03263915f, -0.03778827f, 0.18922213f, -0.07575696f, 0.00834391f, 0.23061927f, 
    0.05436325f, 0.04953828f, -0.00498487f, -0.01858481f, 0.19988844f, -0.00084133f, 0.13417754f, 0.10740925f, 
    0.01235845f, 0.11253625f, 0.02461324f, 0.17300157f, -0.09024061f, -0.08436891f, -0.06116463f, -0.03671042f, 
    0.02268837f, 0.15767828f, 0.08977132f, -0.05259719f, 0.15559499f, 0.15157261f, 0.08432689f, -0.12024327f, 
    0.01751545f, 0.07028512f, -0.04533653f, 0.18944323f, 0.16928326f, -0.54777735f, 0.40343022f, -0.50200081f, 
    0.10181091f, -0.35396478f, 0.25749585f, 0.06363942f, 0.10679252f, 0.06587721f, -0.15136579f, -0.00866764f, 
    -0.18237190f, 0.06877222f, -0.05947518f, 0.25863895f, -0.02078255f, 0.20775649f, 0.27980882f, 0.05485963f, 
    0.00795099f, 0.07607373f, -0.22636339f, 0.07392878f, 0.27472109f, 0.02278156f, -0.16293222f, 0.20319931f, 
    0.06086886f, 0.02433703f, 0.03553021f, 0.06042994f, -0.10142665f, -0.05719615f, 0.04070343f, 0.00266464f, 
    0.08257914f, 0.06296048f, 0.16268447f, -0.01963985f, -0.03461711f, 0.04014582f, -0.06799336f, 0.05882043f, 
    -0.07968750f, -0.10737588f, -0.00042609f, -0.06582744f, 0.20011206f, 0.19345550f, -0.18843304f, -0.05839447f, 
    -0.10259252f, 0.08863802f, 0.07169968f, -0.18138413f, -0.03920508f, -0.07454967f, -0.03689139f, 0.02294797f, 
    0.33469653f, 0.07641914f, 0.16798024f, -0.02335431f, -0.12034106f, 0.02316205f, 0.07472861f, -0.01641402f, 
    0.05170416f, -0.04103174f, 0.09235312f, -0.01331328f, 0.02210892f, -0.17856710f, -0.14978787f, 0.21879318f, 
    0.00924671f, -0.26065531f, 0.03301632f, -0.00652008f, -0.01305461f, 0.09957769f, 0.05901226f, 0.08323862f, 
    0.02361678f, 0.23369624f, 0.10191990f, 0.33776006f, -0.00251431f, -0.01543160f, 0.04475690f, 0.10293171f, 
    -0.13919783f, 0.02455203f, 0.08348891f, -0.00060310f, -0.30458555f, 0.36212176f, 0.28825730f, -0.01047271f, 
    -0.03068373f, -0.01642016f, -0.12604482f, 0.02852516f, -0.01867505f, -0.05449792f, 0.09970585f, 0.02591438f, 
    -0.14846089f, -0.17228425f, 0.03691794f, -0.08083782f, 0.05454117f, -0.06674511f, -0.09833981f, -0.01700066f, 
    -0.14348343f, -0.03938736f, -0.16663869f, -0.08745728f, 0.10407709f, -0.10890610f, -0.11949586f, -0.02771090f, 
    -0.02548864f, 0.11643948f, 0.21155913f, 0.11594991f, 0.21789610f, 0.00836178f, -0.04514889f, -0.11319800f, 
    0.23254612f, -0.25928983f, -0.01183696f, -0.11116444f, 0.02005493f, 0.10465311f, -0.06459863f, 0.08307360f, 
    0.08357757f, -0.00979914f, -0.01137259f, -0.11494589f, 0.20884787f, -0.17034802f, -0.03528897f, 0.01438671f, 
    -0.08658179f, -0.07684865f, 0.10414390f, -0.00960981f, 0.05853565f, 0.01819512f, 0.01970162f, 0.05137546f, 
    0.00695258f, 0.05612846f, 0.23074193f, -0.05340061f, -0.07948992f, 0.23594414f, -0.01301023f, -0.22401406f, 
    0.04813082f, -0.20288187f, -0.04255027f, -0.15711299f, -0.07941321f, 0.22456984f, -0.02265050f, 0.13616644f, 
    0.06226143f, -0.12785754f, 0.00859495f, 0.08374820f, 0.09263527f, -0.00889586f, 0.05116862f, 0.14096895f, 
    -0.07122061f, -0.09276219f, 0.03510232f, 0.23299672f, -0.02251162f, 0.07185484f, -0.05187423f, 0.06102166f, 
    0.00603601f, -0.02264351f, 0.01585403f, -0.01970936f, -0.08661202f, 0.31999591f, -0.33875242f, 0.28547627f, 
    0.10531391f, 0.11393234f, -0.17794371f, 0.13145322f, -0.14981087f, -0.06783836f, -0.03658668f, -0.06662054f, 
    0.23521586f, 0.24089861f, -0.07980356f, 0.00006418f, 0.06454979f, -0.17076965f, -0.17307562f, -0.01539644f, 
    -0.02414614f, 0.04468118f, 0.11606611f, -0.20212620f, -0.16769016f, 0.06846111f, 0.26462737f, 0.06927750f, 
    0.13973986f, -0.02090800f, 0.02331559f, 0.05198888f, 0.11865184f, 0.05907698f, 0.10406066f, 0.12730752f, 
    0.08793674f, 0.11305331f, -0.10580957f, 0.02242249f, 0.15657082f, 0.09028636f, 0.15570985f, -0.05726642f, 
    0.00354077f, -0.03793745f, -0.04707507f, -0.01721732f, 0.22327603f, 0.12086716f, 0.39761335f, -0.16455978f, 
    0.08847362f, -0.16087019f, 0.09076731f, 0.05237193f, 0.00149517f, 0.11656981f, -0.07467144f, 0.07568520f, 
    -0.16841076f, 0.07562085f, -0.10623367f, 0.20720956f, 0.27586398f, 0.07317373f, -0.00258734f, 0.11256587f, 
    -0.15229806f, -0.01604824f, -0.00793132f, -0.06026687f, 0.08930043f, 0.27252766f, 0.08442710f, -0.09350162f, 
    0.02476582f, 0.07451764f, 0.04207756f, 0.08318823f, -0.12917803f, -0.12456018f, -0.01260223f, 0.18617088f, 
    0.08556952f, -0.20247968f, -0.20355292f, -0.21143329f, -0.06945448f, -0.05626201f, -0.08216541f, 0.06755837f, 
    0.13747324f, -0.03575537f, -0.02300492f, 0.16492775f, 0.33646551f, -0.38931364f, -0.22763638f, -0.28096828f, 
    -0.04522087f, -0.12017702f, 0.05761070f, 0.16419502f, -0.07269286f, 0.04004586f, 0.12523316f, -0.04048010f, 
    -0.09326205f, 0.14903674f, -0.07644551f, 0.00927453f, 0.00291144f, -0.10189185f, 0.02968774f, 0.00090198f, 
    -0.09689660f, 0.05374861f, -0.24394508f, -0.14314967f, 0.12221389f, 0.17633693f, 0.05523314f, -0.00257248f, 
    -0.05124103f, 0.00621693f, 0.08061562f, 0.04065385f, 0.08151532f, 0.07763590f, -0.00171128f, 0.08917180f, 
    0.36093390f, -0.17255938f, 0.30116454f, 0.00971137f, 0.07015320f, -0.11858355f, -0.07380634f, 0.09283004f, 
    -0.09288117f, 0.19469111f, -0.06174355f, -0.08635076f, 0.00606041f, -0.02092324f, -0.12985307f, -0.00047584f, 
    -0.05940627f, 0.00317809f, -0.07362089f, 0.03095070f, 0.00830010f, -0.04494468f, -0.12273470f, -0.04442251f, 
    -0.42119521f, 0.01629638f, -0.00626967f, 0.17866613f, -0.01431311f, 0.12349669f, 0.14320241f, -0.01710269f, 
    -0.07475499f, 0.02089387f, -0.03082950f, -0.04507154f, -0.27431893f, 0.12800469f, -0.01137047f, 0.07939503f, 
    -0.10643228f, -0.12650707f, 0.05669541f, -0.06637772f, 0.06924810f, 0.01976258f, 0.00793402f, 0.00300087f, 
    -0.10552852f, 0.04843356f, 0.03013821f, -0.06539673f, -0.16421537f, -0.07647898f, 0.00716462f, -0.13683419f, 
    -0.06296621f, 0.16472672f, 0.20846544f, 0.11343001f, 0.81433511f, 0.12391985f, 0.06561738f, 0.47501555f, 
    -0.08261672f, 0.05482327f, -0.04761493f, 0.11905590f, -0.04110933f, 0.03822740f, -0.10532472f, -0.05434546f, 
    -0.16918977f, -0.12107670f, 0.35153204f, 0.02014802f, -0.03075843f, -0.00572227f, -0.00165735f, 0.03447748f, 
    0.02627616f, 0.05780945f, -0.11923322f, -0.02348290f, -0.31079525f, 0.10234391f, 0.05640210f, -0.19131550f, 
    -0.17742047f, -0.16968355f, -0.06456701f, -0.05978811f, -0.01731739f, 0.10546000f, -0.02278262f, 0.04671259f, 
    0.00971638f, -0.07612942f, 0.05037324f, 0.28960037f, 0.03437908f, 0.12865393f, 0.08578300f, 0.15082577f, 
    0.09523435f, 0.13742678f, 0.07495041f, 0.02225897f, -0.32327285f, 0.29109907f, -0.34327504f, 0.11729414f, 
    -0.00823968f, 0.03154534f, 0.07143653f, 0.05525795f, -0.12325339f, 0.09053351f, -0.01019638f, 0.07393853f, 
    -0.02476611f, -0.23325153f, 0.08269206f, 0.10820615f, 0.22052644f, -0.00849937f, -0.01117839f, 0.01169258f, 
    0.03367385f, 0.05799174f, -0.07673128f, 0.16710460f, 0.01071231f, 0.26477575f, -0.07328174f, -0.10683949f, 
    -0.06933852f, 0.10970034f, 0.00024495f, -0.09567405f, 0.00935018f, -0.01278275f, 0.07114213f, 0.05076541f, 
    0.02145815f, -0.00774614f, 0.25082743f, -0.02338465f, -0.02871119f, -0.04964830f, 0.14691578f, -0.04353998f, 
    -0.00437409f, -0.02136667f, 0.00029330f, 0.13852067f, 0.27937579f, 0.18020798f, -0.30600017f, -0.40099818f, 
    -0.21500555f, 0.00159186f, -0.03491447f, -0.00741213f, -0.04462332f, -0.04026762f, -0.01712918f, 0.05995740f, 
    -0.00454961f, 0.13122237f, -0.00899749f, -0.11295067f, 0.10377068f, -0.21597801f, -0.01373071f, -0.13138291f, 
    -0.07410473f, -0.10179114f, 0.05053797f, -0.11140300f, -0.22108294f, -0.30662999f, -0.33803156f, -0.17407355f, 
    -0.16265322f, -0.02813602f, 0.05794149f, 0.03266473f, 0.02015525f, 0.04507406f, 0.07532584f, 0.08498425f, 
    0.01305649f, -0.34580868f, -0.35079563f, -0.28749299f, 0.05873044f, 0.05586907f, -0.07093458f, 0.02755252f, 
    0.16880158f, 0.05634148f, -0.02073651f, -0.06947830f, 0.16952711f, -0.10490113f, -0.12060259f, -0.05303127f, 
    0.08036188f, 0.00306740f, -0.01045343f, -0.04364672f, 0.00636314f, -0.16303396f, -0.09274010f, -0.06224409f, 
    0.07740774f, 0.04654233f, 0.03286687f, -0.05943411f, 0.12991787f, 0.09115917f, 0.11024036f, 0.17302062f, 
    -0.03604625f, -0.14466561f, -0.09488700f, -0.23190144f, 0.01501491f, 0.23840460f, 0.02907738f, -0.10988902f, 
    -0.00492379f, -0.16750784f, -0.18869975f, -0.06292769f, -0.06050157f, -0.02385440f, 0.04791795f, -0.04573507f, 
    -0.10089391f, 0.01919513f, -0.03016113f, -0.13499609f, -0.05152394f, -0.02093995f, -0.17116418f, -0.02935177f, 
    0.17628516f, 0.20904937f, 0.08971152f, 0.20481810f, -0.08041844f, 0.04264076f, 0.18749930f, -0.12619103f, 
    0.14970587f, 0.01465786f, -0.04185437f, 0.10508457f, 0.08987208f, 0.17257120f, -0.21788061f, -0.04419722f, 
    0.25087276f, 0.30718604f, -0.07244978f, -0.17837608f, -0.20213291f, -0.09472755f, -0.08091723f, 0.06554651f, 
    0.01648632f, 0.07080323f, 0.02621206f, -0.14870819f, -0.02823561f, 0.16503000f, 0.34023237f, 0.01984425f, 
    0.10433350f, -0.09429824f, -0.12518984f, -0.04686379f, -0.17423229f, -0.12025306f, -0.08018403f, -0.11738165f, 
    0.01316720f, -0.02281520f, 0.06996603f, -0.00118342f, 0.28828105f, 0.11552653f, 0.20634244f, 0.08589908f, 
    0.03767253f, 0.14088766f, 0.00257171f, 0.14528379f, 0.10000402f, 0.34447601f, 0.07872255f, -0.17141967f, 
    0.07363949f, -0.06372840f, 0.19798595f, -0.00613804f, 0.10649411f, -0.00509270f, 0.05728642f, 0.17170505f, 
    0.00507563f, 0.09811743f, 0.01805316f, -0.19260545f, 0.12787424f, 0.22723715f, -0.01741560f, 0.22868977f, 
    -0.01486783f, 0.00089120f, 0.03891918f, -0.05056690f, -0.01776763f, -0.07332654f, -0.10063754f, 0.13673916f, 
    -0.16531299f, -0.02708162f, -0.12883674f, -0.22101727f, 0.08344790f, -0.13317716f, 0.06541365f, 0.15267716f, 
    0.10265058f, 0.09446923f, 0.07567844f, 0.30969611f, 0.22601619f, 0.09999204f, 0.05426912f, 0.12165168f, 
    0.14728218f, -0.00090224f, -0.02584190f, 0.26366347f, 0.25696325f, -0.28347379f, -0.07384977f, -0.07975456f, 
    0.11026143f, -0.19897084f, 0.00182544f, 0.00915054f, 0.02215951f, 0.13979857f, 0.10936936f, -0.01585039f, 
    0.13059244f, -0.18295534f, 0.17886111f, -0.01903653f, 0.01971439f, -0.21553537f, 0.03188780f, 0.12989251f, 
    0.18705459f, 0.10417419f, 0.07478943f, 0.03173011f, -0.04427953f, -0.03487877f, 0.21801431f, -0.08184882f, 
    -0.02746414f, -0.04277198f, 0.06134313f, -0.00636018f, 0.04885165f, -0.14076176f, 0.07722692f, 0.20102406f, 
    -0.08193848f, 0.01217720f, 0.39219669f, 0.21246776f, -0.10407888f, -0.06268413f, -0.00072551f, 0.09111893f, 
    0.28152224f, 0.10702429f, 0.09534149f, 0.13283715f, 0.08240946f, 0.00350873f, 0.35347715f, 0.10007306f, 
    -0.05705646f, -0.04946239f, 0.00673011f, 0.01397579f, 0.11160142f, 0.11548159f, 0.01931410f, 0.01440760f, 
    -0.21880093f, -0.07626967f, -0.03755093f, 0.00485804f, 0.11581395f, 0.17627256f, 0.04640524f, -0.09856484f, 
    -0.10231346f, 0.03825147f, 0.06983442f, 0.08971446f, -0.11519532f, -0.04834081f, -0.13630280f, 0.02831846f, 
    0.15592934f, 0.16180509f, 0.18078837f, 0.12105419f, 0.03385126f, 0.04837306f, 0.03495567f, -0.03554711f, 
    0.05348045f, -0.04781653f, -0.04331567f, 0.02219309f, 0.09386664f, 0.05316683f, 0.10008987f, 0.04330277f, 
    0.00226971f, -0.02812672f, 0.02780936f, 0.01705874f, 0.21874914f, 0.06948955f, -0.36746165f, 0.52481711f, 
    -0.02932336f, 0.00248270f, -0.16031903f, 0.11765233f, 0.01453784f, -0.01461930f, 0.07899306f, -0.05286464f, 
    0.04930481f, 0.00826528f, 0.09441172f, -0.19871362f, 0.08875050f, -0.01740542f, 0.14288063f, 0.01393253f, 
    0.06063963f, 0.02404347f, -0.04851170f, 0.03239528f, 0.02578119f, 0.01380658f, -0.14108595f, -0.10459384f, 
    -0.03450428f, 0.01670315f, 0.02126108f, -0.00938221f, -0.06805368f, -0.12356124f, 0.02548491f, 0.00880780f, 
    -0.20545864f, -0.39047292f, -0.29113877f, 0.01357181f, 0.00131705f, 0.01019890f, -0.10830350f, -0.03129212f, 
    0.08221927f, -0.05860452f, 0.01729733f, 0.01207077f, -0.15919182f, -0.44637123f, 0.03490284f, 0.18254125f, 
    0.08855711f, 0.16162373f, -0.09609643f, -0.07124823f, -0.01393473f, 0.04500064f, 0.03461777f, -0.00319525f, 
    -0.15173110f, -0.05189698f, -0.04068019f, 0.06141645f, 0.15564002f, -0.08155556f, 0.04418554f, -0.10978544f, 
    -0.01364888f, 0.02186691f, 0.10865033f, -0.07777674f, -0.02946600f, -0.05663672f, 0.07084405f, 0.04892612f, 
    0.00650246f, -0.01384532f, -0.05768513f, -0.02200810f, -0.26170138f, 0.17151101f, 0.04738266f, 0.02769947f, 
    0.08323538f, -0.06312357f, 0.11032163f, -0.11054134f, 0.16816893f, -0.04771557f, 0.11004230f, 0.02009377f, 
    0.09791778f, -0.04994553f, 0.24671175f, 0.06159846f, 0.59743744f, -0.23361121f, -0.18613295f, 0.27054378f, 
    0.15580951f, 0.04146023f, -0.05873124f, -0.11351332f, 0.12908037f, 0.08842304f, 0.00336282f, 0.10743304f, 
    0.23306325f, 0.13085397f, -0.00481437f, -0.08643349f, -0.11295054f, 0.07288439f, 0.07316017f, 0.13015503f, 
    0.01010949f, 0.14825080f, 0.01234239f, -0.11834544f, 0.13835372f, 0.12857014f, 0.13907282f, -0.00172543f, 
    0.04087103f, -0.04506673f, -0.17805307f, -0.13660239f, -0.11715214f, 0.00814256f, 0.08746969f, 0.13963777f, 
    -0.03274238f, -0.16248560f, -0.22784325f, -0.09891829f, 0.03698985f, 0.02904877f, -0.08815473f, 0.09273232f, 
    -0.07849986f, 0.06995420f, -0.04875032f, 0.06706673f, 0.03713949f, 0.03857534f, -0.02307341f, -0.10114164f, 
    0.14189374f, 0.10167044f, -0.13577700f, -0.07316006f, -0.02096819f, -0.14075883f, -0.14471382f, -0.09483059f, 
    0.18031205f, 0.07128482f, -0.05923072f, 0.05085258f, 0.11519846f, -0.01761384f, 0.14622158f, 0.16395523f, 
    -0.12938645f, 0.01192543f, -0.11665914f, -0.04100201f, -0.14005429f, -0.39711401f, -0.09732560f, 0.25501227f, 
    -0.08096904f, 0.18148516f, -0.20047671f, 0.00345472f, -0.00428926f, 0.05416561f, -0.01829589f, -0.04968701f, 
    -0.05694177f, 0.04401298f, -0.02050836f, -0.21833539f, 0.01880269f, -0.07866661f, 0.02733311f, -0.06658424f, 
    0.07645299f, -0.07839043f, 0.00000949f, 0.19384111f, 0.01114855f, -0.16301818f, 0.03709317f, -0.00874780f, 
    -0.15561596f, 0.04267575f, 0.00552942f, 0.01138617f, 0.15029697f, 0.07667833f, -0.07767431f, 0.02927430f, 
    0.01934995f, -0.24104142f, 0.45191720f, -0.03254076f, -0.16112983f, 0.34820628f, -0.11339285f, 0.04812890f, 
    0.03801314f, -0.04529803f, -0.09001824f, 0.02576387f, -0.09740347f, -0.07669435f, -0.36881244f, -0.03539263f, 
    -0.10222526f, -0.00331844f, 0.06787218f, -0.16988795f, -0.10352360f, -0.06205415f, -0.00048930f, -0.09446090f, 
    -0.02282817f, 0.01661324f, -0.03107524f, -0.01758556f, 0.12803838f, -0.02625394f, -0.01324707f, 0.20622680f, 
    -0.06810019f, 0.07735056f, 0.11141770f, 0.23040411f, 0.26714993f, 0.10989860f, -0.31607285f, -0.08191834f, 
    -0.05162865f, 0.14502589f, -0.00665539f, 0.03413473f, -0.03699619f, -0.06295512f, 0.01370957f, -0.00910106f, 
    0.27019513f, -0.05071943f, -0.11898241f, -0.00288861f, 0.03469399f, 0.06521658f, 0.10686968f, 0.13247849f, 
    0.09649593f, 0.02629815f, -0.06200832f, -0.04276357f, 0.21405292f, -0.24320567f, -0.04841024f, 0.05611194f, 
    -0.05965391f, -0.00985008f, -0.00187662f, -0.02596104f, 0.05276908f, 0.11376140f, 0.11143594f, 0.07773664f, 
    -0.17076805f, 0.18337555f, 0.22838239f, -0.08630256f, 0.00788987f, -0.13913925f, 0.08186903f, -0.05346867f, 
    -0.14720123f, -0.05867637f, -0.00595479f, -0.13112158f, 0.25437632f, 0.31096482f, 0.52394187f, -0.12787277f, 
    -0.10150259f, 0.06790654f, -0.03052610f, -0.17256731f, -0.02334304f, -0.06359740f, -0.01371952f, 0.05007865f, 
    -0.05371583f, -0.04036348f, -0.01412499f, -0.01328618f, -0.01326825f, -0.01067423f, -0.05463975f, 0.00230594f, 
    -0.02247090f, -0.01070403f, 0.04152665f, 0.04066253f, 0.06483176f, -0.03884712f, -0.02371432f, -0.04932784f, 
    -0.07449754f, -0.05048369f, -0.07873406f, 0.02664388f, -0.05570846f, -0.07930887f, -0.03878796f, 0.00707115f, 
    -0.02314216f, -0.08102132f, -0.00542074f, -0.00363659f, -0.02324427f, 0.04818989f, -0.02932198f, 0.00733636f, 
    0.02990286f, -0.01655100f, 0.00064464f, -0.02849034f, -0.02436921f, -0.04597920f, -0.06710409f, -0.02983161f, 
    -0.03133741f, 0.03619020f, -0.06949674f, -0.04276998f, 0.00676645f, -0.03965504f, 0.02738541f, -0.06900753f, 
    0.05352265f, -0.01053730f, 0.02771273f, 0.05696189f, 0.02713572f, -0.01744298f, 0.00865549f, 0.05535522f, 
    -0.07704248f, -0.07813502f, -0.00059283f, 0.05687920f, -0.07100520f, -0.03450130f, 0.04091535f, 0.01529511f, 
    -0.05775873f, -0.07143328f, 0.01417363f, 0.00632214f, -0.02979270f, 0.05329808f, -0.03839971f, -0.01102391f, 
    -0.05698232f, -0.07223064f, -0.07635521f, -0.04593443f, -0.01675003f, -0.01584853f, 0.05745387f, -0.06030157f, 
    -0.06372430f, -0.02564487f, 0.02453507f, -0.05386883f, 0.02976436f, 0.00091682f, -0.00796399f, 0.05715962f, 
    0.01953670f, 0.01001588f, -0.06931047f, 0.01067979f, -0.04336830f, 0.03280738f, -0.00554866f, -0.01281606f, 
    0.04425078f, 0.05900564f, 0.04048233f, -0.04703988f, 0.05150634f, -0.02442237f, -0.07214332f, 0.04716839f, 
    -0.06409266f, -0.06631392f, -0.06038779f, -0.01742885f, 0.00224177f, 0.03965963f, -0.02182386f, -0.06611188f, 
    0.03027734f, -0.02780979f, -0.04134377f, 0.05291019f, -0.04149429f, -0.07510614f, -0.02715161f, 0.03297902f, 
    -0.04803564f, 0.04051803f, 0.01102091f, -0.02907352f, -0.04445655f, -0.03846220f, -0.05325732f, -0.04366887f, 
    -0.04824683f, 0.01617067f, 0.04914856f, 0.02338749f, 0.04375549f, -0.03820001f, 0.02965662f, -0.01143223f, 
    0.02625258f, 0.00134293f, 0.03723420f, -0.02095833f, 0.03113299f, 0.04930044f, -0.03091796f, -0.02515559f, 
    -0.07228085f, 0.00208009f, -0.02222701f, 0.03618807f, 0.02401285f, 0.04082146f, 0.04536586f, 0.06135274f, 
    -0.01662711f, 0.05181946f, -0.02056894f, -0.07838833f, -0.02433542f, 0.04697371f, 0.03730667f, 0.00334713f, 
    0.04396070f, 0.00304145f, -0.07415497f, -0.00223941f, 0.05707236f, -0.00972207f, -0.00189150f, -0.01266226f, 
    -0.02359261f, 0.01382656f, -0.07249235f, -0.02627563f, 0.05616866f, -0.05693099f, 0.03230606f, -0.04374909f, 
    0.00065995f, -0.05067988f, 0.00850712f, 0.04204490f, 0.02216706f, 0.02014731f, -0.07466802f, -0.04684239f, 
    -0.04480712f, -0.04847592f, 0.05497389f, -0.01318402f, 0.01908437f, -0.04273608f, -0.02701075f, 0.02640098f, 
    -0.14839426f, -0.07671484f, -0.15155162f, -0.08894439f, -0.06383949f, -0.04337199f, 0.18072723f, -0.00455455f, 
    -0.11640774f, 0.09382313f, 0.10560887f, 0.06604268f, -0.06214684f, -0.22664003f, -0.14111026f, -0.11624168f, 
    0.08591832f, 0.08287827f, 0.01915517f, -0.01743639f, 0.04206195f, -0.06385054f, 0.05122165f, -0.12386616f, 
    -0.46815905f, 0.26478150f, -0.26545706f, -0.13797554f, 0.06221396f, 0.02927993f, 0.42537048f, -0.01246286f, 
    0.03491195f, -0.02031427f, -0.07921068f, 0.06620090f, -0.04949884f, -0.19081314f, -0.31709340f, -0.09908621f, 
    0.06407379f, 0.01030726f, 0.09597382f, 0.08321419f, 0.06479122f, -0.01837891f, 0.06710114f, 0.01063165f, 
    0.27362105f, 0.07756068f, 0.11604431f, -0.04444369f, 0.20746705f, 0.01031487f, 0.10224696f, -0.00867280f, 
    -0.02503632f, -0.02275346f, -0.06435563f, 0.04307819f, -0.10100922f, 0.24984248f, 0.31652388f, -0.00835489f, 
    -0.07315565f, -0.04080673f, 0.04076825f, 0.07240683f, 0.02098758f, -0.02443132f, 0.03219390f, -0.09867155f, 
    -0.07069982f, 0.09165245f, 0.02172561f, 0.04360919f, 0.18730259f, 0.02717125f, -0.06404076f, 0.01588271f, 
    0.05238299f, 0.00776841f, -0.07313985f, 0.18257786f, 0.34601548f, -0.39314076f, 0.18868497f, -0.08661303f, 
    0.24231330f, -0.29294470f, 0.11554696f, 0.01105415f, -0.02342593f, 0.01979070f, -0.15238316f, 0.04458175f, 
    -0.18975514f, 0.25632030f, -0.15903115f, 0.08806744f, 0.00976487f, -0.02540962f, 0.16080996f, 0.03457690f, 
    -0.00199041f, 0.01823641f, 0.01531394f, 0.00637772f, -0.05582414f, 0.00880308f, 0.02876337f, 0.03598184f, 
    0.06170993f, 0.04878381f, 0.09216608f, -0.03021542f, 0.04273012f, 0.02633367f, 0.00496523f, 0.11432081f, 
    0.27469391f, 0.17216052f, 0.10536913f, -0.03064310f, 0.09793670f, 0.15397403f, 0.02092350f, -0.05384529f, 
    0.01367778f, -0.04099205f, 0.04432880f, -0.08783183f, 0.30364928f, 0.36465085f, 0.14582616f, 0.03057620f, 
    -0.01622559f, -0.08706398f, 0.12412067f, -0.07062609f, -0.03303147f, 0.03110785f, -0.05906901f, 0.04240083f, 
    0.24235825f, 0.27007219f, 0.00735676f, 0.07527374f, 0.08118744f, 0.08844768f, 0.06709170f, -0.03036681f, 
    -0.09380555f, -0.00169911f, 0.08737841f, -0.06295960f, -0.03037005f, -0.25848776f, -0.15687287f, 0.09085606f, 
    0.00132972f, -0.01045992f, -0.01999192f, 0.09657613f, -0.14782594f, 0.06395388f, 0.08064590f, -0.08459197f, 
    0.08874981f, 0.06642723f, -0.05888569f, 0.30216578f, -0.05961039f, 0.08878047f, 0.01954174f, 0.02646468f, 
    -0.26593405f, -0.12509704f, 0.23104173f, -0.01832169f, 0.00704279f, 0.10320431f, 0.07288455f, -0.26310223f, 
    0.07864793f, 0.02789151f, 0.12694769f, -0.01797967f, 0.03262125f, -0.05696043f, -0.03640073f, -0.01987188f, 
    -0.08050523f, 0.14697139f, -0.11937609f, 0.23270673f, 0.11467386f, 0.02820527f, -0.14549147f, -0.19127755f, 
    0.06665884f, 0.09218378f, -0.12721913f, 0.01366952f, 0.07606345f, -0.19796905f, -0.07484365f, -0.05665810f, 
    -0.11727524f, 0.11055935f, 0.09692793f, 0.09887773f, 0.08504223f, 0.07140943f, -0.06984268f, 0.04240797f, 
    0.47332054f, 0.15698983f, -0.01713773f, -0.04227379f, 0.01401160f, -0.14244463f, 0.01062436f, 0.10853291f, 
    -0.06381064f, -0.07778180f, -0.07362791f, -0.20559606f, 0.32353592f, -0.20176764f, -0.13039038f, 0.09513418f, 
    -0.07102137f, -0.05530382f, -0.06082517f, 0.00216212f, 0.03114204f, -0.09007316f, -0.03515081f, -0.07971808f, 
    -0.11760546f, 0.13822947f, 0.12216813f, -0.09626990f, 0.03501671f, -0.02272023f, 0.05596289f, 0.05284170f, 
    0.02462214f, -0.05295817f, -0.03801675f, -0.07436377f, 0.14380875f, 0.48203361f, 0.07416539f, -0.02492228f, 
    -0.05582583f, -0.24525495f, -0.02820844f, -0.08004405f, -0.09747503f, -0.01556545f, -0.01023464f, 0.02444818f, 
    0.07408997f, 0.14632584f, 0.01873781f, -0.15074086f, -0.02082937f, 0.10003600f, -0.06107590f, -0.07931551f, 
    -0.02541066f, 0.05017912f, 0.14895083f, 0.02547959f, -0.38810134f, 0.46912146f, 0.05768421f, -0.18856232f, 
    0.00673243f, 0.08176030f, 0.19146752f, 0.04139325f, -0.01352361f, -0.00870340f, 0.09757773f, -0.01876008f, 
    0.31462479f, 0.14924334f, 0.26627547f, -0.30023015f, -0.13544825f, -0.13608854f, -0.12241896f, 0.01364389f, 
    -0.05617324f, 0.05950021f, 0.11325964f, 0.11048501f, -0.02462438f, 0.25037104f, 0.18458326f, -0.00544152f, 
    -0.09210594f, -0.13824262f, -0.13772310f, -0.14230235f, -0.03553019f, -0.04576925f, -0.05983455f, 0.06767977f, 
    -0.02202874f, 0.03422073f, 0.03583018f, 0.04419579f, 0.06175262f, 0.17871954f, 0.11588594f, 0.06301752f, 
    -0.10958161f, -0.04372905f, 0.07986822f, -0.00907296f, 0.09103386f, 0.10931621f, 0.09188956f, -0.24318181f, 
    0.02126659f, -0.00077832f, 0.01979560f, 0.10878443f, 0.01862638f, -0.06178422f, -0.05773604f, -0.13384362f, 
    -0.20838843f, 0.10234068f, -0.04790675f, 0.09294080f, -0.01354850f, 0.07103097f, -0.04730943f, 0.17508370f, 
    0.02775748f, 0.08151382f, -0.10546038f, 0.08546472f, 0.13670531f, 0.14268191f, -0.01669708f, -0.13664609f, 
    -0.18161124f, 0.14294505f, -0.10901128f, -0.20542040f, 0.17832246f, -0.08512587f, -0.05793585f, 0.08909027f, 
    0.07113446f, 0.00337716f, 0.17412172f, 0.13115831f, -0.06953394f, 0.27995071f, -0.07154011f, 0.08590540f, 
    0.24835257f, -0.03117471f, -0.02510948f, 0.05945800f, -0.19019209f, 0.05403144f, -0.26709026f, 0.07949478f, 
    0.10136800f, 0.13693891f, 0.05482116f, -0.00285133f, -0.08313822f, 0.01543677f, -0.03846876f, 0.00687586f, 
    -0.06707416f, -0.15131569f, 0.07682718f, -0.03696074f, 0.01500662f, 0.03872472f, 0.04073782f, -0.16707723f, 
    0.01244212f, -0.02869643f, 0.23058237f, 0.06080840f, 0.26028129f, -0.04994982f, -0.18546329f, -0.03486315f, 
    -0.18917061f, -0.08654302f, -0.07376424f, -0.03712978f, -0.02789551f, 0.01808218f, -0.13893659f, -0.18610165f, 
    -0.01654782f, 0.20560046f, 0.09894250f, 0.09556924f, -0.04917257f, -0.00056060f, -0.00283176f, 0.09626096f, 
    0.13822100f, 0.09016055f, -0.00877840f, 0.14250582f, 0.24626094f, -0.09035727f, -0.15200841f, 0.02818028f, 
    -0.01447550f, -0.10344198f, 0.02259150f, 0.06560346f, 0.09231996f, 0.07361285f, 0.06302639f, 0.12460245f, 
    0.03322595f, -0.10331391f, 0.08727768f, 0.02145009f, 0.15148370f, 0.03840729f, 0.13301685f, -0.01305848f, 
    0.03950578f, 0.06200894f, 0.01830679f, 0.12215688f, -0.25583634f, 0.22554824f, 0.34376583f, 0.09980901f, 
    0.08833815f, -0.18279448f, -0.10540680f, 0.13239153f, 0.04814186f, -0.05803747f, 0.02311839f, 0.03756706f, 
    -0.13129725f, 0.02830321f, 0.03511355f, 0.08280090f, -0.02693592f, -0.00960212f, -0.11627981f, -0.12364510f, 
    -0.11625871f, -0.22969149f, -0.39403248f, -0.11448827f, 0.65273136f, -0.05827473f, -0.00733675f, 0.05882664f, 
    0.05575464f, 0.11882683f, 0.06661371f, -0.04404166f, -0.11454750f, -0.11173266f, -0.10050334f, 0.15055856f, 
    -0.13410449f, 0.47670817f, -0.25296393f, -0.02792816f, -0.04546238f, -0.13577233f, -0.13840187f, -0.04114455f, 
    0.10854336f, 0.00771632f, -0.06452883f, -0.15614574f, -0.11517995f, -0.16069058f, 0.49541724f, 0.19435270f, 
    -0.10489979f, -0.12514716f, -0.36325645f, -0.08156575f, 0.05286155f, 0.01998892f, 0.07087431f, 0.14715704f, 
    0.04526195f, 0.07534420f, 0.05587663f, 0.01623502f, 0.19691685f, 0.10835274f, 0.06795834f, 0.09860612f, 
    0.00266246f, -0.11231498f, 0.05373436f, -0.11078838f, 0.05051440f, 0.24784620f, 0.35176188f, 0.12058713f, 
    0.07652397f, -0.02609888f, 0.13740477f, 0.05088559f, -0.03751954f, -0.00868656f, -0.03232369f, 0.02149568f, 
    0.14152101f, 0.28823555f, 0.07717043f, 0.43557900f, 0.21162806f, 0.13590126f, 0.18254912f, -0.09344656f, 
    0.05173599f, -0.09521300f, -0.17978013f, -0.03883171f, 0.10228565f, -0.14867225f, 0.06867334f, -0.04051061f, 
    -0.07822422f, 0.06311386f, -0.11523123f, 0.11764807f, -0.08657423f, -0.02742622f, 0.01728820f, -0.18491907f, 
    0.07379313f, -0.04918304f, -0.13089657f, 0.01255644f, -0.16928877f, -0.17434512f, 0.04752848f, 0.01558610f, 
    -0.18352443f, -0.08836236f, 0.05966123f, 0.10141319f, 0.01180536f, 0.00635501f, -0.00165065f, -0.08470260f, 
    0.04247347f, -0.02155850f, -0.12538300f, -0.10803138f, -0.04937517f, -0.06423934f, 0.14399096f, -0.08593068f, 
    -0.14709967f, 0.15727729f, 0.04515933f, -0.04405736f, 0.01020959f, -0.03019791f, -0.13763352f, 0.11631508f, 
    -0.03384243f, -0.00210881f, -0.21181458f, -0.13763742f, 0.01649061f, 0.23009723f, -0.00137196f, 0.03656873f, 
    -0.07448811f, -0.07120386f, 0.09097410f, 0.03905691f, 0.01300886f, 0.10904088f, -0.02512530f, 0.01985407f, 
    0.22814932f, -0.06992621f, 0.28257900f, 0.02990691f, 0.04555449f, -0.23758122f, -0.19872828f, -0.01676973f, 
    -0.06894300f, 0.15205593f, 0.04139651f, -0.00610087f, -0.18073761f, 0.27630088f, 0.08759706f, 0.02669161f, 
    0.01240853f, 0.03195666f, -0.06071148f, -0.03683005f, -0.00020671f, 0.01362326f, -0.03646757f, -0.09750760f, 
    -0.24509157f, 0.04490647f, -0.03990814f, 0.19634126f, -0.05234201f, 0.23136304f, 0.07353248f, 0.00290256f, 
    0.04297547f, 0.06387953f, 0.04928555f, 0.12480786f, -0.02881233f, 0.00429730f, -0.10358839f, 0.07127084f, 
    -0.02591699f, -0.07745757f, 0.08227041f, -0.08898080f, 0.08849560f, -0.00571623f, 0.05178520f, 0.13454680f, 
    0.07061929f, -0.00802672f, 0.09077547f, -0.06607944f, -0.10684224f, 0.05502794f, 0.05001400f, 0.07810149f, 
    -0.00348780f, 0.09780861f, 0.15949367f, -0.05212941f, 0.55963326f, -0.01689574f, -0.00092233f, 0.36445847f, 
    -0.10547028f, 0.20785943f, -0.00863893f, 0.03625394f, 0.08497541f, -0.03966124f, -0.03371768f, 0.01367000f, 
    0.12385421f, 0.03789618f, 0.17105499f, 0.22836307f, 0.03650402f, 0.05215771f, 0.11820626f, 0.04408292f, 
    0.07807129f, -0.07502415f, 0.02437046f, -0.13437691f, 0.08725727f, 0.14909263f, 0.01591189f, 0.00682403f, 
    -0.12656504f, 0.04232494f, 0.02206753f, 0.04176360f, -0.05315413f, 0.09439116f, -0.08950608f, -0.04543101f, 
    -0.17029887f, -0.03727567f, 0.06849856f, 0.26218322f, -0.07071959f, 0.03289931f, -0.12587798f, -0.01175457f, 
    0.01940586f, -0.00054091f, 0.06138354f, 0.00818161f, -0.49887890f, -0.07634532f, -0.13805400f, 0.32872564f, 
    0.01106211f, 0.16461824f, -0.07191411f, -0.01373853f, -0.06339280f, -0.02522365f, -0.02342155f, 0.03090724f, 
    -0.15895636f, -0.24421622f, 0.10594816f, 0.19486964f, 0.09001527f, -0.15187673f, -0.04796644f, -0.04393591f, 
    -0.08554710f, -0.09701036f, 0.02902748f, 0.05557370f, 0.00479014f, 0.25955462f, 0.16147193f, 0.02283040f, 
    -0.06465872f, 0.04922001f, 0.05332484f, -0.01803313f, -0.03145182f, -0.09035963f, -0.04567717f, 0.06332611f, 
    -0.15950078f, -0.02887008f, 0.09771596f, -0.01729259f, -0.04115907f, -0.12445591f, 0.04893858f, 0.08383025f, 
    -0.06655782f, 0.03105447f, 0.07856029f, -0.06509496f, -0.06760408f, 0.06513705f, -0.13235469f, -0.09085575f, 
    -0.09638929f, 0.00731993f, -0.07434352f, 0.05592230f, -0.10946680f, -0.03753143f, -0.02329470f, -0.01901888f, 
    0.15266804f, 0.05157957f, 0.03479818f, 0.04628425f, -0.26783350f, 0.11041302f, -0.06852767f, 0.09265631f, 
    0.05746500f, 0.09357297f, 0.05510244f, 0.08069957f, 0.24840459f, 0.14464211f, 0.17336519f, -0.00121893f, 
    -0.00345959f, -0.16942216f, -0.02114629f, 0.00686404f, 0.02316347f, 0.05560528f, -0.04700792f, -0.03645240f, 
    0.11220189f, -0.24522631f, -0.37550297f, -0.38860577f, -0.16424496f, 0.01394190f, -0.20688571f, 0.04869884f, 
    0.12518518f, -0.02326977f, 0.00298256f, -0.04333914f, 0.13655762f, 0.05109378f, 0.07999939f, -0.03195834f, 
    -0.12100123f, 0.02281944f, -0.12698627f, -0.03309273f, 0.12402087f, 0.17842348f, 0.05040222f, 0.10018098f, 
    0.04740219f, 0.06776202f, -0.04941313f, -0.37987611f, -0.06753533f, -0.01148221f, 0.24574168f, 0.08999677f, 
    0.15002485f, 0.02882964f, 0.16689204f, 0.01546374f, 0.25337490f, -0.07232004f, 0.03826398f, 0.43025562f, 
    0.20376599f, 0.16089551f, 0.04984232f, 0.07240915f, -0.00063703f, -0.05311605f, -0.06938666f, 0.02439435f, 
    -0.02696564f, 0.04630469f, -0.04041449f, -0.03734008f, 0.03159521f, 0.02902222f, -0.01077317f, -0.10389379f, 
    -0.15774699f, -0.08592407f, -0.14807571f, -0.09983152f, -0.55319262f, 0.09300932f, -0.45942917f, -0.23327090f, 
    0.01028346f, -0.05897197f, -0.09878293f, 0.05183048f, 0.07242489f, -0.08674417f, -0.00016805f, 0.08023261f, 
    0.46165034f, 0.02128101f, 0.13716760f, 0.19002198f, 0.08851797f, -0.01803832f, -0.17776026f, 0.16521990f, 
    -0.08645512f, -0.16775583f, -0.02147061f, -0.09104666f, -0.00341806f, 0.03833728f, -0.02969208f, 0.17500564f, 
    0.05550427f, 0.06602856f, -0.00942963f, -0.06218919f, 0.07832587f, -0.01184159f, 0.06781768f, 0.09524512f, 
    -0.30458599f, -0.24677694f, -0.32289460f, -0.26218739f, 0.06742685f, 0.08897173f, 0.17849462f, 0.15502316f, 
    -0.13300833f, -0.01816670f, -0.09246454f, 0.08865985f, 0.40878874f, -0.11906794f, -0.08807657f, -0.15325528f, 
    0.17365487f, 0.16116312f, 0.02200034f, -0.02518200f, 0.07248893f, -0.02451286f, -0.00574612f, -0.02429668f, 
    -0.01500722f, -0.01388901f, -0.26200438f, 0.02473241f, 0.17326276f, -0.01762653f, 0.16015230f, 0.20585036f, 
    -0.10262299f, -0.00013919f, 0.07415015f, 0.22903368f, 0.13271430f, 0.05485614f, 0.02529461f, 0.11799660f, 
    -0.08349165f, -0.03936670f, -0.03316895f, -0.06290809f, 0.10628737f, 0.10570142f, -0.02706973f, 0.01000789f, 
    -0.03846248f, -0.10649653f, 0.04332944f, -0.39045572f, 0.04268312f, -0.12365796f, 0.00167084f, -0.04188478f, 
    0.12888774f, 0.11692663f, -0.09406730f, 0.14019752f, -0.15096152f, 0.11414956f, 0.52904344f, 0.00555572f, 
    -0.37486291f, 0.03327806f, 0.02848492f, -0.18733002f, 0.04271625f, -0.06967650f, -0.00343729f, -0.02276213f, 
    -0.10717287f, 0.16038999f, 0.12277363f, 0.11431904f, -0.07198057f, -0.07472055f, -0.06507652f, -0.19303721f, 
    -0.07610131f, -0.06733812f, -0.00328322f, -0.03880043f, 0.15533639f, -0.18792516f, -0.10497028f, -0.12681696f, 
    -0.04150145f, 0.04690947f, 0.05368451f, 0.01155336f, 0.20203988f, 0.11835800f, -0.01017307f, 0.05013163f, 
    0.23795770f, -0.20684651f, 0.15459122f, -0.09054963f, 0.06461547f, -0.12010242f, -0.15201212f, 0.10855990f, 
    0.18451108f, 0.00697756f, 0.05468264f, 0.00002117f, 0.22342435f, -0.07564371f, 0.06337873f, -0.03486377f, 
    0.07646758f, 0.00130358f, -0.09360180f, 0.05313206f, -0.01929841f, -0.08018657f, -0.03636160f, 0.06196695f, 
    -0.04299798f, 0.06831544f, 0.02178838f, 0.03424026f, 0.16661315f, 0.09766781f, 0.10129301f, -0.13079137f, 
    -0.03385325f, -0.06394825f, -0.06824828f, -0.17288862f, -0.16615929f, -0.04586148f, 0.02499896f, 0.05622236f, 
    -0.02488847f, -0.12666135f, -0.20068251f, 0.01146417f, -0.04673732f, -0.21631707f, -0.04399585f, -0.12072991f, 
    -0.14276291f, -0.05614085f, 0.06042666f, -0.07058989f, -0.16172692f, -0.00293143f, -0.11408702f, 0.02477057f, 
    0.25782830f, 0.32230866f, 0.18441096f, 0.14213386f, 0.00225500f, 0.39048246f, 0.00369063f, 0.01020168f, 
    -0.15961783f, 0.13487239f, -0.10051925f, 0.18252553f, 0.12874462f, 0.06132426f, -0.16211602f, 0.06159784f, 
    0.27424902f, -0.00450050f, 0.09547383f, -0.15539360f, -0.03931221f, -0.12207270f, -0.25127384f, 0.06530408f, 
    -0.09266828f, 0.03121164f, 0.04984503f, -0.04404638f, -0.36731228f, -0.02072985f, 0.19387852f, 0.14484614f, 
    -0.23875600f, -0.22498141f, -0.20542629f, -0.17475016f, -0.03664967f, -0.14607888f, -0.06569491f, -0.01751344f, 
    -0.01683686f, 0.08977291f, 0.06676834f, 0.08457529f, 0.28255284f, 0.29953435f, 0.23783301f, 0.28230140f, 
    0.05546349f, 0.11131500f, 0.13422160f, 0.10123181f, 0.05232101f, 0.23142809f, -0.11806056f, -0.34144664f, 
    0.04357075f, 0.02770468f, 0.05234990f, 0.31283790f, 0.03066041f, -0.05293805f, -0.05278307f, 0.01524192f, 
    -0.07975591f, 0.01385150f, -0.00140731f, -0.13464098f, 0.13492255f, 0.20068365f, 0.10021410f, 0.16373190f, 
    0.06323580f, -0.01065264f, -0.10180096f, 0.02118143f, 0.05916915f, 0.06092869f, -0.11832507f, -0.13176560f, 
    -0.18018474f, 0.24252649f, -0.20730837f, -0.13149945f, 0.19387640f, -0.18629506f, 0.14209244f, 0.24783646f, 
    0.20017721f, -0.09392096f, 0.34331819f, -0.02176649f, 0.09277941f, -0.13336843f, 0.03868018f, 0.13447243f, 
    0.20570132f, 0.08571941f, -0.01064021f, 0.21474810f, -0.36188921f, 0.11198552f, 0.31522289f, 0.18690385f, 
    -0.13660210f, -0.03711304f, -0.11670420f, 0.12361894f, -0.11573412f, 0.02251627f, -0.01909510f, -0.08134934f, 
    0.05831339f, 0.16891702f, 0.01289761f, -0.17643376f, -0.05805066f, 0.00136747f, 0.05854397f, -0.02158226f, 
    -0.07885068f, -0.00759089f, 0.04816891f, -0.11407626f, -0.31914455f, -0.07946558f, -0.17513748f, -0.11502131f, 
    -0.09754627f, -0.08998486f, 0.00591407f, -0.03870117f, 0.11608814f, 0.02761419f, 0.24573216f, 0.14865731f, 
    -0.02904841f, -0.28916141f, -0.11436818f, -0.02638937f, 0.06837546f, 0.15893792f, -0.04109827f, 0.05307846f, 
    0.14776164f, -0.07638035f, 0.00056050f, -0.15099917f, -0.00519549f, 0.14684527f, -0.01774216f, -0.06767626f, 
    0.00264142f, -0.00843310f, 0.03336714f, -0.01145527f, -0.02319778f, -0.07922743f, -0.06783778f, -0.07957314f, 
    0.13222682f, 0.00613391f, -0.13465002f, -0.07191146f, 0.13106608f, 0.15185420f, -0.07128863f, -0.00068378f, 
    -0.12655424f, -0.14372413f, -0.17595790f, -0.23176612f, -0.18640846f, -0.13860193f, -0.14465711f, 0.02893391f, 
    -0.01289202f, 0.06682090f, -0.16186936f, -0.03704026f, -0.03463288f, -0.01925403f, 0.01057017f, -0.07986581f, 
    -0.08798304f, -0.00903058f, -0.12989990f, -0.18533736f, -0.02940211f, -0.01129967f, -0.09261633f, -0.07440852f, 
    0.07420810f, 0.06477130f, 0.15642323f, 0.18180858f, -0.03173041f, 0.00402503f, 0.18001866f, -0.01391263f, 
    -0.04958932f, 0.16252151f, -0.11980749f, 0.03946750f, 0.02155325f, 0.11592316f, -0.03027769f, -0.00549547f, 
    0.03723302f, -0.19539070f, 0.26291782f, -0.11977104f, -0.16337496f, 0.07570284f, -0.07401957f, 0.05020582f, 
    -0.06216194f, 0.03225528f, -0.05465046f, 0.00156689f, -0.15739198f, -0.02808958f, 0.07954134f, -0.07579941f, 
    0.04045927f, 0.01862212f, -0.09355263f, -0.08651558f, -0.11428589f, -0.12742785f, -0.04056166f, -0.10861401f, 
    0.01823532f, 0.01955515f, -0.11853643f, 0.00833796f, 0.22023021f, 0.08584991f, 0.09187801f, 0.13613476f, 
    -0.02231387f, 0.15487280f, 0.02787419f, 0.08113877f, 0.08589636f, 0.16863497f, -0.14099960f, -0.17022526f, 
    0.05363408f, 0.07666505f, 0.20989014f, 0.02299098f, 0.14889665f, -0.03017239f, -0.03710034f, 0.03789262f, 
    0.04893689f, -0.05606449f, -0.00295396f, -0.16097559f, 0.06348154f, 0.08983444f, 0.03690977f, -0.00658310f, 
    0.03483635f, 0.03479355f, -0.01084954f, -0.04415580f, 0.08423306f, 0.01519959f, 0.01768106f, -0.00682068f, 
    -0.02381104f, -0.03748654f, -0.09943812f, -0.12370379f, 0.20366795f, 0.03920183f, 0.14877902f, 0.22126938f, 
    0.02925102f, 0.21147680f, 0.16755918f, 0.09915786f, 0.19005062f, 0.05599933f, 0.06450906f, -0.07946170f, 
    0.08467141f, 0.08632161f, -0.02392719f, 0.27266714f, 0.19030449f, 0.13935089f, 0.26475668f, -0.08818410f, 
    -0.01315174f, -0.03908806f, 0.05212153f, -0.03188605f, 0.10499143f, 0.02510613f, 0.12794200f, -0.02042268f, 
    -0.06170947f, 0.01546925f, -0.02855016f, -0.12240907f, 0.05567703f, 0.00605974f, -0.23708959f, -0.11611012f, 
    -0.05275774f, -0.08640688f, -0.21526460f, -0.09786126f, -0.04203050f, -0.05661290f, -0.16481632f, 0.07931534f, 
    -0.01046258f, 0.10862977f, 0.17836650f, 0.00154950f, 0.19008611f, 0.08524895f, 0.02352387f, 0.10211441f, 
    0.07424399f, -0.13833307f, 0.10178263f, 0.10037791f, 0.15760793f, 0.08413560f, -0.08344392f, -0.00564736f, 
    -0.04715347f, -0.05584766f, 0.07874572f, -0.11470222f, -0.12269980f, 0.01359499f, -0.14662492f, 0.01801230f, 
    -0.07032127f, 0.01066002f, 0.00093782f, -0.00556186f, 0.02406285f, -0.05745109f, -0.03721598f, -0.07457879f, 
    -0.17144573f, 0.01817178f, -0.00996464f, 0.16673160f, -0.07020900f, 0.13646427f, 0.03664297f, -0.01124451f, 
    0.01107106f, 0.01588657f, 0.00324441f, 0.04818003f, -0.00110235f, 0.22746994f, 0.08818518f, 0.11007848f, 
    -0.05690170f, -0.15031597f, 0.11958517f, -0.09116854f, -0.06636047f, 0.02102516f, -0.04550733f, 0.09231529f, 
    0.06203498f, -0.04390715f, -0.04982329f, 0.03744771f, -0.16797639f, -0.02283616f, -0.01038255f, 0.04027544f, 
    -0.09116162f, -0.01163313f, 0.14204013f, -0.09558619f, 0.56851399f, 0.11755972f, -0.03132428f, 0.24410401f, 
    0.19752009f, -0.02132955f, -0.13135296f, -0.02568171f, -0.05434579f, 0.07781692f, 0.05512499f, -0.11874395f, 
    0.09527496f, 0.03334082f, 0.02377729f, 0.25026521f, 0.07203629f, -0.07679521f, -0.13612625f, -0.01674969f, 
    -0.06183354f, -0.07706055f, 0.05098128f, -0.13745083f, -0.10125354f, 0.05433596f, 0.28514570f, -0.04167205f, 
    -0.02939321f, -0.03917671f, -0.14037946f, 0.03325194f, -0.04729633f, 0.08324810f, -0.02836440f, 0.06066785f, 
    0.03875036f, -0.02203915f, 0.04604559f, 0.09991230f, 0.06525557f, 0.09148911f, -0.00070630f, 0.12857491f, 
    -0.01633782f, 0.00016807f, -0.03603204f, 0.05071390f, -0.24904649f, 0.30740908f, -0.02325739f, 0.19326168f, 
    0.01693970f, -0.00432303f, 0.07023207f, -0.03488429f, 0.06933784f, -0.02240675f, -0.08352311f, 0.06122656f, 
    0.02315729f, -0.08841560f, 0.11117803f, 0.13414027f, 0.24168439f, 0.02021249f, -0.04587502f, 0.17574801f, 
    -0.09712190f, -0.01690012f, 0.07280765f, 0.11994346f, -0.01000613f, 0.25335735f, -0.02151723f, -0.01361087f, 
    0.02418168f, -0.02094365f, -0.01988974f, -0.01857012f, 0.03582380f, -0.12939259f, -0.07931159f, -0.01830307f, 
    0.06178409f, -0.11264322f, -0.17055774f, -0.10290172f, 0.07537446f, 0.07742190f, 0.08348405f, 0.03036683f, 
    0.01173846f, 0.11753201f, -0.16446276f, 0.15084164f, 0.04618909f, -0.11820745f, -0.39833680f, -0.49024945f, 
    -0.09987858f, -0.11821849f, 0.03731635f, 0.02151105f, -0.10599048f, 0.06473028f, -0.03198673f, 0.15349734f, 
    -0.07008613f, -0.02959472f, -0.02528720f, -0.02381571f, 0.03522190f, 0.02258663f, 0.01079923f, 0.01381965f, 
    -0.02881752f, 0.04229873f, -0.02512385f, -0.07448655f, -0.05739778f, -0.01531608f, -0.06141637f, 0.01952307f, 
    0.00600655f, -0.00731871f, -0.06969422f, 0.00523931f, -0.04368181f, -0.04662570f, 0.01649230f, 0.04629798f, 
    0.04496821f, 0.00995711f, 0.04280169f, 0.00330161f, 0.04087366f, -0.00377261f, -0.02268004f, -0.05252855f, 
    0.05345928f, -0.06826697f, -0.05329447f, 0.00110439f, -0.01581774f, -0.04496734f, -0.07123856f, -0.03069189f, 
    0.05392531f, -0.02631033f, 0.04748009f, -0.05512139f, 0.04804483f, -0.05985273f, -0.01797337f, -0.04379021f, 
    0.01880351f, -0.05624496f, -0.06144982f, 0.05187882f, 0.00850014f, -0.06719413f, 0.00641518f, 0.01687582f, 
    0.05344287f, 0.02270972f, 0.06579693f, -0.01893284f, 0.06480474f, -0.04510856f, 0.05542586f, 0.04292314f, 
    0.06500550f, -0.04995036f, -0.03710403f, -0.00503110f, -0.04567775f, 0.05150383f, -0.04617192f, -0.04607390f, 
    -0.02457401f, -0.07792301f, -0.04987718f, 0.03489438f, -0.05375994f, -0.02452588f, -0.06442064f, -0.03197211f, 
    -0.04579081f, 0.03084167f, -0.00513128f, -0.06605060f, 0.04668078f, 0.04761949f, -0.02543992f, -0.05497369f, 
    -0.04398993f, 0.01727407f, -0.02687143f, 0.04487943f, -0.03261986f, 0.02549169f, 0.02012724f, -0.04649692f, 
    -0.02859048f, 0.02098042f, -0.00717395f, 0.03694263f, 0.06037558f, -0.07496668f, 0.02671827f, -0.02628763f, 
    -0.00831901f, 0.01571513f, 0.01795048f, -0.02671469f, -0.04779536f, 0.05643095f, 0.04957058f, -0.04971257f, 
    0.02613146f, -0.05840929f, -0.06255505f, -0.01539681f, 0.02678523f, -0.06273732f, -0.02922529f, -0.02128531f, 
    0.05530527f, -0.02314525f, 0.05365747f, 0.00350514f, 0.05304093f, -0.01043304f, 0.06507335f, -0.05064521f, 
    0.06423435f, 0.05504207f, -0.02265359f, 0.02920307f, -0.05235665f, -0.02736232f, 0.02826861f, 0.04259714f, 
    0.02701282f, 0.03439852f, -0.02483232f, 0.02355417f, 0.04120786f, -0.00601860f, -0.02456071f, 0.04430475f, 
    0.02034354f, -0.01079396f, -0.04279930f, -0.02970013f, -0.02733313f, 0.00930096f, 0.00891412f, 0.04344703f, 
    -0.03824133f, -0.06543954f, -0.06879325f, 0.00957105f, 0.02421405f, -0.06029639f, -0.05979140f, 0.03291634f, 
    -0.04021983f, -0.05605591f, -0.01683124f, 0.00322225f, -0.07347801f, -0.04913989f, 0.07205395f, 0.04586833f, 
    -0.01964939f, 0.00884707f, -0.03914905f, -0.02634220f, -0.07050638f, 0.03692743f, 0.00000771f, -0.04829634f, 
    -0.02511331f, -0.07713525f, 0.03415102f, -0.07413590f, 0.04489432f, -0.03451148f, -0.01413523f, -0.06671724f, 
    -0.01164822f, -0.07139909f, -0.04270061f, 0.02950963f, -0.04233197f, -0.06538054f, 0.00510747f, 0.00995688f, 
    -0.00400604f, -0.12865607f, -0.10298066f, 0.19788729f, 0.06954087f, 0.08254609f, 0.07040657f, -0.10026376f, 
    0.03868227f, 0.00247776f, 0.06968851f, 0.09597424f, 0.03432286f, -0.26121470f, -0.10038394f, 0.07060941f, 
    -0.08627800f, 0.18705483f, 0.03457842f, 0.07404027f, 0.21962164f, -0.00638285f, -0.06298488f, -0.14477660f, 
    -0.01691885f, 0.19592512f, -0.10224742f, -0.05105553f, -0.06268115f, 0.07918501f, 0.13561873f, 0.15532900f, 
    0.10484730f, -0.20589814f, -0.06611824f, -0.04932038f, 0.19718128f, -0.16389230f, -0.05760046f, 0.09263164f, 
    -0.03311381f, -0.07493177f, 0.04790796f, 0.01427686f, 0.05044387f, -0.10263135f, -0.00210786f, 0.00529817f, 
    0.17207964f, 0.08240326f, 0.15344597f, -0.18911605f, 0.05709551f, -0.01669564f, -0.08662399f, 0.06319302f, 
    0.09927049f, -0.04028714f, -0.03808624f, -0.02927281f, 0.15836073f, 0.19003791f, 0.04934804f, -0.20308399f, 
    -0.01691648f, -0.12943801f, -0.06304456f, -0.00155829f, -0.07134791f, -0.03347447f, 0.04380726f, 0.04850591f, 
    -0.03659067f, 0.00815165f, -0.00241393f, 0.15919711f, 0.01301340f, 0.11379527f, 0.00063794f, 0.10569268f, 
    -0.01264355f, 0.10787252f, 0.03753404f, -0.01391719f, -0.57512051f, 0.14442544f, 0.10478561f, -0.14516810f, 
    0.07571270f, -0.13140000f, 0.07472877f, -0.03345007f, -0.04954438f, 0.02817997f, 0.01229125f, -0.01996795f, 
    0.05929006f, 0.21864091f, -0.38033256f, -0.13641317f, -0.00522231f, -0.25553232f, 0.02990592f, -0.09499606f, 
    -0.20340921f, -0.04007621f, 0.18034185f, 0.07833931f, 0.00816643f, -0.00635980f, 0.09888591f, 0.04552059f, 
    0.06617387f, -0.03878513f, -0.03041442f, 0.08446348f, 0.02621800f, -0.00712069f, -0.01310502f, 0.15111840f, 
    -0.03105109f, 0.12195556f, 0.05995536f, -0.07402204f, 0.13853009f, 0.00000903f, 0.15762849f, -0.05133541f, 
    -0.13616197f, -0.08421335f, -0.11453548f, -0.08005970f, 0.30249628f, -0.00509276f, 0.23130284f, -0.27053681f, 
    0.09839381f, -0.08121673f, 0.06927298f, -0.06012996f, 0.06026724f, 0.01148078f, -0.02318311f, -0.11344352f, 
    -0.07360750f, 0.17215657f, -0.06559191f, -0.17137071f, -0.00649135f, 0.07286063f, -0.07633255f, 0.09923756f, 
    0.04230377f, -0.03405249f, 0.02800924f, 0.03352931f, 0.01579927f, 0.01696329f, 0.01495806f, -0.00779135f, 
    -0.00792039f, -0.06401327f, -0.06267063f, 0.04230664f, 0.07647063f, -0.04988985f, 0.09044927f, 0.12200505f, 
    0.22060160f, -0.06896811f, -0.03719582f, 0.16089734f, 0.08591573f, 0.16820978f, 0.02098361f, 0.14288849f, 
    0.24503966f, 0.04205861f, 0.12617214f, 0.09830430f, -0.36594751f, -0.11657120f, -0.02173433f, 0.32571444f, 
    -0.00135822f, 0.05682918f, 0.10261097f, 0.15245371f, 0.10306288f, 0.18275344f, 0.07253797f, -0.02781636f, 
    0.03034021f, 0.15301920f, -0.18892057f, 0.12549752f, 0.02463411f, -0.04521037f, -0.03268676f, 0.04561554f, 
    0.03236593f, 0.08067549f, -0.19238077f, 0.12943421f, -0.13393188f, 0.05449964f, -0.06900208f, 0.12009566f, 
    0.07080966f, 0.00813650f, 0.20754623f, 0.10870101f, -0.01560011f, 0.08493108f, -0.09779615f, -0.01065912f, 
    0.52522868f, 0.11949348f, 0.29298124f, 0.18432951f, 0.03084330f, 0.07806750f, 0.02278337f, -0.10093293f, 
    -0.10634278f, -0.06716196f, 0.15419924f, 0.08987607f, 0.04425097f, -0.01932663f, -0.17220204f, 0.14572823f, 
    -0.10759966f, -0.02616356f, 0.09052677f, -0.20798796f, -0.00161008f, -0.07737627f, 0.11843298f, 0.08549956f, 
    -0.11196967f, 0.10196516f, -0.03757812f, -0.02325069f, -0.00727016f, -0.00684474f, -0.07621306f, -0.01300651f, 
    0.04280395f, 0.02270964f, 0.08380532f, 0.01694626f, 0.05877172f, 0.49530739f, 0.17429933f, -0.00989364f, 
    -0.10949003f, -0.17382415f, 0.05701339f, -0.14207774f, -0.10901099f, -0.06148689f, 0.00131643f, 0.02586753f, 
    0.08303980f, 0.02099716f, 0.04927698f, -0.02795239f, 0.00075169f, 0.02460559f, -0.05144501f, -0.05530612f, 
    -0.04214210f, -0.04508015f, 0.08903867f, -0.09087395f, 0.18478069f, 0.22754098f, 0.31738639f, -0.08687982f, 
    0.07833914f, -0.06275252f, -0.02615624f, -0.08249938f, 0.00971784f, 0.01365498f, 0.15250491f, 0.02207816f, 
    -0.12444127f, -0.19102649f, 0.12952049f, 0.19257897f, 0.07030562f, -0.30229712f, -0.12814409f, 0.04790994f, 
    -0.21152540f, -0.07666291f, 0.20246670f, 0.18549600f, 0.03490100f, 0.22677182f, 0.27894202f, 0.03669828f, 
    -0.10124039f, -0.21822143f, -0.15572795f, 0.04228785f, -0.17750160f, -0.04105172f, -0.10976782f, -0.00170335f, 
    0.14018705f, 0.14794582f, -0.05451947f, 0.01646433f, -0.04493866f, 0.07513732f, 0.05115620f, -0.06734245f, 
    0.00496068f, 0.01030432f, -0.08389810f, -0.20272072f, -0.11375020f, 0.24186371f, -0.30870342f, -0.07959916f, 
    0.06533848f, -0.03945271f, 0.02008111f, 0.02789026f, 0.02729688f, 0.10733787f, 0.12089407f, -0.14404856f, 
    -0.07015125f, -0.14463432f, 0.05227615f, -0.26253176f, 0.07001610f, 0.05700565f, -0.01548327f, 0.04197545f, 
    -0.07692857f, 0.00002194f, -0.06584433f, 0.06432375f, -0.09163726f, 0.24146877f, -0.01082213f, -0.15314236f, 
    -0.02869218f, -0.08359110f, -0.00671483f, -0.11552194f, 0.09609069f, -0.03482388f, -0.04390986f, -0.00125813f, 
    0.14751783f, 0.02650583f, -0.09117231f, 0.16532505f, -0.01779504f, 0.29671964f, 0.05086193f, -0.08231168f, 
    0.23475175f, 0.27770525f, -0.17198250f, 0.16446239f, -0.28527394f, 0.28138742f, -0.29808423f, -0.20112602f, 
    0.11722588f, 0.04775213f, 0.09903999f, -0.09696235f, -0.03497716f, 0.08380852f, 0.01222490f, 0.17664318f, 
    -0.03364400f, -0.00993814f, 0.00869476f, -0.07050293f, 0.02093028f, -0.00443156f, -0.07788537f, 0.06292471f, 
    0.05353521f, -0.05022817f, 0.02066495f, -0.02717425f, 0.06058222f, 0.03594034f, -0.07570224f, 0.01767565f, 
    -0.07864273f, 0.04317986f, 0.01454938f, 0.06203112f, 0.05526736f, 0.02090237f, -0.02730376f, 0.04540512f, 
    0.04480491f, 0.01338773f, -0.05369384f, 0.01434994f, -0.01524933f, -0.07175947f, 0.03295399f, 0.01019021f, 
    0.01399740f, 0.03483374f, -0.03857115f, -0.08111657f, -0.01611800f, -0.07875399f, 0.05600085f, 0.04636163f, 
    -0.01053809f, -0.03712172f, -0.01063248f, 0.01440458f, 0.04114912f, 0.00227612f, 0.03500754f, 0.01036043f, 
    -0.01032173f, 0.04185769f, 0.03967109f, -0.07037600f, -0.01459582f, -0.01026142f, 0.00304036f, 0.04609872f, 
    0.04065172f, 0.05463274f, -0.00195582f, 0.00049244f, -0.06134525f, -0.01356856f, -0.01608006f, -0.01290643f, 
    0.00377798f, -0.07987524f, -0.06285348f, -0.03103342f, -0.03610986f, -0.00336827f, 0.05605281f, -0.07089297f, 
    0.06192831f, 0.00899450f, -0.01287576f, 0.01078033f, -0.02313190f, -0.07427297f, 0.00494490f, -0.00725808f, 
    0.01344245f, -0.03820729f, 0.03620313f, -0.01691699f, -0.05813903f, -0.03352757f, -0.02576790f, -0.04728894f, 
    0.05802926f, -0.06070670f, 0.02159012f, -0.00125637f, -0.00675450f, -0.00340988f, 0.05344624f, -0.06152161f, 
    -0.05835961f, -0.05216306f, -0.02136062f, 0.06282708f, 0.03221198f, -0.02075856f, -0.05086331f, -0.00965457f, 
    -0.06020354f, 0.02919214f, -0.05018667f, 0.01192483f, 0.03533592f, 0.03529248f, 0.02744844f, -0.06296942f, 
    -0.02720211f, -0.04355805f, 0.01302324f, -0.03878191f, -0.05918497f, -0.05853266f, 0.06587147f, 0.00689521f, 
    0.01613267f, -0.01525345f, -0.00645090f, 0.04559799f, -0.05055439f, -0.03000237f, -0.06011244f, 0.03805442f, 
    -0.05175372f, -0.06514937f, 0.02192876f, 0.02757833f, 0.05831112f, 0.05438460f, -0.01099612f, -0.03287438f, 
    0.06064501f, -0.02952094f, 0.02609454f, -0.04563491f, 0.05392023f, -0.07923289f, -0.04962565f, -0.04710798f, 
    -0.00460307f, 0.02395045f, 0.00151224f, -0.01687931f, -0.03972464f, -0.02880304f, -0.00511075f, -0.05091638f, 
    0.05161799f, -0.07348622f, -0.04872109f, -0.00777142f, 0.03724191f, -0.04581506f, 0.01786175f, 0.06075533f, 
    -0.01183239f, -0.05158264f, 0.04141441f, 0.01736341f, -0.02790788f, 0.00744803f, -0.06688925f, -0.04983792f, 
    -0.02874888f, -0.07370485f, -0.02365105f, -0.07936273f, 0.00320903f, -0.06436182f, 0.01062139f, -0.02181854f, 
    -0.03902218f, 0.01813389f, -0.07924777f, -0.06793492f, -0.02425946f, -0.02550508f, 0.02915969f, -0.05792053f, 
    0.03155702f, 0.04457854f, 0.00977299f, 0.02001013f, -0.02505609f, 0.06594072f, -0.07557140f, -0.00833937f, 
    -0.02395152f, -0.08206201f, -0.22102444f, 0.13960044f, -0.05447811f, -0.03532439f, -0.02901222f, 0.07077327f, 
    0.07896542f, 0.06618536f, 0.12680528f, 0.09832566f, -0.08021235f, 0.27467388f, 0.30024004f, 0.21611103f, 
    0.10032476f, -0.01402508f, 0.00182689f, -0.06595510f, 0.05968819f, 0.05149197f, 0.03198478f, 0.13416801f, 
    -0.18634573f, 0.25833958f, 0.48578218f, 0.31977344f, -0.00652664f, -0.13517378f, 0.03100180f, -0.22303024f, 
    -0.08519862f, 0.02611810f, 0.00888076f, 0.09762727f, -0.28954017f, 0.04020269f, 0.20087950f, 0.07539990f, 
    -0.06001150f, -0.05696926f, -0.10519713f, -0.03841692f, 0.04123249f, 0.20500082f, 0.06506109f, 0.03122215f, 
    -0.20152307f, -0.10737829f, -0.08720953f, 0.05829818f, -0.06850825f, -0.01915737f, 0.02567003f, 0.01276040f, 
    0.00001375f, 0.12639043f, 0.04570738f, 0.14235905f, 0.20226705f, 0.04709121f, 0.21862175f, -0.01418013f, 
    -0.03963325f, 0.20345296f, 0.21024378f, -0.02046762f, -0.03915324f, -0.03121496f, -0.06628422f, 0.09538873f, 
    0.07982698f, 0.05973183f, -0.00738182f, 0.01883622f, 0.07811762f, 0.00110331f, 0.03290870f, -0.02018503f, 
    -0.06054728f, 0.07749145f, 0.03358709f, 0.11638321f, 0.64249104f, 0.00046710f, 0.20503019f, 0.22823781f, 
    -0.03772004f, -0.35263422f, 0.19244394f, 0.03260778f, 0.10388440f, -0.09624097f, 0.05508465f, 0.10973841f, 
    -0.10201491f, -0.15167965f, 0.07069205f, 0.17469174f, 0.18197921f, 0.11409342f, 0.25598055f, -0.04326986f, 
    0.05520876f, -0.02499083f, -0.13041037f, 0.20136391f, 0.14682417f, 0.03310160f, -0.32816327f, -0.08487313f, 
    -0.13363928f, 0.06006749f, 0.14794767f, -0.02775780f, 0.02748320f, 0.00019926f, 0.01780042f, 0.02761059f, 
    -0.16914837f, -0.29991803f, 0.03027047f, 0.05634448f, -0.23181938f, -0.11882085f, -0.03703497f, -0.04558644f, 
    -0.08834984f, -0.13266829f, -0.05760602f, -0.09295016f, -0.56405646f, -0.21696663f, -0.26785707f, 0.38236564f, 
    -0.01683195f, 0.10287160f, -0.04316277f, -0.04312592f, -0.13753513f, -0.05794704f, -0.08219749f, -0.00926490f, 
    0.00056775f, -0.24792679f, 0.02245271f, -0.05650092f, -0.00208427f, -0.12582500f, 0.03189739f, -0.04074610f, 
    0.04781533f, 0.02818470f, 0.12240080f, -0.06106031f, -0.13757971f, 0.01712710f, -0.07435047f, 0.08709651f, 
    -0.04003438f, -0.12766601f, 0.07263131f, 0.02652790f, 0.00415682f, 0.10962692f, 0.05305988f, -0.09751394f, 
    0.14460078f, 0.28401199f, 0.23013836f, 0.20615721f, 0.14092460f, 0.09185535f, 0.05644811f, 0.01842756f, 
    0.06584400f, 0.07785784f, 0.11662330f, 0.02379992f, -0.37386346f, 0.15691385f, -0.18076056f, 0.48506352f, 
    0.04199754f, 0.14135808f, -0.02084239f, 0.00421797f, 0.18489318f, 0.12334653f, 0.14916395f, 0.36718404f, 
    -0.05479209f, -0.02541829f, 0.02129561f, -0.04740538f, 0.01796757f, -0.07174401f, -0.01067191f, -0.01611612f, 
    0.01448779f, -0.04693344f, -0.00644403f, 0.03036934f, -0.07413874f, 0.04079645f, 0.01288234f, -0.01750351f, 
    -0.05226819f, -0.06202683f, 0.04535015f, -0.01976282f, -0.06166128f, -0.02857016f, -0.06788227f, 0.03610415f, 
    -0.06606521f, -0.05574928f, 0.05303447f, -0.05115258f, -0.00817247f, 0.01793437f, -0.00455595f, 0.02833409f, 
    0.05177872f, -0.05534707f, -0.05507987f, -0.05242149f, 0.05210727f, -0.02199861f, 0.05040254f, -0.00770955f, 
    0.03521733f, 0.00543357f, -0.01128346f, -0.07289577f, 0.05067288f, 0.01020704f, -0.00244207f, 0.03339423f, 
    -0.04590981f, 0.00713410f, 0.05392570f, -0.04954137f, -0.02547816f, -0.04833117f, 0.04152380f, -0.05538160f, 
    -0.06590566f, -0.01042006f, 0.00054680f, -0.03367189f, 0.00057968f, 0.01645430f, -0.03568075f, -0.04657175f, 
    -0.05454214f, 0.04387140f, -0.02416466f, 0.03243788f, -0.05452656f, -0.04237758f, 0.04374481f, 0.01184379f, 
    -0.05473536f, 0.01763842f, 0.03837888f, -0.00012954f, -0.04351445f, -0.03611638f, -0.06885732f, 0.00868348f, 
    -0.05592707f, 0.04580764f, -0.04450867f, 0.03384158f, 0.03229075f, 0.03893787f, -0.01729609f, 0.05881007f, 
    -0.01794691f, 0.06317360f, 0.00097977f, -0.01831428f, 0.06571021f, -0.04035141f, 0.01771833f, -0.00765294f, 
    0.05877376f, 0.01655308f, -0.07200477f, 0.04379445f, -0.01084983f, -0.05366852f, 0.05013081f, -0.06859706f, 
    -0.05384789f, -0.03018577f, 0.00602724f, -0.04088759f, 0.03000310f, -0.06335294f, -0.01904424f, 0.02102107f, 
    -0.07102628f, -0.01329473f, -0.01173373f, -0.01572488f, 0.05358518f, -0.07629278f, -0.07545574f, -0.05899433f, 
    0.01558756f, -0.01430026f, -0.00275004f, 0.01585919f, 0.05813579f, -0.05221004f, 0.04343633f, 0.00702080f, 
    -0.00960707f, -0.02133964f, -0.05699937f, 0.02672574f, -0.04007590f, 0.04022365f, -0.06537618f, 0.05644138f, 
    -0.06483728f, -0.03437198f, -0.04923168f, -0.07414245f, 0.05417343f, 0.03254069f, -0.01555121f, 0.00530896f, 
    0.01780329f, -0.04098374f, 0.01372302f, -0.02774325f, -0.00201152f, 0.04761010f, -0.05732666f, -0.04743843f, 
    -0.04353958f, -0.02275020f, 0.05773343f, -0.02147915f, -0.02281943f, -0.01277079f, 0.06314195f, -0.07324170f, 
    0.02493890f, -0.05045748f, -0.02693731f, -0.02155277f, 0.04505229f, 0.06341480f, -0.02364450f, 0.02727568f, 
    -0.06768068f, -0.03511186f, -0.03394409f, 0.01663814f, -0.03586227f, 0.04811915f, -0.05491561f, 0.00350769f, 
    0.02568102f, -0.02248576f, -0.04779892f, -0.00424956f, 0.06519486f, 0.02326618f, -0.05082999f, 0.00724632f, 
    0.04235498f, -0.04016075f, 0.05753654f, -0.03678182f, 0.01055724f, -0.06829568f, 0.01963834f, -0.02065117f, 
    -0.09096663f, -0.01529633f, 0.15295714f, -0.07005817f, 0.00095039f, 0.04353015f, 0.01520172f, -0.00537140f, 
    -0.15139391f, -0.10676897f, 0.12471759f, -0.08725892f, 0.23495512f, 0.15398172f, 0.09821220f, 0.03817030f, 
    -0.00371974f, -0.06723569f, -0.05286349f, -0.05772272f, 0.14729445f, 0.08338439f, 0.07305776f, 0.05066675f, 
    0.18374500f, 0.14810698f, -0.13409366f, -0.05705109f, -0.06662464f, 0.06654920f, 0.01186893f, 0.02085797f, 
    -0.21238464f, 0.01744070f, -0.17086931f, -0.11418144f, -0.03364748f, -0.02241237f, 0.00899243f, -0.12094175f, 
    0.04064830f, 0.08060021f, -0.02405244f, -0.01913864f, -0.28583074f, -0.08907681f, -0.26002499f, -0.17451152f, 
    0.28046396f, 0.14998896f, 0.16228777f, 0.17247935f, 0.04848844f, 0.02321189f, -0.02542960f, 0.01566272f, 
    0.05554762f, -0.05503211f, -0.10860393f, -0.17478214f, -0.13094783f, -0.24245934f, -0.39705911f, -0.00894606f, 
    0.08220886f, -0.10899824f, -0.23013024f, -0.11032766f, -0.01681418f, 0.04542384f, -0.02180931f, 0.05482630f, 
    -0.02088716f, -0.02952712f, -0.05254052f, -0.02716166f, 0.03459031f, 0.03340770f, 0.07878188f, 0.06622965f, 
    0.01717369f, 0.00683538f, 0.03294140f, 0.00644124f, -0.05577147f, 0.02209789f, -0.01909932f, -0.12316511f, 
    0.13262981f, 0.03788090f, 0.07192229f, 0.05900133f, -0.10126624f, -0.07810581f, 0.05412323f, 0.10340253f, 
    0.07636796f, -0.08949401f, 0.14625932f, 0.04177322f, -0.04201214f, 0.14425732f, -0.09437218f, 0.08466139f, 
    0.06835931f, 0.10453631f, 0.05317953f, -0.00478325f, -0.23878556f, -0.35760212f, -0.21619770f, -0.14670506f, 
    0.09917965f, 0.04235267f, 0.00307242f, -0.09471649f, 0.13977234f, 0.04305724f, 0.05142175f, 0.07956776f, 
    0.11878633f, 0.39724776f, 0.35511792f, 0.30797899f, 0.14263403f, 0.02863969f, -0.02217494f, 0.06264450f, 
    -0.00041350f, 0.08697317f, 0.02681868f, 0.01069277f, 0.31165725f, -0.00612734f, 0.45068872f, 0.21945672f, 
    -0.01637982f, 0.06035775f, -0.09594324f, 0.10448590f, -0.00914864f, -0.04868733f, -0.11961053f, -0.00830228f, 
    0.19393086f, 0.36846390f, 0.31407180f, 0.24306588f, 0.04088392f, 0.04010323f, 0.04930968f, -0.00016889f, 
    -0.05253875f, -0.03156316f, -0.03776472f, -0.14927587f, 0.07545240f, -0.19777289f, -0.00477239f, -0.07589007f, 
    0.00866814f, 0.02036164f, -0.00461452f, 0.06971180f, 0.02296687f, -0.09466480f, -0.01813517f, 0.10573144f, 
    -0.16822155f, -0.04154895f, 0.11858657f, -0.13985300f, -0.03220418f, -0.18977889f, -0.04607715f, -0.03691993f, 
    -0.06439109f, -0.11105382f, -0.03370477f, -0.23425220f, -0.37164605f, -0.12335742f, 0.25259858f, 0.02994598f, 
    0.00481757f, -0.03981084f, 0.04180409f, 0.17481542f, -0.05304316f, -0.00508200f, 0.15144739f, -0.05331856f, 
    -0.09007182f, -0.14442024f, 0.18819305f, 0.09909391f, 0.00472437f, -0.08815700f, 0.12580362f, 0.03285461f, 
    -0.05437779f, -0.08877251f, 0.13150865f, 0.11586354f, 0.05143690f, -0.09887525f, 0.32123557f, 0.03052619f, 
    -0.07441285f, -0.03826976f, -0.12753339f, -0.04392811f, 0.33562857f, 0.16367458f, 0.11499619f, 0.05003567f, 
    -0.31988072f, 0.04650698f, 0.23305276f, 0.04320305f, -0.10465854f, -0.04663780f, 0.03719087f, 0.11882906f, 
    0.21181607f, -0.03686371f, 0.08868542f, 0.01839632f, 0.03293486f, 0.00613749f, 0.36903372f, 0.10116345f, 
    -0.01078706f, -0.03608309f, -0.07638216f, 0.05794948f, -0.00154149f, 0.06625915f, -0.06187127f, 0.05582136f, 
    -0.10229688f, -0.01167757f, 0.07511622f, -0.03592908f, -0.00005794f, 0.12341220f, -0.01771303f, -0.06606405f, 
    0.04417496f, -0.03977898f, -0.03659999f, -0.05902184f, 0.11391331f, -0.27048302f, -0.04821863f, 0.09763821f, 
    0.15703706f, 0.11693971f, -0.10625374f, -0.04990003f, -0.09595758f, -0.09908260f, 0.00603096f, -0.07683782f, 
    -0.12742512f, -0.13752626f, -0.19506061f, -0.04950988f, -0.04990800f, -0.06530020f, -0.11035293f, 0.03073286f, 
    -0.04449196f, 0.09086606f, 0.01031385f, -0.00578048f, -0.04269157f, 0.12863314f, -0.25211480f, 0.32915601f, 
    -0.04722070f, -0.21712361f, -0.00709570f, 0.18185209f, 0.03925653f, 0.06455519f, -0.12367778f, -0.01319214f, 
    0.00908410f, -0.20669299f, 0.11164650f, -0.05260996f, 0.14447536f, 0.04902853f, -0.10841129f, -0.02115047f, 
    0.04453145f, 0.01826346f, -0.19272262f, -0.18553820f, -0.25245839f, -0.09485041f, -0.33657631f, -0.01949276f, 
    0.02623194f, -0.00923555f, -0.03654778f, -0.16846292f, 0.07101302f, -0.18019079f, -0.09936066f, -0.04498418f, 
    -0.14689007f, -0.13595378f, -0.01448823f, 0.05126033f, 0.08274981f, 0.12922947f, 0.14153489f, 0.21946682f, 
    0.04291718f, 0.06789758f, 0.10244937f, 0.14236060f, -0.03351861f, 0.02250918f, 0.02537484f, -0.02543673f, 
    0.10535236f, 0.07922099f, -0.02405374f, -0.04877468f, 0.07364690f, -0.00661010f, -0.08946578f, 0.14302923f, 
    -0.08881092f, -0.04390835f, 0.04078316f, -0.21192019f, 0.12573136f, 0.08904871f, 0.10054140f, 0.06142775f, 
    0.00182744f, 0.06032066f, 0.04145193f, 0.13073759f, -0.11196467f, -0.05936980f, -0.19074675f, 0.05766431f, 
    -0.05270790f, -0.05359562f, -0.14651006f, -0.10468556f, -0.05117359f, -0.03220442f, 0.05578572f, 0.22522345f, 
    0.19351780f, 0.03607683f, 0.23513871f, -0.06624947f, 0.22287342f, -0.01654258f, 0.20091198f, 0.15917419f, 
    0.09256280f, 0.00373136f, 0.08133940f, 0.20063266f, -0.25309855f, -0.33852801f, 0.08296985f, 0.44084045f, 
    -0.24116816f, -0.27731240f, -0.09723658f, 0.05529397f, -0.03109771f, 0.06736863f, 0.08496858f, 0.12564564f, 
    0.02060263f, -0.03922589f, 0.05106284f, 0.05223791f, 0.00061029f, -0.02027185f, 0.05189668f, -0.04582721f, 
    0.00803515f, -0.05621501f, -0.03476346f, -0.07014362f, -0.07744238f, 0.05480755f, 0.00499074f, 0.02157868f, 
    -0.03868703f, -0.07817797f, -0.07847489f, -0.06829073f, 0.05006058f, 0.04211662f, -0.07872696f, -0.02737246f, 
    -0.02631255f, -0.03491918f, 0.01447366f, 0.04249907f, -0.03272860f, -0.06989015f, -0.03338211f, -0.01609667f, 
    0.02971941f, -0.02735704f, -0.01901010f, -0.07750069f, 0.02104701f, 0.04050469f, 0.01735703f, -0.03381334f, 
    0.02202975f, -0.00358023f, 0.00793830f, -0.02667404f, -0.06813893f, -0.07765888f, 0.02985908f, -0.07064701f, 
    0.06414271f, 0.04135733f, -0.07371271f, -0.04091287f, -0.04830500f, 0.02155858f, -0.02975754f, -0.01126670f, 
    -0.04874415f, -0.04333995f, 0.03849433f, -0.03642996f, 0.04596824f, -0.07388997f, -0.02043677f, -0.01404236f, 
    0.02363229f, -0.00110707f, -0.02522464f, -0.00018191f, -0.02881897f, -0.04051086f, 0.01567444f, -0.02996603f, 
    -0.06836188f, -0.03393704f, -0.01398460f, -0.00129495f, 0.05350624f, 0.04671016f, -0.06816171f, -0.06065116f, 
    -0.03310659f, 0.05626960f, -0.06643691f, 0.03311241f, 0.04291003f, -0.02277809f, 0.00662788f, 0.04182017f, 
    -0.02662518f, -0.06295519f, 0.00909029f, 0.03988811f, -0.04821176f, -0.01310589f, -0.05580935f, -0.02867608f, 
    0.02904186f, -0.07135398f, -0.06621275f, 0.04483262f, 0.04213623f, -0.04470950f, -0.03801866f, -0.03135755f, 
    -0.00438685f, -0.05059445f, -0.07207289f, -0.01666480f, -0.06301683f, 0.05952566f, -0.01274879f, -0.01723462f, 
    -0.04572272f, 0.00656920f, 0.00325472f, -0.06251288f, 0.02997702f, -0.05368477f, 0.05319759f, 0.03844899f, 
    0.03106568f, 0.05117648f, 0.01247933f, 0.02071480f, -0.01148254f, 0.01714750f, 0.06309836f, -0.03807194f, 
    -0.05564857f, -0.05402343f, 0.06635241f, -0.01216607f, -0.05234851f, -0.04303313f, -0.04143872f, -0.00860268f, 
    -0.02620581f, 0.04947452f, -0.03702125f, -0.03934325f, -0.06378291f, 0.07078499f, -0.06970786f, 0.05351214f, 
    -0.00538071f, 0.03028512f, 0.01636897f, 0.05512005f, -0.01739809f, -0.07746143f, -0.04026017f, -0.04472857f, 
    -0.02902737f, -0.07092989f, 0.05159901f, -0.01410380f, 0.02746450f, 0.04531913f, 0.05628433f, -0.03159858f, 
    -0.02052543f, -0.02648437f, 0.04062988f, -0.03332961f, -0.01388712f, 0.00000707f, 0.05388325f, -0.00606177f, 
    0.00549498f, -0.05048379f, -0.06946211f, -0.00702074f, -0.03778535f, 0.02739717f, 0.00324501f, -0.02893570f, 
    -0.05472996f, -0.03649930f, 0.03078502f, 0.05095411f, -0.03331209f, 0.01506696f, -0.01650219f, -0.03786616f, 
    0.01983882f, -0.02620771f, -0.01965297f, 0.05423276f, -0.06880509f, -0.05063098f, -0.02511537f, -0.05300746f, 
    0.17497917f, -0.14453727f, 0.04967046f, 0.01872162f, -0.12251671f, 0.03333364f, 0.04952349f, -0.20382056f, 
    0.06552368f, -0.07046313f, 0.25656578f, 0.19774166f, 0.26781559f, -0.04157528f, -0.11063921f, -0.19747433f, 
    -0.09708785f, -0.09161858f, -0.21608612f, -0.16558081f, -0.06069997f, 0.02058738f, -0.01624044f, -0.11983652f, 
    0.09926983f, -0.17045109f, -0.12480269f, -0.00024940f, 0.04559680f, -0.00966829f, -0.19175325f, -0.05988901f, 
    0.16638845f, 0.09436313f, -0.07119500f, 0.16468897f, 0.19604206f, -0.14066178f, 0.08638024f, -0.00756313f, 
    0.15083207f, -0.00940550f, -0.26246047f, 0.04828312f, 0.11941510f, 0.03262440f, 0.09100401f, 0.14671627f, 
    0.16963580f, -0.00227964f, 0.07193600f, 0.03020873f, 0.14385410f, 0.02170593f, 0.21813354f, 0.13222782f, 
    -0.02267471f, 0.10838702f, 0.09250096f, -0.00649172f, -0.07174978f, -0.04748037f, 0.17671970f, 0.24071589f, 
    0.12619662f, 0.09211587f, -0.10667811f, 0.29067510f, 0.03078801f, -0.06404564f, -0.05392253f, -0.10223524f, 
    -0.16718870f, -0.13523462f, -0.12037502f, -0.04997118f, 0.09403832f, -0.06456457f, -0.28466916f, -0.32783309f, 
    0.05289622f, -0.14186889f, -0.37556514f, -0.08583247f, 0.27824825f, 0.11563601f, -0.16792580f, -0.02409911f, 
    -0.17203963f, 0.23220044f, -0.08493013f, -0.06386922f, -0.03684046f, 0.08168851f, -0.18300824f, 0.16981591f, 
    0.07945743f, 0.19357820f, -0.08111116f, -0.07271813f, -0.15138879f, 0.03261668f, -0.20180133f, -0.02063757f, 
    0.16882718f, -0.15037414f, -0.14370833f, 0.07889494f, -0.19187610f, -0.16224295f, 0.24215579f, 0.15327018f, 
    0.03941526f, -0.00292341f, -0.01080312f, -0.12176391f, 0.14662156f, -0.04760337f, 0.08474103f, -0.11519500f, 
    -0.01774764f, 0.03805114f, -0.19022648f, -0.08650472f, 0.18508731f, 0.05425054f, 0.09053780f, 0.22158393f, 
    0.01593316f, -0.19241953f, 0.00559872f, 0.05250157f, 0.15282018f, 0.13782795f, 0.12400170f, -0.13212706f, 
    -0.04353357f, 0.06015491f, 0.20079106f, 0.12102664f, -0.00872867f, -0.11030219f, -0.01478114f, -0.01769292f, 
    0.17973693f, 0.17018506f, -0.05251381f, 0.15413663f, 0.07942192f, 0.17208143f, 0.13045460f, 0.08536482f, 
    0.00412802f, -0.03136004f, -0.07866811f, 0.07792909f, 0.19863887f, -0.22385037f, 0.01605762f, 0.00314785f, 
    -0.27252868f, 0.05287005f, -0.24064957f, -0.16303203f, 0.12880871f, 0.09693442f, 0.12220681f, -0.11693847f, 
    0.02302895f, -0.09995053f, -0.09292569f, -0.18782422f, 0.07842688f, -0.30392510f, 0.00946900f, 0.16456260f, 
    -0.04770423f, -0.00578709f, -0.08170118f, 0.07655423f, 0.20992616f, -0.05163957f, 0.43568400f, 0.17408198f, 
    0.01718496f, -0.05418011f, -0.20218331f, -0.14233953f, 0.16845447f, 0.04189597f, 0.01827840f, -0.25183094f, 
    0.04311435f, -0.06777733f, 0.04034187f, -0.01735633f, -0.07493748f, -0.08091622f, -0.00126407f, -0.06044114f, 
    0.03579818f, 0.03674943f, -0.02419275f, -0.06645312f, 0.00448431f, 0.05460777f, -0.00573440f, -0.08436395f, 
    0.00915559f, -0.02658515f, -0.03011028f, -0.00171633f, -0.03620927f, 0.00797743f, 0.01985403f, 0.04665712f, 
    0.03865496f, -0.03827845f, -0.06210186f, 0.01697925f, 0.00332335f, -0.06093699f, -0.01213571f, -0.05466853f, 
    0.03564470f, -0.02992987f, -0.06695609f, -0.00378954f, 0.00198356f, -0.07256072f, 0.00753930f, 0.05529935f, 
    -0.02152616f, -0.01878206f, -0.03070471f, 0.02700105f, -0.06587113f, -0.02085340f, -0.02268598f, 0.05257999f, 
    0.01327877f, 0.01030848f, -0.05722141f, 0.03615550f, 0.03568988f, 0.02275055f, 0.02566625f, -0.05321844f, 
    0.02783639f, -0.04757297f, -0.03994946f, 0.02280243f, 0.03698524f, 0.00335417f, -0.00887918f, 0.02121272f, 
    0.04792196f, -0.08421195f, 0.05035177f, -0.02940149f, -0.00650911f, 0.01556654f, 0.01480667f, -0.08043755f, 
    -0.05975206f, 0.01979168f, -0.00057010f, 0.02219542f, 0.01820948f, 0.03613546f, -0.07855822f, 0.03520688f, 
    -0.00145186f, 0.02826719f, -0.06725874f, -0.03771498f, 0.04072333f, -0.04609689f, 0.02057781f, 0.06322632f, 
    -0.02596143f, -0.02963483f, -0.06293838f, -0.04457687f, 0.05307739f, 0.02783536f, -0.06840348f, 0.00006931f, 
    0.03370763f, -0.08138470f, 0.05673541f, -0.00430948f, 0.05740642f, -0.06338524f, -0.03044990f, -0.00329038f, 
    0.04510296f, 0.03830952f, 0.05479250f, 0.00164465f, -0.00983126f, -0.04266103f, 0.04386990f, 0.00764222f, 
    -0.00495828f, -0.01747979f, -0.04389626f, -0.03411416f, 0.05146249f, -0.07593425f, -0.07282944f, -0.06718847f, 
    -0.06710913f, 0.04274914f, -0.06140592f, 0.03381234f, -0.02741807f, 0.02079906f, 0.03948279f, -0.07634365f, 
    -0.07473653f, 0.00202980f, -0.04180611f, 0.00832649f, 0.01029310f, -0.04382688f, 0.01141855f, -0.00749130f, 
    -0.03460890f, -0.05517974f, -0.04837343f, 0.05557839f, -0.04013512f, -0.01198824f, -0.04710010f, -0.05440692f, 
    -0.02843819f, 0.03175947f, 0.01106497f, -0.08694623f, -0.01658917f, -0.00451824f, -0.04908044f, 0.04840605f, 
    -0.07109068f, -0.03601511f, 0.06363482f, -0.04798678f, 0.04890312f, 0.03019414f, -0.03443270f, -0.05406031f, 
    0.00432643f, -0.07425963f, 0.04446578f, 0.04540700f, -0.02590266f, 0.06024487f, -0.02890741f, -0.03226511f, 
    0.02560018f, -0.01129145f, 0.00714419f, 0.03751472f, -0.02088976f, -0.06815723f, 0.04949971f, 0.00863108f, 
    0.03596249f, -0.02923717f, 0.03882458f, 0.04973454f, 0.02151855f, -0.01988927f, -0.01653839f, -0.04764986f, 
    -0.00879673f, 0.04105199f, -0.01373016f, 0.03321378f, -0.03789119f, 0.00946626f, -0.02296971f, -0.02839154f, 
    -0.03215273f, 0.09586134f, -0.10137916f, 0.31055099f, 0.06247618f, -0.05372336f, -0.17299813f, -0.05130107f, 
    0.13097875f, 0.10718557f, -0.18833433f, 0.06845479f, -0.09985114f, 0.09839863f, -0.06586643f, 0.14099637f, 
    0.11245455f, 0.01231547f, 0.15690705f, 0.15692115f, -0.06520332f, -0.03981651f, -0.05679480f, -0.09837757f, 
    0.64603680f, 0.10894774f, 0.30339521f, 0.26560792f, 0.05231661f, 0.01665355f, 0.00102663f, -0.09208531f, 
    -0.04316849f, 0.07125705f, 0.06651197f, 0.06409153f, 0.23225856f, 0.02380706f, -0.12382174f, 0.30036098f, 
    -0.06210535f, 0.03216238f, 0.08653134f, -0.08892269f, -0.02780355f, 0.17726104f, 0.13548504f, 0.11793757f, 
    0.00352042f, 0.20089029f, 0.15506928f, 0.05033379f, -0.11520302f, -0.14715733f, 0.13725817f, 0.03554686f, 
    0.10095607f, 0.11201698f, 0.06694677f, 0.03397975f, -0.30811700f, 0.11162108f, -0.10394890f, -0.10980632f, 
    0.06831849f, -0.09981862f, 0.08962905f, -0.10954189f, -0.08614879f, 0.02835721f, -0.01074965f, 0.07024828f, 
    -0.24774256f, -0.10393421f, -0.12216695f, -0.14190269f, -0.01814509f, -0.10944902f, -0.04623656f, 0.05464051f, 
    -0.14720383f, -0.03336213f, -0.04177290f, -0.15815173f, 0.31773359f, 0.35691833f, 0.19176580f, 0.14127922f, 
    0.09941650f, 0.09495691f, -0.08374459f, 0.04571987f, -0.08262732f, -0.03952670f, 0.15976514f, -0.02287774f, 
    -0.51269293f, -0.42022038f, -0.10674060f, -0.08356912f, 0.06730334f, -0.36654866f, -0.24579370f, -0.06779680f, 
    -0.18848269f, -0.06818166f, 0.11702509f, 0.22146644f, -0.37065274f, -0.12811553f, 0.00142771f, -0.25062129f, 
    -0.05005166f, -0.12046352f, -0.10424154f, -0.04100936f, -0.07035244f, -0.06789787f, -0.03638962f, 0.07908490f, 
    0.21212281f, 0.11886039f, 0.16591637f, 0.18422365f, -0.03702234f, 0.14333154f, 0.10442368f, 0.05491482f, 
    -0.02849019f, 0.04141787f, 0.02452982f, -0.03577049f, -0.06040155f, 0.23213792f, -0.08965117f, 0.01325645f, 
    0.08448222f, -0.06005269f, -0.00186800f, 0.05509872f, -0.00592516f, 0.08021240f, -0.04287100f, 0.02784803f, 
    0.04328972f, -0.01952589f, 0.15544976f, 0.10480671f, -0.06168623f, -0.02916874f, -0.07995637f, 0.10909655f, 
    0.01107233f, 0.05531767f, -0.00768960f, 0.03900252f, -0.39087683f, 0.10011496f, -0.14378275f, -0.30049768f, 
    -0.09231897f, -0.02028858f, -0.07869429f, 0.03641159f, 0.06082824f, 0.00456505f, 0.06451827f, -0.06349339f, 
    0.17362018f, -0.17563589f, -0.13543776f, -0.13297921f, -0.23318028f, 0.03512101f, -0.04512834f, -0.04631756f, 
    0.00196022f, 0.00558683f, -0.18394846f, -0.00675298f, -0.41292173f, 0.27955517f, -0.36900076f, -0.14209005f, 
    0.08411048f, -0.00790633f, 0.12972248f, 0.00507315f, -0.01263982f, -0.00959011f, -0.17323254f, 0.01558715f, 
    0.17936072f, 0.09752592f, -0.03240775f, -0.09550558f, -0.02244392f, -0.06371951f, -0.20950422f, -0.00583947f, 
    -0.08447162f, 0.02966116f, -0.28527012f, -0.09727430f, 0.20987631f, 0.25418875f, 0.00019401f, 0.00572519f, 
    0.01103126f, -0.05083004f, 0.06172916f, 0.16912715f, -0.08879856f, 0.08215868f, 0.15128930f, 0.09342729f, 
    0.57103789f, -0.22642878f, -0.11064989f, -0.04258027f, 0.06638680f, -0.01672979f, -0.21834284f, 0.07562365f, 
    -0.11514614f, 0.10299384f, 0.01651115f, -0.13010125f, 0.02812213f, -0.00568391f, -0.26464909f, -0.00282177f, 
    0.03662893f, -0.00349707f, -0.05051424f, -0.10434262f, -0.00653756f, -0.16066015f, -0.08085652f, -0.00534252f, 
    -0.20780879f, 0.01616879f, -0.15631928f, 0.20446645f, -0.02272947f, 0.03014251f, 0.11718932f, 0.12849449f, 
    0.03620009f, 0.12027539f, 0.03891084f, -0.05387734f, -0.03697896f, 0.30464762f, -0.07119255f, 0.16356085f, 
    -0.19302168f, -0.07850313f, -0.01023029f, -0.11666646f, -0.01247506f, 0.01275421f, 0.02841954f, 0.08260933f, 
    0.00029257f, 0.04091017f, 0.03423192f, -0.10175908f, -0.02781808f, 0.01138485f, 0.05157651f, 0.02088287f, 
    0.09120666f, -0.01014338f, 0.10597891f, -0.04837898f, 0.41240698f, 0.09922435f, 0.01002018f, 0.06865960f, 
    -0.02285321f, 0.22746083f, -0.01827838f, 0.05344907f, -0.01048209f, 0.04782531f, 0.10279274f, 0.07062844f, 
    0.01646578f, 0.06709448f, 0.41569296f, -0.00685239f, -0.11616554f, 0.04969219f, -0.26996416f, 0.12493786f, 
    0.04610791f, 0.03007764f, 0.09527004f, 0.02027239f, -0.04765524f, 0.01818437f, 0.04479593f, -0.15665081f, 
    -0.16391206f, -0.03052925f, -0.06616072f, -0.00588773f, 0.02581515f, 0.09705291f, 0.03850622f, 0.01955561f, 
    -0.01312757f, 0.02011702f, -0.01957115f, 0.26875329f, -0.05455803f, -0.01427718f, -0.03099202f, 0.12132597f, 
    -0.01902998f, 0.06606884f, 0.03751090f, -0.00399660f, -0.16136473f, 0.20579532f, -0.06408321f, 0.16413242f, 
    0.01233843f, 0.07506393f, -0.03133110f, 0.12163394f, 0.00802798f, -0.00325514f, 0.04434574f, 0.00236568f, 
    0.01088654f, -0.16021432f, 0.06448272f, 0.28159890f, 0.04299069f, -0.00672906f, 0.02304472f, 0.13702600f, 
    -0.02687992f, 0.05631521f, 0.00356797f, 0.06652485f, 0.19813934f, 0.08978065f, 0.10622653f, -0.19181307f, 
    -0.06410892f, 0.21194711f, -0.06500973f, -0.04926621f, 0.13496812f, -0.02077108f, 0.09838059f, -0.03251880f, 
    -0.16272132f, -0.10734381f, 0.05999534f, -0.23112343f, -0.07002684f, -0.01508362f, -0.09541544f, -0.08931598f, 
    -0.03778339f, 0.08201616f, -0.16420299f, -0.09754328f, 0.56885469f, 0.19657673f, -0.10430498f, -0.50448567f, 
    0.18975921f, 0.01036423f, 0.03849803f, -0.13466677f, -0.05920403f, -0.08764535f, -0.06579759f, 0.18778335f, 
    -0.05351827f, 0.05121801f, -0.04838901f, 0.04279001f, 0.06188716f, 0.00531688f, -0.05719290f, 0.02670295f, 
    0.05745005f, -0.07450651f, -0.04114511f, 0.06250574f, 0.05765500f, -0.00350734f, -0.00947720f, 0.04317067f, 
    -0.00585151f, -0.03648875f, 0.02162521f, 0.06264681f, 0.04653925f, 0.02229300f, -0.03807168f, 0.01520496f, 
    0.06218464f, -0.01871814f, -0.06481366f, -0.00708791f, 0.06109037f, 0.03678977f, 0.01019764f, -0.04666133f, 
    0.05421274f, -0.05142819f, -0.02551809f, 0.04540509f, -0.01836466f, -0.02104449f, -0.03990170f, -0.03387339f, 
    -0.02676797f, -0.01894670f, 0.01475198f, -0.02973481f, -0.01427691f, -0.02606814f, -0.02770397f, -0.06501655f, 
    -0.06863013f, -0.03845468f, 0.00064114f, -0.05661198f, -0.07301651f, -0.01720650f, -0.04627209f, -0.00582573f, 
    0.03912232f, 0.04283407f, -0.06736024f, -0.03544141f, -0.05864093f, 0.02296536f, 0.01822297f, 0.01625565f, 
    -0.03460489f, 0.05120553f, 0.05846992f, -0.06854914f, -0.05684753f, -0.06644017f, -0.06767228f, 0.05628785f, 
    -0.06779104f, -0.01440322f, -0.00752502f, -0.01481752f, -0.02314790f, 0.01800305f, -0.04725824f, -0.07051609f, 
    -0.02401532f, 0.00680522f, -0.00410750f, -0.05264544f, 0.06242187f, -0.06117437f, -0.02273770f, -0.00388961f, 
    -0.04339837f, -0.04172755f, 0.02766495f, -0.06413793f, 0.02346108f, -0.05966692f, -0.02701356f, -0.00170732f, 
    -0.01076281f, -0.02722689f, 0.03855743f, 0.05208006f, 0.02776412f, -0.04700676f, -0.00479648f, -0.04492585f, 
    -0.02026900f, 0.02935842f, 0.05002464f, 0.03439038f, -0.03480588f, 0.04812367f, -0.03521029f, -0.02246640f, 
    -0.07358792f, -0.07284975f, -0.05302877f, -0.01842571f, 0.01217518f, 0.02970030f, 0.00249920f, -0.02806344f, 
    -0.02538401f, -0.04173324f, -0.07667956f, 0.00189137f, -0.05823154f, 0.04695544f, 0.04054366f, 0.03132849f, 
    -0.05056479f, 0.04280617f, -0.04257482f, -0.07169138f, -0.04639732f, 0.02475868f, -0.06447855f, 0.01183353f, 
    0.01485909f, 0.05937447f, 0.05301217f, -0.00416236f, -0.06591924f, 0.05261613f, -0.05660383f, -0.02669648f, 
    -0.06550459f, -0.00129895f, -0.02286927f, 0.01635851f, -0.01131945f, -0.03034831f, -0.00911827f, -0.07237470f, 
    -0.04336350f, -0.01137175f, 0.06154862f, 0.03118290f, 0.05428446f, -0.05826878f, -0.00501947f, -0.04366473f, 
    0.02114979f, 0.03482557f, -0.05846131f, -0.07135035f, 0.05876486f, 0.00893336f, -0.02293357f, -0.05401128f, 
    -0.06244218f, -0.00122754f, -0.04459917f, -0.04516525f, -0.03614588f, 0.02854905f, 0.01771354f, 0.06067344f, 
    -0.03037335f, -0.03440987f, 0.04978915f, 0.05551501f, -0.03502775f, 0.02411055f, -0.07321189f, 0.00915056f, 
    -0.06585576f, 0.06343845f, -0.04662159f, 0.03592523f, -0.05879935f, 0.04644811f, 0.05675741f, -0.00973390f, 
    -0.10465830f, -0.28182614f, 0.25932026f, -0.12649973f, -0.11278219f, 0.01252224f, 0.16149157f, 0.13240148f, 
    0.04586887f, -0.11829783f, 0.23619565f, 0.20330401f, -0.12128761f, 0.04574638f, 0.16849606f, -0.07996669f, 
    -0.10693663f, -0.20645501f, -0.34042653f, -0.15044644f, -0.03634047f, 0.02060947f, 0.11881191f, -0.00972322f, 
    -0.36188740f, -0.20762518f, 0.11509455f, 0.12257235f, -0.02165355f, 0.11944637f, -0.09051386f, 0.13459221f, 
    0.15340722f, -0.01773926f, 0.01910353f, 0.17374548f, -0.07349171f, 0.02987413f, 0.27472535f, 0.02049930f, 
    0.11554849f, 0.02175525f, -0.02990257f, 0.20009941f, 0.00573008f, 0.18516931f, -0.05659459f, 0.05298097f, 
    0.00315585f, -0.19815055f, 0.00069727f, 0.09308469f, 0.03150941f, 0.06568860f, 0.10986843f, -0.01884978f, 
    -0.00497561f, -0.04029847f, -0.03924060f, 0.00379606f, -0.10416409f, -0.35261270f, 0.13514775f, 0.10254847f, 
    0.17347333f, 0.20424150f, 0.01250835f, 0.13411635f, -0.00025956f, -0.08231390f, -0.01354649f, -0.11969724f, 
    -0.20809318f, -0.11248096f, -0.25899398f, 0.01854278f, 0.02015396f, -0.03015398f, -0.09107623f, -0.05786873f, 
    0.05026861f, -0.09676722f, -0.15114301f, -0.12386207f, 0.42101225f, -0.07310548f, -0.18879180f, 0.36654180f, 
    -0.04661439f, 0.10749456f, -0.08295213f, 0.11626825f, 0.00551462f, 0.10633310f, -0.03174907f, 0.03094449f, 
    -0.11415674f, 0.08824063f, -0.14202374f, -0.11856183f, 0.12587434f, 0.10466188f, 0.06650449f, -0.16792315f, 
    0.06120550f, 0.03258802f, -0.19535913f, -0.23402771f, -0.23833507f, -0.38509753f, -0.25588363f, -0.14400929f, 
    0.02130355f, -0.04656221f, -0.01848657f, 0.01831877f, 0.12797058f, -0.14886059f, 0.07375304f, -0.06283037f, 
    -0.09406561f, -0.15979803f, -0.21550250f, -0.01645771f, 0.14085732f, 0.00549030f, -0.04878425f, -0.12565252f, 
    -0.07003426f, -0.10481099f, -0.02024947f, 0.07758799f, -0.09114113f, -0.08595444f, 0.15908961f, 0.18855995f, 
    0.08739024f, 0.12499157f, 0.01830149f, -0.03066681f, 0.12318449f, 0.00015170f, -0.03596476f, 0.17455707f, 
    0.01675634f, 0.08690722f, -0.10254479f, 0.05292702f, 0.09911583f, -0.03444016f, 0.11874440f, -0.10674198f, 
    0.09921586f, -0.09077063f, -0.04669504f, 0.01338128f, 0.11922131f, -0.14849366f, -0.08027205f, 0.03614786f, 
    0.08438047f, -0.07559179f, 0.13014728f, 0.08820436f, -0.04902084f, 0.09263656f, 0.09461659f, 0.01786701f, 
    0.11773862f, -0.00692743f, -0.10562627f, -0.06581760f, 0.05714614f, -0.16405037f, 0.14430910f, 0.13690788f, 
    -0.15325448f, 0.00969322f, 0.03392141f, 0.26685259f, 0.62514734f, -0.40661839f, 0.09895307f, 0.20128661f, 
    -0.04653312f, -0.06954806f, -0.13500731f, 0.04698748f, 0.07109040f, 0.04889387f, -0.00492588f, -0.02967803f, 
    0.17190237f, -0.00249251f, -0.19022998f, -0.05129390f, 0.06378479f, -0.00645327f, -0.09148439f, -0.13416202f, 
    -0.08452245f, -0.08304816f, -0.04657511f, 0.05024334f, -0.21327266f, -0.23254886f, -0.21745138f, 0.01286665f, 
    -0.00578491f, 0.03187880f, 0.04184014f, -0.03336071f, 0.03550541f, 0.03344477f, 0.11989485f, 0.09872431f, 
    -0.10806946f, -0.21971920f, -0.39816347f, -0.15322599f, 0.06371413f, 0.04066274f, 0.02616300f, -0.12274269f, 
    0.02795660f, 0.03199824f, 0.05417721f, -0.02130488f, -0.11859876f, -0.02362029f, -0.39869493f, -0.02649967f, 
    0.01964064f, -0.06760813f, -0.01210359f, 0.01138067f, -0.01659755f, -0.16911799f, -0.02666986f, -0.07095180f, 
    -0.07938809f, -0.00896240f, 0.05225088f, 0.09410014f, 0.00408201f, 0.02200076f, -0.04941474f, 0.14959268f, 
    0.02800242f, 0.07495634f, 0.09064654f, -0.15187247f, 0.29758385f, 0.37026361f, 0.08519775f, 0.04327295f, 
    -0.13070406f, -0.18761940f, 0.04816440f, -0.04376493f, -0.12011770f, -0.05062735f, -0.05566457f, -0.02497300f, 
    0.00792555f, 0.14680906f, -0.06883373f, -0.03532661f, -0.04720657f, -0.03986501f, -0.14052837f, -0.10851894f, 
    -0.01445992f, 0.11489204f, 0.03984024f, 0.05676964f, 0.26295507f, 0.09623055f, 0.09865853f, -0.02863630f, 
    0.24753650f, -0.06806033f, 0.01538956f, -0.03104210f, -0.03615815f, 0.20926024f, -0.02259143f, 0.01303440f, 
    0.06310203f, 0.23022406f, -0.16142456f, 0.13499370f, -0.13743605f, -0.12778781f, -0.14184289f, 0.05538733f, 
    -0.05199924f, -0.02069987f, 0.06831853f, -0.16669071f, 0.25284496f, 0.20579922f, 0.23940283f, 0.12641947f, 
    0.00855662f, -0.06610110f, -0.21977992f, -0.05561722f, -0.02712684f, -0.02470780f, -0.06426695f, -0.08408003f, 
    0.13710158f, 0.04465162f, 0.05397540f, 0.20191085f, 0.00202160f, 0.06733472f, 0.01985231f, 0.01337437f, 
    0.06967525f, 0.01084207f, -0.00002187f, 0.01490195f, -0.07932116f, 0.37110442f, 0.16873793f, 0.10741700f, 
    -0.09177841f, -0.05073662f, 0.09346906f, 0.09711908f, 0.03243526f, 0.04179326f, 0.02326715f, 0.00723991f, 
    -0.04405162f, 0.13728201f, 0.15501413f, 0.13862139f, 0.14922354f, 0.07604048f, -0.05128061f, 0.22037798f, 
    0.03202678f, 0.05350984f, 0.04317497f, 0.14239421f, -0.05757207f, 0.00427160f, -0.06414270f, 0.05490649f, 
    -0.16340123f, -0.10637041f, -0.15524352f, -0.17590271f, -0.02956673f, 0.09005304f, 0.02440249f, 0.04703899f, 
    0.08574412f, 0.04976426f, -0.16176896f, 0.19447726f, 0.16188915f, 0.09777175f, 0.08261807f, 0.04390810f, 
    0.10497180f, 0.13791358f, -0.02851587f, 0.21731772f, 0.21693261f, -0.14994167f, -0.23763163f, -0.32370308f, 
    0.12767746f, -0.09491190f, -0.01251913f, -0.02380701f, 0.08308133f, 0.15236552f, -0.06903462f, 0.05630315f, 
    -0.01410468f, 0.28492939f, -0.10075592f, 0.25902599f, 0.04380993f, 0.00011242f, -0.17050585f, -0.02185337f, 
    0.21968055f, 0.04707319f, 0.07063683f, 0.04297082f, 0.04997928f, 0.19819988f, 0.11864566f, 0.05606478f, 
    -0.04083917f, 0.04281744f, 0.04233890f, 0.05022646f, -0.00680035f, -0.00463512f, 0.03239385f, -0.03506378f, 
    0.34873110f, 0.19479971f, 0.22146408f, 0.08876490f, -0.08368656f, -0.17819519f, 0.02974132f, -0.09064698f, 
    -0.06804161f, 0.06942658f, 0.06281669f, 0.01784221f, 0.03957382f, -0.03841167f, 0.21025789f, 0.09302749f, 
    -0.06719150f, 0.03740205f, -0.00767295f, -0.03877883f, 0.05749300f, 0.00495369f, 0.09621623f, 0.06122413f, 
    -0.10736419f, 0.20308553f, 0.01524364f, -0.01135766f, -0.00054268f, -0.03338749f, -0.00439919f, -0.02101852f, 
    0.01699970f, 0.15698372f, -0.02268175f, -0.00576216f, 0.11334482f, 0.04544254f, -0.09039462f, -0.20255589f, 
    -0.02517939f, -0.06603356f, 0.05273076f, -0.08429499f, -0.05062191f, 0.06317368f, 0.01322869f, -0.05463035f, 
    0.12434940f, 0.04194272f, -0.02365809f, -0.13686050f, 0.02831778f, 0.04971394f, 0.11064225f, -0.02564804f, 
    -0.07791560f, -0.01641475f, 0.00938613f, -0.03880132f, -0.44745767f, 0.36099762f, 0.18307315f, -0.24549475f, 
    -0.21122575f, 0.14847711f, 0.03478007f, -0.04252009f, 0.03928819f, -0.09153362f, -0.02056201f, 0.02683293f, 
    0.35148397f, -0.06020364f, 0.10914525f, -0.22620147f, -0.15183073f, 0.05913306f, 0.14950001f, 0.00533159f, 
    -0.02042037f, 0.11434665f, 0.05911127f, 0.16529961f, 0.05305742f, 0.18018746f, -0.08665857f, 0.05733195f, 
    -0.09628062f, 0.03257217f, 0.09522730f, -0.07463400f, 0.05123733f, 0.05128639f, -0.07023525f, 0.08255948f, 
    -0.09237969f, 0.03714098f, 0.07096809f, 0.06125227f, -0.08646609f, -0.01070436f, 0.00013570f, -0.00337275f, 
    -0.05721969f, -0.03975471f, -0.08562683f, -0.06638397f, -0.20576777f, -0.33167583f, -0.05385119f, -0.04039311f, 
    0.06897054f, 0.10679968f, -0.09579704f, 0.10832853f, -0.08106357f, 0.02798675f, -0.02093849f, -0.26288125f, 
    -0.22982278f, -0.07476778f, 0.00929464f, -0.08363970f, -0.12579428f, 0.01766756f, -0.01517196f, 0.01786389f, 
    0.06316283f, -0.04948854f, -0.07451211f, -0.01023025f, -0.11062306f, 0.21377605f, 0.06683563f, -0.10181606f, 
    -0.08411407f, 0.18435128f, -0.02641055f, -0.08309277f, 0.19999054f, 0.03252038f, -0.07158003f, -0.01609874f, 
    -0.01114441f, 0.04585978f, 0.35995802f, 0.11458538f, 0.04488040f, 0.20915657f, -0.13375133f, 0.00362454f, 
    0.13856727f, 0.06320920f, 0.14272295f, -0.06070999f, -0.50127202f, 0.14602363f, 0.05517124f, 0.58836460f, 
    -0.02529982f, 0.20161140f, -0.05645058f, 0.06403702f, 0.06829734f, -0.01448521f, 0.08575254f, 0.02351783f, 
    0.02498840f, -0.36387181f, 0.05021834f, -0.08260686f, -0.11003134f, 0.24722593f, -0.03430443f, -0.06834456f, 
    0.30210266f, 0.25335148f, 0.14859277f, 0.23187655f, 0.20502895f, 0.14563207f, 0.11440487f, -0.00283623f, 
    -0.06366171f, -0.16348000f, -0.14946596f, -0.16525002f, 0.02710847f, -0.08776536f, -0.21956933f, -0.20253986f, 
    -0.03780789f, 0.29777807f, 0.04808783f, 0.14050302f, -0.15930602f, 0.01896308f, -0.01878086f, -0.10772762f, 
    0.03811138f, 0.05595943f, 0.12251173f, 0.19870822f, 0.15415771f, -0.04058015f, -0.02238507f, -0.03808177f, 
    -0.11737709f, 0.00327943f, -0.02028763f, 0.01800763f, 0.18442363f, 0.21090277f, 0.06665959f, 0.19053954f, 
    0.11895179f, 0.03874171f, 0.18538165f, 0.15357421f, 0.00664925f, -0.07153542f, 0.09602597f, 0.02070183f, 
    0.16079393f, 0.14214410f, 0.18357505f, 0.23879570f, 0.08084033f, 0.10861731f, 0.20804858f, 0.15481122f, 
    0.05163108f, 0.09821636f, 0.09613203f, 0.02869433f, -0.07024756f, -0.12042522f, -0.06415697f, 0.01938527f, 
    -0.16864909f, -0.29544091f, -0.15177585f, -0.13774817f, 0.01255813f, 0.01717176f, -0.06529431f, -0.15344314f, 
    -0.45778158f, -0.49355105f, -0.26528582f, -0.46392274f, -0.13274965f, -0.06541182f, -0.14300063f, 0.19375044f, 
    -0.06832794f, 0.25295043f, 0.02688350f, -0.16101369f, -0.02202583f, -0.13218017f, 0.32777420f, 0.09299951f, 
    -0.08113181f, 0.15998118f, 0.04057851f, 0.00236301f, 0.08474762f, 0.04760702f, -0.02950682f, -0.13949597f, 
    -0.00007615f, -0.01496177f, -0.12575707f, 0.14478959f, 0.08773810f, -0.19125156f, 0.06539989f, -0.05458507f, 
    -0.14611973f, -0.05778889f, 0.07360731f, -0.23496276f, -0.02616555f, 0.04080291f, 0.06944503f, 0.17427766f, 
    0.00673760f, 0.03077205f, -0.02692772f, 0.07805875f, 0.03702321f, 0.05490785f, -0.07743712f, 0.07380188f, 
    -0.21432886f, -0.30984169f, -0.06144517f, -0.14140570f, 0.14692813f, -0.15683134f, 0.27186882f, 0.09430221f, 
    -0.01908448f, 0.06465869f, -0.10277048f, 0.08807126f, -0.16663703f, 0.08548211f, -0.20415673f, -0.02402576f, 
    0.10858150f, 0.28059039f, 0.11976093f, 0.41356805f, -0.03839806f, -0.08269117f, 0.18827407f, 0.06740724f, 
    0.02642479f, -0.00897177f, 0.01647988f, 0.10065664f, 0.12206063f, -0.01500904f, 0.17085943f, -0.19118460f, 
    -0.27762923f, -0.05445410f, 0.20136581f, 0.17569000f, -0.11267485f, 0.13961095f, -0.03437764f, -0.25218889f, 
    -0.05058409f, -0.19693488f, -0.05485116f, -0.06026151f, -0.09677774f, -0.10687300f, 0.10181176f, -0.24484037f, 
    -0.18625692f, -0.10017049f, 0.02387208f, -0.26382345f, 0.31735703f, 0.23001906f, 0.08014199f, -0.30251065f, 
    -0.04566544f, 0.12021969f, -0.11858328f, -0.25886539f, -0.05838475f, 0.02816006f, 0.00050128f, 0.07957347f, 
    -0.08211085f, -0.01951458f, 0.03937502f, -0.08310761f, -0.03923520f, -0.01180156f, -0.03706148f, -0.04260208f, 
    0.02190740f, -0.05362079f, 0.04281454f, -0.07185524f, 0.00101873f, -0.05585179f, -0.06342641f, 0.01878623f, 
    -0.05996821f, 0.02160811f, -0.04943623f, -0.07163884f, 0.03274095f, -0.02408623f, 0.04310192f, -0.05378595f, 
    -0.06759861f, 0.06187718f, -0.00576806f, -0.02936074f, 0.00964956f, -0.06016975f, -0.01992258f, 0.01624830f, 
    0.05365077f, -0.02483942f, -0.05682837f, 0.01646521f, -0.09249368f, -0.03662087f, -0.03376175f, -0.07144507f, 
    0.02903498f, -0.04804789f, -0.04749407f, 0.03038540f, -0.00715491f, -0.08535488f, 0.03152689f, 0.05266702f, 
    -0.06597965f, -0.08156750f, -0.00675719f, 0.01818269f, 0.02281328f, 0.05284216f, 0.05725617f, -0.01211197f, 
    -0.06887913f, -0.06910377f, -0.00181481f, -0.07083686f, 0.01597166f, -0.01641899f, 0.04760208f, 0.01655750f, 
    -0.06950535f, -0.01654573f, -0.02633793f, 0.03790605f, -0.06805237f, -0.02930422f, 0.00445123f, -0.02424377f, 
    -0.08448590f, -0.07121442f, -0.04944356f, -0.06413300f, -0.05467968f, -0.09850939f, 0.02186181f, -0.06464847f, 
    -0.01540827f, -0.03043865f, -0.08701414f, -0.03922383f, -0.11109649f, 0.00198717f, -0.12178265f, -0.02034110f, 
    -0.00378515f, -0.04405505f, 0.03079929f, 0.02459507f, 0.05372700f, 0.01925829f, -0.08275787f, 0.02334828f, 
    0.00770888f, 0.04790412f, -0.05696592f, 0.02332901f, 0.02786105f, -0.02513240f, 0.00863666f, -0.02185168f, 
    0.06783825f, 0.01914134f, -0.06707056f, -0.03041878f, -0.05348610f, 0.01597957f, 0.07896444f, 0.06294607f, 
    -0.04226395f, -0.02656700f, 0.00218831f, -0.02800373f, -0.01631980f, 0.06586115f, 0.02312595f, 0.03157078f, 
    -0.08450140f, 0.03903783f, -0.02165589f, -0.13214527f, -0.03019222f, 0.07084014f, 0.01224766f, -0.07297485f, 
    -0.03769746f, -0.03214697f, 0.03811484f, -0.07348465f, -0.06265675f, 0.04792953f, 0.02100676f, 0.02391105f, 
    -0.00707107f, -0.05905825f, -0.02965675f, -0.02976729f, 0.05192055f, -0.04490138f, 0.00172231f, 0.04870028f, 
    -0.05483419f, -0.06429905f, -0.09683215f, 0.00906005f, 0.01873216f, 0.00828404f, -0.05728305f, 0.03025600f, 
    0.05028882f, 0.04670266f, -0.05487771f, -0.04420339f, -0.04490687f, 0.00809669f, 0.05053204f, -0.06304960f, 
    0.01770212f, -0.06784273f, -0.01739950f, -0.02823988f, -0.01407810f, -0.08900018f, 0.04853016f, -0.08946235f, 
    -0.07644635f, -0.02215151f, -0.07816589f, -0.06592854f, -0.02392177f, -0.02911884f, -0.08042830f, -0.07720913f, 
    0.03826764f, 0.00524395f, 0.07928094f, 0.03566638f, -0.01450416f, -0.04928014f, 0.00842351f, -0.09939708f, 
    -0.04490317f, 0.03921860f, -0.04227829f, -0.00188721f, -0.00661764f, -0.02358809f, -0.07689305f, 0.03371747f, 
    -0.03512580f, 0.12422861f, -0.06197878f, -0.05691244f, 0.03068780f, 0.05619616f, 0.15918623f, 0.01207108f, 
    -0.19753492f, 0.00796256f, 0.13776645f, -0.08061132f, -0.21886106f, 0.02627327f, 0.03732109f, 0.12646735f, 
    -0.17741412f, -0.02802103f, -0.06188361f, -0.00883394f, 0.03491512f, 0.04302327f, 0.10994146f, -0.02177963f, 
    -0.39829046f, -0.02045026f, -0.00760265f, -0.14504509f, -0.01242394f, -0.05204862f, 0.16561189f, 0.05198722f, 
    0.02570697f, 0.14920685f, -0.04715433f, 0.06768724f, -0.07520010f, 0.17423414f, -0.13861017f, -0.14574027f, 
    0.07852222f, -0.03037946f, 0.05697552f, 0.01652724f, -0.01936214f, -0.13056239f, -0.09347777f, -0.10021961f, 
    0.09958833f, -0.02320886f, -0.10041379f, -0.08509102f, 0.06302409f, 0.02303525f, 0.06616752f, -0.02244862f, 
    -0.10539632f, -0.17118141f, -0.23110217f, -0.05843401f, -0.03505580f, -0.00605709f, 0.20876470f, 0.08115173f, 
    -0.02815736f, -0.01273482f, -0.09328073f, -0.05871810f, -0.07150786f, 0.05711110f, 0.03441049f, -0.02014585f, 
    -0.11911413f, 0.05295447f, 0.01247270f, -0.04647654f, 0.03219851f, -0.04793034f, 0.03789778f, -0.11432168f, 
    -0.03167607f, 0.08193174f, 0.02137841f, 0.22463997f, 0.58249956f, -0.46935728f, 0.30660149f, 0.09043722f, 
    0.08586903f, -0.26644507f, 0.19878626f, 0.12147640f, 0.00292906f, 0.13217913f, -0.18392836f, 0.04866881f, 
    -0.20524946f, 0.07100596f, -0.01583196f, 0.20370428f, -0.07946833f, 0.15590058f, 0.24302034f, 0.06007289f, 
    0.03207503f, -0.04072224f, -0.22900535f, -0.14174591f, 0.02206568f, 0.02035017f, -0.00358977f, 0.05377055f, 
    -0.09577178f, -0.16304211f, -0.13500980f, -0.11596707f, -0.21319795f, -0.07711759f, -0.09964879f, -0.05724033f, 
    0.03340036f, -0.04345870f, 0.12950508f, 0.04775953f, 0.18465860f, 0.06291202f, 0.12261144f, 0.14563479f, 
    0.02122247f, 0.11183208f, 0.02647025f, 0.14632338f, 0.05454598f, 0.31287125f, -0.06570941f, 0.14438762f, 
    0.05778029f, 0.10787921f, 0.19831966f, -0.12218200f, -0.05032147f, 0.06511565f, -0.02809552f, 0.11263020f, 
    0.31943795f, -0.18001783f, -0.01322814f, -0.14148585f, 0.12071115f, 0.11843478f, 0.00195416f, -0.07774615f, 
    0.08547198f, 0.02212396f, -0.04143017f, -0.06036964f, -0.01897547f, -0.15000075f, -0.11787798f, 0.18268549f, 
    0.04422310f, -0.20867756f, -0.06963844f, -0.06862483f, -0.00222897f, 0.03934813f, 0.12013499f, 0.08102430f, 
    0.13361874f, 0.31370172f, 0.23852544f, 0.32748130f, 0.11436190f, 0.09648721f, 0.16219541f, 0.12121575f, 
    -0.15495910f, -0.04284121f, 0.12230016f, 0.12455247f, -0.15779597f, 0.21051872f, 0.18109509f, -0.28078860f, 
    -0.02092568f, -0.06525847f, -0.01666517f, -0.08433694f, 0.00535590f, 0.02425104f, 0.16422585f, 0.04361396f, 
    0.04511642f, -0.04484477f, 0.00222620f, 0.05692364f, -0.02887296f, -0.04008424f, -0.06183826f, -0.03131475f, 
    -0.07329240f, -0.02545494f, 0.03577867f, 0.02526856f, -0.03599814f, -0.06519103f, -0.06836177f, 0.01132455f, 
    0.04967589f, -0.01218832f, 0.01183582f, 0.03349208f, -0.05882544f, 0.05119843f, 0.01311092f, -0.00899906f, 
    0.04532241f, 0.05072467f, -0.06546350f, -0.02330232f, -0.07346377f, -0.00427047f, -0.02447582f, -0.01772578f, 
    0.03218046f, -0.01885115f, -0.06284613f, 0.00264852f, -0.01765180f, -0.00272877f, -0.03568172f, -0.04754636f, 
    0.05670907f, -0.00124793f, -0.02661989f, -0.00713364f, -0.04090791f, 0.00383895f, 0.02772027f, -0.03170599f, 
    -0.06494714f, 0.01355294f, -0.03016975f, 0.02296197f, -0.01366331f, -0.06223358f, -0.01693037f, -0.04917044f, 
    -0.00031316f, 0.04742672f, -0.05371216f, 0.01472259f, 0.01438279f, -0.04559115f, -0.00519376f, -0.00231328f, 
    0.05268677f, -0.03204935f, -0.07002211f, -0.04020928f, 0.04659880f, 0.02295268f, -0.02426131f, 0.04650106f, 
    0.02039026f, 0.03850730f, 0.02988582f, -0.07703469f, -0.00115851f, -0.01387221f, -0.07339948f, 0.04942473f, 
    0.04793106f, 0.00875277f, -0.08381009f, -0.06811545f, -0.01019507f, -0.00082780f, -0.00553172f, -0.03255850f, 
    -0.07592552f, 0.00800457f, 0.05447366f, -0.03281026f, 0.03334736f, -0.05488563f, 0.02793088f, -0.01656281f, 
    0.01573933f, 0.04851094f, -0.01577536f, 0.01976880f, -0.04574686f, 0.01135189f, -0.06886979f, 0.03453647f, 
    -0.05966482f, -0.02045028f, 0.01642257f, 0.03364005f, -0.02798637f, -0.05621807f, 0.03675254f, 0.01635734f, 
    0.01486590f, -0.08311323f, -0.04355869f, 0.02939976f, -0.02897896f, 0.03868198f, -0.01737111f, -0.07598247f, 
    -0.01559757f, 0.00842399f, 0.02841701f, -0.04860244f, -0.01569647f, 0.01601083f, 0.06212560f, 0.01357075f, 
    -0.04852271f, 0.04809906f, -0.02075108f, -0.07824442f, 0.03636944f, -0.07521573f, -0.04400620f, -0.02339378f, 
    -0.03338148f, 0.00166530f, -0.05981701f, -0.07806385f, 0.00319199f, -0.04264230f, -0.02031733f, 0.00603479f, 
    0.02095496f, -0.07392040f, -0.04340592f, 0.01962285f, 0.03711941f, 0.01995054f, 0.02521092f, -0.03953211f, 
    0.02638622f, 0.04199518f, -0.06822000f, 0.06131775f, -0.03677694f, 0.04181101f, -0.01490040f, 0.02197750f, 
    0.01211217f, 0.04622126f, 0.02295485f, -0.01006300f, -0.03107389f, 0.06095916f, 0.05320540f, -0.06071257f, 
    0.03501642f, -0.00222719f, -0.01246507f, -0.05845480f, -0.05959562f, -0.07292207f, 0.03155596f, -0.01335130f, 
    -0.03260018f, -0.01997091f, 0.01520190f, -0.01972863f, 0.04106532f, -0.06683034f, 0.00057702f, -0.07957949f, 
    -0.03312428f, 0.03667500f, -0.02927650f, 0.04798352f, 0.01830215f, 0.01405235f, 0.05513868f, 0.02731389f, 
    -0.08669307f, 0.25679451f, -0.13569804f, 0.10895918f, 0.03138207f, 0.05209383f, -0.03428131f, -0.08008820f, 
    0.09295687f, 0.20865008f, -0.03393865f, -0.10244899f, 0.18680203f, 0.14041393f, -0.05297709f, 0.00593828f, 
    -0.10772537f, -0.00362781f, 0.09330176f, 0.05068129f, -0.00185434f, -0.07563335f, -0.04784628f, -0.02620031f, 
    0.38968948f, 0.16350089f, 0.10954993f, -0.09320948f, -0.05703135f, -0.19058616f, -0.01010650f, 0.01639754f, 
    -0.15155302f, 0.07686748f, -0.05127810f, -0.13090219f, 0.08234979f, 0.16061530f, -0.11240090f, -0.03583259f, 
    -0.11722706f, -0.01780815f, 0.00599997f, -0.06654320f, 0.04549384f, 0.03352099f, -0.05865494f, 0.06466495f, 
    0.05373265f, 0.19394562f, 0.16981386f, -0.06764023f, 0.03828689f, 0.08286881f, 0.02406711f, -0.00316451f, 
    0.04725360f, 0.06146528f, -0.02541888f, 0.14967808f, 0.04035445f, 0.03577071f, -0.12294745f, 0.03759641f, 
    -0.07181507f, -0.04626947f, 0.02977819f, -0.13813585f, -0.06642275f, -0.03010010f, 0.03401759f, -0.04734694f, 
    0.13485768f, 0.03631510f, 0.00030487f, 0.01159228f, -0.00291364f, 0.08579756f, 0.01658287f, -0.04885997f, 
    -0.12424171f, 0.01706789f, -0.02353557f, -0.10555317f, -0.40268105f, 0.10007934f, 0.13757953f, -0.25142732f, 
    -0.08563326f, 0.09093272f, 0.04296685f, -0.06978938f, 0.17011026f, -0.14367847f, -0.01796440f, -0.08103543f, 
    0.13818383f, 0.02223743f, 0.15908650f, 0.02307211f, 0.01948376f, -0.03660320f, 0.09345295f, 0.11457968f, 
    -0.12302484f, 0.07520824f, 0.16288307f, -0.02083916f, 0.09650746f, 0.23992173f, 0.11864115f, 0.18953693f, 
    -0.05304257f, -0.02884170f, 0.01849208f, -0.05610452f, 0.05672475f, 0.04753554f, 0.02210004f, 0.05653883f, 
    -0.08665158f, 0.13491538f, 0.08749903f, 0.08422800f, 0.04423825f, 0.09885474f, 0.07827611f, -0.02784591f, 
    -0.07626230f, -0.00917920f, -0.01127963f, -0.00395354f, 0.04334188f, -0.11093695f, -0.03399423f, -0.03804103f, 
    0.10217039f, 0.05597588f, 0.01595775f, -0.01817078f, 0.01133266f, 0.07721876f, 0.01070096f, -0.09354916f, 
    -0.06187608f, 0.10370103f, 0.07720943f, 0.01956145f, -0.04467313f, -0.05841028f, 0.07558869f, 0.02430052f, 
    0.01976001f, -0.05256781f, -0.02344396f, 0.11154621f, -0.05296203f, 0.23754685f, 0.23488833f, -0.03640931f, 
    -0.12719128f, 0.05768749f, 0.07561110f, 0.02413055f, 0.15431252f, -0.02150876f, -0.12805107f, -0.03588807f, 
    -0.15909156f, 0.00991441f, 0.25755161f, 0.11649892f, -0.08365901f, 0.13138612f, -0.04190119f, -0.09864845f, 
    0.08224336f, 0.02944642f, 0.09839188f, -0.12265967f, -0.58549088f, 0.35387146f, 0.17908059f, 0.04693519f, 
    -0.17128494f, 0.19108018f, 0.06422517f, 0.03243986f, 0.00113615f, -0.09902006f, 0.01400263f, 0.08342789f, 
    -0.09592582f, -0.09685136f, 0.04322973f, -0.00131973f, -0.04176394f, 0.09700192f, 0.07317510f, 0.11787337f, 
    -0.11290518f, 0.09246389f, 0.05835417f, -0.00275294f, 0.30646724f, 0.18851310f, 0.19698565f, 0.10054094f, 
    0.15903445f, 0.01718846f, -0.07983607f, 0.00512374f, 0.04983492f, 0.05952687f, -0.00595767f, 0.04508756f, 
    -0.21541195f, 0.26682371f, 0.12105591f, 0.15621606f, 0.11938474f, 0.02890653f, 0.18578890f, 0.08824262f, 
    -0.23374097f, 0.07882333f, -0.08844460f, 0.06999038f, -0.18800288f, 0.03628302f, 0.04549305f, 0.08611999f, 
    0.12912947f, -0.01128891f, -0.19095272f, -0.03163841f, -0.06112744f, 0.05194075f, -0.17915583f, 0.02301894f, 
    0.12106663f, 0.04937251f, 0.04086503f, 0.11570182f, 0.06076427f, -0.07447539f, 0.10413256f, 0.07012545f, 
    0.01744905f, 0.10634956f, 0.03660050f, 0.20066752f, -0.18381535f, -0.27894166f, 0.08501601f, 0.30932632f, 
    0.00874174f, 0.27038944f, 0.10535225f, 0.19939367f, 0.08778273f, -0.16021520f, 0.03363655f, -0.00918991f, 
    -0.00928604f, -0.06229809f, 0.01863888f, -0.09359182f, 0.07289423f, 0.08979919f, 0.01416454f, -0.01029645f, 
    -0.03884734f, 0.00996067f, -0.05326504f, 0.02642670f, 0.59400088f, -0.37748063f, -0.01851525f, 0.03627620f, 
    0.05900767f, -0.15202734f, 0.14665896f, 0.06023363f, -0.02590939f, -0.09312620f, -0.11632416f, 0.13822028f, 
    -0.14145388f, 0.01671028f, 0.20218115f, 0.09675796f, 0.06651610f, 0.29493156f, -0.03039850f, -0.05997466f, 
    0.11828675f, -0.09420504f, -0.29359838f, -0.07241659f, -0.23408976f, -0.31934500f, -0.48146367f, -0.06604239f, 
    -0.17877984f, 0.05678055f, 0.07425790f, -0.09715658f, 0.12317094f, 0.07329167f, -0.07559049f, 0.01924943f, 
    0.14447288f, 0.01961096f, 0.21002610f, 0.09244467f, -0.03035379f, 0.09467775f, -0.16306856f, 0.04674396f, 
    0.12215005f, -0.00734931f, 0.04979214f, -0.04124623f, 0.15539336f, 0.07490733f, 0.12433411f, 0.26676348f, 
    -0.01476812f, 0.16008225f, -0.14496583f, 0.00340723f, -0.09934895f, 0.00941929f, -0.08402937f, -0.02263206f, 
    0.27894768f, 0.01958578f, 0.18247934f, 0.29779476f, 0.01901976f, 0.02616557f, 0.17271860f, -0.04641078f, 
    -0.02879563f, -0.10969369f, -0.07829108f, 0.02747603f, -0.01386245f, -0.32619619f, -0.12750851f, 0.04386899f, 
    0.05834895f, -0.05961666f, 0.05185716f, -0.01160688f, -0.04606126f, 0.04624784f, 0.03622552f, -0.16689044f, 
    -0.23933677f, 0.13368905f, 0.15226194f, -0.09619132f, 0.03292565f, -0.18859997f, 0.10345123f, -0.06259287f, 
    -0.22766799f, -0.22179101f, -0.02051337f, -0.13195145f, -0.34750050f, 0.34196171f, 0.39217323f, -0.14428499f, 
    -0.05819688f, 0.06253495f, 0.00214997f, -0.13784915f, 0.00044027f, 0.00121088f, 0.05053129f, -0.08293437f, 
    0.05378991f, 0.06739889f, 0.05580294f, -0.05114456f, -0.00921988f, 0.06864572f, -0.19233894f, -0.06418419f, 
    0.00658825f, 0.03605973f, -0.07714064f, -0.01341986f, 0.19493200f, 0.05717925f, -0.10902695f, -0.06286981f, 
    0.01536425f, -0.00651884f, -0.02125980f, 0.02921369f, -0.02057368f, 0.05297427f, -0.00510408f, -0.10934778f, 
    0.44794819f, 0.01827141f, -0.24881199f, -0.13706613f, -0.00889590f, 0.11863383f, -0.17299832f, 0.05306878f, 
    -0.05153017f, -0.14531490f, -0.07445200f, -0.10811705f, 0.22746415f, -0.07318848f, -0.19657974f, 0.06579860f, 
    0.04301571f, -0.04370102f, 0.03621008f, -0.10590709f, -0.06178740f, -0.06738855f, 0.12903601f, 0.16968460f, 
    0.22909565f, 0.11847817f, 0.04869210f, -0.04745157f, -0.01104120f, -0.03118500f, 0.08344164f, 0.08293696f, 
    0.12238048f, 0.00316942f, 0.00821803f, -0.06144853f, 0.06190257f, 0.01820393f, -0.04174286f, 0.05071824f, 
    -0.00524002f, -0.11630998f, -0.13290276f, -0.00281249f, -0.05686311f, -0.03554360f, 0.00960789f, 0.08724156f, 
    0.06667070f, -0.00757117f, -0.01582355f, 0.00241506f, -0.03695092f, -0.04359322f, -0.00612035f, -0.08982977f, 
    0.00934251f, -0.12344138f, -0.01037760f, -0.05380131f, -0.52636480f, 0.33226609f, -0.03382092f, -0.31220230f, 
    0.08243109f, 0.07247098f, -0.13562997f, -0.06076469f, -0.09875066f, 0.04571272f, 0.21496093f, -0.02103033f, 
    0.13541399f, -0.12125866f, 0.17457905f, -0.01416430f, -0.03331371f, -0.05493590f, -0.19640204f, -0.01802214f, 
    -0.05166945f, -0.08162101f, 0.08526941f, -0.07073728f, -0.07365233f, -0.09982955f, 0.15050709f, 0.06821641f, 
    -0.04281288f, -0.01504482f, -0.09794475f, -0.01990971f, 0.01136944f, 0.04498823f, 0.09107726f, 0.02461794f, 
    0.16025706f, 0.32383189f, 0.01047946f, -0.06755616f, 0.06206142f, 0.07854698f, 0.07477129f, 0.15097150f, 
    -0.12066946f, 0.02344841f, -0.05450091f, 0.00200377f, 0.45626199f, 0.19936152f, 0.00428837f, -0.24873421f, 
    0.00943047f, -0.10276622f, 0.07780745f, 0.11477829f, 0.03456349f, -0.05366860f, -0.01166780f, -0.03045770f, 
    0.09273830f, 0.14366283f, -0.05090629f, -0.03103971f, 0.01077485f, 0.03740205f, 0.05420338f, 0.25127515f, 
    -0.05617027f, 0.05462826f, -0.10504578f, 0.03539372f, 0.16423360f, 0.07946983f, 0.05984730f, -0.12749299f, 
    -0.07051472f, 0.02719002f, -0.00838548f, -0.03586478f, 0.23584740f, -0.00655147f, -0.03876026f, -0.01847337f, 
    0.01687727f, -0.17780116f, -0.16567968f, -0.19663306f, -0.10270296f, 0.09476753f, -0.16691886f, 0.02134837f, 
    0.09511112f, 0.09031937f, -0.28160948f, 0.00420809f, 0.03675226f, 0.11303973f, 0.21741727f, -0.20854111f, 
    -0.04233690f, -0.07237571f, 0.05972482f, -0.07477033f, -0.05221249f, -0.01042546f, -0.11747369f, 0.09370981f, 
    0.08745478f, -0.16312476f, -0.09987568f, 0.01801210f, 0.00942414f, -0.05346712f, 0.02953152f, -0.14394683f, 
    0.08422397f, -0.13060580f, 0.23411092f, 0.30476227f, 0.09235629f, -0.09624279f, -0.08125699f, 0.01888233f, 
    0.00047198f, -0.07467482f, -0.18651697f, -0.07822628f, -0.12989049f, -0.01749291f, -0.14258520f, -0.20466250f, 
    -0.15674521f, 0.31883973f, 0.01910871f, 0.05602315f, 0.04262366f, -0.08262645f, 0.00788042f, -0.06767111f, 
    0.12542424f, 0.01206811f, 0.05905391f, 0.15984164f, -0.09895729f, -0.14217380f, -0.04321903f, 0.17054215f, 
    0.05905826f, -0.13676660f, -0.08505005f, 0.04157982f, 0.03297634f, 0.20256381f, 0.10280889f, 0.15107825f, 
    -0.00513796f, 0.02138547f, 0.27143031f, 0.08370388f, -0.09145125f, -0.17106670f, 0.04794703f, 0.11539494f, 
    0.12282332f, 0.17555168f, 0.21817943f, 0.08264501f, 0.18907468f, 0.05609484f, 0.21707277f, -0.08107935f, 
    -0.07025315f, -0.20278656f, 0.04322888f, 0.28622517f, 0.05255373f, -0.11931846f, 0.06715532f, -0.04773353f, 
    0.06955096f, 0.07328516f, -0.01418764f, 0.03793564f, 0.06436928f, 0.02739508f, -0.10091786f, -0.05071336f, 
    0.00743977f, -0.01666056f, -0.24790661f, -0.12392270f, 0.33400550f, 0.01996789f, 0.06409350f, -0.32621536f, 
    0.11814573f, -0.22217545f, 0.11310410f, -0.19336125f, 0.09329484f, 0.02283495f, -0.08074424f, 0.11378179f, 
    0.12685297f, 0.29331991f, -0.27452984f, 0.09846518f, 0.11312075f, -0.07245910f, 0.05305094f, -0.00615036f, 
    0.22210880f, 0.06121203f, 0.00457757f, 0.03484431f, 0.05429941f, -0.20064297f, 0.00681634f, 0.23827311f, 
    -0.12428225f, 0.00096586f, -0.09083938f, -0.00734948f, 0.22854139f, 0.13706653f, 0.07827415f, 0.02290693f, 
    0.04335742f, 0.09875856f, 0.21857947f, 0.12122544f, 0.08048972f, 0.00636920f, 0.12647469f, -0.10975477f, 
    0.09955343f, -0.14995466f, -0.01610406f, -0.15505224f, -0.15527351f, 0.08401056f, 0.23786804f, 0.06123786f, 
    -0.00516081f, -0.01856816f, 0.12650412f, 0.10436071f, 0.05536101f, -0.07333636f, 0.00173688f, 0.02754215f, 
    -0.00173071f, 0.43793187f, 0.20778796f, 0.33286172f, -0.00206303f, 0.08806980f, 0.00554465f, -0.11949080f, 
    0.05737903f, -0.09940553f, 0.03586213f, 0.14305307f, -0.12613654f, -0.17166927f, -0.20012861f, -0.01529926f, 
    0.05498092f, -0.06352557f, -0.09438989f, -0.02179534f, -0.13204475f, 0.15387169f, -0.05469650f, -0.18821411f, 
    0.09874693f, 0.05428328f, -0.20953073f, 0.12619632f, 0.10258555f, -0.07379949f, -0.03288228f, 0.15378717f, 
    -0.05237167f, 0.09441116f, 0.03461301f, 0.18563782f, -0.27412277f, -0.06623654f, 0.09448573f, 0.43258491f, 
    0.06532278f, -0.04526130f, -0.15522124f, -0.04932904f, -0.01943202f, 0.08498822f, 0.04905563f, -0.16071972f, 
    -0.18532178f, 0.11967494f, 0.01890714f, -0.14895801f, 0.00073142f, 0.00563883f, 0.10212975f, -0.12541606f, 
    -0.18371397f, -0.13179903f, -0.04301152f, -0.20299488f, 0.07756715f, -0.23978931f, -0.10437395f, 0.02502538f, 
    -0.17835182f, 0.08216322f, 0.02875925f, -0.03823143f, 0.23100935f, 0.12274823f, 0.09847359f, 0.01717781f, 
    -0.42045143f, -0.03914288f, -0.33542833f, -0.28564155f, -0.04158209f, -0.14945656f, 0.09666672f, 0.07851548f, 
    0.04531669f, -0.04198215f, -0.08570171f, -0.18635079f, -0.06750792f, 0.01353230f, -0.12719333f, -0.23645210f, 
    -0.02721251f, -0.08877915f, -0.01059550f, 0.11758882f, -0.05647713f, -0.20292880f, -0.17734961f, -0.19675437f, 
    0.17725523f, 0.11098445f, 0.15169872f, 0.00857018f, 0.11992704f, 0.08577336f, 0.03114695f, 0.14309977f, 
    -0.02069192f, -0.21235500f, -0.26504830f, -0.20660299f, 0.12438529f, 0.02958929f, -0.03691449f, 0.01461794f, 
    -0.04018844f, -0.09307477f, -0.10558388f, -0.00318643f, -0.02268013f, -0.03037788f, 0.02926136f, -0.11576168f, 
    -0.06296036f, 0.09460805f, 0.16171563f, 0.05457260f, -0.02372414f, 0.02676596f, -0.01696348f, -0.00057279f, 
    0.05370702f, 0.13948506f, 0.11962610f, 0.16861616f, -0.28306651f, -0.28742987f, 0.02744298f, -0.08570998f, 
    0.15743069f, -0.04955138f, 0.11798974f, 0.15989518f, 0.06548558f, 0.00652281f, -0.18760198f, -0.00062493f, 
    0.29229328f, 0.41342610f, -0.05566602f, 0.02931641f, -0.05967720f, 0.27988920f, 0.19569309f, 0.01397739f, 
    -0.04149955f, 0.09379561f, -0.13931343f, -0.17062509f, 0.10733172f, 0.15744752f, 0.05035830f, 0.07870066f, 
    0.09189353f, -0.01728923f, -0.04365768f, 0.08054893f, 0.03304925f, -0.03377430f, 0.09251179f, -0.09251751f, 
    -0.04488128f, 0.01740504f, 0.18336618f, 0.05867442f, 0.17294021f, 0.16093524f, 0.13031803f, 0.06016709f, 
    0.01698828f, 0.05541434f, 0.09766444f, 0.10508879f, -0.00966077f, 0.00780732f, 0.27587783f, -0.07489918f, 
    0.10278384f, 0.03087400f, 0.14751084f, -0.06931002f, -0.01703730f, 0.04760475f, -0.02195531f, 0.08984695f, 
    -0.02297015f, 0.13364743f, 0.14235306f, 0.20154227f, 0.06818708f, 0.03965141f, 0.13869317f, 0.09435135f, 
    -0.02636793f, -0.11059657f, 0.02868007f, 0.09378080f, 0.05105334f, 0.01426379f, 0.05232272f, 0.17131968f, 
    -0.00858775f, 0.06492561f, -0.01769386f, -0.08512294f, 0.07209279f, -0.00404909f, 0.03327009f, 0.15625846f, 
    -0.02709271f, 0.22390077f, 0.24220799f, 0.33368114f, 0.01589251f, 0.13423418f, 0.09291290f, 0.18632810f, 
    0.04680103f, -0.08196037f, 0.30964243f, 0.08216185f, -0.33162963f, -0.10475899f, 0.16163349f, 0.07392608f, 
    -0.13585095f, 0.00931313f, -0.04306323f, 0.06284779f, 0.01148757f, 0.10074594f, 0.10504059f, -0.06321058f, 
    0.02577903f, 0.06106726f, -0.06063528f, -0.03181989f, 0.00832808f, -0.02860147f, 0.04258228f, -0.07549974f, 
    -0.00980727f, -0.02450908f, 0.05874335f, 0.03570594f, 0.04803545f, -0.00239564f, 0.02338124f, -0.04073208f, 
    0.00412781f, -0.00485131f, 0.02785957f, -0.07484892f, 0.01025418f, 0.02021580f, -0.06718708f, -0.00122623f, 
    -0.07488728f, -0.05894209f, -0.01596797f, 0.04526101f, -0.06848259f, -0.03078525f, 0.03638229f, 0.02067292f, 
    0.05572867f, 0.04848093f, -0.08157593f, 0.03790838f, 0.00148490f, -0.07740920f, -0.06604359f, 0.04591466f, 
    0.04118383f, -0.00062379f, 0.00961201f, -0.02258538f, 0.00483908f, -0.02073908f, -0.05473258f, 0.01279857f, 
    -0.03766355f, -0.05937866f, 0.05322181f, -0.02687161f, 0.03604215f, -0.06015712f, -0.07232194f, -0.00563688f, 
    0.00760356f, -0.04226679f, -0.04933120f, 0.02805345f, 0.06169213f, -0.05582029f, -0.02437742f, 0.04564472f, 
    0.05910862f, -0.01564855f, -0.06884018f, -0.00085784f, 0.04981773f, -0.04577561f, 0.01461877f, -0.02475722f, 
    0.02719804f, -0.05381948f, 0.04286158f, 0.03673220f, -0.00754940f, -0.06342401f, 0.02941237f, -0.07401568f, 
    -0.01920211f, -0.02457869f, -0.06863050f, -0.02395951f, -0.01516252f, -0.06142568f, 0.04602992f, 0.00992031f, 
    -0.02147823f, 0.03231125f, 0.04675562f, -0.04961743f, 0.05481596f, -0.03778872f, 0.05174400f, 0.00179018f, 
    0.02869697f, -0.02383771f, 0.04718751f, -0.05287896f, -0.03454419f, 0.02902939f, -0.01723418f, 0.01584957f, 
    0.00600470f, 0.02072844f, -0.03360415f, 0.01753124f, -0.00638543f, 0.03196745f, -0.01199692f, 0.04798044f, 
    -0.01066080f, -0.05647504f, 0.01149693f, 0.05182631f, -0.06837075f, -0.00935524f, 0.05166332f, -0.02284240f, 
    0.07208746f, -0.06114981f, 0.01767571f, 0.05640297f, -0.05952890f, -0.01333973f, -0.01397380f, 0.03182382f, 
    0.03197966f, 0.03252538f, -0.02687311f, 0.02313673f, 0.05369799f, 0.04379741f, -0.01550262f, -0.06973824f, 
    0.02115236f, -0.05881314f, -0.05568345f, 0.00853524f, 0.00744836f, -0.06814764f, -0.05545750f, -0.04054780f, 
    0.00577348f, 0.01183840f, -0.01139083f, 0.05502364f, 0.02430078f, 0.01709501f, -0.04087896f, 0.03204195f, 
    -0.05882256f, -0.06214198f, 0.01840440f, 0.03415389f, -0.06413600f, -0.00540542f, 0.02486348f, -0.07242449f, 
    -0.01059444f, -0.02523675f, -0.06973715f, -0.00033265f, -0.00855891f, -0.03388806f, 0.05916160f, 0.00700227f, 
    0.01235222f, 0.03447259f, 0.00605587f, -0.07245200f, 0.05734899f, 0.04079934f, -0.03640488f, -0.05719743f, 
    -0.07616891f, 0.04426493f, -0.01320599f, -0.06929254f, 0.02866662f, -0.02601581f, -0.06721804f, -0.07409010f, 
    -0.05420296f, -0.07596451f, 0.04293297f, -0.05862208f, -0.02627345f, 0.06380521f, -0.05675364f, -0.02030538f, 
    0.14957182f, -0.07138564f, -0.10317326f, -0.00614036f, 0.14349610f, -0.03111921f, -0.25182530f, -0.00299125f, 
    0.05133918f, 0.10189012f, -0.11780022f, 0.13450660f, 0.02980502f, 0.09919143f, -0.06328297f, 0.14482892f, 
    0.05899098f, 0.00304508f, 0.10317501f, 0.10185550f, -0.01201083f, 0.04105480f, -0.08148527f, 0.10707831f, 
    0.43132344f, 0.06728761f, 0.06706740f, 0.17611699f, 0.00313970f, 0.04449911f, -0.00706742f, -0.09046642f, 
    -0.08205346f, -0.10983834f, 0.17426707f, -0.08022168f, -0.01616780f, -0.06771106f, -0.16990606f, 0.15263706f, 
    -0.06557266f, -0.03070677f, 0.00192210f, -0.12712461f, -0.04060404f, 0.00223611f, 0.18785059f, -0.01629139f, 
    -0.18545027f, -0.05272856f, -0.06165966f, 0.04655558f, -0.06198272f, 0.04156116f, -0.05476668f, 0.06000072f, 
    0.06654357f, 0.14257731f, 0.04314331f, 0.06641123f, 0.12600830f, 0.40621415f, -0.10004383f, -0.05221064f, 
    -0.07782082f, -0.20767485f, 0.04392043f, -0.02865785f, 0.04259327f, 0.06276692f, 0.05009811f, 0.12345205f, 
    0.09722906f, -0.06956550f, -0.05429283f, -0.08164486f, 0.00689184f, -0.01075532f, 0.01269019f, 0.07221716f, 
    0.06566609f, -0.01431766f, 0.04594800f, -0.16068493f, 0.17919390f, 0.32046703f, 0.02302287f, 0.08199957f, 
    0.13900571f, 0.22337386f, -0.09999102f, -0.08479099f, -0.01098802f, -0.02734097f, 0.26127079f, -0.05922880f, 
    -0.01391868f, 0.04272402f, 0.02019872f, 0.02367069f, -0.01632310f, -0.20112793f, -0.21348414f, -0.00921865f, 
    -0.05289318f, -0.08401188f, 0.15298653f, 0.01699828f, 0.03631047f, 0.01931334f, 0.15762602f, -0.03430668f, 
    -0.10744061f, -0.09032043f, -0.01809518f, 0.02023372f, -0.06744339f, 0.05942426f, 0.01108042f, 0.02108159f, 
    0.00908830f, 0.02546143f, 0.01267226f, 0.13945337f, -0.15005930f, 0.05688061f, -0.10379872f, -0.15319435f, 
    -0.06163109f, -0.05719241f, 0.00945114f, -0.04541897f, -0.22375332f, 0.09763639f, -0.01901581f, 0.11162359f, 
    -0.02620657f, -0.01784448f, 0.03582895f, 0.08091723f, -0.06467035f, 0.00835966f, 0.02806188f, 0.00907831f, 
    -0.14060064f, 0.01692938f, 0.03233811f, 0.17725872f, 0.00090028f, 0.02008104f, -0.11608481f, 0.20683907f, 
    -0.02039923f, 0.09392488f, -0.05222905f, 0.01004253f, -0.07865770f, 0.20178753f, 0.16738857f, -0.20749596f, 
    -0.10699441f, 0.09780279f, 0.02644368f, -0.01364562f, 0.05563795f, 0.07083597f, -0.03682066f, -0.06792995f, 
    0.06950386f, -0.15044570f, -0.29790202f, -0.06429013f, -0.03884652f, 0.10987175f, -0.06677866f, -0.07448338f, 
    0.11213762f, 0.17934383f, -0.17780712f, 0.04889983f, 0.31773236f, -0.06918911f, -0.50962675f, -0.12375673f, 
    0.22335343f, 0.08669530f, -0.03694330f, -0.05544381f, 0.01268741f, 0.04674947f, 0.03324553f, 0.18071903f, 
    0.02199563f, 0.19624458f, 0.11340604f, 0.03460291f, -0.02698646f, -0.06254628f, -0.02178693f, 0.02720390f, 
    -0.05679375f, 0.05776405f, 0.07239071f, -0.02871676f, -0.14259844f, -0.05421435f, 0.00971194f, 0.00423101f, 
    -0.11922515f, -0.08638673f, -0.02332855f, 0.02376043f, 0.18338507f, 0.07434249f, 0.10864440f, 0.15806223f, 
    -0.10175288f, -0.16029416f, -0.06605785f, -0.23066147f, 0.03477581f, 0.03267584f, -0.04902927f, 0.09337890f, 
    0.08444852f, -0.04973989f, 0.07976683f, -0.12999952f, -0.01746836f, 0.11597099f, 0.18283285f, -0.08651906f, 
    -0.01381552f, -0.01615063f, 0.00258300f, 0.15376507f, 0.12732171f, -0.06933889f, 0.05066208f, -0.03637227f, 
    0.09086174f, 0.12631263f, 0.09408687f, -0.08850941f, 0.13713641f, 0.07752950f, -0.09897140f, 0.03664585f, 
    -0.06235154f, -0.19235311f, -0.13981253f, -0.05722620f, 0.14768387f, -0.18884401f, -0.03493236f, 0.01504216f, 
    0.09682963f, 0.15746365f, -0.16904232f, -0.03832047f, -0.06015639f, -0.01768548f, -0.05317845f, -0.05740817f, 
    0.04563143f, 0.00012256f, 0.00352551f, -0.04196794f, 0.05286894f, 0.12779027f, 0.03835673f, -0.02436196f, 
    0.08686356f, 0.06059496f, 0.00718618f, 0.03596032f, -0.60102236f, 0.08222849f, 0.06086089f, -0.13971442f, 
    -0.04685000f, 0.04585990f, -0.07210035f, 0.10719970f, 0.05140609f, 0.05787342f, -0.15918405f, -0.04749351f, 
    0.37899306f, -0.17385453f, 0.03586734f, -0.08319760f, -0.04174216f, 0.08977390f, 0.11037633f, -0.02959261f, 
    -0.08183315f, 0.02331619f, 0.02839625f, -0.14349535f, 0.09047521f, 0.07137408f, -0.07103135f, 0.19233939f, 
    0.03095899f, 0.00983335f, 0.00658616f, -0.01567412f, 0.01751516f, -0.14714804f, -0.01741719f, -0.15560475f, 
    0.03263577f, 0.09318550f, -0.03749509f, -0.07505273f, 0.18653780f, -0.00563198f, 0.07807404f, 0.04910934f, 
    -0.20255372f, 0.04185188f, -0.02982074f, 0.09757390f, 0.11811069f, -0.11927935f, 0.00270294f, -0.17106618f, 
    0.06745083f, -0.06487099f, 0.11311174f, 0.04260035f, 0.06336837f, -0.04848841f, 0.00705444f, -0.00061454f, 
    -0.07591572f, -0.02337755f, -0.05676927f, -0.26688942f, -0.05842470f, 0.11660592f, -0.05320266f, 0.07696262f, 
    -0.00513978f, -0.06923202f, 0.00285262f, -0.02884789f, 0.02208351f, 0.05743432f, 0.05118898f, 0.15155159f, 
    -0.08262560f, -0.05351224f, -0.04741592f, -0.03748977f, 0.17375173f, 0.07713617f, 0.07773008f, 0.33402961f, 
    0.10642117f, 0.13843241f, 0.20344861f, 0.16978203f, 0.08625583f, 0.16391557f, 0.04365130f, 0.09711776f, 
    0.14673787f, 0.21569869f, 0.24936587f, 0.18611911f, -0.36052513f, -0.19084607f, 0.39594275f, 0.38674101f, 
    -0.21403053f, -0.09760352f, -0.04254578f, 0.11022004f, 0.07646994f, 0.07413957f, 0.02161942f, -0.07922435f, 
    0.05586660f, -0.35347512f, 0.11884036f, -0.20060393f, -0.10246873f, 0.06811509f, 0.10751048f, -0.01239916f, 
    0.05229744f, -0.10235961f, 0.21122716f, 0.07301529f, 0.14883944f, -0.27874625f, -0.14429396f, -0.13341282f, 
    -0.03138682f, -0.04677906f, -0.06600655f, -0.05880721f, 0.14632124f, 0.08766307f, 0.03862193f, 0.03268432f, 
    -0.22288044f, -0.22301020f, -0.17505133f, 0.06967133f, 0.09536043f, 0.26058739f, 0.06438391f, 0.26006860f, 
    0.16134799f, -0.01695039f, -0.13829625f, 0.06971750f, 0.15617158f, -0.26789594f, -0.06510524f, -0.10709432f, 
    -0.01872883f, 0.07069255f, -0.04797818f, 0.13894968f, -0.02602209f, 0.02057113f, -0.08299752f, 0.05748374f, 
    0.17524502f, -0.24018326f, 0.06220495f, 0.02922189f, 0.14973779f, 0.07675097f, 0.01262716f, -0.04622940f, 
    0.02561327f, -0.03527869f, -0.01074547f, -0.13528766f, -0.17766818f, -0.04695482f, 0.07425962f, 0.11037304f, 
    0.07129468f, -0.00035113f, -0.02588366f, 0.19012481f, -0.03026154f, -0.07244894f, 0.00035315f, -0.02987884f, 
    -0.24129651f, -0.13865755f, 0.02358936f, -0.01230416f, 0.02723891f, -0.04775588f, -0.15489368f, -0.04540136f, 
    -0.03020418f, -0.14449605f, -0.11125254f, 0.09687646f, 0.13594213f, 0.00454503f, -0.26456219f, 0.23764946f, 
    0.03807429f, 0.11937681f, -0.07994898f, -0.04738406f, -0.17119619f, 0.09715272f, 0.00471978f, 0.12648843f, 
    -0.08388038f, 0.24823716f, -0.08672706f, -0.19319212f, -0.05569289f, -0.18374220f, -0.14602666f, -0.05151325f, 
    0.02248642f, -0.07505792f, -0.06837364f, -0.13164672f, -0.23468731f, -0.18999299f, 0.16456158f, 0.02390446f, 
    0.07807204f, -0.01843313f, -0.07046132f, -0.07396483f, -0.05038415f, -0.10498430f, 0.04864387f, 0.03615309f, 
    0.07220870f, 0.05013498f, -0.08295514f, -0.03884592f, 0.26199421f, 0.09323137f, 0.01384861f, 0.13610861f, 
    -0.02399600f, -0.02663868f, -0.06539508f, 0.06538527f, 0.47535846f, 0.11143101f, 0.40428105f, -0.03745130f, 
    0.05807021f, -0.00135408f, 0.13664426f, -0.01453278f, 0.06046614f, 0.09413526f, 0.01267219f, 0.09438759f, 
    0.09350956f, 0.14628869f, -0.07627842f, 0.28218567f, 0.20594907f, 0.12586874f, 0.05562286f, 0.01398300f, 
    0.03258699f, 0.05148700f, -0.01295617f, -0.02160346f, 0.07615002f, -0.27996752f, -0.07063008f, 0.03560494f, 
    -0.01692704f, -0.06922110f, -0.15213718f, -0.00595935f, -0.01129086f, 0.01729678f, 0.18810633f, 0.11474878f, 
    0.13073555f, -0.08820249f, -0.04724991f, -0.26080570f, 0.13321832f, -0.10959242f, 0.02581047f, 0.03951138f, 
    -0.10130971f, -0.11793585f, 0.10308991f, 0.05487642f, 0.60640609f, -0.26402828f, 0.11373625f, -0.16667849f, 
    0.04641496f, -0.01581112f, -0.02458657f, -0.03677797f, 0.09909765f, 0.01855451f, 0.12694402f, -0.04803153f, 
    0.27798679f, -0.09318434f, -0.09038778f, -0.12843381f, -0.15427890f, 0.08792942f, 0.10596846f, 0.06446151f, 
    0.00168593f, 0.22523548f, 0.13241993f, 0.15469189f, 0.04915252f, 0.23509140f, 0.06109412f, 0.07291562f, 
    -0.04790465f, -0.23391636f, -0.12466024f, -0.15068153f, -0.16739233f, -0.02686681f, 0.02586835f, -0.02332921f, 
    0.03578013f, 0.00802230f, -0.17145842f, -0.11144730f, -0.04896321f, 0.14205359f, 0.00116562f, 0.02515501f, 
    -0.03825471f, 0.06265248f, 0.05398686f, 0.00890210f, 0.16210862f, 0.18845510f, 0.01248525f, -0.04880167f, 
    0.02272317f, 0.00303657f, -0.07265996f, -0.02775958f, 0.16029543f, 0.09111517f, 0.09948734f, 0.01092778f, 
    0.30440515f, 0.12493835f, -0.05221378f, 0.03954482f, 0.10971750f, -0.06301887f, 0.10737006f, 0.08264484f, 
    -0.10039631f, 0.19790383f, -0.03002829f, 0.20441823f, -0.12516944f, -0.27438179f, -0.01128678f, 0.25853711f, 
    0.04971252f, 0.36714649f, 0.09362700f, -0.01004503f, 0.06474091f, 0.06169346f, -0.20839949f, 0.08196950f, 
    -0.00322961f, -0.26623306f, -0.06478602f, -0.06937631f, 0.00966611f, 0.01511743f, -0.16441222f, -0.20724827f, 
    -0.32859835f, -0.31457332f, -0.16649969f, -0.09022379f, 0.05303749f, -0.30908409f, -0.00354417f, 0.23175980f, 
    -0.15451385f, 0.29503319f, -0.13732439f, 0.05917813f, 0.05132124f, -0.00311366f, 0.04883013f, 0.17565235f, 
    -0.01596193f, -0.17255805f, 0.30762267f, 0.06844511f, 0.01834585f, 0.38519713f, 0.15490165f, -0.08257517f, 
    0.10492822f, -0.22971998f, -0.10648730f, 0.11848430f, 0.09739981f, -0.09849223f, -0.21947530f, -0.02905059f, 
    0.00242692f, 0.17620023f, 0.15842415f, -0.14936320f, -0.15181337f, 0.01445004f, 0.06207833f, 0.00898668f, 
    0.09685646f, 0.01228777f, -0.09124097f, -0.13641590f, 0.09297878f, 0.01172230f, -0.15156953f, 0.11122005f, 
    -0.07531432f, -0.06476217f, 0.07160658f, 0.05659911f, 0.44919816f, -0.06126901f, -0.09221191f, 0.12214455f, 
    -0.03109742f, 0.19960868f, -0.04840950f, 0.00061661f, -0.04186686f, 0.03539131f, -0.10986285f, -0.01584085f, 
    0.26926601f, 0.07452234f, 0.02217416f, 0.10032579f, -0.12605999f, 0.02177679f, 0.14580627f, 0.00468261f, 
    -0.00255681f, 0.07524184f, 0.11708854f, -0.11786724f, 0.19131012f, -0.13836089f, 0.20138414f, 0.02708489f, 
    -0.04285074f, -0.04492051f, 0.10306391f, 0.06406756f, -0.01096232f, 0.00769666f, 0.07754072f, -0.17584608f, 
    -0.24856748f, -0.02695912f, 0.22161259f, -0.18991064f, -0.01752258f, -0.24498785f, 0.11796352f, -0.22893173f, 
    -0.19812776f, 0.04263860f, 0.06763479f, -0.11083354f, 0.51394904f, 0.35439244f, 0.50545663f, -0.26874512f, 
    -0.12664697f, -0.05133969f, -0.26261199f, -0.13745092f, 0.02499442f, 0.01286890f, 0.05240295f, 0.02685276f, 
    -0.06969132f, -0.02016729f, -0.06669714f, -0.06513701f, -0.05678111f, 0.03715241f, -0.03705976f, -0.03591539f, 
    0.05122850f, 0.01336092f, -0.01786467f, -0.01542361f, -0.08127491f, 0.00460246f, 0.00781258f, -0.01918712f, 
    -0.00391224f, 0.03215993f, -0.01654937f, 0.02127903f, 0.01313976f, -0.03659828f, -0.05422751f, -0.02663405f, 
    -0.05435897f, -0.01612593f, 0.00127810f, -0.05016870f, 0.06442931f, 0.00816992f, -0.00864018f, -0.05000483f, 
    -0.06048677f, 0.03997111f, -0.00432896f, -0.06378940f, 0.02392746f, 0.03768619f, -0.03734138f, -0.05315784f, 
    -0.01879034f, -0.06035945f, -0.03138117f, 0.01556241f, 0.02774272f, 0.01194787f, 0.04748264f, 0.04766062f, 
    -0.06620780f, -0.04863472f, 0.01126197f, -0.05727907f, 0.05232633f, 0.00157526f, -0.03677825f, 0.01548606f, 
    0.00164291f, -0.01244941f, -0.05396813f, -0.01397566f, 0.03107083f, 0.00363693f, -0.05168350f, 0.05700994f, 
    0.02509867f, 0.05430972f, 0.04475178f, -0.04887593f, -0.08354842f, 0.01161129f, -0.03981087f, -0.00391414f, 
    -0.01471292f, 0.02169067f, -0.07380502f, 0.04892460f, -0.07816234f, 0.04943612f, 0.01493414f, 0.00044798f, 
    -0.07417309f, 0.02824608f, 0.04045189f, 0.04055878f, -0.02675947f, -0.01911408f, 0.01246768f, 0.06256169f, 
    0.06307419f, 0.06005895f, -0.06891739f, 0.00165456f, -0.03049351f, -0.06938835f, 0.04329711f, 0.00349695f, 
    -0.01631066f, -0.08520505f, 0.02604578f, 0.00989108f, -0.04663918f, -0.00521733f, -0.00225213f, 0.05128942f, 
    -0.01871879f, 0.00506084f, 0.00847892f, -0.02952158f, -0.03092002f, -0.02649238f, -0.03582251f, -0.05887616f, 
    -0.02430245f, -0.04326238f, 0.04819170f, -0.06754827f, -0.02039188f, -0.01158638f, -0.08219434f, 0.03183763f, 
    -0.05859108f, 0.06778910f, -0.04022434f, -0.06172156f, -0.04086978f, -0.03941581f, -0.06249332f, 0.00668953f, 
    0.02377323f, -0.03889253f, -0.00452921f, -0.01594184f, -0.06416826f, 0.06584878f, -0.07547598f, 0.06116673f, 
    -0.07642424f, 0.06571567f, -0.07067571f, -0.06713521f, -0.06036763f, 0.02194052f, 0.00144925f, -0.02099453f, 
    -0.06037359f, -0.01296721f, -0.02458790f, -0.04930960f, -0.04363318f, -0.06422219f, 0.06637057f, 0.03356581f, 
    -0.02996048f, 0.05095205f, -0.04575586f, 0.03038716f, -0.02998064f, 0.04413415f, 0.02921287f, -0.04353114f, 
    -0.05914392f, -0.05314479f, -0.04419863f, -0.04037672f, 0.02365677f, -0.00278211f, -0.01523110f, 0.05873218f, 
    -0.01157051f, -0.05707378f, -0.07909592f, 0.01756374f, -0.03564550f, -0.00785476f, -0.04634540f, -0.03184842f, 
    -0.00071716f, 0.01638381f, 0.04018825f, 0.03906890f, -0.01742344f, -0.05998983f, 0.04521093f, -0.06680825f, 
    -0.04245467f, 0.04353202f, -0.05436982f, -0.05685129f, -0.06298143f, -0.04598735f, -0.02484420f, -0.02686304f, 
    -0.11929714f, 0.18456179f, 0.01879253f, 0.20424616f, -0.05341327f, 0.10454381f, -0.05751235f, -0.02667050f, 
    0.10429118f, 0.15218823f, -0.03781146f, -0.01665652f, 0.01539931f, -0.02133016f, 0.09382398f, -0.00296242f, 
    -0.06009012f, -0.07170125f, 0.02652323f, 0.10666446f, 0.01907020f, 0.21207657f, 0.02499612f, -0.13158974f, 
    0.41835931f, -0.03087121f, 0.04534188f, -0.03030591f, 0.07312486f, -0.06779701f, 0.09069967f, -0.02189231f, 
    -0.04733365f, 0.04409516f, -0.11654578f, -0.06661946f, 0.08289130f, 0.07711422f, 0.03924817f, -0.00728324f, 
    -0.01397614f, 0.06048016f, 0.03175695f, 0.04274353f, 0.07476370f, 0.07750814f, -0.02598035f, 0.15131371f, 
    0.02677746f, 0.22977914f, 0.02634860f, -0.03200647f, -0.10087182f, -0.07357655f, 0.11122923f, 0.08300143f, 
    -0.10267279f, -0.03068142f, 0.01239544f, 0.03590493f, -0.15334216f, -0.24589027f, -0.14114952f, -0.01602211f, 
    0.11009431f, 0.05289819f, -0.04152586f, -0.03125819f, 0.03781880f, -0.08281673f, -0.02255000f, 0.12221779f, 
    -0.13464305f, -0.11011364f, -0.04411115f, -0.06269085f, -0.11161704f, -0.12779872f, 0.05819704f, 0.00166272f, 
    -0.00882472f, 0.10926180f, 0.09006089f, 0.06448174f, -0.10418113f, 0.24606045f, 0.12211912f, -0.13543575f, 
    -0.14966413f, -0.17301717f, 0.07117525f, 0.06459220f, 0.11912556f, -0.12508059f, -0.10191421f, 0.04517508f, 
    0.03724649f, -0.26922560f, 0.07947928f, -0.05337772f, 0.01294520f, -0.08915190f, -0.15028515f, -0.03353315f, 
    -0.05177821f, -0.06410718f, -0.05114255f, -0.06834039f, -0.30504537f, -0.16358577f, -0.16367388f, 0.01627916f, 
    0.01692460f, 0.05426482f, 0.06330934f, 0.01202982f, -0.03503877f, -0.01594524f, 0.04417685f, 0.01413622f, 
    0.04374575f, 0.19598252f, 0.03785698f, 0.08666710f, 0.14912464f, 0.17578837f, 0.26947740f, 0.20331831f, 
    0.02865815f, 0.11303389f, 0.09065028f, 0.16850910f, 0.11127590f, 0.26336813f, -0.25826073f, -0.16551751f, 
    0.11328904f, 0.08736670f, 0.06709758f, 0.23027708f, 0.04620445f, 0.02346097f, 0.06802922f, 0.05591328f, 
    0.08836154f, -0.10919478f, 0.11567228f, -0.17353699f, 0.03393084f, 0.11737658f, 0.02798272f, 0.11332506f, 
    0.04036896f, -0.03062828f, -0.12554932f, 0.13799334f, -0.01019200f, -0.04185717f, -0.09364565f, 0.01619750f, 
    -0.00125788f, 0.01366286f, -0.06404564f, 0.06436546f, 0.32487538f, -0.09639344f, 0.12212241f, 0.01119523f, 
    -0.00054758f, 0.19310047f, 0.29043037f, -0.26138607f, -0.04186910f, -0.04949717f, 0.10757536f, 0.02654515f, 
    0.06541705f, 0.00504062f, -0.17680170f, 0.10703654f, -0.67420983f, 0.43663427f, 0.34052876f, 0.19639376f, 
    -0.26752889f, 0.03578174f, 0.09965448f, 0.16719279f, 0.03067908f, -0.18930995f, -0.27237833f, -0.07014848f, 
    -0.00944115f, 0.12436572f, -0.06417401f, 0.08875894f, 0.08547907f, 0.12386242f, -0.12279980f, 0.04073912f, 
    0.14769213f, 0.16612448f, -0.12085217f, 0.01464947f, 0.01086040f, 0.04711813f, -0.35874817f, 0.06835920f, 
    0.10505631f, 0.13580510f, 0.11287682f, -0.00652007f, -0.04709307f, -0.06842686f, -0.11718052f, -0.12990823f, 
    0.54959577f, 0.21604478f, 0.08371694f, 0.03530016f, 0.14693606f, 0.14213520f, 0.05316722f, -0.06367122f, 
    0.03606094f, 0.01183068f, 0.08028129f, -0.02280856f, 0.19272165f, 0.09562287f, -0.03261306f, 0.11617704f, 
    0.01180407f, 0.00202134f, 0.16009486f, -0.14495322f, -0.01926664f, 0.12077799f, 0.18361343f, 0.05010561f, 
    0.24987853f, 0.26906714f, 0.25570738f, 0.05835345f, 0.01703213f, 0.03044827f, 0.08920532f, 0.04792203f, 
    0.09075291f, 0.04759804f, 0.03342448f, 0.14019136f, -0.27457261f, -0.04637806f, -0.38641793f, -0.18622792f, 
    -0.03106141f, 0.03465572f, -0.01597465f, -0.21999159f, -0.10004631f, 0.06715801f, 0.00641350f, 0.06745509f, 
    -0.12793192f, -0.34061053f, -0.17743245f, -0.12675853f, 0.00379561f, 0.05012764f, -0.00472451f, -0.04270252f, 
    -0.12276967f, -0.14608781f, 0.03387361f, -0.18762521f, -0.28052893f, 0.21227840f, 0.22507410f, -0.02299353f, 
    0.05933133f, 0.12323739f, -0.13844062f, -0.08868349f, 0.00386039f, 0.00003982f, 0.22569583f, -0.04439623f, 
    -0.35386884f, -0.44341731f, -0.19482100f, -0.14908002f, 0.06724901f, -0.33491281f, 0.01234302f, 0.01388484f, 
    -0.19350806f, -0.02454087f, 0.16072796f, 0.24936607f, -0.41346440f, -0.28188750f, -0.09426365f, -0.27211800f, 
    0.07215369f, 0.07778465f, -0.11123931f, -0.03767079f, -0.10403201f, -0.09556231f, 0.04482266f, 0.16443443f, 
    0.10018027f, 0.31202924f, 0.21841066f, 0.12496307f, -0.07646334f, -0.03030298f, 0.06539652f, -0.04370705f, 
    -0.03774288f, -0.12431871f, -0.12400276f, -0.15670565f, 0.27158016f, 0.08317890f, 0.14838693f, -0.01996465f, 
    0.01797118f, -0.09006721f, 0.06269611f, 0.06387546f, 0.03336614f, 0.02201884f, -0.04217369f, 0.06637909f, 
    0.10611147f, 0.15963514f, 0.13459156f, 0.05630040f, -0.15489678f, 0.09646818f, -0.02642371f, 0.10628642f, 
    -0.09194882f, 0.01794462f, -0.01214712f, -0.01176705f, -0.26183444f, -0.05442157f, 0.01236392f, -0.26698875f, 
    0.00235154f, 0.01384379f, -0.05519525f, 0.15332580f, 0.01768554f, -0.10297129f, -0.09054440f, -0.03178288f, 
    -0.03375007f, -0.09003248f, -0.13309371f, -0.03882385f, -0.14253366f, 0.03362526f, -0.03943324f, -0.13554707f, 
    0.02067373f, -0.00883732f, -0.05489262f, -0.31369564f, -0.55077910f, 0.23627359f, 0.09955677f, -0.10043434f, 
    0.03580768f, 0.10945345f, 0.14475890f, -0.03684375f, -0.00224578f, 0.07831097f, -0.17700696f, 0.14715774f, 
    -0.04537620f, 0.04439535f, 0.03963229f, 0.00392826f, -0.00645794f, 0.04778060f, -0.01160711f, 0.04957578f, 
    -0.01830540f, -0.04846642f, -0.03353724f, -0.05341759f, -0.01337881f, -0.07482681f, 0.06070118f, -0.04104719f, 
    -0.04213039f, -0.04474187f, 0.05698276f, 0.03822358f, -0.01529585f, -0.07121980f, 0.01938612f, -0.00651034f, 
    -0.05102051f, 0.03239965f, -0.05981013f, -0.02259458f, -0.07071950f, 0.01806229f, -0.01191982f, 0.01386185f, 
    -0.01361164f, -0.00089879f, -0.05026140f, -0.05393964f, -0.04639737f, -0.03415116f, -0.03969234f, -0.03546837f, 
    0.04880716f, -0.04982151f, -0.04240207f, -0.02584350f, -0.01013363f, 0.03348713f, -0.00229149f, -0.07830711f, 
    0.04731187f, 0.02483682f, -0.05342631f, 0.00674131f, 0.02581093f, 0.00582920f, 0.02274846f, 0.05013745f, 
    -0.05602830f, 0.06116842f, -0.00023377f, -0.01733682f, 0.06485596f, 0.00656001f, 0.00655708f, 0.01929262f, 
    0.00185941f, -0.04089611f, -0.07853397f, -0.02635346f, -0.07523540f, 0.05739078f, -0.02557065f, -0.01044534f, 
    -0.02942283f, -0.02295427f, -0.04116535f, -0.00535215f, -0.00179152f, -0.04167365f, -0.00921636f, 0.05301077f, 
    0.03564921f, -0.00912220f, -0.06824759f, 0.04070430f, -0.05487343f, 0.00141950f, -0.00729934f, 0.02471559f, 
    -0.07325497f, 0.01226814f, 0.05929458f, 0.01738922f, -0.05681886f, -0.03214989f, 0.06066241f, -0.01891957f, 
    -0.05265577f, -0.05149964f, 0.02121805f, 0.05565517f, -0.02572305f, 0.05203658f, -0.00474614f, -0.03988055f, 
    -0.07741836f, -0.03983558f, -0.00102778f, 0.03194088f, 0.04766048f, -0.02264562f, -0.03943703f, 0.05517768f, 
    0.02799321f, -0.01136179f, -0.00781417f, 0.00672614f, 0.05228795f, -0.05733449f, -0.04676374f, 0.02374277f, 
    0.02055456f, -0.06928950f, 0.05767429f, -0.01425709f, -0.01213580f, -0.00543277f, -0.03990372f, 0.02862224f, 
    0.01882758f, 0.04247797f, 0.04623596f, -0.04799723f, 0.03238926f, -0.02171012f, -0.04974835f, -0.05628933f, 
    -0.00483726f, 0.04398860f, -0.07610605f, -0.06171485f, -0.06303017f, 0.05818637f, 0.00065245f, -0.03808571f, 
    -0.03088348f, 0.00321854f, 0.03756878f, 0.04636805f, -0.04031419f, -0.00908079f, 0.00225438f, 0.02106730f, 
    -0.03489464f, -0.05666127f, -0.01650455f, -0.03589826f, 0.05069346f, -0.06959539f, -0.00526039f, -0.03544467f, 
    0.01930461f, 0.01668741f, -0.02760085f, 0.03165298f, -0.04068254f, 0.00763163f, 0.04325323f, -0.03456955f, 
    0.00054382f, -0.00593308f, -0.06684763f, -0.07436043f, -0.02004288f, 0.05804259f, -0.00911542f, -0.03932560f, 
    -0.04537348f, -0.01464806f, -0.01360881f, 0.02826233f, -0.02636381f, -0.02291352f, 0.02721053f, -0.05823609f, 
    -0.00231416f, 0.04411829f, 0.00745768f, 0.03843698f, 0.04895824f, 0.03250116f, -0.05900218f, -0.05338046f, 
    0.10112666f, 0.20801117f, -0.21959886f, 0.25037241f, 0.12612626f, 0.08151010f, -0.06312054f, -0.05306662f, 
    0.21732399f, 0.15653014f, -0.07638232f, -0.01098432f, -0.25285536f, 0.03353435f, -0.30970749f, 0.13256142f, 
    -0.05126180f, 0.04353724f, 0.13832660f, 0.04937951f, -0.21606790f, 0.07856495f, -0.09998615f, -0.10720100f, 
    0.54112053f, 0.08020422f, 0.05137568f, 0.12587257f, 0.16303462f, 0.11168358f, 0.12719405f, -0.11096547f, 
    -0.04759537f, -0.03697023f, 0.08565082f, -0.03226910f, 0.18223493f, -0.00510638f, -0.27115276f, 0.15608624f, 
    0.01917649f, -0.00965800f, 0.08451236f, -0.16887020f, 0.08330940f, 0.00816416f, 0.17854184f, -0.00744712f, 
    0.03364907f, 0.00897499f, -0.00207311f, -0.02720525f, 0.09572510f, -0.15726945f, -0.00593062f, -0.02828132f, 
    -0.08011182f, 0.07423559f, -0.04908114f, 0.02504290f, -0.16537176f, 0.31815806f, -0.01303994f, -0.33370224f, 
    -0.16957635f, -0.11406074f, 0.11095183f, -0.00307055f, -0.11512744f, 0.04667529f, -0.05388067f, 0.07729957f, 
    0.05707633f, 0.09545659f, 0.05244755f, -0.11200748f, 0.00054844f, -0.03079019f, -0.00440880f, -0.08110908f, 
    -0.06733862f, -0.06036821f, 0.06856167f, -0.05748664f, 0.03885746f, 0.28711826f, 0.32107016f, -0.18883997f, 
    -0.04848586f, 0.21862765f, 0.01316803f, -0.00731838f, 0.02336343f, 0.06473482f, 0.01338210f, 0.00904325f, 
    -0.22276253f, -0.08714339f, -0.23172794f, -0.16467166f, -0.11637676f, -0.33176613f, -0.03329692f, 0.06275329f, 
    -0.15181154f, 0.04058175f, 0.12770936f, 0.08527471f, -0.06388579f, 0.01572818f, 0.15395971f, -0.13768165f, 
    -0.01583250f, -0.12013113f, -0.06359377f, 0.13840921f, -0.07475418f, 0.08122461f, -0.00917307f, 0.03081638f, 
    0.12674379f, 0.11078065f, 0.05762855f, 0.04310259f, -0.04360358f, 0.03430327f, 0.08748508f, -0.04420497f, 
    -0.09970375f, -0.07201700f, -0.11162280f, -0.12577780f, -0.10284076f, 0.19551094f, -0.30077097f, -0.22591762f, 
    -0.09534082f, -0.14238575f, 0.05496938f, -0.00641544f, 0.07630698f, 0.07596964f, -0.01742858f, -0.05001974f, 
    -0.05036590f, -0.01393750f, 0.03116835f, -0.24335536f, -0.09705950f, 0.12652235f, -0.07432967f, 0.04219563f, 
    0.09553445f, 0.05007313f, -0.15307701f, 0.08190729f, -0.26096091f, 0.21781282f, -0.05049234f, -0.23171346f, 
    0.01549417f, 0.10870072f, 0.09194814f, -0.02474019f, 0.27999443f, 0.00595930f, 0.11156441f, -0.07568462f, 
    0.08854198f, -0.05044318f, -0.04574890f, 0.20563124f, -0.10780019f, 0.23451979f, -0.18924610f, -0.07794134f, 
    0.05241670f, 0.22103330f, -0.21761291f, 0.01537024f, -0.33140633f, 0.38915586f, -0.21640332f, -0.02069882f, 
    0.25432727f, 0.15558554f, 0.14448212f, -0.00560963f, 0.01656897f, 0.07044645f, -0.06712714f, -0.01680072f, 
    0.05590503f, -0.26093149f, 0.21288419f, -0.05631585f, -0.08659522f, 0.10938633f, 0.14799334f, 0.00917377f, 
    0.04035997f, 0.01155016f, 0.24899328f, 0.26678228f, 0.21007550f, -0.10799669f, -0.10124820f, -0.11390529f, 
    0.05307096f, -0.13443179f, -0.11472999f, -0.08059586f, 0.04157763f, 0.04977608f, -0.07055303f, -0.16214304f, 
    -0.09764622f, 0.03031244f, -0.03073195f, 0.13695320f, 0.07445616f, 0.19526915f, 0.08186349f, 0.05944948f, 
    0.12660500f, -0.03258786f, -0.02496308f, 0.26223356f, 0.08673465f, -0.09158583f, 0.29577485f, 0.07198856f, 
    0.02811619f, -0.08123509f, -0.02027054f, 0.20772663f, 0.07340312f, 0.16236389f, 0.22622582f, 0.26633069f, 
    0.24060588f, -0.02269079f, 0.21584444f, 0.08361280f, 0.14177966f, 0.12295524f, 0.09581777f, -0.01146285f, 
    0.05786367f, -0.08359432f, 0.19300085f, 0.15955946f, -0.01214001f, -0.22296919f, 0.11646592f, 0.14558591f, 
    0.17692254f, -0.03133805f, 0.00171479f, 0.14334317f, 0.01006684f, -0.10770448f, -0.02544774f, -0.04654161f, 
    -0.16587548f, -0.28606677f, -0.17112337f, 0.21207058f, 0.04044544f, 0.00395550f, -0.14376830f, 0.01403783f, 
    -0.06690147f, -0.26315004f, -0.35715830f, -0.19321860f, 0.14745191f, 0.00571467f, -0.21944161f, 0.16771565f, 
    0.02524676f, 0.11083519f, -0.13347735f, -0.03464958f, -0.05438662f, -0.02169954f, -0.01217108f, 0.19068556f, 
    -0.00177371f, 0.26605573f, -0.30150566f, 0.00717657f, 0.14570761f, -0.18912387f, -0.15694894f, -0.20154254f, 
    0.12689909f, -0.12613021f, 0.03745742f, -0.00145285f, -0.19917680f, -0.59030330f, 0.01185898f, 0.13711172f, 
    0.08607775f, 0.15476155f, -0.04871481f, -0.08410245f, 0.14998202f, -0.00110836f, 0.09380046f, 0.11447766f, 
    0.12266178f, 0.11166783f, -0.03901162f, 0.01218051f, 0.09734569f, -0.03750536f, -0.04751989f, -0.09451482f, 
    -0.01619685f, -0.20302279f, -0.10814326f, -0.10828134f, 0.40397379f, -0.03280733f, 0.41835424f, 0.13594677f, 
    -0.04448719f, -0.05094239f, 0.04037615f, 0.04946470f, 0.11071221f, -0.03760993f, -0.03165983f, -0.00060743f, 
    0.26827124f, 0.40068856f, -0.01732123f, 0.08566609f, 0.11544289f, 0.09403563f, 0.09943526f, -0.08446752f, 
    -0.10689662f, -0.04479701f, -0.00633000f, -0.04284311f, 0.05003587f, -0.29695994f, -0.06897665f, -0.00831113f, 
    0.02340066f, -0.08648284f, -0.02469321f, 0.16251232f, -0.17686577f, 0.04222425f, 0.02035022f, -0.12787719f, 
    0.13438946f, -0.07950187f, -0.24358545f, -0.20527840f, 0.04010119f, -0.29712868f, -0.06614583f, 0.02710520f, 
    -0.11699381f, -0.02465132f, 0.03372598f, 0.08138859f, 0.26157573f, -0.16895309f, 0.33704081f, 0.10917910f, 
    -0.04872667f, -0.15992588f, -0.07424752f, -0.09822021f, 0.08814540f, -0.02222373f, 0.09606870f, -0.07383949f, 
    -0.11935136f, 0.03863376f, -0.00680227f, 0.07747466f, 0.08434242f, -0.09051587f, -0.00948508f, 0.14613059f, 
    -0.06193573f, 0.03807002f, -0.10943539f, -0.01056467f, -0.16892630f, 0.11743613f, 0.18209347f, -0.02782474f, 
    -0.04373470f, 0.02161991f, 0.09917589f, 0.04797674f, 0.15817343f, 0.11954891f, 0.16795242f, 0.11694499f, 
    -0.01473488f, -0.07207435f, 0.53022236f, 0.31675655f, -0.00599877f, -0.07660341f, -0.02354648f, 0.07273341f, 
    0.12506886f, 0.15532745f, -0.00042929f, 0.07484663f, -0.17168969f, 0.03832443f, 0.18125527f, 0.13300055f, 
    0.03395836f, 0.07094117f, -0.04822508f, 0.08300722f, 0.04797506f, 0.03954290f, -0.08997079f, 0.04242342f, 
    -0.40855557f, -0.11093739f, -0.17111425f, 0.21206726f, -0.13742882f, 0.12162066f, 0.06815732f, -0.15173125f, 
    -0.00764186f, -0.02174309f, 0.00251662f, -0.09005730f, -0.26180854f, 0.04149063f, 0.05230435f, 0.02678583f, 
    -0.00145716f, -0.16118994f, -0.01295860f, -0.11505386f, -0.03552862f, -0.05821482f, 0.10566344f, 0.03837969f, 
    -0.17256093f, 0.09313612f, -0.04064716f, -0.11692865f, -0.12314190f, -0.15788344f, -0.04214009f, -0.07702320f, 
    0.07109611f, 0.18257257f, 0.10953090f, 0.05438514f, 0.78745252f, 0.20683265f, 0.15259512f, 0.67438394f, 
    0.01645228f, -0.06172577f, 0.10297608f, 0.04459367f, 0.07108902f, 0.17040630f, 0.02969274f, 0.00477515f, 
    -0.14607866f, -0.21508792f, 0.23983033f, 0.04914508f, 0.01905346f, 0.06040869f, -0.02555128f, -0.08435656f, 
    -0.05444768f, 0.00184249f, -0.11444248f, -0.00055170f, -0.51710308f, 0.10496429f, -0.29242796f, -0.36750653f, 
    -0.35044506f, -0.26906168f, -0.00709979f, -0.18410923f, 0.05569800f, 0.12363280f, -0.11474761f, -0.05416928f, 
    -0.15379991f, -0.24231890f, -0.09292670f, 0.13276999f, -0.04404704f, 0.06103757f, 0.11899137f, 0.05578408f, 
    -0.00197287f, 0.02910509f, 0.02361644f, 0.02723742f, -0.55719233f, 0.27297953f, -0.41717428f, 0.22853895f, 
    0.08664007f, 0.10613249f, 0.10829669f, 0.04591193f, 0.02439284f, -0.01133271f, -0.03596804f, 0.06992740f, 
    0.00360780f, -0.35930470f, -0.03688581f, -0.08560658f, 0.16650771f, -0.07047372f, 0.02589653f, -0.00734184f, 
    -0.00501340f, 0.11123942f, -0.00323282f, 0.02698551f, -0.09165193f, 0.16213030f, -0.21201608f, -0.13621277f, 
    -0.06646751f, -0.03632703f, -0.15661076f, -0.18429881f, 0.09388009f, 0.04838764f, 0.03055228f, 0.12140452f, 
    0.14616264f, 0.13942763f, 0.14502284f, 0.05187675f, 0.08021909f, 0.08362635f, 0.18923308f, 0.10899972f, 
    -0.00674402f, 0.08757568f, 0.06517237f, 0.25518292f, 0.15031911f, -0.01123024f, -0.35766014f, 0.07395693f, 
    -0.06882865f, -0.03394227f, 0.09081201f, 0.02564761f, -0.03251971f, 0.03461229f, 0.03488580f, -0.04388091f, 
    0.12604655f, -0.16298519f, 0.17672449f, -0.12170068f, -0.06520541f, -0.09765915f, 0.16994734f, 0.08637425f, 
    0.09460418f, -0.04718272f, 0.32629648f, 0.09134138f, 0.01169794f, -0.02818346f, 0.22272296f, -0.05737015f, 
    0.07538689f, 0.00152235f, -0.15567343f, -0.04326230f, -0.02078484f, -0.09638474f, 0.17778504f, 0.11422005f, 
    -0.49520290f, 0.11006910f, -0.08212399f, -0.02578156f, -0.03348958f, -0.05825737f, 0.01080893f, 0.12075899f, 
    0.04886961f, 0.05137457f, 0.05365992f, 0.13257664f, -0.07759876f, 0.09987888f, 0.29071707f, -0.06537320f, 
    0.02905057f, 0.00493125f, -0.11427203f, 0.13350518f, 0.00473429f, 0.14511558f, 0.06036572f, 0.02938458f, 
    0.06393193f, -0.18031442f, -0.07873969f, 0.01087144f, 0.06348098f, 0.02303528f, 0.02038659f, 0.01942564f, 
    0.10598370f, 0.00751158f, 0.03465107f, 0.08683602f, 0.09475918f, -0.13683656f, -0.11397628f, 0.12504794f, 
    0.08935422f, 0.10544971f, 0.04556754f, 0.07142982f, 0.04188580f, 0.00281329f, -0.06175441f, -0.07003493f, 
    0.03548440f, -0.06952765f, -0.01554276f, 0.06362693f, 0.03632220f, 0.09329709f, 0.05138283f, 0.08225264f, 
    0.11633103f, -0.00551015f, 0.02011443f, 0.10595518f, -0.19723931f, -0.34285215f, -0.28890577f, 0.09885093f, 
    0.05856423f, -0.02788370f, 0.09036727f, 0.03408975f, -0.04621359f, 0.03009355f, 0.02934599f, 0.08723606f, 
    -0.02987343f, 0.02753180f, 0.03435726f, 0.01462169f, 0.00583098f, 0.22598425f, 0.14905348f, -0.06499396f, 
    0.11898796f, 0.02489162f, -0.06067155f, 0.03783111f, 0.23969220f, -0.06589942f, -0.10041855f, 0.04197569f, 
    -0.01689347f, 0.08762910f, 0.06132616f, -0.08713816f, -0.03596810f, -0.03845682f, 0.01718742f, -0.13345401f, 
    -0.09556772f, -0.08829073f, -0.02480685f, 0.05563323f, -0.07342692f, -0.07876179f, -0.17820595f, -0.07117843f, 
    0.05187462f, 0.05828702f, 0.01251024f, 0.04069636f, -0.01153462f, -0.36049929f, 0.32675305f, 0.33692545f, 
    -0.01773906f, 0.15577291f, 0.03220408f, -0.02834454f, -0.07471587f, -0.01895547f, 0.03606029f, 0.09448873f, 
    -0.14440370f, 0.09871536f, -0.04456799f, 0.23613235f, -0.00136383f, -0.02678110f, 0.03472578f, -0.00070712f, 
    -0.06962571f, 0.09738615f, 0.19799732f, -0.11733158f, 0.03019226f, -0.24320592f, 0.03425621f, 0.04740825f, 
    0.08241141f, -0.07937226f, -0.07203548f, -0.02977893f, -0.22626230f, 0.23884526f, -0.06261189f, 0.13392906f, 
    -0.08989263f, 0.07844502f, 0.04931653f, 0.06506717f, 0.26570314f, -0.04849052f, 0.03592945f, 0.02132261f, 
    -0.11321139f, -0.00176920f, 0.34690186f, -0.08423284f, 0.76089621f, -0.44451827f, 0.12214068f, 0.22880399f, 
    0.06132419f, -0.05449332f, -0.04262738f, -0.13285448f, 0.13242908f, 0.11821242f, 0.09611456f, -0.03555745f, 
    -0.04806163f, 0.04821566f, -0.02310325f, 0.14502645f, 0.04314284f, -0.06124209f, 0.02186552f, -0.17718431f, 
    -0.01089568f, 0.00205337f, -0.01904171f, -0.05009750f, 0.16803785f, -0.20836098f, 0.17177372f, 0.02662070f, 
    -0.08715180f, -0.00425673f, -0.11881793f, -0.10309529f, 0.21120369f, 0.07034325f, 0.09145688f, 0.12219559f, 
    -0.28520069f, 0.12495337f, -0.36110908f, -0.11837698f, -0.10630281f, -0.22038756f, -0.09452064f, 0.04217232f, 
    -0.00675851f, -0.05280245f, -0.09830394f, -0.14836845f, 0.08382670f, -0.13283050f, 0.05569714f, -0.04765341f, 
    0.00475970f, -0.07278708f, -0.11446957f, 0.01769704f, 0.02499156f, -0.12222511f, -0.17342655f, -0.11428478f, 
    0.09908035f, 0.18345620f, 0.17443588f, -0.12738436f, 0.15940487f, -0.05690213f, -0.02606624f, 0.22441454f, 
    0.00709018f, -0.04690181f, -0.19825904f, -0.16427664f, 0.27675802f, 0.02952764f, -0.05510690f, 0.01981325f, 
    -0.04017868f, 0.11745685f, -0.26269269f, 0.04087338f, -0.14710636f, -0.02439919f, -0.14192258f, -0.14801407f, 
    -0.00804482f, 0.17723839f, 0.12329493f, -0.11672716f, 0.12014355f, 0.14228721f, -0.01264696f, -0.07805686f, 
    0.11418774f, 0.23151261f, 0.17221576f, 0.22050989f, -0.73925555f, 0.07128509f, 0.09679202f, -0.33910435f, 
    -0.05172531f, -0.18239792f, 0.20137964f, -0.02183649f, 0.09852008f, -0.00026504f, -0.09536771f, -0.02774806f, 
    0.30621347f, 0.03706899f, 0.08061216f, -0.10732268f, -0.15493910f, 0.10783795f, 0.00227816f, 0.02399028f, 
    0.08642951f, 0.13933955f, -0.08634289f, 0.08491255f, 0.11556261f, 0.09382550f, -0.14943951f, 0.06486655f, 
    0.07271443f, -0.00494292f, 0.03039128f, -0.05825452f, -0.08087021f, -0.14047948f, 0.01828660f, -0.16794513f, 
    0.02055228f, 0.08944200f, 0.15826482f, -0.05796685f, 0.09147044f, 0.09403960f, 0.19959392f, 0.11834160f, 
    -0.04705647f, 0.09982719f, 0.03014933f, 0.07004146f, 0.26568824f, -0.13115920f, 0.08304182f, -0.28776273f, 
    -0.02011772f, -0.01782408f, 0.16474082f, -0.01317937f, 0.01997399f, 0.03962068f, -0.02161808f, -0.08390702f, 
    -0.07373425f, 0.25057682f, 0.06976250f, 0.02447504f, 0.00127645f, 0.10502103f, 0.04570732f, 0.10410339f, 
    0.11382119f, -0.00055027f, 0.01345017f, 0.18218961f, 0.04156126f, -0.11928841f, -0.08939809f, 0.07455177f, 
    -0.15917535f, -0.06248727f, -0.05405462f, -0.24643868f, 0.11209771f, 0.02039121f, 0.09643902f, 0.21950802f, 
    -0.00519165f, 0.16034505f, 0.25346196f, 0.18249978f, 0.16853651f, 0.21901767f, 0.01070571f, 0.13222416f, 
    0.18341078f, -0.02902815f, 0.03504258f, -0.06940682f, -0.23483704f, -0.07169908f, 0.21201608f, 0.31057209f, 
    0.06110580f, 0.03429534f, -0.06198602f, 0.01201145f, 0.08256954f, 0.02829845f, 0.12839364f, -0.03245446f, 
    -0.01650792f, -0.01807191f, -0.02434153f, 0.05022485f, -0.03873566f, -0.07473648f, -0.03732774f, 0.04535534f, 
    0.01362857f, 0.04924754f, -0.04097069f, 0.05671655f, -0.01998678f, -0.06150004f, 0.02485240f, 0.06321461f, 
    -0.03559415f, 0.00733603f, 0.06556399f, -0.04997519f, 0.02846207f, -0.06453837f, 0.04085627f, 0.01007791f, 
    -0.07349323f, -0.04001757f, 0.00819603f, -0.05782416f, -0.00174882f, -0.00581485f, -0.05942849f, -0.05192952f, 
    0.05685234f, -0.07574607f, 0.00234409f, -0.01666382f, 0.05320259f, -0.01770751f, 0.04654276f, -0.02326410f, 
    0.03864854f, 0.02156161f, -0.00821336f, -0.07464444f, 0.01613942f, 0.00448141f, -0.03992136f, -0.07417259f, 
    -0.02185469f, 0.06745166f, -0.02926980f, 0.04811363f, -0.05117390f, 0.02279416f, -0.04005765f, 0.05106358f, 
    -0.04613449f, -0.04748154f, 0.02212245f, -0.05841726f, 0.02027479f, -0.00432120f, 0.01892287f, -0.01679407f, 
    0.03757100f, -0.06928527f, 0.01582982f, 0.03397607f, -0.07169504f, -0.02479809f, -0.04463399f, -0.07204535f, 
    -0.02159581f, 0.01171599f, 0.01697283f, -0.04203375f, -0.01815551f, 0.05150549f, 0.00521843f, -0.05705089f, 
    -0.03196119f, -0.03985801f, -0.04087026f, -0.03703769f, -0.02153968f, -0.00060938f, -0.06032423f, 0.05673511f, 
    -0.04406239f, 0.05386443f, -0.01128820f, -0.03686816f, -0.01921691f, 0.02162715f, -0.03809129f, 0.02812154f, 
    -0.04770770f, 0.02511917f, -0.05890065f, 0.01140908f, -0.01506644f, -0.03779752f, -0.05298434f, -0.00213015f, 
    -0.02977953f, -0.05373584f, 0.00442370f, -0.06717133f, 0.04750952f, -0.01701331f, -0.04966046f, 0.05993582f, 
    0.00389062f, 0.01535429f, -0.05545640f, -0.05070880f, -0.02026352f, -0.06556923f, -0.04943058f, -0.06812041f, 
    -0.02140007f, -0.07381439f, 0.05791620f, 0.03860935f, -0.06711891f, -0.03479322f, -0.02780198f, 0.00026676f, 
    -0.02423916f, 0.03551569f, 0.03893523f, 0.04327993f, -0.06799828f, 0.03682209f, 0.03596578f, 0.00508851f, 
    -0.03250362f, 0.00933857f, 0.05533125f, 0.04203949f, -0.04502473f, -0.03438008f, 0.04232397f, 0.05314170f, 
    0.03652085f, -0.04487814f, -0.01906563f, 0.05711561f, 0.06059669f, 0.05226289f, -0.02492706f, -0.06409329f, 
    -0.04895192f, -0.05111280f, 0.02429908f, -0.00674986f, -0.06136655f, -0.01664219f, -0.00974151f, -0.02935817f, 
    -0.02593837f, 0.04673565f, 0.04299227f, 0.02109751f, -0.00974873f, -0.07786327f, -0.01559185f, -0.07008446f, 
    -0.05010737f, 0.00533071f, -0.05322544f, 0.00464998f, 0.02845688f, -0.02149916f, 0.02615810f, -0.03832507f, 
    -0.07121187f, 0.04971472f, 0.02686874f, 0.00819034f, 0.06017573f, 0.02314113f, 0.01481049f, 0.04806687f, 
    -0.07549915f, -0.00728086f, 0.02100346f, -0.06482182f, -0.07034040f, -0.03474121f, -0.04676067f, -0.04271162f, 
    0.02083235f, 0.02907588f, -0.04009121f, 0.00656860f, 0.00472235f, -0.07938091f, -0.06457143f, -0.03439034f, 
    -0.07147401f, -0.05973748f, -0.04210154f, 0.02373866f, -0.04929505f, 0.02929094f, -0.04435393f, 0.02214978f, 
    0.05729575f, 0.00570436f, 0.00843669f, -0.02783955f, 0.00346753f, 0.04314642f, -0.00871143f, 0.00725680f, 
    -0.01489836f, 0.01554518f, -0.04945992f, 0.01895968f, 0.04384621f, 0.03442892f, 0.05992832f, -0.06555235f, 
    -0.05111168f, 0.00863707f, -0.00566402f, -0.06890514f, -0.00902205f, 0.06167164f, -0.03198987f, 0.00484756f, 
    0.02279557f, 0.02514480f, -0.08377323f, 0.02807932f, -0.00173000f, 0.03404043f, 0.03829560f, 0.03001656f, 
    0.02653923f, 0.00261906f, -0.07857142f, -0.06244062f, -0.08572684f, 0.05784487f, -0.01716053f, -0.04639689f, 
    0.05539502f, -0.00730746f, -0.02550947f, -0.00383547f, -0.01749481f, -0.03032457f, 0.05753191f, 0.00829151f, 
    0.01512319f, -0.07443951f, 0.02965692f, 0.01563542f, 0.02910456f, -0.04097864f, -0.03370242f, -0.01976555f, 
    -0.05850412f, -0.04028334f, -0.05361132f, -0.05606118f, -0.00099421f, -0.04860339f, 0.00617564f, -0.06363778f, 
    0.04469957f, -0.07336050f, -0.02977155f, -0.01171005f, -0.00991162f, -0.06389804f, -0.04534910f, -0.04381830f, 
    -0.00095332f, 0.02500901f, 0.04876533f, 0.03371659f, 0.04698859f, 0.01330984f, -0.05727214f, 0.03161789f, 
    -0.03313741f, 0.00861758f, -0.03859985f, -0.05047951f, -0.00594485f, 0.04084413f, 0.00219954f, -0.01172731f, 
    0.04458982f, 0.03213468f, -0.03894462f, 0.00597424f, 0.01324856f, -0.00883890f, -0.01843289f, -0.02729553f, 
    -0.02039330f, -0.00344752f, 0.00587905f, -0.07978968f, -0.03682952f, 0.01240361f, -0.01286376f, -0.07485989f, 
    0.00200493f, 0.05021561f, -0.01728617f, 0.01620910f, 0.00848393f, -0.04165609f, 0.04552396f, -0.01767267f, 
    -0.00480264f, -0.03500356f, 0.04637805f, 0.04306675f, -0.03329096f, 0.01768839f, -0.02180054f, -0.05691421f, 
    0.01341127f, -0.00969133f, 0.03642898f, -0.05525991f, -0.07622295f, -0.02190275f, -0.04298837f, 0.05999684f, 
    -0.07676680f, 0.05556191f, -0.06154772f, -0.02813018f, -0.07873072f, 0.02740127f, 0.02445227f, 0.02914869f, 
    0.03976559f, -0.04671498f, 0.02438001f, -0.01529138f, 0.01102068f, -0.00969525f, -0.04941164f, -0.01597136f, 
    0.04060784f, 0.00068681f, -0.07191096f, 0.01940769f, -0.07465184f, 0.04257913f, -0.02065219f, -0.01845709f, 
    0.02988119f, -0.01638750f, -0.04563313f, 0.02975392f, 0.02394678f, -0.01179870f, 0.03570408f, -0.05320564f, 
    -0.05460816f, 0.02703619f, -0.03819499f, 0.04691377f, -0.06652433f, -0.05326912f, -0.04682821f, -0.02796615f, 
    0.01213050f, -0.07040745f, 0.04625109f, -0.07558488f, -0.02497717f, 0.01416444f, 0.05129902f, -0.07500225f, 
    0.23447412f, -0.12972437f, -0.25927663f, 0.06110663f, -0.09384378f, -0.02248670f, -0.00627900f, -0.17833407f, 
    0.05337737f, 0.04096688f, 0.00434884f, -0.04861780f, 0.03982799f, -0.01186295f, 0.04627979f, 0.26149172f, 
    -0.07204425f, -0.02529229f, 0.09945310f, -0.09511215f, 0.14851476f, 0.12695155f, -0.11427619f, 0.15043537f, 
    -0.18277106f, -0.08115401f, -0.37194216f, -0.10360232f, 0.06793711f, 0.03659756f, 0.19790722f, -0.09991980f, 
    -0.20098555f, -0.06865678f, 0.01667847f, -0.00208157f, -0.07498414f, -0.14406404f, -0.22239366f, -0.10711227f, 
    -0.07616927f, 0.04138205f, -0.07620502f, -0.07029116f, -0.02165653f, -0.12550762f, -0.04617923f, -0.05712992f, 
    0.00394593f, -0.11796512f, -0.20880856f, -0.30914089f, 0.11372448f, 0.01819248f, 0.04394016f, 0.24973218f, 
    -0.14460403f, 0.09721626f, 0.04097052f, 0.06929309f, 0.60588068f, 0.40387774f, 0.17055780f, 0.22434072f, 
    -0.15566295f, -0.05214239f, 0.10386565f, -0.12180162f, -0.01240178f, 0.05706004f, -0.07409313f, 0.03583718f, 
    0.14885496f, 0.15458418f, 0.14436559f, 0.02720913f, 0.08967010f, 0.09907177f, -0.10032304f, -0.01092122f, 
    -0.05750589f, -0.13722758f, 0.01858627f, 0.08518591f, -0.60350388f, -0.10892171f, -0.11475760f, -0.44442853f, 
    0.02125269f, -0.12475386f, 0.12005628f, -0.20346251f, -0.07604045f, 0.03936164f, 0.21385956f, -0.07110626f, 
    0.40088600f, 0.19826771f, 0.23215191f, 0.17843997f, -0.07862806f, 0.12932096f, 0.02595783f, -0.02179804f, 
    0.01077613f, -0.02794737f, -0.02905953f, 0.14266758f, 0.37405616f, 0.29742321f, 0.16572644f, 0.06925520f, 
    -0.05570083f, 0.04124628f, -0.06083427f, -0.01983967f, -0.10047574f, 0.04206402f, -0.01255403f, 0.02155522f, 
    0.03935773f, -0.19776750f, -0.19192198f, -0.28483951f, 0.04974413f, -0.01046329f, -0.13434845f, -0.05699606f, 
    -0.13923907f, -0.11821799f, -0.16319199f, -0.16463912f, 0.15826486f, 0.11578823f, 0.12071817f, -0.20703247f, 
    -0.13821520f, 0.17517164f, -0.02645036f, 0.13580638f, -0.03022902f, -0.03281575f, 0.00188807f, -0.15288576f, 
    -0.15429559f, -0.35100064f, -0.04969006f, -0.15816534f, -0.11474476f, -0.03911047f, 0.05608138f, 0.28707609f, 
    -0.00609690f, 0.09217329f, 0.18171105f, -0.00351273f, 0.11130943f, 0.16178639f, 0.05874307f, 0.02408788f, 
    -0.09487309f, -0.23458228f, -0.01479647f, 0.06303022f, 0.37945753f, 0.10618454f, 0.05948278f, 0.11658350f, 
    -0.09297285f, 0.08390117f, 0.04721446f, -0.01589040f, -0.12111679f, 0.21467991f, 0.21797045f, -0.01040427f, 
    0.26633057f, 0.08631869f, -0.02605179f, -0.06027377f, 0.18390404f, 0.30647451f, -0.08725604f, -0.07323620f, 
    0.13340025f, 0.17335150f, -0.03684719f, -0.01479661f, 0.13232324f, -0.11013597f, 0.05383144f, 0.23960091f, 
    0.01722630f, -0.04188852f, -0.07291359f, -0.05885346f, 0.02447532f, -0.00715020f, 0.04943894f, 0.01297543f, 
    -0.05232571f, -0.01135840f, 0.01622655f, 0.05684812f, 0.06453441f, -0.03853181f, 0.06069876f, -0.02695370f, 
    0.02725938f, -0.00453489f, -0.01046506f, -0.04682545f, -0.04692502f, -0.07279968f, 0.03321126f, -0.03907646f, 
    -0.03633757f, -0.03329439f, 0.00090083f, 0.04836380f, 0.06206691f, -0.04065771f, -0.04090887f, -0.01296262f, 
    0.00698945f, 0.00327266f, 0.00775240f, -0.06290238f, -0.00666553f, -0.04691001f, -0.02267716f, 0.03932829f, 
    0.06690553f, -0.03331716f, 0.01335244f, 0.02991850f, 0.04143982f, -0.06818784f, -0.03264529f, 0.01873141f, 
    -0.06345937f, 0.05684829f, 0.06208567f, 0.05684617f, -0.05699844f, 0.01761740f, -0.04335133f, -0.05435134f, 
    0.01794308f, 0.02556373f, -0.00814073f, 0.04673783f, -0.02065784f, -0.05192366f, 0.01945803f, -0.02765964f, 
    -0.02732270f, 0.02185675f, 0.04395884f, -0.05853478f, -0.07295582f, -0.07213876f, 0.02141481f, -0.04374385f, 
    0.04623612f, -0.01676152f, 0.01394095f, -0.05211895f, -0.04697580f, -0.02558239f, 0.05867668f, -0.03994443f, 
    0.06066014f, 0.02816687f, 0.06081986f, -0.04532281f, -0.02309421f, -0.07692426f, 0.02763469f, -0.06621077f, 
    0.00938971f, 0.06906519f, 0.03254539f, -0.00069415f, -0.03711531f, -0.06839149f, -0.03201124f, 0.00473937f, 
    -0.05815789f, -0.00513538f, -0.02665192f, 0.05828562f, 0.02689077f, -0.04231359f, -0.00999026f, 0.00748995f, 
    0.05283101f, -0.00394753f, 0.00619333f, 0.02169945f, 0.05970174f, 0.03746184f, -0.01680144f, -0.04086231f, 
    -0.03679778f, 0.03190281f, -0.05045021f, 0.05956797f, -0.07181246f, -0.01625397f, -0.00393409f, 0.04558483f, 
    0.05034913f, -0.01282395f, -0.05184008f, -0.04826315f, -0.06544569f, -0.05761780f, -0.02730599f, -0.07106543f, 
    -0.02360175f, -0.05752493f, -0.00749420f, 0.06002300f, -0.04512335f, 0.00488649f, 0.05577097f, -0.05487234f, 
    0.01531320f, 0.00312847f, -0.00470374f, -0.03901542f, 0.02445854f, -0.04935208f, -0.02665775f, -0.00955092f, 
    0.06598884f, -0.03510837f, -0.03241867f, 0.02541647f, 0.05676116f, -0.03333576f, -0.04156900f, -0.02337352f, 
    0.02017072f, 0.03742329f, -0.02597462f, 0.05985118f, -0.02253320f, 0.01247465f, -0.06619394f, -0.05670227f, 
    -0.04527199f, -0.00474087f, 0.02241531f, 0.01593550f, -0.06334434f, -0.03515071f, -0.05366748f, -0.00076593f, 
    -0.06067114f, -0.06298929f, -0.00702674f, -0.02135663f, 0.06498789f, -0.07615157f, 0.04657993f, -0.03373405f, 
    0.04890770f, 0.05384825f, -0.05432749f, -0.01686471f, -0.05910401f, 0.03898988f, 0.04708347f, -0.05661028f, 
    0.05242110f, -0.04522347f, -0.02101500f, 0.01606090f, 0.02780486f, -0.06832341f, -0.00859491f, -0.02161963f, 
    -0.06617043f, -0.01744655f, -0.02243075f, 0.03079698f, 0.03410750f, 0.00294700f, 0.00408162f, -0.06739943f, 
    0.05495930f, -0.03427999f, 0.02727349f, 0.03306795f, 0.05116357f, 0.01902404f, 0.07033380f, 0.01013484f, 
    -0.06891582f, -0.00717790f, -0.06620894f, -0.07171916f, 0.04922750f, -0.07515372f, -0.07712048f, -0.08001950f, 
    -0.03939194f, -0.06414079f, -0.04377660f, 0.04817725f, -0.03650702f, 0.06386621f, -0.00110501f, 0.04031850f, 
    0.05447249f, -0.07738150f, 0.03440943f, 0.00239297f, -0.01855507f, -0.06558155f, -0.04307400f, -0.05300276f, 
    0.00805866f, 0.04154875f, 0.03787525f, 0.04621069f, 0.01105734f, -0.01292760f, -0.03240699f, 0.03130263f, 
    -0.04297666f, -0.01639518f, 0.01842815f, 0.05688426f, 0.04902317f, -0.02271382f, -0.04898278f, -0.08034341f, 
    -0.03721210f, -0.01250997f, 0.03053350f, -0.07756314f, 0.05950718f, 0.02203142f, 0.00878799f, 0.02223082f, 
    -0.01516229f, 0.06133298f, -0.04689473f, 0.03649082f, 0.05032345f, -0.07893665f, -0.05984800f, -0.04487845f, 
    0.00783253f, -0.00452543f, -0.07626703f, 0.05656132f, -0.05445747f, -0.08272459f, -0.04241933f, 0.01297820f, 
    0.05251204f, 0.02664180f, -0.04079569f, 0.00255370f, 0.01584853f, 0.02578915f, -0.07132204f, -0.05804024f, 
    -0.06785013f, -0.05206474f, 0.04125979f, 0.05261303f, -0.04156786f, 0.01489034f, 0.03785149f, 0.05804314f, 
    -0.00496935f, 0.05629472f, -0.07249556f, 0.00189145f, 0.00700860f, 0.03471108f, 0.04356682f, -0.03773285f, 
    -0.05439920f, -0.01182370f, 0.01742510f, -0.08044071f, 0.05459098f, -0.02097851f, 0.00978018f, -0.04487201f, 
    0.01720155f, 0.04531410f, -0.07369687f, 0.05755704f, -0.04258344f, 0.03895608f, -0.06009347f, 0.04267889f, 
    0.02999534f, -0.04278264f, -0.04846948f, -0.06257328f, 0.05741269f, 0.01767450f, 0.00192494f, -0.03014195f, 
    -0.08112119f, -0.03410469f, -0.05538575f, -0.07655593f, 0.00501553f, -0.07820994f, -0.02620221f, -0.05544932f, 
    -0.03789411f, 0.01537538f, -0.01783050f, -0.06087849f, -0.06003555f, -0.02922757f, -0.04868127f, -0.05412654f, 
    0.05558412f, -0.06645077f, -0.07285630f, -0.07172099f, -0.03716475f, 0.05496141f, -0.04812577f, -0.01925447f, 
    -0.01342524f, 0.05324938f, 0.02484813f, 0.03437991f, -0.06348485f, -0.00556852f, -0.06225739f, 0.02000539f, 
    0.00517588f, 0.00508551f, -0.01510085f, 0.01732139f, 0.05206050f, -0.00702848f, -0.07124230f, -0.03259028f, 
    -0.01306454f, -0.05090115f, 0.02436103f, 0.00907938f, -0.08381323f, 0.03886322f, -0.07591400f, -0.01657137f, 
    0.00879460f, 0.02593092f, 0.05810158f, -0.03308239f, 0.05200176f, 0.05334800f, -0.02722253f, -0.03107598f, 
    -0.04686295f, 0.00474774f, -0.00782889f, -0.00698458f, -0.01502876f, 0.00075031f, 0.01359138f, -0.00747816f, 
    -0.07111908f, -0.08784122f, -0.11934930f, -0.18254746f, -0.01781651f, 0.19607016f, 0.15336862f, 0.03695981f, 
    0.05499609f, 0.11962306f, 0.11292114f, -0.06797166f, -0.21643683f, -0.07686128f, -0.16226240f, -0.02411300f, 
    -0.04295444f, 0.15681650f, 0.07838577f, 0.12275450f, 0.12584837f, 0.00414243f, 0.01862718f, 0.03119880f, 
    -0.34801632f, 0.20877503f, -0.29494491f, -0.13461754f, -0.09871633f, 0.06713782f, 0.20094293f, 0.18289445f, 
    0.13574044f, 0.15954731f, -0.09034738f, 0.06601593f, 0.21129271f, 0.12660998f, -0.25983056f, -0.19628470f, 
    -0.03786315f, -0.09201623f, 0.05173190f, -0.07638948f, 0.05081541f, 0.02706198f, 0.08696064f, -0.06340992f, 
    0.14100766f, -0.17461275f, -0.07638849f, -0.22909822f, 0.17587759f, 0.11009087f, 0.02411336f, 0.03550135f, 
    0.00702709f, -0.15907118f, -0.12868103f, 0.09970383f, -0.02032391f, 0.08066425f, 0.08257186f, -0.05228375f, 
    0.01937206f, -0.07139058f, -0.03776932f, 0.09705132f, -0.03857984f, 0.02533207f, -0.12808819f, -0.11705127f, 
    -0.15014873f, -0.01119612f, 0.06032195f, -0.04722464f, 0.00914776f, 0.16561587f, 0.08509881f, 0.03251484f, 
    -0.12600188f, -0.04273565f, 0.04086084f, 0.12702262f, -0.24152517f, -0.58568949f, 0.01853238f, 0.11050253f, 
    0.10300127f, 0.11445121f, 0.15545429f, 0.04640964f, 0.00191959f, 0.06912611f, 0.08317021f, 0.09031005f, 
    -0.19384153f, 0.30593109f, -0.09165009f, 0.04324065f, -0.03692396f, 0.05598698f, 0.37006193f, -0.12823786f, 
    0.09049229f, 0.08831079f, -0.09336894f, 0.01730594f, 0.21695313f, 0.10746191f, 0.15028992f, -0.20113514f, 
    0.17984341f, 0.02591657f, -0.04610165f, 0.03059855f, -0.07346246f, -0.13830002f, 0.06401985f, -0.05355278f, 
    0.08545835f, 0.01369283f, 0.01930183f, -0.16146982f, 0.04192830f, -0.03749561f, -0.05204896f, -0.11633541f, 
    -0.22816320f, -0.18884921f, -0.12835902f, -0.07922758f, 0.31336278f, -0.01923564f, 0.25055397f, -0.07646353f, 
    0.00319261f, -0.10388256f, 0.12593512f, -0.06132449f, -0.03771850f, 0.01330344f, -0.10012799f, 0.02455293f, 
    -0.03971322f, 0.20688066f, -0.14471138f, 0.11810116f, 0.08534418f, 0.09279414f, 0.06714046f, -0.07088282f, 
    0.08429305f, -0.01791735f, 0.14649044f, -0.02809288f, 0.10337384f, -0.08551336f, 0.00797462f, 0.20113595f, 
    0.11338478f, -0.13609450f, 0.02369065f, 0.16354977f, -0.08971205f, 0.13130006f, 0.12277217f, -0.08998057f, 
    -0.03403981f, 0.11475867f, -0.09370893f, 0.32158771f, -0.04352888f, 0.04127830f, 0.02819754f, 0.01871088f, 
    -0.10495060f, -0.06888585f, 0.21579483f, -0.17026590f, 0.65529859f, 0.12108862f, -0.12394156f, -0.26639351f, 
    0.14141615f, 0.04718237f, -0.08744246f, -0.07824142f, 0.09221153f, 0.16577585f, 0.17180708f, -0.03547816f, 
    0.01658516f, -0.15339004f, -0.03338043f, 0.16747034f, 0.10960708f, 0.05440434f, 0.10562367f, 0.13494727f, 
    0.26921797f, 0.16290450f, 0.12994923f, 0.16492535f, 0.06685193f, 0.17364889f, 0.26495790f, 0.12139814f, 
    -0.04314806f, -0.12945658f, -0.21476270f, -0.13852817f, -0.06560821f, 0.04030413f, -0.15600261f, -0.07905692f, 
    0.01310905f, 0.31334117f, 0.38151467f, 0.30341244f, -0.18403488f, -0.05668775f, -0.03798656f, -0.07981884f, 
    -0.04835573f, -0.02111279f, 0.02070204f, 0.14432073f, -0.02962190f, -0.18695407f, 0.08855110f, 0.07693306f, 
    -0.17051081f, 0.00202413f, 0.00804011f, -0.00361686f, 0.07113815f, 0.13363028f, 0.26615691f, 0.16861269f, 
    -0.20920917f, -0.14286776f, -0.01722723f, 0.12453666f, -0.16525987f, -0.04487137f, 0.13479863f, 0.06267104f, 
    0.10152995f, 0.12241916f, 0.18526493f, 0.07288384f, 0.19078366f, 0.37649384f, 0.34483969f, 0.06982413f, 
    0.02748139f, 0.04920739f, 0.17804037f, 0.02065460f, 0.01716390f, -0.00557066f, -0.03881002f, 0.05948007f, 
    0.03613966f, -0.01551925f, 0.03763345f, -0.06244745f, 0.04974210f, -0.03033262f, -0.03929767f, -0.01128711f, 
    -0.16729023f, -0.41543663f, -0.23911884f, -0.34374288f, 0.32169372f, 0.04968125f, -0.05191623f, 0.27291235f, 
    0.05543231f, 0.04118930f, 0.08637638f, -0.22176802f, -0.09646303f, -0.07630970f, 0.26446897f, 0.20471160f, 
    -0.24065733f, 0.09646431f, 0.14491534f, 0.06426004f, 0.17201307f, -0.01873706f, -0.03658129f, -0.21609206f, 
    0.03967019f, -0.08545947f, -0.04195493f, 0.15929168f, -0.01045560f, -0.07509165f, -0.06481646f, -0.06782097f, 
    -0.13940242f, -0.02419201f, 0.11084746f, -0.11282708f, -0.01144380f, -0.00446275f, -0.08040967f, 0.13609454f, 
    -0.18175171f, -0.07610945f, -0.14762865f, -0.04248541f, -0.21014227f, -0.03243968f, -0.04921862f, 0.02090317f, 
    -0.05647220f, -0.12093306f, -0.08517168f, -0.15103450f, -0.27223730f, -0.12401618f, -0.02704781f, 0.17228799f, 
    0.09387779f, 0.15170895f, -0.07916171f, 0.18211709f, -0.17323723f, 0.05825880f, 0.02055217f, -0.12209944f, 
    -0.04780908f, -0.04050376f, 0.04471231f, 0.24345940f, 0.01408974f, -0.00544916f, 0.11523554f, 0.05513755f, 
    -0.06777410f, 0.03558129f, -0.10050713f, 0.01948534f, -0.04250754f, 0.06108016f, 0.04078202f, -0.26656294f, 
    -0.03884205f, -0.15865695f, 0.01666738f, 0.13049163f, -0.03462235f, 0.18213776f, -0.07437657f, -0.32917640f, 
    0.05022101f, 0.00384458f, 0.01491815f, -0.02372183f, -0.01065049f, 0.04362670f, 0.08643683f, 0.05726233f, 
    0.03814530f, 0.07887747f, -0.03346603f, -0.08596537f, 0.31009522f, -0.01820816f, -0.39111462f, 0.16264392f, 
    0.14496928f, -0.03725776f, -0.07884210f, -0.09184501f, 0.01521745f, -0.11044868f, 0.11136594f, 0.18275243f, 
    -0.06819576f, -0.29101411f, -0.00432205f, -0.06721041f, -0.09493317f, 0.03534055f, 0.11017045f, -0.00062483f, 
    -0.07205261f, -0.09856191f, -0.01622489f, 0.01497689f, 0.02968314f, -0.21457227f, 0.06975995f, 0.01767861f, 
    -0.04289943f, -0.02744157f, 0.04505865f, -0.08490695f, 0.12955444f, -0.01673846f, 0.05260325f, -0.07638404f, 
    -0.13021098f, -0.18605566f, 0.07442643f, 0.10796615f, 0.16093592f, 0.14908254f, 0.22634193f, 0.06424503f, 
    0.06748785f, -0.07454518f, -0.03142698f, -0.00861804f, 0.03214367f, -0.19318226f, -0.13633594f, -0.01467234f, 
    0.02851806f, 0.05780322f, 0.11407026f, 0.08645517f, -0.00297430f, 0.02024811f, -0.05050042f, 0.09506512f, 
    0.16762522f, 0.04085091f, 0.14560501f, -0.09517978f, 0.10818261f, 0.08327568f, 0.15831941f, 0.00811379f, 
    -0.10839186f, -0.01952558f, -0.05597765f, 0.05446681f, -0.34768862f, -0.04981780f, 0.10369015f, 0.11380170f, 
    0.02020803f, -0.05593731f, -0.08192032f, 0.00034242f, -0.06429856f, 0.00405385f, -0.04353214f, 0.07914517f, 
    -0.24063647f, -0.07323021f, 0.00042690f, 0.01843696f, 0.07379441f, -0.06121191f, -0.06688686f, 0.07111774f, 
    -0.01473094f, 0.08219704f, -0.01431303f, 0.19485685f, 0.53912431f, 0.07801682f, -0.11648601f, 0.42509776f, 
    0.07851282f, -0.22770573f, -0.11604474f, -0.04858432f, -0.21250390f, -0.00209418f, 0.03968010f, -0.10767774f, 
    -0.30393612f, -0.16162454f, 0.03153647f, -0.10056324f, 0.15798973f, -0.19633488f, -0.17810443f, -0.07343374f, 
    -0.07046440f, 0.00786963f, -0.03185295f, 0.03430789f, -0.51828814f, -0.13246036f, 0.02446078f, -0.16313672f, 
    0.05483807f, -0.07234647f, -0.07007285f, -0.08106980f, 0.05304259f, 0.05510106f, 0.03457327f, 0.15210468f, 
    0.19044901f, -0.00296988f, -0.03849423f, -0.01564281f, 0.14422587f, 0.16823648f, 0.06414285f, 0.28373942f, 
    0.01362558f, 0.05577414f, 0.13229175f, 0.04843665f, 0.38880074f, 0.52877533f, 0.03115772f, -0.03299367f, 
    -0.01039359f, -0.00448347f, 0.01858384f, 0.04246689f, 0.10473351f, 0.10601864f, -0.09495953f, 0.09866647f, 
    0.39974108f, -0.01886000f, -0.04572785f, -0.10987985f, 0.27425542f, 0.08323385f, 0.14657277f, 0.14089884f, 
    0.00704297f, 0.04858378f, 0.00231888f, 0.03957279f, 0.00810854f, -0.16759811f, -0.17506889f, 0.04683836f, 
    0.13492835f, -0.06416266f, -0.06935021f, 0.12131771f, 0.08574446f, -0.00209845f, 0.21138068f, -0.11075868f, 
    0.25500149f, -0.04208477f, -0.00005085f, -0.21967632f, -0.03896947f, -0.10336912f, 0.13083592f, -0.09118133f, 
    -0.07405891f, -0.02590819f, -0.14388822f, 0.17285343f, 0.14201021f, 0.10228448f, 0.00461327f, -0.44314751f, 
    -0.12925410f, -0.05691156f, 0.06121509f, 0.11377938f, 0.04799092f, -0.04450168f, -0.18561240f, 0.21216503f, 
    0.21024086f, 0.09985960f, -0.14576329f, 0.05328752f, 0.03054734f, -0.06182037f, -0.09179804f, -0.09902790f, 
    0.01201246f, 0.00040190f, -0.11964740f, -0.12375531f, -0.03506069f, -0.14758247f, -0.36947799f, 0.06941442f, 
    -0.00966273f, 0.10747388f, 0.13484824f, 0.05910693f, -0.03682069f, 0.11409813f, -0.05273536f, -0.01812548f, 
    0.45062935f, -0.15204109f, -0.38993460f, -0.17103469f, 0.15119098f, 0.16992778f, 0.03608485f, 0.02394329f, 
    0.01220221f, -0.04868713f, -0.03935327f, -0.02788500f, 0.28740531f, -0.07767891f, -0.42412454f, -0.04235256f, 
    0.07271907f, -0.01531564f, 0.10822088f, -0.07544197f, -0.00908603f, -0.05562710f, 0.01329346f, 0.01421345f, 
    0.10057416f, 0.13578181f, -0.04766382f, -0.08262216f, 0.16095789f, -0.04795616f, -0.00188688f, 0.20861024f, 
    0.10206769f, -0.00937417f, -0.04100168f, 0.02626037f, 0.06771774f, 0.49138418f, 0.02745878f, -0.08226898f, 
    -0.17062391f, -0.12989856f, -0.05552362f, -0.15079917f, -0.08738372f, 0.11811826f, -0.01016839f, 0.04701393f, 
    0.07034332f, 0.15876989f, 0.12273681f, -0.02671938f, -0.00122025f, 0.05674993f, -0.05562890f, 0.00161265f, 
    0.03188155f, -0.01126330f, -0.00608982f, 0.05959569f, -0.12666418f, 0.19661036f, 0.24518120f, -0.25243464f, 
    0.08677606f, 0.19623719f, -0.09605719f, -0.01659167f, 0.08231478f, 0.02978025f, 0.08306205f, -0.07707138f, 
    0.09550613f, 0.13098842f, 0.01616609f, 0.01376326f, -0.21979310f, -0.01415390f, -0.04465436f, 0.14494914f, 
    -0.10592354f, -0.08418364f, 0.16385391f, -0.00958554f, 0.15679626f, 0.16343495f, 0.34361842f, 0.14167482f, 
    -0.03582662f, -0.08848760f, -0.14778975f, 0.08186587f, -0.02254198f, -0.00137803f, 0.01881450f, 0.05031456f, 
    0.15825157f, 0.15262525f, 0.04682277f, 0.03256054f, -0.03457051f, -0.01466228f, 0.14207128f, 0.05771156f, 
    0.02292355f, -0.00514380f, -0.04968391f, -0.03010618f, 0.21406154f, 0.28183952f, 0.01493078f, -0.28810909f, 
    -0.04462557f, -0.07555688f, 0.11966027f, 0.13612983f, 0.07531212f, 0.02297169f, 0.15644638f, 0.03699071f, 
    0.06710406f, 0.08615369f, -0.05967349f, -0.05598120f, -0.00849307f, 0.12445883f, -0.12949507f, 0.15107055f, 
    -0.00706130f, 0.02261834f, 0.09675490f, -0.00955358f, 0.04992206f, 0.15284576f, 0.11661632f, -0.03181157f, 
    -0.14338943f, 0.00740245f, -0.04798361f, -0.13208282f, 0.17125851f, -0.00109164f, 0.02448510f, 0.08030314f, 
    0.06997385f, -0.03844425f, -0.24290055f, 0.12188529f, 0.04652852f, 0.24892516f, -0.03498646f, -0.00589240f, 
    0.12797050f, 0.16550168f, -0.11249357f, 0.11205363f, 0.24871975f, 0.11575156f, -0.02824992f, -0.31688932f, 
    0.23372127f, -0.01380582f, 0.11155970f, -0.06319332f, -0.08407934f, 0.02350130f, -0.03771557f, 0.09662928f, 
    -0.04424782f, 0.13458288f, 0.01784710f, 0.12648225f, -0.00271214f, -0.04380620f, -0.15511928f, -0.00500174f, 
    0.20164339f, 0.26605105f, -0.12916219f, -0.11149211f, 0.14526564f, 0.05977059f, 0.20188765f, -0.04020383f, 
    -0.05634490f, 0.00248237f, 0.07414216f, -0.01215023f, 0.21031412f, 0.13800353f, 0.06226281f, 0.20906377f, 
    0.36233237f, -0.21216226f, 0.05436052f, 0.05577200f, -0.11219133f, -0.03847123f, -0.17050338f, 0.10414821f, 
    0.02253770f, 0.02116804f, 0.01107469f, -0.07634505f, 0.23793472f, -0.04867682f, 0.22936425f, 0.02218428f, 
    -0.05025961f, 0.01681224f, -0.11551824f, -0.07046790f, -0.01737518f, -0.14372666f, -0.06223999f, -0.01530287f, 
    -0.00914003f, 0.17494510f, -0.05040468f, -0.17980385f, 0.01201952f, 0.07800154f, 0.05826964f, 0.01066284f, 
    0.03815488f, 0.04718957f, -0.08661522f, -0.04969168f, -0.06158511f, -0.16906407f, -0.20422734f, 0.08270222f, 
    0.02941233f, 0.04846589f, -0.07041662f, -0.11613996f, -0.02970678f, -0.00455273f, -0.02764378f, -0.05901852f, 
    -0.05504541f, -0.05193368f, 0.05434756f, -0.15275316f, -0.01079672f, -0.03573824f, 0.02857686f, -0.04393201f, 
    0.12056572f, 0.12299820f, 0.23527007f, 0.15928170f, -0.49789757f, 0.44291735f, -0.08097234f, 0.04460032f, 
    -0.11815631f, -0.11213403f, -0.09420078f, 0.11189309f, 0.02557895f, -0.01568126f, 0.11598798f, 0.03145072f, 
    0.20684785f, -0.34459621f, 0.47424519f, -0.22949423f, -0.08997545f, 0.01996956f, -0.27453849f, 0.07083385f, 
    -0.10129891f, -0.02773457f, 0.05226004f, 0.09436620f, -0.23321040f, 0.20759456f, -0.25753951f, -0.05901216f, 
    0.01786488f, -0.05569006f, 0.04805880f, -0.23355857f, -0.04878684f, -0.12258165f, -0.14329852f, -0.00534481f, 
    -0.11391148f, 0.00189179f, -0.05299569f, 0.00805784f, 0.00531628f, 0.11168175f, 0.13569541f, 0.22721305f, 
    0.00863561f, 0.10241283f, 0.02038561f, 0.21593106f, 0.24697721f, -0.09484933f, -0.20791319f, -0.27450648f, 
    0.07488508f, 0.03137533f, 0.02118265f, 0.11537951f, 0.01207410f, 0.08164324f, -0.02677058f, 0.00064440f, 
    -0.12781721f, -0.13721842f, -0.07850312f, -0.14133935f, 0.10449261f, 0.03893899f, -0.06050663f, 0.17112851f, 
    0.10489726f, 0.08545766f, 0.03643902f, 0.13144007f, 0.10051348f, 0.16378890f, 0.02753893f, -0.06407920f, 
    -0.07481916f, 0.04855032f, -0.04900519f, -0.09428702f, 0.29175189f, 0.05304890f, -0.01152668f, 0.16016945f, 
    -0.02938296f, -0.06263186f, 0.45147946f, -0.11474662f, 0.07527081f, 0.16623408f, 0.11934941f, -0.00324830f, 
    0.24760170f, 0.08665965f, -0.06626244f, 0.05891949f, -0.01391606f, 0.20807092f, 0.13657200f, -0.00270393f, 
    -0.04639677f, 0.08694976f, 0.00975103f, -0.18490899f, -0.03600314f, -0.04700312f, -0.06679380f, 0.03783805f, 
    0.05446217f, -0.01598921f, -0.07692332f, 0.04865033f, -0.06535160f, -0.00256255f, -0.07841284f, 0.03938961f, 
    -0.02709758f, -0.01463142f, -0.04712763f, -0.03877574f, 0.04811169f, 0.00768412f, -0.05555799f, 0.01215412f, 
    0.01388467f, -0.03718889f, -0.01501600f, -0.07415913f, 0.04872842f, -0.06953797f, -0.06235519f, -0.07555226f, 
    -0.06572967f, -0.01612344f, -0.07510225f, -0.02631472f, -0.06718796f, -0.04280950f, -0.08245979f, 0.03147591f, 
    0.01191149f, -0.06286767f, -0.06594100f, 0.05098845f, -0.00859178f, 0.00288864f, -0.00688077f, -0.03590922f, 
    0.00152468f, 0.05390182f, -0.01725280f, 0.00797440f, -0.02070137f, -0.01121522f, -0.08302758f, -0.05991905f, 
    0.06326917f, -0.04995329f, -0.03156905f, 0.04707969f, 0.01355212f, -0.01912945f, -0.02882076f, -0.08210331f, 
    -0.05574902f, -0.08418877f, 0.05613745f, -0.04653934f, 0.03355333f, -0.02432670f, -0.00979804f, 0.05525030f, 
    0.02577818f, 0.03953164f, 0.05834668f, 0.01724425f, -0.01797512f, 0.05611282f, 0.03516315f, 0.05674289f, 
    -0.04777852f, -0.07233679f, -0.02566986f, -0.04185275f, -0.04042178f, -0.07432899f, -0.00638104f, -0.04624093f, 
    0.02363120f, 0.00772241f, 0.00660942f, 0.04892433f, -0.00606026f, -0.03039574f, -0.00062051f, 0.03582912f, 
    0.01741185f, 0.05819516f, 0.00135280f, 0.04231837f, -0.00079696f, -0.00906208f, -0.01056158f, 0.05205116f, 
    0.00697068f, -0.00033138f, 0.05827234f, 0.02184859f, -0.05398919f, -0.04418481f, -0.01414207f, 0.03056054f, 
    -0.04216843f, -0.06401772f, -0.07609235f, 0.04805133f, -0.02348570f, -0.01716082f, -0.04002805f, 0.02662754f, 
    0.02698469f, -0.03824356f, 0.00922469f, 0.05703844f, 0.04144743f, 0.00351011f, -0.07380081f, 0.00887463f, 
    0.01658200f, -0.06844155f, -0.06747647f, -0.01662470f, -0.05766684f, -0.01010903f, -0.06042923f, 0.00550685f, 
    0.01961200f, -0.00088922f, -0.05124414f, 0.00149923f, -0.04119800f, -0.06076818f, -0.06055561f, -0.06299646f, 
    0.02658227f, 0.00783242f, 0.01740961f, -0.01645844f, -0.03746120f, 0.04627783f, 0.00597569f, 0.02571619f, 
    -0.02771264f, -0.05639083f, -0.02375133f, 0.02561896f, 0.03896778f, 0.03462453f, -0.01897666f, -0.00487768f, 
    -0.02381004f, 0.02486990f, 0.04929002f, 0.01135056f, -0.07859935f, 0.04678233f, -0.03240951f, 0.05199588f, 
    -0.00866276f, 0.05223029f, 0.02022315f, 0.01572623f, 0.00828347f, -0.06010590f, 0.00016968f, -0.00925911f, 
    0.05419196f, -0.00495310f, 0.02086501f, -0.05128070f, -0.06146153f, 0.02852755f, -0.02592815f, -0.04271674f, 
    -0.02816655f, 0.01385969f, -0.02995452f, 0.00859096f, -0.08376972f, -0.00351121f, -0.07096470f, -0.03943984f, 
    -0.03691311f, 0.04300464f, 0.04657040f, -0.01092945f, -0.06385639f, -0.06979580f, 0.03440107f, -0.07685508f, 
    -0.07614671f, 0.09045102f, -0.26807129f, 0.07747546f, 0.08912357f, 0.12492355f, 0.05806316f, 0.10734977f, 
    0.11904986f, 0.16858813f, 0.03472923f, -0.03118195f, -0.35131332f, 0.04123666f, -0.18891580f, 0.10116147f, 
    -0.00318804f, 0.10289133f, 0.10464390f, 0.09647256f, 0.00886358f, 0.06499551f, -0.00286725f, -0.04455860f, 
    -0.08420257f, 0.00768387f, 0.18011810f, 0.07547263f, 0.06324887f, 0.13992476f, 0.23983790f, -0.08416572f, 
    -0.01172690f, 0.07215824f, 0.11534131f, 0.07377191f, -0.10932719f, 0.27731478f, -0.09152643f, 0.00871662f, 
    -0.03409024f, 0.04177371f, 0.10680729f, -0.08840788f, 0.06308059f, 0.11922166f, 0.18068297f, -0.04000524f, 
    -0.18699157f, -0.03538869f, -0.08731859f, -0.10910906f, 0.04944115f, 0.08589008f, -0.09976551f, -0.12310172f, 
    -0.08849277f, -0.06858111f, -0.03565850f, 0.10368440f, -0.12387594f, 0.10617588f, 0.11329141f, -0.14272992f, 
    -0.10146447f, -0.07070463f, 0.06798647f, -0.06474837f, -0.06043395f, -0.02946405f, -0.01121291f, 0.06450431f, 
    -0.04634840f, 0.04351293f, -0.00835549f, -0.03811176f, -0.05745696f, 0.09528301f, 0.09287348f, 0.05511984f, 
    -0.08803979f, 0.09299415f, 0.15938391f, -0.02928068f, 0.55648595f, -0.11803702f, 0.51872039f, 0.23807101f, 
    -0.03455138f, -0.00372655f, -0.00774687f, -0.04523268f, -0.00658127f, 0.03198840f, -0.05090880f, 0.01922890f, 
    -0.20777297f, -0.09356495f, -0.22497006f, 0.06359125f, -0.04655058f, -0.14172508f, 0.26697356f, 0.02037293f, 
    -0.01700014f, 0.02755287f, 0.09378398f, 0.16791728f, -0.02100288f, 0.08587591f, 0.10049954f, -0.07981091f, 
    -0.04482007f, 0.00487275f, 0.04849567f, 0.02884948f, -0.19000040f, 0.06168007f, -0.10584938f, 0.06213353f, 
    0.03156942f, -0.10418782f, -0.07689754f, -0.09998197f, -0.03347813f, 0.00937608f, -0.01561942f, -0.14110057f, 
    -0.06306174f, -0.11463584f, -0.04067499f, -0.00196852f, -0.27885130f, 0.24084719f, -0.31791285f, 0.03096925f, 
    0.02640113f, -0.03499007f, 0.09703414f, -0.07302313f, -0.00434073f, 0.00478641f, -0.04317132f, -0.00029053f, 
    -0.04264557f, -0.33914688f, 0.02886070f, -0.23238039f, 0.02127755f, 0.06878208f, -0.02854678f, -0.04671951f, 
    0.00154287f, 0.04800853f, 0.10510559f, 0.04438088f, -0.26123831f, 0.12205122f, 0.05515055f, -0.00115218f, 
    -0.02312339f, -0.15008686f, 0.02629988f, 0.03485023f, 0.06160068f, 0.07475334f, 0.12874062f, -0.04135026f, 
    0.15050873f, 0.24202983f, 0.00176467f, 0.42725053f, -0.00544792f, 0.11408466f, 0.02102480f, 0.00575337f, 
    0.00424666f, 0.08806819f, 0.00768604f, 0.10254180f, -0.26359564f, 0.41802546f, -0.23747000f, -0.12574859f, 
    -0.01213320f, 0.06481311f, 0.03205089f, 0.08073454f, 0.10659664f, 0.09471569f, -0.02040334f, 0.02457690f, 
    0.09757347f, -0.13764274f, 0.07447395f, 0.25672528f, 0.09997793f, -0.02494388f, -0.00983565f, 0.07821619f, 
    0.19308648f, 0.01037727f, 0.24736287f, 0.19692779f, 0.12396166f, 0.09244388f, 0.24201411f, 0.03254465f, 
    0.07973048f, -0.02329673f, -0.16817565f, -0.08490276f, -0.05818918f, 0.01444957f, -0.11774868f, -0.06943110f, 
    -0.13225448f, 0.26704586f, 0.29922831f, 0.15428439f, -0.16022672f, -0.23837712f, 0.01766620f, -0.15263867f, 
    0.18893708f, 0.04856775f, 0.08025005f, 0.08895385f, -0.04661977f, -0.09111125f, 0.28413767f, 0.14909749f, 
    -0.09041271f, 0.00977026f, -0.09415568f, 0.03556794f, 0.03152872f, 0.23400249f, 0.01764399f, 0.07601911f, 
    -0.18070684f, -0.05894135f, -0.03511352f, 0.01255327f, -0.11138256f, -0.09929728f, 0.05440992f, -0.06870586f, 
    -0.02783147f, 0.14875619f, 0.15877587f, 0.02866533f, 0.25961027f, -0.10817853f, -0.13446036f, -0.12101933f, 
    0.16262949f, 0.08657677f, 0.16566229f, 0.09159989f, 0.06726610f, -0.01079714f, -0.05928525f, -0.01229800f, 
    0.00096856f, -0.03027640f, -0.12419385f, 0.00331444f, 0.02611419f, 0.01105975f, 0.01551711f, 0.08301732f, 
    0.02508864f, -0.05929625f, -0.14246920f, -0.00240780f, -0.32240191f, 0.31698459f, -0.27641308f, 0.05096609f, 
    -0.00604214f, -0.19691709f, 0.10075542f, -0.03199214f, 0.15737130f, -0.06565419f, 0.04782146f, 0.03610402f, 
    0.17740506f, 0.00922930f, -0.16592783f, -0.13216344f, 0.12305894f, -0.15512902f, 0.10644503f, -0.07034378f, 
    0.02155492f, -0.02230934f, -0.09376674f, 0.03660196f, 0.16483867f, -0.13020448f, -0.32038859f, 0.15961875f, 
    -0.05023848f, 0.01380642f, 0.02696084f, 0.01128968f, 0.08409451f, -0.00568172f, 0.00562735f, -0.00394271f, 
    -0.15067787f, -0.09653491f, -0.00757993f, 0.11093593f, -0.05780593f, -0.06947500f, -0.01579385f, -0.07186212f, 
    -0.00396967f, -0.11390698f, -0.03761704f, -0.10941426f, -0.22969601f, -0.46190667f, 0.14661258f, -0.03997944f, 
    0.09806972f, 0.00240814f, -0.06843896f, 0.03480246f, 0.06854124f, 0.08557580f, 0.05379530f, -0.02853786f, 
    -0.21272233f, 0.07573494f, 0.06857618f, 0.01695047f, 0.02148433f, -0.08099183f, -0.00763098f, -0.03224339f, 
    0.08975227f, 0.05808717f, 0.00140692f, 0.05790362f, -0.13384661f, -0.08581851f, 0.07464430f, 0.07778443f, 
    -0.07455115f, 0.04151144f, 0.01029325f, -0.07853635f, -0.00299495f, 0.14820980f, -0.16861422f, -0.05809421f, 
    0.14256260f, -0.06625742f, 0.01952720f, -0.02164841f, 0.26726350f, 0.08064574f, 0.02696018f, 0.11730654f, 
    0.13001961f, 0.04530166f, 0.11648849f, 0.01110522f, -0.48304957f, -0.20297797f, 0.03916230f, 0.64597291f, 
    0.00234540f, 0.04415374f, -0.05094661f, -0.02346383f, 0.11892600f, -0.02159889f, 0.04422205f, 0.04050926f, 
    -0.01881001f, 0.03886499f, -0.00670359f, 0.03651037f, -0.01375871f, -0.07937411f, 0.00121568f, 0.04872682f, 
    -0.04927094f, -0.06041712f, 0.01299338f, -0.02761519f, -0.00054767f, 0.05044372f, -0.04667378f, 0.05836112f, 
    -0.00921309f, 0.00492826f, 0.05231606f, -0.05912279f, 0.04105443f, -0.02942338f, 0.06458544f, -0.06459451f, 
    0.00326665f, 0.02745232f, 0.02911800f, 0.02478164f, 0.04040437f, 0.02135600f, -0.03174235f, -0.05390808f, 
    0.04152333f, 0.05202561f, -0.06654932f, 0.04863964f, -0.05323119f, -0.03920584f, -0.01263496f, 0.03622013f, 
    -0.05316508f, -0.00741087f, 0.03629293f, -0.00012138f, 0.05877674f, -0.03604063f, 0.06044783f, -0.01206253f, 
    0.03759325f, -0.05104549f, -0.05560855f, -0.08052475f, -0.00879169f, 0.04481903f, 0.05745338f, 0.01145780f, 
    -0.00810503f, -0.07778844f, -0.05645290f, -0.05377454f, -0.06346197f, 0.01970570f, -0.04073516f, -0.05203305f, 
    0.05760058f, -0.07439803f, -0.06305540f, 0.02449128f, -0.02698993f, -0.03377138f, -0.04174709f, 0.04290209f, 
    -0.03320904f, -0.06828718f, -0.00614804f, -0.02622182f, 0.05149611f, -0.00973931f, 0.02524805f, 0.04575833f, 
    -0.03772622f, 0.01767561f, -0.00984354f, 0.00689543f, -0.07065934f, 0.05499328f, 0.00087220f, -0.06621909f, 
    -0.05773789f, -0.02553217f, 0.00279328f, -0.03283678f, -0.04951093f, -0.05156214f, -0.07412776f, 0.04929627f, 
    0.06328393f, -0.03657543f, 0.02573169f, -0.03138637f, -0.00066635f, -0.03181374f, -0.05658881f, -0.02378080f, 
    0.01303933f, 0.04615079f, -0.04494624f, -0.01449908f, 0.01423525f, -0.03435251f, -0.03724288f, -0.00650282f, 
    0.03282199f, 0.00789854f, -0.00340270f, 0.01288040f, -0.04491065f, -0.02503352f, -0.03926059f, -0.06973860f, 
    0.03988937f, -0.00423205f, 0.00967691f, 0.03212088f, 0.03652644f, -0.07887418f, -0.02018856f, 0.02467412f, 
    -0.07638023f, -0.06989728f, -0.02672748f, -0.03063346f, -0.00591274f, -0.00720726f, 0.01439371f, 0.06061517f, 
    0.00730024f, -0.00952829f, -0.05705255f, -0.07991190f, 0.03373009f, 0.04449029f, -0.02908039f, -0.07650791f, 
    0.02118514f, -0.07613415f, 0.01163973f, -0.02362757f, -0.03428954f, -0.03444827f, -0.05163107f, -0.04794081f, 
    0.06321532f, -0.02874973f, -0.05044413f, -0.01292847f, -0.03212750f, 0.00015399f, 0.01298701f, -0.02226525f, 
    -0.01940057f, -0.05452470f, -0.01900695f, -0.06975822f, -0.00672178f, 0.01457655f, -0.01416993f, -0.04374896f, 
    0.00325616f, -0.07958785f, -0.02347467f, -0.04275016f, -0.01718247f, -0.03807911f, -0.00115107f, 0.04069610f, 
    -0.03298282f, -0.03444526f, -0.07479348f, 0.02609581f, -0.00437201f, 0.05532292f, -0.02612905f, -0.00731105f, 
    0.01463076f, 0.04640375f, -0.04682583f, -0.02279926f, -0.05718436f, -0.03641525f, 0.02315125f, 0.00548362f, 
    0.23644313f, -0.11467975f, -0.01479492f, 0.12742640f, -0.06094743f, -0.01553392f, -0.11917304f, -0.03115977f, 
    0.19790374f, -0.15579987f, 0.06895439f, 0.11892607f, -0.17951666f, -0.06997778f, -0.10170938f, -0.04364187f, 
    -0.07928711f, 0.03640264f, -0.04896178f, 0.04803184f, -0.08720069f, 0.11399740f, -0.09287803f, 0.05356673f, 
    0.36286837f, -0.21733943f, -0.04220216f, 0.08467104f, -0.07684588f, -0.01992322f, -0.19946270f, 0.02830394f, 
    0.03436617f, -0.12395737f, 0.12307665f, -0.00167547f, 0.07689444f, 0.02460174f, -0.01947956f, 0.11255199f, 
    -0.10345921f, -0.08039524f, -0.00107545f, -0.09487643f, -0.02198645f, -0.05213589f, 0.18405312f, 0.05657167f, 
    -0.20445059f, -0.13765313f, -0.10790469f, -0.11687337f, -0.18192707f, -0.05859441f, -0.03225775f, 0.04150703f, 
    -0.13741437f, 0.01426282f, 0.09190218f, -0.10244366f, 0.01189513f, 0.11515097f, -0.09249534f, -0.23519458f, 
    -0.05562109f, -0.06051043f, 0.00368042f, 0.05584946f, -0.00477386f, -0.05356774f, 0.01097667f, -0.02820822f, 
    -0.01780952f, -0.04614307f, -0.01224723f, -0.08365458f, -0.00114846f, 0.02027237f, 0.03019156f, 0.05929000f, 
    0.05900177f, -0.10192665f, 0.06417001f, -0.04603835f, -0.06528719f, 0.32032022f, -0.05120593f, -0.08589935f, 
    -0.02573418f, 0.27807894f, -0.14345601f, -0.13421823f, -0.03073368f, 0.15808505f, 0.05372171f, -0.01995676f, 
    0.11319388f, 0.02080649f, -0.13465084f, -0.24728580f, -0.05345646f, -0.23918313f, -0.16646369f, -0.01236396f, 
    -0.07025848f, 0.01721089f, 0.11752716f, 0.01547797f, -0.00388026f, -0.07387017f, 0.17437755f, -0.05547137f, 
    -0.06963476f, -0.06237807f, -0.10195616f, 0.00726173f, -0.08377456f, -0.06017963f, -0.08224751f, 0.01039882f, 
    -0.05670722f, -0.16111772f, -0.19924745f, -0.05474520f, -0.02162237f, 0.04016438f, 0.11381076f, -0.07900978f, 
    -0.09465702f, -0.04568866f, -0.13480239f, -0.08589035f, -0.29538399f, -0.11076131f, -0.03295584f, -0.29939118f, 
    0.03465769f, 0.00008521f, 0.05775850f, 0.19703065f, 0.08213569f, 0.02710351f, 0.06084887f, -0.13596064f, 
    -0.22645752f, -0.14141570f, -0.12124473f, -0.08326887f, 0.01311470f, 0.02463518f, -0.01961171f, 0.09608527f, 
    0.04924584f, -0.01541755f, -0.09427155f, 0.07423672f, -0.00992431f, 0.06639408f, 0.12063401f, -0.09022533f, 
    -0.02395904f, 0.04763451f, -0.02695976f, -0.12960900f, 0.05839215f, 0.21731944f, -0.00599714f, -0.01594550f, 
    0.15473485f, -0.12026366f, -0.21522278f, 0.02704645f, -0.00797474f, 0.00728375f, -0.12384994f, 0.09435617f, 
    0.24319403f, 0.20540775f, -0.22101408f, 0.22934358f, 0.49502608f, -0.03106968f, -0.17651193f, 0.20409709f, 
    0.19593161f, -0.04638444f, -0.09453767f, -0.04109541f, -0.02711585f, 0.06217493f, 0.06835072f, -0.05212373f, 
    0.02665015f, 0.07542995f, -0.18094829f, -0.04452364f, 0.01460478f, -0.04735225f, -0.02611751f, 0.02444959f, 
    0.05147721f, -0.08202329f, -0.06417663f, -0.01076415f, -0.34527752f, 0.17963079f, -0.05895687f, -0.01446535f, 
    -0.07457057f, 0.04845129f, 0.04127954f, 0.09112065f, -0.09068882f, 0.07818127f, 0.09394035f, 0.06108629f, 
    0.18604180f, -0.24308611f, -0.04817218f, -0.01151603f, 0.07776839f, -0.01339442f, -0.07918180f, 0.05765880f, 
    0.05915112f, 0.13321956f, 0.14639935f, -0.01318731f, -0.12680775f, 0.14550066f, -0.26968595f, -0.00860872f, 
    -0.05182511f, 0.03741078f, 0.01412007f, 0.00588707f, 0.01648331f, -0.02878927f, 0.12292998f, 0.01800946f, 
    -0.26210660f, -0.13803294f, -0.13831118f, 0.05409923f, 0.00347427f, 0.03545385f, 0.07450925f, 0.12234497f, 
    0.02314951f, 0.08005600f, -0.00731019f, -0.00699141f, 0.00937300f, 0.36213422f, 0.02804571f, -0.14655624f, 
    -0.10979201f, -0.21605702f, 0.01831661f, -0.21672116f, -0.04315183f, 0.06676392f, 0.03449443f, 0.04297310f, 
    0.14013037f, 0.07336908f, 0.05124573f, -0.13195965f, -0.03462947f, -0.13863796f, -0.05903392f, -0.18009409f, 
    0.09036990f, 0.09517298f, 0.02116441f, -0.01887097f, 0.58196223f, 0.08610627f, 0.24237023f, 0.15361129f, 
    0.07171162f, 0.18728925f, 0.03489623f, 0.01139914f, 0.06470855f, 0.09767233f, 0.02413676f, 0.03893755f, 
    -0.02054719f, 0.07943747f, 0.01646644f, 0.06175679f, -0.17066082f, 0.01795894f, -0.00473302f, -0.01318560f, 
    0.00217141f, 0.02750441f, 0.11410194f, 0.03083567f, 0.16703358f, 0.23776412f, 0.26171350f, -0.04831399f, 
    -0.18723178f, -0.16968071f, -0.13376482f, -0.02390570f, -0.07979416f, 0.07069152f, -0.09197994f, 0.01946827f, 
    -0.07640573f, -0.19042866f, -0.06623081f, 0.14774086f, -0.12664889f, 0.01560808f, 0.03432692f, -0.10186064f, 
    0.11508705f, -0.03382101f, -0.07899805f, -0.02307439f, -0.44886559f, 0.22083674f, -0.12301748f, 0.06250653f, 
    0.07032205f, -0.03723016f, 0.18566655f, 0.08131626f, -0.00957096f, -0.02844566f, 0.09325749f, -0.01481817f, 
    -0.14873473f, -0.17609428f, 0.03869680f, -0.00138030f, 0.05042337f, 0.04595357f, -0.00076801f, 0.03527764f, 
    0.00929030f, 0.03644968f, 0.00530177f, 0.10074097f, -0.13004772f, 0.06169349f, -0.08566811f, -0.20615201f, 
    -0.03589446f, -0.03720697f, -0.06497756f, -0.16417328f, 0.00743805f, 0.02934686f, -0.00474514f, 0.08272062f, 
    0.06490329f, 0.10539950f, -0.08077155f, 0.33301315f, 0.09595251f, 0.17414878f, 0.08478551f, 0.16093631f, 
    0.00369441f, 0.27261057f, -0.00553440f, 0.29227683f, 0.29453269f, 0.04088252f, -0.56110066f, -0.16485104f, 
    0.16830344f, -0.12750170f, -0.04164985f, -0.07894272f, 0.05498716f, 0.12346169f, 0.05814314f, 0.02657051f, 
    -0.04185003f, -0.03183956f, 0.10019492f, -0.01999101f, -0.06500084f, -0.02564700f, -0.01588608f, 0.13998254f, 
    0.00222777f, -0.12089162f, 0.08907307f, 0.00904361f, 0.14751241f, 0.24964952f, 0.27863994f, 0.03277501f, 
    -0.05189998f, -0.13815504f, -0.17766282f, -0.04094138f, 0.08090794f, 0.03354852f, -0.01045444f, 0.05317779f, 
    -0.16963494f, 0.15718149f, 0.19309618f, 0.08638559f, -0.04575123f, -0.24112920f, -0.23970853f, -0.08043661f, 
    0.02254356f, 0.08219001f, 0.00137554f, 0.00906872f, -0.29888198f, 0.15050931f, 0.26060262f, 0.04792713f, 
    0.04421701f, 0.04366437f, -0.06793360f, 0.15657496f, 0.01915593f, 0.15336651f, -0.07442900f, -0.00674177f, 
    -0.16696332f, -0.08633310f, -0.03955812f, 0.18877421f, -0.08380350f, 0.13540232f, -0.01318623f, 0.01444243f, 
    0.01874537f, 0.01832633f, 0.11284561f, 0.03404273f, 0.24746068f, -0.28126433f, -0.02400637f, 0.01872336f, 
    0.11041758f, 0.03848885f, 0.17626940f, 0.02119523f, 0.07797370f, 0.00846912f, -0.03047032f, -0.04535774f, 
    0.00896475f, -0.00052601f, -0.03475112f, 0.06749588f, -0.10059605f, 0.03661999f, 0.13987760f, 0.12581061f, 
    -0.06090734f, 0.08352603f, 0.05917715f, -0.05799088f, 0.30005589f, -0.05339028f, -0.06377280f, 0.18524177f, 
    0.03899159f, -0.09722540f, 0.06864637f, -0.04300771f, 0.05220375f, -0.08115102f, -0.15716240f, -0.00081424f, 
    0.22212283f, -0.09238074f, 0.06916429f, 0.21745694f, 0.15749149f, -0.05052759f, 0.11580749f, 0.01591261f, 
    0.16241156f, -0.04226627f, -0.09718984f, -0.21278287f, 0.09160838f, -0.07662678f, -0.20610151f, -0.05560745f, 
    -0.09449315f, 0.05574909f, 0.09928259f, 0.06325034f, 0.02808198f, 0.03248501f, 0.02923175f, -0.00454684f, 
    -0.21843612f, -0.14222063f, 0.09604210f, 0.09330583f, -0.11460028f, 0.02513674f, -0.00918825f, -0.07374798f, 
    0.03096279f, 0.05039874f, 0.06738245f, 0.09585667f, -0.42211270f, -0.22427826f, 0.00754514f, 0.36869052f, 
    0.11984538f, 0.19221658f, 0.00319811f, -0.03588174f, -0.02274791f, 0.10676182f, 0.00748758f, 0.10129495f, 
    -0.14247389f, -0.00777476f, 0.19226576f, 0.21939716f, 0.06022572f, -0.10306807f, 0.09387062f, -0.05633551f, 
    0.04405734f, 0.05937165f, -0.00004727f, 0.04906361f, -0.11328774f, 0.14511549f, 0.12471824f, 0.07730909f, 
    0.03459509f, 0.11098748f, 0.03081480f, 0.01064004f, -0.10901829f, 0.14615333f, -0.06467523f, 0.06707421f, 
    0.00534952f, 0.08551439f, 0.07553129f, 0.06544293f, 0.06816512f, -0.05462307f, 0.06357552f, 0.06694847f, 
    -0.01902746f, 0.01792241f, 0.12052438f, 0.09194797f, -0.31580618f, -0.19223937f, -0.03605924f, 0.35158834f, 
    -0.24008235f, -0.02239653f, -0.02669453f, 0.14233246f, -0.01007655f, 0.03729102f, 0.06561752f, 0.10398339f, 
    0.11682404f, 0.08047131f, -0.19442709f, -0.01164884f, 0.09483781f, -0.03492004f, -0.19172998f, 0.01953807f, 
    0.12496217f, 0.03717593f, -0.13964653f, 0.04368084f, -0.12322179f, 0.20629106f, 0.00361114f, 0.05725928f, 
    0.01256513f, 0.02043723f, 0.04438990f, 0.11289923f, -0.04039680f, 0.06527763f, -0.01694853f, 0.13191846f, 
    0.28976133f, -0.01479168f, -0.20389535f, 0.05905077f, 0.04851504f, -0.09704275f, 0.03492519f, -0.16137539f, 
    -0.11166996f, -0.03184889f, 0.01584130f, -0.07172326f, -0.14979315f, -0.07765472f, -0.26601323f, 0.02434982f, 
    0.00121639f, -0.05604019f, -0.00979431f, -0.10336203f, 0.04078576f, -0.06989399f, 0.01066829f, -0.06327346f, 
    -0.19356182f, -0.04966962f, -0.14488108f, 0.04010179f, -0.08051790f, -0.06772133f, 0.08821473f, 0.20812878f, 
    0.11765030f, 0.19525020f, 0.08626877f, 0.03183491f, 0.32613856f, 0.44000250f, 0.00146568f, -0.01654713f, 
    -0.18271899f, -0.07330175f, -0.01024934f, -0.03581570f, 0.03273864f, 0.10228539f, -0.03285471f, 0.05713321f, 
    0.14066485f, 0.10416152f, 0.04227974f, -0.18145686f, -0.02638507f, -0.05539616f, 0.06175184f, -0.01869179f, 
    0.06217553f, -0.04857912f, 0.15483488f, -0.06538159f, 0.21326804f, 0.05361380f, 0.18224208f, -0.02409371f, 
    0.14444707f, 0.03216700f, 0.09475748f, -0.10214525f, 0.09311195f, 0.13909145f, 0.15865314f, 0.08791944f, 
    0.02188318f, 0.07605548f, 0.11065574f, 0.01162743f, -0.06642237f, 0.00820868f, -0.11521060f, -0.04196057f, 
    0.06843749f, -0.02477433f, -0.02301171f, 0.05307961f, 0.26243970f, 0.15530775f, 0.00705935f, 0.03191908f, 
    -0.10625883f, -0.03836348f, -0.09005956f, -0.00634460f, -0.06590339f, 0.03782331f, -0.09608355f, -0.02133097f, 
    -0.03555446f, -0.05554555f, 0.08715165f, 0.18233749f, -0.21657503f, -0.08415272f, -0.06645605f, -0.07142348f, 
    0.04495152f, -0.00314879f, -0.03513616f, -0.04590026f, -0.26249912f, -0.01121277f, -0.05959168f, 0.21769200f, 
    0.00295491f, 0.04001356f, 0.08560731f, 0.11242525f, -0.05080602f, -0.05126753f, -0.01204650f, 0.00169453f, 
    -0.03930037f, -0.11758954f, 0.14800891f, 0.22152139f, -0.03326004f, -0.08142678f, -0.00035907f, 0.17133670f, 
    -0.06034278f, 0.01304293f, 0.00832395f, 0.18662661f, -0.17595482f, 0.07587650f, 0.04483841f, -0.13016881f, 
    -0.04285965f, -0.07405310f, -0.02899222f, -0.14753562f, 0.04509054f, 0.07182202f, -0.03144106f, -0.04708965f, 
    -0.05033068f, -0.02701070f, -0.03652639f, 0.21781917f, 0.06377294f, 0.16185004f, -0.02259559f, 0.01881826f, 
    0.08214279f, 0.14606887f, -0.05158847f, 0.04472100f, 0.28985646f, 0.16602285f, -0.39209056f, -0.05290089f, 
    0.24637152f, -0.02184859f, -0.08973980f, -0.01280299f, 0.13602094f, 0.15275283f, -0.03757374f, 0.16009480f, 
    0.01588632f, -0.06282661f, 0.03559598f, -0.01452725f, -0.01648573f, -0.03981195f, -0.05248175f, 0.07192100f, 
    -0.03145478f, 0.02967798f, 0.06594071f, 0.03961407f, 0.03332771f, -0.06613195f, 0.06766331f, 0.04262602f, 
    -0.04533292f, -0.02994039f, -0.06912275f, -0.04396534f, -0.04501177f, -0.04662329f, 0.03926821f, 0.03988982f, 
    0.02494978f, -0.01161406f, -0.06215978f, -0.02504617f, -0.00420807f, 0.01901661f, 0.02215221f, -0.04652118f, 
    0.04913070f, -0.03395072f, -0.05977182f, -0.06984886f, 0.02997130f, 0.02488321f, 0.04264140f, 0.01211130f, 
    -0.05845890f, -0.00481328f, -0.03371486f, -0.01234743f, 0.02691968f, 0.03312406f, -0.01459513f, -0.06835575f, 
    -0.06915562f, -0.05332847f, -0.02116841f, 0.02239177f, 0.00856666f, 0.02872588f, 0.06144220f, 0.06879463f, 
    0.00331292f, 0.01595594f, -0.05426174f, -0.05385862f, -0.06923094f, -0.06437259f, -0.01587143f, -0.03925240f, 
    -0.07017402f, -0.04525154f, -0.03580384f, 0.02339702f, -0.06536819f, 0.06634481f, -0.04965081f, 0.00406839f, 
    0.06914564f, -0.02109054f, -0.06841342f, 0.01925705f, 0.01162553f, -0.00338505f, -0.00035855f, -0.04373917f, 
    -0.02333757f, -0.04225197f, -0.01392396f, 0.07208735f, -0.05515123f, -0.05308556f, 0.03618784f, -0.01232551f, 
    -0.02605173f, 0.03496750f, -0.02667602f, 0.03174532f, -0.05753780f, -0.04110694f, -0.03992707f, 0.00842384f, 
    -0.02638558f, -0.04404176f, -0.00580977f, -0.02183151f, 0.01692116f, 0.00937554f, 0.05775608f, 0.03158306f, 
    -0.02873208f, -0.06903052f, -0.01409534f, 0.05854535f, 0.01383728f, 0.02859640f, -0.05899174f, 0.01393913f, 
    -0.06555178f, 0.04045836f, -0.06400660f, 0.01028713f, -0.03097770f, -0.02423365f, 0.04358314f, -0.02967598f, 
    -0.03406377f, -0.02244551f, -0.05809470f, -0.06114727f, -0.00704053f, 0.06867841f, -0.06472478f, -0.06867178f, 
    0.03405283f, 0.00727063f, -0.05982777f, -0.06237051f, -0.00500192f, -0.04877387f, -0.07068739f, 0.03792483f, 
    -0.06822757f, -0.01665605f, 0.01983174f, -0.06649654f, 0.01864630f, -0.05831144f, 0.04277431f, 0.05253522f, 
    0.05613045f, 0.00454892f, 0.03074302f, 0.01298820f, 0.01312281f, -0.06064153f, -0.01050808f, -0.00981139f, 
    0.01813523f, -0.06521904f, 0.01802524f, 0.04579812f, 0.02104325f, -0.03132819f, -0.03227708f, 0.03020782f, 
    -0.02855974f, 0.06981069f, -0.03815595f, 0.00669422f, 0.00829811f, -0.00682420f, 0.05486246f, -0.06700347f, 
    -0.03656560f, -0.01931655f, -0.03409331f, -0.01128545f, 0.01066814f, -0.03999414f, 0.02849321f, -0.06357051f, 
    -0.02861171f, -0.02985653f, -0.00795649f, 0.05553049f, 0.01422819f, -0.02683538f, 0.06564245f, 0.06935047f, 
    -0.03699094f, -0.02338707f, -0.04808014f, -0.00788037f, 0.01520030f, -0.07041352f, -0.06251916f, 0.05951524f, 
    0.08346611f, 0.13590033f, -0.09342404f, -0.00730504f, -0.03286757f, -0.09111766f, -0.13926247f, 0.07958525f, 
    -0.01390636f, -0.00108728f, -0.01829848f, -0.04241433f, -0.22672836f, 0.09036306f, -0.12959670f, 0.03972927f, 
    0.00099594f, 0.01707780f, 0.14220810f, 0.10910443f, 0.04879170f, 0.17110458f, 0.08003119f, 0.06795196f, 
    0.27260882f, -0.39884901f, 0.06038352f, -0.05485086f, 0.14686203f, 0.14682718f, -0.05575966f, 0.04317742f, 
    -0.02369607f, -0.02012888f, 0.13135217f, -0.02284158f, -0.05752704f, 0.10659472f, -0.11445357f, 0.01080666f, 
    -0.04625086f, 0.01921121f, 0.14735281f, -0.01650308f, -0.00277452f, 0.01517699f, 0.02521592f, 0.07640801f, 
    -0.02489748f, 0.01997452f, -0.14253786f, -0.02273312f, 0.01028604f, 0.10314177f, -0.01165349f, 0.02774604f, 
    -0.04942596f, -0.13215721f, -0.10624194f, -0.12739269f, -0.11365744f, 0.09352122f, -0.15799776f, -0.07454156f, 
    0.01713572f, -0.13234401f, -0.13301416f, -0.15297332f, -0.09711828f, 0.02407952f, 0.06371500f, 0.06047223f, 
    0.02261830f, -0.00941478f, -0.00795836f, -0.07237805f, -0.12112868f, -0.03704151f, -0.04500566f, -0.04181292f, 
    -0.01829356f, 0.00682192f, 0.09701888f, 0.02694018f, 0.15970419f, 0.25348657f, 0.17687300f, 0.07651503f, 
    0.04042448f, 0.37672949f, -0.28265277f, 0.05281137f, 0.07412898f, 0.18103230f, -0.05838245f, 0.03723371f, 
    0.10940946f, -0.07058424f, 0.08926768f, 0.06126745f, -0.12711871f, -0.05448677f, -0.07355692f, -0.00810857f, 
    -0.06557251f, -0.11267415f, 0.21073939f, -0.08154036f, -0.01665249f, 0.08519765f, 0.21880102f, -0.05941205f, 
    -0.05127448f, -0.05196124f, -0.14777763f, 0.04333983f, -0.10320707f, 0.06965378f, -0.01294084f, -0.05752933f, 
    0.06393664f, 0.12722945f, -0.11784446f, -0.02867402f, 0.08420363f, 0.09516843f, 0.07055025f, -0.00711208f, 
    -0.02725343f, 0.07262658f, -0.06846234f, -0.00400954f, -0.07993785f, 0.19772229f, -0.21985562f, -0.14015062f, 
    0.05984979f, -0.00284450f, 0.15440170f, 0.11112096f, 0.10109160f, -0.03312888f, -0.01333866f, 0.04211731f, 
    0.03329096f, -0.16840108f, 0.00065533f, -0.07542200f, 0.07634275f, 0.07030478f, -0.01405251f, 0.00588402f, 
    -0.05645303f, -0.01977384f, 0.04745752f, 0.03075672f, -0.05042269f, 0.16270313f, 0.03496857f, -0.12469267f, 
    -0.06722134f, 0.01946852f, -0.11821488f, -0.08961193f, 0.16630237f, 0.09021507f, -0.00130267f, 0.06978094f, 
    0.10026807f, 0.05645715f, -0.06098807f, -0.01737454f, 0.03281635f, 0.00104855f, 0.02024522f, 0.00255334f, 
    0.18412298f, 0.06086007f, -0.16445141f, 0.28759935f, 0.16139461f, 0.03351308f, -0.03379640f, -0.15923862f, 
    -0.09242366f, 0.00268950f, 0.00231776f, 0.01850468f, -0.04947338f, 0.06530456f, -0.04546333f, 0.05762700f, 
    0.09578103f, -0.35998014f, 0.02798922f, -0.00052456f, -0.01075061f, 0.03055944f, 0.03977588f, -0.14487557f, 
    0.30585006f, 0.18341094f, 0.17910372f, 0.28518558f, 0.08855201f, 0.07262726f, 0.08243622f, 0.05521635f, 
    0.07778889f, -0.23775306f, -0.17173809f, -0.24684729f, -0.07047825f, -0.07970906f, -0.17390256f, -0.17289774f, 
    -0.18115860f, 0.22845009f, -0.12236501f, 0.18274692f, -0.11501487f, 0.00439905f, -0.12954009f, -0.26499674f, 
    -0.03073363f, -0.05814004f, 0.11828791f, 0.19503681f, 0.14274181f, -0.11115243f, 0.14115855f, 0.14546172f, 
    -0.05102918f, -0.04087095f, -0.13389955f, -0.01930476f, 0.08506673f, 0.00227245f, 0.10666232f, 0.15635821f, 
    0.26242498f, 0.10231052f, 0.14991613f, 0.21371415f, 0.00967885f, -0.10439964f, 0.18209243f, 0.09800757f, 
    0.06782048f, 0.16979802f, 0.12617660f, 0.27107313f, 0.17622970f, -0.04436332f, 0.17218745f, 0.25726077f, 
    0.07128192f, 0.08827762f, 0.08347221f, 0.17792253f, 0.10362238f, -0.11854554f, -0.13050579f, -0.07826613f, 
    -0.06256156f, -0.12810738f, -0.12963267f, -0.13745782f, 0.02173292f, -0.15940121f, -0.24396497f, -0.03774181f, 
    -0.22425498f, -0.32547855f, -0.35446915f, -0.41372430f, -0.29272589f, -0.03958125f, -0.26720262f, 0.12715508f, 
    0.03018390f, 0.13516018f, 0.00653576f, -0.20818622f, -0.08671868f, -0.03964100f, 0.25459945f, 0.24899298f, 
    -0.00442052f, 0.07504003f, 0.00871618f, -0.07996187f, -0.02739240f, 0.00415817f, -0.17321609f, -0.09132485f, 
    0.00736361f, 0.01222547f, -0.24244840f, 0.17967214f, 0.14949976f, -0.21801412f, -0.02702056f, 0.17964414f, 
    -0.07861608f, 0.00058894f, 0.14526102f, -0.10252365f, 0.07518820f, -0.00687135f, 0.07029144f, 0.09931640f, 
    -0.06695248f, 0.09660141f, 0.06048787f, -0.04333317f, 0.02055454f, 0.00657578f, 0.02204017f, 0.14475830f, 
    -0.09399378f, -0.20485950f, 0.05620949f, -0.07655876f, 0.30811727f, -0.17096315f, 0.24160357f, 0.10356840f, 
    0.00228047f, 0.15033887f, -0.04724560f, 0.05204236f, -0.06400391f, 0.04391693f, -0.16773991f, -0.08721120f, 
    0.12415159f, 0.21791482f, -0.01014703f, 0.45672029f, -0.08919812f, -0.04430187f, 0.10999828f, 0.11809213f, 
    -0.00789848f, 0.02364623f, -0.04129235f, 0.08881070f, 0.13914444f, -0.26706588f, 0.10069651f, -0.16279058f, 
    -0.21633796f, -0.03544974f, 0.04471232f, -0.16310997f, 0.01495125f, 0.12239133f, -0.05699109f, -0.31357816f, 
    -0.15364257f, -0.01702505f, -0.00679735f, -0.05057066f, -0.05008414f, -0.05891617f, -0.00455625f, -0.09159984f, 
    -0.16578862f, -0.14025512f, 0.07232694f, -0.20654525f, 0.24674207f, 0.05765540f, 0.19270761f, 0.06790565f, 
    0.22113705f, 0.04171802f, -0.20062073f, -0.20071532f, 0.05727161f, -0.05753226f, 0.06933165f, 0.12932143f, 
    -0.06392289f, -0.02921214f, -0.04920861f, 0.00679431f, -0.06466548f, -0.02849660f, -0.00593882f, -0.01494928f, 
    -0.00291116f, 0.04502594f, 0.02654960f, 0.00013160f, 0.00999383f, 0.04504938f, -0.02199946f, 0.02446351f, 
    -0.06483042f, -0.01647095f, -0.00836963f, -0.04873068f, -0.04252579f, 0.02629193f, 0.00756483f, 0.04322362f, 
    -0.01666297f, 0.04959250f, 0.00523260f, -0.02531010f, -0.05860756f, -0.07130641f, -0.04972000f, 0.05415256f, 
    -0.00876664f, 0.02074928f, 0.02127016f, 0.02434321f, 0.01062501f, 0.03074024f, -0.03219093f, 0.02627108f, 
    0.04132928f, -0.01639312f, 0.06025498f, -0.04038811f, 0.02464484f, -0.01541946f, 0.04252690f, 0.04131980f, 
    0.00472652f, 0.01106710f, -0.08186238f, -0.08480793f, 0.05073975f, -0.05877933f, 0.00870167f, -0.04882482f, 
    0.05948505f, 0.04757259f, -0.07236671f, -0.01960530f, -0.07438058f, -0.04310567f, 0.04265724f, 0.03234433f, 
    0.02145793f, 0.00458853f, -0.03138481f, -0.05178541f, -0.02430663f, -0.03709638f, -0.06006700f, -0.06266155f, 
    -0.02871204f, -0.08187383f, 0.00328100f, -0.02066538f, 0.01363195f, -0.00417355f, -0.00947406f, 0.04112903f, 
    -0.06545885f, -0.06552975f, -0.02866423f, -0.02472164f, 0.04880992f, 0.05489085f, 0.02280291f, 0.03931106f, 
    0.00951220f, 0.03183453f, 0.04894922f, -0.08438645f, -0.00803355f, 0.02543196f, 0.04731986f, -0.04878544f, 
    0.02302756f, 0.04082957f, -0.06613269f, -0.00155009f, -0.03965769f, 0.02549271f, -0.00601967f, 0.00533346f, 
    -0.05012761f, 0.05718928f, 0.06423634f, 0.03471457f, 0.03927800f, -0.02373902f, 0.01401732f, 0.03525704f, 
    -0.02620066f, 0.03142934f, 0.00139332f, -0.04114496f, 0.01940621f, -0.02314374f, -0.05468468f, 0.04770738f, 
    -0.04060359f, -0.04476833f, -0.01334057f, 0.00998845f, -0.06434138f, 0.03788310f, 0.03096799f, 0.05620911f, 
    -0.02887953f, -0.07788301f, -0.07720397f, 0.05916401f, -0.05230230f, -0.04418143f, 0.01708212f, 0.02914288f, 
    -0.04868240f, -0.03694183f, 0.02235270f, -0.05368662f, 0.00929814f, -0.04775720f, 0.03874263f, -0.06773525f, 
    0.00421910f, -0.01659535f, -0.03282098f, 0.02159172f, -0.06334097f, -0.05982449f, 0.05802736f, -0.03749030f, 
    -0.01145463f, 0.00164876f, -0.00568775f, 0.03132446f, -0.00312310f, -0.00959017f, 0.01750198f, -0.00415306f, 
    -0.02252230f, 0.02625092f, 0.03506368f, 0.05424241f, -0.07950687f, -0.05489710f, -0.07099023f, 0.03933558f, 
    -0.04273450f, 0.03794954f, -0.03428081f, -0.05615110f, -0.05987233f, -0.03257785f, -0.04536699f, -0.02917067f, 
    -0.02904897f, -0.00127171f, -0.03162019f, -0.07649103f, -0.06948062f, -0.04114338f, -0.05543953f, 0.01729113f, 
    -0.03316975f, -0.03813676f, 0.00172285f, -0.05003928f, -0.05168596f, -0.07873072f, -0.00568108f, -0.04752689f, 
    -0.14807059f, 0.11248443f, -0.04259979f, -0.22317749f, 0.03576576f, 0.09596153f, 0.16294010f, 0.03802441f, 
    -0.03188607f, 0.03196752f, 0.08374872f, -0.04226332f, -0.15968275f, 0.05335831f, -0.23466675f, 0.06542779f, 
    -0.24482317f, 0.00285569f, 0.00544087f, -0.02468132f, 0.01251816f, -0.01974439f, 0.05241324f, 0.03060133f, 
    -0.23913153f, 0.03671966f, 0.08950305f, -0.02469114f, 0.01349551f, -0.00345189f, 0.21939355f, 0.11814667f, 
    0.02476126f, 0.14664523f, -0.03661455f, 0.05972744f, -0.04035151f, 0.25340194f, -0.15398808f, -0.23262234f, 
    -0.01883035f, -0.00966935f, 0.25572258f, -0.05354327f, 0.09087624f, 0.05128670f, -0.03894785f, -0.10256413f, 
    -0.05785830f, -0.16773199f, -0.10912450f, -0.02770239f, 0.08995886f, 0.16310202f, -0.05499146f, -0.08460135f, 
    -0.10236503f, -0.08522680f, -0.06814002f, 0.04049728f, -0.28139931f, 0.23050934f, 0.24230731f, -0.01844171f, 
    -0.18678117f, -0.15307570f, 0.00166484f, -0.04989192f, -0.02773277f, 0.08347045f, 0.05875625f, 0.04337248f, 
    -0.18313938f, -0.04917204f, -0.05340098f, 0.04071251f, -0.10973556f, -0.02887456f, 0.01077642f, -0.06300291f, 
    -0.28910547f, -0.07137575f, -0.09689294f, 0.06212873f, 0.84371340f, -0.36221614f, 0.35981056f, 0.40162519f, 
    0.15000871f, 0.01532558f, -0.01715011f, 0.03675906f, -0.05908387f, 0.13676029f, 0.01920873f, 0.04439041f, 
    -0.33019823f, 0.30967841f, -0.01822815f, 0.19455567f, -0.04636655f, 0.07686774f, 0.31866482f, 0.00606939f, 
    0.05780975f, 0.12153049f, -0.08727130f, -0.06078032f, -0.04092929f, 0.09594889f, 0.26605773f, -0.13315853f, 
    -0.18657205f, -0.19663776f, -0.17662010f, -0.12778929f, -0.06034495f, -0.00548276f, -0.06128564f, 0.00393267f, 
    0.11469120f, -0.17182051f, -0.03059669f, -0.04020544f, 0.07691686f, 0.03732331f, -0.02897966f, -0.03318053f, 
    -0.06598943f, 0.00372206f, -0.01255442f, 0.04432023f, -0.19074845f, 0.29739350f, 0.03368202f, 0.28974554f, 
    0.10366775f, -0.01457711f, 0.12287112f, -0.09880610f, -0.04462257f, 0.07949439f, -0.01333610f, 0.05744294f, 
    0.08442093f, -0.15966220f, -0.09044468f, 0.09940021f, 0.08808338f, 0.04713533f, 0.03863808f, -0.12939356f, 
    -0.02597247f, -0.01366805f, -0.06538390f, -0.06204396f, -0.01703969f, 0.02770667f, -0.00033446f, 0.01683647f, 
    0.12312687f, -0.16169910f, 0.13992970f, 0.14850071f, -0.11004036f, 0.05696612f, 0.24436243f, -0.01665448f, 
    0.03623221f, 0.08721168f, 0.03447958f, 0.31660044f, -0.06012747f, 0.11281695f, 0.03663874f, 0.06685230f, 
    -0.23227695f, 0.05385615f, 0.14085962f, 0.12514941f, 0.46481985f, 0.29050547f, -0.14721297f, -0.40334475f, 
    -0.03017174f, 0.09005699f, 0.14062312f, 0.00702765f, 0.11126741f, 0.07334330f, 0.13265848f, 0.13011214f, 
    -0.05490608f, -0.07210924f, -0.08400650f, -0.24435252f, -0.03664935f, 0.13339074f, 0.23404451f, -0.02236205f, 
    -0.10630460f, -0.02200254f, 0.20826252f, 0.03470463f, -0.20088661f, -0.09215289f, -0.21143246f, 0.03338689f, 
    0.02523627f, -0.02799402f, 0.01177617f, -0.06842399f, -0.06445908f, -0.02211634f, 0.14340162f, -0.01016261f, 
    -0.46838853f, -0.12258914f, -0.26331046f, -0.06990646f, 0.10498753f, 0.25119409f, 0.24161503f, 0.00797757f, 
    0.00446644f, 0.05009047f, 0.02597563f, 0.06671467f, -0.19475624f, 0.12324348f, -0.31663173f, -0.18984304f, 
    0.11362021f, 0.05715111f, 0.02241143f, 0.02765352f, -0.06849939f, -0.07087090f, -0.01270508f, 0.05190427f, 
    0.19141519f, -0.01883860f, 0.01695774f, 0.09007216f, 0.10134718f, 0.06031897f, 0.02782343f, 0.04201366f, 
    -0.01084956f, 0.06790461f, 0.03549391f, 0.14773414f, -0.04320939f, -0.04880600f, 0.26882464f, 0.09718237f, 
    -0.06024717f, -0.08819573f, -0.06998906f, 0.03053028f, 0.01676334f, 0.00052584f, 0.08174691f, 0.04606427f, 
    0.00469947f, 0.06663952f, -0.00292107f, -0.01441100f, 0.10661691f, -0.01083632f, -0.13325781f, -0.13796702f, 
    -0.05325506f, 0.00080982f, -0.16171661f, 0.05974809f, 0.48952469f, -0.53975016f, 0.14555225f, -0.12616703f, 
    0.17771068f, -0.11073294f, 0.06539141f, 0.00754875f, -0.12302559f, 0.08286598f, -0.07226606f, 0.12043706f, 
    -0.43234175f, 0.00798327f, -0.24484172f, 0.29244691f, 0.02102965f, 0.12582859f, 0.13960008f, -0.06637314f, 
    -0.00747928f, -0.09000276f, -0.05249939f, -0.01226361f, 0.06996858f, 0.06702486f, 0.13719861f, 0.02907122f, 
    -0.00440341f, 0.00630633f, -0.00257698f, 0.06460764f, 0.01396820f, 0.06010198f, 0.04787115f, -0.03906804f, 
    0.24920902f, 0.14552493f, 0.01929301f, 0.00127443f, 0.14483549f, 0.05286096f, 0.01568816f, -0.07421716f, 
    0.07985584f, -0.02045550f, -0.04077759f, -0.02441474f, 0.07803810f, 0.37072811f, -0.05802377f, 0.18965596f, 
    -0.10539182f, 0.03644815f, 0.12741666f, -0.18750395f, -0.02360754f, 0.07118142f, -0.07635234f, 0.09304105f, 
    0.22252256f, 0.01495281f, -0.00691043f, -0.09510405f, 0.07655817f, 0.09595795f, -0.05544288f, -0.02193169f, 
    -0.10358696f, -0.08506244f, 0.06899051f, 0.00385264f, -0.09884664f, -0.18596728f, -0.21657377f, 0.05060742f, 
    0.03647552f, -0.22456224f, -0.04247133f, 0.10927334f, -0.04837927f, 0.11360192f, 0.12184413f, -0.06025782f, 
    0.00700992f, 0.11554978f, -0.11460090f, 0.16164613f, 0.13318102f, -0.11036090f, 0.07304355f, -0.01751355f, 
    -0.27574578f, 0.08459458f, -0.00488661f, 0.11606974f, -0.08338828f, 0.17835903f, 0.13392727f, -0.26407713f, 
    -0.06454095f, -0.11818563f, -0.00844655f, 0.11183926f, -0.02845487f, 0.02127861f, -0.01873303f, -0.01554309f, 
    0.00336331f, -0.00333783f, -0.01665287f, -0.01210527f, 0.01982594f, -0.08819681f, -0.08130538f, -0.02192989f, 
    -0.04856952f, -0.04517405f, -0.01777509f, 0.02435644f, -0.02650960f, -0.07577401f, -0.02331285f, 0.02398647f, 
    -0.06103458f, -0.05016552f, -0.08980235f, -0.05359137f, -0.03312162f, -0.01461466f, 0.00414993f, 0.03765906f, 
    0.03898207f, -0.02262269f, -0.00589190f, -0.01776604f, -0.01014851f, 0.03707032f, 0.02578844f, 0.00989799f, 
    -0.05738898f, -0.01068362f, -0.03476078f, -0.02279136f, -0.06996267f, 0.00960186f, 0.05182816f, -0.03176444f, 
    0.00408857f, 0.01460363f, 0.05265047f, 0.00607986f, -0.02160085f, 0.01793033f, 0.05135652f, 0.01252656f, 
    -0.05257710f, -0.02431751f, -0.07262061f, 0.01337516f, 0.02856121f, -0.05071802f, 0.00198119f, -0.05113428f, 
    0.00169600f, -0.06227076f, -0.06103698f, 0.01861607f, -0.01601080f, -0.02063043f, -0.03713826f, -0.07923729f, 
    -0.08834764f, 0.02992508f, -0.03147559f, -0.04099037f, -0.08231374f, -0.06823023f, -0.07321382f, -0.03847951f, 
    -0.03857565f, -0.01192837f, -0.04087117f, 0.00801319f, -0.06055931f, -0.01275466f, 0.01615604f, -0.04136914f, 
    -0.07549936f, 0.02606017f, 0.04098759f, -0.07711864f, -0.08707970f, 0.03723593f, -0.03990674f, 0.02886528f, 
    0.00883130f, -0.05913169f, 0.02544756f, -0.07987558f, -0.02360379f, -0.00045894f, -0.01385032f, -0.10009690f, 
    0.00714265f, 0.03205473f, 0.03391481f, 0.05435150f, -0.07277091f, -0.06841594f, -0.03795725f, -0.09287773f, 
    -0.01330362f, -0.04823449f, 0.01088677f, 0.01678874f, 0.03256098f, 0.00360516f, 0.03802495f, -0.00577611f, 
    -0.00929430f, -0.07043807f, 0.01553949f, 0.02164625f, -0.06226197f, -0.10225835f, -0.02986137f, -0.09071206f, 
    0.03678343f, 0.01628978f, -0.00556310f, -0.04241085f, -0.03946090f, -0.07363229f, 0.05179957f, 0.01322568f, 
    -0.01006875f, -0.07635525f, -0.00963047f, -0.07822766f, 0.05475219f, -0.09291748f, -0.08916843f, -0.03413558f, 
    -0.05641537f, 0.00756404f, -0.08287261f, -0.00798979f, -0.03877925f, -0.02375981f, 0.01259237f, -0.03919099f, 
    0.02453074f, 0.00983010f, -0.05947531f, -0.01172561f, -0.00254735f, 0.02880858f, -0.06391491f, -0.00159446f, 
    0.02497345f, -0.06589066f, -0.02139296f, -0.05094113f, -0.05478894f, -0.09889641f, -0.02803039f, -0.04779221f, 
    0.03421874f, -0.02967890f, -0.00730443f, -0.02275660f, -0.02797833f, -0.03160303f, -0.02379437f, -0.05253429f, 
    -0.08054408f, -0.07324939f, -0.03701990f, -0.01278393f, -0.06334119f, 0.03169552f, -0.01568330f, 0.03268631f, 
    -0.03590898f, -0.04756428f, 0.03415171f, 0.03465964f, 0.03992061f, 0.02241945f, 0.00129927f, 0.03011113f, 
    0.01963771f, -0.01852945f, -0.06363992f, -0.04371336f, 0.01837237f, 0.00515316f, -0.05649765f, 0.03342840f, 
    -0.08060775f, -0.16826707f, -0.15383583f, 0.02256978f, 0.07729787f, -0.01993169f, 0.05864938f, 0.08243907f, 
    0.02440824f, -0.08676763f, 0.09799432f, 0.01321116f, -0.05420496f, 0.10526846f, 0.27373528f, 0.05287572f, 
    -0.02164879f, 0.01932236f, -0.11090306f, 0.04865206f, 0.04989443f, 0.04720559f, 0.14121582f, 0.08864444f, 
    -0.49001226f, 0.20420964f, 0.12273519f, 0.28042960f, -0.12463032f, -0.01683070f, 0.02740167f, 0.01054313f, 
    0.08359575f, -0.02579533f, -0.05743852f, -0.04239856f, -0.19964178f, -0.13935065f, 0.11669636f, 0.05179175f, 
    0.04656040f, -0.02148739f, -0.05365429f, -0.02847260f, 0.09275462f, 0.02570839f, -0.07700316f, -0.19505359f, 
    -0.04911881f, -0.25688314f, -0.18945998f, -0.06504989f, -0.08598311f, -0.17413132f, -0.08435653f, 0.09071276f, 
    -0.02332602f, 0.04157837f, -0.19550088f, -0.12674652f, 0.19599874f, 0.06340509f, 0.14427347f, 0.02199453f, 
    -0.03311756f, 0.09918086f, -0.01086570f, 0.03057932f, -0.12872270f, -0.02290341f, -0.01390780f, -0.02777995f, 
    0.05832620f, 0.14532179f, -0.06371059f, -0.01894897f, 0.10721011f, 0.07500146f, 0.02910348f, -0.05860392f, 
    0.12538935f, 0.10297781f, 0.09148984f, 0.17390834f, -0.00434090f, -0.12208870f, 0.10899622f, 0.15437780f, 
    0.05109045f, -0.27327228f, 0.18419218f, -0.00708223f, -0.05759609f, 0.17898361f, -0.07863281f, 0.02558207f, 
    -0.08470285f, -0.02524984f, 0.11017746f, -0.06767876f, -0.15765783f, 0.17562948f, 0.10861910f, -0.07712942f, 
    0.10087497f, 0.07473196f, -0.15136972f, 0.08331100f, 0.05049976f, -0.01237203f, -0.42021108f, -0.20457862f, 
    -0.03874691f, -0.01629256f, 0.10521737f, 0.02860893f, -0.04118679f, -0.08314510f, 0.00784139f, -0.03589102f, 
    -0.03569170f, -0.15222491f, 0.00560077f, -0.03400614f, -0.08092748f, -0.03826135f, -0.05963218f, -0.05517047f, 
    -0.07856023f, -0.09245627f, -0.02846924f, 0.03533797f, -0.01012093f, 0.08568469f, -0.01674979f, 0.05357508f, 
    0.06274974f, 0.08624496f, 0.07929873f, -0.01596654f, -0.06856653f, -0.04511751f, -0.09345058f, -0.01715425f, 
    -0.08743853f, -0.07274612f, -0.03762244f, -0.14809030f, -0.02651174f, -0.03813769f, 0.07292665f, 0.00174809f, 
    0.02660952f, -0.04752650f, -0.01928800f, -0.01738013f, 0.00074459f, -0.09975615f, -0.16486278f, 0.07398505f, 
    0.04740239f, -0.16537040f, -0.00460042f, -0.11269905f, 0.05553710f, 0.12652706f, 0.15457420f, 0.16759969f, 
    0.06771898f, 0.35042211f, 0.17638262f, 0.32471985f, 0.20060684f, 0.12699872f, 0.04421895f, 0.22025220f, 
    -0.03159450f, 0.07015897f, 0.05700855f, 0.14670260f, 0.07809808f, -0.14732730f, -0.06501054f, 0.39209369f, 
    0.19971970f, -0.03483806f, -0.07158415f, -0.05087207f, 0.24955642f, 0.11435079f, 0.14343634f, 0.08255885f, 
    -0.07124144f, -0.02394740f, -0.02707946f, 0.03917839f, -0.00661287f, 0.01813336f, 0.05690045f, -0.08016155f, 
    -0.00996462f, -0.06689490f, -0.06027913f, 0.04147726f, -0.01616553f, 0.05553379f, 0.02930353f, 0.03278812f, 
    0.02075080f, 0.01148241f, 0.03019972f, 0.06045143f, -0.02277534f, 0.02201831f, -0.04760345f, -0.04229240f, 
    -0.01925829f, -0.05515716f, -0.04719713f, -0.02953716f, 0.00236130f, 0.02530440f, -0.06224896f, 0.02488937f, 
    0.00888495f, -0.07605424f, -0.01626896f, -0.07611339f, -0.06873100f, -0.00042810f, -0.01135091f, -0.00869537f, 
    -0.00318977f, -0.04542867f, -0.05715355f, -0.06109992f, -0.05830774f, -0.07715657f, -0.06017725f, -0.06029448f, 
    -0.04647429f, 0.00855243f, -0.04972228f, -0.03161738f, 0.05215977f, -0.00888633f, 0.03617826f, 0.05535490f, 
    -0.03475999f, 0.05708849f, 0.04412657f, -0.02276696f, 0.03072229f, -0.06029490f, 0.03997656f, 0.01861961f, 
    0.05411323f, 0.05434018f, -0.01524891f, 0.01760892f, 0.00450210f, 0.01086037f, -0.00314747f, -0.02776070f, 
    -0.06145194f, -0.07455660f, -0.01813420f, -0.07303908f, 0.01231645f, -0.05285015f, 0.01934141f, -0.02861565f, 
    0.02491619f, 0.03948204f, -0.07866885f, 0.00984832f, -0.02440823f, -0.01827504f, 0.00721835f, 0.05882917f, 
    -0.02141379f, -0.03161535f, 0.03082024f, 0.05697655f, -0.00512010f, -0.04698642f, 0.01941567f, -0.05858273f, 
    0.02866133f, 0.04318589f, 0.02254474f, -0.04747297f, -0.05697695f, -0.07840309f, 0.03213582f, 0.00832763f, 
    0.01963489f, -0.07039852f, -0.00271812f, 0.04665616f, 0.03580184f, 0.00428926f, 0.04951203f, -0.07836115f, 
    -0.01560365f, -0.06458751f, -0.06859297f, -0.02985874f, -0.03279731f, 0.05507588f, -0.04971302f, 0.01495489f, 
    -0.05423325f, 0.05284552f, -0.04568232f, -0.06259584f, 0.03818656f, 0.02213708f, 0.02843213f, 0.00901165f, 
    -0.06319925f, 0.03438124f, -0.05985957f, 0.05628783f, -0.05828210f, -0.00079691f, 0.03172338f, -0.07379019f, 
    -0.01277131f, 0.02767519f, -0.07068474f, -0.07368550f, 0.01985037f, 0.04375561f, -0.06444740f, 0.04127536f, 
    -0.02652499f, -0.02968184f, 0.03394868f, 0.01502313f, -0.04817600f, 0.02652218f, 0.02999173f, -0.03646879f, 
    -0.00220232f, -0.06732754f, 0.03271648f, 0.00248953f, 0.03675234f, -0.05003377f, 0.04971815f, 0.01499217f, 
    0.03409345f, 0.03642405f, -0.03664749f, 0.02629041f, 0.03152410f, 0.04720236f, -0.04957997f, -0.07729121f, 
    0.01754618f, -0.00836376f, -0.02194652f, 0.04513549f, 0.05874595f, 0.04413033f, -0.07833247f, 0.00786296f, 
    0.01629633f, -0.04689999f, 0.02295902f, -0.05056928f, -0.01895839f, -0.07169853f, 0.00058611f, -0.02142607f, 
    -0.04463299f, -0.07696370f, -0.04423998f, 0.05547588f, 0.05274870f, 0.06081823f, -0.04528989f, -0.07473710f, 
    0.04594523f, 0.06104447f, -0.08853763f, -0.27084172f, -0.26889068f, 0.22281080f, 0.05294845f, 0.09066971f, 
    0.15425296f, 0.12151086f, 0.07965847f, 0.02512289f, 0.12457484f, 0.17520340f, -0.02635391f, -0.01615906f, 
    -0.14073713f, -0.15279034f, -0.08632857f, 0.00558097f, 0.01925573f, 0.06883788f, 0.03651470f, -0.00653478f, 
    -0.09660049f, -0.38155669f, -0.23070081f, -0.51628655f, -0.23605590f, -0.07414297f, -0.01020160f, 0.15874605f, 
    -0.09944713f, 0.04681315f, 0.09878933f, 0.11648840f, -0.12944731f, 0.40385818f, -0.04133227f, -0.37215695f, 
    -0.20015959f, -0.03548450f, 0.07039750f, 0.07583734f, 0.10061702f, 0.12674941f, 0.03487873f, 0.01984851f, 
    -0.19457091f, -0.13411275f, -0.50790429f, -0.12378139f, -0.06095241f, 0.23276119f, -0.08528294f, 0.06512236f, 
    -0.02989426f, -0.10260557f, -0.06606331f, 0.02855146f, 0.22542976f, -0.14167812f, 0.08013967f, 0.33253571f, 
    0.06888779f, 0.15908834f, 0.18082865f, -0.10516621f, -0.06934103f, 0.00892776f, -0.02335134f, 0.10835411f, 
    0.03551933f, 0.03424666f, -0.01069043f, 0.02765706f, -0.03461337f, 0.05616310f, 0.08307505f, 0.06562064f, 
    -0.17279370f, -0.21007721f, -0.00214453f, -0.12246335f, -0.49991307f, -0.46608675f, -0.23546636f, -0.06123149f, 
    0.02251873f, 0.20100653f, -0.32535011f, 0.14663637f, 0.00360251f, 0.10689851f, -0.12076122f, 0.01755590f, 
    0.26758152f, 0.15009278f, 0.05500326f, 0.35409415f, 0.17788357f, 0.16318151f, 0.10337692f, 0.09973324f, 
    -0.08224463f, -0.10934560f, -0.00253143f, -0.18710820f, 0.22272219f, 0.16219950f, 0.20949693f, 0.23097387f, 
    0.00939439f, 0.07169980f, -0.04739865f, 0.04396572f, 0.11240671f, 0.14578469f, 0.08553819f, 0.09668869f, 
    -0.44662765f, -0.42032963f, -0.43556711f, -0.23856646f, 0.15794079f, -0.05215555f, -0.06896355f, -0.15459280f, 
    -0.23001420f, -0.13404876f, -0.20202219f, -0.06878150f, -0.68754184f, -0.44692758f, 0.11190322f, 0.27365443f, 
    0.28555456f, 0.20952643f, 0.05186098f, -0.08132686f, 0.08209539f, -0.00902121f, -0.00472122f, 0.01025516f, 
    -0.38856572f, -0.44626430f, 0.01427038f, 0.07476502f, 0.08219123f, -0.02603795f, 0.06838991f, -0.00908822f, 
    -0.12393904f, 0.00327991f, 0.18991101f, 0.05739109f, -0.02562366f, 0.17369668f, 0.27202973f, 0.10731704f, 
    -0.03009807f, -0.04297702f, 0.03757404f, -0.06783123f, 0.14613526f, 0.12516527f, -0.01744578f, 0.10571231f, 
    -0.04756942f, -0.07642295f, 0.03336238f, -0.06248505f, -0.01551429f, 0.02755370f, 0.04482942f, -0.10205857f, 
    0.15849203f, 0.18026000f, 0.20770775f, 0.07211454f, 0.17711671f, 0.24738315f, 0.23042433f, -0.11774798f, 
    -0.27628073f, 0.12191970f, 0.00858892f, 0.04273730f, 0.02091014f, 0.15930797f, 0.11356199f, 0.17851143f, 
    -0.13672461f, 0.17494160f, -0.06730405f, -0.05665589f, 0.09198648f, -0.07640373f, 0.07115303f, -0.00282890f, 
    -0.06298683f, -0.03487644f, 0.09096910f, -0.06494322f, -0.24794719f, 0.00738849f, 0.02039119f, -0.01838783f, 
    -0.14112085f, 0.08153425f, -0.00487457f, 0.05728050f, 0.05010194f, 0.11642849f, 0.17698969f, 0.07676659f, 
    -0.20234415f, -0.10929492f, 0.08756801f, -0.03897937f, -0.04265758f, -0.10747246f, 0.07015725f, 0.02302783f, 
    0.12391404f, 0.06646790f, -0.06366888f, -0.05251399f, -0.08224486f, 0.04258822f, -0.11982839f, -0.09130699f, 
    0.02905924f, -0.07621440f, 0.02581909f, 0.06291080f, 0.01037425f, -0.01449076f, -0.10706998f, -0.15917023f, 
    -0.28474358f, -0.06781802f, -0.03878286f, 0.09231329f, 0.08059676f, 0.14545777f, -0.03637601f, 0.03951782f, 
    0.02209458f, -0.05012741f, -0.07324341f, -0.10085711f, 0.18778412f, 0.19675760f, 0.11666562f, -0.09866872f, 
    -0.05203615f, -0.19344009f, -0.00740826f, -0.01792767f, -0.13898800f, -0.01481293f, 0.01686265f, -0.08393327f, 
    -0.08251860f, 0.10150351f, -0.07190981f, -0.11581885f, -0.08537718f, 0.01687631f, -0.00967781f, -0.12011787f, 
    0.10997410f, 0.22557889f, 0.17807114f, 0.18737729f, 0.16513580f, -0.03091570f, 0.32977986f, 0.11818125f, 
    0.16095954f, -0.03224122f, 0.09712745f, 0.01849548f, 0.08102348f, 0.08794927f, -0.18149313f, -0.00694575f, 
    0.04247493f, 0.29884925f, -0.08363285f, 0.05351023f, -0.11099071f, 0.06759363f, 0.21157527f, 0.09615923f, 
    -0.06876941f, 0.01668650f, -0.10491717f, -0.13830861f, 0.29042590f, 0.26414663f, 0.18118741f, 0.00404166f, 
    -0.05707154f, -0.07676172f, -0.03548682f, -0.02735104f, -0.13802916f, 0.04201304f, -0.05501310f, -0.05013197f, 
    -0.09013789f, -0.18487598f, 0.11848105f, 0.07803378f, 0.02191254f, 0.03613971f, 0.05413141f, -0.03507206f, 
    -0.01943622f, 0.03667033f, 0.01127981f, 0.06848066f, -0.52599394f, 0.16923225f, -0.06244915f, 0.02055940f, 
    0.06679346f, -0.02461547f, 0.14429326f, -0.05838023f, 0.01633858f, 0.09014335f, -0.03607505f, -0.00502762f, 
    -0.19761059f, -0.12852281f, 0.06398521f, -0.09751534f, 0.12398329f, -0.00491745f, -0.00605162f, -0.03680591f, 
    0.02635304f, -0.05536796f, 0.03953862f, 0.08085380f, -0.04362601f, 0.06531093f, -0.10416224f, -0.06386952f, 
    0.01208764f, -0.05559038f, -0.08321930f, -0.04773648f, 0.06269844f, 0.01983685f, 0.10897937f, 0.22801648f, 
    0.19049694f, 0.22414929f, 0.23073299f, 0.46509945f, 0.17331140f, 0.22228801f, 0.07320643f, 0.22805074f, 
    0.16748510f, 0.21392088f, 0.17659578f, 0.40930980f, -0.02603503f, -0.19046722f, -0.39007139f, 0.07379722f, 
    0.00100717f, -0.09087718f, -0.09982721f, 0.08213715f, 0.12162817f, 0.24179150f, 0.18429786f, 0.01169787f, 
    -0.03609592f, -0.17311428f, 0.15176001f, 0.02505482f, 0.00309772f, -0.12753925f, 0.00783772f, 0.06254537f, 
    -0.00406826f, -0.09749310f, 0.15859427f, 0.15550169f, 0.14972505f, 0.01635903f, 0.10962436f, 0.03023203f, 
    -0.09740848f, -0.08831412f, -0.12275553f, -0.02028670f, 0.04781780f, 0.00815381f, 0.08330267f, 0.01137646f, 
    -0.30553055f, 0.05563128f, -0.03343865f, 0.01738057f, -0.07815702f, -0.13842465f, -0.09719099f, -0.00539811f, 
    0.10266153f, -0.01892192f, 0.02665774f, -0.07122560f, -0.08047628f, -0.00541129f, 0.21096301f, 0.04219922f, 
    -0.03164787f, -0.04753238f, -0.01279445f, 0.18199265f, -0.02979076f, 0.09699700f, -0.03597737f, 0.05735782f, 
    -0.12639290f, -0.08851037f, 0.02939848f, 0.01069202f, -0.16037926f, 0.00254462f, -0.07875399f, 0.10985994f, 
    0.16785759f, 0.11664679f, 0.18090959f, 0.04897056f, 0.50489610f, -0.12329368f, -0.00762722f, 0.04260280f, 
    0.02748344f, 0.02890990f, 0.08266492f, 0.02122189f, -0.00558493f, -0.04693499f, 0.06511739f, -0.03778250f, 
    0.09153222f, 0.01616049f, -0.03420736f, 0.04115289f, -0.04491875f, -0.00326148f, -0.05124170f, 0.07178620f, 
    0.03765871f, 0.05914864f, -0.08192354f, -0.08825673f, -0.15721682f, -0.04013736f, -0.14805414f, -0.00922234f, 
    0.14579859f, -0.14620045f, 0.23034035f, 0.00531726f, 0.13666354f, 0.12612650f, -0.07830814f, 0.03217418f, 
    0.23193161f, 0.27581584f, -0.20287704f, 0.13882545f, -0.00327061f, 0.06299996f, 0.04454434f, -0.02038791f, 
    0.15622805f, -0.06956382f, -0.06990951f, -0.15350264f, 0.34810323f, -0.10159187f, -0.12795708f, 0.07548346f, 
    0.06940757f, 0.07391832f, 0.01091428f, 0.00006272f, 0.06643938f, 0.01011661f, 0.05403671f, -0.11258448f, 
    -0.13104744f, -0.09420865f, 0.10494383f, 0.20134629f, -0.08999276f, -0.13353065f, -0.05608060f, -0.13102801f, 
    0.04703726f, 0.10775101f, 0.03830006f, -0.07173584f, -0.31821200f, -0.19755642f, 0.24868838f, 0.24620615f, 
    0.01552966f, 0.05165356f, 0.10171030f, -0.02370629f, -0.00458054f, 0.08482271f, -0.07240888f, -0.01837199f, 
    -0.17507368f, 0.11918228f, 0.11438110f, 0.23279640f, -0.03813063f, -0.02989961f, 0.00019494f, 0.00240473f, 
    0.01886275f, 0.09214553f, 0.11789006f, 0.10106189f, 0.01904603f, 0.02985768f, 0.03840795f, 0.05276477f, 
    -0.00271636f, 0.01261442f, 0.00853791f, -0.05995947f, -0.16139157f, 0.16895142f, -0.16487938f, 0.21272820f, 
    0.13449426f, -0.01591235f, 0.00374282f, 0.06937021f, 0.23828964f, -0.01381633f, 0.11458671f, 0.25444803f, 
    0.04165863f, 0.06314120f, 0.24986906f, 0.06606771f, 0.09710154f, -0.51084131f, -0.05856840f, 0.52950877f, 
    0.01608676f, -0.07163504f, -0.08587804f, 0.09274315f, 0.07571780f, 0.09726242f, 0.15008920f, -0.02302292f, 
    -0.07552324f, -0.03483322f, -0.10544442f, -0.01062197f, 0.02254651f, -0.09121191f, -0.05181631f, 0.07585515f, 
    0.03501347f, 0.06220542f, -0.05458793f, 0.06060791f, -0.13009463f, 0.05872020f, -0.05087660f, -0.04214844f, 
    -0.02131068f, -0.06225747f, 0.14401530f, 0.04692140f, 0.06409013f, -0.04159826f, 0.03524318f, 0.08108100f, 
    0.27546185f, -0.31899828f, 0.23098083f, 0.11416942f, 0.10347654f, 0.08576263f, -0.06759888f, 0.12476224f, 
    0.01377568f, 0.06896833f, 0.14441304f, -0.02312529f, 0.08733320f, 0.09792253f, 0.01007653f, 0.07522572f, 
    -0.07939255f, -0.05935571f, 0.03019687f, 0.03490549f, 0.01979994f, 0.03561737f, 0.05363635f, 0.09224199f, 
    -0.21257746f, -0.18224218f, -0.16176623f, 0.14174838f, 0.01175758f, 0.16176569f, -0.02003919f, -0.07045924f, 
    -0.02882208f, -0.10602655f, 0.04679591f, 0.02677443f, -0.17143101f, 0.11464104f, 0.04094819f, -0.00980891f, 
    -0.06822577f, -0.07679372f, 0.01638692f, -0.03977418f, -0.00036932f, -0.00829518f, -0.03166129f, 0.04896594f, 
    -0.03990059f, -0.14240578f, -0.07888733f, -0.01026139f, -0.04002323f, -0.04954992f, -0.12759702f, -0.00036363f, 
    0.02528883f, 0.01177968f, -0.02407552f, 0.02264385f, 0.52007240f, 0.20641457f, 0.07705197f, 0.44440532f, 
    -0.02396453f, 0.13960339f, -0.22071268f, 0.07076100f, -0.07293795f, 0.03752923f, 0.05227928f, -0.00422707f, 
    -0.10717491f, -0.08887330f, 0.03702204f, -0.01715112f, -0.03737362f, -0.18408185f, -0.07486933f, -0.01620566f, 
    -0.06595453f, -0.01292720f, 0.10044216f, -0.00406016f, -0.20982142f, 0.01696359f, 0.24208993f, -0.23831980f, 
    -0.09914456f, -0.09746508f, -0.07257051f, -0.03013333f, -0.01996316f, -0.04327595f, -0.09120336f, -0.07031733f, 
    0.04456032f, -0.14621042f, -0.16671810f, 0.06124569f, -0.04548481f, 0.07643308f, 0.03366529f, 0.01212658f, 
    -0.01127489f, -0.07916887f, -0.08017109f, 0.00063299f, -0.36848417f, 0.17996907f, -0.08785096f, 0.05051402f, 
    0.14096098f, -0.00948128f, 0.07566289f, 0.00424306f, 0.03163379f, 0.00229346f, -0.01493889f, 0.04225453f, 
    0.00189468f, -0.21214019f, -0.10479645f, 0.05570244f, 0.17572927f, -0.05153781f, 0.01935892f, 0.00819276f, 
    -0.03951425f, 0.05573365f, -0.03342815f, -0.01692214f, -0.09932568f, 0.14973788f, -0.06847152f, -0.12920566f, 
    -0.07814489f, -0.03467432f, -0.11160177f, -0.01888637f, -0.01973180f, 0.04361455f, 0.13591702f, -0.07837513f, 
    0.07091293f, -0.04593537f, -0.14071584f, -0.06003992f, 0.07162770f, -0.05575046f, -0.03056531f, -0.01170175f, 
    0.09038115f, 0.02921413f, -0.04458494f, 0.14017020f, 0.37705243f, -0.09369507f, -0.44645175f, -0.24455146f, 
    -0.02718800f, -0.03596698f, 0.09248892f, -0.00209779f, -0.07300401f, 0.04503769f, 0.00916743f, 0.04332457f, 
    0.03176533f, 0.07496274f, 0.09768402f, 0.28147703f, -0.00202007f, 0.13987470f, -0.06543129f, 0.10039394f, 
    0.21164723f, 0.01445946f, 0.12576590f, 0.06677972f, 0.06889676f, 0.07178472f, 0.06551614f, 0.05049250f, 
    -0.04708574f, -0.07924293f, 0.00637413f, 0.03528257f, -0.16636053f, 0.04229458f, -0.05975055f, -0.04710894f, 
    0.22799407f, 0.10726522f, 0.10473637f, 0.19912560f, -0.01787997f, -0.00361128f, -0.11688596f, 0.03554161f, 
    -0.00191302f, -0.08663889f, -0.01804366f, -0.00749712f, 0.05796330f, -0.02141956f, 0.03646211f, 0.04857882f, 
    0.02881208f, -0.06187291f, -0.06195270f, -0.04075794f, 0.03635276f, 0.03570526f, 0.22464241f, 0.07613837f, 
    -0.09212559f, -0.10114025f, -0.20927924f, -0.09853777f, -0.11644022f, -0.14557837f, 0.02981216f, 0.11096184f, 
    0.00999102f, 0.06770087f, 0.09906680f, 0.02098472f, 0.16928881f, 0.11794271f, 0.08362411f, 0.10383078f, 
    0.08860464f, 0.07064350f, -0.06618045f, 0.06049822f, -0.00832708f, 0.00347545f, -0.00242106f, -0.02743237f, 
    0.05052958f, 0.04334749f, -0.03167272f, -0.06800763f, -0.01540454f, 0.01300286f, -0.03177211f, -0.14808993f, 
    -0.03277971f, -0.11818309f, -0.11603544f, -0.08963373f, -0.46344361f, 0.46706519f, 0.07709654f, -0.34055999f, 
    -0.10327412f, 0.16286637f, 0.13531210f, -0.03122718f, 0.16769421f, 0.11034214f, 0.04988302f, 0.03828864f, 
    0.28941235f, 0.08775636f, -0.02665686f, -0.09246419f, 0.02676107f, -0.06757257f, -0.07992117f, -0.05875859f, 
    0.01800526f, -0.06106522f, 0.09528758f, -0.00773512f, 0.11821848f, 0.01105602f, 0.08092330f, 0.16037238f, 
    -0.06379592f, 0.01601285f, -0.00005615f, 0.01421204f, 0.04417208f, 0.03320090f, 0.07942219f, 0.05426139f, 
    -0.06591847f, -0.09432046f, -0.14455043f, -0.21298940f, -0.16833405f, -0.19782975f, 0.05841559f, -0.17921628f, 
    -0.00394352f, -0.06401270f, -0.11265928f, -0.03508146f, -0.21785486f, -0.14360365f, 0.01275105f, -0.05785916f, 
    0.06723598f, -0.03756871f, -0.03243405f, 0.12901783f, -0.03555689f, -0.05313940f, -0.00352400f, -0.14407556f, 
    -0.27404898f, -0.05061531f, -0.07597694f, -0.05023390f, 0.05560539f, 0.06467818f, 0.09983646f, 0.17044854f, 
    0.00038149f, -0.00486720f, -0.02529543f, 0.13500987f, -0.06795347f, 0.06496397f, 0.04002991f, -0.08296181f, 
    -0.02770058f, 0.10157248f, -0.08393943f, -0.03162960f, 0.11086258f, 0.06110714f, -0.11269782f, -0.11398346f, 
    0.13957977f, -0.03771644f, 0.02634288f, 0.00773160f, -0.05291685f, -0.03222542f, -0.04457492f, 0.13576195f, 
    0.19110945f, 0.21207948f, -0.09775230f, 0.23998247f, -0.04814030f, 0.01719668f, 0.05583225f, 0.48680949f, 
    0.01939677f, -0.01323352f, -0.07423569f, -0.08523084f, -0.09981614f, -0.10504391f, 0.13600223f, -0.29854825f, 
    -0.03154941f, -0.14044900f, -0.10121889f, -0.05107986f, 0.15240964f, 0.01514153f, 0.01319973f, 0.08183654f, 
    0.25129268f, 0.14274727f, 0.24300055f, 0.24468045f, -0.08901197f, 0.26793444f, 0.19968839f, 0.12683995f, 
    -0.12564784f, -0.16252026f, -0.12424354f, -0.06477536f, -0.07590478f, -0.15657982f, -0.17009826f, -0.18381390f, 
    -0.19146290f, 0.40702343f, 0.42721218f, 0.28474271f, -0.10300171f, -0.21165805f, 0.00049058f, -0.07968113f, 
    -0.11729032f, -0.06513337f, 0.09576281f, 0.18245482f, -0.23393543f, 0.00886447f, -0.00273373f, 0.12080824f, 
    -0.14022619f, -0.03323133f, 0.16199215f, 0.06755461f, 0.09919565f, 0.28080648f, 0.16092327f, 0.10278784f, 
    -0.12671106f, -0.14360587f, 0.02850870f, 0.16700816f, -0.18556634f, -0.05737610f, 0.01437369f, -0.08492988f, 
    0.14503685f, 0.03446351f, 0.09738306f, 0.07744913f, 0.11940768f, 0.25562605f, 0.38656551f, 0.01548751f, 
    0.07348453f, -0.06547957f, 0.19602272f, 0.05459534f, -0.08451678f, -0.06158747f, 0.03883178f, 0.02186341f, 
    -0.01854495f, 0.07620453f, -0.04346933f, -0.02163098f, 0.01913168f, -0.06129619f, -0.03080842f, 0.09329508f, 
    -0.36336669f, -0.28228381f, -0.27890557f, -0.34562191f, 0.56160676f, -0.18620495f, 0.05708637f, 0.21766746f, 
    0.13008969f, -0.22571205f, 0.09720249f, -0.21601242f, -0.04534171f, -0.06829258f, 0.08977557f, 0.04890552f, 
    -0.28058952f, 0.21325614f, -0.13612907f, 0.17665826f, 0.34200874f, -0.12462262f, 0.22857456f, -0.07059557f, 
    -0.09123719f, 0.07617341f, -0.02515336f, -0.04132945f, 0.23206383f, -0.06032587f, 0.00111850f, 0.03124140f, 
    -0.13512322f, -0.01593115f, 0.02209496f, 0.00137849f, 0.06158322f, 0.03863261f, 0.00276265f, 0.03523395f, 
    -0.14367393f, -0.17124960f, 0.00990510f, -0.01649460f, -0.13770834f, -0.09174106f, -0.10691339f, -0.21998779f, 
    -0.03957053f, -0.17892630f, -0.08674753f, -0.31010887f, -0.46552601f, 0.01006193f, -0.01289563f, 0.33007154f, 
    -0.02893122f, 0.11110539f, 0.08291158f, -0.07456495f, 0.02500613f, 0.13414814f, -0.00495076f, 0.01059125f, 
    -0.02003173f, -0.13301519f, 0.10039563f, 0.06550055f, -0.05102275f, -0.04436488f, 0.00519056f, -0.04315067f, 
    -0.02965887f, -0.07884264f, -0.00997772f, -0.04637688f, -0.11406132f, 0.08282273f, 0.12947513f, -0.06580737f, 
    0.12210214f, -0.11162852f, 0.10163809f, 0.16728841f, -0.06765117f, 0.17287055f, -0.00889852f, -0.24197099f, 
    0.20032495f, 0.09902943f, -0.16891001f, 0.30699965f, 0.00713843f, 0.08690675f, 0.07366456f, 0.14079905f, 
    -0.01859721f, 0.18811782f, 0.16899700f, 0.12162977f, -0.00929843f, -0.03304200f, -0.46050388f, -0.00327322f, 
    0.18246421f, -0.07818073f, 0.02801448f, 0.08677834f, 0.00207325f, 0.15735951f, 0.14636789f, 0.11209004f, 
    -0.02086765f, 0.13488266f, 0.16635755f, -0.05446601f, -0.02709337f, 0.11392516f, 0.23605749f, 0.12987839f, 
    0.03562858f, 0.11155029f, 0.14811979f, -0.02167086f, -0.21877789f, -0.00748350f, 0.08810879f, 0.03673118f, 
    -0.03725843f, 0.00017139f, -0.10273985f, -0.11347853f, 0.03607524f, -0.03595757f, 0.06991059f, 0.15654530f, 
    -0.19120322f, -0.09397362f, 0.11268194f, -0.07643013f, 0.04873901f, 0.27494511f, -0.02830021f, 0.12219478f, 
    0.07494301f, 0.07162219f, 0.14035378f, 0.11640471f, -0.08578831f, 0.10120650f, 0.16701181f, -0.07216390f, 
    0.10580342f, 0.11679280f, 0.06859806f, 0.08554606f, 0.14999726f, 0.02571429f, 0.16145425f, 0.01760726f, 
    0.16893332f, 0.04252405f, -0.11980572f, -0.13856955f, 0.18124741f, 0.05345928f, 0.05946355f, -0.05356069f, 
    -0.16220078f, -0.21332915f, -0.12200430f, 0.09752142f, -0.24208710f, -0.36334690f, -0.06480283f, 0.12460990f, 
    0.04580071f, 0.19381244f, -0.02702202f, -0.03970996f, 0.01922489f, -0.01385890f, 0.02902897f, 0.04387408f, 
    -0.06356820f, -0.05176611f, 0.00206707f, -0.05343346f, -0.09820568f, -0.05677143f, -0.08294954f, 0.03529231f, 
    0.05792618f, -0.04918969f, -0.06285190f, 0.01217396f, -0.17463659f, -0.18953098f, 0.08252299f, 0.01989689f, 
    -0.14811152f, 0.02103695f, -0.28466943f, 0.13293202f, -0.04593666f, 0.06811804f, 0.06361700f, 0.03973429f, 
    -0.10315429f, -0.44273344f, 0.26338896f, 0.19070365f, 0.03169466f, 0.05945113f, 0.10728710f, -0.01839634f, 
    -0.07459523f, -0.03316590f, -0.01007807f, 0.02596969f, -0.19820540f, -0.03080572f, -0.10039933f, 0.04800469f, 
    0.05402585f, 0.00298197f, 0.06079673f, 0.04770830f, -0.11282071f, -0.11167884f, -0.04534844f, -0.12697013f, 
    0.00167219f, -0.00993131f, -0.17839475f, -0.27551085f, 0.07067055f, -0.02538544f, 0.04685655f, -0.03485848f, 
    -0.01547551f, -0.03362964f, -0.00884169f, 0.09829532f, 0.27467099f, 0.06207345f, -0.23683022f, -0.14920309f, 
    0.16561286f, 0.02975940f, -0.00856051f, -0.15764543f, 0.04676792f, 0.07780779f, 0.01548468f, 0.12191418f, 
    0.16397853f, -0.12170046f, -0.17378400f, -0.25990161f, -0.00284019f, 0.16415821f, -0.01323913f, -0.12273342f, 
    0.00259064f, 0.00619611f, 0.14849618f, -0.11165152f, 0.07150070f, -0.11498767f, -0.01943940f, 0.12381073f, 
    0.04869378f, -0.09720343f, 0.01631052f, 0.01934196f, 0.03983804f, 0.01115352f, 0.09113473f, 0.10322390f, 
    0.01496432f, 0.16575703f, 0.04437303f, -0.11904258f, 0.00874339f, -0.16614266f, 0.11266503f, -0.22481614f, 
    0.04098041f, -0.03667497f, 0.20581178f, 0.02162268f, 0.04596247f, 0.26102278f, 0.44267619f, -0.05895644f, 
    -0.26222253f, -0.00261795f, 0.10404888f, -0.04272237f, 0.05801204f, -0.09582828f, -0.02802908f, 0.08223247f, 
    -0.01816583f, -0.08058297f, -0.08527042f, 0.04203468f, -0.03580925f, -0.06544935f, -0.07537320f, -0.06982069f, 
    -0.00297754f, -0.09072180f, -0.03873399f, -0.01925910f, -0.05698815f, -0.05080878f, -0.02673564f, 0.00286999f, 
    0.03064926f, -0.07544892f, -0.02702384f, -0.00483575f, -0.08982837f, -0.01217957f, 0.03922683f, -0.01318369f, 
    -0.06671701f, -0.09110118f, -0.06053654f, -0.00387502f, 0.00373996f, -0.08769182f, -0.01767203f, 0.05011213f, 
    -0.05758004f, -0.01216089f, -0.06067535f, 0.02427771f, 0.00515570f, 0.01571536f, 0.01800681f, 0.03566208f, 
    -0.07881764f, 0.01807572f, 0.00031482f, 0.00481919f, -0.03459826f, 0.04025457f, -0.02059247f, -0.02081897f, 
    -0.09189911f, -0.09757105f, -0.03339310f, 0.03641337f, 0.03933404f, 0.03342145f, 0.05205588f, 0.02460090f, 
    0.01531518f, 0.03042133f, 0.01627756f, -0.06968422f, 0.00761551f, 0.01443086f, 0.05330035f, -0.02595104f, 
    -0.00362418f, -0.02748493f, -0.07471476f, 0.01568714f, -0.07613344f, -0.02588362f, -0.00178568f, -0.03999376f, 
    -0.01839425f, -0.08028682f, -0.05819893f, -0.06734999f, -0.00766484f, 0.04835519f, 0.02218203f, -0.03287688f, 
    -0.07310960f, -0.09164391f, 0.02893085f, -0.04381666f, -0.06735690f, -0.08185495f, 0.04121290f, 0.03092459f, 
    -0.06070947f, 0.01786041f, -0.03869726f, -0.07601772f, -0.01776919f, 0.02947557f, 0.02935379f, 0.02493853f, 
    0.00680733f, 0.05047679f, -0.03139246f, 0.01161164f, -0.00299105f, 0.05430638f, -0.05016647f, 0.00972007f, 
    -0.02797710f, -0.09483302f, 0.03052552f, 0.03261744f, -0.05184687f, -0.04412613f, -0.03228069f, 0.02844962f, 
    0.01423952f, -0.00047831f, 0.00146158f, -0.09961163f, 0.04070992f, -0.04028366f, -0.04954762f, -0.02819364f, 
    -0.00037518f, 0.01279193f, 0.03120863f, -0.05057203f, -0.07114906f, 0.01407848f, -0.00048537f, 0.02695953f, 
    0.02534319f, -0.01376385f, -0.07044400f, -0.00425767f, -0.04164425f, -0.07723353f, 0.00906783f, 0.00276219f, 
    0.01217750f, 0.04931331f, -0.03504630f, -0.02057109f, -0.04996878f, -0.05875218f, -0.09477752f, -0.05213692f, 
    -0.09117197f, -0.04321793f, 0.00775678f, -0.03480283f, 0.02420952f, -0.04314975f, 0.01591476f, 0.01575962f, 
    0.02396651f, 0.03482007f, -0.05623401f, 0.00542283f, 0.05918433f, -0.02065441f, -0.04723905f, 0.04678405f, 
    -0.10204340f, -0.06317996f, 0.03646025f, 0.03622857f, 0.00754639f, -0.03042905f, -0.04685424f, -0.03802224f, 
    -0.08083945f, -0.07343706f, -0.00884208f, 0.00769933f, -0.02559575f, -0.08466403f, 0.00572805f, -0.02377306f, 
    -0.00332572f, -0.03528934f, -0.05009317f, -0.04581987f, -0.00866908f, 0.04491473f, -0.05969889f, -0.04965026f, 
    -0.02148077f, -0.01344326f, -0.02111074f, 0.02177453f, 0.05045586f, -0.03995313f, 0.01248361f, -0.03447796f, 
    -0.03938260f, -0.05917325f, 0.04363028f, -0.04882941f, -0.02694905f, -0.07411819f, -0.00944895f, 0.01225106f, 
    -0.07688584f, -0.04849850f, -0.03972638f, -0.03694025f, 0.01639363f, 0.01640098f, 0.04973862f, -0.05721095f, 
    0.05843626f, -0.03785559f, 0.00291724f, 0.02075318f, 0.00771366f, -0.02154846f, 0.02090991f, 0.01709129f, 
    0.05636133f, -0.05354404f, 0.02328290f, 0.04885225f, -0.02981205f, -0.03600336f, 0.01982401f, -0.01883950f, 
    -0.03858174f, -0.00852393f, 0.01520419f, 0.03596754f, -0.00055674f, 0.05414287f, -0.00297773f, 0.00210416f, 
    -0.06766961f, -0.05733029f, 0.03077493f, 0.02356337f, -0.01956841f, 0.03005769f, 0.00308687f, -0.02115019f, 
    0.01736433f, 0.01645172f, 0.00636198f, -0.04632221f, -0.02686423f, -0.04721475f, -0.04296112f, -0.07802659f, 
    -0.05235115f, 0.02953830f, 0.01748006f, -0.05514615f, 0.05860262f, -0.06805112f, 0.01631094f, -0.02970472f, 
    0.02111501f, -0.06866414f, 0.05940339f, -0.01270921f, -0.02119599f, -0.03600619f, -0.06284928f, -0.03555699f, 
    0.02671224f, -0.00730721f, 0.00687461f, 0.00842557f, 0.03065250f, 0.00973602f, -0.03481511f, 0.00795043f, 
    -0.06734993f, 0.06029196f, -0.02927635f, -0.07267446f, 0.03338384f, -0.01856038f, -0.06630600f, -0.04872487f, 
    -0.06054284f, -0.04796651f, -0.00150286f, 0.00385223f, 0.01558550f, -0.00114612f, 0.05857621f, 0.03305738f, 
    0.00631209f, -0.00838520f, 0.01737035f, 0.02555980f, 0.03184636f, -0.06539067f, -0.05123315f, -0.06902935f, 
    -0.04430439f, -0.07030647f, 0.05253513f, -0.06259139f, 0.02960936f, -0.04918558f, 0.00714415f, -0.04397472f, 
    0.05407440f, -0.04331468f, 0.00036155f, -0.01606831f, -0.01667734f, -0.02237136f, -0.06302359f, 0.02205796f, 
    0.01927328f, -0.02344198f, -0.04097439f, 0.00686183f, 0.00957825f, -0.00680808f, -0.03892588f, 0.04227183f, 
    0.03873065f, -0.02978501f, 0.00179845f, 0.01956272f, 0.01094344f, -0.02824076f, -0.02107275f, 0.01296404f, 
    -0.01221023f, 0.01794263f, -0.06934111f, 0.03127300f, 0.02589283f, -0.02558175f, -0.07078775f, -0.07816260f, 
    -0.04991352f, 0.04798084f, -0.02171938f, 0.01802392f, -0.05303062f, -0.06074329f, 0.06228270f, -0.07049708f, 
    -0.04052079f, -0.05787982f, -0.02915641f, 0.02442449f, -0.01244101f, 0.01326928f, -0.03356296f, -0.04569422f, 
    0.00334760f, -0.06892321f, -0.04299529f, -0.01155693f, 0.00043963f, -0.04348244f, -0.04797769f, -0.06871380f, 
    0.05416866f, 0.00228740f, -0.00837209f, 0.01338216f, -0.02143342f, 0.06197940f, -0.00575349f, 0.03854365f, 
    0.05142498f, 0.02401925f, -0.02710409f, -0.04491099f, 0.04515869f, 0.05949135f, 0.05937195f, -0.05622788f, 
    -0.01553247f, 0.03736341f, 0.02671895f, -0.00148857f, 0.03101253f, -0.03767648f, 0.03582307f, 0.06473337f, 
    -0.06274014f, 0.21050708f, -0.12241974f, 0.00521893f, -0.02111049f, -0.00332757f, -0.02895474f, 0.02501204f, 
    0.02145360f, 0.01022805f, 0.10827111f, -0.01165687f, -0.22326975f, -0.29388732f, -0.32952437f, -0.01913501f, 
    -0.12659062f, 0.05861183f, 0.05663592f, 0.03407698f, 0.04825453f, -0.00711054f, 0.09277094f, 0.12746432f, 
    0.21575494f, -0.05944410f, -0.27686900f, -0.23026973f, 0.05966891f, -0.02441350f, 0.14195229f, 0.01701380f, 
    -0.04203626f, 0.00305701f, 0.05838314f, 0.03680015f, 0.08062469f, 0.08354417f, -0.03927130f, 0.05504243f, 
    0.02730937f, -0.01686324f, 0.05707625f, -0.02999174f, 0.06121966f, -0.08479030f, 0.01561005f, 0.01802693f, 
    0.28525078f, 0.20281637f, 0.14915910f, -0.03229239f, 0.21072908f, 0.15224366f, 0.01193980f, 0.18013133f, 
    -0.07768960f, -0.16690457f, -0.05747489f, 0.04638465f, -0.12955880f, -0.08842361f, -0.17374307f, -0.07727340f, 
    -0.17723659f, -0.13595000f, -0.09202026f, -0.09611003f, -0.09492479f, 0.10971148f, 0.06900373f, 0.04319476f, 
    -0.10782307f, -0.09813442f, -0.07972337f, -0.05180399f, -0.03745734f, 0.04241640f, -0.08366527f, -0.11191346f, 
    0.08209128f, 0.16495635f, 0.04369773f, 0.04345726f, -0.36652929f, 0.07511645f, 0.20390414f, -0.22250396f, 
    -0.06490049f, -0.02790630f, -0.07535762f, 0.00275990f, 0.14226303f, 0.16626354f, -0.01824470f, 0.12098426f, 
    -0.11428504f, 0.01813215f, -0.13782264f, -0.00578090f, -0.17286195f, -0.15771432f, 0.09363045f, 0.08169109f, 
    -0.17233948f, 0.03681059f, 0.13845493f, 0.01233104f, 0.01890710f, -0.00651177f, 0.05921196f, -0.14524296f, 
    -0.06303191f, -0.17656483f, -0.12859979f, 0.03500220f, -0.13808793f, -0.10037263f, 0.00452492f, -0.04812581f, 
    0.11790849f, 0.22361445f, 0.19129506f, -0.03910623f, 0.09901101f, 0.04573157f, 0.09307919f, 0.17463437f, 
    -0.09381361f, -0.08560391f, -0.13013458f, 0.05244953f, 0.43442783f, 0.08709844f, 0.00944870f, -0.25078660f, 
    -0.07000297f, -0.05962120f, 0.10868709f, 0.02682847f, 0.06325277f, -0.12071444f, 0.01079423f, 0.01998879f, 
    0.06461195f, 0.16137543f, 0.10034619f, -0.07611609f, -0.06212924f, 0.06926234f, 0.12327965f, 0.12687309f, 
    -0.09452356f, 0.03911004f, 0.13532251f, 0.01133274f, -0.08199713f, -0.27945998f, -0.08798293f, -0.04434538f, 
    -0.06552713f, -0.04377704f, -0.03023697f, -0.11103049f, 0.13214931f, -0.04239533f, 0.10165185f, 0.23082036f, 
    -0.04629871f, 0.02709564f, 0.03134269f, 0.12463493f, -0.00975355f, -0.03546084f, 0.06184538f, 0.02856867f, 
    0.19404584f, 0.07515743f, 0.15320599f, -0.02760158f, -0.26472631f, 0.17702149f, 0.21844006f, -0.17952025f, 
    -0.02638548f, -0.00309175f, -0.07799341f, -0.01497409f, 0.13061908f, 0.09871687f, -0.16333003f, 0.06385922f, 
    -0.04254907f, -0.00446172f, -0.09259699f, 0.03610431f, -0.07252404f, -0.07123467f, -0.03081735f, 0.02812787f, 
    -0.10537282f, 0.00175358f, -0.03077734f, -0.06928179f, -0.07963286f, -0.04561346f, 0.00724155f, -0.02614142f, 
    -0.08003350f, -0.06693286f, -0.01288080f, -0.01385159f, -0.07800518f, -0.00295380f, -0.01616291f, -0.08483316f, 
    0.00754548f, 0.01164095f, 0.00826525f, -0.01294718f, -0.09589475f, -0.03462623f, 0.00589768f, 0.02812045f, 
    -0.07212073f, -0.01198791f, -0.07873680f, -0.02997206f, 0.02127954f, 0.00968105f, -0.08187926f, -0.03148130f, 
    -0.08289256f, -0.03075014f, 0.03350820f, 0.02961573f, -0.08574235f, -0.09128182f, 0.02573250f, -0.00265994f, 
    -0.04635050f, 0.04105977f, 0.01811912f, 0.03326812f, -0.04755906f, -0.04753705f, -0.02671986f, 0.00846290f, 
    -0.01641067f, -0.06755991f, -0.07912122f, -0.06599306f, -0.10747637f, -0.07844703f, 0.03264216f, -0.05963003f, 
    -0.07715257f, 0.03741612f, 0.00713405f, -0.11302277f, -0.07529075f, -0.05013806f, 0.00283748f, -0.07879033f, 
    -0.07944186f, -0.06475240f, -0.03858913f, -0.08979479f, -0.01041206f, -0.00515729f, -0.06330569f, -0.07212470f, 
    -0.07035097f, -0.09921893f, -0.03197385f, -0.01895790f, -0.09170052f, 0.01488884f, -0.06833795f, -0.04780791f, 
    0.01260803f, 0.02349771f, 0.01142501f, -0.06136407f, 0.00234005f, 0.02279880f, 0.03714144f, -0.10398345f, 
    0.02412524f, -0.06251081f, -0.03505472f, 0.00203819f, -0.06589620f, -0.05534041f, -0.07282625f, -0.04378004f, 
    -0.07821863f, -0.09353162f, -0.01553638f, -0.06194869f, -0.00110151f, -0.09780496f, -0.02170311f, -0.08263937f, 
    -0.08461674f, -0.05689539f, 0.00821744f, -0.00180036f, -0.04652286f, 0.03412315f, -0.05818013f, -0.08308817f, 
    -0.04721547f, -0.02870177f, -0.01235857f, -0.07142717f, -0.06955810f, -0.07178076f, -0.08267994f, 0.02490395f, 
    -0.08704235f, -0.02923777f, -0.05991113f, -0.03334080f, -0.10670877f, 0.00351604f, -0.04285536f, -0.02663820f, 
    0.01450187f, -0.10340773f, -0.03907739f, -0.06068352f, -0.05407454f, 0.01295112f, -0.04177261f, 0.00822371f, 
    0.01627962f, -0.05201755f, -0.04545998f, -0.05168004f, -0.04568110f, 0.00497792f, 0.01126699f, 0.02953753f, 
    0.01829912f, 0.01495978f, 0.01286450f, -0.01246364f, -0.04488155f, -0.06402227f, -0.00037516f, -0.07696415f, 
    0.03189819f, -0.06969246f, -0.07533997f, -0.08253345f, -0.05212895f, -0.04375801f, 0.01070318f, -0.05725231f, 
    -0.08494467f, -0.04538240f, -0.07714496f, -0.02496490f, -0.08865853f, -0.00668023f, -0.00314831f, -0.10188618f, 
    -0.03408695f, -0.08762019f, -0.09884284f, -0.01182757f, -0.07013310f, 0.02151821f, -0.00550258f, -0.02870144f, 
    -0.05853360f, 0.01484485f, -0.11014660f, 0.01503746f, 0.03097651f, 0.05324670f, 0.00322550f, 0.01981262f, 
    0.05924541f, -0.04382315f, -0.05033405f, -0.08029069f, 0.02026825f, -0.08066736f, -0.05336024f, 0.01026063f, 
    -0.04934623f, -0.01713412f, 0.05673685f, -0.00632708f, 0.05263318f, -0.04024491f, -0.04807868f, 0.00009266f, 
    0.04167683f, -0.04372465f, -0.06501106f, -0.04734641f, -0.05507303f, -0.04801045f, -0.00823087f, 0.02390245f, 
    0.04803723f, -0.05020451f, -0.07300001f, -0.08018700f, 0.01639642f, -0.01507301f, 0.04437958f, -0.00845324f, 
    0.00559010f, -0.05711308f, -0.02113820f, 0.03241371f, -0.06137242f, 0.00988354f, -0.06441071f, 0.03023751f, 
    -0.01722419f, 0.05837515f, 0.02494101f, 0.02323736f, -0.02804169f, 0.03594610f, 0.04237799f, -0.00672573f, 
    0.04140650f, 0.02627708f, 0.02828907f, -0.02139705f, -0.05845134f, 0.05422737f, -0.05202028f, -0.02232545f, 
    0.03151990f, 0.02650692f, 0.02104596f, -0.01640770f, 0.00013504f, -0.07049196f, 0.00223171f, 0.02866015f, 
    -0.05119072f, -0.08117088f, -0.02649259f, -0.08332255f, 0.00487276f, 0.05856269f, -0.03821208f, 0.05422845f, 
    0.05149053f, -0.00061434f, 0.00400728f, -0.04422689f, 0.01128811f, 0.00681928f, -0.00361008f, -0.03761552f, 
    0.05436589f, -0.00481686f, 0.04923067f, 0.00882224f, 0.03261425f, -0.06923551f, 0.02463445f, 0.05081547f, 
    -0.01961271f, 0.02214569f, -0.07458973f, 0.04029548f, -0.07507092f, -0.04388645f, -0.07821455f, -0.05297964f, 
    -0.06657521f, 0.01448553f, -0.00358845f, 0.03181578f, -0.02269947f, 0.04722686f, -0.05936873f, 0.01657973f, 
    0.03242173f, -0.04872696f, -0.04142428f, 0.02917529f, 0.04136911f, 0.06133696f, -0.06454668f, -0.05758628f, 
    -0.00952858f, -0.02349867f, 0.02100872f, -0.04038255f, -0.03010390f, 0.03366134f, 0.02440215f, -0.02171271f, 
    0.03063442f, 0.03416341f, -0.04002837f, -0.01455254f, -0.02089494f, -0.02019773f, 0.00234167f, 0.04827105f, 
    0.03862237f, 0.05178128f, -0.01702892f, -0.02092281f, -0.07518553f, 0.05696106f, 0.04071049f, 0.04608206f, 
    -0.04913153f, 0.04385593f, -0.00191179f, -0.03724436f, -0.03825640f, 0.00433442f, 0.03842340f, -0.07726750f, 
    0.00669340f, 0.01296641f, 0.02201875f, -0.05180496f, -0.04583885f, -0.03537581f, -0.08286126f, -0.06766886f, 
    0.03913855f, -0.07503426f, -0.07254664f, 0.02798693f, -0.02335252f, -0.03273373f, 0.05641253f, -0.03705199f, 
    -0.03994979f, -0.04868390f, 0.01651594f, -0.06291182f, -0.05613651f, -0.04657081f, 0.04711850f, -0.07909700f, 
    -0.05508083f, 0.05286651f, -0.04316226f, -0.05457211f, -0.02345273f, -0.03588306f, -0.02836593f, 0.01848447f, 
    0.02033599f, -0.07931440f, -0.03081186f, 0.06076785f, -0.06177122f, 0.03827791f, -0.01350859f, -0.04005566f, 
    -0.05958109f, -0.07085662f, -0.04500765f, -0.04137786f, -0.05217814f, -0.01214094f, -0.00027761f, -0.03885157f, 
    -0.00546858f, -0.00831969f, 0.03644791f, 0.03941742f, -0.03895833f, -0.07026628f, -0.06081408f, 0.05597215f, 
    -0.07744716f, 0.05601668f, 0.03138039f, -0.02385673f, -0.00216362f, -0.02132996f, -0.01533118f, 0.04385436f, 
    0.02186868f, -0.01837352f, -0.00953335f, -0.02102539f, -0.04513883f, 0.02191020f, 0.02319134f, 0.00746491f, 
    -0.06417854f, 0.03653902f, -0.05637303f, 0.00909730f, 0.03711402f, -0.04402647f, 0.03629174f, -0.04277079f, 
    0.00612524f, -0.07079595f, 0.01194574f, -0.04082313f, -0.05107419f, -0.04052278f, 0.04346392f, 0.01586939f, 
    -0.01125777f, 0.03237865f, 0.01597175f, -0.03339961f, -0.08021942f, 0.01476020f, -0.02900209f, -0.07136147f, 
    -0.04221990f, 0.05495358f, -0.02903025f, -0.03320013f, -0.03425905f, -0.01105350f, 0.02719824f, -0.07908805f, 
    0.00705655f, -0.02061843f, -0.06098283f, -0.00097295f, 0.00895271f, -0.06766620f, 0.01746770f, 0.02006121f, 
    -0.07770569f, 0.03790499f, -0.07068992f, 0.00743239f, -0.01442953f, -0.04442468f, 0.04775854f, -0.01378604f, 
    -0.00609726f, 0.03879914f, -0.04752184f, 0.05574122f, -0.07186648f, 0.02512819f, -0.00493099f, -0.02217803f, 
    -0.05568980f, 0.01193379f, -0.05493649f, 0.00608142f, 0.03303115f, -0.01697371f, 0.05748660f, -0.05061855f, 
    0.04396325f, -0.07493072f, -0.06961606f, 0.05876423f, 0.01533222f, 0.00937921f, 0.00561297f, -0.05245343f, 
    -0.02509014f, -0.00649609f, 0.02471146f, -0.00573541f, -0.03201595f, -0.01931084f, -0.00215505f, 0.01308934f, 
    0.05824974f, -0.01457014f, 0.01228722f, 0.03667267f, -0.02717938f, -0.00654418f, 0.01755262f, -0.00456811f, 
    0.01688586f, -0.00559719f, -0.05321948f, 0.04624229f, 0.00654534f, 0.05213964f, -0.02841117f, 0.03894449f, 
    -0.02967584f, -0.01297394f, 0.06033229f, -0.04548304f, -0.03333296f, -0.06673162f, -0.01077048f, -0.02938685f, 
    -0.07058129f, 0.02597669f, -0.06642234f, 0.02709502f, 0.05232519f, 0.02574467f, -0.04814665f, 0.00102933f, 
    -0.02825406f, 0.05834134f, 0.01603315f, -0.07956696f, 0.05617122f, -0.07752296f, -0.04754940f, 0.00487302f, 
    0.05696500f, -0.03234069f, -0.04773436f, -0.07634178f, 0.01066825f, -0.07070053f, 0.05194778f, -0.06207949f, 
    -0.03227563f, -0.04665402f, -0.02871171f, -0.00572665f, -0.00687163f, 0.05841067f, -0.03835016f, -0.01472239f, 
    -0.07450680f, -0.07770971f, 0.00147238f, -0.01506529f, 0.03638647f, -0.05475829f, 0.00308248f, -0.00306315f, 
    0.02972600f, -0.02198944f, -0.03556904f, -0.07992748f, 0.04019158f, -0.06142990f, 0.03763911f, -0.07374824f, 
    0.04072003f, -0.07397145f, -0.01748789f, 0.01163794f, -0.04255798f, -0.06448866f, -0.03500651f, -0.06057539f, 
    0.05935934f, 0.00523665f, -0.02008813f, 0.04702951f, -0.05357412f, 0.00174639f, -0.02413480f, 0.03343187f, 
    0.06668341f, -0.16020890f, 0.18832013f, 0.09644680f, -0.05257394f, 0.20954143f, 0.19145671f, 0.02478568f, 
    -0.02452979f, 0.01044704f, 0.17323120f, 0.09892012f, 0.14801937f, -0.18967500f, -0.13422477f, -0.21842390f, 
    -0.10470340f, -0.15075870f, -0.15338130f, -0.10812483f, 0.05354963f, 0.06802801f, 0.07352005f, -0.04716671f, 
    0.01363588f, -0.22783196f, -0.14781503f, -0.15721114f, -0.08946140f, 0.14608230f, -0.04526470f, 0.34119284f, 
    0.22090879f, -0.05556612f, -0.07622851f, 0.05822387f, 0.32541430f, -0.02227155f, 0.15055886f, -0.11748543f, 
    0.05739283f, -0.07467115f, -0.15490247f, 0.29765123f, 0.03571711f, -0.06950257f, 0.01477314f, 0.05492277f, 
    0.19359002f, 0.01702835f, 0.02421920f, -0.06821501f, 0.13981241f, 0.05260136f, 0.10144660f, 0.05171569f, 
    -0.04471944f, -0.10404357f, -0.13983792f, -0.12996848f, -0.23028539f, -0.29111731f, -0.00927021f, -0.00201705f, 
    0.13702813f, 0.12139145f, -0.15131445f, 0.25467813f, -0.10361312f, -0.15761931f, -0.05549644f, -0.05088080f, 
    -0.15057890f, -0.12121544f, -0.00433062f, 0.02879740f, 0.02748416f, -0.03504096f, -0.24248065f, -0.10581634f, 
    0.12690525f, -0.03421114f, -0.11216240f, 0.10599089f, -0.32615244f, 0.06207257f, -0.10356813f, -0.03804966f, 
    -0.18282583f, 0.27452177f, -0.01558249f, 0.15867999f, 0.11912860f, 0.01533210f, -0.03378586f, 0.09911780f, 
    0.16299836f, 0.17141202f, 0.05530528f, -0.33072105f, -0.22439949f, -0.01368874f, -0.15112711f, 0.04587909f, 
    -0.00266213f, 0.03955310f, -0.14133488f, -0.08825169f, -0.09885889f, -0.23899406f, 0.06457359f, 0.14644961f, 
    0.01222387f, 0.11765090f, 0.05809711f, -0.10207900f, 0.08261374f, -0.21450374f, 0.12040924f, -0.08390523f, 
    0.07657006f, 0.05852416f, -0.05669072f, -0.05616489f, 0.21030742f, 0.09209339f, 0.05847668f, 0.06205167f, 
    -0.08768921f, -0.11048214f, 0.05979688f, 0.23905392f, 0.38356021f, -0.04349872f, 0.19050981f, -0.33978942f, 
    0.08764648f, -0.03564929f, 0.04891802f, 0.13895451f, 0.02833053f, 0.02806960f, -0.01578597f, -0.00423768f, 
    0.11195061f, 0.20702653f, -0.18032345f, -0.01255339f, 0.00111551f, 0.16702712f, 0.17061844f, 0.01144051f, 
    0.02983955f, -0.09667714f, -0.06848324f, 0.00465521f, 0.25385413f, -0.20707904f, -0.00959193f, 0.04147903f, 
    -0.21251197f, 0.19340116f, -0.09282619f, 0.00392771f, 0.06630789f, 0.05713295f, 0.10047793f, -0.00370619f, 
    0.01881719f, -0.02167265f, 0.18360737f, -0.07870013f, 0.07198689f, -0.26009110f, 0.00670970f, 0.10833348f, 
    -0.07270907f, -0.11080810f, 0.08580431f, 0.08948267f, 0.37028873f, -0.07067966f, 0.46653897f, 0.26650503f, 
    0.00075849f, 0.03795556f, -0.15311691f, -0.11974501f, 0.08868738f, -0.06596975f, 0.12791836f, -0.24648474f, 
    0.05156984f, -0.02104543f, 0.02847113f, -0.10694379f, -0.03042201f, -0.03948278f, 0.10444522f, 0.05273745f, 
    -0.07748602f, -0.15572776f, -0.02050439f, 0.02578949f, -0.13595162f, -0.03715052f, 0.17252818f, 0.03138787f, 
    -0.13026796f, -0.00445291f, -0.04131840f, -0.07435130f, 0.12120023f, 0.08939292f, 0.23774520f, 0.11222877f, 
    -0.13952641f, -0.45500016f, -0.04868560f, -0.05880349f, 0.02063605f, 0.07807473f, -0.12556997f, 0.10100389f, 
    0.26878205f, -0.03887972f, 0.02435042f, -0.08152579f, 0.02896131f, 0.01618191f, 0.18735628f, -0.04079036f, 
    0.05127233f, 0.04937044f, -0.08641692f, 0.06051436f, -0.04220906f, -0.05831739f, -0.00533727f, -0.04568415f, 
    -0.13142234f, -0.08256110f, -0.14109458f, 0.02412667f, -0.03805212f, 0.03264732f, -0.03579228f, 0.08279202f, 
    0.03126626f, 0.04942172f, -0.01629914f, -0.09192710f, -0.08587986f, -0.03413253f, -0.07957339f, 0.20713487f, 
    0.05980640f, 0.12916443f, -0.09719117f, -0.05148784f, -0.04414454f, 0.03597263f, -0.06447761f, -0.01597039f, 
    -0.12488520f, -0.05935114f, -0.14502905f, -0.16608952f, -0.04673160f, -0.02002600f, -0.04480406f, -0.09213182f, 
    0.14138068f, 0.06081125f, 0.11729729f, 0.06270872f, 0.25176650f, 0.12735686f, -0.03492982f, 0.37014532f, 
    0.04339418f, 0.12926319f, -0.11655331f, 0.09957607f, 0.00367920f, 0.15470795f, 0.05221402f, 0.02351082f, 
    0.04962125f, -0.19294418f, 0.33428508f, -0.11332566f, -0.12792350f, 0.13455747f, -0.31846499f, -0.05449199f, 
    0.10422161f, -0.12174619f, -0.00840321f, -0.09875251f, -0.11626843f, -0.02732225f, -0.03423971f, -0.18106283f, 
    0.01082257f, -0.01000347f, -0.02933600f, -0.13437454f, -0.01226872f, -0.10421320f, -0.08998565f, -0.08799934f, 
    -0.05501255f, -0.16733317f, -0.16261427f, 0.07776042f, 0.06465326f, -0.04311583f, 0.09033839f, 0.19132039f, 
    0.03777144f, 0.18785764f, 0.00905873f, 0.13383722f, -0.09085263f, 0.18930589f, -0.09711241f, 0.07874547f, 
    0.13554491f, 0.11967739f, 0.06725699f, 0.04343534f, 0.07178491f, -0.01500428f, 0.10821809f, 0.02881335f, 
    0.02718716f, -0.06130194f, -0.05517568f, 0.07073172f, 0.11754309f, 0.05138470f, 0.10270236f, 0.06331928f, 
    0.08630276f, 0.03182803f, 0.08036689f, 0.02607162f, 0.12123533f, -0.08031754f, -0.08973922f, -0.02469743f, 
    -0.04658232f, -0.09851263f, -0.10408588f, -0.08928184f, 0.04215751f, 0.13790673f, 0.13243105f, 0.14617532f, 
    0.12457941f, 0.11466189f, 0.03757225f, -0.06196357f, 0.20986560f, -0.05593388f, 0.19132894f, -0.06099755f, 
    0.07153553f, 0.07310814f, -0.04251656f, 0.23126249f, 0.65273213f, -0.32125935f, -0.03757062f, -0.08149923f, 
    0.13298228f, -0.15920320f, -0.07302941f, -0.10528720f, 0.05266909f, 0.10202459f, -0.00521570f, 0.12640063f, 
    -0.10434318f, 0.23809090f, 0.04822116f, -0.08095422f, 0.05193642f, -0.01887433f, -0.12227222f, 0.13746394f, 
    -0.06263331f, -0.01909106f, -0.15267138f, -0.09921327f, 0.16073015f, 0.27429086f, 0.34761176f, -0.11161252f, 
    -0.03891373f, -0.10552089f, -0.03609727f, -0.06895501f, 0.20795645f, 0.05401387f, 0.09628260f, 0.09932458f, 
    0.15572822f, -0.08059505f, 0.38555884f, 0.01783543f, 0.00100203f, -0.21930057f, -0.17072102f, 0.12466107f, 
    -0.04491184f, 0.05125546f, -0.01618512f, -0.11022139f, -0.24285932f, 0.17466033f, 0.26367205f, 0.04479732f, 
    -0.06441386f, 0.08710327f, -0.13766022f, 0.07718844f, -0.00490000f, -0.00844092f, -0.15227626f, -0.01930037f, 
    -0.40098777f, 0.00199475f, -0.03769631f, 0.19247401f, -0.09558059f, 0.19959325f, -0.05831315f, -0.04923456f, 
    0.09300507f, 0.03904136f, 0.02899113f, -0.03535575f, -0.01067788f, -0.25013021f, -0.14739403f, 0.08861506f, 
    -0.03671051f, -0.00282118f, 0.09494421f, -0.12617023f, 0.14312485f, 0.00300953f, -0.03842581f, 0.04525944f, 
    -0.00662458f, 0.00264144f, -0.02216417f, -0.02632154f, -0.20404473f, -0.07228475f, 0.07424967f, -0.01359329f, 
    0.09957062f, 0.17842194f, 0.16077562f, -0.11429249f, 0.25235221f, 0.22240369f, -0.07969522f, 0.36689296f, 
    -0.01858178f, -0.03161007f, 0.00323386f, 0.14364749f, 0.10564060f, -0.00011029f, -0.08282051f, -0.00636952f, 
    0.26501763f, -0.22530445f, 0.32782584f, 0.12188809f, -0.03560854f, 0.13216290f, 0.04646370f, 0.03300859f, 
    0.11244861f, -0.00815343f, -0.16900125f, -0.11185499f, -0.15176733f, 0.02286901f, -0.36510351f, -0.09422264f, 
    -0.19063485f, -0.15401673f, 0.00379709f, -0.16389744f, 0.00229433f, 0.11293801f, -0.13100387f, -0.00119771f, 
    -0.20362124f, -0.10335948f, 0.11343765f, 0.14247388f, 0.00015929f, 0.12160688f, 0.09301210f, 0.12755112f, 
    0.03959811f, 0.08712275f, 0.08283275f, 0.09282739f, -0.44854537f, -0.04448225f, -0.27466705f, 0.18950875f, 
    0.24325497f, 0.21133909f, 0.04962667f, 0.10608333f, -0.12006923f, 0.01969934f, -0.02441362f, 0.00908316f, 
    -0.12292170f, -0.23866631f, 0.15348868f, 0.04479526f, 0.06987554f, -0.11797996f, 0.00243228f, -0.00531799f, 
    -0.00941188f, 0.02430151f, -0.01945347f, 0.16932964f, -0.10849096f, 0.15131846f, 0.04976240f, -0.16120614f, 
    -0.13641417f, 0.15705365f, -0.04823092f, -0.15849020f, 0.16710567f, 0.00702271f, -0.12369537f, 0.13886273f, 
    0.00706608f, 0.16119602f, 0.42224327f, -0.08073588f, 0.05110103f, -0.02984725f, 0.05702417f, 0.01317860f, 
    0.19646338f, 0.03976518f, 0.11276618f, 0.13368958f, -0.45701513f, 0.00879363f, 0.05476478f, 0.27760366f, 
    -0.30892673f, -0.01951099f, -0.09366195f, 0.00540153f, 0.04040915f, 0.00832580f, 0.05530283f, 0.07350821f, 
    0.16719073f, -0.11760265f, -0.22308318f, -0.25340629f, -0.11379964f, 0.10315119f, 0.00452420f, -0.03533567f, 
    0.20102841f, 0.05621463f, 0.02370645f, 0.01598891f, -0.02139949f, 0.02334610f, -0.04340366f, 0.03922351f, 
    -0.03889036f, -0.21721004f, 0.00055861f, -0.06632376f, 0.07090074f, -0.00706439f, -0.06317767f, -0.02894729f, 
    -0.10052910f, -0.25448394f, -0.29956391f, -0.34269634f, -0.16876398f, -0.20647685f, 0.10321873f, -0.01947594f, 
    -0.16747656f, -0.05669332f, 0.05100837f, 0.07626525f, -0.05030024f, 0.31713125f, -0.15626723f, -0.22991213f, 
    -0.10160855f, -0.11801100f, -0.09784613f, 0.00942062f, 0.06335351f, 0.11028255f, 0.05377591f, 0.04331305f, 
    0.00759344f, -0.24750130f, -0.25006962f, -0.07442989f, -0.06994639f, 0.17752759f, -0.12207222f, 0.07276800f, 
    -0.00841711f, 0.06249851f, 0.10264133f, 0.05909888f, 0.33843616f, 0.05650471f, 0.15162018f, 0.06655844f, 
    -0.02369452f, -0.05434355f, 0.08397182f, -0.03893047f, -0.00485740f, 0.03198171f, 0.03044228f, 0.09701277f, 
    0.10282146f, -0.00072441f, 0.00450714f, 0.09616216f, 0.03876497f, -0.00924619f, -0.06943480f, -0.01728041f, 
    -0.09494206f, -0.05604866f, -0.14219974f, -0.11129752f, -0.34595910f, -0.30977696f, -0.02169527f, -0.17633916f, 
    0.03778121f, -0.11652481f, -0.03242654f, -0.02825769f, 0.05537583f, 0.10940247f, 0.00990987f, -0.03869884f, 
    0.25420970f, 0.22198141f, -0.03773891f, 0.36263424f, 0.15448561f, 0.11275996f, 0.05876858f, 0.03301072f, 
    -0.00314721f, -0.09124905f, 0.12668113f, -0.08528472f, 0.39887887f, 0.16871610f, 0.21314377f, 0.13619757f, 
    -0.05575256f, 0.08404147f, 0.01230107f, 0.00274944f, -0.00616331f, 0.05195674f, 0.04233682f, 0.02584110f, 
    -0.15883070f, -0.26665014f, -0.19720387f, -0.34534302f, 0.18295115f, -0.00061174f, -0.06585454f, -0.17884932f, 
    -0.05233604f, -0.17306611f, -0.15942138f, -0.06787661f, -0.45067665f, -0.26787320f, 0.05345183f, 0.09248190f, 
    0.08895057f, 0.33305302f, 0.04576701f, 0.14644063f, 0.11091629f, 0.05608021f, -0.03728501f, -0.13214630f, 
    -0.20817515f, -0.24855205f, 0.03675322f, 0.09365688f, -0.03213440f, -0.23196681f, -0.04818363f, -0.03570110f, 
    -0.15270665f, 0.00580487f, 0.24586278f, -0.05472640f, 0.12913282f, 0.27721336f, 0.16042159f, 0.05734982f, 
    -0.07436422f, -0.04671914f, 0.07853302f, -0.05624659f, 0.08788785f, 0.07647314f, 0.02018273f, 0.04386462f, 
    -0.13910112f, 0.03644667f, -0.04510792f, 0.06198925f, 0.05784468f, 0.00513710f, 0.07601170f, -0.03559239f, 
    0.25195593f, 0.19261137f, 0.18159437f, 0.08374661f, 0.28338373f, 0.26658916f, 0.11417914f, -0.15273663f, 
    -0.23584490f, 0.13528170f, -0.18877476f, -0.05846926f, 0.10502609f, 0.06712695f, 0.08560146f, 0.01324153f, 
    0.14895858f, -0.13965343f, -0.09798363f, 0.08944672f, 0.00722852f, 0.20601375f, -0.23248926f, -0.12839735f, 
    0.16945526f, -0.05821049f, -0.06061125f, -0.01170767f, 0.17654683f, 0.03747810f, 0.06525425f, 0.06150743f, 
    -0.11312766f, -0.14935754f, 0.03438679f, -0.00688726f, 0.14923173f, 0.14225557f, -0.05799097f, 0.00832057f, 
    0.21971336f, -0.10890006f, -0.25460559f, -0.09901366f, -0.06884439f, -0.08877844f, 0.00453262f, 0.06788651f, 
    -0.04554744f, -0.16174941f, 0.01424443f, 0.02009653f, 0.19287817f, -0.38955918f, -0.05801165f, -0.07023177f, 
    -0.03750282f, -0.01762450f, -0.09948537f, -0.09358102f, -0.00092419f, -0.09759905f, -0.11056476f, 0.02025667f, 
    -0.18884972f, 0.04951285f, -0.13657601f, -0.18487664f, 0.02681038f, 0.07556841f, -0.01537331f, 0.07434811f, 
    -0.06044110f, -0.06238052f, 0.02278354f, -0.12165560f, 0.29282004f, 0.07278018f, 0.28955036f, 0.32669404f, 
    0.05344713f, 0.07469992f, -0.00127932f, 0.07123347f, 0.03028975f, -0.06468300f, 0.07161258f, 0.11776921f, 
    0.14445584f, 0.15171228f, 0.04079861f, 0.14889875f, 0.06434270f, 0.01066550f, -0.01962124f, 0.02575400f, 
    -0.07369087f, -0.12224440f, -0.06053850f, -0.08423270f, -0.46312845f, 0.36186928f, -0.41435379f, -0.32966515f, 
    -0.11882606f, -0.04461047f, 0.19064181f, -0.08484054f, 0.10628772f, -0.23531367f, -0.07023074f, 0.06242766f, 
    0.46315372f, 0.04246913f, 0.25553954f, 0.13985626f, 0.03055519f, 0.00771938f, -0.11044156f, 0.07301015f, 
    0.00995783f, -0.05753994f, -0.01382831f, -0.01139670f, 0.12986878f, 0.17937784f, 0.02991626f, 0.18841718f, 
    -0.07676365f, 0.00360193f, 0.05411388f, -0.05515173f, 0.03840249f, 0.07193025f, 0.13558905f, 0.15214214f, 
    -0.13531841f, -0.14705192f, -0.33332482f, -0.25391081f, 0.13736597f, 0.19899479f, 0.07582732f, 0.12735602f, 
    -0.10958463f, -0.02322717f, -0.05127630f, 0.04850062f, 0.22844017f, -0.09730834f, -0.14238870f, -0.34694228f, 
    -0.05438630f, 0.13869111f, -0.12323441f, 0.17007510f, 0.07326330f, 0.10255204f, -0.07676886f, -0.10614207f, 
    -0.12038635f, -0.16393428f, -0.23745224f, 0.11201681f, 0.07869846f, -0.02033590f, 0.09228713f, 0.22151713f, 
    0.00298640f, -0.08763485f, -0.21821029f, -0.04599158f, 0.13526540f, 0.19112939f, 0.10944707f, -0.16286242f, 
    -0.06694660f, 0.09999280f, 0.08442610f, 0.00462562f, 0.22305389f, 0.08278281f, 0.07309684f, -0.01530853f, 
    0.02092106f, -0.13749340f, 0.08432807f, -0.50296831f, 0.09570420f, -0.10321785f, -0.08623975f, -0.04082774f, 
    0.22382523f, 0.14569092f, -0.25658593f, 0.09730672f, -0.18813740f, 0.34204602f, 0.31962955f, 0.07367902f, 
    -0.00379812f, 0.25332952f, 0.01829668f, -0.06360135f, -0.03840681f, -0.13661253f, 0.21165755f, 0.09989337f, 
    0.07031281f, 0.02227370f, 0.09080113f, 0.05155601f, 0.06214119f, -0.02060405f, -0.04228433f, 0.04859775f, 
    0.16148567f, -0.12862746f, 0.10062698f, 0.01032289f, 0.03479301f, -0.11657330f, 0.16353007f, -0.07681585f, 
    -0.10930241f, -0.04701065f, -0.16951647f, -0.08331406f, 0.18690695f, 0.11920179f, 0.14677802f, 0.13474289f, 
    -0.15107530f, 0.04052156f, -0.05221722f, -0.12205905f, -0.07224037f, 0.05156311f, -0.11967416f, 0.16198033f, 
    0.10955837f, -0.17152606f, 0.03909459f, -0.10000819f, 0.01942993f, 0.02770141f, 0.18407585f, -0.02118813f, 
    -0.07497333f, -0.04451736f, -0.09176207f, 0.05041549f, 0.04305844f, -0.11449792f, 0.02773244f, -0.13047497f, 
    0.02786090f, 0.01400312f, -0.01401464f, -0.15464495f, -0.02546309f, 0.00524322f, -0.07429556f, 0.08630447f, 
    0.05641616f, -0.06443335f, -0.08049812f, -0.12496875f, 0.34275255f, -0.26591855f, -0.20502278f, -0.01683784f, 
    0.11934293f, 0.08614441f, -0.06029200f, -0.03261987f, -0.04262015f, 0.01217953f, -0.09377656f, -0.08131525f, 
    -0.06883276f, -0.03102267f, -0.12103773f, -0.01137541f, 0.04377508f, 0.04055380f, -0.03104527f, -0.01830915f, 
    0.09608077f, 0.11706394f, 0.14901276f, 0.08269939f, -0.73613644f, 0.09991547f, -0.17446658f, -0.02465916f, 
    0.06979454f, 0.01784879f, 0.06534718f, 0.07805590f, 0.06102123f, 0.14056572f, 0.08759866f, 0.02457567f, 
    0.41862673f, -0.10980252f, 0.14492832f, -0.24906333f, -0.05900791f, 0.03255541f, -0.04817816f, -0.03674388f, 
    0.07216956f, -0.03640576f, -0.06361383f, -0.13486473f, 0.11532789f, 0.04932097f, -0.30376032f, -0.00655020f, 
    0.11763664f, 0.06366248f, -0.04861511f, -0.04776322f, 0.04869122f, -0.14020935f, 0.04745512f, -0.16640356f, 
    -0.14557876f, -0.00930175f, -0.02502411f, -0.00571423f, 0.04310896f, -0.02012515f, 0.11473401f, 0.05499610f, 
    -0.07404086f, 0.06058460f, -0.04232090f, -0.01927503f, 0.03989281f, -0.25336123f, 0.24395272f, -0.11540908f, 
    0.13087550f, 0.04688660f, 0.12996823f, 0.03294399f, 0.09151928f, 0.01512046f, -0.02459584f, 0.06152994f, 
    -0.19246958f, 0.07009818f, -0.00826843f, -0.15322100f, -0.01802542f, 0.00531557f, 0.06334997f, 0.13715093f, 
    -0.03056334f, 0.10949276f, -0.00457938f, -0.00210605f, 0.12823352f, -0.02193389f, 0.04599905f, 0.11853877f, 
    -0.01699508f, -0.14218752f, -0.06874074f, -0.14176053f, 0.14902547f, 0.13848606f, -0.01654584f, 0.27958348f, 
    0.07708216f, 0.10418142f, 0.16518658f, 0.16432948f, 0.20781179f, 0.18024172f, 0.05241420f, 0.18271577f, 
    0.32242540f, 0.19399039f, 0.11389185f, 0.18058047f, 0.12953049f, -0.27275780f, 0.06580902f, 0.49245363f, 
    -0.01424010f, -0.05588467f, -0.11090144f, 0.04594960f, 0.29753596f, 0.16393916f, 0.16890922f, 0.12407687f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05048937f, 0.02599399f, -0.08684339f, -0.07857258f, -0.08006301f, 0.04267740f, 0.09236651f, -0.03518045f, 
    -0.02554787f, 0.02558072f, 0.12882689f, -0.08283488f, -0.07329186f, -0.16180275f, 0.14960104f, -0.00848281f, 
    0.01459328f, 0.05198530f, 0.10783738f, 0.08570348f, -0.01183560f, 0.18646342f, -0.10397663f, 0.04857666f, 
    0.15796751f, -0.06642728f, -0.11475424f, -0.00418805f, 0.06350669f, 0.02255311f, 0.11996435f, 0.14473893f, 
    -0.09614999f, -0.00994499f, -0.12059126f, 0.10316490f, -0.03938856f, 0.09895335f, 0.10892656f, 0.16421829f, 
    0.14184144f, 0.00522241f, -0.02264711f, 0.03311330f, 0.06644392f, -0.00971899f, 0.09709691f, 0.05481141f, 
    -0.07579100f, 0.23585102f, -0.07205524f, -0.03967696f, 0.03997428f, -0.09474252f, -0.10984226f, -0.07326017f, 
    0.08863921f, 0.03239769f, 0.19900329f, -0.16571867f, -0.07887299f, 0.11168889f, -0.02747948f, 0.01336262f, 
    -0.01216943f, -0.01075857f, 0.07878951f, 0.14580332f, -0.04812303f, -0.03125633f, 0.16330710f, -0.05022867f, 
    -0.20624919f, -0.03323007f, 0.07296896f, -0.11374430f, 0.00465364f, -0.00989988f, -0.01289889f, 0.13496470f, 
    -0.02749152f, 0.20818621f, -0.05187383f, -0.06394503f, 0.14870054f, -0.04029086f, 0.05531815f, -0.13144600f, 
    0.05879573f, 0.05325378f, 0.02394421f, 0.21099266f, 0.00446133f, -0.00701251f, 0.12014427f, 0.02294024f, 
    0.04669894f, 0.06508690f, 0.16347642f, 0.09001789f, 0.04208349f, 0.08956864f, -0.12690033f, -0.00028046f, 
    -0.11230037f, -0.15992296f, -0.04578587f, 0.11103625f, -0.04518089f, 0.17890252f, 0.20227385f, 0.21046910f, 
    0.06771445f, 0.18263575f, 0.05849485f, 0.02295588f, -0.07717737f, 0.05041169f, -0.00670336f, 0.01652939f, 
    0.01024601f, -0.02871650f, 0.00075313f, 0.17496774f, 0.17707567f, 0.03762493f, 0.20544539f, 0.21766783f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01793785f, -0.07580628f, -0.04077635f, -0.02622946f, -0.06374036f, -0.21705911f, 0.03334711f, 0.11105295f, 
    0.05467115f, -0.03453448f, -0.33967185f, -0.02633974f, 0.07641628f, 0.11168402f, -0.37419033f, 0.22834869f, 
    -0.29781312f, -0.17560664f, 0.01961027f, 0.00441885f, 0.02241907f, 0.02742570f, 0.16326205f, -0.02904775f, 
    -0.31603724f, 0.11386222f, -0.36997297f, 0.09621409f, 0.06291290f, -0.13133094f, -0.04170371f, -0.26442289f, 
    0.17735334f, -0.04636012f, 0.15927507f, -0.01001990f, 0.10780869f, -0.16111676f, -0.02282130f, 0.09494769f, 
    0.07556634f, -0.20350759f, -0.06507120f, 0.12548921f, 0.08254222f, -0.07807044f, -0.27633533f, -0.06066409f, 
    0.09045243f, -0.19797578f, -0.08930375f, 0.14395350f, -0.07016106f, 0.12346942f, -0.04630528f, -0.01708102f, 
    -0.26260427f, -0.27954769f, -0.03866471f, 0.08500711f, 0.04084805f, 0.05200220f, -0.08314907f, 0.21805535f, 
    0.01666213f, 0.18875128f, -0.05464257f, -0.17389826f, 0.03620309f, -0.14924067f, 0.08035268f, 0.07145620f, 
    0.36305100f, 0.02609265f, 0.13787097f, 0.23951262f, -0.06271920f, 0.20500501f, 0.13481098f, -0.44872555f, 
    -0.30580750f, -0.09574357f, -0.07088170f, -0.07935856f, -0.13601494f, -0.07107674f, -0.08113946f, 0.24800125f, 
    -0.25344744f, 0.10758100f, 0.19577739f, -0.00521392f, 0.07134483f, 0.04555707f, -0.26759842f, 0.05593067f, 
    -0.10908247f, -0.37110001f, -0.37160718f, -0.35428372f, 0.07215723f, 0.07010999f, 0.04203252f, 0.06967749f, 
    0.07726112f, 0.10617688f, 0.07575153f, -0.31434584f, 0.05105384f, -0.27782398f, -0.29244289f, -0.48261708f, 
    -0.10711833f, -0.00526278f, -0.26801342f, 0.19327693f, 0.01452344f, -0.01088517f, 0.22460853f, 0.00142696f, 
    -0.03989241f, 0.03644034f, 0.29033652f, -0.31445906f, -0.37610203f, -0.19312724f, -0.13349117f, -0.24271615f, 
    -0.04397295f, 0.03803827f, -0.29864156f, -0.05730020f, -0.03945030f, 0.00944901f, 0.22500649f, 0.08694348f, 
    0.00012204f, 0.12005223f, -0.07878206f, -0.01937306f, 0.10831071f, -0.09635193f, 0.08293890f, 0.11453487f, 
    -0.16556865f, 0.09753547f, -0.18132955f, 0.22675860f, 0.02739795f, -0.00601321f, 0.11543877f, -0.09091242f, 
    0.01944363f, 0.03666217f, -0.55343163f, -0.05983404f, 0.11792871f, 0.02418393f, 0.10197757f, -0.18203948f, 
    -0.20510855f, 0.04726167f, -0.06024422f, 0.25102127f, -0.14236204f, 0.03195131f, 0.16871150f, 0.19818325f, 
    0.06224404f, 0.11369412f, 0.02715866f, 0.15641999f, 0.30276343f, -0.07408690f, -0.11252876f, 0.08240073f, 
    0.07690332f, 0.01917635f, -0.07302950f, -0.30699617f, -0.07618267f, 0.28457403f, 0.05977503f, -0.09166446f, 
    -0.57897884f, 0.18356326f, 0.13952163f, -0.80183071f, -0.07695298f, -0.11096083f, -0.05223210f, 0.19683635f, 
    -0.18136172f, 0.13160536f, 0.00679511f, 0.07739735f, 0.04509718f, 0.12140580f, 0.10920416f, -0.12397187f, 
    -0.54228568f, 0.05613326f, 0.12067214f, 0.25220749f, -0.06823127f, 0.18597089f, -0.26951870f, -0.03597175f, 
    -0.27374068f, 0.10259651f, -0.05966052f, -0.04680286f, 0.39435557f, 0.02342013f, -0.05038310f, -0.33423078f, 
    -0.23209031f, -0.02860045f, 0.22073814f, 0.08362292f, -0.00138447f, -0.01505505f, -0.11826429f, -0.04973403f, 
    0.08420915f, 0.09548810f, -0.06423973f, 0.13396309f, 0.05972451f, 0.12733014f, -0.62876374f, -0.03490522f, 
    -0.24221410f, -0.12796937f, -0.09513878f, -0.16232222f, -0.03548417f, 0.36881196f, 0.10645602f, 0.00042604f, 
    -0.02587056f, 0.11273189f, -0.35543630f, -0.15942331f, 0.06038750f, -0.07030559f, 0.16454247f, -0.01713442f, 
    -0.07182104f, -0.01399057f, -0.29094249f, -0.06229207f, 0.06355583f, 0.32758650f, 0.23404649f, 0.02807253f, 
    0.02953582f, 0.05604059f, 0.13537565f, 0.03287151f, -0.06705821f, -0.24080949f, -0.39312494f, -0.32096463f, 
    0.09916791f, -0.05335091f, -0.11073568f, -0.08364710f, -0.33237889f, -0.07213777f, 0.15382186f, -0.39276621f, 
    -0.10960089f, -0.07995202f, 0.05156367f, -0.47443250f, 0.08749947f, 0.14495990f, 0.36474442f, -0.05326672f, 
    -0.03860787f, -0.00139698f, 0.02201452f, -0.31147450f, 0.07791388f, 0.16647512f, -0.07025366f, 0.13271035f, 
    -0.35210791f, -0.02082482f, -0.02196790f, 0.17745793f, 0.27237481f, -0.02651116f, -0.30400872f, 0.33524266f, 
    0.05157636f, 0.03389148f, -0.04958353f, 0.14099702f, 0.26203239f, -0.09114571f, 0.18109649f, -0.07894601f, 
    -0.26622534f, 0.13244338f, -0.08922536f, 0.11425855f, -0.01553814f, 0.16207255f, -0.16367021f, 0.04247653f, 
    0.13239449f, -0.21327864f, 0.15340504f, -0.16942509f, 0.02011782f, -0.02804610f, 0.02256495f, -0.05402473f, 
    -0.08111618f, -0.10925855f, 0.10803926f, -0.25488275f, -0.00457425f, 0.04669158f, -0.06890254f, 0.00566020f, 
    -0.62450546f, -0.00499025f, 0.10813233f, -0.34573296f, 0.06724443f, 0.16344473f, 0.04438977f, 0.42620113f, 
    -0.21738154f, -0.23267962f, 0.08004554f, 0.06375624f, -0.53232610f, -0.04744113f, -0.06238982f, -0.51060909f, 
    0.28508219f, 0.03889339f, -0.17999935f, 0.09653726f, -0.02175169f, 0.06489859f, 0.08648707f, -0.01867447f, 
    0.13683283f, 0.11658987f, 0.07302225f, -0.14461049f, 0.08517521f, 0.05588986f, -0.32336900f, -0.06635040f, 
    0.12370505f, -0.19385299f, -0.07752632f, 0.04608694f, 0.00933386f, -0.92100227f, 0.13351288f, -0.02444058f, 
    0.22467850f, 0.10505428f, 0.32106802f, -0.04341835f, 0.05820282f, 0.01326074f, -0.55385059f, -0.02607311f, 
    0.01207542f, 0.06583676f, 0.00121955f, 0.06550459f, 0.16534874f, -0.62338716f, 0.09886653f, -0.06307019f, 
    -0.06769201f, 0.07141693f, 0.24252902f, 0.03463712f, 0.00476435f, 0.12166910f, -0.14010040f, 0.02048899f, 
    -0.23147966f, 0.10637824f, -0.27443653f, -0.07004839f, 0.04718636f, -0.19057959f, -0.02263451f, -0.04283122f, 
    -0.10044345f, 0.03240669f, -0.45536560f, -0.04774982f, 0.04430853f, -0.26021829f, -0.05905459f, 0.03583683f, 
    -0.61081046f, 0.13472320f, 0.31758159f, 0.06179364f, 0.02671080f, 0.24152552f, -0.08493450f, -0.10307497f, 
    0.09104183f, -0.04649750f, 0.10341299f, -0.42689922f, 0.14613949f, 0.13742571f, 0.02282352f, -0.06691087f, 
    -0.01419291f, 0.27107614f, -0.04349543f, -0.38448703f, 0.04533909f, 0.06828952f, -0.01662452f, -0.04863106f, 
    0.03907374f, -0.10097238f, -0.06147275f, 0.15817469f, -0.00418635f, 0.15174834f, 0.33434263f, -0.06248412f, 
    0.15660736f, 0.20718654f, -0.49904025f, 0.04413866f, -0.01864259f, 0.09783861f, 0.04825096f, -0.34737903f, 
    0.13315494f, -0.01614459f, 0.09206930f, -0.30408391f, 0.04933704f, 0.14040750f, -0.48751548f, 0.15854006f, 
    0.16877761f, 0.01649919f, 0.02668120f, -0.05445267f, -0.09743697f, -0.02323620f, 0.12463250f, 0.14650114f, 
    -0.09475212f, -0.65012372f, -0.05971595f, 0.00717784f, -0.13225825f, -0.08475430f, 0.01997024f, -0.12026224f, 
    0.10369376f, 0.18233494f, 0.05200103f, -0.41524035f, -0.01896061f, 0.05960001f, -0.28715774f, -0.01488184f, 
    0.07180672f, 0.20513944f, 0.00830329f, 0.11049474f, 0.01200139f, 0.12530771f, 0.03378301f, -0.08990525f, 
    0.24167213f, 0.27004570f, -0.04349083f, -0.17679566f, -0.05042726f, -0.23055312f, -0.07919981f, -0.11655258f, 
    0.28543925f, -0.31275237f, 0.21540797f, -0.05232583f, -0.06915115f, 0.02080625f, -0.06445472f, -0.03567520f, 
    -0.01425309f, -0.05672491f, -0.22475794f, 0.17669511f, -0.13117833f, 0.08898921f, -0.07868847f, -0.44255847f, 
    0.02929802f, 0.05671828f, -0.30113292f, 0.02257463f, 0.04339444f, 0.22590324f, -0.09484962f, 0.01397484f, 
    0.14402299f, 0.06906825f, 0.11467084f, 0.04653320f, 0.12711118f, 0.19444901f, 0.09518496f, -0.19444801f, 
    0.23346545f, 0.14128262f, -0.27813712f, 0.00854031f, 0.00191077f, 0.00071293f, 0.19008693f, 0.06168757f, 
    0.14843816f, -0.01921886f, -0.09930021f, 0.01176988f, 0.09786199f, -0.08725791f, -0.30484462f, 0.03991673f, 
    -0.17957132f, -0.01780749f, 0.13665162f, -0.04356866f, 0.13501167f, 0.05880264f, -0.29532704f, -0.15861332f, 
    -0.44989559f, 0.02367904f, -0.08618506f, 0.05084572f, -0.15236934f, -0.02124371f, 0.03444033f, -0.04507891f, 
    0.12192881f, 0.06647796f, -0.00577627f, -0.05625781f, -0.03269721f, 0.10844585f, -0.10169329f, 0.03481033f, 
    -0.03509759f, -0.10993087f, -0.06725521f, 0.35751221f, -0.05279712f, -0.09906041f, 0.07649881f, 0.10543456f, 
    0.17588235f, -0.05443364f, 0.10275754f, 0.07213316f, 0.07209948f, 0.00780108f, -0.29698482f, 0.09132233f, 
    0.00972840f, -0.06981190f, -0.00758015f, 0.11569282f, 0.02029964f, -0.24097829f, 0.15215312f, -0.25155696f, 
    0.07838919f, -0.06209552f, 0.00372629f, 0.02606888f, -0.18286687f, 0.02251259f, 0.02188031f, 0.20412150f, 
    0.19135460f, 0.03599969f, -0.18618146f, -0.16354896f, 0.00059366f, -0.14765355f, 0.02206156f, -0.08093891f, 
    -0.26455647f, -0.51508248f, 0.08236914f, -0.05721858f, -0.02975972f, -0.33757836f, 0.25714129f, -0.08541531f, 
    -0.00032084f, -0.01774823f, 0.00163386f, -0.12275042f, 0.06761437f, -0.42429984f, -0.23606786f, 0.12677971f, 
    -0.20239308f, -0.19090371f, 0.21283214f, -0.19268578f, -0.02560780f, -0.04757357f, -0.07599523f, -0.01269162f, 
    0.03592068f, -0.04324923f, -0.15727633f, -0.32446340f, -0.11065363f, -0.14343573f, -0.05353092f, -0.09909851f, 
    -0.05402513f, -0.01097170f, -0.49946371f, -0.03685906f, 0.03227419f, 0.21412966f, -0.15426531f, 0.06649866f, 
    0.10113445f, 0.03923132f, 0.03258231f, 0.05957520f, 0.03653226f, -0.04558902f, 0.17067228f, 0.00055494f, 
    -0.05214228f, -0.11654889f, 0.10469936f, 0.26930991f, -0.16491394f, 0.17520835f, -0.28345171f, -0.08745015f, 
    0.17930104f, -0.02110049f, -0.21278048f, 0.12252467f, 0.08271533f, -0.15319805f, 0.14992699f, -0.06597456f, 
    0.07673176f, 0.06647316f, 0.10381096f, -0.11446573f, 0.03790077f, -0.15081857f, 0.25871089f, 0.17006329f, 
    0.12070586f, -0.07352149f, 0.00837977f, 0.15135685f, -0.34812140f, -0.07397284f, -0.17043430f, -0.03222750f, 
    0.14459506f, 0.16996877f, -0.01126405f, 0.14131817f, -0.02487369f, -0.26832891f, -0.28980756f, 0.06218828f, 
    0.26623330f, 0.07841365f, -0.15022992f, -0.45104137f, 0.04279028f, 0.12691917f, 0.03026184f, -0.16926292f, 
    -0.00465918f, -0.00769196f, 0.09160142f, 0.25038639f, 0.08075579f, -0.36856410f, 0.25140959f, 0.21384175f, 
    -0.13993575f, -0.08843789f, 0.05970215f, -0.18823351f, -0.03660985f, -0.33485067f, 0.11750307f, -0.12387730f, 
    0.07072534f, 0.24858147f, 0.06019800f, -0.01299766f, -0.52477282f, -0.08242160f, -0.00247706f, 0.06923655f, 
    -0.62290114f, 0.08501522f, -0.03980885f, -0.06516746f, 0.04873133f, -0.18096484f, -0.06108127f, 0.05425938f, 
    -0.13079582f, -0.24862389f, 0.03712145f, -0.27101108f, 0.02245579f, -0.04376360f, -0.28518417f, -0.03771972f, 
    -0.06606048f, 0.07479109f, -0.00639082f, 0.02509685f, -0.04520366f, -0.01258866f, 0.07613164f, 0.12795883f, 
    -0.23291761f, -0.03658554f, -0.39597684f, 0.10694346f, -0.09027773f, -0.00820905f, 0.15654968f, -0.02756076f, 
    -0.03763394f, -0.03791079f, 0.31367359f, 0.08410311f, -0.04862670f, -0.22942516f, -0.18238740f, 0.15250745f, 
    0.01904470f, 0.07873378f, 0.07708680f, 0.06574532f, -0.06059542f, -0.22349828f, 0.22044961f, -0.68002307f, 
    0.05356150f, -0.63360465f, 0.10986583f, 0.08133767f, -0.20476739f, 0.09800649f, -0.42061055f, 0.04561366f, 
    -0.34611619f, -0.45457691f, 0.15562920f, -0.39247733f, 0.16323718f, 0.15647082f, -0.22351743f, -0.04917749f, 
    0.19714358f, -0.49820191f, 0.16592525f, -0.11278000f, -0.09031063f, -0.05587079f, -0.42992064f, 0.19326003f, 
    -0.11447212f, -0.07099224f, -0.28765777f, -0.46333355f, -0.54016429f, 0.20331292f, -0.06203188f, -0.57270205f, 
    0.03063351f, -0.06141056f, 0.03684154f, -0.06506675f, 0.00349280f, -0.08052319f, 0.25010580f, 0.02514269f, 
    -0.30464342f, 0.08328232f, 0.03438246f, -0.50047773f, 0.00098787f, -0.27060252f, -0.19653741f, -0.02107490f, 
    0.17921776f, -0.30054942f, 0.13040335f, -0.11327428f, 0.01104745f, -0.06524367f, -0.07772697f, 0.07008664f, 
    -0.16882272f, -0.25349236f, -0.19283029f, -0.22355027f, 0.06017910f, 0.01141436f, 0.18079752f, -0.30744222f, 
    0.13603196f, 0.01596570f, 0.03689893f, -0.18909869f, 0.04980851f, -0.05354657f, -0.06602152f, 0.21984953f, 
    0.15143612f, -0.34201688f, -0.04519556f, -0.04700711f, -0.07371247f, 0.00181132f, 0.06782803f, -0.08387250f, 
    0.10291927f, -0.38458514f, -0.42017978f, -0.02723687f, -0.05531698f, 0.14382449f, 0.08564609f, -0.00054870f, 
    0.06358425f, 0.01662860f, 0.27203244f, 0.01109531f, 0.02532871f, 0.08615076f, -0.24404286f, 0.07877982f, 
    0.12077212f, -0.12466944f, 0.02021769f, 0.06255903f, 0.01476873f, 0.25931513f, 0.10437033f, 0.15203953f, 
    0.13399638f, 0.03886630f, 0.27504322f, 0.16238374f, -0.02720864f, 0.00536307f, -0.09421046f, 0.05586657f, 
    -0.03339121f, -0.01734824f, -0.36829033f, 0.04590423f, 0.25884107f, 0.18911316f, -0.19032200f, 0.13153674f, 
    0.00180860f, -0.01860367f, 0.16431332f, 0.01338175f, -0.00946793f, 0.14984934f, -0.10208145f, -0.18988769f, 
    0.07559249f, -0.31817436f, 0.12317409f, -0.06079682f, -0.26614359f, 0.04694647f, -0.07692037f, -0.36251616f, 
    0.14028409f, 0.06706657f, -0.30368239f, -0.15292495f, -0.24740902f, -0.34735680f, 0.36646071f, -0.06567277f, 
    -0.08918283f, -0.49995387f, 0.12054945f, -0.48075444f, 0.19199000f, 0.16361004f, 0.11922567f, 0.16024850f, 
    -0.08206198f, -0.02163289f, -0.08908483f, 0.10410652f, 0.19517381f, 0.11624981f, -0.10147148f, 0.07086305f, 
    0.06725573f, -0.05937625f, 0.03710311f, -0.09960281f, -0.41749954f, 0.02782083f, -0.38301864f, -0.01294160f, 
    -0.00046238f, -0.39924484f, 0.00155518f, 0.34510002f, -0.04074128f, -0.28953749f, 0.29298323f, 0.07598863f, 
    0.11242682f, 0.03624355f, 0.02719333f, 0.30112484f, -0.11513010f, -0.40024331f, 0.03694373f, -0.03653651f, 
    -0.57795662f, 0.00667149f, -0.11791364f, 0.04364911f, -0.05618383f, 0.18185814f, -0.12838016f, 0.29592642f, 
    0.11808009f, 0.03163525f, -0.50521886f, -0.18407163f, 0.05052838f, -0.02002366f, 0.06465355f, -0.23822610f, 
    0.15876538f, -0.10547483f, -0.00698342f, 0.01368233f, -0.12063424f, 0.07115450f, -0.07155012f, 0.17330419f, 
    -0.06624647f, -0.40857983f, 0.12398895f, -0.06008446f, -0.08114902f, -0.33120680f, -0.07950144f, 0.03595320f, 
    0.21008633f, 0.12022959f, -0.01972152f, 0.11331130f, 0.03291678f, 0.09228760f, 0.16610262f, -0.03646066f, 
    0.08209296f, -0.29432151f, 0.01661655f, -0.28169742f, -0.06222262f, 0.05458921f, 0.04858397f, 0.10808249f, 
    0.15634137f, 0.05020570f, -0.38560444f, -0.19838198f, 0.09921988f, -0.05328956f, -0.23734832f, -0.01201337f, 
    -0.03740375f, -0.09016167f, 0.47735119f, 0.10559523f, -0.07770712f, 0.10330081f, -0.07803216f, 0.00304872f, 
    0.02788161f, 0.04011468f, -0.13843848f, 0.02147444f, -0.05307952f, -0.01590823f, 0.09443372f, -0.69084513f, 
    -0.28163311f, -0.00998972f, 0.00361704f, 0.04188688f, -0.25594205f, -0.31545800f, -0.05787463f, -0.13413462f, 
    -0.05080315f, 0.22304364f, 0.16061936f, -0.59421104f, -0.15634409f, -0.31780741f, -0.39452487f, -0.02609831f, 
    0.00515956f, -0.44782567f, 0.21886070f, -0.07479311f, 0.05723653f, 0.15026483f, 0.24612194f, 0.11116381f, 
    0.13453376f, 0.05167408f, 0.07798234f, 0.19268984f, -0.38838592f, -0.15736048f, -0.22747266f, -0.05576855f, 
    0.20207931f, 0.07287905f, 0.02500357f, 0.15068124f, 0.06145578f, -0.04061184f, -0.08181895f, 0.06863520f, 
    -0.31711552f, 0.07880785f, 0.01476137f, -0.35139289f, 0.03957501f, 0.08909742f, 0.06256538f, 0.05182784f, 
    -0.04128322f, 0.16137235f, -0.16439757f, -0.20273986f, -0.04071774f, 0.17172983f, -0.02794284f, -0.35152951f, 
    -0.55982846f, 0.00683439f, -0.76050025f, 0.06618486f, 0.02757694f, 0.12558465f, 0.05688328f, 0.25634372f, 
    -0.01818188f, 0.03158424f, -0.06285516f, -0.28984904f, 0.02666501f, 0.06318358f, -0.35031426f, 0.17879146f, 
    0.01558784f, 0.17663407f, -0.07522003f, -0.07923428f, 0.27722535f, 0.00730049f, -0.09117310f, 0.36558741f, 
    -0.07418870f, 0.23032337f, 0.28772631f, 0.38205907f, -0.05201478f, 0.10852873f, -0.26984406f, 0.07852989f, 
    -0.00309678f, 0.07193090f, -0.27474853f, 0.08106413f, 0.00045555f, 0.03362452f, -0.28145596f, 0.03620835f, 
    0.28645864f, 0.00638129f, 0.06666846f, 0.17876753f, -0.07082035f, -0.21972060f, 0.12260006f, -0.14271314f, 
    0.11527167f, -0.19446753f, -0.32011324f, 0.07211750f, 0.01551232f, -0.04169776f, 0.11762197f, -0.03236571f, 
    -0.07320546f, 0.02338945f, -0.09194119f, 0.24618611f, -0.25235176f, -0.16558374f, -0.17941298f, 0.12472764f, 
    0.03818567f, -0.01973924f, 0.15743010f, 0.03348248f, -0.06354102f, -0.04473443f, -0.33640561f, 0.01533179f, 
    0.22073165f, 0.02972989f, 0.13467789f, 0.07055265f, -0.35282302f, -0.15828776f, -0.27106369f, -0.40019837f, 
    0.34352699f, -0.11034611f, 0.11194851f, -0.27845559f, 0.23997410f, 0.27084747f, 0.19064352f, -0.08073781f, 
    0.18536766f, 0.24800029f, -0.04606719f, 0.02256491f, -0.29040354f, -0.34387973f, -0.38877586f, 0.08533254f, 
    0.21932639f, 0.02910369f, -0.32364216f, -0.04764991f, -0.27633265f, -0.17903867f, 0.15319191f, -0.16699617f, 
    -0.06693655f, -0.48229849f, 0.04981308f, -0.03003178f, -0.18105939f, 0.06787440f, 0.09883912f, -0.09287114f, 
    0.13792846f, 0.07708539f, -0.04237879f, 0.21645688f, 0.06435730f, -0.18377987f, -0.00139650f, -0.06114848f, 
    0.07810397f, -0.28341368f, 0.15140946f, 0.09780439f, -0.00374490f, -0.35524660f, -0.01083071f, -0.08592948f, 
    0.07739591f, 0.10921644f, 0.07003628f, -0.47427556f, -0.04790576f, 0.04461222f, 0.01899358f, -0.01126473f, 
    0.21855824f, 0.00607959f, 0.13326465f, -0.28370091f, 0.01170673f, -0.15364379f, 0.09703348f, -0.15979575f, 
    0.10185036f, 0.23273200f, 0.06817048f, 0.05120010f, 0.11457822f, 0.06403790f, -0.03363844f, -0.36511466f, 
    0.20072366f, -0.17012371f, -0.19566852f, 0.26061273f, -0.00600124f, -0.43467352f, 0.16770567f, 0.00481044f, 
    0.09570181f, -0.23542914f, 0.05632548f, 0.01765424f, -0.06423403f, -0.20750143f, 0.33783111f, 0.02348424f, 
    -0.67343825f, -0.50810498f, 0.03793437f, 0.09246673f, -0.02740052f, -0.27065185f, -0.20303583f, 0.07101186f, 
    -0.28713644f, 0.11622164f, -0.12312543f, -0.02343689f, 0.05416879f, -0.07834630f, -0.30433685f, 0.03772841f, 
    0.01099104f, -0.09076595f, 0.20506689f, 0.07128017f, 0.03608172f, -0.10775530f, 0.22315016f, 0.15626138f, 
    -0.01225589f, 0.04064648f, -0.34279945f, 0.07565987f, -0.02654465f, -0.16589816f, -0.06455552f, 0.26655370f, 
    -0.21375556f, -0.08963168f, -0.09577522f, 0.04595134f, -0.05147687f, -0.04165133f, -0.12218290f, 0.25331903f, 
    -0.37099996f, 0.24207297f, 0.03375540f, 0.00869681f, -0.34551001f, -0.08097610f, -0.46025091f, 0.04294643f, 
    -0.19010563f, -0.04492231f, -0.12250484f, 0.19592832f, -0.53047162f, 0.40467304f, -0.09873515f, -0.03853611f, 
    0.37429357f, -0.01591396f, 0.01055635f, -0.03863811f, -0.14015350f, 0.39908108f, -0.45158324f, 0.12386001f, 
    0.10329142f, -0.02212336f, 0.06091921f, -0.52586979f, -0.11425407f, -0.07410851f, 0.27721718f, -0.09235768f, 
    0.03243938f, 0.05717238f, -0.02540096f, -0.32134205f, -0.07832123f, -0.04431384f, 0.26686519f, -0.05747872f, 
    -0.09653690f, -0.13489483f, 0.16210847f, -0.31430969f, -0.11866024f, 0.28511661f, 0.05406336f, 0.22185764f, 
    0.24443345f, -0.35324457f, -0.16282570f, 0.20442043f, 0.02686188f, -0.28700384f, -0.04778815f, -0.34603977f, 
    0.27061683f, 0.05117082f, 0.16010074f, -0.32413420f, -0.01776164f, -0.11883179f, -0.63297766f, 0.28871676f, 
    -0.08676878f, 0.12072051f, -0.00211014f, -0.02227775f, -0.22240394f, -0.06358295f, 0.01695107f, -0.17155069f, 
    -0.12622714f, -0.03665128f, -0.32796830f, 0.18042096f, 0.00003466f, 0.11150300f, -0.16883089f, -0.01616482f, 
    -0.35234994f, 0.08599376f, 0.23128763f, 0.08649458f, 0.08118696f, -0.08681123f, -0.30755997f, -0.05636978f, 
    0.22648428f, 0.04291266f, 0.05070857f, 0.07315048f, 0.07666983f, -0.19566600f, 0.17273323f, -0.06567080f, 
    -0.11860713f, -0.31861925f, -0.22502749f, 0.05044708f, 0.03161166f, -0.04259478f, -0.12463982f, -0.04033097f, 
    0.07737720f, -0.07543270f, -0.33442292f, 0.07797982f, 0.42593649f, -0.18260495f, -0.64554757f, -0.13675429f, 
    -0.06374962f, 0.06682011f, 0.10546271f, -0.06779301f, 0.00102772f, -0.19889131f, 0.12639871f, 0.04126867f, 
    -0.23527960f, 0.16225432f, 0.14548315f, 0.07490224f, -0.49951088f, 0.22736999f, 0.26612887f, 0.30756876f, 
    0.16821714f, -0.02904469f, 0.18334673f, -0.08992157f, 0.04165868f, 0.06979663f, -0.23371267f, 0.02320679f, 
    -0.02156873f, -0.28347313f, 0.05961338f, 0.33925220f, -0.30549651f, -0.49946836f, -0.03537047f, -0.07792021f, 
    -0.32167390f, 0.06564357f, 0.20745666f, 0.00124872f, 0.09630066f, -0.18495110f, -0.41230002f, -0.60544837f, 
    -0.13377200f, -0.16869032f, -0.07223430f, 0.23420301f, 0.17102107f, -0.01645791f, 0.17160420f, -0.02729272f, 
    -0.24235317f, -0.34078223f, 0.05823404f, -0.18679138f, 0.04759965f, -0.12127903f, -0.27119371f, -0.07201976f, 
    -0.12739496f, 0.20753792f, 0.12709981f, -0.16115308f, -0.05444052f, 0.09896115f, -0.04983710f, 0.01631459f, 
    -0.08183974f, -0.14451052f, 0.28439233f, 0.01654998f, 0.08959627f, 0.10047665f, -0.03048632f, -0.17967845f, 
    -0.32585475f, -0.02578076f, -0.27464625f, -0.16676582f, 0.07865132f, 0.34862882f, -0.12366577f, -0.29519814f, 
    0.07225917f, 0.08950795f, -0.05568660f, 0.03858049f, 0.18673421f, 0.07465222f, -0.07257190f, 0.26203993f, 
    0.04255477f, -0.32184300f, 0.17457807f, -0.71184433f, -0.07984278f, 0.23350875f, 0.03809627f, -0.01354836f, 
    0.13516301f, 0.20498499f, -0.05948259f, 0.21740036f, 0.08293048f, -0.04005452f, -0.03728395f, 0.04103531f, 
    0.22459315f, 0.21634385f, 0.06035230f, 0.14864101f, -0.01855649f, -0.12033442f, 0.21060561f, 0.14872201f, 
    -0.16950314f, 0.07342654f, 0.33671671f, -0.30106100f, 0.06503392f, -0.09327471f, 0.00549208f, 0.01339196f, 
    0.01129112f, 0.06748424f, -0.38854820f, -0.25127888f, -0.50012875f, 0.15210013f, -0.30696785f, 0.00217226f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17354946f, 0.07110350f, 0.08898692f, -0.08242887f, -0.04475431f, 0.02966690f, 0.13076709f, -0.09412849f, 
    -0.01768918f, 0.03723681f, 0.01864556f, -0.02470689f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
