#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.91350138f, -0.90303689f, -0.29166290f, 0.83379906f, 0.48399925f, 0.30524984f, 0.04352609f, -0.04450976f, 
    -0.65652275f, -0.86163938f, 0.14247389f, -0.19108179f, -0.21696840f, 0.16711421f, 0.07314221f, 0.08147424f, 
    -0.09934852f, -0.41074955f, -0.06130968f, -0.30598006f, 0.47166520f, 0.08873964f, 0.31432742f, 0.37788984f, 
    0.41050273f, -1.49142861f, -0.72550398f, -0.54934227f, 0.09023148f, 0.03470014f, 1.17039669f, 0.95785677f, 
    0.22158812f, 0.18148175f, 0.44621626f, 0.19234246f, -0.04101511f, -0.09451011f, 0.25989944f, -0.49667302f, 
    -0.16557212f, -0.04015918f, -0.15166266f, -0.22154090f, 0.24004403f, -0.05268317f, -0.17518246f, 0.27777675f, 
    0.02972559f, -0.22892554f, -0.13123925f, -0.75994295f, -0.95822054f, -0.66770834f, -0.95665604f, -0.90833479f, 
    -0.67383474f, -0.64059627f, -1.41161168f, -1.16179967f, -0.02310233f, 0.20046398f, -0.05162441f, -0.42146093f, 
    -0.45925334f, 0.11204778f, 0.20855252f, 0.14878534f, 0.02573149f, -0.18387181f, -0.08602341f, -0.19770491f, 
    0.00842987f, 0.22334076f, -0.06243839f, -1.56604373f, -0.66212565f, -0.56539512f, -1.16942799f, -0.32346663f, 
    0.41066194f, -0.10212684f, -0.75300616f, -0.35800418f, 0.29881099f, -0.38061923f, -0.35867375f, 0.08162719f, 
    -0.60028028f, -0.25214481f, 0.44951171f, 0.65374988f, 0.37191045f, 0.21574157f, 0.00642764f, 0.19617930f, 
    0.66021425f, 0.08919931f, -0.41306806f, -0.14972262f, 0.29285756f, 0.78998011f, 0.33214653f, -0.24624048f, 
    0.13539001f, 0.10624220f, 0.42326757f, -0.24343030f, -0.14622709f, 0.67595351f, 0.33191743f, -0.25583178f, 
    -0.48178199f, -0.40653834f, -0.16902044f, -0.22410055f, -0.22499406f, -0.16968495f, -0.03018010f, -0.09497162f, 
    0.27186558f, 0.37202933f, -0.01459243f, -0.20962821f, -0.59982872f, 1.10711384f, 1.49374557f, -0.57756972f, 
    -0.56243545f, -1.25971830f, -0.96852219f, -0.33129764f, 0.40281811f, 0.18401100f, 0.55063695f, 0.00387202f, 
    0.12975024f, 0.63349819f, 0.17739345f, -0.34428164f, -0.24318512f, 0.24329528f, 0.17504850f, -0.14863047f, 
    -0.64392489f, 0.06451945f, 0.14241950f, -0.20220649f, 0.42020631f, 0.17095378f, -1.65204263f, -0.52562106f, 
    0.21502775f, 1.04749441f, 0.75564349f, 0.23824178f, -0.89716482f, -0.04637790f, 0.85842282f, 0.67090601f, 
    -0.12333144f, -0.35263488f, -0.23594922f, 0.56378078f, 0.12461382f, -0.08527357f, 0.14355667f, -0.05603914f, 
    -0.17996092f, -0.19749896f, -0.35452783f, -0.18122172f, 0.14492543f, 0.06102979f, -0.18351513f, 1.67615509f, 
    -0.44284245f, 0.21921551f, 0.85239667f, -0.29250762f, 0.34533256f, 0.30196202f, -0.11541026f, -0.82386529f, 
    -0.84273541f, -0.12590657f, -0.01409393f, 0.17819148f, -0.13535182f, -0.21158053f, 0.01846276f, -0.20499283f, 
    0.06966066f, 0.13318218f, -0.21898849f, 0.02463621f, -0.30471495f, -0.27379364f, 0.04042923f, 0.19691059f, 
    -1.21978319f, -0.64059836f, -1.27762115f, -1.17968762f, -0.62552053f, 0.35212016f, 0.22327042f, -0.40687552f, 
    -0.22993183f, 0.89287919f, 0.12369668f, -0.27475795f, -0.40093076f, 0.50308436f, 0.65452909f, -0.48796695f, 
    -0.04268170f, -0.36519426f, -0.31823102f, -0.44778305f, -0.20311041f, -0.18144868f, 0.03043795f, 0.55447561f, 
    -0.04585776f, 1.54260552f, -0.90615773f, -1.61559296f, -0.89349532f, -1.15290189f, 0.73999381f, 0.11074741f, 
    0.30787504f, 0.12558143f, 0.35344380f, 0.04582470f, -0.07608944f, -0.25719264f, -0.52580273f, -0.36836830f, 
    0.22682853f, 0.01919416f, 0.13122417f, -0.29136595f, -0.07066589f, -0.40783280f, -0.34268796f, -0.28456342f, 
    -0.46112379f, -0.61471593f, 0.26226804f, 0.62673384f, 0.16944836f, -0.55129385f, -0.80700392f, -1.31887007f, 
    -1.10189974f, -0.92637002f, -0.86625046f, -1.37624478f, 0.93339044f, -0.67257637f, -0.03144303f, 0.32691926f, 
    0.29965255f, 0.12307236f, 0.04517528f, 0.09088018f, -0.08589465f, -0.45976132f, -0.24448767f, -0.11189090f, 
    -0.05361642f, -0.08700200f, 0.18185057f, 0.01387461f, 0.18293817f, 0.05023464f, -0.29376397f, 0.34247851f, 
    -0.53992981f, -0.32437745f, 0.52338231f, -0.26177150f, 0.06346899f, -0.22344120f, -0.31032050f, -0.18832509f, 
    0.92018294f, -0.05461911f, -0.22734937f, 0.10579861f, -0.12621841f, 0.02888485f, 0.11028095f, 0.15895772f, 
    0.00090326f, 0.51231736f, 0.30206794f, 0.00976707f, 0.11899893f, 0.62398928f, 0.35296389f, -0.02930071f, 
    -0.08637808f, -0.83345079f, -0.07723354f, 0.19077475f, 0.39775908f, -0.05139835f, -0.29623440f, -0.28332314f, 
    -0.33286104f, 0.58063859f, 0.17867957f, 0.54807067f, -0.12823583f, 0.16453063f, -0.21291141f, -0.50218779f, 
    0.02137142f, 0.31237999f, -0.37668869f, -0.52926952f, -0.48228288f, -0.03722126f, 0.06923305f, -0.78483689f, 
    -0.23374239f, 0.90657020f, -0.14596620f, -0.00890605f, 0.22894558f, 0.24624369f, -0.45979634f, 0.42727384f, 
    -0.53724670f, 0.68436515f, -0.22903074f, -0.17610529f, 0.12101085f, -0.39939007f, 0.51307112f, -0.38086337f, 
    -0.16133559f, -0.29493219f, -0.03005835f, 0.26078027f, 0.11987496f, 0.24087965f, 0.17586602f, 0.92377251f, 
    0.87615955f, 0.38894218f, -0.50375253f, -0.61491776f, -0.25672588f, 0.32433236f, -0.60462862f, -0.64387494f, 
    -0.09759147f, 0.08300469f, -0.05173349f, -0.35728329f, 0.03567961f, 0.36201134f, 0.05324844f, -0.18126057f, 
    0.01256350f, 0.27192235f, 0.06154952f, -0.03495496f, -0.06268238f, 0.15537229f, 0.12765393f, 0.69199121f, 
    0.31829911f, 0.34087914f, 0.23733267f, -0.10281545f, 0.14384097f, 0.67869925f, 0.47761127f, 0.24954857f, 
    0.29928058f, 0.18664719f, 0.12175313f, 0.48912740f, 0.37788656f, -0.28545094f, 0.27606040f, 0.02490913f, 
    0.20649621f, 0.13203792f, -0.17596239f, -0.03757074f, 0.25972816f, 0.15334807f, 0.07256800f, -0.12690987f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00006192f, 0.38105327f, -0.52152556f, 0.10617116f, 0.09323256f, 0.54215670f, 0.64270461f, 0.31003153f, 
    -0.08643815f, 0.01155018f, 0.27653450f, 0.65664935f, 0.48565340f, 0.59015340f, 0.44401178f, 0.08597094f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.32697889f, 0.05642924f, -0.01981701f, -0.18330845f, 0.20217560f, 0.04683518f, 0.16734479f, -0.29231223f, 
    -0.11934502f, -0.18540734f, -0.12210017f, -0.14144090f, 0.60232055f, -0.33985814f, -0.30031177f, 0.01750445f, 
    -0.01226963f, 0.10723028f, 0.17016026f, -0.05407029f, -0.05438003f, 0.11550456f, -0.12527129f, -0.22514361f, 
    0.61221093f, 0.28901267f, -0.14708145f, -0.23396999f, 0.29434717f, 0.01736487f, 0.06834206f, 0.17238016f, 
    -0.08798403f, -0.05124963f, -0.00715213f, 0.01787841f, 0.51290792f, 0.42149591f, -0.33341050f, -0.33240145f, 
    0.13741454f, 0.46156469f, 0.10372870f, 0.08343827f, 0.03124462f, 0.15723868f, -0.02397256f, -0.05493553f, 
    -0.24936092f, -1.27331865f, 0.05274843f, 0.11406640f, 0.00374192f, 0.08572768f, 0.10285456f, 0.10062414f, 
    -0.09730978f, -0.10486793f, -0.03551702f, 0.02572726f, -0.08807311f, -0.65625209f, -0.29887331f, 0.14835359f, 
    -0.09656954f, 0.14206138f, -0.10834690f, -0.36875898f, -0.11122587f, -0.15811361f, -0.13448879f, -0.03463052f, 
    0.44732872f, -0.02228757f, 0.53470987f, -0.65770805f, 0.03278653f, 0.06711224f, 0.02113523f, 0.03501926f, 
    -0.14285322f, 0.05945081f, -0.16115189f, -0.29295063f, -0.66268712f, -0.95573145f, 0.14433488f, -0.15263134f, 
    0.02299774f, 0.00241069f, 0.10358944f, 0.05519310f, -0.02411045f, 0.03694844f, -0.07520473f, 0.03427836f, 
    0.41694188f, 0.08989173f, 0.08053410f, -0.20839535f, 0.10431520f, 0.28238964f, -0.41651350f, -0.21369685f, 
    -0.31627557f, -0.13054840f, -0.07220596f, -0.03055823f, 0.12989260f, 0.00033149f, -0.43329811f, 0.11485316f, 
    0.18185210f, 0.01666387f, -0.03883265f, -0.13093676f, -0.11616591f, 0.13125212f, 0.27239859f, 0.07299231f, 
    0.43543932f, 0.25031197f, 0.10859130f, -0.34508562f, 0.03207094f, 0.13086405f, -0.12183292f, -0.07968441f, 
    -0.05865306f, 0.07191985f, 0.00430724f, -0.23672585f, -0.02352948f, 0.28108948f, 0.11218110f, 0.07341217f, 
    -0.08853436f, -0.25260508f, -0.35933700f, -0.11617088f, 0.09415269f, -0.01251284f, -0.14912142f, -0.08560616f, 
    -0.72083223f, -0.24452485f, 0.33496878f, 0.13281795f, -0.15467699f, 0.02840672f, 0.01283568f, -0.02516456f, 
    -0.06290895f, -0.26304579f, -0.27879098f, -0.23292434f, -0.11555215f, 0.09908843f, -0.23593396f, -0.15317720f, 
    -0.04913349f, 0.14374679f, -0.05703353f, 0.09829848f, -0.02781411f, -0.26616719f, -0.19969577f, -0.30009055f, 
    -0.17466164f, -0.03867963f, 0.17929028f, -0.01141351f, -0.14013736f, 0.22071555f, -0.33561209f, -0.01777861f, 
    0.04519174f, 0.01638359f, 0.03943788f, -0.00535829f, 0.04152739f, -0.00430646f, 0.14564133f, 0.07253938f, 
    0.03448187f, -0.02958426f, 0.15121819f, 0.10533000f, -0.36549771f, -0.36922076f, -0.04516235f, -0.07602303f, 
    -0.48851237f, -0.06295688f, 0.49619761f, 0.09612326f, -0.02121950f, -0.09455574f, 0.30877963f, 0.07851656f, 
    0.10626625f, -0.02788926f, 0.09834661f, -0.00909497f, 0.34919301f, -0.25128347f, -0.31214285f, -0.17906107f, 
    -0.19738238f, -0.04058267f, 0.03553923f, 0.03518435f, 0.11198768f, -0.12954532f, -0.09644275f, 0.11908373f, 
    0.05342865f, 0.07492988f, 0.32649910f, 0.11868261f, -0.31693560f, 0.05328584f, -0.06321276f, -0.26835045f, 
    -0.04661899f, 0.01763076f, 0.00974760f, 0.18407762f, 0.10999648f, 0.27393821f, 0.20223624f, 0.11967599f, 
    0.10027701f, 0.09610344f, -0.13728994f, 0.04937557f, -0.09929506f, -0.09111067f, -0.10451205f, -0.10611119f, 
    0.64503169f, 0.42346203f, 0.45832801f, 0.34170121f, -0.06403750f, -0.03033870f, 0.02374060f, 0.03759268f, 
    -0.03630768f, -0.02107960f, -0.01412516f, -0.09132006f, 0.14166716f, -0.66535550f, 0.42905736f, -0.54519856f, 
    0.06955120f, 0.08332803f, -0.03170801f, 0.16339000f, 0.02647424f, -0.10818099f, 0.10574355f, 0.04877625f, 
    -0.49290642f, 0.23317075f, -0.09724668f, -0.11969173f, 0.12155743f, -0.03778240f, 0.07159851f, -0.03032741f, 
    -0.08964618f, -0.21951711f, -0.25484052f, -0.17512468f, 0.94867998f, 0.19262210f, -0.00872349f, 0.18498480f, 
    -0.12175754f, -0.01839168f, -0.11617507f, -0.26556182f, 0.01883615f, -0.10803295f, 0.07635111f, 0.06547815f, 
    0.16237731f, -0.15701877f, 0.21537122f, -0.24455334f, 0.19306913f, 0.03224808f, 0.10846752f, 0.07488620f, 
    0.05386512f, -0.06001347f, 0.12091348f, -0.30865011f, 0.72526789f, 0.08248029f, -0.02912506f, -0.16268185f, 
    -0.01183535f, -0.01739263f, -0.33744904f, -0.38980243f, 0.15750481f, -0.36556643f, -0.36015499f, -0.21441792f, 
    -0.22576240f, -0.05957620f, -0.21595377f, -0.52950525f, -0.09510252f, -0.30805147f, -0.04878975f, 0.15512457f, 
    -0.14434625f, 0.08509381f, -0.01472784f, 0.20906892f, 0.00524748f, -0.04184953f, -0.04340892f, -0.00586327f, 
    0.01219677f, 0.07238268f, 0.20482805f, -0.08447287f, -0.09780279f, -0.09498338f, 0.22996268f, -0.03307648f, 
    -0.10008743f, 0.05641418f, -0.00289984f, -0.00570218f, 0.11005904f, -0.08098026f, -0.22734675f, 0.16957882f, 
    0.06146481f, 0.25109521f, -0.12014523f, -0.01182985f, -0.46536565f, 0.16880108f, 0.07330184f, -0.04924725f, 
    0.21441635f, -0.00504301f, 0.41050717f, -0.23587963f, 0.10249107f, 0.33449659f, -0.07248424f, 0.04301849f, 
    0.19979282f, -0.16682367f, -0.02110904f, -0.45630568f, -0.36856049f, -0.18631871f, 0.12293306f, -0.08829574f, 
    -0.07153966f, -0.01810961f, -0.01580951f, -0.05904575f, 0.24044558f, 0.18838145f, 0.19337028f, 0.12068837f, 
    -0.08364481f, -0.04853610f, 0.04609188f, -0.01608351f, -0.07767384f, 0.12463975f, 0.14143026f, 0.00416004f, 
    -0.03541027f, -0.27668899f, -0.38395467f, 0.12716432f, -0.06583389f, -0.27029118f, 0.32961255f, 0.01515615f, 
    -0.13182260f, -0.11084702f, -0.07876062f, -0.18979953f, -0.29001358f, -0.29352683f, 0.73634142f, 0.29645589f, 
    0.05497607f, 0.02114484f, 0.11680603f, 0.16103674f, 0.14073037f, -0.08107968f, 0.04727539f, -0.12882704f, 
    -1.19945598f, -0.69190073f, -0.25850874f, -0.47490042f, -0.16351913f, 0.01332484f, 0.26672634f, -0.30400226f, 
    0.00003209f, -0.08864775f, 0.00125146f, -0.14773636f, -0.28717253f, -0.30852559f, 0.43370852f, 0.82829612f, 
    0.12544768f, 0.01736721f, 0.03664592f, 0.06458529f, 0.10478752f, 0.00871112f, 0.04498433f, -0.00430902f, 
    0.21140049f, -0.55893165f, 0.09280086f, -0.37388739f, 0.05949797f, -0.08105040f, 0.04348942f, 0.11170706f, 
    0.06126704f, -0.06645529f, -0.15038639f, 0.16140835f, -0.51989698f, -0.02852204f, 0.28830203f, -0.06254207f, 
    0.03304449f, 0.12756906f, -0.18216515f, -0.07817523f, 0.14010581f, -0.06006881f, -0.04408389f, 0.12607621f, 
    -0.28493169f, 0.06028557f, -0.12851548f, 0.33270916f, 0.03784856f, 0.11740615f, -0.00459415f, 0.06010213f, 
    0.09734311f, 0.02939931f, 0.03239985f, 0.06623257f, -1.46165550f, 0.61416525f, -0.23499051f, -0.21708226f, 
    0.04490113f, 0.01087995f, 0.00913354f, 0.01170783f, -0.01604072f, -0.01702874f, 0.11633918f, -0.10644283f, 
    0.15690547f, 0.34935263f, 0.87198758f, 0.49603042f, 0.10103054f, 0.03050826f, 0.04821880f, 0.02181713f, 
    -0.21113843f, -0.01345908f, -0.06794144f, 0.03716805f, 0.00404404f, 0.64082152f, 0.21824750f, 0.22060400f, 
    -0.08318246f, -0.02811044f, 0.12398837f, -0.24632293f, 0.02066648f, 0.16604188f, -0.05256831f, 0.19536343f, 
    -1.42303371f, -0.49582791f, 0.15228701f, -0.37630510f, 0.21922803f, -0.11429740f, 0.01871454f, -0.42979804f, 
    -0.03623391f, -0.00967513f, 0.02154072f, 0.03873004f, 0.01611214f, -0.14128754f, -0.09577775f, 0.11245454f, 
    -0.31653705f, 0.08103938f, 0.28236446f, -0.18566413f, 0.00951389f, -0.01561138f, 0.02862628f, -0.04470756f, 
    0.03577770f, -0.08310319f, -0.08283205f, 0.15382917f, 0.00577991f, -0.01756666f, -0.14058705f, -0.04465585f, 
    0.10872314f, -0.19963270f, 0.01749096f, 0.38115084f, -0.09224796f, -0.18253003f, 0.01258206f, -0.02642339f, 
    0.09323512f, 0.00088149f, 0.23367558f, -0.23356809f, -0.11355563f, 0.12801972f, 0.29827535f, -0.19036542f, 
    0.02052971f, 0.19492956f, 0.14008734f, -0.32453617f, -0.09205725f, -0.00670187f, 0.04916491f, 0.17174742f, 
    -0.04068367f, -0.07891501f, -0.07081694f, -0.05436752f, -0.23725596f, -0.11604951f, -0.05617683f, -0.01313386f, 
    0.04194425f, -0.00755237f, 0.08268076f, -0.03165348f, 0.02797183f, -0.32442680f, 0.15868466f, -0.12379105f, 
    -0.03988726f, 0.58420551f, -0.22663468f, -0.07185179f, 0.05509431f, 0.07465287f, -0.15871853f, 0.07347913f, 
    -0.10774014f, 0.00078760f, 0.23839818f, 0.09314653f, -0.10597659f, 0.30485737f, -0.24792890f, -0.36132279f, 
    0.39512578f, 0.47759047f, 0.21086293f, 0.08417547f, -0.46783063f, -0.01797531f, -0.03804521f, -0.06061503f, 
    -0.29332170f, -0.37171131f, -0.02604036f, 0.43041116f, 0.08284523f, 0.15043463f, 0.11802451f, -0.01350799f, 
    0.03166131f, 0.06364182f, -0.15271942f, -0.10866082f, 0.37110627f, -0.18505621f, -0.08046104f, 0.16531825f, 
    0.05594758f, 0.01940159f, -0.09162222f, -0.19409339f, 0.06415944f, 0.09968130f, -0.16900334f, 0.17666282f, 
    -0.46145052f, -0.28761587f, -0.39806488f, -0.33834219f, -0.40733850f, 0.23707384f, -0.29727584f, 0.12050687f, 
    0.02422425f, 0.05566817f, 0.22224481f, 0.10159510f, -0.48504373f, 0.54770607f, -0.12923676f, 0.36569065f, 
    -0.25462547f, -0.03207086f, -0.30398354f, -0.30817148f, -0.10513771f, 0.11313388f, -0.02617729f, -0.24562940f, 
    -0.07904090f, 0.85292685f, -0.36074030f, -1.15000832f, -0.14252262f, 0.08018077f, -0.07050223f, 0.03742619f, 
    -0.17420487f, -0.16989113f, 0.00692570f, -0.19806613f, -0.60506254f, 0.86743474f, -0.14130068f, 1.01466346f, 
    0.14280741f, -0.28280461f, 0.08054274f, 0.19605553f, 0.12648742f, 0.00372324f, 0.20507817f, 0.08556557f, 
    0.13027743f, -0.19013184f, -0.02900065f, 0.38119692f, 0.08048718f, 0.03772706f, 0.20784912f, -0.29984787f, 
    0.16754423f, -0.05693904f, 0.02552611f, 0.25909525f, -0.38052318f, -0.05460191f, 0.04735461f, 0.35550073f, 
    -0.03102297f, 0.19452508f, 0.01898477f, -0.23992097f, -0.00704731f, 0.07218102f, -0.02969849f, 0.21535395f, 
    0.10508587f, -0.46334150f, 0.30348033f, 0.10142437f, 0.02325479f, 0.32455704f, 0.09742342f, 0.20162909f, 
    -0.04857603f, -0.17395489f, 0.00275364f, -0.14969432f, 0.12373326f, -0.41810802f, -0.09635538f, -0.19632459f, 
    -0.10849726f, 0.16070555f, 0.06724152f, 0.05427583f, 0.32051238f, -0.35783350f, -0.09421229f, -0.19134927f, 
    0.44765341f, -0.23993254f, 0.02175565f, -0.30987740f, -0.36443961f, -0.18937825f, 0.09661221f, 0.13475300f, 
    -0.16371593f, -0.09777111f, 0.43001044f, -0.03123757f, 0.20006363f, -0.00018570f, -0.59477097f, 0.21719760f, 
    -0.11847824f, -0.35226911f, -0.30552489f, -0.32155684f, -0.01311045f, 0.27287722f, 0.05685531f, -0.35703135f, 
    0.20182538f, -0.12430494f, 0.37614962f, 0.18292078f, -0.25634712f, -0.33189499f, -0.08724931f, 0.05188362f, 
    0.04597966f, 0.11114272f, -0.05582555f, -0.02774171f, -0.45818716f, -0.68181050f, -0.45664838f, 0.21962026f, 
    0.08609746f, 0.11079621f, 0.03632112f, -0.08610965f, 0.03788686f, 0.04872961f, 0.11364740f, -0.35823590f, 
    0.60171777f, -0.37159169f, 0.08893609f, 0.18725704f, -0.12438811f, 0.02352701f, -0.23577467f, -0.10194477f, 
    -0.00737375f, 0.09376653f, -0.10718493f, -0.16187638f, 0.06738976f, -0.26788041f, 0.16335048f, -0.04705409f, 
    -0.08771975f, -0.14480747f, -0.05770938f, 0.01226035f, 0.07525780f, -0.11724126f, -0.06933978f, -0.07614717f, 
    0.01536791f, 0.24356252f, 0.06542885f, 0.06599953f, -0.14535940f, -0.13610186f, 0.16283606f, 0.22033657f, 
    0.04168677f, -0.01705953f, 0.13784257f, -0.00385769f, -0.24915612f, -0.07445131f, 0.19697817f, 0.14507180f, 
    -0.36101112f, -0.04958772f, -0.06625324f, -0.20659937f, 0.14136228f, -0.01963793f, 0.04213461f, 0.04016557f, 
    0.38581479f, -0.13944916f, -0.98025787f, -0.11962649f, 0.21257821f, 0.00890792f, 0.09748597f, 0.02684395f, 
    0.07454947f, 0.01501553f, -0.10052452f, 0.16545941f, -0.50126553f, -0.18830051f, -0.16289203f, 0.07807617f, 
    0.13469452f, 0.08182304f, -0.26764154f, -0.18173060f, -0.03189030f, 0.10814207f, -0.01810093f, -0.20551518f, 
    -0.28839487f, -0.73269212f, -0.37673143f, -0.08385096f, -0.20917016f, -0.03987468f, 0.15619415f, 0.02554712f, 
    -0.18422940f, 0.13383695f, -0.20043713f, 0.17667167f, 0.14478356f, -0.64955771f, 0.05904925f, -0.26860431f, 
    0.11583925f, 0.11532677f, 0.00845599f, 0.29139829f, 0.06553168f, 0.05962567f, -0.07709941f, 0.07466415f, 
    0.03925582f, 0.39273560f, -0.04568838f, 0.24295945f, -0.16295256f, -0.22422680f, -0.00286114f, -0.10380402f, 
    -0.23275548f, -0.06537788f, 0.00648542f, 0.08861379f, -0.07336885f, -0.04087916f, 0.11100620f, 0.05666695f, 
    0.06178065f, -0.08820160f, 0.01275656f, -0.15905258f, 0.09290680f, -0.06283281f, 0.09543496f, 0.43283230f, 
    0.14430119f, 0.75458497f, 0.12209640f, 0.37252733f, 0.16195306f, 0.02219233f, 0.07497306f, 0.18544297f, 
    0.04413609f, -0.14648679f, -0.06365705f, -0.08977087f, -0.06323013f, 0.01972296f, 0.00538897f, 0.01466055f, 
    -0.30390546f, 0.19243667f, -0.24198832f, 0.15886392f, -0.08840410f, -0.20937535f, -0.04271112f, -0.13942173f, 
    -0.25632495f, 0.02562056f, -0.41498360f, 0.07730123f, -0.05396185f, 0.02142392f, 0.07502376f, -0.36047769f, 
    0.30158582f, -0.02051845f, -0.06306557f, 0.04106542f, -0.10369782f, -0.19016781f, 0.30463368f, -0.12474418f, 
    0.04226487f, -0.13237733f, -0.54006243f, 0.04846645f, -0.28109300f, -0.37366834f, -0.08880501f, -0.22918668f, 
    0.22093491f, 0.42402384f, -0.02631104f, 0.61055112f, 0.08022998f, 0.01635023f, -0.00379409f, 0.28562024f, 
    0.05575170f, -0.11513280f, -0.13781185f, -0.22423016f, 0.07508024f, 0.11188101f, -0.00237228f, -0.03073832f, 
    0.19685687f, 0.10242763f, 0.05987151f, 0.07265665f, 0.11244338f, -0.02562763f, -0.19001941f, 0.01589076f, 
    -0.02032104f, 0.16897039f, -0.02720395f, -0.14108789f, 0.15409249f, 0.08369377f, 0.10324617f, -0.01345272f, 
    0.20389310f, 0.09497051f, -0.02461298f, 0.14894907f, -0.97027737f, -0.09525835f, -0.60022128f, -0.17047508f, 
    -0.00645262f, -0.10230991f, -0.12802801f, -0.00892936f, 0.03281738f, 0.04100641f, -0.00228200f, 0.11583052f, 
    0.24534686f, 0.32202107f, 0.16336560f, -0.01882830f, 0.47502387f, 0.03457024f, -0.28160504f, 0.05627612f, 
    -0.06113827f, -0.07182304f, 0.13511124f, 0.05575747f, -0.36079371f, 0.20176245f, 0.05724499f, -0.34876254f, 
    0.34982175f, -0.24778378f, 0.27488735f, 0.27387166f, -0.07690134f, 0.00599254f, 0.20632617f, 0.09866021f, 
    -0.89489615f, 0.20284580f, -0.30522847f, 0.16846727f, 0.04956323f, -0.03212276f, -0.14092581f, 0.08549061f, 
    0.09367783f, -0.02728765f, -0.15432407f, -0.05269940f, 0.61463821f, 0.30627406f, -0.41430014f, 0.26874390f, 
    0.02582967f, -0.01458289f, -0.20321748f, 0.02878206f, 0.11188462f, -0.05779521f, -0.00528171f, -0.05390229f, 
    -0.06992617f, -0.93308008f, 0.68403888f, 0.57423556f, -0.09815998f, -0.01377872f, -0.10625108f, -0.01232687f, 
    0.01895423f, -0.01543142f, 0.10183333f, 0.00296875f, -0.12269372f, -0.18266328f, -0.45193484f, -0.00924372f, 
    0.09852842f, -0.00183888f, 0.11928830f, -0.12133121f, 0.08404414f, -0.00709366f, -0.17709237f, -0.15607667f, 
    -0.36952201f, -0.00080501f, -0.07130419f, -0.36979619f, -0.05626148f, 0.08783188f, -0.04194552f, 0.06353563f, 
    0.24830216f, -0.04562931f, -0.24850033f, -0.11851863f, 0.19031459f, -0.31124008f, -0.13478573f, -0.56489545f, 
    -0.07276276f, 0.01588595f, 0.07235534f, 0.25782239f, -0.03605954f, -0.40189263f, -0.02039559f, -0.43784520f, 
    0.15636459f, 0.18650408f, 0.12103199f, -0.03511884f, -0.01902519f, -0.11217663f, -0.00133535f, -0.15055133f, 
    0.06738258f, -0.06373411f, 0.04454783f, 0.03499293f, -0.16405970f, -0.15806958f, 0.02931104f, 0.02522539f, 
    0.15719128f, -0.05242203f, -0.04175105f, -0.02444379f, -0.02841771f, 0.42934239f, -0.11884881f, 0.10977159f, 
    -0.13107008f, -0.35301504f, 0.04741453f, 0.23402579f, -0.01880529f, 0.02171967f, 0.07240001f, 0.00967039f, 
    -0.01307161f, 0.23574273f, -0.09336267f, -0.11046060f, 0.32312825f, -0.06290394f, -0.03362123f, -0.12267204f, 
    -0.17466272f, 0.18448626f, 0.09454089f, -0.03848787f, -0.01042874f, -0.24074005f, 0.08600829f, 0.50522631f, 
    -0.32856417f, -0.06552760f, -0.39480752f, 0.46240860f, 0.49166229f, 0.07793639f, -0.09248919f, 0.05434695f, 
    0.00753110f, 0.03212645f, 0.05597242f, 0.11908742f, -0.10093229f, -0.22790313f, -0.15528627f, 0.06535093f, 
    0.05780249f, -0.23232886f, -0.14226623f, -0.10743800f, 0.17651357f, -0.01492612f, -0.06229752f, 0.17178552f, 
    -0.34087348f, -0.36734936f, -0.34913671f, 0.20745903f, -0.07572841f, -0.34129089f, -0.43919426f, -0.15006237f, 
    -0.12495920f, -0.02536581f, 0.06398096f, -0.24716406f, -0.39636019f, 0.14339507f, 0.87378007f, 0.28389466f, 
    -0.08737463f, 0.11243147f, 0.05822173f, -0.01490454f, 0.11122297f, 0.21054734f, 0.19190687f, 0.16707055f, 
    -0.75552434f, -1.34983432f, -0.29085144f, 0.00353741f, -0.27153516f, -0.25038791f, -0.08132908f, -0.36474127f, 
    0.03279042f, 0.02428719f, -0.07852191f, -0.04437618f, -0.92550719f, -0.37907925f, 0.28468713f, -0.13817106f, 
    0.08855966f, -0.03785174f, -0.16996551f, -0.12803461f, -0.02954839f, 0.01872790f, -0.05685107f, -0.04208431f, 
    0.02977709f, 0.14302561f, -0.34681499f, 0.06935482f, 0.09899894f, 0.01957663f, -0.09011034f, -0.04010677f, 
    0.12746948f, 0.18025272f, 0.24716455f, -0.15184174f, 1.31646740f, 0.18784617f, -1.16997588f, -0.66388917f, 
    -0.12597865f, -0.44346881f, 0.43734398f, 0.30246079f, 0.08313612f, 0.26579842f, -0.33022159f, -0.18877017f, 
    -0.04773849f, -0.03218532f, -0.27996230f, 0.08010570f, -0.23292269f, 0.02910080f, -0.13230480f, 0.30318165f, 
    0.08443438f, 0.13961948f, 0.22577982f, 0.20258090f, -0.21606365f, -0.28911692f, -0.09499834f, -0.19740582f, 
    0.23966928f, 0.05956168f, 0.21657950f, -0.19387527f, -0.03436071f, 0.06249438f, -0.01560481f, 0.15330803f, 
    -0.65519464f, 0.00604955f, -0.17833188f, 0.25815523f, -0.19183916f, -0.08003864f, -0.21009749f, 0.33085728f, 
    -0.14627838f, -0.10133527f, 0.19405006f, 0.06212985f, -0.19285856f, 0.55261582f, 0.00281990f, 0.38408014f, 
    0.06428172f, 0.23679133f, 0.12768020f, 0.13538916f, 0.05158618f, 0.22810340f, 0.12251756f, -0.08549696f, 
    -0.63029522f, -2.24153781f, -0.45720381f, -0.79537165f, 0.16765630f, -0.15511774f, 0.09808877f, -0.29348344f, 
    0.01530819f, -0.10233770f, -0.07750391f, -0.05986477f, -0.05670149f, -0.01024901f, -0.11382085f, 0.03344435f, 
    0.14156666f, 0.18449120f, -0.13730702f, 0.21109915f, -0.04849673f, -0.09757797f, 0.02104312f, 0.04715550f, 
    0.26395708f, -0.02919591f, -0.04957986f, -0.12080037f, -0.15459898f, 0.10436600f, 0.27338052f, 0.16760714f, 
    -0.08716690f, 0.17682225f, 0.34565368f, -0.13565935f, -0.17568132f, 0.00024890f, 0.00073530f, 0.30992985f, 
    0.20248927f, -0.17872123f, -0.18431480f, 0.54442918f, -0.19671880f, 0.31275246f, -0.10963021f, -0.17194869f, 
    -0.17241703f, -0.33899075f, -0.21756633f, -0.41062856f, -0.08240415f, 0.12533934f, 0.46591088f, -0.18994437f, 
    -0.06872559f, 0.08217718f, 0.08003839f, 0.02055514f, 0.18642673f, 0.00635883f, -0.19558024f, -0.25223839f, 
    0.04204478f, 0.00972749f, 0.10232661f, -0.01323509f, -0.22422518f, -0.14083339f, -0.32454574f, -0.23273540f, 
    0.54215699f, -0.02430555f, 0.13251474f, -0.07395449f, -0.10977828f, -0.10929938f, 0.27979833f, 0.46013060f, 
    0.07508058f, 0.11489121f, 0.03772787f, 0.11980297f, 0.72753018f, 0.42903259f, -0.29072574f, -0.43001306f, 
    0.10271030f, -0.07920489f, -0.16277774f, -0.01868207f, 0.00015617f, 0.07130144f, 0.00960387f, -0.34973252f, 
    -0.52232486f, -0.03455615f, -0.02306487f, 0.08574624f, 0.24295594f, -0.09215786f, 0.08580121f, 0.36356851f, 
    -0.00299246f, -0.05117022f, -0.14587031f, -0.02453044f, -0.19916525f, -1.00540078f, -0.27602947f, -0.81204331f, 
    -0.17341743f, -0.05786659f, -0.16102800f, 0.08824828f, 0.15948033f, -0.04999623f, 0.04575635f, -0.08906757f, 
    -0.04303969f, -0.25478357f, 0.22097833f, -0.10812118f, 0.03809900f, 0.03843599f, 0.02368405f, -0.10054614f, 
    0.20223491f, -0.00576194f, 0.06390822f, -0.07792962f, -0.88975787f, -0.25305104f, -0.09897045f, 0.45705304f, 
    -0.09670727f, 0.00963518f, 0.08219808f, -0.07068287f, 0.04716215f, -0.17776562f, 0.14665315f, 0.00555239f, 
    0.77884388f, -0.67406023f, 0.18651128f, -0.56640565f, 0.05633422f, 0.07994545f, -0.10098995f, -0.17060800f, 
    0.06687730f, 0.22641191f, -0.11911166f, -0.20949326f, 0.24344386f, 0.20044963f, 0.15364251f, -0.44382539f, 
    -0.03663926f, -0.01990658f, 0.09407401f, -0.01134067f, 0.00446904f, 0.07397880f, -0.00089932f, 0.04590658f, 
    0.54704994f, -1.22862017f, -1.29714143f, -0.88087612f, -0.04532101f, -0.17774424f, -0.18791558f, -0.05986170f, 
    0.10274141f, 0.22123000f, 0.00525947f, 0.07011674f, -0.53331828f, -0.36374262f, -0.04715588f, -0.08658037f, 
    -0.26271042f, -0.17365980f, 0.16255461f, -0.00827228f, -0.04049771f, 0.02285071f, 0.33689111f, -0.00725403f, 
    -1.48158360f, 0.23822379f, -0.46429053f, 0.93699861f, -0.19434887f, 0.21214736f, 0.09426282f, 0.04660831f, 
    -0.07609638f, -0.08851010f, -0.14680113f, -0.04595940f, -0.02456699f, 0.09660768f, -0.10994120f, 0.02207742f, 
    -0.28451851f, -0.27576244f, 0.10611181f, -0.05969045f, -0.00899154f, 0.11812145f, -0.05932540f, -0.01870297f, 
    0.06214079f, 0.04210142f, -0.00640432f, 0.07000414f, -0.15922093f, 0.01777583f, 0.03220003f, -0.19745971f, 
    -0.09975551f, -0.40859109f, -0.25462922f, 0.22738025f, 0.10350601f, 0.10265609f, -0.28189057f, 0.09178868f, 
    -0.08827983f, 0.14086318f, 0.12288205f, -0.03444420f, 0.01024517f, -0.10276573f, -0.01868954f, -0.22526255f, 
    -0.23464720f, 0.49480984f, -0.53885013f, 0.06485959f, 0.10757758f, 0.02455889f, -0.23524055f, -0.23318292f, 
    0.05574208f, 0.12305388f, 0.00436133f, 0.03573240f, 0.03359058f, 0.12261964f, -0.07123611f, 0.06105433f, 
    0.05968029f, 0.01285187f, -0.08002159f, -0.11343963f, 0.00661197f, -0.11367961f, -0.03341130f, -0.09137542f, 
    -0.00242399f, -0.37017751f, -0.55274659f, -0.65869260f, -0.36131218f, -0.24054332f, -0.07691921f, -0.13203973f, 
    -0.01482916f, 0.23421323f, 0.10822537f, 0.19455059f, -0.10094888f, -0.50027394f, -0.17352079f, -0.19940011f, 
    -0.32783517f, 0.08924869f, 0.17713164f, 0.05929954f, 0.06658330f, 0.02282481f, 0.12429813f, -0.13257349f, 
    0.20198826f, -0.40992200f, -0.37748170f, -0.01670881f, -0.13990389f, 0.06367975f, 0.04905593f, -0.39402097f, 
    -0.03870865f, -0.11153350f, -0.02287164f, 0.09550600f, 0.15869153f, -0.14300124f, -0.62874854f, 0.05126488f, 
    0.17334813f, 0.15302259f, 0.32271850f, 0.07468791f, -0.17174789f, 0.05631341f, -0.20846567f, 0.11574021f, 
    -0.65731788f, 0.27401662f, 0.29074210f, -0.37343433f, -0.22957538f, -0.13686572f, -0.08413508f, -0.18483493f, 
    -0.24938241f, 0.02906692f, -0.09835009f, -0.04520155f, -0.99085432f, 0.36770791f, 0.08899733f, 0.50575292f, 
    0.14692628f, 0.07134313f, -0.08525825f, 0.24588643f, -0.10644525f, 0.06948608f, 0.20208876f, 0.41421825f, 
    0.67899084f, 0.12803400f, -0.51095653f, -0.95654923f, 0.22583193f, -0.15186773f, 0.09435325f, -0.07270890f, 
    0.18781494f, 0.18229038f, 0.27939326f, 0.25950775f, -0.52236825f, 0.08429357f, 0.36511868f, 0.03717048f, 
    -0.09530688f, -0.11792731f, -0.12968095f, -0.33585542f, -0.18860018f, -0.24552462f, 0.03271221f, -0.01404193f, 
    -1.06468654f, -1.23448932f, -0.72422189f, -0.13137986f, 0.24658111f, 0.57678688f, 0.29246578f, 0.14887023f, 
    0.08638527f, -0.10857388f, 0.04534536f, 0.09649041f, -0.43609220f, -0.60598409f, 0.07374309f, 0.33441558f, 
    -0.01402857f, 0.32062775f, 0.14483756f, 0.00451057f, -0.18481648f, -0.07485424f, -0.32666165f, -0.47146451f, 
    -0.35388520f, 0.08503607f, 0.06602117f, -0.13132626f, 0.25497591f, -0.24045286f, -0.29507801f, -0.11987660f, 
    -0.00077305f, 0.02312358f, 0.03044098f, -0.02515387f, 0.02635039f, 0.06499624f, -0.01583773f, 0.06728482f, 
    0.26661307f, -0.01281251f, 0.05721844f, -0.06908063f, 0.09393326f, 0.12632827f, 0.33894134f, 0.29529232f, 
    -0.48144940f, 0.12236460f, 0.11684620f, -0.23057678f, 0.16601613f, 0.10296577f, 0.07253364f, 0.05683846f, 
    -0.42803597f, -0.28865778f, -0.06571591f, -0.19640090f, 0.14840536f, -0.15138561f, -0.11758810f, -0.13050556f, 
    -0.02621719f, -0.08324131f, 0.07976148f, 0.03257032f, 0.36181015f, 0.29184604f, 0.01103387f, 0.39631829f, 
    -0.06901868f, 0.25425777f, 0.34465596f, 0.27551877f, 0.17613484f, -0.08181222f, -0.23552008f, -0.24952391f, 
    -0.01095894f, 0.14784390f, 0.20699780f, 0.09376216f, -0.57974023f, 0.16486837f, -0.05998355f, -0.17603412f, 
    -0.08794758f, 0.05719303f, -0.15710017f, -0.03324458f, 0.06512861f, 0.08309182f, 0.06310828f, 0.17981136f, 
    -0.30147269f, -0.14145249f, 0.34684432f, -0.18813758f, 0.11523840f, 0.16020387f, -0.20904253f, 0.28899494f, 
    -0.31856135f, -0.20882308f, -0.10764581f, -0.10792515f, 0.12014121f, 0.40552652f, 0.18306372f, 0.47553480f, 
    0.02455915f, 0.09542861f, -0.49320605f, -0.18936913f, 0.09931228f, -0.13848229f, -0.02313009f, 0.08574174f, 
    -0.66454148f, 0.57844973f, 0.57620609f, -0.53404981f, 0.09254065f, -0.32717478f, 0.00701695f, 0.34680963f, 
    -0.05441888f, 0.07049032f, 0.05761950f, 0.04714496f, -0.11097465f, -0.35111415f, -0.13523881f, -0.28223690f, 
    -0.38331047f, 0.16868351f, -0.14818098f, 0.02906946f, 0.22239015f, 0.01600943f, 0.00017344f, 0.10032522f, 
    -0.01107207f, -0.42963174f, -0.06087659f, -0.11012134f, -0.11451603f, 0.34883130f, 0.09699186f, -0.19597754f, 
    0.00188971f, 0.27635771f, 0.11184920f, -0.07300024f, -0.68671429f, 0.89280796f, -0.13080889f, -0.45361060f, 
    -0.08476546f, -0.46806747f, 0.21770516f, -0.19914782f, 0.10832152f, 0.11872112f, -0.09254003f, 0.06253344f, 
    0.05863084f, 0.11231997f, 0.09952110f, 0.72948539f, 0.08738700f, 0.05560432f, -0.04947324f, -0.24011904f, 
    0.03479750f, -0.12939817f, 0.02558253f, 0.02855144f, 0.02189034f, -0.70653814f, 0.21757823f, -0.16942436f, 
    0.25264242f, 0.06222191f, 0.06511470f, 0.20035180f, -0.12654684f, 0.00558188f, -0.03883404f, 0.03651280f, 
    0.00624007f, -0.39839742f, 0.15404075f, -0.11033244f, -0.26247674f, -0.33672404f, -0.07583184f, -0.10815825f, 
    -0.07610745f, -0.12498400f, 0.23092914f, 0.10324766f, 0.01131930f, -0.05653325f, 0.91251749f, -0.80645865f, 
    0.07956772f, 0.08667820f, -0.23537543f, 0.03843773f, 0.01054960f, -0.01017275f, 0.16043471f, 0.05690430f, 
    0.31525528f, 0.08049700f, -0.55291706f, -0.20221709f, -0.00100131f, -0.10655396f, 0.22770764f, 0.23743056f, 
    -0.00981222f, 0.08594876f, 0.10454060f, -0.13683523f, 0.06788379f, 0.00728442f, -0.43423027f, 0.01680610f, 
    0.27491644f, -0.34436068f, -0.00323525f, 0.03834848f, 0.10560327f, -0.23300013f, -0.19730023f, -0.08446913f, 
    -0.07335016f, 0.41948244f, -0.62389839f, 0.13452359f, 0.25525045f, -0.04964809f, 0.25077698f, -0.04539365f, 
    0.15868667f, -0.00666817f, 0.17819919f, 0.18898751f, -0.25015610f, -0.19546005f, 0.08290559f, -0.18177615f, 
    0.21151301f, -0.56637853f, 0.03602766f, -0.10987636f, -0.08123877f, -0.18613422f, -0.41810560f, -0.25810745f, 
    -0.48339635f, -0.34184554f, -1.07441592f, -0.01078523f, 0.28498688f, 0.08729523f, 0.01716407f, 0.17054147f, 
    -0.01488263f, -0.26261824f, -0.14497297f, -0.06408550f, -0.03313298f, 0.07424818f, 0.00006592f, 0.04678376f, 
    0.24025679f, 0.12356709f, 0.14022976f, 0.01589915f, 0.20177943f, 0.02493240f, -0.10404009f, 0.08110953f, 
    -0.25504112f, 0.28200999f, -0.14683627f, 0.35347733f, -0.26684043f, -0.02180331f, -0.47677538f, 0.17024888f, 
    0.22255765f, 0.16117276f, 0.23548943f, 0.35999095f, 0.10427041f, 0.56886351f, 0.15914054f, 0.02546891f, 
    0.20263951f, -0.18870811f, -0.11901677f, -0.06692556f, -0.20043138f, 0.30016786f, 0.06631866f, -0.03621663f, 
    -0.19928069f, -0.72047591f, -0.29335466f, 0.33271822f, -0.01753585f, 0.08805852f, -0.24581745f, -0.08949210f, 
    0.11462033f, 0.01398070f, -0.07979158f, -0.06704558f, 0.05101477f, 0.04272901f, -0.20369013f, 0.26701891f, 
    -0.13899788f, -0.12215181f, 0.01169325f, 0.33439317f, -0.29366967f, 0.14333029f, 0.17407568f, -0.02488400f, 
    0.21907423f, 0.35128665f, 0.01074726f, 0.13154025f, -0.24312335f, -0.26740935f, 0.04546737f, -0.32262442f, 
    -0.08097517f, 0.07824434f, -0.06573525f, 0.13021347f, 0.03708197f, 0.00180294f, -0.09433652f, 0.02807511f, 
    -0.32561517f, 0.19374952f, 0.36331725f, -0.24528195f, -0.27437383f, -0.23068132f, 0.03284502f, 0.48099023f, 
    -0.92489064f, 0.61338675f, -0.26778421f, -0.14512073f, -0.02964604f, 0.12851776f, 0.10692707f, 0.23704974f, 
    -0.14457011f, -0.06063207f, -0.26871082f, -0.27290192f, -0.27153075f, -0.26567551f, -0.49413621f, 0.03301885f, 
    -0.22814758f, 0.08983368f, -0.73013508f, 0.29528534f, 0.13180330f, -0.03707351f, -0.03764839f, -0.08698299f, 
    -0.23682274f, 0.37755239f, -0.25268686f, -0.01952699f, -0.18222304f, -0.02450616f, 0.20893370f, 0.04661772f, 
    -0.11530665f, 0.22159895f, -0.11502211f, -0.25002080f, -0.33105248f, 0.07437304f, -0.34247494f, 0.27046320f, 
    0.18846732f, -0.28275272f, -0.23304032f, 0.16587260f, -0.00525129f, -0.17183226f, -0.49788737f, -0.68219721f, 
    -0.17800996f, -0.53914970f, -0.08968111f, 0.48428452f, -0.06078745f, -0.29862267f, 0.30932698f, -0.16379502f, 
    0.09608702f, 0.07270556f, -0.07401745f, 0.14870948f, 0.05138942f, 0.31309953f, 0.24036609f, -0.11421368f, 
    -0.12174144f, 0.21084325f, -0.00827339f, 0.00440279f, 0.13016167f, 0.17036872f, 0.11689421f, 0.28206608f, 
    0.09408455f, -0.01478139f, -0.10370914f, -0.14098482f, -0.34918830f, -0.23807186f, 0.10556274f, 0.10922581f, 
    -0.59528023f, -0.22261654f, -0.59064996f, -0.09715315f, -0.02414227f, 0.14041406f, -0.08063083f, 0.93915248f, 
    -0.22543123f, 0.43551287f, -0.04364945f, 0.22353275f, 0.19016843f, -0.17404073f, 0.36768308f, 0.46679065f, 
    0.24351998f, -1.36432755f, 0.43787652f, -0.67379141f, -0.29433724f, 0.39027435f, 0.26622531f, 0.10245769f, 
    0.14958642f, 0.03653583f, 0.06203980f, 0.08906510f, -0.04405117f, -0.34941402f, -0.28970444f, -0.73518616f, 
    -0.05044996f, -0.05409769f, -0.17687069f, -0.16385894f, -0.06828853f, 0.42391571f, 0.05957554f, 0.19605534f, 
    -0.51608622f, 0.06231200f, 0.06274933f, 0.27507398f, 0.14524670f, 0.20890029f, -0.00728322f, -0.24025516f, 
    -0.22906096f, -0.46156743f, -0.10973814f, -0.30622828f, -0.84405935f, -0.04948943f, -0.79952693f, 0.21875024f, 
    0.09116216f, 0.04912575f, 0.09160589f, -0.07589856f, -0.07592807f, -0.02313162f, -0.05263314f, -0.02973666f, 
    -0.32055584f, -0.38708028f, -0.22399525f, -0.15775931f, -0.02708821f, 0.02393655f, -0.30875701f, -0.11897985f, 
    0.02265467f, 0.09042592f, -0.05136942f, -0.17130005f, 0.27533796f, 0.24750613f, -0.09707889f, 0.32107484f, 
    -0.38706651f, 0.01560736f, 0.35579538f, -0.53652740f, 0.01240661f, 0.01543673f, 0.11562923f, -0.30253795f, 
    -0.15333299f, 0.34522656f, 0.09753411f, 0.03184814f, -0.16615944f, 0.10540370f, -0.15470558f, -0.10260025f, 
    -0.15532795f, -0.03618764f, 0.10531353f, 0.03446429f, 0.43364087f, -0.56926590f, 1.10224104f, -0.28401205f, 
    0.25591320f, 0.05843764f, -0.01926124f, 0.34837568f, -0.49701270f, 0.17928658f, 0.18385373f, 0.10459197f, 
    -0.20550001f, -0.49521258f, -0.30181500f, 0.24445248f, 0.19333827f, -0.21052697f, 0.13588062f, 0.01134230f, 
    0.23556651f, 0.20636000f, 0.26519170f, 0.17117272f, 0.31498036f, 0.53880537f, 0.27930054f, -0.12518096f, 
    -0.22223024f, -0.25557527f, 0.33857724f, 0.42836392f, -0.11903048f, -0.07448865f, -0.05072255f, -0.00302984f, 
    -0.47067481f, 0.50882441f, -0.43079677f, -0.42146862f, 0.08730201f, -0.28050536f, 0.15567215f, 0.04740774f, 
    0.11643516f, 0.22378945f, -0.19464983f, 0.12323925f, -0.69744825f, 0.23631689f, -0.43263471f, -0.18987273f, 
    0.02337873f, 0.15046503f, 0.08479780f, 0.34289163f, 0.02732692f, 0.28877163f, 0.13723432f, 0.15863766f, 
    0.15138438f, -0.63814425f, 0.31312180f, 0.14254759f, -0.45015863f, -0.14364719f, -0.52431136f, -0.08707963f, 
    0.15994684f, -0.01670491f, 0.15977766f, 0.13744844f, 0.54080659f, -0.34168360f, 0.37858438f, -0.37056205f, 
    0.11312057f, 0.02949281f, -0.16273345f, 0.03400060f, -0.31296635f, -0.37846485f, -0.16381586f, -0.20771934f, 
    0.40544891f, -0.11636573f, 0.26142743f, -0.14575623f, 0.16209804f, 0.23297112f, -0.04973897f, 0.26302615f, 
    -0.07932065f, 0.01855402f, 0.34482402f, -0.10862867f, 0.26418936f, -0.14909190f, 0.25530532f, -0.31176451f, 
    -0.11289048f, 0.11918855f, -0.40139019f, 0.31176838f, -0.13698956f, 0.16351902f, 0.03228462f, -0.41451043f, 
    0.43622053f, 0.29403588f, 0.63104826f, -0.41005716f, -0.03973981f, -0.12135053f, -0.22135998f, 0.02604680f, 
    -0.11776996f, -0.07924638f, -0.13898993f, -0.12763016f, 0.09203766f, -0.03224465f, 0.11583197f, -0.07889648f, 
    -0.09091767f, 0.01102478f, 0.09529251f, 0.21735635f, -0.25618824f, -0.00973711f, 0.00536074f, -0.29047576f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.36679029f, 0.07138713f, 0.19444479f, -0.14951265f, -0.12258263f, 0.13049415f, 0.14268015f, -0.18414663f, 
    0.07322814f, -0.01016424f, 0.10999442f, -0.11095598f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
