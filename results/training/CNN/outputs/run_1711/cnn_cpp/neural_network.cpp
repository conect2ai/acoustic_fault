#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.14966486f, -0.13870195f, 0.16310300f, 0.31682736f, 0.16957672f, 0.15863764f, -0.08066785f, -0.06828650f, 
    0.11346281f, -0.04091607f, -0.14789860f, 0.17825627f, -0.06168917f, 0.28077400f, -0.25442946f, -0.03201070f, 
    -0.05231367f, -0.02910613f, -0.12463056f, -0.15491997f, 0.34651172f, -0.31355491f, -0.38938221f, 0.11348801f, 
    0.19626679f, -0.40403026f, -0.04707213f, -0.04495572f, 0.22604494f, 0.30079854f, -0.55134881f, 0.47505131f, 
    -0.10397371f, -0.10917560f, 0.34862316f, -0.00176378f, -0.32823026f, -0.22304401f, 0.07683763f, 0.19070995f, 
    0.09382685f, -0.33324057f, 0.19712891f, 0.15667886f, -0.44344455f, 0.26314116f, 0.13132130f, -0.27463728f, 
    0.34473544f, 0.00143295f, -0.42543766f, -0.75499284f, 0.08383651f, 0.54897755f, 0.58790690f, -0.22607532f, 
    0.20722422f, 0.06478667f, -0.34483555f, -0.29661095f, 0.13936898f, -0.06102544f, -0.00286376f, -0.28780392f, 
    -0.22593385f, -0.08204751f, -0.31741849f, 0.29747412f, 0.24815337f, 0.03239634f, -0.21057758f, -0.44713947f, 
    -0.03189404f, 0.36685872f, -0.00898512f, -0.61830539f, -0.09275621f, 0.37034741f, 0.57049680f, 0.06129281f, 
    0.18898858f, -0.14211006f, -0.29983261f, -0.06465659f, -0.27273887f, 0.07012507f, -0.46152359f, -0.06669333f, 
    0.00559320f, -0.18513791f, -0.23840868f, 0.19277799f, 0.08406753f, -0.11942055f, 0.07069506f, 0.20081212f, 
    -0.08579129f, -0.19819753f, -0.01236654f, 0.03314528f, -1.05185485f, 0.58258206f, -0.36746338f, -0.89783710f, 
    -0.18897854f, 0.12876622f, 0.15292612f, 0.03644395f, 0.35109469f, 0.11860560f, 0.08525734f, 0.19443427f, 
    -0.08420119f, -0.32641274f, -0.18134332f, -0.11793768f, -0.06926566f, -0.29706228f, -0.28733042f, -0.27918509f, 
    -0.12022779f, -0.03070206f, -0.25925973f, -0.38877574f, -0.52171153f, 0.21995026f, -0.44599429f, -0.09868415f, 
    -0.11044505f, -0.05423708f, 0.39273986f, -0.35169071f, -0.25977615f, 0.13225535f, 0.48296115f, 0.31414500f, 
    -0.26737493f, -0.03918929f, 0.36037898f, -0.26687726f, -0.21181552f, -0.34793520f, 0.00860677f, 0.11289480f, 
    -0.04132717f, -0.21302921f, -0.07948374f, 0.14984843f, 0.22129761f, 0.32659787f, 0.37840861f, 0.50177652f, 
    0.35330820f, 0.17122443f, 0.16206400f, -0.35378575f, -0.39656666f, -0.05829164f, 0.16444778f, 0.27117115f, 
    0.15388462f, -0.05324466f, -0.02623556f, 0.04924822f, -0.03744852f, -0.24010302f, 0.07531706f, -0.09824160f, 
    0.04462244f, -0.19852817f, -0.09594835f, 0.04187622f, -0.10306817f, 0.02363570f, 0.06175021f, -0.88406885f, 
    -0.19761926f, -0.42427489f, -0.74737698f, -0.84457344f, 0.47291663f, 0.06097215f, -0.59123021f, -0.00484959f, 
    0.64994413f, -0.29030368f, -0.24629080f, -0.08612529f, -0.21591128f, -0.09049708f, 0.05294220f, 0.08734138f, 
    -0.14973022f, -0.00988401f, -0.20648286f, -0.00883339f, -0.09524026f, -0.04017238f, -0.04217612f, 0.32569787f, 
    0.37685919f, 0.15533972f, 0.02712388f, -0.94066131f, -1.10785019f, 0.20761396f, 0.54287350f, 0.31387770f, 
    0.20103273f, 0.09722394f, -0.07692846f, 0.27071142f, -0.07759546f, 0.08211535f, -0.23705514f, -0.23445076f, 
    -0.21882872f, -0.17240395f, 0.23761502f, 0.06316181f, 0.07034033f, 0.04982962f, 0.09558000f, 0.12218312f, 
    0.04227385f, -0.23074849f, -0.18339507f, -0.30860373f, -0.26645347f, -0.48470297f, 0.26251167f, -0.01557636f, 
    -0.25997442f, -0.23168281f, 0.05825553f, 0.27440101f, 0.03048009f, -0.24633047f, -0.47201315f, -0.33517686f, 
    0.01172810f, 0.06928877f, 0.01707121f, 0.04398019f, 0.08366180f, 0.20942557f, 0.03988218f, 0.05679789f, 
    0.19972622f, 0.24318886f, -0.03137641f, 0.47122729f, 0.44286153f, 0.22603863f, -0.01463756f, 0.10710081f, 
    -0.03073319f, -0.22872694f, -0.41719019f, -0.33722910f, 0.09727582f, -0.28347823f, -0.05433173f, -0.05126392f, 
    0.20112790f, 0.16247438f, 0.14726131f, 0.05022498f, 0.15572554f, -0.09090198f, -0.03411637f, -0.20859487f, 
    -0.25758997f, -0.28404087f, -0.45240229f, -0.40190202f, -0.47351173f, -0.26671648f, 0.30271313f, 0.49543995f, 
    0.31330013f, 0.26020545f, 0.35457179f, -0.35509521f, 0.23748276f, -0.23107357f, -0.20739271f, -0.15138270f, 
    -0.27273485f, -0.14184757f, 0.21196945f, 0.08750673f, -0.20216621f, -0.03574342f, 0.19734441f, -0.12696588f, 
    -0.30665332f, -0.16455273f, 0.06731239f, -0.26940113f, -0.97032189f, -0.14899796f, 0.17948154f, 0.01309959f, 
    0.08986159f, 0.11188583f, 0.16394447f, 0.29068232f, 0.09889443f, 0.25770697f, -0.20249833f, -0.13008927f, 
    0.28892061f, -0.10765715f, -0.07817776f, 0.10082719f, -0.31547463f, -0.28505728f, -0.21989991f, 0.08825124f, 
    0.03644185f, 0.19303614f, 0.31474885f, 0.11047106f, 0.13640951f, -0.51802438f, -0.23981507f, 0.16915740f, 
    0.31650248f, 0.35873470f, -0.44692072f, -0.39365453f, 0.27409139f, 0.45975196f, -0.07967793f, 0.09643177f, 
    -0.15405855f, 0.03138367f, 0.25104684f, 0.13871630f, -0.13066870f, 0.01270466f, -0.03641595f, -0.22370411f, 
    0.07134305f, -0.23334655f, -0.15319578f, -0.07578882f, 0.30971876f, 0.17717730f, 0.42552862f, 0.09239909f, 
    0.40506160f, -0.28090119f, -0.75309402f, 0.30029055f, 0.04098061f, 0.18948218f, -0.09248287f, -0.33055127f, 
    -0.18676864f, -0.17217310f, -0.03048746f, 0.12521218f, -0.04696894f, 0.08836748f, -0.03383479f, 0.18805987f, 
    -0.19916226f, -0.13350718f, -0.26703954f, -0.26291341f, -0.20137443f, -0.05629879f, -0.38196179f, -0.01564738f, 
    -0.03754548f, 0.17152868f, 0.18320556f, 0.25330353f, 0.01283872f, 0.28708336f, 0.04595762f, 0.00854733f, 
    0.18423747f, 0.07452626f, 0.12006706f, -0.10271737f, 0.05254706f, 0.00725095f, 0.27350396f, -0.04406237f, 
    0.16692157f, 0.24375512f, -0.13035479f, 0.12587433f, -0.20537098f, -0.16100702f, -0.02835853f, 0.12826248f, 
    0.58779705f, -0.14197938f, -0.57327473f, -0.26152393f, -0.08195508f, -0.07035357f, 0.05863884f, 0.26735306f, 
    -0.18152459f, 0.13233350f, 0.05173983f, 0.01113534f, 0.29766953f, 0.05843556f, 0.20434721f, 0.16015987f, 
    -0.15922169f, -0.29853961f, -0.24031368f, -0.23998868f, 0.16267005f, 0.21878722f, 0.31169447f, 0.29563099f, 
    -0.16216436f, -0.68394458f, -0.48078856f, -0.35794133f, -0.38142228f, -0.72953600f, -0.05865473f, -0.25407168f, 
    -0.36271173f, -0.48461357f, -0.43481860f, 0.51469404f, 0.26358697f, 0.64200932f, 0.47679490f, 0.28281653f, 
    -0.26644027f, -0.10607933f, -0.12237711f, -0.28458652f, -0.36167169f, -0.03075916f, 0.25129646f, 0.22219175f, 
    -0.21508314f, 0.22754192f, -0.79522914f, 0.19979900f, -0.14965490f, -0.32787070f, 0.37545341f, 0.12549488f, 
    -0.23143855f, -0.22511056f, 0.46611634f, 0.59688091f, -0.16966578f, 0.01796954f, -0.37936231f, -0.43065229f, 
    0.53533298f, 0.23255295f, 0.18344994f, 0.04984613f, 0.27142075f, -0.20425172f, 0.00062693f, -0.04037934f, 
    -0.18762179f, -0.15236916f, -0.25796947f, 0.13983493f, 0.18375020f, -0.12388279f, -0.11502517f, 0.28452742f, 
    -0.01491487f, 0.04250108f, 0.20031200f, -0.15583313f, -0.24506606f, -0.03113966f, -0.21015522f, -0.19274895f, 
    0.11286505f, -0.12638153f, -0.18443733f, -0.07275908f, -0.10968000f, -0.09135230f, -0.03445950f, -0.33401251f, 
    -0.31711212f, -0.51452774f, -0.51177090f, -0.60117710f, -0.40452752f, 0.51020086f, -0.13366514f, -0.26753762f, 
    0.20759185f, 0.22897808f, -0.22670273f, -0.16954879f, -0.03857239f, -0.28419051f, -0.18278080f, -0.35190794f, 
    0.63482529f, -0.60405219f, 0.03520154f, -0.14109010f, -0.28210834f, -0.23899251f, 0.22116151f, 0.22308998f, 
    -0.01847301f, -0.11755654f, -0.07068828f, 0.00630145f, 0.21849686f, -0.38584396f, -0.21368034f, 0.46103895f, 
    0.03925129f, 0.43301028f, -0.39865172f, -0.80625880f, -0.48297009f, 0.34565917f, 0.73112261f, 0.02614204f, 
    0.10114850f, -0.11805464f, 0.13396114f, 0.25379670f, 0.31961372f, -0.20912261f, 0.15770029f, -0.11467596f, 
    -0.23809884f, 0.06841465f, -0.12729466f, 0.17559348f, -0.10158567f, 0.03049131f, -0.60054845f, -0.42169672f, 
    -0.46549451f, -0.52493691f, -0.37339976f, 0.00851051f, -0.27277210f, -0.55585736f, -0.64807576f, -0.35497162f, 
    -0.23075169f, -0.20531708f, 0.02181965f, -0.03530856f, -0.23979181f, -0.14409651f, -0.30460832f, -0.32297638f, 
    -0.16339181f, 0.12003671f, -0.25285622f, -0.17639203f, -0.11612962f, -0.05771141f, -0.23102956f, 0.08321530f, 
    -0.04354158f, 0.11137924f, 0.04458442f, 0.09570169f, 0.25504154f, -0.10915031f, 0.04015507f, -0.08946293f, 
    0.09499981f, -0.12258368f, 0.23004681f, 0.08313404f, -0.17605889f, 0.28251955f, -0.27748564f, 0.06383517f, 
    -0.06168606f, -0.04100281f, -0.00204675f, 0.07570277f, -0.06275805f, 0.16938810f, 0.11472924f, -0.04009926f, 
    0.53697556f, -0.80980545f, -0.70970142f, -0.25820288f, 0.18110384f, 0.27797681f, 0.53911906f, 0.50267899f, 
    0.14610119f, -0.22663984f, -0.16260384f, -0.00369152f, -0.12906569f, -0.35702255f, 0.16882405f, 0.10562331f, 
    -0.18605033f, 0.08052635f, 0.14389151f, 0.01638697f, -0.07598200f, -0.07484899f, -0.22095655f, 0.17423697f, 
    0.19028759f, 0.15048942f, 0.37260434f, 0.03967886f, -0.26413050f, -0.05663455f, 0.37518206f, -0.21511997f, 
    -0.26156789f, -0.35675761f, -0.05674456f, 0.32418120f, -0.05583581f, 0.01122784f, -0.16598040f, -0.08397654f, 
    0.01621832f, 0.32017884f, 0.11697455f, -0.05953398f, -0.30466279f, -0.24934614f, -0.02007644f, 0.21793404f, 
    0.02734542f, 0.24831149f, -0.63213289f, -0.73895973f, 0.13713466f, 0.52133238f, -0.28900477f, 0.14696215f, 
    -0.64808524f, -0.08568589f, 0.50929755f, 0.41235489f, -0.22331247f, 0.08565865f, -0.26588884f, 0.08543088f, 
    0.02167337f, -0.05277978f, -0.21678443f, -0.26343337f, -0.16041304f, -0.14319105f, -0.25967050f, -0.30602023f, 
    0.07712920f, -0.01266588f, -0.22947367f, -0.28696710f, -0.44443369f, -0.36706537f, -0.58874762f, -0.26695776f, 
    -0.50437808f, -0.46076652f, -0.67631704f, -0.62245667f, -0.62280750f, 0.16536114f, 0.37568727f, -0.13138878f, 
    0.06820405f, -0.16819599f, -0.19939107f, -0.24162260f, 0.00491982f, -0.04685938f, -0.25028917f, -0.18690924f, 
    0.01899918f, 0.27031752f, 0.24316002f, -0.04572646f, 0.14910415f, -0.51025701f, -0.02961370f, 0.04988091f, 
    -0.62391233f, -0.26895422f, -0.29901478f, -0.47658205f, -0.36835268f, -0.40603700f, 0.15723662f, 0.13842338f, 
    -0.11631566f, -0.49621579f, 0.28903648f, -0.39296582f, -0.13293657f, -0.20605862f, -0.43788359f, -0.44289124f, 
    -0.43352395f, 0.25843939f, 0.00938240f, 0.17455526f, 0.08388255f, 0.55583525f, 0.26924828f, 0.19108753f, 
    -0.01486119f, 0.38223296f, 0.06895036f, -0.34118554f, -0.29162279f, -0.25466976f, -0.26092842f, -0.14084928f, 
    0.11097678f, 0.15262936f, -0.18526508f, -0.12838325f, 0.09227450f, -0.12947866f, 0.04769745f, 0.03356991f, 
    -0.17011391f, 0.13250750f, 0.05038030f, 0.16018927f, -0.04374227f, 0.02520985f, 0.55806845f, 0.30154404f, 
    -0.32361621f, -0.09477127f, -0.56915301f, 0.11403327f, 0.04762840f, -0.20751341f, -0.02981217f, 0.28966066f, 
    0.09990996f, -0.14806932f, 0.18200083f, 0.22412495f, -0.28067324f, -0.29232824f, 0.03711323f, 0.35718966f, 
    -0.19548434f, -0.23377818f, 0.39727271f, -0.28423756f, -0.04160372f, 0.12104885f, 0.18647775f, -0.02003764f, 
    -0.80511719f, -0.04130642f, 0.38067761f, -0.15568556f, 0.66101325f, 0.61493337f, -0.00701279f, -0.22285984f, 
    0.06614307f, 0.03152968f, -0.34346634f, -0.12759967f, -0.09211792f, 0.02147749f, -0.05567400f, -0.13429762f, 
    -0.06692876f, 0.14984716f, -0.25112814f, 0.03859382f, 0.09881151f, 0.22985710f, 0.22908144f, -0.19232380f, 
    0.14986736f, -0.07269013f, -0.44142225f, -0.20910601f, 0.60617453f, -0.11668657f, -0.03102275f, -0.36818647f, 
    -0.42672518f, 0.36475849f, -0.17794283f, -0.23994364f, 0.44486594f, -0.13268667f, -0.17848594f, 0.11449216f, 
    0.38094172f, -0.21492602f, -0.09425010f, -0.34484029f, 0.01158724f, -0.34104142f, -0.24610743f, 0.26999301f, 
    0.22655433f, 0.08035839f, 0.02507301f, -0.22834848f, 0.07669607f, 0.18759374f, -0.18545882f, -0.11429683f, 
    -0.38724679f, 0.30280301f, 0.26919758f, -0.18978944f, 0.22096823f, 0.06099194f, -0.06026174f, 0.02508094f, 
    -0.32794625f, -0.03587083f, -0.05242797f, -0.00690711f, 0.24925166f, 0.19012557f, -0.43424442f, -0.02421409f, 
    0.31996971f, -0.16152491f, -0.09021670f, -0.34925926f, 0.25757599f, 0.60422164f, -0.38342932f, -0.26709041f, 
    -0.63403392f, -0.59465325f, -0.24295180f, -0.29445866f, 0.29087111f, -0.01543770f, -0.09807859f, 0.41849706f, 
    0.28609014f, -0.19991125f, -0.04904798f, 0.25867760f, -0.11551379f, 0.18063381f, -0.09195216f, -0.03747705f, 
    -0.17384361f, 0.02900582f, -0.35727561f, -0.49884200f, -0.46830243f, 0.45328853f, 0.55843270f, 0.54366523f, 
    -0.03748269f, -0.09666573f, -0.19047952f, -0.19754121f, -0.04417114f, -0.43790308f, 0.09590324f, -0.16450624f, 
    -0.07409880f, 0.13895902f, 0.03441364f, -0.16707629f, 0.09502496f, 0.27412528f, 0.39586341f, 0.00050627f, 
    -0.26461756f, -0.10065557f, -0.14988625f, -0.24924377f, 0.11205132f, -0.68610138f, -0.49150023f, -0.07141733f, 
    -0.10445418f, -0.23987217f, -0.18687965f, -0.49530753f, 0.01896745f, 0.12402026f, -0.04136989f, 0.25829500f, 
    0.11765745f, -0.33598676f, -0.13386190f, 0.18101574f, 0.06461942f, 0.22090566f, 0.13290903f, 0.31005660f, 
    0.12192324f, -0.30018923f, -0.19559415f, -0.05970893f, -0.22995752f, -0.41203094f, -0.48251858f, 0.01658093f, 
    0.20119511f, 0.18750224f, 0.30374748f, 0.04447852f, 0.14595328f, -0.36723009f, 0.35251534f, -0.28866139f, 
    0.13933621f, -0.03565279f, -0.03478550f, -0.35159215f, -0.24019203f, 0.20107745f, 0.10638362f, 0.26918930f, 
    0.00782183f, 0.02180928f, 0.06773299f, 0.00274187f, 0.01486770f, 0.03665935f, 0.02961173f, -0.07270773f, 
    -0.32793689f, -0.36709377f, -0.08411876f, 0.10954196f, -0.18945472f, 0.00746800f, -0.17543906f, 0.55134475f, 
    0.03103715f, -0.10603873f, 0.24250287f, -0.15285139f, 0.03064644f, -0.23638488f, -0.13020389f, -0.05744761f, 
    -0.19345430f, -0.21741921f, 0.22893707f, 0.44095892f, 0.25210172f, 0.01222184f, 0.29927328f, -1.12766671f, 
    -0.52239144f, -0.03943536f, -0.55552661f, -0.42908973f, 0.15334386f, 0.03436281f, 0.16325946f, 0.46297842f, 
    0.53947240f, -0.09016735f, 0.29197076f, -0.06455317f, 0.40781286f, -0.28593147f, -0.12148366f, -0.06184199f, 
    -0.09668557f, 0.06285521f, 0.29521528f, -0.05490732f, 0.25446531f, 0.08103532f, -0.07536692f, -0.25674143f, 
    -0.79793715f, -0.05260653f, 0.59129751f, -0.42892316f, -0.12573516f, -0.61426842f, 0.27320877f, 0.02509849f, 
    0.46720216f, 0.02810103f, -0.22227660f, -0.39404151f, -0.45929611f, 0.06310917f, 0.43117198f, -0.02577872f, 
    0.04124679f, 0.11523627f, -0.20753232f, -0.32242340f, -0.00517678f, -0.06022907f, -0.05916840f, -0.27227572f, 
    -0.32696444f, -0.93057513f, -1.05307639f, -0.22219549f, 0.52895564f, 0.47454730f, 0.87484771f, 0.16473500f, 
    -0.32350722f, -0.22919743f, 0.51191413f, 0.06659207f, -0.31143868f, -0.16708912f, -0.13791189f, 0.15583819f, 
    0.08817402f, 0.13786739f, 0.06405669f, 0.16281216f, -0.13778260f, -0.02204344f, -0.04721862f, -0.26539859f, 
    0.15886687f, -0.11883304f, -0.51390260f, -1.12368298f, 0.18107545f, 0.54669374f, 0.49736181f, -0.53990555f, 
    -0.75568497f, -0.43870270f, -0.22875278f, -0.07143954f, -0.16433205f, -0.08575758f, -0.09026167f, -0.17107117f, 
    -0.01409843f, -0.17215782f, -0.33742118f, -0.04685089f, 0.03356824f, -0.12876962f, -0.03538014f, -0.13569397f, 
    -0.14363903f, -0.04891023f, 0.23233970f, 0.27809238f, 0.21206433f, 0.10253932f, 0.03810139f, -0.30462691f, 
    -0.12787147f, 0.05308434f, 0.03098891f, -0.19722490f, 0.15528832f, -0.41503486f, 0.32258454f, -0.11338112f, 
    -0.02576859f, -0.08727980f, 0.18095316f, 0.19105881f, 0.09858174f, -0.25854221f, -0.25559115f, 0.23861617f, 
    -0.17790547f, 0.08590570f, 0.08232310f, -0.20308268f, -0.32664692f, -0.21731468f, 0.10686697f, 0.26023194f, 
    0.35451075f, -0.26126510f, -0.61975574f, 0.00478364f, 0.30639639f, 0.26862192f, 0.08014105f, -0.10552628f, 
    -0.11796667f, 0.14687543f, -0.18394923f, 0.28836504f, -0.17690705f, -0.09105764f, -0.26641706f, 0.08628096f, 
    -0.21168436f, -0.10438188f, -0.09214509f, 0.11172713f, -0.26885623f, -0.06501620f, -0.71302533f, -0.74515742f, 
    -0.63864368f, -0.36658704f, 0.66620004f, -0.21539319f, 0.36894482f, 0.16140482f, 0.28001663f, 0.05530353f, 
    0.32071567f, 0.24812385f, 0.00711914f, -0.01533567f, -0.00075763f, -0.21422514f, -0.03786439f, -0.09252919f, 
    -0.27938831f, -0.18447274f, -0.00727562f, -0.03415037f, -0.06827299f, -0.29983521f, 0.57860607f, 0.17905901f, 
    -0.16558915f, 0.23553050f, -0.52854896f, 0.35684276f, 0.41100654f, -0.04708354f, -0.45434639f, -0.44951487f, 
    -0.07650013f, -0.29769820f, -0.13236988f, -0.11077072f, -0.02921298f, 0.04869170f, -0.08459982f, 0.33938411f, 
    -0.06792019f, -0.16325429f, -0.06141237f, -0.12693612f, 0.15629798f, 0.09828524f, -0.01736237f, -0.20784692f, 
    -0.07701367f, 0.05478615f, 0.25374511f, -0.02512569f, 0.75926149f, -0.14739299f, -0.54836953f, -0.30949178f, 
    0.14539441f, 0.06538117f, 0.18534446f, 0.17359859f, 0.25417119f, -0.29398510f, 0.00121090f, -0.28331161f, 
    -0.09661075f, 0.23607621f, -0.27122146f, -0.18053328f, 0.28434879f, -0.07075577f, 0.19813593f, 0.18768674f, 
    1.15959549f, -0.37552899f, -0.45208493f, -0.26507354f, -0.26674896f, -0.02331661f, 0.39457220f, 0.02911174f, 
    -0.01384365f, -0.19365101f, -0.24326591f, -0.04469597f, -0.26277378f, 0.01499652f, 0.44352147f, 0.07029315f, 
    0.29959768f, 0.08760229f, 0.04763724f, -0.41459799f, -0.04579156f, 0.05424221f, -0.03319802f, -0.32242727f, 
    -0.15089959f, 0.37900135f, 0.25001556f, -0.71703643f, -0.57395506f, -0.59133869f, -0.32105535f, -0.20361882f, 
    0.20797636f, -0.08813433f, 0.43380502f, 0.23990519f, 0.36020038f, 0.18132107f, 0.24482097f, -0.10395903f, 
    0.16126665f, -0.09262910f, -0.19074892f, 0.07206268f, -0.06465781f, -0.04750475f, 0.08336979f, -0.29062375f, 
    -0.11314873f, 0.10968672f, 0.73581785f, 0.22853422f, -0.28509858f, -0.03753184f, -0.16005187f, 0.21403769f, 
    0.11721786f, 0.10019886f, -0.11710072f, -0.10011339f, -0.05963428f, 0.07827901f, 0.28141060f, -0.36547455f, 
    -0.39958254f, -0.29456019f, 0.12587364f, 0.04676752f, 0.18939172f, -0.19324790f, 0.03633427f, -0.11619427f, 
    0.02891052f, -0.09817374f, 0.09494735f, -0.55557179f, 0.02427303f, 0.37030184f, 0.04715095f, -0.07754164f, 
    -0.16382596f, -0.31513813f, 0.20697504f, 0.26758879f, 0.15927534f, -0.18897051f, 0.33308199f, 0.66860265f, 
    -0.56167078f, -0.41480479f, -0.23369019f, 0.11164770f, -0.05124679f, 0.16089098f, 0.03319038f, 0.10715145f, 
    0.08878823f, -0.20439418f, 0.09229448f, -0.03883777f, -0.53627461f, -0.31605664f, 0.07740435f, -0.14251490f, 
    0.51388490f, 0.39129549f, 0.37450153f, -0.57135206f, -0.59972978f, -0.69016957f, -0.06444746f, -0.08284037f, 
    0.48579863f, -0.28754574f, -0.14245884f, -0.04688909f, -0.25903189f, 0.09423199f, -0.17610897f, -0.35137561f, 
    0.24778597f, 0.02224067f, 0.01047598f, -0.20710777f, 0.10091341f, 1.30695450f, -0.40709782f, -0.43634719f, 
    -0.05436566f, -0.64636958f, 0.11357848f, -0.15578461f, 0.21187136f, 0.03198842f, 0.22998284f, 0.04582395f, 
    0.25972077f, -0.15181917f, -0.28571796f, 0.08340272f, -0.00134310f, -0.01079960f, 0.10352638f, -0.28766102f, 
    -0.01020777f, 0.05803272f, -0.21715908f, -0.06054419f, 0.15806833f, -0.13572980f, 0.06055599f, 0.18083030f, 
    0.39059752f, -0.12169743f, -0.52393061f, -0.41441125f, -0.39708954f, 0.42550176f, 0.39613548f, -0.15926412f, 
    -0.43082350f, 0.11635611f, 0.27917653f, 0.34088308f, -0.29513392f, 0.23239647f, -0.12382200f, 0.08168142f, 
    -0.10530166f, -0.18704452f, 0.24110210f, -0.06096548f, -0.27205101f, -0.05074282f, 0.19072478f, -1.00551820f, 
    -0.44068009f, -0.36838585f, -0.40240940f, -0.60517144f, 0.48048615f, 0.20847264f, -0.10398915f, -0.22489960f, 
    0.45712069f, -0.32460234f, -0.40606725f, -0.34073314f, -0.16921183f, -0.30277014f, 0.12078046f, 0.17289743f, 
    -0.09965801f, -0.07034165f, -0.15249915f, -0.08518653f, -0.16828124f, -0.24001253f, -0.11824821f, 0.02248961f, 
    0.47103781f, 0.10109904f, 0.02150283f, 0.12128493f, -0.08767153f, -0.25864252f, -0.18057507f, 0.18238883f, 
    -0.15739425f, -0.18972896f, 0.38507432f, -0.17534238f, -0.08721108f, -0.36698294f, 0.09808132f, -0.11704180f, 
    -0.13222452f, 0.07672912f, 0.24328019f, -0.03710052f, -0.19503623f, 0.06905734f, -0.02744411f, -0.03198577f, 
    0.13886668f, 0.39867023f, 0.91561455f, -0.11588240f, 0.05272067f, -0.47043216f, -0.42026579f, -0.44391653f, 
    -0.22585641f, -0.56784439f, -0.65665919f, 0.15814143f, 0.14080289f, -0.02168054f, 0.12964217f, -0.42315304f, 
    -0.14003015f, -0.22749022f, 0.01777346f, -0.20429018f, -0.42506173f, 0.02631695f, -0.01813440f, -0.21107222f, 
    -0.30857465f, -0.36720824f, -0.38685742f, -0.52439076f, -0.44943458f, 0.04529679f, 0.09847085f, 0.40446240f, 
    0.23227894f, -0.17844984f, 0.17364962f, 0.52955490f, 0.36687520f, -0.16754825f, 0.08072447f, 0.02344674f, 
    -0.27497450f, 0.05438487f, 0.09365821f, -0.19789188f, 0.01727305f, -0.14796568f, -0.10515057f, -0.05271551f, 
    0.16219077f, -0.26070204f, 0.16436672f, -0.04514959f, 0.46320724f, 0.00216195f, -0.62012875f, 0.16621242f, 
    -0.01928999f, -0.17229807f, 0.07157873f, 0.15924813f, -0.21486890f, -0.16711533f, -0.18773341f, -0.06035622f, 
    0.29604217f, -0.27032384f, -0.31571507f, -0.16722892f, 0.32195666f, 0.36994269f, -0.01047165f, 0.13490999f, 
    0.10830303f, 0.01660935f, -0.14338535f, -0.23183157f, 0.42321274f, 0.34404898f, 0.16223940f, 0.28028610f, 
    -0.43563810f, -0.18306965f, 0.37484354f, -0.26723659f, -0.26948109f, -0.06832302f, -0.00756206f, 0.11745451f, 
    -0.06575916f, -0.25899157f, -0.05220207f, -0.06869035f, 0.02793538f, 0.09270617f, 0.15537456f, 0.03921072f, 
    0.15448253f, -0.29527897f, -0.02143292f, -0.05678977f, -0.16789338f, 0.77915120f, -0.02683025f, -0.43486419f, 
    -0.27890208f, 0.29808760f, -0.50389290f, -0.41627479f, 0.10468477f, 0.46422693f, -0.01432386f, 0.05408626f, 
    0.17665656f, 0.16611189f, -0.13020532f, 0.00453685f, 0.18644467f, 0.05001118f, 0.17534895f, -0.03339655f, 
    -0.19317438f, 0.08624456f, 0.14886148f, -0.11385232f, 0.01623419f, 0.04508491f, -0.42282683f, -0.15846980f, 
    -0.22639000f, -0.14460251f, 0.03670325f, 0.26572302f, 0.18665934f, -0.09156573f, 0.29134214f, -0.21773389f, 
    -0.00440810f, 0.21752240f, 0.02723671f, 0.35063276f, -0.36443633f, -0.19216891f, -0.16713960f, -0.18490931f, 
    0.03707607f, -0.12024515f, 0.22889414f, 0.00481625f, 0.10330051f, 0.27957228f, 0.26387075f, 0.13868108f, 
    0.02281327f, 0.16516557f, -0.18492989f, 0.24937454f, -0.34051868f, -0.35645559f, -0.12917465f, -0.44553056f, 
    -0.42192519f, 0.27733955f, -0.05545636f, 0.24910162f, 0.17707434f, 0.03714377f, 0.27885467f, 0.09638543f, 
    -0.10555337f, 0.05528144f, -0.07158197f, -0.27670553f, 0.01039391f, 0.12890086f, 0.28050345f, 0.05250581f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02688981f, 0.00865833f, 0.07366750f, -0.11105599f, 0.05639013f, 0.24685463f, -0.05163387f, -0.02491571f, 
    0.32851589f, 0.18823270f, -0.06680929f, -0.06659533f, 0.19100749f, 0.38840899f, 0.03502892f, -0.19521151f, 
    -0.09525005f, 0.24231525f, 0.11349540f, -0.09034336f, 0.12688504f, 0.33163321f, -0.54726207f, 0.02302650f, 
    0.08006442f, 0.22261424f, 0.11533652f, -0.45110399f, -0.08882129f, 0.03496223f, 0.20846173f, 0.18715441f, 
    -0.01330757f, 0.22174120f, 0.11134845f, -0.09945824f, 0.12645304f, 0.05027544f, 0.04401010f, -0.09463564f, 
    -0.11830179f, 0.15657461f, 0.34878495f, 0.29117191f, 0.12021038f, -0.09082135f, 0.24354458f, 0.09935975f, 
    0.06913040f, 0.28585008f, 0.09869426f, 0.00106214f, 0.23958582f, 0.22258060f, 0.29487944f, -0.38923761f, 
    0.26500407f, -0.28062168f, 0.04912522f, -0.01228887f, 0.12345883f, 0.19049834f, 0.10658614f, 0.08680321f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.37193912f, -0.34847370f, -0.22500600f, 0.07619387f, 0.02438052f, 0.01119868f, 0.02896308f, 0.01393764f, 
    -0.02665319f, 0.04446875f, 0.00450957f, 0.05444654f, -0.10685916f, 0.23560528f, 0.18105760f, 0.04959489f, 
    -0.06765350f, -0.08183967f, 0.02435072f, 0.00575591f, -0.03592777f, -0.03821309f, -0.20832948f, 0.06703927f, 
    0.37309766f, -0.06132817f, 0.07747589f, -0.28760472f, 0.03660770f, -0.08103459f, 0.11602823f, -0.08756030f, 
    -0.03526190f, -0.08670197f, 0.02474023f, 0.06374081f, 0.38327155f, 0.05505422f, 0.11228437f, -0.25664455f, 
    -0.11576298f, -0.13498336f, -0.08910312f, 0.14185005f, 0.01629279f, 0.04490501f, -0.01570832f, 0.01086385f, 
    -0.08848427f, 0.05827928f, -0.08281446f, -0.13486397f, 0.01943941f, 0.08787727f, 0.03117009f, 0.00440516f, 
    -0.09247633f, 0.15013294f, 0.04174739f, 0.02005655f, -0.11821783f, -0.04376768f, -0.15231143f, -0.07312418f, 
    -0.06120968f, 0.00628070f, -0.03941235f, -0.03137714f, 0.11034556f, -0.04380875f, -0.11096854f, -0.18226011f, 
    -0.27569553f, -0.10488494f, -0.11237206f, 0.04815429f, 0.07880373f, 0.01437468f, -0.00824007f, 0.00477301f, 
    0.00489875f, -0.02198969f, -0.01415301f, 0.02249126f, 0.12488239f, 0.11369626f, 0.02600297f, -0.11607230f, 
    0.03706919f, 0.11899735f, 0.02238741f, -0.00358575f, 0.00476768f, -0.03178173f, 0.04404496f, 0.01778384f, 
    -0.29368550f, -0.87803131f, -0.19487511f, 0.10439073f, 0.06229285f, -0.01628536f, -0.20520291f, -0.13802430f, 
    0.08391148f, -0.21486679f, -0.18805021f, -0.09091872f, 0.23124173f, 0.16402483f, -0.15402158f, -0.15111037f, 
    0.04192412f, 0.06312340f, 0.03318886f, 0.01909901f, 0.01712641f, 0.02308426f, 0.03158117f, -0.05748688f, 
    -0.07012686f, -0.09580798f, 0.00573720f, 0.01537424f, 0.02363154f, 0.01773102f, -0.03958666f, -0.06624614f, 
    -0.05662476f, 0.03641158f, 0.11300757f, 0.07238115f, 0.27838749f, 0.01233279f, -0.25379387f, -0.04305446f, 
    0.01645042f, 0.01694188f, 0.11558563f, 0.00743494f, 0.01676216f, -0.00736347f, 0.17659785f, 0.08346505f, 
    -0.14862019f, -0.02102409f, 0.10028349f, -0.11959946f, 0.08502398f, -0.00512270f, 0.04638693f, 0.01508870f, 
    -0.14943273f, -0.13895036f, -0.01913005f, -0.13455649f, -0.30112946f, -0.04655133f, 0.21938255f, -0.36148682f, 
    0.04670600f, -0.01799832f, 0.04533606f, 0.02422745f, 0.04439573f, -0.02769067f, -0.11443586f, -0.06585695f, 
    -0.19451134f, -0.37920511f, -0.02926793f, 0.03007577f, 0.01520360f, 0.04535617f, -0.09960936f, -0.03216762f, 
    -0.02202314f, 0.05027340f, -0.03097246f, 0.14067143f, 0.01392890f, 0.00442719f, 0.05837054f, 0.02519409f, 
    0.03370646f, 0.04790784f, 0.01835327f, 0.02293229f, -0.45209619f, -0.26361915f, -0.06796733f, 0.01041127f, 
    -0.05064493f, 0.18108138f, -0.13702992f, 0.10811808f, 0.07364970f, 0.00401745f, 0.04075003f, -0.12564015f, 
    -0.04592356f, -0.03049474f, -0.21307251f, -0.02578829f, 0.29924420f, 0.20798513f, -0.21763404f, -0.26488003f, 
    0.06038276f, 0.02361328f, 0.05346671f, -0.02360693f, -0.04622052f, -0.05363422f, 0.01505337f, 0.01673570f, 
    -0.24317087f, 0.32095855f, 0.04849195f, 0.01511113f, -0.08635050f, 0.11489674f, 0.11369506f, -0.05583845f, 
    0.05549642f, 0.06807941f, -0.08934072f, -0.11760369f, -0.13259782f, -0.21610795f, -0.09667933f, 0.07110394f, 
    -0.01353931f, -0.01530659f, -0.01192913f, -0.03555292f, 0.02978206f, -0.04606966f, -0.02093582f, 0.15435462f, 
    -0.06494652f, 0.29793659f, -0.32138160f, -0.01398696f, 0.09645750f, -0.17637810f, -0.00127387f, 0.01129222f, 
    -0.02790028f, 0.02937651f, -0.06102088f, 0.01168161f, -0.01950334f, 0.27227914f, 0.19109790f, -0.37004104f, 
    -0.14879665f, 0.08599293f, -0.07925653f, -0.02869827f, -0.01406852f, -0.17131311f, -0.11251732f, -0.04079687f, 
    0.27931964f, 0.23012048f, -0.03738064f, -0.06887429f, 0.13450894f, 0.13281161f, 0.11369491f, 0.10648708f, 
    -0.08698473f, -0.08666981f, 0.00551786f, -0.04753288f, -0.02311787f, 0.02189785f, 0.00421697f, 0.01060658f, 
    -0.01100002f, 0.03298649f, -0.00598477f, 0.01653941f, -0.02029722f, -0.01636146f, 0.02163779f, -0.08035639f, 
    -0.00270817f, -0.39085731f, -0.36026672f, 0.08717734f, 0.04835043f, 0.06648074f, 0.10751194f, -0.01753240f, 
    0.04767151f, 0.00017393f, 0.02972909f, -0.06826068f, 0.08361900f, -0.08743568f, -0.61866939f, 0.01738483f, 
    -0.03191590f, -0.04016525f, -0.08343486f, -0.11479533f, -0.01182761f, -0.01578300f, 0.06103610f, 0.00217570f, 
    0.24082828f, 0.05160497f, 0.20206973f, -0.17835490f, -0.00329691f, -0.05179250f, -0.03550726f, -0.06418369f, 
    -0.09712058f, 0.01079136f, -0.07229224f, 0.06425761f, 0.36949098f, 0.21170545f, -0.10198649f, -0.14069936f, 
    0.13874476f, 0.05769360f, 0.10958216f, 0.13512430f, -0.00865080f, -0.05060833f, -0.01002365f, -0.02790158f, 
    0.24351618f, 0.09173201f, -0.11254331f, -0.14419019f, 0.03497491f, -0.03807887f, -0.11187229f, -0.11048564f, 
    -0.10133422f, -0.09326891f, -0.11207142f, -0.08458006f, -0.21912456f, 0.04983623f, -0.44944116f, 0.13169706f, 
    0.00676104f, -0.03741195f, -0.03575346f, 0.00464898f, 0.01422897f, -0.00298646f, 0.00088127f, 0.02756415f, 
    -0.12438095f, -0.51281887f, -0.51316899f, 0.01478178f, 0.01442636f, 0.00030317f, -0.08884894f, -0.06363601f, 
    -0.07337811f, -0.14586687f, -0.14373514f, -0.04730035f, 0.18684013f, -0.27071184f, -0.35636023f, 0.01888293f, 
    0.04611319f, -0.03008928f, 0.05590269f, -0.05067983f, 0.01414984f, -0.07906276f, -0.14091061f, 0.16546395f, 
    -0.12159046f, 0.28053537f, -0.21823867f, 0.08618640f, -0.07255175f, -0.02413531f, 0.00056050f, 0.04948078f, 
    -0.03356943f, -0.09813983f, -0.03513602f, 0.04281434f, -0.22306433f, -0.01238619f, -0.11808242f, -0.04120839f, 
    0.01074453f, -0.04670808f, 0.03046991f, 0.03475443f, -0.08839767f, -0.05569366f, 0.04205963f, -0.09427619f, 
    0.17599492f, 0.07324188f, 0.00061979f, -0.29786238f, 0.05390712f, -0.07967485f, -0.05467666f, 0.11392120f, 
    0.04691162f, 0.05273161f, -0.01326884f, 0.08890242f, 0.24339035f, 0.14112245f, 0.11971546f, -0.19386154f, 
    0.03200966f, -0.21697672f, -0.04205162f, -0.20946065f, -0.07483215f, -0.06981519f, 0.03045245f, -0.06264371f, 
    0.30457333f, 0.24922401f, 0.04629220f, -0.12484708f, 0.19685508f, 0.01642596f, 0.10591806f, -0.08229192f, 
    -0.02591193f, 0.05830761f, 0.07266069f, 0.04369431f, 0.12632072f, 0.07321655f, 0.04125000f, -0.04871953f, 
    -0.02896944f, -0.06055503f, 0.05081241f, -0.04117746f, 0.00613625f, -0.00069913f, -0.01359227f, -0.07892281f, 
    0.09361934f, 0.10191151f, -0.00872257f, -0.04377254f, 0.16404821f, 0.21051149f, -0.03634692f, -0.13754588f, 
    -0.01060148f, -0.10051642f, -0.00376422f, -0.05076787f, 0.12957874f, 0.07160692f, 0.14155412f, -0.07375798f, 
    0.04613562f, 0.18108898f, 0.07082579f, -0.03496290f, -0.07905624f, 0.07483700f, 0.03453938f, 0.06934136f, 
    -0.10159797f, 0.04450733f, 0.20788449f, -0.11859716f, -0.01227716f, 0.01275613f, -0.12352709f, -0.06013724f, 
    -0.14842486f, -0.07607365f, 0.00800428f, 0.08068724f, 0.41461512f, 0.18057309f, 0.03205328f, -0.22095306f, 
    -0.05077458f, -0.00832606f, 0.11632371f, -0.10566604f, -0.09347519f, -0.02272222f, -0.03144398f, -0.02085461f, 
    0.35174787f, 0.19361123f, 0.08644181f, -0.25089952f, 0.03146522f, -0.01920207f, 0.07511254f, -0.02940901f, 
    -0.02020554f, -0.09740692f, -0.08073542f, -0.16109343f, -0.32003307f, -0.17259644f, -0.07409568f, -0.06355803f, 
    0.00034222f, -0.01561592f, -0.04787503f, -0.02915121f, -0.03473435f, -0.05425983f, 0.00732728f, -0.04018592f, 
    -0.36078772f, 0.11980328f, 0.09609672f, -0.22947823f, -0.01478852f, -0.04447035f, -0.00334380f, 0.06369061f, 
    -0.12747650f, -0.09868891f, -0.13515286f, 0.06847742f, 0.25168160f, -0.10311115f, -0.09371450f, 0.01876180f, 
    0.08436935f, 0.09980226f, 0.03879789f, -0.04312213f, -0.02369175f, 0.08033672f, 0.06752181f, 0.11748499f, 
    0.12351856f, -0.32265249f, -0.13013740f, -0.08660013f, -0.04899177f, 0.03547299f, -0.07112246f, 0.00416077f, 
    -0.02595871f, -0.01123802f, 0.03862764f, 0.07192691f, 0.16162024f, 0.04196950f, -0.14965829f, -0.01325643f, 
    -0.05222073f, -0.00829511f, 0.01047918f, -0.12186810f, -0.01984913f, -0.01528780f, -0.00428718f, -0.08437285f, 
    -0.08471796f, -0.24118176f, 0.10337725f, 0.01082564f, -0.03513874f, -0.06560565f, 0.21157749f, -0.09415504f, 
    -0.14447890f, 0.07288034f, -0.14315058f, -0.00194230f, 0.18847510f, 0.05699531f, -0.01000558f, 0.02499512f, 
    0.06637325f, 0.05557352f, -0.08762810f, -0.22128665f, -0.23471849f, 0.00793784f, 0.00716826f, 0.01298232f, 
    -0.48046353f, -0.36981678f, -0.80891335f, 0.18878387f, 0.05904667f, -0.01007949f, -0.00867103f, 0.01175271f, 
    0.04121981f, -0.03327202f, -0.02886020f, 0.04555092f, -0.14365113f, 0.17634819f, 0.27752683f, -0.14043812f, 
    -0.14476687f, -0.13989459f, -0.14958119f, -0.10778955f, 0.19221289f, -0.14665657f, 0.00391601f, -0.04829775f, 
    0.29645720f, 0.19562566f, -0.37444758f, -0.11629139f, 0.05421893f, -0.08278225f, 0.08485329f, -0.03686643f, 
    -0.07982879f, -0.09679247f, -0.12116122f, -0.11305691f, -0.16520360f, -0.09640481f, -0.16426849f, 0.06087738f, 
    -0.02361683f, 0.01863671f, -0.08118410f, -0.05763628f, -0.13862140f, -0.03563685f, -0.08944559f, 0.07543086f, 
    -0.26696989f, -0.23360042f, 0.18797570f, -0.01691848f, -0.15412623f, -0.03223637f, -0.16107884f, -0.06686398f, 
    -0.01064823f, -0.11634292f, -0.05340477f, -0.15785706f, 0.30525911f, 0.23656562f, 0.06081646f, -0.10767985f, 
    0.14168523f, 0.16324249f, 0.12567121f, 0.24030417f, -0.05306269f, 0.04056135f, -0.00718154f, -0.07832804f, 
    -0.44101024f, -0.39130881f, 0.00052957f, -0.09118102f, -0.00072112f, -0.04200569f, 0.01406470f, 0.04254548f, 
    -0.00417609f, 0.00559163f, 0.00704264f, 0.00440904f, 0.08618441f, 0.07314784f, -0.20112216f, -0.03381914f, 
    -0.24301514f, -0.06582895f, -0.01778347f, 0.05095731f, -0.04144567f, 0.02100928f, 0.04262118f, 0.10096949f, 
    -0.05420063f, 0.13637570f, -0.05880997f, 0.03535149f, 0.04109134f, 0.03954488f, 0.04687846f, 0.00288700f, 
    0.02639412f, 0.17901625f, 0.00029732f, -0.11351760f, -0.37948337f, -0.05975403f, -0.22903813f, 0.21050958f, 
    -0.07966335f, 0.00074475f, -0.01697000f, 0.09794114f, 0.11465113f, 0.05069153f, -0.08081367f, -0.03782606f, 
    -0.16057611f, -0.07330016f, -0.08578424f, -0.15682603f, 0.03860594f, 0.02678946f, -0.03765441f, -0.13522001f, 
    -0.04494678f, 0.01676087f, 0.00670180f, 0.04516188f, -0.01080019f, 0.05501640f, -0.07077105f, -0.06807287f, 
    -0.34457439f, -0.14586297f, -0.12804669f, -0.25776911f, -0.04591765f, -0.04153980f, -0.00821085f, -0.00632623f, 
    0.05412910f, 0.10848587f, -0.04198836f, -0.02416921f, 0.07833353f, 0.07357775f, -0.06232398f, -0.11532398f, 
    -0.15770398f, -0.13983430f, -0.11764130f, -0.12391674f, 0.13183443f, 0.12344804f, -0.05358700f, -0.00164075f, 
    -0.01699229f, -0.00295353f, -0.03778962f, 0.04445606f, -0.00821490f, 0.06628308f, -0.00303403f, -0.03866261f, 
    0.08684837f, 0.23249184f, 0.11598043f, 0.19330035f, -0.06393097f, 0.02954761f, -0.02602728f, -0.05655688f, 
    0.09009270f, -0.12409135f, 0.04063764f, 0.00381489f, -0.42416248f, -0.09035459f, 0.23357169f, -0.11166809f, 
    -0.23440689f, -0.09197476f, 0.21208672f, 0.09607198f, 0.03097298f, -0.04024845f, 0.00366694f, -0.26300478f, 
    -0.32310957f, -0.10023506f, -0.06616907f, -0.03494843f, -0.05797015f, -0.02361281f, 0.07118167f, -0.01277509f, 
    0.15730254f, -0.01955635f, -0.00459850f, 0.03889501f, -0.30535594f, -0.02961469f, -0.34120217f, -0.45765585f, 
    -0.07602166f, -0.08777025f, 0.00783862f, -0.10406200f, 0.06986842f, -0.03094968f, -0.04968116f, -0.02999740f, 
    -0.20588008f, -0.07499110f, -0.03868620f, -0.18203902f, 0.00968943f, 0.04323190f, -0.06697153f, 0.06544583f, 
    -0.18965192f, -0.20363399f, -0.33432353f, -0.12326713f, 0.12145410f, 0.18153994f, -0.27613455f, -0.16204417f, 
    -0.01567871f, 0.02343692f, 0.06098923f, 0.05603853f, 0.11915197f, 0.07307569f, 0.04189570f, -0.19906539f, 
    0.11550026f, 0.27716634f, 0.12519655f, 0.09479441f, -0.00916043f, 0.01498698f, -0.03593640f, -0.03548822f, 
    0.00023467f, -0.00520236f, -0.00657158f, 0.01406867f, 0.29068103f, 0.17496778f, 0.06795858f, -0.05613078f, 
    0.08950376f, 0.12927562f, -0.13487945f, -0.08358452f, -0.00097704f, 0.04805570f, -0.01480777f, -0.12608485f, 
    0.24687436f, -0.42122948f, -0.36557645f, -0.41837102f, 0.00124415f, 0.01948976f, -0.04884020f, 0.07713044f, 
    0.03129143f, 0.05928794f, -0.09141473f, 0.04430696f, 0.16469686f, 0.19632299f, -0.03220818f, -0.25157747f, 
    0.00721356f, 0.02501487f, 0.02172910f, 0.19689773f, -0.02238813f, -0.01573031f, -0.14206013f, 0.01082609f, 
    0.05773954f, 0.05547486f, 0.07014994f, -0.03756801f, 0.02376785f, -0.02991042f, -0.08288115f, 0.01604007f, 
    0.00788001f, 0.02704263f, -0.04894386f, -0.04136164f, 0.22369380f, -0.18643668f, 0.12208619f, 0.04894524f, 
    -0.03965426f, -0.02602362f, 0.00398742f, -0.04724550f, 0.14773925f, -0.12512921f, -0.16354072f, -0.13107598f, 
    -0.11658760f, -0.02081013f, 0.05501195f, 0.12286422f, -0.08569872f, -0.00381015f, 0.05121216f, -0.00915859f, 
    -0.04454021f, 0.12907565f, -0.03560669f, 0.07684182f, -0.37371725f, 0.09565981f, 0.02959315f, 0.07660826f, 
    -0.04364527f, 0.02988688f, 0.01418589f, -0.00542343f, 0.10739625f, -0.02834236f, 0.00865821f, 0.17853414f, 
    0.19790085f, -0.03730668f, 0.16627024f, -0.10321730f, 0.02397220f, -0.00186775f, -0.04305651f, -0.04919403f, 
    -0.04764999f, -0.12869886f, -0.20856586f, -0.06913882f, 0.04647470f, 0.06758790f, 0.08232168f, 0.08161293f, 
    -0.00857858f, 0.02340516f, -0.02186789f, -0.03893097f, 0.16652411f, -0.07963442f, 0.01590511f, -0.05849678f, 
    0.27816662f, -0.09179651f, 0.05356596f, -0.03545643f, -0.13329723f, -0.00809938f, 0.06966241f, 0.06642959f, 
    -0.06009979f, -0.12738094f, -0.01451547f, -0.11358919f, -0.42671213f, -0.16972719f, 0.07955433f, -0.07224526f, 
    0.11107084f, 0.10202053f, 0.07088025f, 0.04995678f, 0.00487643f, 0.03781268f, 0.02464333f, -0.01175383f, 
    -0.17952915f, 0.10979085f, 0.03813957f, -0.07984625f, 0.08189803f, 0.10210151f, -0.18037383f, -0.04129370f, 
    -0.15796921f, -0.08847292f, -0.02366380f, 0.01617195f, 0.18778001f, 0.05524880f, 0.04376135f, -0.03708712f, 
    -0.02848995f, -0.01447409f, -0.02282131f, 0.03570882f, -0.49167553f, -0.15039670f, 0.00281588f, -0.20448959f, 
    0.01331049f, -0.15891367f, -0.27333757f, 0.29029965f, 0.00242597f, 0.06714716f, 0.03494501f, -0.20441969f, 
    -0.03362845f, -0.00983545f, 0.04392857f, -0.06615183f, -0.54272711f, 0.10828885f, 0.09446354f, -0.04526830f, 
    0.19037265f, 0.01120986f, -0.12512186f, 0.31231776f, -0.08449881f, 0.04893792f, 0.14445764f, -0.04310950f, 
    0.27867666f, 0.19501923f, 0.29219145f, 0.35568222f, 0.07082298f, 0.11323486f, 0.10585043f, -0.15983082f, 
    0.01406386f, 0.00941927f, -0.00468018f, 0.02680208f, 0.09397723f, 0.05509698f, -0.00088247f, 0.05113290f, 
    0.00526537f, -0.04810882f, 0.00332176f, -0.01910425f, -0.03516294f, -0.03238616f, -0.06284558f, -0.01384381f, 
    0.54689687f, 0.19462812f, -0.09285826f, 0.10705177f, -0.03110410f, -0.00871304f, 0.09255782f, -0.16379081f, 
    0.19456410f, -0.13028409f, -0.08956531f, -0.09830555f, 0.03858046f, 0.01065261f, -0.01463552f, -0.09431128f, 
    -0.02474136f, -0.07896186f, 0.00503661f, -0.04848311f, 0.03923371f, 0.05444415f, -0.09885725f, 0.07923412f, 
    -0.15615126f, 0.23395680f, -0.33325163f, -0.30828357f, 0.00779681f, 0.02434520f, 0.02405782f, -0.01538394f, 
    -0.13244864f, -0.15698545f, 0.01601268f, -0.28782111f, 0.14489032f, 0.09861293f, 0.10912386f, 0.31127447f, 
    -0.23015702f, 0.07954876f, -0.11458621f, 0.03294734f, -0.05535196f, 0.04660153f, -0.04497908f, 0.09904255f, 
    -0.17808795f, -0.02068005f, -0.04684680f, -0.13861166f, -0.03947939f, 0.11960166f, -0.00100915f, 0.22827603f, 
    0.00166539f, -0.05579750f, 0.02863145f, -0.01110596f, 0.24673274f, 0.13267271f, -0.03845593f, 0.03798836f, 
    -0.07745715f, -0.06426608f, -0.04156988f, -0.01706630f, -0.04770302f, 0.01113991f, -0.03508007f, -0.00440375f, 
    0.21511482f, -0.01867750f, 0.19692193f, -0.23499632f, -0.00853473f, -0.01253171f, 0.00452297f, 0.03224137f, 
    0.02409144f, -0.13733196f, 0.28436717f, -0.06364719f, 0.28363925f, -0.18404417f, 0.15124661f, -0.06660534f, 
    -0.10842454f, -0.05863700f, 0.04262192f, 0.03943349f, -0.03955934f, -0.03747189f, 0.15852278f, 0.01815883f, 
    -0.18594316f, -0.25875601f, -0.43066677f, 0.33954147f, 0.07540300f, -0.07418279f, 0.10735892f, 0.04180817f, 
    0.08218361f, 0.05700906f, -0.00645513f, 0.01068560f, 0.02139163f, 0.04467398f, 0.10241011f, 0.15468530f, 
    0.00687325f, -0.02811148f, -0.02586811f, -0.05428801f, 0.15167949f, 0.04575276f, 0.02542641f, 0.08874743f, 
    -0.11599489f, 0.06120307f, -0.01099921f, -0.33178055f, -0.17212527f, -0.22096063f, -0.02744074f, 0.18606119f, 
    0.02437601f, -0.01310444f, 0.09203807f, 0.01776106f, -0.03182244f, 0.04334660f, -0.03854831f, -0.11083841f, 
    -0.03783743f, 0.03607149f, -0.02940846f, 0.17105377f, 0.20164962f, -0.00457936f, 0.12634964f, -0.20594773f, 
    0.03216894f, 0.12427453f, -0.08622715f, 0.12917180f, -0.15114048f, -0.10006831f, -0.12243970f, -0.17044431f, 
    0.06355532f, -0.18992282f, -0.01646969f, 0.01715843f, -0.03739751f, -0.05696857f, -0.02523446f, 0.02094029f, 
    -0.14439388f, 0.05292943f, 0.00544111f, -0.00917996f, 0.02742795f, -0.11697140f, -0.10927345f, 0.04629130f, 
    -0.01570806f, -0.00191077f, 0.02605886f, 0.01083861f, -0.09236261f, 0.10605560f, 0.01307993f, 0.11389042f, 
    -0.09954381f, 0.00789330f, -0.02819457f, -0.10362480f, -0.28970614f, 0.04951661f, -0.20163815f, 0.04889039f, 
    0.00280306f, 0.07407165f, 0.01345259f, -0.07394331f, -0.10036775f, -0.13747652f, -0.02653452f, -0.04933661f, 
    -0.37713522f, -0.02692342f, 0.00680416f, -0.39672425f, 0.05466829f, -0.00969346f, -0.09223946f, 0.12192046f, 
    0.01954835f, 0.17337787f, -0.05979646f, -0.36124873f, 0.23383090f, -0.03401945f, -0.23399340f, 0.07167355f, 
    0.00296013f, 0.01964370f, -0.00363305f, 0.03552752f, 0.16596200f, -0.20134878f, -0.00979636f, -0.07078178f, 
    -0.32227263f, 0.01551238f, -0.23434095f, -0.04079243f, -0.02052032f, 0.10173689f, 0.10498128f, 0.10837183f, 
    0.03961394f, 0.03464182f, 0.02066339f, -0.02167477f, 0.31493014f, 0.02233830f, 0.24259068f, -0.06782861f, 
    0.03893758f, 0.02757350f, 0.04025454f, 0.01585252f, 0.01588340f, -0.07871638f, -0.04878815f, 0.07054375f, 
    -0.14154971f, 0.14136226f, -0.01506025f, -0.00575962f, 0.02972716f, -0.05167629f, -0.01809671f, 0.02606980f, 
    0.08292871f, 0.04009813f, -0.12283652f, -0.10309409f, 0.07597288f, -0.01394599f, -0.26264533f, -0.11296266f, 
    -0.01244252f, 0.06630120f, -0.02437920f, -0.05562174f, -0.15965332f, 0.08360666f, 0.02308835f, -0.06480777f, 
    0.54602861f, -0.14770900f, 0.24544857f, 0.10133305f, -0.10168159f, -0.19236842f, -0.02134037f, -0.01407502f, 
    0.04229816f, 0.08046316f, 0.03230816f, 0.03340909f, -0.03645274f, -0.07727346f, -0.00667259f, 0.21274163f, 
    0.10457282f, -0.19413710f, 0.10439954f, 0.03358987f, -0.08363885f, 0.03837286f, 0.07644864f, 0.07987825f, 
    0.33588359f, -0.03188294f, -0.11715159f, -0.02894580f, -0.01961123f, 0.07841125f, -0.10840899f, -0.19601439f, 
    -0.05958022f, 0.01992566f, -0.13306817f, -0.11454070f, -0.15851064f, -0.31852865f, -0.00489512f, -0.10415729f, 
    0.10260880f, 0.12466964f, -0.03579965f, -0.05036299f, 0.33593401f, 0.05814746f, -0.12003035f, 0.04300259f, 
    0.58294034f, 0.18425329f, 0.17681715f, 0.12981042f, -0.08696011f, -0.07270948f, -0.06066046f, 0.02997326f, 
    -0.08248225f, -0.13161077f, 0.09230723f, 0.11437711f, -0.40435934f, 0.09388497f, 0.04797777f, -0.07276747f, 
    0.17002033f, 0.19751069f, 0.00405048f, -0.08303667f, -0.06920259f, 0.12959661f, 0.01089551f, 0.17289995f, 
    -0.23734772f, -0.32930213f, 0.06440592f, 0.08291110f, 0.05998494f, -0.09146846f, 0.16348842f, 0.14433536f, 
    0.00173817f, -0.04213092f, -0.04704041f, 0.08314186f, 0.57023013f, -0.16080192f, 0.08718322f, -0.16600423f, 
    -0.02187436f, -0.01473052f, 0.07627827f, -0.03602517f, 0.13105403f, -0.08521949f, -0.06569878f, 0.14984041f, 
    0.00144706f, -0.07993059f, 0.18455110f, -0.17676562f, -0.00430752f, 0.15293939f, 0.11546553f, -0.04386184f, 
    0.10065660f, -0.04966732f, 0.04802808f, 0.05568468f, 0.42840633f, 0.15990034f, 0.15517928f, -0.02210330f, 
    -0.01683136f, 0.03944056f, -0.06758334f, -0.16062468f, 0.09547000f, -0.01811141f, -0.11047703f, -0.14112784f, 
    0.19932967f, 0.14613858f, 0.21592972f, -0.10037193f, 0.01960923f, -0.01332956f, 0.04218841f, -0.12047625f, 
    0.00670330f, 0.00644663f, 0.04176004f, 0.00785718f, -0.12296690f, -0.25696605f, -0.21880586f, -0.54416478f, 
    -0.05272286f, -0.17671366f, -0.04914744f, 0.15632208f, -0.06002288f, 0.02245558f, -0.11626515f, 0.10271933f, 
    0.12110522f, 0.07030243f, -0.08986387f, -0.00137493f, -0.02767434f, 0.01977931f, 0.02167683f, -0.08305184f, 
    0.00721140f, -0.02335966f, 0.14142548f, 0.03403641f, 0.15216923f, -0.10705092f, 0.05145203f, -0.09574780f, 
    0.03619180f, 0.04557331f, 0.01661867f, 0.07409512f, -0.14924228f, -0.13505571f, 0.04402461f, 0.02942081f, 
    0.25320977f, 0.05181164f, 0.07375290f, -0.13242221f, -0.06116508f, 0.02700638f, -0.09612284f, -0.17924009f, 
    -0.00122637f, -0.07899258f, 0.08314001f, 0.02689937f, -0.08092105f, 0.01246622f, 0.10144962f, -0.00144103f, 
    0.13023975f, 0.08058129f, 0.11071470f, -0.16193159f, -0.02818125f, -0.01115266f, 0.02260413f, 0.01864843f, 
    -0.10971523f, -0.05254895f, -0.09861890f, 0.03122256f, -0.01880944f, -0.01758521f, 0.12614933f, 0.10977726f, 
    -0.00558610f, -0.17583327f, 0.05216162f, 0.03526496f, 0.00972229f, -0.03892456f, -0.08453619f, -0.00661630f, 
    -0.18568394f, -0.00586207f, 0.01247359f, -0.04792586f, -0.06450880f, 0.05151676f, 0.03860357f, 0.09766626f, 
    -0.16410659f, 0.10328453f, -0.08549410f, -0.07722625f, -0.02387886f, 0.00347364f, 0.02656405f, 0.12964745f, 
    -0.06077830f, -0.05620310f, 0.06277420f, -0.04427850f, -0.03768601f, -0.27389166f, -0.07506454f, 0.21923216f, 
    0.10290016f, 0.05172627f, -0.05516795f, -0.00688896f, -0.00130110f, -0.14389345f, 0.13348101f, -0.14762354f, 
    0.05296963f, 0.08327842f, -0.20441742f, 0.01558922f, -0.06522597f, -0.03160196f, 0.10619754f, -0.01867089f, 
    -0.02737478f, -0.04189940f, 0.02447117f, -0.05346544f, -0.12591420f, 0.41917944f, -0.31967154f, -0.04956499f, 
    0.03246137f, 0.01812279f, 0.03955051f, 0.05682408f, -0.01170380f, -0.02183515f, -0.00857314f, 0.00720741f, 
    0.20470728f, 0.17080359f, 0.00614370f, 0.23545539f, -0.01238246f, -0.00678541f, 0.03584717f, -0.04858131f, 
    0.03858100f, 0.01987795f, 0.03100169f, 0.24589017f, -0.29990149f, 0.20376937f, 0.03358094f, -0.23640908f, 
    0.06105701f, 0.05387146f, -0.04013934f, 0.04411123f, 0.01238663f, -0.20798098f, 0.11433659f, -0.17175506f, 
    -0.52942616f, -0.13328877f, 0.21113423f, -0.03805462f, -0.02618288f, 0.03511218f, -0.01318506f, 0.02479248f, 
    -0.02486067f, -0.01826002f, -0.00980774f, 0.01796135f, 0.28210747f, 0.19101688f, 0.47448841f, 0.59225756f, 
    -0.09930035f, 0.21228552f, 0.00077562f, -0.02714835f, 0.02334094f, -0.02720856f, -0.05069553f, 0.12020852f, 
    0.04612184f, 0.49377868f, 0.11923903f, 0.06767052f, 0.00600682f, 0.00043040f, -0.17875731f, 0.14418910f, 
    -0.09009843f, -0.11343843f, -0.24758631f, -0.10216952f, -0.10296672f, 0.05578652f, 0.13785429f, 0.03492946f, 
    0.13867481f, 0.11246699f, 0.03489310f, 0.09847807f, -0.02134958f, 0.00195945f, -0.04002173f, 0.02225700f, 
    0.01754989f, 0.03429592f, -0.03015672f, -0.14933607f, 0.02115338f, -0.03652162f, -0.10244132f, 0.03617972f, 
    -0.01336072f, 0.00644016f, -0.05088173f, 0.02647356f, 0.05990637f, -0.22735251f, -0.09028944f, 0.03747071f, 
    0.04607933f, -0.04829099f, 0.03774359f, -0.02421193f, 0.07571261f, 0.05127186f, -0.00680724f, 0.02192076f, 
    0.09514211f, -0.16206306f, -0.02780236f, 0.09059909f, 0.03936962f, 0.02445652f, 0.04844265f, -0.00629068f, 
    -0.07865448f, -0.10271976f, -0.01760286f, -0.05714350f, 0.03845804f, 0.13175365f, -0.21130665f, 0.14507857f, 
    -0.12455390f, 0.00705961f, 0.04806248f, 0.02751949f, -0.08971722f, 0.07655741f, -0.00100498f, 0.00984993f, 
    0.01616490f, 0.03834493f, -0.00288713f, -0.16555631f, 0.00160998f, -0.05258710f, 0.00618960f, -0.00926868f, 
    0.03807573f, 0.04896349f, 0.17944983f, -0.03273932f, -0.06662439f, -0.07044316f, 0.01170079f, 0.05847274f, 
    -0.02671587f, 0.02402798f, 0.00652106f, 0.06316211f, -0.03915794f, -0.10828706f, 0.07461314f, -0.07821731f, 
    -0.27620831f, -0.29445812f, 0.07225934f, 0.13843855f, -0.04321234f, -0.05487125f, 0.07552484f, -0.18421149f, 
    0.00934558f, -0.00867625f, -0.19625247f, -0.00546824f, -0.23883826f, -0.33179680f, 0.02238392f, 0.02565831f, 
    -0.04656714f, -0.02663113f, -0.00312458f, -0.16843227f, 0.03392829f, -0.03776095f, 0.02723155f, 0.01399722f, 
    0.00132513f, -0.12527427f, 0.00342387f, 0.13045312f, 0.07712977f, -0.00239717f, -0.06381343f, 0.02167464f, 
    -0.05365041f, 0.08497939f, -0.15191703f, 0.05508697f, 0.03005385f, 0.01303766f, 0.00621484f, -0.02277139f, 
    -0.00583293f, -0.01383138f, -0.03191578f, -0.00952924f, 0.13311839f, 0.17867872f, 0.03212345f, 0.06079550f, 
    0.07858387f, -0.12439321f, -0.05443797f, 0.08857847f, 0.06334898f, 0.02704430f, 0.00693022f, -0.04463828f, 
    0.03929674f, 0.01422409f, 0.08038272f, -0.09983107f, 0.08647112f, -0.17309923f, 0.01642837f, 0.15054154f, 
    -0.12772959f, -0.04202296f, -0.05526735f, 0.01106619f, 0.05427441f, -0.00099293f, -0.03011780f, 0.03039883f, 
    -0.67509669f, -0.35568500f, -0.04870091f, -0.03543014f, -0.04099078f, -0.09983428f, 0.08222733f, -0.03334314f, 
    -0.01158747f, 0.02730709f, -0.01263109f, -0.04279188f, -0.06036957f, -0.08348626f, -0.03462358f, -0.02790987f, 
    -0.05822515f, 0.01259339f, -0.00425472f, 0.03323705f, 0.02817035f, -0.02701304f, -0.00004569f, -0.01979092f, 
    -0.11546469f, 0.24678309f, 0.46922576f, 0.03327234f, -0.14792702f, 0.01904141f, -0.00920039f, -0.03551660f, 
    0.03112679f, 0.05363873f, -0.10561489f, -0.08760010f, -0.26642752f, -0.27094766f, 0.17587872f, -0.11436627f, 
    -0.00866669f, -0.02761074f, 0.03224319f, -0.06267693f, 0.06289933f, -0.02860383f, 0.06437711f, 0.02979823f, 
    0.06509945f, 0.09620504f, 0.09742203f, 0.12914754f, -0.04782630f, -0.00224294f, 0.03380255f, 0.01525757f, 
    -0.04684922f, -0.10220890f, 0.02522593f, 0.02485241f, -0.99549472f, -0.42484999f, -0.37836328f, -0.67635578f, 
    -0.04058199f, -0.07158156f, 0.04713024f, -0.05706808f, -0.05842285f, 0.00163968f, -0.04476926f, -0.01320696f, 
    -0.56036514f, -0.17778900f, -0.12185921f, -0.27563021f, -0.03088376f, 0.13946809f, -0.13302225f, -0.12106533f, 
    0.06377454f, -0.02536332f, -0.16412255f, -0.01948665f, -0.34388211f, -0.14933608f, 0.15307990f, -0.22186798f, 
    0.01327099f, -0.00608943f, 0.03204920f, 0.07283880f, -0.02412993f, -0.04868277f, 0.01306600f, -0.04713139f, 
    -0.09690081f, 0.20729135f, 0.14461207f, -0.33665323f, 0.07453325f, 0.00853354f, -0.00267015f, -0.00368710f, 
    -0.00106222f, -0.08143303f, 0.19251396f, 0.06085937f, -0.21665440f, 0.01494607f, 0.40283749f, 0.07010402f, 
    0.03211303f, -0.07553676f, -0.02503264f, -0.02130040f, 0.01477879f, -0.11313935f, 0.09154316f, -0.11680163f, 
    0.12880813f, -0.34895223f, 0.04295882f, -0.02332553f, 0.01904888f, 0.01261357f, 0.03171211f, -0.04960371f, 
    -0.01248262f, 0.01288187f, 0.02021305f, -0.06270776f, -0.07107497f, -0.00325643f, 0.03591070f, 0.14208066f, 
    -0.06310794f, -0.03822582f, 0.05500634f, 0.04717848f, -0.01787805f, 0.07371069f, -0.07951411f, 0.05960469f, 
    -0.21797980f, -0.02719990f, -0.07326704f, -0.28444502f, 0.05011961f, 0.02312397f, 0.01417505f, -0.07045135f, 
    -0.06425616f, 0.07114228f, 0.03188946f, 0.01482872f, 0.02331344f, 0.07149569f, -0.25919059f, 0.00450914f, 
    -0.01879744f, 0.14248814f, -0.04883372f, 0.12282196f, 0.00944626f, 0.07487817f, -0.02803149f, -0.07807352f, 
    -0.06338738f, -0.11888635f, -0.10953285f, 0.16625166f, 0.11169544f, 0.13095713f, 0.08377026f, 0.07154032f, 
    0.04062771f, 0.08080580f, 0.03810504f, -0.00386278f, 0.00517859f, 0.01809866f, 0.04974933f, 0.04587266f, 
    -0.16109356f, -0.06414687f, -0.14307199f, -0.05113793f, 0.04264535f, -0.01534815f, 0.02383544f, -0.02491407f, 
    -0.07864098f, -0.12377613f, 0.04722170f, 0.07780424f, 0.04951303f, 0.14224774f, -0.18051210f, 0.04845072f, 
    -0.04555092f, -0.05886702f, -0.11915927f, -0.05103505f, 0.17026730f, 0.43783551f, 0.07254043f, 0.39476314f, 
    -0.01591129f, -0.05624993f, -0.03002362f, 0.11880526f, 0.14176397f, -0.04942842f, -0.00074656f, 0.00746953f, 
    0.22286330f, -0.07756826f, -0.03405675f, -0.02574979f, 0.04653465f, -0.01919994f, -0.01729113f, -0.04467377f, 
    -0.03920488f, 0.10961284f, -0.08997423f, -0.12387099f, -0.16570042f, -0.35787156f, 0.14978954f, 0.24718180f, 
    -0.00257610f, 0.03941538f, -0.05372921f, 0.07317672f, 0.12720756f, 0.11520005f, -0.02582638f, 0.03609379f, 
    -0.17647283f, 0.19285479f, -0.44361210f, 0.08822755f, -0.00096509f, 0.06348168f, -0.11798158f, 0.06365215f, 
    -0.07715043f, -0.02977651f, 0.01830995f, -0.03550713f, -0.07700023f, -0.05063654f, 0.10468997f, -0.09976828f, 
    0.02109531f, -0.05432712f, 0.00462661f, 0.03529091f, 0.06077362f, -0.06593775f, -0.03379049f, 0.13279714f, 
    -0.00958793f, 0.02895989f, -0.25090948f, 0.17096321f, -0.05508641f, 0.01954391f, 0.01185234f, 0.02490668f, 
    -0.11383279f, -0.07215980f, 0.02419480f, 0.07154165f, -0.08775072f, 0.31485808f, 0.12217342f, 0.22580843f, 
    -0.06279612f, -0.00422218f, 0.06964558f, -0.02051340f, -0.02705563f, 0.01943136f, 0.05315008f, -0.03138966f, 
    -0.37392205f, -0.07175441f, -0.05413449f, -0.34667793f, 0.09622817f, -0.05425224f, 0.01093211f, -0.05741959f, 
    -0.07617336f, 0.01517362f, 0.08425966f, -0.01301222f, -0.08592312f, -0.21525082f, -0.06151465f, -0.05182594f, 
    0.22222762f, -0.17054021f, -0.08111234f, 0.15228795f, -0.03708678f, -0.12037931f, 0.22084220f, -0.03390599f, 
    -0.13323551f, 0.11424715f, 0.14465375f, -0.07579620f, 0.02103684f, 0.06515081f, -0.14813077f, 0.01215083f, 
    0.14796790f, 0.04735782f, -0.04122186f, 0.03254838f, 0.09039401f, 0.18656571f, -0.06707594f, 0.07107382f, 
    -0.01456822f, 0.02762346f, -0.04234168f, -0.06983676f, 0.02043789f, -0.05616046f, 0.00748993f, 0.04891643f, 
    -0.30568063f, 0.05482333f, 0.14421856f, -0.37781990f, -0.02211205f, -0.01314786f, -0.07905763f, 0.01417840f, 
    0.08595526f, -0.19383639f, 0.09115668f, -0.02302471f, 0.23663832f, 0.09186451f, -0.31872860f, 0.27770346f, 
    -0.15239589f, 0.01668270f, -0.06857989f, 0.09883275f, 0.01971468f, -0.10738349f, 0.13258462f, -0.00423694f, 
    0.30538160f, 0.13215131f, -0.12883584f, -0.23616400f, 0.18924478f, -0.13542897f, -0.05820062f, 0.11958675f, 
    -0.02996593f, -0.00426013f, 0.11210732f, -0.22516999f, -0.34323004f, 0.36260787f, 0.03390265f, -0.00761401f, 
    -0.07769393f, 0.07013235f, 0.02403134f, -0.29706666f, 0.02964395f, 0.19389796f, -0.04257120f, 0.25909874f, 
    -0.02224483f, 0.01464852f, -0.08783135f, 0.01033752f, -0.12351366f, 0.05183720f, 0.00454657f, 0.16644704f, 
    -0.05079316f, -0.11123907f, 0.03136673f, 0.05714753f, -0.20535943f, 0.12423886f, 0.53981960f, 0.36290342f, 
    -0.10646012f, -0.02647593f, -0.01481924f, 0.04903010f, 0.02891532f, -0.01618113f, 0.01340988f, -0.07032631f, 
    -0.28117383f, 0.00253731f, 0.00791249f, 0.05209507f, 0.00838132f, 0.06324325f, 0.03568028f, -0.00825951f, 
    0.08795082f, -0.01816577f, -0.03285344f, 0.04386858f, -0.40718642f, -0.33276746f, 0.19139020f, -0.42360595f, 
    0.16355047f, -0.11751591f, -0.38707048f, -0.31087586f, 0.04539181f, -0.06648940f, 0.02557220f, 0.00273342f, 
    -0.03112105f, 0.00948950f, 0.12684001f, 0.03956633f, -0.01792768f, 0.03190054f, 0.02594133f, 0.05565972f, 
    -0.00335253f, -0.23896417f, 0.02493391f, 0.03446601f, 0.02378551f, 0.00734366f, 0.04320269f, 0.02755837f, 
    0.00296110f, -0.03807664f, -0.05609501f, -0.01060109f, -0.03372964f, -0.06574780f, 0.05536789f, -0.11919864f, 
    -0.17912735f, -0.01791336f, 0.20706211f, -0.56507123f, 0.03337724f, -0.01043138f, -0.04249144f, 0.17615335f, 
    -0.01434564f, -0.08684715f, 0.04917484f, 0.02970886f, -0.21053870f, 0.00421424f, 0.03405551f, 0.14620335f, 
    -0.20167473f, 0.03583573f, -0.17009695f, 0.00545535f, 0.03632916f, 0.08901820f, -0.00674866f, 0.08954227f, 
    -0.05005020f, -0.12788551f, -0.06692094f, 0.03988701f, 0.03181259f, 0.04014047f, -0.03367648f, 0.01677977f, 
    -0.05161983f, -0.36453950f, -0.02618737f, -0.05398131f, -0.15176640f, -0.12660937f, -0.05396025f, 0.03963328f, 
    -0.07338928f, -0.02666659f, 0.07285261f, -0.13225289f, 0.05383990f, -0.01882373f, 0.07280308f, -0.02326588f, 
    0.03017310f, 0.05222902f, -0.17466737f, -0.26715800f, 0.15891536f, -0.24329303f, -0.04914923f, -0.12819640f, 
    -0.26541176f, 0.14594042f, -0.24596909f, 0.08578856f, 0.34713835f, 0.29713026f, -0.28464755f, -0.31474680f, 
    -0.10399845f, 0.02482946f, 0.15550981f, -0.11235306f, -0.02370734f, -0.04370603f, 0.18288702f, 0.07114968f, 
    -0.35098505f, 0.45482641f, -0.41338050f, 0.09979209f, -0.01154332f, 0.06713885f, 0.05653093f, -0.08341470f, 
    0.01669319f, -0.04843409f, -0.04866851f, -0.01106244f, -0.11283441f, 0.34782058f, 0.07344025f, 0.10050341f, 
    -0.09642027f, 0.00152507f, -0.02292731f, 0.02947943f, -0.15274322f, 0.08512761f, 0.09589539f, 0.10954607f, 
    0.33293128f, -0.09121550f, 0.08699133f, 0.17018886f, 0.12088860f, -0.02259964f, -0.06695511f, -0.09041035f, 
    -0.05301156f, 0.01690376f, -0.09010611f, 0.13318326f, -0.40822226f, -0.18972793f, 0.00910245f, -0.09174532f, 
    0.03732377f, 0.02475779f, -0.10730114f, -0.11295183f, -0.04648085f, -0.04417587f, 0.02176498f, 0.02036498f, 
    -0.54267341f, -0.13985170f, 0.05360840f, -0.23139435f, -0.29612553f, -0.12782528f, -0.21484239f, -0.04845594f, 
    0.05907854f, 0.10202775f, -0.01514073f, -0.00456588f, 0.16409262f, -0.16807419f, 0.06523737f, 0.19067146f, 
    0.09473970f, -0.02932231f, -0.03678153f, -0.02895444f, -0.02546415f, 0.06437564f, -0.04595385f, 0.10998731f, 
    0.10745960f, -0.07280780f, 0.13729826f, 0.35870656f, 0.06995996f, -0.05361668f, -0.12116700f, -0.05417057f, 
    -0.00535910f, 0.00262901f, 0.15505625f, 0.05988839f, -0.02188353f, -0.09849317f, -0.01427386f, 0.16865729f, 
    0.00616578f, -0.11308106f, 0.01296301f, -0.04396639f, -0.03299922f, 0.10180988f, -0.01139632f, 0.07475668f, 
    -0.04973007f, 0.11678080f, 0.40140331f, 0.16429578f, -0.15630385f, 0.07789656f, 0.05973360f, -0.03530333f, 
    0.20532686f, 0.14595929f, 0.12236194f, 0.19676383f, 0.03934253f, 0.40562785f, -0.30538043f, -0.27881527f, 
    0.01659895f, 0.10346077f, 0.04194847f, 0.06291857f, -0.03614280f, -0.00857411f, -0.09494635f, -0.01558036f, 
    0.23147316f, 0.21116498f, -0.05891137f, -0.19626518f, 0.12575833f, 0.11941770f, -0.14977005f, 0.13342501f, 
    -0.02457200f, 0.02992579f, 0.04191566f, 0.09697887f, 0.04062666f, 0.15888484f, -0.16414830f, -0.57430804f, 
    -0.02519123f, -0.12142771f, -0.12390546f, 0.11491784f, -0.12088463f, 0.04805022f, 0.09974789f, -0.15229104f, 
    -0.17881429f, -0.11242670f, 0.25649670f, 0.10770828f, -0.06691565f, 0.01453651f, 0.08644358f, -0.05361734f, 
    0.13037992f, 0.24351119f, 0.16234182f, 0.05123258f, -0.01406856f, 0.11944427f, -0.08856376f, 0.09352459f, 
    -0.11993131f, -0.20038062f, -0.09000880f, -0.14428036f, -0.06247953f, -0.00236502f, -0.06626046f, -0.13241842f, 
    -0.18144096f, 0.05964469f, -0.12725176f, 0.23844589f, 0.03107069f, -0.07230089f, -0.04615479f, -0.07992228f, 
    -0.03890850f, -0.06728084f, -0.03889125f, -0.00059057f, -0.01425589f, -0.18104985f, -0.04469312f, 0.20412263f, 
    0.10362516f, 0.05415501f, -0.00736679f, 0.14242940f, -0.00910773f, 0.05848322f, -0.04952569f, -0.02316171f, 
    0.72677767f, -0.13445473f, -0.11287853f, -0.12550734f, -0.03933042f, -0.07265767f, 0.05788267f, -0.01758618f, 
    -0.18181248f, -0.06056770f, -0.15733021f, 0.07060660f, 0.10284048f, 0.02639856f, 0.08281350f, 0.09289053f, 
    -0.08560839f, 0.03291837f, -0.09991571f, -0.00470580f, -0.04969193f, -0.03347345f, -0.03556715f, -0.08731905f, 
    0.24884932f, -0.21302705f, -0.03020229f, -0.11704396f, -0.08540743f, 0.03207970f, -0.28970689f, -0.05109690f, 
    -0.01790798f, -0.03752394f, 0.04250393f, -0.19980875f, 0.24887680f, 0.04270094f, -0.23805164f, -0.26072672f, 
    -0.03441019f, -0.07236530f, -0.00497332f, -0.13391672f, 0.10923869f, -0.01047046f, -0.14064085f, -0.01716586f, 
    -0.02590439f, -0.16659856f, -0.01766645f, 0.14712398f, 0.02333232f, -0.01659614f, 0.09017616f, 0.04469999f, 
    -0.03458606f, 0.03176437f, -0.14640640f, -0.02365112f, -0.34891781f, -0.14013380f, 0.11101533f, -0.12303863f, 
    0.10292814f, -0.16915457f, 0.00220019f, -0.05186296f, -0.09536271f, -0.04313522f, -0.24547598f, 0.05603283f, 
    0.14918658f, 0.78942347f, -0.17937705f, 0.13398021f, 0.23791198f, 0.07492922f, 0.28875023f, 0.04296925f, 
    -0.10055248f, -0.10882209f, 0.01680210f, -0.01809147f, -0.07467242f, -0.03363289f, 0.17662394f, 0.05786316f, 
    -0.09694723f, -0.07220810f, -0.16661216f, -0.10802327f, 0.01946890f, 0.01052391f, -0.08223667f, 0.04225855f, 
    -0.26070762f, 0.04925673f, -0.01989668f, -0.11538705f, -0.01360074f, -0.04020713f, -0.09060548f, -0.09222058f, 
    -0.05316879f, 0.05087103f, 0.06462168f, 0.03349139f, -0.00049787f, -0.15563256f, -0.03696652f, 0.13906066f, 
    0.07182276f, 0.04528010f, 0.12806201f, 0.08333218f, -0.02390744f, -0.02352236f, -0.01529635f, -0.00694654f, 
    -0.06025275f, -0.02099034f, 0.02698550f, 0.27491140f, -0.01687104f, -0.04232468f, 0.08005809f, 0.11937568f, 
    -0.05153976f, 0.01494551f, -0.00513600f, -0.03754913f, -0.27980670f, 0.06439494f, 0.27892435f, 0.22680353f, 
    0.02593177f, 0.00157779f, -0.19958122f, -0.15683003f, 0.03497026f, 0.05878476f, -0.00943375f, 0.12708630f, 
    -0.24062005f, -0.00524909f, -0.13465512f, 0.34152430f, 0.04281995f, 0.12224880f, 0.03066738f, 0.02025654f, 
    -0.05689070f, 0.16973795f, 0.04608497f, 0.04164872f, -0.36528084f, 0.49046439f, 0.00027746f, -0.10169674f, 
    0.24264809f, 0.11792041f, 0.05601267f, -0.06131383f, -0.10935120f, -0.06174821f, 0.15031253f, -0.05524101f, 
    -0.08482081f, 0.07565285f, -0.28550711f, 0.25785381f, 0.00426591f, -0.09548049f, 0.06036863f, -0.20002812f, 
    -0.05868909f, 0.06750811f, -0.03900562f, -0.07206209f, -0.11691574f, 0.01053064f, -0.16162218f, -0.42423785f, 
    0.02752003f, -0.07082357f, 0.01852750f, -0.16904978f, -0.10889568f, 0.04374747f, -0.14001021f, 0.19334786f, 
    -0.02916412f, -0.02165988f, -0.00447015f, 0.28104618f, 0.06494171f, 0.04296533f, -0.00673539f, 0.02398154f, 
    -0.01458844f, -0.00966635f, -0.02712296f, 0.01826386f, -0.24214345f, 0.37040803f, -0.17077135f, 0.11646675f, 
    -0.13814212f, 0.08707519f, 0.01208431f, -0.04163766f, 0.09259082f, 0.00345811f, -0.00269989f, 0.11651674f, 
    -0.16297472f, 0.04466998f, -0.08096178f, 0.08504152f, -0.04055779f, -0.04425585f, 0.02804156f, -0.07950062f, 
    -0.06505449f, -0.04823586f, -0.00151047f, 0.05245528f, -0.13226463f, 0.16105954f, -0.16128491f, -0.33299330f, 
    0.10290990f, 0.01220251f, 0.07786628f, 0.05802224f, -0.18975303f, -0.06703920f, -0.00805028f, -0.06506252f, 
    0.08172029f, 0.01040721f, -0.09136978f, 0.18202382f, 0.05105992f, -0.11356235f, -0.04681865f, -0.23363291f, 
    0.07983092f, 0.02068837f, -0.06765325f, 0.00433523f, 0.37095881f, -0.14360778f, 0.01165652f, 0.05915992f, 
    0.06346704f, 0.10771656f, -0.00839491f, 0.14098768f, -0.05822343f, 0.03036747f, -0.05792467f, 0.01529724f, 
    0.59306794f, 0.00067539f, 0.08995879f, -0.16532508f, 0.00113656f, 0.00486839f, 0.04557110f, -0.09781850f, 
    -0.08071633f, -0.03864459f, -0.02394751f, -0.00235241f, -0.35700324f, 0.63900858f, -0.13227388f, -0.51709276f, 
    0.28304282f, 0.08204576f, -0.00329585f, 0.01951190f, -0.30139738f, -0.01544118f, -0.09392903f, -0.00986352f, 
    -0.19650009f, 0.19824439f, -0.17589954f, 0.09665149f, 0.03660735f, -0.02911937f, -0.01759735f, -0.01473865f, 
    -0.07912791f, -0.05987312f, -0.00692361f, 0.03431691f, -0.13483235f, 0.04589960f, 0.00233749f, -0.28878486f, 
    -0.14234143f, -0.04928224f, 0.18785231f, 0.00085401f, -0.06944405f, -0.04870719f, -0.11826946f, 0.06666859f, 
    -0.17207333f, 0.10010365f, -0.25627291f, -0.41735485f, -0.18214741f, -0.13186258f, -0.06643840f, -0.01776316f, 
    0.07035145f, 0.15410168f, 0.00449160f, -0.07794757f, -0.32575786f, -0.13909976f, -0.06713024f, 0.08121234f, 
    0.18218341f, 0.09984031f, 0.07190365f, 0.00413700f, 0.01721856f, -0.01827915f, -0.04025079f, 0.03617179f, 
    -0.45663106f, 0.10534094f, -0.01605762f, 0.49021086f, 0.07337537f, -0.05601795f, -0.05745441f, -0.04046021f, 
    -0.08226587f, 0.00566756f, -0.08167159f, -0.16270888f, -0.19138312f, 0.09433410f, -0.00972259f, -0.15230022f, 
    0.03047475f, -0.10685699f, -0.16002966f, 0.01712635f, -0.12704772f, -0.07998414f, 0.00932845f, 0.01158308f, 
    -0.33936319f, 0.10031825f, -0.10454517f, 0.23786546f, -0.20523959f, -0.05084533f, -0.05550684f, -0.05961746f, 
    -0.10072309f, 0.16598801f, -0.10215042f, 0.06922278f, -0.27705693f, -0.03948597f, -0.22998951f, 0.32518512f, 
    -0.03478416f, 0.02561863f, -0.04060303f, -0.07803547f, -0.13160013f, -0.07892116f, 0.06351775f, -0.06050250f, 
    -0.18681251f, 0.00221548f, -0.11948214f, 0.04827607f, 0.02009605f, 0.07438453f, -0.02070161f, -0.14492249f, 
    0.14540587f, 0.15774812f, -0.10554931f, -0.05154361f, 0.19602010f, -0.06828227f, -0.24658906f, -0.30719888f, 
    0.05079074f, 0.00004372f, -0.11739605f, -0.10096366f, -0.06176975f, 0.03008110f, -0.14162198f, 0.05355219f, 
    -0.15964234f, 0.26896897f, -0.11756146f, 0.02954279f, -0.00718025f, 0.00616054f, -0.12089756f, -0.02151458f, 
    -0.12218869f, -0.02959641f, -0.00705791f, 0.11474190f, -0.81733531f, -0.04545588f, 0.10700605f, 0.00829273f, 
    -0.23306547f, -0.00602406f, 0.21778938f, -0.16084954f, 0.01883339f, 0.13840172f, 0.09481764f, 0.07573124f, 
    0.14008489f, -0.27304330f, 0.06735534f, -0.19656771f, -0.17637239f, -0.01445008f, -0.05677666f, -0.00081867f, 
    0.06993748f, 0.12650338f, 0.04534109f, -0.00398782f, 0.08044170f, -0.15882528f, 0.01283507f, 0.17365764f, 
    0.10415670f, -0.00190946f, 0.00788519f, -0.06127101f, -0.08171215f, 0.05499789f, 0.12736277f, 0.06954856f, 
    -0.40146732f, -0.06289010f, -0.03253769f, 0.03741419f, -0.17919599f, -0.03971012f, -0.25785488f, -0.18143526f, 
    -0.10870992f, 0.12986989f, -0.05413659f, 0.05133623f, -0.02692686f, -0.02698513f, 0.31454772f, 0.05997367f, 
    0.04591092f, 0.05564423f, -0.11834007f, 0.15835854f, 0.05758523f, -0.02093403f, 0.05241498f, 0.07063558f, 
    -0.11581522f, -0.11023684f, -0.14788942f, -0.10652190f, 0.23615396f, 0.15177916f, 0.06205104f, -0.12336229f, 
    -0.08612473f, -0.02520557f, 0.00822491f, -0.14679219f, 0.30016780f, -0.51915580f, 0.31468982f, -0.07240871f, 
    -0.23954229f, 0.03729612f, -0.06910971f, -0.00659778f, 0.07821126f, -0.15023223f, 0.00551241f, -0.11827128f, 
    -0.30681100f, -0.00797870f, 0.00669691f, 0.24145137f, -0.08724757f, -0.17791168f, 0.13328391f, -0.08420870f, 
    0.02445278f, 0.05237563f, -0.05824601f, 0.13523692f, -0.26312000f, 0.12051240f, -0.07675029f, 0.22930209f, 
    0.07723251f, -0.12504497f, -0.08324961f, 0.01051612f, -0.21277060f, -0.01525410f, -0.06977771f, -0.16420835f, 
    0.01597509f, -0.08858481f, -0.11392353f, 0.05287499f, 0.13053739f, -0.01959602f, -0.00874489f, 0.04315276f, 
    -0.01496853f, 0.04054637f, 0.04837945f, -0.00802527f, -0.00110970f, -0.14838825f, 0.08890112f, 0.10820419f, 
    0.02969361f, -0.01825124f, -0.05419958f, -0.00262962f, 0.06474391f, -0.02416649f, 0.00162377f, -0.01596213f, 
    -0.13209154f, -0.18841408f, 0.02277650f, 0.08077162f, 0.00208506f, -0.00172673f, -0.08787716f, 0.02846058f, 
    0.04317386f, 0.02942427f, 0.03778731f, 0.04899911f, -0.21760318f, -0.13570929f, -0.07365891f, 0.14241262f, 
    0.32314458f, 0.02694008f, -0.17448434f, -0.01072307f, 0.10731579f, 0.12130692f, -0.26540929f, -0.04281930f, 
    -0.07633545f, -0.29771608f, 0.15784641f, 0.06248985f, -0.10461608f, 0.06932359f, -0.07442939f, 0.00551182f, 
    -0.34283578f, 0.06023728f, -0.04522930f, -0.03150662f, 0.13848880f, -0.32620949f, -0.02953139f, 0.20822069f, 
    0.05188192f, -0.05545544f, 0.11557554f, -0.05835802f, 0.05960739f, -0.03832553f, -0.01913416f, -0.00083817f, 
    0.11153471f, -0.01140511f, 0.00005737f, 0.19129796f, -0.03899101f, -0.06973084f, 0.03696419f, 0.01627559f, 
    0.23252825f, -0.09284388f, 0.15239799f, 0.13962476f, 0.03721462f, 0.12815528f, -0.06129416f, 0.03865186f, 
    -0.02872362f, -0.04018925f, 0.04282285f, 0.03161528f, -0.31089818f, -0.15152171f, -0.17611869f, -0.11031628f, 
    -0.08846259f, -0.20160957f, -0.11019977f, 0.11303120f, -0.02343844f, -0.00707435f, 0.05110279f, 0.00888475f, 
    0.04418369f, 0.06411541f, 0.01312054f, 0.01567721f, -0.05756845f, 0.06376593f, -0.08650268f, 0.11473624f, 
    -0.19163780f, -0.08898518f, -0.03742893f, -0.17092422f, -0.03902997f, 0.00496553f, 0.08436031f, -0.04077563f, 
    -0.17533398f, 0.22890641f, 0.06206908f, -0.06590748f, 0.02874124f, -0.06449305f, -0.10070637f, -0.12030011f, 
    -0.25022340f, -0.19847731f, -0.07152617f, -0.07046174f, -0.01952193f, -0.08149215f, 0.06588647f, 0.10917486f, 
    -0.03001328f, -0.04609697f, -0.08033743f, -0.16753097f, 0.04288440f, -0.00244386f, -0.01492439f, 0.02155599f, 
    0.20141347f, 0.04688874f, -0.06930238f, 0.26081207f, 0.05869824f, -0.08854947f, -0.06096142f, -0.03960571f, 
    0.04256183f, 0.02919067f, -0.00071318f, 0.16711473f, -0.18512270f, -0.29620844f, 0.18310821f, -0.12774272f, 
    -0.00487470f, 0.04763024f, 0.00950369f, 0.03055680f, 0.00194445f, 0.20529824f, 0.11237411f, 0.18869977f, 
    0.19342533f, -0.05644253f, -0.06374925f, -0.00464865f, -0.09044442f, 0.01258968f, 0.04973071f, 0.00208744f, 
    -0.07028075f, -0.22222418f, -0.05269306f, -0.15039694f, -0.31194508f, -0.13965297f, 0.00472677f, 0.02541191f, 
    0.06184868f, -0.02080056f, -0.03429865f, 0.04258738f, -0.09309202f, -0.07739019f, -0.08015653f, 0.07076867f, 
    -0.01449281f, 0.20591128f, -0.12441774f, -0.07428922f, 0.01849922f, -0.11417370f, 0.01811006f, -0.06519432f, 
    -0.15840720f, 0.06626862f, -0.02118425f, 0.13994505f, 0.02477354f, 0.01088213f, -0.00652288f, 0.09081283f, 
    0.15550923f, 0.05402251f, 0.03903101f, 0.03885572f, 0.00892704f, 0.04632852f, -0.03641714f, 0.08086567f, 
    0.13660373f, -0.05487642f, 0.00528038f, 0.01231161f, 0.04819194f, 0.07266268f, 0.05055513f, 0.09752143f, 
    0.03151137f, -0.12080079f, 0.01449281f, 0.00301500f, 0.25698286f, 0.27452394f, 0.19895472f, 0.12599796f, 
    -0.08706613f, -0.11220008f, -0.08722951f, -0.02101070f, 0.19224481f, 0.04382836f, 0.03096022f, -0.01709766f, 
    -0.03636563f, -0.10634758f, -0.15423372f, 0.06831367f, -0.04303567f, -0.00364736f, 0.00078003f, -0.12280735f, 
    -0.04058719f, -0.04045667f, 0.07550181f, 0.07318779f, -0.06459235f, 0.04840871f, 0.00107673f, -0.01863114f, 
    0.01925419f, -0.03933915f, 0.02538651f, -0.00447329f, 0.15600617f, 0.13224030f, 0.15168566f, 0.30975029f, 
    -0.07660201f, -0.02644860f, 0.06755041f, -0.13996400f, 0.00239489f, -0.07469072f, 0.01471462f, 0.05504198f, 
    -0.03381055f, -0.05878571f, -0.14399296f, -0.09498115f, -0.18660766f, -0.02618595f, -0.08365130f, 0.14219061f, 
    -0.13180354f, -0.00481184f, -0.03359145f, -0.19006017f, -0.09812511f, 0.02285448f, -0.03533918f, 0.01752944f, 
    -0.02045677f, 0.12011468f, 0.09564881f, 0.06715786f, -0.05038362f, -0.05768996f, -0.00407322f, 0.06856014f, 
    0.04133235f, -0.03589623f, 0.01280995f, 0.10338414f, 0.12201340f, 0.02284322f, -0.00575606f, 0.04658250f, 
    0.13276055f, -0.00869261f, -0.00206099f, 0.01718089f, -0.01705821f, 0.00499213f, 0.01341377f, -0.04024573f, 
    -0.44540483f, -0.27580190f, 0.00664925f, -0.03955360f, -0.02752834f, 0.11081267f, -0.22765438f, 0.15807231f, 
    -0.10700270f, 0.10286277f, -0.11299668f, -0.03702185f, 0.10622922f, 0.09806573f, -0.17253304f, 0.11217737f, 
    0.12931655f, -0.02167504f, 0.09723683f, 0.01903179f, -0.06130563f, 0.03780671f, -0.08082075f, -0.09286249f, 
    0.01209025f, 0.05492530f, -0.09404592f, 0.13444561f, -0.00071265f, -0.06778726f, 0.08205678f, -0.03359529f, 
    0.02380790f, 0.07920254f, -0.15053861f, -0.00806598f, 0.04573261f, 0.14982203f, 0.19797543f, 0.19497617f, 
    -0.09079146f, -0.03904421f, 0.02688556f, 0.10052820f, 0.01441807f, 0.05756725f, 0.02865152f, 0.00125507f, 
    0.06100752f, 0.16818023f, 0.22429743f, 0.02689458f, 0.03241222f, 0.05613078f, 0.08856750f, -0.07177287f, 
    -0.09087881f, -0.00842374f, 0.01501692f, -0.08242550f, 0.28206593f, 0.07913753f, 0.11069296f, 0.17403388f, 
    -0.02015104f, -0.04492785f, 0.13696508f, 0.04202048f, 0.03291184f, -0.02761028f, -0.00191577f, 0.00233689f, 
    -0.36091575f, -0.08415487f, -0.14039803f, 0.16832469f, -0.00465752f, -0.10713620f, -0.05358590f, -0.03328297f, 
    0.00115779f, -0.12597799f, -0.10089851f, -0.03104233f, 0.14125176f, -0.07133058f, -0.08487908f, -0.07251503f, 
    0.01338034f, 0.08466046f, 0.00579555f, 0.01340190f, 0.10184903f, 0.00962431f, -0.15518788f, -0.07314801f, 
    -0.02323863f, -0.06294189f, 0.09101837f, -0.21689183f, -0.00083235f, 0.11836872f, -0.13420996f, 0.11276286f, 
    -0.06249487f, -0.01263598f, -0.08032788f, -0.03827301f, -0.20616969f, -0.03974398f, -0.11630137f, -0.13359129f, 
    0.10288579f, -0.04674469f, -0.10303038f, 0.01828577f, -0.08560994f, -0.02444222f, -0.14327809f, -0.10892706f, 
    -0.01609640f, 0.05873046f, 0.12763891f, 0.13592090f, -0.05879098f, -0.00414787f, -0.01168952f, 0.02698214f, 
    -0.04074966f, -0.00175355f, -0.05507618f, -0.02921888f, -0.00988303f, -0.19856234f, 0.29674804f, 0.34165078f, 
    -0.08500798f, -0.06901821f, -0.10486956f, -0.01033984f, -0.13600028f, 0.00411708f, -0.06834225f, 0.23357664f, 
    0.03037012f, -0.00138375f, 0.09697162f, 0.05447925f, -0.05903338f, -0.07165924f, -0.12501350f, -0.08717138f, 
    -0.01393200f, 0.03742066f, -0.05064040f, -0.00797137f, -0.01698342f, -0.05077564f, 0.12817827f, 0.01247212f, 
    -0.09607249f, 0.01885328f, 0.05081175f, -0.12429698f, 0.04045147f, 0.00673721f, -0.04644432f, -0.08647481f, 
    -0.00442028f, 0.11092629f, -0.03382512f, -0.04358708f, -0.03384883f, 0.06903590f, 0.06673897f, 0.05512819f, 
    0.01082428f, -0.05188342f, -0.00774664f, -0.02926030f, 0.11981644f, 0.17472138f, 0.09234736f, 0.02639370f, 
    -0.08111405f, -0.16386840f, -0.06232305f, -0.12678388f, 0.02954777f, -0.05968125f, -0.07418270f, 0.06460384f, 
    -0.32658163f, -0.03489943f, -0.32786027f, 0.00990184f, -0.01642709f, -0.01995224f, 0.05164998f, -0.07373526f, 
    0.10370663f, -0.04788410f, 0.08389939f, 0.36129186f, 0.04162314f, -0.41982111f, -0.18786751f, 0.04960460f, 
    -0.21633673f, -0.03246023f, -0.03856956f, -0.13745415f, -0.11586477f, 0.04682365f, -0.10845666f, 0.05435195f, 
    0.04173874f, -0.01612668f, 0.16375300f, -0.00659204f, -0.04322905f, 0.02898109f, -0.13740417f, -0.14051494f, 
    -0.18471353f, -0.02384581f, -0.12214833f, 0.04370209f, -0.10668366f, -0.21004263f, -0.53951412f, 0.06013392f, 
    0.00324515f, -0.02113493f, -0.01305783f, -0.03775542f, 0.09332794f, 0.06678534f, -0.02730402f, -0.05842572f, 
    0.02912391f, -0.19932230f, 0.01273761f, -0.09970706f, -0.03564697f, 0.05608324f, -0.03987458f, 0.02527085f, 
    -0.09681875f, -0.00389461f, 0.16557069f, 0.13907820f, 0.17650697f, 0.22535324f, 0.18513419f, 0.16850163f, 
    -0.01535206f, 0.00432769f, -0.08119551f, 0.07529491f, 0.20439982f, -0.15827988f, -0.11574634f, 0.13148475f, 
    -0.19766624f, 0.21592027f, -0.13367030f, -0.14435315f, 0.11071379f, -0.04487989f, 0.06394559f, 0.05453863f, 
    0.04621242f, -0.02711941f, -0.01407830f, -0.12231583f, 0.20228527f, 0.20531821f, -0.19305083f, 0.00551347f, 
    0.08284426f, 0.01783003f, 0.02235234f, -0.03500422f, -0.07137867f, -0.01449964f, -0.06252743f, -0.07994618f, 
    0.01290113f, 0.17028296f, -0.08197338f, -0.15715471f, 0.06371887f, -0.02588077f, 0.04926138f, -0.14841440f, 
    0.01796211f, -0.05692745f, 0.03408709f, 0.31408903f, -0.00985041f, -0.01766591f, 0.11250461f, -0.01339687f, 
    0.00147571f, -0.00745379f, 0.03967480f, -0.01659470f, 0.13509983f, 0.00629103f, -0.01535269f, -0.10706910f, 
    -0.14821082f, -0.19056247f, -0.36147156f, -0.43028602f, 0.09177881f, 0.03757799f, 0.06540635f, 0.04548972f, 
    0.00443338f, -0.00777042f, 0.03050031f, -0.15711983f, 0.11244214f, 0.05918531f, -0.16722316f, -0.10104033f, 
    -0.01121033f, -0.31251904f, 0.22296786f, 0.02046311f, -0.05268692f, -0.04980997f, -0.13160317f, -0.36769509f, 
    0.06523300f, -0.17007327f, 0.08005784f, 0.03274693f, 0.01767611f, -0.11353255f, -0.12566592f, -0.16818811f, 
    0.01412650f, -0.05869722f, -0.05429836f, -0.01152649f, 0.07509857f, -0.15541042f, -0.00329674f, -0.06063004f, 
    0.08283231f, -0.06824855f, -0.13367274f, -0.02722350f, -0.02877742f, -0.05992240f, -0.14419459f, 0.04519588f, 
    -0.06010642f, -0.06711728f, -0.08514112f, -0.08489044f, -0.12379109f, -0.22327559f, -0.08998019f, -0.12273284f, 
    -0.04201965f, -0.02560980f, 0.00572622f, -0.18433291f, -0.23270543f, -0.07919169f, 0.02482914f, 0.04209466f, 
    -0.08572932f, 0.02232366f, 0.03496049f, -0.12518111f, 0.01781382f, -0.04409496f, 0.01580665f, 0.14126730f, 
    -0.06902099f, 0.18928023f, 0.01484344f, -0.13889879f, -0.01925957f, -0.02902497f, 0.06855731f, 0.04895946f, 
    0.06503962f, 0.01231642f, 0.03598990f, -0.06631836f, 0.13196862f, 0.32884258f, 0.06694610f, 0.30930063f, 
    0.07000643f, -0.11131991f, 0.05379821f, -0.20524658f, 0.02353601f, -0.02564438f, 0.12043419f, -0.07407642f, 
    0.16668822f, -0.06908717f, -0.01409479f, -0.04040162f, -0.01473521f, 0.00932469f, 0.04963317f, 0.01793269f, 
    0.04280569f, -0.09129193f, -0.03188559f, -0.02002303f, 0.15171006f, 0.01381975f, -0.04746800f, 0.21998376f, 
    0.13996178f, 0.10307200f, -0.07698641f, -0.08332332f, 0.01418870f, 0.02384088f, -0.05550238f, -0.00294963f, 
    0.16671041f, 0.22778639f, -0.05504108f, 0.15303196f, 0.05497835f, -0.03145791f, 0.05921198f, 0.08057059f, 
    0.07280177f, 0.00257264f, -0.06224220f, 0.00156894f, 0.11268885f, -0.00532403f, 0.13801408f, -0.11945847f, 
    -0.10834293f, 0.01536656f, 0.11717859f, -0.12090072f, 0.16942063f, 0.00794900f, -0.01740037f, -0.11181246f, 
    0.26842722f, -0.04727808f, -0.09536386f, 0.04749425f, -0.05299940f, 0.00034711f, -0.16743386f, -0.08152986f, 
    -0.00930823f, -0.09604286f, -0.09212214f, -0.02146244f, 0.07762612f, 0.20822734f, 0.18488014f, 0.16359493f, 
    -0.04682089f, 0.11140346f, 0.07845028f, 0.18648086f, 0.01250957f, -0.09787887f, -0.02340273f, -0.02363837f, 
    0.05082633f, -0.23088636f, -0.00552792f, -0.08056083f, 0.03009012f, -0.06005338f, 0.04130470f, -0.01482420f, 
    0.01405775f, 0.04245903f, 0.08387239f, 0.02177574f, 0.09565105f, 0.03615474f, 0.16085857f, -0.13215292f, 
    0.05915502f, 0.02282321f, -0.08664538f, -0.03421270f, -0.08317908f, 0.03482340f, 0.15037778f, 0.25873658f, 
    0.37302169f, 0.05288444f, 0.14909807f, 0.00112167f, 0.06463564f, -0.05968169f, -0.02093727f, 0.09604897f, 
    0.08464229f, -0.03203419f, -0.12273280f, 0.03509261f, 0.07759875f, -0.04293587f, 0.32211840f, 0.26864806f, 
    0.01464382f, 0.03270241f, -0.04613096f, 0.01387761f, -0.01292776f, -0.07410160f, 0.01531821f, -0.00019613f, 
    -0.41269973f, 0.16444410f, -0.03152760f, -0.11043105f, -0.00101780f, -0.00579749f, 0.09499817f, 0.01525284f, 
    0.05709691f, -0.09242801f, 0.06957514f, -0.18466903f, -0.01866813f, -0.17067441f, 0.21645775f, 0.14028007f, 
    -0.10188761f, 0.03811986f, -0.05167935f, -0.00179408f, 0.07625524f, -0.00210490f, 0.16487008f, 0.27966890f, 
    -0.12732191f, -0.19786906f, 0.00491239f, 0.10303940f, 0.04860460f, 0.00704212f, -0.03859980f, 0.01610829f, 
    0.03061182f, -0.01298679f, 0.03636491f, -0.01956463f, -0.25173172f, -0.05337086f, 0.06432197f, -0.16560224f, 
    0.10932866f, -0.02234034f, -0.05039113f, 0.14896518f, -0.00919700f, -0.08056591f, 0.00115977f, 0.08584384f, 
    -0.06585658f, -0.06274296f, -0.54556441f, -0.07700717f, -0.02177692f, 0.04876632f, 0.02440771f, 0.03500384f, 
    0.25207663f, 0.17108881f, 0.03486088f, 0.08801132f, -0.11417029f, 0.03666644f, 0.04015017f, 0.01217826f, 
    0.01101377f, 0.08913215f, 0.07178817f, -0.03523398f, 0.05953183f, 0.06988796f, 0.12275454f, 0.04210372f, 
    -0.16369420f, -0.09475009f, -0.09807121f, 0.00845986f, -0.01172245f, 0.05220862f, -0.04749886f, 0.09410777f, 
    -0.06330245f, -0.12574051f, 0.00582713f, -0.17634730f, -0.12402428f, 0.17170693f, -0.00061556f, 0.05795195f, 
    -0.01073249f, -0.05718018f, 0.00591589f, 0.07400722f, -0.26966953f, -0.25201297f, -0.21271262f, -0.18632965f, 
    -0.27360356f, -0.06651254f, -0.00699466f, 0.12038570f, 0.03374150f, -0.15157355f, -0.07224261f, -0.02886204f, 
    0.22924602f, 0.09874688f, -0.03382711f, -0.02011852f, 0.29383716f, -0.31821272f, 0.29247174f, 0.30229032f, 
    -0.07374533f, 0.03339800f, -0.03740726f, -0.02477422f, -0.06434063f, 0.01379678f, 0.08647262f, -0.10659320f, 
    -0.02585685f, -0.05501357f, -0.35954243f, -0.07015636f, -0.03264493f, 0.13070969f, -0.02529867f, 0.03434679f, 
    -0.01921298f, -0.35309309f, -0.07409466f, -0.35983321f, -0.04456777f, -0.03097972f, -0.05864563f, -0.03312409f, 
    -0.00439614f, -0.15674554f, -0.05045651f, -0.03906511f, -0.09747207f, 0.07344161f, 0.01124196f, 0.15946312f, 
    -0.10975402f, 0.01453705f, 0.06855524f, -0.09998998f, 0.06729738f, -0.06430778f, -0.08194884f, 0.01142923f, 
    0.05797423f, 0.21500224f, 0.05431799f, -0.05611369f, 0.15773080f, 0.12924863f, -0.07473997f, -0.02311057f, 
    -0.02494346f, 0.13230115f, -0.00132468f, -0.03630046f, 0.01727683f, -0.06666836f, -0.06745983f, -0.01592728f, 
    -0.41597456f, -0.10196508f, 0.10484665f, -0.00373085f, -0.15167347f, -0.17469522f, 0.05665388f, 0.33598706f, 
    0.01242728f, -0.02728092f, 0.13192056f, 0.13333267f, -0.02128530f, -0.00386902f, -0.17993531f, -0.04124549f, 
    0.06783327f, 0.08758088f, 0.04300955f, 0.04504441f, -0.07487939f, -0.16686530f, -0.37335169f, -0.57528931f, 
    -0.05498848f, 0.33561015f, 0.06710114f, -0.00601981f, -0.12624113f, 0.09383447f, -0.05229618f, -0.00551619f, 
    0.06517267f, 0.03674140f, -0.02796965f, 0.22271894f, -0.01238014f, -0.10576575f, 0.18540476f, 0.05618894f, 
    -0.09615241f, -0.08577383f, 0.03886062f, 0.09720615f, 0.05309110f, 0.02555864f, -0.09796342f, 0.05330757f, 
    -0.03345095f, 0.10559579f, 0.09744495f, -0.11285627f, 0.09412407f, 0.02991970f, -0.16640334f, -0.09142569f, 
    0.03933363f, -0.00938617f, 0.01910736f, -0.01358481f, -0.06992876f, -0.10001498f, -0.00532840f, 0.01543897f, 
    -0.10468825f, 0.04030930f, -0.07456240f, -0.01170445f, 0.08977207f, 0.06868640f, 0.15726507f, 0.07983028f, 
    -0.02375785f, -0.28097346f, -0.06328449f, -0.38751623f, -0.00707133f, -0.01837104f, -0.09786222f, 0.02260640f, 
    -0.06100575f, -0.03452663f, -0.11919068f, 0.16297741f, 0.07219577f, 0.10810313f, -0.07352754f, -0.12891895f, 
    0.23078051f, 0.18068595f, -0.02656948f, -0.01211718f, 0.06769311f, -0.13878202f, 0.12655528f, 0.02577017f, 
    0.03385492f, -0.25507295f, 0.20947699f, 0.08335838f, -0.06949896f, 0.00958552f, -0.02287933f, 0.03886190f, 
    0.11097495f, -0.11838140f, -0.02825966f, 0.01600121f, 0.06122040f, 0.16942339f, 0.08314700f, -0.14972693f, 
    0.23806126f, 0.11189039f, 0.08546737f, -0.16120784f, 0.04265966f, 0.06080383f, 0.05173194f, 0.01797920f, 
    0.28756899f, 0.09162343f, 0.08152615f, -0.03701050f, 0.01182129f, 0.03848068f, 0.05658729f, -0.00426075f, 
    0.10984211f, -0.03498933f, 0.05736193f, 0.06493748f, -0.13863680f, -0.07798191f, -0.05114894f, -0.05124992f, 
    0.02853085f, 0.10581719f, -0.05375326f, 0.05413411f, 0.02244577f, -0.00139706f, 0.02267584f, 0.02037263f, 
    0.19030894f, 0.09283241f, -0.20747489f, -0.23304942f, -0.17124711f, 0.04724059f, -0.01804014f, -0.01779230f, 
    0.01153212f, 0.01846261f, -0.30074030f, -0.05323697f, -0.00398519f, 0.04654390f, -0.13250671f, -0.09018018f, 
    -0.02428823f, -0.02875618f, -0.06159609f, -0.09961346f, 0.11918738f, 0.12003379f, -0.21648233f, -0.09732629f, 
    0.11013025f, 0.14932942f, 0.25727260f, -0.43886200f, -0.11560428f, 0.04285074f, -0.11022244f, -0.07057995f, 
    -0.01809270f, -0.04418271f, 0.04059920f, 0.12633038f, 0.14244778f, -0.17936088f, 0.02557214f, -0.05060617f, 
    -0.09694040f, 0.04688206f, 0.01465709f, 0.11150723f, -0.05840237f, -0.06803712f, 0.13081868f, -0.14752993f, 
    0.11648948f, -0.06367254f, 0.17304772f, 0.09188643f, -0.00018572f, 0.15157971f, -0.01921320f, -0.16708590f, 
    -0.07895285f, 0.05176785f, 0.02171803f, -0.08645853f, -0.04792042f, -0.14135765f, 0.18852320f, 0.02374062f, 
    -0.02154232f, -0.19381100f, 0.04202325f, 0.00198825f, -0.07701520f, 0.04259996f, -0.12933560f, -0.15844804f, 
    0.14719796f, -0.06110485f, 0.16109313f, -0.13531706f, 0.18466350f, 0.07241108f, 0.00341947f, 0.21702145f, 
    -0.09746896f, 0.06729817f, 0.08280476f, -0.01222384f, -0.05857079f, -0.03968023f, -0.12187804f, 0.08772560f, 
    0.15339237f, -0.02351095f, 0.02783422f, 0.02532303f, -0.05214541f, 0.23119903f, 0.17604125f, -0.02492627f, 
    0.03591301f, -0.06053757f, 0.02163318f, -0.01430188f, -0.07329591f, -0.17025924f, -0.10393507f, 0.00285354f, 
    0.10704888f, 0.10101930f, 0.01651429f, 0.08448336f, -0.46823546f, -0.47576344f, -0.16009088f, -0.11760133f, 
    0.06396578f, -0.01367976f, -0.01539996f, -0.01174684f, 0.06701568f, 0.12974231f, 0.06000040f, -0.16966546f, 
    -0.02079918f, 0.04954166f, 0.19420500f, 0.29069349f, 0.00558863f, -0.05841986f, -0.01144611f, 0.03275111f, 
    -0.05724361f, -0.04991452f, -0.26073253f, -0.33541808f, -0.39320850f, -0.05581618f, 0.41125223f, -0.25967577f, 
    -0.10529439f, -0.09607499f, -0.04275502f, 0.02065116f, 0.02978310f, 0.00150769f, -0.26972759f, 0.03567862f, 
    0.27930090f, -0.00087806f, 0.35509485f, -0.02516460f, 0.11439551f, 0.00027777f, -0.04584997f, -0.03203104f, 
    0.12308154f, 0.02856625f, -0.06690788f, 0.09866675f, 0.01713633f, 0.03881951f, -0.15504248f, 0.20306949f, 
    0.06421807f, -0.02589149f, -0.09089205f, 0.06160450f, 0.00436110f, 0.00963793f, 0.25609082f, -0.05285968f, 
    -0.04497272f, -0.23680705f, 0.13779530f, 0.18936394f, -0.00011543f, 0.03144668f, 0.06842238f, -0.03914545f, 
    0.09055976f, -0.10544931f, -0.01811640f, -0.07182401f, 0.00486208f, -0.42983669f, -0.03395427f, -0.35990143f, 
    0.06645424f, 0.00195196f, 0.01053882f, 0.01488838f, 0.06571642f, -0.17219843f, 0.07949650f, -0.18308213f, 
    0.03000463f, 0.10571274f, -0.46713388f, -0.35453799f, 0.02265638f, 0.15663897f, -0.09129359f, 0.01612267f, 
    0.06058464f, -0.06816899f, -0.04390327f, 0.00791810f, -0.09427374f, 0.22111185f, 0.05347731f, -0.25973663f, 
    -0.23830234f, 0.20890725f, -0.06892864f, -0.00563051f, 0.17654850f, -0.00157118f, -0.09731882f, -0.07522556f, 
    -0.10173319f, -0.15361413f, -0.06878681f, -0.01957756f, -0.05706018f, -0.01161972f, 0.04408337f, 0.26699933f, 
    0.16996141f, -0.26418898f, 0.18962485f, -0.32548606f, 0.18322751f, -0.02611552f, -0.13839853f, 0.00816652f, 
    0.02002232f, -0.02481609f, 0.00909532f, 0.11552463f, -0.18455154f, -0.00007343f, 0.02906272f, 0.05432040f, 
    0.10566684f, -0.23658773f, -0.31112939f, 0.10582071f, 0.01508258f, 0.05957719f, 0.02163041f, -0.04046850f, 
    0.10200407f, -0.00318664f, -0.01567201f, 0.02289469f, -0.14056292f, -0.33603051f, 0.03686450f, 0.11795466f, 
    -0.17240471f, -0.00107469f, -0.26823559f, 0.10553720f, -0.04446304f, 0.00726205f, 0.19044970f, 0.05438920f, 
    0.14002903f, 0.35640517f, 0.00617711f, -0.07208663f, 0.02650506f, -0.04271708f, 0.07373665f, 0.08063672f, 
    0.10515030f, 0.04541786f, 0.05080891f, 0.10132760f, -0.09456512f, -0.06032656f, -0.27797663f, -0.02595521f, 
    0.06709602f, 0.02015724f, -0.13036442f, 0.17438851f, 0.09699405f, -0.14253293f, 0.07169358f, -0.29217160f, 
    0.07675918f, -0.02602240f, -0.17873694f, 0.23961656f, 0.27783743f, 0.03427622f, -0.07491709f, 0.12933627f, 
    -0.02910300f, 0.05519246f, -0.10811287f, 0.09641958f, -0.26622778f, 0.04948514f, -0.08197089f, -0.20821851f, 
    -0.06690760f, -0.31616643f, -0.18771322f, -0.03415505f, -0.06105182f, -0.11336897f, -0.04558031f, -0.03162042f, 
    0.12935995f, -0.18338881f, -0.19396885f, 0.25725958f, 0.10005244f, -0.01277455f, -0.04004545f, 0.03278227f, 
    0.00925456f, 0.00376827f, -0.06441005f, 0.06364863f, 0.21821089f, 0.05186647f, -0.01020914f, 0.18325657f, 
    0.04527043f, 0.07340103f, -0.02127336f, -0.11696265f, 0.01350465f, 0.00127589f, -0.09321178f, -0.16159248f, 
    -0.32311687f, -0.40980002f, 0.05937362f, -0.13453008f, 0.00865890f, 0.02233054f, -0.08081883f, 0.08541030f, 
    -0.06034632f, -0.01864756f, -0.08506074f, 0.15429251f, -0.39484233f, 0.14755951f, -0.16307883f, -0.12651744f, 
    -0.01483643f, -0.13402437f, -0.00549972f, 0.02404599f, 0.02392085f, 0.15393406f, -0.05335645f, -0.06470107f, 
    0.11880011f, -0.21259770f, -0.26071972f, 0.09941905f, 0.16329062f, 0.01297682f, 0.06662813f, 0.14118117f, 
    0.05116530f, -0.00932561f, -0.03386552f, -0.14958067f, 0.17449096f, -0.07500685f, -0.03408853f, -0.03138462f, 
    0.01892455f, 0.05786047f, -0.16702512f, 0.15303583f, 0.09628137f, -0.01751402f, 0.02763395f, 0.10969899f, 
    -0.04409860f, 0.12707733f, 0.07037998f, -0.12570632f, -0.14850803f, 0.03642068f, -0.00806640f, -0.16641904f, 
    0.14828639f, 0.29406336f, -0.02097835f, 0.01487872f, -0.09438808f, -0.01144873f, -0.04947504f, -0.18664849f, 
    0.18204086f, 0.06982179f, 0.03574375f, -0.12114532f, 0.03655039f, -0.01292700f, 0.05187470f, 0.06637319f, 
    0.04311376f, -0.01169221f, -0.00660535f, -0.06877928f, 0.06014053f, 0.05034621f, 0.06365614f, -0.07262174f, 
    -0.05082425f, 0.00523518f, -0.12868261f, -0.04217482f, -0.00398355f, -0.08460955f, -0.14724843f, -0.19644211f, 
    -0.05705035f, -0.09813346f, 0.09389649f, -0.02817069f, 0.00310003f, 0.08044289f, 0.01739325f, 0.14574549f, 
    -0.00483107f, -0.13571015f, 0.04454450f, 0.13148716f, 0.12039675f, -0.12296616f, -0.11776537f, -0.01907193f, 
    -0.13286227f, 0.08440811f, 0.00347179f, 0.03745010f, -0.29886967f, -0.33464932f, -0.12141792f, 0.11682639f, 
    0.13886611f, 0.14049280f, -0.12168803f, -0.17137946f, -0.02372882f, 0.04404255f, 0.01340005f, 0.06512566f, 
    -0.08402619f, 0.05053954f, 0.04705085f, -0.01542859f, -0.05351390f, 0.04982667f, 0.02895597f, 0.01229266f, 
    0.09894457f, 0.13222219f, 0.11090177f, 0.06093804f, 0.06053259f, 0.15127893f, 0.08889954f, 0.17533323f, 
    0.05631941f, -0.13502835f, -0.03379710f, 0.16339462f, 0.01364351f, 0.04512861f, 0.02375941f, 0.05634600f, 
    0.15079674f, -0.12395150f, -0.28929335f, -0.04056469f, -0.04095710f, 0.09005365f, 0.06693537f, 0.06963563f, 
    -0.06178832f, 0.01321618f, -0.03111410f, -0.05169313f, -0.75493950f, -0.54767674f, -0.00816599f, 0.05966360f, 
    0.09613806f, -0.26600185f, 0.06586987f, 0.03249681f, -0.03306361f, -0.00895526f, 0.03696866f, 0.04541707f, 
    0.39150926f, 0.23288745f, 0.18839307f, 0.32038632f, 0.02911597f, -0.10389710f, -0.05144894f, -0.08145303f, 
    0.01855195f, 0.05213084f, -0.00601249f, 0.10854828f, -0.28398234f, -0.39837193f, 0.12155313f, 0.20042627f, 
    -0.10548409f, -0.32518953f, -0.12631501f, -0.18352324f, -0.01829526f, -0.01619595f, -0.00269543f, -0.14809015f, 
    0.01910716f, -0.12470216f, -0.06303830f, 0.06244296f, 0.02210308f, 0.13595437f, 0.18710122f, -0.04867140f, 
    0.02596385f, -0.03839268f, 0.09428889f, 0.02177593f, 0.01014260f, -0.01352493f, 0.03998175f, 0.07798434f, 
    0.01859006f, -0.02284998f, -0.02158781f, 0.04592893f, 0.02566444f, 0.05545684f, 0.13412835f, -0.02268873f, 
    -0.05679169f, -0.05457323f, 0.17332791f, 0.02559491f, 0.00066758f, -0.06698358f, -0.08001190f, 0.02993818f, 
    -0.01707158f, -0.08895381f, 0.11066508f, 0.18701135f, -0.11169903f, 0.04356048f, -0.17622662f, -0.01916350f, 
    -0.00435151f, 0.00407416f, -0.00256879f, 0.12395253f, -0.11706606f, -0.10753756f, 0.04537787f, -0.05850989f, 
    0.12384619f, -0.00106401f, 0.08883587f, -0.06880757f, -0.00620785f, 0.06166735f, -0.03096888f, 0.02783797f, 
    -0.00981088f, 0.08221766f, 0.02652358f, 0.15131894f, 0.00254339f, -0.06782617f, -0.04826403f, -0.05652543f, 
    0.05790596f, -0.08018678f, 0.05877011f, -0.05418478f, -0.08751283f, -0.12589714f, -0.07447158f, -0.05810887f, 
    0.23349123f, 0.38620842f, -0.17975260f, -0.01779505f, 0.04512643f, -0.02446468f, -0.13694364f, 0.15826029f, 
    -0.01477560f, 0.03514684f, 0.13131817f, -0.01079290f, -0.75555652f, 0.05511184f, 0.27037516f, -0.59201187f, 
    -0.18402998f, -0.24794611f, -0.11030177f, -0.15171994f, -0.16626871f, 0.02440488f, 0.01622377f, 0.03833893f, 
    0.09179289f, -0.10538840f, -0.06713142f, 0.10279632f, 0.07789820f, 0.03804534f, -0.03115364f, 0.12948006f, 
    0.08627068f, -0.01770306f, 0.22955947f, 0.05626497f, -0.00796339f, 0.00769170f, 0.05973468f, -0.08103020f, 
    0.03166518f, -0.00899743f, 0.05247862f, -0.02270258f, 0.03810134f, 0.10072909f, 0.07823086f, 0.00640383f, 
    -0.11300072f, -0.16161165f, -0.01882977f, 0.03396112f, 0.08366304f, -0.01386545f, -0.01057147f, -0.04296010f, 
    0.07184599f, -0.02499231f, 0.03004156f, 0.20769490f, 0.10336519f, -0.40610293f, -0.40803373f, 0.15313821f, 
    -0.20962207f, -0.02282126f, 0.07405422f, 0.21835129f, -0.00124750f, -0.08811577f, 0.00244549f, -0.08601070f, 
    -0.33327615f, -0.43268824f, -0.51297605f, -0.23671550f, -0.06556289f, -0.05515894f, -0.17369775f, -0.28604844f, 
    -0.03628728f, -0.01553398f, 0.01310578f, 0.04466005f, -0.01279888f, -0.05222106f, 0.04353407f, 0.06716833f, 
    -0.02586102f, 0.00779928f, 0.06356690f, 0.02106224f, -0.08568664f, -0.16061652f, -0.10016476f, -0.01657054f, 
    -0.29238120f, 0.27709177f, -0.00584302f, 0.07121673f, -0.06319509f, -0.04004313f, 0.03526839f, 0.12487517f, 
    0.09038460f, 0.08125709f, 0.12282354f, -0.10080267f, -0.01838355f, -0.21114662f, 0.11874653f, -0.13549456f, 
    0.02892066f, 0.05978384f, -0.03312863f, 0.05533674f, 0.02237271f, 0.05314715f, -0.05901296f, -0.04495281f, 
    -0.01966152f, -0.13812433f, -0.26391351f, 0.16477950f, -0.11075787f, 0.09039902f, -0.14101480f, 0.14113335f, 
    0.07323628f, 0.11317776f, 0.09055154f, 0.08825312f, -0.55583751f, -0.68494403f, -0.48410368f, -0.07819300f, 
    -0.13872679f, -0.19122395f, -0.37068576f, -0.42333528f, -0.02588005f, -0.03772400f, -0.04206848f, -0.06706332f, 
    -0.27311364f, -0.44335046f, -0.20205487f, -0.40873069f, -0.01225036f, -0.21974199f, -0.04719730f, -0.22441460f, 
    0.05388807f, -0.02493842f, 0.05542686f, -0.07260833f, -0.26347151f, -0.32780156f, -0.20486753f, -0.03438261f, 
    0.07180338f, 0.15756187f, 0.11042833f, -0.01371514f, -0.03218238f, -0.02057803f, -0.06185281f, -0.02358029f, 
    0.32068396f, 0.12821558f, -0.07365553f, -0.24310619f, 0.05991901f, -0.12491671f, 0.19487377f, -0.00905193f, 
    0.06693100f, 0.23726204f, -0.13063088f, -0.02394589f, -0.11903764f, 0.03125206f, 0.00293018f, -0.10915085f, 
    -0.09727719f, 0.00200894f, -0.08396754f, 0.00411199f, 0.06897496f, -0.04949166f, 0.06888809f, 0.10042357f, 
    0.06606778f, -0.43417537f, -0.24926129f, -0.13553101f, -0.10908468f, -0.00586850f, -0.03756384f, 0.12155953f, 
    -0.01523561f, 0.15268609f, -0.18599580f, -0.06364127f, -0.04744263f, 0.03106716f, -0.03544033f, 0.09489945f, 
    0.03388647f, -0.04048133f, 0.05788457f, 0.11763161f, -0.03183488f, -0.05142522f, 0.03222542f, 0.02080412f, 
    -0.26364490f, -0.39450526f, -0.37836823f, 0.22048596f, 0.01338647f, 0.13371915f, 0.02311684f, -0.28775743f, 
    0.02247440f, -0.10611446f, 0.01587002f, 0.05299861f, -0.12663247f, -0.14665782f, -0.19023256f, 0.25653714f, 
    0.07956057f, 0.11286995f, 0.18140000f, -0.00289894f, 0.02455245f, -0.01848660f, 0.10315077f, 0.13550660f, 
    -0.36124384f, -0.04609842f, -0.22867312f, 0.07158580f, -0.29082897f, 0.18732895f, 0.02400855f, -0.05910273f, 
    0.08949787f, 0.06938433f, -0.10977186f, -0.02965437f, -0.08763033f, -0.01414329f, 0.07727403f, 0.16090024f, 
    0.04692147f, -0.04800561f, -0.06183504f, 0.05452105f, -0.10156827f, 0.07663351f, -0.12421655f, 0.01842658f, 
    -0.16475475f, -0.18360676f, 0.01985260f, -0.00008284f, 0.00200075f, -0.42518234f, 0.00795733f, 0.12359307f, 
    -0.05990493f, 0.00946820f, -0.08549210f, -0.07200027f, -0.42585927f, -0.13530351f, 0.44618329f, 0.23656960f, 
    -0.06070805f, 0.07486641f, -0.10390727f, -0.10298492f, -0.00227112f, 0.12820971f, 0.02737163f, 0.07439569f, 
    -0.04551177f, -0.06265062f, -0.21186970f, -0.09983257f, -0.10830147f, 0.04888566f, 0.07448683f, -0.01201827f, 
    -0.00597641f, 0.02745128f, 0.20480873f, 0.22807410f, -0.26727241f, -0.19535100f, 0.24120237f, 0.06970312f, 
    -0.03246995f, -0.07812783f, 0.02637873f, 0.13024464f, 0.01497955f, 0.04689515f, 0.20069702f, -0.14408675f, 
    -0.39841533f, -0.63309324f, -0.61916763f, 0.21028924f, -0.07997168f, -0.06786541f, -0.02327196f, -0.03289576f, 
    -0.02391646f, -0.00047548f, 0.08593562f, 0.08608089f, 0.03697340f, -0.12454680f, -0.05077945f, -0.10220455f, 
    -0.04116746f, 0.06343121f, 0.07333265f, -0.08413174f, -0.05343876f, 0.09484056f, -0.15310459f, -0.03634908f, 
    0.06558787f, -0.02799226f, -0.05213444f, 0.10148986f, -0.01729631f, 0.03730881f, 0.00992854f, 0.13604075f, 
    -0.02253612f, -0.05223226f, 0.10609373f, -0.02981042f, -0.30188400f, 0.55403888f, 0.12993890f, -0.08752225f, 
    -0.07546066f, -0.00243345f, -0.06057096f, 0.07481128f, 0.07135365f, 0.00749645f, -0.01093350f, 0.14963406f, 
    -0.16152905f, -0.29579404f, 0.11201145f, 0.01192463f, 0.07358535f, 0.01688488f, 0.12925471f, 0.00312147f, 
    -0.02408522f, -0.01902679f, -0.04259685f, 0.03095154f, -0.16245586f, -0.17956981f, 0.09222824f, 0.06279680f, 
    0.05077904f, -0.09413104f, 0.09074746f, -0.11091585f, 0.10757153f, 0.04846523f, -0.29571488f, -0.07478756f, 
    0.21933180f, 0.24661228f, -0.15658206f, -0.01328602f, -0.06447604f, 0.15056491f, 0.13762467f, -0.09689624f, 
    0.21054648f, -0.02988121f, 0.16482940f, 0.09085327f, 0.51448840f, 0.32119003f, -0.13228805f, 0.01823300f, 
    -0.01682711f, -0.11871398f, -0.10796329f, 0.14077419f, 0.06340163f, -0.01042036f, 0.01232695f, -0.07006882f, 
    -0.21772610f, -0.18978579f, -0.06750842f, -0.32107773f, 0.07579165f, -0.04199156f, 0.04371153f, -0.06997927f, 
    -0.02238316f, 0.14433433f, -0.06300180f, 0.06279632f, 0.01500841f, -0.00090153f, 0.05403496f, -0.01575258f, 
    -0.00078006f, 0.12648965f, 0.15173207f, -0.08853331f, -0.06115548f, 0.25370637f, -0.12296614f, -0.00330274f, 
    -0.48435128f, -0.45390165f, 0.02610184f, 0.32044697f, 0.09047738f, -0.03789597f, -0.14820343f, -0.19401801f, 
    0.01186987f, 0.10829374f, -0.09496940f, 0.03552214f, 0.35667527f, 0.27773374f, -0.26812655f, 0.05539205f, 
    -0.03722949f, 0.02962372f, 0.09395212f, 0.03407212f, 0.13263062f, 0.01670241f, 0.08612229f, -0.07656432f, 
    0.14768338f, 0.13692632f, -0.15046453f, -0.26802373f, -0.06413306f, -0.03561138f, 0.13590932f, -0.14868575f, 
    -0.06001569f, 0.01087259f, -0.05398496f, -0.01817794f, -0.33616093f, -0.35197759f, -0.20391199f, -0.00825100f, 
    -0.11955120f, -0.05555812f, 0.15314473f, -0.09996756f, -0.06817523f, 0.03540598f, 0.06626745f, 0.09720378f, 
    0.05771916f, -0.03534247f, -0.05727131f, -0.07481147f, 0.11348800f, -0.03107270f, 0.11469501f, 0.01157830f, 
    -0.02849199f, 0.03785644f, 0.06071479f, 0.01384050f, 0.15590629f, -0.74994963f, -0.17581108f, -0.39641291f, 
    -0.01506477f, 0.12066404f, 0.26442525f, 0.09082302f, 0.04324652f, 0.07290137f, -0.02084314f, 0.05486970f, 
    -0.09861302f, 0.05530474f, 0.23020519f, 0.00708855f, -0.01911728f, -0.03548655f, -0.00566487f, 0.08214772f, 
    0.03609695f, 0.04464846f, -0.01678032f, -0.05903116f, -0.14770795f, 0.17006089f, 0.00342376f, -0.11649086f, 
    -0.02884541f, 0.04707468f, -0.08289655f, -0.04363940f, 0.02046843f, -0.05981683f, -0.01259974f, 0.04569512f, 
    0.15349522f, -0.26174083f, -0.08618183f, -0.05177717f, 0.02273713f, 0.08192405f, 0.17657492f, -0.20043373f, 
    -0.02549697f, 0.07632849f, -0.01423074f, 0.05239372f, 0.20000845f, 0.18197052f, -0.40163189f, -0.23281126f, 
    -0.07979742f, -0.09678077f, 0.06713908f, 0.12436483f, 0.08434854f, 0.05572322f, -0.04149321f, -0.15932180f, 
    -0.32975420f, 0.04592588f, 0.39162064f, 0.03830562f, -0.00413731f, -0.17697160f, -0.03944932f, -0.03087759f, 
    -0.08090248f, 0.10455005f, -0.08014908f, 0.01990640f, -0.19108126f, -0.21771580f, -0.08611613f, -0.02863144f, 
    0.03781110f, 0.00269321f, -0.01534937f, -0.22190274f, -0.01800752f, -0.06211888f, -0.08775968f, -0.08495720f, 
    0.09448894f, 0.06206016f, 0.02637529f, -0.08014451f, 0.02608812f, -0.05687504f, 0.01179705f, -0.05770764f, 
    -0.04854410f, -0.02518693f, -0.05890188f, 0.01850672f, 0.30211920f, -0.12189516f, -0.05311548f, -0.05754225f, 
    -0.05419370f, 0.04443913f, -0.10977934f, 0.00465529f, -0.05442204f, -0.00402547f, -0.05687812f, 0.04511689f, 
    0.06775740f, -0.02616007f, -0.12015808f, -0.11330174f, -0.14740045f, -0.07252052f, -0.02708076f, 0.10573377f, 
    -0.15376748f, 0.04332097f, 0.02355600f, -0.03274847f, 0.15903673f, -0.24902232f, 0.01833463f, -0.07129921f, 
    -0.05815317f, -0.03587182f, -0.08639292f, -0.01789564f, -0.04342774f, 0.03723793f, 0.00575233f, 0.02684287f, 
    0.51120919f, -0.25724286f, -0.22012189f, -0.02889251f, -0.05060650f, -0.08707625f, 0.02615037f, -0.00396375f, 
    0.17606589f, -0.08267128f, 0.00907622f, -0.01515764f, 0.12021552f, -0.18183906f, 0.14288457f, -0.29965228f, 
    -0.02455254f, 0.09320068f, 0.01010979f, -0.02567222f, -0.10844303f, 0.14961229f, -0.09324997f, -0.07058287f, 
    0.02552563f, -0.06132458f, 0.03881847f, -0.10420732f, 0.02817763f, 0.02224968f, -0.06987288f, -0.00623958f, 
    0.07382680f, -0.01528258f, -0.01136417f, -0.04191203f, -0.15088010f, -0.43591449f, -0.33214274f, -0.36537957f, 
    -0.08898338f, 0.17155388f, -0.03904288f, 0.05203791f, 0.09493206f, 0.03312059f, -0.07214004f, -0.00518290f, 
    -0.35049859f, -0.03211686f, -0.29175073f, 0.30676147f, -0.07597030f, 0.01035501f, 0.18001704f, -0.02496251f, 
    0.01896258f, 0.03568094f, 0.07247304f, -0.06789036f, -0.33124885f, -0.37419859f, -0.19188425f, -0.19804668f, 
    -0.14701958f, -0.00791034f, -0.07020640f, -0.01296900f, 0.05277336f, 0.02734337f, -0.04141986f, 0.01268256f, 
    0.09949284f, 0.08807104f, -0.03122739f, -0.03537956f, -0.03299872f, -0.09864891f, 0.10932568f, -0.00769081f, 
    0.02761756f, 0.06612325f, 0.09840991f, 0.03978989f, 0.01122923f, -0.02764649f, -0.15752693f, 0.04231030f, 
    0.07154473f, -0.03375122f, -0.00574888f, -0.02766068f, -0.04957378f, 0.18413392f, 0.02688483f, -0.12288735f, 
    0.30901417f, 0.07871393f, -0.22437337f, -0.15416977f, -0.00696144f, 0.05850412f, 0.01903451f, 0.02659340f, 
    -0.18133089f, 0.03609664f, 0.11029910f, 0.04455720f, 0.15855527f, 0.01068531f, -0.09612908f, -0.14160983f, 
    0.01961984f, 0.04385221f, 0.00683506f, -0.06557113f, -0.05222138f, 0.01867911f, -0.07944692f, -0.20797098f, 
    0.01224079f, 0.14228506f, -0.02979483f, 0.15446332f, -0.03241704f, 0.00768394f, -0.02984169f, 0.06336829f, 
    -0.01442312f, 0.02517002f, -0.06828566f, -0.13372858f, 0.08696207f, 0.07156275f, 0.04767305f, -0.06945230f, 
    -0.03273414f, -0.03615142f, -0.03588740f, -0.06029150f, -0.21255924f, -0.08688498f, -0.05496400f, 0.07147156f, 
    -0.06805293f, 0.09997833f, 0.06709426f, 0.07971633f, 0.05289740f, -0.03096695f, -0.00658353f, -0.02104974f, 
    0.01600106f, -0.16249372f, 0.06640975f, 0.07236154f, -0.35268256f, -0.35547847f, -0.09139801f, 0.00896458f, 
    0.19491082f, -0.00104609f, -0.04704028f, -0.08795721f, 0.06763612f, 0.01009996f, 0.08804061f, 0.03305171f, 
    0.26116967f, -0.13572970f, 0.11979598f, -0.08784442f, 0.05920175f, 0.01814081f, -0.31432858f, -0.19080064f, 
    -0.04898839f, -0.08045298f, -0.06623753f, -0.11897232f, -0.02758073f, 0.04739572f, -0.09272365f, 0.06531686f, 
    -0.03493540f, -0.02987510f, -0.02110748f, -0.06720935f, 0.07321767f, 0.03655516f, 0.07717349f, 0.03912452f, 
    -0.37472373f, 0.44106564f, 0.25633651f, -0.10614970f, 0.00059545f, -0.11285126f, 0.02223097f, 0.08845538f, 
    -0.07937670f, 0.01226929f, 0.01959682f, -0.15842570f, 0.17816027f, -0.53342038f, 0.09314182f, -0.02914571f, 
    0.10668640f, 0.08477014f, -0.05811622f, -0.14359900f, -0.01660754f, -0.06608010f, 0.00353922f, 0.07010201f, 
    -0.25321934f, -0.22921480f, -0.03823640f, -0.13146165f, 0.05571583f, -0.06273843f, -0.00972826f, 0.22657019f, 
    -0.04613522f, -0.07013567f, -0.01704356f, 0.04492167f, -0.00072651f, 0.01591444f, 0.03743492f, -0.04246532f, 
    -0.01798143f, -0.00509078f, 0.00397663f, -0.03777700f, -0.01727904f, -0.00971978f, -0.01710742f, -0.06102150f, 
    -0.06128576f, -0.17990544f, -0.17875288f, 0.04585652f, 0.09755288f, 0.01365365f, 0.16712487f, 0.01141084f, 
    -0.11473276f, 0.04840389f, 0.08200509f, -0.04708176f, -0.09463234f, 0.13180314f, 0.04684330f, -0.14725225f, 
    -0.18267523f, -0.02922584f, -0.07333762f, -0.01450324f, 0.01268931f, -0.12984292f, 0.08499251f, 0.00011933f, 
    0.44423431f, -0.56183374f, 0.30944851f, -0.17641544f, -0.05223691f, -0.00095568f, -0.15193251f, 0.04588770f, 
    0.02154379f, 0.07131179f, -0.00992221f, 0.04880177f, -0.36074790f, -0.39365321f, -0.23846184f, 0.20571411f, 
    0.05014626f, 0.01529044f, 0.01875270f, 0.12226436f, -0.01016916f, -0.01809911f, 0.01552333f, -0.03513248f, 
    -0.49821109f, -0.04524580f, 0.30117711f, 0.34478316f, -0.09511655f, -0.06448613f, -0.09373005f, -0.10078677f, 
    -0.05732962f, -0.04365802f, -0.00538525f, -0.06114171f, -0.13185449f, 0.01043538f, 0.05167048f, -0.03619412f, 
    -0.00237198f, -0.13367303f, -0.04383892f, 0.03808550f, 0.05981229f, -0.00718586f, 0.02067389f, -0.04246920f, 
    -0.04471327f, -0.12857585f, 0.08356684f, 0.05303739f, -0.04709010f, 0.01351976f, -0.06729840f, 0.00437743f, 
    -0.03474394f, -0.14931569f, -0.08260202f, -0.14667481f, 0.18805060f, -0.08908822f, -0.00471691f, -0.20536543f, 
    -0.00097408f, 0.06855480f, 0.04765152f, 0.10491449f, -0.09082245f, -0.01366567f, 0.04636306f, -0.08674331f, 
    -0.06898510f, 0.00296140f, 0.28541607f, 0.01533384f, 0.02991389f, -0.01102314f, -0.08916251f, -0.03913959f, 
    0.02860666f, -0.07723672f, -0.04890296f, 0.06787132f, 0.04455728f, -0.00231603f, 0.01611847f, -0.14944902f, 
    0.00456842f, 0.01049535f, -0.07812212f, -0.00106068f, -0.00130629f, 0.04735436f, 0.01308926f, -0.15247066f, 
    -0.27945814f, -0.39516604f, 0.09524357f, 0.30387947f, 0.07091147f, 0.08572043f, -0.00557157f, 0.02663760f, 
    -0.00441790f, -0.00588179f, 0.01125291f, -0.02547046f, 0.16031805f, -0.06026958f, -0.09283289f, -0.12837133f, 
    0.00612438f, -0.16665290f, 0.00001763f, 0.02198656f, -0.12673213f, 0.12000521f, 0.01832270f, -0.00326852f, 
    -0.29388309f, -0.38297468f, -0.03139662f, -0.18456946f, -0.06969212f, 0.03451401f, 0.17346436f, 0.05226032f, 
    -0.03546062f, -0.07764203f, -0.05059625f, 0.03869638f, 0.14506596f, 0.04882784f, -0.00787184f, -0.15936705f, 
    -0.00786348f, -0.04784623f, 0.03606293f, 0.16131108f, 0.00882510f, -0.00897891f, 0.02050141f, -0.11444774f, 
    0.09355203f, -0.05773179f, 0.15268347f, 0.03945542f, -0.02618213f, 0.04737028f, 0.16918150f, 0.00409785f, 
    0.03162789f, -0.00810553f, 0.03281911f, 0.01100616f, 0.53161591f, -0.49146166f, -0.07435838f, -0.41578302f, 
    -0.06550361f, -0.09141560f, -0.34948868f, 0.19494389f, -0.02771657f, 0.03440690f, 0.05674830f, 0.04577430f, 
    0.02051467f, -0.08541159f, 0.14206074f, 0.20366631f, 0.00207537f, 0.02054665f, 0.02739161f, -0.12576854f, 
    -0.00879277f, 0.03982655f, -0.11389305f, 0.12103651f, 0.62981623f, -0.68579072f, 0.09793045f, -0.43705389f, 
    0.07078005f, 0.07555556f, -0.23197770f, 0.02585759f, -0.08601101f, 0.10889308f, -0.03227077f, -0.06495190f, 
    0.06192711f, -0.64553827f, 0.52944720f, 0.25935051f, -0.08994644f, -0.10755906f, 0.04535976f, 0.12475484f, 
    -0.02929343f, -0.05759693f, -0.08987272f, -0.10280228f, 0.00954194f, -0.06422891f, -0.02237238f, 0.09192000f, 
    0.00148021f, -0.03767282f, -0.07137551f, 0.03842184f, 0.01080970f, -0.12722410f, -0.02132636f, 0.04281010f, 
    0.16899022f, -0.07581365f, 0.05495456f, -0.10067976f, -0.01829075f, -0.01140030f, -0.06095829f, -0.03222983f, 
    0.07396422f, 0.04738010f, -0.15390199f, -0.15856577f, 0.09539872f, -0.88800049f, -0.26200259f, -0.40949076f, 
    -0.08896869f, 0.02295460f, 0.07237026f, 0.04745529f, 0.13420872f, 0.09341082f, 0.05702968f, 0.03900321f, 
    0.14183038f, 0.22165889f, -0.02904001f, 0.01685662f, -0.03937199f, 0.04240827f, 0.06067384f, 0.06652020f, 
    -0.02910119f, -0.03535408f, 0.07227772f, -0.00884004f, 0.02709742f, -0.05983886f, 0.28800869f, -0.17732503f, 
    -0.14020820f, 0.18565370f, 0.06280319f, 0.05268966f, -0.08915678f, 0.04198458f, -0.02388447f, 0.06281029f, 
    -0.06223491f, 0.01434756f, 0.24267772f, 0.16019824f, 0.02845697f, -0.02784787f, 0.05727535f, -0.08851101f, 
    -0.26983413f, 0.08832262f, 0.05698452f, -0.03110732f, -0.30626655f, -0.17250177f, -0.29639077f, -0.03584483f, 
    0.01532243f, -0.04296250f, 0.05467074f, -0.03399375f, -0.14472692f, 0.04099781f, 0.13376054f, 0.07780325f, 
    -0.08118121f, 0.16755733f, 0.10508582f, 0.00656521f, 0.07154454f, -0.01395807f, 0.08043895f, -0.01160340f, 
    0.04638907f, 0.03328674f, 0.06135496f, -0.04526365f, 0.29902568f, 0.16715954f, -0.25583196f, 0.01985170f, 
    0.01152316f, 0.10522182f, -0.08749416f, -0.02157142f, 0.01266325f, -0.02594188f, 0.02605155f, 0.01268558f, 
    -0.03450723f, -0.10663030f, 0.29897213f, -0.00098686f, 0.01004041f, 0.01096745f, -0.04844217f, 0.07516573f, 
    -0.00622656f, -0.02750932f, 0.03225149f, -0.06914757f, -0.08220001f, -0.06195563f, 0.09247754f, -0.04434220f, 
    -0.05557808f, -0.03577338f, 0.11508124f, -0.02867348f, -0.22444272f, -0.08116685f, -0.05418140f, -0.11874162f, 
    -0.05734079f, 0.10390636f, -0.20275179f, 0.10011872f, -0.11833378f, 0.08184193f, -0.04089951f, -0.09621209f, 
    -0.09172370f, 0.03492564f, -0.02255134f, 0.05311256f, 0.05300776f, -0.46844137f, -0.31059328f, -0.43656817f, 
    0.04775732f, 0.02359503f, -0.03903405f, 0.30093932f, 0.04645573f, 0.04146236f, -0.11298398f, 0.12446483f, 
    -0.03319260f, 0.05806968f, -0.00858561f, -0.10753714f, -0.03549070f, 0.00868439f, -0.06832854f, -0.00818131f, 
    0.06610249f, 0.02618342f, 0.01148299f, -0.01048031f, -0.72369248f, 0.44277725f, -0.14511923f, 0.14749523f, 
    -0.06456953f, -0.09672910f, 0.04280876f, 0.14745346f, 0.09599895f, -0.07528144f, 0.07391491f, 0.03743879f, 
    0.29538062f, 0.04135963f, -0.02367865f, -0.17783076f, -0.00020116f, -0.01785378f, -0.03422017f, -0.02241945f, 
    0.04182740f, -0.09597567f, -0.06762300f, -0.11715343f, -0.12216308f, 0.16954844f, -0.00250130f, 0.03620396f, 
    -0.03954549f, 0.06328427f, -0.02203243f, -0.02311671f, 0.05021225f, 0.05011519f, 0.12711315f, 0.03384508f, 
    0.01855256f, 0.26600403f, -0.00107580f, -0.02335955f, -0.02780557f, -0.04721902f, -0.07084954f, 0.02782605f, 
    -0.03765967f, 0.08368278f, 0.06018230f, 0.03822136f, -0.01353146f, -0.14682236f, -0.00623428f, -0.03398776f, 
    0.10875941f, -0.23508134f, 0.02640774f, -0.12887330f, -0.03292101f, -0.02929303f, 0.01091421f, 0.04352887f, 
    0.11910274f, 0.07627553f, -0.03984056f, -0.00157001f, -0.05373409f, 0.06029481f, 0.02119336f, 0.09192675f, 
    -0.03239226f, 0.11270291f, -0.03785961f, 0.06913422f, -0.27202505f, 0.07538840f, 0.02102136f, 0.04753581f, 
    -0.06842718f, -0.01437931f, -0.11292761f, -0.04479369f, -0.01105823f, 0.03648343f, -0.03733005f, 0.00802982f, 
    0.02818723f, -0.10324911f, 0.00352812f, -0.16877842f, -0.02643054f, 0.03452775f, 0.01601977f, 0.02547055f, 
    -0.01116371f, -0.01126449f, 0.04206900f, -0.02958230f, 0.20132038f, -0.02994507f, -0.04793066f, -0.13775453f, 
    -0.09334257f, -0.03883609f, -0.12524343f, 0.04633838f, 0.05568925f, 0.13613126f, 0.07413110f, 0.00035024f, 
    0.37013462f, 0.19023187f, -0.03901013f, -0.08089066f, -0.07981088f, -0.06795780f, 0.05441407f, -0.02074593f, 
    0.12471604f, -0.08906277f, 0.04257434f, 0.08247240f, 0.24859621f, 0.39133632f, 0.04973942f, -0.18300687f, 
    0.00297929f, -0.11686023f, -0.01715292f, -0.01447855f, -0.02951549f, -0.04920165f, -0.07777967f, -0.00865112f, 
    -0.12824942f, -0.02659335f, 0.09240037f, 0.01614570f, 0.06712669f, 0.11409564f, 0.09560915f, 0.05187592f, 
    -0.31373045f, 0.03282323f, -0.20183256f, -0.56115204f, 0.09692153f, -0.10734017f, 0.04990415f, -0.03989726f, 
    0.08057099f, 0.04806253f, 0.03265418f, -0.05146483f, 0.03207483f, -0.03624424f, 0.07073468f, 0.09775430f, 
    0.01445736f, 0.14533572f, -0.05603218f, -0.04905079f, 0.00503779f, -0.12621719f, 0.03956793f, -0.03483479f, 
    -0.03891195f, -0.04185937f, 0.02375113f, -0.03836012f, -0.46089640f, -0.39784721f, -0.38404721f, 0.23585589f, 
    0.11085076f, 0.07970798f, 0.17347106f, 0.06130860f, -0.01125509f, -0.04913104f, 0.04257404f, -0.00614816f, 
    -0.49705592f, 0.18592612f, 0.21981725f, 0.42799214f, -0.04099881f, 0.13023290f, 0.04705612f, 0.08370557f, 
    0.02637945f, 0.15547244f, 0.15337685f, 0.01322962f, -0.00044873f, -0.24347971f, -0.14042208f, 0.20147482f, 
    0.16025566f, 0.11291205f, -0.00495689f, -0.00863841f, -0.01260774f, -0.02304037f, 0.14152806f, 0.09534843f, 
    -0.18966149f, -0.09732243f, 0.05596950f, -0.05971967f, 0.01756231f, -0.07735875f, -0.10145390f, -0.05559328f, 
    -0.28922898f, -0.08527576f, -0.15830682f, -0.20471041f, 0.15420736f, -0.02993772f, -0.05193743f, -0.07599161f, 
    -0.07036744f, -0.04586821f, -0.03388034f, -0.02771769f, 0.06335693f, -0.13000654f, 0.00247329f, -0.09590656f, 
    0.05645615f, -0.09331399f, -0.06745657f, -0.06112942f, -0.06002180f, 0.04287329f, 0.00590861f, -0.03645350f, 
    0.18367627f, 0.13205995f, 0.07021035f, 0.10692499f, 0.36515749f, 0.10223981f, -0.11019180f, -0.26194629f, 
    0.07871567f, -0.09044334f, 0.00020714f, -0.00022684f, 0.16791269f, -0.00100892f, 0.14523470f, 0.05432172f, 
    -0.22590968f, -0.13400581f, 0.04785226f, 0.13507171f, 0.06375197f, -0.09160281f, -0.11311284f, 0.03447745f, 
    -0.02075997f, 0.00598329f, -0.11332929f, -0.30981323f, -0.04765433f, -0.11444382f, -0.07751539f, -0.16517426f, 
    -0.07154243f, -0.08660507f, -0.00863900f, -0.02389544f, -0.01975554f, 0.02661706f, 0.00486311f, -0.07267046f, 
    -0.42076620f, -0.12268724f, -0.14616951f, -0.08095965f, 0.11790346f, 0.05680873f, -0.08077826f, -0.03227192f, 
    0.07380311f, 0.16317588f, 0.08912105f, 0.14975934f, -0.33155531f, -0.49265695f, -0.37037945f, -0.11841920f, 
    -0.01732851f, 0.09401056f, 0.07990693f, 0.10286500f, -0.08676340f, 0.06808934f, -0.00284954f, 0.04128340f, 
    -0.04701564f, -0.05861633f, -0.04404447f, -0.16816828f, 0.11029734f, -0.00263769f, 0.15658890f, -0.08818860f, 
    0.00141441f, 0.02859671f, -0.13167734f, -0.21848039f, -0.13171108f, -0.00388147f, 0.07536214f, -0.00013583f, 
    -0.03156116f, 0.04309414f, 0.02502326f, 0.01927856f, 0.00080814f, -0.00829055f, -0.17315416f, -0.47350392f, 
    0.18212757f, 0.01039214f, -0.01951731f, -0.03183935f, 0.05349604f, -0.09086660f, 0.17687744f, 0.04408190f, 
    0.10936129f, 0.01286037f, 0.08167797f, -0.01117003f, 0.57312113f, -0.17601970f, 0.06374428f, -0.11024807f, 
    0.13907182f, -0.19830661f, -0.01776765f, 0.00541828f, -0.02143029f, 0.04736352f, 0.09281249f, -0.10962540f, 
    -0.04315947f, -0.41489831f, -0.45022234f, -0.39547288f, -0.24234079f, -0.10851570f, 0.01860704f, -0.16397096f, 
    -0.05827797f, -0.03044459f, -0.02871130f, -0.07438102f, -0.09495493f, -0.07595005f, 0.05292939f, -0.09636711f, 
    -0.06021244f, -0.06103747f, -0.02992653f, 0.04420691f, 0.08197535f, 0.02035001f, 0.10208301f, 0.03766290f, 
    0.08993998f, -0.21973515f, 0.08944486f, -0.06168376f, -0.11127805f, -0.03365704f, 0.05877182f, -0.09048808f, 
    0.15665767f, -0.01032120f, 0.08212816f, 0.01613543f, -0.16279925f, 0.04481357f, 0.06082977f, 0.19019148f, 
    -0.06391370f, -0.03412016f, 0.07474707f, 0.15992016f, 0.18566357f, 0.02683445f, 0.05423210f, -0.00030648f, 
    0.04205409f, -0.05618192f, -0.28101715f, -0.19361426f, 0.15470752f, 0.00906732f, 0.07961809f, 0.07226471f, 
    0.08333277f, -0.01097393f, -0.01752714f, -0.03530450f, -0.38895330f, -0.48178294f, -0.50860798f, -0.10300860f, 
    -0.04218458f, -0.04704880f, -0.03143235f, -0.10414811f, 0.03349909f, 0.00888744f, 0.03469260f, 0.01373989f, 
    -0.05327201f, -0.51742959f, -0.20711532f, -0.06910627f, 0.09906287f, -0.06279562f, 0.02934647f, 0.08132493f, 
    0.10300469f, 0.13342710f, 0.06416669f, 0.09788636f, -0.22041106f, 0.02974865f, 0.09018803f, -0.03804785f, 
    -0.00475239f, -0.12361906f, -0.10545083f, -0.11690945f, 0.03485828f, 0.10811590f, -0.02490931f, 0.07808212f, 
    -0.61155832f, -0.00907010f, -0.02612280f, 0.14606430f, 0.10439026f, 0.02200527f, 0.06832684f, -0.00532840f, 
    -0.03826271f, 0.08538026f, 0.13998687f, 0.17724234f, -0.08353838f, -0.05372106f, 0.05808560f, 0.09403761f, 
    -0.12961426f, 0.01651674f, -0.03506641f, -0.04247474f, 0.03854029f, 0.08226094f, 0.02287673f, 0.16268703f, 
    0.19521283f, -0.21420787f, 0.12270342f, 0.09041385f, -0.00895967f, 0.00644827f, 0.06081584f, -0.13915323f, 
    0.12334077f, 0.11138383f, 0.19106187f, -0.05145357f, 0.03369892f, 0.10247989f, -0.05390427f, -0.04304099f, 
    0.03505385f, 0.02145393f, 0.10910369f, -0.05500086f, -0.04606861f, -0.03858984f, 0.00919941f, 0.15430880f, 
    0.17150113f, 0.03301336f, -0.10266492f, -0.15311773f, 0.05863731f, 0.01287393f, 0.08818174f, 0.02406197f, 
    -0.05815954f, -0.01482372f, -0.03628393f, -0.04430423f, 0.25835064f, 0.12940812f, -0.06629292f, -0.12429803f, 
    0.10135844f, 0.08116659f, 0.03073231f, -0.12509966f, 0.01303644f, -0.07573008f, -0.09332281f, -0.10629468f, 
    0.23015976f, -0.10980661f, -0.36314148f, 0.18514907f, -0.05175027f, 0.04669379f, 0.07446098f, -0.02067503f, 
    -0.07311721f, -0.12605685f, -0.05586975f, -0.09229510f, 0.05978698f, 0.02543199f, -0.05009252f, 0.05998890f, 
    0.05452916f, -0.15349117f, -0.00893103f, 0.02495476f, 0.09816428f, -0.00866556f, 0.08630770f, 0.09894277f, 
    -0.13594215f, -0.23055698f, -0.17123953f, 0.11881240f, 0.25695166f, 0.02618322f, 0.04379944f, -0.08338426f, 
    0.04795327f, 0.18123427f, 0.12071627f, 0.23010157f, -0.27614933f, -0.37587178f, -0.30279794f, -0.03323827f, 
    0.07158284f, 0.20542833f, 0.16767457f, 0.21393332f, -0.03542642f, -0.00608136f, 0.00676682f, 0.00686123f, 
    -0.10682651f, 0.03801879f, 0.01997196f, -0.22791398f, 0.11625615f, -0.01722999f, 0.00641530f, 0.20722482f, 
    0.02535563f, -0.05493848f, 0.12042741f, -0.25127661f, 0.11418701f, -0.09095210f, -0.35115874f, -0.24943772f, 
    -0.03847783f, -0.12486420f, 0.04861091f, 0.06452677f, 0.07275386f, -0.02993127f, -0.05846556f, 0.05740611f, 
    0.52228415f, 0.04820902f, -0.35825413f, -0.37233183f, -0.06990574f, -0.18899642f, -0.02282347f, -0.02388039f, 
    0.08990295f, 0.07217570f, 0.05753054f, 0.07972464f, -0.29902270f, 0.04225726f, 0.17018709f, 0.15116480f, 
    -0.00007540f, -0.00139558f, -0.10984945f, -0.06905753f, -0.08550601f, 0.08352749f, -0.05831450f, -0.06801590f, 
    0.30002058f, 0.00107443f, -0.23233314f, -0.20596698f, 0.01835575f, -0.08399814f, 0.04827366f, -0.05747351f, 
    0.01828283f, -0.00843929f, -0.02802687f, -0.02942844f, -0.25507253f, -0.28269193f, -0.26525006f, 0.05386920f, 
    0.10219628f, 0.11917934f, 0.05081352f, 0.05580830f, -0.19256821f, 0.10930593f, -0.11247677f, -0.12755322f, 
    -0.36411786f, 0.01534272f, 0.22240929f, 0.22201431f, -0.11613972f, -0.05599647f, -0.17792572f, -0.03413021f, 
    0.00643547f, -0.01498591f, 0.00736495f, 0.06362465f, 0.10514020f, -0.22399637f, -0.03763780f, -0.11610132f, 
    -0.02309230f, 0.00595524f, -0.04192898f, -0.06642009f, 0.11323774f, 0.09730129f, 0.01607116f, 0.00406942f, 
    -0.37328720f, -0.26694921f, 0.07608029f, 0.00104367f, -0.05977206f, 0.17616053f, -0.02097886f, -0.05767236f, 
    0.01506513f, -0.07944328f, -0.10917392f, 0.06841763f, -0.17958355f, -0.26557308f, -0.13649479f, 0.04182168f, 
    -0.01819899f, 0.07300324f, -0.01458863f, 0.12949054f, -0.19820294f, -0.08579151f, 0.01558782f, -0.06140067f, 
    -0.49563333f, -0.16289693f, -0.02459113f, 0.24073119f, -0.09901658f, -0.06195901f, -0.02221299f, -0.11438891f, 
    -0.10237354f, -0.05145098f, -0.12794536f, 0.03033714f, 0.31867209f, 0.13153496f, -0.27237424f, 0.18455106f, 
    0.18006320f, -0.10835285f, 0.21440782f, 0.07163128f, -0.01099141f, -0.11802700f, -0.01633224f, -0.05351670f, 
    0.28082010f, 0.05407666f, -0.14757071f, -0.33250704f, -0.23427294f, 0.04428204f, 0.06893235f, -0.08206680f, 
    -0.00094235f, 0.09693051f, -0.04456588f, 0.12727396f, -0.37826127f, 0.02644585f, 0.05380749f, 0.08733240f, 
    0.13679788f, 0.00599618f, -0.06719656f, -0.03464836f, 0.02394181f, -0.07178630f, -0.07910898f, 0.04570095f, 
    -0.08879377f, -0.00788154f, -0.01921040f, 0.18677251f, 0.13413717f, -0.00918799f, -0.00317670f, 0.09743228f, 
    -0.08091365f, -0.07742541f, 0.00679665f, 0.00745535f, -0.09329096f, -0.08467760f, -0.44252872f, -0.02545786f, 
    -0.02875796f, 0.11141509f, 0.07092877f, -0.07352930f, -0.09809015f, -0.10270941f, -0.02852917f, -0.17496131f, 
    -0.00852760f, 0.10832670f, 0.06077572f, 0.01125725f, 0.00044665f, -0.09029913f, 0.00583503f, -0.00829117f, 
    -0.03704553f, -0.04030151f, 0.06792602f, 0.00613351f, -0.32152504f, 0.07778630f, -0.26076147f, -0.07230667f, 
    0.11908296f, 0.17904967f, -0.14981736f, 0.03795016f, -0.11941969f, 0.09415673f, 0.02106972f, -0.08142016f, 
    -0.18917347f, -0.15796569f, -0.11438780f, -0.09979795f, -0.05553749f, 0.07672872f, 0.03684534f, -0.00536644f, 
    0.01710178f, 0.09467830f, -0.01913222f, -0.07755831f, -0.16440496f, -0.01985819f, 0.00749505f, 0.00215658f, 
    0.06821956f, -0.16217376f, 0.05109086f, 0.04789021f, -0.17999199f, -0.04708456f, -0.05596313f, 0.01676783f, 
    -0.43125060f, -0.01879395f, 0.14619848f, 0.16482589f, -0.12502255f, 0.01149971f, -0.17173474f, -0.08899115f, 
    -0.19628985f, 0.01983180f, -0.05969369f, -0.09176292f, -0.00316935f, -0.07212662f, -0.08868555f, 0.01969616f, 
    0.07474570f, -0.01711914f, 0.08984414f, 0.01389767f, 0.00976156f, -0.00429289f, 0.08506159f, 0.11132812f, 
    -0.02675014f, -0.13765520f, -0.17602223f, -0.05229770f, -0.03024310f, 0.07012600f, 0.11813217f, 0.02134972f, 
    0.15790355f, 0.12315853f, 0.21138717f, 0.11169330f, 0.04105546f, 0.08185921f, 0.01565644f, 0.04681335f, 
    0.06628440f, -0.21263486f, -0.06789723f, -0.06007096f, 0.14467333f, 0.12632498f, 0.03107591f, 0.00635303f, 
    -0.01611327f, -0.26224187f, -0.11384152f, 0.04712009f, 0.10429212f, 0.05201502f, 0.03658227f, -0.00519424f, 
    -0.05145770f, 0.01855236f, -0.09829400f, -0.03909245f, -0.02019740f, -0.40616396f, 0.00551645f, 0.15116736f, 
    0.07419779f, -0.06097109f, -0.03443932f, -0.02226937f, -0.19339311f, -0.14343661f, -0.16786255f, -0.19173813f, 
    -0.49974576f, -0.37409765f, 0.07937368f, -0.08251064f, 0.16284056f, 0.15796895f, -0.11399332f, 0.16623011f, 
    -0.01581451f, 0.01085532f, 0.07304897f, -0.11628132f, -0.34985247f, -0.36902821f, 0.01637905f, 0.17534438f, 
    0.02746179f, 0.13201094f, 0.05230324f, 0.09990063f, -0.09437966f, 0.01586685f, 0.04298531f, -0.00548845f, 
    -0.24919732f, 0.03986343f, 0.13380368f, 0.03119992f, 0.04371442f, -0.06711739f, -0.04369551f, -0.10388431f, 
    -0.02032526f, 0.05180928f, 0.08999228f, 0.11733198f, 0.19506565f, -0.29910538f, 0.19112276f, -0.24576403f, 
    0.00212985f, 0.04417373f, 0.01069511f, -0.11864436f, -0.11881130f, 0.04204370f, -0.08714645f, -0.05944824f, 
    -0.12160249f, -0.20795444f, -0.34483370f, 0.10692503f, 0.07874877f, 0.10057262f, 0.16788666f, -0.07855846f, 
    -0.04791395f, -0.06692114f, 0.02447467f, -0.00429055f, 0.02557663f, -0.01368854f, -0.23018359f, -0.52909046f, 
    -0.31115246f, -0.15102866f, 0.05243997f, -0.02241167f, 0.03976314f, 0.05028143f, -0.01938364f, -0.03196213f, 
    -0.11596467f, 0.17401730f, 0.15826996f, -0.70793200f, 0.08104859f, -0.09122402f, 0.11895430f, -0.02608360f, 
    -0.00014847f, -0.03019185f, 0.14284043f, 0.01328833f, 0.09872109f, 0.02508094f, 0.08678238f, -0.34660205f, 
    0.10679518f, 0.09943435f, 0.06383594f, -0.03015714f, 0.03386291f, -0.02224020f, -0.01708811f, -0.01306895f, 
    0.02277991f, -0.18525898f, -0.05046017f, -0.03521699f, 0.00932235f, 0.22240986f, 0.14547172f, 0.13264915f, 
    -0.04052772f, 0.02329623f, -0.03087223f, 0.07103373f, -0.16196769f, -0.07520668f, 0.00922032f, 0.22113171f, 
    0.05631993f, 0.08194933f, -0.09082754f, 0.00198886f, 0.04396120f, 0.07907317f, 0.09500751f, 0.14144097f, 
    -0.23155169f, 0.35406268f, 0.02767568f, 0.32125118f, -0.05395396f, 0.04254195f, -0.13664077f, -0.03667979f, 
    -0.04160957f, -0.13985701f, -0.10456873f, -0.22732833f, -0.11469036f, 0.02201837f, 0.02571011f, 0.25637430f, 
    0.10388862f, -0.02006510f, -0.06516264f, -0.10574516f, 0.00766757f, -0.16529854f, 0.07487811f, -0.06073515f, 
    -0.04869546f, 0.03218532f, -0.11644997f, -0.04809418f, 0.00208763f, -0.03240640f, 0.12342072f, 0.08358000f, 
    0.15654662f, 0.04636437f, 0.12535183f, 0.26897597f, -0.08451980f, -0.15298030f, 0.01866426f, 0.03446259f, 
    -0.02844352f, 0.21508944f, 0.10079296f, 0.03308442f, 0.14250560f, 0.18988143f, -0.00575231f, -0.07167512f, 
    0.02916080f, -0.03923295f, 0.23915680f, -0.15745430f, 0.12570998f, -0.22948793f, -0.01356754f, -0.13025966f, 
    0.18417971f, 0.08452685f, -0.03033823f, -0.06835771f, 0.20521110f, 0.23167498f, 0.02121512f, -0.14921422f, 
    -0.10867897f, -0.23055105f, 0.03096600f, 0.21407078f, -0.02030772f, -0.00551626f, 0.02878444f, 0.01767998f, 
    0.03359179f, -0.13024208f, 0.25277603f, 0.14069982f, -0.14843415f, -0.00113440f, -0.07992683f, -0.31533593f, 
    0.20618185f, -0.00181745f, -0.04965095f, 0.00552160f, -0.08461928f, -0.03810789f, -0.05092121f, 0.06094294f, 
    0.05214248f, 0.08853941f, 0.04739199f, 0.03727678f, 0.16518685f, 0.08864982f, 0.11908495f, 0.30147552f, 
    -0.24374352f, -0.14118287f, -0.24505143f, -0.12907152f, -0.11128772f, -0.05402108f, 0.11454961f, -0.07126950f, 
    -0.03955464f, -0.00012136f, -0.03994292f, -0.06092007f, 0.07273909f, -0.08040207f, 0.14465180f, -0.00014225f, 
    0.07455211f, 0.12825775f, -0.02245283f, -0.26135913f, 0.12268638f, 0.08554000f, -0.05847846f, 0.00250679f, 
    -0.33148396f, 0.09235054f, 0.16726327f, -0.20822957f, -0.24559869f, 0.01559775f, 0.07011259f, 0.19645762f, 
    0.06701382f, 0.02801278f, 0.05159348f, -0.00744477f, 0.00219314f, -0.08955941f, -0.02967913f, -0.03523262f, 
    0.13437086f, 0.10019839f, 0.04882667f, -0.08731195f, 0.13221034f, 0.00214667f, 0.02453902f, -0.02585911f, 
    0.14626472f, -0.24771014f, 0.22036882f, 0.00858143f, 0.23938873f, -0.15934083f, -0.05364154f, 0.06654420f, 
    -0.18822561f, 0.00044360f, -0.00639447f, 0.01986687f, 0.06027557f, -0.17799483f, -0.12249196f, 0.04580492f, 
    -0.01636386f, 0.03402789f, 0.07361276f, 0.07066025f, -0.02041469f, -0.01972417f, -0.07380701f, -0.07875400f, 
    -0.12613413f, 0.09266728f, 0.05958408f, 0.11317816f, -0.07319739f, -0.06755726f, -0.06846878f, -0.09223188f, 
    -0.01066713f, 0.02209984f, 0.07329834f, 0.03571476f, -0.39941642f, -0.08874948f, 0.24161485f, -0.36444256f, 
    -0.06482489f, -0.20377296f, 0.04969354f, 0.26225901f, -0.00534408f, 0.03688141f, -0.01277211f, 0.00047601f, 
    0.24708903f, -0.13550624f, -0.06638231f, -0.21182729f, -0.01457903f, -0.11782926f, -0.06409686f, 0.06868276f, 
    0.06552675f, 0.00950339f, -0.02640732f, -0.05839374f, 0.10200817f, -0.41271132f, -0.12146497f, 0.04902263f, 
    0.21671164f, 0.07340495f, 0.17613935f, 0.01759055f, 0.01815658f, -0.06668688f, -0.07903340f, -0.07225493f, 
    0.15191302f, 0.21172749f, 0.09161340f, -0.12174396f, -0.12495332f, 0.02300806f, -0.03804347f, -0.19334878f, 
    0.04210856f, 0.11298894f, -0.21012348f, 0.02675444f, 0.10350844f, -0.20513617f, 0.11944635f, 0.18130647f, 
    0.01289595f, 0.07247124f, -0.21008584f, 0.08287952f, -0.05822409f, -0.10844373f, -0.01100983f, 0.00011790f, 
    -0.06201817f, -0.17101975f, -0.04070655f, 0.04712978f, 0.01818559f, -0.01898968f, 0.10005124f, -0.07536646f, 
    -0.05313446f, -0.03142086f, -0.02481969f, -0.06175162f, 0.14684123f, -0.14993669f, 0.09213591f, -0.10479524f, 
    0.00601366f, 0.04482824f, 0.00378095f, -0.10368099f, -0.06075673f, -0.03496894f, -0.04329062f, -0.01307125f, 
    0.48748425f, 0.16261557f, -0.15753280f, -0.22024725f, -0.09418663f, -0.03732172f, 0.01003239f, 0.22894372f, 
    -0.09773750f, 0.07774206f, -0.00177501f, -0.02160384f, -0.12682685f, -0.16380718f, 0.12872756f, -0.08134325f, 
    0.01979847f, 0.07802665f, -0.11386279f, 0.09571157f, 0.03801126f, 0.04428004f, 0.08988377f, 0.01127830f, 
    -0.05100456f, 0.13003260f, 0.46469608f, -0.33463290f, -0.12109886f, -0.15613738f, -0.06748620f, 0.04472597f, 
    0.01483736f, 0.05532129f, 0.05060270f, -0.00791143f, 0.02189304f, -0.38773644f, 0.05986036f, -0.00879668f, 
    0.07202498f, 0.12615062f, -0.08545913f, 0.06743550f, 0.14978257f, -0.22041121f, -0.00919928f, -0.04944228f, 
    0.25515431f, -0.05452614f, 0.07628274f, -0.25988653f, -0.07668745f, 0.00714169f, 0.06889848f, 0.00496854f, 
    0.00448263f, 0.01839522f, -0.08131174f, -0.03455088f, -0.25129026f, 0.18470781f, -0.14363421f, -0.10280916f, 
    -0.06435361f, -0.18128462f, -0.07036661f, -0.15472355f, 0.04510213f, -0.16336954f, 0.06485301f, 0.13912253f, 
    -0.15289383f, 0.16850793f, -0.18366382f, 0.29065952f, 0.02482096f, -0.09689312f, 0.01657521f, -0.02677064f, 
    0.09543453f, -0.07218917f, 0.13431026f, 0.06913589f, 0.17116868f, -0.32012492f, 0.13158536f, 0.39332390f, 
    -0.13778003f, 0.09648811f, -0.27729183f, -0.04840462f, 0.10023975f, -0.00554925f, 0.02257566f, 0.03918474f, 
    -0.30018699f, -0.75281334f, 0.04906439f, -0.06920314f, 0.01172721f, -0.03282798f, 0.05831749f, 0.07942766f, 
    -0.01988170f, 0.04998992f, 0.09759153f, -0.07102681f, -0.07036038f, 0.01696582f, -0.14487745f, -0.10880636f, 
    0.08232817f, -0.06205739f, 0.08621009f, -0.05554467f, 0.19274366f, -0.05490799f, -0.05564658f, -0.08453301f, 
    -0.05112983f, -0.02211371f, 0.04224728f, 0.22850381f, 0.12871799f, 0.05197204f, -0.03784708f, -0.15220134f, 
    0.16827005f, -0.00745031f, 0.02462785f, 0.01374243f, 0.35101175f, 0.05711589f, 0.43794894f, -0.19774635f, 
    -0.06425016f, -0.24616006f, -0.13528247f, -0.12814483f, -0.04060943f, 0.08913955f, 0.00981679f, 0.11713777f, 
    0.02915483f, -0.34069493f, 0.07527214f, -0.14694181f, 0.01376953f, 0.03151765f, -0.01899930f, 0.19091558f, 
    -0.04176819f, -0.03528728f, -0.07880019f, -0.00518931f, 0.08072218f, -0.30230549f, 0.19687253f, -0.05608454f, 
    -0.16782013f, 0.26207981f, -0.17749372f, 0.07852712f, 0.03740542f, -0.03432250f, -0.14470933f, -0.00918231f, 
    -0.00642796f, -0.25773489f, 0.04037540f, -0.43956882f, 0.07031334f, -0.13487434f, -0.06867433f, -0.08803579f, 
    0.06350462f, 0.13985053f, 0.00320584f, 0.08221738f, -0.21431425f, 0.34652418f, 0.57863897f, -0.46446112f, 
    -0.14682974f, -0.29128438f, 0.09969463f, -0.01037625f, -0.12818681f, 0.09228651f, 0.07000468f, 0.08663593f, 
    0.09498912f, -0.04522381f, 0.14212385f, -0.14635366f, 0.03067717f, -0.01366607f, 0.11242961f, 0.04640368f, 
    -0.01686902f, 0.01278297f, -0.10013861f, -0.01238896f, -0.36745039f, -0.10852953f, -0.09697265f, -0.00551660f, 
    -0.11673524f, -0.07315545f, -0.12917490f, -0.03234169f, 0.11216110f, -0.12311664f, -0.21768403f, 0.00298951f, 
    -0.35626379f, -0.35415626f, 0.19248560f, 0.00426724f, -0.09216399f, 0.09001380f, -0.22979042f, -0.00792345f, 
    0.00136190f, 0.03036356f, -0.11090103f, -0.04438517f, -0.07246438f, -0.01677135f, 0.46680871f, -0.48294425f, 
    -0.01361137f, 0.00737833f, -0.07523894f, -0.02280377f, -0.06511523f, -0.00636627f, 0.05019187f, -0.09579480f, 
    -0.12198658f, 0.36769152f, -0.55739850f, 0.10886647f, 0.07172596f, -0.19633035f, 0.08704863f, -0.07671414f, 
    0.15839915f, 0.02789445f, -0.06137689f, -0.00021803f, 0.01614251f, -0.17367515f, -0.18859304f, -0.02053050f, 
    0.00769236f, -0.02799928f, -0.00009344f, 0.01864284f, 0.13770591f, 0.03740730f, 0.07623657f, 0.03648096f, 
    -0.02388179f, -0.40363905f, -0.26240331f, -0.08047073f, -0.01047242f, 0.14537156f, 0.14286141f, 0.06960304f, 
    -0.08655471f, 0.00460889f, 0.02050163f, -0.08009681f, -0.14526019f, 0.46660852f, -0.25583974f, 0.10685468f, 
    -0.05985889f, 0.10607115f, 0.13872351f, -0.06933258f, 0.08638147f, 0.06865858f, -0.01957014f, -0.10020895f, 
    0.28347477f, 0.07123388f, 0.24117944f, 0.22228046f, -0.01658593f, -0.08064281f, -0.19212534f, -0.11952644f, 
    0.03739223f, 0.15613902f, 0.00061372f, 0.00420469f, -0.07818419f, -0.00324512f, -0.27596626f, -0.06951877f, 
    0.05857802f, -0.12402804f, 0.21135551f, -0.17385945f, 0.10898624f, 0.05793071f, -0.06409289f, 0.17308347f, 
    -0.07298344f, -0.27618274f, -0.15524676f, -0.16233844f, -0.04874318f, 0.07816426f, -0.04202901f, 0.11225846f, 
    0.02427460f, 0.04930787f, 0.00359654f, 0.11455230f, -0.21529880f, 0.04859682f, 0.40546963f, -0.02755786f, 
    0.09233815f, -0.09869055f, 0.13408060f, -0.16248651f, -0.00172345f, -0.16451760f, -0.11107532f, -0.18900384f, 
    0.16418910f, 0.05967016f, 0.05738257f, -0.05929603f, 0.14918379f, -0.17538959f, -0.15746631f, 0.07144017f, 
    -0.09429922f, -0.15703958f, -0.02607500f, 0.06488222f, 0.18296683f, -0.01885753f, -0.16557875f, -0.07219856f, 
    0.20473453f, -0.07338163f, 0.04744283f, 0.13175714f, -0.11844978f, -0.07182184f, -0.07774189f, -0.09322985f, 
    -0.15935592f, 0.07052799f, 0.10424876f, -0.12507631f, -0.03591663f, 0.02299279f, -0.22153179f, 0.02028758f, 
    0.07869553f, 0.04408145f, 0.15503994f, -0.19701520f, -0.28166759f, -0.01897983f, 0.12661941f, 0.02658273f, 
    -0.20890260f, 0.20923370f, 0.07525817f, -0.03204869f, 0.15648523f, -0.05581653f, -0.00925432f, 0.09367787f, 
    -0.34888256f, -0.09810374f, 0.12657490f, 0.07786748f, 0.07037035f, 0.08393224f, -0.36058703f, -0.08638419f, 
    0.00079052f, -0.21643497f, -0.00293064f, -0.00899719f, -0.08236563f, 0.15370621f, -0.16112421f, 0.00321748f, 
    -0.01813349f, 0.11765079f, -0.03561132f, -0.31910849f, 0.03741597f, -0.03410260f, -0.05595109f, -0.01245087f, 
    0.35063860f, -0.11478344f, -0.05126539f, -0.15989771f, 0.02903196f, -0.04612960f, -0.00037110f, 0.04066830f, 
    -0.12693171f, -0.15904576f, -0.39727700f, -0.37171736f, -0.00611123f, 0.20385113f, -0.23794197f, 0.23507698f, 
    -0.03934453f, -0.03461333f, 0.00504095f, 0.06155464f, 0.10323079f, 0.14985466f, -0.12411850f, 0.05578744f, 
    -0.17974675f, -0.13386925f, -0.57389379f, -0.22282667f, -0.28938755f, -0.12747128f, 0.01541973f, -0.12682854f, 
    -0.07129027f, 0.18501258f, -0.02812046f, 0.00004576f, -0.00022423f, -0.03071130f, 0.05724634f, -0.03338621f, 
    0.03127114f, -0.03881745f, 0.14633311f, -0.05953486f, 0.06269383f, 0.03970901f, 0.00515823f, -0.08803708f, 
    0.29541633f, -0.18555784f, 0.30845401f, -0.06761133f, -0.04243425f, 0.04999555f, 0.07681917f, -0.03210044f, 
    -0.06907764f, -0.02205044f, -0.07233565f, -0.22423050f, -0.05556192f, -0.20609882f, 0.10216856f, 0.08964343f, 
    -0.04786363f, -0.06228831f, 0.09768618f, 0.03242537f, 0.03344195f, -0.16394012f, 0.01858979f, -0.01417487f, 
    0.03905827f, -0.25836182f, -0.01734390f, -0.15809745f, -0.20407589f, -0.02516834f, 0.01239075f, -0.10216272f, 
    -0.07126161f, -0.11752605f, -0.22490354f, -0.16763474f, -0.15870884f, 0.02781456f, 0.30165094f, -0.19893645f, 
    -0.00168602f, 0.04609874f, -0.22972471f, -0.04460822f, -0.08524052f, -0.15150996f, -0.29399669f, -0.14761081f, 
    0.26101941f, 0.04047805f, 0.26274908f, -0.16472335f, -0.11203379f, -0.03895724f, 0.07288078f, 0.03557035f, 
    -0.02050646f, 0.15496969f, 0.07938810f, 0.08628048f, -0.29230878f, 0.21089336f, -0.04461297f, -0.24445622f, 
    -0.10268717f, 0.06581604f, 0.03495093f, -0.04022004f, 0.02559567f, 0.03741629f, -0.01697692f, 0.03649962f, 
    -0.08979883f, -0.01062456f, -0.09459028f, 0.20250511f, -0.03540637f, -0.07961858f, -0.09238347f, 0.07256887f, 
    -0.18381897f, -0.35140595f, -0.22680549f, -0.09659909f, -0.22699618f, -0.16353618f, -0.09889209f, -0.28928497f, 
    -0.04988695f, -0.05667762f, -0.07005791f, -0.08959337f, -0.00151196f, -0.00696776f, -0.02139916f, -0.07039297f, 
    -0.14522153f, 0.22779766f, 0.03463059f, 0.13071410f, 0.00134590f, 0.12185967f, 0.00406614f, 0.02401697f, 
    -0.09660292f, -0.09781776f, 0.03616813f, 0.08524685f, -0.03414647f, -0.01939298f, 0.06042789f, 0.13050888f, 
    0.00788613f, 0.10750761f, 0.01638403f, 0.01703754f, -0.08418734f, 0.11584824f, 0.02925033f, 0.08944729f, 
    -0.03968713f, 0.08615741f, -0.15765600f, -0.15215720f, -0.08021570f, -0.02583576f, 0.11299238f, -0.06426206f, 
    -0.02702365f, -0.02583159f, 0.09641442f, -0.18226135f, 0.16100596f, 0.02227396f, 0.02146545f, -0.14078097f, 
    -0.02554110f, 0.03616149f, 0.00041700f, -0.05464453f, -0.03019388f, -0.19302134f, -0.19010322f, -0.23957261f, 
    0.12836720f, -0.39566109f, 0.36207590f, 0.20461807f, 0.01933754f, 0.16069603f, 0.07714246f, 0.16057140f, 
    0.12560862f, -0.07348742f, 0.11244991f, 0.10258170f, -0.63757902f, 0.09353175f, -0.35694587f, -0.13358676f, 
    -0.01999337f, 0.03713726f, 0.27657673f, 0.04681987f, -0.07819797f, -0.03097222f, -0.07651273f, 0.13012151f, 
    -0.11930221f, -0.38986364f, -0.40576580f, -0.07096470f, 0.06058704f, -0.04856993f, -0.15803033f, -0.03024466f, 
    0.06808735f, 0.09102580f, -0.04417886f, -0.06925110f, -0.22374615f, 0.04730892f, -0.07533503f, -0.14951678f, 
    -0.09965835f, -0.07562135f, -0.08432310f, -0.00639687f, -0.06851114f, 0.15714934f, 0.15144187f, 0.11096824f, 
    -0.20484212f, 0.30951312f, 0.05068094f, -0.03928150f, 0.11210937f, -0.00684701f, -0.08717018f, -0.06445558f, 
    0.18073101f, 0.01108902f, 0.11294184f, 0.09045753f, 0.13035326f, -0.11941160f, -0.12569472f, 0.33845398f, 
    -0.11250074f, -0.11417321f, 0.00785436f, -0.03165601f, 0.04481628f, 0.04727368f, -0.02234423f, 0.16548447f, 
    -0.36304519f, 0.23131478f, -0.00816102f, -0.00341526f, -0.01428894f, 0.14629553f, 0.02400592f, 0.03471013f, 
    -0.07465029f, -0.09709163f, -0.21260309f, -0.25997889f, -0.18572375f, -0.47008342f, 0.02639868f, 0.00533645f, 
    -0.07819320f, -0.18273640f, -0.02836698f, -0.02542813f, 0.04261215f, 0.10460525f, 0.13379155f, 0.02387762f, 
    -0.30058044f, 0.09416489f, -0.00060015f, 0.08271060f, 0.02449399f, 0.10832255f, -0.03994725f, 0.04429127f, 
    -0.01858677f, 0.16635461f, 0.10503508f, 0.11145712f, -0.30213198f, -0.11892865f, -0.27831966f, 0.00959708f, 
    -0.14444305f, -0.08361494f, 0.01160735f, 0.00896831f, 0.06095627f, 0.06779592f, 0.05544355f, 0.04939331f, 
    0.04037170f, 0.04564185f, -0.01330763f, 0.20035324f, 0.01644772f, 0.02725133f, 0.21729612f, 0.01443170f, 
    -0.03043757f, -0.00808671f, 0.10142738f, -0.00448003f, -0.06435499f, 0.23105094f, 0.05019241f, 0.07596185f, 
    0.04795809f, -0.04276675f, -0.01333272f, 0.04624812f, -0.04483760f, 0.25869772f, -0.24531466f, 0.07568854f, 
    -0.03493737f, 0.10925993f, -0.24618350f, 0.25377262f, -0.05031167f, 0.17248964f, 0.09485303f, 0.04400115f, 
    -0.03429411f, 0.03642200f, 0.21402846f, 0.05806335f, -0.32623854f, 0.19520223f, 0.13342635f, -0.16195628f, 
    -0.02436939f, 0.07370117f, -0.11033072f, -0.00225312f, 0.06739914f, -0.00472423f, 0.12650619f, -0.10010380f, 
    -0.21766776f, 0.09016112f, -0.21805133f, -0.06429221f, 0.01609839f, 0.12206314f, 0.05465343f, -0.05115611f, 
    -0.03149557f, 0.06309168f, 0.04668962f, -0.02909097f, -0.24357553f, -0.01910429f, -0.04539966f, -0.14216670f, 
    -0.08293566f, 0.08973738f, 0.00878321f, -0.06157156f, -0.03654385f, -0.17626160f, -0.06255733f, -0.22735761f, 
    -0.31433958f, -0.02199620f, -0.09852073f, 0.05238347f, 0.09524092f, 0.06095875f, -0.24554937f, 0.08066002f, 
    -0.09429579f, -0.06871922f, -0.03105934f, -0.03353682f, -0.27619174f, 0.05580505f, 0.17478564f, 0.18273295f, 
    0.01076076f, -0.08488367f, -0.06945653f, 0.00049618f, -0.07903882f, 0.05276836f, 0.11367245f, 0.06614112f, 
    -0.00314918f, 0.17694634f, 0.07537332f, 0.11837409f, -0.13785656f, 0.03225240f, 0.07240865f, 0.00137565f, 
    0.02619726f, 0.05915300f, 0.30729082f, 0.27305812f, 0.16661243f, 0.23939408f, 0.06826368f, -0.22787665f, 
    0.02605784f, -0.27879167f, 0.01736655f, 0.03738628f, -0.14000444f, 0.10946125f, -0.07818933f, -0.14307661f, 
    0.23859537f, -0.04157325f, 0.17407757f, -0.00555475f, -0.06929539f, -0.04587258f, 0.12549806f, 0.12033622f, 
    -0.12393644f, -0.21665117f, -0.05744800f, -0.22473501f, -0.50232011f, 0.18768890f, -0.22717166f, 0.03707545f, 
    0.05756223f, 0.06706916f, 0.00466966f, -0.15146388f, -0.19529298f, 0.07254972f, 0.11213586f, -0.13562883f, 
    -0.47166547f, 0.03156677f, -0.26919878f, 0.16996832f, -0.08910573f, 0.08453931f, -0.01005219f, 0.07089400f, 
    0.05153498f, 0.04087507f, 0.03783111f, -0.03679427f, -0.05885083f, 0.05280922f, 0.24367760f, 0.06132194f, 
    -0.08288262f, 0.12235063f, -0.05792130f, 0.03082736f, -0.15901476f, -0.01134744f, 0.01292447f, 0.03592727f, 
    -0.22874768f, 0.24630268f, 0.09566388f, -0.27274039f, -0.03162054f, 0.10017989f, 0.07941121f, 0.03282635f, 
    -0.08200911f, -0.11180364f, -0.19978739f, -0.05181487f, -0.31504336f, 0.02030234f, -0.18825403f, 0.27471367f, 
    0.12028380f, -0.19361480f, -0.05661790f, 0.02752849f, -0.10013541f, -0.11312330f, -0.26179278f, -0.27593002f, 
    0.05017230f, -0.07250538f, 0.19404098f, 0.23867401f, -0.03485484f, 0.11713913f, -0.01471458f, 0.05144425f, 
    0.03540341f, 0.00709651f, -0.06377238f, 0.16587479f, 0.03124359f, 0.27696317f, -0.16841863f, 0.10513171f, 
    0.04219833f, 0.07162706f, 0.04357914f, -0.07137678f, 0.06342096f, 0.10985281f, 0.06142428f, 0.10400447f, 
    -0.21928880f, 0.29475090f, 0.12827775f, 0.12006775f, 0.10420961f, -0.21486600f, -0.02491900f, 0.24999911f, 
    -0.14686175f, 0.00348158f, -0.03263967f, -0.18239935f, 0.01982049f, 0.07680760f, 0.08440607f, 0.05895251f, 
    -0.02523877f, -0.09590802f, 0.26737124f, -0.04296926f, 0.07702722f, -0.07195714f, -0.05723992f, -0.10356513f, 
    -0.05476220f, 0.20038067f, -0.14045252f, 0.20758203f, -0.06728179f, -0.08542489f, 0.05133087f, 0.09973901f, 
    -0.12716509f, -0.00908236f, 0.07488818f, 0.03986917f, -0.18402839f, -0.11613731f, 0.28677639f, 0.01887709f, 
    -0.09426392f, 0.03486417f, 0.04318400f, 0.11730935f, -0.03733057f, -0.08660660f, -0.05432392f, 0.01834789f, 
    0.06642176f, -0.09511525f, 0.13283224f, 0.10698834f, -0.05146190f, 0.18692666f, 0.08237015f, 0.09177076f, 
    0.12054522f, -0.02445802f, 0.06457479f, 0.14058504f, -0.31357032f, 0.14294632f, -0.13757972f, 0.15653412f, 
    -0.00093713f, 0.01470058f, -0.26593345f, 0.16762303f, -0.18224218f, -0.08577981f, 0.01445397f, -0.11985894f, 
    -0.07148481f, 0.18048033f, 0.08309136f, 0.15659684f, -0.21564518f, -0.03636685f, -0.18889929f, 0.07761085f, 
    -0.06227006f, 0.01690419f, -0.02762354f, 0.16577075f, -0.00515832f, -0.14101192f, -0.12996215f, 0.03744690f, 
    0.04550593f, 0.01864995f, -0.08061575f, 0.04573219f, -0.01447409f, 0.01201465f, -0.07052842f, -0.44288275f, 
    -0.04923563f, -0.00474916f, -0.01431050f, 0.26083517f, 0.04770730f, -0.07795112f, -0.09797405f, 0.11032058f, 
    -0.04241333f, 0.05960723f, -0.02405339f, -0.01632478f, 0.01207229f, -0.22567464f, -0.10882393f, -0.00715764f, 
    -0.09810252f, 0.10244783f, 0.30514550f, -0.06653168f, -0.03612604f, -0.02001911f, -0.18975456f, -0.14775211f, 
    -0.17332458f, 0.05758848f, -0.06632560f, 0.11897637f, -0.04237623f, -0.15783988f, 0.09403609f, -0.08914150f, 
    -0.11572904f, 0.09693246f, -0.04276228f, -0.05166332f, 0.11615101f, 0.10209233f, -0.17743233f, 0.13406603f, 
    -0.12248860f, 0.02521667f, 0.05469017f, -0.11743321f, 0.02930705f, 0.18153653f, -0.12842415f, -0.00851006f, 
    -0.08599203f, -0.20318827f, 0.31209272f, 0.06418563f, -0.05334868f, 0.21966654f, -0.10641753f, -0.02089744f, 
    -0.05433558f, -0.11522774f, -0.03475772f, -0.11843967f, -0.35720697f, 0.28129065f, -0.33269769f, 0.05136131f, 
    -0.14685181f, 0.02316034f, -0.04245539f, 0.20204116f, -0.03744235f, -0.04773361f, 0.06633764f, 0.10151156f, 
    0.08709250f, 0.29416230f, 0.21891679f, -0.03530460f, -0.03845468f, -0.01871764f, 0.05280787f, 0.07629627f, 
    0.02798723f, 0.13149476f, 0.22616594f, 0.01628938f, -0.15408558f, -0.28286794f, -0.08124930f, 0.13606556f, 
    -0.08329764f, 0.05308728f, 0.08812176f, 0.13692357f, 0.02214325f, 0.20102675f, -0.02520050f, 0.03846932f, 
    0.06441475f, 0.02600981f, -0.03394254f, -0.03263422f, 0.05623375f, -0.09229118f, 0.11769373f, 0.02220348f, 
    0.01449466f, 0.03448192f, -0.07244647f, -0.03909590f, 0.05076400f, 0.10373551f, -0.51384050f, 0.33369598f, 
    0.14154796f, -0.10938159f, 0.05831351f, -0.02456876f, 0.08626302f, 0.03844632f, 0.12814121f, 0.01350041f, 
    -0.17261167f, -0.01690716f, -0.03808018f, 0.07820365f, 0.13096987f, 0.04987772f, 0.02713696f, -0.05459366f, 
    0.10059069f, 0.12475494f, -0.02868149f, 0.03220334f, -0.21182342f, 0.03332050f, 0.02665525f, -0.07161634f, 
    -0.01780489f, -0.02583801f, 0.02753747f, 0.06928243f, 0.02460532f, 0.09036901f, 0.08761997f, -0.06960298f, 
    -0.22740921f, -0.12625171f, -0.10678525f, -0.34141499f, -0.00034716f, -0.02149533f, -0.08196411f, 0.01842807f, 
    -0.04609711f, 0.06632274f, 0.09707924f, -0.05478251f, -0.15747648f, 0.01959916f, -0.01536664f, 0.29036912f, 
    0.15220515f, -0.08970352f, 0.03035476f, 0.00908008f, -0.11943828f, -0.04579864f, -0.03791368f, 0.05822561f, 
    0.40998158f, 0.13308257f, 0.17595293f, -0.11603431f, -0.03413495f, -0.04005621f, -0.06347477f, 0.07297489f, 
    -0.12059115f, 0.00410824f, -0.06758843f, -0.11319249f, -0.14511482f, 0.54337674f, -0.19985218f, -0.33185798f, 
    -0.09065762f, 0.01322934f, 0.12631285f, 0.00192744f, 0.02574769f, 0.07005265f, -0.02936309f, -0.01787019f, 
    -0.04938323f, -0.28636402f, 0.08435521f, -0.36373702f, -0.01315210f, 0.14719266f, 0.15544520f, -0.03029398f, 
    -0.17908002f, -0.05573175f, 0.04479119f, -0.00245093f, -0.07219804f, 0.33688357f, -0.12044138f, -0.04238746f, 
    -0.02292716f, -0.02289000f, -0.03344193f, -0.03213130f, -0.09390957f, 0.02816390f, -0.06146390f, -0.13535354f, 
    0.03007193f, 0.18561539f, -0.06102986f, -0.22600225f, -0.08567377f, -0.01649258f, -0.02325662f, 0.07536492f, 
    0.02013843f, 0.09643733f, 0.13972607f, 0.01689406f, -0.29724011f, 0.11064330f, -0.06373182f, -0.08141226f, 
    0.02588896f, 0.08504264f, 0.09060695f, -0.07076310f, 0.12149481f, -0.00748171f, 0.08984593f, 0.07847848f, 
    -0.27950653f, -0.24065466f, -0.16316564f, -0.22818458f, 0.12991798f, -0.06542841f, -0.04502719f, -0.03703033f, 
    -0.09312816f, -0.12152001f, -0.05568746f, -0.20945860f, 0.17337605f, -0.15347840f, 0.00426925f, -0.04865865f, 
    0.17727052f, 0.04808333f, -0.05870624f, 0.04573315f, -0.00149971f, 0.11222013f, -0.05008422f, -0.01302134f, 
    -0.07143105f, 0.04479311f, 0.13654271f, -0.03204865f, 0.01513558f, -0.08875718f, 0.07003339f, 0.03727488f, 
    0.08994526f, 0.13232763f, 0.06907915f, 0.08084621f, -0.11938601f, -0.00874455f, -0.17607409f, -0.06178877f, 
    -0.07436318f, -0.03081454f, 0.04163784f, 0.04012823f, 0.10611504f, 0.12917277f, 0.01290347f, -0.00106730f, 
    -0.02345317f, -0.11757708f, 0.11965241f, -0.06564111f, -0.28509918f, 0.07953607f, 0.05970806f, 0.24305022f, 
    -0.09874202f, -0.04297511f, -0.04573402f, 0.02611607f, -0.26829877f, -0.38384309f, -0.04542693f, 0.12656662f, 
    -0.20195588f, -0.10172718f, -0.12965155f, -0.12438993f, 0.02239473f, -0.07607113f, -0.08058766f, 0.02910408f, 
    0.04892138f, 0.14976819f, -0.06600719f, 0.05297575f, 0.09214760f, -0.04760488f, 0.11777596f, 0.09998465f, 
    0.07886120f, 0.16967668f, 0.00562092f, 0.06730803f, -0.00956599f, 0.01579262f, -0.01442960f, -0.07046425f, 
    -0.00859335f, 0.06114409f, -0.05263863f, 0.00908486f, 0.12010328f, 0.04260319f, 0.14417130f, 0.16330189f, 
    -0.10219058f, -0.31338233f, 0.41456720f, -0.20671135f, 0.08246923f, 0.01926515f, -0.07744174f, 0.08975385f, 
    -0.01320468f, 0.07460603f, -0.10861764f, 0.09833016f, 0.17784183f, 0.17366554f, -0.15110902f, 0.16115291f, 
    0.15770860f, 0.01829200f, 0.20503139f, -0.28599405f, -0.00124378f, 0.04931552f, 0.13008176f, -0.07330103f, 
    -0.09262642f, -0.20277908f, -0.06476034f, -0.11264571f, -0.20183776f, -0.13586399f, 0.01254555f, -0.06310986f, 
    0.02092790f, 0.00321306f, -0.04712005f, -0.00560110f, 0.02907104f, 0.10405108f, -0.15311345f, -0.13490009f, 
    -0.01509880f, 0.00532739f, -0.00801805f, -0.04060641f, -0.04377969f, -0.00410386f, -0.23485079f, -0.08870798f, 
    -0.50862074f, -0.05142954f, -0.00671837f, 0.04064256f, 0.09001235f, -0.02767411f, -0.09374290f, 0.14287318f, 
    -0.14038478f, -0.00388316f, 0.01596640f, 0.01722546f, 0.00291288f, 0.09939242f, 0.18345520f, -0.06139870f, 
    -0.20007794f, -0.00679108f, -0.05542965f, -0.02769966f, -0.13721438f, 0.08149379f, 0.04787405f, -0.12201393f, 
    0.02608592f, -0.42509770f, -0.07479136f, 0.21094616f, 0.17858617f, -0.18741299f, 0.07281411f, 0.11812650f, 
    -0.04506676f, 0.00883901f, 0.08663807f, 0.10526051f, -0.22797979f, -0.21433359f, -0.27525502f, -0.13140467f, 
    -0.18097749f, -0.12505093f, -0.09956299f, -0.15112087f, -0.06787698f, 0.04458833f, -0.15024726f, -0.09774153f, 
    -0.37627056f, 0.04183340f, -0.27457851f, 0.17530906f, -0.33655915f, -0.14880782f, -0.03095281f, -0.13439940f, 
    -0.01211429f, 0.02996466f, -0.00997556f, 0.00031899f, 0.42078313f, 0.30630401f, 0.13351873f, -0.11433154f, 
    -0.12264251f, -0.00874390f, -0.15779738f, 0.01048236f, -0.08464365f, -0.02142978f, -0.00758976f, -0.05780455f, 
    -0.16971657f, -0.10344548f, 0.19383051f, 0.15805423f, 0.05426775f, -0.08005174f, 0.03255419f, 0.01897527f, 
    -0.17264932f, -0.01938960f, 0.01023654f, 0.11606684f, -0.51007205f, 0.09957274f, -0.49579912f, 0.24439751f, 
    0.13018836f, -0.03392556f, 0.07472712f, -0.02095488f, -0.06737217f, -0.16588825f, 0.11548308f, 0.02045930f, 
    -0.02416278f, 0.41914436f, 0.24527429f, -0.00280738f, 0.06923921f, 0.00587258f, 0.00388945f, 0.10599497f, 
    -0.09763167f, -0.07031925f, 0.07643858f, 0.01153051f, 0.14237878f, -0.13259456f, -0.02759350f, 0.17023782f, 
    0.07560410f, 0.13840911f, 0.08435097f, -0.01004575f, 0.03615339f, 0.08547011f, -0.10805488f, -0.02788894f, 
    -0.00987364f, -0.05948375f, 0.25440010f, 0.29303429f, -0.04135169f, -0.18110986f, 0.00048374f, -0.17275600f, 
    0.08308800f, -0.02085742f, -0.00734083f, 0.11583621f, -0.09157524f, 0.01583641f, -0.03943935f, -0.12884606f, 
    0.04168418f, 0.00754417f, 0.18143786f, -0.02559318f, -0.02525769f, 0.07219332f, -0.05126923f, 0.17295007f, 
    -0.05282833f, -0.09027959f, -0.14492533f, 0.12214307f, 0.04920480f, -0.09134306f, 0.09955030f, -0.02950048f, 
    0.03694327f, 0.16667998f, -0.01957737f, -0.05781258f, -0.16361591f, 0.20834661f, -0.13148141f, -0.07653558f, 
    0.08534535f, 0.06146124f, 0.10456309f, -0.03851873f, -0.13912064f, -0.06211788f, -0.04630912f, -0.02457623f, 
    -0.18320921f, 0.17207918f, -0.06196652f, -0.12292451f, -0.07348915f, 0.08100025f, -0.03060453f, -0.07094529f, 
    -0.01722690f, -0.09877864f, -0.07015456f, -0.25627780f, 0.16366643f, -0.09841967f, -0.16475660f, -0.45902506f, 
    0.07852158f, -0.01754823f, 0.10992455f, -0.07793209f, 0.04553469f, 0.01232055f, -0.00227868f, -0.06458354f, 
    0.08763617f, -0.15753804f, -0.19786657f, -0.01083963f, 0.02195574f, 0.07595222f, 0.08074511f, -0.06444766f, 
    0.01276600f, 0.10641830f, 0.01911980f, 0.10408735f, -0.70106554f, 0.34718627f, -0.62252837f, 0.29428127f, 
    0.18281062f, -0.11287584f, 0.23436393f, 0.02052435f, -0.08388996f, 0.04042841f, 0.32676992f, 0.05433011f, 
    -0.12429955f, -0.58556223f, -0.10804628f, 0.10712525f, -0.03862455f, -0.15701540f, 0.02718867f, -0.11048041f, 
    -0.04252430f, 0.02610708f, 0.10537522f, 0.02224612f, 0.07894579f, 0.04642038f, 0.01060168f, 0.01967053f, 
    -0.03029094f, -0.03701819f, 0.01635784f, 0.00867328f, 0.01241488f, 0.01754968f, 0.10194191f, -0.04178888f, 
    0.04592945f, -0.12124543f, 0.04694395f, -0.00955082f, 0.08260898f, -0.03938033f, 0.06553838f, -0.01287344f, 
    -0.01443570f, 0.07099514f, 0.13162045f, 0.02361696f, -0.29397592f, -0.10662197f, -0.13573787f, 0.01395280f, 
    -0.10634935f, -0.12191116f, -0.04313404f, 0.04372779f, -0.16394699f, 0.03524961f, -0.06158381f, -0.10983911f, 
    -0.09226006f, 0.18143858f, -0.07207264f, -0.06449674f, -0.07561969f, -0.08766478f, -0.01082813f, -0.09629494f, 
    -0.10711398f, 0.02990306f, 0.01624799f, -0.13485715f, -0.16431791f, 0.14191534f, -0.07456393f, 0.24325858f, 
    0.09658340f, -0.11425979f, 0.13254187f, 0.00088940f, -0.10440536f, -0.13697025f, -0.01213299f, -0.01401827f, 
    -0.06074662f, 0.03898395f, -0.20011471f, 0.26038882f, 0.01564943f, -0.00525332f, 0.02384629f, 0.19024737f, 
    -0.15096389f, 0.03040878f, 0.10003038f, 0.03170318f, -0.11703722f, -0.17898989f, 0.16724144f, -0.13078293f, 
    -0.09096192f, 0.00440989f, -0.11755459f, 0.01089778f, 0.02372145f, -0.01438712f, -0.07238983f, -0.07528561f, 
    0.03782755f, -0.02225543f, 0.27897260f, 0.01879748f, -0.17738682f, 0.04856113f, -0.09096544f, 0.18332924f, 
    -0.24383758f, 0.08755152f, 0.06410056f, -0.00834478f, 0.12326129f, -0.17499983f, 0.29292664f, -0.06657409f, 
    0.08582865f, 0.01538817f, 0.07213277f, 0.01069540f, 0.01644519f, 0.12142220f, 0.14270853f, -0.10900786f, 
    -0.47433534f, 0.09136677f, -0.13096178f, 0.14655349f, -0.17183194f, 0.11020379f, -0.14028840f, -0.21740192f, 
    -0.03315037f, 0.04897800f, -0.01607346f, -0.11674664f, -0.11134657f, -0.14803234f, -0.02885730f, 0.37693530f, 
    -0.02538689f, -0.09357041f, 0.10127262f, 0.24132110f, -0.13584928f, 0.06268004f, -0.03196160f, 0.04722796f, 
    0.29104322f, -0.28085774f, 0.31980667f, -0.02027024f, 0.12738685f, 0.06756779f, 0.24023944f, 0.08728409f, 
    -0.03169367f, 0.09679476f, 0.08739918f, 0.03926420f, -0.09774493f, 0.25743708f, -0.06221276f, -0.08720913f, 
    0.06176984f, 0.14625746f, 0.09375793f, 0.00116179f, -0.01675969f, 0.04746396f, 0.08307650f, 0.07062347f, 
    0.21037851f, 0.19112195f, 0.04638470f, -0.04551781f, -0.13284506f, -0.04991027f, -0.04707679f, 0.09291657f, 
    -0.00391930f, -0.06005182f, -0.00931434f, -0.09340123f, 0.09184592f, -0.33154616f, 0.37038487f, -0.23470189f, 
    -0.03316544f, -0.00518523f, -0.26956505f, -0.03412296f, 0.01206306f, 0.15043923f, 0.15386359f, 0.07634228f, 
    -0.32451481f, 0.16750771f, -0.26445854f, 0.19464770f, 0.03801897f, -0.06802460f, -0.00621070f, -0.03813127f, 
    -0.00758405f, -0.02182119f, 0.08761514f, -0.03157546f, 0.29231137f, -0.24110711f, 0.16877459f, -0.02194602f, 
    0.00550446f, 0.15486312f, -0.01369963f, -0.00681892f, 0.09304641f, 0.04170937f, 0.11825969f, 0.19122697f, 
    0.09743277f, 0.16120535f, -0.06431641f, 0.19165185f, -0.05128829f, -0.09106208f, 0.13442945f, 0.04014730f, 
    -0.10356462f, -0.02404409f, -0.02435804f, -0.04043220f, 0.26107669f, -0.18517052f, 0.17191824f, 0.32548490f, 
    -0.00500315f, 0.23877905f, -0.05764746f, 0.23044494f, -0.11537920f, -0.02546591f, -0.09519199f, -0.16421358f, 
    -0.16047132f, -0.21085572f, -0.07470275f, 0.02700828f, 0.18179290f, -0.04464013f, -0.08129887f, 0.13368180f, 
    0.00315710f, -0.03078826f, -0.17278932f, -0.18669355f, 0.41179544f, 0.13329382f, 0.33079389f, -0.08400718f, 
    -0.10782921f, 0.08611218f, -0.14889038f, 0.03339232f, -0.12890036f, -0.08278018f, -0.00315547f, 0.01599108f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13739800f, 0.09760156f, 0.05004055f, -0.08133452f, -0.08379775f, 0.08670319f, 0.03952713f, -0.10361285f, 
    0.06460562f, -0.00610966f, 0.01406925f, -0.01052819f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
