#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.39574504f, 0.16962902f, -0.28206792f, 0.99699515f, 1.37347245f, 0.86675918f, 0.08385418f, -0.19776951f, 
    0.51392537f, 1.24365175f, 0.63036418f, 0.35356504f, 0.22497712f, 0.57923895f, 0.37650260f, 0.17365500f, 
    -0.47833216f, 0.12676841f, 0.66696137f, 0.67330575f, 0.74884075f, -0.22302239f, 0.24884202f, 0.44687036f, 
    -0.86191660f, -0.33453119f, -0.51014894f, -0.77603304f, 1.45767570f, 0.52337885f, 0.44071424f, 0.53605920f, 
    -0.13147524f, -0.00675044f, 0.23485848f, -0.01316014f, 1.01333356f, 0.62631065f, 0.88361108f, 0.93864882f, 
    -0.20235576f, 0.72241688f, 0.32319793f, 0.66926467f, -0.08866335f, -0.93857759f, 0.63147140f, 0.85567939f, 
    -0.08607423f, -0.03048689f, 1.22274852f, 0.18835992f, 0.05929282f, 1.07072759f, 0.75258112f, 0.95767105f, 
    0.13852897f, -0.62171137f, -1.04134488f, -1.08086967f, 0.49842855f, 0.70665926f, -0.18631715f, 0.12131720f, 
    -0.27849257f, -0.86101735f, -0.96116251f, 0.83224899f, -0.99163634f, -0.07406125f, 0.03521837f, -0.25276116f, 
    0.96645981f, -0.56086397f, -0.10367706f, 0.89141148f, 0.24290922f, -1.24963021f, -0.50559443f, -0.40459332f, 
    -0.16167846f, 1.20543814f, 1.01513278f, 0.40086111f, 0.11481979f, -0.60466087f, 0.39180136f, -0.82627660f, 
    -0.04176383f, 0.13186540f, -0.71183461f, -1.12244856f, -0.88310474f, 0.42112017f, 1.18088019f, 0.09918014f, 
    -0.11595334f, -0.02391973f, -0.50294161f, 1.02124929f, -1.04858172f, 0.94960099f, 0.61800122f, -0.54779971f, 
    0.27683359f, 0.19423844f, -0.42021996f, -0.27437812f, 1.04239249f, 0.86914992f, -1.39083683f, 0.99409157f, 
    0.27820837f, -0.15135422f, 0.52719426f, 0.51294923f, 0.25604808f, 1.16085875f, 0.88325310f, 0.88786864f, 
    -0.31399706f, 0.35844153f, -0.14918585f, 0.54823983f, 0.45011300f, 0.25327212f, -0.85609621f, -1.05901992f, 
    -0.93547130f, -0.08090500f, -0.68499827f, 0.14053269f, -0.53913653f, -0.09987240f, -0.34873104f, 0.20668526f, 
    -0.95945317f, -0.84133619f, -0.67168629f, -0.24836442f, 0.33715722f, 0.05575272f, 0.42403322f, 1.03160298f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07046637f, 0.19629994f, 0.72634947f, 0.24700481f, 0.04269742f, 0.01584261f, -0.05296965f, 0.46837321f, 
    0.52876717f, -0.27853712f, -0.02027813f, -0.45154360f, 0.27666804f, 0.12071898f, -0.58424795f, 0.17759871f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.68005276f, 0.04280793f, -0.18109302f, 0.03719537f, -0.08747334f, -0.19837025f, 0.16004016f, -0.05168483f, 
    -0.17234790f, -0.83828849f, -0.16518827f, -0.31960940f, -0.19173023f, -0.14237218f, 0.10411403f, 0.03287940f, 
    0.14432271f, 0.05539858f, -0.37123072f, -0.04059106f, 0.03732336f, 0.10284096f, 0.14054196f, 0.10356732f, 
    -0.11012015f, -0.25708339f, -0.27534750f, -0.00109152f, 0.16993357f, -0.23682195f, -0.01279551f, 0.09162809f, 
    -0.07499335f, -0.09855887f, -0.00743350f, 0.22966407f, -0.86054713f, -0.19865914f, -0.16301602f, 0.04174331f, 
    0.03041269f, 0.17212605f, 0.00335032f, 0.05602892f, 0.01924943f, -0.16651407f, -0.20639881f, 0.06479289f, 
    -0.25189131f, 0.11595448f, 0.22077015f, 0.14373483f, 0.11468200f, -0.05591793f, 0.30679706f, 0.67801636f, 
    -0.02739116f, 0.10469470f, -0.02565676f, -0.10256853f, -0.06933614f, 0.00401887f, 0.24887706f, 0.23725039f, 
    0.10473824f, 0.13857591f, 0.22366430f, 0.10799190f, 0.04303676f, 0.17414185f, 0.13554567f, 0.18828025f, 
    -0.25382787f, 0.09706591f, -0.20422509f, 0.11502107f, 0.08240283f, 0.03414663f, 0.19516522f, 0.13176651f, 
    0.18562189f, -1.24120128f, 0.37523326f, -0.04964902f, 0.12716955f, 0.22772138f, 0.06841503f, 0.02256577f, 
    0.08980807f, 0.12510996f, 0.25661919f, -0.05329116f, -0.43431428f, -0.22337766f, -0.27863559f, 0.11269113f, 
    -0.03149846f, 0.09045699f, -0.06428806f, -0.22962110f, -0.01737582f, 0.33296758f, -0.17461534f, 0.02467506f, 
    0.04885430f, -0.02921054f, 0.03473426f, 0.00018660f, 0.14102738f, -0.22399922f, -0.13997450f, -0.08316840f, 
    -0.23484355f, 0.00073129f, -0.01193368f, 0.11986459f, 0.02134309f, -0.98106098f, 0.10557256f, 0.18808818f, 
    0.44896445f, 0.19158322f, 0.00141514f, 0.05878214f, -0.03165260f, 0.10015349f, -0.23206221f, -0.12349085f, 
    -0.25265777f, -0.01502473f, -0.09496754f, 0.04674892f, -0.01424494f, -0.10695580f, 0.13700926f, 0.26300359f, 
    -0.23162179f, -0.04100376f, 0.18126859f, -0.12208745f, 0.06741658f, 0.09261481f, 0.26884776f, -0.12037110f, 
    -0.94479018f, -0.71140712f, 0.41913545f, -0.11864777f, 0.20461923f, -0.09238210f, -0.00816725f, -0.01529767f, 
    -0.14407010f, 0.34153700f, 0.23186852f, 0.23889393f, 0.00138299f, -0.08003161f, -0.28062230f, 0.05021510f, 
    0.01141428f, -0.02449006f, 0.34978303f, 0.18725722f, 0.19133461f, 0.07636001f, 0.41960350f, -0.00198411f, 
    -0.13825926f, 0.02988057f, 0.36317337f, -0.30953243f, -0.35497248f, -0.06421337f, -0.23772536f, -0.14820266f, 
    -0.03371930f, -0.08655673f, -0.16911696f, 0.12784639f, 0.73545170f, 0.22932664f, 0.39272487f, -0.03683103f, 
    0.24495138f, -0.19062690f, 0.18107507f, -0.08789304f, 0.01922485f, -0.49101058f, -0.21922660f, -0.04770973f, 
    0.05600183f, -0.07053435f, -0.00656033f, 0.05345515f, -0.21615642f, 0.14760117f, 0.72874528f, -0.12676954f, 
    -0.29930779f, 0.16170812f, -0.08540860f, -0.05096379f, 0.10511024f, 0.14183074f, 0.16185163f, -0.34230134f, 
    -0.20064558f, -0.14252692f, 0.20291880f, 0.02414210f, 0.07461063f, 0.12893479f, -0.41071934f, -0.04726557f, 
    -0.38706258f, -0.15900117f, -0.25511920f, 0.06774234f, 0.13839291f, -0.11293362f, -0.03420288f, 0.17389293f, 
    0.26792997f, 0.40365356f, 0.26644897f, -0.03833589f, 0.14750056f, 0.14421786f, 0.14621758f, -0.04186614f, 
    -0.01012432f, 0.18870249f, -0.55068392f, 0.08380282f, -0.58864141f, 0.13045120f, 0.17408468f, 0.15678702f, 
    -0.09686436f, -0.16831201f, -0.23387043f, -0.21062589f, -0.03354527f, -0.03172617f, -0.17872418f, 0.24695991f, 
    0.18227059f, 0.14417225f, 0.41576371f, 0.34914532f, 0.15851787f, -0.20446326f, 0.47523805f, -0.16315767f, 
    0.10955753f, -0.26166695f, 0.04477287f, 0.05047783f, 0.08433181f, 0.79731566f, 0.24794145f, 0.14329591f, 
    -0.15583780f, -0.14509501f, -0.10158657f, 0.09802030f, 0.06157060f, -0.00426665f, 0.03385112f, 0.28194627f, 
    -0.34626162f, 0.24911930f, 0.08516359f, 0.04554471f, -0.05394404f, 0.43182370f, -0.15126325f, -0.34473354f, 
    0.04045893f, 0.24332356f, 0.18723021f, 0.11605730f, -0.00197455f, 0.30043185f, -0.25199279f, 0.20046002f, 
    0.54464185f, 0.03720275f, -0.12182487f, 0.18570070f, -0.05974067f, 0.04195631f, 0.16220181f, -0.13244072f, 
    0.01141175f, -0.38622910f, -0.26275083f, 0.03651629f, 0.00672154f, 0.13048610f, 0.20337917f, -0.11612923f, 
    0.10812295f, -0.06272577f, 0.01568622f, 0.04445307f, 0.21905564f, 0.05535909f, 0.13832584f, 0.03014155f, 
    0.10917969f, -0.04260632f, -0.12445441f, 0.31779388f, -0.30782053f, -0.01368218f, -0.00342478f, 0.11588691f, 
    -0.13601981f, -0.10188538f, -0.16159433f, -0.07416176f, 0.13110664f, 0.02983667f, 0.05518936f, -0.17320323f, 
    0.10693263f, 0.07152746f, -0.19999945f, 0.13466081f, -0.02288504f, 0.11650114f, -0.35903329f, -0.19804780f, 
    -0.14799942f, -0.20171754f, 0.02350800f, -0.04063108f, -0.09182075f, -0.00944246f, 0.11089718f, 0.31988251f, 
    -0.00504949f, -0.14953919f, 0.11051007f, -0.02362655f, -0.14127634f, 0.03533781f, 0.18168133f, -0.50532526f, 
    -0.10881809f, -0.01074124f, 0.03887296f, 0.19000693f, 0.08614535f, 0.00199537f, 0.04401794f, 0.07416087f, 
    -0.45833087f, 0.04317477f, -0.15331061f, 0.36571953f, -0.04951945f, -0.04627177f, 0.26950863f, 0.08551319f, 
    0.09414823f, -0.23640451f, 0.20576090f, 0.03618263f, -0.11117264f, 0.02262071f, -0.02797970f, -0.21929041f, 
    0.27906168f, -0.02175779f, 0.16023895f, -0.30460390f, -0.36421767f, 0.09532628f, 0.07589382f, -0.08399832f, 
    0.15925792f, -0.12989402f, -0.26702201f, 0.63688475f, -0.18562430f, -0.43166515f, -0.26865456f, -0.05196677f, 
    0.35491875f, 0.00734429f, -0.17641903f, -0.11682941f, -0.43108469f, 0.16180681f, 0.61921877f, -0.06982387f, 
    -0.00846168f, -0.02960015f, 0.22804859f, -0.06317936f, 0.15291183f, 0.06512838f, -0.00697052f, 0.22761697f, 
    -0.16648902f, 0.18078420f, -0.02661498f, -0.00659351f, 0.05949221f, 0.06705934f, -0.10173257f, 0.17707522f, 
    -0.44371036f, -0.26206049f, 0.45594692f, -0.05528027f, -0.16590227f, -0.01817124f, 0.10405722f, -0.49465203f, 
    -0.04587206f, -0.49452272f, 0.00744474f, -0.00615558f, 0.01726284f, -0.11036927f, 0.09962104f, -0.31129974f, 
    -0.08871459f, 0.05507865f, 0.02354298f, -0.08338980f, -0.09529949f, 0.03515539f, 0.02226104f, -0.00463634f, 
    0.00609995f, -0.03590547f, 0.02471046f, -0.10369378f, -0.10604633f, -0.01539192f, -0.00470899f, -0.05123454f, 
    0.00552956f, -0.01309949f, 0.04756610f, -0.08767027f, -0.10559674f, -0.02829531f, 0.00280618f, -0.07027987f, 
    -0.10141937f, 0.02483058f, -0.03897113f, -0.05714975f, 0.01247407f, 0.01585903f, -0.06882680f, -0.04238633f, 
    -0.06291304f, -0.07286387f, -0.08084569f, 0.03895727f, -0.00058441f, 0.01802228f, -0.09094390f, -0.05580560f, 
    0.00339248f, -0.05812192f, 0.05318649f, 0.01351253f, 0.00216418f, 0.05185376f, -0.06100497f, -0.01724476f, 
    -0.04088966f, -0.07666797f, 0.04595242f, -0.05257157f, -0.09129708f, -0.05867550f, -0.03126090f, 0.04137981f, 
    0.03085873f, 0.03386135f, 0.03997182f, -0.08764701f, -0.02415398f, -0.02858374f, 0.03837921f, 0.00767178f, 
    0.04044056f, -0.01955166f, 0.04747176f, -0.06044406f, -0.02866344f, -0.09006087f, -0.10095163f, -0.01414698f, 
    -0.08767617f, -0.00960811f, 0.05536973f, -0.09232602f, -0.00145113f, 0.02607679f, -0.01124394f, -0.09582873f, 
    -0.01585275f, 0.00138300f, -0.06408957f, 0.04483268f, 0.02662609f, 0.06979882f, -0.08964659f, 0.04218862f, 
    -0.11681655f, -0.10690720f, -0.08210850f, 0.02875987f, -0.08854537f, -0.02629283f, 0.03026910f, 0.04989620f, 
    0.02489405f, -0.02551813f, 0.02129569f, -0.05108808f, 0.02045600f, -0.01696447f, 0.02495339f, -0.07887989f, 
    -0.07785510f, -0.04596025f, 0.02338373f, -0.09238934f, 0.03019566f, 0.03317535f, -0.05282999f, 0.02773837f, 
    -0.08385301f, -0.05619926f, 0.00533714f, 0.00988670f, 0.02443141f, -0.05941062f, 0.01151123f, 0.03001730f, 
    -0.04853930f, -0.02695940f, -0.07284120f, -0.08508255f, 0.01079687f, -0.01565044f, -0.06274906f, -0.10849284f, 
    -0.07017156f, -0.04230881f, -0.00326881f, 0.03731394f, -0.03569125f, -0.10171840f, 0.00542534f, 0.06161340f, 
    -0.02694185f, -0.08751778f, -0.03136732f, 0.00200114f, 0.01605722f, -0.05162749f, -0.03598012f, -0.03757082f, 
    -0.01751828f, -0.00534520f, -0.07560160f, 0.00401663f, -0.08028164f, -0.03591442f, 0.06794839f, -0.02831298f, 
    -0.10477960f, 0.00165892f, -0.05215628f, -0.00980386f, -0.06876629f, -0.07960461f, -0.05827194f, -0.03202223f, 
    -0.08352497f, -0.00002202f, -0.08760156f, 0.00144673f, 0.03883516f, -0.00202599f, -0.00198114f, 0.02755875f, 
    -0.03076470f, -0.08270759f, 0.05449085f, -0.04675516f, -0.02616346f, -0.02173296f, -0.03331535f, 0.04212186f, 
    -0.04728883f, -0.08509185f, 0.07545233f, 0.06217885f, 0.00203124f, -0.01303562f, 0.05518762f, 0.05547994f, 
    0.03265096f, 0.04931302f, 0.03554706f, 0.03104494f, -0.01287804f, 0.07161304f, -0.07804768f, 0.04770842f, 
    0.05818569f, 0.03515904f, 0.03820878f, -0.04273462f, -0.06549165f, 0.05300941f, 0.02270120f, 0.04366774f, 
    0.01803366f, -0.05169027f, 0.02571145f, -0.03299024f, -0.03708303f, -0.04534173f, -0.03781931f, -0.09864052f, 
    0.05022793f, -0.03413282f, -0.06560207f, -0.06441639f, -0.02127938f, 0.00889932f, -0.05182062f, 0.05546791f, 
    0.02942883f, -0.01462693f, 0.00254552f, -0.06335917f, -0.02632125f, -0.05020374f, -0.08102293f, 0.05287440f, 
    -0.04893866f, -0.03366290f, 0.06153163f, -0.07167281f, -0.03012898f, 0.00716313f, 0.01952800f, -0.06391502f, 
    -0.08529302f, 0.02281340f, 0.04754233f, 0.07680501f, -0.02363292f, -0.04540307f, -0.02700159f, -0.04299549f, 
    0.00838064f, 0.00158162f, -0.04957204f, -0.00492403f, 0.00434587f, -0.06393011f, 0.05152492f, -0.08506059f, 
    -0.01418611f, -0.02813913f, -0.07709813f, -0.04175173f, -0.06061855f, -0.06513125f, -0.06536571f, 0.05364300f, 
    0.01460490f, 0.03352793f, 0.03836915f, 0.04805764f, -0.06591155f, 0.01105027f, 0.04522402f, -0.06276941f, 
    0.03623239f, -0.03334424f, 0.00391450f, -0.08686464f, 0.01620818f, 0.01039985f, -0.01487505f, 0.07146664f, 
    0.04774247f, -0.06504380f, -0.08510929f, 0.06774010f, -0.03392870f, 0.02404227f, 0.01095246f, 0.06904156f, 
    -0.07552496f, -0.09025007f, 0.03754514f, -0.07714046f, -0.00160795f, -0.05028662f, -0.05753258f, -0.08308352f, 
    0.66410875f, 0.58735889f, 0.24201465f, 0.02705137f, -0.15645540f, -0.17770398f, 0.04491248f, 0.06576608f, 
    0.01224964f, 0.43832090f, -0.13143893f, 0.15636395f, -0.15844615f, -0.20661020f, 0.21037130f, 0.06826138f, 
    0.12705433f, 0.33734652f, 0.07153058f, 0.29636854f, -0.02551721f, 0.13090728f, -0.17606170f, 0.10390683f, 
    -0.03308406f, 0.17721288f, -0.21944615f, 0.26019037f, -0.25094622f, -0.06948271f, -0.38726902f, 0.27797294f, 
    -0.05022877f, -0.08451953f, 0.06769568f, 0.31677550f, -0.46850148f, 0.09667566f, 0.02522475f, 0.03440743f, 
    -0.22458692f, 0.02792870f, -0.04224114f, 0.02893299f, 0.14542903f, 0.20930597f, 0.90397984f, -0.54089642f, 
    -0.20407143f, 0.02260972f, -0.05116839f, 0.11802186f, -0.04883174f, 0.06866118f, -0.06873586f, -0.02876279f, 
    -0.08884411f, 0.07538105f, 0.09474214f, -0.03123780f, -0.04378892f, 0.16236176f, 0.07511295f, 0.21619581f, 
    -0.77610832f, -0.39206910f, 0.20230882f, 0.30654135f, 0.17086400f, -0.15208317f, -0.27147907f, 0.01640045f, 
    -0.26394525f, -0.60258025f, -0.13233095f, 0.15869485f, 0.16120782f, -0.10162146f, 0.06820498f, 0.00513998f, 
    -0.17942020f, -0.01201925f, -0.28544495f, -0.13467987f, 0.00033780f, 0.07289153f, 0.17801461f, -0.13568802f, 
    -0.08113153f, 0.14399423f, 0.19560640f, -0.19805096f, 0.02519899f, -0.09128403f, 0.34205887f, -0.06994671f, 
    0.14073806f, 0.02394949f, -0.10144178f, -1.06851768f, 0.35943186f, -0.00793601f, 0.17325415f, 0.19433118f, 
    0.01627366f, 0.07556321f, 0.06137271f, 0.11718313f, 0.27074200f, -0.43688577f, -0.16995147f, -0.06723393f, 
    -0.37686065f, -0.17969832f, -0.08329905f, -0.02864103f, -0.10117572f, 0.14918868f, 0.17984240f, -0.24949493f, 
    0.07776704f, -0.00300067f, 0.00999832f, -0.07921871f, -0.08164795f, -0.14145721f, -0.48744485f, -0.06604398f, 
    0.05393558f, -0.23841268f, -0.05610592f, -0.02117717f, -0.13424471f, 0.12146923f, 0.31317472f, 0.53062463f, 
    -0.13378666f, 0.11194772f, -0.05686428f, -0.06427892f, 0.03561448f, 0.06278002f, -0.10833086f, -0.02378476f, 
    0.81579447f, 0.26383811f, 0.33378589f, 0.11342773f, -0.10866844f, 0.11890414f, 0.11049659f, -0.21076469f, 
    0.14048958f, -0.17442065f, 0.15112153f, -0.16445756f, -0.18232413f, 0.08167268f, 0.18409801f, -0.07390404f, 
    0.00268663f, 0.05799294f, -0.12633525f, 0.17567469f, -0.17893502f, -0.12596345f, 0.02775145f, -0.04705503f, 
    0.08655361f, 0.01471230f, 0.15568894f, 0.59785217f, 0.20942077f, 0.50467235f, -0.07959284f, 0.02022457f, 
    0.05169905f, -0.09711897f, -0.17868796f, -0.12122143f, -0.26809385f, 0.09904191f, -0.00044177f, 0.22762689f, 
    -0.01740243f, 0.03351742f, 0.08272737f, -0.00655606f, -0.11011282f, -0.69610554f, -0.24383989f, -0.13154852f, 
    -0.14479300f, 0.20427817f, -0.12403378f, 0.10980295f, 0.04315055f, -0.32120314f, 0.15331097f, -0.04310058f, 
    0.17008105f, -0.24434353f, 0.02440073f, -0.06243786f, -0.03190332f, 0.20839000f, -0.10618579f, -0.33165333f, 
    0.34030619f, -0.02135221f, 0.20954457f, 0.19037990f, -0.02219141f, -0.17428271f, -0.13205756f, 0.01801240f, 
    -0.03408914f, -0.33505106f, 0.27680820f, -0.21989857f, -0.05165508f, 0.00611540f, 0.06423549f, 0.06369837f, 
    0.12202782f, 0.16965975f, -0.05894161f, 0.24748309f, -0.22957784f, -0.01713844f, 0.00319520f, 0.02886609f, 
    0.05584251f, -0.20044915f, -0.46239737f, 0.51351541f, -0.21853407f, 0.26488575f, 0.12629890f, 0.29568923f, 
    0.18490791f, -0.05040191f, 0.08991899f, 0.39678565f, -0.38816091f, -0.17024225f, -0.09419719f, 0.22120504f, 
    -0.00119553f, -0.16278592f, 0.24642779f, -0.29101416f, -0.15512927f, -0.49380335f, 0.12654193f, -0.28801730f, 
    -0.10493070f, 0.05251595f, -0.11209546f, -0.12282723f, 0.03284966f, 0.12730914f, 0.33447066f, -0.25295064f, 
    -0.26410672f, -0.23505464f, -0.11794162f, 0.05688224f, -0.01831483f, -0.06541580f, -0.32217678f, -0.01170937f, 
    -0.21257499f, -0.03413910f, 0.01016951f, -0.06841567f, 0.21248974f, -0.10748815f, 0.14179133f, -0.21764494f, 
    0.08912303f, -0.22363038f, 0.05608758f, 0.19378124f, 0.38426447f, 0.03823463f, 0.21868375f, -0.06251430f, 
    -0.02787814f, 0.02619231f, -0.05929258f, -0.07358385f, -0.05268835f, -0.01186182f, -0.09694722f, 0.01519424f, 
    0.01470847f, 0.05129300f, 0.07632599f, 0.00217891f, -0.04255152f, -0.07644819f, 0.05377714f, 0.06608933f, 
    -0.04673321f, -0.04956221f, -0.07740357f, -0.06901772f, 0.02239453f, 0.05881421f, -0.04711802f, -0.00047683f, 
    -0.02434980f, 0.05606269f, 0.03810630f, -0.00984711f, -0.03684543f, -0.04470863f, 0.00435558f, 0.00013764f, 
    0.03323957f, 0.03190459f, 0.02658192f, -0.03463281f, -0.05276420f, 0.06765578f, -0.03819904f, -0.02133473f, 
    0.03709572f, 0.02050820f, -0.01048165f, -0.06112492f, -0.10758953f, 0.04930962f, -0.02971721f, -0.06563345f, 
    -0.05382420f, -0.05354806f, -0.01208248f, -0.03929507f, -0.03875373f, -0.10476316f, 0.04873700f, -0.05618585f, 
    -0.06621619f, -0.06993912f, 0.01562114f, -0.07473314f, 0.06345219f, -0.03884582f, 0.01719594f, -0.00238870f, 
    0.06008177f, 0.03563950f, -0.03203031f, 0.05299978f, -0.06515010f, -0.03200329f, -0.00430074f, -0.04247476f, 
    0.04603652f, -0.08748120f, 0.03085557f, -0.01425941f, 0.02532862f, 0.01145681f, 0.04790669f, -0.04743555f, 
    0.05983713f, 0.06158903f, -0.01249451f, 0.02400850f, 0.01870522f, -0.03487241f, -0.02016191f, 0.06117617f, 
    -0.09340492f, -0.09395276f, -0.06312399f, -0.08883927f, -0.07709280f, -0.06681002f, -0.01826339f, 0.05062624f, 
    -0.02170931f, -0.07229924f, 0.04162278f, 0.02952840f, -0.02146463f, -0.00144222f, -0.04653718f, -0.03454067f, 
    0.03955926f, -0.07450987f, -0.02107289f, 0.01735129f, -0.01340136f, -0.02313634f, 0.06070517f, 0.06921266f, 
    -0.02781901f, -0.05849812f, 0.03254232f, -0.02307905f, 0.03774244f, -0.06022900f, -0.07416464f, -0.00106426f, 
    0.01348623f, -0.05654377f, -0.02502708f, 0.01548602f, -0.01625749f, -0.08504821f, 0.02695044f, -0.02474179f, 
    0.05113419f, 0.02398264f, -0.09640808f, -0.08418733f, -0.02032149f, -0.04896199f, 0.03333993f, 0.03416453f, 
    0.03153038f, 0.03100565f, 0.00752221f, 0.01293394f, 0.04633452f, -0.05574527f, 0.05409796f, 0.04520909f, 
    0.11955626f, 0.15636803f, -0.16578355f, 0.20589414f, 0.15203544f, -0.05533828f, 0.19977130f, -0.23297410f, 
    0.00096394f, -0.10504897f, 0.04926585f, 0.15366010f, 0.10851942f, 0.20031546f, 0.19696814f, -0.17490248f, 
    -0.01237375f, -0.01614713f, 0.17954446f, 0.53506082f, 0.29206550f, 0.34332103f, 0.01737738f, 0.45791736f, 
    0.29248631f, 0.30799529f, -0.08461869f, 0.15130824f, 0.23726282f, 0.30625176f, 0.08584893f, 0.39885762f, 
    0.08575107f, -0.01500345f, 0.19833793f, 0.13372703f, -0.36031529f, -0.13978778f, 0.14664720f, -0.03581201f, 
    0.00919253f, 0.04253429f, 0.32082802f, 0.00097469f, -0.10372237f, -0.06722236f, -0.18107828f, -0.39659032f, 
    -0.14873166f, -0.06617337f, 0.06774963f, -0.01461306f, -0.16797097f, 0.07224099f, 0.00220683f, 0.03155821f, 
    0.00373869f, -0.61670518f, -0.11718604f, -0.03487428f, -0.17025064f, 0.27286410f, -0.01421055f, -0.22362837f, 
    -0.24335335f, -0.00477707f, 0.44471771f, 0.18802856f, 0.26815131f, 0.06390397f, -0.17454359f, 0.14379451f, 
    0.13177258f, -0.27502578f, -0.16463214f, 0.27765155f, 0.15703441f, -0.04163620f, 0.01666550f, 0.24055147f, 
    0.23935798f, -0.40373716f, 0.25388363f, 0.41266289f, -0.27355430f, 0.22232269f, 0.06049520f, 0.16463646f, 
    -0.16491179f, -0.01182426f, -0.06829031f, -0.29830727f, -0.39274174f, 0.33163092f, -0.09089082f, 0.37049296f, 
    0.08109323f, -0.03232187f, -0.15508389f, -0.54535311f, -0.09962494f, -0.30647817f, 0.02339852f, -0.00651205f, 
    -0.03550632f, -0.14960405f, -0.19204223f, -0.05091444f, -0.19581862f, -0.06312766f, -0.47284001f, -0.31589663f, 
    -0.15175419f, -0.23409171f, 0.07124428f, -0.23212788f, -0.08676349f, -0.28352153f, 0.02179981f, 0.42821023f, 
    -0.24377917f, 0.07189609f, 0.14839044f, 0.02387419f, -0.14327899f, 0.08257408f, -0.48047951f, -0.17389773f, 
    0.54295677f, 0.07037742f, 0.43088400f, 0.18681888f, 0.10380494f, -0.20413974f, -0.01666206f, -0.19646175f, 
    -0.30088788f, -0.43284720f, 0.09455263f, -0.14661579f, -0.16939530f, 0.06953897f, -0.03476511f, -0.04768555f, 
    -0.08401765f, -0.36538133f, 0.20768672f, 0.09245632f, 0.11539977f, 0.07624301f, -0.20906362f, -0.03435690f, 
    -0.12940539f, 0.01135059f, 0.20470083f, 0.10157011f, 0.03980993f, -0.07906666f, 0.13138767f, -0.04506448f, 
    -0.18590559f, -0.01908606f, 0.11262672f, 0.18951510f, -0.39944148f, 0.04920672f, 0.08694246f, 0.15323864f, 
    0.12357253f, 0.00055219f, -0.20515317f, 0.33645830f, 0.31968075f, 0.14113641f, 0.11582964f, 0.02636976f, 
    0.36252856f, 0.09552459f, -0.15111893f, -0.06422829f, -0.32893836f, -0.58546603f, -0.52168173f, 0.17224516f, 
    0.35128221f, 0.01795255f, -0.21234116f, 0.23144323f, -0.31755245f, -0.15896012f, 0.11494513f, 0.00261580f, 
    -0.01833593f, 0.25325507f, 0.28918168f, 0.09480131f, -0.14625740f, -0.49270040f, -0.05288650f, -0.05825621f, 
    -0.03836256f, -0.09628771f, -0.05798002f, -0.19129051f, 0.26748323f, 0.04777706f, -0.23590533f, 0.18388100f, 
    0.51394314f, 0.07287445f, -0.14752100f, -0.18975861f, -0.02633316f, 0.24862091f, 0.16412742f, 0.14588057f, 
    0.26822376f, -0.30047289f, -0.15871127f, 0.18360165f, 0.03668038f, 0.21884347f, -0.15607528f, 0.23801285f, 
    0.13236469f, 0.27300248f, 0.24632841f, -0.16819698f, 0.13613118f, 0.09304772f, -0.12149636f, 0.10171297f, 
    -0.15469718f, -0.11668307f, -0.38051707f, -0.06572241f, 0.48625687f, -0.11543180f, -0.20043816f, 0.31247354f, 
    -0.03711993f, 0.16257755f, 0.25436246f, -0.02509181f, -0.11577562f, -0.19059812f, 0.03639720f, 0.28939694f, 
    -0.09895252f, -0.10918251f, 0.02811544f, -0.36201385f, 0.14923942f, 0.04508489f, 0.14833012f, 0.18169788f, 
    -0.01084385f, -0.00988504f, -0.05065813f, -0.11924187f, -0.09904000f, -0.16264763f, -0.07460959f, -0.04942831f, 
    -0.23463303f, -0.03163139f, -0.09669938f, -0.01235935f, 0.21063733f, 0.00684701f, -0.01457684f, -0.40768263f, 
    -0.02773801f, -0.17815071f, 0.11719263f, 0.21104631f, 0.10067639f, -0.09411974f, 0.12828483f, -0.05072680f, 
    -0.22930011f, -0.19956736f, 0.10455091f, 0.15364924f, 0.18959880f, 0.02831464f, 0.03333512f, -0.11039226f, 
    -0.10583640f, -0.56883186f, 0.27481255f, 0.04664330f, -0.01413499f, 0.02377797f, -0.23515595f, 0.12068987f, 
    0.08882301f, -0.05426272f, 0.09354375f, 0.28841287f, 0.09248714f, -0.26928911f, -0.02200387f, -0.17290685f, 
    0.17241086f, 0.17755470f, 0.19904943f, -0.11663825f, 0.26063398f, -0.12992783f, -0.17074165f, -0.07612178f, 
    -0.07280973f, 0.14046536f, 0.00914758f, 0.15690838f, 0.02681261f, -0.38622791f, 0.01844366f, -0.12883013f, 
    -0.02119289f, 0.00560565f, -0.03721178f, -0.02536897f, 0.19372319f, 0.14469860f, -0.10615586f, 0.01936379f, 
    0.22630560f, 0.24151632f, 0.09853759f, -0.08028832f, -0.03076801f, 0.29852843f, -0.11500960f, 0.08348187f, 
    0.02997139f, -0.01891945f, -0.05010886f, -0.07632736f, 0.05978471f, 0.15525384f, -0.23643485f, 0.38195994f, 
    -0.71541834f, 0.05171390f, -0.04307078f, -0.34715131f, 0.04264332f, 0.13023756f, -0.22670810f, 0.15690856f, 
    -0.24778719f, -0.13100295f, -0.03851628f, -0.03938975f, 0.00376899f, -0.10701902f, 0.03857221f, -0.04877992f, 
    0.50202948f, -0.33629221f, -0.26843339f, -0.21447122f, -0.17912869f, 0.15201882f, -0.11697988f, 0.08329272f, 
    0.04620034f, 0.14466317f, 0.33903226f, 0.12322839f, -0.07993335f, 0.38294700f, 0.05396389f, -0.07074074f, 
    0.01907314f, 0.03243798f, -0.13564505f, 0.06117969f, 0.84414530f, 0.14208911f, 0.03289366f, 0.08188491f, 
    -0.08677806f, 0.19573912f, 0.16840270f, -0.10967904f, 0.01372319f, -0.40878797f, -0.00258341f, 0.08724860f, 
    -0.07666979f, 0.02408767f, -0.09688829f, 0.02258309f, -0.01332287f, 0.28882051f, 0.22604027f, -0.17943871f, 
    -0.26724103f, -0.08607742f, 0.04538293f, 0.09315516f, -0.03495993f, -0.07003925f, 0.13639468f, -0.26130089f, 
    0.05844272f, -0.24124159f, -0.15715836f, 0.05867893f, -0.04949523f, -0.10305239f, -0.13770649f, -0.39767864f, 
    0.93519670f, 0.39347386f, 0.11596084f, 0.07420236f, -0.12038771f, 0.18041244f, -0.04998551f, 0.30815917f, 
    -0.00931283f, 0.32127139f, -0.02348599f, 0.06430458f, -0.03074914f, -0.16525483f, -0.22142480f, -0.09348861f, 
    -0.06960580f, -0.02296363f, -0.08210394f, -0.05616230f, 0.00254722f, 0.04413765f, -0.03447044f, -0.05313655f, 
    -0.07800179f, 0.00985697f, 0.04181072f, 0.04671142f, -0.07589929f, 0.05702229f, -0.08171935f, 0.05653322f, 
    0.02145789f, -0.03428887f, -0.06345893f, -0.08741178f, 0.01453655f, -0.04543300f, -0.04625327f, -0.06327465f, 
    0.05370020f, -0.07641017f, 0.06246144f, 0.05191604f, -0.06540552f, 0.04715041f, -0.06908400f, -0.06747792f, 
    -0.04879466f, 0.05056884f, -0.08469024f, 0.04146262f, 0.05307339f, -0.01173938f, -0.05132465f, -0.07414758f, 
    -0.06417666f, -0.07660500f, -0.00903710f, 0.06344710f, -0.06619338f, -0.06982413f, 0.02591583f, 0.02468529f, 
    0.03481557f, 0.07427865f, 0.06221180f, 0.05606777f, 0.02230365f, -0.04728313f, -0.05523225f, -0.04628797f, 
    0.00638674f, -0.07043207f, -0.06493423f, -0.01915215f, -0.05382464f, 0.00252172f, 0.02570222f, 0.04652520f, 
    -0.08323555f, -0.05956706f, 0.02594602f, -0.08299784f, 0.01184405f, -0.04524841f, -0.04126408f, 0.06999637f, 
    -0.01521014f, -0.08961623f, 0.02792160f, 0.01368088f, -0.02730087f, -0.02843954f, 0.06418895f, -0.08985523f, 
    0.00223951f, 0.05990661f, -0.07394187f, -0.02577604f, -0.00391681f, -0.08029309f, -0.06374042f, 0.06801707f, 
    0.01075092f, 0.06362654f, -0.00498094f, -0.04956962f, 0.08034924f, 0.05171098f, -0.07812095f, -0.04158734f, 
    -0.06740385f, 0.06664436f, -0.03483117f, -0.04382503f, -0.06102555f, 0.03750307f, -0.05870684f, -0.03095934f, 
    -0.04122543f, -0.06040479f, 0.06065278f, 0.01169238f, 0.01811191f, -0.04255028f, -0.07513493f, 0.00597205f, 
    -0.03686981f, 0.06341774f, -0.08783060f, -0.01791144f, 0.00548115f, -0.08721108f, 0.01535568f, -0.05883846f, 
    -0.04560534f, 0.03676682f, -0.00644211f, -0.09374271f, -0.00843903f, 0.05919251f, -0.05386044f, -0.05156342f, 
    -0.08399443f, -0.07912913f, 0.05861292f, -0.01598767f, -0.05053036f, 0.00718694f, -0.05787428f, 0.00669029f, 
    -0.07151845f, 0.06130521f, 0.03508879f, -0.03721402f, 0.02990661f, 0.06297223f, -0.05298400f, -0.04103837f, 
    0.11497137f, 0.12174754f, -0.02051692f, -0.07231134f, 0.00310755f, -0.09527440f, 0.13465254f, 0.52626687f, 
    0.14371444f, -0.85696191f, -0.53850859f, -0.31471634f, -0.22726326f, 0.11974923f, -0.09723261f, 0.26553339f, 
    -0.25120789f, 0.05720923f, -0.19323082f, -0.69214964f, 0.39956599f, -0.02584662f, 0.03610574f, 0.09687529f, 
    -0.29583097f, 0.03544076f, 0.14759985f, 0.73033291f, -0.06502096f, -0.24783783f, 0.03657261f, -0.17016236f, 
    -0.16437440f, 0.13763773f, -0.14031358f, -0.08993562f, -0.94805771f, -0.41769001f, -0.05804791f, -0.10841000f, 
    0.04309155f, 0.25679442f, -0.00022784f, 0.07317097f, -0.12230792f, -0.50580257f, -0.23581025f, -0.15756352f, 
    0.06381067f, -0.06946398f, -0.03205662f, 0.12587909f, -0.19923683f, 0.11119352f, 0.36091617f, -0.23656957f, 
    -0.24168046f, 0.16942309f, -0.04300527f, 0.07217292f, -0.38500082f, -0.08960012f, -0.08943984f, -0.11352997f, 
    0.45786801f, 0.14491814f, 0.15790749f, 0.05191270f, 0.14221029f, -0.19714774f, -0.06970972f, -0.40094665f, 
    -0.11235299f, 0.34144425f, 0.00288517f, 0.00308670f, 0.04242639f, -0.07422455f, 0.23470774f, -0.02958823f, 
    0.20201136f, -0.13001248f, -0.84422040f, 0.31617588f, -0.20260039f, 0.04195610f, 0.18446682f, 0.00682199f, 
    0.01346002f, -0.08653580f, 0.15913665f, 0.41209352f, 0.04717202f, 0.15462546f, -0.00566922f, -0.17110279f, 
    -0.02094930f, 0.01199982f, 0.15270211f, -0.09925725f, -0.11823653f, -0.07786400f, 0.16645457f, 0.31813422f, 
    0.01068551f, -0.02711722f, 0.09477576f, 0.16743945f, 0.75054258f, 0.11407313f, -0.02581513f, -0.42593014f, 
    -0.21273136f, 0.05952901f, -0.26158527f, 0.05259747f, 0.18145800f, -0.71742326f, -0.45245829f, 0.16683996f, 
    0.27997604f, 0.26646730f, 0.15381567f, 0.08821111f, -0.07605301f, -0.10210033f, -0.11904863f, 0.31688222f, 
    0.01819315f, 0.15275775f, -0.18708222f, -0.10713205f, -0.19894318f, -0.04728523f, -0.11475341f, 0.25262088f, 
    0.12094212f, -0.31683323f, -0.01001702f, 0.02072388f, -0.16029596f, -0.14301510f, 0.21568453f, 0.17129710f, 
    0.04900450f, 0.05934091f, -0.03717678f, 0.04911700f, 0.00232901f, -0.01532132f, 0.04439555f, -0.03144043f, 
    0.02962663f, -0.01614407f, 0.03857206f, -0.04857455f, -0.04716839f, 0.04102558f, 0.05810864f, -0.04966698f, 
    0.02694440f, 0.04953088f, -0.05501583f, -0.04462885f, -0.05737136f, -0.01119609f, -0.03921849f, 0.00506755f, 
    0.01209419f, -0.07439390f, 0.06677078f, -0.05536813f, -0.02026811f, -0.02877015f, -0.07483218f, 0.00496237f, 
    -0.04664053f, 0.04721100f, 0.03745113f, -0.07355469f, -0.11232141f, 0.04361473f, -0.02986588f, 0.01887492f, 
    -0.05818143f, -0.05403977f, -0.08596881f, 0.07178426f, -0.01459809f, -0.05713888f, -0.02773483f, -0.04358538f, 
    0.00658410f, 0.06212877f, -0.10256395f, -0.00471947f, -0.07503850f, -0.06700809f, 0.03986576f, 0.00458354f, 
    -0.05894729f, 0.05701634f, -0.06270903f, -0.07078861f, -0.01810190f, -0.03654306f, -0.02456897f, 0.06676274f, 
    -0.05114850f, -0.03983641f, -0.04446799f, 0.04395489f, -0.07600738f, 0.06079128f, 0.03633143f, -0.04124087f, 
    -0.00711210f, -0.02107754f, -0.10393072f, 0.03266888f, 0.03203064f, 0.01591882f, 0.05452474f, -0.06602634f, 
    -0.10056976f, -0.07844599f, 0.02312250f, 0.06006642f, -0.04908357f, -0.01349675f, -0.07741018f, -0.03199589f, 
    0.02589993f, 0.02637054f, 0.06280750f, -0.03346429f, 0.00328646f, -0.03928430f, -0.08694710f, 0.03473800f, 
    -0.03686554f, 0.04268494f, 0.06238545f, 0.03929360f, -0.06857993f, -0.08392481f, 0.02376653f, -0.09083426f, 
    0.01692306f, -0.07727892f, -0.03213188f, -0.07333484f, -0.07768043f, 0.01446998f, 0.04549598f, -0.02730193f, 
    -0.00761412f, -0.05239122f, 0.04052649f, -0.02697132f, -0.06644676f, -0.01079495f, -0.11033410f, -0.06979032f, 
    -0.06817526f, -0.01092065f, 0.01868782f, -0.07544044f, -0.05945003f, 0.05275183f, -0.03535359f, -0.04998429f, 
    0.01356037f, -0.05124962f, 0.06499844f, 0.02100340f, 0.06092401f, 0.03854528f, -0.06389326f, -0.02154347f, 
    0.05807785f, 0.00460993f, -0.03691994f, -0.06403023f, -0.06074116f, -0.05009272f, 0.03581040f, -0.05034700f, 
    -0.35327736f, 0.05976043f, 0.07940069f, 0.10804477f, 0.20345058f, 0.05226942f, -0.18272655f, 0.08815435f, 
    0.13620409f, -0.10794252f, 0.35651049f, 0.07181241f, 0.13014093f, 0.31445241f, 0.14643966f, 0.06943400f, 
    0.05277346f, 0.00743714f, -0.34622380f, 0.00938964f, -0.36356547f, 0.01333940f, 0.02853463f, 0.05635260f, 
    -0.03431945f, -0.07839261f, 0.08258026f, 0.67597532f, -0.03832859f, -0.04182011f, 0.11073306f, -0.10629502f, 
    -0.18060037f, -0.13542008f, -0.19385648f, 0.11321706f, -0.03456814f, -0.61642200f, -0.03155317f, -0.04200086f, 
    0.01948814f, 0.02891595f, 0.05350764f, -0.01658068f, 0.01392126f, -0.56253934f, 0.01091522f, 0.03532718f, 
    -0.01199240f, 0.01708313f, 0.01054539f, 0.13914089f, -0.10996287f, -0.21795744f, 0.60172385f, -0.34693035f, 
    0.09959168f, -0.03077730f, -0.14715500f, 0.00513198f, 0.24414109f, -0.07541381f, 0.12280186f, 0.18729933f, 
    0.39662421f, -0.55433267f, -0.01456658f, 0.19603503f, -0.04119401f, -0.21808347f, -0.11326166f, -0.25704423f, 
    -0.15406801f, -0.51553577f, -0.10492396f, -0.03534022f, 0.14252649f, -0.03833370f, -0.13442335f, -0.00409403f, 
    0.06400848f, 0.02261795f, 0.45134544f, 0.11171172f, -0.02239898f, 0.03286891f, 0.00265074f, 0.10131062f, 
    -0.03409883f, 0.11961769f, -0.12005976f, 0.56686527f, -0.04054055f, 0.04080553f, 0.03841671f, -0.02425005f, 
    -0.17921898f, 0.14113905f, 0.06932969f, -0.35028905f, -0.55890477f, -0.11093309f, -0.08928698f, -0.21568987f, 
    0.06468451f, -0.19777526f, 0.11621435f, 0.06610890f, -0.01300461f, 0.11712990f, -0.05171446f, -0.00810441f, 
    0.03325965f, -0.29831284f, 0.19713055f, -0.11955200f, 0.06537323f, 0.71294653f, -0.02481721f, -0.01213240f, 
    -0.09302370f, 0.11219403f, 0.15304142f, -0.08161461f, 0.06805292f, -0.11561947f, 0.70103312f, 0.24611425f, 
    0.03394929f, -0.00784614f, -0.13113946f, -0.17484474f, 0.14407480f, 0.07779920f, 0.21545486f, -0.31734926f, 
    0.36216202f, -0.26446247f, 0.14998677f, -0.02489928f, -0.07911908f, 0.05172195f, -0.01670857f, -0.21182844f, 
    -0.03616153f, 0.08847018f, 0.14050694f, 0.12023708f, 0.15282576f, -0.05052996f, 0.14256255f, -0.04189496f, 
    0.15849982f, -0.07240982f, 0.01646662f, -0.18436243f, 0.28176957f, 0.14572498f, -0.05529206f, -0.00729916f, 
    0.00320960f, 0.08518458f, 0.21235254f, -0.12108998f, 0.14726396f, -0.00298292f, 0.13027419f, 0.21671070f, 
    -0.15247202f, 0.01817081f, 0.33384612f, -0.60337043f, 0.12417421f, -0.29954690f, 0.31208500f, -0.13613112f, 
    -0.04686919f, -0.15266199f, 0.16440573f, 0.03100722f, -0.41869593f, 0.14802468f, -0.30704826f, 0.11925329f, 
    0.05865311f, -0.27664417f, 0.19391619f, 0.04547368f, 0.28551862f, -0.05942150f, 0.14056352f, -0.27805752f, 
    -0.05459239f, -0.05274535f, -0.14076795f, -0.21695998f, 0.18964885f, 0.01637634f, -0.06715281f, -0.57139391f, 
    -0.01628980f, -0.27184054f, 0.01238152f, 0.20344706f, 0.10628419f, -0.11050039f, -0.21689382f, 0.01047540f, 
    -0.15190117f, 0.32507277f, 0.37555689f, 0.08047286f, -0.00195829f, -0.08169491f, -0.12533997f, -0.27770776f, 
    -0.06062040f, 0.03728924f, -0.08609194f, -0.12668997f, 0.10698768f, 0.00870453f, -0.11995389f, 0.30435866f, 
    0.09693986f, 0.12686029f, -0.08169224f, 0.14478187f, 0.00002532f, -0.19149631f, -0.09711682f, -0.06941614f, 
    -0.20746250f, 0.15397093f, 0.37413019f, 0.21593718f, 0.17165349f, -0.03751800f, 0.01824692f, -0.22247565f, 
    0.25740778f, 0.02720882f, 0.13843602f, 0.03387215f, -0.22664148f, -0.09569680f, 0.24610311f, 0.07531442f, 
    -0.05999014f, -0.02623451f, 0.25870559f, 0.11254133f, -0.26242268f, -0.10998203f, 0.38560352f, -0.00770041f, 
    0.10218639f, -0.03695121f, 0.14272836f, 0.14104059f, 0.02625884f, -0.25352943f, -0.46289787f, 0.06413225f, 
    0.04047416f, -0.03315007f, 0.00966090f, 0.12672995f, -0.06329753f, 0.06063713f, 0.32719338f, 0.59069306f, 
    0.00591964f, 0.16924520f, -0.00725596f, 0.16020691f, 0.15127671f, 0.30717346f, 0.16535558f, -0.14337662f, 
    0.17193097f, 0.20118693f, -0.19805333f, -0.00830699f, 0.11142005f, 0.07581560f, -0.03775973f, 0.06649512f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.41767481f, 0.04043851f, 0.35174987f, -0.02047517f, -0.08620846f, 0.10916802f, -0.18212371f, -0.05384429f, 
    0.34406844f, 0.00589246f, -0.28669494f, -0.05717060f, -0.01276122f, -0.08164251f, -0.14906736f, 0.17552139f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10591306f, -0.29791352f, -0.32069287f, -0.09904806f, -0.03914474f, -0.14831235f, 1.23813343f, 0.14619696f, 
    -0.11287454f, 0.14893301f, -0.32302627f, 0.23530677f, -0.42546132f, 0.05133892f, -0.14260696f, 0.01402827f, 
    -0.29674271f, -0.07042545f, 0.43432707f, 0.09676329f, 0.24351260f, 0.38387650f, -0.33657187f, -0.05348828f, 
    0.35968408f, -0.51227915f, -0.13685717f, -0.11199647f, -0.04632584f, 0.16265154f, -0.35666993f, 0.33256361f, 
    0.55948120f, 0.06372871f, -0.15105212f, 0.11555456f, -0.16757819f, 1.03957260f, -0.07652146f, -0.12255152f, 
    -0.40962890f, -0.04339192f, 0.38821867f, -0.24497695f, -0.86351842f, -0.13876399f, -0.22666046f, -1.06594551f, 
    0.18408194f, -0.33483806f, -0.46607959f, -0.14170329f, 0.12262142f, 0.02965983f, 0.00275805f, -0.16133949f, 
    -0.23311858f, 0.42807156f, -0.30215105f, 0.18100895f, 0.92810404f, 0.09269503f, 0.01132575f, -0.05938597f, 
    0.19230801f, -0.23213220f, -0.87742066f, -0.17011577f, 0.17786588f, -0.32167196f, 0.18360023f, 0.06940977f, 
    0.60467184f, 0.52068299f, 0.35692790f, -0.13585635f, -0.33866277f, 0.01981010f, -0.25652730f, -0.28210923f, 
    -0.41255596f, 0.27884719f, 0.16541825f, 0.04271769f, 0.20528673f, -0.36778945f, -0.09574590f, -0.13521184f, 
    0.62280297f, -0.53089678f, -0.88945359f, -0.12059563f, -0.09078827f, 0.03183895f, 0.08831149f, 0.27031112f, 
    0.30083153f, 0.54864061f, 0.16723433f, 0.23015271f, -0.17032480f, -0.70590961f, 0.14553161f, 0.18122692f, 
    0.29168814f, 0.13712467f, -0.40369076f, -0.11929358f, -0.44166982f, -0.21337853f, -0.04444457f, -0.56778401f, 
    -0.51420510f, -0.48432532f, -0.34851807f, -0.04576699f, 0.16130355f, -0.02775772f, -0.05518082f, -0.13094430f, 
    -0.38088343f, -0.26884559f, 1.02108741f, 0.06998661f, 0.54762834f, -0.05513318f, 0.52062261f, 0.14641286f, 
    -0.66347343f, 0.72864753f, -0.82171977f, -0.11743532f, -0.05431918f, 0.41150790f, -0.31494185f, -0.16555698f, 
    -0.85354161f, -0.91960233f, 0.61391747f, 0.01450718f, -0.23173347f, -0.16736865f, 0.08612520f, 0.11436848f, 
    -0.08278156f, 0.07117141f, 1.25905478f, 0.03704662f, -0.16536321f, -0.68012333f, -0.12915316f, 0.22707847f, 
    -0.14607169f, 0.43896475f, 0.61585999f, -0.19307832f, -0.17619839f, -0.08923686f, -0.42104161f, -0.38132316f, 
    0.93871421f, -0.00102188f, -0.39314961f, -0.16926619f, -0.02954493f, 0.37697729f, -0.77930504f, 0.11117582f, 
    -0.60000646f, -0.13786912f, -0.50350320f, 0.12467675f, 0.20782647f, 0.02721897f, -0.64164394f, 0.36526212f, 
    0.02843383f, 0.09946287f, -0.05767860f, 0.09590918f, 0.21618581f, -0.19028071f, -0.31216151f, 0.07587545f, 
    -0.60881931f, 0.59598660f, -0.62760323f, 0.02480712f, -0.84663528f, 0.02259892f, 1.29091215f, 0.25383866f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10357215f, 0.06977203f, 0.09700111f, 0.09822057f, 0.25229782f, 0.26706940f, -0.50050563f, -1.03949904f, 
    0.32193628f, -0.06647443f, 0.18843113f, -0.29278177f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
