#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.92467725f, -0.56952888f, -0.75689381f, 0.43405122f, 0.87699944f, 0.51060134f, -0.73517901f, 0.47648084f, 
    -0.50737542f, -0.54930270f, -0.92160380f, 0.16952442f, 0.23510523f, -0.50041729f, 0.62144071f, -0.57336676f, 
    0.08085364f, 0.62493223f, 1.44174743f, -1.15721786f, -0.94782543f, 0.26992276f, -0.08172964f, 0.71311402f, 
    -0.12181750f, -0.11763332f, 0.13653089f, 0.43108192f, 0.13399632f, -0.58175159f, -0.13563527f, 0.08546875f, 
    0.20765480f, 0.04250587f, 0.45386431f, 0.42592159f, -0.84819317f, -0.61588615f, -0.75277656f, -0.87965471f, 
    -1.09113789f, -1.11064434f, 0.26389834f, 0.11597513f, 0.07210764f, -0.29320702f, -0.75116271f, 0.35689512f, 
    -0.54469633f, -1.32887387f, -0.64405763f, -0.05974874f, 0.43141434f, 0.14714287f, 0.61950076f, 1.25774825f, 
    -1.18971968f, -1.00431514f, -0.60808682f, -0.94262987f, 0.09974179f, 0.15951724f, -0.01966587f, 0.05230453f, 
    -0.77350795f, 0.54277182f, 0.31137645f, -0.85900050f, 0.40280920f, 0.36190584f, 0.03300994f, -0.27226597f, 
    -0.51302516f, -0.83583039f, 0.20274322f, 0.69903183f, 0.72675586f, 0.19921923f, 0.27097028f, -0.46299532f, 
    -0.30625051f, -1.10546911f, -1.01026213f, -0.96239513f, 0.06747574f, 0.23907351f, -0.35927871f, -0.35317492f, 
    -0.41837645f, -0.25910714f, 0.57971305f, -0.58265364f, -0.69818282f, 0.55921263f, -0.50182605f, 0.33762139f, 
    0.20096989f, 0.06987879f, 0.19641840f, 0.08925471f, 0.70979786f, 0.82183278f, 0.32573029f, -0.65074134f, 
    -0.57379907f, -0.26746505f, -0.24078943f, -0.72454262f, 0.71334815f, 0.63134831f, -0.90611774f, 0.30632031f, 
    0.14274417f, 0.12349758f, 0.14046085f, -0.24160017f, -0.39941415f, 0.39251605f, 0.62099403f, -0.06615809f, 
    -0.03248119f, 0.11648730f, 0.12304909f, -0.29088125f, 0.64120394f, 0.28113189f, 0.41906089f, 0.62256122f, 
    0.42699665f, -0.30812007f, -0.55657858f, 0.22751935f, -0.37297788f, -0.40844631f, 0.10755981f, -1.27311766f, 
    -0.49588165f, -0.17309862f, 0.67310685f, -0.37340981f, -1.13374650f, -0.59434408f, -0.69416642f, -0.55854338f, 
    -0.96429789f, -0.92191607f, -0.29850090f, -0.07690327f, -0.12698908f, -0.02688439f, 0.51500160f, 0.38195360f, 
    0.25135630f, -0.65317750f, -0.34035841f, -0.53082722f, 0.53385973f, -0.35636947f, 0.57341206f, 0.45099577f, 
    0.35341668f, 0.06162511f, -0.38509667f, 0.52211303f, 0.54763699f, -0.32766831f, 0.04289492f, 0.18280615f, 
    0.23840271f, -0.34241718f, 0.13622777f, -1.39820492f, 0.62405759f, 0.66854984f, 0.22112186f, 0.58569306f, 
    -0.00062341f, -0.66552109f, 0.07647771f, -0.01639318f, 1.26448703f, -0.89777422f, -0.82104993f, 0.30661073f, 
    0.08016750f, -0.77854007f, 0.08752229f, 0.65715116f, -0.16878924f, 0.30987102f, 0.48994386f, 0.36706200f, 
    -0.16597709f, -0.43408903f, 0.01766350f, 0.65348643f, -0.12325890f, -0.46342495f, 0.52520847f, 0.37084487f, 
    0.32648155f, 0.48717916f, -0.62534595f, 0.23867708f, -0.07982605f, -0.44861600f, 0.24808171f, -1.25465155f, 
    0.65237558f, 0.38360652f, -0.55704963f, -0.54239947f, 1.09787655f, -0.13784400f, 0.12340271f, 0.01803439f, 
    -1.06199610f, -0.84080946f, -0.57488078f, 0.50905728f, 0.85433704f, 0.33847821f, 0.28373817f, -0.03893157f, 
    0.23235942f, 0.28524342f, 0.75322336f, 0.75651884f, -0.93813163f, -0.62892151f, -0.17378187f, 0.39365610f, 
    -0.16829918f, 0.56657958f, 0.36436933f, 0.35822681f, -0.10273494f, -0.40877119f, 0.13338883f, 0.37976107f, 
    0.35180262f, 0.32406390f, -0.46976402f, -0.53434253f, 0.17212477f, -0.36108309f, -0.04970438f, -0.53488213f, 
    -0.18093500f, 0.32520595f, 0.46896973f, 0.57622367f, -0.28770807f, 0.55044299f, -0.05639470f, 0.60278213f, 
    -0.71127719f, 0.61681670f, 0.29042712f, -0.54844677f, -0.29010299f, -1.08532321f, 0.36874563f, -1.03668618f, 
    0.25009447f, 0.61194682f, -0.14373584f, 0.03091033f, 0.40722865f, 0.11630483f, 0.61855620f, 0.16568942f, 
    -0.22376367f, -0.41788927f, -0.61023170f, 0.45606586f, 0.03831603f, 0.31392643f, 0.32074955f, -0.46725950f, 
    0.11225795f, 0.46618158f, -0.88995689f, -0.48542109f, 0.41559324f, 0.25450209f, 0.33320472f, 0.35937768f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21742608f, 0.29009628f, 0.22931485f, 0.29694253f, -0.25660521f, 0.37648574f, 0.10140067f, 0.07220006f, 
    0.25033823f, -0.07410328f, 0.01208616f, 0.00696818f, 0.55008358f, 0.04808929f, 0.43927562f, -0.24030027f, 
    0.15044701f, 0.09064655f, 0.46466136f, 0.27357131f, 0.35795748f, -0.06251335f, -0.16017760f, 0.29565826f, 
    0.15801509f, 0.20949085f, 0.51665562f, -0.19422223f, 0.20207876f, 0.12628779f, 0.05751075f, 0.14506815f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09581217f, -0.42619532f, -0.64015090f, 0.20247157f, -0.04048041f, 0.01223837f, -0.01442344f, 0.05650565f, 
    -0.01357312f, 0.10506382f, 0.02490905f, 0.11196770f, -0.28569901f, -0.05706455f, -0.12593900f, -0.01744162f, 
    0.10244495f, -0.02854348f, -0.01938755f, 0.04450294f, 0.12957993f, 0.07720415f, 0.12016716f, -0.16782185f, 
    0.08728377f, -0.02782018f, 0.05719907f, 0.10157602f, -0.33423209f, -0.20588662f, -0.18509531f, -0.17788085f, 
    0.02828181f, -0.01440116f, 0.02399509f, -0.03312293f, 0.01403982f, 0.01576012f, 0.01005662f, -0.07840777f, 
    -0.01633966f, -0.13305789f, -0.70615119f, 0.10592259f, 0.05684764f, 0.05302388f, -0.03473973f, 0.02770256f, 
    -0.26552776f, -0.14708413f, -0.06179704f, -0.13879308f, -0.18382272f, 0.01371064f, -0.05436901f, 0.09884319f, 
    0.14634494f, -0.04792880f, 0.02451287f, -0.02951488f, -0.01466270f, -0.07556899f, -0.12652269f, 0.02170056f, 
    0.00507094f, -0.00811095f, -0.01800948f, 0.02856164f, 0.07287993f, 0.02467829f, -0.18546879f, -0.09765188f, 
    -0.05666987f, -0.03563845f, -0.00229339f, -0.03894489f, -0.07806972f, -0.05061792f, -0.07943576f, -0.06801717f, 
    0.40765271f, 0.40850541f, 0.11225966f, -0.40875304f, -0.15075584f, 0.18421632f, 0.22875294f, 0.16648917f, 
    0.05758035f, 0.08574975f, 0.00365876f, -0.05346788f, -0.03594159f, 0.02076455f, -0.01958202f, -0.01189294f, 
    -0.06197010f, -0.09757269f, 0.04096933f, -0.02789240f, 0.26820368f, 0.34234622f, 0.03074834f, -0.43957207f, 
    -0.19708596f, 0.05426917f, 0.06599939f, -0.08044529f, -0.04979366f, 0.01564675f, 0.11016695f, -0.07276349f, 
    0.01778897f, -0.04290400f, -0.01931722f, -0.04435827f, -0.07822762f, -0.02770600f, 0.12726778f, -0.14792788f, 
    0.15232880f, 0.27440757f, -0.40893158f, -0.26918703f, -0.59183955f, 0.02982579f, -0.00766095f, -0.02767275f, 
    -0.04780664f, 0.19116406f, -0.04011621f, -0.06885941f, 0.04137403f, 0.00378106f, -0.01610233f, -0.06459763f, 
    -0.02680749f, 0.02095723f, -0.07356714f, 0.00754283f, 0.04693058f, -0.01289343f, 0.36708039f, -0.49358758f, 
    0.07374901f, 0.00012835f, 0.02942483f, 0.06991088f, -0.10330690f, 0.04474787f, 0.09471016f, 0.09152541f, 
    0.01920133f, -0.11987650f, -0.12108508f, -0.03512789f, -0.10576283f, -0.01746656f, -0.34932944f, -0.07403174f, 
    0.29475158f, -0.47210634f, -0.38650364f, 0.01505807f, -0.04841212f, 0.00609692f, 0.02996762f, 0.04469150f, 
    0.00709136f, 0.01361599f, -0.01256731f, 0.05665777f, -0.06532126f, 0.10443791f, 0.03525604f, 0.01535809f, 
    0.07964526f, 0.08447411f, 0.02576750f, 0.00490569f, 0.43697450f, 0.21248409f, -0.02539381f, -0.18285659f, 
    -0.05566611f, 0.26712364f, 0.17009591f, 0.33106431f, -0.10852360f, 0.06241005f, -0.04817057f, -0.01321481f, 
    -0.01818512f, 0.00321198f, 0.02860831f, 0.00649351f, -0.08733302f, -0.13168882f, -0.05040745f, -0.06761899f, 
    0.17860149f, 0.05250768f, -0.26752797f, -0.00288673f, 0.11716539f, 0.04215022f, 0.04724412f, 0.05809472f, 
    -0.07502044f, -0.08644835f, -0.21354401f, 0.04411018f, 0.10870236f, -0.04985126f, 0.04864949f, 0.01982401f, 
    -0.01036629f, 0.01073316f, 0.00431451f, -0.01866128f, -0.56835938f, 0.55155188f, -0.34843007f, 0.06556985f, 
    0.31447196f, -0.01723900f, -0.06945145f, -0.02474773f, 0.04148354f, 0.10373840f, 0.01019518f, -0.04878135f, 
    -0.02323148f, 0.03008250f, 0.00396039f, 0.02543340f, 0.12268040f, 0.19094065f, 0.10623839f, 0.23172218f, 
    -0.64192575f, -0.35554412f, -0.38529620f, 0.11126809f, -0.20545445f, -0.07770217f, -0.02610277f, -0.01188407f, 
    0.05442805f, 0.04478897f, -0.07283671f, -0.05756373f, -0.14163274f, -0.07700191f, -0.07254367f, -0.12667033f, 
    -0.08591083f, -0.00842471f, 0.01784581f, -0.00856202f, -0.05109717f, -0.01128711f, -0.01140670f, 0.01920483f, 
    0.05194685f, 0.00363921f, -0.03243402f, -0.01335434f, 0.07178608f, 0.04317417f, -0.03754180f, 0.03236168f, 
    -0.04995363f, -0.05276987f, 0.03113628f, -0.14760345f, -0.11261392f, -0.08432800f, 0.01788024f, -0.08407898f, 
    -0.73478013f, 0.05675681f, 0.18022542f, 0.05331653f, 0.10138453f, -0.00220994f, -0.08602386f, -0.04262484f, 
    0.04635800f, -0.04144174f, 0.06093377f, -0.03432352f, -0.00547323f, 0.06001728f, 0.00301173f, 0.07651505f, 
    0.07665212f, -0.22607891f, -0.00552563f, -0.10092436f, 0.60619485f, 0.35806683f, -0.08564072f, -0.37084270f, 
    -0.02568207f, 0.03614397f, 0.08737513f, 0.09020351f, 0.04949903f, 0.04317146f, -0.01054491f, -0.05468341f, 
    -0.00267076f, -0.15503192f, -0.00295740f, 0.01071065f, -0.21032794f, 0.13329077f, -0.13037746f, 0.12518710f, 
    0.32721719f, 0.33445728f, 0.02700212f, -0.17761974f, -0.04427149f, 0.09127262f, 0.12735841f, 0.15192987f, 
    -0.04109132f, -0.19804843f, 0.01698161f, -0.11365797f, -0.01697266f, -0.00971474f, 0.07360044f, -0.02690125f, 
    -0.04202294f, -0.05417259f, 0.03839829f, 0.00402544f, 0.18325441f, 0.06425025f, 0.03139924f, -0.08656938f, 
    0.09143320f, 0.09106483f, 0.12010983f, 0.07411636f, -0.05571234f, -0.21810623f, -0.05529256f, -0.01515291f, 
    0.01870430f, 0.00631103f, 0.06924701f, -0.00856302f, 0.03955945f, 0.00204139f, -0.00681579f, 0.00399175f, 
    -0.38291216f, -0.24231526f, 0.09803199f, 0.05500529f, 0.02834784f, 0.00474074f, -0.07744768f, -0.04954433f, 
    0.05892339f, -0.03348975f, 0.01237572f, -0.04252676f, -0.04073282f, 0.00297975f, -0.02048067f, -0.09263540f, 
    -0.08714443f, -0.04831007f, -0.08752870f, -0.00597415f, -0.17649350f, -0.03919579f, -0.02381456f, -0.17520434f, 
    0.03928817f, -0.05564487f, -0.07198921f, 0.04835433f, 0.12406287f, 0.02529689f, -0.11197130f, 0.06883933f, 
    -0.03380594f, -0.08940205f, 0.03414815f, -0.15554373f, -0.06861163f, 0.03246187f, 0.02847039f, 0.06168469f, 
    0.19234291f, 0.21792834f, -0.47553289f, 0.08830239f, 0.02370754f, 0.01345689f, -0.04337859f, -0.05060273f, 
    -0.08631939f, -0.01439838f, -0.06352387f, -0.03081300f, -0.01016307f, -0.05024869f, 0.00482887f, -0.04746178f, 
    0.00615299f, -0.07838199f, -0.00698956f, 0.20155090f, -0.17146438f, -0.01177199f, 0.00953763f, 0.02343006f, 
    0.03637090f, -0.00099744f, 0.02597998f, -0.07229540f, 0.06689860f, 0.00786698f, -0.00410755f, 0.02345021f, 
    0.03451058f, 0.04283153f, 0.03746771f, -0.06081190f, 0.12069374f, -0.02928753f, -0.09393454f, -0.03433166f, 
    -0.02084123f, -0.06576986f, 0.03507315f, -0.08395318f, 0.10386565f, 0.04729628f, 0.00253390f, 0.02125346f, 
    0.04550464f, -0.02177952f, 0.00959762f, 0.05675609f, 0.05115356f, 0.05473667f, 0.03673116f, -0.05212949f, 
    -0.04494545f, -0.24367605f, 0.03076427f, -0.05082459f, -0.65279460f, -0.06035444f, 0.42898744f, -0.00917396f, 
    0.04432120f, -0.31764504f, -0.13402158f, 0.12475536f, 0.07822202f, -0.42294231f, -0.01963401f, -0.13306437f, 
    -0.06776442f, -0.12844378f, -0.02195469f, -0.12118992f, -0.16123524f, -0.05796006f, -0.22253366f, -0.09205483f, 
    0.19799252f, 0.07366441f, -0.21037330f, 0.00468792f, 0.06707532f, 0.12295928f, 0.09638204f, 0.11076605f, 
    0.05957477f, -0.13168749f, -0.05054785f, -0.03454757f, -0.13928312f, 0.03569918f, 0.05988852f, 0.01851564f, 
    0.04932594f, 0.06762880f, 0.00087452f, -0.02279975f, -0.14436761f, -0.03934750f, 0.21030846f, -0.20117672f, 
    -0.07924851f, -0.19023773f, -0.07297841f, -0.08158152f, -0.01309567f, 0.00550016f, 0.03047878f, 0.02388863f, 
    -0.03798036f, 0.00447045f, -0.03919851f, -0.02604651f, 0.01252000f, -0.03655815f, -0.09618205f, -0.16233113f, 
    -0.19536528f, -0.10300072f, -0.03461493f, 0.06237506f, -0.10078391f, -0.05804966f, -0.03458405f, -0.11422940f, 
    0.00054768f, 0.05727815f, -0.12134412f, 0.01151677f, -0.04450461f, -0.04948773f, -0.08345690f, -0.06336000f, 
    -0.23512298f, -0.10435034f, -0.01721275f, -0.04636301f, 0.30255869f, 0.25749522f, 0.07312732f, -0.05866558f, 
    -0.01856865f, 0.06162753f, 0.03010721f, 0.09994502f, 0.05569306f, 0.04052793f, 0.13130796f, 0.05346785f, 
    0.05749986f, 0.02114306f, 0.06305992f, -0.02743781f, -0.01857832f, -0.01876194f, -0.01940114f, 0.01418669f, 
    -0.45721763f, -0.11638947f, 0.33334497f, -0.29667342f, -0.18517792f, -0.07470253f, -0.04925532f, -0.03137087f, 
    0.04884490f, 0.00480900f, -0.08295425f, 0.13538557f, -0.11792440f, -0.01330460f, 0.01867376f, -0.04189426f, 
    -0.05128376f, 0.01001250f, -0.08352426f, 0.10828443f, 0.25586879f, 0.09688792f, -0.28023946f, 0.02408446f, 
    0.06664641f, 0.07996757f, 0.10230754f, 0.08011687f, -0.13044195f, -0.16684423f, -0.11817175f, -0.05955804f, 
    -0.02245327f, -0.00703593f, 0.02700342f, -0.00141978f, 0.07673477f, -0.04403310f, -0.03370162f, -0.01521522f, 
    0.02317517f, -0.01681208f, -0.04309206f, -0.01087435f, -0.00368649f, -0.10880730f, -0.08479259f, -0.05028912f, 
    0.09099925f, -0.07946565f, -0.08211306f, 0.08941884f, -0.09305197f, 0.12711044f, -0.03617710f, -0.14313696f, 
    -0.07650349f, 0.00973127f, -0.01974603f, -0.18434118f, 0.03588795f, 0.11109372f, 0.29034716f, -0.01314350f, 
    0.02512201f, -0.22076081f, 0.03194626f, 0.08171943f, 0.04833857f, -0.08687675f, 0.07572127f, 0.05395420f, 
    -0.05852275f, -0.01445356f, -0.02026870f, 0.05626408f, -0.03506789f, -0.01760301f, -0.09594321f, -0.09797835f, 
    1.12761307f, 0.02982947f, 0.04878723f, 0.10887526f, -0.04699976f, -0.01208670f, 0.04106458f, 0.02490980f, 
    -0.04898344f, 0.04560602f, 0.05497773f, -0.09954887f, -0.04599541f, -0.18113425f, 0.00118544f, 0.08353897f, 
    -0.05792560f, -0.32236990f, 0.06946231f, 0.01235730f, -0.63933200f, 0.07967081f, -0.14018390f, 0.04152489f, 
    -0.10886608f, -0.14902335f, 0.13509098f, 0.20171954f, -0.09032316f, -0.15688357f, -0.02098189f, -0.14037767f, 
    0.06104926f, 0.01341102f, -0.07781864f, -0.00235180f, 0.12413365f, 0.04078537f, -0.03028273f, 0.03770778f, 
    1.16334534f, 0.15610281f, -0.21389198f, 0.13310108f, -0.28944814f, -0.09660576f, 0.05168989f, 0.01594646f, 
    -0.27893355f, 0.10514040f, 0.17237517f, -0.19692364f, -0.00809857f, -0.06798638f, -0.04768510f, -0.01421167f, 
    0.00963337f, -0.10173086f, -0.08430007f, 0.01943824f, -0.00364481f, -0.09211476f, -0.00136794f, -0.00586604f, 
    0.02208615f, -0.01041915f, -0.05015367f, -0.00687474f, -0.00955277f, -0.01377628f, 0.15991572f, 0.15661244f, 
    -0.02134611f, 0.04749688f, 0.02759735f, -0.17500575f, 0.03812437f, 0.03220664f, 0.07888601f, 0.01548532f, 
    -0.10175844f, 0.23255567f, -0.06833444f, 0.39478388f, 0.10808965f, -0.31015223f, -0.11545208f, -0.22146636f, 
    -0.21723983f, -0.19689527f, 0.01371378f, 0.00343037f, 0.00689058f, 0.00240459f, 0.04621208f, 0.00555627f, 
    0.03449169f, 0.07035508f, -0.28117201f, 0.10534997f, -0.42614052f, 0.12320314f, -0.32662654f, 0.12326518f, 
    0.01466579f, -0.00162711f, -0.08730027f, -0.14336924f, 0.15279759f, -0.16869168f, -0.04944272f, 0.06390367f, 
    0.04900774f, 0.01787738f, 0.03744603f, -0.01815169f, 0.01727712f, 0.02744091f, -0.17999144f, -0.03573193f, 
    -0.41863185f, -0.40496498f, -0.17199104f, -0.05669230f, -1.04404986f, -0.02512426f, -0.27111539f, -0.46487930f, 
    -0.00996501f, 0.01632217f, -0.02563806f, -0.02464513f, -0.05709136f, 0.17264113f, 0.10245837f, -0.00973762f, 
    0.00156473f, -0.10194102f, 0.00752756f, -0.00225196f, -0.42066902f, 0.16620128f, -0.12541494f, -0.34476429f, 
    0.08055063f, -0.23520844f, -0.07679639f, -0.04764023f, 0.32776922f, 0.05946227f, 0.11740230f, 0.00555469f, 
    -0.05883221f, 0.15899393f, -0.22327125f, -0.07095103f, 0.07049776f, -0.00829427f, 0.04471917f, -0.03382688f, 
    0.10920375f, -0.28964078f, 0.07783568f, 0.07766228f, 0.01801963f, 0.01142400f, 0.02127618f, 0.00898327f, 
    0.00504931f, -0.02357703f, 0.10518952f, -0.08422854f, 0.08184429f, -0.14957900f, -0.05106739f, 0.05515538f, 
    -0.08426727f, -0.07914551f, 0.03132770f, -0.05724606f, 0.19669439f, 0.20998611f, 0.39395946f, 0.09917694f, 
    -0.07322124f, 0.02447516f, -0.08641772f, -0.09240072f, 0.01341645f, -0.24297738f, 0.03878920f, -0.03959665f, 
    -0.00181536f, -0.06587115f, 0.05307809f, 0.09979349f, 0.06632511f, -0.09356523f, -0.03634212f, -0.03020380f, 
    0.30188641f, -0.04538217f, -0.21205801f, -0.15801232f, -0.14487986f, -0.13467520f, 0.02954890f, 0.00425510f, 
    -0.00551178f, 0.04983841f, 0.12543593f, 0.17436685f, -0.08924654f, -0.03898679f, -0.02256802f, -0.04677449f, 
    0.02522224f, -0.02492326f, -0.09674805f, 0.05247201f, 0.40037751f, 0.01769352f, -0.19482875f, 0.08368140f, 
    -0.06413085f, 0.02936056f, -0.04482995f, -0.09416187f, -0.03427285f, -0.10345694f, -0.01540140f, -0.04524972f, 
    0.02580502f, 0.00773587f, 0.09279998f, -0.18651910f, -0.17330064f, -0.13952769f, -0.06933617f, -0.22470060f, 
    0.24388939f, 0.07062826f, 0.14028153f, 0.16519347f, -0.03725475f, -0.01892151f, -0.04067654f, 0.02394195f, 
    -0.02467103f, -0.04619030f, -0.08339570f, -0.00629541f, -0.02681277f, 0.06877128f, -0.06872424f, 0.07347681f, 
    -0.28644753f, 0.05270417f, 0.11322345f, -0.01204474f, 0.04255651f, 0.07625326f, 0.02262302f, -0.01745643f, 
    0.07430810f, 0.01031663f, -0.09658566f, 0.01180662f, -0.07121836f, -0.07158060f, -0.01525207f, 0.03768723f, 
    0.04047411f, 0.02543940f, -0.02844938f, -0.15086514f, 0.11325163f, -0.15533672f, -0.01622901f, 0.00903282f, 
    0.29782903f, 0.01830084f, 0.00840917f, -0.10760529f, 0.03470147f, 0.00249615f, -0.03855002f, 0.00644376f, 
    -0.04885081f, -0.07667770f, -0.03930075f, 0.02938597f, 0.00317655f, 0.01967550f, 0.00547409f, 0.03139381f, 
    -0.02589056f, -0.05639492f, 0.09943758f, 0.15121524f, 0.16217327f, 0.25294670f, 0.16683435f, 0.20746630f, 
    0.00085327f, 0.33325949f, -0.24390979f, -0.05824747f, 0.14443836f, -0.02260980f, 0.10279354f, 0.00466343f, 
    0.03988619f, -0.07824604f, -0.04908737f, -0.29755375f, -0.13457014f, -0.39815971f, -0.20150748f, -0.01900513f, 
    -0.31137881f, -0.00577036f, -0.12672634f, 0.13472579f, 0.09079666f, 0.05530943f, 0.24984509f, 0.17439801f, 
    -0.01174116f, 0.00437086f, -0.02844474f, 0.00513766f, -0.04200448f, 0.01427325f, 0.01805858f, 0.02694364f, 
    0.02193984f, 0.04724787f, -0.03140787f, 0.00283794f, -0.12219403f, -0.09359682f, -0.25950056f, -0.12460923f, 
    -0.14128409f, -0.07031085f, 0.04910642f, 0.03219998f, 0.04976145f, 0.01782074f, -0.18229425f, 0.12887487f, 
    -0.15643491f, 0.08083708f, -0.05673706f, -0.03014238f, 0.00489249f, 0.03294105f, -0.05808567f, 0.01906859f, 
    0.08664770f, -0.03832429f, 0.01377630f, -0.01191444f, 0.22411941f, -0.03990445f, 0.00369046f, 0.08199966f, 
    -0.00943949f, 0.03622119f, 0.01267407f, -0.03685652f, 0.01680378f, -0.00695493f, 0.01046476f, 0.15901032f, 
    0.06814525f, 0.03978864f, 0.01487920f, 0.00029693f, -0.15598279f, -0.44131687f, 0.11437592f, 0.12500077f, 
    0.34219569f, -0.01024584f, 0.04571048f, -0.00246745f, -0.02548588f, 0.00767270f, 0.06352708f, 0.03909666f, 
    -0.07406690f, -0.02853274f, 0.24957894f, 0.15981528f, -0.01796869f, 0.00797864f, -0.00570218f, -0.08424705f, 
    0.40557134f, 0.09712113f, -0.47124353f, 0.02505662f, -0.21097235f, -0.03934105f, 0.02686581f, -0.10229121f, 
    -0.10878385f, -0.04298866f, 0.10998192f, 0.15773922f, -0.04912055f, 0.05583206f, 0.13435780f, -0.05948512f, 
    0.00588162f, 0.07082731f, 0.15472880f, 0.19863556f, 0.22068074f, 0.08039656f, 0.11586614f, -0.05365703f, 
    0.05304152f, -0.01856507f, -0.06285070f, 0.00788549f, -0.00057003f, -0.02631185f, 0.02803057f, -0.05683519f, 
    -0.00631979f, -0.02712882f, -0.01937334f, 0.15909475f, -0.04312914f, -0.01924771f, 0.06021963f, -0.20678413f, 
    0.20507257f, 0.11080914f, 0.00838521f, -0.03422924f, 0.17113055f, -0.03782003f, -0.05470865f, -0.06556451f, 
    -0.05316130f, -0.02369249f, -0.06903999f, 0.05271067f, -0.03139530f, 0.00998545f, 0.00223245f, 0.07267254f, 
    0.12916423f, 0.08819754f, 0.04024925f, 0.01822715f, -0.96242929f, -0.57000989f, 0.17762130f, -0.13984895f, 
    -0.00514224f, 0.17557423f, 0.04280398f, 0.23940139f, 0.11345784f, -0.14992529f, 0.01668300f, 0.12387467f, 
    0.04052337f, -0.04088758f, -0.11696774f, -0.04499820f, 0.05267451f, 0.03360931f, 0.06498055f, 0.00173829f, 
    0.04852378f, -0.38720909f, -0.10326150f, -0.03746184f, -0.09570336f, -0.04732113f, -0.02029827f, 0.13159584f, 
    -0.02876659f, -0.17488451f, 0.02322392f, -0.09368232f, 0.04313230f, -0.11015306f, -0.04084318f, -0.01387570f, 
    -0.05620230f, -0.02024332f, -0.03752629f, -0.00490809f, 0.10866973f, 0.01837661f, -0.01695240f, -0.19592698f, 
    -0.02083729f, -0.01129933f, -0.00869165f, -0.08840889f, -0.02831543f, 0.00072930f, -0.03210596f, -0.04612811f, 
    0.02395200f, 0.07822521f, -0.04108552f, 0.01116001f, 0.00357795f, -0.02180533f, 0.01864392f, 0.12009507f, 
    0.05862647f, -0.00105402f, 0.11450354f, 0.05538341f, 0.04392636f, 0.00872457f, 0.04876331f, 0.07592815f, 
    -0.02926197f, -0.04230789f, 0.06517417f, -0.10412675f, 0.03905411f, 0.07835081f, -0.05366045f, -0.04576079f, 
    0.18060580f, 0.07132558f, 0.01411560f, -0.01033869f, -0.22024660f, -0.10887020f, -0.05015191f, 0.04342141f, 
    0.00139470f, 0.06812529f, 0.19098979f, 0.03075717f, 0.15657991f, -0.07604787f, -0.28552327f, 0.13405731f, 
    -0.02033803f, 0.02443553f, -0.06277388f, -0.05742666f, 0.01174201f, -0.07768546f, -0.02122708f, 0.01838253f, 
    -0.37011823f, 0.20080516f, -0.06138033f, 0.06164851f, 0.22978520f, -0.01314991f, -0.04203504f, 0.06460211f, 
    0.03969051f, -0.03732694f, 0.00209440f, 0.03058242f, 0.02096032f, -0.19967072f, 0.19197354f, 0.14539859f, 
    -0.07320651f, -0.02325163f, 0.04485442f, -0.27254760f, -0.13035344f, -0.46902701f, -0.13872881f, -0.01316003f, 
    -0.10610967f, -0.04007578f, 0.05128284f, 0.02403408f, 0.04484864f, -0.17132285f, -0.01784234f, -0.01944004f, 
    -0.14253519f, -0.00901858f, -0.02235965f, 0.01831281f, 0.05356070f, -0.09773988f, 0.09948518f, 0.00383373f, 
    -0.08467826f, -0.07332610f, 0.14534581f, -0.08948937f, -0.03615707f, 0.01462452f, 0.04394925f, 0.05282270f, 
    -0.05371534f, -0.00712752f, 0.06536416f, -0.02423866f, 0.01127595f, 0.17205559f, -0.06357124f, -0.04987785f, 
    -0.04803933f, -0.07453800f, 0.03201772f, -0.01831458f, -0.15566620f, -0.10059945f, 0.02674583f, -0.12574179f, 
    0.03402938f, 0.01047072f, 0.10565937f, 0.14197811f, 0.13780946f, 0.22211289f, 0.10589611f, 0.13171838f, 
    0.02255585f, 0.08586943f, 0.02473668f, 0.00699584f, -0.02542503f, 0.02658650f, 0.14461505f, 0.07717749f, 
    -0.20066342f, 0.10418646f, 0.44595793f, -0.06729434f, 0.08293387f, -0.05036037f, -0.13607007f, -0.02371075f, 
    -0.02370638f, 0.15191495f, 0.09586827f, -0.07015277f, -0.25332856f, 0.05827393f, 0.10082453f, 0.07172664f, 
    0.01161626f, 0.15581940f, 0.14667089f, -0.09163661f, 0.38811579f, 0.15655778f, -0.04221396f, 0.22637346f, 
    0.09404291f, -0.05847188f, 0.03296624f, 0.07336771f, -0.04480845f, 0.00864185f, 0.05926691f, 0.06793964f, 
    0.05616390f, 0.05945180f, 0.05536119f, -0.05468841f, -0.06292165f, 0.06497220f, -0.00224714f, -0.03413992f, 
    -0.39284435f, 0.79551595f, 0.19161603f, 0.20755069f, 0.09192029f, -0.10462437f, 0.02398595f, -0.02346217f, 
    -0.16651237f, 0.16847830f, 0.00526560f, 0.14050445f, 0.19319355f, -0.16219464f, 0.07582471f, -0.03349103f, 
    -0.00017855f, -0.03553447f, 0.04427341f, -0.12817962f, -0.08126104f, 0.07109881f, -0.05175800f, 0.03321727f, 
    0.04008229f, 0.00821829f, 0.02522111f, 0.04455780f, 0.03533778f, -0.04478203f, -0.08776548f, -0.05560047f, 
    -0.05684423f, 0.05632611f, 0.07738459f, 0.04956768f, -0.12741329f, -0.03457766f, -0.03224375f, -0.05717142f, 
    -0.53674138f, -0.88385820f, -0.80356640f, -0.10446691f, -0.94259155f, -0.05759274f, -0.05472862f, 0.00566197f, 
    0.10959575f, -0.19471005f, -0.01935225f, 0.00766374f, 0.03466753f, -0.04371372f, -0.09606442f, -0.00344315f, 
    -0.04016187f, -0.03861409f, -0.17335366f, 0.10158266f, -0.10175928f, -0.44519618f, -0.55804139f, 0.04796321f, 
    -0.26133087f, 0.05374978f, 0.24819735f, 0.02790361f, 0.07589269f, 0.06130197f, 0.00713733f, 0.06320411f, 
    -0.04206388f, 0.03053886f, -0.03957124f, 0.02464315f, -0.01224594f, 0.06381438f, -0.08700822f, -0.03991004f, 
    -0.64969707f, -0.84644663f, 0.54240000f, -0.36187217f, -0.25160739f, 0.20786400f, 0.10775255f, -0.33476308f, 
    -0.04226706f, -0.21199669f, 0.00879931f, -0.02650307f, 0.06316741f, -0.00549453f, -0.05015248f, 0.08946483f, 
    -0.03661731f, -0.25102851f, -0.03115214f, 0.14147249f, -0.02698654f, 0.12829491f, -0.42368615f, 0.07488970f, 
    -0.01702275f, 0.10562783f, -0.10429052f, -0.21233027f, 0.12803926f, -0.03372926f, -0.05343306f, 0.06219739f, 
    0.08502543f, 0.03374854f, -0.08567786f, -0.07128540f, 0.01719874f, 0.08021498f, -0.06816146f, 0.02867286f, 
    -0.03111722f, -0.08489428f, 0.42207757f, 0.01775241f, 0.23447950f, -0.01138706f, -0.02569573f, 0.02210675f, 
    0.13084571f, -0.08582024f, 0.06479170f, 0.00446393f, 0.06917100f, -0.06049091f, 0.16207077f, 0.01767242f, 
    0.02301975f, 0.04784569f, -0.01757682f, 0.01103829f, -0.01562005f, -0.28741232f, 0.69768673f, 0.52208698f, 
    0.25574628f, -0.07981352f, 0.04579431f, 0.01364679f, 0.22124600f, 0.04585195f, -0.04549342f, -0.01280151f, 
    -0.01880398f, -0.04700014f, -0.02051263f, -0.08934527f, 0.00073405f, -0.10716384f, -0.02114555f, 0.00860984f, 
    -0.10046650f, 0.27252212f, -0.00637340f, 0.09498660f, 0.01175082f, 0.00108606f, -0.07294646f, 0.02354683f, 
    0.04695366f, -0.41871259f, -0.02481110f, 0.04872771f, 0.03829945f, 0.00528550f, -0.00262423f, -0.05170234f, 
    -0.08038491f, 0.00660781f, -0.04315744f, -0.04376820f, -0.47536042f, 0.15224628f, 0.13243121f, -0.61559314f, 
    0.09469464f, 0.07745182f, -0.05649821f, -0.07274317f, 0.06888836f, 0.00025142f, 0.02492573f, 0.00434214f, 
    -0.00896483f, 0.01718201f, -0.01830824f, 0.07572499f, 0.08000855f, 0.10720999f, 0.08119842f, -0.00178333f, 
    -0.00111082f, 0.07447325f, 0.20348696f, -0.14292443f, 0.01560791f, 0.01622792f, -0.07140180f, -0.01103131f, 
    -0.01138566f, 0.06887661f, -0.03368968f, 0.05604381f, -0.10185298f, 0.04975159f, 0.02812092f, 0.08895831f, 
    -0.00269580f, 0.04807526f, 0.11227030f, -0.00469912f, -0.10287668f, -0.14989464f, -0.00062381f, -0.17149584f, 
    0.04885951f, -0.06151638f, -0.05701853f, -0.04559023f, 0.01975271f, 0.01607306f, -0.01946987f, -0.07974502f, 
    -0.15802196f, 0.04773536f, -0.00545512f, -0.05249562f, -0.27808714f, -0.06337827f, 0.03530265f, -0.01233329f, 
    -0.30608267f, -0.17722709f, 0.07838672f, -0.16929096f, 0.12681687f, -0.00184209f, 0.06090127f, 0.00754069f, 
    0.00403350f, 0.02629937f, 0.01408326f, -0.02638243f, 0.01232254f, 0.00768292f, 0.03399986f, -0.06468567f, 
    0.06412008f, 0.07686490f, -0.00391952f, -0.15717034f, -0.39633745f, -0.43276125f, 0.31047264f, 0.79363930f, 
    -0.06730921f, -0.02287106f, 0.01453099f, -0.24339220f, 0.13281222f, -0.27503911f, -0.04399846f, -0.01825179f, 
    -0.00987395f, -0.11802161f, 0.04320532f, -0.04436736f, 0.12742248f, 0.23263046f, -0.00186010f, 0.18396232f, 
    0.02173618f, 0.05934283f, 0.16966538f, 0.17884228f, 0.22420439f, -0.08142584f, -0.05134880f, -0.12734360f, 
    0.24208379f, 0.00275829f, -0.00730505f, 0.03047714f, 0.02099768f, 0.04504166f, 0.00120514f, -0.00061963f, 
    0.01074184f, -0.00826750f, -0.05663534f, -0.02907078f, -0.05289834f, 0.17154332f, 0.11641167f, 0.12074470f, 
    0.16131744f, -0.00074184f, -0.07015674f, 0.07955726f, 0.09666678f, -0.22263141f, -0.07578327f, -0.04192727f, 
    -0.19931377f, 0.04617229f, 0.01464106f, -0.01391635f, -0.07753685f, 0.00848198f, 0.00008712f, -0.02730617f, 
    0.13672416f, 0.08024226f, 0.05224850f, -0.10158636f, 0.04529021f, 0.09231206f, -0.06395292f, -0.03732999f, 
    -0.01480354f, 0.07164321f, -0.04556595f, 0.04508899f, 0.02530560f, 0.04031926f, -0.00398494f, 0.04107759f, 
    0.02625632f, 0.03968222f, -0.01179019f, -0.00690325f, 0.33316687f, 0.09064651f, -0.19823055f, 0.01356305f, 
    0.18726581f, 0.04217545f, 0.02650482f, -0.07673682f, 0.05140458f, -0.00444227f, -0.18719524f, 0.07924333f, 
    0.12825875f, -0.03556125f, -0.03295435f, 0.07233784f, 0.18455718f, 0.02112565f, 0.07310877f, 0.05108793f, 
    -0.38387373f, 0.26232782f, -0.20974131f, -0.09168682f, -0.31628650f, 0.01310820f, -0.13858485f, -0.22589637f, 
    0.13613485f, -0.30828670f, -0.00854376f, 0.08202480f, -0.02643763f, 0.00922869f, -0.08686175f, 0.05571282f, 
    0.03975575f, 0.01667508f, 0.23363054f, -0.13911282f, -0.22141473f, -0.22325784f, 0.04327536f, -0.35757220f, 
    -0.20746377f, -0.01477448f, -0.05287633f, 0.01123866f, 0.03863396f, 0.07965694f, 0.02295982f, 0.04235246f, 
    -0.03486587f, 0.10708702f, -0.13400233f, -0.10889364f, -0.12392643f, -0.08799580f, -0.02782470f, -0.00582982f, 
    -0.56778866f, -0.16566510f, -0.18657245f, -0.37388343f, -0.01254895f, -0.04203023f, -0.03844644f, -0.06178127f, 
    -0.02400105f, 0.00469003f, 0.03829025f, 0.04043205f, 0.05618318f, 0.03049851f, 0.05735386f, -0.28533715f, 
    -0.20648547f, -0.02263077f, 0.03900909f, -0.01041789f, 0.44881833f, 0.30769292f, -0.31564870f, 0.04223909f, 
    0.10922559f, -0.05754033f, 0.12179028f, -0.03402579f, -0.12856781f, 0.05789995f, -0.11499388f, -0.06351963f, 
    -0.13333112f, 0.05919816f, -0.00189922f, -0.03262457f, 0.03555443f, 0.09461128f, 0.00787977f, 0.21416052f, 
    0.00725072f, -0.07720855f, 0.46921977f, 0.11256158f, 0.28837994f, -0.06161107f, -0.01012069f, 0.07282296f, 
    0.15374672f, -0.11760907f, -0.00017645f, -0.00372994f, 0.09534272f, -0.12677389f, 0.14008766f, 0.05439478f, 
    -0.04536222f, -0.00039420f, 0.00629417f, -0.02795513f, -0.34503585f, -0.15555257f, 0.08437103f, -0.11013645f, 
    0.06947221f, -0.05675684f, -0.06819881f, -0.18127342f, -0.20091386f, 0.14504737f, -0.00850772f, -0.06681128f, 
    0.04128945f, 0.01699581f, -0.08746728f, 0.07378454f, -0.04754405f, -0.03091573f, -0.14597844f, -0.03354445f, 
    -0.01811521f, -0.04536476f, 0.06291719f, -0.06502062f, 0.11518152f, 0.01639622f, -0.02979804f, -0.02821231f, 
    -0.01989693f, 0.10108833f, 0.15841575f, 0.03013721f, -0.08811914f, 0.08573694f, -0.01679532f, 0.11816394f, 
    -0.04412949f, 0.09998818f, 0.03515672f, -0.04700503f, 0.03500147f, -0.04179732f, -0.15415850f, 0.09348101f, 
    -0.00561854f, 0.01377026f, -0.11877657f, -0.27703083f, -0.06248376f, -0.23870398f, 0.02484475f, 0.04478625f, 
    0.03285357f, -0.01635778f, -0.03086206f, -0.02866046f, -0.06363915f, -0.03057728f, -0.01892179f, -0.10402907f, 
    -0.07146139f, -0.20141920f, -0.46633479f, -0.27659845f, 0.02721704f, 0.01559968f, 0.02009783f, -0.02763502f, 
    -0.03209149f, 0.04617999f, -0.05411305f, 0.05950803f, -0.21390758f, 0.14431342f, -0.08981562f, 0.01755457f, 
    0.10637753f, -0.02821410f, 0.16184683f, -0.01315029f, 0.28845182f, -0.04779049f, 0.30217332f, 0.16240795f, 
    0.09331466f, 0.05483399f, -0.11450282f, 0.03217910f, 0.11118558f, -0.12483610f, 0.01105006f, -0.08264850f, 
    -0.00671285f, 0.00153485f, 0.09651180f, 0.04851906f, -0.03826145f, -0.06211727f, 0.08981702f, -0.09974504f, 
    -0.34693298f, 0.12783313f, 0.02283907f, 0.07945049f, 0.08178169f, -0.07906939f, 0.07894874f, -0.08468443f, 
    -0.14226547f, -0.04512147f, 0.01992308f, 0.02403288f, -0.13199121f, 0.10494144f, 0.06380127f, -0.06750452f, 
    -0.03842444f, -0.05955109f, -0.14659916f, -0.07787792f, -0.00631191f, -0.01288621f, -0.16154230f, 0.05103059f, 
    0.09749302f, -0.05547087f, -0.06585383f, -0.16852999f, -0.12162822f, -0.01398751f, -0.04384085f, -0.10748040f, 
    -0.09859597f, -0.01330924f, -0.06800034f, -0.01543226f, -0.04188619f, 0.01485187f, -0.17956881f, -0.04509433f, 
    -0.06301666f, 0.76991087f, -0.14376128f, 0.12472001f, -0.10642873f, 0.19159776f, 0.06453565f, 0.28295884f, 
    0.14104150f, -0.13239339f, -0.15140985f, -0.06433299f, 0.04896193f, 0.06018546f, -0.01851702f, -0.10871790f, 
    -0.10956532f, -0.05370283f, -0.07638800f, -0.02594952f, -0.49658427f, 0.29172516f, -0.33393931f, -0.27730900f, 
    0.22441101f, 0.10267407f, 0.00944661f, -0.11882801f, 0.07851671f, -0.27962267f, -0.07715359f, -0.04723507f, 
    -0.03047720f, -0.01929175f, 0.06910240f, -0.13345551f, 0.04470937f, 0.05609188f, -0.06146844f, -0.35526770f, 
    -0.59753978f, 0.45920050f, 0.33960086f, 0.23721290f, 0.63828689f, 0.08594431f, 0.00057228f, -0.19548805f, 
    -0.25497174f, -0.09169323f, -0.01787256f, -0.01837962f, -0.14536649f, 0.06250549f, 0.07002848f, 0.10932858f, 
    0.02387650f, 0.13560382f, -0.08241081f, -0.12277105f, -0.22094844f, -0.10043314f, -0.02977332f, 0.23778841f, 
    -0.14068231f, 0.06045773f, -0.14168727f, -0.00683177f, -0.11011531f, -0.00834833f, 0.05630456f, -0.05011076f, 
    0.02094620f, -0.12551107f, -0.07760393f, 0.02248172f, -0.12080931f, 0.14036509f, -0.05244373f, -0.16844976f, 
    0.10699641f, -0.18284251f, -0.40067235f, 0.06218756f, 0.28579915f, 0.06171857f, 0.11170617f, -0.01216497f, 
    0.12744111f, 0.17156282f, -0.04367334f, -0.05033534f, -0.04463489f, -0.10914911f, -0.06966551f, -0.08875062f, 
    -0.12650853f, 0.01141973f, -0.21174060f, 0.03194891f, -0.02378394f, -0.07581776f, -0.24861737f, -0.01216007f, 
    0.19887017f, 0.06267703f, -0.03500299f, -0.00562072f, 0.11814395f, 0.03173377f, 0.05716350f, -0.10497253f, 
    -0.09351490f, 0.01709939f, -0.00336570f, -0.05375127f, -0.18398993f, 0.13922149f, -0.37160310f, -0.01387171f, 
    -0.20986570f, 0.01795002f, 0.33239061f, 0.31267050f, 0.71204239f, -0.02535196f, 0.10944095f, -0.00192581f, 
    0.09230262f, -0.03662943f, 0.09376831f, 0.01173150f, -0.10255999f, -0.15697449f, 0.04352164f, -0.10876743f, 
    -0.08689156f, -0.06746531f, 0.08587445f, -0.04077694f, -0.46704325f, 0.03192399f, 0.22111271f, -0.38999292f, 
    -0.20279501f, 0.03962585f, 0.11043709f, -0.14614171f, 0.04458896f, -0.30977067f, -0.18087313f, 0.20544158f, 
    -0.23966907f, 0.12824702f, -0.11766112f, 0.14138028f, 0.09694701f, 0.10452877f, -0.29164475f, -0.21075687f, 
    -0.64204109f, 0.87437820f, 0.00178425f, -0.40082857f, 0.03942183f, 0.30814075f, 0.16614033f, 0.04757351f, 
    0.01316417f, 0.08736566f, -0.16659892f, -0.07265054f, 0.08023855f, 0.02344731f, 0.10159969f, -0.07799577f, 
    0.05623717f, -0.11584974f, 0.03279266f, -0.00319164f, -0.09677123f, 0.04563264f, -0.22807108f, 0.05810610f, 
    0.29811108f, -0.04374472f, -0.05377540f, -0.11935652f, -0.06174338f, 0.06745864f, 0.03037500f, 0.14868055f, 
    -0.02363660f, 0.12168189f, 0.05312668f, -0.05038650f, 0.03062650f, 0.08094887f, -0.04195301f, 0.02243202f, 
    -0.26566038f, 0.08066104f, 0.46079889f, -0.10852595f, 0.62205809f, 0.10202088f, 0.02811115f, -0.25692159f, 
    -0.17791714f, 0.03655092f, -0.14118163f, -0.06525662f, -0.04677170f, 0.14323863f, 0.00864951f, 0.06213885f, 
    0.04916991f, 0.26040897f, 0.04669848f, -0.11854091f, -0.26697016f, -0.07216793f, 0.60547429f, -0.13095291f, 
    0.39817494f, -0.39091933f, 0.13140029f, 0.23690271f, -0.04261642f, 0.08290029f, 0.19165482f, 0.05925319f, 
    -0.09424393f, -0.01954691f, 0.05146138f, 0.02418863f, -0.09768652f, 0.05403031f, -0.08347842f, 0.04083005f, 
    -0.09328102f, -0.08249792f, 0.03116930f, 0.42824724f, -0.26765582f, 0.12416158f, -0.07671969f, -0.15477152f, 
    0.00746418f, -0.10464913f, 0.01435584f, -0.04267929f, 0.04114125f, 0.00088126f, -0.11890776f, -0.04524972f, 
    0.01707539f, -0.08451350f, -0.09189605f, -0.06258588f, -0.18035436f, -0.49674159f, 0.02899234f, 0.04340265f, 
    -0.20833950f, -0.02801232f, -0.19275770f, -0.14690495f, -0.20415312f, -0.14358395f, 0.01799098f, -0.00643988f, 
    -0.12569419f, 0.11536746f, 0.07340445f, 0.09890071f, 0.11132111f, 0.19460559f, -0.44898215f, -0.27515650f, 
    -0.27772146f, -0.58602989f, 0.35494336f, -0.20844284f, 0.03411775f, -0.27496514f, -0.02666806f, -0.10877999f, 
    0.03352117f, -0.16373146f, 0.09153733f, 0.01673640f, 0.05017748f, -0.06567062f, -0.05061733f, 0.06258406f, 
    0.01836604f, 0.07192095f, -0.01552747f, -0.11629205f, 0.00204036f, 0.19018409f, -0.19801323f, -0.03886546f, 
    0.35843882f, 0.07076825f, 0.19165084f, -0.01144214f, -0.04799045f, 0.23684713f, -0.27321073f, 0.11822596f, 
    -0.13370599f, -0.12714696f, 0.10815228f, -0.11226825f, -0.11151970f, 0.18525723f, 0.17036924f, 0.03785536f, 
    0.02752930f, -0.10703665f, -0.17381606f, -0.09199569f, 0.36128631f, 0.07446339f, -0.01776718f, -0.04200218f, 
    0.04230171f, -0.02851630f, -0.04367848f, 0.12533017f, 0.08368579f, 0.07250097f, 0.00439867f, 0.08606165f, 
    -0.00953312f, 0.13986233f, 0.05403508f, 0.12125442f, -0.01432011f, -0.24361715f, -0.12504959f, -0.12460055f, 
    0.34706253f, 0.20850483f, -0.06531122f, 0.02189768f, 0.00975916f, -0.12325864f, -0.04767369f, -0.03334032f, 
    -0.05055336f, 0.06127242f, -0.03360004f, 0.06598243f, 0.03494497f, 0.21964253f, 0.02090047f, 0.00849440f, 
    0.22125071f, -0.13506269f, 0.48671767f, -0.39767289f, -0.16405129f, -0.16507755f, -0.02061203f, -0.16521737f, 
    -0.20847695f, -0.34887004f, 0.02550367f, -0.04530225f, 0.15317363f, -0.13425352f, -0.17490128f, -0.03208078f, 
    -0.17456976f, -0.14440940f, 0.08613330f, -0.05070735f, 0.94896811f, 1.16959119f, -0.06664265f, -0.43533418f, 
    -0.37665462f, 0.15496601f, 0.13201213f, -0.11035594f, -0.16138120f, 0.09293459f, -0.35019115f, -0.14204523f, 
    0.11405011f, 0.07085351f, 0.19792472f, -0.21660012f, 0.02769533f, -0.14210029f, 0.00826046f, -0.03771571f, 
    -0.51425034f, 0.00531124f, -0.22379290f, 0.26561069f, 0.31601411f, -0.03963694f, -0.04176526f, 0.06579384f, 
    -0.08314074f, 0.13699174f, 0.01273124f, 0.05906261f, 0.23678090f, -0.01748862f, -0.17471988f, 0.10894314f, 
    0.02506535f, 0.11378801f, -0.03694244f, -0.08882497f, -0.10173693f, -0.28821257f, 0.00947128f, -0.07603046f, 
    0.01463942f, -0.22320132f, 0.00899247f, -0.13116544f, 0.15176004f, -0.08722870f, 0.07887685f, -0.07577599f, 
    -0.15131600f, 0.18131416f, 0.13666381f, -0.13467699f, -0.06017948f, -0.00613284f, -0.11884982f, 0.01205677f, 
    -0.57466269f, -0.68551737f, -0.29179671f, -0.38091919f, -0.31898999f, -0.17018853f, 0.13754106f, -0.07329753f, 
    0.13001366f, 0.13921076f, 0.12324006f, 0.14016050f, 0.25907719f, 0.03653780f, 0.10829139f, 0.04243416f, 
    0.20351955f, 0.25045693f, -0.45288923f, -0.17870222f, 0.82106036f, 0.67363054f, -0.35105601f, -0.43553814f, 
    -0.16412903f, 0.04863982f, -0.18214014f, 0.12310675f, -0.06145209f, -0.37211156f, -0.06211929f, -0.03246189f, 
    -0.15854411f, -0.05794127f, -0.05005043f, 0.03106272f, -0.02859646f, 0.06686675f, -0.05497562f, -0.08586736f, 
    -0.22283116f, 0.38469911f, 0.04381607f, -0.22737205f, 0.29025033f, 0.33028784f, -0.04349086f, -0.05498441f, 
    -0.18516657f, -0.14169388f, -0.16663654f, -0.01004771f, 0.14520536f, 0.03783629f, 0.00021412f, -0.13190199f, 
    -0.05604307f, -0.09718205f, 0.15862596f, 0.13759683f, 0.22902153f, -0.07894966f, 0.52915317f, -0.17333055f, 
    0.23189647f, -0.09631090f, 0.08893113f, -0.03781466f, 0.02756282f, -0.12033311f, 0.19925660f, -0.04174978f, 
    0.13941258f, -0.06996167f, 0.05680103f, -0.04220054f, 0.03832886f, 0.01574716f, 0.00523496f, -0.09517118f, 
    -0.35513860f, 0.08407280f, 0.03754973f, -0.11214158f, -0.42264146f, -0.00460204f, -0.27751848f, -0.16573803f, 
    -0.10635900f, -0.20491563f, -0.11417039f, 0.02607974f, -0.01435629f, -0.01706026f, -0.09222621f, -0.15115318f, 
    -0.08323700f, -0.18003166f, -0.09008774f, -0.00243511f, -0.10103089f, -0.17870428f, -0.28631434f, -0.18425578f, 
    0.24257444f, 0.15368004f, 0.15035462f, 0.13515136f, 0.09845445f, 0.09529892f, 0.22349246f, 0.04756629f, 
    -0.06067308f, 0.12365840f, 0.03034784f, 0.25515184f, -0.10489933f, 0.18277639f, 0.00616997f, -0.02987199f, 
    0.33674833f, -0.50583649f, 0.16885886f, -0.56010288f, -0.40199643f, -0.07611945f, 0.21105878f, 0.20592187f, 
    0.09935655f, -0.09351642f, 0.04538016f, 0.01900814f, 0.14790587f, -0.18342283f, -0.08646379f, -0.17692178f, 
    -0.04225828f, 0.28304616f, -0.16383044f, -0.24875700f, 0.27425960f, -0.09429033f, -0.23503424f, -0.00638942f, 
    0.27776703f, 0.17238855f, -0.01683836f, 0.08411700f, -0.25818187f, 0.02362803f, -0.13429677f, -0.08051311f, 
    -0.01427427f, 0.00203867f, -0.10349313f, 0.06764831f, 0.00185440f, 0.02819690f, 0.04169878f, 0.05920664f, 
    -0.30107668f, -0.13812824f, -0.09136464f, 0.22399773f, 0.07490085f, 0.04171442f, -0.00095977f, 0.22442858f, 
    -0.02803621f, -0.05523741f, 0.06724608f, 0.06785414f, -0.28762007f, -0.14663260f, 0.06362038f, 0.08870752f, 
    0.04894079f, 0.21876110f, 0.00282000f, -0.08946674f, 0.41292956f, 0.11789908f, -0.30818447f, -0.56529289f, 
    0.08986638f, -0.07817786f, 0.00680218f, -0.07261864f, -0.00530125f, -0.05353849f, 0.06150907f, -0.02528042f, 
    -0.06352779f, -0.00933824f, 0.14092225f, 0.09386867f, -0.04092299f, -0.18634325f, -0.06443138f, -0.09354281f, 
    -0.54103810f, -0.00796971f, 0.03712000f, -0.34498188f, -0.14632519f, 0.10559093f, 0.07260482f, -0.09802402f, 
    0.11734121f, 0.03885882f, 0.05840481f, -0.13383394f, -0.04654533f, 0.03913236f, 0.09236306f, 0.01305629f, 
    0.11614797f, -0.05095913f, -0.08400444f, -0.01938524f, 0.21327795f, -0.22584048f, 0.07062456f, -0.04868615f, 
    -0.02990337f, -0.25067937f, -0.18001838f, -0.01470071f, 0.12118513f, -0.02202158f, -0.03457116f, -0.05536847f, 
    -0.03748256f, -0.00053016f, 0.02981621f, -0.13923076f, -0.15078743f, -0.04338613f, -0.00356521f, -0.04413419f, 
    -0.21348649f, -0.62977916f, 0.10071381f, -0.08738382f, 0.07012367f, -0.14335836f, -0.00612047f, -0.04634924f, 
    -0.12036236f, -0.37742680f, -0.17362532f, -0.24982572f, -0.09796529f, 0.21403328f, -0.17042731f, -0.09752329f, 
    -0.00550481f, -0.09481817f, -0.10762930f, -0.13874508f, 0.08863717f, -0.01093567f, 0.01780893f, -0.02634665f, 
    0.01083953f, 0.05761892f, 0.03465792f, 0.02697523f, -0.03680250f, 0.00004219f, -0.03859234f, -0.11592756f, 
    0.13716939f, -0.10098385f, -0.05400075f, 0.09027262f, -0.01788575f, -0.08653557f, -0.08244186f, -0.05896570f, 
    0.06605240f, 0.22634928f, 0.37783271f, 0.22152051f, 0.23581436f, -0.18946511f, 0.07835404f, -0.10863727f, 
    0.01398307f, 0.40179053f, 0.02463170f, 0.00398441f, 0.02789025f, 0.05873728f, -0.01389743f, 0.04854150f, 
    0.00245263f, -0.13128595f, 0.10193182f, -0.09193706f, 0.04730707f, 0.22577740f, 0.36170250f, 0.17720747f, 
    0.25681341f, -0.13405478f, 0.04180926f, 0.08834299f, 0.07431524f, 0.14653249f, -0.11041967f, 0.02986637f, 
    -0.00287309f, -0.00465857f, 0.01724522f, -0.04244071f, -0.04174080f, -0.11427467f, -0.02584619f, -0.13732621f, 
    -0.17014495f, 0.21451825f, 0.21805368f, 0.20623554f, 0.30315593f, 0.21977860f, 0.14504796f, 0.09148160f, 
    0.03056822f, 0.26507321f, 0.04394164f, -0.08439530f, -0.00051146f, -0.12562610f, -0.11058704f, -0.06029104f, 
    -0.00647571f, -0.07844503f, 0.01903402f, -0.08081543f, -0.02984531f, -0.18467517f, -0.10018721f, -0.04109979f, 
    -0.21525396f, -0.01178783f, -0.09981024f, 0.00575786f, -0.15238558f, -0.18710585f, -0.08413912f, 0.15123388f, 
    -0.30746844f, -0.02417189f, 0.04743798f, 0.15138040f, -0.20097531f, -0.21211185f, 0.10828345f, 0.07010882f, 
    0.11223724f, -0.40521935f, 0.04224075f, -0.08397303f, -0.11108724f, -0.15745278f, -0.11504374f, -0.01834192f, 
    -0.05251028f, 0.14467946f, -0.07314350f, 0.02916262f, -0.03364294f, -0.18722527f, -0.25948581f, -0.00674319f, 
    0.01678728f, 0.01892053f, -0.04726052f, 0.07864310f, -0.12786202f, -0.13818964f, 0.11323725f, 0.15581192f, 
    0.19262160f, -0.19610085f, 0.12780812f, -0.09583916f, -0.11044636f, -0.04473151f, -0.03607767f, -0.00751647f, 
    0.03520148f, 0.07895079f, 0.04287478f, -0.03206829f, 0.05146071f, 0.01159708f, 0.11355620f, 0.12974237f, 
    0.13743402f, -0.12094198f, 0.17097592f, 0.18604998f, -0.02742926f, 0.02895899f, -0.06906383f, -0.03564243f, 
    -0.18198656f, -0.12777658f, 0.11050592f, -0.20318861f, -0.10316221f, 0.05330059f, 0.03098978f, 0.05117526f, 
    0.02051220f, -0.06805494f, -0.06566290f, -0.00042838f, 0.69410020f, -0.24246940f, -0.57396418f, 0.37912291f, 
    0.05502064f, 0.03995362f, 0.07672843f, 0.04836687f, 0.00983945f, 0.13461576f, -0.02437614f, 0.03901616f, 
    -0.01517999f, -0.01540639f, 0.00663663f, 0.26506534f, 0.15731245f, -0.00758042f, 0.06835355f, 0.15897992f, 
    -0.43478221f, 0.05116960f, -0.15702479f, -0.24558029f, -0.24667922f, 0.10369786f, -0.01725599f, -0.01612067f, 
    0.06051894f, 0.04481140f, 0.01150463f, -0.06503535f, 0.04992022f, 0.08152127f, -0.05710857f, -0.09079913f, 
    -0.05442333f, -0.04320547f, -0.07357707f, 0.13879728f, 0.07613362f, 0.08559634f, -0.05494616f, 0.03016673f, 
    0.08495882f, 0.13257754f, 0.15639664f, 0.10867832f, -0.03873264f, 0.00557193f, 0.09980505f, 0.12820932f, 
    0.08352359f, -0.12920476f, 0.07719347f, 0.07547164f, -0.10541276f, 0.08592660f, -0.03926375f, -0.01943379f, 
    0.07259451f, 0.12565492f, -0.23494907f, 0.21603510f, 0.20298612f, -0.05256617f, 0.03776913f, 0.03815928f, 
    0.08916852f, -0.02747124f, 0.04848755f, -0.04130031f, -0.02829297f, -0.03209727f, 0.04899019f, -0.04696748f, 
    0.16523844f, 0.24327230f, -0.10315313f, 0.04778182f, -0.21155895f, -0.38555014f, 0.17614694f, 0.04950610f, 
    0.04706668f, -0.15374421f, 0.04632372f, 0.11228109f, -0.22586438f, -0.12329710f, 0.03129696f, -0.04108733f, 
    0.05930390f, 0.09133675f, -0.08694403f, 0.13760409f, 0.25927347f, 0.12427106f, -0.05911212f, 0.18141085f, 
    0.13628042f, 0.08244205f, 0.04569741f, 0.23308079f, 0.02111431f, -0.04204915f, -0.10984973f, -0.16022268f, 
    -0.11595357f, -0.02999070f, -0.00413985f, 0.06600033f, 0.06089381f, 0.02171617f, -0.00856353f, 0.07785988f, 
    -0.06942365f, -0.03801760f, -0.06327230f, -0.08519553f, 0.15198809f, 0.07616150f, 0.10384160f, 0.20711036f, 
    0.07088598f, -0.05102035f, -0.07327398f, -0.04045865f, 0.04290141f, 0.02774321f, 0.17372547f, 0.04562710f, 
    -0.06537108f, 0.04576808f, 0.00386828f, 0.10581870f, 0.04221542f, -0.02204427f, -0.02396810f, -0.04905523f, 
    -0.08275653f, -0.05984457f, -0.24755138f, 0.08796445f, -0.12912303f, -0.01737239f, 0.08912744f, -0.05273415f, 
    -0.11136506f, -0.02520691f, 0.08766210f, -0.06126064f, 0.02038068f, 0.02932464f, 0.02668492f, 0.03225105f, 
    0.06245204f, 0.00714121f, -0.10500997f, 0.07358229f, 0.25576219f, -0.89156532f, -0.04470214f, -0.02199755f, 
    -0.28757250f, 0.14561129f, -0.02707394f, 0.10053536f, -0.07732900f, 0.09222762f, 0.22209693f, -0.06460229f, 
    -0.06190459f, -0.24969643f, -0.16269636f, -0.20734459f, -0.10614847f, 0.01957703f, -0.19855683f, -0.01769364f, 
    0.25020400f, -0.16963945f, 0.35088953f, -0.27222544f, -0.09910808f, 0.07148540f, -0.02413362f, 0.01802605f, 
    -0.08767521f, -0.13929555f, 0.00870921f, -0.06705379f, -0.01934240f, 0.05970760f, -0.01203388f, 0.06830686f, 
    -0.05414175f, -0.18321289f, -0.06328727f, -0.34175935f, -0.02672116f, -0.11713203f, 0.06302483f, 0.08789482f, 
    0.14437431f, 0.04017692f, 0.05081862f, 0.08567522f, 0.01533830f, 0.05102120f, 0.05057696f, 0.01589392f, 
    0.07941038f, -0.02076675f, 0.04166723f, -0.03907820f, -0.00150814f, -0.15669158f, -0.04286103f, 0.08022001f, 
    0.03573999f, 0.07747875f, 0.00502962f, 0.18641470f, 0.08331451f, 0.02926960f, 0.06798775f, 0.00806591f, 
    0.02614820f, 0.09749926f, 0.09015924f, 0.04349751f, -0.01823484f, -0.02629902f, 0.12518005f, -0.16129521f, 
    -0.02639510f, -0.05458925f, 0.01181402f, 0.05554696f, 0.08744822f, -0.55554897f, -0.00767331f, -0.08091358f, 
    -0.01537103f, -0.27271339f, -0.06791226f, -0.15949814f, -0.10497745f, -0.10914714f, 0.01497600f, -0.18596263f, 
    0.13487989f, 0.05600483f, -0.00976112f, -0.09739906f, -0.21554284f, -0.10099535f, -0.14159447f, -0.14039029f, 
    0.22469373f, -0.21591851f, 0.14381383f, 0.06814689f, 0.00407083f, -0.13984634f, -0.03898014f, -0.08388161f, 
    -0.05877568f, 0.06501040f, 0.05919716f, -0.04091863f, -0.07860106f, -0.00561479f, -0.00905181f, 0.04040442f, 
    0.00915571f, 0.05946717f, -0.00591084f, -0.04865803f, -0.17482805f, 0.00494457f, -0.04846679f, 0.33428401f, 
    0.21843624f, -0.08383399f, 0.10344895f, -0.17738892f, -0.05116019f, 0.07075953f, 0.09404256f, -0.01481500f, 
    -0.01701894f, -0.02945878f, 0.04126549f, -0.02634863f, -0.02470927f, -0.14637694f, 0.00116732f, -0.09400792f, 
    -0.07362359f, -0.15098086f, -0.12859654f, -0.24213493f, -0.01179976f, 0.03532518f, -0.11172508f, 0.08224534f, 
    -0.04594464f, -0.04787385f, 0.08654404f, -0.03768949f, 0.11561844f, -0.06042467f, 0.01622994f, 0.08332116f, 
    -0.02830206f, -0.06577229f, -0.17251801f, 0.08242542f, 0.10497372f, 0.14060530f, 0.09422641f, 0.03061818f, 
    0.01140757f, 0.08982113f, -0.03447905f, -0.07671737f, -0.10476150f, 0.08320331f, 0.15084873f, 0.16642343f, 
    0.03329988f, 0.00690942f, 0.05787707f, 0.03174048f, -0.09085584f, -0.07215303f, -0.05931880f, -0.09197697f, 
    0.64770788f, -0.03170745f, -0.22015761f, 0.00202526f, -0.46988901f, 0.03614661f, -0.02606497f, -0.03166461f, 
    0.10771312f, 0.00530856f, 0.02036442f, -0.07449003f, -0.07231859f, -0.09230884f, -0.12662372f, -0.07503834f, 
    0.05984800f, -0.12804970f, -0.09067491f, 0.20239335f, 0.10215102f, -0.11473718f, 0.11735331f, 0.18470499f, 
    0.01405206f, -0.07186680f, -0.16759059f, -0.10984047f, 0.05125500f, 0.02916902f, 0.14917660f, -0.07294241f, 
    0.08583787f, -0.02393072f, 0.14597446f, 0.09401800f, -0.04626102f, 0.09827113f, -0.17951247f, -0.05966411f, 
    0.05127910f, 0.00945389f, 0.02927148f, -0.02893287f, 0.16567284f, 0.13904175f, 0.02091603f, 0.09239684f, 
    -0.07320121f, 0.04276675f, 0.03943746f, 0.01912281f, 0.05720592f, -0.21878143f, 0.02544712f, -0.09285742f, 
    -0.14231218f, -0.01633578f, -0.12483767f, -0.03126113f, -0.10835102f, 0.05783604f, 0.03889085f, 0.14833677f, 
    0.01165123f, 0.10363279f, -0.02832103f, -0.11328205f, 0.02119061f, 0.12501201f, -0.01412448f, -0.20361078f, 
    0.06913328f, -0.03853149f, 0.02106988f, -0.03520431f, -0.06089321f, -0.02720097f, -0.24363811f, -0.21589585f, 
    -0.53503644f, -0.24236785f, -0.26185238f, -0.23091082f, 0.12953059f, -0.05146505f, -0.13709863f, -0.02320384f, 
    -0.09906694f, -0.13343725f, 0.02615116f, 0.01936504f, 0.14332899f, -0.10610431f, 0.00623128f, -0.17280924f, 
    -0.14613706f, 0.40460995f, -0.07338019f, -0.02234976f, 0.11453690f, -0.37360746f, 0.13036029f, -0.01105733f, 
    -0.16070813f, 0.38286167f, -0.08088395f, -0.15413338f, -0.01256408f, 0.23510510f, 0.08280984f, 0.20665659f, 
    -0.09032457f, 0.01103140f, 0.02877009f, 0.04510647f, -0.03717039f, 0.04140038f, 0.03757559f, 0.13222565f, 
    -0.27864003f, -0.34412381f, 0.11604612f, -0.44751576f, -0.03871835f, 0.08003398f, -0.05794806f, -0.14343186f, 
    0.15636700f, 0.09955947f, 0.02646390f, 0.26063591f, 0.09717193f, -0.21166769f, -0.04296036f, 0.04797760f, 
    -0.05839903f, 0.04232703f, 0.11735304f, 0.19990440f, 0.10715543f, -0.06693513f, -0.13040929f, -0.04273115f, 
    0.04864278f, 0.03950901f, -0.01243802f, 0.01555065f, -0.06395821f, 0.04688121f, 0.01914402f, -0.06368917f, 
    -0.07935226f, -0.01562662f, -0.12542625f, 0.10463449f, 0.15424253f, 0.03449610f, -0.10594145f, 0.13140427f, 
    0.00813420f, -0.10560057f, 0.37718523f, -0.00025691f, -0.18418035f, 0.36595342f, 0.11988695f, 0.24605154f, 
    -0.06112323f, -0.33842453f, 0.05225474f, 0.00577523f, 0.03349974f, 0.06700280f, 0.04875341f, 0.02080525f, 
    0.04211667f, -0.02329480f, 0.02543715f, 0.06373069f, 0.22966331f, -0.01445928f, 0.40059444f, -0.06000367f, 
    -0.15193942f, 0.06352308f, 0.10745002f, -0.04249256f, -0.14527203f, 0.01542211f, 0.09811155f, -0.00414352f, 
    0.01355247f, 0.00444777f, 0.01800479f, -0.03906347f, 0.01372200f, -0.10162732f, -0.05111174f, 0.24581014f, 
    0.63499016f, 0.38012239f, 0.09052446f, -0.22781155f, 0.10443316f, -0.18259484f, -0.14179415f, 0.14948113f, 
    -0.18423031f, -0.08879941f, -0.02993131f, 0.01520870f, -0.09856945f, -0.05717407f, -0.03314548f, 0.08592220f, 
    0.02717680f, 0.07266573f, -0.10051501f, 0.01515792f, 0.51633239f, 0.00169944f, 0.18230517f, 0.21953461f, 
    -0.01910750f, 0.12504201f, 0.13032757f, 0.08081707f, -0.31966141f, 0.11029740f, -0.01693491f, -0.15408282f, 
    0.20043999f, -0.14884701f, 0.16852209f, 0.01574855f, -0.00544645f, 0.16879030f, 0.17311403f, -0.00717844f, 
    -0.14633594f, 0.19011410f, -0.44886985f, -0.20536557f, -0.05268147f, 0.00565670f, -0.02195536f, 0.04226315f, 
    -0.05771957f, -0.14144444f, -0.06135293f, 0.07919426f, -0.24508168f, 0.17097147f, 0.20138608f, -0.08689141f, 
    -0.00285088f, 0.14520569f, -0.05681944f, -0.07429887f, -0.19635300f, 0.10571562f, 0.02575324f, -0.12121099f, 
    -0.09998111f, 0.17881677f, -0.05570025f, 0.08240531f, -0.01165821f, 0.11918589f, 0.00033033f, -0.02313254f, 
    -0.02804444f, -0.00389676f, -0.05720128f, -0.05016371f, 0.00461709f, 0.04779164f, -0.11488549f, -0.08398055f, 
    -0.22042547f, -0.14014417f, 0.10071461f, -0.12356728f, -0.05242633f, 0.00193842f, 0.08384819f, 0.03074562f, 
    0.04237800f, 0.08469883f, -0.04109098f, 0.01412449f, 0.02920767f, -0.05337609f, -0.07259969f, -0.00137529f, 
    0.01833599f, 0.02136778f, 0.07446233f, 0.07786705f, -0.69543177f, -0.10112818f, 0.13547081f, -0.20686796f, 
    0.00423500f, 0.02924525f, 0.00905301f, -0.12744072f, 0.05397475f, 0.04121310f, -0.01763953f, 0.09663279f, 
    0.00794077f, -0.00068038f, -0.07687073f, -0.10982046f, -0.10926681f, 0.06279419f, 0.00208489f, -0.11112316f, 
    0.56416237f, 0.03822545f, -0.36772606f, -0.31267709f, 0.25121787f, -0.01962953f, 0.05598967f, -0.10759992f, 
    -0.03188225f, -0.00358856f, 0.19719978f, -0.00079207f, -0.02108536f, -0.03781068f, 0.17578317f, 0.04423065f, 
    0.21357301f, -0.06535900f, -0.07354875f, -0.13204242f, 0.09126218f, -0.12087311f, -0.19709362f, 0.17198917f, 
    0.03275528f, -0.02210546f, 0.13001350f, 0.00227229f, -0.01974079f, 0.03602070f, 0.08453978f, -0.11677095f, 
    0.14256911f, 0.12903179f, 0.02840484f, 0.25773486f, -0.08694622f, 0.12875204f, -0.04711210f, 0.02328217f, 
    -0.01497491f, -0.04071313f, -0.19022691f, 0.18539953f, -0.05383258f, 0.07522484f, 0.05700859f, -0.03731349f, 
    -0.00904889f, 0.12795661f, 0.01607907f, 0.01582229f, -0.03822061f, -0.00875027f, 0.03322709f, -0.06461574f, 
    -0.23600464f, 0.18456987f, -0.04520107f, -0.01952076f, -0.50983775f, -0.03153735f, 0.28158113f, -0.19496946f, 
    -0.15884528f, -0.02413491f, -0.01467509f, 0.05818570f, 0.08216607f, -0.02039901f, -0.00303298f, 0.00294001f, 
    -0.03149203f, 0.06849856f, 0.03738928f, 0.05977048f, -0.05409803f, -0.39181590f, -0.13319519f, -0.23724164f, 
    -0.02372598f, -0.13365804f, 0.03897571f, -0.15783541f, -0.31504333f, 0.00529440f, -0.02012069f, 0.01939230f, 
    -0.06069022f, 0.01183523f, 0.06607898f, -0.05256845f, -0.03930392f, -0.09297883f, -0.03669987f, -0.02836572f, 
    0.07965597f, 0.04043471f, 0.00604329f, 0.08023719f, -0.18709596f, 0.06809092f, -0.10564014f, -0.04274568f, 
    -0.07483751f, 0.06850804f, 0.04551516f, -0.01531558f, -0.07248349f, 0.04115689f, 0.12381944f, -0.08120620f, 
    0.13445996f, -0.11646023f, -0.02480910f, -0.00838624f, 0.06361759f, -0.00329366f, 0.04557189f, 0.00103917f, 
    -0.32117450f, -0.10906653f, -0.08562364f, 0.15137437f, -0.01042363f, 0.25395709f, -0.12568884f, -0.11116324f, 
    -0.00442237f, 0.13150379f, -0.06103358f, -0.03199875f, -0.01972116f, 0.05389010f, 0.06496361f, 0.00629593f, 
    -0.06386635f, 0.05878661f, -0.01593763f, -0.02159117f, -0.44266540f, 0.29340908f, -0.04490253f, 0.25165841f, 
    -0.37110710f, -0.02986966f, -0.20141344f, -0.04665173f, 0.12980774f, -0.03554809f, -0.02218021f, -0.14758140f, 
    -0.05365634f, 0.02705213f, -0.24654387f, 0.02756415f, 0.03223477f, 0.04729559f, 0.11691160f, 0.07949681f, 
    -0.05966356f, -0.03634195f, 0.26506266f, -0.45456719f, 0.13304412f, 0.10230631f, 0.09577369f, 0.05796374f, 
    -0.11499836f, -0.09596042f, 0.10143650f, -0.07852080f, 0.03863626f, -0.03771878f, -0.13908555f, 0.03233336f, 
    -0.05593045f, -0.08303437f, 0.00063475f, -0.04164186f, -0.35012195f, 0.10962417f, -0.18972495f, -0.00884008f, 
    0.10372601f, 0.26229417f, -0.06242904f, -0.17942642f, -0.08276594f, 0.09367082f, -0.12394276f, 0.08119007f, 
    -0.00041819f, -0.01494358f, 0.00461101f, -0.00000562f, -0.06693035f, 0.24886543f, -0.00024532f, 0.06124898f, 
    -0.14635335f, -0.11503706f, 0.07262899f, 0.03662044f, 0.08453487f, 0.06092210f, 0.04176484f, -0.07015777f, 
    -0.04059729f, 0.05756205f, 0.01367772f, -0.15959798f, -0.07644567f, 0.06149669f, 0.01417489f, -0.03822955f, 
    -0.13936055f, 0.04702515f, -0.02735993f, -0.06205148f, -0.45655525f, 0.12618802f, -0.03572077f, 0.33738807f, 
    -0.13555777f, 0.12778971f, -0.03946493f, -0.26994622f, -0.00523966f, 0.48852101f, 0.06291657f, 0.02893236f, 
    -0.13475436f, -0.08176534f, 0.10555217f, 0.09879769f, 0.08582960f, 0.09989589f, 0.04286611f, 0.11763407f, 
    -0.50686145f, 0.18622641f, -0.54913497f, -0.14730377f, -0.13150461f, 0.06447682f, -0.03579097f, -0.09718280f, 
    0.04334794f, 0.12368432f, 0.06209745f, 0.05565612f, -0.09524709f, 0.05314444f, -0.09776244f, -0.07828206f, 
    -0.01287365f, 0.07231146f, -0.06582436f, 0.11752413f, -0.24274175f, -0.04339238f, -0.26476526f, 0.19813675f, 
    -0.11216513f, 0.07936500f, -0.20039684f, 0.08547214f, 0.06338407f, 0.09855877f, -0.08390321f, 0.01845851f, 
    -0.01223074f, 0.00373291f, 0.03702686f, -0.03504790f, 0.05627532f, 0.22843257f, -0.17637837f, -0.02687745f, 
    0.10986678f, 0.02479880f, -0.26355332f, 0.06111954f, 0.06051093f, 0.13778336f, -0.10632767f, -0.08641152f, 
    -0.02719327f, 0.06940371f, -0.03169608f, 0.10088550f, -0.09288832f, 0.06383219f, 0.06872443f, -0.00027630f, 
    -0.05486279f, 0.03314895f, 0.16767913f, -0.06121217f, -0.00507053f, 0.04019654f, 0.13039596f, -0.07901124f, 
    -0.11550361f, -0.10395648f, -0.11062577f, 0.03308764f, 0.07182933f, -0.04143924f, 0.03195790f, -0.25690040f, 
    -0.03397021f, -0.00919662f, 0.00302397f, 0.04165889f, 0.08863713f, 0.01417643f, 0.04298334f, 0.14607951f, 
    -0.03183775f, 0.05970578f, -0.18933396f, 0.01813761f, 0.06610977f, 0.02333559f, 0.04992046f, -0.20012960f, 
    -0.07587986f, 0.11651947f, 0.09690293f, -0.23481223f, 0.16603795f, 0.19921419f, -0.09829997f, 0.02740651f, 
    -0.05887609f, 0.10170663f, 0.07025352f, 0.04171918f, -0.64884740f, 0.52952743f, -0.07219445f, -0.26885742f, 
    -0.11220268f, -0.05239057f, -0.02146930f, 0.15871292f, 0.03416308f, 0.12675311f, 0.04784998f, 0.05343474f, 
    -0.01415984f, -0.01802623f, -0.05253392f, -0.01914620f, -0.04807356f, 0.11469459f, -0.04803492f, 0.04217117f, 
    0.21935846f, -0.10699390f, -0.06675293f, -0.00244201f, -0.05301983f, 0.03603826f, -0.16392401f, -0.14141384f, 
    -0.02308557f, 0.17183070f, -0.10856603f, -0.06891903f, 0.08951797f, -0.14031909f, 0.01928869f, 0.11565025f, 
    0.07140537f, 0.03689124f, -0.04446259f, 0.14821048f, 0.01305045f, -0.09243722f, 0.04749952f, 0.25460076f, 
    -0.15278661f, 0.06930678f, -0.16859761f, -0.06762004f, -0.05275014f, -0.05652039f, -0.02878483f, 0.02841827f, 
    -0.10267875f, -0.09373274f, 0.01737805f, -0.02467340f, 0.10480332f, 0.02920986f, -0.02798763f, 0.11362836f, 
    -0.20662615f, 0.16564356f, 0.13082583f, 0.02660344f, 0.26900545f, 0.01812019f, -0.03173070f, -0.01237240f, 
    -0.02553024f, -0.05248734f, 0.19548523f, 0.08268597f, 0.31039244f, 0.06044059f, 0.02133539f, 0.07866028f, 
    -0.03075423f, 0.02122707f, -0.03050673f, 0.03142169f, -0.21251281f, 0.43446368f, 0.13905931f, -0.00674670f, 
    0.19083224f, -0.07079889f, -0.05176026f, -0.00211783f, -0.02145950f, 0.20198137f, -0.17855000f, 0.12590699f, 
    -0.03136236f, 0.14194058f, -0.02454787f, 0.01606418f, 0.03359029f, -0.04228741f, 0.00530166f, 0.02315738f, 
    -0.25595203f, 0.81044030f, -0.12710774f, -0.08952482f, 0.33526054f, -0.04216100f, 0.01991321f, -0.03924597f, 
    0.23791237f, 0.18014558f, 0.12634601f, 0.02994622f, 0.16230841f, -0.08847757f, 0.01473383f, 0.08827092f, 
    -0.04250741f, 0.03952881f, 0.06328230f, -0.03644092f, 0.10666309f, 0.14113809f, -0.04040454f, -0.04451989f, 
    0.02319687f, -0.02666236f, -0.03935593f, -0.01526813f, -0.00376440f, -0.01461263f, -0.01470318f, -0.04507001f, 
    -0.10465953f, -0.00031377f, 0.02426664f, 0.03431161f, -0.07932712f, -0.06063301f, -0.08465586f, -0.09890992f, 
    -0.85054457f, -0.84065127f, -0.62550914f, -0.30252922f, 0.04756144f, -0.27007517f, -0.10253082f, -0.37089923f, 
    -0.13013431f, -0.25046930f, 0.01278950f, -0.02332421f, -0.01328189f, -0.01780681f, 0.00375916f, 0.00114026f, 
    -0.00734288f, 0.09831368f, 0.17552495f, 0.03095348f, -0.70620722f, -0.91252857f, -0.83026379f, -0.00137402f, 
    0.19955204f, -0.02895893f, -0.02705712f, -0.17529556f, 0.00785639f, -0.39566386f, -0.00705835f, -0.03592830f, 
    -0.01643463f, -0.04570823f, 0.00838402f, -0.02287469f, -0.01094926f, 0.07271870f, 0.22201675f, 0.05509280f, 
    0.47680694f, -0.72013265f, -1.31704092f, -0.28373393f, -0.05027554f, -0.02832814f, 0.13125624f, 0.23154621f, 
    0.21307266f, -0.60842288f, 0.05668622f, 0.03037571f, -0.04381306f, -0.10768735f, 0.07083303f, 0.06089959f, 
    -0.00222756f, 0.28270701f, 0.14526847f, -0.01768251f, -0.04471729f, 0.02914625f, 0.08132035f, 0.32736620f, 
    -0.14759073f, 0.10960094f, 0.17704915f, -0.03650548f, 0.05760013f, 0.24033578f, 0.02648716f, -0.06415883f, 
    0.16697954f, -0.13769311f, 0.14094612f, -0.01080860f, 0.06491978f, -0.14943488f, 0.07060551f, -0.15852244f, 
    -0.12240731f, 0.12393831f, 0.20913991f, 0.04015952f, 0.17894875f, 0.01674280f, -0.02292380f, -0.01609395f, 
    -0.04829054f, 0.18302155f, -0.03975777f, 0.09631034f, 0.11733121f, 0.05205830f, -0.09542780f, -0.00962847f, 
    0.05675078f, -0.03118400f, 0.01361367f, 0.05904837f, -0.54053855f, -0.81194806f, -0.48520932f, -0.12303019f, 
    0.08420955f, -0.14965628f, -0.15426674f, -0.08297759f, -0.19913001f, 0.00646770f, 0.00079110f, 0.05350453f, 
    0.02278458f, 0.05189726f, -0.09003123f, -0.06957875f, -0.06870275f, 0.03357863f, 0.08951935f, -0.02909240f, 
    -0.22792564f, 0.56318295f, 0.06105873f, -0.06165945f, 0.01220258f, -0.08944502f, -0.01866274f, -0.07855831f, 
    -0.00230829f, 0.07849191f, -0.06980249f, -0.12009870f, 0.04537062f, 0.06316572f, 0.10484923f, 0.00665638f, 
    0.01567611f, -0.03497605f, -0.02446339f, -0.05030907f, -0.43605226f, -0.46354941f, -0.32886598f, -0.09554572f, 
    -0.09725513f, -0.00587426f, 0.12540326f, 0.07542805f, -0.05440957f, 0.01652674f, -0.00697576f, -0.03790705f, 
    0.06027777f, 0.01989656f, 0.02751259f, 0.11922326f, 0.17402199f, 0.00074309f, 0.06167985f, 0.11467207f, 
    0.09792198f, 0.00301023f, 0.07498463f, -0.08601056f, -0.06460565f, 0.07472657f, 0.01316001f, 0.03625156f, 
    0.07951779f, -0.11650377f, 0.04216821f, 0.04317461f, 0.05484262f, -0.10163964f, 0.02719813f, 0.02723350f, 
    0.06388712f, -0.03610959f, -0.14063390f, 0.03392423f, 0.03054911f, -0.07033871f, -0.06286237f, -0.16577891f, 
    0.01687899f, 0.00004962f, -0.08038484f, 0.02245382f, -0.00573729f, 0.01764098f, -0.12615791f, -0.09393691f, 
    -0.17377302f, -0.14305498f, -0.08383095f, -0.16690856f, -0.19313395f, -0.08461803f, -0.08530854f, -0.02454610f, 
    -0.01709906f, -0.05395832f, -0.07730855f, -0.18278398f, 0.06066213f, -0.04730992f, 0.07374430f, 0.10314053f, 
    -0.01433547f, -0.00384919f, 0.00075170f, -0.04498750f, -0.02325326f, 0.04395210f, 0.01587241f, 0.03412371f, 
    -0.07331274f, -0.14337100f, 0.07669215f, 0.10279141f, -0.09615176f, -0.74404675f, -0.85236984f, -0.15210792f, 
    -0.05312167f, -0.11177284f, -0.25854421f, -0.07713710f, -0.20840831f, -0.08585745f, -0.06288569f, 0.04959897f, 
    -0.03635265f, 0.01130915f, -0.15914473f, -0.05419419f, 0.00034117f, 0.26332328f, 0.13226572f, 0.06076710f, 
    -0.52978879f, 0.27639264f, 0.42101085f, -0.06616600f, -0.16736640f, -0.22125699f, -0.02594029f, -0.13285717f, 
    -0.15402265f, -0.01270222f, -0.15178493f, 0.04578184f, 0.02234204f, -0.01598847f, -0.00521948f, -0.04106759f, 
    -0.06271280f, -0.01946999f, 0.04872505f, -0.10640662f, -0.41596773f, 0.34431210f, 0.27705759f, -0.02709987f, 
    0.00995986f, -0.12687682f, -0.01294113f, -0.05914392f, -0.07487608f, 0.15921678f, -0.04924172f, -0.08496098f, 
    0.04851054f, -0.01682377f, 0.01563625f, 0.00485579f, 0.02763040f, -0.03022866f, -0.05264886f, -0.01711884f, 
    0.02478546f, 0.04846440f, -0.15700389f, -0.00384744f, 0.10446895f, -0.07619788f, 0.08168298f, 0.04307252f, 
    -0.01934967f, 0.07839383f, -0.03378733f, 0.04265691f, 0.01360273f, -0.01356861f, -0.02218235f, -0.06145557f, 
    -0.13415472f, -0.13654593f, 0.00182854f, -0.01280676f, -0.14434096f, -0.01667602f, 0.17075366f, -0.17426561f, 
    -0.00790151f, 0.00705208f, 0.06744449f, 0.03152489f, -0.07699009f, 0.10875928f, 0.09510128f, 0.15766679f, 
    0.00021134f, 0.04761310f, -0.10159451f, -0.02282636f, 0.07966357f, -0.06036497f, 0.08732712f, 0.15188758f, 
    -0.19516711f, 0.20254433f, -0.15485343f, 0.15732342f, -0.37613812f, 0.19960478f, 0.16546632f, -0.08885194f, 
    -0.24107596f, -0.33774066f, -0.05220876f, -0.08096317f, -0.08534020f, -0.00020232f, 0.07347653f, -0.00073207f, 
    -0.03879739f, 0.22500667f, -0.21030915f, -0.23312359f, 0.10616423f, -0.20458838f, -0.19467486f, -0.12384164f, 
    0.00189605f, 0.03112264f, 0.00833091f, 0.03466453f, -0.00714594f, 0.06476951f, -0.04799880f, 0.01607274f, 
    -0.03799569f, -0.13084546f, 0.02041481f, -0.14015260f, 0.03040004f, -0.07756080f, 0.01604235f, 0.03210492f, 
    0.00102709f, 0.02108558f, 0.06551043f, 0.01904191f, 0.21443747f, -0.09380226f, 0.04094910f, -0.02393760f, 
    0.02701426f, -0.05283333f, -0.03300007f, -0.07585338f, -0.10319421f, -0.01251649f, -0.00239343f, 0.00786420f, 
    -0.14341606f, -0.09872817f, -0.06127156f, 0.02547493f, -0.23879735f, 0.12840007f, -0.24359053f, 0.03535675f, 
    0.27101693f, -0.14709307f, 0.11154675f, 0.04536062f, 0.05071306f, 0.24335970f, 0.05312848f, 0.00123668f, 
    0.19179942f, -0.00558386f, 0.06647377f, -0.04879675f, 0.05782389f, -0.17892842f, 0.16829386f, -0.08934630f, 
    -0.53873295f, 0.33957487f, 0.46667114f, -0.01065879f, 0.25118837f, -0.11060178f, -0.08562201f, -0.03541880f, 
    -0.16768330f, 0.24505693f, -0.08660111f, 0.08658482f, 0.03611656f, 0.07159183f, 0.01592429f, 0.03093776f, 
    -0.03338556f, -0.03951216f, -0.00013905f, 0.00997167f, 0.17544770f, -0.31647709f, -0.43197507f, -0.22146669f, 
    0.28284082f, -0.14627732f, 0.14154938f, 0.28971773f, 0.14896779f, -0.01532659f, -0.05654057f, 0.02685795f, 
    -0.12324675f, -0.02511511f, 0.07018587f, -0.02285213f, 0.02550476f, -0.07389981f, 0.14101863f, -0.03858621f, 
    0.16257504f, 0.01491163f, -0.09767980f, -0.03698537f, -0.08527490f, 0.06077963f, -0.01580772f, 0.05476729f, 
    0.01047764f, 0.05612876f, 0.04152407f, -0.00745322f, 0.02129731f, -0.21501228f, 0.02203230f, -0.06167828f, 
    0.00081450f, -0.14779717f, -0.02452640f, 0.05622521f, -0.27643764f, 0.11485684f, 0.04463961f, -0.05290794f, 
    -0.07375975f, -0.19474772f, -0.08647297f, -0.20324419f, -0.13678779f, -0.09115417f, 0.05233924f, -0.15096422f, 
    -0.06234308f, 0.02878162f, 0.01383141f, -0.02365911f, 0.03137193f, 0.01947508f, -0.01921451f, -0.06033606f, 
    -0.02612497f, 0.20418322f, 0.15705238f, 0.21341068f, 0.09615055f, 0.04044350f, -0.03494961f, -0.03580861f, 
    -0.05533401f, 0.01149157f, -0.04261150f, -0.05095727f, 0.18191475f, -0.14129910f, 0.01158126f, 0.03217287f, 
    0.16746300f, -0.15363796f, -0.06421675f, 0.00415535f, -0.60994506f, 0.29714635f, 0.56565118f, 0.05012005f, 
    0.02249457f, 0.03525710f, -0.09474136f, -0.02468377f, -0.01150716f, 0.15424235f, 0.01205679f, 0.13824630f, 
    -0.01491595f, 0.06858741f, 0.07973196f, 0.01668431f, -0.03355570f, -0.02572885f, -0.07660654f, -0.04948143f, 
    0.20417073f, 0.11349219f, -0.18383382f, -0.16326240f, 0.06071102f, -0.09460231f, -0.08863151f, -0.01415389f, 
    0.08396383f, 0.07678574f, 0.02589635f, 0.01686210f, -0.12881944f, -0.06405613f, 0.03516231f, -0.06207969f, 
    -0.06525185f, -0.09445892f, -0.01025792f, 0.03286996f, -0.03145282f, -0.06250966f, -0.15012524f, -0.11895907f, 
    0.16468529f, -0.20509107f, 0.06425955f, -0.04448508f, -0.00294163f, 0.00693943f, -0.09899449f, 0.03990186f, 
    0.03902048f, 0.01314626f, 0.08263421f, 0.01490095f, -0.06328057f, -0.04759960f, 0.09160275f, -0.18388397f, 
    -0.12833536f, -0.08227088f, -0.07886790f, 0.09109450f, -0.17457230f, 0.05906675f, 0.01019403f, 0.18934588f, 
    -0.04318055f, -0.00025774f, -0.14888446f, 0.00186767f, -0.04565433f, -0.03101163f, -0.03649423f, -0.01546802f, 
    -0.01770092f, -0.02065978f, 0.03574332f, 0.16340621f, 0.41222534f, -0.29997259f, 0.03677152f, -0.32422197f, 
    -0.08238371f, -0.14348426f, 0.00981274f, -0.22026648f, 0.10750504f, -0.24665652f, 0.10375127f, -0.03591750f, 
    0.04351255f, -0.04941903f, -0.04703477f, -0.08763089f, -0.05166895f, 0.03475026f, -0.00440499f, 0.00507980f, 
    -0.21431416f, -0.35171121f, -0.08719162f, -0.08631246f, 0.10790144f, 0.04399189f, -0.01153725f, 0.20357376f, 
    -0.07741016f, 0.01291677f, -0.18801548f, 0.11471757f, 0.03379316f, 0.05605997f, -0.02407118f, 0.00303026f, 
    -0.00863058f, 0.04446976f, -0.05799303f, -0.00664121f, -0.08897299f, 0.03945483f, -0.06801338f, -0.04952525f, 
    -0.05728426f, 0.01682164f, -0.04022549f, -0.02005051f, -0.03047391f, -0.00903721f, -0.19252723f, -0.06302978f, 
    0.05316325f, 0.00861839f, -0.01839194f, 0.03341836f, -0.05643861f, -0.05041112f, -0.03432478f, 0.03785287f, 
    -0.01118994f, -0.57362580f, -0.05837650f, 0.42034632f, 0.08780432f, -0.20331828f, 0.22558665f, -0.11016037f, 
    0.24256782f, 0.29493958f, -0.02223471f, -0.02599878f, -0.06604587f, -0.05690006f, -0.02412814f, 0.02294871f, 
    -0.02818726f, -0.06375457f, 0.12440909f, -0.12412167f, -0.69169360f, -0.85111433f, 0.44822326f, 0.65267819f, 
    0.20521629f, -0.11768230f, 0.02536186f, -0.01458245f, -0.01401751f, 0.08705757f, 0.06686560f, -0.03613471f, 
    -0.00537721f, -0.03224507f, -0.00813400f, 0.01896307f, 0.04817480f, -0.06868216f, 0.17458311f, -0.07516426f, 
    -0.98813921f, -0.59354508f, -0.12068062f, 0.27488130f, 0.38065624f, 0.00097955f, 0.04205610f, -0.08377755f, 
    -0.02401358f, 0.02518426f, 0.07812177f, -0.02224521f, 0.07860757f, -0.05205484f, -0.03557673f, 0.07801564f, 
    0.04315877f, -0.15585932f, -0.10693104f, -0.14014062f, 0.06794880f, -0.18156165f, 0.08478603f, -0.05528709f, 
    0.12224276f, -0.10163638f, 0.12257232f, -0.05139967f, -0.02241647f, 0.02151351f, 0.09188857f, 0.03047301f, 
    -0.16248307f, -0.05001070f, 0.11935682f, -0.12775737f, 0.04255354f, -0.11598055f, -0.00609277f, -0.01034844f, 
    0.13594599f, 0.07343934f, -0.14812207f, -0.12912466f, -0.22369459f, -0.03558711f, 0.00950635f, -0.09045471f, 
    0.03899506f, -0.04606975f, 0.07178381f, 0.02139481f, 0.01587671f, -0.17715041f, -0.11363617f, 0.03522602f, 
    0.01005729f, -0.03375230f, 0.01805024f, 0.09109308f, 0.49649912f, -0.90087473f, -0.62348807f, -0.55857694f, 
    -0.38504803f, -0.00659984f, -0.05888995f, 0.00616827f, 0.37450334f, 0.01815578f, -0.00101232f, 0.02127388f, 
    -0.02958809f, -0.07053477f, -0.05421250f, -0.02811304f, -0.04193821f, -0.05566445f, 0.05611456f, 0.03872086f, 
    -0.15124214f, -0.25140569f, -0.08897036f, -0.02892954f, 0.11011115f, 0.05549830f, 0.06919195f, 0.05482767f, 
    0.02603135f, 0.06409864f, -0.01738747f, 0.03938186f, -0.02512428f, 0.08126654f, 0.01388394f, 0.00105726f, 
    0.02835853f, 0.08233616f, -0.01598286f, -0.00971725f, 0.09126190f, 0.29050875f, 0.07756630f, -0.07104156f, 
    -0.18638970f, 0.02241946f, 0.04609650f, -0.07236180f, 0.03163555f, -0.04807565f, 0.03871803f, -0.00779048f, 
    0.07809643f, 0.00801831f, -0.04862476f, 0.20934990f, 0.15016493f, -0.15928170f, -0.09311460f, -0.12960783f, 
    -0.10002287f, 0.05303208f, 0.02417683f, 0.03460893f, -0.01976955f, -0.03100459f, 0.03655034f, 0.07475445f, 
    -0.02496379f, -0.03165184f, 0.06517112f, 0.00022181f, 0.06173702f, -0.05076907f, -0.00197923f, 0.03084471f, 
    -0.11077362f, -0.08281530f, -0.01033011f, 0.01189467f, 0.00553103f, 0.12367283f, -0.01328966f, 0.08213715f, 
    -0.06123227f, -0.00585991f, -0.02876627f, 0.03433758f, 0.03993343f, -0.02194284f, 0.06196761f, -0.04895604f, 
    0.01611886f, -0.03034743f, -0.06194148f, -0.11246368f, -0.13291815f, 0.14584784f, -0.00137845f, 0.03012440f, 
    -0.10374963f, 0.06934353f, -0.01456553f, -0.00907931f, -0.10139537f, -0.01116949f, 0.00837361f, 0.01758494f, 
    -0.03967546f, -0.04636965f, 0.06490641f, 0.00200454f, 0.03187462f, 0.04274623f, -0.01369764f, 0.07090403f, 
    0.03145554f, -0.13605775f, 0.00925106f, 0.04061423f, 0.32890522f, -0.89825332f, 0.42219129f, -0.68958801f, 
    -0.40328512f, -0.08904827f, 0.06154219f, -0.35054499f, 0.41111127f, 0.11716048f, -0.02810615f, 0.02299220f, 
    -0.01105771f, -0.11276924f, -0.05685557f, -0.02809669f, 0.14548969f, -0.03648589f, 0.21120800f, -0.00410091f, 
    0.53258133f, -0.58998221f, -0.36295599f, -0.26712620f, -0.18871135f, 0.06123275f, -0.06584422f, -0.04121533f, 
    0.15749596f, 0.02693186f, 0.05021836f, -0.00892745f, 0.06484336f, 0.00776347f, 0.04400752f, 0.00950982f, 
    -0.00087790f, -0.03796537f, 0.01109930f, -0.02167737f, 0.38038638f, -0.05118551f, -0.13575797f, -0.11401934f, 
    -0.10790458f, 0.04549799f, 0.05560699f, 0.03097311f, 0.01253706f, 0.02774112f, 0.06327493f, 0.00372451f, 
    0.06371199f, 0.03155715f, 0.04548088f, -0.03583911f, -0.02550121f, 0.01888657f, 0.05925444f, -0.06153784f, 
    0.04349086f, 0.11804589f, 0.06579007f, -0.02133089f, -0.21698776f, -0.06240716f, 0.04623771f, -0.04167845f, 
    -0.03395609f, -0.09106878f, -0.06862979f, 0.03565524f, -0.06591754f, -0.00041813f, -0.05743819f, -0.22275558f, 
    -0.11532578f, 0.02750255f, -0.00956836f, -0.03623832f, 0.18821177f, 0.17271267f, -0.28401068f, -0.06616843f, 
    -0.25542817f, 0.02046960f, 0.03868657f, 0.02079134f, 0.00454762f, -0.01807829f, -0.25445300f, 0.03172933f, 
    0.04503804f, -0.07002188f, -0.21510325f, -0.10027302f, -0.05510738f, 0.04360234f, -0.12045094f, -0.03884666f, 
    -0.91458905f, -0.68072462f, 0.65292573f, -0.12323083f, 0.50513560f, -0.10243701f, 0.10476541f, 0.21560016f, 
    -0.02715589f, -0.01360900f, -0.04699527f, 0.03909453f, 0.01853972f, 0.01407534f, 0.03773931f, -0.00673869f, 
    0.00962612f, -0.04966743f, -0.02325442f, -0.13973753f, 0.01990590f, 0.07166744f, 0.11101785f, -0.00771674f, 
    -0.07762875f, -0.06265841f, 0.02830407f, -0.03102726f, 0.04929853f, 0.01012054f, 0.03844146f, 0.02608448f, 
    0.01489033f, 0.00566278f, -0.02781926f, -0.21285307f, 0.05262162f, -0.06099184f, 0.09255821f, 0.05778038f, 
    0.03432824f, 0.04699049f, -0.03170106f, -0.03590899f, -0.07685605f, 0.01817369f, -0.00302903f, -0.01714247f, 
    -0.00336482f, -0.00283473f, 0.02262118f, -0.03103721f, 0.02315709f, -0.00536587f, 0.00208510f, -0.10988535f, 
    -0.14259379f, -0.19313386f, 0.07306872f, -0.02656750f, 0.59745473f, 0.39442900f, -0.26105660f, 0.20242853f, 
    -0.44542345f, 0.09911373f, -0.01815244f, 0.05373062f, -0.17067008f, -0.08201630f, -0.13309367f, -0.04926421f, 
    0.08406103f, 0.05916473f, 0.03537972f, -0.05479096f, -0.08598834f, 0.07131080f, -0.07496153f, -0.18730253f, 
    0.39040649f, 0.08784451f, -0.26243353f, -0.17699288f, -0.19602002f, 0.05379931f, -0.03077974f, -0.04530587f, 
    -0.00900100f, -0.07386810f, 0.04654821f, 0.07151529f, 0.04211935f, 0.03950919f, 0.01937898f, -0.02276798f, 
    0.06841555f, -0.01330685f, 0.07831974f, 0.01245319f, -0.11142778f, -0.03499490f, -0.14176184f, 0.10930011f, 
    -0.17266330f, -0.02862107f, 0.05624265f, -0.03124066f, 0.06085439f, 0.01157754f, 0.05823500f, 0.01047235f, 
    -0.03458603f, -0.01345813f, -0.01289513f, 0.03881640f, -0.00781309f, -0.01869950f, -0.00244219f, 0.01460063f, 
    0.01919333f, 0.03294531f, -0.01970300f, -0.01746484f, -0.09644048f, -0.01434804f, -0.01550201f, 0.01028832f, 
    -0.09660671f, -0.01491067f, 0.03319752f, -0.02868539f, 0.01028069f, -0.08237271f, 0.02671496f, 0.03683746f, 
    -0.09752724f, -0.00380739f, -0.01999701f, 0.03969898f, 0.29711524f, -0.21433322f, -0.00741842f, 0.09318960f, 
    -0.00711150f, 0.09396832f, 0.04399863f, 0.10679436f, -0.04673701f, 0.06466477f, 0.07709429f, 0.02876575f, 
    0.10541902f, 0.03612897f, 0.01675195f, 0.04614843f, -0.02670179f, 0.00892807f, 0.01441111f, -0.08283509f, 
    0.06149497f, 0.02523726f, 0.18656677f, -0.17599908f, -0.03360305f, -0.03590760f, 0.03694746f, -0.01070029f, 
    -0.02491758f, -0.03626085f, 0.00258444f, -0.00643795f, 0.02623854f, -0.05554839f, -0.04166243f, -0.06297787f, 
    -0.04625995f, -0.29099941f, -0.01426238f, 0.01285484f, 0.77397966f, -0.22369184f, -0.29548815f, -0.14667058f, 
    -0.13368323f, 0.00482303f, -0.00159319f, -0.04201774f, -0.14987873f, -0.04478144f, 0.08636924f, -0.16714852f, 
    0.09935841f, 0.04439433f, -0.03828920f, -0.00027988f, 0.00389979f, -0.00035643f, -0.03069159f, -0.02232437f, 
    -0.01994448f, -0.08433097f, -0.16453317f, 0.00457316f, -0.00648280f, 0.05031298f, -0.06378251f, 0.00407354f, 
    0.00652353f, 0.01948792f, 0.08322047f, 0.01970525f, 0.07672029f, -0.01539669f, 0.03974408f, 0.07841481f, 
    -0.02849666f, 0.02250328f, 0.02138059f, 0.01923500f, 0.04490727f, -0.03354855f, -0.18024603f, 0.14975910f, 
    -0.10371253f, 0.07762621f, -0.00212657f, 0.13867691f, -0.03866251f, 0.00910022f, -0.08527588f, 0.03263329f, 
    0.05265119f, 0.04748016f, -0.07003525f, 0.02178102f, 0.04373668f, -0.01299731f, -0.10735450f, -0.01234622f, 
    -0.41018265f, -0.28108060f, 0.20907709f, 0.07219688f, 0.06484561f, -0.16861573f, 0.09677402f, -0.05916704f, 
    -0.10458463f, 0.01609811f, -0.00670556f, 0.11928986f, 0.08447258f, 0.10891363f, 0.00865194f, -0.05122320f, 
    0.03842990f, -0.13086055f, 0.05452569f, -0.03805302f, 0.36048603f, -0.29221389f, -0.55897146f, 0.04939705f, 
    0.07495273f, 0.15400326f, 0.15853025f, 0.19190866f, 0.14682609f, 0.09782252f, -0.02499982f, 0.02905422f, 
    -0.02992260f, 0.05525636f, -0.05576036f, 0.00789877f, 0.04169068f, -0.06868398f, 0.08523555f, -0.02743900f, 
    -0.27858296f, -0.67484653f, -0.09336732f, 0.08533718f, 0.45178950f, 0.20540066f, 0.13941520f, 0.10534349f, 
    -0.07601132f, 0.07151951f, 0.16071677f, 0.21004917f, 0.02394215f, 0.28121677f, 0.02853325f, -0.05550968f, 
    -0.01806519f, -0.06638068f, -0.01455618f, -0.01538525f, -0.21080214f, -0.09400553f, 0.00073680f, 0.04439785f, 
    -0.02073857f, -0.02907061f, 0.01660268f, -0.04719504f, -0.00157902f, 0.05500065f, 0.09914327f, 0.10324772f, 
    0.00174133f, 0.11904400f, -0.03689386f, -0.01263758f, 0.10561199f, 0.14462338f, 0.17610276f, 0.11295007f, 
    -0.19497731f, -0.85290307f, -0.76181066f, -0.25628215f, -0.07873766f, 0.02264186f, -0.25847158f, -0.14973775f, 
    -0.03513423f, -0.27037004f, -0.05467877f, -0.03058572f, 0.00756888f, 0.02951235f, 0.03130721f, 0.01031461f, 
    0.05181558f, 0.11751797f, 0.05929593f, 0.06863423f, 0.74937671f, -0.25223297f, -0.25518605f, -0.07967038f, 
    -0.14911394f, 0.12772982f, -0.11592341f, -0.08638586f, 0.10323837f, -0.08989473f, -0.03131881f, 0.07689598f, 
    0.04520667f, 0.00253206f, 0.09749260f, 0.02314790f, 0.08474610f, 0.08305079f, 0.07217124f, 0.06054911f, 
    -0.46590447f, -0.23573555f, 0.02935342f, -0.03762174f, 0.11397472f, 0.10833093f, -0.07970790f, -0.04886225f, 
    -0.10950479f, -0.33339453f, -0.07852916f, 0.07401418f, 0.14321890f, 0.01225328f, 0.04064938f, -0.00931517f, 
    0.01379257f, 0.15177451f, -0.08645505f, -0.07564809f, 0.33541447f, 0.07141063f, -0.32012376f, -0.05886214f, 
    0.11869553f, 0.11588883f, -0.04110210f, -0.02173471f, 0.15505639f, -0.00399890f, 0.06833288f, 0.02565950f, 
    0.24218334f, -0.00690163f, 0.11190951f, -0.09881879f, 0.07775714f, -0.03299504f, 0.08475745f, 0.03239354f, 
    -0.02024530f, -0.13631018f, -0.06351373f, -0.02797803f, -0.02705634f, -0.08081757f, 0.07923932f, 0.05324184f, 
    0.16891457f, 0.01689409f, 0.09613553f, -0.05906694f, -0.02145944f, -0.02970830f, 0.01035503f, -0.02659337f, 
    0.02281535f, 0.05303336f, -0.01620017f, -0.06592540f, -0.08646250f, -0.32770506f, -0.89930671f, -0.52962118f, 
    0.17926739f, 0.01795279f, 0.00627933f, 0.05720283f, -0.00458161f, -0.29369476f, -0.01197652f, -0.04424976f, 
    -0.09648161f, 0.03579760f, 0.06773370f, 0.12177923f, -0.02372852f, -0.05119022f, 0.03050161f, -0.01950417f, 
    -0.31331602f, -0.20536640f, -0.33626348f, 0.00497011f, 0.08411754f, 0.06440104f, 0.04751605f, 0.03700539f, 
    0.10464040f, 0.11486813f, 0.15685631f, 0.14416052f, -0.01801128f, -0.00134067f, 0.02108382f, -0.03634493f, 
    0.09923189f, -0.05635888f, -0.02102355f, 0.05420519f, -0.39597145f, 0.28927052f, 0.31160587f, -0.02482639f, 
    -0.29084986f, 0.01617799f, -0.23021950f, -0.11837492f, -0.03742087f, -0.20010500f, -0.09926944f, -0.02610548f, 
    -0.06953061f, -0.05971572f, -0.05611782f, -0.04494029f, -0.10844621f, -0.37024453f, -0.24682851f, -0.18683329f, 
    -0.48803025f, 0.00274945f, 0.25822654f, 0.05933872f, 0.13905774f, -0.05479324f, 0.02235526f, -0.02807085f, 
    -0.01382897f, -0.06240419f, -0.03067858f, -0.01899160f, 0.07243894f, 0.00323253f, 0.08216108f, -0.07657398f, 
    0.00228237f, -0.07428150f, -0.00943539f, -0.00415873f, -0.31870118f, 0.00337275f, 0.07832136f, -0.02505970f, 
    -0.20759617f, -0.06934151f, -0.00730249f, -0.08503615f, 0.01390688f, -0.01910966f, -0.04476537f, -0.01495256f, 
    -0.10983837f, 0.08528557f, 0.05397177f, -0.00510922f, 0.14273007f, 0.04149983f, 0.03837460f, 0.09173972f, 
    -0.26305026f, 0.22073030f, 0.19484419f, 0.12044465f, -0.06923687f, 0.02315167f, -0.07457758f, -0.02885644f, 
    -0.02562680f, -0.10615908f, -0.05347244f, -0.05739169f, 0.00120849f, -0.05441518f, 0.00989922f, 0.00453289f, 
    -0.12545319f, -0.11318367f, -0.04347228f, -0.16025531f, 0.16308562f, 0.00153084f, -0.62036151f, -0.47880402f, 
    -0.13667972f, -0.00311029f, -0.29176584f, 0.21003963f, -0.06708065f, -0.09090556f, 0.04934617f, -0.03926263f, 
    -0.06753041f, 0.07994933f, 0.07370344f, 0.18043320f, -0.06997842f, 0.04507176f, -0.35530671f, -0.53229100f, 
    -0.06618226f, -0.32382023f, -0.43552354f, -0.20381349f, 0.08914186f, -0.02092052f, -0.01762225f, 0.04586626f, 
    0.09959877f, 0.11996517f, -0.03923495f, -0.13390686f, -0.03829564f, -0.04681960f, -0.03250578f, -0.03651861f, 
    0.02128308f, 0.01905750f, 0.01536273f, 0.05928164f, -0.13462549f, -0.35713527f, -0.32515681f, -0.13227208f, 
    0.01397709f, -0.01085364f, 0.09076843f, 0.11839011f, 0.02734817f, 0.15858757f, 0.00657642f, -0.08632360f, 
    -0.04611204f, -0.06918459f, -0.08311295f, -0.01019895f, 0.07151858f, -0.01648883f, -0.02234793f, 0.05576583f, 
    0.21381927f, 0.20364369f, 0.01573740f, -0.06689437f, -0.15074648f, 0.00070011f, -0.03154626f, -0.04592899f, 
    0.07782586f, -0.07807814f, -0.07100240f, 0.04616180f, -0.00586018f, -0.05193707f, 0.04394842f, 0.02134316f, 
    0.01402055f, -0.04508786f, 0.09049234f, 0.07304042f, 0.08621854f, 0.17573631f, 0.00149122f, -0.04204636f, 
    -0.38598028f, -0.11609836f, -0.01975092f, -0.05509032f, 0.03979530f, -0.07174080f, 0.07518248f, 0.00970650f, 
    -0.00309310f, 0.08708756f, 0.03433965f, 0.01088408f, 0.05684693f, -0.01520483f, -0.04400040f, 0.00257026f, 
    0.19331273f, -0.50100648f, -0.29336268f, 0.29873475f, 0.20042138f, -0.00428448f, 0.04633529f, -0.01598366f, 
    -0.00455792f, 0.33626544f, -0.02472864f, -0.08048383f, -0.02395357f, -0.04958317f, -0.00721276f, -0.01743390f, 
    0.11946864f, 0.02590470f, -0.00173446f, 0.12190287f, -0.14253554f, 0.22417894f, 0.00016784f, -0.07510486f, 
    -0.08587259f, 0.06396776f, -0.06694552f, 0.03716978f, 0.01161766f, -0.19514008f, -0.08763316f, -0.03006405f, 
    -0.00627890f, -0.06762928f, 0.02537362f, -0.08839514f, 0.12473743f, 0.09589740f, 0.06920290f, 0.01699005f, 
    -0.40599817f, 0.01249184f, 0.13040105f, 0.03931075f, -0.19705614f, 0.01858760f, -0.11413734f, -0.07327693f, 
    -0.00013314f, -0.13288663f, -0.02375736f, -0.05327889f, -0.05868530f, -0.09357256f, -0.01975239f, 0.01615082f, 
    0.01396624f, 0.00479795f, -0.09053754f, 0.00545948f, 0.78574347f, -0.01801551f, -0.23077244f, -0.09072541f, 
    0.05507483f, 0.06351548f, 0.16435926f, 0.08718864f, 0.07307559f, -0.01242862f, 0.07685818f, 0.06859401f, 
    0.05400347f, 0.09889016f, -0.03942351f, 0.13822669f, -0.01203788f, -0.11318263f, 0.11768752f, -0.05317776f, 
    -0.18904719f, -0.44102231f, -0.45421082f, -0.23263380f, -0.02407258f, -0.11418323f, 0.11027908f, 0.16651459f, 
    0.11070096f, 0.11982410f, 0.06767940f, -0.02896734f, -0.02897203f, -0.03800733f, -0.06830841f, 0.01594881f, 
    0.05215215f, 0.02912958f, 0.02098029f, -0.02219246f, 0.20245372f, 0.25470063f, 0.06285232f, 0.02324920f, 
    -0.22424665f, 0.09254125f, -0.12570390f, -0.08216926f, -0.04727989f, -0.24785472f, -0.10626992f, 0.04445906f, 
    0.02339629f, -0.02092883f, 0.03847895f, -0.01997600f, 0.01322175f, 0.16215490f, 0.16562802f, 0.09332637f, 
    -0.21558073f, 0.14080173f, 0.14439677f, -0.00348744f, -0.02306331f, -0.07087588f, 0.05371547f, -0.02712163f, 
    0.03894543f, -0.01361892f, 0.02655502f, -0.02979650f, 0.00832758f, 0.06307746f, 0.04701182f, -0.02739971f, 
    0.06612133f, 0.07699408f, 0.12199939f, 0.04296244f, 0.04284140f, -0.19181651f, -0.13039516f, -0.08188667f, 
    -0.06567261f, -0.17398365f, -0.19760823f, -0.07755812f, -0.07463402f, 0.00534090f, -0.06597458f, 0.02649292f, 
    -0.12229531f, -0.06097982f, -0.04154039f, -0.01770180f, 0.10236111f, 0.11019766f, 0.11233860f, 0.11924896f, 
    0.02121969f, 0.19009207f, -0.01469391f, 0.00410850f, -0.00667498f, 0.07924817f, -0.07403460f, 0.01631001f, 
    -0.00537822f, -0.06702961f, -0.04270930f, 0.12098334f, -0.10798115f, 0.01808302f, 0.15133795f, -0.15566443f, 
    0.08635774f, -0.33721909f, -0.24844484f, 0.00755127f, 0.01510506f, -0.26502663f, -0.41626722f, -0.06032045f, 
    -0.02673271f, -0.08345655f, 0.16080885f, 0.11372145f, 0.08094976f, 0.04379964f, 0.03659065f, 0.00237446f, 
    -0.04318202f, -0.03237312f, -0.05602820f, -0.08557927f, 0.10343624f, -0.05025046f, 0.05735467f, -0.00336160f, 
    -0.09039304f, -0.02225467f, -0.07664810f, 0.06635261f, -0.07068568f, -0.07400715f, 0.00671615f, -0.10513537f, 
    -0.08280854f, -0.03371273f, 0.07443587f, -0.04331524f, 0.08308901f, 0.10548449f, -0.00732211f, -0.00817993f, 
    0.08230846f, 0.05031440f, 0.09962287f, 0.07853345f, 0.38241234f, -0.00808369f, -0.15154012f, -0.07382220f, 
    -0.09987439f, -0.03350851f, -0.06403286f, -0.08234970f, -0.11247926f, -0.18564822f, -0.01240272f, -0.00877068f, 
    0.05205835f, -0.00430946f, -0.00618266f, 0.01174157f, 0.11655239f, 0.11329101f, 0.22599855f, 0.10239016f, 
    0.05717851f, -0.02950501f, 0.14929974f, -0.30372399f, 0.01568918f, 0.05218643f, -0.10580806f, -0.05817987f, 
    0.01079936f, -0.19765212f, -0.10206927f, 0.10233949f, 0.00138446f, 0.06146441f, 0.04587238f, 0.08931278f, 
    0.07842053f, 0.01513783f, -0.05321288f, 0.19403110f, 0.05759103f, 0.18338834f, -0.28919697f, 0.16696496f, 
    -0.10182713f, -0.20873176f, -0.09434626f, -0.21323374f, -0.06353507f, -0.08222359f, 0.06314000f, -0.03324939f, 
    -0.01400750f, 0.05862759f, 0.07694744f, 0.04188506f, 0.00992331f, 0.01443511f, -0.08037116f, 0.04840074f, 
    -0.18754292f, -0.45857897f, 0.37928346f, -0.49534401f, -0.80844522f, 0.14163388f, -0.43955809f, 0.02805966f, 
    -0.14321221f, -0.23713645f, -0.07885840f, -0.01170745f, -0.10914920f, 0.09638689f, 0.10647343f, -0.01595291f, 
    -0.05906155f, -0.02002861f, -0.15366919f, -0.01723640f, -0.02137035f, 0.26046517f, 0.34357104f, -0.08432763f, 
    0.01860207f, 0.02640000f, -0.04497855f, -0.05513341f, 0.03019829f, -0.03800370f, -0.01400198f, 0.06846647f, 
    0.06140865f, 0.04025320f, 0.01864360f, -0.02947064f, -0.03092719f, -0.10254469f, -0.02449156f, -0.08933444f, 
    -0.51481164f, -0.30312991f, 0.29632542f, 0.08671877f, -0.32780480f, -0.08853228f, -0.24621570f, 0.22319950f, 
    0.27527332f, 0.34112602f, -0.02567399f, 0.04143462f, 0.05521766f, -0.01439226f, -0.04617032f, 0.03928218f, 
    0.01174654f, 0.07099144f, 0.09323812f, -0.09910204f, 0.14775985f, 0.07218239f, -0.11353417f, -0.02928157f, 
    -0.25328997f, -0.02780189f, -0.09557386f, 0.25660631f, 0.01539293f, 0.19407377f, -0.13836400f, -0.00385175f, 
    -0.05175028f, -0.01355259f, -0.07342815f, 0.08506851f, 0.06067982f, 0.04528433f, 0.08004294f, -0.06463510f, 
    0.11269861f, 0.56774616f, -0.24902341f, -0.33278474f, -0.23569421f, -0.25893241f, -0.01986450f, 0.05444191f, 
    -0.10052004f, 0.39794284f, -0.01582846f, 0.07102167f, -0.06721605f, -0.04876781f, 0.00654816f, -0.02967075f, 
    0.08834009f, -0.02187183f, -0.01755679f, -0.12459786f, -0.04348350f, -0.24718298f, 0.05347355f, -0.15558746f, 
    -0.12796359f, -0.01293188f, -0.03127366f, -0.15468673f, -0.14995526f, -0.28976998f, -0.00945836f, -0.07821511f, 
    0.10340229f, 0.01148371f, 0.04849300f, 0.11410499f, -0.04119062f, -0.29075497f, -0.15517604f, 0.07266611f, 
    0.08307403f, 0.14208297f, 0.24713740f, 0.44594386f, -0.02860811f, -0.02299344f, 0.00494896f, -0.28687140f, 
    -0.01319744f, -0.26611200f, 0.04175583f, -0.07713065f, 0.13163240f, -0.04076246f, -0.02865764f, 0.14726694f, 
    0.03288116f, -0.08387940f, 0.04792536f, 0.07969528f, -0.14820711f, -0.13524801f, -0.13136512f, 0.21979551f, 
    -0.84590012f, -0.08222410f, 0.02460341f, -0.13331832f, 0.20254172f, 0.07582916f, 0.05077695f, 0.01496763f, 
    0.08408275f, 0.04965486f, 0.00163291f, -0.04782680f, 0.05314819f, 0.13862413f, 0.10808118f, 0.06519555f, 
    0.10650163f, -0.02609580f, 0.52361119f, -0.33000487f, -0.29845017f, 0.14398287f, -0.22427160f, -0.24790289f, 
    0.00348679f, -0.13238223f, -0.02749081f, -0.05328783f, 0.09296757f, 0.05515290f, 0.02353247f, 0.07858184f, 
    -0.18854673f, 0.00030106f, -0.17406446f, -0.04004459f, -0.11550278f, -0.40152916f, -0.24286267f, 0.15676849f, 
    0.04780047f, -0.03188830f, 0.24469295f, 0.20544368f, -0.05309762f, 0.16877323f, -0.00088366f, -0.05903701f, 
    -0.00307051f, 0.03723779f, -0.07553171f, -0.01629793f, 0.06099531f, -0.04506891f, -0.00747404f, 0.08896386f, 
    0.00809232f, -0.20196790f, -0.03793069f, -0.18608893f, 0.16574836f, -0.11310042f, 0.03362695f, 0.08626560f, 
    0.01221136f, -0.00229570f, 0.01036987f, 0.10861424f, 0.04691602f, -0.13525382f, -0.00947850f, 0.14773147f, 
    0.20364167f, 0.02350500f, 0.02800569f, 0.18430805f, -0.16047899f, 0.08929665f, -0.14831448f, -0.14524938f, 
    -0.03850720f, 0.07964435f, 0.01721534f, 0.08438865f, 0.07368857f, 0.07426202f, 0.14085124f, -0.00435607f, 
    -0.04779516f, -0.04004169f, 0.01117080f, 0.06664192f, 0.05411996f, -0.10606098f, -0.00314722f, 0.01605053f, 
    -0.21495272f, 0.01629553f, -0.56219316f, 0.19270140f, -0.01610734f, 0.11441737f, 0.00329044f, 0.24454637f, 
    -0.02266126f, 0.09045135f, -0.01416809f, -0.01270184f, 0.03216822f, 0.08347993f, -0.03250954f, -0.03718518f, 
    0.17781182f, -0.13800290f, -0.03641942f, 0.14799751f, -0.06259818f, -0.39166522f, -0.31542587f, 0.27706403f, 
    -0.35657817f, -0.32017300f, 0.09249742f, -0.26735249f, -0.01705910f, 0.21635471f, 0.15257019f, -0.00040874f, 
    0.05797028f, 0.11348352f, 0.03393616f, -0.06030157f, 0.01820599f, 0.07359232f, 0.28761038f, 0.11392448f, 
    -0.24774531f, -0.11297034f, 0.24783021f, 0.22303011f, -0.32050216f, 0.12219623f, -0.14602056f, -0.15077350f, 
    0.08641800f, 0.00347552f, 0.07692718f, -0.11014782f, 0.07481810f, -0.02660322f, 0.04132846f, -0.00818889f, 
    -0.02522900f, -0.05001360f, 0.04425601f, 0.00061547f, 0.13224004f, 0.03452839f, 0.41930422f, 0.12543875f, 
    -0.15054299f, 0.12362290f, -0.19602938f, -0.34824473f, -0.17028728f, -0.15415901f, 0.04174554f, 0.02400642f, 
    0.18448466f, 0.02314422f, 0.06905624f, 0.04011829f, -0.06858060f, -0.09305204f, -0.04530492f, -0.03674008f, 
    -0.23514318f, -0.01946389f, -0.33399901f, 0.10395841f, 0.02729382f, 0.02249974f, 0.08726251f, 0.12570003f, 
    -0.00536573f, 0.00210577f, -0.00741842f, 0.04990392f, 0.00309364f, -0.02953670f, -0.04159486f, -0.03753992f, 
    0.03183803f, -0.08219048f, 0.03051539f, 0.05936691f, -0.47125584f, 0.12385099f, -0.00521067f, 0.24017514f, 
    0.38445437f, -0.10002614f, -0.07775875f, -0.21660665f, -0.00052604f, 0.10417749f, 0.16057785f, -0.00187959f, 
    -0.06068790f, 0.00036149f, 0.02250184f, 0.18156086f, -0.08237225f, 0.00907256f, -0.04382971f, 0.00719169f, 
    0.14260010f, -0.35559538f, 0.66736841f, -0.69796622f, -0.52493358f, -0.27870548f, -0.18138488f, -0.04181041f, 
    0.07789793f, 0.12303225f, -0.05817691f, -0.03111714f, -0.04988163f, 0.06286922f, -0.06146054f, -0.01049745f, 
    0.11028159f, -0.03364263f, -0.22520229f, -0.01109041f, -0.03856235f, -0.27046701f, -0.74344879f, 0.06209112f, 
    0.14937067f, -0.19883133f, 0.25332555f, 0.34471029f, -0.01396908f, 0.06513580f, 0.03026677f, 0.00750870f, 
    -0.05742662f, -0.00893864f, -0.04509626f, 0.08105868f, 0.12829240f, -0.12733932f, -0.02441466f, -0.09423430f, 
    -0.16922103f, -0.10181081f, -0.41440609f, -0.15044829f, -0.23825589f, 0.09099278f, 0.05037687f, 0.24333256f, 
    -0.07839292f, 0.08342349f, 0.02999113f, 0.01248299f, 0.00314399f, 0.07109888f, 0.02721435f, 0.12561475f, 
    0.17875117f, 0.01704864f, -0.02143964f, -0.03143408f, -0.73748887f, 0.12033632f, -0.45620251f, 0.36503488f, 
    -0.28757599f, 0.00784438f, -0.09421622f, 0.04800581f, -0.28558847f, -0.11862990f, 0.08815297f, 0.02669328f, 
    0.01816564f, -0.05359749f, -0.05141466f, -0.02771277f, 0.05182406f, -0.10256819f, 0.12260728f, 0.13699828f, 
    0.19482134f, 0.19042744f, 0.24765618f, 0.45977291f, -0.31586117f, 0.16542935f, -0.03334634f, -0.39741325f, 
    -0.17134152f, -0.26587385f, 0.08802652f, -0.10581689f, 0.03474837f, 0.10487838f, 0.02116294f, 0.03783741f, 
    0.03332127f, -0.02114836f, -0.00044499f, 0.02034178f, 0.04862929f, 0.34054661f, -0.91352099f, 0.18210968f, 
    -0.12075358f, 0.14104715f, 0.09231631f, 0.24251521f, -0.01530110f, 0.00894587f, 0.06640811f, -0.04147461f, 
    -0.10059816f, -0.10701157f, -0.01042739f, -0.00961392f, 0.02580303f, -0.15303715f, 0.03339812f, -0.10005583f, 
    -0.13278970f, 0.06684231f, -0.03363841f, -0.02756473f, 0.22356907f, -0.07115773f, 0.18709718f, 0.11889208f, 
    0.00121540f, -0.00852648f, 0.00945053f, 0.09859762f, -0.09483395f, -0.14376290f, 0.07775012f, 0.11675494f, 
    0.08529878f, -0.20193084f, -0.02974295f, -0.05665492f, -0.11017907f, 0.10328045f, 0.14646845f, -0.00333556f, 
    -0.02897183f, -0.07920191f, 0.00635178f, 0.00039671f, -0.00659326f, 0.02479389f, -0.04496523f, 0.02055534f, 
    0.08786298f, -0.02626915f, -0.03697402f, 0.02138240f, -0.05625141f, -0.05892319f, -0.04305198f, -0.28599116f, 
    -0.08744147f, -0.25812498f, -0.35458764f, -0.12361559f, 0.13189028f, -0.01941616f, 0.11365728f, 0.14603503f, 
    -0.13698773f, 0.01317552f, 0.19810979f, -0.00995937f, -0.02391968f, -0.02731748f, -0.12356652f, 0.02728668f, 
    0.11429446f, -0.02670081f, -0.00210348f, 0.16285847f, -0.09157434f, 0.11780488f, 0.18773063f, -0.18202431f, 
    -0.13922609f, -0.00577788f, 0.08454850f, -0.36288136f, -0.23512703f, 0.00806571f, -0.00017089f, -0.00884536f, 
    0.09015804f, 0.08832361f, -0.00386475f, -0.00993341f, -0.04195933f, 0.02769235f, -0.06045347f, -0.01961020f, 
    -0.13197440f, 0.21986894f, 0.02172333f, 0.14390658f, -0.20157903f, 0.13014115f, 0.04157475f, 0.15056273f, 
    -0.03142253f, -0.08291082f, -0.00354440f, -0.06368977f, -0.00147543f, -0.21340825f, -0.12006755f, 0.07325303f, 
    -0.00232924f, -0.15972051f, 0.00178502f, -0.09166276f, -0.09672414f, 0.25761810f, -0.23243144f, 0.15746020f, 
    -0.06147141f, 0.07490803f, -0.03929950f, 0.05750940f, -0.00216582f, -0.09712016f, 0.03146265f, 0.04907636f, 
    -0.07261258f, -0.10292664f, -0.03712813f, 0.05170013f, -0.09704990f, -0.09875982f, 0.08391934f, -0.13298634f, 
    -0.34662449f, 0.34736326f, 0.14204295f, 0.00224736f, -0.25837421f, 0.15114842f, 0.04080986f, -0.17567025f, 
    -0.05269899f, -0.00141759f, -0.02675892f, 0.09645867f, 0.03673408f, 0.02498048f, -0.16587426f, -0.17675494f, 
    -0.04304670f, -0.05011673f, -0.04441532f, -0.22782806f, -0.17302990f, 0.06963301f, 0.23753116f, 0.20740604f, 
    0.13022220f, -0.05020831f, -0.09994145f, -0.20349506f, 0.10785346f, 0.23046684f, 0.00808710f, 0.03259151f, 
    -0.02496391f, -0.05923100f, -0.15709764f, 0.11380639f, 0.11510932f, -0.02130360f, 0.09660104f, -0.01218970f, 
    -0.59974110f, 0.28019023f, -0.12891787f, 0.46152410f, 0.22013485f, 0.04043014f, -0.07893378f, -0.03127410f, 
    0.34327471f, 0.18324833f, 0.08413345f, -0.09205219f, -0.03227137f, -0.04703341f, 0.21150114f, -0.00724946f, 
    -0.03810033f, -0.11720954f, 0.19415669f, 0.03455890f, -0.06945046f, -0.18787494f, 0.01726145f, 0.05785711f, 
    -0.16197735f, -0.06119219f, 0.09521541f, -0.07479791f, 0.07599652f, -0.01818447f, -0.04429416f, -0.20149323f, 
    0.05776661f, 0.03866275f, -0.02887907f, -0.01365975f, 0.14710808f, 0.03180491f, 0.20131601f, 0.14089642f, 
    -0.41094527f, -0.05345013f, -0.41284230f, -0.12578514f, 0.08777965f, -0.11771676f, -0.22536926f, 0.10796061f, 
    -0.09017849f, -0.06906483f, -0.07511222f, 0.12270918f, 0.03244408f, 0.02328626f, -0.01430026f, 0.02846583f, 
    -0.07947210f, -0.17749724f, -0.02686096f, -0.08296518f, -0.56828743f, 0.00574959f, -0.09553055f, -0.06820171f, 
    0.12650970f, -0.04543746f, -0.18817002f, -0.04833640f, -0.10382730f, 0.03642605f, -0.05023617f, 0.13960673f, 
    0.00179248f, 0.06768614f, -0.04985974f, 0.05604774f, -0.00730600f, -0.18913883f, -0.00130298f, -0.02123830f, 
    -0.15557858f, -0.21344221f, 0.08215221f, 0.14483516f, -0.25301221f, 0.00841131f, -0.00244342f, 0.42290130f, 
    -0.05574753f, -0.25036126f, -0.00016821f, -0.04070705f, 0.03929099f, 0.06197939f, 0.01534634f, -0.03245026f, 
    -0.08227476f, 0.18891788f, -0.22085811f, 0.01336447f, -0.43679020f, 0.19968405f, 0.24413730f, 0.36477268f, 
    0.29602796f, -0.13152836f, 0.04516992f, 0.20600884f, 0.00633551f, 0.06612384f, -0.19609325f, -0.13181144f, 
    -0.18302526f, -0.12176444f, -0.01756852f, -0.02541676f, -0.06396238f, 0.17191961f, 0.14948630f, 0.36012936f, 
    0.13952783f, 0.09376021f, 0.14500467f, 0.04075378f, 0.03322937f, 0.11207504f, -0.12388999f, 0.00418163f, 
    -0.00779853f, 0.04459647f, -0.12330633f, 0.07564546f, -0.16818355f, -0.04464162f, -0.15691920f, -0.11859257f, 
    -0.19545166f, 0.06911647f, -0.01033710f, -0.09236617f, -0.42574453f, 0.12709364f, -0.17805232f, 0.00668488f, 
    0.00007780f, -0.16149315f, -0.17015612f, -0.08878306f, -0.08093217f, -0.00864038f, -0.07625555f, 0.13399707f, 
    -0.01249632f, -0.13091300f, -0.08168863f, 0.02348043f, -0.01807283f, 0.00299626f, -0.06820154f, -0.22206083f, 
    -0.28546515f, 0.14180318f, -0.19174722f, 0.45983160f, 0.29166847f, -0.02888686f, -0.08659119f, -0.14441061f, 
    0.06577884f, 0.16452648f, -0.05712376f, -0.08673347f, 0.06122718f, -0.05559501f, -0.01909517f, 0.04353076f, 
    0.05714209f, -0.11447721f, 0.10677272f, 0.11892425f, 0.14728740f, -0.50130486f, -0.17553531f, 0.19657721f, 
    0.08956521f, -0.08231997f, -0.19683020f, 0.09749977f, -0.30282024f, -0.13101435f, -0.05230755f, -0.05586648f, 
    -0.09667701f, 0.06184841f, 0.04467055f, -0.07294874f, -0.37911844f, -0.27027473f, -0.12032222f, -0.07251229f, 
    0.15347448f, -0.00217985f, -0.10774342f, 0.22482745f, -0.16894381f, -0.03247574f, -0.04668414f, 0.09411331f, 
    -0.07627095f, -0.03337315f, 0.12584886f, 0.10079688f, -0.16806553f, 0.08476458f, -0.02364166f, -0.00825457f, 
    -0.03407618f, 0.12382945f, -0.15425581f, -0.01101814f, -0.20367587f, -0.36927590f, -0.07357356f, -0.24457702f, 
    -0.33071679f, 0.02400177f, -0.11091240f, 0.00205541f, 0.02757909f, 0.04437681f, -0.09560991f, -0.00258000f, 
    0.09689710f, -0.13987415f, -0.15814625f, -0.04845146f, 0.24668720f, 0.26031005f, 0.16958316f, -0.00300539f, 
    -0.09347419f, -0.20129345f, 0.01251868f, 0.01956582f, -0.02923374f, -0.14846760f, -0.02988629f, -0.05076636f, 
    -0.03259883f, -0.10802125f, -0.12683161f, -0.00943888f, -0.04085495f, 0.02886233f, -0.05055711f, 0.13641183f, 
    -0.17335309f, -0.03003056f, -0.06255022f, -0.09112178f, -0.14519274f, 0.04171298f, -0.39061967f, 0.00020291f, 
    0.15212297f, 0.03292566f, -0.00897332f, 0.17141587f, -0.18833819f, -0.03990946f, -0.05452745f, 0.05251177f, 
    0.05505972f, -0.03625134f, 0.02854388f, 0.01929015f, -0.03540682f, -0.42664847f, -0.08077346f, -0.26395875f, 
    -0.20171750f, 0.05250466f, -0.20801842f, 0.02868235f, 0.16838990f, -0.04057466f, 0.05845182f, -0.09301991f, 
    0.03251442f, 0.00134916f, -0.09605011f, 0.09063609f, -0.06451801f, 0.02820465f, -0.02334562f, 0.07720937f, 
    0.07165320f, -0.11619952f, 0.10579958f, 0.11650322f, 0.08202554f, -0.04358387f, 0.12936133f, 0.21207097f, 
    0.09918635f, -0.02427892f, 0.05338839f, -0.17007455f, 0.05011794f, 0.05975276f, -0.10557045f, 0.15657867f, 
    -0.03774893f, -0.08861038f, -0.10370518f, -0.00615261f, -0.00242291f, 0.00074746f, 0.06785525f, 0.09418975f, 
    0.03470413f, -0.30442101f, 0.08072499f, -0.00632793f, -0.14493115f, -0.20039345f, -0.06537085f, 0.07407679f, 
    -0.09792892f, -0.02089349f, -0.07428715f, 0.04253641f, -0.20119435f, 0.08220841f, 0.04646004f, -0.03735508f, 
    0.04062629f, 0.10296470f, -0.00193546f, 0.05219544f, 0.64431405f, -0.37971532f, 0.42880204f, -0.11531512f, 
    -0.18929252f, -0.09801759f, -0.05845033f, 0.14348878f, -0.05706586f, -0.06786533f, 0.05989233f, 0.12490327f, 
    0.01424015f, -0.11149421f, -0.00615328f, 0.02386205f, -0.06659474f, -0.02330391f, -0.07195531f, -0.23185980f, 
    -0.42772406f, 0.32147139f, -0.00284710f, 0.17096679f, 0.16332951f, -0.03403902f, -0.06415571f, -0.13681884f, 
    0.18609060f, 0.18142463f, -0.22920771f, -0.17454045f, 0.06138720f, 0.03117717f, -0.08932109f, -0.08601257f, 
    -0.02533816f, -0.19072062f, 0.01846399f, 0.14451183f, 0.02251220f, -0.32079938f, -0.42271629f, 0.05246618f, 
    0.10306238f, -0.04190163f, -0.17023060f, 0.03190136f, -0.15025043f, 0.01802660f, -0.08089867f, 0.10825989f, 
    -0.17063004f, 0.01451650f, 0.04427600f, 0.08074203f, -0.19369705f, 0.05510145f, -0.06391113f, 0.12875813f, 
    -0.06169064f, -0.24919966f, -0.26490819f, 0.36565715f, -0.23561196f, -0.05143739f, -0.14691371f, -0.17769507f, 
    -0.06412444f, 0.01491402f, -0.16001603f, -0.01304505f, -0.06464141f, -0.06232325f, 0.00771871f, 0.17426945f, 
    -0.05276201f, -0.07946802f, 0.14740376f, 0.14190373f, 0.39251366f, -0.23261991f, 0.33815637f, -0.04180679f, 
    0.12506725f, -0.16462176f, 0.09337548f, 0.06433185f, 0.20813049f, -0.03020131f, -0.18917392f, 0.06598636f, 
    -0.07473194f, 0.02302812f, 0.15226291f, 0.09756998f, -0.02240447f, 0.06011305f, 0.03049952f, -0.13453667f, 
    0.24227847f, 0.12030567f, 0.17297645f, -0.05522949f, 0.02319467f, -0.01452589f, -0.03191725f, -0.14078118f, 
    -0.05162777f, 0.00672211f, -0.09905212f, 0.17163372f, -0.10216033f, -0.02360673f, -0.06599728f, -0.01848500f, 
    -0.04106286f, -0.02584497f, -0.03552962f, -0.01129691f, -0.27079046f, -0.52039587f, 0.25340393f, -0.05238948f, 
    -0.08418193f, -0.09140736f, -0.16856188f, 0.15050019f, -0.08336582f, -0.03593863f, -0.16881782f, 0.12818365f, 
    -0.07892844f, 0.11146019f, 0.04640742f, 0.05914908f, -0.03913923f, 0.08733798f, 0.16650857f, 0.07358434f, 
    -0.00885548f, -0.15531817f, 0.16733111f, 0.01893713f, -0.02345255f, 0.08518134f, -0.00241200f, 0.07016269f, 
    0.09702830f, -0.06912974f, -0.16421498f, 0.04391918f, 0.09781940f, 0.06670219f, 0.17838474f, 0.11524132f, 
    -0.01063807f, 0.18223357f, -0.01414284f, 0.06191752f, -0.31387851f, -0.17539880f, 0.04227967f, -0.07664080f, 
    0.10505843f, -0.04074035f, 0.07453889f, 0.16654961f, 0.06546362f, -0.04151040f, -0.05435737f, -0.10727506f, 
    0.01151304f, -0.00729692f, 0.01039873f, 0.06996419f, 0.14571674f, 0.03565909f, 0.21269926f, 0.23818883f, 
    0.16758548f, -0.17905487f, 0.26418054f, 0.46760905f, 0.12564956f, -0.14062819f, 0.01867244f, 0.07503049f, 
    -0.21991932f, 0.08347153f, -0.20110078f, -0.03415882f, -0.29367235f, 0.16726950f, 0.09536040f, -0.11762419f, 
    -0.25754607f, 0.15463731f, 0.00090353f, 0.22728810f, 0.39425445f, -0.01758130f, 0.28864497f, -0.13867584f, 
    -0.09413534f, -0.04619705f, 0.11040194f, 0.09366611f, 0.23283121f, -0.04009964f, -0.05254240f, 0.14038932f, 
    -0.04928678f, -0.15914325f, -0.31167313f, -0.00382327f, 0.07919277f, 0.19175817f, 0.11669124f, 0.03260750f, 
    -0.38867861f, -0.38904908f, -0.05569374f, 0.10649414f, -0.12366422f, -0.05407048f, -0.03507422f, -0.21679480f, 
    0.22551137f, -0.03125853f, -0.15141976f, -0.06745460f, 0.09279953f, -0.03173874f, 0.01229219f, 0.08822576f, 
    0.11259147f, -0.01832516f, 0.18521515f, 0.05549837f, -0.32057664f, -0.37215826f, 0.21327808f, -0.18605922f, 
    -0.00104017f, -0.03329888f, -0.02668485f, 0.04463156f, 0.08382725f, -0.04307351f, -0.01610167f, 0.12089030f, 
    -0.05326022f, 0.05356495f, 0.02486352f, 0.08823063f, 0.08105414f, 0.07004002f, 0.15420736f, 0.03595393f, 
    -0.39924946f, 0.04345402f, -0.54341459f, 0.31219909f, 0.05703903f, 0.03425690f, 0.24577048f, -0.04692719f, 
    0.20862672f, 0.02139102f, -0.23375718f, -0.20122458f, 0.10668685f, 0.16954817f, 0.07078255f, 0.09029576f, 
    -0.06093962f, 0.16539915f, -0.10651414f, 0.17010966f, 0.02240052f, -0.11613435f, 0.32980633f, 0.07606235f, 
    -0.29832566f, 0.01585679f, -0.03988975f, -0.04413320f, 0.03482607f, 0.04164255f, -0.01777380f, -0.10712635f, 
    0.01353983f, -0.07938247f, 0.18066955f, 0.10224409f, -0.06922255f, -0.06749581f, -0.04066348f, -0.14046423f, 
    -0.51968944f, -0.55596548f, 0.07946598f, 0.19650391f, -0.44693798f, -0.07277770f, 0.17900649f, -0.13157885f, 
    0.29845574f, -0.10257881f, -0.28722540f, -0.03164082f, 0.05558453f, -0.07436089f, 0.12187624f, 0.03171329f, 
    -0.05398274f, 0.16857210f, 0.00335290f, -0.03135051f, 0.06222756f, -0.06623894f, 0.01981937f, 0.12967542f, 
    0.01352532f, -0.07470968f, 0.14861360f, -0.03375822f, 0.00769829f, -0.03229717f, -0.06458656f, 0.09873488f, 
    0.07401779f, -0.08770794f, 0.07121377f, -0.17133203f, -0.06903493f, 0.07262414f, -0.20494331f, -0.18456899f, 
    0.00143674f, -0.26766694f, -0.35898599f, -0.24248336f, -0.06140545f, -0.01110518f, -0.38708985f, -0.03340939f, 
    -0.30627972f, -0.24172878f, -0.01639405f, 0.08928906f, -0.02343899f, -0.05975138f, -0.06105801f, 0.04667955f, 
    -0.06150588f, -0.02280215f, 0.09291305f, -0.04846728f, -0.00838893f, -0.38915926f, -0.01959309f, 0.13974711f, 
    -0.06847423f, 0.03468305f, -0.40352279f, 0.08729104f, -0.08385713f, -0.21596710f, 0.02108025f, 0.08764402f, 
    -0.00326357f, 0.01336634f, -0.01316654f, 0.05151918f, -0.06894229f, 0.09894070f, 0.00860378f, -0.08595557f, 
    0.53897250f, -0.54984188f, 0.18857291f, 0.34078175f, 0.25698328f, -0.10398236f, -0.07826822f, -0.24163513f, 
    0.24375100f, -0.01457446f, -0.07804692f, 0.05832392f, 0.06919158f, 0.03198925f, 0.07724752f, -0.02331098f, 
    0.02704891f, -0.08983954f, 0.29383382f, 0.16373299f, 0.03282392f, -0.10829000f, 0.14990400f, 0.37684423f, 
    -0.08815049f, 0.02457271f, -0.15379168f, 0.17768806f, -0.05331545f, -0.06312753f, 0.07979138f, -0.12121256f, 
    -0.04172131f, 0.07944675f, -0.15870330f, 0.10440418f, -0.10549516f, 0.24332455f, -0.14189300f, -0.12717099f, 
    -0.39406040f, 0.12742177f, -0.22001719f, 0.06979230f, -0.24552925f, 0.12031890f, 0.16569068f, 0.07869896f, 
    -0.08152568f, 0.05037310f, -0.03416837f, -0.10437234f, 0.14659438f, 0.16450237f, -0.03524673f, 0.02990480f, 
    -0.03614471f, 0.02300154f, -0.02047452f, 0.07998572f, -0.12694319f, -0.11434842f, -0.16748139f, -0.05580385f, 
    -0.49713036f, -0.21065839f, -0.24710217f, 0.06809828f, -0.13711354f, -0.04867091f, 0.02198643f, 0.05197275f, 
    0.09298163f, 0.07862023f, 0.00654171f, 0.04354433f, 0.02108128f, 0.02785256f, 0.05608619f, 0.10365807f, 
    -0.31323415f, -0.38860115f, 0.01888395f, 0.14143489f, -0.24133894f, -0.15968576f, -0.14572653f, 0.05509538f, 
    0.09979327f, 0.02172779f, -0.05074833f, -0.05138286f, -0.10768466f, -0.15148859f, -0.01618336f, -0.04713580f, 
    -0.08455254f, 0.08758081f, -0.03710642f, -0.24596821f, 0.40668955f, -0.00267471f, 0.34660807f, 0.06304917f, 
    -0.24629505f, -0.03170684f, -0.08584298f, 0.11463387f, -0.11371018f, 0.00976168f, -0.04540953f, 0.05558227f, 
    -0.07135812f, -0.07769682f, 0.03528386f, -0.01559324f, 0.16108407f, 0.26252139f, 0.09216628f, 0.11144323f, 
    -0.03881470f, -0.13071029f, -0.10855088f, 0.12443356f, 0.01067660f, -0.05392892f, 0.16663726f, -0.08624583f, 
    0.12925072f, 0.06717090f, -0.16101870f, 0.00717555f, 0.09151007f, 0.04852903f, 0.05088652f, 0.07367895f, 
    0.01695438f, 0.01078133f, -0.03053799f, -0.09179571f, 0.25063783f, -0.01419074f, 0.11351348f, 0.07491283f, 
    -0.00909666f, -0.03344788f, 0.21463521f, -0.09900910f, 0.02133506f, 0.01838244f, -0.21958418f, 0.09440613f, 
    -0.04337963f, -0.01548063f, -0.02214894f, -0.11616688f, 0.02243142f, 0.01547498f, -0.20329943f, -0.07406695f, 
    0.41348827f, -0.12288673f, 0.24084413f, -0.16886814f, -0.08102960f, 0.04955312f, -0.01506814f, -0.10657810f, 
    0.03695634f, -0.10960766f, -0.03705102f, 0.06040464f, -0.00693263f, -0.03879267f, -0.03649005f, 0.04799643f, 
    0.14985950f, -0.00631279f, -0.01331924f, 0.06270872f, -0.42925173f, -0.59768480f, -0.32862228f, 0.27633181f, 
    -0.10997789f, -0.07982724f, -0.09791531f, 0.19819902f, -0.22648416f, -0.03500079f, -0.01355023f, 0.01983490f, 
    0.06928928f, 0.01953371f, -0.03199987f, 0.13413224f, 0.01417053f, 0.08467007f, 0.10553586f, 0.04885241f, 
    -0.01630954f, -0.13925250f, -0.15720110f, 0.21291274f, -0.14319183f, -0.11383754f, -0.17952418f, -0.04039775f, 
    -0.14221987f, 0.05541101f, 0.03148733f, 0.00632883f, -0.00281926f, -0.12643258f, -0.17050521f, -0.01846207f, 
    -0.04789972f, 0.04786847f, -0.08018425f, -0.08057241f, -0.14959967f, -0.17057365f, -0.07011355f, 0.05238044f, 
    -0.11116790f, 0.05002059f, -0.12977479f, 0.00922216f, -0.06292867f, 0.08274999f, -0.01698395f, -0.08416794f, 
    -0.04424981f, -0.08868086f, -0.05417325f, -0.08426207f, -0.08426789f, -0.00189315f, -0.03064608f, -0.09784961f, 
    0.12579936f, -0.04570285f, 0.09224273f, -0.10504144f, -0.00396321f, 0.01960183f, -0.02062762f, 0.02913014f, 
    0.05013980f, 0.00387692f, 0.05353746f, 0.00738739f, 0.00250779f, -0.06016204f, -0.09245306f, 0.01093805f, 
    0.08276077f, -0.06323214f, 0.03916490f, 0.00702638f, -0.35010540f, -0.22540851f, -0.24503617f, -0.30061495f, 
    0.26677182f, 0.06267930f, 0.16186816f, 0.07921629f, -0.12284692f, 0.00621228f, -0.11428779f, 0.07947824f, 
    -0.00834946f, 0.18090445f, 0.20140482f, -0.08509587f, 0.01622659f, 0.00643447f, 0.05323872f, 0.01365071f, 
    -0.46839672f, -0.18878886f, -0.47545180f, 0.70847327f, 0.13248830f, -0.07499835f, 0.07531168f, 0.13326859f, 
    0.31036958f, 0.08603997f, -0.17539975f, 0.02569980f, -0.15871276f, -0.12050700f, 0.09396899f, 0.08839190f, 
    0.03577558f, 0.26494133f, -0.03887155f, -0.11653166f, 0.30210349f, 0.13085380f, 0.27471563f, 0.14747404f, 
    -0.21410571f, -0.16236968f, -0.01651755f, -0.04055360f, 0.02891970f, -0.06263267f, -0.03483355f, -0.04805800f, 
    0.07685405f, -0.06923788f, -0.01354571f, 0.16561195f, 0.00129445f, -0.00328394f, -0.06082703f, -0.03103821f, 
    0.36248150f, -0.19988985f, 0.15399222f, -0.10802381f, -0.43984306f, -0.07286572f, -0.01218238f, -0.01001168f, 
    0.00407253f, -0.10061426f, -0.03216239f, 0.09518404f, 0.09712913f, -0.11052936f, -0.11091449f, -0.00099255f, 
    0.14882185f, 0.03601766f, 0.00779388f, -0.13484307f, 0.10660300f, -0.23142134f, 0.44553831f, -0.45321381f, 
    0.36842236f, 0.23759782f, 0.20053253f, -0.15709521f, 0.15950558f, 0.04364276f, -0.05515682f, 0.05171890f, 
    0.02613696f, 0.13000050f, 0.01851710f, 0.08864638f, 0.17242984f, 0.03603895f, -0.14190710f, 0.09224531f, 
    -0.48472103f, 0.04439111f, -0.24588363f, 0.16674300f, -0.37599078f, 0.02770825f, 0.06003217f, -0.01790201f, 
    -0.03310988f, 0.06507915f, -0.07618134f, -0.06313139f, 0.04682621f, -0.05966667f, -0.11499160f, 0.01672045f, 
    -0.02219306f, -0.03759396f, -0.04657438f, 0.01706644f, 0.53788680f, 0.12377311f, 0.53458774f, -0.12444197f, 
    -0.07275350f, 0.16109519f, 0.04317044f, -0.19305730f, 0.00866504f, -0.08321314f, -0.09451719f, -0.02011884f, 
    0.07640064f, -0.03365910f, -0.03154507f, -0.10327310f, 0.02309398f, -0.15198272f, -0.00073171f, 0.07115272f, 
    0.16362277f, 0.03871886f, -0.02054257f, 0.11777611f, -0.01477181f, -0.08019656f, 0.09956359f, -0.07527000f, 
    0.05069849f, -0.02196652f, -0.10654647f, -0.07578681f, 0.06137221f, -0.02914828f, -0.01160147f, -0.03012836f, 
    -0.05896415f, 0.03345274f, -0.04308974f, -0.00914248f, -0.11644974f, -0.23256996f, -0.10346628f, 0.06926525f, 
    0.03134914f, -0.01306372f, -0.08362744f, -0.01244463f, -0.12126942f, -0.01222692f, -0.07790056f, -0.03204979f, 
    -0.20245406f, -0.06767204f, -0.15139848f, -0.07323456f, -0.11100014f, 0.02349405f, -0.28596020f, -0.37026164f, 
    0.06036848f, -0.30620852f, 0.06817164f, 0.10596268f, -0.25645190f, -0.09764782f, 0.00544959f, -0.00896002f, 
    0.22199209f, 0.00766822f, 0.00923446f, 0.08108363f, 0.01081808f, 0.07419450f, -0.05207044f, -0.04374701f, 
    -0.06040285f, 0.10952277f, 0.15869401f, -0.10530295f, -0.55859482f, 0.14143589f, -0.31430775f, 0.40589756f, 
    0.14567001f, -0.03032729f, 0.01739528f, -0.16043355f, -0.02130040f, 0.09487706f, 0.00907105f, 0.06793902f, 
    -0.01436741f, -0.07165118f, -0.01411665f, 0.02896195f, -0.07572702f, -0.02594073f, 0.03798047f, 0.02511289f, 
    0.37736562f, -0.10312437f, 0.15287477f, 0.15821281f, -0.04960986f, -0.00291999f, 0.16009097f, -0.04613058f, 
    0.08780121f, -0.19951318f, -0.02942144f, -0.00267709f, -0.03436468f, 0.00787030f, 0.11608665f, -0.14172617f, 
    -0.04500472f, 0.05428658f, -0.04554670f, -0.08773245f, 0.15723729f, -0.15897930f, 0.12037101f, -0.18993120f, 
    0.22047715f, 0.18252282f, 0.16468967f, -0.06553505f, -0.00145816f, -0.10063363f, -0.05903774f, -0.01862372f, 
    -0.01041942f, 0.02966487f, 0.05744439f, 0.05818068f, -0.00099759f, -0.06138403f, -0.20548154f, -0.00198540f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22362530f, 0.07809239f, 0.04825069f, -0.07231609f, -0.03612559f, 0.01107824f, 0.06469787f, -0.12716497f, 
    0.08893976f, 0.00665863f, 0.02917255f, -0.00364764f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
