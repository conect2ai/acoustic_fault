#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.56555527f, -0.55302721f, -0.57854360f, 0.52344239f, 0.02506026f, 0.16529410f, 0.40461779f, 0.46869528f, 
    0.27699044f, 0.60063988f, -0.25542450f, 0.05186565f, 0.48973289f, 0.48965555f, 0.24549867f, -0.26919794f, 
    0.36340773f, -0.02892096f, -1.07964087f, -0.89851636f, -0.16981505f, 0.66562116f, 0.87442064f, -0.02346215f, 
    0.11935804f, -0.45584276f, 0.13408904f, -0.53512365f, 0.35112020f, -0.34585431f, 0.74494565f, -0.32305184f, 
    -0.63770241f, 0.23786624f, -0.27656296f, 0.63903344f, 0.57563359f, -1.22014976f, 0.67960584f, 0.55076301f, 
    0.60704559f, -0.63128960f, -0.10079394f, -0.17917183f, -0.29917970f, -0.91346776f, 0.23830095f, 0.93645436f, 
    -0.65612978f, 0.10848353f, 0.24172662f, 0.51256281f, -0.17289646f, -0.36696362f, 0.34579068f, 0.26936519f, 
    0.21384282f, 0.05984495f, -0.40685612f, 0.54358137f, -0.12182429f, -0.29789215f, -0.40813258f, 0.68626237f, 
    0.56852221f, -1.04540980f, 0.02354757f, 0.66764444f, -0.09147143f, 0.01463447f, -0.11679190f, -0.46147230f, 
    0.28451020f, -0.10309612f, 0.59447062f, -0.57506794f, -0.06296548f, -0.13632990f, 0.46476027f, -0.28027159f, 
    0.45377403f, -0.51174456f, -0.55269140f, 0.84314090f, -0.07060786f, 0.55550230f, -0.19552606f, 0.04463330f, 
    -0.16627622f, 0.28073186f, -0.66317952f, -0.15046677f, -0.09634024f, -0.69531351f, -0.31050172f, -0.38382885f, 
    -0.23757496f, -0.57388628f, -0.77913529f, -0.63875735f, -0.24668208f, -0.68737638f, -0.38623840f, -0.11778080f, 
    -0.64221585f, -0.34840214f, -0.42740887f, -0.52429926f, 0.39047870f, -0.35751686f, 0.15323091f, -0.00470941f, 
    0.13728911f, 0.21715035f, 0.13731058f, 0.31804726f, 0.07257447f, 1.24446464f, -1.04657817f, -0.36996168f, 
    0.22165504f, 0.45360598f, -0.30268776f, -0.56278670f, -0.21799630f, 0.49823904f, -1.47389758f, 1.27282596f, 
    -0.17269100f, -0.25661430f, 0.18048923f, 0.48255149f, 0.11699742f, -0.36667800f, -0.09347037f, 0.33071586f, 
    -0.58863980f, 0.29413921f, 0.05987072f, 0.01677012f, 0.04419158f, -0.33955181f, -0.09445038f, 0.49788964f, 
    -0.84621054f, -0.04455020f, 0.29915047f, -0.79875338f, -0.49061900f, -0.65000397f, 0.33074850f, 0.45428112f, 
    -0.01612968f, 0.44289801f, -0.57673436f, 0.26536998f, -0.04028781f, -0.11241920f, -0.05767990f, 0.22157240f, 
    0.21980073f, 0.14524211f, -0.25342822f, 0.79228532f, -0.53485209f, 0.04666747f, 0.08022124f, -0.09138525f, 
    -0.30815998f, 0.56350082f, -0.21683671f, 0.01050820f, 0.46037906f, 0.62531853f, -0.60644537f, -0.48536101f, 
    0.55276740f, 0.21709985f, -0.21303730f, -0.02593343f, 0.85070574f, 0.51360226f, 0.24846506f, 0.28238142f, 
    -0.55803955f, -0.58366901f, -0.33631259f, -0.01042166f, 0.29132792f, -0.43042719f, 0.14184646f, 0.74870634f, 
    -0.22974505f, -0.88258994f, -0.23176236f, 0.09336170f, 0.35908389f, 0.50296986f, 0.45539895f, 0.87684989f, 
    0.17252895f, -0.39623502f, -0.53880841f, -0.41969469f, -0.35331482f, 0.26829478f, 0.23358689f, -0.35652530f, 
    0.05676838f, 0.32492983f, 0.80221587f, -0.16578616f, -0.59847093f, 0.05990114f, 0.59955579f, -0.58139437f, 
    -0.58198434f, -0.88189816f, -0.29838830f, -0.06334671f, 0.70985955f, -0.00077531f, 0.21070027f, -0.08650284f, 
    -0.43308625f, 0.55139768f, -0.59849143f, 0.49143443f, -0.91498005f, 0.16469233f, 0.73108721f, -0.17494138f, 
    -0.10651116f, -0.14131634f, -0.61011857f, -0.56641442f, -0.39799222f, 0.45463869f, 0.21200861f, -0.15496917f, 
    -0.46423754f, 0.27531108f, 0.46373358f, -0.04218458f, -0.50467223f, -0.03246767f, 0.17172429f, -0.45515415f, 
    0.48445708f, 0.08736906f, 0.24360457f, 0.22322941f, -0.92982900f, 0.03662156f, 0.74536860f, -0.20738082f, 
    0.03225989f, 0.50279099f, -0.34883782f, 0.24792157f, 0.21498285f, -0.02521661f, 1.16526937f, -0.44017825f, 
    -0.69532067f, -0.74351001f, -0.46208909f, -0.06054667f, -0.67608833f, 0.20605798f, 0.10351012f, 0.35631853f, 
    0.02424425f, 0.57756150f, 0.52606803f, 0.35198656f, -0.02367065f, 0.01632551f, 0.07437795f, -0.53429121f, 
    -0.40788144f, -0.57242531f, -0.43394077f, -0.67426187f, -0.56367916f, 0.69328219f, 0.22460060f, 0.06889658f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08155633f, 0.11990152f, -0.07286119f, -0.01892917f, 0.13821629f, -0.00476373f, 0.18379253f, 0.20648730f, 
    -0.10519885f, -0.10058506f, -0.00136644f, -0.31671685f, -0.15411524f, 0.32427567f, 0.10275961f, 0.15003578f, 
    0.05717831f, -0.24787673f, -0.03908953f, 0.16208696f, -0.00761141f, -0.22256897f, 0.01340861f, 0.08691683f, 
    0.04892277f, 0.14759217f, 0.28753909f, 0.14875785f, -0.18239261f, 0.14348724f, -0.30964282f, 0.03512123f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01286272f, -0.00867388f, -0.01997651f, -0.02129643f, -0.01625078f, 0.00424713f, -0.00660172f, -0.03573578f, 
    -0.00546304f, -0.02874047f, 0.00461537f, 0.02267012f, -0.04047962f, 0.02492945f, -0.01580953f, 0.01527671f, 
    0.02343065f, -0.00665795f, -0.03960714f, -0.03366248f, 0.00153040f, -0.03135826f, 0.00412655f, 0.00175338f, 
    -0.02007823f, -0.01078789f, 0.02672713f, -0.01322972f, -0.03362821f, -0.01939440f, 0.03171805f, 0.00214410f, 
    -0.02289782f, -0.03334066f, -0.03214810f, -0.01607011f, -0.03989388f, -0.03462518f, -0.03242932f, 0.00299502f, 
    -0.00038334f, 0.00485797f, -0.03694172f, -0.00054454f, -0.02806013f, -0.03798588f, -0.02422221f, -0.04445135f, 
    -0.01604292f, -0.00249228f, -0.04395530f, 0.02736335f, 0.01791843f, -0.02127410f, -0.02272015f, 0.00696569f, 
    0.02660911f, -0.02442812f, -0.03714164f, -0.01375206f, -0.01654601f, -0.01527999f, 0.02815699f, -0.02932855f, 
    0.01620690f, 0.00548185f, -0.00395776f, -0.04182420f, -0.01476325f, -0.02249028f, -0.04396590f, -0.00542736f, 
    0.02275984f, -0.01192554f, 0.00905735f, 0.00332925f, -0.00982243f, 0.02629804f, -0.03937321f, 0.02280971f, 
    -0.03254166f, -0.03162758f, 0.00252067f, -0.03921939f, 0.01232849f, -0.03881510f, 0.00280591f, 0.00157257f, 
    0.01508880f, -0.00812311f, 0.00756437f, -0.00283031f, 0.01615788f, 0.00200483f, -0.02020786f, -0.04332169f, 
    0.00602622f, -0.02598512f, -0.03367572f, 0.02411137f, 0.00236613f, -0.04232570f, -0.03135207f, -0.01523785f, 
    -0.01562329f, 0.02284472f, -0.02091546f, -0.04205896f, -0.02470408f, -0.02539138f, 0.00672922f, 0.02111696f, 
    0.01144350f, 0.01891381f, 0.03265348f, 0.03039385f, 0.02644170f, -0.00433611f, -0.00143962f, -0.01569620f, 
    -0.01334236f, 0.02294082f, -0.03172453f, -0.02464365f, -0.03699294f, -0.01483078f, 0.02537196f, -0.04333881f, 
    -0.00100489f, -0.00669549f, 0.01902405f, -0.01430838f, 0.00486179f, -0.01524115f, 0.01751767f, -0.00230971f, 
    -0.00257282f, -0.02708646f, -0.02935723f, -0.01448554f, -0.04380289f, 0.00050774f, 0.02970510f, 0.02217189f, 
    0.02715666f, 0.02038144f, -0.03276381f, -0.01539645f, -0.01370922f, -0.04061698f, -0.02864460f, -0.00850298f, 
    0.01890303f, 0.02985642f, -0.01381667f, 0.01531940f, 0.02411150f, -0.03349766f, -0.02820441f, -0.00301925f, 
    0.03765331f, 0.02990231f, 0.03614619f, 0.00302924f, 0.02557339f, -0.00842386f, 0.00917821f, -0.04150795f, 
    0.02063758f, -0.00205354f, -0.03039539f, 0.02682993f, -0.03960513f, -0.04490907f, -0.02826709f, -0.02991655f, 
    -0.00233670f, -0.00003603f, 0.03127279f, -0.00298357f, 0.02555995f, 0.00869706f, -0.02748824f, -0.03146638f, 
    -0.00978764f, -0.00512384f, 0.01262486f, 0.01176716f, -0.01984510f, -0.01540517f, -0.01157704f, 0.00729207f, 
    -0.00510553f, 0.02602575f, -0.01056302f, -0.01263873f, 0.00156059f, -0.03292219f, -0.03953517f, 0.00411833f, 
    -0.00003650f, -0.02754182f, -0.02918641f, 0.01429000f, -0.03743088f, -0.01218930f, 0.02656835f, -0.03730175f, 
    -0.00787775f, -0.04416089f, -0.00592661f, 0.00305415f, -0.01831559f, 0.00326960f, 0.01933406f, 0.00849217f, 
    -0.02193854f, -0.02978809f, 0.00540158f, 0.01829492f, 0.01512149f, -0.00476548f, 0.00009692f, -0.01873644f, 
    -0.00365238f, -0.02104263f, 0.02528254f, 0.02007382f, -0.02879529f, -0.01317842f, 0.03213284f, -0.03754899f, 
    0.02440391f, -0.04173280f, -0.04102795f, -0.01742621f, 0.01948558f, 0.00729435f, -0.03708976f, -0.03145546f, 
    0.01265204f, 0.03939002f, 0.00861600f, -0.00786415f, 0.03521131f, 0.01161952f, -0.04018671f, -0.00862589f, 
    -0.00006789f, 0.02087466f, 0.01714501f, 0.01838898f, 0.02239199f, -0.02180914f, 0.02331774f, -0.00860420f, 
    -0.03188610f, -0.00401472f, 0.00110659f, 0.01861052f, 0.02289817f, -0.04449390f, -0.04426463f, 0.01018401f, 
    0.00126881f, -0.03547019f, -0.00666640f, -0.03702856f, -0.00958330f, 0.02337083f, 0.00199835f, 0.00280184f, 
    0.01778267f, -0.01835340f, 0.01174217f, -0.01146183f, -0.04256970f, -0.03879442f, 0.01589619f, -0.02873302f, 
    -0.00026784f, 0.01356525f, 0.02216889f, -0.03513821f, -0.02862708f, -0.01607750f, -0.03321457f, -0.00089367f, 
    -0.03448643f, -0.01647533f, -0.04452120f, 0.02519785f, 0.02515382f, -0.03773791f, 0.00631544f, 0.02448301f, 
    -0.03394746f, 0.01935866f, -0.00979298f, -0.04217203f, 0.03226674f, -0.00726343f, -0.03540003f, -0.03285879f, 
    -0.02126917f, -0.02286997f, -0.00940141f, -0.00688973f, -0.03699373f, -0.01004287f, -0.01549208f, -0.03974947f, 
    -0.01154888f, -0.00321924f, -0.01888796f, 0.01467704f, -0.04001229f, -0.02854768f, -0.03869698f, 0.00364412f, 
    -0.04241003f, -0.02072599f, -0.03325547f, -0.04353955f, 0.01791896f, 0.01190407f, -0.04494475f, -0.02100196f, 
    -0.01398116f, 0.01937261f, 0.01348497f, -0.03287450f, -0.03944734f, 0.01285072f, 0.02691509f, 0.02320368f, 
    -0.01186429f, -0.00267832f, 0.02758777f, -0.00674188f, 0.01662837f, 0.03141976f, -0.02249506f, 0.00450743f, 
    -0.01109716f, -0.03308478f, -0.01993608f, -0.03680923f, 0.02435167f, -0.02116664f, -0.00737926f, -0.00643500f, 
    -0.03634743f, -0.01011420f, 0.00495289f, -0.03203114f, -0.03602653f, -0.01151153f, 0.02125102f, -0.03010608f, 
    -0.01860334f, -0.01913656f, -0.01275426f, 0.02788999f, -0.01898248f, 0.02518335f, -0.00402027f, 0.01427055f, 
    0.01248911f, -0.00702589f, 0.02571801f, 0.00460159f, -0.00488035f, 0.02300439f, -0.04369669f, -0.01415220f, 
    -0.01399105f, 0.00235282f, -0.02476709f, -0.03656544f, -0.01809205f, 0.02030443f, 0.00109218f, 0.02375348f, 
    -0.01703054f, -0.03952999f, 0.02882173f, -0.02851203f, -0.02187713f, -0.01112472f, -0.03624758f, 0.00450472f, 
    0.01865015f, -0.03163698f, -0.02285722f, -0.01940887f, -0.01361733f, -0.03337808f, -0.04052178f, -0.00821722f, 
    -0.02555455f, 0.02507719f, -0.04490822f, 0.00330800f, -0.02053335f, 0.02474105f, -0.00869575f, 0.01123132f, 
    0.00786466f, -0.02032951f, 0.01893092f, 0.01242655f, 0.02356749f, 0.00583446f, -0.00916989f, -0.02432422f, 
    -0.02185998f, -0.00356592f, -0.01035410f, -0.01298241f, 0.01811641f, -0.00792567f, -0.00446364f, -0.01048596f, 
    0.00120979f, 0.00913135f, 0.00220454f, -0.02829399f, 0.03183307f, 0.00999353f, -0.01631303f, 0.01422361f, 
    -0.02852177f, -0.00370225f, -0.04525053f, -0.03722504f, 0.00782408f, 0.02776291f, 0.03548783f, 0.01042127f, 
    -0.03385285f, 0.01560973f, -0.02452861f, 0.00438354f, -0.02917414f, -0.02789022f, 0.03031955f, -0.01303486f, 
    0.00915368f, 0.00437732f, 0.01108272f, -0.01439062f, -0.00632788f, -0.01624552f, -0.04561036f, -0.03218152f, 
    -0.03075444f, 0.01729237f, -0.02487891f, -0.03124949f, -0.02178851f, -0.02850133f, -0.03639216f, -0.01224674f, 
    0.03207174f, -0.00988345f, -0.04066687f, 0.00387259f, -0.00880160f, -0.01661160f, -0.04215831f, 0.01056805f, 
    0.01292397f, -0.02315351f, -0.02241931f, -0.00944355f, -0.00178929f, 0.02246084f, -0.01256199f, 0.01803264f, 
    -0.03453119f, -0.01614364f, -0.01010859f, -0.04141679f, 0.02609723f, 0.00182764f, 0.01855243f, 0.00476477f, 
    -0.01805864f, 0.01403226f, -0.01236773f, -0.01102230f, 0.00809724f, -0.02843884f, -0.02738313f, 0.01875355f, 
    -0.03390480f, -0.01897884f, -0.00474494f, -0.02627794f, -0.01687582f, -0.02750403f, 0.02071040f, -0.00960944f, 
    -0.01538270f, -0.01265405f, 0.02433035f, 0.02098929f, -0.02999817f, -0.01183562f, -0.03918165f, -0.01431420f, 
    0.00091922f, -0.00849588f, 0.00687407f, -0.01541370f, 0.01494013f, 0.01285355f, 0.02471581f, -0.01389434f, 
    -0.04260008f, -0.04484163f, 0.00121814f, 0.01530483f, 0.00284693f, -0.01770701f, -0.01781514f, -0.03650026f, 
    -0.00891469f, 0.00988449f, 0.02122381f, 0.01239808f, 0.00979761f, 0.01132668f, -0.03501980f, -0.03104657f, 
    -0.01847597f, 0.02731476f, -0.02341059f, -0.04336746f, 0.01989136f, -0.02507102f, -0.02200320f, -0.00144948f, 
    0.02282725f, -0.04577089f, 0.01335596f, 0.01507651f, 0.02886171f, -0.02507350f, 0.02339285f, -0.02826859f, 
    0.00394988f, 0.02500608f, -0.02519477f, -0.01443598f, 0.00853566f, -0.02979730f, 0.00112470f, 0.00320698f, 
    0.03086325f, 0.01219696f, -0.00344104f, -0.02212786f, -0.02965923f, -0.02804657f, 0.02637133f, 0.00005487f, 
    0.02829626f, 0.02269865f, 0.03323460f, -0.02552732f, -0.01601589f, -0.00789455f, 0.01025400f, -0.03646294f, 
    -0.00874752f, 0.00968165f, 0.01874827f, -0.03233968f, -0.03915934f, -0.02864582f, 0.02595812f, 0.02769324f, 
    -0.01965616f, 0.00010674f, -0.00744623f, 0.01975504f, 0.00540087f, -0.02112352f, -0.02803020f, 0.03197473f, 
    0.02327804f, -0.02761132f, -0.02399719f, 0.00204457f, -0.02744254f, -0.03022500f, -0.04431979f, -0.00581431f, 
    0.02174488f, -0.03722973f, -0.00455796f, -0.04114665f, -0.03058695f, -0.03725830f, 0.00616635f, -0.01864344f, 
    0.03779453f, -0.01604500f, 0.01485186f, 0.02723167f, 0.00757948f, -0.00296574f, -0.01373692f, -0.03678988f, 
    0.01666564f, 0.02883262f, -0.03625802f, -0.01095404f, -0.03848743f, -0.04327500f, 0.02489231f, 0.01026308f, 
    0.02792774f, -0.03602962f, 0.02678014f, -0.01855840f, -0.02151402f, -0.01392788f, 0.00677154f, 0.01657181f, 
    -0.03531510f, -0.01626077f, -0.03368995f, 0.03390534f, 0.02399011f, -0.03467768f, -0.02841821f, 0.00403076f, 
    -0.03092230f, 0.01674239f, 0.01581050f, -0.04536001f, -0.01744341f, -0.00681564f, 0.02780740f, 0.02951498f, 
    0.00497586f, 0.02425483f, 0.02271390f, -0.00700162f, -0.02803836f, 0.01539144f, -0.02792923f, -0.03667117f, 
    0.01190225f, -0.04388725f, 0.02024521f, 0.00349220f, 0.01558021f, -0.03236152f, -0.03549524f, -0.02313282f, 
    -0.02410896f, 0.00558878f, 0.00080729f, 0.00428413f, -0.01033310f, 0.03069183f, -0.00971170f, -0.00398375f, 
    -0.00466267f, -0.00198620f, -0.03053616f, 0.02113817f, -0.03188869f, -0.00722021f, 0.00551924f, -0.01163442f, 
    0.02129299f, 0.02894028f, -0.02297575f, -0.00695767f, 0.02739789f, -0.02970313f, 0.01238398f, -0.00723619f, 
    0.02715684f, 0.03710481f, 0.03350503f, 0.02120252f, 0.02904193f, -0.03493789f, 0.02461141f, -0.03505722f, 
    0.03120866f, -0.03422989f, -0.00247625f, -0.01721360f, 0.00037193f, -0.03060620f, 0.00461509f, 0.01575163f, 
    -0.02179550f, -0.01588549f, -0.03165734f, -0.02292716f, 0.00357395f, -0.01115401f, 0.00720503f, -0.03857324f, 
    -0.03866927f, -0.00843736f, 0.00044763f, -0.01122665f, -0.02279289f, -0.02512291f, 0.01901299f, -0.00658380f, 
    0.01794472f, 0.01944778f, 0.02222293f, 0.00617562f, -0.02707863f, 0.00468486f, -0.03210275f, -0.01933814f, 
    -0.04392248f, -0.02530806f, -0.00265112f, 0.01955786f, -0.03303926f, -0.03027004f, -0.03465033f, 0.03137470f, 
    0.03249664f, -0.01009592f, 0.01433558f, -0.03777020f, 0.01866145f, 0.02993698f, -0.02695353f, -0.00381252f, 
    0.01535719f, 0.00586166f, -0.00952135f, 0.00668309f, 0.00408227f, -0.01251746f, -0.04122891f, 0.00196457f, 
    0.00181996f, -0.01814214f, 0.00043783f, 0.02263745f, -0.03516998f, -0.03991310f, -0.01660929f, 0.02999098f, 
    -0.03390583f, 0.02294682f, -0.03387099f, -0.00820750f, -0.02099080f, 0.01881496f, -0.02483289f, 0.02875072f, 
    -0.03430710f, -0.02497766f, -0.01689664f, -0.00066741f, -0.03705906f, 0.01048062f, -0.03169226f, 0.01603772f, 
    -0.01988328f, -0.00592163f, 0.00113137f, -0.00326185f, 0.00101858f, 0.02763978f, -0.00872384f, 0.00681295f, 
    -0.01807511f, -0.00743617f, 0.00135303f, 0.02222602f, -0.03774801f, -0.00486637f, -0.04542556f, 0.02875976f, 
    0.00563280f, -0.01304772f, -0.02414811f, 0.00817383f, -0.02237709f, -0.03104866f, -0.03739595f, -0.02418372f, 
    0.02751934f, -0.00034324f, 0.00935233f, 0.00282815f, 0.01605067f, 0.00683059f, -0.04331258f, 0.00789328f, 
    -0.02724804f, -0.01794483f, 0.02321199f, -0.04326911f, 0.02282562f, -0.01135423f, -0.02686926f, 0.03072679f, 
    -0.03817134f, -0.02220866f, 0.00316784f, -0.03745236f, 0.01035310f, -0.02711081f, 0.02239034f, 0.02518239f, 
    -0.04007229f, 0.00979655f, -0.03936723f, -0.03229623f, -0.00602767f, -0.04200596f, 0.01862709f, 0.00222095f, 
    -0.01105277f, 0.02828402f, -0.01128377f, -0.03030865f, -0.02063630f, 0.01323764f, 0.00125113f, 0.01887263f, 
    0.02259237f, -0.03273722f, 0.03134986f, -0.02071563f, -0.01073244f, 0.00559851f, -0.04340726f, 0.01925949f, 
    -0.02546722f, 0.03209267f, -0.03456244f, 0.01937928f, -0.01849685f, -0.02013159f, -0.04541389f, -0.03352503f, 
    -0.03037932f, 0.01400175f, 0.03020592f, -0.02141923f, -0.01997877f, -0.00673673f, -0.00388606f, 0.02707717f, 
    0.02801709f, -0.01894188f, -0.00112062f, 0.00303529f, -0.02799278f, 0.01939825f, 0.02719081f, 0.03009562f, 
    0.01184400f, -0.01130421f, 0.01151361f, 0.01095217f, 0.02716873f, 0.00848215f, 0.02029175f, -0.00647499f, 
    -0.00248881f, 0.01963052f, 0.02115559f, 0.00635113f, -0.01785783f, 0.00666678f, 0.01662362f, 0.01979570f, 
    0.01619204f, -0.01369875f, -0.03858169f, -0.00401089f, 0.00051812f, -0.01871990f, 0.00019777f, 0.03878840f, 
    0.00689276f, -0.03020659f, 0.00408067f, -0.02159806f, -0.01475854f, -0.03048890f, 0.01322453f, 0.02487218f, 
    -0.01293259f, 0.00028935f, -0.00529875f, 0.02071290f, 0.01557914f, -0.03943113f, -0.00663610f, -0.02400057f, 
    -0.01362401f, -0.03038261f, -0.03602657f, -0.02818528f, -0.01273519f, -0.00576568f, -0.03890337f, 0.00023878f, 
    -0.02044050f, -0.03616291f, 0.02202290f, -0.00201908f, -0.01810945f, -0.01456487f, -0.03400547f, -0.00310034f, 
    -0.04373062f, 0.00807550f, -0.01538781f, 0.02606406f, 0.00497875f, 0.00420901f, 0.01893457f, -0.01139532f, 
    -0.03884222f, -0.03482834f, 0.00781521f, -0.02386252f, 0.00872910f, -0.00598738f, -0.01135660f, 0.01559914f, 
    -0.03783077f, -0.03449414f, -0.02224433f, -0.03672174f, -0.03738325f, 0.02741270f, -0.01365651f, 0.00509470f, 
    -0.02364404f, -0.02296874f, -0.04223381f, -0.00833851f, 0.03283230f, -0.02770801f, 0.01310735f, 0.01966091f, 
    -0.02909521f, -0.03376701f, 0.02152856f, -0.03883927f, -0.00251275f, 0.00824568f, -0.03574163f, -0.03988801f, 
    -0.03582236f, -0.02105947f, -0.01180522f, 0.02071165f, 0.01977495f, -0.02812892f, -0.03803293f, -0.00500053f, 
    0.01369168f, -0.03665866f, 0.02163851f, 0.01160325f, -0.03613387f, -0.01370292f, -0.00365145f, 0.03066147f, 
    0.02763654f, -0.03312728f, 0.02834896f, -0.03487241f, -0.00508514f, 0.02064078f, -0.02146986f, 0.02487338f, 
    -0.02599100f, -0.02419139f, -0.03536586f, -0.00824157f, 0.00246086f, -0.02232126f, -0.00705587f, -0.02201138f, 
    0.00752763f, -0.00767984f, 0.03562989f, -0.01475876f, -0.04299807f, -0.03021333f, -0.03271973f, -0.01029918f, 
    0.02874715f, 0.01898839f, 0.03003442f, -0.00066099f, -0.02279958f, -0.03969793f, -0.00161410f, 0.00763034f, 
    0.00815647f, -0.02682430f, -0.02121309f, 0.01168412f, 0.01210956f, 0.02317784f, -0.01405007f, 0.02752831f, 
    0.00040751f, -0.02842109f, -0.00499649f, -0.04545854f, -0.04052889f, 0.01874829f, 0.03140308f, -0.04221170f, 
    0.00889444f, -0.02875988f, 0.00292705f, 0.01693495f, -0.01004549f, 0.00993147f, 0.01129155f, 0.03108888f, 
    -0.00723465f, 0.00080590f, -0.00186090f, -0.03623515f, -0.00871465f, -0.03005491f, -0.03795357f, 0.01706902f, 
    -0.01968548f, 0.00025130f, 0.02535621f, 0.03009966f, -0.01778065f, 0.00271136f, -0.02885720f, 0.02206637f, 
    0.02532674f, -0.03414957f, 0.02731980f, -0.02836433f, -0.00250535f, 0.02446086f, -0.00785325f, 0.01584451f, 
    0.03333624f, 0.02306441f, -0.03379119f, -0.02965660f, -0.02570510f, -0.01246910f, -0.04357178f, 0.00795817f, 
    -0.02789738f, 0.00236251f, 0.00730645f, 0.01307745f, -0.00291187f, -0.03561461f, -0.00389645f, -0.01494910f, 
    -0.02500593f, -0.00100740f, -0.00593298f, -0.00784105f, 0.00439071f, -0.04449942f, -0.02022130f, 0.01230241f, 
    0.01388438f, -0.03390087f, -0.04273435f, -0.00686756f, -0.02866725f, 0.01228337f, -0.04518510f, 0.02504631f, 
    0.02364679f, -0.04427126f, -0.02414259f, -0.04035045f, -0.03419559f, -0.00555502f, -0.03387225f, 0.00259939f, 
    -0.02317729f, -0.01392272f, -0.02642969f, -0.02700499f, -0.03977981f, 0.00686501f, -0.02340124f, 0.02681980f, 
    -0.01343585f, 0.00928743f, -0.03167263f, 0.02475563f, 0.01093734f, 0.02210879f, 0.00511886f, -0.02471649f, 
    -0.04101280f, 0.03038761f, -0.04351540f, 0.03059060f, -0.04258436f, -0.02140768f, -0.01566092f, -0.02875959f, 
    -0.03249528f, -0.03749524f, 0.01473831f, -0.03240670f, -0.02107297f, -0.00311700f, -0.04538411f, -0.03485509f, 
    -0.02371326f, 0.02924769f, 0.00833514f, -0.00137817f, -0.04036729f, -0.03126718f, -0.00936363f, 0.02598771f, 
    0.03145509f, -0.01076551f, -0.01904861f, -0.00219303f, -0.03369733f, 0.02253480f, 0.01418296f, 0.01967223f, 
    0.01400671f, -0.03591386f, 0.00889361f, -0.01904249f, 0.00213180f, 0.01936227f, -0.01224283f, 0.03221756f, 
    0.01794017f, 0.00537450f, 0.01347862f, -0.00839683f, 0.00778530f, -0.03680885f, 0.01953345f, -0.04037371f, 
    -0.04459843f, -0.04062600f, -0.01666155f, -0.00570832f, 0.02793576f, -0.03346642f, -0.02628338f, 0.02334538f, 
    -0.00082342f, 0.01566100f, 0.01153904f, -0.00728662f, 0.02996878f, -0.01287578f, 0.00446542f, 0.02961683f, 
    0.01737957f, 0.00025859f, -0.00159997f, -0.00748574f, -0.01983279f, -0.01032354f, 0.02628089f, 0.00474609f, 
    0.00716541f, -0.04511115f, -0.04148842f, -0.04406192f, -0.04332174f, -0.01582262f, 0.03161287f, -0.02452266f, 
    -0.03952063f, -0.02307629f, -0.01458211f, -0.02951698f, 0.00678514f, -0.03266298f, 0.02694437f, -0.00639827f, 
    0.02869654f, -0.01836158f, 0.03245984f, 0.01710079f, 0.00650732f, -0.00139948f, 0.00462742f, -0.01342224f, 
    -0.00689873f, -0.03654664f, -0.02602596f, 0.01423655f, -0.01840575f, 0.00827932f, -0.03848571f, 0.00054340f, 
    0.02225067f, 0.01670860f, -0.02661495f, 0.01300748f, 0.02570473f, 0.01445265f, 0.01968149f, -0.03729562f, 
    0.02086849f, -0.01325142f, -0.03960649f, -0.00688139f, 0.01131245f, 0.00320030f, -0.02350409f, -0.03639164f, 
    -0.03368580f, -0.01721438f, 0.02121874f, 0.01677150f, 0.00479811f, 0.02444490f, 0.03925473f, -0.01846767f, 
    0.01865487f, 0.03666401f, -0.01148744f, 0.02920273f, 0.02896258f, 0.01200195f, -0.01405148f, 0.03351527f, 
    0.02218798f, -0.03783761f, 0.02987982f, 0.01627853f, -0.01641227f, -0.02878568f, -0.04242659f, 0.00723027f, 
    -0.00539827f, -0.03224735f, 0.02671521f, 0.03028065f, 0.03397869f, 0.01686103f, -0.04257107f, -0.01023130f, 
    0.00756925f, -0.04168041f, 0.02168289f, -0.00445617f, -0.00706507f, 0.01962403f, -0.03386109f, -0.00259691f, 
    0.09790643f, 0.18266204f, -0.04058593f, 0.02250708f, -0.10021655f, -0.02531215f, 0.03703677f, -0.07520996f, 
    0.00224582f, 0.04519835f, 0.09584346f, 0.01858394f, 0.02636931f, 0.00041796f, 0.01535087f, 0.08744327f, 
    0.09550665f, 0.00940248f, -0.08949017f, -0.00349004f, 0.16759713f, -0.10958065f, -0.17179137f, -0.08631285f, 
    0.01106656f, -0.03646978f, -0.10596452f, -0.11889759f, -0.13386314f, -0.03941636f, 0.04495009f, 0.05344044f, 
    0.01044536f, -0.04206372f, 0.03600944f, 0.06221822f, 0.02538848f, 0.11557440f, -0.00761205f, 0.03560049f, 
    0.00382243f, 0.05309473f, 0.12386258f, 0.09920280f, 0.05619851f, -0.05668796f, 0.01481566f, 0.07054319f, 
    -0.07174104f, 0.00042476f, 0.08364194f, 0.02989084f, -0.11913726f, -0.03881165f, -0.03785081f, -0.02843632f, 
    -0.02411402f, 0.02786049f, -0.07329736f, -0.04384686f, 0.08544848f, 0.37292105f, 0.24438418f, 0.16191511f, 
    0.04967863f, 0.09041561f, -0.10589439f, 0.04343328f, 0.17046836f, 0.08488704f, 0.13305737f, -0.00209495f, 
    -0.03997197f, 0.07213379f, 0.01521799f, 0.12479438f, -0.00163966f, -0.15091832f, -0.12823908f, 0.11601616f, 
    0.59084374f, -0.33423477f, 0.01780710f, -0.32451943f, 0.19274561f, 0.02744030f, 0.03373789f, -0.03037263f, 
    0.07379621f, 0.03456716f, 0.02513328f, 0.13849619f, -0.05978184f, -0.03268608f, 0.05409004f, -0.01705525f, 
    -0.05934308f, -0.02893016f, 0.28112763f, 0.09761599f, -0.44681886f, -0.35039330f, 0.11657350f, 0.39170071f, 
    -0.21297748f, -0.01325573f, -0.17515476f, -0.04797248f, 0.10887685f, 0.13450190f, 0.08967681f, -0.03774136f, 
    -0.13409150f, 0.01027199f, 0.05925846f, 0.14930433f, -0.05157850f, 0.07947396f, -0.17384706f, -0.04574577f, 
    0.13159490f, 0.02791774f, -0.26417792f, -0.03618658f, 0.11171050f, -0.02847352f, -0.01377458f, -0.14729680f, 
    -0.03889554f, 0.03349966f, 0.03970996f, 0.00108790f, -0.05431399f, 0.01018027f, 0.01118091f, -0.08053014f, 
    -0.14070976f, -0.03747323f, 0.09168763f, 0.09575300f, 0.35192874f, 0.03186913f, -0.17088470f, -0.35495925f, 
    -0.11304075f, 0.05598154f, -0.18300289f, -0.04929807f, -0.17679441f, 0.10762429f, 0.28152099f, -0.00464188f, 
    -0.21022837f, 0.09332200f, 0.03197509f, 0.11594160f, -0.01341624f, 0.11895586f, -0.03302091f, -0.11213741f, 
    -0.36853838f, -0.14306943f, -0.13830915f, 0.03373749f, -0.00180356f, -0.08088026f, 0.00285815f, -0.03782775f, 
    -0.06105451f, -0.00403012f, -0.09828446f, -0.07499007f, -0.08768533f, 0.02048957f, 0.17362271f, 0.00481950f, 
    -0.11658819f, -0.07641034f, -0.07658384f, 0.09245963f, 0.06626656f, -0.28651258f, 0.00856248f, 0.03755059f, 
    0.01808058f, -0.02853246f, -0.08855601f, 0.10231210f, -0.01264323f, 0.02299255f, -0.01819201f, 0.07634164f, 
    -0.00708468f, 0.06709051f, 0.11148284f, -0.08419460f, -0.10502400f, 0.10720797f, -0.03305937f, 0.03034998f, 
    -0.00109660f, 0.12599988f, 0.33998802f, 0.25275666f, 0.04699504f, 0.12757364f, 0.09535018f, 0.05793142f, 
    0.11700299f, 0.01487809f, 0.02351681f, -0.01131758f, -0.06392492f, -0.01051281f, -0.00247153f, -0.00515723f, 
    0.01788880f, -0.09944135f, -0.04556661f, -0.04584013f, -0.03985347f, 0.24293999f, 0.38462135f, 0.32543170f, 
    0.05032366f, 0.19311845f, 0.09668755f, 0.12978056f, 0.08420614f, 0.07694101f, 0.06458092f, -0.01004879f, 
    -0.08538885f, 0.04437246f, 0.02869361f, 0.00244974f, 0.00763754f, -0.11770332f, -0.03248189f, -0.04335893f, 
    0.04369904f, -0.06832714f, -0.04695630f, -0.01466824f, -0.02595881f, 0.01863559f, -0.00684099f, -0.10080504f, 
    -0.03566026f, 0.03175148f, 0.07810932f, -0.00068517f, 0.10202931f, -0.01602850f, -0.00166432f, 0.04835543f, 
    -0.01465834f, -0.03131917f, -0.04791181f, -0.01523236f, 0.38217148f, 0.08969866f, 0.27322775f, -0.10333019f, 
    0.08211876f, 0.02122398f, -0.01807877f, -0.03863350f, 0.05500127f, 0.14994428f, -0.07695197f, 0.09044386f, 
    0.16996081f, 0.04093017f, -0.03092663f, 0.00174392f, -0.08258647f, -0.03397441f, 0.13279800f, 0.14068249f, 
    -0.72594631f, 0.21601151f, 0.16547701f, 0.31310537f, -0.05610101f, 0.02495736f, -0.13593979f, 0.06329588f, 
    0.28856036f, 0.18698512f, 0.15301667f, -0.04379711f, -0.07912633f, -0.04911502f, -0.00083260f, 0.00711761f, 
    0.11870854f, 0.22450007f, -0.07448398f, 0.04301578f, 0.02311149f, -0.23707096f, 0.05339399f, -0.11706361f, 
    0.13028935f, -0.04837042f, -0.08543558f, -0.07735296f, 0.08772526f, 0.02422656f, 0.01318187f, 0.13227463f, 
    0.10611382f, 0.07402530f, 0.01013822f, -0.03091843f, -0.00900955f, -0.01220815f, 0.18422548f, 0.13342224f, 
    -0.18950981f, 0.23659694f, 0.54632956f, 0.31871265f, -0.06748300f, 0.01158922f, -0.00283297f, 0.01386387f, 
    0.10222820f, 0.05010922f, -0.02172645f, 0.01795519f, -0.04583379f, -0.02817698f, 0.02128011f, -0.04948033f, 
    0.00064607f, 0.03829604f, -0.01899834f, 0.01042519f, -0.04543990f, 0.09540526f, 0.07345792f, -0.15261073f, 
    0.03783345f, -0.04403828f, 0.02788915f, -0.11522240f, 0.01950517f, 0.02498063f, 0.06191287f, -0.07313390f, 
    0.06192599f, -0.02565240f, -0.00850848f, -0.01550211f, -0.05412071f, -0.04692429f, 0.00500407f, 0.03621208f, 
    0.15050934f, 0.13215527f, -0.27389604f, -0.01396550f, -0.18264982f, -0.17562056f, -0.00106169f, 0.21618479f, 
    0.05035644f, 0.02342694f, -0.02500589f, 0.07922219f, 0.12200890f, -0.15279202f, -0.03766838f, 0.10727561f, 
    -0.13207921f, 0.02794699f, 0.05043788f, -0.01432709f, -0.42630705f, -0.26194051f, -0.18792762f, 0.03416299f, 
    -0.03603800f, 0.00108388f, -0.09923374f, -0.10334922f, 0.01173947f, 0.15049127f, 0.05326165f, 0.01945303f, 
    -0.04496954f, -0.05311010f, -0.03307246f, -0.01383491f, -0.08135048f, 0.10993946f, -0.04855338f, 0.04454017f, 
    0.23558265f, -0.25319177f, -0.57251650f, 0.00762899f, 0.11174221f, -0.12479521f, 0.03410671f, 0.00905994f, 
    -0.01547872f, 0.02948859f, -0.09763439f, -0.05555731f, -0.00223278f, -0.07484340f, -0.09707683f, -0.09009219f, 
    -0.03611210f, -0.08212178f, 0.03086897f, 0.03004391f, -0.27753425f, 0.01408737f, 0.05174013f, 0.14422977f, 
    -0.14375095f, 0.05918201f, -0.07016505f, 0.01444026f, 0.09464797f, 0.16336852f, -0.12372208f, -0.04841016f, 
    -0.00550249f, -0.03803278f, 0.06906742f, -0.07658935f, -0.01074021f, -0.04230867f, -0.01045021f, -0.03235061f, 
    0.12443630f, -0.02590779f, -0.43680584f, 0.05354062f, -0.01133391f, -0.01361781f, -0.00065185f, 0.07065046f, 
    -0.05501176f, 0.05131628f, -0.10649004f, -0.06626032f, -0.04327792f, -0.19864856f, -0.06193803f, -0.01902758f, 
    -0.06748449f, -0.00193982f, 0.00117817f, -0.03135892f, 0.03786571f, -0.22940835f, 0.10890570f, -0.08235671f, 
    -0.01362561f, 0.08108891f, -0.08117349f, -0.08674224f, -0.08017421f, 0.00395896f, 0.14158556f, -0.00659491f, 
    0.09892380f, 0.11989442f, 0.11966218f, 0.05837399f, 0.03255960f, 0.01074932f, 0.08155359f, -0.06705101f, 
    0.14653583f, 0.09846990f, 0.22248065f, 0.22662558f, 0.04346203f, 0.02217748f, 0.12946987f, 0.06752911f, 
    -0.04900150f, 0.07693281f, 0.05253046f, -0.01084117f, -0.11573984f, -0.07302877f, -0.01507040f, -0.08760457f, 
    0.03402546f, -0.00910806f, -0.00300012f, -0.08595377f, 0.18331175f, -0.39338544f, -0.06523781f, -0.00763367f, 
    0.07082790f, 0.00771315f, -0.05854167f, -0.06769060f, 0.11349174f, 0.05034582f, 0.02981505f, 0.06430238f, 
    0.07964452f, -0.03052299f, 0.08516975f, 0.00158842f, -0.01955164f, -0.00934460f, 0.01064437f, 0.15182967f, 
    0.13451073f, 0.17541526f, 0.26416662f, 0.09503289f, 0.00959111f, -0.00033387f, 0.08789338f, -0.01731824f, 
    0.04269069f, 0.11037234f, 0.05853580f, 0.05054275f, 0.06618828f, -0.11276758f, -0.06547368f, 0.04719267f, 
    0.00033210f, -0.09214193f, -0.05768878f, 0.05097546f, 0.06118754f, -0.02899469f, 0.05530060f, 0.09147081f, 
    0.00412734f, -0.04233002f, 0.01974158f, -0.08225542f, -0.01750839f, 0.07580763f, 0.08989991f, -0.01536724f, 
    0.12212924f, 0.01278559f, 0.01704734f, 0.06637304f, 0.04924301f, -0.04659878f, -0.00567580f, 0.11421381f, 
    -0.15868033f, -0.26964360f, -0.04072632f, 0.01946483f, 0.01233318f, 0.02789694f, -0.06681738f, -0.03748561f, 
    0.00955339f, 0.02602624f, 0.09586262f, -0.03968015f, 0.05989002f, -0.00873619f, -0.00372188f, -0.03173742f, 
    -0.05485152f, 0.06735083f, -0.05203788f, -0.03008545f, 0.06889831f, 0.38307968f, 0.05482500f, 0.24736822f, 
    -0.20030196f, 0.06572523f, 0.02126336f, 0.05975246f, 0.06864982f, 0.25480220f, -0.02368996f, 0.06496241f, 
    0.00329294f, -0.00868565f, 0.00629969f, 0.04217862f, 0.06529334f, 0.10171173f, -0.07478129f, 0.15416020f, 
    0.18875797f, 0.00103731f, -0.18295172f, -0.02811799f, 0.05442319f, -0.01626502f, -0.07367928f, -0.14835982f, 
    -0.15838973f, -0.03140034f, 0.09025981f, 0.04283521f, -0.04803401f, 0.06710710f, 0.05103384f, 0.05122071f, 
    0.10113560f, 0.11456683f, -0.02939516f, -0.02807096f, 0.18513553f, 0.42780268f, 0.41094950f, 0.23128098f, 
    0.16553010f, 0.07115969f, 0.08932517f, 0.03505760f, 0.08158920f, 0.00256849f, 0.05554989f, -0.01009001f, 
    -0.11789643f, -0.05829658f, 0.00356035f, 0.03513512f, 0.00757835f, -0.09743617f, -0.05993298f, 0.00984151f, 
    -0.15159221f, 0.31860399f, 0.26175827f, 0.14879327f, 0.14345959f, -0.02780321f, -0.11828166f, -0.00644036f, 
    -0.07461069f, -0.04228781f, 0.00099003f, -0.09390303f, -0.14130677f, -0.01301136f, 0.10362035f, 0.06038615f, 
    -0.03449367f, -0.00365330f, -0.15540375f, -0.12623495f, 0.08352450f, -0.07201775f, -0.16536613f, -0.06358548f, 
    -0.02955407f, 0.04647376f, -0.02340232f, 0.05683153f, 0.03406840f, 0.04771673f, -0.08163336f, 0.00657078f, 
    0.03374020f, 0.02531988f, -0.02231497f, 0.01752967f, 0.02013743f, -0.01247339f, -0.13602446f, -0.15160312f, 
    -0.18190332f, 0.24383113f, 0.32340354f, 0.15525238f, 0.12507297f, 0.06425045f, 0.02400225f, 0.08891379f, 
    -0.14447488f, 0.00837201f, -0.18564372f, -0.00989353f, 0.03948766f, 0.05607842f, 0.17657627f, -0.10749424f, 
    0.07948609f, 0.04907994f, 0.02170273f, -0.01236338f, -0.11499891f, 0.21368408f, -0.01438038f, 0.21851851f, 
    -0.03017304f, 0.08450226f, -0.15004872f, -0.07434743f, -0.07695993f, -0.01764482f, 0.12239704f, -0.03125786f, 
    -0.12192883f, 0.07225491f, -0.04565006f, 0.00965310f, -0.11405194f, -0.09247347f, -0.13938323f, -0.39097983f, 
    -0.50999761f, 0.21142329f, -0.19111121f, 0.15442099f, -0.11957625f, 0.18054217f, -0.07847388f, 0.18514013f, 
    -0.13908224f, 0.01537043f, -0.01772771f, 0.03949768f, 0.01839920f, 0.06115029f, -0.02391566f, 0.09155016f, 
    0.02391453f, 0.18017061f, 0.30305961f, 0.21702471f, -0.36382306f, -0.22073995f, 0.19143878f, -0.02293133f, 
    0.26988447f, 0.01979871f, -0.02395082f, -0.08732498f, -0.22411612f, 0.10377927f, 0.09676374f, -0.05406824f, 
    -0.01013373f, -0.02454766f, 0.00753519f, 0.35728085f, 0.05455068f, 0.03597869f, -0.07493401f, 0.14758471f, 
    0.32017627f, -0.00496346f, -0.00617939f, -0.06869741f, 0.05069393f, -0.05620953f, 0.01878207f, -0.08686207f, 
    0.10063284f, 0.00748795f, 0.03830716f, 0.05839568f, -0.06088978f, -0.05328204f, 0.01868365f, 0.16032811f, 
    0.18927927f, 0.31425655f, 0.07910390f, 0.12923664f, 0.06148881f, 0.07424309f, -0.30096862f, 0.13514210f, 
    -0.25489193f, 0.04787547f, -0.02476743f, -0.15150799f, 0.11715423f, 0.06937702f, -0.00943856f, -0.02124482f, 
    -0.06431879f, 0.13167197f, 0.01606921f, 0.08928631f, 0.19195162f, 0.07820640f, 0.09372789f, 0.03600286f, 
    -0.17662972f, -0.04905742f, 0.20436198f, -0.07317337f, 0.03984001f, 0.04086265f, 0.13168560f, 0.07978041f, 
    -0.06895680f, 0.07119329f, 0.09105422f, -0.10612565f, 0.03380227f, -0.11135112f, 0.03127667f, 0.01974519f, 
    -0.15423575f, -0.25333762f, -0.07870471f, -0.10665643f, -0.12397195f, -0.17357661f, 0.09112161f, 0.05761653f, 
    0.19367982f, 0.12985188f, -0.01873444f, 0.03038069f, -0.19906667f, 0.09103737f, 0.00267916f, -0.03843348f, 
    -0.03089886f, 0.02079085f, 0.06918626f, -0.06011567f, 0.01113295f, -0.01905376f, -0.01287371f, -0.18213673f, 
    0.03931729f, -0.07421535f, 0.05132002f, -0.17677678f, 0.08564077f, -0.04789677f, 0.13213338f, 0.13960342f, 
    -0.09830023f, 0.08732365f, 0.00429660f, 0.04751915f, 0.10036410f, -0.00684994f, 0.04323981f, 0.14146006f, 
    0.12709242f, 0.11935151f, 0.09682887f, 0.33307692f, 0.02418738f, -0.02942107f, 0.08422676f, 0.02568505f, 
    0.09409467f, 0.02785496f, 0.08554984f, 0.10188091f, -0.10879115f, 0.13030785f, -0.00292260f, 0.08298285f, 
    0.08700905f, 0.14530003f, 0.02299411f, 0.14555669f, 0.11899596f, 0.04101505f, 0.10724474f, 0.27590027f, 
    -0.11863272f, 0.00589906f, 0.01558664f, 0.02467284f, 0.00807873f, -0.05078537f, -0.01068874f, 0.01191386f, 
    0.04593375f, -0.05223226f, -0.08010747f, 0.07563724f, 0.11793406f, -0.06064896f, -0.06881528f, 0.13979387f, 
    -0.11125437f, -0.15801089f, -0.18420893f, -0.18961433f, -0.10992561f, 0.37547743f, -0.09034949f, 0.02752398f, 
    -0.26286072f, -0.09176037f, -0.05322982f, 0.00626282f, 0.15315039f, -0.06149934f, -0.10023713f, -0.00182810f, 
    0.00867155f, 0.00522078f, 0.10484782f, -0.10148561f, 0.08336794f, 0.01891250f, 0.05545418f, 0.00314665f, 
    -0.32614857f, -0.48198998f, 0.25867304f, -0.00169281f, 0.28252730f, 0.20806734f, -0.10595085f, 0.02637448f, 
    0.09090140f, 0.04168719f, -0.05994785f, 0.01588564f, 0.11383002f, 0.05533881f, 0.01619823f, -0.08028720f, 
    0.08391857f, 0.11204871f, -0.04752878f, -0.00482997f, -0.16483167f, 0.12632959f, -0.04658366f, -0.26097968f, 
    -0.16199136f, 0.03746808f, -0.08933409f, 0.05024360f, -0.01579944f, 0.00334279f, -0.01796758f, 0.00291846f, 
    0.13511950f, -0.04666443f, 0.10743728f, -0.06696628f, -0.02966474f, -0.11907752f, -0.07829111f, -0.29855666f, 
    -0.07385100f, 0.28942412f, 0.07737671f, -0.00358133f, 0.28541470f, 0.04058770f, 0.08850721f, 0.08433121f, 
    -0.02777332f, 0.01295140f, 0.08651737f, -0.01842579f, -0.04063726f, -0.02451130f, -0.00915097f, -0.06509347f, 
    -0.12264777f, 0.02615687f, 0.00732119f, -0.02760425f, -0.24678189f, 0.07762881f, 0.01982700f, -0.05407071f, 
    0.01094629f, -0.02950329f, 0.05437667f, 0.10794590f, 0.10500770f, 0.02661141f, -0.01946143f, 0.15688774f, 
    0.06023240f, -0.04184242f, 0.02688607f, 0.15141389f, -0.21683152f, -0.17134124f, -0.23277554f, -0.27053568f, 
    -0.10123966f, -0.04763923f, -0.15925142f, 0.07361636f, 0.11987506f, 0.00192679f, 0.08905626f, -0.05039571f, 
    -0.05378474f, 0.09963863f, -0.01415193f, -0.00478125f, -0.06456389f, -0.04418171f, 0.08703590f, 0.12880653f, 
    -0.02418642f, -0.02342167f, -0.23181778f, -0.05287949f, 0.12872578f, -0.15485376f, 0.01259962f, -0.13341156f, 
    0.14439721f, -0.08471221f, -0.00115131f, -0.12322044f, 0.05196047f, -0.04781673f, 0.04132225f, -0.08043133f, 
    -0.05292543f, -0.08142755f, -0.01332369f, 0.13659289f, 0.07047314f, 0.05007576f, -0.06284257f, 0.03742697f, 
    0.29812074f, -0.07925912f, -0.05967507f, 0.04528896f, 0.13115665f, -0.12216369f, 0.06318101f, 0.08597136f, 
    0.06083940f, 0.03037558f, -0.05977483f, 0.01165924f, -0.01111017f, -0.01767297f, 0.01940051f, -0.05708617f, 
    0.02967523f, 0.05891543f, 0.13174115f, -0.00125185f, -0.16682369f, 0.21774408f, 0.02784580f, -0.06452645f, 
    0.24908158f, 0.13461328f, 0.17091370f, 0.05477563f, -0.06482827f, 0.15232620f, 0.07574046f, -0.12597980f, 
    -0.03662420f, 0.09145693f, -0.00593044f, -0.06407122f, -0.20153758f, 0.03946479f, -0.16596954f, -0.08889903f, 
    0.32305634f, -0.02452212f, 0.02755636f, 0.07813574f, 0.14444017f, -0.10653560f, 0.14223704f, 0.03409010f, 
    -0.08613721f, 0.02631347f, 0.01769419f, -0.02323637f, -0.03890983f, -0.05365956f, 0.02380984f, -0.13087976f, 
    -0.01069582f, 0.03785284f, 0.02846976f, 0.10227539f, -0.14649402f, 0.09204284f, -0.10220971f, 0.15517330f, 
    -0.02369305f, -0.02074219f, -0.07828303f, 0.01680283f, -0.13474801f, 0.04284031f, -0.04773032f, -0.01298122f, 
    -0.07374553f, 0.05326246f, -0.10303523f, 0.17480800f, -0.13480534f, -0.02781031f, 0.01312176f, 0.00930005f, 
    -0.05386256f, 0.20369129f, 0.13081403f, 0.22385238f, 0.17081408f, 0.12172702f, 0.12561312f, -0.03167620f, 
    -0.18838817f, 0.04560049f, -0.06206055f, 0.10078456f, 0.04886628f, 0.11493943f, 0.05273189f, 0.01789960f, 
    0.10467692f, 0.07566780f, 0.07795452f, 0.06750453f, -0.16833010f, -0.09811469f, 0.08972424f, -0.16906692f, 
    0.08377264f, -0.03808875f, -0.08263001f, -0.02947018f, 0.11884978f, -0.09848165f, -0.06504163f, -0.01115718f, 
    -0.04240597f, -0.02376825f, -0.05063127f, 0.20134790f, 0.19722135f, 0.17212982f, 0.00100755f, 0.16225098f, 
    0.00139282f, 0.29407313f, 0.28772599f, 0.07773868f, 0.08656257f, 0.11169461f, -0.07799150f, 0.02315449f, 
    -0.11885577f, -0.05733623f, -0.09947028f, -0.06982126f, -0.01642262f, -0.01539515f, 0.10153314f, 0.01801571f, 
    -0.05769457f, 0.02907705f, -0.07960179f, -0.00642282f, -0.07095452f, 0.11353591f, 0.13852075f, -0.00475480f, 
    0.01539319f, -0.01632673f, -0.10807189f, -0.00875343f, -0.02499503f, -0.03648216f, 0.03915234f, -0.04262710f, 
    -0.03797615f, -0.01919294f, 0.02281599f, 0.06188194f, -0.11712699f, -0.04174504f, -0.16708052f, -0.21115087f, 
    -0.27333516f, -0.10220562f, 0.20690870f, -0.06204962f, 0.22701955f, 0.01641891f, 0.12140264f, -0.03253705f, 
    -0.05948832f, 0.02003267f, 0.05752715f, 0.05582253f, 0.14675665f, -0.00671121f, 0.10355519f, -0.06779861f, 
    -0.10907616f, -0.05452093f, -0.08336554f, -0.12431081f, 0.29968494f, -0.00862721f, 0.34683862f, -0.05093129f, 
    0.25763240f, -0.14850304f, 0.13238028f, -0.05558050f, 0.18308815f, 0.04814437f, 0.01250117f, -0.07659639f, 
    0.01320250f, -0.06981987f, 0.00120365f, -0.09002593f, 0.15218775f, 0.13675484f, 0.19854940f, 0.13638751f, 
    -0.01124831f, -0.16914080f, -0.08725309f, -0.21188603f, 0.03476014f, 0.10541455f, 0.07005890f, -0.03588266f, 
    0.00215983f, 0.12905796f, -0.02907516f, -0.03981551f, 0.11203548f, 0.01663319f, 0.00819039f, -0.05493431f, 
    0.03689056f, 0.01711531f, -0.04277611f, -0.08146680f, 0.11905114f, 0.31570426f, 0.24232848f, 0.14833458f, 
    0.15115388f, 0.07121226f, 0.01362706f, -0.02193136f, -0.05673306f, -0.03552254f, 0.11266164f, 0.09833591f, 
    0.00356369f, -0.00874986f, -0.03003656f, 0.06419940f, -0.05420252f, -0.01196267f, 0.03617519f, -0.14341021f, 
    -0.26961532f, 0.09458223f, 0.26390949f, -0.12959225f, -0.11287125f, -0.06639362f, -0.11970191f, -0.07458100f, 
    -0.07550970f, -0.15061545f, -0.05487572f, 0.05542469f, 0.06900281f, 0.04746374f, 0.05705502f, -0.03901564f, 
    -0.04375796f, 0.02890464f, -0.04899710f, -0.06744710f, 0.10025238f, 0.04387740f, 0.03187416f, 0.02533633f, 
    0.11397664f, 0.00623490f, -0.07801417f, 0.01912734f, -0.09393805f, -0.07054979f, 0.06067798f, 0.08353484f, 
    0.07473529f, 0.03835915f, 0.03160282f, -0.04126273f, -0.13320792f, 0.01257890f, -0.05495133f, -0.04531809f, 
    -0.53789163f, 0.28665206f, 0.40777147f, -0.08603158f, 0.01120620f, 0.00739271f, -0.00726187f, -0.10960571f, 
    -0.13382077f, -0.00858796f, 0.14541069f, 0.00095661f, 0.17268011f, 0.02828072f, 0.01549152f, 0.01679833f, 
    -0.02206216f, -0.07608394f, 0.08155642f, 0.01817021f, -0.35486376f, -0.09167175f, 0.12620713f, -0.10973999f, 
    -0.00116467f, -0.02739431f, -0.02307224f, -0.06403861f, 0.14134410f, -0.07730073f, -0.04833332f, 0.08578838f, 
    -0.10346426f, -0.03026642f, -0.08919270f, -0.02850099f, -0.02079737f, 0.08081113f, -0.00636253f, 0.01456514f, 
    0.00352075f, 0.06855095f, -0.08961037f, 0.22572926f, 0.16605489f, -0.03898675f, 0.20530151f, -0.14304797f, 
    -0.10568863f, -0.02505156f, 0.16348037f, 0.05611088f, 0.01465616f, -0.00615805f, 0.04402571f, 0.31630465f, 
    0.08898220f, 0.01503483f, 0.13548204f, 0.10259065f, -0.14986099f, 0.36740053f, -0.20774056f, 0.25688559f, 
    0.05455028f, 0.23514789f, 0.19385110f, -0.04560075f, 0.04403808f, 0.27279499f, 0.00081437f, 0.14789909f, 
    0.14640762f, -0.20459601f, 0.00748423f, -0.01740645f, 0.12942488f, -0.15252344f, 0.28510565f, -0.21672104f, 
    0.13533859f, 0.04040939f, -0.02903618f, -0.10164267f, 0.04809983f, -0.01574225f, 0.08340438f, 0.05118046f, 
    -0.02557804f, -0.01618117f, 0.01841121f, -0.02159327f, 0.04436946f, -0.00673457f, -0.00387677f, 0.04545503f, 
    0.14660832f, 0.15623416f, 0.13950725f, 0.01204458f, 0.61954081f, 0.21528134f, -0.07624229f, -0.23026736f, 
    0.21193808f, -0.02466977f, -0.01899099f, 0.00802594f, 0.01651130f, -0.09624800f, -0.00347620f, 0.06801451f, 
    0.07070635f, -0.11150170f, 0.00932729f, 0.14366162f, 0.05873923f, -0.00757117f, 0.34134999f, 0.01589480f, 
    0.18761733f, 0.02947218f, -0.29093412f, -0.16635537f, 0.16079263f, 0.21877183f, 0.03955960f, -0.07520713f, 
    0.01868205f, -0.02585932f, 0.01811028f, -0.13002022f, -0.08986673f, -0.04966563f, 0.00203366f, -0.00411359f, 
    -0.03915673f, -0.00332614f, -0.09739868f, -0.11728911f, -0.10291730f, 0.09817410f, -0.08133193f, 0.06121845f, 
    0.03590479f, 0.03826792f, 0.02568801f, -0.17078495f, -0.10614269f, -0.01817382f, 0.14005966f, -0.10140679f, 
    0.06918982f, -0.01663844f, -0.07718219f, 0.03435840f, 0.00937942f, -0.11470255f, 0.03418732f, -0.03768440f, 
    -0.00272526f, -0.03494520f, -0.04140090f, 0.04921680f, 0.08157311f, 0.00380585f, -0.07467266f, 0.01028530f, 
    0.06519327f, 0.05953220f, -0.00868028f, -0.04589618f, 0.05131507f, 0.00299175f, 0.08532643f, -0.14185120f, 
    0.01727602f, 0.07163709f, 0.14427669f, 0.15291791f, 0.02187316f, -0.02563213f, -0.03819101f, 0.02766569f, 
    0.01103127f, -0.03048381f, -0.09240606f, -0.13514459f, 0.08040369f, 0.09328904f, -0.02135738f, -0.06886831f, 
    -0.00784525f, 0.02061761f, 0.02037616f, -0.04292865f, 0.02650848f, 0.05009477f, 0.10210603f, 0.24847719f, 
    0.05196741f, 0.06128423f, 0.06824833f, -0.04078503f, 0.03896347f, -0.04816851f, -0.07326713f, -0.02892394f, 
    -0.13994555f, -0.03569434f, 0.00929978f, 0.09049749f, 0.05290340f, 0.03303195f, -0.01650479f, -0.05687877f, 
    -0.07229850f, -0.11185175f, -0.08163011f, -0.15510039f, 0.29209825f, 0.29485580f, -0.17930518f, 0.03462126f, 
    0.02418864f, 0.03314131f, -0.04120193f, 0.18825257f, -0.06523655f, -0.03240871f, 0.19130281f, 0.17516066f, 
    -0.02301843f, 0.06146738f, 0.02250534f, 0.16500349f, -0.03735932f, 0.21685864f, -0.12582664f, 0.22105990f, 
    -0.76864207f, 0.64711505f, -0.09365129f, 0.25959283f, 0.12785912f, 0.09139722f, 0.00421267f, -0.14500770f, 
    -0.15040734f, 0.11606288f, 0.09480610f, -0.09388278f, 0.16803126f, 0.01320487f, 0.07249729f, 0.17245656f, 
    0.08178111f, -0.16343088f, 0.40786716f, -0.10011657f, 0.16502699f, 0.22778012f, -0.12389175f, -0.00101723f, 
    0.02991552f, 0.02592471f, 0.04949709f, -0.02305737f, -0.15014902f, 0.01957500f, 0.06874120f, 0.16284822f, 
    -0.04777648f, -0.04129209f, 0.00914047f, 0.10347122f, -0.02172696f, 0.00792430f, -0.18613540f, 0.06199830f, 
    -0.31826887f, -0.38528410f, -0.18988915f, -0.00922512f, -0.04209760f, 0.19215570f, 0.09596197f, -0.00846537f, 
    -0.04508029f, -0.05276194f, -0.03798261f, -0.03628628f, -0.03132764f, -0.02902105f, 0.00154520f, -0.07152019f, 
    -0.01180107f, 0.00223797f, 0.25446433f, 0.08971210f, 0.04110037f, -0.02039617f, 0.03230892f, -0.01828303f, 
    0.03797670f, -0.02094853f, -0.09515371f, -0.08000307f, -0.13235457f, -0.05573871f, -0.05793742f, -0.03695012f, 
    -0.07093744f, 0.05903435f, -0.03665886f, -0.08400867f, -0.06900978f, -0.06462791f, -0.06810712f, -0.13452497f, 
    -0.03522280f, 0.11578155f, -0.10933177f, -0.15102841f, 0.11402003f, 0.06817462f, -0.15247902f, -0.18526360f, 
    -0.06737450f, -0.08950330f, 0.36913708f, -0.12114534f, -0.23727059f, 0.29432490f, 0.00515769f, 0.16223054f, 
    -0.09442328f, -0.07598121f, 0.04255566f, 0.01573767f, 0.11802071f, 0.04393904f, -0.19319552f, 0.13478066f, 
    0.11428765f, 0.02455143f, 0.08621904f, 0.04576884f, -0.02719841f, 0.08516350f, -0.05118279f, 0.00612560f, 
    0.03620001f, -0.11022107f, -0.05729798f, -0.13524063f, 0.01689933f, -0.07406340f, 0.11003621f, -0.06838232f, 
    0.20563954f, 0.11306063f, 0.11912496f, -0.04551785f, 0.19509335f, -0.01413113f, 0.12814862f, 0.04924808f, 
    -0.08123494f, -0.07715711f, 0.00943840f, -0.09297990f, -0.05939154f, -0.04897875f, -0.03385510f, 0.13939628f, 
    0.12998626f, 0.19355831f, -0.09333915f, 0.01332217f, -0.09599815f, -0.11125708f, -0.17113604f, 0.06274465f, 
    0.08721231f, 0.12737316f, 0.23893501f, -0.05202008f, 0.24575408f, 0.07024048f, 0.01282644f, -0.07962169f, 
    -0.09624252f, 0.01912238f, -0.03279291f, -0.04961480f, -0.01511424f, 0.03596359f, 0.03023596f, -0.12595579f, 
    0.19506401f, -0.00537433f, 0.06354140f, -0.00038234f, 0.16753222f, 0.12431113f, 0.27102989f, 0.18663800f, 
    0.13720626f, 0.08963679f, 0.00424713f, -0.07550233f, -0.09405565f, -0.02309572f, -0.02622557f, 0.13098402f, 
    0.04636584f, 0.14731701f, -0.02816974f, -0.03492360f, -0.08148476f, 0.00098297f, -0.03557804f, -0.04586603f, 
    -0.04672185f, 0.13782249f, 0.12623252f, -0.03039375f, 0.09350242f, 0.01716302f, 0.32034561f, -0.05781078f, 
    0.10909756f, 0.05873847f, -0.01621444f, 0.04704266f, 0.05310757f, 0.03314380f, 0.04150750f, -0.06042086f, 
    -0.20118465f, 0.08297086f, 0.24344520f, 0.00581343f, 0.00768977f, -0.00419394f, -0.06028123f, -0.08513895f, 
    -0.01473762f, 0.03647132f, 0.02796382f, 0.02618299f, 0.16951892f, -0.05056185f, 0.01710158f, 0.00116442f, 
    -0.02389634f, -0.03589294f, 0.03782057f, -0.01121603f, 0.32712150f, 0.13173731f, -0.20957392f, 0.21619412f, 
    0.07365767f, -0.01202700f, -0.02098927f, 0.03382574f, -0.17699344f, -0.01528427f, 0.02124597f, 0.05701802f, 
    -0.02062852f, 0.00216154f, -0.05459428f, -0.05306347f, 0.09998345f, -0.02114529f, 0.31027123f, 0.14983715f, 
    -0.29375598f, 0.06331816f, 0.26780710f, 0.05043843f, -0.12191007f, -0.02520413f, -0.02343238f, 0.00731740f, 
    0.04656751f, 0.04109077f, 0.12754092f, 0.14806758f, -0.02509685f, 0.15578899f, 0.00937388f, 0.02385870f, 
    -0.09090161f, 0.08463841f, -0.06786820f, 0.06359720f, -0.01169333f, 0.20300548f, 0.00387432f, -0.09376098f, 
    -0.05159701f, -0.07858782f, -0.06647883f, -0.05558622f, -0.01846432f, -0.04731738f, -0.00120229f, 0.08171983f, 
    0.04745613f, 0.06653957f, 0.00882234f, -0.01742360f, -0.02377333f, -0.05066228f, -0.08961780f, -0.07367243f, 
    -0.27551809f, 0.04884206f, -0.16009338f, 0.07945178f, 0.01160168f, -0.00157792f, -0.10257446f, -0.10372341f, 
    -0.11089117f, -0.01076378f, 0.07105801f, 0.01872109f, -0.08726616f, 0.15993123f, 0.01744374f, 0.04945507f, 
    0.06394286f, -0.09116067f, -0.03599259f, 0.03995991f, -0.10232849f, -0.18339056f, -0.33350587f, -0.21157117f, 
    0.13365263f, -0.03154968f, 0.13124391f, -0.01140357f, 0.02802644f, 0.02722841f, -0.03480519f, -0.01998765f, 
    0.04724980f, -0.02065127f, 0.01289035f, -0.02409979f, 0.00521226f, 0.04251708f, 0.16491352f, 0.11086421f, 
    0.01744528f, 0.07582332f, 0.03737584f, -0.00774505f, 0.11098030f, -0.07842332f, -0.08809592f, -0.08124742f, 
    -0.03836925f, -0.06271937f, 0.11237625f, 0.07917707f, 0.03927278f, -0.02454257f, 0.01549702f, -0.05925244f, 
    -0.10663616f, -0.07097496f, 0.00000389f, 0.03817975f, -0.26662412f, -0.34523398f, 0.02090841f, 0.00720698f, 
    -0.16611515f, 0.05028033f, 0.13353628f, 0.03538414f, 0.02816834f, -0.05436804f, -0.00522727f, -0.02869205f, 
    0.04290602f, -0.05775211f, -0.06428516f, -0.05384396f, -0.02644141f, 0.08802290f, 0.09037891f, 0.00833905f, 
    0.13867502f, -0.20624623f, -0.30477244f, -0.10788274f, -0.04565583f, 0.02064983f, 0.07269251f, -0.01837502f, 
    0.06022169f, -0.03284939f, -0.06644592f, 0.14908640f, 0.06599732f, 0.03275552f, 0.04613104f, -0.05274134f, 
    0.02558535f, 0.01217757f, 0.06714722f, 0.07197848f, 0.29500824f, 0.13341513f, 0.23904714f, 0.04683252f, 
    -0.02809908f, 0.01252385f, -0.06498046f, -0.02580164f, 0.01501269f, -0.08356842f, 0.08125052f, 0.05055340f, 
    0.00578175f, 0.02203858f, -0.00340464f, -0.08821783f, -0.00554508f, -0.12095186f, 0.00795062f, -0.07543267f, 
    0.73371506f, 0.10200659f, -0.02404889f, -0.01717449f, 0.12248613f, 0.17686413f, 0.10902056f, 0.02301389f, 
    0.17011377f, -0.09684861f, 0.05037418f, -0.05632929f, 0.03354594f, -0.15548591f, 0.05595721f, 0.06941909f, 
    0.03997488f, -0.04641661f, -0.02586650f, -0.06486730f, -0.06131633f, -0.14259586f, -0.17131054f, -0.11934470f, 
    0.17999619f, 0.12037265f, 0.10556377f, 0.08803675f, 0.02167920f, -0.02653769f, -0.12351339f, 0.08565045f, 
    0.06880746f, -0.02822041f, -0.03400214f, -0.00732320f, 0.02761549f, 0.15492509f, 0.00864943f, 0.06788266f, 
    0.17583145f, -0.12867849f, 0.25365740f, 0.19323485f, 0.26984620f, -0.08556917f, -0.03063188f, -0.06614549f, 
    0.02802004f, -0.01350403f, -0.03755398f, 0.13575529f, 0.11556970f, 0.00293642f, -0.10514408f, 0.00624834f, 
    0.03733139f, -0.11422420f, -0.23602022f, -0.04996654f, 0.22879843f, -0.08915859f, 0.12436783f, -0.30249837f, 
    0.31644455f, -0.09109786f, 0.18222980f, -0.06269874f, 0.07631775f, -0.10356603f, -0.03204156f, 0.03482817f, 
    -0.02613576f, -0.04422699f, -0.07724000f, 0.06028692f, 0.07245941f, 0.02636555f, 0.15465094f, 0.06262981f, 
    -0.00298097f, 0.13662863f, 0.10987523f, 0.20828043f, 0.15009116f, -0.05819666f, 0.00053945f, 0.01406530f, 
    -0.05950360f, -0.06605127f, 0.02581285f, 0.02012416f, -0.02146052f, 0.00880917f, 0.01883434f, -0.01061364f, 
    -0.08994012f, -0.01859329f, -0.06004699f, -0.06375443f, 0.05309097f, -0.01825695f, 0.37374756f, 0.32203159f, 
    -0.27090698f, -0.09582440f, -0.10148632f, 0.11510928f, -0.03524213f, -0.01419839f, 0.01929045f, 0.00787057f, 
    0.01742292f, -0.03048891f, -0.02787608f, -0.00135382f, -0.11456130f, -0.04087020f, 0.04298920f, 0.09421006f, 
    0.08446845f, 0.04019285f, -0.01729804f, 0.00686995f, -0.04472684f, -0.12973127f, 0.09273732f, 0.07626243f, 
    0.07642817f, 0.00924892f, 0.02938886f, 0.06759217f, 0.02749979f, -0.06532504f, -0.06652474f, 0.00156202f, 
    0.02879701f, 0.03309167f, 0.10639858f, -0.09055866f, 0.27033597f, 0.27537090f, 0.10966542f, -0.08685233f, 
    -0.08388674f, -0.21771398f, -0.04108479f, -0.01922484f, -0.01653646f, -0.09696755f, 0.04641859f, -0.00288331f, 
    0.15151156f, -0.06211802f, -0.20899950f, -0.03113761f, 0.12575111f, 0.03419720f, -0.04418389f, -0.12707332f, 
    0.15362912f, 0.15978573f, -0.07811458f, -0.13332212f, 0.11817542f, 0.12607144f, 0.06767253f, -0.10286680f, 
    0.01295275f, 0.24040823f, -0.01910198f, -0.00673240f, -0.04460159f, 0.04462946f, 0.02184273f, -0.05141192f, 
    -0.06309415f, 0.11419631f, -0.08797374f, -0.01938165f, 0.29653120f, 0.20672669f, -0.03840991f, -0.06802605f, 
    0.07129152f, 0.09081288f, -0.00597702f, -0.13535604f, -0.02235804f, 0.15527742f, -0.00509427f, 0.03068214f, 
    -0.01917922f, -0.13428007f, 0.06174337f, -0.04645992f, -0.05722522f, 0.14034903f, -0.05798271f, 0.00581788f, 
    -0.00370236f, -0.06445397f, 0.01017120f, -0.04817243f, -0.09374780f, -0.03843707f, -0.02955132f, 0.04070125f, 
    0.00148576f, -0.01395358f, 0.04099469f, 0.06305712f, -0.10607195f, 0.01029109f, -0.05963059f, -0.09139930f, 
    -0.03335167f, 0.07332356f, 0.11837458f, 0.01599543f, 0.31150752f, 0.03978302f, 0.03980906f, 0.10219292f, 
    -0.03142213f, 0.15529181f, 0.07366709f, 0.09627023f, 0.02492923f, -0.06868908f, 0.04632480f, 0.03475908f, 
    0.02540762f, 0.05662330f, -0.04624529f, 0.02137253f, 0.22357884f, -0.10560235f, -0.05378655f, 0.06891978f, 
    0.35461989f, -0.45992202f, 0.17043944f, -0.10634006f, -0.01299627f, -0.04292601f, 0.24561955f, 0.27645075f, 
    -0.34021577f, -0.20726906f, -0.04223362f, 0.04225964f, 0.00519277f, 0.01420400f, 0.15081093f, 0.14992636f, 
    -0.00801095f, -0.17864330f, -0.02512668f, -0.01548276f, -0.04780945f, 0.11861172f, 0.00919742f, 0.10202978f, 
    -0.02994232f, 0.00215639f, 0.04396707f, 0.03412426f, -0.04601918f, -0.13534795f, 0.01221959f, -0.06845709f, 
    0.05157134f, 0.10103733f, -0.09987704f, 0.02159749f, 0.29054669f, -0.00047762f, -0.09451291f, -0.05017526f, 
    0.08885381f, 0.27039164f, -0.15842125f, -0.09037893f, 0.19523804f, -0.05035902f, -0.04419610f, -0.07906302f, 
    0.11707222f, 0.12838043f, -0.06514403f, 0.01760438f, 0.04328849f, 0.05213147f, -0.04113176f, 0.02631393f, 
    -0.03054591f, -0.10304911f, -0.00217489f, -0.04737691f, -0.10940844f, -0.15107881f, -0.04709575f, -0.07485018f, 
    -0.02986364f, 0.03484244f, -0.02238889f, 0.02390828f, 0.04945571f, 0.00246116f, -0.01651883f, 0.16716169f, 
    -0.02348456f, 0.08434920f, -0.12806122f, -0.11370239f, 0.02320587f, 0.16233188f, 0.13626215f, 0.02705862f, 
    -0.23052116f, 0.00280109f, 0.34043500f, -0.04559258f, -0.27004504f, -0.02278838f, 0.02896595f, 0.17928141f, 
    0.05568412f, -0.07621402f, -0.00788030f, -0.00929285f, -0.08307634f, 0.09069590f, -0.10303548f, -0.32006764f, 
    0.27356297f, -0.17958781f, 0.06182765f, 0.08568902f, 0.11230546f, 0.07308520f, 0.15892546f, -0.05277247f, 
    0.06291837f, -0.12531050f, 0.02963826f, 0.02203687f, -0.07560790f, -0.14434496f, 0.02248868f, -0.00333981f, 
    0.00050486f, 0.01525746f, -0.01356534f, 0.05451227f, 0.06784347f, 0.08337976f, 0.00582419f, -0.10628239f, 
    -0.10289630f, 0.21935749f, 0.02238553f, 0.04167823f, -0.04444111f, 0.01442084f, -0.19752303f, -0.03607556f, 
    -0.02850347f, -0.03734863f, 0.00766304f, 0.00397164f, -0.07723733f, 0.05430416f, -0.00208423f, 0.15401910f, 
    0.09712543f, -0.08814655f, 0.16343114f, 0.01472821f, -0.13988660f, 0.08610880f, 0.06940571f, -0.03816471f, 
    -0.01493185f, 0.16745019f, -0.01125659f, 0.11022946f, 0.13568148f, 0.05834593f, 0.01804660f, 0.03658037f, 
    0.07124240f, -0.00434481f, -0.01461773f, -0.03742716f, 0.01795701f, 0.03545226f, 0.16809325f, 0.16964400f, 
    -0.26265901f, 0.08388806f, 0.13919620f, -0.01583410f, -0.12315460f, 0.22663385f, -0.05957219f, -0.02425264f, 
    0.10905319f, 0.04818852f, -0.00982423f, -0.02922661f, -0.02308530f, 0.01642238f, -0.03941175f, 0.05170642f, 
    0.12108798f, -0.19124760f, 0.15529160f, 0.14085430f, 0.12957387f, 0.12467680f, 0.03634414f, 0.05425373f, 
    0.12978804f, -0.00635129f, 0.14698134f, 0.04176519f, 0.16016512f, -0.06147368f, -0.06069928f, -0.03433326f, 
    0.06322700f, -0.04939836f, 0.19109853f, -0.10796734f, -0.02828842f, -0.06588846f, 0.05229419f, -0.01133376f, 
    0.27919286f, 0.08738574f, -0.07250242f, -0.02076747f, 0.08188547f, 0.10711406f, -0.01964020f, 0.03315300f, 
    0.11358965f, 0.09625967f, -0.01935834f, -0.05690267f, 0.00711307f, -0.05982362f, -0.02770122f, 0.09048732f, 
    -0.00577849f, -0.08074120f, -0.01731027f, -0.00330169f, -0.24265507f, 0.45679283f, 0.14176808f, 0.12741067f, 
    0.02293540f, -0.09387177f, 0.03348745f, -0.03059200f, -0.10054699f, -0.06010195f, -0.11827872f, -0.00657904f, 
    0.02477690f, 0.00795253f, -0.05412709f, -0.03949900f, -0.07083152f, 0.00833408f, -0.00943734f, -0.16646434f, 
    0.09323389f, -0.03399785f, -0.14689681f, -0.05779292f, 0.08728405f, 0.01326055f, 0.19394538f, 0.14231701f, 
    0.15363415f, -0.08368440f, -0.13365066f, -0.04306500f, 0.00777231f, 0.02565080f, -0.04222460f, 0.01965419f, 
    0.15750280f, -0.00181765f, 0.04812348f, -0.05676122f, -0.08399983f, -0.11280703f, -0.12616979f, -0.12166807f, 
    -0.10448729f, -0.03736817f, -0.01357851f, 0.01427364f, 0.00423338f, 0.06709551f, -0.05133589f, 0.06447632f, 
    -0.07232216f, 0.02171893f, -0.06178553f, -0.05346637f, 0.02404837f, 0.07811847f, 0.03190173f, 0.09072111f, 
    0.26744387f, 0.16726448f, 0.06225251f, -0.03763239f, -0.19138978f, -0.09571401f, -0.11993872f, 0.00600424f, 
    -0.06368358f, -0.14796488f, -0.08320531f, 0.07244199f, -0.22275615f, 0.14566758f, 0.07244854f, -0.00354808f, 
    0.10235158f, 0.03746812f, 0.09075131f, -0.10613966f, -0.37856635f, -0.08548875f, -0.20549193f, -0.06161708f, 
    -0.05082317f, -0.03068920f, -0.12466457f, 0.05131079f, -0.24157809f, 0.10492357f, -0.04771976f, 0.00249956f, 
    -0.03609363f, -0.02881793f, 0.03129538f, 0.01283037f, -0.05960464f, -0.06752157f, -0.15204473f, -0.13610651f, 
    0.26079249f, 0.21122625f, 0.14734298f, 0.13509628f, -0.08276930f, -0.04554196f, -0.02644182f, 0.02961504f, 
    -0.01694137f, -0.13542025f, 0.14194095f, 0.04429986f, 0.04794333f, 0.02737666f, -0.06113515f, -0.06958911f, 
    -0.11214416f, -0.16937031f, -0.07810323f, -0.08608916f, -0.01618039f, -0.00045649f, -0.27212292f, 0.01475063f, 
    0.16709754f, 0.00759880f, 0.00089077f, -0.10591789f, -0.03311586f, 0.18096046f, -0.10949691f, -0.08497677f, 
    0.04635276f, 0.02276004f, 0.01982278f, -0.02128212f, -0.04713941f, -0.01889213f, -0.15663233f, 0.12320568f, 
    -0.28077531f, -0.29976931f, -0.20064479f, -0.02576704f, -0.02007448f, -0.08506260f, 0.00449284f, 0.09618610f, 
    0.02524220f, 0.11107530f, 0.03327655f, -0.08459643f, -0.05171961f, -0.09245881f, -0.12954021f, -0.04008931f, 
    -0.01392118f, -0.01712289f, -0.06065592f, -0.09484392f, -0.54661196f, -0.18899630f, -0.24259001f, -0.04750361f, 
    -0.16837682f, -0.15541688f, -0.07480019f, -0.03051146f, -0.03166647f, -0.04385725f, -0.02513813f, -0.01025252f, 
    -0.01390504f, 0.02441514f, 0.08562136f, -0.10888649f, -0.06231550f, 0.04893907f, 0.07672528f, -0.00589165f, 
    -0.49235600f, -0.05810433f, -0.09757657f, -0.12136341f, 0.06736714f, -0.04684356f, -0.08361938f, -0.03361049f, 
    0.07316975f, 0.15844774f, -0.08694247f, 0.02641251f, 0.02251966f, 0.10381665f, -0.01536157f, -0.09365369f, 
    -0.17977048f, -0.04385850f, -0.08088613f, -0.00543750f, -0.00890627f, -0.30871707f, 0.14055620f, 0.17744711f, 
    -0.04163063f, 0.08401147f, 0.08690304f, 0.11015842f, 0.09402639f, 0.19469945f, -0.09750203f, 0.12660527f, 
    -0.08692774f, 0.03956446f, 0.03454931f, 0.01188312f, 0.07918204f, 0.02084073f, 0.19507480f, 0.27588174f, 
    -0.19256809f, 0.77868348f, 0.01760920f, 0.19238369f, -0.15971056f, 0.02533068f, -0.03244784f, 0.03216190f, 
    -0.00140396f, -0.00152943f, -0.03245833f, -0.01742895f, -0.04827583f, 0.07994171f, 0.20729969f, 0.17203385f, 
    -0.05146427f, 0.11088766f, 0.14206772f, -0.02663165f, 0.72660661f, 0.46829364f, -0.03985320f, -0.06826343f, 
    -0.03333064f, 0.09785534f, 0.11497264f, 0.28114173f, 0.16648722f, 0.08932950f, 0.09675953f, 0.05875763f, 
    -0.03380533f, 0.04542261f, 0.07468600f, 0.01934943f, 0.05715760f, 0.28089613f, -0.01215195f, 0.04123848f, 
    0.04619405f, -0.13471304f, 0.25916523f, -0.03408382f, -0.10994081f, -0.01472349f, -0.09014047f, -0.16456705f, 
    -0.02101930f, 0.06255388f, -0.13734013f, -0.08286214f, -0.00290823f, -0.01291560f, 0.06276780f, 0.01731806f, 
    -0.05604539f, 0.05542478f, -0.06937320f, -0.08131506f, 0.15129386f, 0.21789731f, 0.05111232f, 0.11556184f, 
    0.39191487f, -0.02793499f, 0.16184475f, -0.14509673f, 0.02544393f, -0.13791341f, -0.09025272f, 0.02876356f, 
    0.07101752f, 0.03032438f, 0.20732567f, -0.00860134f, -0.09296438f, -0.00643792f, 0.14719003f, -0.16367094f, 
    0.09946574f, 0.01128917f, 0.02450824f, -0.00154496f, -0.14064617f, 0.13118002f, -0.21317074f, -0.03743895f, 
    -0.05429782f, -0.10681336f, -0.16980931f, -0.16091548f, 0.11100122f, 0.08583479f, -0.01111549f, 0.03536827f, 
    0.05745202f, 0.24692604f, 0.02158987f, 0.20967937f, -0.23418517f, -0.08675951f, -0.20957747f, -0.06966349f, 
    -0.09148002f, 0.11870776f, 0.02418189f, -0.04588481f, -0.07604708f, 0.03533106f, 0.06079428f, 0.01540550f, 
    0.15636103f, 0.12516572f, 0.21141922f, 0.01308605f, -0.09403291f, -0.02089536f, 0.08632216f, 0.19615005f, 
    -0.05599390f, -0.14044885f, -0.04162892f, 0.12486931f, -0.00642573f, -0.02399973f, -0.02166977f, 0.01649339f, 
    0.13105595f, -0.07059322f, -0.03149866f, -0.07044741f, -0.09833247f, -0.05773472f, -0.06002436f, 0.07247394f, 
    0.00990839f, -0.07902341f, -0.01103375f, -0.26459673f, -0.18984824f, -0.21900597f, -0.16055267f, 0.00030340f, 
    -0.00658146f, -0.01286491f, -0.08904595f, 0.02845534f, 0.05002700f, -0.17583150f, -0.10413918f, -0.16526379f, 
    -0.09526929f, -0.09215949f, -0.08604888f, 0.04926561f, -0.02963772f, -0.06893253f, 0.03781819f, -0.20245919f, 
    -0.19099236f, -0.08755382f, -0.31197062f, -0.03440828f, -0.11243891f, -0.05885636f, -0.06374071f, -0.09062783f, 
    -0.03548941f, -0.00215124f, -0.05833346f, -0.04198498f, 0.05709661f, 0.00324333f, 0.05177530f, -0.06509367f, 
    0.11173751f, 0.00899986f, 0.00204075f, -0.00514259f, -0.15009432f, 0.24892272f, -0.05726944f, 0.19406152f, 
    0.22591767f, 0.12075800f, 0.03137112f, 0.01943812f, 0.17514440f, 0.28875536f, -0.04536209f, 0.05428034f, 
    0.05282334f, -0.01862968f, 0.09943559f, 0.18200283f, -0.00302795f, 0.11900744f, 0.22491749f, 0.14769742f, 
    0.94175160f, 0.51806480f, -0.25662708f, -0.19770253f, 0.20079152f, 0.04503155f, 0.33027837f, -0.10145976f, 
    0.42117909f, 0.17156447f, -0.02445115f, 0.15453163f, -0.02684253f, 0.06018522f, -0.01787335f, 0.01169885f, 
    -0.10461451f, 0.16184337f, 0.18523844f, 0.10023750f, 0.18477462f, 0.02684932f, 0.08696090f, 0.11749301f, 
    -0.03134234f, 0.05432866f, -0.02150888f, 0.05098020f, 0.10366306f, 0.24640463f, -0.01957533f, 0.05408313f, 
    0.09162780f, -0.06901272f, 0.22540015f, 0.14250965f, -0.07794156f, 0.09563202f, 0.17026322f, 0.11813106f, 
    0.17750303f, -0.47051591f, -0.07409182f, -0.04443568f, -0.11422648f, 0.13545406f, 0.07785179f, -0.03521247f, 
    0.03823745f, -0.05003964f, 0.07609511f, -0.02194932f, -0.00677273f, -0.01691462f, 0.09670862f, 0.03811196f, 
    0.07947876f, 0.11158125f, 0.05301342f, 0.20243300f, 0.07999888f, -0.03334938f, -0.34812635f, 0.06302539f, 
    -0.29451737f, -0.04716760f, -0.19389614f, -0.10804332f, -0.07763872f, -0.09041781f, 0.00029565f, -0.10881827f, 
    0.00599084f, -0.10921987f, 0.03270492f, -0.05668506f, 0.13466510f, -0.03120940f, 0.00428912f, 0.00840126f, 
    0.29245046f, 0.05860399f, 0.15683505f, 0.14804892f, 0.46072331f, 0.06741055f, 0.07594212f, -0.21138293f, 
    0.03732641f, -0.01756200f, 0.06828988f, 0.10934143f, 0.10323066f, 0.25413698f, 0.15792239f, 0.25569132f, 
    -0.05565884f, 0.11495972f, 0.16788088f, 0.05307175f, 0.22018351f, 0.20880063f, 0.33106637f, -0.01633698f, 
    -0.06960021f, 0.08109082f, -0.14151460f, -0.12776095f, 0.07570443f, 0.13285890f, -0.11828384f, -0.04326260f, 
    -0.01252847f, 0.04202834f, 0.09265126f, -0.02806323f, -0.10227577f, 0.16202341f, -0.07348083f, 0.04187217f, 
    -0.15549578f, 0.03511806f, 0.48628810f, -0.06403784f, -0.11698591f, -0.12280773f, 0.05160752f, -0.07501708f, 
    0.00639291f, -0.04378192f, -0.08320091f, 0.00602494f, 0.11707463f, -0.13346970f, 0.04095073f, -0.09231640f, 
    0.10098685f, 0.08008712f, 0.02349542f, -0.05351435f, 0.32609475f, -0.33068562f, 0.00514255f, -0.12878606f, 
    -0.16358688f, -0.04617528f, -0.08792584f, -0.10533419f, -0.15389198f, -0.09211631f, -0.07916873f, 0.02667411f, 
    0.08910031f, -0.05461683f, 0.13621219f, 0.03140104f, 0.10606373f, -0.05904036f, -0.10154571f, 0.09549283f, 
    0.03399312f, 0.04104600f, 0.50727785f, 0.04354035f, 0.06495865f, -0.03921439f, 0.09432819f, -0.09424144f, 
    -0.03688067f, -0.09367906f, -0.11378326f, 0.04006988f, 0.06149776f, 0.02411114f, -0.00805900f, -0.01388085f, 
    0.10862386f, 0.13444002f, -0.09930543f, 0.01872817f, -0.01798857f, 0.20941196f, 0.13173608f, 0.00848981f, 
    0.00972975f, 0.01028007f, -0.05751592f, 0.12870319f, 0.04307290f, -0.00736406f, 0.00985220f, 0.14021669f, 
    0.03359443f, 0.08840571f, 0.08276513f, 0.14050807f, 0.08759375f, 0.14138108f, 0.08893479f, -0.02181975f, 
    -0.19262227f, -0.05070823f, -0.10582088f, -0.08915551f, 0.17144941f, -0.08286526f, 0.08695269f, 0.01901080f, 
    0.12786078f, -0.00491431f, -0.03129713f, -0.01479759f, 0.04337616f, 0.06989506f, -0.01067346f, -0.13623053f, 
    -0.12318524f, 0.03249135f, -0.09466843f, 0.01210873f, 0.50143117f, 0.03193148f, 0.15316369f, 0.21257871f, 
    -0.05249328f, 0.02827202f, 0.03537175f, -0.05595922f, 0.05775172f, 0.09241410f, 0.09571635f, -0.08831751f, 
    -0.01531996f, 0.03389698f, 0.04668708f, -0.00542578f, -0.03396195f, 0.10609471f, -0.01249873f, 0.04054753f, 
    -0.04510630f, -0.07794549f, -0.04212000f, 0.12331606f, 0.12800215f, 0.17986840f, -0.05768580f, 0.02198186f, 
    0.05359865f, 0.21424724f, 0.07693935f, 0.03146688f, -0.04725055f, -0.06295200f, -0.01400253f, -0.02130532f, 
    -0.05400511f, 0.00770128f, -0.05466378f, 0.11242535f, 0.00329726f, -0.19259019f, -0.06868739f, 0.00612007f, 
    0.06108040f, 0.02027439f, 0.04374343f, 0.02617919f, 0.00376760f, 0.07108343f, 0.05295604f, -0.02246133f, 
    0.05780360f, -0.00362146f, 0.04991631f, 0.03010475f, 0.15735574f, 0.05320547f, -0.05442285f, -0.06112090f, 
    0.18286327f, -0.15615158f, -0.23655351f, -0.12679863f, -0.06031146f, -0.03026450f, 0.13873895f, 0.02626082f, 
    -0.06635913f, 0.04470075f, 0.02570337f, -0.07787599f, 0.19366379f, -0.00412054f, 0.09170802f, 0.00537288f, 
    0.09693875f, 0.07880774f, -0.06773911f, 0.09956296f, 0.44871253f, -0.24795946f, 0.33303127f, -0.02325161f, 
    0.18823604f, 0.15934327f, 0.13660729f, -0.11018734f, 0.19658054f, -0.12532777f, -0.05263712f, -0.01522090f, 
    0.13401534f, -0.16788696f, -0.02822463f, 0.11991974f, -0.01674565f, -0.03474592f, 0.02024465f, 0.03835880f, 
    -0.51942939f, -0.38952720f, -0.30818784f, -0.24162324f, -0.25703529f, -0.19588339f, -0.06319331f, -0.20125009f, 
    -0.08059640f, -0.20338601f, -0.13426124f, 0.01005236f, -0.04227288f, -0.01225546f, 0.12784614f, -0.06166975f, 
    -0.06509345f, -0.02810906f, 0.05049738f, -0.09259187f, -0.05928635f, -0.35196471f, -0.19898197f, 0.02157103f, 
    -0.03769248f, 0.01840424f, 0.04293758f, 0.08915506f, 0.02926832f, -0.10912438f, -0.01817629f, 0.01298362f, 
    -0.02706212f, -0.04096032f, -0.00881581f, -0.02889061f, 0.02262265f, 0.08128701f, -0.00553148f, 0.10553040f, 
    -0.01696736f, 0.00083684f, 0.00150276f, 0.00896248f, -0.03979847f, -0.00360504f, 0.00024060f, -0.01382173f, 
    -0.01188082f, 0.00676959f, 0.03059159f, -0.00306321f, 0.02015254f, 0.00854127f, -0.03896850f, -0.03375847f, 
    -0.02686568f, 0.01214714f, -0.00876832f, -0.01623857f, -0.04101082f, 0.01279583f, -0.04171905f, -0.02764716f, 
    -0.00844776f, 0.02820738f, -0.01541921f, 0.02413904f, 0.01493534f, 0.00534024f, -0.00484921f, -0.03023075f, 
    -0.02108791f, 0.02765027f, -0.01833478f, 0.01963048f, 0.02631493f, -0.00015160f, -0.01445857f, -0.02139768f, 
    -0.00285948f, 0.02787028f, -0.02052924f, 0.00081976f, 0.00940239f, -0.00372013f, 0.01938599f, -0.00138296f, 
    -0.00127609f, 0.03542913f, -0.03373442f, -0.01895092f, 0.01023957f, 0.00161457f, -0.00209933f, 0.03433399f, 
    -0.00734927f, -0.00644967f, -0.04589730f, 0.01274021f, -0.01504865f, -0.01708307f, -0.01820081f, -0.01653924f, 
    0.02776632f, -0.03985725f, -0.02113661f, -0.02465613f, 0.02030023f, 0.03295173f, 0.00741662f, 0.00924900f, 
    0.03079886f, -0.02408790f, -0.04422718f, 0.01031978f, -0.01970084f, -0.02286920f, -0.03230864f, 0.02317469f, 
    0.02001243f, -0.03887848f, 0.00926953f, -0.02118602f, 0.02120726f, -0.02713356f, -0.03462518f, -0.03937916f, 
    0.03208114f, 0.02537439f, -0.01779540f, -0.04545766f, -0.04277796f, -0.00239604f, 0.01022273f, 0.03427248f, 
    0.03494662f, -0.02735771f, -0.02392844f, 0.00561235f, -0.02423001f, 0.02248173f, -0.01639055f, -0.01909371f, 
    -0.00887375f, 0.01063928f, 0.03480873f, 0.01312606f, 0.01950975f, 0.00473461f, 0.02687463f, -0.00317529f, 
    0.01231070f, -0.04223530f, -0.02841144f, 0.02365967f, 0.00631435f, -0.02664627f, 0.03340749f, -0.00423607f, 
    -0.04208277f, -0.04325584f, -0.01236674f, 0.00521862f, 0.01955667f, -0.03157635f, -0.00704667f, -0.04086888f, 
    0.01485140f, 0.03177852f, -0.01671071f, -0.04210007f, -0.00662618f, 0.00736120f, -0.00958046f, -0.02253495f, 
    0.03170938f, -0.01765240f, -0.01530837f, 0.03038890f, -0.02224518f, 0.00747306f, -0.04028431f, 0.02682087f, 
    -0.00618627f, -0.01186968f, -0.01187900f, -0.01033941f, 0.01598910f, -0.03119237f, -0.01479654f, 0.02453530f, 
    0.00309142f, -0.02874640f, -0.01501355f, -0.02806154f, -0.04323844f, -0.01466961f, 0.01584434f, 0.00518038f, 
    -0.02600444f, 0.03045323f, -0.02417605f, -0.01593409f, -0.01771687f, -0.02086242f, -0.04481852f, -0.00449659f, 
    0.03412409f, -0.03019352f, 0.02253670f, -0.02617402f, -0.01471741f, -0.03527940f, -0.03170710f, -0.03184886f, 
    -0.01616014f, -0.04791471f, 0.00675657f, -0.01676647f, -0.03025255f, -0.02428716f, 0.01612725f, 0.01560624f, 
    -0.04056020f, 0.00695056f, -0.04286256f, -0.00033924f, -0.00174956f, -0.03133734f, -0.03494507f, 0.01598719f, 
    -0.00005530f, 0.02034163f, -0.01694265f, -0.00614084f, 0.01700029f, 0.01221752f, 0.03155235f, -0.01415570f, 
    -0.00417772f, 0.00033486f, -0.00399924f, -0.00221969f, 0.01888193f, -0.02755970f, 0.02031396f, 0.02615035f, 
    0.01290871f, -0.02012360f, 0.02395979f, -0.03479222f, -0.01331733f, 0.01077142f, -0.03921217f, -0.01164008f, 
    -0.02621474f, -0.00782888f, 0.00702818f, 0.02668016f, -0.03088347f, -0.02118194f, -0.03803788f, -0.03523766f, 
    -0.01532533f, 0.01566426f, 0.01550614f, -0.03748437f, -0.00069390f, -0.00506352f, 0.01415300f, 0.02270778f, 
    -0.03082030f, -0.03749481f, -0.01526359f, 0.02388054f, 0.01192105f, -0.01650020f, -0.02512278f, -0.03776073f, 
    0.00612776f, 0.00155854f, -0.03005763f, 0.02851141f, 0.00144436f, 0.00921611f, -0.02381075f, -0.04024974f, 
    0.00670951f, -0.04148361f, 0.01586347f, 0.00013249f, 0.01458882f, -0.04093412f, -0.00690254f, -0.04137446f, 
    -0.03192411f, -0.01696001f, 0.00596089f, -0.01195116f, -0.01808869f, 0.01119272f, -0.01732945f, 0.00938446f, 
    0.01207389f, 0.01834222f, 0.02104001f, -0.02076202f, 0.03881032f, 0.01664504f, 0.02284904f, -0.01737209f, 
    -0.00600502f, -0.01555789f, 0.02441019f, -0.01613392f, 0.01348646f, 0.01808875f, 0.03355886f, 0.00919128f, 
    0.00137470f, -0.02222201f, -0.01182769f, 0.00142193f, -0.03551035f, -0.03753764f, -0.02397447f, 0.02951411f, 
    -0.01260590f, 0.01282891f, 0.01615687f, 0.02232785f, -0.01964720f, 0.02135340f, -0.01711284f, 0.00504746f, 
    -0.02485562f, -0.03981903f, 0.02110451f, -0.03902968f, 0.01039722f, -0.00785964f, -0.00475913f, 0.00692370f, 
    -0.00642304f, -0.04061640f, 0.01489179f, 0.00256830f, -0.02150613f, 0.00736200f, 0.02212177f, -0.03177913f, 
    -0.01673296f, 0.01879622f, 0.00671618f, 0.00222952f, 0.03175822f, 0.03375188f, 0.02687537f, -0.00720690f, 
    -0.00499773f, 0.02790715f, 0.03345318f, 0.03442438f, -0.04453052f, 0.02555957f, 0.03157197f, 0.01629912f, 
    0.02670016f, 0.00834356f, 0.02787825f, -0.04355210f, -0.02765249f, 0.02164366f, 0.01154242f, -0.04717714f, 
    0.00529784f, -0.00028701f, 0.00899702f, -0.02053767f, -0.02012712f, -0.00508188f, 0.02177283f, 0.00758583f, 
    -0.00911132f, 0.01954371f, -0.02751801f, 0.03046901f, 0.01732172f, 0.02921515f, 0.02078657f, -0.00167285f, 
    -0.01984411f, 0.01222005f, 0.01250751f, 0.01400624f, -0.00050404f, -0.01394016f, 0.00081188f, -0.03405224f, 
    -0.03601041f, -0.01108945f, 0.01214880f, -0.02212695f, 0.02814285f, -0.04504275f, 0.02129102f, 0.02954962f, 
    -0.03641679f, 0.01864592f, -0.01803004f, -0.02222974f, 0.01536668f, -0.00788475f, 0.00204074f, 0.00143114f, 
    0.01160471f, -0.00080935f, 0.03501565f, -0.03517051f, -0.04494311f, 0.00709627f, -0.03683892f, 0.00230946f, 
    -0.01643993f, -0.03095540f, 0.02891534f, -0.03147899f, -0.03441360f, -0.02740305f, 0.00151608f, 0.00749408f, 
    0.01286155f, -0.02545720f, 0.02953004f, 0.03624134f, -0.02983575f, 0.00663665f, -0.00263193f, 0.03016214f, 
    0.00346781f, -0.00570860f, -0.01783502f, 0.02271993f, -0.01038827f, 0.00116461f, 0.02181436f, -0.02643322f, 
    0.00499367f, -0.00484207f, -0.01790121f, 0.01328835f, 0.02938984f, 0.01013278f, -0.00611870f, -0.00360563f, 
    0.00054770f, -0.00631452f, -0.03223744f, -0.00844201f, -0.04601981f, -0.00241470f, -0.01113982f, -0.04168107f, 
    -0.01103459f, -0.00242273f, -0.04242314f, -0.02299216f, -0.00116391f, 0.01944004f, 0.01035803f, 0.00806871f, 
    -0.00663927f, -0.02021137f, -0.02747453f, 0.01889768f, -0.00165142f, 0.01418638f, -0.03265309f, -0.03604544f, 
    -0.01693449f, 0.01395008f, -0.04078655f, 0.02597945f, 0.03414843f, -0.00216196f, -0.01690524f, -0.03730637f, 
    0.03181201f, 0.01655619f, -0.04050415f, 0.00669088f, -0.01820081f, 0.02366328f, -0.00589126f, -0.02077075f, 
    0.01150751f, 0.03584443f, 0.03271092f, -0.01746999f, -0.02632290f, -0.03800039f, -0.01386760f, 0.01661830f, 
    -0.00220273f, -0.03911008f, -0.01236520f, 0.00153431f, 0.03244546f, -0.01199787f, 0.00205833f, -0.01736479f, 
    -0.03602849f, 0.02583895f, 0.01547195f, -0.00139545f, -0.02489563f, -0.00938293f, 0.02274448f, -0.01448845f, 
    -0.02700294f, 0.01422222f, 0.02250080f, 0.00160428f, 0.04358572f, -0.04078660f, 0.02295035f, -0.01590739f, 
    -0.00858329f, 0.00155361f, 0.00989584f, -0.02976578f, -0.02398901f, 0.01970292f, -0.01071916f, -0.04215620f, 
    0.00631423f, -0.04447566f, 0.00059210f, -0.02641825f, 0.01942770f, 0.01126242f, 0.01402482f, -0.02548119f, 
    -0.03431562f, -0.00487493f, 0.01981363f, 0.02655273f, 0.01664202f, -0.01581849f, -0.02734491f, -0.02248634f, 
    0.00534931f, 0.03031680f, 0.02770291f, -0.02285560f, -0.01422157f, -0.02560822f, -0.02362308f, -0.04329847f, 
    -0.01194382f, 0.00654744f, 0.01255420f, 0.01928976f, 0.02449062f, -0.02633298f, 0.02938067f, -0.02004559f, 
    -0.00013533f, -0.00462067f, -0.02404008f, 0.01605259f, -0.02419456f, 0.01345968f, -0.02307533f, 0.01587356f, 
    -0.00841088f, 0.00862570f, -0.03898632f, -0.02842442f, -0.03165365f, 0.00180772f, -0.00010858f, 0.01465907f, 
    0.00280773f, 0.01932806f, -0.01994330f, -0.01760111f, 0.02338900f, -0.03927711f, -0.01056878f, 0.01212671f, 
    -0.01645252f, 0.01565926f, 0.01172271f, 0.02847405f, -0.00672052f, 0.00948928f, -0.03213502f, -0.00261979f, 
    0.01997691f, -0.01794978f, 0.02318003f, 0.00963240f, 0.00880892f, 0.01364424f, 0.02357520f, -0.03219970f, 
    0.01164726f, -0.00546977f, 0.02402861f, -0.01565322f, -0.00850989f, 0.01655197f, -0.03460516f, -0.03774470f, 
    -0.03665867f, -0.03816414f, 0.00755405f, 0.01452139f, 0.02997485f, -0.01692990f, 0.02322696f, 0.02868347f, 
    -0.00183466f, 0.01385189f, 0.03107429f, 0.01465049f, 0.03206121f, 0.02846450f, -0.01566844f, -0.00524929f, 
    -0.00350526f, -0.01509269f, -0.01550000f, -0.03236802f, 0.01173039f, 0.00743538f, 0.03595982f, -0.02154222f, 
    -0.01927022f, -0.00771264f, 0.02775426f, -0.03860097f, 0.00062189f, -0.01188817f, 0.02268626f, -0.01664296f, 
    -0.00796355f, 0.00420911f, -0.01381391f, -0.03846428f, 0.02034155f, 0.02789579f, 0.00023591f, -0.01923884f, 
    -0.03499379f, -0.01233410f, -0.00905563f, -0.02135216f, 0.02100825f, -0.01523917f, -0.02897693f, 0.04326458f, 
    0.01598739f, -0.00545997f, 0.01610341f, 0.02475658f, -0.02161066f, -0.02479018f, 0.01279583f, -0.03857931f, 
    0.00985147f, -0.00058191f, -0.03134224f, 0.01929581f, 0.00316579f, 0.00080241f, -0.02170948f, -0.00750559f, 
    0.01225610f, -0.15702061f, -0.35706392f, 0.10915433f, -0.06616154f, -0.04160772f, -0.04891415f, -0.03091858f, 
    -0.00744555f, 0.09803096f, -0.05749472f, 0.09361375f, -0.07798685f, -0.05978554f, 0.01318739f, -0.00302733f, 
    -0.05809441f, -0.08260925f, -0.08158370f, 0.01635144f, 0.11885057f, 0.07108155f, 0.04052067f, 0.07548615f, 
    -0.07775386f, 0.00448806f, -0.01432635f, -0.02497580f, 0.10250659f, -0.03758633f, 0.01032088f, 0.05356049f, 
    0.00895623f, 0.04392149f, -0.01418096f, -0.00537867f, 0.05152967f, -0.08564052f, -0.10646249f, -0.02205041f, 
    0.34403905f, -0.07535993f, -0.26559317f, 0.17516485f, -0.19689269f, 0.07983848f, 0.06983376f, 0.04606904f, 
    -0.17609106f, 0.02000489f, -0.02089623f, -0.09946087f, 0.02069749f, -0.13595760f, -0.03351673f, 0.08191035f, 
    0.03997296f, 0.00373587f, -0.09481912f, -0.01601174f, -0.15733667f, -0.01078373f, -0.06869529f, 0.25149170f, 
    -0.00987931f, -0.00736423f, -0.00417430f, 0.06609572f, 0.03516738f, 0.04557760f, -0.03353236f, -0.02157770f, 
    -0.05355063f, 0.01788234f, 0.04893620f, -0.02227337f, -0.02172987f, 0.06897029f, -0.02619671f, -0.17863029f, 
    -0.32300571f, -0.11061388f, -0.01851816f, 0.24736604f, -0.04386681f, 0.03368486f, -0.06011553f, 0.22377533f, 
    0.04319124f, -0.08892322f, -0.01897656f, 0.00383784f, 0.00333476f, 0.16433908f, -0.13219170f, 0.16578235f, 
    -0.03205432f, 0.05616185f, -0.17634837f, -0.02733215f, -0.22257131f, -0.25213382f, 0.24219021f, -0.17890233f, 
    0.39435866f, -0.23673168f, 0.09507480f, 0.13875322f, -0.03510597f, 0.04471516f, 0.01713664f, -0.08540637f, 
    0.02613092f, 0.05277303f, 0.01138202f, 0.25541997f, 0.10642027f, 0.11163182f, 0.08264375f, 0.19389389f, 
    0.30272791f, -0.04312762f, 0.15586676f, 0.15542744f, 0.04235544f, -0.08783974f, -0.07699455f, 0.00036292f, 
    -0.03287878f, -0.08927318f, -0.03050994f, -0.00176204f, -0.06945224f, -0.08687101f, 0.00388223f, 0.11836533f, 
    0.01048787f, 0.05414609f, -0.02095992f, 0.11996309f, -0.19754264f, -0.25588027f, 0.03881206f, 0.48174131f, 
    -0.23371743f, -0.01721489f, 0.06760645f, -0.00095004f, 0.06524002f, -0.05745618f, -0.16184247f, 0.09453908f, 
    0.07121138f, 0.16821107f, 0.03298881f, 0.08515237f, 0.00034963f, 0.05531111f, -0.12889087f, 0.09934688f, 
    0.11723793f, 0.18429132f, 0.32072765f, 0.04033330f, -0.10371340f, -0.11864295f, 0.13143992f, 0.06835458f, 
    0.03270689f, -0.12229516f, -0.01143619f, -0.01297984f, -0.00017001f, -0.01645480f, -0.01410093f, 0.05316367f, 
    -0.06214875f, -0.08850930f, 0.07962613f, -0.04991763f, -0.21582222f, -0.02218039f, 0.02764144f, 0.07201794f, 
    0.03518458f, -0.08436588f, -0.01630386f, 0.16066487f, -0.11503888f, -0.04794384f, -0.02620547f, 0.10110213f, 
    0.06255314f, 0.05103573f, -0.06080003f, -0.00771147f, -0.07250994f, 0.05527195f, -0.11037097f, -0.16011821f, 
    0.13097900f, 0.15712921f, -0.09128223f, -0.09649788f, 0.18199763f, 0.15113769f, 0.01442117f, 0.05192144f, 
    -0.09123039f, 0.14740853f, 0.07179873f, 0.06045987f, 0.05004326f, -0.02733132f, 0.04414590f, 0.09525933f, 
    -0.01263238f, 0.17940430f, 0.13391714f, 0.04348694f, 0.24291375f, 0.26162401f, -0.02059305f, 0.00988234f, 
    0.21753073f, 0.04740356f, 0.07873920f, 0.05235636f, -0.06821181f, 0.13681500f, 0.08162578f, 0.13680552f, 
    0.07825153f, -0.05523542f, 0.02039372f, 0.05861418f, 0.00797474f, 0.13237007f, 0.12210779f, 0.10213863f, 
    -0.10391176f, -0.08973576f, 0.03945873f, -0.01447429f, -0.11351237f, -0.02357129f, 0.05708111f, 0.03379518f, 
    0.09040262f, -0.04056902f, 0.01507652f, 0.13308069f, 0.02358437f, -0.01304602f, -0.02032230f, -0.05400928f, 
    -0.04186117f, -0.00922192f, -0.04764352f, 0.02505729f, 0.09159128f, -0.03526673f, 0.01896326f, 0.15340413f, 
    -0.12293465f, 0.05984147f, 0.09110384f, 0.00506504f, 0.21295737f, -0.18160138f, -0.13429005f, -0.16110434f, 
    0.02443238f, 0.12695427f, 0.07597292f, 0.04114619f, 0.17679313f, -0.03290148f, 0.05280374f, -0.03160185f, 
    -0.19305527f, -0.93208086f, 0.26553932f, -0.37068033f, 0.17013489f, 0.12115113f, 0.11712205f, 0.13705990f, 
    0.04713898f, 0.08501592f, -0.00010904f, 0.17075874f, -0.04678585f, 0.12938036f, 0.06560902f, 0.08957927f, 
    0.02164349f, -0.02118708f, -0.05225952f, 0.03063837f, -0.15689710f, -0.00130602f, 0.14993352f, 0.02457716f, 
    -0.17076938f, 0.01706207f, 0.00851058f, 0.12978169f, 0.11247545f, -0.13698834f, -0.02547634f, -0.12782818f, 
    0.06370150f, 0.16697395f, 0.04357214f, -0.02515085f, 0.12270916f, -0.01535274f, 0.01019320f, -0.20587525f, 
    -0.10264200f, 0.33379415f, -0.05319864f, 0.05102858f, 0.34825447f, -0.23601758f, -0.15546797f, -0.00049261f, 
    -0.01768377f, 0.14059816f, 0.09013777f, 0.08454238f, 0.02437756f, -0.00018956f, -0.01538899f, 0.04487408f, 
    -0.07917089f, -0.02009129f, 0.00396468f, -0.08075021f, -0.08431545f, 0.00018010f, -0.01154903f, 0.01632638f, 
    -0.08727048f, -0.06875230f, -0.01344404f, 0.05085357f, 0.12414041f, -0.06616583f, -0.00352103f, 0.29371449f, 
    0.04941572f, -0.07279141f, -0.03876848f, 0.00649981f, -0.10491128f, 0.02936174f, 0.00649369f, -0.07016978f, 
    -0.30396461f, -0.12915233f, 0.16777506f, 0.14181419f, 0.09932432f, -0.04828922f, 0.17874075f, 0.07181882f, 
    0.07493746f, 0.13997042f, -0.15815099f, 0.13787405f, -0.07798193f, -0.04333400f, 0.03882603f, -0.36661515f, 
    0.06507880f, -0.06066552f, -0.14054015f, 0.04980299f, 0.42326537f, -0.00155330f, 0.35144606f, -0.07551249f, 
    0.00979760f, -0.09050754f, -0.00835587f, 0.06562380f, 0.05466779f, -0.14065744f, -0.00033889f, -0.03391762f, 
    0.00373374f, -0.03103993f, -0.02305473f, 0.20633891f, 0.25196996f, 0.03484995f, -0.03322555f, 0.11386248f, 
    0.33248720f, 0.21331176f, 0.07662136f, 0.20928164f, -0.35798314f, -0.02847431f, -0.10458863f, 0.02745407f, 
    0.09656184f, -0.03429628f, -0.08729447f, 0.04785373f, -0.05461189f, -0.00238339f, -0.00965879f, 0.13130748f, 
    0.17335941f, 0.04155839f, 0.12559935f, 0.09522386f, -0.18113846f, 0.16097836f, 0.11128802f, -0.14733690f, 
    -0.04485712f, 0.16191347f, -0.07976481f, 0.20810701f, 0.00229097f, 0.06115484f, -0.12873441f, 0.12413926f, 
    0.09639079f, 0.12632889f, -0.01767308f, 0.02756116f, -0.07427061f, -0.00518523f, 0.03703095f, 0.17686562f, 
    0.15500021f, 0.09192132f, 0.16653012f, 0.04973825f, -0.27756307f, 0.19486518f, -0.01667758f, -0.00157809f, 
    0.00233859f, 0.00347486f, -0.04532317f, 0.02585274f, 0.04703779f, 0.05223929f, 0.03163638f, -0.09650251f, 
    0.12270872f, -0.05592242f, 0.08379466f, 0.17598590f, 0.00083934f, 0.09838013f, -0.03672201f, 0.25650352f, 
    0.10440219f, -0.11572804f, 0.05788752f, 0.16277495f, -0.11387467f, 0.04163434f, -0.27096367f, 0.02334052f, 
    0.00702233f, 0.04962146f, 0.16336918f, 0.00815178f, -0.09748267f, 0.05125226f, -0.04715667f, -0.08013285f, 
    0.09599865f, 0.01667125f, -0.23064508f, 0.19406800f, -0.14707191f, 0.05918435f, 0.01181355f, -0.07809227f, 
    -0.02890971f, 0.11988059f, -0.05901002f, 0.00504394f, 0.05293848f, -0.00767959f, -0.13641582f, 0.11506649f, 
    0.02896900f, 0.01552193f, -0.04178866f, 0.06241465f, -0.08725017f, 0.18713912f, 0.28351945f, -0.03225597f, 
    0.14803879f, -0.00535300f, 0.01688396f, -0.00731566f, 0.12062785f, -0.20760417f, -0.14297287f, -0.04374223f, 
    -0.04814774f, -0.05335483f, -0.10042812f, 0.14041264f, 0.01470731f, 0.05112734f, -0.04706935f, 0.01493343f, 
    0.08735249f, 0.05784147f, -0.19052476f, -0.00402031f, -0.02543186f, -0.02987042f, -0.00267429f, 0.06495433f, 
    0.04495127f, 0.03738514f, -0.07160074f, -0.14271308f, -0.05303340f, -0.03489174f, -0.00197290f, 0.01323376f, 
    0.11601004f, -0.03024078f, 0.04405900f, -0.03986761f, -0.12786110f, -0.16246966f, 0.00270029f, 0.01675085f, 
    -0.12785147f, 0.00677443f, -0.05358772f, -0.02206379f, -0.01797420f, 0.00674954f, 0.04808861f, 0.02716762f, 
    -0.09091801f, -0.09269842f, 0.04228053f, -0.09372994f, -0.01019198f, -0.02860011f, -0.01137343f, -0.02925553f, 
    -0.05766322f, -0.08581962f, 0.20850854f, -0.17371905f, 0.02413840f, 0.03822929f, 0.01755993f, 0.12211512f, 
    -0.02741569f, -0.00387799f, -0.00335722f, 0.20834771f, 0.04445243f, 0.07562092f, 0.16556260f, -0.06682329f, 
    -0.00032949f, -0.07203925f, -0.02403858f, -0.05166627f, 0.17716749f, 0.07343267f, 0.13904069f, 0.02120133f, 
    0.06967182f, 0.07255009f, -0.26768994f, -0.12727569f, 0.02668373f, -0.00199690f, -0.05497268f, 0.01296284f, 
    0.00643475f, 0.05806008f, -0.02844391f, 0.00659861f, -0.00743247f, -0.04206543f, -0.00376313f, 0.08094934f, 
    0.12223378f, 0.10257939f, 0.15605962f, 0.08571386f, -0.07258438f, -0.06063214f, 0.01422279f, -0.01681089f, 
    -0.01370230f, -0.03233028f, 0.04581596f, 0.15334804f, 0.05512144f, 0.06079818f, 0.00808641f, 0.02381432f, 
    -0.09648609f, -0.08640595f, -0.18012287f, -0.09741083f, 0.01405995f, 0.17774649f, -0.09992385f, 0.30595574f, 
    0.22728063f, -0.08436387f, -0.15008442f, -0.09547949f, -0.07018670f, 0.16843046f, 0.02060042f, 0.03118248f, 
    -0.00349547f, -0.02505372f, 0.02740572f, 0.07471655f, -0.04213465f, 0.01302631f, -0.08489220f, -0.11384878f, 
    -0.29203984f, -0.31963286f, -0.45969889f, -0.24959375f, 0.02825376f, 0.12521134f, 0.12034122f, 0.07461487f, 
    -0.09257749f, -0.04212277f, 0.04515596f, 0.15501161f, 0.10227033f, 0.11247130f, 0.02353738f, -0.02043355f, 
    0.12522538f, 0.16291904f, 0.01379260f, 0.01768639f, 0.30344242f, -0.06652743f, 0.13662638f, 0.01831791f, 
    -0.00803167f, -0.04196383f, -0.10363872f, -0.04652244f, -0.14593734f, -0.13647227f, 0.00940954f, 0.03893140f, 
    0.07687508f, 0.03256374f, 0.06488367f, 0.00488713f, 0.05122965f, -0.02116163f, 0.02536418f, -0.00640447f, 
    0.42189541f, 0.35150093f, -0.23464888f, -0.35989353f, 0.04716600f, 0.19972557f, 0.18551564f, 0.19484362f, 
    0.16013713f, -0.10703941f, 0.13748541f, -0.00365229f, 0.06863789f, -0.09070227f, 0.06046250f, 0.02551549f, 
    -0.07206630f, 0.01540793f, 0.02458213f, -0.01647596f, -0.15721032f, 0.13700837f, -0.31332541f, -0.24244142f, 
    0.11412622f, 0.10423417f, 0.10559634f, -0.07504700f, 0.12281609f, -0.02439247f, -0.02197884f, 0.01845484f, 
    0.06113912f, 0.00613739f, -0.08964276f, 0.01834038f, -0.05958408f, 0.11899835f, 0.14615276f, 0.13352294f, 
    0.45959964f, -0.09903978f, -0.16964518f, -0.08325382f, 0.05479587f, -0.18589669f, -0.07633994f, -0.12421457f, 
    -0.08839577f, -0.01165631f, -0.02649560f, 0.13181262f, 0.16092689f, 0.06498823f, -0.01233977f, 0.05049020f, 
    -0.01208241f, 0.10877942f, -0.15382862f, -0.20539632f, 0.09829874f, 0.12449744f, 0.23859206f, -0.21886654f, 
    0.14740649f, 0.09296592f, 0.14914683f, -0.12658145f, 0.18241675f, -0.12532370f, 0.05122418f, -0.00275866f, 
    -0.08388422f, -0.02931768f, 0.08709063f, -0.00222641f, 0.13523550f, 0.04570649f, 0.12207086f, 0.00686718f, 
    -0.20601614f, -0.03034810f, 0.11665791f, -0.08374415f, 0.03984351f, -0.05945477f, -0.08354029f, 0.02234778f, 
    -0.03233172f, -0.04605418f, 0.00576048f, -0.08507285f, -0.03141594f, 0.01765758f, -0.03317446f, -0.10744131f, 
    -0.09068067f, 0.12439247f, 0.01396120f, -0.23140816f, 0.20854208f, 0.02698917f, -0.13726738f, 0.03903766f, 
    -0.04576113f, -0.10349879f, -0.03846265f, -0.07996430f, -0.04904046f, 0.04080971f, 0.03844130f, -0.19452079f, 
    -0.07971477f, -0.10098084f, 0.03030277f, 0.02444553f, -0.01735158f, -0.07371318f, 0.16443786f, -0.13164359f, 
    0.18901114f, 0.28114155f, -0.07024484f, -0.40281197f, -0.16363740f, -0.07064579f, -0.14164692f, -0.00876135f, 
    -0.16578880f, -0.10486349f, -0.02227604f, 0.03027352f, 0.14014046f, 0.00203382f, 0.04122643f, -0.03382895f, 
    0.03975664f, 0.13572180f, -0.06579980f, -0.03468646f, 0.11612324f, 0.23103812f, -0.10191075f, -0.20127508f, 
    -0.08102324f, -0.17768651f, -0.04022639f, -0.07544841f, -0.05427844f, -0.16606031f, 0.04377888f, -0.07452638f, 
    0.16050443f, -0.03184309f, 0.01212387f, 0.14524738f, 0.13319659f, 0.03789708f, 0.01236886f, 0.08457063f, 
    0.31037664f, 0.24246137f, 0.23297240f, -0.08355451f, 0.01309516f, 0.13765067f, 0.10170643f, 0.06449220f, 
    0.09283399f, 0.13526027f, 0.01873360f, -0.05295206f, -0.00347761f, 0.00005435f, 0.02987537f, -0.04264254f, 
    -0.08003213f, 0.03403480f, -0.05996740f, -0.19886535f, 0.38046435f, 0.32066542f, 0.18996482f, -0.06475089f, 
    0.03138953f, 0.25236002f, 0.08479482f, 0.06010638f, 0.00376768f, 0.01404997f, 0.02791065f, -0.06213460f, 
    -0.02512183f, 0.00830912f, 0.14808002f, -0.04653228f, -0.02555231f, 0.02140747f, -0.02455306f, -0.04358610f, 
    0.07216156f, -0.18065119f, -0.12954478f, -0.09754261f, -0.14184409f, -0.09088833f, -0.06576630f, -0.15343401f, 
    -0.14309828f, -0.13028188f, -0.01641122f, 0.10480669f, 0.05745208f, 0.05787765f, -0.02760136f, -0.07178695f, 
    0.10404742f, 0.09169074f, 0.04244470f, 0.07443673f, 0.49447978f, 0.09140149f, -0.10692479f, 0.12185225f, 
    0.03859323f, 0.09755266f, -0.07043686f, 0.01572523f, -0.23269548f, 0.09482621f, 0.07334284f, 0.11240104f, 
    -0.02957648f, -0.04239059f, -0.12563537f, 0.08646265f, 0.04944576f, 0.04764687f, -0.15900697f, 0.16768096f, 
    -0.54725534f, 0.46200904f, 0.08293428f, -0.16066699f, 0.04986989f, -0.02703285f, 0.11473419f, -0.03692474f, 
    -0.11971368f, -0.27648577f, 0.02682401f, -0.02137307f, 0.08315004f, 0.02623707f, 0.11959524f, 0.07123503f, 
    -0.01341392f, -0.07959707f, 0.00532210f, 0.07820957f, 0.07876475f, -0.10096879f, -0.09128192f, 0.12039306f, 
    0.07711530f, 0.05575818f, 0.00982830f, -0.04880670f, -0.20367171f, -0.10133141f, 0.03048115f, 0.02917521f, 
    0.00969744f, -0.14526065f, -0.10521246f, 0.10343277f, 0.16588894f, 0.09040215f, -0.06354491f, 0.12548546f, 
    0.38130084f, 0.29309535f, 0.14935602f, -0.18979381f, -0.05115842f, 0.10413673f, 0.05765279f, -0.09546092f, 
    0.18238087f, 0.05304143f, -0.04772699f, -0.00991341f, 0.05411123f, 0.10454505f, 0.02287933f, -0.05166087f, 
    -0.02102748f, -0.02709100f, -0.00584883f, 0.17656548f, 0.11181293f, -0.12900050f, -0.02524621f, -0.11782932f, 
    -0.17205831f, -0.00601753f, -0.07723070f, -0.23226783f, -0.22347289f, -0.12619850f, -0.00900067f, 0.14472130f, 
    0.14617804f, 0.07994519f, -0.10431115f, -0.10350852f, 0.17359442f, 0.12123864f, -0.03096830f, 0.04808687f, 
    -0.60185379f, -0.07829295f, -0.20800006f, -0.07402221f, -0.13929436f, -0.02924078f, -0.08733983f, -0.28489906f, 
    0.01277743f, -0.16854611f, -0.04669232f, 0.08299453f, -0.10567841f, 0.15212964f, -0.02631175f, 0.00921251f, 
    0.27341810f, -0.18913536f, 0.03882433f, 0.12183522f, -0.29934642f, 0.04912072f, 0.17577061f, -0.00428670f, 
    0.04024122f, -0.01511145f, -0.19117306f, -0.09610840f, -0.08033353f, -0.05569702f, 0.00012991f, 0.02464815f, 
    -0.03130466f, -0.06837218f, -0.02986386f, -0.06219040f, 0.07414936f, 0.18820536f, 0.07002026f, -0.14582276f, 
    -0.29559678f, 0.08164936f, -0.09993967f, 0.05275013f, -0.01398142f, -0.08643235f, -0.18809412f, -0.09496445f, 
    -0.08968191f, -0.04783918f, 0.03910792f, -0.03132835f, -0.03977340f, 0.00361299f, 0.07587566f, 0.03554615f, 
    0.11864411f, 0.07068691f, 0.05413165f, 0.02328091f, 0.33393413f, 0.35595682f, 0.07347611f, -0.20251861f, 
    -0.20395799f, -0.00770977f, -0.02507817f, -0.24387313f, 0.20292005f, 0.11558838f, 0.05736491f, 0.06056534f, 
    0.09970973f, -0.08147812f, -0.01424711f, 0.00796193f, 0.11983139f, -0.00829891f, -0.01040398f, 0.25588116f, 
    -0.08120019f, 0.20893750f, 0.06043770f, 0.02369653f, -0.13741869f, -0.06835333f, -0.08689107f, -0.12821797f, 
    0.12747423f, -0.03426093f, 0.06005935f, -0.02180562f, -0.04302058f, 0.03917562f, 0.08738412f, 0.04141171f, 
    0.16779937f, -0.01941721f, 0.02470488f, 0.10584188f, 0.02767143f, 0.29326391f, -0.13323933f, -0.20044513f, 
    0.10024003f, 0.04706009f, 0.03229878f, -0.16473652f, 0.22581822f, -0.06823451f, 0.03385915f, 0.00965333f, 
    -0.00285046f, -0.00707662f, 0.02296648f, -0.05469066f, 0.01788651f, 0.06924340f, 0.07300862f, -0.05610942f, 
    0.36654767f, 0.28356072f, -0.17707740f, -0.18301946f, 0.07177946f, 0.21436635f, 0.20301452f, 0.25940156f, 
    -0.00015574f, 0.04158476f, -0.02079503f, -0.02517640f, -0.02279701f, 0.04391782f, 0.05795561f, 0.00081269f, 
    0.01650805f, -0.02465206f, -0.02277879f, 0.03228370f, 0.15106365f, 0.07032461f, 0.16827407f, 0.19376156f, 
    -0.09886907f, -0.05372652f, -0.07664292f, -0.11970957f, -0.19798765f, 0.13536686f, -0.03739611f, -0.04123588f, 
    -0.05684705f, 0.00430159f, -0.11554292f, -0.14983578f, -0.06372092f, 0.08304732f, 0.07449581f, -0.05307144f, 
    -0.03738707f, 0.10585321f, -0.13268158f, -0.10384730f, 0.05204803f, 0.10242575f, 0.15975665f, 0.13802186f, 
    -0.02569058f, -0.03286645f, 0.03530348f, 0.03372979f, 0.01895771f, 0.01155835f, -0.02912848f, 0.04685813f, 
    0.06534736f, 0.03270401f, 0.08027647f, 0.10691731f, -0.16246784f, -0.26182920f, -0.26556745f, -0.23335162f, 
    0.02528634f, 0.02132176f, 0.03744229f, -0.04219077f, -0.10646892f, -0.05020725f, -0.05252466f, 0.10891291f, 
    0.10537975f, 0.09796742f, 0.01406251f, -0.00302777f, 0.12191883f, 0.14033128f, -0.03842695f, 0.05190234f, 
    -0.26321858f, -0.03162077f, -0.12483676f, -0.02132439f, -0.23458341f, -0.20558514f, -0.25817370f, -0.20258801f, 
    -0.02991356f, -0.03857380f, -0.07085565f, -0.01887244f, -0.12507762f, 0.14004439f, 0.12394625f, 0.09715703f, 
    0.33930725f, -0.03916079f, 0.01978832f, 0.06916296f, -0.14202578f, 0.11937606f, 0.04125907f, -0.17335750f, 
    -0.07911920f, 0.01772206f, -0.00526278f, -0.16267371f, -0.01254654f, 0.23707663f, 0.00314294f, 0.02869650f, 
    0.03074280f, 0.05868502f, 0.09766397f, -0.02824923f, 0.02395148f, 0.02931360f, -0.09777778f, -0.16251752f, 
    0.11617585f, 0.25381628f, 0.07730404f, 0.18868770f, -0.00262762f, -0.05053625f, -0.07624994f, -0.13464016f, 
    -0.12058893f, -0.25216079f, 0.11150416f, -0.09407791f, 0.02898749f, 0.05143286f, 0.14486255f, -0.04770781f, 
    0.11223903f, -0.06946622f, -0.06874914f, -0.04535474f, 0.28127095f, 0.13903457f, 0.00294748f, -0.12996240f, 
    0.02929053f, 0.22111514f, 0.20561039f, 0.06712670f, -0.02036345f, 0.03411697f, -0.01056646f, -0.10167643f, 
    0.09003754f, 0.08259339f, 0.01829709f, -0.03123723f, 0.02139364f, 0.03048946f, -0.05939751f, 0.20502263f, 
    -0.11419097f, 0.25157505f, 0.28542215f, 0.08897799f, 0.12678981f, 0.06343620f, 0.01560954f, -0.00297165f, 
    -0.10652937f, -0.29903415f, 0.07267599f, -0.09814141f, -0.00354142f, 0.06226666f, -0.02785354f, -0.03129267f, 
    -0.02464612f, 0.02696482f, -0.00373343f, -0.05597261f, 0.00934318f, -0.07836676f, -0.00672272f, 0.01406878f, 
    0.14180551f, 0.01052477f, 0.01566482f, 0.04041076f, -0.03583191f, 0.07815523f, -0.18057007f, 0.00047056f, 
    0.09247465f, -0.09082557f, 0.09938819f, -0.01697220f, -0.06931454f, 0.06043334f, -0.01500494f, 0.00590675f, 
    -0.53478640f, 0.11333390f, 0.36460087f, -0.03548210f, 0.27773350f, 0.00424159f, 0.04460321f, 0.18058442f, 
    -0.07542799f, 0.15247022f, 0.12230399f, 0.16533020f, 0.09008035f, 0.17241500f, 0.05940161f, -0.02514265f, 
    0.02928237f, 0.05303764f, 0.04745107f, -0.02690583f, 0.09378599f, 0.18770356f, -0.08493447f, 0.05515957f, 
    0.00040110f, 0.12801950f, -0.31638005f, -0.26326281f, 0.00796724f, -0.20585020f, 0.10722852f, 0.13310103f, 
    -0.02450450f, 0.05981962f, -0.00985777f, -0.04593256f, -0.02515580f, -0.00586330f, 0.03902707f, -0.11466542f, 
    0.27698004f, -0.14215338f, -0.06575359f, -0.25928932f, -0.00530116f, 0.00304838f, 0.06943332f, -0.10003479f, 
    0.02470934f, 0.02050937f, 0.07298936f, 0.17206381f, -0.01192378f, -0.17635094f, 0.12485487f, -0.03154446f, 
    -0.10745330f, 0.06118174f, 0.21202487f, 0.21426132f, -0.25071111f, 0.15480123f, -0.12071785f, -0.03333833f, 
    -0.10157475f, 0.16949295f, -0.19476123f, -0.24751140f, -0.06516448f, 0.06715279f, -0.01593947f, 0.02376898f, 
    0.06428932f, 0.13803959f, -0.06000556f, 0.16621254f, 0.02605310f, -0.07298914f, -0.10702598f, 0.17764686f, 
    0.01311127f, 0.31628010f, -0.12965813f, -0.06764939f, 0.02718534f, 0.04251778f, 0.03117841f, 0.04419193f, 
    0.09156464f, 0.10206549f, 0.02860088f, -0.03401605f, -0.03349163f, 0.07185300f, 0.01876074f, -0.05051101f, 
    0.09588091f, 0.03689852f, 0.07776403f, -0.13662671f, 0.15076147f, 0.17991389f, -0.02123531f, -0.29525492f, 
    0.10826516f, 0.08686613f, -0.09183697f, -0.04516990f, 0.09867816f, 0.05633677f, 0.05373943f, 0.04490431f, 
    -0.09933993f, -0.19929999f, -0.07712610f, 0.00063169f, 0.09578849f, -0.08993673f, 0.18484534f, -0.12799990f, 
    -0.03387696f, -0.07082799f, -0.06493045f, -0.05794140f, 0.20262009f, -0.08163760f, -0.05722507f, -0.04798472f, 
    0.03065228f, 0.16803361f, 0.00368845f, 0.06791550f, 0.01704540f, 0.00701265f, 0.02014713f, -0.03503525f, 
    0.00406876f, 0.00437217f, -0.20904852f, -0.00947135f, -0.03038893f, 0.03744052f, 0.09336596f, 0.00537952f, 
    0.09682176f, 0.02482423f, -0.01897200f, -0.02318779f, 0.03040199f, 0.10242990f, -0.04738569f, -0.04945107f, 
    -0.10477392f, 0.03332883f, 0.00491440f, -0.04239091f, -0.04022250f, -0.03539800f, -0.00173531f, 0.03968544f, 
    0.11718061f, -0.02050807f, 0.15961571f, -0.12213945f, -0.04893987f, -0.11917137f, 0.14770490f, 0.11508460f, 
    0.02745777f, -0.16538267f, -0.00528183f, -0.02162507f, 0.05100790f, 0.00635699f, -0.01835148f, -0.15439048f, 
    -0.04236223f, -0.23171072f, 0.10383026f, 0.22642837f, 0.09263419f, -0.01621541f, 0.16129583f, -0.08678308f, 
    -0.11923546f, -0.04664123f, 0.11555285f, 0.07956626f, -0.01155421f, -0.12131316f, -0.07238910f, -0.01026062f, 
    -0.00634182f, 0.12394276f, -0.01376469f, -0.11866006f, -0.07532849f, -0.22020850f, 0.05133018f, 0.20954119f, 
    0.03236477f, 0.06613919f, 0.04818333f, 0.04201405f, 0.09783085f, 0.00283156f, -0.00952671f, -0.00381144f, 
    0.02172671f, 0.04741498f, -0.12885965f, -0.07717302f, 0.01505553f, -0.09285044f, -0.04240790f, -0.00520345f, 
    -0.02341869f, -0.02350549f, -0.10861447f, -0.03467349f, -0.10836451f, 0.09917895f, -0.05175538f, 0.01576374f, 
    -0.06774822f, 0.05200865f, -0.12072735f, -0.11620183f, -0.05573069f, 0.03129866f, 0.10697128f, 0.20374554f, 
    -0.02255202f, 0.03191192f, 0.17017330f, -0.07780325f, -0.13181596f, 0.13684149f, 0.08059073f, -0.01959781f, 
    -0.66293895f, 0.13052586f, 0.10482585f, 0.05057277f, 0.24579848f, 0.06461217f, -0.28203636f, -0.18845177f, 
    0.00550339f, -0.11138021f, 0.19003364f, -0.03689649f, 0.31659025f, -0.06413613f, -0.18494283f, -0.07827304f, 
    0.01854709f, 0.04412440f, 0.04178111f, 0.20930152f, -0.03587281f, 0.01492198f, -0.10946132f, -0.01280150f, 
    0.06913633f, 0.05809584f, -0.11387309f, 0.00896608f, 0.00079856f, -0.03081714f, 0.07649747f, 0.05861970f, 
    -0.04305147f, 0.00577732f, -0.06057977f, 0.04023935f, -0.14791578f, -0.03608370f, 0.03948743f, 0.03940955f, 
    0.04871952f, -0.06005213f, -0.11428233f, -0.27771711f, -0.17667848f, 0.04637247f, 0.16517960f, -0.01145880f, 
    -0.00776404f, -0.15122846f, -0.05896733f, -0.06317917f, -0.13549779f, -0.04376977f, -0.02420797f, 0.01112556f, 
    -0.00424529f, 0.05928056f, 0.21480909f, 0.06165827f, 0.06705988f, 0.08009983f, 0.04428153f, 0.01860270f, 
    0.08904076f, -0.03837477f, 0.02464811f, -0.02445175f, 0.01150222f, 0.06297567f, -0.14998925f, -0.07568336f, 
    -0.15019183f, -0.05182370f, -0.03675729f, -0.01764965f, -0.04567088f, -0.07756928f, -0.15044856f, -0.01898807f, 
    0.24483198f, -0.18400741f, -0.16372056f, -0.05087506f, -0.01545334f, 0.14981359f, -0.15320311f, -0.07529023f, 
    0.00815543f, 0.00673457f, 0.10643534f, -0.02122872f, -0.01732171f, -0.06442565f, 0.12294652f, 0.17052388f, 
    -0.15964951f, -0.11103237f, 0.07085130f, -0.02315910f, -0.16560560f, 0.03100936f, -0.16918772f, 0.04624308f, 
    0.10700746f, 0.07879248f, -0.00615529f, 0.07367533f, -0.00352627f, 0.12089564f, -0.01008808f, 0.05476602f, 
    -0.05030623f, 0.07639619f, -0.03776760f, -0.04095331f, -0.10177907f, -0.10821497f, 0.03349484f, 0.01101420f, 
    -0.07400206f, -0.13441139f, -0.13650347f, -0.07353349f, 0.30176827f, 0.04324961f, 0.15345643f, 0.09300356f, 
    -0.00142197f, 0.08372505f, -0.00863027f, -0.02634355f, 0.01373108f, -0.03413402f, 0.05631668f, -0.00888632f, 
    -0.03189867f, -0.08220166f, -0.11168724f, -0.10382629f, 0.08670532f, -0.00234315f, -0.04930753f, -0.00861046f, 
    0.17081797f, -0.22091880f, 0.13759054f, -0.16283312f, -0.00882781f, 0.07187827f, 0.24669771f, -0.06869381f, 
    -0.13018546f, -0.06796535f, -0.03180053f, 0.01676769f, 0.03405012f, 0.06378808f, 0.13009903f, -0.02232612f, 
    0.11985960f, -0.19192818f, -0.17952622f, -0.03312794f, 0.28710103f, -0.20501575f, 0.12100420f, 0.25593331f, 
    -0.00892789f, 0.03678837f, 0.06887058f, 0.02061400f, -0.05520786f, 0.00520940f, 0.09188521f, 0.05200772f, 
    0.01755917f, 0.04507566f, -0.00221032f, -0.13139208f, 0.01762505f, -0.19036350f, -0.11216606f, -0.07485420f, 
    -0.01308293f, 0.07297928f, -0.12646623f, -0.10635087f, 0.00714427f, 0.21763688f, 0.12775177f, 0.07439955f, 
    -0.07361603f, 0.08867399f, -0.34714651f, 0.14140725f, 0.08256343f, -0.02554949f, 0.08455404f, 0.15124966f, 
    -0.05232815f, 0.13192099f, 0.24956253f, -0.21166067f, 0.07885949f, -0.13671283f, -0.06915045f, 0.06076289f, 
    -0.04752292f, 0.03676395f, 0.03010444f, 0.06282067f, 0.10687295f, 0.11156691f, 0.03155534f, 0.00231908f, 
    -0.00326933f, 0.00883876f, 0.01563788f, 0.00954578f, 0.06544512f, 0.13371624f, -0.12413260f, -0.09269886f, 
    0.05091351f, 0.03910487f, -0.02265867f, 0.07003725f, -0.00328733f, 0.06699726f, 0.01596425f, -0.00806018f, 
    -0.01904413f, -0.00876573f, -0.05004579f, 0.00242375f, 0.17020299f, -0.06791675f, 0.19557646f, 0.13584174f, 
    -0.15776479f, 0.20697393f, 0.22336760f, 0.01241543f, -0.02191070f, 0.10452487f, -0.08336158f, 0.03451667f, 
    -0.08700518f, 0.05293241f, 0.05187729f, 0.16629162f, 0.04639128f, 0.07799339f, 0.08323291f, -0.01467098f, 
    -0.02687055f, 0.01643447f, -0.02695270f, 0.00907128f, 0.05451594f, 0.21741860f, 0.09662756f, 0.07755716f, 
    0.06188749f, -0.03252819f, 0.04387695f, 0.02063194f, -0.01121543f, -0.16607119f, 0.07961982f, 0.01815685f, 
    0.00247568f, 0.02493022f, -0.00236729f, 0.06535047f, -0.07025735f, -0.02442600f, -0.01933163f, -0.00030013f, 
    -0.21606809f, 0.03457371f, 0.01584700f, 0.07163943f, 0.11095242f, -0.00711413f, -0.01201579f, -0.00433366f, 
    0.04064277f, 0.07770842f, -0.08197245f, -0.07803752f, -0.16876617f, -0.00433504f, -0.06744475f, 0.04502420f, 
    -0.05874372f, 0.01837983f, 0.00008183f, 0.09235936f, -0.13182600f, 0.02614162f, -0.00992921f, -0.12349852f, 
    0.07737414f, -0.08272058f, 0.22309506f, 0.05507525f, 0.11052860f, -0.12289704f, -0.00654571f, 0.01297703f, 
    0.02009186f, 0.00582612f, -0.01748989f, -0.10703035f, 0.02545185f, 0.26049036f, 0.09790886f, 0.10949568f, 
    -0.03310740f, -0.14570047f, 0.06278798f, 0.00391047f, 0.17203367f, 0.01362248f, 0.00208620f, 0.00139405f, 
    0.03005933f, 0.08388917f, -0.25163993f, -0.11827735f, 0.17563923f, -0.04239879f, 0.04428349f, -0.08208443f, 
    -0.03231320f, 0.05213638f, 0.03810013f, 0.03988955f, 0.04327627f, 0.01866273f, 0.13932158f, -0.47222751f, 
    -0.17942704f, 0.00281787f, 0.11747438f, 0.03600616f, 0.01018737f, -0.21970499f, 0.03905805f, 0.02742512f, 
    -0.03737941f, -0.04735074f, -0.05505589f, 0.00384022f, -0.02254406f, 0.00110607f, 0.20255040f, -0.03586527f, 
    0.03347325f, -0.04513388f, 0.02368339f, -0.01905232f, 0.00979408f, 0.03277712f, -0.02326117f, 0.00974704f, 
    -0.02501067f, 0.02773832f, -0.01537497f, -0.00182196f, -0.02889397f, 0.01386146f, -0.01380745f, 0.00116386f, 
    0.01321560f, -0.00694743f, 0.00055571f, 0.02850770f, 0.00798793f, 0.03015956f, -0.03116491f, 0.00192746f, 
    -0.04367232f, -0.03295845f, 0.03194384f, -0.04316410f, -0.01562638f, -0.00127075f, 0.03054827f, -0.01249902f, 
    0.00569918f, 0.03603229f, -0.03710134f, -0.02090905f, -0.04056970f, -0.03896848f, -0.03403908f, -0.03597974f, 
    0.02866363f, -0.01985266f, -0.02892606f, -0.00237777f, -0.04368605f, 0.04205143f, 0.01083321f, 0.03065614f, 
    -0.03565235f, 0.01945239f, 0.01100099f, -0.00798653f, -0.01904991f, -0.00323396f, -0.01231756f, -0.01432331f, 
    -0.01182463f, 0.02272565f, 0.01831128f, -0.00775321f, 0.01707507f, 0.02487613f, 0.01154317f, 0.02662062f, 
    -0.01843742f, -0.02981010f, 0.01042950f, -0.03924931f, -0.03449607f, -0.02545489f, 0.00742177f, -0.02641148f, 
    0.00415822f, -0.00493386f, -0.01670343f, 0.02704189f, 0.00653634f, -0.02549219f, -0.03365813f, -0.03980929f, 
    0.01421208f, 0.02417899f, 0.02303909f, -0.03640785f, -0.03548953f, -0.00393610f, 0.02147201f, -0.04530397f, 
    -0.02586260f, 0.02792002f, 0.02594378f, -0.01986918f, -0.03598715f, -0.00090929f, -0.00643327f, -0.01131136f, 
    0.01872716f, 0.02286264f, 0.02259209f, -0.02139262f, -0.04498665f, 0.01906995f, 0.01056573f, 0.00915700f, 
    0.02210678f, -0.02786281f, -0.03621776f, 0.01246112f, -0.01659497f, -0.03739113f, -0.01081004f, -0.01848348f, 
    -0.01580359f, -0.01191600f, -0.01670084f, 0.02602025f, 0.01631975f, 0.03277835f, 0.02668009f, -0.00957174f, 
    -0.00201179f, -0.00169610f, 0.02836188f, 0.00929996f, 0.03068737f, -0.02590073f, -0.03060790f, 0.03190395f, 
    -0.02465826f, -0.00045926f, -0.02950233f, 0.02121216f, 0.03330154f, -0.03464789f, -0.01582906f, -0.03997333f, 
    -0.01460883f, 0.00059012f, -0.04264415f, -0.03012015f, 0.01554923f, -0.03393172f, -0.04088011f, -0.02723224f, 
    -0.00126165f, 0.03192931f, 0.00569013f, -0.00232489f, 0.01536628f, 0.00906903f, 0.02813138f, -0.02737615f, 
    0.02933731f, 0.00879130f, -0.01305459f, -0.00520603f, 0.03258339f, -0.03959389f, 0.02163829f, -0.01906066f, 
    -0.03959912f, -0.00178121f, -0.03699172f, -0.03401623f, -0.03236274f, 0.00508282f, -0.03652371f, -0.00657192f, 
    -0.04213626f, -0.04265698f, -0.03872921f, 0.02019085f, -0.01861510f, 0.02179548f, -0.00504602f, 0.00431326f, 
    -0.04009072f, -0.01239868f, 0.00083177f, 0.00377167f, 0.01853190f, 0.00497703f, -0.02466571f, 0.01054752f, 
    -0.03726289f, -0.03929386f, 0.02307598f, -0.01074576f, 0.00381244f, 0.03024579f, 0.00265239f, -0.00946614f, 
    -0.00789060f, 0.00934678f, -0.02900293f, 0.03232174f, 0.02825322f, 0.00385638f, 0.01937881f, -0.01281719f, 
    -0.03043021f, 0.01048151f, 0.03024746f, -0.01906237f, 0.02312581f, -0.02712920f, 0.02703908f, 0.00342885f, 
    0.01789538f, -0.01794483f, -0.00916476f, -0.04280292f, -0.00485321f, -0.04328431f, 0.01644943f, -0.01610182f, 
    -0.00155007f, -0.00621789f, -0.01981062f, -0.04356744f, 0.03571003f, 0.00352906f, -0.03293044f, -0.03067196f, 
    -0.03216970f, -0.04507576f, 0.01789569f, 0.03443113f, -0.02830941f, 0.01483481f, -0.03965994f, -0.00121959f, 
    -0.00872472f, 0.02842792f, 0.01915619f, -0.02611248f, -0.03015888f, -0.00041246f, 0.03303339f, 0.02384356f, 
    0.01006110f, -0.03056044f, 0.00875792f, 0.00025474f, 0.01700574f, -0.04245793f, 0.01526112f, -0.04106306f, 
    0.00493771f, 0.01528491f, 0.01382930f, 0.01145434f, -0.01397337f, -0.01389136f, 0.00475076f, 0.01619822f, 
    0.01112391f, -0.01474818f, -0.03733793f, -0.01673728f, -0.04528311f, 0.02273515f, 0.01250094f, 0.01809680f, 
    0.00286793f, -0.01566414f, 0.02931804f, 0.01870857f, 0.02812148f, -0.00702031f, 0.02642614f, -0.04155252f, 
    0.01348901f, -0.03475227f, -0.04440996f, -0.04522938f, 0.00015352f, -0.03707342f, 0.00303528f, 0.02115021f, 
    -0.04440172f, -0.02945962f, -0.00613717f, 0.03156294f, 0.01306393f, -0.02744873f, -0.01967731f, 0.03326640f, 
    0.00071537f, -0.01215371f, -0.03651077f, 0.01533720f, 0.02971167f, 0.02801985f, -0.04309325f, -0.00885417f, 
    0.02530566f, 0.00640718f, 0.02293087f, -0.03545098f, -0.02507618f, -0.01255065f, -0.03122322f, 0.02440115f, 
    0.01859572f, 0.00195127f, -0.01193100f, -0.01674023f, 0.01869706f, -0.01390287f, -0.02541844f, 0.02512486f, 
    0.02956815f, 0.03631097f, 0.01575647f, 0.02313658f, 0.02487013f, -0.00645475f, -0.02078939f, -0.03059659f, 
    -0.01908419f, -0.02687741f, 0.00761406f, 0.01535050f, 0.02298565f, -0.00899204f, -0.03177048f, 0.02775943f, 
    -0.02430501f, -0.01762328f, 0.01429521f, -0.03495665f, 0.03042921f, -0.04060062f, -0.01103052f, 0.01282933f, 
    -0.02633759f, 0.01458838f, 0.01791993f, 0.03031321f, -0.04189650f, -0.02164697f, -0.03864456f, 0.02343023f, 
    0.00595661f, -0.00606414f, -0.00716596f, -0.03713714f, -0.02231413f, 0.02101897f, 0.00243700f, 0.00772831f, 
    -0.00983503f, -0.00169026f, -0.02581254f, -0.02474915f, -0.04015792f, 0.02550723f, 0.02722866f, -0.02308760f, 
    -0.02583547f, 0.02568367f, 0.02285655f, -0.03038480f, 0.00766129f, -0.04534215f, 0.02409908f, -0.01564957f, 
    0.03151144f, -0.00330762f, 0.02451353f, -0.02339468f, -0.04356503f, -0.01005387f, -0.03041977f, 0.00908675f, 
    0.00854645f, 0.03049987f, -0.00015113f, 0.02120517f, -0.00766640f, -0.03610499f, 0.00864737f, 0.02328752f, 
    -0.03313289f, 0.01945903f, -0.01165722f, 0.00442715f, -0.00123066f, 0.02148652f, 0.00159551f, 0.02592364f, 
    0.02905818f, 0.00646463f, 0.02112645f, 0.00077311f, 0.00073307f, -0.00247984f, -0.01036614f, -0.04202491f, 
    0.00894127f, 0.00493322f, -0.00459009f, -0.04092993f, 0.02288281f, -0.00398862f, -0.04523235f, 0.01106704f, 
    -0.03218009f, 0.00453618f, 0.03339518f, 0.00567225f, 0.01558440f, -0.04042359f, 0.02657566f, -0.01811232f, 
    0.02777154f, -0.00129365f, 0.03309564f, -0.02776078f, -0.00700978f, -0.01311341f, 0.02987836f, 0.02452822f, 
    -0.00960820f, 0.02005156f, 0.00262485f, -0.03439962f, -0.00045351f, -0.02390489f, 0.00643947f, -0.01143694f, 
    -0.01848280f, 0.02887297f, -0.01224246f, -0.04434700f, -0.01947663f, 0.01800846f, -0.00131746f, -0.02961234f, 
    0.03072513f, -0.04425149f, 0.01124704f, 0.02513346f, -0.02138836f, -0.00775451f, -0.03301159f, 0.00739086f, 
    -0.02267493f, -0.02837652f, -0.02079708f, 0.02672660f, -0.03886198f, -0.01139292f, -0.00123450f, 0.01162213f, 
    -0.01912916f, -0.04456713f, -0.02932577f, -0.02965153f, 0.02557615f, 0.02624643f, -0.03111966f, -0.02698906f, 
    -0.04517560f, -0.02102488f, -0.01122495f, -0.02829535f, 0.03260198f, -0.03353691f, -0.04022042f, -0.03089525f, 
    -0.02999652f, -0.01296424f, 0.01594045f, -0.03373636f, 0.00128441f, -0.01441320f, 0.00159691f, -0.00690277f, 
    0.03183308f, 0.02287299f, -0.02946651f, -0.01209411f, 0.04000358f, 0.00046537f, -0.01114763f, 0.01545613f, 
    -0.04329025f, -0.03344237f, -0.03522788f, 0.00075914f, 0.03154150f, -0.00924279f, -0.00143507f, -0.03049907f, 
    -0.00054499f, 0.01387053f, 0.02357723f, -0.01493543f, 0.00730266f, -0.02126181f, -0.01570611f, -0.02349764f, 
    -0.01991510f, -0.00402931f, -0.01441196f, -0.03621647f, -0.00971111f, -0.02333121f, -0.02479726f, -0.00044509f, 
    0.03176073f, 0.00362734f, -0.03976309f, -0.02507783f, -0.00692914f, -0.02260165f, 0.01245035f, 0.02685449f, 
    -0.04308846f, -0.03979735f, 0.01891465f, -0.02825441f, 0.04211540f, -0.02574872f, 0.01813575f, -0.02042266f, 
    0.00816892f, -0.02177509f, 0.02472436f, 0.00695220f, -0.03447183f, -0.04364904f, 0.03265097f, 0.03188470f, 
    -0.04341854f, -0.03126687f, -0.04111996f, -0.02184467f, -0.01019928f, 0.02927255f, -0.04370873f, -0.03460411f, 
    -0.03083265f, 0.03225428f, 0.01292413f, 0.00102077f, -0.00497886f, -0.00692333f, 0.01615971f, 0.00759991f, 
    -0.00443721f, -0.00634160f, -0.01719991f, -0.03693476f, -0.04551515f, 0.00420446f, 0.01521318f, 0.00779372f, 
    -0.01086274f, -0.01850947f, -0.03398433f, 0.00450241f, -0.03934408f, 0.00963930f, -0.00615738f, -0.00539731f, 
    0.02904980f, 0.01049966f, 0.03292877f, -0.02031529f, -0.04251700f, -0.02322113f, 0.00433823f, 0.03040961f, 
    -0.02067271f, -0.00007148f, -0.02220772f, -0.01870538f, 0.00055835f, 0.02845437f, -0.01114652f, -0.01077317f, 
    -0.04537842f, -0.02771692f, 0.03629178f, -0.01568002f, 0.00154031f, 0.02130351f, 0.02677538f, -0.02749712f, 
    -0.02505659f, 0.02663583f, -0.00958853f, -0.00484065f, -0.03167727f, -0.00578985f, 0.02139404f, -0.02544203f, 
    0.00953186f, 0.00431656f, -0.03445613f, -0.01118013f, -0.02343442f, 0.03231953f, 0.00301105f, 0.03096262f, 
    -0.00628515f, -0.03274818f, 0.01328634f, 0.04096276f, -0.02850894f, 0.02423027f, 0.01082332f, 0.00292469f, 
    -0.01759600f, -0.03870264f, 0.03253386f, 0.00337782f, -0.02413210f, -0.02950326f, 0.03719319f, -0.02092355f, 
    0.03036128f, -0.00983317f, -0.03190919f, -0.00207278f, -0.00023048f, -0.01039404f, -0.03019387f, 0.00294021f, 
    -0.01572982f, -0.04445264f, -0.02207671f, 0.02635344f, -0.00699527f, -0.03676122f, 0.02355586f, 0.02415556f, 
    -0.19154784f, -0.02362078f, -0.09151954f, 0.00373433f, 0.00635317f, -0.05400063f, -0.03932776f, 0.03512484f, 
    0.10343599f, -0.07628538f, -0.13720982f, 0.07538278f, 0.02882734f, 0.04134166f, 0.00799962f, -0.04540029f, 
    -0.09686790f, -0.03143789f, 0.05100190f, -0.03370691f, 0.14468223f, 0.01219255f, 0.00981374f, 0.00487491f, 
    -0.09418882f, -0.00929851f, -0.04413890f, 0.05618300f, 0.03987826f, -0.04457089f, -0.07117967f, 0.04331961f, 
    -0.00371886f, 0.04336210f, -0.07175590f, -0.07382986f, -0.04399729f, -0.02939254f, 0.03401706f, -0.10682654f, 
    0.10902591f, 0.10331537f, 0.45497090f, 0.01146024f, 0.34513432f, 0.20303416f, -0.01558941f, 0.07409412f, 
    0.08355503f, -0.06637999f, -0.01079069f, 0.08867671f, 0.14448875f, -0.06826869f, 0.00718844f, -0.01561891f, 
    -0.02292410f, -0.07850181f, -0.03242888f, -0.00891019f, -0.19549046f, -0.29374728f, 0.09789830f, 0.31343645f, 
    0.22846444f, 0.27878255f, 0.00326564f, 0.16468889f, 0.02751274f, -0.16106179f, -0.11500815f, 0.12489226f, 
    0.08052327f, 0.01470488f, -0.06111522f, -0.07206915f, 0.00672349f, 0.12933560f, 0.18968832f, 0.00812996f, 
    -0.46487591f, 0.50859630f, 0.01639441f, 0.30070674f, 0.03030552f, 0.12698482f, 0.02086931f, 0.10191471f, 
    -0.00648218f, -0.01238646f, -0.06719710f, 0.07703956f, 0.02309477f, -0.03471384f, -0.02217630f, 0.18627560f, 
    0.00358141f, 0.06323734f, 0.04063327f, -0.13162749f, 0.31686863f, 0.14868164f, 0.13170758f, -0.33859366f, 
    0.43688020f, 0.04574825f, 0.13938449f, 0.10403060f, -0.02905651f, 0.13451654f, -0.03084029f, -0.04369034f, 
    -0.07983447f, -0.05921550f, -0.14607421f, 0.01734530f, 0.07768899f, 0.10200856f, 0.09166051f, -0.12274199f, 
    0.20095150f, -0.17319645f, 0.16798072f, 0.02226325f, -0.07931212f, -0.10202700f, -0.01592778f, -0.04959828f, 
    -0.01088516f, 0.00184987f, 0.01414867f, 0.01498008f, 0.01030218f, 0.01967518f, -0.06461961f, 0.04449136f, 
    -0.11627508f, 0.17186430f, 0.01262134f, -0.10706712f, 0.42970458f, 0.10521095f, 0.26351324f, 0.44248012f, 
    -0.17640597f, 0.03755770f, -0.07407976f, 0.02983897f, -0.01915906f, -0.04677753f, -0.00903009f, -0.10044409f, 
    0.01962860f, 0.04374101f, -0.07399865f, 0.08127388f, -0.16352552f, 0.06578992f, 0.12708455f, -0.07783791f, 
    -0.00385367f, -0.06054666f, 0.15611635f, -0.06201475f, -0.05147968f, -0.05640218f, 0.01103819f, -0.03531580f, 
    0.02898627f, -0.03745746f, 0.04163267f, -0.01042558f, 0.07257285f, 0.07550159f, -0.00277735f, 0.04826308f, 
    -0.02567630f, 0.09290403f, 0.07859854f, -0.07110652f, 0.18243207f, 0.09773809f, 0.09904075f, -0.10270701f, 
    0.02160158f, 0.00728376f, -0.00392616f, -0.02349124f, -0.07378194f, 0.09421594f, -0.07705424f, -0.09610352f, 
    0.21093740f, 0.02241710f, -0.12911175f, 0.00220107f, 0.02488587f, 0.04326245f, 0.01841981f, -0.13763422f, 
    -0.10373335f, -0.13797000f, -0.14015077f, -0.04104156f, 0.17756107f, 0.09439462f, 0.10564534f, -0.01978965f, 
    0.08022081f, 0.07026450f, -0.00159466f, 0.02830348f, -0.01798190f, -0.08997164f, 0.00943129f, -0.00929235f, 
    -0.02016566f, 0.05246259f, 0.01448786f, -0.05456386f, -0.00751910f, -0.04681784f, -0.15951566f, 0.03162981f, 
    0.00724309f, -0.03170346f, -0.10432022f, -0.10966153f, 0.06692683f, 0.08572110f, -0.08242232f, -0.00856450f, 
    -0.00989661f, -0.07954759f, -0.01144811f, -0.02537804f, -0.01684335f, 0.03876704f, 0.00808814f, 0.05200097f, 
    -0.07077236f, -0.05051211f, -0.09798500f, -0.08133331f, -0.03447614f, -0.04739186f, -0.02891519f, 0.04110843f, 
    0.00923110f, -0.00578302f, -0.11862280f, 0.06684585f, 0.03182771f, 0.01518995f, -0.07106507f, -0.08009387f, 
    -0.07515412f, 0.03190789f, 0.03588596f, -0.01667708f, 0.04074782f, 0.50459868f, -0.06309549f, 0.25789639f, 
    -0.03954494f, 0.11854918f, -0.02539960f, 0.11009270f, 0.17534061f, -0.04132181f, -0.00617337f, 0.00382171f, 
    0.06355011f, -0.04296540f, 0.02964805f, 0.11694993f, 0.10270983f, 0.03489549f, 0.15173347f, 0.09557360f, 
    0.48990759f, -0.16794434f, 0.11952290f, -0.18189208f, 0.29476744f, 0.09254277f, 0.26759848f, 0.19921347f, 
    -0.06336585f, 0.08923434f, -0.15907520f, 0.00851972f, -0.00651285f, 0.10769232f, 0.10457899f, 0.00163123f, 
    0.07024709f, -0.06305528f, 0.23254582f, 0.07993296f, -0.03845577f, 0.35622048f, -0.01221803f, 0.03279011f, 
    -0.06465019f, -0.01610253f, -0.04492673f, 0.07617219f, 0.05647941f, 0.03510673f, -0.14107205f, -0.02430326f, 
    0.20333913f, -0.05763965f, 0.03797281f, 0.15845753f, 0.08863893f, 0.07630426f, 0.06503092f, -0.03649355f, 
    -0.25505507f, -0.20833202f, -0.31279850f, -0.06806131f, 0.25058889f, 0.14028017f, 0.06241159f, -0.12341154f, 
    0.05922298f, -0.01511167f, 0.00093461f, 0.08346815f, -0.07320535f, 0.03596381f, -0.07167559f, 0.01109880f, 
    -0.03503548f, -0.06919990f, -0.00052835f, 0.05655264f, -0.20168357f, -0.05560177f, -0.14789338f, -0.06052429f, 
    -0.04304398f, -0.03987002f, -0.03582216f, 0.05596600f, 0.10941161f, -0.02327125f, -0.18462689f, 0.08187763f, 
    -0.14598088f, -0.01263576f, -0.11746016f, -0.00314072f, -0.08972465f, 0.15180014f, 0.09831252f, -0.00072015f, 
    0.09830079f, -0.12598747f, 0.45731089f, 0.02152530f, 0.11344735f, 0.14383078f, -0.01780977f, -0.01480694f, 
    0.04929782f, -0.10646772f, 0.03088442f, -0.20404944f, -0.06652137f, 0.30210525f, 0.00683922f, -0.09475277f, 
    -0.08436045f, 0.04963211f, 0.10680833f, -0.01841279f, 0.22351663f, -0.13519102f, 0.31150103f, -0.14931446f, 
    -0.06720601f, -0.14140190f, -0.08512018f, -0.04660698f, -0.02598940f, 0.01361373f, 0.03692736f, -0.00772119f, 
    -0.03252833f, -0.00988355f, 0.03388923f, 0.03643357f, -0.01519634f, 0.21940169f, -0.01921617f, -0.08042532f, 
    -0.03324330f, 0.17281476f, 0.25012192f, -0.11137639f, -0.09645623f, -0.10408545f, -0.14088146f, -0.10552780f, 
    -0.01409085f, -0.05477740f, 0.02551971f, -0.00452288f, 0.02873358f, 0.04724801f, 0.04353147f, 0.06380153f, 
    0.03072411f, -0.02045651f, 0.17672479f, -0.00111200f, -0.27207166f, -0.15126680f, 0.06889997f, -0.05809053f, 
    0.13103060f, 0.34436584f, 0.06514436f, 0.10588349f, 0.00029369f, 0.09574211f, 0.02014414f, -0.06925191f, 
    0.02356822f, 0.08306904f, 0.02026464f, -0.01268825f, -0.03161833f, 0.06865701f, -0.04542958f, 0.19763856f, 
    -0.12536725f, -0.14956775f, 0.36845112f, -0.13293980f, 0.07073233f, 0.09276682f, -0.03086925f, -0.02267131f, 
    -0.00539755f, 0.00320801f, 0.01991459f, -0.04724143f, 0.03059985f, 0.09232255f, 0.05327759f, -0.00354717f, 
    0.04478901f, -0.08207195f, -0.04217412f, 0.14510912f, 0.00703908f, 0.20220733f, 0.07521180f, 0.07397106f, 
    -0.02047641f, 0.08306772f, -0.03468242f, 0.12176894f, 0.15300065f, 0.02538539f, 0.04274704f, 0.00316783f, 
    0.11405072f, 0.04762289f, 0.15878592f, -0.10191803f, -0.15395561f, -0.01248862f, 0.06624565f, -0.03120558f, 
    -0.05124047f, 0.26711631f, 0.12204383f, -0.02785305f, 0.27202252f, -0.05932043f, -0.05624550f, -0.11064357f, 
    0.19405100f, 0.06700668f, -0.06570550f, 0.07874522f, 0.07035363f, -0.02969573f, -0.01533296f, 0.00489033f, 
    -0.09965924f, -0.07152919f, 0.00635037f, -0.03086794f, 0.04926062f, 0.22308451f, 0.01299059f, 0.12711224f, 
    -0.06059441f, -0.08879445f, 0.04954641f, -0.00860113f, -0.07717323f, 0.00148888f, -0.09757686f, 0.00507839f, 
    -0.00552711f, -0.04950863f, -0.10918106f, 0.09001241f, -0.02365986f, 0.23626901f, 0.07228585f, 0.04720525f, 
    -0.13304558f, 0.09108904f, 0.17726080f, 0.21632376f, 0.08564190f, 0.08127716f, 0.02150897f, 0.14656368f, 
    0.13169229f, 0.00212752f, -0.05951072f, 0.04450403f, 0.03950364f, 0.03282540f, -0.02542566f, 0.03134550f, 
    -0.02162865f, -0.02866583f, 0.04296513f, -0.01466450f, -0.19106705f, 0.03149628f, -0.09666225f, -0.06239677f, 
    0.04397418f, -0.04316001f, 0.02097119f, 0.05544651f, 0.09080379f, 0.01623370f, -0.04729995f, 0.04091064f, 
    -0.04224205f, 0.04418894f, -0.00760635f, -0.04987491f, -0.04003780f, 0.12791803f, 0.00254468f, 0.01525451f, 
    0.24656609f, 0.03050488f, 0.06223218f, -0.14159094f, -0.07628347f, 0.02776257f, -0.04791094f, 0.02996684f, 
    -0.06568929f, -0.01915198f, -0.07228330f, 0.08299265f, -0.09318531f, 0.03141999f, 0.14608255f, 0.01102459f, 
    0.09300213f, 0.08969908f, -0.00536406f, -0.00680776f, -0.16521408f, -0.53023565f, 0.02374387f, -0.16531694f, 
    0.05763234f, -0.03349818f, 0.02763362f, -0.01430985f, 0.00646942f, 0.01672579f, -0.00097493f, 0.00522618f, 
    -0.02538755f, 0.00685858f, 0.03493555f, -0.00678800f, -0.06276892f, -0.08496039f, 0.02721717f, 0.01035498f, 
    0.05115459f, -0.10576340f, -0.07861003f, -0.02535980f, -0.04952132f, 0.04887548f, 0.00920478f, 0.01107881f, 
    0.00791694f, -0.09129877f, -0.03717908f, -0.04637038f, -0.09055625f, -0.08460207f, -0.00142336f, -0.04287276f, 
    -0.07010122f, -0.07283261f, 0.02778601f, -0.10615256f, -0.30139589f, -0.19909711f, -0.39004475f, 0.10101549f, 
    0.11344846f, 0.02040933f, 0.07263065f, -0.06518064f, 0.03957285f, -0.15249416f, -0.04937632f, -0.00295260f, 
    0.00702540f, 0.04801908f, 0.00878262f, 0.01675549f, -0.01101639f, 0.03416692f, -0.06802569f, 0.07347651f, 
    0.08328886f, 0.25939599f, 0.47671929f, 0.12724562f, 0.04324351f, -0.01640011f, -0.05465563f, -0.23104799f, 
    -0.03112077f, 0.03308537f, -0.00419296f, 0.10242698f, 0.07822075f, 0.03948417f, -0.00244190f, 0.05750234f, 
    0.00199018f, -0.05541550f, 0.01242975f, 0.10027037f, 0.00422030f, -0.13850220f, 0.06101169f, -0.19049317f, 
    -0.02202825f, 0.01683399f, -0.14746605f, -0.12924799f, -0.09444273f, -0.04527745f, 0.19909060f, 0.18469390f, 
    0.05493930f, 0.10176361f, -0.02661923f, 0.14759627f, 0.03392485f, 0.04860834f, 0.05855686f, 0.01774550f, 
    -0.07555788f, 0.38203034f, 0.68159449f, 0.54758859f, 0.32004923f, -0.09929978f, -0.05652550f, -0.20616499f, 
    -0.04005558f, 0.04706171f, 0.03893510f, -0.01704712f, -0.08650161f, 0.00836465f, 0.00056885f, 0.05175024f, 
    0.03883106f, -0.01155777f, -0.07320399f, -0.01019570f, -0.01879935f, 0.05956145f, -0.03939338f, 0.11325432f, 
    0.00843472f, 0.09410680f, -0.05515007f, 0.12520577f, -0.11481415f, 0.24896249f, 0.09689245f, 0.12947780f, 
    0.02719234f, 0.04683708f, 0.10796580f, 0.05755553f, 0.05539473f, 0.07277779f, -0.03909644f, -0.09664401f, 
    -0.05097179f, -0.06190629f, 0.17530400f, -0.00420821f, 0.09444867f, 0.05702134f, 0.07468448f, -0.25184894f, 
    0.13555373f, -0.00697598f, 0.03266761f, 0.04463086f, -0.00427872f, -0.10008670f, 0.07223782f, -0.03018453f, 
    0.07863042f, -0.02699256f, -0.03123001f, 0.09043290f, -0.17789572f, -0.30489957f, -0.48706609f, 0.02323682f, 
    -0.01866243f, -0.04963458f, 0.03820628f, -0.13865732f, -0.14535370f, -0.08611787f, 0.13997480f, -0.13713603f, 
    0.10110439f, 0.09142308f, -0.02903636f, 0.12736954f, -0.08698551f, -0.02989826f, -0.03783389f, 0.00908479f, 
    -0.20598769f, -0.07165151f, -0.34870434f, -0.04917379f, 0.10112055f, -0.06584910f, -0.02004776f, 0.02763392f, 
    -0.01910790f, -0.02606319f, -0.00028272f, 0.02142610f, -0.05087923f, 0.01204125f, 0.00564686f, 0.14127752f, 
    0.10250228f, -0.01749580f, 0.01094929f, 0.16717955f, 0.14048623f, -0.08173295f, 0.14985363f, -0.51738173f, 
    -0.19487961f, -0.03636508f, -0.24616519f, 0.04585230f, -0.07640140f, 0.09259944f, 0.20860511f, 0.12241102f, 
    -0.13313119f, 0.06631540f, -0.09060587f, 0.04500690f, 0.23090048f, 0.10867839f, -0.04391358f, 0.17932120f, 
    -0.22190216f, -0.23245937f, -0.40267727f, -0.03438026f, 0.09924155f, 0.02567085f, 0.12257288f, -0.01631853f, 
    0.06710458f, 0.03068929f, 0.03710561f, -0.04288933f, -0.04595682f, 0.03028502f, 0.06340477f, 0.03093899f, 
    -0.00510583f, 0.09942304f, 0.09316727f, -0.02093909f, 0.01230043f, -0.06945499f, 0.29241714f, 0.11222295f, 
    -0.07490341f, -0.08008444f, -0.10100147f, -0.14035855f, -0.03181204f, -0.01992538f, -0.03644537f, -0.01210014f, 
    0.11506765f, -0.01973723f, 0.05670651f, -0.08434757f, -0.04340155f, -0.04052185f, -0.05861900f, -0.05400657f, 
    -0.34986749f, -0.05862758f, -0.13327709f, 0.14941609f, 0.01377639f, 0.03399679f, 0.10319739f, -0.00366493f, 
    0.01186171f, 0.14612556f, -0.03124421f, 0.00840549f, 0.08521730f, 0.11356062f, 0.14237225f, 0.11407930f, 
    0.13354596f, 0.07886395f, 0.05927343f, 0.21658193f, -0.41268751f, -0.10853045f, -0.05254198f, 0.19699413f, 
    0.04069458f, -0.10026821f, 0.13995230f, -0.06921031f, 0.06829478f, 0.20738840f, 0.02496130f, 0.05883805f, 
    0.01617261f, 0.13154593f, 0.05045662f, 0.02141243f, 0.09857935f, 0.11264207f, -0.03312418f, 0.13201612f, 
    -0.08595107f, -0.09955296f, 0.06998730f, -0.12200563f, -0.02571237f, -0.02344077f, -0.02481738f, -0.09603777f, 
    -0.07453287f, -0.02281177f, 0.16128217f, 0.06434267f, 0.03721270f, -0.00124226f, 0.03996047f, 0.13360222f, 
    0.00265665f, -0.02627841f, 0.08395819f, 0.06888182f, 0.02920924f, 0.26653016f, 0.02143472f, -0.26543015f, 
    -0.12057959f, 0.07118966f, 0.08338276f, 0.02688869f, 0.10293470f, 0.06183054f, 0.17888854f, 0.08952425f, 
    0.10491040f, 0.16933854f, 0.01468369f, -0.03410310f, 0.12233189f, 0.02111237f, 0.11726158f, -0.12684284f, 
    -0.01141924f, -0.27504110f, -0.19107682f, 0.50498843f, -0.04773927f, 0.15555198f, -0.18175144f, 0.31633446f, 
    -0.26163486f, 0.09528698f, 0.22477189f, -0.16261430f, 0.04019980f, 0.05226590f, 0.17110085f, 0.01599698f, 
    0.05326081f, 0.01787486f, -0.00019497f, 0.02413245f, -0.14281867f, -0.04781529f, -0.10440398f, -0.17403251f, 
    -0.04446279f, 0.03270499f, -0.09900319f, -0.07904986f, 0.05518297f, -0.01761362f, 0.13661656f, 0.05182057f, 
    0.07963260f, 0.16348279f, 0.04671451f, -0.05296617f, 0.08640206f, -0.00167989f, 0.14695053f, 0.07463427f, 
    -0.19507022f, 0.28093764f, -0.10628766f, 0.08827677f, 0.20922080f, 0.10722756f, 0.07595446f, 0.06244728f, 
    0.13040985f, 0.20489000f, -0.09049459f, 0.02666784f, -0.01296523f, 0.01362473f, -0.01101557f, 0.05739247f, 
    0.03121184f, 0.11237211f, 0.04772025f, -0.09669800f, -0.07932655f, -0.08927146f, -0.05336173f, -0.21148188f, 
    -0.03068079f, 0.01304762f, -0.02932035f, -0.12340225f, 0.01459331f, -0.02931652f, 0.09080385f, 0.02432708f, 
    0.05326058f, -0.01428941f, -0.06460130f, -0.00400902f, 0.05994492f, -0.01371853f, 0.14368676f, 0.12638363f, 
    -0.01791034f, -0.04391701f, 0.24596621f, -0.30690518f, -0.21466249f, 0.02367165f, -0.09971517f, 0.20322646f, 
    -0.01162503f, 0.00991338f, 0.19517021f, -0.08058652f, 0.09046891f, -0.07266813f, -0.05762538f, 0.03625236f, 
    0.13364191f, 0.09250612f, 0.12195252f, 0.03936343f, -0.33926460f, -0.30434945f, -0.64591539f, -0.11991373f, 
    0.01054499f, -0.04939950f, 0.01054235f, 0.13259684f, -0.00797249f, -0.03340087f, 0.03354697f, -0.03604649f, 
    -0.04137695f, 0.02286335f, -0.04658917f, 0.13540299f, 0.04953585f, 0.03485795f, 0.09880951f, -0.01222245f, 
    -0.18268803f, -0.39859581f, -0.49169546f, -0.11147390f, 0.15995006f, 0.05418049f, 0.05045023f, 0.10806269f, 
    -0.02306699f, -0.00166823f, 0.02413863f, -0.07528921f, -0.15426661f, -0.08817396f, -0.06215747f, 0.09954996f, 
    -0.01158087f, 0.01863537f, -0.02010165f, 0.03408286f, -0.16298227f, -0.01757532f, -0.37770158f, -0.12312602f, 
    0.11746903f, 0.07783917f, 0.03649265f, 0.06182082f, 0.10185745f, 0.09960346f, -0.10056688f, -0.14880230f, 
    -0.06836269f, 0.03262437f, 0.00659396f, 0.04411140f, 0.03402948f, 0.10709641f, 0.09800197f, -0.12251443f, 
    -0.26034123f, -0.22093882f, -0.49259022f, -0.15605880f, 0.24014285f, 0.14195126f, 0.03250652f, 0.28362960f, 
    -0.07686660f, -0.00230296f, 0.04589258f, -0.13293453f, -0.09205098f, -0.16820198f, -0.05819113f, 0.07573377f, 
    -0.01615967f, -0.00418350f, 0.10295557f, -0.08774913f, 0.05791295f, -0.26796415f, -0.05705388f, 0.05520878f, 
    0.01359956f, 0.14162038f, 0.03700312f, -0.03538828f, -0.13475458f, 0.01625340f, 0.16285281f, 0.03018622f, 
    0.14999245f, 0.09490719f, -0.03205900f, 0.16701829f, 0.06890010f, -0.06817023f, 0.04605380f, 0.16438699f, 
    -0.33586553f, 0.19006243f, 0.53314304f, 0.46019837f, 0.40291715f, 0.08102056f, 0.00517335f, -0.11665041f, 
    0.06209964f, 0.06726810f, -0.01074159f, -0.00062027f, 0.06226093f, -0.04798406f, 0.01066831f, -0.00415800f, 
    -0.03830545f, -0.06668752f, 0.00413603f, 0.04463116f, -0.41155398f, -0.09390947f, -0.36597136f, -0.32315713f, 
    0.02812069f, 0.03569327f, -0.02496510f, 0.03479110f, 0.11511492f, -0.12460899f, -0.00515106f, 0.00860577f, 
    -0.04297660f, -0.07807034f, 0.02566687f, 0.08691154f, 0.14634636f, -0.07892442f, 0.09301951f, 0.03818946f, 
    -0.01659391f, 0.20114824f, 0.35206142f, 0.34672490f, 0.17434649f, 0.02232747f, 0.04568029f, -0.10569332f, 
    0.14409979f, 0.16803145f, 0.00965854f, 0.06471512f, 0.07337151f, 0.10375765f, 0.01294956f, 0.07959996f, 
    0.02529002f, -0.01061910f, 0.04017391f, -0.06112221f, 0.01165111f, 0.21680403f, 0.16441964f, 0.11378145f, 
    0.06107284f, -0.05944372f, -0.04563721f, -0.19795504f, -0.00362153f, 0.02815973f, 0.06526028f, 0.07609549f, 
    -0.03109694f, 0.08436897f, 0.09350906f, 0.06777536f, -0.00470656f, -0.04012289f, 0.05486239f, 0.16881371f, 
    -0.10625569f, 0.00735486f, 0.00711482f, 0.13519235f, -0.00299178f, -0.12389288f, -0.16076052f, -0.06924354f, 
    -0.05411882f, -0.06285412f, 0.04447795f, 0.04212806f, -0.02179633f, -0.03806050f, -0.02258320f, 0.02244791f, 
    -0.07251975f, 0.00340872f, 0.03430202f, -0.01615517f, -0.21590315f, 0.10838407f, -0.48424584f, 0.14508438f, 
    0.14097577f, 0.04733952f, 0.15323058f, 0.42527828f, -0.18674402f, 0.05879024f, 0.02409450f, 0.03242675f, 
    -0.08930616f, 0.01097915f, 0.02358285f, 0.11121371f, -0.04786579f, 0.29633594f, 0.05752148f, 0.06551556f, 
    -0.06309919f, -0.20075756f, 0.04078265f, -0.11763892f, -0.05341199f, 0.01634895f, -0.20759593f, -0.11019517f, 
    -0.11653256f, -0.02406195f, 0.27170488f, 0.17156118f, 0.13785583f, 0.07385631f, -0.01719051f, 0.15740816f, 
    0.06181002f, 0.09299253f, -0.05836526f, -0.01529050f, -0.22376710f, 0.20115016f, 0.22900681f, 0.26898623f, 
    0.18858097f, 0.02910341f, -0.05574154f, 0.03908586f, 0.22613695f, 0.19047533f, 0.01429192f, -0.01671070f, 
    -0.01213154f, 0.02849905f, 0.03718606f, 0.03625341f, 0.01837639f, -0.04914083f, -0.01755316f, 0.07389332f, 
    0.50217968f, -0.07388761f, 0.02404181f, 0.02806563f, -0.20224155f, 0.02840482f, -0.08230212f, -0.22081904f, 
    -0.01712897f, 0.10919484f, 0.06177044f, 0.00469567f, 0.01963781f, -0.10173622f, 0.00350781f, -0.05966268f, 
    -0.14186628f, -0.05873239f, -0.06550033f, 0.06815860f, -0.18268497f, 0.06592012f, -0.01112522f, -0.00397617f, 
    0.05987660f, -0.09708089f, -0.13398340f, -0.15432222f, -0.18175055f, -0.23637035f, 0.04884585f, 0.04142297f, 
    0.04002280f, -0.02283020f, -0.00924786f, -0.10741106f, -0.08916605f, 0.16495803f, -0.05329506f, 0.09466752f, 
    0.05690151f, 0.17739098f, -0.46590260f, 0.02776553f, -0.43971446f, -0.03759461f, -0.04450619f, -0.27558509f, 
    0.08347294f, 0.09661539f, -0.05423417f, 0.03718922f, -0.02184564f, 0.07067415f, 0.05093750f, -0.08989982f, 
    -0.07278536f, 0.03300598f, 0.12014921f, 0.14893559f, 0.39723051f, 0.27245280f, 0.15922503f, -0.33225563f, 
    -0.15229113f, -0.31686154f, 0.30107832f, -0.04313386f, 0.12337280f, 0.27185637f, 0.12039228f, -0.13114639f, 
    0.04885138f, -0.15199076f, 0.09538355f, 0.25613493f, 0.00208360f, 0.00946872f, 0.09320632f, -0.02447695f, 
    0.09413406f, -0.07659241f, 0.08025648f, -0.20075254f, 0.13595994f, -0.27262884f, -0.05939171f, -0.12280289f, 
    -0.03840761f, -0.10277698f, 0.12388695f, 0.00532451f, -0.04492795f, -0.03525130f, 0.18186712f, -0.16067457f, 
    0.10337607f, -0.07554745f, 0.16202939f, 0.14057519f, -0.21467680f, 0.04916420f, 0.18660507f, 0.53258085f, 
    -0.55967993f, -0.13083729f, 0.04704262f, 0.19301534f, 0.05824877f, -0.02157335f, 0.13728322f, 0.10849238f, 
    0.07587798f, 0.05485644f, 0.10389307f, 0.01640483f, -0.00711659f, -0.00627641f, -0.02273143f, 0.07070618f, 
    -0.04381707f, 0.02898161f, -0.18227883f, 0.02103129f, 0.12163213f, -0.04189820f, -0.01130025f, 0.05401980f, 
    0.01146630f, -0.05637341f, 0.00427284f, -0.04741551f, -0.01096451f, 0.00978729f, 0.05752096f, -0.05778205f, 
    0.11003479f, -0.09345738f, 0.03800458f, 0.16277717f, 0.07513028f, 0.12312906f, -0.29738793f, -0.39439803f, 
    0.22743168f, -0.03771797f, -0.29234448f, 0.14102966f, -0.13300055f, 0.04685247f, 0.03507321f, 0.16777202f, 
    -0.08204596f, -0.00933779f, -0.02352400f, -0.08349993f, 0.19635475f, 0.09973586f, -0.08964420f, 0.02674423f, 
    -0.38186941f, -0.25593674f, -0.27306011f, 0.23266560f, -0.15263838f, 0.22127247f, 0.16993579f, 0.08580632f, 
    0.12484310f, -0.06078608f, -0.10148519f, 0.02730609f, -0.00270675f, 0.03010016f, 0.05264710f, 0.03485971f, 
    0.11611678f, -0.12571529f, -0.14492562f, 0.00827837f, -0.20648275f, 0.04071034f, -0.05379001f, 0.22366221f, 
    -0.26874682f, 0.04169085f, -0.10872915f, -0.20481658f, 0.10199813f, -0.46821001f, 0.06958906f, 0.11381538f, 
    -0.23738520f, 0.03413675f, 0.08904184f, 0.02972145f, -0.07042506f, -0.00789089f, -0.07930573f, 0.31916273f, 
    0.03788758f, 0.07168732f, 0.22395752f, 0.25727013f, -0.11604960f, 0.11405183f, 0.05726442f, 0.08133354f, 
    0.15576926f, 0.14695996f, 0.05155025f, -0.03837213f, 0.06156211f, 0.03744895f, 0.00320505f, -0.02461423f, 
    0.14207567f, -0.02940557f, 0.10233139f, 0.01199633f, -0.03111321f, 0.07226395f, 0.15713164f, 0.06842133f, 
    0.07299221f, 0.13266636f, 0.10967080f, 0.08040375f, 0.16962491f, 0.24765435f, -0.01087260f, -0.09016977f, 
    0.02515102f, 0.19104332f, 0.06124590f, 0.02496287f, 0.07628317f, 0.00703983f, 0.12760353f, -0.06737304f, 
    -0.01688368f, -0.03190971f, 0.04948907f, 0.06643540f, -0.05808367f, 0.12936811f, -0.07267559f, -0.11407617f, 
    -0.17517039f, -0.10305158f, 0.04207014f, 0.00898079f, 0.03198265f, 0.09084132f, -0.02152443f, -0.02673114f, 
    -0.06686047f, 0.03415799f, -0.13865910f, -0.03831750f, -0.21194185f, -0.13720424f, 0.22625634f, -0.37460902f, 
    0.11253622f, -0.00655660f, -0.17703772f, 0.03676777f, -0.07311729f, 0.19709532f, -0.04812036f, 0.12483593f, 
    -0.03629213f, -0.01053588f, 0.00135428f, -0.06977565f, -0.06212588f, 0.00210300f, 0.10878365f, 0.09329118f, 
    0.01810090f, 0.60420245f, 0.13985913f, 0.40165746f, -0.32704422f, -0.25888559f, -0.08137497f, 0.12892903f, 
    -0.04964679f, 0.13242288f, 0.18223214f, -0.11802314f, 0.00503645f, 0.01809791f, -0.25831091f, -0.08933982f, 
    0.06271413f, 0.14593454f, -0.07452520f, -0.14680247f, -0.06393395f, -0.23043412f, 0.06011797f, -0.07746220f, 
    0.05106993f, 0.00534975f, -0.03728709f, -0.14850104f, -0.11636831f, -0.15295069f, 0.19647157f, 0.08767851f, 
    -0.04914524f, 0.06021599f, 0.03401721f, -0.10184070f, -0.07304685f, -0.02087702f, -0.06229963f, 0.14670368f, 
    0.27654982f, 0.29165798f, 0.51825786f, 0.26933107f, -0.32182044f, 0.10324197f, 0.02164816f, 0.24351187f, 
    0.05487452f, 0.15916498f, -0.02015585f, -0.02293527f, -0.03838517f, -0.11255053f, -0.04495228f, 0.05945279f, 
    -0.07459754f, 0.12689321f, 0.04124259f, 0.00610676f, -0.04278288f, -0.13491802f, 0.28420410f, 0.09181026f, 
    0.02220141f, 0.09691233f, -0.06893843f, 0.10318398f, -0.12458210f, -0.01451602f, 0.22897382f, -0.14060342f, 
    0.09503165f, -0.00172441f, -0.02662003f, 0.10354282f, 0.05002972f, -0.13874267f, -0.17981994f, 0.04075046f, 
    -0.01550093f, 0.43818435f, -0.27390581f, -0.17750713f, -0.10405365f, -0.22725523f, -0.12374467f, 0.28687796f, 
    -0.18321510f, 0.04967567f, 0.12139569f, 0.00660512f, 0.11619839f, -0.13849542f, -0.04042459f, 0.31208679f, 
    -0.16976136f, 0.14916797f, -0.14445147f, -0.06874522f, -0.43444023f, 0.01564948f, -0.30934915f, 0.22395219f, 
    -0.13130890f, -0.05802502f, 0.04715323f, -0.02345832f, -0.07550538f, 0.00058547f, -0.02708472f, 0.05808497f, 
    -0.00345518f, 0.06061363f, -0.00780809f, -0.00073883f, 0.03957980f, -0.09838701f, -0.02316128f, 0.10119709f, 
    0.04640199f, -0.12026990f, -0.25365856f, 0.03208549f, 0.08476796f, 0.05469957f, 0.06018476f, 0.10847908f, 
    -0.01851940f, 0.04869955f, -0.04167685f, -0.14635722f, -0.04482752f, -0.10049461f, -0.09786758f, -0.06262926f, 
    -0.03302210f, -0.02820841f, -0.16210622f, 0.01112904f, -0.12213060f, 0.11610441f, 0.18526727f, 0.21163303f, 
    -0.26441580f, -0.13938995f, 0.18381514f, 0.18755119f, 0.14065519f, 0.16186099f, 0.02464572f, 0.04451423f, 
    -0.11020701f, -0.13007659f, -0.07733066f, 0.09373862f, -0.00621510f, -0.03484778f, -0.02543371f, -0.07149816f, 
    -0.16730000f, 0.32639748f, -0.30445820f, 0.12349735f, 0.04488755f, -0.01075883f, 0.08353437f, 0.21318053f, 
    0.01283862f, 0.10682951f, -0.07599492f, -0.13083102f, -0.01961246f, -0.15469654f, -0.08484481f, 0.13404091f, 
    -0.08640148f, 0.14635918f, -0.02681108f, -0.09539141f, 0.03639834f, -0.19919500f, 0.15532976f, -0.14693068f, 
    0.04161732f, -0.10204832f, 0.00404118f, -0.08914740f, -0.15924281f, -0.04222202f, 0.09435909f, 0.12362608f, 
    0.02492524f, 0.00453228f, -0.14569671f, 0.18103206f, 0.15533702f, 0.03251736f, 0.04887929f, 0.05159108f, 
    0.07493033f, -0.07067455f, -0.10253358f, 0.14931554f, -0.31126702f, 0.18797405f, -0.11078823f, -0.00096857f, 
    0.02576691f, -0.03813316f, -0.03488332f, -0.00331952f, -0.00166992f, 0.03888815f, 0.13793419f, -0.12199145f, 
    -0.02752119f, 0.05190044f, 0.08569498f, 0.08425444f, 0.00687656f, -0.33107191f, -0.09152289f, 0.05792814f, 
    0.05178266f, 0.19492307f, -0.19345355f, 0.10405880f, 0.08953590f, -0.23888931f, 0.10767257f, 0.07680303f, 
    -0.07983302f, 0.05264254f, 0.13960932f, -0.00769523f, -0.00665911f, -0.06178609f, -0.03023935f, 0.10803163f, 
    0.17396294f, -0.02969365f, -0.07621845f, -0.23321389f, -0.10803900f, 0.01107440f, -0.00266444f, -0.21672283f, 
    0.03812119f, 0.07092684f, 0.01940255f, 0.08236325f, -0.00401877f, -0.06052092f, 0.03369458f, 0.04439032f, 
    -0.11432479f, 0.07573022f, -0.09005327f, 0.00859841f, 0.23437281f, -0.11709545f, 0.31097293f, 0.09613699f, 
    -0.16574249f, 0.04267609f, -0.09290603f, -0.21327493f, -0.09843294f, -0.09662935f, -0.00192044f, -0.05002501f, 
    -0.04333644f, -0.04202873f, 0.01681546f, 0.01652643f, -0.04853028f, -0.19385299f, 0.03119740f, 0.02126889f, 
    -0.10711695f, 0.29308844f, -0.23184989f, 0.21299665f, -0.00064111f, 0.04208298f, -0.08310103f, -0.14202911f, 
    -0.07511813f, -0.18122253f, 0.10541248f, -0.01230718f, 0.02658281f, -0.04928862f, -0.24344599f, 0.01504321f, 
    -0.17771193f, 0.01090897f, -0.04514405f, 0.03412734f, 0.15307565f, 0.66898203f, -0.03998002f, 0.37647796f, 
    0.03327760f, 0.03658227f, 0.18965285f, 0.18178833f, 0.00775677f, 0.28721753f, 0.03660820f, -0.05119845f, 
    -0.01100728f, -0.03231866f, -0.05404184f, 0.12331761f, 0.08923053f, 0.15669492f, 0.03912478f, -0.04780004f, 
    0.04797224f, 0.21438061f, -0.03738105f, 0.16782348f, 0.07123404f, -0.28658342f, -0.20895787f, 0.06949255f, 
    0.00245687f, 0.11819027f, 0.12490919f, -0.00810470f, 0.07712594f, 0.09113935f, -0.01259399f, -0.04328395f, 
    -0.00474679f, 0.27960101f, 0.03569018f, 0.10127751f, 0.35357466f, 0.13981007f, 0.37395522f, -0.00710193f, 
    0.01968177f, 0.10823677f, 0.06282156f, 0.19864590f, 0.16850978f, 0.26685321f, -0.01599123f, -0.04040975f, 
    -0.12131450f, -0.09084558f, -0.01221208f, -0.04755112f, -0.04916304f, -0.08764240f, 0.11829166f, -0.02956157f, 
    0.03665964f, -0.10229605f, -0.37136540f, -0.17706554f, 0.12970887f, 0.07420008f, 0.08756234f, 0.15789491f, 
    0.08820842f, 0.15709743f, 0.16774684f, 0.10868233f, -0.17836589f, -0.13743803f, -0.11511028f, -0.03685471f, 
    0.02850189f, 0.10953223f, 0.07237015f, 0.04964681f, -0.14018050f, -0.11407426f, -0.10781221f, 0.01126922f, 
    -0.05623144f, 0.01334500f, 0.02649270f, 0.02216613f, 0.01700448f, 0.04062599f, 0.00309464f, -0.05761292f, 
    0.06029599f, 0.08985438f, 0.07200510f, -0.08081524f, 0.07176708f, 0.06609512f, 0.04545674f, -0.00162722f, 
    -0.12076842f, 0.10833150f, -0.46514159f, -0.42221785f, 0.22295876f, 0.30332083f, 0.15940540f, 0.17609562f, 
    0.24628757f, 0.06916659f, -0.01882261f, 0.13892449f, -0.17335227f, -0.01958434f, 0.10731719f, -0.04959350f, 
    -0.06828391f, -0.00465233f, 0.02056151f, -0.02084840f, 0.17296349f, -0.05178249f, -0.16678220f, -0.19550735f, 
    0.11115603f, -0.04197483f, 0.26971713f, 0.28369370f, -0.04317092f, 0.16133565f, 0.03055622f, -0.01124197f, 
    -0.05746202f, -0.04703532f, -0.00484465f, -0.03066661f, 0.08727552f, 0.06239367f, 0.19688295f, 0.19191244f, 
    0.02733368f, 0.53913021f, 0.04710804f, -0.17392026f, -0.13458481f, -0.05603890f, -0.16868111f, 0.05471228f, 
    -0.02500680f, 0.07399371f, -0.04833855f, -0.08950007f, 0.01921362f, 0.13351497f, 0.20880626f, -0.13207154f, 
    0.00303217f, -0.03031641f, 0.12662391f, 0.03509091f, 0.42944157f, 0.28769818f, 0.36852071f, -0.21698777f, 
    -0.20685673f, 0.21623756f, -0.30909869f, 0.00932052f, 0.18162917f, -0.16123100f, -0.01995248f, 0.04766559f, 
    -0.04038880f, -0.06596708f, 0.14963683f, -0.23580740f, 0.00565517f, 0.01239538f, 0.03772579f, 0.03469244f, 
    -0.33213708f, 0.01233281f, 0.33101714f, 0.09579605f, -0.04435996f, 0.03665890f, -0.01305861f, -0.13557957f, 
    0.01730638f, 0.00757031f, -0.04143650f, -0.02300182f, 0.06579773f, 0.05301814f, 0.01657079f, -0.15573885f, 
    -0.07389942f, 0.00898305f, -0.25659275f, -0.20908029f, -0.05147186f, 0.11224560f, 0.00183923f, 0.24481924f, 
    0.20471339f, 0.01932032f, 0.01104836f, 0.00148072f, -0.10045114f, 0.00983747f, 0.09898182f, -0.21809308f, 
    0.13573414f, 0.07675376f, 0.05276028f, -0.01390472f, -0.06512746f, 0.00667399f, -0.07742792f, -0.23341049f, 
    -0.10110867f, -0.02594076f, 0.08363545f, 0.10475511f, -0.10067284f, -0.01464440f, -0.17312832f, 0.02961802f, 
    0.04594885f, -0.01612502f, -0.05740619f, 0.09283875f, 0.13825220f, 0.01755873f, 0.04958612f, -0.03506162f, 
    0.14827079f, 0.16655487f, -0.00761109f, 0.09568353f, 0.01432498f, -0.02005679f, -0.08855544f, -0.23840882f, 
    -0.08923469f, 0.06237636f, -0.05807395f, -0.05932457f, 0.10200956f, -0.05393439f, 0.14944318f, -0.00686365f, 
    -0.03972058f, 0.03541879f, 0.14160413f, 0.00138793f, 0.04049142f, -0.06741337f, 0.14233814f, 0.14001676f, 
    0.27586484f, 0.15126306f, 0.15445985f, -0.01036905f, 0.01656643f, -0.01774714f, 0.14449847f, 0.02454478f, 
    0.17385700f, -0.00127657f, -0.03217822f, 0.01928403f, -0.01906879f, -0.01436490f, -0.04951107f, 0.13000718f, 
    -0.05555161f, -0.13075896f, -0.15549555f, -0.22851467f, 0.22625162f, 0.14843287f, -0.06258063f, -0.11951053f, 
    0.06532190f, 0.14835405f, 0.07881001f, 0.04395608f, 0.08554567f, -0.07322207f, 0.01963213f, -0.02270372f, 
    -0.07410575f, 0.07493769f, 0.08777633f, 0.07188858f, 0.00581491f, 0.00053891f, -0.05499743f, -0.19116235f, 
    -0.00257329f, -0.09187211f, -0.15221637f, 0.01596434f, -0.05707086f, 0.03139190f, 0.03571668f, 0.01771776f, 
    -0.02872561f, 0.03036691f, 0.03427164f, 0.01537241f, 0.03460024f, 0.00324742f, -0.04387610f, 0.00146928f, 
    0.15963648f, 0.07991157f, 0.02732718f, 0.04189609f, -0.20363213f, 0.01856972f, -0.20403934f, 0.24356624f, 
    0.27609336f, -0.19172765f, 0.00071139f, 0.00337580f, -0.23686954f, 0.24679323f, 0.02033449f, -0.07717986f, 
    -0.15531112f, -0.04523593f, 0.07800654f, 0.04310929f, -0.06684148f, -0.07354523f, -0.07414272f, 0.11815148f, 
    0.83840662f, 0.56579876f, 0.07309487f, -0.08504410f, -0.20545636f, -0.01230230f, 0.07030531f, -0.05887964f, 
    0.22865544f, -0.25493270f, -0.24701065f, 0.01866799f, 0.05606848f, 0.03322775f, -0.06844448f, 0.01757757f, 
    -0.05196992f, 0.02370816f, -0.02369466f, 0.03872198f, 0.08078999f, -0.26483813f, -0.12766641f, 0.09038551f, 
    -0.05229696f, 0.01123806f, -0.01782987f, -0.07524691f, -0.03337954f, 0.10854193f, 0.00109494f, -0.01267849f, 
    -0.15875593f, -0.11418474f, 0.08377347f, 0.08540294f, -0.01570819f, -0.00183334f, 0.08195397f, 0.14855777f, 
    0.50391543f, 0.19157130f, 0.22262368f, -0.29484957f, -0.08543288f, 0.18534204f, 0.14939190f, 0.06659191f, 
    0.14350781f, -0.01765650f, -0.04034999f, 0.10009397f, 0.07269546f, -0.00044368f, -0.00953535f, -0.04248612f, 
    0.05898134f, 0.08652303f, 0.18464001f, 0.27892515f, 0.08467377f, -0.01391724f, -0.04100124f, -0.00277173f, 
    -0.07857253f, -0.01554105f, -0.00979222f, -0.02175288f, -0.02510799f, -0.01759000f, 0.01252702f, -0.03287974f, 
    0.10812601f, -0.09531157f, -0.11731691f, 0.06034104f, 0.13643020f, 0.03764062f, 0.08906160f, 0.16123970f, 
    0.00332222f, -0.00271008f, 0.01348508f, 0.10553906f, -0.03413063f, -0.07445126f, -0.02767882f, 0.05078646f, 
    -0.00703662f, 0.00143592f, -0.08735184f, -0.06691436f, 0.08313439f, 0.07361731f, 0.20686427f, 0.12975748f, 
    0.02287572f, 0.10150708f, 0.11225353f, 0.03817502f, -0.32181910f, 0.03493863f, 0.22553506f, 0.13166744f, 
    -0.10668780f, 0.09703349f, -0.16774647f, -0.21113601f, -0.00963683f, 0.02482883f, -0.01272752f, 0.02469414f, 
    0.00308782f, -0.03619271f, 0.03810515f, 0.05906606f, -0.05464416f, -0.05096194f, -0.14138979f, -0.08116309f, 
    -0.45173505f, -0.14381774f, 0.16277656f, 0.06751750f, 0.07275670f, -0.03377488f, 0.01608390f, -0.16861211f, 
    -0.01083152f, -0.07052380f, 0.03988985f, -0.00329468f, 0.06409298f, 0.01990071f, 0.02594774f, -0.02431874f, 
    0.01454321f, 0.01261997f, -0.15339015f, -0.08695722f, 0.37134013f, 0.03418540f, 0.23125812f, -0.18015203f, 
    -0.04013011f, -0.06479062f, 0.00491303f, -0.01071721f, 0.04083174f, -0.06940573f, 0.04159079f, 0.06767164f, 
    0.03494506f, -0.10640682f, -0.02648307f, -0.02727734f, 0.06203533f, -0.00698209f, 0.04972259f, 0.19047077f, 
    -0.14203389f, 0.00174218f, 0.27746531f, 0.08954798f, 0.02846063f, -0.02019891f, 0.03959916f, -0.11582861f, 
    -0.04195371f, -0.05904736f, -0.05056284f, 0.07295976f, 0.01629198f, 0.02759441f, 0.01526386f, 0.00093822f, 
    -0.01292402f, 0.02707981f, -0.07815769f, -0.04176068f, 0.00480515f, 0.34419560f, 0.02442975f, -0.11192697f, 
    0.07914039f, -0.03505044f, -0.03511718f, -0.06369342f, 0.04480608f, -0.05168933f, 0.06879791f, -0.00223468f, 
    0.01578067f, -0.02622239f, 0.11658876f, -0.13960360f, 0.01987069f, -0.01564609f, 0.02538484f, 0.06544727f, 
    0.12745659f, 0.22679570f, -0.28247645f, -0.22779381f, 0.23542050f, 0.18926762f, 0.10221284f, 0.23713250f, 
    0.03928391f, -0.01949990f, -0.08200818f, 0.03543613f, -0.11038461f, 0.02916671f, 0.08948398f, -0.07229733f, 
    -0.00732158f, 0.02068358f, 0.03745568f, -0.02537244f, 0.10110296f, -0.07524782f, 0.35846543f, 0.10885835f, 
    -0.08848175f, -0.02318681f, -0.01400144f, -0.10271797f, -0.01068064f, 0.13355522f, -0.00182072f, 0.05053998f, 
    0.05898974f, -0.00305039f, 0.02717805f, -0.20974515f, -0.09353411f, -0.09578928f, -0.14438224f, -0.20585936f, 
    -0.00317934f, -0.04108143f, -0.26877749f, -0.15952265f, 0.20924303f, 0.14644855f, 0.20183045f, 0.09905922f, 
    0.04870984f, 0.07396939f, 0.03303954f, 0.08344058f, -0.14331266f, -0.06610231f, 0.03904950f, -0.06255101f, 
    0.03810474f, 0.04643188f, 0.00579044f, -0.01078273f, 0.02266796f, -0.15884349f, -0.15753408f, -0.03021443f, 
    0.03901188f, 0.01187280f, 0.07903225f, 0.11481675f, 0.08410949f, 0.03636091f, 0.08184658f, 0.02910434f, 
    -0.10210901f, -0.05178177f, -0.04798381f, 0.01908454f, 0.11761545f, 0.09744503f, 0.09046724f, 0.02920290f, 
    0.15480871f, -0.08399548f, -0.00780558f, -0.09049732f, -0.15009950f, 0.02502179f, -0.07699676f, -0.04498548f, 
    0.05346861f, -0.06027437f, 0.05050476f, -0.10732963f, -0.16135547f, -0.01926786f, 0.04319737f, 0.02864472f, 
    0.12137809f, -0.02637137f, 0.07238128f, 0.08076097f, 0.15926301f, 0.07518347f, 0.37132975f, 0.03630919f, 
    0.14175013f, 0.00269960f, 0.15817107f, 0.03100244f, 0.12612085f, 0.05718898f, 0.02812833f, 0.00279405f, 
    0.06484342f, -0.04352982f, -0.02065322f, 0.07545108f, -0.03601909f, 0.02859591f, -0.06920602f, -0.09830423f, 
    -0.08086617f, -0.09697881f, -0.14022040f, 0.00379916f, -0.09803190f, -0.02366450f, 0.03667433f, 0.04745644f, 
    0.02205147f, 0.02873986f, -0.05515993f, -0.07515017f, 0.00052025f, 0.02689502f, 0.09741998f, -0.02738126f, 
    0.06252961f, 0.05877682f, -0.01048213f, -0.01696765f, 0.35685143f, 0.11839718f, -0.15167095f, -0.28384596f, 
    0.15106831f, 0.22074075f, 0.25018120f, 0.12163083f, 0.01447175f, -0.05027849f, 0.06631897f, 0.01478859f, 
    -0.03361879f, -0.04929486f, 0.00543392f, 0.01701697f, 0.05364148f, 0.03827773f, 0.15079190f, 0.27983576f, 
    -0.04038695f, 0.01766767f, 0.36143047f, -0.05730013f, -0.14216110f, -0.10730928f, -0.12179410f, -0.15882708f, 
    -0.13925166f, -0.07660683f, -0.02506004f, -0.01365938f, 0.10416843f, 0.06581454f, -0.00290698f, -0.07637473f, 
    0.01355617f, -0.03007299f, 0.05949429f, -0.00438836f, -0.21128368f, -0.03167034f, 0.06533077f, -0.07601656f, 
    -0.00290315f, -0.14102976f, -0.12440757f, -0.07390159f, -0.13923322f, -0.12228443f, 0.10481993f, 0.15481569f, 
    0.10366954f, 0.03438099f, 0.09298205f, 0.03927341f, -0.04157998f, 0.08029923f, 0.00140109f, 0.09197308f, 
    0.30072320f, -0.09047541f, -0.02697859f, 0.00652976f, -0.22811468f, -0.13849267f, -0.09476598f, -0.03442135f, 
    0.13299990f, 0.05529199f, 0.21544828f, 0.13942248f, 0.03317897f, 0.17510776f, 0.02735802f, 0.07379111f, 
    0.03672469f, 0.08052418f, 0.07765321f, 0.05962644f, 0.22641657f, -0.09209124f, 0.01607423f, 0.00805748f, 
    -0.05575042f, -0.16880262f, -0.14255305f, -0.07706609f, 0.03028823f, -0.00722622f, 0.15596016f, 0.06780024f, 
    0.16999529f, 0.00455895f, 0.07438052f, 0.00776104f, 0.04847722f, 0.05435055f, -0.11742679f, 0.21972443f, 
    0.60921735f, -0.48988023f, 0.14043021f, -0.02922763f, 0.24788114f, -0.14489156f, 0.00028435f, -0.21225028f, 
    0.11709686f, -0.01331025f, 0.20716569f, 0.03088976f, 0.16561951f, 0.04319560f, 0.19174597f, 0.04167442f, 
    0.25624919f, -0.01427616f, 0.11965910f, 0.18406747f, -0.03978908f, 0.15062612f, -0.11493987f, 0.21506713f, 
    0.05052371f, -0.00037352f, 0.22402720f, 0.03816627f, 0.11525634f, 0.00783757f, -0.00280966f, 0.10115693f, 
    0.00946360f, -0.02893945f, 0.07702546f, -0.04217600f, 0.17581083f, -0.06262738f, 0.12911092f, -0.02924643f, 
    -0.21875879f, 0.21096233f, -0.06418124f, 0.13267569f, 0.12193100f, -0.00852664f, 0.01735695f, 0.02144108f, 
    -0.04762850f, -0.07009681f, -0.05651503f, -0.08469734f, -0.02678276f, 0.02032115f, -0.02297475f, 0.01327459f, 
    0.03471819f, -0.17597018f, 0.14300591f, 0.01369579f, -0.12258365f, -0.10649207f, 0.32534331f, -0.19139355f, 
    0.27616224f, -0.03118787f, -0.05827158f, 0.07731599f, -0.00972934f, -0.03223525f, 0.15001801f, 0.23079050f, 
    -0.06803805f, -0.11583415f, 0.14992362f, 0.11451191f, 0.13736217f, 0.13102171f, 0.01971780f, 0.06679203f, 
    0.04866553f, -0.08356522f, -0.28209826f, -0.15927289f, -0.07336499f, -0.05017441f, -0.10354321f, -0.05253078f, 
    -0.06548084f, -0.01238780f, -0.08246183f, 0.03261085f, -0.11580704f, -0.02662880f, -0.12425798f, -0.04292335f, 
    0.08340013f, 0.02770561f, 0.06045710f, 0.18163374f, 0.00633445f, -0.09384372f, -0.10371640f, -0.00606640f, 
    -0.09400689f, -0.21756643f, -0.01275533f, -0.05787316f, 0.04524032f, -0.08926278f, 0.11345002f, 0.22402936f, 
    0.01567510f, 0.01108178f, 0.08627129f, 0.02239764f, 0.00987180f, -0.01776617f, 0.08828332f, 0.05911651f, 
    -0.04380940f, 0.04225452f, -0.01920517f, -0.07025962f, -0.18417622f, 0.09132865f, -0.02714727f, -0.00496599f, 
    0.09554490f, -0.14532962f, 0.08595044f, 0.00919411f, 0.03431171f, 0.10866681f, 0.07709407f, -0.03694254f, 
    -0.02758314f, -0.00888697f, 0.12098607f, 0.01620332f, -0.01187777f, 0.01538705f, -0.00842004f, -0.15463132f, 
    -0.30825171f, 0.06269229f, -0.03396729f, 0.01147109f, 0.01953988f, -0.21606754f, 0.04661971f, -0.07746604f, 
    -0.05615393f, -0.01368255f, -0.04086162f, -0.04793032f, 0.00669131f, 0.02913221f, 0.06898093f, -0.06402358f, 
    -0.02673588f, 0.02002500f, 0.02090290f, -0.02151731f, -0.02814356f, -0.13905498f, -0.07136983f, -0.13532943f, 
    -0.10045084f, -0.08786803f, 0.05256828f, -0.01215857f, 0.01433520f, 0.13771495f, 0.04156215f, -0.09824564f, 
    -0.07276904f, -0.07113861f, 0.02544575f, 0.03576642f, 0.13697021f, -0.12905934f, 0.13304253f, -0.01873694f, 
    0.21420312f, 0.15903741f, 0.06177065f, 0.01499401f, 0.03052964f, 0.13374588f, 0.22307855f, 0.31797236f, 
    0.08207469f, 0.27015138f, 0.17259493f, 0.19614257f, 0.06373367f, 0.25033033f, 0.30507663f, 0.26899540f, 
    -0.59416860f, 0.32425943f, 0.12042457f, 0.29552048f, 0.12837258f, -0.21707188f, 0.21645181f, -0.01562832f, 
    -0.08937258f, 0.11010382f, 0.31435177f, 0.22303382f, 0.19561216f, 0.01908117f, 0.18382031f, 0.09041352f, 
    0.20446572f, -0.01613902f, -0.02843853f, 0.09382951f, 0.08685401f, 0.05033012f, 0.01396863f, 0.10102893f, 
    0.15770246f, -0.05854972f, 0.03475523f, -0.05303390f, -0.04147147f, 0.00210505f, 0.19923648f, 0.26721707f, 
    0.03734403f, 0.25762993f, -0.01737280f, -0.01735166f, 0.06242248f, 0.09457739f, 0.10486152f, 0.16852348f, 
    -0.11123851f, -0.19617629f, -0.25235105f, -0.16356307f, -0.39384630f, -0.01779473f, 0.02251594f, 0.00267711f, 
    -0.01174512f, -0.16361223f, 0.04189859f, 0.02592509f, 0.01199078f, 0.03103292f, 0.02396251f, 0.04045973f, 
    0.14369185f, 0.07217401f, 0.22458586f, 0.11439196f, 0.03606448f, -0.03689429f, -0.06893574f, -0.04456008f, 
    -0.06299265f, -0.19404612f, -0.17077893f, -0.18988205f, -0.16331233f, -0.12594351f, 0.09945533f, -0.18958594f, 
    0.01177557f, 0.05438403f, 0.05814915f, -0.13311598f, 0.03089731f, -0.17878364f, 0.07581360f, 0.15751275f, 
    0.03955937f, -0.01997356f, -0.03761891f, -0.06206396f, -0.14558676f, 0.02965119f, 0.01630801f, 0.12300626f, 
    0.04365413f, 0.08009983f, 0.27976492f, 0.27092910f, 0.15503636f, 0.05564763f, 0.14413407f, -0.04290681f, 
    0.14916672f, -0.01198980f, 0.17802525f, 0.07925678f, -0.08759148f, 0.25635815f, -0.24475671f, 0.13783497f, 
    -0.06697994f, 0.03335295f, 0.09583704f, 0.21037914f, 0.00316682f, 0.06742715f, -0.08985115f, -0.00643781f, 
    -0.07038175f, 0.01106698f, -0.05976930f, 0.04437244f, 0.10453226f, -0.15670153f, 0.20657220f, 0.09986761f, 
    -0.14297803f, -0.05936295f, -0.13984968f, -0.10804107f, -0.13569802f, 0.17547618f, 0.02915566f, 0.11546335f, 
    0.05307435f, -0.01511354f, -0.03122395f, -0.09673681f, -0.12051389f, -0.04791665f, -0.09048530f, -0.00938347f, 
    0.02949790f, 0.01497943f, 0.04150508f, 0.07608438f, 0.13389465f, -0.23409505f, -0.26606840f, 0.07806341f, 
    -0.29802695f, -0.20042260f, 0.07740442f, -0.05105905f, -0.08242597f, -0.34079525f, 0.15018409f, 0.03323552f, 
    0.04168737f, -0.07359687f, -0.18028437f, -0.01793108f, 0.08717690f, 0.04582518f, 0.47105464f, 0.02570892f, 
    -0.08153774f, -0.08766059f, -0.43184760f, -0.08228572f, -0.32703078f, 0.11505376f, 0.14366505f, 0.21864989f, 
    0.14098103f, -0.00128815f, -0.02489198f, -0.01217407f, -0.10575132f, -0.06651131f, -0.07716005f, 0.05145635f, 
    0.00063582f, 0.06933846f, 0.25987628f, -0.02195518f, 0.01483350f, -0.37419972f, 0.12589230f, -0.02869216f, 
    0.19908158f, -0.01820424f, 0.14166975f, -0.02822487f, 0.17839845f, 0.11332329f, 0.09548150f, 0.08896178f, 
    0.16899487f, 0.04234732f, 0.04187416f, 0.07672526f, 0.28293076f, 0.13994186f, 0.15146962f, 0.18934190f, 
    0.16827027f, -0.13278101f, 0.05491959f, -0.19929293f, -0.37842542f, -0.01899362f, -0.04009707f, 0.06400573f, 
    0.20724858f, 0.10327203f, 0.15579195f, -0.02517986f, 0.04390200f, 0.09107864f, 0.03471721f, 0.10215296f, 
    0.05938521f, 0.06073995f, 0.06052379f, 0.01445821f, 0.25644487f, 0.00097882f, -0.12129309f, 0.18334883f, 
    0.16279055f, 0.00673921f, -0.04655212f, 0.03432424f, -0.05075680f, 0.07864661f, 0.11280918f, -0.04179111f, 
    0.07591435f, 0.06252097f, 0.01754619f, 0.04569987f, 0.17849837f, -0.09477638f, 0.01783457f, 0.04615784f, 
    0.14517879f, 0.07676375f, -0.01193435f, -0.04670267f, -0.18443908f, -0.00878154f, 0.00607528f, 0.02220367f, 
    0.04039225f, 0.10931049f, 0.07756792f, 0.12857732f, 0.10127962f, 0.04568019f, -0.02497754f, 0.03945060f, 
    0.08036021f, 0.07642689f, 0.09657749f, 0.03903114f, 0.07798552f, 0.11904434f, 0.05401431f, 0.13393979f, 
    -0.08688622f, -0.10196542f, -0.00534893f, -0.09810521f, -0.11979897f, -0.05761540f, -0.02146230f, 0.06896555f, 
    0.17057642f, 0.10505160f, 0.09342881f, -0.06073285f, -0.01122771f, -0.12249763f, 0.14355104f, 0.02571094f, 
    -0.06762684f, -0.02592435f, -0.02095568f, 0.08170311f, -0.08684242f, -0.21402451f, -0.02822819f, 0.03233278f, 
    -0.00991284f, -0.11543357f, 0.18789087f, 0.05881532f, 0.07664239f, 0.00549741f, -0.07184432f, -0.03571993f, 
    0.06619181f, -0.01049014f, 0.10996715f, 0.02227392f, -0.28986663f, 0.08950861f, -0.25502145f, -0.00540386f, 
    -0.24596968f, 0.23080255f, -0.02316581f, 0.24339887f, -0.05782784f, -0.10279251f, -0.01002603f, 0.01997311f, 
    -0.03591716f, 0.07277610f, -0.00436981f, 0.20956530f, 0.04475945f, 0.11798332f, -0.00831336f, 0.06179708f, 
    -0.25497630f, -0.09593812f, -0.03456755f, -0.07753955f, -0.02925859f, -0.27598676f, -0.23433624f, -0.11707205f, 
    -0.14976566f, -0.21822739f, 0.06630107f, 0.19532691f, 0.11956963f, 0.21331327f, 0.01617411f, 0.05667196f, 
    0.03218199f, 0.14274909f, 0.04636294f, 0.02851432f, -0.10545809f, -0.12723531f, -0.04893202f, -0.28226236f, 
    -0.26333654f, -0.08961183f, -0.02139298f, 0.05194575f, -0.01622064f, -0.10693092f, 0.01806702f, -0.00599053f, 
    -0.02268894f, 0.01767202f, -0.03275634f, 0.06075720f, 0.05109790f, 0.07631987f, 0.08898486f, -0.06969406f, 
    -0.04024668f, 0.00375133f, -0.00019169f, 0.02283832f, 0.02110794f, 0.01637624f, 0.02130902f, -0.04096130f, 
    -0.01632232f, 0.02533024f, -0.00420956f, 0.03521081f, 0.00416477f, -0.01039261f, -0.01921969f, -0.02451570f, 
    0.00612119f, 0.02699574f, -0.02081075f, -0.01794132f, 0.02389912f, -0.02883281f, 0.02974737f, -0.00943405f, 
    -0.00557705f, -0.03875614f, -0.01823278f, 0.02345999f, -0.02452562f, -0.03423170f, -0.02794912f, -0.02802259f, 
    0.01849071f, -0.03323361f, -0.03596154f, -0.01923680f, -0.03593554f, -0.02106504f, 0.02949675f, -0.03330059f, 
    -0.01462587f, -0.03869840f, -0.01813828f, -0.04215119f, 0.01867370f, 0.01995539f, -0.03634691f, 0.00731479f, 
    -0.03269279f, -0.00709402f, 0.01601678f, 0.00587953f, -0.00771031f, 0.03260369f, -0.01971104f, -0.01640405f, 
    0.00225208f, -0.02021296f, 0.00523280f, -0.00381619f, -0.03415711f, -0.02855114f, -0.00336642f, -0.01464700f, 
    -0.04038016f, 0.01170369f, 0.02681431f, 0.02957113f, -0.01644594f, 0.00503832f, 0.02988999f, -0.04220994f, 
    -0.00028517f, 0.00882171f, 0.01215382f, -0.02293150f, 0.00767622f, 0.00241412f, -0.00816712f, 0.02716266f, 
    -0.00069260f, 0.02510856f, -0.01577910f, -0.01854299f, -0.00239626f, -0.00979962f, 0.02934503f, -0.03136611f, 
    -0.03523885f, 0.02748728f, 0.01661559f, -0.01519411f, 0.02099621f, 0.00629628f, -0.04214527f, -0.02219690f, 
    -0.01345441f, 0.00973716f, -0.01863367f, -0.04383279f, -0.01584710f, -0.04558998f, 0.00927215f, -0.03669015f, 
    -0.02935791f, -0.03581604f, 0.03276727f, -0.02944330f, -0.02953053f, -0.02898396f, 0.02366798f, -0.00450786f, 
    0.02758861f, 0.02675289f, 0.02830371f, 0.03740839f, 0.01332215f, -0.04298253f, 0.01275832f, -0.01561126f, 
    0.01177243f, 0.00571009f, 0.00011933f, 0.04433931f, 0.01429017f, -0.00231304f, 0.00278297f, 0.01503075f, 
    -0.04442660f, -0.00629156f, 0.01324263f, -0.03992423f, 0.02349719f, 0.03153577f, -0.02507174f, -0.01929466f, 
    0.00750204f, -0.01681542f, 0.02897924f, 0.02787650f, -0.03411903f, 0.00124630f, 0.03586917f, 0.01704163f, 
    -0.03729660f, -0.04842495f, -0.03787456f, -0.01484966f, 0.02760171f, -0.01018692f, -0.02603593f, -0.02566946f, 
    -0.01613111f, -0.02760919f, 0.00240241f, -0.00727402f, 0.01821920f, 0.00483516f, -0.02603535f, -0.03905549f, 
    -0.01786727f, -0.00423681f, -0.01222761f, 0.02391623f, 0.00208206f, -0.03316854f, -0.00133205f, -0.01184855f, 
    0.03332928f, -0.03397689f, -0.02206467f, -0.02088011f, -0.02323071f, 0.02213753f, 0.03270578f, -0.02534138f, 
    -0.01548121f, -0.00853249f, -0.01062789f, 0.01492674f, 0.01093786f, 0.01656296f, -0.00131858f, 0.02395289f, 
    -0.03224463f, 0.03200385f, -0.04472613f, -0.00159412f, 0.01387400f, -0.03930376f, -0.01269510f, -0.02112235f, 
    0.01006405f, 0.01184000f, -0.02036188f, -0.00516227f, -0.01688482f, 0.03435552f, -0.04677590f, -0.03640646f, 
    -0.03536663f, 0.01919780f, 0.01321934f, 0.02008432f, -0.00908037f, 0.00468562f, -0.02033189f, 0.01827983f, 
    0.01416563f, -0.01041537f, 0.03400915f, -0.01016913f, -0.02839246f, -0.01995119f, -0.04545359f, -0.04697282f, 
    0.00033182f, -0.00689730f, 0.00486426f, -0.04053205f, -0.01968422f, -0.00383783f, -0.00674080f, 0.01271094f, 
    0.00885451f, 0.01860944f, 0.01920590f, 0.00682296f, 0.01851826f, 0.00381783f, -0.00110057f, -0.00624116f, 
    -0.00464316f, -0.00041752f, -0.01442000f, -0.01316355f, -0.02278475f, 0.00823317f, -0.02634362f, -0.01610640f, 
    -0.02553622f, 0.00174656f, -0.01980682f, 0.01427309f, -0.03573770f, 0.01155361f, 0.00288724f, 0.02125865f, 
    -0.03185020f, 0.01868143f, -0.01227320f, 0.03650460f, 0.03553692f, -0.02236978f, 0.01307221f, -0.00010374f, 
    -0.01489417f, -0.00828165f, 0.02382152f, -0.02965860f, -0.00469368f, 0.00636701f, -0.00741779f, -0.03227075f, 
    -0.04502748f, 0.00817702f, 0.00217826f, -0.02913638f, 0.02226640f, -0.04145081f, -0.00538614f, -0.04476198f, 
    -0.02875860f, 0.00902638f, 0.02063629f, -0.03106313f, -0.00971902f, -0.00411180f, 0.01433307f, 0.00014427f, 
    0.00308931f, 0.01423070f, 0.02283607f, 0.03443527f, -0.00185921f, -0.00614665f, 0.02840445f, 0.03469997f, 
    -0.02461956f, -0.04157788f, -0.01952576f, -0.02397875f, 0.01144442f, -0.03694787f, -0.02063410f, 0.01368713f, 
    -0.00202252f, -0.00902848f, 0.01594163f, 0.00111310f, 0.02323537f, -0.00534835f, -0.00876861f, -0.04021060f, 
    -0.00091294f, -0.03244794f, -0.00529498f, 0.00395844f, -0.03829157f, -0.00726253f, -0.03906434f, 0.00338555f, 
    -0.03726174f, -0.03958790f, 0.02201174f, 0.01509758f, 0.01516504f, -0.00022813f, 0.01424187f, -0.01765439f, 
    -0.00127747f, -0.01181245f, 0.03149353f, -0.00164559f, 0.03126171f, -0.00003914f, -0.03586196f, -0.02963297f, 
    -0.00696717f, -0.04356508f, 0.01496078f, -0.03310278f, 0.00113041f, -0.03179896f, 0.02613819f, 0.01086562f, 
    -0.00360979f, 0.02502248f, 0.02642010f, -0.00310828f, -0.02720919f, 0.00500687f, -0.02243851f, 0.02323464f, 
    0.00978323f, -0.03983134f, 0.00669520f, -0.00487276f, 0.03355725f, -0.01576856f, 0.00715201f, -0.01716486f, 
    0.00763684f, 0.03731558f, 0.00351292f, -0.01742438f, 0.02575771f, -0.04732846f, 0.00846352f, 0.02223957f, 
    0.02236051f, 0.01060935f, -0.01121065f, 0.03678870f, 0.02975344f, 0.00353963f, 0.02603123f, 0.00308735f, 
    -0.03720401f, -0.00150484f, -0.03215687f, -0.02450222f, 0.00873063f, -0.00139258f, -0.01544935f, 0.03478994f, 
    -0.00839045f, -0.04233909f, -0.02085669f, -0.01126541f, -0.02828788f, -0.00847304f, -0.04364420f, -0.02679046f, 
    0.01573929f, 0.01090316f, -0.03156555f, -0.00002555f, -0.04400212f, 0.03065043f, -0.01464016f, -0.03624987f, 
    0.01819561f, -0.03423276f, 0.03111470f, -0.02202720f, -0.02928933f, 0.00782630f, -0.02938980f, 0.02892603f, 
    0.00927648f, -0.04420820f, -0.02036989f, -0.00356658f, -0.01106945f, -0.01590797f, -0.01827343f, -0.02090252f, 
    0.00331796f, -0.04564807f, -0.00530029f, -0.00266029f, 0.01696984f, -0.02580331f, -0.02150033f, -0.01332152f, 
    -0.02809885f, 0.01097534f, -0.00961936f, 0.02736643f, 0.02364453f, 0.00956036f, 0.00737089f, -0.01296194f, 
    0.02467887f, 0.03682341f, -0.02471605f, 0.02071278f, 0.04219288f, 0.01937140f, 0.03309605f, -0.01552940f, 
    -0.04334774f, -0.02736788f, -0.03275768f, -0.02118798f, 0.03251183f, -0.01492904f, 0.03386913f, -0.02785197f, 
    -0.01242043f, -0.04071390f, -0.03367578f, 0.00906228f, 0.01349006f, -0.04012382f, -0.04493774f, -0.02914389f, 
    -0.01996295f, -0.02773901f, 0.03757799f, 0.02495849f, 0.01405928f, 0.02299946f, -0.01048494f, -0.00709312f, 
    0.02578711f, -0.02789021f, -0.02738668f, 0.00973663f, -0.02627832f, -0.01151570f, -0.00801786f, -0.02203084f, 
    0.00655139f, -0.04179295f, 0.00344925f, -0.03652465f, 0.00609228f, -0.02648085f, 0.03091404f, -0.03508491f, 
    -0.02545491f, -0.02999335f, -0.03586026f, -0.01119527f, -0.00026174f, 0.00820288f, -0.00789595f, 0.03491147f, 
    -0.04319025f, -0.03963263f, 0.02535470f, 0.01140822f, 0.00190269f, -0.03097930f, -0.01220297f, -0.03925741f, 
    -0.04157510f, 0.00859254f, 0.02349827f, 0.02858246f, -0.03320278f, 0.02142828f, -0.02842452f, -0.00166831f, 
    -0.01753786f, -0.04678227f, -0.02487522f, -0.00535874f, -0.00350080f, -0.02362780f, -0.00999274f, -0.01487977f, 
    0.01430084f, -0.00130512f, -0.04202046f, -0.01595903f, -0.03355919f, -0.00099720f, 0.03141266f, -0.03907810f, 
    -0.04460762f, -0.02804564f, -0.01627507f, -0.02370348f, -0.04068064f, -0.03974130f, 0.00204512f, -0.00194744f, 
    0.03440578f, 0.02251098f, -0.00552171f, -0.03563644f, -0.01188980f, 0.00705537f, -0.00475876f, 0.02885468f, 
    0.01664898f, 0.03077654f, 0.00424764f, -0.03209262f, 0.01052109f, -0.03858036f, 0.01191646f, -0.02367537f, 
    0.02778719f, 0.01474152f, 0.02150353f, -0.00567069f, 0.02789779f, 0.03391900f, 0.03084485f, -0.01665639f, 
    -0.04838059f, -0.00314256f, -0.00667183f, 0.01654932f, 0.03300591f, 0.01795072f, -0.00287516f, -0.02828944f, 
    0.00469753f, -0.00986744f, -0.00062531f, -0.03444091f, -0.00681833f, -0.03425217f, -0.04431094f, -0.01924600f, 
    -0.01852838f, -0.00729000f, -0.03929565f, -0.03356692f, 0.02591517f, 0.00687078f, -0.02440562f, 0.02878366f, 
    -0.01572754f, 0.00223081f, 0.03880355f, -0.02739990f, 0.02120520f, 0.02780476f, 0.02968339f, 0.03650019f, 
    0.02422368f, -0.03078812f, 0.03559973f, 0.02233877f, -0.00087232f, -0.01270831f, 0.02154673f, -0.00015078f, 
    0.03154305f, -0.02371912f, -0.03791521f, -0.00789073f, 0.01515183f, 0.00298615f, -0.01260895f, 0.02520340f, 
    0.02799403f, 0.01077403f, -0.00617514f, 0.02772298f, -0.03396921f, -0.03055173f, 0.02133783f, -0.03643024f, 
    0.02402076f, -0.02392293f, -0.03071422f, -0.00939039f, 0.00455671f, 0.03320123f, -0.04124739f, 0.01748093f, 
    0.00398318f, -0.01835692f, 0.00919962f, 0.03024692f, 0.02057782f, 0.02960943f, -0.00475331f, -0.01055398f, 
    0.00934845f, -0.03499780f, -0.00506277f, -0.02307824f, 0.00298862f, 0.03054561f, -0.01817922f, -0.03687022f, 
    -0.01132692f, -0.00866798f, -0.00319462f, -0.01796797f, -0.02028481f, -0.00663965f, 0.01452818f, 0.02365008f, 
    -0.01910231f, -0.04415339f, -0.03942694f, -0.00022008f, -0.00155557f, 0.01977768f, 0.03373359f, -0.01783367f, 
    -0.03888309f, -0.01998179f, -0.03339765f, -0.01212315f, -0.00031477f, -0.02426184f, 0.03101629f, -0.02503081f, 
    -0.00536545f, -0.04057922f, 0.01709792f, 0.02784507f, 0.02225940f, 0.00436890f, 0.01242831f, -0.00830856f, 
    0.02918011f, -0.01817688f, 0.00567433f, 0.00983535f, 0.01980492f, -0.01473917f, -0.03146047f, 0.00481346f, 
    -0.03024941f, -0.03531187f, 0.01537285f, -0.01713902f, 0.00220698f, 0.02155285f, -0.01191900f, -0.02758200f, 
    -0.04700284f, -0.04836843f, 0.00358096f, -0.00154601f, -0.00464140f, -0.03126612f, -0.00929857f, -0.01537638f, 
    -0.01542862f, 0.00756585f, 0.00418205f, 0.02536674f, -0.01518821f, 0.00885157f, -0.04119576f, -0.01615127f, 
    -0.02770493f, 0.01046928f, 0.00195503f, -0.01388802f, -0.03815693f, -0.01199373f, -0.03427346f, 0.00549140f, 
    -0.04161792f, -0.03886048f, -0.01596396f, 0.02750896f, 0.02168041f, 0.02330741f, 0.01734145f, -0.01942773f, 
    -0.04319276f, 0.02544091f, -0.00597377f, 0.01973476f, -0.03095502f, -0.01447939f, -0.02630289f, 0.00630017f, 
    0.02421927f, -0.02725014f, -0.04676813f, 0.01154301f, 0.02260510f, 0.00024887f, -0.03987906f, -0.04792217f, 
    0.01640573f, -0.02457265f, -0.02273703f, 0.03838209f, 0.02508746f, -0.00837194f, 0.00460014f, -0.02292712f, 
    0.02661895f, -0.01935818f, -0.01611806f, 0.00491432f, 0.00105561f, 0.01001471f, 0.00891667f, 0.01040886f, 
    -0.03319915f, -0.04338633f, -0.03401864f, -0.03766493f, 0.03135114f, 0.01456840f, -0.01237292f, -0.01987374f, 
    0.02587453f, -0.04558541f, -0.01317265f, 0.02977307f, -0.03941314f, 0.01426011f, -0.03342240f, -0.03026805f, 
    0.00072044f, 0.01540036f, -0.04372881f, -0.01822261f, 0.00017351f, 0.02054442f, -0.02345327f, -0.02765423f, 
    -0.01703479f, 0.02911029f, 0.00391430f, -0.01654087f, 0.02482989f, 0.00453666f, 0.00975447f, -0.02903780f, 
    0.02403976f, 0.02583523f, 0.02725266f, 0.01058556f, -0.03798262f, 0.02353682f, 0.00958464f, 0.00980946f, 
    0.02481277f, -0.01227437f, -0.03422294f, -0.01282484f, -0.00934280f, -0.00070914f, -0.02399756f, -0.02791979f, 
    0.02392721f, 0.02438400f, -0.02851966f, 0.03261099f, -0.01813632f, -0.03341438f, 0.02555036f, 0.02027076f, 
    -0.01368711f, 0.01171209f, 0.01472438f, -0.00339810f, 0.01561985f, 0.01855282f, -0.00380288f, -0.03269330f, 
    -0.00211239f, 0.01896896f, 0.03049164f, 0.00707135f, 0.02028426f, 0.00520424f, -0.02511916f, -0.00109716f, 
    0.00499339f, -0.01360872f, -0.03763804f, -0.00078252f, 0.01571530f, 0.00769949f, -0.00344983f, 0.01405338f, 
    -0.04196471f, -0.00367299f, -0.04764777f, -0.02084628f, 0.03448075f, -0.00053198f, -0.01745482f, 0.00859035f, 
    -0.04130466f, 0.02322560f, -0.02012728f, -0.00004339f, 0.00385970f, 0.02152787f, -0.01060713f, -0.03104185f, 
    -0.03269445f, 0.01426011f, 0.01340244f, 0.00184480f, -0.04789484f, -0.00036415f, -0.04504747f, 0.01433540f, 
    -0.00781381f, 0.01249563f, -0.00196266f, -0.03794527f, 0.01886247f, 0.01476963f, 0.01142247f, -0.04175287f, 
    -0.00505393f, 0.03934833f, 0.01220923f, -0.02894929f, -0.02957204f, -0.04592928f, -0.01861948f, 0.00250357f, 
    0.01652887f, 0.02477613f, -0.03280951f, -0.01291072f, -0.01445959f, -0.04653036f, -0.01551166f, -0.02019757f, 
    -0.00696008f, -0.02575650f, -0.00942673f, -0.02114937f, -0.02960151f, 0.01174447f, -0.04329753f, -0.01133413f, 
    0.01390234f, 0.03328143f, -0.03779186f, 0.02048791f, -0.04028226f, -0.02085291f, -0.00012217f, 0.04392533f, 
    0.02517820f, -0.02426993f, -0.04226006f, -0.03459639f, 0.02538140f, -0.02811655f, 0.03238065f, -0.01293651f, 
    0.00740291f, 0.02108943f, 0.00801273f, 0.00811341f, 0.01992551f, -0.00939548f, -0.04585893f, -0.01066421f, 
    0.02216702f, -0.00376860f, -0.04445620f, 0.03242061f, -0.04820756f, -0.01622720f, 0.01610619f, -0.01571481f, 
    -0.00345159f, 0.02387381f, 0.00526479f, -0.01922912f, -0.03196749f, 0.01004316f, -0.03010914f, 0.02655675f, 
    -0.01934370f, -0.00937115f, -0.00549568f, 0.03042214f, -0.02127633f, -0.00187118f, 0.01981398f, -0.03900452f, 
    -0.02589975f, 0.00850908f, -0.00641802f, 0.00546930f, -0.02727592f, 0.02259028f, -0.03985818f, 0.00565844f, 
    -0.03165281f, -0.01161192f, -0.01162761f, 0.01593447f, 0.03694100f, 0.02029876f, -0.02348303f, -0.05025133f, 
    0.00176166f, -0.03439961f, 0.00787768f, -0.04205799f, 0.01496037f, 0.02904391f, -0.03975311f, -0.03426840f, 
    -0.00671947f, -0.00169065f, 0.03303207f, -0.00535024f, 0.01867654f, -0.00707190f, -0.03942398f, -0.04220861f, 
    -0.02906153f, -0.02433378f, -0.00864712f, 0.00521907f, -0.01833159f, -0.03245142f, 0.02936630f, -0.04972606f, 
    0.00813426f, 0.02496633f, -0.03482462f, -0.03971557f, -0.00249875f, -0.02299238f, 0.02309350f, 0.00611680f, 
    -0.04300956f, -0.03983366f, -0.01992762f, 0.02789236f, -0.00781924f, -0.01095047f, -0.02199656f, -0.01349317f, 
    -0.04509825f, -0.01235252f, 0.01849794f, -0.00243478f, -0.03248137f, -0.00145044f, 0.02797899f, 0.02556290f, 
    0.01782011f, -0.01706178f, 0.02442897f, -0.00449039f, 0.02509466f, -0.01984092f, -0.00311021f, -0.03196897f, 
    0.01818454f, -0.02873366f, 0.01731551f, 0.00172271f, 0.01205947f, 0.01781032f, 0.02702226f, 0.00898401f, 
    0.00999734f, -0.00550356f, -0.04808128f, 0.00981275f, -0.00771832f, -0.02251549f, 0.01538152f, -0.01348760f, 
    -0.02328422f, 0.01210745f, 0.00317315f, 0.01422424f, 0.01432056f, -0.02197028f, -0.01355740f, 0.00804860f, 
    -0.02314967f, -0.01583626f, 0.02454232f, 0.03002920f, -0.00130073f, 0.01849786f, -0.00518055f, 0.03894687f, 
    0.01430796f, 0.00255270f, 0.02428076f, -0.02006461f, -0.03351065f, -0.00057714f, 0.00112245f, 0.00880282f, 
    -0.03389689f, 0.01030034f, 0.01326796f, -0.02738474f, -0.03742530f, 0.00583452f, -0.00438005f, -0.00599967f, 
    0.01528611f, 0.03321357f, -0.02550234f, -0.01657080f, 0.01886655f, 0.00371150f, -0.00515807f, -0.01850749f, 
    -0.02453998f, -0.02656069f, -0.01358740f, -0.00464947f, 0.00576759f, -0.00007400f, -0.01201126f, -0.03320795f, 
    -0.03257783f, -0.01819137f, 0.00313122f, -0.02040259f, -0.01895233f, -0.02668085f, -0.00388976f, -0.00099220f, 
    -0.01681897f, 0.00934082f, 0.02295621f, 0.03088455f, -0.01500506f, -0.03592080f, 0.02562009f, -0.03670494f, 
    -0.03088176f, 0.02988965f, 0.01977689f, -0.01392545f, 0.00168268f, 0.03004130f, 0.01555097f, -0.02166712f, 
    0.03130730f, -0.00319700f, -0.01839655f, -0.03143332f, -0.02215030f, 0.03023708f, -0.00229081f, 0.00083697f, 
    0.01724225f, -0.00457595f, 0.00100774f, 0.01461658f, -0.01778934f, 0.00827478f, 0.02340824f, 0.01557975f, 
    -0.00836034f, -0.02078667f, -0.03000328f, -0.01584708f, 0.01546713f, -0.02837906f, 0.01463009f, -0.01934444f, 
    -0.00945979f, 0.01221735f, -0.02493612f, -0.01720069f, -0.02722546f, -0.02970671f, 0.02536711f, -0.01508220f, 
    -0.03985261f, -0.00201574f, -0.03269625f, 0.02722137f, -0.03897510f, -0.00037912f, -0.02191664f, -0.04945229f, 
    -0.04102273f, -0.00554428f, 0.00001057f, 0.01381326f, -0.04440128f, 0.02209667f, -0.04215617f, -0.03056806f, 
    0.00883931f, 0.00443496f, -0.02896068f, -0.00091173f, -0.00464646f, -0.04339090f, -0.00613473f, -0.03981131f, 
    -0.03966076f, -0.01877823f, -0.00993795f, -0.01887731f, -0.01126877f, 0.03374305f, 0.01088700f, 0.03333399f, 
    -0.00190375f, 0.02373833f, 0.03061364f, -0.03424529f, 0.00640897f, 0.02176751f, 0.02168069f, 0.02475910f, 
    0.03576721f, -0.00619230f, -0.03621464f, -0.01074169f, -0.04012562f, 0.02131929f, -0.02580671f, -0.00296922f, 
    -0.04216402f, 0.01802114f, 0.01958461f, -0.02214183f, 0.01218201f, -0.04702875f, -0.03596511f, -0.01789990f, 
    0.00710123f, 0.01749299f, -0.01396383f, 0.02702369f, 0.01771907f, -0.03762740f, 0.00344950f, -0.03593311f, 
    -0.01883387f, -0.03100926f, 0.00531868f, -0.04268053f, -0.01157768f, 0.01049776f, -0.01513681f, -0.04378783f, 
    -0.02379689f, -0.03015711f, -0.00044812f, -0.02964723f, -0.03024535f, -0.04344178f, -0.01884720f, 0.02393549f, 
    0.01942723f, 0.00143216f, -0.03080903f, -0.01716256f, 0.02632907f, 0.01188559f, -0.02091538f, 0.01705160f, 
    0.01541170f, 0.00571652f, -0.00886041f, -0.03985535f, 0.01422291f, 0.00743567f, -0.00593140f, 0.03337658f, 
    0.00577229f, 0.01485748f, 0.00081562f, -0.04440818f, -0.01984198f, -0.03625972f, 0.02356441f, -0.01076540f, 
    0.01296326f, 0.01505204f, 0.02243262f, -0.00947038f, -0.00063626f, -0.01350044f, 0.01810961f, -0.01196599f, 
    -0.00254387f, 0.00786899f, -0.00140591f, -0.03687447f, 0.01270150f, 0.00268303f, 0.01456265f, -0.03823122f, 
    -0.00729357f, -0.02071918f, -0.01611185f, -0.01859234f, -0.04638230f, -0.02407934f, -0.04102825f, -0.03860511f, 
    -0.01761533f, -0.02744628f, -0.02849612f, 0.00109363f, -0.01211881f, -0.00908774f, 0.02867871f, 0.01313222f, 
    0.03624819f, 0.01073934f, 0.01760354f, -0.02833080f, 0.03191519f, -0.04169632f, 0.00157576f, -0.02061416f, 
    -0.03825346f, 0.01595906f, -0.00121425f, 0.01236519f, -0.05030050f, 0.01801272f, 0.00292736f, 0.00793112f, 
    -0.00985060f, -0.04822538f, -0.03257329f, -0.02737649f, -0.03591863f, 0.00799905f, 0.02772785f, -0.01867397f, 
    0.00903067f, 0.00366569f, 0.02347026f, -0.02399207f, 0.00346831f, 0.02281370f, 0.01767411f, 0.02556423f, 
    -0.03733483f, -0.00280258f, -0.02657133f, -0.03326251f, 0.00752989f, -0.02127869f, 0.00112004f, -0.01795459f, 
    0.00560801f, -0.00739942f, 0.00890844f, -0.01836300f, -0.04435825f, -0.02252133f, 0.02793963f, 0.02224052f, 
    0.02037954f, -0.02199168f, 0.02343242f, 0.01044429f, -0.03496056f, -0.01985226f, -0.04050213f, -0.00390389f, 
    0.00303231f, -0.00717763f, -0.04298424f, -0.04080405f, 0.01089752f, -0.04443374f, 0.02705163f, 0.02217721f, 
    0.01762013f, 0.03518438f, -0.03170934f, 0.00886174f, 0.00479639f, -0.01667188f, 0.02416634f, -0.02288559f, 
    0.00634333f, 0.03051653f, -0.02334633f, -0.02064665f, -0.02337833f, -0.01164710f, 0.00845089f, -0.03364576f, 
    0.03013052f, 0.01446677f, -0.02620594f, -0.00080690f, 0.02093897f, -0.01325270f, 0.02689115f, -0.02078270f, 
    0.00255781f, -0.02012248f, -0.01356305f, -0.03691271f, 0.00184512f, -0.02888359f, -0.01073805f, -0.00686212f, 
    -0.02004420f, -0.04332718f, -0.01183074f, -0.00205789f, 0.02981168f, 0.01896267f, -0.02515170f, 0.02770676f, 
    0.00554844f, -0.00704151f, -0.03967301f, -0.01235656f, 0.02576033f, 0.01296108f, -0.01301744f, -0.02081578f, 
    -0.03538584f, 0.02359696f, 0.00153315f, 0.01974981f, -0.01672634f, 0.02619074f, -0.00854185f, 0.02145664f, 
    0.01854436f, -0.02434118f, -0.02533377f, -0.02903884f, -0.02704457f, 0.00051888f, -0.01641602f, -0.03089437f, 
    0.03583895f, -0.02396311f, -0.02646996f, -0.01928594f, -0.02884476f, 0.02283734f, -0.03368641f, -0.02319566f, 
    -0.01615926f, 0.01024251f, -0.01828705f, -0.00048218f, 0.03119980f, 0.03132070f, 0.01969454f, -0.01164364f, 
    -0.03370765f, 0.00210759f, -0.02830175f, -0.02958668f, -0.02556934f, -0.02599194f, 0.01790318f, -0.03090351f, 
    -0.02493789f, 0.01494383f, -0.01719577f, -0.03564381f, -0.02241932f, -0.02865605f, -0.00093939f, -0.03610959f, 
    0.00366595f, 0.00969126f, -0.00944434f, -0.02658234f, -0.00876683f, -0.02245670f, -0.02815326f, 0.03049764f, 
    0.00499534f, -0.01143219f, -0.01416463f, 0.02967342f, 0.02415459f, -0.04012431f, 0.02172569f, -0.01713749f, 
    0.01592989f, 0.01595017f, 0.01971721f, -0.01218577f, 0.00292620f, 0.02260747f, -0.00759285f, 0.00887542f, 
    0.00891082f, 0.03451886f, -0.01714314f, -0.02923787f, 0.00869464f, -0.03015203f, 0.02899665f, 0.01211651f, 
    -0.03672390f, 0.00941452f, -0.04416140f, -0.03569767f, 0.00452326f, 0.01186335f, -0.00569035f, -0.04329817f, 
    0.02108791f, 0.00986508f, 0.01668714f, 0.01422427f, 0.01477895f, 0.03118096f, -0.02486305f, -0.00143385f, 
    -0.01878745f, 0.00844560f, -0.01784401f, -0.02018501f, -0.00353744f, -0.02130439f, 0.02981726f, 0.02965735f, 
    -0.02087015f, -0.04087603f, 0.03110988f, -0.01701910f, 0.01638533f, -0.02394265f, -0.02072231f, 0.00517972f, 
    -0.01337386f, -0.01737017f, 0.03384384f, 0.02494247f, -0.01039641f, 0.03034103f, 0.00390398f, 0.01255649f, 
    -0.00150712f, 0.01577951f, -0.02413173f, -0.01051939f, 0.01849530f, -0.03685397f, 0.01492977f, 0.02840149f, 
    -0.02160086f, 0.00678182f, -0.03340803f, 0.03089601f, -0.00171271f, -0.04333056f, 0.03729071f, 0.00087358f, 
    0.01824531f, -0.00399400f, -0.01302234f, -0.01933437f, -0.03435443f, -0.00149959f, -0.00326182f, -0.02112943f, 
    0.03985418f, -0.02371643f, 0.01291752f, 0.02584285f, 0.00634563f, 0.01219513f, 0.02197807f, -0.04060587f, 
    -0.01919288f, -0.03906206f, 0.02327979f, -0.03896118f, 0.00985953f, -0.01845116f, -0.02396443f, -0.02006032f, 
    -0.00034975f, 0.01159720f, 0.00099376f, -0.02741762f, 0.02107751f, -0.00449325f, -0.00761244f, 0.00834490f, 
    0.02018954f, -0.02734643f, 0.02406184f, 0.03124817f, -0.04195649f, -0.02932275f, -0.04278686f, 0.01160392f, 
    -0.03097045f, 0.00598495f, -0.01360874f, 0.02831746f, -0.03511601f, -0.04507884f, 0.01142492f, 0.03019978f, 
    -0.01573758f, -0.02374309f, -0.02022389f, 0.03282837f, -0.04030924f, 0.01315407f, -0.02874363f, 0.01714462f, 
    0.02813174f, 0.04062604f, 0.01692661f, -0.03795339f, 0.00359894f, 0.01995854f, 0.02660351f, 0.03504785f, 
    0.01547630f, -0.03299856f, -0.03076013f, 0.00280661f, -0.03286880f, 0.03306702f, 0.00176376f, 0.00247541f, 
    -0.03854893f, -0.01174815f, 0.01548172f, -0.02193796f, 0.02924830f, -0.00848890f, 0.02664718f, -0.00993798f, 
    0.03626402f, 0.03241346f, -0.01126322f, -0.01596838f, 0.02481406f, -0.00636567f, -0.01905337f, -0.00246042f, 
    -0.02242173f, -0.03310069f, 0.01369824f, 0.01331722f, -0.00210965f, -0.01000389f, 0.00773815f, 0.00625640f, 
    -0.03529168f, -0.00378067f, -0.04060983f, -0.03974475f, -0.00283717f, 0.02287021f, -0.02667546f, -0.00574335f, 
    0.00517615f, -0.01672109f, 0.01288706f, -0.04669054f, -0.01435069f, 0.02851327f, 0.01882144f, 0.00782706f, 
    0.02970351f, -0.00482375f, -0.01677915f, 0.02318175f, -0.03344437f, -0.04110292f, -0.03808499f, 0.02570386f, 
    0.01609755f, -0.02006091f, 0.01628725f, -0.02463880f, -0.04208775f, -0.01710926f, 0.01605897f, 0.02991966f, 
    0.01532758f, 0.02671877f, -0.00678248f, -0.00921616f, 0.02889272f, 0.00625046f, 0.01177381f, -0.01117550f, 
    -0.01021760f, 0.02466191f, -0.02997866f, -0.04450917f, 0.02098154f, 0.01494136f, -0.00452338f, 0.01787505f, 
    -0.03818164f, 0.03313839f, -0.03938732f, -0.00201966f, 0.01863765f, 0.00376939f, 0.03329075f, -0.03205004f, 
    -0.02608657f, -0.01876221f, -0.00636511f, 0.03556781f, 0.00762906f, -0.03647394f, -0.01301497f, -0.02671980f, 
    -0.03488499f, -0.03182749f, 0.00586512f, -0.02160323f, -0.02239894f, -0.02946560f, -0.03614692f, 0.02837726f, 
    0.01834585f, -0.01284916f, -0.02614898f, 0.00816744f, -0.00515360f, 0.03070165f, 0.00985011f, -0.03021924f, 
    0.02095815f, -0.01331962f, -0.00289207f, 0.01127624f, 0.03488357f, -0.02403325f, -0.03501906f, 0.03067004f, 
    0.00872947f, -0.04385624f, -0.01183721f, -0.04419652f, -0.04485732f, -0.03001568f, -0.02004092f, 0.00161954f, 
    -0.02790064f, -0.02743762f, 0.01580670f, -0.01700883f, 0.00675915f, 0.01490617f, 0.01046433f, -0.00958523f, 
    0.01458783f, 0.01795474f, 0.00561512f, -0.01453388f, -0.01681751f, 0.02644264f, -0.02733467f, -0.00503333f, 
    -0.00572952f, 0.00257072f, -0.03711427f, 0.02168249f, -0.00006155f, -0.04395832f, -0.01709452f, -0.04070756f, 
    0.00709963f, -0.00728020f, 0.01386943f, 0.02849754f, 0.01102438f, -0.03406462f, -0.00506593f, -0.00873959f, 
    0.01424997f, -0.00109932f, 0.00020473f, 0.02287624f, -0.04417775f, -0.01218594f, -0.00578903f, -0.02996587f, 
    -0.02306363f, -0.04008244f, -0.03974855f, -0.01814498f, -0.03708925f, 0.01744252f, -0.00950139f, -0.04563802f, 
    -0.03518954f, -0.03427854f, 0.03760910f, -0.00582574f, 0.03040173f, 0.01748286f, 0.00849461f, 0.02687935f, 
    0.00225517f, -0.03011871f, -0.02133127f, -0.02179042f, -0.03741706f, 0.00356988f, 0.01421694f, 0.02149197f, 
    -0.04595186f, 0.00705062f, 0.00862801f, -0.02412740f, -0.04481559f, -0.00948782f, -0.02086371f, 0.02203535f, 
    0.01296635f, -0.01289759f, 0.00858153f, -0.02209146f, -0.03383985f, 0.03824615f, -0.03094094f, -0.02885691f, 
    -0.00687329f, -0.02390916f, -0.03835912f, 0.02594922f, -0.01232926f, -0.02253464f, -0.00293757f, -0.00301880f, 
    -0.03851263f, 0.00900650f, -0.03583983f, -0.02367617f, 0.01496097f, -0.00254677f, 0.01853409f, 0.00151153f, 
    -0.03243694f, 0.02044346f, -0.04408015f, -0.00957665f, -0.02178508f, 0.01779175f, 0.02877812f, -0.02480872f, 
    -0.01068828f, 0.00812122f, 0.02320666f, -0.01984254f, -0.00702192f, -0.01062158f, -0.01200039f, -0.02210083f, 
    -0.00700914f, -0.00222597f, -0.02249032f, -0.00780537f, 0.01855923f, 0.03341007f, 0.02717599f, 0.00247979f, 
    -0.01761027f, -0.01157495f, 0.00593772f, 0.02756586f, 0.02213042f, -0.02549120f, 0.00953925f, -0.02089737f, 
    -0.00649845f, -0.01249130f, 0.02594750f, -0.01187748f, 0.01321105f, 0.01673395f, -0.04520121f, -0.00694466f, 
    -0.02444723f, 0.02900096f, 0.00090278f, -0.04199562f, 0.02445722f, 0.00173168f, -0.03094050f, 0.02611526f, 
    -0.00982562f, 0.01067429f, -0.01645455f, -0.02633615f, -0.00881568f, 0.00898907f, -0.02790519f, -0.02475914f, 
    -0.01493714f, -0.04203724f, -0.04126018f, 0.01115923f, 0.01175130f, -0.01387643f, -0.02350385f, -0.01554168f, 
    0.00239224f, -0.03828664f, 0.01575896f, -0.02797155f, -0.02392085f, 0.01918360f, -0.00370303f, 0.01313331f, 
    -0.01210736f, 0.01241427f, -0.00159244f, -0.04471509f, 0.00350740f, 0.00547364f, 0.04093827f, -0.01164679f, 
    -0.03125624f, -0.03116000f, 0.01483802f, -0.03386070f, -0.04419012f, -0.02510977f, 0.00989129f, 0.00963683f, 
    -0.00735951f, -0.03207856f, -0.03296351f, -0.04012100f, -0.02945484f, 0.02619424f, -0.02116794f, 0.02110026f, 
    -0.00944630f, 0.02057446f, -0.04042913f, -0.03554155f, -0.04344114f, -0.03649847f, -0.04417385f, -0.01332862f, 
    0.00965057f, 0.00684057f, 0.00406530f, 0.01026731f, 0.03641503f, -0.00118880f, -0.02684680f, -0.01789390f, 
    0.01893939f, -0.01773992f, 0.00679838f, -0.01043386f, -0.01535699f, -0.02769091f, 0.01748552f, 0.00566606f, 
    0.00182121f, -0.03326052f, -0.00932257f, -0.00124596f, -0.00980548f, 0.01820387f, 0.01106675f, -0.01913311f, 
    0.00298254f, 0.00940647f, 0.02216185f, -0.01220914f, 0.02875655f, -0.00012289f, 0.00651804f, -0.00484643f, 
    -0.01337012f, 0.02663204f, -0.00873972f, -0.04418772f, -0.03200704f, 0.01846418f, -0.02071224f, -0.03590805f, 
    0.00641017f, -0.03439704f, -0.00815343f, -0.04053938f, -0.01943590f, 0.01635323f, 0.00947010f, -0.01619884f, 
    0.00058419f, -0.00091449f, -0.04118450f, 0.00243994f, 0.03039507f, -0.02513918f, -0.04408460f, -0.02909070f, 
    0.02941949f, -0.03938896f, -0.00202012f, -0.00070107f, 0.01332463f, 0.02063219f, -0.01759978f, -0.01789612f, 
    -0.01360835f, 0.01427729f, 0.00663201f, -0.03305723f, 0.00490271f, 0.01059217f, -0.01016231f, 0.00583981f, 
    0.00240217f, 0.03060137f, 0.01313223f, -0.03036525f, 0.03075605f, -0.00147860f, -0.02575159f, -0.03247132f, 
    -0.01889135f, 0.02258170f, 0.01620594f, -0.01470816f, -0.04379826f, -0.00237009f, -0.04642180f, -0.04268361f, 
    0.00094499f, 0.01921008f, 0.02507008f, 0.02778676f, -0.00173385f, 0.01235422f, 0.01533276f, -0.01678497f, 
    -0.04637952f, 0.02564269f, -0.01512227f, -0.02897113f, -0.00127368f, 0.00010123f, -0.00003547f, -0.03100955f, 
    0.02423690f, 0.01484413f, 0.02773667f, 0.00851302f, -0.03157194f, 0.03525033f, -0.02585809f, -0.02748271f, 
    0.00095955f, 0.02949552f, 0.02753002f, 0.01764963f, 0.00985599f, -0.03115975f, 0.02930357f, 0.01281410f, 
    -0.03176843f, -0.03526396f, 0.00719439f, -0.00926451f, -0.02080526f, 0.02874335f, 0.02792525f, -0.02100045f, 
    -0.00922489f, 0.01844985f, -0.04318672f, 0.00801704f, 0.02830428f, 0.00032911f, -0.01118513f, -0.04469730f, 
    0.00185231f, -0.03031715f, -0.01426189f, 0.04155965f, -0.02294445f, -0.00596870f, 0.00071938f, 0.00641146f, 
    -0.00560515f, -0.03011221f, 0.02123334f, 0.00214235f, -0.02981704f, -0.03596979f, -0.02056649f, 0.00350826f, 
    0.03087929f, -0.02886888f, 0.02319920f, 0.00899862f, -0.00681914f, 0.00489163f, 0.02479178f, -0.04677710f, 
    0.01216859f, 0.02409803f, -0.04445439f, -0.01946143f, -0.01310057f, -0.01353817f, -0.00175809f, -0.01965245f, 
    0.02546714f, 0.00002182f, 0.01940802f, 0.01235427f, 0.02043289f, 0.02878754f, -0.02150509f, 0.00341275f, 
    0.00859888f, -0.03488227f, -0.02420796f, 0.02690749f, -0.02848582f, -0.00393719f, -0.02843349f, -0.02419882f, 
    0.02510179f, -0.00260938f, 0.00387335f, -0.01628670f, 0.00182060f, -0.03094313f, -0.02626649f, -0.00565969f, 
    -0.03997856f, -0.03854421f, 0.02921931f, 0.01949768f, -0.01456935f, -0.02428049f, 0.02373666f, -0.00247683f, 
    -0.03113032f, 0.01847819f, 0.02959880f, -0.00036969f, -0.04326372f, 0.02721650f, 0.00269498f, 0.02217412f, 
    -0.01087022f, 0.00325732f, 0.00841914f, -0.04533777f, -0.01613490f, 0.03157711f, -0.00620658f, 0.01740585f, 
    -0.02259206f, -0.02394880f, 0.00943433f, 0.01486659f, 0.00875890f, 0.00561871f, 0.03062929f, -0.04031733f, 
    -0.03541129f, -0.00602903f, -0.00563426f, 0.01669883f, 0.00167603f, 0.02269600f, -0.02116011f, -0.03542920f, 
    -0.01847130f, -0.01934846f, 0.00525711f, -0.03649291f, 0.01185545f, 0.01127586f, -0.03122081f, 0.03278046f, 
    -0.01426367f, -0.01886772f, 0.00132441f, -0.01127632f, -0.03195281f, 0.02444157f, -0.02782882f, -0.01605904f, 
    0.00681522f, 0.00709837f, 0.02489465f, 0.01770559f, -0.02775370f, 0.01443202f, -0.04395098f, -0.04149464f, 
    0.03749027f, 0.02480415f, -0.02524161f, 0.01986973f, 0.01337788f, -0.00044762f, 0.01372490f, -0.00716731f, 
    -0.00867718f, -0.02174237f, -0.01754122f, -0.03169860f, 0.01862136f, -0.01095668f, 0.00396186f, -0.01676184f, 
    0.00628608f, 0.03223878f, 0.01615373f, -0.00525827f, 0.02118368f, 0.02774617f, -0.00677548f, 0.00827188f, 
    0.01263124f, -0.02488666f, 0.01027510f, -0.02958835f, -0.03075551f, -0.02782116f, 0.01747787f, -0.02221901f, 
    -0.01491599f, 0.00610814f, -0.01673594f, -0.03271135f, 0.02687045f, -0.00952670f, -0.03992769f, -0.04422407f, 
    0.02531419f, 0.00679238f, 0.01662604f, 0.01166153f, -0.01677828f, -0.02340828f, 0.00013320f, 0.01116150f, 
    0.00830504f, 0.01103874f, -0.03988175f, 0.00936492f, -0.03092935f, 0.00682685f, 0.00436314f, -0.01767526f, 
    0.02169590f, -0.02018632f, -0.00608155f, -0.03910052f, 0.01108351f, 0.02116788f, -0.01743496f, -0.04362250f, 
    0.00150097f, -0.04256965f, -0.01372477f, 0.00956267f, -0.02031760f, -0.02572349f, -0.03783649f, -0.00586682f, 
    -0.02531636f, -0.00700985f, 0.00149134f, -0.04475962f, -0.03487097f, 0.00894914f, 0.01881915f, -0.01608448f, 
    0.01473346f, 0.02696039f, 0.01888900f, -0.01608524f, -0.02244204f, -0.01771702f, -0.03631157f, -0.02141110f, 
    0.00560018f, 0.00683192f, 0.01322628f, -0.01516929f, 0.03048774f, -0.03708159f, 0.01400530f, -0.02513764f, 
    0.02740699f, -0.01111318f, -0.00199976f, -0.04570913f, -0.03354029f, 0.00470808f, -0.01833131f, -0.01408277f, 
    -0.04268883f, -0.03822015f, 0.02596615f, 0.01282404f, -0.02114645f, -0.01303547f, -0.04483022f, 0.00417580f, 
    -0.02846014f, -0.01696717f, -0.04313471f, -0.02561127f, -0.04323765f, -0.01677059f, -0.01791196f, -0.02310245f, 
    -0.00777027f, -0.02382147f, 0.01819931f, -0.00350892f, -0.02446889f, 0.01206795f, 0.01448010f, 0.01385283f, 
    -0.01047232f, -0.03177007f, -0.01908371f, -0.02362962f, 0.01676118f, -0.02717724f, -0.00294192f, -0.02667250f, 
    -0.00773852f, 0.00034022f, 0.00295641f, -0.01494711f, 0.01044957f, -0.02789429f, -0.02656543f, 0.01248384f, 
    0.01663161f, 0.02551926f, -0.01524991f, 0.03284603f, 0.00710470f, -0.03564735f, -0.03788833f, -0.00081678f, 
    -0.02625651f, -0.04603656f, 0.00833004f, -0.04634027f, -0.00363916f, 0.00766922f, -0.04571704f, 0.01407053f, 
    -0.02894086f, -0.04073957f, -0.04635167f, -0.01192500f, 0.01754438f, 0.01365748f, 0.02567242f, 0.00264358f, 
    0.02037632f, -0.02691554f, 0.01090955f, 0.02672015f, 0.01869726f, -0.00221727f, -0.03695248f, -0.02724843f, 
    -0.03750441f, -0.01849112f, -0.04534258f, -0.02411043f, -0.04664270f, 0.00734100f, 0.00947735f, -0.04211542f, 
    -0.03432896f, -0.02485864f, 0.02338904f, -0.02687480f, -0.04070807f, -0.00437862f, 0.01667726f, 0.02275099f, 
    0.01751167f, 0.03372250f, 0.02909655f, -0.01231109f, -0.00135150f, 0.00675796f, -0.03217760f, -0.04454019f, 
    -0.00489334f, 0.02038869f, -0.02444224f, -0.01330017f, -0.02919650f, -0.02593564f, -0.03575837f, 0.00848811f, 
    0.02206839f, 0.01680256f, -0.04400642f, -0.01426655f, -0.00412642f, 0.02659488f, -0.04214985f, 0.02310899f, 
    0.00552489f, -0.02439120f, -0.01469487f, 0.01093650f, -0.03511460f, -0.03401304f, -0.04273787f, -0.03119153f, 
    -0.00245408f, -0.01478589f, 0.01007528f, -0.04779880f, -0.01393511f, 0.00468674f, -0.04734029f, 0.02473514f, 
    -0.01355585f, 0.03374207f, -0.04389463f, 0.00100440f, 0.00456823f, -0.03458659f, -0.04048107f, 0.01717024f, 
    0.02190193f, 0.00782009f, 0.03020682f, -0.02147887f, 0.03031494f, 0.00117256f, 0.00590860f, -0.00375253f, 
    0.02536974f, 0.02895181f, -0.03194133f, -0.00371624f, 0.01606307f, -0.02040818f, 0.01113468f, 0.00350041f, 
    -0.01521300f, -0.02117242f, -0.00034035f, 0.02553622f, -0.03917760f, -0.03999768f, -0.03305015f, 0.02051233f, 
    0.02921139f, -0.02312869f, 0.02417118f, -0.01302723f, -0.01929241f, 0.02787881f, -0.02822996f, -0.03029212f, 
    0.00672803f, 0.02249378f, -0.03099376f, -0.04058479f, 0.02647056f, 0.02704720f, -0.01334640f, -0.04117540f, 
    0.00460929f, -0.03360132f, -0.04522869f, 0.02172324f, -0.03350819f, -0.02452289f, 0.02261594f, 0.00271928f, 
    0.02505006f, -0.01927000f, -0.02840541f, 0.02490299f, 0.03058057f, -0.00716558f, -0.01674786f, 0.02103283f, 
    -0.04194009f, 0.01062753f, 0.01965435f, 0.01958027f, -0.04289301f, 0.00878466f, -0.02696672f, -0.00035088f, 
    0.01599287f, -0.01527049f, 0.03611575f, 0.01060130f, 0.02343257f, -0.01697986f, 0.00449151f, 0.00260573f, 
    -0.00984013f, 0.01739816f, -0.02150942f, -0.02686816f, -0.01554038f, -0.00311856f, -0.00191925f, -0.00278921f, 
    -0.04591561f, -0.02410289f, -0.03072107f, -0.02990020f, 0.00413695f, -0.01092051f, -0.00811352f, 0.02916835f, 
    -0.03340510f, -0.00964496f, 0.02263864f, 0.00753659f, -0.03412580f, 0.00398271f, -0.04838270f, 0.00148980f, 
    0.00886674f, 0.00440203f, 0.00781311f, -0.04073359f, 0.00476937f, -0.01378807f, -0.00220365f, 0.01634498f, 
    0.00537349f, -0.04418311f, 0.01877585f, -0.04340238f, -0.03951126f, 0.00742918f, 0.01918349f, 0.03077822f, 
    -0.02722419f, -0.03035094f, -0.02949618f, -0.04532776f, -0.01982122f, 0.01497708f, -0.00847358f, -0.02314021f, 
    0.00050580f, -0.04253045f, 0.00835210f, -0.03354084f, 0.00518925f, -0.00919123f, 0.00348663f, 0.00610888f, 
    -0.03983342f, -0.02322625f, 0.00232193f, -0.00043359f, -0.02676663f, -0.01315514f, -0.04306601f, -0.03370590f, 
    0.01269784f, 0.02082982f, -0.02507348f, -0.02343494f, -0.04485889f, -0.03744691f, -0.01493588f, -0.02061143f, 
    0.01821878f, 0.01223367f, -0.03904818f, 0.01605191f, -0.02690124f, 0.02911977f, 0.02127446f, -0.04002989f, 
    0.02622313f, -0.04439215f, -0.04241110f, 0.00616428f, -0.03981590f, 0.02279606f, 0.02572860f, -0.03821455f, 
    -0.02835780f, -0.01898817f, -0.01437876f, -0.03334139f, -0.01400273f, 0.00449032f, -0.02502371f, 0.03242531f, 
    -0.03544357f, -0.04290970f, 0.01812992f, -0.04217615f, -0.03993991f, -0.00341603f, -0.03586972f, -0.00021527f, 
    0.18442930f, 0.26798496f, 0.67752242f, 0.13506103f, 0.34104916f, -0.15219411f, -0.27418345f, -0.06554597f, 
    0.08145829f, -0.13011926f, -0.01500273f, -0.11820257f, -0.08289753f, -0.00964876f, 0.10787452f, -0.04835135f, 
    -0.28148028f, -0.10106859f, -0.02539200f, -0.15649813f, -0.13622917f, 0.04413247f, -0.00030229f, -0.18827564f, 
    -0.12608993f, -0.05436584f, 0.01028429f, 0.06429193f, -0.03064299f, -0.04972735f, -0.01868409f, -0.04019402f, 
    -0.03503522f, 0.03366623f, -0.06680302f, -0.08268395f, -0.12646353f, -0.26556021f, -0.12067432f, -0.14007819f, 
    0.26803169f, 0.07071695f, 0.59930289f, 0.37032714f, 0.34509963f, -0.03995048f, -0.00590376f, -0.08136032f, 
    0.30547032f, -0.05941714f, -0.02499822f, -0.01440407f, 0.07920465f, 0.10543812f, 0.20634125f, 0.04162302f, 
    0.14309691f, -0.07521985f, 0.07952566f, 0.22409461f, 0.39922965f, -0.32986081f, 0.20237558f, -0.12191924f, 
    -0.16400133f, -0.14591599f, 0.06615835f, -0.04307394f, -0.05880592f, -0.10556007f, 0.12599806f, 0.04538874f, 
    -0.08293299f, -0.04125991f, -0.12102821f, -0.05216330f, -0.16650358f, -0.13702594f, -0.09141064f, -0.35011652f, 
    -0.36565447f, 0.13096315f, 0.14134887f, 0.10955843f, -0.00524078f, -0.09555121f, 0.02026303f, -0.07308365f, 
    -0.15318182f, -0.00402937f, 0.06072820f, 0.02294536f, 0.15145999f, 0.04787613f, 0.11363056f, 0.17189670f, 
    0.23688540f, 0.06812482f, 0.10164725f, 0.16161864f, 0.27564675f, 0.38365433f, -0.10264055f, 0.08253232f, 
    0.09384219f, 0.00151808f, 0.16701499f, -0.00610757f, -0.01012040f, 0.00661042f, 0.02074344f, 0.02606327f, 
    0.18996565f, -0.06766693f, -0.06670494f, -0.03571540f, 0.15672615f, -0.23621780f, 0.03026978f, 0.18917936f, 
    -0.15349512f, 0.02491661f, 0.07272235f, 0.04401195f, -0.02611478f, -0.04611004f, 0.08658174f, 0.07015447f, 
    -0.01921895f, 0.03777975f, -0.03436883f, 0.05565048f, 0.06131567f, 0.07892664f, 0.01013440f, 0.19260144f, 
    0.27452284f, 0.11395488f, 0.01135637f, 0.12303006f, -0.14331934f, 0.03181982f, 0.09357659f, -0.01325725f, 
    -0.04637174f, -0.04591918f, -0.20070833f, 0.00884280f, 0.08972592f, -0.09754704f, -0.12867233f, 0.22834654f, 
    0.21596497f, -0.01613744f, 0.01799217f, 0.11550935f, 0.17669801f, -0.02616372f, 0.10384473f, 0.15973306f, 
    -0.15962723f, -0.20124026f, -0.14392565f, 0.08256035f, -0.01371763f, 0.23540185f, 0.12412967f, 0.03407442f, 
    0.07578695f, 0.05569047f, 0.24334440f, -0.05660716f, -0.07156651f, -0.06654277f, -0.14010207f, -0.10720461f, 
    -0.01160677f, -0.17960253f, -0.14652349f, -0.23673560f, 0.11111338f, 0.31965846f, 0.00387068f, -0.14885610f, 
    -0.10585420f, 0.07231295f, 0.06626731f, -0.28626803f, 0.03087839f, -0.15678477f, 0.14054522f, -0.00502852f, 
    0.10311981f, -0.18251239f, -0.07396562f, -0.09081503f, 0.18648611f, -0.29855058f, 0.05477445f, 0.00627238f, 
    -0.00248342f, -0.19681978f, -0.21583770f, -0.03228986f, -0.03593636f, -0.02998897f, 0.07340112f, 0.05680413f, 
    -0.00238167f, 0.14458621f, -0.05632979f, -0.03620087f, 0.01006214f, 0.09506886f, -0.02416247f, 0.07906045f, 
    0.23099615f, 0.26682508f, 0.18711059f, 0.39238963f, -0.03712518f, -0.38597846f, -0.30302855f, -0.13622257f, 
    -0.10427949f, -0.05945890f, 0.04737312f, -0.00767521f, 0.14504856f, 0.14609547f, -0.04297734f, -0.05093815f, 
    -0.00995977f, 0.04896617f, 0.04334373f, 0.14070426f, 0.25045967f, 0.29871765f, 0.11632330f, 0.28625220f, 
    -0.09762409f, 0.06431799f, -0.02092826f, -0.10695049f, -0.01458702f, -0.07337110f, -0.22817805f, 0.08801905f, 
    -0.10585604f, -0.11703422f, 0.00801105f, -0.01641243f, -0.14357936f, -0.01189596f, -0.01092685f, -0.17792866f, 
    -0.27759653f, -0.30519956f, -0.30922890f, -0.29843199f, -0.31594700f, 0.10272291f, 0.05611609f, 0.14311431f, 
    0.05249049f, 0.03063717f, 0.07085502f, 0.31302804f, -0.03283260f, -0.16617714f, 0.05551599f, 0.06984313f, 
    -0.06213298f, 0.00711034f, 0.18406984f, 0.00999063f, 0.19738318f, 0.02528257f, 0.02278602f, -0.12091980f, 
    0.91008192f, -0.04456485f, 0.07335526f, 0.27992085f, -0.04865473f, 0.12186535f, -0.08648741f, -0.01386742f, 
    -0.07721865f, -0.11018672f, -0.01990136f, 0.02316771f, 0.27460438f, 0.10009945f, 0.04639665f, 0.03883050f, 
    0.03424653f, -0.00172841f, 0.17024454f, 0.09366255f, -0.05646964f, 0.21441481f, -0.19501573f, -0.11180235f, 
    -0.05700073f, 0.04893103f, 0.14956686f, 0.01035268f, -0.20673209f, -0.12553585f, 0.06545894f, 0.07021939f, 
    -0.06878354f, -0.07822867f, 0.08280122f, -0.11096794f, -0.00897712f, -0.08566607f, -0.15812106f, -0.28748918f, 
    0.26064822f, -0.20619832f, -0.48843163f, 0.14173505f, 0.13208799f, 0.07031529f, 0.04921995f, 0.04407417f, 
    0.05368426f, 0.18078321f, 0.15618016f, -0.01793296f, -0.06398393f, -0.11026613f, -0.16968659f, -0.07089872f, 
    -0.14795379f, -0.06239160f, 0.03111508f, -0.05671952f, -0.22043295f, -0.16470921f, -0.08378971f, -0.01099775f, 
    0.06277856f, -0.08389560f, -0.14343944f, 0.11170610f, -0.06168697f, -0.04606720f, 0.00977799f, 0.02481774f, 
    -0.14993747f, -0.03566717f, 0.02455766f, -0.16877820f, -0.28261805f, -0.26543429f, -0.56461918f, -0.33317313f, 
    0.40321004f, -0.10746763f, 0.11800890f, -0.06607436f, -0.06123428f, 0.23333198f, -0.02114035f, -0.03397667f, 
    -0.04906499f, -0.04962359f, 0.20135836f, -0.04378465f, -0.10768105f, 0.09714414f, 0.19239935f, -0.00793787f, 
    0.01422315f, -0.09460838f, -0.04096138f, -0.01720922f, -0.04393454f, 0.12603034f, -0.08242810f, 0.02810893f, 
    0.06685619f, -0.04371998f, 0.19067684f, 0.06376749f, -0.04036668f, -0.13719596f, 0.03583162f, -0.05152474f, 
    -0.06168189f, 0.00572425f, 0.04567887f, -0.02911457f, 0.21788524f, -0.08717285f, -0.06289914f, 0.01688607f, 
    -0.18821333f, 0.02475009f, 0.37838510f, -0.10047859f, 0.23701912f, 0.16981439f, 0.04273429f, -0.03460072f, 
    0.00919812f, -0.10731596f, -0.11436159f, -0.13964586f, -0.09713373f, -0.05050768f, -0.03461317f, 0.17668869f, 
    -0.00117756f, 0.06501064f, -0.07329914f, -0.04741328f, 0.26834035f, -0.07381071f, -0.08762191f, 0.29280391f, 
    0.14378405f, -0.02534974f, 0.09028003f, 0.10501468f, -0.06001705f, 0.01352726f, 0.19396773f, -0.12104899f, 
    -0.15315433f, -0.05080516f, -0.14270225f, -0.15726478f, -0.28847408f, -0.05526543f, -0.12638710f, -0.33467135f, 
    -0.16614482f, -0.11796997f, 0.34768355f, -0.01580913f, 0.23227939f, 0.08102032f, 0.12115515f, 0.11427186f, 
    0.13154002f, 0.06906755f, 0.05804995f, -0.08794782f, -0.11265238f, -0.02961035f, -0.08713677f, -0.00807199f, 
    -0.09711870f, -0.01154220f, 0.00564747f, -0.05236534f, 0.03409373f, 0.00242095f, 0.09444591f, 0.03615256f, 
    -0.06929316f, 0.03491787f, 0.07586389f, 0.01371356f, 0.03689017f, 0.03345516f, 0.03215653f, 0.05778494f, 
    -0.00042677f, -0.03968348f, -0.17019893f, 0.00981968f, 0.02477404f, -0.20212299f, -0.00902180f, 0.05526773f, 
    0.07238709f, 0.01384722f, 0.38099757f, 0.17807342f, 0.33547720f, 0.01932928f, -0.13152215f, 0.04257827f, 
    0.22292952f, 0.04816338f, -0.04568391f, 0.07382512f, 0.15405905f, 0.08403329f, 0.06660346f, 0.07694482f, 
    0.05028351f, 0.01327303f, 0.17386857f, 0.22298923f, -0.40747553f, 0.16817500f, -0.21450104f, 0.05987673f, 
    -0.01081409f, -0.01823303f, -0.01329390f, 0.12204223f, -0.18994682f, -0.10545584f, 0.08596990f, 0.10134243f, 
    -0.06767134f, 0.03348799f, -0.12769297f, 0.22851981f, 0.15244313f, 0.04588645f, 0.13651712f, 0.13788390f, 
    0.30878317f, 0.03295276f, 0.18552384f, 0.17009793f, 0.12386273f, -0.06238520f, -0.03582232f, 0.06240373f, 
    0.13302313f, -0.03263593f, -0.00333158f, 0.03041988f, -0.10088927f, 0.13011955f, 0.06066364f, -0.12820038f, 
    -0.16669115f, 0.15650502f, -0.05606266f, -0.05696915f, -0.01091900f, 0.28918192f, 0.00623239f, -0.04787215f, 
    0.07242941f, -0.09098851f, -0.14888905f, 0.03965777f, -0.07872145f, -0.15269724f, 0.02687287f, 0.03482409f, 
    -0.09154372f, -0.03011012f, 0.07789699f, -0.14693449f, -0.36824584f, -0.07899696f, -0.19479488f, -0.29639679f, 
    0.19987848f, 0.37484947f, -0.25594831f, -0.00532213f, 0.09815893f, 0.05444735f, -0.00071930f, 0.09176899f, 
    -0.06700081f, -0.14142244f, 0.02910805f, 0.05496465f, 0.12174509f, 0.00257136f, -0.07180484f, -0.10760096f, 
    -0.20884126f, -0.23177211f, 0.00084547f, -0.08112326f, -0.22127536f, -0.28631076f, -0.04645266f, 0.02092746f, 
    0.27982995f, 0.02258108f, 0.20812415f, 0.18313450f, 0.02974861f, -0.05501406f, 0.01004259f, -0.15759204f, 
    -0.07525085f, -0.13332662f, 0.02324774f, 0.04659953f, 0.16353305f, 0.09517787f, 0.25071084f, 0.11390461f, 
    -0.14353374f, -0.10882530f, -0.15106630f, -0.23435618f, -0.18168645f, 0.00146258f, 0.02418766f, 0.28141946f, 
    0.17689516f, -0.01313493f, 0.03408774f, -0.12146380f, 0.17342709f, -0.05900763f, -0.04639613f, -0.03283912f, 
    -0.12161685f, -0.27669796f, -0.05218510f, 0.01779965f, 0.01859043f, -0.17579730f, -0.06699268f, -0.13470829f, 
    -0.10556182f, -0.02010752f, -0.01596461f, -0.07045477f, 0.17400810f, 0.15190697f, 0.02868980f, 0.07464950f, 
    0.04524276f, -0.12451847f, -0.09402972f, -0.01903025f, -0.09333379f, 0.01836505f, 0.05782626f, -0.05640770f, 
    0.06357937f, -0.02445125f, -0.01380887f, -0.05071957f, -0.14778532f, 0.00977630f, -0.05948293f, -0.08560805f, 
    -0.01435291f, 0.10906389f, 0.09953901f, -0.01839104f, 0.14000237f, 0.00987161f, 0.02931314f, 0.13550167f, 
    0.02151962f, -0.05545875f, -0.02044053f, -0.06027865f, 0.11627008f, 0.18830323f, 0.04370353f, -0.07971320f, 
    -0.03352652f, 0.04548094f, 0.04294173f, -0.00675546f, -0.03934613f, -0.04543902f, 0.09869431f, -0.07379085f, 
    -0.09660441f, -0.05851400f, -0.15613855f, 0.09697400f, 0.03683582f, -0.06657869f, -0.09323966f, -0.04401841f, 
    0.21959859f, -0.33073723f, 0.13504626f, -0.04429783f, -0.24298868f, -0.22672009f, -0.21970437f, -0.23137036f, 
    -0.07563654f, 0.11476550f, -0.18214934f, 0.13120730f, 0.10956250f, 0.02919900f, 0.06559660f, 0.02769581f, 
    0.04015069f, -0.06866902f, 0.02846602f, 0.07825346f, -0.10438839f, -0.05909770f, 0.22709960f, -0.07910430f, 
    -0.10344267f, -0.13756989f, -0.05674085f, -0.05967338f, -0.03723027f, 0.03391143f, 0.16147758f, 0.02807937f, 
    0.19602266f, 0.11406786f, 0.03913627f, 0.00751108f, 0.05064385f, 0.01974455f, -0.27060515f, -0.01803919f, 
    -0.01741957f, -0.06209935f, 0.21312544f, 0.11413577f, 0.15414050f, 0.19325610f, 0.12303913f, 0.03937818f, 
    0.03601451f, 0.02085064f, 0.27780181f, -0.12040745f, 0.08465938f, 0.01740038f, -0.17053162f, 0.01531044f, 
    -0.04245570f, -0.06179423f, 0.20169209f, -0.11226603f, -0.01276077f, 0.08367278f, -0.12084014f, 0.30538148f, 
    -0.17204264f, -0.03925601f, 0.07342430f, -0.10505044f, -0.13348377f, 0.20667221f, -0.11980562f, 0.03857740f, 
    0.00182442f, 0.02434960f, -0.08334529f, 0.04179319f, 0.08342227f, -0.11884349f, -0.33059323f, 0.07948585f, 
    0.37812161f, 0.13960634f, 0.13731763f, 0.02574110f, -0.10905676f, 0.02268937f, 0.05848859f, -0.02842487f, 
    -0.02754557f, -0.01691072f, 0.03033723f, 0.07243753f, 0.03246223f, 0.01802468f, -0.02654075f, 0.09823364f, 
    0.03430970f, -0.13151960f, -0.05449974f, 0.33400384f, -0.07753946f, 0.18815424f, 0.12228492f, 0.13613634f, 
    0.04203669f, 0.10311262f, 0.12002765f, 0.03781775f, 0.07820312f, -0.04568088f, 0.25768834f, -0.04182638f, 
    0.25025418f, 0.22279683f, 0.03584242f, 0.04742040f, -0.04132001f, 0.11799727f, -0.32718712f, 0.12155923f, 
    0.06593487f, 0.04035326f, -0.06134834f, 0.05791800f, 0.03995375f, 0.15969384f, 0.16759361f, -0.00320692f, 
    -0.09876842f, 0.03082322f, 0.10102477f, 0.03482062f, -0.07871005f, 0.01042060f, 0.01020515f, 0.03495133f, 
    -0.09302504f, -0.13191767f, 0.09281746f, 0.03285238f, 0.07925090f, 0.01453976f, -0.09117515f, -0.08132816f, 
    -0.06537471f, 0.06470626f, 0.04465122f, -0.09382921f, -0.07707880f, 0.04770067f, -0.07715113f, 0.10227451f, 
    0.05706939f, -0.06526645f, 0.21759872f, 0.09080327f, -0.01278364f, -0.02144033f, 0.01800204f, -0.04013640f, 
    -0.19911990f, -0.14547703f, -0.07213622f, 0.22754622f, 0.08307037f, 0.00642885f, -0.03739424f, 0.00630182f, 
    0.00919459f, 0.01106361f, -0.03211045f, -0.06703997f, -0.11190820f, 0.10813951f, 0.01193464f, 0.18303126f, 
    0.13756801f, 0.01859946f, 0.08602840f, 0.09112199f, -0.26925734f, -0.09677676f, 0.06999216f, 0.15345825f, 
    0.10810172f, -0.04533188f, -0.06088225f, -0.03823461f, 0.03596285f, 0.03849733f, -0.04270791f, 0.00937017f, 
    -0.01290634f, 0.09553341f, 0.08630943f, 0.10255311f, 0.13132316f, -0.03418264f, 0.08666734f, 0.06622151f, 
    0.08134492f, 0.08902027f, -0.02550600f, -0.09507579f, -0.10919428f, 0.10224196f, 0.05634876f, -0.05598775f, 
    0.00532289f, -0.02180879f, -0.03977353f, -0.09240101f, 0.03831711f, 0.01299011f, -0.01366500f, 0.14792179f, 
    0.05887254f, -0.04714333f, -0.03644651f, -0.05548008f, -0.09902268f, -0.10977548f, 0.14645886f, -0.12209037f, 
    0.25100350f, -0.10415424f, 0.25337976f, 0.13373294f, 0.09763176f, -0.00554797f, -0.00622672f, 0.16267228f, 
    -0.00515763f, 0.04580870f, 0.09084948f, -0.04692843f, -0.21597303f, 0.00884798f, -0.03427188f, -0.08599324f, 
    0.55420876f, -0.09057707f, -0.18802480f, 0.21141818f, -0.22855198f, 0.25478253f, -0.03785596f, -0.06904285f, 
    0.03330090f, 0.19122759f, 0.03006791f, -0.00220412f, -0.14589722f, 0.10066312f, 0.31942990f, 0.02367699f, 
    -0.05979407f, 0.02365375f, -0.10062524f, 0.05759960f, 0.07957902f, 0.03854843f, 0.02569592f, -0.04236836f, 
    0.09687932f, 0.01246090f, 0.10379250f, 0.00097102f, 0.10888016f, -0.02503202f, -0.02063611f, 0.07813265f, 
    -0.01128968f, -0.04216078f, 0.05802135f, -0.00145674f, -0.07368401f, -0.08001776f, 0.06215455f, -0.14525937f, 
    -0.39092460f, -0.24560529f, 0.10656609f, 0.51298416f, 0.13471337f, -0.05116238f, 0.01049929f, 0.12588549f, 
    -0.22473334f, 0.04408555f, 0.02276061f, 0.00418841f, 0.09314862f, -0.07821852f, 0.06127272f, 0.00468653f, 
    -0.01638328f, -0.19728509f, 0.11500408f, -0.02616667f, 0.02921675f, 0.01516015f, -0.03777448f, -0.02521751f, 
    0.03859845f, 0.12922497f, 0.03840199f, 0.02745545f, -0.04251146f, -0.08312622f, 0.03794820f, -0.05456704f, 
    0.01466511f, 0.07033697f, 0.09339040f, 0.17289150f, -0.03836124f, -0.02609430f, 0.06819963f, -0.04205294f, 
    0.33267382f, 0.18367279f, -0.05040596f, -0.00191584f, -0.08180327f, -0.03803959f, 0.14628799f, 0.18317051f, 
    -0.03500212f, -0.05197348f, 0.07270510f, 0.08244284f, 0.24160154f, -0.21940093f, -0.17657903f, 0.01585558f, 
    -0.10120413f, 0.24025416f, -0.27881801f, -0.03105062f, 0.31605202f, 0.23811495f, -0.05509345f, 0.01698838f, 
    0.17410791f, -0.00645606f, 0.07557093f, -0.06714692f, 0.06301895f, 0.01625993f, 0.03479351f, 0.05187733f, 
    0.05101820f, -0.06685200f, 0.02216165f, -0.08635798f, -0.12808752f, 0.01537427f, -0.04642604f, 0.17500597f, 
    0.41140291f, 0.24043587f, 0.14873660f, 0.16033788f, 0.17440240f, -0.04196429f, -0.00457457f, 0.07456410f, 
    -0.00932081f, 0.01145641f, 0.10620796f, 0.05818745f, 0.02493964f, 0.00197548f, -0.03124654f, -0.02945520f, 
    -0.06372469f, 0.06348862f, -0.00811488f, 0.02247285f, -0.32070440f, -0.21530806f, -0.11850154f, 0.20745461f, 
    -0.01681995f, 0.14035676f, 0.08327913f, 0.13655898f, 0.00057620f, 0.09225348f, -0.11596990f, 0.15173000f, 
    0.04044399f, 0.04585508f, 0.01560888f, 0.06781169f, -0.04686922f, -0.14763634f, -0.01163866f, 0.10892648f, 
    0.22430490f, -0.00328701f, -0.07494774f, 0.17844164f, 0.10372157f, -0.02361905f, -0.01386021f, 0.17014077f, 
    0.03803288f, 0.09601120f, 0.07124094f, 0.09164649f, 0.00769451f, -0.02250483f, 0.01070535f, -0.14788094f, 
    -0.07764238f, 0.18249696f, -0.01835469f, 0.19600892f, 0.00871016f, -0.08261538f, 0.25327185f, 0.06858435f, 
    -0.09291316f, 0.23638317f, 0.13823535f, 0.05141209f, -0.05755422f, 0.02486588f, 0.01643980f, 0.01865265f, 
    -0.07282349f, -0.00874611f, 0.06043639f, -0.00128854f, 0.15207559f, -0.10436721f, -0.03021201f, -0.18909180f, 
    0.00006414f, -0.23369612f, 0.07766517f, 0.22552383f, 0.05428810f, -0.01859874f, 0.06465878f, 0.10925431f, 
    0.02078727f, 0.01269149f, -0.03685664f, 0.10851796f, 0.04454840f, 0.01939144f, 0.09889128f, -0.06924654f, 
    -0.08277813f, 0.13884787f, 0.07066076f, -0.07604386f, 0.08801580f, 0.02690896f, 0.01663404f, 0.10132472f, 
    -0.02246066f, -0.02820760f, 0.06809881f, -0.00485707f, 0.02543767f, -0.03486596f, 0.00068055f, 0.01703924f, 
    0.08908486f, -0.03959343f, 0.09346505f, 0.04903473f, 0.02028484f, -0.09564844f, -0.07070502f, 0.20968926f, 
    0.15451582f, -0.10056570f, 0.18519139f, -0.18099314f, -0.19899662f, -0.14036952f, -0.13912611f, -0.34764874f, 
    0.17733291f, 0.07907775f, -0.01938018f, 0.12385989f, 0.01456895f, -0.08096179f, 0.00005537f, -0.02856523f, 
    -0.03941415f, -0.05743134f, -0.03192956f, -0.01025418f, -0.00100854f, 0.04998612f, -0.05954087f, -0.05223224f, 
    -0.11243370f, 0.05933582f, 0.01760100f, -0.06303457f, -0.00264176f, 0.10179929f, 0.05926130f, -0.08125515f, 
    0.14268462f, 0.00618469f, 0.04993260f, 0.09965381f, 0.03779554f, -0.06504684f, -0.04046775f, -0.05731218f, 
    0.11549079f, 0.09214133f, -0.14072908f, -0.09002692f, -0.12264594f, 0.07651645f, 0.08020819f, -0.14066517f, 
    0.02430119f, 0.00308606f, -0.00881372f, 0.12626417f, 0.21607329f, -0.12750201f, 0.11170246f, 0.02916462f, 
    -0.08586421f, -0.02733870f, -0.02049542f, -0.05150298f, 0.16912657f, 0.00405483f, -0.02870204f, 0.26852319f, 
    -0.00199639f, 0.15737925f, 0.09799448f, 0.05346514f, 0.14661281f, 0.07538300f, 0.09819522f, 0.00192856f, 
    -0.00904113f, 0.01690912f, -0.02349448f, -0.10875800f, 0.16972302f, -0.15235806f, 0.11875410f, 0.10155018f, 
    0.18712325f, 0.24783367f, -0.03752786f, -0.11155482f, -0.10258391f, 0.07242079f, 0.02217992f, -0.00646603f, 
    -0.06219642f, -0.03808797f, 0.02410775f, -0.18337065f, -0.13187687f, -0.12114199f, -0.14820635f, 0.11771995f, 
    0.04055630f, -0.04237691f, -0.07209267f, 0.00410324f, -0.10293519f, -0.09844150f, 0.16317055f, 0.32761163f, 
    0.00493954f, -0.09089262f, 0.02350114f, 0.04675886f, -0.02663663f, 0.06389101f, -0.01530724f, 0.06129005f, 
    0.04219475f, -0.03388780f, 0.03165270f, -0.00453647f, -0.01097038f, -0.06580174f, 0.12088652f, -0.16657832f, 
    0.44400427f, -0.16928382f, -0.02730758f, 0.04066068f, -0.03536320f, 0.07648143f, -0.00741002f, 0.02329148f, 
    0.06606902f, 0.13210383f, -0.01032964f, 0.03053875f, 0.13085009f, 0.12333055f, 0.07997755f, -0.02944582f, 
    0.01466435f, 0.04560795f, 0.00026004f, -0.03324768f, 0.16107967f, 0.08179397f, 0.11655234f, 0.07839594f, 
    0.10305736f, -0.03605881f, -0.00242355f, -0.00893868f, -0.03329998f, -0.05078206f, 0.08016666f, -0.06825262f, 
    -0.09438904f, -0.08211523f, -0.07724415f, 0.04867087f, 0.02062227f, -0.04488254f, 0.03701150f, -0.02526919f, 
    0.76995474f, -0.27138382f, -0.18592824f, 0.23317404f, -0.23945904f, -0.05636378f, 0.00556450f, -0.11349403f, 
    0.16105610f, -0.16402115f, 0.19983160f, -0.25392458f, 0.01420779f, -0.02337372f, 0.05548061f, 0.07502514f, 
    0.10557157f, 0.07109131f, 0.00189201f, -0.00176349f, 0.42761323f, 0.10006946f, -0.12969673f, -0.19555910f, 
    0.00668115f, 0.09576368f, 0.22948851f, -0.08811715f, 0.19947432f, -0.07618359f, 0.18523943f, 0.01347588f, 
    0.12582417f, -0.07937964f, 0.01017981f, 0.02625249f, -0.01895485f, -0.21340521f, 0.10730208f, -0.12858053f, 
    0.58410996f, -0.66396505f, 0.04027853f, -0.11399687f, 0.20793219f, -0.11563591f, -0.09666461f, 0.01901543f, 
    -0.01553677f, 0.01308567f, 0.10747392f, 0.21937552f, 0.10792170f, 0.09925909f, -0.04791189f, 0.02055341f, 
    0.03278409f, -0.03892653f, -0.17444102f, 0.08084017f, -0.22953033f, -0.11894542f, -0.00182228f, 0.22579113f, 
    -0.02099851f, -0.16935438f, 0.17665371f, 0.05048354f, 0.16620189f, -0.13991120f, 0.06968302f, 0.00511055f, 
    -0.05283527f, 0.03652274f, 0.08305442f, 0.01305932f, 0.06434419f, 0.21083514f, -0.02894030f, 0.00682992f, 
    0.06106247f, 0.13565831f, -0.17481734f, 0.19666004f, 0.26015702f, -0.01767437f, -0.00240393f, 0.04546157f, 
    0.01260255f, 0.04226676f, 0.06391502f, 0.10390310f, -0.03355484f, 0.08014464f, 0.06568875f, 0.01759133f, 
    0.07904676f, 0.14183900f, 0.19832781f, -0.01962085f, -0.27573687f, -0.12001234f, 0.00589829f, -0.30968243f, 
    -0.11407842f, -0.03924705f, 0.07848201f, -0.02443964f, -0.09984586f, 0.09688503f, 0.05503713f, 0.17631471f, 
    -0.03299919f, 0.01169585f, -0.02197334f, 0.09879437f, 0.24036188f, -0.09314299f, 0.23043130f, 0.21739216f, 
    -0.15904059f, 0.02880801f, -0.05656355f, -0.01844050f, -0.08067248f, 0.10450569f, 0.10208695f, 0.03412821f, 
    -0.07788245f, -0.00094616f, 0.15425120f, -0.04685450f, 0.01986899f, -0.04087795f, -0.03841090f, -0.11759062f, 
    -0.13453031f, -0.11152308f, -0.06402902f, -0.13071758f, 0.28085700f, 0.07454535f, -0.13962092f, 0.09556164f, 
    0.06116010f, -0.12290549f, -0.03889340f, 0.00984230f, 0.01176030f, -0.10461283f, -0.10205528f, -0.05721027f, 
    -0.02329336f, -0.13318039f, -0.03902500f, 0.02918759f, 0.02665210f, 0.08413925f, -0.18624118f, -0.08140542f, 
    0.13655630f, 0.12016582f, 0.20198233f, -0.01534040f, -0.20779511f, 0.14712904f, -0.00467080f, 0.02503306f, 
    0.09118986f, 0.23551494f, -0.00448359f, -0.04487195f, -0.03088801f, -0.12331118f, -0.09179562f, -0.11133464f, 
    0.11527333f, 0.13042451f, 0.03156961f, 0.28757474f, 0.19207272f, 0.11247097f, 0.31944504f, 0.02824384f, 
    -0.17879893f, 0.12580276f, 0.12206027f, 0.06850920f, 0.12437245f, 0.23081671f, 0.00672273f, -0.06080385f, 
    -0.04868498f, -0.18657795f, -0.08826522f, -0.13130003f, 0.01153604f, 0.02680979f, -0.03072838f, 0.21808781f, 
    0.07928512f, -0.00403231f, 0.06788898f, 0.07709667f, 0.09210372f, 0.00268604f, 0.04056210f, -0.02093278f, 
    0.04272199f, -0.03697782f, -0.00789806f, -0.12571184f, -0.10678589f, 0.05601133f, -0.08002535f, 0.00105726f, 
    -0.06792722f, -0.02358043f, -0.03135704f, 0.01028399f, 0.54196429f, -0.36701992f, 0.51465416f, -0.29239622f, 
    -0.04855569f, 0.18284249f, 0.07814637f, 0.17796224f, -0.20337577f, -0.01158010f, -0.06909394f, -0.03543961f, 
    0.20970726f, -0.07584058f, -0.15713121f, -0.10091637f, 0.27589554f, -0.07829821f, -0.07207761f, 0.01699784f, 
    -0.45827371f, -0.06503347f, -0.01585924f, 0.13278598f, -0.37338662f, -0.00693567f, -0.02085713f, -0.02413179f, 
    -0.06571596f, -0.10849205f, 0.16315804f, -0.06216070f, 0.02774048f, -0.02161071f, 0.07428636f, 0.10575596f, 
    0.02375617f, 0.02220975f, -0.24047065f, -0.05815534f, 0.09973455f, -0.09921522f, 0.09721550f, -0.01048272f, 
    0.19598316f, -0.02873380f, 0.10518786f, -0.00988213f, -0.18999448f, -0.09748128f, 0.08344833f, 0.05204021f, 
    0.19794744f, -0.02614766f, -0.15611778f, -0.18223551f, 0.13787808f, 0.07175878f, -0.14038527f, -0.04916773f, 
    0.33307597f, 0.44054139f, 0.13041951f, 0.34352988f, -0.21493278f, -0.01636604f, -0.01919688f, -0.02530817f, 
    0.08568985f, 0.22210371f, 0.03450516f, -0.01992737f, 0.04977420f, -0.00569181f, -0.05926648f, -0.07501924f, 
    -0.08739641f, -0.06454666f, -0.22742231f, -0.04735778f, -0.00630183f, -0.03705663f, 0.07111000f, -0.03557709f, 
    0.06884374f, 0.09149113f, 0.06123727f, -0.01895277f, -0.02363693f, 0.08524784f, 0.00816672f, -0.08287081f, 
    0.10936233f, 0.15716977f, -0.01264138f, -0.02108044f, -0.02438949f, -0.10121584f, -0.10187598f, -0.03493724f, 
    -0.04686478f, 0.18839681f, -0.35242137f, -0.03157377f, -0.18132149f, -0.14320652f, 0.12708387f, -0.04906499f, 
    -0.07450967f, 0.09960863f, -0.20444801f, 0.13678470f, 0.00401954f, -0.04994359f, -0.05076487f, -0.13026612f, 
    0.08589978f, -0.20911543f, -0.05235584f, 0.03286698f, -0.08538560f, 0.09737469f, -0.07774938f, 0.08762573f, 
    0.01054417f, 0.03272677f, -0.00367916f, -0.05141360f, -0.02864316f, -0.03344161f, 0.10116407f, -0.02781534f, 
    0.00539599f, 0.02150243f, 0.07263160f, -0.06611931f, 0.15859950f, 0.21813682f, -0.00951912f, 0.03324690f, 
    -0.02092776f, 0.23416904f, -0.04091752f, -0.06275122f, 0.03236816f, 0.11163065f, -0.18674183f, -0.09787384f, 
    0.01432684f, 0.09104335f, -0.02225428f, -0.00030163f, 0.08320223f, 0.03394812f, -0.03230608f, 0.00245964f, 
    -0.07737041f, -0.03101350f, 0.12206040f, -0.07638396f, -0.02920669f, 0.19689502f, -0.10999404f, 0.21475181f, 
    -0.24583270f, 0.10053492f, -0.03522111f, 0.04550553f, 0.05302877f, 0.22560306f, -0.06886388f, -0.03366498f, 
    0.08771085f, -0.08832252f, -0.02721565f, -0.01700298f, -0.04762243f, -0.00894809f, -0.25347146f, -0.18164234f, 
    -0.11510226f, 0.26267704f, -0.11879406f, 0.01654756f, -0.24358684f, 0.20875101f, -0.21508066f, -0.44727409f, 
    -0.00829571f, 0.08508340f, 0.07303186f, 0.02422836f, 0.10841365f, -0.00340970f, -0.06534746f, 0.08274585f, 
    -0.04205748f, -0.17621820f, 0.08261297f, -0.09896245f, 0.17253792f, -0.04942036f, -0.08971911f, -0.13847725f, 
    0.17086959f, -0.05444372f, 0.08737639f, -0.06038720f, 0.06014919f, -0.10596166f, -0.04514696f, 0.11614449f, 
    -0.05246735f, -0.01482429f, -0.00192124f, 0.01604827f, -0.11498965f, -0.04024327f, -0.07527764f, -0.05676068f, 
    0.46316683f, -0.19001986f, 0.01150751f, -0.04868327f, -0.37204903f, 0.07892169f, -0.01584402f, 0.05470575f, 
    0.17918317f, 0.05991268f, 0.07448345f, -0.13278916f, -0.13958859f, 0.10053444f, -0.04083380f, -0.03347856f, 
    0.07613732f, -0.01550507f, -0.07274732f, 0.00877591f, 0.01486409f, 0.01994999f, -0.07669907f, 0.09097757f, 
    0.12508720f, 0.03815669f, 0.01367123f, -0.06632551f, -0.04659475f, 0.07735886f, 0.08877477f, -0.02697119f, 
    0.03723799f, 0.02020514f, 0.07896365f, 0.07933141f, 0.10963942f, 0.22942938f, 0.05673494f, 0.14171942f, 
    0.40645802f, -0.25456095f, -0.10701561f, -0.00458741f, -0.07755731f, -0.05873002f, 0.12695488f, 0.07934374f, 
    0.00800692f, -0.19253486f, -0.03592591f, -0.18820579f, 0.12567213f, -0.00926192f, -0.03511549f, -0.01284137f, 
    0.02851587f, 0.04633988f, 0.01343016f, 0.01873779f, 0.20007333f, -0.06437970f, -0.03001871f, 0.01738743f, 
    -0.00418741f, 0.06089976f, -0.01246985f, 0.09447851f, -0.08214942f, 0.17300965f, -0.03987541f, 0.04483431f, 
    0.16549496f, 0.03592503f, 0.01512180f, -0.05490121f, -0.11441896f, 0.01767507f, -0.03831233f, -0.02108941f, 
    0.10956795f, 0.08070848f, 0.00770187f, 0.17097543f, 0.04909774f, -0.04402512f, -0.07381187f, 0.08775698f, 
    0.04319100f, 0.01129397f, -0.14035903f, -0.09840862f, 0.18600582f, -0.02588104f, -0.10924283f, -0.11594018f, 
    -0.22667323f, 0.05831625f, -0.05352828f, -0.09205655f, -0.23711383f, 0.36901301f, -0.01345119f, 0.13829574f, 
    -0.38885036f, 0.14391887f, -0.10290521f, -0.04964512f, -0.12305602f, 0.33748055f, -0.04544911f, -0.03932479f, 
    -0.01176828f, 0.00024555f, -0.00558166f, -0.09251089f, 0.12231039f, 0.01471399f, -0.01896765f, 0.11057854f, 
    0.14703989f, 0.21928263f, 0.06154691f, 0.16781859f, -0.00461000f, -0.01207080f, -0.03977653f, 0.03960082f, 
    0.06649697f, -0.00937501f, 0.12155465f, -0.13144177f, -0.03751684f, -0.10258218f, -0.11435223f, 0.00476654f, 
    -0.01965077f, -0.00784362f, 0.04395798f, 0.05418008f, 0.42410961f, 0.34333304f, 0.29874942f, 0.06244977f, 
    -0.04171346f, 0.12803151f, -0.00827393f, -0.01935610f, 0.10117472f, 0.23340204f, -0.02100960f, -0.02176959f, 
    -0.01154516f, 0.01150016f, 0.00540800f, -0.01984659f, 0.00801922f, -0.06720056f, -0.27132526f, -0.02761989f, 
    -0.24789034f, 0.04526695f, 0.14026189f, 0.15808606f, 0.17739624f, -0.03714820f, -0.05173961f, -0.07370941f, 
    -0.09076371f, 0.22835577f, -0.01410289f, -0.05692988f, -0.11668595f, -0.04017144f, 0.02376459f, 0.03215071f, 
    0.00336662f, -0.07115285f, -0.12918377f, -0.08792029f, -0.33472121f, 0.03039970f, -0.07431713f, -0.04302909f, 
    -0.09617350f, 0.01970680f, 0.04890312f, 0.03860239f, 0.02841056f, 0.02943604f, 0.03798890f, 0.05693439f, 
    0.07871628f, 0.10844228f, 0.02403628f, 0.03991723f, 0.02583795f, -0.08490171f, -0.16174568f, 0.01299626f, 
    -0.18094443f, 0.24925236f, -0.30876046f, 0.08937456f, -0.02659145f, 0.01563557f, 0.12515567f, -0.02827447f, 
    -0.07863586f, 0.25697744f, -0.12320300f, -0.12071732f, 0.03922176f, 0.11153026f, 0.07927087f, -0.04859202f, 
    0.08033760f, 0.02863165f, 0.02022694f, -0.01452115f, -0.17434253f, 0.05511413f, -0.20831709f, -0.09842033f, 
    -0.00575478f, -0.11538168f, 0.09878349f, -0.08155061f, -0.03621568f, 0.21646725f, 0.05106265f, 0.01813899f, 
    -0.18266048f, -0.00913679f, -0.05383878f, -0.02528089f, -0.03958521f, 0.14209698f, -0.07884528f, -0.16969003f, 
    -0.56585652f, 0.26549134f, -0.11897492f, 0.27106053f, -0.13001555f, 0.06415009f, -0.04421246f, 0.05293201f, 
    -0.05780866f, 0.08206895f, 0.02237507f, -0.14062886f, 0.06176733f, 0.14548591f, -0.01746950f, 0.06559332f, 
    0.05987977f, 0.10186898f, -0.06765024f, 0.09723359f, 0.21124355f, 0.22456746f, -0.07267480f, -0.10792194f, 
    -0.00745292f, 0.01334472f, 0.16772966f, 0.08256607f, -0.17483948f, -0.07213504f, 0.09217079f, -0.01414385f, 
    0.21682057f, -0.07166095f, 0.08661295f, 0.11832932f, 0.09530915f, -0.08621182f, 0.14933258f, 0.24892054f, 
    -0.11930725f, 0.01813654f, 0.06091802f, -0.02934925f, -0.06064617f, -0.05357692f, -0.02432688f, 0.06412818f, 
    0.04438074f, 0.00641197f, -0.01719802f, -0.03544189f, 0.03680657f, -0.12089801f, -0.02556600f, 0.07692865f, 
    0.13402671f, 0.01689989f, -0.10471179f, 0.10310739f, -0.54337817f, -0.06270264f, -0.19348559f, 0.18133694f, 
    0.15806438f, -0.10791402f, 0.06482607f, -0.12010942f, 0.14886460f, -0.01009878f, -0.18235454f, 0.10407177f, 
    0.19562912f, -0.00820242f, 0.05852757f, -0.04664597f, 0.24923596f, -0.07738053f, 0.07084213f, 0.10495759f, 
    0.23557994f, 0.12438423f, 0.04101467f, -0.00201796f, -0.07462148f, 0.21633846f, 0.14757237f, 0.04041189f, 
    0.02432659f, -0.09539784f, 0.01162142f, -0.01060506f, 0.01008429f, -0.06383527f, -0.00776523f, -0.03535732f, 
    0.14475267f, -0.03655776f, 0.02153716f, -0.08111382f, -0.40381891f, -0.03753804f, -0.07587775f, 0.10100575f, 
    -0.06894507f, 0.00862550f, 0.03881251f, -0.03569194f, -0.10168787f, -0.10051481f, 0.11474811f, 0.01796345f, 
    0.01473018f, -0.04763245f, 0.05190273f, 0.01593422f, 0.08735871f, -0.12021156f, -0.01375214f, 0.04910878f, 
    0.20800216f, 0.03395081f, -0.17575276f, -0.19984932f, 0.10689821f, -0.02045679f, 0.03284048f, 0.11546578f, 
    -0.17362952f, 0.06228367f, 0.04092328f, 0.00550924f, 0.04927329f, 0.04419809f, 0.00151410f, 0.13437361f, 
    0.16763473f, 0.25720382f, 0.16301945f, 0.14054534f, 0.17099544f, -0.07692643f, -0.24271458f, -0.23824331f, 
    0.18960397f, -0.06365543f, 0.04730409f, 0.04444915f, -0.07797153f, 0.04615752f, -0.04239596f, -0.01575325f, 
    0.01922594f, 0.07384901f, 0.08031536f, 0.10733220f, 0.01597428f, 0.21379252f, 0.08762959f, 0.13204013f, 
    -0.19437237f, 0.00010446f, 0.07370469f, 0.02090823f, -0.04064371f, -0.01297788f, -0.05396305f, -0.04971194f, 
    -0.04752307f, -0.03144301f, 0.06674647f, 0.06951934f, -0.01539170f, -0.03633236f, -0.01105881f, 0.08314125f, 
    0.02871885f, -0.10598337f, -0.08579162f, -0.08484258f, -0.32701045f, -0.08945189f, -0.18592115f, 0.03388643f, 
    0.17439738f, 0.08252444f, 0.06069160f, -0.00956382f, 0.01086663f, 0.00432932f, -0.04151697f, -0.05975640f, 
    -0.08060175f, 0.24367280f, 0.11943887f, 0.09104326f, 0.04996743f, 0.20293824f, -0.13820736f, -0.08189780f, 
    0.51146233f, -0.19380477f, -0.13371302f, -0.00642611f, -0.01053537f, 0.20939735f, 0.14331676f, -0.09415694f, 
    0.04533540f, 0.03084632f, 0.14844988f, 0.13692005f, 0.21993716f, 0.11068940f, 0.04222619f, 0.05058962f, 
    -0.05707695f, -0.10235274f, 0.05100729f, 0.00518736f, -0.08374427f, -0.06423490f, -0.01323931f, -0.10855383f, 
    -0.15357175f, 0.14982633f, -0.01614570f, 0.02909683f, -0.04047869f, 0.01174491f, 0.13179350f, -0.10137966f, 
    -0.14261192f, 0.12335414f, 0.16533582f, 0.06215203f, -0.06190585f, -0.06368320f, -0.18613425f, -0.17212516f, 
    0.38015303f, 0.19902413f, -0.25128928f, -0.08612894f, 0.28635764f, 0.00864484f, -0.05408518f, 0.08327464f, 
    0.00354977f, 0.11099501f, 0.13554722f, -0.04260323f, 0.01617991f, -0.04979261f, -0.00131632f, 0.00451058f, 
    -0.01857010f, 0.07292832f, 0.20428787f, 0.04677054f, 0.01679886f, -0.01540680f, 0.01196996f, 0.04380297f, 
    -0.02524353f, 0.02708011f, -0.04463481f, 0.00075540f, -0.07742087f, -0.07477130f, 0.10720321f, 0.14142291f, 
    -0.03287501f, -0.13917150f, 0.09939136f, 0.07320024f, 0.04238664f, -0.11443727f, -0.16738819f, -0.09031056f, 
    -0.39608869f, 0.07248019f, -0.10537583f, 0.06854449f, 0.15660371f, -0.01369171f, 0.11521529f, -0.25604448f, 
    0.02718999f, 0.16554035f, 0.04716484f, 0.09438509f, -0.01551661f, 0.05233747f, 0.13145857f, 0.09869292f, 
    0.22238387f, -0.01552321f, -0.16252597f, -0.00983926f, 0.17420971f, 0.25632614f, -0.07837864f, -0.03806274f, 
    0.00704152f, -0.06310667f, 0.09883986f, 0.05933533f, 0.08058194f, -0.16173294f, -0.01490410f, -0.10421938f, 
    0.01924093f, -0.06883491f, -0.01200936f, 0.02989358f, 0.11966682f, -0.16040729f, -0.05844026f, -0.03854084f, 
    -0.04609366f, -0.05514907f, 0.22788940f, 0.11354630f, -0.04799234f, -0.03878875f, 0.11458110f, 0.12880112f, 
    0.06223199f, 0.08115379f, -0.02752335f, 0.01562541f, -0.05678955f, 0.01998017f, -0.00697599f, -0.02259511f, 
    0.14018498f, 0.12165205f, -0.19517198f, 0.01101334f, 0.37554026f, 0.24033980f, -0.10156070f, -0.10581813f, 
    0.13323930f, 0.03379486f, -0.02627439f, 0.00210434f, -0.00440858f, -0.05175634f, -0.04402310f, 0.06631396f, 
    -0.02401014f, -0.02352534f, -0.01070228f, -0.03233664f, -0.06930808f, -0.04121518f, 0.05956341f, -0.00018818f, 
    0.17181024f, 0.16110143f, 0.17268749f, 0.10868867f, 0.10522191f, 0.04455508f, 0.17329085f, 0.18593296f, 
    0.15928285f, 0.01138490f, 0.01185825f, 0.01216648f, -0.05768298f, 0.06245015f, 0.07995173f, -0.08832271f, 
    0.03419445f, 0.13555485f, -0.03403420f, -0.02282084f, -0.15771605f, 0.18423706f, -0.22838032f, 0.14073193f, 
    -0.02809360f, -0.07760566f, 0.12538424f, 0.02062429f, -0.12327116f, 0.06043027f, -0.15654135f, 0.09942900f, 
    -0.14355995f, 0.03475312f, -0.10709985f, 0.17689060f, 0.06683084f, 0.06696050f, -0.03875683f, 0.04967565f, 
    -0.15643010f, -0.02004832f, -0.26113617f, 0.11592374f, 0.08066865f, 0.19849321f, 0.20923978f, 0.03908212f, 
    -0.16449562f, 0.07265474f, -0.12053131f, -0.09493884f, 0.07639772f, 0.12784319f, 0.06953812f, -0.00480745f, 
    0.02973092f, -0.01733394f, -0.07114263f, 0.01636415f, -0.15621394f, 0.13095674f, 0.09290893f, -0.27597952f, 
    0.00983247f, 0.08389121f, 0.01160247f, 0.02819917f, 0.09293064f, -0.09233877f, 0.07089449f, -0.07106102f, 
    -0.03585475f, -0.00342297f, -0.14847323f, 0.02916740f, 0.02619815f, -0.02002629f, -0.00329348f, 0.02319234f, 
    0.03729235f, 0.04728667f, -0.25077277f, -0.00895310f, 0.26483861f, 0.01142138f, 0.01074859f, -0.03492273f, 
    -0.06930960f, 0.10364556f, -0.08433228f, -0.08997914f, -0.13786638f, 0.06592900f, 0.05436567f, -0.03155292f, 
    0.00955070f, 0.07581630f, -0.08584476f, -0.10365071f, -0.07210481f, 0.01377813f, 0.11462784f, 0.04334611f, 
    0.04458929f, 0.04533047f, -0.05938303f, 0.00221436f, -0.00894861f, -0.02329153f, 0.04209497f, -0.00244946f, 
    -0.15147963f, -0.06279752f, 0.02700527f, 0.05963745f, -0.05746237f, -0.10868413f, -0.08414251f, -0.12120720f, 
    -0.31732228f, 0.06233168f, -0.02078991f, -0.09738442f, 0.04912183f, 0.01173331f, 0.09999003f, 0.00944259f, 
    -0.06142710f, -0.06976949f, 0.02593987f, 0.01202100f, 0.08270930f, -0.04993032f, 0.01597245f, 0.00464113f, 
    -0.00675802f, -0.20221683f, -0.00476496f, 0.02664200f, 0.40572032f, 0.12102091f, 0.13581665f, -0.04163230f, 
    0.44862512f, -0.01285767f, 0.06415774f, -0.02850444f, 0.24967803f, -0.10288464f, 0.04639142f, -0.03034786f, 
    0.05471932f, -0.03937667f, 0.02286210f, -0.03855326f, 0.08833567f, 0.07781453f, 0.16115735f, -0.09975974f, 
    -0.28431788f, -0.05574768f, 0.05296550f, -0.13615286f, -0.11596024f, 0.01727733f, 0.04247527f, -0.01456329f, 
    0.13076417f, 0.09571867f, -0.04662827f, 0.06982188f, 0.16297196f, 0.02575022f, -0.02821617f, -0.01114575f, 
    -0.04267439f, -0.07699100f, -0.13750027f, 0.00730368f, 0.11879192f, -0.09099776f, -0.03683629f, -0.06578873f, 
    0.20517391f, 0.04866885f, -0.10888614f, 0.01449378f, 0.08761747f, 0.26335377f, -0.01605842f, -0.00268318f, 
    -0.04717385f, -0.11004261f, -0.05449195f, -0.02039040f, -0.03297249f, 0.05201202f, 0.08299183f, -0.05626618f, 
    -0.03838441f, 0.02329092f, -0.02747428f, -0.03410364f, -0.03676686f, -0.00677170f, 0.01525987f, 0.00265001f, 
    0.01766501f, -0.03496733f, 0.00929935f, -0.01134451f, 0.00035557f, 0.02697197f, -0.02620637f, -0.03644910f, 
    0.02488788f, -0.00916749f, -0.01051833f, 0.02375828f, 0.00481488f, -0.03441019f, -0.01014458f, -0.01595280f, 
    0.03274165f, -0.02065304f, -0.01194243f, 0.00301028f, 0.02653673f, -0.02574196f, 0.02017474f, 0.00443052f, 
    -0.04536841f, 0.03001465f, 0.00844860f, -0.01918676f, 0.02783526f, -0.03842007f, -0.02484361f, 0.02780833f, 
    0.00688332f, -0.04297330f, 0.03364706f, -0.02655450f, -0.03328754f, -0.00367019f, 0.02600520f, 0.00033312f, 
    -0.02760719f, -0.00570167f, -0.04430953f, 0.01651078f, 0.02063304f, 0.02774478f, -0.02625737f, 0.01289201f, 
    -0.00325020f, -0.03452253f, -0.03599433f, 0.02520734f, 0.01957386f, 0.00391980f, -0.02075460f, 0.01416865f, 
    0.03107248f, -0.03294638f, 0.02362287f, 0.00642422f, 0.02472058f, 0.00127083f, -0.03561524f, -0.01874281f, 
    -0.02333663f, -0.03560352f, -0.01443472f, 0.00033283f, 0.02068368f, -0.03224428f, 0.00399499f, 0.01772606f, 
    -0.01234181f, -0.01461870f, 0.01980329f, -0.00140261f, 0.01042990f, -0.02220719f, 0.03195256f, -0.04228942f, 
    -0.03289614f, -0.02131783f, -0.02576469f, -0.03058807f, 0.01820602f, -0.00389756f, 0.02706314f, 0.02080294f, 
    -0.02295033f, 0.00482885f, -0.03816013f, 0.02447958f, -0.04506894f, 0.03600109f, -0.03579966f, -0.04432194f, 
    -0.03577095f, 0.02413499f, -0.03981213f, 0.00789729f, 0.00457519f, 0.00546684f, 0.01973729f, -0.02636146f, 
    -0.02431069f, 0.02690344f, -0.03340495f, -0.00586982f, -0.01017637f, -0.04031380f, 0.02763972f, 0.02932224f, 
    0.02357416f, 0.00897167f, 0.01668419f, -0.03211421f, -0.03350991f, 0.01818060f, -0.02807668f, 0.03095782f, 
    -0.02143930f, -0.02427916f, -0.03582864f, 0.02428759f, 0.02661213f, -0.02816607f, 0.02477647f, -0.01170180f, 
    -0.03185649f, -0.02378753f, -0.03315923f, -0.02205794f, -0.02877055f, -0.03112981f, -0.02821887f, 0.00266715f, 
    -0.02293176f, 0.00442800f, -0.04607455f, -0.02741160f, -0.03780322f, 0.02707796f, -0.02092901f, -0.00983370f, 
    0.02515054f, 0.03098420f, 0.01897613f, 0.02460775f, 0.02543572f, -0.01151073f, -0.00851633f, 0.02701020f, 
    0.02017317f, 0.01022759f, -0.00691940f, 0.00923304f, -0.02760087f, -0.00815787f, -0.02733714f, 0.02584796f, 
    0.00283941f, 0.00107045f, 0.03036107f, -0.03312650f, -0.00169754f, 0.00799582f, 0.02279811f, 0.01182147f, 
    0.01071553f, 0.00228267f, -0.00140562f, -0.03358399f, -0.02888262f, 0.00728927f, -0.02620736f, -0.01684342f, 
    0.02363220f, -0.04480392f, -0.01447668f, 0.00040996f, -0.03799792f, -0.00131417f, -0.02212322f, 0.00385378f, 
    -0.03256205f, 0.00156035f, -0.03584350f, 0.00777438f, -0.01092651f, -0.01224956f, -0.03559310f, 0.00356055f, 
    -0.00187285f, 0.00036709f, -0.01481358f, -0.04705399f, -0.01802546f, 0.00724100f, 0.00238608f, -0.03154694f, 
    0.02965682f, 0.01963403f, 0.02216440f, 0.01668505f, -0.03816577f, -0.02897923f, -0.03829183f, -0.03657107f, 
    -0.00998315f, 0.00630715f, -0.03293469f, 0.02883810f, 0.02988972f, 0.00359817f, 0.02232196f, -0.03789240f, 
    0.02248305f, 0.02681142f, 0.02364795f, 0.02612371f, -0.04076338f, -0.00511821f, -0.01037232f, -0.00308997f, 
    -0.03150835f, -0.04250488f, 0.01354019f, -0.03721407f, 0.01666313f, -0.02672476f, 0.01089161f, -0.03575006f, 
    -0.00676930f, -0.02815500f, -0.00302731f, -0.04203801f, 0.02012011f, -0.04407714f, 0.01421578f, 0.01180066f, 
    -0.02156368f, -0.01198911f, 0.02564944f, 0.02376948f, -0.02474282f, 0.00314744f, -0.02983566f, 0.01803656f, 
    0.00113510f, -0.01075805f, 0.00831807f, 0.00014853f, 0.02925303f, 0.00916595f, 0.01846574f, -0.00133596f, 
    0.02597342f, -0.01169448f, -0.02534679f, -0.04104394f, -0.04330464f, -0.02531795f, 0.01879223f, -0.00535495f, 
    -0.01251890f, -0.01822963f, 0.02199757f, -0.03460921f, 0.00685177f, -0.04453875f, 0.02785523f, -0.01225786f, 
    -0.01683860f, -0.00585475f, 0.02978405f, -0.01213103f, 0.02291054f, -0.03609554f, -0.03297554f, -0.02666749f, 
    -0.02443282f, -0.01945041f, 0.01565658f, 0.01695666f, -0.01166822f, 0.02150523f, 0.01693061f, -0.03028391f, 
    -0.00999752f, -0.04248885f, -0.03084348f, 0.01013655f, 0.00485333f, -0.04432457f, -0.04412486f, 0.02385813f, 
    0.02870416f, 0.02157445f, -0.02827800f, -0.02716647f, 0.00002397f, 0.03167301f, -0.03073667f, -0.02000052f, 
    -0.03472292f, -0.02297501f, 0.00989199f, 0.01679645f, 0.00936447f, -0.04750183f, -0.04179282f, -0.03957099f, 
    -0.03947164f, -0.00576419f, -0.03635085f, -0.01156066f, -0.04579185f, 0.02293969f, -0.01774601f, -0.02494819f, 
    0.01378470f, -0.04495260f, -0.02637202f, -0.02725111f, -0.04102110f, 0.02165385f, 0.00012971f, -0.00274601f, 
    0.02605807f, 0.00243193f, 0.02985057f, 0.02904032f, -0.03410822f, 0.02431682f, -0.03051452f, -0.00292425f, 
    -0.01685407f, -0.03183027f, -0.03166208f, -0.00109792f, -0.02792026f, -0.03500651f, -0.02351179f, 0.00593012f, 
    0.00149365f, -0.01151569f, -0.03105991f, -0.01235002f, -0.02879985f, -0.04325563f, 0.02020369f, 0.01296609f, 
    -0.02846549f, -0.00923281f, 0.00882164f, -0.00534155f, -0.01524899f, -0.04612504f, -0.00946969f, 0.01539913f, 
    -0.02437733f, -0.01212989f, 0.00088500f, -0.04295298f, -0.02509320f, 0.01514923f, 0.01413916f, -0.04627146f, 
    -0.00195823f, -0.00865615f, 0.00569561f, -0.04627614f, 0.03314951f, 0.00617593f, -0.03475446f, 0.00258219f, 
    0.01374457f, 0.02884903f, 0.01281069f, 0.02378910f, -0.01203072f, -0.02585674f, -0.00290498f, 0.00298100f, 
    0.01105502f, 0.02535849f, -0.02627051f, -0.00089104f, -0.01260093f, 0.00112021f, -0.02838920f, 0.02297494f, 
    -0.03609377f, 0.01350851f, -0.00679297f, 0.00971950f, 0.00195755f, -0.04618420f, 0.03162855f, 0.01835471f, 
    0.02910259f, -0.03111806f, 0.02540823f, 0.02282139f, 0.00468293f, 0.00585607f, 0.01790889f, -0.03183253f, 
    0.00462256f, -0.02862030f, -0.03454959f, -0.03724627f, -0.03867218f, 0.01113005f, 0.01806410f, 0.01873840f, 
    0.00750503f, 0.01130877f, -0.03040087f, -0.03571343f, -0.04682388f, 0.02814165f, -0.04634553f, -0.01633942f, 
    -0.04207541f, -0.01775958f, -0.00673176f, 0.00977817f, 0.03061887f, 0.00885472f, 0.01347245f, -0.00761178f, 
    -0.00704365f, -0.04322067f, 0.02802408f, -0.03487581f, 0.02413483f, -0.00610053f, -0.01654418f, 0.00303395f, 
    -0.00420098f, -0.03846466f, 0.00437313f, 0.01798882f, -0.02019786f, 0.02997147f, -0.02984105f, 0.00900690f, 
    -0.01633615f, 0.00744314f, -0.03266418f, 0.00217766f, 0.01393669f, 0.02598370f, 0.01347775f, 0.00094517f, 
    -0.02166285f, -0.00169125f, 0.00406799f, 0.00577089f, 0.00259312f, -0.02153276f, -0.03868455f, 0.01138693f, 
    0.00196099f, -0.03038283f, -0.02057597f, -0.04032791f, -0.00104091f, -0.02165748f, -0.01777798f, -0.03396722f, 
    0.01436440f, -0.00858371f, -0.02766713f, -0.01473400f, 0.02832856f, -0.01592583f, 0.00568394f, -0.01470020f, 
    -0.04232663f, 0.02284277f, -0.02324247f, 0.01277990f, 0.00205936f, -0.04040890f, -0.01488561f, -0.00515315f, 
    -0.01477280f, 0.00337231f, 0.01258627f, -0.03405673f, -0.03912540f, 0.01934430f, -0.03253290f, 0.00974789f, 
    -0.04124063f, 0.01574580f, -0.00001547f, 0.01000265f, 0.02856889f, -0.03884253f, -0.03266872f, -0.02211985f, 
    0.02908145f, -0.01725662f, -0.04330185f, -0.02004211f, 0.01725485f, -0.00963034f, -0.00752866f, 0.02838666f, 
    -0.01359490f, 0.03141607f, 0.02834490f, 0.00304621f, -0.02197540f, 0.01243413f, -0.03035021f, 0.03058185f, 
    -0.00000254f, 0.00205767f, -0.02370615f, 0.01337049f, -0.04736859f, -0.01840894f, -0.03104574f, -0.02548855f, 
    -0.00491892f, -0.01823461f, 0.01108286f, 0.00422534f, -0.03736723f, -0.02415647f, -0.04247759f, 0.01104658f, 
    -0.02106166f, -0.03857750f, -0.00120574f, 0.00770397f, -0.04470245f, -0.04516346f, 0.01238852f, -0.00967681f, 
    0.03014435f, -0.02949538f, -0.01533625f, -0.04250447f, -0.04135320f, -0.04539357f, 0.03077267f, 0.02877026f, 
    -0.01252993f, 0.01076177f, -0.03242429f, -0.00141036f, 0.02950282f, -0.01464482f, -0.00363395f, 0.00270522f, 
    0.00803897f, -0.01706963f, -0.04494840f, -0.02329230f, -0.01445546f, 0.00420708f, 0.03279406f, -0.02220900f, 
    -0.00651978f, -0.03830087f, 0.03169076f, -0.00025801f, -0.01516433f, -0.03487146f, 0.00595876f, -0.00893802f, 
    -0.02231017f, -0.04135835f, -0.02594808f, 0.03320126f, -0.02224442f, 0.01664609f, 0.00559941f, 0.02111819f, 
    0.01164355f, 0.02042042f, 0.02427762f, 0.02286628f, 0.02847612f, 0.01142468f, 0.01299706f, 0.00690670f, 
    -0.03291570f, -0.01863411f, 0.00909813f, -0.03724257f, 0.03105967f, 0.02904411f, -0.02987389f, -0.01527325f, 
    -0.03060182f, 0.00436750f, -0.02223864f, 0.02654540f, -0.00436175f, -0.04116014f, -0.02278099f, 0.00321913f, 
    0.00719774f, 0.00957349f, 0.01910699f, -0.03603701f, 0.00583384f, -0.00956527f, -0.03077642f, -0.02410153f, 
    0.01499887f, -0.01550232f, 0.00430273f, -0.03093916f, 0.01542039f, -0.00728638f, 0.02927749f, -0.03904962f, 
    -0.03347206f, 0.00934150f, -0.01455935f, -0.00581316f, -0.04687380f, 0.00210137f, 0.01302216f, 0.02494677f, 
    -0.13103712f, -0.01098985f, -0.09002293f, -0.02204161f, -0.18242441f, -0.13534008f, -0.03447645f, 0.05096484f, 
    0.12795129f, 0.05432240f, -0.00253065f, 0.02083520f, -0.11394773f, -0.05808626f, -0.10261679f, -0.03384360f, 
    -0.01935362f, -0.01808334f, -0.03584583f, 0.06598190f, 0.13672633f, 0.04414085f, 0.03055532f, -0.00143693f, 
    -0.00882806f, -0.02722427f, -0.02365959f, 0.03484554f, -0.00058064f, 0.01522277f, 0.27392638f, 0.30124724f, 
    0.07418285f, 0.16034815f, 0.25355715f, -0.11361010f, -0.08480020f, 0.01360540f, 0.02805307f, 0.01377993f, 
    -0.20768148f, -0.34225872f, 0.26203549f, -0.00816660f, -0.00483969f, -0.26321027f, -0.09411704f, 0.19804996f, 
    -0.03890837f, 0.07719674f, 0.06972884f, -0.01957414f, -0.04034261f, -0.20484230f, -0.42249945f, 0.00080475f, 
    -0.04973444f, 0.02559908f, -0.07273291f, 0.01116801f, -0.24694890f, 0.04895324f, 0.14859352f, 0.16271624f, 
    -0.10406183f, 0.25248590f, -0.26695657f, 0.16705313f, 0.19628507f, 0.00650285f, -0.20564157f, 0.07759148f, 
    -0.01517312f, 0.06163286f, 0.01171231f, 0.02999986f, 0.08702188f, -0.01568175f, -0.03940368f, 0.18234980f, 
    0.69271564f, -0.15481651f, 0.13306189f, 0.05594312f, -0.05676502f, 0.04303823f, 0.06774100f, -0.00934503f, 
    0.11606426f, 0.00410277f, -0.02328624f, 0.16494867f, -0.13454852f, 0.03419869f, -0.03091217f, -0.01514936f, 
    -0.20436628f, 0.00930430f, -0.09348042f, -0.02196930f, 0.02312709f, -0.31873670f, -0.12710015f, 0.24202281f, 
    0.25989121f, 0.03904624f, -0.02042483f, 0.05788995f, 0.12384985f, 0.25853559f, 0.12618454f, -0.09973224f, 
    0.12245935f, 0.07162050f, 0.02747983f, 0.34856454f, -0.10627634f, 0.04083219f, 0.20457555f, -0.20011908f, 
    0.26610917f, 0.30384991f, 0.15189233f, 0.01873705f, 0.09669331f, -0.00992814f, -0.05169522f, -0.02784147f, 
    -0.03579753f, 0.04320045f, -0.06717927f, 0.03053957f, -0.01239366f, 0.00243483f, 0.04877280f, 0.07652928f, 
    -0.04369849f, -0.12116574f, 0.03620455f, -0.00897410f, 0.25376946f, 0.11070302f, 0.40966159f, 0.01880313f, 
    -0.11112982f, 0.06371388f, -0.05487974f, 0.03194077f, 0.02461553f, -0.00103946f, 0.01588892f, 0.19072023f, 
    0.03204304f, 0.21373595f, 0.01355792f, -0.04920061f, -0.37336403f, 0.13575487f, 0.05919326f, -0.01334220f, 
    0.11864314f, -0.00091975f, 0.02385581f, 0.05597447f, 0.10818527f, -0.07887175f, 0.01271440f, -0.09316575f, 
    -0.04292361f, 0.08058535f, -0.07927392f, -0.06485631f, -0.07377527f, -0.00639546f, 0.06026826f, 0.06638137f, 
    -0.11152124f, -0.01293368f, 0.03041224f, 0.03308408f, 0.11888582f, -0.20342706f, 0.06905575f, -0.00837019f, 
    0.01064293f, -0.11334889f, -0.01022576f, 0.14940451f, 0.03242727f, 0.13450974f, 0.03200752f, 0.00082121f, 
    0.09519898f, 0.22074142f, -0.22875531f, -0.05154183f, -0.15544610f, 0.00458308f, -0.01583561f, -0.07059033f, 
    -0.21171933f, -0.06229383f, -0.04359256f, 0.09302860f, 0.09058943f, 0.05426750f, -0.00653416f, -0.03661210f, 
    -0.04464683f, -0.13926181f, 0.04322977f, 0.01783615f, 0.08407791f, 0.06407547f, 0.15370789f, 0.07661385f, 
    0.03930060f, 0.16590574f, -0.05185297f, -0.07335551f, -0.20119755f, 0.00706258f, 0.09830323f, 0.17642511f, 
    -0.00058486f, -0.00122969f, -0.03911490f, -0.05089325f, 0.00032778f, -0.13765028f, 0.05892930f, 0.03082930f, 
    -0.00372751f, -0.03449579f, 0.04720294f, -0.01329953f, 0.03909336f, 0.13271745f, 0.00707583f, 0.02217340f, 
    0.09215531f, 0.01135257f, 0.01370319f, -0.00612124f, 0.00366106f, 0.00429940f, -0.00965464f, 0.08093089f, 
    -0.02666906f, 0.03869029f, 0.22437061f, 0.17599854f, 0.12828819f, -0.09813176f, -0.04944096f, -0.11922056f, 
    -0.02138139f, 0.01505816f, -0.00930319f, -0.01243634f, 0.61159015f, 0.04661125f, 0.19454792f, 0.12642942f, 
    -0.07290322f, 0.12726836f, 0.15920797f, 0.07979164f, 0.34254754f, -0.20408140f, 0.13727115f, -0.04476575f, 
    0.15968072f, 0.12582600f, 0.00880610f, 0.15499410f, 0.08117444f, 0.02131692f, 0.11272059f, -0.04845647f, 
    -0.45614237f, -0.34614313f, -0.07333442f, -0.29121345f, 0.21118858f, 0.01793848f, -0.06280798f, 0.27013084f, 
    0.26463106f, 0.25968021f, 0.20059700f, 0.18675120f, -0.27260178f, -0.01503235f, 0.08580367f, 0.15688373f, 
    0.18649179f, -0.12006446f, 0.14395292f, 0.07435504f, 0.13579507f, 0.11283351f, 0.14156577f, 0.05817012f, 
    0.01584207f, -0.10486238f, 0.03712714f, 0.09077796f, 0.09683425f, 0.10843976f, 0.01909876f, 0.16787285f, 
    0.16891098f, 0.25975984f, 0.16229483f, 0.05424095f, -0.03340827f, 0.09494401f, 0.00464784f, -0.00963731f, 
    -0.45247072f, -0.20931588f, 0.14882493f, 0.21518998f, 0.05201541f, -0.14944629f, -0.02576491f, 0.00900364f, 
    -0.10105614f, -0.15470292f, -0.03792777f, 0.10815132f, 0.01534632f, 0.06624486f, 0.07584003f, -0.04017554f, 
    -0.00704821f, 0.07858989f, -0.06119876f, -0.09882990f, 0.05039012f, 0.01771561f, 0.00037779f, -0.04636924f, 
    0.02985043f, -0.02817832f, -0.04763431f, 0.01256575f, -0.02994786f, 0.06458988f, 0.12409348f, 0.16851845f, 
    -0.01413154f, -0.04589438f, 0.01548929f, -0.16969702f, -0.10345774f, 0.04086408f, 0.02647090f, -0.05939107f, 
    0.21907145f, -0.13461712f, 0.04476481f, 0.15804762f, -0.01011645f, 0.06825342f, -0.09040380f, 0.18157771f, 
    0.15668666f, -0.07885183f, 0.09644482f, 0.15966500f, -0.10852356f, 0.04740538f, -0.10092374f, -0.12886406f, 
    -0.15231435f, 0.00758189f, 0.06326815f, -0.06454027f, 0.41771004f, 0.11028966f, 0.17066240f, 0.05970010f, 
    0.16727430f, 0.04326998f, -0.05149835f, 0.12519547f, 0.02251728f, 0.08574577f, -0.06506321f, -0.04549232f, 
    0.00309984f, 0.03261469f, 0.00550462f, 0.22677605f, 0.02106798f, -0.04726180f, 0.00730289f, -0.02656864f, 
    0.33280632f, 0.13175373f, -0.06383362f, 0.11018610f, 0.08835310f, -0.00255745f, 0.06031622f, -0.03406741f, 
    0.04323453f, -0.13217182f, -0.03721305f, -0.02449906f, 0.00472641f, 0.00375243f, -0.01162861f, 0.20114017f, 
    0.22508538f, 0.07725283f, -0.00755968f, 0.07255787f, -0.24771558f, -0.15838398f, 0.09708879f, -0.04618221f, 
    0.06743147f, 0.00268119f, -0.06886365f, -0.13554938f, -0.00334495f, 0.04933376f, -0.18949385f, -0.06344779f, 
    0.04453589f, 0.04363412f, 0.09563647f, -0.06718732f, -0.00540817f, -0.03258768f, 0.18359381f, 0.07963595f, 
    0.15753491f, -0.08149759f, -0.02508576f, -0.02082165f, 0.07769172f, 0.01296642f, -0.00732527f, -0.08031256f, 
    0.00814912f, -0.01181852f, -0.14392675f, -0.02226414f, 0.07954242f, -0.01830334f, 0.02493608f, 0.08770733f, 
    0.13024275f, 0.11306544f, 0.01447398f, -0.03554831f, 0.14203514f, -0.12986436f, 0.14480701f, 0.14373635f, 
    -0.17454106f, 0.12490110f, -0.04615038f, 0.08962619f, 0.05429432f, 0.01277588f, 0.13394307f, 0.02549799f, 
    0.25216454f, 0.04816854f, 0.27467260f, 0.04517537f, -0.12659965f, 0.09159759f, 0.01792696f, -0.03591783f, 
    -0.09936889f, -0.17111501f, 0.09693963f, 0.01241823f, 0.13790733f, -0.23292561f, 0.07292704f, -0.02515166f, 
    -0.00481854f, 0.08262531f, 0.03775173f, -0.05824935f, 0.01863357f, -0.25982201f, -0.19883369f, -0.02796475f, 
    -0.01399207f, 0.02600713f, -0.02569873f, 0.01368879f, 0.33475509f, 0.31424680f, 0.08770375f, 0.16749308f, 
    0.25945118f, -0.02265146f, 0.01203736f, 0.10734706f, 0.07392251f, 0.01786517f, 0.07486574f, -0.01859513f, 
    -0.00473001f, 0.04974073f, 0.05237234f, 0.07571925f, 0.07247069f, -0.01595567f, 0.07054114f, -0.07611113f, 
    -0.03093034f, -0.04966954f, 0.20650175f, 0.09697859f, -0.13218868f, -0.06157961f, -0.03047728f, 0.26109856f, 
    0.00363683f, 0.09446625f, 0.03798589f, 0.01732841f, -0.01848101f, 0.02776095f, -0.04490566f, 0.11766419f, 
    0.05642679f, -0.03971286f, 0.07934409f, 0.01827579f, -0.04627702f, -0.00227351f, 0.05797975f, -0.04577794f, 
    -0.06379321f, -0.00994386f, 0.03242544f, 0.01570699f, 0.02653441f, 0.10638908f, 0.14107199f, 0.06168279f, 
    -0.02754317f, -0.01994294f, -0.04565903f, -0.04065355f, 0.07534351f, -0.01041046f, 0.03801898f, 0.12160253f, 
    -0.00000613f, -0.23689699f, 0.04148480f, -0.09022085f, -0.03063793f, -0.00425219f, -0.04268137f, 0.11561455f, 
    0.03820326f, 0.09157909f, 0.23638152f, 0.04258278f, 0.07028030f, 0.20410274f, -0.12897959f, -0.11132371f, 
    -0.02182277f, 0.04626423f, 0.05093574f, -0.02355925f, 0.03092821f, -0.11415441f, -0.03809357f, 0.00314570f, 
    -0.15270194f, 0.20165659f, 0.00505207f, 0.02138067f, 0.02272285f, -0.11961637f, -0.08015988f, 0.01044782f, 
    0.02944781f, -0.01146268f, 0.01187978f, 0.26924989f, 0.02269019f, -0.03651808f, -0.09739649f, 0.10506289f, 
    0.13580941f, -0.00997382f, 0.03189129f, 0.02328705f, 0.05065900f, -0.07572345f, -0.02480708f, -0.03715518f, 
    -0.06225488f, -0.07074261f, 0.30609059f, 0.42539471f, -0.03205396f, 0.15633868f, 0.30553377f, -0.10740769f, 
    -0.13181849f, -0.08009876f, -0.05853412f, -0.02559053f, -0.26299274f, -0.05027634f, 0.04815992f, 0.36660090f, 
    -0.00796378f, -0.19255666f, -0.07504760f, -0.03919028f, -0.11679733f, -0.19241388f, -0.02700350f, 0.00307287f, 
    -0.02670353f, 0.01204894f, 0.01572296f, 0.01355476f, 0.07032425f, 0.06886403f, -0.00781679f, 0.09800360f, 
    0.27082917f, -0.17461388f, 0.08250902f, 0.22276732f, 0.10735322f, -0.00081597f, -0.05512520f, 0.06446065f, 
    0.10900397f, -0.18534718f, 0.10883645f, 0.17477202f, 0.02803039f, 0.11892670f, 0.06167300f, 0.10898877f, 
    -0.07058822f, -0.05557587f, -0.05557220f, -0.12716909f, 0.02967452f, -0.28430316f, -0.26249605f, -0.25153431f, 
    -0.10750026f, -0.00597243f, -0.16415496f, -0.00390880f, -0.07763456f, -0.22417250f, 0.00919579f, 0.10387532f, 
    0.04834133f, 0.03635428f, -0.02389110f, 0.09350947f, 0.02685216f, -0.11617813f, -0.03760802f, -0.20914273f, 
    -0.05999310f, -0.05907800f, 0.65945369f, 0.38207105f, 0.27119234f, -0.12203772f, 0.04592325f, 0.03741448f, 
    0.17724247f, -0.19651073f, 0.21321851f, 0.03454404f, 0.04020309f, -0.06661579f, 0.17308754f, 0.09613992f, 
    0.05789667f, -0.01076058f, -0.09861463f, -0.06732069f, 0.25380984f, -0.14375162f, 0.13811679f, 0.14264640f, 
    0.00827610f, 0.14878517f, 0.04536624f, -0.16983104f, -0.02837495f, -0.06034243f, -0.11073116f, 0.08270639f, 
    -0.02784321f, 0.07045346f, -0.04574116f, 0.03590287f, -0.03350811f, -0.26811239f, -0.15039504f, -0.23722912f, 
    -0.21580349f, 0.09834247f, -0.02043646f, -0.00469021f, 0.06761117f, 0.04043901f, 0.10589911f, -0.16938336f, 
    -0.05964502f, -0.08530461f, 0.00146607f, 0.00072732f, 0.09217370f, 0.00028341f, -0.07768892f, 0.11442117f, 
    -0.00588473f, -0.04043295f, 0.14550030f, -0.03830842f, 0.21158144f, -0.06548252f, -0.56165773f, 0.00922307f, 
    0.03115811f, 0.10108471f, -0.02577124f, -0.09107669f, -0.06127405f, 0.04154155f, 0.05887142f, -0.05564722f, 
    -0.02365164f, -0.02316068f, -0.14678726f, 0.09021436f, 0.09496123f, -0.04026803f, -0.15077890f, 0.10345943f, 
    0.01347138f, -0.30183512f, -0.25667453f, -0.17318210f, -0.10390171f, -0.03176804f, 0.02422165f, -0.03255478f, 
    -0.04697135f, 0.06615519f, -0.01338527f, 0.05842655f, -0.03239602f, -0.03660364f, -0.02927530f, 0.03407451f, 
    0.10125171f, 0.30141571f, 0.10528701f, 0.09465601f, 0.05273546f, 0.03385281f, 0.06020467f, -0.45638755f, 
    -0.31292358f, -0.04800139f, -0.05258796f, -0.14865771f, -0.17943835f, 0.10697465f, -0.13439271f, -0.21287923f, 
    0.14619806f, -0.04472812f, -0.01037356f, 0.13777256f, 0.00746811f, -0.10481733f, 0.20404188f, 0.02925537f, 
    -0.40986228f, 0.34858316f, -0.34209654f, -0.01427928f, -0.19688028f, -0.00416357f, -0.03012932f, -0.13731609f, 
    -0.11627626f, -0.11362403f, 0.12535867f, -0.08413403f, 0.04961081f, 0.01360337f, -0.06085178f, -0.05313577f, 
    -0.09732933f, -0.02113099f, -0.01183377f, -0.07177394f, 0.33388641f, 0.09003387f, -0.22627223f, 0.20104255f, 
    0.31325212f, -0.11765339f, 0.10555059f, -0.10606895f, -0.20190483f, -0.13771521f, 0.02151348f, 0.03179662f, 
    0.26108176f, -0.10389682f, 0.00549332f, 0.07391290f, 0.02650062f, -0.01528037f, -0.25782904f, -0.24402446f, 
    -0.10827298f, -0.04308539f, 0.08776488f, 0.22809471f, 0.08919513f, 0.02450889f, 0.00717709f, -0.00557315f, 
    0.02402512f, 0.08942893f, 0.06098874f, 0.12470979f, -0.00313108f, 0.03919330f, 0.05020283f, 0.01812609f, 
    0.12174807f, 0.22386274f, 0.00851473f, 0.19896795f, -0.13513894f, -0.06168836f, 0.19907497f, 0.26663449f, 
    0.09297905f, -0.08594652f, -0.01964312f, 0.00017669f, 0.07405846f, 0.01449658f, 0.06994642f, 0.02712187f, 
    0.08467702f, -0.03172671f, 0.04903682f, 0.00754288f, 0.20699710f, 0.11603228f, 0.00501962f, 0.13466345f, 
    -0.25445029f, -0.26191321f, -0.30687156f, -0.03026400f, 0.04908280f, -0.06121529f, 0.02641413f, 0.00490125f, 
    -0.04631209f, -0.15515605f, 0.03735916f, 0.16470623f, 0.00144318f, -0.02186814f, 0.02286959f, 0.01693198f, 
    -0.06950770f, -0.09625138f, -0.17244755f, -0.18244806f, 0.19741924f, 0.07548981f, 0.14709869f, -0.02456438f, 
    -0.12320112f, -0.01836726f, 0.15299714f, 0.12806064f, -0.14734343f, 0.02227519f, 0.04205057f, -0.13863881f, 
    0.11843868f, 0.00141931f, -0.10251275f, -0.02643424f, 0.05690238f, -0.04146552f, 0.04325502f, -0.04716948f, 
    0.29394293f, -0.27608165f, -0.43176106f, -0.02787452f, -0.14688504f, 0.37762856f, -0.14327195f, -0.20089979f, 
    -0.20145307f, -0.12873311f, -0.02206051f, -0.11200463f, 0.05650095f, 0.11019411f, 0.02467113f, 0.21660355f, 
    0.02471910f, -0.07851239f, 0.11342121f, 0.14315924f, 0.01822011f, -0.01381846f, -0.18305472f, -0.11447112f, 
    0.01064556f, -0.05250876f, 0.05262443f, 0.15178996f, -0.32680923f, -0.08748728f, -0.06417241f, 0.00566946f, 
    0.04519445f, -0.14398776f, -0.05683992f, 0.02542454f, -0.04854993f, 0.03413061f, -0.14157797f, -0.12010967f, 
    0.10161441f, 0.03521272f, -0.00808693f, 0.43260789f, -0.00293469f, 0.11857703f, 0.12234142f, 0.03622513f, 
    0.13746679f, 0.17915286f, -0.02775074f, -0.01109632f, 0.01586944f, -0.02274043f, -0.07733721f, -0.02571729f, 
    0.02562262f, -0.14682712f, -0.14231643f, 0.00793184f, -0.50942355f, -0.19400980f, -0.27349851f, -0.07419268f, 
    -0.07824244f, -0.00669101f, 0.05391778f, -0.10234003f, -0.16030475f, -0.11062699f, -0.03222255f, 0.19392478f, 
    0.10676932f, 0.09846838f, -0.08614710f, 0.02989452f, -0.17850623f, -0.10061970f, -0.20161536f, -0.26626605f, 
    0.27914011f, -0.16337347f, -0.24837598f, -0.25424623f, 0.01532779f, 0.04410471f, -0.07069624f, -0.29455063f, 
    -0.11135669f, -0.15437065f, -0.04633991f, -0.20280439f, -0.08331750f, 0.08262257f, 0.07438240f, 0.02048829f, 
    -0.18213148f, -0.14508271f, 0.22976297f, -0.01845758f, -0.14848791f, -0.25671545f, -0.07318547f, -0.05866227f, 
    -0.13124445f, -0.04302374f, -0.10011803f, -0.10729607f, -0.01007763f, -0.02371857f, 0.19324273f, -0.01414792f, 
    -0.02707649f, -0.06862135f, -0.20223023f, -0.03108841f, 0.14241236f, 0.21328032f, -0.01295122f, 0.08562175f, 
    -0.49442825f, 0.03276313f, 0.24088073f, -0.31430829f, 0.01585641f, 0.08314393f, -0.15943602f, -0.15905765f, 
    -0.10805161f, 0.10576813f, -0.03745963f, 0.06848049f, 0.04079445f, -0.10171025f, -0.01352734f, 0.10534271f, 
    0.04503382f, 0.05917879f, 0.12034074f, 0.04300713f, 0.14550050f, 0.29552776f, -0.12687828f, 0.28162056f, 
    -0.09985762f, 0.17821203f, -0.04563791f, 0.06200108f, 0.05634275f, 0.11153415f, -0.10516799f, 0.04047719f, 
    -0.00983385f, 0.02968241f, -0.03274383f, -0.04757184f, -0.15493609f, -0.11209949f, -0.26171175f, -0.02822315f, 
    -0.23840412f, 0.05689852f, 0.46906301f, -0.17856677f, 0.05574410f, 0.08106268f, 0.01380912f, -0.15456988f, 
    0.04743400f, 0.16165633f, 0.00884359f, 0.06088123f, -0.05089486f, -0.01398484f, 0.06860042f, 0.07218444f, 
    -0.00750958f, -0.20590679f, -0.00799815f, 0.13979365f, 0.08583770f, 0.10420518f, -0.17941943f, -0.14199387f, 
    0.08630905f, 0.11468509f, -0.17323130f, 0.04885500f, 0.14579898f, -0.11057460f, 0.04445789f, -0.04195185f, 
    -0.00477599f, 0.02685611f, 0.05689734f, -0.03839820f, -0.08581657f, -0.11987212f, 0.14486496f, -0.16698103f, 
    0.06406884f, 0.10601172f, 0.41729775f, 0.22904274f, 0.32816833f, -0.12290189f, 0.12662978f, 0.00932011f, 
    0.13457850f, 0.09217238f, 0.09471916f, 0.10307062f, -0.00352161f, 0.00703640f, 0.12643722f, 0.06803581f, 
    0.00297493f, -0.02224304f, -0.02007726f, 0.06131368f, -0.12922598f, 0.06883629f, -0.21671082f, 0.15955746f, 
    -0.14935872f, -0.06722336f, 0.20667352f, -0.20641354f, -0.16897668f, 0.06128000f, -0.06928098f, 0.08836478f, 
    -0.01236290f, 0.00861385f, -0.05644088f, 0.07392234f, -0.03313312f, 0.17171562f, -0.00049844f, 0.18145730f, 
    0.18471105f, -0.17430949f, 0.36564866f, 0.38058105f, 0.12908457f, -0.15879646f, 0.14177164f, 0.08172654f, 
    0.18026789f, -0.10255852f, 0.17563958f, -0.03020089f, 0.04688222f, 0.08252568f, 0.13998309f, 0.00508089f, 
    -0.02343305f, 0.03593084f, 0.03511206f, -0.00536437f, 0.10369686f, -0.07404480f, -0.26862973f, 0.05894008f, 
    0.12836735f, -0.03778016f, 0.06397843f, 0.11373006f, -0.00536452f, -0.06653720f, 0.13103047f, 0.10855038f, 
    0.01534508f, 0.12393551f, 0.00615190f, -0.02645723f, -0.11745629f, 0.05029640f, -0.20078711f, -0.07425511f, 
    0.22740094f, 0.01533650f, -0.63671768f, 0.27809176f, 0.07391295f, 0.04720788f, -0.02854567f, -0.01511701f, 
    -0.03736636f, -0.15237434f, -0.15015994f, 0.14685310f, -0.06116086f, 0.03171919f, 0.13757540f, 0.13623196f, 
    -0.07810011f, -0.04076654f, -0.31458721f, -0.07585406f, 0.03759217f, -0.15168253f, 0.12945226f, 0.06292089f, 
    -0.06161960f, 0.07851169f, 0.09547935f, -0.24912055f, 0.01113658f, 0.20333180f, -0.02029794f, 0.04329015f, 
    -0.02014671f, -0.03738649f, -0.00779665f, -0.10613251f, 0.10017524f, -0.05974976f, 0.06907696f, 0.23172626f, 
    -0.36214295f, -0.67186934f, -0.59899187f, -0.19590183f, -0.06763830f, 0.03927267f, -0.05204783f, -0.11245983f, 
    -0.01192923f, -0.23645601f, 0.02226412f, 0.03203217f, 0.12654096f, -0.19613786f, 0.07631432f, 0.18114828f, 
    0.10069006f, -0.29770637f, -0.08978771f, -0.12481430f, 0.08356135f, 0.03420283f, 0.03878308f, 0.46223062f, 
    0.16356166f, 0.02737324f, 0.02568013f, -0.05273617f, 0.13179642f, 0.10882612f, 0.04288793f, 0.07486770f, 
    0.10879382f, 0.08013988f, -0.00784777f, 0.03112959f, 0.10356030f, -0.02933583f, -0.11827517f, -0.05062662f, 
    -0.11526583f, -0.16519207f, -0.00369427f, -0.08471869f, -0.04675329f, -0.03583751f, 0.02945427f, -0.04590051f, 
    -0.01924089f, 0.10855884f, 0.12798613f, 0.12526640f, 0.09098331f, -0.12898190f, -0.05336395f, -0.09772345f, 
    -0.05504791f, 0.03204504f, 0.01024402f, -0.01627208f, -0.22052705f, -0.06486929f, -0.08697642f, -0.04901109f, 
    -0.06679333f, -0.03312627f, 0.00945392f, 0.01011667f, -0.03641733f, -0.08878783f, 0.01163713f, 0.06298711f, 
    0.14888026f, 0.12450283f, 0.05781138f, 0.02717154f, -0.00847951f, 0.05626410f, 0.00734115f, 0.04237293f, 
    -0.28221184f, 0.27821037f, -0.32799169f, -0.17134960f, -0.18767624f, 0.15274914f, 0.04724913f, -0.08123135f, 
    0.18615642f, 0.03655233f, 0.05639585f, -0.04961658f, -0.00787256f, 0.17716348f, 0.05757536f, -0.02569063f, 
    -0.10836532f, -0.09541639f, -0.00087777f, 0.03791378f, -0.14063935f, -0.13303082f, 0.05137702f, -0.28892899f, 
    -0.06190985f, -0.19834787f, 0.23551629f, -0.03916709f, -0.06448419f, 0.19117174f, 0.08119256f, -0.03440322f, 
    -0.03508356f, -0.09762920f, -0.03759758f, -0.09184428f, -0.03451460f, 0.12641121f, -0.01005882f, 0.10065496f, 
    -0.43804875f, 0.47304574f, 0.01227214f, 0.21032636f, -0.03064062f, -0.10402358f, 0.04152427f, -0.06611852f, 
    -0.10621382f, -0.06654603f, -0.00886877f, -0.17242612f, 0.02478656f, 0.06425560f, 0.13000591f, 0.00407127f, 
    -0.00328295f, 0.05595797f, 0.08024808f, -0.01082478f, 0.34750566f, 0.41493273f, 0.05180430f, 0.04791175f, 
    -0.16818273f, 0.09898982f, 0.13654155f, 0.13847940f, 0.06843098f, -0.01737620f, 0.06438952f, 0.12864988f, 
    -0.00729705f, -0.16819087f, 0.11618858f, -0.23333324f, 0.05313266f, 0.04901801f, 0.00063935f, 0.02293429f, 
    -0.29270619f, -0.24877164f, 0.10264375f, 0.03621208f, 0.01161864f, 0.02589439f, -0.05510533f, 0.06170509f, 
    -0.04908445f, -0.06345060f, -0.04192533f, -0.08071987f, 0.03634032f, -0.06782487f, -0.02754434f, -0.08690486f, 
    0.03603927f, -0.02569144f, -0.11283064f, -0.07669197f, 0.11827616f, 0.00324529f, -0.14722569f, 0.05495765f, 
    0.45813549f, -0.06095177f, 0.06830127f, -0.01937492f, 0.02505037f, -0.17365630f, -0.06034322f, 0.02494899f, 
    0.12357537f, -0.14881095f, 0.14488909f, -0.01915095f, 0.12319814f, 0.01850903f, 0.00448913f, -0.03351748f, 
    0.21747451f, 0.02685893f, -0.08843942f, 0.02552468f, -0.08700086f, 0.23482947f, -0.02527044f, 0.08244970f, 
    0.09942335f, -0.17916007f, 0.00551343f, -0.00129598f, 0.04511700f, -0.02773834f, -0.02876034f, -0.06639943f, 
    0.05745742f, 0.11638413f, 0.03710840f, 0.08070921f, -0.30210662f, 0.05219501f, -0.10480044f, 0.05781385f, 
    -0.09202038f, 0.04802940f, 0.07807730f, -0.21245250f, 0.07618420f, -0.13275041f, 0.19399835f, 0.06934477f, 
    0.04900074f, 0.04537875f, 0.16659059f, 0.10036512f, 0.05456036f, -0.06660914f, 0.07612259f, 0.13128366f, 
    0.05658096f, 0.00625449f, 0.03877624f, 0.00333813f, 0.01270068f, 0.01795511f, -0.00590628f, 0.09911643f, 
    0.14586470f, 0.13206598f, 0.02665862f, 0.02451266f, 0.03083798f, 0.09734977f, 0.05975530f, 0.14866175f, 
    0.18336946f, 0.11430417f, 0.06308331f, -0.19098321f, 0.06860287f, -0.08572130f, -0.17033753f, -0.15926662f, 
    -0.01335168f, 0.04916286f, -0.05750261f, 0.03844799f, 0.06884323f, 0.08339334f, 0.01692215f, -0.06226909f, 
    -0.03102092f, 0.07024956f, 0.16071674f, 0.15165105f, 0.11862309f, 0.15348676f, 0.15058810f, -0.00063945f, 
    -0.10539661f, 0.01337767f, -0.01561285f, 0.00678957f, -0.05502057f, 0.02378109f, -0.04791641f, -0.08289297f, 
    -0.04655011f, -0.07614822f, 0.11311813f, 0.11480492f, 0.16348812f, 0.13299455f, 0.04038598f, 0.02009255f, 
    0.09975914f, 0.06865992f, 0.04463752f, -0.01737113f, -0.20263962f, 0.02486573f, -0.23757286f, 0.01193815f, 
    0.15169244f, 0.05356797f, -0.05621645f, 0.03501609f, -0.09792139f, 0.22028877f, 0.08166543f, 0.09828274f, 
    -0.17260420f, -0.05214404f, 0.04905621f, 0.12956299f, -0.09730726f, 0.09356326f, -0.00271065f, 0.18103202f, 
    0.26499870f, 0.71056134f, -0.10778148f, 0.14593692f, 0.03912687f, -0.01800046f, 0.20569055f, -0.18832287f, 
    -0.07659746f, -0.01567343f, 0.04478060f, 0.00527817f, 0.07304596f, 0.02558685f, -0.10136163f, -0.05496592f, 
    -0.12717746f, 0.06476005f, 0.16851163f, -0.12758508f, 0.01404206f, -0.07080423f, -0.00078639f, 0.08036888f, 
    -0.05555434f, 0.09500638f, 0.01946783f, 0.00700344f, -0.06297926f, 0.04380302f, 0.13580070f, 0.07720118f, 
    -0.10405581f, -0.05817203f, 0.13962342f, 0.11208310f, -0.03746404f, -0.01460016f, 0.00823737f, 0.16565737f, 
    0.34512278f, -0.02384762f, -0.01043766f, -0.11173379f, -0.08764634f, 0.08955753f, -0.04845434f, 0.04735626f, 
    0.04908480f, 0.05150838f, 0.07649738f, -0.02825956f, 0.06623992f, -0.02466964f, 0.02193154f, -0.02747431f, 
    -0.00609035f, 0.07770225f, 0.14158291f, 0.14717400f, 0.07196847f, -0.06800363f, 0.03046443f, 0.10439139f, 
    -0.08425253f, 0.03617660f, -0.02111430f, -0.07130183f, -0.06326378f, -0.13607559f, 0.10714749f, 0.02896501f, 
    0.14571312f, 0.06752595f, -0.01102345f, 0.06636572f, 0.11173763f, 0.04244371f, 0.03824684f, -0.02593144f, 
    -0.22289127f, 0.20912483f, -0.03297013f, -0.03482470f, 0.20250054f, 0.03951353f, 0.01792322f, -0.16254640f, 
    -0.05533070f, 0.03881814f, 0.15360881f, 0.01682215f, 0.08288727f, 0.20058639f, 0.07675294f, 0.26916546f, 
    0.15494321f, 0.14386085f, 0.02593891f, -0.03829452f, -0.09210311f, 0.13152832f, -0.11350827f, 0.13411254f, 
    -0.11318757f, 0.06370586f, 0.03407201f, 0.06111004f, 0.05264476f, 0.00334959f, -0.05864443f, 0.04111201f, 
    0.00153950f, -0.10119024f, -0.01762186f, -0.04607362f, -0.02609098f, 0.07987753f, 0.02704090f, -0.04796157f, 
    -0.18222024f, -0.04073707f, 0.24755670f, 0.07830341f, -0.09667430f, 0.02544389f, 0.03131684f, 0.11098524f, 
    0.06281320f, 0.01608925f, 0.01307444f, -0.02225386f, -0.03315255f, -0.07484075f, -0.01340389f, 0.03525418f, 
    0.08394318f, 0.07703373f, -0.07429757f, -0.03861492f, 0.37210122f, 0.01895550f, 0.08820811f, 0.02547592f, 
    -0.11310186f, -0.14094299f, -0.02360849f, -0.02632435f, -0.04988315f, -0.15793744f, 0.03742403f, 0.02010773f, 
    -0.00831942f, -0.14737082f, -0.02558216f, -0.03514265f, -0.01304748f, -0.00811013f, 0.02562996f, -0.01929083f, 
    -0.02992019f, 0.23711753f, 0.25456432f, 0.13549662f, 0.01783854f, 0.00127435f, 0.09367237f, 0.22353783f, 
    0.04385837f, 0.05371497f, 0.01868186f, -0.03438058f, -0.02599757f, 0.00639166f, -0.07608871f, -0.01060578f, 
    -0.02396779f, 0.18639989f, -0.02962438f, -0.01575446f, -0.11917740f, 0.20268419f, 0.00863466f, -0.12442971f, 
    0.03882605f, -0.10408207f, 0.12321075f, -0.04188919f, 0.04746555f, -0.05417914f, 0.13955916f, 0.05841080f, 
    0.03294051f, 0.08117989f, 0.02320377f, 0.01735467f, 0.11378535f, 0.12141384f, 0.04841759f, 0.01822799f, 
    -0.13901907f, 0.04553657f, -0.17435327f, -0.03000701f, -0.10928361f, 0.16905710f, 0.04182599f, 0.04682704f, 
    -0.03215871f, -0.03083670f, -0.00519319f, -0.04775280f, 0.05905594f, 0.10541325f, 0.13277988f, -0.02178859f, 
    -0.02519884f, 0.04336222f, 0.01170016f, 0.04443020f, 0.13289297f, -0.11264028f, 0.07299455f, 0.11393732f, 
    0.02120847f, 0.07754081f, -0.01541764f, 0.00504720f, -0.02740058f, -0.06671892f, 0.03544684f, 0.04284479f, 
    -0.00904903f, 0.01545522f, -0.03144472f, -0.16427588f, -0.09953418f, -0.01208308f, 0.02678342f, -0.08529253f, 
    -0.11145191f, -0.03578885f, -0.21027438f, -0.11521076f, 0.08767725f, 0.13104226f, 0.00420153f, -0.09592853f, 
    0.04154610f, 0.10546888f, 0.10982491f, 0.05076257f, -0.04034333f, -0.03284808f, -0.05665729f, -0.01939643f, 
    0.00775055f, 0.05582536f, -0.06177041f, 0.04263300f, -0.07472133f, -0.05318260f, 0.00404557f, -0.01072215f, 
    -0.05407631f, 0.06421503f, 0.02133741f, -0.06392123f, -0.00424928f, -0.03498200f, 0.07966705f, 0.09410392f, 
    0.08818980f, -0.07370052f, 0.04162102f, 0.01570093f, 0.08604612f, 0.04619409f, 0.04071281f, -0.04879415f, 
    -0.13041620f, 0.15828058f, -0.18108878f, 0.05627200f, -0.05177754f, -0.02457499f, 0.01990120f, -0.14545630f, 
    -0.04260042f, -0.10578923f, 0.14340045f, 0.02963704f, 0.02720019f, 0.03698644f, 0.00665054f, 0.09430269f, 
    0.16447788f, -0.02574106f, 0.02121961f, 0.03074057f, 0.16870449f, 0.09242214f, -0.03074410f, -0.06403985f, 
    0.15963602f, 0.03396187f, 0.00079682f, 0.02054993f, 0.10303736f, 0.00591754f, 0.01536471f, 0.02062531f, 
    0.00325301f, -0.04981564f, 0.05210851f, 0.15519468f, 0.03394693f, 0.07819103f, 0.05499436f, -0.13737231f, 
    -0.15145259f, 0.01781264f, -0.05641983f, 0.01279425f, -0.10077005f, -0.07089596f, -0.00323086f, -0.01570373f, 
    0.04235920f, -0.10522852f, 0.07426996f, 0.08810931f, 0.14006212f, 0.12345485f, 0.12223704f, -0.02032441f, 
    0.09482938f, 0.05568459f, 0.07149059f, 0.04545370f, 0.04221528f, -0.20482476f, -0.06537323f, -0.16308735f, 
    0.00058174f, 0.04691172f, -0.01957487f, 0.12589020f, 0.10308161f, 0.13408370f, -0.02019300f, 0.01252693f, 
    0.00015832f, -0.07952383f, -0.03383428f, -0.03728238f, -0.00308002f, 0.06846941f, 0.00719776f, 0.06058564f, 
    0.10131548f, -0.23729138f, -0.27159169f, 0.09416268f, -0.14596246f, 0.01020840f, -0.04319621f, -0.07940908f, 
    -0.00978431f, -0.07268351f, -0.09810373f, 0.00411917f, -0.03568750f, -0.08823485f, -0.03203868f, -0.03947516f, 
    -0.08750118f, -0.06283287f, -0.05808318f, -0.05059209f, 0.01008520f, -0.07924533f, -0.12639156f, 0.13215818f, 
    0.09275993f, -0.03069344f, 0.01095484f, -0.07194111f, 0.03473299f, -0.13276492f, 0.01357677f, 0.01459434f, 
    0.01335786f, 0.01473569f, 0.06679515f, -0.11449637f, -0.06919627f, 0.05706435f, -0.02920303f, -0.03670132f, 
    -0.34962061f, 0.10000804f, -0.43416363f, 0.22413906f, -0.49848217f, 0.18417762f, 0.05731365f, -0.07922540f, 
    0.06427819f, -0.13393873f, -0.09164749f, -0.07291056f, -0.00745199f, 0.04667087f, -0.06704455f, -0.04303165f, 
    -0.11913387f, -0.03992013f, -0.10579120f, 0.01625912f, 0.04978734f, -0.03841421f, -0.05557611f, 0.25131798f, 
    -0.01779748f, -0.15194893f, 0.10232075f, 0.02670562f, 0.17170855f, 0.05731045f, -0.08222624f, 0.08686296f, 
    -0.05459113f, -0.12290541f, 0.01538562f, 0.09080170f, -0.08372541f, -0.06502301f, 0.21905449f, -0.05496844f, 
    -0.00946744f, 0.12706514f, -0.01415587f, 0.07999624f, 0.08730286f, -0.04847880f, -0.12888174f, 0.18072587f, 
    -0.01891619f, -0.03709077f, -0.01259407f, -0.04260478f, -0.01573031f, 0.02312878f, 0.18529083f, 0.06514367f, 
    0.06363907f, 0.03073399f, 0.21309444f, 0.00639687f, -0.30297610f, -0.11675880f, 0.28815860f, 0.18866155f, 
    0.12453827f, 0.08916215f, 0.06228308f, 0.25599250f, 0.22895108f, 0.09496835f, 0.06231525f, -0.09262487f, 
    -0.19188082f, 0.02236546f, 0.03487952f, 0.16069135f, 0.08731209f, 0.23348032f, 0.03590288f, 0.00207069f, 
    0.36687714f, -0.18410030f, 0.04729341f, 0.10805417f, 0.20944646f, -0.04420938f, -0.02918140f, 0.01016454f, 
    0.02170182f, 0.02764336f, -0.05067703f, -0.05332128f, -0.10731192f, -0.02116619f, -0.00942919f, 0.02697507f, 
    -0.02451783f, 0.20236720f, 0.03494261f, -0.05888767f, 0.41624364f, -0.11235458f, -0.22914499f, 0.09217503f, 
    0.15643549f, -0.06234460f, 0.09459081f, 0.01295736f, -0.05193819f, 0.09871283f, 0.02936853f, 0.03493128f, 
    -0.25622788f, 0.08137607f, 0.08961543f, 0.08874072f, 0.04722692f, 0.09208126f, 0.09518152f, -0.08843610f, 
    -0.15994242f, 0.05702176f, 0.33264327f, 0.02856456f, -0.10995961f, 0.16170745f, 0.00069618f, 0.13871394f, 
    -0.05097613f, -0.12395214f, -0.08274299f, -0.10248810f, 0.16834408f, 0.00175180f, -0.05546744f, -0.03393782f, 
    -0.07851665f, -0.08466721f, -0.09167226f, 0.01906725f, -0.13456134f, -0.12449843f, 0.03335913f, 0.21778724f, 
    0.17461450f, 0.10956674f, -0.10654084f, 0.20929611f, 0.03479927f, -0.13034904f, -0.06230296f, 0.05486509f, 
    -0.13971192f, -0.02122190f, 0.15109690f, 0.02157435f, -0.09565446f, -0.04704354f, -0.04621695f, 0.03332872f, 
    0.12729180f, 0.20578864f, 0.36530930f, 0.07113616f, -0.14710736f, 0.15924466f, 0.01457629f, 0.08400025f, 
    0.09518136f, 0.09787279f, -0.00138292f, 0.04295614f, 0.08203925f, -0.04959321f, 0.04630388f, 0.08914606f, 
    -0.00708775f, -0.07373379f, 0.02622650f, -0.14737648f, 0.05356570f, 0.27740589f, 0.22514930f, 0.05406277f, 
    -0.22593698f, 0.18184170f, -0.00960484f, 0.20293817f, 0.11744608f, 0.09901707f, 0.06871339f, -0.00341906f, 
    0.05203474f, -0.00543622f, 0.02650042f, 0.06410968f, -0.01481939f, -0.06265054f, 0.06357463f, -0.06021255f, 
    0.00307750f, -0.02807738f, -0.00234718f, 0.16500030f, 0.02336415f, -0.02041177f, -0.01530326f, -0.04728608f, 
    0.01191667f, -0.12155678f, -0.03077558f, 0.01952919f, 0.14083152f, 0.01967321f, -0.05501200f, -0.06187407f, 
    -0.03369974f, 0.02085744f, -0.13401872f, -0.09927180f, 0.12119763f, 0.06769674f, -0.04832393f, 0.01344268f, 
    -0.19154809f, -0.00922234f, -0.10142368f, -0.13543768f, 0.20521690f, 0.28212222f, -0.06678298f, 0.02749339f, 
    -0.09941652f, -0.03657288f, 0.10912655f, 0.05848070f, 0.03156817f, -0.00776072f, 0.31295630f, 0.21888912f, 
    -1.03869390f, 0.39074281f, 0.20755982f, 0.00169375f, 0.34264085f, 0.00900156f, 0.14227401f, 0.04050124f, 
    0.25914058f, 0.20258190f, -0.08563410f, -0.05797655f, -0.17489992f, 0.04765175f, -0.14848785f, -0.06961428f, 
    0.08597790f, 0.01356917f, 0.06676085f, 0.06081100f, 0.02675190f, -0.11085646f, 0.27068123f, 0.12200108f, 
    0.06686619f, -0.01687803f, -0.06187927f, 0.08199011f, 0.05188382f, -0.04926643f, 0.00791294f, 0.04388532f, 
    0.08172147f, -0.04322666f, 0.09297483f, 0.06206223f, 0.04754644f, -0.10163780f, 0.15846902f, 0.18157718f, 
    0.14376415f, 0.27598903f, 0.43670192f, -0.10350991f, -0.33987817f, -0.00668444f, -0.07668658f, 0.10307933f, 
    0.13430803f, -0.02534743f, -0.04631265f, 0.04783561f, -0.04177597f, -0.03602517f, -0.03468050f, 0.07871112f, 
    -0.10075012f, -0.03719134f, -0.01689643f, 0.03173710f, -0.06578776f, 0.00757790f, 0.02446766f, 0.11181108f, 
    -0.02181115f, -0.07309955f, -0.02799000f, 0.04223165f, 0.07751124f, -0.08529528f, -0.00341332f, 0.00169539f, 
    0.08140204f, -0.11260754f, -0.12236248f, -0.04722829f, -0.06920053f, -0.04806763f, -0.11345334f, -0.10696141f, 
    -0.15670310f, 0.05004014f, -0.06788802f, 0.17789574f, 0.27028251f, -0.05834721f, 0.06170806f, 0.01862193f, 
    -0.00417148f, 0.14141344f, -0.09354605f, 0.07162590f, -0.09892432f, 0.12211009f, 0.05580563f, 0.05819775f, 
    -0.16494514f, -0.16519329f, 0.01456353f, -0.05120840f, -0.04542983f, -0.12830521f, 0.29471070f, 0.12084482f, 
    0.10270464f, 0.05219234f, -0.05479009f, -0.03183058f, -0.00459594f, 0.06222705f, -0.08911933f, -0.01297009f, 
    -0.09338682f, -0.00597518f, -0.09092533f, 0.14935698f, 0.06705899f, 0.16161367f, -0.10537113f, 0.00929195f, 
    0.21446827f, 0.12312833f, 0.06244705f, 0.16807106f, -0.14118278f, 0.03509068f, 0.00935673f, 0.01418645f, 
    0.09030814f, 0.04395797f, -0.11411089f, -0.02912376f, -0.01843710f, -0.06485178f, -0.00838195f, -0.18330388f, 
    0.05709586f, 0.05791520f, 0.10262722f, 0.06221009f, 0.03151739f, 0.13632305f, 0.26929393f, -0.20741878f, 
    -0.24316360f, 0.03655059f, -0.03429383f, 0.17234038f, -0.06197371f, -0.03154213f, -0.11192096f, 0.06860476f, 
    0.01237283f, -0.07491169f, -0.08596905f, 0.04122961f, -0.11070418f, -0.12389457f, -0.15184115f, 0.11065751f, 
    0.10737763f, 0.23860496f, 0.21038495f, 0.05443154f, -0.14640936f, 0.14265805f, 0.01872218f, -0.06453825f, 
    -0.09296662f, 0.05028357f, -0.11531662f, 0.00858149f, -0.01380918f, -0.01562836f, -0.07933716f, 0.00109496f, 
    -0.06387544f, -0.01151947f, -0.10377213f, 0.09124399f, 0.04469660f, 0.14047800f, 0.07328499f, 0.00308795f, 
    0.27791393f, -0.11798143f, -0.09072940f, -0.03557143f, 0.00412875f, 0.08921438f, -0.05163227f, 0.10418256f, 
    -0.01844598f, 0.11152968f, 0.07205320f, 0.07924637f, -0.00754309f, -0.00985172f, 0.14250085f, 0.09137072f, 
    -0.07325697f, 0.12612541f, -0.11427988f, 0.23102841f, -0.52635807f, 0.35094896f, 0.09290268f, 0.00483018f, 
    0.02155394f, -0.01762331f, -0.03767497f, -0.06359245f, -0.02086544f, 0.02463789f, -0.06124242f, -0.03812350f, 
    -0.01051062f, -0.00397326f, -0.08154467f, 0.06360235f, 0.36922765f, -0.32133585f, 0.26901662f, 0.31736881f, 
    0.19614331f, 0.03910637f, -0.01884235f, -0.05963731f, 0.13017663f, -0.16963148f, -0.16484985f, -0.07201347f, 
    -0.05664421f, -0.00820298f, 0.05920692f, 0.17764814f, -0.04539534f, 0.13796079f, -0.04158434f, 0.03338698f, 
    0.01181390f, 0.09736850f, -0.08630867f, 0.05184712f, -0.23042329f, 0.13665505f, -0.03421462f, -0.07645699f, 
    0.04274372f, 0.05639220f, -0.07310602f, -0.01732920f, -0.03841564f, -0.13426314f, 0.01045002f, 0.04495301f, 
    -0.03555426f, -0.09927819f, -0.05042873f, 0.08287888f, 0.09959172f, -0.22756392f, 0.20071797f, 0.09311168f, 
    -0.07583436f, 0.10123444f, -0.05603458f, 0.00368309f, 0.00783366f, -0.09195237f, -0.04416664f, 0.00714216f, 
    0.05868531f, -0.08140171f, 0.00218288f, -0.04588558f, -0.03314579f, -0.05279447f, -0.07180685f, -0.03990891f, 
    -0.11816737f, -0.06048948f, 0.18615018f, 0.07493103f, 0.22245403f, 0.09684266f, -0.00928806f, -0.05580597f, 
    0.01142570f, -0.05328305f, -0.00936954f, 0.03085054f, -0.02114340f, -0.05782901f, 0.03311415f, 0.04487396f, 
    -0.03490863f, -0.04016452f, -0.11949624f, -0.00952285f, 0.27243719f, 0.35451448f, 0.41738722f, 0.00245890f, 
    -0.20468545f, 0.15201020f, -0.17890953f, -0.06687439f, 0.09203245f, 0.35520038f, -0.03954538f, 0.08821558f, 
    0.03976389f, -0.02187262f, -0.08473353f, 0.13566287f, -0.05057747f, -0.02190096f, -0.05185190f, 0.06775496f, 
    -0.00990514f, -0.09400343f, 0.03911655f, 0.19963302f, 0.12502460f, -0.01125668f, -0.02093455f, -0.06385470f, 
    -0.03735405f, -0.11727583f, -0.00023544f, 0.08359111f, 0.02425729f, 0.06257688f, -0.04010031f, -0.08943675f, 
    -0.01142983f, 0.08754285f, -0.07647369f, -0.12679762f, 0.23719788f, 0.28025854f, 0.27063829f, 0.04712763f, 
    -0.04308739f, 0.11375190f, -0.06076913f, 0.07078844f, -0.00815779f, 0.00823961f, 0.03142903f, 0.07185739f, 
    0.02609444f, -0.01713039f, -0.08206056f, 0.02673319f, -0.09748825f, -0.11171601f, -0.04863104f, 0.08686103f, 
    0.26617327f, 0.14511244f, -0.27359152f, -0.02990187f, 0.35892403f, 0.06549317f, 0.00948781f, 0.06055617f, 
    -0.03218440f, -0.06188618f, 0.10176845f, 0.00589569f, -0.04015214f, 0.02466207f, 0.01237756f, 0.01199830f, 
    -0.01907365f, -0.04488565f, -0.01470424f, -0.01248453f, -0.11534985f, 0.00172618f, -0.02720843f, -0.09172699f, 
    -0.27776238f, 0.05765513f, -0.18244369f, 0.05033031f, -0.06139283f, 0.04347636f, 0.05407657f, -0.02956355f, 
    -0.05809739f, 0.04241634f, 0.03965774f, -0.11019495f, -0.00350650f, -0.07604967f, 0.00464957f, -0.05766144f, 
    0.30395359f, 0.09398543f, -0.06895783f, -0.22311342f, 0.33277678f, 0.12357986f, 0.01875679f, 0.15979929f, 
    0.06786240f, 0.06095741f, -0.10888056f, 0.14363421f, -0.10928252f, 0.07156908f, 0.08313327f, -0.19498825f, 
    0.06975855f, 0.00609896f, 0.07445487f, 0.07933144f, 0.47494289f, 0.28949133f, -0.08089118f, -0.11618180f, 
    0.08398318f, 0.08022871f, -0.00380933f, 0.12375809f, -0.05619884f, 0.12975886f, 0.14807194f, -0.00205271f, 
    0.03208697f, 0.16206826f, 0.09682892f, -0.05876765f, -0.15748058f, 0.00334782f, 0.08051623f, -0.14736867f, 
    -0.35795149f, 0.37166500f, 0.10758578f, -0.10529891f, -0.10119900f, -0.00409303f, -0.28624871f, 0.17535572f, 
    -0.07341279f, -0.02573441f, -0.08835545f, 0.08109295f, -0.22683904f, -0.01222366f, 0.00266570f, -0.10440406f, 
    0.07343679f, 0.02883400f, -0.03135747f, 0.19376566f, 0.42961916f, 0.15369919f, 0.50847417f, -0.05430603f, 
    -0.13071877f, -0.05228667f, -0.01026588f, 0.01334387f, -0.06511424f, -0.07434076f, 0.05191329f, -0.00128185f, 
    -0.02377211f, 0.17801991f, 0.00123223f, 0.04960331f, 0.02135709f, -0.04118090f, 0.11189511f, 0.21435042f, 
    -0.33762196f, 0.17766270f, 0.21031334f, 0.06698191f, -0.13821158f, -0.07400283f, -0.07550271f, -0.15821120f, 
    -0.02925641f, -0.01074542f, 0.06039974f, -0.07827963f, -0.06054177f, -0.07224087f, -0.00546684f, 0.10527798f, 
    0.05725430f, 0.02071865f, -0.02225337f, 0.19261225f, -0.53587514f, 0.20666115f, -0.03354345f, 0.44047323f, 
    -0.16874894f, 0.11469220f, -0.36403546f, 0.05186178f, -0.03813260f, 0.01354972f, 0.06286904f, -0.00368560f, 
    0.01589845f, 0.10160804f, -0.05812847f, -0.15463951f, 0.01131358f, 0.11766709f, -0.03220914f, 0.04315270f, 
    -0.46091291f, -0.52714801f, 0.50231510f, 0.36432081f, -0.07118564f, -0.04497552f, 0.15203865f, 0.04010418f, 
    -0.01890538f, 0.15119027f, 0.00334773f, 0.10639684f, 0.00233479f, -0.11041576f, 0.04694531f, 0.06298666f, 
    0.11043669f, -0.07269765f, 0.00982110f, -0.14135616f, 0.22440460f, 0.34055543f, 0.31936699f, -0.58712631f, 
    -0.35836029f, 0.06444516f, -0.29841682f, 0.05666034f, -0.21358153f, -0.04470885f, 0.03971842f, 0.06104391f, 
    -0.08430841f, 0.09965304f, -0.02154722f, -0.10685185f, 0.03026217f, -0.11501348f, 0.15855551f, 0.00186325f, 
    0.18202738f, 0.08762725f, -0.00143055f, -0.08426791f, 0.08536619f, -0.05410329f, 0.23097725f, 0.00789299f, 
    -0.04665416f, 0.04601194f, 0.04949271f, -0.06068883f, -0.07620669f, 0.02448875f, -0.04365459f, 0.17000777f, 
    0.12942946f, -0.03216979f, 0.01452669f, 0.25990269f, 0.13775332f, 0.03504614f, -0.10421490f, -0.06090550f, 
    0.22208904f, 0.02218323f, 0.22866103f, 0.08577364f, 0.03504404f, 0.12942608f, -0.01544288f, 0.00309199f, 
    -0.04456621f, 0.11369012f, 0.06728751f, 0.22333752f, 0.08723885f, -0.01681079f, 0.06489661f, 0.15655698f, 
    -0.07862367f, -0.10502376f, -0.20550096f, -0.22050838f, -0.12305034f, -0.13575539f, -0.11580714f, 0.07311945f, 
    -0.08729706f, -0.03645628f, 0.03404105f, 0.03164039f, -0.08104853f, -0.02039224f, 0.06369760f, 0.04726369f, 
    -0.08015975f, -0.00190126f, -0.07290070f, -0.09071932f, -0.35748389f, 0.06296569f, 0.05198624f, 0.06623808f, 
    0.18942705f, 0.05984377f, -0.06917403f, 0.00326954f, 0.02530706f, -0.10256559f, 0.10881564f, 0.05768749f, 
    -0.14949480f, 0.08499940f, 0.04868258f, -0.16283476f, 0.06088017f, -0.02357177f, -0.00241487f, -0.12638701f, 
    1.61252069f, -0.08143155f, 0.33278900f, -0.17373280f, -0.13471437f, -0.22841398f, -0.02620525f, 0.23863587f, 
    0.19584621f, -0.19674568f, -0.08031558f, 0.10283378f, 0.07034089f, -0.00153347f, -0.06663997f, -0.13830948f, 
    0.00431644f, 0.03225767f, -0.17079359f, 0.03060973f, -0.28034398f, -0.06626455f, -0.09841439f, -0.27331302f, 
    -0.16507412f, 0.04756420f, -0.09634214f, -0.19109647f, 0.15655246f, -0.12421174f, 0.05346623f, 0.02857829f, 
    -0.07769689f, 0.00724818f, 0.03693428f, -0.13700297f, -0.04175076f, -0.01051418f, 0.03736477f, -0.28454521f, 
    0.30536625f, 0.35069141f, 0.22247218f, -0.02054732f, 0.21674234f, 0.03992443f, 0.16504130f, 0.11056014f, 
    0.10580768f, 0.15014414f, 0.04451446f, 0.11356846f, -0.01471468f, -0.00900374f, 0.02338532f, -0.12516887f, 
    -0.07464852f, -0.05432729f, -0.10695161f, 0.13843775f, -0.08576842f, -0.24327059f, 0.01066162f, -0.15263695f, 
    0.02283256f, -0.01707778f, -0.00140077f, 0.22922555f, 0.01148543f, 0.09529474f, 0.07727792f, 0.12455443f, 
    -0.09913655f, -0.05261992f, 0.08113541f, 0.07412772f, -0.13603036f, 0.07018926f, -0.12070393f, 0.01213508f, 
    0.24013905f, -0.05928778f, 0.26607066f, 0.16129127f, -0.30970255f, 0.00773246f, -0.04583126f, 0.37046599f, 
    -0.08050008f, -0.13529186f, -0.05502094f, 0.06321795f, 0.15393929f, -0.17261961f, 0.06651165f, -0.00092585f, 
    0.01220502f, 0.22705983f, -0.19586378f, 0.02274157f, -0.26182988f, -0.07978871f, 0.32491255f, -0.04454414f, 
    -0.10602630f, -0.08250324f, -0.04908326f, -0.24847761f, -0.00849512f, -0.09909487f, 0.08331306f, -0.08113684f, 
    -0.04666824f, 0.01332327f, 0.11615349f, 0.05995436f, 0.03675271f, 0.01551966f, -0.06662420f, -0.08852030f, 
    -0.40591466f, -0.19501267f, -0.04392138f, 0.05175696f, 0.17013721f, -0.11534920f, -0.08002821f, -0.11979873f, 
    0.09074157f, 0.03114058f, -0.08138175f, -0.01887426f, -0.03231556f, -0.10997136f, -0.05561308f, 0.05193098f, 
    -0.01158462f, 0.01662627f, 0.02613623f, 0.06070429f, -0.01530825f, 0.13801485f, 0.44886190f, -0.07817422f, 
    0.31894541f, 0.02280978f, 0.15974525f, 0.06535708f, -0.01042589f, 0.16795070f, 0.15082185f, -0.05937293f, 
    -0.15469323f, 0.07014363f, 0.10564581f, -0.07511663f, -0.15545462f, 0.01988572f, 0.00162824f, -0.10831475f, 
    -0.27806228f, -0.15288824f, 0.13763207f, 0.13017842f, 0.20414253f, -0.12207326f, -0.03851333f, -0.00382624f, 
    0.03218412f, 0.10340729f, -0.03484500f, -0.00512205f, -0.02112863f, -0.14637926f, -0.03009990f, -0.02286828f, 
    -0.11528160f, 0.02458975f, 0.00037396f, 0.03901380f, 0.00800032f, 0.24310321f, 0.00498479f, 0.07691530f, 
    -0.18216103f, 0.02253368f, -0.11075131f, -0.04043332f, -0.07619173f, -0.03858226f, -0.08711182f, -0.04458974f, 
    0.01133849f, -0.03330394f, -0.07097476f, 0.04078063f, -0.05838633f, -0.10249868f, -0.09759818f, 0.12494949f, 
    0.14041436f, 0.08921501f, -0.16560449f, -0.05943184f, 0.46942520f, 0.08559290f, -0.05485525f, 0.21491648f, 
    -0.00366973f, -0.02629177f, -0.07981002f, 0.12071987f, 0.01656080f, 0.09208752f, 0.02037339f, 0.03056636f, 
    -0.02408052f, -0.05366525f, -0.02621519f, 0.09194124f, -0.54797405f, 0.09114207f, 0.27495876f, -0.23206928f, 
    -0.18304352f, -0.01051819f, -0.16530578f, 0.00088157f, 0.09364160f, -0.10149500f, 0.08852077f, 0.01692964f, 
    -0.13368817f, -0.02814153f, -0.05584075f, 0.07331077f, 0.02989931f, 0.09499025f, 0.03221742f, -0.03722017f, 
    0.22516756f, 0.09108855f, -0.11636599f, -0.08239909f, 0.28986812f, 0.14080507f, 0.05407569f, 0.12534447f, 
    0.00027764f, 0.02290313f, -0.05655963f, 0.05205242f, -0.09998573f, 0.01015706f, 0.09163392f, -0.07228706f, 
    -0.09040286f, 0.06301211f, -0.04798625f, -0.15456025f, -0.04914832f, -0.05623053f, -0.00245397f, -0.11254822f, 
    0.16763245f, -0.04419164f, -0.06012549f, 0.03822402f, -0.04205465f, -0.12034971f, 0.06365971f, -0.00448873f, 
    -0.08779468f, -0.08697889f, 0.01791598f, -0.01168865f, -0.20659645f, -0.06435644f, -0.02547652f, -0.21303917f, 
    0.45008180f, 0.23418283f, 0.20194602f, -0.38781261f, -0.20495126f, 0.00249120f, -0.05914906f, 0.09279142f, 
    -0.05266490f, -0.11579835f, 0.12708297f, -0.06533129f, 0.00819648f, 0.15395913f, 0.00813075f, -0.05190232f, 
    -0.11192288f, 0.03635041f, 0.11828007f, -0.21290433f, 0.15966718f, 0.15084617f, 0.46274772f, 0.17801389f, 
    0.37025088f, -0.08651076f, 0.22758600f, 0.13507821f, 0.27656847f, 0.05055731f, 0.11281093f, -0.09641200f, 
    -0.01328228f, -0.21519183f, -0.04146865f, 0.02631871f, 0.01176274f, 0.07269153f, 0.04110904f, 0.01922957f, 
    0.24198474f, 0.20950352f, -0.09015452f, -0.09602452f, -0.35434937f, 0.20313208f, -0.00365130f, 0.17100322f, 
    0.13658229f, 0.34307989f, 0.04013673f, -0.10985228f, -0.04908496f, 0.02485422f, 0.04811235f, -0.15449291f, 
    -0.03475722f, 0.00606234f, -0.05240400f, -0.03889715f, 0.30953303f, 0.18940005f, -0.04692571f, -0.13433422f, 
    0.25118518f, 0.12942360f, 0.18772304f, 0.03877433f, 0.09358333f, 0.09343754f, 0.13598555f, 0.13888264f, 
    -0.03860563f, 0.05052325f, 0.11453089f, -0.09834764f, -0.12680756f, -0.15666738f, 0.06308635f, 0.07326066f, 
    -0.29576683f, 0.11942745f, -0.11846486f, -0.23040606f, -0.03380725f, -0.06744746f, -0.02785846f, 0.01131218f, 
    -0.00003998f, -0.04264025f, -0.08858366f, 0.07081468f, -0.07293133f, 0.05736729f, 0.07810453f, -0.09830809f, 
    -0.05527230f, -0.03371304f, 0.01150031f, -0.07112779f, 0.39476302f, 0.11225175f, 0.25039119f, 0.11887278f, 
    0.03879151f, -0.02760630f, -0.05334264f, 0.00739185f, 0.00120198f, 0.04955886f, -0.02316801f, 0.01157595f, 
    0.08013964f, -0.01822557f, 0.03588158f, 0.00125655f, -0.00920499f, -0.13545705f, 0.03788000f, -0.11849775f, 
    0.46160042f, -0.01025598f, 0.14847687f, -0.19914463f, 0.13638051f, 0.12060909f, 0.03998829f, 0.20632042f, 
    0.01996375f, -0.09621228f, 0.06145523f, -0.10213193f, -0.00159525f, -0.08809405f, 0.03149927f, 0.07181867f, 
    -0.04270975f, -0.07419217f, -0.08943419f, -0.11958066f, -0.28031421f, 0.00792590f, -0.23377126f, 0.04253419f, 
    0.07937036f, 0.13039824f, -0.14503995f, -0.04494064f, 0.07480568f, -0.29468638f, 0.04155242f, 0.06981591f, 
    0.01119739f, 0.01017332f, -0.05707506f, -0.17984597f, 0.01471518f, 0.03902992f, -0.02137489f, 0.01331999f, 
    0.41606766f, -0.47863477f, -0.05118965f, 0.16915591f, 0.12570365f, 0.05250314f, -0.03556650f, -0.00363939f, 
    0.04199728f, 0.09152140f, 0.00755390f, 0.10322715f, 0.16917931f, 0.05209981f, -0.12154076f, 0.11355700f, 
    0.05410769f, 0.08464132f, -0.16827682f, 0.02459949f, -0.20715418f, -0.02114359f, 0.14267926f, -0.38709447f, 
    0.62004673f, 0.03264394f, -0.00079019f, -0.14091861f, 0.08053656f, 0.00742683f, -0.06900435f, 0.01342628f, 
    -0.00808442f, -0.05717663f, -0.03899309f, 0.13544664f, 0.03449593f, -0.09912895f, 0.16703478f, -0.03936186f, 
    -0.01264871f, 0.30636829f, 0.19693303f, 0.15182672f, 0.12479772f, -0.02290399f, -0.11107442f, -0.05136544f, 
    0.01605639f, 0.01566786f, 0.05061366f, -0.00040376f, 0.03656977f, 0.03791603f, -0.07639190f, 0.01149481f, 
    -0.01781728f, 0.06643921f, 0.02713983f, -0.17393248f, -0.01278910f, -0.16499776f, 0.38029763f, 0.40760750f, 
    -0.24193975f, -0.01606058f, -0.04885897f, -0.09422985f, 0.10363545f, -0.02008047f, 0.04909234f, -0.01923025f, 
    -0.01720403f, -0.02331132f, -0.03458847f, 0.11988784f, -0.12944204f, -0.06120921f, 0.14183876f, 0.02826455f, 
    0.32953149f, 0.12203538f, 0.01451960f, -0.24253885f, 0.21350381f, -0.27807650f, 0.05091836f, 0.12085543f, 
    -0.06236494f, 0.01082801f, -0.02707283f, 0.00696456f, -0.06512935f, -0.06018637f, -0.01326838f, -0.02793451f, 
    -0.13232517f, -0.01532520f, -0.06991321f, -0.11865321f, 0.36216569f, 0.04321650f, 0.27130562f, -0.16931602f, 
    0.08572762f, -0.25436687f, -0.14602020f, 0.08715421f, -0.05733024f, 0.17532624f, 0.02144675f, -0.02446643f, 
    0.12666774f, 0.02083250f, -0.12334163f, -0.03274117f, 0.02827591f, 0.04393347f, 0.00824644f, -0.15852615f, 
    0.14820069f, 0.12937535f, 0.03137039f, -0.26582631f, 0.02435471f, 0.02431056f, 0.08439360f, 0.00194511f, 
    0.01134899f, 0.05523618f, -0.03475638f, -0.05579767f, 0.04894893f, -0.03556057f, 0.02882824f, 0.01404433f, 
    -0.09483232f, 0.16501741f, 0.05210066f, 0.06178127f, 0.31268802f, 0.20690259f, 0.06028765f, -0.07112959f, 
    -0.07577919f, 0.10471793f, 0.10347769f, -0.00453105f, -0.01569706f, -0.00424789f, -0.09121257f, -0.01448850f, 
    -0.05685081f, -0.05681746f, 0.01601028f, -0.11993114f, -0.03814491f, 0.13596042f, 0.03523380f, 0.05229383f, 
    0.14005347f, 0.09286691f, 0.10024780f, 0.00911557f, -0.04818299f, -0.16058894f, -0.05306376f, -0.05633930f, 
    0.06032852f, 0.04823831f, -0.01740447f, -0.03908720f, -0.01563421f, -0.04475173f, -0.00500124f, -0.12386972f, 
    -0.13674153f, -0.07308784f, 0.05117473f, -0.02975505f, 0.50550312f, -0.02715792f, -0.13984635f, 0.28248569f, 
    -0.10624228f, 0.12387672f, 0.12803783f, 0.01598134f, -0.01876913f, -0.09254959f, 0.05514928f, 0.02840415f, 
    0.07712793f, 0.12771709f, 0.07160980f, 0.13816345f, 0.24888986f, 0.03028451f, -0.17106709f, 0.05961664f, 
    -1.00561166f, -0.42443895f, 0.39563465f, -0.25394237f, 0.27480903f, 0.07116436f, 0.03157494f, 0.06798512f, 
    -0.01494215f, -0.06781407f, -0.00376568f, 0.13912307f, 0.14990121f, -0.02650120f, 0.21298003f, 0.22647430f, 
    0.05870308f, -0.14830805f, 0.03510640f, 0.12601519f, 0.14751652f, 0.19648404f, 0.01563166f, 0.13007717f, 
    0.11276268f, -0.03122522f, 0.13316403f, 0.12080347f, -0.02826946f, -0.02876861f, -0.04183353f, 0.00795227f, 
    0.13962798f, 0.10311461f, 0.03324633f, 0.08549891f, 0.14336485f, 0.02934315f, -0.08030932f, -0.07230634f, 
    -0.11289725f, 0.11606415f, -0.22697194f, -0.28299084f, 0.15268478f, -0.08959064f, 0.01974772f, -0.06724232f, 
    0.11209541f, -0.06757818f, 0.04449016f, 0.05205740f, -0.04779558f, 0.04639333f, -0.10084718f, -0.09156352f, 
    0.00061991f, -0.07350827f, 0.14031748f, 0.02134682f, 0.04598466f, -0.03069534f, -0.08892766f, -0.17127538f, 
    0.04856278f, -0.18131578f, -0.03200930f, -0.11169571f, -0.00065346f, 0.01706471f, -0.13262549f, 0.02770510f, 
    -0.03386861f, 0.00884195f, -0.04384830f, -0.21135345f, -0.11475111f, 0.02171618f, 0.06098094f, -0.03238218f, 
    -0.14614420f, -0.44929621f, 0.08333273f, 0.15473649f, -0.21821530f, 0.04335943f, -0.08988477f, -0.03407825f, 
    0.19930294f, -0.08401936f, -0.02599574f, 0.11556942f, -0.12193045f, 0.12207345f, -0.03796011f, -0.29768100f, 
    0.22220537f, -0.27214587f, 0.08201707f, 0.05139899f, 0.12850641f, 0.10808183f, 0.20609082f, -0.05696125f, 
    0.27723855f, -0.06522172f, -0.08444225f, 0.13338087f, 0.09628121f, -0.03777266f, -0.03124972f, -0.06179360f, 
    -0.05112308f, -0.04455155f, 0.03046907f, 0.09186023f, 0.04289583f, 0.02829473f, -0.00877949f, -0.09328291f, 
    0.04431413f, 0.06722699f, -0.03225365f, 0.12123729f, 0.03722097f, 0.02403025f, -0.07916860f, -0.04139068f, 
    0.03118506f, -0.07395577f, -0.08403585f, -0.04513030f, -0.09707603f, 0.15070464f, 0.03218050f, 0.17278273f, 
    0.05210504f, -0.02764379f, 0.06459741f, -0.00751217f, -0.08152892f, -0.09765481f, -0.19247806f, -0.18851596f, 
    0.04112156f, 0.04820205f, 0.03403583f, -0.03949765f, 0.10186387f, -0.13795759f, -0.05192754f, 0.02283734f, 
    0.03537191f, 0.10344043f, -0.05313804f, -0.04642209f, 0.01874120f, 0.00250325f, 0.17496797f, 0.13321802f, 
    0.10854812f, -0.30141351f, -0.14761567f, -0.07082908f, -0.13554895f, 0.10037692f, -0.00961263f, 0.02198788f, 
    0.15942541f, -0.13845827f, -0.05794248f, -0.09604191f, -0.06622849f, 0.07117243f, 0.00776338f, -0.00316944f, 
    0.08502702f, -0.15324500f, 0.07783528f, 0.04610594f, 0.10703047f, 0.00978682f, -0.01783387f, 0.05992647f, 
    0.09520204f, 0.06747547f, 0.05136969f, -0.02471459f, 0.29133564f, 0.03886691f, -0.09170647f, -0.02030944f, 
    0.04909160f, -0.08508144f, 0.13545750f, -0.13335574f, -0.01735469f, -0.05144827f, 0.01634457f, -0.03665187f, 
    0.21637774f, 0.10444941f, 0.05698220f, -0.14717330f, 0.06192179f, -0.00299723f, 0.02160198f, 0.15496123f, 
    0.06033710f, 0.10309085f, -0.00318007f, -0.05441359f, -0.03053019f, 0.00631607f, 0.01640724f, 0.09791096f, 
    -0.03474935f, -0.04998683f, 0.02091678f, -0.13978790f, -0.13983801f, 0.33558398f, 0.18043783f, 0.16821355f, 
    0.03498654f, -0.22766200f, -0.00863579f, 0.02253972f, -0.23809561f, 0.24453816f, -0.01258177f, 0.00590522f, 
    -0.00001006f, 0.00273251f, -0.02349424f, 0.07570592f, 0.11514794f, 0.08774200f, 0.05159434f, 0.05850988f, 
    0.01536629f, 0.14858167f, 0.02421237f, 0.03207311f, -0.01666988f, -0.00940839f, 0.10746823f, 0.27274460f, 
    -0.00210587f, -0.03671892f, 0.01381887f, -0.07989209f, -0.03164968f, 0.04580289f, 0.05534643f, -0.00011910f, 
    0.08658325f, -0.02427083f, 0.07696889f, -0.04657583f, -0.09590512f, 0.16150737f, -0.20266816f, -0.18165345f, 
    -0.01301333f, -0.10853401f, -0.02372045f, 0.03378741f, -0.01212421f, 0.01757546f, -0.02916020f, 0.09760805f, 
    0.02483936f, 0.08976458f, -0.00311484f, -0.08388641f, -0.04474138f, 0.06257451f, -0.03882341f, 0.01525032f, 
    0.05941368f, -0.18178055f, 0.34291667f, -0.11254653f, -0.12814198f, -0.26766124f, -0.10580882f, 0.10657263f, 
    0.03936592f, 0.04655198f, 0.01262785f, 0.13713060f, -0.05701750f, 0.08919786f, 0.18711464f, -0.02907588f, 
    0.10467141f, -0.09602251f, 0.10764813f, -0.10302064f, -0.34298748f, -0.19858661f, -0.09769660f, -0.28722864f, 
    -0.24169441f, 0.08467245f, -0.08233803f, -0.01048205f, -0.04033355f, 0.00799902f, -0.06002802f, -0.00575621f, 
    -0.06595430f, 0.10934553f, 0.09916135f, -0.01312678f, -0.01818915f, -0.04606407f, -0.01789837f, 0.07332462f, 
    0.18682618f, 0.08373433f, 0.19903351f, 0.07025953f, 0.10403421f, -0.07410067f, -0.13044678f, -0.06247464f, 
    -0.06763676f, -0.20458554f, 0.03006159f, 0.03778405f, 0.01600845f, 0.01723045f, 0.05614938f, -0.04299787f, 
    -0.09172717f, -0.17384429f, -0.01998258f, -0.10924534f, -0.03124719f, 0.14815325f, -0.07361110f, -0.07611606f, 
    -0.03464789f, -0.04210997f, 0.07421980f, -0.06020974f, -0.09992438f, -0.10277779f, -0.01526689f, -0.05716414f, 
    -0.02765532f, 0.01069563f, -0.03202314f, -0.00108560f, -0.04441979f, 0.01781909f, -0.07838564f, 0.05164864f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02700949f, -0.02734944f, 0.12033605f, -0.01013484f, 0.14490701f, -0.02287183f, 0.13509014f, -0.02842933f, 
    -0.04286700f, 0.04247571f, -0.01989159f, -0.03439909f, 0.06548720f, 0.10506608f, 0.00154620f, -0.05728104f, 
    0.15331373f, -0.04495241f, -0.00811286f, 0.02098791f, -0.03041897f, -0.01607581f, 0.09668431f, 0.02127495f, 
    -0.02205178f, 0.00369031f, 0.11537219f, 0.08180165f, 0.03705942f, 0.09347792f, -0.08866986f, 0.02857150f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05560124f, 0.01170702f, 0.10585977f, 0.16129383f, -0.35379061f, 0.15034968f, -0.50408250f, -0.03554630f, 
    0.08471156f, 0.30508155f, 0.14091000f, 0.05120254f, -0.34022146f, -0.19444062f, 0.11179253f, 0.20629019f, 
    -0.03657091f, 0.07722070f, -0.05146976f, -0.02219739f, 0.10981727f, -0.14797741f, -0.38213518f, 0.26477900f, 
    -0.07748096f, -0.02755296f, -0.24724776f, -0.34864232f, -0.30921733f, 0.12759176f, 0.31947249f, 0.49185333f, 
    0.09593716f, -0.16910414f, 0.19475906f, -0.05237406f, 0.07058113f, 0.32575372f, -0.23427892f, 0.11822686f, 
    0.13344409f, 0.34902796f, -0.00018444f, 0.00129351f, 0.16614988f, -0.00933731f, -0.38056517f, -0.02892273f, 
    -0.07065409f, -0.13233961f, -0.10507230f, 0.09464779f, -0.04587177f, -0.61779100f, -0.11335289f, 0.14618966f, 
    -0.43774712f, -0.04870930f, 0.24642900f, 0.29393128f, -0.23966154f, 0.05875576f, -0.58920926f, 0.64826816f, 
    -0.13299142f, -0.04049850f, -0.15079476f, 0.02517404f, 0.11220358f, -0.08862966f, 0.27591038f, 0.05359657f, 
    -0.44047293f, -0.32798427f, 0.27005422f, 0.06993987f, 0.20526798f, 0.13947286f, -0.48148420f, -0.09599427f, 
    0.04392268f, -0.10421894f, -0.12754968f, -0.09724556f, -0.15398769f, 0.44167089f, -0.27804098f, 0.03564980f, 
    -0.40887985f, 0.02644752f, 0.01838135f, 0.62530047f, -0.25546607f, -0.14330944f, -0.22183217f, -0.13171676f, 
    0.04655223f, -0.13291332f, -0.23301825f, 0.11119384f, 0.10713167f, 0.16666432f, 0.06809764f, 0.14074516f, 
    -0.07284352f, 0.17560181f, -0.09060746f, 0.13316613f, 0.31137484f, 0.04047181f, -0.04507892f, 0.27417320f, 
    -0.56402647f, 0.05161474f, 0.05012042f, 0.13032773f, 0.11325631f, 0.15818755f, -0.27434447f, -0.49372122f, 
    0.29554436f, 0.12173619f, -0.44635785f, 0.14073358f, 0.29491046f, -0.19029203f, 0.33042902f, -0.40489694f, 
    -0.09707415f, 0.08474805f, 0.24141417f, 0.17495738f, -0.10191806f, -0.22403604f, -0.26704675f, 0.11648959f, 
    0.04616418f, -0.37162960f, 0.04078682f, -0.11921889f, -0.43867305f, 0.21132384f, 0.23271303f, -0.08340352f, 
    -0.19028884f, -0.16058224f, -0.14393507f, 0.07677719f, -0.16688146f, -0.07704112f, 0.17284626f, 0.07169169f, 
    0.08611357f, 0.01728047f, 0.04574943f, 0.17991860f, -0.32088599f, -0.19490892f, 0.25194991f, -0.43369618f, 
    0.00272053f, -0.15404014f, 0.36560756f, -0.08064416f, 0.12810817f, -0.38802382f, 0.22284512f, -0.16311438f, 
    -0.28207701f, 0.18937957f, 0.04741210f, -0.18020260f, -0.28062859f, -0.07847580f, 0.46504146f, 0.20069595f, 
    -0.02286962f, -0.06728253f, -0.11346201f, 0.16373175f, -0.10225752f, -0.63266104f, -0.00418162f, -0.11032842f, 
    -0.28770867f, -0.05805149f, 0.02285756f, -0.08974195f, 0.17999922f, 0.29556087f, -0.32816917f, -0.60147977f, 
    0.09570897f, -0.07766443f, -0.18493325f, 0.05220952f, 0.34806299f, -0.28794652f, -0.01984676f, -0.05027089f, 
    -0.27064291f, -0.64100683f, 0.17831010f, 0.06864566f, 0.08434994f, 0.17431843f, -0.48221025f, -0.37357438f, 
    0.16234291f, -0.10913196f, -0.14817548f, 0.08012215f, 0.02439592f, 0.25621212f, 0.08284919f, -0.41822320f, 
    0.08236684f, 0.16684662f, 0.04281364f, -0.87572604f, -0.03356167f, -0.44938180f, -0.27047849f, 0.37561655f, 
    -0.00669975f, -0.11232822f, -0.33272770f, -0.53139365f, 0.00048486f, 0.20213744f, -0.03194790f, -0.07346408f, 
    -0.11403222f, -0.16280359f, -0.26670745f, -0.12997065f, 0.06376041f, -0.53014493f, 0.48952886f, -0.07407922f, 
    0.11059797f, -0.16251636f, 0.09256876f, -0.07377965f, -0.08291279f, 0.38511047f, 0.28160226f, 0.27876261f, 
    -0.39704061f, 0.03068322f, -0.10504704f, -0.62556273f, 0.02073528f, -0.32252353f, 0.25638297f, -0.49996439f, 
    -0.00299907f, -0.07954296f, -0.65550429f, -0.82703143f, -0.15498179f, 0.19352365f, 0.43529287f, 0.08165473f, 
    0.06265537f, 0.23146506f, -0.27207744f, 0.08620948f, -0.19616583f, -0.04909070f, -0.29652554f, 0.23001112f, 
    0.23942502f, -0.13591480f, 0.02728176f, -0.10522903f, -0.13000289f, -0.33958545f, -0.22429524f, -0.15947416f, 
    0.19710948f, 0.05308314f, 0.08320434f, -0.42065525f, 0.27805492f, -0.21409212f, -0.06464663f, 0.05378360f, 
    0.12071607f, -0.14187874f, -0.09454038f, -0.02548789f, 0.18503664f, 0.00202555f, -0.43547007f, 0.00680922f, 
    0.02027025f, -0.41871160f, -0.03005813f, 0.13583988f, -0.50225258f, 0.41727012f, 0.46904314f, -0.59283781f, 
    0.23740128f, 0.14035513f, 0.03026631f, 0.07952707f, 0.02295852f, 0.19842784f, -0.07409072f, 0.27966225f, 
    0.17723799f, -0.02616142f, -0.23076154f, -0.03235031f, 0.17860827f, 0.13732308f, -0.78801966f, -0.32797208f, 
    0.08633925f, -0.13466428f, 0.05059844f, -0.11201612f, -0.41385028f, 0.23320827f, 0.10726818f, 0.09295100f, 
    0.24687618f, -0.42758575f, -0.43300465f, 0.06563289f, 0.37451640f, 0.42662004f, -0.10074997f, 0.06420408f, 
    -0.01109114f, 0.11013412f, -0.11816148f, 0.08097479f, 0.08170906f, -0.45046535f, -0.10956282f, -0.63177067f, 
    -0.33761132f, 0.16127756f, 0.08049496f, -0.54531735f, -0.19768248f, 0.12849955f, 0.18476678f, -0.13108368f, 
    0.11123440f, 0.08644111f, -0.39592457f, 0.30189869f, 0.05435037f, -0.38012761f, 0.41918588f, -0.03524787f, 
    0.40089604f, -0.35472894f, -0.12492870f, -0.11933250f, 0.21327370f, -0.52844864f, -0.39077723f, -0.19672303f, 
    -0.09439267f, 0.10147131f, 0.16564766f, -0.14535141f, -0.04920416f, -0.16478272f, 0.04422683f, -0.40224430f, 
    0.34708422f, -0.07886478f, 0.02709110f, -0.22127765f, 0.11232590f, 0.40680727f, -0.33861804f, -0.18618158f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.37743500f, 0.15322769f, -0.00393892f, 0.00207839f, 0.08804866f, 0.17334457f, 0.15308443f, 0.03153771f, 
    -0.08236804f, -0.00727623f, 0.14578979f, 0.16276650f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
