#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.95276886f, 0.04641666f, -1.48393059f, 1.03697896f, -0.64072245f, -1.07778752f, -0.56741738f, 0.04018778f, 
    0.51417726f, -1.50186658f, 0.73576152f, -0.00650773f, -0.48814276f, 1.34283161f, 0.82347476f, 0.12040626f, 
    0.10999337f, 0.76984829f, -1.26414049f, -1.61039507f, -1.27557325f, -0.91930944f, -0.00865944f, 0.28364572f, 
    0.56232888f, 0.15067112f, 0.05359242f, -0.06110958f, -1.64724708f, 1.29635048f, -1.01201129f, -0.91941190f, 
    0.03393012f, 0.41012579f, -0.01518715f, -0.48160994f, -0.46220583f, -0.91296071f, -0.52781671f, 0.62433153f, 
    1.73476005f, -0.91394854f, 0.28974649f, 0.06451721f, -0.44809246f, -1.27033019f, -0.47005478f, 1.55553019f, 
    -0.32842925f, -0.29683712f, 0.91933155f, -0.61798251f, -0.41760275f, -0.20433645f, 1.37194884f, 1.52490437f, 
    0.08514406f, -0.63107258f, 0.91110474f, 1.26700926f, -0.50671017f, 0.09993604f, -0.10652434f, -1.22792304f, 
    -1.01988566f, 0.09499057f, 0.52282894f, -0.91206199f, 0.81516230f, 0.64798051f, -0.29362887f, 0.65993202f, 
    -0.35768858f, -0.99678218f, -0.84561056f, -0.94761890f, -0.90708292f, -0.04794972f, -0.86665535f, -0.51654822f, 
    -0.63837391f, 0.54310650f, 1.87523484f, 1.69024563f, -0.93794632f, 0.91181296f, -1.07347393f, -0.02617302f, 
    0.19534500f, 0.11499199f, -1.15694749f, -1.37140656f, -0.74705744f, 0.76012766f, 1.32987833f, 0.87404048f, 
    -0.79098451f, -0.58023638f, -0.06498445f, -0.33019137f, 1.61736834f, 1.27551389f, 1.11310434f, -0.23174286f, 
    0.67367965f, -0.75916260f, -0.35146499f, -0.15949273f, 0.77488244f, -0.62428784f, 0.46577078f, 0.76989430f, 
    -1.67592478f, -1.36679292f, 0.53011256f, 0.11508717f, 0.39527783f, 0.10507410f, 0.83999497f, 1.23007941f, 
    -1.38418090f, 0.44790763f, 0.82614094f, 0.91614133f, 0.40556592f, 0.11814994f, 1.60169709f, -0.44965354f, 
    -1.02569067f, -1.04203403f, -0.99873221f, -0.59223795f, -0.81133205f, -0.16548686f, -0.17364167f, 0.79493308f, 
    -0.84699398f, -1.66705966f, -0.92359489f, 1.16884553f, 0.78494477f, 0.33022124f, 0.18989128f, -0.04254363f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05033327f, 0.10445525f, 0.35772860f, 0.43933934f, 0.31115544f, 0.26575816f, 0.43576613f, 0.34732896f, 
    -0.01366902f, 0.27865863f, 0.27964291f, 0.27391067f, 0.15523165f, 0.24844022f, 0.08651634f, 0.02531956f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.57409000f, -0.39299962f, -0.20477372f, 0.02186734f, 0.02171024f, 0.21708186f, -0.12965646f, 0.01189500f, 
    -0.06558544f, 0.08869667f, 0.10356230f, -0.10194936f, -0.21871379f, 0.05137952f, -0.04709464f, 0.02613180f, 
    -0.06385276f, 0.01488664f, -0.19164436f, -0.18169092f, 0.23413551f, 0.21651241f, 0.07593463f, -0.14893928f, 
    -0.12616271f, 0.10135795f, -0.04009942f, -0.01409824f, 0.05222954f, -0.16432559f, 0.08471198f, -0.09234039f, 
    0.07778133f, 0.30055824f, 0.15708123f, 0.01683248f, -0.02894819f, -0.10517558f, 0.14326407f, -0.18043827f, 
    -0.51453537f, -0.03894503f, -0.58438265f, 0.09582984f, -0.37311354f, -0.21804287f, -0.07548091f, 0.12972456f, 
    0.17397445f, 0.05119831f, -0.06102540f, -0.03370331f, -0.15541121f, 0.00553832f, 0.10535987f, 0.04148214f, 
    -0.07233208f, -0.18539822f, 0.07401247f, 0.02743750f, 0.02349145f, -0.36646527f, -0.33740407f, 0.10509610f, 
    -0.71814466f, -0.13915549f, 0.02416668f, 0.07269146f, -0.05837016f, 0.10588269f, -0.05162131f, 0.17853591f, 
    -0.10750408f, -0.05296697f, -0.04762071f, -0.14651063f, -0.03102048f, 0.02966473f, 0.12282828f, 0.16372015f, 
    0.16553217f, 0.47774160f, 0.35027397f, -0.29388461f, -0.25499254f, -0.13280851f, 0.05059608f, -0.01751295f, 
    0.02582983f, -0.18931235f, 0.02862727f, 0.08878656f, 0.06693102f, 0.00613742f, -0.02384751f, 0.21666828f, 
    0.12646540f, 0.15347570f, -0.01747521f, -0.05374952f, -0.63653064f, 0.21244696f, -0.06858953f, 0.46999556f, 
    -0.15537654f, -0.10780046f, -0.04240207f, 0.19179361f, 0.07918195f, 0.08229719f, 0.13361812f, 0.07436899f, 
    -0.04679154f, -0.14545229f, -0.17724539f, 0.04128763f, -0.03655532f, -0.10962136f, 0.23940626f, 0.08088660f, 
    0.24877162f, 0.07923030f, -0.14189313f, -0.20520379f, 0.50076777f, -0.38495860f, -0.11096410f, -0.18016265f, 
    0.06371430f, -0.06169640f, -0.08266757f, 0.00599640f, 0.21189246f, -0.04987984f, -0.02776502f, 0.02124003f, 
    0.24399850f, -0.13546586f, 0.01810966f, 0.03733846f, -0.31682375f, -0.42717147f, -0.06404909f, 0.05324921f, 
    -0.17447388f, 0.06911651f, 0.29253358f, -0.16683947f, -0.00672004f, 0.18912670f, -0.03682029f, -0.05868915f, 
    0.05210898f, -0.09443590f, 0.13951989f, -0.16938446f, 0.12413729f, 0.10554654f, -0.00966485f, -0.14341463f, 
    0.05516481f, -0.53175032f, -0.11474918f, 0.27041849f, -0.13329704f, 0.06155980f, -0.02485451f, -0.35691294f, 
    -0.03277661f, -0.02569682f, 0.10515545f, -0.16243762f, 0.09536499f, 0.04045657f, -0.12799399f, 0.02243020f, 
    -0.03544952f, 0.05393628f, -0.09763214f, -0.08451269f, 0.09899843f, 0.13180514f, -0.16505376f, -0.20322444f, 
    -0.03707770f, -0.31620228f, -0.08665244f, 0.03174095f, 0.11213481f, 0.07650985f, -0.04446812f, 0.05387479f, 
    0.01489184f, -0.01419002f, -0.09642387f, -0.01182738f, 0.08347075f, 0.11907571f, -0.03760302f, -0.23882592f, 
    0.10550165f, 0.44104758f, 0.21145377f, -0.14536044f, -0.52933657f, 0.15672529f, 0.21942171f, -0.16139226f, 
    0.05843556f, -0.22258498f, 0.01118389f, 0.05973896f, 0.02578769f, 0.07869360f, 0.07694358f, -0.02570784f, 
    0.11977164f, -0.07522767f, 0.07542056f, 0.14568257f, -0.07528985f, 0.17316756f, 0.33390820f, 0.15130317f, 
    0.36860448f, -0.25115737f, -0.19814973f, 0.24284758f, 0.08510100f, 0.06367814f, 0.10844333f, -0.19678427f, 
    -0.12184141f, 0.08631841f, 0.02530153f, 0.05698502f, 0.06112542f, -0.05248540f, -0.08674568f, 0.04528626f, 
    -0.01410337f, -0.43538821f, 0.34418154f, 0.04319436f, -0.01883363f, -0.09990276f, -0.09350625f, 0.03127691f, 
    -0.18217756f, 0.10155923f, -0.27722737f, -0.05120983f, -0.02107703f, 0.02431634f, -0.08810171f, 0.20306711f, 
    0.08298251f, 0.11592124f, 0.10503800f, -0.23968624f, -0.24131311f, 0.05113505f, -0.24525672f, 0.02127875f, 
    0.24139358f, 0.10034262f, -0.29320139f, -0.07612202f, -0.12616116f, 0.08702478f, -0.06565477f, -0.25813720f, 
    0.22121322f, -0.01961902f, 0.08631212f, -0.16670386f, -0.04681394f, -0.04098187f, -0.12146286f, -0.11371538f, 
    0.36834317f, -0.36325848f, 0.39035469f, 0.20007513f, 0.27545589f, 0.00049963f, -0.07688861f, -0.18380854f, 
    0.09635752f, -0.01735429f, -0.14078158f, -0.06401334f, 0.19209179f, 0.10048642f, -0.00736906f, -0.08869888f, 
    0.00158877f, -0.09024055f, 0.13648282f, -0.22692086f, -0.67522299f, 0.31160516f, -0.01970339f, 0.00051683f, 
    -0.07887628f, -0.20136237f, 0.00926865f, 0.06272945f, -0.26836884f, 0.23998822f, 0.00574626f, 0.01398582f, 
    0.07016277f, 0.09022877f, -0.01387485f, -0.13809450f, -0.03846753f, -0.00110925f, -0.11074932f, -0.06348065f, 
    -0.47113112f, 0.00679843f, -0.06315535f, -0.17438973f, 0.09921089f, 0.10973278f, -0.19598834f, 0.01995503f, 
    -0.10457242f, -0.14617413f, 0.08686545f, -0.05536441f, 0.03870190f, -0.12562956f, 0.19376086f, -0.07032921f, 
    0.14490092f, -0.30506375f, -0.06380589f, -0.22603367f, -0.23859346f, 0.31182688f, -0.14832409f, -0.25781095f, 
    -0.00907428f, -0.14505145f, 0.22746438f, -0.11027215f, -0.01381145f, -0.02348342f, -0.06769568f, -0.14202636f, 
    0.03483800f, -0.26287499f, 0.11676943f, 0.17564783f, -0.10024647f, 0.01992041f, -0.04289560f, 0.19456965f, 
    0.41413099f, 0.08763050f, 0.01210514f, 0.22913828f, -0.18710746f, 0.12625484f, 0.08182145f, 0.05248461f, 
    0.13832814f, 0.15835550f, 0.10640315f, -0.20452920f, 0.11442960f, 0.22436261f, -0.06392218f, 0.14534256f, 
    0.14605162f, 0.04615415f, -0.16338408f, -0.03403674f, -0.90931785f, 0.19347888f, -0.05293250f, -0.06934804f, 
    -0.47353894f, -0.04263460f, 0.05934159f, 0.04215175f, 0.16439873f, 0.09728722f, -0.00595361f, -0.09334838f, 
    0.04117569f, -0.00533464f, 0.01202028f, 0.05932404f, -0.15446377f, -0.12642796f, -0.12770469f, -0.06965262f, 
    0.02947352f, -0.49132869f, -0.43790117f, -0.02563266f, -0.11406475f, -0.07079616f, -0.15039971f, -0.09619734f, 
    -0.00376917f, 0.21780688f, -0.07830450f, 0.06139798f, -0.09782661f, -0.07217540f, -0.01671424f, 0.01147294f, 
    0.02319153f, -0.14938296f, -0.03145711f, -0.03182622f, -0.39169881f, 0.16320972f, -0.17738168f, -0.37111649f, 
    -0.62009668f, -0.10544468f, 0.00383981f, -0.08285819f, -0.16313978f, 0.06460639f, -0.12195068f, 0.01986106f, 
    -0.11288029f, -0.06353120f, -0.19585906f, 0.02306459f, -0.22601014f, 0.13600767f, 0.03274890f, 0.03134780f, 
    0.48600367f, 0.45037320f, 0.15554094f, 0.15925646f, 0.14037943f, 0.01008803f, -0.21309152f, -0.02698423f, 
    0.07617264f, -0.04356109f, -0.03831061f, -0.02593226f, -0.13761456f, 0.26086327f, -0.10468590f, -0.02751982f, 
    -0.08142732f, 0.23836477f, -0.04264977f, -0.17924316f, -0.05118751f, 0.46065703f, 0.06114120f, 0.19032623f, 
    -0.25951701f, 0.10189152f, -0.16633154f, 0.17465174f, 0.01891383f, 0.14386322f, 0.26492187f, -0.05985516f, 
    0.02355522f, 0.11593339f, -0.05136827f, 0.22092471f, 0.11727184f, -0.13642253f, 0.15723149f, 0.46098459f, 
    -0.19308794f, -0.15002449f, -0.20270102f, -0.55615634f, 0.05537025f, -0.06630742f, 0.07359792f, 0.12429889f, 
    0.03841039f, 0.16529873f, -0.02840251f, -0.01837934f, 0.06118541f, 0.18003821f, -0.24789837f, -0.21179809f, 
    -0.03769568f, -0.21078360f, -0.19005552f, -0.26082560f, 0.08062574f, 0.29056811f, 0.00059180f, -0.09408000f, 
    0.48782095f, -0.19389823f, -0.05551204f, 0.04379755f, 0.06045927f, 0.11562945f, 0.15016049f, -0.19643675f, 
    0.20889385f, 0.06110070f, -0.01002280f, -0.10926989f, 0.25386900f, -0.00184801f, -0.15056430f, 0.02409697f, 
    0.18274844f, 0.07804219f, -0.28354770f, 0.03961187f, -0.34781316f, 0.09018190f, 0.03695475f, -0.08565355f, 
    -0.07623975f, 0.03143045f, 0.16302086f, 0.24272096f, -0.14648126f, -0.00054555f, 0.02005764f, 0.09605664f, 
    -0.00877342f, -0.03935039f, -0.05489203f, 0.06387709f, 0.40424663f, 0.20529476f, -0.08927932f, -0.03572430f, 
    0.56133604f, -0.08997609f, -0.09808938f, 0.03775323f, -0.13664605f, 0.13880153f, 0.03320136f, 0.16205239f, 
    0.15660064f, -0.07704249f, 0.09757052f, 0.04907746f, -0.14457180f, 0.06787956f, 0.07320294f, 0.02410436f, 
    -0.25078565f, -0.17067838f, 0.05399622f, -0.12043952f, 0.02780582f, 0.05793732f, 0.13644701f, 0.24685249f, 
    -0.09453910f, -0.07913464f, 0.14038196f, -0.00834483f, 0.22559920f, 0.09979396f, -0.11926859f, -0.05124877f, 
    -0.01492337f, -0.35531253f, 0.02667475f, 0.04436508f, -0.26974097f, 0.30043992f, -0.01297480f, -0.05990585f, 
    0.03130027f, -0.12860171f, -0.00736972f, -0.13955259f, 0.10163897f, 0.02958363f, -0.01432433f, -0.03030286f, 
    -0.06089690f, -0.01987186f, -0.11190184f, 0.03052573f, -0.12971421f, 0.18963438f, -0.08842611f, -0.04487391f, 
    0.27660930f, -0.56144470f, 0.05619231f, -0.58437115f, -0.04994281f, -0.03105501f, -0.03922816f, 0.17575289f, 
    0.05966968f, -0.08800392f, -0.23966485f, 0.05143368f, -0.11821764f, 0.04132979f, -0.12927252f, -0.11121394f, 
    -0.28962862f, -0.25669506f, -0.10755497f, -0.12478943f, 0.45434561f, -0.95770490f, -0.00999334f, 0.03238472f, 
    -0.05027915f, -0.22247553f, 0.00156768f, 0.03443485f, 0.03080072f, -0.04103032f, -0.08718186f, -0.08481797f, 
    -0.09385213f, -0.04955574f, 0.16008757f, 0.05972311f, -0.02286713f, 0.12559642f, -0.08632731f, 0.03815680f, 
    -0.27127990f, -0.38976291f, 0.19226593f, -0.38637131f, -0.04101040f, 0.15409672f, -0.08757479f, -0.19586286f, 
    0.08483573f, -0.05863845f, -0.09950746f, 0.01261463f, -0.11078038f, 0.08516734f, -0.06750953f, -0.03903731f, 
    -0.05603255f, 0.14282247f, 0.08933431f, 0.09751023f, 0.28194261f, 0.12356059f, -0.06372096f, 0.05298025f, 
    0.05845819f, -0.10731346f, 0.03309400f, -0.22302628f, 0.03599518f, 0.06418920f, 0.06635261f, -0.12279893f, 
    0.12138552f, -0.07434329f, -0.04139849f, 0.04427518f, -0.20046917f, -0.10023026f, 0.15960988f, 0.08576560f, 
    0.83615738f, -0.76460904f, 0.07262957f, 0.05407728f, -0.18110566f, -0.15907666f, 0.07597025f, -0.09371425f, 
    -0.13236795f, -0.05566861f, 0.06549879f, -0.12011881f, -0.01442587f, -0.11868788f, -0.02883680f, 0.07130298f, 
    -0.01833080f, 0.12568681f, 0.09892264f, 0.09438295f, 0.26208219f, 0.05557132f, -0.51610655f, -0.05178013f, 
    -0.40225297f, -0.17891750f, 0.21018201f, -0.12212665f, 0.07001025f, -0.19008042f, -0.00658953f, -0.17802271f, 
    0.03734226f, -0.04707258f, -0.05750500f, 0.02802774f, -0.05262376f, -0.02640160f, 0.05004061f, -0.12263218f, 
    0.61758566f, -0.43841043f, 0.40836081f, -0.35150194f, 0.25600860f, -0.15098481f, -0.05763404f, -0.07276807f, 
    -0.04288075f, 0.07006733f, 0.19609180f, -0.13567962f, 0.09075405f, 0.02640201f, 0.04949700f, 0.08603328f, 
    -0.30869827f, 0.05734166f, 0.08343043f, -0.09985062f, -0.06527706f, 0.07008929f, -0.46572641f, 0.00471008f, 
    -0.19974691f, -0.09460330f, -0.11861621f, 0.22122125f, 0.10899768f, -0.15581796f, 0.06471562f, 0.04433548f, 
    0.10503937f, -0.07209197f, 0.02943544f, -0.17933743f, -0.02260436f, -0.04055279f, -0.10874056f, 0.01200149f, 
    -0.04932799f, -0.00094036f, -0.17348833f, -0.03885744f, 0.01798081f, 0.13393615f, -0.04962573f, 0.26017880f, 
    -0.03267968f, -0.05555227f, -0.13627458f, 0.03610326f, 0.19769771f, 0.20879287f, -0.07452995f, -0.11901031f, 
    -0.02656575f, 0.06283590f, -0.07871431f, 0.03485435f, -0.20849323f, 0.15645093f, 0.07993168f, -0.07064503f, 
    0.15051131f, -0.28379455f, 0.03262832f, -0.28140059f, -0.05488635f, -0.06887363f, 0.00656849f, -0.01328181f, 
    -0.05657385f, -0.18375997f, 0.06280080f, 0.01213513f, -0.00511013f, 0.16465373f, 0.03947562f, 0.03410067f, 
    0.33278888f, -0.53116214f, -0.32931659f, 0.14837860f, -0.78202182f, -0.08989801f, 0.02081244f, -0.11365863f, 
    0.07328560f, -0.12196881f, 0.01119717f, -0.02128979f, 0.09478993f, 0.13987587f, -0.13672887f, -0.09010509f, 
    -0.23364209f, 0.00011235f, 0.02624931f, -0.20119631f, 0.18002042f, 0.38031554f, -0.21945801f, -0.12853959f, 
    0.20577504f, 0.08128248f, 0.25958663f, 0.04228031f, -0.22618395f, -0.20815468f, -0.10111872f, -0.02690974f, 
    -0.12040485f, -0.25443950f, -0.06599452f, 0.00535405f, -0.09111485f, -0.11888345f, -0.10889661f, -0.03093672f, 
    0.18482064f, 0.02311071f, 0.25986516f, 0.16126364f, 0.50178176f, -0.23063709f, -0.13443890f, -0.16177981f, 
    0.13064696f, 0.18808085f, 0.24782152f, 0.01621729f, -0.08556050f, -0.01893468f, -0.09801762f, -0.20051372f, 
    -0.05330231f, -0.19335917f, -0.11327379f, -0.19706362f, 0.15756977f, -0.16470595f, -0.12405153f, -0.08342757f, 
    -0.05381903f, 0.06013053f, 0.14966403f, 0.01886851f, -0.09081167f, 0.06163390f, -0.07810868f, 0.15414195f, 
    -0.06620441f, 0.11667524f, -0.06447348f, -0.01118633f, 0.05172653f, 0.05807540f, -0.24578382f, 0.07989437f, 
    -0.32096487f, -0.32148620f, 0.01332745f, -0.21444032f, -0.21257921f, 0.10174499f, 0.13435435f, -0.05462557f, 
    0.07716990f, 0.02200261f, -0.14197516f, -0.03831029f, 0.05005764f, -0.20512213f, 0.03161240f, 0.15606505f, 
    -0.00911742f, 0.06428661f, -0.06091610f, 0.17450349f, 0.27673638f, 0.33945999f, -0.28310457f, 0.07986623f, 
    -0.01820792f, 0.02949556f, 0.03082860f, 0.16334964f, -0.11087818f, -0.36868438f, -0.11198673f, 0.09728155f, 
    0.00910330f, 0.06760615f, -0.08235861f, 0.00379513f, -0.13015351f, -0.21036802f, 0.01387141f, -0.01794499f, 
    -0.45561641f, -0.11547063f, -0.35934493f, -0.19812690f, -0.46362287f, 0.11186942f, 0.07241741f, 0.20931344f, 
    0.22273421f, 0.11304482f, -0.05758139f, 0.02059333f, -0.07603340f, -0.11400934f, -0.21316744f, 0.03387419f, 
    -0.01452237f, 0.20655958f, 0.10471429f, -0.10811272f, 0.60792786f, 0.08371142f, 0.06627722f, 0.12451991f, 
    -0.22215517f, -0.15120335f, 0.04973109f, 0.14895768f, 0.12451980f, 0.16356321f, 0.06608370f, -0.05758603f, 
    0.11147037f, 0.04550369f, -0.03079211f, 0.00020790f, -0.16291954f, 0.02955137f, 0.11147707f, 0.08728957f, 
    0.40954095f, 0.27556530f, -0.32846919f, 0.04563495f, 0.08810084f, -0.02952519f, -0.07232485f, -0.07190041f, 
    0.21898717f, 0.14192267f, -0.15793367f, -0.07350320f, -0.09684363f, -0.08477952f, 0.10494296f, 0.00284671f, 
    -0.11597451f, 0.10096083f, 0.00299483f, 0.02891030f, -0.68228638f, 0.33220232f, 0.16829032f, -0.27512693f, 
    -0.33816946f, 0.08890526f, -0.09522796f, -0.00962209f, 0.04995538f, -0.05975975f, 0.01267171f, 0.09045327f, 
    -0.16705567f, 0.12269022f, -0.01755470f, 0.03861711f, 0.04425885f, -0.03936656f, 0.19848610f, -0.12729123f, 
    -0.08103699f, -0.05238589f, -0.05816520f, -0.11218797f, -0.04160851f, -0.18736358f, -0.23413692f, -0.03339215f, 
    -0.20090023f, -0.15262903f, -0.10874133f, -0.01921310f, 0.01499077f, 0.01248140f, 0.17283192f, -0.11349794f, 
    0.13635981f, 0.08920570f, 0.06089924f, -0.06167321f, 0.14510648f, 0.27018461f, 0.21022287f, 0.28275383f, 
    0.08443495f, -0.05979822f, 0.11992144f, 0.08214256f, -0.12568220f, -0.04598898f, -0.03630303f, 0.17739853f, 
    -0.06640470f, -0.04024877f, 0.00561229f, 0.04860341f, 0.07531635f, -0.18059108f, 0.19977047f, -0.19114706f, 
    -0.39885581f, 0.12138471f, -0.28177801f, 0.11496853f, 0.10045718f, 0.04359877f, -0.14209251f, 0.05508544f, 
    0.10046629f, -0.10981665f, -0.01293489f, -0.13502879f, -0.04721855f, 0.13604884f, -0.16693178f, -0.03679952f, 
    0.03443828f, -0.07011213f, 0.15048327f, 0.02235480f, 0.07092310f, -0.22069331f, 0.24449240f, -0.08347801f, 
    0.16393945f, -0.01885021f, 0.04881389f, 0.12664247f, 0.04722934f, -0.01508367f, -0.00079584f, 0.01537935f, 
    0.05602542f, -0.01125613f, -0.04556126f, -0.02566506f, 0.04928559f, -0.00530981f, -0.02049417f, 0.05072670f, 
    -0.18270205f, -0.64007860f, -0.13304587f, -0.41216075f, 0.04869884f, -0.23842490f, 0.19436990f, -0.09573426f, 
    -0.01702579f, -0.07267746f, -0.09210613f, 0.09321994f, 0.01225348f, 0.03469978f, 0.06415915f, -0.10010893f, 
    -0.11833405f, -0.18838571f, -0.07376567f, 0.07835183f, 0.24565069f, 0.18705457f, -0.06657624f, -0.13960695f, 
    -0.05281899f, -0.19325656f, -0.04272379f, -0.01535464f, -0.00805569f, -0.04550986f, -0.06605633f, -0.02147700f, 
    0.13449492f, 0.14033048f, -0.14487034f, -0.13679729f, -0.06804796f, -0.09019437f, -0.07996818f, -0.01788737f, 
    0.05008088f, 0.14257590f, 0.21128954f, 0.39405638f, -0.04061047f, -0.02281914f, -0.02526226f, 0.14440078f, 
    -0.18634938f, -0.11722188f, -0.16160476f, -0.12478847f, -0.10264941f, -0.11197492f, 0.18015739f, 0.04548448f, 
    0.11178542f, 0.23754886f, 0.08823208f, 0.04239609f, -0.51964682f, 0.03516969f, -0.23354891f, 0.30447522f, 
    0.35268828f, -0.05188385f, 0.18320575f, 0.05264147f, 0.07758694f, -0.03356941f, -0.06499766f, 0.06164792f, 
    0.06027763f, -0.02312655f, -0.03773490f, -0.04212260f, 0.05286331f, -0.01046672f, -0.05727846f, 0.06555290f, 
    -0.09457049f, -0.28419584f, -0.12711707f, -0.13055155f, -0.26010489f, -0.13052677f, -0.28034857f, 0.11709633f, 
    -0.02608757f, 0.14151871f, -0.01756773f, -0.05860285f, 0.08893661f, -0.20670955f, 0.00635393f, 0.07715770f, 
    -0.01656054f, 0.21899790f, 0.03233638f, -0.00719880f, -0.27333790f, -0.84443825f, -0.38710174f, 0.13080367f, 
    -0.10593031f, -0.16927673f, -0.10053515f, 0.00020513f, 0.13750529f, -0.04368361f, -0.02101454f, 0.02680961f, 
    -0.03945735f, 0.15317321f, -0.03939569f, 0.07248591f, 0.04566317f, -0.02897854f, 0.17101841f, 0.03223147f, 
    0.24537419f, 0.27859819f, -0.06906650f, 0.30439088f, -0.00542712f, 0.15962383f, 0.29169655f, -0.05425125f, 
    0.07530055f, -0.07302216f, 0.00972922f, 0.11844810f, -0.19122095f, -0.12940997f, -0.04015925f, -0.09142520f, 
    0.24494572f, 0.08945125f, -0.02354882f, -0.03061675f, -1.09234154f, -0.13079208f, -0.01539791f, 0.14123188f, 
    0.21975620f, 0.00168053f, 0.05861544f, 0.01622069f, -0.02196804f, -0.27983767f, -0.16926855f, 0.06260059f, 
    -0.15125351f, -0.13269016f, 0.17463773f, -0.08248378f, 0.19717164f, -0.16415414f, 0.07758477f, -0.12069761f, 
    0.26699319f, 0.09483302f, 0.33448192f, 0.01248316f, 0.31938797f, 0.15127718f, 0.20024347f, 0.01165371f, 
    -0.10238864f, 0.02509524f, 0.13144243f, 0.04224304f, -0.09535003f, -0.13208511f, -0.06788612f, 0.10724685f, 
    -0.03076675f, 0.00930921f, 0.17813160f, 0.06944437f, 0.12452874f, -0.43216777f, -0.00413115f, 0.04491351f, 
    -0.26136863f, -0.06851587f, -0.28490883f, 0.03640618f, -0.11198764f, -0.07511617f, -0.03945223f, 0.10071997f, 
    -0.22228554f, 0.07856862f, 0.07543120f, 0.05541734f, -0.01133693f, -0.05852069f, -0.00498791f, 0.04480676f, 
    -0.16247326f, -0.12644626f, 0.17350805f, -0.07475033f, -0.16982174f, -0.09750770f, 0.12413275f, -0.04204025f, 
    -0.04594005f, 0.11234840f, 0.03763518f, -0.04262197f, 0.05638451f, 0.09444450f, 0.09726718f, 0.04500645f, 
    -0.02870830f, 0.07388349f, -0.02315926f, 0.21876159f, -0.31993070f, 0.08904271f, -0.19051594f, -0.00308111f, 
    0.11262385f, 0.03507372f, 0.17793886f, 0.04646165f, 0.00818064f, -0.00976197f, -0.15319075f, -0.10156366f, 
    -0.14564282f, 0.12463511f, -0.00755053f, 0.08117195f, 0.15357889f, -0.12018249f, -0.06284611f, -0.28168222f, 
    -0.49698448f, 0.11463920f, -0.16536897f, 0.12145814f, 0.28019473f, 0.19328737f, 0.09731900f, 0.00487334f, 
    0.24562773f, 0.13626929f, 0.07522930f, 0.14310601f, 0.00087579f, -0.10075440f, -0.11082142f, -0.00992749f, 
    0.04003375f, 0.08867405f, 0.00152289f, -0.29431075f, -0.27790213f, -0.32665950f, 0.29087675f, -0.07885671f, 
    0.07211134f, 0.17626938f, -0.18389331f, -0.08323026f, -0.18571986f, 0.01489271f, -0.00610055f, 0.05160875f, 
    0.04731106f, -0.08336575f, -0.01499183f, -0.06211958f, 0.06048103f, 0.05489994f, 0.04632160f, 0.03381256f, 
    -0.87003398f, 0.04655822f, 0.19072491f, -0.12359931f, -0.00500873f, 0.01969643f, -0.10182780f, -0.03371233f, 
    -0.04909200f, -0.14464776f, -0.13282399f, 0.04943644f, -0.00174379f, 0.03745382f, 0.16158628f, -0.12061275f, 
    0.04222346f, 0.06672166f, 0.01046476f, -0.06009826f, 0.44494465f, 0.04881016f, 0.00519563f, -0.35606131f, 
    0.11461951f, -0.30011678f, 0.03667931f, 0.09472249f, 0.08994851f, -0.21633075f, 0.07917804f, -0.10299383f, 
    -0.05720690f, 0.12640171f, 0.02717045f, -0.17995021f, 0.06756226f, -0.05100844f, -0.07916644f, -0.00567119f, 
    0.22861618f, -0.35486633f, 0.34591991f, -0.01523960f, -0.17756617f, -0.00936988f, -0.02541961f, 0.04841336f, 
    -0.00197926f, 0.01514094f, 0.10418662f, -0.06331005f, -0.00969432f, -0.11342194f, 0.01839269f, 0.12597090f, 
    0.00181154f, -0.03188901f, 0.04333799f, -0.07587264f, 0.19272177f, 0.30388415f, -0.18303289f, -0.12418421f, 
    0.29775575f, 0.12456976f, -0.00714353f, -0.01069259f, 0.08360621f, -0.15278897f, 0.04980440f, -0.03758041f, 
    -0.15423819f, -0.14517114f, -0.06919111f, 0.04111236f, -0.22698379f, -0.27921703f, -0.05950040f, 0.00616135f, 
    -0.23955210f, -0.12544301f, -0.13992453f, 0.22220062f, 0.07591549f, 0.09852021f, -0.00363950f, 0.10209290f, 
    0.19674970f, 0.01219859f, 0.17254098f, 0.03442342f, -0.10931944f, 0.03128846f, 0.18082316f, 0.02673611f, 
    0.06571269f, 0.12981430f, 0.30373943f, -0.01157126f, -1.19983590f, 0.17364995f, 0.12780422f, 0.24599481f, 
    -0.03289549f, -0.12053153f, -0.11562607f, -0.00705883f, -0.01697885f, -0.00021480f, 0.06390352f, -0.03110105f, 
    -0.08105578f, -0.21724975f, 0.05436052f, 0.11656922f, 0.06255305f, -0.07497247f, -0.01111984f, 0.13163556f, 
    -1.01209569f, -0.21817280f, -0.13457701f, 0.16269504f, 0.36357674f, 0.06108900f, -0.09274923f, 0.20735419f, 
    0.09392647f, 0.18897967f, -0.02226567f, -0.19562978f, 0.20510605f, 0.02964203f, 0.16132393f, -0.01545433f, 
    0.12198519f, 0.14502001f, 0.15865037f, -0.01273317f, 0.51612431f, 0.24158953f, -0.11616282f, -0.09830087f, 
    0.05281192f, 0.11963223f, -0.02195281f, 0.03502066f, 0.08066969f, 0.13175909f, -0.06146045f, 0.10205385f, 
    0.16508198f, 0.18627739f, -0.12962504f, -0.08232579f, 0.13526563f, -0.06247383f, 0.04068543f, 0.08748938f, 
    -0.24545221f, -0.08671843f, 0.46240515f, 0.07825521f, -0.23501131f, -0.08436292f, 0.14692867f, -0.22948906f, 
    -0.14815910f, -0.15597834f, -0.06002652f, -0.19302845f, -0.18245736f, 0.09280907f, 0.08185305f, -0.30258095f, 
    -0.11520907f, -0.01043247f, -0.11370072f, 0.05889465f, -0.41077435f, -0.41595450f, -0.22198039f, 0.15359885f, 
    0.08060110f, -0.02319386f, -0.04250185f, 0.19012861f, -0.04639323f, -0.01731721f, -0.05178723f, 0.14028652f, 
    -0.25389078f, 0.03014596f, 0.02060466f, -0.05375570f, -0.07032464f, -0.19868071f, 0.04459169f, -0.01338257f, 
    0.02235320f, 0.09925321f, -0.37722445f, 0.41553903f, -0.28323594f, -0.22382906f, -0.05992398f, -0.02401210f, 
    -0.09723718f, -0.00898582f, 0.03729939f, 0.17357430f, -0.00321616f, -0.03981385f, 0.06608116f, 0.08596428f, 
    0.10881931f, 0.07417285f, 0.13920578f, 0.00720082f, -0.08643612f, 0.39380220f, -0.09389209f, -0.16443057f, 
    0.00658344f, 0.11901077f, 0.12667421f, -0.11996830f, -0.01936404f, 0.07281950f, -0.08126505f, 0.01170724f, 
    0.01512182f, -0.03288326f, -0.12137684f, 0.00848211f, -0.11940943f, 0.12510411f, 0.08031199f, -0.03640588f, 
    -0.36017483f, -0.00080301f, -0.15099297f, -0.23122498f, -0.28525490f, -0.01530498f, 0.18133084f, 0.02412039f, 
    -0.07639568f, 0.19451198f, -0.08577033f, 0.23917815f, 0.22212769f, -0.23506418f, -0.17899320f, -0.02874526f, 
    0.07268516f, -0.24929719f, -0.06361051f, 0.07358686f, -0.78094745f, 0.07064176f, -0.07726271f, 0.00273675f, 
    -0.11549192f, -0.03560942f, -0.11577330f, 0.08961190f, 0.00298175f, -0.02616037f, 0.31246927f, 0.14878029f, 
    -0.07278398f, -0.12633780f, -0.12048388f, -0.05810896f, -0.14870967f, -0.08774488f, -0.09491283f, 0.14511110f, 
    -0.65554667f, -0.22573403f, -0.34763220f, -0.33333373f, 0.07404564f, 0.12187856f, -0.00983924f, -0.04921354f, 
    -0.12299141f, -0.16870853f, -0.07116628f, 0.11854149f, -0.12220876f, 0.06040972f, -0.04250813f, 0.16983880f, 
    0.00332417f, 0.11871830f, -0.16687304f, 0.05640266f, -0.00101678f, 0.01045827f, 0.06505711f, 0.20125611f, 
    0.27705604f, 0.01352578f, 0.03663125f, -0.15970701f, 0.19139887f, 0.01739429f, 0.05757204f, -0.22171687f, 
    0.11468036f, 0.18331981f, 0.10916290f, 0.01919282f, -0.15766397f, -0.00629850f, -0.32129824f, -0.06543584f, 
    -0.52966678f, 0.12773582f, -0.09937920f, -0.23565249f, 0.10977508f, 0.15755691f, -0.00965005f, 0.17990226f, 
    0.13282688f, -0.10141893f, 0.02505084f, -0.18708108f, -0.00307410f, -0.01521304f, 0.07053780f, -0.08383287f, 
    0.19318511f, -0.23773888f, 0.08488233f, 0.11813368f, 0.11774182f, 0.17446287f, -0.07540610f, 0.10268749f, 
    -0.10557379f, 0.20120597f, -0.19519226f, -0.08984808f, -0.13941218f, 0.21504724f, -0.17273901f, -0.04175809f, 
    0.03650898f, 0.00485803f, -0.06555703f, -0.07877829f, 0.00031727f, 0.01644899f, -0.11091898f, -0.09073085f, 
    0.26353937f, 0.00952392f, 0.11889336f, 0.03052962f, 0.16193521f, -0.06258795f, 0.30936381f, -0.07230403f, 
    -0.11046139f, 0.14852536f, 0.16013278f, 0.07252301f, -0.03070226f, -0.00712726f, -0.02267505f, 0.05333323f, 
    -0.07432929f, 0.16811073f, 0.13107525f, -0.02179553f, -0.48745382f, -0.75639820f, -0.09922980f, 0.11825817f, 
    -0.04843520f, 0.04667431f, 0.11781818f, 0.02916566f, 0.09554859f, 0.00686500f, 0.04856370f, 0.00299136f, 
    0.09371784f, 0.18188074f, -0.05701824f, 0.14968862f, 0.06482195f, 0.06750908f, -0.27312130f, -0.12706929f, 
    -0.04947377f, 0.28487641f, -0.06893282f, -0.14433418f, 0.10676230f, 0.20495197f, 0.16161667f, -0.08638867f, 
    0.10174540f, 0.21945332f, -0.10729834f, 0.15187074f, 0.09636085f, -0.10598591f, 0.07356023f, -0.30772737f, 
    0.00935332f, 0.11192838f, -0.19205481f, 0.01389373f, 0.11844239f, -0.07084661f, 0.09275541f, 0.27090797f, 
    -0.42976126f, -0.06534644f, 0.14102998f, 0.02658136f, 0.01275641f, 0.09161495f, -0.24312712f, -0.14341985f, 
    -0.02564860f, 0.22851917f, 0.29121312f, -0.09473503f, -0.16965298f, 0.00531623f, 0.02658568f, -0.07562431f, 
    -0.29446661f, 0.40523288f, -0.14240745f, -0.28570101f, -0.13802502f, -0.03060414f, 0.13128680f, 0.21724737f, 
    -0.18286927f, -0.15936713f, 0.01372892f, -0.13025348f, -0.07012621f, -0.14891304f, -0.06111343f, 0.15865491f, 
    0.00359949f, -0.01401432f, 0.18647894f, -0.08536136f, -0.12991644f, 0.02232978f, 0.52478075f, 0.29194319f, 
    -0.40994239f, 0.14192833f, 0.04212818f, 0.05399840f, -0.03856348f, -0.18909210f, -0.03878915f, -0.00881538f, 
    -0.00628975f, -0.21333155f, 0.00327281f, -0.00596592f, -0.03611641f, 0.19059451f, 0.21523380f, 0.00062103f, 
    0.11509893f, -0.06047998f, -0.20418870f, 0.43023387f, 0.38199112f, -0.09540351f, -0.09224194f, -0.00861983f, 
    -0.00051349f, 0.06937722f, 0.07453699f, -0.05078180f, 0.09204589f, 0.14355914f, 0.07273981f, 0.03801695f, 
    0.00857542f, -0.23513938f, 0.10109615f, -0.09078927f, 0.39339158f, 0.12971051f, 0.01598185f, 0.00145928f, 
    -0.32741800f, -0.29367536f, -0.14904286f, 0.05762743f, 0.10608422f, 0.02786447f, -0.00010360f, -0.04316193f, 
    0.09288277f, 0.06152600f, 0.09393968f, -0.12712874f, 0.15622343f, 0.13872664f, 0.06463660f, 0.13999727f, 
    0.04108151f, -0.29258606f, 0.00775069f, -0.02652850f, 0.19390701f, -0.02763002f, -0.15260576f, 0.14067173f, 
    0.00018041f, 0.15983027f, -0.10596089f, -0.16132645f, 0.15129934f, 0.06118868f, 0.08930130f, -0.06930012f, 
    -0.23968051f, -0.18453620f, -0.21379371f, 0.01334052f, -0.67916566f, -0.13630566f, 0.01006706f, -0.08064262f, 
    0.03479576f, 0.03461945f, -0.07744406f, -0.11987060f, 0.04131244f, -0.16998161f, 0.04564599f, 0.14747626f, 
    -0.09003430f, 0.01691180f, -0.00562052f, -0.02966993f, 0.14487751f, 0.05979545f, 0.02140425f, 0.00170421f, 
    0.08314503f, 0.09409109f, 0.00485463f, -0.05466522f, 0.46419567f, -0.23355879f, 0.06027555f, -0.13873281f, 
    0.03415231f, -0.24765131f, 0.09881546f, 0.08565794f, -0.08620615f, 0.13531843f, 0.04324973f, 0.05350688f, 
    0.10391484f, 0.15893750f, 0.09893931f, -0.05614588f, -0.18286453f, -0.88679218f, 0.03000951f, 0.11161585f, 
    0.06039754f, 0.10163102f, -0.03914350f, 0.24829155f, -0.17517711f, -0.01716344f, -0.15261866f, -0.06718609f, 
    -0.16485380f, -0.06384000f, 0.09242342f, -0.15738483f, 0.06992183f, 0.07434770f, 0.00535440f, -0.14344111f, 
    -0.40258312f, 0.12911364f, 0.03765654f, -0.33555424f, 0.09596127f, -0.06281167f, 0.03718990f, 0.07019769f, 
    -0.06795055f, -0.00715302f, -0.02595232f, -0.15155068f, 0.22896340f, -0.18903519f, 0.04563445f, -0.23830606f, 
    0.05198286f, -0.20358872f, 0.12374417f, 0.11928210f, 0.41286871f, 0.06741656f, -0.02825625f, -0.02435214f, 
    -0.06371840f, 0.13989770f, -0.02543685f, 0.13680969f, -0.11020542f, -0.03431382f, 0.00395297f, 0.03845202f, 
    -0.21040963f, -0.00452367f, -0.04429965f, -0.00472292f, -0.05517524f, 0.15854625f, 0.26777425f, 0.05090036f, 
    0.47725606f, -0.28888810f, -0.21759066f, 0.02553109f, -0.08097842f, -0.11188467f, 0.31850845f, -0.06405412f, 
    -0.08493781f, -0.13476117f, 0.07091267f, 0.18290851f, 0.09893107f, -0.05604089f, 0.12567452f, -0.02259936f, 
    -0.15921643f, 0.27089804f, -0.22326794f, 0.13288856f, 0.03694174f, -0.45842054f, -0.02068390f, 0.02691438f, 
    0.15015277f, 0.30908185f, 0.02389921f, 0.02718085f, 0.01446561f, 0.13449028f, 0.04861266f, 0.01349476f, 
    0.01886587f, -0.12436252f, 0.22329402f, 0.13669103f, 0.10994627f, -0.04976767f, 0.17674303f, -0.10153344f, 
    -0.94168985f, 0.30598581f, 0.01114217f, 0.25018111f, -0.11418948f, -0.01040207f, -0.19567664f, 0.10289018f, 
    0.12843846f, -0.09555374f, -0.14063966f, 0.06076967f, -0.01371078f, 0.09736581f, -0.05996150f, 0.04910621f, 
    0.14246462f, -0.34398487f, -0.11279353f, -0.06101543f, -0.25619814f, -0.57108819f, 0.07454085f, -0.31409860f, 
    -0.31834379f, 0.03945258f, 0.09947916f, 0.06876452f, -0.08032502f, 0.00165603f, -0.15102105f, 0.04385730f, 
    -0.19047537f, 0.02536151f, 0.02766171f, -0.14030844f, 0.01497922f, 0.12295993f, 0.19574359f, -0.05275475f, 
    -0.24331073f, 0.10641944f, -0.14367440f, -0.74458820f, -0.00460080f, -0.09328388f, -0.07116468f, 0.17310667f, 
    -0.07664134f, 0.03898441f, -0.05190259f, -0.05211935f, -0.15138230f, -0.25011945f, -0.09937163f, 0.16749442f, 
    0.05714436f, -0.26436520f, 0.15571173f, 0.05567648f, 0.18577422f, 0.36746627f, 0.43214995f, -0.08812527f, 
    -0.37898058f, 0.34575221f, -0.08081011f, 0.08442074f, 0.10653556f, 0.04931876f, 0.00853447f, 0.12735328f, 
    0.00349974f, -0.03806493f, -0.18586132f, 0.00578594f, -0.03435148f, -0.04070932f, -0.01896670f, -0.04992096f, 
    0.06203912f, -0.82366657f, -0.16314618f, -0.33359227f, 0.02094856f, -0.01502203f, -0.04021187f, -0.17014511f, 
    -0.00526529f, -0.03776648f, -0.03163961f, 0.04629251f, 0.02368614f, 0.22339873f, -0.05669057f, 0.06333774f, 
    0.06953464f, -0.18775463f, -0.17045249f, -0.01101484f, 0.05924776f, 0.47943321f, -0.16947827f, 0.21692860f, 
    -0.49436745f, -0.17284290f, -0.07400520f, 0.13226816f, 0.21102867f, 0.11030973f, 0.04469454f, 0.03781500f, 
    -0.10680819f, 0.00036207f, 0.06916664f, 0.04180896f, -0.09337617f, -0.14002557f, -0.09823478f, -0.10928073f, 
    -0.08973024f, -0.08616503f, -0.41614959f, -0.08519370f, 0.06285075f, -0.07574762f, 0.00289128f, 0.19306733f, 
    0.09313518f, 0.21322687f, -0.03338823f, 0.01568033f, 0.01750126f, -0.03829959f, -0.05822753f, 0.01634157f, 
    -0.13286823f, 0.40271008f, 0.12192353f, 0.17394628f, 0.05611965f, 0.13269226f, 0.29867026f, 0.21789156f, 
    0.12214879f, 0.06636736f, 0.12989900f, 0.02857859f, -0.10257293f, 0.09529916f, -0.02105015f, -0.22805832f, 
    -0.00797765f, 0.06773498f, -0.01481698f, 0.07037299f, -0.01660482f, -0.13323955f, -0.16453119f, -0.30809125f, 
    0.02311797f, -0.07345482f, -0.31820971f, -0.31383955f, -0.10128254f, -0.03418166f, 0.14909619f, -0.01950409f, 
    -0.12308072f, -0.00635176f, 0.08622373f, -0.20713897f, -0.01501789f, 0.04945733f, -0.06234705f, -0.01778273f, 
    0.03218076f, 0.09851035f, 0.08054914f, 0.06741544f, 0.12614332f, -0.23628472f, 0.01412491f, -0.06636882f, 
    0.40575260f, 0.02829666f, -0.02293176f, 0.02570034f, 0.11669947f, -0.11567552f, 0.04728501f, -0.09435230f, 
    0.13921642f, 0.00162069f, -0.06890712f, 0.05367795f, 0.02370623f, -0.11865586f, 0.06958680f, 0.08200871f, 
    0.02289669f, 0.28857827f, 0.08373006f, 0.21411148f, 0.18983762f, 0.12426244f, -0.05767544f, 0.01103407f, 
    0.03072239f, 0.08286515f, -0.15069236f, 0.04265962f, -0.05450536f, 0.00950991f, -0.07310930f, 0.11638661f, 
    0.06826347f, 0.11508118f, 0.07299977f, -0.07361168f, 0.24656515f, -0.54697704f, 0.14470698f, 0.05228728f, 
    -0.22024986f, 0.09856851f, -0.13726234f, -0.08801106f, -0.06552526f, -0.02608346f, -0.02794079f, 0.10522207f, 
    -0.06663886f, 0.06042174f, -0.22626033f, -0.04418801f, 0.00114921f, -0.00116841f, 0.11379655f, -0.05707930f, 
    0.24933279f, 0.01389162f, 0.30476573f, 0.01589964f, 0.12344464f, 0.01977031f, 0.14673418f, -0.04449694f, 
    -0.14930427f, -0.03852800f, -0.04956248f, 0.06046492f, -0.00130740f, -0.07330500f, -0.13081259f, 0.08631335f, 
    -0.04107933f, -0.11174656f, 0.13549086f, -0.17327903f, 0.29167628f, -0.26542050f, -0.10202938f, 0.10291844f, 
    0.53339481f, -0.13710302f, -0.04289237f, -0.08053551f, -0.17498794f, 0.01219561f, -0.15481442f, 0.06843974f, 
    -0.15161274f, -0.01788948f, -0.14757054f, -0.14227104f, -0.14122047f, 0.01527167f, -0.02149182f, -0.00574134f, 
    -0.26606485f, 0.42875889f, 0.37239558f, -0.01637392f, 0.06207392f, -0.06823689f, -0.01100020f, 0.01061925f, 
    0.09030811f, -0.15196896f, -0.13430528f, 0.06812544f, 0.07204806f, 0.02811936f, -0.23683666f, -0.07693385f, 
    -0.06854051f, 0.10108253f, 0.06132312f, -0.11906797f, 0.22558759f, -0.07881904f, 0.07638261f, 0.22224863f, 
    0.27349588f, 0.01703901f, -0.03582639f, -0.10082630f, -0.12985413f, -0.00930699f, -0.01397002f, -0.09009863f, 
    -0.07040923f, -0.09299015f, -0.04762892f, -0.08434679f, 0.03694456f, -0.02692518f, -0.04883065f, 0.06899854f, 
    -0.32220784f, -0.26953462f, -0.15504514f, -0.31671131f, -0.31600943f, -0.06792115f, 0.00538659f, -0.04249559f, 
    -0.11767249f, -0.08301490f, -0.04277619f, -0.04201608f, 0.04743771f, -0.25501260f, 0.00851327f, 0.12482954f, 
    0.02464436f, -0.15594807f, -0.10330809f, 0.06042712f, 0.02453229f, -0.13065730f, 0.08101800f, 0.18995047f, 
    0.05474164f, 0.07706053f, -0.07727526f, -0.05319186f, -0.06145036f, -0.11932744f, -0.03054783f, -0.03595722f, 
    -0.06557401f, -0.06232958f, -0.01500660f, -0.01826771f, -0.12092220f, 0.00381078f, 0.02172922f, -0.22650705f, 
    0.15327585f, 0.17412740f, 0.38727769f, 0.09256636f, 0.28613636f, 0.17906958f, 0.17705397f, -0.06755392f, 
    -0.04943728f, -0.10593954f, 0.07928574f, 0.06392167f, -0.01439569f, -0.06281797f, -0.11458936f, 0.05836553f, 
    0.04076145f, -0.13284463f, 0.03056504f, 0.03083706f, -0.03166284f, -0.76471102f, -0.18351248f, -0.07977799f, 
    -0.26508340f, 0.10569014f, -0.03604138f, -0.08485926f, 0.06416464f, -0.13710439f, -0.10246260f, 0.06437880f, 
    -0.11866023f, 0.01918786f, -0.03923744f, -0.00528073f, 0.08470772f, -0.07118282f, 0.05707603f, -0.09100473f, 
    0.00212887f, 0.15708190f, 0.24655741f, 0.14877702f, 0.13651885f, 0.09612562f, 0.08430488f, -0.03192005f, 
    0.05130520f, -0.17455475f, 0.01896296f, 0.05823964f, 0.03240796f, -0.08789919f, -0.05518173f, -0.06178597f, 
    0.00781699f, -0.01998862f, 0.08831428f, 0.03845807f, -0.01765175f, 0.30232072f, -0.20552564f, -0.25893706f, 
    -0.36130282f, -0.11874298f, -0.07953481f, -0.04507734f, -0.10069575f, -0.16166890f, -0.09935894f, 0.07964437f, 
    -0.19536579f, 0.11917066f, -0.18029623f, 0.11646325f, -0.17075859f, -0.01304365f, -0.04735124f, -0.03475050f, 
    -0.36259189f, 0.19689909f, -0.40740243f, 0.08036549f, 0.19670874f, -0.21189530f, -0.19990158f, -0.33344609f, 
    0.04281995f, 0.02996508f, -0.16728517f, 0.17820956f, -0.11278550f, -0.12441651f, -0.09854389f, -0.04467044f, 
    -0.02850501f, -0.02747940f, -0.10093787f, -0.03703916f, 0.25977072f, -0.37211379f, 0.03562867f, -0.25077191f, 
    -0.05475236f, 0.02496567f, -0.01296089f, -0.02778803f, -0.19005355f, 0.00881485f, -0.02088467f, -0.17546935f, 
    -0.13990578f, 0.01210097f, -0.13349341f, -0.23261702f, 0.29131988f, -0.04823396f, 0.06314113f, 0.11224294f, 
    -0.05444826f, 0.39307198f, 0.03945931f, 0.09465139f, 0.32075435f, -0.21600975f, 0.11681639f, -0.20114839f, 
    0.01922941f, -0.07078756f, -0.24164817f, -0.01606454f, -0.02927851f, -0.07468993f, -0.14748441f, 0.11634581f, 
    0.02445785f, 0.02598001f, -0.11061812f, 0.07708398f, 0.20311598f, -0.04309376f, 0.35286388f, -0.25152770f, 
    0.24076433f, -0.06726035f, 0.29377684f, -0.16089095f, -0.10498314f, -0.06468325f, -0.05415077f, 0.16883914f, 
    -0.18896185f, 0.01059815f, -0.13877437f, -0.00472301f, 0.02446907f, 0.14139467f, 0.05447426f, -0.18405379f, 
    -0.26511228f, -0.29566959f, 0.07044317f, -0.29756245f, -0.51863354f, 0.04794488f, -0.09626500f, -0.07268617f, 
    0.08982374f, 0.03675693f, 0.12652645f, 0.01700175f, 0.03290192f, -0.11507991f, 0.05049032f, -0.26175538f, 
    -0.05588263f, -0.35535255f, 0.14961441f, -0.10167194f, 0.21870004f, -0.02058587f, 0.23198478f, 0.15393542f, 
    0.27608460f, -0.34504071f, -0.04208007f, -0.08403236f, -0.29380131f, 0.11171165f, -0.05182269f, 0.02406602f, 
    0.02431012f, 0.12520990f, -0.03775382f, 0.06503613f, -0.05417712f, -0.02186775f, 0.05999653f, 0.09820246f, 
    -0.43865633f, -0.17151806f, 0.57197386f, -0.16953076f, -0.06180307f, -0.02495083f, 0.05998210f, 0.09707012f, 
    -0.08997861f, -0.06317820f, 0.06143367f, 0.01103594f, 0.04715726f, 0.22026576f, 0.00657249f, -0.01125343f, 
    0.05576505f, 0.07579768f, -0.29680660f, 0.18414424f, -0.39407694f, -0.43822250f, 0.04329493f, -0.36011019f, 
    -0.10935216f, 0.16852339f, -0.09093974f, -0.10273437f, -0.00743206f, -0.22321118f, 0.00581848f, 0.03550747f, 
    0.01782062f, -0.00368099f, -0.09273081f, 0.01274566f, 0.11803330f, 0.04645384f, -0.57632315f, 0.01127706f, 
    0.22784728f, -0.13147701f, -0.03219212f, 0.09508456f, -0.03082388f, -0.32375383f, -0.07121688f, -0.01259722f, 
    -0.05790061f, 0.04592083f, 0.03757812f, -0.11318398f, 0.02794531f, 0.16774248f, 0.20561700f, 0.24401319f, 
    -0.08477008f, -0.17415284f, 0.09897110f, -0.13317706f, -0.03505335f, -0.16741835f, 0.18331926f, -0.18347922f, 
    0.15812345f, -0.00627551f, 0.03289147f, -0.08134996f, -0.11465395f, -0.00603737f, 0.07760692f, -0.06405282f, 
    0.03695086f, 0.07857209f, 0.15860155f, 0.01546937f, -0.05242856f, 0.11335027f, -0.09356727f, 0.00949670f, 
    0.20354822f, 0.04242318f, -0.20412453f, 0.25405586f, 0.02498125f, 0.21192797f, 0.04500603f, -0.21091053f, 
    -0.10542323f, 0.01105286f, -0.03752742f, 0.06970029f, -0.28865290f, 0.00647340f, 0.10683318f, -0.18399198f, 
    -0.10572770f, -0.00316705f, 0.14752807f, 0.01635772f, -0.05375519f, -0.11501443f, 0.26592731f, -0.00306857f, 
    0.12645908f, -0.10639613f, -0.04170347f, 0.18322250f, -0.05552171f, 0.00756044f, 0.03745795f, -0.04722770f, 
    0.21172346f, 0.03366040f, -0.00827391f, 0.09264745f, -0.06176428f, 0.00592411f, -0.34471285f, 0.12970813f, 
    -0.26933062f, -0.13454877f, -0.09705278f, -0.76075727f, -0.38735658f, 0.15307252f, 0.00632197f, -0.05080066f, 
    0.12496694f, -0.06563445f, 0.00253800f, 0.00879263f, -0.24861762f, 0.02261591f, 0.05929407f, -0.33658478f, 
    0.17705728f, -0.08263267f, -0.25130445f, -0.18744528f, 0.18033168f, -0.28186339f, -0.65539777f, 0.17992276f, 
    0.26575944f, 0.14048550f, -0.03734248f, -0.13805433f, -0.13865310f, -0.09068172f, -0.03010942f, -0.02241289f, 
    0.12635711f, 0.02355975f, 0.09890152f, 0.08940642f, 0.01817817f, -0.02127086f, 0.18038209f, -0.15323326f, 
    -0.08464353f, -0.15282698f, 0.21554843f, 0.01588403f, 0.22346100f, -0.11643229f, -0.20361854f, 0.10234701f, 
    -0.09949803f, 0.14285558f, -0.08809053f, -0.05960961f, -0.18137583f, -0.28254408f, 0.11159991f, -0.10204940f, 
    -0.01927722f, 0.10847493f, 0.08005316f, 0.01866543f, 0.27262464f, 0.21824260f, 0.10045500f, 0.03639275f, 
    0.22839931f, 0.04733823f, 0.01640676f, -0.30706871f, -0.05464834f, -0.20381273f, 0.09670953f, -0.01043679f, 
    0.03422958f, -0.21642616f, 0.08448089f, -0.17289348f, 0.06408267f, 0.07493124f, -0.02228680f, -0.17174935f, 
    -0.05392238f, 0.10491342f, 0.03773347f, -0.18897280f, -0.21393181f, 0.03872409f, -0.03723097f, -0.08306440f, 
    -0.02048465f, -0.31068063f, 0.11381522f, 0.25656450f, 0.01552408f, 0.03087297f, 0.00094052f, -0.09326435f, 
    0.00237244f, -0.07857950f, 0.01484804f, -0.03152318f, 0.23416543f, 0.06061291f, 0.00465544f, -0.13016707f, 
    0.20190626f, 0.19966386f, -0.05648977f, -0.01537787f, -0.12172312f, -0.12606609f, 0.00862397f, 0.11178440f, 
    -0.06935273f, 0.07795050f, -0.13981359f, 0.11933913f, 0.03573177f, 0.06533726f, 0.08782893f, -0.01749695f, 
    -0.29512388f, 0.03884119f, -0.12206651f, -0.44492328f, -0.46024188f, -0.06932122f, 0.01152373f, -0.03999555f, 
    -0.00013897f, -0.12838463f, 0.17312999f, 0.01594742f, -0.03308330f, 0.08846115f, 0.02899057f, -0.17564608f, 
    0.00313868f, -0.12149835f, -0.01584454f, -0.01205036f, -0.11501931f, 0.52466547f, -0.04266261f, 0.03311178f, 
    0.05710604f, -0.14449845f, -0.03683265f, -0.05645689f, 0.00172345f, 0.07860763f, 0.10619966f, -0.01324527f, 
    -0.13820061f, 0.09858562f, 0.06611411f, -0.02529981f, -0.07573935f, -0.01653321f, 0.17380573f, 0.18268839f, 
    -0.71864754f, -0.61920345f, 0.20061015f, 0.26041076f, -0.12871179f, 0.03498191f, -0.02067671f, 0.13883315f, 
    0.07000801f, 0.13000767f, -0.10697486f, -0.08385224f, -0.15077378f, 0.05674994f, 0.03356466f, 0.14634421f, 
    -0.16521873f, 0.32384172f, 0.09000333f, 0.07754720f, 0.84506190f, -0.62913525f, -0.06721175f, 0.10753281f, 
    -0.13301879f, -0.07640442f, -0.09773317f, -0.02385396f, 0.11478913f, 0.04603091f, -0.12748629f, 0.11557849f, 
    0.15291023f, 0.02470032f, -0.03926800f, 0.08546371f, -0.06143795f, 0.00042266f, 0.00185080f, 0.15033244f, 
    -0.14265147f, -0.46513975f, -0.19571319f, 0.46300608f, 0.09990815f, -0.17432769f, 0.07813511f, -0.12932695f, 
    -0.04019829f, -0.02066712f, 0.01843353f, 0.11367715f, 0.01172443f, -0.18842298f, 0.07505615f, -0.15418068f, 
    -0.02105958f, -0.06986360f, 0.17983302f, 0.01447538f, 0.38444686f, -0.20684937f, -0.32860720f, -0.35997766f, 
    -0.07142303f, -0.21574166f, 0.16155627f, 0.10598385f, -0.03786737f, -0.06701831f, 0.02225222f, 0.00255972f, 
    -0.03323419f, -0.02306527f, -0.18159802f, 0.10516968f, 0.13899574f, 0.03347354f, 0.13612224f, 0.15443289f, 
    -0.76486415f, -0.15117964f, -0.14418958f, 0.23296681f, 0.20359305f, 0.19732884f, -0.10739284f, -0.11416745f, 
    -0.10748298f, 0.24166985f, 0.02216718f, 0.11868548f, -0.05150753f, -0.03548813f, -0.00094244f, -0.06650461f, 
    0.00749462f, 0.14185993f, -0.01142072f, -0.08493894f, 0.31577188f, -0.02575421f, 0.02732313f, 0.13262290f, 
    -0.05070829f, 0.05279597f, 0.05477043f, -0.00367857f, -0.19642508f, -0.02108664f, -0.00295926f, -0.07255781f, 
    -0.01115767f, 0.13060144f, -0.05731893f, 0.15608399f, 0.09635523f, -0.15321393f, -0.03557028f, 0.06108844f, 
    0.19520094f, -0.18815161f, 0.21630564f, 0.17291199f, -0.21600819f, 0.06712382f, 0.00590815f, 0.14693609f, 
    -0.10291211f, -0.05927303f, -0.07294519f, -0.11040481f, -0.08207224f, -0.20644253f, -0.03770014f, 0.05954031f, 
    -0.10280057f, 0.11938928f, -0.09305207f, 0.15485397f, 0.28465539f, 0.18839949f, -0.25112230f, 0.13695107f, 
    0.10267819f, -0.11334562f, -0.20410672f, -0.06043458f, 0.10509697f, 0.02039928f, -0.10218947f, 0.04380119f, 
    0.18506680f, -0.02759542f, 0.08918899f, 0.01383592f, -0.02400843f, 0.05849731f, 0.06492738f, -0.07420594f, 
    0.20194033f, 0.10005729f, -0.15371664f, -0.00493939f, -0.22670886f, -0.25319684f, 0.00369576f, -0.15228972f, 
    -0.12152334f, -0.08228792f, -0.13453686f, 0.03890612f, 0.14234073f, 0.04972570f, 0.16936468f, 0.18308581f, 
    -0.03972750f, 0.02000459f, -0.16653308f, 0.33194917f, 0.14026964f, -0.48278478f, 0.37670922f, -0.70405704f, 
    -0.09055673f, -0.00100456f, 0.10589226f, -0.24962972f, 0.11681277f, -0.08466478f, -0.02423362f, 0.09541099f, 
    -0.10502057f, -0.12214824f, -0.06799958f, -0.13786486f, -0.07187247f, 0.09224076f, 0.16777089f, 0.10574760f, 
    0.37759537f, -0.08184489f, -0.02029719f, 0.08496022f, -0.07505756f, 0.12250942f, 0.04167640f, -0.05165992f, 
    0.01997695f, 0.18450463f, -0.19748975f, -0.00261715f, 0.01868471f, 0.18352823f, -0.05041301f, 0.00669057f, 
    -0.16940311f, -0.00291582f, -0.06821947f, 0.01494599f, -0.26028469f, -0.40438980f, 0.07668813f, -0.37401339f, 
    -0.10340705f, -0.00574306f, 0.14694469f, -0.17141563f, -0.08261883f, -0.10954095f, -0.07808112f, -0.04195989f, 
    -0.05834934f, 0.09378749f, -0.06928142f, 0.07154948f, 0.19493730f, -0.29457343f, -0.20350954f, -0.28496397f, 
    0.32226181f, 0.43346944f, -0.15088806f, -0.63242090f, -0.42212540f, 0.07221825f, -0.17199771f, 0.11305997f, 
    0.15586504f, -0.09979379f, -0.00353721f, -0.05414775f, 0.06789886f, -0.21346940f, 0.05467014f, 0.01955594f, 
    0.09708054f, 0.03720758f, -0.17743613f, 0.08173286f, 0.25885537f, -0.24783094f, 0.44767818f, -0.04885655f, 
    -0.48534560f, 0.06202692f, 0.13075005f, 0.02998295f, -0.10289429f, 0.18979087f, 0.06862538f, 0.06362569f, 
    0.22863205f, -0.12909864f, 0.00859393f, -0.05420808f, -0.04410639f, -0.04851819f, 0.11918521f, 0.05428527f, 
    -0.44675606f, 0.15267336f, 0.11317026f, 0.01776057f, -0.28242925f, -0.00592251f, -0.13697803f, 0.00560819f, 
    -0.07865370f, 0.04649470f, -0.01912262f, 0.01425579f, -0.01552287f, 0.09594610f, 0.18299659f, 0.10985047f, 
    0.18737313f, 0.14034143f, -0.03231648f, 0.06108201f, -0.70068675f, 0.04976071f, 0.11420655f, 0.16075565f, 
    -0.31102693f, 0.11672597f, 0.14109248f, -0.10662831f, 0.14523652f, 0.10864474f, -0.00158150f, -0.09497406f, 
    0.09657520f, 0.09897976f, 0.17697814f, 0.12033508f, -0.14493011f, -0.02176456f, -0.16573976f, -0.24297227f, 
    0.25433636f, 0.14950916f, -0.14820644f, 0.30647936f, 0.02302085f, 0.13380754f, -0.11813657f, 0.16686976f, 
    -0.14529480f, 0.02090800f, 0.03186421f, -0.08477928f, 0.16413173f, -0.02244174f, 0.11105610f, -0.01644587f, 
    -0.14487341f, -0.16300209f, -0.11793046f, 0.11585415f, 0.24446717f, -0.08661576f, -0.16704851f, -0.05880684f, 
    -0.05849182f, -0.06280041f, 0.07178256f, -0.08164280f, 0.09213426f, 0.04197163f, -0.01111357f, 0.08598931f, 
    0.07532091f, -0.00161126f, 0.10489320f, -0.00711004f, 0.19072689f, 0.20081967f, -0.14167747f, 0.16854206f, 
    0.27688384f, 0.04813864f, 0.06851622f, -0.12546642f, -0.35844955f, 0.17795578f, 0.07184289f, 0.12452801f, 
    0.07316028f, -0.04645266f, -0.04839145f, -0.01161484f, -0.10620832f, 0.16246517f, -0.13070744f, 0.06294179f, 
    0.13047788f, -0.19198266f, -0.28908116f, 0.04972944f, 0.13626549f, 0.44393077f, 0.24070926f, -0.08933168f, 
    -0.19935001f, 0.11848291f, -0.01793155f, 0.04018558f, 0.03559917f, 0.09291549f, -0.07347803f, 0.15842976f, 
    0.14124347f, 0.02571328f, 0.18122467f, 0.05201991f, 0.14569938f, -0.00170429f, -0.05422233f, 0.13073786f, 
    0.57656598f, 0.13071635f, -0.42816976f, 0.17944217f, -0.35510203f, -0.15327607f, -0.11667031f, 0.08792718f, 
    0.06152540f, 0.02373876f, 0.17506976f, -0.15860768f, 0.11644170f, -0.14202805f, 0.00969678f, 0.05687817f, 
    0.01468608f, -0.16093084f, 0.06465950f, -0.03533239f, -0.30465370f, 0.15793854f, 0.01612065f, 0.06192247f, 
    0.07809085f, -0.10847494f, 0.04053104f, -0.04022112f, 0.03715664f, 0.00235911f, 0.01120583f, 0.03461808f, 
    0.10986929f, -0.06507746f, -0.01179713f, -0.06360295f, -0.02055085f, 0.07992294f, -0.04517586f, 0.08172370f, 
    -1.05806398f, -0.34739381f, -0.29812559f, 0.11527502f, 0.04353937f, 0.02117426f, 0.02627086f, -0.08461523f, 
    -0.12868738f, -0.10680462f, 0.09651124f, -0.08025809f, -0.06463370f, 0.11901708f, 0.15045033f, 0.02573939f, 
    0.06271897f, 0.16130011f, 0.02987650f, 0.11296132f, 0.03456013f, 0.16813742f, 0.03623934f, -0.13568689f, 
    -0.06214820f, -0.08929674f, -0.03094580f, 0.25285605f, -0.02672898f, 0.16172811f, -0.19287395f, -0.04081363f, 
    -0.00934360f, -0.05148697f, -0.00504802f, 0.05016251f, 0.11543998f, 0.21577756f, -0.04247655f, 0.19822757f, 
    0.07669789f, -0.24860390f, -0.08226778f, -0.11316536f, 0.11002797f, 0.07819588f, 0.08634011f, 0.05023934f, 
    -0.00409911f, -0.01751924f, -0.07257489f, 0.23688720f, -0.08306095f, 0.05316277f, -0.21088310f, -0.08606334f, 
    -0.22264946f, -0.52150476f, -0.26391560f, -0.01481805f, -1.07049322f, -0.36509463f, -0.18356533f, -0.34492046f, 
    -0.08234932f, 0.02991130f, -0.05166561f, -0.18016538f, -0.03441389f, 0.27085656f, 0.15808931f, 0.01332320f, 
    -0.05178091f, 0.30492654f, 0.17098428f, 0.31143653f, -0.09545031f, 0.03329612f, -0.10752311f, 0.01733716f, 
    0.47449175f, 0.10994101f, -0.03484732f, 0.06674864f, -0.20491748f, -0.22067848f, -0.11143204f, -0.02588976f, 
    0.06096541f, -0.31661224f, -0.04841521f, 0.07761858f, -0.13628179f, -0.10748677f, -0.11532522f, -0.13027924f, 
    -0.05629310f, 0.00813074f, -0.15790384f, -0.08222666f, -1.74329400f, -0.44058877f, -0.26237220f, -0.41630936f, 
    -0.32463959f, 0.24213910f, 0.12408499f, -0.19365627f, -0.10436993f, -0.08319552f, -0.00526405f, -0.11888757f, 
    0.01426612f, -0.26953870f, 0.00475496f, -0.04545963f, -0.19092321f, 0.26485723f, -0.00440049f, 0.08895358f, 
    -0.09466147f, 0.26460016f, 0.15789589f, -0.05080242f, 0.01770699f, 0.31217694f, 0.00338374f, 0.15580653f, 
    0.11259784f, 0.19214387f, 0.03978702f, 0.03085677f, 0.07175456f, 0.13807078f, 0.10383937f, 0.00974731f, 
    0.12843566f, -0.19087961f, -0.03635257f, 0.03183264f, -0.71463996f, 0.00453436f, -0.24686086f, -0.28257588f, 
    -0.02738426f, 0.11193033f, 0.05688077f, -0.03168313f, 0.11821254f, 0.06056858f, -0.06126535f, -0.04472601f, 
    -0.00699644f, 0.21906732f, 0.02071854f, 0.11840562f, 0.05708046f, 0.31416765f, 0.00309914f, 0.28885990f, 
    -0.70960736f, -0.49275309f, 0.20148370f, 0.19547091f, 0.04797268f, 0.08186356f, 0.05866832f, -0.04926834f, 
    0.01082024f, -0.14853504f, 0.13650566f, 0.09233393f, 0.00749940f, 0.07469682f, -0.05764671f, 0.02024345f, 
    -0.13380851f, -0.36605245f, -0.12053442f, -0.17605464f, -0.05878530f, -0.22702739f, -0.15562953f, 0.00794290f, 
    0.24353591f, -0.13491823f, 0.06523085f, 0.09372512f, 0.00658788f, -0.19733064f, -0.04929164f, -0.02737305f, 
    -0.09931067f, -0.19940810f, 0.06717955f, -0.22552525f, 0.22330965f, 0.07206558f, -0.00028010f, 0.18260327f, 
    0.48045847f, -0.03017226f, 0.02537261f, 0.02281736f, 0.03983431f, -0.11681855f, 0.13457486f, 0.02374406f, 
    -0.02548233f, -0.06072389f, 0.06020352f, -0.08668541f, -0.04316581f, 0.08356975f, -0.17772323f, -0.13484067f, 
    0.02090809f, 0.01347433f, -0.00610254f, -0.07821000f, -0.62084371f, 0.12026974f, -0.02820621f, -0.07971226f, 
    0.04770381f, -0.06244008f, -0.01822802f, -0.07748222f, 0.03877939f, 0.03220012f, -0.20481631f, 0.00154436f, 
    0.16918144f, -0.06836927f, -0.18339744f, -0.01977382f, 0.01025693f, 0.12685370f, -0.25900254f, -0.25048968f, 
    0.02079269f, 0.41517889f, -0.10691176f, -0.33480731f, -0.07252528f, -0.09553322f, -0.18201125f, 0.08493954f, 
    -0.32804787f, -0.34144899f, 0.05266202f, -0.09139858f, -0.03533520f, -0.27967295f, -0.00329521f, 0.17960440f, 
    -0.14689939f, -0.04736631f, -0.00265174f, -0.16334069f, -0.52671796f, 0.17071734f, -0.01800182f, -0.24394028f, 
    0.55381262f, 0.06285590f, -0.08002428f, -0.01168158f, 0.19461146f, 0.11329383f, -0.03322268f, -0.15036181f, 
    0.09993511f, 0.12354996f, 0.23791517f, -0.00509207f, 0.07582805f, 0.03643420f, 0.03418478f, 0.04886317f, 
    0.27907929f, -0.32570308f, 0.11224300f, 0.09097405f, -0.07737247f, -0.05232755f, 0.07461095f, 0.07910261f, 
    -0.08823895f, -0.12216689f, -0.28480190f, -0.08247659f, 0.11236386f, 0.00290905f, -0.10685030f, 0.06477771f, 
    -0.04407576f, -0.05755689f, -0.22762081f, -0.12752733f, -0.89024627f, 0.10678227f, 0.16434701f, -0.12351537f, 
    0.33863133f, -0.18362965f, 0.09556236f, -0.08113437f, 0.10910261f, -0.11461408f, 0.08704893f, -0.05270953f, 
    0.00074795f, 0.05341294f, 0.02744768f, 0.13354146f, -0.02063314f, -0.02425398f, 0.00321570f, 0.01804267f, 
    -0.29875398f, 0.31146944f, -0.20752092f, -0.03984021f, -0.48709980f, 0.24578682f, 0.02457461f, -0.01303235f, 
    0.13015051f, 0.09814838f, 0.22388910f, -0.03851384f, 0.02221733f, -0.02772638f, 0.09158466f, -0.06706239f, 
    -0.07166950f, -0.00989005f, -0.19901426f, 0.12324770f, 0.12318052f, 0.10641399f, 0.06720444f, -0.11656822f, 
    0.06015870f, -0.13267489f, 0.08771957f, 0.05053559f, -0.01128246f, -0.13430029f, 0.17834020f, 0.04318602f, 
    0.07898152f, 0.01847314f, -0.13065347f, -0.04158501f, -0.05701582f, 0.05017032f, -0.09858470f, -0.20668356f, 
    0.16003284f, 0.01725417f, -0.15958916f, -0.16040544f, -0.09383076f, -0.06733777f, -0.23602080f, -0.05757213f, 
    -0.06892369f, -0.18134847f, 0.10923444f, 0.01367324f, -0.04640189f, 0.11026110f, 0.02944279f, 0.20375313f, 
    -0.00401185f, 0.12263890f, 0.22752224f, 0.11017571f, 0.88689339f, 0.00100117f, -0.62481999f, 0.16214970f, 
    -0.23127732f, -0.11558820f, -0.15719430f, 0.02921440f, -0.06199168f, -0.00226311f, 0.09726786f, 0.04378770f, 
    0.05462161f, 0.04601452f, -0.05914834f, 0.14865889f, 0.06664815f, -0.09677719f, 0.05946571f, 0.12712607f, 
    -0.27058268f, -0.27695021f, 0.14385305f, 0.02869380f, -0.13125959f, 0.06859763f, 0.01336205f, -0.00240855f, 
    0.03519439f, -0.20582844f, -0.06163365f, -0.05959453f, 0.09934448f, 0.01709433f, 0.01051658f, -0.23720071f, 
    -0.06237896f, -0.02054547f, -0.16442187f, 0.01754036f, -0.19521342f, -0.65860122f, -0.20263714f, -0.27651602f, 
    -0.29675072f, -0.03489110f, 0.21438929f, 0.04373090f, -0.06650589f, 0.00511461f, 0.05392060f, -0.13571940f, 
    0.00175634f, -0.06437346f, -0.04565496f, -0.12189247f, 0.03191433f, -0.13731802f, -0.00381979f, 0.02446792f, 
    0.34678808f, -0.45790520f, -0.17422326f, 0.04200319f, 0.02597383f, 0.05638670f, -0.21435915f, -0.11451738f, 
    0.16454561f, 0.05077888f, 0.01316935f, -0.02092203f, 0.08417197f, 0.01607647f, 0.06632894f, 0.16436365f, 
    0.06194926f, 0.07650592f, 0.06025297f, 0.00203377f, 0.26572424f, -0.03578831f, -0.24311619f, -0.03444970f, 
    0.19934836f, 0.05123121f, 0.05492659f, 0.07574804f, 0.15041254f, 0.16329898f, 0.12713270f, 0.14352980f, 
    -0.08939381f, -0.15657562f, 0.04394246f, 0.00779327f, -0.04032423f, -0.12153270f, 0.03087279f, -0.07923588f, 
    -0.10051903f, 0.48133186f, -0.14653842f, -0.20302704f, 0.33104223f, 0.18635128f, -0.15076503f, 0.04315139f, 
    -0.05126653f, -0.08403611f, 0.09625511f, 0.17550954f, -0.05151440f, -0.04988343f, 0.04647695f, 0.08350012f, 
    0.30226159f, 0.14331350f, 0.10792434f, 0.15842980f, -0.59199536f, 0.34616160f, -0.05025297f, 0.15491337f, 
    -0.13728088f, 0.32479909f, -0.00766978f, 0.09363753f, 0.00404837f, 0.06957059f, 0.13342157f, 0.01480644f, 
    0.10839048f, -0.11223253f, -0.05638507f, -0.04010778f, 0.16681020f, -0.30001163f, 0.07515170f, -0.02020309f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08826957f, 0.02480875f, -0.13011195f, -0.02524262f, 0.08109761f, 0.01472650f, 0.03496786f, -0.08877669f, 
    -0.05270108f, -0.00863930f, 0.15856387f, -0.01153423f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
