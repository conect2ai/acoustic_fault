#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.88335901f, -1.02692771f, -0.56428927f, -0.17325236f, 0.27471513f, 0.88121510f, 0.57508755f, -0.06053847f, 
    0.21156318f, 1.17483890f, -0.75023872f, 0.88217252f, 0.83651942f, 0.06537450f, 0.12289528f, -0.08667822f, 
    0.11218658f, -0.85676342f, -0.67918533f, -0.71157378f, -0.25735307f, -0.41049212f, -0.51732409f, -0.81183547f, 
    0.87185329f, 0.41398668f, 0.39914030f, 1.07824302f, 0.35378078f, -0.96035165f, 0.58775717f, 0.97908819f, 
    -0.45051569f, 0.40457556f, -0.22696255f, -0.17146780f, -0.65769058f, -1.68729436f, 0.58241040f, 0.24382305f, 
    0.49999022f, 0.55139464f, -0.14926359f, -0.10578337f, -0.31473854f, 0.00185960f, -0.59992319f, 0.91975409f, 
    0.30077130f, 0.73019588f, 0.78877717f, -0.29819369f, -0.48083243f, 0.09018276f, -1.27620244f, 0.08164860f, 
    0.59577429f, 0.73821968f, 0.84075224f, -0.31253272f, 0.46386066f, -0.27262250f, -0.33300379f, 1.15150428f, 
    -0.49392974f, -1.16499627f, 0.84095371f, -0.34611297f, -0.17997864f, -0.45667309f, 0.18411134f, -0.00180681f, 
    1.14335537f, -1.05218542f, 0.66121811f, 0.48832315f, -0.64254063f, 0.51404715f, 0.11321775f, 0.29920220f, 
    -0.17809302f, 0.01947242f, -1.36594844f, 0.40448719f, -0.64878154f, -0.66074896f, -0.40054181f, 0.40915799f, 
    -0.14602326f, -0.37969273f, 1.08144164f, 1.13556790f, 0.69468212f, 0.25170872f, -1.14325345f, -0.47419187f, 
    0.31034759f, -0.13297626f, 0.02775572f, 0.10782358f, -1.06500614f, -0.87963605f, -0.17390731f, -0.61058569f, 
    -0.75741166f, -0.61717415f, 0.46115187f, 0.01972628f, -0.82148504f, -0.93593419f, -0.72892648f, 0.68314856f, 
    -0.14165187f, 0.66848934f, -0.47438857f, 0.04223369f, 0.13573284f, -0.49020728f, 0.76005656f, 0.39980260f, 
    0.88718796f, 0.64029431f, 0.92314780f, -0.16367741f, -0.33887571f, -0.41794223f, -0.36057088f, -0.19134574f, 
    1.12060320f, -1.33292413f, -0.35737014f, -0.76071006f, 0.33225361f, 0.41909662f, 0.14332752f, 1.36046875f, 
    0.08321069f, 0.66147053f, 0.20975217f, -0.39383197f, -0.81760675f, 0.19437687f, 0.02782694f, 0.35801867f, 
    0.56844968f, 1.30104589f, 0.72494185f, 0.70542735f, 0.69267803f, -0.58179176f, -0.10235269f, 0.57837945f, 
    -0.22021051f, 0.25805223f, -1.55351162f, -0.78541040f, -0.60288006f, 0.75068331f, 0.52612627f, -0.04048095f, 
    0.30182302f, -0.26773974f, -0.53447431f, -1.12784362f, -0.57116473f, 0.89189565f, 1.19182515f, 0.07158469f, 
    -0.58790809f, -0.01516390f, 0.28423437f, 0.87812823f, -0.00173645f, -0.14752978f, 0.53123599f, 0.45883501f, 
    0.67357010f, -0.03959249f, -0.55105281f, 0.63228470f, 1.18414080f, 0.04327754f, -0.10063332f, -0.58852220f, 
    0.11072738f, 0.31904548f, -0.62118149f, -0.33745536f, 0.35533217f, -0.62262768f, -0.70155054f, -0.10229665f, 
    -0.65866607f, -0.98912615f, -0.74799567f, -0.43267515f, 0.78058231f, -0.71798670f, 1.01582313f, 0.42218697f, 
    -1.19222355f, 0.11500790f, -0.50536120f, 0.24533397f, -0.16137956f, 0.31298664f, 0.93387014f, 1.21543586f, 
    0.68692750f, 0.67979020f, -0.61376208f, -0.75585383f, 0.50800133f, -0.21048445f, -0.02897601f, 0.38090891f, 
    -1.67521751f, 1.30143166f, 0.46730348f, -0.53934777f, 1.12821484f, 0.17727318f, -0.51213157f, 0.39363915f, 
    0.19885632f, -0.99195933f, -0.49694207f, -1.04273558f, -1.19453919f, 0.76868647f, 0.45594999f, 0.25297880f, 
    -0.33685669f, 0.32940334f, 0.35184649f, 0.63612068f, 0.80446339f, 0.16331623f, 0.53816015f, 0.30579248f, 
    0.33899924f, -0.10446838f, 0.65729141f, 0.69473988f, 1.01473379f, -0.27957731f, 0.23816094f, 0.22890979f, 
    0.60708302f, -0.82067025f, 0.37311897f, -0.41175053f, -1.30190206f, 1.33017528f, 0.06971388f, 0.55279571f, 
    -0.80611074f, -0.73941833f, -0.40431276f, -0.22588174f, -0.41822264f, 0.82156527f, 1.10295117f, 0.96846485f, 
    -1.46223617f, 0.62200254f, -0.58426267f, 0.41666591f, 0.23443285f, -0.06967571f, 0.90294224f, -0.14945772f, 
    -0.98210967f, -0.61002541f, 0.83928800f, 0.78782266f, 0.41079411f, -0.52904916f, -0.10574875f, 0.47812653f, 
    -0.89595151f, 1.16079533f, 0.16980118f, -0.70954490f, -0.03846744f, -0.58483398f, -0.36810446f, -0.06900551f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31479901f, 0.05609236f, 0.15997705f, 0.24937108f, 0.10389178f, 0.11413157f, -0.26179656f, 0.05202133f, 
    -0.09047733f, 0.26887220f, -0.00029661f, 0.33093774f, 0.05803359f, 0.02228148f, 0.19407310f, -0.04527253f, 
    0.36009920f, 0.00290507f, 0.00819963f, 0.13162668f, -0.16666001f, 0.03165264f, -0.05493103f, 0.22592075f, 
    0.13463221f, 0.08668064f, 0.37303174f, 0.32944095f, 0.13686575f, -0.08818823f, -0.00697608f, 0.06257581f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26962450f, 0.05923189f, -0.11564098f, -0.10630023f, -0.28661683f, 0.05451144f, 0.04203924f, -0.11526805f, 
    0.06580134f, 0.05077829f, -0.10713902f, 0.05052128f, -0.06670810f, 0.07072528f, 0.02492649f, 0.03049207f, 
    -0.06970686f, -0.04989510f, 0.08711956f, -0.04170419f, 0.28985798f, -0.14657766f, 0.05848698f, -0.01011356f, 
    -0.18526138f, -0.09218839f, -0.08351476f, -0.01059774f, -0.00389124f, -0.08552928f, -0.16890471f, 0.03259557f, 
    0.00626393f, 0.10795707f, -0.05044787f, 0.03834601f, -0.07525885f, 0.10628989f, 0.01192910f, -0.00832275f, 
    -0.35074723f, -0.58483261f, -0.12970245f, 0.15699758f, -0.10516968f, -0.01844843f, -0.08664633f, -0.06549753f, 
    0.13072938f, -0.01619078f, 0.11281940f, 0.04655193f, -0.04777033f, -0.06287430f, 0.06952433f, 0.08702164f, 
    0.07944928f, -0.07369193f, 0.05371840f, -0.12168811f, -0.11198109f, 0.09170225f, 0.13087797f, -0.12269200f, 
    0.38029626f, -0.18820539f, 0.07785178f, 0.03274318f, 0.03241876f, -0.13340999f, 0.01367982f, 0.10434804f, 
    -0.00142764f, -0.00197554f, -0.00986069f, 0.01667466f, -0.04839848f, 0.10239565f, -0.10507101f, -0.02023483f, 
    -0.24035698f, 0.19616933f, 0.02649347f, -0.03231968f, -0.57221848f, 0.13351662f, -0.00465233f, 0.01690093f, 
    0.15393986f, -0.01635992f, -0.06638777f, 0.00706213f, -0.11362332f, -0.14869422f, 0.01706957f, -0.07336891f, 
    -0.02651115f, -0.07628617f, -0.00894750f, 0.02337325f, -0.10545727f, 0.13887665f, 0.18741943f, 0.04500944f, 
    -0.07655115f, -0.04993976f, -0.00284861f, 0.13494079f, 0.04601520f, -0.03148547f, 0.01079722f, -0.08689047f, 
    -0.05337750f, -0.07863852f, 0.08945327f, -0.01824150f, 0.11925448f, -0.05418663f, 0.03477101f, 0.10919770f, 
    0.51467341f, -0.00714087f, 0.53542525f, -0.12447392f, -0.23071441f, -0.00960248f, 0.06000067f, 0.12476082f, 
    0.03967299f, -0.00627249f, -0.01152540f, 0.03469365f, 0.23651657f, 0.01036780f, -0.01803859f, 0.08021164f, 
    -0.05265331f, -0.05873393f, 0.04385396f, -0.04179471f, 0.28530210f, -0.59568679f, 0.16907378f, 0.08035073f, 
    0.20468713f, 0.02552368f, 0.02772304f, 0.05580419f, 0.01786297f, -0.18679182f, -0.15961082f, 0.10333820f, 
    -0.02960808f, 0.08958801f, -0.01011289f, -0.05447524f, 0.05595228f, 0.06392375f, -0.08319548f, 0.12466881f, 
    0.37800223f, -0.40881655f, 0.07762355f, -0.17729998f, -0.40516818f, 0.02844284f, 0.05249010f, 0.03064988f, 
    -0.02840442f, -0.05559063f, -0.25489488f, 0.10113756f, 0.03754622f, 0.10406867f, 0.03004523f, 0.05785022f, 
    -0.02137530f, -0.00709527f, 0.01093663f, -0.05729368f, 0.08319855f, -0.51591164f, 0.00343603f, 0.18787368f, 
    -0.34623379f, -0.06448510f, -0.11035807f, 0.07814762f, -0.11077220f, 0.01957352f, -0.05448376f, -0.02431886f, 
    -0.17154203f, 0.01235593f, 0.00151417f, -0.10562272f, -0.09249794f, 0.07183620f, 0.01382410f, 0.12401447f, 
    0.18060225f, -0.01975039f, 0.05095283f, -0.25112078f, 0.09631505f, -0.26397741f, -0.14943071f, 0.03996413f, 
    -0.01273939f, -0.00461577f, 0.06408537f, -0.06540830f, -0.03281387f, -0.05453566f, -0.06341625f, 0.11883628f, 
    0.03498069f, 0.09110140f, -0.03248748f, -0.00749549f, -0.19010100f, -0.65588361f, 0.16446273f, 0.13688818f, 
    -0.13819848f, 0.02880018f, -0.08390491f, 0.09405137f, -0.02406055f, 0.07991956f, -0.07958708f, -0.03334164f, 
    0.02834981f, 0.05879609f, -0.01787229f, -0.06083458f, 0.04637684f, 0.04300791f, -0.07699263f, -0.08442578f, 
    0.10426962f, 0.03566622f, -0.13370726f, -0.28541264f, -0.55044305f, 0.11101800f, 0.22486447f, 0.03500225f, 
    0.08988322f, -0.07857488f, 0.03015440f, 0.01449618f, 0.06957862f, 0.11898097f, -0.03672598f, 0.07059178f, 
    -0.06542327f, 0.13093579f, -0.04905432f, 0.04119822f, 0.05294378f, 0.05405364f, 0.24267450f, 0.03161515f, 
    0.20544355f, -0.09599914f, -0.09594248f, 0.11914062f, -0.07691617f, 0.10481179f, 0.02935759f, -0.03611275f, 
    -0.01625798f, -0.08007768f, 0.05552306f, 0.12001179f, 0.05052308f, -0.15246572f, 0.04050891f, 0.05851999f, 
    0.11950530f, -0.16434415f, -0.09168874f, 0.20074998f, -0.09343686f, -0.05072215f, 0.07306504f, -0.07254615f, 
    0.03902478f, -0.01575983f, -0.03069040f, 0.11365806f, -0.00074852f, -0.05246213f, -0.13036564f, 0.02466342f, 
    -0.01600418f, -0.05251130f, 0.08155604f, 0.02703719f, 0.23180304f, -0.12167479f, 0.11407802f, -0.10599422f, 
    -0.03098689f, -0.06427085f, -0.18195616f, -0.07825769f, 0.06109925f, -0.00400567f, -0.15160398f, -0.03597759f, 
    -0.10669494f, -0.00898559f, -0.17821734f, -0.00272653f, -0.05095483f, 0.06860462f, 0.12100101f, -0.00598490f, 
    -0.13159500f, 0.02040610f, 0.11710910f, -0.11371402f, 0.24520284f, -0.12764671f, -0.13544086f, 0.04528358f, 
    -0.03152055f, -0.02365009f, 0.03788731f, 0.11326035f, -0.03644068f, 0.00437154f, 0.02107238f, -0.03506313f, 
    0.02987069f, -0.01479190f, -0.06295707f, -0.03425385f, -0.12570216f, 0.10939910f, -0.17752446f, -0.04330441f, 
    -0.43145770f, -0.06985249f, 0.01857373f, 0.03673198f, -0.08916651f, 0.10163715f, -0.05674314f, -0.04219539f, 
    0.04102783f, -0.01301083f, 0.01657539f, 0.12553206f, -0.06785116f, 0.08193601f, -0.04260776f, 0.12153558f, 
    -0.06347740f, 0.27293411f, 0.05758180f, -0.11344944f, -0.37602520f, 0.05729141f, 0.12393596f, 0.13128604f, 
    -0.06302442f, -0.09205851f, 0.05925555f, 0.07161678f, 0.05075077f, 0.06283518f, 0.10345378f, -0.04904332f, 
    0.01889899f, 0.11158086f, -0.12127549f, 0.05800462f, -0.05826928f, -0.04579217f, -0.14563321f, -0.09654418f, 
    0.13389514f, -0.02333376f, 0.02140185f, 0.00566605f, -0.02800942f, -0.02171850f, -0.10056993f, 0.04290246f, 
    0.05079095f, 0.00627787f, 0.04336448f, 0.06795534f, 0.09943854f, -0.02438601f, -0.17588124f, 0.08583132f, 
    0.20184080f, 0.01482935f, -0.16173896f, 0.16009100f, 0.09801446f, -0.00632324f, -0.02203333f, -0.03899028f, 
    0.10466955f, -0.07091988f, -0.06622731f, 0.05176362f, 0.11883368f, 0.00635906f, -0.00465586f, 0.00029179f, 
    -0.03095607f, -0.27497882f, 0.09046001f, -0.11090784f, -0.20911440f, -0.59756780f, 0.06448282f, 0.22831269f, 
    -0.11075693f, 0.00243824f, -0.05339982f, 0.02241945f, 0.01975670f, 0.13098077f, -0.10479342f, 0.05364085f, 
    -0.00645751f, -0.10153376f, -0.09380364f, 0.05928117f, 0.09625099f, -0.06068653f, -0.07675492f, -0.00769710f, 
    -0.14331584f, -0.38739666f, 0.04230779f, -0.10605297f, 0.16096455f, -0.15299681f, -0.03875367f, -0.06134082f, 
    0.04293684f, -0.07209420f, -0.03732289f, 0.00489622f, 0.02162242f, 0.05328301f, 0.04417944f, 0.07401352f, 
    -0.05190916f, 0.04220820f, -0.01012685f, 0.00653015f, 0.24759956f, 0.10058942f, -0.08781046f, -0.15205243f, 
    0.03596247f, -0.11880000f, -0.11165995f, -0.14553593f, 0.00205163f, 0.01047775f, -0.11695090f, -0.02796322f, 
    0.03415550f, -0.06977534f, -0.00828198f, 0.03361416f, 0.00557188f, -0.14009637f, 0.03900429f, 0.12440944f, 
    0.21774562f, 0.15429406f, 0.25424087f, -0.13627645f, 0.24149667f, -0.00577249f, -0.08285596f, 0.01042380f, 
    -0.09428433f, -0.02245735f, 0.06121125f, -0.07112635f, -0.10414971f, -0.09204159f, 0.08745302f, 0.03692102f, 
    -0.07108616f, 0.14513293f, 0.11189359f, 0.01426932f, -0.35898462f, 0.48405892f, -0.13272338f, -0.06405959f, 
    -0.29684663f, 0.03654105f, 0.02603118f, -0.04646620f, 0.07837626f, -0.01914612f, 0.01276211f, 0.01651000f, 
    -0.01111336f, 0.20806278f, 0.02442925f, -0.06775989f, -0.08214319f, -0.02615967f, 0.02443682f, 0.05803205f, 
    0.03228501f, -0.03277161f, -0.12464530f, -0.18648255f, 0.19739829f, -0.11701985f, -0.19673504f, -0.01876189f, 
    -0.00439915f, -0.08486401f, -0.02986655f, -0.04447938f, 0.01939483f, -0.04361874f, 0.11380155f, -0.22249660f, 
    0.03325790f, -0.08735510f, -0.09263280f, 0.02828641f, 0.17460850f, 0.03427884f, -0.00002029f, -0.24249101f, 
    0.27250910f, -0.09018667f, -0.07903543f, -0.06057748f, 0.00383989f, 0.02305631f, -0.09863782f, 0.04983269f, 
    -0.05305069f, -0.09248155f, -0.08196130f, -0.05292977f, 0.03325000f, -0.14603871f, -0.05166183f, 0.04895185f, 
    -0.12041783f, 0.31093726f, 0.16256194f, 0.07650737f, 0.12467093f, -0.07130053f, -0.28083888f, 0.03990735f, 
    -0.20053647f, 0.04554611f, 0.00885349f, 0.00223310f, -0.10272007f, 0.02023686f, -0.07140078f, -0.13008478f, 
    -0.06683324f, 0.13240203f, -0.06505115f, -0.15861958f, 0.16440791f, 0.07484033f, 0.02901000f, 0.04818087f, 
    0.21575134f, -0.19724832f, -0.05427656f, -0.20988089f, 0.01105432f, 0.02433618f, 0.00022177f, -0.03944300f, 
    -0.04871371f, -0.07579931f, 0.10301536f, -0.16485210f, -0.01418924f, 0.07602626f, -0.03570648f, -0.03868965f, 
    -0.45485389f, 0.30713528f, -0.00074381f, -0.04778334f, 0.18006910f, -0.05152899f, -0.02428285f, -0.07579586f, 
    -0.08993445f, 0.09678163f, -0.01876633f, -0.09323735f, 0.03578303f, -0.07610878f, 0.00866952f, 0.01497739f, 
    -0.04963691f, -0.08195826f, -0.13764988f, -0.05405970f, 0.33931229f, -0.15984839f, -0.05166305f, 0.22905472f, 
    -0.29705319f, 0.01453134f, -0.07486771f, 0.08341278f, -0.02667815f, -0.02657325f, -0.18251543f, 0.02925012f, 
    -0.09733857f, 0.06835962f, 0.20773430f, 0.01998358f, -0.09595926f, 0.11856017f, 0.07967098f, 0.00950294f, 
    0.28293225f, 0.15160392f, -0.14640036f, 0.04762249f, -0.20535862f, -0.02547226f, 0.00743662f, 0.04331142f, 
    0.09054878f, 0.08984177f, 0.01068072f, -0.11255483f, -0.01437715f, 0.02579968f, -0.08861367f, 0.06410258f, 
    0.07939570f, -0.03908285f, -0.05883432f, 0.09072787f, 0.45686936f, -0.03171473f, 0.15593357f, -0.08566614f, 
    -0.03674793f, 0.05570967f, -0.00203488f, 0.00155581f, -0.02760477f, 0.06731918f, -0.06968018f, -0.07842070f, 
    0.08327126f, -0.09822864f, -0.01038038f, -0.00046540f, 0.08920457f, -0.05662583f, 0.08661555f, 0.20400144f, 
    -0.12102237f, -0.02263831f, -0.09162065f, 0.00474256f, -0.13154429f, 0.02492389f, 0.00935888f, 0.07041537f, 
    0.06289569f, -0.10418245f, -0.04010612f, 0.03863628f, 0.05596488f, -0.00969796f, -0.02555566f, 0.07280044f, 
    0.03496878f, -0.17954955f, -0.00646486f, -0.06363781f, 0.34034413f, -0.63251776f, -0.07280672f, -0.17854381f, 
    -0.13946180f, -0.01710110f, -0.07293919f, -0.01565870f, -0.03298845f, -0.02642373f, -0.10439082f, -0.09652302f, 
    -0.14513744f, 0.05730826f, 0.08052805f, -0.01486647f, 0.16598810f, -0.14277162f, 0.12221005f, 0.02899204f, 
    0.11224602f, -0.07448315f, -0.14527287f, 0.13419479f, -0.51283628f, -0.04199019f, 0.06052883f, 0.00124053f, 
    -0.05714768f, 0.11648725f, 0.07006205f, 0.07347343f, -0.08924788f, 0.12351000f, -0.00049892f, 0.05078759f, 
    0.12882020f, 0.04515261f, -0.03801730f, -0.09318124f, -0.11425164f, 0.07592624f, -0.00842364f, 0.05230334f, 
    0.03018772f, -0.03903835f, 0.02822107f, -0.06560779f, -0.04576751f, 0.13595806f, 0.07519556f, 0.21158229f, 
    -0.10752886f, -0.03467862f, 0.00323927f, 0.02006529f, -0.04680905f, 0.10039138f, -0.04041598f, -0.01641449f, 
    -0.82014120f, -0.05800661f, -0.15289502f, -0.06269210f, 0.13340865f, -0.12149913f, -0.02937216f, -0.09745155f, 
    0.02539470f, 0.07966121f, -0.15891381f, 0.00279001f, -0.11800031f, -0.11493989f, -0.04869453f, 0.10260313f, 
    -0.00686020f, -0.07043260f, 0.07581304f, -0.01393407f, 0.08036040f, -0.71644664f, 0.12463393f, -0.37603599f, 
    -0.08177987f, -0.11633845f, -0.02748910f, -0.14474589f, -0.12070228f, -0.06032655f, -0.08530050f, -0.15204553f, 
    0.05071259f, -0.04782895f, -0.05210075f, 0.01701937f, -0.01038734f, -0.18591732f, 0.07620478f, -0.14212964f, 
    0.14212708f, 0.23482184f, 0.13649465f, -0.07885843f, -0.04933764f, -0.05971875f, -0.02811681f, -0.05546154f, 
    0.00310210f, 0.03732276f, 0.05160421f, -0.06125521f, 0.04707154f, -0.07254241f, -0.12517920f, -0.00349753f, 
    -0.03464799f, -0.02098141f, 0.00780841f, 0.07576878f, -0.20452526f, 0.18105306f, -0.04410132f, -0.05967461f, 
    -0.22191761f, 0.00791941f, 0.12110156f, -0.02457872f, 0.08385593f, -0.08861493f, -0.01316146f, -0.06036511f, 
    0.09137638f, 0.19442342f, 0.01852773f, -0.04854508f, 0.04442383f, -0.13043654f, -0.13795926f, -0.15256496f, 
    -0.00243058f, 0.06203736f, 0.13370787f, 0.04270529f, 0.27289864f, -0.01476601f, -0.06603111f, 0.10705242f, 
    0.02588122f, 0.02920788f, -0.12635781f, -0.07032874f, 0.08965287f, 0.11568124f, -0.08377504f, -0.08784381f, 
    0.00837967f, -0.08327214f, -0.07106014f, 0.02541288f, 0.02627471f, -0.03953662f, 0.00950409f, -0.27862349f, 
    0.07502390f, -0.09317101f, 0.04877487f, 0.12122889f, 0.03033385f, 0.02089725f, -0.16174909f, -0.18300125f, 
    0.04634274f, 0.00783913f, -0.00165122f, 0.09637555f, 0.02388054f, -0.20129435f, -0.08005413f, -0.05524908f, 
    0.04038491f, 0.01268659f, -0.13868810f, 0.03824165f, -0.34533066f, -0.03660114f, -0.04881650f, -0.08650134f, 
    -0.04989722f, 0.07268517f, 0.18549691f, 0.06285673f, 0.00202151f, 0.04985351f, -0.06632715f, 0.00384570f, 
    0.13956740f, -0.22287986f, -0.04640110f, 0.02425607f, -0.02375199f, 0.08113876f, 0.04189377f, 0.03831692f, 
    0.15727028f, -0.05262801f, 0.04505026f, -0.04198544f, -0.10029453f, 0.00074248f, 0.07354998f, 0.15855235f, 
    -0.03325590f, 0.07732905f, 0.09469244f, 0.08128695f, -0.00782215f, 0.18391699f, -0.00583903f, 0.06268001f, 
    -0.50557774f, -0.19361170f, -0.24818532f, -0.07009780f, -0.28934982f, 0.04776681f, 0.01115050f, -0.05103194f, 
    0.05880981f, 0.04598212f, 0.03319293f, 0.05498211f, 0.04107506f, 0.02364113f, 0.00012676f, -0.12005752f, 
    0.02244035f, -0.06791195f, -0.18412475f, 0.11600492f, 0.16668674f, -0.09745125f, 0.14454873f, 0.00601598f, 
    -0.07769950f, 0.00826511f, -0.08334966f, 0.01001616f, -0.04004854f, -0.01934805f, 0.07078197f, -0.01228355f, 
    0.08118803f, -0.03357350f, 0.18863368f, -0.04158670f, 0.04091814f, -0.19142981f, -0.04770311f, -0.06753809f, 
    0.09298450f, 0.33065629f, 0.18692058f, 0.03045942f, 0.34255663f, -0.13590218f, 0.01418166f, 0.04751141f, 
    -0.05177875f, 0.08428734f, -0.08580433f, -0.13801330f, 0.02905348f, -0.03016696f, 0.08464122f, -0.02627195f, 
    0.09325720f, -0.01500579f, -0.01201187f, 0.16327128f, 0.20955531f, -0.55226082f, -0.04567834f, 0.07796490f, 
    0.03184131f, -0.20726977f, 0.10420231f, -0.00288776f, 0.07161965f, 0.04982667f, 0.14262179f, 0.00006933f, 
    0.07679483f, 0.10436635f, -0.15018310f, 0.13001801f, -0.03913315f, -0.03342599f, -0.07077299f, 0.01249029f, 
    0.23230213f, -0.07402550f, -0.19573787f, 0.02056841f, -0.28885251f, 0.01553446f, 0.01110078f, -0.03408729f, 
    -0.05866826f, 0.01449446f, -0.08665372f, 0.05347563f, -0.04961522f, -0.03235628f, -0.08308809f, 0.10169041f, 
    0.07321519f, -0.11372288f, 0.03567925f, -0.00128282f, 0.15235326f, -0.02492003f, 0.18194835f, 0.07254685f, 
    0.04326395f, -0.09781563f, -0.00323955f, -0.06723695f, 0.06775395f, 0.04333038f, 0.13679704f, 0.07112478f, 
    -0.05866998f, 0.06455658f, 0.00010552f, -0.01126581f, 0.11146633f, 0.01997288f, 0.11249460f, 0.08139616f, 
    0.30426133f, -0.14112285f, 0.06551202f, -0.10536651f, -0.18297763f, -0.11119302f, -0.07755245f, -0.04629331f, 
    -0.04710917f, -0.04226886f, -0.11789529f, -0.07495373f, -0.31281105f, -0.11288384f, -0.08493274f, -0.09816378f, 
    -0.12276016f, 0.14396749f, -0.00010257f, -0.04049375f, -0.12747476f, -0.12619931f, -0.08287536f, -0.11433183f, 
    -0.16103444f, 0.05667508f, -0.04275169f, 0.00730079f, 0.01565797f, 0.07949232f, -0.14877898f, -0.10397986f, 
    0.04789408f, 0.10859549f, -0.01318059f, -0.24904771f, 0.06784596f, -0.02174968f, -0.23440748f, 0.09474508f, 
    0.16630055f, -0.27384102f, 0.15342750f, -0.11084479f, 0.14929286f, 0.00343900f, -0.33599114f, 0.03539144f, 
    0.12842481f, -0.12258083f, -0.04640808f, -0.09572528f, 0.00761746f, -0.10834238f, 0.15783840f, -0.01713878f, 
    -0.07436437f, -0.02657531f, 0.04720503f, -0.24578406f, 0.16350093f, 0.05165312f, 0.00686916f, 0.08007058f, 
    0.01921021f, 0.09395521f, -0.06726862f, 0.08438883f, -0.02035948f, 0.00663937f, -0.08626810f, -0.03172883f, 
    -0.08050603f, 0.09287959f, 0.04736022f, 0.11773950f, -0.03038164f, 0.06833985f, -0.03607808f, -0.13589419f, 
    -0.71949959f, 0.18089354f, -0.22486337f, -0.32983437f, 0.00432921f, -0.10136292f, 0.23997962f, -0.07007438f, 
    -0.01441989f, 0.04616970f, 0.02035072f, -0.02475258f, 0.14680365f, -0.03491484f, -0.06576555f, -0.04120198f, 
    -0.03472285f, 0.12727152f, -0.10670597f, 0.01828025f, 0.39565110f, -0.16422382f, -0.12767521f, 0.06801714f, 
    -0.13759710f, -0.03080417f, 0.10735124f, -0.10123650f, 0.13320725f, 0.08368514f, -0.01072440f, -0.10821568f, 
    0.03700282f, 0.00990476f, 0.13067621f, 0.02704120f, 0.02429941f, 0.07056189f, -0.16158681f, -0.03985430f, 
    0.04518126f, 0.22267620f, 0.11493203f, 0.03369953f, 0.23202001f, -0.08757950f, -0.03437999f, 0.08996185f, 
    -0.01893073f, -0.00073963f, 0.10464719f, -0.09619870f, 0.00869663f, -0.02169859f, 0.06180889f, 0.08742595f, 
    0.00359240f, 0.12570597f, -0.07705241f, 0.06049512f, 0.18057044f, 0.13207157f, 0.12637028f, 0.02987142f, 
    0.18214849f, -0.00003332f, -0.10112853f, -0.09132216f, 0.00108163f, -0.04293075f, 0.04146961f, 0.01772685f, 
    0.02324905f, 0.09375109f, -0.11548506f, 0.05767267f, 0.04879468f, 0.08114669f, 0.11167394f, -0.08898825f, 
    -0.11641423f, -0.38462156f, -0.31298959f, -0.18297926f, 0.06718159f, 0.09355757f, 0.09635373f, 0.02556314f, 
    -0.11572512f, -0.03833044f, 0.00230834f, 0.03627424f, 0.03707051f, -0.09747496f, -0.00234370f, 0.01321010f, 
    -0.08992829f, -0.05994503f, -0.00709766f, -0.03804490f, 0.23104398f, 0.08018376f, -0.24095656f, 0.02743843f, 
    0.27302429f, 0.05522843f, -0.17868771f, 0.07673552f, 0.04160843f, -0.06305213f, 0.08074225f, 0.03152326f, 
    0.03561635f, 0.13877568f, -0.11288188f, 0.00072324f, 0.11596879f, -0.02507848f, -0.14728136f, 0.01929254f, 
    0.43043637f, -0.35488012f, 0.00066410f, -0.06289665f, 0.01778221f, -0.22181679f, 0.01238186f, -0.07954688f, 
    0.04115166f, -0.11242422f, -0.00924344f, 0.08120360f, -0.12147440f, 0.11147010f, 0.00768834f, -0.05441054f, 
    -0.14219230f, 0.00060694f, 0.04548023f, 0.08239663f, -0.11869744f, 0.22738913f, -0.07036868f, -0.13422196f, 
    -0.18220109f, -0.23378666f, 0.04862807f, -0.03245554f, -0.05825057f, 0.12551299f, 0.22781366f, 0.03880597f, 
    0.10195255f, -0.13160208f, -0.03849403f, 0.00688910f, -0.11064681f, -0.16837928f, 0.06639928f, 0.12726410f, 
    0.21871290f, -0.01136385f, 0.15541232f, 0.15711804f, 0.13417865f, -0.23548332f, -0.01878875f, -0.10736047f, 
    -0.02546963f, 0.05284790f, 0.07696886f, -0.00819772f, -0.02573866f, -0.02897364f, -0.01735970f, 0.10289565f, 
    -0.06007734f, 0.01645859f, 0.02536520f, 0.00853248f, -0.50467646f, 0.11885119f, 0.03697239f, -0.21075384f, 
    0.13099685f, 0.02700466f, 0.05340948f, -0.00889413f, 0.01207822f, 0.06519850f, -0.03194470f, -0.08209188f, 
    0.07913329f, -0.09056313f, -0.00037146f, -0.01857960f, 0.01912890f, -0.08984965f, -0.05040587f, 0.05540936f, 
    0.16789441f, -0.25277483f, 0.07996595f, -0.02825490f, -0.26506835f, -0.14003146f, -0.01573170f, -0.19091354f, 
    0.03455124f, 0.02261271f, 0.02385055f, -0.01472572f, 0.01974053f, -0.08725588f, -0.06576016f, -0.00718992f, 
    0.04887405f, 0.10513560f, 0.01168240f, -0.00656395f, 0.21084999f, -0.19148524f, 0.16064098f, -0.22939363f, 
    0.01695126f, 0.00800307f, -0.17559385f, 0.08634468f, 0.03400608f, 0.07440072f, -0.08710384f, -0.02917683f, 
    0.08760149f, 0.03756068f, -0.01699261f, -0.02839047f, -0.16395408f, 0.08214991f, -0.03622218f, -0.04513907f, 
    0.04365227f, -0.17818464f, 0.05420634f, -0.09310458f, 0.10595785f, -0.17055544f, -0.03469297f, -0.04614944f, 
    -0.04927749f, -0.02774272f, 0.12793662f, -0.09433936f, 0.00892955f, -0.12803160f, 0.02000053f, 0.08167332f, 
    -0.06190880f, -0.03768347f, -0.02777441f, 0.06239158f, -0.01378669f, 0.01465152f, 0.11940528f, -0.02317000f, 
    0.11767622f, 0.02885894f, -0.07338589f, 0.08972298f, 0.10531925f, -0.06332161f, 0.01053413f, 0.05696459f, 
    -0.01270398f, -0.07464432f, 0.08131287f, -0.02840710f, -0.10687148f, -0.08767845f, 0.01202415f, 0.01959736f, 
    0.65776038f, -0.27459133f, 0.09422882f, -0.05390750f, 0.12092667f, 0.05348605f, -0.06873366f, -0.00786095f, 
    -0.01199184f, -0.01513846f, 0.04372708f, 0.01553561f, -0.02705387f, -0.08710745f, 0.06160317f, 0.13883767f, 
    -0.13074143f, -0.02361801f, 0.06640311f, -0.13390718f, -0.25188419f, -0.36147386f, 0.06093186f, -0.09651175f, 
    -0.19341534f, -0.04258401f, -0.11993905f, 0.07130172f, 0.05092230f, 0.11225713f, -0.07055437f, 0.06171606f, 
    -0.07731593f, 0.00036042f, 0.00450847f, 0.12588046f, -0.00067898f, 0.02067951f, -0.06595116f, -0.09673682f, 
    -0.68284905f, 0.26040250f, 0.06876733f, -0.18042612f, 0.01842277f, 0.00066040f, 0.08867199f, 0.05174521f, 
    0.08507712f, 0.03255875f, -0.15560672f, -0.09362370f, 0.00578958f, -0.03750182f, 0.10431410f, -0.04653293f, 
    0.04777890f, -0.01579787f, 0.07487235f, 0.06171732f, -0.03713466f, -0.26152423f, -0.16001643f, -0.08768979f, 
    -0.22070161f, -0.09067649f, 0.05177144f, -0.13782527f, -0.02790220f, -0.13227610f, 0.08216531f, -0.08858104f, 
    0.05550686f, -0.02352817f, -0.09089851f, 0.07239892f, -0.00724575f, -0.04682968f, 0.05341853f, -0.01725162f, 
    -0.08213809f, 0.04010980f, -0.02625581f, -0.08609170f, 0.12606494f, 0.09085662f, 0.13766979f, 0.14472923f, 
    -0.07961648f, -0.03426453f, -0.11553221f, 0.08679339f, -0.06811126f, -0.08379557f, -0.06356393f, 0.02507388f, 
    0.03797172f, -0.03164355f, -0.23422170f, -0.01493597f, -0.28347161f, -0.43556404f, 0.04782921f, -0.23422727f, 
    -0.30732557f, -0.13399971f, 0.00019577f, -0.10505734f, 0.00158183f, -0.03791525f, 0.13034071f, 0.00762674f, 
    -0.04212679f, -0.05927737f, -0.00175146f, 0.01075201f, 0.10585018f, 0.13945958f, -0.07005160f, -0.11630427f, 
    0.14236832f, 0.11613535f, 0.16514559f, 0.16750482f, 0.24522875f, -0.18558882f, -0.19865347f, -0.26487920f, 
    0.07361045f, 0.02753069f, -0.02962735f, -0.04123290f, -0.17965667f, -0.02903377f, 0.03311048f, -0.05076219f, 
    0.07662582f, -0.03683408f, 0.04843288f, 0.02878666f, 0.17368078f, 0.02523144f, 0.00053852f, -0.06681552f, 
    0.14436941f, 0.03930910f, -0.01419525f, -0.01107729f, 0.14133570f, 0.10893017f, -0.02750585f, -0.00272574f, 
    0.04080299f, 0.07055469f, -0.01048642f, -0.01730947f, -0.04549954f, -0.16074902f, -0.10721154f, -0.01103824f, 
    0.27407745f, 0.05950662f, -0.15038307f, -0.02040502f, -0.25482506f, -0.02610006f, 0.02229271f, -0.03882564f, 
    0.00694544f, -0.03070409f, 0.02893510f, -0.11937056f, -0.03506677f, -0.03660666f, -0.12796292f, -0.01526917f, 
    0.11750484f, -0.00207963f, 0.06464646f, -0.14535704f, -0.26418102f, 0.07274617f, 0.02486493f, -0.28732586f, 
    0.07155100f, 0.06874416f, 0.09371874f, 0.05119212f, 0.03181797f, -0.02458486f, -0.16485345f, 0.13189323f, 
    -0.05504785f, -0.05408460f, -0.07490151f, 0.00034225f, -0.06388444f, 0.18415321f, -0.06466648f, 0.03280212f, 
    0.18373050f, -0.16164145f, 0.00708351f, -0.11711472f, 0.00275558f, 0.06285935f, 0.08669842f, 0.08222427f, 
    -0.02476827f, 0.01780090f, -0.01337190f, 0.05469457f, 0.08537666f, -0.09742678f, 0.02872740f, 0.02835607f, 
    -0.10567740f, -0.00163818f, -0.09501725f, -0.07152227f, 0.42514548f, -0.00692982f, 0.09401385f, 0.16217536f, 
    -0.10144501f, -0.21418248f, -0.05153081f, 0.05502921f, 0.05308424f, 0.04515543f, 0.06877446f, -0.08115138f, 
    0.00392982f, 0.08322592f, 0.02520811f, 0.05301025f, -0.05937762f, -0.01801742f, -0.06555082f, -0.02485372f, 
    0.20750502f, -0.08000046f, 0.37565681f, 0.10454161f, 0.34405288f, -0.20845672f, -0.08102746f, -0.09725416f, 
    0.09473100f, 0.04802715f, 0.14777887f, -0.05971902f, -0.07338186f, 0.05236332f, 0.02568727f, -0.17919461f, 
    0.00151428f, -0.01538717f, -0.01500154f, 0.04678965f, -0.13448398f, 0.06015052f, 0.01476423f, -0.01575158f, 
    -0.03843623f, 0.05164997f, -0.17605199f, 0.04235468f, 0.12602711f, 0.06350516f, -0.12330965f, -0.01782809f, 
    0.03473560f, 0.04437685f, -0.14899690f, -0.08922143f, -0.03094679f, -0.02155920f, 0.02373198f, -0.02870816f, 
    0.00539091f, 0.18072234f, -0.28732672f, -0.12650825f, -0.12712274f, -0.00676427f, 0.08257896f, 0.08770736f, 
    0.07087313f, 0.06874248f, 0.01793247f, 0.09610222f, -0.06402142f, 0.09566027f, -0.09306451f, -0.11086881f, 
    -0.06839149f, 0.00011166f, 0.07135341f, 0.01720179f, -0.03759135f, -0.35235509f, 0.04200090f, -0.20682468f, 
    -0.31441054f, -0.06784479f, -0.02084762f, -0.10649665f, 0.05216153f, -0.06640888f, 0.12267783f, 0.04942992f, 
    0.07196464f, -0.07432956f, -0.03632398f, -0.03366615f, -0.05426233f, -0.04163725f, -0.00655899f, -0.15109766f, 
    -0.07043463f, 0.02634762f, 0.09756467f, -0.14698777f, -0.29462910f, -0.01895716f, -0.14661144f, 0.12928538f, 
    -0.11661816f, 0.12057688f, -0.16422990f, 0.01822279f, 0.01414568f, -0.06413607f, -0.01137167f, 0.10739405f, 
    -0.00826629f, 0.01324006f, 0.06207215f, -0.06120542f, -0.35297936f, 0.12512964f, -0.15624879f, -0.09395330f, 
    0.00768207f, 0.00507846f, 0.11009431f, 0.07975753f, 0.04119572f, -0.09162398f, -0.10591910f, 0.05290047f, 
    -0.00940028f, -0.06140565f, -0.09702905f, -0.07817841f, -0.06163947f, -0.01180838f, 0.00206042f, -0.03067169f, 
    0.38053000f, 0.11773520f, -0.31891507f, -0.04361248f, -0.06530657f, 0.01601600f, 0.09880814f, 0.04582522f, 
    -0.00434739f, 0.01030372f, -0.01692936f, 0.07385954f, 0.04371982f, -0.02585667f, 0.00762374f, -0.02722041f, 
    0.00384116f, -0.16678979f, -0.06308404f, -0.02977564f, 0.47408378f, -0.06359938f, -0.15497220f, 0.17967837f, 
    -0.08274086f, -0.18603818f, 0.03132611f, -0.12201972f, -0.03782711f, 0.12055686f, -0.04989461f, 0.02154137f, 
    0.02044898f, 0.01547244f, -0.01720112f, -0.07625654f, -0.12901115f, -0.01874872f, 0.12003810f, -0.01438338f, 
    0.00016299f, 0.02267216f, -0.00552722f, 0.05651415f, -0.04980940f, -0.01441877f, 0.04558126f, 0.05429173f, 
    -0.03701278f, -0.10641982f, 0.00037704f, 0.07716026f, 0.01542136f, -0.06179230f, -0.05369491f, 0.01397737f, 
    -0.09390078f, -0.00168874f, -0.00746191f, -0.02400137f, 0.10146839f, -0.12707850f, -0.04143878f, -0.11391210f, 
    -0.03156273f, -0.00099045f, -0.00988533f, 0.05435284f, -0.01000665f, 0.03353011f, -0.06332979f, -0.02570979f, 
    0.10794570f, 0.00383034f, -0.07604489f, -0.01482775f, -0.00214043f, 0.08047738f, -0.13151607f, -0.05258601f, 
    0.13101627f, 0.08510976f, -0.22020212f, -0.13178489f, -0.12815763f, 0.01850858f, 0.06864227f, 0.03725228f, 
    -0.14178225f, -0.03266396f, -0.15478657f, 0.00157996f, -0.10567845f, -0.00463598f, -0.06294915f, -0.06919169f, 
    0.10399236f, 0.06733911f, -0.01861626f, -0.00189100f, 0.15151726f, 0.28036824f, -0.02916887f, -0.22692785f, 
    0.05844582f, 0.07110585f, 0.08851697f, -0.01102472f, -0.12464346f, -0.14517258f, -0.06057312f, -0.09946850f, 
    -0.04914536f, -0.15804181f, 0.02059475f, 0.03038812f, 0.03414264f, -0.08366603f, 0.04125663f, -0.01499486f, 
    0.12448671f, 0.00833012f, -0.02276439f, 0.10498506f, -0.16615406f, 0.06692467f, -0.11687212f, 0.02457063f, 
    0.17757703f, 0.01030735f, -0.01870225f, 0.01012499f, 0.05122251f, 0.06059026f, 0.02519260f, -0.01371738f, 
    0.01803690f, -0.04782824f, 0.04836931f, -0.02275857f, -0.53145254f, 0.10228197f, -0.19346312f, -0.05794615f, 
    -0.08251328f, 0.10148960f, 0.16129911f, -0.00370736f, -0.06788776f, -0.11805513f, -0.03165334f, -0.03283559f, 
    -0.11242282f, -0.00868459f, -0.01559943f, -0.05987353f, 0.08272859f, 0.07627590f, -0.10929587f, -0.06937626f, 
    0.19209027f, -0.10976281f, 0.03645353f, -0.05776381f, -0.09701999f, -0.09366316f, -0.08898151f, 0.03060073f, 
    -0.10540204f, -0.04049570f, -0.09428933f, 0.04675644f, 0.05105592f, -0.00766546f, 0.03939974f, 0.00552176f, 
    0.06813998f, 0.04821831f, 0.00808503f, -0.00926036f, -0.35914308f, -0.26891750f, -0.53221488f, 0.01931803f, 
    -0.05595423f, -0.06067654f, 0.02323590f, -0.08605772f, -0.02663295f, -0.01287026f, 0.03588000f, 0.02988421f, 
    0.04836800f, -0.03308275f, -0.02992463f, 0.03864846f, -0.13051924f, 0.04208148f, -0.02209123f, 0.04313863f, 
    -0.02905844f, 0.14947899f, 0.04499272f, 0.13228570f, -0.09387524f, 0.03251311f, 0.05200412f, 0.00007713f, 
    -0.05495702f, 0.07656852f, -0.09719837f, -0.00545200f, 0.01046425f, -0.05725712f, 0.03411438f, -0.02316537f, 
    0.03870622f, 0.08391962f, -0.00367560f, 0.00425429f, 0.03538846f, -0.02497089f, -0.13110285f, -0.02028659f, 
    -0.01772823f, -0.09812041f, 0.00704354f, 0.01417835f, 0.04433041f, 0.07885791f, -0.07634056f, -0.03960748f, 
    -0.03471718f, 0.09475276f, -0.05901549f, -0.02918298f, 0.00326887f, -0.09305488f, -0.03501486f, -0.02664122f, 
    0.40698448f, -0.05523624f, 0.14487049f, -0.07089357f, -0.06154232f, -0.12445110f, -0.12004327f, -0.23703910f, 
    -0.05879480f, -0.03604064f, 0.07280628f, -0.04716875f, 0.02068524f, -0.03632253f, 0.05186662f, -0.03573095f, 
    0.06521811f, 0.01373375f, 0.09750035f, 0.06664640f, -0.06915940f, -0.28788885f, 0.00591593f, -0.11093694f, 
    -0.18505616f, 0.04315308f, -0.08139446f, -0.00310494f, -0.00521751f, -0.12330511f, -0.06809542f, -0.04014966f, 
    -0.01301979f, 0.04280903f, 0.02961345f, 0.05363592f, 0.01799510f, -0.01253079f, -0.05653444f, 0.04887142f, 
    -0.26740769f, 0.14279449f, 0.05075850f, 0.11208449f, 0.11403291f, 0.14417076f, -0.19915418f, -0.14297642f, 
    0.13837431f, -0.17820798f, 0.17536035f, -0.14654817f, 0.00869241f, 0.06650051f, -0.07839604f, -0.12161071f, 
    0.00700997f, -0.08677220f, 0.02733397f, 0.00193136f, 0.00671795f, 0.25725710f, 0.06397274f, 0.23456974f, 
    -0.02609369f, 0.04081597f, 0.10447294f, 0.00248076f, 0.05069298f, -0.02186712f, -0.10481200f, -0.02505232f, 
    -0.01370513f, -0.01723344f, -0.01308606f, 0.04640920f, -0.00874042f, -0.01203205f, 0.00032436f, 0.08555282f, 
    0.04875780f, 0.10339177f, -0.22982146f, 0.19340704f, 0.09299223f, -0.02629446f, 0.12194814f, 0.06731763f, 
    0.06291099f, -0.09728464f, 0.05708688f, 0.06854482f, -0.12875764f, -0.02685087f, -0.02101442f, -0.02822616f, 
    -0.08971602f, 0.06256336f, 0.06099267f, -0.05581546f, 0.02930668f, 0.19758703f, 0.13057482f, 0.12407909f, 
    0.03478254f, -0.10243959f, 0.11430751f, -0.00604523f, -0.04638234f, 0.06463446f, -0.03292485f, 0.07517333f, 
    -0.01990777f, -0.07970879f, -0.02158074f, -0.06672420f, 0.12944919f, 0.01541056f, 0.13549624f, -0.07968741f, 
    0.06138643f, -0.28753507f, -0.43017650f, 0.26355833f, 0.09487511f, 0.06220276f, 0.09929776f, -0.00319766f, 
    0.06232351f, -0.02482546f, 0.05292344f, 0.00076459f, -0.12592170f, -0.13035819f, -0.04545340f, 0.04100459f, 
    0.07676582f, 0.10643875f, 0.02927526f, -0.11492518f, 0.09797174f, 0.19714604f, 0.01142211f, 0.07611249f, 
    -0.02729126f, -0.05648048f, 0.01817645f, -0.05941733f, -0.01551051f, -0.05160319f, 0.04733701f, -0.02725846f, 
    -0.01066448f, -0.01266433f, -0.03761547f, 0.11900656f, -0.07951602f, 0.12105873f, 0.02848782f, 0.03767519f, 
    0.14827934f, 0.02099888f, -0.12834570f, -0.00967165f, -0.05867264f, -0.14587629f, -0.13946821f, 0.02253797f, 
    -0.01766860f, 0.11729588f, -0.27381393f, -0.04899175f, 0.04084248f, -0.09972337f, 0.05656995f, -0.04272930f, 
    -0.05384699f, 0.05380937f, 0.01190074f, 0.03705214f, -0.57260287f, -0.25191903f, -0.02457084f, -0.12004389f, 
    -0.24211647f, -0.05408772f, -0.15250404f, 0.01082813f, 0.07240302f, -0.03878094f, 0.03550383f, -0.12095165f, 
    0.01661154f, -0.04327367f, -0.03929980f, 0.06022476f, 0.02915354f, -0.08927535f, 0.05662562f, 0.10264583f, 
    -0.34598893f, 0.41893494f, 0.10708068f, 0.24928880f, 0.06770951f, 0.15093231f, 0.09925761f, 0.06877017f, 
    -0.02024385f, -0.03011858f, -0.03755031f, -0.06207756f, 0.00026287f, -0.04636011f, -0.19008906f, -0.01580348f, 
    0.01567106f, 0.01080053f, 0.07184892f, -0.07000282f, -0.06939194f, -0.31634244f, -0.24132365f, 0.19200648f, 
    0.05671859f, 0.01154699f, 0.07779644f, 0.04385599f, 0.00772970f, -0.04900981f, -0.05371129f, 0.00440313f, 
    -0.10333333f, -0.17007034f, -0.05010941f, 0.04457711f, 0.06273194f, 0.12531951f, -0.00987479f, -0.10211796f, 
    0.27483428f, -0.30229992f, -0.21923703f, 0.05477249f, 0.00042007f, -0.14878574f, -0.13114114f, -0.10556310f, 
    0.07520153f, -0.07117940f, -0.01481843f, 0.01337761f, -0.05082725f, 0.05095766f, -0.05702859f, 0.05304450f, 
    0.01759581f, 0.00531327f, -0.04980418f, -0.04276295f, 0.02789005f, -0.04168075f, 0.02879334f, 0.07002294f, 
    -0.22911118f, -0.04244052f, -0.09198993f, -0.02780003f, -0.06681486f, 0.05736668f, -0.06238572f, 0.10407580f, 
    -0.08993507f, -0.01404801f, 0.08126599f, -0.06993648f, 0.01861513f, 0.01978888f, -0.06341549f, 0.02511320f, 
    0.00294936f, -0.00782215f, -0.17960635f, -0.02545745f, -0.26329517f, -0.05882673f, -0.08892766f, 0.01481269f, 
    -0.00916619f, -0.02091479f, -0.20219977f, 0.03107943f, 0.06026398f, -0.07822742f, 0.11428762f, 0.00995532f, 
    -0.08301676f, 0.01649485f, -0.01565095f, 0.01386626f, -0.06707393f, -0.02517101f, -0.16688366f, -0.09335490f, 
    -0.14635031f, -0.01419167f, 0.04739841f, -0.04268064f, 0.04679716f, -0.05656409f, -0.08661906f, 0.03230287f, 
    0.03912347f, 0.09787369f, -0.01461512f, 0.05027170f, -0.00612841f, 0.00806899f, -0.18397585f, 0.04041068f, 
    0.09055800f, -0.16808645f, -0.02807788f, -0.03693052f, 0.18439527f, 0.06493182f, -0.01292036f, 0.00602583f, 
    0.03887732f, -0.05436632f, -0.00768709f, 0.01563040f, 0.03623558f, 0.05178905f, -0.09551491f, 0.04414266f, 
    -0.04484485f, 0.07662507f, 0.01547303f, 0.02989678f, -0.09734609f, 0.24882895f, 0.14471781f, 0.20704906f, 
    0.04771904f, -0.05099170f, 0.00399333f, -0.08127972f, -0.06215738f, 0.04250385f, 0.00774438f, -0.07530901f, 
    -0.05618989f, -0.03533126f, -0.03421538f, -0.02222626f, -0.00038028f, 0.12275095f, 0.06104332f, -0.00308863f, 
    0.30908507f, 0.02542171f, -0.16121131f, 0.10138004f, -0.06816081f, -0.07096571f, -0.02626777f, -0.13126695f, 
    0.10528221f, 0.04121847f, 0.07111657f, -0.04986385f, 0.04184242f, -0.05730321f, 0.12363318f, -0.01412406f, 
    0.00536551f, -0.04278268f, -0.13258144f, 0.08665351f, 0.11975649f, -0.51887131f, -0.25987145f, 0.15170117f, 
    0.21892242f, 0.11923807f, 0.04367350f, 0.08215852f, -0.02682947f, -0.11986583f, 0.05801766f, 0.00137274f, 
    -0.03670162f, 0.01695396f, -0.01598089f, -0.03015906f, 0.00016712f, 0.01770861f, -0.02135327f, -0.07380728f, 
    -0.29419455f, 0.43447584f, -0.00555791f, -0.06963465f, -0.11413243f, -0.11032195f, 0.04580046f, -0.12423410f, 
    0.15314351f, -0.06951515f, -0.00560603f, -0.09587393f, -0.11269051f, 0.02725476f, -0.13564903f, -0.11753486f, 
    0.01651268f, -0.18346550f, 0.17238271f, -0.02856818f, -0.18949167f, 0.06664824f, -0.07199021f, 0.04043045f, 
    -0.07632344f, -0.06598188f, -0.23716372f, 0.17013261f, -0.05642982f, -0.01367604f, -0.09367143f, -0.01908307f, 
    -0.13597056f, 0.01504638f, 0.03194772f, 0.05873818f, 0.01049085f, 0.09307622f, 0.17333239f, -0.06822768f, 
    -0.45920449f, -0.61062127f, -0.00139242f, 0.06424444f, -0.09974662f, -0.00193667f, -0.09779868f, 0.01445718f, 
    -0.01838582f, -0.23188646f, -0.03354254f, -0.04704291f, 0.05778476f, 0.00107981f, -0.00734908f, 0.03035022f, 
    -0.05811925f, -0.02120445f, -0.15925123f, -0.08676808f, -0.11550560f, -0.35123321f, -0.26766884f, -0.06666752f, 
    0.01524109f, -0.13687673f, -0.04115684f, 0.03115763f, 0.01319408f, -0.01145142f, -0.09822334f, -0.01445718f, 
    0.07861914f, 0.04258443f, 0.02062961f, 0.02028727f, -0.06763297f, -0.00273499f, -0.08227666f, 0.10549047f, 
    0.52068573f, 0.26320025f, -0.02937433f, 0.08433196f, 0.17292553f, 0.10822908f, 0.03645434f, -0.04343292f, 
    0.10023742f, 0.05161360f, -0.00685007f, 0.02342533f, -0.10597049f, -0.04365361f, -0.08989847f, -0.02843134f, 
    0.01496389f, 0.00404009f, 0.06100318f, 0.05611299f, -0.75103313f, 0.22353867f, -0.27797219f, 0.12622656f, 
    0.34087068f, -0.03716987f, 0.12821335f, 0.04359734f, 0.02275071f, 0.00891765f, 0.03713623f, 0.01394115f, 
    0.05050181f, -0.23120429f, 0.00188663f, -0.10352315f, 0.00044369f, -0.13246292f, 0.06288507f, 0.08099172f, 
    -0.03122949f, -0.31982207f, 0.01614771f, -0.06775433f, -0.01443054f, -0.11247057f, 0.01339207f, 0.03375252f, 
    0.01066764f, 0.06617632f, -0.04820006f, 0.05318163f, -0.09297708f, 0.06291527f, -0.00266458f, -0.04658482f, 
    -0.02280444f, -0.06168791f, -0.02684534f, -0.00121085f, 0.02449737f, 0.01908152f, -0.05050205f, 0.13084187f, 
    0.08746149f, 0.03727459f, 0.11657178f, 0.12430906f, -0.01987867f, -0.01884494f, -0.01230125f, 0.06479646f, 
    -0.12475427f, -0.01076716f, -0.04730902f, -0.01472148f, 0.10217149f, 0.14387023f, 0.07811416f, 0.08738521f, 
    -0.25971282f, 0.14180951f, -0.15410416f, 0.03629306f, 0.21838072f, 0.05656455f, 0.04860457f, 0.00716968f, 
    0.06405916f, 0.04007470f, -0.07064766f, 0.00982083f, 0.04788255f, 0.00763781f, -0.08327536f, -0.05194144f, 
    0.03880057f, 0.03439377f, -0.02183336f, -0.05898535f, -0.26239794f, 0.30601063f, 0.14901638f, -0.18656226f, 
    -0.06659190f, 0.24660683f, -0.03198817f, 0.05232224f, -0.06204066f, -0.09448436f, 0.20769921f, -0.10108650f, 
    -0.05698887f, -0.10657754f, -0.01251730f, 0.06270757f, -0.08541475f, -0.12135175f, -0.15799993f, 0.06453722f, 
    -0.13806501f, 0.09196076f, -0.02309735f, 0.07343806f, 0.04239667f, 0.12986881f, 0.07115765f, 0.02555532f, 
    -0.06042745f, 0.03027326f, 0.12663683f, -0.08871437f, -0.05302412f, 0.05920822f, 0.10364287f, -0.12166589f, 
    -0.14751929f, 0.09826375f, -0.10606430f, 0.10548513f, 0.01776514f, 0.03935231f, 0.04024135f, 0.02399743f, 
    -0.21893907f, 0.02053301f, 0.05337036f, -0.00670474f, -0.02376573f, -0.10075840f, 0.03940168f, -0.05805138f, 
    -0.00157485f, 0.00039444f, 0.01435516f, -0.05112756f, 0.01299803f, -0.01850372f, -0.09106270f, 0.00303915f, 
    -0.56431180f, -0.04064135f, -0.07958259f, -0.08237755f, 0.28135064f, 0.01565507f, 0.00421349f, -0.06673185f, 
    0.13420725f, 0.03689754f, -0.03025749f, -0.08313824f, -0.02824258f, 0.11171751f, 0.03452758f, -0.02109161f, 
    0.05478460f, -0.07355604f, 0.11409374f, 0.00145675f, -0.26025459f, -0.01916352f, -0.13397436f, 0.03992178f, 
    0.03726402f, 0.01053717f, -0.01015318f, -0.00198014f, 0.17145818f, -0.04266966f, 0.01355472f, -0.19750412f, 
    0.08548529f, 0.03312553f, -0.00500928f, 0.07547078f, 0.12419294f, -0.01116596f, -0.01717622f, -0.01578345f, 
    0.09959836f, 0.39769861f, -0.39882162f, -0.23922998f, -0.01360592f, -0.05467632f, 0.01199708f, 0.06985682f, 
    0.00242883f, -0.07742445f, 0.04257010f, 0.04871679f, 0.04694449f, -0.02276233f, -0.03556004f, -0.04758431f, 
    0.09129059f, -0.19824234f, -0.11983616f, -0.05027773f, -0.10246427f, 0.30384433f, -0.42492867f, 0.21395203f, 
    -0.51329666f, -0.10171848f, -0.11082025f, 0.08494502f, -0.03661911f, -0.01501813f, -0.05651888f, -0.14914933f, 
    -0.02265274f, -0.05478497f, -0.00331582f, 0.06274488f, -0.01831765f, -0.00510901f, -0.16056567f, -0.00613074f, 
    -0.24195224f, 0.04740513f, -0.05851885f, -0.08837375f, -0.10328252f, -0.01297114f, -0.02265858f, -0.13449967f, 
    -0.12932099f, -0.04345871f, 0.11511613f, -0.02151081f, -0.03386429f, -0.01648904f, -0.19536254f, -0.02898143f, 
    -0.01587718f, -0.21321352f, -0.10724201f, -0.08410725f, -0.08508538f, -0.14668821f, -0.00504796f, 0.03869902f, 
    0.04716478f, 0.12608327f, -0.05974512f, -0.02276613f, 0.02385750f, 0.07177557f, -0.03716628f, 0.04344446f, 
    -0.02421381f, -0.13612661f, 0.00206795f, 0.03829055f, -0.05301133f, 0.12323330f, 0.10001022f, 0.04157830f, 
    -0.31939110f, -0.19538292f, 0.26976961f, 0.16850492f, 0.01644266f, -0.18122809f, 0.04998818f, -0.12212455f, 
    -0.03964317f, 0.10795379f, 0.00499867f, 0.09009258f, 0.06181659f, -0.02560141f, 0.03047119f, -0.09907649f, 
    -0.07991058f, -0.01430221f, 0.04872878f, 0.02300247f, -0.05791616f, 0.22268589f, -0.06489842f, 0.17509504f, 
    -0.06130641f, 0.00120388f, 0.06136646f, -0.05983235f, 0.14276206f, -0.01808173f, 0.08141087f, 0.00980874f, 
    -0.02108110f, -0.05586035f, -0.01559755f, 0.04269455f, -0.00451800f, -0.01594099f, 0.05491986f, 0.06305368f, 
    -0.48965570f, -0.17094176f, -0.19308268f, 0.07746571f, 0.26331982f, 0.04768123f, -0.01811744f, 0.07877528f, 
    0.12986211f, 0.06357481f, 0.11810513f, 0.00407795f, -0.04438502f, -0.05964018f, 0.01905677f, 0.06294641f, 
    -0.04020786f, 0.06666991f, 0.14560437f, 0.05596715f, 0.34126905f, 0.09031346f, -0.14873153f, 0.32683733f, 
    0.22876750f, 0.08901950f, 0.07190436f, 0.11892707f, 0.09000514f, 0.00318283f, -0.06757171f, 0.02887858f, 
    0.09274522f, 0.11914500f, -0.07596522f, -0.12014263f, 0.03146258f, -0.01455106f, 0.01286129f, -0.05999920f, 
    -0.39331207f, -0.30141255f, 0.07600075f, 0.06219250f, 0.09014266f, -0.14522898f, -0.08712688f, 0.01985320f, 
    -0.15807749f, -0.01387047f, -0.03301515f, -0.06519268f, 0.02194460f, -0.06687298f, 0.03305968f, -0.00662626f, 
    -0.06549090f, 0.02206573f, 0.11771863f, -0.16195497f, -0.14643209f, 0.04522728f, 0.25396824f, 0.10379612f, 
    -0.12283093f, -0.02543058f, 0.05108228f, -0.06827573f, -0.01078516f, 0.01722879f, 0.07590710f, -0.15202872f, 
    -0.03122953f, -0.05411887f, 0.00133671f, -0.24878643f, 0.04042152f, -0.00825792f, -0.00372620f, 0.03701264f, 
    -0.23824108f, 0.15365054f, 0.05688448f, -0.11924458f, -0.04349105f, -0.02536168f, -0.03694574f, 0.02479076f, 
    0.12817416f, 0.03464933f, 0.01557110f, -0.02508310f, -0.04783956f, 0.01460668f, 0.00379772f, 0.00822278f, 
    0.10583752f, -0.05571868f, -0.01218531f, 0.03680754f, -0.67049617f, 0.34648496f, 0.04537712f, 0.09496620f, 
    0.02699640f, 0.07406919f, -0.06284155f, -0.00793618f, 0.01410767f, 0.11072981f, -0.17613885f, 0.02435455f, 
    0.02368817f, -0.01030502f, -0.10990845f, 0.00335895f, 0.01766307f, 0.10936114f, 0.07943571f, -0.16680998f, 
    -0.83217835f, 0.08111190f, 0.06678966f, 0.09544589f, 0.17143138f, 0.05887948f, -0.10654312f, 0.04005547f, 
    0.01593386f, -0.02912377f, 0.03287717f, 0.10512386f, -0.07261558f, 0.03012214f, 0.06100067f, 0.12058485f, 
    0.00260041f, 0.19858123f, 0.05227637f, -0.00945137f, 0.29053444f, 0.01624455f, -0.13027193f, -0.02242947f, 
    -0.11183523f, 0.06198503f, -0.03683525f, -0.21257043f, 0.03340099f, -0.00335350f, -0.05225840f, -0.00576715f, 
    0.11763313f, 0.08386770f, 0.05745424f, -0.09650712f, -0.06089229f, -0.02583317f, -0.14887227f, -0.14169866f, 
    0.21487266f, 0.00485792f, 0.13393287f, -0.02076505f, -0.20569161f, 0.01663337f, -0.04158693f, -0.08829283f, 
    -0.02415134f, -0.06633086f, 0.00962947f, 0.14905119f, 0.00322759f, -0.01038440f, 0.03575190f, -0.00404875f, 
    0.17373833f, 0.00997156f, 0.08715399f, -0.02994895f, -0.01480194f, -0.04315335f, 0.04227267f, 0.14695176f, 
    -0.08109044f, -0.03641685f, 0.15638945f, -0.03696991f, 0.07017194f, 0.00980279f, 0.03014314f, -0.01700261f, 
    -0.04883330f, 0.07991534f, 0.16816646f, -0.11930748f, -0.12722301f, -0.01408184f, 0.16911840f, 0.01890797f, 
    0.15748452f, -0.17827892f, -0.27617937f, 0.07959816f, -0.33015347f, -0.09387041f, 0.05666087f, 0.08886864f, 
    -0.10822211f, -0.15177505f, -0.18973714f, 0.06365376f, 0.04665914f, -0.03921676f, 0.05057019f, -0.17208143f, 
    0.03107944f, 0.03226811f, 0.12551291f, -0.11874287f, 0.08861803f, -0.27604598f, 0.14386487f, 0.09550592f, 
    0.04861003f, -0.20401692f, 0.02489827f, 0.00853935f, -0.07689042f, 0.01312890f, 0.06908245f, 0.14254746f, 
    0.00308753f, -0.07974805f, 0.04446814f, -0.15131293f, 0.09398275f, 0.00023637f, 0.08870707f, 0.03612970f, 
    0.07448506f, 0.36894521f, 0.16638698f, -0.04246625f, -0.01922861f, 0.04993838f, -0.07799691f, 0.15129797f, 
    0.01868217f, -0.01759895f, -0.06289787f, -0.04729135f, -0.15355423f, 0.04408203f, -0.03107135f, -0.02141130f, 
    0.03460443f, -0.07798854f, -0.08285005f, -0.13696468f, -0.09870770f, -0.07758135f, -0.06759085f, 0.06110761f, 
    0.12221144f, 0.11183982f, -0.04681098f, 0.05587538f, -0.07580084f, 0.13111897f, 0.00672111f, -0.11217101f, 
    -0.05324410f, -0.02245013f, -0.04722445f, -0.05880428f, 0.00306809f, 0.02445978f, 0.15567888f, -0.16935369f, 
    -0.11395333f, 0.17709714f, -0.20872647f, -0.15950805f, 0.01032401f, 0.04658822f, 0.01300967f, -0.12880594f, 
    0.17193748f, 0.15250069f, -0.06254195f, -0.00664259f, 0.04006432f, -0.00944579f, -0.00276326f, 0.06169820f, 
    -0.00873434f, -0.34010541f, -0.01045867f, -0.08398224f, 0.10615861f, -0.18317580f, 0.04605120f, 0.02801923f, 
    -0.03776764f, 0.00628712f, -0.01661210f, 0.25825003f, 0.01752547f, 0.17398454f, 0.03594647f, -0.03582541f, 
    0.03572120f, -0.04784149f, -0.04359660f, 0.10036145f, -0.00802811f, -0.02103887f, -0.04682010f, -0.09721404f, 
    0.42649469f, 0.04511321f, -0.02441515f, -0.25635442f, -0.25343686f, -0.12817276f, 0.14295831f, -0.01473062f, 
    0.07227534f, -0.00212587f, 0.00455163f, -0.11211310f, 0.00730902f, 0.12009567f, 0.03778183f, -0.09863582f, 
    0.15387674f, 0.11141338f, 0.00442244f, 0.15201895f, -0.60515785f, -0.39233696f, 0.26876983f, 0.14850791f, 
    0.10230008f, -0.19999611f, -0.08248832f, 0.15932077f, -0.12027420f, -0.01651957f, 0.12610367f, 0.03715039f, 
    -0.13218459f, -0.22605774f, 0.03291559f, -0.05386981f, -0.00955048f, -0.20270538f, 0.03880877f, -0.10049616f, 
    0.11375009f, -0.07219144f, 0.02006640f, -0.24073783f, -0.07842740f, -0.04236653f, -0.00781352f, -0.04671075f, 
    -0.17497292f, 0.03438334f, 0.00062989f, -0.04425270f, 0.13983075f, 0.00453424f, 0.06657986f, -0.03824890f, 
    0.04812026f, 0.07223094f, -0.00767008f, -0.00663573f, -0.05100242f, 0.08280585f, 0.08458782f, -0.05430683f, 
    -0.00124478f, 0.16424264f, 0.06930435f, 0.00472098f, -0.05983241f, -0.19954422f, 0.07362431f, 0.01862696f, 
    -0.03346894f, 0.18162583f, -0.29438943f, -0.04227141f, 0.14450230f, 0.03638539f, 0.08023972f, -0.02500295f, 
    -0.57374668f, -0.26574966f, -0.27972421f, -0.16725694f, -0.07902385f, 0.12109438f, 0.01997263f, 0.11593594f, 
    -0.00049732f, -0.19146572f, 0.06442518f, 0.07286885f, -0.04801738f, -0.02087457f, -0.00463367f, 0.09314299f, 
    0.02446304f, 0.00090370f, -0.17984973f, 0.02471723f, -0.27835265f, 0.09234007f, 0.07644030f, 0.27314085f, 
    0.13638158f, -0.06683066f, -0.05135355f, -0.01797401f, -0.12681711f, 0.02613491f, 0.13723041f, 0.03276815f, 
    -0.04880825f, 0.09579673f, 0.11009426f, -0.01688633f, 0.07338184f, -0.02980610f, -0.04300230f, -0.25395390f, 
    0.00164951f, -0.07901304f, -0.05052057f, -0.03837027f, 0.22290258f, -0.07606275f, -0.01400082f, -0.04632145f, 
    0.04797672f, 0.06755061f, -0.05625828f, 0.14077401f, 0.19542009f, 0.17810734f, 0.04207621f, 0.09331401f, 
    0.12329308f, -0.01652538f, -0.20888300f, -0.06034087f, -0.06583594f, 0.20614894f, -0.05365552f, -0.06572316f, 
    0.10881587f, 0.02782063f, -0.16538911f, -0.04733540f, -0.09685646f, 0.03858525f, -0.00596186f, -0.01507487f, 
    -0.02385074f, -0.05706433f, 0.07238751f, -0.07851005f, 0.04805640f, -0.07031932f, 0.10694765f, -0.00789850f, 
    -0.52815634f, 0.42140046f, -0.34794286f, -0.11764143f, -0.27566868f, 0.10418635f, 0.07575241f, 0.08838709f, 
    -0.07408644f, -0.03419525f, -0.00471079f, 0.06212803f, -0.05658530f, -0.08553184f, -0.11870735f, 0.04699881f, 
    -0.07317948f, -0.00709795f, 0.07728250f, 0.00280256f, 0.06619750f, 0.27806291f, -0.01368289f, 0.05358620f, 
    -0.21366914f, 0.00078593f, 0.00072178f, 0.07269041f, -0.11684381f, 0.01080905f, -0.00340249f, -0.00444963f, 
    -0.07537831f, -0.01142406f, -0.07205446f, 0.04062064f, -0.12688217f, 0.05997696f, 0.12724043f, 0.06889460f, 
    -0.45442882f, -0.04152272f, 0.04906767f, 0.00586725f, -0.31187642f, 0.09888373f, -0.05240603f, 0.19850728f, 
    -0.12876019f, -0.10064837f, 0.03947591f, -0.04102664f, -0.16939062f, -0.03452617f, -0.13569772f, -0.05288468f, 
    0.02102159f, 0.17358699f, 0.04190423f, 0.02458038f, -0.11447707f, -0.14721723f, -0.08716597f, -0.23596670f, 
    0.07123598f, 0.09651926f, -0.05964801f, -0.11131316f, 0.00636223f, 0.16918188f, 0.22832674f, 0.11508270f, 
    0.12453456f, -0.08397974f, -0.03998943f, -0.05951498f, -0.09279329f, 0.02321586f, 0.15657409f, -0.01793773f, 
    -0.37459350f, -0.10756925f, 0.07404095f, 0.24793474f, -0.01415694f, -0.10648147f, -0.07206725f, -0.00429230f, 
    -0.10402209f, 0.04884743f, 0.15009153f, -0.00632799f, -0.01680797f, -0.04415350f, -0.04493523f, -0.01964823f, 
    -0.09066292f, 0.01822218f, -0.16311921f, -0.05696323f, -0.19704762f, -0.03555599f, -0.06765281f, 0.15138645f, 
    0.15243088f, 0.02887416f, 0.00875452f, -0.13496535f, 0.08251257f, 0.01929527f, 0.11138939f, -0.00080980f, 
    0.07127071f, 0.00219541f, 0.15127452f, 0.12007101f, -0.04896132f, -0.02335445f, -0.30480787f, -0.03360340f, 
    0.04795821f, 0.04454128f, -0.10427875f, 0.20600641f, 0.02602504f, -0.03126486f, -0.09587059f, 0.03448841f, 
    -0.03775529f, 0.04003898f, 0.02285034f, -0.05325068f, 0.03094059f, 0.00970063f, 0.23080362f, -0.00459987f, 
    0.01253929f, -0.01200953f, 0.15072711f, -0.03645137f, -0.14613505f, -0.16655031f, -0.18997562f, 0.20733370f, 
    0.10284629f, 0.07644121f, 0.00404061f, -0.05342072f, 0.00163964f, 0.21012849f, 0.00632634f, 0.15214272f, 
    0.16150069f, -0.03127842f, -0.00932022f, -0.23388328f, 0.00464227f, -0.02614846f, 0.02234205f, -0.14584146f, 
    -0.46639860f, 0.01431007f, -0.13195127f, -0.19133234f, 0.02358342f, 0.16961382f, 0.22836982f, 0.10986125f, 
    -0.07777788f, 0.03447500f, -0.15322833f, 0.09021107f, -0.00592455f, -0.24198456f, -0.08178094f, 0.06586163f, 
    0.10921437f, -0.09923778f, -0.07027674f, 0.04286702f, 0.03549909f, 0.22903237f, 0.17324182f, -0.04989694f, 
    -0.29919872f, 0.09081649f, -0.11990091f, -0.02563960f, -0.02555216f, -0.02363153f, 0.06711578f, -0.08100815f, 
    -0.09203810f, -0.07092681f, -0.01388215f, 0.04056481f, -0.11047143f, 0.12449495f, 0.03533632f, -0.05177309f, 
    0.19313028f, 0.11389148f, 0.02928047f, 0.05464083f, -0.00601685f, -0.13203350f, -0.10468478f, 0.04010054f, 
    -0.00143291f, 0.00558578f, -0.05387178f, -0.01269637f, 0.00190733f, 0.12936248f, 0.19655961f, 0.03700825f, 
    -0.02569421f, 0.02606399f, -0.28321272f, -0.01179446f, 0.15874010f, 0.05973780f, -0.00840699f, 0.25548121f, 
    0.34792459f, -0.03249982f, -0.07364349f, 0.13343513f, 0.03960067f, 0.02830358f, -0.03266544f, -0.08708953f, 
    -0.03789437f, 0.17547826f, -0.00006923f, 0.11856350f, 0.05237947f, -0.08403007f, 0.00539426f, 0.02034021f, 
    0.01449202f, -0.35413250f, 0.09435932f, 0.21544598f, -0.13150986f, 0.09233844f, 0.01440797f, -0.11816829f, 
    0.01230266f, -0.07100102f, -0.08327893f, 0.05544116f, 0.04992458f, 0.03676207f, 0.06571185f, 0.00614101f, 
    -0.05581694f, 0.02449143f, 0.07799994f, -0.00735585f, -0.49139720f, -0.00589689f, -0.21219885f, -0.15861060f, 
    -0.10944338f, 0.15194209f, 0.04677884f, -0.08598583f, 0.04480822f, -0.25769502f, 0.00249772f, 0.02337858f, 
    -0.17986149f, 0.03161407f, 0.00763855f, -0.05985256f, 0.01896548f, 0.01187591f, 0.07260401f, -0.02843772f, 
    -0.43713102f, 0.19194648f, -0.34919780f, -0.18364133f, 0.09937846f, -0.01351631f, 0.08277549f, -0.06178506f, 
    0.00716745f, -0.10175350f, 0.10831705f, -0.01816922f, 0.14759275f, -0.18167907f, 0.09946342f, 0.06952010f, 
    0.13683723f, -0.12720294f, 0.14201669f, -0.03572850f, 0.21549860f, 0.25154796f, 0.14083953f, -0.11172278f, 
    0.12763298f, -0.03901068f, 0.07737325f, 0.08404461f, 0.01913646f, -0.04008976f, 0.04235419f, 0.03670214f, 
    -0.11277624f, -0.10253710f, 0.03424378f, 0.11790670f, -0.14774607f, 0.08610871f, 0.13013247f, 0.04781852f, 
    0.03689345f, 0.04100721f, 0.11498507f, -0.14232920f, 0.15696245f, 0.00390430f, -0.13548577f, 0.02850764f, 
    -0.12641490f, 0.09423821f, -0.03655408f, -0.12331516f, 0.07109095f, -0.06759647f, -0.04888438f, -0.03984510f, 
    -0.36581466f, 0.01309550f, -0.06704558f, 0.07735521f, 0.05231938f, 0.17485714f, -0.19963060f, 0.06287323f, 
    0.27510625f, 0.06904291f, -0.23878136f, -0.03962676f, 0.06667277f, -0.01826314f, -0.01182908f, -0.01177611f, 
    -0.04387463f, 0.11262404f, 0.16308661f, -0.05235697f, 0.14520136f, -0.03677341f, -0.27303165f, -0.15253386f, 
    -0.16607550f, 0.18862310f, 0.01730136f, -0.04881966f, -0.05074228f, -0.14688194f, -0.01255665f, 0.01103349f, 
    0.00313275f, 0.18934920f, 0.00129626f, -0.04712836f, -0.05188953f, 0.01727752f, -0.11456807f, 0.13536470f, 
    -0.01170064f, -0.16829093f, -0.00823945f, 0.18822023f, 0.08122831f, 0.15605120f, 0.10637809f, 0.15123947f, 
    0.02079076f, -0.07128451f, -0.08444335f, -0.07295065f, 0.00369979f, 0.07284384f, -0.00139855f, -0.07153899f, 
    0.07159088f, 0.13144159f, -0.05410403f, 0.06296947f, -0.13239710f, 0.04179249f, 0.00646736f, 0.05374743f, 
    -0.44612920f, -0.33187425f, -0.01084825f, 0.15960534f, -0.34624177f, 0.01535402f, 0.03337775f, -0.07835463f, 
    -0.01519842f, -0.04839850f, 0.08729573f, 0.04135728f, 0.02146979f, 0.09729226f, -0.00937735f, -0.07818663f, 
    -0.03080084f, -0.04022449f, 0.01843679f, -0.05590608f, -0.69015706f, -0.20735410f, -0.24426411f, -0.23297295f, 
    0.06001524f, 0.17336822f, 0.03727186f, -0.00165125f, 0.00002852f, -0.13780083f, 0.11078092f, 0.09733161f, 
    -0.05364311f, -0.07996928f, -0.09222212f, -0.05302612f, -0.05996760f, -0.05538058f, -0.26867771f, -0.03895193f, 
    0.00425000f, 0.05302523f, 0.15493199f, 0.17330939f, -0.24546616f, -0.05696342f, 0.04908141f, 0.02991270f, 
    -0.04538102f, 0.09880363f, -0.02300914f, 0.07862207f, -0.02433866f, 0.00488973f, -0.02004907f, 0.08946203f, 
    0.00380222f, 0.13658513f, 0.15884548f, 0.15389718f, 0.16561954f, 0.00926198f, 0.15876479f, -0.04966279f, 
    -0.05872670f, 0.04063428f, 0.25539055f, -0.05704274f, -0.09784014f, -0.05144735f, -0.03827370f, -0.02515676f, 
    -0.07635192f, 0.04661055f, 0.13009605f, -0.05444288f, -0.01367298f, 0.04206721f, 0.01218608f, -0.00853765f, 
    -0.14753598f, -0.07602260f, 0.36598197f, 0.28012601f, -0.30398113f, -0.02211661f, -0.07587223f, 0.01423110f, 
    -0.01769965f, -0.06683515f, -0.06118645f, 0.08871522f, 0.04867626f, -0.03661571f, 0.03320049f, -0.10221803f, 
    -0.04743209f, -0.09271556f, 0.07439664f, -0.05759707f, 0.02647030f, -0.06104609f, -0.01646643f, 0.11734229f, 
    -0.12705022f, -0.26631773f, -0.07887213f, 0.01144100f, 0.06913467f, 0.12373009f, -0.09598629f, -0.07151203f, 
    0.15116853f, 0.13459262f, 0.19238441f, -0.11715312f, -0.01821829f, 0.03147542f, 0.05884395f, 0.15747672f, 
    -0.13911694f, 0.05950481f, -0.07274002f, -0.05499008f, 0.12655276f, -0.00054993f, 0.02656665f, -0.06670981f, 
    -0.10362274f, 0.00861890f, -0.01836181f, 0.07266419f, -0.14793050f, 0.01985588f, 0.00554961f, -0.06165801f, 
    0.04582737f, 0.06986310f, -0.00423649f, -0.10944100f, 0.03984253f, -0.04427919f, 0.03959764f, 0.16207680f, 
    0.03461303f, 0.10177650f, -0.15603022f, -0.07248897f, 0.00193828f, 0.03331985f, -0.11149102f, -0.00613349f, 
    -0.07132359f, -0.01881128f, 0.06433067f, -0.00076143f, -0.05877652f, -0.08277031f, -0.17729999f, -0.10785623f, 
    -0.13120402f, -0.18709157f, 0.10948996f, -0.10262109f, 0.01179216f, -0.01398004f, -0.00433604f, 0.08047804f, 
    -0.12513827f, 0.05893951f, 0.04118283f, -0.04034815f, 0.01665231f, 0.07460828f, 0.08651821f, -0.11058661f, 
    -0.04684386f, -0.06341486f, 0.05331405f, -0.04297643f, -0.04134610f, -0.04821402f, -0.08361191f, 0.00267725f, 
    0.35719734f, -0.13855867f, -0.10149366f, -0.01842567f, 0.11879744f, -0.02541727f, -0.14978816f, -0.02575109f, 
    -0.03771875f, 0.06428747f, 0.12393794f, -0.17468742f, -0.03116721f, -0.02047632f, -0.05822914f, 0.04985107f, 
    -0.04339151f, 0.04219878f, -0.16348638f, -0.10992144f, 0.03040446f, 0.00899730f, 0.10044987f, -0.02680431f, 
    -0.13536721f, -0.06841962f, -0.02137162f, -0.13608710f, -0.16081041f, -0.05580153f, -0.02718187f, -0.21033914f, 
    -0.02208926f, 0.04634262f, 0.00304604f, -0.01049598f, -0.15683661f, -0.09572124f, -0.24070331f, 0.25348994f, 
    0.07279753f, -0.01256544f, 0.08898579f, -0.08204857f, 0.13939953f, 0.09100793f, -0.06940981f, -0.00146281f, 
    -0.02993263f, -0.02734452f, -0.05059299f, 0.04383029f, -0.08729905f, 0.15196119f, -0.14038819f, 0.06489973f, 
    0.26596496f, -0.57615393f, 0.03872732f, -0.05972258f, 0.02972510f, -0.02158982f, -0.00347464f, -0.01762087f, 
    -0.02625129f, -0.10005187f, -0.11771355f, -0.01406418f, 0.04511908f, 0.01647364f, 0.02322267f, 0.03709774f, 
    -0.12954149f, 0.01379756f, -0.12541521f, 0.01495285f, 0.02275852f, -0.55953765f, -0.09500895f, 0.05565862f, 
    0.00790862f, 0.09927128f, 0.06977904f, 0.00757870f, 0.08745500f, 0.07593799f, 0.01212670f, -0.05727170f, 
    0.10389732f, 0.10854939f, 0.15240376f, 0.03546343f, 0.06054819f, -0.12247118f, -0.14112246f, -0.19199410f, 
    0.50522655f, -0.61899149f, -0.10832760f, 0.15207583f, -0.11859534f, -0.04178594f, 0.17137787f, -0.17109135f, 
    0.06048956f, 0.03603729f, 0.07887641f, 0.04583543f, 0.06604717f, -0.02519398f, 0.16527484f, -0.14765893f, 
    -0.03942406f, 0.08775979f, -0.17042777f, 0.09081995f, 0.02625884f, -0.38338712f, -0.17195097f, -0.14560042f, 
    0.21866657f, -0.11715995f, 0.06153874f, 0.00556251f, -0.00279876f, -0.02549926f, -0.05238195f, -0.06041240f, 
    -0.10126594f, 0.05011227f, 0.03228935f, -0.03244389f, -0.08621592f, 0.17906040f, -0.08860626f, 0.03578332f, 
    0.23246337f, -0.09804568f, 0.18102428f, 0.09406507f, 0.45568308f, 0.03517204f, -0.02827518f, 0.01885429f, 
    0.00514871f, -0.06776358f, -0.19322339f, 0.04384322f, 0.00213482f, 0.03040466f, 0.11141510f, -0.05143141f, 
    0.01776975f, 0.08560614f, 0.05932831f, 0.01207670f, 0.20085353f, 0.23115477f, -0.10471395f, -0.24396501f, 
    -0.10284801f, -0.07921100f, -0.08596750f, 0.11499599f, -0.15719633f, 0.01107581f, -0.01380599f, 0.00861173f, 
    -0.09741803f, -0.05171615f, -0.03350601f, 0.01206142f, -0.04703937f, 0.13059379f, 0.13674629f, 0.12865432f, 
    -0.17264807f, 0.38320744f, -0.06362872f, 0.10644268f, -0.51437682f, -0.02990150f, 0.02646655f, 0.05763867f, 
    0.10396026f, -0.02913257f, 0.09601875f, 0.09282025f, -0.06901442f, -0.05880656f, -0.11226665f, -0.04578700f, 
    -0.03764446f, 0.07865477f, 0.00261104f, 0.05049280f, -0.05758690f, 0.07614477f, -0.09279428f, -0.33861461f, 
    0.12681986f, 0.04400049f, -0.08572065f, 0.02720358f, -0.16344191f, -0.14541510f, -0.00770228f, -0.13781498f, 
    -0.13521126f, 0.01832821f, 0.05962040f, 0.03188716f, -0.00779656f, 0.14287119f, 0.07960442f, 0.06313860f, 
    -0.20209222f, -0.35713163f, -0.15858959f, -0.48706016f, 0.01402723f, -0.16479507f, -0.09343764f, -0.04153592f, 
    -0.10203693f, -0.05016568f, -0.11847907f, -0.01629857f, -0.09876268f, 0.16357936f, 0.02271356f, -0.05324491f, 
    0.02085232f, -0.01449573f, 0.02425869f, -0.07994357f, 0.13209042f, -0.18466011f, -0.17264909f, 0.13287818f, 
    -0.28341061f, -0.13007021f, 0.04694846f, 0.00770059f, 0.08740011f, 0.04260522f, -0.04178656f, -0.00741054f, 
    0.08926550f, 0.09859075f, 0.04484522f, 0.13596071f, -0.03621992f, -0.21521844f, -0.06510663f, -0.05842518f, 
    0.23177436f, -0.03155595f, -0.05247890f, -0.08006836f, -0.10822236f, 0.16446486f, 0.02902252f, 0.00832468f, 
    -0.09564473f, -0.00767709f, 0.03595102f, -0.00112516f, -0.07324917f, -0.03673391f, -0.06240976f, 0.00814580f, 
    0.03242934f, -0.02067448f, 0.02963027f, 0.08356872f, -0.31459060f, 0.23829789f, -0.03868740f, 0.01459147f, 
    -0.05680411f, -0.14660244f, 0.06006693f, 0.00223563f, -0.02198971f, 0.05702917f, 0.02040260f, 0.08377573f, 
    0.11876451f, 0.02782789f, 0.01839185f, 0.11404908f, -0.10261996f, 0.06646712f, -0.00667335f, 0.08680155f, 
    -0.18655601f, 0.20921020f, -0.06146326f, 0.15402935f, -0.41886067f, -0.10075701f, -0.02148922f, 0.09254815f, 
    0.07180178f, -0.01740677f, -0.06975102f, -0.10542651f, 0.00299624f, 0.03826736f, -0.10686696f, -0.02634290f, 
    -0.14840528f, -0.00026309f, -0.17514449f, -0.03916060f, 0.34540939f, -0.23906900f, 0.02402317f, -0.39294234f, 
    0.29553294f, 0.02218392f, -0.14798106f, -0.03374776f, -0.08327627f, -0.03168549f, 0.01186680f, -0.04649793f, 
    0.12481534f, -0.09587058f, 0.00510870f, 0.01635757f, -0.06841454f, -0.11048878f, -0.04779610f, 0.13594510f, 
    0.21459913f, -0.64064628f, 0.00170245f, -0.22642784f, 0.03739661f, -0.10491860f, 0.02643328f, -0.04358537f, 
    -0.02277890f, -0.14425516f, 0.08012735f, 0.00689631f, -0.10738794f, 0.24104343f, 0.00791192f, 0.03427303f, 
    0.01056703f, -0.00255804f, -0.10459111f, 0.01692009f, -0.31311086f, -0.24278927f, -0.01528949f, 0.01022748f, 
    0.12093360f, -0.06534597f, 0.13313150f, -0.02836351f, -0.08811616f, 0.07652905f, -0.02121991f, 0.01569712f, 
    0.07729233f, 0.01369640f, -0.13441369f, -0.05774937f, -0.03006870f, 0.00732286f, 0.02962424f, -0.08047862f, 
    -0.16842528f, -0.08158442f, 0.20535232f, 0.14697245f, -0.10805873f, 0.15949056f, 0.06227663f, 0.07175734f, 
    0.01307883f, 0.00427148f, -0.05830566f, -0.01108294f, 0.15804930f, 0.17132458f, -0.01376274f, 0.07218929f, 
    0.20091075f, 0.02024520f, -0.06513444f, -0.05440545f, -0.11680838f, 0.03732208f, -0.19746277f, -0.26907834f, 
    -0.04822950f, 0.11023977f, 0.09538885f, 0.05589636f, -0.11267778f, 0.05003979f, -0.04186904f, 0.01069981f, 
    0.05626760f, -0.07209739f, -0.08047377f, 0.11328907f, -0.18888053f, 0.12007499f, 0.07808109f, -0.03006526f, 
    0.01713404f, -0.10527287f, -0.02230122f, 0.12904836f, 0.11908626f, 0.03464074f, 0.11673099f, -0.19969542f, 
    -0.12235329f, 0.03056178f, 0.02562862f, 0.02817189f, 0.02278047f, -0.07825790f, -0.09172249f, -0.08330088f, 
    0.03708911f, 0.01589514f, -0.13840491f, -0.11735153f, -0.11748259f, 0.26891086f, 0.11524352f, -0.02662915f, 
    -0.14278977f, 0.06997535f, 0.10352952f, 0.05686291f, 0.08630844f, 0.01973239f, -0.11272534f, 0.06802120f, 
    -0.02802811f, -0.09739403f, 0.05118648f, 0.01031315f, 0.10474653f, -0.14323369f, 0.00131757f, -0.12823197f, 
    0.24691457f, -0.37384865f, 0.02819935f, 0.09607612f, 0.00472584f, 0.16311488f, -0.03046192f, 0.18304221f, 
    0.02173786f, 0.03239921f, -0.05410754f, 0.03405660f, -0.03911867f, -0.02960429f, -0.02297629f, 0.02304750f, 
    -0.03597137f, 0.11812636f, 0.13020445f, 0.00346136f, -0.49979088f, -0.02097635f, -0.04392573f, -0.25464976f, 
    0.13265702f, -0.03206112f, 0.01847056f, 0.19811651f, -0.22154753f, -0.05168185f, -0.07140308f, -0.16360858f, 
    0.05731525f, 0.03866315f, 0.06252472f, 0.03527445f, 0.10553263f, -0.08504784f, 0.22102357f, 0.22178586f, 
    0.02245160f, 0.08974425f, 0.08202708f, 0.07922588f, -0.16264091f, -0.00708097f, -0.15560143f, -0.06279922f, 
    0.02752663f, 0.05077604f, 0.16031125f, 0.04259358f, 0.01366667f, -0.01852928f, -0.01198427f, -0.02022853f, 
    0.01527293f, -0.08367895f, 0.10429184f, -0.34376845f, -0.44482902f, 0.11830996f, -0.18023930f, 0.08072741f, 
    -0.15221100f, -0.12700532f, -0.02160387f, 0.00425003f, 0.07791809f, 0.06755470f, -0.00323686f, -0.08922575f, 
    0.02401272f, 0.05408998f, 0.01633392f, 0.04052337f, -0.04064628f, -0.08698624f, -0.05254480f, 0.07678285f, 
    0.03421151f, 0.13325730f, 0.02084283f, -0.06870227f, 0.31298018f, -0.00592145f, 0.05877870f, -0.01401795f, 
    0.04629271f, 0.03070524f, 0.02667506f, -0.00702723f, 0.06504571f, 0.05799505f, -0.11734614f, 0.09213984f, 
    0.04020359f, 0.05819334f, 0.03953961f, 0.06011943f, -0.12642477f, 0.36821985f, 0.30469552f, 0.01100128f, 
    -0.44244769f, 0.25890473f, -0.01356573f, 0.02183679f, 0.08852378f, -0.06321473f, -0.09697288f, -0.00758290f, 
    -0.12388369f, 0.07936933f, -0.07479099f, -0.00639769f, -0.06911633f, -0.02958051f, -0.06892391f, -0.16597144f, 
    -0.11666474f, -0.09333870f, -0.09557637f, 0.14912339f, 0.14976849f, 0.22760652f, -0.04038015f, 0.02508241f, 
    0.11148358f, -0.14035811f, -0.01725974f, -0.07897301f, 0.04490563f, -0.07227892f, -0.20138837f, 0.07790080f, 
    0.07961571f, -0.16203573f, 0.09164095f, 0.13830663f, -0.14460780f, 0.04369901f, 0.03782120f, 0.03698843f, 
    0.11887448f, 0.07156935f, 0.02870361f, 0.11206206f, 0.04932096f, 0.07401840f, -0.04226603f, -0.00872120f, 
    0.06875107f, -0.10018858f, 0.23604497f, 0.06574155f, -0.02035587f, -0.01368518f, 0.16565886f, 0.05166487f, 
    0.06108983f, 0.00994467f, 0.18158226f, 0.11503410f, 0.06924217f, 0.05467887f, 0.06431356f, -0.10003569f, 
    -0.01776115f, -0.04926950f, -0.02121282f, 0.05068544f, -0.06426961f, 0.00229321f, -0.06259126f, -0.04026707f, 
    -0.05077412f, -0.03687891f, 0.11238296f, -0.07147627f, -0.18487613f, -0.10824038f, -0.31775096f, -0.04767929f, 
    -0.00608148f, -0.05163349f, -0.00055011f, -0.08532624f, 0.07565008f, -0.11169157f, -0.02612602f, 0.03418003f, 
    -0.08283627f, -0.04161470f, 0.00394549f, -0.02943932f, -0.12613194f, -0.05312596f, -0.09832474f, -0.08969128f, 
    0.06699698f, 0.05429340f, 0.14072329f, 0.00725332f, 0.13787372f, -0.09497458f, -0.03057383f, -0.01021224f, 
    -0.02629984f, -0.01021010f, -0.03388092f, -0.04333061f, -0.02445111f, -0.02560405f, -0.08895892f, -0.08594524f, 
    -0.07678603f, 0.04526484f, 0.15027207f, -0.00266687f, -0.36042783f, 0.11679494f, -0.07653420f, 0.02423647f, 
    -0.02142256f, -0.08236200f, 0.01503057f, -0.04254216f, -0.01989086f, -0.11170688f, -0.03139247f, 0.04452108f, 
    -0.06594794f, -0.06137120f, -0.04614624f, -0.03851942f, -0.04244575f, 0.00476351f, -0.01393436f, -0.06762860f, 
    0.06449529f, -0.11676621f, 0.16781133f, 0.16118900f, 0.39346868f, 0.06908307f, 0.05621439f, 0.03070344f, 
    0.08631105f, 0.01131681f, -0.04588840f, 0.03200011f, -0.08553182f, -0.03797114f, -0.08654284f, -0.04986408f, 
    -0.01747561f, -0.02752735f, -0.06800909f, 0.00078890f, 0.02732793f, -0.05292125f, -0.04758970f, -0.13543697f, 
    -0.03335251f, -0.04514136f, -0.10653958f, -0.04530461f, -0.02317165f, -0.05565777f, 0.08234084f, 0.01943544f, 
    -0.02500376f, -0.01636366f, -0.02996546f, -0.01866922f, -0.07322676f, -0.00803235f, -0.01366095f, -0.01030832f, 
    0.37165084f, 0.39259252f, 0.21717758f, 0.16342255f, 0.06877176f, 0.02452386f, 0.10627643f, 0.01180941f, 
    0.08175977f, -0.01561709f, -0.03984055f, 0.05507768f, 0.11668327f, -0.03436493f, 0.05449756f, 0.00819178f, 
    0.01321288f, 0.09805481f, 0.06244637f, -0.08592385f, 0.12483638f, 0.18144870f, -0.13910805f, 0.02952261f, 
    0.14253429f, -0.13476889f, 0.13269907f, -0.11695862f, 0.03527074f, -0.00181387f, -0.15876834f, 0.06229602f, 
    -0.08663104f, -0.06332719f, -0.06497939f, 0.03918950f, 0.07822695f, 0.10127341f, -0.04959572f, -0.05299966f, 
    -0.09710441f, 0.20968726f, -0.24265996f, 0.08889658f, 0.02107497f, -0.01757125f, 0.01248610f, -0.12063464f, 
    0.17697045f, -0.06185780f, -0.09917617f, 0.00296059f, -0.03258321f, 0.00290172f, 0.04904158f, -0.03531702f, 
    -0.10827887f, 0.06090560f, -0.11508976f, -0.01731877f, 0.20751424f, 0.08979596f, 0.06418953f, 0.09037083f, 
    0.28280723f, -0.13581188f, -0.04602420f, -0.02628040f, -0.07409454f, -0.01208162f, -0.02590607f, 0.03696329f, 
    -0.12034717f, 0.00275934f, -0.07042953f, 0.05108469f, -0.08416371f, 0.01807813f, -0.02792895f, -0.09170834f, 
    -0.36970225f, -0.04859671f, -0.30498025f, -0.15856549f, 0.07265176f, -0.00115044f, -0.15712485f, -0.11317223f, 
    0.01881591f, -0.12066940f, -0.10911524f, 0.07095674f, -0.02508644f, 0.00129996f, -0.02882799f, -0.00754630f, 
    -0.05406123f, -0.01907303f, -0.04216736f, 0.00781345f, 0.17526740f, 0.11218446f, 0.14639868f, 0.07531896f, 
    0.23462166f, 0.01554043f, 0.02847271f, -0.03992016f, 0.02743115f, -0.09753569f, -0.02254972f, -0.02376429f, 
    -0.09203783f, -0.05853262f, -0.05706239f, -0.04733342f, 0.07274164f, 0.04298108f, -0.01011653f, -0.08026419f, 
    0.14698000f, 0.16872637f, 0.29171383f, 0.29195762f, 0.22684377f, 0.09572358f, 0.08513718f, 0.03725949f, 
    0.00882950f, -0.03385776f, 0.01033682f, 0.00524862f, -0.05509593f, 0.03366692f, -0.10339575f, -0.12951253f, 
    -0.08248793f, 0.08356772f, -0.05086026f, -0.05867836f, 0.02644650f, -0.07694115f, -0.03064979f, -0.10054191f, 
    -0.27229747f, -0.06493874f, -0.12121090f, 0.00771581f, -0.10118110f, -0.08467481f, 0.08004485f, -0.00809669f, 
    -0.01632598f, 0.05005984f, -0.04413061f, 0.00442749f, -0.03530603f, -0.00070013f, -0.07815810f, -0.03876567f, 
    0.22726315f, -0.30287120f, 0.08172277f, 0.01125834f, 0.13481098f, -0.00652550f, -0.06004210f, -0.02312385f, 
    -0.09353013f, -0.00216161f, -0.06432129f, -0.05929973f, 0.02686226f, -0.01225995f, -0.03775918f, -0.05400700f, 
    0.00562428f, 0.03815172f, 0.02360043f, 0.02252097f, -0.21953255f, 0.06632473f, -0.46028882f, 0.08072120f, 
    0.10576534f, -0.05533530f, -0.08386607f, -0.13922521f, -0.01758428f, -0.06504257f, -0.12481326f, 0.07449645f, 
    -0.03360805f, -0.01245715f, -0.11143479f, -0.03338372f, -0.01599840f, -0.02423174f, -0.06322165f, 0.01773214f, 
    -0.17011538f, -0.03780962f, -0.23606676f, -0.09901157f, -0.23247810f, 0.04169300f, -0.05704108f, 0.05972200f, 
    -0.04563922f, -0.19584410f, -0.08017658f, -0.02508993f, -0.09736290f, -0.02780695f, -0.08050074f, -0.02996764f, 
    0.04101819f, -0.05318850f, 0.03832603f, -0.14278646f, 0.23164783f, 0.11757344f, 0.34302825f, 0.01618867f, 
    0.24375677f, -0.06188375f, 0.13185970f, -0.00061520f, 0.03444145f, 0.07393223f, -0.03155984f, 0.10607924f, 
    -0.17330819f, 0.00517460f, -0.14429723f, 0.01413218f, 0.04456729f, 0.03084727f, 0.02130717f, -0.08774173f, 
    -0.06701101f, 0.04336611f, 0.23942563f, 0.00007637f, 0.16379856f, 0.01055638f, 0.15722749f, 0.03569837f, 
    -0.03777315f, -0.06516976f, 0.03694965f, 0.07347502f, -0.03538965f, -0.05526414f, -0.02938616f, -0.18312687f, 
    0.05899365f, 0.07723872f, -0.00206432f, 0.01094719f, -0.19509828f, -0.08533313f, -0.00582382f, -0.17386529f, 
    -0.16233973f, -0.07591186f, 0.04006332f, -0.02929682f, -0.06602316f, 0.04413979f, 0.02566894f, -0.09553736f, 
    -0.03533759f, -0.06818575f, -0.00179038f, -0.05416626f, 0.01705999f, 0.01239988f, -0.00500790f, 0.00540414f, 
    0.02995262f, 0.09335967f, -0.09990747f, -0.07691418f, 0.08632213f, -0.16430347f, 0.11986639f, -0.00201108f, 
    -0.03842076f, 0.04266869f, -0.06840245f, -0.09247368f, 0.00552597f, -0.06495945f, 0.16851029f, 0.00173663f, 
    0.04171910f, -0.09066752f, -0.11618780f, 0.04979102f, 0.14460874f, 0.04379649f, 0.06828643f, 0.10560320f, 
    0.18984520f, 0.07181249f, 0.04827406f, -0.02480050f, -0.06056647f, -0.05553961f, -0.05302594f, 0.02479296f, 
    -0.05803492f, -0.17459165f, -0.03969454f, 0.00719153f, 0.02623188f, 0.04980964f, -0.03751452f, -0.06982769f, 
    -0.02959802f, 0.22443214f, 0.04937645f, -0.10663106f, 0.02496526f, 0.02698928f, 0.15207900f, -0.16615108f, 
    0.10392947f, 0.07874093f, -0.04613359f, 0.04537448f, -0.03055048f, 0.03265834f, -0.05289685f, 0.01834541f, 
    0.04706030f, 0.17764491f, -0.09530069f, 0.05967173f, -0.23351885f, -0.00269721f, -0.31713262f, -0.11032020f, 
    -0.01802038f, -0.03049114f, -0.04071765f, -0.01490599f, 0.00767839f, -0.07291873f, -0.12439505f, -0.06004209f, 
    0.05587089f, -0.09856365f, -0.08598722f, -0.04410778f, 0.05292739f, -0.11476142f, -0.06875227f, 0.07938382f, 
    0.27783939f, -0.58515817f, 0.11866630f, 0.07631058f, -0.26188213f, 0.15460266f, -0.00023355f, -0.00592146f, 
    -0.09791477f, -0.00085487f, -0.01760500f, 0.07432114f, -0.03512547f, 0.04006680f, -0.09850064f, -0.02273634f, 
    0.20251474f, -0.03639239f, -0.12448963f, -0.07119928f, 0.28373659f, 0.03406505f, 0.34503630f, 0.01780645f, 
    0.03702252f, 0.11067988f, 0.05112654f, -0.07297128f, -0.03950843f, 0.03301713f, -0.04502849f, 0.03638236f, 
    -0.02315352f, -0.02212385f, -0.19222520f, -0.02397759f, -0.05386478f, -0.03066212f, 0.09673828f, -0.03510237f, 
    0.06178960f, -0.20944813f, 0.03498181f, -0.18282646f, -0.15494624f, -0.01002312f, -0.00271264f, 0.01324651f, 
    -0.07329372f, -0.05320808f, -0.02627461f, -0.13031039f, -0.10607243f, -0.03506829f, -0.08352291f, -0.08651312f, 
    0.07968392f, -0.02131049f, -0.01942015f, -0.01327958f, -0.06191455f, -0.01991669f, -0.00939993f, -0.15959448f, 
    -0.19639255f, -0.07401112f, -0.02530598f, -0.03334988f, -0.04204515f, -0.05789687f, 0.05164524f, -0.03423684f, 
    -0.01873154f, 0.02329196f, -0.08637754f, -0.03181318f, -0.03279836f, -0.06366378f, -0.07644916f, -0.02074425f, 
    -0.21534970f, 0.17887898f, -0.07258442f, 0.21965516f, 0.05138223f, 0.05547176f, -0.19614179f, -0.04632537f, 
    -0.00668504f, -0.03356563f, -0.02524653f, 0.02674258f, 0.00616864f, -0.02749492f, -0.07905556f, 0.05759485f, 
    -0.02702472f, -0.01805508f, -0.07275376f, -0.06409245f, 0.01338533f, -0.56969392f, -0.14663714f, -0.15548368f, 
    -0.25549936f, -0.03560146f, -0.00782138f, -0.05623239f, 0.03494362f, -0.00368594f, -0.03534169f, -0.02791370f, 
    -0.02883416f, -0.00710334f, -0.05103752f, -0.07540943f, 0.06781844f, 0.02452220f, 0.00412829f, -0.00187901f, 
    0.05471361f, 0.10434205f, 0.10764438f, -0.14174716f, -0.01618654f, 0.01473565f, 0.05979229f, -0.06913735f, 
    -0.10825270f, 0.01285254f, -0.04533889f, 0.03200011f, 0.02380993f, -0.19411443f, -0.02792241f, -0.00305721f, 
    0.01352218f, 0.01136676f, -0.01200368f, 0.05096295f, 0.03924219f, 0.02552631f, -0.15867849f, -0.00618446f, 
    0.17364670f, 0.01016617f, -0.13820647f, -0.06435847f, 0.03113824f, -0.04999994f, -0.10830069f, -0.02739653f, 
    -0.06841239f, -0.00167321f, -0.09381589f, -0.00977149f, -0.03712032f, -0.15069041f, -0.02826167f, -0.10124494f, 
    -0.07848863f, -0.09032777f, 0.21688932f, -0.02809197f, 0.16567893f, -0.04975553f, -0.06904119f, 0.06473993f, 
    -0.07191454f, -0.06374906f, -0.00836165f, -0.00411459f, 0.01653593f, 0.01988059f, 0.06492542f, 0.00694876f, 
    -0.01412013f, 0.08354823f, -0.09452008f, 0.08320195f, 0.19496617f, 0.25970522f, 0.14030564f, 0.09074228f, 
    0.02893335f, -0.01288377f, -0.01871897f, -0.14420073f, -0.08854166f, -0.05717113f, 0.10784170f, 0.02773790f, 
    0.04886390f, 0.02525766f, -0.10011880f, -0.17337152f, -0.00140057f, -0.02586462f, 0.05611506f, -0.16723323f, 
    0.00046199f, -0.05978901f, 0.08555764f, -0.19502245f, -0.24212590f, -0.06636291f, -0.05059290f, -0.06335003f, 
    -0.03194405f, -0.13520178f, 0.05948661f, 0.04044984f, 0.01094764f, 0.01839439f, -0.04322665f, 0.06609524f, 
    -0.06220410f, -0.09601894f, -0.18233268f, 0.04306380f, 0.16235960f, 0.13491991f, -0.20265670f, 0.09448199f, 
    -0.08438907f, -0.03615652f, 0.02093789f, -0.12471706f, -0.06926828f, 0.01989456f, 0.04794467f, -0.01501109f, 
    -0.02421197f, -0.00941229f, 0.02237434f, 0.09561061f, -0.05591571f, -0.11109669f, 0.16961530f, -0.06102487f, 
    -0.30042586f, -0.16847144f, 0.27160504f, -0.06119927f, 0.09504195f, -0.14681749f, -0.16497378f, -0.00301676f, 
    -0.08056227f, -0.02013132f, 0.15097797f, -0.00382813f, 0.09192459f, -0.09613394f, 0.02743713f, 0.02283250f, 
    0.00137293f, 0.04837893f, -0.03731078f, 0.08519501f, 0.19459969f, 0.15909483f, 0.03091978f, 0.03950747f, 
    0.15957581f, -0.03628518f, -0.14029436f, -0.06504171f, -0.10111940f, -0.03874586f, 0.03669335f, -0.08133011f, 
    0.01818869f, -0.09554128f, -0.00038595f, 0.06368405f, -0.00824454f, 0.08388907f, 0.06521151f, 0.05405857f, 
    -0.12100901f, -0.21146390f, -0.07504229f, 0.08460647f, -0.05548864f, 0.03731573f, -0.17398773f, -0.11476910f, 
    0.03144240f, 0.09446749f, 0.06392779f, 0.03078379f, -0.03402292f, 0.13490118f, 0.07060517f, 0.14778164f, 
    0.08485099f, -0.12864724f, 0.02706077f, -0.03052623f, -0.02508418f, 0.21488599f, 0.02852760f, -0.03704268f, 
    -0.24422772f, -0.06867796f, 0.04085953f, 0.04105068f, -0.02990528f, -0.07277991f, 0.10819481f, 0.07835617f, 
    -0.00971907f, 0.08003249f, 0.03139864f, -0.09787376f, -0.02471240f, -0.19266871f, 0.18530656f, -0.05989483f, 
    -0.02492433f, 0.14692298f, -0.06238547f, -0.12170930f, 0.00003222f, -0.07221712f, -0.05657390f, -0.02553480f, 
    -0.13605364f, -0.14944579f, 0.21491179f, 0.08126782f, 0.02447372f, 0.08429823f, -0.06214881f, -0.06468093f, 
    0.11088471f, -0.02059523f, 0.05497573f, -0.00288170f, -0.32804173f, -0.16603059f, 0.14618705f, -0.23117846f, 
    -0.17888525f, 0.11363749f, -0.00666732f, -0.04633214f, -0.00463907f, -0.09916067f, 0.05413935f, 0.00915224f, 
    0.01429380f, -0.02140205f, -0.07979141f, -0.15143457f, 0.04372307f, -0.00176943f, -0.29423851f, -0.05937798f, 
    -0.05212950f, 0.00635652f, -0.11735403f, 0.10467635f, 0.17717324f, 0.14393796f, 0.01088976f, -0.11854149f, 
    -0.05958187f, -0.09736693f, 0.10390279f, 0.00892067f, 0.06918422f, -0.03082652f, 0.07209487f, -0.01960353f, 
    0.09258503f, -0.00828918f, 0.12029209f, -0.19639359f, -0.11907645f, 0.14436078f, 0.02718347f, -0.21425393f, 
    -0.31940836f, -0.05770881f, -0.01930413f, -0.08630148f, -0.02523393f, -0.21047959f, 0.05793713f, -0.03427571f, 
    -0.00168046f, -0.02950516f, 0.07833053f, -0.01211122f, -0.03452262f, -0.15495872f, -0.14416717f, -0.00144970f, 
    -0.30181992f, -0.10217641f, 0.22980073f, -0.02924153f, 0.13933532f, -0.09740571f, -0.09124219f, -0.08689423f, 
    -0.20842837f, -0.15143856f, 0.02534105f, 0.00847436f, 0.02016239f, -0.24781746f, 0.07148263f, 0.02889406f, 
    0.08269490f, 0.00997523f, -0.06033340f, 0.00711869f, 0.24788642f, 0.26479471f, -0.00501015f, 0.07206204f, 
    0.20518635f, -0.08274270f, -0.01242384f, -0.10127395f, -0.04715937f, -0.07363252f, -0.01756627f, -0.05033030f, 
    -0.01098260f, -0.14448142f, 0.02714115f, -0.04577044f, 0.03882812f, 0.05092253f, 0.09552045f, 0.03353748f, 
    -0.07960412f, -0.13205267f, -0.06822682f, -0.27597299f, -0.04138453f, -0.08905253f, -0.02235939f, -0.03723318f, 
    -0.06936099f, -0.12571612f, 0.04521040f, 0.07996156f, 0.01066469f, 0.03529835f, 0.01569597f, 0.03137355f, 
    -0.02027632f, -0.01746804f, -0.23297310f, -0.02766452f, 0.02067260f, 0.02138102f, -0.09209248f, 0.11115874f, 
    0.02485727f, 0.00359980f, 0.01898891f, -0.04650506f, -0.15290318f, -0.06860936f, 0.05889776f, 0.02068031f, 
    0.03407702f, 0.01034667f, -0.00290991f, -0.09161915f, 0.13714620f, -0.07348394f, 0.06303287f, -0.06111478f, 
    0.22603974f, 0.02299439f, -0.22949088f, 0.14458767f, 0.11600021f, 0.06192011f, 0.07227570f, -0.06602297f, 
    -0.06623960f, -0.03155580f, -0.05503766f, -0.07756583f, -0.06989764f, -0.00017994f, -0.03934213f, 0.04259999f, 
    -0.06893922f, 0.00081970f, 0.09614127f, -0.02851892f, -0.24749711f, 0.31447077f, 0.11658547f, -0.08299665f, 
    0.06232617f, -0.05979155f, -0.09141866f, 0.05358218f, -0.05323124f, 0.01339861f, 0.10580944f, -0.03424564f, 
    -0.11001175f, 0.01669046f, 0.07050320f, -0.10077036f, 0.02098237f, -0.00617084f, 0.15563948f, 0.01871825f, 
    0.04398061f, 0.06217590f, 0.16598499f, -0.00983497f, 0.15252577f, -0.14776443f, -0.12913746f, 0.11998170f, 
    0.02707336f, -0.00017514f, -0.03297758f, -0.15222092f, -0.03031468f, -0.24066287f, 0.02551463f, 0.06083504f, 
    -0.08888235f, -0.11289670f, 0.07249414f, -0.00923153f, 0.13676423f, 0.19022171f, -0.04430409f, 0.02740532f, 
    0.11136311f, -0.05898066f, -0.03451694f, 0.06772067f, -0.06141900f, -0.05175789f, 0.08378989f, -0.03663301f, 
    -0.04010176f, -0.07883980f, -0.02367028f, -0.07467142f, 0.00595370f, -0.03308971f, 0.13819891f, -0.09711547f, 
    -0.18004540f, -0.11912113f, -0.12078764f, -0.11659889f, 0.00906842f, -0.03115591f, 0.03073848f, 0.10566311f, 
    -0.04569944f, -0.10184752f, 0.13536380f, 0.04380434f, -0.04746836f, 0.10259372f, 0.15698920f, -0.09694943f, 
    -0.00190857f, -0.03149159f, 0.03768858f, -0.01793700f, -0.14990333f, -0.17556335f, 0.01224299f, -0.39506918f, 
    -0.27302477f, -0.06778848f, 0.07908606f, -0.02289223f, -0.08070047f, -0.11992744f, 0.09013172f, 0.00100717f, 
    -0.04389574f, 0.12493297f, -0.07473995f, -0.00639564f, 0.08362043f, -0.06999828f, -0.39549354f, 0.00221896f, 
    -0.08101048f, 0.16337883f, -0.12564945f, 0.05364790f, -0.18361457f, 0.01572959f, 0.05185144f, -0.06734318f, 
    0.00427874f, 0.04332833f, 0.21087904f, 0.02230661f, 0.03337142f, 0.05826348f, -0.04902405f, 0.04717837f, 
    0.03858975f, -0.14273165f, 0.12666181f, 0.01325791f, -0.00595741f, -0.09247806f, -0.05009408f, -0.04768124f, 
    0.12255836f, 0.08256097f, 0.05307978f, -0.06576671f, -0.06481824f, -0.05514174f, 0.06983141f, 0.04950182f, 
    0.04133689f, 0.02629870f, 0.03699725f, -0.03844739f, 0.07083032f, 0.12506668f, -0.03786499f, -0.02148576f, 
    -0.00456093f, 0.15605491f, -0.01930253f, 0.16937940f, 0.12032497f, -0.05341823f, -0.02194039f, -0.09734783f, 
    -0.17278038f, 0.08538902f, -0.05540966f, -0.05875121f, -0.05123571f, -0.12277616f, -0.01438174f, 0.03556115f, 
    -0.06210731f, -0.02476059f, 0.15728925f, -0.00330349f, -0.15097637f, -0.06647848f, 0.22780402f, -0.15590599f, 
    -0.03854221f, -0.03386709f, -0.04973369f, -0.04661988f, -0.11763000f, -0.08583283f, 0.02344161f, -0.00851626f, 
    -0.02465214f, -0.00280515f, -0.01911246f, -0.04393642f, -0.15991768f, 0.00786870f, -0.23042358f, 0.02112944f, 
    0.14605339f, 0.04296253f, -0.07703939f, 0.06970949f, 0.25606427f, 0.11719951f, 0.06956109f, -0.04628825f, 
    -0.05045779f, -0.02226725f, -0.03742630f, 0.03495103f, -0.00357093f, -0.00706912f, -0.06282745f, 0.03492197f, 
    0.03694869f, 0.08387463f, 0.02372045f, 0.04239447f, 0.10976604f, 0.02684534f, -0.25807267f, 0.05376849f, 
    0.02575477f, -0.00059214f, 0.05720769f, -0.20555307f, -0.03913754f, -0.01427895f, -0.11872984f, 0.04725211f, 
    -0.10994212f, -0.08467777f, -0.02056548f, -0.02246294f, -0.02031079f, -0.04207290f, 0.07610407f, -0.04653083f, 
    -0.34951636f, -0.11439531f, -0.16578510f, -0.28173491f, -0.21900921f, 0.18452764f, -0.05381434f, -0.27496520f, 
    -0.03004496f, -0.06283139f, 0.18524806f, -0.01867871f, 0.08658873f, -0.08920047f, 0.14530259f, -0.12668866f, 
    -0.04720132f, -0.14396077f, -0.00629295f, -0.08161572f, 0.08199938f, -0.06460005f, -0.40992299f, 0.00946937f, 
    0.12900098f, 0.20951734f, 0.06200440f, -0.02992080f, -0.08810107f, -0.11726515f, -0.01095699f, 0.07953189f, 
    -0.01035520f, 0.13448608f, -0.05647202f, 0.12089112f, -0.00166145f, -0.06012426f, 0.06752162f, -0.04655159f, 
    -0.02418811f, 0.25541249f, -0.20643237f, 0.07525645f, -0.08284093f, 0.14775233f, -0.09278315f, 0.05544094f, 
    -0.03690436f, -0.08969922f, 0.05497938f, -0.01309879f, -0.03540138f, 0.01971301f, 0.09392112f, 0.05115186f, 
    -0.08681073f, 0.04593790f, 0.00401292f, 0.00817720f, -0.18673076f, 0.00098469f, 0.08410051f, -0.08946907f, 
    0.05293242f, -0.01937656f, 0.00109748f, -0.12951477f, -0.02456891f, -0.09550894f, 0.06837411f, 0.04798177f, 
    0.07216381f, 0.05781700f, 0.03128209f, -0.03261438f, -0.04314668f, 0.05088578f, -0.12498275f, -0.07543341f, 
    0.23954765f, 0.02839145f, -0.12941444f, 0.07809094f, 0.02353015f, 0.02839702f, -0.05497957f, -0.03619194f, 
    0.13864553f, -0.02787341f, -0.05438749f, 0.05666175f, 0.06556383f, -0.15355012f, 0.15620515f, -0.02523837f, 
    -0.07774816f, -0.02875969f, 0.08263083f, 0.01108678f, 0.38017076f, 0.06122939f, -0.31764334f, 0.03050776f, 
    -0.19639075f, 0.00170259f, 0.06470258f, 0.12600212f, 0.05654732f, -0.14236476f, -0.14495805f, 0.03653584f, 
    0.03942849f, 0.09730840f, 0.03803695f, 0.16858809f, 0.01028817f, 0.14616536f, 0.06069695f, 0.03485779f, 
    -0.09739804f, -0.10695475f, -0.10132214f, 0.04447708f, 0.10985296f, -0.04733974f, -0.05834679f, -0.01180845f, 
    -0.09462780f, 0.05168169f, 0.00477696f, 0.13292611f, -0.12465689f, -0.19788077f, -0.11295652f, -0.08309060f, 
    -0.03489806f, 0.00224672f, 0.14295706f, 0.08964016f, -0.60598403f, 0.24544021f, 0.27330887f, 0.05894774f, 
    0.11156865f, 0.16245216f, 0.02212035f, -0.02802997f, 0.03396221f, -0.04164109f, 0.05369105f, 0.07221874f, 
    0.12160561f, 0.02668412f, -0.01023805f, 0.10772265f, -0.03288648f, 0.05085935f, -0.17186148f, 0.03180547f, 
    0.68790603f, -0.19467156f, -0.15629594f, -0.13129395f, 0.04362918f, 0.05792850f, -0.02879637f, 0.11479662f, 
    -0.08307742f, 0.11311572f, -0.08627831f, 0.06612220f, 0.06801046f, 0.05827487f, 0.01956539f, 0.05375921f, 
    0.04525742f, -0.08143999f, 0.03303093f, 0.07315174f, 0.33085287f, 0.00561353f, -0.01071342f, -0.04644093f, 
    0.00105963f, 0.11746714f, 0.03095110f, 0.03829433f, -0.02214904f, -0.08973729f, 0.03323652f, 0.07382662f, 
    -0.02571815f, 0.05911133f, -0.23933223f, 0.00164770f, 0.05544350f, -0.15978733f, 0.00821021f, -0.02695643f, 
    -0.36702198f, -0.06985126f, -0.21198054f, 0.05783763f, 0.34099355f, 0.10033493f, -0.09611241f, -0.03639719f, 
    -0.13312684f, 0.17322746f, 0.08675310f, -0.16338557f, -0.03458629f, 0.11324339f, 0.00321954f, -0.06914140f, 
    0.11021012f, -0.04451479f, 0.02342132f, 0.02130835f, -0.40948045f, 0.47758391f, 0.24225238f, 0.24773762f, 
    0.08428294f, 0.16152975f, 0.00970904f, -0.03567182f, -0.07093849f, 0.01992967f, -0.08544115f, -0.00599626f, 
    0.04389597f, 0.08147651f, 0.12021094f, 0.04572709f, 0.10127082f, 0.04820968f, -0.23669969f, 0.02876592f, 
    0.43673933f, 0.00597992f, -0.40748316f, -0.03531907f, -0.29267335f, -0.04175493f, 0.07287920f, 0.15865695f, 
    0.01643394f, -0.07419380f, -0.13809161f, -0.08695840f, -0.04556844f, -0.03021816f, 0.00247547f, 0.01523548f, 
    0.16287699f, -0.04480718f, 0.09173077f, 0.16483080f, 0.15420891f, -0.28006956f, -0.18975116f, -0.03722891f, 
    -0.05716660f, -0.05932622f, 0.01814048f, 0.08574709f, 0.05123742f, -0.07041071f, 0.06527708f, 0.01686626f, 
    0.00362136f, 0.07173203f, -0.05579286f, -0.00798002f, 0.04365176f, -0.07715399f, 0.09917461f, 0.05876971f, 
    0.05453102f, 0.06162696f, 0.20954999f, -0.45805219f, -0.31185773f, -0.06284889f, 0.03499644f, 0.00432274f, 
    -0.08315847f, 0.10715607f, -0.07988694f, -0.17670061f, -0.04873344f, -0.14240314f, 0.08669908f, 0.01443276f, 
    0.09607783f, -0.06116428f, -0.25399533f, -0.07641795f, -0.21553175f, -0.14583795f, -0.01364750f, 0.02675761f, 
    -0.01270777f, -0.01666136f, 0.03300983f, 0.01308466f, -0.09221946f, 0.06282253f, -0.00049719f, 0.04091868f, 
    -0.08095174f, 0.02560981f, 0.04475805f, 0.12501769f, -0.17593329f, -0.00817624f, 0.08551470f, 0.16879979f, 
    0.19315949f, -0.09642524f, -0.01186479f, 0.14401042f, 0.05121487f, 0.07645464f, -0.03278669f, -0.09267087f, 
    -0.06138835f, 0.05580441f, -0.03989841f, -0.10929967f, 0.06606358f, 0.09573802f, 0.23438443f, 0.04606227f, 
    -0.17472599f, 0.10032255f, -0.01126186f, 0.00977672f, -0.26683685f, -0.13061066f, -0.10743045f, -0.18582323f, 
    -0.03721368f, -0.00252134f, 0.06511735f, -0.00486899f, -0.02045846f, -0.07263111f, 0.02445776f, -0.02978542f, 
    -0.12509908f, 0.02820697f, -0.02917196f, -0.12586527f, -0.04208372f, -0.18740919f, 0.02488250f, -0.01311648f, 
    -0.10577795f, -0.07791299f, 0.10904150f, -0.31784388f, -0.00577250f, -0.04217729f, 0.03205496f, 0.02579630f, 
    -0.00628303f, 0.11330093f, 0.00411212f, -0.04124407f, 0.08348318f, -0.14192311f, -0.00949407f, -0.12628968f, 
    0.00377343f, 0.14923598f, 0.11484697f, 0.03861371f, 0.04222192f, 0.07429630f, -0.04801180f, -0.32285228f, 
    -0.29923230f, -0.02555392f, 0.07459863f, -0.04756142f, 0.01501158f, 0.00149456f, -0.09975892f, -0.02376699f, 
    -0.12996762f, -0.11378402f, 0.12662211f, 0.01500508f, -0.03649375f, 0.05832144f, -0.08583343f, -0.04658351f, 
    -0.16820778f, 0.08344220f, 0.16975643f, -0.26304054f, 0.11485676f, 0.13004641f, 0.00312294f, -0.12377033f, 
    -0.00749702f, -0.12732434f, 0.01313878f, 0.13231111f, 0.01549943f, 0.04962692f, 0.03847449f, -0.00065124f, 
    0.05590534f, 0.01613675f, -0.00853121f, -0.05234876f, -0.20233564f, -0.21364368f, -0.25518006f, 0.12610489f, 
    -0.18663612f, 0.12514286f, 0.20675313f, -0.10604259f, 0.01480243f, 0.01991985f, -0.05491576f, -0.02208962f, 
    0.10707063f, 0.05230276f, 0.20214377f, -0.02510788f, -0.05997944f, -0.04273991f, -0.08414113f, -0.13865489f, 
    -0.02421013f, -0.16022915f, -0.05652537f, 0.10977396f, 0.03903067f, 0.24145988f, -0.01521880f, 0.02436154f, 
    0.06433681f, 0.29837108f, -0.12464333f, -0.07481082f, -0.02897734f, -0.09180114f, -0.20986027f, -0.10345417f, 
    -0.24562936f, -0.01986898f, -0.14690354f, -0.08808840f, -0.21198425f, 0.00163097f, -0.04537871f, 0.09261701f, 
    -0.09931587f, 0.08683022f, -0.03501008f, 0.13209796f, 0.02624795f, -0.15613182f, -0.06722167f, -0.01697573f, 
    -0.04292864f, -0.06979577f, 0.03193425f, 0.15830155f, 0.00157831f, -0.08514323f, -0.17403860f, 0.02320047f, 
    -0.41563916f, -0.08088884f, -0.43853167f, 0.23521355f, -0.01916003f, 0.01325440f, 0.04129711f, 0.00570333f, 
    -0.03603684f, -0.07140205f, 0.04128858f, -0.09490214f, -0.05212503f, -0.10013339f, -0.03599325f, -0.01091033f, 
    -0.02555900f, 0.01587352f, -0.06998755f, -0.00379871f, -0.05979560f, -0.10977498f, 0.06216224f, 0.09740061f, 
    0.05712372f, -0.17339464f, 0.09161594f, 0.08589181f, -0.05741052f, -0.09164481f, 0.14458528f, -0.00950707f, 
    -0.06679288f, -0.09002221f, -0.10726395f, 0.17830215f, -0.00621314f, -0.06648371f, 0.18539365f, 0.12275019f, 
    -0.33106086f, 0.13326003f, 0.25526753f, -0.08071060f, -0.03316861f, 0.04407330f, 0.10564403f, -0.03479885f, 
    0.02229601f, -0.08167574f, 0.09638707f, -0.05065551f, 0.03162029f, 0.08198266f, -0.03552205f, 0.10108982f, 
    -0.01923333f, 0.04702761f, -0.07432042f, 0.02521637f, 0.09519307f, -0.19065860f, 0.03323671f, 0.04484415f, 
    -0.24979670f, 0.02793511f, 0.13514999f, 0.17250691f, -0.06750900f, -0.06169927f, -0.06799887f, -0.04173703f, 
    -0.00771339f, -0.14922029f, 0.01210054f, 0.00756608f, -0.04048334f, -0.16234498f, -0.04074908f, -0.03387697f, 
    0.49538335f, -0.75757629f, 0.18354636f, 0.08928135f, 0.15266916f, 0.00470893f, -0.14821792f, 0.01354294f, 
    0.04333637f, -0.08717521f, 0.04619808f, -0.08151007f, 0.08350399f, 0.05617588f, 0.02884415f, 0.10170624f, 
    -0.01693188f, -0.17384927f, -0.09261864f, 0.03229461f, 0.19066714f, -0.43112460f, -0.07868919f, 0.24331349f, 
    -0.02395407f, -0.13729922f, -0.04686156f, -0.07169361f, 0.17666505f, -0.00936536f, -0.14536963f, 0.11608147f, 
    -0.02018231f, 0.00604293f, -0.00358922f, 0.03987709f, 0.16453575f, 0.04900929f, 0.03728848f, -0.05768270f, 
    0.03356254f, -0.13486609f, 0.12624258f, 0.03729329f, -0.12629719f, 0.03285218f, 0.13417594f, 0.00536263f, 
    -0.14191927f, -0.22022058f, -0.04664611f, -0.05482501f, -0.05995341f, 0.10132397f, -0.15643606f, 0.01459777f, 
    -0.10367994f, -0.02608867f, -0.13123645f, -0.07315098f, -0.14887495f, 0.03677036f, 0.06755412f, 0.19078562f, 
    -0.02914464f, -0.00442344f, -0.08260179f, -0.03015360f, 0.05826374f, -0.21500297f, 0.08908753f, 0.09806365f, 
    0.01438844f, 0.00122227f, 0.03989531f, 0.00748185f, -0.09204412f, 0.11085183f, -0.02905088f, 0.14690235f, 
    -0.35350060f, -0.37556523f, 0.02019561f, -0.14356935f, 0.02573933f, -0.06821908f, 0.00585881f, -0.02748672f, 
    0.09948682f, 0.11390788f, -0.09530908f, -0.07489869f, -0.00580713f, 0.06062099f, 0.09549309f, 0.26619908f, 
    0.05273100f, -0.00633421f, -0.09065300f, -0.14950411f, -0.14890787f, -0.26217118f, 0.24154168f, -0.29859149f, 
    -0.43347025f, -0.02558503f, 0.03661191f, -0.15357693f, -0.06804729f, -0.01176251f, -0.14868838f, 0.02804577f, 
    0.08446001f, -0.09492179f, -0.11323055f, 0.02235110f, -0.11410952f, 0.05220063f, 0.12548971f, 0.03499727f, 
    -0.13745961f, 0.10233522f, 0.03927688f, 0.07365484f, -0.24063778f, 0.00496168f, 0.09647352f, 0.03740017f, 
    0.08985486f, 0.05203756f, -0.11050673f, -0.01109814f, 0.11372023f, -0.00243986f, 0.01993574f, 0.14540635f, 
    -0.09678484f, 0.04689648f, -0.07025087f, -0.11501254f, 0.41216752f, -0.15613776f, -0.14209068f, -0.30284441f, 
    -0.13068725f, -0.00616986f, -0.02170563f, -0.13179454f, 0.06162298f, -0.01991648f, -0.02680836f, 0.00273608f, 
    0.01266803f, -0.00090719f, -0.18429674f, 0.11750806f, 0.11276899f, 0.07657806f, -0.09127434f, 0.11690544f, 
    0.17312565f, 0.08856094f, 0.01302374f, -0.03125240f, 0.00292684f, -0.00232654f, -0.07123625f, 0.00790491f, 
    0.01426683f, 0.01426561f, -0.01086044f, -0.02563848f, -0.03751276f, 0.10894170f, -0.07246391f, 0.03070744f, 
    0.18557541f, 0.02043320f, -0.02608778f, 0.02032224f, -0.36692062f, -0.24510086f, 0.10754559f, -0.09065919f, 
    -0.23039535f, 0.04315265f, 0.07694254f, 0.02357609f, -0.07315028f, 0.04610261f, -0.02186683f, -0.04094630f, 
    0.07164564f, -0.09661540f, 0.00938329f, -0.08597456f, 0.03681754f, 0.12920722f, 0.15718333f, 0.08930450f, 
    0.26599932f, 0.15949489f, -0.02603337f, -0.09588845f, -0.09379368f, 0.04825704f, -0.03859907f, 0.10398424f, 
    0.02251336f, -0.02027980f, -0.05825272f, -0.07306141f, 0.03489431f, -0.02903472f, -0.03884893f, 0.10121027f, 
    0.15575638f, -0.06792631f, -0.02072657f, 0.12889773f, -0.04552599f, 0.00249758f, -0.16202973f, -0.05028557f, 
    -0.16524450f, 0.02993417f, 0.05553224f, 0.14277993f, -0.04722004f, 0.05688348f, 0.10612957f, 0.00999805f, 
    0.00220095f, -0.15631764f, 0.15918486f, 0.07431767f, 0.03051816f, -0.01924594f, 0.13205047f, 0.03579830f, 
    0.16274942f, 0.19310871f, -0.02766037f, 0.00516966f, 0.03974276f, -0.06533359f, -0.06655373f, 0.01150024f, 
    0.04169173f, -0.02207246f, 0.00696766f, 0.05768618f, -0.03591917f, -0.05620494f, 0.01661892f, -0.01426073f, 
    -0.08116180f, 0.07271525f, -0.22480693f, -0.02730884f, 0.11192497f, 0.05188109f, -0.07647655f, -0.02529675f, 
    0.10586522f, -0.07271320f, -0.04416322f, -0.09064905f, 0.03381925f, -0.02448422f, -0.03635436f, -0.00240113f, 
    -0.02243913f, -0.11650825f, -0.04891883f, -0.08944423f, -0.03412724f, 0.10433301f, 0.05450691f, 0.10816933f, 
    -0.10104132f, 0.10140464f, -0.35705835f, 0.00529463f, -0.12824148f, -0.03265870f, 0.01811280f, -0.09767577f, 
    -0.04936225f, 0.08491734f, 0.09584115f, 0.02830243f, -0.17922087f, -0.05076064f, 0.02100270f, -0.08762535f, 
    -0.00391381f, 0.08251439f, 0.11989196f, -0.06715047f, -0.27969149f, -0.22607549f, -0.05757321f, -0.01674975f, 
    0.12113724f, 0.02078546f, 0.00029439f, 0.06812853f, -0.09102973f, 0.02744904f, 0.03792406f, -0.10163040f, 
    0.03646389f, -0.10527983f, -0.03306696f, 0.00207856f, -0.05147563f, -0.08993804f, 0.13373321f, -0.01170443f, 
    -0.44748512f, -0.43693843f, 0.08499810f, 0.01506010f, 0.02834687f, 0.05802506f, -0.01380148f, 0.06370352f, 
    -0.09910063f, 0.06463492f, 0.01258230f, 0.01072684f, 0.04352726f, -0.05302742f, 0.03187050f, 0.02210538f, 
    -0.04020526f, 0.05449750f, 0.11180823f, 0.10089742f, 0.07688170f, 0.14733186f, 0.12660462f, -0.04853245f, 
    -0.05342244f, 0.10739782f, -0.01305925f, -0.01811618f, 0.04710856f, -0.05247540f, -0.06402254f, -0.01091302f, 
    0.04288089f, -0.00777526f, -0.02980945f, 0.01008799f, -0.01613059f, -0.16442309f, -0.07750210f, 0.06430959f, 
    -0.50722253f, -0.17134044f, -0.02737906f, -0.20648693f, -0.14795503f, 0.08379893f, -0.06502584f, -0.02613131f, 
    -0.09109224f, 0.05967595f, 0.02712060f, -0.04021586f, 0.04751603f, 0.15081151f, 0.01210239f, -0.05573656f, 
    -0.07761712f, -0.07890119f, -0.00771969f, -0.08621564f, 0.20212619f, 0.03488027f, -0.06470773f, -0.02347423f, 
    -0.01387625f, 0.01730668f, 0.02492632f, 0.15260418f, -0.02268745f, 0.05224980f, -0.05425133f, 0.00588556f, 
    0.06081084f, -0.07061191f, -0.05450954f, -0.03066829f, 0.02438568f, -0.33347052f, -0.08896232f, -0.00502738f, 
    0.23417613f, 0.13275819f, 0.01241119f, -0.00899754f, -0.14967516f, -0.21260655f, -0.19384092f, 0.14251053f, 
    -0.00837514f, 0.01945051f, -0.00866379f, 0.02835853f, -0.04107110f, -0.07970880f, -0.03717726f, 0.02240114f, 
    -0.00385652f, 0.00431445f, -0.08844028f, -0.06287658f, -0.18990156f, -0.13799565f, -0.17013058f, -0.17481904f, 
    -0.05419782f, 0.03427777f, 0.08651777f, -0.16179611f, -0.01295983f, -0.03856964f, -0.05759170f, -0.00479690f, 
    -0.16835287f, -0.12113846f, 0.08448195f, -0.09300835f, 0.01342756f, 0.20015495f, 0.04022495f, 0.06422383f, 
    0.25661170f, 0.25273481f, 0.02692371f, -0.05800390f, -0.01945383f, 0.12137332f, -0.01704649f, 0.00341507f, 
    0.13823372f, 0.06362735f, -0.06653787f, 0.03580786f, 0.10487143f, 0.06985091f, 0.03342189f, 0.11719450f, 
    0.09502353f, -0.06492259f, -0.13762920f, 0.06142476f, -0.44691363f, -0.33890784f, 0.14803195f, -0.14713167f, 
    -0.31090549f, 0.12093936f, 0.01774223f, 0.07715882f, -0.05320053f, 0.05259377f, 0.02016148f, 0.06456856f, 
    0.00109417f, 0.09742790f, -0.01896645f, 0.01673610f, 0.01289506f, -0.07170185f, -0.06792399f, -0.06372379f, 
    -0.72925150f, -0.37073788f, -0.36745727f, -0.26102224f, -0.26567322f, 0.06804657f, 0.11598353f, -0.10351514f, 
    -0.09596625f, 0.11611718f, 0.10141949f, -0.00475211f, 0.05678322f, 0.03977958f, -0.00313418f, 0.00318719f, 
    -0.00324123f, 0.07392063f, 0.08838715f, 0.07477152f, 0.20754237f, -0.18285817f, -0.06927014f, -0.05113399f, 
    0.11741508f, -0.15045613f, -0.02109319f, -0.00421831f, -0.01396549f, -0.09319209f, -0.02722640f, -0.07897346f, 
    -0.06527064f, -0.03342593f, -0.04827252f, -0.09003548f, -0.00888566f, -0.00902582f, -0.00864263f, 0.01437255f, 
    0.37387183f, 0.24347062f, -0.19986084f, 0.08614156f, -0.12972653f, -0.21283090f, -0.19422098f, 0.03397349f, 
    0.11317355f, -0.09591332f, -0.07059588f, -0.11248846f, -0.00035802f, -0.13611332f, -0.10244111f, -0.01216404f, 
    -0.03398089f, 0.11528771f, -0.00593505f, -0.09246880f, -0.00733864f, -0.06890336f, -0.06535076f, -0.00331235f, 
    -0.03501219f, -0.09743287f, 0.00113553f, 0.16076516f, -0.03942931f, -0.07007072f, 0.09884090f, -0.03821978f, 
    0.00542086f, -0.05615682f, 0.04401425f, -0.02443136f, 0.05149872f, 0.03990147f, 0.11389530f, 0.02655534f, 
    -0.69039494f, -0.49586108f, 0.24078822f, -0.07977939f, -0.03653641f, 0.00233333f, 0.04204920f, 0.09299912f, 
    -0.07561163f, -0.09334704f, 0.10816627f, 0.05538393f, -0.06879062f, 0.04271578f, 0.05469132f, 0.06230244f, 
    -0.01031262f, -0.03348701f, -0.17202699f, 0.02475540f, 0.33363673f, 0.14980274f, -0.03587604f, -0.02366265f, 
    -0.11234482f, 0.14863986f, -0.02145712f, 0.13959451f, -0.00550269f, 0.02754525f, -0.05485449f, -0.03496806f, 
    0.00300373f, 0.00410357f, -0.06150858f, 0.02698038f, 0.09654863f, -0.21775264f, -0.12637661f, -0.01139148f, 
    -0.24136490f, -0.27949533f, -0.08882684f, -0.01306681f, 0.30575529f, 0.04848230f, 0.02570286f, 0.04989431f, 
    0.00515736f, -0.11794788f, -0.00835878f, -0.09748021f, -0.01202813f, 0.03411543f, 0.04731854f, 0.14399053f, 
    0.07187449f, 0.08182358f, 0.19650280f, 0.03074729f, -0.49460310f, -0.12942508f, 0.08265949f, -0.09716574f, 
    -0.08949798f, 0.10877804f, 0.03605789f, 0.01039129f, -0.03011083f, -0.00794238f, 0.07735494f, 0.02170983f, 
    0.01292552f, 0.22391221f, 0.09261272f, 0.07165340f, -0.05907637f, 0.13250957f, 0.00376841f, 0.01482824f, 
    -0.45350558f, 0.06212735f, -0.36048442f, -0.04148743f, 0.20967153f, 0.02958663f, -0.01536317f, -0.14690812f, 
    -0.01191799f, 0.13831466f, 0.03876735f, 0.04481596f, 0.05425876f, -0.10252371f, 0.17415278f, 0.12710270f, 
    0.05001132f, 0.09421273f, -0.10324588f, 0.06557690f, 0.18364426f, -0.04435847f, -0.00198370f, 0.08979564f, 
    0.04008583f, -0.06147727f, 0.06495378f, -0.06881268f, -0.00144029f, -0.02247089f, 0.04513533f, 0.15516636f, 
    0.00442542f, 0.03360621f, 0.03135456f, 0.01381719f, 0.07286517f, -0.05740472f, -0.39959899f, 0.03436051f, 
    -0.43490034f, -0.18646923f, -0.17361318f, -0.23229313f, -0.05200975f, 0.08396517f, 0.04045783f, -0.09191340f, 
    -0.05430202f, 0.05746975f, -0.03016056f, 0.01245570f, -0.03394951f, 0.00111010f, 0.06181006f, 0.05365026f, 
    0.14031529f, 0.15653752f, 0.12145385f, 0.17137621f, -0.31623688f, -0.14656647f, -0.06586961f, -0.06469006f, 
    -0.02779171f, -0.00530212f, 0.02973857f, -0.03901241f, -0.01884772f, 0.01038032f, 0.02923875f, -0.04171547f, 
    -0.01979055f, 0.00129449f, 0.01063316f, 0.03586223f, 0.09492148f, -0.03317871f, 0.15178323f, 0.06085679f, 
    -0.15482479f, 0.09556933f, -0.11240625f, 0.10692143f, 0.16906635f, 0.10113861f, -0.00924474f, -0.07060587f, 
    -0.00185800f, 0.06733388f, 0.00794104f, 0.02549426f, 0.08813555f, -0.10994859f, 0.10367467f, -0.00013519f, 
    -0.08194659f, -0.11763944f, -0.11835282f, 0.04754691f, -0.35915294f, -0.11781610f, -0.02993235f, -0.18265642f, 
    -0.23434514f, 0.11892869f, 0.04918813f, -0.04599854f, 0.00259637f, 0.01661010f, -0.02726563f, 0.05586515f, 
    -0.03690680f, 0.14184214f, -0.01491742f, 0.13128006f, 0.06758571f, 0.16786636f, -0.06445830f, -0.01312880f, 
    0.01991430f, -0.16715208f, -0.04384814f, 0.06085137f, 0.15817028f, -0.02227058f, 0.05532635f, 0.08229163f, 
    -0.07335611f, -0.06495684f, -0.01690802f, -0.03083442f, -0.02275049f, -0.04838645f, 0.05895174f, -0.09422018f, 
    0.03778996f, 0.05130978f, 0.02769518f, 0.07449722f, -0.41117418f, -0.01133928f, 0.17244211f, 0.00240539f, 
    -0.11867622f, 0.00547780f, -0.00296525f, 0.01718132f, -0.03998205f, 0.08972197f, 0.01422811f, -0.05044669f, 
    0.05693446f, -0.08309340f, 0.11632047f, -0.05132919f, -0.04913624f, -0.08883928f, -0.10667868f, -0.03451725f, 
    -0.21104823f, 0.11599600f, 0.10267612f, -0.00883235f, -0.00891383f, -0.01598813f, 0.02351892f, 0.01068662f, 
    -0.15345985f, -0.09669821f, 0.00757219f, -0.00909777f, 0.03150077f, -0.13845438f, -0.07337104f, -0.03473330f, 
    -0.08564679f, -0.07645968f, 0.05807142f, -0.04647210f, -0.08687454f, -0.49597812f, -0.14251043f, -0.11881147f, 
    -0.08087576f, -0.04062930f, -0.03220235f, 0.04062673f, 0.01501466f, 0.11739942f, -0.03447437f, -0.02694845f, 
    -0.08235962f, 0.02648638f, -0.07507600f, 0.04935498f, 0.09467429f, 0.02556884f, -0.00438634f, -0.13849063f, 
    0.03865121f, 0.03627398f, -0.07054143f, -0.12310446f, 0.06538310f, 0.09035809f, -0.03572199f, 0.06199102f, 
    0.04233373f, -0.01224246f, 0.08073959f, -0.23091893f, -0.07823540f, -0.03133592f, 0.07177478f, -0.03330150f, 
    -0.06352568f, 0.02568778f, 0.13901857f, 0.00240383f, 0.08872008f, -0.23443158f, 0.10278627f, 0.07545278f, 
    -0.17707422f, 0.07120586f, 0.13188267f, 0.08907795f, -0.02315831f, 0.05306060f, -0.00160210f, -0.01513517f, 
    -0.01963719f, -0.03426444f, -0.07613908f, -0.12142082f, -0.03442191f, -0.01772026f, -0.03163450f, -0.05083144f, 
    -0.50805622f, 0.24616034f, -0.02518595f, -0.06215459f, 0.13219973f, -0.04939044f, 0.03958569f, -0.03729539f, 
    0.02147131f, -0.05363059f, -0.02357335f, -0.02980404f, 0.13483654f, 0.02399762f, -0.01495173f, -0.03978830f, 
    -0.14539234f, 0.04885629f, -0.18909228f, -0.03357520f, -0.59737152f, -0.10797497f, 0.00908007f, -0.15209377f, 
    -0.01286566f, 0.04579708f, 0.05839182f, 0.04762011f, 0.05571317f, 0.13141531f, -0.09998126f, 0.05609278f, 
    0.06146165f, -0.07557294f, -0.06302479f, -0.04348853f, -0.05339856f, -0.03854807f, -0.10690393f, -0.05856762f, 
    -0.10349856f, -0.22116475f, 0.02585398f, 0.04166303f, 0.01204553f, -0.08745833f, 0.03375603f, -0.09436871f, 
    0.00978749f, -0.08579040f, -0.15111578f, 0.06077237f, 0.19199052f, 0.16740906f, 0.07865747f, 0.05187185f, 
    -0.03837520f, 0.03910883f, -0.23883469f, 0.05030682f, 0.12466081f, 0.01622061f, -0.09322255f, 0.14152195f, 
    0.04853413f, 0.11498780f, -0.04990288f, -0.09408941f, 0.02360265f, 0.09571723f, -0.01302552f, 0.06090395f, 
    -0.03154740f, 0.01956002f, -0.00619128f, -0.05854518f, 0.16643152f, -0.01807864f, -0.16948670f, 0.00254246f, 
    -0.19759209f, -0.11128715f, -0.07779925f, -0.20205738f, 0.04585937f, 0.13835926f, -0.18235214f, 0.01225290f, 
    0.13153426f, 0.12879336f, -0.00596299f, 0.00721951f, 0.04333138f, 0.02813982f, 0.04487459f, 0.13829249f, 
    0.05028924f, 0.04959909f, -0.15946691f, -0.14199542f, -0.06111640f, 0.14259595f, -0.10211830f, -0.14943890f, 
    0.36488241f, 0.02951539f, -0.05288468f, 0.05755967f, 0.01302404f, -0.04664818f, -0.06182866f, -0.06215088f, 
    0.02250227f, 0.01742908f, 0.08811728f, -0.07507885f, 0.08335017f, -0.02326776f, 0.08897625f, 0.00588362f, 
    0.50810403f, -0.15973367f, -0.28774711f, -0.11540956f, -0.06727585f, 0.00766121f, 0.04075002f, -0.13469538f, 
    0.03625996f, -0.03811220f, 0.07852564f, 0.02629247f, -0.00140877f, 0.01638729f, -0.00928983f, 0.06679459f, 
    0.00831646f, -0.06899683f, 0.05812303f, 0.09980155f, 0.09273183f, 0.05580242f, -0.17326041f, -0.08050662f, 
    -0.00270046f, 0.05581738f, -0.13360327f, -0.08747540f, 0.00252630f, -0.04715033f, 0.13414261f, 0.05978075f, 
    0.01994192f, 0.07606033f, -0.15763861f, 0.10506169f, 0.02536753f, 0.04482890f, -0.02339301f, -0.01312317f, 
    0.22686909f, 0.02260592f, 0.02070101f, -0.06869988f, 0.01040137f, -0.04643057f, -0.00109349f, -0.02450671f, 
    -0.01713379f, -0.24524583f, -0.06875064f, -0.08364470f, 0.16948932f, 0.12469828f, -0.18637004f, -0.06020155f, 
    -0.06819896f, 0.03790748f, -0.08374482f, -0.07632151f, -0.51358533f, -0.44063699f, -0.14312541f, -0.18813385f, 
    -0.15851411f, -0.06379589f, 0.07032979f, 0.06917785f, 0.04711128f, 0.09917622f, -0.09688229f, 0.09486668f, 
    0.09323353f, 0.00097315f, -0.04683157f, -0.13646305f, 0.07181311f, -0.05053536f, -0.13930771f, -0.02191112f, 
    0.11483858f, 0.05332679f, -0.13767904f, 0.04282629f, 0.34988877f, -0.01960104f, -0.04870409f, 0.01222776f, 
    0.08893503f, -0.03362010f, 0.01797970f, 0.00964257f, -0.03464353f, 0.04793992f, 0.03322503f, 0.00452059f, 
    0.02925014f, -0.01819664f, 0.08686093f, 0.04476331f, 0.41769695f, 0.12524672f, -0.28572485f, -0.01492393f, 
    0.05068032f, -0.00687199f, -0.13298103f, -0.06851827f, 0.05325460f, 0.05616412f, 0.08682612f, 0.01427233f, 
    0.01334716f, 0.03219991f, -0.04676593f, 0.03594962f, -0.08189087f, -0.00175287f, 0.02011699f, -0.00868312f, 
    0.42150655f, -0.17444861f, -0.29965839f, 0.06292146f, -0.33962417f, 0.04630037f, 0.03797894f, 0.12417016f, 
    -0.06648970f, 0.06242392f, 0.05308809f, -0.04419535f, 0.09301025f, -0.00422827f, -0.01962594f, 0.00824605f, 
    -0.04953024f, -0.03249423f, 0.03217804f, 0.00329563f, -0.33584082f, 0.13765481f, -0.04618338f, 0.00508845f, 
    0.00279310f, 0.17655787f, -0.10635210f, 0.09816089f, -0.11736587f, -0.03419491f, -0.02096835f, 0.00691081f, 
    0.03937929f, -0.01881862f, -0.04412789f, -0.00771149f, 0.05099245f, -0.17399837f, 0.00870315f, -0.00373554f, 
    -0.00963027f, -0.25457141f, 0.03832529f, -0.02653061f, -0.02718788f, 0.09967031f, 0.23503621f, 0.11833041f, 
    -0.01066648f, -0.01905228f, -0.10571997f, -0.19054711f, -0.03676846f, 0.01645453f, -0.01370601f, -0.09420227f, 
    -0.04706635f, 0.02918645f, -0.22625093f, 0.00571043f, -0.22811881f, -0.30473018f, 0.01476988f, -0.01754555f, 
    -0.18529393f, 0.07936653f, -0.02401471f, 0.07662540f, 0.04239407f, 0.14451671f, -0.00259430f, -0.08103926f, 
    -0.05305253f, 0.05014344f, 0.05379533f, -0.03768261f, -0.04190391f, -0.00774853f, -0.09846710f, -0.14263469f, 
    -0.51095140f, 0.57778209f, -0.10673617f, -0.04852143f, -0.06618132f, 0.01540751f, -0.00096994f, 0.00112666f, 
    0.14466874f, 0.04645421f, 0.05747596f, 0.10699438f, -0.09124558f, -0.02739377f, 0.13296017f, 0.04651261f, 
    0.14997567f, 0.02935833f, -0.06808774f, 0.01911930f, -0.15200460f, 0.06890369f, -0.27187899f, -0.20432997f, 
    0.09619159f, -0.01732880f, -0.14925525f, -0.07444920f, -0.05517758f, -0.17600176f, 0.02901970f, 0.05420900f, 
    -0.09586734f, -0.03991892f, -0.05986430f, 0.18090774f, -0.14284302f, 0.08371995f, 0.13215269f, -0.09154513f, 
    -0.07004559f, 0.20346251f, -0.04891199f, 0.20860401f, 0.17562999f, 0.25683966f, -0.01206061f, -0.03434248f, 
    0.03705050f, 0.01373071f, 0.03511815f, 0.07448342f, -0.02097157f, 0.14528435f, -0.00281043f, -0.11163948f, 
    -0.01908467f, -0.03741243f, -0.24089442f, -0.02870566f, 0.17997766f, 0.19966809f, -0.14093237f, -0.21293218f, 
    0.00696159f, -0.06978147f, -0.08910265f, 0.01136370f, 0.08114953f, -0.01519665f, 0.09599694f, 0.04584007f, 
    0.02013665f, -0.05221592f, 0.04277706f, -0.01433345f, -0.08785240f, 0.04402946f, -0.02099153f, 0.06160226f, 
    -0.64821798f, 0.23621650f, -0.03725200f, 0.00871636f, -0.05275690f, -0.01146023f, 0.02435150f, -0.08702891f, 
    0.02749538f, 0.01277640f, -0.10418297f, 0.01408961f, 0.11706601f, 0.06049932f, 0.02635464f, -0.01265894f, 
    -0.01116915f, -0.17545609f, 0.03410747f, -0.02104109f, -0.07545764f, 0.19352907f, 0.07458757f, -0.10117622f, 
    -0.06769159f, -0.01346905f, -0.04132795f, -0.08455916f, -0.16517003f, -0.19915327f, -0.05221889f, 0.00618903f, 
    0.06868315f, -0.12761071f, -0.11858592f, 0.02536754f, 0.05910868f, 0.08876990f, 0.12291425f, -0.01304861f, 
    0.12712002f, -0.08949864f, -0.15851210f, -0.05181916f, 0.00810660f, 0.00762103f, -0.00515868f, -0.02916283f, 
    0.00123461f, 0.06526655f, 0.00716304f, 0.04074221f, -0.05217091f, 0.00590036f, 0.06096191f, -0.04733190f, 
    -0.07006299f, -0.08887579f, -0.07308420f, -0.00541022f, -0.15452659f, 0.09650806f, -0.03875991f, 0.02138718f, 
    -0.33034697f, 0.21523684f, 0.03160863f, 0.04454760f, -0.04239685f, -0.02122076f, -0.00775070f, 0.01775746f, 
    0.03882521f, -0.04498081f, 0.00802895f, -0.01077658f, -0.00368858f, -0.03348920f, -0.06058192f, -0.02833473f, 
    -0.17020193f, -0.18778428f, -0.05028593f, 0.12482926f, -0.03405220f, -0.14904545f, 0.11316172f, 0.04822373f, 
    0.00728771f, -0.13159269f, 0.11124942f, -0.05315898f, -0.07429165f, 0.12854172f, 0.01807316f, 0.07524744f, 
    -0.00292629f, -0.09128897f, 0.04436978f, 0.02670635f, 0.65896386f, 0.04910735f, -0.30764511f, -0.06117718f, 
    0.08663814f, -0.02249331f, 0.04670512f, 0.00673960f, 0.02242716f, 0.04040785f, 0.06679074f, 0.16174160f, 
    -0.02511499f, -0.03845132f, 0.02611842f, 0.11372352f, -0.06297950f, 0.00036962f, -0.00936486f, 0.09187327f, 
    -0.24066168f, 0.13503180f, 0.12209444f, 0.03624625f, -0.19674164f, 0.15104064f, 0.11978037f, 0.06316975f, 
    -0.04977503f, 0.12257191f, 0.00789500f, 0.03412632f, -0.00857132f, -0.04070112f, -0.04149873f, -0.01955629f, 
    0.03574793f, -0.10188647f, 0.02942951f, 0.05942036f, -0.06282893f, -0.11006635f, 0.03199504f, -0.22713089f, 
    0.17179310f, -0.07005052f, -0.12272007f, 0.10024608f, 0.11109174f, 0.09239408f, 0.02664061f, -0.07416191f, 
    0.04549761f, 0.13746943f, -0.08964293f, 0.01904455f, 0.09784829f, -0.09726656f, -0.01646993f, -0.01855138f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07525125f, 0.07866313f, -0.01396438f, -0.00931562f, 0.01535031f, 0.02191048f, 0.01279720f, -0.04912737f, 
    0.00708259f, 0.03510035f, 0.04893836f, -0.02311520f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
