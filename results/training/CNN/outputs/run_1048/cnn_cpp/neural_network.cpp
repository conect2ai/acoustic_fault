#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.04579287f, -0.38745949f, -0.98748547f, 0.30213425f, 0.71169019f, 0.29528651f, 0.02175809f, -0.03797346f, 
    -0.16098475f, -0.16558091f, -0.15880248f, 0.20994887f, 0.09291222f, 0.21246286f, 0.00847029f, 0.20687249f, 
    -0.04164870f, -0.13386181f, 0.53337008f, 0.03931357f, -0.15741691f, -0.16847697f, -0.29560515f, -0.01021407f, 
    -0.10396785f, 0.18980601f, 0.37811065f, -0.60316509f, 1.08391666f, 0.65313357f, -0.65063375f, 0.02683918f, 
    -0.35826534f, 0.13060682f, -0.32700333f, -0.16463161f, 0.13988589f, 0.52057588f, -0.16396242f, -0.40021247f, 
    -0.23836690f, 0.00657293f, 0.23785816f, 0.37382430f, -0.25206438f, -0.91025847f, -0.18907638f, 0.67495769f, 
    -0.14525300f, 0.46329820f, -0.40189350f, -0.31942189f, -0.03261501f, 0.11700139f, -0.15874778f, 0.40389636f, 
    0.05217284f, -0.41519424f, -0.06947547f, 0.09482611f, -0.15061754f, 0.34411958f, 0.17748392f, -0.63482642f, 
    -0.45845273f, -0.33139449f, -0.02846561f, -0.48852655f, -0.30193833f, -0.37508121f, -0.48525044f, -0.31934318f, 
    -1.18391633f, 0.63296402f, 0.67145669f, -0.66930610f, -0.31392518f, 0.87453055f, -0.20466943f, 0.12137862f, 
    -0.25132120f, -0.85773098f, -0.29026818f, 0.31561261f, -0.01320485f, -0.52531064f, 0.19534688f, 0.45218757f, 
    0.55909777f, -0.05137769f, 0.70535851f, -0.41995594f, -0.32864559f, 0.15828170f, 0.18405078f, 0.30236199f, 
    -0.50403398f, 0.54956007f, -0.08251651f, -0.78788888f, -0.30782396f, -0.33631226f, 0.48281440f, 0.59682178f, 
    0.21734899f, -0.00312166f, -0.08470557f, 0.19061376f, 0.37774143f, -0.49544367f, 0.32751524f, 0.63254988f, 
    -0.25886908f, -0.47221890f, -0.37694085f, 0.12004285f, 0.27849051f, -0.21229586f, 0.74302471f, -0.81882042f, 
    -0.38023484f, 1.11118126f, -0.60623914f, -0.03812611f, -0.08762679f, -0.03061162f, -0.57321870f, -0.32493263f, 
    -0.05123487f, 0.24868441f, 0.36573988f, 0.47526404f, -0.05102536f, -0.21461850f, -0.25987396f, 0.11752387f, 
    -0.86584044f, -0.48508510f, -0.49446085f, -0.65183848f, -0.30434611f, 0.25268871f, -0.15163264f, -0.01369145f, 
    0.67897546f, -0.12626383f, -0.44933742f, 0.38865826f, 0.16806567f, -0.42918420f, 0.17038070f, 0.43090099f, 
    -0.48593143f, 0.35570097f, 0.09625801f, -0.52356786f, -0.41248572f, -0.52438462f, 0.75955802f, -0.31119713f, 
    -0.26019454f, -0.19798936f, -0.70006657f, -0.85892957f, -0.60185403f, 0.72467941f, 0.33432025f, -0.29392850f, 
    -0.27811143f, -0.45963657f, 0.09017310f, 0.30063906f, 0.55916643f, 0.59478945f, -0.30187008f, -0.38636997f, 
    -0.49315310f, 0.21950184f, 0.15868138f, -0.12745818f, -0.70744187f, -0.19162524f, -0.10702354f, -0.15259534f, 
    0.53430963f, -0.68316388f, 0.26564315f, -0.49415252f, -0.74175429f, -0.08865297f, 0.89197451f, -0.68822777f, 
    -0.45807740f, -0.30246356f, -0.48038802f, -0.44265220f, -0.20387779f, -0.44112417f, -0.43827876f, 0.83694273f, 
    -0.43789530f, -0.33520654f, 0.29583597f, 0.24623853f, -0.05013361f, -0.02829230f, 0.10576472f, 0.34672228f, 
    -0.52427423f, -0.26978981f, -0.12459633f, -0.33142260f, -0.67587185f, -0.31368807f, 0.44546086f, 0.35809460f, 
    0.23621552f, -0.23465168f, -0.30604398f, 0.56183904f, -0.25715357f, 0.16404405f, -0.21884142f, 0.39767209f, 
    -0.45154458f, -0.15183772f, 0.09978089f, 0.12003048f, 0.42817795f, -0.03143686f, 0.00187390f, 0.31280792f, 
    -0.25266948f, 0.04054965f, 0.15062232f, 0.02434430f, -0.27484381f, 0.67283291f, -0.27606869f, -0.64843309f, 
    0.40905190f, -0.47046083f, -0.53604305f, -0.28677511f, -0.10516822f, 0.44142461f, -0.31640014f, -0.02376412f, 
    0.31768411f, -0.64230746f, 0.07103823f, 0.58790654f, 0.28935513f, -0.10568959f, -0.64208198f, -0.14600195f, 
    -0.00695818f, -0.03122491f, 0.18417542f, 0.23504572f, 0.21388189f, 0.39524654f, -0.05224423f, 0.02619695f, 
    -0.19669937f, -0.07658633f, 0.16908599f, -0.00952510f, 0.01070258f, 0.27057362f, -0.59772319f, -0.40830165f, 
    -0.30305001f, -0.53975207f, -0.56602550f, 0.17010511f, 0.13164392f, 0.00249305f, -0.30725372f, -0.53631663f, 
    -0.26754248f, -0.10265387f, 0.02145536f, 0.08141498f, -0.23066171f, 0.23958066f, 0.22165246f, 0.22920550f, 
    0.63536119f, -0.82144988f, -0.31036523f, 0.64633191f, 0.29478422f, 0.08500504f, -0.40129250f, -0.38743737f, 
    0.19944510f, 0.18291542f, -0.36616313f, 0.22976312f, -0.02261073f, 0.23834929f, -0.11758777f, -0.57864344f, 
    0.15930121f, 0.43705922f, 0.86135888f, -0.21243955f, -0.46755004f, -0.22862977f, -0.16716349f, -0.32710499f, 
    0.16346568f, -0.03688298f, 0.24914522f, -0.21151979f, 0.13329719f, 0.19324565f, 0.01164451f, 0.31342301f, 
    -0.24676022f, 0.27621630f, 0.10040521f, -0.34481326f, -0.73508185f, 0.30948585f, -0.66770142f, -0.05195047f, 
    0.42790726f, 0.45218515f, 0.18808128f, 0.11367775f, -0.23170482f, -0.84246832f, -0.54063326f, -0.22109474f, 
    0.21933587f, -0.27184767f, 0.13952270f, 0.09935403f, -0.36860019f, -0.16055883f, 0.11541069f, 0.59997880f, 
    -0.02372673f, -0.34340328f, -0.23051585f, 0.10222023f, -0.15017790f, 0.25714633f, -0.13439433f, 0.39303935f, 
    0.52358073f, -0.61636591f, -0.68881750f, -0.56261355f, -0.34005773f, 0.34565058f, -0.48086679f, -0.37533206f, 
    0.00959062f, -0.10146780f, 0.02768397f, 0.04340221f, -0.02609340f, 0.13911401f, 0.23642078f, -0.08715766f, 
    -0.19333941f, 0.61982584f, 0.23306562f, -0.94253993f, -0.44199151f, -0.03240924f, 0.57375711f, -0.07266118f, 
    -0.16403461f, 0.15080117f, 0.61371201f, 0.78494656f, -0.59862292f, -0.62878221f, -0.13766773f, -0.08636361f, 
    -0.28780353f, -0.04663434f, 0.38932398f, -1.13384545f, -0.82523459f, 0.95363373f, 0.15328826f, -0.09149181f, 
    0.46590266f, 0.16827692f, -0.00758581f, -0.24529624f, 0.09904689f, 0.28368649f, 0.58504736f, -0.69639885f, 
    -0.30273545f, 0.52178842f, 0.13290402f, -0.06125046f, -0.11717471f, -0.42850056f, 0.85057020f, 0.06531758f, 
    -0.46065006f, -0.49737343f, -0.25930119f, 0.50656325f, 0.12710153f, 0.10960561f, 0.40579447f, -0.27947444f, 
    -0.36231643f, -0.48479986f, -0.34951255f, -0.12652768f, -0.30445039f, -0.08861163f, 0.05667679f, -0.21036457f, 
    0.17851083f, 0.28796440f, 0.47200546f, 0.10490353f, -0.08985835f, -0.01131754f, -0.21918596f, -0.25113243f, 
    -0.51827103f, 0.10009376f, 0.22133420f, 0.15487823f, 0.32785118f, 0.09108697f, 0.01457469f, -0.09587561f, 
    -0.01794042f, -0.81242782f, 0.51090598f, 0.44553426f, 0.30659050f, 0.22226386f, -0.36749449f, -0.44697663f, 
    0.04316206f, 0.04144462f, -0.02570743f, -0.62678468f, -0.26642251f, -0.74741381f, -0.15579996f, -0.23755805f, 
    -0.42791256f, -0.20134576f, -0.69874346f, -0.37647843f, 0.53571975f, 0.17098892f, -0.03455721f, 0.49489367f, 
    0.29808253f, -0.10392174f, -0.23581499f, -0.37861326f, -0.48465240f, 0.13178401f, -0.14937778f, -0.44839635f, 
    -0.23733498f, -0.21758302f, -0.10590924f, -0.32757783f, -0.39775473f, -0.45341787f, 0.00622277f, 0.45432654f, 
    -0.70776248f, -0.91743606f, -0.88233268f, 0.32346541f, -0.25240359f, 0.46752909f, 1.21420419f, -0.89629012f, 
    -0.92917210f, 0.51426530f, 0.82365739f, -0.37945980f, -0.17924441f, -0.08878985f, -0.14048022f, -0.28589663f, 
    -0.73652965f, 0.16104266f, -0.66830254f, -0.19142018f, -0.92729825f, 0.21997838f, -0.35645017f, 0.62309825f, 
    -0.54094005f, -0.81873763f, -0.18872659f, -0.39390728f, 0.05796234f, -0.03179268f, -0.20011531f, 0.19219401f, 
    0.37383294f, 0.41954336f, -0.58700651f, 0.28615716f, 0.30739266f, -0.46234950f, 0.15606251f, 0.17434391f, 
    -0.46289197f, 0.31901899f, 0.66696912f, 0.50823963f, 0.37500682f, -0.05128418f, -0.23245393f, -0.27813637f, 
    -0.32627180f, -0.41970640f, -0.25067034f, -0.61204219f, -0.56224042f, -0.41469049f, -0.06122150f, 0.48782241f, 
    0.09015311f, 0.43619987f, -0.08696440f, 0.29672870f, -0.86532456f, 0.36870894f, 0.29128501f, 0.16522303f, 
    0.34008604f, -0.32190281f, -0.05163284f, -0.36785415f, -0.48766172f, -0.37517956f, -0.38150033f, 0.42234069f, 
    -0.22134313f, -0.83172852f, 0.69724065f, 0.49749276f, -0.38027632f, 0.12666875f, 0.08639763f, 0.06063027f, 
    -0.18111837f, -0.00639608f, 0.41770619f, -0.36086321f, -0.08007690f, 0.49041563f, -0.35032028f, -0.38405651f, 
    -0.87420011f, -0.43015501f, 0.60145593f, 0.32564756f, -0.14307274f, -0.24802923f, -0.25367174f, -0.42970762f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06678316f, -0.29287833f, -0.24663909f, 0.08017647f, -0.11376901f, 0.17223965f, -0.12904878f, -0.29627484f, 
    0.06784062f, -0.07070714f, -0.10207169f, -0.09932049f, 0.12387110f, 0.07132167f, -0.05139047f, -0.25318673f, 
    0.15127131f, 0.00823593f, -0.37082508f, 0.00596808f, -0.28328380f, -0.20803379f, -0.03944950f, 0.11143045f, 
    -0.04670918f, -0.25408798f, -0.03852981f, 0.06629037f, 0.07581126f, -0.09429526f, -0.37589601f, 0.14567587f, 
    0.08170883f, -0.01254520f, 0.11206117f, 0.30487791f, 0.13429500f, 0.17096414f, 0.17862467f, -0.03993560f, 
    0.28942034f, 0.14700010f, 0.07444195f, -0.11393806f, 0.19241481f, -0.00779411f, 0.26392660f, 0.27814439f, 
    0.01454058f, 0.07169650f, -0.26284879f, 0.13723537f, 0.06534655f, 0.08760446f, 0.15587938f, -0.10540819f, 
    -0.46372670f, -0.01225019f, 0.06712719f, 0.35882032f, -0.10729363f, 0.20043123f, 0.23582590f, -0.27459905f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.24482657f, -0.13723765f, -0.47546718f, 0.09142018f, 0.02268078f, 0.16747347f, 0.07825509f, 0.00836280f, 
    -0.08330426f, -0.06714136f, -0.00389799f, 0.02658944f, -0.12513779f, -0.07716127f, -0.04582901f, 0.05130208f, 
    0.06211399f, -0.12053780f, 0.01957345f, 0.01971916f, -0.02444564f, 0.02307017f, 0.01218499f, 0.03751876f, 
    0.07215755f, 0.03410583f, 0.03581672f, 0.06945775f, 0.02887843f, 0.05205236f, -0.04845792f, -0.12575713f, 
    -0.09113429f, 0.09992919f, -0.12796314f, 0.01197071f, 0.03984202f, 0.00226428f, -0.00507380f, 0.06468412f, 
    0.03379790f, -0.02764263f, -0.01555294f, -0.00166754f, 0.00201174f, -0.03282434f, 0.00171187f, -0.03522303f, 
    0.07158565f, 0.02090742f, -0.03201152f, 0.05340905f, 0.03645933f, 0.02059312f, -0.07751769f, -0.06679434f, 
    -0.05065066f, -0.00626430f, 0.04839394f, 0.00775045f, -0.47229955f, 0.00388620f, 0.08717600f, 0.08166193f, 
    0.11662099f, -0.06646483f, -0.11501429f, -0.07784057f, 0.05360265f, 0.03576032f, -0.01018777f, 0.01162794f, 
    0.01871189f, 0.03413081f, 0.03421320f, -0.07372341f, 0.00900150f, 0.00225549f, -0.13228008f, -0.17288934f, 
    -0.01088277f, 0.01483951f, -0.01751659f, -0.01886408f, -0.05587849f, -0.13017391f, -0.02010684f, -0.11885653f, 
    0.04588222f, 0.05572126f, 0.00595946f, 0.04241246f, -0.00012411f, -0.00039249f, -0.01203644f, -0.00653095f, 
    -0.06161953f, -0.03055023f, -0.07480171f, -0.04711619f, 0.28453997f, 0.07848669f, -0.07444905f, -0.22632089f, 
    0.04575155f, -0.17961210f, -0.00837952f, 0.02682612f, 0.05455658f, -0.03237561f, -0.10067352f, -0.01405872f, 
    -0.05377958f, -0.09438083f, -0.11781949f, -0.04673610f, -0.02928699f, -0.01298823f, 0.01233564f, -0.02981284f, 
    0.02066009f, -0.00663871f, 0.04065878f, 0.05545562f, -0.01627490f, -0.06451762f, -0.02185469f, 0.09505322f, 
    0.01022091f, 0.02362699f, 0.00706196f, 0.07008830f, 0.00723995f, 0.00079165f, -0.07421217f, -0.06984859f, 
    -0.05468222f, -0.01367935f, -0.05638895f, 0.01566057f, 0.25315636f, 0.19746919f, 0.11146109f, -0.16921814f, 
    -0.00445536f, 0.13809787f, 0.14223188f, 0.12300716f, -0.00488088f, 0.05238328f, -0.01199764f, 0.01621640f, 
    0.00430183f, -0.05353349f, -0.06023900f, -0.02066922f, -0.14401273f, -0.01188647f, -0.05409956f, 0.07319734f, 
    -0.60377371f, 0.17170584f, 0.48755631f, 0.03627406f, 0.09530336f, -0.17081471f, -0.17656013f, 0.01225162f, 
    0.05735920f, -0.10805996f, -0.02385925f, -0.06277007f, -0.06830612f, 0.01294307f, 0.03255815f, 0.00943575f, 
    0.05311612f, -0.00235494f, -0.18107553f, 0.02495209f, 0.24315082f, 0.26872987f, 0.24371377f, -0.17545147f, 
    0.04674114f, -0.00076826f, 0.17265238f, 0.11979283f, -0.05086378f, -0.07561730f, 0.18661018f, -0.15210338f, 
    0.01394607f, 0.03858859f, 0.04385379f, -0.01735072f, -0.00915713f, -0.00993455f, -0.01294798f, 0.01018220f, 
    -0.23325093f, -0.12561348f, 0.01987901f, 0.10706086f, 0.03105160f, -0.01211256f, 0.00315549f, 0.01272510f, 
    -0.00184700f, 0.02539081f, 0.03674886f, -0.03436697f, -0.01134591f, -0.26020226f, -0.19911034f, 0.02412072f, 
    0.02938114f, -0.02465270f, 0.01552108f, -0.01662446f, 0.12280175f, -0.09856029f, -0.23426358f, 0.07524513f, 
    0.07441201f, 0.13477431f, 0.09939600f, 0.06886061f, 0.02881233f, 0.10861081f, -0.07557014f, 0.09361974f, 
    -0.02108985f, -0.02875704f, 0.06577259f, 0.04581954f, 0.05747151f, 0.03459842f, 0.01552694f, 0.01511430f, 
    -0.03934557f, -0.14126348f, -0.11586680f, 0.05766333f, -0.02923818f, -0.06573937f, -0.03449137f, -0.11080348f, 
    -0.07519838f, 0.00489978f, -0.02046907f, -0.03122905f, 0.00660318f, -0.02975889f, -0.02558897f, -0.18806547f, 
    0.07489798f, -0.22028278f, 0.00166695f, -0.09555744f, -0.16317433f, 0.00614381f, -0.00305891f, -0.01332089f, 
    -0.20419085f, -0.03092738f, -0.07657453f, -0.04855807f, -0.10071317f, 0.00097470f, -0.05795977f, -0.00202416f, 
    -0.06254363f, 0.00908580f, -0.06537697f, -0.15384631f, 0.04182928f, -0.10924567f, -0.16593026f, -0.15889263f, 
    0.29166228f, -0.25527823f, -0.18521599f, -0.09715526f, -0.02712734f, -0.01176338f, 0.02532321f, 0.08384714f, 
    0.11612177f, 0.01347665f, -0.04990115f, 0.02244642f, 0.11287979f, 0.04444325f, -0.04551786f, 0.07926600f, 
    0.05534602f, 0.05678303f, 0.07064822f, 0.01676113f, 0.27388835f, 0.19496609f, 0.07593782f, -0.35370740f, 
    -0.02356638f, 0.19631550f, 0.13668451f, 0.11664265f, 0.00724349f, 0.06207765f, -0.00382701f, 0.03877254f, 
    0.01299357f, 0.02736035f, -0.01385183f, 0.00267249f, -0.04543418f, 0.01168673f, 0.06719857f, 0.10480620f, 
    -0.15152557f, -0.07711868f, -0.22117735f, 0.10730910f, 0.04312720f, -0.05354971f, -0.03650213f, -0.12292335f, 
    0.06260375f, 0.02786808f, -0.26867735f, -0.12420332f, -0.11405461f, -0.18717623f, -0.13615765f, -0.09180205f, 
    -0.07645357f, 0.00788989f, -0.12736422f, 0.06093484f, -0.00469029f, 0.19009285f, 0.13294813f, -0.06714731f, 
    -0.18164481f, -0.06168645f, 0.00208437f, -0.15696323f, 0.00683842f, -0.05559834f, -0.00413036f, -0.01903906f, 
    -0.13742800f, 0.01653979f, -0.06440994f, 0.08097389f, -0.04765403f, 0.01017084f, 0.06797519f, -0.12150070f, 
    0.43055490f, 0.07452198f, -0.17110093f, -0.13602899f, -0.06293319f, 0.07963815f, 0.07535654f, 0.17835408f, 
    -0.14074382f, 0.04805254f, 0.01859725f, 0.04792275f, 0.04617397f, 0.05860958f, 0.08322079f, -0.00098714f, 
    0.12507300f, 0.14711912f, 0.01198624f, 0.06743247f, -0.00746025f, 0.06030493f, -0.14506653f, -0.03116690f, 
    -0.01692293f, 0.06582721f, -0.04446308f, -0.20839636f, -0.04106404f, -0.01971276f, 0.04104825f, 0.04147114f, 
    0.06681412f, 0.04229867f, -0.02937818f, 0.03639241f, 0.04923368f, -0.11852930f, -0.04856290f, -0.09411290f, 
    0.36585221f, 0.12131295f, -0.01816464f, -0.17295195f, -0.11561990f, 0.05480653f, 0.15495476f, -0.06094157f, 
    0.04097515f, 0.06700417f, 0.00503872f, -0.01653907f, -0.07915994f, 0.05304429f, 0.07133161f, 0.03737868f, 
    -0.06709180f, -0.14992139f, -0.00193314f, 0.04344156f, -0.08547211f, 0.19184585f, 0.07491777f, -0.03290336f, 
    -0.32794371f, -0.08208768f, -0.00801516f, 0.02776750f, -0.05018199f, 0.01481324f, 0.00182299f, -0.01307571f, 
    -0.05227904f, 0.01753114f, 0.05009150f, -0.06226322f, 0.11435001f, 0.06802028f, 0.00439274f, 0.16155846f, 
    -0.10566141f, -0.09735104f, 0.11910786f, 0.06872587f, 0.05489757f, -0.02480579f, -0.01582555f, 0.00300859f, 
    0.04105696f, 0.04804526f, 0.00976044f, -0.04647792f, -0.19437321f, -0.10697859f, 0.02727754f, -0.04248297f, 
    0.00130586f, 0.01324689f, -0.06633256f, -0.01858472f, 0.24571414f, 0.23593171f, -0.07116061f, -0.12204511f, 
    -0.05452402f, 0.00776664f, -0.01729891f, 0.04131948f, -0.15544617f, 0.05478350f, 0.02556753f, -0.04447430f, 
    -0.00313939f, 0.00754118f, 0.00688465f, -0.02802317f, -0.01741921f, -0.04198649f, 0.02544926f, 0.00248784f, 
    0.07103118f, -0.27748340f, -0.18171316f, -0.11454522f, 0.10805381f, -0.12001792f, 0.04843287f, 0.07649168f, 
    -0.02454081f, 0.02227706f, -0.13324109f, 0.16428316f, -0.05741358f, -0.06249197f, 0.03690048f, 0.01358013f, 
    -0.00990526f, -0.02774822f, -0.09114988f, 0.05847305f, -0.02611755f, -0.03801127f, -0.05564075f, 0.03778325f, 
    0.02972329f, 0.02756848f, 0.00211242f, 0.04956980f, 0.04795783f, 0.08006766f, 0.01288332f, -0.06789139f, 
    -0.27043492f, 0.06559945f, -0.09576514f, -0.04416034f, 0.01203876f, 0.02139845f, 0.04186036f, 0.08199248f, 
    0.09075608f, 0.06383619f, -0.09794459f, -0.02380319f, 0.02789096f, -0.14821494f, -0.01902187f, -0.14076218f, 
    -0.12140425f, 0.08399425f, -0.01088605f, 0.03096036f, 0.01990412f, -0.01117257f, -0.02180595f, -0.04753341f, 
    0.02333443f, 0.11464493f, -0.10481363f, 0.12101846f, -0.62184668f, -0.31012616f, 0.26959777f, 0.03563861f, 
    0.00855995f, 0.03143142f, -0.07122532f, -0.02866522f, -0.00111728f, 0.00480766f, 0.07012481f, 0.00838902f, 
    0.01538027f, -0.15121193f, -0.05745208f, -0.14228907f, -0.00720770f, -0.06125296f, 0.00554686f, -0.19883581f, 
    0.13603273f, 0.11773475f, -0.10677178f, 0.02236290f, -0.01810781f, 0.02976747f, 0.00669805f, 0.05149855f, 
    -0.00026370f, -0.04590527f, -0.10653603f, -0.00714061f, -0.00449106f, 0.00569526f, 0.04817941f, -0.00690257f, 
    -0.04814533f, -0.03781953f, -0.02610746f, -0.01608548f, -0.02249437f, -0.01690784f, 0.03443107f, 0.05445131f, 
    0.02796534f, -0.00404495f, -0.00488367f, 0.01565142f, 0.05244503f, 0.00123411f, -0.05511469f, 0.00488853f, 
    -0.03768058f, -0.00840285f, -0.04872976f, -0.02821241f, -0.09863915f, -0.03148654f, 0.00609918f, -0.00115521f, 
    0.29037645f, 0.20811951f, 0.14667125f, -0.28424865f, -0.10559338f, 0.15206066f, 0.15013796f, 0.11395943f, 
    0.00134769f, -0.03113503f, 0.02373004f, 0.00049065f, -0.04712559f, 0.00444045f, 0.02706251f, -0.00144778f, 
    -0.01502953f, -0.01682917f, -0.11896735f, 0.05237385f, 0.13985038f, 0.14038263f, -0.00278138f, -0.05220118f, 
    0.00174387f, 0.03988919f, 0.00989867f, 0.09176850f, -0.03792738f, -0.03159032f, -0.01185029f, -0.13386337f, 
    -0.04336318f, -0.02021520f, 0.01702311f, -0.03560247f, -0.02523196f, -0.02886318f, -0.01301448f, -0.02607622f, 
    0.14574234f, -0.27334920f, -0.13662787f, 0.08292694f, -0.07252856f, -0.02390374f, 0.00499428f, 0.04937319f, 
    -0.00517581f, 0.02750170f, -0.01125190f, 0.08519638f, -0.02213983f, 0.05670938f, -0.03686866f, -0.05221172f, 
    0.12948643f, -0.01120655f, -0.02312279f, -0.00165837f, -0.09762935f, -0.13993679f, 0.10776237f, 0.05427754f, 
    0.02861526f, 0.01161783f, -0.00494370f, 0.00812772f, -0.01387472f, 0.04444349f, -0.01820641f, -0.03643264f, 
    0.02447123f, -0.17428531f, -0.08594550f, -0.07336329f, 0.10268104f, -0.05134779f, -0.03044193f, 0.00016055f, 
    0.07137319f, 0.14151227f, -0.10597393f, -0.09341040f, -0.08306045f, -0.12280376f, -0.05949465f, -0.05281300f, 
    0.00771328f, -0.15886259f, -0.04942677f, -0.00243914f, -0.02970858f, 0.00220672f, -0.05002952f, -0.02401489f, 
    -0.06153726f, -0.00291385f, -0.15278828f, 0.04372781f, -0.24848734f, -0.17640197f, -0.11013349f, 0.02759325f, 
    -0.06173138f, -0.01964341f, -0.00454294f, -0.02628801f, 0.00993182f, 0.01122327f, -0.12915635f, -0.06733470f, 
    -0.04728060f, -0.00414617f, -0.12117031f, -0.04416824f, -0.03878271f, -0.00586917f, -0.00464210f, 0.04841293f, 
    0.06708679f, -0.18803918f, -0.08599885f, 0.05017916f, 0.05290221f, 0.06183978f, 0.07668043f, -0.02473618f, 
    0.01115507f, -0.02668050f, -0.01943088f, -0.00769322f, -0.02708574f, 0.03566373f, -0.00136073f, 0.05720316f, 
    0.06733991f, -0.04517411f, -0.03524532f, -0.00029095f, 0.26445022f, 0.09534329f, 0.08745267f, -0.19688293f, 
    -0.03536104f, 0.05169221f, 0.14871109f, 0.06188987f, 0.01156649f, 0.00293512f, 0.02073050f, -0.00159243f, 
    0.00003680f, -0.07369784f, 0.04653665f, 0.02815340f, -0.01718307f, 0.01641564f, -0.05429285f, 0.01100218f, 
    -0.31927022f, -0.06922846f, -0.15475531f, -0.11555561f, -0.23454472f, 0.01925423f, -0.04725725f, -0.09612072f, 
    -0.01348191f, 0.04329643f, -0.00325755f, 0.03946049f, -0.04452260f, -0.00924843f, 0.02449376f, -0.03331406f, 
    0.01712947f, -0.18412387f, -0.04309853f, -0.01551019f, 0.04585346f, 0.21523014f, 0.22077489f, -0.20224440f, 
    -0.13019186f, -0.09168741f, 0.12764429f, -0.07307640f, -0.00923659f, 0.05115106f, 0.01376147f, -0.00612991f, 
    -0.02658893f, 0.01584806f, 0.02507043f, -0.07058905f, 0.01094312f, 0.07330080f, 0.10089143f, 0.05824377f, 
    -0.22553588f, -0.21070896f, -0.08511179f, 0.02477615f, -0.03478238f, -0.01702783f, -0.00588345f, -0.03803687f, 
    0.00324407f, 0.01016798f, -0.07934307f, -0.12041969f, -0.08939526f, -0.03861272f, -0.07822523f, -0.00036679f, 
    -0.03429216f, 0.03351051f, 0.00013050f, 0.01020863f, -0.41711527f, 0.13568968f, -0.20064564f, 0.07158337f, 
    -0.16666433f, -0.02072176f, -0.01842211f, -0.17482969f, 0.07703930f, -0.08488767f, -0.02446058f, -0.16199350f, 
    -0.28417027f, 0.06853255f, 0.08754075f, 0.09179167f, -0.08317345f, -0.02731719f, -0.02299019f, -0.15222737f, 
    -0.36789960f, -0.15676366f, 0.11670241f, -0.01373580f, -0.62518346f, -0.01396485f, -0.20014566f, -0.13711250f, 
    -0.16969025f, 0.00283679f, 0.04612622f, 0.02639231f, -0.06079009f, 0.03619960f, 0.07069031f, -0.04107470f, 
    0.00294123f, 0.02385254f, -0.10659143f, -0.05052943f, 0.31074968f, -0.01267037f, 0.33067212f, -0.45156917f, 
    0.09025489f, 0.05384829f, 0.08168264f, 0.16735289f, 0.00761184f, -0.01089843f, -0.01737321f, 0.01243472f, 
    -0.04758812f, 0.01737513f, -0.07799327f, 0.05597451f, 0.01523012f, 0.03223430f, 0.00062545f, 0.06553147f, 
    -0.39701515f, -0.04346782f, 0.20229124f, -0.04782366f, 0.03321375f, -0.00595583f, 0.00481382f, -0.06923107f, 
    -0.03420198f, -0.01325865f, 0.00407819f, 0.01237275f, -0.00341539f, 0.06343743f, 0.02989057f, 0.12443478f, 
    0.07682347f, 0.00413432f, -0.04364738f, -0.02530959f, 0.03776250f, 0.12051372f, 0.10435323f, -0.04445101f, 
    -0.02257704f, -0.11862911f, 0.04595753f, -0.16420484f, -0.00166803f, -0.05725059f, -0.02561014f, 0.05121578f, 
    -0.01005737f, -0.08671983f, -0.08271930f, -0.05005296f, 0.02199649f, -0.00362339f, -0.17491819f, -0.02502231f, 
    0.05384669f, 0.17058334f, 0.06750172f, -0.21011242f, -0.15817760f, 0.02793417f, 0.03931034f, -0.06972528f, 
    -0.04476056f, -0.05479307f, -0.05630156f, -0.03456310f, 0.00119057f, 0.03239193f, -0.04296286f, -0.01383026f, 
    0.00148728f, -0.02466306f, 0.07519066f, -0.00172159f, -0.11421688f, -0.11999805f, -0.28766796f, -0.14620833f, 
    -0.16072306f, -0.03988415f, -0.02893844f, -0.00023170f, 0.06949046f, 0.05076605f, 0.01269271f, 0.02121641f, 
    -0.03216632f, 0.00666212f, 0.02725392f, 0.00992836f, -0.05018651f, 0.01825230f, 0.08763060f, 0.08933511f, 
    -0.07751513f, -0.14218371f, 0.01421978f, 0.00070453f, 0.01630448f, -0.02479925f, 0.00310635f, 0.03785127f, 
    0.04613287f, 0.04879469f, -0.07129409f, -0.01313665f, -0.09619707f, -0.01688185f, -0.07047711f, -0.01514693f, 
    -0.00901680f, 0.01701467f, 0.01684629f, 0.06712946f, -0.29463956f, 0.19368449f, -0.36564031f, -0.12878223f, 
    0.17958993f, 0.00153787f, -0.07273081f, 0.00586783f, 0.05199318f, 0.02718986f, -0.01612035f, 0.02535805f, 
    -0.02090511f, -0.06864993f, -0.01593949f, -0.15927003f, 0.00699133f, 0.06121727f, 0.03756930f, -0.08877754f, 
    0.24697815f, 0.16391191f, 0.18834370f, -0.21263506f, -0.09507139f, 0.14026450f, 0.11445258f, 0.16181742f, 
    0.05063497f, 0.10567392f, -0.03385008f, -0.03558729f, -0.02578288f, -0.08803087f, -0.11773910f, 0.03655831f, 
    -0.09345242f, -0.04554660f, 0.23515339f, 0.16909119f, -0.20312832f, -0.19400428f, -0.04962426f, -0.14236172f, 
    -0.20136802f, 0.03199079f, 0.03712060f, 0.01450278f, 0.06123788f, 0.05249478f, 0.02507227f, 0.02655131f, 
    0.05609279f, 0.04835689f, 0.05252982f, -0.03395673f, -0.07112513f, 0.07137891f, -0.05080392f, 0.07358052f, 
    0.11392222f, 0.14888789f, 0.12812060f, -0.18881792f, -0.10433363f, 0.00167309f, 0.09706734f, -0.02006361f, 
    -0.06075093f, 0.01274364f, -0.02069617f, -0.02385100f, -0.01949008f, -0.06461390f, -0.02688668f, -0.06233510f, 
    -0.06796472f, -0.00079309f, -0.06434304f, 0.09001348f, 0.24125999f, 0.34012565f, 0.06948955f, -0.30697453f, 
    -0.04085531f, 0.02179962f, 0.00898949f, -0.02255249f, 0.08440021f, 0.10234383f, 0.10445876f, 0.01965063f, 
    0.04047977f, -0.03461904f, -0.07496455f, -0.03733796f, -0.00521941f, 0.07529141f, 0.01690178f, -0.09260536f, 
    0.09553806f, -0.39367208f, -0.84190196f, 0.20347831f, -0.09839172f, -0.02977664f, -0.05404327f, 0.04377083f, 
    -0.09502581f, 0.04963531f, -0.02580497f, 0.06366996f, -0.23353584f, -0.07289518f, -0.06470831f, -0.05051997f, 
    0.09798118f, -0.02171136f, -0.07589822f, 0.07170969f, 0.25257245f, 0.28110361f, 0.07230623f, -0.39496118f, 
    -0.04926984f, 0.05059537f, -0.00025858f, 0.10923114f, -0.04521901f, 0.10309230f, 0.01818978f, 0.03455477f, 
    0.02734098f, 0.01814476f, 0.00711796f, -0.00450685f, -0.06012051f, -0.00826045f, 0.04165028f, -0.13349403f, 
    0.32481116f, 0.33499998f, -0.00041416f, -0.20435640f, -0.05917639f, 0.14819215f, 0.08263017f, 0.28181404f, 
    -0.22804323f, -0.04083807f, -0.04957161f, 0.01303077f, 0.02134826f, 0.04174281f, 0.06227102f, 0.03563962f, 
    -0.00781188f, -0.01941472f, -0.02305729f, -0.01745029f, -0.07415766f, -0.04972738f, 0.05382286f, -0.08484223f, 
    0.07832652f, 0.00504583f, 0.00113189f, -0.03694196f, 0.01452918f, -0.03818687f, 0.14272764f, 0.06186665f, 
    -0.06126620f, -0.04480794f, -0.16205470f, -0.25125015f, 0.01395985f, 0.00277976f, -0.02944486f, -0.06519876f, 
    -0.31887943f, 0.29522291f, -0.13600029f, 0.10735416f, 0.10768165f, 0.04166320f, -0.02167517f, -0.06055024f, 
    0.01558190f, 0.05657146f, 0.02257403f, 0.00632683f, 0.02309323f, 0.05549847f, 0.05781184f, 0.13186280f, 
    0.06576643f, -0.00036267f, 0.08358482f, 0.05097160f, 0.18038818f, 0.18160386f, -0.06690825f, -0.03796763f, 
    0.02507090f, 0.09245203f, 0.03830006f, 0.07308887f, -0.05247988f, -0.09523424f, -0.15246789f, -0.09998912f, 
    -0.10760047f, 0.01795938f, 0.01610640f, 0.03433173f, 0.05022155f, -0.07470388f, -0.00536887f, -0.00264622f, 
    0.09044797f, 0.04175254f, -0.14246030f, -0.21560672f, 0.02253945f, -0.04831787f, -0.04470505f, 0.04480885f, 
    0.06954691f, 0.04068534f, 0.02800060f, 0.04844242f, -0.07164855f, 0.04658923f, 0.02301665f, 0.10189976f, 
    -0.01638521f, 0.05328537f, 0.02394692f, 0.05946935f, 0.01934529f, 0.15821269f, 0.23427200f, -0.43351391f, 
    0.00977788f, -0.03132977f, 0.07206909f, -0.03125816f, -0.05913015f, -0.05638636f, 0.03922713f, -0.05414009f, 
    -0.14965101f, -0.09800968f, -0.04574846f, 0.01404811f, -0.01697969f, -0.02350599f, -0.08081890f, -0.08369007f, 
    -0.21910697f, -0.17450291f, -0.30228126f, -0.00676939f, 0.02787973f, -0.04088179f, -0.02530149f, -0.03908101f, 
    0.03883993f, 0.04514782f, -0.18067560f, -0.04958967f, -0.10734008f, -0.24175510f, -0.20970723f, -0.08392284f, 
    -0.06873603f, -0.08548991f, -0.11808598f, 0.06960505f, 0.31571609f, -0.01741603f, -0.27673116f, -0.10429856f, 
    -0.04619702f, 0.11170995f, 0.05845279f, 0.16815211f, -0.11343829f, 0.12432589f, 0.03720289f, 0.04717355f, 
    -0.08406385f, -0.00484076f, -0.01181235f, 0.06637589f, 0.12788765f, 0.10889301f, 0.01132127f, 0.06553715f, 
    0.22932094f, -0.29365361f, 0.02123131f, -0.01822814f, -0.24868190f, -0.00396100f, 0.05862027f, -0.00007826f, 
    -0.10402202f, -0.09664808f, 0.10558312f, -0.12729457f, -0.09855960f, -0.05010561f, 0.01074434f, 0.01027451f, 
    -0.02812148f, -0.12622717f, -0.01346559f, -0.01407604f, 0.09179685f, -0.00030470f, 0.02019144f, 0.06921880f, 
    0.00696751f, -0.03654670f, -0.00758459f, 0.00474260f, 0.01455993f, -0.02202286f, -0.04728339f, 0.01808568f, 
    0.00435978f, -0.06336194f, -0.09205581f, -0.11059891f, -0.11059949f, -0.02137409f, 0.01128465f, -0.05586305f, 
    -0.01010870f, -0.00090105f, -0.01281641f, -0.01287386f, 0.02469364f, 0.02030114f, 0.03725170f, -0.00605888f, 
    -0.10718492f, 0.01647226f, -0.03926967f, -0.01300104f, 0.07672445f, 0.07765793f, 0.03159266f, -0.10392890f, 
    0.01735112f, -0.08660810f, 0.04017770f, -0.03068200f, 0.32438189f, -0.27793583f, -0.05320085f, -0.30867383f, 
    0.28545687f, -0.06023672f, -0.06324639f, -0.08104982f, -0.03171714f, 0.06323338f, 0.01464085f, 0.03282339f, 
    -0.01763548f, 0.00468014f, 0.02752218f, 0.09833927f, 0.09005658f, -0.07310688f, 0.04306852f, -0.04887583f, 
    -0.01379526f, -0.03721237f, 0.10617255f, -0.00486872f, -0.02225532f, 0.02914085f, 0.11033383f, -0.06215679f, 
    0.02335328f, -0.04489836f, 0.02715916f, -0.06882393f, -0.00942596f, 0.12623534f, -0.01015885f, -0.04850918f, 
    0.03088433f, -0.06291562f, 0.02123119f, -0.03336969f, -0.04954818f, -0.18104555f, 0.06537537f, -0.13664426f, 
    0.16909967f, 0.05372134f, 0.07187451f, 0.11805356f, 0.10973004f, 0.10073649f, 0.12905204f, 0.03699734f, 
    0.01034219f, 0.07161673f, -0.10248266f, 0.02445793f, -0.02758906f, 0.01904515f, -0.07007254f, -0.23323879f, 
    -0.02271559f, -0.00665994f, 0.05758584f, -0.00823827f, 0.01914929f, 0.05224172f, 0.02506406f, 0.00584018f, 
    -0.04828766f, 0.00959561f, 0.03803513f, -0.03997341f, 0.03208858f, 0.10105642f, 0.09945396f, -0.09410528f, 
    0.01876967f, -0.13133033f, 0.05902049f, -0.01158750f, 0.14446007f, 0.27204680f, 0.12885335f, 0.26654446f, 
    0.03741948f, 0.06809460f, -0.12770723f, 0.03459658f, 0.01482442f, -0.03739294f, 0.01024311f, 0.01249092f, 
    0.03964169f, -0.05483979f, 0.01724548f, -0.04990146f, -0.00667814f, 0.06689321f, -0.01619140f, 0.05845887f, 
    -0.89996779f, -0.57207173f, -0.00470818f, -0.25841397f, -0.00214488f, 0.12631910f, 0.00731703f, 0.00767287f, 
    0.03293809f, -0.08755999f, 0.07857272f, 0.04483188f, 0.01928511f, -0.09606346f, 0.04932792f, -0.00162554f, 
    0.00806669f, 0.09261770f, 0.19917127f, -0.00302959f, -0.42864570f, -0.16125335f, -0.20086411f, -0.08316080f, 
    0.10493332f, -0.06282163f, 0.05799070f, 0.18677980f, 0.26090711f, -0.05510655f, -0.20714572f, 0.08565658f, 
    -0.03114690f, 0.06850816f, 0.04230989f, -0.07293595f, 0.02708975f, 0.03114703f, -0.03811648f, -0.00223628f, 
    0.58725196f, 0.04818360f, 0.02528141f, 0.04072862f, 0.02414256f, 0.00586661f, 0.03033505f, -0.03628084f, 
    -0.02789403f, 0.02380921f, -0.10440109f, 0.01715670f, -0.13161696f, -0.01699710f, 0.01228477f, -0.12132148f, 
    0.01220782f, -0.06203921f, 0.00468676f, 0.02836250f, -0.03241969f, -0.30795431f, -0.05290266f, 0.01930152f, 
    -0.00971923f, 0.01424608f, -0.01529575f, -0.00288809f, -0.02773706f, -0.18121785f, -0.04928923f, -0.07555865f, 
    -0.05221155f, -0.03363621f, 0.03736145f, 0.04707322f, 0.01052707f, -0.03719140f, -0.00629817f, -0.05906063f, 
    0.04852083f, 0.09786604f, -0.03264741f, 0.07136530f, 0.03399901f, 0.15335107f, -0.04068954f, 0.10493185f, 
    0.00256430f, -0.02224740f, 0.00202388f, 0.08666551f, 0.10410393f, 0.05447975f, -0.08183742f, 0.14648224f, 
    0.18321919f, 0.02260995f, 0.00815774f, 0.05040622f, -0.33498132f, -0.62911463f, -0.12553792f, -0.31667364f, 
    -0.09515745f, -0.08529900f, 0.07760540f, -0.07643516f, 0.00070322f, 0.02415943f, 0.04381655f, 0.10209519f, 
    -0.01636106f, 0.04513313f, -0.06698854f, 0.13226575f, 0.02347079f, -0.16186425f, 0.05981542f, 0.03348458f, 
    -0.16040203f, -0.24058856f, 0.08705830f, 0.04324207f, -0.19109641f, 0.01965605f, 0.01366134f, -0.03944288f, 
    -0.13103111f, -0.04895713f, 0.08290313f, -0.01388942f, -0.14489627f, -0.02204540f, 0.07993623f, 0.07543535f, 
    0.00409544f, -0.05672158f, 0.04578080f, -0.05909785f, -0.17170650f, 0.22124419f, 0.00335404f, 0.27888086f, 
    0.15299152f, -0.18972479f, -0.12448325f, 0.01040630f, -0.25060198f, 0.03331751f, 0.03345816f, -0.03107804f, 
    0.02238121f, 0.00390152f, 0.04123095f, 0.02817690f, 0.04830551f, 0.03556280f, -0.25670105f, 0.05437596f, 
    0.32441816f, 0.08752979f, -0.04427771f, 0.09812593f, -0.07694557f, -0.03342366f, -0.04819056f, 0.00990986f, 
    0.02414529f, -0.07388509f, 0.01182155f, 0.08786414f, -0.07036353f, 0.07460864f, 0.12396232f, -0.01594511f, 
    -0.06123691f, 0.10392668f, 0.11079874f, -0.01611372f, 0.11271435f, 0.28710976f, -0.06511845f, 0.07714595f, 
    -0.13788569f, -0.03563460f, 0.04915476f, 0.09462158f, -0.01549007f, 0.04643400f, -0.05022643f, 0.08762263f, 
    -0.00348080f, -0.00028110f, -0.01630741f, -0.04698884f, -0.26106837f, -0.02341432f, -0.14948702f, -0.13693874f, 
    0.17673694f, 0.11124626f, 0.42230105f, 0.02001367f, -0.02118377f, 0.03070590f, -0.20267510f, 0.01032387f, 
    0.13521816f, -0.36261696f, 0.08184898f, -0.10345531f, -0.02761579f, -0.18082467f, -0.09125805f, 0.12017705f, 
    -0.07896756f, -0.08323757f, 0.06262637f, 0.01483312f, 0.17531610f, 0.01933327f, 0.09476238f, -0.01919479f, 
    0.00713049f, -0.03647498f, -0.03741810f, -0.32388321f, 0.05591419f, -0.08408126f, 0.00377234f, -0.03650694f, 
    0.01475156f, 0.02961887f, 0.04298323f, -0.00811550f, 0.00808693f, -0.13768400f, 0.09884299f, -0.10365837f, 
    0.35163361f, 0.03039737f, 0.01884873f, -0.36123338f, 0.13337059f, 0.09140474f, -0.13069774f, -0.09037636f, 
    0.19372928f, 0.06696811f, 0.05432538f, 0.00623247f, 0.11771935f, -0.08730524f, -0.11269257f, 0.00044035f, 
    -0.02972948f, -0.08948830f, 0.01193701f, 0.05358580f, -0.38460916f, 0.02942724f, -0.16244604f, -0.16843031f, 
    -0.67804897f, 0.00069448f, -0.11211393f, -0.27594644f, -0.22057776f, 0.04388007f, -0.04269449f, 0.03824824f, 
    -0.03990207f, 0.00719046f, -0.00409520f, -0.28364548f, -0.15776907f, -0.30428484f, -0.10529908f, -0.21362872f, 
    -0.11600553f, -0.06469475f, 0.13561095f, 0.00633997f, 0.06054340f, 0.00688480f, 0.00904135f, -0.01879930f, 
    -0.05882069f, 0.00661467f, 0.15764418f, 0.10860315f, -0.04376736f, 0.05275751f, -0.02662763f, -0.04033919f, 
    -0.04022066f, -0.12406027f, -0.00303613f, 0.04142108f, -0.10299566f, -0.00301868f, -0.11958628f, 0.08251074f, 
    -0.12137065f, 0.03372054f, 0.11204500f, -0.26094851f, -0.06868369f, 0.04608242f, 0.03383590f, -0.05868794f, 
    -0.01985490f, 0.06039464f, -0.00835301f, -0.03333844f, 0.03959793f, 0.03136314f, 0.04108156f, 0.08518226f, 
    0.60269290f, 0.19582328f, -0.21314006f, -0.16799873f, -0.18188757f, -0.11124485f, -0.01287100f, -0.03749424f, 
    0.11149804f, -0.02120993f, 0.03587222f, 0.00107637f, -0.12047730f, -0.07632910f, -0.04012388f, -0.04965165f, 
    -0.01857682f, -0.01751437f, 0.08440972f, -0.02523027f, 0.19702114f, 0.10667338f, 0.04275148f, 0.12555359f, 
    0.09579954f, -0.08583610f, -0.02528899f, -0.08657748f, 0.01062046f, -0.05739496f, -0.05083025f, 0.11349487f, 
    0.07740634f, -0.12106918f, 0.05488471f, -0.11119328f, -0.17410330f, 0.01176120f, 0.00406426f, -0.10822703f, 
    -0.01206587f, 0.25127593f, -0.26519978f, -0.11067729f, -0.08776537f, 0.12205411f, -0.16710772f, 0.05293756f, 
    0.07954510f, -0.12571818f, 0.04374597f, 0.04594652f, -0.04307000f, -0.10465832f, 0.15138507f, -0.09655246f, 
    0.00635870f, -0.23122641f, 0.08012140f, -0.17917652f, -0.11163561f, 0.14256063f, -0.00395464f, 0.09892223f, 
    0.10634687f, -0.09580865f, -0.04563171f, 0.05109853f, -0.13031113f, -0.03507579f, 0.03160494f, 0.03521355f, 
    0.08006934f, 0.01611017f, -0.12565221f, 0.07195088f, 0.32574382f, -0.02850457f, -0.06327569f, 0.12052982f, 
    -0.03729917f, -0.12380637f, -0.12947768f, -0.07968628f, -0.08979605f, -0.03097343f, 0.05131002f, 0.01756410f, 
    -0.05496101f, 0.05523280f, 0.22418965f, 0.10454971f, 0.02869567f, 0.07846819f, -0.00706578f, -0.01150734f, 
    0.04279030f, 0.01753943f, 0.00218524f, 0.04977591f, 0.10999306f, 0.02720892f, 0.09638076f, 0.02171069f, 
    0.06451523f, -0.00977764f, -0.00256481f, -0.00137397f, -0.06392252f, -0.02230255f, -0.02082809f, -0.01279364f, 
    -0.01890534f, 0.09321886f, -0.04957702f, -0.14770879f, -0.01184048f, -0.00036835f, 0.01457698f, 0.01111986f, 
    -0.14091200f, 0.24522491f, -0.03253698f, 0.22625521f, 0.27171376f, -0.17257388f, 0.03334212f, -0.03706101f, 
    -0.13351265f, -0.13266912f, -0.01389080f, -0.00788595f, 0.00851287f, 0.00167081f, 0.01780783f, 0.01574475f, 
    -0.02450520f, 0.04186119f, -0.10529047f, -0.01344506f, -0.09865120f, -0.06112840f, -0.09104167f, -0.01862105f, 
    -0.05830977f, -0.04081011f, 0.06274917f, 0.07895068f, 0.07682666f, -0.06083992f, -0.10649285f, 0.02544527f, 
    0.00775170f, 0.06972772f, 0.00178792f, -0.01951233f, 0.06285852f, 0.06935034f, -0.00354976f, -0.00398412f, 
    0.64545619f, -0.21282281f, 0.35683209f, 0.18771364f, -0.04756483f, 0.04269889f, 0.00483150f, 0.05017853f, 
    0.01175481f, -0.09859992f, 0.06028143f, -0.16595139f, 0.10692544f, -0.09471734f, -0.17893711f, 0.18905914f, 
    -0.02545805f, -0.07033217f, -0.02792439f, 0.05427962f, 0.12170537f, 0.06736132f, 0.09201128f, 0.10060368f, 
    0.05775425f, -0.02072887f, 0.05853472f, 0.07413455f, -0.05736768f, -0.02712200f, -0.03402348f, 0.06876236f, 
    0.14069356f, 0.03155820f, -0.11248191f, 0.05652772f, 0.08918539f, -0.05620164f, -0.03772707f, -0.01844667f, 
    -0.05569199f, 0.01566354f, -0.14702566f, -0.02661106f, -0.15996347f, -0.01291114f, -0.05547959f, 0.03145752f, 
    -0.09208860f, 0.11612087f, 0.03536277f, 0.00828987f, 0.12452842f, 0.08434485f, 0.08443297f, 0.06131475f, 
    -0.01524247f, 0.03195525f, 0.19626062f, 0.00880194f, 0.18050882f, 0.01722989f, 0.05571365f, 0.11051885f, 
    0.07469382f, -0.04297286f, 0.03021480f, -0.02519596f, 0.04089297f, 0.02237969f, 0.11017675f, 0.01423448f, 
    0.01539664f, 0.02765554f, 0.09449434f, -0.03757306f, -0.02314513f, 0.04075759f, 0.06844574f, -0.08593396f, 
    -0.36402288f, -0.33661804f, 0.03963913f, -0.05780325f, -0.17142092f, 0.05541482f, 0.05034465f, -0.01342081f, 
    -0.02928672f, -0.06585515f, 0.01637303f, 0.03857303f, 0.06619973f, 0.04388748f, -0.02451150f, -0.01583657f, 
    0.02021280f, -0.02848271f, 0.04020227f, 0.06139799f, -0.02820421f, 0.13467976f, -0.02307774f, -0.03234991f, 
    -0.07430028f, 0.04098614f, -0.05210494f, 0.04419356f, -0.09878455f, -0.04785047f, 0.02627447f, 0.04336431f, 
    0.02545157f, -0.08324641f, 0.00938351f, 0.13230065f, 0.06986813f, 0.00214712f, -0.10712665f, -0.01553670f, 
    0.12062316f, 0.04156215f, 0.24106961f, -0.05376006f, 0.00238202f, 0.03857959f, -0.02012971f, -0.03561921f, 
    -0.02066886f, -0.01770146f, 0.01108115f, 0.01154014f, 0.00989790f, 0.07316349f, 0.03582387f, -0.07407230f, 
    0.21877053f, -0.10377234f, 0.08602033f, 0.01372570f, -0.23707162f, 0.08580992f, -0.03983349f, -0.20430596f, 
    -0.25649929f, 0.03696826f, -0.23146422f, -0.05895485f, -0.05178677f, 0.00501063f, -0.02842951f, 0.03047542f, 
    -0.00663824f, -0.01526432f, -0.01613652f, 0.00248546f, -0.09362391f, 0.07279307f, -0.15465459f, -0.21755747f, 
    0.09655752f, 0.02493654f, 0.01998927f, 0.09778922f, 0.02714838f, -0.00192490f, -0.00191240f, -0.00197430f, 
    -0.01112757f, -0.02231304f, 0.11299087f, 0.01552926f, 0.01899576f, 0.05782588f, 0.04437377f, -0.04493728f, 
    -0.03724280f, -0.01698462f, 0.04354990f, -0.03766932f, 0.28511322f, 0.03687370f, 0.21323340f, 0.19295345f, 
    -0.40063372f, 0.05142068f, 0.07962684f, 0.15329984f, -0.02791564f, 0.09670400f, 0.01677492f, 0.05557397f, 
    0.01924627f, 0.08805294f, -0.18548909f, -0.11078092f, -0.04835033f, 0.01040104f, 0.04058622f, -0.02822297f, 
    -0.00627165f, -0.16075605f, -0.08674123f, -0.05387184f, -0.21068101f, 0.12296352f, -0.06876460f, -0.09435629f, 
    -0.11566596f, 0.05517239f, -0.07877284f, -0.02359515f, 0.05061145f, 0.05505154f, -0.03132829f, 0.03115826f, 
    0.10957088f, 0.00356851f, 0.16038877f, 0.07003549f, -0.32990071f, -0.27504376f, -0.24284039f, -0.16114277f, 
    0.02841058f, -0.11427390f, -0.05705375f, 0.05052028f, 0.11949184f, 0.03499296f, 0.02395301f, 0.06040334f, 
    -0.01073855f, -0.00806738f, -0.16205551f, 0.01969188f, 0.04392800f, 0.00417544f, 0.00926514f, -0.09998707f, 
    0.28419656f, 0.03380985f, 0.18357711f, 0.01743703f, 0.09067605f, 0.03206518f, -0.02045086f, -0.03529530f, 
    0.00736586f, 0.01208669f, 0.00509623f, -0.02540049f, 0.00500084f, 0.00800181f, -0.01912815f, 0.11358441f, 
    0.08540938f, 0.04428102f, 0.02081305f, -0.06949640f, -0.23242024f, -0.23389113f, 0.08992501f, -0.07587110f, 
    -0.00532020f, 0.09466721f, 0.19900107f, -0.11578623f, 0.02094904f, 0.10057037f, -0.06344017f, -0.06373657f, 
    0.03809775f, 0.16041455f, 0.08581013f, -0.01486665f, -0.00869877f, -0.05278163f, 0.07630622f, 0.01990237f, 
    0.03787027f, 0.04026166f, -0.12633753f, 0.00584736f, -0.06169901f, -0.06163660f, -0.01511472f, -0.02902122f, 
    -0.13303921f, 0.15030546f, 0.02038024f, 0.00031291f, 0.07516615f, 0.01039598f, 0.06613707f, 0.02966134f, 
    0.04039732f, 0.00243710f, -0.18901333f, -0.00754991f, 0.11862667f, 0.02228821f, 0.10312132f, 0.15957712f, 
    0.22967085f, -0.03783441f, -0.01785997f, 0.04539790f, 0.00835788f, 0.00420199f, 0.02279312f, 0.02131040f, 
    0.00980153f, -0.05234316f, 0.11934553f, 0.16101027f, -0.04285894f, 0.00248223f, 0.00620287f, -0.02071180f, 
    0.05641292f, -0.00734649f, 0.03414905f, 0.12674752f, 0.09990036f, -0.00653280f, 0.00459959f, -0.01176914f, 
    -0.02802570f, -0.03101047f, -0.02369341f, -0.04705500f, -0.04446372f, 0.05103814f, 0.13133323f, 0.03176416f, 
    -0.03875345f, -0.01150147f, 0.03085135f, -0.08121660f, -0.09005940f, -0.13020970f, 0.21695475f, 0.20677941f, 
    0.30697680f, -0.04197996f, -0.01068883f, 0.01838846f, 0.03418656f, -0.01135156f, 0.02132050f, 0.02832351f, 
    0.06455498f, -0.09633557f, 0.09852315f, -0.01735870f, 0.09638229f, 0.07908785f, -0.10323050f, -0.05417982f, 
    0.00540824f, 0.24731526f, 0.08908793f, -0.01239123f, 0.13891141f, 0.05854347f, 0.03682215f, -0.06540040f, 
    0.00859390f, 0.14355007f, 0.01073746f, 0.05083961f, 0.00512696f, -0.02930181f, 0.03417914f, -0.06928705f, 
    -0.10072994f, 0.21285859f, -0.17555535f, -0.01632877f, 0.05801626f, -0.06093164f, 0.19015667f, 0.12616116f, 
    0.24131960f, -0.00810462f, -0.03081687f, -0.00112161f, -0.06384988f, 0.02185906f, 0.03128737f, -0.01224561f, 
    -0.03159010f, 0.00927569f, 0.05212118f, 0.18413219f, -0.04800599f, -0.10990130f, 0.09372082f, -0.02062395f, 
    0.00003194f, 0.05944185f, -0.00307108f, -0.06259799f, 0.06658787f, 0.15962806f, -0.04842037f, -0.03889983f, 
    -0.02875458f, 0.05040296f, -0.00877415f, 0.06882783f, 0.01363346f, -0.00041111f, 0.03412962f, -0.06890576f, 
    -0.04382224f, 0.17878096f, -0.22257636f, -0.14339963f, -0.23099984f, 0.08377467f, -0.20763282f, -0.06173153f, 
    0.06818749f, -0.06830954f, -0.16019213f, -0.02259777f, 0.00782920f, -0.06577857f, -0.09454871f, 0.10283201f, 
    0.03111521f, 0.06691607f, 0.09725382f, -0.06782860f, 0.00129782f, 0.11478132f, -0.10984925f, 0.12152977f, 
    1.06489646f, -0.25260064f, -0.27099857f, 0.16034187f, -0.27853051f, 0.03865396f, 0.00840690f, 0.03407434f, 
    -0.03521459f, -0.06564901f, 0.10935836f, -0.11346820f, 0.18329446f, -0.09182161f, 0.04466991f, 0.04754341f, 
    -0.10978895f, -0.19868591f, -0.01015719f, 0.05138050f, -0.21608435f, 0.14875789f, -0.13947462f, 0.08525176f, 
    0.13455069f, -0.17151937f, -0.02342995f, 0.08146212f, -0.03764451f, -0.07672699f, -0.02983911f, -0.02588280f, 
    0.04303140f, -0.07029613f, 0.00328131f, -0.03486594f, 0.06179117f, 0.07697452f, -0.24904676f, -0.08105962f, 
    -0.17976816f, 0.10177500f, 0.07451210f, 0.28334063f, 0.06515849f, -0.16455346f, 0.11197766f, 0.02392457f, 
    -0.08960792f, -0.06187645f, -0.00347649f, -0.01239543f, -0.00296624f, 0.00725159f, 0.00596643f, 0.00038072f, 
    0.04556018f, -0.04049179f, -0.01820672f, 0.03253409f, -0.01094170f, 0.16752641f, -0.01010418f, 0.06326012f, 
    0.09725089f, -0.10045810f, 0.01051839f, -0.04567756f, -0.03866912f, -0.02157237f, -0.04099426f, 0.04786008f, 
    0.02360014f, 0.00000777f, -0.08552476f, -0.02010659f, 0.03573706f, 0.02599988f, -0.04392117f, 0.01902807f, 
    0.64823210f, 0.26875681f, 0.06308033f, 0.08763956f, 0.00296602f, -0.05548249f, -0.02975428f, -0.04163701f, 
    0.00216069f, -0.01828833f, 0.01574973f, 0.03508275f, 0.00748718f, 0.04087130f, 0.01255717f, 0.07353681f, 
    -0.17379686f, -0.13167135f, 0.07842784f, 0.06195812f, -0.14126641f, -0.21717747f, -0.17820096f, -0.08170570f, 
    -0.07837096f, -0.02954440f, 0.08327108f, 0.16691115f, -0.01827545f, -0.14946748f, 0.02557632f, 0.03898348f, 
    0.09880676f, 0.01300761f, -0.02488937f, -0.01242129f, 0.05516199f, 0.04283420f, -0.02087388f, -0.01294052f, 
    0.01130451f, -0.34690544f, -0.00409134f, 0.00977782f, 0.11903935f, -0.00933045f, -0.05315329f, -0.03688050f, 
    -0.00258080f, 0.01095905f, 0.07929611f, 0.07590814f, 0.03193201f, -0.02591144f, 0.09898880f, 0.07106435f, 
    -0.21006235f, -0.11105722f, -0.06537127f, -0.25907245f, -0.83419317f, 0.04441884f, -0.12641166f, -0.12870979f, 
    0.19822997f, -0.12427904f, -0.05246849f, 0.08161881f, 0.11625084f, -0.03483022f, -0.00325106f, 0.05685000f, 
    0.02941664f, -0.03986359f, -0.00073189f, 0.04448181f, 0.00392707f, 0.03292826f, -0.00203254f, 0.04463904f, 
    0.21400380f, -0.00015521f, 0.06418741f, 0.07422603f, 0.01872892f, -0.11041558f, 0.02759298f, -0.08941101f, 
    0.06133495f, -0.05933288f, 0.06034839f, 0.09516206f, -0.03661808f, 0.06638603f, 0.02955825f, -0.15427211f, 
    0.02802050f, 0.02959414f, 0.16342942f, -0.01773819f, 0.14952509f, 0.13862838f, 0.22987792f, -0.06652433f, 
    -0.20740177f, -0.04926505f, -0.14518520f, 0.03347545f, 0.15877134f, -0.06999857f, 0.07772341f, -0.05881659f, 
    0.04152507f, -0.12862909f, -0.09379677f, 0.07534870f, -0.07597407f, -0.01534083f, 0.02251884f, 0.00703500f, 
    -0.11810915f, 0.08493074f, 0.56821829f, -0.02138030f, 0.23744088f, -0.01164420f, 0.00250269f, 0.12842850f, 
    0.00593834f, 0.03918215f, 0.09905306f, -0.02486779f, 0.04315462f, -0.16341141f, 0.13700265f, -0.00884729f, 
    -0.00326256f, -0.04289413f, 0.02016301f, -0.03419236f, -0.00709400f, -0.10407892f, -0.02714904f, 0.01539441f, 
    0.14699528f, 0.00059463f, 0.02368718f, 0.01561405f, 0.03957862f, 0.01851691f, -0.08306950f, -0.02497405f, 
    0.06446033f, 0.00201531f, 0.10400304f, 0.01491559f, 0.03010867f, -0.02731630f, 0.00765184f, -0.01094657f, 
    -0.17049320f, 0.02054124f, 0.01400627f, 0.04989927f, 0.07231963f, -0.06394684f, -0.05980202f, -0.18672980f, 
    -0.10331985f, 0.03307541f, -0.00312476f, -0.05592955f, -0.01105564f, 0.00727462f, 0.00785006f, 0.00371378f, 
    -0.05247569f, -0.05953478f, -0.06300808f, -0.04491841f, -0.04341980f, 0.09942952f, 0.29609746f, -0.30724433f, 
    0.15088204f, 0.16160801f, 0.01927830f, -0.04327067f, -0.04168246f, 0.02721399f, -0.01170879f, -0.00180290f, 
    0.03163198f, 0.02723675f, -0.03100238f, 0.08014063f, 0.01078513f, -0.21220528f, -0.01453372f, 0.02746319f, 
    -0.08304866f, -0.09032805f, 0.10198849f, 0.00761035f, 0.01211207f, -0.05143902f, -0.08705679f, -0.22017601f, 
    -0.09222588f, 0.05918332f, 0.06600760f, 0.00121284f, 0.02443923f, 0.04118413f, -0.05639587f, 0.01975511f, 
    -0.09352165f, -0.05041726f, -0.01223796f, -0.03039501f, 0.43094975f, 0.10593933f, 0.08626245f, 0.17747653f, 
    0.22505365f, 0.08099571f, -0.02930683f, -0.14855370f, -0.00100334f, 0.13206714f, 0.03631561f, 0.00592390f, 
    0.04868918f, -0.00666333f, -0.02121486f, 0.00738587f, 0.10345975f, 0.03524653f, -0.02122053f, 0.00574815f, 
    -0.01964977f, -0.04384259f, 0.03096315f, -0.03763954f, 0.10779445f, -0.09598384f, -0.12740377f, -0.10405984f, 
    -0.05498971f, 0.00220583f, 0.04751818f, -0.10435642f, -0.14029132f, -0.00472457f, -0.03021412f, 0.00681891f, 
    -0.12000401f, -0.03794685f, -0.04180108f, -0.03150348f, -0.36574611f, -0.32012075f, -0.05622593f, 0.27271637f, 
    -0.22484674f, -0.06117064f, 0.03687526f, 0.06015697f, 0.07798743f, -0.00540093f, 0.01089808f, -0.01797728f, 
    0.01155885f, 0.01519974f, 0.03515755f, -0.03565617f, 0.03918176f, 0.00905449f, -0.11973483f, 0.04974994f, 
    0.45811522f, 0.06641615f, -0.44808638f, -0.05058038f, 0.04163144f, -0.03364395f, 0.13424781f, -0.03072557f, 
    -0.09379447f, 0.07243145f, 0.06190182f, -0.02377899f, -0.00029575f, 0.02072940f, -0.08956113f, 0.02818782f, 
    0.06497075f, 0.10899097f, 0.08906803f, 0.08047044f, 0.16821636f, 0.13480861f, -0.14651224f, 0.14107904f, 
    0.10007402f, -0.00778539f, -0.02416085f, -0.10939046f, -0.01743398f, -0.06948388f, -0.09917440f, 0.07260597f, 
    -0.10889088f, 0.02152990f, -0.02531717f, -0.00628822f, 0.00438376f, 0.03698852f, -0.07327452f, -0.00011461f, 
    -0.19780146f, 0.09320176f, 0.02187110f, -0.00859713f, 0.04119037f, -0.04474616f, 0.02804241f, 0.02568652f, 
    0.00805027f, 0.01715613f, 0.04010456f, -0.05249929f, -0.13758156f, 0.17381121f, 0.02052394f, 0.00787481f, 
    -0.07614858f, 0.04827148f, 0.10185272f, -0.07154336f, -0.23207965f, -0.42920780f, 0.40612969f, 0.12527823f, 
    0.16012423f, -0.01949684f, 0.04102872f, 0.07151430f, 0.10071237f, -0.18099108f, -0.05874506f, -0.07015233f, 
    0.06994865f, -0.09548666f, 0.07211906f, -0.03206249f, -0.01012047f, -0.00286782f, 0.02932184f, -0.02505502f, 
    -0.08043075f, 0.21678957f, -0.10058729f, -0.12993193f, 0.03593240f, 0.10626079f, -0.00261595f, -0.07519111f, 
    0.01092244f, 0.06159740f, -0.01413951f, 0.03255107f, 0.09571365f, -0.06546520f, 0.08902773f, -0.14702658f, 
    0.00449490f, 0.01127183f, 0.01040567f, 0.00020693f, 0.50968313f, -0.49282712f, -0.07299082f, -0.34847024f, 
    -0.01855789f, 0.09599423f, -0.10234213f, -0.04361445f, -0.00568000f, -0.04996559f, 0.02966934f, -0.09450805f, 
    0.11074512f, -0.13799395f, 0.09158542f, 0.13425373f, -0.03949773f, -0.14827587f, 0.19898902f, -0.04150949f, 
    -0.22795871f, -0.13155842f, 0.36033449f, 0.07679661f, 0.30526441f, -0.07518778f, 0.00764574f, 0.04170591f, 
    -0.08572756f, -0.04461531f, 0.04394135f, 0.00852008f, 0.04973335f, -0.01576253f, 0.12076887f, 0.02578911f, 
    0.04458343f, 0.06778385f, -0.06369428f, 0.00778107f, -0.36061099f, -0.35258746f, -0.49857432f, 0.00954373f, 
    -0.57248032f, 0.01837010f, -0.00011022f, 0.01099457f, 0.02120527f, -0.10453878f, -0.01743407f, 0.01265083f, 
    0.03630257f, -0.01212475f, -0.05252212f, -0.01955768f, 0.02865552f, -0.02659437f, -0.08767013f, 0.02624266f, 
    -0.12424517f, 0.00095350f, -0.04236032f, -0.15564005f, 0.01448451f, -0.01450214f, -0.06546750f, -0.07078569f, 
    0.02858496f, 0.08826926f, 0.03180402f, -0.04889970f, -0.12573719f, 0.05405234f, -0.02519156f, 0.08597736f, 
    -0.03357635f, -0.17146708f, 0.12059813f, -0.00534075f, 0.01995192f, 0.02323388f, 0.03470295f, 0.31246412f, 
    -0.08290484f, 0.00993346f, 0.01335709f, 0.02367394f, -0.09993927f, 0.15707846f, -0.01052853f, 0.04680829f, 
    0.03622041f, -0.03779786f, -0.01163748f, -0.02742163f, 0.03541787f, -0.09231520f, 0.11033139f, 0.08184749f, 
    -0.23985562f, -0.35919780f, 0.75071281f, 0.43699801f, 0.16381449f, -0.13420396f, -0.18416212f, -0.05649329f, 
    0.13005379f, -0.07210054f, 0.02396763f, 0.02587757f, -0.01960497f, -0.14491484f, 0.05714613f, -0.05529945f, 
    0.02230290f, 0.04352468f, 0.02521169f, -0.11434358f, -0.28723130f, -0.10409842f, 0.24091093f, -0.33645922f, 
    -0.01050010f, -0.00586478f, 0.03538236f, -0.07307569f, -0.02399295f, 0.18428051f, 0.04449240f, -0.04942367f, 
    0.01784152f, -0.00433897f, -0.03095250f, -0.01310271f, -0.17028974f, -0.11085363f, -0.14861701f, 0.02582329f, 
    -0.24126132f, -0.27431917f, 0.18015212f, 0.25794384f, -0.00665188f, 0.05051178f, -0.04926590f, -0.02406389f, 
    0.12392055f, -0.13497214f, -0.00279526f, -0.01642665f, 0.00056950f, 0.04483495f, 0.00294510f, 0.02040669f, 
    0.05249430f, -0.06020623f, -0.01432724f, 0.05414601f, 0.34990588f, -0.77206200f, 0.32594115f, -0.12786312f, 
    -0.12822632f, -0.01200981f, -0.13755994f, -0.10796273f, -0.06513342f, -0.10000537f, -0.03273834f, -0.02473728f, 
    0.01563494f, -0.01668500f, -0.01230553f, -0.06665350f, -0.03044524f, -0.06100068f, 0.27880660f, 0.12102170f, 
    0.18162949f, -0.07727727f, 0.00168313f, 0.00237562f, 0.04287425f, -0.01930395f, 0.03792169f, 0.03480223f, 
    -0.05024186f, -0.01199797f, -0.03260351f, -0.17188053f, -0.01148670f, 0.05022075f, 0.10002814f, 0.06529555f, 
    0.02293070f, -0.04010610f, 0.08087747f, -0.03009563f, -0.11515834f, -0.11737486f, -0.19175114f, 0.06049627f, 
    -0.13750163f, -0.00555304f, 0.17882448f, -0.01635688f, -0.04951357f, -0.26559305f, 0.06705340f, 0.02315890f, 
    0.01146669f, 0.01626271f, -0.03363752f, 0.03229538f, 0.00481385f, -0.01841146f, 0.05583846f, -0.02384375f, 
    -0.34453359f, -0.10352548f, 0.14121772f, -0.03060231f, 0.00343245f, -0.02752096f, -0.07866035f, -0.04935180f, 
    -0.03207906f, 0.07154111f, 0.02016604f, -0.00855882f, -0.30063197f, 0.12942003f, 0.04185404f, 0.08811448f, 
    -0.01889989f, 0.07742728f, 0.09997173f, -0.02568040f, -0.10484422f, -0.13968366f, -0.12465281f, -0.05575821f, 
    0.09853280f, 0.03538143f, -0.01214569f, 0.07165415f, 0.07708017f, 0.04192205f, -0.24877715f, 0.00073991f, 
    -0.00223303f, 0.02175397f, 0.12908459f, 0.01170537f, 0.03577648f, -0.01242535f, 0.05142019f, 0.03445148f, 
    -0.13683601f, 0.10229606f, 0.04835178f, -0.00019774f, -0.39354578f, 0.06703417f, 0.09146953f, -0.04886532f, 
    0.16275674f, -0.03937183f, -0.09738247f, 0.01396711f, -0.01560797f, -0.03105610f, -0.08431716f, 0.07557936f, 
    -0.01906074f, -0.06059559f, 0.07480776f, -0.06792961f, 0.37251303f, 0.21068087f, -0.17671476f, -0.05511101f, 
    0.20128837f, -0.15553480f, 0.13609532f, -0.00673400f, -0.03524213f, -0.06667563f, -0.03441321f, -0.04362281f, 
    0.01654582f, -0.04694965f, -0.05582092f, 0.12731645f, -0.03276470f, 0.04399703f, -0.05565429f, -0.02041281f, 
    -0.00956823f, 0.08074252f, 0.01782092f, 0.08071212f, 0.11714616f, -0.04055867f, -0.03377767f, -0.04485709f, 
    -0.04571223f, -0.24967052f, -0.00356100f, 0.02339762f, 0.03113948f, -0.01688289f, 0.02169114f, -0.01426714f, 
    -0.02084902f, -0.03089208f, 0.00460897f, -0.07148840f, -0.08695552f, 0.00445463f, 0.00768281f, 0.00008401f, 
    0.02596257f, -0.02015016f, 0.00136490f, 0.02121173f, -0.00837057f, 0.01266767f, -0.03595660f, -0.09002604f, 
    -0.05910982f, 0.01450722f, -0.09573023f, -0.04176078f, -0.11478045f, 0.01504961f, 0.00664010f, -0.03079388f, 
    -0.46616706f, -0.02393990f, -0.35339594f, 0.05596419f, -0.47494948f, -0.00485461f, -0.04888716f, 0.02368622f, 
    0.08387365f, -0.07416910f, -0.03757733f, 0.03973468f, -0.00604671f, 0.00074485f, -0.04581622f, -0.01070541f, 
    0.00667997f, -0.01283838f, -0.12935336f, -0.01984629f, 0.10721343f, 0.01649234f, 0.09035600f, 0.09103966f, 
    0.09486738f, 0.00916228f, -0.04475866f, -0.00662989f, 0.01354071f, -0.11852410f, 0.06458991f, 0.03384279f, 
    0.01997740f, 0.03401145f, -0.00650753f, -0.01075501f, -0.05665207f, -0.05234440f, 0.02282630f, -0.05680472f, 
    -0.15325125f, 0.11373214f, 0.26288748f, 0.02351569f, -0.01439167f, 0.04135899f, -0.06295280f, -0.06974380f, 
    0.00060445f, 0.02506634f, 0.03726716f, 0.00821617f, 0.04515084f, -0.15869373f, 0.08758282f, -0.06264808f, 
    0.04760175f, 0.14442363f, 0.10617847f, -0.12320879f, 0.05558846f, 0.07266509f, -0.12293019f, -0.09529348f, 
    0.00377171f, -0.02297250f, 0.01369475f, 0.06037001f, 0.01066742f, 0.03256238f, -0.04975868f, -0.00224439f, 
    0.10240890f, 0.04285232f, -0.00629222f, 0.02382590f, -0.05311340f, 0.03554980f, 0.03939021f, 0.00722767f, 
    -0.34390441f, 0.16236976f, 0.09644061f, 0.09350669f, -0.05454913f, -0.00522244f, 0.14242953f, -0.16399159f, 
    -0.18465656f, -0.11588847f, 0.07638934f, 0.00750779f, -0.00525474f, 0.03306945f, -0.02602425f, 0.02450612f, 
    0.01709315f, -0.05811484f, -0.10286830f, 0.09281518f, 0.08133399f, -0.04393302f, -0.08105152f, -0.06334364f, 
    0.12297194f, 0.00703940f, -0.03315264f, 0.02058647f, 0.02978906f, 0.03666091f, -0.04943959f, 0.02898037f, 
    0.01373900f, 0.00036631f, -0.03779464f, 0.09986717f, -0.00627539f, -0.04171583f, 0.02654425f, 0.00431513f, 
    0.02335806f, 0.18355161f, 0.29696190f, 0.05682720f, 0.20911705f, -0.00702345f, 0.03076232f, 0.04354705f, 
    0.01985807f, -0.05271298f, 0.07000537f, 0.01624897f, -0.02546515f, 0.03543787f, 0.10885746f, 0.03758801f, 
    -0.02991030f, 0.01437583f, 0.01129925f, 0.00910637f, -0.11452588f, 0.21113570f, 0.27640989f, 0.36340714f, 
    0.31584015f, 0.06656672f, 0.00216723f, -0.01588023f, 0.15043038f, 0.09801574f, 0.00288653f, 0.01773335f, 
    0.04346426f, -0.01643711f, -0.03452390f, -0.03763923f, -0.01678746f, 0.06827193f, -0.01376158f, -0.00423494f, 
    -0.11563552f, -0.21378279f, 0.20694879f, -0.23301443f, -0.04679865f, -0.00569428f, 0.03307460f, -0.02448630f, 
    0.01336064f, 0.06672724f, 0.02671441f, -0.01936355f, -0.00404914f, 0.08659807f, 0.02089305f, -0.01777068f, 
    -0.10586254f, -0.05552772f, -0.02727119f, -0.03981586f, -0.24728286f, -0.10103982f, 0.30234852f, 0.03221219f, 
    -0.35601881f, -0.03027593f, 0.05774892f, -0.15836711f, -0.04009954f, -0.04245235f, 0.00188053f, 0.00185625f, 
    -0.02365663f, 0.02539290f, -0.03455156f, 0.03000468f, -0.04751180f, -0.03735216f, 0.10139776f, 0.10643835f, 
    0.00319158f, -0.06564269f, 0.02390690f, -0.02344533f, 0.11259495f, -0.01095397f, 0.02617863f, 0.04226639f, 
    0.00929166f, 0.00451674f, 0.02475365f, 0.04252795f, 0.01598933f, 0.05460542f, 0.10864517f, 0.02519968f, 
    0.01753442f, 0.05669923f, -0.03307472f, 0.01838788f, -0.50082278f, 0.42617208f, 0.05658364f, 0.18079168f, 
    0.00043937f, -0.10298374f, 0.04797305f, 0.06626817f, -0.19486931f, 0.26647592f, 0.00476115f, 0.01011814f, 
    0.13663311f, -0.11673082f, 0.14612010f, -0.10233311f, 0.09356853f, 0.04126153f, 0.04201705f, -0.17616360f, 
    -0.46236157f, -0.33734262f, 0.12265347f, -0.22568919f, -0.01400027f, -0.06506366f, -0.01431382f, -0.00741583f, 
    -0.06897790f, 0.08786872f, -0.02060198f, -0.00183776f, -0.06531222f, 0.03425432f, -0.00484757f, 0.06691581f, 
    -0.16507439f, -0.13806091f, 0.01216152f, -0.11658178f, 0.47516480f, 0.05526805f, -0.05468251f, 0.13000220f, 
    0.36727536f, -0.01447843f, 0.09130142f, -0.10781052f, 0.03649797f, 0.04974934f, 0.03325456f, -0.01625930f, 
    -0.01427413f, 0.04014702f, -0.05748342f, -0.00190862f, 0.01833837f, 0.03481816f, -0.15856960f, 0.07607011f, 
    -0.10825554f, -0.19889051f, -0.04506322f, -0.06273514f, -0.10851251f, 0.03786779f, 0.01775810f, 0.01205330f, 
    -0.05161789f, 0.06107564f, 0.07432452f, 0.02568856f, -0.00517970f, 0.01786862f, -0.08073306f, -0.08163248f, 
    -0.04561997f, 0.15609552f, -0.03031106f, -0.07312433f, 0.04371496f, -0.04134835f, 0.11785837f, -0.14096946f, 
    -0.04512540f, 0.05612458f, -0.03463516f, -0.24754205f, -0.19829728f, -0.01156045f, 0.03161744f, -0.03996490f, 
    0.04625185f, 0.04580004f, -0.09071280f, 0.01342313f, -0.04434825f, -0.08274088f, 0.06881329f, 0.07962801f, 
    -0.11563192f, 0.07396214f, 0.09636406f, 0.13126403f, -0.14428858f, 0.04321454f, 0.13894573f, 0.00996626f, 
    0.01670634f, 0.10509722f, 0.02474036f, 0.00129349f, 0.02498765f, -0.01608399f, -0.00799771f, -0.01220245f, 
    0.03669461f, -0.02922340f, 0.04112760f, 0.09269453f, -0.07831349f, 0.02377564f, -0.14642267f, -0.11555871f, 
    0.12368170f, 0.05240808f, 0.02071084f, 0.01860353f, 0.03563083f, 0.01230652f, 0.00995568f, 0.01270805f, 
    -0.01585059f, -0.06859346f, 0.01464283f, -0.01099758f, 0.09817360f, 0.04998848f, 0.01168073f, 0.01165777f, 
    0.02208561f, -0.12596805f, -0.05206988f, -0.02632042f, 0.12186643f, 0.03674262f, -0.01565386f, 0.03305896f, 
    0.01082512f, 0.00997344f, -0.12332624f, 0.00788575f, -0.01733213f, 0.00527166f, -0.01927632f, -0.00552612f, 
    0.01288136f, 0.00549918f, 0.02138703f, 0.00737678f, 0.21996841f, 0.06935192f, -0.07877152f, -0.05371832f, 
    0.15629725f, 0.11331914f, -0.00645004f, -0.06248165f, 0.04843881f, -0.00436293f, -0.00788068f, 0.06046201f, 
    0.11347681f, -0.11005320f, 0.05363024f, 0.05900119f, 0.14707796f, 0.03135392f, 0.07031048f, 0.11708201f, 
    -0.33226082f, -0.46799541f, -0.09023111f, 0.10893709f, -0.31286848f, 0.04316887f, 0.06212338f, -0.00813045f, 
    0.05136899f, 0.03045565f, -0.01447266f, -0.01892655f, 0.01081729f, 0.00160011f, -0.01358855f, -0.04859066f, 
    -0.00146840f, -0.16072699f, -0.03755836f, 0.07241736f, 0.00264328f, -0.15548262f, -0.23839895f, -0.29155353f, 
    0.20947804f, 0.00969221f, 0.00118545f, -0.00089410f, 0.00833905f, 0.01519240f, 0.01200240f, 0.04131130f, 
    0.02602316f, 0.01189817f, -0.06767739f, 0.09263792f, -0.00785924f, 0.01079097f, 0.05237522f, -0.03985383f, 
    -0.05215355f, -0.13803282f, -0.08070246f, 0.11636972f, -0.10254376f, 0.08706392f, 0.03666941f, 0.03075919f, 
    0.03473482f, -0.03296540f, 0.01468319f, -0.01949835f, 0.02769957f, -0.03697788f, 0.01506644f, 0.00202522f, 
    0.02467551f, 0.05407056f, 0.06739124f, 0.11775084f, -0.29763103f, -0.45212272f, -0.27287251f, -0.23889044f, 
    -0.26064226f, 0.18190895f, -0.06751513f, -0.04876506f, -0.01498799f, 0.05288227f, -0.00846966f, 0.02604718f, 
    0.01382411f, 0.00443949f, -0.06742080f, -0.02842062f, 0.00880201f, 0.05729070f, -0.17389204f, 0.02114580f, 
    -0.39893976f, 0.30090374f, 0.45043498f, -0.23054320f, -0.10937086f, 0.03778436f, -0.12362608f, -0.11570945f, 
    0.01557728f, 0.10288320f, 0.01356220f, -0.07376281f, -0.00818912f, -0.03666708f, -0.02918963f, 0.01907077f, 
    0.03869326f, 0.00698325f, 0.15989250f, -0.12555799f, -0.31644055f, -0.74955255f, -0.27669141f, 0.02496360f, 
    -0.34625635f, 0.01308431f, -0.07853076f, 0.03611362f, -0.02922177f, -0.06663235f, 0.01854088f, 0.03166776f, 
    0.03564706f, -0.00766909f, -0.06422675f, -0.00601338f, -0.00549585f, 0.03913868f, -0.08435512f, -0.06306601f, 
    0.07755061f, -0.40637636f, -0.07757955f, 0.09920422f, -0.10049741f, -0.11095115f, -0.01772171f, 0.04674295f, 
    0.02476499f, -0.07655641f, 0.00007710f, -0.00560493f, 0.02679457f, -0.01196058f, -0.01036814f, 0.02043964f, 
    0.01565266f, -0.01617095f, -0.00473292f, -0.03322862f, -0.06948016f, 0.13690248f, -0.20325607f, -0.05282252f, 
    -0.06344663f, 0.00806986f, -0.10239904f, -0.00845581f, -0.01302234f, -0.00930465f, -0.09066117f, -0.03376499f, 
    0.07632146f, -0.00776757f, 0.01090121f, -0.10913665f, -0.02299928f, 0.01119080f, 0.02852142f, 0.00332269f, 
    -0.51022166f, -0.18931857f, 0.18474723f, -0.32007441f, -0.03152751f, 0.03467070f, 0.01810673f, 0.00891600f, 
    0.06257112f, -0.00130568f, 0.02254945f, -0.01657611f, 0.01962899f, 0.02526554f, 0.00025373f, 0.02034797f, 
    0.05325801f, 0.17890112f, -0.00553722f, -0.18643089f, 0.03385042f, 0.09004973f, 0.21604605f, 0.10164726f, 
    0.20948866f, -0.02496557f, -0.01155031f, -0.00279177f, 0.12568240f, -0.05024174f, 0.07148458f, -0.01135862f, 
    0.07381569f, -0.00506083f, 0.05129113f, 0.01705698f, -0.01534449f, 0.00325039f, 0.01453812f, 0.00340896f, 
    -0.03368016f, 0.05173222f, -0.08670243f, 0.24579760f, 0.06363916f, 0.09560648f, 0.02072712f, -0.00963291f, 
    -0.01325929f, -0.04085107f, -0.00865256f, 0.01298814f, -0.03552327f, -0.01378013f, 0.01186191f, 0.10992415f, 
    0.11179113f, -0.00281864f, 0.00168305f, 0.09141616f, 0.12770657f, 0.21714588f, -0.44624707f, 0.05956640f, 
    0.08322186f, 0.08377494f, -0.07236092f, 0.02824054f, -0.03118982f, 0.06711894f, 0.00875122f, 0.04949468f, 
    0.12426480f, 0.00600109f, -0.03844935f, -0.01145691f, 0.00867006f, 0.07902308f, -0.17050228f, 0.11047699f, 
    0.06209879f, -0.11870299f, -0.07651512f, -0.17109531f, 0.03112474f, 0.02709370f, -0.08798121f, 0.03899106f, 
    0.04327993f, 0.08447587f, 0.08003026f, -0.03384681f, -0.07467882f, 0.08048055f, 0.09746102f, 0.07174974f, 
    -0.08691426f, -0.09193724f, 0.13800004f, 0.06541829f, -0.21441334f, -0.13951150f, 0.60789859f, 0.24963108f, 
    0.09026747f, -0.13321333f, -0.14221123f, -0.13559787f, 0.13688208f, -0.14235742f, 0.05809445f, 0.00379415f, 
    -0.00187280f, -0.04376281f, -0.01335822f, -0.00175183f, 0.00635027f, 0.04724342f, 0.03077117f, -0.07133633f, 
    0.22807439f, 0.30365920f, -0.04307124f, 0.08342826f, 0.19422047f, 0.14218491f, -0.01775155f, -0.01898866f, 
    -0.04316581f, -0.01214084f, -0.13163209f, -0.02422242f, 0.11180926f, 0.00995403f, 0.03052360f, -0.06756677f, 
    -0.00415003f, -0.02116944f, 0.01846555f, 0.01256971f, -0.19935235f, -0.09146515f, -0.24115996f, -0.09058300f, 
    -0.07279304f, 0.27274695f, 0.11736880f, 0.08213913f, 0.05888841f, -0.01552720f, -0.19364946f, -0.04997705f, 
    -0.00691411f, -0.12403250f, -0.04865164f, -0.00661828f, 0.06390198f, -0.09932603f, 0.06768014f, 0.09735558f, 
    -0.27451718f, -0.31963721f, 0.20606242f, 0.03684898f, 0.01910436f, 0.12681219f, 0.03656447f, 0.04982280f, 
    -0.02202676f, 0.02131337f, 0.07242593f, 0.14028953f, -0.07013455f, -0.13081405f, 0.10078248f, 0.02007464f, 
    -0.00800205f, 0.13522723f, -0.04652819f, -0.17977212f, 0.27771881f, 0.03236711f, 0.42590863f, -0.33296570f, 
    0.22089072f, -0.20075886f, 0.05011387f, -0.00135207f, -0.06372403f, -0.05801678f, 0.10693207f, -0.02874416f, 
    0.10176124f, -0.04334104f, -0.04998990f, -0.10567905f, -0.06799627f, -0.03584589f, 0.13177472f, -0.02805692f, 
    -0.20032267f, -0.06162238f, 0.21328990f, -0.02100716f, 0.14408848f, 0.01716390f, 0.01192266f, -0.09238900f, 
    0.05815704f, -0.05293854f, 0.10179632f, -0.04944187f, -0.04742693f, -0.02971512f, 0.02156029f, 0.03910121f, 
    -0.06884535f, -0.00827081f, -0.11564101f, 0.02467692f, 0.05658340f, 0.30309579f, 0.03909286f, -0.16727519f, 
    0.07157197f, 0.09785163f, -0.03109266f, -0.14470129f, -0.12261164f, -0.00074375f, -0.14392573f, -0.01109962f, 
    -0.00621665f, -0.06670813f, 0.12195215f, -0.04281636f, -0.01330836f, 0.04144400f, -0.05840610f, -0.03540529f, 
    -0.06232175f, -0.00104502f, 0.30300039f, -0.41396028f, 0.11561164f, -0.07122063f, -0.04708258f, -0.04091806f, 
    -0.12952249f, -0.00686836f, 0.03903361f, -0.03349648f, 0.06519217f, -0.04972158f, 0.22518229f, 0.07020335f, 
    0.01368505f, -0.06153029f, -0.09180557f, -0.01837854f, 0.00000297f, -0.08317316f, -0.16536400f, -0.03282196f, 
    0.17961939f, 0.04327349f, 0.02228301f, -0.02709272f, 0.00840318f, 0.03538410f, -0.08964027f, 0.03848733f, 
    -0.03570241f, 0.00526897f, -0.03262641f, -0.02948125f, -0.02526182f, 0.06618929f, -0.00085090f, 0.01113864f, 
    0.69460487f, 0.41916320f, -0.13877709f, -0.72726572f, -0.03902844f, 0.04326166f, -0.05701651f, 0.08994440f, 
    0.02915210f, -0.02607494f, -0.08110254f, -0.07742594f, -0.03614030f, -0.02629380f, -0.00311727f, 0.05139675f, 
    -0.01532723f, 0.01628522f, 0.06167565f, 0.00928691f, 0.16108732f, 0.01486349f, -0.30939686f, -0.18084361f, 
    0.20809379f, 0.15607367f, 0.01205777f, -0.00249366f, 0.07366024f, -0.10387970f, 0.05636972f, 0.08448165f, 
    -0.11226073f, -0.03442926f, -0.09288885f, 0.15004633f, -0.02973040f, 0.14545208f, 0.10766169f, 0.12605211f, 
    -0.31136349f, -0.19913900f, -0.03861938f, 0.05227067f, -0.01806037f, 0.06275706f, -0.06837486f, 0.12894559f, 
    0.02107888f, -0.14911383f, -0.00526080f, -0.00323297f, 0.11209907f, 0.02344155f, -0.06870592f, -0.03105221f, 
    0.03390544f, 0.08963621f, -0.13439539f, -0.10710415f, -0.08695720f, 0.29840311f, -0.00561579f, -0.02297091f, 
    0.23280153f, 0.34476897f, 0.13391380f, 0.05776775f, -0.01062874f, 0.01294072f, -0.15145627f, -0.03887784f, 
    0.09072322f, 0.01224170f, 0.04376602f, -0.15477152f, 0.09041258f, -0.14338015f, 0.08662111f, 0.02475153f, 
    -0.69930345f, 0.17548060f, 0.03262199f, -0.02936161f, -0.16838269f, -0.01921587f, -0.07403670f, 0.12764376f, 
    -0.06747133f, -0.03795533f, -0.15963826f, 0.02637032f, -0.21487394f, -0.09655252f, 0.16327217f, -0.10428946f, 
    -0.20580754f, 0.09881097f, -0.12215716f, -0.18095422f, 0.13819453f, 0.04945935f, -0.14915752f, 0.00971369f, 
    -0.02238384f, 0.02359826f, -0.06127521f, -0.00049824f, -0.04619248f, 0.04964849f, -0.08330737f, -0.17462498f, 
    -0.02332627f, -0.22872469f, -0.01932066f, -0.02303539f, -0.01655851f, -0.00608190f, 0.07664723f, -0.02118071f, 
    0.13467349f, 0.36314455f, -0.05570295f, -0.18192902f, 0.11902898f, 0.24513207f, 0.06745866f, 0.02317652f, 
    0.08619515f, 0.04467664f, -0.23391919f, -0.05827453f, 0.04898622f, 0.01905474f, 0.04456003f, -0.10340086f, 
    0.14864603f, -0.05620029f, -0.00816593f, 0.02365516f, -0.12333250f, -0.04991200f, -0.16307996f, 0.10600293f, 
    0.19815354f, -0.00482928f, -0.01223243f, -0.07879764f, -0.01761393f, -0.00160105f, -0.04681214f, 0.00022258f, 
    0.02747761f, -0.04621922f, 0.01600583f, -0.00367776f, -0.03590903f, 0.11439501f, -0.11428332f, -0.00835597f, 
    -0.35574746f, 0.08323891f, -0.18045394f, 0.24995132f, -0.11204792f, -0.06076627f, -0.14464778f, -0.01599375f, 
    -0.08618011f, -0.11523023f, 0.04336166f, -0.02911682f, 0.18379970f, 0.01313457f, -0.17389354f, 0.01711303f, 
    0.00858938f, -0.06905539f, 0.03536937f, -0.07385973f, 0.09678142f, -0.13247678f, -0.05607272f, -0.08264995f, 
    0.15037015f, -0.10295589f, -0.07959991f, -0.04234290f, 0.12545481f, -0.10196589f, 0.07747707f, -0.03071466f, 
    -0.10021610f, -0.03468585f, 0.00220047f, -0.03019320f, 0.00234077f, 0.12625991f, -0.11390622f, 0.02007304f, 
    -0.26266399f, 0.27320769f, -0.20505109f, 0.01676689f, 0.36154711f, 0.22860923f, 0.10887860f, -0.00594754f, 
    -0.00010548f, 0.10042021f, -0.11431189f, 0.06484649f, 0.01703714f, 0.07822954f, 0.19921018f, 0.00448096f, 
    0.05900952f, 0.11253420f, 0.11767351f, 0.01504795f, -0.18012592f, -0.19731733f, 0.44974965f, -0.05154318f, 
    0.31144729f, -0.19681355f, 0.08439352f, 0.02239713f, 0.10249745f, -0.03864499f, 0.12193938f, 0.01831078f, 
    -0.07514502f, 0.06592494f, 0.09754159f, -0.08114325f, 0.01343144f, -0.04375554f, -0.12770602f, 0.02896137f, 
    0.04304840f, 0.02390645f, -0.12165866f, -0.11829203f, 0.19236138f, 0.02348363f, 0.06045702f, 0.01686019f, 
    -0.01741210f, 0.10243256f, 0.05583107f, -0.05561172f, 0.05978343f, 0.02140585f, 0.11470169f, 0.04221760f, 
    0.08760506f, 0.10734860f, 0.07949839f, 0.08782783f, 0.08174791f, -0.24902312f, 0.11571714f, -0.01345652f, 
    0.40444604f, -0.01075498f, 0.09592935f, -0.01113726f, 0.09235632f, 0.03599961f, -0.02485833f, 0.00757756f, 
    -0.03110427f, -0.05221402f, 0.03258847f, 0.13439699f, -0.02296609f, 0.04990450f, 0.10875420f, -0.04305678f, 
    -0.10866748f, -0.18297888f, -0.02212296f, 0.19574484f, -0.30070922f, 0.15472817f, -0.05842709f, 0.04729102f, 
    -0.19877462f, -0.13695662f, -0.18691595f, 0.00600337f, 0.07780631f, 0.04749996f, -0.09574898f, 0.07335666f, 
    0.00903067f, 0.02901563f, -0.07971475f, 0.01379664f, -0.06641000f, -0.08154579f, -0.16876268f, 0.09599733f, 
    0.15875013f, 0.05519696f, -0.10027266f, 0.13281763f, 0.05983711f, 0.06120015f, 0.03933554f, 0.03710375f, 
    0.00314560f, -0.02765439f, -0.10299450f, -0.01482121f, -0.09106856f, 0.07280973f, -0.11606516f, -0.00554436f, 
    0.05383940f, 0.22138299f, 0.07214126f, -0.02000698f, -0.01496188f, 0.20212902f, 0.12610558f, 0.16794989f, 
    0.09366491f, -0.05831796f, -0.07968102f, 0.08925347f, 0.16420205f, -0.01454548f, -0.13347633f, -0.04068441f, 
    0.06092270f, 0.18728191f, 0.13437144f, -0.01954131f, -0.23793446f, -0.26537192f, -0.26721692f, -0.55520004f, 
    -0.42153829f, 0.13674192f, 0.30608678f, 0.13481018f, 0.10073097f, -0.00527801f, 0.01385691f, -0.09121200f, 
    0.18649609f, -0.25140074f, -0.17936000f, -0.01596357f, 0.14175558f, 0.01596585f, 0.02560533f, -0.13160317f, 
    -0.05208614f, -0.08258510f, -0.04342489f, 0.07181553f, 0.26451251f, -0.16448638f, 0.03524761f, 0.04151839f, 
    -0.03081382f, 0.06944257f, -0.02761274f, 0.02497892f, -0.02453317f, 0.05901658f, 0.04990444f, -0.09059872f, 
    -0.10877982f, 0.01931836f, 0.06667089f, 0.04465786f, 0.10845190f, 0.11867433f, -0.19975065f, -0.44128960f, 
    -0.22117221f, -0.07154974f, -0.12551457f, -0.06898288f, -0.13211533f, -0.10434113f, -0.07125410f, -0.04011463f, 
    0.04823576f, -0.02324670f, 0.07879417f, 0.12357134f, -0.04446368f, -0.27590629f, -0.25126469f, -0.12494571f, 
    -0.17392625f, -0.03421729f, -0.12752327f, 0.26543075f, 0.18760242f, 0.02652893f, -0.02357354f, 0.03405887f, 
    -0.04764141f, 0.05100041f, 0.01732275f, 0.06191957f, 0.11211668f, -0.08392516f, -0.04501478f, 0.11411452f, 
    -0.05276569f, 0.08576774f, 0.03652918f, -0.01958741f, -0.34961036f, -0.47403941f, -0.15731470f, -0.14577585f, 
    -0.23925106f, 0.02826565f, -0.10906917f, -0.04678297f, -0.04437714f, -0.14215700f, 0.02978366f, 0.07150822f, 
    0.00805698f, -0.10165752f, 0.02751262f, 0.09425446f, 0.04323133f, 0.02190166f, -0.11724048f, -0.20187090f, 
    0.10638195f, -0.12012316f, -0.16662952f, -0.09490136f, 0.21610355f, 0.07267664f, -0.00342027f, -0.01652549f, 
    0.07467624f, -0.19269535f, 0.00961422f, -0.02647871f, 0.02768511f, -0.00564738f, 0.04750708f, -0.07058699f, 
    -0.01116880f, 0.12819938f, -0.07802883f, 0.05849217f, -0.15017264f, -0.13047133f, -0.12854454f, -0.12355447f, 
    0.26013702f, 0.13634862f, 0.02963261f, -0.02778520f, 0.03445686f, 0.01697377f, -0.05043870f, 0.05794875f, 
    -0.00494030f, 0.03027396f, -0.03755476f, 0.06112503f, 0.03656496f, -0.02874161f, 0.08792859f, 0.06110141f, 
    -0.36710370f, 0.62600255f, -0.21523789f, 0.01820312f, 0.07882799f, 0.17119756f, 0.07481248f, 0.06978244f, 
    0.01927811f, 0.17169116f, -0.08985940f, -0.10241344f, -0.02815781f, -0.09761667f, 0.03903944f, -0.00494552f, 
    -0.03468652f, -0.03122508f, -0.05107105f, -0.06711419f, -0.27357668f, -0.01832641f, -0.24267541f, -0.10608163f, 
    -0.30756786f, 0.08551273f, -0.06597328f, 0.12494294f, 0.03489357f, -0.02930608f, -0.00249461f, -0.08510108f, 
    -0.13110380f, -0.04214825f, 0.00597834f, -0.10669768f, -0.08351748f, -0.20152487f, -0.22036578f, -0.15656701f, 
    -0.20631951f, 0.03428620f, -0.11685225f, 0.21561152f, 0.17709182f, 0.04909243f, -0.02515936f, 0.12979025f, 
    0.02176892f, -0.02620550f, 0.01501699f, 0.07357346f, -0.00526819f, -0.06698788f, -0.04381963f, -0.06155054f, 
    0.00870720f, -0.01523490f, 0.08735864f, -0.18474512f, 0.05625320f, 0.13343666f, -0.23616968f, -0.23433216f, 
    -0.21617119f, -0.01656645f, -0.12094887f, 0.05614817f, -0.13744901f, -0.03866968f, -0.04003440f, -0.09846299f, 
    0.05210137f, -0.04740392f, -0.12159967f, -0.08598287f, -0.05384483f, -0.02792210f, 0.00263520f, -0.01986725f, 
    0.31893629f, -0.14151908f, -0.11730740f, -0.00152934f, 0.10657540f, 0.11847245f, -0.05334178f, 0.05597747f, 
    -0.18255237f, -0.15101898f, -0.20436718f, -0.05382808f, 0.04109509f, 0.03992906f, -0.03230740f, -0.07112988f, 
    0.06926941f, -0.06069364f, -0.05688413f, 0.05156212f, -0.05112127f, -0.02495888f, -0.13406657f, -0.07293659f, 
    0.22176053f, 0.06675989f, -0.01471040f, -0.10002251f, -0.06859332f, -0.11319051f, 0.00764176f, 0.04494073f, 
    0.07173904f, 0.12064924f, 0.08646045f, -0.03684011f, 0.03364994f, 0.09679489f, -0.01056757f, -0.02462004f, 
    -0.24870738f, -0.14693040f, 0.49068660f, -0.21508645f, 0.15554999f, -0.19084537f, -0.11278482f, -0.11116484f, 
    0.01474746f, -0.17137517f, 0.07774024f, -0.01836796f, 0.00786082f, -0.03591909f, -0.01166066f, 0.00564926f, 
    -0.08530271f, 0.09190480f, -0.07010021f, -0.02065275f, -0.09112169f, -0.19982286f, 0.02298918f, 0.07938778f, 
    0.31139979f, -0.05013476f, 0.14217536f, -0.00356915f, 0.09055244f, -0.01485655f, 0.04724096f, -0.02482587f, 
    0.01566757f, -0.09602101f, 0.03005915f, -0.06705309f, 0.00962447f, -0.04438768f, 0.00295550f, -0.00322384f, 
    -0.20707002f, -0.07930131f, -0.01287190f, -0.18116605f, -0.18871616f, 0.10560835f, 0.03078847f, -0.03556857f, 
    -0.00568391f, -0.09807141f, -0.03186763f, 0.02920374f, -0.06098113f, 0.03691313f, -0.07982256f, -0.09196377f, 
    0.00851471f, -0.02799905f, -0.15068109f, -0.03621260f, 0.25118774f, -0.15892075f, -0.05641950f, 0.31686696f, 
    0.17576365f, -0.12234225f, -0.15665302f, -0.05762079f, -0.07180682f, -0.25879860f, -0.05008299f, 0.01933224f, 
    0.02326479f, -0.10039111f, -0.01465920f, -0.00200041f, -0.00914384f, 0.15128525f, -0.08830735f, 0.02454067f, 
    -0.30765459f, 0.01650743f, 0.43315640f, 0.29651088f, 0.44472322f, -0.10778181f, -0.11235513f, -0.04184904f, 
    0.07205190f, -0.02822950f, 0.06140487f, 0.10470471f, 0.03297418f, -0.06520600f, 0.08884092f, -0.10418564f, 
    0.03855596f, 0.03480890f, 0.12534460f, -0.11445273f, -0.19214721f, 0.58455610f, -0.07860117f, -0.30736667f, 
    0.14576061f, 0.17736429f, 0.12159528f, -0.13315114f, 0.05843940f, -0.26140314f, -0.09632602f, 0.04558930f, 
    -0.07652038f, -0.02312003f, 0.05653723f, 0.09517464f, 0.05497995f, -0.07426666f, -0.00966996f, -0.04533854f, 
    -0.12818387f, -0.21888155f, 0.09598906f, -0.33049709f, -0.29474244f, -0.08642519f, -0.09562967f, -0.16590156f, 
    0.02849755f, -0.09572168f, 0.10817681f, -0.00573533f, -0.00724651f, -0.05527585f, -0.03181990f, -0.04101306f, 
    -0.04622600f, 0.01376711f, -0.11700166f, -0.09416642f, 0.10980640f, -0.00393900f, 0.23662327f, -0.26365021f, 
    0.23060785f, -0.03828702f, 0.13716653f, -0.04961190f, 0.06378985f, 0.02559281f, 0.04378424f, -0.01481148f, 
    -0.04860912f, -0.06959745f, 0.04575380f, -0.07915235f, -0.11573898f, -0.03283894f, 0.01200098f, -0.01994602f, 
    -0.04026687f, -0.05142529f, -0.08668529f, 0.16610140f, 0.17665452f, -0.08224718f, -0.09102619f, 0.01586140f, 
    -0.04038070f, -0.01216112f, 0.01134977f, 0.01787164f, -0.02409109f, -0.07353669f, -0.03674643f, -0.14450382f, 
    -0.03090893f, -0.03875518f, 0.04785139f, -0.04434461f, 0.04771473f, 0.22034431f, 0.18098998f, -0.15421718f, 
    -0.28627214f, -0.01816459f, 0.07983974f, 0.03248488f, -0.01402371f, 0.11130878f, 0.00250592f, -0.05321500f, 
    0.02338171f, -0.13084356f, -0.05004403f, -0.02718701f, -0.07990098f, -0.04749344f, -0.03648836f, -0.02593010f, 
    0.20964637f, 0.24502641f, -0.04400425f, -0.10074782f, -0.28190485f, 0.18337832f, 0.04266543f, -0.01518453f, 
    -0.02236138f, -0.02248017f, -0.10038727f, -0.12839800f, 0.11829533f, -0.12008125f, -0.03859199f, -0.06761438f, 
    0.01646385f, -0.18054543f, 0.00892759f, 0.01949485f, 0.48310074f, 0.62152731f, 0.26918575f, -0.32616210f, 
    0.02701183f, -0.04230707f, 0.11664114f, -0.05908678f, -0.15825953f, 0.15339176f, -0.20959193f, 0.02798705f, 
    0.02165612f, 0.03206321f, 0.13576135f, -0.15971947f, -0.08434973f, -0.01913640f, 0.00688089f, 0.06013362f, 
    -0.08962206f, -0.06130950f, -0.19392304f, 0.00982795f, 0.15008828f, -0.08669909f, 0.06174291f, 0.05548612f, 
    0.04845012f, 0.04228325f, -0.08847496f, 0.03200884f, 0.04108214f, -0.09182376f, -0.03522628f, 0.06824168f, 
    0.08372341f, 0.11087400f, -0.00144698f, -0.07083197f, 0.48354375f, 0.01050089f, -0.10329624f, -0.00078843f, 
    -0.47728831f, 0.13412571f, 0.07416517f, 0.13160849f, 0.04540848f, 0.18751554f, -0.04419748f, -0.13785656f, 
    0.15711433f, 0.03457903f, 0.01445947f, -0.00944887f, -0.02855997f, -0.18234825f, 0.04099052f, 0.07600039f, 
    0.14964314f, -0.06506994f, -0.11990984f, -0.04585956f, 0.14709264f, 0.00001613f, 0.08945675f, 0.01650560f, 
    0.00706599f, 0.03836686f, -0.01114052f, -0.03993382f, -0.02450173f, -0.06601261f, -0.02857144f, 0.02800295f, 
    -0.01402203f, 0.01509723f, 0.07575300f, -0.08795507f, 0.15204567f, -0.12293375f, 0.01084034f, -0.09650329f, 
    0.19411351f, 0.03433591f, 0.13851544f, -0.01463584f, 0.07117736f, 0.07450881f, 0.02823795f, -0.07630316f, 
    0.00560657f, -0.02251337f, -0.06958771f, -0.04488217f, -0.09932280f, 0.05965690f, -0.08446288f, -0.00683724f, 
    -0.41306704f, 0.68699372f, -0.33608216f, 0.27081412f, 0.27487218f, 0.09940127f, -0.07029495f, 0.11800823f, 
    -0.06317516f, 0.04757343f, -0.04150562f, -0.00456524f, 0.05553928f, -0.07533324f, 0.01702552f, 0.09436283f, 
    -0.02227315f, -0.03781369f, 0.00132500f, -0.07511534f, -0.04497020f, -0.04195648f, -0.24300799f, 0.01900026f, 
    0.13827884f, 0.18363886f, -0.04293016f, 0.08296216f, 0.06227105f, 0.08021463f, 0.03806342f, 0.00304426f, 
    -0.02750163f, -0.14194839f, -0.12324473f, 0.11535319f, -0.05125397f, 0.15138753f, -0.03003156f, -0.02209477f, 
    -0.17635688f, 0.04547257f, -0.13191177f, -0.07817588f, 0.32308400f, 0.14577681f, 0.02303338f, -0.02867655f, 
    0.04526727f, 0.08116430f, -0.02506312f, 0.10562001f, 0.00162666f, 0.06364424f, 0.05373771f, 0.09841584f, 
    -0.02965177f, 0.09779146f, -0.03332303f, 0.14767933f, -0.80424559f, -0.12714250f, 0.15909295f, -0.34509018f, 
    -0.13380767f, -0.00174906f, 0.06498739f, -0.18039615f, -0.14505365f, -0.12288658f, -0.07333177f, 0.04671154f, 
    0.10456776f, -0.03393833f, 0.12369359f, 0.20517418f, 0.14816865f, 0.17697680f, -0.17806442f, -0.36488315f, 
    -0.27453965f, -0.40576097f, 0.31114906f, -0.03506350f, 0.01694623f, -0.20220914f, -0.08585890f, 0.01460018f, 
    0.10586845f, 0.06172660f, 0.09524313f, 0.05275840f, 0.09511522f, -0.03702221f, 0.09658182f, -0.03957494f, 
    0.06327341f, 0.00190268f, 0.05824354f, -0.04950995f, -0.10293757f, -0.04947011f, -0.02242477f, -0.08092888f, 
    0.23529942f, 0.09582369f, -0.04395009f, -0.02385956f, -0.08380228f, -0.01378282f, -0.06235223f, 0.04816426f, 
    0.05838286f, -0.04728826f, -0.03329520f, -0.01929951f, -0.00952109f, -0.01972769f, 0.10836200f, 0.05727518f, 
    0.34459582f, 0.30826145f, 0.08313880f, -0.19903491f, -0.05507007f, 0.00776816f, 0.09676038f, 0.01593404f, 
    -0.11387934f, 0.14424630f, -0.09179123f, -0.11390609f, 0.09788097f, -0.12807931f, 0.02968073f, -0.03365690f, 
    -0.00984653f, -0.02555010f, 0.07116184f, 0.08491868f, 0.14809282f, -0.04457684f, -0.09847290f, -0.28444707f, 
    -0.04963978f, 0.01820839f, 0.05369966f, -0.10042659f, 0.06448222f, -0.18645822f, -0.00730623f, 0.05872803f, 
    -0.09939367f, -0.08449410f, -0.03943534f, 0.03832006f, 0.00654763f, 0.10953487f, -0.14430270f, -0.20009902f, 
    -0.08218850f, 0.13151240f, -0.22178935f, 0.05891938f, -0.30952659f, -0.03354063f, -0.19040185f, -0.02060349f, 
    -0.11758955f, 0.01109485f, -0.08272762f, -0.11703846f, 0.03563024f, 0.01645411f, -0.07948763f, -0.02425734f, 
    0.06141186f, -0.13329093f, 0.11286458f, -0.09144019f, -0.20138997f, 0.27957210f, -0.15471055f, 0.03704200f, 
    0.28504494f, 0.13387446f, 0.04454293f, 0.07446492f, 0.02872309f, 0.12274075f, -0.20430183f, 0.07771076f, 
    0.07531969f, 0.09728359f, 0.17470080f, -0.00500446f, 0.01356189f, 0.05218092f, 0.07757994f, 0.07741931f, 
    -0.24979123f, -0.07230720f, 0.21057926f, -0.00230970f, 0.05348791f, -0.21502560f, -0.02807089f, -0.04730175f, 
    0.02750676f, 0.13954142f, 0.01507494f, 0.02376638f, -0.00261439f, -0.01067026f, -0.02546347f, 0.03257611f, 
    0.02804705f, 0.13035153f, -0.01705026f, 0.02170165f, 0.03297418f, 0.02519733f, -0.01133355f, -0.00891423f, 
    0.00415687f, 0.04123902f, 0.00683161f, 0.01366488f, -0.00692315f, 0.08296432f, -0.06127376f, -0.00644233f, 
    -0.01803330f, -0.14572321f, -0.08124552f, 0.07113090f, 0.05548785f, 0.03011072f, 0.01080424f, 0.00236273f, 
    0.03740642f, 0.06113686f, -0.01458352f, 0.02776191f, 0.06613214f, 0.10424329f, 0.06030483f, 0.11603595f, 
    -0.05082449f, 0.05824537f, 0.00969979f, 0.03335031f, 0.03627574f, -0.08847006f, 0.04772187f, 0.07716560f, 
    -0.04327271f, -0.02325914f, -0.05037583f, -0.01093275f, 0.31538805f, 0.01233788f, -0.36606699f, 0.41704324f, 
    -0.14857161f, 0.02119497f, 0.04955641f, 0.04148154f, 0.07722893f, 0.01094554f, 0.09682553f, -0.06964537f, 
    -0.05204372f, 0.02075527f, 0.03507098f, 0.03096296f, 0.06990881f, 0.01538948f, -0.16228682f, 0.07413723f, 
    -0.01236719f, 0.00147886f, -0.00846676f, 0.03741279f, 0.10731155f, 0.03278201f, 0.05992721f, 0.16901563f, 
    -0.02927808f, 0.03722283f, 0.03369939f, -0.00745145f, 0.12575139f, -0.06044312f, 0.02227639f, -0.05914609f, 
    -0.03233282f, -0.06364785f, -0.03553703f, -0.08487175f, -0.14798990f, -0.20187166f, -0.04088918f, 0.18116505f, 
    -0.10101544f, -0.08509039f, -0.10485134f, 0.14547569f, -0.35005707f, -0.09925096f, -0.04761899f, -0.01364500f, 
    0.00670653f, 0.04520610f, 0.00175598f, -0.07129981f, -0.01516312f, 0.00456814f, -0.11062407f, -0.01903656f, 
    0.00640908f, 0.06812890f, -0.03173615f, 0.07105228f, 0.04760985f, 0.07579871f, 0.06150943f, -0.04167869f, 
    -0.00068573f, 0.04484579f, 0.09252162f, -0.00665069f, 0.02304668f, -0.05158735f, 0.05171205f, -0.02987968f, 
    -0.10078099f, -0.03009680f, -0.03738075f, -0.05374184f, -0.09605945f, -0.05224123f, 0.10754278f, 0.09756842f, 
    0.03274544f, -0.09476659f, 0.07403363f, -0.02528816f, 0.01798861f, -0.02098068f, -0.00024929f, -0.01080785f, 
    0.02606392f, 0.08097848f, 0.03708660f, 0.05607725f, 0.13335575f, -0.00792534f, 0.09097958f, 0.10757849f, 
    0.07246817f, -0.44788691f, -0.15208660f, 0.18198369f, -0.10540962f, 0.01950279f, -0.07649463f, -0.05341242f, 
    -0.03115687f, -0.01537455f, 0.10299896f, -0.19091602f, 0.02597821f, 0.12841752f, 0.01842735f, -0.06989422f, 
    -0.02705433f, -0.08973116f, -0.08238740f, 0.03885689f, 0.03733024f, 0.15432560f, 0.10695343f, 0.24082601f, 
    -0.06788816f, -0.07311770f, -0.10451639f, -0.06345987f, -0.06635859f, 0.01625494f, 0.03496633f, 0.05882591f, 
    -0.00372285f, 0.02429298f, 0.05732000f, 0.06544563f, -0.03124478f, -0.02264704f, -0.07601002f, -0.03061255f, 
    0.13437045f, 0.02405920f, -0.03436506f, -0.07713987f, -0.05340712f, 0.05727809f, -0.01055648f, 0.03114439f, 
    -0.00726287f, 0.02012085f, 0.06511045f, -0.19934349f, -0.02189260f, 0.04624522f, -0.01841942f, 0.09503659f, 
    0.05368381f, -0.04856818f, -0.12020148f, -0.03865743f, 0.21047817f, -0.11904357f, 0.20140302f, 0.04498319f, 
    0.00039953f, -0.11561935f, -0.04882286f, 0.01003534f, 0.07196784f, 0.12928645f, 0.16482079f, -0.00581141f, 
    -0.09141369f, -0.09776887f, 0.06587331f, 0.06151197f, 0.02550886f, 0.04311996f, -0.01662397f, 0.00785560f, 
    0.12169791f, -0.16496962f, -0.03405181f, -0.25353989f, 0.07321853f, 0.02160367f, -0.02640560f, 0.14616711f, 
    0.02208832f, -0.02496772f, 0.08245651f, -0.02920952f, -0.10922731f, 0.07866637f, -0.09851812f, 0.03984082f, 
    -0.30994415f, -0.00129148f, -0.05176963f, -0.10863441f, 0.01723916f, -0.01209322f, -0.09902269f, 0.20852132f, 
    -0.11881394f, 0.12401813f, -0.08651920f, -0.04570691f, 0.02491593f, 0.04987376f, -0.11841296f, -0.01371448f, 
    0.06325024f, -0.03525540f, 0.02761440f, -0.12976684f, -0.06167664f, 0.08027133f, -0.29590201f, -0.08647022f, 
    -0.31626561f, -0.19715028f, 0.10978092f, -0.11442111f, -0.03768764f, -0.03186177f, 0.04864803f, -0.00801400f, 
    0.02053088f, 0.13063465f, 0.01496843f, 0.03330507f, -0.10694099f, -0.09233730f, -0.08422320f, 0.01066289f, 
    0.01697400f, -0.02529620f, 0.07954372f, 0.09348191f, 0.11991027f, 0.03776097f, 0.30197805f, 0.13237891f, 
    0.11509968f, -0.18077554f, 0.02051698f, 0.00240570f, 0.00278840f, 0.01758694f, 0.05195726f, -0.00409731f, 
    0.01385251f, 0.07389101f, 0.00340429f, 0.02146554f, -0.00273863f, -0.14748809f, 0.03698882f, -0.12314865f, 
    0.09109380f, -0.08233604f, 0.00171076f, -0.12337773f, -0.02876464f, 0.03909238f, -0.01483772f, 0.12993585f, 
    -0.08459992f, -0.01740592f, 0.05331275f, -0.04700914f, -0.03519410f, -0.01183873f, -0.07994595f, 0.12518294f, 
    0.05866024f, -0.09896769f, -0.12086588f, -0.04588682f, -0.24612232f, -0.04391857f, -0.05315824f, -0.08191168f, 
    -0.10745613f, -0.09317690f, -0.02601098f, 0.00663212f, -0.01601337f, -0.04178125f, -0.03720978f, -0.00499991f, 
    0.03315457f, -0.00268930f, 0.05979550f, 0.03709640f, 0.10949845f, -0.02160995f, -0.04174583f, 0.14098129f, 
    -0.00458637f, -0.15796429f, 0.14246142f, 0.16013639f, 0.12511612f, -0.23364320f, 0.09037948f, 0.00159461f, 
    -0.10723648f, -0.05378911f, -0.00259264f, 0.03901243f, 0.05762925f, -0.01666368f, -0.01075017f, -0.05281730f, 
    0.05025318f, -0.02420675f, -0.01061892f, -0.05740566f, 0.01520818f, -0.04371398f, -0.06630717f, 0.20230301f, 
    0.17037329f, 0.04039029f, 0.03599305f, 0.06434713f, -0.05267413f, 0.10622638f, 0.02984627f, 0.03423435f, 
    0.00451097f, 0.02288925f, 0.06235614f, -0.03376799f, -0.04224204f, -0.04353379f, 0.03905236f, -0.01021523f, 
    -0.16494261f, -0.02717586f, 0.06177239f, 0.17300346f, 0.02637578f, -0.07085500f, -0.12545054f, -0.01190071f, 
    -0.20805928f, -0.03670903f, -0.04812991f, 0.04995337f, -0.04347081f, 0.03513802f, -0.11489003f, 0.09439088f, 
    0.12685694f, 0.05676099f, -0.12693256f, 0.17447345f, 0.11740886f, 0.16669735f, -0.06717758f, 0.23234276f, 
    0.04550553f, 0.16230685f, 0.09116933f, 0.04866434f, 0.19228309f, 0.13055830f, 0.01221422f, -0.00268505f, 
    0.03629838f, -0.01526938f, -0.01944296f, 0.08842426f, 0.09184449f, 0.17502393f, 0.02989202f, 0.32365471f, 
    0.13909589f, 0.04705836f, -0.10636325f, -0.02666683f, -0.08045164f, 0.03005029f, -0.02184976f, 0.06382851f, 
    0.09474479f, -0.01779448f, 0.03326778f, -0.14806142f, 0.02300000f, -0.23193267f, 0.19552147f, 0.05889416f, 
    -0.09089553f, -0.00757752f, -0.15072419f, 0.02045857f, 0.17685623f, 0.05329496f, 0.29301155f, 0.03105983f, 
    0.14263700f, -0.01178954f, -0.01491291f, 0.09729816f, 0.07819277f, 0.15461069f, -0.01327867f, -0.00573457f, 
    0.00391509f, 0.05418805f, -0.01457351f, 0.05954796f, -0.04041331f, -0.04190117f, -0.15297556f, -0.22101714f, 
    -0.10379554f, -0.14135703f, 0.05985554f, 0.06080169f, -0.31630573f, -0.04588892f, 0.04392552f, -0.00477433f, 
    0.00184989f, 0.06509600f, 0.16297404f, -0.02132568f, -0.28232178f, -0.14018799f, 0.02149014f, 0.08059064f, 
    0.07871979f, -0.01405038f, -0.13564356f, -0.01584680f, 0.11087298f, 0.04785077f, 0.08598695f, -0.01188975f, 
    -0.03846664f, 0.07174657f, 0.03962508f, 0.03217025f, -0.00015407f, 0.05656457f, -0.04582858f, -0.07514766f, 
    -0.17841528f, -0.00757791f, -0.12024622f, 0.08801869f, 0.03633067f, 0.01591554f, -0.04133338f, 0.05056136f, 
    0.02639608f, 0.05264943f, 0.09149779f, -0.02753540f, -0.22899294f, 0.19860715f, -0.10459824f, -0.09051991f, 
    0.07012478f, 0.00178442f, -0.04063402f, -0.03803067f, -0.08532253f, -0.06661279f, -0.17302886f, 0.00858481f, 
    0.07531384f, -0.10524236f, 0.01403006f, 0.11093185f, -0.12608014f, -0.04295100f, -0.08772192f, -0.13690625f, 
    -0.11713602f, 0.03865948f, -0.11216956f, -0.07261942f, 0.17670871f, 0.05854360f, -0.01018031f, -0.14583063f, 
    0.01129746f, -0.13357046f, 0.07758788f, -0.28904933f, -0.44042939f, 0.02356745f, 0.03416318f, -0.22746965f, 
    0.15368655f, -0.01904402f, 0.16220528f, 0.00397477f, 0.02009626f, -0.00838550f, 0.02579927f, -0.00658656f, 
    -0.11896329f, 0.00910831f, 0.02202870f, -0.18404384f, 0.07551569f, -0.02075162f, -0.01654074f, -0.00793559f, 
    -0.04990560f, -0.03063115f, -0.03810891f, -0.02178260f, 0.02658619f, 0.02827426f, -0.01775212f, 0.00364407f, 
    0.00809625f, 0.05414780f, 0.06595743f, 0.03539601f, 0.00337218f, 0.02559457f, 0.06049839f, 0.02684938f, 
    -0.02235951f, -0.05109837f, 0.09940765f, 0.09889828f, -0.00761048f, -0.06787587f, -0.02239553f, 0.02830290f, 
    -0.01854850f, 0.01245403f, 0.16121615f, 0.20018557f, 0.10383181f, -0.15468225f, -0.08529697f, -0.08622030f, 
    -0.04689693f, 0.11880186f, 0.04393563f, 0.02485192f, 0.04160054f, 0.05688452f, 0.03893354f, 0.00731141f, 
    0.01361847f, -0.05476798f, 0.10597153f, 0.00050147f, 0.08336455f, 0.09136583f, 0.06785994f, 0.15389515f, 
    0.00989375f, 0.00427139f, -0.03476786f, -0.05372750f, -0.06700025f, 0.01050168f, 0.09072917f, -0.02851633f, 
    -0.01595671f, 0.05399058f, 0.02133800f, 0.03263754f, -0.02750207f, 0.00614718f, -0.08860742f, -0.02958990f, 
    -0.16409540f, -0.28606740f, -0.00755480f, -0.28924602f, -0.13108568f, 0.01588376f, 0.07274026f, -0.04155073f, 
    0.00785846f, 0.01195844f, -0.03498485f, 0.02440129f, -0.01220791f, 0.11110877f, -0.04285758f, -0.12700893f, 
    -0.03459682f, -0.00762515f, -0.03766499f, 0.01317014f, 0.04651007f, -0.00600424f, -0.11858393f, -0.05233588f, 
    -0.03903146f, 0.06162009f, -0.02960285f, 0.00761149f, 0.05112968f, 0.02136829f, 0.00589470f, 0.00229926f, 
    -0.05896869f, -0.03963017f, -0.03374717f, -0.02693695f, -0.11019821f, 0.08273993f, 0.05486429f, -0.09853137f, 
    0.16777319f, -0.10652070f, 0.22665769f, -0.17862916f, 0.07300371f, -0.01978345f, -0.09291396f, 0.09477522f, 
    -0.11288209f, 0.05341403f, 0.01282584f, -0.04405271f, 0.04154440f, -0.05356853f, -0.07308775f, -0.03265851f, 
    -0.04189695f, -0.07582539f, -0.09462108f, -0.14592771f, -0.02264035f, -0.10103551f, -0.05974113f, -0.02034602f, 
    -0.08866144f, 0.05004482f, -0.06891640f, 0.02734190f, -0.03862877f, 0.00559327f, -0.00588793f, -0.08443183f, 
    0.03558935f, 0.02430562f, 0.04588440f, 0.02259315f, 0.04024242f, 0.00564067f, -0.07717934f, 0.06828953f, 
    -0.05557077f, 0.06313776f, 0.03930281f, -0.05806072f, 0.01499051f, -0.11222613f, -0.00334514f, -0.00892501f, 
    0.07597841f, 0.15785915f, 0.02301986f, -0.00740424f, -0.07321616f, -0.13032742f, 0.00060687f, 0.06872214f, 
    -0.03143269f, 0.00721189f, -0.00086178f, 0.01998216f, 0.00372677f, -0.06677815f, 0.06701479f, 0.14265940f, 
    0.02687436f, -0.12249003f, -0.04791934f, 0.02143925f, -0.09684175f, -0.10034485f, -0.00921820f, 0.01719888f, 
    -0.05686622f, 0.06191094f, -0.02420573f, -0.00571006f, 0.00294434f, -0.01496196f, 0.03718971f, 0.03066376f, 
    0.11890625f, 0.00121427f, -0.27416435f, 0.18417364f, 0.21804927f, 0.01871611f, -0.00125236f, 0.05930384f, 
    -0.00399902f, -0.02352225f, 0.02730650f, -0.00775422f, 0.03020237f, -0.05380514f, 0.04784824f, -0.02861357f, 
    0.01119778f, 0.04389967f, -0.04156692f, -0.04296323f, 0.02735635f, 0.13068816f, 0.04590777f, 0.06619977f, 
    -0.00858256f, 0.15754296f, 0.01933781f, 0.05028640f, 0.10315694f, 0.09540188f, 0.02787965f, -0.02836367f, 
    -0.00718792f, 0.04406074f, -0.03816703f, 0.01235347f, 0.11188610f, -0.13232364f, 0.04004659f, 0.14463088f, 
    0.05714077f, -0.01854598f, -0.06083722f, -0.09556353f, -0.03484557f, -0.01414986f, -0.05861707f, 0.02404246f, 
    0.04065998f, 0.03821924f, -0.07799768f, -0.04916915f, -0.04400023f, -0.09875133f, -0.10679460f, 0.05753532f, 
    -0.00865662f, -0.04146411f, 0.02211419f, 0.04702840f, -0.62877125f, -0.30028418f, 0.05855254f, -0.32548049f, 
    0.07061877f, -0.06529073f, -0.09848077f, -0.07098943f, -0.01684001f, -0.16995898f, -0.11355387f, -0.13174215f, 
    -0.01618993f, -0.14776121f, -0.18650375f, -0.02537989f, -0.06627502f, -0.04951260f, -0.13515709f, 0.05173101f, 
    -0.08957494f, -0.04040403f, -0.13498141f, -0.14153291f, 0.23443393f, -0.09293657f, 0.03769512f, -0.04625685f, 
    -0.05500775f, -0.13186429f, 0.08678620f, 0.01046445f, 0.00018894f, -0.09949858f, 0.02077505f, -0.03349020f, 
    -0.13638471f, 0.09190210f, -0.05866970f, -0.03985886f, -0.03749454f, -0.33465439f, -0.05686626f, 0.17424513f, 
    -0.02386780f, -0.25223833f, -0.15517607f, 0.10997453f, -0.15929033f, 0.00320009f, -0.19940801f, 0.01309725f, 
    -0.01583208f, -0.02418086f, -0.15111817f, -0.02701156f, -0.08102207f, -0.00048815f, 0.10501873f, 0.08317743f, 
    -0.08062345f, -0.02868707f, -0.15342602f, -0.02077191f, 0.07561149f, -0.00592970f, 0.04897551f, 0.02881053f, 
    0.09837699f, -0.01987307f, 0.09305529f, -0.02875492f, 0.03327389f, 0.01209223f, 0.03363119f, -0.06868420f, 
    -0.01674662f, -0.07929777f, -0.05427153f, 0.16293669f, 0.04983045f, 0.10524154f, -0.10676835f, 0.16841805f, 
    0.04095340f, 0.01055538f, 0.02371329f, 0.04395316f, -0.04298457f, 0.07889834f, 0.07866471f, -0.01772656f, 
    0.02337963f, 0.00132541f, 0.00210648f, -0.01287213f, 0.04348759f, -0.11113154f, -0.10373236f, -0.21977268f, 
    0.05484495f, 0.05495666f, 0.14957196f, 0.04656569f, 0.07784452f, -0.03370485f, 0.05586965f, 0.02745304f, 
    0.05975445f, 0.02888939f, -0.03412238f, -0.02132990f, -0.02277001f, 0.02960756f, -0.05125972f, -0.00466497f, 
    -0.01618720f, -0.04014204f, -0.00175920f, 0.08331402f, 0.19112539f, -0.22888057f, -0.09294304f, -0.07756448f, 
    -0.36145356f, 0.08528323f, -0.01644842f, 0.04577655f, 0.02474413f, 0.03580406f, 0.02050834f, 0.02974952f, 
    0.01008862f, 0.02796234f, -0.04239522f, -0.08038438f, 0.04884973f, -0.01755562f, -0.01623179f, 0.13930473f, 
    0.06889287f, 0.02165307f, 0.02198222f, -0.06171728f, -0.02826413f, -0.01906427f, -0.00682705f, 0.04511676f, 
    0.03425222f, 0.03317087f, -0.04077357f, 0.00296158f, 0.01256748f, -0.05900525f, -0.05882214f, 0.03907942f, 
    -0.00506804f, 0.02367450f, -0.02456776f, -0.01871500f, 0.32662210f, -0.87475359f, -0.29574317f, 0.04838856f, 
    -0.51353955f, 0.09811325f, 0.00050188f, 0.07125303f, -0.07662641f, 0.00766941f, 0.06856378f, -0.01481434f, 
    -0.08122793f, 0.02678527f, -0.01336852f, -0.08457481f, -0.02718861f, 0.01608972f, -0.12138143f, -0.04446616f, 
    -0.11782259f, 0.02109247f, 0.07185388f, 0.07317864f, 0.13407633f, -0.04670231f, 0.08216046f, -0.06754846f, 
    -0.11526141f, 0.00286687f, 0.01263728f, 0.00897133f, -0.01127439f, 0.11817488f, 0.02327991f, 0.07336494f, 
    0.14238484f, -0.13957867f, -0.07112370f, 0.24274376f, 0.20761687f, 0.03263931f, -0.07795665f, -0.09937129f, 
    -0.28580886f, 0.06101569f, 0.01253585f, 0.04473820f, 0.03556250f, 0.06699654f, 0.08852311f, 0.00148486f, 
    -0.00998396f, 0.00518793f, 0.02627113f, -0.07786223f, -0.00068977f, 0.03243447f, -0.10891992f, 0.19986388f, 
    -0.03911643f, -0.04179940f, 0.05518332f, 0.11087292f, 0.03194728f, -0.01347518f, 0.02029111f, -0.03012133f, 
    -0.02002483f, 0.02183459f, 0.01137088f, 0.00496520f, -0.05330143f, 0.06398018f, -0.03342780f, 0.08470183f, 
    0.14619969f, -0.02667936f, 0.09972695f, 0.23445271f, -0.08493020f, 0.17998229f, 0.13740550f, 0.35271320f, 
    0.08809390f, -0.08339477f, 0.12192172f, -0.02246819f, 0.08707745f, 0.16979618f, 0.01173078f, -0.01279374f, 
    -0.05017519f, -0.00103933f, 0.01105966f, -0.01845231f, -0.00555356f, -0.14836191f, -0.01231636f, -0.11062815f, 
    -0.14113127f, -0.31806982f, 0.11934284f, -0.15298411f, -0.04570429f, 0.02982946f, 0.11436755f, -0.18358323f, 
    0.07654580f, -0.07298934f, -0.00505694f, 0.01004332f, -0.06019729f, 0.18467739f, -0.01578254f, -0.06906972f, 
    -0.02035677f, -0.04972288f, -0.03042182f, -0.13802411f, 0.13458069f, 0.17189468f, 0.21617945f, 0.26876733f, 
    0.12352843f, -0.14838803f, 0.06357362f, -0.09386702f, 0.04490962f, 0.11392169f, -0.01108123f, 0.02222250f, 
    -0.04692560f, 0.04751216f, 0.06948094f, -0.04006019f, 0.00879049f, -0.13885160f, -0.09893354f, -0.16836418f, 
    0.20254190f, 0.08251243f, 0.18468189f, 0.30134729f, 0.09345779f, -0.18853986f, -0.07052351f, 0.00847747f, 
    0.07388666f, -0.04981580f, -0.00399877f, 0.02150533f, 0.03097214f, 0.04596633f, 0.03956122f, -0.01145330f, 
    -0.00814812f, 0.04085394f, -0.04304939f, -0.10719115f, 0.02680064f, -0.05332276f, -0.00833545f, -0.04275138f, 
    -0.02288071f, 0.07920735f, 0.04105690f, 0.07148638f, -0.03704125f, 0.00501615f, -0.00756326f, 0.00624476f, 
    -0.08086904f, -0.03873447f, 0.06022233f, -0.07077753f, -0.20882048f, -0.12552579f, -0.02698831f, 0.03622422f, 
    0.08482377f, 0.16145454f, -0.31955644f, 0.11567375f, 0.23949011f, 0.01001120f, 0.05957810f, 0.06533720f, 
    0.10118560f, 0.09912575f, 0.06123271f, 0.02305829f, 0.01423374f, -0.01741675f, 0.04291015f, 0.10263644f, 
    0.12807393f, 0.10452371f, 0.05638462f, 0.16944683f, 0.10546111f, 0.04637858f, 0.05852093f, 0.16850731f, 
    0.03081889f, -0.09587638f, -0.03938638f, -0.05549740f, -0.04790943f, -0.03266959f, -0.01020623f, 0.01904099f, 
    -0.06661092f, 0.02821437f, 0.03328522f, -0.00515920f, 0.02323277f, 0.08523022f, -0.02360448f, -0.06389099f, 
    0.10839542f, -0.33947870f, -0.08627821f, 0.05234951f, -0.26257437f, 0.03307489f, -0.04434234f, 0.02581301f, 
    -0.05848040f, -0.01524542f, 0.01092855f, 0.02015919f, -0.00669834f, 0.07984561f, -0.09928434f, -0.01799065f, 
    0.11449129f, 0.09267773f, -0.01686247f, 0.27537099f, -0.00002790f, -0.04728970f, 0.13310109f, 0.09209813f, 
    -0.04957024f, -0.17420265f, -0.04659438f, -0.06956804f, 0.01425449f, -0.09697742f, -0.00937905f, -0.05025110f, 
    0.00519130f, 0.07815731f, -0.02450980f, 0.02052361f, -0.07376601f, -0.05209501f, 0.06258082f, -0.02137458f, 
    0.03027586f, -0.11100366f, -0.02265038f, -0.00119067f, -0.02314018f, 0.02880313f, 0.03367668f, 0.12873991f, 
    -0.03270010f, 0.00428203f, -0.11231959f, -0.07503831f, 0.00800281f, -0.09269900f, -0.02383710f, 0.09424817f, 
    -0.06979971f, -0.06523501f, -0.17220812f, 0.03834156f, -0.05598175f, -0.08127913f, 0.11863520f, 0.08984967f, 
    0.16743270f, -0.09392605f, 0.09740072f, -0.08991402f, -0.14636676f, -0.04999133f, -0.00513816f, 0.03699226f, 
    0.00884437f, 0.01054514f, -0.09502952f, -0.06341407f, 0.02224862f, -0.05342690f, 0.00726118f, -0.01840053f, 
    -0.29380170f, 0.21139115f, -0.34106535f, -0.25135264f, -0.04741440f, 0.04226007f, -0.03338423f, 0.06681735f, 
    -0.09232245f, -0.05704040f, -0.02347437f, 0.09276533f, -0.00246515f, 0.10345259f, 0.03634088f, -0.07489361f, 
    -0.05731929f, 0.15731581f, 0.01504065f, -0.03879777f, -0.00897867f, -0.00739731f, -0.08674919f, -0.00758092f, 
    0.01436079f, 0.07450974f, 0.00693585f, -0.02852602f, 0.01525385f, -0.03719611f, 0.11603450f, 0.02680198f, 
    -0.08523239f, 0.23510283f, 0.10215147f, 0.03719357f, 0.04082860f, 0.01179523f, 0.00499890f, -0.02716274f, 
    0.14763515f, -0.04521193f, -0.00986866f, 0.03146699f, 0.03143028f, -0.11481650f, -0.06653042f, 0.05566924f, 
    0.06954563f, 0.00052231f, -0.03664807f, -0.09765929f, -0.03979351f, -0.09467912f, -0.02217110f, 0.05880176f, 
    0.05104551f, 0.00304214f, -0.18225406f, 0.04130732f, -0.85127497f, 0.23385595f, -0.00249402f, 0.23726241f, 
    -0.23708725f, 0.27639672f, -0.10424165f, -0.02422842f, 0.13816079f, 0.00461195f, -0.10271031f, 0.01017406f, 
    0.00162966f, 0.01997313f, 0.02427791f, 0.07305603f, -0.10030289f, 0.22242288f, -0.04455900f, 0.03281293f, 
    0.08302448f, 0.15079853f, -0.13183819f, 0.04430252f, 0.04255056f, 0.04833596f, -0.25897181f, -0.02457571f, 
    -0.05622241f, 0.06038614f, -0.09772020f, 0.11648201f, -0.04723270f, -0.05370145f, -0.03023551f, 0.11734810f, 
    -0.01316367f, 0.14035316f, -0.05747357f, 0.00912266f, -0.23745489f, 0.03157014f, 0.14460467f, 0.02817901f, 
    -0.24819648f, 0.01787958f, -0.13010648f, -0.12449090f, 0.18247621f, -0.04227175f, -0.05779943f, 0.01953465f, 
    -0.02568137f, -0.03491348f, 0.18296780f, 0.09225573f, -0.00050506f, -0.03588124f, 0.14344132f, 0.22321911f, 
    0.02911900f, 0.04680873f, -0.03729155f, 0.13548249f, -0.02455304f, -0.10074051f, -0.11536467f, -0.03511256f, 
    0.09628308f, -0.00272200f, -0.17522611f, 0.11140177f, -0.03452818f, -0.10119708f, -0.12526272f, 0.15730195f, 
    0.06501682f, 0.19875586f, -0.13680565f, 0.01609708f, -0.07306910f, -0.03733588f, 0.15393962f, -0.03671664f, 
    -0.08153858f, 0.12609260f, -0.00213440f, 0.02126263f, 0.02168069f, -0.02143283f, 0.03333487f, 0.00900040f, 
    -0.00852021f, 0.04630631f, 0.01650001f, 0.01302876f, -0.00630302f, -0.12270793f, -0.18847679f, -0.14964657f, 
    -0.58575338f, 0.13321689f, 0.09440901f, 0.36606723f, -0.21519893f, -0.05944168f, -0.10793830f, -0.07322300f, 
    -0.01445176f, 0.19610767f, -0.03714621f, 0.09246519f, -0.03344192f, -0.02217254f, 0.01223409f, -0.06659727f, 
    -0.09204016f, 0.03803324f, -0.16705857f, -0.06741433f, 0.05713999f, -0.05469166f, 0.10959908f, 0.08140668f, 
    -0.25233772f, -0.06432851f, -0.01435257f, -0.07116807f, -0.07491901f, 0.05065646f, 0.15075453f, -0.09498675f, 
    -0.00404772f, -0.08348539f, 0.04854399f, 0.03477401f, 0.08820950f, 0.01428299f, 0.04543228f, 0.03209136f, 
    -0.49065682f, -0.13214302f, -0.28768992f, 0.00415157f, 0.07074567f, 0.04916286f, -0.04908609f, 0.05575359f, 
    -0.02880660f, -0.05820369f, 0.14413312f, 0.13363339f, 0.16651073f, -0.09778839f, 0.03640597f, 0.02486493f, 
    -0.10479795f, 0.06737056f, -0.02692879f, 0.02983146f, -0.47411847f, 0.12432475f, -0.61240757f, -0.18164085f, 
    -0.08153644f, 0.03877106f, -0.01053270f, -0.04496136f, -0.00567156f, 0.10398117f, 0.12714384f, 0.06878566f, 
    -0.02340106f, 0.06048835f, -0.13308558f, -0.03783572f, -0.03135013f, 0.11765330f, -0.02671606f, 0.07747884f, 
    -0.00378676f, -0.12826668f, -0.00317145f, 0.00631821f, 0.02813715f, -0.24266948f, 0.02641399f, -0.24751808f, 
    -0.09592398f, 0.05617763f, 0.09024927f, -0.04448922f, 0.06567557f, -0.09897293f, 0.09919950f, 0.05756088f, 
    0.00914798f, -0.04447617f, 0.04079054f, 0.11152704f, 0.13596517f, 0.70938766f, -0.00274048f, -0.07774095f, 
    0.17529258f, -0.09133705f, -0.13141982f, 0.01890093f, -0.08862533f, 0.04313350f, 0.11854975f, -0.12874787f, 
    0.00284715f, 0.14070636f, -0.01039493f, 0.06741422f, -0.06585532f, 0.11081227f, 0.25636864f, 0.03497164f, 
    -0.11939342f, 0.18896976f, -0.45540112f, -0.09136063f, -0.05842831f, -0.05165254f, -0.09620201f, 0.09702815f, 
    -0.04091550f, -0.10750939f, 0.01383983f, 0.01108402f, -0.02067621f, 0.07711168f, 0.11562246f, -0.13727465f, 
    -0.05880284f, 0.07029333f, -0.08827878f, -0.06717093f, 0.17317875f, -0.09292698f, 0.19043113f, -0.07190007f, 
    -0.19179077f, 0.26081070f, 0.15093729f, -0.00479808f, 0.06572825f, -0.09896747f, 0.03115092f, 0.03113394f, 
    -0.02193276f, 0.03424878f, 0.02021779f, -0.00178400f, -0.01601572f, -0.01414503f, 0.13546206f, 0.05720742f, 
    -0.14449079f, 0.05199365f, -0.13222151f, -0.32490268f, 0.18149795f, 0.12047721f, 0.12676661f, -0.00981606f, 
    -0.12595910f, -0.07421898f, 0.14465959f, -0.02622952f, 0.00565710f, -0.12184937f, 0.00620687f, -0.01335388f, 
    0.03775761f, -0.02878755f, -0.00832918f, -0.00682001f, 0.16566767f, -0.02639148f, 0.14043494f, -0.14353417f, 
    0.05553006f, 0.10218901f, 0.05829480f, -0.11720544f, 0.01556061f, 0.10534845f, 0.05568327f, -0.02456102f, 
    0.04442463f, -0.00439681f, 0.00789900f, -0.18780953f, -0.02046663f, -0.11842567f, 0.19399351f, -0.01478039f, 
    -0.43233076f, -0.03641674f, -0.24055064f, -0.36452243f, -0.45754340f, 0.04296197f, -0.04853614f, -0.03834201f, 
    -0.22457521f, 0.30813646f, 0.02016288f, 0.05793869f, -0.06615887f, 0.02806054f, -0.04162735f, -0.08338456f, 
    -0.13546456f, -0.08723973f, -0.00932602f, 0.06790280f, -0.22794725f, 0.14119518f, -0.07816731f, -0.02803589f, 
    -0.01923691f, 0.14072047f, -0.16812254f, -0.01532347f, -0.01486716f, 0.03263179f, -0.01014617f, 0.00822101f, 
    -0.03441000f, -0.01208161f, 0.03559550f, 0.09873778f, 0.04481919f, 0.25395057f, -0.16117257f, 0.04430461f, 
    -0.34635201f, 0.10641983f, 0.07029116f, 0.15076360f, -0.04906762f, -0.05532962f, 0.06448984f, 0.13045968f, 
    0.03141573f, -0.11694792f, 0.01018491f, 0.03457869f, -0.04148156f, 0.01655760f, 0.10289022f, -0.11865892f, 
    -0.07728073f, -0.10257077f, -0.07318097f, -0.35956568f, 0.29519737f, 0.25786889f, 0.19445361f, 0.07421982f, 
    0.13347577f, -0.01776773f, -0.02911650f, 0.04799262f, -0.02409466f, 0.01020930f, 0.08644548f, 0.05601548f, 
    0.04416264f, 0.03063694f, -0.02414576f, 0.12103562f, -0.05023310f, -0.08487545f, -0.20328373f, -0.32111898f, 
    -0.04463032f, 0.08436449f, -0.23508179f, 0.07924101f, 0.07967451f, 0.00795854f, -0.01828283f, -0.13237424f, 
    0.00978391f, 0.05399531f, -0.05704310f, -0.07889194f, 0.00722530f, 0.01580506f, -0.27370432f, 0.00580085f, 
    0.02867350f, 0.16476597f, 0.07659312f, -0.02545366f, 0.11386304f, 0.03595708f, 0.22643651f, -0.06709621f, 
    0.00179482f, 0.02829070f, -0.02531788f, -0.04035667f, 0.01119834f, -0.03469351f, 0.01562078f, 0.03728496f, 
    0.06422938f, 0.00670724f, 0.02675504f, 0.06263657f, 0.01164820f, -0.09001449f, 0.04593202f, 0.20407297f, 
    -0.49938691f, -0.17717338f, -0.00245380f, -0.23631406f, 0.21120308f, 0.09335681f, -0.03478725f, 0.02991947f, 
    -0.11027404f, -0.11537761f, 0.01989065f, -0.10489117f, 0.18434672f, 0.09447822f, 0.05660049f, -0.05850055f, 
    -0.14416263f, -0.06980482f, 0.01156183f, -0.09910172f, -0.06322247f, -0.00558922f, -0.03735144f, -0.14954588f, 
    0.04787862f, 0.08912423f, 0.00610847f, -0.05340576f, -0.01462599f, 0.00103164f, 0.13146424f, -0.17486450f, 
    -0.04351735f, 0.07503750f, 0.09092073f, 0.01949497f, 0.04149596f, 0.01283783f, 0.02047336f, -0.01217834f, 
    0.07241993f, 0.01633115f, 0.11216958f, -0.17585033f, 0.18745232f, -0.05232870f, 0.12519278f, 0.05296082f, 
    -0.07561801f, -0.10006479f, 0.03415303f, 0.02949200f, 0.04457055f, 0.13345592f, -0.00876117f, 0.15600201f, 
    -0.10219608f, -0.08756103f, -0.13054907f, 0.03438852f, 0.07346056f, -0.70883995f, -0.08438473f, 0.26164156f, 
    -0.09382387f, 0.17902996f, -0.00165833f, -0.17921333f, 0.07595615f, 0.07873324f, -0.03344464f, 0.11107615f, 
    -0.11867673f, 0.06774364f, 0.07771352f, 0.04937715f, -0.09763373f, 0.09951592f, 0.00622713f, 0.34764346f, 
    0.11534368f, 0.00093218f, -0.04215590f, -0.10352092f, -0.01252518f, 0.05307725f, 0.00700086f, 0.04667038f, 
    -0.02212663f, 0.08270513f, -0.14049472f, -0.04982254f, -0.07221618f, -0.01972980f, -0.05138877f, 0.04470221f, 
    0.08964623f, 0.03906002f, 0.04086161f, 0.09210777f, 0.02567529f, -0.11455552f, -0.05801231f, 0.03516825f, 
    0.00070735f, 0.02843990f, -0.03657461f, -0.02018925f, 0.03865828f, 0.03996959f, -0.00268852f, -0.09187379f, 
    0.06747327f, -0.06103477f, -0.00707229f, 0.11222858f, 0.06769808f, 0.07039595f, -0.02082906f, 0.02401110f, 
    -0.00193219f, -0.09211779f, 0.07749949f, 0.09515528f, -0.23262204f, 0.11443791f, 0.11867201f, 0.09910213f, 
    -0.01462017f, 0.05033678f, 0.05132122f, -0.01688167f, 0.01126595f, 0.01198402f, 0.00520279f, -0.04065797f, 
    0.06315172f, 0.04409109f, 0.03400936f, 0.02817135f, -0.01194814f, 0.00502658f, -0.00669310f, -0.07593857f, 
    -0.08143180f, 0.01305661f, 0.00968418f, -0.03999271f, 0.04360219f, 0.02596468f, 0.03711040f, -0.02335697f, 
    -0.03606141f, -0.07071992f, 0.02058044f, 0.01655803f, 0.09270861f, 0.03628459f, 0.01728102f, 0.10879710f, 
    -0.07496944f, 0.13180755f, -0.20966776f, -0.29813516f, 0.02147068f, -0.12654555f, -0.04860003f, -0.03407459f, 
    -0.07653668f, 0.09128419f, -0.08656327f, 0.14881606f, -0.17936076f, -0.07804983f, 0.16341737f, -0.07025827f, 
    -0.17467517f, 0.00743873f, 0.09162851f, 0.05094285f, -0.00025235f, -0.25601193f, -0.15331347f, 0.10024511f, 
    0.07110687f, 0.05754539f, -0.08562560f, -0.13269183f, -0.00078665f, -0.00098681f, 0.03568512f, 0.07771857f, 
    -0.11655825f, -0.00936250f, 0.07551440f, 0.00181186f, -0.17543797f, 0.11443018f, 0.04685394f, 0.21096972f, 
    0.14639883f, -0.03150909f, -0.00080942f, -0.13052425f, 0.06230497f, 0.08612438f, 0.11316368f, -0.07947016f, 
    0.07461498f, 0.06546386f, -0.05802825f, 0.04179045f, -0.10452877f, -0.04062942f, 0.05849909f, -0.02601370f, 
    0.08494541f, 0.02265250f, -0.06495678f, 0.18698172f, -0.09865011f, 0.09117344f, -0.13453718f, 0.00062616f, 
    0.01106389f, 0.11307808f, -0.03188305f, -0.02190515f, 0.02173030f, -0.01777269f, 0.09802135f, 0.08010523f, 
    -0.15406325f, 0.04201975f, -0.00106769f, 0.00660999f, -0.03459524f, 0.09085145f, -0.03466798f, -0.01669029f, 
    -0.19608027f, 0.32938921f, -0.35535136f, 0.00362146f, -0.01814902f, -0.00984442f, -0.02192014f, 0.05349331f, 
    -0.00093104f, 0.07650142f, 0.04578634f, 0.01688828f, 0.05459265f, 0.03625523f, 0.02295594f, -0.08755095f, 
    0.02291238f, 0.10997666f, -0.02876924f, -0.00893882f, -0.18758141f, 0.02625207f, 0.02745876f, 0.01407603f, 
    -0.14521594f, 0.02212440f, 0.05635991f, 0.01590691f, -0.04005064f, 0.08018149f, 0.06628364f, -0.02072741f, 
    -0.03657725f, 0.05959207f, 0.01615144f, -0.10491236f, -0.05490411f, -0.03991544f, 0.04857915f, 0.03045535f, 
    0.07380783f, 0.11071001f, -0.21463576f, 0.19547358f, 0.02800906f, 0.04688041f, -0.01112143f, -0.01652586f, 
    0.00708483f, 0.07023719f, -0.04711086f, 0.05218314f, 0.00506802f, -0.04906208f, -0.04662696f, 0.06515575f, 
    -0.20283546f, 0.15308416f, -0.03751300f, -0.04303208f, 0.36178842f, 0.06639773f, -0.01579277f, 0.02140640f, 
    0.02585009f, -0.03918651f, 0.01183783f, 0.04770854f, -0.04716307f, 0.09891414f, 0.04711115f, 0.09440544f, 
    0.00728225f, 0.03510644f, -0.00276857f, -0.00685034f, -0.01456162f, -0.02310031f, -0.09516552f, -0.01346829f, 
    0.02047570f, -0.04152942f, -0.13850759f, -0.00561225f, 0.04566802f, -0.00068835f, 0.03926100f, -0.04447230f, 
    -0.02006312f, 0.00482957f, -0.01475096f, 0.05303317f, 0.04022555f, 0.02078027f, 0.04136536f, 0.01064982f, 
    0.03614208f, 0.07981291f, 0.01460281f, -0.04361291f, 0.49394754f, -0.23970829f, -0.21560231f, -0.17323291f, 
    0.13230717f, 0.09430503f, -0.04599180f, -0.08248020f, -0.12837003f, 0.19288360f, 0.11390560f, -0.03038623f, 
    0.00868019f, 0.03306492f, -0.04059073f, 0.16027997f, 0.17791608f, -0.10437724f, 0.07915235f, 0.20835456f, 
    0.64570475f, 0.14280762f, -0.54337245f, 0.16772434f, -0.00311598f, 0.02051735f, 0.25708997f, 0.04896610f, 
    -0.11782621f, 0.10258076f, -0.00464756f, 0.02492549f, 0.06190096f, 0.01298899f, -0.04399927f, 0.05920886f, 
    0.02831698f, 0.02061267f, -0.11366065f, 0.02471207f, -0.24548493f, -0.11938912f, -0.05591513f, 0.14588226f, 
    -0.37503743f, 0.08074376f, 0.07794849f, 0.02596473f, 0.05722077f, 0.04147199f, 0.11112343f, -0.03339355f, 
    -0.08186443f, -0.08803651f, 0.22416694f, -0.01196797f, 0.02361742f, 0.04655943f, -0.01540487f, -0.05297778f, 
    -0.40131631f, -0.16762809f, -0.22134425f, 0.24894261f, -0.09981080f, 0.09690227f, -0.17073834f, -0.06926937f, 
    -0.02983859f, 0.17947866f, -0.09008019f, 0.08624865f, -0.04380206f, -0.01153475f, -0.01442987f, -0.10593814f, 
    -0.14645158f, 0.05905611f, -0.07229722f, 0.00281333f, -0.05901349f, 0.21689586f, 0.06555666f, 0.12941435f, 
    -0.07749772f, -0.04729654f, -0.27210188f, 0.10752483f, 0.02076244f, -0.03848418f, -0.05750505f, 0.05097624f, 
    -0.05019905f, -0.07744776f, -0.04584224f, 0.11094864f, 0.03696866f, 0.18228483f, -0.07430416f, -0.02152803f, 
    0.12398499f, 0.02466291f, 0.16699913f, 0.05975158f, -0.04094696f, 0.18630427f, 0.05492546f, -0.02676378f, 
    0.11177444f, 0.07975067f, 0.06492773f, 0.05279453f, 0.00241265f, 0.04940942f, 0.04082232f, -0.01188810f, 
    0.03121447f, 0.00516566f, -0.06372007f, 0.02004980f, -0.07144530f, 0.09172358f, -0.08308923f, -0.08270458f, 
    0.02495668f, 0.03454009f, -0.00572620f, -0.00787364f, -0.02082680f, -0.04290261f, 0.00789474f, -0.04245655f, 
    0.02077617f, 0.09415034f, -0.03207108f, -0.07808167f, 0.01090778f, -0.02287582f, -0.06648265f, -0.12752318f, 
    -0.18945438f, -0.01104637f, -0.13167489f, 0.02467745f, -0.01156568f, 0.02499650f, -0.03666825f, -0.08799127f, 
    0.02585088f, -0.01644805f, 0.11770032f, 0.01486343f, -0.01279653f, 0.05352204f, -0.03070523f, -0.06881312f, 
    0.02321712f, 0.12517582f, 0.02808294f, 0.04277253f, -0.51933181f, 0.15540017f, -0.06030073f, 0.22272287f, 
    -0.26948410f, -0.01385548f, -0.06857745f, -0.02928815f, 0.02137979f, -0.04923414f, 0.07546683f, -0.10717012f, 
    0.01178756f, 0.00680401f, -0.10885309f, 0.17960458f, -0.05569758f, -0.18072601f, 0.12003488f, 0.08896406f, 
    0.19577469f, -0.05497043f, 0.18447898f, 0.17695759f, -0.16943227f, -0.00054339f, -0.10205000f, -0.04926283f, 
    0.06569091f, -0.11291895f, 0.04156949f, 0.00763585f, 0.05302700f, -0.00127838f, 0.02124495f, -0.06354184f, 
    -0.00848455f, -0.18784815f, -0.14598729f, -0.37759119f, -0.13617560f, 0.23831871f, -0.14682141f, 0.07611013f, 
    0.08075129f, 0.02086802f, 0.01416738f, -0.04467444f, 0.03654224f, -0.00690736f, 0.00182611f, -0.02541924f, 
    -0.08985344f, 0.02824141f, -0.02294767f, -0.21106470f, -0.01838563f, 0.09705184f, -0.00816620f, -0.25703490f, 
    -0.06022284f, 0.11000747f, 0.21571010f, 0.15226571f, -0.07713735f, -0.00673590f, -0.05659132f, 0.05230091f, 
    0.11397549f, -0.02791220f, 0.02449863f, 0.01993082f, 0.03075442f, -0.01179551f, 0.01142624f, -0.04347550f, 
    -0.09960842f, -0.20792346f, -0.14973615f, -0.24403010f, 0.06165516f, -0.00474785f, 0.26142508f, 0.03553284f, 
    -0.21474062f, 0.07595050f, 0.04934471f, 0.02772699f, 0.00461160f, -0.09247761f, 0.01843853f, -0.08425320f, 
    0.08815965f, -0.02170892f, 0.05434708f, 0.07614852f, 0.05361656f, -0.06789231f, -0.02512601f, 0.04035242f, 
    -0.25395983f, 0.24333383f, -0.15317388f, -0.69321859f, 0.02568520f, -0.12828130f, -0.02899045f, 0.06803120f, 
    -0.08471917f, -0.01266079f, 0.05419345f, 0.06984209f, -0.05974096f, -0.13884735f, -0.01830968f, -0.02791373f, 
    -0.05306238f, 0.14788967f, 0.04057068f, -0.00096711f, 0.07678702f, -0.04565468f, 0.32456458f, -0.05998960f, 
    -0.14715457f, 0.13571452f, 0.11988495f, -0.02938110f, -0.01155400f, -0.11792706f, 0.06012715f, -0.02483809f, 
    0.04659306f, 0.02966730f, 0.03489333f, -0.00457234f, 0.05320535f, -0.08416365f, 0.18475991f, 0.28764701f, 
    -0.05040295f, -0.18062089f, 0.08207213f, -0.16480398f, -0.30141559f, 0.20211333f, 0.04092883f, -0.18307377f, 
    0.10809620f, 0.07901769f, 0.08690912f, 0.00398387f, -0.05546851f, -0.03599342f, -0.05545500f, 0.02627209f, 
    0.09282924f, 0.06185402f, 0.06973428f, 0.10727546f, 0.08622287f, -0.11987515f, 0.01901296f, -0.01050438f, 
    -0.01247175f, 0.07679296f, -0.03093557f, 0.04138814f, -0.06895215f, 0.11168841f, 0.01124468f, -0.07379818f, 
    -0.03226111f, 0.07675837f, 0.10666882f, 0.13864200f, -0.08840416f, -0.09239237f, 0.16363879f, 0.11568105f, 
    -0.09073240f, 0.03453599f, -0.18411593f, -0.00200917f, 0.06215315f, 0.13352774f, 0.08104511f, -0.01927943f, 
    0.01235584f, 0.05929166f, 0.04614728f, 0.00391397f, 0.01242168f, -0.00268730f, -0.02857696f, -0.27613285f, 
    -0.08665594f, 0.04832999f, -0.01736186f, -0.14386471f, -0.18945189f, -0.02916734f, -0.07369027f, -0.06369957f, 
    -0.11855499f, 0.02984150f, -0.00297521f, -0.04765086f, 0.14418077f, 0.17012535f, 0.09465718f, -0.01694468f, 
    -0.05769418f, 0.02113244f, -0.01195472f, -0.03517327f, 0.04604772f, 0.03496023f, 0.02663433f, 0.10167637f, 
    -0.50701714f, 0.42843616f, 0.05488580f, -0.08007059f, 0.06881679f, 0.03619973f, -0.01597927f, 0.01440798f, 
    0.08803710f, -0.07245490f, -0.03281400f, -0.08795023f, -0.05483090f, -0.02274944f, -0.02056491f, -0.11623235f, 
    0.03280918f, -0.04347162f, -0.04370850f, -0.16812322f, 0.28407168f, -0.09428047f, 0.01232766f, 0.20911901f, 
    -0.14383659f, 0.09216125f, 0.04079606f, -0.07856882f, -0.13506851f, 0.20342365f, -0.08644079f, 0.02240825f, 
    0.00176843f, 0.05912428f, 0.11906838f, -0.01574028f, -0.00365606f, -0.02537824f, 0.07851080f, 0.18740466f, 
    -0.04887544f, 0.07338943f, -0.08653424f, -0.09205383f, 0.10519619f, 0.16370524f, -0.03961864f, 0.08229628f, 
    -0.05162930f, -0.07777245f, 0.19756700f, 0.01759145f, 0.08341262f, 0.03540276f, 0.07971430f, 0.08808295f, 
    0.01845510f, 0.10778663f, -0.02396994f, -0.06602912f, -0.14002423f, -0.01466489f, -0.05389164f, -0.28091478f, 
    -0.27078521f, 0.00712794f, -0.01385444f, 0.01944943f, -0.17230090f, 0.00742872f, -0.03069383f, 0.01615492f, 
    -0.02345053f, 0.01343398f, 0.01262510f, -0.08722354f, -0.13095531f, -0.14264186f, -0.00057450f, -0.06701051f, 
    -0.39054012f, 0.24714361f, 0.32207188f, -0.02510769f, 0.32560316f, -0.06429443f, -0.06942931f, -0.02298507f, 
    0.10716405f, 0.01144442f, 0.08099158f, 0.06716430f, 0.08397692f, -0.01085102f, -0.03477265f, 0.02947298f, 
    0.05580931f, 0.03763131f, 0.00881878f, 0.02125359f, -0.11200350f, -0.04551793f, 0.12044672f, -0.07815173f, 
    -0.00609069f, -0.03301792f, 0.01043344f, -0.08636557f, -0.00806125f, -0.01025042f, -0.01315064f, -0.06717978f, 
    -0.02424687f, 0.00732601f, -0.04356787f, -0.00321225f, -0.01803598f, -0.03639818f, 0.00829771f, 0.03700712f, 
    0.15385005f, 0.07871839f, -0.15438497f, -0.11257672f, 0.10513791f, -0.05685728f, -0.10844827f, -0.04328253f, 
    0.08113083f, -0.00098636f, -0.04337073f, -0.03060641f, -0.22198738f, -0.01613605f, -0.00824421f, -0.05057601f, 
    -0.00238352f, 0.04074843f, -0.10638355f, -0.05492521f, -0.24392906f, -0.47851107f, -0.37202820f, -0.20781730f, 
    0.25614232f, -0.06742913f, 0.15077451f, 0.18787120f, -0.13553178f, -0.02902573f, 0.00925133f, 0.03269064f, 
    0.02398520f, 0.00870886f, 0.09046654f, -0.03511148f, -0.01778291f, 0.00573893f, 0.15671559f, -0.03273920f, 
    0.20679890f, -0.11995750f, -0.19304109f, -0.11128233f, 0.04713023f, 0.07037923f, 0.05126162f, 0.04481370f, 
    0.05206830f, -0.05671677f, 0.03712355f, -0.01486620f, 0.00706030f, -0.17751521f, -0.01465951f, -0.00191523f, 
    0.00837318f, -0.02316746f, 0.00990959f, 0.01969599f, -0.07049385f, -0.30281562f, 0.07594428f, -0.05012777f, 
    0.11294163f, 0.02001944f, -0.01725488f, 0.05985675f, -0.07417198f, -0.00422970f, -0.00639390f, 0.00119558f, 
    0.00789791f, 0.08760911f, -0.09683646f, 0.00434983f, 0.05050856f, -0.03043834f, 0.06741984f, 0.10023590f, 
    0.01037927f, -0.12394379f, -0.17365903f, -0.11754584f, 0.13604756f, -0.06925233f, -0.00091043f, 0.07674196f, 
    0.04232461f, -0.01344661f, -0.05897458f, -0.07480785f, -0.05285648f, -0.04151969f, 0.01640099f, -0.05125359f, 
    0.00456566f, -0.03969804f, 0.06407175f, -0.02178724f, -0.20111614f, -0.31939867f, -0.55251020f, -0.24474789f, 
    -0.03910583f, -0.08621300f, -0.18643562f, -0.06386643f, -0.13870148f, -0.14150885f, -0.03865491f, 0.00485298f, 
    -0.01585977f, -0.03354354f, -0.07995351f, -0.03443874f, -0.05489448f, 0.00730599f, 0.11360174f, -0.00722163f, 
    -0.24192128f, 0.22136907f, -0.65831459f, -0.10870311f, 0.24095370f, -0.04732960f, 0.04057482f, 0.04930121f, 
    0.01391157f, 0.18050589f, -0.02775426f, 0.03139722f, 0.11867561f, 0.00388874f, 0.06364437f, -0.04287949f, 
    0.00173079f, -0.23168464f, 0.14470142f, -0.05059037f, -0.37204185f, -0.04460188f, 0.23511292f, 0.04796173f, 
    -0.10789505f, -0.20920160f, -0.01603724f, -0.20578980f, -0.18075709f, 0.10215830f, 0.07752515f, -0.05929241f, 
    0.03643880f, -0.07255749f, 0.07373048f, -0.01493184f, -0.00399105f, -0.03054601f, 0.05450063f, -0.08324194f, 
    -0.09093726f, 0.24343032f, 0.06732977f, -0.12892337f, 0.11305268f, 0.04653113f, -0.01386766f, 0.02221853f, 
    -0.02188585f, 0.00585822f, -0.02517923f, -0.03829144f, 0.09117566f, 0.06877743f, 0.05119904f, 0.06324145f, 
    -0.05988017f, -0.03600891f, -0.13716878f, -0.03180278f, -0.45017734f, 0.30172035f, 0.42725199f, -0.05908164f, 
    0.15915349f, -0.03748428f, -0.03747808f, 0.00972048f, -0.15712123f, 0.12556782f, -0.09101164f, 0.07777099f, 
    -0.00500819f, 0.11522465f, -0.02616660f, -0.01691140f, -0.00782658f, -0.02636560f, -0.04600632f, 0.05119501f, 
    0.02703876f, -0.09167731f, -0.04793228f, 0.00389182f, 0.05669456f, -0.01494189f, 0.09986622f, 0.02483912f, 
    0.12876737f, -0.04505653f, 0.08192076f, -0.06125189f, -0.03181436f, 0.04449206f, 0.04952309f, -0.02353478f, 
    -0.00957726f, 0.01302245f, -0.02110541f, -0.04860153f, -0.14451663f, -0.18038695f, 0.23393540f, 0.15130326f, 
    -0.09815899f, -0.08437434f, 0.12530434f, 0.13940348f, 0.18958263f, -0.29826942f, 0.05497053f, 0.12654613f, 
    -0.00500111f, 0.08544369f, 0.03903693f, -0.05263269f, 0.02760113f, 0.08490671f, 0.00909637f, 0.02982978f, 
    -0.12873006f, 0.03987592f, 0.10141796f, 0.06307964f, 0.22036660f, -0.03340738f, -0.05127984f, -0.09813860f, 
    0.02577079f, 0.14577019f, -0.04963351f, 0.09461118f, 0.14220040f, 0.05809487f, -0.04034748f, 0.02250573f, 
    0.05711289f, -0.01135471f, 0.10678206f, 0.07503952f, -0.55779946f, -0.43318707f, -0.50681359f, -0.21768837f, 
    -0.37409753f, -0.16070884f, 0.06840535f, -0.15295961f, -0.01583661f, -0.27813312f, 0.01926105f, -0.01755111f, 
    -0.00934738f, -0.01301782f, 0.02386050f, -0.02754906f, 0.00054627f, 0.07014269f, 0.08355020f, 0.00543831f, 
    0.10826515f, 0.06940418f, 0.03786222f, 0.00910601f, -0.11936680f, 0.07914053f, 0.06062342f, 0.00920277f, 
    -0.08359565f, -0.06789576f, -0.04491792f, 0.02786993f, 0.02867138f, -0.09194050f, -0.00119322f, 0.07485858f, 
    -0.07883908f, -0.00669774f, -0.18164781f, -0.04476762f, -0.08019214f, 0.13541742f, -0.01887977f, -0.27565524f, 
    0.03286356f, -0.11794116f, -0.04728334f, 0.01304059f, 0.15407901f, 0.01390256f, 0.06822522f, -0.03706525f, 
    0.06813012f, -0.01072958f, -0.04263187f, 0.07447588f, 0.12177001f, -0.12448792f, 0.15561084f, -0.00041317f, 
    -0.28374878f, -0.18718201f, 0.08868545f, -0.39538881f, 0.34456667f, -0.04749874f, -0.19462661f, -0.18503779f, 
    -0.07374635f, 0.06987654f, 0.01825023f, 0.08672109f, 0.01272742f, 0.13857910f, -0.18866363f, -0.02101986f, 
    0.06283908f, 0.07494739f, 0.00864388f, 0.05084371f, 0.17243348f, -0.46267200f, -0.36732846f, -0.12920326f, 
    0.16550593f, -0.01837346f, 0.16091341f, 0.17505541f, 0.08015876f, -0.06479393f, -0.00650722f, -0.03837781f, 
    -0.02975824f, -0.03876323f, 0.06351413f, -0.00535772f, 0.02935738f, -0.05560765f, 0.14142643f, 0.01907312f, 
    -0.09512091f, -0.41544405f, -0.39386067f, -0.03218035f, 0.11445658f, -0.00063136f, -0.06472427f, 0.02553284f, 
    0.08698127f, -0.12272220f, -0.03122787f, 0.01704492f, 0.02275093f, 0.02666386f, -0.06153918f, 0.05477428f, 
    -0.00171601f, 0.05814613f, 0.07813575f, -0.07787643f, -0.66508037f, -0.42258257f, -0.57648772f, -0.04067095f, 
    -0.09842438f, -0.14767997f, 0.08366235f, -0.03330600f, 0.12413453f, -0.27914861f, 0.02406924f, -0.02538052f, 
    0.05572721f, 0.02656928f, 0.06416364f, 0.07447186f, 0.10517080f, 0.23324361f, 0.12436504f, 0.02298374f, 
    0.03838312f, -0.02821494f, -0.05344041f, -0.08816332f, 0.07745545f, -0.02750826f, 0.01690777f, 0.02354030f, 
    0.04376858f, 0.02193977f, 0.03387873f, 0.08862302f, 0.09488706f, -0.12919278f, 0.03516449f, -0.04104719f, 
    -0.03989380f, -0.06729084f, -0.04585211f, -0.03325346f, -0.57445639f, -0.27297667f, -0.54331928f, -0.22694929f, 
    -0.15978889f, -0.05470649f, 0.05053515f, -0.12333112f, -0.00590010f, -0.35270968f, -0.02108717f, -0.05236813f, 
    -0.06398738f, -0.00184893f, 0.05203776f, -0.01812270f, -0.00998505f, 0.16374047f, -0.09313770f, -0.14088278f, 
    -0.02354463f, 0.07773122f, 0.06027987f, 0.14818880f, 0.04392953f, 0.04213488f, 0.05883403f, -0.01216055f, 
    -0.00166987f, 0.07822163f, -0.01102617f, 0.09396764f, 0.16175045f, 0.07499983f, -0.00838751f, 0.11326536f, 
    0.03423576f, 0.11833311f, -0.13371037f, 0.03001301f, -0.09165183f, 0.00349396f, 0.18984406f, 0.00827300f, 
    -0.02181405f, -0.00673137f, -0.06231593f, -0.01437438f, -0.04762971f, 0.06454026f, 0.06363460f, -0.01552023f, 
    -0.02405752f, -0.00902549f, -0.01699335f, -0.07523821f, 0.02980247f, -0.04619751f, -0.00765041f, 0.05238858f, 
    -0.18384974f, -0.31262445f, -0.01347388f, 0.03592826f, -0.31864822f, 0.09717388f, 0.08236019f, 0.05139142f, 
    0.00958886f, -0.10401703f, -0.00400789f, 0.02814420f, 0.02302470f, 0.05535876f, 0.06037673f, 0.15731816f, 
    0.05662544f, 0.10511411f, -0.00960864f, 0.02665514f, -0.10726177f, 0.05900413f, -0.12216033f, -0.10496364f, 
    0.08943818f, 0.11580274f, 0.08419110f, 0.03377913f, 0.01914631f, 0.13880427f, -0.05382286f, -0.03049414f, 
    -0.09929088f, 0.14847544f, 0.05949414f, -0.06771269f, 0.05848750f, -0.03268082f, 0.09140798f, 0.00788194f, 
    0.07982209f, 0.22964172f, 0.04583959f, -0.05673359f, 0.01952626f, -0.07139965f, -0.02540223f, -0.14232577f, 
    0.00033847f, -0.04255784f, -0.05140668f, -0.14121605f, -0.08752451f, 0.01804592f, 0.06614926f, -0.00909422f, 
    -0.07126019f, 0.02462542f, -0.04697714f, -0.06879454f, 0.13072190f, 0.02826483f, -0.09230807f, -0.07931467f, 
    0.05771682f, 0.00159509f, -0.02574086f, 0.04754860f, 0.05632579f, 0.08748109f, -0.05256730f, -0.03337452f, 
    -0.08581487f, -0.12831005f, -0.02010259f, 0.01949137f, -0.06392982f, -0.15999614f, -0.04649232f, -0.02389073f, 
    -0.40488377f, -0.47879645f, -0.45755035f, -0.16420412f, -0.14479482f, -0.29862294f, -0.02220693f, -0.01770761f, 
    -0.08673508f, -0.02881275f, -0.00976450f, 0.02714993f, 0.00622638f, -0.08377075f, -0.01863923f, -0.00166617f, 
    -0.03046850f, -0.01376541f, 0.13728592f, -0.09291360f, -0.21349202f, 0.20195179f, 0.27604130f, -0.00008975f, 
    -0.02498616f, -0.08369697f, -0.07093996f, -0.12247429f, -0.10337886f, 0.00394023f, -0.05343304f, 0.01845953f, 
    -0.07200741f, 0.01187274f, 0.04916838f, -0.04091990f, -0.03600162f, -0.00244745f, -0.03099007f, -0.06290182f, 
    -0.20635079f, 0.16078527f, 0.06877812f, -0.04989074f, 0.22868152f, -0.02736662f, -0.00526902f, -0.03536928f, 
    0.03199553f, 0.01428321f, 0.11255429f, 0.10398962f, 0.07413708f, 0.12903623f, 0.01908559f, 0.05864931f, 
    0.02458995f, 0.08199674f, -0.00210699f, 0.17576104f, -0.04496981f, 0.06055540f, 0.01542567f, -0.04070086f, 
    0.03069147f, 0.02539378f, -0.00363608f, -0.04227231f, 0.00800961f, 0.03224998f, -0.05473232f, -0.01557564f, 
    -0.07007371f, 0.04721114f, 0.01845875f, 0.03013058f, -0.01779329f, -0.02500161f, -0.04483450f, 0.02377174f, 
    0.30799142f, 0.13812749f, -0.41652632f, -0.07817711f, 0.00975184f, 0.01247767f, 0.10985059f, 0.02928761f, 
    -0.00953316f, -0.14864825f, 0.06783446f, 0.08063456f, -0.09109192f, -0.02346048f, 0.08602878f, -0.01250200f, 
    0.00600975f, 0.10281265f, -0.08144049f, -0.08756685f, 0.03209511f, -0.00001318f, 0.06174900f, 0.01138024f, 
    -0.04600267f, 0.02058788f, -0.02213960f, 0.03405396f, 0.02855036f, 0.05815624f, -0.04947352f, -0.00985674f, 
    -0.01711270f, -0.02841141f, -0.11358355f, -0.00332290f, -0.00670467f, 0.01959890f, -0.01348596f, 0.02802132f, 
    -0.28584501f, 0.09251723f, 0.24151908f, 0.04348947f, 0.17561738f, -0.07925332f, 0.01079515f, 0.02214103f, 
    0.05298972f, 0.09259471f, 0.04587729f, 0.04108180f, 0.02359749f, -0.08342514f, 0.12474786f, 0.03191976f, 
    0.01105791f, -0.04406738f, 0.04440772f, -0.02782289f, -0.32088503f, -0.47697082f, 0.14250173f, -0.06483581f, 
    0.08829337f, -0.12170652f, -0.14488536f, 0.05217214f, -0.08497409f, -0.01429650f, -0.00232060f, -0.02681753f, 
    0.01485280f, -0.00817442f, 0.00486198f, -0.00337346f, 0.01869553f, 0.00580733f, 0.08432377f, -0.02096257f, 
    0.14525077f, -0.07333672f, -0.21379682f, -0.21816646f, 0.05043117f, 0.01123491f, 0.05899210f, 0.11033094f, 
    0.04029214f, -0.00832854f, 0.01428338f, -0.01206674f, -0.00703779f, -0.05305408f, 0.00140121f, -0.05857717f, 
    -0.02417684f, -0.02848982f, 0.08683793f, 0.06997027f, -0.02526964f, -0.32406870f, -0.62673998f, -0.15080595f, 
    -0.05221742f, 0.07820857f, 0.05512366f, 0.12902534f, 0.01865476f, -0.29139364f, 0.05437026f, 0.00581324f, 
    0.03034033f, -0.00947303f, 0.05193643f, 0.02898372f, 0.01120839f, 0.06544690f, 0.11870033f, 0.10079337f, 
    0.00529526f, 0.06724901f, 0.06485827f, 0.04495841f, 0.02496156f, 0.01423924f, -0.02355042f, -0.00068827f, 
    -0.05027246f, 0.08091436f, 0.08740090f, 0.01697858f, 0.07479315f, -0.00548885f, -0.00162827f, 0.00115107f, 
    0.04821133f, -0.07954477f, 0.01139886f, 0.00867983f, 0.48978159f, 0.47122124f, -0.30771634f, -0.20115918f, 
    0.20985626f, -0.12344555f, -0.03208572f, -0.01831306f, 0.19264808f, -0.00499473f, 0.14237942f, -0.00715777f, 
    0.05239842f, -0.21601212f, -0.14148901f, 0.03412781f, 0.15555008f, -0.15655458f, 0.05188777f, -0.01402351f, 
    0.44530979f, -0.08024140f, -0.63233519f, -0.25204888f, 0.07061954f, -0.19151424f, -0.00548292f, 0.26395226f, 
    0.16451240f, -0.13788354f, 0.04121637f, 0.00350505f, -0.03386206f, -0.04531340f, 0.02381114f, -0.07146174f, 
    0.03831463f, 0.10852982f, -0.09646559f, 0.11499069f, -0.31986153f, -0.01084844f, 0.17281865f, 0.11833448f, 
    -0.05814362f, -0.17882203f, 0.01596829f, -0.16737600f, -0.11889200f, 0.21039189f, -0.14574230f, 0.03601837f, 
    0.10911532f, -0.03713972f, 0.00528952f, -0.00399647f, 0.04852112f, -0.09206942f, 0.11853737f, 0.00863261f, 
    0.18963958f, 0.10173345f, -0.30388081f, -0.11542569f, 0.08869758f, -0.01686637f, 0.02431447f, 0.11815591f, 
    0.00422336f, 0.12589908f, -0.03805667f, 0.04332170f, -0.02300223f, -0.05441106f, 0.05236519f, -0.06352120f, 
    -0.07456693f, -0.36229855f, 0.12201493f, 0.06275667f, 0.00022231f, -0.33761662f, -0.19979118f, -0.16505177f, 
    0.13203272f, -0.01018960f, 0.05631477f, 0.12764321f, 0.08937027f, -0.08316182f, 0.00981898f, -0.03410307f, 
    0.02668359f, -0.11957344f, 0.00124971f, 0.00935122f, 0.02234552f, 0.09652535f, 0.08579606f, -0.02565839f, 
    -0.24059607f, -0.34399185f, -0.65819007f, -0.23834904f, 0.00009082f, -0.10866070f, 0.11286043f, -0.05725030f, 
    -0.03870562f, -0.15243082f, 0.02432175f, -0.02029879f, -0.06434157f, 0.02427558f, 0.05739122f, 0.00577069f, 
    -0.01306870f, 0.09846276f, 0.07032675f, 0.08080946f, 0.03891854f, 0.05189973f, 0.06347529f, -0.04511958f, 
    -0.04086569f, 0.00660828f, 0.04812386f, -0.05048599f, -0.04205686f, 0.05856218f, 0.02716148f, 0.01284736f, 
    0.01918561f, -0.00375411f, -0.09822723f, 0.03480476f, 0.01215493f, 0.06472853f, -0.03356809f, 0.04303709f, 
    -0.00164746f, 0.03280091f, 0.07067217f, 0.00448002f, 0.00103156f, 0.02625622f, -0.00911265f, -0.03329243f, 
    -0.00608589f, 0.08410674f, 0.00192930f, 0.02999261f, 0.04009772f, 0.09851900f, -0.01646417f, -0.01787091f, 
    0.02364491f, -0.05823873f, -0.03970956f, 0.04061235f, -0.04904397f, -0.08237737f, 0.04874654f, -0.03303566f, 
    -0.10119617f, -0.04717600f, 0.09669963f, -0.00555860f, -0.05582667f, 0.08162782f, 0.07304464f, -0.01648874f, 
    -0.09649462f, 0.04614926f, -0.05805221f, 0.02283784f, 0.03944519f, 0.04774075f, 0.11082207f, 0.06904730f, 
    -0.19306882f, -0.33573276f, -0.44747743f, -0.11787120f, 0.13959005f, -0.16506861f, 0.06180564f, -0.03650386f, 
    -0.15809630f, -0.13192736f, 0.02625842f, -0.03349042f, 0.01445925f, 0.03470642f, 0.04515111f, -0.03478844f, 
    -0.06586161f, 0.06591573f, 0.13721175f, 0.04654985f, -0.02461366f, 0.03711038f, 0.08276714f, -0.02862268f, 
    0.02752916f, -0.00591487f, -0.01397186f, -0.02650646f, -0.00677798f, 0.04830953f, -0.02039425f, -0.01186056f, 
    0.04404548f, -0.04356613f, -0.08278625f, -0.03339180f, -0.03850370f, -0.00954463f, -0.03063563f, 0.07946149f, 
    -0.25849500f, -0.35195252f, -0.54604805f, -0.04433807f, 0.10052730f, -0.11963465f, 0.00559564f, -0.06071311f, 
    -0.00877666f, -0.15728976f, 0.02607336f, 0.00189860f, 0.00034149f, 0.03117626f, 0.05480380f, 0.00067666f, 
    -0.01675272f, 0.08026432f, 0.11128911f, 0.05073779f, -0.63421369f, -0.74319428f, -0.54014045f, -0.22816274f, 
    0.21927473f, -0.06738555f, 0.03922572f, -0.08364727f, -0.18205191f, -0.38306552f, 0.04239895f, -0.02780079f, 
    -0.10536319f, -0.03047121f, 0.04117877f, -0.00630049f, -0.00267719f, 0.06800560f, 0.16862187f, 0.01244181f, 
    -0.35580418f, 0.31123784f, -0.01616913f, 0.19553341f, 0.17907111f, 0.06543300f, 0.00521826f, -0.04294181f, 
    0.05010255f, -0.07402811f, 0.08621544f, 0.07235943f, 0.18009153f, 0.07087527f, 0.10102133f, 0.09143221f, 
    0.07110755f, 0.00289582f, -0.10185965f, 0.02547553f, -0.55305415f, -0.58925146f, -0.29612100f, -0.07861298f, 
    0.06934465f, 0.01475315f, -0.11586737f, -0.19963677f, -0.04410046f, -0.36579844f, 0.04680649f, -0.00431121f, 
    -0.07714821f, -0.00691461f, 0.03236127f, 0.01239022f, -0.01547195f, 0.07263584f, 0.05916438f, -0.00450770f, 
    -0.52074593f, -0.18260893f, -0.08453904f, -0.34030461f, -0.43982300f, -0.08068473f, -0.00988883f, 0.12463776f, 
    -0.13198379f, 0.02776128f, 0.04654770f, 0.00468501f, -0.02525870f, 0.01333665f, 0.05133861f, -0.04182655f, 
    -0.01124777f, -0.00803304f, 0.03091971f, -0.08246534f, 0.02903296f, 0.09170084f, 0.06658306f, 0.05140667f, 
    0.06941048f, 0.00858453f, 0.10986129f, -0.03444651f, 0.16513620f, 0.13278322f, 0.02978077f, -0.05634477f, 
    -0.00784194f, -0.00779845f, 0.03639764f, -0.02690960f, -0.00483909f, -0.11215710f, -0.00129569f, 0.02683226f, 
    -0.19129945f, -0.18150094f, -0.16283295f, -0.19056194f, -0.01925524f, 0.02693380f, 0.08085625f, 0.09253329f, 
    -0.03350694f, -0.06334786f, -0.00718374f, -0.02875477f, 0.01047436f, 0.05252109f, 0.02038309f, 0.02971287f, 
    0.03891348f, 0.00316076f, -0.07738022f, 0.09479796f, -0.47135547f, 0.35132316f, 0.35231596f, 0.00102200f, 
    0.05710069f, -0.11840188f, -0.05437110f, -0.06141615f, -0.10807489f, 0.20514895f, -0.01071933f, 0.01757358f, 
    -0.01252267f, 0.04741776f, 0.03328156f, 0.02999530f, -0.00456620f, -0.01076800f, 0.00283746f, 0.00854538f, 
    0.06426086f, -0.07540917f, 0.17933081f, -0.04903313f, -0.10674353f, 0.02156118f, 0.00639662f, -0.00930816f, 
    0.04038023f, 0.04252220f, -0.06684739f, 0.08373388f, 0.03687922f, 0.02823386f, -0.01564012f, 0.03301058f, 
    0.12788482f, 0.04606987f, -0.00266003f, 0.03053040f, -0.13605568f, 0.13837339f, -0.04847125f, 0.17088442f, 
    0.02345237f, -0.02810916f, 0.06992693f, -0.01951398f, 0.02098292f, 0.14799544f, -0.01031832f, 0.01240904f, 
    0.05939404f, -0.04859909f, 0.06591742f, -0.00688113f, -0.00349308f, -0.07200010f, 0.21455149f, -0.14090817f, 
    0.04308695f, -0.00496699f, 0.11480776f, 0.07928128f, -0.07348431f, 0.06700159f, 0.05842632f, 0.01181387f, 
    -0.03358991f, -0.05584002f, -0.02364886f, 0.05262871f, 0.09883443f, -0.04644378f, -0.03516122f, 0.06591570f, 
    -0.06370723f, 0.01945074f, -0.09446605f, 0.00433532f, -0.12057753f, -0.44612467f, -0.19946443f, -0.03946768f, 
    0.33869207f, 0.00708005f, -0.04161261f, -0.08829827f, -0.00182085f, 0.06223997f, 0.02577036f, 0.07087017f, 
    0.05833453f, -0.02879873f, -0.16525531f, 0.06942368f, 0.06026189f, 0.09526083f, -0.02419711f, 0.04488704f, 
    0.15039621f, -0.41758594f, -0.41034064f, -0.09715812f, -0.24504800f, 0.05553559f, -0.14006487f, 0.00785026f, 
    0.14460200f, 0.06523897f, -0.04464726f, 0.05297871f, 0.01070439f, 0.04944756f, -0.04174172f, -0.01707039f, 
    0.02729082f, 0.08374943f, 0.05293997f, 0.06327467f, 0.10224013f, 0.10106029f, -0.01405190f, -0.11803162f, 
    -0.06933173f, 0.03426913f, 0.01202586f, 0.01508190f, 0.02626395f, -0.00937587f, 0.00173574f, -0.03758517f, 
    -0.12478590f, -0.17614751f, -0.03505226f, 0.03776137f, 0.04648522f, 0.04510094f, 0.01669791f, -0.00579341f, 
    -0.00934477f, -0.00508588f, -0.00230598f, 0.04660219f, 0.00080623f, 0.05047813f, 0.02160245f, 0.03521077f, 
    0.02397958f, 0.00040854f, 0.05112139f, -0.00685615f, 0.03360856f, 0.01833460f, -0.00887346f, 0.07856793f, 
    -0.00212436f, 0.00274615f, 0.02772167f, 0.05180494f, -0.10452988f, 0.13523866f, -0.06620704f, 0.11050043f, 
    -0.43717280f, -0.19467451f, 0.08959679f, -0.15519017f, -0.07750714f, 0.02890403f, -0.01534435f, 0.00962806f, 
    0.03641691f, 0.00203965f, -0.03490511f, -0.10218929f, -0.04281489f, 0.10911399f, -0.07790118f, -0.02308578f, 
    -0.01143686f, -0.01364964f, -0.01620745f, 0.07922417f, -0.02697934f, 0.05283558f, 0.00790416f, 0.07540054f, 
    0.00025332f, 0.01749342f, 0.09045954f, 0.04238357f, 0.01597181f, -0.01636792f, 0.00262442f, -0.02458833f, 
    0.05231787f, 0.00566384f, 0.02083323f, 0.06623539f, 0.22674993f, -0.25391811f, -0.41669935f, -0.09749141f, 
    -0.15858589f, -0.00570315f, 0.05680141f, -0.01648774f, -0.09346209f, -0.03907903f, -0.04013146f, 0.04302530f, 
    0.00253570f, -0.06451007f, -0.02897871f, 0.01370179f, -0.03575528f, -0.00630315f, -0.09338395f, 0.04039060f, 
    0.01487987f, 0.06303396f, -0.10747329f, 0.05151902f, -0.15158117f, 0.07253666f, 0.02790390f, 0.08123294f, 
    -0.01486628f, 0.00390462f, 0.00458589f, 0.05328691f, 0.07973125f, 0.07202411f, -0.06042770f, 0.01467382f, 
    0.00765692f, 0.07019016f, -0.01411936f, 0.00930340f, -0.03806038f, -0.25595841f, 0.15436608f, -0.25166446f, 
    -0.17757750f, 0.10671970f, 0.08455953f, -0.11333489f, 0.18488267f, 0.13403742f, 0.02004211f, 0.00008932f, 
    -0.01848120f, -0.06652921f, -0.03418600f, 0.04397376f, -0.01813714f, -0.12773806f, 0.04899413f, -0.06199921f, 
    0.28822687f, 0.35484532f, -0.30474737f, 0.31974897f, -0.35467920f, 0.02195692f, 0.17276148f, -0.09005609f, 
    -0.12247535f, -0.21169430f, -0.11917219f, 0.12025127f, -0.04423890f, -0.07474513f, 0.00577640f, -0.10494289f, 
    -0.01692161f, 0.02614843f, -0.01694292f, -0.07971622f, 0.43308085f, -0.18546373f, -0.24902411f, 0.01475223f, 
    -0.18079652f, 0.20666689f, 0.03414080f, 0.01983094f, 0.01927577f, 0.16456497f, 0.03870408f, 0.05857076f, 
    0.15455429f, 0.03439317f, 0.02969109f, 0.00010378f, 0.00340765f, -0.02945703f, 0.03020763f, -0.07211439f, 
    -0.02167963f, 0.05485449f, 0.04005662f, 0.04129833f, -0.05477751f, -0.02544149f, 0.02780757f, 0.08691629f, 
    -0.03833079f, -0.03410471f, -0.22953784f, -0.02637623f, 0.07400997f, -0.03685736f, -0.11325842f, 0.01297274f, 
    0.00237284f, -0.01302126f, 0.00397181f, 0.03170451f, 0.39956245f, 0.20747937f, -0.23491994f, -0.13219069f, 
    -0.21483468f, -0.03160141f, -0.02982349f, -0.07941221f, 0.00854560f, -0.06252811f, -0.00036449f, -0.09116197f, 
    0.01791972f, 0.01788214f, -0.02984140f, 0.04214570f, 0.05508379f, 0.03786464f, 0.03103379f, 0.03985604f, 
    0.07710111f, 0.11829994f, 0.16314967f, -0.06589444f, 0.11567084f, -0.08546046f, 0.04614299f, -0.10877485f, 
    -0.01792715f, -0.06306619f, -0.00435376f, 0.00928411f, 0.00091443f, 0.01404105f, -0.02203647f, -0.09742833f, 
    -0.10507428f, 0.11115903f, -0.02130754f, -0.02323065f, -0.00400920f, -0.08101968f, 0.29678652f, 0.01623396f, 
    -0.05909501f, 0.06337725f, -0.07451173f, -0.02011255f, -0.14087696f, -0.02903253f, -0.02274266f, 0.04622339f, 
    -0.04164981f, 0.01083322f, -0.08991233f, -0.07428216f, 0.00152142f, 0.10565355f, -0.23750988f, -0.03521489f, 
    0.40049383f, -0.03131011f, -0.27806923f, -0.11262062f, -0.23820950f, 0.02778960f, -0.00726911f, 0.07182375f, 
    0.16373023f, 0.02202846f, 0.06216994f, 0.00698906f, -0.06660400f, 0.03068317f, -0.02307218f, 0.00343567f, 
    0.02002532f, -0.03833847f, 0.09630741f, 0.08796384f, -0.51434171f, -0.28409997f, -0.01633805f, 0.00405451f, 
    0.01057354f, -0.11888859f, 0.19841164f, 0.17226684f, 0.12965527f, 0.17185232f, 0.00381775f, 0.00441816f, 
    -0.01178147f, -0.01555333f, -0.02411930f, -0.01490795f, -0.01050770f, 0.02847607f, 0.11979700f, -0.13148031f, 
    -0.05961906f, 0.06185244f, 0.13683321f, -0.09709672f, 0.10316487f, 0.04082070f, 0.03094166f, 0.04883791f, 
    -0.00058604f, 0.00761720f, 0.09366291f, -0.07199272f, 0.01789822f, 0.02187835f, -0.02767699f, -0.04889489f, 
    0.03129547f, -0.04336161f, 0.00506324f, -0.01973989f, -0.54834461f, 0.30762857f, -0.22806661f, 0.12574154f, 
    0.11640010f, 0.15416388f, -0.06136267f, 0.08830751f, -0.15138274f, -0.04868154f, -0.00734842f, -0.00798345f, 
    -0.05504381f, 0.04920003f, 0.03693980f, 0.09231400f, 0.13741203f, 0.10403553f, 0.10016485f, 0.09535205f, 
    0.56509072f, -0.78221732f, -0.39755926f, -0.38075313f, -0.52592909f, 0.04037758f, 0.08228579f, 0.00358687f, 
    0.40352601f, -0.09234738f, 0.04335340f, 0.09184493f, 0.05766739f, 0.03919571f, 0.04577504f, -0.09126935f, 
    0.02141267f, -0.12615566f, 0.03223074f, 0.06660343f, -0.07123414f, 0.06386720f, 0.03628816f, 0.11404374f, 
    -0.08853874f, 0.08077925f, -0.00581668f, -0.11979022f, 0.04489565f, -0.01599009f, 0.05303621f, 0.04482526f, 
    0.08028372f, -0.00595656f, -0.02158758f, 0.00096022f, -0.01286855f, -0.04220276f, 0.09099177f, 0.12295476f, 
    0.07203844f, -0.59492034f, -0.03571295f, -0.36100957f, -0.29452884f, -0.14342880f, -0.11828153f, -0.03535643f, 
    0.21379210f, 0.12201593f, -0.01561131f, -0.02038171f, -0.16590837f, -0.11598149f, -0.02944100f, -0.08484695f, 
    -0.03048250f, -0.05956892f, 0.11621395f, -0.02578959f, -0.42031214f, 0.03426886f, -0.19756533f, 0.37787521f, 
    0.20288400f, 0.07991911f, -0.07600475f, 0.13107592f, -0.05189383f, 0.14823987f, 0.01514506f, -0.02147561f, 
    -0.00925362f, -0.02278947f, 0.01709434f, 0.02042869f, 0.10677539f, -0.02528522f, 0.01055914f, 0.16193761f, 
    0.17686275f, 0.11664164f, -0.13288808f, 0.02295928f, -0.13942955f, 0.02040721f, 0.02508369f, 0.04710050f, 
    -0.08596734f, -0.03820725f, -0.14143877f, -0.14049165f, -0.06222282f, 0.06318318f, -0.10183842f, 0.04508002f, 
    -0.03857418f, 0.06978355f, -0.09484205f, 0.00134115f, -0.73951179f, -0.56596267f, 0.26092994f, -0.16534612f, 
    0.15121965f, -0.19220559f, 0.10275593f, 0.09249147f, -0.02894846f, -0.00669320f, -0.00354003f, 0.01809005f, 
    -0.00232725f, 0.00087716f, -0.02191338f, 0.04535295f, 0.00150757f, -0.03911947f, -0.01419913f, 0.02080304f, 
    -0.03198048f, -0.28245732f, 0.12596443f, -0.27810180f, 0.11707386f, 0.04707381f, 0.02197112f, 0.09026756f, 
    0.10740613f, 0.00505890f, 0.03574746f, -0.07066132f, 0.02768574f, -0.08197561f, -0.07237551f, -0.12366094f, 
    0.00499209f, -0.21214700f, 0.09377948f, 0.08962616f, 0.09982283f, 0.09428662f, 0.05855951f, -0.15275995f, 
    -0.06367051f, 0.04261747f, 0.02443290f, 0.05531371f, 0.00401956f, -0.03291189f, 0.05024111f, -0.23766509f, 
    -0.20479707f, -0.27463600f, -0.22967611f, 0.05514835f, 0.05838563f, -0.00627679f, 0.01794219f, 0.03067698f, 
    0.12573434f, -0.59913176f, 0.38128933f, -0.21625271f, 0.09890674f, -0.25805137f, -0.02164669f, -0.10351672f, 
    0.10584566f, 0.06372102f, 0.01400686f, -0.04927978f, 0.07626989f, -0.06281053f, -0.12784988f, -0.12234176f, 
    0.01093525f, 0.05599289f, 0.01623471f, -0.08699548f, 0.19183290f, 0.16331764f, -0.23684692f, 0.05121679f, 
    -0.20726496f, -0.06838589f, 0.18541512f, 0.03773686f, -0.18456960f, -0.00971823f, -0.03870053f, 0.19440758f, 
    0.08915665f, 0.06202223f, -0.23131180f, -0.10667885f, -0.10765846f, 0.12982717f, -0.12880275f, -0.10436033f, 
    -0.17086017f, -0.12408999f, -0.10144433f, -0.00273262f, 0.00245192f, 0.02816365f, -0.00508860f, 0.03955352f, 
    0.04926249f, 0.01876302f, -0.17105971f, 0.06628595f, 0.05174465f, 0.04655662f, 0.03518167f, 0.02415808f, 
    -0.01285753f, 0.00362889f, -0.03654340f, -0.00813974f, 0.01971614f, 0.03934641f, 0.00041763f, 0.04687726f, 
    -0.00992751f, 0.05721890f, 0.00283526f, 0.00533971f, 0.01975827f, -0.03578128f, 0.02303475f, -0.00943384f, 
    0.01551989f, 0.02400458f, -0.02837913f, -0.00191310f, -0.05498718f, 0.02328212f, 0.03874548f, 0.01246511f, 
    0.38218358f, -0.24628514f, -0.26982853f, 0.19691500f, -0.15830736f, 0.06122310f, 0.11220598f, 0.02758151f, 
    0.13202570f, 0.17934260f, 0.02583423f, 0.02461757f, -0.01139697f, -0.02515038f, -0.02611362f, -0.01058731f, 
    -0.01733597f, 0.01936538f, -0.00842283f, -0.14300266f, 0.17967974f, -0.08533545f, -0.13141789f, -0.12651780f, 
    -0.09607770f, 0.04589529f, -0.00243182f, 0.01538348f, -0.01768376f, -0.01101249f, -0.02669466f, 0.02861871f, 
    0.09326746f, 0.03537016f, 0.03137903f, 0.03119313f, 0.02507954f, 0.00326549f, 0.02051328f, 0.00078886f, 
    -0.10572527f, -0.25278425f, -0.06069517f, 0.03744953f, 0.04752638f, 0.02025224f, 0.05304708f, 0.18238205f, 
    0.02392795f, -0.02712834f, 0.02778421f, 0.00429500f, -0.00770020f, 0.04463944f, 0.04231958f, -0.09077658f, 
    0.01751811f, -0.23450330f, 0.02919342f, 0.08689309f, 0.03096493f, 0.12671947f, 0.03444223f, 0.03158044f, 
    -0.02616192f, -0.02884269f, 0.06913443f, -0.00653941f, 0.00603837f, -0.02247667f, -0.00839195f, 0.01868080f, 
    0.01393394f, -0.06397700f, -0.16781077f, -0.12901536f, 0.01735854f, 0.05917171f, -0.01921435f, -0.01488102f, 
    -0.30322060f, -0.36273366f, 0.28626725f, 0.06211142f, 0.10353439f, 0.07157099f, -0.02295200f, -0.02456011f, 
    -0.00441887f, 0.02674406f, 0.01898336f, -0.03373990f, -0.03438256f, -0.01974546f, -0.01450603f, 0.05751621f, 
    -0.00293406f, -0.09153620f, -0.12136625f, 0.01257716f, 0.06213387f, 0.09030371f, 0.04862526f, -0.04364929f, 
    -0.05909299f, -0.04390329f, 0.01905921f, 0.03959266f, -0.00586122f, -0.07047530f, 0.01985478f, 0.01940048f, 
    -0.04522072f, -0.09554315f, -0.06839038f, -0.04272658f, -0.00035106f, -0.03790741f, 0.01474933f, -0.00566062f, 
    0.53409052f, 0.04159153f, -0.25672975f, -0.17711833f, -0.30363089f, -0.08950111f, -0.19591564f, -0.10209148f, 
    -0.13391921f, -0.01926985f, -0.05630349f, -0.10314055f, -0.06605949f, -0.01014219f, -0.04017709f, 0.02764600f, 
    -0.00243852f, 0.04690021f, 0.03686247f, 0.01811814f, 0.34646398f, -0.51990044f, -0.38562739f, -0.43256500f, 
    -0.29305115f, 0.06225537f, 0.07936059f, -0.14522210f, 0.22513664f, 0.04401770f, -0.00605228f, 0.01754872f, 
    -0.03896375f, -0.02924296f, -0.01400918f, -0.10245297f, -0.04666847f, -0.03438115f, 0.00330189f, -0.02582137f, 
    -0.06124373f, 0.14841956f, -0.09103253f, 0.00962910f, -0.07880291f, -0.02464281f, -0.01892556f, -0.02680223f, 
    -0.06801669f, -0.07321879f, 0.07332343f, 0.04040594f, 0.02185885f, 0.00497277f, 0.01665817f, -0.00688301f, 
    -0.12380523f, 0.02917776f, 0.01709891f, 0.00510459f, -0.46247971f, -0.14883302f, 0.23295732f, 0.23937953f, 
    0.14424506f, 0.06421099f, 0.13035178f, -0.00820277f, 0.03814097f, 0.06208509f, 0.01626339f, -0.01572687f, 
    0.05521734f, -0.01849139f, 0.01771794f, 0.01925117f, 0.10654312f, -0.17250562f, 0.07984820f, -0.02166672f, 
    0.05286706f, 0.09025347f, 0.03783724f, -0.10703177f, -0.07175495f, 0.00303199f, 0.04006126f, -0.02707056f, 
    -0.04653058f, -0.03358647f, -0.06051151f, -0.10428506f, -0.11560251f, -0.15582648f, -0.08967976f, 0.00378577f, 
    -0.02823609f, -0.05653383f, 0.01232671f, 0.01561757f, -0.19316560f, 0.09839942f, -0.28606680f, 0.02513261f, 
    0.04670429f, 0.11181425f, 0.04001362f, 0.06300777f, -0.14811715f, -0.03403378f, -0.05026378f, 0.14972599f, 
    0.03629387f, 0.06052781f, 0.19301690f, 0.04285091f, -0.06242742f, 0.08104396f, -0.11892638f, 0.06997617f, 
    -0.44871342f, 0.19323006f, 0.02038966f, 0.03844848f, -0.04295697f, 0.03872217f, -0.16026674f, -0.06998730f, 
    0.10114014f, 0.06087638f, 0.06981075f, 0.04033763f, 0.05928384f, -0.00614878f, 0.06489323f, 0.11533599f, 
    -0.10007058f, -0.05660563f, -0.11980417f, 0.09438157f, 0.48201296f, 0.10303808f, -0.25705057f, -0.23908865f, 
    -0.14485839f, 0.14729923f, -0.19351189f, -0.25027260f, 0.01460907f, -0.11380827f, 0.03299167f, 0.07486785f, 
    0.01399297f, -0.03420512f, 0.04962278f, 0.00856707f, 0.00085990f, 0.01867678f, 0.09441198f, -0.08352733f, 
    0.05449584f, 0.09871209f, 0.03206868f, 0.02415245f, -0.09436713f, 0.00297716f, 0.05162818f, -0.08580918f, 
    -0.09086879f, -0.08270723f, 0.02173834f, 0.07282423f, 0.03064875f, -0.01176900f, -0.00334822f, -0.18558706f, 
    -0.11432500f, 0.00813542f, -0.00502583f, 0.04553345f, 0.01305280f, -0.15125456f, -0.03902255f, 0.20032473f, 
    -0.24118800f, 0.08389118f, 0.04287142f, 0.01848299f, 0.13653003f, -0.00343437f, 0.02467212f, -0.01277612f, 
    0.00348048f, -0.03104762f, -0.00375721f, 0.00951429f, 0.03206463f, -0.01976598f, -0.04661122f, -0.10896306f, 
    -0.59306717f, -0.47129279f, 0.06662916f, 0.14206903f, 0.26655790f, 0.01597115f, 0.03637948f, 0.04327558f, 
    0.04444976f, 0.09616777f, -0.00543569f, 0.03073574f, -0.07188006f, -0.04796150f, -0.05399369f, 0.04582005f, 
    -0.01359033f, 0.00906638f, 0.02953247f, -0.04130562f, 0.03869513f, 0.00930292f, 0.03541638f, 0.06538168f, 
    0.00800729f, 0.01811124f, 0.02035644f, -0.02160863f, 0.00422071f, -0.01594369f, 0.00166807f, 0.06218283f, 
    0.08778726f, -0.01312900f, -0.03342778f, -0.06973577f, -0.00284313f, -0.04876456f, -0.02723036f, -0.00703908f, 
    0.10846506f, 0.13365453f, -0.00581096f, -0.01549678f, -0.09715591f, -0.01892874f, 0.04593834f, -0.02179252f, 
    -0.00091413f, -0.07186724f, -0.05860238f, -0.12806179f, -0.09269744f, -0.13659790f, -0.13816206f, 0.03019825f, 
    0.01466060f, 0.01148810f, -0.00186589f, 0.04095621f, 0.16169839f, 0.12210226f, -0.22174670f, -0.04513384f, 
    -0.15360765f, 0.02878382f, 0.06221607f, -0.01992542f, 0.05819340f, 0.00524102f, -0.09716126f, 0.12121702f, 
    0.06351724f, -0.00496482f, -0.02423970f, 0.06646104f, -0.05536604f, 0.00658514f, -0.11709657f, -0.02869891f, 
    -0.38390735f, -0.24290065f, -0.32763791f, -0.03711943f, 0.06102900f, 0.13325106f, -0.08936591f, 0.04714710f, 
    0.03918738f, 0.07761867f, 0.01183877f, 0.00132084f, -0.10135229f, -0.11125464f, -0.05261498f, 0.01675128f, 
    -0.01373638f, -0.11184631f, 0.08008352f, -0.00748698f, 0.02149631f, 0.09124567f, 0.07048841f, 0.16542111f, 
    -0.18284313f, 0.01817623f, 0.07455385f, 0.00441604f, -0.00565203f, -0.01582476f, -0.00673654f, 0.03644673f, 
    0.06620888f, -0.02854400f, -0.02062244f, -0.00494363f, -0.01347167f, 0.08222623f, -0.06492284f, 0.00051327f, 
    -0.21304986f, -0.34244800f, -0.23789942f, 0.28460246f, -0.17567930f, 0.03797837f, 0.04593597f, 0.02641133f, 
    -0.01089410f, 0.08209637f, -0.01208981f, -0.04440986f, -0.10734183f, -0.12313406f, -0.06676146f, 0.00047220f, 
    0.07096528f, -0.10855044f, -0.01838655f, 0.03159350f, -0.54246634f, -0.64376718f, 0.08527424f, 0.51364428f, 
    -0.06598455f, -0.04535350f, 0.16475721f, -0.07401889f, -0.00743884f, 0.08020869f, -0.03204411f, -0.06549955f, 
    0.00727502f, -0.00436268f, -0.01219297f, 0.04766086f, 0.00132215f, -0.12009085f, 0.04524815f, -0.11312480f, 
    -0.35320431f, -0.34792867f, 0.43051958f, -0.04586242f, 0.26017407f, 0.05996082f, -0.01067255f, 0.22546218f, 
    -0.01829766f, -0.00682378f, -0.13403678f, 0.08131961f, 0.07077055f, 0.14452600f, -0.05129248f, -0.12587872f, 
    0.05348491f, -0.00340737f, -0.00234156f, 0.07784947f, -0.20582333f, -0.50030041f, -0.09303502f, 0.24727270f, 
    0.09918618f, -0.02294518f, 0.16062649f, 0.07597834f, 0.04773778f, 0.06705954f, 0.02597544f, 0.00321431f, 
    -0.00777884f, -0.03277296f, -0.00809518f, 0.07149966f, -0.00106620f, -0.06027968f, 0.19911051f, 0.05777158f, 
    0.49466383f, -0.37791881f, -0.18746477f, -0.17542286f, -0.14968805f, 0.09476229f, -0.04387590f, 0.23158257f, 
    0.16411722f, -0.03435398f, 0.01894329f, 0.03832002f, 0.00542817f, -0.03721821f, 0.01761709f, 0.03137656f, 
    -0.08112109f, 0.06385315f, 0.00235936f, 0.00071252f, 0.05804078f, 0.01969318f, 0.05948246f, -0.01501081f, 
    0.10954393f, 0.00696388f, 0.00566880f, -0.08064748f, -0.03809131f, -0.05185907f, 0.08384426f, -0.02609541f, 
    -0.01219596f, 0.02632456f, -0.08229241f, -0.00321697f, 0.05355719f, 0.07902901f, 0.06273144f, -0.03956664f, 
    -0.08352201f, 0.08064218f, -0.01114843f, -0.02275828f, -0.11860942f, 0.06872299f, 0.02434943f, 0.01113926f, 
    -0.02947139f, 0.03329821f, 0.03353605f, 0.00049290f, 0.05063530f, 0.02475027f, -0.01912085f, 0.12726980f, 
    0.08651304f, -0.03090473f, -0.11452054f, -0.05047953f, 0.42177582f, -0.39264536f, -0.34828469f, -0.33752722f, 
    -0.28370088f, -0.00988140f, -0.16382597f, -0.00640329f, 0.07367443f, -0.07432325f, -0.03223681f, 0.02775140f, 
    0.02067352f, -0.01154982f, 0.01679795f, 0.02295318f, 0.01898427f, 0.00921469f, 0.03213193f, 0.02086391f, 
    0.06483217f, -0.03255847f, -0.09587734f, 0.02969739f, -0.13782783f, -0.01080001f, 0.05609670f, -0.03927058f, 
    0.02466877f, 0.02153310f, -0.06663649f, -0.03409148f, -0.01913658f, -0.05628885f, -0.03840747f, 0.04845260f, 
    0.01626274f, -0.11316905f, -0.03205017f, 0.14715528f, 0.11333761f, -0.42914638f, -0.08466704f, 0.08298121f, 
    -0.16764595f, -0.02649225f, 0.08566611f, 0.01138596f, 0.00273609f, -0.15071446f, 0.02513399f, -0.00491239f, 
    -0.12532589f, 0.02069958f, -0.01136192f, -0.07276879f, 0.03904525f, 0.01331483f, -0.07656986f, -0.19716254f, 
    -0.02538846f, 0.04591907f, 0.05420172f, -0.00704097f, 0.00031385f, 0.03882463f, 0.03972903f, 0.02285711f, 
    -0.00391822f, -0.02841367f, 0.00999267f, -0.02013872f, -0.04008941f, -0.09251933f, -0.12432328f, -0.04244286f, 
    -0.01896929f, 0.04694692f, -0.07631759f, 0.02698934f, 0.14492333f, -0.64325273f, -0.30588624f, -0.32814801f, 
    -0.29758784f, -0.01505011f, -0.04233552f, 0.05166171f, 0.26645708f, -0.04623327f, 0.03512136f, 0.03914597f, 
    -0.06619599f, -0.01075252f, 0.04202191f, -0.13169938f, -0.00328299f, -0.18891302f, 0.07538992f, 0.08160881f, 
    -0.11570169f, -0.62268221f, -0.00874152f, -0.06138767f, 0.18519813f, -0.17527764f, 0.11705012f, 0.07001372f, 
    0.08051353f, 0.03324248f, 0.00555526f, -0.02333071f, -0.01031146f, 0.01460271f, -0.05536638f, 0.02252359f, 
    -0.03657754f, -0.08228253f, -0.01165908f, -0.09395570f, -0.11188524f, -0.11075601f, -0.10049435f, -0.10244077f, 
    -0.08445469f, -0.09945092f, -0.01416483f, -0.06724797f, -0.01019476f, -0.01657065f, 0.11728532f, -0.00646373f, 
    0.12394262f, -0.02479594f, 0.08799808f, -0.03745860f, 0.04452176f, 0.03898660f, 0.05744786f, 0.05306723f, 
    -0.13534138f, -0.10534415f, -0.02724716f, 0.05612021f, -0.08906543f, -0.03569815f, -0.07981113f, -0.13529508f, 
    -0.04880921f, -0.06985907f, 0.02533997f, 0.04224580f, 0.06708089f, 0.13288899f, -0.01272199f, 0.03729605f, 
    0.08048944f, 0.12669101f, 0.10709567f, 0.09985565f, 0.42524362f, 0.26740819f, 0.12022436f, -0.05051129f, 
    -0.12413245f, 0.08529808f, -0.12720105f, -0.09838484f, 0.02955139f, -0.31861028f, -0.01407312f, 0.03822343f, 
    0.01940931f, -0.02733207f, -0.00307501f, -0.02506351f, 0.02661697f, -0.13270085f, -0.00211452f, -0.08632550f, 
    -0.03908720f, 0.08388650f, 0.02654621f, -0.00424323f, -0.01322429f, -0.04143345f, -0.04747612f, -0.09369017f, 
    -0.03098793f, -0.13148367f, -0.07979040f, 0.00828804f, 0.04595059f, -0.01093271f, 0.06161865f, -0.06412582f, 
    0.04941753f, 0.17774941f, 0.15932579f, 0.07754207f, 0.17784372f, 0.24393845f, -0.13212253f, -0.10364332f, 
    -0.17027013f, 0.04431619f, 0.11057122f, 0.06542896f, 0.22390503f, 0.02063725f, 0.13040033f, 0.01261794f, 
    -0.03070533f, 0.03973755f, 0.07377103f, 0.06480734f, 0.06644127f, 0.05204432f, 0.02841250f, 0.01634965f, 
    0.08983873f, 0.03474993f, 0.00788614f, -0.01971310f, -0.17860663f, -0.05726715f, -0.07447322f, -0.10599072f, 
    -0.03406236f, -0.09225717f, -0.04307803f, -0.00542826f, 0.00960140f, 0.01823317f, 0.02033218f, 0.01541741f, 
    0.11287258f, 0.08918817f, 0.13447216f, 0.09039154f, 0.00834454f, -0.15974292f, -0.32279402f, -0.34972265f, 
    -0.09997030f, -0.11198540f, -0.25308445f, 0.07500655f, -0.06854834f, -0.22130017f, 0.02966231f, -0.01684958f, 
    -0.02313893f, 0.00090429f, 0.05944746f, 0.03894828f, 0.02326882f, 0.09363332f, -0.12332587f, -0.27118108f, 
    0.78198129f, 0.27921155f, -0.04572298f, 0.00061229f, -0.02482388f, 0.06679153f, 0.07610399f, -0.01442415f, 
    0.06571074f, -0.04989162f, 0.09549154f, -0.01131319f, 0.04622740f, -0.01599661f, 0.07176497f, -0.00752239f, 
    -0.16302282f, -0.16040914f, -0.00476419f, -0.10883141f, 0.04995634f, -0.16589320f, -0.26162547f, -0.17286839f, 
    -0.02098631f, 0.00946676f, -0.06204398f, -0.02035449f, 0.04781111f, 0.10169372f, -0.02456501f, -0.05015648f, 
    0.00446505f, -0.05441096f, -0.01548324f, -0.06570492f, 0.01638483f, 0.04123385f, 0.05165034f, 0.04254235f, 
    -0.18778902f, -0.15206997f, 0.02137307f, -0.02910047f, -0.00998352f, -0.01580183f, 0.06883724f, 0.00052863f, 
    -0.00882509f, 0.09417155f, 0.08444800f, 0.05161325f, 0.04386954f, 0.09976384f, 0.07835454f, -0.02500145f, 
    0.06995086f, -0.03588508f, 0.13625050f, 0.09048725f, -0.17624934f, -0.44971740f, -0.38413659f, -0.20124558f, 
    -0.17776395f, -0.16606683f, 0.05700116f, 0.12141830f, 0.09242131f, 0.05114547f, 0.12312409f, 0.03333333f, 
    0.02011876f, -0.03029735f, -0.03165352f, 0.02415661f, 0.01455095f, 0.04048176f, 0.06173623f, -0.02470510f, 
    0.20895088f, -0.11796389f, 0.06118190f, 0.08195835f, -0.05432229f, 0.07181125f, 0.02769243f, -0.03035695f, 
    0.03449979f, 0.04919881f, 0.00765536f, -0.01037705f, -0.05119599f, 0.06537064f, 0.05378189f, 0.12388586f, 
    0.19171198f, -0.01805490f, -0.03161518f, 0.04059801f, -0.01842027f, -0.33488768f, -0.03143424f, 0.10681301f, 
    0.14116079f, -0.01472129f, 0.15614705f, 0.01453711f, 0.23189268f, 0.00508723f, 0.01690281f, 0.13538627f, 
    0.09039750f, 0.01339542f, 0.18520071f, 0.00480883f, -0.05773694f, -0.08435429f, 0.02615911f, 0.10016970f, 
    0.04277239f, -0.20957805f, -0.14960791f, -0.14804640f, 0.01224096f, -0.14636305f, -0.04317611f, -0.02361753f, 
    0.06596357f, 0.00414776f, 0.07542230f, -0.04749459f, -0.00078564f, -0.11520199f, -0.10176720f, 0.03331301f, 
    -0.03249266f, -0.03965971f, -0.06891982f, -0.12582199f, 0.12803927f, -0.49794593f, -0.48059362f, -0.30320638f, 
    -0.05701613f, -0.14019413f, -0.24801651f, -0.02557731f, 0.08771326f, -0.08099822f, -0.00007253f, -0.03461058f, 
    -0.00588767f, -0.02311833f, 0.03040342f, -0.00189069f, 0.04259224f, 0.06186035f, -0.04267688f, 0.05196259f, 
    -0.28947523f, -0.09840452f, 0.07778241f, 0.11742453f, 0.01823093f, -0.01475482f, -0.00548441f, 0.01378867f, 
    0.03165691f, 0.06714060f, -0.03551434f, -0.00689787f, 0.01176796f, 0.07682210f, 0.04164857f, -0.03633954f, 
    0.07241344f, 0.03332870f, 0.07190505f, 0.11407456f, 0.14084697f, -0.27675301f, -0.03918201f, 0.25595835f, 
    0.21340664f, 0.04023529f, 0.06838763f, 0.06361303f, 0.09775311f, 0.04067205f, 0.06028762f, -0.02023187f, 
    0.11796717f, 0.01550504f, 0.02832080f, -0.04828052f, -0.06473037f, -0.09858228f, -0.31899592f, -0.20282117f, 
    -0.10527425f, -0.28559339f, -0.89098614f, -0.15128087f, 0.17591104f, 0.03048600f, 0.10185909f, 0.23389950f, 
    0.06957194f, 0.04646815f, -0.01342442f, -0.12800288f, -0.10684520f, 0.03176684f, 0.03747696f, 0.04533349f, 
    -0.03534598f, 0.08412800f, -0.10172750f, -0.08156064f, -0.06585057f, 0.16471435f, 0.11583017f, 0.01050663f, 
    -0.27913591f, -0.01440926f, -0.21392743f, -0.01409406f, -0.04826726f, -0.20412533f, -0.03199885f, 0.03240969f, 
    0.02086280f, -0.00928198f, 0.07380395f, -0.11372912f, 0.05873050f, 0.16895130f, 0.09595872f, 0.00925079f, 
    0.02983144f, 0.06680486f, -0.27090019f, -0.16639297f, -0.07119198f, 0.05552384f, 0.04332317f, -0.01365218f, 
    -0.09392824f, -0.04162098f, 0.01085203f, 0.00815866f, -0.05253072f, 0.11479066f, 0.19459830f, 0.01374201f, 
    -0.00218861f, 0.06132203f, -0.24164513f, -0.14407547f, -0.05894969f, -0.29754636f, 0.10979698f, -0.03690856f, 
    -0.09791438f, 0.07454863f, 0.09414124f, -0.03024046f, 0.00454560f, -0.18633348f, 0.02913956f, -0.01725937f, 
    0.04304246f, 0.01553167f, 0.06346189f, 0.03633844f, -0.03914949f, -0.15108709f, -0.01117289f, -0.39282954f, 
    0.04606453f, -0.06828715f, 0.01230250f, -0.09969637f, -0.09579865f, -0.10473814f, 0.09009741f, -0.02828980f, 
    0.08383940f, -0.07574795f, 0.00364468f, 0.14006004f, 0.06563188f, 0.07523690f, 0.11235809f, 0.04432606f, 
    0.05230106f, -0.03487101f, 0.09051562f, -0.01261579f, 0.35452431f, -0.43651456f, -0.33428884f, 0.04165225f, 
    0.03713785f, 0.07162689f, 0.04345552f, 0.02104547f, 0.12048631f, 0.00096824f, -0.00049661f, 0.04647071f, 
    0.00194035f, -0.00011228f, 0.02840165f, -0.00656314f, 0.11035138f, 0.10778826f, 0.18215518f, 0.01348128f, 
    -0.12387988f, -0.03801416f, -0.03040500f, 0.22798958f, 0.19434786f, -0.02147259f, -0.14376161f, 0.04235555f, 
    -0.02727789f, 0.02403153f, 0.13781212f, -0.02884651f, 0.02324413f, -0.02897502f, -0.01604750f, -0.06760465f, 
    0.06307001f, -0.12313114f, -0.19973528f, -0.02832036f, -0.10306197f, -0.13111003f, -0.17004573f, -0.13600428f, 
    -0.14694317f, -0.04573803f, -0.04812026f, -0.00264752f, -0.01627977f, -0.05174202f, 0.05008081f, 0.06774917f, 
    0.04535622f, -0.00264306f, 0.09883214f, 0.00683814f, -0.00022378f, -0.03221274f, -0.03160723f, 0.08248708f, 
    0.00657875f, 0.11563588f, -0.10711701f, 0.10232176f, 0.05059541f, 0.20064072f, -0.08853908f, 0.23287868f, 
    0.17037223f, -0.05413624f, 0.00739677f, 0.01479990f, 0.08189543f, 0.01473977f, 0.05595290f, -0.13474081f, 
    -0.00792008f, -0.04730890f, -0.11382563f, -0.19599266f, 0.18487339f, 0.05981129f, -0.07868122f, -0.00305120f, 
    -0.25411296f, 0.03288976f, 0.02808069f, 0.14221598f, 0.05124063f, 0.04088538f, 0.03635289f, -0.01526084f, 
    -0.03251053f, -0.05322608f, 0.05388404f, 0.08734106f, 0.07527442f, 0.09917209f, 0.21080910f, -0.02877114f, 
    -0.13833657f, -0.21301493f, -0.15901817f, 0.02763974f, 0.07764690f, -0.06089043f, 0.02419952f, 0.00876424f, 
    0.04739030f, 0.06477639f, 0.01463888f, 0.02110883f, -0.10138983f, -0.00790090f, -0.01530178f, -0.01748882f, 
    0.08253659f, 0.08616472f, 0.11337583f, 0.08193528f, -0.13549167f, 0.00078175f, 0.04285033f, 0.00856172f, 
    -0.07084978f, -0.00031968f, -0.02220154f, -0.04427430f, -0.07016356f, -0.01116821f, 0.02607970f, 0.02504924f, 
    0.02176252f, 0.05836888f, 0.05289561f, -0.01370679f, 0.06416398f, 0.09988070f, 0.09271529f, 0.07463904f, 
    -0.27423686f, -0.39089507f, -0.47431296f, -0.48775035f, -0.12650882f, -0.00794246f, -0.02822872f, -0.10106603f, 
    0.06185388f, -0.07267419f, 0.04248918f, -0.03169155f, -0.02412704f, 0.04038016f, 0.00190316f, 0.03416282f, 
    0.02403552f, 0.00307217f, 0.07833173f, 0.06348086f, -0.03395767f, -0.16542272f, -0.24569255f, -0.07118672f, 
    -0.02541829f, -0.07363835f, 0.04064605f, 0.04714244f, 0.00679205f, 0.12229447f, 0.08381063f, -0.01559780f, 
    -0.03700180f, -0.05062744f, -0.04190223f, -0.01329539f, 0.06518817f, 0.04015367f, 0.09473238f, 0.03527351f, 
    -0.02079540f, -0.32035074f, 0.05689785f, 0.18083151f, 0.16255133f, -0.01311711f, -0.02234906f, -0.05002794f, 
    -0.10029618f, 0.00456597f, 0.07940914f, -0.06505635f, -0.11976934f, 0.12522918f, 0.01478261f, 0.03341484f, 
    -0.04461929f, 0.05831239f, -0.11392855f, -0.06758635f, -0.02053468f, -0.04035611f, 0.01664868f, 0.02427758f, 
    -0.09804960f, -0.01051814f, 0.04977230f, 0.02566972f, 0.03190598f, 0.06531069f, -0.03233177f, -0.02642586f, 
    0.02818118f, 0.03484973f, 0.03111150f, 0.06135757f, 0.05728996f, 0.09032276f, 0.03240471f, 0.05650412f, 
    0.08514678f, -0.21213461f, -0.06521638f, 0.18104680f, 0.08446522f, 0.13759592f, 0.00051211f, -0.17027625f, 
    -0.05287784f, 0.01154557f, 0.07324041f, 0.00609131f, 0.10298500f, 0.02450812f, -0.04646546f, 0.00612724f, 
    0.01120360f, 0.08315758f, -0.04156421f, 0.17955944f, -0.05497455f, 0.09524265f, 0.01163651f, 0.03581265f, 
    -0.06897910f, -0.01443291f, 0.00953098f, 0.02976749f, 0.02476204f, -0.05473566f, -0.04548563f, 0.07936703f, 
    0.04471873f, 0.01205286f, 0.12023976f, -0.09008698f, 0.03199912f, 0.01482195f, 0.06876084f, 0.05842167f, 
    0.00788757f, -0.38262859f, -0.17106205f, -0.13148355f, -0.00309091f, -0.09984601f, 0.11622038f, 0.05443930f, 
    0.13494699f, 0.00369168f, 0.05045136f, -0.00264831f, 0.00512420f, -0.03792517f, -0.02951854f, 0.03335927f, 
    -0.01534570f, -0.02407708f, 0.04951283f, -0.06097896f, -0.05587802f, -0.29219463f, -0.66814518f, -0.41815767f, 
    -0.06066673f, 0.09148461f, -0.00361942f, 0.17775682f, 0.14899978f, 0.00742161f, -0.00950782f, -0.05506550f, 
    -0.05398745f, 0.04959731f, 0.02732932f, 0.05188698f, 0.02055407f, 0.03471916f, -0.03573488f, 0.03139035f, 
    -0.10695950f, 0.12108385f, 0.12967633f, 0.09408105f, -0.07356225f, 0.06158476f, 0.02315638f, -0.04733798f, 
    0.01446119f, -0.05956350f, -0.01762948f, -0.00894162f, 0.00316717f, 0.00615780f, 0.00423592f, 0.02411685f, 
    0.04761270f, 0.06080218f, 0.04823179f, -0.03911378f, -0.10360947f, -0.01131653f, 0.10498206f, 0.03785602f, 
    0.07363530f, 0.10873424f, -0.11618931f, -0.04750069f, -0.16207628f, -0.24698867f, -0.00618006f, 0.00028009f, 
    0.02187855f, -0.01432411f, 0.05389997f, 0.03787046f, 0.02766322f, 0.11444011f, -0.18904589f, -0.21446067f, 
    -0.03357166f, 0.01369528f, -0.00363794f, -0.02580214f, 0.02007870f, -0.02423326f, 0.02560864f, 0.01854115f, 
    0.02038114f, 0.02220826f, 0.05518827f, 0.03286381f, 0.03413853f, 0.02289700f, 0.06346507f, 0.01992992f, 
    0.01121225f, 0.00540696f, 0.06817392f, 0.05854084f, -0.65984261f, -0.35150945f, 0.13436955f, 0.03456900f, 
    0.37118253f, 0.03054262f, 0.20766985f, -0.01722755f, 0.06281349f, 0.06282001f, 0.10561477f, -0.04812146f, 
    0.17129265f, 0.19424587f, 0.03841330f, 0.00921661f, -0.03289265f, -0.00100339f, 0.05549821f, -0.03645113f, 
    -0.65348393f, -0.15756620f, 0.09809054f, 0.19546020f, 0.03008890f, 0.02434049f, 0.11426603f, -0.04370921f, 
    0.10342475f, 0.06156504f, -0.03779003f, 0.01402921f, 0.01666338f, -0.01784981f, -0.01899466f, -0.00570619f, 
    -0.03015612f, -0.02085462f, 0.05497496f, 0.02995070f, 0.05283205f, -0.16126700f, -0.54448622f, -0.54405338f, 
    -0.12316622f, 0.07779501f, -0.02123752f, 0.06239931f, 0.13155022f, -0.04088093f, 0.12762430f, -0.03034494f, 
    0.14546625f, 0.01698333f, 0.09424464f, -0.03059513f, -0.05678602f, -0.08228634f, 0.08797535f, -0.03937472f, 
    0.08158837f, 0.30974072f, 0.06743030f, 0.06415953f, -0.09774397f, -0.00626388f, -0.05549438f, 0.00866458f, 
    0.01353375f, -0.12127264f, -0.00156470f, -0.01429485f, 0.00964128f, -0.04635426f, -0.00350583f, -0.02057604f, 
    0.09351410f, 0.04487283f, 0.10320033f, -0.01122726f, 0.36543122f, 0.04478518f, -0.02933589f, -0.12292212f, 
    -0.07222760f, 0.06913599f, -0.08939073f, -0.09065095f, -0.07136934f, -0.20980769f, -0.03010102f, 0.05654392f, 
    0.06240189f, -0.00336432f, 0.04497770f, -0.04912055f, 0.04468912f, 0.18792719f, 0.22044843f, 0.14786477f, 
    0.21600482f, -0.38112625f, -0.11075049f, 0.01580165f, 0.05848846f, 0.12310755f, 0.07174212f, -0.03385745f, 
    -0.01348772f, -0.13415058f, 0.04743013f, 0.00653216f, 0.09183109f, 0.04333551f, 0.07403908f, 0.06773981f, 
    0.03385492f, 0.04673873f, -0.00111436f, -0.05392099f, -0.12191676f, 0.06125615f, 0.10536842f, 0.05917108f, 
    -0.10312228f, -0.05383858f, -0.04838439f, -0.03997244f, 0.03909300f, -0.05334748f, -0.04112994f, -0.01873402f, 
    -0.02756948f, 0.02828779f, -0.01467056f, -0.11220041f, -0.04818454f, -0.10659124f, -0.08294163f, -0.02591198f, 
    -0.06231198f, 0.01050624f, 0.01378563f, -0.08390051f, -0.14655915f, -0.07728724f, 0.04973532f, -0.01477514f, 
    0.04375563f, -0.02247740f, 0.11641243f, 0.08844817f, 0.09132940f, 0.04028237f, 0.07822099f, 0.00395736f, 
    -0.00594903f, 0.00640043f, 0.00954221f, 0.06651030f, 0.17666739f, 0.15653123f, 0.13366230f, 0.02969229f, 
    -0.26535892f, -0.02809096f, -0.05707619f, -0.03427767f, 0.03403359f, -0.11533274f, 0.08097610f, -0.06330121f, 
    -0.08176576f, 0.06396117f, -0.01312222f, 0.03294782f, -0.10412065f, -0.04275996f, -0.13218193f, -0.05427419f, 
    0.17824061f, -0.15963016f, -0.32314423f, -0.27270222f, -0.04871704f, -0.15631716f, -0.03868639f, -0.00271649f, 
    -0.07532002f, -0.18493369f, 0.04115841f, -0.02437237f, -0.02369583f, 0.08159023f, 0.12303456f, 0.09212963f, 
    0.04483273f, 0.05877556f, -0.09833795f, -0.28857958f, -0.07992187f, 0.17880426f, 0.14649141f, 0.00952644f, 
    -0.23616247f, -0.09789721f, -0.04223569f, -0.08082083f, 0.01230074f, -0.04056244f, -0.15447232f, -0.01903103f, 
    -0.00012520f, -0.06447805f, -0.01380489f, -0.03633496f, -0.02461307f, -0.16987908f, -0.03345674f, -0.05688616f, 
    0.18043651f, 0.00071362f, -0.07593956f, -0.19799492f, -0.01482543f, -0.02281732f, -0.13973063f, -0.10409340f, 
    -0.09366789f, -0.15081795f, 0.04858068f, -0.00108907f, 0.02634998f, 0.09209042f, 0.04649244f, 0.09813783f, 
    0.03346013f, 0.03737799f, -0.11303779f, -0.24564670f, 0.40276325f, -0.06749471f, -0.13899708f, -0.25471380f, 
    -0.31833011f, 0.03392627f, -0.19711463f, -0.02930918f, 0.08325450f, -0.02891880f, -0.04846267f, 0.13483304f, 
    0.04327709f, -0.02596116f, 0.05037485f, 0.02693788f, 0.10605282f, 0.12015681f, 0.15562938f, 0.07563686f, 
    -0.36783394f, -0.70963222f, 0.15352875f, 0.17696369f, 0.25629216f, -0.11807470f, 0.07085143f, -0.04269496f, 
    -0.09113868f, 0.02515506f, -0.02569941f, -0.01817060f, 0.00330889f, 0.11372528f, 0.10710609f, -0.04815308f, 
    -0.04664426f, -0.00542536f, -0.10678086f, 0.01246553f, 0.22263946f, -0.50251377f, -0.47746861f, -0.13279249f, 
    -0.07933036f, -0.01192809f, -0.09900176f, 0.00627326f, -0.07359948f, 0.05893783f, -0.05785720f, 0.04589587f, 
    0.00264650f, -0.02452794f, 0.01006961f, 0.04106986f, 0.04300996f, 0.10202907f, -0.02410653f, 0.16727425f, 
    -0.24580380f, -0.52599537f, -0.58569759f, -0.31180844f, -0.04282083f, -0.04153029f, 0.03099161f, 0.20518190f, 
    -0.07455889f, -0.09037453f, -0.04720537f, -0.07760447f, -0.04338302f, -0.05756862f, 0.03740335f, 0.03685040f, 
    0.02187151f, -0.00553513f, 0.12019769f, 0.05084682f, 0.11162607f, -0.08373988f, -0.00125796f, -0.01172038f, 
    -0.03074780f, 0.04407640f, -0.02874097f, 0.00472535f, -0.06792101f, -0.00726287f, 0.04551706f, 0.00649271f, 
    -0.01462434f, -0.00346955f, -0.01189097f, 0.03540337f, 0.06147466f, 0.06878888f, -0.09048090f, 0.12096904f, 
    -0.66667140f, 0.08256900f, 0.26523310f, 0.15379402f, -0.09207661f, -0.00997812f, -0.10952005f, -0.12984304f, 
    -0.11752217f, -0.07963009f, -0.03938179f, -0.01343230f, -0.00458967f, -0.07094295f, -0.06793929f, -0.08622973f, 
    -0.17661281f, -0.07542738f, -0.21407300f, -0.20215456f, 0.04725862f, -0.33879203f, -0.49394044f, -0.23758799f, 
    0.08590491f, 0.02947091f, 0.17219292f, 0.11248100f, 0.07647681f, 0.12818965f, 0.10381708f, -0.05339896f, 
    -0.09692977f, -0.10926165f, -0.02480554f, 0.02507974f, -0.00444076f, 0.00337975f, 0.05054507f, 0.00837944f, 
    0.15143715f, 0.16793062f, 0.07151528f, 0.08089202f, -0.23511691f, -0.09754013f, -0.09423654f, -0.08389439f, 
    -0.01017869f, -0.04331687f, -0.00287383f, 0.09385797f, 0.01485196f, 0.05421883f, 0.04668397f, -0.17153504f, 
    -0.20057571f, -0.01881132f, -0.23370266f, -0.20501035f, 0.27450076f, 0.02515378f, -0.27401784f, -0.10922205f, 
    0.09485706f, 0.11370973f, 0.01375494f, 0.09001531f, 0.08732313f, 0.06550233f, -0.02542236f, 0.06073709f, 
    0.03733189f, 0.02916017f, 0.01132441f, 0.03589771f, -0.01518251f, -0.03965491f, 0.05229089f, 0.00291887f, 
    -0.13902076f, 0.02493014f, 0.07297596f, 0.08916322f, -0.04475931f, -0.00657974f, 0.10076734f, 0.04146038f, 
    0.07108960f, 0.04765211f, -0.06050116f, 0.05063514f, 0.01989711f, 0.13137078f, 0.08800010f, -0.02011132f, 
    0.07387081f, 0.00692027f, 0.06380453f, 0.02942842f, 0.07248750f, -0.18816836f, -0.62034637f, -0.06175096f, 
    0.23426720f, -0.02370478f, 0.06542085f, 0.20112650f, 0.05434113f, 0.11481974f, 0.00554551f, -0.13323706f, 
    -0.03989448f, 0.03488377f, 0.07186876f, 0.08234759f, 0.05118358f, 0.07112768f, -0.11899193f, -0.10110288f, 
    0.22926527f, 0.08448848f, 0.18785016f, 0.22653188f, -0.39463240f, 0.04708630f, -0.15018533f, -0.12951913f, 
    0.09589734f, -0.07598303f, -0.02585437f, 0.04205921f, -0.00168130f, 0.06290846f, -0.00871728f, 0.07846178f, 
    0.08229836f, 0.02685499f, 0.00603383f, 0.10960747f, 0.00429145f, 0.06184440f, 0.19248633f, 0.22385022f, 
    0.06861231f, -0.01230845f, 0.00846415f, -0.03547830f, -0.02886158f, -0.09679184f, 0.00206987f, -0.00201233f, 
    0.06936444f, -0.09235702f, 0.07264725f, 0.09970357f, -0.03117042f, -0.05342641f, -0.02802124f, 0.01976680f, 
    -0.07880304f, 0.15624762f, 0.08645759f, -0.04132657f, -0.20810209f, 0.02803582f, 0.01366854f, 0.10089474f, 
    0.02597546f, -0.03009991f, 0.08579203f, -0.03209149f, 0.05470491f, -0.04850048f, 0.00696863f, 0.03325188f, 
    -0.07236202f, -0.01404121f, 0.04030751f, -0.03186148f, -0.39653730f, -0.01133235f, -0.65541798f, 0.09794237f, 
    -0.08837957f, 0.09670972f, 0.08651340f, 0.05695093f, -0.08573865f, 0.02580248f, -0.06785469f, -0.02208556f, 
    0.00143987f, 0.03330685f, -0.02971580f, 0.02559515f, -0.08138976f, 0.01699144f, 0.04227239f, 0.03949440f, 
    -0.09910115f, 0.13554646f, -0.14982687f, -0.01069919f, -0.01953650f, -0.01749372f, 0.11986870f, 0.19469953f, 
    0.00261399f, 0.07913851f, 0.05281606f, 0.05747159f, -0.13976651f, -0.04554811f, -0.00764753f, 0.09556130f, 
    0.07529668f, -0.16162428f, 0.05489594f, -0.04300570f, -0.70278054f, 0.08177664f, -0.22695777f, 0.12679975f, 
    -0.13583881f, -0.12917791f, 0.16847038f, -0.24561712f, 0.09179586f, 0.02027954f, 0.01838663f, -0.06868339f, 
    0.01098506f, -0.08018631f, 0.02146464f, 0.03205248f, 0.05880905f, 0.00219724f, -0.00101076f, -0.03042359f, 
    -0.25747436f, 0.18570690f, -0.12299629f, 0.01715709f, -0.11221459f, 0.07860312f, 0.08683796f, 0.07334529f, 
    0.03953505f, -0.01854284f, 0.12110494f, -0.00736987f, 0.06951077f, -0.13027395f, -0.04545479f, 0.14880715f, 
    -0.04480907f, -0.16310538f, 0.07103529f, -0.03515042f, 0.00224127f, -0.12109047f, 0.04541605f, 0.19851996f, 
    -0.27174854f, -0.08869265f, -0.01569811f, -0.01880758f, 0.06801442f, 0.11549772f, 0.07517836f, 0.00619869f, 
    0.06985332f, 0.05026333f, -0.03131607f, -0.11698520f, 0.05078078f, 0.08186208f, 0.13479300f, 0.05845154f, 
    -0.84987432f, -0.08060005f, -0.78722966f, 0.22113556f, -0.13816319f, -0.00930896f, -0.11783151f, 0.06413142f, 
    -0.13256522f, -0.08045432f, 0.05800670f, -0.00245258f, 0.03272280f, -0.02173596f, -0.04925237f, -0.00208158f, 
    -0.00475492f, 0.03114848f, 0.11290816f, 0.21378545f, -0.18823361f, -0.01977004f, 0.15268186f, 0.17131203f, 
    -0.09194519f, 0.06097581f, -0.16722153f, -0.09830511f, -0.14978106f, -0.01135205f, 0.02849126f, -0.12868257f, 
    0.05556557f, 0.00667968f, 0.00187984f, 0.04240261f, -0.04769821f, -0.09077049f, -0.00535152f, -0.04643235f, 
    0.09157839f, -0.00430623f, 0.23971093f, -0.29531696f, 0.03473416f, 0.03723653f, -0.15255289f, -0.07886647f, 
    -0.06684367f, -0.11356562f, 0.00335928f, 0.05462462f, -0.05448944f, 0.03729875f, 0.01620307f, 0.05361858f, 
    -0.01648989f, -0.05212096f, -0.07427090f, 0.06911308f, 0.13943763f, 0.28732029f, 0.10101032f, 0.37240499f, 
    -0.17232358f, -0.09799592f, -0.12051919f, -0.28179309f, -0.07304113f, -0.15535781f, 0.09503996f, -0.03247940f, 
    0.09494253f, 0.13828129f, 0.09315720f, 0.07311572f, 0.00823096f, 0.01642029f, -0.04047162f, -0.04018334f, 
    -0.01572668f, -0.32238612f, 0.05294870f, -0.02492192f, -0.00288089f, 0.01338262f, 0.05355823f, 0.00992276f, 
    -0.08244568f, -0.06937639f, 0.03348630f, -0.01673153f, -0.14693183f, 0.01739301f, -0.05795265f, 0.10907780f, 
    -0.02598965f, -0.01773378f, -0.17490244f, 0.02091513f, -0.20842932f, 0.23373374f, -0.15921557f, -0.62036920f, 
    0.03936648f, -0.08155482f, 0.08173250f, -0.08470625f, -0.22687010f, 0.10952506f, -0.04069873f, 0.02530896f, 
    -0.10933215f, -0.04379405f, -0.03962935f, 0.03677586f, 0.11054507f, -0.01274313f, -0.08078462f, -0.02799298f, 
    0.09155649f, 0.25299269f, 0.20423874f, 0.50067538f, -0.10018015f, 0.04179771f, -0.02913757f, -0.23532329f, 
    0.01967265f, -0.17478673f, 0.08267628f, -0.01310671f, 0.05696898f, -0.03177442f, -0.00280215f, 0.07950407f, 
    0.04197310f, -0.09944567f, 0.03725119f, 0.12650703f, -0.32170340f, -0.28606406f, 0.28484014f, 0.04284681f, 
    -0.28626952f, 0.00258857f, -0.27390188f, 0.06082226f, 0.12510921f, 0.27548856f, -0.00695884f, 0.04763775f, 
    0.04455231f, 0.00804440f, -0.02383875f, -0.01809099f, 0.02905727f, 0.00303997f, -0.05132788f, -0.07979771f, 
    0.11605924f, -0.10684699f, 0.17448482f, -0.18184450f, 0.12099185f, -0.10594210f, 0.04689299f, -0.01844437f, 
    0.19423793f, 0.13783492f, 0.00851817f, 0.10292924f, 0.07776910f, -0.03037939f, 0.08285173f, 0.05289281f, 
    0.13800694f, 0.04217836f, -0.11314443f, 0.03768205f, 0.05717199f, -0.47133461f, -0.55330420f, 0.11238362f, 
    -0.10095735f, 0.05865069f, -0.10108289f, 0.16304247f, 0.02408884f, -0.03919246f, -0.04466743f, 0.02568090f, 
    -0.04528324f, 0.00318319f, 0.13165186f, 0.03714684f, 0.08589303f, 0.17388897f, -0.00542237f, 0.22695626f, 
    0.10080006f, -0.00364802f, -0.32705125f, 0.22068200f, -0.66937608f, -0.22696736f, 0.13151237f, -0.23260391f, 
    0.14712703f, -0.04207593f, 0.02800971f, -0.02431889f, 0.08745534f, 0.07131743f, 0.01169731f, 0.09893601f, 
    0.04710129f, 0.04671939f, -0.06987449f, 0.00738670f, 0.04175740f, 0.16110198f, -0.49800402f, 0.19135331f, 
    -0.03493734f, 0.05978241f, 0.25005144f, 0.30837199f, -0.00661724f, 0.14255463f, 0.01096312f, -0.01870444f, 
    -0.08758433f, -0.01667150f, -0.04213916f, 0.08905356f, -0.02206497f, -0.07138050f, -0.02918966f, 0.01583813f, 
    -0.24877112f, -0.00702432f, 0.11246514f, 0.18475321f, -0.42212370f, -0.07804766f, -0.01058729f, -0.14251439f, 
    -0.08533248f, 0.07228964f, 0.08938722f, -0.01656016f, 0.00568418f, -0.04736879f, -0.10245347f, -0.04884456f, 
    0.11325718f, -0.02645670f, 0.03521663f, 0.02572229f, -0.11186197f, -0.14593852f, -0.39700219f, -0.16697413f, 
    0.09551538f, 0.06383985f, 0.02087275f, 0.07908579f, -0.08265758f, 0.12186513f, 0.00997086f, 0.05943607f, 
    0.01555840f, 0.06401948f, -0.02315375f, 0.00178078f, 0.05883706f, 0.04143263f, -0.06614571f, 0.15088476f, 
    -0.47081640f, 0.23968223f, 0.05376256f, 0.08853884f, -0.01620988f, 0.09508381f, -0.13384417f, -0.09087037f, 
    -0.16787748f, -0.04557489f, -0.02631569f, 0.04691478f, 0.08675572f, 0.00591832f, 0.01197710f, 0.02833974f, 
    0.01804511f, -0.09942473f, 0.03347517f, 0.08309913f, 0.01733649f, -0.02893859f, 0.20830970f, -0.07911310f, 
    -0.12919688f, -0.20778857f, -0.15111583f, 0.17074956f, -0.02093106f, 0.07785026f, -0.06613320f, -0.01823555f, 
    0.02593562f, 0.00275395f, -0.01826481f, -0.01146981f, -0.02698433f, -0.00863683f, -0.11338317f, -0.13025849f, 
    0.14607643f, 0.17709653f, 0.03857743f, -0.18058999f, 0.04621682f, 0.01152821f, -0.09012239f, -0.02463737f, 
    0.03256844f, -0.10084132f, 0.10759229f, 0.05291475f, 0.05167521f, -0.09850687f, -0.03301458f, 0.13739459f, 
    0.06715440f, 0.03383737f, 0.03345866f, 0.16352125f, -0.05875523f, -0.06640654f, -0.06130223f, 0.12377113f, 
    0.09096904f, -0.05640570f, 0.08238437f, 0.02137836f, -0.02941631f, -0.04682842f, 0.08622456f, -0.03264634f, 
    0.11244183f, -0.00929276f, -0.10671164f, 0.21488202f, 0.00651394f, 0.02264095f, -0.09269097f, -0.00772430f, 
    0.08557188f, -0.64431673f, -0.01573608f, 0.07548691f, 0.04332855f, -0.19455728f, 0.07152618f, -0.01322016f, 
    0.02788764f, 0.12426497f, 0.02074312f, -0.01604312f, -0.02019529f, -0.08105686f, -0.07199333f, -0.04320006f, 
    0.12403464f, 0.14871518f, 0.01724997f, 0.01688794f, -0.50934237f, 0.17311490f, -0.28900579f, 0.10086665f, 
    0.09246996f, 0.02142807f, -0.15524152f, -0.05897553f, 0.10344727f, -0.06359981f, 0.07800089f, -0.13691562f, 
    -0.09751067f, -0.09300613f, -0.08703549f, -0.11025286f, -0.12394328f, -0.01784682f, -0.11461200f, 0.02840083f, 
    0.01139833f, 0.19111104f, 0.40555641f, -0.15946357f, -0.13554037f, 0.05548549f, -0.15557262f, -0.02205986f, 
    0.05438239f, 0.09733959f, -0.07021026f, 0.08874118f, 0.05179005f, 0.04837741f, 0.05280380f, -0.03905696f, 
    -0.02103001f, -0.06208742f, -0.05308754f, -0.05356294f, -0.09556177f, 0.08210291f, 0.05697056f, -0.05498923f, 
    -0.01913571f, 0.11441624f, 0.05528467f, 0.08604617f, 0.00896747f, -0.05657426f, 0.07706190f, 0.03353626f, 
    -0.00945519f, 0.04158593f, 0.03190047f, 0.04122005f, 0.00698860f, 0.03676542f, 0.02210269f, 0.01715164f, 
    -0.40277436f, -0.29904324f, 0.28350857f, 0.21611489f, -0.37851176f, 0.28365442f, -0.37268868f, 0.05726176f, 
    -0.00096123f, 0.18462776f, 0.06336925f, 0.01461852f, 0.05038808f, 0.03868267f, -0.00951401f, -0.03538494f, 
    0.01334288f, 0.01260048f, -0.04778996f, 0.05318095f, 0.05298849f, 0.03282592f, 0.10638291f, 0.10862917f, 
    0.01330114f, 0.03350381f, 0.04358778f, -0.14638460f, -0.02082670f, 0.00954288f, 0.01717055f, -0.02994896f, 
    0.10890529f, 0.01696444f, 0.05040183f, 0.02891452f, -0.07701410f, -0.06906904f, -0.04488388f, -0.04604822f, 
    0.03688241f, -0.07671358f, -0.02516098f, 0.01518017f, -0.06381182f, -0.03249725f, -0.03989867f, -0.09092208f, 
    0.04175080f, -0.03316456f, -0.07737539f, 0.02493250f, 0.06370491f, 0.07625944f, -0.06339028f, 0.08271720f, 
    0.11030645f, 0.06465530f, -0.09595896f, -0.00337321f, -0.14339875f, 0.03301999f, 0.02469925f, -0.08276329f, 
    0.11332285f, 0.03287559f, -0.04557209f, -0.02831593f, -0.09519561f, -0.14030591f, 0.16844174f, 0.03851510f, 
    -0.08602519f, 0.10257489f, -0.00527122f, -0.02372954f, -0.02044976f, -0.05141805f, -0.14447068f, 0.01844436f, 
    0.07053209f, 0.11638818f, 0.25287646f, -0.23004325f, -0.14261617f, -0.02617212f, -0.08624167f, 0.09500822f, 
    0.01541769f, 0.06326809f, 0.03994877f, 0.00861646f, 0.04980915f, -0.06046792f, -0.01070484f, 0.01582631f, 
    -0.03047448f, -0.01786066f, -0.04049200f, -0.15666573f, -0.12888046f, -0.06249114f, -0.01282794f, 0.06056096f, 
    0.17432232f, -0.09244632f, 0.14241925f, -0.01171012f, -0.08130388f, -0.05466531f, 0.01648984f, 0.05524879f, 
    0.03329037f, -0.10178052f, 0.07646200f, 0.11335966f, 0.09904484f, -0.00405611f, -0.06332171f, 0.03897090f, 
    0.10666499f, 0.19084108f, 0.18308055f, 0.22611058f, -0.19849737f, 0.21852730f, -0.14081381f, -0.10944328f, 
    -0.14242694f, -0.08623537f, 0.00396583f, 0.02128070f, 0.08245340f, 0.07893087f, 0.03983574f, 0.03250732f, 
    0.01181797f, -0.06226571f, -0.03628310f, 0.08722898f, -0.13221250f, 0.00070694f, 0.11460759f, 0.26695222f, 
    -0.63597584f, 0.06536862f, -0.07516500f, -0.11976464f, 0.05831093f, 0.06521612f, 0.09284307f, -0.02762592f, 
    0.02240614f, 0.09738953f, 0.08465406f, -0.01178223f, 0.03626874f, 0.01861393f, -0.04416781f, 0.01899084f, 
    -0.17356670f, 0.16032025f, -0.41735646f, 0.07946694f, 0.01870388f, 0.02795787f, 0.13475840f, 0.12318571f, 
    -0.04867810f, 0.03553215f, 0.06012170f, -0.03325272f, -0.01264046f, -0.02692481f, 0.00949592f, 0.10580038f, 
    0.11139658f, -0.12168463f, -0.01038619f, 0.02756356f, 0.22510575f, -0.03062487f, -0.38690042f, -0.04611108f, 
    0.07409472f, -0.06698041f, -0.00154592f, 0.06653813f, -0.01149917f, 0.15759090f, -0.00278659f, 0.02161315f, 
    -0.03720456f, 0.03349616f, 0.03803847f, 0.00188769f, 0.09796540f, 0.06414528f, -0.03134477f, 0.01616097f, 
    0.03618551f, 0.10929839f, 0.10442751f, 0.08112197f, 0.06444493f, 0.00706299f, 0.02860123f, 0.00241023f, 
    -0.00586024f, -0.09481540f, -0.04354449f, 0.03960964f, 0.05633021f, -0.09317811f, 0.01323321f, 0.07449368f, 
    0.02448455f, -0.06460971f, -0.05129735f, 0.05714269f, -0.45340341f, 0.01539121f, 0.14931084f, -0.24869147f, 
    -0.32051095f, 0.07380213f, -0.33672228f, -0.01604990f, -0.12704884f, -0.16332954f, -0.16193615f, 0.11530862f, 
    -0.10975353f, 0.01143779f, 0.15320118f, 0.05336204f, -0.08352746f, 0.01148891f, -0.06410675f, 0.11552333f, 
    -0.59076750f, 0.54884404f, -0.58280271f, -0.30605891f, -0.01511180f, 0.15597050f, -0.12670392f, 0.04047598f, 
    -0.07720935f, 0.04426168f, 0.02481918f, -0.03114538f, -0.06430337f, 0.01167429f, 0.10121474f, -0.11100943f, 
    0.02879452f, -0.06789899f, 0.02628019f, -0.07850423f, -0.40617135f, 0.15941165f, 0.09517047f, 0.51310462f, 
    -0.17579179f, -0.03506310f, 0.00475456f, -0.23974864f, -0.09609732f, -0.16394006f, 0.13855474f, -0.07828413f, 
    0.05822061f, 0.01098175f, 0.11071074f, 0.02856459f, -0.01044170f, -0.08586268f, 0.02672912f, 0.10107797f, 
    -0.28734922f, -0.07190028f, -0.61311001f, 0.14779826f, 0.09801319f, -0.02796253f, 0.22661825f, 0.17480420f, 
    0.02365305f, -0.15536891f, 0.02698659f, -0.05670428f, -0.01721186f, 0.03622248f, -0.01671538f, -0.00252621f, 
    0.18435693f, -0.09920419f, 0.01568358f, 0.10061128f, -0.14240649f, 0.22292855f, -0.41173092f, 0.06894127f, 
    -0.05455937f, -0.01071998f, 0.02256269f, 0.06765494f, -0.12955891f, 0.11263555f, 0.03015020f, 0.03865689f, 
    -0.11713387f, -0.04815950f, -0.01708482f, 0.07552032f, -0.00649188f, -0.13761365f, 0.03922410f, -0.14024547f, 
    -0.00794434f, 0.01275397f, 0.07770469f, -0.09287740f, -0.08351671f, 0.02440200f, -0.20031229f, 0.04831862f, 
    0.01134844f, 0.03933999f, -0.03957829f, 0.08320595f, 0.05547613f, -0.05699586f, -0.02185362f, -0.00243127f, 
    0.02125384f, 0.01636608f, 0.02174465f, 0.00073788f, -0.07509103f, -0.05549797f, -0.03200035f, 0.05153681f, 
    0.15365079f, -0.00011128f, 0.06226072f, 0.07086124f, 0.02507610f, 0.04035133f, -0.09202602f, -0.11312307f, 
    -0.00861609f, 0.06792796f, -0.03745407f, 0.04319851f, 0.08594570f, 0.01727232f, 0.00601176f, 0.02267275f, 
    -0.12409054f, 0.14972121f, 0.09023834f, 0.21734093f, 0.11116120f, -0.08576546f, 0.04567052f, -0.03442053f, 
    -0.04259592f, -0.08425356f, 0.01236176f, 0.04359071f, 0.05702773f, -0.06560402f, -0.00966629f, 0.06454801f, 
    0.04976749f, -0.00589246f, -0.05258637f, 0.00826193f, -0.40444100f, -0.06171652f, -0.04256919f, -0.01542429f, 
    0.13457121f, 0.00216614f, 0.04985899f, -0.00426091f, -0.03313680f, 0.13473013f, -0.03358543f, -0.13360280f, 
    0.00406419f, 0.09709133f, -0.11301958f, 0.11770929f, -0.02460679f, 0.00745663f, -0.03243667f, -0.02797203f, 
    -0.05368365f, -0.15196948f, 0.02049721f, 0.15338722f, -0.15224986f, 0.00620920f, -0.32545540f, -0.02647110f, 
    0.10878348f, 0.12637955f, 0.02716729f, 0.02864162f, 0.06946104f, 0.04057255f, -0.00864375f, -0.06482673f, 
    0.10927945f, 0.12304720f, 0.09989195f, 0.14493825f, -0.16844048f, 0.00159291f, -0.19737951f, 0.08867347f, 
    0.17392312f, -0.02030214f, 0.09203223f, 0.12995389f, -0.00925381f, 0.01265244f, -0.07020337f, -0.01233486f, 
    -0.01403281f, -0.07718396f, 0.04062181f, 0.03059126f, 0.12276095f, 0.02602618f, 0.11445134f, 0.12385812f, 
    -0.15314485f, 0.01718089f, 0.09084342f, 0.05832770f, -0.12927608f, 0.04219412f, -0.12197512f, 0.01654145f, 
    -0.06962433f, 0.10785327f, 0.00094222f, 0.01578881f, 0.00072420f, 0.09850698f, 0.01946451f, -0.06939194f, 
    0.06493789f, 0.16452068f, 0.12659761f, 0.06931765f, 0.33122370f, 0.15662248f, -0.50510079f, 0.06329545f, 
    -0.33297521f, -0.02190283f, 0.01068705f, 0.12851061f, 0.07570921f, 0.13019630f, -0.01887173f, -0.00471220f, 
    -0.02903854f, -0.11067149f, -0.01207295f, 0.01934602f, -0.04793976f, 0.01808204f, 0.07539164f, -0.22144666f, 
    0.10259242f, -0.56657284f, 0.13579902f, -0.44512486f, -0.23803782f, -0.17239453f, -0.02086641f, -0.05543667f, 
    0.07008095f, 0.06934483f, -0.06295162f, 0.01093074f, -0.04540267f, -0.06049814f, -0.07138147f, 0.04801647f, 
    0.09668984f, 0.06826339f, -0.03503872f, 0.08784417f, -0.14647648f, -0.15805383f, -0.25171176f, 0.01959748f, 
    -0.37973112f, -0.05732968f, -0.01678885f, 0.11138902f, 0.07226442f, 0.15050015f, 0.03376921f, 0.01830703f, 
    -0.03125098f, -0.02518478f, -0.01050328f, -0.02180481f, 0.01314967f, 0.02447571f, 0.00566547f, -0.11453635f, 
    -0.40825665f, -0.15756615f, -0.01217052f, 0.14024374f, -0.21592863f, -0.06873860f, -0.12539808f, -0.17915729f, 
    0.04722478f, 0.04789042f, -0.01643517f, -0.00076517f, 0.04985854f, 0.03633220f, -0.01230595f, -0.06460109f, 
    0.03687769f, 0.02438342f, -0.04941323f, -0.03645508f, -0.01661783f, -0.19436052f, -0.14278226f, -0.20647849f, 
    -0.14827783f, 0.03789080f, 0.04609228f, 0.03091386f, -0.07544477f, -0.13117513f, 0.00811438f, -0.01126255f, 
    -0.12435651f, -0.00884936f, 0.06264674f, 0.10307275f, 0.09922637f, -0.04295425f, -0.18767951f, -0.01182515f, 
    -0.07261445f, -0.22654089f, -0.27778912f, 0.06728338f, 0.07361976f, 0.10305891f, 0.10949848f, 0.15369274f, 
    -0.01416272f, 0.09437256f, -0.02886681f, -0.00700215f, -0.04806999f, 0.03726009f, -0.04647782f, -0.03290085f, 
    0.11354593f, 0.02746218f, -0.01257932f, 0.05003024f, 0.14092602f, 0.07855308f, 0.19641240f, 0.21932517f, 
    -0.34641001f, 0.15057243f, -0.08217467f, -0.22207452f, -0.07866017f, -0.10856541f, 0.12434990f, 0.03166668f, 
    0.01417660f, 0.05143734f, 0.03825470f, -0.00009666f, 0.00131592f, -0.03456990f, 0.00355607f, 0.03435655f, 
    -0.28144065f, -0.12989332f, -0.05408463f, 0.16131808f, 0.13045198f, -0.03378434f, 0.10125256f, -0.01666257f, 
    -0.00341188f, 0.06443729f, 0.09256551f, -0.07681077f, 0.02865810f, 0.01116320f, -0.07940593f, 0.10499327f, 
    0.03155056f, -0.01777088f, 0.08507898f, 0.07742162f, -0.02996528f, -0.02617060f, -0.07107479f, -0.01827251f, 
    -0.21395333f, 0.04545128f, -0.07314967f, 0.03656892f, -0.04192121f, -0.08025270f, 0.08358085f, -0.00335106f, 
    -0.00843367f, 0.04385526f, 0.06287314f, 0.00047553f, 0.09356102f, -0.03323567f, -0.00175067f, 0.09087893f, 
    0.03762981f, 0.02115179f, 0.07030270f, -0.28748637f, 0.06601416f, -0.07670546f, 0.11755146f, -0.00945789f, 
    0.07385101f, 0.03166090f, -0.06212470f, 0.06963974f, -0.06446541f, -0.00405367f, 0.08133908f, 0.08487050f, 
    0.14458582f, 0.01679596f, -0.04492821f, 0.02108422f, 0.10928650f, -0.12243918f, -0.01975495f, 0.19134565f, 
    -0.51156211f, -0.13186362f, 0.04970591f, -0.20186424f, 0.12952626f, -0.07203811f, 0.02738813f, -0.01964210f, 
    0.08265679f, 0.04618990f, 0.06010471f, 0.09325203f, 0.10200240f, 0.01314873f, 0.01684311f, 0.10543859f, 
    0.07144849f, 0.09723213f, 0.10329261f, -0.00047945f, -0.02860282f, 0.04840784f, -0.02061030f, 0.02051831f, 
    0.02722394f, -0.02357936f, -0.03420204f, 0.03424416f, -0.05703115f, -0.05899164f, -0.14460781f, -0.03553680f, 
    -0.15142055f, -0.01810212f, -0.13384193f, -0.09650747f, -0.07989623f, -0.16924170f, 0.06094119f, -0.08267541f, 
    -0.12520437f, -0.06364659f, -0.09187558f, 0.04104895f, -0.08423357f, -0.01111880f, -0.01793884f, 0.12411349f, 
    -0.15659529f, 0.00903988f, 0.04438818f, -0.06407806f, -0.04211670f, 0.00775151f, -0.04002272f, -0.04934413f, 
    -0.23294920f, -0.27253777f, -0.17129280f, 0.04545437f, -0.11183035f, 0.02025519f, -0.05479076f, -0.11469476f, 
    0.16936560f, 0.06581621f, -0.10849951f, -0.03199697f, 0.04486905f, 0.02237443f, -0.06810822f, 0.09626613f, 
    0.06102260f, 0.03964382f, 0.19547589f, 0.09404492f, 0.08707960f, -0.24065803f, 0.18789782f, -0.00635062f, 
    0.03270937f, -0.21654247f, 0.03655394f, 0.11224153f, -0.10967182f, -0.01058280f, -0.03227172f, 0.02827717f, 
    -0.10675265f, 0.05754970f, -0.00250810f, 0.06108957f, -0.05136129f, -0.00539874f, -0.03867667f, 0.02378904f, 
    -0.14954865f, -0.19861880f, 0.15140986f, -0.10649939f, -0.04696419f, 0.09936118f, -0.07158131f, 0.20203923f, 
    0.00315924f, -0.05432894f, -0.13312379f, 0.00497877f, 0.10211138f, 0.03515826f, 0.07241900f, 0.04203516f, 
    0.00365315f, 0.15938960f, 0.05600208f, 0.11413028f, 0.19578436f, 0.06055883f, 0.19147168f, 0.11130223f, 
    0.16206121f, 0.06120350f, 0.01303133f, 0.06042678f, 0.01615799f, 0.03643615f, -0.07414908f, 0.00413465f, 
    0.02741498f, 0.01035794f, 0.03699005f, -0.10184122f, 0.03547402f, -0.03474155f, -0.00738288f, -0.03543220f, 
    -0.18958633f, -0.42100453f, 0.14071326f, -0.12974666f, -0.08568959f, 0.05524025f, -0.02893184f, 0.13331935f, 
    0.03767416f, -0.02962803f, -0.09958442f, -0.03250951f, -0.02545686f, -0.03325771f, 0.01043804f, -0.06404106f, 
    0.14141801f, 0.15033568f, 0.18407246f, 0.02317388f, -0.21072106f, 0.01388529f, -0.43952769f, -0.04328377f, 
    0.02607893f, -0.09720705f, -0.01999781f, -0.05152505f, -0.10389070f, 0.03031909f, -0.02402167f, 0.08785675f, 
    0.03540232f, -0.01753966f, 0.01866315f, 0.05842858f, -0.02673163f, -0.01147413f, -0.01120166f, -0.11004126f, 
    0.29325986f, -0.17635202f, 0.26627585f, -0.04948356f, 0.03039054f, -0.23986584f, 0.13272841f, 0.02241525f, 
    0.08726295f, -0.09716056f, -0.05874170f, -0.02612759f, 0.06181464f, -0.01639846f, 0.00430829f, 0.12535512f, 
    -0.16796026f, 0.00473513f, -0.04609550f, -0.30613405f, -0.07365783f, 0.10004625f, -0.03231655f, -0.19352634f, 
    0.07732660f, -0.12545747f, 0.02259985f, 0.07738703f, 0.07381808f, -0.02476252f, -0.17114784f, 0.09332418f, 
    -0.05295713f, 0.00511191f, 0.02307488f, 0.08379878f, 0.04914975f, 0.08150678f, 0.10178562f, 0.15612306f, 
    -0.45897594f, 0.03768907f, 0.07126063f, 0.08627317f, -0.04310989f, 0.06456123f, -0.01815283f, -0.18332228f, 
    0.10012337f, 0.12333967f, -0.02868101f, 0.00095568f, -0.07218879f, 0.03024626f, -0.01435519f, -0.06167716f, 
    0.09175426f, -0.03167416f, 0.06169973f, -0.03435641f, 0.30702770f, -0.04398735f, 0.10897198f, -0.17004079f, 
    -0.04554804f, 0.08730026f, -0.08386651f, -0.08134944f, -0.00236518f, 0.05086045f, -0.25192150f, 0.16324626f, 
    -0.09060191f, -0.08908852f, -0.18721841f, 0.02540146f, -0.04291613f, -0.00360002f, 0.02071787f, -0.01478509f, 
    -0.24216093f, 0.02880328f, -0.19867766f, 0.16476581f, 0.03653229f, 0.03899077f, -0.01847320f, 0.03556750f, 
    0.12025268f, 0.13469353f, -0.06449601f, 0.03643990f, -0.00686569f, 0.05047996f, 0.05195740f, -0.11987473f, 
    0.15036342f, -0.12908740f, 0.04462144f, 0.19995974f, 0.24425706f, -0.04816046f, 0.37915650f, 0.34507769f, 
    0.05355233f, 0.05925228f, 0.11915428f, 0.25547236f, 0.03739256f, -0.09668439f, 0.06921747f, -0.10903986f, 
    -0.03068062f, 0.10741510f, -0.00342180f, -0.03088223f, 0.09744888f, 0.13642246f, -0.09100024f, 0.05611931f, 
    0.21838090f, 0.02933577f, 0.13870119f, -0.04229229f, -0.10691745f, 0.04259330f, -0.01614079f, 0.02117516f, 
    0.04753178f, -0.01290949f, -0.10041748f, 0.02984252f, -0.06388099f, -0.08450429f, -0.23696958f, -0.06505471f, 
    -0.19418104f, 0.08054154f, -0.05874378f, -0.08860008f, -0.40381235f, 0.04125262f, -0.56114382f, 0.00829209f, 
    0.01126992f, -0.03352023f, -0.17546093f, -0.23239847f, 0.07851476f, -0.07855032f, -0.02776223f, 0.06991141f, 
    -0.03236393f, 0.01726899f, 0.08647055f, 0.04542655f, -0.03415402f, -0.13859116f, 0.06423174f, -0.04295025f, 
    0.01055874f, 0.01869535f, 0.15359083f, 0.10251562f, -0.02303491f, -0.02092063f, 0.00867252f, -0.09563691f, 
    -0.05303457f, 0.06734379f, -0.07390717f, 0.04798598f, 0.04955098f, 0.00166333f, 0.05893381f, -0.08040390f, 
    -0.00730670f, 0.10158949f, 0.02841642f, 0.12729031f, -0.19108324f, 0.00066151f, 0.06933162f, 0.10914983f, 
    0.06819224f, -0.03576840f, 0.04250648f, -0.07164500f, -0.06722400f, -0.08455550f, -0.02427568f, 0.01493497f, 
    -0.02870590f, 0.07001009f, 0.01161846f, 0.07325202f, -0.13789354f, -0.02061112f, -0.41508967f, -0.11784586f, 
    -0.24485821f, 0.05118082f, -0.45302126f, 0.01933594f, 0.03262053f, 0.12032148f, -0.02410648f, -0.00528413f, 
    -0.04460539f, 0.05090309f, -0.15908331f, 0.13454825f, 0.04092202f, -0.17672446f, -0.15058629f, 0.04386940f, 
    -0.01550638f, -0.12355364f, 0.02430234f, -0.08858854f, -0.21888182f, -0.37618771f, -0.17837091f, -0.31466499f, 
    -0.03977467f, -0.04991190f, -0.16243646f, 0.20503852f, -0.16774285f, -0.06547855f, -0.05737038f, 0.11398619f, 
    0.04622065f, -0.02259204f, -0.03010080f, 0.11939323f, -0.08551224f, -0.00459586f, 0.02306953f, 0.09721038f, 
    -0.24188817f, -0.07487500f, 0.23560098f, 0.13291857f, 0.12440013f, 0.13671295f, -0.09136477f, -0.03289567f, 
    0.02795154f, -0.00153200f, -0.01417577f, -0.03686689f, 0.00690709f, -0.00040600f, 0.01375384f, -0.07122251f, 
    -0.10892404f, 0.19715449f, -0.06594909f, -0.01685375f, 0.00257703f, -0.19865486f, -0.09550720f, -0.15290625f, 
    -0.02468322f, -0.11820322f, 0.05857661f, 0.25753692f, -0.01159100f, -0.06094367f, 0.05804845f, 0.04277763f, 
    -0.00692120f, 0.02825593f, -0.01545270f, 0.02951548f, -0.16184066f, 0.07439735f, -0.33269748f, -0.30859673f, 
    0.15301055f, -0.37214255f, 0.09145372f, -0.09347118f, -0.01926966f, -0.08598416f, 0.03611816f, 0.26041871f, 
    0.03747023f, 0.00238376f, -0.01327850f, -0.06949846f, -0.16836444f, 0.21622892f, 0.02596421f, -0.11300915f, 
    0.06560760f, 0.12379535f, 0.01974285f, 0.09273290f, -0.39642361f, 0.00976141f, -0.06053308f, 0.08423815f, 
    0.05387399f, 0.07251926f, -0.00623463f, -0.07470032f, 0.00384762f, 0.02147043f, -0.07301352f, -0.00285677f, 
    -0.01813627f, 0.01587943f, -0.01181323f, 0.04608825f, 0.07833815f, -0.16235128f, 0.05065680f, 0.11942633f, 
    0.05050540f, 0.16172518f, 0.16418031f, 0.23228501f, 0.08352242f, 0.04243832f, 0.08756813f, -0.07980372f, 
    -0.13528493f, -0.02392376f, -0.22282945f, 0.02084888f, 0.09860940f, -0.08431003f, -0.01163907f, -0.13375762f, 
    0.02499778f, -0.17367534f, 0.00338212f, 0.04481124f, -0.14863853f, -0.37153888f, -0.34465587f, 0.19037959f, 
    -0.09527060f, -0.00632256f, -0.05045052f, -0.07779390f, -0.28017020f, -0.04161786f, -0.15447187f, 0.24235053f, 
    -0.14150672f, 0.14875658f, 0.24883088f, -0.19766673f, 0.01208799f, 0.00031068f, 0.05576004f, 0.13891169f, 
    0.05678134f, 0.00273556f, -0.02614074f, 0.18677017f, 0.16001464f, -0.03013526f, -0.05647265f, 0.01596023f, 
    -0.19948269f, 0.15542206f, 0.08058164f, -0.01317653f, -0.16912010f, 0.03844141f, 0.12791957f, 0.01993210f, 
    -0.06671310f, -0.04418208f, -0.06759119f, 0.06712057f, 0.04550479f, -0.48747593f, 0.25986046f, -0.07702670f, 
    0.05256804f, -0.16205144f, -0.11859348f, -0.01206996f, 0.10220222f, 0.07548578f, -0.02108302f, -0.10692778f, 
    0.00864785f, 0.02903414f, -0.04154109f, 0.08010839f, 0.13010889f, 0.03913490f, 0.23102178f, -0.13796373f, 
    -0.09059665f, -0.04179297f, -0.04089487f, 0.14698189f, -0.02831335f, -0.01558304f, 0.04675527f, -0.03232954f, 
    0.09467027f, 0.08146848f, -0.03182186f, -0.11155461f, -0.00106788f, 0.00671752f, 0.04326741f, 0.01096464f, 
    0.02082307f, 0.04055689f, 0.09034673f, 0.15824690f, -0.16631295f, -0.26593688f, -0.07220914f, -0.03835302f, 
    -0.19404040f, -0.05435303f, -0.04814023f, -0.06280967f, 0.10086237f, 0.03313008f, -0.07179280f, -0.00808229f, 
    0.04256556f, -0.01801553f, 0.01607189f, 0.09652795f, 0.04125210f, 0.09613858f, 0.14677624f, 0.05591246f, 
    -0.30746618f, -0.06023026f, -0.21549965f, -0.22747535f, 0.00994704f, -0.08447539f, -0.11696650f, -0.23255205f, 
    0.07353002f, -0.03622050f, -0.06196692f, 0.08029152f, 0.01676059f, -0.03587687f, 0.03644630f, 0.05525340f, 
    -0.00044611f, -0.05452448f, 0.06538838f, -0.00584296f, 0.01704752f, -0.02342645f, 0.04396019f, -0.03703751f, 
    0.06359486f, -0.01205351f, 0.03797126f, 0.00587022f, 0.00788080f, 0.05320146f, -0.07072552f, 0.07411376f, 
    -0.01512690f, -0.03910370f, -0.02483236f, 0.05217841f, 0.08890820f, -0.01945206f, 0.10907637f, 0.10402019f, 
    -0.21881320f, 0.15910812f, -0.20487499f, 0.07023662f, 0.01854499f, 0.03306752f, -0.04288236f, -0.01810294f, 
    0.09703727f, 0.00182149f, -0.01118673f, -0.00406814f, -0.06905058f, 0.04462264f, 0.02770781f, -0.03296511f, 
    0.03547828f, -0.23667103f, 0.11887140f, -0.05600268f, -0.23671854f, -0.09027170f, 0.10301759f, -0.07806718f, 
    -0.14515458f, -0.04962830f, -0.12899402f, -0.10222936f, 0.16442014f, 0.02816099f, -0.04489056f, -0.03326983f, 
    -0.02857304f, 0.06562921f, 0.08336445f, -0.05390847f, 0.19957256f, 0.02745843f, 0.17413108f, 0.01457014f, 
    -0.15823361f, 0.00180569f, -0.20609409f, 0.21118318f, -0.06298938f, 0.06404448f, 0.03578221f, -0.06276315f, 
    0.21546519f, 0.06094164f, -0.10341173f, -0.02399444f, 0.01813983f, 0.05883266f, 0.02708406f, 0.07640970f, 
    -0.03303182f, -0.04478789f, 0.12770948f, 0.14025231f, 0.08634345f, -0.13077466f, 0.15414152f, -0.00862395f, 
    -0.05449983f, -0.03704792f, -0.08760199f, 0.05429301f, 0.04872135f, -0.02856489f, 0.05418964f, -0.00586440f, 
    0.02717105f, 0.01973770f, 0.01347701f, 0.02150995f, 0.03930603f, 0.02664243f, -0.00228569f, 0.00850190f, 
    0.21614785f, -0.13152494f, 0.12089018f, 0.02168889f, -0.03397887f, -0.00119045f, 0.05080958f, -0.00364249f, 
    0.15070482f, -0.01165434f, 0.02272447f, -0.03733686f, -0.03814974f, -0.08339506f, -0.15107372f, -0.03604731f, 
    -0.06125181f, 0.07591819f, 0.03749629f, -0.00265565f, -0.11094875f, 0.03774365f, -0.06109632f, 0.05812030f, 
    0.11303282f, -0.08334061f, -0.03490774f, -0.04141645f, -0.04053483f, 0.09412304f, -0.09176501f, 0.06543051f, 
    -0.01964406f, -0.06027580f, -0.02996887f, 0.07754144f, -0.01888693f, -0.01903995f, -0.01908363f, -0.01942680f, 
    -0.05305956f, -0.05787691f, 0.19778852f, -0.12679861f, 0.03306702f, -0.02497971f, -0.08517748f, 0.08199448f, 
    -0.01273918f, 0.00039475f, -0.14183740f, 0.06344491f, 0.10268058f, 0.05729885f, 0.03948777f, -0.02636625f, 
    0.03240760f, 0.09747855f, -0.04280966f, 0.00414279f, -0.05855834f, -0.01763950f, -0.26756671f, 0.03743767f, 
    -0.01853213f, 0.04528696f, -0.08709544f, 0.14675339f, -0.17536585f, -0.07989801f, 0.00504250f, 0.02346730f, 
    -0.03316379f, 0.06163561f, 0.03706480f, 0.07721218f, -0.10230202f, 0.04738794f, -0.27718374f, -0.13627169f, 
    0.03047744f, -0.05414597f, 0.09406343f, 0.02915323f, -0.05354591f, -0.01659438f, 0.01142751f, -0.05559971f, 
    0.03703403f, 0.04963008f, 0.02687660f, 0.01081574f, 0.01408290f, 0.02367814f, 0.05058697f, -0.01193193f, 
    -0.08742303f, 0.02686978f, 0.00982623f, 0.01911757f, -0.09771499f, -0.02444217f, 0.01191573f, 0.08280125f, 
    0.01622484f, 0.06427053f, 0.02957821f, 0.09233450f, 0.05999545f, -0.03556693f, 0.01170067f, 0.05397453f, 
    -0.03278660f, 0.13805333f, 0.08649303f, -0.04897552f, -0.10896353f, 0.00574541f, -0.13164140f, 0.02264600f, 
    -0.16380294f, -0.13721012f, -0.07033014f, 0.17987661f, -0.12384146f, -0.02432215f, 0.07116337f, 0.15188168f, 
    0.02113043f, -0.06817102f, -0.11590701f, -0.08015364f, 0.07619043f, -0.01882358f, -0.03221438f, 0.01054743f, 
    0.04875204f, 0.10490436f, 0.01810914f, -0.05439638f, 0.24694131f, 0.30778417f, 0.20630552f, -0.01292746f, 
    -0.01414532f, -0.02149420f, -0.11338422f, 0.05223557f, -0.01602401f, 0.10145895f, -0.13256189f, -0.02598038f, 
    -0.01618736f, 0.04143723f, -0.02136890f, 0.02589522f, -0.07265864f, 0.02196125f, 0.02821920f, 0.05214974f, 
    -0.21633436f, -0.41857463f, 0.09448706f, -0.30573121f, -0.08496611f, -0.03344426f, -0.21448004f, 0.14766212f, 
    0.05911900f, -0.06490816f, -0.15560637f, 0.01329061f, 0.04622127f, 0.07160996f, 0.07344817f, 0.17347397f, 
    -0.05542618f, 0.06047830f, 0.05547222f, -0.01048856f, -0.23818135f, -0.07481188f, -0.22202054f, -0.03142890f, 
    0.08857671f, -0.04885329f, -0.02375323f, 0.26329044f, -0.03430087f, 0.07148963f, -0.02430963f, 0.07771210f, 
    -0.00771460f, 0.10769653f, 0.11805671f, 0.09305635f, -0.00786575f, 0.12342364f, 0.03972260f, 0.19383751f, 
    -0.15454042f, 0.05853042f, -0.14788753f, 0.02331083f, 0.02250250f, -0.00449619f, -0.00594510f, -0.11144298f, 
    0.05468745f, -0.10338520f, -0.02821545f, 0.04809349f, -0.01666923f, 0.05472074f, 0.02366725f, 0.02048572f, 
    0.01599972f, -0.12417721f, -0.20122023f, -0.14195153f, 0.10049019f, -0.18817106f, 0.00120711f, 0.08457752f, 
    -0.03641491f, -0.00386796f, -0.03940992f, -0.02500315f, -0.11439322f, -0.05912067f, 0.00165690f, -0.01891073f, 
    -0.07105567f, 0.01088396f, 0.04306690f, -0.03489774f, -0.00821956f, -0.07186073f, -0.01630217f, -0.08132801f, 
    0.23759809f, -0.20087433f, 0.13686551f, -0.10145634f, -0.14822228f, 0.02213238f, -0.10134853f, -0.00172783f, 
    -0.02380423f, 0.01053234f, -0.03621714f, 0.04481080f, -0.05958699f, -0.00865915f, -0.01678902f, -0.05950898f, 
    -0.01999007f, 0.09312421f, 0.00653726f, -0.04956326f, 0.35603830f, -0.27142525f, 0.22268647f, -0.12208369f, 
    0.07292669f, -0.07260156f, -0.00522334f, 0.08383027f, -0.02510906f, -0.04045181f, 0.03757068f, 0.00848092f, 
    -0.01378974f, 0.06901151f, 0.09916547f, -0.07011690f, -0.10242643f, -0.03302763f, -0.06116223f, -0.10528279f, 
    -0.27365515f, 0.04495557f, -0.27864870f, 0.11408786f, -0.10463758f, -0.02131871f, 0.04612250f, -0.17241517f, 
    -0.11438562f, -0.07657100f, 0.01293849f, 0.10338081f, 0.05856364f, -0.00555441f, 0.02113832f, 0.02033972f, 
    0.03399088f, -0.02575000f, -0.10654493f, -0.20073302f, 0.22257087f, -0.38361686f, 0.09234869f, -0.18313992f, 
    -0.27170274f, -0.08277161f, -0.01844063f, 0.00520648f, -0.00878747f, -0.08979329f, 0.07748141f, 0.00432409f, 
    -0.10530324f, 0.07906301f, -0.03023805f, 0.06056197f, 0.01861830f, 0.01162042f, -0.12378551f, -0.21189941f, 
    -0.07012840f, -0.03870960f, -0.20096849f, -0.02920643f, 0.02578699f, -0.03572539f, 0.09059304f, 0.10325582f, 
    0.00452524f, -0.00500344f, -0.01426767f, 0.03274101f, 0.01380322f, 0.02906885f, -0.03532285f, 0.10073039f, 
    -0.10722291f, -0.10993779f, -0.07378294f, -0.13884941f, -0.33293480f, -0.12066545f, 0.12960535f, 0.02262011f, 
    0.09292398f, 0.00710184f, -0.00923438f, 0.04771663f, -0.21153376f, 0.00874490f, -0.02815605f, 0.15833740f, 
    0.01556792f, 0.09410477f, 0.02602852f, 0.10297898f, 0.02201910f, -0.03810716f, 0.12195726f, 0.08670136f, 
    -0.27111334f, 0.39454719f, 0.16037573f, 0.12897997f, 0.09324224f, 0.07292146f, -0.06858139f, -0.02873816f, 
    0.07157104f, 0.08817854f, -0.08759074f, 0.05651883f, -0.15013672f, 0.04217724f, 0.02579389f, -0.08565350f, 
    -0.02537373f, 0.00853018f, 0.08863594f, -0.08307990f, -0.37491685f, -0.04065727f, 0.12345939f, 0.10758402f, 
    0.13290443f, -0.03605235f, 0.05215953f, -0.14029278f, 0.01952023f, -0.01815160f, -0.07349201f, 0.11698437f, 
    0.05689095f, 0.09360883f, 0.00639003f, 0.01921350f, -0.01648053f, -0.06256699f, 0.08718114f, 0.04396602f, 
    -0.40079787f, -0.05930226f, -0.01243823f, 0.00548499f, 0.08362053f, -0.08971389f, -0.00396721f, -0.34062555f, 
    -0.03434591f, -0.03449333f, -0.03568799f, 0.09098564f, 0.01108249f, -0.01946417f, -0.00632617f, 0.03682096f, 
    0.10752670f, -0.02752235f, 0.08841974f, -0.04561504f, -0.20104551f, -0.03662988f, 0.05970681f, 0.30969316f, 
    0.01072785f, -0.04048193f, -0.09164786f, 0.08733846f, 0.32275960f, 0.12770458f, -0.12749004f, -0.00458147f, 
    -0.00366381f, -0.02930093f, 0.06847992f, 0.02492776f, 0.07656213f, -0.01991501f, 0.24017355f, 0.20207377f, 
    0.02360287f, -0.19782302f, -0.06624282f, -0.03906232f, -0.00707464f, -0.17822996f, -0.01738918f, -0.03729018f, 
    -0.14505999f, -0.14603241f, -0.04619603f, -0.00629483f, -0.07702597f, 0.00855439f, 0.00912992f, 0.07160151f, 
    -0.23496124f, -0.22864145f, -0.16798592f, -0.11040363f, -0.07728694f, 0.04625365f, 0.07151143f, 0.11854003f, 
    0.13923255f, -0.04660642f, 0.02299982f, -0.10774124f, -0.05945635f, 0.02969046f, -0.04470552f, 0.10449536f, 
    -0.01581371f, 0.03204009f, -0.02717682f, 0.00643855f, 0.01919701f, -0.03570858f, 0.00129271f, 0.07231874f, 
    0.22229832f, -0.19541955f, 0.21968450f, -0.04892755f, 0.04765998f, 0.02450570f, -0.00974821f, 0.02835215f, 
    0.00336993f, -0.04726800f, 0.04934081f, -0.05338654f, 0.00548799f, 0.04542611f, -0.00613220f, -0.10476346f, 
    -0.14010024f, -0.00074941f, -0.09964240f, -0.17569734f, -0.17916314f, 0.00211834f, 0.16459325f, 0.07228523f, 
    0.14893773f, 0.00281874f, 0.00603180f, 0.07720000f, 0.10310278f, 0.06210123f, -0.05938042f, -0.11986778f, 
    -0.12016523f, 0.11254542f, 0.06244727f, 0.12771986f, -0.07713914f, -0.02108865f, -0.04070334f, 0.13969246f, 
    0.03310394f, 0.05079889f, 0.26466465f, 0.08169354f, -0.05880909f, 0.03962935f, -0.05326209f, -0.09462184f, 
    -0.01025253f, 0.02889285f, 0.01422053f, -0.06097135f, 0.14235388f, 0.07725854f, 0.01328172f, -0.02708732f, 
    0.07387827f, 0.12024123f, -0.01218549f, 0.07111064f, -0.21948609f, 0.12089978f, -0.41480881f, 0.05823709f, 
    0.05571176f, 0.12480389f, 0.05263583f, -0.02311308f, -0.02551869f, -0.00094213f, -0.11426387f, 0.08460204f, 
    -0.05920969f, -0.15113844f, -0.09629086f, -0.03192533f, -0.01804849f, -0.11519972f, 0.01555963f, -0.09447821f, 
    -0.59355795f, 0.10317418f, -0.45554194f, 0.19224247f, -0.22521190f, 0.01017861f, 0.08179477f, -0.10978693f, 
    0.12526408f, 0.03037528f, -0.05109385f, 0.00691743f, 0.02993354f, 0.01882999f, -0.02339390f, -0.00753648f, 
    0.03051935f, -0.07107001f, 0.03325098f, 0.07480612f, -0.20262092f, 0.02111688f, -0.11579965f, 0.05360650f, 
    0.01408021f, -0.00124640f, -0.03148467f, 0.05901997f, -0.01538282f, 0.02819002f, -0.00336081f, 0.07644654f, 
    0.05138537f, 0.06263706f, -0.05212738f, 0.09769335f, -0.05079679f, -0.03914502f, -0.04206993f, -0.08198608f, 
    0.19918390f, 0.06445734f, 0.23369610f, 0.14157182f, -0.09937484f, -0.07115925f, 0.07123813f, -0.00040755f, 
    0.06049542f, -0.06071585f, -0.08012171f, 0.05993338f, -0.02480376f, 0.02975033f, 0.03944810f, -0.10279439f, 
    -0.03310387f, 0.08569282f, -0.05024967f, -0.13846873f, 0.20232484f, 0.04892040f, 0.30320159f, 0.01922457f, 
    -0.01675720f, -0.02575598f, -0.06104273f, 0.03520713f, 0.13433704f, 0.08196335f, -0.01238011f, -0.01916706f, 
    -0.00734817f, -0.17218669f, -0.11401088f, -0.08179040f, 0.12643766f, 0.02374355f, 0.07089347f, 0.16742648f, 
    0.20954509f, 0.03497417f, 0.15099579f, 0.15376118f, 0.06901697f, -0.16724932f, 0.06115764f, -0.01022279f, 
    0.00109332f, -0.02520971f, -0.07856335f, 0.01533292f, -0.04287783f, 0.03682602f, 0.06724484f, -0.04896708f, 
    -0.08656802f, -0.00222912f, -0.04025739f, -0.01034967f, -0.27967587f, -0.25078666f, -0.24211144f, 0.14338417f, 
    0.19150241f, 0.13912168f, 0.08890979f, 0.15578546f, -0.20638663f, 0.04865065f, -0.03780314f, 0.03869431f, 
    -0.00477607f, 0.07031549f, 0.01632886f, -0.07899442f, 0.00590413f, 0.08348504f, 0.08923367f, 0.04024529f, 
    0.25878680f, 0.06028207f, 0.16264628f, -0.02049726f, 0.06913821f, 0.03406102f, 0.18168059f, -0.07105394f, 
    -0.00197795f, -0.03071667f, -0.10499042f, 0.09155291f, 0.03877406f, 0.07008390f, 0.00108939f, -0.07264642f, 
    -0.09115802f, -0.01790600f, -0.28162795f, 0.01039235f, 0.01121154f, -0.23836979f, -0.12004393f, -0.20935847f, 
    -0.05905733f, 0.01096691f, -0.07739983f, 0.05976954f, -0.02006238f, -0.03548409f, 0.00681121f, 0.04831632f, 
    0.06811357f, -0.01292343f, -0.01199593f, 0.08314481f, 0.05946645f, -0.02164170f, 0.02137731f, 0.03673209f, 
    0.10691209f, -0.53183973f, 0.36611393f, -0.49497682f, 0.35034364f, 0.09379549f, 0.11682588f, 0.10617569f, 
    0.06395257f, -0.06222555f, -0.09688149f, -0.03179052f, -0.00838814f, 0.05246934f, -0.00143616f, 0.03293294f, 
    0.13983566f, 0.14915730f, -0.22551839f, 0.04403239f, -0.04650487f, -0.29656777f, -0.15819396f, 0.02107948f, 
    0.12838621f, 0.06115203f, -0.08446807f, -0.05609645f, -0.09827343f, -0.06986903f, 0.04133559f, 0.01570296f, 
    -0.14564253f, -0.03709850f, -0.19457299f, 0.04757436f, -0.08303094f, 0.06864343f, -0.13914022f, -0.20098148f, 
    -0.17285128f, -0.02017613f, -0.26864076f, 0.35466519f, 0.00368446f, -0.11498975f, 0.12147179f, -0.01028748f, 
    0.19265015f, -0.00402097f, -0.14970064f, -0.03147646f, 0.03126622f, -0.02394603f, 0.09498141f, -0.03883526f, 
    -0.03102443f, 0.08399215f, -0.14920045f, -0.07153092f, -0.48832196f, -0.15756045f, -0.47949848f, 0.11878064f, 
    -0.26874378f, -0.04598900f, 0.01558073f, -0.01082323f, -0.00180538f, 0.06924492f, -0.04154245f, -0.09435736f, 
    0.01109540f, -0.05788153f, -0.05914615f, -0.02679961f, -0.10005798f, -0.04916839f, -0.00241334f, 0.02340892f, 
    -0.07752758f, 0.20195821f, 0.09838933f, 0.19453429f, -0.22780043f, 0.02721842f, -0.01474262f, 0.21032321f, 
    -0.01291691f, -0.06809716f, -0.13347273f, -0.00858710f, -0.08052650f, -0.07476502f, 0.05000197f, 0.00105214f, 
    -0.10903225f, 0.10437599f, 0.12473453f, -0.11721337f, -0.09409349f, 0.05619740f, -0.25709030f, 0.43281496f, 
    0.44282040f, 0.13358736f, 0.17073545f, -0.15156531f, 0.13684358f, 0.04645434f, 0.04856860f, 0.08945715f, 
    -0.10127357f, -0.04227956f, -0.03192313f, 0.13139646f, 0.07729239f, -0.06226851f, 0.08097021f, 0.09216578f, 
    -0.20899837f, 0.01878989f, -0.12522741f, -0.09356541f, -0.23454490f, 0.07189684f, 0.12925331f, 0.05479318f, 
    -0.08518253f, 0.06485817f, -0.09118713f, -0.05540627f, 0.06970587f, 0.17320774f, 0.01771421f, -0.07729309f, 
    0.01640970f, 0.02026300f, -0.03873612f, 0.07922165f, 0.08905619f, -0.27306265f, -0.17852935f, -0.12082016f, 
    -0.10505794f, 0.05168701f, -0.26489487f, -0.06828076f, -0.01869340f, -0.09623323f, -0.01386821f, 0.03945531f, 
    -0.01183194f, -0.06032031f, -0.07520019f, 0.06575649f, 0.03664419f, 0.10457297f, 0.06812254f, -0.04572654f, 
    -0.14669482f, 0.01168842f, -0.09851880f, 0.33294222f, 0.09753548f, -0.14811228f, 0.08857959f, 0.00391560f, 
    0.11478254f, 0.08589851f, -0.16490354f, -0.00794175f, -0.00190350f, 0.10942958f, -0.02230328f, -0.05365594f, 
    0.05694709f, -0.02322734f, -0.09604298f, -0.13154936f, 0.13908720f, -0.53147960f, 0.33526731f, -0.03554206f, 
    0.02590454f, -0.00757179f, 0.00838489f, -0.07642483f, 0.00753279f, -0.17266767f, -0.06047746f, -0.02720803f, 
    0.02132434f, -0.00299039f, 0.01311079f, 0.11852843f, 0.00618045f, 0.15912500f, 0.10039692f, -0.08311497f, 
    -0.43383557f, -0.21847016f, -0.42982244f, 0.05600350f, -0.41589102f, 0.00616302f, -0.00543651f, -0.00037643f, 
    -0.09907139f, 0.05183552f, -0.12604836f, -0.05327093f, 0.11348948f, 0.05957597f, 0.05174556f, 0.04380182f, 
    0.05226257f, 0.08692771f, -0.06576215f, 0.10184167f, 0.33500040f, 0.23600033f, 0.41075879f, 0.07425478f, 
    -0.23598284f, -0.12432966f, 0.02492638f, 0.02521314f, -0.11371527f, -0.03472560f, -0.08838459f, -0.01418442f, 
    0.01630562f, -0.01133020f, -0.05770328f, -0.04357255f, -0.01988989f, 0.04666803f, -0.04771031f, 0.10593319f, 
    -0.23050100f, -0.04118427f, -0.34715894f, 0.13396677f, 0.03238691f, -0.15086974f, 0.18416347f, 0.10041039f, 
    -0.15556584f, 0.11189514f, 0.02119713f, 0.09378489f, 0.19162491f, -0.01062762f, -0.01707739f, 0.02866343f, 
    0.05508828f, 0.03625973f, 0.12443311f, 0.08530561f, 0.14621632f, -0.51131988f, -0.04469440f, -0.06150841f, 
    0.27978015f, -0.05747112f, -0.10066286f, -0.10421620f, 0.08071497f, -0.07048471f, 0.02077691f, 0.08737429f, 
    0.05745549f, -0.01767801f, -0.03289415f, 0.10623066f, 0.02504759f, -0.10441521f, 0.11179542f, 0.06639200f, 
    -0.03139818f, -0.14006062f, 0.14580314f, -0.00590798f, 0.15327702f, 0.03091409f, 0.12849474f, -0.14480057f, 
    0.22022229f, 0.11614763f, -0.09274744f, 0.07944826f, -0.00033867f, 0.00846427f, 0.02305483f, -0.07174160f, 
    -0.04926356f, -0.01465818f, -0.05299469f, -0.08038492f, -0.30759007f, -0.14403278f, -0.05095948f, 0.23231688f, 
    -0.03872662f, -0.06055497f, -0.18592861f, -0.00367284f, -0.00130293f, -0.06299853f, -0.01204278f, 0.07223138f, 
    -0.06501465f, -0.02605721f, 0.04894894f, 0.07177881f, -0.09158788f, 0.13006246f, 0.04768174f, -0.13839366f, 
    -0.30001467f, 0.13777384f, -0.21909849f, 0.31119263f, -0.09486242f, 0.03803683f, 0.04560414f, -0.04005520f, 
    -0.04761894f, 0.09823625f, -0.14129470f, -0.17950176f, -0.01157701f, 0.26712552f, -0.01215299f, -0.00340134f, 
    0.03150318f, 0.17751946f, 0.08654695f, -0.02822665f, -0.40618429f, -0.08031232f, -0.02755988f, 0.09314449f, 
    -0.14032051f, 0.07838429f, 0.04319804f, 0.02380192f, -0.03006777f, 0.05407827f, -0.06059588f, 0.09151413f, 
    0.06215511f, 0.12043174f, -0.11617794f, 0.04822180f, 0.03222982f, -0.08397433f, -0.03194077f, -0.20311387f, 
    -0.30712289f, 0.02438570f, 0.10403689f, 0.23261884f, -0.04439558f, -0.12125427f, 0.01651987f, 0.00880822f, 
    -0.16830951f, 0.10163584f, -0.02747800f, 0.05455940f, 0.06531753f, -0.03680318f, -0.00140216f, 0.12970652f, 
    0.06874325f, 0.24208444f, 0.07934345f, -0.07141583f, 0.21424733f, 0.08827292f, 0.13697617f, -0.22383069f, 
    0.24844313f, 0.10046702f, 0.16705789f, 0.09224586f, 0.04072903f, -0.01570093f, 0.07951533f, 0.09920334f, 
    0.11585637f, 0.05089345f, 0.11787017f, 0.00508654f, -0.07421486f, -0.11981115f, -0.00549937f, -0.09255373f, 
    -0.12271615f, -0.19900197f, -0.03988335f, 0.17993444f, 0.07178758f, -0.06611726f, 0.03926177f, 0.03615267f, 
    0.05295997f, -0.04893058f, -0.01977112f, -0.00451667f, -0.07427564f, -0.14639173f, 0.05527728f, -0.12888487f, 
    -0.07321232f, 0.02550806f, -0.09424167f, -0.19984277f, 0.15096729f, 0.10117046f, 0.19819817f, 0.00595244f, 
    -0.09129364f, -0.02039744f, 0.10254431f, 0.01785143f, 0.04802118f, -0.04002435f, -0.05316610f, 0.02250837f, 
    0.04898400f, -0.04640837f, 0.01321901f, -0.00140759f, 0.01132889f, -0.04981059f, -0.17540441f, -0.11030117f, 
    0.08291788f, -0.21974166f, -0.08395118f, -0.39653668f, 0.01396789f, -0.01171255f, -0.01089907f, 0.00250877f, 
    -0.05129256f, -0.09648941f, -0.01585348f, 0.04425953f, 0.07372090f, -0.05875227f, -0.05078273f, 0.03646706f, 
    0.06636874f, 0.03204700f, 0.00978279f, -0.07622935f, -0.18403932f, -0.13368797f, -0.20868300f, 0.12230316f, 
    0.00101717f, -0.06357716f, -0.06465257f, 0.00192406f, -0.11933540f, 0.04598361f, 0.03157625f, 0.01725649f, 
    -0.06551058f, -0.11355034f, -0.12055971f, 0.01819493f, -0.14363845f, -0.06673588f, -0.12660517f, -0.14037649f, 
    -0.45924270f, 0.06231552f, -0.27515084f, 0.10361010f, -0.17388204f, 0.02108001f, 0.07765909f, 0.06887940f, 
    -0.02146608f, -0.00922874f, -0.10434134f, -0.12484164f, 0.05810881f, 0.02029872f, 0.06676833f, 0.09694705f, 
    -0.03871882f, 0.02858583f, -0.05361952f, -0.03022652f, 0.00343327f, 0.14844972f, -0.01868572f, -0.03494243f, 
    0.01553991f, -0.01332118f, 0.04853901f, 0.10937060f, 0.07589940f, 0.02422055f, -0.02721306f, -0.03570989f, 
    -0.01096662f, -0.04778476f, 0.12327863f, 0.05163915f, -0.08376272f, -0.04283208f, -0.03805602f, -0.18861829f, 
    0.05196783f, -0.16983177f, 0.18783560f, 0.17644797f, 0.02478957f, -0.11908862f, 0.02335346f, 0.02431869f, 
    0.13978915f, -0.09339540f, -0.08451663f, -0.07160668f, -0.01179361f, 0.05690601f, 0.03929629f, 0.01924296f, 
    -0.01548289f, 0.15526836f, 0.04145679f, -0.07996863f, -0.18353082f, 0.08753715f, -0.03940503f, 0.02838887f, 
    0.02035336f, -0.03362997f, 0.01794306f, 0.00776953f, -0.04053092f, 0.03691819f, -0.02707256f, 0.00793214f, 
    0.02525295f, -0.01139247f, 0.01240955f, 0.12518658f, 0.03725912f, 0.03324617f, 0.01053455f, -0.11623768f, 
    -0.18135011f, 0.05639116f, -0.18548483f, -0.07451817f, -0.08862482f, -0.00504692f, 0.08938709f, -0.12664431f, 
    0.10236064f, -0.00581077f, -0.02189678f, -0.03372543f, 0.01848277f, -0.01196274f, -0.04022788f, 0.00520741f, 
    0.00543211f, 0.02892739f, 0.01958068f, 0.04692361f, 0.07362387f, -0.16252095f, 0.02396520f, -0.22628467f, 
    -0.17386115f, -0.03171790f, -0.10392714f, -0.07038693f, 0.00483160f, 0.05592502f, -0.03833019f, 0.02945024f, 
    0.11497667f, 0.02516106f, -0.06438053f, -0.03137109f, 0.02947817f, 0.02629666f, 0.07137261f, 0.01971005f, 
    0.33666360f, -0.02806634f, 0.23241217f, 0.18420634f, -0.08921982f, -0.08293999f, 0.06959818f, -0.14560644f, 
    0.06985595f, -0.01516879f, -0.05956086f, 0.02102485f, -0.04128145f, -0.00726468f, -0.02097218f, 0.00383513f, 
    0.01181236f, 0.01202816f, -0.06024460f, 0.10362003f, 0.19360544f, -0.34959835f, 0.11812889f, 0.18886520f, 
    0.15217370f, -0.17673272f, -0.11523858f, -0.18614791f, 0.05723658f, -0.14874451f, -0.02326851f, -0.01110944f, 
    0.03519539f, -0.01222997f, 0.04028681f, 0.03894787f, 0.01048207f, -0.02177930f, 0.13481446f, 0.04138404f, 
    -0.11735223f, 0.01362945f, 0.01744474f, 0.06385315f, -0.09593247f, -0.00321733f, -0.01223604f, 0.04031309f, 
    -0.00526413f, -0.01382904f, -0.07868614f, 0.02658440f, 0.04164497f, 0.11714070f, -0.03124494f, -0.04607917f, 
    0.00996442f, 0.00324355f, -0.01149547f, -0.07766654f, 0.29076055f, -0.53894091f, 0.22785720f, 0.03809330f, 
    0.01722999f, -0.11254422f, 0.19327837f, -0.07963354f, 0.27980581f, -0.25098586f, -0.19134362f, -0.00080204f, 
    -0.04936505f, 0.03963893f, 0.14075093f, -0.01993268f, -0.04539363f, 0.13232565f, 0.05985229f, -0.06707381f, 
    0.71331626f, -0.25928649f, 0.66450918f, 0.18264967f, 0.07337551f, 0.00800509f, 0.13334168f, -0.24578634f, 
    0.16891663f, -0.01628386f, -0.12660728f, 0.07242810f, -0.09380765f, 0.03648065f, -0.03160514f, 0.00015647f, 
    0.11667778f, 0.01099463f, 0.12593861f, 0.03240447f, -0.20725009f, -0.31656539f, 0.06038431f, 0.04914989f, 
    0.03101932f, 0.20955315f, 0.17043154f, 0.08394934f, -0.12510136f, 0.13325648f, 0.00456359f, -0.02220760f, 
    0.07135610f, 0.10038844f, -0.01741052f, -0.00265262f, 0.02022569f, 0.14936458f, -0.01701169f, 0.02315439f, 
    0.34900057f, 0.01898557f, 0.28306821f, -0.04223715f, 0.10586503f, -0.00782686f, 0.04803358f, 0.00257006f, 
    0.10310714f, -0.13215140f, -0.07325856f, -0.09297884f, -0.01742813f, -0.10027312f, -0.07853318f, 0.03859833f, 
    -0.01405034f, -0.03028326f, -0.07667614f, 0.08324346f, 0.19144773f, 0.08837508f, 0.17417122f, 0.01293725f, 
    0.12241204f, -0.04259600f, -0.07330796f, -0.06939004f, 0.10799407f, -0.05105744f, -0.04856491f, 0.03542954f, 
    -0.01448628f, -0.02113786f, -0.02802588f, 0.03473647f, -0.04674727f, -0.16285019f, -0.00419553f, 0.09633190f, 
    -0.09174324f, -0.19568934f, -0.00667941f, 0.00497750f, 0.02300681f, -0.10546141f, -0.27847064f, -0.06333091f, 
    0.08852393f, -0.22099876f, -0.06550128f, -0.00990293f, -0.00263493f, 0.03068685f, 0.04054878f, 0.04172240f, 
    0.01207714f, 0.07048616f, 0.19060794f, -0.03967978f, -0.11417507f, -0.04251032f, -0.03293619f, 0.00202719f, 
    0.01422576f, 0.01998333f, 0.00996593f, 0.03385319f, -0.06756009f, -0.03431523f, -0.04602985f, 0.00818597f, 
    -0.00840743f, 0.02977791f, 0.02630053f, 0.05274481f, 0.08128297f, 0.04514166f, 0.05402214f, -0.09853193f, 
    -0.22480823f, -0.10993085f, -0.13255738f, -0.10116440f, 0.05388740f, 0.03454867f, 0.08143567f, 0.01393415f, 
    -0.01025369f, 0.04624447f, 0.03527471f, 0.01365699f, 0.03137152f, 0.03501618f, 0.01745747f, -0.00716175f, 
    0.00761995f, -0.00436839f, 0.03612234f, -0.05217162f, -0.19212313f, -0.10721251f, -0.05135164f, -0.21440549f, 
    0.26296592f, 0.09993430f, 0.05905106f, 0.08336872f, -0.02873226f, -0.00143776f, -0.15875274f, 0.12871395f, 
    0.02551647f, 0.04409496f, 0.12683788f, -0.03617936f, 0.03767670f, 0.11012702f, 0.09734941f, -0.00930131f, 
    0.04309215f, -0.24029145f, -0.32839042f, -0.30845332f, -0.00162191f, -0.04484680f, -0.14886554f, 0.04508102f, 
    -0.00011717f, -0.16479245f, 0.00083593f, 0.01333652f, 0.05322655f, -0.00876723f, -0.01193206f, 0.07265846f, 
    -0.01590734f, 0.05399110f, 0.09324565f, 0.08765943f, -0.02548772f, -0.16218740f, -0.11473835f, -0.04681760f, 
    0.13962330f, 0.00124570f, 0.03295189f, -0.04479874f, -0.01764642f, -0.00918928f, -0.02034365f, -0.02845824f, 
    0.00526939f, -0.00376376f, -0.03554608f, -0.00222753f, 0.03294985f, 0.04824024f, -0.01099596f, -0.09008709f, 
    0.01724244f, -0.26480094f, -0.19062832f, -0.15426193f, 0.05885067f, -0.10311897f, -0.12378146f, 0.04184920f, 
    -0.00399791f, -0.06943458f, 0.04363573f, 0.01170373f, 0.01970686f, -0.07851134f, 0.03463492f, 0.03105992f, 
    0.05433626f, -0.08811170f, 0.08163750f, 0.02661128f, 0.04189789f, -0.36377054f, 0.11812007f, 0.03101130f, 
    0.07364535f, -0.04170866f, -0.25030863f, -0.01529571f, -0.08790951f, -0.09662519f, 0.07246606f, -0.02609547f, 
    -0.00761035f, -0.00794023f, -0.05820726f, -0.05873362f, -0.03776639f, -0.04469540f, 0.00490573f, -0.02212729f, 
    -0.95104682f, 0.08314124f, -0.40531349f, 0.37997779f, -0.03327126f, 0.00556985f, 0.16964239f, 0.02126737f, 
    0.17247172f, -0.01856565f, -0.19392192f, -0.00814141f, -0.06548458f, 0.06195553f, -0.12275580f, 0.06813270f, 
    0.07438879f, 0.06464417f, -0.07793409f, 0.10428776f, -0.09248128f, -0.24732749f, -0.18299013f, 0.05774673f, 
    -0.10063352f, -0.01662418f, -0.26965520f, 0.02307597f, -0.20112193f, 0.01230349f, -0.00862539f, 0.00925832f, 
    -0.02858098f, -0.02688507f, -0.10719520f, 0.07224299f, -0.04199055f, 0.03989922f, 0.13906124f, -0.00911918f, 
    -0.01735231f, -0.08223127f, -0.05499204f, -0.20486012f, -0.42967063f, 0.02026958f, -0.16320871f, -0.20113830f, 
    -0.00457815f, 0.05118765f, 0.00019617f, 0.07968797f, -0.01197892f, -0.11877680f, -0.00589297f, 0.05624276f, 
    0.00362282f, 0.06307204f, -0.07654510f, 0.03652932f, -0.07019135f, -0.02005845f, 0.12636641f, 0.11515170f, 
    -0.27370739f, -0.04611162f, -0.00678469f, 0.15181461f, -0.02264228f, -0.04903366f, -0.04949768f, -0.01262357f, 
    0.10572098f, -0.02460465f, 0.05114250f, 0.05796485f, 0.03630649f, 0.00586930f, -0.09512586f, -0.20454881f, 
    0.39274877f, -0.01558305f, 0.26022032f, 0.00038957f, -0.14432731f, -0.06330500f, -0.03656222f, -0.06347427f, 
    -0.05769979f, -0.01954665f, -0.07033396f, 0.01299767f, -0.02029652f, -0.10222038f, -0.07473286f, 0.04075849f, 
    0.10613895f, -0.01093752f, 0.08730293f, 0.00268571f, -0.11456285f, -0.17702956f, -0.20237547f, 0.20824379f, 
    -0.21645176f, -0.08021285f, -0.06963316f, -0.04350140f, 0.00415871f, 0.05204930f, -0.04731064f, -0.03387364f, 
    0.00817518f, -0.09666575f, -0.10725552f, 0.03505697f, -0.05511297f, -0.04478105f, 0.00458126f, -0.04231504f, 
    -0.33768034f, -0.13934216f, -0.21616158f, -0.04812596f, 0.28181532f, -0.03220768f, 0.13888787f, 0.11842113f, 
    -0.02004843f, 0.06279530f, 0.03002132f, 0.10595883f, 0.05411029f, 0.00486193f, 0.09545707f, -0.04148222f, 
    0.04799943f, 0.12356574f, 0.15099484f, -0.03645949f, 0.27813071f, -0.39780483f, 0.27549085f, 0.09817487f, 
    0.06347533f, 0.01792945f, -0.16259113f, 0.01208935f, -0.03848320f, -0.07111422f, 0.15957218f, -0.10111825f, 
    -0.04335912f, -0.05449012f, 0.02229778f, 0.03008089f, 0.08818988f, 0.09470011f, -0.00529310f, -0.11237977f, 
    -0.03123284f, 0.08811816f, -0.23538311f, 0.20178699f, 0.21959770f, -0.03082224f, 0.12498905f, -0.01983403f, 
    0.02760398f, 0.07836945f, 0.00750057f, 0.01441090f, -0.01490605f, 0.11311951f, 0.03240258f, 0.00871886f, 
    0.01119367f, 0.04271299f, -0.08650821f, 0.00601113f, -0.40899971f, -0.13906246f, -0.35304534f, 0.09382420f, 
    -0.32359210f, 0.12134411f, 0.10718563f, 0.01452562f, -0.15585449f, 0.05877847f, -0.05909808f, 0.00585716f, 
    0.10967467f, 0.19884260f, 0.08277458f, 0.05989138f, 0.11150897f, 0.16264609f, -0.01807297f, 0.06198327f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14061978f, 0.11498176f, 0.02554828f, -0.09542466f, -0.00866334f, 0.04516933f, 0.04566171f, -0.06748164f, 
    0.02628563f, 0.03076007f, 0.01475835f, -0.03653267f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
