#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.04581419f, 0.18939435f, -0.10944107f, -0.67355525f, -0.55776447f, -0.00431591f, 0.10138613f, 0.29898748f, 
    -0.00660601f, -0.07270447f, 0.09534725f, -0.12362799f, -0.24215269f, -0.09881709f, 0.33834344f, -0.32272571f, 
    -0.30961311f, -0.20744990f, 0.10654967f, -0.44079703f, 0.27951017f, -0.04719256f, -0.11895403f, 0.03648316f, 
    0.52547997f, 0.65608627f, -0.88309306f, 0.22627874f, -0.46923235f, -0.47631836f, 0.37451568f, -0.21479163f, 
    -0.20092970f, 0.28490070f, 0.04569081f, -0.28722697f, -0.21271746f, 0.39627582f, -0.06406771f, 0.13261044f, 
    -0.31475213f, -0.06865086f, 0.02136522f, -0.35217783f, 0.01522856f, -0.01693765f, -0.08960400f, -0.01875740f, 
    0.10482493f, 0.13509873f, 0.18303265f, -0.11285057f, -0.43496832f, -0.68917304f, -0.16797733f, 0.03881920f, 
    -0.19239403f, -0.10721710f, -0.25715396f, -0.22652327f, 0.42360035f, 0.41543359f, 0.55015767f, 0.28215688f, 
    -0.06694442f, -0.13926883f, -0.23735972f, 0.03998664f, 0.15477028f, -0.02712357f, 0.19893335f, -0.09059792f, 
    -0.14309537f, -0.17692837f, -0.16353540f, -0.74868464f, -0.30196241f, 0.27229661f, -0.15770920f, -0.52863497f, 
    -0.11057793f, 0.07718525f, 0.21011029f, 0.42164993f, 0.33491647f, 0.05014146f, -0.24325930f, 0.23648612f, 
    0.25309750f, -0.09302173f, -0.05633159f, 0.07761493f, 0.28936699f, -0.10910645f, -0.10200609f, 0.14499114f, 
    0.21246141f, 0.15212570f, -0.40318304f, 0.14618988f, -0.70080620f, -0.45357546f, 0.26880711f, 0.53528112f, 
    0.21925811f, -0.19519417f, -0.71514678f, -0.42651147f, 0.43763337f, 0.26096532f, -0.11343339f, -0.18103933f, 
    -0.08403392f, 0.14354716f, -0.28069448f, -0.13036333f, 0.26420626f, -0.08634192f, -0.07439736f, 0.27383527f, 
    0.00298778f, 0.23281564f, -0.02844724f, 0.02136214f, 0.09845995f, -0.32924107f, -0.46839646f, 0.16290684f, 
    -0.00674866f, -0.50530440f, -0.28292373f, -0.09723412f, -0.36091065f, -0.17528968f, -0.48038688f, -0.09963123f, 
    -0.25524944f, 0.09120306f, 0.26259643f, -0.23368260f, -0.19706950f, -0.33172530f, 0.05297510f, -0.29337820f, 
    0.06604079f, 0.11215463f, 0.22607478f, -0.07739845f, -0.09420979f, 0.17590480f, 0.51404226f, -0.05745709f, 
    -0.01868190f, 0.19765629f, 0.00788862f, -0.39350510f, 0.04282392f, 0.41988674f, 0.02011056f, -0.02692871f, 
    -0.01623737f, 0.14719483f, 0.21214028f, 0.03606723f, -0.22509953f, -0.00961417f, 0.01767600f, -0.18984601f, 
    -0.27780908f, -0.03065395f, 0.11206842f, -0.08555849f, 0.10579951f, -0.02714246f, 0.11955002f, 0.17226292f, 
    0.44035894f, -0.23179017f, -0.27152312f, 0.03123207f, 0.21212639f, -0.17890683f, 0.06390356f, -0.37442136f, 
    -0.27738380f, -0.10232767f, 0.19518293f, -0.25162986f, 0.40101358f, -0.04247702f, 0.31810975f, -0.37335688f, 
    -0.38456708f, -0.13031240f, -0.28258008f, 0.17953141f, 0.28456604f, 0.24409184f, 0.30211303f, 0.08471842f, 
    0.60160410f, 0.55707741f, 0.32405773f, 0.20744969f, -0.12328251f, -0.28321791f, -0.27420172f, -0.15899195f, 
    -0.06398165f, -0.25434467f, -0.05600889f, -0.06985553f, 0.32661909f, -0.23858158f, -0.63101614f, 0.13466722f, 
    -0.21408097f, 0.16328262f, 0.18751344f, -0.17781374f, -0.16686940f, 0.04197224f, 0.10592481f, -0.06573012f, 
    0.29768196f, 0.26607522f, 0.15455177f, 0.02112191f, -0.27585572f, -0.26698107f, -0.01885185f, 0.05688646f, 
    -0.14771485f, 0.09408500f, 0.24898162f, 0.16121456f, 0.05941363f, -0.26378712f, 0.14639407f, -0.07061859f, 
    0.02299884f, -0.02349103f, -0.05274462f, -0.05493422f, 0.10907181f, 0.00178495f, -0.06648383f, 0.21466602f, 
    -0.17489929f, 0.17239225f, -0.10450409f, -0.49793470f, -0.58077735f, 0.52665335f, 0.77711833f, -0.34450337f, 
    0.82322490f, -0.39791927f, -0.62085581f, -0.62228531f, -0.02425207f, -0.21822624f, 0.29421538f, 0.19952831f, 
    -0.18186820f, -0.13638066f, -0.18633528f, 0.18721005f, 0.27422100f, 0.16815844f, -0.09522839f, -0.03622238f, 
    -0.13637434f, -0.20480870f, 0.13323455f, 0.59384394f, 0.34236524f, 0.01498094f, 0.25615087f, 0.00458920f, 
    -0.28842977f, -0.05919963f, -0.31348059f, -0.26332784f, -0.01909175f, -0.06878082f, 0.18644786f, 0.05700524f, 
    -0.18912727f, 0.19148512f, 0.21515243f, 0.17092586f, 0.02735244f, 0.25390044f, -0.28420171f, 0.22516760f, 
    -0.07718755f, -0.02980612f, -0.00852108f, -0.01949819f, 0.06741367f, -0.27628985f, 0.10351582f, 0.56556547f, 
    0.06227885f, -0.39787281f, -0.37561259f, 0.37492800f, -0.01678627f, -0.16517767f, 0.21938057f, 0.06322930f, 
    -0.04967288f, 0.22263303f, -0.13752922f, -0.35776865f, 0.01554930f, 0.22587243f, -0.22303723f, 0.19648854f, 
    -0.14257203f, 0.08170000f, -0.08004493f, 0.09690353f, -0.11904763f, 0.25067568f, -0.37801793f, -0.52961159f, 
    -0.19386248f, -0.53658283f, 0.71038330f, 0.03789074f, 0.70693290f, -0.24475701f, 0.01214981f, 0.02320825f, 
    -0.17920817f, -0.13927534f, -0.37953401f, -0.15203172f, 0.26902390f, 0.19082211f, 0.11804686f, 0.01083042f, 
    0.28229225f, -0.08007460f, -0.13636731f, -0.03170624f, 0.06963736f, 0.10025192f, 0.43975788f, 0.81211787f, 
    0.39133951f, -0.72108907f, -0.52631247f, 0.20299181f, -0.08477902f, 0.01290026f, -0.34527239f, -0.04315815f, 
    -0.07559022f, -0.19526468f, 0.02219997f, 0.27398628f, -0.15127370f, 0.11855651f, -0.29260641f, -0.21173431f, 
    0.25467885f, -0.06621595f, 0.11207464f, 0.01802500f, -0.02400968f, 0.03730337f, 0.02863733f, 0.21856718f, 
    -0.54767847f, 0.13492523f, 0.25573274f, 0.15789801f, 0.15173084f, 0.18585576f, 0.23975345f, -0.41703597f, 
    0.16007726f, -0.10266565f, -0.13008156f, 0.14840113f, -0.39935160f, -0.13641304f, 0.10721766f, 0.30828887f, 
    -0.26882574f, 0.07398593f, -0.16060948f, -0.14764088f, -0.32364926f, -0.07707359f, 0.03921921f, 0.22808729f, 
    0.48415294f, 0.11536206f, 0.15808907f, 0.09509601f, -0.43717745f, -0.02497226f, 0.34074634f, 0.39427099f, 
    -0.31180134f, -0.04633796f, -0.34690887f, -0.00763018f, 0.07854118f, -0.17531006f, -0.03958832f, 0.36686367f, 
    0.09946347f, -0.17021644f, -0.07852016f, -0.35053030f, 0.11409855f, -0.11079903f, 0.27613664f, 0.02633251f, 
    -0.27843738f, 0.30881956f, -0.77505416f, -0.34882420f, 0.06196881f, 0.40309221f, 0.24995318f, 0.21656834f, 
    -0.11465910f, -0.04282039f, 0.04854407f, -0.29102424f, -0.32006088f, -0.36331969f, -0.25635561f, 0.36775577f, 
    -0.12837371f, -0.10067682f, -0.05429975f, 0.14948682f, -0.25716874f, -0.15789427f, -0.07936297f, -0.08895626f, 
    -0.49567592f, -0.58919013f, 0.36221507f, 0.02489271f, -0.47611067f, -0.46408400f, -0.01048977f, 0.37923953f, 
    0.61365229f, 0.40256748f, -0.53001308f, -0.17292890f, -0.04580777f, -0.23456663f, -0.16983294f, -0.02521151f, 
    -0.18894218f, -0.12522745f, 0.11942396f, 0.45228007f, -0.28515646f, -0.04661651f, 0.23677661f, -0.43416104f, 
    -0.27397215f, 0.38885283f, -0.31398842f, -0.23114957f, -0.56090206f, -0.42496681f, 0.48716509f, 0.17997073f, 
    -0.70330966f, -0.54341751f, -0.25842544f, -0.31174847f, -0.43703875f, 0.12626776f, 0.51075912f, -0.07257064f, 
    0.60575235f, -0.34136629f, 0.12501539f, 0.23490435f, 0.02810864f, -0.15757257f, -0.14470045f, -0.29633459f, 
    0.05841542f, -0.06898127f, -0.24570961f, 0.32253861f, -0.55641973f, -0.25649640f, -0.23472106f, 0.35388115f, 
    -0.17284065f, 0.06958742f, 0.27085987f, -0.20142241f, 0.04390966f, 0.61502218f, 0.04791872f, 0.02355560f, 
    0.10892804f, -0.22404675f, 0.16635333f, -0.33785456f, -0.29629150f, 0.12500012f, 0.02106680f, -0.16899237f, 
    0.39045244f, 0.03132560f, -0.08269387f, 0.41796955f, -0.00552794f, -0.18414211f, -0.37492397f, -0.12611899f, 
    0.34970796f, 0.29465654f, 0.53188646f, -0.38628602f, 0.04934471f, -0.14127873f, 0.36995998f, 0.15144753f, 
    0.25965390f, -0.07025242f, -0.21242540f, -0.23507658f, -0.32283086f, -0.15866736f, 0.36819643f, -0.01821191f, 
    -0.06255205f, -0.30700746f, 0.19672179f, 0.03779257f, 0.04111744f, 0.17132683f, -0.74776852f, -0.26497626f, 
    -0.13028151f, -0.47758052f, -0.45687664f, 0.73479402f, -0.32114559f, -0.38474452f, -0.16768251f, 0.02091437f, 
    -0.31193396f, -0.20136355f, -0.02617704f, -0.18625289f, -0.27281696f, 0.21082760f, 0.18562795f, 0.14239080f, 
    0.09995601f, 0.03815690f, 0.06686453f, 0.25105190f, 0.22114953f, -0.06465130f, 0.16855074f, -1.06415963f, 
    -0.60533500f, 0.01447893f, 0.33610925f, 0.72083610f, -0.30877054f, -0.37257773f, 0.17924385f, 0.74326342f, 
    0.00088937f, 0.01504418f, -0.24305741f, 0.14815098f, -0.10954779f, 0.13279477f, 0.19916190f, -0.19744405f, 
    -0.19223775f, -0.19036689f, 0.20389999f, -0.12687796f, 0.16736157f, -0.17510702f, -0.17861933f, 0.49351159f, 
    -0.14840718f, -0.14765634f, 0.07225478f, 0.31447440f, -0.07961041f, -0.41463289f, 0.33147055f, 0.07655953f, 
    0.18797792f, -0.10873117f, -0.10708578f, -0.00901355f, 0.08334532f, 0.54715228f, -0.56217915f, 0.02728149f, 
    0.23555969f, 0.05495868f, -0.12925802f, -0.23913522f, 0.12370826f, -0.05518081f, 0.33948201f, -0.13305742f, 
    -0.21873635f, 0.43341333f, -0.06899390f, 0.21312514f, -0.11755992f, -0.02154534f, 0.22477809f, -0.21164447f, 
    0.00167974f, -0.13534656f, 0.34867638f, -0.18735628f, 0.26415357f, -0.21528172f, -0.41409853f, 0.04162528f, 
    -0.04272873f, 0.04755242f, -0.11259426f, -0.09594371f, -0.29014736f, -0.39739752f, -0.36234751f, -0.31298012f, 
    -0.32006904f, -0.34813997f, 0.48176652f, -0.29122108f, 0.10518509f, 0.55059612f, 0.27440381f, 0.07603160f, 
    0.24322495f, -0.41838157f, -0.41272229f, -0.24814554f, -0.17956823f, 0.15071917f, -0.07343884f, -0.25039494f, 
    0.18852946f, -0.06956085f, 0.09075349f, 0.17807682f, 0.07994166f, 0.05850254f, 0.13062485f, -0.04846225f, 
    -0.12853000f, 0.01627132f, -0.35829458f, -0.57052416f, -0.12414072f, 0.12416144f, 0.23643468f, -0.42900088f, 
    0.82963645f, 0.21813606f, -0.38043937f, -0.44607240f, -0.10141417f, 0.12826580f, 0.05131140f, -0.48694992f, 
    -0.18843503f, 0.06504478f, -0.12483227f, -0.38862935f, 0.04984661f, 0.26090011f, -0.05587359f, 0.15644117f, 
    -0.34466401f, -0.19892979f, -0.09633110f, 0.20540890f, 0.08623540f, -0.76778674f, 0.47974968f, 0.47674412f, 
    -0.02728011f, -0.78248966f, -0.58697784f, -0.17093867f, 0.06807675f, 0.62860441f, 0.23930636f, 0.00079530f, 
    -0.26881006f, 0.02415888f, 0.30411825f, -0.05333897f, -0.14724606f, 0.00113925f, 0.18504038f, -0.41087860f, 
    0.05935084f, -0.08748277f, -0.24379359f, -0.06134422f, 0.11864828f, -0.44065741f, 0.00817287f, 0.21321477f, 
    -0.08053341f, 0.40459660f, -0.01108989f, -0.01744558f, 0.04197945f, 0.12617457f, 0.08788080f, 0.00244238f, 
    -0.00579027f, -0.23580293f, 0.09133011f, 0.04932880f, 0.29155588f, 0.00702877f, -0.32962471f, 0.05052768f, 
    0.04839848f, -0.08088218f, 0.27071801f, -0.18682870f, -0.15458368f, -0.22757052f, -0.54078579f, -0.40033212f, 
    -0.03064035f, 0.11670610f, 0.43780392f, 0.35052919f, 0.08223597f, -0.01007968f, -0.15440644f, -0.03759275f, 
    0.25367752f, 0.21621501f, -0.14542226f, -0.12672421f, -0.24439441f, 0.23161484f, -0.24695157f, 0.07846046f, 
    0.28741816f, 0.05068797f, -0.00941881f, 0.20821215f, -0.14320385f, 0.08647387f, -0.18649819f, -0.84939271f, 
    -0.78224152f, -0.66365844f, -0.09149712f, -0.09338414f, 0.45077723f, 0.49280939f, 0.07907972f, 0.13052128f, 
    0.56292665f, 0.19742569f, 0.16736041f, 0.09692714f, 0.41549712f, -0.02948887f, -0.19182000f, -0.22790173f, 
    -0.20398940f, -0.05621871f, -0.27243829f, 0.05954530f, 0.04230760f, 0.16167276f, 0.24324989f, -0.13696928f, 
    -0.53169721f, -0.24915051f, -0.49042466f, -0.28095654f, 0.27889737f, -0.40008277f, -0.52130616f, -0.45875725f, 
    -0.35308564f, -0.32170096f, -0.11870338f, -0.02539961f, -0.16506945f, 0.32677522f, -0.40856561f, -0.11698168f, 
    -0.50857574f, -0.03964863f, -0.20102854f, -0.34153652f, -0.21599157f, -0.04720961f, -0.03795658f, 0.15224153f, 
    0.07823478f, -1.06211722f, 0.20199119f, -0.43898278f, -0.57065809f, -0.21827337f, 0.17955756f, -0.13192189f, 
    0.35261193f, 0.12373621f, -0.07156681f, -0.52037430f, -0.12044274f, 0.10044460f, -0.56137973f, -0.32238847f, 
    0.22380571f, -0.34038672f, -0.28876269f, 0.31296211f, 0.05869178f, 0.07151037f, 0.27398765f, -0.18470971f, 
    -0.11631381f, -0.10022023f, 0.76514328f, 0.74849421f, 0.24767479f, -0.40405363f, -0.80749929f, -0.01431592f, 
    -0.22123420f, -0.20658572f, -0.29568374f, -0.50622702f, 0.22829968f, 0.35667551f, 0.09118385f, 0.22844960f, 
    0.26287034f, -0.01534521f, -0.13012230f, 0.18955895f, -0.30549788f, -0.21732126f, -0.30781737f, 0.02769206f, 
    0.00149368f, 0.07411906f, 0.04993674f, 0.24197812f, -0.19403452f, -0.24332021f, 0.04228073f, 0.33934605f, 
    -0.29346010f, -0.12311158f, 0.00561099f, -0.09380858f, -0.22686730f, -0.04294413f, 0.34379044f, -0.04164947f, 
    -0.13323331f, -0.00746782f, -0.03537137f, 0.07094908f, 0.11568834f, -0.01746199f, -0.29722309f, 0.11937434f, 
    -0.28696799f, 0.04428500f, 0.35956812f, 0.24945755f, -0.54754847f, -0.43529707f, -0.88877630f, -0.03562040f, 
    0.76927179f, 0.60182095f, 0.61771464f, 0.22089477f, -0.20207554f, -0.18702276f, -0.13208605f, -0.12449095f, 
    -0.58342904f, -0.19589163f, -0.21309055f, 0.22166978f, -0.19082280f, -0.03186569f, 0.00621237f, -0.25433296f, 
    0.09852728f, 0.10268673f, -0.07511647f, -0.10135209f, -0.12719722f, -0.21206523f, 0.08966883f, -0.15836073f, 
    -0.09455500f, 0.05945499f, 0.32585365f, 0.09949709f, 0.22241057f, -0.02318963f, 0.27747589f, -0.23925745f, 
    0.01832346f, -0.27061507f, -0.02123864f, 0.24176048f, 0.16917546f, -0.25955740f, -0.00704062f, 0.11601895f, 
    -0.25457025f, -0.00682878f, -0.32952660f, -0.04518748f, 0.05462954f, 0.12493747f, -0.38072163f, -0.22003391f, 
    -0.67497498f, -0.23290418f, -0.24472359f, 0.31843579f, 0.40849304f, 0.26110399f, 0.28838736f, 0.10565281f, 
    -0.07990137f, -0.18671204f, -0.02881357f, -0.19146492f, -0.08037381f, -0.08165526f, -0.13744214f, -0.01877300f, 
    0.30498570f, -0.12108129f, -0.29304010f, -0.33662298f, 0.05416768f, -0.14948314f, -0.13866855f, 0.16096163f, 
    -1.11666965f, -0.30706948f, 0.40892911f, 0.86370283f, -0.46112692f, 0.00689869f, -0.51083452f, -0.28402960f, 
    -0.18348074f, -0.15269148f, -0.36570346f, 0.44195083f, -0.47357395f, -0.21405403f, 0.02750776f, -0.23334083f, 
    0.16181672f, -0.11936724f, 0.13098076f, -0.15195979f, -0.25364774f, -0.06169954f, 0.06746008f, 0.02387198f, 
    -0.92066932f, -0.81246668f, -0.30093735f, 0.49332201f, 0.60559601f, 0.44381762f, -0.00644899f, -0.30015215f, 
    -0.00437572f, 0.47213906f, -0.17571153f, -0.24587886f, -0.02424506f, 0.56368864f, 0.16330223f, 0.12080608f, 
    0.02037326f, -0.16174755f, 0.04958424f, -0.13483575f, 0.23793705f, -0.29916957f, -0.09073342f, 0.21059711f, 
    -0.13276832f, 0.49290934f, -0.22978692f, 0.25183538f, -0.23356004f, -0.41817197f, -0.32249695f, -0.30040899f, 
    0.69247246f, -0.11731627f, -0.21769947f, -0.38421485f, -0.21664952f, 0.51888669f, -0.17012407f, -0.07695504f, 
    0.32490736f, -0.07522145f, -0.05647174f, 0.15646464f, -0.33251974f, -0.07263914f, -0.04252683f, -0.19558805f, 
    -0.30219576f, -0.19249178f, -0.30962357f, -0.15547554f, -0.35090023f, -0.28614163f, -0.14607559f, 0.24845752f, 
    0.11300154f, 0.23047495f, 0.21249916f, -0.09657981f, 0.20584889f, 0.10624678f, 0.08357254f, -0.05923342f, 
    -0.13152283f, -0.01897094f, 0.08424957f, -0.09667784f, 0.12254021f, 0.12826623f, 0.02614124f, -0.00720828f, 
    0.08811044f, 0.20381972f, -0.27096197f, 0.57064319f, 0.33783346f, -0.32003164f, 0.11824038f, 0.21913494f, 
    -0.16408519f, 0.24300463f, -0.28368253f, -0.26750416f, -0.41022214f, 0.12448344f, 0.15969984f, 0.07521924f, 
    -0.09887227f, 0.15057813f, -0.11910322f, 0.05488905f, -0.20890968f, 0.05113178f, 0.05174567f, -0.16649812f, 
    0.19644901f, -0.02632344f, 0.02658547f, -0.26876548f, 0.10453042f, 0.80615598f, 0.18143822f, -0.41629446f, 
    -0.14046846f, -0.37633109f, -0.12941757f, 0.26054537f, -0.26915178f, -0.23812403f, -0.16265260f, 0.15469550f, 
    -0.02901861f, 0.41171190f, -0.36076817f, -0.00887931f, 0.12198319f, -0.15436959f, 0.17590217f, -0.11478465f, 
    -0.00165719f, -0.06932041f, -0.00581599f, 0.23768246f, 0.18491961f, -0.84187895f, 0.37351859f, -0.33844092f, 
    -0.62459618f, -0.53230035f, -0.05944275f, 0.38270366f, 0.09728152f, 0.23058496f, 0.04934295f, 0.43404102f, 
    -0.24132736f, -0.03258570f, -0.25523698f, 0.11595476f, -0.05865251f, -0.12856492f, -0.20453303f, 0.17923637f, 
    -0.44599327f, -0.07270938f, -0.17074420f, 0.38673508f, -0.33536175f, -0.33979204f, -0.36862236f, -0.18183279f, 
    0.32837400f, -0.36027947f, -0.59143490f, -0.02277764f, 0.21722652f, -0.45428297f, -0.04222094f, 0.13069485f, 
    0.08659418f, -0.26765916f, -0.08203290f, -0.28210270f, 0.25516495f, -0.31560922f, -0.10593912f, -0.28955597f, 
    0.10910279f, -0.07504689f, -0.17598420f, -0.17417823f, -0.15969761f, -0.19312850f, -0.45400092f, -0.67505896f, 
    -0.21094655f, -0.47321332f, -0.68607664f, -0.49989766f, 0.40534380f, -0.20685987f, 0.31594649f, 0.07997252f, 
    0.34363660f, 0.15397051f, 0.42004409f, 0.19118616f, 0.20358379f, -0.30147436f, -0.02071181f, -0.00590204f, 
    0.10930149f, 0.24525534f, 0.15075336f, 0.09120227f, -0.13439307f, 0.18386605f, -0.24472694f, -0.15860157f, 
    0.42801329f, 0.44224679f, -0.16397302f, -0.26306981f, 0.03301070f, 0.26619324f, -0.38499969f, -0.26222053f, 
    0.08124852f, -0.06702460f, -0.04222591f, -0.05820059f, -0.04397881f, -0.34397373f, -0.37445414f, -0.02388266f, 
    0.07856634f, 0.29734862f, 0.31776339f, -0.13299632f, -0.17447765f, -0.16722733f, 0.02592000f, -0.01198044f, 
    0.32230160f, -0.26422325f, -0.44861698f, -0.21963814f, -0.17670441f, -0.27263120f, -0.46962997f, -0.43414450f, 
    -0.51836950f, -0.49024478f, -0.62611586f, 0.45103571f, 0.40494633f, 0.05611715f, 0.24066868f, -0.21307549f, 
    0.25627413f, 0.07469369f, -0.02332074f, -0.11396015f, -0.23074514f, 0.12378381f, 0.34111536f, -0.00407775f, 
    0.04769087f, 0.33465531f, 0.00472440f, 0.05036502f, -0.09717961f, -0.04401714f, 0.40637583f, 0.18151455f, 
    0.10737506f, 0.10741218f, 0.25249079f, -0.01072536f, -0.13280821f, 0.07666408f, 0.13806579f, -0.33977613f, 
    0.35976180f, 0.19999704f, -0.17268531f, -0.16066314f, -0.13614804f, -0.28337470f, 0.10633153f, -0.10032602f, 
    -0.19521125f, 0.13320993f, 0.32240143f, 0.47738081f, 0.20881829f, 0.25576735f, -0.63857794f, -0.47031528f, 
    -0.00290039f, 0.16966236f, 0.15690950f, 0.14229016f, 0.05778658f, -0.16705939f, 0.29283637f, -0.26945451f, 
    -0.01415288f, 0.21086380f, -0.29507202f, 0.24880131f, -0.27649924f, -0.00787095f, 0.13764572f, 0.21943972f, 
    0.20231837f, 0.06302290f, -0.27940917f, -0.29914108f, -0.40779817f, -0.24842979f, -0.12038745f, 0.47192690f, 
    0.03011678f, -0.12152211f, 0.01040184f, -0.19429299f, -0.02470817f, 0.10900974f, 0.37896490f, -0.03953711f, 
    -0.29015294f, 0.30585054f, -0.32017714f, 0.12168478f, -0.06340539f, 0.18535548f, -0.41237518f, -0.19857438f, 
    0.11641768f, 0.08810401f, -0.08332045f, 0.28286999f, 0.27335855f, -0.18498953f, 0.22375451f, -0.07230587f, 
    0.21095985f, -0.32773358f, 0.14932393f, 0.68337572f, -0.57483459f, -0.48648909f, -0.47684577f, -0.15595494f, 
    0.54224330f, -0.00772131f, -0.04082623f, -0.01181797f, -0.22859068f, -0.15249485f, 0.37318236f, -0.08905036f, 
    0.06554753f, -0.07579754f, -0.45966500f, 0.08893427f, 0.24653742f, -0.00585678f, -0.43137154f, 0.47976780f, 
    0.26225299f, -0.25242037f, -0.21636367f, -0.20171638f, 0.16577443f, -0.01180712f, 0.33440545f, 0.08192385f, 
    -0.23603114f, -0.33982107f, -0.15607047f, -0.42024910f, 0.21979365f, -0.02680597f, 0.35725564f, 0.13730496f, 
    -0.06442954f, 0.23649246f, -0.20761421f, -0.17065048f, -0.41893840f, -0.39661071f, -0.41331938f, -0.55987388f, 
    -0.40933800f, 0.13371900f, 0.24708679f, 0.15816839f, 0.22313160f, 0.43058580f, 0.40949655f, 0.02705448f, 
    0.15262312f, 0.17158413f, -0.15247108f, 0.19079505f, -0.26381794f, -0.23449384f, 0.08705156f, 0.01348127f, 
    -0.34695640f, -0.35108075f, 0.22404763f, -0.00638494f, -0.04218490f, 0.28845683f, 0.27018344f, -0.05198863f, 
    -0.39114976f, -0.01646282f, 0.19919842f, 0.39120758f, 0.35321042f, 0.23987901f, -0.21077164f, 0.07708687f, 
    0.23498434f, 0.31646124f, -0.11273304f, 0.16270246f, 0.01010423f, -0.31628010f, -0.26435906f, 0.05571574f, 
    0.09173602f, -0.29974848f, 0.02053452f, -0.17605086f, 0.03320924f, -0.17324421f, 0.21627724f, -0.09657852f, 
    -0.00176252f, -0.22466683f, -0.01579123f, 0.39550036f, 0.39910716f, -0.24141671f, 0.32340816f, -0.18592827f, 
    -0.33184966f, -0.10360130f, 0.12168020f, -0.13923010f, 0.21880569f, -0.26589832f, -0.19621384f, 0.39794299f, 
    0.14845198f, 0.04275397f, -0.05606814f, -0.11222104f, -0.10985100f, -0.04654605f, 0.19875810f, 0.16663423f, 
    0.03923470f, -0.20845322f, -0.76676410f, -0.49813193f, -0.30833691f, -0.18960898f, -0.47491860f, 0.39705724f, 
    0.05872144f, -0.58990473f, -0.72626013f, 0.16540894f, -0.23511370f, -0.27286074f, -0.00546647f, 0.01496502f, 
    -0.14606124f, -0.05474591f, -0.32710499f, -0.27007180f, 0.02653413f, -0.50360030f, -0.14318204f, -0.13751890f, 
    0.01082840f, -0.10456951f, -0.03567705f, -0.06054857f, 0.00095954f, -0.40519667f, -0.34841472f, 0.01313964f, 
    -0.03010841f, -0.32166648f, -0.03750611f, -0.15192175f, -0.31602752f, 0.20416759f, -0.19786933f, 0.04733675f, 
    0.53468359f, -0.41169596f, -0.04162582f, -0.06332868f, -0.00794014f, -0.24347013f, -0.27021542f, -0.25924009f, 
    -0.19871861f, 0.04308211f, -0.14053452f, -0.01463476f, 1.11352193f, -0.19083053f, -0.85214448f, -0.71311814f, 
    -0.51427871f, 0.57423073f, 0.12452577f, 0.17859477f, 0.09280340f, 0.18310508f, -0.26124823f, 0.62339467f, 
    -0.52675569f, -0.08873630f, -0.01546602f, 0.13007601f, -0.22594878f, 0.38969016f, -0.07848983f, -0.26502380f, 
    -0.07549920f, -0.06302777f, 0.05265427f, 0.15469483f, 0.27290329f, 0.14938566f, -0.08486585f, 0.18115470f, 
    0.05392331f, -0.00583936f, -0.10874074f, 0.38833013f, 0.02674195f, -0.19232583f, 0.04151534f, 0.03067081f, 
    -0.11468092f, -0.02126577f, -0.02514547f, 0.32708535f, 0.01155624f, -0.31657940f, -0.37736085f, 0.03643796f, 
    0.14173430f, 0.03419729f, 0.18598254f, -0.19085747f, -0.05114234f, 0.35030413f, 0.02309354f, 0.70400476f, 
    0.20759210f, 0.07973456f, -0.39021346f, -0.27818578f, -0.42871308f, -0.06032994f, 0.23984534f, -0.23988451f, 
    -0.12339964f, -0.19499324f, 0.19096337f, 0.09850711f, 0.10847848f, 0.12264564f, 0.30983329f, -0.15573952f, 
    0.05213318f, -0.27177835f, -0.15132299f, 0.11130083f, -0.08378065f, 0.08918601f, -0.04638788f, -0.88991815f, 
    -0.29418683f, -0.14975695f, -0.52374846f, -0.36878091f, 0.06372838f, 0.16764408f, -0.47617206f, -0.53298402f, 
    0.12680645f, -0.19974723f, -0.37737751f, -0.24838579f, -0.38340661f, -0.22587840f, -0.00927940f, -0.21719538f, 
    -0.23297116f, -0.13414854f, -0.18694581f, -0.01710784f, -0.23594116f, -0.31716964f, -0.24683340f, -0.02316145f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01242075f, 0.08566502f, 0.13993710f, -0.01095574f, 0.15064782f, 0.16874982f, 0.35487017f, 0.06226799f, 
    0.13674574f, 0.10634854f, -0.01194110f, 0.20488769f, 0.20710866f, -0.14386003f, 0.09857541f, 0.16926357f, 
    -0.00366673f, -0.17694257f, 0.14614837f, 0.01293684f, -0.09022131f, 0.24299084f, -0.25858426f, 0.40002957f, 
    0.23654088f, -0.01694069f, 0.15852430f, 0.30713943f, 0.19012117f, -0.18014561f, 0.00283013f, 0.25001523f, 
    -0.22885773f, -0.08585291f, 0.16386512f, 0.14119141f, -0.09861072f, -0.04974153f, -0.14248195f, -0.11831795f, 
    0.26933539f, 0.27662709f, -0.09220981f, 0.09032743f, 0.04662545f, -0.14189082f, -0.01137650f, 0.15703391f, 
    0.13831078f, -0.00366048f, 0.15523155f, 0.39758101f, -0.03519151f, 0.25607461f, -0.23185264f, 0.01967841f, 
    0.18971418f, 0.09106029f, 0.13278326f, 0.09240920f, 0.19830526f, -0.07962580f, 0.13884470f, -0.17724985f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00182572f, -0.02449961f, -0.03477453f, 0.01764804f, 0.02011306f, -0.00462693f, 0.02761054f, -0.01022757f, 
    -0.01557304f, -0.00278339f, -0.00583289f, 0.02924631f, -0.03204433f, 0.00774090f, -0.00802584f, 0.01989958f, 
    -0.00093743f, -0.00005488f, -0.02816989f, 0.01150892f, -0.01496947f, -0.02997634f, -0.02201196f, 0.00601824f, 
    -0.00793828f, -0.01236227f, 0.00696524f, 0.02940283f, -0.03188382f, 0.01127752f, 0.02409238f, -0.01623363f, 
    0.02738571f, -0.02685028f, -0.02530377f, -0.03132575f, 0.02956567f, 0.00649041f, -0.01414375f, 0.00956526f, 
    -0.04023227f, -0.00821406f, 0.00256753f, -0.02537638f, 0.02117393f, -0.02601084f, 0.01312175f, 0.02956685f, 
    -0.00875510f, -0.03922217f, -0.02777914f, -0.01308861f, -0.00099313f, -0.03490196f, -0.00243515f, -0.00227435f, 
    -0.03342019f, 0.00888770f, -0.01309293f, 0.02160846f, -0.00947589f, -0.02394550f, -0.00686268f, -0.00109772f, 
    -0.00235933f, -0.03058945f, 0.01687133f, 0.00023271f, -0.03659773f, 0.00811382f, 0.00483251f, 0.02878680f, 
    -0.01453051f, -0.00521542f, 0.02613513f, -0.03367410f, -0.02133437f, -0.00107210f, -0.03804276f, 0.02664204f, 
    0.02485660f, 0.02953080f, 0.03165940f, 0.02680142f, -0.00776170f, -0.00667372f, 0.01670951f, 0.02071711f, 
    -0.00472785f, 0.00619532f, -0.01007197f, -0.02558440f, 0.01751513f, -0.02760057f, 0.02566562f, -0.03741254f, 
    0.02799696f, -0.02295015f, -0.02236286f, 0.02097493f, -0.02477200f, 0.03292003f, 0.00416641f, 0.03194413f, 
    0.02572081f, 0.00094170f, -0.03127464f, -0.01244530f, -0.01908365f, -0.00877727f, -0.00521815f, 0.00300650f, 
    0.00483688f, 0.02491285f, 0.03227736f, -0.02424050f, 0.02550289f, 0.01585874f, -0.01884812f, 0.02785869f, 
    0.02350584f, -0.03144539f, -0.00321020f, -0.03193796f, -0.02887763f, 0.02461672f, 0.02358503f, -0.04079454f, 
    0.01840825f, 0.03119552f, -0.01731337f, -0.02736733f, -0.02397037f, -0.02244143f, -0.00669649f, 0.01479971f, 
    0.00976582f, -0.02237100f, -0.03641136f, -0.01980369f, 0.01353792f, 0.02912075f, -0.02477852f, 0.03102013f, 
    -0.01893160f, -0.01858901f, 0.02699032f, 0.02751929f, -0.03534082f, 0.01451073f, 0.01432242f, -0.03120224f, 
    -0.03697348f, -0.02521829f, -0.01752467f, -0.02391229f, -0.00860409f, 0.01936158f, -0.00167780f, -0.01599121f, 
    0.01196760f, -0.03611763f, -0.02848822f, -0.02123055f, 0.00602556f, 0.01556632f, -0.02812282f, -0.03132458f, 
    -0.00622510f, -0.02543274f, -0.00874286f, -0.02055619f, 0.01323424f, -0.02022036f, -0.02787072f, 0.03039779f, 
    0.02306204f, -0.00953312f, -0.00474087f, 0.00647318f, -0.01459693f, -0.01207397f, -0.00464856f, -0.02616982f, 
    0.02176421f, 0.01691070f, -0.02936819f, -0.03209173f, -0.01302098f, -0.03444993f, -0.03636707f, -0.01882188f, 
    0.01283582f, -0.00834329f, 0.01907887f, -0.00917980f, 0.00424283f, 0.01337775f, 0.02602048f, 0.00245343f, 
    -0.02797533f, -0.01359671f, -0.02292001f, -0.03724013f, 0.00239783f, 0.02959209f, 0.00212452f, -0.00446922f, 
    -0.00145234f, 0.03625911f, 0.02832364f, 0.02821295f, -0.00335569f, -0.02514676f, -0.00805419f, -0.02284482f, 
    0.03204206f, -0.00311351f, -0.00136453f, -0.01809498f, -0.02143509f, -0.03921130f, 0.02418085f, 0.03263608f, 
    -0.02004946f, -0.03280046f, -0.00341081f, 0.01518922f, -0.00126787f, 0.01333961f, 0.00003275f, 0.00600043f, 
    0.02843532f, 0.01490820f, 0.01879502f, 0.01267369f, 0.02865899f, 0.03469733f, -0.01885691f, -0.03066916f, 
    -0.01703324f, -0.00380904f, 0.01329751f, -0.02073553f, -0.00917878f, 0.00449205f, -0.03498312f, -0.00404544f, 
    -0.03666750f, 0.02505882f, 0.00501898f, -0.00878184f, -0.00003983f, -0.00320607f, 0.04248310f, 0.02725364f, 
    0.00279646f, 0.01943485f, 0.02120664f, 0.00454607f, -0.01509562f, -0.01801431f, -0.02262544f, -0.01451076f, 
    -0.01611874f, -0.00746656f, 0.00117803f, 0.01365744f, 0.02371305f, 0.01498358f, 0.01194915f, -0.01234142f, 
    0.01691172f, 0.02928421f, -0.00355211f, -0.00767001f, 0.00449670f, -0.00311685f, -0.02941703f, -0.00608535f, 
    -0.02445778f, 0.00806692f, -0.02464310f, 0.00276863f, -0.00099885f, -0.02022604f, 0.02773162f, -0.00449462f, 
    0.00343843f, -0.03134355f, 0.02543264f, 0.01154565f, -0.03424349f, 0.02580190f, -0.01430634f, 0.03118346f, 
    -0.00572716f, -0.03016156f, -0.03287058f, 0.00671564f, 0.01530840f, 0.02347144f, -0.03554657f, -0.00701881f, 
    0.03111930f, -0.01842341f, 0.02412608f, 0.01208789f, 0.01470486f, -0.03241932f, -0.01724201f, 0.02446132f, 
    -0.03319025f, -0.03249093f, -0.01106769f, 0.00268497f, -0.03402193f, -0.03492357f, 0.01959692f, 0.00951724f, 
    -0.00429540f, -0.00649294f, 0.00032510f, -0.02920790f, 0.01996997f, -0.02496255f, 0.00589259f, 0.00880363f, 
    0.03295473f, -0.01892880f, -0.00562534f, 0.01360379f, -0.03142834f, -0.02246237f, 0.01789281f, -0.01381977f, 
    0.00815735f, -0.02902988f, -0.00022881f, 0.00309853f, 0.01759098f, 0.02505119f, -0.02932029f, 0.02433514f, 
    -0.01440060f, -0.00985559f, -0.03403339f, -0.02056034f, 0.02043703f, 0.00040319f, -0.02858147f, -0.00051022f, 
    -0.02632301f, 0.03089604f, -0.03959522f, -0.00361723f, 0.00349063f, -0.00111864f, -0.00009498f, -0.02929999f, 
    0.01128402f, 0.00499232f, -0.02996230f, -0.00280319f, -0.03700559f, 0.02276474f, -0.00234892f, -0.03637737f, 
    -0.01783825f, 0.00891646f, -0.03164284f, -0.01148335f, -0.01686048f, -0.02038018f, -0.01216086f, 0.00950419f, 
    0.02653410f, -0.01190944f, -0.03427390f, -0.00267938f, 0.02450690f, -0.00826442f, -0.04454001f, 0.01343245f, 
    0.02003605f, -0.03306463f, 0.01677780f, -0.04186779f, -0.03893347f, 0.00355594f, 0.01368520f, 0.02256473f, 
    0.00649452f, 0.00257125f, -0.00614743f, 0.03067807f, 0.02261505f, -0.01920646f, 0.00902491f, -0.04322500f, 
    0.01001204f, 0.02282919f, 0.00244249f, 0.01639865f, -0.01064032f, -0.01688649f, 0.01994990f, 0.00027471f, 
    -0.01458847f, 0.01563107f, -0.02040134f, 0.00424571f, -0.03233401f, 0.02520742f, 0.00886123f, -0.03256692f, 
    -0.00739012f, -0.03272877f, 0.03112420f, -0.01319475f, -0.01978389f, 0.02679141f, -0.01778182f, -0.01854607f, 
    -0.01756777f, -0.00179556f, -0.01160408f, -0.00249580f, 0.00797215f, -0.03705062f, -0.00174255f, 0.01364829f, 
    0.00214180f, -0.03585334f, -0.00680549f, -0.00790672f, 0.01764692f, 0.01539576f, 0.00561925f, -0.01727715f, 
    0.00590198f, 0.00719428f, -0.02525878f, 0.04071071f, -0.02195534f, -0.01892057f, 0.00143210f, 0.00406389f, 
    -0.01728515f, -0.01815382f, -0.03893566f, -0.01553382f, 0.00046277f, -0.01159907f, 0.02573117f, 0.02109391f, 
    0.01770035f, 0.00197081f, -0.00085902f, 0.03126221f, 0.00409320f, 0.01699070f, 0.03136603f, -0.01782834f, 
    -0.01131357f, -0.03880447f, -0.02634213f, 0.01883963f, -0.02351214f, 0.01174526f, -0.00546459f, -0.03063641f, 
    0.02276671f, 0.04101791f, 0.02909037f, 0.03330174f, 0.00381556f, 0.02693546f, -0.02601807f, 0.01243425f, 
    0.02126853f, -0.01302086f, -0.01986214f, -0.00973127f, -0.00734013f, -0.02763220f, -0.03829903f, 0.01941662f, 
    -0.01020173f, -0.00105082f, -0.03214573f, -0.03071610f, 0.02294833f, -0.00405340f, -0.00667452f, 0.00955149f, 
    -0.02301100f, -0.03917682f, -0.01047185f, 0.03646708f, 0.00019274f, -0.03048843f, -0.00252121f, 0.01232402f, 
    -0.03735496f, -0.00518773f, 0.01697694f, 0.02608300f, -0.04282304f, 0.02479983f, -0.02132865f, 0.00438957f, 
    0.01126763f, -0.03710763f, -0.00270716f, 0.00608652f, -0.02613813f, -0.00214000f, -0.00168507f, -0.01223836f, 
    0.00435706f, -0.01026675f, -0.02434750f, -0.00559747f, 0.00961405f, 0.01546515f, -0.03463021f, -0.01002234f, 
    0.00041388f, 0.02352488f, -0.02145232f, -0.01539427f, -0.01367787f, 0.01644915f, -0.01330822f, 0.00351787f, 
    -0.02441438f, 0.02898970f, -0.03903041f, 0.01876842f, 0.01197291f, -0.01165421f, -0.02897407f, 0.02536247f, 
    -0.01403436f, 0.00772245f, -0.02066555f, 0.01539600f, -0.00690885f, 0.00251905f, 0.02224381f, -0.00751035f, 
    0.02918667f, 0.01559189f, -0.01430408f, -0.04024733f, 0.00262620f, 0.02615344f, 0.03610677f, 0.02784204f, 
    -0.03150790f, -0.00117165f, 0.00173278f, -0.02216234f, 0.02269490f, -0.03732544f, -0.02309244f, 0.01558448f, 
    0.01899118f, 0.02322426f, -0.01044675f, -0.00392504f, 0.01153314f, 0.02746790f, 0.02299182f, -0.02268644f, 
    0.01619704f, -0.01651383f, -0.02228365f, -0.02022312f, -0.02499045f, 0.02461660f, -0.03442712f, 0.00589298f, 
    0.00898196f, -0.00987917f, -0.01543358f, -0.02057154f, -0.00263289f, -0.02480032f, 0.01110537f, -0.00109403f, 
    0.00598471f, -0.00157200f, 0.02063970f, 0.02781581f, 0.00699584f, -0.00240995f, 0.00506518f, -0.01190819f, 
    -0.02230315f, 0.03482033f, 0.01322040f, -0.00606505f, 0.03129362f, 0.00321730f, 0.00165821f, -0.02354230f, 
    -0.00942815f, 0.00553618f, 0.00411319f, -0.00133466f, 0.02778329f, -0.00115830f, -0.02818554f, 0.00197451f, 
    -0.02494373f, 0.01735561f, 0.00776650f, 0.01460970f, 0.02160035f, -0.01467935f, 0.03006588f, -0.02583450f, 
    0.00580094f, -0.03385385f, 0.00204010f, -0.00833001f, 0.02593010f, 0.01143663f, -0.03288817f, -0.02026972f, 
    0.00474424f, -0.03461302f, 0.01636632f, 0.02415650f, -0.01240883f, -0.00358442f, -0.02194748f, -0.00662933f, 
    0.00262528f, -0.02551025f, -0.03660752f, 0.01359665f, 0.00978808f, -0.00263270f, 0.00098969f, -0.03654778f, 
    -0.00732894f, 0.01905905f, 0.02967724f, -0.04074636f, -0.01639291f, -0.00215843f, -0.03362686f, 0.03615602f, 
    -0.02365090f, -0.04162484f, 0.00663277f, 0.01059849f, -0.03865463f, 0.01999992f, 0.03279666f, 0.02033700f, 
    -0.01652237f, 0.02700936f, -0.01296259f, -0.00911786f, -0.01247452f, -0.03621420f, 0.00923496f, 0.02359174f, 
    -0.02209720f, 0.03286915f, -0.00806890f, -0.02649619f, -0.02314688f, -0.03230565f, -0.00103866f, -0.02489703f, 
    0.00813745f, -0.02547600f, -0.03726364f, -0.01250790f, 0.01321183f, -0.00896765f, 0.00067962f, 0.02741129f, 
    -0.03978008f, -0.02338064f, 0.00041537f, -0.03730958f, 0.00056248f, -0.00797029f, -0.03708234f, -0.01940708f, 
    0.02754620f, -0.01023251f, -0.03193083f, -0.03132375f, 0.00021867f, -0.02825882f, -0.00386507f, 0.02582000f, 
    -0.00341364f, 0.03083606f, -0.02090948f, 0.02305574f, -0.01013813f, -0.02356131f, 0.00616422f, -0.02468557f, 
    0.01446421f, -0.00664571f, -0.02816601f, 0.00541088f, 0.02087364f, -0.00855206f, -0.01352207f, 0.01465974f, 
    0.01065816f, 0.03134780f, 0.02030037f, -0.02550894f, 0.02244760f, -0.01794635f, -0.00822483f, 0.02178193f, 
    -0.01821084f, -0.04042581f, 0.00057038f, -0.03671585f, -0.00630992f, 0.00910373f, -0.01295514f, -0.02702554f, 
    -0.03610831f, -0.01027537f, 0.03212002f, -0.02480494f, -0.02614771f, -0.01986040f, 0.00145968f, -0.00272426f, 
    0.03078819f, -0.01771014f, -0.03388600f, -0.04201146f, -0.02391559f, -0.02319141f, -0.02593100f, -0.03642195f, 
    -0.01422066f, -0.02878346f, -0.01984457f, 0.01460733f, -0.04360744f, -0.00553851f, -0.02961747f, -0.01912850f, 
    0.03467819f, 0.03333538f, -0.03028026f, 0.01822294f, 0.03747158f, 0.03643607f, 0.00461645f, -0.01549310f, 
    -0.00430806f, -0.02008642f, -0.00736114f, 0.02400149f, 0.01268853f, -0.02022330f, -0.02439694f, 0.01637415f, 
    -0.03594550f, -0.04107549f, -0.02968452f, 0.02734421f, -0.03447581f, -0.02507787f, 0.02920532f, -0.01435377f, 
    0.02155730f, 0.03997241f, 0.01578042f, -0.01540952f, 0.00700299f, 0.01157294f, -0.03236676f, -0.00835366f, 
    0.01468686f, 0.00144066f, -0.01011820f, -0.02175827f, -0.02262089f, -0.00908424f, -0.00548977f, -0.01261781f, 
    -0.01790772f, -0.03166954f, 0.03213111f, 0.01924502f, -0.00044859f, -0.00815497f, -0.01013116f, -0.03015454f, 
    -0.01476728f, -0.02776336f, 0.01560400f, 0.03080504f, 0.00017293f, -0.03057759f, 0.00145028f, -0.00228943f, 
    0.00881605f, -0.03422524f, -0.02819419f, 0.01070236f, -0.00222354f, 0.01390004f, 0.03831565f, -0.02160458f, 
    -0.03594463f, 0.02519596f, -0.02492621f, 0.01747172f, 0.00850488f, -0.03385677f, -0.00239856f, 0.02283314f, 
    -0.01651251f, 0.02152992f, 0.00899684f, 0.00746448f, -0.02159699f, -0.03890411f, -0.01633252f, 0.00372520f, 
    -0.01658918f, -0.00905918f, 0.01065732f, 0.00576373f, -0.00506661f, -0.01821486f, -0.00266864f, -0.03363283f, 
    -0.04055171f, 0.01249459f, -0.03940867f, -0.03253647f, 0.01298298f, 0.00019489f, 0.02546075f, -0.00580278f, 
    0.01211594f, 0.01539066f, 0.01054798f, -0.00329101f, -0.02150395f, 0.01076384f, -0.01217919f, -0.00162662f, 
    -0.02287824f, -0.00741682f, -0.04141738f, 0.00112573f, -0.01046298f, 0.02048473f, -0.00352221f, -0.04237029f, 
    -0.00895987f, -0.03393618f, 0.01369731f, -0.02362126f, 0.00098234f, -0.00141486f, -0.02489921f, -0.00815568f, 
    -0.02570936f, -0.00877074f, -0.00772702f, -0.00492637f, 0.01121876f, -0.00714359f, 0.01143443f, 0.01743095f, 
    -0.01817706f, 0.00686521f, -0.00441076f, 0.00898727f, -0.03266160f, -0.03193247f, -0.02764335f, 0.00270384f, 
    -0.02201441f, -0.03190967f, -0.00768662f, 0.01050124f, -0.01884709f, -0.02301681f, -0.01121539f, -0.01875787f, 
    0.01433905f, 0.00952027f, -0.01544188f, -0.03603966f, -0.00959681f, -0.01133847f, -0.02829232f, 0.02637205f, 
    0.01679447f, 0.00355764f, -0.03299233f, 0.00688154f, 0.01515900f, -0.02007178f, -0.01668766f, -0.00072042f, 
    -0.00848061f, 0.03262227f, -0.00049900f, -0.00011653f, 0.00093907f, -0.00588642f, -0.01253837f, 0.01966482f, 
    0.01217175f, -0.02447831f, 0.02050443f, 0.00884419f, 0.00637802f, 0.00099018f, 0.00988640f, 0.01484983f, 
    -0.03918266f, -0.02746646f, 0.01833206f, -0.03865412f, 0.00599909f, 0.00642964f, -0.00645992f, -0.02507580f, 
    -0.01736569f, -0.04109328f, -0.02339401f, 0.01038070f, 0.00971037f, -0.04412764f, -0.04221829f, -0.03350436f, 
    -0.02938366f, -0.02007693f, -0.01330751f, -0.03291941f, -0.01039085f, 0.00217523f, -0.02516436f, -0.01139789f, 
    0.02665349f, -0.03139613f, -0.02878328f, -0.02857980f, 0.02682063f, 0.03369213f, 0.01983959f, -0.04136815f, 
    -0.03582063f, 0.02287120f, 0.01769085f, 0.01407886f, 0.01272873f, -0.03227635f, -0.03063545f, 0.00743353f, 
    0.01862368f, -0.00223285f, 0.00423730f, -0.04098865f, -0.01293732f, -0.00365354f, -0.04145039f, 0.01250128f, 
    0.02260543f, -0.00043522f, 0.00217460f, 0.00031204f, -0.01268088f, -0.01532898f, -0.03566283f, -0.02623543f, 
    -0.02725641f, -0.00387170f, -0.03166929f, -0.01890979f, 0.00789308f, -0.02610508f, -0.01080542f, -0.02012746f, 
    0.01414707f, -0.02863937f, 0.02837775f, -0.00193447f, 0.01891107f, 0.02908073f, 0.01942057f, 0.02017860f, 
    -0.03391821f, -0.00145878f, -0.02995132f, -0.03732290f, -0.02003137f, 0.02789409f, 0.01585892f, 0.01642841f, 
    -0.00122679f, -0.01990335f, 0.03491199f, 0.03265905f, -0.00078105f, -0.01618285f, -0.00589591f, -0.00362543f, 
    0.01538873f, -0.02080463f, 0.00994604f, 0.00303548f, 0.00515347f, 0.00767586f, 0.00825381f, -0.00399149f, 
    -0.02597738f, -0.02401809f, 0.01945988f, 0.01471214f, -0.02221426f, -0.01714595f, 0.03293746f, -0.00120339f, 
    0.00130781f, 0.00349043f, 0.01106282f, 0.02814275f, -0.03352655f, -0.01487444f, -0.00636008f, -0.00121106f, 
    0.01367188f, -0.00314447f, -0.00522937f, -0.01053053f, -0.00188861f, -0.03920487f, -0.02301280f, 0.00628200f, 
    -0.03814676f, -0.01665740f, 0.02243283f, -0.00489814f, 0.01981029f, 0.01661480f, 0.01604628f, -0.03548079f, 
    -0.01237397f, 0.01962597f, 0.00463183f, 0.00593388f, 0.02794379f, -0.01658009f, -0.00817558f, -0.02037636f, 
    -0.02707086f, -0.02860296f, 0.02375657f, 0.00276072f, -0.04190591f, 0.00818901f, 0.01014916f, 0.01596922f, 
    0.02214580f, 0.02874033f, 0.01228749f, 0.00629044f, 0.01638310f, -0.01177256f, -0.01098885f, 0.03647024f, 
    -0.02081341f, 0.00237464f, -0.03549919f, -0.01183522f, -0.00301095f, 0.00614208f, 0.03548358f, -0.03072128f, 
    -0.02897149f, 0.00256686f, -0.01608722f, -0.02197341f, -0.00946825f, 0.02961851f, 0.01090177f, -0.02777230f, 
    -0.03474361f, 0.01877793f, -0.00432728f, -0.02061358f, 0.02713798f, 0.03222973f, -0.03088738f, -0.01948053f, 
    -0.00633728f, -0.00368250f, -0.03073670f, -0.00432621f, -0.03122460f, -0.04065553f, -0.01945048f, 0.00614053f, 
    -0.02506647f, -0.01639493f, -0.03329188f, -0.03177487f, 0.01159789f, 0.02371557f, 0.00870090f, 0.02720757f, 
    0.02880036f, 0.00457047f, -0.02718512f, -0.02671901f, 0.02933014f, -0.00823608f, 0.01814610f, 0.02416055f, 
    0.01011199f, -0.00143495f, 0.01971506f, 0.02197070f, 0.00302276f, -0.03930538f, -0.02216546f, -0.03701900f, 
    0.03194451f, 0.02220162f, 0.02117993f, -0.00615471f, -0.00039192f, -0.03738046f, -0.02518992f, 0.01836554f, 
    -0.03240877f, -0.03981037f, -0.01437432f, 0.00600631f, -0.01075806f, -0.01046197f, -0.00588263f, 0.04006615f, 
    -0.01092463f, -0.04570833f, 0.00367326f, 0.00583008f, -0.01565130f, -0.00682525f, -0.01111467f, -0.00244774f, 
    -0.02903478f, 0.00684331f, 0.01128897f, 0.01756847f, 0.01555008f, -0.00672231f, -0.03383795f, -0.02636844f, 
    -0.00404584f, -0.03852269f, 0.01905611f, 0.02468687f, -0.01573868f, -0.01096560f, 0.02004837f, -0.02350514f, 
    0.01934288f, 0.00281117f, 0.02894965f, -0.02448828f, -0.01182542f, -0.00156478f, -0.00290280f, 0.02641525f, 
    0.03210346f, -0.02712776f, -0.01187710f, 0.00813613f, 0.01096245f, -0.00064371f, -0.00636933f, 0.01613940f, 
    0.01521218f, 0.03463316f, -0.01880654f, -0.00217236f, -0.00742752f, 0.00346231f, 0.00834599f, -0.04479579f, 
    -0.00941766f, -0.03967137f, -0.00276982f, -0.00907333f, 0.01800140f, -0.01875921f, 0.03623104f, -0.03201428f, 
    0.02026945f, 0.00921263f, 0.02071730f, 0.00894367f, -0.02780268f, -0.00079542f, 0.00583423f, -0.02388730f, 
    0.02584920f, -0.02632819f, 0.02695744f, -0.01989022f, -0.02631836f, -0.01262181f, -0.00480915f, 0.00803824f, 
    0.01999250f, 0.00393167f, 0.02287713f, -0.04279092f, 0.02975099f, -0.00598519f, -0.02444438f, 0.00441835f, 
    0.00263691f, -0.00542979f, 0.00950820f, 0.02617764f, -0.04417160f, 0.00510429f, 0.01983638f, -0.00803890f, 
    -0.03409581f, -0.01560697f, 0.01602894f, 0.01669638f, -0.02938983f, 0.01761578f, -0.03702601f, 0.00265641f, 
    0.02836695f, 0.00031001f, 0.01216524f, -0.02593561f, 0.00715778f, 0.01480199f, -0.03825798f, -0.01392950f, 
    -0.03658436f, 0.00082124f, -0.03732480f, 0.02011830f, 0.00469668f, 0.00558518f, 0.02976541f, 0.00205266f, 
    -0.04032012f, 0.01939655f, 0.00432404f, -0.00515168f, 0.02640972f, -0.00840450f, 0.02915565f, 0.01517697f, 
    -0.03116354f, 0.02184587f, -0.00844216f, 0.03523013f, -0.00038753f, -0.04192508f, 0.00548083f, -0.03071078f, 
    -0.01659807f, 0.02364549f, 0.02101408f, 0.01331158f, 0.01220709f, 0.02213103f, 0.02587252f, 0.03054687f, 
    -0.00202490f, -0.00463865f, -0.01364642f, -0.01512250f, 0.02071244f, 0.01541237f, 0.02658888f, -0.02263634f, 
    0.00337363f, 0.01141370f, 0.01053137f, -0.03029005f, -0.03345883f, 0.01493082f, -0.03400789f, -0.04048216f, 
    0.01097473f, 0.01898655f, 0.01857484f, -0.00211142f, 0.01891990f, -0.03124277f, -0.04168842f, 0.02375779f, 
    0.02236475f, 0.01420204f, 0.00961244f, -0.03821009f, -0.01630214f, -0.04251835f, -0.00734925f, 0.01488261f, 
    0.02910795f, -0.03620682f, 0.00040509f, 0.02217060f, 0.01317303f, -0.04035473f, -0.02504713f, -0.03812597f, 
    0.01114717f, -0.02008807f, 0.00167644f, -0.02058308f, -0.02980900f, 0.02389076f, 0.02052514f, 0.03449634f, 
    0.01531413f, -0.03209057f, 0.01027246f, -0.03262000f, -0.03245265f, -0.00597017f, -0.00176912f, 0.00033488f, 
    0.00829290f, 0.00101709f, -0.00159465f, -0.03854650f, -0.04143595f, 0.01757347f, 0.00021082f, -0.03854984f, 
    0.00661401f, 0.00059607f, 0.02237102f, -0.02067355f, 0.01008065f, -0.01094569f, -0.03139497f, -0.00635695f, 
    -0.02356766f, -0.00763724f, 0.01658438f, -0.03794648f, -0.00945490f, -0.00805263f, -0.01669080f, 0.02781536f, 
    -0.00990686f, -0.02978881f, 0.01699143f, -0.00406521f, -0.03696316f, 0.02733576f, -0.01879398f, -0.02919274f, 
    -0.01120196f, -0.00196796f, -0.00035519f, 0.02431191f, 0.02124745f, -0.00961563f, -0.00807146f, 0.03148286f, 
    -0.04039369f, 0.02310082f, -0.02934024f, 0.01003048f, -0.01959112f, -0.00153423f, -0.00686112f, 0.01183093f, 
    -0.03065128f, -0.02672558f, -0.03191006f, 0.01129498f, -0.01427937f, -0.02989508f, -0.02548921f, 0.01943061f, 
    0.02728965f, -0.01801909f, -0.03527676f, 0.03380896f, 0.01891958f, 0.01954746f, 0.00220462f, -0.01017395f, 
    0.01180566f, 0.00274561f, -0.01505833f, -0.00858729f, 0.03318569f, -0.00297780f, -0.01849283f, 0.00565561f, 
    -0.01722017f, -0.00250247f, 0.02090592f, 0.02410796f, -0.00169745f, -0.03518635f, -0.01893484f, 0.02165037f, 
    0.02996386f, 0.00349394f, -0.03895411f, 0.02631791f, -0.01020574f, 0.01899230f, 0.01981872f, 0.02872423f, 
    -0.00608124f, -0.00750734f, -0.02907379f, -0.03592960f, -0.02111792f, 0.02995785f, 0.02325686f, -0.00778420f, 
    -0.02426989f, -0.00498687f, -0.01756149f, 0.02916223f, -0.03426536f, 0.02403769f, -0.01738316f, 0.00155377f, 
    -0.01257211f, -0.01862960f, 0.02531000f, -0.01403938f, 0.01155366f, -0.01144077f, 0.01644988f, 0.00693616f, 
    -0.00761924f, 0.02684755f, 0.02998878f, 0.01389306f, 0.00701750f, 0.02826083f, -0.02905952f, 0.01419897f, 
    -0.02919598f, 0.01081647f, -0.02043739f, -0.01843075f, 0.03104653f, 0.01536695f, 0.01337879f, 0.01341608f, 
    -0.03778533f, 0.01407811f, 0.03254795f, -0.04343626f, 0.00561454f, 0.01915651f, -0.03629190f, 0.01043695f, 
    -0.02851215f, 0.02036189f, 0.01282201f, -0.01490735f, 0.01818243f, 0.01335665f, 0.01429348f, -0.03210753f, 
    0.00366610f, -0.03026145f, 0.01263748f, -0.03091322f, -0.02851667f, -0.03466205f, 0.00025728f, 0.00351608f, 
    -0.03941901f, -0.03194784f, 0.02675856f, 0.02610997f, -0.03713349f, 0.02258656f, -0.02395692f, -0.02066024f, 
    -0.00664207f, 0.02707808f, -0.00801290f, 0.00738330f, 0.00480801f, -0.02729807f, -0.03003205f, -0.03193469f, 
    -0.03173757f, -0.00354598f, -0.00746290f, 0.00505078f, -0.04173091f, -0.00585652f, 0.02992196f, -0.02170876f, 
    -0.00015045f, -0.00926137f, -0.00800750f, -0.00601843f, 0.00269902f, -0.03682087f, -0.02265971f, -0.02968138f, 
    -0.01568100f, -0.04909110f, 0.00177208f, -0.26102212f, 0.01058820f, 0.04139614f, 0.17646670f, 0.01685809f, 
    0.06259659f, 0.10732187f, -0.14846890f, -0.13422665f, 0.21684365f, 0.04950483f, -0.07357202f, -0.18297455f, 
    0.02907036f, -0.07351995f, -0.06170535f, 0.04293153f, 0.03336029f, -0.09497510f, 0.06041295f, -0.02649136f, 
    0.09277268f, 0.12602031f, 0.16253243f, -0.17950580f, 0.01749223f, -0.03423256f, -0.00354377f, -0.05575803f, 
    0.15476094f, 0.11042236f, -0.06755556f, 0.14893387f, -0.47069290f, 0.08159628f, -0.04113674f, -0.06851688f, 
    -0.14955635f, 0.04685105f, 0.06548315f, -0.08020855f, -0.06874318f, 0.00693219f, 0.05711972f, -0.05636588f, 
    -0.10021148f, -0.14616221f, -0.04659306f, 0.13273403f, -0.01092629f, 0.00870072f, -0.02740597f, -0.00607799f, 
    0.12775360f, -0.03475903f, 0.01892714f, 0.02018629f, -0.03819904f, 0.08465125f, 0.05467404f, -0.04575345f, 
    0.11901014f, 0.00987795f, 0.04005687f, -0.06812163f, 0.03089226f, -0.06896711f, -0.03418381f, 0.08056699f, 
    0.29695678f, 0.00931181f, 0.10611238f, -0.02380317f, 0.02304653f, -0.02680670f, 0.04473101f, 0.04128278f, 
    -0.01652627f, -0.02491919f, -0.04592159f, 0.01096265f, 0.20268176f, -0.07247877f, -0.04523649f, 0.02434771f, 
    -0.01758170f, 0.17433672f, 0.11252121f, 0.10105024f, 0.03194113f, -0.09182329f, -0.08628275f, -0.05162511f, 
    0.23910080f, 0.00486965f, -0.24233735f, -0.30561659f, -0.03852104f, 0.04052118f, 0.17218761f, 0.05105492f, 
    0.00149206f, -0.03699632f, -0.02578183f, -0.00347805f, 0.17211957f, -0.05769659f, 0.00735757f, 0.03206370f, 
    0.03480514f, -0.05644647f, 0.02785903f, 0.02752767f, 0.07618870f, 0.00871724f, -0.04173993f, -0.09325042f, 
    -0.19503748f, -0.25326818f, 0.22540668f, -0.13929135f, 0.03092161f, 0.01554000f, 0.04231503f, -0.00329981f, 
    0.04180906f, 0.06903645f, -0.05805865f, 0.01364271f, 0.27595857f, 0.01554318f, -0.11810176f, -0.11106043f, 
    -0.04425574f, -0.04435143f, 0.12279688f, -0.05094625f, 0.00704115f, -0.00245150f, 0.04948433f, -0.03463606f, 
    -0.11618292f, -0.00612464f, 0.07484402f, -0.03904886f, 0.02639062f, 0.13390243f, 0.13518831f, -0.10448212f, 
    0.00923005f, -0.03165843f, 0.01566757f, 0.02982474f, 0.04852275f, 0.00021691f, 0.09904294f, -0.10252751f, 
    -0.19206822f, -0.06491964f, 0.04606007f, 0.00894130f, 0.04806925f, 0.03373674f, -0.03069241f, -0.17853385f, 
    0.38425490f, -0.04158904f, -0.21238284f, -0.08711459f, 0.09163655f, -0.08199376f, 0.12240430f, -0.01598753f, 
    -0.01275695f, 0.00391984f, -0.06384883f, 0.05156229f, 0.30188951f, -0.21402681f, 0.09739596f, 0.03959502f, 
    0.05371628f, 0.04795391f, 0.01457808f, 0.07953823f, -0.03921852f, 0.14483130f, 0.02423533f, 0.04015536f, 
    0.18161102f, -0.27263919f, 0.05449564f, -0.20088586f, 0.06002733f, -0.02157962f, 0.03382726f, -0.01095463f, 
    -0.02920215f, 0.03429719f, 0.19045582f, -0.07171737f, 0.08982433f, -0.31213516f, 0.03055287f, -0.01551759f, 
    0.01238419f, 0.07121385f, 0.03408339f, 0.06579023f, -0.00835149f, -0.10942589f, 0.04384748f, 0.20900959f, 
    0.05560691f, -0.18565847f, 0.09400613f, -0.27920151f, 0.05072293f, -0.05733833f, -0.06320211f, -0.06787948f, 
    -0.03289739f, -0.00634392f, 0.11896070f, 0.13182920f, -0.03914507f, 0.04581222f, 0.22852172f, -0.04663075f, 
    -0.10394257f, -0.11804660f, 0.14865527f, -0.13766503f, -0.01348576f, -0.02475722f, -0.04643388f, 0.00785999f, 
    -0.15353133f, 0.10347130f, 0.00708396f, 0.16489685f, -0.07871754f, -0.12360972f, 0.07616061f, 0.11384398f, 
    -0.07271941f, 0.11013015f, -0.20360358f, -0.00457460f, 0.02146300f, -0.02463391f, 0.10724459f, 0.22987324f, 
    0.03354622f, 0.11607601f, 0.00006861f, -0.01002461f, 0.00468521f, 0.01995399f, -0.08747631f, -0.01028123f, 
    -0.07478313f, 0.16224855f, 0.04509884f, -0.06789725f, -0.05447205f, -0.00014733f, 0.00969611f, 0.01380491f, 
    0.07228449f, -0.05078561f, 0.01913913f, -0.04428116f, -0.22192730f, -0.02134624f, 0.23840800f, 0.33360597f, 
    -0.02815166f, -0.03480549f, 0.10914283f, -0.05278182f, 0.10952488f, -0.07527265f, 0.12394660f, 0.09298442f, 
    -0.15977697f, -0.04641425f, 0.12991343f, -0.00601057f, 0.03848671f, 0.14930606f, -0.04991358f, 0.01511076f, 
    0.07780363f, 0.07472990f, 0.05454226f, -0.03057788f, 0.35753644f, -0.00324977f, 0.07602648f, -0.00482559f, 
    -0.02335633f, 0.03997227f, 0.08646652f, 0.00874421f, -0.21460596f, -0.00473898f, 0.17692487f, 0.15393278f, 
    0.20721547f, -0.21493539f, -0.08130248f, -0.06435128f, 0.00304771f, -0.02047151f, 0.05651268f, 0.07502869f, 
    0.02028918f, -0.05045093f, 0.01375256f, 0.02403904f, 0.17192690f, -0.14350373f, 0.02797257f, -0.03268192f, 
    -0.06125181f, 0.05791857f, 0.05310358f, -0.08022628f, 0.07660123f, 0.04706520f, -0.01904687f, 0.12620787f, 
    -0.29823047f, 0.00815211f, -0.04753655f, -0.23369049f, -0.13667147f, 0.06436217f, 0.12182564f, -0.05886451f, 
    0.01734016f, 0.02268959f, -0.00562556f, -0.06377107f, -0.12179996f, 0.03947534f, 0.03807404f, 0.10499948f, 
    -0.00257972f, 0.00130862f, 0.00236516f, 0.06329378f, 0.03975481f, 0.13832510f, -0.05079488f, 0.05464333f, 
    0.04300025f, -0.18000776f, 0.13984084f, 0.19873938f, 0.02155107f, -0.03050465f, 0.03223558f, 0.01990218f, 
    -0.02061506f, 0.02557381f, -0.09610482f, -0.00402736f, -0.01853506f, 0.21791156f, 0.05204504f, 0.07929337f, 
    -0.07861204f, -0.09587499f, -0.06258439f, 0.05042327f, 0.00086795f, 0.00174503f, 0.10408627f, 0.09585879f, 
    0.04027684f, 0.13562058f, 0.14275883f, 0.08488204f, 0.00834128f, -0.04152996f, -0.08550751f, -0.04613175f, 
    -0.01472147f, 0.02543082f, 0.00728929f, 0.02316047f, -0.28278017f, 0.23177350f, 0.10104463f, -0.07473474f, 
    -0.08021619f, -0.05711813f, -0.05573145f, -0.25341043f, 0.07774299f, -0.00760979f, -0.13177828f, -0.07353872f, 
    0.47389138f, 0.04499280f, -0.23415865f, -0.21515614f, 0.02414635f, 0.11700938f, 0.05027548f, -0.02617216f, 
    0.00666792f, 0.11022997f, -0.01632546f, 0.16425006f, 0.06896973f, -0.00145024f, -0.04748590f, -0.07849304f, 
    -0.01995118f, 0.04343383f, 0.04838714f, 0.09164454f, -0.06183120f, 0.00161216f, -0.03733506f, 0.00565708f, 
    -0.29046848f, -0.42278534f, 0.34924775f, 0.17621376f, -0.01351129f, 0.08685265f, -0.13371330f, 0.01622644f, 
    0.14190432f, 0.04430065f, -0.02877198f, -0.05689074f, -0.05786944f, 0.07866378f, 0.09885544f, 0.10139303f, 
    -0.02273335f, -0.06872364f, 0.00973071f, 0.02575003f, 0.14339443f, 0.07270659f, 0.03942708f, -0.02366067f, 
    -0.22821309f, 0.09483510f, 0.13234293f, 0.01564979f, -0.12658663f, -0.06576065f, -0.05791373f, 0.01330170f, 
    -0.06494416f, -0.04081648f, 0.01525192f, 0.13199608f, 0.13733774f, -0.28918162f, 0.10652784f, -0.21631408f, 
    -0.00066483f, 0.02866586f, -0.07414895f, 0.02883084f, 0.00837928f, 0.04536352f, -0.00900752f, 0.04664642f, 
    0.16093269f, -0.26786566f, 0.18657973f, 0.32677862f, -0.07023171f, -0.00638009f, 0.11239476f, 0.04927259f, 
    0.16437438f, 0.15094733f, 0.19846697f, 0.09889024f, 0.06915034f, 0.13153946f, 0.08658227f, -0.26104876f, 
    -0.01284228f, -0.04044668f, 0.05295598f, -0.13204663f, 0.00315858f, 0.05374238f, 0.02622565f, 0.12635288f, 
    -0.05739387f, 0.06276042f, 0.02723220f, 0.00224217f, -0.01831069f, -0.04118173f, -0.06813505f, -0.02165946f, 
    -0.06834662f, 0.00008577f, -0.05391988f, 0.04548865f, 0.27790284f, -0.00631043f, -0.11953079f, -0.12223279f, 
    -0.03450602f, 0.00740753f, 0.13344239f, 0.04332118f, 0.03833258f, -0.02741330f, 0.09597653f, -0.01787839f, 
    0.11361397f, 0.05810465f, -0.23791146f, -0.12657759f, 0.02773762f, -0.00441487f, 0.09672298f, 0.06390292f, 
    -0.06128568f, -0.01453455f, -0.01276970f, 0.03729213f, -0.37880817f, 0.11379612f, 0.05522142f, -0.14028804f, 
    0.03860347f, 0.00622961f, -0.07253322f, 0.04364547f, 0.04483303f, -0.05506362f, -0.06819136f, 0.03161155f, 
    0.01085221f, 0.12027976f, -0.05387351f, -0.03956969f, -0.02182162f, 0.05233867f, 0.00794982f, -0.06832939f, 
    -0.03168010f, 0.00348962f, 0.00382653f, 0.14307438f, -0.20640633f, 0.17246406f, 0.20563772f, -0.10399770f, 
    -0.11680132f, 0.04263061f, -0.09595358f, -0.01497517f, 0.07240915f, 0.03091333f, -0.01488844f, 0.02825684f, 
    0.17406444f, -0.02735511f, -0.20468830f, -0.09845653f, 0.08495891f, -0.02230556f, 0.06435883f, -0.00516349f, 
    -0.05151678f, -0.02683653f, 0.04764469f, 0.08406946f, 0.01337903f, 0.20206866f, 0.23093256f, -0.03215213f, 
    -0.06732512f, -0.08891707f, 0.01520534f, -0.14969055f, 0.02599420f, -0.06039816f, -0.00761634f, 0.00414632f, 
    0.11797971f, 0.03630811f, 0.13376056f, 0.24793261f, -0.01217240f, 0.03329875f, -0.04615007f, 0.00072146f, 
    0.03635460f, -0.00327594f, 0.03579583f, -0.01375726f, 0.22456709f, -0.07245099f, -0.07358444f, -0.20121956f, 
    0.05964912f, 0.03487510f, 0.01599883f, 0.02246360f, 0.13464609f, 0.01053172f, 0.14524396f, -0.05004954f, 
    -0.09712400f, -0.02325514f, 0.20811176f, 0.00147165f, 0.04819489f, 0.09619686f, -0.01362017f, 0.06016992f, 
    -0.11305197f, -0.08026613f, -0.07420735f, -0.23361297f, 0.10653915f, -0.21868031f, -0.06785853f, -0.07626607f, 
    0.01505443f, 0.00088896f, -0.05414782f, 0.01386105f, 0.08471648f, 0.04502296f, -0.08826420f, 0.09037735f, 
    -0.26934850f, 0.04865999f, -0.07632609f, 0.06777465f, -0.03846093f, -0.03586876f, -0.06972973f, 0.06066796f, 
    0.08245292f, -0.14621675f, 0.20219480f, 0.20928968f, 0.12275861f, -0.14330845f, 0.13348906f, 0.10606430f, 
    -0.04618967f, -0.11341234f, 0.02742086f, -0.01705741f, -0.07650409f, 0.07684705f, 0.08195584f, -0.07210759f, 
    0.15889053f, -0.03643138f, 0.00368352f, 0.27372515f, -0.03515716f, 0.05938550f, -0.05483349f, 0.01283922f, 
    -0.01784540f, -0.00396432f, 0.02974269f, -0.01091001f, 0.04665396f, -0.03963477f, -0.07515352f, 0.04713903f, 
    -0.04341713f, 0.12067160f, 0.05611555f, -0.02858146f, -0.02462109f, -0.08252182f, 0.06624150f, -0.04065568f, 
    0.18959785f, 0.13925716f, 0.06438106f, -0.01491729f, 0.02850026f, -0.00018511f, 0.05028788f, -0.03955898f, 
    0.04479218f, 0.00699433f, 0.01801313f, -0.02419809f, 0.06604670f, 0.15788887f, 0.13432057f, -0.07237823f, 
    0.00233342f, -0.08282194f, -0.03370377f, 0.06394427f, -0.03096054f, 0.04582738f, -0.08983014f, -0.00264128f, 
    0.45292187f, 0.01024629f, -0.20937613f, -0.24281509f, -0.01580309f, -0.06678958f, 0.00879961f, 0.18660635f, 
    0.05692301f, -0.02086992f, -0.19665548f, -0.21944441f, 0.11677222f, -0.10808301f, 0.09544697f, 0.17229405f, 
    -0.02127301f, 0.02936235f, 0.00063827f, 0.04988513f, 0.00108248f, 0.03088170f, -0.02500886f, -0.14434241f, 
    0.00587201f, 0.12203091f, -0.09533928f, -0.06654875f, 0.17255834f, 0.04196810f, 0.02203727f, 0.05947585f, 
    -0.01721840f, -0.04070420f, -0.08982674f, -0.01840765f, -0.01769001f, 0.16474687f, 0.05572171f, -0.00943718f, 
    -0.07221614f, 0.00400801f, 0.02228162f, -0.04973502f, 0.05252007f, 0.04832080f, 0.01934956f, -0.00790375f, 
    -0.03503470f, 0.02136235f, 0.01162271f, -0.02934917f, 0.01630804f, 0.00798764f, -0.02615242f, 0.02873997f, 
    -0.00418201f, -0.03356794f, 0.01501891f, -0.03015449f, 0.02797670f, -0.00745013f, -0.03726670f, -0.03070266f, 
    0.00577286f, 0.00281669f, -0.01817114f, -0.02143341f, -0.01849086f, -0.03130274f, -0.03902006f, -0.01134833f, 
    -0.03711810f, 0.02915893f, 0.03001104f, 0.00464049f, -0.00392202f, -0.01295651f, -0.02768336f, -0.00230369f, 
    0.01195223f, -0.04265338f, 0.00944016f, 0.02322097f, -0.03505953f, 0.01435625f, -0.00181804f, 0.00484491f, 
    0.01939268f, 0.02375828f, -0.01622559f, -0.02081952f, -0.03011951f, -0.03414023f, 0.02048436f, -0.00703325f, 
    0.00887320f, 0.01505049f, -0.00094259f, -0.00307488f, -0.00810483f, -0.01725233f, -0.03470004f, 0.01534537f, 
    -0.02711047f, -0.00988734f, 0.01171527f, 0.00176363f, 0.01816183f, 0.00081417f, 0.02282937f, 0.02203450f, 
    -0.02974259f, 0.01382918f, 0.02523773f, -0.00554957f, -0.01347328f, 0.00861545f, 0.00239452f, -0.01994079f, 
    0.01003815f, 0.00326325f, 0.02351302f, -0.01647758f, -0.02520584f, -0.01207584f, -0.03480696f, 0.00018405f, 
    -0.01292446f, -0.02631579f, -0.04007562f, 0.02154866f, -0.02312606f, -0.03967091f, -0.00441065f, 0.02138018f, 
    -0.04383599f, -0.00691035f, -0.03012752f, -0.04207843f, -0.01018888f, 0.00890166f, -0.01765304f, 0.01770450f, 
    -0.01936610f, 0.00678069f, -0.00710928f, -0.03494532f, -0.01138035f, -0.01577691f, 0.01401181f, 0.02167232f, 
    -0.03704923f, -0.00810770f, -0.04390230f, -0.01586314f, 0.03298072f, -0.00883068f, 0.01822581f, -0.02679818f, 
    0.03046886f, -0.03484223f, 0.02156327f, -0.03560688f, 0.02051101f, 0.00709359f, -0.03024584f, -0.02926240f, 
    0.00929570f, -0.02713370f, -0.04240631f, 0.01929273f, -0.02150227f, 0.00833589f, 0.00644972f, 0.02596283f, 
    -0.02718974f, -0.04112376f, 0.02656898f, 0.01591983f, 0.01753004f, -0.02135783f, -0.03924684f, 0.01363639f, 
    -0.03705377f, -0.03749108f, 0.00433720f, -0.02556001f, -0.03303086f, -0.03472230f, 0.01870105f, 0.01647462f, 
    0.01112044f, -0.01241220f, -0.03816484f, 0.00187082f, -0.00049361f, 0.00391029f, 0.02143466f, 0.00569775f, 
    0.00670371f, -0.02907243f, -0.02745793f, -0.01987203f, 0.02881871f, 0.02577273f, 0.00216915f, 0.01633056f, 
    0.01520577f, -0.02484837f, 0.00652327f, 0.02084375f, 0.01718219f, 0.01693763f, -0.02933035f, -0.02828352f, 
    -0.03217398f, -0.02779647f, -0.00089058f, -0.02558829f, -0.00318383f, 0.02772254f, -0.00478941f, -0.00213791f, 
    0.03075517f, -0.03675690f, -0.03583251f, 0.00428435f, -0.00758333f, -0.00685694f, 0.00384413f, 0.02811364f, 
    0.00506862f, -0.01332170f, -0.00445013f, -0.01584707f, 0.00610438f, -0.02495387f, -0.03212557f, 0.02094802f, 
    -0.01512332f, -0.04411462f, -0.01853067f, 0.01938520f, 0.01658481f, 0.02244170f, -0.01337612f, -0.01898084f, 
    -0.01094878f, -0.00644244f, -0.01857697f, 0.01348227f, 0.02332794f, -0.02880398f, 0.01280614f, 0.00258704f, 
    0.01746871f, 0.01307377f, -0.02446461f, 0.02185598f, -0.01213238f, 0.01797036f, 0.01156779f, -0.02743707f, 
    0.01988932f, -0.03732993f, -0.00006652f, 0.00404874f, -0.02297460f, -0.00674420f, -0.02115593f, 0.01143050f, 
    0.01412145f, -0.03851168f, -0.01882118f, 0.00340846f, -0.03899524f, 0.00254638f, -0.00567394f, 0.00889394f, 
    -0.03539332f, -0.01819550f, 0.00540387f, -0.00741785f, 0.00587794f, -0.00973207f, -0.01286968f, -0.00020573f, 
    -0.01007487f, -0.02295836f, -0.03603576f, -0.03381806f, 0.02405157f, -0.02525970f, 0.00515485f, -0.01875114f, 
    0.01498529f, -0.00377203f, -0.03698117f, -0.02461459f, -0.01050485f, -0.01946010f, 0.00090687f, -0.01376840f, 
    -0.04147518f, 0.00237039f, -0.04357940f, -0.01866428f, 0.01545417f, 0.01025236f, -0.02476585f, -0.01655574f, 
    0.00219086f, 0.01145945f, -0.04033531f, 0.02799252f, -0.02812110f, -0.00884055f, 0.02462778f, 0.01147092f, 
    -0.03335320f, 0.02509173f, 0.00879532f, 0.01120525f, -0.03053554f, -0.04007110f, 0.00030299f, 0.01209882f, 
    -0.00406312f, 0.00918470f, 0.01668916f, -0.04291607f, -0.03900341f, -0.03994372f, -0.01553209f, -0.00186348f, 
    0.01745703f, 0.01958533f, 0.00080353f, 0.00355378f, -0.02998209f, 0.02289542f, -0.01918359f, -0.01122043f, 
    -0.00217755f, -0.01144205f, 0.00914589f, -0.03716568f, -0.01131709f, 0.02933999f, 0.00366786f, -0.02302777f, 
    0.02499798f, -0.02174609f, -0.01977138f, -0.00679020f, 0.02452581f, -0.03992628f, -0.00732629f, -0.02653355f, 
    0.00721659f, -0.01149872f, 0.01508785f, 0.02840502f, -0.03857530f, -0.02118402f, -0.00942203f, -0.00154288f, 
    -0.03749932f, 0.01031449f, 0.02553479f, -0.01989494f, -0.03197063f, 0.02796405f, -0.03618000f, 0.01099274f, 
    0.00138979f, -0.02929495f, 0.00874026f, -0.00366391f, 0.02510582f, -0.02265128f, 0.02540965f, -0.00669500f, 
    -0.00509077f, -0.02650660f, -0.01224884f, -0.03462275f, 0.00653847f, -0.02357510f, -0.02596807f, -0.01341010f, 
    0.01366433f, -0.00849469f, -0.01640930f, 0.01543416f, 0.00861661f, -0.03272298f, -0.00108522f, -0.01302203f, 
    -0.01708636f, 0.01692852f, -0.02020741f, -0.01324283f, 0.00135992f, 0.02004855f, -0.00878729f, -0.02968369f, 
    0.02871864f, -0.02071322f, 0.02633824f, 0.02652257f, -0.00638300f, -0.00895480f, -0.01370587f, -0.04248821f, 
    -0.01267688f, -0.02744496f, -0.01591391f, -0.02204669f, -0.03291913f, -0.01970140f, 0.00608934f, 0.00607335f, 
    -0.00254210f, -0.00851478f, -0.02948391f, 0.02223816f, -0.03402715f, -0.03895852f, -0.02062776f, 0.02250827f, 
    -0.02257096f, 0.01798593f, 0.01479967f, -0.03249790f, 0.00644987f, -0.03919893f, -0.00311986f, 0.01767040f, 
    -0.01260989f, -0.01030310f, -0.03706291f, 0.02130331f, -0.02672769f, 0.00531930f, -0.00621404f, 0.02211598f, 
    -0.02198678f, 0.02267594f, 0.02711587f, -0.01308248f, 0.01113860f, 0.01039530f, -0.01067989f, -0.01691760f, 
    0.00578974f, -0.01390420f, -0.03143945f, 0.02198309f, 0.01053797f, -0.01544003f, 0.00440211f, 0.02015776f, 
    0.02826004f, 0.02277508f, -0.00569211f, 0.00906622f, 0.01117173f, 0.02842442f, -0.01577903f, 0.00483538f, 
    -0.00743458f, 0.01868334f, -0.02879427f, -0.00108378f, -0.02346045f, -0.00631508f, 0.01322166f, 0.00673282f, 
    0.01804568f, 0.01173523f, -0.02270613f, -0.01212080f, 0.00440945f, 0.00023950f, -0.04006674f, 0.02442348f, 
    -0.00040946f, 0.00395739f, 0.00958906f, 0.02096987f, -0.02568739f, -0.01212536f, -0.00425187f, 0.00256823f, 
    0.02359398f, 0.02601305f, 0.01210809f, 0.03143907f, 0.02528787f, 0.02133323f, -0.02237317f, -0.02726708f, 
    -0.00374410f, 0.02827555f, -0.03962148f, -0.02095961f, -0.03463907f, -0.01073070f, -0.03074020f, -0.00004185f, 
    -0.00328701f, -0.01641971f, 0.00052539f, -0.03909573f, -0.03468497f, -0.01135948f, -0.02639128f, 0.00501439f, 
    0.01507199f, -0.00123856f, 0.01254750f, -0.03896463f, -0.03737986f, 0.02192230f, -0.00126449f, 0.03126068f, 
    -0.00964592f, -0.02602006f, 0.02860149f, 0.00917518f, -0.03918398f, 0.01367386f, -0.01807235f, -0.02946610f, 
    -0.01534735f, -0.01490778f, 0.00873024f, 0.01582456f, -0.00791602f, -0.01995747f, -0.01040610f, -0.02720931f, 
    -0.01098683f, 0.02145075f, -0.02552985f, 0.00883108f, -0.03259684f, 0.01917612f, -0.02401254f, -0.03223293f, 
    0.00015397f, -0.03765622f, -0.01637927f, -0.00109232f, 0.01259131f, -0.00882683f, 0.01096603f, -0.02478540f, 
    0.00943105f, 0.00618465f, 0.00591194f, -0.01100271f, -0.01434676f, 0.00471970f, 0.02312700f, -0.01930428f, 
    -0.01805543f, -0.03975406f, -0.01646512f, 0.02423953f, -0.03690542f, 0.01103244f, -0.03467825f, 0.00814182f, 
    0.00263241f, -0.00351293f, 0.01878870f, -0.01612257f, 0.01004646f, 0.01678776f, -0.00689915f, 0.00631705f, 
    -0.02749547f, -0.02874394f, -0.03393159f, 0.00296323f, 0.01049281f, -0.03482263f, 0.01938207f, 0.03007116f, 
    -0.01513935f, 0.00530656f, 0.01434208f, 0.00377658f, 0.00852821f, -0.00185777f, -0.01542709f, -0.00756595f, 
    -0.00831385f, -0.00085391f, 0.00547384f, -0.01043402f, 0.01996799f, -0.02656950f, 0.00301874f, -0.03258475f, 
    -0.00876306f, -0.01184427f, 0.00607471f, 0.02469427f, 0.02349386f, -0.00316758f, 0.00906928f, -0.00708768f, 
    -0.01365918f, -0.03385085f, -0.00153713f, 0.00743086f, 0.00416169f, 0.00424861f, -0.03867175f, 0.02820980f, 
    0.02905722f, -0.00008235f, 0.01387877f, 0.01889609f, -0.00245215f, 0.00083804f, 0.02641163f, -0.00234022f, 
    0.02796017f, 0.00379830f, 0.02056088f, 0.01767974f, -0.02967530f, -0.02897177f, -0.01752453f, -0.02118596f, 
    -0.01807680f, 0.01419483f, 0.00360745f, -0.03208567f, 0.00005341f, 0.00205978f, -0.01273192f, 0.02087719f, 
    0.00709870f, 0.03052745f, 0.03035307f, 0.02730982f, -0.03769596f, -0.02453724f, 0.00674117f, 0.03111788f, 
    0.00260010f, -0.00128032f, 0.01370315f, 0.01648129f, -0.02146322f, -0.01999128f, -0.00196735f, -0.03621117f, 
    0.00568144f, -0.02257911f, -0.03816138f, 0.02297366f, -0.03681681f, -0.01865882f, 0.02022475f, -0.01498278f, 
    -0.02864423f, -0.01893777f, -0.02069032f, -0.01569440f, 0.03054290f, -0.00277898f, -0.01276905f, -0.02529767f, 
    -0.01973040f, 0.01464559f, -0.01986012f, -0.01037352f, -0.01842905f, -0.01037010f, 0.00631707f, 0.00631600f, 
    -0.03623560f, 0.01815219f, 0.00355922f, -0.03339833f, -0.01656053f, 0.02899211f, -0.02726294f, 0.01084924f, 
    0.02135473f, -0.00779431f, 0.01786677f, 0.01255521f, -0.01275631f, -0.00479421f, -0.00012794f, 0.00664035f, 
    0.03125693f, 0.01044388f, 0.00387006f, -0.00558288f, 0.02461358f, -0.00518945f, -0.02752563f, 0.01726913f, 
    -0.01342192f, -0.03720653f, -0.03130308f, 0.01460924f, -0.03235413f, 0.01916468f, 0.02391193f, -0.01391504f, 
    -0.00267718f, -0.00737866f, 0.03267847f, -0.02974332f, 0.01213582f, 0.01895654f, -0.00507621f, 0.01219508f, 
    -0.03073561f, 0.00914105f, 0.00000051f, 0.01453104f, -0.02669092f, -0.00400860f, 0.01206488f, 0.01435462f, 
    0.00799316f, -0.00868555f, -0.02767652f, -0.00941613f, 0.02750518f, -0.01494294f, -0.01943078f, 0.02293385f, 
    -0.03164415f, -0.03460309f, -0.03874449f, -0.01881389f, -0.01698877f, 0.02114112f, 0.00551892f, 0.01375451f, 
    -0.04063610f, -0.00416085f, 0.01802681f, -0.02014926f, -0.00600028f, -0.03847918f, 0.01004749f, -0.02232218f, 
    0.01165236f, -0.00877382f, -0.02636827f, -0.03899032f, -0.00363424f, 0.00687012f, -0.02162300f, -0.03634947f, 
    0.00587772f, 0.03001029f, -0.03506675f, -0.01481906f, 0.02422846f, -0.01890946f, -0.02916577f, 0.01840678f, 
    0.02388098f, 0.02035246f, 0.01426126f, 0.00242969f, -0.02212772f, 0.00740394f, 0.01241263f, -0.03871143f, 
    -0.01514553f, -0.02934593f, 0.02897823f, -0.03034571f, -0.03141140f, 0.01471110f, 0.01866673f, 0.02088318f, 
    -0.04022653f, -0.00208991f, 0.02145875f, 0.02348468f, -0.03719198f, -0.02763656f, 0.00183393f, 0.01398707f, 
    0.00439245f, -0.00832840f, -0.01523072f, -0.03478308f, 0.02387130f, 0.01729858f, 0.00738390f, -0.02472929f, 
    0.02886509f, -0.01298525f, 0.01719616f, -0.02333398f, 0.01603706f, -0.03563755f, -0.02611031f, -0.03948493f, 
    0.19802473f, -0.17997536f, 0.15916502f, -0.20558634f, 0.05868855f, -0.01979219f, -0.04063187f, -0.01831458f, 
    -0.01077532f, 0.01457493f, 0.06013235f, -0.08637660f, 0.40130258f, 0.06968655f, -0.25583899f, -0.18675394f, 
    -0.14532945f, 0.04521445f, -0.12531851f, -0.11174933f, -0.03574993f, -0.08299718f, 0.08673278f, -0.05620398f, 
    0.20218524f, 0.30793080f, 0.13444221f, -0.13153259f, -0.07684689f, -0.02606668f, -0.01480095f, 0.03521349f, 
    0.08319040f, 0.11784495f, 0.15450689f, 0.13984944f, -0.20078073f, 0.18511048f, -0.06957584f, 0.00362691f, 
    -0.02622760f, -0.04028574f, -0.04254006f, 0.02468703f, 0.01405153f, -0.05535651f, 0.01036856f, -0.04383601f, 
    -0.16471092f, 0.04440439f, -0.03601743f, -0.08605161f, 0.01313144f, 0.06433782f, 0.09940513f, 0.03223758f, 
    0.11711437f, -0.08519480f, 0.03625264f, 0.00374838f, 0.14867733f, 0.19695343f, -0.03557952f, -0.09652022f, 
    0.03937704f, 0.05952365f, 0.06810614f, 0.05031577f, -0.01318902f, -0.02357781f, 0.00840546f, -0.05586511f, 
    -0.13990000f, -0.15786403f, -0.15453848f, 0.09687695f, 0.02401867f, 0.12223013f, -0.02584699f, -0.04726791f, 
    0.08671643f, -0.00005322f, 0.06876846f, -0.00279978f, 0.10830095f, -0.15962210f, -0.17168371f, -0.04633869f, 
    0.03363143f, 0.10513883f, 0.04250627f, -0.06287219f, 0.09013925f, -0.07864295f, -0.08152992f, -0.22970228f, 
    -0.16885830f, -0.28507745f, -0.34622672f, 0.02996762f, 0.04575018f, 0.09166497f, 0.11109673f, -0.00286779f, 
    0.00960179f, -0.05445386f, -0.07995012f, 0.00440968f, 0.05785292f, -0.02708144f, -0.11050097f, -0.09786278f, 
    0.04642293f, -0.03925270f, 0.07176638f, 0.04918801f, -0.01252868f, 0.15246803f, -0.11573612f, 0.04918915f, 
    0.04499305f, -0.17586684f, -0.04076949f, -0.21185184f, 0.10559332f, -0.08383454f, 0.12309245f, 0.06341510f, 
    0.08727598f, 0.02413014f, -0.06909777f, 0.06697280f, 0.08281834f, -0.10300146f, -0.16645259f, -0.08544827f, 
    0.05505900f, 0.09665832f, 0.13216378f, 0.00234782f, 0.04868241f, 0.02845758f, 0.05293068f, 0.00774582f, 
    -0.14858781f, -0.21367227f, -0.12930696f, 0.00609070f, 0.20699881f, 0.04106433f, 0.07121696f, -0.07471293f, 
    0.03794310f, -0.02445812f, -0.03425119f, 0.03364090f, 0.33795917f, 0.10505565f, -0.07875762f, -0.28310958f, 
    0.00112777f, -0.00753857f, -0.07920500f, 0.04885643f, 0.00434522f, -0.00589329f, -0.00023928f, 0.06726813f, 
    -0.04344687f, -0.10029088f, -0.28946093f, -0.03983976f, 0.09882852f, -0.06291837f, 0.08118042f, -0.01766859f, 
    0.00650374f, 0.00986250f, -0.01277620f, -0.02175042f, 0.11023165f, -0.20035575f, -0.00894976f, 0.03235338f, 
    0.02458097f, 0.02238258f, -0.03266293f, 0.00076868f, 0.08578821f, 0.13305150f, 0.03393964f, 0.10717980f, 
    -0.09924185f, -0.30855295f, 0.09262346f, -0.17873245f, 0.04991398f, -0.06313315f, 0.02941936f, -0.01255039f, 
    -0.00013641f, 0.04182191f, 0.12676452f, 0.03793992f, 0.07949688f, -0.08177970f, 0.19055621f, -0.02853440f, 
    0.00744339f, 0.02415954f, -0.07395598f, -0.05166151f, -0.02792136f, -0.03711210f, 0.00068580f, 0.09523608f, 
    0.30263323f, -0.19571647f, -0.03966062f, -0.17383514f, -0.01979940f, 0.00926521f, -0.13585036f, -0.08897203f, 
    0.18684790f, -0.02910500f, 0.11931692f, 0.09619334f, 0.14520709f, 0.15133150f, 0.01572738f, -0.12149879f, 
    -0.04547726f, -0.11691127f, 0.23715122f, 0.15021674f, 0.08412649f, -0.01065559f, -0.00757316f, 0.05184237f, 
    0.02863147f, -0.04921720f, 0.27860186f, 0.06512342f, -0.08630912f, -0.18712865f, -0.05734845f, -0.05138161f, 
    -0.15021750f, -0.12627533f, -0.15388943f, 0.06123282f, 0.09071706f, -0.25035974f, 0.07613886f, 0.07424466f, 
    0.14097644f, 0.07691703f, -0.00264968f, -0.00275272f, 0.04044261f, 0.05925694f, -0.04302828f, 0.14481716f, 
    0.04178518f, 0.17539112f, 0.05656364f, -0.18247396f, 0.01083684f, 0.08642261f, -0.02522646f, 0.03976052f, 
    0.01037719f, -0.06674335f, -0.03451603f, -0.05574207f, -0.25179666f, 0.20785604f, 0.23546313f, 0.34365377f, 
    0.09280719f, -0.07193051f, 0.05668617f, -0.04602014f, 0.09526271f, 0.04824429f, -0.03865224f, 0.12839603f, 
    -0.13042632f, -0.21056892f, -0.12911221f, 0.10642277f, 0.14577003f, -0.08258495f, -0.09639686f, 0.13168906f, 
    0.16651045f, 0.05595708f, 0.05222394f, -0.08022747f, 0.04294054f, -0.16598868f, -0.01194138f, -0.06601767f, 
    0.01970874f, 0.05603427f, 0.04246833f, 0.00362564f, 0.02998418f, 0.00297875f, 0.16942209f, 0.02585092f, 
    0.03103896f, -0.34352213f, -0.05879916f, -0.05391283f, 0.01904156f, 0.01480367f, 0.01274440f, 0.03877911f, 
    0.08474666f, 0.02274610f, 0.03971801f, 0.02432845f, 0.09824760f, 0.07813491f, 0.04526084f, -0.13916564f, 
    0.01961596f, 0.01481518f, -0.09298527f, -0.12552787f, 0.20431025f, 0.02129435f, 0.13882159f, 0.19913188f, 
    -0.19791621f, 0.09216309f, 0.07622473f, -0.24009724f, 0.06298304f, 0.08392211f, -0.02556556f, 0.00068895f, 
    0.04359416f, 0.02738100f, -0.01745403f, -0.02109854f, -0.15730622f, 0.04047504f, 0.03469629f, 0.14732015f, 
    -0.01026440f, -0.01421116f, -0.11373452f, -0.00745372f, -0.01573917f, 0.12974615f, 0.05461777f, 0.11768738f, 
    -0.06196070f, -0.02916379f, 0.21774521f, 0.22534858f, 0.03664293f, 0.04114153f, -0.10514560f, -0.00557249f, 
    0.11654310f, 0.08312503f, 0.03142484f, 0.15062325f, 0.16134880f, 0.21188487f, 0.36350784f, 0.23224641f, 
    -0.10099466f, -0.10987860f, -0.08437176f, -0.08240306f, -0.11163829f, -0.11901016f, 0.09677699f, 0.07497959f, 
    0.06876370f, 0.19025144f, 0.26543477f, 0.02062484f, 0.17266138f, 0.11791269f, 0.11330625f, 0.00026384f, 
    -0.01942204f, 0.01127688f, 0.03542447f, -0.06130121f, -0.16733222f, 0.40043953f, 0.11839165f, 0.19369587f, 
    -0.01561854f, 0.06546782f, -0.11766190f, -0.09508961f, -0.07554065f, -0.01245849f, -0.10230892f, -0.01370962f, 
    0.30028105f, 0.03706944f, -0.26479498f, -0.24497351f, -0.08236998f, 0.10405870f, 0.03126184f, 0.04301766f, 
    0.06233561f, -0.03360199f, -0.02258557f, 0.07240012f, 0.11791071f, 0.00857247f, -0.02111416f, -0.17152597f, 
    0.14020543f, -0.04137479f, 0.18544070f, -0.07492246f, 0.00377493f, -0.09779280f, -0.02221400f, 0.01056089f, 
    0.03368774f, 0.18283300f, 0.30737269f, 0.33832064f, -0.01331099f, -0.02069457f, -0.12598845f, -0.05112389f, 
    0.08328069f, 0.05372883f, -0.07386491f, 0.03481845f, 0.11296082f, 0.19598207f, 0.04470357f, -0.00713273f, 
    0.01929479f, -0.01115527f, -0.00556990f, -0.04668429f, 0.01623366f, 0.06521777f, 0.04572976f, -0.03580432f, 
    0.10401088f, 0.19449387f, 0.15436171f, 0.03733366f, 0.02858504f, -0.07942946f, -0.07029803f, -0.07191376f, 
    -0.06534005f, 0.00470842f, 0.02902276f, 0.10725064f, 0.14906116f, -0.09487389f, -0.01891902f, -0.08030556f, 
    0.06017916f, 0.04073278f, 0.12029072f, 0.00268672f, 0.01776257f, -0.01148439f, -0.04099103f, 0.01429942f, 
    0.15287466f, 0.04197682f, 0.34561899f, 0.41852576f, 0.05071117f, -0.01579486f, 0.01938383f, -0.07975424f, 
    -0.00191777f, 0.01399041f, 0.10863415f, 0.01619556f, 0.11703310f, 0.05351003f, 0.01564053f, -0.06893434f, 
    0.15604869f, -0.10463054f, -0.00217759f, -0.00463192f, -0.00161245f, 0.12304980f, 0.15968007f, 0.06000581f, 
    0.02804150f, 0.08760136f, 0.01509942f, -0.07240064f, 0.00817161f, -0.07273849f, -0.00783924f, -0.02269002f, 
    0.01124145f, -0.00086227f, 0.00462491f, 0.03208625f, 0.06578027f, -0.19018851f, -0.22540192f, -0.11284829f, 
    0.02863067f, 0.02774318f, 0.02258524f, -0.05312555f, 0.08041499f, -0.04935847f, 0.04554102f, 0.02981215f, 
    -0.17992891f, 0.07389300f, -0.28995359f, -0.01469342f, 0.07097521f, 0.06100873f, 0.05651201f, -0.01546921f, 
    -0.00119958f, -0.05322023f, -0.03938499f, 0.04584393f, -0.30292422f, 0.32166013f, 0.20957103f, -0.11112696f, 
    0.05585222f, -0.11216730f, -0.05575322f, 0.00792664f, 0.03970496f, -0.00129816f, -0.07214929f, 0.06939833f, 
    0.16517146f, 0.13379925f, 0.09909084f, -0.01784110f, 0.04062219f, 0.01178956f, -0.07763720f, 0.00967467f, 
    0.10701492f, -0.00671166f, 0.11020066f, 0.09669144f, -0.08705735f, 0.18247963f, 0.16755350f, -0.20119917f, 
    -0.08671018f, 0.03866942f, -0.03261532f, -0.11670493f, 0.04588274f, 0.00314782f, 0.04157746f, 0.04039723f, 
    -0.11034187f, -0.27469772f, -0.29107857f, -0.06696324f, 0.03824592f, 0.02953835f, 0.07010345f, -0.01429991f, 
    -0.00508640f, 0.00618469f, 0.03098861f, 0.07095285f, 0.22074230f, 0.38986704f, 0.20488687f, -0.03333050f, 
    0.03315626f, 0.00949684f, 0.08347405f, 0.05179127f, -0.02537923f, -0.06766602f, -0.05372362f, -0.00588459f, 
    -0.08377727f, -0.00769978f, 0.02210060f, 0.16641651f, -0.02595777f, 0.04024541f, -0.03534331f, -0.04371008f, 
    0.07103962f, 0.06101374f, -0.11753805f, 0.11827730f, -0.00102243f, 0.02570904f, -0.11402153f, -0.13798688f, 
    0.03619023f, 0.07825486f, -0.03626249f, 0.11346382f, 0.15151712f, 0.04341484f, -0.01262209f, 0.11613763f, 
    -0.04108460f, -0.04338612f, 0.18762448f, -0.00925651f, 0.19863009f, 0.24111986f, 0.00737037f, -0.07336996f, 
    -0.12562494f, -0.18179941f, -0.16949558f, -0.09601153f, 0.19731987f, -0.20021872f, -0.07991611f, -0.17868121f, 
    0.01273613f, 0.10160062f, -0.02117738f, 0.02543351f, 0.06270072f, -0.02976486f, 0.02435154f, 0.10958266f, 
    -0.30978334f, -0.08901020f, -0.23339678f, 0.01012999f, 0.04086356f, -0.04831651f, -0.10358035f, 0.04446377f, 
    0.17934202f, 0.10743722f, 0.17007440f, 0.21282622f, -0.04036878f, 0.11949857f, 0.20655473f, 0.32579988f, 
    -0.02083724f, -0.08447342f, -0.00559685f, -0.00743788f, -0.01769160f, 0.00249289f, 0.03757700f, -0.05803910f, 
    -0.15181635f, -0.16209067f, 0.01019330f, 0.21244338f, 0.05356812f, 0.04232039f, 0.02006666f, 0.01875329f, 
    -0.01349430f, 0.06814102f, 0.16951132f, 0.10416333f, -0.01351812f, -0.18018815f, -0.17331286f, -0.01332835f, 
    0.07438071f, 0.06721197f, 0.07728080f, 0.15388773f, 0.07370001f, 0.00011193f, -0.05803052f, 0.06743810f, 
    0.32243234f, 0.31051722f, 0.12679930f, 0.12180528f, 0.09056590f, 0.13856857f, 0.09982523f, -0.01262196f, 
    0.07443839f, 0.01082422f, 0.02966436f, -0.01941146f, 0.21175669f, 0.11411494f, 0.07208710f, 0.05701809f, 
    -0.05533569f, 0.01694163f, 0.03638879f, 0.02931015f, 0.03687282f, 0.02467567f, -0.02524562f, 0.01740164f, 
    0.55090535f, -0.09501712f, -0.06828607f, -0.39866793f, -0.03571387f, -0.10993526f, -0.05854569f, -0.10419663f, 
    0.02182310f, 0.00603988f, -0.10114142f, -0.06727210f, -0.13653007f, -0.24597684f, 0.01334141f, 0.02333054f, 
    0.06516654f, 0.10758298f, -0.10456409f, -0.01084199f, -0.09098811f, 0.01768429f, 0.02179333f, -0.00793439f, 
    -0.26312658f, -0.08408713f, -0.27347010f, -0.15051612f, 0.09179817f, -0.06149014f, 0.04980881f, 0.09435189f, 
    0.04660991f, -0.00463927f, 0.06956175f, -0.01352942f, 0.14785023f, 0.39476100f, 0.14265272f, 0.08907320f, 
    0.02462203f, 0.07078677f, 0.00332953f, -0.02643901f, 0.05600688f, 0.04647954f, -0.00244262f, 0.05051713f, 
    0.03335589f, -0.04315910f, 0.03460356f, -0.17101336f, -0.14046614f, 0.11031213f, -0.00547353f, 0.06472597f, 
    0.11523089f, 0.04112479f, -0.06284539f, 0.07837954f, 0.05379802f, -0.08911262f, 0.13304947f, 0.01190938f, 
    -0.03961832f, -0.06706204f, -0.13391753f, 0.01929814f, 0.06175422f, 0.03517502f, -0.07676440f, 0.02278269f, 
    0.09780638f, 0.04124562f, 0.19955465f, -0.00495317f, -0.00419349f, -0.07553980f, 0.03459985f, 0.04214272f, 
    0.00601037f, 0.06951332f, -0.03522508f, 0.00070372f, -0.02014184f, 0.09760106f, -0.16478041f, -0.11728147f, 
    -0.10612539f, -0.14398763f, 0.13023812f, 0.09190574f, 0.07481316f, -0.16805674f, 0.04147489f, -0.00843482f, 
    -0.07503594f, -0.15943149f, 0.12401610f, 0.15593614f, 0.00331226f, 0.06943932f, 0.10556445f, -0.01393511f, 
    0.00321639f, 0.06387686f, -0.00505928f, -0.02844334f, 0.06887691f, 0.26154029f, 0.07858025f, 0.13773419f, 
    0.00874881f, 0.10496061f, 0.06780390f, 0.21520102f, 0.07553232f, 0.05304992f, 0.04430632f, 0.07000913f, 
    -0.12904400f, -0.28223240f, -0.04467471f, 0.07327095f, 0.10036583f, -0.04800962f, -0.15299836f, 0.04797344f, 
    0.12843868f, -0.01013297f, 0.10347831f, 0.03456628f, -0.01837290f, 0.15650810f, 0.05445116f, -0.09405439f, 
    0.02643088f, 0.16433740f, 0.09514938f, -0.05957422f, 0.22390434f, 0.01505624f, -0.13269091f, 0.03554837f, 
    0.13052128f, -0.05829408f, -0.32192177f, 0.24415830f, -0.01709299f, 0.05968456f, 0.00644730f, 0.14298025f, 
    0.03479813f, -0.04662857f, -0.02102858f, -0.12089688f, -0.14362463f, -0.07081258f, -0.01380649f, -0.24463542f, 
    -0.12417120f, -0.07603057f, 0.10769980f, 0.07706066f, 0.01282563f, 0.16768496f, 0.15790038f, 0.22205995f, 
    -0.14072759f, 0.04603874f, 0.32086325f, -0.27788153f, -0.09817716f, 0.12670210f, -0.05854971f, 0.18458496f, 
    -0.07078610f, 0.05958568f, -0.11097273f, -0.07176748f, 0.03036083f, 0.00122962f, -0.00742501f, -0.16523556f, 
    0.18188073f, 0.00905993f, -0.01136464f, 0.09181852f, -0.01622547f, -0.07655173f, 0.10867490f, -0.12517586f, 
    0.10331578f, -0.23277119f, 0.00807490f, 0.07225240f, 0.12043152f, 0.17446665f, 0.08763701f, -0.04554639f, 
    -0.03038507f, 0.02181662f, 0.12499198f, -0.27019879f, -0.01788452f, -0.18588084f, 0.10733943f, 0.08151360f, 
    -0.03251013f, 0.09985849f, -0.04938773f, 0.04191456f, -0.06958752f, -0.00224323f, -0.00861576f, -0.00030773f, 
    -0.15552263f, 0.20728900f, -0.46751258f, 0.17715433f, -0.07336034f, -0.01366229f, 0.03211607f, 0.03811306f, 
    0.06227141f, 0.07380273f, -0.16973670f, 0.05337039f, 0.04971248f, -0.31779379f, 0.21814770f, 0.11326841f, 
    0.05291095f, -0.08120506f, -0.09640485f, 0.06968226f, -0.07893142f, 0.03429488f, 0.05470739f, 0.00040217f, 
    -0.00762811f, -0.17849034f, -0.12270926f, 0.18800476f, -0.03353770f, -0.08000138f, -0.04428978f, -0.00456663f, 
    0.02095434f, -0.12681112f, -0.12363987f, -0.10939625f, 0.12773995f, -0.08255910f, 0.27694428f, -0.13738114f, 
    -0.02868586f, -0.04451041f, -0.05166940f, 0.10102364f, -0.06283649f, -0.05284008f, -0.15131098f, -0.06230316f, 
    -0.07702332f, 0.01364320f, -0.15477680f, -0.02953000f, -0.16886334f, 0.09389867f, -0.14167757f, 0.05146005f, 
    0.05405939f, -0.11521266f, -0.11092666f, -0.02092421f, 0.00217318f, 0.31071684f, 0.39159036f, 0.12886807f, 
    0.15040317f, 0.09557245f, -0.03486522f, 0.17687714f, -0.02827921f, 0.03062413f, 0.02372394f, -0.02865317f, 
    -0.04648123f, -0.00883184f, 0.03902107f, -0.01381760f, -0.25424951f, 0.14179230f, -0.10702424f, 0.02397167f, 
    0.04641997f, 0.01941041f, 0.08122170f, -0.17689835f, 0.08938984f, -0.14609747f, 0.09970047f, 0.14599325f, 
    -0.04672506f, 0.17368418f, -0.03852946f, -0.12487952f, 0.12071298f, -0.04637188f, 0.09089758f, 0.03881980f, 
    -0.22297771f, -0.00997694f, 0.07744804f, 0.08050903f, -0.01803366f, 0.02656310f, 0.15722533f, 0.13878779f, 
    0.04508095f, -0.10256530f, 0.09599535f, 0.08165025f, 0.14081757f, -0.05698929f, 0.25251257f, 0.32542515f, 
    0.00604987f, 0.14082804f, -0.00519344f, -0.06056303f, 0.10977495f, -0.02048079f, -0.14029187f, 0.11193743f, 
    -0.03534261f, 0.19627462f, -0.17054041f, 0.22787026f, 0.06683926f, 0.04267088f, -0.07277323f, 0.10880870f, 
    0.06297699f, 0.18492228f, -0.01108195f, -0.02173164f, 0.08722978f, -0.10996440f, 0.09165369f, -0.03303300f, 
    -0.03573414f, 0.00573606f, 0.06530143f, -0.06465998f, 0.09689485f, -0.11132775f, 0.00873209f, -0.09386631f, 
    0.25091809f, -0.29385448f, 0.18892060f, -0.28315929f, 0.08821958f, -0.00309341f, -0.04671224f, 0.16358040f, 
    -0.03553206f, 0.06691132f, 0.00227730f, -0.10627118f, 0.06948797f, -0.07006360f, 0.05861028f, -0.03791643f, 
    -0.03683511f, 0.16008320f, -0.07527140f, 0.12415820f, 0.22229287f, 0.09688798f, -0.12404449f, 0.06435513f, 
    -0.04761500f, -0.05447526f, 0.30724514f, 0.24635026f, 0.11345941f, 0.05981642f, 0.06923839f, 0.05011264f, 
    0.01831646f, -0.01559688f, -0.04432117f, 0.07059268f, -0.21418092f, -0.03884222f, 0.01473261f, -0.00410351f, 
    -0.10370293f, -0.13943282f, 0.05366919f, -0.09510137f, 0.04469566f, 0.05723663f, -0.10881752f, -0.03785627f, 
    -0.01926861f, -0.20523076f, 0.09564446f, 0.11307462f, 0.07657669f, 0.07149577f, -0.07683026f, -0.06091179f, 
    0.06220875f, 0.06796808f, -0.09152687f, 0.00539583f, 0.33529839f, 0.09271638f, -0.12626864f, -0.01349150f, 
    0.01316110f, -0.02606929f, -0.14515291f, -0.05655579f, 0.07953995f, 0.03781289f, 0.02513171f, -0.06507972f, 
    -0.10867840f, 0.20468172f, 0.25163957f, 0.03842531f, 0.16645044f, 0.02512456f, 0.15764458f, 0.03325379f, 
    0.12652300f, 0.12537034f, 0.05146121f, 0.06427843f, -0.25249887f, -0.00687892f, 0.19361779f, -0.12416713f, 
    -0.09495799f, 0.02962567f, -0.03825622f, 0.15473320f, 0.03463745f, 0.02183723f, -0.09231345f, -0.05945832f, 
    -0.20857146f, 0.37061992f, -0.08723517f, 0.18871363f, -0.02812271f, 0.07845365f, 0.07490987f, 0.09698734f, 
    -0.15063086f, -0.00829237f, 0.11866392f, -0.13179432f, 0.03700648f, -0.04434134f, 0.12662381f, -0.02423610f, 
    0.19451791f, 0.01758128f, 0.04380305f, 0.16243787f, -0.07628137f, -0.00157924f, 0.03594847f, 0.10833608f, 
    -0.30494097f, 0.00733331f, 0.07774566f, 0.07514523f, -0.11435471f, 0.03116973f, -0.01719018f, 0.03405554f, 
    0.10745164f, 0.00555228f, -0.12736835f, -0.08561277f, -0.04837035f, 0.08326896f, 0.02689317f, -0.08828350f, 
    -0.17656331f, -0.00554843f, -0.15498513f, 0.02359124f, 0.20378499f, 0.17612971f, -0.14097580f, 0.10184557f, 
    0.06408748f, -0.18663441f, -0.05587889f, -0.19801378f, -0.07275493f, -0.16528882f, -0.02674932f, 0.08931898f, 
    -0.04966091f, -0.02895619f, -0.17779271f, -0.06441815f, 0.03402902f, -0.20976651f, 0.42479762f, -0.31630334f, 
    0.07193976f, 0.21003635f, -0.05962328f, 0.21568923f, -0.02566322f, -0.02045678f, -0.02222484f, 0.10462247f, 
    0.06383578f, -0.05812762f, 0.14017490f, 0.18560570f, -0.07542458f, -0.04493321f, -0.20592275f, -0.04580601f, 
    0.19039688f, 0.02768226f, -0.06712041f, -0.06784350f, -0.02010915f, -0.02900149f, 0.09583862f, 0.06960492f, 
    0.03589274f, -0.22142337f, -0.02488184f, 0.15561457f, -0.13081053f, -0.02982230f, -0.06328484f, -0.12925145f, 
    -0.01971588f, -0.04294723f, -0.08862502f, -0.11240843f, -0.05113052f, -0.03189340f, -0.04336834f, 0.06075783f, 
    0.01877439f, 0.14616202f, -0.05033685f, 0.05537985f, 0.17037034f, 0.00208022f, 0.09672678f, -0.30841532f, 
    0.05564492f, 0.07838370f, 0.06594935f, -0.02751426f, 0.02780532f, -0.03030051f, -0.06329565f, -0.14966492f, 
    -0.13592379f, 0.38788390f, -0.15465251f, 0.31355220f, 0.12426779f, 0.02067538f, 0.11549318f, 0.02462335f, 
    -0.07868885f, 0.15408844f, -0.00639798f, -0.00871752f, -0.19122931f, 0.08435058f, -0.11256328f, -0.01781851f, 
    -0.08005500f, -0.21866934f, 0.16616234f, 0.17063971f, 0.03957214f, -0.12963676f, -0.21098414f, -0.05464505f, 
    -0.14195859f, 0.08464938f, 0.00282359f, 0.02290884f, -0.00738641f, 0.00796634f, 0.08153193f, 0.10590004f, 
    0.01629042f, -0.01725574f, -0.18914843f, -0.12543288f, -0.05921529f, -0.09546489f, -0.02587223f, -0.19376679f, 
    0.04420834f, -0.16928232f, 0.08598655f, 0.13730368f, 0.01582488f, 0.05665181f, 0.03474480f, -0.08214559f, 
    0.24475361f, -0.03211930f, -0.25178337f, 0.19138607f, 0.12012643f, 0.00996692f, 0.08073074f, 0.02902854f, 
    0.07041197f, -0.07242602f, -0.05150304f, -0.01677864f, 0.12749462f, 0.24732737f, 0.24918436f, 0.12020168f, 
    -0.00230702f, 0.15394001f, 0.11818725f, 0.16894782f, 0.00145943f, -0.03653814f, -0.00773384f, 0.05005002f, 
    -0.22536208f, 0.03233678f, 0.03560729f, -0.01469289f, -0.12108880f, 0.03351982f, -0.09117236f, -0.14835323f, 
    0.28535581f, -0.08662324f, 0.07379600f, 0.28259885f, -0.33809730f, -0.05621407f, -0.02110516f, -0.30005047f, 
    -0.01402314f, -0.00236791f, -0.03797206f, 0.07234798f, 0.06754559f, 0.09759949f, 0.24300380f, -0.01224865f, 
    0.03920293f, 0.17820999f, 0.11913305f, 0.15201861f, -0.01730837f, 0.25534719f, -0.16948625f, -0.11891308f, 
    0.00584240f, -0.08943193f, 0.01591712f, -0.00199237f, 0.20709817f, 0.05725573f, 0.07492182f, -0.05817708f, 
    -0.04529637f, 0.05475731f, -0.00408437f, 0.21418716f, 0.10112704f, 0.12393153f, 0.09507965f, -0.16138315f, 
    -0.35944727f, -0.09057850f, -0.21953741f, -0.01661650f, -0.00333231f, -0.15287599f, 0.05853037f, -0.06329153f, 
    0.04176981f, -0.20352706f, -0.00805164f, -0.08148599f, -0.05005608f, -0.05915463f, -0.03040011f, 0.19715758f, 
    0.01383968f, -0.09821031f, -0.13407420f, -0.16001526f, 0.13879514f, 0.09105521f, 0.01535756f, 0.00647470f, 
    -0.28229743f, -0.16033494f, 0.03120486f, 0.18419102f, -0.05208371f, -0.04239072f, -0.06784835f, -0.13626905f, 
    0.04511110f, -0.08849353f, -0.01125745f, 0.01631085f, 0.09194168f, -0.16051526f, -0.10914902f, -0.03098408f, 
    0.01198755f, 0.02235602f, 0.00163667f, -0.05061065f, -0.02739919f, 0.00066133f, 0.09062959f, 0.09057260f, 
    -0.10449509f, 0.06262564f, -0.00025354f, -0.15536560f, -0.01826487f, 0.15553473f, 0.00258677f, 0.17717600f, 
    0.07958893f, -0.01718081f, -0.01671509f, -0.01362665f, 0.08988968f, 0.23263441f, 0.03348581f, 0.12439006f, 
    -0.06578809f, -0.02033440f, 0.08397518f, 0.02904742f, 0.00289338f, -0.06254200f, -0.04239684f, 0.01238337f, 
    -0.06239435f, -0.33471131f, 0.33354092f, -0.42084172f, -0.04418364f, -0.14873660f, -0.05278846f, 0.03117239f, 
    0.04947603f, -0.04435094f, -0.04560675f, 0.13629374f, -0.17520399f, -0.28882548f, 0.13534984f, -0.22969384f, 
    -0.01186852f, -0.00164664f, -0.12545541f, 0.00251771f, 0.03189726f, 0.12756327f, -0.09834689f, 0.28538978f, 
    -0.20885728f, 0.18966764f, -0.39585328f, 0.18753336f, 0.25230315f, 0.14955862f, 0.12166026f, 0.02843167f, 
    -0.07075285f, -0.04320719f, 0.11905626f, -0.08794019f, -0.19766966f, 0.04038840f, 0.07355227f, -0.08139949f, 
    -0.01943989f, -0.00668624f, -0.02623314f, 0.15829708f, 0.13368143f, 0.01632158f, 0.07343313f, -0.03507204f, 
    0.00523344f, 0.01055098f, 0.01291294f, 0.03078324f, 0.01218234f, -0.01425578f, -0.02313748f, -0.00820485f, 
    0.02962337f, -0.00533600f, -0.00202212f, 0.02313664f, -0.02547289f, -0.02139951f, 0.00075322f, 0.02769539f, 
    0.00328367f, -0.03014747f, 0.00962242f, -0.01730051f, -0.02293253f, 0.02914450f, -0.03413497f, -0.02638376f, 
    0.01367984f, -0.00374342f, 0.00423231f, 0.02610251f, 0.02312527f, -0.00554319f, -0.02518934f, 0.01672355f, 
    -0.02032874f, -0.01607667f, -0.01235169f, -0.03478961f, -0.02566156f, 0.00633079f, -0.01266068f, -0.00369535f, 
    -0.01324258f, -0.00549452f, 0.01472165f, -0.01166490f, -0.04051098f, 0.02296891f, 0.00039805f, -0.02529034f, 
    -0.04091875f, 0.02986736f, -0.00624898f, -0.03821672f, -0.00722159f, -0.01578530f, -0.02202292f, 0.00759554f, 
    -0.03608344f, 0.01597902f, -0.03207037f, -0.04086737f, 0.01437210f, 0.00959391f, -0.02246737f, 0.01440136f, 
    0.00542907f, -0.00442007f, 0.02453738f, -0.00281115f, 0.02572329f, -0.04062360f, -0.03003616f, -0.03127111f, 
    0.02434436f, 0.02137201f, -0.00245140f, -0.04052683f, -0.03196577f, -0.00256686f, -0.01065327f, -0.01006670f, 
    -0.01186919f, 0.01152675f, 0.00032209f, 0.03027885f, 0.01989455f, 0.00508692f, 0.01387840f, 0.01609194f, 
    -0.03748321f, 0.00579208f, -0.00969838f, 0.02625992f, 0.02502163f, -0.03959360f, -0.02374428f, 0.01545885f, 
    -0.03708600f, -0.02558233f, 0.02429530f, -0.03595781f, 0.00699381f, -0.02822873f, 0.01245740f, -0.00266635f, 
    -0.00514774f, -0.00330977f, 0.02002192f, 0.02907786f, 0.02367647f, 0.01055656f, -0.00766137f, -0.03891239f, 
    -0.02236523f, 0.00339714f, -0.00134347f, -0.02886024f, -0.02650713f, -0.00395716f, 0.01926808f, 0.00736540f, 
    -0.01693158f, 0.00541202f, -0.02813402f, 0.01138310f, 0.02633540f, -0.02225416f, 0.02544183f, 0.02989764f, 
    0.02203290f, -0.03607138f, 0.02690235f, 0.00194662f, 0.00029010f, -0.02763208f, -0.02356956f, 0.02219852f, 
    0.02906616f, -0.01240813f, 0.00975835f, 0.02847554f, -0.00308335f, -0.03434512f, -0.02804375f, -0.03902081f, 
    0.00379138f, -0.01677827f, -0.01024326f, -0.04051408f, 0.01132209f, 0.00633694f, -0.01943565f, -0.00346677f, 
    -0.01773904f, 0.01366981f, -0.00494946f, 0.00955457f, 0.00134323f, 0.00520813f, -0.03489820f, 0.02635384f, 
    -0.00133659f, -0.01261400f, -0.04084940f, -0.03509053f, -0.00535603f, -0.03949175f, 0.02339689f, 0.00736709f, 
    0.00332102f, -0.02045251f, 0.02433364f, 0.01128367f, 0.01482063f, -0.01782623f, -0.01532494f, 0.01356804f, 
    -0.03261028f, -0.00223612f, -0.01533452f, -0.03751869f, 0.00834261f, 0.01361680f, -0.01410432f, 0.00123607f, 
    0.01596265f, -0.00378144f, -0.01345091f, -0.02053495f, -0.03712827f, -0.01461423f, 0.02263887f, -0.03503058f, 
    -0.00598612f, 0.02840805f, -0.00263603f, -0.01421557f, -0.01686234f, -0.01568938f, -0.01276022f, -0.01924144f, 
    0.01579516f, 0.02928548f, -0.02283411f, 0.01766039f, 0.02541506f, -0.00191801f, -0.01055868f, -0.02084110f, 
    -0.01966000f, 0.00156059f, -0.01487014f, -0.01909760f, -0.00590043f, -0.03749640f, -0.01551763f, -0.02295472f, 
    -0.03232630f, -0.03217728f, 0.00677264f, -0.02676642f, -0.04085513f, 0.00475788f, -0.02527408f, -0.00040439f, 
    0.02529244f, -0.03904074f, -0.02888043f, 0.00312916f, 0.01552308f, 0.02617850f, -0.00551430f, 0.02057882f, 
    -0.03714994f, -0.04081619f, 0.02448636f, 0.01748427f, 0.01132661f, -0.03273265f, -0.02481345f, -0.00305710f, 
    -0.00481206f, 0.03257231f, -0.00155045f, -0.01852520f, -0.00612877f, 0.00879012f, -0.03577060f, -0.02343148f, 
    -0.01212139f, 0.01274348f, 0.01715011f, -0.01043519f, -0.03270315f, -0.03679910f, -0.03279638f, -0.00856884f, 
    -0.00105779f, -0.02881054f, -0.03530262f, 0.01581847f, -0.00708977f, 0.00124368f, -0.02583451f, 0.02108249f, 
    -0.03399928f, -0.02434951f, -0.04033278f, 0.00574598f, -0.00904396f, -0.02604866f, -0.02421102f, -0.02145112f, 
    0.02450819f, 0.02225572f, 0.00751595f, -0.01085243f, -0.03219238f, -0.03297123f, 0.01230097f, -0.02808105f, 
    -0.02917502f, -0.03166281f, -0.02395101f, 0.02200770f, -0.03894894f, 0.01195442f, -0.02303560f, -0.03739420f, 
    0.00412205f, -0.02705849f, -0.00321015f, 0.02471998f, -0.02395114f, 0.00269787f, -0.03086171f, 0.01158781f, 
    0.01137105f, 0.01222043f, -0.00337156f, 0.02229641f, -0.03248487f, -0.00677637f, 0.02314252f, -0.03263211f, 
    0.00298845f, -0.01201259f, 0.01488743f, 0.00333630f, -0.02667516f, -0.00888789f, 0.00353426f, -0.02237736f, 
    0.01800994f, -0.02992344f, -0.01230808f, 0.00887112f, -0.00276038f, -0.00195416f, 0.00614945f, 0.01315388f, 
    -0.03146207f, 0.00351759f, -0.00481601f, -0.02609153f, -0.02623067f, -0.01048635f, 0.02812692f, 0.00616117f, 
    -0.03529569f, -0.00503716f, -0.02254258f, 0.02902773f, 0.00805579f, -0.02991342f, -0.02256537f, -0.01599448f, 
    0.00659895f, -0.02500623f, 0.02568579f, 0.03087774f, 0.01296284f, 0.01890516f, -0.02791752f, 0.02789397f, 
    0.00424754f, -0.00589716f, -0.03436551f, -0.03678031f, -0.01160127f, 0.02862172f, 0.02702021f, 0.00423978f, 
    0.00442987f, -0.01589643f, -0.01657208f, 0.01683029f, -0.00569184f, 0.00445547f, 0.02526333f, -0.03490900f, 
    -0.03474207f, 0.00054327f, -0.03016447f, -0.00845163f, 0.01633857f, 0.01375823f, 0.03086942f, -0.00241115f, 
    0.01759663f, -0.03901729f, 0.01785946f, -0.02002868f, -0.01662828f, -0.02650668f, -0.02795881f, -0.01471642f, 
    -0.03064164f, -0.02594855f, 0.00875741f, -0.00693235f, -0.03618532f, -0.02853246f, 0.02351284f, -0.03173070f, 
    -0.02218499f, -0.01429711f, 0.01788383f, -0.03748436f, 0.01975098f, -0.01031362f, -0.02834089f, 0.01818880f, 
    0.01699380f, -0.02989578f, -0.00273358f, -0.01248434f, 0.01901365f, -0.01961983f, -0.02311732f, -0.01791049f, 
    -0.02611762f, 0.01906866f, 0.00801947f, -0.03036536f, 0.01069808f, 0.01794531f, -0.03523871f, -0.00980333f, 
    -0.03115840f, 0.02400684f, -0.03658450f, -0.03042139f, -0.00787550f, -0.00852360f, -0.04045564f, -0.00236766f, 
    -0.00395219f, 0.00300281f, -0.03004594f, 0.01863994f, 0.00117243f, -0.03442869f, -0.02661784f, -0.03969173f, 
    -0.01946490f, 0.01371805f, 0.02793990f, -0.03700012f, 0.01513447f, -0.03245248f, 0.01031053f, -0.02165790f, 
    -0.03308252f, -0.01755629f, -0.02989211f, -0.01533984f, -0.00946007f, 0.00966807f, 0.01625417f, -0.01899384f, 
    -0.03672076f, -0.02388062f, -0.01252662f, -0.00494370f, -0.00610680f, -0.03531087f, -0.04024123f, -0.01999455f, 
    -0.00605334f, 0.01296169f, -0.00370241f, 0.02172623f, -0.01949883f, 0.02316819f, 0.01493334f, -0.00009286f, 
    0.02296074f, -0.00161606f, -0.01045804f, 0.01783768f, -0.03005426f, -0.03325590f, 0.01336574f, -0.03587484f, 
    0.01143768f, 0.00358109f, -0.03805605f, -0.02038249f, 0.03464991f, 0.00110777f, 0.00275201f, -0.00278385f, 
    0.00023828f, 0.01708559f, 0.02169894f, 0.02685639f, -0.00794982f, 0.00757302f, 0.03380393f, -0.00979598f, 
    -0.03759448f, 0.02525941f, -0.02077456f, -0.00758532f, -0.03410303f, -0.00919981f, 0.00929900f, 0.01932443f, 
    0.02944484f, -0.03996637f, 0.02373865f, -0.02242400f, -0.01551564f, 0.03063297f, -0.01264209f, 0.02255201f, 
    -0.02946049f, -0.02899781f, 0.01200612f, -0.02819429f, -0.01651291f, 0.01934830f, -0.02388113f, 0.02932585f, 
    0.02540107f, 0.00234699f, -0.00898293f, 0.02824747f, -0.01045938f, -0.01265755f, 0.01631996f, -0.03265116f, 
    -0.03755712f, 0.00846795f, -0.02469057f, 0.01575550f, -0.01482678f, -0.00963370f, -0.02240529f, -0.02011750f, 
    0.01960984f, 0.02247219f, -0.02894095f, -0.00978912f, 0.01239480f, 0.02305350f, 0.02451919f, -0.00690274f, 
    0.00564275f, 0.02716258f, -0.03370492f, 0.02489288f, 0.02442924f, -0.02269991f, 0.00958829f, 0.02250425f, 
    0.02253682f, -0.00447731f, -0.00053450f, -0.01221134f, 0.00401457f, -0.01912927f, 0.02729260f, -0.02247991f, 
    -0.03961736f, -0.03835571f, 0.02915890f, 0.01202506f, 0.00192650f, -0.01100150f, -0.00271826f, 0.02053505f, 
    0.02569003f, -0.00829654f, -0.02267824f, 0.01458772f, -0.00799779f, -0.03197380f, 0.01626425f, 0.02217810f, 
    -0.00967985f, -0.03396729f, 0.00294522f, -0.04074945f, -0.02713613f, 0.01096084f, -0.00588382f, -0.03328106f, 
    -0.01151522f, -0.00026951f, -0.02716197f, -0.03484042f, -0.00756566f, -0.01808546f, -0.01318611f, 0.00682017f, 
    -0.00838290f, 0.02776260f, -0.02296432f, -0.01298813f, 0.02352498f, -0.00864000f, 0.01268031f, -0.01194024f, 
    -0.01712887f, 0.01745967f, 0.00312757f, -0.03991377f, -0.02916820f, -0.03857367f, 0.01508778f, -0.03368688f, 
    0.00299764f, -0.01197314f, -0.02320419f, 0.00490692f, -0.02963156f, -0.02215438f, 0.03505904f, -0.03209718f, 
    -0.03405973f, 0.01353298f, -0.01384493f, -0.03183688f, 0.02868983f, 0.00251357f, -0.02761485f, -0.01976653f, 
    0.01781978f, -0.01804722f, -0.01299860f, 0.02695840f, -0.03543484f, 0.00703946f, 0.02408255f, 0.01749375f, 
    -0.01877772f, 0.01491880f, -0.02403763f, 0.02651265f, -0.00623269f, 0.00111845f, 0.00233630f, -0.04083766f, 
    0.02210199f, -0.00422622f, -0.01405692f, -0.03077994f, 0.01110648f, -0.02720705f, -0.03298236f, -0.01499880f, 
    -0.04111858f, 0.02333689f, -0.00025203f, 0.01505487f, -0.03159307f, -0.00293130f, -0.00911099f, -0.02823739f, 
    -0.02049980f, 0.01504082f, -0.00797202f, -0.03116922f, -0.02825466f, -0.00884387f, 0.00589809f, -0.02025562f, 
    -0.00118459f, -0.00945364f, 0.01060651f, 0.01129819f, -0.02129264f, 0.02699385f, -0.03864422f, -0.00768791f, 
    -0.01062090f, -0.00870749f, -0.02862673f, 0.01924986f, -0.03767321f, -0.00304871f, -0.00256847f, 0.01544853f, 
    -0.00163741f, -0.03215278f, 0.02149298f, 0.01350252f, -0.03242176f, -0.02806453f, 0.02597974f, -0.01732511f, 
    -0.01111167f, -0.02399480f, 0.03074298f, -0.00743179f, 0.00400214f, -0.00227752f, -0.02192502f, -0.00816401f, 
    -0.03237886f, 0.02724958f, 0.00456457f, -0.01308010f, -0.01582463f, -0.03023873f, -0.01881093f, -0.01195490f, 
    -0.02863981f, 0.00479648f, -0.01755661f, 0.02178651f, -0.00277134f, 0.00220410f, 0.00102584f, -0.03190513f, 
    0.02891178f, -0.03190149f, -0.03047524f, -0.03753721f, -0.02894708f, -0.03739812f, 0.01563660f, 0.00945847f, 
    -0.02588496f, 0.01121483f, -0.01656400f, 0.01865803f, -0.03835175f, 0.00841297f, 0.01640273f, -0.02317603f, 
    0.01890360f, -0.02043979f, -0.02145308f, 0.01661755f, 0.01005873f, -0.00690047f, -0.02605097f, 0.00269418f, 
    0.01205354f, -0.03615297f, 0.01984187f, -0.03378814f, -0.00063733f, -0.00179113f, 0.00329680f, -0.01634247f, 
    -0.00959736f, 0.02466651f, 0.01926028f, 0.01995539f, -0.01615820f, -0.02373602f, 0.01349430f, -0.02598480f, 
    -0.02363321f, 0.00221604f, -0.01050258f, -0.03149234f, -0.02789747f, 0.02208999f, -0.03551938f, -0.02028975f, 
    0.00389492f, -0.00293593f, 0.00593096f, -0.01584774f, 0.02121539f, -0.02761290f, -0.03313677f, 0.02521320f, 
    -0.01358386f, -0.02383506f, -0.02217341f, -0.01429188f, 0.01767593f, 0.00388689f, -0.03841985f, 0.00669979f, 
    0.00152720f, 0.00931546f, -0.01595618f, 0.01034306f, -0.03235374f, 0.00737691f, -0.00080215f, -0.00299431f, 
    -0.21200116f, 0.10640927f, 0.03535030f, 0.05272587f, -0.01507361f, 0.06932624f, 0.12317896f, 0.06399600f, 
    0.10139095f, 0.03385145f, 0.03584681f, 0.08765877f, 0.35824162f, -0.11884210f, 0.07071649f, 0.19146532f, 
    0.14581500f, 0.16656978f, -0.05050877f, -0.05918020f, 0.26931536f, 0.03607096f, -0.02350959f, 0.06214652f, 
    0.03422076f, -0.03850219f, -0.07778517f, -0.15003276f, 0.00810691f, 0.15944055f, 0.07867650f, 0.11794417f, 
    -0.13491368f, -0.10810446f, -0.03064300f, 0.01375294f, -0.30956280f, -0.38643673f, -0.11683796f, -0.04765756f, 
    0.04223447f, 0.03278980f, -0.03038031f, 0.10978451f, -0.14754206f, -0.02163358f, -0.02004566f, -0.00490284f, 
    -0.08784050f, -0.08408764f, 0.13027948f, 0.12383386f, -0.00816107f, 0.10814914f, 0.02519808f, 0.02716440f, 
    -0.01142593f, 0.01581952f, 0.03202120f, 0.02685460f, 0.03152834f, -0.03225718f, 0.17711797f, 0.14451987f, 
    0.13720234f, 0.04978771f, 0.12888654f, -0.04439450f, -0.02040134f, 0.07955022f, 0.03608768f, 0.09798691f, 
    0.34433007f, 0.18201680f, 0.09785533f, 0.11800402f, -0.01649083f, 0.00976711f, 0.07903723f, -0.05408120f, 
    0.01029480f, 0.01386245f, 0.01787579f, 0.12905759f, -0.10986119f, -0.01971200f, 0.06749438f, -0.05477130f, 
    0.13857362f, 0.02348525f, -0.13515191f, 0.02495288f, -0.01121399f, 0.05409232f, 0.06723425f, 0.01878572f, 
    0.37486550f, 0.23442979f, 0.00747580f, 0.08412555f, 0.01879545f, 0.05718333f, 0.02596818f, -0.08559880f, 
    0.04866558f, -0.00144827f, -0.05537907f, 0.01496029f, 0.01947404f, 0.09325443f, -0.03107526f, 0.12849192f, 
    0.01667890f, 0.03486041f, -0.01582228f, 0.02045796f, 0.23128317f, -0.04065097f, 0.13163012f, 0.07083528f, 
    -0.00791834f, 0.32618025f, -0.17474064f, -0.02117873f, -0.08466263f, -0.01498962f, 0.05406855f, -0.00494418f, 
    -0.00514339f, 0.04376613f, -0.11572926f, 0.16172099f, 0.11427627f, -0.08162320f, 0.01961297f, 0.02799353f, 
    0.04349049f, 0.12791750f, 0.02418416f, -0.03809267f, 0.00368832f, 0.01257657f, -0.02730867f, 0.01314360f, 
    0.17818159f, 0.01419467f, -0.01718982f, 0.14820133f, 0.09963087f, -0.05664331f, 0.18655992f, -0.15223363f, 
    -0.01897601f, 0.03349171f, 0.00571473f, 0.03521202f, 0.01052962f, 0.04208672f, -0.13451377f, 0.09905331f, 
    -0.03109596f, -0.09874585f, 0.04179481f, -0.03088561f, -0.06430530f, -0.03055123f, -0.03410603f, 0.01817190f, 
    0.08828028f, 0.09373424f, 0.07299338f, 0.09812869f, 0.17782415f, 0.02683484f, -0.04566072f, -0.01549198f, 
    -0.03674972f, -0.02830065f, 0.03294655f, -0.08894709f, 0.15305506f, 0.03510920f, 0.06587333f, 0.03961013f, 
    0.02163795f, -0.02085829f, -0.08018367f, -0.06665831f, -0.01745946f, -0.05688675f, -0.05191884f, 0.14954592f, 
    0.37096632f, 0.23968725f, -0.00856073f, 0.08543510f, -0.03226606f, 0.04478773f, -0.01997445f, -0.06273041f, 
    -0.07277805f, 0.00716342f, 0.12273092f, -0.23929967f, -0.08917419f, -0.21125619f, -0.05712483f, -0.24979348f, 
    -0.04368423f, -0.02195641f, -0.07382251f, 0.09849052f, -0.07450959f, -0.13483651f, -0.14977665f, -0.42528605f, 
    -0.05367352f, 0.19272238f, 0.04758885f, -0.13979481f, -0.10765558f, -0.11367840f, 0.01219461f, 0.09456106f, 
    0.05231186f, -0.14811815f, 0.03023839f, -0.07379559f, 0.05639924f, -0.17612632f, 0.29721746f, 0.17929322f, 
    -0.08767258f, 0.13195893f, 0.06698263f, -0.22232980f, 0.04534960f, -0.09750166f, -0.05562290f, 0.13799825f, 
    -0.07723325f, -0.13533062f, -0.13625425f, 0.03460969f, -0.04432121f, -0.11286286f, 0.00238771f, 0.03331082f, 
    -0.00628529f, 0.12849341f, 0.23931861f, -0.04443325f, 0.17081827f, 0.01366024f, -0.05555486f, 0.13462712f, 
    -0.02556244f, -0.11277362f, -0.03694038f, 0.03356322f, 0.06465694f, 0.09914038f, 0.01987153f, 0.21861230f, 
    -0.27168083f, -0.03044094f, 0.18959700f, 0.01987472f, 0.25119326f, -0.21354282f, 0.02395144f, -0.04577558f, 
    -0.02496856f, 0.02774649f, 0.04183710f, -0.00824089f, -0.05077744f, -0.25828043f, -0.08617053f, 0.07705107f, 
    0.02456414f, -0.16505542f, 0.05413825f, 0.16884206f, 0.04728963f, 0.18170087f, -0.07525190f, 0.25354493f, 
    0.10916130f, -0.04291920f, 0.07650158f, -0.08944038f, -0.09040634f, 0.07764725f, 0.15721692f, 0.00022589f, 
    0.05581231f, 0.04998308f, 0.16716772f, 0.17227149f, 0.22935823f, -0.04251892f, -0.06984762f, -0.01519163f, 
    -0.00495699f, 0.02926673f, -0.00523106f, 0.05383667f, 0.04500391f, -0.26174694f, -0.12700963f, -0.08424898f, 
    0.01612106f, -0.02574403f, 0.08269809f, 0.12497765f, 0.03368634f, 0.14151876f, -0.03210009f, 0.00695404f, 
    0.06615885f, 0.00210374f, -0.08247974f, -0.07217695f, -0.12356310f, 0.08184461f, 0.11566882f, 0.07134220f, 
    0.25900614f, -0.14863041f, 0.09389593f, 0.04256449f, 0.09631866f, 0.01660435f, 0.00582489f, 0.14986424f, 
    0.32841337f, -0.00072254f, 0.13054271f, 0.29565984f, 0.03980661f, -0.14825514f, 0.09293189f, 0.26416293f, 
    -0.01490087f, 0.17017266f, 0.13455139f, 0.06982511f, -0.02305462f, -0.07128268f, 0.02129597f, -0.07151058f, 
    0.05987502f, -0.02050916f, -0.04570169f, 0.08477059f, -0.00400785f, -0.08983884f, -0.03854798f, 0.05616992f, 
    -0.05522588f, 0.02724003f, -0.05756395f, -0.06619566f, -0.00591306f, -0.04295728f, 0.02008140f, 0.08345222f, 
    -0.03194585f, 0.08250895f, -0.03990974f, -0.09234979f, -0.31792951f, -0.30191064f, 0.02522992f, -0.23424098f, 
    -0.05210216f, -0.02635238f, -0.02317297f, 0.03136592f, 0.12321399f, 0.14341341f, 0.12298407f, -0.21275941f, 
    -0.01446993f, -0.00217772f, 0.19403894f, 0.09230456f, 0.00432830f, -0.07670540f, 0.03748457f, -0.16318828f, 
    0.09169974f, 0.05024081f, -0.02444163f, 0.17732751f, -0.07454992f, -0.00948344f, 0.01822652f, 0.15226868f, 
    0.01853974f, -0.07439154f, 0.16245227f, 0.02186553f, -0.06533823f, 0.03778455f, -0.01132340f, -0.02323470f, 
    0.01431540f, 0.16917801f, -0.12799075f, 0.01063266f, 0.04828927f, 0.09249581f, -0.06808108f, 0.10791116f, 
    0.00442329f, -0.21931717f, 0.02714988f, 0.08963035f, -0.02179098f, -0.05182528f, -0.06173436f, -0.02600331f, 
    0.02674471f, 0.15630397f, 0.09142695f, 0.03176140f, 0.07104383f, 0.06531806f, 0.01840329f, 0.16372123f, 
    -0.25491461f, 0.08942054f, 0.07574631f, -0.40376201f, -0.13608904f, -0.11918937f, -0.00879767f, 0.02697475f, 
    0.07978994f, -0.00302396f, -0.14843339f, -0.11667603f, -0.09332158f, -0.06899129f, 0.01848402f, -0.07064749f, 
    -0.02180468f, -0.02573398f, -0.02285904f, -0.02976833f, 0.02989494f, -0.02817663f, -0.02621527f, 0.16434580f, 
    -0.24923727f, -0.07152620f, -0.16247328f, -0.17464936f, -0.10490438f, -0.02040964f, 0.00147983f, -0.05512780f, 
    -0.15257542f, -0.05627108f, -0.08421689f, -0.17662217f, 0.11654261f, 0.17149685f, 0.17850928f, 0.02566572f, 
    -0.11941532f, -0.05730737f, -0.15540121f, -0.07627541f, 0.08775946f, 0.04426378f, -0.01236824f, 0.10579222f, 
    -0.19362508f, -0.20123467f, 0.15839334f, -0.22845846f, -0.00473795f, -0.07727337f, 0.03449938f, 0.11523917f, 
    0.11484824f, 0.02518852f, -0.02700308f, 0.08259448f, 0.39007318f, 0.00639009f, -0.16311078f, 0.08465752f, 
    -0.02259525f, 0.14957832f, 0.02324869f, 0.06958022f, -0.02101611f, -0.04079143f, -0.06129934f, -0.22992773f, 
    -0.06853769f, -0.00583638f, -0.11238570f, 0.02797971f, -0.09923747f, -0.00929466f, 0.06120168f, 0.03174411f, 
    0.03032371f, -0.02331696f, -0.05812231f, -0.12046830f, -0.00798705f, 0.13815509f, 0.06149449f, 0.02374551f, 
    0.08765860f, 0.06540879f, 0.04290721f, 0.00661015f, -0.04058782f, -0.08451758f, -0.03396231f, 0.04007671f, 
    0.03205589f, -0.05692719f, -0.03845872f, 0.13793612f, 0.13056576f, 0.10424357f, -0.00598615f, -0.09722816f, 
    0.02085129f, -0.02571787f, 0.02036900f, 0.05999178f, -0.22297473f, 0.14850351f, -0.13840684f, -0.14590101f, 
    -0.00442157f, 0.10040127f, 0.03944007f, -0.02878221f, 0.06976767f, 0.01089254f, -0.11637078f, -0.20211759f, 
    -0.12938018f, -0.09709433f, -0.01935978f, 0.03132150f, 0.05845142f, 0.10530009f, -0.08132707f, 0.02846815f, 
    0.01933149f, -0.08055740f, -0.10158741f, -0.22777623f, -0.23887645f, -0.16723518f, -0.14312148f, -0.02810529f, 
    -0.00515853f, 0.18619618f, 0.10628457f, 0.12954664f, -0.08115300f, -0.09694535f, -0.12310335f, -0.08360104f, 
    0.17242430f, 0.15878157f, 0.17632890f, -0.08102652f, 0.14254944f, -0.01247821f, -0.11963015f, -0.01890031f, 
    0.07779496f, -0.01673662f, -0.02168825f, 0.05286831f, 0.01498804f, -0.12369091f, 0.20319681f, 0.17077713f, 
    0.22692393f, 0.15331471f, 0.03313255f, -0.03689129f, -0.02989042f, 0.04283644f, 0.03018213f, 0.05836597f, 
    -0.00863126f, 0.10049994f, 0.18186700f, 0.14997089f, 0.01730356f, -0.01832116f, -0.00674122f, 0.03275286f, 
    0.06566896f, 0.06540037f, 0.08500019f, 0.35963792f, 0.19319375f, 0.07734119f, -0.09296960f, 0.21080692f, 
    0.06749689f, 0.03625126f, -0.06859144f, 0.01036510f, 0.21018991f, 0.14880674f, 0.12192054f, 0.04886352f, 
    -0.05359303f, -0.11742185f, 0.09215553f, -0.06836625f, -0.00443168f, -0.19246723f, 0.08079428f, -0.00014120f, 
    0.12657039f, 0.04410472f, 0.14737339f, 0.07242610f, -0.00215308f, 0.18106684f, -0.03749679f, 0.10375950f, 
    0.04614301f, 0.07507119f, 0.24270238f, -0.08050518f, 0.20473291f, 0.14423044f, -0.03742851f, 0.12734495f, 
    -0.08490238f, -0.08418204f, -0.09321684f, 0.03402898f, -0.01678293f, -0.02784783f, -0.08898766f, 0.06488822f, 
    -0.23782390f, -0.24916749f, -0.08766043f, -0.30810505f, -0.05120303f, -0.09388697f, -0.04893131f, 0.14874329f, 
    -0.12475075f, -0.05897903f, -0.00490360f, -0.03066456f, 0.12732470f, 0.08533530f, 0.06811010f, 0.17463583f, 
    0.19705513f, 0.15159057f, 0.17852147f, -0.01211439f, 0.00999447f, -0.07909255f, -0.06110160f, 0.01686132f, 
    -0.08209197f, 0.02907920f, 0.03290686f, 0.09627268f, -0.09381001f, -0.00729535f, 0.13226350f, 0.07940292f, 
    0.14690141f, 0.07337938f, -0.18450612f, -0.01370751f, 0.02964794f, 0.02822721f, -0.05796264f, 0.01398060f, 
    -0.11421658f, -0.00288948f, 0.24363515f, 0.05027298f, 0.10054328f, 0.00490871f, 0.02358642f, 0.03507407f, 
    0.01765489f, 0.11050146f, -0.01386864f, -0.06332087f, -0.06124448f, -0.04526241f, 0.07821758f, 0.00762770f, 
    0.05786867f, 0.06664763f, -0.06350143f, -0.10342020f, -0.02512662f, -0.11304445f, -0.12615618f, 0.01833718f, 
    0.22608913f, 0.18398431f, -0.19780254f, -0.08214129f, -0.02196671f, 0.08707611f, 0.04205320f, 0.05754356f, 
    0.35257888f, -0.18467321f, -0.11890511f, 0.16672537f, 0.02655774f, 0.04702632f, 0.12933920f, 0.05760932f, 
    0.05185634f, -0.07075392f, 0.01833597f, -0.02594267f, -0.02258111f, -0.01053600f, 0.07509708f, 0.21727395f, 
    -0.03176248f, -0.10241774f, 0.03239187f, 0.02101460f, 0.11176091f, 0.09351423f, -0.10066670f, 0.06212591f, 
    -0.03267159f, -0.01755000f, 0.12920502f, -0.01208960f, -0.12897541f, 0.02141176f, 0.16287349f, 0.07643443f, 
    -0.08807109f, -0.17009659f, -0.01471640f, -0.02454224f, -0.00843229f, 0.03347893f, -0.03420900f, 0.05138528f, 
    0.00927013f, 0.06793688f, -0.02389153f, 0.10933090f, -0.03166762f, -0.05761841f, -0.03758553f, 0.03906222f, 
    -0.01088060f, 0.06088277f, 0.00605476f, 0.10338919f, -0.21058904f, -0.01795052f, 0.10134215f, 0.14031833f, 
    0.02396114f, -0.05863925f, 0.12700233f, 0.06040033f, 0.01411504f, 0.09138892f, -0.15066199f, 0.01418406f, 
    -0.18085243f, 0.06204007f, 0.24781987f, 0.05139410f, 0.00352502f, -0.02396312f, 0.01608629f, -0.15802538f, 
    0.09739272f, 0.03130041f, -0.01251314f, -0.05986968f, 0.30543458f, -0.05088056f, -0.06048477f, 0.19125383f, 
    -0.02525481f, -0.00642418f, 0.14451087f, -0.15673397f, 0.18231973f, 0.03651446f, -0.00476870f, 0.07793681f, 
    -0.08046576f, -0.33148080f, 0.03011447f, 0.41984513f, -0.14959541f, 0.07847058f, -0.00904472f, 0.08296657f, 
    0.03440573f, 0.00730543f, 0.03501382f, -0.01721236f, -0.10753453f, -0.02843029f, 0.00531496f, 0.18238379f, 
    -0.05106221f, 0.04503100f, 0.01452947f, 0.01824738f, 0.06222718f, 0.04879317f, -0.02588937f, -0.04394336f, 
    0.08769149f, -0.03134061f, 0.04697512f, 0.13493006f, 0.05190529f, -0.04406787f, -0.04879135f, 0.05001963f, 
    0.01104006f, 0.01065259f, 0.00475694f, -0.12550209f, -0.01175736f, 0.16537870f, -0.00966413f, -0.09072833f, 
    0.17986229f, 0.03406693f, -0.04261088f, 0.07653327f, 0.07237052f, -0.02848691f, -0.03335594f, -0.05592040f, 
    0.18421552f, -0.08892802f, 0.04677574f, 0.17217654f, -0.02431185f, 0.02579364f, 0.10655480f, 0.10279246f, 
    0.05998698f, -0.05264483f, -0.01313588f, -0.07703958f, -0.01409271f, -0.01968157f, -0.01825636f, 0.03337387f, 
    0.05791917f, -0.02283481f, -0.00496732f, -0.00534346f, 0.04766849f, 0.07371891f, 0.06299806f, 0.14021291f, 
    -0.33852735f, 0.01512824f, 0.05058599f, 0.20755032f, -0.03687870f, -0.01733699f, -0.17020781f, 0.03636557f, 
    -0.08040505f, -0.06676010f, 0.05335236f, 0.01269386f, 0.10550900f, 0.03973953f, 0.11996662f, 0.12482244f, 
    0.21361864f, 0.12557216f, 0.10724974f, 0.16504507f, 0.15173474f, 0.00602000f, -0.05996536f, 0.01297043f, 
    0.14029069f, -0.19356222f, -0.09570246f, 0.30470669f, 0.03155695f, 0.00411565f, -0.07062391f, 0.11162756f, 
    -0.00184818f, -0.04851917f, -0.00478286f, -0.06838588f, -0.32051414f, -0.06494462f, 0.26999041f, 0.09750727f, 
    0.03169541f, -0.08846325f, -0.02687615f, 0.09975488f, -0.02286636f, -0.01962573f, 0.10950749f, 0.06955868f, 
    -0.09487060f, 0.39806280f, -0.08185390f, -0.03915645f, -0.06653927f, 0.13546656f, -0.06307869f, 0.07152694f, 
    0.06243990f, 0.03170231f, -0.08021176f, 0.00359644f, -0.35345867f, 0.07157547f, 0.00421121f, -0.08838873f, 
    0.07216523f, -0.06196712f, -0.03110902f, 0.03969329f, -0.26019636f, 0.13572477f, -0.00876249f, -0.12451079f, 
    -0.04613057f, 0.13752738f, -0.38829166f, -0.29848319f, 0.04027460f, -0.00421750f, 0.01778289f, 0.01734052f, 
    0.00834923f, -0.03697713f, 0.01694616f, -0.07647121f, -0.16025339f, 0.02148514f, 0.01273574f, 0.03975807f, 
    -0.03657974f, -0.03897092f, -0.00435392f, 0.11031218f, 0.14575377f, 0.07743421f, -0.09722418f, 0.16198868f, 
    -0.27158079f, 0.38614428f, -0.12872016f, -0.07533856f, -0.04368161f, 0.05974666f, -0.07351240f, -0.01690722f, 
    -0.12312777f, -0.07423866f, 0.03345006f, 0.06889451f, -0.02357895f, -0.16108428f, 0.28361043f, 0.24734904f, 
    0.03053838f, 0.07527515f, -0.17960483f, 0.04742486f, 0.01127275f, 0.04697940f, 0.03682257f, -0.10783703f, 
    0.10567855f, -0.25122568f, -0.07085721f, 0.05137881f, -0.02861316f, 0.10985418f, 0.01783764f, -0.04749988f, 
    0.09548279f, 0.17511301f, 0.01431726f, -0.05973949f, 0.06960656f, -0.04925668f, -0.00931824f, -0.01421264f, 
    0.12841643f, -0.00721767f, -0.04901868f, -0.00526376f, 0.00839575f, -0.12692484f, 0.03696813f, -0.18039961f, 
    -0.30671638f, -0.31408128f, 0.12981854f, 0.13531028f, 0.05804421f, -0.15342060f, 0.07607130f, -0.17489545f, 
    0.08568709f, -0.01554744f, -0.00568704f, -0.02210072f, 0.11187430f, -0.32488886f, -0.07644537f, 0.28254509f, 
    -0.00784942f, -0.05135412f, -0.17025630f, 0.07995526f, -0.09481049f, 0.01440126f, -0.04874239f, 0.12745039f, 
    0.21638116f, -0.03576032f, -0.10026925f, 0.16419937f, 0.07342543f, 0.00997180f, 0.09270261f, -0.03148870f, 
    0.01122139f, 0.00659964f, 0.03976527f, -0.05349872f, 0.06076441f, -0.03843552f, -0.07126860f, 0.05651885f, 
    -0.00012138f, -0.06024952f, 0.01325262f, -0.04282678f, 0.27428937f, 0.14848024f, 0.06397881f, 0.17739286f, 
    0.06718614f, -0.03172777f, 0.09187064f, 0.15246817f, 0.16060226f, 0.18744294f, -0.07493370f, 0.06021851f, 
    0.05549943f, 0.00602415f, 0.00016158f, 0.03380890f, -0.27056170f, -0.10132015f, 0.12094454f, 0.16587278f, 
    0.00516634f, 0.07229844f, 0.09036697f, 0.04645649f, 0.01459905f, 0.04038621f, -0.03284708f, -0.06637969f, 
    0.06035688f, -0.29552245f, -0.11634307f, 0.64539403f, 0.05360504f, -0.10643905f, -0.06031852f, 0.01036298f, 
    -0.02499693f, 0.05448543f, -0.11223566f, 0.13101724f, 0.06364384f, -0.04531202f, -0.10036091f, -0.02222155f, 
    0.03374934f, -0.01657275f, 0.05231928f, -0.01496351f, 0.17501657f, -0.07178120f, -0.05493648f, 0.02573051f, 
    -0.16132265f, -0.01224571f, 0.12944880f, 0.02721035f, 0.16951396f, -0.06297950f, -0.10562775f, -0.02401175f, 
    0.20216295f, 0.05232165f, -0.00720985f, -0.02571000f, 0.15473403f, 0.15125138f, 0.26810443f, 0.19435196f, 
    0.04868652f, -0.07893918f, -0.09963712f, -0.02239449f, 0.11614510f, -0.04353548f, -0.00952468f, 0.10732548f, 
    -0.13968796f, -0.14366333f, 0.06841069f, 0.06635564f, -0.05442027f, -0.03229479f, -0.05839863f, 0.02495763f, 
    -0.02779068f, 0.04493168f, 0.01254418f, 0.03192006f, -0.09870070f, -0.20391333f, 0.01275922f, -0.01990781f, 
    -0.00637342f, -0.11571439f, 0.03789388f, 0.07783946f, -0.00429623f, -0.04842079f, 0.07155120f, 0.06649465f, 
    -0.13874456f, 0.46076331f, 0.18974507f, 0.14428368f, 0.03855321f, 0.02720285f, 0.16521756f, -0.05669445f, 
    0.07505554f, 0.08568846f, 0.01282247f, -0.14765915f, -0.09501483f, -0.10774177f, 0.12711577f, 0.01332615f, 
    0.08587182f, 0.02511130f, 0.05714713f, 0.13825420f, -0.05020641f, -0.00874156f, -0.02913542f, -0.04986491f, 
    -0.31766170f, 0.14666839f, 0.20876464f, 0.02028881f, 0.10996971f, 0.02256179f, -0.13057940f, 0.06098478f, 
    -0.08646198f, -0.05273939f, 0.07270774f, 0.06487544f, -0.03459093f, 0.04301635f, -0.03845860f, -0.11736158f, 
    0.01753048f, -0.01550307f, -0.05644906f, 0.08152302f, 0.04190063f, -0.00246764f, -0.13913733f, 0.12549658f, 
    0.00406357f, 0.02165418f, 0.21678706f, -0.04336189f, -0.06153028f, -0.04063603f, 0.06479747f, 0.21598330f, 
    -0.07115722f, -0.02586388f, 0.10216569f, 0.08438200f, -0.14751330f, -0.04732853f, 0.12087333f, 0.07857528f, 
    -0.10882577f, -0.01214431f, -0.15081419f, 0.19724070f, -0.13855208f, 0.02065713f, 0.03118696f, -0.06709978f, 
    -0.22492608f, -0.07420659f, 0.10095626f, 0.18573105f, -0.02849905f, -0.05354482f, -0.10526394f, 0.02112115f, 
    -0.09742022f, 0.07949013f, -0.08752992f, 0.15207483f, -0.01947023f, 0.17297255f, -0.08853610f, -0.05137894f, 
    -0.03773015f, -0.06264067f, 0.06102594f, 0.06980249f, 0.00856976f, 0.08880477f, 0.06674749f, 0.00052040f, 
    -0.03318418f, 0.06391300f, 0.08766709f, 0.02842168f, -0.00955925f, -0.03138538f, 0.01961332f, -0.05557306f, 
    0.15887916f, 0.09743804f, -0.02143514f, 0.02043347f, 0.09749366f, 0.00801401f, 0.18320015f, 0.04234420f, 
    0.11700423f, 0.13582505f, 0.06413035f, 0.00217950f, 0.08548415f, -0.10008363f, -0.00985937f, -0.02932457f, 
    0.00791467f, 0.09103211f, 0.05614794f, 0.05504534f, 0.01240245f, 0.10234258f, -0.05156132f, 0.08852696f, 
    0.00032662f, 0.02083457f, -0.09844293f, -0.08943923f, 0.01393925f, -0.01323730f, 0.05568970f, 0.26624623f, 
    -0.06203116f, -0.13237350f, 0.22036946f, 0.00661423f, 0.09913440f, -0.07334117f, 0.17531221f, 0.04957531f, 
    -0.18318176f, -0.09329923f, 0.02568549f, 0.22750308f, -0.04461011f, 0.09249089f, 0.09406062f, 0.06551847f, 
    0.02025989f, 0.13480990f, -0.04401008f, 0.12713316f, -0.05721257f, 0.02786150f, 0.09580433f, 0.12158288f, 
    0.03213246f, -0.23195617f, 0.07853404f, -0.05348860f, 0.21174219f, 0.15942925f, 0.02299363f, 0.00950720f, 
    0.10580535f, -0.11244833f, 0.31184739f, 0.02406956f, 0.09944699f, 0.06126157f, 0.03547880f, 0.07481743f, 
    0.00601297f, 0.02211987f, -0.02327488f, -0.07675606f, 0.01436418f, -0.02492070f, 0.22129259f, 0.06522271f, 
    0.03163916f, 0.02032088f, 0.00327165f, -0.02640773f, 0.08562087f, 0.02600356f, -0.03228440f, -0.06763618f, 
    0.03151633f, -0.00955207f, 0.06603678f, 0.00342426f, 0.04777665f, -0.03005710f, -0.07455996f, 0.03915286f, 
    -0.09367925f, -0.05772778f, -0.07830621f, 0.00390644f, 0.06081180f, 0.09275566f, -0.10600052f, -0.12469674f, 
    0.02764475f, -0.00113636f, 0.09781182f, -0.04939487f, 0.04737083f, -0.03156338f, 0.13361344f, -0.04297441f, 
    0.12273561f, -0.18718503f, -0.04033159f, 0.20570868f, -0.00336907f, 0.17319788f, -0.13596264f, -0.00569255f, 
    -0.05451282f, 0.04321249f, 0.01639796f, -0.02139044f, -0.16725110f, 0.24621110f, 0.02427590f, 0.14358559f, 
    0.05194359f, -0.02733515f, 0.05692535f, -0.04765942f, -0.13181852f, 0.00336384f, 0.03540875f, -0.15559128f, 
    0.31734404f, -0.11177379f, -0.14111860f, -0.04543186f, -0.01989102f, -0.09451037f, 0.23637541f, 0.03439213f, 
    0.13500768f, 0.01382152f, 0.06942363f, 0.06052542f, 0.03584564f, 0.12596709f, -0.02312863f, 0.14351548f, 
    0.05662135f, 0.06022059f, -0.06795126f, 0.02909864f, -0.16331162f, -0.15567878f, -0.04555609f, -0.10103114f, 
    -0.03311897f, -0.02259377f, -0.15277357f, 0.05038945f, 0.05943975f, 0.04530706f, 0.00653873f, -0.00033370f, 
    0.03548339f, -0.07647672f, -0.03357125f, -0.01434724f, 0.08137178f, -0.09654969f, -0.11614446f, 0.17083353f, 
    0.10149322f, -0.03130669f, 0.00093377f, -0.08787382f, 0.00162587f, -0.05384995f, -0.03332425f, 0.04581383f, 
    -0.27398583f, -0.09678919f, 0.04520899f, 0.02811452f, -0.01892409f, 0.03018214f, -0.06635276f, 0.04025720f, 
    0.00898892f, 0.10873324f, 0.01892839f, 0.11536425f, -0.08890212f, 0.04750173f, 0.15294120f, 0.00202283f, 
    0.07647648f, 0.04469915f, -0.03078843f, -0.13063401f, -0.04080699f, 0.11702774f, 0.19285087f, 0.09730051f, 
    -0.44237700f, 0.08197997f, 0.01159191f, 0.00410680f, 0.02779193f, -0.01810868f, -0.11652736f, 0.11731683f, 
    -0.03833964f, -0.09976072f, 0.18765174f, 0.24941009f, -0.08969049f, 0.02578395f, -0.04500014f, 0.00983705f, 
    0.10236143f, -0.00019230f, -0.05246688f, 0.02800967f, -0.04412422f, -0.11437238f, -0.13525067f, 0.16373990f, 
    0.15737692f, -0.00117377f, -0.15834621f, 0.20360976f, 0.04236209f, 0.20263968f, 0.04586797f, 0.11063308f, 
    0.07939162f, 0.03396877f, -0.01247870f, -0.07284203f, -0.30864090f, -0.19944981f, 0.06034910f, 0.09438632f, 
    -0.05538754f, -0.00765889f, -0.04857095f, -0.02439592f, -0.02954627f, 0.02202007f, 0.16323376f, 0.10615251f, 
    -0.20392206f, -0.42635965f, -0.05455608f, -0.25173274f, 0.03086383f, -0.00450802f, 0.08536839f, 0.07431925f, 
    0.02474871f, -0.03715977f, -0.05062729f, 0.14113387f, -0.11327438f, -0.52357382f, -0.12091588f, -0.08188356f, 
    -0.08021928f, 0.00803693f, 0.10218090f, -0.11267714f, 0.07475502f, -0.01203574f, 0.06408729f, 0.08125280f, 
    -0.12693003f, -0.19196945f, 0.09410237f, -0.17263174f, -0.02110589f, 0.00895575f, 0.11771814f, 0.06438761f, 
    0.06857015f, 0.08503469f, 0.00070979f, -0.03017900f, -0.22062534f, -0.05625360f, -0.27092370f, -0.12236405f, 
    0.04775546f, 0.03310381f, 0.03596896f, 0.01140973f, -0.14156319f, 0.03315111f, -0.02593592f, -0.07401834f, 
    0.04563288f, 0.20671795f, -0.05014490f, -0.24164757f, 0.16443351f, -0.10237799f, 0.14127801f, -0.07840772f, 
    0.00688526f, -0.06536914f, -0.03801886f, -0.04650976f, 0.10979141f, -0.07631316f, -0.17749771f, -0.25406829f, 
    -0.12891351f, -0.11316188f, 0.03485562f, 0.07679214f, 0.03251546f, -0.05614480f, 0.05522404f, -0.00718865f, 
    0.34062007f, 0.24938400f, 0.21496199f, 0.15652120f, 0.06936796f, 0.05799782f, 0.05748274f, 0.01734542f, 
    -0.03053395f, -0.02387695f, 0.01916386f, 0.05867151f, 0.04181889f, -0.10419116f, 0.00903346f, 0.05950764f, 
    -0.16479678f, 0.23695925f, -0.11782791f, -0.12759072f, -0.02876820f, -0.10844429f, -0.00451912f, -0.05387337f, 
    0.51486766f, 0.41913876f, 0.41674164f, 0.24628574f, -0.04099883f, -0.02558067f, -0.03175789f, -0.04418533f, 
    -0.08093125f, -0.02641466f, -0.01484565f, -0.04423387f, 0.00009712f, 0.07572426f, 0.12136155f, -0.00346769f, 
    0.04921396f, 0.02786396f, 0.01169170f, 0.00306025f, 0.05393421f, 0.05366320f, 0.02654269f, -0.07189927f, 
    0.18015905f, 0.06621969f, -0.17682636f, -0.17929159f, -0.08725584f, 0.04821326f, -0.09831376f, 0.04374177f, 
    -0.02296847f, 0.06026963f, -0.03530683f, -0.08534306f, 0.23294541f, 0.25660598f, 0.09857133f, 0.09566953f, 
    0.02890707f, 0.14042622f, 0.15087172f, 0.03465407f, -0.02929943f, 0.01986693f, 0.00301381f, 0.02234638f, 
    0.20339115f, 0.06016751f, 0.16439566f, 0.02712574f, 0.12744717f, -0.06960565f, 0.05805702f, 0.05213089f, 
    0.03558418f, -0.01358906f, 0.00469958f, 0.06270228f, 0.01795322f, -0.12645499f, -0.12917960f, -0.26889953f, 
    -0.09526742f, -0.08968712f, -0.10198458f, 0.04480604f, -0.06521109f, -0.03173877f, -0.00080826f, 0.03299278f, 
    0.26951087f, -0.07481626f, 0.29309013f, 0.04745788f, -0.07211576f, -0.03054791f, 0.14938274f, -0.03152381f, 
    -0.01353176f, -0.06669099f, -0.01375501f, 0.00398102f, 0.05401764f, -0.01393612f, 0.07001881f, 0.04756163f, 
    -0.01661497f, 0.00192135f, 0.02675382f, 0.04544178f, 0.24477029f, 0.10517545f, 0.01156837f, 0.11823797f, 
    0.06843005f, -0.08491190f, 0.36637774f, 0.12312435f, -0.02445607f, -0.01466646f, -0.01902184f, 0.01530016f, 
    0.05481541f, -0.01874800f, 0.18785395f, 0.07068950f, 0.10057615f, 0.03465285f, 0.01109309f, 0.03509329f, 
    0.00711969f, 0.10640092f, 0.00746130f, -0.00603589f, -0.14943182f, 0.11953130f, 0.01106524f, 0.09366030f, 
    -0.06641649f, -0.07942629f, 0.10590485f, -0.04843199f, -0.05574725f, 0.02865912f, -0.02444187f, 0.02309925f, 
    -0.00670196f, 0.05565845f, 0.05545423f, 0.00466448f, 0.24835591f, 0.21327460f, 0.02831274f, -0.08543963f, 
    0.01812223f, -0.17704460f, -0.04038101f, 0.11120429f, 0.02942764f, -0.05426234f, -0.03750743f, -0.04471462f, 
    -0.05827394f, 0.10391051f, -0.20159945f, 0.09239566f, 0.04703454f, -0.12860823f, 0.09951825f, -0.05379777f, 
    -0.01285660f, -0.07465305f, -0.02525543f, 0.06366731f, -0.01220552f, 0.06398638f, 0.01263789f, 0.19888814f, 
    -0.01952755f, 0.05028929f, -0.05902905f, 0.01904849f, -0.03773063f, -0.00969001f, 0.01642627f, 0.05308735f, 
    0.01275515f, 0.17159277f, -0.07860941f, -0.09129948f, -0.09619807f, -0.14781220f, -0.06804913f, -0.13173470f, 
    -0.11598220f, -0.02102279f, -0.04151907f, -0.05830921f, -0.19319695f, -0.02741498f, -0.07021000f, 0.07559046f, 
    0.25086361f, 0.00901093f, -0.00980076f, -0.02886687f, 0.10115679f, -0.09747370f, 0.02579072f, 0.10462195f, 
    -0.01888140f, -0.06211292f, 0.00866607f, 0.20353949f, 0.16708581f, 0.06176161f, 0.03210913f, 0.07494848f, 
    0.09327520f, -0.01601057f, 0.22852507f, 0.07589293f, 0.02222396f, 0.06667076f, -0.02080548f, 0.05636811f, 
    -0.03115639f, 0.04293406f, 0.04529210f, -0.07009760f, 0.04696802f, 0.12664035f, -0.13904499f, -0.01094577f, 
    0.15378162f, 0.18388546f, 0.09882458f, 0.05740496f, 0.00031811f, 0.11543544f, 0.13396870f, 0.19950563f, 
    0.00049545f, 0.03579753f, -0.02797948f, 0.02236001f, -0.17315136f, -0.06028756f, -0.39654922f, -0.08081483f, 
    -0.10481581f, -0.00641629f, 0.07917749f, 0.00767324f, 0.11386213f, 0.06928333f, 0.08331481f, 0.23628618f, 
    0.32192561f, 0.22103120f, 0.00345157f, -0.14791195f, 0.15324423f, -0.03218208f, 0.06170369f, 0.00948309f, 
    -0.00202339f, -0.06201885f, 0.19365701f, 0.02068393f, -0.07326607f, 0.05766353f, 0.03210061f, 0.15295093f, 
    -0.04427030f, -0.00103670f, 0.00169377f, -0.00420801f, 0.07726771f, -0.02424895f, 0.11068422f, 0.17916855f, 
    -0.01616202f, -0.06053843f, -0.11405825f, 0.16115309f, -0.11338954f, 0.04410650f, 0.05455310f, 0.01520461f, 
    0.09281083f, 0.04918841f, 0.00379567f, 0.15026149f, -0.12130988f, -0.22248827f, -0.35542747f, 0.19465867f, 
    -0.10625260f, 0.01808463f, 0.02533972f, -0.04910343f, -0.07686533f, -0.06119261f, -0.00430138f, 0.00132722f, 
    0.07937010f, -0.34746644f, -0.00692557f, -0.18856752f, 0.09867860f, -0.06862111f, -0.03169194f, -0.00107586f, 
    0.08015217f, 0.07704680f, 0.06435855f, 0.02463788f, 0.09627575f, 0.07817789f, -0.08762335f, -0.31894109f, 
    -0.05856653f, -0.12506323f, 0.01549143f, -0.06606082f, -0.02988885f, 0.11393477f, 0.11287104f, 0.03132440f, 
    0.04034061f, -0.06072141f, 0.27179587f, 0.08210409f, -0.08363979f, 0.14748262f, 0.08855435f, 0.15689331f, 
    -0.01882106f, 0.17177713f, 0.05751235f, 0.12865424f, 0.14293727f, 0.00572496f, -0.12429296f, 0.08665042f, 
    0.06928185f, -0.00889477f, -0.04965864f, 0.06325313f, -0.07214815f, 0.00309025f, -0.11880169f, 0.02346328f, 
    -0.25899324f, -0.01546229f, -0.33899248f, 0.27586797f, 0.01806976f, 0.17634520f, -0.15447007f, -0.06280617f, 
    -0.10326290f, 0.00964263f, 0.00926639f, 0.11304992f, 0.03623375f, 0.16032763f, 0.00189320f, 0.03200997f, 
    -0.01605633f, -0.03174622f, 0.01095790f, -0.00837740f, -0.14571521f, 0.09396221f, 0.00379804f, -0.02057137f, 
    -0.12005968f, -0.17619529f, -0.10724539f, -0.10529037f, -0.06818483f, -0.05854061f, -0.06209027f, -0.02074971f, 
    -0.17366122f, -0.09545353f, -0.11277661f, -0.05812666f, 0.16532405f, -0.04983773f, -0.23235716f, -0.22586529f, 
    -0.01924302f, 0.03502787f, -0.13000143f, 0.09671489f, -0.01036654f, 0.09788316f, -0.11430062f, -0.03121772f, 
    -0.12689734f, -0.04470564f, -0.51483881f, 0.15339643f, 0.09416550f, -0.06220952f, -0.01699747f, -0.09634446f, 
    -0.02269808f, -0.16950601f, 0.11149605f, 0.09714437f, 0.11704124f, -0.22422114f, 0.25246066f, -0.11790588f, 
    0.01339172f, 0.03383663f, 0.00083064f, 0.01232141f, 0.03720124f, 0.05665568f, 0.15069424f, -0.00897132f, 
    -0.04465891f, -0.03115703f, -0.08063392f, -0.00269016f, 0.03629714f, 0.03349699f, 0.03126621f, 0.01930900f, 
    -0.02406265f, -0.04632427f, -0.04313302f, -0.06942983f, 0.18199953f, 0.18335180f, 0.03952469f, -0.00738750f, 
    -0.06375641f, 0.10112847f, 0.03677839f, 0.02552746f, -0.03563296f, 0.12692425f, -0.01332630f, 0.12334799f, 
    0.33775100f, -0.07869036f, 0.29922000f, 0.03352370f, 0.00374230f, -0.20514722f, 0.01847018f, 0.00990000f, 
    -0.08465797f, -0.00236992f, 0.05221149f, -0.01622998f, -0.62710559f, -0.11118086f, -0.21211891f, -0.34468621f, 
    0.05809153f, 0.03865762f, 0.08420067f, 0.05644852f, -0.07292638f, -0.00344437f, -0.05309318f, 0.04276251f, 
    -0.10681958f, 0.08204198f, -0.35529107f, -0.17437118f, 0.12181148f, -0.03179836f, 0.02890111f, -0.04567472f, 
    -0.04769904f, -0.05006240f, 0.09358685f, 0.01766516f, -0.35032365f, -0.22510953f, -0.22985540f, -0.27572814f, 
    -0.06419403f, 0.02776675f, 0.05372902f, -0.13791737f, -0.05103994f, -0.07788411f, 0.00126587f, -0.05274468f, 
    0.25508654f, 0.05353786f, 0.11790671f, 0.35458386f, -0.12022644f, 0.00071573f, 0.01456558f, 0.00750913f, 
    -0.03822003f, 0.03432603f, -0.08900875f, -0.03536147f, 0.02954660f, 0.18987663f, 0.08037130f, -0.03303593f, 
    0.06954764f, 0.01242316f, -0.02291739f, 0.13099809f, -0.12511382f, -0.08855289f, -0.04604204f, -0.12363660f, 
    0.04411265f, 0.14708173f, 0.10304531f, 0.24280693f, 0.05931967f, 0.06327463f, -0.05432838f, -0.05941557f, 
    0.01774843f, -0.01677778f, 0.00327216f, 0.00015259f, -0.09451177f, 0.13336794f, 0.14014533f, -0.01092950f, 
    0.03277798f, 0.05934194f, -0.11190745f, 0.03831912f, 0.10202380f, 0.14457659f, 0.14184301f, 0.06086385f, 
    -0.20389450f, 0.00247358f, -0.03964448f, 0.10002229f, 0.13429123f, -0.07611679f, -0.12167938f, -0.18038630f, 
    -0.08626119f, -0.01291538f, 0.04160291f, -0.10302553f, -0.03272524f, -0.02649283f, -0.18206935f, -0.00014946f, 
    -0.21785958f, 0.03491260f, 0.01190267f, 0.11040130f, 0.13286044f, 0.13571526f, -0.06703687f, 0.12813602f, 
    -0.17963083f, -0.03990591f, -0.05783259f, -0.09863503f, -0.05494942f, -0.06124755f, 0.01855631f, 0.08630054f, 
    0.06117649f, -0.13505545f, -0.03328056f, -0.02261742f, -0.02781647f, 0.02603714f, 0.13513948f, 0.14845234f, 
    -0.02663723f, -0.03943489f, -0.04831478f, -0.02835789f, 0.00108006f, -0.07036289f, -0.00539719f, 0.02814797f, 
    0.04255506f, 0.19632176f, 0.11407976f, 0.29286128f, -0.01621866f, 0.01087412f, 0.01529462f, -0.02683129f, 
    0.04697929f, 0.01487088f, 0.00005093f, 0.08168955f, 0.01479539f, 0.17147456f, -0.00012910f, -0.05488819f, 
    0.18032835f, 0.09430470f, 0.01948177f, 0.01575012f, -0.03910469f, -0.00501430f, 0.05023739f, -0.01995440f, 
    -0.06515376f, -0.06743108f, -0.55714422f, -0.14542568f, -0.00962568f, 0.06607231f, 0.12592860f, -0.07089182f, 
    -0.00490320f, -0.01141260f, 0.06105633f, -0.03561428f, 0.09468210f, -0.35223487f, 0.02971543f, -0.08736300f, 
    0.03959191f, -0.04127801f, 0.04504091f, 0.12900901f, 0.06343777f, 0.08156393f, 0.08542390f, 0.03209315f, 
    0.09993859f, -0.20050046f, 0.07897665f, -0.08929104f, 0.00891426f, -0.04296619f, -0.12373528f, 0.01902475f, 
    -0.08164541f, 0.04683132f, -0.01767348f, 0.07720487f, 0.12133063f, 0.06484493f, 0.05938108f, 0.07531133f, 
    -0.02176255f, 0.03509368f, -0.03167475f, 0.01117205f, 0.06599831f, -0.07707570f, -0.03566015f, 0.03124858f, 
    0.31484011f, 0.16040167f, 0.15304843f, 0.08227474f, 0.09937731f, -0.04019777f, 0.03161470f, 0.10987438f, 
    -0.00415956f, -0.02822541f, 0.03218981f, 0.01405399f, -0.09753252f, 0.06271654f, -0.21587437f, -0.02764742f, 
    0.01783603f, 0.08040611f, 0.10413101f, -0.10287596f, 0.05684481f, 0.05132246f, 0.18305597f, 0.03565645f, 
    0.13530540f, -0.01325946f, 0.02032382f, 0.20183626f, 0.02770698f, 0.03196029f, -0.00620348f, -0.01799163f, 
    0.06682111f, -0.07185566f, 0.32176411f, 0.22127758f, 0.09233599f, -0.03150738f, 0.03158755f, 0.08486504f, 
    0.08547096f, -0.07419111f, 0.06104596f, 0.12989938f, 0.08978532f, 0.06802393f, 0.05767864f, 0.03820611f, 
    -0.12857458f, -0.08720788f, -0.14064026f, 0.03815790f, -0.08131097f, 0.04318526f, 0.17040481f, 0.12068772f, 
    -0.12768814f, -0.07858715f, -0.02906624f, -0.11995696f, 0.12587430f, -0.05473741f, -0.00822797f, -0.13055405f, 
    0.10897503f, -0.14963782f, -0.02199502f, 0.22380587f, -0.02544693f, 0.05463343f, -0.17218861f, 0.01535331f, 
    -0.03507341f, 0.22022462f, 0.03479114f, -0.04406671f, 0.09692111f, 0.01533499f, 0.07334157f, -0.01361605f, 
    -0.11171815f, 0.04775534f, -0.00385358f, -0.04875578f, 0.05265827f, 0.09907918f, -0.00617675f, 0.08741610f, 
    0.01075507f, 0.05395003f, 0.05137382f, 0.06982535f, -0.03361522f, 0.08236548f, 0.03093618f, 0.06889692f, 
    -0.17770010f, 0.03915581f, -0.01389094f, 0.07610632f, 0.02737673f, -0.08132230f, -0.06068743f, -0.03427315f, 
    -0.02626147f, 0.04520481f, 0.02967820f, 0.04859834f, -0.11289984f, 0.26595837f, 0.19991693f, 0.00427281f, 
    0.07246400f, -0.12917037f, -0.01026436f, -0.14487198f, -0.06019566f, 0.10035457f, 0.13404483f, 0.06016323f, 
    -0.16438094f, 0.01396119f, -0.19210348f, 0.28488427f, -0.05483009f, -0.07542334f, -0.15159528f, -0.07425629f, 
    -0.02100510f, 0.04554044f, -0.10198230f, 0.08602007f, -0.13887356f, -0.05750733f, -0.07660341f, -0.01789068f, 
    -0.09392594f, -0.03919604f, 0.04879593f, -0.04354326f, 0.06770451f, 0.12459975f, 0.21039549f, 0.08637774f, 
    0.21575215f, 0.27633968f, -0.03974831f, 0.14657028f, 0.12447803f, -0.04511625f, 0.03839200f, -0.03751228f, 
    -0.04426813f, 0.05691867f, -0.03249089f, 0.16510944f, -0.16837634f, -0.08412945f, -0.05052361f, -0.05149068f, 
    0.09398939f, 0.13705511f, 0.08314253f, -0.02661723f, -0.08864163f, 0.08575796f, -0.01222740f, 0.01551861f, 
    0.06717768f, -0.08484727f, 0.03330510f, -0.05322112f, 0.05955083f, 0.10503519f, -0.09679176f, -0.02056590f, 
    0.03451334f, 0.02530348f, -0.04544187f, -0.09744411f, 0.10470211f, -0.09781361f, -0.15029947f, 0.17575945f, 
    0.19887115f, 0.11954609f, -0.03170956f, 0.16137964f, -0.05624575f, -0.05533810f, -0.00528516f, 0.05074257f, 
    -0.21508217f, 0.19755559f, 0.00629962f, 0.19851838f, -0.19396883f, -0.11689004f, 0.03742760f, -0.06319636f, 
    0.05227668f, -0.03401617f, -0.05810660f, 0.06748780f, -0.20398691f, 0.36310369f, 0.05284353f, 0.01867932f, 
    0.00221922f, -0.05839826f, -0.07209598f, -0.04087129f, 0.04984948f, -0.14087361f, 0.14393778f, 0.05790544f, 
    -0.19023649f, 0.20504104f, 0.09980342f, 0.30611274f, -0.14733255f, -0.03154967f, -0.08228045f, 0.03745658f, 
    -0.06167998f, -0.05260998f, -0.04690568f, 0.11399285f, 0.10921640f, 0.28380778f, 0.06863160f, 0.07140203f, 
    -0.01340834f, -0.01335190f, 0.03924263f, -0.06172427f, -0.11790119f, -0.05484156f, 0.06267722f, -0.20653659f, 
    0.27230325f, 0.14544082f, -0.14431672f, 0.39390293f, -0.03495859f, 0.15507421f, 0.04201993f, 0.11799923f, 
    0.10967781f, -0.04603695f, -0.18469355f, 0.04698650f, -0.02759164f, 0.19543454f, -0.15681593f, 0.10924900f, 
    0.20239410f, 0.08663527f, -0.02215934f, 0.17419404f, -0.02012366f, 0.09798009f, -0.01227961f, -0.01015372f, 
    0.08048726f, -0.02266713f, 0.18816386f, -0.26234949f, -0.00060932f, 0.12524544f, -0.17576548f, -0.02384963f, 
    0.14373957f, -0.00422806f, 0.17776684f, 0.16041614f, 0.00171381f, -0.06520319f, 0.26199299f, -0.08838037f, 
    -0.01848315f, -0.07491560f, -0.03200601f, -0.06199842f, 0.09832675f, 0.18369018f, 0.13147451f, 0.22674075f, 
    0.11658997f, 0.01323370f, -0.15365933f, 0.05758794f, 0.07842766f, 0.10814914f, 0.02306665f, 0.07026766f, 
    -0.13088208f, 0.02169455f, -0.03075708f, 0.08255982f, 0.06976576f, 0.20319495f, 0.13411969f, -0.28520754f, 
    0.05989987f, 0.00051397f, 0.02499445f, -0.00422462f, -0.00172209f, -0.00407983f, 0.03319163f, -0.07563320f, 
    0.01326404f, 0.29526570f, -0.00379898f, -0.08446873f, 0.00587584f, -0.06653976f, -0.04556759f, 0.11225449f, 
    -0.05798713f, 0.20237276f, -0.17785232f, 0.02540177f, -0.12393133f, 0.04817868f, 0.09293170f, 0.02206574f, 
    -0.05569949f, -0.03033044f, 0.01011537f, 0.01580283f, 0.15796599f, -0.12080093f, -0.06468965f, -0.27594671f, 
    -0.13148622f, 0.00920042f, 0.08559604f, -0.00903035f, -0.12338596f, 0.09079058f, 0.01859387f, -0.08827630f, 
    -0.02501768f, 0.06434075f, 0.00647679f, -0.06919807f, -0.09975894f, 0.05613166f, 0.05188782f, 0.06979702f, 
    0.08998957f, 0.02977818f, 0.00010066f, -0.00325478f, 0.03875407f, -0.09897133f, 0.11385758f, -0.05014522f, 
    0.27765796f, -0.01934279f, 0.14247014f, -0.04631059f, 0.12760553f, 0.02671239f, 0.09817424f, 0.08513558f, 
    0.00739202f, 0.04126530f, -0.01806947f, 0.08605037f, 0.00296393f, -0.01030707f, -0.03978153f, -0.22934955f, 
    -0.08052609f, -0.04376347f, -0.00294723f, -0.09318483f, -0.10308632f, -0.07103553f, 0.07416049f, -0.19824472f, 
    -0.07262074f, 0.14868198f, -0.01160811f, -0.25114849f, 0.02606033f, 0.07630791f, 0.01390005f, -0.08949824f, 
    0.00517432f, 0.02083781f, 0.08017068f, -0.11094468f, 0.03726842f, -0.05966106f, -0.13454819f, -0.26333120f, 
    0.04008277f, 0.02887581f, -0.13040178f, -0.11765870f, 0.04983208f, 0.15514094f, 0.03096534f, -0.02358758f, 
    0.11169250f, 0.05248791f, -0.08917242f, -0.01233655f, 0.09010171f, 0.10642654f, 0.13191566f, 0.01032992f, 
    0.08654076f, 0.00616352f, 0.02818235f, 0.03382309f, 0.18819030f, -0.09034148f, 0.03938913f, -0.06689663f, 
    0.12651066f, 0.17322904f, 0.16741174f, 0.25596061f, -0.07014164f, 0.02455265f, 0.05013466f, 0.12457566f, 
    -0.13191268f, -0.10000419f, 0.09342883f, 0.20847906f, -0.06752110f, -0.01263513f, 0.19491628f, 0.19012868f, 
    -0.00693628f, -0.21476918f, 0.05947890f, -0.08073145f, -0.08824907f, 0.02992073f, 0.09494263f, -0.02700029f, 
    0.15525249f, 0.00480106f, 0.02789311f, -0.07807988f, 0.05631185f, 0.02197360f, 0.08717232f, 0.09687719f, 
    0.41898176f, 0.51190245f, -0.51985514f, -0.09604190f, 0.07280639f, -0.06202026f, 0.17494905f, 0.02998412f, 
    -0.13829285f, 0.13300116f, 0.11416969f, 0.09937011f, 0.07833591f, 0.15847641f, -0.11383566f, -0.16540778f, 
    0.02340642f, -0.04814104f, -0.04464693f, -0.07391179f, 0.01635816f, 0.02839340f, 0.09382009f, 0.07842215f, 
    0.33608922f, -0.02367429f, -0.16189049f, -0.12010880f, 0.16225143f, 0.07834314f, -0.02540044f, -0.01880704f, 
    0.10779635f, -0.00140564f, 0.00788708f, -0.07622199f, -0.02239299f, 0.28044197f, -0.07188721f, 0.16931780f, 
    0.31029755f, 0.06929418f, 0.15146509f, 0.03461653f, 0.08325923f, 0.00076199f, -0.00264180f, -0.03364510f, 
    -0.08438295f, 0.37709773f, -0.15601294f, -0.28867432f, 0.06805602f, 0.00288655f, -0.14749122f, -0.03487750f, 
    -0.02162033f, -0.05178117f, -0.15689798f, -0.01513220f, -0.05472274f, -0.02284005f, -0.01249504f, 0.18005712f, 
    0.08006667f, -0.03595062f, 0.00084875f, 0.27272460f, -0.03927219f, -0.01786898f, -0.11761730f, -0.15836138f, 
    0.03417104f, -0.12237928f, -0.13542746f, -0.09133346f, 0.02983380f, 0.12844685f, -0.01165756f, 0.09911773f, 
    -0.03834408f, 0.02886109f, 0.06876962f, -0.07461881f, -0.17912668f, -0.12462237f, 0.16642164f, 0.15123791f, 
    0.11251652f, 0.10117287f, 0.00237055f, -0.01410138f, -0.08491636f, -0.00027951f, -0.12281119f, -0.03680987f, 
    -0.10608484f, 0.17590325f, 0.07991753f, 0.17799614f, -0.04619751f, 0.01955202f, 0.10905699f, -0.04882776f, 
    0.00676254f, 0.08433507f, -0.00287471f, 0.07795475f, 0.28535798f, -0.10842482f, -0.07540323f, 0.06151387f, 
    -0.02613747f, 0.06130801f, 0.07754850f, 0.05727754f, 0.00633239f, 0.05405577f, 0.02211007f, -0.16703814f, 
    0.03738587f, -0.09415272f, 0.10225596f, 0.00682300f, 0.04542369f, 0.02067726f, 0.03286313f, 0.16732526f, 
    0.14919809f, -0.04145442f, -0.03368488f, -0.23549496f, -0.05463041f, -0.32633173f, -0.21146561f, -0.15430066f, 
    0.09067836f, 0.06031219f, 0.09557579f, 0.16577944f, -0.13908277f, 0.01418176f, -0.06041210f, -0.11826910f, 
    -0.03514889f, 0.01291263f, -0.19334063f, 0.24802032f, -0.10247532f, -0.06913614f, -0.03395585f, -0.09171554f, 
    0.01822784f, 0.02045647f, -0.04790207f, 0.05327125f, -0.02082353f, 0.06096986f, -0.08448027f, 0.00640562f, 
    0.12567258f, 0.15079483f, 0.10653996f, 0.07753283f, -0.03331865f, 0.06326804f, 0.02102869f, -0.00522442f, 
    -0.14456068f, 0.12866166f, 0.05346363f, -0.22364046f, 0.01738744f, -0.04746038f, -0.07473524f, -0.10947125f, 
    0.05805810f, 0.04179343f, 0.20028818f, 0.22051097f, -0.17062739f, 0.05708506f, 0.04346221f, 0.14555225f, 
    -0.15955655f, -0.03177294f, 0.11407350f, -0.00735462f, -0.04069831f, 0.03209605f, 0.01403320f, 0.04904213f, 
    0.06513461f, 0.26873699f, 0.07433558f, -0.04166181f, -0.04736924f, 0.09873910f, 0.04913507f, -0.03266816f, 
    0.15925737f, 0.13737923f, 0.20785666f, 0.20642367f, -0.04103246f, 0.01503136f, 0.21282493f, 0.14502968f, 
    -0.07046374f, 0.17343588f, 0.04203446f, 0.11671288f, 0.06904288f, -0.09191955f, 0.10376566f, 0.04143492f, 
    0.08704558f, 0.00832487f, 0.09331671f, 0.00401840f, -0.07134846f, 0.01873833f, 0.13536514f, 0.15782344f, 
    -0.15401582f, 0.06730750f, -0.10909834f, -0.22177573f, -0.14559367f, 0.18651712f, 0.05099671f, -0.02648859f, 
    0.07490937f, 0.11374904f, -0.12788329f, 0.01404263f, 0.15352140f, 0.17937879f, 0.17339785f, 0.14788707f, 
    -0.09228794f, 0.14331357f, 0.14240044f, -0.20339052f, -0.05701811f, -0.02155954f, -0.02387887f, -0.08700708f, 
    -0.03392899f, 0.08131033f, 0.05541093f, 0.00201351f, 0.03371517f, -0.09112728f, 0.06658332f, -0.07253584f, 
    -0.10287816f, 0.12264328f, -0.08213267f, -0.07306919f, 0.02828683f, 0.13086236f, 0.04979635f, 0.00342827f, 
    -0.05167431f, 0.02265622f, -0.09781494f, -0.09615306f, 0.09250460f, 0.13814293f, -0.00349112f, 0.09518006f, 
    -0.03643688f, 0.03391176f, -0.04247824f, 0.05533339f, 0.05104041f, -0.03294375f, -0.10437163f, 0.09391948f, 
    0.04742404f, 0.09155408f, 0.02767021f, 0.03392676f, 0.03294638f, 0.06854532f, -0.11007741f, -0.05277837f, 
    -0.03857620f, -0.33118021f, 0.32685289f, 0.13637450f, 0.02184045f, 0.02018251f, 0.11957286f, -0.03803488f, 
    0.18771899f, 0.06858652f, 0.29008418f, 0.11860613f, -0.05500786f, 0.10014474f, 0.07922021f, -0.21249552f, 
    0.01258351f, -0.05557164f, 0.01887223f, -0.12017571f, 0.08602915f, -0.08971850f, 0.04074799f, 0.19886002f, 
    0.01084896f, 0.02916056f, -0.00092398f, -0.07652476f, -0.17897256f, 0.12148514f, 0.16775715f, -0.04254490f, 
    -0.04152015f, 0.00135095f, 0.10571301f, -0.01501968f, 0.12300306f, -0.05609893f, -0.00375322f, -0.02361551f, 
    0.11175448f, 0.07201995f, 0.10635452f, 0.15866986f, -0.05604154f, -0.02706227f, 0.00669178f, -0.01341705f, 
    -0.04386678f, 0.02191883f, -0.03924233f, -0.01901014f, 0.02700788f, -0.01241762f, -0.04497220f, 0.00973834f, 
    -0.02320541f, -0.03211616f, 0.01146561f, 0.03201257f, 0.00646872f, 0.02130717f, 0.01632443f, 0.02708415f, 
    0.01842191f, -0.00651477f, 0.01202425f, -0.01760113f, -0.03390922f, -0.02200174f, -0.02813070f, 0.00216598f, 
    -0.01133842f, -0.01912058f, 0.01039857f, -0.03190998f, -0.01178214f, -0.00088915f, -0.02396633f, -0.04369351f, 
    -0.03671126f, -0.03492364f, -0.01509763f, -0.01573407f, -0.04077919f, 0.00985414f, 0.00286198f, -0.01706339f, 
    -0.00722718f, -0.01909552f, -0.00014301f, -0.01053241f, -0.01033415f, 0.01488069f, 0.00663763f, -0.02400292f, 
    0.02523992f, -0.03142682f, -0.00859290f, 0.01110488f, -0.00779438f, -0.00574979f, 0.02172476f, -0.02537625f, 
    -0.00161121f, 0.03287453f, -0.02801151f, -0.00508160f, 0.01115576f, 0.00753180f, -0.04212982f, 0.00571195f, 
    -0.03665873f, -0.00309681f, 0.01420196f, 0.01894214f, -0.03442375f, -0.03105526f, -0.01119990f, -0.00991992f, 
    0.01288668f, -0.00873211f, -0.01736089f, -0.02540293f, -0.03350422f, -0.02773127f, -0.01515186f, 0.02590332f, 
    -0.00616251f, -0.03721114f, -0.03609388f, 0.02041489f, -0.04485597f, -0.00890207f, -0.03682383f, 0.02410111f, 
    0.00448890f, -0.00043577f, 0.00339899f, -0.00871581f, -0.02739763f, 0.00376310f, -0.02492725f, -0.01651954f, 
    -0.02315915f, -0.01145460f, 0.02573787f, 0.02435258f, 0.02747092f, -0.04162244f, -0.00074117f, 0.03111114f, 
    -0.01318828f, 0.01667370f, -0.00228709f, -0.01035300f, 0.00214037f, -0.01901938f, 0.01024072f, 0.00427060f, 
    0.02569028f, 0.00144303f, 0.02066951f, 0.02567133f, 0.01739303f, -0.00744555f, 0.00540060f, -0.02545025f, 
    -0.03640087f, -0.01556189f, 0.00046026f, -0.00948930f, 0.00953123f, -0.02344862f, -0.04177216f, 0.01023480f, 
    -0.04193851f, -0.01484203f, -0.02369596f, 0.00514709f, 0.01449318f, -0.01159369f, -0.00948790f, 0.01361580f, 
    -0.03246087f, -0.03258142f, 0.01316930f, -0.00252094f, 0.02319777f, 0.00061837f, 0.00100540f, -0.01359606f, 
    -0.02167677f, -0.04321389f, -0.01701020f, -0.00554339f, -0.01510896f, -0.00261870f, -0.03322671f, -0.04408737f, 
    -0.03649640f, 0.00701311f, -0.01194405f, -0.02078029f, 0.02385855f, -0.01059203f, -0.01177958f, 0.00086622f, 
    -0.02538241f, 0.01104527f, -0.01929388f, 0.01672363f, -0.03280206f, -0.02026438f, -0.01719975f, 0.02479069f, 
    0.00097537f, -0.03865207f, 0.00767546f, 0.01985134f, -0.01547654f, -0.00066764f, -0.00339874f, -0.03268426f, 
    -0.00865889f, -0.00438718f, -0.01230784f, -0.03346072f, 0.01798727f, -0.03002528f, -0.03807958f, -0.03111234f, 
    0.02067494f, -0.03570164f, -0.02811481f, -0.03729884f, -0.00686565f, 0.01322611f, 0.01264914f, 0.00228283f, 
    0.02366032f, 0.02469578f, -0.03304217f, -0.01466701f, -0.02053208f, -0.02604479f, 0.00963466f, -0.01876638f, 
    0.00409065f, 0.00031110f, -0.01344161f, -0.00725419f, -0.01187698f, -0.04495948f, 0.01588149f, -0.00046746f, 
    -0.01636297f, 0.01776489f, -0.02876951f, 0.01250427f, -0.02765284f, 0.02948176f, 0.03519655f, -0.02753515f, 
    -0.00623829f, -0.00053062f, 0.02193242f, -0.01365458f, -0.01688584f, 0.01952300f, -0.01934631f, -0.04333881f, 
    0.01006345f, -0.02109480f, 0.00220664f, -0.04429942f, -0.04130077f, -0.01874165f, -0.01605185f, -0.03800202f, 
    -0.02249223f, 0.00267247f, -0.04268664f, -0.02341857f, 0.02535357f, 0.01505971f, -0.01023888f, -0.01171362f, 
    -0.04320536f, 0.03269635f, -0.03244309f, -0.03826022f, -0.03287264f, -0.02809587f, 0.01485692f, -0.00278261f, 
    -0.02420597f, -0.01349553f, -0.01507559f, -0.02093677f, -0.00844151f, -0.04176549f, 0.02115231f, -0.01982136f, 
    0.00762843f, 0.00770238f, -0.03528103f, -0.01241375f, -0.00691740f, -0.02604816f, -0.01746755f, 0.01922927f, 
    -0.01684218f, 0.00956983f, 0.01185547f, -0.01435498f, 0.02709057f, -0.01768795f, -0.02130012f, -0.01487116f, 
    0.00673735f, -0.01257322f, -0.00639025f, 0.00447510f, -0.00996016f, 0.00151511f, -0.04301385f, -0.02897708f, 
    -0.03126843f, -0.03093663f, 0.00758165f, -0.00152949f, 0.01846508f, -0.03166964f, -0.00483761f, 0.02567049f, 
    -0.04113390f, 0.00925456f, -0.02667413f, 0.00519570f, -0.02788023f, 0.02712308f, -0.03449006f, -0.00853947f, 
    -0.00295255f, 0.00603843f, -0.00906631f, 0.00264943f, -0.00907506f, -0.00238520f, -0.01033429f, -0.00041208f, 
    0.00962012f, -0.00837460f, 0.01127460f, -0.01159774f, -0.03049371f, -0.02027577f, -0.02396235f, -0.03966304f, 
    0.00015997f, 0.01825084f, -0.02330936f, -0.03443343f, 0.00952658f, -0.02838446f, -0.02919402f, 0.01139771f, 
    -0.02372121f, -0.01226831f, 0.01530885f, -0.01836467f, 0.00803043f, 0.01751230f, 0.01504876f, 0.01438657f, 
    0.02414252f, 0.02676033f, -0.04007030f, -0.03022136f, -0.00683907f, -0.03298576f, 0.01847607f, -0.03544894f, 
    -0.02316132f, -0.04286301f, -0.03630516f, -0.00564968f, 0.02348425f, 0.00276946f, 0.01225626f, 0.01439544f, 
    0.01011250f, -0.02054239f, -0.00478130f, 0.00019099f, 0.03092736f, -0.02903529f, 0.02442190f, 0.03484457f, 
    -0.01062867f, 0.02630236f, -0.00719291f, -0.00657213f, 0.00864107f, -0.00457460f, -0.03119896f, -0.02644692f, 
    -0.03491791f, -0.02190128f, -0.02218097f, 0.02378077f, -0.03299180f, 0.01861383f, 0.02078536f, -0.02022019f, 
    -0.03935944f, 0.00707776f, -0.04351685f, 0.01990577f, -0.01277387f, -0.03821233f, -0.03175063f, -0.01966695f, 
    -0.04485811f, -0.03615718f, 0.02629735f, 0.03013693f, -0.04159195f, -0.00272070f, -0.01395047f, -0.01366157f, 
    -0.00957776f, -0.03661963f, -0.03599159f, 0.02328844f, -0.00299274f, -0.03219102f, -0.03954787f, -0.02012878f, 
    -0.00503612f, -0.01614326f, -0.02436272f, -0.02213875f, -0.01071990f, 0.00764520f, -0.03244551f, -0.03644603f, 
    0.00826560f, -0.02538717f, 0.01606660f, -0.03193650f, -0.02863667f, 0.00463991f, 0.02762271f, -0.01880333f, 
    -0.01940993f, -0.02472862f, -0.00615183f, -0.02683872f, -0.03945075f, -0.03490626f, 0.01089291f, -0.01307461f, 
    0.01984505f, -0.01324764f, -0.02449064f, 0.00177777f, -0.04419753f, 0.01192708f, 0.01449666f, -0.01304897f, 
    -0.02135322f, -0.03619122f, 0.00079925f, -0.03405188f, 0.00374314f, -0.03399573f, -0.00991163f, -0.00085231f, 
    -0.02940141f, -0.03479966f, -0.01530643f, 0.00579129f, 0.00486038f, -0.03260460f, -0.02581396f, 0.01860824f, 
    -0.00796500f, -0.00424758f, -0.03051088f, -0.02210260f, -0.01641533f, 0.02988138f, -0.02336921f, 0.02695711f, 
    -0.00045690f, -0.01696154f, -0.02710458f, 0.01049665f, -0.02239210f, 0.00915661f, -0.04339685f, -0.04259298f, 
    0.00955864f, -0.04197247f, -0.02033672f, -0.03653621f, 0.00507356f, 0.01129286f, -0.02510452f, -0.01276679f, 
    0.02183015f, -0.01511179f, 0.01864045f, -0.04452592f, -0.01598866f, 0.00001497f, -0.00092576f, -0.01992840f, 
    -0.03172164f, -0.03423781f, -0.02174231f, -0.02979848f, -0.02648560f, 0.01656776f, -0.02301779f, -0.00211766f, 
    0.00306104f, -0.03760586f, -0.01399397f, -0.00663538f, -0.03360290f, -0.01563757f, -0.00075948f, 0.00660065f, 
    -0.02329728f, -0.01586624f, -0.03857341f, -0.02719544f, -0.03463538f, 0.01801409f, 0.01979370f, -0.03161096f, 
    -0.01727245f, -0.02023304f, -0.02503235f, -0.02789711f, -0.00391719f, -0.03905373f, -0.00443136f, -0.02663099f, 
    -0.02750974f, -0.03154439f, 0.00823325f, -0.03350634f, -0.02252995f, -0.01490346f, -0.02601903f, -0.00088556f, 
    -0.00829591f, 0.02188743f, -0.04014922f, 0.02634148f, 0.02625071f, -0.00928321f, -0.00594345f, -0.01416185f, 
    -0.03530610f, -0.04101238f, -0.02720901f, -0.03318269f, -0.01917095f, 0.00266598f, 0.02305154f, 0.00523630f, 
    -0.00517713f, -0.03603934f, -0.03278387f, -0.02897414f, 0.02129322f, -0.02596472f, 0.02308575f, -0.00167639f, 
    -0.02818587f, 0.03554470f, -0.00589344f, -0.02621483f, -0.01769556f, -0.02728653f, -0.02951361f, 0.02590598f, 
    -0.01444094f, -0.00236246f, 0.03552676f, -0.01106799f, -0.02257136f, -0.03317027f, -0.01710503f, 0.02825055f, 
    0.01572994f, -0.00989293f, 0.00661273f, 0.02410426f, 0.01372983f, 0.00263017f, 0.02008667f, -0.04347667f, 
    -0.02659201f, -0.02317071f, 0.02060612f, 0.00110191f, -0.02748382f, -0.03831658f, -0.00782009f, 0.01277384f, 
    0.01683726f, 0.00300564f, -0.02678025f, -0.00557446f, -0.04034464f, 0.01902914f, 0.01101161f, -0.02261277f, 
    -0.01005754f, 0.02492335f, -0.03791618f, -0.00365017f, 0.00839145f, -0.01726470f, -0.03203648f, 0.02662116f, 
    -0.01077041f, 0.02385467f, -0.03657512f, -0.00866810f, 0.02156528f, -0.02149782f, 0.01517457f, -0.01365435f, 
    0.01574159f, -0.03165228f, -0.00689349f, -0.02408070f, -0.01040095f, 0.02603036f, -0.02056001f, 0.03317390f, 
    -0.03335700f, 0.01228633f, 0.02046178f, -0.03485063f, 0.00068709f, -0.03245082f, -0.02202608f, -0.04474087f, 
    0.00904220f, 0.01016096f, 0.02220796f, 0.00817033f, -0.00531858f, 0.00772552f, 0.02711517f, -0.03242292f, 
    -0.03124882f, -0.02264321f, -0.04022317f, -0.03055391f, 0.00508000f, -0.03595283f, -0.02973661f, -0.03316806f, 
    0.01305371f, 0.00352603f, -0.01882126f, 0.00491697f, -0.00154612f, 0.00839854f, -0.03968218f, 0.01112774f, 
    -0.00780568f, -0.02360862f, 0.01602444f, 0.01740157f, -0.00517543f, 0.01972858f, -0.03917137f, 0.01095652f, 
    -0.01138164f, 0.01502023f, -0.03989374f, -0.00187564f, 0.00566826f, -0.00728696f, 0.01364127f, 0.00851497f, 
    -0.02393475f, -0.02958204f, 0.00644823f, -0.01626668f, -0.00813848f, -0.00392570f, 0.00212774f, 0.01421996f, 
    -0.01213622f, 0.00908783f, 0.02753870f, 0.01411801f, -0.03602205f, -0.02649338f, -0.01109088f, 0.02353702f, 
    -0.00081464f, -0.03280834f, 0.03444761f, -0.04342515f, -0.02589080f, 0.01192347f, -0.02317128f, -0.01745088f, 
    -0.04262349f, -0.00248104f, -0.03826897f, 0.00533977f, -0.01986516f, -0.01131281f, 0.00116969f, 0.00677219f, 
    0.00408005f, 0.00548252f, -0.01227616f, -0.01315466f, -0.00915234f, -0.00476016f, -0.00749808f, 0.00941411f, 
    -0.02586996f, 0.02364503f, -0.00356425f, 0.01544288f, -0.00717873f, 0.01226940f, -0.01822406f, 0.02702508f, 
    -0.00061369f, 0.01441178f, 0.00132816f, -0.01121952f, 0.00515250f, -0.03353085f, 0.01623970f, -0.02856583f, 
    -0.00499925f, 0.02607634f, 0.01178355f, 0.01837579f, -0.00060574f, -0.03038661f, -0.03511493f, -0.01814449f, 
    -0.01850735f, 0.00700232f, 0.02196640f, -0.02439637f, 0.02268082f, 0.01765007f, 0.03473701f, -0.03726802f, 
    -0.03513543f, 0.01907599f, 0.00830754f, 0.01036678f, -0.03985147f, 0.00148067f, 0.01635617f, -0.02000071f, 
    -0.01590495f, -0.02492434f, -0.02578213f, -0.00957471f, 0.02484680f, -0.02381252f, -0.01376725f, -0.03748709f, 
    0.00166819f, -0.02756196f, -0.02101666f, -0.03550290f, -0.00875950f, -0.02931997f, -0.03433200f, -0.02981619f, 
    -0.03746614f, -0.00095794f, -0.02751050f, -0.00049629f, -0.01951771f, 0.01989555f, -0.03197129f, -0.04283518f, 
    -0.01010448f, 0.01370370f, 0.00680253f, -0.00083981f, -0.03412034f, -0.00775562f, -0.03705683f, 0.02416497f, 
    0.03199745f, -0.03898415f, 0.00909438f, 0.03024691f, 0.01263792f, -0.03261914f, -0.02149962f, -0.03347364f, 
    -0.24118814f, 0.04255230f, 0.01288126f, 0.07243745f, 0.10628332f, -0.00872668f, 0.06047669f, 0.03371617f, 
    0.19345771f, -0.06648148f, 0.24106814f, 0.00827824f, 0.28506061f, -0.08835907f, -0.12421755f, -0.14543809f, 
    0.13111578f, 0.02338000f, 0.12509915f, 0.07687149f, -0.07236683f, 0.01190287f, 0.06568804f, 0.11909799f, 
    0.00017454f, 0.14553753f, 0.01414233f, -0.08824176f, -0.06768450f, -0.07129117f, -0.09987833f, 0.16255525f, 
    -0.17795171f, 0.05628382f, -0.03203449f, 0.04662172f, -0.02435309f, 0.16715384f, -0.00557196f, 0.13189381f, 
    0.18308274f, 0.06156278f, -0.14603399f, 0.07348089f, 0.08494294f, 0.02860377f, -0.05596756f, 0.05706053f, 
    0.30571681f, 0.11814859f, -0.10676987f, -0.17459041f, 0.01850294f, -0.13513717f, -0.03906763f, -0.06746361f, 
    -0.02048829f, 0.04145339f, 0.00147439f, 0.03329486f, -0.17607605f, -0.29866844f, -0.16987523f, -0.13155195f, 
    -0.02874629f, 0.02721986f, -0.01973140f, -0.05819467f, -0.02034358f, -0.04269719f, 0.00953645f, 0.01981953f, 
    -0.22521387f, 0.03239038f, -0.08799801f, -0.03511586f, 0.02062821f, 0.08038445f, 0.01076060f, -0.13034901f, 
    0.09228425f, 0.05365753f, -0.05681539f, 0.07329249f, -0.35792044f, -0.09982028f, 0.02588104f, 0.02118772f, 
    0.00529539f, -0.08906241f, 0.11874697f, 0.00269993f, 0.01560790f, 0.13643333f, 0.07366032f, 0.04918325f, 
    -0.34448132f, -0.07756303f, -0.15256120f, 0.04797896f, 0.08854380f, 0.09250129f, 0.02542214f, -0.05288090f, 
    -0.00179331f, -0.02455017f, -0.05064853f, -0.02524339f, -0.04558891f, 0.01396148f, -0.01241689f, -0.03151151f, 
    0.01446707f, 0.00121023f, 0.02094578f, -0.01885572f, 0.04701309f, 0.11650603f, 0.04360056f, 0.00132942f, 
    0.27266526f, -0.17480211f, 0.00611685f, -0.23029424f, 0.06186508f, -0.18370567f, 0.00339211f, 0.17833775f, 
    0.15503886f, 0.04011991f, 0.05298593f, 0.05375721f, -0.13060087f, -0.07305782f, 0.00587599f, -0.04421376f, 
    0.13094346f, 0.17139104f, 0.03792976f, -0.00215681f, -0.00402285f, 0.01519578f, -0.00561193f, 0.01699732f, 
    -0.00872975f, 0.08918960f, -0.16670921f, -0.16738491f, 0.06019277f, -0.02115538f, -0.00879151f, 0.03332049f, 
    0.05929396f, 0.00060928f, -0.04939554f, 0.06342006f, 0.14509335f, -0.00189578f, -0.07072882f, 0.06675034f, 
    -0.05356726f, 0.03456646f, 0.17701238f, -0.06522155f, 0.07414560f, 0.04545786f, 0.00646817f, -0.02473749f, 
    -0.24789721f, -0.00157634f, -0.03961168f, 0.04304378f, -0.04645647f, 0.05066536f, 0.12081496f, 0.07810230f, 
    -0.08225981f, -0.04604576f, 0.09531885f, -0.01948030f, 0.31103963f, 0.06024850f, 0.04656842f, 0.17630531f, 
    -0.02755247f, -0.01297369f, -0.08671463f, -0.05608761f, 0.23743546f, 0.03740989f, -0.04389881f, 0.01819911f, 
    -0.30213583f, 0.15692064f, 0.19596988f, 0.12004034f, -0.06862056f, 0.00714550f, -0.05286790f, -0.02981872f, 
    -0.02062843f, -0.03097378f, 0.00252129f, 0.20343742f, 0.14183913f, -0.21248522f, 0.12817100f, 0.04773367f, 
    -0.00255025f, -0.07299300f, 0.04304868f, 0.03012892f, -0.03381203f, -0.07975660f, 0.23467013f, -0.07968196f, 
    0.18575023f, -0.17066261f, 0.19704792f, 0.29589400f, -0.03098181f, -0.14605612f, 0.05689567f, -0.10310718f, 
    0.31535107f, 0.35087532f, 0.04734468f, 0.05049194f, -0.12163880f, -0.11787751f, -0.52726728f, -0.22739170f, 
    -0.11425441f, -0.08139269f, 0.17827977f, 0.00796157f, 0.04476622f, -0.01449119f, -0.03909641f, 0.06323995f, 
    0.18058480f, -0.17851590f, -0.03572168f, -0.06803053f, 0.00955769f, 0.01415517f, 0.00440382f, -0.00936991f, 
    -0.05559141f, -0.10081512f, 0.00902720f, 0.19977228f, 0.06663859f, -0.11680937f, 0.11540587f, -0.06144150f, 
    0.03044237f, -0.09228332f, -0.02479899f, -0.02882109f, 0.11690180f, 0.18405955f, 0.02718921f, 0.14685738f, 
    0.01357942f, 0.00673208f, -0.20762502f, -0.08722892f, -0.13764206f, -0.01467806f, -0.16282420f, 0.04427637f, 
    0.01061636f, -0.00332181f, -0.08899096f, -0.01622862f, 0.33069909f, 0.21670467f, -0.10956882f, 0.00159447f, 
    0.07215073f, 0.01403636f, 0.00543019f, -0.00411922f, 0.04172869f, 0.13710998f, 0.04589206f, -0.05501164f, 
    0.01914586f, 0.10441202f, -0.06736055f, -0.02611365f, 0.03328725f, 0.09108331f, -0.03982608f, -0.01283748f, 
    0.14692679f, -0.08989595f, -0.02757519f, 0.15521485f, -0.00327246f, -0.09201913f, 0.12636003f, 0.00377838f, 
    -0.02052756f, -0.04505670f, -0.04514447f, -0.00508939f, -0.18234600f, 0.07102900f, 0.12964559f, -0.02906774f, 
    -0.04741583f, -0.10153600f, -0.04410370f, -0.07918516f, 0.11283036f, 0.18841095f, 0.14714278f, -0.01795748f, 
    -0.05065378f, 0.00138348f, -0.04308374f, 0.04028265f, 0.18137421f, -0.04209876f, 0.21139687f, -0.00580074f, 
    0.01621220f, -0.07832002f, -0.03459854f, 0.16552541f, 0.12848009f, 0.09892754f, 0.17501286f, 0.05959434f, 
    0.59138805f, -0.05877127f, -0.13698372f, -0.09132531f, 0.03102569f, 0.25087905f, -0.11842070f, -0.00110731f, 
    0.08222230f, -0.00879246f, 0.15027024f, 0.00150614f, 0.10014334f, -0.01950026f, 0.01525559f, -0.06930580f, 
    -0.03265616f, 0.01611264f, -0.01650634f, -0.04042243f, -0.08684754f, 0.08099853f, 0.09439536f, -0.18346748f, 
    0.22874755f, -0.00592162f, 0.03883744f, -0.08316118f, -0.04650228f, 0.07974561f, 0.04789962f, -0.01669771f, 
    0.17141946f, 0.11691920f, 0.05353896f, -0.09729496f, 0.26315647f, -0.17173415f, 0.24826907f, 0.05838621f, 
    -0.07119812f, 0.04717815f, -0.00098806f, -0.07142248f, -0.01222995f, 0.00599326f, 0.14620827f, 0.20045748f, 
    -0.11652459f, -0.21947916f, -0.28771576f, -0.07890286f, -0.11209749f, -0.05624894f, 0.10509585f, 0.12995358f, 
    -0.04411563f, -0.02288931f, -0.01403667f, 0.02220819f, -0.05457098f, -0.07890668f, -0.15266758f, 0.12401574f, 
    -0.15132374f, 0.01136652f, 0.12736391f, 0.08723370f, -0.02636710f, -0.00183128f, -0.01607174f, 0.01744758f, 
    -0.02064155f, 0.00450835f, -0.02864331f, 0.14873654f, -0.06144516f, -0.28713742f, 0.03450553f, 0.23745242f, 
    0.13748027f, -0.10662035f, -0.02545520f, 0.02849578f, -0.10241749f, 0.00816233f, -0.08264961f, 0.01656423f, 
    -0.03212513f, -0.16951479f, 0.10540817f, -0.12367154f, 0.16443157f, 0.03125196f, 0.04124501f, 0.01263246f, 
    0.48250949f, -0.21557942f, 0.08787175f, -0.01634987f, -0.12387481f, -0.24452882f, 0.03509164f, 0.03949698f, 
    0.13825753f, 0.19091244f, 0.15918958f, -0.08111300f, 0.16971233f, -0.18724592f, 0.08885260f, 0.05674814f, 
    -0.07732036f, -0.05117590f, -0.00877192f, -0.10603996f, 0.05798818f, 0.06965808f, 0.24222407f, -0.07069305f, 
    0.17087509f, -0.05904527f, 0.07031871f, 0.29054260f, 0.04322651f, 0.09958327f, -0.00136303f, -0.04593616f, 
    0.00690876f, 0.05975386f, 0.04784114f, 0.01345704f, 0.27912110f, -0.14849427f, -0.14803264f, -0.03045520f, 
    0.17809805f, -0.07866216f, 0.19794674f, -0.01034123f, 0.15896642f, -0.01778576f, -0.03438282f, 0.07387818f, 
    0.45718008f, -0.10657715f, -0.10233222f, -0.14606759f, -0.01595143f, 0.13418512f, 0.05385543f, -0.05058191f, 
    0.09430917f, -0.01833870f, 0.10536984f, -0.05491420f, -0.16542584f, 0.05449153f, -0.22909209f, 0.19044462f, 
    0.09961027f, 0.10092198f, 0.14745474f, 0.06112047f, 0.09172180f, 0.06374468f, -0.06184360f, -0.06330158f, 
    0.07811070f, 0.01322126f, 0.08249421f, 0.06113104f, -0.00267040f, 0.03652230f, -0.00111070f, 0.10928344f, 
    0.07168821f, 0.00113831f, 0.08743139f, 0.03766236f, -0.10313656f, -0.01754510f, 0.03256527f, 0.05686395f, 
    -0.00832333f, -0.03647482f, -0.04461999f, 0.04398103f, -0.02297105f, 0.03241640f, -0.02664182f, -0.02182992f, 
    -0.33248478f, 0.05352817f, -0.23201121f, 0.11514078f, 0.09293556f, 0.08460735f, 0.42150933f, 0.08414516f, 
    0.06249819f, -0.06729818f, 0.02900323f, 0.00792671f, -0.01077212f, -0.09250891f, -0.06481858f, -0.06377731f, 
    0.03472949f, 0.12975328f, -0.08783299f, 0.15645216f, -0.02782552f, 0.05228169f, 0.02880922f, -0.21331540f, 
    0.02781698f, -0.23635341f, 0.04970099f, -0.03215729f, 0.02122944f, 0.09756335f, 0.11370514f, 0.14503162f, 
    -0.01220111f, -0.13265173f, 0.10007481f, -0.03766238f, -0.00201253f, 0.10864932f, -0.00746992f, 0.05096618f, 
    0.02904429f, 0.20615561f, 0.08807819f, 0.25156114f, 0.05603651f, -0.03191483f, -0.05282513f, 0.01305842f, 
    -0.23354746f, 0.08905081f, -0.12036073f, -0.17154275f, 0.00755584f, -0.00235630f, 0.10419948f, 0.01229926f, 
    -0.02713020f, -0.00698706f, 0.04874136f, -0.02976785f, -0.38872337f, -0.36969289f, -0.40171096f, -0.12366158f, 
    -0.09938333f, -0.10843682f, -0.08602858f, 0.09557486f, -0.06539793f, -0.02267759f, -0.02101971f, 0.01414369f, 
    -0.00062004f, -0.05253116f, -0.03521447f, -0.13602358f, 0.03995628f, -0.09068447f, 0.04159949f, -0.07240224f, 
    0.09731770f, 0.13938713f, 0.11865508f, 0.00764828f, -0.16113278f, 0.25480479f, 0.16780342f, -0.02700697f, 
    0.02502912f, 0.03084725f, -0.10799669f, 0.08765895f, 0.09334517f, 0.05419007f, -0.10153446f, 0.18575709f, 
    -0.00199892f, -0.17976853f, -0.15913816f, -0.07360037f, -0.08657023f, -0.20998584f, 0.06641277f, 0.07587336f, 
    0.05893111f, 0.15564193f, 0.06427468f, 0.17901722f, 0.05510648f, -0.11669162f, 0.18704619f, -0.10586897f, 
    -0.10927740f, 0.07370369f, 0.07193035f, 0.14546064f, 0.06145881f, -0.03581241f, -0.04928203f, 0.13106708f, 
    -0.20900077f, -0.02425151f, -0.06043515f, -0.02495651f, 0.01368977f, 0.04139324f, 0.04186671f, -0.01457042f, 
    -0.22709070f, 0.10954657f, -0.01799458f, -0.03153464f, 0.06624618f, 0.02101947f, -0.09920206f, -0.01220529f, 
    -0.14287375f, 0.05715486f, -0.08616603f, 0.02017053f, 0.25147241f, 0.17031567f, 0.15661319f, 0.09539118f, 
    0.17926404f, -0.03276923f, 0.13075447f, -0.05436872f, 0.00970974f, -0.01478045f, -0.03429263f, -0.06268557f, 
    -0.01870741f, 0.05505233f, -0.00758567f, 0.03302623f, 0.06026247f, -0.15935618f, 0.09469493f, -0.12856147f, 
    -0.00465040f, 0.18480530f, -0.11316097f, 0.17411749f, -0.00083515f, 0.07436068f, 0.03932757f, 0.03535877f, 
    0.18568362f, -0.20207605f, -0.01493654f, -0.09178222f, -0.02293042f, 0.05788876f, 0.11510543f, 0.13956600f, 
    -0.00473321f, -0.03674271f, -0.03603796f, -0.00933273f, -0.12020922f, -0.17899130f, -0.16934410f, -0.03857702f, 
    -0.02675650f, 0.02997166f, 0.18125936f, 0.17676093f, 0.00573626f, -0.06601766f, 0.00169016f, -0.03727018f, 
    0.01865222f, 0.12780935f, 0.35940894f, 0.07825989f, 0.09227019f, 0.05880151f, 0.19622454f, -0.06163294f, 
    0.00219395f, 0.33298954f, -0.07354821f, -0.08188539f, -0.04868933f, -0.02926372f, -0.05007946f, -0.20263092f, 
    -0.08260671f, 0.02785266f, 0.00650096f, -0.06186653f, -0.03173107f, -0.00349400f, 0.17436290f, -0.13963640f, 
    -0.16266327f, 0.16879499f, -0.03938232f, -0.02015667f, -0.01804935f, 0.08457690f, 0.19020762f, -0.06233296f, 
    -0.05291390f, -0.03760399f, 0.05045331f, 0.02036131f, 0.15947372f, -0.05823376f, -0.11123143f, -0.07818875f, 
    0.05748845f, 0.03907715f, 0.14447038f, 0.16325109f, 0.03558479f, -0.03534786f, -0.02337877f, 0.07336634f, 
    0.22350131f, 0.01055198f, 0.07506308f, 0.28938842f, -0.08152717f, -0.21930426f, 0.00168908f, -0.06545348f, 
    -0.11035348f, 0.04756868f, 0.14822310f, 0.00116679f, -0.28743628f, 0.10216875f, 0.03133962f, 0.17727338f, 
    0.06529575f, -0.11511225f, 0.13306381f, 0.12037827f, -0.08644021f, 0.02708159f, -0.19094306f, 0.14069080f, 
    0.06725689f, 0.18195307f, 0.13889369f, 0.14066216f, 0.03438043f, -0.02446556f, 0.12578756f, -0.08062416f, 
    0.22101419f, 0.10279061f, -0.11785261f, -0.07581499f, 0.34367341f, 0.06013061f, 0.26271391f, 0.13544732f, 
    -0.01708592f, -0.07132179f, 0.09848873f, -0.10269743f, -0.02484974f, -0.04574914f, -0.17501616f, -0.03357277f, 
    0.28333443f, -0.09987661f, 0.06125437f, 0.08262961f, 0.00895479f, 0.11303893f, -0.00876395f, -0.06036318f, 
    -0.09210249f, 0.01726314f, 0.01884178f, -0.15797460f, 0.05014224f, -0.03140705f, -0.08106162f, 0.00778127f, 
    -0.08164133f, -0.02710357f, 0.00494818f, -0.02925662f, -0.07347839f, -0.03767627f, -0.11227703f, -0.06198785f, 
    -0.12395608f, -0.01614640f, 0.04429248f, -0.20057273f, -0.00378502f, -0.10936886f, -0.11288182f, 0.15253066f, 
    -0.14717785f, -0.13340899f, -0.05751173f, -0.13395721f, 0.04891785f, 0.16308184f, 0.04563839f, 0.11416055f, 
    0.13434361f, 0.13546631f, -0.14655408f, 0.12084682f, -0.11421576f, -0.18868451f, -0.18664587f, -0.28565368f, 
    0.03305769f, -0.17429815f, 0.17271055f, 0.04596048f, -0.00520326f, -0.01737753f, -0.07844281f, 0.13124040f, 
    -0.11376954f, -0.09618052f, -0.02086809f, -0.22754931f, 0.02112237f, -0.11117118f, -0.06211113f, 0.14405003f, 
    0.01427654f, 0.04082394f, -0.01822693f, -0.09065883f, -0.14375950f, -0.13013263f, -0.04580006f, -0.21706283f, 
    0.04766396f, -0.12576716f, 0.10581099f, 0.38812056f, 0.04192171f, 0.04226273f, -0.13052064f, 0.03103601f, 
    0.08481114f, -0.06616681f, 0.01700194f, 0.03952455f, 0.08592008f, 0.05517624f, 0.06239785f, 0.29139158f, 
    0.01878163f, 0.01724857f, 0.18192892f, -0.05555657f, 0.01888371f, -0.00401270f, -0.21235999f, -0.08314815f, 
    -0.01231616f, -0.10122479f, 0.15929961f, -0.05018459f, -0.07408712f, -0.06991523f, -0.06247852f, 0.10587990f, 
    0.02453140f, -0.08991584f, -0.07060149f, 0.02024898f, -0.31044546f, -0.12645656f, 0.17151137f, 0.24403882f, 
    0.06983432f, -0.07000106f, 0.02276847f, 0.14975965f, -0.14741333f, 0.05253079f, 0.06386598f, 0.02448823f, 
    -0.03533932f, 0.13213818f, 0.02352615f, 0.15572684f, 0.03996932f, 0.17626572f, -0.08958403f, -0.17825495f, 
    -0.13811164f, -0.01827292f, -0.05396369f, 0.05075951f, -0.40662220f, 0.15089688f, -0.06741669f, -0.34533048f, 
    0.08959074f, -0.14743087f, 0.04955899f, 0.13049272f, -0.09068990f, 0.24801067f, 0.01944808f, -0.13059846f, 
    -0.42578009f, 0.13430236f, -0.03580730f, -0.23177694f, 0.00148055f, -0.09395342f, -0.07347307f, 0.12127891f, 
    0.06266434f, -0.00041545f, 0.09096536f, 0.32642299f, -0.16599405f, 0.15728858f, -0.24313059f, 0.09235424f, 
    -0.08304894f, 0.09168751f, 0.11785612f, -0.03956233f, 0.22303708f, 0.21851705f, 0.12756908f, 0.54972088f, 
    -0.25438091f, 0.21328473f, -0.03940771f, 0.13918318f, 0.01344588f, -0.04381167f, -0.07725509f, 0.10342612f, 
    -0.07369141f, 0.11443552f, -0.00087091f, 0.19130480f, 0.18051127f, 0.05465114f, 0.21929717f, 0.05461410f, 
    0.06705052f, 0.00451982f, -0.11708443f, 0.23404785f, 0.01421540f, 0.06444222f, 0.00966982f, -0.26632515f, 
    0.16887966f, 0.34293628f, -0.02936218f, 0.22804721f, 0.13665251f, 0.02284125f, 0.09974600f, -0.24067275f, 
    0.04671656f, 0.05542083f, -0.21311535f, -0.05495708f, -0.03795367f, 0.03505043f, 0.04541712f, -0.04549962f, 
    0.13874070f, -0.00905018f, -0.02238274f, -0.13352339f, -0.15219204f, 0.05055723f, -0.08289325f, -0.14036921f, 
    0.13059589f, -0.22131760f, -0.15925163f, 0.05350328f, -0.01489934f, -0.03057928f, 0.03777141f, -0.13000008f, 
    -0.07896794f, -0.03037455f, -0.10696582f, -0.00971121f, 0.20955288f, 0.05050211f, 0.27145997f, -0.23847274f, 
    0.05306624f, 0.03444248f, -0.02186120f, -0.03426208f, 0.06922781f, -0.11571693f, 0.21355236f, -0.13639884f, 
    0.14693967f, -0.07071944f, 0.11592759f, 0.03150962f, -0.03161564f, -0.02456990f, -0.06944299f, 0.10656765f, 
    -0.02359114f, -0.01709812f, -0.11892726f, 0.03990181f, -0.18659523f, 0.09421699f, -0.26758999f, 0.00771115f, 
    -0.10151444f, -0.09830079f, 0.02947348f, -0.02711325f, 0.20223302f, 0.31389874f, 0.22551663f, 0.28502804f, 
    -0.24669918f, 0.07762831f, 0.14742443f, 0.31797835f, 0.07840353f, 0.02156502f, 0.05545687f, -0.07694405f, 
    0.00136472f, 0.02490870f, -0.12041315f, 0.11549322f, -0.14027597f, -0.08959142f, -0.03826792f, 0.16435297f, 
    -0.01778344f, -0.09910479f, 0.13933109f, -0.19754092f, -0.08810841f, 0.02875974f, -0.06206445f, -0.03165837f, 
    0.17647344f, -0.03211494f, -0.07357328f, 0.00858082f, -0.09628193f, -0.18833397f, 0.15062907f, -0.13571575f, 
    0.02037461f, 0.06990312f, -0.07652198f, 0.08349637f, -0.06984502f, -0.11471210f, -0.20672877f, -0.28693444f, 
    -0.08725341f, 0.13572417f, 0.16741075f, -0.05669248f, 0.20321289f, 0.05965235f, 0.08302955f, 0.14422633f, 
    -0.16053849f, 0.15231752f, 0.14473367f, 0.00880088f, 0.08631913f, -0.05368224f, -0.10458931f, -0.14706516f, 
    0.01827804f, 0.04044216f, 0.14257602f, 0.05929628f, 0.00424315f, 0.45419681f, 0.06097658f, 0.33252424f, 
    0.04606965f, -0.05240339f, -0.05713822f, 0.00712531f, 0.06007309f, 0.00514509f, -0.13367075f, 0.12135491f, 
    0.15173502f, 0.05317179f, 0.00725814f, -0.00733824f, -0.07310614f, 0.06432544f, -0.06564931f, 0.16021495f, 
    -0.00505067f, -0.02552817f, 0.00073196f, -0.07286160f, 0.24060531f, -0.28480291f, 0.02673811f, -0.12683509f, 
    0.03646665f, -0.02119103f, -0.01772331f, 0.04122305f, 0.03815093f, -0.02006608f, 0.08677538f, 0.04242884f, 
    0.25357634f, 0.21980979f, 0.24851100f, 0.29944384f, 0.03643600f, 0.04793933f, 0.14150895f, -0.06346117f, 
    -0.05166769f, 0.12480099f, 0.14285259f, -0.15758651f, 0.08157774f, -0.02091218f, 0.10680552f, 0.04236320f, 
    -0.03911415f, -0.05255551f, 0.03756165f, 0.04337345f, -0.22637002f, -0.13100733f, -0.17614196f, -0.31561339f, 
    -0.01301884f, -0.03425757f, -0.21972503f, 0.18445934f, 0.09524154f, 0.17965735f, -0.20222488f, 0.02812142f, 
    -0.04851319f, 0.12775828f, 0.22629744f, 0.15159974f, 0.07871798f, 0.11747007f, -0.24110277f, -0.05723238f, 
    -0.02758733f, -0.09131057f, 0.02810691f, 0.22232835f, -0.06955558f, 0.01097457f, 0.07271028f, -0.05554181f, 
    0.02120083f, -0.01097999f, 0.10525007f, 0.19079189f, -0.00913219f, 0.07594357f, 0.03323756f, 0.27056977f, 
    0.00995544f, 0.17577307f, 0.16587469f, 0.25633737f, 0.04537258f, 0.04889607f, 0.10480507f, 0.19508247f, 
    0.11052421f, 0.03791067f, -0.16870281f, 0.09109362f, -0.04690838f, 0.09078491f, 0.01264188f, -0.00397102f, 
    0.00479661f, 0.17699571f, -0.22638983f, -0.03435865f, -0.02601010f, 0.02226747f, -0.04711670f, -0.11032993f, 
    -0.06157682f, 0.06458113f, -0.05625712f, 0.23356870f, -0.08709785f, -0.01820026f, 0.12992135f, -0.18298107f, 
    0.04999258f, -0.02169275f, 0.01521699f, 0.11629448f, 0.02074247f, 0.06496535f, 0.09249780f, 0.30071872f, 
    0.12538041f, 0.15301557f, 0.26703182f, 0.19739097f, 0.05127217f, -0.02678287f, -0.09483141f, 0.02147844f, 
    -0.07964394f, -0.05431227f, -0.07741185f, -0.11817396f, 0.03584471f, 0.08145794f, 0.13108267f, 0.17918125f, 
    0.03125279f, 0.16195227f, 0.11654774f, -0.07015057f, 0.00075429f, 0.04872041f, 0.12177206f, 0.04728095f, 
    0.07201165f, 0.22189339f, 0.15555730f, 0.05304850f, -0.01001102f, 0.14888559f, -0.17504789f, -0.01900061f, 
    -0.17570348f, -0.07610467f, -0.09314642f, -0.31425384f, 0.33782199f, -0.06469619f, 0.08325160f, 0.33922389f, 
    -0.01888773f, -0.00346358f, -0.00571290f, 0.17298639f, 0.05911670f, 0.07500292f, 0.34366974f, 0.19826064f, 
    -0.08029619f, 0.03813353f, -0.13650467f, 0.20321959f, -0.00196208f, -0.01232208f, -0.01515151f, -0.03805117f, 
    0.18892348f, 0.14895441f, 0.17980626f, 0.31804690f, 0.16254407f, 0.14917569f, 0.31369522f, 0.22391491f, 
    0.08988956f, -0.10142849f, 0.04519649f, -0.02233929f, -0.00268766f, 0.05305032f, -0.07430972f, -0.04972594f, 
    -0.12264076f, -0.27543363f, -0.03056767f, 0.23630507f, -0.08587516f, 0.00069770f, 0.06906900f, 0.04400899f, 
    -0.03148913f, 0.09799767f, -0.20687018f, -0.26914832f, 0.20084737f, 0.09140120f, 0.07735996f, 0.06511462f, 
    -0.02621326f, -0.07453241f, -0.01626969f, 0.00401761f, -0.06291885f, -0.09433711f, -0.08611587f, -0.23413621f, 
    -0.08203914f, -0.03219050f, -0.05173215f, -0.16204718f, 0.12574917f, -0.10354168f, -0.08379773f, 0.09867445f, 
    -0.20860171f, 0.05057634f, 0.02596123f, -0.22796172f, -0.09987903f, 0.09399512f, 0.10615187f, -0.11985923f, 
    -0.00978960f, 0.06848634f, 0.08299894f, -0.15914193f, -0.05561655f, -0.19946070f, 0.05186967f, 0.02467366f, 
    0.18782762f, 0.11364606f, 0.02302667f, 0.19375756f, 0.06367677f, -0.00198206f, -0.01250745f, -0.02912788f, 
    -0.23155710f, 0.05284102f, -0.32840094f, -0.23692185f, -0.03773658f, 0.05937809f, 0.00900236f, 0.32792822f, 
    0.06429625f, -0.03225084f, 0.09174606f, 0.00583865f, -0.11688016f, -0.04018297f, -0.18029687f, -0.10144449f, 
    0.33313656f, -0.01929471f, -0.03607495f, -0.07019711f, -0.07256733f, 0.08939344f, 0.24990791f, 0.03447034f, 
    0.28740251f, 0.23129024f, 0.17932533f, 0.37464195f, 0.06432193f, 0.31968161f, 0.17417185f, -0.12097253f, 
    0.08953142f, 0.02687982f, -0.06173587f, 0.12706238f, -0.10504507f, -0.06243654f, -0.01250325f, -0.13834198f, 
    0.02949532f, -0.11962793f, -0.18988250f, -0.18983258f, 0.05980443f, 0.04246818f, -0.01167072f, 0.02063703f, 
    0.07176030f, 0.07555816f, 0.07959604f, -0.02852466f, -0.08655685f, 0.02621730f, -0.09617357f, 0.11123839f, 
    0.01754828f, 0.09846546f, -0.03141612f, -0.30297929f, 0.00864432f, -0.10730360f, -0.22263421f, -0.07432576f, 
    -0.07757834f, 0.00493934f, -0.27943671f, 0.08742229f, -0.07403711f, -0.08544061f, -0.01918499f, -0.05395984f, 
    0.02344045f, 0.04418122f, 0.02830977f, 0.18344228f, 0.05023260f, 0.03908052f, 0.11374721f, 0.08776163f, 
    -0.10646320f, 0.01844638f, -0.08782320f, 0.14536174f, 0.13269402f, 0.10550503f, 0.22574526f, -0.00637582f, 
    -0.48868918f, -0.04616985f, -0.13133574f, 0.63796353f, 0.12886339f, -0.04672715f, -0.06672887f, 0.11538775f, 
    -0.16316272f, 0.01762166f, 0.11907919f, 0.02207011f, -0.09367764f, 0.05923550f, 0.02332863f, 0.01140566f, 
    0.04527540f, -0.05197806f, 0.03003855f, 0.05009306f, -0.15131602f, -0.17782886f, -0.05351052f, -0.23279446f, 
    0.39186841f, 0.09541579f, -0.01862318f, 0.14713906f, -0.07126474f, 0.13864641f, -0.04494311f, 0.08190865f, 
    -0.03381281f, 0.02710010f, -0.04517846f, -0.22546458f, -0.10698290f, -0.14637575f, -0.12389189f, 0.09520802f, 
    0.01708474f, 0.07065069f, 0.19283025f, -0.03529090f, 0.02332647f, 0.09930903f, 0.10849951f, 0.13594764f, 
    -0.05591555f, -0.06712607f, -0.15370673f, -0.33039069f, 0.02873995f, -0.15527248f, -0.07927970f, -0.09902154f, 
    0.05943981f, 0.01443967f, 0.17781390f, 0.14506108f, 0.28840706f, -0.11873908f, 0.06802242f, -0.13666050f, 
    0.13748378f, -0.13659598f, 0.02385502f, -0.01054057f, 0.10843580f, -0.01431328f, -0.06831358f, 0.07435543f, 
    0.08031068f, 0.24126558f, 0.13601612f, -0.21131010f, -0.06979401f, -0.06929957f, -0.05737319f, -0.01825516f, 
    -0.02471874f, 0.05369879f, -0.10868493f, 0.03033342f, -0.19036995f, -0.04414259f, -0.00438225f, 0.13160039f, 
    0.03889259f, -0.06680056f, 0.19425131f, -0.00904257f, 0.03573565f, -0.04933875f, -0.08673797f, 0.06549936f, 
    0.12769331f, -0.20642358f, 0.27731159f, 0.16941646f, -0.04107873f, 0.09750585f, 0.03967590f, 0.07849310f, 
    0.12185664f, 0.01212346f, 0.07533725f, -0.02779637f, 0.09368736f, 0.06562588f, -0.04151294f, -0.02878908f, 
    0.17437690f, 0.07164034f, 0.10367253f, -0.13760014f, 0.01925256f, -0.05178777f, -0.08191942f, 0.02291374f, 
    0.21190922f, -0.06501992f, -0.01991583f, -0.00555885f, 0.05202367f, -0.09070721f, 0.01666858f, 0.08815899f, 
    0.09620272f, 0.04866387f, -0.01794355f, -0.13066104f, -0.08586858f, 0.12507674f, -0.07382116f, -0.40159822f, 
    0.17495883f, -0.05407135f, -0.11271493f, -0.10095384f, 0.06380085f, 0.13988979f, -0.11565607f, -0.13054958f, 
    0.17669487f, -0.03296521f, -0.36040294f, -0.05830614f, 0.16263470f, 0.04999296f, 0.03201945f, 0.02517997f, 
    -0.07443217f, -0.02601471f, -0.09838266f, -0.00821011f, 0.01956483f, -0.11838606f, -0.01976599f, 0.17928062f, 
    -0.10904121f, -0.01045729f, 0.00941109f, -0.10410286f, 0.01593755f, 0.09709802f, 0.06750114f, -0.00701584f, 
    -0.02085751f, 0.00832705f, -0.04420389f, -0.02844509f, -0.05376632f, -0.09969597f, -0.00308793f, -0.02104814f, 
    0.04498959f, 0.10883544f, -0.12744097f, 0.05565551f, 0.18520141f, -0.14797574f, -0.11644995f, -0.03266034f, 
    0.14707319f, 0.10275327f, 0.12085185f, 0.07399210f, 0.00891529f, 0.01229236f, -0.01629950f, -0.00656447f, 
    0.21320178f, -0.11899944f, -0.00381647f, 0.18925893f, 0.15929066f, 0.16478671f, -0.00611906f, 0.07249197f, 
    0.12760833f, -0.05178518f, -0.12289406f, -0.14245461f, -0.04325354f, 0.03895449f, -0.14510339f, -0.20949650f, 
    -0.08081889f, -0.06363551f, 0.01926189f, 0.11610063f, -0.10380605f, -0.01305430f, 0.07919987f, 0.02513698f, 
    -0.01927084f, 0.02382426f, -0.10967790f, -0.38583490f, 0.17065182f, 0.01875961f, 0.13605016f, -0.03910908f, 
    0.01955013f, 0.02107230f, -0.01274119f, 0.09354229f, -0.03823987f, -0.02365157f, 0.07443198f, -0.05978737f, 
    0.07107227f, -0.07003166f, -0.12317000f, 0.10541867f, -0.08297064f, 0.19138078f, 0.06419729f, 0.07880008f, 
    -0.02366093f, 0.03948452f, -0.26082769f, -0.14313526f, 0.04828703f, -0.06299850f, -0.03611628f, -0.00225970f, 
    -0.03242150f, 0.05151927f, 0.19018038f, 0.00426866f, 0.05126802f, -0.17732200f, 0.16726561f, -0.04346365f, 
    -0.01065406f, -0.05420471f, 0.04165215f, 0.08715130f, 0.00458774f, -0.01137224f, 0.12350152f, -0.12543669f, 
    -0.24995615f, 0.19477484f, -0.31094232f, -0.13548248f, 0.00836033f, 0.16141377f, -0.13133609f, 0.13205275f, 
    -0.06923646f, -0.01291736f, -0.02369593f, 0.24024789f, 0.04058421f, -0.08932046f, 0.08719117f, -0.07660993f, 
    0.13954780f, -0.12028139f, -0.05918386f, -0.00992634f, 0.10351212f, -0.00151601f, -0.01434296f, -0.09073302f, 
    -0.21782443f, -0.22522072f, 0.01541060f, 0.09046976f, -0.11456975f, -0.02651316f, 0.00928513f, -0.10735060f, 
    0.07213570f, 0.01845440f, 0.01754905f, -0.11064594f, -0.06222458f, -0.22043489f, 0.23780559f, 0.18613204f, 
    0.04706073f, -0.02616893f, -0.07128634f, -0.05060795f, 0.21590120f, -0.08003613f, 0.11130708f, -0.05225154f, 
    -0.17645000f, -0.02809339f, -0.05823344f, -0.34132683f, 0.15769519f, 0.01267458f, 0.05970205f, -0.16219522f, 
    0.00434630f, -0.00013706f, -0.02942755f, -0.02996385f, 0.15131478f, -0.23608065f, 0.47661468f, 0.19395189f, 
    0.08671398f, 0.04402481f, 0.07046393f, 0.03486342f, 0.11052824f, -0.15887262f, 0.08597498f, 0.04590683f, 
    0.11748558f, -0.09022432f, 0.09181353f, 0.03420733f, 0.19997363f, -0.00798615f, -0.08341420f, 0.06492283f, 
    0.19401762f, 0.24081969f, -0.02538662f, 0.08280382f, -0.09983451f, -0.12290994f, -0.05351536f, -0.02983249f, 
    0.02221126f, 0.06036665f, 0.08027336f, 0.05853841f, 0.26614925f, 0.02261445f, 0.20068814f, -0.06055978f, 
    -0.11024420f, -0.28223667f, -0.02334628f, -0.04550518f, 0.02584613f, 0.09197099f, 0.04786326f, -0.04984447f, 
    0.03551173f, 0.08076027f, -0.02720189f, -0.14950871f, -0.20348909f, 0.12663947f, 0.08977492f, -0.02459693f, 
    0.05468779f, 0.08179389f, 0.18463309f, -0.08981401f, 0.14851584f, 0.11263137f, 0.05074988f, 0.07849316f, 
    0.50874490f, -0.02984781f, 0.09688871f, 0.22038090f, 0.16740319f, -0.03575627f, 0.25489438f, 0.16795456f, 
    0.02707319f, -0.01108781f, -0.06495123f, 0.11491856f, -0.07391663f, 0.02079085f, -0.01874416f, -0.07248697f, 
    0.05700563f, 0.04505461f, 0.10009884f, -0.03483875f, 0.15154326f, -0.03631348f, 0.09698769f, -0.07108375f, 
    -0.21497209f, 0.09726162f, 0.18636705f, -0.16137391f, 0.14327282f, 0.02768475f, 0.05177948f, -0.02447802f, 
    0.13365744f, 0.03002830f, 0.16589054f, -0.06963799f, -0.50601184f, 0.09947030f, 0.18013200f, 0.12985018f, 
    0.06700062f, -0.13779731f, -0.19022900f, -0.00612125f, 0.09386511f, 0.15663011f, 0.05865080f, 0.02766825f, 
    0.03049496f, 0.10351750f, 0.11609212f, -0.18438222f, 0.08111642f, -0.08374894f, -0.05100306f, -0.22361542f, 
    0.02032514f, -0.03828285f, 0.00924376f, 0.06544412f, -0.24911739f, 0.11679866f, 0.19474827f, -0.22522047f, 
    0.17320481f, 0.04256701f, 0.18956643f, -0.08440000f, 0.00296933f, 0.00246962f, 0.08527684f, 0.14962699f, 
    0.33623245f, 0.23015632f, -0.26453647f, -0.03257500f, -0.01444570f, 0.01521794f, 0.16424894f, 0.09454882f, 
    -0.08280264f, -0.03706013f, -0.02923405f, -0.08322871f, 0.06017202f, -0.17074651f, -0.06891037f, -0.15700032f, 
    0.20610993f, 0.00619188f, -0.00256243f, 0.04237071f, -0.05007350f, -0.05509277f, -0.03127980f, 0.05849559f, 
    -0.37758040f, 0.12394985f, -0.08200557f, -0.07390921f, 0.00342035f, 0.03455353f, 0.05113040f, -0.05896644f, 
    -0.06810687f, -0.00394695f, 0.15091681f, 0.04609121f, -0.15349020f, 0.02489588f, 0.05313409f, -0.10599553f, 
    -0.10271496f, -0.00566859f, -0.07168914f, 0.06714473f, 0.11530736f, 0.06849343f, 0.03894949f, 0.20631266f, 
    -0.16345859f, -0.01450466f, 0.08060699f, -0.08786810f, -0.02913581f, -0.04607068f, -0.05970547f, 0.15426341f, 
    0.04417491f, -0.02033771f, 0.19162817f, 0.14152014f, 0.24921089f, -0.16662839f, 0.23857230f, -0.04622268f, 
    0.11677469f, -0.07884897f, 0.00769853f, 0.09538062f, -0.00611994f, -0.01008894f, 0.10960460f, 0.00850907f, 
    -0.07094950f, -0.05099517f, 0.16507997f, 0.07838126f, 0.10092738f, -0.07391261f, 0.02768495f, 0.09518412f, 
    0.04900035f, 0.20267668f, 0.02140162f, 0.17829803f, 0.18042403f, 0.13870588f, 0.08155657f, -0.17228110f, 
    0.06272612f, 0.00621729f, 0.07579663f, 0.21940847f, 0.02341660f, 0.19438359f, 0.14604110f, 0.03402491f, 
    -0.18480007f, 0.01100853f, 0.04671316f, -0.08790877f, -0.04256084f, 0.06854498f, -0.06799370f, -0.05137450f, 
    -0.06850109f, -0.03924352f, 0.02734588f, -0.06163632f, 0.14826044f, -0.03255628f, -0.13953331f, -0.02873737f, 
    0.14078240f, 0.16946904f, 0.13788940f, 0.02754255f, -0.00161761f, -0.08341451f, -0.09853854f, -0.08158089f, 
    0.10261082f, 0.14497826f, -0.12331115f, -0.18966217f, 0.11719426f, 0.05166863f, -0.02701053f, -0.05173449f, 
    -0.06745830f, 0.10879895f, -0.07910283f, -0.01853221f, -0.38462052f, 0.15269251f, -0.19016020f, -0.24966890f, 
    -0.16722780f, -0.03572845f, 0.05956761f, 0.14129761f, 0.14392962f, -0.06339774f, 0.08095473f, -0.08193348f, 
    -0.17782620f, 0.06763109f, -0.06376062f, -0.03574817f, -0.01704529f, 0.00582745f, 0.09142351f, 0.07780855f, 
    0.18872836f, -0.00715920f, -0.01256990f, 0.04564603f, -0.19666591f, -0.06615590f, 0.11924350f, -0.23801170f, 
    0.02606401f, 0.03806987f, -0.10161529f, 0.00130946f, -0.02016748f, -0.02174777f, 0.03326433f, -0.05253053f, 
    0.08249546f, -0.08070935f, -0.16689537f, -0.05195902f, 0.04628430f, -0.06979445f, -0.05584276f, 0.05651043f, 
    -0.02300997f, 0.00589208f, -0.00448641f, 0.07891165f, 0.03934572f, 0.05709254f, 0.01577220f, -0.13080077f, 
    0.02774380f, -0.04708198f, 0.05807445f, -0.15290913f, -0.06356688f, -0.12745039f, -0.10324546f, -0.12316082f, 
    -0.14961727f, -0.09598787f, 0.07043099f, -0.10369627f, -0.05236952f, -0.03827324f, -0.08811267f, -0.01491509f, 
    0.04190831f, 0.04963689f, 0.18753982f, 0.18552886f, 0.13763781f, -0.03787579f, -0.10533632f, 0.02762970f, 
    -0.02328183f, 0.02478589f, 0.12943611f, -0.02597588f, 0.10694876f, 0.02011738f, 0.13584717f, -0.00135008f, 
    -0.06049668f, -0.15172580f, 0.23894796f, 0.10975235f, 0.01945926f, 0.02863020f, -0.06470791f, 0.05354843f, 
    0.17276481f, -0.09068772f, -0.03753997f, -0.05942369f, 0.01004738f, 0.06534790f, -0.13774340f, 0.06126366f, 
    0.02292849f, 0.06502559f, 0.15614206f, -0.05701057f, -0.01233617f, 0.05129265f, 0.04763784f, -0.02522975f, 
    -0.25958124f, -0.06843372f, -0.11481410f, 0.06522667f, -0.07470780f, -0.06040077f, 0.09584308f, 0.21170197f, 
    0.06742586f, 0.16807182f, 0.11075583f, -0.01609397f, -0.38972923f, 0.04695763f, -0.11709531f, 0.30352119f, 
    0.06115540f, -0.00437897f, -0.22270781f, -0.03292153f, 0.06527878f, 0.05962326f, 0.21157290f, -0.16973154f, 
    -0.07532690f, -0.04667971f, -0.01778912f, 0.14346386f, 0.01614899f, -0.03242676f, -0.08502541f, -0.06538655f, 
    -0.10131186f, -0.12937875f, 0.09326899f, -0.06357535f, -0.03686904f, 0.00136010f, -0.09842243f, -0.01289204f, 
    -0.08046052f, 0.04694658f, -0.03535501f, -0.09655703f, 0.11384610f, -0.03442858f, -0.06932059f, 0.00527085f, 
    -0.17999372f, 0.09622740f, -0.09315211f, -0.32542321f, 0.04666664f, 0.00587866f, -0.05846576f, -0.04118980f, 
    -0.03781190f, 0.03908945f, -0.07649169f, 0.06924148f, -0.02476409f, 0.04162002f, 0.14861125f, -0.13081333f, 
    -0.09202489f, -0.00416798f, -0.15862811f, -0.05645920f, -0.02926823f, 0.06410242f, -0.03303131f, 0.06509969f, 
    -0.13007009f, -0.27033195f, -0.21331216f, -0.03125198f, 0.03430754f, -0.00979949f, -0.06013917f, 0.14971074f, 
    0.04239549f, -0.11093262f, -0.02083989f, 0.01530792f, -0.11307342f, 0.12059450f, -0.10715415f, -0.01672086f, 
    0.19364913f, -0.04992828f, 0.00015658f, -0.04848075f, -0.10808633f, -0.09190345f, -0.07945927f, 0.18529059f, 
    0.14974454f, -0.06543071f, -0.13507131f, 0.00991424f, 0.09397663f, 0.19304541f, 0.02662014f, 0.09570912f, 
    0.08064394f, -0.06213579f, 0.08361056f, 0.04228244f, -0.16395137f, 0.16520900f, 0.04778120f, -0.19587488f, 
    -0.02224209f, 0.03946002f, 0.14507437f, 0.02371599f, -0.03283715f, -0.01081344f, 0.01059138f, 0.08237182f, 
    0.14781307f, -0.07242722f, 0.12512815f, -0.05677820f, 0.07873158f, 0.08024033f, 0.21389365f, 0.07886950f, 
    0.04660351f, 0.00489462f, -0.03145189f, 0.11827236f, -0.23109581f, 0.17085257f, 0.07979345f, 0.17207669f, 
    0.12682210f, -0.13777529f, 0.18301450f, 0.24626325f, -0.05800539f, 0.08684096f, 0.10871655f, -0.03028553f, 
    -0.19797079f, -0.37317613f, -0.09701402f, 0.05837140f, -0.05206755f, 0.12673143f, 0.03187046f, 0.02013041f, 
    0.02452208f, -0.05959458f, -0.05272256f, -0.03576797f, -0.06998082f, 0.04986442f, 0.04861892f, -0.05621555f, 
    0.01977507f, 0.08290441f, 0.09745546f, 0.11354903f, -0.07227859f, 0.13554510f, 0.04623973f, -0.10294029f, 
    -0.38325608f, 0.27954015f, -0.34411967f, 0.09943289f, 0.24199851f, -0.06092032f, 0.08299581f, 0.06568100f, 
    -0.07285754f, 0.01156764f, -0.00696224f, -0.01749257f, -0.11217010f, 0.00458188f, 0.15465930f, 0.12557764f, 
    -0.11680312f, -0.14673734f, -0.13919139f, -0.08529854f, -0.03306248f, -0.01896656f, 0.02131696f, 0.02830668f, 
    0.36573523f, 0.24375051f, 0.21931337f, -0.03270174f, -0.11653408f, 0.02701909f, 0.03436228f, 0.05243995f, 
    -0.13197076f, -0.09050226f, 0.06330697f, 0.03849072f, 0.15071420f, -0.22286937f, 0.15612552f, -0.05091453f, 
    -0.12635644f, 0.09650034f, -0.02633740f, 0.08600950f, -0.17546579f, -0.07724874f, 0.23192981f, 0.12808032f, 
    0.38009930f, 0.17741629f, 0.42826983f, -0.13423491f, -0.18393165f, -0.09168956f, -0.12391207f, -0.10554136f, 
    -0.09746806f, 0.02393099f, 0.00656059f, 0.00374736f, 0.05145173f, 0.06282315f, 0.14460723f, -0.04939608f, 
    0.04735772f, -0.01132794f, 0.07550566f, -0.05927828f, 0.02574721f, 0.02612228f, 0.10389876f, 0.01742939f, 
    -0.29305854f, 0.12384602f, -0.12743682f, 0.39048183f, 0.00136355f, 0.15522183f, 0.00344628f, -0.16721225f, 
    0.06495064f, -0.04957546f, 0.15531769f, -0.03830331f, 0.09885285f, 0.16964233f, -0.02738072f, -0.04118267f, 
    -0.01325148f, 0.04997062f, 0.00787302f, 0.07792481f, -0.06951281f, 0.03696546f, 0.07034571f, 0.01581771f, 
    -0.02691555f, 0.17841157f, 0.14381474f, 0.02782400f, -0.05113109f, 0.04389231f, -0.08320089f, 0.02899795f, 
    0.03330192f, 0.07996397f, 0.03866258f, 0.15786661f, 0.11312290f, 0.09540095f, 0.22196867f, 0.25299627f, 
    -0.02566788f, 0.04047332f, 0.06499828f, -0.03427518f, -0.01148631f, -0.08786199f, -0.12026982f, -0.01310138f, 
    0.56723422f, -0.27462888f, 0.49205512f, -0.19561619f, -0.19476792f, -0.10829459f, 0.04197284f, -0.00481154f, 
    0.00716118f, -0.06595117f, -0.01263983f, 0.06276743f, -0.08989415f, 0.32328150f, 0.04959875f, 0.09557418f, 
    -0.01359160f, -0.01736190f, 0.06353503f, -0.08547861f, 0.14999117f, -0.19536562f, 0.15772338f, 0.16346093f, 
    0.38623524f, -0.01749998f, 0.22427663f, -0.15494712f, -0.13655539f, -0.01949942f, 0.00923606f, -0.04739647f, 
    -0.14252821f, -0.00235237f, -0.05312015f, 0.10191742f, -0.25258419f, 0.33526865f, -0.31076610f, 0.16061337f, 
    -0.02788920f, 0.05301207f, -0.04586609f, -0.00888846f, -0.09667082f, -0.01031083f, 0.00887194f, -0.24145438f, 
    0.40174246f, 0.14031143f, 0.42486876f, -0.02078937f, 0.00735565f, -0.05898019f, 0.16292344f, 0.04475303f, 
    -0.11626381f, 0.05763165f, 0.02106729f, -0.00785363f, -0.30874220f, 0.08247587f, -0.18841022f, 0.16744843f, 
    -0.01490958f, -0.05546424f, -0.03024638f, -0.16877998f, -0.02087180f, -0.05726227f, -0.13710065f, 0.00427957f, 
    -0.34450963f, 0.26248422f, -0.03553977f, 0.01588341f, 0.09290989f, -0.05354064f, -0.01127221f, 0.06632737f, 
    0.04558511f, 0.14057562f, 0.12367360f, 0.16124934f, -0.22438468f, 0.34284663f, -0.12862130f, 0.23021640f, 
    -0.05139392f, -0.02540094f, -0.01114722f, 0.07887072f, -0.10696859f, -0.00213899f, -0.01252103f, 0.11818615f, 
    0.09481323f, 0.17509991f, 0.07858871f, 0.34174609f, -0.10864071f, -0.06067998f, 0.07238110f, -0.12413058f, 
    -0.15293923f, -0.03671827f, -0.08710201f, -0.10577337f, -0.42614418f, 0.06917852f, -0.04943475f, -0.00012509f, 
    0.15359262f, 0.04587175f, 0.02546201f, 0.06096405f, 0.18612206f, 0.09493252f, 0.14540657f, 0.00335089f, 
    -0.08753709f, 0.14364393f, 0.25503066f, -0.06243358f, -0.03500688f, 0.18277326f, 0.24930745f, 0.13698421f, 
    -0.01621057f, 0.09528605f, 0.12851086f, 0.08656742f, 0.05989725f, 0.26431358f, -0.02897697f, -0.01151301f, 
    -0.05846025f, -0.04870713f, -0.03603676f, -0.00013161f, -0.12309178f, -0.16308703f, -0.36337391f, -0.19833967f, 
    -0.04276250f, 0.30062762f, -0.17700255f, 0.03048653f, -0.13282089f, 0.03070402f, 0.01997968f, 0.09934036f, 
    0.01466350f, -0.03226138f, -0.02997680f, 0.03291810f, -0.04088791f, -0.12008534f, -0.04642462f, 0.21730457f, 
    0.04256523f, 0.08999231f, 0.02587759f, 0.05735629f, 0.00290425f, -0.07325199f, 0.15118065f, 0.04636711f, 
    -0.48593295f, 0.23832099f, -0.26535264f, -0.10073812f, 0.14248912f, -0.01788130f, 0.07591363f, 0.09919712f, 
    0.05439309f, 0.05442777f, 0.18427776f, -0.13059667f, -0.07644726f, 0.05737980f, -0.11891956f, -0.02408320f, 
    -0.06088012f, -0.05288217f, 0.00844843f, 0.00918322f, 0.00927339f, -0.11804153f, 0.11651662f, 0.03019800f, 
    -0.26621270f, 0.05295762f, -0.17944632f, 0.04201156f, -0.07573144f, 0.00130959f, 0.21580657f, -0.05188298f, 
    -0.11473190f, -0.03154770f, 0.02587773f, 0.14910768f, -0.27465743f, 0.10145807f, -0.16142599f, -0.09168953f, 
    0.01737586f, 0.02454249f, 0.02363753f, 0.01786061f, -0.04150995f, 0.10370910f, 0.04957490f, -0.02315634f, 
    -0.00898584f, -0.13666795f, -0.08729926f, 0.09925181f, -0.16584118f, -0.06599509f, -0.05943725f, -0.05065780f, 
    -0.01393889f, 0.07708379f, -0.00276762f, 0.01280777f, 0.20927060f, -0.03147139f, 0.11694188f, 0.04679785f, 
    -0.06310799f, 0.00206171f, -0.06128111f, -0.03151054f, -0.02453028f, 0.00561347f, 0.01702869f, 0.05441269f, 
    0.07272542f, -0.47176144f, 0.28212205f, -0.18193239f, 0.03517308f, 0.03004235f, 0.06346687f, -0.04547330f, 
    -0.04621613f, 0.13996172f, 0.05996160f, 0.25193816f, -0.05208062f, 0.04031749f, 0.01523123f, 0.05861195f, 
    -0.11281034f, 0.18529317f, -0.10841545f, 0.00144534f, -0.03836425f, 0.00459316f, 0.06485514f, 0.00932647f, 
    -0.13748175f, 0.16541499f, -0.11698502f, 0.10327209f, 0.09715618f, 0.05229504f, -0.04026731f, -0.09604651f, 
    0.01159011f, -0.02612928f, 0.02518858f, 0.12956849f, -0.09285425f, 0.17125617f, 0.03353912f, 0.02269878f, 
    0.04958439f, -0.07961315f, 0.01146491f, -0.07530723f, -0.10886402f, 0.00091167f, -0.01739638f, 0.01250028f, 
    -0.02834610f, 0.15605964f, 0.02362919f, -0.11513429f, 0.01252293f, -0.02013127f, -0.13861607f, -0.24221365f, 
    -0.00495226f, -0.00448563f, -0.13891813f, -0.17438687f, -0.57163411f, 0.13942768f, -0.47204664f, 0.26454327f, 
    -0.08062662f, 0.03509632f, -0.01369589f, -0.02204343f, 0.07936287f, -0.00546895f, -0.04429828f, 0.02700291f, 
    -0.57909971f, 0.31035697f, -0.14908634f, 0.15346870f, 0.20105451f, -0.01272574f, 0.09873322f, -0.00323733f, 
    0.10118826f, -0.11356938f, 0.10682996f, -0.00434033f, 0.21311425f, -0.07539678f, 0.22520399f, -0.10818097f, 
    -0.03323681f, 0.06135092f, 0.03545714f, 0.07870658f, 0.09754221f, 0.03296019f, -0.05942113f, 0.02198483f, 
    -0.08059096f, -0.05781180f, -0.02986685f, 0.01055142f, -0.02831740f, 0.11483834f, 0.03023827f, -0.03646234f, 
    -0.03581618f, 0.02193652f, 0.03497394f, -0.04956257f, 0.02237189f, 0.06046046f, 0.00797311f, 0.06996059f, 
    -0.12064496f, 0.00185604f, -0.05045722f, 0.06709025f, -0.15479094f, 0.00862070f, 0.06892884f, 0.13397676f, 
    0.48645067f, -0.45643055f, 0.51844943f, -0.39973545f, -0.16971433f, -0.02723183f, 0.03742329f, 0.03980893f, 
    -0.04138405f, -0.06084672f, 0.09437229f, 0.12763143f, 0.10371806f, -0.18237853f, 0.23901066f, 0.06271692f, 
    0.00892981f, 0.02675554f, -0.01851162f, -0.07353897f, 0.01041454f, 0.17612441f, 0.04831026f, 0.08321106f, 
    0.18844934f, 0.00972606f, 0.12017678f, -0.10451400f, 0.01680509f, -0.01973431f, 0.07646798f, -0.02847187f, 
    -0.04346057f, 0.09269568f, 0.09657703f, -0.12712336f, -0.12484483f, 0.06678552f, -0.07433421f, -0.03875894f, 
    -0.07646140f, -0.07343961f, 0.02582541f, -0.05235070f, -0.06923885f, 0.04790787f, -0.06427042f, -0.12141191f, 
    0.23621172f, 0.06404335f, 0.11713585f, 0.18582654f, -0.17897572f, -0.04554555f, -0.18456708f, -0.06800484f, 
    -0.04484846f, -0.03161903f, -0.06697858f, -0.03333531f, -0.23554869f, -0.07997628f, -0.02353430f, 0.06992756f, 
    -0.07978705f, 0.00624400f, -0.09654290f, -0.14938565f, -0.08711132f, -0.00789364f, -0.07871678f, -0.01013779f, 
    0.03439091f, 0.07811306f, 0.06320536f, 0.12947349f, -0.05641056f, 0.00410796f, 0.01689119f, 0.04583599f, 
    -0.02226774f, 0.00319993f, 0.07938645f, 0.00235445f, 0.28992289f, 0.02363214f, 0.12968625f, 0.09519678f, 
    -0.02557856f, -0.03623924f, 0.12085614f, 0.01278230f, -0.05471103f, 0.18926646f, 0.09063501f, 0.07010227f, 
    -0.25961211f, 0.09707030f, -0.11932970f, 0.06927703f, 0.02241908f, -0.10490419f, 0.12941676f, 0.03560962f, 
    0.06526780f, 0.14308637f, 0.18030256f, 0.04120897f, -0.03190940f, -0.18220508f, 0.20749648f, 0.13383162f, 
    -0.06939831f, 0.15742944f, -0.06115141f, 0.04524001f, 0.12440124f, -0.00531074f, 0.03081886f, 0.21437998f, 
    0.23670921f, -0.05528128f, 0.08895209f, -0.18414846f, -0.08439582f, -0.08389661f, -0.02087325f, -0.01654854f, 
    -0.03740413f, 0.03595404f, -0.09493698f, -0.19533509f, -0.16959170f, -0.14585808f, 0.26463777f, -0.11849549f, 
    0.02829308f, -0.02675161f, -0.00560146f, -0.04219945f, 0.00440608f, 0.05558594f, 0.02891054f, 0.19770682f, 
    -0.13392220f, 0.14630549f, -0.00405833f, 0.13247976f, -0.10386358f, -0.00660356f, -0.05762341f, -0.07585890f, 
    -0.00094200f, 0.02060437f, -0.10796236f, 0.01921931f, -0.17887402f, 0.20778364f, -0.06118665f, -0.01814957f, 
    0.01235153f, -0.00996670f, 0.24782231f, 0.10324645f, -0.05820853f, 0.00275275f, 0.12700169f, -0.02434055f, 
    0.00142504f, -0.03079031f, 0.04528932f, 0.22734918f, 0.02356053f, -0.07239521f, -0.00445243f, -0.04053988f, 
    0.00557361f, 0.04286163f, 0.05274770f, 0.02489659f, -0.03134419f, -0.03463914f, 0.06129602f, 0.12774238f, 
    0.12760113f, -0.12929976f, 0.12245397f, 0.03786509f, 0.14832808f, 0.10891431f, 0.00159589f, 0.12025089f, 
    0.46507427f, 0.30862141f, 0.12857974f, 0.26167634f, 0.03614714f, 0.14336324f, -0.10586628f, -0.00345164f, 
    -0.07489573f, 0.11948949f, 0.17798732f, 0.06583752f, 0.19756487f, 0.07982478f, -0.03672078f, 0.07657804f, 
    -0.12262686f, 0.01967265f, 0.00599249f, 0.00717866f, 0.07172025f, -0.12294735f, 0.07556860f, -0.08651743f, 
    0.30611366f, -0.13908853f, 0.13849783f, -0.25582495f, 0.00693937f, -0.03511407f, 0.09184684f, -0.07916314f, 
    -0.03662592f, 0.19513731f, -0.11126326f, 0.04559387f, 0.08161806f, -0.20837027f, 0.01197412f, 0.09143914f, 
    0.08111479f, 0.03681405f, -0.08268914f, -0.20168705f, -0.00123772f, 0.00254899f, 0.08366423f, -0.00062606f, 
    0.11231513f, -0.04149762f, 0.12462788f, -0.10197227f, -0.00293847f, -0.01901767f, 0.18026598f, 0.02158080f, 
    0.07503735f, 0.09732688f, -0.07462969f, -0.13273820f, -0.07966567f, 0.29085568f, -0.08386600f, -0.03392406f, 
    -0.00219553f, -0.07435872f, 0.00089889f, 0.28574705f, -0.05359372f, 0.04933527f, 0.04627392f, -0.00743982f, 
    0.00496789f, 0.04879661f, 0.07769638f, 0.04829392f, -0.00610283f, 0.06173896f, 0.00892184f, 0.00830527f, 
    0.14184780f, 0.06000122f, -0.08733203f, 0.00742923f, -0.23593655f, 0.23385169f, 0.09944148f, 0.02995562f, 
    -0.07416690f, 0.06114643f, 0.05012846f, 0.02240766f, -0.06365018f, -0.05870453f, -0.00172159f, 0.00103738f, 
    -0.28564709f, 0.06546780f, -0.41575828f, 0.09839159f, 0.02045283f, 0.06325863f, 0.02925516f, -0.05261091f, 
    -0.03735415f, 0.03602479f, -0.05399784f, 0.02461016f, -0.19921362f, 0.01260559f, 0.03270174f, 0.00651472f, 
    -0.06169004f, -0.02625273f, -0.14926146f, -0.05348212f, 0.01906729f, -0.05200220f, 0.01690716f, -0.00184614f, 
    0.03317646f, 0.08914524f, 0.02076235f, -0.07536589f, -0.06122053f, 0.06861884f, 0.00022739f, -0.04152939f, 
    -0.09270889f, -0.12705261f, 0.00822817f, 0.01396331f, 0.21712315f, -0.19454679f, 0.08862040f, 0.07875767f, 
    0.01679103f, 0.13487084f, 0.06826556f, 0.01438996f, -0.03543912f, -0.13768966f, 0.02903728f, 0.06545283f, 
    -0.06306992f, -0.20009942f, 0.01778617f, -0.26708707f, -0.11687991f, 0.06317680f, 0.09762323f, -0.02315896f, 
    -0.05833811f, -0.00408284f, 0.01259569f, -0.02128891f, 0.13115594f, 0.11769376f, -0.00852904f, -0.02266969f, 
    0.09221923f, -0.05588074f, 0.05695153f, 0.02226025f, -0.00000575f, -0.04983768f, -0.05477393f, 0.01318024f, 
    -0.38732803f, -0.31305447f, 0.23551716f, 0.02564862f, 0.06073693f, 0.14540178f, -0.01038243f, -0.05228533f, 
    0.05905135f, -0.05741340f, 0.11503743f, -0.08321133f, 0.01549008f, -0.10706379f, -0.04817800f, -0.06815500f, 
    0.06905238f, 0.06480073f, 0.05714133f, -0.01225457f, -0.05092547f, -0.05461566f, -0.00029992f, -0.04197524f, 
    -0.26847771f, 0.16036345f, -0.05845894f, -0.04902691f, 0.00694931f, 0.10906298f, 0.07350582f, -0.04308764f, 
    -0.03652800f, 0.00779722f, 0.02619427f, 0.15322572f, -0.04727931f, -0.06522308f, 0.26945066f, 0.29051703f, 
    -0.04532158f, -0.01423676f, -0.00894196f, -0.16616230f, -0.02292549f, -0.07819408f, -0.15016277f, -0.13375394f, 
    0.47343785f, -0.17387213f, -0.00261318f, 0.04710316f, -0.06520964f, 0.01080439f, -0.05958853f, 0.03883414f, 
    -0.08217888f, -0.03522996f, -0.13344175f, 0.00250445f, 0.25821745f, 0.00384984f, 0.16311073f, 0.13680241f, 
    -0.06239705f, 0.06178723f, 0.01723917f, 0.05512635f, 0.10860789f, 0.07703855f, 0.07882490f, -0.04939194f, 
    0.21851675f, -0.10465771f, 0.13841675f, -0.36637878f, 0.01007121f, -0.03121697f, -0.01684731f, -0.06508647f, 
    -0.11591613f, -0.06990626f, -0.05621442f, 0.07372741f, -0.19177236f, -0.03550762f, -0.01845655f, 0.05244545f, 
    -0.08203220f, 0.10685244f, -0.12149363f, 0.06563173f, 0.01677733f, -0.04895396f, -0.01283596f, 0.14191349f, 
    0.37408274f, -0.16012073f, 0.49268690f, -0.18893802f, 0.01192628f, -0.10799851f, 0.00330736f, -0.11389776f, 
    0.08634792f, 0.20841341f, 0.08880141f, 0.03482431f, -0.36182776f, 0.01723825f, 0.02637515f, -0.01824691f, 
    -0.11681262f, 0.07051087f, 0.08174977f, -0.15498623f, -0.02918308f, 0.03981397f, -0.02127282f, 0.04546180f, 
    -0.11204216f, 0.20932533f, 0.28900453f, 0.06812511f, -0.12952517f, 0.00325907f, -0.00405178f, 0.06685277f, 
    -0.15789312f, 0.07432482f, -0.06188999f, 0.03148977f, 0.01838349f, 0.18816108f, 0.01211383f, 0.28581330f, 
    -0.01003816f, -0.05535889f, 0.01336600f, 0.03584405f, -0.05446412f, 0.04656865f, -0.05226141f, 0.14559017f, 
    -0.13888313f, -0.01458568f, -0.04390661f, 0.22370525f, -0.09728217f, -0.10105358f, -0.06116538f, -0.00830423f, 
    -0.06002707f, -0.08223011f, -0.09074896f, -0.04350251f, -0.31312442f, 0.28825027f, 0.00037557f, 0.25016883f, 
    0.00526960f, 0.00087128f, 0.16002654f, 0.02410568f, 0.02535064f, 0.14053126f, -0.02172068f, 0.09750537f, 
    -0.19686463f, 0.11836175f, 0.13931587f, -0.06208064f, -0.09887724f, 0.13158634f, 0.10762748f, 0.02701965f, 
    -0.05193656f, 0.01155227f, 0.06320450f, 0.07623737f, 0.24583660f, 0.20024866f, 0.03309056f, -0.00358382f, 
    -0.00601308f, -0.07388099f, 0.00235505f, -0.03483412f, -0.17338990f, -0.00904765f, -0.01217236f, 0.10687666f, 
    -0.01412515f, -0.05608195f, 0.03252290f, 0.02969286f, 0.10459202f, 0.02301849f, -0.06861827f, 0.08160917f, 
    0.02238895f, -0.18775584f, 0.00888701f, 0.04428523f, 0.23344186f, -0.32724360f, 0.12110856f, 0.12305211f, 
    0.09045225f, 0.02146720f, -0.03703791f, 0.09881999f, 0.03002032f, 0.04392955f, 0.02428131f, -0.03846259f, 
    -0.57210362f, 0.05713379f, -0.31005704f, -0.20569693f, -0.05978197f, 0.24129851f, 0.04416515f, -0.03406461f, 
    -0.03453012f, 0.07142453f, -0.00785955f, -0.11751022f, -0.02669137f, 0.01213968f, -0.03581004f, 0.04875899f, 
    -0.08083963f, -0.12385263f, -0.07698043f, 0.08738879f, -0.04311083f, 0.08798004f, 0.01063806f, 0.03788254f, 
    0.05707166f, -0.18131126f, 0.12349098f, 0.17851987f, -0.04618464f, -0.01657241f, -0.03586029f, 0.01839580f, 
    -0.01866227f, 0.06177285f, -0.07296048f, -0.00981903f, 0.20547423f, 0.44087893f, 0.42233849f, 0.06130916f, 
    -0.11951215f, -0.02011458f, -0.04341694f, 0.09264117f, -0.04229810f, 0.01882855f, 0.04225236f, 0.09476409f, 
    -0.13320157f, -0.01742931f, 0.01696194f, 0.09386504f, -0.12519789f, 0.02908714f, -0.03408213f, 0.04202927f, 
    0.01815728f, 0.09847790f, 0.00410106f, 0.08537614f, -0.12717251f, -0.09533892f, -0.01145011f, 0.15010487f, 
    -0.17064300f, -0.03271006f, -0.17628358f, -0.13094091f, -0.06444010f, -0.09181876f, -0.17779508f, -0.11207505f, 
    0.27024966f, -0.14445275f, 0.00159730f, -0.23702525f, 0.08037646f, 0.01083112f, 0.08304010f, -0.15579003f, 
    0.05891537f, 0.05252656f, -0.05334575f, 0.01253607f, -0.10351507f, -0.02636500f, -0.03174206f, -0.01813290f, 
    -0.08832859f, 0.04749048f, -0.01370218f, 0.01730890f, -0.03445404f, -0.04953754f, 0.01096285f, -0.08875223f, 
    -0.17858645f, -0.43009189f, 0.52628791f, 0.14054319f, -0.04815561f, 0.03187981f, -0.08000774f, -0.01103641f, 
    0.16913335f, 0.09177911f, -0.12036562f, -0.06991055f, 0.11062102f, 0.05405980f, 0.14327763f, 0.13198027f, 
    -0.06340542f, -0.06028414f, 0.01273756f, -0.01309555f, 0.09151892f, 0.12152831f, 0.04509984f, -0.12360754f, 
    -0.24830851f, 0.21157327f, 0.22640733f, 0.18123642f, -0.08466008f, 0.00191013f, -0.02024280f, -0.00323073f, 
    0.05877337f, 0.08619354f, -0.15546235f, -0.05783949f, -0.25365508f, -0.24692997f, -0.20900656f, -0.02294941f, 
    -0.10122435f, 0.14125447f, -0.05177510f, 0.02928447f, 0.03312868f, -0.01239713f, -0.01847512f, 0.06217673f, 
    -0.06805315f, -0.07773834f, 0.04886943f, 0.27117115f, -0.13798271f, 0.11840619f, 0.11388483f, 0.08150297f, 
    0.11531018f, 0.04060949f, 0.00585438f, -0.08815209f, 0.01892200f, 0.06290183f, 0.01397299f, -0.09409302f, 
    -0.00436137f, -0.05236045f, 0.12800746f, -0.12608731f, 0.06742127f, -0.01880200f, -0.01416914f, 0.13895902f, 
    0.00354927f, 0.15823992f, 0.11286037f, 0.09414711f, 0.01941930f, -0.03221643f, -0.05217806f, 0.02047700f, 
    -0.01778107f, 0.03861409f, -0.04081226f, -0.02284512f, 0.06127926f, -0.09346869f, 0.03894217f, 0.03749803f, 
    -0.02944875f, -0.07334589f, 0.04685512f, -0.07273876f, 0.02733873f, -0.11136898f, 0.07665669f, 0.07535055f, 
    0.02279105f, -0.20889650f, -0.04053995f, -0.16096279f, -0.00625782f, 0.13637611f, 0.18030848f, 0.02421394f, 
    0.01242370f, -0.05588448f, -0.04778579f, -0.10004946f, -0.15782703f, -0.09506948f, 0.21752913f, 0.16738658f, 
    0.11216423f, 0.03029398f, -0.01240265f, 0.13007766f, 0.01458566f, -0.04718442f, -0.07512514f, 0.06025646f, 
    0.04396541f, 0.04227746f, 0.12146187f, -0.01423542f, 0.09865705f, 0.17419557f, 0.04531994f, 0.01632047f, 
    -0.06036755f, 0.04266714f, 0.12723711f, -0.01854800f, -0.09840167f, 0.35861400f, 0.25859648f, 0.22100423f, 
    -0.04042517f, -0.03787953f, 0.07025228f, 0.06227864f, 0.03639537f, 0.06786389f, -0.08942685f, -0.00620109f, 
    0.07394727f, -0.11081386f, -0.00607113f, -0.11825841f, -0.06376995f, 0.04129095f, 0.02633955f, -0.10817207f, 
    -0.01307710f, -0.05292588f, 0.01415707f, -0.04936151f, -0.19029915f, -0.02250687f, 0.06660426f, 0.03517090f, 
    -0.12011795f, -0.15051956f, -0.09996928f, -0.13658604f, -0.02416072f, 0.00714027f, 0.00642103f, 0.00407348f, 
    0.19984464f, 0.04695551f, 0.04405811f, 0.12744604f, -0.05079363f, -0.04685432f, 0.01410602f, 0.03025804f, 
    0.05009631f, 0.00102728f, -0.00134501f, -0.00960935f, 0.36721611f, 0.06405830f, 0.04695036f, -0.11699423f, 
    0.06187773f, -0.10583919f, 0.02850829f, 0.06596339f, 0.04647425f, 0.07678562f, 0.09501612f, 0.05437053f, 
    -0.14661057f, 0.03461446f, -0.05352441f, -0.03033884f, 0.01830655f, -0.01922915f, 0.02623735f, -0.05480380f, 
    -0.17320243f, -0.00563155f, 0.04518276f, -0.03567473f, 0.04480601f, -0.33847064f, 0.31257707f, -0.06702244f, 
    0.04532765f, 0.06497662f, -0.11371090f, 0.03239154f, 0.10053565f, 0.07148562f, -0.02040880f, 0.03522115f, 
    -0.05171845f, -0.01115662f, -0.08845551f, -0.02835590f, -0.04374783f, -0.08836984f, 0.04015076f, -0.06894252f, 
    -0.00949044f, -0.07365424f, 0.22803208f, 0.13804248f, 0.20152856f, 0.00148324f, 0.41257527f, 0.13330239f, 
    -0.13789642f, -0.12874730f, -0.01333311f, -0.05776680f, 0.03696289f, 0.05470340f, 0.02591158f, 0.17384586f, 
    0.12587902f, -0.02606851f, -0.01356020f, 0.11793693f, -0.08187951f, -0.03010770f, -0.07951885f, 0.02733305f, 
    0.10190392f, 0.08101256f, 0.01539541f, 0.02845209f, -0.10200118f, -0.20795731f, -0.02415023f, 0.10061704f, 
    0.07625076f, 0.16800445f, 0.12346882f, 0.03867330f, -0.02980428f, -0.08131859f, 0.08733043f, -0.08712570f, 
    0.11030006f, -0.03535061f, 0.12128547f, 0.10804278f, -0.04537399f, 0.01050722f, 0.02250770f, 0.04386612f, 
    0.07412577f, 0.03579584f, 0.05334490f, -0.04199006f, -0.03706709f, 0.13055928f, 0.08111358f, 0.05360803f, 
    0.15330349f, 0.01043792f, 0.13115840f, 0.03903147f, 0.12362092f, 0.11178280f, -0.05259454f, 0.03359845f, 
    0.60366118f, 0.54153699f, 0.19347748f, -0.03144829f, 0.06105247f, 0.02955377f, -0.04271784f, -0.00568316f, 
    0.11293881f, 0.13738208f, -0.02474728f, -0.02699250f, 0.10654719f, -0.10999853f, 0.13732930f, 0.05451120f, 
    -0.16464914f, 0.00450752f, -0.01588836f, 0.00874196f, -0.01368058f, -0.00201427f, 0.07598581f, -0.23851451f, 
    -0.04522629f, -0.00064705f, -0.13739593f, -0.10497931f, 0.06736814f, 0.04818968f, 0.13884483f, -0.11541969f, 
    -0.07966578f, 0.07132956f, -0.12461872f, -0.04316137f, -0.06002258f, -0.17739061f, -0.02929581f, -0.01149799f, 
    -0.04990864f, 0.01310705f, -0.01688722f, -0.13346267f, 0.04072855f, 0.01822755f, 0.05959264f, -0.00836428f, 
    -0.22362776f, 0.17387620f, -0.08130510f, -0.15874131f, 0.11100087f, 0.22619639f, 0.02858405f, 0.04478217f, 
    -0.01039002f, 0.10472171f, -0.10042623f, 0.05465365f, 0.03142590f, 0.06672224f, 0.12361167f, -0.09582851f, 
    -0.00931701f, 0.28507146f, 0.00343398f, -0.15752541f, 0.05572608f, -0.01775767f, 0.02233703f, -0.19819227f, 
    -0.26269302f, -0.16668794f, -0.16267186f, -0.09462578f, 0.00837388f, 0.05769163f, 0.08187523f, 0.26787907f, 
    -0.05255602f, 0.11255246f, 0.22197206f, 0.04147480f, 0.31118560f, 0.09996638f, -0.05777729f, 0.09649962f, 
    -0.02497735f, 0.14130242f, -0.19185556f, 0.06630161f, 0.00309024f, -0.02000518f, 0.05745624f, -0.04757967f, 
    -0.07355124f, 0.01213117f, -0.05878013f, 0.09436101f, 0.05371894f, 0.00010402f, 0.00701675f, 0.19405293f, 
    -0.04107290f, 0.01433043f, -0.05151066f, 0.04510755f, -0.11337379f, -0.17773201f, -0.07902253f, -0.01534267f, 
    0.04063427f, 0.06462615f, 0.01494699f, 0.10239051f, -0.03338709f, 0.05290835f, 0.01239809f, -0.03716044f, 
    0.12315445f, 0.20104264f, 0.04659411f, 0.30787775f, -0.00469511f, 0.00155457f, 0.03695591f, -0.12801826f, 
    0.01813089f, 0.02814518f, -0.06917140f, 0.04233430f, -0.12741494f, -0.03791730f, 0.04488115f, 0.05759374f, 
    -0.07716419f, -0.00204474f, 0.21499327f, 0.00019773f, -0.00589691f, -0.05694113f, -0.03255065f, 0.22357501f, 
    -0.12747370f, 0.22108439f, 0.20945397f, 0.01535238f, -0.06950275f, -0.08612398f, -0.13826647f, -0.14223213f, 
    -0.05471068f, -0.03986369f, -0.00732706f, -0.02947100f, -0.07462005f, 0.10411149f, 0.09076207f, -0.08635548f, 
    -0.01463761f, 0.07715779f, 0.00926613f, 0.01192814f, 0.11912755f, 0.09227601f, 0.04365787f, 0.17750297f, 
    0.04060142f, 0.19670460f, 0.04638026f, -0.28781673f, 0.06071368f, -0.05766203f, 0.14352332f, 0.22952887f, 
    0.01292918f, 0.12262683f, 0.00369918f, -0.15105659f, -0.14239536f, 0.06264929f, 0.13922314f, -0.04289962f, 
    0.04643714f, -0.03015453f, -0.24900067f, 0.07563975f, -0.01267115f, -0.00546814f, 0.01337498f, 0.05845299f, 
    0.05575109f, 0.13582145f, -0.16916162f, 0.04677425f, 0.06539508f, 0.01288943f, 0.00334822f, 0.02494587f, 
    0.01591531f, 0.02441118f, -0.01169774f, 0.06567444f, -0.15778437f, 0.10071377f, -0.08019664f, -0.16891576f, 
    0.07992894f, 0.01839485f, 0.08833457f, -0.01291234f, -0.04457724f, -0.02740317f, -0.08978750f, 0.00990970f, 
    -0.18724148f, 0.07183159f, 0.37135822f, -0.06160286f, -0.07007406f, -0.05297698f, -0.01338966f, 0.01065196f, 
    0.02861226f, -0.04882562f, 0.07592221f, -0.05852292f, 0.26069674f, 0.07006389f, -0.00128162f, 0.12804917f, 
    -0.04695848f, 0.01818245f, -0.08889873f, -0.10477916f, 0.16251618f, 0.10601195f, 0.11143404f, 0.07693218f, 
    0.26511854f, 0.11748935f, 0.02507667f, 0.27459893f, -0.07236754f, 0.02732612f, 0.00153332f, -0.08816720f, 
    -0.01683764f, -0.00091515f, 0.03349087f, -0.00088990f, 0.14709191f, -0.24182636f, 0.10379574f, 0.01450260f, 
    -0.01865608f, -0.09582576f, -0.07360336f, -0.03594523f, 0.03872510f, -0.02400645f, 0.01666212f, -0.19787130f, 
    0.19442953f, -0.08266462f, 0.19413766f, 0.07754452f, -0.04629018f, -0.07131569f, 0.10628111f, -0.07245994f, 
    0.07151101f, 0.18921821f, 0.21764836f, -0.15463243f, -0.31762424f, -0.39260435f, -0.43547389f, 0.05185209f, 
    0.06839470f, 0.02295892f, 0.05534359f, -0.10034114f, -0.01874281f, -0.07264052f, 0.06471384f, 0.03079628f, 
    0.30092752f, -0.20386532f, 0.02305107f, -0.05830908f, -0.04364371f, -0.02555302f, -0.03876567f, 0.18642494f, 
    -0.09337654f, 0.02854246f, 0.24268381f, -0.04682422f, 0.13684890f, 0.05407729f, 0.07796533f, -0.18242663f, 
    0.01241455f, 0.01759741f, -0.05167985f, 0.04136183f, 0.08416205f, 0.02887220f, 0.12654798f, -0.05919795f, 
    -0.23920067f, -0.15438044f, 0.08781149f, 0.04525387f, -0.06271499f, 0.20611914f, -0.16806380f, 0.15205523f, 
    -0.00778709f, -0.05231370f, -0.10682696f, -0.04766295f, 0.33256435f, 0.09151935f, -0.41564488f, 0.13487153f, 
    0.12095598f, 0.13726129f, -0.10810613f, -0.00852090f, -0.03241961f, 0.27581900f, -0.07626438f, 0.03499679f, 
    0.20671746f, 0.03681623f, -0.15897150f, 0.14770418f, 0.07382741f, -0.00886887f, 0.19931667f, -0.05278023f, 
    0.07123013f, -0.18025087f, 0.24985152f, 0.06523542f, 0.08819674f, -0.07539236f, 0.22072308f, -0.00885419f, 
    -0.04320068f, -0.00731012f, -0.07446006f, -0.05840108f, 0.03505234f, 0.05790241f, -0.07988945f, -0.03887257f, 
    0.06871143f, 0.13555171f, -0.02153991f, -0.04812264f, -0.07781662f, -0.08624997f, 0.08555943f, 0.12839590f, 
    -0.03478040f, 0.06145109f, 0.00076258f, -0.04993379f, 0.05998157f, 0.13048652f, 0.30240524f, -0.08699650f, 
    0.09239131f, 0.09570024f, -0.08738609f, 0.32529455f, 0.05002527f, 0.05699694f, 0.14614040f, 0.04566250f, 
    -0.05369183f, -0.03269172f, -0.11153478f, 0.23379149f, 0.13947558f, 0.19824959f, -0.23729666f, 0.05318174f, 
    -0.01499846f, -0.06430533f, 0.17332175f, 0.08287503f, 0.11352522f, -0.02909170f, -0.06414163f, 0.03109317f, 
    -0.02096389f, -0.09222388f, -0.09944928f, -0.02313694f, -0.10352928f, 0.01991889f, 0.00848765f, -0.01774186f, 
    0.11901340f, 0.01155332f, -0.01912273f, -0.09579133f, 0.07158633f, -0.04953483f, 0.00000505f, 0.09491979f, 
    0.07011790f, -0.02079924f, 0.17274973f, -0.00283145f, 0.40839341f, -0.28046826f, 0.20438828f, -0.00298667f, 
    -0.04192513f, -0.04147471f, 0.05641198f, 0.04710893f, -0.00457548f, -0.03974390f, 0.10363224f, -0.04515706f, 
    -0.24462353f, -0.31728017f, -0.17106916f, -0.14779915f, 0.09623660f, -0.02226024f, 0.06247550f, -0.02617087f, 
    0.02617405f, -0.06064430f, -0.00433976f, -0.03321278f, -0.11966946f, 0.11467068f, -0.11673541f, 0.28572527f, 
    -0.02546173f, -0.00267036f, 0.04180621f, 0.08840574f, -0.06812972f, -0.08664992f, -0.00087238f, 0.03263607f, 
    -0.54274875f, -0.09010431f, 0.09429003f, -0.07730329f, 0.06389914f, 0.04097997f, -0.05024391f, 0.05548965f, 
    0.13481055f, -0.07258235f, 0.01143513f, 0.10345159f, -0.19684534f, -0.05712311f, -0.02382495f, -0.00138731f, 
    0.08141711f, 0.03773364f, 0.01343335f, -0.06109303f, 0.01243792f, 0.07499003f, 0.06341060f, 0.04654905f, 
    0.23732486f, 0.04596891f, 0.36023912f, -0.00267059f, 0.06057779f, -0.25402528f, 0.08647494f, 0.05328295f, 
    0.08657696f, -0.04440172f, 0.13739316f, 0.01779725f, 0.12655692f, -0.19902329f, 0.07505112f, -0.02345024f, 
    -0.01412972f, -0.02660174f, -0.02486314f, -0.08744662f, 0.00531666f, -0.01991448f, 0.05497719f, 0.08786700f, 
    0.05703879f, -0.02931769f, 0.11336406f, 0.01148414f, 0.01247343f, -0.11910234f, 0.00684718f, -0.11174627f, 
    0.01528056f, -0.04129732f, 0.06519700f, -0.04322229f, -0.04727367f, 0.03859204f, -0.17915279f, -0.08929154f, 
    -0.10044339f, -0.09533746f, 0.21988256f, -0.01716939f, 0.05620196f, 0.05606796f, -0.02802861f, -0.17318787f, 
    0.28064734f, -0.19166192f, 0.27617902f, -0.00264428f, 0.04292639f, -0.01319134f, -0.06990858f, -0.00617360f, 
    0.03637688f, -0.01219547f, 0.13440846f, -0.04221321f, -0.02153818f, 0.13949186f, -0.22046736f, 0.36621439f, 
    -0.01664392f, 0.20012327f, 0.07971230f, -0.05537331f, 0.05381583f, 0.14264859f, 0.16897821f, -0.10107461f, 
    -0.00042046f, 0.02303991f, -0.02022673f, -0.05146789f, 0.00078224f, -0.08768588f, 0.18237318f, 0.09625993f, 
    0.01888809f, -0.07517831f, 0.08430282f, -0.03334977f, -0.12608489f, 0.04947161f, 0.14378907f, 0.02507580f, 
    -0.04920230f, -0.09423120f, -0.09268256f, 0.01673026f, 0.06945369f, 0.06134497f, -0.02842168f, 0.07019347f, 
    -0.25686410f, -0.09991084f, -0.00326381f, -0.02526925f, 0.10528407f, -0.09397675f, 0.16132101f, 0.04602523f, 
    0.02017385f, -0.06099930f, 0.01512273f, -0.00737886f, -0.01703387f, 0.09940897f, 0.06835736f, -0.11588629f, 
    -0.08909050f, -0.12881503f, 0.12729664f, -0.11396885f, 0.01883023f, 0.06228627f, 0.00709036f, -0.04182742f, 
    0.17167290f, -0.10281208f, 0.08572401f, -0.01301004f, -0.00396879f, 0.02065203f, 0.01953138f, 0.16028643f, 
    -0.03960564f, -0.00735056f, -0.03874055f, -0.01858985f, 0.11139487f, 0.01767776f, -0.20456979f, -0.01997167f, 
    -0.02324067f, 0.06505645f, 0.17090243f, 0.08961771f, -0.03815449f, -0.05736876f, 0.01915796f, -0.01097490f, 
    -0.03722298f, 0.15581232f, 0.38455683f, -0.10578020f, -0.02383991f, -0.05616700f, -0.08715640f, -0.09053392f, 
    -0.00442774f, -0.02929290f, 0.03399361f, 0.02076572f, -0.33744392f, -0.34097192f, -0.36224034f, -0.14681590f, 
    0.09264609f, 0.14437981f, -0.03457990f, 0.14883922f, 0.00159510f, 0.01970925f, -0.00205250f, 0.04428500f, 
    0.17351562f, 0.01221895f, -0.03456744f, 0.06008355f, -0.00936321f, 0.03700884f, 0.05463694f, -0.06279133f, 
    0.03266170f, 0.07563490f, -0.05084692f, 0.08866894f, 0.00824359f, 0.32244363f, 0.01519443f, 0.14596047f, 
    -0.03618148f, 0.05987239f, 0.05539827f, 0.10938868f, 0.23319928f, 0.17092466f, -0.14502169f, 0.14331786f, 
    0.06708604f, -0.11767738f, -0.13309126f, -0.08915211f, 0.08794313f, 0.16100758f, 0.10253987f, 0.13106090f, 
    0.05171349f, -0.00453622f, 0.16607225f, 0.18533751f, 0.03706469f, 0.14429550f, 0.07143012f, -0.24436757f, 
    0.14980192f, 0.00458930f, -0.02842779f, 0.12281429f, -0.10479173f, 0.07854656f, 0.17411746f, 0.05364897f, 
    0.02311649f, -0.00857347f, -0.03807655f, -0.03583153f, -0.04089098f, 0.02460386f, -0.11308565f, 0.00986620f, 
    -0.06243116f, 0.05785392f, -0.18848656f, -0.03014678f, 0.16520695f, 0.14456995f, -0.13223870f, 0.02033645f, 
    0.01861829f, 0.04850352f, 0.04974528f, -0.06807464f, 0.06519981f, 0.08627058f, 0.09060853f, 0.04963002f, 
    0.11432432f, 0.19344202f, 0.07367893f, 0.06976249f, -0.00258531f, -0.01276233f, -0.05390584f, -0.06200494f, 
    0.06042719f, -0.02725013f, 0.06075706f, 0.02822695f, 0.06803328f, -0.00295283f, 0.11770559f, -0.07609149f, 
    0.03752470f, -0.01814836f, 0.02538064f, 0.22887528f, -0.09565429f, 0.06695227f, -0.06071028f, -0.02700065f, 
    0.00484142f, -0.16773441f, 0.27649075f, 0.06746161f, 0.03078626f, 0.03742960f, 0.03797215f, 0.18706858f, 
    0.04207486f, -0.05232643f, 0.01974818f, -0.08428042f, -0.12958930f, -0.15983969f, -0.14900117f, -0.01278589f, 
    0.08355884f, 0.06654446f, 0.12303689f, -0.04398388f, -0.00595647f, -0.05774164f, 0.08349999f, -0.01998985f, 
    0.04135859f, 0.29016522f, 0.36544687f, -0.24799114f, -0.05918046f, 0.09424421f, 0.09336104f, -0.07986759f, 
    0.02659652f, 0.14268894f, -0.00794654f, 0.00361644f, 0.14212324f, 0.03954264f, -0.04201440f, -0.02453711f, 
    -0.06622755f, 0.00158427f, -0.03969832f, -0.07639530f, -0.03376387f, 0.05410314f, -0.05213756f, 0.11117985f, 
    -0.30872300f, 0.08925599f, 0.09390413f, 0.05241127f, 0.03965598f, -0.06888629f, -0.03811146f, -0.08131966f, 
    -0.00557955f, -0.02632381f, 0.00924884f, 0.05814325f, -0.04298236f, -0.08568395f, 0.03094589f, 0.02105040f, 
    -0.05040290f, -0.11293428f, -0.21481223f, 0.10251196f, -0.03417066f, -0.01584336f, -0.08595184f, -0.00208239f, 
    0.01966286f, -0.03617350f, -0.01600393f, 0.02145843f, 0.00369910f, -0.04103860f, -0.02173541f, -0.02391002f, 
    -0.00112269f, 0.02414834f, 0.01308797f, -0.00334215f, 0.03668813f, 0.03679613f, -0.02298054f, -0.00497982f, 
    -0.00075060f, 0.00979462f, 0.00699325f, 0.00519796f, 0.02043849f, 0.00729262f, 0.01769833f, -0.00804935f, 
    0.00972514f, 0.00978677f, -0.00352506f, -0.00660752f, -0.02958591f, -0.02099456f, -0.02248612f, -0.03174334f, 
    0.02603294f, -0.00398222f, 0.01213931f, -0.02996234f, -0.01515908f, 0.02756978f, -0.02384803f, -0.03849164f, 
    -0.01335817f, -0.01453989f, -0.02328626f, -0.00533603f, -0.02586394f, 0.00653483f, -0.02659192f, -0.01153662f, 
    -0.00371396f, -0.00539648f, 0.01972936f, -0.01359048f, -0.01278964f, -0.01578714f, -0.01846331f, -0.04152156f, 
    0.01697738f, 0.02920448f, -0.00291362f, -0.03216926f, 0.03962320f, -0.04174845f, -0.03469668f, -0.00334865f, 
    -0.00538939f, 0.00311823f, -0.02016796f, -0.00344110f, -0.03333754f, -0.02008601f, 0.02476346f, -0.03599548f, 
    0.00623496f, 0.02038637f, 0.00730074f, -0.01135037f, -0.04101766f, 0.00804808f, 0.02361318f, 0.01437144f, 
    0.02941740f, -0.01837525f, 0.00669201f, 0.02831444f, -0.00464463f, -0.03289269f, 0.02834474f, 0.02970335f, 
    -0.01174228f, 0.00280956f, -0.01213568f, -0.03679253f, 0.01635163f, -0.03069301f, -0.01663043f, -0.02333311f, 
    0.03861479f, -0.04032527f, 0.00807021f, 0.01322533f, -0.02274527f, 0.00023365f, 0.00672974f, -0.03525541f, 
    -0.00006251f, -0.01966540f, 0.02457431f, 0.02146790f, 0.01521788f, 0.01863864f, -0.02425126f, -0.03131682f, 
    0.01780432f, -0.01057427f, 0.02237448f, -0.02051581f, 0.02826994f, -0.00091509f, 0.01635331f, -0.00287887f, 
    0.02683361f, -0.01851332f, -0.02369552f, 0.01826500f, 0.01298807f, -0.03853263f, 0.01785300f, -0.02815853f, 
    0.00992589f, 0.01019588f, 0.00976942f, -0.03526606f, 0.01347017f, -0.00557411f, -0.01330000f, 0.01070429f, 
    -0.03928765f, -0.01148589f, 0.00755936f, 0.00826896f, -0.03467494f, 0.01041018f, -0.02449035f, -0.02950734f, 
    -0.03392014f, 0.01829000f, -0.03241710f, 0.00716640f, -0.03493932f, -0.03465842f, 0.00935029f, 0.01760106f, 
    -0.02533138f, -0.00899189f, -0.02975975f, 0.01663949f, -0.00812806f, -0.02121958f, -0.01258859f, 0.01281493f, 
    -0.02742362f, -0.01489713f, -0.01933001f, 0.01503816f, -0.03629861f, -0.01835200f, -0.00485194f, 0.01949576f, 
    0.04175508f, -0.00436658f, 0.01832610f, -0.02067384f, -0.01686839f, 0.01218382f, -0.01706995f, -0.01721084f, 
    0.00815981f, -0.03567206f, -0.02085817f, -0.02876072f, -0.03586727f, -0.01204677f, -0.03375516f, -0.01351453f, 
    0.01275148f, 0.00553670f, -0.02512197f, -0.03097696f, 0.00472658f, -0.02733004f, -0.03458142f, -0.01512453f, 
    0.02039846f, -0.03712262f, -0.04153379f, -0.03133585f, 0.00726508f, -0.03422435f, 0.00796031f, -0.02255372f, 
    0.02043941f, -0.02764009f, 0.01759902f, -0.00744103f, 0.01651283f, 0.02641371f, -0.02893409f, 0.02443192f, 
    0.02722553f, -0.01011753f, 0.02921319f, -0.04056174f, -0.02437571f, -0.00505962f, -0.03203178f, -0.02303004f, 
    -0.03795091f, -0.03099367f, -0.03380290f, 0.01092012f, 0.00544505f, -0.00967014f, -0.04040302f, -0.01264549f, 
    -0.00389873f, -0.02369825f, 0.01218964f, 0.01100684f, 0.02295827f, -0.01446906f, -0.01847360f, 0.02351894f, 
    -0.02761669f, 0.01965067f, -0.01852398f, 0.01697302f, 0.01488605f, -0.00410243f, -0.03105311f, -0.00664022f, 
    -0.00680262f, 0.00001858f, 0.03168439f, -0.04158556f, -0.03434487f, 0.00343788f, -0.03789934f, -0.01716825f, 
    0.01438317f, -0.02618107f, -0.02448989f, -0.03489803f, -0.00599207f, -0.00722437f, 0.01203238f, -0.01179475f, 
    0.02675925f, -0.01015096f, 0.02033799f, -0.02887588f, -0.00414614f, 0.02412237f, -0.03003812f, -0.00810132f, 
    -0.01252122f, 0.01366507f, 0.00310178f, 0.00115609f, 0.00205536f, 0.02963952f, 0.00225019f, -0.01823311f, 
    -0.01660858f, -0.02107831f, -0.00972894f, -0.01215624f, -0.00674518f, -0.00313153f, -0.03398800f, -0.01019897f, 
    -0.03746121f, -0.01614750f, 0.02527971f, 0.01887753f, 0.01453326f, -0.03590063f, 0.01683217f, -0.02388324f, 
    0.01824709f, -0.02587809f, -0.01832111f, -0.02360596f, -0.01547266f, -0.02457588f, -0.02916604f, 0.02959445f, 
    -0.03161774f, 0.02116411f, -0.00981879f, -0.01565653f, 0.00977195f, -0.02123567f, 0.01853334f, 0.02885303f, 
    -0.00617232f, 0.02793667f, -0.03545311f, -0.03305437f, -0.02876494f, 0.01625321f, -0.01792720f, -0.00540578f, 
    0.01309788f, -0.03429268f, 0.01680687f, -0.02415108f, -0.00666835f, -0.00836110f, -0.01587340f, 0.01798040f, 
    0.00769842f, -0.01335399f, 0.00451901f, -0.03875586f, 0.02324487f, -0.02066809f, 0.02210258f, -0.00230451f, 
    -0.00412967f, 0.01684686f, -0.03389969f, 0.00033467f, 0.00448937f, 0.02320096f, 0.01518268f, -0.04054534f, 
    0.00917149f, 0.01989531f, -0.02690356f, 0.02793491f, -0.02441618f, -0.03805007f, 0.02266170f, 0.02522156f, 
    0.02371396f, 0.00880599f, -0.02452118f, 0.00658918f, -0.00652270f, -0.02417143f, -0.00349634f, -0.01062318f, 
    -0.01061750f, -0.00328423f, -0.03904370f, -0.00514527f, 0.02264582f, -0.01518521f, -0.00362891f, 0.01002410f, 
    -0.02597580f, -0.03808372f, -0.02934321f, 0.00854840f, 0.01779943f, -0.01870875f, 0.00296144f, -0.02149877f, 
    -0.02849559f, -0.01213923f, 0.00116931f, -0.02556812f, -0.00239324f, -0.02781487f, 0.01173110f, 0.01295159f, 
    -0.01427392f, -0.00511024f, -0.00896148f, 0.01087424f, -0.04173721f, 0.01971717f, -0.00318740f, 0.00433719f, 
    0.01220096f, 0.00623995f, -0.00242919f, -0.02457664f, -0.00024580f, -0.03909060f, 0.02341840f, 0.01651837f, 
    -0.00467275f, -0.02020757f, -0.02642915f, 0.00631293f, -0.01683510f, 0.02040591f, 0.02489270f, 0.01338883f, 
    -0.01311272f, -0.00493037f, -0.00191480f, -0.03427416f, -0.03143368f, 0.02754264f, -0.02860838f, -0.02588341f, 
    -0.00326554f, -0.02954539f, 0.02850628f, -0.02429746f, 0.01962782f, 0.02723474f, -0.01342909f, 0.00567644f, 
    0.00539058f, -0.01046346f, 0.02146968f, -0.02523040f, -0.02249672f, -0.03688813f, 0.02407903f, 0.01681975f, 
    0.02639134f, 0.02093623f, 0.01328046f, -0.03501937f, 0.01211555f, -0.00948502f, -0.00113753f, 0.01917363f, 
    -0.00841438f, 0.00824238f, 0.01590844f, -0.03539596f, -0.00878963f, -0.01374569f, -0.03692795f, 0.00067292f, 
    0.02720096f, -0.02156340f, -0.04083365f, 0.00968338f, -0.03266310f, -0.01142009f, -0.02358785f, 0.00460228f, 
    0.00096079f, 0.00410287f, 0.00528250f, 0.01886974f, -0.02982339f, -0.03860728f, -0.03734090f, 0.00408584f, 
    -0.02210838f, -0.01425068f, 0.01780450f, 0.02713458f, -0.03896858f, -0.00264336f, 0.02616401f, 0.01079278f, 
    0.02622679f, 0.00527529f, 0.00805973f, -0.00649143f, 0.01125813f, -0.02260020f, 0.00941568f, 0.01031425f, 
    0.00130397f, 0.00769135f, 0.02076023f, 0.02377178f, -0.01428971f, 0.00525196f, 0.00484176f, -0.04104077f, 
    -0.01245194f, 0.00381003f, 0.00858473f, 0.01189994f, 0.02979023f, -0.00642627f, -0.00415416f, 0.02280094f, 
    0.00720831f, 0.01494055f, -0.01655462f, -0.01587664f, 0.02168164f, -0.00664438f, 0.02754731f, -0.03849769f, 
    0.02399539f, 0.00885439f, -0.00647686f, -0.02254531f, 0.00130149f, -0.01058329f, -0.03888802f, -0.01594325f, 
    -0.04206683f, 0.01664389f, 0.01532712f, -0.03754823f, 0.03158322f, -0.00360487f, 0.02515680f, -0.02790247f, 
    -0.03524628f, -0.00534167f, -0.03165201f, -0.01327295f, -0.03022297f, 0.01146121f, -0.03315965f, 0.02054871f, 
    -0.01784064f, -0.00787038f, 0.02110673f, 0.02763225f, -0.04012109f, -0.01618386f, 0.01918053f, 0.02087294f, 
    0.01917160f, -0.03346656f, -0.00983569f, 0.01450829f, 0.01272440f, 0.02905200f, -0.03883067f, -0.03748753f, 
    0.00961497f, -0.03390954f, -0.00642847f, 0.02072489f, 0.03160241f, 0.02800279f, 0.02701668f, 0.01775563f, 
    0.02246964f, -0.04149587f, 0.02354281f, -0.03155496f, -0.03559279f, -0.00066534f, -0.00637888f, -0.02142522f, 
    -0.01407051f, -0.03476647f, -0.00819761f, -0.02778187f, -0.00666454f, -0.01750181f, 0.02415407f, -0.01193441f, 
    0.00375133f, 0.00987583f, 0.02543198f, -0.02004404f, -0.00405213f, -0.00504644f, -0.01822707f, -0.01509514f, 
    -0.02611294f, 0.01273337f, -0.03486424f, -0.02846635f, -0.03705565f, -0.02017947f, -0.03520501f, -0.01485738f, 
    -0.02149956f, -0.02395533f, 0.01030866f, -0.00653867f, -0.01603423f, 0.02557795f, 0.01019240f, -0.02372032f, 
    -0.03396058f, -0.03570343f, -0.03121392f, 0.00381044f, -0.01116143f, 0.02397322f, -0.03240136f, -0.00800332f, 
    0.01904863f, -0.00219269f, -0.00841251f, 0.02697060f, -0.03542203f, 0.00350615f, 0.01494988f, 0.01993410f, 
    -0.00826984f, -0.02179045f, -0.01427279f, 0.01339337f, -0.01264867f, 0.00379014f, -0.00831201f, -0.04166164f, 
    0.02290560f, -0.03895662f, -0.03788043f, -0.04098446f, 0.01071914f, -0.02329715f, -0.01262020f, -0.00451509f, 
    0.01092882f, -0.03730892f, -0.01783263f, 0.02132734f, -0.02194022f, 0.02213478f, -0.00818938f, -0.03901505f, 
    -0.02631672f, 0.00176435f, 0.02073000f, 0.00915651f, -0.02046983f, 0.01103175f, 0.02486660f, -0.01486562f, 
    0.02280123f, 0.00053874f, -0.01190649f, 0.02721662f, 0.00673328f, 0.00071588f, -0.03542520f, 0.01961707f, 
    -0.01736375f, 0.01272929f, 0.01223684f, 0.02848450f, 0.01830140f, -0.02804503f, 0.00070830f, -0.00169952f, 
    0.02490250f, -0.02553091f, -0.03241288f, 0.02290311f, -0.03568779f, 0.01089502f, -0.02546491f, -0.04182253f, 
    0.01688370f, -0.03776116f, 0.00222840f, -0.03732141f, -0.02272480f, 0.01534431f, -0.01486669f, 0.00351268f, 
    0.00424220f, -0.02008390f, -0.01261252f, -0.02568621f, 0.00498299f, -0.02637926f, -0.03633851f, -0.01394768f, 
    -0.00603221f, -0.02647293f, -0.03102704f, 0.00296623f, -0.01545036f, -0.02089436f, 0.00729662f, -0.00658971f, 
    0.00209120f, 0.02353338f, 0.00248055f, -0.01627226f, -0.00173250f, 0.01077764f, -0.00082334f, -0.01652381f, 
    0.02840409f, -0.02053469f, -0.03094121f, -0.03226167f, -0.02053255f, -0.03163574f, -0.01245722f, 0.01069957f, 
    -0.02778528f, -0.00381521f, -0.01225022f, 0.01135420f, -0.02000215f, -0.00490662f, 0.01082910f, 0.02644832f, 
    -0.03112975f, 0.00801564f, -0.00046006f, -0.01746339f, -0.00399767f, -0.03682924f, 0.01317783f, 0.02643870f, 
    0.02606397f, 0.00735241f, -0.01283644f, -0.03436926f, -0.04038370f, -0.03416013f, -0.00975196f, 0.02552476f, 
    -0.02368347f, 0.02236527f, 0.00296849f, -0.03527546f, -0.02873944f, -0.03095501f, -0.03109914f, 0.02717714f, 
    0.01473347f, 0.00733062f, -0.03395110f, -0.00722158f, -0.03209373f, -0.02831182f, -0.03172819f, -0.03463389f, 
    -0.01133364f, 0.00897668f, 0.01821684f, -0.02062959f, 0.01360223f, 0.00119429f, 0.01027707f, -0.03853397f, 
    0.02916066f, -0.02298294f, -0.03548817f, -0.00026816f, -0.03199234f, -0.02860080f, -0.03999872f, -0.04050978f, 
    -0.02375509f, 0.02562662f, 0.01072966f, 0.00483914f, -0.00789699f, 0.03157569f, 0.01617846f, -0.01414030f, 
    -0.04101185f, 0.02531048f, -0.01241758f, -0.03604526f, -0.01388776f, 0.02598764f, 0.01229164f, -0.03239204f, 
    0.02728155f, -0.01602489f, -0.00926823f, 0.00289066f, -0.02091018f, -0.03937062f, -0.03711449f, -0.00863011f, 
    0.02566584f, -0.03451715f, 0.01442993f, 0.00326838f, -0.03010504f, -0.02036299f, 0.02426472f, -0.01698536f, 
    -0.03265592f, 0.02008352f, -0.03674766f, 0.01960603f, 0.02831264f, 0.01605061f, -0.03216596f, 0.00423038f, 
    0.02705282f, 0.02443809f, -0.00907699f, -0.01233529f, -0.02523243f, -0.01193321f, 0.00201623f, 0.00229650f, 
    -0.03568410f, -0.01198460f, -0.00166419f, 0.00040452f, -0.00453985f, -0.00938448f, 0.01055375f, 0.02781328f, 
    0.00009395f, -0.03887847f, -0.00830481f, 0.02416724f, 0.01515813f, -0.01750617f, -0.00975631f, -0.02943210f, 
    -0.00690661f, 0.01895747f, 0.02928027f, 0.00882945f, 0.00887710f, 0.01436968f, -0.02674854f, -0.03561860f, 
    -0.01737165f, 0.02179518f, 0.01011046f, -0.02072420f, -0.00300573f, 0.02094954f, -0.02574946f, 0.02172906f, 
    0.02307184f, -0.02147582f, -0.04154229f, -0.00801910f, -0.02766670f, 0.00097548f, 0.02772846f, -0.03587581f, 
    -0.02921984f, -0.01233196f, 0.01835687f, 0.00352602f, -0.00625952f, -0.02107129f, -0.00217667f, -0.01119523f, 
    0.03008471f, 0.00603527f, -0.02191021f, 0.00537205f, 0.02717727f, -0.01374900f, 0.01285277f, -0.03001995f, 
    -0.03493408f, -0.02075579f, 0.02310417f, -0.02746835f, 0.01578256f, -0.02233432f, -0.04159519f, 0.02497169f, 
    0.00506475f, -0.00705541f, -0.03841429f, 0.01890669f, -0.00297513f, -0.00166264f, -0.02800077f, 0.00468198f, 
    -0.02669932f, 0.02227446f, 0.01466366f, -0.03801343f, -0.03613025f, -0.02695498f, -0.03345084f, -0.01334023f, 
    0.01676759f, -0.01794690f, -0.03647761f, 0.00680953f, 0.01619290f, 0.02448325f, -0.03140842f, -0.00434243f, 
    -0.03094369f, -0.01648961f, -0.01689016f, -0.02659658f, -0.03585851f, -0.03293049f, 0.01744715f, -0.02134891f, 
    0.02657484f, 0.01747332f, 0.00431937f, 0.03206496f, -0.02951019f, 0.03034869f, -0.01010840f, -0.03997918f, 
    0.00198554f, 0.01391438f, -0.00247788f, 0.00855577f, 0.00585189f, 0.01829600f, -0.01635168f, -0.04107949f, 
    -0.03056294f, 0.00195536f, -0.03451053f, -0.02036941f, 0.00021511f, -0.03219168f, -0.03575100f, -0.03450541f, 
    0.02211033f, 0.01813694f, -0.00036697f, -0.02234070f, 0.01580217f, -0.00275726f, -0.01785536f, -0.00909962f, 
    -0.00310338f, -0.01490285f, -0.01759111f, -0.03646966f, -0.02394742f, -0.02454193f, 0.01187501f, 0.02298490f, 
    0.00793652f, -0.00203352f, -0.02331047f, -0.03810241f, 0.01072528f, -0.03161948f, 0.02541472f, -0.00709396f, 
    -0.02780587f, 0.01302163f, 0.00140946f, 0.00668581f, 0.01600564f, -0.00820524f, -0.01056621f, 0.01025954f, 
    -0.00746356f, 0.01949387f, 0.02462274f, -0.01661562f, -0.03088689f, 0.02413384f, -0.02955579f, 0.02771590f, 
    0.01585266f, -0.03156505f, -0.00970032f, -0.03854680f, 0.01365728f, 0.01269402f, 0.00590870f, -0.02309055f, 
    0.00354336f, -0.01393210f, 0.02000416f, 0.02168115f, 0.00459053f, -0.02745781f, -0.01913660f, 0.00850420f, 
    0.00736132f, -0.02370141f, -0.01851740f, 0.00737649f, -0.03123577f, 0.01780359f, -0.01280348f, 0.00498544f, 
    -0.01948021f, 0.01681837f, -0.02462416f, -0.04065267f, -0.02271555f, -0.00035498f, 0.01013449f, -0.00460112f, 
    -0.00026948f, -0.02832843f, -0.00205789f, 0.00132880f, -0.02212223f, -0.00798809f, -0.01863534f, -0.01589343f, 
    0.00306568f, -0.00875095f, -0.02255774f, -0.01046039f, -0.00391867f, -0.02230945f, 0.00963671f, -0.01564950f, 
    -0.01037876f, -0.00630708f, 0.01554795f, 0.00553325f, 0.00951384f, -0.03624149f, -0.00071601f, 0.01182836f, 
    -0.03653279f, -0.01263864f, -0.00244468f, -0.03237485f, 0.00506336f, -0.01913333f, 0.00807714f, -0.02810545f, 
    0.00933675f, -0.03155856f, -0.02892710f, 0.00098130f, -0.02887339f, -0.01274802f, 0.02667917f, -0.03337010f, 
    -0.03081459f, -0.04092302f, -0.03630416f, -0.00118305f, -0.03740536f, -0.02632282f, 0.00122965f, 0.02367887f, 
    -0.00206551f, 0.02636048f, 0.02826101f, -0.01753240f, 0.02523477f, 0.00537907f, -0.00415446f, 0.03190217f, 
    -0.00414659f, -0.00151113f, -0.03862436f, -0.04086268f, -0.01308681f, -0.00075734f, 0.01371614f, -0.02169172f, 
    -0.03731229f, -0.01550178f, -0.00592917f, -0.03360716f, -0.02492261f, 0.02684650f, 0.02237398f, -0.01227571f, 
    0.02648328f, -0.02050111f, 0.01976400f, -0.02901156f, -0.04151459f, -0.03187644f, 0.00324085f, 0.02143955f, 
    -0.01108479f, -0.00780559f, 0.01057061f, 0.02602371f, 0.00322750f, 0.01201387f, 0.00339338f, 0.02896123f, 
    -0.03759624f, -0.00923802f, 0.01488217f, 0.01478656f, -0.02068750f, 0.02580713f, -0.01779385f, -0.03271464f, 
    -0.01606124f, -0.00311176f, -0.00991284f, -0.01560269f, -0.00769353f, 0.03010930f, 0.00789650f, 0.00955800f, 
    -0.02118033f, 0.01739990f, -0.00063485f, -0.02401237f, 0.02844422f, 0.01278243f, 0.00850270f, -0.01925852f, 
    0.02208503f, 0.02397025f, -0.01180992f, -0.03169733f, -0.02790534f, -0.03267337f, -0.02063919f, -0.02507718f, 
    0.02076768f, -0.00030618f, -0.00673328f, -0.00591618f, -0.03952396f, -0.00122407f, -0.01959942f, -0.01363775f, 
    -0.03522582f, 0.01470533f, 0.01121488f, 0.02237264f, -0.01435597f, 0.00535903f, 0.01864008f, 0.01009737f, 
    -0.03276946f, 0.02274600f, -0.03953885f, -0.01447427f, -0.01138085f, -0.02684885f, 0.01870926f, -0.02943348f, 
    0.01148732f, -0.02546001f, -0.00579587f, -0.00042702f, -0.01183454f, -0.04147507f, -0.02690955f, 0.01301022f, 
    -0.04080038f, -0.01045591f, 0.01591457f, 0.00045872f, 0.02618489f, 0.02793184f, 0.02497918f, 0.01664344f, 
    0.01404417f, 0.01588634f, 0.00610287f, -0.01717322f, -0.01207250f, -0.00786123f, 0.00951288f, 0.02535383f, 
    -0.03825235f, -0.03613465f, 0.02594130f, -0.03267501f, -0.01985155f, 0.01500118f, -0.01924165f, 0.01565191f, 
    0.00836910f, 0.02461356f, 0.02882135f, -0.01732723f, -0.00714604f, -0.03237497f, 0.00646042f, 0.00349514f, 
    -0.02837912f, -0.03802850f, -0.03931327f, -0.02695005f, -0.01399447f, 0.01710999f, 0.00989664f, -0.02996377f, 
    -0.00868934f, -0.01547479f, -0.01190365f, -0.03671949f, -0.01558468f, -0.00531328f, 0.00683533f, 0.01083306f, 
    -0.02931468f, -0.00193016f, 0.00394551f, -0.02528670f, -0.03944036f, -0.02762338f, -0.02897961f, 0.02170131f, 
    -0.03269109f, 0.02493017f, 0.01249110f, 0.01941570f, 0.00169808f, 0.01547532f, 0.02392947f, -0.03006400f, 
    -0.02164609f, -0.01211099f, -0.01352941f, -0.00576492f, -0.02517892f, -0.01273656f, 0.01128925f, -0.00195592f, 
    -0.01914049f, 0.00192863f, -0.00169801f, -0.01965476f, -0.02503706f, 0.02025879f, -0.03215944f, 0.01520369f, 
    -0.00376005f, -0.02527640f, 0.01929267f, 0.00147032f, -0.03208562f, 0.01429961f, -0.03121575f, 0.02268831f, 
    0.01433022f, -0.01627682f, 0.01996989f, 0.00714073f, 0.02058312f, -0.02447778f, -0.03901177f, -0.01484077f, 
    -0.00608068f, -0.00412734f, 0.01130556f, 0.00933133f, 0.00302159f, -0.03677063f, -0.02961834f, -0.02339797f, 
    -0.02311002f, 0.01085070f, -0.01463514f, 0.01948923f, 0.02644385f, -0.01701881f, -0.02734832f, 0.02466999f, 
    -0.03803551f, 0.02291897f, 0.00457569f, -0.03519448f, -0.02393343f, -0.04006314f, -0.02340815f, -0.01822658f, 
    -0.00572986f, 0.03001948f, -0.02431039f, -0.00045664f, 0.02105242f, -0.01362482f, -0.00041819f, -0.00214292f, 
    -0.03173347f, 0.02548224f, -0.03712679f, 0.00566852f, 0.02340995f, -0.03353594f, -0.02583238f, -0.01416797f, 
    -0.02218738f, 0.01949848f, -0.03401817f, -0.03471370f, -0.03548975f, -0.04067079f, 0.01196684f, -0.02576564f, 
    0.01737589f, -0.00872140f, -0.03921207f, -0.00672675f, -0.02984741f, 0.02264588f, -0.02331139f, 0.02147444f, 
    -0.03183996f, 0.02062171f, -0.00366718f, 0.02746939f, -0.00149111f, -0.01235963f, -0.02966624f, -0.03472086f, 
    -0.01556589f, 0.00766784f, 0.00256231f, -0.00775981f, 0.00555618f, -0.01276010f, 0.02759396f, -0.01951073f, 
    -0.01034479f, -0.01907420f, 0.02605696f, 0.02784965f, -0.00729749f, 0.02151206f, -0.02236721f, 0.01712885f, 
    -0.03708075f, -0.00492626f, 0.01130301f, 0.01532547f, -0.03562615f, 0.01101800f, 0.00341244f, -0.00812234f, 
    0.00662209f, -0.03194074f, -0.03013567f, -0.02398238f, 0.02073817f, -0.00501581f, -0.00638359f, 0.02697043f, 
    -0.01403912f, -0.02638461f, -0.03635083f, -0.00545044f, 0.00847960f, 0.01681652f, -0.02405320f, 0.02936515f, 
    0.00356046f, 0.00523971f, 0.01441862f, -0.03774384f, 0.01792208f, 0.01532579f, -0.00249093f, -0.01156570f, 
    -0.01745810f, -0.02904875f, 0.00505715f, -0.00769845f, -0.01148392f, 0.00847975f, -0.03525285f, -0.00003114f, 
    -0.04082061f, -0.01919142f, 0.02538159f, -0.03739943f, -0.02283021f, 0.02824962f, -0.01118765f, 0.03179604f, 
    0.01261503f, -0.03282148f, -0.01357205f, -0.02342222f, -0.00612429f, 0.01128961f, -0.00023751f, -0.01088113f, 
    0.01678796f, 0.01644522f, -0.01102813f, 0.02843836f, 0.00899058f, -0.03580859f, 0.02855455f, 0.01028577f, 
    -0.01305248f, -0.00030333f, 0.00679670f, -0.03516019f, 0.02340576f, -0.02106667f, -0.03420626f, -0.01700229f, 
    0.01953169f, -0.02349704f, -0.02843592f, 0.01336492f, -0.00170138f, -0.03552320f, -0.00245209f, 0.00085471f, 
    -0.02733839f, -0.01680492f, 0.01206667f, -0.00451795f, -0.02927138f, -0.01795682f, -0.00343201f, 0.00612625f, 
    -0.00633510f, -0.03796068f, -0.03400072f, -0.01651159f, 0.01549683f, -0.03660567f, -0.01621067f, 0.01287617f, 
    0.00362018f, 0.01354803f, 0.03276528f, 0.02588054f, -0.02150094f, -0.02632189f, -0.03134955f, 0.01770951f, 
    -0.03522144f, 0.01818910f, 0.00382780f, -0.03542553f, 0.00808578f, -0.01642511f, -0.03065873f, -0.04131038f, 
    0.00287882f, -0.01182769f, -0.03015469f, -0.03208730f, -0.01589620f, -0.01693682f, -0.03974733f, 0.00748233f, 
    0.02660824f, 0.00331354f, 0.01818244f, -0.03685637f, 0.00787115f, -0.03702698f, -0.03524869f, -0.01823981f, 
    -0.01163845f, -0.00022412f, 0.01331869f, -0.03435907f, -0.01131321f, -0.00852075f, -0.02164403f, 0.01087320f, 
    -0.03474897f, 0.00939229f, 0.01982190f, -0.00108661f, 0.01399990f, -0.00271028f, -0.03543018f, -0.03214376f, 
    -0.02511796f, 0.00421447f, -0.03218336f, 0.00645830f, 0.00529836f, 0.02792955f, -0.02315900f, -0.03550037f, 
    -0.02332455f, 0.01515372f, -0.00593574f, -0.03895090f, 0.02750111f, -0.02053157f, 0.00027928f, -0.02330571f, 
    0.02512182f, -0.01389411f, -0.03696141f, -0.01323977f, -0.02632686f, -0.02998565f, 0.00763850f, -0.01807144f, 
    0.02038276f, -0.04102945f, -0.01843956f, -0.00345341f, 0.01048266f, 0.01753547f, 0.00066013f, -0.02594429f, 
    -0.01054997f, 0.02212964f, -0.01194840f, -0.00126645f, -0.00118938f, 0.01369555f, 0.01363564f, 0.00605451f, 
    -0.03770416f, 0.00555144f, -0.02040436f, 0.00986474f, 0.02076171f, -0.03450778f, -0.02129098f, -0.02747587f, 
    -0.02070638f, 0.00418935f, 0.00364740f, 0.01220314f, 0.02668843f, -0.04107860f, -0.02501149f, -0.01461068f, 
    0.02777828f, -0.01046962f, -0.03793023f, -0.00776839f, 0.02259276f, -0.00884926f, -0.01260723f, 0.01150195f, 
    0.01687710f, -0.01820138f, -0.00064788f, -0.02970558f, -0.00210053f, 0.01514622f, 0.01682767f, 0.00888351f, 
    0.00607595f, -0.00553816f, -0.03042319f, -0.03062163f, 0.02321155f, -0.00934055f, -0.02380789f, 0.01029328f, 
    0.00518666f, -0.02320398f, 0.02479757f, -0.03121579f, 0.00078713f, 0.02387998f, 0.00892690f, -0.04143873f, 
    -0.02830231f, -0.01152095f, -0.00488968f, -0.00026624f, -0.01516656f, -0.02713524f, 0.02022376f, -0.01849804f, 
    0.01227778f, 0.01489957f, -0.02435434f, -0.01000192f, 0.01494866f, -0.00909749f, -0.03280495f, 0.00385318f, 
    -0.04321837f, -0.03650679f, -0.01376860f, 0.02537188f, -0.00138777f, -0.04131795f, -0.02283376f, 0.00281376f, 
    -0.00699912f, -0.01354583f, 0.00590582f, -0.02979254f, -0.03117528f, 0.00940030f, -0.04073259f, 0.00048279f, 
    0.00468121f, -0.03028635f, -0.02740379f, 0.00152380f, 0.01569048f, -0.01949450f, 0.01070544f, -0.02670429f, 
    0.01603415f, 0.01201006f, 0.00841991f, -0.01689169f, -0.00663056f, -0.02786704f, 0.01218762f, -0.00912213f, 
    -0.01519418f, 0.00533249f, -0.03974774f, 0.02757354f, 0.01954854f, 0.00667523f, -0.02054433f, 0.01559752f, 
    0.00709847f, -0.00089905f, -0.02154911f, -0.01956762f, 0.00873683f, -0.02641025f, 0.00440313f, 0.02354141f, 
    0.02654698f, -0.03362191f, -0.02080663f, 0.00387706f, -0.00595769f, -0.03635133f, -0.03323926f, 0.01254623f, 
    0.01594606f, -0.03206528f, -0.01526672f, -0.03107921f, 0.00063209f, 0.01745440f, -0.03881360f, -0.00679411f, 
    0.02916995f, -0.03734371f, -0.01904365f, -0.02436610f, 0.00339771f, -0.03940598f, -0.01216373f, -0.03990263f, 
    -0.00569829f, 0.01674720f, 0.01005723f, -0.02756945f, -0.00570749f, 0.02764952f, 0.02841231f, 0.02157542f, 
    0.01533976f, -0.00375757f, 0.00932539f, 0.00195004f, 0.02708481f, -0.00815315f, -0.00290452f, -0.00724695f, 
    -0.03934686f, 0.02507152f, -0.03540462f, 0.01507629f, 0.00256994f, -0.00659499f, -0.03455171f, -0.02431658f, 
    -0.00850711f, 0.01059109f, -0.02897268f, -0.03512707f, -0.01633699f, -0.00522661f, -0.00096808f, -0.00301757f, 
    -0.00545360f, -0.04001492f, 0.01778415f, 0.01018106f, -0.01015855f, -0.00823246f, -0.01668495f, 0.02443618f, 
    -0.01933314f, 0.01395759f, 0.02597452f, -0.02016147f, 0.02555335f, 0.00613043f, -0.02219972f, -0.02713519f, 
    0.01639408f, -0.01149092f, -0.02035986f, -0.03392560f, -0.03373468f, 0.01932644f, 0.01232297f, 0.02572039f, 
    -0.01827434f, 0.00884376f, -0.00225406f, -0.00010258f, -0.01265904f, -0.01970673f, -0.03928513f, -0.03709460f, 
    -0.00024000f, -0.03420434f, -0.03492909f, -0.01394417f, -0.03726155f, -0.03941082f, -0.03168780f, 0.01121943f, 
    0.01354141f, -0.00712230f, 0.01030147f, -0.03801519f, 0.02902368f, -0.00760812f, 0.01420738f, 0.00021248f, 
    -0.04075300f, -0.01890251f, 0.02538490f, 0.01254513f, -0.03739879f, 0.00454029f, 0.01394192f, 0.01422817f, 
    0.02084133f, -0.01929772f, -0.01024816f, 0.01041613f, -0.00833955f, -0.00086732f, 0.01523819f, 0.03007836f, 
    -0.01440233f, 0.02741330f, -0.00071967f, -0.00707135f, 0.01474795f, -0.01719665f, -0.03893463f, 0.01767851f, 
    0.02234588f, -0.03434221f, 0.00162666f, -0.02214527f, -0.02163779f, -0.02405269f, 0.02137879f, -0.02800302f, 
    -0.01520472f, -0.03177521f, 0.02254086f, -0.02474215f, -0.00687332f, 0.01546061f, -0.00751883f, -0.02458522f, 
    -0.03539180f, 0.01217912f, -0.01514218f, -0.02758097f, 0.03540407f, -0.03626946f, -0.04080864f, -0.02091629f, 
    0.02728802f, 0.02734461f, -0.01388325f, 0.01016681f, -0.00341710f, -0.02759931f, -0.03603715f, 0.00469543f, 
    -0.03114214f, -0.04374173f, -0.03365384f, -0.04251852f, 0.02394346f, 0.03663170f, -0.02994318f, -0.03042135f, 
    -0.01296274f, -0.03214647f, 0.03536531f, 0.01372444f, -0.01447198f, -0.03466225f, -0.00889224f, -0.02585175f, 
    0.01444711f, -0.00721652f, -0.00782113f, -0.01774419f, 0.00593818f, -0.02710279f, -0.03007913f, 0.02691045f, 
    -0.03751799f, -0.00307388f, -0.02233950f, 0.01981077f, -0.03912053f, 0.02331209f, 0.03543813f, 0.01185991f, 
    -0.03148071f, -0.02761279f, -0.04111259f, -0.03568976f, -0.02089054f, -0.03993383f, 0.02309747f, 0.00477787f, 
    0.00785733f, 0.01338735f, 0.02904790f, 0.00713321f, 0.01732545f, -0.00455562f, -0.02301718f, 0.01436127f, 
    -0.01587658f, -0.00467809f, 0.00431214f, -0.01017259f, -0.04002477f, 0.02031355f, 0.02722968f, 0.02446276f, 
    -0.02587793f, -0.04011764f, -0.00424025f, 0.02312472f, -0.03241013f, -0.02721030f, -0.02749835f, 0.00463343f, 
    0.00844878f, -0.00826274f, -0.01983742f, 0.01189721f, 0.00854665f, -0.04109197f, 0.01581234f, 0.01691009f, 
    -0.01816540f, -0.01985577f, -0.03273389f, -0.03145198f, 0.02552101f, -0.01035257f, -0.02632621f, 0.02200682f, 
    -0.00352816f, -0.02113735f, -0.00948354f, -0.02118355f, 0.01448160f, -0.03641485f, -0.03910970f, -0.02383228f, 
    -0.00840283f, -0.01926733f, -0.01258849f, 0.00526354f, 0.02715936f, -0.00438384f, -0.01789171f, 0.01812798f, 
    0.00088666f, -0.00123687f, 0.02112106f, -0.02623425f, 0.01293451f, -0.03542294f, 0.00957536f, 0.00758158f, 
    -0.00985079f, 0.02940989f, 0.01234759f, 0.02831956f, -0.01712833f, 0.01125911f, 0.00033055f, 0.01670664f, 
    -0.03311219f, 0.02581297f, 0.00345249f, 0.02134548f, -0.04039632f, -0.02336254f, 0.01276697f, -0.03087694f, 
    -0.01540186f, -0.00995593f, 0.00270066f, -0.01652795f, 0.02416144f, -0.00732909f, -0.03992728f, -0.00869700f, 
    0.02815909f, -0.03872357f, -0.04184514f, -0.00273772f, -0.01898742f, 0.00516817f, 0.02796659f, 0.02650451f, 
    -0.00784109f, 0.00166437f, -0.00965712f, -0.02224855f, -0.02599768f, -0.00465106f, -0.00769138f, 0.00995288f, 
    -0.03641743f, -0.01701458f, 0.01583901f, 0.00009193f, -0.00601036f, -0.03896811f, 0.02739315f, 0.00856751f, 
    -0.00685198f, -0.01266572f, 0.01735310f, -0.02953181f, -0.01871487f, -0.02016944f, 0.00855629f, -0.00072749f, 
    0.02995004f, 0.01607581f, 0.00265824f, -0.01972890f, 0.01518153f, -0.02732917f, 0.00161874f, -0.04051570f, 
    -0.00326047f, 0.02766505f, 0.00309679f, -0.02972334f, -0.00123709f, -0.01567459f, -0.02055355f, -0.02615080f, 
    0.01102588f, -0.00257230f, -0.03211798f, 0.01350693f, -0.01246511f, 0.00468369f, -0.00184823f, -0.02676099f, 
    0.00946947f, -0.00055135f, -0.02131565f, -0.02206877f, -0.00536663f, 0.02075247f, 0.00096848f, -0.00849025f, 
    0.02690471f, -0.00120583f, 0.00153441f, 0.01665325f, -0.00431353f, -0.02901389f, -0.02478444f, -0.00667806f, 
    -0.02759787f, -0.03851745f, 0.01010879f, -0.02437150f, -0.01051207f, -0.04224639f, -0.03771969f, -0.02142082f, 
    0.02249903f, -0.03191901f, 0.02677587f, -0.00385068f, -0.00211524f, 0.02398687f, -0.00582110f, 0.00747854f, 
    -0.00167603f, -0.00167726f, 0.01242597f, -0.00146413f, 0.02358767f, 0.02915210f, -0.00096551f, 0.02976507f, 
    0.01956121f, -0.03373349f, -0.02177626f, -0.03740646f, -0.00751879f, -0.02349518f, -0.03475139f, -0.04099217f, 
    -0.01748959f, -0.01447629f, -0.03962686f, 0.00274347f, -0.00716382f, -0.02670258f, -0.01567155f, -0.00734888f, 
    -0.03824787f, 0.02584080f, -0.02792982f, -0.00318353f, 0.02939268f, 0.02726463f, -0.01161828f, 0.01961859f, 
    -0.03218188f, 0.00120972f, -0.00186033f, 0.01745531f, -0.03485373f, 0.00920277f, 0.00111287f, 0.00255073f, 
    -0.02658898f, -0.01720743f, 0.00174008f, -0.00765411f, 0.00135046f, -0.03273008f, -0.00020252f, -0.03829190f, 
    0.00891219f, -0.00377034f, -0.00766344f, 0.02874073f, -0.04137224f, 0.01248220f, 0.01558730f, -0.00747511f, 
    -0.01860714f, -0.02012181f, -0.04191241f, 0.01260105f, -0.03980129f, -0.01147318f, -0.01953930f, -0.00726944f, 
    -0.01523029f, -0.00119282f, 0.01759505f, 0.02673734f, 0.00380560f, 0.01576564f, 0.02650893f, 0.00894371f, 
    0.00853449f, -0.01971959f, 0.01280410f, 0.01179056f, 0.00285470f, 0.02068514f, -0.04088934f, 0.00362404f, 
    -0.00996372f, 0.00075002f, 0.01737728f, 0.01551147f, -0.03609214f, -0.03446269f, 0.02682941f, -0.01783227f, 
    0.00028802f, -0.03203743f, -0.01296737f, 0.01376788f, -0.01636951f, -0.03873944f, -0.00662297f, 0.01041353f, 
    -0.03522832f, -0.00360401f, -0.01364960f, -0.00740081f, -0.03631742f, 0.02308725f, -0.03879865f, -0.02840476f, 
    -0.00262128f, -0.02092981f, -0.02333083f, 0.01948036f, 0.01779396f, -0.02748921f, -0.03527337f, 0.01001151f, 
    -0.02541319f, 0.00951463f, -0.02016301f, 0.01559359f, -0.03983650f, -0.02371651f, -0.03100409f, -0.00781621f, 
    -0.01114723f, 0.00446830f, 0.00303023f, -0.03876038f, -0.02684692f, -0.04050985f, -0.03111729f, -0.01721305f, 
    -0.00629580f, -0.02865808f, 0.00700023f, 0.02108606f, -0.00720632f, -0.04091347f, -0.03180808f, 0.02824524f, 
    -0.01266950f, 0.00647336f, 0.02193499f, -0.03211160f, 0.02697342f, 0.02578942f, -0.03855873f, -0.02140306f, 
    0.01881206f, -0.02598826f, -0.01492785f, -0.01296247f, 0.01129258f, 0.02716504f, 0.00290970f, -0.02754728f, 
    -0.02187707f, 0.01334282f, 0.00861442f, 0.00973804f, 0.01482022f, 0.01633803f, -0.00614589f, -0.02808445f, 
    0.00254641f, -0.01785022f, -0.02067066f, 0.00504622f, 0.02634812f, -0.01487482f, -0.00759766f, 0.01088603f, 
    -0.02528974f, -0.03527517f, 0.00018280f, -0.00079019f, -0.01917321f, 0.01850957f, 0.01301533f, 0.02325802f, 
    0.01301350f, -0.02367890f, 0.00511611f, -0.04187314f, 0.02097312f, -0.03950312f, -0.02500765f, -0.02388315f, 
    0.01922566f, -0.00000351f, -0.03932978f, -0.02691864f, -0.02889810f, -0.02374201f, -0.01562563f, -0.00189638f, 
    0.01441629f, -0.00909977f, 0.01005743f, -0.03048949f, 0.00323306f, 0.02178326f, 0.02222601f, 0.01075578f, 
    0.02444756f, 0.01946572f, -0.00647986f, -0.01608532f, 0.00053388f, -0.00943344f, -0.03284515f, 0.01031597f, 
    -0.03422540f, -0.04303118f, -0.03293457f, -0.03706365f, -0.02736498f, 0.00405364f, -0.02140887f, -0.03860774f, 
    -0.04201940f, -0.00775115f, 0.01186360f, 0.01194417f, 0.00673800f, -0.02599191f, -0.02547573f, -0.00229707f, 
    0.01476843f, 0.00787723f, 0.01215580f, -0.01235697f, -0.00070054f, 0.00245004f, -0.04152834f, -0.03555131f, 
    0.02208778f, -0.01365380f, -0.00617237f, -0.03631350f, -0.03447478f, -0.02100610f, 0.00109369f, -0.01986666f, 
    0.00861983f, -0.02815268f, -0.00476045f, -0.02391956f, -0.00388270f, 0.00366680f, -0.00946765f, 0.00153437f, 
    -0.03021419f, 0.02478457f, 0.01666113f, -0.00831528f, -0.00651069f, -0.00235764f, -0.02606121f, 0.00619097f, 
    -0.00701499f, 0.02464801f, 0.01546760f, -0.01385706f, -0.01809162f, 0.00457497f, -0.03772507f, -0.00794707f, 
    -0.03537723f, -0.00735238f, -0.01334272f, -0.03816098f, -0.01372414f, 0.01855907f, 0.01499271f, 0.02326926f, 
    -0.00591023f, -0.02112583f, -0.01169834f, -0.01392605f, -0.03953667f, 0.00664572f, -0.03017353f, 0.02410215f, 
    0.02498260f, -0.01050365f, -0.01509426f, 0.02628273f, -0.03528075f, 0.00191056f, -0.03774025f, -0.03422846f, 
    -0.03375597f, -0.01317851f, 0.02553486f, -0.00018506f, -0.00823660f, -0.00578639f, -0.01578095f, -0.03351501f, 
    -0.02515135f, -0.03661504f, 0.02714694f, -0.02743422f, 0.02936243f, 0.02576134f, 0.02088398f, -0.03991934f, 
    0.00411722f, 0.02106362f, -0.00672285f, -0.03030316f, -0.03228845f, 0.02894243f, 0.02891869f, -0.01467608f, 
    -0.46442270f, 0.10354611f, -0.07732638f, 0.22745401f, 0.04333021f, -0.07605724f, 0.07416154f, -0.07614454f, 
    0.08551946f, 0.03244648f, 0.17963280f, 0.06339931f, 0.06739792f, -0.13549720f, 0.03761258f, 0.09496059f, 
    0.24604860f, 0.05420831f, 0.24528907f, 0.14611141f, 0.01906678f, 0.07400972f, 0.05324807f, 0.06341806f, 
    -0.11070676f, -0.07098497f, -0.07702810f, 0.02464140f, -0.00856603f, 0.02727297f, -0.09810124f, 0.03803955f, 
    -0.10800764f, -0.03531336f, -0.11161599f, -0.00895355f, -0.16079435f, -0.29370144f, -0.05032055f, 0.03316301f, 
    0.04057994f, -0.04008912f, 0.09009345f, 0.18416725f, -0.04169777f, 0.10413852f, -0.01384384f, 0.02228259f, 
    0.43480361f, -0.09286764f, 0.03775596f, 0.11553550f, 0.04274899f, -0.02731836f, 0.00241854f, -0.02043280f, 
    -0.05328473f, -0.04165043f, 0.03803716f, 0.02865305f, -0.17636190f, -0.56135494f, -0.25054625f, -0.07642166f, 
    0.07981867f, -0.03644091f, 0.00115148f, -0.26456645f, -0.05025554f, -0.05400880f, -0.02879843f, 0.00407750f, 
    0.09666864f, 0.19850828f, 0.04674852f, -0.14481649f, -0.05261277f, -0.05154281f, -0.03235428f, -0.01466055f, 
    -0.00147581f, 0.00983028f, -0.04178574f, 0.01990056f, -0.18665241f, 0.08269632f, 0.09438476f, 0.03779515f, 
    0.11169416f, -0.13731594f, -0.11316148f, -0.01770678f, -0.02421374f, 0.06717747f, 0.01489027f, -0.02434896f, 
    0.15074874f, 0.09416946f, 0.13804509f, -0.08467152f, -0.03787344f, -0.09948299f, -0.01452602f, -0.11438803f, 
    -0.00660204f, -0.00230842f, -0.09079827f, -0.04637751f, -0.01652941f, -0.01703555f, -0.01531695f, 0.03688251f, 
    -0.05860534f, 0.00719690f, -0.07096369f, -0.03959285f, 0.02709351f, 0.00101708f, 0.04460020f, -0.02344528f, 
    0.08730204f, -0.12276621f, 0.05684015f, 0.33645335f, -0.06302869f, 0.01270178f, 0.09276672f, 0.06702732f, 
    -0.03526314f, -0.02143933f, 0.02471236f, 0.12169424f, -0.05747076f, -0.08956278f, 0.01300839f, 0.05679390f, 
    -0.16556805f, -0.04849279f, 0.01444641f, 0.06992731f, 0.00668812f, 0.00294192f, -0.12879182f, -0.02140781f, 
    0.01312009f, 0.09182106f, -0.04426610f, 0.01404092f, -0.06182341f, 0.01947124f, 0.04657828f, -0.04638233f, 
    0.03695751f, -0.04050197f, 0.02098361f, 0.02017454f, -0.38773948f, -0.20623200f, -0.02260136f, 0.33890191f, 
    -0.14887297f, -0.07634156f, 0.11200630f, -0.10043372f, 0.01038981f, -0.03692570f, -0.08490417f, -0.08178352f, 
    0.10526850f, 0.20805082f, 0.12685467f, -0.02725316f, -0.01747411f, 0.09855355f, -0.03497761f, -0.05395481f, 
    -0.05940481f, 0.04518475f, 0.01777869f, -0.02970509f, 0.15856640f, 0.11241431f, 0.01307422f, -0.07704537f, 
    -0.05316340f, -0.05209899f, -0.03886178f, -0.00431230f, 0.11731257f, -0.01571495f, 0.02446713f, 0.13818458f, 
    0.03599442f, 0.35481918f, 0.09931450f, 0.04911243f, -0.09972101f, -0.07243474f, -0.06199937f, -0.11984155f, 
    0.03942920f, 0.03862481f, 0.02161805f, 0.05101327f, 0.12144502f, -0.07173114f, -0.15402657f, -0.00365393f, 
    -0.01927171f, -0.04145303f, -0.00240858f, -0.03111919f, 0.06343326f, 0.01863114f, 0.22971687f, -0.04628661f, 
    -0.07147603f, 0.13352433f, 0.20319346f, 0.05233004f, -0.06733835f, -0.06439342f, -0.06265490f, 0.06120953f, 
    0.04598901f, 0.21886545f, 0.01316674f, 0.08451921f, -0.09342197f, -0.31462109f, 0.03354761f, -0.00386971f, 
    -0.07672508f, 0.05212728f, -0.06304950f, -0.17329669f, -0.00058401f, 0.00624723f, -0.02932437f, -0.03722259f, 
    0.09435841f, -0.07815673f, -0.29755658f, -0.05525379f, -0.04038141f, -0.05762940f, 0.09059643f, 0.03344591f, 
    0.10080445f, 0.08200411f, 0.05383025f, 0.07841770f, 0.04387941f, -0.00013982f, -0.00514058f, 0.01990308f, 
    -0.07057342f, -0.16498214f, -0.01939539f, -0.00500787f, 0.04603406f, 0.00508216f, 0.01711094f, 0.14929831f, 
    -0.16616210f, -0.14944331f, -0.27435794f, -0.08381243f, 0.19534554f, -0.15860204f, -0.10857818f, -0.14903983f, 
    -0.04044852f, -0.05829291f, -0.10412743f, -0.09680993f, 0.44596460f, -0.03660652f, -0.07804745f, -0.25963217f, 
    -0.03610213f, 0.03458928f, 0.06072428f, -0.02331894f, -0.08031276f, 0.00894324f, 0.17071795f, 0.04969839f, 
    0.17308766f, 0.12427336f, 0.23508701f, -0.16838209f, 0.03647305f, 0.10802994f, -0.00019326f, -0.05092871f, 
    0.01441331f, 0.01266888f, 0.04363732f, 0.08494059f, 0.01740634f, 0.08681330f, 0.03180415f, -0.05272767f, 
    0.01171203f, -0.03603299f, -0.02198653f, 0.01915461f, -0.02629490f, 0.05652075f, 0.03166034f, 0.06700966f, 
    -0.16289130f, -0.01149212f, -0.01774373f, 0.11678810f, -0.03680904f, 0.13158134f, 0.13607596f, -0.12154991f, 
    0.01988627f, -0.07995375f, -0.06438278f, -0.02143167f, -0.01047642f, 0.00216753f, 0.02586046f, 0.17617582f, 
    0.14757159f, -0.03439051f, 0.17132989f, -0.01451560f, -0.01352967f, 0.03199556f, 0.03212650f, -0.00063326f, 
    0.64369065f, -0.00483988f, -0.17065813f, 0.12321597f, 0.05082298f, 0.07479312f, 0.13662972f, 0.04387846f, 
    0.02202033f, 0.01222643f, 0.05826663f, -0.00024822f, 0.07917624f, -0.04962957f, -0.06812112f, -0.23353690f, 
    0.00598712f, 0.02074632f, -0.02311863f, -0.02949369f, -0.08870392f, -0.05842268f, 0.11039335f, 0.01224258f, 
    0.08135882f, -0.02798923f, -0.03906812f, -0.19830565f, -0.10944702f, -0.01097339f, 0.00349601f, 0.02867576f, 
    0.01681462f, 0.03712699f, 0.02817138f, -0.08500446f, -0.16853432f, -0.15113644f, -0.09842338f, -0.24334452f, 
    -0.10716302f, 0.00706977f, -0.04541131f, 0.05545143f, 0.10765240f, 0.14705767f, 0.06348963f, 0.05385597f, 
    -0.15841490f, -0.54706794f, -0.49405950f, -0.13258541f, -0.17877054f, -0.18122853f, -0.14849162f, -0.09189921f, 
    0.03338022f, -0.01428058f, -0.11020202f, 0.02530793f, 0.08188826f, -0.47989523f, -0.31226546f, -0.06502006f, 
    0.03859821f, -0.03437937f, 0.19779471f, -0.02221417f, -0.01072732f, -0.03420461f, 0.00152643f, -0.00854700f, 
    0.04937814f, 0.01203866f, 0.06931748f, 0.26191393f, 0.07034852f, -0.17803659f, -0.02758260f, 0.01005505f, 
    0.05200442f, -0.05858247f, -0.03775279f, -0.07958946f, -0.08953545f, -0.11258038f, -0.07724344f, 0.06910054f, 
    -0.13024689f, 0.01693114f, -0.14397126f, 0.02448377f, 0.05863360f, -0.04464581f, 0.04330257f, -0.00683953f, 
    0.08826005f, -0.40639237f, -0.18202431f, -0.47433579f, -0.17843118f, -0.12751237f, 0.00441775f, 0.01391456f, 
    -0.04261778f, 0.11868767f, 0.18572445f, -0.03183508f, -0.04014804f, -0.13916965f, 0.02746663f, -0.05045667f, 
    -0.07077979f, -0.00606176f, -0.05591475f, -0.06057683f, 0.01038627f, -0.03900137f, 0.14534023f, 0.05502325f, 
    -0.19228595f, -0.06719746f, -0.00647171f, -0.03564977f, -0.11552276f, -0.08372591f, -0.03257883f, -0.01021519f, 
    0.02412594f, 0.05634618f, 0.11146533f, -0.01574210f, 0.43328446f, -0.28858313f, 0.02011283f, 0.09643140f, 
    0.08251956f, -0.04254660f, -0.02199375f, -0.02924683f, 0.08417633f, -0.06076335f, 0.03830115f, 0.00324438f, 
    0.19898723f, -0.16357005f, -0.22631781f, -0.34824881f, -0.05397610f, 0.00129116f, 0.03937201f, 0.01008844f, 
    0.06024094f, 0.19541351f, 0.07396974f, 0.04998566f, 0.17594676f, 0.08601245f, -0.03384951f, 0.02466754f, 
    0.08107239f, 0.17743264f, 0.17977390f, 0.03551988f, 0.14316677f, 0.01988281f, 0.03213561f, 0.06955863f, 
    -0.07780822f, -0.03511404f, -0.05365048f, -0.02065574f, -0.16497016f, 0.01048378f, -0.03501007f, 0.13282689f, 
    0.04711270f, -0.08790565f, -0.02239320f, -0.05904237f, -0.13080536f, 0.02489110f, 0.08173132f, 0.11471795f, 
    -0.07125304f, -0.00341096f, -0.03337513f, -0.02211220f, -0.01187855f, -0.01365918f, -0.05361715f, -0.03452503f, 
    0.01121512f, -0.03885513f, -0.08552828f, -0.01725340f, -0.00337219f, 0.11622665f, 0.03128901f, 0.13013200f, 
    -0.02951082f, -0.00765090f, -0.00650720f, -0.05117705f, -0.14188811f, -0.29579571f, -0.21894673f, -0.08428866f, 
    -0.07142450f, 0.12633941f, -0.05818464f, 0.09013864f, 0.10281701f, 0.07022274f, 0.08179644f, -0.13138540f, 
    -0.27320835f, -0.22690359f, -0.19126494f, 0.02485833f, 0.08340850f, 0.08264405f, 0.13692527f, -0.00515529f, 
    0.06466473f, 0.04559383f, 0.03099989f, -0.01153479f, -0.17629281f, -0.14020747f, -0.05286763f, 0.15800522f, 
    -0.03404213f, 0.16884200f, 0.06924359f, 0.24144858f, 0.03158945f, -0.06786493f, -0.06236521f, -0.08510870f, 
    -0.21870513f, 0.07001016f, 0.19282579f, 0.06079119f, -0.00581792f, -0.07319371f, -0.03713546f, -0.02566675f, 
    0.03240822f, -0.05101665f, -0.03043895f, 0.01551967f, -0.38995513f, -0.46893322f, -0.23447278f, -0.07173073f, 
    -0.04196521f, -0.10941268f, -0.17399548f, -0.14109184f, -0.03702964f, -0.00510768f, -0.07118600f, -0.06214334f, 
    0.06835703f, -0.06583278f, 0.01763816f, -0.22251660f, 0.02249278f, -0.06351437f, -0.05648626f, -0.01174951f, 
    -0.02636081f, -0.03048396f, 0.18480395f, 0.01237676f, 0.13129005f, 0.19246139f, 0.08234939f, 0.14245279f, 
    -0.01871817f, 0.00529052f, 0.07427315f, -0.01903197f, -0.08955789f, 0.08027171f, 0.09810883f, -0.00571537f, 
    0.02011240f, -0.22421286f, -0.09450626f, -0.10148446f, -0.02638173f, -0.15692358f, 0.11765616f, 0.05508969f, 
    0.03312060f, 0.10750543f, -0.04979749f, 0.03220845f, -0.17649741f, 0.03771476f, 0.21124056f, 0.27008727f, 
    -0.01160695f, 0.06402850f, 0.22504312f, -0.07530992f, 0.00076707f, -0.05825910f, -0.07296243f, 0.04637617f, 
    -0.04041419f, 0.04445631f, 0.00335461f, -0.00902954f, 0.00795241f, 0.04281145f, 0.00694656f, 0.04664997f, 
    -0.15119757f, 0.00132984f, 0.04155280f, -0.03415788f, 0.05117702f, -0.12944895f, -0.12094556f, -0.20424360f, 
    -0.19525173f, 0.04451125f, -0.05151785f, -0.03138049f, 0.12525280f, 0.05435555f, 0.09675243f, 0.09255602f, 
    0.29767722f, 0.15021691f, 0.04398938f, -0.25805610f, -0.05111647f, -0.09323443f, -0.06616553f, -0.08844724f, 
    -0.06259482f, -0.03456748f, -0.00561414f, 0.08013161f, -0.05447937f, 0.01817984f, 0.13434297f, 0.04171019f, 
    0.00941519f, 0.07149475f, -0.03905580f, -0.01399737f, 0.01978527f, 0.02874275f, -0.03267689f, -0.06035154f, 
    -0.32298324f, -0.46018133f, -0.18192981f, -0.27487573f, 0.01682003f, -0.15437028f, -0.01327152f, -0.07619461f, 
    -0.05348496f, 0.02331350f, 0.00554255f, 0.03652354f, -0.27570644f, -0.13838071f, 0.05076073f, -0.19004202f, 
    0.20632362f, 0.04217939f, -0.07577320f, 0.04366453f, 0.07098208f, 0.09890065f, -0.01051532f, -0.02744765f, 
    -0.24871089f, 0.04736702f, -0.12291139f, 0.45022416f, -0.02953838f, 0.08286191f, 0.07470070f, 0.05020060f, 
    0.09018047f, 0.07708213f, -0.02562908f, -0.02344442f, 0.10066415f, 0.17674515f, -0.05431588f, -0.06140697f, 
    -0.08362265f, -0.06110460f, -0.01633527f, -0.07178050f, -0.01387325f, 0.02128978f, -0.00519385f, -0.05274527f, 
    0.10331843f, 0.05096101f, 0.05751916f, -0.02665965f, -0.10143943f, -0.06222122f, 0.05773470f, 0.12684931f, 
    -0.03598624f, 0.02112675f, -0.01300534f, 0.00358728f, -0.24395068f, -0.45888382f, -0.21155937f, -0.26123941f, 
    -0.01340147f, -0.02481270f, 0.06573935f, -0.03503915f, -0.10798215f, -0.04165804f, 0.02889413f, 0.04073426f, 
    -0.05445242f, -0.11099044f, 0.09008053f, 0.02246020f, -0.02385555f, -0.01094504f, 0.05678823f, 0.02718678f, 
    0.22297068f, 0.01794373f, 0.08913419f, 0.03373102f, -0.04576422f, 0.18756993f, 0.09470292f, 0.17765804f, 
    0.30329758f, -0.07055065f, 0.07766484f, 0.19662321f, 0.12685208f, 0.12900044f, -0.03651049f, 0.10607021f, 
    0.08268862f, -0.22764733f, -0.12050839f, 0.03331352f, -0.08643813f, -0.02508646f, -0.02205575f, 0.01152483f, 
    -0.09596743f, -0.15400767f, -0.12841608f, -0.16518570f, -0.17635362f, -0.03491248f, 0.04686514f, 0.12102794f, 
    0.04008223f, -0.08518870f, 0.21034497f, 0.14035028f, -0.08276282f, -0.09725419f, -0.04662909f, 0.02927436f, 
    0.06696963f, 0.14777571f, -0.18689606f, 0.04638454f, 0.14583904f, 0.12950589f, 0.13213380f, 0.15693919f, 
    0.01480211f, 0.06383388f, 0.03904800f, -0.01684890f, -0.05481143f, -0.01545734f, -0.08049265f, -0.12123804f, 
    0.00412441f, 0.04486303f, 0.05039269f, -0.07256123f, -0.01548037f, 0.06005276f, -0.00770720f, 0.09792098f, 
    0.13998108f, 0.11686239f, 0.19315828f, 0.00314849f, -0.04120363f, 0.02661462f, -0.03537357f, 0.12299722f, 
    -0.03163643f, -0.05270241f, 0.10881037f, 0.05585460f, -0.17954604f, -0.19478410f, 0.01983264f, -0.29373151f, 
    0.21381517f, 0.14295520f, -0.16437747f, 0.01991757f, -0.07019975f, 0.13499649f, 0.05100709f, 0.15226316f, 
    0.16308053f, 0.03031133f, 0.36348286f, 0.01475702f, -0.02463683f, -0.00840498f, -0.05776988f, -0.03490923f, 
    -0.07074267f, -0.03896462f, -0.00588118f, 0.00840393f, -0.05700175f, 0.06163414f, 0.06862299f, 0.14631814f, 
    -0.09150640f, -0.06133932f, 0.02657590f, -0.00526360f, 0.02353819f, 0.06187324f, 0.08778610f, 0.13428234f, 
    0.06488203f, 0.19420475f, -0.18268736f, 0.33775342f, -0.19112863f, 0.18709630f, -0.07639392f, -0.00412789f, 
    -0.02978000f, 0.04571962f, 0.05717981f, -0.06644382f, -0.13301098f, -0.12690854f, 0.07663454f, 0.06943595f, 
    -0.00378025f, 0.10395056f, -0.02034545f, 0.14137340f, -0.08098325f, -0.01708476f, 0.02832356f, -0.07261848f, 
    0.11331280f, 0.16868280f, 0.07869027f, 0.20620948f, 0.03684852f, 0.10523608f, 0.03467999f, 0.06845856f, 
    -0.03345294f, 0.00446468f, 0.05038606f, -0.10138065f, -0.21055532f, -0.19962010f, 0.03728486f, 0.28558362f, 
    0.05047189f, 0.09454396f, -0.10866263f, -0.09481297f, -0.11302885f, -0.04856364f, 0.02613300f, 0.06374658f, 
    0.14648634f, -0.35753822f, 0.40048850f, -0.08193134f, 0.00980559f, 0.00491056f, -0.13746572f, 0.02140309f, 
    -0.00336639f, 0.07005679f, -0.11203335f, 0.06219707f, -0.08531169f, 0.11426055f, 0.13456644f, -0.00197794f, 
    -0.04538024f, -0.06954420f, -0.02835716f, 0.02156785f, 0.10234259f, -0.06889467f, 0.16015184f, 0.07275486f, 
    0.02163348f, 0.11189348f, 0.03659837f, -0.21634187f, -0.10383455f, -0.02011784f, -0.07536972f, 0.03189608f, 
    0.02506416f, -0.13259539f, -0.01873884f, 0.01910669f, -0.23482403f, 0.27923226f, -0.07632101f, -0.08864698f, 
    0.01234343f, 0.04559734f, 0.04083773f, 0.06126937f, 0.04580788f, 0.12420915f, -0.13312894f, -0.17620155f, 
    -0.17576858f, 0.09876402f, 0.17510182f, 0.02822093f, -0.08817651f, 0.03482265f, -0.11025295f, 0.16998285f, 
    -0.01823509f, 0.02671499f, -0.06795899f, 0.14994061f, -0.15380870f, 0.06206349f, -0.07154928f, -0.02082953f, 
    0.11677831f, 0.10959796f, -0.07871244f, -0.12830560f, 0.09375218f, 0.09551951f, 0.01471709f, 0.02817391f, 
    -0.34976587f, 0.09523352f, -0.02865541f, 0.19160104f, -0.06341243f, 0.07313564f, 0.05560168f, 0.00513791f, 
    0.20371714f, -0.03232645f, 0.17851579f, -0.15573590f, -0.14568335f, 0.20353186f, -0.09940258f, 0.39051074f, 
    -0.15495791f, -0.07530568f, 0.04955974f, -0.02573810f, 0.17483425f, 0.00121481f, 0.12432507f, 0.06088531f, 
    -0.24117169f, -0.15503877f, -0.27366960f, 0.13686033f, 0.12953088f, -0.10748228f, 0.19115415f, -0.18263710f, 
    -0.10384281f, -0.05675850f, -0.01972383f, -0.04688864f, 0.18259773f, -0.09324594f, 0.16785051f, 0.01269322f, 
    0.11194815f, 0.08875079f, 0.04880328f, 0.18356642f, 0.03836755f, 0.03458467f, 0.12583731f, -0.00205562f, 
    0.09873354f, 0.16584837f, 0.22861119f, 0.01808009f, -0.03604652f, 0.04921978f, 0.13711610f, 0.18678884f, 
    -0.00767453f, 0.20115760f, 0.08121971f, 0.23071997f, -0.14723361f, 0.19140646f, -0.14081496f, 0.03788497f, 
    0.02108319f, -0.02364924f, -0.01477891f, 0.05902464f, 0.20820186f, -0.03123933f, -0.23444830f, -0.09156544f, 
    -0.24379905f, 0.17005675f, -0.01536714f, 0.10503869f, 0.01571865f, 0.15989617f, 0.04315149f, -0.07745879f, 
    -0.00709006f, -0.03128026f, -0.13369906f, -0.10334050f, -0.00727911f, 0.15564124f, -0.05411590f, 0.27143857f, 
    0.21416740f, 0.07122093f, 0.13829805f, -0.00777274f, 0.07254567f, 0.11924787f, -0.07717647f, -0.03962608f, 
    0.38395354f, 0.39181596f, -0.05866914f, 0.11977932f, 0.18418278f, -0.03848993f, 0.21386911f, 0.38752154f, 
    0.00986135f, 0.05650635f, -0.00637194f, 0.10933974f, -0.02665851f, -0.10034527f, -0.07198128f, -0.15835990f, 
    -0.01420662f, -0.09574611f, 0.06227274f, 0.00263759f, 0.05904234f, 0.09954032f, -0.02532682f, 0.03375953f, 
    -0.11987411f, 0.03760447f, -0.08144019f, -0.10196617f, -0.01962205f, -0.02038250f, 0.10979458f, 0.02250161f, 
    -0.10958707f, 0.02338705f, 0.12616746f, -0.08707789f, -0.57801491f, 0.18209217f, 0.10181265f, -0.02299141f, 
    -0.00539053f, 0.03181390f, 0.00329686f, 0.06410010f, 0.12458691f, 0.12120793f, -0.03746074f, -0.13257790f, 
    -0.21075471f, -0.01363735f, -0.27079865f, -0.41128436f, -0.14228353f, -0.08140926f, -0.01491411f, -0.15545550f, 
    0.11148244f, 0.07055901f, 0.01831815f, 0.04708604f, 0.02754063f, -0.25556526f, 0.11333463f, -0.11117209f, 
    0.03419437f, -0.01048594f, 0.06514753f, 0.04970111f, -0.02140201f, 0.04946911f, 0.09569686f, -0.05825395f, 
    -0.12731768f, -0.16097197f, 0.17527975f, 0.02542246f, 0.13554566f, -0.04282060f, -0.00829622f, -0.12200706f, 
    -0.15854186f, 0.05946117f, 0.09849635f, -0.05638741f, -0.03889148f, -0.11451034f, -0.05411329f, -0.01803306f, 
    -0.00210670f, 0.24413022f, -0.19400872f, 0.14660874f, 0.02773043f, 0.01074484f, 0.14597093f, 0.00380677f, 
    -0.25508997f, 0.04742045f, -0.02108264f, -0.27934766f, -0.09949054f, 0.05530655f, 0.05842359f, -0.13217711f, 
    -0.05483664f, 0.03600230f, -0.04827157f, 0.03397941f, -0.23390122f, -0.07114553f, 0.04677744f, -0.00037805f, 
    -0.10415071f, 0.00758513f, -0.10109664f, -0.01331743f, 0.13708179f, 0.07808099f, -0.03636424f, 0.31674275f, 
    -0.30363491f, -0.04759533f, 0.02498039f, -0.10822494f, -0.01816041f, 0.04145135f, 0.03980897f, -0.02774720f, 
    0.06007233f, 0.08272540f, 0.01142253f, -0.14307481f, 0.07049158f, -0.00075516f, -0.14797238f, 0.13386597f, 
    -0.16946651f, 0.18012920f, -0.10253049f, 0.11609398f, 0.06726179f, -0.02688194f, 0.06204788f, -0.01663779f, 
    -0.40232646f, 0.21840566f, -0.03011595f, 0.03136542f, 0.08949108f, 0.04987277f, 0.04074863f, 0.13743359f, 
    0.14834821f, 0.09622221f, -0.02632677f, 0.09156398f, 0.28495476f, -0.14012007f, 0.21308671f, 0.03594615f, 
    0.06635042f, 0.04319176f, 0.04648834f, 0.23685013f, 0.07911644f, 0.00244952f, -0.01155981f, -0.04356332f, 
    -0.22614816f, 0.02847659f, -0.00494387f, 0.05981801f, -0.10130731f, 0.03412552f, 0.02388081f, 0.03836994f, 
    -0.06540506f, 0.02474181f, -0.06084592f, -0.10126126f, -0.05173242f, 0.06102271f, 0.14482974f, 0.14757060f, 
    -0.08494004f, 0.10456281f, -0.09206974f, -0.06228691f, -0.13046645f, -0.00794480f, -0.07361943f, -0.02041312f, 
    0.32194039f, -0.36067078f, 0.40243816f, -0.22184646f, 0.11588520f, 0.09301962f, -0.04175450f, 0.09448446f, 
    -0.05347168f, 0.09900542f, 0.09656048f, -0.00697127f, -0.05307005f, -0.09783377f, -0.13891117f, 0.16850820f, 
    -0.04579270f, 0.15367551f, 0.14282814f, 0.17033519f, 0.01063832f, -0.04733212f, 0.01763437f, -0.04683057f, 
    -0.09905033f, 0.08313002f, -0.05788166f, -0.08627020f, 0.09605095f, 0.04984536f, 0.08666029f, -0.00976858f, 
    0.03114968f, 0.03797892f, -0.08703487f, -0.10393202f, -0.09834108f, 0.01648214f, -0.05511223f, 0.17366141f, 
    0.00067099f, -0.01528808f, 0.12080963f, 0.17605503f, -0.16609772f, 0.04884452f, -0.09137358f, -0.16224442f, 
    -0.06315254f, -0.05481323f, 0.17847592f, 0.20874605f, -0.01033643f, 0.00408382f, -0.07419644f, -0.01991407f, 
    0.01657605f, -0.01473745f, -0.05260668f, -0.04517337f, -0.23583077f, -0.30854899f, -0.22888102f, -0.22640736f, 
    -0.06744245f, 0.07256070f, -0.07091733f, -0.17151724f, -0.04722362f, 0.01576228f, 0.00834932f, 0.03912301f, 
    -0.12591223f, -0.04526538f, 0.06266260f, -0.12840861f, -0.09044570f, -0.00278368f, -0.05105640f, 0.07359148f, 
    0.08531088f, -0.04801326f, 0.27258828f, 0.20601158f, 0.20605478f, -0.08211186f, 0.22470199f, 0.20615308f, 
    -0.00899727f, -0.07843041f, 0.14460553f, 0.04124194f, -0.05085557f, 0.14240521f, 0.13202280f, 0.03710510f, 
    -0.21019576f, 0.07093381f, -0.10625690f, -0.01790037f, 0.04952979f, -0.09437244f, 0.06465370f, 0.04999834f, 
    0.13989855f, 0.04935515f, 0.13630611f, 0.12639597f, -0.04498405f, 0.05293591f, 0.14265831f, 0.12786438f, 
    0.13731854f, 0.16207843f, 0.12412867f, -0.02478741f, 0.18231870f, 0.09968760f, 0.15282042f, 0.03238295f, 
    -0.05200084f, -0.03498315f, -0.06983971f, -0.12880164f, -0.04682931f, -0.04036137f, 0.06382608f, 0.00170678f, 
    -0.10061917f, 0.12033685f, -0.04644743f, -0.36249608f, -0.25995028f, -0.19710021f, 0.22578855f, 0.00044469f, 
    -0.13982564f, -0.14109424f, -0.12082538f, -0.06793687f, 0.18144207f, -0.01697785f, 0.01212496f, 0.12993947f, 
    -0.14860009f, 0.06117713f, -0.04879089f, 0.05269866f, -0.10302091f, -0.08882982f, -0.04946184f, -0.05576593f, 
    -0.03563883f, -0.09766064f, -0.00664643f, 0.01065052f, -0.23359716f, 0.21256012f, 0.00604067f, 0.03996044f, 
    0.05808180f, 0.08093849f, 0.06547058f, -0.04296607f, -0.00748212f, -0.01416378f, 0.08345938f, 0.10334641f, 
    -0.29888359f, -0.18757351f, -0.18512547f, -0.20455307f, -0.06863482f, 0.00613659f, -0.07169779f, -0.02977334f, 
    0.04723960f, 0.00724592f, -0.02867618f, -0.03163985f, -0.11344092f, 0.06033562f, -0.03968964f, -0.15772399f, 
    0.10461432f, -0.06377785f, 0.02450219f, -0.03842356f, 0.05478287f, -0.00779509f, 0.03068260f, 0.03683685f, 
    -0.26084644f, 0.19934686f, 0.02048928f, 0.39761630f, -0.00981660f, 0.12808751f, -0.16995171f, 0.07153220f, 
    0.10367793f, -0.05510465f, -0.05122458f, 0.13104963f, -0.06011819f, 0.07637776f, -0.08524905f, 0.02137732f, 
    -0.07397617f, -0.05456939f, 0.06785475f, -0.00844744f, 0.07403655f, -0.02277208f, 0.06465296f, 0.12866694f, 
    0.16833210f, -0.19732115f, 0.16005029f, -0.01371097f, 0.08599070f, 0.19458309f, 0.13356212f, 0.08430541f, 
    -0.05600428f, 0.03670898f, 0.01966784f, 0.00433613f, -0.20588137f, -0.20322420f, -0.22474906f, -0.21771479f, 
    -0.09766659f, 0.03360266f, -0.00013580f, -0.12097114f, 0.00335073f, -0.03612732f, 0.04622541f, -0.11125683f, 
    0.03257551f, 0.01687142f, -0.00941370f, 0.00034938f, -0.01922786f, 0.02474665f, 0.02012201f, -0.01842790f, 
    -0.01517697f, 0.00626970f, 0.00254741f, -0.01245290f, -0.02070533f, 0.02304043f, 0.02303894f, -0.01858768f, 
    0.02855702f, -0.02986718f, 0.01393521f, 0.01533531f, -0.02606850f, 0.00242704f, 0.01740684f, -0.02455118f, 
    -0.03413275f, -0.02588346f, -0.02143169f, -0.00444079f, -0.03444049f, -0.02576778f, -0.01509025f, 0.01548314f, 
    -0.02797902f, 0.00205513f, 0.01709495f, -0.03337478f, 0.03026829f, -0.01288325f, -0.01628798f, -0.02448862f, 
    -0.02654427f, 0.00741229f, -0.00199126f, -0.00743118f, -0.03564678f, 0.00863146f, -0.04235861f, 0.01401192f, 
    0.00258293f, 0.01156559f, -0.02123044f, -0.04066585f, -0.02970261f, 0.02122358f, -0.03112850f, -0.00607438f, 
    -0.03187861f, 0.02320096f, -0.02948781f, -0.01896078f, 0.01383139f, -0.00143844f, -0.01151944f, 0.01363664f, 
    0.02435465f, -0.01123036f, -0.03880878f, 0.02309464f, 0.02444267f, 0.02627943f, 0.00429915f, -0.00170122f, 
    -0.00103848f, 0.00658655f, 0.02364032f, 0.02202014f, -0.01686214f, -0.02980119f, -0.01254544f, 0.02140888f, 
    0.02457494f, -0.04333089f, -0.01498562f, -0.01728253f, -0.03316368f, 0.01362531f, 0.01049395f, -0.03898551f, 
    -0.01013855f, -0.02091907f, -0.02597846f, -0.04124419f, -0.02535073f, 0.00618456f, -0.02664497f, -0.01756829f, 
    0.01349057f, -0.01545271f, 0.02643868f, -0.01781497f, -0.01465781f, 0.01801752f, -0.00400122f, -0.04028074f, 
    -0.01423519f, -0.00667834f, 0.00190519f, -0.01610387f, -0.00795024f, -0.01048378f, 0.00880064f, -0.01825258f, 
    0.00237447f, -0.03387061f, 0.02276045f, 0.00568493f, -0.02042615f, -0.00652622f, 0.02179024f, 0.00128170f, 
    -0.02324925f, 0.03765312f, 0.00480606f, -0.01975598f, 0.01464496f, 0.00612812f, -0.01987975f, 0.00809779f, 
    -0.02335487f, 0.00763824f, -0.01790177f, -0.03080506f, 0.02798478f, -0.04089929f, 0.00521947f, 0.01380049f, 
    -0.00189986f, -0.01443368f, -0.00619639f, -0.03061379f, -0.02089840f, -0.02875010f, -0.02070586f, -0.01217818f, 
    -0.00233240f, 0.01215576f, 0.02443354f, -0.01109733f, -0.02664991f, 0.00886497f, -0.01397674f, -0.00623988f, 
    -0.02027407f, 0.02179476f, 0.01415531f, 0.00062266f, 0.00384878f, 0.00078942f, -0.00804129f, -0.01867665f, 
    0.02779999f, 0.00490655f, 0.02181692f, -0.02530699f, 0.01435326f, -0.03249392f, -0.04122688f, 0.00827614f, 
    0.02541107f, -0.02840585f, 0.02805135f, -0.01841720f, -0.04264298f, -0.02578690f, 0.00435765f, -0.00841455f, 
    0.02853207f, 0.01091583f, -0.01287136f, 0.01478518f, -0.01898872f, 0.01898474f, 0.00254077f, -0.00192505f, 
    -0.00172987f, -0.02257072f, -0.00223722f, -0.02513727f, 0.02228457f, -0.00965612f, -0.00363832f, 0.01117038f, 
    -0.00276122f, 0.00632802f, -0.03177330f, -0.03140509f, 0.00624501f, -0.03471505f, 0.01728737f, -0.03054623f, 
    -0.02793045f, 0.02128072f, -0.01678847f, 0.01209649f, -0.02800574f, -0.00085853f, -0.02929230f, -0.02176043f, 
    0.02760488f, -0.00061828f, 0.03129176f, 0.02757746f, -0.00852783f, 0.00807397f, -0.00429699f, 0.02196115f, 
    0.02316520f, -0.04203553f, -0.01418739f, -0.00905980f, -0.01876921f, -0.03293204f, -0.02001573f, -0.01210430f, 
    0.02738645f, -0.00522673f, -0.00327270f, -0.01144464f, 0.02222904f, 0.03412474f, 0.02463205f, -0.01020111f, 
    -0.02438655f, 0.00956329f, -0.02385484f, 0.02053723f, -0.00596398f, -0.01689058f, -0.01157649f, -0.03051051f, 
    -0.03739810f, 0.02199991f, 0.00096345f, -0.00112428f, -0.00409457f, -0.00901511f, 0.01021656f, 0.02330859f, 
    -0.03643235f, -0.03678723f, 0.03875019f, -0.02972756f, -0.01899135f, -0.03740608f, 0.00489537f, 0.01196603f, 
    0.02382275f, -0.02158375f, 0.02121496f, 0.00253217f, -0.02011313f, 0.02406851f, -0.03750934f, 0.00846282f, 
    0.02150011f, -0.00860287f, 0.01450094f, 0.01150695f, -0.02279867f, 0.01862934f, 0.01756473f, -0.03529866f, 
    -0.03638425f, -0.02274030f, 0.00499515f, 0.03521980f, -0.00581790f, -0.01952852f, -0.02009030f, 0.02391941f, 
    0.01829727f, -0.01825639f, -0.00079600f, 0.03003474f, 0.02390441f, -0.01763284f, 0.00490582f, 0.01096034f, 
    -0.01710146f, 0.02173808f, 0.00952312f, 0.00968117f, -0.03794672f, -0.01882996f, 0.01755546f, -0.02878760f, 
    -0.00236675f, 0.00712985f, -0.00870019f, 0.00820321f, 0.01755702f, -0.01908094f, -0.01937171f, 0.01093738f, 
    -0.04169318f, 0.02114888f, -0.04056884f, 0.00054777f, -0.01454620f, 0.00261814f, 0.00900543f, 0.00697224f, 
    -0.00436404f, 0.02541137f, -0.00472819f, -0.01440211f, 0.02810715f, 0.00602147f, 0.01262658f, 0.01303391f, 
    -0.03164794f, -0.03377270f, -0.01573809f, -0.01726471f, -0.01492264f, -0.00874014f, 0.00580310f, -0.02663541f, 
    -0.00798763f, 0.01324685f, -0.02574879f, 0.01123365f, 0.01364805f, -0.03832891f, 0.01837556f, 0.02162791f, 
    0.00067691f, -0.02315608f, -0.00297061f, -0.01540122f, -0.03360839f, -0.02492880f, 0.01401609f, -0.02808329f, 
    0.00782643f, 0.01300781f, 0.00104845f, -0.00925042f, 0.02620701f, -0.04391710f, -0.03582808f, -0.00116064f, 
    -0.02001202f, -0.00264065f, -0.02085635f, -0.01397806f, 0.01976932f, 0.01027288f, -0.02658385f, 0.01947318f, 
    -0.02306265f, 0.01766758f, 0.01356923f, 0.00006997f, 0.03043913f, -0.04143610f, -0.02694370f, -0.01214692f, 
    0.00677449f, -0.04006420f, -0.03696519f, 0.02203009f, 0.02843185f, 0.00092545f, 0.01872617f, -0.04303462f, 
    0.03370903f, -0.01238031f, 0.01327061f, 0.01566407f, 0.02248052f, 0.02106863f, 0.01481329f, -0.03133683f, 
    0.00352938f, 0.01910462f, 0.02405770f, -0.00096054f, 0.00665078f, -0.00786201f, 0.01515195f, -0.03235891f, 
    0.02015742f, 0.01943685f, -0.03244989f, 0.00216120f, -0.00869639f, -0.02202726f, 0.02771578f, -0.01763378f, 
    0.01607782f, 0.00366500f, -0.03919739f, -0.03664900f, 0.03195248f, -0.04098642f, 0.03920387f, -0.03247016f, 
    -0.03840617f, -0.01765408f, -0.00800128f, 0.03188873f, -0.00099281f, 0.02859783f, -0.02204097f, -0.03085079f, 
    -0.00542286f, -0.01374727f, -0.02202761f, 0.00314062f, 0.01205348f, -0.01582834f, -0.00410319f, -0.03302950f, 
    -0.01400551f, -0.03192874f, -0.00601173f, 0.02679312f, 0.02133462f, 0.02733485f, -0.02322021f, -0.03645972f, 
    -0.02468657f, -0.00105841f, -0.02949087f, -0.01062578f, -0.00268316f, 0.01550543f, 0.00597308f, 0.01969718f, 
    0.02743251f, -0.02914164f, 0.00095309f, -0.03688420f, -0.00175957f, -0.01051543f, 0.01511669f, 0.01912935f, 
    -0.03927225f, 0.00112014f, -0.02844238f, -0.03743468f, 0.01150280f, 0.02200420f, -0.03690837f, -0.02404350f, 
    -0.02387669f, -0.01490239f, -0.01852178f, 0.00762065f, -0.01581505f, -0.02618943f, 0.01412389f, -0.01712980f, 
    0.00344035f, 0.00260762f, -0.01400810f, -0.02665737f, 0.03963763f, 0.01948178f, 0.03859005f, 0.03165117f, 
    -0.03596282f, -0.00773156f, 0.01250842f, -0.00942366f, -0.03090183f, -0.02986987f, -0.00413208f, -0.02392636f, 
    0.02661047f, 0.00827631f, -0.00686620f, 0.01355659f, -0.01415595f, -0.01212523f, -0.01690010f, -0.00839064f, 
    -0.02688230f, 0.00367817f, -0.03659224f, -0.03527839f, -0.01633769f, 0.02840029f, 0.02938581f, -0.02509119f, 
    0.02637527f, -0.02879970f, -0.00486389f, -0.00873382f, 0.01777465f, -0.01428775f, -0.02666692f, -0.02531661f, 
    -0.02977492f, -0.00169028f, -0.02327198f, -0.01529599f, -0.00630927f, 0.02051841f, -0.04303587f, -0.02655339f, 
    0.00824098f, 0.01669883f, -0.01972072f, -0.02034565f, -0.03669677f, 0.02363408f, -0.02570351f, 0.02144218f, 
    0.00872415f, -0.00174706f, -0.03365671f, -0.00240493f, 0.02759739f, -0.03446082f, 0.02188304f, -0.03086831f, 
    0.02062716f, 0.02517691f, -0.03508190f, 0.02278672f, 0.00199749f, -0.00570444f, -0.01415275f, 0.00038985f, 
    -0.02509632f, 0.02744322f, 0.01193522f, 0.02469700f, 0.03881992f, 0.00043698f, 0.03320980f, 0.01816973f, 
    0.01664149f, 0.00831214f, -0.01203984f, 0.02101330f, -0.01649331f, 0.03027274f, -0.02187934f, -0.00318850f, 
    -0.00238418f, -0.01908942f, 0.00155843f, -0.00789748f, 0.00434661f, -0.02875359f, -0.03272308f, -0.01324203f, 
    0.00040128f, -0.01225733f, -0.00908722f, 0.02629280f, -0.01426927f, -0.01089197f, 0.00639598f, 0.02462690f, 
    -0.01233167f, -0.01225091f, -0.04346204f, 0.02282297f, -0.03411771f, -0.00835518f, -0.01521089f, 0.02224744f, 
    0.00974263f, 0.02459581f, 0.02411584f, 0.00990058f, -0.00618884f, -0.01874572f, 0.01255614f, 0.01927132f, 
    0.01879944f, -0.00005189f, -0.00693622f, -0.01809479f, 0.03976937f, -0.00756261f, -0.02182094f, -0.00882529f, 
    -0.00869581f, 0.02536889f, -0.04260817f, -0.03441098f, -0.00550317f, 0.00740424f, 0.01103176f, 0.02134446f, 
    0.02086410f, 0.00077612f, -0.04026810f, -0.03307335f, -0.04330622f, 0.00749860f, -0.03943563f, 0.02334745f, 
    -0.00520680f, 0.01518449f, 0.00582907f, 0.00862114f, 0.00674721f, -0.00825262f, -0.03045803f, -0.03158340f, 
    -0.03949791f, 0.01299047f, 0.00776846f, 0.00489837f, -0.02621834f, 0.01799781f, -0.04310102f, -0.01223298f, 
    -0.02009044f, -0.00837715f, 0.01721167f, 0.00337700f, 0.02809597f, 0.01144136f, -0.04349846f, -0.02869184f, 
    -0.01842571f, -0.00330001f, -0.02565353f, -0.03100946f, -0.02621352f, 0.02550425f, -0.03253055f, -0.01513259f, 
    0.01450337f, -0.02520546f, -0.01530098f, -0.01981447f, 0.01137241f, -0.01201292f, -0.00237712f, -0.03528868f, 
    -0.03386977f, 0.03239826f, -0.02826376f, 0.01714108f, -0.01751208f, 0.00567399f, 0.01464312f, -0.02965861f, 
    -0.01697837f, 0.03614388f, -0.00258052f, 0.00367613f, 0.00472415f, 0.02540065f, 0.00493905f, -0.03779374f, 
    0.00983647f, -0.03428573f, -0.00141961f, 0.03211503f, 0.00091158f, -0.02068817f, -0.01713549f, -0.03031732f, 
    0.00743372f, -0.02343823f, 0.01704857f, 0.00640297f, -0.04000847f, 0.00444384f, -0.03759234f, 0.00814280f, 
    0.03080743f, 0.02801512f, 0.02817509f, -0.02156428f, -0.00264474f, -0.01475067f, -0.03256737f, -0.04457248f, 
    0.00882011f, -0.02722203f, -0.02656196f, -0.03998447f, 0.00200410f, -0.01234254f, 0.01551295f, -0.04205123f, 
    0.02440194f, 0.03606603f, 0.03141442f, 0.02177359f, 0.04147726f, -0.00820100f, 0.03063915f, 0.00770323f, 
    -0.03400198f, -0.00271598f, -0.03077796f, 0.00762578f, -0.02957119f, 0.00199733f, 0.02379554f, -0.00636669f, 
    0.01265230f, -0.01278357f, -0.00424798f, 0.02327606f, 0.01123015f, -0.01776464f, 0.00519068f, -0.00609989f, 
    0.00973055f, 0.02729264f, 0.02305350f, -0.03397536f, 0.02666906f, -0.04294389f, -0.02431004f, -0.02856084f, 
    -0.03182140f, -0.01685555f, -0.02440578f, -0.02179713f, -0.00045498f, 0.01581861f, 0.02504379f, 0.00012911f, 
    0.02015160f, -0.02956877f, 0.01280907f, 0.01372133f, -0.01437324f, -0.00266529f, 0.00319666f, -0.01849545f, 
    -0.02963651f, -0.01951601f, 0.02263737f, -0.03560029f, -0.04439393f, -0.03493616f, -0.01668638f, 0.02526025f, 
    -0.03568933f, -0.04264920f, 0.00830691f, -0.02421243f, -0.01473858f, 0.02871152f, -0.01065318f, 0.02064935f, 
    0.00644273f, -0.00881680f, -0.01004155f, -0.01193433f, -0.01542290f, -0.00138206f, 0.01276439f, 0.02195930f, 
    0.04058974f, 0.20649408f, 0.18417171f, 0.23104034f, 0.09720363f, 0.17133880f, -0.14596510f, -0.01027066f, 
    -0.03236176f, -0.02963128f, -0.21024604f, 0.02415237f, 0.09395958f, 0.12724631f, 0.00510030f, 0.27686942f, 
    -0.01368387f, 0.16751398f, -0.06680711f, -0.07609099f, 0.02664583f, -0.04669517f, 0.00686521f, -0.09059563f, 
    0.11335247f, -0.17534433f, -0.24754576f, 0.27054459f, 0.14946352f, 0.08771604f, -0.07331358f, 0.02277006f, 
    0.10800316f, 0.02780788f, 0.08723424f, -0.05624991f, 0.02292460f, 0.03521308f, 0.13612595f, -0.05816996f, 
    0.12251870f, 0.23671395f, 0.03541420f, 0.10292602f, -0.08222628f, -0.10405563f, 0.06216985f, -0.06636399f, 
    0.16161166f, 0.50568157f, 0.21494448f, -0.23148416f, 0.09669111f, 0.08691581f, 0.04178189f, 0.08582554f, 
    0.02220800f, -0.01324306f, -0.09627700f, -0.03506251f, 0.35898164f, 0.15043323f, 0.20370464f, 0.04486628f, 
    0.09743847f, 0.11566686f, 0.15462685f, 0.21382022f, 0.00264402f, -0.02447118f, 0.02671661f, -0.05937619f, 
    0.11007056f, 0.03533641f, 0.08497787f, 0.03091718f, -0.06033879f, 0.10563222f, 0.09991736f, -0.00100346f, 
    -0.02610449f, 0.01501886f, 0.05076201f, 0.20664935f, 0.14079501f, -0.15199751f, -0.10577519f, 0.13811089f, 
    0.02577253f, 0.16053945f, -0.06326404f, -0.06845608f, -0.06634076f, -0.01423104f, -0.02397350f, 0.08672764f, 
    0.17334776f, 0.18610486f, 0.46083769f, 0.02898122f, -0.13564153f, -0.06006381f, -0.12482002f, -0.04387906f, 
    0.00407125f, -0.04166522f, 0.10164439f, 0.07323609f, -0.00547668f, 0.03942904f, 0.04287542f, 0.06858984f, 
    0.01271520f, 0.04934981f, -0.06900179f, 0.04139511f, 0.06941172f, -0.03894153f, 0.00439926f, 0.06250305f, 
    0.54937899f, 0.34591851f, -0.25678754f, 0.01800183f, 0.00318799f, 0.14988934f, 0.06476726f, -0.03444619f, 
    0.06740521f, 0.01257914f, 0.00774379f, -0.12312340f, -0.05473561f, 0.07193449f, 0.03896048f, 0.00453871f, 
    -0.08237071f, -0.08887790f, -0.11169489f, 0.01327832f, -0.04558016f, -0.01371773f, 0.11584175f, 0.03645373f, 
    -0.03584898f, 0.14288405f, 0.20457019f, -0.09179419f, -0.03829364f, -0.05837562f, 0.01840746f, -0.02004286f, 
    -0.03980592f, 0.08467082f, 0.04116963f, 0.13501765f, 0.33754754f, 0.26813218f, 0.09503946f, 0.05481485f, 
    0.13244767f, 0.10340200f, 0.02562599f, -0.05547138f, -0.00046676f, -0.02559708f, -0.05767252f, 0.11157127f, 
    0.12782192f, -0.29764181f, 0.09933519f, 0.11790934f, 0.14721264f, -0.09298010f, -0.16697136f, 0.01163326f, 
    -0.04855704f, -0.04542296f, 0.12461103f, -0.07324667f, 0.02176883f, -0.06391081f, -0.09227285f, -0.04192576f, 
    -0.04714387f, 0.03090231f, 0.08557712f, -0.07806064f, 0.11007258f, -0.11547012f, 0.00559529f, 0.12170924f, 
    0.29636174f, -0.10074109f, 0.15615335f, 0.11823202f, 0.00059754f, -0.02727978f, -0.00588274f, 0.01630096f, 
    -0.04687762f, 0.06826267f, 0.07728495f, 0.12378520f, 0.05772532f, 0.16095167f, -0.11281874f, -0.11348341f, 
    -0.04203968f, 0.03225178f, -0.03894910f, -0.03467314f, 0.07100268f, 0.19070581f, -0.06914716f, 0.03455530f, 
    0.17720458f, -0.03692166f, 0.08863840f, -0.21340851f, -0.02197435f, -0.04549041f, 0.11806072f, -0.01937339f, 
    0.04315481f, -0.02886475f, 0.11005212f, -0.15086302f, 0.45871037f, 0.25454316f, 0.00208724f, -0.05786030f, 
    0.04841761f, 0.21456744f, 0.16492195f, -0.02588323f, -0.00489413f, -0.11072543f, -0.05070766f, 0.04805097f, 
    -0.16504359f, 0.20985796f, -0.04334863f, 0.01905655f, 0.13351540f, 0.00746657f, 0.13257773f, 0.08425833f, 
    0.03614638f, -0.00709714f, 0.07166558f, -0.06799933f, -0.07211956f, 0.18596153f, -0.19274288f, -0.02154265f, 
    -0.12075828f, 0.07437974f, 0.01848023f, 0.06664540f, 0.01597351f, 0.03602485f, 0.07946344f, 0.01580117f, 
    0.42910269f, 0.43362436f, 0.42532772f, 0.33445451f, 0.06820078f, 0.13554764f, 0.09999958f, 0.15139508f, 
    -0.03968246f, -0.04163416f, 0.03847617f, -0.01419003f, -0.07208499f, -0.01368137f, -0.13940018f, -0.24660274f, 
    0.00185609f, 0.19126979f, 0.08456670f, 0.05065509f, 0.08909331f, 0.09091718f, -0.03330082f, -0.05716776f, 
    -0.00520990f, -0.14828886f, 0.04764137f, -0.01785399f, -0.06183452f, 0.11971726f, 0.16901621f, -0.00716771f, 
    -0.06204581f, -0.04281820f, 0.23940070f, 0.10919372f, -0.15295853f, -0.03718154f, -0.17608309f, -0.04289484f, 
    0.02845234f, 0.03805910f, -0.06532968f, 0.00766780f, -0.05548377f, -0.00305204f, -0.15726720f, -0.02657159f, 
    -0.02597741f, 0.27821505f, -0.07954297f, -0.01838263f, -0.07809675f, -0.12372335f, -0.09813785f, 0.09463803f, 
    -0.01078884f, 0.06154156f, -0.01444512f, 0.00830138f, 0.51275253f, 0.42232564f, -0.06175987f, 0.01097431f, 
    -0.07630586f, -0.07850147f, -0.00349539f, 0.20201094f, 0.03491876f, -0.06490087f, 0.01067837f, 0.07664108f, 
    -0.24672689f, 0.57982278f, 0.23188099f, -0.16874889f, 0.04336365f, -0.00904787f, -0.12389722f, 0.00441906f, 
    0.00206876f, -0.11250506f, 0.07341991f, -0.08654548f, -0.12734404f, -0.06689488f, 0.01706713f, 0.04834966f, 
    0.03776731f, 0.05704426f, 0.02088061f, 0.07840817f, -0.14135912f, 0.11046881f, -0.01575134f, 0.22241175f, 
    0.05672040f, 0.00818532f, -0.24424694f, 0.09671761f, -0.10101244f, -0.01654361f, 0.12129378f, 0.15425016f, 
    -0.02764518f, -0.02806493f, 0.00779085f, 0.17778361f, -0.10220512f, -0.24644428f, -0.21755928f, -0.01348191f, 
    0.03383084f, 0.04649908f, 0.15150107f, 0.05789381f, 0.07551568f, 0.00148073f, -0.05023135f, -0.15464340f, 
    0.36423063f, 0.28769341f, 0.11905164f, 0.11983587f, 0.27203038f, 0.27635995f, 0.19719046f, 0.03875581f, 
    -0.05168308f, -0.06677274f, -0.06078711f, -0.06127961f, 0.36464116f, 0.34327400f, 0.22936736f, 0.38838282f, 
    0.11706939f, 0.15769468f, 0.10632142f, 0.12850003f, -0.02135732f, -0.05124810f, -0.02106152f, 0.03034988f, 
    -0.14903469f, -0.34068424f, 0.11602482f, -0.15902202f, 0.09522027f, 0.15121286f, -0.26611292f, -0.10322929f, 
    -0.06841534f, 0.12546678f, 0.00805604f, 0.15271220f, 0.11280218f, 0.16245717f, -0.00719609f, 0.09465669f, 
    -0.06757551f, 0.21108431f, 0.08011544f, -0.02272818f, -0.01448276f, 0.02511347f, 0.06473513f, 0.05239906f, 
    0.13330515f, 0.11849778f, 0.11679445f, -0.01936780f, -0.13813798f, 0.02871833f, -0.02428460f, -0.10011375f, 
    0.02871280f, -0.10506252f, -0.12649959f, 0.15948397f, -0.10881532f, -0.06526794f, -0.06310572f, 0.00992827f, 
    0.02278592f, 0.06449576f, 0.04473880f, -0.01761325f, 0.00227432f, -0.08441103f, 0.05486146f, 0.03778186f, 
    -0.02352917f, -0.00760834f, -0.23576450f, -0.09449177f, -0.01577413f, -0.00376161f, -0.00423044f, -0.01822533f, 
    0.08618644f, 0.07586142f, -0.00284511f, 0.00450542f, 0.28760299f, 0.53215784f, 0.01482581f, 0.13280573f, 
    0.00170703f, 0.04448408f, 0.03577695f, -0.09539106f, 0.01778194f, 0.01242767f, -0.04704971f, -0.06090495f, 
    -0.05986570f, 0.22192146f, 0.02161697f, -0.01787484f, 0.05988958f, 0.02554576f, 0.13907555f, 0.04874766f, 
    0.08726844f, -0.13363890f, 0.07673159f, -0.06518702f, 0.06123650f, -0.28712839f, 0.19231468f, 0.04977704f, 
    -0.04936717f, 0.19411953f, -0.03645878f, -0.06173217f, 0.00599223f, 0.01148024f, 0.09303843f, -0.00226044f, 
    0.05147863f, 0.00180481f, -0.02372016f, 0.05115537f, 0.11227286f, 0.05131474f, 0.10476977f, -0.06038992f, 
    -0.05775725f, -0.01391647f, -0.02268433f, -0.00632956f, -0.07442610f, 0.14375117f, -0.11702117f, -0.05402286f, 
    -0.12003230f, -0.14099611f, -0.14513743f, 0.05143959f, -0.09470895f, 0.10240109f, 0.07823743f, 0.10391907f, 
    0.35369518f, -0.20239192f, 0.25310540f, 0.06495958f, 0.04959493f, -0.04863679f, -0.17922266f, -0.14351214f, 
    -0.05218030f, 0.00717873f, 0.04785846f, 0.02377705f, 0.37907070f, 0.23542579f, 0.19269720f, 0.02670358f, 
    0.02905880f, 0.07155616f, 0.03064198f, -0.03295339f, -0.01320244f, 0.12921388f, -0.07002548f, 0.20153357f, 
    0.43485069f, 0.26663059f, 0.15032671f, 0.05853964f, 0.10988276f, -0.12905475f, 0.00702916f, -0.01394137f, 
    -0.04447586f, 0.06896620f, 0.02340073f, 0.07766593f, 0.18966146f, 0.02311090f, -0.07113874f, 0.25012296f, 
    0.14417943f, 0.20450397f, 0.05167494f, 0.00283640f, -0.04867794f, -0.10010758f, -0.01941098f, -0.06766368f, 
    0.10719473f, 0.12596314f, 0.15389764f, 0.04003191f, -0.09061856f, 0.02090372f, -0.10860163f, -0.05686061f, 
    0.00936459f, -0.07922960f, 0.07524183f, -0.00510723f, 0.27822673f, 0.09846766f, -0.04099926f, 0.19210219f, 
    0.16854361f, 0.23239268f, 0.10967974f, 0.14947686f, 0.02237185f, -0.05234173f, 0.00604396f, 0.08252466f, 
    0.02210430f, -0.04239701f, -0.11194393f, 0.13413928f, -0.05134567f, 0.10426144f, 0.00610222f, 0.08671858f, 
    0.08194859f, 0.09704608f, 0.02181466f, 0.07026348f, -0.01320264f, -0.11052842f, 0.04068507f, 0.13910230f, 
    0.03326498f, 0.03340130f, -0.09020381f, 0.09317959f, -0.06503247f, 0.05674475f, -0.09993947f, 0.06224656f, 
    -0.05165825f, 0.16075294f, -0.07706490f, -0.05554720f, 0.07540582f, 0.02910722f, 0.01234460f, -0.07274630f, 
    -0.01178087f, -0.03542443f, -0.00002052f, 0.02449005f, 0.24112041f, 0.16684960f, -0.14732754f, -0.08320267f, 
    0.10607089f, -0.10558235f, 0.06871267f, 0.02870345f, -0.01121314f, 0.00749354f, 0.05516228f, 0.02133948f, 
    -0.03187276f, -0.04163475f, 0.00616335f, -0.12915501f, 0.04289372f, -0.00535720f, -0.12229560f, 0.00036040f, 
    0.01046478f, 0.10255016f, -0.08587909f, -0.05207054f, -0.02348212f, -0.20048170f, 0.01033223f, -0.10419007f, 
    -0.00139058f, -0.04007750f, 0.13434204f, -0.02917429f, 0.05012736f, 0.08646523f, -0.09866305f, 0.18249463f, 
    -0.09282720f, 0.03167346f, -0.02773743f, 0.03103575f, -0.03344355f, 0.02172102f, 0.09499323f, 0.09880005f, 
    0.09758025f, 0.05366451f, 0.06628639f, 0.14203024f, -0.03815096f, 0.25167391f, 0.02633440f, -0.00357629f, 
    0.04928117f, -0.13524863f, 0.07249566f, 0.09348510f, -0.04145202f, 0.05804975f, -0.01273157f, 0.05213258f, 
    0.47470510f, 0.24486846f, 0.33872449f, 0.38034397f, 0.19498631f, 0.07546751f, 0.09250960f, 0.02075452f, 
    -0.00628775f, -0.17756283f, 0.01995519f, -0.06073786f, 0.33920556f, 0.10214774f, -0.01187447f, 0.10922857f, 
    0.12236343f, 0.06960820f, 0.19438881f, 0.01026608f, 0.02592537f, -0.05125118f, 0.05593717f, 0.03596300f, 
    0.04724651f, 0.14003742f, -0.14763609f, 0.11147898f, -0.03062824f, 0.02648487f, -0.13370307f, -0.12144421f, 
    0.00682714f, -0.09268945f, -0.08144010f, 0.05777466f, -0.01115352f, -0.00802264f, -0.06575362f, 0.11113364f, 
    -0.06905169f, 0.02022951f, -0.03525011f, 0.09232175f, 0.00968407f, 0.04007101f, 0.07974396f, 0.03572971f, 
    -0.07167792f, -0.14930832f, 0.22310340f, -0.06364883f, 0.05393727f, -0.11401952f, -0.13768692f, 0.00121325f, 
    -0.01565225f, 0.08548969f, -0.01912542f, 0.04808199f, 0.49384925f, 0.30530721f, 0.20644730f, 0.32524374f, 
    0.04761336f, 0.00398425f, -0.01702106f, 0.05541496f, -0.06303614f, -0.10344922f, -0.05387908f, 0.00240228f, 
    0.03398409f, 0.00136421f, 0.00559041f, 0.04074918f, 0.01191407f, 0.02705891f, -0.00764350f, -0.04669758f, 
    0.00889740f, 0.01752446f, -0.01405152f, 0.00308229f, 0.02144706f, -0.02027607f, -0.04042292f, 0.00435681f, 
    0.02540857f, -0.00421636f, -0.00903864f, -0.02390211f, 0.01814881f, -0.04186200f, 0.00106024f, 0.01964754f, 
    0.01608734f, -0.02276487f, -0.01824523f, -0.00031126f, 0.00714222f, -0.00427431f, -0.00413188f, -0.01175466f, 
    -0.03004652f, -0.02222479f, 0.01300358f, -0.02337234f, -0.03561958f, 0.00310031f, -0.01183834f, -0.01366031f, 
    0.00342581f, -0.00602309f, -0.02640933f, -0.03824622f, -0.03310722f, -0.03717756f, -0.04404062f, 0.00316810f, 
    -0.01729694f, 0.02431912f, -0.00050529f, 0.00871242f, 0.01598939f, 0.00221255f, 0.01245121f, 0.00108209f, 
    0.01177699f, -0.04503322f, -0.02799350f, -0.02803493f, 0.01033238f, -0.03412657f, 0.02256028f, -0.01970512f, 
    -0.03384131f, 0.00340390f, -0.01546858f, -0.02183327f, -0.02793305f, -0.00781966f, -0.02288201f, -0.00931384f, 
    -0.01666558f, -0.01769164f, -0.00587779f, 0.02360739f, -0.00552040f, 0.01375649f, 0.00205204f, 0.01669377f, 
    -0.00563970f, 0.00925548f, -0.02536229f, -0.03249297f, 0.03527287f, 0.00785617f, 0.01741095f, 0.02368494f, 
    0.00186015f, -0.00238144f, 0.00083354f, 0.00781172f, -0.01732388f, -0.00216125f, 0.00999622f, 0.01262853f, 
    0.01851359f, 0.00436494f, -0.03531525f, -0.02268257f, -0.00241975f, -0.03505408f, -0.02626193f, -0.03968944f, 
    -0.00634917f, -0.02867558f, 0.01989282f, 0.03109354f, 0.01999781f, -0.00907069f, -0.00768248f, 0.00944836f, 
    -0.01874537f, -0.01723096f, -0.03723356f, -0.03973587f, 0.00619099f, 0.01037652f, 0.02101300f, 0.00246589f, 
    -0.01587559f, -0.02318150f, -0.00953372f, -0.01301518f, -0.03268244f, -0.01159300f, 0.01048464f, -0.03398032f, 
    -0.04123169f, -0.00679663f, -0.04536201f, -0.02745985f, -0.02913066f, 0.02665345f, -0.03311385f, 0.02213092f, 
    -0.00209960f, -0.02031483f, 0.01131177f, 0.00825279f, -0.03111107f, 0.01177705f, -0.03416410f, 0.02683152f, 
    -0.00966813f, 0.00795196f, -0.03851409f, -0.01368430f, 0.03041831f, 0.00564528f, 0.01364280f, 0.02972781f, 
    -0.00239270f, -0.00260655f, -0.03027718f, -0.00009235f, -0.03666763f, -0.01759789f, 0.00668367f, -0.02898663f, 
    -0.02269006f, 0.00559303f, 0.03768736f, 0.01069340f, 0.00738420f, 0.00855908f, -0.00255072f, -0.01606846f, 
    0.01860833f, -0.04266643f, -0.01912513f, 0.00503034f, -0.02177643f, -0.01929399f, -0.01597444f, -0.03844270f, 
    -0.02129632f, 0.02108435f, -0.03287119f, -0.03543351f, 0.02635361f, -0.02814721f, -0.00854497f, 0.02450462f, 
    0.00240061f, 0.00232258f, -0.02134373f, -0.01772322f, 0.02065527f, -0.02667669f, -0.03939785f, -0.00442865f, 
    -0.02646221f, 0.00250691f, -0.02056716f, 0.00661258f, 0.00992295f, 0.01784760f, -0.03430199f, 0.01790983f, 
    -0.01724874f, 0.03598184f, 0.00607213f, 0.03984357f, -0.01470509f, -0.02196495f, 0.00316930f, -0.03701753f, 
    -0.02398729f, 0.02303283f, 0.01195281f, 0.00458792f, -0.01651878f, -0.04251781f, 0.02599028f, 0.00011135f, 
    -0.01853189f, -0.01644108f, -0.03614177f, -0.02166360f, -0.03244605f, -0.02345779f, 0.02587812f, 0.02178793f, 
    0.00865605f, -0.02461749f, 0.02196030f, 0.02410392f, 0.02096922f, -0.01913727f, 0.02379750f, -0.03967306f, 
    0.02107839f, -0.00245816f, -0.02059562f, 0.02544305f, -0.00801199f, -0.02125923f, 0.00120095f, -0.03684464f, 
    -0.04148977f, 0.01541182f, 0.01669342f, -0.00335202f, 0.02752602f, 0.00827654f, 0.01315291f, -0.04536391f, 
    -0.02937900f, -0.03571854f, 0.01521148f, -0.00393399f, -0.01645380f, 0.00162476f, -0.01517675f, -0.01603372f, 
    0.01716954f, -0.01024997f, 0.01842606f, -0.03868167f, 0.01221345f, 0.02151020f, -0.01514452f, -0.03193381f, 
    -0.00864222f, 0.01002077f, -0.02901417f, 0.02619153f, 0.02152912f, -0.00016292f, 0.01892644f, 0.00631367f, 
    -0.02550786f, 0.02711755f, -0.04453855f, -0.01174774f, -0.01734618f, 0.01863600f, 0.00525779f, -0.03430747f, 
    -0.03393916f, 0.00876625f, 0.02911058f, -0.02166496f, 0.02430705f, -0.03673100f, -0.01325121f, -0.00170108f, 
    -0.04345394f, -0.03164764f, -0.03766430f, 0.00119089f, 0.00511766f, 0.01893049f, 0.00651512f, 0.02665688f, 
    0.03187959f, -0.00503227f, -0.00227174f, -0.01408639f, -0.03832421f, -0.00581018f, 0.01770832f, 0.00047231f, 
    0.00203574f, 0.01782891f, -0.00611384f, -0.00864614f, 0.02978067f, 0.00622456f, 0.02303132f, -0.01966609f, 
    0.00165006f, -0.02076923f, -0.00050766f, -0.01039985f, 0.00218117f, -0.02448731f, 0.02744511f, -0.01909637f, 
    -0.03161937f, 0.00386104f, -0.02241644f, -0.00888162f, 0.01211563f, 0.00422126f, 0.03091680f, 0.01763599f, 
    -0.00029836f, -0.01128046f, -0.01928043f, -0.02058717f, -0.00192161f, -0.03034508f, -0.03271335f, -0.03340801f, 
    -0.00400259f, -0.02086759f, -0.01874779f, 0.02601860f, -0.03260157f, 0.01079181f, -0.00284751f, -0.00770224f, 
    -0.03086375f, 0.01889677f, 0.02800947f, 0.00929127f, 0.00226079f, -0.00053747f, -0.03802508f, -0.01707720f, 
    0.01952804f, 0.02088147f, -0.02404013f, 0.02903635f, 0.00113331f, -0.00234793f, -0.00017210f, -0.00915332f, 
    -0.04253745f, 0.00601963f, 0.02982553f, 0.01334350f, 0.02169842f, -0.03421216f, 0.00653754f, 0.01505629f, 
    0.02818963f, -0.02064331f, -0.00243273f, 0.01944113f, 0.01699942f, -0.00486648f, -0.03396798f, -0.00100294f, 
    -0.00103443f, -0.03715561f, 0.02865895f, 0.02175801f, -0.00943910f, 0.01024429f, 0.03117915f, 0.02137295f, 
    -0.01926278f, -0.02300491f, -0.03150684f, 0.00376943f, 0.02778331f, -0.03731823f, 0.00686389f, -0.01235154f, 
    -0.00887070f, 0.00240277f, 0.02649554f, -0.00890143f, 0.01322307f, 0.01301376f, 0.01687576f, 0.00543858f, 
    -0.00442639f, 0.02334612f, 0.01621294f, 0.00811619f, 0.02445712f, -0.03582675f, 0.00565519f, 0.01753833f, 
    0.01922163f, -0.00499130f, -0.00520616f, 0.01799665f, -0.03902182f, -0.03462080f, 0.00264987f, 0.02307037f, 
    0.01596069f, -0.03153669f, -0.01588081f, -0.04436022f, 0.02367151f, -0.02243737f, -0.02758513f, -0.00897968f, 
    0.00752276f, -0.00267444f, -0.00783737f, 0.00165488f, 0.00803924f, -0.04318542f, -0.01690591f, 0.01750942f, 
    -0.01827549f, 0.03716642f, -0.00323556f, -0.03144810f, -0.02011461f, -0.03807236f, -0.01265067f, -0.01955639f, 
    -0.03206900f, 0.00772966f, -0.02898654f, -0.02160263f, 0.00624458f, -0.03182643f, 0.01245287f, 0.00820782f, 
    -0.03422334f, -0.00730354f, -0.00710481f, -0.01515848f, 0.00168018f, 0.02477415f, -0.04059047f, -0.02924527f, 
    -0.01183482f, 0.00317694f, -0.03874608f, 0.03398616f, 0.00237314f, -0.00545296f, -0.03596342f, -0.03510858f, 
    -0.00578701f, 0.00749543f, -0.03849799f, -0.01054443f, -0.00549274f, 0.02409693f, 0.01025843f, -0.01746292f, 
    0.01600710f, -0.00169057f, -0.01857210f, 0.01547570f, 0.01954656f, -0.02913154f, -0.01547152f, -0.02646777f, 
    0.02795568f, 0.01035462f, 0.00970738f, -0.01419393f, 0.01704065f, -0.02212850f, -0.00335413f, -0.01129750f, 
    0.02474556f, 0.00151033f, -0.02338401f, 0.03476601f, -0.02970562f, 0.03507619f, -0.01263427f, 0.02930986f, 
    -0.02095827f, 0.03693991f, 0.01556526f, 0.01683054f, 0.02110484f, 0.03106011f, 0.01947712f, 0.02250692f, 
    -0.03308467f, 0.00117167f, 0.01941875f, -0.02844086f, 0.01096702f, 0.01917713f, -0.02786412f, 0.03011652f, 
    -0.00680383f, 0.00422184f, -0.00064030f, -0.00962573f, -0.00538060f, -0.01206017f, -0.02353692f, 0.01602125f, 
    -0.00085229f, -0.01873523f, -0.02158236f, 0.02653374f, 0.02636658f, -0.00641618f, 0.02303249f, -0.00620893f, 
    -0.00872392f, 0.01318529f, 0.00301869f, 0.01915052f, -0.01008776f, 0.01055435f, -0.00147858f, -0.01369206f, 
    0.00734935f, -0.03573377f, -0.02407349f, 0.00806852f, 0.03144841f, 0.02868884f, -0.01724964f, -0.01927480f, 
    -0.00946582f, 0.00188548f, -0.00324714f, 0.00346527f, 0.02386061f, 0.00464566f, -0.00687526f, -0.03882195f, 
    0.03321144f, -0.00971839f, 0.00558217f, 0.01633700f, 0.02918315f, -0.04274021f, 0.01941381f, -0.00559595f, 
    0.01985505f, -0.01617521f, 0.02007124f, 0.00640369f, 0.01306079f, -0.01795733f, -0.00437698f, -0.03726903f, 
    -0.01615594f, 0.03362286f, 0.01076354f, -0.00649100f, -0.00764614f, -0.01007108f, -0.03206320f, -0.00217086f, 
    -0.01017378f, -0.00728690f, -0.00459090f, -0.00079300f, -0.01298509f, 0.02052142f, 0.02609148f, -0.02445260f, 
    -0.03813637f, 0.00400280f, -0.02409259f, -0.03195743f, 0.03139082f, -0.01267480f, -0.00599799f, -0.03363566f, 
    0.02524041f, 0.02868997f, -0.03319286f, 0.01121257f, -0.01216914f, 0.00488038f, 0.02007292f, 0.02325653f, 
    0.03256537f, 0.02420053f, 0.01356281f, -0.02403989f, 0.00863540f, -0.02623846f, -0.00875754f, -0.00867852f, 
    -0.02388511f, -0.02857782f, -0.00075769f, 0.02123754f, 0.02723546f, 0.03246018f, -0.01065772f, -0.01433969f, 
    -0.02484772f, 0.02997036f, 0.02957345f, -0.03553891f, 0.03137651f, 0.00309459f, -0.02296483f, 0.03201460f, 
    0.00192183f, 0.01079803f, -0.00489186f, 0.02517130f, 0.00237543f, -0.02509428f, 0.01587610f, -0.01214849f, 
    -0.03385123f, 0.00559572f, 0.00286914f, -0.00395844f, -0.01840382f, -0.01527156f, -0.00354993f, -0.03840911f, 
    -0.02696341f, -0.02307441f, 0.02317352f, 0.01118318f, 0.00337399f, 0.01803596f, -0.00134302f, 0.02474429f, 
    -0.00038622f, -0.01312769f, 0.01933957f, -0.03494849f, -0.00105624f, 0.02123039f, -0.03448131f, -0.00259095f, 
    0.02419781f, 0.01237039f, -0.04190572f, 0.03438184f, -0.02703063f, -0.02375512f, 0.01838982f, 0.01612173f, 
    0.00958495f, -0.00485428f, -0.00587356f, 0.00876740f, 0.00512040f, 0.01414156f, -0.04056713f, 0.01177171f, 
    -0.01775660f, -0.04025200f, 0.03027574f, -0.00057112f, -0.00935935f, 0.01322222f, 0.00493230f, -0.00257709f, 
    0.00066714f, 0.02617520f, -0.03755025f, 0.02692415f, 0.00860055f, 0.01591833f, -0.04029638f, 0.02347591f, 
    -0.03493863f, 0.02722834f, 0.01455365f, 0.00747837f, 0.01064069f, -0.04374467f, -0.02041589f, 0.01370180f, 
    0.01871997f, -0.00035852f, 0.03258732f, -0.00774819f, 0.01361759f, -0.02771585f, 0.02666270f, 0.01484243f, 
    0.02117937f, 0.02850393f, 0.00567468f, -0.03024230f, 0.01354500f, -0.03065605f, 0.00905595f, -0.00475509f, 
    -0.02675038f, -0.03861776f, -0.03926418f, -0.02495680f, 0.00169261f, 0.01380586f, -0.01989421f, -0.02543195f, 
    -0.01290178f, -0.03061991f, 0.00442532f, -0.00439247f, 0.02050594f, -0.02267823f, -0.03082504f, 0.01454322f, 
    -0.03548225f, -0.00926358f, -0.00962731f, -0.04166157f, -0.00025933f, -0.02958935f, 0.01196603f, -0.02082885f, 
    -0.02126867f, -0.04601241f, -0.02246094f, -0.03391954f, 0.01991246f, 0.02515689f, 0.02861492f, -0.02031989f, 
    -0.00415285f, 0.02237845f, -0.01937563f, -0.01268357f, -0.02775243f, -0.03065860f, -0.03092591f, 0.00856849f, 
    0.01933013f, 0.00936483f, -0.02407327f, -0.01923324f, 0.01244936f, -0.01562224f, -0.00585403f, 0.03300855f, 
    -0.01738949f, -0.00666751f, -0.02075636f, -0.03738112f, -0.00628403f, -0.00342480f, -0.03680228f, -0.00202227f, 
    0.00422962f, 0.00056072f, -0.03807961f, -0.01682332f, -0.00019250f, -0.02570621f, -0.03441211f, 0.01017094f, 
    0.01911331f, -0.01893454f, 0.00375699f, -0.00714653f, -0.00887420f, -0.01025438f, 0.00785659f, 0.00704728f, 
    0.00175633f, -0.03154142f, -0.03948471f, 0.00718083f, 0.00185092f, -0.02184431f, -0.00912444f, 0.02111213f, 
    0.03241400f, -0.00176061f, 0.02675580f, 0.03602610f, 0.00220665f, 0.00861071f, 0.00250341f, 0.00647567f, 
    -0.03410113f, -0.01636650f, -0.03851878f, 0.03230607f, 0.02269496f, -0.02726883f, -0.01091396f, -0.02892338f, 
    -0.03460738f, 0.00755997f, -0.02625910f, -0.00485310f, -0.01698141f, 0.03435914f, 0.00237168f, 0.02825102f, 
    0.03009803f, 0.00979553f, 0.02307731f, 0.01680472f, 0.01504515f, 0.00673487f, -0.02922953f, 0.03806385f, 
    -0.00960899f, 0.01854705f, -0.03749274f, 0.00835440f, -0.00448433f, -0.00137698f, -0.01589552f, 0.02116064f, 
    -0.01140143f, -0.01265832f, -0.01047745f, -0.02276717f, -0.02675410f, -0.00880568f, 0.02213577f, -0.02753433f, 
    0.00670873f, 0.02276076f, 0.02037902f, 0.02197199f, -0.00871512f, 0.00670357f, -0.01096376f, -0.02022362f, 
    0.03452368f, -0.01589201f, 0.01991540f, 0.00974413f, 0.01688643f, 0.02587891f, -0.01316693f, 0.02933137f, 
    0.01965830f, 0.00747357f, 0.02265153f, 0.03165631f, -0.01076800f, 0.02662760f, 0.00249468f, -0.02922609f, 
    0.00442310f, 0.01409329f, 0.01027160f, 0.01450849f, 0.01120520f, 0.00165083f, -0.01620345f, 0.02702454f, 
    -0.02619352f, -0.00420338f, 0.00089059f, -0.01963883f, -0.00444245f, -0.03147469f, 0.01742143f, -0.03416405f, 
    0.00150335f, -0.00979892f, 0.02887798f, -0.02787087f, -0.04284661f, -0.03558723f, -0.00325989f, 0.02376259f, 
    0.00286551f, 0.00361052f, 0.00151312f, -0.00563065f, -0.01633571f, -0.00130330f, -0.02693622f, -0.03289087f, 
    0.02485900f, -0.01393069f, -0.00149547f, -0.02693580f, -0.01445008f, -0.01254795f, -0.00251878f, 0.01945617f, 
    -0.01341988f, -0.02336993f, -0.01535360f, 0.00655008f, 0.03133026f, 0.02792674f, 0.00646705f, -0.01352409f, 
    0.00269784f, -0.02143888f, 0.00980330f, -0.01115266f, 0.00884163f, -0.02277579f, -0.03351351f, 0.02595409f, 
    -0.01032199f, 0.02577241f, -0.00208865f, -0.01914494f, -0.02348088f, -0.01531697f, -0.02144824f, -0.02593383f, 
    -0.02382454f, -0.00429894f, 0.00575383f, 0.00831596f, 0.01705175f, 0.00839646f, -0.01818080f, -0.03479813f, 
    -0.03697279f, 0.01202522f, -0.00464584f, 0.03193172f, 0.01225237f, -0.02480040f, 0.02977512f, -0.02016951f, 
    0.02970587f, 0.00018887f, -0.02263743f, 0.01505537f, -0.01106833f, -0.02470447f, 0.01117368f, -0.01233987f, 
    0.02662041f, 0.01287905f, 0.04039472f, -0.00365524f, 0.00182838f, 0.00128929f, -0.03318792f, 0.00741390f, 
    0.03263040f, -0.02191348f, -0.03360662f, 0.02472316f, 0.01232279f, -0.03484229f, -0.00660458f, -0.00211633f, 
    -0.00601454f, -0.03226335f, 0.03371710f, 0.00694364f, -0.01996301f, 0.02950853f, -0.00035214f, -0.01736725f, 
    0.01238927f, -0.00374023f, -0.03611108f, 0.01615919f, 0.01482297f, 0.02579323f, -0.01015940f, 0.01694376f, 
    0.01871703f, 0.03192004f, 0.00462428f, 0.03663334f, 0.02251462f, -0.01293052f, -0.03296328f, 0.00743994f, 
    -0.03005001f, -0.01229799f, 0.01120003f, -0.02553373f, -0.03339508f, -0.03032489f, -0.03688928f, 0.02548417f, 
    -0.03777458f, -0.02192682f, -0.01194754f, 0.02136964f, 0.02971201f, -0.01217555f, -0.04087366f, 0.02237759f, 
    0.01349115f, -0.03811345f, 0.02136374f, -0.02435516f, -0.04333075f, -0.02571559f, -0.02049216f, -0.03462699f, 
    -0.01201887f, -0.01657253f, 0.00370318f, 0.00185692f, 0.03016066f, 0.00926170f, 0.02296596f, -0.00172635f, 
    0.00642391f, -0.03147966f, 0.02356017f, -0.02695758f, -0.03500825f, -0.02144249f, 0.00803941f, 0.00479285f, 
    -0.01742054f, 0.01178653f, -0.02627501f, 0.02088955f, -0.02246618f, -0.02082021f, 0.01202180f, 0.02586578f, 
    -0.00218282f, 0.02975738f, -0.00690304f, -0.02666336f, 0.02362248f, -0.00258836f, 0.02738314f, 0.02452541f, 
    0.01557515f, 0.00707519f, 0.00802953f, 0.01468315f, 0.02423248f, -0.02214834f, -0.01527601f, 0.01140802f, 
    0.03967098f, -0.02741667f, -0.01758853f, 0.00905272f, 0.02279947f, 0.00541572f, 0.02867679f, -0.01025333f, 
    0.00614261f, -0.01116772f, 0.01123673f, -0.00086794f, 0.02291776f, -0.02791643f, -0.02443279f, -0.01583694f, 
    0.00938749f, -0.00989697f, -0.02580409f, -0.03150734f, -0.02340486f, 0.00844441f, -0.02915030f, -0.01819680f, 
    -0.01341496f, 0.03028019f, 0.01075158f, -0.01855613f, 0.02542293f, -0.02394467f, -0.03215291f, 0.00277943f, 
    -0.02176273f, -0.01853903f, -0.03419216f, -0.00307998f, 0.01668710f, -0.01999325f, -0.00065126f, 0.00499747f, 
    -0.01069893f, -0.01073895f, -0.01611792f, 0.01339706f, 0.03249297f, -0.01486251f, -0.01849361f, -0.00664054f, 
    -0.02639844f, -0.03259891f, 0.00034821f, 0.01914250f, 0.02676274f, -0.02092178f, -0.04247911f, 0.00631764f, 
    -0.03465976f, -0.01332027f, -0.00473646f, 0.00548849f, -0.01966712f, 0.01124647f, 0.02797653f, -0.00275758f, 
    0.01002183f, 0.00974384f, 0.01130942f, -0.02444798f, 0.00667669f, 0.00295533f, -0.01708452f, -0.01762086f, 
    -0.03254579f, 0.03680088f, -0.00654548f, 0.00462165f, -0.03751321f, -0.03719491f, -0.00800230f, -0.03566286f, 
    -0.02139872f, -0.01355822f, -0.02915874f, 0.00220707f, -0.03422113f, 0.00723943f, -0.01848781f, -0.01775563f, 
    -0.02556314f, -0.01078047f, -0.01987514f, 0.02563359f, -0.00688328f, -0.02530225f, -0.02973576f, -0.01702612f, 
    -0.03503277f, -0.00050509f, 0.00228742f, 0.02563003f, -0.00798109f, -0.03238882f, -0.01288275f, 0.00732424f, 
    0.01773108f, -0.01289504f, -0.02532936f, 0.01532401f, -0.00899342f, -0.03147564f, 0.00025790f, -0.00957561f, 
    0.00893000f, 0.01734043f, 0.01575791f, 0.03329703f, 0.03000619f, 0.00207333f, -0.03200812f, -0.01831567f, 
    0.03097716f, 0.01202104f, -0.01790301f, 0.02274376f, 0.01804336f, 0.02095656f, -0.00985830f, 0.01729950f, 
    -0.01780428f, -0.00027726f, 0.02317574f, -0.02624509f, -0.01726574f, -0.03798809f, 0.01786325f, 0.02988864f, 
    0.00459974f, -0.03218179f, 0.02649024f, -0.02917027f, 0.01376137f, 0.02604317f, -0.00185211f, -0.03712115f, 
    0.01261961f, -0.02902975f, -0.03238361f, -0.00999560f, 0.03333054f, 0.03095924f, -0.03946277f, 0.03004953f, 
    0.01624488f, 0.03690256f, 0.00160821f, -0.03038770f, 0.00979315f, -0.01428574f, -0.01633441f, 0.02753243f, 
    0.03495604f, -0.04022677f, -0.01473554f, -0.01216224f, 0.01004299f, -0.01050211f, 0.01436549f, 0.01212904f, 
    -0.02485403f, 0.02566654f, 0.00646045f, -0.01055905f, -0.02862377f, 0.00744330f, 0.00236566f, -0.02975446f, 
    0.02798910f, -0.01941736f, 0.00349303f, 0.03417407f, 0.01022006f, -0.01480295f, 0.01408675f, -0.01940598f, 
    -0.02962059f, 0.02920165f, -0.00651015f, 0.02934866f, -0.00233698f, 0.01945160f, 0.01971813f, -0.00508815f, 
    -0.03206192f, 0.00217385f, -0.00563393f, 0.02746372f, -0.01087719f, 0.00370626f, 0.02265624f, -0.02419440f, 
    0.00862884f, 0.00930699f, 0.01851231f, 0.01345577f, -0.02807480f, 0.02863761f, -0.03809961f, -0.01957785f, 
    -0.01531793f, -0.03146233f, -0.03641147f, -0.02994685f, -0.01925896f, 0.01060160f, -0.00444892f, 0.01237158f, 
    -0.02276731f, -0.03866135f, -0.00644466f, 0.02886308f, -0.03894947f, 0.01721932f, -0.00841499f, 0.01928030f, 
    0.01880135f, -0.01164877f, 0.02741553f, 0.00648153f, -0.00001317f, -0.02549063f, 0.02319562f, -0.01210251f, 
    0.01307461f, 0.01782152f, -0.03019668f, 0.00019223f, 0.00476409f, -0.02999318f, 0.02388282f, -0.01144778f, 
    0.01757529f, 0.01632775f, -0.02941410f, 0.01167893f, 0.00083580f, -0.03131443f, 0.00532715f, 0.00730181f, 
    0.00905511f, -0.03363619f, 0.01080836f, -0.01558378f, -0.01816311f, -0.00770191f, -0.02796960f, -0.00946627f, 
    -0.00902379f, -0.01745748f, -0.03352624f, 0.03289407f, -0.01799239f, 0.00333764f, 0.03857553f, -0.00882789f, 
    -0.03567972f, -0.00517695f, -0.01395593f, 0.01822753f, 0.03454674f, -0.00748258f, 0.02524361f, 0.02096393f, 
    0.02776716f, -0.02096165f, -0.00316338f, 0.00275231f, 0.02882319f, -0.03564114f, -0.01504573f, 0.01576772f, 
    -0.02997644f, -0.01788682f, 0.00669550f, 0.01967262f, 0.01020103f, -0.03400475f, 0.00506127f, -0.01816121f, 
    0.00291276f, -0.02914345f, -0.01987343f, 0.02845916f, -0.02578887f, 0.02955466f, -0.02851126f, -0.01716659f, 
    -0.02602925f, 0.00285234f, 0.01211934f, -0.03281521f, -0.03292282f, -0.02900156f, 0.02005047f, 0.00769917f, 
    -0.00323584f, -0.01828601f, -0.02975689f, -0.02541560f, 0.02933592f, -0.00094412f, -0.02919305f, -0.02288395f, 
    0.04048828f, 0.00690531f, -0.02669021f, 0.02756519f, 0.00091147f, 0.01000914f, -0.02595202f, 0.00867615f, 
    0.02224121f, 0.02323869f, -0.00292256f, -0.03100671f, 0.03797418f, -0.00675935f, 0.01035557f, -0.00335703f, 
    0.01625689f, -0.00213230f, -0.04025880f, 0.00010008f, 0.01200527f, -0.03573293f, 0.00609592f, 0.01860868f, 
    0.01215816f, 0.02708391f, -0.01907180f, -0.04109111f, -0.00479969f, 0.00809648f, -0.03562682f, -0.02099487f, 
    0.03814065f, -0.01057033f, -0.01680172f, 0.01493195f, 0.00224090f, 0.00610363f, -0.02487454f, -0.02941380f, 
    -0.00205358f, -0.00963490f, -0.03030326f, 0.02226960f, -0.02392308f, -0.00360377f, -0.01240869f, -0.03054327f, 
    -0.01554928f, 0.02603869f, -0.02565307f, -0.01520549f, -0.00588037f, -0.02057339f, -0.03175101f, 0.01090678f, 
    0.01382932f, -0.02655501f, 0.01634897f, 0.01105313f, 0.02241885f, 0.00372020f, -0.03029829f, -0.01016439f, 
    0.01077989f, -0.03662601f, -0.03068381f, 0.01653406f, 0.00982512f, -0.01695384f, -0.02256046f, 0.02472749f, 
    -0.01125903f, 0.01656964f, -0.00834172f, 0.00403592f, -0.00179224f, -0.00080916f, 0.01912808f, 0.01164546f, 
    0.03188846f, -0.03696061f, -0.02216690f, 0.00423292f, 0.01549173f, -0.01505572f, -0.01896206f, -0.03081451f, 
    0.00095102f, 0.01496861f, 0.01984015f, -0.00800768f, 0.01927326f, -0.01592200f, -0.00579935f, -0.01927997f, 
    0.01005064f, -0.02981389f, -0.03624059f, 0.00360559f, 0.02409786f, 0.00871535f, -0.02589609f, 0.01177734f, 
    -0.03817861f, 0.02650639f, 0.03004155f, -0.03574027f, 0.02563682f, 0.00056473f, 0.00408338f, -0.02253086f, 
    0.01701932f, 0.00884324f, 0.01512831f, -0.01126436f, 0.00166982f, 0.03364420f, -0.03413008f, 0.02408837f, 
    -0.00154574f, -0.00901465f, 0.00780147f, -0.02187100f, -0.01920215f, 0.01028756f, -0.01721366f, -0.03239278f, 
    -0.01902762f, -0.03475426f, -0.02714906f, -0.01006607f, -0.02729543f, 0.02182358f, 0.01298454f, -0.02788174f, 
    0.03389575f, -0.01306023f, -0.03475961f, -0.03033387f, 0.01227428f, 0.01518451f, 0.03129030f, -0.03307388f, 
    0.03637306f, 0.02579821f, 0.03191227f, -0.03985888f, -0.01986552f, 0.01684928f, -0.00447627f, -0.01731550f, 
    0.01792585f, 0.02682342f, -0.03457494f, 0.00280382f, 0.01809212f, -0.01578623f, 0.00380467f, -0.00867803f, 
    0.02393914f, 0.01942419f, 0.00796348f, 0.00016700f, 0.01357787f, -0.02099193f, 0.00348639f, 0.02280274f, 
    -0.06710392f, 0.09533826f, 0.02296459f, 0.00718442f, 0.05052005f, -0.09337982f, 0.01350320f, -0.01571136f, 
    -0.12682627f, -0.03154385f, -0.10025173f, 0.01537554f, -0.29321507f, 0.07484144f, 0.16972472f, 0.08838948f, 
    -0.02188343f, 0.05572187f, 0.03285783f, -0.07843175f, -0.12724388f, -0.03188284f, -0.08627037f, -0.07275481f, 
    -0.21644422f, 0.08568116f, 0.33075988f, 0.01798567f, -0.08303668f, -0.01484627f, 0.06183191f, 0.01298232f, 
    0.14398950f, 0.03326112f, 0.14367384f, -0.08049832f, 0.30086964f, 0.08200111f, -0.01095497f, 0.26433465f, 
    0.02693005f, 0.11810365f, 0.01749629f, -0.13130513f, 0.02787611f, 0.03640384f, 0.00785770f, 0.02774915f, 
    -0.23782128f, -0.19985324f, -0.22779512f, 0.36020294f, 0.07456639f, 0.00070955f, -0.06166749f, 0.15858081f, 
    0.09020816f, 0.04670024f, -0.03434044f, 0.05647263f, -0.17460428f, -0.19862276f, 0.03563492f, 0.20689479f, 
    0.02512305f, -0.07121770f, -0.06848118f, 0.01465734f, 0.01114195f, 0.01180390f, -0.13122766f, -0.08037084f, 
    0.15789884f, 0.14309417f, 0.01775765f, 0.01785466f, 0.02504707f, 0.00657603f, -0.00893893f, 0.00254883f, 
    -0.08128709f, -0.01905263f, -0.09262434f, -0.08777577f, -0.00462330f, -0.02700710f, 0.10047340f, 0.07323813f, 
    -0.01025820f, 0.06438499f, 0.00429777f, 0.00391873f, -0.10778328f, -0.35775927f, -0.14076588f, -0.06408434f, 
    0.16712888f, 0.14895181f, 0.29494327f, -0.14691275f, -0.08061440f, -0.09844943f, -0.03216817f, 0.04979996f, 
    -0.03373453f, -0.05993630f, -0.03811331f, -0.13926511f, -0.00753241f, 0.06280117f, 0.03658249f, -0.12782934f, 
    0.09634154f, 0.10769810f, -0.04479901f, 0.00869856f, -0.02809455f, -0.08926611f, -0.03086359f, 0.00446839f, 
    -0.28788006f, -0.01260456f, 0.07355375f, 0.10121693f, 0.08222000f, 0.07166246f, -0.03102453f, 0.18555658f, 
    0.01441248f, 0.04598669f, 0.08355157f, -0.11087842f, 0.07018843f, 0.05255222f, 0.11685059f, 0.01345540f, 
    0.01140026f, 0.04396370f, -0.05107332f, 0.04137057f, 0.02606101f, -0.07286364f, -0.02365620f, 0.00987045f, 
    0.06143604f, 0.06907773f, -0.18595962f, 0.09624533f, 0.01870961f, 0.00276171f, 0.05401679f, 0.08983584f, 
    0.05067982f, -0.05319428f, -0.03966792f, 0.11487459f, -0.30574363f, 0.07595485f, 0.19078474f, -0.07121167f, 
    0.03209056f, -0.11186701f, 0.09646634f, 0.10416145f, -0.00935741f, -0.12213212f, 0.01973808f, 0.05635829f, 
    0.07492536f, 0.25228813f, 0.54131335f, -0.26691028f, 0.06654476f, 0.07124764f, -0.03692437f, 0.06922641f, 
    -0.09563283f, -0.04293014f, 0.04098272f, -0.06638668f, -0.05019445f, 0.19114083f, -0.09438734f, -0.05947142f, 
    0.00333420f, 0.03978402f, -0.06363108f, -0.11866564f, 0.19489607f, 0.20940401f, -0.01361918f, -0.01789705f, 
    0.09809636f, 0.13571383f, -0.11508524f, -0.10328365f, -0.00702957f, 0.01432591f, -0.01089751f, -0.06657552f, 
    0.05856573f, 0.09250098f, 0.09467252f, -0.03212302f, -0.02924895f, -0.16858849f, -0.07743418f, 0.17114334f, 
    0.03058881f, 0.10167202f, -0.10164969f, -0.00459858f, 0.23199426f, 0.09047489f, 0.20506024f, 0.20451397f, 
    -0.00852787f, 0.14160092f, 0.20988095f, -0.11226162f, -0.07352985f, -0.18874511f, 0.03402674f, -0.05490134f, 
    -0.04435116f, 0.22393751f, 0.26253143f, 0.04076761f, -0.25357920f, -0.42002940f, -0.12791280f, 0.26499560f, 
    -0.02918439f, -0.06769095f, -0.12314796f, 0.03436998f, -0.01773066f, -0.10347129f, 0.02890000f, -0.03868322f, 
    0.06459811f, -0.16401564f, -0.06028786f, 0.09179918f, 0.04993405f, -0.07394186f, -0.06320491f, 0.04983790f, 
    -0.10077614f, -0.01786897f, -0.07154141f, -0.00849528f, -0.08938888f, 0.05057009f, -0.05267464f, -0.23610801f, 
    0.03037888f, 0.02545874f, -0.00471508f, 0.13195303f, -0.14688838f, 0.00320921f, 0.01198750f, -0.10286564f, 
    -0.25819814f, -0.32881024f, 0.07474648f, 0.14246099f, -0.02490375f, -0.03570531f, -0.02474481f, 0.02917174f, 
    0.01046264f, -0.10270390f, -0.15893763f, -0.10962772f, -0.04275746f, -0.05622956f, -0.34371150f, 0.30174315f, 
    0.18989781f, -0.04605877f, -0.08788621f, 0.07063818f, 0.06565199f, 0.25908968f, -0.00248448f, 0.01773970f, 
    0.09201562f, -0.09152738f, -0.01771533f, 0.00814566f, 0.01282396f, 0.06727820f, 0.16693927f, -0.01069826f, 
    -0.05569052f, -0.13115466f, 0.07004936f, 0.04386666f, 0.14811234f, -0.03048250f, -0.01967047f, -0.02117232f, 
    -0.03560911f, 0.05749702f, -0.07107697f, -0.04126003f, 0.13326727f, 0.28897607f, 0.11805672f, 0.27286983f, 
    0.08137961f, 0.08599418f, -0.06852441f, 0.05592920f, -0.03329462f, -0.02219666f, 0.03196129f, 0.07841511f, 
    -0.00210474f, -0.05390120f, -0.01100012f, 0.08819089f, -0.13013166f, -0.17059401f, 0.25825909f, 0.11731025f, 
    0.10048829f, -0.00824282f, 0.03988115f, 0.09253773f, 0.00463632f, 0.09866080f, 0.07786459f, 0.03964488f, 
    -0.12267681f, -0.24143344f, -0.36225051f, 0.41723302f, 0.01321272f, -0.01565613f, -0.03335605f, -0.03681735f, 
    0.16882983f, 0.06632417f, 0.06164444f, 0.03737522f, 0.10667651f, -0.00188935f, -0.14518833f, 0.12483934f, 
    0.02817255f, -0.06759784f, -0.11393440f, 0.01001555f, 0.18516409f, -0.04289387f, 0.08521997f, 0.15462182f, 
    -0.12162418f, 0.00073568f, 0.04335806f, 0.06622776f, 0.07473066f, -0.04222359f, -0.09830987f, 0.01234879f, 
    0.12669978f, 0.07893543f, 0.13014302f, 0.08978694f, 0.21528284f, 0.04642937f, 0.26693434f, 0.27728108f, 
    -0.05801383f, -0.14849722f, 0.01205210f, 0.10991584f, -0.00184849f, -0.08665693f, 0.01296635f, 0.08073282f, 
    -0.17936468f, -0.28191146f, -0.05691297f, 0.18093392f, -0.07287439f, -0.08013586f, -0.12597641f, 0.13689040f, 
    -0.05212388f, -0.00351641f, 0.02099515f, -0.11993102f, -0.06262615f, -0.15969250f, -0.11496533f, 0.21634306f, 
    0.03473870f, -0.07103313f, -0.04381128f, -0.01564732f, 0.04126802f, -0.12414514f, 0.04482356f, 0.06107694f, 
    -0.12551175f, 0.38095784f, 0.28686291f, -0.07467914f, 0.01634474f, 0.03187649f, 0.03891020f, 0.00839028f, 
    0.02582154f, 0.03360647f, -0.04154526f, -0.00185633f, -0.04511468f, -0.05588819f, 0.07849735f, 0.05835953f, 
    -0.04965983f, -0.01320110f, 0.00631377f, -0.00223474f, -0.12292483f, -0.05468488f, -0.13294640f, -0.16972117f, 
    -0.11228120f, -0.02296201f, 0.45660388f, 0.23235373f, 0.11958493f, -0.09708001f, -0.10146474f, 0.01607305f, 
    0.20822968f, 0.03191051f, 0.26757178f, 0.04894240f, 0.13185678f, -0.10587718f, 0.00675277f, -0.04781716f, 
    0.07881927f, -0.07724568f, -0.04087795f, -0.02998220f, -0.00083171f, -0.02986831f, 0.07185576f, 0.03965086f, 
    0.04920341f, 0.10861269f, 0.23061354f, 0.13425787f, -0.05290088f, -0.04271837f, -0.06074344f, -0.02930915f, 
    0.06975101f, 0.07415603f, 0.15415491f, 0.18717825f, -0.27685887f, -0.04057032f, -0.13392548f, 0.17461613f, 
    -0.10803787f, -0.04338088f, 0.16080900f, 0.14947771f, 0.09504078f, 0.07782577f, 0.00363708f, -0.04123889f, 
    0.00443808f, -0.18097503f, 0.11823076f, 0.28981715f, 0.05743177f, 0.03392864f, 0.02855217f, 0.06599288f, 
    -0.02639486f, 0.10029376f, 0.05234703f, 0.10211345f, -0.03084368f, 0.12203310f, -0.06585091f, 0.00539741f, 
    -0.05871539f, 0.11168911f, 0.10789727f, -0.07638720f, 0.20260817f, 0.23978159f, 0.19034065f, 0.13964422f, 
    0.00322052f, 0.13009289f, 0.10734282f, 0.05280261f, 0.02191290f, -0.18287539f, 0.04307032f, -0.03152152f, 
    0.10663991f, -0.07335748f, -0.06617526f, -0.00670881f, 0.04003616f, 0.05861519f, 0.15115665f, -0.05609879f, 
    0.00312511f, -0.02807163f, -0.00588549f, 0.03191675f, 0.09154892f, -0.07710720f, 0.03859697f, 0.08245267f, 
    0.02313484f, -0.11134889f, 0.21269214f, -0.20425949f, 0.03130990f, -0.02988277f, -0.08621956f, 0.06724283f, 
    -0.10269482f, -0.16048674f, -0.11434418f, -0.18544361f, 0.04184074f, 0.04147772f, 0.21800391f, 0.06457183f, 
    -0.02364555f, -0.15986031f, -0.05582365f, -0.20188934f, 0.05510783f, 0.10329019f, 0.26357591f, 0.20129818f, 
    0.02186304f, -0.09581643f, 0.02942873f, 0.19977233f, -0.06477749f, 0.05603684f, 0.00365369f, 0.01089928f, 
    0.06972017f, 0.17696047f, 0.23192213f, 0.24477628f, 0.14101234f, 0.23412797f, 0.13544248f, 0.13057849f, 
    -0.01872162f, -0.09575598f, 0.06642151f, -0.11639426f, 0.11772114f, -0.07269502f, -0.07773904f, 0.10232414f, 
    0.14376710f, -0.04376391f, 0.48427498f, -0.16265978f, 0.02863726f, -0.03067092f, -0.09679175f, 0.10486124f, 
    -0.19333547f, -0.01414275f, 0.01826409f, -0.05249692f, -0.22526564f, -0.23718062f, 0.00422859f, 0.06786150f, 
    -0.03728896f, -0.10176290f, -0.17299727f, 0.06795701f, -0.03237671f, -0.16875181f, -0.12848641f, -0.09854409f, 
    0.14135993f, 0.00190935f, -0.10524031f, -0.04230587f, 0.00249788f, -0.06875891f, 0.00668301f, 0.01953048f, 
    -0.15888748f, 0.04651533f, -0.12042569f, -0.16220523f, 0.00568469f, 0.22868291f, -0.00792610f, -0.02431345f, 
    0.00383400f, 0.11881585f, -0.02909199f, -0.14254260f, 0.02281806f, -0.03252937f, -0.05825910f, 0.10671490f, 
    0.00358689f, -0.14867330f, -0.14000250f, 0.09864365f, 0.07216869f, -0.11574482f, -0.05731644f, 0.12342805f, 
    -0.18338089f, -0.02089869f, -0.04644193f, -0.17872667f, -0.08761235f, 0.05369555f, 0.03982900f, 0.05720959f, 
    0.06570172f, -0.03379478f, -0.03295246f, 0.07534963f, -0.23501602f, 0.10567576f, -0.02050639f, 0.04520057f, 
    0.31332743f, -0.11492565f, -0.10858816f, -0.07126588f, 0.06828406f, 0.10767436f, 0.11927569f, -0.16883536f, 
    0.17131680f, 0.19550872f, 0.13702807f, 0.37680659f, -0.04824141f, 0.18656626f, -0.07548723f, -0.05755663f, 
    -0.03527500f, -0.02254473f, 0.01350624f, 0.00211258f, -0.04092767f, 0.07689803f, 0.07527440f, -0.05055019f, 
    0.00518646f, 0.04891338f, -0.23291191f, -0.06564077f, 0.01455520f, 0.02001388f, -0.01575034f, 0.01021829f, 
    0.15555020f, 0.11560009f, 0.01592594f, 0.03836277f, 0.02728280f, 0.04992111f, -0.07566913f, 0.08497577f, 
    0.11362399f, 0.04877235f, 0.11814269f, 0.00673421f, 0.00204178f, -0.11941127f, -0.07084769f, -0.05395149f, 
    -0.17218143f, -0.19296987f, 0.25551894f, 0.23822126f, -0.05634389f, -0.07144137f, -0.05896098f, 0.09835492f, 
    0.06589473f, 0.03921818f, 0.03605552f, 0.03411052f, -0.17925726f, -0.16160879f, 0.17160307f, 0.09539107f, 
    -0.03309713f, -0.06179000f, 0.00001915f, 0.05128217f, 0.12131301f, 0.08850446f, 0.12837639f, 0.08257821f, 
    0.06900923f, 0.40673608f, 0.27976841f, -0.10060974f, -0.01851203f, 0.03835782f, -0.03139233f, -0.03576516f, 
    -0.09604228f, 0.10096752f, 0.12745036f, 0.03878118f, 0.09719039f, 0.06024312f, -0.03703690f, -0.03244696f, 
    0.02010179f, -0.02829838f, -0.10254892f, 0.00809967f, -0.01420294f, -0.11618521f, -0.14410110f, -0.16921911f, 
    0.06618663f, 0.15689631f, 0.05016974f, -0.02923235f, 0.02217575f, -0.10777939f, -0.06431534f, -0.03925558f, 
    0.00847763f, -0.02339303f, -0.15246063f, -0.01441205f, -0.17732278f, -0.21415362f, 0.07233428f, 0.13742113f, 
    -0.01719044f, -0.03258993f, -0.10010576f, -0.11431845f, 0.04665776f, 0.05975023f, 0.05809220f, 0.07861455f, 
    -0.02623440f, 0.01848184f, -0.03374673f, -0.00204071f, 0.02022411f, -0.00671956f, 0.02548341f, -0.00672714f, 
    0.00872457f, -0.00251289f, 0.01710274f, -0.03577113f, 0.02395147f, -0.00291691f, 0.03292803f, -0.01657145f, 
    0.02329995f, -0.02299568f, -0.03134664f, -0.02431961f, -0.02258945f, -0.03963206f, -0.01649645f, 0.01061148f, 
    -0.00202951f, -0.01219903f, -0.00666922f, -0.01618782f, -0.03052636f, 0.02204335f, -0.02151716f, -0.02368915f, 
    0.01502704f, -0.00774351f, -0.00232589f, -0.03396884f, -0.03183107f, 0.01836030f, -0.03125207f, -0.02162907f, 
    -0.02293688f, 0.02344033f, -0.02458101f, -0.00914987f, -0.04074427f, 0.03434731f, 0.01664154f, -0.03114688f, 
    -0.01245969f, -0.00061772f, -0.01777142f, -0.03141966f, 0.03261039f, 0.02408790f, 0.02784561f, -0.02505664f, 
    -0.03336797f, -0.02738448f, -0.04011320f, -0.00204898f, 0.01078357f, -0.02654988f, 0.01194870f, 0.01278908f, 
    -0.00137799f, -0.02471234f, -0.01282976f, -0.02306751f, 0.02239637f, 0.00180384f, -0.01648881f, -0.04246157f, 
    0.00339238f, -0.02121643f, -0.02843038f, 0.03204706f, 0.03443035f, -0.01836660f, -0.01302921f, -0.00295724f, 
    -0.00015554f, -0.01561499f, 0.02544910f, 0.00750846f, 0.02485405f, -0.03919128f, 0.00350560f, -0.01212517f, 
    0.03710340f, 0.01030128f, -0.03568842f, 0.01262973f, 0.02301630f, -0.02300780f, 0.01837595f, 0.02688270f, 
    -0.01541956f, -0.03181506f, 0.02262586f, 0.01694238f, -0.04008580f, 0.01364711f, 0.02246372f, -0.03388495f, 
    -0.03724660f, -0.00730161f, 0.02030616f, -0.03611341f, 0.00129425f, -0.03277868f, 0.00281629f, -0.03093635f, 
    -0.01980839f, 0.00728056f, 0.03624843f, 0.01819622f, -0.02923236f, 0.01187070f, 0.00951813f, -0.01237015f, 
    0.02170024f, 0.01494695f, -0.03183912f, -0.02136363f, -0.02292849f, -0.03387195f, -0.01716389f, -0.02103490f, 
    -0.00920086f, -0.01550576f, 0.01587442f, 0.03106857f, 0.03123774f, 0.00292023f, -0.03175944f, -0.03381159f, 
    -0.02745304f, -0.00112658f, 0.02301263f, -0.03133012f, 0.00420434f, -0.02672898f, -0.01999089f, -0.03313274f, 
    0.02674570f, -0.03368275f, 0.01919254f, 0.00820594f, -0.01029639f, 0.03013505f, 0.00058089f, -0.01922774f, 
    -0.00093073f, -0.00067574f, -0.02574844f, 0.01085588f, 0.02640752f, -0.03335076f, -0.04091442f, 0.01795720f, 
    -0.01699893f, -0.01750304f, -0.01677207f, -0.00897259f, -0.03439455f, 0.00960858f, -0.01595258f, 0.01848219f, 
    -0.04038047f, -0.04101170f, 0.02291976f, 0.02058976f, 0.00436140f, 0.02251684f, -0.02291820f, -0.02553828f, 
    -0.02539966f, -0.01230400f, 0.00641036f, -0.01465103f, -0.02651610f, -0.02148861f, -0.03889132f, -0.01245360f, 
    0.00697227f, 0.01984309f, -0.01847368f, -0.00482289f, -0.00951130f, 0.01656005f, 0.00441492f, -0.01760053f, 
    0.02278478f, 0.01261240f, -0.00823600f, -0.00771469f, 0.02207788f, -0.02645860f, 0.00682164f, -0.04173196f, 
    0.00285772f, -0.01111249f, -0.03187310f, 0.02756270f, -0.03090080f, 0.00459396f, 0.03048781f, -0.01456380f, 
    -0.02168594f, -0.00910276f, -0.01106972f, 0.01750628f, -0.01253166f, 0.03191569f, 0.01669057f, -0.00631799f, 
    -0.00271876f, 0.01789071f, -0.03542714f, -0.00764431f, -0.01628370f, -0.00644709f, 0.02853220f, 0.02765207f, 
    -0.00258083f, 0.00171480f, -0.03441736f, -0.03777616f, 0.00852704f, 0.00375615f, -0.02044753f, 0.02280046f, 
    0.00899869f, -0.03822356f, -0.03626931f, -0.03134820f, -0.01146769f, 0.02688736f, -0.00962255f, -0.04190141f, 
    -0.01115528f, 0.03171426f, 0.01830552f, -0.02386752f, -0.03453426f, 0.00009997f, -0.00806557f, -0.01608628f, 
    -0.01489626f, -0.01289367f, -0.03297664f, -0.00892649f, 0.00550165f, 0.02416920f, -0.01546683f, -0.01320739f, 
    0.00910019f, -0.00876347f, 0.02422814f, -0.01871332f, -0.01052894f, 0.01322959f, -0.03201235f, 0.00641982f, 
    0.02517365f, -0.01728055f, -0.00987669f, -0.02526391f, -0.02420175f, -0.00258031f, -0.03805042f, -0.02511087f, 
    -0.01588905f, 0.01273116f, 0.00097055f, -0.02573359f, -0.00560409f, 0.00441821f, 0.00282061f, -0.03337009f, 
    0.02449298f, -0.04060357f, -0.00611546f, 0.00563849f, -0.03780903f, 0.02749924f, -0.03123428f, 0.02817788f, 
    0.01351336f, -0.03681091f, -0.01156876f, 0.00321285f, 0.03741880f, -0.01525358f, -0.02685389f, -0.03867298f, 
    -0.00758507f, -0.01403534f, 0.03162755f, -0.00903036f, 0.02311019f, -0.03486823f, 0.02033935f, 0.01434162f, 
    -0.01565044f, 0.00710612f, -0.03576310f, -0.00096205f, -0.00306725f, 0.02382441f, 0.00243180f, 0.02727824f, 
    0.00927969f, -0.00189945f, -0.00221470f, -0.00701002f, 0.01109039f, 0.02669290f, 0.01078992f, -0.01754513f, 
    -0.02408787f, -0.03399222f, -0.01665442f, -0.00099040f, -0.02045778f, 0.01371913f, 0.00692805f, -0.00868255f, 
    -0.01013464f, -0.04193345f, -0.02248169f, 0.00855874f, -0.03839560f, -0.01673057f, 0.01293975f, -0.00542074f, 
    -0.01290595f, -0.01984883f, 0.00383779f, -0.03997910f, 0.01340087f, -0.03688456f, 0.00899586f, -0.00577979f, 
    -0.03523572f, 0.01591443f, 0.01790262f, -0.00406489f, 0.02155368f, -0.00877483f, -0.00664878f, -0.04308244f, 
    -0.00420101f, 0.01366045f, -0.03511016f, -0.01995525f, -0.00344098f, -0.02071275f, -0.00296587f, -0.02975323f, 
    -0.03105535f, 0.02982113f, 0.00598736f, 0.01707804f, 0.00364575f, -0.00169616f, -0.02595413f, -0.01370046f, 
    0.03017982f, -0.01733142f, 0.02079381f, -0.02761881f, -0.03921634f, -0.03409414f, -0.02140010f, -0.00013510f, 
    -0.04258331f, 0.01513737f, -0.00315455f, -0.00265236f, -0.02002289f, 0.00029435f, 0.00346277f, -0.02774111f, 
    -0.04119278f, -0.01393064f, -0.02791586f, 0.00190262f, -0.03960012f, -0.03109826f, -0.00204908f, -0.02089930f, 
    0.01625575f, -0.00977781f, 0.02613655f, -0.00759560f, 0.03020895f, -0.00791311f, 0.00691964f, 0.02804921f, 
    -0.02185784f, 0.01071618f, -0.03264332f, 0.01782333f, 0.02666197f, -0.01402638f, -0.02013364f, 0.02435422f, 
    -0.01008110f, -0.02967115f, 0.01409958f, 0.00036452f, 0.01168331f, -0.03408854f, 0.02074235f, -0.00670348f, 
    0.01175803f, -0.02449040f, -0.01924278f, 0.01743311f, -0.02361396f, -0.01252076f, 0.02524004f, -0.03787570f, 
    0.01859772f, -0.01314972f, -0.02336793f, -0.00843114f, -0.01091916f, -0.01174622f, 0.01075815f, 0.00968430f, 
    -0.00919020f, -0.02253916f, -0.00595698f, -0.00936246f, -0.02342765f, -0.01273936f, 0.02529701f, -0.03402660f, 
    0.00132967f, -0.01039491f, 0.02588880f, 0.03046759f, -0.00506879f, 0.01091220f, -0.02282520f, -0.00105022f, 
    -0.00010648f, 0.02456231f, -0.02111554f, -0.01997418f, 0.00855653f, -0.03836336f, -0.01717486f, -0.01953406f, 
    0.01919814f, 0.01413593f, 0.00576988f, 0.01062001f, 0.02944552f, -0.00933955f, 0.02514201f, 0.01073364f, 
    0.00890448f, -0.03167231f, 0.02701141f, -0.02933916f, -0.03349169f, -0.02216961f, -0.03555221f, 0.02839435f, 
    -0.02757522f, 0.00462193f, 0.00267364f, -0.01751812f, -0.01011369f, -0.00215783f, -0.01154332f, 0.01318234f, 
    -0.03828682f, 0.02276184f, -0.02182739f, 0.01743342f, 0.01513990f, -0.02295555f, 0.00629106f, -0.03702380f, 
    0.00663061f, 0.00899511f, -0.00415622f, -0.01026235f, 0.01195567f, 0.02928983f, 0.02181506f, 0.00069582f, 
    0.01878575f, -0.03180881f, -0.03258472f, 0.02681045f, -0.02852722f, -0.02595938f, -0.00394113f, -0.00213120f, 
    -0.03326232f, 0.00871298f, -0.03647774f, -0.01175841f, 0.00034110f, -0.00615465f, -0.02595371f, 0.02356051f, 
    0.03189123f, -0.04496580f, -0.03363593f, 0.02192618f, 0.02276328f, -0.00999315f, 0.02000896f, -0.02982505f, 
    -0.03320883f, -0.02935999f, -0.02312705f, 0.02844842f, 0.02069741f, -0.03555932f, 0.02229497f, -0.00999407f, 
    0.00400060f, -0.02473724f, -0.03492645f, 0.01965102f, -0.01934139f, 0.02373583f, 0.01901210f, -0.01781964f, 
    0.02626814f, 0.02323752f, -0.03745463f, 0.02892565f, -0.02503728f, -0.01449166f, 0.02791576f, 0.02070296f, 
    -0.02644818f, 0.01517724f, 0.01665145f, 0.02314043f, 0.03252781f, 0.00341653f, -0.04097116f, -0.04184647f, 
    -0.03511197f, 0.00032138f, -0.02068721f, 0.01216778f, 0.02079348f, -0.01063245f, 0.00430330f, -0.04185582f, 
    -0.01045367f, 0.00556048f, -0.00567112f, 0.01189707f, -0.00366384f, -0.01521771f, 0.02167107f, -0.01926033f, 
    -0.01752978f, -0.00373422f, -0.01036037f, 0.01308884f, -0.00822912f, -0.03722982f, -0.02364048f, 0.02646239f, 
    0.02959197f, -0.02620076f, 0.00921240f, -0.01001581f, 0.02930964f, 0.02811278f, -0.01494069f, 0.01310196f, 
    -0.03794096f, -0.01472603f, -0.00446386f, -0.00564001f, 0.01045113f, 0.00730744f, -0.00499767f, -0.00627796f, 
    0.01563803f, -0.04186027f, 0.01701833f, -0.02702226f, -0.03684220f, -0.03568277f, 0.02144983f, 0.02842551f, 
    -0.03227939f, -0.03972968f, -0.00955870f, -0.00898952f, 0.01760156f, -0.00296561f, -0.03023197f, 0.03121314f, 
    -0.00968063f, -0.00420753f, -0.00093830f, -0.00042179f, 0.01346313f, -0.00314468f, -0.03682145f, 0.01085100f, 
    -0.03923912f, 0.03276876f, -0.02443257f, 0.00278197f, -0.00079649f, 0.02751679f, -0.01051587f, 0.00917447f, 
    -0.01588692f, -0.00673900f, -0.01621352f, 0.00860950f, -0.02137532f, 0.00750116f, 0.00097122f, -0.00924023f, 
    0.01985680f, -0.00821068f, -0.01916695f, 0.01659910f, 0.00179333f, -0.03236305f, -0.00376825f, -0.01764891f, 
    0.02566204f, 0.01551496f, -0.02336113f, 0.02169410f, 0.01559465f, -0.03558521f, 0.02844533f, 0.00355906f, 
    -0.01991501f, 0.01283022f, 0.02400611f, 0.01967476f, -0.02309684f, -0.00199056f, -0.02075394f, -0.02010729f, 
    0.00416112f, -0.00043274f, -0.02315847f, -0.02651388f, -0.02699840f, 0.02880719f, -0.04086747f, -0.00528381f, 
    -0.04123247f, 0.00863268f, -0.00303782f, 0.00934043f, -0.01566679f, -0.01562737f, -0.01471416f, 0.03290018f, 
    0.01649792f, -0.01569087f, -0.01546771f, 0.00781696f, 0.02835858f, -0.02916487f, 0.02951674f, -0.03468741f, 
    -0.03678397f, -0.03779842f, 0.02637025f, 0.00220151f, -0.03627593f, 0.02121990f, 0.01902205f, -0.02873308f, 
    0.02023934f, -0.02734153f, -0.01355169f, -0.00420461f, 0.00309605f, 0.01959798f, 0.00543959f, -0.01075640f, 
    0.02621992f, 0.02692389f, 0.02879524f, -0.04022888f, 0.00822801f, 0.02530976f, -0.01107929f, -0.02163637f, 
    -0.03255411f, -0.00142895f, 0.01301644f, 0.01902046f, 0.00096096f, 0.01616731f, 0.02439301f, -0.00939573f, 
    -0.00538181f, -0.00409417f, -0.02019595f, -0.02609033f, -0.03096456f, 0.02165676f, 0.02431840f, -0.01733861f, 
    -0.00257039f, 0.00829333f, 0.02353329f, 0.02720495f, 0.01336162f, -0.01747989f, 0.00729215f, -0.00843846f, 
    -0.00297609f, -0.00951470f, -0.00259674f, -0.01982456f, 0.03113477f, -0.02906191f, 0.04141575f, -0.01237141f, 
    0.03645182f, 0.01803616f, 0.01221971f, 0.00685189f, -0.02277500f, -0.03986631f, -0.01463692f, 0.03887822f, 
    0.00350343f, 0.02285085f, 0.00678220f, 0.03577071f, 0.01322033f, 0.01017202f, -0.00682048f, -0.00458861f, 
    -0.02531612f, -0.03202776f, -0.02475780f, 0.01614304f, -0.03808761f, -0.02561971f, -0.01199001f, -0.02732627f, 
    -0.00323418f, 0.01640272f, -0.03619932f, 0.02888215f, 0.00878111f, -0.00529367f, 0.00580177f, -0.00761392f, 
    0.00898860f, 0.02877199f, 0.00186092f, 0.01250179f, -0.00068612f, -0.03493893f, 0.01972573f, -0.00615384f, 
    0.01130783f, -0.03271157f, -0.01677646f, -0.04038097f, -0.02125056f, -0.01558430f, 0.01454723f, 0.02565356f, 
    0.00496335f, 0.01690593f, -0.01795364f, 0.02628803f, 0.00576810f, -0.00183578f, 0.01814996f, -0.01412332f, 
    -0.03451149f, 0.00546211f, -0.01521320f, -0.00864080f, -0.01594602f, -0.00507157f, -0.03215389f, -0.03513470f, 
    -0.02345037f, 0.01924021f, -0.02995176f, 0.01868582f, -0.00065578f, -0.00238426f, -0.01571104f, -0.03844364f, 
    0.02057448f, -0.01396621f, -0.03363701f, 0.02579303f, 0.02031758f, -0.02294046f, 0.01289566f, -0.00485147f, 
    -0.01397476f, -0.01681500f, -0.02740516f, 0.00256007f, -0.02482643f, -0.00174771f, -0.04175102f, -0.02185920f, 
    -0.00301569f, -0.03762342f, -0.01295481f, -0.00060021f, 0.00568581f, -0.00799707f, 0.02464928f, -0.01693061f, 
    -0.03069234f, -0.00707538f, -0.00740585f, -0.01383427f, 0.01677898f, -0.02012181f, 0.00816801f, 0.01586714f, 
    -0.00878617f, 0.00601985f, 0.01912485f, -0.00384367f, -0.02179930f, 0.01798694f, -0.02527344f, 0.00730426f, 
    0.02405623f, -0.02296468f, -0.02522432f, -0.03403204f, -0.02308187f, 0.00088162f, -0.01989331f, -0.00426008f, 
    -0.03136491f, 0.02676218f, -0.01905790f, -0.04175104f, -0.02388751f, 0.00848814f, -0.01849789f, 0.01711556f, 
    -0.03573832f, -0.00406488f, 0.02149356f, 0.00074096f, -0.00280129f, -0.02024715f, 0.00691434f, -0.02852236f, 
    0.02145840f, -0.03720500f, 0.00686987f, 0.02564783f, 0.03240408f, 0.01618067f, -0.03098234f, 0.02210992f, 
    0.00542717f, -0.01767550f, -0.03072319f, -0.03139923f, 0.01695609f, -0.03176016f, 0.01096193f, -0.02326856f, 
    -0.00921992f, 0.00930542f, -0.03725693f, -0.01465604f, -0.00418346f, 0.01962161f, -0.00624010f, -0.03780694f, 
    0.00675349f, -0.01347074f, -0.01944071f, 0.01663397f, -0.04023032f, -0.02151853f, -0.03705303f, -0.01791615f, 
    -0.00979877f, 0.02018117f, -0.00088644f, -0.00786517f, 0.00094575f, -0.00495625f, 0.02975477f, -0.01390520f, 
    -0.01269369f, -0.04042666f, 0.02229833f, 0.00740518f, -0.01765154f, 0.00130724f, -0.02751678f, 0.01862523f, 
    0.02741565f, 0.02680681f, -0.01838743f, 0.02259618f, -0.04177111f, 0.00439334f, 0.00699826f, 0.02308179f, 
    -0.03086972f, -0.01009805f, 0.00548923f, 0.00984220f, -0.00273345f, 0.01888655f, -0.02474544f, -0.01081627f, 
    0.02747000f, 0.02305985f, 0.01468729f, -0.02364359f, -0.03380161f, -0.00089782f, -0.02822918f, 0.01361622f, 
    -0.03874505f, 0.01346876f, -0.02511471f, -0.03196212f, 0.00463301f, -0.03534966f, -0.03154561f, 0.02335513f, 
    -0.01183999f, -0.03588072f, -0.00485052f, -0.03428871f, -0.01350093f, -0.03939049f, 0.01018658f, -0.02426255f, 
    0.02485627f, 0.02503560f, -0.04130701f, 0.01104223f, 0.00200154f, -0.01982931f, -0.02344630f, 0.00167704f, 
    -0.01264957f, 0.03321843f, 0.02301303f, -0.02463476f, -0.01172609f, 0.00269632f, 0.00547594f, -0.00369578f, 
    -0.02941375f, -0.00179747f, 0.00549444f, -0.00569054f, -0.00098362f, 0.01442833f, -0.02947445f, 0.00669557f, 
    0.00179057f, -0.01067576f, -0.01290151f, -0.03390396f, 0.01940726f, -0.01038251f, 0.01947582f, 0.01303198f, 
    -0.00741584f, 0.00456706f, -0.03873949f, 0.01364793f, -0.00564149f, -0.03255083f, -0.01000562f, 0.00533537f, 
    0.02800054f, -0.03321668f, 0.02070045f, -0.03928296f, -0.03490091f, -0.04168277f, -0.03404681f, 0.02902031f, 
    -0.01729471f, -0.01401967f, 0.02745540f, -0.02933639f, 0.02457560f, 0.02763750f, 0.01180549f, -0.03793206f, 
    -0.04144528f, 0.00120482f, -0.02817021f, 0.02949691f, -0.01433972f, 0.02498979f, 0.01105402f, -0.03744986f, 
    0.01678286f, -0.04113750f, -0.02996132f, 0.02192626f, 0.01272938f, 0.02433735f, -0.02913187f, -0.03766363f, 
    -0.02477037f, -0.02599156f, -0.00556486f, 0.01581648f, 0.02770993f, -0.01269945f, 0.02922305f, 0.00360118f, 
    0.01318816f, -0.00835850f, -0.01535754f, -0.02086469f, 0.00763630f, -0.00400773f, 0.02220430f, 0.01222601f, 
    0.00524569f, -0.00221177f, -0.03466341f, -0.01498127f, -0.03382871f, -0.02647365f, 0.00303428f, 0.02379185f, 
    0.03578867f, 0.00072518f, 0.00330157f, -0.04033915f, 0.02870744f, 0.01510155f, -0.02971631f, -0.01958430f, 
    -0.01018596f, -0.00354766f, -0.01575612f, -0.02643435f, -0.01009698f, -0.02571106f, -0.01388588f, 0.00963299f, 
    0.02725783f, 0.02683404f, 0.01207405f, -0.00699193f, -0.01295015f, -0.03111951f, -0.00383231f, 0.00774621f, 
    0.00278825f, -0.01880765f, 0.01062542f, -0.01263638f, -0.01809721f, -0.03614857f, -0.01944841f, -0.03431958f, 
    0.01593266f, 0.01168410f, -0.00102526f, -0.00492254f, 0.02072755f, 0.00284208f, 0.01686055f, -0.03707905f, 
    -0.01878664f, -0.00194271f, 0.00219808f, 0.00583965f, 0.01712289f, -0.02297450f, 0.00013023f, 0.00449381f, 
    -0.03480806f, -0.02854342f, -0.02188503f, -0.03388996f, -0.00464483f, 0.01690467f, -0.00409827f, 0.01603148f, 
    -0.02511594f, 0.01996944f, -0.01807750f, -0.01207204f, 0.01086774f, 0.02860409f, 0.00011728f, 0.00588577f, 
    -0.00221098f, -0.03360184f, 0.01235800f, 0.02548358f, 0.01587773f, 0.00805362f, -0.02008574f, -0.02719944f, 
    -0.01105212f, 0.02186338f, -0.02950241f, -0.02321330f, -0.00769497f, 0.01060510f, 0.01779637f, -0.04050119f, 
    -0.02005957f, -0.01360505f, 0.02311991f, 0.00063314f, 0.02882264f, -0.02842130f, 0.02257021f, -0.04165790f, 
    0.00934497f, -0.03016186f, 0.00173382f, -0.00093084f, -0.03865355f, -0.00647715f, -0.00449472f, 0.00742124f, 
    -0.03985245f, -0.01909383f, -0.03883389f, -0.00635421f, -0.00248520f, -0.03863618f, 0.00309049f, -0.02663531f, 
    -0.01207050f, -0.01124990f, -0.02993556f, 0.01130262f, -0.01844458f, -0.03394086f, 0.00648629f, -0.01199457f, 
    -0.00435625f, -0.02966219f, -0.03265191f, -0.00216250f, -0.01476829f, -0.03014816f, 0.01045166f, 0.02315319f, 
    0.02340931f, -0.01890176f, -0.01919165f, -0.03376413f, -0.02901826f, 0.02643696f, 0.02210215f, -0.03421509f, 
    -0.03191734f, -0.01663117f, -0.01414332f, -0.03551225f, -0.03917634f, -0.02546729f, 0.02583464f, -0.00875654f, 
    0.01319818f, 0.01093762f, 0.02547895f, 0.00152103f, -0.02170460f, -0.00106382f, 0.00150663f, -0.03056186f, 
    -0.01805012f, 0.00771712f, 0.02888714f, -0.01229642f, -0.02001949f, 0.00073123f, -0.03100300f, 0.03312036f, 
    0.02617279f, -0.02128184f, -0.01161398f, 0.02532854f, -0.00073481f, 0.02123906f, 0.00246835f, -0.02946819f, 
    -0.03972984f, -0.01276922f, -0.00686352f, -0.00212643f, 0.00873041f, -0.01614184f, -0.03301173f, 0.02544396f, 
    -0.00524477f, -0.03216887f, 0.02748356f, -0.03277707f, -0.01988165f, 0.02255774f, 0.02411355f, -0.01121620f, 
    -0.03952508f, 0.01800826f, -0.00610060f, -0.03323543f, 0.02142353f, 0.02099390f, -0.02852126f, -0.01804995f, 
    -0.03287145f, -0.03447438f, 0.00961364f, -0.00857258f, -0.02234145f, 0.00564453f, -0.01073529f, -0.00719914f, 
    0.02591141f, -0.03491181f, -0.01877706f, 0.01008257f, 0.00850787f, 0.02533821f, 0.01656741f, 0.00661556f, 
    0.00627832f, -0.02703990f, -0.00823320f, -0.03000032f, 0.01393536f, 0.00296105f, -0.00701740f, 0.03006055f, 
    0.01737963f, -0.02834273f, -0.00491901f, -0.00166099f, -0.03063141f, 0.02934431f, -0.01119823f, 0.00051724f, 
    -0.03089692f, -0.03608135f, -0.00793371f, 0.02151618f, -0.02077701f, 0.02764833f, -0.00104746f, -0.02705425f, 
    0.00143285f, 0.01587958f, -0.03280034f, 0.01278589f, 0.02206274f, -0.02267195f, -0.01702819f, -0.01337111f, 
    0.00671610f, -0.02295280f, -0.03164732f, 0.02415382f, 0.00524582f, -0.00963604f, 0.00073591f, 0.00400002f, 
    -0.04202248f, 0.02413173f, -0.00609870f, -0.03025745f, -0.03768095f, -0.03692514f, 0.00455221f, -0.02791376f, 
    -0.01596150f, 0.00063252f, -0.02481284f, 0.02041273f, -0.00661084f, 0.02103773f, 0.00143434f, 0.01611159f, 
    -0.01591128f, 0.02618508f, 0.03445111f, 0.00521226f, -0.04203449f, 0.03324090f, -0.01952811f, -0.02447271f, 
    -0.02006267f, -0.03020001f, -0.02703676f, -0.00356931f, -0.02598395f, -0.04168950f, 0.03285159f, -0.01348857f, 
    -0.03751649f, 0.00773485f, -0.00846014f, -0.00782008f, -0.01468478f, -0.03311374f, -0.01241589f, -0.03262148f, 
    -0.03740067f, 0.01499770f, 0.01590678f, 0.01699306f, -0.03616396f, -0.02594639f, 0.00076597f, 0.00978684f, 
    0.01562850f, 0.00291697f, 0.01690318f, -0.02017388f, -0.01741451f, -0.00877712f, -0.01115938f, -0.02181987f, 
    0.00881994f, 0.02542580f, -0.04195404f, -0.03149888f, -0.03926111f, -0.01333788f, -0.01995425f, 0.02754934f, 
    -0.00480227f, 0.02129242f, 0.02017411f, -0.02751633f, -0.03126014f, 0.02235519f, -0.03272439f, -0.03593642f, 
    -0.02860173f, -0.02631550f, -0.01838139f, 0.03388214f, -0.04189385f, -0.01466696f, -0.02198861f, -0.01294856f, 
    -0.00527352f, -0.03255407f, 0.02515300f, 0.01984115f, 0.02745780f, -0.01036957f, -0.02184420f, 0.00292479f, 
    -0.03720318f, 0.00494397f, 0.01828923f, 0.01287359f, 0.02940851f, -0.01558269f, -0.01274833f, -0.03303590f, 
    -0.01683668f, 0.00282580f, 0.01739402f, 0.00717486f, -0.00457410f, -0.01068270f, 0.02658417f, -0.03991916f, 
    0.00200949f, -0.00506003f, -0.03265788f, 0.01797265f, 0.01581768f, 0.00432925f, 0.02631097f, -0.03183468f, 
    0.01885082f, 0.02676823f, -0.03515363f, -0.02087169f, -0.02299830f, 0.00064880f, 0.01857107f, -0.03696746f, 
    -0.00758157f, 0.00258485f, 0.02584531f, -0.00756179f, 0.01690102f, -0.02800139f, 0.00964528f, -0.03283029f, 
    -0.00921581f, -0.01521287f, 0.02895773f, -0.03392859f, 0.01395991f, 0.00891840f, 0.00395013f, -0.02133693f, 
    -0.03510400f, -0.02142252f, -0.00994611f, 0.02415886f, 0.02568505f, 0.02897521f, 0.00931455f, -0.01353422f, 
    -0.01980286f, -0.02533759f, -0.00079977f, 0.00288413f, -0.01209361f, -0.02685286f, 0.01941635f, -0.01851827f, 
    0.01483750f, -0.00551536f, 0.01361333f, -0.00976939f, 0.01147964f, -0.01309067f, 0.02516292f, 0.02234062f, 
    -0.00361535f, -0.02270338f, -0.03953069f, -0.03946975f, -0.01917606f, -0.00211644f, -0.04045857f, -0.02227105f, 
    -0.02542612f, 0.02994865f, 0.01484137f, -0.00537102f, -0.01328810f, -0.00295754f, 0.01579063f, -0.01551713f, 
    -0.02847653f, 0.00431121f, 0.00335668f, 0.00521328f, -0.02054564f, -0.01435083f, -0.02808545f, 0.01925458f, 
    -0.01752225f, -0.02410389f, -0.01511806f, -0.02011416f, -0.00764452f, -0.03461339f, -0.01372841f, 0.01376030f, 
    -0.00739946f, -0.01082432f, -0.01428453f, 0.00167510f, 0.02601968f, -0.02058494f, 0.01616277f, 0.00247209f, 
    -0.02308292f, 0.02942009f, -0.01803765f, -0.01116580f, -0.01543378f, 0.01692588f, 0.01226829f, 0.02896372f, 
    0.01311074f, -0.02762551f, 0.00112807f, -0.00585893f, -0.00311896f, -0.02270995f, -0.02959309f, 0.01063073f, 
    -0.04026140f, -0.02526389f, 0.00966370f, -0.02885381f, -0.03089969f, -0.01398029f, -0.02647840f, -0.01524147f, 
    -0.02726606f, -0.01040045f, 0.02677557f, -0.01610905f, 0.02613029f, 0.00982822f, 0.01825145f, 0.00123602f, 
    0.00511880f, -0.02585534f, 0.00809797f, 0.03251207f, -0.00272397f, 0.00566068f, 0.00256141f, -0.00170440f, 
    0.01751686f, -0.18202351f, -0.17955770f, -0.20210506f, 0.03493460f, -0.03561846f, 0.11586781f, -0.00129047f, 
    0.19118132f, 0.02358077f, 0.08601574f, 0.09237224f, -0.12690219f, -0.09147217f, -0.19010048f, -0.25319141f, 
    -0.23831081f, -0.07670399f, -0.09653044f, 0.10535657f, -0.02751933f, 0.02522592f, 0.06529785f, -0.06199273f, 
    -0.22965375f, 0.09815272f, 0.10245912f, -0.20585725f, 0.00558482f, 0.13347225f, 0.12562765f, 0.08089603f, 
    0.13342024f, 0.15170594f, 0.04195330f, 0.10885123f, 0.07529505f, 0.05535791f, -0.06671387f, -0.15396936f, 
    -0.02691454f, -0.12131343f, -0.16247956f, -0.06510836f, -0.13089870f, 0.00423482f, 0.11639979f, -0.09188101f, 
    -0.24610184f, -0.12358646f, -0.06725201f, -0.01748333f, -0.06245027f, 0.05866538f, -0.00459195f, -0.01862133f, 
    -0.01909313f, 0.04396723f, -0.02547455f, -0.01174054f, -0.33819899f, 0.00436858f, -0.09512628f, -0.04701827f, 
    0.09967641f, 0.08084963f, -0.06476711f, 0.03104824f, -0.08023179f, -0.05389689f, 0.00871260f, -0.00656882f, 
    0.18242219f, 0.09725732f, 0.09368174f, 0.09523360f, 0.02873410f, -0.01331823f, 0.01630050f, -0.00062918f, 
    0.01366356f, 0.03431984f, -0.02764616f, -0.02081584f, 0.19115478f, 0.21740983f, 0.24943326f, 0.24944575f, 
    -0.06571560f, -0.17156397f, 0.24741428f, 0.00741404f, 0.03291860f, -0.04616087f, -0.09443121f, -0.02341495f, 
    0.32993039f, 0.19616193f, -0.24764729f, 0.10443383f, 0.00137758f, 0.03442174f, 0.01781499f, -0.07776266f, 
    0.00067656f, 0.01641308f, 0.00341508f, 0.05665516f, 0.12147371f, -0.00232232f, 0.02230683f, -0.03232699f, 
    0.06215575f, 0.01898851f, 0.09550012f, -0.06811796f, 0.05812775f, 0.07394432f, -0.08555090f, -0.09173184f, 
    -0.53061610f, -0.14475028f, 0.32221052f, -0.28868103f, 0.08846402f, -0.01047478f, 0.14782195f, 0.12430999f, 
    -0.03496524f, -0.06750939f, -0.07432123f, 0.06428900f, 0.14385307f, 0.08006771f, 0.00771117f, -0.09286950f, 
    0.07897004f, -0.09147003f, -0.02036106f, -0.03703518f, 0.02432474f, -0.02042105f, 0.01135425f, 0.03392338f, 
    -0.00430044f, -0.03862337f, 0.05347703f, -0.07241713f, 0.01625269f, 0.09709769f, 0.06576308f, 0.01651566f, 
    0.06224899f, 0.06749970f, -0.02215885f, -0.02248563f, -0.11147192f, -0.30115199f, -0.10975353f, -0.03798733f, 
    -0.07320339f, -0.08463641f, -0.01689388f, 0.17282251f, 0.03513176f, -0.01981254f, -0.11192288f, -0.08024925f, 
    0.38997850f, 0.27719608f, -0.19085974f, 0.13442500f, -0.16522349f, -0.06386154f, 0.31229770f, -0.03823026f, 
    0.00861395f, 0.03019960f, -0.03391835f, -0.01838565f, 0.10438661f, 0.12923303f, 0.11515117f, 0.14393671f, 
    0.04567156f, 0.06379398f, 0.03548548f, -0.00667369f, 0.09163336f, 0.12675054f, -0.07319062f, 0.20455104f, 
    0.23083116f, 0.15396973f, 0.12425708f, 0.21859899f, -0.01672282f, 0.01021982f, 0.10714477f, 0.05324339f, 
    0.00777299f, -0.02808186f, -0.00397047f, 0.06360337f, 0.19686389f, -0.12715964f, 0.05383699f, 0.09699784f, 
    0.01457340f, -0.05324888f, -0.05898981f, -0.02962895f, -0.04736568f, -0.12465537f, 0.11159198f, 0.13986728f, 
    0.21662827f, 0.04394713f, 0.04449500f, 0.20026785f, -0.02598746f, 0.04838241f, 0.17036611f, -0.05285491f, 
    0.10288484f, 0.06220154f, -0.00635475f, -0.01682891f, -0.53478736f, 0.01285304f, -0.08726642f, -0.02778119f, 
    0.04743506f, 0.00530730f, -0.02680818f, 0.06809402f, -0.11307793f, -0.01953641f, 0.00672870f, -0.03906615f, 
    0.27911901f, 0.00081394f, 0.09032297f, -0.17892481f, -0.16731635f, -0.01470442f, -0.10367789f, 0.00671519f, 
    -0.17926843f, 0.11491249f, -0.05514786f, -0.01617965f, 0.10818747f, 0.01751603f, 0.27562350f, -0.01860053f, 
    0.09335228f, 0.14089437f, -0.07198549f, 0.04082701f, 0.02475208f, 0.08415387f, -0.04843876f, -0.00232273f, 
    -0.23565279f, -0.19638205f, -0.37686622f, -0.39501119f, 0.06768247f, -0.05234315f, -0.13019148f, 0.18986219f, 
    0.03930503f, -0.04583889f, -0.03204310f, -0.04129125f, 0.07082956f, 0.15422821f, 0.12772329f, 0.15678009f, 
    -0.02590723f, 0.11780945f, 0.01496973f, -0.12616758f, -0.13905865f, -0.01065226f, -0.00860000f, -0.11222483f, 
    -0.09730064f, 0.11548987f, 0.07150164f, 0.03803400f, 0.01687268f, 0.09347443f, -0.02231129f, 0.04730423f, 
    0.01500772f, 0.02264578f, 0.06540317f, -0.09042212f, 0.03765995f, -0.06738506f, 0.14044279f, -0.05628008f, 
    -0.00750136f, 0.01137001f, -0.00810343f, 0.01798301f, -0.03273754f, 0.01072160f, 0.05434769f, 0.03368270f, 
    0.17531002f, -0.10574464f, 0.12153713f, -0.08129117f, 0.05918165f, -0.10415549f, 0.07648671f, 0.07263508f, 
    0.04950568f, -0.02225495f, 0.07845516f, 0.08536060f, -0.02029259f, -0.25222275f, 0.10710683f, -0.07449421f, 
    -0.06046134f, 0.04190925f, -0.06749051f, 0.11530656f, 0.14574069f, -0.09558997f, 0.04416026f, 0.04685213f, 
    -0.42430985f, -0.42637831f, -0.07062085f, -0.03438004f, -0.16390222f, 0.24749005f, 0.02579491f, -0.17549205f, 
    -0.04704871f, -0.03390740f, -0.09665506f, -0.07022824f, 0.12962034f, 0.07759766f, 0.09326322f, 0.11263819f, 
    -0.02164933f, -0.05394239f, -0.07412007f, 0.01483516f, -0.05057603f, -0.13681252f, -0.07406155f, -0.09838024f, 
    0.11738528f, 0.00876349f, 0.18010397f, 0.01847027f, 0.05122597f, 0.12472890f, 0.04658655f, -0.05092337f, 
    0.06697033f, -0.15433848f, -0.12273256f, 0.05819960f, 0.43021697f, 0.05485202f, -0.10616490f, -0.27752098f, 
    -0.08014390f, -0.08433185f, -0.09535319f, -0.07540756f, -0.10306215f, 0.05474817f, 0.13068688f, 0.05860536f, 
    -0.19961840f, -0.02802957f, 0.01022373f, 0.17300281f, 0.10443842f, 0.10289276f, 0.05708021f, 0.13948129f, 
    -0.06612414f, -0.05427429f, -0.15050381f, -0.05967006f, -0.21418074f, -0.07246261f, -0.19093141f, -0.32381719f, 
    -0.05742573f, -0.04283024f, 0.07427303f, 0.04165607f, -0.01811605f, -0.10084985f, -0.14038973f, -0.01813588f, 
    0.20260051f, 0.05804168f, -0.10040842f, 0.03037138f, -0.03951494f, 0.07972343f, 0.21749485f, 0.16929342f, 
    0.02683811f, -0.11867971f, -0.02687177f, -0.00976220f, -0.00682188f, 0.00146049f, 0.10827705f, 0.05820091f, 
    0.16125305f, -0.07824037f, 0.09213708f, -0.09009210f, -0.04435326f, -0.09281725f, -0.08114643f, 0.01913840f, 
    0.03938694f, -0.18806791f, -0.18795350f, 0.16172376f, 0.07271745f, -0.05213433f, 0.00808903f, 0.13585429f, 
    0.00897053f, -0.00655045f, 0.09081062f, -0.01669643f, 0.16655819f, 0.19944577f, 0.05456283f, -0.00491474f, 
    -0.00895141f, -0.00029035f, 0.00673424f, -0.06040769f, 0.12762657f, 0.09369176f, -0.01916274f, -0.16442464f, 
    0.10829268f, -0.14466558f, -0.11758792f, -0.09684002f, -0.01828972f, -0.08422897f, -0.11402606f, -0.02353353f, 
    0.04433370f, -0.05026809f, -0.04851703f, 0.06827193f, -0.42756137f, -0.21916163f, -0.03461373f, -0.19146904f, 
    0.26811573f, -0.03146525f, 0.13045545f, 0.32155266f, 0.00991526f, -0.03136353f, -0.13440445f, -0.01969883f, 
    0.25796109f, -0.03285761f, -0.10775924f, -0.10274756f, -0.08060341f, 0.07265630f, -0.09932163f, -0.04437250f, 
    -0.04310912f, 0.05446471f, 0.08258379f, -0.01730496f, -0.26406115f, 0.03915627f, -0.09635776f, 0.07532501f, 
    -0.01454424f, -0.22313115f, 0.17460294f, -0.00492488f, -0.11706604f, 0.04217272f, 0.00081797f, -0.02650329f, 
    0.09520276f, 0.01000889f, 0.06663347f, -0.05477181f, -0.00779299f, -0.09694227f, -0.12041499f, -0.09058186f, 
    -0.01595489f, -0.07131830f, 0.02343085f, 0.01090170f, 0.12715541f, 0.02831282f, 0.11995129f, 0.12314278f, 
    0.07805664f, 0.03488236f, 0.13492751f, 0.07425538f, 0.09303597f, 0.04314210f, -0.00220807f, 0.04203245f, 
    -0.01406383f, 0.24437228f, -0.22145976f, 0.11413905f, -0.11394680f, -0.07768080f, 0.27037701f, -0.16152918f, 
    -0.05024381f, -0.03209164f, -0.00041940f, -0.08079890f, -0.20602590f, -0.31036356f, 0.01758583f, -0.16157271f, 
    -0.09208284f, -0.21905655f, -0.12694372f, 0.04881706f, 0.02895387f, -0.08941350f, 0.07125159f, -0.03170566f, 
    -0.07095605f, -0.11529782f, -0.01091832f, 0.00637339f, -0.06445865f, 0.05553500f, 0.02185204f, 0.07986790f, 
    -0.04559994f, -0.08554013f, 0.03909472f, 0.06308110f, -0.10429442f, 0.02987560f, 0.08825655f, -0.27097055f, 
    0.03920997f, -0.07780692f, -0.15310311f, -0.07432012f, -0.05889769f, -0.04471592f, 0.01211186f, 0.04531554f, 
    0.25435200f, 0.08109287f, -0.08617894f, 0.09602844f, -0.00757641f, 0.01574151f, 0.05570055f, -0.04937978f, 
    0.06161701f, 0.04645604f, 0.07410920f, 0.04683347f, -0.38912085f, 0.02612948f, -0.03095148f, -0.06535977f, 
    0.09806062f, -0.09639199f, -0.08234277f, -0.08115570f, -0.03892431f, -0.00769388f, -0.00455222f, -0.02449388f, 
    0.28360343f, 0.17401558f, 0.15112223f, 0.09571979f, 0.02015281f, 0.03216486f, 0.00162034f, -0.08099800f, 
    0.20518145f, -0.03119174f, -0.15068267f, -0.04064520f, 0.10285085f, 0.28711292f, -0.00734991f, -0.08952270f, 
    -0.05917545f, -0.01035124f, 0.03025247f, 0.11774093f, 0.10275573f, -0.00538886f, 0.09075810f, -0.07368097f, 
    0.08413951f, 0.04567132f, 0.16683719f, 0.02341470f, -0.06315889f, 0.17961971f, 0.07265940f, 0.03958501f, 
    -0.10510633f, -0.03483698f, -0.04506088f, -0.01815391f, -0.02756722f, -0.31576291f, 0.26919547f, -0.07155599f, 
    -0.08992806f, -0.04343402f, -0.09086582f, 0.17656991f, -0.12238949f, -0.00863036f, -0.07700440f, 0.11906550f, 
    -0.06154713f, -0.03021386f, 0.01662422f, 0.08974705f, -0.11660646f, 0.09527341f, -0.00401353f, 0.07556944f, 
    -0.00445269f, -0.19685364f, 0.03800060f, 0.19587772f, 0.24323989f, 0.18153396f, 0.10655287f, 0.08969388f, 
    0.01475876f, 0.08480019f, -0.05575136f, 0.01442913f, -0.00369842f, 0.12375358f, 0.07291519f, -0.00915512f, 
    0.27171046f, 0.11682750f, 0.22530271f, 0.12071427f, 0.00453998f, 0.06034832f, -0.04107566f, -0.02193742f, 
    0.15416496f, 0.09244543f, 0.00958099f, 0.06581523f, 0.10887232f, -0.09709134f, 0.11308619f, -0.01260412f, 
    -0.06624520f, 0.11266200f, 0.06457657f, 0.12155861f, -0.02239138f, 0.00827317f, 0.02419955f, -0.06007890f, 
    0.00762888f, -0.08980785f, -0.09508356f, -0.19190830f, 0.08427928f, 0.06232713f, 0.13762245f, 0.12718302f, 
    -0.07494909f, 0.02416733f, -0.05209339f, 0.00286365f, -0.03714611f, 0.06536007f, -0.04327007f, 0.11641107f, 
    0.00337657f, 0.07548431f, 0.01036411f, 0.15224622f, 0.04057765f, -0.02834060f, -0.08736760f, -0.04497720f, 
    0.49964032f, -0.14340341f, 0.17531526f, -0.27098718f, 0.07931723f, -0.07581414f, 0.15460481f, 0.09590329f, 
    0.14296475f, 0.33234501f, 0.03338920f, -0.05661216f, 0.24258286f, 0.07887743f, 0.17230058f, 0.07822698f, 
    0.01724680f, 0.06552894f, -0.00306424f, -0.09612077f, 0.01143193f, 0.06631211f, -0.05995946f, -0.21550953f, 
    0.08943848f, 0.26296332f, -0.11176061f, -0.07810205f, -0.09138500f, 0.01438554f, 0.20913862f, -0.13630703f, 
    -0.03466685f, -0.00662547f, -0.01753156f, -0.03420619f, -0.10560308f, -0.03849791f, -0.02929759f, -0.13136740f, 
    0.16185685f, -0.04420124f, 0.11392298f, 0.28269157f, -0.05127997f, -0.11628661f, -0.09878030f, 0.12164148f, 
    0.00841573f, -0.00321786f, -0.00931847f, 0.03027676f, 0.01313923f, -0.01033367f, 0.02229018f, -0.03624891f, 
    -0.00384901f, -0.03701585f, 0.03033873f, 0.01500316f, -0.02798421f, 0.02073707f, -0.00521452f, -0.02228225f, 
    -0.00488295f, -0.02763999f, 0.01093074f, -0.02229185f, 0.00949236f, 0.01123269f, -0.03730530f, -0.03928516f, 
    -0.00889295f, -0.00799518f, -0.00630208f, -0.01419154f, -0.02438115f, -0.02605599f, 0.00912878f, -0.01372187f, 
    0.00403907f, 0.00281894f, -0.01902364f, -0.01173589f, -0.03533906f, -0.01350657f, -0.00845712f, 0.00479352f, 
    -0.03033371f, -0.00358336f, 0.00563661f, -0.00341860f, -0.00794521f, 0.02161560f, 0.01009676f, -0.03645200f, 
    -0.03701327f, 0.03081544f, -0.01272067f, -0.00774936f, -0.01268133f, -0.03099851f, 0.01966124f, 0.02679042f, 
    -0.02980986f, -0.00747969f, -0.01223053f, -0.00049869f, 0.01444842f, -0.00844405f, -0.01331656f, 0.03254493f, 
    -0.04011754f, 0.01645466f, -0.00970481f, -0.00325492f, 0.02482434f, -0.00867880f, -0.02960903f, -0.01251284f, 
    0.02435520f, -0.04171134f, 0.00455282f, 0.00208159f, 0.01856712f, -0.01378114f, -0.02887836f, 0.00892597f, 
    0.02020466f, -0.03707393f, 0.01970288f, -0.03591309f, -0.01428778f, 0.02926165f, -0.02580708f, -0.01371784f, 
    0.01226573f, -0.01458375f, -0.00877354f, -0.04094882f, 0.02756071f, -0.00425345f, -0.02608092f, -0.02122086f, 
    -0.00815683f, -0.03640020f, -0.01559091f, -0.04095036f, -0.00765351f, 0.02506920f, -0.02084346f, -0.02127368f, 
    0.00822657f, 0.02274872f, -0.02230107f, 0.02296749f, -0.00467231f, -0.01620947f, 0.00621637f, 0.00980894f, 
    -0.03885896f, -0.00625707f, -0.02774241f, 0.03000348f, -0.01921646f, 0.03280844f, 0.01838127f, -0.03026389f, 
    0.01563709f, 0.02830739f, 0.01092903f, 0.02286088f, 0.03117806f, -0.03537236f, -0.01126067f, -0.00147453f, 
    0.00760628f, -0.03616105f, -0.03833356f, -0.00317990f, 0.01820819f, -0.02578899f, 0.02722428f, -0.01975544f, 
    -0.03497564f, -0.02245202f, 0.00626404f, -0.00125174f, -0.00069320f, -0.01295958f, 0.01206040f, -0.03684871f, 
    0.00736304f, -0.02674891f, -0.02768756f, 0.01220783f, 0.02541916f, -0.02393786f, -0.03810276f, -0.00869069f, 
    0.02630695f, -0.02472470f, -0.02738418f, 0.00341616f, -0.01915440f, 0.03119749f, -0.01645997f, 0.02387806f, 
    -0.03318151f, 0.01767650f, -0.01284262f, 0.00370311f, -0.02915676f, -0.03729254f, -0.00149852f, -0.02886994f, 
    0.03501625f, -0.03616203f, -0.02567005f, -0.00544274f, 0.01517949f, -0.03704137f, -0.02434452f, 0.00569356f, 
    -0.04510051f, 0.01995247f, -0.03567449f, 0.00174693f, 0.02308721f, 0.00852681f, -0.02516440f, -0.00660171f, 
    0.03365818f, -0.04011758f, -0.02302143f, 0.02134913f, -0.03286099f, 0.01581434f, 0.02542429f, 0.01760517f, 
    0.00317564f, -0.01148093f, -0.03150954f, -0.01461803f, -0.02463671f, -0.01280388f, -0.01402997f, 0.01684914f, 
    -0.03720390f, 0.02325752f, 0.02375045f, -0.03112385f, -0.02156799f, -0.03443670f, 0.02129740f, 0.01102796f, 
    0.00943635f, 0.03116358f, -0.00788760f, 0.00214459f, -0.01424291f, -0.01087515f, 0.02809601f, -0.00250958f, 
    -0.03406317f, 0.01550996f, -0.01710961f, 0.00473968f, 0.00059665f, 0.02168716f, -0.03578332f, -0.01189825f, 
    -0.01200517f, -0.03830612f, 0.02972915f, -0.00608514f, 0.02425860f, 0.01618528f, -0.03663562f, -0.01541799f, 
    -0.01561673f, 0.01262583f, 0.01667118f, -0.02374015f, -0.03308494f, -0.00969664f, -0.03449905f, 0.02756950f, 
    -0.02635102f, 0.00735886f, -0.03922398f, -0.01263987f, 0.01272886f, -0.01742038f, 0.03010477f, 0.00693941f, 
    -0.01963675f, -0.00778307f, 0.01803539f, 0.03100511f, -0.04077613f, -0.02902607f, 0.00812851f, 0.02531119f, 
    -0.03792224f, -0.03430752f, -0.02458025f, 0.01429224f, 0.00634900f, 0.01429775f, -0.03376880f, -0.00600411f, 
    -0.01410935f, 0.01225734f, 0.01735334f, 0.00356315f, -0.01564659f, 0.00252888f, 0.02607553f, -0.01639918f, 
    -0.01387254f, 0.02301896f, -0.01912631f, 0.02190221f, -0.01104273f, -0.03467487f, -0.03541579f, 0.00549949f, 
    -0.02062933f, -0.01292651f, -0.03602799f, 0.02961515f, -0.02102215f, -0.01128718f, 0.00697850f, -0.01760413f, 
    -0.03491549f, 0.00379416f, 0.01519826f, 0.01946412f, -0.00854434f, 0.00411459f, 0.02062870f, 0.01650652f, 
    -0.00602040f, -0.03413399f, 0.00914270f, -0.01857755f, -0.02033741f, -0.01285315f, 0.02535607f, -0.03711338f, 
    -0.02767397f, 0.00849158f, -0.01859157f, -0.03961989f, 0.01036446f, 0.02898923f, -0.00103996f, 0.00220622f, 
    -0.03079164f, -0.00758995f, -0.03724864f, -0.04353007f, -0.01507969f, 0.02589973f, -0.00040441f, 0.01163418f, 
    0.00545123f, 0.02617708f, -0.03626424f, -0.00698222f, -0.01180378f, -0.00715568f, 0.02092262f, 0.00367229f, 
    0.00664313f, -0.00819952f, -0.02448941f, -0.02933702f, -0.02658865f, 0.02226943f, -0.01871391f, -0.00375702f, 
    0.02838698f, 0.00091033f, -0.03796789f, 0.01887153f, 0.01519349f, 0.00770535f, -0.02258096f, 0.01222592f, 
    -0.04360903f, -0.03568999f, 0.01570268f, -0.02829968f, 0.01748409f, -0.02495044f, 0.01225298f, 0.00572292f, 
    -0.00508327f, -0.02773110f, 0.00789239f, -0.01047892f, -0.03157131f, -0.02044142f, -0.00516195f, -0.00021115f, 
    -0.02829638f, -0.02186811f, -0.03503084f, 0.02500774f, -0.02494009f, -0.02222460f, -0.00903912f, -0.02709054f, 
    -0.00792692f, -0.04018124f, -0.03105627f, 0.02213541f, -0.00120320f, 0.02875915f, -0.03276021f, -0.00868039f, 
    -0.01165042f, -0.04266392f, -0.02899627f, -0.03888127f, 0.01945183f, -0.03354576f, 0.02412841f, 0.02203743f, 
    0.03452930f, -0.00005222f, 0.00128487f, -0.01010128f, -0.02762551f, 0.00309642f, 0.01428490f, -0.02312853f, 
    0.01985740f, 0.02841789f, 0.00353780f, 0.01456077f, 0.02347172f, 0.00168693f, 0.01469267f, -0.01477554f, 
    -0.01115745f, 0.01300260f, -0.02972102f, 0.02829796f, -0.03210060f, -0.02197902f, -0.03363830f, 0.02579321f, 
    -0.00135534f, -0.00767043f, -0.02461659f, 0.00411866f, 0.00014340f, -0.01462341f, -0.03792947f, 0.01069744f, 
    -0.00123822f, -0.03200541f, 0.01565860f, 0.02934264f, 0.01862814f, 0.02313837f, -0.00172014f, 0.01575017f, 
    0.00165389f, 0.00300649f, -0.01410145f, 0.00447481f, -0.01786563f, 0.02768115f, -0.02328143f, -0.02803847f, 
    0.01957570f, -0.02876240f, 0.02936548f, -0.00541860f, -0.01995640f, -0.02856546f, -0.00425462f, -0.00941872f, 
    -0.03665656f, -0.02045123f, 0.02323163f, 0.03554450f, -0.02261323f, 0.01860288f, 0.02710990f, -0.00168895f, 
    -0.01755167f, -0.00120720f, -0.02411400f, -0.03506243f, -0.03431639f, -0.00814815f, -0.01231950f, -0.03846791f, 
    -0.01396368f, 0.02791100f, 0.02359573f, -0.02899522f, -0.00940809f, -0.02386581f, -0.02593602f, -0.03728145f, 
    0.03076117f, 0.00700975f, -0.02265386f, -0.03681355f, -0.01360013f, -0.02316423f, 0.00711925f, -0.00906852f, 
    -0.02108283f, 0.03171502f, -0.01415795f, -0.00307725f, -0.03235189f, 0.02302012f, -0.04137618f, -0.04164539f, 
    -0.02398529f, -0.02764416f, -0.02468501f, 0.00252388f, 0.01919988f, 0.02077316f, -0.03315799f, -0.00426572f, 
    0.01960844f, 0.02061289f, 0.00798658f, -0.03953461f, 0.01179935f, 0.01979551f, 0.00679684f, -0.01022776f, 
    -0.01815238f, -0.01537231f, 0.02100678f, -0.03509729f, -0.00019120f, -0.03902671f, -0.01642641f, -0.03099796f, 
    -0.03206132f, 0.01830042f, -0.03884393f, -0.02235930f, 0.00772110f, -0.02555177f, -0.00761179f, 0.02796549f, 
    -0.02056892f, 0.01626015f, -0.00168287f, -0.01817014f, -0.01861326f, -0.04224024f, -0.00071960f, -0.01608024f, 
    0.01676821f, -0.02155147f, -0.01669252f, -0.03024980f, 0.02595563f, 0.01324108f, 0.01426828f, -0.01129702f, 
    0.02583595f, 0.02507474f, 0.02271490f, -0.00448947f, 0.01872859f, 0.00405949f, -0.02648562f, -0.03609590f, 
    -0.03124284f, 0.00375435f, 0.00160724f, -0.01045094f, 0.02303301f, -0.03056923f, -0.02078617f, -0.03259406f, 
    -0.02446975f, -0.04269432f, -0.00469916f, 0.01750006f, -0.02007353f, -0.02139086f, 0.00474872f, 0.00197304f, 
    0.01098802f, 0.00582157f, -0.02793339f, -0.01083679f, 0.00149974f, 0.01128560f, -0.00139683f, 0.01736856f, 
    -0.01982876f, 0.00962556f, 0.01869858f, 0.01230048f, -0.00170850f, -0.02015408f, -0.02824203f, 0.01768690f, 
    0.01102545f, 0.02199823f, -0.02380741f, -0.01764298f, 0.00537067f, 0.00589407f, -0.00591579f, -0.00102431f, 
    0.01766722f, 0.01920297f, -0.03173757f, -0.00465779f, -0.01911658f, 0.02266926f, -0.02735342f, 0.02950767f, 
    -0.00370775f, -0.01108283f, 0.02170848f, -0.02199840f, -0.01390669f, 0.01780648f, -0.00222933f, 0.03222153f, 
    -0.00327211f, -0.03282804f, -0.02233654f, 0.00009550f, -0.00579698f, 0.00371774f, -0.03844639f, -0.01732411f, 
    0.02741958f, 0.02970616f, 0.00883405f, 0.00461676f, -0.02744704f, 0.00057585f, -0.04071974f, -0.03101924f, 
    0.01676295f, -0.01012660f, -0.01072692f, -0.03593908f, -0.00381382f, 0.00591086f, 0.02938287f, 0.02155231f, 
    -0.00401460f, -0.01156903f, -0.01335339f, -0.03500738f, 0.01895739f, -0.03234505f, 0.00792394f, -0.01541669f, 
    -0.00362672f, 0.01179067f, 0.00594913f, 0.00258316f, -0.01944643f, 0.02879706f, 0.01119881f, -0.01969492f, 
    -0.03583437f, -0.01154716f, -0.02616034f, -0.02172076f, -0.00360653f, -0.03748023f, 0.00140149f, 0.00861570f, 
    0.00427667f, 0.03374680f, 0.02935333f, 0.02685745f, -0.02816971f, -0.03852955f, -0.01865065f, -0.00011004f, 
    -0.02456990f, -0.00243148f, -0.01386240f, -0.03335870f, 0.01493069f, -0.00338791f, 0.02401528f, 0.02375015f, 
    -0.02898808f, 0.02499793f, -0.03629092f, 0.00687201f, 0.02971620f, 0.01317374f, 0.01827226f, 0.01797803f, 
    0.00501304f, -0.01886618f, -0.01578982f, 0.03257702f, -0.01517939f, 0.02716997f, -0.03783280f, -0.01801561f, 
    0.01993904f, -0.02008662f, -0.01455822f, -0.03240433f, 0.02698153f, 0.02008705f, -0.00813783f, -0.02587193f, 
    -0.03735452f, -0.03652415f, -0.00744170f, -0.02219815f, 0.00757188f, -0.02621510f, 0.01001321f, 0.00442823f, 
    0.02216729f, 0.01589758f, -0.03498291f, 0.01266171f, -0.03793246f, 0.01819152f, -0.00272643f, 0.00349752f, 
    0.00832620f, 0.03079123f, -0.01963008f, 0.03439263f, 0.01327512f, 0.02660177f, -0.02965854f, 0.00146065f, 
    -0.01329886f, -0.04099841f, 0.02391573f, -0.02386414f, -0.02519275f, 0.00395611f, -0.01991369f, -0.01613226f, 
    -0.03893271f, -0.03571827f, 0.01763546f, 0.02512253f, -0.03306411f, 0.00198949f, -0.03922832f, 0.01427456f, 
    -0.00930146f, 0.00674930f, -0.01419560f, -0.03645407f, -0.00599973f, 0.01612958f, 0.01335061f, -0.02249375f, 
    0.02974129f, 0.02714788f, 0.01644458f, -0.02263270f, -0.00450280f, -0.02770816f, -0.01754650f, -0.02628955f, 
    -0.02954311f, -0.03826188f, -0.03483790f, 0.00086315f, 0.01365677f, -0.04171496f, -0.04023746f, -0.01601819f, 
    -0.00381186f, -0.00931265f, -0.03671800f, -0.02345981f, 0.02151764f, -0.02506476f, -0.04032041f, -0.00579124f, 
    -0.03180750f, 0.00457763f, 0.00274210f, 0.00853034f, -0.03179434f, 0.02979848f, -0.00997316f, 0.02803674f, 
    0.02274513f, -0.00911867f, 0.02934390f, -0.02863099f, -0.00559017f, -0.02981487f, -0.00016685f, -0.00919970f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03091137f, -0.01387936f, 0.10266653f, 0.02077471f, 0.08749916f, 0.06331619f, 0.01388199f, 0.09241887f, 
    0.03745626f, 0.13133074f, -0.00943857f, -0.03594907f, 0.10347143f, -0.09804355f, 0.03385017f, 0.16049221f, 
    0.13780037f, 0.12386560f, 0.02771396f, -0.01419484f, -0.00210240f, 0.07413174f, 0.10161424f, 0.01103936f, 
    0.01528491f, -0.00122825f, -0.03369652f, 0.08685269f, 0.02523377f, 0.00894391f, 0.09463103f, -0.02045595f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.16157314f, -0.14797872f, -0.02676313f, 0.14199439f, 0.17614007f, -0.10728524f, 0.06127122f, -0.37228337f, 
    -0.50909185f, -0.00926117f, 0.00753040f, -0.13263468f, 0.00483508f, 0.21311401f, 0.04280058f, -0.46308279f, 
    -0.31394580f, -0.27647024f, 0.09746475f, -0.15768972f, 0.07095775f, -0.02590555f, -0.31170973f, 0.13966446f, 
    0.23835590f, 0.16821352f, -0.00096535f, -0.79886073f, -0.07500762f, -0.17242736f, -0.33602646f, -0.05674750f, 
    -0.00761849f, 0.13833877f, 0.11978685f, 0.10762665f, 0.21304458f, -0.04438500f, 0.11754038f, 0.11050081f, 
    -0.39077401f, 0.45581707f, -0.14127487f, 0.14728349f, -0.03542132f, -0.75136471f, -0.40235674f, 0.25774959f, 
    0.19316380f, -0.00620493f, -0.05177795f, -0.05693757f, -0.08501523f, -0.08673277f, -0.21539010f, 0.02984233f, 
    0.12698092f, 0.12111556f, 0.04674007f, -0.08874035f, 0.08589156f, -0.12251285f, 0.12418107f, -0.05579710f, 
    -0.14814523f, 0.14023210f, 0.07193879f, -0.14061217f, 0.03241888f, -0.38197833f, 0.16276163f, -0.17311819f, 
    0.16830389f, -0.52496529f, -0.42479524f, 0.12348020f, 0.11555477f, -0.26312920f, -0.27183038f, -0.15068990f, 
    0.19205403f, 0.29774588f, -0.07482502f, -0.04402465f, 0.04026679f, -0.21073419f, 0.07669084f, -0.01104007f, 
    0.09026402f, -0.15145051f, 0.02295132f, 0.39994341f, 0.01093765f, -0.07859325f, -0.25754079f, -0.11634263f, 
    0.12857012f, 0.08573081f, -0.80442762f, 0.00556634f, -0.04945088f, -0.50862920f, -0.11649362f, -0.08468426f, 
    0.26299295f, -0.47976866f, 0.22929439f, -0.06447073f, -0.06418122f, 0.26735026f, -0.49820191f, 0.18304364f, 
    -0.47231331f, -0.05158292f, -0.01478101f, -0.08340755f, 0.02422234f, -0.23165613f, -0.20684539f, 0.07533298f, 
    0.11644508f, -0.03012014f, 0.16528173f, 0.11031871f, 0.11028541f, 0.13825612f, -0.28924602f, 0.14698595f, 
    0.04405859f, -0.12706631f, 0.17519520f, -0.02748964f, 0.08496796f, 0.27090901f, 0.04795481f, 0.03896368f, 
    0.35527992f, 0.07579964f, -0.35177824f, 0.00919948f, -0.34727696f, 0.34229761f, -0.30613950f, -0.43483061f, 
    0.10556565f, -0.41242966f, 0.16756240f, 0.03773231f, -0.17986847f, 0.02309023f, -0.26085159f, 0.05569982f, 
    0.03576864f, -0.00181105f, -0.12921160f, -0.01873608f, -0.16563746f, -0.00401684f, 0.04151401f, 0.14987868f, 
    -0.05116639f, 0.14669256f, 0.05453150f, -0.15119208f, 0.15207040f, 0.51085860f, 0.04472411f, 0.32497090f, 
    0.09535018f, -0.09175782f, -0.01882559f, 0.06900027f, -0.16130348f, -0.44523829f, 0.47055840f, -0.30736312f, 
    -0.42187253f, -0.11328899f, -0.09729923f, 0.08764358f, 0.14634828f, -0.20489924f, 0.18923907f, 0.02342176f, 
    0.03159803f, -0.16290072f, -0.11504763f, -0.41911107f, 0.00678694f, -0.07391752f, -0.22061801f, 0.09464417f, 
    0.11122674f, -0.08379450f, 0.26603407f, 0.05710298f, -0.03409189f, -0.79261386f, 0.10339802f, -0.00344402f, 
    0.10427357f, -0.29566959f, -0.19348226f, -0.11277881f, 0.12669501f, 0.19000380f, 0.39110830f, 0.00030306f, 
    0.37350655f, -0.22076976f, -0.09923331f, -0.00161434f, 0.01931095f, 0.14533652f, 0.09278423f, -0.13706802f, 
    -0.54893452f, 0.12697238f, 0.09310032f, 0.15403897f, -0.09646686f, 0.15703109f, 0.08618554f, -0.15917179f, 
    0.02802663f, 0.16216607f, -0.07906240f, -0.13936333f, -0.54922897f, 0.12956616f, -0.09196790f, -0.06903283f, 
    0.10376555f, -0.34756401f, 0.07881963f, -0.14765108f, 0.16824497f, -0.11000542f, -0.08611223f, -0.34958354f, 
    -0.25732517f, 0.22033229f, 0.17030361f, 0.14164430f, 0.07892227f, 0.13839065f, -0.39131707f, -0.15691143f, 
    -0.10539428f, -0.15265554f, -0.01790282f, 0.22134656f, 0.05229924f, 0.10867431f, 0.29483691f, 0.05756253f, 
    -0.07785122f, -0.13854598f, -0.47410479f, -0.06665476f, -0.47592133f, -0.10783607f, -0.15455706f, 0.24220547f, 
    -0.32369965f, 0.19914758f, 0.12874818f, -0.13793017f, 0.35818064f, -0.28287947f, -0.07696705f, -0.15032445f, 
    -0.41739374f, 0.04652079f, -0.03787600f, -0.03572746f, 0.13063768f, 0.30651462f, 0.32199159f, 0.04849680f, 
    0.02549140f, -0.02399064f, 0.06326713f, -0.27355522f, 0.07106847f, 0.11974189f, -0.35080305f, 0.00992110f, 
    0.00222864f, -0.06111234f, 0.18330818f, -0.00923113f, 0.42461544f, 0.35800153f, -0.05432278f, -0.54974955f, 
    0.15249255f, 0.15117536f, -0.12342588f, -0.06698484f, 0.06130475f, -0.00397526f, 0.11109019f, -0.34574407f, 
    0.10518759f, -0.03596278f, -0.00261831f, -0.15104796f, 0.03037435f, -0.52242810f, -0.49118865f, 0.13407354f, 
    -0.43757892f, 0.07107637f, -0.09736235f, 0.23342228f, 0.08258824f, 0.10267255f, 0.12338174f, -0.13941947f, 
    0.11012352f, -0.16094185f, -0.23952134f, -0.01881507f, -0.27992895f, 0.34556517f, -0.16107015f, -0.24394049f, 
    -0.02429699f, -0.64307916f, 0.14602870f, -0.01619817f, -0.09666946f, -0.06329545f, -0.48610204f, 0.36161765f, 
    0.36314994f, -0.20968838f, -0.15786146f, -0.08540127f, -0.06051329f, -0.22996403f, 0.44834641f, 0.01171333f, 
    -0.04706771f, -0.15609640f, -0.14142409f, -0.31646356f, -0.05274610f, 0.13868494f, 0.03136803f, 0.09540051f, 
    0.00036569f, -0.04637759f, 0.00376654f, -0.09307248f, -0.44787756f, -0.25786340f, 0.05426062f, -0.19220549f, 
    0.25577444f, 0.38388681f, -0.22961318f, -0.15722494f, -0.35427895f, 0.22063257f, 0.24471807f, 0.39916292f, 
    -0.43330503f, -0.14747593f, -0.15895620f, 0.16283952f, -0.05611795f, -0.02572599f, 0.33262762f, -0.07659534f, 
    -0.01837444f, -0.11820472f, 0.06470601f, 0.20284705f, -0.01029630f, -0.00219702f, -0.28613707f, 0.05838564f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.20553814f, 0.04126244f, -0.00450262f, -0.01172010f, -0.14593245f, 0.16367072f, -0.03424949f, -0.03442831f, 
    0.14068647f, 0.00733324f, -0.05409459f, -0.16445096f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
