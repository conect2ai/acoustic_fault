#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.00741148f, 0.73042244f, -0.69154710f, -0.59797907f, 0.37344635f, 0.26055083f, -0.17849159f, 0.66148174f, 
    -0.19478406f, 0.02655049f, 1.35316193f, -0.87235612f, -0.09008008f, -0.07745102f, 0.14998297f, -0.15324736f, 
    0.31155279f, 0.29684538f, -0.64186621f, 0.37917221f, 0.33957505f, 0.21117643f, 0.61494094f, 0.23710684f, 
    -0.48499331f, -0.55674469f, -0.74851799f, 0.42445651f, -0.06296408f, -0.03906382f, -0.68032449f, -0.07727291f, 
    -0.15349722f, 0.46229848f, 0.43885612f, 0.59404343f, 0.43787795f, -0.53561425f, 0.39305818f, -0.58928323f, 
    -0.73391593f, -0.89545792f, -0.13107400f, 0.59624648f, -0.35468289f, 0.24672681f, -0.74183917f, 0.01399922f, 
    -0.40840018f, -0.66112071f, -0.44237503f, -0.11562685f, -0.49780896f, -0.11403686f, -1.28030181f, -0.36172006f, 
    0.33191767f, -0.47312766f, -0.56492758f, -0.07377001f, 0.31154764f, 0.40530616f, 0.27609542f, -0.87115872f, 
    0.75366265f, -0.32691363f, -0.85598350f, 0.10177372f, -0.27114639f, 0.51983196f, -0.61304247f, -0.08336335f, 
    -0.19910371f, 0.20968369f, 0.77471083f, -0.65859658f, -0.65203470f, 0.76439995f, 0.03000160f, 0.03435908f, 
    0.15287928f, -0.32190192f, 0.04017298f, -0.22164162f, 0.87339365f, -0.54227680f, -0.11465544f, -0.55399686f, 
    -0.56855530f, -0.07028165f, -0.44659668f, -0.98479617f, -0.78334528f, 0.75755048f, 0.76711208f, 0.17500497f, 
    -0.29441905f, -0.04917431f, -0.39759648f, 0.68981570f, 0.29079187f, 0.23468797f, 0.41451451f, 0.21800883f, 
    0.36133701f, -0.02635575f, -0.25660789f, -0.44313821f, -0.18007219f, -0.06008356f, 0.47389624f, -0.02958961f, 
    0.17553608f, -0.32163072f, 0.37964135f, 0.60944915f, 0.53925055f, -0.81164944f, -0.70296437f, -0.40127075f, 
    -0.24755506f, -0.25029275f, -0.67899919f, 0.11060870f, -0.36144716f, -0.19284573f, 0.78906715f, -0.21417607f, 
    0.65556353f, 0.45026225f, 0.17887853f, 0.36218357f, 0.13062233f, 0.32853737f, -0.05733890f, -1.17066920f, 
    0.62687749f, -0.11853003f, 0.53588814f, 0.28282359f, -0.44831228f, 0.10751581f, -0.14655343f, -0.28125891f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.40759781f, 0.33961117f, -0.28382745f, 0.34913838f, 0.38874972f, -0.41087925f, 0.32453677f, -0.42762104f, 
    0.19059718f, 0.24174662f, 0.42816052f, -0.26589707f, 0.05408393f, -0.15469743f, 0.60138428f, 0.49135590f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.56987119f, -0.05721337f, -0.16675791f, 0.25704226f, 0.00886500f, -0.15476610f, 0.18169276f, 0.13098162f, 
    -0.03013925f, -0.33296880f, 0.21153712f, -0.37836468f, 0.13209184f, 0.03329853f, 0.21911152f, -0.02237183f, 
    0.00354552f, -0.09626830f, -0.04775755f, 0.11165435f, 0.14447248f, -0.26697394f, -0.18358767f, -0.08385149f, 
    0.00313054f, -0.01361182f, 0.13437259f, 0.21752667f, 0.14618972f, 0.03925380f, 0.25971437f, -0.02165595f, 
    0.21453173f, -0.02502470f, 0.00025360f, 0.01704531f, 0.23717628f, -0.35450834f, -0.61193317f, 0.03944510f, 
    0.11532138f, 0.22443901f, -0.05851597f, 0.00023605f, -0.04494062f, 0.36556396f, -0.24096276f, -0.28490657f, 
    -0.19751866f, -0.45392078f, -0.12567054f, 0.18013574f, 0.13811062f, 0.05027549f, -0.50710762f, 0.03332429f, 
    0.18424430f, -0.22025357f, -0.26811990f, -0.02911363f, 0.02106447f, -0.03807862f, -0.00151630f, -0.19739892f, 
    -0.09006523f, -0.58976644f, 0.22521591f, -0.21599552f, -0.05290927f, -0.09097958f, 0.01325761f, 0.12752484f, 
    -0.44069731f, -0.03559499f, -0.29068646f, -0.05156175f, -0.00378763f, 0.22576070f, 0.09722670f, 0.06301388f, 
    -0.05511270f, 0.17276092f, -0.10692770f, -0.50471014f, -0.10474596f, 0.10825965f, 0.08700303f, 0.17136870f, 
    -0.06104873f, 0.05318084f, 0.39761895f, 0.00807057f, 0.28149465f, -0.17087820f, 0.00423494f, -0.39758956f, 
    0.10230134f, 0.08962043f, 0.06546231f, 0.06267064f, -0.07630139f, 0.05152603f, -0.01492330f, -0.16332084f, 
    0.03749657f, -0.03872969f, -0.01800776f, 0.06373570f, 0.20127933f, -0.20488051f, -0.00788141f, -0.13958944f, 
    0.05932472f, -0.03018336f, 0.20176217f, 0.01875473f, -0.04750667f, -0.05272705f, -0.26459944f, 0.27312887f, 
    0.07934245f, -0.32630065f, -0.05174585f, 0.05114865f, 0.09650537f, 0.15704972f, 0.24853086f, -0.03440141f, 
    0.06328896f, 0.22131141f, 0.16181649f, 0.07616425f, 0.04956055f, 0.03520340f, 0.01012556f, -0.21257946f, 
    -0.08436262f, 0.03544091f, -0.15482430f, 0.26663721f, 0.04563880f, 0.18335032f, -0.10510688f, -0.00588502f, 
    -0.09309365f, -0.06558263f, 0.02519632f, -0.10294474f, 0.00963978f, 0.01237170f, -0.02162111f, -0.04849167f, 
    -0.01816298f, 0.20213200f, 0.02979378f, -0.07594514f, 0.01060599f, -0.01415901f, 0.05606843f, 0.18591784f, 
    -0.06901206f, 0.03239079f, 0.16284247f, 0.34001261f, -0.14691199f, 0.15885673f, 0.10592754f, 0.06458906f, 
    -0.06454317f, 0.05596766f, -0.11392897f, 0.01962347f, 0.04195052f, 0.08500762f, 0.08466242f, 0.07560342f, 
    -0.16551612f, 0.01072059f, -0.26176175f, -0.58107483f, 0.12071847f, -0.11262242f, 0.02979988f, 0.11358743f, 
    0.09040463f, -0.13876441f, 0.14988795f, -0.17177334f, 0.22629745f, 0.26616693f, 0.06493826f, 0.21789296f, 
    0.07635935f, -0.16527383f, -0.26750517f, -0.13301377f, -0.06494358f, 0.06321436f, -0.00243635f, -0.04070185f, 
    -0.06055290f, 0.21746910f, -0.02857439f, -0.31313762f, 0.09954099f, -0.00678902f, -0.14342946f, -0.03993763f, 
    0.03670833f, 0.21207939f, -0.39723983f, -0.11558821f, 0.12363829f, -0.01042633f, -0.04762947f, 0.13471758f, 
    -0.05058251f, 0.19507667f, -0.12732042f, -0.17313223f, 0.01972271f, 0.01502198f, -0.10673930f, 0.17302687f, 
    0.01347986f, 0.06324811f, -0.06317227f, 0.22191098f, 0.11659270f, -0.09304664f, -0.22964942f, 0.20052037f, 
    0.03804930f, 0.21484417f, 0.07072476f, 0.09950255f, -0.07330276f, -0.07124779f, 0.06895601f, -0.16993083f, 
    0.04334022f, 0.11325877f, 0.26484114f, -0.17287475f, 0.16252837f, -0.26338154f, 0.13592429f, 0.10127514f, 
    0.16754915f, 0.03002427f, 0.25336772f, -0.11585119f, -0.03904851f, 0.03818911f, 0.03568741f, 0.01859883f, 
    0.18700913f, -0.05196233f, -0.07125519f, -0.36190605f, -0.22622819f, -0.12154146f, -0.15034200f, -0.32941452f, 
    -0.13389307f, 0.22036621f, 0.10522033f, -0.06019847f, 0.01889704f, 0.07193844f, 0.04502441f, -0.05520793f, 
    -0.03012386f, 0.17360836f, 0.02609426f, 0.27717674f, -0.00023811f, 0.03222857f, 0.10450320f, 0.05854058f, 
    -0.01277798f, -0.13265468f, -0.01318683f, -0.05626915f, 0.22062503f, 0.04027080f, -0.24853991f, 0.08143932f, 
    -0.00016928f, -0.08166457f, -0.02855079f, 0.07307325f, -0.03343233f, 0.00404682f, -0.00212202f, -0.07681112f, 
    0.06091652f, -0.06048451f, 0.03609475f, 0.04245760f, -0.03643966f, -0.03866730f, 0.06973390f, 0.02563810f, 
    -0.05725845f, -0.03242014f, 0.05311695f, 0.03521654f, 0.01676324f, -0.07465529f, -0.00064656f, -0.07731224f, 
    -0.01900900f, 0.05507909f, -0.00522540f, -0.02549927f, -0.08629248f, -0.01391145f, -0.03705506f, -0.06183020f, 
    0.03594666f, -0.07499576f, -0.05131591f, -0.07142365f, -0.07604218f, 0.02049460f, 0.02811431f, 0.06874766f, 
    0.01760354f, -0.03349458f, 0.04017863f, -0.08370227f, -0.05252033f, 0.00685164f, -0.04228786f, -0.01149367f, 
    -0.02451825f, -0.01048584f, 0.01904144f, 0.04617628f, 0.06099740f, 0.03775546f, -0.04909152f, 0.02706004f, 
    0.02233555f, 0.03777177f, -0.06417848f, -0.06253412f, 0.00058370f, -0.07361405f, -0.03168073f, -0.07546367f, 
    -0.06885475f, -0.05399184f, 0.00655258f, -0.01906234f, -0.06982455f, -0.05508119f, 0.04441810f, -0.07432628f, 
    -0.06125260f, -0.06036950f, -0.00587409f, 0.03758550f, -0.01889070f, -0.07465223f, -0.00166085f, -0.00259701f, 
    0.05310234f, -0.08495029f, -0.07439749f, -0.03876647f, -0.01085864f, 0.01242688f, -0.04162904f, -0.06907757f, 
    -0.03381506f, -0.07303569f, 0.04176096f, 0.03386954f, -0.01631453f, 0.03915725f, -0.08441356f, 0.03062730f, 
    -0.01745444f, -0.07958625f, 0.02157434f, 0.00176416f, 0.03602451f, 0.03137978f, 0.00858668f, 0.01376565f, 
    -0.05392698f, -0.00120026f, -0.00594494f, -0.07575455f, 0.02941577f, 0.02306787f, 0.05245024f, 0.05068521f, 
    -0.08570575f, -0.04932635f, -0.08194485f, -0.04949165f, -0.01812146f, 0.03419993f, -0.01526594f, -0.02874440f, 
    -0.01114870f, -0.02946026f, 0.00993253f, 0.05261326f, -0.02192381f, -0.02671211f, 0.05791292f, -0.04465927f, 
    0.02486597f, -0.04292082f, -0.03935964f, 0.02636732f, 0.05383201f, -0.08899984f, -0.07926692f, 0.00449505f, 
    0.00238315f, -0.03338316f, 0.05000934f, -0.03009580f, -0.01421460f, 0.05742737f, -0.07477904f, 0.06082239f, 
    -0.02964095f, 0.00508141f, 0.22990458f, 0.20135365f, 0.01926134f, 0.02955914f, -0.02442641f, 0.13058011f, 
    0.08638868f, 0.28298005f, -0.29391769f, -0.36554486f, 0.13371357f, -0.08696390f, 0.00884667f, 0.25487205f, 
    -0.03094117f, -0.22594504f, -0.01721301f, 0.05106997f, -0.19569740f, -0.26664546f, -0.12840213f, -0.06623396f, 
    -0.19218653f, 0.00933238f, 0.19334784f, 0.25363114f, -0.11180969f, -0.45389768f, -0.04553419f, 0.01151969f, 
    -0.11760607f, -0.09138324f, -0.06874745f, -0.18328625f, -0.05834026f, -0.43036324f, -0.35177615f, 0.27113751f, 
    0.14227271f, -0.29260811f, 0.10609295f, -0.05634595f, -0.05874383f, -0.07479961f, -0.26608089f, -0.05180823f, 
    -0.11405585f, -0.11655241f, -0.19646423f, 0.14843430f, 0.12940225f, -0.03057508f, -0.25374863f, -0.12149674f, 
    0.10122638f, 0.12176336f, 0.22663213f, -0.03953599f, 0.18600723f, 0.06818339f, 0.01471096f, 0.02972173f, 
    -0.55102086f, -0.35889727f, -0.12206509f, -0.12166721f, -0.11465529f, -0.08586434f, -0.15099269f, 0.11929550f, 
    0.37073982f, -0.09253767f, 0.00064445f, 0.02270279f, 0.11448763f, -0.04670438f, 0.03411547f, 0.05209282f, 
    0.09463419f, -0.04077471f, 0.07173322f, 0.09148517f, -0.17530353f, -0.13487504f, -0.10001314f, 0.26218101f, 
    0.23658447f, 0.17090499f, -0.36308470f, 0.00108577f, 0.61687261f, -0.18794186f, 0.13404950f, 0.12244969f, 
    0.11459464f, 0.02071410f, 0.20899992f, -0.27259830f, 0.30300137f, -0.22732361f, 0.15309715f, -0.08557279f, 
    -0.23392013f, -0.21773335f, 0.00772293f, 0.06500563f, -0.25746700f, -0.27213347f, -0.06903848f, -0.32284147f, 
    -0.09244292f, 0.04021460f, 0.07544736f, -0.10978277f, -0.01599935f, 0.05597616f, -0.22908928f, 0.05264710f, 
    -0.21812369f, -0.00222141f, 0.02698629f, 0.00431472f, -0.14249262f, 0.10428326f, 0.10065363f, 0.18195438f, 
    -0.18092979f, 0.10974526f, 0.18960112f, 0.09175542f, 0.07810814f, -0.00405269f, -0.08714504f, -0.09436524f, 
    -0.14027086f, 0.04544547f, -0.17868388f, 0.22059929f, 0.22195847f, 0.01420517f, 0.12156457f, 0.04061554f, 
    0.01537813f, -0.00939779f, -0.07848863f, 0.00373858f, 0.00128791f, 0.03008499f, 0.03916809f, 0.02988164f, 
    -0.02731284f, -0.02195863f, -0.07646923f, -0.04909775f, -0.03342078f, -0.01436942f, -0.00626885f, -0.03826758f, 
    -0.05874158f, 0.04003511f, -0.06694423f, 0.02357016f, -0.07464691f, -0.02149140f, -0.07928587f, 0.05311320f, 
    0.06686204f, -0.02956024f, -0.01106558f, 0.05780588f, 0.03358705f, 0.05124508f, -0.06742132f, 0.04496910f, 
    0.02033709f, 0.07091279f, -0.05136221f, 0.00825120f, 0.06866134f, -0.03535824f, -0.06432133f, -0.02296511f, 
    0.03479967f, 0.05342527f, -0.07763562f, -0.05076913f, -0.04245175f, 0.05661643f, -0.06640808f, -0.05763027f, 
    -0.02215538f, -0.07962608f, 0.04068514f, 0.00543263f, 0.02505003f, -0.07819021f, 0.02730726f, 0.00823153f, 
    -0.06751127f, -0.05250950f, -0.08781464f, -0.08570850f, -0.02907668f, -0.08415690f, -0.03113331f, -0.06998018f, 
    0.05271627f, 0.03881613f, -0.03488911f, 0.05635515f, -0.03720336f, 0.01863622f, -0.03285596f, 0.04439936f, 
    -0.06967194f, 0.03204308f, 0.01993435f, -0.05654447f, 0.06779990f, -0.04348002f, -0.07173620f, -0.02788530f, 
    -0.01697680f, -0.01034520f, -0.02788894f, 0.03397717f, -0.05688516f, 0.05451469f, 0.04128507f, 0.00821582f, 
    0.02882157f, 0.01237539f, 0.02534519f, -0.08464488f, -0.04400495f, 0.04376808f, 0.03988872f, 0.05526705f, 
    -0.02966471f, -0.00732747f, -0.06990591f, -0.02396508f, 0.02700395f, -0.02085178f, 0.01541155f, 0.04922306f, 
    0.01419009f, 0.02556664f, -0.06259041f, 0.01305183f, 0.00727301f, -0.05855341f, -0.02566737f, -0.07720032f, 
    0.01343772f, -0.08424721f, 0.01574208f, 0.04268554f, -0.01502051f, -0.06656661f, -0.01426366f, -0.01085174f, 
    0.02778760f, -0.08536511f, -0.04099040f, -0.01208025f, 0.05516699f, -0.03039524f, -0.01267720f, 0.03448683f, 
    0.03270827f, 0.03068891f, -0.04220763f, -0.08748093f, -0.07538038f, 0.04562922f, 0.02154411f, 0.01789108f, 
    0.01143344f, 0.01279648f, 0.02777471f, -0.03277542f, -0.00847530f, -0.02617961f, -0.00347170f, -0.02283426f, 
    0.51595271f, -0.25745746f, -0.03360498f, 0.06079545f, 0.06987798f, 0.06905324f, -0.03284097f, -0.28809318f, 
    0.05187852f, -0.06032971f, -0.18722853f, 0.24137186f, 0.03828419f, -0.12296390f, -0.06190915f, 0.00451691f, 
    0.28312084f, 0.04456097f, 0.39541808f, 0.02672008f, -0.25948292f, -0.30604437f, -0.01023265f, 0.22105651f, 
    -0.08564660f, -0.06532436f, 0.02303388f, -0.01010389f, -0.06607725f, -0.03552084f, 0.04750275f, -0.05324654f, 
    -0.06998106f, -0.06252218f, 0.05061114f, 0.03658147f, 0.23749684f, 0.13756676f, 0.38824022f, -0.01296280f, 
    -0.12949109f, -0.06892475f, 0.08930544f, 0.09740172f, -0.06412927f, -0.20181580f, 0.02512621f, 0.38186377f, 
    -0.10617874f, -0.00562502f, -0.16741177f, 0.08694241f, 0.18851477f, -0.02679660f, 0.11436060f, 0.02015135f, 
    -0.06965844f, 0.28046605f, -0.06219130f, -0.13351175f, 0.25849286f, 0.01830316f, 0.06803095f, 0.24980560f, 
    0.11276785f, 0.08158538f, 0.10670331f, -0.21198998f, -0.06565183f, -0.22534472f, 0.03169531f, 0.05503992f, 
    0.32494229f, 0.16598780f, -0.24683210f, -0.11501669f, -0.05938377f, -0.10551625f, 0.10278688f, 0.04564653f, 
    -0.18048064f, 0.12810473f, -0.03160301f, 0.21460243f, 0.06846385f, 0.00344287f, -0.01407154f, 0.07939962f, 
    0.24368885f, 0.06320237f, -0.12722464f, -0.10626722f, -0.06311572f, 0.07677949f, 0.07634940f, 0.33595279f, 
    -0.18065955f, 0.01441269f, 0.20603819f, -0.11353362f, 0.12096842f, 0.02418186f, -0.04946458f, -0.21145652f, 
    -0.05116644f, 0.11770876f, 0.03845552f, 0.03006586f, -0.13398227f, -0.08949562f, -0.39095065f, -0.17984046f, 
    -0.10487235f, 0.05750685f, 0.07614281f, -0.04579921f, -0.05817679f, -0.03814786f, 0.06842296f, 0.16963179f, 
    0.19534591f, 0.02287360f, 0.01704539f, -0.00775715f, 0.04249271f, -0.20507394f, 0.09917705f, 0.25188813f, 
    -0.03937254f, -0.07807530f, -0.03385394f, 0.05660091f, 0.18319908f, 0.02538871f, 0.04725853f, 0.23525995f, 
    0.17050467f, -0.27947479f, 0.03489060f, 0.14238921f, 0.00975249f, 0.20274797f, -0.05270305f, 0.32748964f, 
    -0.00270111f, 0.49402282f, -0.12271886f, -0.11548105f, 0.13415891f, 0.24927168f, 0.13980447f, 0.27115452f, 
    -0.08679788f, -0.16842103f, 0.25616065f, -0.14318469f, -0.00482073f, 0.22943814f, -0.04286732f, -0.02349412f, 
    -0.07526671f, -0.14880641f, -0.21598399f, -0.02226544f, -0.47783825f, -0.12014888f, -0.01251621f, -0.00370512f, 
    0.03028958f, -0.03928189f, 0.06758823f, 0.05226329f, -0.01752886f, 0.09514397f, 0.01245370f, -0.12119656f, 
    -0.00381011f, -0.15501088f, -0.05390092f, -0.05190943f, -0.04611535f, 0.47136885f, 0.35374230f, 0.19725522f, 
    0.18537731f, 0.20385578f, 0.14669718f, -0.09400564f, -0.28498587f, 0.10234093f, 0.23387739f, -0.00782360f, 
    0.06893525f, -0.21729501f, 0.09934854f, 0.10592178f, -0.11474842f, 0.02757716f, 0.14013387f, 0.19143514f, 
    0.16507100f, 0.13611373f, 0.05802239f, -0.08945186f, 0.07529203f, 0.00119915f, 0.13468315f, 0.08169589f, 
    -0.41716480f, 0.52947849f, 0.05407654f, -0.04603928f, 0.12459193f, -0.05302063f, -0.14871320f, 0.07193807f, 
    -0.67401540f, 0.06346237f, -0.45705095f, -0.19242388f, -0.15211132f, -0.07085847f, -0.16220088f, 0.07161107f, 
    0.06093935f, -0.29478347f, -0.16482240f, 0.28704596f, 0.01696295f, 0.14583598f, -0.08471835f, 0.11715931f, 
    0.09418038f, 0.12395453f, -0.29474130f, 0.01971000f, 0.36525163f, -0.02215052f, -0.11999945f, -0.12895404f, 
    0.11075093f, 0.11225829f, 0.23054250f, 0.07886389f, 0.23702481f, 0.10649376f, -0.03846611f, -0.20141122f, 
    -0.06813831f, 0.01199666f, 0.02712579f, -0.19924754f, 0.09997921f, -0.09688644f, -0.29714036f, -0.01401892f, 
    0.00908634f, -0.20793749f, -0.06569674f, -0.21125378f, 0.01027918f, -0.06866580f, 0.01138056f, 0.32525000f, 
    -0.02928406f, -0.33986959f, -0.28931910f, 0.16834562f, -0.00672247f, 0.03310294f, -0.10259905f, -0.03400250f, 
    0.21790178f, -0.12410463f, -0.00436562f, 0.19249861f, -0.04969671f, 0.20363426f, -0.05938945f, -0.31559274f, 
    -0.21582682f, -0.00137633f, -0.43453845f, 0.12405418f, -0.09599681f, -0.02153026f, 0.00263604f, 0.00764097f, 
    0.23130064f, 0.32213262f, 0.49863714f, 0.09551400f, -0.22478786f, -0.02733035f, -0.00758032f, -0.03742170f, 
    0.08045100f, 0.34822932f, 0.07810791f, 0.11633433f, 0.08872174f, -0.07391986f, 0.13628970f, 0.04254482f, 
    0.16106977f, -0.03250003f, 0.08266519f, -0.33084339f, -0.20392926f, -0.12901959f, -0.00395439f, -0.11977718f, 
    -0.11065697f, 0.00701017f, -0.48268729f, -0.10680028f, -0.13634209f, -0.18059146f, -0.08354968f, 0.19452061f, 
    -0.03303840f, 0.26809609f, 0.26978880f, 0.29614979f, -0.20726244f, -0.19923803f, -0.14245476f, 0.29886463f, 
    -0.07506485f, 0.04124955f, 0.13005187f, 0.17325625f, 0.04899365f, -0.09114482f, 0.03062454f, -0.10250545f, 
    0.14228973f, 0.24227454f, -0.13191223f, 0.05823413f, 0.12785554f, -0.19300677f, 0.08106183f, -0.04714151f, 
    0.02653051f, -0.23033853f, 0.06524766f, -0.04880606f, -0.15193512f, -0.05857585f, 0.02663407f, -0.26637018f, 
    -0.16580658f, -0.45931610f, 0.08476109f, -0.10221898f, 0.18368888f, 0.09428025f, 0.17653017f, 0.00066801f, 
    -0.20839441f, -0.48843497f, 0.17818239f, 0.13817500f, 0.22618321f, -0.04286576f, -0.15250342f, -0.06451961f, 
    0.03045749f, -0.00090587f, 0.08649092f, -0.03268656f, 0.15201269f, -0.06086672f, -0.06645706f, 0.18033592f, 
    -0.09810094f, -0.02486924f, -0.10347664f, 0.01224118f, 0.08434452f, 0.16808161f, 0.00243445f, 0.10204923f, 
    -0.02681576f, -0.17171490f, -0.19120611f, -0.41563702f, -0.26480213f, -0.12931208f, 0.02970449f, -0.12065231f, 
    -0.13130966f, 0.15003331f, 0.00316039f, -0.14262284f, 0.15692955f, -0.06719222f, 0.13319302f, -0.03322444f, 
    0.01996189f, 0.04603852f, 0.36605537f, 0.11613294f, 0.27966964f, -0.39376277f, -0.14566121f, -0.07545273f, 
    -0.10468806f, 0.05767578f, -0.03576205f, 0.00089239f, -0.06868656f, 0.11028655f, -0.20511295f, 0.11009596f, 
    -0.00278312f, 0.04174655f, 0.00024790f, 0.06249222f, 0.07225869f, -0.04138705f, 0.09233607f, 0.15002812f, 
    -0.18501240f, 0.22883999f, 0.18287331f, 0.09084674f, 0.05866437f, -0.06222773f, -0.07630587f, 0.04763649f, 
    0.65670139f, -0.19346726f, -0.64654213f, -0.01062975f, 0.02167355f, -0.04980890f, 0.22008973f, -0.07747793f, 
    -0.20168099f, -0.03438216f, -0.01221046f, -0.07645572f, -0.17389549f, -0.19389458f, 0.36192158f, 0.22475795f, 
    -0.12064838f, 0.00291745f, 0.11517384f, 0.16230081f, 0.06345735f, -0.06523034f, -0.05263624f, -0.11767662f, 
    -0.05510353f, -0.13928211f, 0.12957257f, -0.05021812f, 0.07904721f, 0.01833012f, 0.07981554f, 0.04574225f, 
    -0.02683381f, -0.03183871f, -0.07873712f, 0.14983770f, -0.13421665f, -0.49427822f, 0.24974006f, -0.03291938f, 
    -0.09284126f, 0.10010440f, 0.02172327f, -0.00641540f, 0.07554041f, -0.05745874f, 0.05087361f, -0.19650106f, 
    -0.12479652f, -0.24647464f, -0.01011884f, 0.07613243f, 0.12889256f, 0.02323290f, 0.84298676f, -0.28431386f, 
    -0.15372841f, 0.18675736f, 0.05287689f, 0.08440930f, -0.02093937f, -0.03181417f, -0.10463876f, 0.06962639f, 
    -0.14050397f, -0.38287744f, -0.11729793f, -0.18620357f, -0.06881151f, 0.08467608f, -0.07993009f, -0.19143821f, 
    -0.45143563f, 0.21199711f, -0.16191353f, 0.04246694f, -0.02717313f, -0.08513093f, 0.00000752f, 0.24382521f, 
    0.01440799f, -0.19231121f, -0.43338183f, -0.01719564f, -0.00524210f, 0.07936625f, -0.05211167f, 0.00537928f, 
    -0.00263572f, 0.28493467f, 0.24200013f, -0.54737014f, -0.28020853f, -0.08218129f, 0.05173191f, 0.08858901f, 
    0.14898317f, -0.05750490f, 0.01197146f, 0.08488339f, 0.10663908f, 0.24660364f, -0.13447076f, -0.02959045f, 
    0.08597344f, -0.09761804f, -0.15562183f, 0.16229308f, 0.08605654f, 0.17033720f, -0.03555408f, 0.07153774f, 
    -0.14468448f, 0.00477848f, 0.11389396f, 0.00278795f, -0.08824476f, 0.63591278f, 0.27532789f, -0.18356277f, 
    -0.05576149f, -0.23309438f, -0.07638648f, -0.06258281f, 0.07252488f, 0.07722243f, 0.24528885f, 0.12878335f, 
    0.29305986f, -0.14737059f, -0.11899651f, -0.10199580f, 0.11589567f, -0.11690488f, -0.02119763f, 0.63840067f, 
    0.01692409f, -0.03196299f, -0.28275147f, 0.16344377f, 0.08907457f, 0.07422109f, -0.00051235f, -0.10914434f, 
    -0.08587147f, 0.15553153f, 0.21336292f, 0.26131693f, 0.12413107f, -0.02886856f, 0.18028137f, 0.02742732f, 
    0.18751191f, 0.19509745f, 0.03417548f, 0.20366344f, 0.25754455f, 0.04800007f, 0.32226244f, 0.04267044f, 
    -0.10418182f, -0.10705846f, -0.09640705f, 0.05810429f, -0.03470144f, 0.04516242f, -0.00997572f, -0.20186047f, 
    -0.08310942f, -0.09611732f, 0.23710422f, 0.25806800f, 0.13094136f, -0.22461079f, 0.14567395f, 0.03032248f, 
    0.01076887f, -0.03812815f, 0.11879237f, -0.03594317f, -0.57693464f, -0.50196767f, -0.26723200f, -0.06185396f, 
    0.03147756f, 0.10885649f, 0.11321042f, -0.00846414f, 0.10276863f, -0.16069980f, -0.42088148f, -0.22306101f, 
    0.01421781f, 0.06209415f, -0.08019864f, 0.09276330f, 0.13270092f, -0.01586108f, -0.70204020f, -0.05397378f, 
    0.17052932f, -0.08468311f, 0.07131458f, -0.04601841f, -0.00416619f, -0.03919216f, -0.04130160f, -0.72495639f, 
    -0.21428841f, -0.27714255f, 0.09561249f, 0.09642816f, 0.14137892f, -0.14877219f, -0.01570480f, -0.08528619f, 
    0.12585250f, 0.34275824f, 0.15617743f, -0.10346488f, 0.07886944f, 0.04201843f, 0.04582151f, 0.09663320f, 
    -0.27158076f, -0.09977549f, -0.08796963f, 0.47195530f, -0.14081849f, -0.02986179f, -0.18695825f, 0.02070970f, 
    -0.06277692f, -0.14096273f, -0.24956867f, -0.31997544f, -0.08794203f, -0.01896466f, 0.13002920f, -0.16258715f, 
    -0.06598579f, 0.02535696f, 0.05802486f, -0.08501355f, -0.02556074f, 0.06137172f, -0.19937372f, -0.18281253f, 
    -0.25808281f, 0.15503384f, -0.20347928f, 0.26853418f, -0.04548706f, 0.06852379f, -0.00207323f, 0.08416406f, 
    0.11419027f, -0.05607219f, -0.08087686f, -0.00791110f, -0.03077607f, -0.18318644f, 0.10120804f, -0.35798857f, 
    -0.06194311f, -0.02803718f, -0.20088628f, 0.02554527f, 0.12412263f, -0.05609112f, 0.34958017f, 0.14664201f, 
    0.15053375f, -0.07034526f, 0.01689452f, 0.11436278f, -0.04021231f, -0.11091766f, -0.10265473f, 0.27804425f, 
    -0.00743537f, 0.31148705f, 0.05226845f, 0.17141752f, 0.30902559f, 0.21231893f, 0.02040116f, 0.22201005f, 
    0.09057580f, 0.13999453f, 0.24022307f, -0.01124208f, -0.12368726f, -0.00229346f, 0.17843659f, 0.11492693f, 
    0.16684709f, 0.00893221f, 0.07458237f, -0.06426571f, 0.19081695f, 0.13491426f, 0.04789567f, 0.15800995f, 
    0.05517081f, 0.09063706f, -0.42458248f, -0.09233120f, -0.13806893f, 0.09023915f, -0.12968525f, -0.15207773f, 
    -0.01715642f, -0.42045468f, -0.19490513f, -0.12775400f, -0.34075937f, -0.19611023f, -0.09243945f, 0.23498458f, 
    0.11141946f, -0.04122907f, 0.08541732f, 0.04434690f, -0.04764174f, -0.19770554f, 0.09336846f, -0.00400908f, 
    0.04483128f, 0.22285956f, -0.08754640f, 0.06074997f, 0.05957913f, -0.09050465f, 0.06006986f, -0.13743423f, 
    -0.00317234f, 0.13952461f, -0.00673780f, 0.03902558f, 0.08822192f, -0.48201355f, 0.23842964f, -0.01017447f, 
    0.35450551f, 0.14254965f, -0.04003066f, 0.18273294f, 0.04743103f, -0.04882082f, -0.06602596f, -0.28625745f, 
    -0.08674048f, -0.13876995f, -0.02321350f, -0.11793131f, -0.06765032f, -0.05824596f, 0.12181762f, -0.19992463f, 
    -0.15352000f, -0.00079431f, -0.07083956f, 0.06868181f, 0.18238299f, -0.12055825f, 0.12576102f, 0.23294322f, 
    0.15805817f, 0.18702257f, 0.27677229f, 0.09393571f, 0.10919287f, 0.20368575f, -0.00442659f, -0.03889221f, 
    -0.22067624f, 0.13766518f, -0.08635539f, 0.16749352f, 0.15984519f, 0.04499700f, -0.05681695f, -0.11684304f, 
    0.10155443f, 0.01094033f, 0.03744501f, -0.34184510f, -0.18769911f, -0.01236492f, -0.30645701f, -0.21980894f, 
    -0.17491691f, 0.08178276f, 0.10421644f, -0.13710035f, -0.00411689f, 0.11400350f, -0.00744519f, -0.28267673f, 
    0.05251939f, 0.03366443f, -0.12490011f, 0.11053020f, -0.08044246f, -0.19930357f, 0.06208284f, 0.11699627f, 
    0.07755207f, 0.04414972f, 0.12429016f, 0.13815531f, -0.05950807f, -0.18751445f, -0.38653573f, -0.15593040f, 
    -0.09399544f, -0.12896307f, -0.21756324f, -0.07175573f, 0.06536648f, 0.16178785f, 0.17844293f, 0.29695067f, 
    0.18202162f, 0.31660807f, 0.18084919f, -0.21918906f, 0.31439978f, -0.04407157f, 0.23445752f, 0.11309120f, 
    0.06360763f, -0.03104600f, 0.02024646f, -0.00177578f, -0.04527111f, 0.04236132f, 0.00099476f, -0.05107353f, 
    0.03482519f, -0.01255845f, -0.01063254f, 0.06141919f, -0.05883434f, 0.02585471f, 0.05687328f, -0.02766851f, 
    0.04070754f, -0.03757705f, -0.08686750f, -0.01577204f, -0.02714219f, -0.05798070f, 0.01548399f, -0.04335038f, 
    0.03969838f, -0.03578619f, -0.04844755f, 0.06181666f, -0.06176770f, 0.01584844f, 0.02214514f, -0.08305841f, 
    -0.03223668f, 0.00320248f, 0.01539512f, -0.03791928f, 0.01979919f, 0.00243204f, 0.06075538f, 0.03693767f, 
    -0.00285525f, 0.05638773f, -0.06805901f, -0.09102762f, 0.03975162f, -0.00390611f, -0.05090426f, -0.00625639f, 
    0.02706573f, 0.06920233f, -0.02927887f, 0.03722712f, -0.09572569f, -0.08501697f, 0.06732369f, -0.04537078f, 
    0.03157716f, -0.01479046f, -0.06688733f, 0.07302748f, 0.02201795f, 0.06579006f, -0.07892320f, -0.00252121f, 
    -0.02012059f, 0.01619758f, -0.05176851f, -0.04826947f, -0.06549139f, 0.05452399f, -0.02683190f, -0.05544628f, 
    -0.03739535f, -0.01955489f, -0.04091395f, -0.07495589f, 0.00229129f, -0.02419568f, 0.03167585f, 0.00163034f, 
    0.02248728f, 0.07235310f, -0.00006863f, -0.02496375f, -0.03034208f, 0.02063795f, -0.01254369f, 0.04195693f, 
    0.00689710f, -0.00693192f, -0.00464226f, 0.02354526f, -0.04308995f, 0.02072025f, -0.01382913f, -0.02650525f, 
    -0.04819949f, -0.05789503f, 0.06640923f, -0.05414421f, -0.06203181f, -0.01177622f, -0.03430842f, -0.05945488f, 
    -0.05266416f, 0.02080963f, -0.03760395f, 0.05712638f, 0.05542407f, -0.06961196f, 0.03018461f, -0.00822505f, 
    0.04131661f, 0.05855587f, -0.02240577f, -0.03096345f, -0.01706697f, -0.07360324f, -0.04560789f, -0.04797160f, 
    -0.03416134f, -0.02764907f, 0.00312343f, 0.04522149f, -0.01011043f, -0.03001903f, -0.07278905f, 0.05659109f, 
    -0.06797364f, -0.03158527f, 0.04369745f, -0.07660132f, -0.00765149f, -0.08051849f, -0.05938805f, -0.07469936f, 
    -0.03522041f, 0.00897369f, 0.00758327f, -0.03464400f, 0.06420431f, -0.07722277f, -0.01283599f, -0.05004784f, 
    0.01249835f, 0.02245300f, -0.00100110f, 0.01036851f, -0.04934337f, 0.01708580f, 0.02239893f, 0.04511362f, 
    0.03040822f, 0.01303076f, -0.05039468f, 0.03668828f, -0.01021817f, -0.07746394f, -0.05121402f, -0.03117353f, 
    0.02140237f, 0.03148703f, 0.01005561f, -0.06668536f, 0.04837422f, 0.05241900f, -0.02270064f, 0.00666054f, 
    0.00955109f, 0.04512944f, 0.05030397f, 0.03701257f, 0.01798516f, -0.01409777f, 0.06941560f, 0.06070874f, 
    0.05783779f, -0.01454827f, -0.03934542f, -0.01511740f, -0.02201767f, 0.07371553f, 0.05713056f, -0.06642636f, 
    -0.03934992f, -0.01621687f, 0.04748507f, -0.04513395f, -0.02686645f, -0.08056021f, 0.04731447f, 0.01587544f, 
    0.05250197f, 0.01733703f, 0.00387681f, -0.04769207f, -0.04714596f, 0.06640673f, -0.07732338f, 0.02737116f, 
    -0.06338333f, -0.07867795f, -0.03052521f, 0.02205957f, 0.05696216f, -0.07322751f, -0.06002444f, 0.03437754f, 
    -0.02777096f, -0.04249572f, -0.05367114f, 0.04656177f, 0.07804621f, -0.05308352f, 0.01214117f, 0.02831055f, 
    -0.07731766f, 0.06966802f, -0.07146800f, -0.07511608f, -0.07489739f, -0.02748287f, 0.05707151f, 0.02540093f, 
    -0.03050233f, 0.05551102f, 0.07300626f, -0.01423445f, 0.07469615f, -0.05726522f, 0.02081301f, 0.02043466f, 
    -0.01240921f, 0.05290290f, -0.02896219f, -0.06625799f, 0.01894550f, 0.01834244f, -0.05479383f, -0.06995189f, 
    -0.03924164f, -0.08268528f, 0.05013308f, -0.02918242f, 0.01730049f, 0.04733865f, -0.04342950f, 0.01149483f, 
    0.05161013f, -0.05392192f, -0.04941104f, -0.05945827f, 0.02557614f, -0.07717326f, -0.06753398f, 0.07746051f, 
    0.07961430f, -0.04993365f, 0.03829505f, -0.00643624f, 0.03006684f, -0.08282121f, -0.02120915f, -0.05460139f, 
    -0.00097193f, -0.01264778f, -0.01065313f, -0.05824031f, -0.00514094f, 0.03033653f, 0.04798215f, -0.06175680f, 
    -0.08301058f, 0.01755130f, -0.07891604f, 0.02604325f, -0.07189288f, -0.02490898f, -0.03095644f, -0.05647950f, 
    0.00593153f, -0.05736437f, -0.05972503f, -0.00871332f, 0.04277619f, -0.07408717f, -0.03711800f, -0.00385162f, 
    0.07799284f, -0.03533890f, -0.00512072f, -0.06938688f, 0.18600160f, -0.02125009f, 0.11630618f, 0.03152417f, 
    -0.10851914f, -0.17932531f, 0.43953446f, 0.01559837f, -0.01480760f, -0.00440175f, -0.07840399f, 0.10648290f, 
    0.09771264f, 0.01067316f, -0.15518017f, 0.13694288f, 0.01347073f, 0.19338706f, -0.04600227f, 0.34516218f, 
    -0.37020946f, -0.38044506f, -0.23298806f, 0.01547067f, 0.21831478f, 0.19717735f, -0.09447155f, 0.03816917f, 
    0.01943128f, 0.06981302f, 0.16641873f, 0.35593417f, 0.22819929f, 0.16760358f, -0.04410033f, 0.02006902f, 
    0.19868577f, 0.19661233f, 0.05881060f, 0.10186470f, -0.18781303f, 0.27260610f, -0.04620333f, -0.05230564f, 
    0.21440168f, -0.09542596f, 0.04422342f, -0.06945057f, 0.09093144f, 0.01939843f, -0.01270750f, 0.11247025f, 
    -0.35546896f, -0.05162439f, 0.08807930f, -0.06761987f, -0.00271858f, 0.13821965f, 0.14728108f, 0.16554415f, 
    0.56318605f, 0.26654997f, 0.00223594f, -0.10366539f, 0.13885185f, 0.03090902f, 0.19414604f, 0.02752413f, 
    0.04356905f, 0.29007137f, 0.15633614f, 0.09069235f, 0.04461110f, -0.07687139f, -0.02443833f, 0.06125541f, 
    -0.15614684f, 0.01742524f, -0.10838653f, -0.32172468f, 0.14562146f, -0.09904384f, -0.03057042f, -0.22562805f, 
    -0.08780066f, -0.07494388f, 0.12280443f, -0.14305991f, -0.42252883f, -0.09372890f, 0.04502866f, -0.17453654f, 
    -0.04667632f, -0.28393486f, -0.18053459f, -0.20612308f, 0.00014334f, 0.11016071f, 0.17958954f, -0.08157845f, 
    -0.02030804f, -0.02055730f, 0.08641752f, -0.10650727f, -0.04555336f, 0.17701231f, -0.06622474f, 0.00127207f, 
    -0.02100511f, -0.18632904f, 0.08814361f, 0.28889489f, 0.17143813f, 0.15173025f, -0.03231660f, -0.27255946f, 
    -0.00694650f, -0.06253026f, 0.11005002f, -0.00267988f, -0.07813000f, 0.12017035f, -0.04892691f, 0.18387124f, 
    0.11640183f, -0.04150382f, 0.13815281f, -0.18717256f, -0.04521074f, -0.00618395f, -0.12651730f, 0.15235558f, 
    0.23887649f, -0.12200554f, 0.01585736f, 0.09019033f, -0.02766402f, -0.24666001f, 0.20208459f, -0.06221948f, 
    -0.55175811f, -0.43230501f, -0.22950034f, -0.05407667f, 0.07243744f, 0.14729396f, 0.11886317f, 0.09747165f, 
    0.04831735f, 0.24970897f, -0.51346695f, -1.02463257f, -0.03784923f, -0.06801224f, 0.20176354f, 0.13493308f, 
    0.04223628f, 0.01605247f, -0.31476879f, -0.12230806f, 0.25888431f, 0.01853888f, -0.26738021f, -0.06223049f, 
    0.00610652f, 0.02085760f, -0.08919030f, 0.18591034f, 0.02221652f, -0.02119857f, -0.04530790f, 0.02663700f, 
    -0.09533753f, -0.09945916f, 0.01372501f, 0.05341194f, 0.18171385f, 0.20956981f, 0.08336659f, -0.17473641f, 
    0.06912596f, -0.23786607f, 0.02836293f, 0.00466206f, 0.02092541f, 0.51913291f, 0.17812610f, 0.11422899f, 
    -0.06149166f, -0.03795121f, -0.01003863f, 0.20260406f, -0.07938193f, -0.04463213f, 0.16759582f, 0.18516620f, 
    0.34298626f, 0.04272418f, 0.07774894f, -0.06540852f, 0.08113087f, 0.09848874f, 0.12434851f, -0.12049992f, 
    0.16683188f, 0.31092682f, -0.04499606f, -0.20089951f, -0.00753966f, -0.05921968f, 0.02396314f, 0.00795670f, 
    -0.44428116f, -0.85246563f, -0.04084895f, -0.02379487f, -0.07567669f, -0.10091831f, 0.03266251f, 0.10033775f, 
    -0.01050368f, 0.00738222f, 0.26746726f, 0.09025357f, -0.11399035f, -0.07829898f, -0.05189826f, 0.15113762f, 
    0.09521576f, -0.03812319f, 0.22406474f, -0.39381963f, -0.22382861f, 0.09999982f, -0.07910924f, 0.04431504f, 
    0.07094193f, 0.08791414f, 0.16284412f, 0.37114927f, -0.08364949f, -0.35289589f, 0.01070112f, -0.07520189f, 
    -0.23433089f, 0.16467097f, -0.19019625f, 0.00358741f, 0.26443163f, 0.09089811f, 0.13337831f, -0.10847021f, 
    0.04205140f, 0.05981911f, 0.04533534f, 0.16272494f, -0.03657517f, 0.49668404f, 0.16595648f, 0.13176551f, 
    0.07851437f, -0.06373747f, 0.03584525f, 0.16042136f, -0.04598367f, 0.06006220f, 0.23573406f, -0.06657005f, 
    -0.38301417f, -0.00977989f, -0.10184893f, -0.06456186f, 0.15714103f, 0.13687938f, -0.02921263f, -0.38394663f, 
    0.18086806f, -0.11363095f, -0.01979380f, -0.08504241f, 0.13678962f, 0.10947091f, 0.07360109f, 0.00100234f, 
    -0.24794364f, -0.05445144f, -0.21534143f, 0.10979070f, 0.00843162f, 0.00968715f, -0.01285373f, -0.15921590f, 
    -0.03161187f, -0.42036787f, 0.04300855f, -0.25173238f, -0.06958439f, -0.26406944f, -0.00664657f, 0.08367743f, 
    -0.15670151f, 0.02607969f, 0.34795275f, 0.05040842f, -0.18093170f, 0.10938218f, -0.01938027f, 0.11537867f, 
    0.06759159f, 0.04532935f, -0.09413314f, -0.05544358f, 0.08424491f, 0.07639264f, -0.00248342f, -0.13563485f, 
    -0.26007918f, -0.07445185f, -0.25630075f, -0.00178383f, -0.03551966f, -0.12259886f, -0.09027460f, -0.02234379f, 
    -0.06193077f, -0.07361235f, 0.04855980f, 0.05904643f, -0.04311015f, -0.04371184f, 0.48273575f, -0.19105829f, 
    -0.09508660f, 0.00727621f, -0.32883403f, -0.03311512f, 0.11032635f, 0.03098032f, 0.32610962f, 0.07724692f, 
    0.04314033f, -0.11583842f, 0.10976176f, -0.05012671f, 0.19340734f, 0.03795393f, 0.07568033f, 0.16933791f, 
    0.33883712f, -0.33198905f, 0.16102001f, -0.08411043f, 0.18316603f, -0.10216536f, -0.07550388f, 0.06476513f, 
    -0.10620251f, 0.38945231f, -0.27597052f, -0.16707885f, -0.13141601f, -0.07472419f, 0.05723284f, 0.06405197f, 
    -0.07075438f, 0.30254343f, 0.28390893f, 0.15929320f, -0.11583167f, 0.05610133f, 0.04782966f, 0.03736627f, 
    0.23403262f, 0.20460384f, -0.12439752f, 0.20666033f, 0.53978258f, -0.02930977f, 0.20577992f, -0.09229056f, 
    0.26568612f, 0.04982086f, -0.00535436f, 0.14276032f, 0.01238091f, -0.28575796f, 0.09002442f, 0.15390261f, 
    0.06961443f, 0.04325636f, 0.20993370f, 0.18557785f, 0.02580662f, -0.13131496f, -0.06629432f, -0.00203232f, 
    0.04034369f, 0.26026735f, -0.32021108f, -0.23271243f, -0.19666295f, 0.38614893f, 0.12721351f, 0.01053828f, 
    0.19040856f, -0.04870167f, -0.14823714f, 0.04712889f, -0.23829985f, -0.11736521f, 0.14720632f, -0.15741085f, 
    -0.28210410f, 0.04863537f, 0.02196511f, 0.08323552f, 0.06213825f, 0.09780446f, 0.14966811f, 0.32944879f, 
    -0.26598492f, -0.13769475f, -0.23538773f, 0.02177033f, -0.15740807f, -0.13702145f, 0.12623203f, 0.02267428f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.30493891f, -0.04412284f, 0.04985140f, 0.38941252f, -0.05657729f, 0.08666486f, 0.05366359f, 0.15587302f, 
    0.01220808f, 0.18042974f, 0.24177523f, 0.04457054f, -0.07499114f, -0.14531250f, 0.00120572f, -0.06195481f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10945638f, 0.15396729f, -0.02497051f, 0.52691895f, -0.05144180f, -0.20854585f, 0.35127583f, 0.21818091f, 
    -0.12648472f, -0.08601955f, 0.13179670f, 0.04351372f, -0.07951213f, 0.02013443f, -0.36951673f, 0.16451170f, 
    -0.10117467f, 0.32037231f, -0.05707821f, -0.43806145f, -0.23744407f, -0.20733576f, 0.34274936f, 0.24403946f, 
    -0.28631669f, 0.16938946f, -0.28381374f, -0.05050620f, 0.03103577f, -0.16626661f, 0.46790147f, 0.04066320f, 
    0.16421187f, 0.11937191f, -0.22615035f, 0.41633809f, -0.23508818f, -0.05734892f, -0.00383511f, -0.29351622f, 
    -0.22549716f, 0.42635834f, -0.07530683f, -0.14264107f, 0.03190792f, 0.04684665f, 0.18518580f, -0.07444823f, 
    -0.06850490f, 0.13013180f, 0.22115880f, 0.18844829f, -0.08054506f, 0.20994513f, 0.50185591f, -0.31988603f, 
    0.02756348f, 0.49156231f, -0.38058326f, -0.12216330f, 0.22111961f, -0.24346042f, 0.11588237f, -0.53808308f, 
    -0.01789010f, 0.22385788f, 0.24091238f, -0.50461155f, 0.18401870f, -0.11778202f, 0.09054147f, -0.41624206f, 
    -0.17080055f, -0.27212247f, -0.01507316f, -0.10743284f, 0.13273987f, -0.21776782f, 0.48075420f, 0.35013992f, 
    0.01803795f, -0.04287811f, -0.03427796f, -0.37629971f, -0.01423548f, -0.13017441f, 0.05132282f, 0.26288459f, 
    0.36820954f, 0.09526955f, -0.03693080f, 0.19132611f, -0.16422468f, 0.02581950f, 0.12316108f, -0.04419171f, 
    -0.56408113f, 0.17089348f, -0.23701496f, 0.11090656f, -0.24580593f, 0.24114841f, 0.29486296f, -0.02410053f, 
    0.08758926f, 0.14063947f, -0.17304340f, -0.08883599f, 0.16924863f, 0.04837180f, -0.39214033f, -0.06420345f, 
    -0.16731447f, -0.22486857f, -0.24272904f, -0.60116702f, -0.21352896f, -0.01200194f, -0.23025078f, 0.03434461f, 
    -0.28391147f, -0.63442481f, 0.40064225f, -0.01560250f, -0.04740915f, 0.07061883f, 0.54689604f, 0.21736141f, 
    0.06729451f, -0.39135697f, -0.01616389f, -0.24825424f, 0.04587201f, -0.08758036f, -0.18270864f, -0.18906401f, 
    0.33082965f, 0.42346191f, 0.21124212f, 0.06089336f, -0.09618378f, -0.15809187f, 0.51384330f, -0.17981073f, 
    0.24365684f, -0.02104915f, 0.12711725f, -0.25300294f, 0.12683196f, -0.11603624f, -0.21340401f, 0.16827774f, 
    0.02282824f, -0.13214016f, 0.42113942f, -0.09488896f, 0.18514556f, -0.04664138f, -0.17310476f, -0.05586797f, 
    0.18838224f, -0.32777351f, 0.09317239f, -0.14940977f, -0.05460906f, 0.08159883f, 0.12638855f, 0.00481848f, 
    -0.31281537f, -0.14057645f, 0.18466361f, 0.03759126f, 0.25150368f, 0.29781246f, 0.58261615f, -0.23640607f, 
    -0.17018935f, 0.11038931f, 0.00740117f, -0.73919088f, -0.22472760f, -0.08129159f, -0.12082974f, -0.12892734f, 
    0.42799306f, -0.08659911f, 0.12874201f, 0.13791086f, -0.16679956f, 0.30921379f, 0.22994536f, 0.22502369f, 
    -0.28345054f, -0.10947403f, 0.23900518f, 0.17963794f, 0.21849687f, -0.10513136f, -0.06765861f, 0.01583502f, 
    0.05144522f, 0.27523097f, -0.04563954f, -0.20272133f, 0.19016148f, 0.15100783f, 0.32328793f, 0.06628131f, 
    -0.03736174f, -0.24360256f, -0.22610390f, 1.08245659f, -0.19802083f, 0.41464642f, -0.25309017f, -0.11882481f, 
    0.11984273f, -0.30393830f, -0.07309329f, 0.03035859f, -0.17096221f, 0.22075517f, -0.14647403f, 0.30142841f, 
    -0.07008795f, -0.12740341f, -0.17220503f, -0.14902101f, -0.05812606f, -0.21928808f, 0.04259019f, 0.02653692f, 
    -0.15296492f, -0.05582170f, 0.01671720f, 0.18235147f, -0.03983181f, -0.15993665f, -0.07868782f, 0.07255717f, 
    -0.00095613f, 0.07214145f, 0.15076061f, -0.18380888f, 0.12632143f, -0.27903762f, 0.46136305f, 0.09521481f, 
    0.08463475f, 0.10556889f, 0.22178154f, -0.00602194f, 0.23349553f, -0.31631628f, 0.26881114f, 0.32811177f, 
    0.08033178f, -0.37215772f, 0.17142217f, -0.66228968f, 0.01003535f, -0.38635612f, 0.44569287f, 0.12667602f, 
    -0.06203206f, 0.43665889f, 0.28162360f, -0.15167791f, -0.00928266f, -0.07888101f, -0.09719158f, -0.06237155f, 
    0.22639677f, 0.19913609f, -0.05149447f, -0.07711006f, 0.14224777f, -0.13244791f, -0.29225269f, -0.03110838f, 
    0.15772368f, -0.17119335f, 0.11726310f, 0.03507002f, 0.14122820f, 0.12635419f, -0.13776805f, 0.08190206f, 
    -0.29900810f, -0.36497658f, 0.09919157f, 0.42129081f, 0.18971439f, -0.22946468f, -0.07640933f, 0.44245669f, 
    -0.44394878f, -0.10566804f, 0.41307759f, -0.09629253f, -0.09459420f, 0.28791028f, 0.36321008f, -0.16772816f, 
    -0.94852960f, -0.06779163f, -0.10040460f, -0.12245333f, -0.09505904f, 0.40917230f, -0.09714531f, -0.11991533f, 
    0.39540458f, 0.07151788f, 0.02444811f, 0.05337536f, 0.04891345f, 0.25862801f, -0.01656227f, -0.26833716f, 
    -0.13751495f, -0.19712688f, -0.20303822f, 0.10314598f, 0.05617942f, -0.38327321f, 0.14298141f, -0.04734792f, 
    0.19803223f, 0.19921771f, 0.23891082f, 0.08358619f, 0.05879506f, -0.07667103f, 0.26256001f, 0.27758622f, 
    0.03432475f, -0.26743412f, -0.19416907f, -0.24600156f, -0.11850423f, 0.17001869f, -0.07925494f, -0.20605789f, 
    0.02115438f, -0.25412902f, -0.21192472f, 0.20315659f, -0.09897810f, -0.10261855f, 0.01635759f, 0.18341948f, 
    0.13622817f, 0.14539281f, 0.13186273f, -0.00939780f, -0.02749328f, 0.27094406f, -0.14583820f, 0.01873662f, 
    0.16145049f, -0.35878423f, 0.10161502f, 0.03073812f, 0.11885014f, -0.24089451f, -0.39754021f, 0.22623444f, 
    -0.32683414f, -0.07421189f, -0.03369144f, 0.36762616f, -0.15110061f, 0.06113800f, -0.30840969f, -0.02788957f, 
    -0.00768519f, 0.27226135f, 0.07183568f, -0.15973918f, -0.03905508f, 0.15817006f, 0.44339064f, -0.32223794f, 
    -0.11817050f, 0.17963095f, 0.19532683f, 0.01155702f, 0.18186343f, 0.32843482f, 0.49772093f, -0.46229839f, 
    0.22668351f, -0.19886819f, -0.22272019f, -0.01061908f, -0.12806065f, -0.03549056f, 0.00788937f, 0.05772702f, 
    -0.30887136f, -0.52237153f, -0.03275026f, 0.21360907f, 0.10879069f, 0.30296603f, -0.42926133f, 0.37055758f, 
    -0.13839093f, -0.00476977f, 0.30898780f, 0.09074215f, -0.01072691f, 0.09263303f, 0.06529080f, -0.29449072f, 
    0.20442343f, 0.21097650f, 0.08101080f, 0.43064752f, -0.05155305f, 0.10120168f, 0.31194884f, 0.26765010f, 
    -0.48111406f, 0.19504851f, 0.04311786f, 0.07887138f, 0.02595435f, 0.14260849f, -0.05732439f, -0.41427922f, 
    -0.01756141f, -0.24737276f, -0.05094299f, 0.49139562f, 0.16930965f, 0.00980934f, -0.29979551f, 0.05981887f, 
    0.00738360f, -0.01960142f, 0.09986956f, -0.13804419f, -0.16470030f, 0.32436633f, 0.17168377f, 0.08713385f, 
    -0.33784634f, -0.30638894f, -0.15275937f, 0.18775973f, 0.07204889f, -0.17913076f, 0.47632760f, 0.60052490f, 
    0.03259580f, -0.30162987f, 0.52506173f, -0.00540388f, -0.19218676f, -0.22771935f, -0.25049898f, -0.20692894f, 
    0.14225028f, 0.00469865f, -0.15107369f, -0.86777079f, 0.20818214f, -0.14131136f, 0.30927685f, 0.01482896f, 
    0.06077795f, -0.47012529f, -0.03819476f, -0.17786172f, -0.24638464f, 0.17826103f, 0.58612734f, 0.17384444f, 
    0.19905207f, 0.18666868f, -0.10616842f, 0.37605360f, -0.06098640f, 0.01098998f, 0.03035923f, -0.13044345f, 
    -0.45434225f, 0.12964226f, -0.02757966f, 0.04148962f, 0.09912793f, 0.14402491f, 0.09917630f, -0.20963112f, 
    -0.31959555f, 0.17767525f, -0.20206510f, 0.75664347f, -0.05855730f, 0.32594651f, 0.18746726f, -0.31607655f, 
    -0.63339549f, 0.11079062f, 0.17241065f, -0.05947599f, -0.00430239f, -0.31522307f, -0.46584025f, 0.25259292f, 
    0.37939167f, -0.01370113f, -0.24388811f, -0.15731823f, -0.19378392f, 0.05237168f, 0.05283851f, -0.05214120f, 
    0.42730063f, -0.34703371f, 0.18413639f, -0.04177630f, 0.17692560f, -0.09623922f, -0.31174952f, 0.15134546f, 
    -0.21964179f, -0.30451167f, 0.21839470f, 0.19388151f, 0.18315065f, 0.38559565f, 0.07564165f, 0.19336905f, 
    -0.22407031f, -0.17979179f, -0.01969857f, 0.18310121f, 0.24913818f, -0.24516493f, -0.20681608f, 0.14934294f, 
    -0.25904992f, -0.04732494f, -0.04924874f, -0.09935711f, 0.06470144f, -0.05919756f, -0.13664451f, -0.25190562f, 
    -0.06735255f, 0.16627908f, -0.18068677f, 0.05633882f, -0.09994218f, 0.01280268f, -0.05994334f, -0.13123034f, 
    0.29587671f, 0.06128370f, 0.18129374f, -0.07832610f, -0.06983102f, 0.03724942f, -0.01564006f, 0.16546622f, 
    -0.24111708f, -0.41627869f, 0.25475520f, 0.04054119f, -0.22841582f, -0.28980678f, 0.34258595f, 0.47448111f, 
    0.21158645f, 0.22822708f, 0.00504928f, -0.15561198f, 0.04868678f, 0.15528215f, 0.19744985f, -0.17315036f, 
    0.38242695f, -0.36454687f, -0.18437369f, 0.23877296f, -0.23592722f, -0.17035052f, 0.15517506f, 0.21863392f, 
    -0.78036237f, -0.11958316f, 0.20218335f, 0.11496333f, -0.09407452f, -0.04017034f, 0.15562046f, 0.10405656f, 
    0.39242142f, 0.33320081f, 0.22156775f, -0.06397003f, 0.23115088f, -0.16725957f, -0.09121951f, 0.20619990f, 
    0.37603688f, -0.08552126f, 0.14281878f, 0.14181989f, -0.09767117f, 0.03058082f, -0.45803177f, 0.28314167f, 
    -0.12003021f, -0.10577468f, 0.09741183f, 0.12770753f, -0.14932340f, 0.36016300f, 0.02149450f, -0.41165942f, 
    -0.45406038f, 0.28179005f, 0.12237919f, 0.11058053f, -0.07815561f, -0.11567694f, 0.40510291f, -0.07256082f, 
    0.30793732f, 0.07566213f, -0.01937978f, -0.07386974f, -0.05068138f, -0.42769316f, 0.44731298f, -0.37391183f, 
    0.06154728f, -0.55174601f, -0.09004679f, -0.77058870f, 0.04073557f, 0.29803857f, -0.17305829f, -0.18292944f, 
    -0.21222308f, -0.01191077f, 0.32937059f, 0.18064106f, 0.09145366f, 0.31958556f, -0.06818309f, 0.03706187f, 
    -0.12484637f, 0.08215287f, 0.02636727f, -0.56750822f, 0.20931765f, -0.11425435f, -0.18592821f, -0.10786241f, 
    0.44685224f, -0.05402191f, 0.06127333f, -0.22841598f, -0.00530687f, 0.10585743f, 0.31041956f, 0.20712726f, 
    -0.62221837f, 0.48862505f, 0.23690738f, 0.22912908f, 0.19894160f, 0.19835930f, 0.33119887f, -0.65700191f, 
    0.05476419f, 0.05377385f, -0.16201319f, 0.07555307f, -0.21090677f, 0.04688804f, 0.41232792f, -0.11177530f, 
    0.20689628f, 0.06837514f, -0.05014464f, -0.36996776f, 0.01958156f, -0.00074623f, 0.08360638f, 0.56853259f, 
    -0.31721252f, -0.30129698f, -0.01899255f, 0.22940034f, 0.14423764f, 0.16248418f, 0.22852315f, -0.40351066f, 
    0.37827086f, 0.08877618f, 0.14054766f, 0.54142439f, -0.17171350f, 0.23517174f, -0.02318942f, -0.27073294f, 
    -0.06245286f, 0.57835311f, -0.22947468f, 0.01954939f, 0.17300607f, -0.43903399f, -0.03320088f, 0.02046523f, 
    0.04742707f, -0.12951805f, 0.20859705f, -0.57794785f, -0.04157777f, -0.27219206f, 0.14280833f, -0.01168537f, 
    0.30154708f, 0.06512432f, 0.27383682f, 0.04110491f, -0.18985632f, 0.07127366f, 0.30139375f, 0.03545598f, 
    -0.05806483f, -0.00624586f, -0.02731812f, -0.65476787f, -0.04945088f, -0.25562817f, 0.16870134f, 0.06767429f, 
    -0.01275573f, 0.14625935f, 0.19549489f, 0.16143976f, 0.25719157f, 0.23156412f, 0.23603742f, -0.00312312f, 
    -0.16241719f, -0.06408098f, -0.14336428f, -0.22691822f, 0.15554699f, 0.06905916f, -0.18495366f, 0.31573576f, 
    -0.02927296f, -0.22108613f, 0.13138603f, -0.06732834f, -0.08746095f, 0.42645180f, 0.51657307f, -0.47447890f, 
    -0.77654368f, 0.16370392f, 0.12390450f, 0.68725932f, -0.15478610f, 0.18224919f, -0.21540847f, 0.34944043f, 
    0.00736691f, 0.21597958f, 0.31596294f, 0.04413763f, 0.16160639f, -0.49648035f, -0.12139636f, -0.36260861f, 
    -0.25094524f, 0.12031344f, -0.14456557f, 0.00249150f, -0.05604732f, -0.18235469f, -0.31235731f, -0.02263995f, 
    0.26279059f, 0.14002316f, 0.20167597f, -0.11967331f, -0.11592969f, -0.29003260f, 0.56377029f, 0.22730255f, 
    0.27639753f, -0.38251379f, -0.05165069f, 0.11050449f, -0.09577172f, 0.21652165f, 0.31747052f, -0.27558768f, 
    0.44834238f, -0.13771842f, -0.07951666f, 0.07999680f, -0.08474917f, -0.43242532f, 0.19088586f, 0.50295329f, 
    -0.00473070f, -0.53367126f, -0.09346055f, 0.22971110f, -0.19077982f, 0.08725078f, 0.02196206f, 0.25038275f, 
    0.32825464f, -0.03343140f, 0.27001429f, -0.05532092f, -0.10482814f, -0.30383697f, -0.10552242f, 0.06970328f, 
    -0.34645823f, -0.03167338f, -0.24893321f, 0.81170839f, -0.21620804f, -0.12981981f, 0.19827852f, 0.27573466f, 
    -0.22483374f, -0.02630986f, 0.04278664f, 0.18985035f, 0.24229762f, 0.18139941f, -0.27028152f, 0.10919720f, 
    0.11798082f, -0.23555464f, 0.22429308f, -0.03853554f, 0.01350839f, 0.19701657f, -0.02001832f, -0.22899853f, 
    0.13754147f, 0.15726945f, -0.31928706f, 0.18444960f, -0.18585944f, 0.09114046f, -0.22251043f, 0.28233927f, 
    -0.49442998f, -0.30684277f, -0.01755300f, -0.24966577f, -0.07029895f, -0.23727730f, 0.07234707f, 0.31219763f, 
    0.25895318f, 0.37753624f, 0.28668755f, -0.08007386f, -0.12137853f, 0.22912467f, 0.00836144f, -0.13477311f, 
    -0.20908341f, 0.15069553f, -0.00017662f, 0.06954648f, -0.18666327f, -0.22675085f, -0.24361362f, -0.01922008f, 
    0.08394518f, -0.10131815f, 0.03734120f, -0.04572074f, -0.16903788f, -0.19125135f, -0.12293568f, 0.10510335f, 
    -0.23551048f, 0.24061483f, 0.11490946f, -0.30885419f, -0.05628349f, -0.13576992f, -0.30687243f, -0.23916937f, 
    0.33819139f, 0.09446860f, -0.46978951f, 0.18263596f, -0.20802820f, 0.10965521f, -0.53727466f, 0.05484570f, 
    0.26635274f, -0.11369775f, -0.16426040f, 0.18186013f, -0.14872392f, 0.15439995f, -0.14820629f, 0.09315210f, 
    -0.28785995f, 0.39889109f, 0.23889619f, 0.11313581f, 0.23435687f, -0.01378296f, -0.10861422f, -0.17556833f, 
    -0.40526623f, 0.18878619f, -0.05152265f, 0.11002245f, 0.21810129f, -0.12901010f, 0.03805273f, -0.28196886f, 
    0.17275941f, 0.49206287f, 0.11830383f, 0.08882336f, 0.06596786f, 0.03969539f, -0.48797914f, -0.07170285f, 
    0.19818769f, 0.26551813f, -0.05358874f, -0.25973135f, -0.16592005f, -0.04402367f, -0.30509728f, -0.26851740f, 
    0.05759745f, 0.40264004f, 0.08219846f, 0.09141826f, 0.11144961f, -0.12172335f, -0.03751468f, -0.32987607f, 
    -0.13897812f, 0.05448020f, 0.18837449f, -0.07020381f, -0.04225558f, -0.24196249f, -0.17368418f, -0.15797547f, 
    -0.06671664f, -0.10077724f, -0.13044852f, -0.20293599f, -0.06427684f, -0.12266102f, -0.10797986f, 0.08896175f, 
    -0.13774469f, -0.08677378f, 0.08794871f, -0.05981134f, -0.12699856f, -0.10898194f, -0.28625387f, -0.01563995f, 
    -0.05610831f, 0.17015417f, -0.02847578f, -0.08414125f, -0.04488569f, -0.07694367f, -0.03110358f, 0.09249569f, 
    0.18969618f, 0.06894376f, -0.18641566f, 0.57618546f, 0.21288432f, -0.14263676f, 0.34288055f, -0.02157385f, 
    -0.08233508f, -0.10830599f, -0.20702402f, -0.13509929f, -0.11534175f, 0.15492871f, -0.40168172f, 0.24887319f, 
    0.11718176f, -0.20525664f, 0.09559605f, -0.48688814f, -0.14589408f, -0.29097429f, 0.22832319f, 0.09545141f, 
    -0.04618758f, 0.00754078f, 0.00419810f, 0.02553269f, 0.10876611f, 0.27152914f, 0.45405227f, -0.05366642f, 
    -0.15790281f, 0.32230186f, 0.23070975f, 0.59616119f, -0.06837133f, 0.35114521f, 0.21218729f, 0.01343653f, 
    -0.07078318f, 0.33502236f, -0.13081057f, -0.07295651f, 0.19575059f, -0.05763176f, -0.05881395f, -0.40183958f, 
    0.00189847f, 0.28050032f, 0.08420504f, -0.55984038f, 0.09120052f, 0.37067103f, 0.23281407f, -0.20721681f, 
    0.06082183f, -0.04026989f, -0.16931091f, 0.01191075f, -0.18472080f, 0.06379189f, 0.02032375f, -0.21209508f, 
    0.17409779f, 0.16384384f, 0.09018341f, -0.06587856f, -0.22322387f, -0.25821972f, 0.04623900f, -0.24137397f, 
    0.00860292f, -0.09693139f, -0.25439772f, -0.21664608f, -0.15255770f, 0.01448566f, -0.15285915f, -0.34063858f, 
    0.02711892f, -0.05262992f, -0.03887931f, 0.13657752f, 0.04249296f, -0.20697063f, -0.22572184f, -0.05034173f, 
    -0.05157155f, 0.04726556f, -0.08535281f, 0.19602582f, -0.03241009f, -0.20650974f, -0.08985236f, 0.13250706f, 
    0.44270450f, 0.12298460f, 0.02086169f, -0.04866334f, 0.00337404f, 0.23149393f, 0.57577914f, -0.08255051f, 
    -0.26028138f, -0.08784743f, 0.10732316f, 0.16449896f, 0.14771271f, -0.35634995f, -0.25948045f, -0.01054156f, 
    -0.15022945f, 0.26853612f, -0.02772403f, -0.15977034f, 0.05014231f, 0.36877874f, 0.22832766f, 0.35841945f, 
    -0.04540567f, -0.69470590f, 0.07977536f, -0.10138738f, -0.14769693f, -0.09085048f, -0.21379599f, -0.23012798f, 
    -0.17275803f, 0.40824169f, 0.05728893f, 0.29055062f, -0.05883155f, 0.45548612f, 0.28309721f, -0.36907274f, 
    -0.24307339f, -0.06157849f, -0.30530795f, -0.19849411f, -0.13139406f, -0.25005561f, -0.20767461f, 0.10244896f, 
    0.47192448f, -0.22897013f, 0.07271207f, 0.01578484f, 0.14282587f, 0.10066057f, 0.41481662f, -0.15371121f, 
    0.37376022f, -0.21909299f, 0.02791711f, 0.01038682f, 0.16940090f, -0.18032652f, 0.03227621f, -0.00723046f, 
    -0.42833528f, -0.24215463f, 0.23530360f, -0.14069195f, -0.03365444f, 0.24688348f, 0.21372136f, 0.34673253f, 
    0.18277039f, 0.01146066f, -0.02125327f, 0.10641710f, -0.08827862f, 0.33452258f, -0.40437645f, -0.43239161f, 
    0.40611252f, -0.36204332f, 0.23245214f, 0.12678331f, 0.20527145f, 0.38464931f, 0.07096064f, 0.00136484f, 
    -0.09663115f, 0.10959694f, -0.22615513f, 0.21158364f, 0.11193502f, -0.06668048f, -0.39843085f, -0.29225776f, 
    0.38626528f, -0.57869196f, -0.17953202f, -0.26093522f, -0.03975134f, 0.12881482f, 0.14212081f, 0.11255583f, 
    -0.19735976f, -0.14270312f, 0.56850827f, 0.02781641f, 0.24027348f, -0.06264080f, 0.30303368f, -0.06653664f, 
    0.51903957f, -0.42795986f, -0.23952398f, 0.34708503f, 0.13865645f, 0.14777833f, 0.05751524f, -0.28140479f, 
    0.34304485f, -0.16670349f, 0.21729372f, -0.12237122f, -0.01024568f, -0.38570303f, -0.26450083f, 0.24823642f, 
    0.30761126f, -0.02410041f, 0.20058411f, -0.55486721f, -0.11734670f, -0.12873948f, 0.46467957f, 0.03708344f, 
    -0.05330060f, 0.31428111f, 0.22988781f, -0.04658335f, -0.23190147f, -0.31636968f, -0.17659073f, 0.09638055f, 
    0.19203110f, -0.03460262f, -0.16811195f, 0.07333704f, 0.16026354f, -0.08559479f, 0.14753126f, -0.07467456f, 
    -0.24303733f, -0.19817939f, -0.19819039f, -0.16286433f, 0.13293859f, 0.02700582f, -0.18165115f, 0.10934351f, 
    -0.13226053f, 0.23483232f, -0.17688367f, 0.00172819f, -0.11808026f, -0.15246369f, -0.15022492f, -0.26467520f, 
    0.09525750f, -0.01270994f, -0.08592062f, -0.10340875f, 0.07465383f, -0.23837678f, -0.04399917f, 0.12082485f, 
    -0.03476688f, 0.06162539f, 0.04714447f, 0.01608791f, 0.14307627f, -0.19305822f, 0.18904059f, -0.00594822f, 
    -0.26067272f, -0.08963624f, 0.12374046f, -0.17482829f, 0.02385387f, -0.15303284f, -0.19619018f, -0.19748373f, 
    -0.03935353f, -0.16790651f, -0.04118288f, 0.76957411f, 0.16368181f, 0.35174784f, -0.06114936f, -0.08275309f, 
    0.24038902f, 0.03144084f, 0.06027844f, -0.20234969f, 0.22113320f, 0.05396906f, -0.49082932f, 0.15834752f, 
    0.03716229f, -0.32665125f, 0.05575984f, -0.62943137f, -0.16968641f, 0.11549830f, -0.59899670f, -0.06312013f, 
    0.21247205f, 0.27504471f, 0.08822917f, -0.08137263f, 0.11105287f, 0.05107092f, 0.24000835f, 0.11692756f, 
    -0.38195091f, 0.22681612f, -0.05035097f, -0.20218593f, -0.10836510f, 0.36968860f, 0.27072662f, -0.35507664f, 
    0.40299612f, -0.38134342f, 0.20341350f, -0.05463515f, 0.13120991f, -0.26733124f, -0.09930579f, 0.31747589f, 
    0.19538200f, -0.00510992f, -0.25627533f, -0.58323914f, 0.18315980f, 0.34243900f, -0.02225719f, 0.00974657f, 
    -0.16562995f, -0.29377514f, 0.11188617f, -0.13248527f, -0.23598038f, 0.39570552f, -0.11256249f, -0.22705799f, 
    -0.27195457f, -0.19972602f, 0.11971911f, 0.92529052f, -0.18970057f, 0.35679057f, -0.10695487f, 0.15256932f, 
    -0.30348814f, -0.12667267f, -0.00637666f, -0.10685000f, -0.02119485f, -0.33868989f, -0.03681878f, 0.36126032f, 
    0.00876474f, -0.22448692f, 0.23836842f, 0.04244399f, 0.22165939f, -0.11111858f, -0.22471422f, -0.05267343f, 
    -0.09894493f, -0.09279507f, -0.10240349f, -0.15781775f, 0.14792839f, -0.22313923f, -0.13375825f, 0.03384277f, 
    -0.02393116f, -0.11163969f, 0.10572458f, -0.43260139f, 0.01309507f, 0.15140909f, 0.20005384f, 0.48250821f, 
    0.11542384f, -0.24737461f, 0.29112965f, 0.09240558f, -0.22660309f, 0.25159180f, -0.08831251f, -0.69035220f, 
    0.23262119f, 0.10394512f, 0.18113969f, 0.64468372f, 0.01414203f, -0.03985037f, -0.18680269f, -0.02276019f, 
    -0.18531483f, 0.32917711f, 0.17809887f, 0.02791204f, -0.15456197f, -0.35811454f, 0.46435174f, -0.07553334f, 
    0.49735814f, 0.06875313f, 0.15304998f, 0.44983888f, -0.20600477f, 0.17488344f, 0.28426585f, -0.04623041f, 
    -0.15099847f, -0.18624385f, -0.03113011f, 0.00730081f, 0.00948739f, -0.11961016f, -0.37787947f, 0.19344060f, 
    -0.02422360f, 0.20783623f, 0.03857610f, -0.13986206f, -0.14328814f, -0.21533488f, 0.02950787f, -0.20443125f, 
    -0.04448330f, -0.23826596f, 0.10713921f, 0.00895780f, -0.24683508f, -0.24307032f, -0.10249019f, -0.22085094f, 
    -0.08581147f, 0.19293685f, -0.12737808f, -0.49917990f, -0.01576895f, 0.21242152f, -0.34200260f, -0.28340527f, 
    0.00405236f, 0.34200034f, -0.27893484f, -0.02329278f, -0.06251988f, -0.09939227f, 0.19293141f, 0.06600829f, 
    -0.21255289f, -0.47439510f, -0.19102712f, 0.35352650f, 0.24746442f, -0.12984870f, 0.24580015f, 0.45421243f, 
    -0.24057810f, -0.08032646f, 0.48630169f, -0.22510543f, -0.22826131f, -0.01642877f, -0.22092591f, -0.07966031f, 
    -0.09187735f, -0.05104959f, -0.11220756f, 0.12416145f, -0.19827652f, -0.05561081f, -0.21853456f, 0.15128882f, 
    0.07575539f, -0.19105634f, -0.10116449f, 0.12877175f, -0.20032167f, -0.09015359f, 0.09290443f, -0.21178819f, 
    -0.79684854f, -0.14528424f, 0.08340675f, 0.13723464f, 0.05166855f, -0.01694045f, -0.02601391f, 0.46999985f, 
    0.36203253f, 0.36159438f, 0.33077160f, -0.18619758f, 0.15475711f, -0.29191512f, -0.03536708f, -0.28723797f, 
    0.26760790f, 0.11826883f, -0.12439898f, 0.50434059f, 0.03618854f, 0.25497711f, -0.29270869f, 0.18890758f, 
    -0.13679157f, -0.19711219f, -0.21716352f, 0.21418887f, 0.06126902f, -0.19932984f, 0.57274961f, 0.27903584f, 
    0.11021212f, 0.20609017f, 0.00642998f, -0.43093944f, 0.06047913f, 0.17801733f, 0.42754942f, 0.03753171f, 
    -0.08370976f, -0.18518122f, 0.06370069f, 0.07332224f, 0.14619406f, -0.06166473f, -0.19321696f, -0.20469058f, 
    0.17822723f, -0.05948270f, -0.18092555f, 0.38149935f, 0.03912927f, 0.07972296f, -0.19527005f, 0.22185510f, 
    -0.45224866f, 0.24540566f, -0.04490432f, -0.22148487f, 0.02156117f, 0.10441413f, 0.10984014f, 0.01525667f, 
    -0.46348843f, -0.18205027f, 0.05651047f, -0.15724562f, 0.22606146f, -0.24899213f, 0.27544531f, 0.34017691f, 
    -0.19300607f, -0.03319081f, 0.32316601f, 0.13969597f, 0.19806981f, 0.23341882f, 0.53652185f, -0.51470673f, 
    0.31284159f, 0.35908726f, -0.09357975f, 0.34603369f, 0.03518945f, 0.48329234f, 0.54600012f, -0.30376893f, 
    -0.77235055f, 0.12064975f, 0.02282536f, 0.11193904f, 0.04137085f, -0.28213155f, -0.08210997f, -0.26460773f, 
    0.01668888f, -0.12598951f, 0.17951855f, -0.21663460f, 0.20743880f, 0.05690825f, -0.24833682f, -0.20604190f, 
    -0.22617263f, -0.16661811f, -0.11525641f, 0.19099790f, -0.14605632f, -0.18209973f, 0.05558567f, 0.09436192f, 
    0.14483762f, -0.29985902f, 0.24280193f, 0.07515308f, -0.17745245f, -0.26912364f, 0.15799800f, 0.04828895f, 
    0.29593301f, 0.24230868f, 0.16408052f, 0.02141187f, 0.19356263f, -0.03744695f, -0.31181645f, -0.54807562f, 
    -0.06579383f, 0.20528956f, 0.05080851f, 0.34247494f, -0.12108769f, 0.21695603f, 0.49996933f, -0.03086350f, 
    -0.40857166f, 0.16247593f, -0.00611108f, -0.14863971f, -0.13901943f, -0.65305614f, -0.35811776f, 0.20434906f, 
    -0.26498556f, 0.12645772f, -0.22640724f, 0.06785931f, 0.13935718f, 0.13468933f, 0.21707593f, 0.12619667f, 
    -0.25666836f, 0.16164602f, 0.19286609f, -0.05125370f, -0.22522680f, 0.44908017f, -0.43480295f, -0.50569075f, 
    0.02174723f, -0.18112728f, 0.03453583f, -0.59254634f, 0.14759536f, 0.40819377f, -0.00159104f, -0.15643561f, 
    0.28306597f, -0.32367700f, 0.18974164f, 0.14521018f, -0.12589470f, 0.24486148f, 0.64793772f, -0.35061064f, 
    -0.04152000f, 0.11776470f, -0.00867766f, -0.05934507f, 0.20034161f, -0.06779611f, 0.01056100f, -0.06583728f, 
    0.07036018f, 0.43363866f, 0.10296515f, -0.09612114f, -0.14337115f, -0.05941398f, -0.03244459f, -0.42559871f, 
    0.36140147f, 0.21479926f, -0.21885857f, 0.64846247f, 0.15614381f, 0.25910947f, -0.30658481f, 0.13546325f, 
    -0.33878174f, -0.16989276f, 0.11419443f, 0.20219900f, 0.04793208f, -0.14739943f, 0.15991218f, 0.07932344f, 
    0.03270443f, -0.12442515f, -0.24275860f, -0.56207955f, 0.01264554f, -0.36016986f, 0.52495748f, 0.15156178f, 
    -0.21482086f, 0.41742554f, 0.20590253f, -0.11486556f, -0.11351906f, 0.01839292f, -0.02677370f, 0.04716279f, 
    -0.41034254f, -0.31946602f, 0.22581314f, -0.19115137f, 0.13780141f, -0.00452424f, 0.11841782f, -0.11544810f, 
    0.35772350f, 0.09500894f, 0.19989286f, -0.16621631f, -0.08547096f, 0.28218755f, -0.23468578f, 0.27536744f, 
    0.10776293f, -0.24541664f, 0.17054674f, -0.23572963f, 0.09273487f, 0.08357158f, -0.05793238f, -0.07251722f, 
    -0.19984150f, -0.16222313f, 0.01442769f, 0.17992237f, 0.06304464f, -0.03614637f, -0.17124453f, -0.15202478f, 
    -0.73265052f, 0.06537925f, 0.22494382f, 0.14945564f, -0.10881229f, -0.21086381f, 0.02354971f, 0.77435893f, 
    -0.45193061f, -0.16332911f, 0.44023228f, -0.12608293f, -0.01965150f, -0.34030202f, -0.05003267f, -0.03608651f, 
    -0.32747841f, 0.21465094f, -0.20290524f, 0.09721594f, -0.09020508f, 0.30088320f, 0.23049524f, 0.26077917f, 
    0.04552882f, 0.01689586f, 0.07630010f, 0.05813841f, -0.10260968f, -0.10520116f, -0.32638878f, -0.40330255f, 
    -0.04084207f, 0.16142325f, -0.03517288f, -0.59976923f, 0.08861981f, 0.22028874f, -0.09183367f, -0.27086192f, 
    0.15440325f, 0.34286192f, 0.10205728f, -0.03103205f, 0.18033493f, -0.19610669f, 0.53681988f, 0.16146067f, 
    0.33161083f, -0.35460719f, 0.11052042f, -0.68651974f, -0.24365336f, 0.14804626f, 0.23192167f, -0.15192588f, 
    -0.26729122f, -0.01627689f, 0.34968802f, -0.06663808f, 0.20896229f, 0.14716406f, 0.62138629f, -0.19386746f, 
    -0.25980985f, 0.31398365f, -0.18533163f, 0.39122215f, 0.02264459f, 0.08126240f, 0.29849079f, -0.05986092f, 
    -0.60625637f, -0.32882041f, 0.28102526f, -0.23386262f, 0.14030595f, -0.48611405f, 0.31463242f, 0.23246694f, 
    0.32784039f, 0.21636133f, 0.22730085f, -0.11349683f, 0.20924044f, 0.31486908f, 0.04713884f, 0.07895181f, 
    -0.55035937f, -0.04693520f, 0.06068525f, 0.16028495f, 0.04912691f, -0.09121007f, 0.49201259f, -0.01899092f, 
    -0.16999783f, 0.08387827f, 0.00308663f, -0.11726051f, 0.08666921f, 0.21569978f, 0.23889561f, 0.09010607f, 
    -0.11082567f, 0.06830851f, 0.16876803f, -0.02773751f, -0.04118884f, 0.08804093f, -0.39846933f, -0.35692176f, 
    0.08564773f, -0.28500137f, 0.06077595f, -0.11330076f, -0.22379246f, 0.10105558f, -0.43670020f, 0.15661471f, 
    0.19167179f, -0.26828250f, 0.33280253f, -0.03760589f, 0.11974539f, 0.16176654f, 0.02220058f, 0.07779469f, 
    -0.09959519f, -0.29063505f, -0.15662745f, -0.43218097f, 0.08136401f, 0.20011248f, -0.25426292f, -0.25307462f, 
    -0.20776638f, -0.30126327f, 0.29604727f, 0.05180171f, -0.06863904f, -0.01432842f, 0.55936170f, 0.53909791f, 
    -0.46989438f, -0.18895906f, 0.09667899f, 0.13407043f, 0.12217641f, 0.27554637f, 0.07389444f, 0.40836832f, 
    -0.48438957f, 0.07915925f, 0.30788723f, -0.14269599f, 0.20200442f, -0.09422209f, -0.34171179f, -0.06273282f, 
    -0.33840656f, 0.01877117f, -0.12809800f, -0.29690316f, 0.21880284f, 0.22673076f, 0.33374995f, 0.48205739f, 
    0.01888703f, -0.44257081f, 0.43453792f, -0.03312527f, -0.12556721f, -0.11773781f, -0.27661604f, -0.36359107f, 
    -0.11556327f, -0.23628436f, -0.08681244f, 0.00803922f, -0.19493794f, -0.07114056f, -0.06097621f, 0.03133599f, 
    0.07794917f, -0.08733856f, -0.00746564f, 0.18267950f, -0.09298193f, -0.01677473f, -0.24483815f, -0.21243000f, 
    0.22396897f, 0.22710177f, 0.20615822f, -0.32958040f, 0.02542783f, -0.03981813f, 0.15521039f, 0.03789528f, 
    -0.34130412f, -0.27444372f, 0.24671043f, -0.11193815f, -0.12637071f, 0.01895813f, 0.25466171f, -0.04053350f, 
    -0.40767163f, -0.26040602f, -0.04658827f, -0.17573802f, 0.01377486f, -0.09905248f, -0.07371641f, 0.22732668f, 
    0.37804869f, 0.05281854f, 0.23990497f, 0.16758718f, 0.10562091f, 0.29126942f, 0.30947703f, 0.01874625f, 
    -0.05007122f, -0.03329072f, 0.05379474f, 0.53564775f, 0.22798145f, -0.12342431f, -0.04568261f, 0.04167342f, 
    0.06688676f, 0.19704027f, 0.21210554f, -0.00422030f, 0.07752323f, 0.10563045f, 0.06868595f, -0.15773104f, 
    -0.11730623f, 0.23862872f, -0.06018590f, 0.74911159f, -0.17237955f, -0.29151466f, -0.24776171f, 0.27210763f, 
    -0.01133378f, -0.21056789f, 0.20567198f, -0.08636034f, -0.03830896f, -0.12697141f, 0.15038109f, 0.33309287f, 
    -0.67361468f, 0.19915676f, 0.23824175f, -0.04852104f, 0.09246724f, 0.28341874f, -0.06461216f, 0.47273192f, 
    -0.04501290f, -0.55707544f, 0.34766507f, -0.23641439f, -0.05822165f, -0.20114519f, -0.33764350f, -0.05455615f, 
    0.33868673f, -0.02697547f, 0.08045775f, 0.29250368f, -0.22590545f, -0.11747412f, -0.20421414f, -0.11218590f, 
    0.08696652f, -0.05305493f, 0.25216034f, -0.22761083f, -0.09130949f, -0.22467178f, -0.26457968f, 0.17352806f, 
    0.17867818f, -0.26702899f, -0.20113562f, 0.55868477f, 0.24308026f, 0.05250442f, 0.21666488f, -0.35494199f, 
    -0.03725548f, 0.13399155f, -0.12095181f, 0.20150059f, 0.03630703f, -0.15266067f, 0.45972154f, 0.21245381f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10524976f, 0.25144771f, 0.42213458f, 0.43811965f, -0.25967106f, -0.26330528f, 0.03587715f, 0.02740283f, 
    0.06738344f, -0.04958570f, 0.16164745f, 0.20489004f, -0.23459880f, 0.33724633f, 0.18709216f, -0.18894422f, 
    0.40782282f, 0.03572472f, -0.31155783f, -0.19811951f, -0.03501509f, -0.14178890f, 0.12502290f, 0.16726373f, 
    0.00132054f, 0.36812222f, 0.11545663f, -0.21863222f, 0.36351302f, 0.17807302f, 0.33505806f, -0.00677203f, 
    -0.20006691f, -0.18435358f, -0.18444273f, 0.15374325f, 0.08927217f, -0.29307282f, -0.40788308f, 0.08475123f, 
    0.14693797f, 0.23571165f, 0.15515679f, 0.47105759f, 0.42491847f, 0.16051038f, -0.14822951f, 0.22384278f, 
    0.00447697f, -0.10749185f, -0.07283168f, 0.19196518f, 0.22890884f, 0.15072492f, 0.39671758f, -0.13261808f, 
    0.31764379f, 0.48121750f, 0.33234316f, 0.27488273f, -0.19364300f, -0.13789496f, -0.06404435f, -0.12482563f, 
    -0.11569555f, 0.17134613f, 0.28105715f, 0.04451549f, -0.15408841f, 0.22707649f, 0.19337068f, 0.11812939f, 
    0.18177825f, 0.25321484f, 0.35841227f, 0.50564611f, -0.12381084f, -0.21461892f, -0.19102986f, -0.25986299f, 
    -0.02937118f, -0.01154074f, 0.37614205f, 0.25883129f, 0.21113749f, -0.01282755f, -0.19049804f, 0.42419875f, 
    0.13985978f, -0.11213454f, -0.07892656f, 0.38818133f, -0.17138773f, -0.05287105f, 0.34327844f, -0.10724575f, 
    0.13138603f, 0.05106732f, 0.42769048f, 0.02820834f, -0.02722301f, 0.04888521f, 0.03516316f, -0.15067367f, 
    -0.03334543f, -0.01248780f, 0.15982395f, -0.04273650f, -0.09045613f, 0.39258394f, -0.01121904f, -0.11930075f, 
    0.21336082f, 0.47284797f, 0.05853242f, -0.31966335f, -0.14225295f, -0.16406837f, 0.19589177f, 0.50284582f, 
    0.08494593f, 0.31221792f, -0.03145884f, 0.26459160f, -0.19244260f, 0.43673694f, 0.10114092f, 0.28140789f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.27296370f, 0.20424096f, -0.19754905f, -0.36624295f, 0.28391913f, 0.12029006f, 0.03289120f, 0.21464455f, 
    0.37369025f, -0.12035083f, 0.12356336f, 0.19698508f, 0.17381500f, -0.02736965f, 0.02019399f, 0.13648935f, 
    -0.27616537f, -0.05123536f, 0.07662760f, 0.14918354f, 0.26042268f, 0.02242981f, -0.01440018f, 0.28749248f, 
    -0.02215810f, -0.31616357f, -0.36850330f, 0.03045804f, -0.84825885f, 0.21444757f, -0.25534776f, -0.46713567f, 
    -0.02967749f, -0.90455604f, 0.00959059f, -0.02623005f, 0.15200657f, 0.04356492f, -0.36687794f, 0.25806624f, 
    -0.07583928f, 0.22842805f, 0.27707615f, -0.36427030f, -0.11712550f, 0.20731039f, 0.00044595f, 0.15090923f, 
    -0.47462606f, 0.34889728f, 0.03834411f, -0.42258969f, -0.51694453f, -0.06646504f, -0.08561356f, 0.00344867f, 
    0.01296249f, -0.35229269f, -0.03057129f, -0.16137892f, -0.04726069f, 0.00878125f, 0.01426006f, 0.23502016f, 
    -0.22501183f, -0.06107706f, -0.50015783f, 0.07107373f, -0.79830915f, -0.84280777f, -0.24932301f, -0.18204458f, 
    -0.12862946f, -0.51635325f, -0.09673498f, -0.55896652f, -0.28194156f, 0.01055697f, -0.11325666f, 0.02775550f, 
    -0.16379736f, 0.10547125f, 0.06348338f, -0.43881276f, -0.15299664f, -0.04052605f, -0.50636232f, 0.13850139f, 
    -0.36558315f, -0.01888885f, 0.02465437f, -0.74914342f, 0.06530558f, -0.32540414f, 0.11327200f, -0.08867364f, 
    -0.23509017f, 0.13935705f, -0.34485924f, -0.05613716f, -0.44310406f, -0.41944268f, -0.56529778f, 0.22234325f, 
    -0.12206214f, -0.04950795f, -0.51008135f, -0.00838116f, -0.03079549f, -0.59289604f, -0.34575388f, 0.18945175f, 
    0.20031498f, 0.11590660f, 0.00350282f, -0.07074895f, -0.04572002f, 0.24958746f, -0.87549502f, -0.37707210f, 
    0.05078391f, -0.04821329f, 0.25971246f, -0.00948756f, 0.23912825f, -0.46650264f, -0.11896534f, 0.20102319f, 
    -0.08031480f, -0.16076180f, 0.03365004f, 0.50191647f, -0.46245289f, 0.01340117f, -0.08090498f, 0.46239376f, 
    0.49208921f, -0.04192449f, 0.12368096f, 0.05517795f, 0.04477345f, -0.14512229f, 0.02664289f, 0.01460260f, 
    0.53452533f, -0.12566784f, 0.23961711f, -0.43873483f, 0.14168446f, -0.04848449f, -0.08107892f, 0.10133936f, 
    -0.82468492f, 0.21405225f, -0.12382594f, 0.01723557f, 0.02912287f, 0.05734994f, -0.11792779f, -0.11749393f, 
    -0.14192769f, -0.08593236f, -0.02194119f, 0.21187207f, -0.21617936f, -0.04558794f, -0.15549743f, -0.94058442f, 
    0.28722569f, -0.00749854f, -0.95629489f, -0.00214893f, 0.10194092f, 0.12304984f, 0.00891235f, 0.14062141f, 
    -0.26385954f, 0.12869889f, 0.08612497f, 0.28890061f, -0.34838119f, 0.06512869f, 0.15753867f, -0.03050059f, 
    0.19280681f, 0.06995147f, 0.20328356f, 0.11190096f, 0.00617788f, -0.04029275f, -0.03449261f, -0.10328896f, 
    -0.19913268f, -0.11918730f, 0.09943640f, 0.00601838f, -0.31042761f, -0.35148740f, -0.54623598f, -0.12857281f, 
    -0.25725093f, 0.25204310f, 0.23837574f, 0.72342700f, 0.01488836f, -0.00732491f, -0.06321401f, 0.00299956f, 
    -0.07109984f, 0.18160538f, -0.13524836f, -0.03284730f, -0.06709695f, 0.04348703f, -0.14560319f, 0.08404896f, 
    -0.04330164f, 0.02653890f, 0.13641977f, 0.17976986f, 0.01588658f, 0.09769454f, -0.06235506f, -0.13493845f, 
    0.07763760f, 0.04647586f, -0.69644350f, -0.01262396f, 0.11541707f, 0.04270826f, -0.20521960f, -0.13327357f, 
    0.08248703f, -0.05202323f, 0.08253507f, 0.02350233f, 0.07710187f, 0.07856565f, -0.20192160f, 0.09637172f, 
    0.08902453f, -0.04646182f, -0.01996895f, -0.37215465f, 0.10876007f, 0.28769588f, 0.09050734f, -0.04180372f, 
    0.00936718f, -0.04973562f, 0.14329158f, 0.03538158f, 0.09839290f, -0.02796825f, -0.10974944f, -0.00707057f, 
    0.22204928f, -0.35738173f, -0.03849044f, -0.63888907f, -1.28133440f, -0.05532458f, -0.14555657f, -1.00887454f, 
    -0.53769565f, 0.20026450f, -0.52265459f, -0.04655474f, -0.16992302f, 0.08034401f, 0.02728317f, 0.15406851f, 
    -0.71918291f, 0.18706052f, 0.11174721f, -0.53211403f, 0.13222179f, 0.01621363f, 0.20082356f, -0.20315038f, 
    -0.19611119f, -0.00506622f, -0.02859182f, -0.14351149f, 0.59275424f, -0.60854071f, -0.02185586f, 0.19721904f, 
    0.26723388f, 0.35555211f, -0.03769459f, 0.12925196f, 0.04788659f, 0.36317733f, -0.14395069f, -0.28462711f, 
    -0.41071489f, 0.05424971f, -0.29655704f, -0.53906471f, -0.00442333f, -0.08478672f, -0.09769911f, -1.13700700f, 
    0.40075654f, 0.10463642f, 0.08369652f, 0.25948325f, 0.23021491f, -0.14304902f, -0.08852307f, -0.03943733f, 
    0.03731297f, 0.01775067f, -0.05793012f, 0.20048347f, -0.05065094f, -0.03835316f, 0.00658197f, -0.57279503f, 
    -0.09607249f, -0.20320697f, -0.16823381f, 0.05926089f, -0.27222770f, -0.05811194f, -0.08150456f, -0.14540826f, 
    -0.18725717f, -0.42521763f, -0.11103391f, 0.13753870f, 0.11056338f, 0.03331266f, 0.17106341f, -0.07032339f, 
    0.04888194f, 0.02290137f, 0.11397635f, -0.32730854f, 0.37925288f, 0.00707410f, -0.28243417f, 0.11129927f, 
    0.09607355f, -0.07935136f, 0.01594847f, 0.35611871f, -0.03390104f, 0.35018340f, -0.01780131f, -0.01772475f, 
    -0.12128472f, -0.07689539f, -0.11490413f, -0.00799006f, -0.21225742f, 0.22909698f, -0.18661565f, -1.32566273f, 
    -0.03990658f, 0.14486066f, -0.16811192f, -0.16602845f, 0.04000825f, 0.84588408f, 0.04790685f, -0.14473604f, 
    -1.07642257f, 0.25210938f, -0.02916913f, -0.12834765f, 0.13001853f, -0.46433914f, 0.17665456f, 0.29548609f, 
    0.03536112f, 0.03525985f, -0.18146904f, 0.03750381f, 0.38688749f, 0.46689999f, 0.04339731f, -0.15703805f, 
    -0.18096748f, -0.43333131f, -1.34803450f, -0.33009332f, -0.07504183f, -0.14129923f, 0.13968413f, -0.04641281f, 
    -0.43354067f, 0.39534321f, -0.08945519f, 0.14707102f, -0.22225250f, 0.28290340f, -0.01239813f, -0.09386484f, 
    -0.89061517f, 0.19686496f, -0.41638041f, 0.38576299f, -0.26055926f, -0.03684504f, 0.50371516f, -0.33231321f, 
    0.25456619f, -0.06022516f, -0.27471006f, -0.00625277f, -0.27991110f, 0.00075829f, -0.42318058f, 0.25528759f, 
    0.56573164f, 0.05907423f, -0.07509556f, 0.10380739f, 0.29486722f, 0.07101898f, 0.82795596f, -0.44560617f, 
    0.26518509f, 0.02054242f, 0.11623909f, -0.29134774f, -1.32716715f, -0.10302711f, -0.18959220f, -0.11014719f, 
    -0.05272525f, -0.08068168f, 0.10027228f, -0.02678945f, -0.67179912f, -0.38628751f, -0.50854123f, 0.01230960f, 
    -0.82529986f, -0.19716740f, -0.82872176f, -0.72719061f, 0.00970279f, 0.00784043f, -0.08585328f, -0.61333817f, 
    -0.18089169f, 0.28162327f, -0.02128399f, 0.03756857f, 0.01132185f, 0.29879618f, 0.27226278f, 0.06709366f, 
    0.19894558f, 0.19746122f, 0.02472408f, 0.26002809f, -0.20385417f, 0.04869807f, -0.01673978f, 0.01792091f, 
    0.26356420f, 0.64833021f, 0.25892690f, 0.29768348f, -0.01375638f, -0.07947598f, 0.03587904f, -0.42186165f, 
    0.18470438f, -0.01204392f, -0.88776177f, -0.32680511f, -0.00204663f, -0.40773508f, -0.07410161f, 0.09716684f, 
    -0.30328152f, -0.30868042f, 0.10395291f, 0.04145062f, 0.10601661f, 0.11275081f, 0.07403838f, 0.06713904f, 
    -0.11576811f, 0.00432395f, -0.74375027f, 0.15151736f, 0.05890445f, -0.51399028f, 0.07349434f, 0.04315488f, 
    -0.00510940f, 0.07140378f, 0.03058785f, 0.24203777f, 0.24260449f, 0.12907614f, -0.14257440f, 0.11001232f, 
    0.05400630f, 0.02338303f, -0.03837955f, -0.24971163f, -0.32403973f, 0.18646115f, -0.11959958f, -0.07088382f, 
    0.03955839f, 0.40337768f, -0.07540551f, 0.33487895f, -0.11335205f, 0.12441236f, -0.31614110f, -0.22865221f, 
    -0.23379026f, -0.13367036f, 0.02449594f, 0.07148754f, -0.02390318f, -0.44557062f, 0.00345583f, 0.22159050f, 
    0.23168357f, -0.05621320f, -0.13303837f, -0.36304420f, 0.04131183f, -0.15216622f, -0.06078863f, -0.21558513f, 
    0.14462683f, -0.70753270f, 0.08809669f, -0.22830108f, 0.01734779f, 0.18604556f, -0.01978904f, -0.12171147f, 
    0.06382611f, -0.40953198f, 0.06678706f, 0.14407778f, 0.16257675f, -0.07630239f, -0.11707950f, 0.37071171f, 
    -0.18370876f, 0.02113948f, 0.08860643f, 0.01306554f, -0.04134918f, 0.13142298f, 0.15212536f, -0.11169760f, 
    -1.02004230f, 0.01891863f, 0.01609260f, -0.29075557f, 0.01697796f, 0.06642116f, -0.07322855f, -0.09659407f, 
    -0.00307842f, -0.09833924f, -0.19240817f, -0.12296202f, -0.05175266f, -0.07077289f, -0.00951151f, 0.01445905f, 
    -0.08776415f, 0.08187779f, 0.04884516f, 0.03095705f, 0.20254104f, -0.04793495f, -0.02363376f, 0.28218484f, 
    -0.30880052f, -0.14175378f, -0.01667401f, -0.40265691f, 0.17974471f, -0.01924749f, -0.30349708f, 0.06171580f, 
    -0.26045093f, 0.00730684f, 0.09106818f, -0.02926029f, -0.24995162f, 0.02677121f, -0.03238240f, -0.06363211f, 
    0.01767121f, 0.03971733f, -0.12915002f, -0.20086642f, -0.02759496f, -0.15058357f, -0.06430881f, 0.05876449f, 
    -0.03117636f, 0.10817140f, 0.07319781f, 0.01541377f, -0.06501810f, 0.13552417f, -0.39153242f, -0.01520759f, 
    -0.09699417f, -0.08665308f, 0.33055905f, -0.09745045f, 0.03675876f, -0.12690419f, 0.08161518f, 0.14645579f, 
    -0.02106026f, 0.15413176f, 0.14333145f, -0.38428888f, -0.18167646f, -0.00693896f, -0.26681730f, -0.03187041f, 
    -0.06171334f, 0.08289150f, -0.01008347f, -0.01870568f, -0.05441003f, -0.17257455f, -0.23850180f, 0.06049650f, 
    -0.16584328f, 0.22373007f, 0.00177890f, -0.58504850f, 0.09783742f, -0.19373713f, -0.16168118f, -0.00706660f, 
    0.07327919f, -0.18145032f, 0.21645975f, -0.00753036f, 0.00038333f, -0.10108930f, 0.05872624f, -0.02813548f, 
    -0.55100220f, -0.04094790f, 0.18031196f, 0.22301295f, -0.10949010f, -0.08350711f, -0.30491763f, 0.26571047f, 
    -0.13859937f, 0.18713479f, 0.05271532f, -0.02024028f, 0.05454409f, 0.07660845f, 0.16820443f, -0.48563376f, 
    -0.34319255f, -0.46130487f, 0.01281245f, 0.00408228f, -0.12219531f, -0.19296257f, -0.17327654f, 0.27398625f, 
    0.11826743f, -0.08116627f, 0.09721548f, 0.35883847f, -0.03659788f, -0.06222256f, -0.01448919f, 0.24002011f, 
    0.09315820f, 0.04635715f, -0.35144719f, -0.14382048f, 0.01496407f, 0.13656877f, 0.02281101f, -0.10485866f, 
    -0.01903072f, 0.02532684f, 0.00954112f, -0.00892003f, 0.02131542f, 0.02729600f, -0.04058714f, -0.12975281f, 
    -0.01863637f, 0.07447305f, -0.19115239f, -0.05690774f, -0.38707432f, 0.11334185f, -0.46611798f, -0.12965567f, 
    0.05762422f, 0.04551950f, 0.04750980f, -0.32078442f, -0.41592377f, -0.04274744f, -0.13533688f, 0.04603799f, 
    -0.12391230f, 0.02190134f, -0.08865821f, 0.09431306f, -0.05511542f, -0.03036841f, 0.09321497f, 0.11272069f, 
    -0.20748696f, -0.09500761f, 0.30256495f, -0.05886625f, -0.07605778f, -0.02296424f, 0.09453408f, -0.06420697f, 
    0.04899268f, 0.18354937f, 0.13379733f, 0.06095454f, -0.75273782f, -0.40917507f, 0.07127423f, -0.02409496f, 
    -0.12234203f, 0.11617837f, -0.28117383f, -0.00974772f, 0.02208914f, 0.27426168f, -0.00520132f, 0.02719774f, 
    0.00652421f, 0.05598982f, 0.13637474f, 0.12754352f, -0.03013620f, -0.04099947f, 0.06460568f, 0.12716667f, 
    -0.05982476f, 0.09710220f, -0.01341739f, -0.01661577f, -0.06336742f, 0.11575908f, 0.09419067f, -0.01851797f, 
    0.19581342f, -0.01045114f, 0.07366193f, 0.25273386f, -0.30558389f, -0.18940906f, 0.05682413f, -0.13219589f, 
    -0.53315187f, -0.04188323f, -0.73917794f, 0.00364155f, 0.01921977f, 0.17011435f, 0.01202443f, -0.16831677f, 
    -0.16604200f, 0.07724313f, 0.17543994f, -1.05837274f, -0.05526889f, -0.03513900f, -0.01748949f, 0.09834750f, 
    -0.06461073f, -0.05394061f, 0.13981190f, 0.11481807f, -0.72544080f, -0.55708134f, 0.13017090f, 0.53588539f, 
    -0.14359349f, 0.43124959f, 0.05104259f, -1.03505647f, -0.13650036f, -0.21987015f, 0.10397030f, -0.29749975f, 
    0.17388600f, -0.13466975f, 0.12591332f, -0.79069656f, 0.28381166f, -0.10832876f, -0.11152997f, -0.94952792f, 
    0.12638168f, -0.30936766f, -0.33318919f, -0.08926567f, 0.26353642f, -0.01550038f, -0.66010904f, 0.01682216f, 
    0.08941509f, 0.10035163f, -0.05485876f, -0.14525309f, -0.07450197f, -0.07075257f, -0.05799518f, -0.49550822f, 
    0.23872529f, -0.03582348f, -0.25766537f, -0.00676465f, 0.17573828f, -0.75303423f, 0.26164544f, -0.24934931f, 
    -0.34720793f, 0.34470820f, -0.46787491f, -0.26140368f, -0.04040270f, -0.05054355f, -0.06931356f, -0.02073060f, 
    0.17392601f, -0.39550009f, -0.56786734f, -0.23509331f, 0.37511942f, -0.01673273f, -0.61468166f, 0.16440314f, 
    0.25606763f, 0.03513961f, -0.28320950f, 0.05922986f, -0.01860083f, -0.32910568f, 0.05564809f, 0.01554159f, 
    0.21886872f, -0.68861443f, 0.50161785f, -0.03707222f, -0.18802878f, 0.25566819f, 0.08883650f, -1.14364958f, 
    0.10752280f, 0.22082025f, 0.02863863f, -0.12544847f, -0.08127459f, -0.38837206f, 0.06239849f, -0.13157122f, 
    -0.47619027f, -0.13309476f, 0.11321274f, 0.00671029f, -0.16824687f, -0.81462282f, 0.27565894f, -1.29192257f, 
    -0.04559293f, -0.19583423f, -0.60098904f, 0.12693653f, 0.08402973f, -0.99726892f, -0.09655305f, 0.21897942f, 
    -0.07524525f, -0.15588512f, -0.19198057f, 0.03409044f, -0.38585433f, 0.07946989f, 0.08528014f, -0.50844324f, 
    -0.09155757f, -0.01031060f, -0.13417925f, 0.00537275f, 0.16729718f, -0.30296189f, -0.01301683f, 0.09155153f, 
    0.16856661f, -0.05696503f, -0.09178901f, 0.60207236f, 0.24638504f, 0.06180667f, -0.07926893f, 0.04863977f, 
    0.29150963f, -0.66670239f, -0.17998549f, 0.09197041f, -0.36900389f, -0.59006894f, -0.16851789f, 0.21537136f, 
    -0.00015547f, -0.32598618f, -0.03447171f, -0.73189920f, -0.01106421f, 0.62527412f, 0.16953936f, 1.04187906f, 
    -0.15815194f, 0.09056001f, 0.40494511f, 0.23825130f, -0.08725159f, 0.10849570f, 0.03802726f, 0.43604803f, 
    0.07609586f, 0.07150234f, 0.52500796f, 0.04694284f, 0.26483348f, 0.10262783f, 0.25798008f, -0.14100488f, 
    -0.16345082f, -0.10838582f, 0.16266777f, -0.14230354f, -0.03631686f, -0.01687500f, -0.04718046f, 0.17357074f, 
    0.00476936f, 0.07051795f, -0.02291395f, -0.03170330f, -0.26308239f, -0.66755557f, 0.13363822f, 0.01622042f, 
    0.34182858f, -0.23574269f, -1.54278386f, -0.04384591f, 0.03678056f, 0.02762352f, 0.03600120f, -0.04883751f, 
    0.06198314f, 0.01272236f, 0.55439895f, 0.03933829f, -0.03240634f, -0.08002188f, 0.32127655f, -0.36469772f, 
    -0.25872430f, -0.05113201f, -0.09229085f, -0.49245811f, 0.01775963f, 0.33520204f, -0.57442331f, -0.11597690f, 
    -0.19359963f, -1.05065727f, -0.62381601f, 0.01970201f, -0.28725111f, 0.37184671f, 0.05757250f, 0.36515161f, 
    0.08867846f, -0.68006194f, 0.20764668f, 0.32839671f, -0.03474654f, -0.75271451f, 0.00031271f, 0.12357991f, 
    -0.94824165f, -0.03183171f, -0.68271559f, 0.14879291f, 0.11564298f, -0.59097308f, -0.67820710f, -0.37456331f, 
    0.00992811f, -0.22160593f, 0.27691889f, -0.01328430f, -0.26385725f, -0.86314374f, -0.07528928f, 0.04970279f, 
    0.16831926f, 0.02920965f, 0.04063379f, 0.00667203f, -0.23971222f, 0.03176454f, 0.18490618f, -1.22756982f, 
    0.29667959f, 0.00445505f, -0.09882122f, -0.03934686f, 0.05715102f, 0.40082264f, -0.07400975f, -0.47758350f, 
    -0.69120353f, 0.06065731f, 0.21294542f, 0.60269201f, -0.09925742f, 0.06864993f, -0.01963484f, 0.14077751f, 
    -0.32129562f, 0.21544188f, 0.12196969f, 0.16052255f, 0.26211002f, -0.70869261f, -0.07231743f, -0.50543022f, 
    0.05613397f, -0.03319512f, 0.04586410f, -0.56139606f, -0.35710374f, 0.32633200f, 0.09604046f, 0.58337682f, 
    0.00596425f, -0.13610688f, -0.14289217f, 0.07712871f, -0.15468998f, -0.06901406f, -0.12401004f, 0.09986968f, 
    0.24399298f, -0.08856755f, -0.19344673f, 0.29288727f, 0.44163001f, -0.21476653f, 0.14660791f, 0.03928293f, 
    -0.32142869f, -0.03738237f, -0.05607408f, -0.00435849f, 0.03456777f, -0.03377803f, 0.21922410f, -0.18352582f, 
    0.07748450f, -0.16928290f, -0.22652717f, 0.05563613f, -1.17092454f, 0.09516764f, -0.53026617f, 0.02634201f, 
    0.28727686f, 0.12759712f, -0.21191281f, -0.07207713f, -0.46468917f, 0.01230438f, -0.13359272f, -0.04975593f, 
    0.17422274f, -0.15534610f, -0.43685478f, 0.02223911f, -0.00235830f, -0.03512052f, 0.22623464f, -0.22039367f, 
    0.05067389f, 0.00914779f, -0.24178813f, 0.15321194f, 0.04677127f, 0.35349756f, -0.09721530f, -0.06862474f, 
    0.05993319f, 0.08963610f, -1.22482955f, -0.07356428f, 0.17364061f, -0.97875416f, 0.23040357f, -0.03196770f, 
    -0.01209559f, -0.08201038f, -0.34889680f, 0.24649501f, -0.03326835f, -0.12991108f, 0.15488712f, -0.47601652f, 
    -0.85340255f, -1.06627333f, -0.28383237f, 0.02089946f, 0.19597089f, -0.29453108f, 0.05240360f, 0.05982798f, 
    0.01919542f, -0.22737253f, 0.24631973f, 0.18314300f, 0.13495372f, 0.09319253f, -0.09510925f, -0.29403046f, 
    0.15146011f, -0.55484921f, -0.14301850f, -0.13120103f, -1.76730847f, 0.02139088f, -0.27101019f, -1.20676577f, 
    -0.29742524f, 0.11888041f, 0.24754913f, -0.47090307f, -0.28153887f, 0.20555489f, -0.00297322f, 0.07810914f, 
    0.36046711f, -0.09938480f, -0.07740718f, -0.34116265f, -0.18908387f, -0.02455204f, 0.16486824f, -0.39074689f, 
    0.19073194f, -0.35457373f, 0.12211081f, -0.09236665f, -0.13865098f, -0.92777240f, 0.14385898f, 0.02982619f, 
    0.27409431f, -0.12153395f, 0.01208691f, 0.24540375f, 0.27198291f, -1.07493186f, -0.25571999f, -0.88256741f, 
    -0.26725009f, -0.35631293f, -0.16045743f, 0.21334787f, 0.24964702f, -0.16757727f, -0.18647812f, -0.33262891f, 
    -0.65951157f, -0.18072595f, 0.36384410f, -0.03556997f, -0.13946372f, -0.07232996f, -0.45079657f, 0.04320414f, 
    -0.23508449f, 0.10387098f, -0.57329655f, -0.02189457f, 0.06361923f, -0.02255637f, -0.13280323f, -0.84175265f, 
    -0.03012541f, 0.08664941f, -0.29944679f, 0.06914200f, 0.31135160f, -0.04630477f, 0.19215545f, 0.37503737f, 
    -0.29614830f, 0.18982401f, 0.17323621f, 0.58563054f, 0.17402609f, -0.02567605f, 0.00736746f, -0.02175964f, 
    0.11315158f, -0.06588311f, -0.14665399f, 0.15615103f, 0.09279766f, -0.07707073f, 0.05768837f, 0.11226964f, 
    0.30744287f, -0.06605621f, -0.28319752f, -0.00006658f, 0.02531682f, -0.97148901f, 0.21195453f, 0.11029688f, 
    0.10499573f, -0.07656316f, 0.38898939f, 0.07957806f, 0.08160291f, 0.08912195f, -0.13629453f, -0.22252728f, 
    -0.08883563f, 0.15191104f, 0.03999580f, -0.64844644f, 0.00333750f, -0.56832570f, -0.09434358f, -0.00279166f, 
    0.10543039f, 0.27345923f, 0.19065294f, -0.13261335f, -0.06250855f, -0.10521614f, -0.18163446f, -0.06159738f, 
    0.01352254f, 0.24559234f, -0.55570203f, -0.04560518f, 0.11823253f, -0.13581388f, 0.12796615f, 0.30639225f, 
    0.10003824f, -0.57441729f, -0.03489149f, -0.42084619f, -0.72621489f, -0.05070185f, 0.01653309f, -0.18448134f, 
    -0.44791228f, 0.03280224f, 0.10213083f, -0.04254055f, -0.21773668f, -0.69329649f, -0.06052426f, 0.20049764f, 
    0.76394141f, -0.06102179f, 0.13833788f, -0.10212467f, -0.02449385f, -0.02357117f, -0.30772746f, -0.31851715f, 
    -0.10168094f, -0.05664031f, 0.10820636f, -0.14763558f, 0.43822858f, 0.09036674f, 0.04378913f, -0.28650731f, 
    0.12551744f, -0.08025005f, -0.00143397f, -0.38472560f, -0.31475449f, -0.29245126f, -0.32164222f, -0.13722073f, 
    0.07034011f, -0.25933310f, -0.35756952f, 0.25463778f, -0.57779688f, 0.27199993f, 0.26564270f, 0.12212747f, 
    -0.07970750f, -0.78809124f, -0.56957692f, -0.09218558f, 0.02259076f, -0.00691291f, 0.29621714f, -0.01861478f, 
    -0.66862339f, -0.05737320f, -0.00467000f, -0.91638863f, -0.01709414f, -0.02727248f, 0.44535470f, 0.51686323f, 
    -0.21014182f, 0.03448878f, -0.10351943f, -0.01403297f, 0.23190723f, 0.23530105f, -0.57967460f, 0.15994118f, 
    0.24485670f, -0.50460041f, 0.08047401f, -0.72373635f, 0.29407743f, -0.08895118f, 0.04284210f, -0.01160602f, 
    -0.17907281f, -0.76978898f, -0.07056276f, 0.16740146f, -0.75611919f, 0.06249938f, 0.28488547f, -0.58683699f, 
    -0.08615100f, 0.03456485f, -1.47035968f, 0.28627539f, -0.09108918f, 0.11319580f, -0.99098957f, 0.14048544f, 
    -0.14639272f, 0.31258762f, -0.20863096f, -0.08377486f, -0.67833006f, -0.18299401f, 0.31015068f, -0.25973690f, 
    -0.00249405f, -0.32930216f, 0.56146216f, 0.04741382f, -0.04028474f, 0.24874389f, 0.01948434f, -0.38549450f, 
    0.09039508f, -0.37644014f, -0.09423440f, 0.32019782f, -0.14639241f, -0.35064733f, 0.13608721f, 0.22224969f, 
    -0.08098486f, 0.16813017f, 0.05660023f, -0.08053999f, -0.44240066f, 0.03936131f, -0.07529098f, -0.47879028f, 
    -0.05488577f, 0.47102541f, 0.07685853f, 0.22051494f, -1.88640773f, -0.12243253f, 0.27609900f, 0.18310699f, 
    -0.07544799f, -0.07816865f, -0.59433275f, -0.47878236f, 0.12311584f, -0.11016273f, 0.00257984f, -0.41719282f, 
    0.35361990f, -0.40822300f, -1.04349899f, 0.43385687f, -0.33527979f, -0.06837943f, 0.01512918f, 0.20231350f, 
    0.10779774f, 0.02314650f, 0.14257346f, -0.12630022f, -0.18159871f, -0.73914069f, 0.10545684f, 0.24069220f, 
    -0.61101884f, -0.08374555f, -0.11181676f, -0.11263348f, -0.19985333f, 0.02754620f, -0.07216619f, -0.67972702f, 
    -0.25820979f, -0.51307505f, 0.49143475f, 0.28971070f, 0.08567123f, -0.36242586f, -0.18476516f, -0.22332227f, 
    0.21601786f, -0.29167566f, -0.50844425f, -0.09366922f, -0.12454807f, -0.26791489f, 0.10412920f, -0.00051206f, 
    -0.75038445f, 0.14415482f, 0.29627594f, 0.29031634f, 0.06715196f, -0.08115918f, -0.66804075f, 0.19669744f, 
    0.22232969f, 0.19073009f, -0.43817547f, 0.00007397f, -0.19750103f, 0.61187029f, 0.49958143f, -0.85720772f, 
    0.12008578f, -0.18525209f, -0.43036705f, -0.82731789f, 0.02703488f, -0.08520987f, -0.31109130f, -0.04274755f, 
    -0.01636055f, 0.00318151f, 0.20827927f, -0.10814203f, 0.12861572f, 0.05032172f, 0.03547943f, 0.00405284f, 
    -0.14414802f, 0.02052653f, 0.05495178f, -0.01633425f, 0.06179236f, 0.28899205f, -0.21687582f, 0.04209881f, 
    0.07382652f, -0.73480797f, 0.31634986f, -0.02487476f, 0.26675224f, 0.17613904f, 0.32672185f, -0.65548551f, 
    0.22658257f, -0.06574371f, 0.03666186f, -0.12839812f, -0.01295950f, 0.03018611f, 0.17370619f, 0.08020669f, 
    -0.88136280f, 0.24388242f, 0.04243010f, 0.17954132f, -0.33484849f, -0.02484659f, 0.19579962f, 0.09119695f, 
    0.07627779f, -0.01962924f, -0.23225720f, 0.07136280f, -0.45473304f, 0.45327789f, -0.28945234f, -0.20613424f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14877436f, 0.21032293f, -0.08605354f, -0.06468416f, -0.12998495f, -0.00468981f, -0.13925253f, -0.33141613f, 
    -0.06065163f, 0.08660422f, -0.06820926f, 0.00319900f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
