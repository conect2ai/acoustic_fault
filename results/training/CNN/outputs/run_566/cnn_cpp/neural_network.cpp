#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.44720373f, -0.55088437f, -0.92343700f, -0.65404022f, 0.05304803f, 0.81211317f, 0.24005915f, 0.31217778f, 
    0.46507600f, 0.40428680f, -0.34879217f, -0.03338350f, -0.52883947f, -0.07755733f, 0.02743700f, 0.10147391f, 
    -0.18990724f, -0.32713285f, -0.14033662f, 0.01314767f, -0.11573110f, -0.15938029f, 0.13687259f, -0.00692188f, 
    -0.17865391f, 1.17973137f, 0.78055429f, -0.20735905f, 0.55217957f, -0.07883053f, -0.35829136f, 0.23723823f, 
    -0.24655992f, 0.53372467f, 0.21083340f, -0.07179593f, -0.14472422f, -0.12392173f, 0.06016817f, -0.00261878f, 
    0.03318215f, -0.06849401f, -0.29997265f, -0.20093888f, 0.10269599f, 0.04873739f, 0.07212450f, 0.02480242f, 
    -0.02994818f, 0.08860447f, 1.13607478f, 0.74298787f, 0.77531248f, -0.42654938f, -0.57498455f, 0.10826782f, 
    -0.33948055f, -0.11745214f, 0.08109079f, 0.65855002f, 0.29361942f, 0.32279813f, 0.13520628f, -0.01695392f, 
    -0.01215662f, -0.00219103f, -0.02919997f, 0.07965159f, 0.00928573f, -0.17757450f, 0.31140122f, 0.21441083f, 
    0.12144548f, 0.18165897f, 0.07278972f, 0.61126715f, 0.06054864f, 0.18490694f, 1.03422427f, 0.36243805f, 
    0.54165179f, 0.59505421f, 0.07691611f, -0.36133423f, 0.16582656f, -0.20451903f, -0.06488542f, -0.35755506f, 
    0.00535194f, -0.20209360f, -0.29392967f, -0.23158084f, -0.07102698f, -0.12872395f, -0.28892708f, -0.19914928f, 
    -0.22568563f, -0.51533985f, -0.02814160f, 0.03992791f, -0.55493397f, -0.43967551f, -0.56576151f, -0.63768011f, 
    -0.10943040f, -0.34845650f, -0.22285201f, -0.16123915f, 0.60435420f, -0.57130015f, -0.21607772f, -0.20185603f, 
    -0.40724754f, 0.08790909f, -0.17828056f, -0.07168277f, 0.37525892f, -0.34077379f, -0.05435661f, 0.02517560f, 
    0.03214033f, -0.19477850f, 0.24212074f, -0.08774148f, -0.06470469f, -1.16807961f, 0.19992785f, 0.06905705f, 
    -0.78053069f, -0.79761279f, 0.62719107f, 0.40477625f, -0.22658245f, 0.45579690f, 0.69259882f, -0.03085140f, 
    0.23727609f, -0.12963440f, -0.11387006f, -0.20284741f, 0.12364995f, 0.29345205f, 0.03846353f, 0.00443852f, 
    0.00107903f, -0.12238365f, -0.02049541f, 0.00469022f, -0.10766221f, -0.00648284f, -0.54363656f, -0.43410745f, 
    -0.57121074f, -0.39260152f, -0.46970078f, -0.23070604f, -0.52965516f, -0.52210641f, -0.18561789f, -0.28989780f, 
    0.47610447f, 0.49194694f, 0.43670049f, 0.24597633f, 0.02768222f, 0.35745579f, -0.15232070f, -0.09362620f, 
    0.22665641f, -0.03048006f, -0.06213234f, 0.13523179f, 0.03070170f, -0.09354488f, 0.29258049f, 0.11357836f, 
    0.27798241f, -0.84424287f, -0.53437895f, 0.30452016f, -0.39841932f, -0.34450495f, 0.19794983f, 0.47024047f, 
    -0.36582103f, -0.51439160f, -0.10177986f, 0.36261684f, 0.08865168f, -0.37665355f, -0.06961687f, -0.26333776f, 
    -0.14131482f, -0.47231233f, -0.40801296f, 0.10069857f, -0.22320983f, 0.30181161f, 0.23279129f, -0.05376436f, 
    -1.01079631f, -0.72968352f, -0.09169925f, 0.33367336f, 0.61202985f, -0.65968633f, 0.53441948f, -0.11444265f, 
    -0.56866676f, -0.24335557f, 0.48570052f, 0.29751378f, 0.19207163f, -0.20061754f, -0.05823553f, 0.04503499f, 
    0.24980399f, 0.06546538f, 0.24902621f, 0.00692892f, -0.15434591f, -0.10644978f, -0.09207187f, -0.11821885f, 
    0.14466196f, 0.70646757f, -0.30268919f, -0.31050473f, 0.98028392f, 0.31320411f, 0.31538185f, -0.69610834f, 
    0.02764858f, 0.48703924f, 0.11284894f, -0.07071144f, 0.22439401f, 0.22047974f, 0.13556817f, -0.10686769f, 
    -0.08380897f, -0.00061919f, 0.41163567f, -0.04637566f, 0.21573552f, -0.19581127f, -0.10639031f, -0.00027239f, 
    -0.15239164f, -0.26082647f, 1.00104892f, 0.37781572f, -0.09656657f, 0.12695345f, -0.48704499f, -0.25398514f, 
    -0.18413426f, -0.70995164f, -0.47286573f, -0.63924009f, 0.10134684f, 0.15486586f, 0.05333266f, -0.14997937f, 
    -0.27110165f, 0.21728231f, -0.14838739f, 0.14604531f, 0.21640944f, -0.03693229f, -0.28093117f, 0.10785686f, 
    0.12937096f, -0.13350365f, 0.33322045f, 0.27831993f, 0.24203198f, -0.34060794f, 0.58131641f, 0.89646041f, 
    0.66402698f, 0.28255275f, -0.86001885f, 0.57807630f, 0.22251666f, 0.11162120f, -0.02394795f, -0.26349223f, 
    0.18763602f, -0.47952160f, -0.05781446f, -0.11123331f, 0.02400505f, -0.12769529f, -0.24421580f, 0.27590910f, 
    0.08598715f, 0.19405475f, 0.07913642f, 0.08262049f, -0.05950197f, 0.13067852f, -0.04570528f, -0.60632670f, 
    -0.45996463f, -0.13130252f, 0.61976284f, -0.29578063f, -0.78120613f, -0.09801340f, 0.03346281f, 0.03540024f, 
    -0.27160141f, -0.25263321f, -0.21147847f, -0.10918466f, -0.45046604f, -0.02611354f, -0.03594497f, -0.18368219f, 
    -0.06298982f, 0.21223861f, 0.08931632f, 0.02810251f, 0.49319434f, -0.99598962f, 0.49214453f, 0.39805070f, 
    0.56234324f, -0.45231560f, 0.04618049f, 0.16394018f, 0.23569527f, 0.13654187f, -0.59495521f, -0.46593723f, 
    -0.17338462f, -0.36427015f, -0.20322843f, -0.08309343f, -0.04972526f, 0.22362556f, 0.17560634f, 0.02600393f, 
    -0.02403514f, 0.04820788f, 0.05627719f, -0.21082421f, -0.21344312f, -0.35620815f, 0.44597095f, 0.75392717f, 
    0.24832416f, 0.80706829f, 0.56616133f, -0.16602993f, 0.26831645f, 0.59072846f, 0.17900448f, 0.20964402f, 
    0.08769320f, -0.36038449f, 0.03883888f, -0.34350362f, 0.12613000f, 0.44747788f, 0.10576616f, 0.07471596f, 
    0.26278260f, 0.18870670f, 0.05470526f, -0.09219604f, 0.27122271f, 0.28790283f, -0.15919209f, 0.98553497f, 
    -0.40774202f, -0.90905130f, -0.56524664f, -0.24053608f, -0.28488263f, 0.48592296f, 0.16554731f, 0.15801281f, 
    0.39543265f, -0.38009921f, 0.07675523f, 0.14274752f, 0.02960766f, -0.00914974f, -0.34432018f, 0.16627058f, 
    -0.13323033f, 0.09023377f, -0.07539353f, 0.03004787f, 0.16503112f, -0.08535341f, -0.12097319f, 0.00882090f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24334486f, 0.18073690f, 0.08052889f, 0.22350456f, 0.20721079f, -0.11264130f, 0.27421141f, 0.10327270f, 
    0.22046214f, 0.18301523f, -0.09383900f, -0.02323737f, 0.06852930f, -0.03418212f, 0.04360959f, 0.18755935f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.47435492f, 0.25582203f, 0.01944822f, -0.25558209f, 0.02949103f, 0.01367551f, 0.03172789f, -0.02669997f, 
    -0.02002084f, -0.02788009f, 0.03843076f, -0.03123495f, 0.09181859f, -0.18958549f, -0.26574185f, -0.04274263f, 
    -0.10837202f, -0.04535732f, 0.18158066f, -0.13805582f, 0.00673579f, -0.10970884f, 0.11460564f, -0.11625645f, 
    -0.22344215f, 0.06026355f, -0.03889704f, -0.31867766f, 0.11377146f, -0.02702029f, 0.02567570f, -0.06414607f, 
    -0.17085296f, 0.00178312f, -0.07630535f, 0.04992148f, 0.01736954f, -0.10604627f, -0.17421047f, 0.12790400f, 
    -0.24409306f, -0.19645827f, -0.13916960f, -0.09537063f, 0.05568503f, -0.00587244f, 0.01394768f, -0.20639269f, 
    -0.05911011f, 0.20104127f, 0.00333351f, 0.06572213f, 0.07822022f, 0.18690372f, 0.00994935f, 0.04282105f, 
    0.05603744f, 0.15745373f, 0.04949137f, -0.19954132f, 0.64914292f, 0.22620289f, 0.13258454f, -0.18769933f, 
    -0.07553622f, 0.19245243f, -0.01258083f, 0.01722143f, 0.08532649f, 0.01288785f, -0.03616528f, -0.00012785f, 
    -0.10171869f, -0.11312169f, -0.05208141f, -0.17450579f, -0.15978731f, -0.15656139f, -0.07757690f, -0.07310368f, 
    0.10239383f, 0.05262716f, -0.01786024f, -0.14172493f, 0.04242459f, 0.15422302f, 0.14612338f, -0.13937940f, 
    0.02536059f, 0.10721608f, 0.03841293f, -0.05268300f, 0.16776881f, 0.16037719f, 0.06670164f, 0.09013075f, 
    0.28127077f, -0.22150396f, 0.05977248f, 0.01302695f, 0.11282241f, -0.10420798f, 0.00449902f, 0.08544832f, 
    0.01321150f, 0.14928672f, -0.09803072f, -0.00363645f, 0.45341915f, -0.04054191f, -0.21664429f, 0.39066356f, 
    -0.00352014f, 0.00907284f, -0.15099846f, -0.12577908f, 0.12352604f, 0.04764538f, -0.09108314f, -0.04185917f, 
    0.10904142f, 0.11708766f, -0.02908727f, 0.13965444f, -0.03958351f, -0.11016343f, -0.15808080f, 0.11933524f, 
    -0.08036111f, 0.00139292f, 0.00255274f, 0.04439596f, -0.01462583f, -0.03388830f, 0.17953020f, 0.03417514f, 
    0.05257104f, -0.34950927f, -0.14652178f, -0.00445349f, 0.00001783f, 0.13701594f, 0.04126086f, -0.06121098f, 
    -0.01163580f, 0.23952696f, 0.26771307f, -0.08273286f, 0.08412860f, 0.04971112f, -0.19155484f, 0.16356964f, 
    -0.06405547f, -0.01039461f, -0.02260197f, 0.09281007f, 0.04697224f, 0.24159315f, 0.15549475f, 0.44438669f, 
    0.00025543f, -0.03529470f, -0.09716614f, 0.12271561f, -0.09612842f, -0.01484387f, 0.11319506f, 0.00548136f, 
    0.05310977f, 0.12330274f, -0.04376374f, 0.00990501f, -0.10574474f, -0.09839465f, -0.08345459f, -0.12910731f, 
    0.02145509f, -0.10448244f, 0.29639736f, -0.16053855f, 0.16440821f, -0.16075310f, 0.08532645f, -0.09938587f, 
    0.01721312f, -0.07662872f, 0.10345294f, 0.02877992f, -0.12901630f, 0.04708189f, -0.02485292f, 0.10352505f, 
    -0.41120532f, 0.06469407f, -0.23780736f, 0.09493130f, 0.35889181f, 0.06681597f, 0.01807057f, 0.10230225f, 
    0.09706489f, 0.10642246f, 0.25780702f, -0.03420339f, -0.10291871f, 0.28173211f, 0.30332050f, -0.04070823f, 
    -0.16860123f, 0.08201255f, 0.02604207f, -0.06574146f, -0.02235349f, -0.05453917f, 0.14685011f, -0.07745414f, 
    0.13492878f, -0.01067187f, 0.17785873f, 0.21512802f, -0.07899916f, 0.06261738f, -0.07636689f, 0.01211599f, 
    0.06332535f, -0.03372494f, -0.06618252f, -0.16909808f, -0.28426290f, 0.05220089f, 0.05498703f, -0.23752497f, 
    0.12738347f, -0.03351569f, 0.13751787f, 0.20116399f, -0.05084542f, 0.18419531f, 0.10086769f, 0.20659140f, 
    -0.03294232f, 0.05132658f, -0.23738562f, 0.29319701f, -0.02686087f, -0.02881214f, -0.01221999f, -0.00490815f, 
    0.03316779f, -0.01091226f, 0.14196973f, 0.26747704f, 0.09086530f, -0.38960558f, 0.02200344f, -0.17778289f, 
    0.20945038f, 0.24136053f, -0.04689660f, 0.07706305f, -0.14480716f, 0.06775948f, 0.11743294f, 0.04566102f, 
    -0.31508592f, -0.19994277f, -0.00478811f, 0.27582332f, 0.12211079f, 0.16691194f, -0.05239536f, -0.17116272f, 
    -0.04658473f, -0.08632706f, -0.09948657f, -0.07510285f, 0.13449503f, -0.06198356f, -0.07251686f, 0.23474291f, 
    -0.03627031f, -0.00885194f, -0.03337120f, -0.03834927f, 0.05153948f, 0.21884111f, 0.17664593f, 0.13143021f, 
    -0.18183473f, 0.17888713f, -0.11520083f, 0.13897750f, 0.17628172f, 0.09081427f, 0.15177634f, 0.05503435f, 
    0.06633548f, 0.03430364f, 0.03029580f, -0.07584274f, -0.01036750f, 0.18700042f, -0.06930464f, -0.25757316f, 
    -0.00212024f, 0.07830943f, 0.06100455f, 0.11920009f, 0.03876054f, -0.09823358f, -0.10385515f, 0.05525494f, 
    0.16222864f, 0.36606562f, -0.00036337f, 0.16896988f, -0.10529568f, -0.01110844f, 0.06748872f, -0.04427505f, 
    -0.11238660f, -0.08959640f, 0.01409886f, -0.03690394f, -0.18456396f, 0.26652819f, -0.10522272f, -0.30287272f, 
    -0.00654961f, 0.01910254f, 0.03658541f, 0.03029951f, -0.05922433f, -0.01566815f, -0.07784121f, 0.07568505f, 
    -0.12534747f, -0.38386828f, 0.11571316f, 0.24859807f, 0.18944019f, 0.03679131f, -0.01483121f, -0.02691138f, 
    -0.11575627f, 0.12338664f, 0.08280596f, 0.14175723f, 0.28512746f, 0.21779764f, 0.13620654f, -0.02413754f, 
    -0.02945792f, 0.18069738f, 0.07689134f, 0.05471621f, 0.08353481f, 0.04426403f, -0.02881866f, 0.11997037f, 
    0.01157642f, -0.09206834f, 0.11537182f, -0.13097432f, 0.09585936f, 0.01729994f, 0.12474556f, 0.05101880f, 
    0.24060649f, 0.01206539f, -0.03254465f, -0.25405866f, -0.23880813f, 0.06343694f, -0.05947284f, 0.32332066f, 
    0.10146224f, -0.00052875f, -0.05155203f, -0.05106695f, -0.06355524f, 0.02000416f, 0.05764471f, 0.11793582f, 
    0.05894984f, -0.01669315f, 0.03213324f, 0.00354202f, -0.02972272f, 0.04005969f, -0.03109161f, -0.00598054f, 
    -0.03180925f, -0.02785142f, 0.04165308f, -0.06474346f, 0.03224635f, -0.04979663f, 0.04152538f, -0.04474212f, 
    0.00069149f, 0.01929153f, -0.02557200f, -0.07648433f, 0.03603678f, -0.03623310f, 0.01061371f, -0.00682032f, 
    -0.01879869f, -0.06802209f, -0.07648221f, -0.05991022f, 0.05077796f, -0.05147878f, 0.04293732f, -0.07536177f, 
    -0.08075189f, -0.01304104f, 0.03284468f, -0.01283429f, 0.04453401f, 0.02126229f, -0.05731546f, -0.06326070f, 
    -0.04530546f, -0.02682421f, 0.05766605f, -0.01999617f, 0.02951887f, -0.04043000f, -0.05729866f, 0.04807764f, 
    0.05957247f, 0.00849992f, -0.01607068f, 0.02968010f, -0.02066585f, -0.05936421f, -0.06624456f, -0.07629094f, 
    -0.00199957f, -0.07012741f, -0.04922547f, 0.03085880f, -0.01375388f, 0.03586262f, 0.01727138f, 0.01161821f, 
    -0.03862867f, 0.04570106f, 0.02696292f, -0.06956682f, -0.07061813f, -0.04042379f, 0.05470135f, 0.01495569f, 
    -0.05629856f, -0.02397181f, -0.05389426f, -0.07466059f, 0.04617763f, -0.05908010f, -0.06247683f, 0.01404247f, 
    -0.01932622f, -0.07888960f, 0.03813055f, -0.04113455f, -0.00486041f, -0.00648613f, -0.07186966f, 0.04826590f, 
    -0.01661623f, -0.00093259f, -0.00439479f, 0.01840505f, -0.05188275f, 0.00239905f, -0.06486792f, -0.00144157f, 
    -0.04584872f, -0.08046699f, 0.05845335f, 0.04083194f, 0.00572480f, -0.00133130f, 0.02924586f, -0.04519707f, 
    -0.00798529f, 0.06276695f, -0.02809201f, -0.00027116f, -0.05476596f, 0.00289038f, -0.03967080f, 0.01648024f, 
    0.00802683f, -0.07967966f, -0.06127904f, -0.00317428f, 0.02445981f, -0.02763375f, -0.06828432f, -0.03931292f, 
    -0.07436397f, 0.04481559f, 0.01234928f, -0.04178517f, -0.06657993f, 0.00491256f, 0.03485699f, -0.02707930f, 
    0.05460350f, -0.00106261f, 0.04360208f, 0.03695541f, -0.06132220f, -0.01228244f, 0.02112672f, 0.03024183f, 
    -0.04229578f, -0.03892898f, 0.02721311f, -0.03500538f, -0.06970248f, -0.07177953f, -0.00105672f, -0.06052973f, 
    -0.06816211f, -0.04667526f, -0.05092959f, -0.06556568f, 0.01298844f, -0.03971960f, 0.02423433f, -0.00704862f, 
    0.04182457f, -0.00197993f, -0.01050164f, 0.00251116f, 0.00387395f, -0.06296262f, 0.04688454f, 0.03294376f, 
    0.01672386f, -0.06052601f, 0.04155765f, -0.04672812f, -0.00146697f, 0.04159062f, 0.04007702f, 0.03542076f, 
    -0.03926408f, -0.07878540f, -0.01986102f, -0.05474828f, -0.04478661f, -0.06543633f, 0.01394889f, -0.05567444f, 
    -0.05826307f, 0.04419063f, -0.06186171f, -0.06134691f, -0.00027523f, -0.01728475f, -0.00158705f, -0.06817906f, 
    -0.06161385f, 0.03556138f, 0.05067745f, -0.04268341f, -0.00127265f, -0.06612074f, 0.02079274f, -0.03200973f, 
    0.15766452f, 0.13997355f, 0.20898996f, -0.03705372f, -0.02489807f, 0.22395368f, -0.00812551f, -0.04813151f, 
    -0.03231784f, 0.03082030f, -0.00312527f, -0.11000384f, -0.29754934f, -0.50017476f, 0.05124614f, 0.17548865f, 
    0.00569083f, -0.20524801f, -0.00461327f, -0.07069769f, 0.09211123f, 0.14960420f, -0.01293932f, 0.11736628f, 
    -0.43881044f, -0.26242796f, 0.04142470f, 0.16675068f, 0.10733096f, 0.02670274f, 0.09607588f, 0.01926092f, 
    -0.03321871f, -0.05502269f, -0.01463136f, -0.03202787f, -0.33247426f, 0.21116237f, -0.30927888f, 0.37922439f, 
    -0.08789293f, 0.04986027f, -0.00085398f, 0.15133412f, 0.04050025f, -0.00805037f, -0.00839971f, 0.06750080f, 
    -0.07015292f, -0.18177186f, 0.16332872f, 0.10129315f, 0.23030475f, 0.08011409f, 0.14501128f, 0.10910533f, 
    0.01563144f, -0.14343560f, 0.02409158f, -0.14549495f, -0.00071454f, 0.09642945f, 0.18247843f, -0.07098061f, 
    -0.10704643f, -0.19348630f, -0.03705072f, 0.00525475f, 0.10384454f, -0.01808178f, 0.16720310f, 0.21882652f, 
    0.08434051f, -0.06831366f, 0.10819937f, 0.02705002f, 0.09733129f, 0.08092573f, 0.06961473f, 0.20635329f, 
    -0.29987940f, 0.11433192f, -0.00316122f, 0.08475196f, 0.13845478f, -0.10336577f, 0.16675042f, -0.08587769f, 
    -0.12523100f, 0.20209172f, -0.25415498f, 0.06832048f, 0.03092970f, -0.22568242f, -0.18214978f, 0.04466831f, 
    0.13890478f, -0.00300496f, -0.00974960f, 0.04579847f, 0.24067226f, 0.12939225f, -0.01267943f, 0.06034140f, 
    -0.03008658f, 0.01596097f, -0.14126557f, 0.19975282f, -0.09621999f, 0.06577931f, -0.13725263f, 0.33564237f, 
    0.07892867f, -0.03122585f, 0.03037023f, -0.07139359f, 0.03536655f, 0.02668360f, 0.05357598f, 0.08115177f, 
    -0.17682004f, -0.03470199f, 0.43708879f, -0.17874122f, -0.05136139f, -0.00738828f, -0.00681788f, 0.11985549f, 
    -0.12961821f, -0.03670448f, 0.18680964f, -0.07531458f, -0.19108517f, 0.38897857f, -0.11450458f, -0.04645544f, 
    0.02360478f, 0.00808556f, -0.09766674f, 0.17127033f, 0.03821586f, -0.04355830f, 0.09860543f, 0.06264225f, 
    -0.08371155f, 0.16096964f, 0.16136713f, -0.41368428f, 0.01254386f, -0.10951338f, -0.10601966f, 0.02766843f, 
    0.12021706f, -0.03010961f, -0.05954245f, 0.02732062f, 0.11572420f, 0.11871841f, -0.15897644f, 0.08064571f, 
    0.00224051f, 0.04188244f, 0.01924577f, 0.18991774f, 0.13660915f, 0.12023874f, 0.03371505f, -0.03678973f, 
    -0.01049795f, -0.09801272f, -0.05869469f, 0.18224928f, -0.19412139f, 0.02658748f, 0.03986709f, 0.03531760f, 
    0.03659448f, 0.17767249f, 0.25914317f, 0.24154735f, 0.18147963f, -0.10802597f, 0.11576394f, -0.16647039f, 
    -0.03360437f, -0.00504680f, -0.01348001f, -0.01541802f, 0.04833489f, -0.03196582f, 0.05757674f, 0.01186843f, 
    -0.12724748f, -0.17956547f, -0.05331182f, 0.23301502f, -0.27771124f, -0.06432391f, 0.11943326f, 0.03913706f, 
    -0.04252689f, 0.08572330f, 0.16230427f, 0.06247748f, -0.62066269f, -0.02092128f, 0.17780213f, -0.03709532f, 
    0.14648227f, 0.06951976f, 0.10659400f, 0.10996126f, 0.13925456f, -0.01905982f, 0.09867518f, 0.01092269f, 
    -0.67607123f, -0.22783650f, 0.01573655f, 0.18412125f, 0.20265922f, 0.08198967f, -0.03891940f, -0.05632610f, 
    -0.04362293f, 0.02823057f, 0.02669062f, -0.02432945f, 0.10474848f, -0.16661875f, -0.06729019f, -0.19589728f, 
    -0.02597121f, 0.04509344f, -0.04921524f, 0.12876622f, 0.08766900f, -0.02004094f, -0.05586496f, 0.07693321f, 
    0.21000196f, 0.25662962f, 0.02431336f, -0.13872848f, -0.07639077f, -0.07070427f, 0.00578040f, 0.16906646f, 
    0.03995396f, 0.12333840f, 0.15439165f, 0.04507896f, 0.23496340f, 0.23124126f, -0.09780443f, 0.17354341f, 
    -0.34997401f, -0.09083314f, 0.01568549f, 0.05361950f, -0.01274731f, 0.20028576f, 0.15708411f, -0.00885572f, 
    0.30385986f, 0.24220282f, 0.10020445f, -0.09362430f, 0.04988071f, 0.02743899f, 0.05576391f, 0.10948882f, 
    -0.04789295f, -0.02230565f, 0.03710569f, 0.05199288f, 0.18658191f, 0.05426662f, -0.01347702f, 0.31609404f, 
    0.12340067f, 0.02542334f, -0.00589439f, 0.08756762f, 0.02361696f, 0.22732851f, -0.00765651f, 0.05866068f, 
    0.20976563f, 0.19632137f, 0.14814821f, 0.08506067f, -0.01515105f, 0.00911739f, -0.01907854f, 0.03197843f, 
    0.08695775f, -0.08542132f, -0.03029861f, 0.04398838f, -0.07422534f, -0.15851924f, -0.00459014f, -0.19721252f, 
    0.11202028f, 0.04029727f, -0.00206540f, -0.01134173f, -0.01329827f, 0.03247700f, -0.18548641f, -0.04808578f, 
    -0.36273018f, -0.18044095f, 0.31507310f, -0.08768681f, 0.15805729f, 0.12870818f, -0.08462749f, -0.06054296f, 
    0.13210009f, 0.31812394f, -0.01114410f, 0.06304533f, 0.00600256f, -0.28657991f, -0.09539346f, -0.13414560f, 
    0.00828608f, -0.03605305f, 0.04333172f, 0.00585243f, -0.16037241f, -0.06621016f, 0.08120459f, 0.09283227f, 
    0.15354496f, 0.07380625f, 0.19042741f, 0.27250233f, -0.01584936f, -0.03389277f, 0.04891626f, -0.03286957f, 
    0.13194196f, 0.03526220f, -0.01364174f, -0.01827873f, 0.05582775f, -0.01387027f, 0.03867774f, -0.29754728f, 
    -0.04656295f, 0.06504181f, -0.00769440f, -0.03881354f, -0.03216392f, -0.16595489f, 0.05062700f, -0.01983796f, 
    -0.39892763f, -0.30462813f, -0.15379173f, -0.31683150f, 0.16368537f, -0.00004665f, 0.02822151f, 0.02733783f, 
    -0.07224118f, 0.06962364f, 0.01317607f, -0.13975418f, -0.17043677f, 0.05891542f, -0.07920080f, 0.21986911f, 
    -0.17132148f, 0.02904764f, 0.22655363f, -0.12279236f, 0.06659602f, 0.01179669f, 0.08714996f, -0.12592871f, 
    -0.08202802f, 0.00854166f, -0.01343662f, -0.06548972f, -0.02783398f, -0.08170760f, -0.02282509f, 0.03572645f, 
    -0.07437622f, -0.02823842f, -0.07949974f, -0.01811165f, 0.04287978f, -0.01667530f, 0.04892617f, 0.01056061f, 
    -0.07415089f, -0.06108514f, -0.06125949f, -0.03023110f, 0.05658973f, 0.01270503f, -0.01636105f, 0.01937606f, 
    -0.02324935f, -0.08487120f, 0.01776732f, 0.04244629f, -0.04560677f, 0.00007145f, 0.01423184f, -0.01543148f, 
    0.00139683f, 0.02507999f, 0.04835131f, 0.03450659f, -0.01208747f, -0.08555666f, 0.03745834f, -0.02425239f, 
    -0.07250530f, 0.03594313f, 0.01173516f, 0.02070716f, -0.06040208f, 0.00550382f, -0.07773610f, 0.03527487f, 
    -0.03026501f, 0.04738637f, -0.07050421f, -0.01799837f, 0.01972561f, -0.04662602f, 0.04965922f, -0.06770767f, 
    -0.05066863f, -0.01915408f, -0.07968768f, 0.06272769f, 0.03429900f, -0.04639150f, 0.02356155f, -0.05620981f, 
    -0.01316932f, 0.04572327f, -0.01171264f, 0.04581011f, -0.03450049f, 0.05196299f, -0.01702993f, -0.03415649f, 
    -0.02109390f, -0.06198459f, -0.05291744f, -0.06060644f, -0.06632543f, 0.03099954f, -0.08027150f, 0.01040012f, 
    0.04127230f, 0.02558742f, 0.04125332f, -0.03285844f, 0.02116090f, -0.08335656f, -0.04743356f, -0.07848220f, 
    -0.03361127f, 0.00663677f, -0.00598006f, -0.01214518f, -0.03386460f, 0.02616240f, 0.04241468f, 0.03362140f, 
    0.06190260f, 0.03296606f, 0.05435684f, 0.02236930f, -0.01629117f, 0.03761381f, -0.05494454f, 0.02690068f, 
    0.02117872f, 0.01670565f, -0.01034589f, 0.03766646f, -0.05132660f, -0.08269546f, 0.03911557f, 0.05406135f, 
    -0.06468062f, -0.04074178f, 0.05175196f, 0.05442153f, -0.02373951f, -0.05842052f, 0.02308974f, 0.05853967f, 
    -0.02536391f, 0.00978364f, -0.05369249f, 0.03521633f, -0.05783752f, 0.00380630f, -0.07556076f, -0.02870961f, 
    0.02945245f, 0.01349508f, 0.03054689f, -0.02003866f, -0.02825479f, 0.05033376f, 0.05177052f, -0.01642944f, 
    -0.02730696f, 0.01291431f, -0.03227556f, 0.00348953f, 0.02868448f, 0.04277625f, -0.07461213f, -0.01961267f, 
    -0.06788719f, 0.01635244f, -0.05509181f, -0.01738828f, 0.00757317f, 0.03584300f, -0.07339908f, -0.05881106f, 
    -0.02704597f, -0.06566686f, -0.07613358f, 0.00414988f, -0.01143623f, 0.01086890f, 0.03211215f, -0.06441560f, 
    -0.05441455f, -0.06724459f, 0.05917351f, -0.07754046f, -0.04547504f, 0.03200938f, 0.06072649f, 0.01153381f, 
    0.02932942f, -0.06438377f, 0.00662008f, -0.02938030f, -0.05410512f, -0.02972279f, -0.07212711f, -0.01705998f, 
    -0.02239163f, -0.03051647f, -0.00041145f, -0.01359192f, -0.07745225f, -0.00082866f, 0.03020705f, -0.00118266f, 
    -0.05885707f, -0.03765126f, -0.03581471f, 0.00869341f, 0.04224030f, -0.04734509f, 0.03207476f, -0.01327721f, 
    0.35323057f, -0.20975308f, -0.15230723f, -0.31269920f, 0.17483205f, -0.03712857f, 0.17317614f, -0.00769431f, 
    -0.09691368f, 0.05372655f, -0.11067311f, -0.06324792f, 0.04698573f, -0.16555919f, 0.02143124f, -0.03195800f, 
    -0.15450311f, -0.02976461f, 0.03304517f, 0.05583838f, -0.09039554f, 0.02589692f, -0.03932843f, 0.02196152f, 
    0.14554538f, -0.10041288f, -0.08355398f, -0.20510434f, 0.09928912f, -0.07425004f, 0.05970563f, 0.05873984f, 
    0.13093591f, 0.00716603f, -0.09348191f, 0.03831098f, -0.09377395f, -0.02791912f, 0.06730203f, 0.06587080f, 
    -0.10083437f, -0.02978340f, 0.00862486f, -0.18112983f, -0.23416367f, -0.01085406f, -0.12636100f, -0.10585832f, 
    0.38351360f, 0.25487939f, 0.11958179f, 0.07289569f, 0.18154159f, 0.07765119f, -0.02945607f, 0.10037736f, 
    0.01802386f, 0.09316244f, -0.20414431f, -0.01418821f, -0.07150964f, 0.06785538f, -0.00703513f, -0.09688473f, 
    0.12341435f, 0.17739226f, -0.03968212f, -0.11669996f, 0.07557693f, -0.14817627f, 0.01335774f, -0.05236821f, 
    0.13023332f, -0.17252736f, -0.09602007f, 0.23148476f, -0.07768414f, -0.07153182f, -0.03145252f, 0.14760219f, 
    0.19955465f, 0.02122901f, 0.12273690f, 0.03282443f, 0.25153777f, 0.13748251f, 0.06733327f, -0.03667084f, 
    0.07953728f, 0.07287814f, 0.06956541f, -0.00651719f, 0.05239162f, -0.11503934f, 0.09519161f, -0.00976853f, 
    -0.63605469f, 0.19686356f, 0.25453231f, -0.00873518f, 0.06371214f, 0.01296093f, 0.04514280f, 0.04613929f, 
    0.04927306f, 0.06861257f, 0.07979154f, 0.05687602f, 0.38536087f, -0.29437080f, -0.23094748f, 0.15391874f, 
    0.12258649f, -0.04693510f, 0.00375309f, 0.17025945f, 0.06487488f, 0.05218467f, 0.08629575f, 0.08846951f, 
    0.18644083f, 0.25720909f, 0.21083759f, 0.49557263f, -0.32897791f, -0.05534256f, -0.08230705f, 0.01500975f, 
    -0.15793940f, -0.21089642f, 0.10215567f, 0.09523837f, 0.03232815f, -0.02015129f, 0.11944522f, -0.13172244f, 
    -0.07444073f, -0.02480288f, 0.12999620f, -0.03011528f, 0.11889375f, -0.07844099f, -0.11247230f, 0.03349975f, 
    0.06667285f, -0.03491632f, 0.43574426f, 0.27621371f, -0.17396925f, -0.03874604f, -0.08072871f, 0.06251547f, 
    0.00885174f, -0.05756667f, -0.08265254f, -0.07244010f, -0.51452929f, 0.10679007f, 0.23126866f, 0.29300857f, 
    0.05792386f, 0.21817675f, -0.03032464f, 0.08637281f, 0.11822505f, 0.17863508f, 0.06039597f, -0.03020801f, 
    -0.06428179f, 0.06475408f, 0.04247879f, -0.24524198f, -0.11564931f, 0.15538776f, -0.10329458f, -0.01965054f, 
    0.17387182f, 0.02281232f, -0.04981321f, 0.07389901f, 0.05755178f, -0.18149865f, -0.07374004f, -0.23250183f, 
    0.16420220f, -0.02176367f, 0.04627533f, 0.01264427f, -0.02755515f, 0.09297878f, 0.12751028f, -0.08596660f, 
    -0.09712436f, -0.06533858f, 0.10356611f, 0.00483145f, -0.01317795f, 0.00327899f, -0.07604021f, 0.05371212f, 
    -0.01538917f, -0.02331529f, 0.13709192f, 0.06961710f, -0.39802867f, 0.26625690f, -0.02115678f, 0.03647137f, 
    0.09373774f, 0.06825791f, 0.09080594f, 0.04585553f, 0.15859781f, 0.01838028f, 0.13802955f, 0.02325171f, 
    -0.51024735f, -0.09600373f, 0.16210018f, 0.20921704f, 0.09297163f, 0.06396417f, -0.04811757f, -0.04386329f, 
    -0.05945209f, 0.07588585f, -0.07320284f, -0.12075462f, 0.01994666f, -0.04705425f, -0.11527818f, -0.17605257f, 
    -0.17429052f, -0.00833338f, 0.12082850f, 0.15639223f, 0.11302747f, -0.01953816f, 0.14727542f, 0.13669448f, 
    0.00545480f, 0.21025795f, 0.12579824f, 0.00554564f, -0.25590068f, -0.11215793f, -0.00557613f, -0.09934876f, 
    -0.03491561f, -0.11523490f, 0.21179476f, -0.08261386f, 0.06958646f, 0.23504043f, -0.14225607f, -0.00438895f, 
    0.03722640f, -0.01743583f, -0.00402878f, 0.21424457f, -0.08238924f, 0.18687311f, 0.06183758f, -0.04180036f, 
    0.00117180f, 0.01609514f, -0.03164002f, 0.09615517f, -0.08949395f, -0.06702968f, 0.01261118f, -0.07788285f, 
    -0.14508066f, -0.12626180f, -0.19841419f, -0.24279487f, 0.16385882f, -0.03822286f, 0.13539726f, 0.06430337f, 
    -0.02610490f, -0.07337487f, -0.08905385f, 0.02042499f, -0.05944949f, 0.24946664f, -0.00037291f, 0.17845596f, 
    0.15984310f, 0.03754829f, 0.06422466f, 0.23717891f, 0.02997189f, 0.06292867f, -0.04594835f, 0.25089896f, 
    0.00873090f, 0.02003149f, -0.12146123f, -0.15541162f, 0.23634213f, 0.21542192f, -0.01226351f, 0.06031578f, 
    0.04345683f, 0.10504629f, -0.03177802f, 0.00081174f, 0.01236903f, -0.09766458f, -0.29206347f, -0.13686103f, 
    -0.03215757f, -0.17989232f, 0.06342672f, -0.01266440f, 0.15660991f, 0.05679836f, 0.06741960f, 0.09288931f, 
    0.09291027f, 0.11951204f, -0.13034697f, -0.10256973f, -0.16458076f, 0.01487247f, -0.10329360f, 0.01036636f, 
    -0.01270630f, 0.02797944f, -0.00819031f, 0.10764822f, -0.11317764f, 0.16492446f, 0.04762650f, 0.05263470f, 
    0.12711267f, 0.13096656f, 0.05917496f, 0.14073902f, 0.06423508f, 0.00321419f, 0.05268740f, 0.12435411f, 
    0.00857802f, -0.10278979f, -0.05666168f, -0.00421350f, 0.42775944f, -0.04596647f, 0.06661426f, 0.08784361f, 
    -0.05559393f, 0.17288417f, 0.13112609f, -0.10399370f, 0.03391508f, -0.17067736f, 0.09821954f, 0.01856819f, 
    -0.11832700f, 0.02038711f, 0.05182420f, -0.07923602f, -0.04830775f, 0.09763730f, -0.02193891f, 0.07201881f, 
    -0.03334825f, 0.01748814f, -0.01223398f, -0.21333264f, 0.01522603f, -0.13602443f, 0.16879751f, -0.08046415f, 
    -0.01321423f, 0.03645286f, 0.16421950f, -0.11393926f, -0.10499140f, 0.06191331f, 0.01694922f, -0.03845835f, 
    0.29381973f, 0.35010591f, 0.03183299f, 0.05448084f, 0.14469215f, 0.12209106f, 0.04783643f, 0.05251002f, 
    0.03495026f, 0.02377090f, 0.02962353f, -0.12657091f, -0.55073655f, -0.43362585f, -0.06782843f, -0.15782395f, 
    -0.01640233f, 0.01070858f, -0.15503657f, -0.16490991f, 0.08563492f, 0.06280174f, -0.11486617f, -0.05901294f, 
    -0.64796185f, -0.13596167f, 0.02833345f, 0.00397342f, 0.02577198f, -0.05032475f, 0.10524780f, -0.06749956f, 
    -0.03716232f, 0.11826540f, -0.03335898f, 0.01443115f, -0.48021325f, 0.09377038f, -0.02622241f, 0.06678776f, 
    0.03847125f, -0.03035610f, -0.27731311f, 0.06328640f, -0.05189908f, -0.06343503f, -0.06766985f, -0.30946419f, 
    0.17864396f, -0.05765424f, 0.03308178f, 0.09017368f, 0.42265600f, 0.17391317f, 0.15195754f, 0.12478129f, 
    -0.03774001f, -0.05144707f, -0.14533857f, -0.20157099f, -0.23417836f, 0.24507789f, -0.04443650f, -0.14293593f, 
    0.20406510f, 0.21636936f, 0.11918960f, -0.01924560f, 0.20493178f, -0.04244452f, 0.02328073f, 0.10864001f, 
    0.23814970f, 0.05977552f, -0.06932763f, 0.12937738f, 0.08469020f, 0.05020872f, 0.07898139f, -0.10650615f, 
    -0.09771197f, -0.01669865f, 0.18217891f, -0.05538370f, 0.44937205f, -0.09430098f, 0.07193465f, 0.10815572f, 
    0.00510411f, 0.22000718f, -0.20002878f, 0.05732342f, -0.19867520f, -0.01578679f, 0.07546492f, -0.12210640f, 
    0.20882210f, 0.00391272f, 0.23484689f, -0.01080087f, 0.07327858f, 0.21455903f, -0.07157082f, 0.04118134f, 
    0.03160702f, 0.11759857f, -0.00714007f, -0.04128430f, -0.03468391f, -0.03279702f, -0.06016707f, -0.18401495f, 
    0.01144321f, 0.07033789f, -0.08107689f, -0.17341572f, 0.08085555f, 0.02999593f, 0.11856821f, -0.05835127f, 
    0.05408403f, 0.10870120f, 0.01557811f, -0.03109032f, -0.11210924f, -0.07797997f, 0.13916664f, -0.02536027f, 
    -0.29819578f, -0.00477483f, 0.10510889f, 0.07156655f, -0.13863464f, 0.34842774f, -0.30237287f, -0.09529141f, 
    -0.01410929f, -0.05941491f, 0.03780350f, -0.11468787f, 0.20416030f, -0.18393178f, 0.13511723f, 0.05387663f, 
    0.15066920f, 0.17076938f, 0.05545970f, -0.03357622f, 0.17439984f, 0.02603204f, -0.19989413f, -0.11699941f, 
    -0.19258411f, -0.08347752f, 0.02528909f, 0.08773016f, -0.15048075f, 0.21467660f, 0.08873715f, 0.40791407f, 
    0.06239109f, -0.04055547f, -0.01760184f, -0.01160246f, -0.04128071f, 0.22550918f, 0.14943443f, -0.14541890f, 
    -0.31374985f, -0.07174283f, -0.09290540f, -0.04300310f, -0.12258588f, -0.12935640f, -0.03584900f, -0.05261301f, 
    -0.04090558f, 0.01170420f, 0.06107269f, 0.11823189f, 0.15633185f, -0.05344969f, -0.05140274f, 0.18944214f, 
    0.03235064f, 0.19397101f, 0.03324114f, 0.18500850f, 0.09254375f, 0.00268905f, 0.06570877f, -0.09789245f, 
    0.16771135f, -0.10843643f, 0.15816744f, 0.13512360f, -0.01322073f, -0.09416682f, 0.05829334f, 0.09279655f, 
    0.10260227f, 0.06875360f, -0.08148888f, -0.03277526f, 0.45065105f, -0.04548477f, 0.19384120f, 0.03336938f, 
    0.12266149f, -0.02084385f, 0.02065609f, -0.05061175f, 0.00708447f, 0.16915850f, -0.09717154f, 0.14884232f, 
    0.58950299f, 0.12416334f, 0.31791377f, -0.20726068f, -0.00471908f, 0.00770364f, 0.08993429f, -0.04642859f, 
    0.04554773f, -0.08912811f, 0.10063958f, 0.18860969f, 0.04146907f, 0.18292107f, 0.11507209f, -0.10764866f, 
    0.34233212f, 0.12626752f, -0.04125947f, -0.14222789f, 0.03517529f, -0.02787134f, -0.02968433f, -0.12662297f, 
    0.16950907f, -0.10452318f, 0.06622097f, 0.07571510f, 0.00495019f, 0.06496696f, 0.05557459f, 0.13046354f, 
    0.03124644f, 0.02368315f, -0.07314996f, -0.02018286f, -0.28144422f, -0.10766106f, 0.03618825f, 0.07160694f, 
    -0.01457349f, -0.07068942f, 0.01034891f, 0.00417186f, 0.12023555f, -0.05049752f, -0.01049940f, -0.02974587f, 
    0.24795136f, 0.06108800f, -0.01137518f, -0.13636830f, 0.15518625f, 0.00376044f, 0.05689175f, 0.17622046f, 
    0.20068067f, 0.28290883f, -0.04064344f, 0.09592172f, -0.09377155f, -0.10154022f, -0.11054035f, -0.00975007f, 
    0.02079865f, 0.12588544f, 0.08995415f, 0.15741728f, 0.04008027f, -0.22794516f, 0.02610199f, -0.05340112f, 
    0.28710014f, 0.08172711f, -0.29550418f, -0.09615763f, -0.01688436f, -0.04506000f, 0.03043034f, -0.06213991f, 
    -0.11686337f, 0.00638367f, 0.29781237f, -0.00340783f, -0.38433290f, -0.17266864f, -0.03905509f, 0.00183542f, 
    0.16447109f, -0.08622324f, -0.12708960f, -0.01919663f, 0.07374149f, 0.02070568f, 0.20499532f, 0.11063076f, 
    -0.10512481f, -0.14540990f, 0.06928539f, -0.24454767f, 0.09708337f, -0.02722892f, 0.18921927f, -0.11178786f, 
    -0.00726214f, -0.02866733f, 0.09358695f, 0.01364682f, -0.01033376f, 0.03372207f, -0.16063666f, -0.03262880f, 
    0.00498996f, -0.02224572f, 0.11871876f, -0.05865815f, 0.03031030f, -0.08181708f, 0.04651519f, -0.05214882f, 
    -0.03944666f, -0.05417396f, -0.14557877f, -0.14223266f, -0.11583558f, -0.04650936f, 0.01595165f, 0.03032888f, 
    0.09925277f, 0.11374345f, -0.00146762f, -0.13110025f, -0.47410652f, -0.11943871f, -0.20827310f, -0.23208971f, 
    -0.02244828f, -0.00263490f, -0.07734269f, 0.03209770f, -0.08814988f, 0.02249034f, -0.03848752f, -0.10876888f, 
    0.22558761f, -0.05063393f, -0.23575397f, 0.10292625f, 0.13269070f, -0.16604628f, 0.02173423f, 0.00340699f, 
    -0.01057129f, -0.00160246f, -0.06474680f, 0.20015480f, 0.01387441f, 0.07317311f, -0.04671951f, -0.05301229f, 
    0.10893847f, -0.08391145f, -0.02552210f, 0.09505201f, 0.15546241f, -0.05091996f, 0.11046910f, -0.06991082f, 
    0.00767317f, -0.08056433f, 0.01950870f, 0.04235380f, 0.05278483f, -0.06123867f, -0.01922342f, -0.00486309f, 
    0.03353148f, 0.05292257f, 0.03364587f, 0.03432176f, -0.07876047f, -0.03380002f, -0.07835217f, -0.08034244f, 
    -0.07103059f, -0.05088592f, 0.03333133f, 0.00204430f, 0.03453973f, -0.06948100f, 0.03766719f, -0.06320085f, 
    -0.03231314f, -0.03165920f, -0.02221863f, -0.05485784f, 0.02561263f, -0.06112624f, -0.05272050f, -0.03873441f, 
    -0.06418648f, 0.00550733f, 0.02399166f, -0.02764090f, -0.00336700f, -0.04788136f, -0.05129083f, -0.07857791f, 
    0.05061847f, 0.03378642f, -0.00078389f, 0.01458025f, -0.02595181f, 0.06135406f, 0.03963163f, -0.03406230f, 
    -0.02010085f, -0.04852308f, -0.00030642f, -0.03364430f, -0.05357301f, 0.03229858f, 0.03138247f, -0.04635578f, 
    -0.07022547f, 0.02137145f, 0.03545076f, -0.06073415f, -0.00942681f, -0.05679040f, -0.02817756f, 0.01031351f, 
    0.04554343f, 0.00463256f, 0.03218665f, 0.00760563f, -0.02073308f, 0.04198797f, -0.00119980f, 0.04412767f, 
    0.05115392f, 0.00576407f, 0.03653834f, -0.07830734f, 0.00047746f, -0.05441815f, -0.00915972f, -0.07729567f, 
    0.01881318f, 0.05836792f, 0.01165488f, -0.06666539f, 0.05505870f, -0.07838527f, 0.00111648f, -0.06844410f, 
    0.06233737f, -0.04437708f, -0.02739460f, -0.02193317f, 0.03336785f, 0.01163124f, 0.05557035f, -0.07041494f, 
    -0.03651816f, -0.03994028f, -0.03923071f, -0.07092483f, 0.05297922f, -0.04604985f, -0.05991788f, -0.01021277f, 
    0.03655184f, -0.02974216f, -0.06811316f, -0.06803163f, -0.05618839f, 0.02251868f, -0.05852200f, 0.02531841f, 
    0.03296066f, -0.04693354f, -0.05724512f, -0.02021924f, 0.04211589f, -0.01824434f, 0.03239939f, -0.00936970f, 
    0.00366778f, 0.02977828f, 0.00472709f, 0.03797626f, 0.00670146f, 0.03715454f, 0.04060278f, 0.06342535f, 
    -0.03356929f, -0.02657864f, 0.01791562f, 0.05703314f, -0.06026093f, -0.02167678f, 0.03654075f, -0.06447039f, 
    0.04053423f, 0.02346160f, -0.01078116f, -0.00726551f, 0.05586949f, -0.01147926f, 0.03735340f, 0.02984126f, 
    -0.06178542f, 0.00026001f, -0.03674580f, -0.04228405f, -0.01315901f, 0.01801816f, 0.03319828f, -0.01457169f, 
    0.01045563f, 0.00931050f, 0.05564038f, 0.04589552f, -0.04785752f, 0.02176617f, -0.00704219f, -0.03534688f, 
    -0.04606848f, -0.03619121f, 0.02061287f, -0.02728694f, 0.00473039f, -0.04628361f, -0.07245009f, -0.03415057f, 
    0.01066461f, -0.04569636f, 0.04914710f, 0.03396101f, -0.03158634f, -0.07747389f, -0.06178680f, 0.01910181f, 
    -0.02240214f, -0.02730448f, -0.02026540f, 0.06088931f, -0.01093964f, 0.01232623f, 0.01726436f, -0.04169728f, 
    -0.06798035f, 0.02800115f, -0.04729471f, -0.08012659f, 0.01395153f, 0.03553398f, 0.02614255f, -0.02224395f, 
    -0.14813612f, 0.26833546f, -0.09133673f, 0.27089959f, -0.10723291f, -0.05114106f, 0.05231838f, 0.05083496f, 
    -0.04030346f, -0.10845724f, -0.10618694f, -0.19323181f, 0.29495609f, -0.36583987f, -0.23025614f, -0.29101536f, 
    0.32295781f, 0.13484327f, 0.03764242f, -0.00876257f, 0.01854946f, 0.01632434f, 0.08420761f, 0.12607652f, 
    0.17556943f, -0.07988338f, 0.04082252f, -0.06365170f, 0.05999080f, 0.15826237f, 0.25880316f, 0.07019442f, 
    0.03554147f, 0.09764761f, 0.10238650f, 0.25610200f, -0.15935260f, -0.28183573f, -0.00231530f, 0.03038488f, 
    0.35089844f, -0.12436395f, -0.07408462f, -0.13936602f, 0.19866908f, 0.04901114f, 0.09787130f, -0.05168035f, 
    0.01713797f, -0.19818439f, 0.15593532f, 0.12036265f, -0.04078757f, -0.06052857f, 0.01569282f, 0.06267282f, 
    -0.01957074f, 0.05133790f, -0.05464709f, -0.06965398f, -0.03295937f, 0.09800298f, 0.24510103f, -0.09943014f, 
    -0.14246364f, -0.14418721f, 0.13321994f, 0.12088633f, 0.05631388f, -0.30069399f, 0.00071302f, 0.04434773f, 
    0.23425530f, 0.17837664f, 0.00274807f, -0.23425007f, -0.08987731f, -0.11181670f, -0.07964474f, -0.02653303f, 
    0.08801667f, 0.15526830f, 0.20018438f, 0.05839282f, -0.08092229f, -0.03304754f, -0.02770584f, 0.08537418f, 
    -0.00068635f, 0.10904696f, 0.05215447f, 0.05093642f, 0.02427101f, 0.06668988f, -0.08197261f, 0.11269218f, 
    0.23959361f, 0.03165299f, 0.15431803f, 0.01850675f, 0.05763330f, -0.10072472f, -0.05100382f, -0.15925123f, 
    -0.02424113f, 0.02247229f, -0.03895478f, 0.08874522f, -0.14084271f, 0.01452540f, 0.03209638f, 0.02516648f, 
    0.11290247f, -0.06367005f, -0.01665640f, 0.20183747f, 0.04955710f, 0.18877883f, 0.34297898f, 0.01602546f, 
    -0.09600119f, -0.09944861f, -0.18500170f, -0.26133993f, 0.20182163f, 0.08451938f, 0.13527893f, 0.03362326f, 
    0.04930737f, 0.03035706f, 0.05543632f, 0.00122858f, 0.44155711f, -0.18883027f, -0.20426403f, 0.17698450f, 
    0.07818733f, -0.01436860f, -0.02273291f, 0.04314634f, 0.18469974f, -0.02713705f, 0.06033718f, 0.06432430f, 
    -0.01912060f, 0.15191744f, -0.02518359f, -0.05563014f, 0.16896392f, -0.07362958f, -0.07119142f, -0.15333290f, 
    0.07452159f, 0.04992963f, -0.03579326f, 0.08374257f, -0.47878322f, -0.05661727f, -0.12396839f, -0.05184251f, 
    -0.06331378f, -0.15186255f, -0.06025840f, 0.11105847f, 0.03605903f, -0.06951793f, 0.02161497f, -0.04885725f, 
    -0.14209601f, -0.08542240f, -0.27425942f, -0.00833175f, 0.13496757f, -0.03452563f, 0.02040240f, -0.06169020f, 
    -0.02905419f, -0.11374143f, 0.13000059f, 0.15928790f, 0.00628699f, 0.23755696f, -0.25347352f, 0.35570535f, 
    -0.08489694f, -0.00463456f, 0.01348181f, 0.22076637f, 0.16217786f, -0.12601627f, -0.17865942f, 0.15621722f, 
    0.02462596f, 0.02687800f, -0.06449767f, -0.02130157f, 0.02698207f, -0.05568298f, -0.07684901f, 0.04602404f, 
    0.06285865f, 0.01543047f, -0.04573918f, -0.01155398f, 0.06088846f, 0.06339987f, 0.04804637f, -0.04585917f, 
    0.04789561f, -0.00103420f, -0.02397159f, 0.00290249f, 0.01995979f, -0.02332016f, -0.06543371f, 0.00634018f, 
    -0.01175153f, 0.01307388f, -0.06240987f, -0.07172801f, 0.02030264f, -0.01103787f, -0.03587260f, 0.06442554f, 
    -0.06564880f, 0.05316894f, 0.01270773f, 0.02092157f, -0.04930994f, 0.03787002f, -0.01542446f, 0.02654455f, 
    0.00903374f, -0.01961060f, -0.00848994f, 0.01821264f, -0.03262172f, -0.02174102f, 0.03561247f, -0.07024965f, 
    -0.03295607f, 0.01714234f, -0.04242340f, -0.05078957f, -0.03420494f, -0.07447247f, -0.02780828f, -0.01814877f, 
    -0.03487962f, -0.04075705f, 0.04218895f, 0.03499307f, -0.00193304f, 0.05269969f, 0.02412235f, 0.00043405f, 
    -0.04142663f, -0.00449783f, 0.03449630f, 0.05950299f, -0.00977291f, -0.04877012f, 0.03446982f, 0.01711764f, 
    -0.01792042f, 0.00199171f, -0.07474186f, 0.04731309f, -0.00160111f, -0.01982846f, -0.06498376f, -0.03909364f, 
    -0.02470062f, -0.07434881f, 0.06069554f, -0.02597771f, -0.04606114f, 0.03401769f, 0.01970850f, -0.02735661f, 
    0.02723467f, 0.04343987f, -0.03920511f, -0.02120948f, -0.01738721f, 0.04944918f, 0.06543835f, -0.07415918f, 
    0.03485826f, 0.00571233f, 0.06213816f, -0.06231207f, -0.03356594f, -0.04707292f, -0.04920212f, -0.03492654f, 
    -0.07100285f, 0.05838353f, 0.03298875f, -0.06450741f, 0.04680295f, -0.07216953f, 0.01743315f, 0.01996674f, 
    -0.02544832f, -0.05662826f, 0.03116306f, -0.01686972f, -0.00615558f, 0.05941803f, 0.04842161f, -0.06043433f, 
    -0.02240217f, -0.04757876f, 0.03111470f, -0.06507718f, -0.02583079f, -0.05397346f, 0.00071976f, -0.03105045f, 
    0.03988148f, -0.04859793f, -0.05945989f, -0.06650022f, -0.04600282f, -0.03307400f, -0.04360180f, -0.04245359f, 
    -0.00693419f, -0.01254209f, 0.04376809f, -0.05803478f, -0.04262647f, -0.01269018f, -0.06637394f, -0.05151241f, 
    0.01096010f, -0.05412226f, 0.06052035f, 0.02031931f, -0.03264892f, 0.02389087f, -0.01664225f, 0.04991040f, 
    -0.04015172f, 0.06692889f, 0.05052756f, -0.04752392f, -0.00110724f, 0.05116496f, -0.06467258f, -0.02559809f, 
    -0.05167006f, -0.01262075f, -0.02757012f, -0.02557967f, -0.04005336f, 0.03486378f, -0.01941204f, 0.04969973f, 
    0.04431658f, 0.03213027f, -0.04187289f, -0.03590146f, 0.02704200f, 0.04004897f, 0.00755617f, -0.04604026f, 
    -0.02615855f, 0.00057676f, -0.01247715f, -0.05472104f, -0.05163302f, 0.04436037f, -0.03904162f, -0.00629190f, 
    -0.07035094f, 0.05530474f, 0.04988104f, -0.07098587f, 0.03417866f, 0.01455191f, 0.01841194f, 0.02160107f, 
    0.26465130f, -0.01944575f, -0.00846097f, -0.24606037f, -0.16956475f, 0.07746185f, -0.01620729f, 0.01252721f, 
    0.13649534f, 0.12834968f, -0.17246132f, 0.09311425f, -0.41613916f, -0.06294352f, 0.01210485f, 0.09235857f, 
    0.10542433f, 0.23541747f, -0.09590205f, -0.05448116f, -0.00526499f, 0.03046260f, -0.07242245f, 0.17588569f, 
    -0.18123171f, -0.04657091f, -0.07450097f, 0.28121153f, 0.15110651f, 0.03002017f, 0.04806595f, 0.09886715f, 
    0.01177648f, -0.03292678f, 0.10556534f, 0.08102206f, 0.17157432f, 0.12605111f, -0.03422717f, 0.07830260f, 
    -0.01854313f, 0.12142818f, -0.15406139f, -0.05973704f, -0.09393921f, -0.24789442f, -0.21874112f, -0.10574357f, 
    0.23401490f, -0.05683290f, 0.22106554f, -0.04064922f, 0.05925710f, 0.06983917f, 0.11873803f, -0.04583747f, 
    -0.07266465f, 0.10356973f, -0.11394016f, -0.07000072f, -0.45072842f, 0.05295001f, -0.23994243f, 0.11357283f, 
    -0.05212982f, -0.04140687f, 0.03152914f, -0.17414151f, 0.03733969f, -0.00319425f, 0.08802885f, 0.10505053f, 
    0.24458620f, 0.24842779f, 0.00387353f, 0.10259702f, -0.09427947f, -0.04304303f, 0.16057666f, 0.19580303f, 
    -0.14280814f, 0.01936610f, 0.25551859f, 0.22020611f, 0.01374911f, -0.08709722f, 0.28961709f, 0.12492871f, 
    0.00774696f, 0.08923816f, 0.01605312f, 0.05124095f, -0.04570914f, -0.30881315f, 0.02266968f, -0.07677183f, 
    -0.00757427f, 0.05576846f, 0.06829750f, -0.07500905f, -0.00792807f, 0.13713807f, -0.11440873f, 0.04096522f, 
    0.04461195f, -0.05450426f, 0.04417160f, 0.14503676f, -0.06077607f, -0.06990710f, 0.30597213f, -0.11583846f, 
    0.12632908f, -0.13388719f, 0.00488180f, -0.13811289f, -0.03891951f, 0.11561140f, 0.29536548f, 0.02712300f, 
    -0.08732332f, -0.25443617f, 0.14129172f, 0.10775968f, 0.14628956f, -0.01426178f, 0.14474565f, -0.03987297f, 
    0.10870028f, -0.01047342f, 0.13432358f, 0.24830888f, -0.08855005f, -0.07463153f, -0.01915041f, 0.05878282f, 
    0.05306251f, -0.00876556f, 0.13263154f, 0.10709769f, 0.19176744f, -0.13431057f, 0.16056147f, -0.04111639f, 
    0.36024445f, 0.06111387f, -0.23607242f, 0.13683158f, -0.14859715f, 0.00756475f, 0.06462832f, 0.09124676f, 
    0.22555384f, 0.03429202f, 0.05197003f, -0.01007573f, -0.10025257f, -0.11736616f, 0.12314124f, 0.04034012f, 
    0.11984167f, -0.06848513f, -0.00194683f, 0.05810914f, 0.05894538f, 0.08442667f, 0.12842099f, -0.08513516f, 
    -0.11123472f, 0.15365890f, 0.05675401f, -0.16549112f, 0.15107909f, -0.12314107f, -0.06988848f, 0.02033226f, 
    0.01825950f, 0.03683910f, -0.12759101f, 0.40852857f, 0.16199094f, -0.28123578f, -0.00875941f, -0.16942337f, 
    0.13460086f, 0.20120452f, 0.04892387f, 0.00397305f, 0.19853397f, -0.06840333f, 0.00411503f, -0.11010820f, 
    0.21527390f, -0.19926859f, 0.31599334f, -0.16638951f, -0.04195508f, -0.04835787f, 0.02332883f, 0.15458038f, 
    0.12239165f, 0.09047195f, 0.02759307f, 0.10511278f, 0.21198501f, 0.15850194f, 0.35642433f, 0.10243951f, 
    0.01490327f, -0.07031510f, 0.03854708f, -0.04948984f, 0.06521497f, 0.12464221f, -0.21864969f, 0.18349908f, 
    0.26361120f, 0.27570453f, 0.44255048f, -0.08245865f, 0.09640876f, 0.06808858f, -0.01228217f, 0.05660494f, 
    0.06648245f, 0.03781014f, 0.01960036f, 0.07704099f, 0.26741120f, 0.26587322f, 0.09864078f, -0.09796097f, 
    0.12683254f, 0.18242407f, -0.08829471f, -0.00668380f, -0.00274151f, -0.04754025f, -0.09132680f, 0.02394343f, 
    0.01258649f, -0.18001522f, 0.00595052f, -0.04744682f, 0.13680884f, 0.14704771f, -0.02686473f, 0.11708906f, 
    0.16616599f, -0.00326151f, -0.07469154f, -0.02926780f, -0.29212236f, -0.15471679f, -0.13479435f, -0.07006822f, 
    0.03885116f, -0.06064093f, -0.01802506f, 0.02287991f, 0.02298684f, 0.19015299f, 0.04413045f, 0.09095713f, 
    -0.07404710f, 0.05479270f, -0.05078293f, -0.03294518f, 0.11464445f, 0.07516325f, 0.12512203f, 0.25267732f, 
    0.03067964f, 0.24038944f, -0.00547985f, 0.08087721f, -0.23882531f, -0.19420950f, 0.09854506f, -0.09032185f, 
    -0.00338616f, 0.11146855f, 0.09821358f, 0.20607644f, 0.01320059f, -0.18040872f, -0.13750888f, -0.15941904f, 
    0.45418763f, 0.00394058f, -0.46077630f, -0.03057099f, 0.05035581f, -0.00339646f, 0.01090940f, 0.05385674f, 
    0.03995961f, 0.00417138f, 0.26329529f, 0.04610069f, -0.27615973f, -0.17013082f, 0.14985113f, 0.06407141f, 
    0.05551996f, -0.08362442f, -0.16362718f, -0.04620298f, 0.03703763f, 0.18703015f, 0.15698935f, 0.16048318f, 
    -0.09286953f, -0.07643838f, 0.31669593f, -0.31833670f, 0.04551021f, 0.03208074f, 0.03069841f, -0.07452065f, 
    0.05046942f, 0.00383417f, 0.09148839f, 0.10389243f, -0.16476409f, 0.01854485f, 0.14744325f, 0.02715390f, 
    0.07036454f, 0.03522264f, 0.09982336f, 0.14904444f, -0.08392120f, -0.05844331f, -0.07243869f, 0.03641087f, 
    -0.01834811f, -0.15856254f, -0.19816685f, -0.12887758f, -0.24243988f, 0.00513866f, 0.01433321f, 0.18732460f, 
    0.14753570f, 0.13393041f, 0.10094759f, -0.04984335f, -0.25982630f, -0.02045186f, -0.27138633f, -0.00689728f, 
    -0.02775828f, -0.02272297f, -0.02489927f, 0.02190752f, 0.06184336f, -0.02670250f, -0.07475679f, -0.03158530f, 
    0.23763248f, 0.17223974f, -0.23431033f, 0.09629459f, 0.07646935f, -0.08273876f, 0.01513209f, 0.07451618f, 
    -0.00915741f, 0.02005867f, -0.08733695f, 0.16459511f, 0.16318817f, -0.30268726f, 0.04431696f, -0.24479663f, 
    0.12162977f, 0.03475240f, 0.12881610f, 0.02756405f, 0.11963826f, -0.00628963f, 0.12082413f, -0.14542238f, 
    0.05586405f, -0.07605152f, 0.03346067f, 0.04311907f, -0.02450485f, 0.05187378f, -0.07860794f, -0.00837722f, 
    -0.03796369f, 0.01030620f, -0.06238285f, -0.00163004f, 0.01295408f, 0.05425132f, -0.03865576f, -0.02028904f, 
    0.02130723f, -0.06940991f, -0.07619907f, -0.05998037f, 0.04142867f, -0.01515653f, 0.00454448f, 0.05782666f, 
    -0.07438349f, -0.03363278f, 0.01610895f, -0.01854551f, -0.02836395f, 0.00723262f, -0.05783836f, -0.03251460f, 
    -0.07678536f, 0.02596832f, -0.06314635f, 0.06217784f, -0.02303111f, 0.03238312f, 0.03893257f, -0.04597569f, 
    0.05416186f, 0.01345760f, -0.03771433f, -0.03587195f, -0.01139388f, 0.06099672f, -0.04686797f, -0.01695058f, 
    -0.04978351f, -0.02418628f, -0.05072221f, -0.06254072f, -0.02179599f, -0.04112125f, -0.03287251f, 0.03684751f, 
    -0.03885176f, -0.06231876f, -0.05873388f, -0.05862222f, -0.07044678f, -0.01034306f, 0.01149418f, -0.00537485f, 
    -0.00292912f, 0.02021058f, 0.02571983f, 0.02229162f, 0.00033289f, 0.00217364f, 0.02620659f, -0.00991641f, 
    -0.01964515f, 0.03101927f, 0.03840071f, -0.04911023f, 0.01119484f, -0.02467611f, -0.06686646f, 0.04448102f, 
    -0.00625858f, -0.05824976f, 0.00526737f, -0.03063339f, 0.00538401f, -0.06469146f, -0.06510571f, 0.04612879f, 
    -0.02505445f, 0.05630304f, 0.03129975f, 0.02867092f, -0.07747311f, 0.01144788f, -0.07357093f, -0.02018066f, 
    -0.01757996f, 0.05806531f, 0.05888386f, -0.06659175f, 0.01272462f, -0.07515193f, -0.03850108f, 0.00694308f, 
    -0.04736874f, 0.01394012f, 0.02970244f, -0.04154347f, 0.04197307f, -0.03338498f, -0.02942209f, -0.03817584f, 
    -0.03278480f, -0.07317093f, -0.02712564f, -0.00485003f, -0.00327060f, -0.06606907f, 0.05326626f, 0.00241958f, 
    0.03336147f, 0.02028100f, -0.01354104f, -0.02611172f, -0.01550735f, -0.07599392f, 0.01495545f, 0.03306269f, 
    0.00635073f, 0.00715459f, -0.05543299f, -0.04346718f, 0.04578130f, -0.02895849f, 0.04091905f, 0.03294385f, 
    0.05082783f, -0.04058852f, -0.02591675f, -0.06798591f, 0.02062272f, -0.03131309f, -0.06581039f, -0.06115723f, 
    -0.06891011f, 0.02357007f, -0.02280277f, -0.00506804f, -0.00057444f, -0.02002567f, -0.00099722f, 0.01973561f, 
    0.04882034f, 0.05688820f, -0.00608504f, -0.01311354f, -0.01796108f, -0.04885941f, -0.00443163f, -0.03813820f, 
    -0.05400380f, 0.01402544f, 0.02755015f, 0.05470575f, -0.02728966f, 0.04191363f, -0.06193070f, 0.06100644f, 
    0.02940222f, -0.04815781f, 0.00340272f, -0.07691228f, -0.06264940f, -0.08174825f, 0.01148419f, 0.06049988f, 
    -0.05592994f, 0.04518806f, 0.06323946f, -0.00483633f, -0.02503459f, -0.06675667f, 0.00405393f, 0.00372800f, 
    0.01930360f, 0.04673083f, -0.00695035f, 0.01917161f, 0.05828745f, -0.03151238f, 0.02474805f, -0.03500645f, 
    -0.33455372f, 0.28669357f, -0.06595640f, 0.35654470f, 0.01839108f, -0.03590892f, 0.09891430f, 0.10235956f, 
    -0.11844499f, -0.05375661f, 0.22909880f, -0.05304114f, 0.17156431f, -0.05510573f, -0.20688109f, -0.03559385f, 
    0.07835551f, 0.00501618f, 0.08305002f, 0.07272624f, 0.11557628f, 0.00980537f, 0.11442275f, -0.13515395f, 
    0.14434616f, -0.17090757f, -0.06541594f, -0.05877924f, -0.09866641f, -0.03881333f, 0.04681079f, -0.11660835f, 
    0.00409057f, 0.03843787f, 0.08250668f, 0.05268089f, -0.08954766f, -0.15175240f, -0.13013531f, 0.17551656f, 
    0.12151278f, -0.13869651f, 0.11668310f, -0.04397495f, 0.09821140f, 0.15310603f, 0.19874951f, 0.10537425f, 
    -0.21416602f, 0.05703464f, -0.12089830f, 0.04908423f, -0.20812817f, -0.09525704f, -0.12403898f, 0.12653685f, 
    -0.02544781f, 0.03788037f, 0.14300838f, 0.03806765f, 0.23007178f, 0.04977432f, 0.23085999f, -0.01510691f, 
    -0.21342647f, -0.05027684f, -0.02526659f, 0.24459676f, 0.03983877f, -0.05754293f, 0.04869136f, 0.03385073f, 
    0.10412193f, 0.07619119f, 0.01709995f, -0.11885476f, 0.04992025f, -0.04117895f, 0.00660238f, -0.14157347f, 
    0.18545842f, 0.00784888f, 0.04519504f, 0.01239346f, 0.08788636f, 0.15544857f, -0.12492947f, -0.04616271f, 
    0.05719555f, -0.02684799f, 0.02658171f, -0.05576489f, 0.02845066f, 0.38144013f, 0.03293853f, 0.14901973f, 
    -0.27007121f, 0.11169519f, 0.10213484f, 0.07053766f, -0.05199693f, -0.07563009f, 0.08935283f, -0.10336997f, 
    0.02892261f, 0.02810357f, -0.06807832f, -0.02755435f, 0.06946602f, 0.06442486f, -0.01054872f, 0.19996338f, 
    -0.12764376f, 0.03370929f, 0.17763397f, 0.06513456f, 0.11405527f, -0.02517002f, -0.18526261f, -0.01467219f, 
    0.00838895f, 0.16387214f, -0.15081942f, -0.27752295f, 0.08160736f, 0.06236781f, -0.08693019f, -0.02724623f, 
    0.07579371f, 0.05076288f, -0.10439996f, -0.03325849f, 0.34556109f, -0.03138595f, 0.02913547f, 0.09050151f, 
    -0.04108690f, 0.00386538f, -0.10874008f, -0.11643114f, -0.02046829f, -0.02147800f, 0.11748357f, 0.04654527f, 
    -0.18005972f, 0.12268675f, 0.07643150f, -0.05804036f, 0.20235300f, 0.06694552f, -0.05975111f, -0.18790126f, 
    -0.09401886f, -0.08415972f, 0.00041484f, 0.12365679f, -0.09854145f, -0.01881443f, -0.05778381f, -0.09666321f, 
    -0.03055346f, -0.05892861f, 0.06366303f, -0.04440662f, -0.02929106f, -0.08114020f, 0.02652130f, 0.07826231f, 
    0.01134927f, -0.20916115f, -0.08813231f, 0.15034151f, 0.02525742f, 0.02194327f, -0.01692384f, -0.02552994f, 
    -0.21713407f, -0.06082714f, 0.13136257f, -0.16476689f, -0.26205626f, 0.54615986f, 0.01015765f, 0.23787729f, 
    -0.14158690f, -0.04137673f, -0.13872632f, 0.12588577f, 0.09932213f, 0.01388372f, -0.03545785f, 0.19386201f, 
    -0.22935559f, 0.09417391f, 0.02666259f, 0.18365110f, -0.03701380f, -0.13727182f, -0.04347549f, 0.15417880f, 
    0.12141254f, 0.09534661f, 0.35801405f, -0.01374543f, -0.08601496f, 0.35926536f, 0.04078185f, -0.25232247f, 
    0.11006963f, -0.03626849f, 0.05737198f, -0.02551332f, 0.17055549f, -0.15249099f, 0.09987897f, -0.00600086f, 
    0.04149279f, 0.05667242f, 0.11214908f, -0.05101154f, 0.06790742f, -0.02805597f, -0.10758080f, -0.07638846f, 
    -0.09462150f, -0.05946112f, -0.08226900f, -0.08215024f, -0.03993537f, -0.24440189f, -0.15707587f, -0.34353560f, 
    -0.02416981f, -0.11281839f, 0.14341588f, 0.03823986f, 0.10208474f, 0.11182515f, 0.15358283f, 0.10646787f, 
    0.27738070f, 0.42595416f, 0.02230344f, 0.24881351f, -0.31235874f, -0.08533392f, -0.06186828f, 0.09637292f, 
    -0.07432940f, 0.14925863f, 0.25738290f, 0.17814296f, -0.22013260f, 0.23492561f, 0.01661174f, 0.01936789f, 
    -0.02922605f, 0.03798863f, 0.06456813f, 0.21345113f, -0.08156040f, 0.16451918f, 0.04559512f, -0.03517616f, 
    0.28433394f, 0.15854965f, 0.09647185f, -0.00532385f, 0.05205544f, -0.11779168f, 0.07881789f, -0.27282017f, 
    -0.04505460f, -0.09683587f, -0.14309564f, -0.19682382f, 0.03263770f, 0.04792492f, -0.03558695f, 0.24896650f, 
    0.07725691f, -0.03882733f, -0.01498921f, 0.07890174f, -0.01613288f, 0.26159474f, 0.10954565f, 0.14640136f, 
    0.28720617f, 0.17753543f, 0.08865654f, 0.22237192f, -0.03350190f, -0.01661100f, 0.08455615f, 0.10316102f, 
    -0.09509234f, 0.06630024f, 0.10926066f, -0.22041407f, 0.02349795f, 0.31788301f, 0.13337272f, -0.21963763f, 
    0.04202127f, 0.08023633f, 0.04921157f, 0.01538970f, -0.00542405f, -0.09835178f, -0.17080991f, -0.22169030f, 
    0.15112598f, -0.11044952f, -0.27302217f, -0.04518885f, 0.19393761f, 0.02747224f, 0.01336949f, -0.05952891f, 
    0.10853491f, 0.27341697f, -0.01523478f, -0.12719947f, -0.24134058f, 0.12008516f, -0.17876956f, -0.07919008f, 
    -0.01471382f, 0.08972514f, -0.04404839f, -0.10275166f, -0.29354271f, 0.07870337f, 0.07146583f, -0.03852743f, 
    0.27920184f, 0.20680994f, -0.04159386f, 0.33603144f, 0.00352259f, -0.06841430f, -0.15132841f, -0.10496837f, 
    -0.16809376f, 0.05454258f, 0.07842245f, 0.03880173f, 0.18598104f, -0.09555100f, -0.07868119f, -0.02410569f, 
    -0.11523081f, -0.03331703f, 0.03362602f, -0.13338393f, -0.15529668f, -0.05739700f, 0.00023951f, 0.18997996f, 
    -0.17050193f, -0.14984269f, -0.00439553f, -0.26259097f, 0.04672199f, 0.08299232f, -0.01209269f, -0.02317147f, 
    -0.17114526f, -0.11201830f, -0.20960101f, -0.30064297f, 0.11391486f, 0.37475842f, -0.06853134f, 0.20804109f, 
    -0.06635020f, 0.05825284f, 0.06545458f, 0.03202905f, 0.04341859f, -0.02609455f, -0.02315942f, 0.02560650f, 
    -0.05932234f, -0.20248370f, -0.07289094f, -0.13250798f, 0.02858896f, 0.08466263f, -0.03921090f, 0.03712203f, 
    0.01075785f, 0.04425307f, 0.25053629f, 0.09842895f, 0.07780472f, 0.04637729f, -0.01934723f, 0.04325652f, 
    -0.13954489f, -0.04962951f, -0.02911671f, 0.02277793f, 0.08368823f, -0.07398494f, 0.08287977f, 0.04575618f, 
    -0.31699297f, -0.10821843f, -0.01672790f, 0.36455116f, -0.07663504f, -0.06177654f, -0.05662403f, -0.03371062f, 
    -0.14302719f, -0.03899170f, -0.07808701f, -0.09803264f, 0.30794904f, -0.17619473f, 0.05548431f, 0.20846668f, 
    -0.12155801f, 0.02720517f, 0.17533706f, 0.11302498f, 0.06202926f, -0.00392746f, 0.24613963f, 0.27246726f, 
    -0.11204229f, 0.06753454f, 0.11382062f, -0.12139094f, -0.23188646f, -0.14089410f, -0.01538759f, -0.02630355f, 
    0.12467642f, 0.15331376f, 0.14090829f, 0.15117449f, -0.22219402f, -0.22967461f, -0.09748948f, -0.28753173f, 
    -0.15936087f, -0.02343432f, 0.08487739f, 0.13186400f, -0.00931747f, 0.13210909f, 0.02218095f, 0.14678417f, 
    -0.17968319f, -0.15678614f, -0.05897848f, 0.03509454f, -0.02103013f, 0.18153162f, 0.17839800f, -0.00550787f, 
    -0.10453401f, 0.07221024f, -0.11130417f, -0.15150215f, -0.00168787f, -0.01619889f, 0.19839358f, -0.14904320f, 
    -0.06529625f, -0.22822307f, -0.03794149f, 0.01744127f, 0.10701296f, 0.13854651f, -0.07185519f, 0.14003207f, 
    -0.17790276f, 0.11493299f, -0.09842295f, 0.14627051f, 0.06535826f, 0.04944069f, 0.03770772f, 0.28185916f, 
    0.10232472f, 0.09758238f, 0.00422913f, -0.07471001f, 0.15639156f, -0.07959256f, 0.05349343f, 0.10389969f, 
    -0.06395300f, 0.05692590f, 0.08297625f, -0.04928678f, 0.16097485f, 0.00340904f, -0.13569935f, 0.11618803f, 
    0.34217882f, -0.10926880f, 0.08699051f, 0.01795576f, 0.08695266f, -0.04655815f, 0.06848902f, 0.05888389f, 
    0.06111571f, 0.02512030f, -0.07851784f, -0.00472636f, 0.29835895f, -0.09892581f, 0.04894633f, 0.04900355f, 
    0.05441269f, 0.00349684f, -0.12027645f, -0.05302928f, -0.12143397f, 0.12600996f, 0.05715640f, 0.05538544f, 
    -0.13691111f, -0.07901949f, -0.11693736f, -0.08313247f, 0.03699668f, 0.04350403f, 0.18586330f, 0.19771588f, 
    0.13714217f, -0.03373903f, 0.06667386f, 0.13460189f, 0.38260344f, 0.11250876f, 0.02724536f, 0.07614159f, 
    0.00712108f, 0.22257796f, 0.06571166f, -0.00574438f, -0.02746217f, 0.01252157f, 0.00687590f, 0.06402194f, 
    -0.06007395f, 0.19127336f, 0.27692416f, -0.01282499f, -0.25882325f, 0.10251812f, -0.11817049f, 0.01448084f, 
    -0.06620360f, 0.01660770f, -0.02100138f, -0.09665912f, 0.17584105f, -0.37588507f, 0.11813154f, -0.21353139f, 
    0.08783059f, 0.08559766f, 0.01178426f, 0.06008002f, -0.02170407f, 0.04913628f, 0.04721760f, -0.00624110f, 
    -0.28299841f, -0.15317293f, 0.06937340f, 0.00194150f, -0.03809875f, -0.13208359f, -0.02687568f, 0.13159509f, 
    0.19100432f, 0.14895390f, -0.27583441f, 0.00115189f, 0.26230484f, 0.08874611f, -0.04628695f, -0.27825585f, 
    0.11507188f, 0.10060910f, -0.04110191f, 0.15186076f, -0.11781911f, 0.16746871f, 0.09323803f, 0.07270228f, 
    0.49783713f, 0.17488638f, -0.19911267f, -0.14966978f, 0.08026360f, 0.17831874f, 0.09762988f, 0.02910179f, 
    0.15330528f, -0.12061382f, 0.18552044f, 0.02834934f, -0.02872700f, 0.08734020f, 0.10297687f, -0.31024680f, 
    -0.03461829f, 0.00846399f, -0.07823289f, -0.00953318f, 0.01711115f, 0.13927117f, 0.16029973f, 0.04432654f, 
    -0.47595993f, -0.33987081f, -0.24041606f, 0.33353493f, -0.10000995f, -0.14671549f, 0.06791010f, -0.08474824f, 
    -0.00542900f, 0.11488549f, -0.20256238f, 0.01989530f, -0.10451273f, -0.14507362f, 0.19142106f, 0.09230966f, 
    0.00515566f, -0.24848177f, -0.11416187f, -0.00575327f, 0.02032858f, -0.14818738f, 0.18715465f, -0.09178146f, 
    -0.29318789f, -0.34167790f, 0.04159096f, 0.03781028f, -0.30918306f, 0.08493702f, 0.01903439f, -0.08888701f, 
    -0.08903448f, -0.08341638f, -0.02318627f, 0.27180025f, -0.40970474f, 0.03888866f, -0.00798574f, 0.09907003f, 
    0.13989909f, -0.12883654f, 0.17675875f, 0.02753770f, 0.12398992f, -0.04901862f, 0.16139984f, 0.00663269f, 
    -0.00479562f, -0.32634538f, -0.00961292f, -0.08404343f, -0.02756115f, 0.03833696f, -0.13144158f, 0.07385063f, 
    0.01546113f, -0.02616246f, 0.15513110f, 0.19879667f, -0.06224987f, -0.00157209f, -0.12461361f, -0.11210552f, 
    0.12291906f, -0.02970784f, -0.00819173f, 0.29796091f, -0.03262324f, 0.18566164f, 0.24615768f, 0.18519612f, 
    -0.48867282f, -0.47627243f, -0.13743497f, -0.11443041f, 0.12206879f, 0.03543787f, -0.04193991f, 0.17962053f, 
    0.03587324f, -0.32508817f, 0.05813717f, 0.06190120f, 0.08652607f, -0.03123414f, -0.03580160f, -0.16608495f, 
    -0.02667733f, 0.12198132f, 0.07944480f, 0.19878310f, 0.16079071f, -0.02804362f, -0.16379283f, 0.04438731f, 
    -0.22268997f, -0.08595290f, 0.22798321f, 0.15722826f, -0.07615003f, 0.00291699f, -0.07714158f, 0.20239867f, 
    0.10234679f, 0.10376110f, 0.10013343f, 0.02404332f, -0.15638253f, -0.10186654f, -0.34651831f, -0.15422189f, 
    -0.14514123f, -0.16313802f, -0.04004253f, -0.01183177f, 0.04757859f, -0.05453283f, -0.03502623f, 0.00973138f, 
    0.17873123f, -0.00537036f, -0.03176850f, -0.37562570f, 0.13998568f, 0.01236354f, -0.01305840f, 0.03578006f, 
    0.10507610f, -0.09858131f, -0.09664478f, 0.20908457f, -0.13544390f, 0.02612566f, 0.03651341f, -0.01367551f, 
    -0.13092938f, -0.20881520f, 0.08154603f, 0.08063403f, 0.05379518f, 0.16338003f, 0.11042823f, -0.03783303f, 
    -0.11819555f, -0.22656299f, 0.02062838f, 0.35470507f, 0.11299537f, -0.00681084f, 0.05821554f, 0.05231433f, 
    -0.03844778f, -0.02550277f, 0.08958428f, -0.01368092f, 0.60513449f, 0.04737093f, -0.11926580f, -0.09179374f, 
    -0.08389116f, -0.12206230f, 0.05285754f, 0.08864734f, -0.04283762f, 0.07156833f, 0.07190457f, -0.07233258f, 
    -0.16491678f, -0.26189628f, 0.23505379f, -0.03384957f, -0.13183208f, -0.05032163f, -0.07354217f, -0.13662754f, 
    0.03565705f, 0.02397077f, 0.01986369f, -0.00124440f, 0.12416376f, -0.20031184f, 0.14350688f, 0.01258537f, 
    0.04931202f, 0.00961460f, 0.20203519f, 0.05417803f, 0.05575969f, 0.01536651f, 0.22831044f, 0.01817992f, 
    0.19807976f, 0.10346475f, 0.02307330f, -0.02731420f, -0.25112203f, -0.20421673f, -0.06952205f, 0.08533090f, 
    0.04814216f, 0.01777342f, 0.07093054f, 0.06785470f, 0.03711548f, 0.15381661f, 0.03669244f, -0.10915148f, 
    -0.15264308f, -0.04898559f, 0.17082788f, 0.26519874f, -0.08273552f, 0.01305855f, -0.08564012f, -0.17062727f, 
    0.10845809f, 0.00295264f, -0.07793403f, -0.10604440f, 0.07753204f, -0.03879490f, 0.02458281f, 0.00430787f, 
    0.16379814f, 0.04084748f, -0.15308246f, -0.24136379f, 0.22153239f, 0.10012151f, -0.16710293f, -0.13794617f, 
    0.00763467f, -0.10726843f, 0.06476399f, -0.08431268f, 0.01350108f, 0.15938275f, 0.03070731f, 0.12015937f, 
    0.08737936f, 0.13001853f, 0.24220930f, 0.01251085f, -0.04581850f, 0.02010997f, 0.05521586f, 0.10065788f, 
    -0.17933203f, 0.04329522f, -0.07960643f, -0.15011188f, 0.15770088f, 0.11429967f, -0.14914478f, 0.26528031f, 
    -0.01310292f, 0.08901743f, 0.09954178f, 0.15461513f, 0.16174054f, -0.16119541f, -0.17731327f, -0.16576704f, 
    0.24924077f, -0.10719246f, -0.09686071f, 0.07339974f, 0.05403937f, 0.14632055f, 0.08430431f, -0.00508349f, 
    0.07767091f, 0.21528593f, -0.00242674f, -0.14278267f, 0.46523538f, -0.24708217f, -0.06036056f, 0.09643631f, 
    -0.06721704f, -0.03698463f, -0.02920104f, -0.12001243f, -0.10316555f, 0.24119900f, 0.00252227f, 0.07072843f, 
    -0.13973951f, 0.06820583f, -0.09389420f, 0.00582032f, -0.02234300f, -0.09518839f, -0.02535323f, -0.06143644f, 
    0.00612226f, -0.06278720f, 0.03015216f, -0.02125098f, -0.11081560f, -0.02558936f, -0.03212550f, -0.13193701f, 
    -0.01660179f, 0.28909767f, 0.00076935f, 0.06214553f, -0.17372322f, 0.00060768f, 0.02850317f, -0.05761548f, 
    0.16460083f, -0.02555286f, 0.00797549f, -0.01973535f, -0.24601048f, 0.11737987f, -0.02608988f, 0.04443396f, 
    -0.09091229f, -0.06832268f, -0.01530139f, -0.17671882f, 0.20254341f, -0.09257445f, 0.00544088f, -0.02990840f, 
    0.04519518f, -0.04206713f, 0.03256556f, -0.00070162f, -0.12557220f, -0.03770366f, -0.02608135f, 0.04569614f, 
    -0.39480186f, -0.13069811f, 0.02387363f, 0.20466261f, 0.01787723f, 0.13248158f, -0.05126193f, 0.11992897f, 
    -0.02923837f, -0.08818626f, -0.06576630f, 0.06884083f, 0.32921955f, -0.19545156f, 0.15972818f, 0.04067854f, 
    0.14110225f, -0.22483204f, 0.02498272f, -0.14331706f, -0.13152841f, 0.13020360f, -0.03898374f, 0.22360358f, 
    -0.45438385f, -0.38707343f, 0.04914982f, -0.00483560f, 0.00665059f, 0.19766125f, 0.18657342f, 0.00385559f, 
    0.12715806f, -0.06094524f, 0.05971658f, 0.08356637f, 0.18513484f, 0.22442654f, 0.26905349f, 0.00516818f, 
    0.19771908f, 0.12647407f, -0.05103008f, 0.07224423f, -0.06357531f, 0.09898313f, 0.09416428f, -0.05354010f, 
    0.04954419f, -0.35101351f, 0.10657446f, 0.00519679f, -0.00888904f, -0.06833271f, 0.01565789f, 0.15976027f, 
    0.08967476f, -0.16991660f, -0.07819096f, 0.13353680f, -0.33683342f, -0.00950162f, 0.08524103f, 0.04719847f, 
    0.03047907f, -0.14388967f, -0.03621510f, 0.19880982f, 0.05195812f, -0.08944973f, 0.02436501f, 0.01558085f, 
    0.21818054f, 0.13018459f, -0.18554714f, -0.14609487f, 0.17316128f, 0.04441310f, -0.03615350f, 0.19889683f, 
    0.03567453f, 0.02838527f, 0.08003319f, 0.18843527f, 0.19214612f, -0.36659890f, -0.36800054f, -0.00887165f, 
    0.03923502f, 0.06902220f, 0.17478269f, -0.01705941f, -0.16913727f, -0.03360816f, -0.10958950f, -0.12452659f, 
    -0.18732172f, -0.14893779f, 0.14640617f, -0.31483677f, -0.04746281f, 0.10281865f, -0.03116599f, -0.00641477f, 
    0.08593591f, -0.08884528f, 0.15909338f, 0.05799085f, -0.26479360f, -0.12030265f, 0.00704397f, 0.05541074f, 
    -0.08913130f, 0.02861327f, 0.12958671f, -0.09818196f, 0.02000437f, -0.05547277f, 0.00153940f, -0.14343397f, 
    -0.34871832f, 0.01817994f, 0.19412979f, -0.01163646f, 0.01522498f, 0.00231192f, 0.20512408f, -0.05762041f, 
    0.06212060f, 0.03097341f, 0.30715835f, 0.07965094f, 0.29547262f, -0.03291452f, -0.08897535f, -0.14907508f, 
    -0.03814278f, 0.09829926f, -0.06654999f, -0.04806523f, 0.06087022f, 0.06989156f, -0.02505799f, 0.07318190f, 
    -0.55600435f, -0.18710566f, 0.04409866f, -0.10027287f, 0.08682307f, -0.05256440f, -0.00119219f, -0.13065934f, 
    0.15640745f, -0.02653536f, 0.06794208f, 0.08243927f, 0.02125288f, -0.01605384f, -0.19351700f, -0.41319674f, 
    0.18340163f, 0.08804899f, 0.03059856f, 0.15161534f, 0.14122255f, 0.09849867f, -0.01589662f, -0.01310659f, 
    0.38522369f, -0.04415403f, -0.03409834f, 0.23465680f, -0.00403664f, -0.01078110f, -0.06480180f, -0.06420457f, 
    0.06078888f, 0.12056785f, -0.07788534f, 0.32208753f, 0.18393254f, 0.06171387f, 0.06279561f, -0.05824492f, 
    -0.05192744f, 0.10110307f, -0.07308796f, -0.01101588f, 0.08770142f, -0.03833627f, 0.12153342f, -0.04701591f, 
    -0.14946708f, 0.02194483f, -0.19882919f, 0.00200653f, 0.05857131f, 0.05974945f, 0.05410573f, -0.02692390f, 
    0.05463331f, 0.00227834f, -0.09705524f, -0.04161451f, -0.32929853f, -0.42537603f, 0.03196241f, 0.07337265f, 
    -0.07776845f, -0.01352362f, -0.08236063f, -0.00070761f, 0.01144715f, 0.06377104f, 0.01135676f, 0.04287785f, 
    -0.40101728f, -0.34645873f, -0.14615768f, 0.14647157f, 0.03657571f, -0.08611207f, 0.01430734f, 0.05334920f, 
    0.04399717f, 0.06392925f, -0.04474366f, 0.01835179f, -0.33215454f, 0.13431866f, -0.04323038f, 0.10849094f, 
    -0.17458096f, -0.05115344f, -0.03999517f, 0.06998715f, -0.16935597f, -0.10807632f, -0.03060977f, -0.01843104f, 
    0.19731878f, 0.00246925f, 0.01835145f, 0.11778440f, 0.19369277f, 0.00211364f, 0.12706356f, 0.04285344f, 
    -0.12986597f, -0.03853026f, -0.09323648f, -0.00599282f, 0.03419949f, 0.14849596f, 0.18287712f, 0.06822971f, 
    -0.04814428f, -0.02970928f, -0.07739777f, -0.03486888f, -0.02301098f, -0.03419456f, 0.03491233f, 0.07968426f, 
    0.13940281f, -0.01751111f, -0.04564111f, 0.07681002f, 0.04669371f, -0.01146398f, 0.11534152f, 0.03335559f, 
    0.00751583f, -0.05390478f, 0.19510645f, 0.21518421f, 0.37189475f, -0.15542169f, 0.03601029f, 0.11491164f, 
    -0.05054719f, 0.07867406f, 0.02124935f, 0.03759754f, 0.02045851f, -0.10909671f, -0.03904950f, 0.03453426f, 
    -0.45064792f, 0.14655349f, 0.19147180f, -0.09536652f, 0.11919532f, 0.06658345f, 0.04540485f, 0.15658304f, 
    0.08269343f, 0.08293401f, -0.07501825f, 0.17535338f, 0.07891738f, -0.06269284f, -0.18643655f, 0.03337569f, 
    -0.01023816f, -0.08069552f, 0.12621699f, -0.06282359f, -0.03802275f, -0.01107704f, 0.00079279f, 0.07342269f, 
    -0.12284170f, 0.12316943f, 0.35091168f, 0.26311290f, -0.25530568f, 0.01961185f, -0.07552078f, 0.09755325f, 
    0.05949045f, -0.09771663f, 0.02938571f, 0.17084301f, -0.05745151f, 0.16429199f, -0.14189084f, -0.11186510f, 
    -0.06841273f, -0.06381835f, 0.03290945f, 0.10715909f, 0.10933764f, -0.02566109f, 0.10263365f, 0.10657890f, 
    -0.04720718f, 0.00852043f, 0.42814505f, 0.09234179f, 0.15917356f, 0.04868377f, 0.06297110f, 0.11118320f, 
    0.12930901f, -0.07278128f, -0.17050688f, -0.00153229f, -0.06110723f, 0.17276892f, 0.23573156f, -0.08232556f, 
    0.06209018f, 0.00084223f, 0.05332119f, 0.01076408f, 0.10968418f, 0.07564369f, 0.12438908f, 0.08375300f, 
    -0.16660959f, -0.15382951f, 0.00388593f, -0.06550903f, -0.07517297f, -0.00346183f, 0.11491743f, -0.00004895f, 
    0.17774574f, 0.17706360f, 0.03909977f, 0.09666802f, -0.08261455f, 0.09899993f, 0.06658447f, 0.14707392f, 
    -0.11513415f, 0.07836077f, -0.12841853f, -0.05008198f, 0.09724320f, 0.01124193f, 0.05300268f, 0.08755614f, 
    0.03393656f, -0.01583484f, -0.04857880f, 0.02448204f, 0.00117532f, -0.03370795f, 0.00297959f, 0.02371614f, 
    -0.02519217f, -0.01694599f, 0.03800140f, -0.03888773f, 0.04455352f, -0.04991065f, 0.03831527f, 0.00399391f, 
    0.02180132f, -0.07121762f, 0.06526206f, -0.06232777f, 0.06226307f, -0.05225825f, -0.01126367f, -0.01651938f, 
    -0.07008194f, -0.04461300f, 0.04145271f, 0.02083952f, 0.05281303f, 0.05472131f, 0.04394585f, -0.03404061f, 
    -0.05644036f, -0.04753859f, -0.02044265f, -0.06008852f, -0.02251169f, 0.02310447f, 0.03095674f, 0.01218247f, 
    -0.03671294f, -0.03054779f, -0.01965422f, -0.04912074f, -0.07517002f, -0.05239958f, 0.04215276f, 0.00939362f, 
    -0.02349912f, -0.04770702f, 0.01702416f, 0.07172580f, -0.06059507f, -0.05750056f, -0.03304452f, -0.05416982f, 
    0.06386718f, -0.04526285f, 0.01079849f, 0.04779558f, -0.03588338f, -0.07157616f, -0.06555052f, -0.02857885f, 
    -0.02957536f, -0.05359726f, -0.01301348f, 0.01070660f, 0.03818819f, -0.06743310f, -0.05245553f, -0.01024602f, 
    0.04022754f, 0.04518779f, -0.06786565f, -0.02373039f, -0.04606285f, -0.00822964f, -0.05123490f, 0.04119676f, 
    0.04511762f, -0.00291023f, 0.02273826f, 0.02938019f, 0.05485279f, 0.00076688f, -0.06306901f, -0.04335614f, 
    -0.05488619f, -0.02814175f, 0.00318852f, -0.03707146f, -0.04373008f, 0.00645956f, -0.05790899f, 0.03637618f, 
    -0.01472258f, 0.00739290f, -0.04059648f, -0.00098244f, 0.05475895f, 0.04036118f, -0.05910260f, -0.05477404f, 
    -0.02269865f, -0.04255656f, -0.07439190f, -0.06617430f, -0.01316513f, -0.03476487f, -0.06429815f, -0.03062350f, 
    0.03717433f, -0.03471757f, -0.05170844f, 0.02980201f, -0.04500810f, -0.07578819f, -0.05154948f, -0.00465942f, 
    -0.06529848f, -0.00198911f, -0.01278037f, -0.00905290f, -0.00885945f, 0.03983222f, 0.05165915f, 0.03423888f, 
    0.02780281f, -0.02417152f, -0.06500874f, 0.06205753f, -0.01811370f, 0.01536593f, -0.00937517f, 0.06304343f, 
    -0.06603441f, 0.01372122f, -0.00610635f, -0.03965021f, 0.04238752f, 0.03065854f, 0.04455148f, 0.05887740f, 
    -0.05371442f, 0.02098893f, 0.07087329f, -0.01218202f, -0.00045458f, 0.01047485f, 0.00996416f, 0.06417687f, 
    0.02337128f, -0.01615457f, -0.07731801f, -0.05855538f, -0.01673080f, 0.02449786f, -0.07025383f, 0.02637135f, 
    -0.06125850f, -0.05863914f, 0.05357433f, 0.01071191f, 0.02115914f, -0.04516324f, -0.04076653f, -0.05851299f, 
    0.05152609f, -0.05233297f, 0.04661433f, -0.06922403f, 0.03359026f, 0.01137790f, -0.06282928f, -0.06959176f, 
    0.03183286f, 0.02124287f, -0.05802206f, -0.02985859f, 0.05145558f, -0.04447518f, 0.05214418f, 0.06339952f, 
    0.02966146f, 0.04327916f, -0.00080896f, 0.00933859f, 0.02905143f, 0.00312333f, -0.01510227f, -0.00810301f, 
    0.01689810f, 0.03651895f, 0.03516197f, -0.06258911f, 0.05560075f, -0.04576722f, -0.00329485f, -0.01875568f, 
    0.03701361f, 0.02897410f, -0.03022295f, -0.07155599f, -0.00351914f, 0.03046001f, -0.08019051f, -0.07954536f, 
    -0.02967154f, 0.01368657f, 0.00059040f, 0.05533117f, -0.01536444f, -0.00904859f, 0.06653466f, -0.05818419f, 
    0.06440390f, 0.00437485f, 0.00546745f, 0.00759598f, 0.02883164f, 0.06458075f, -0.06795233f, -0.02642829f, 
    -0.06042963f, 0.05934831f, 0.05868925f, -0.05265944f, -0.06362630f, -0.01951174f, -0.02209933f, -0.01285447f, 
    -0.04854218f, -0.06431884f, -0.00128104f, -0.03249050f, -0.03364860f, -0.04240967f, -0.07650785f, 0.02568948f, 
    0.02223526f, 0.00956169f, -0.02993140f, -0.02648408f, 0.05032305f, -0.02891809f, -0.06907812f, -0.03501695f, 
    -0.06858417f, 0.01137543f, -0.05087386f, -0.06316829f, 0.02394488f, -0.00060468f, 0.01293920f, -0.00110880f, 
    0.02777737f, -0.06777803f, 0.05067281f, -0.00113541f, -0.05027762f, 0.05252920f, -0.06506363f, -0.04127366f, 
    0.00115197f, 0.00186145f, -0.04847439f, -0.04623690f, 0.06638353f, 0.01489391f, -0.04725801f, -0.02872520f, 
    -0.01359296f, 0.03486420f, -0.01751437f, -0.00734475f, 0.01118595f, -0.04975284f, 0.00628151f, -0.06147145f, 
    0.06538820f, 0.01553363f, 0.02236755f, 0.04979515f, -0.05575086f, 0.05595476f, -0.00393696f, -0.01090317f, 
    0.00175289f, -0.01836978f, -0.06358363f, 0.04817782f, 0.05147559f, 0.00563070f, -0.04920037f, -0.06828361f, 
    0.04586735f, -0.07558595f, 0.05711568f, 0.05817862f, -0.07130856f, -0.04098731f, -0.05906339f, -0.01180183f, 
    -0.02163510f, -0.05303605f, -0.02874465f, -0.06556275f, -0.07765102f, 0.04232692f, -0.05408532f, 0.02892630f, 
    -0.01223859f, -0.07190441f, 0.04202423f, -0.05675756f, -0.04635764f, 0.06145703f, 0.05767131f, -0.03104994f, 
    0.02833587f, -0.01156928f, 0.02501296f, 0.01591475f, 0.02350579f, -0.04125021f, 0.01937459f, -0.02870001f, 
    0.05530876f, 0.06459416f, -0.05605187f, -0.07009494f, 0.03310568f, -0.00661471f, -0.00377653f, -0.03902077f, 
    0.04011742f, -0.07006684f, -0.01140904f, -0.03117297f, -0.04069653f, -0.03202752f, -0.01399754f, 0.06570386f, 
    0.03693471f, -0.02506118f, 0.05931577f, 0.01250159f, -0.03338632f, -0.07455228f, 0.00263180f, 0.05777323f, 
    -0.03584382f, -0.03249859f, 0.02416881f, -0.05169536f, -0.06268758f, 0.02615319f, 0.05067946f, -0.05663734f, 
    -0.01852140f, -0.02635296f, 0.03473257f, -0.02861869f, -0.06309325f, 0.02977882f, 0.06280383f, 0.04478747f, 
    0.00283034f, -0.07817096f, 0.02311726f, -0.07039951f, -0.05803060f, -0.06814475f, 0.05938424f, 0.04041867f, 
    -0.07356966f, 0.04863165f, -0.00092629f, -0.03516394f, -0.02537942f, -0.01794712f, 0.00658177f, -0.01247532f, 
    -0.01187658f, 0.00990769f, -0.07399351f, 0.02079767f, 0.00077347f, 0.05347029f, 0.05344453f, 0.01315448f, 
    -0.07192614f, -0.07108828f, 0.00554451f, 0.06627059f, -0.03770437f, 0.04823110f, -0.01060421f, -0.06636067f, 
    -0.03373406f, -0.06443388f, -0.03051723f, 0.05192046f, -0.02921141f, 0.02509269f, -0.05747811f, -0.01414930f, 
    -0.03402287f, -0.05099652f, -0.02568812f, -0.07230106f, 0.02675580f, 0.02434078f, 0.06200239f, -0.06030206f, 
    0.04939869f, -0.06826243f, -0.00663723f, -0.05981970f, -0.06659143f, -0.07114707f, -0.03958254f, -0.05953027f, 
    0.03105768f, -0.07015572f, 0.01686108f, 0.06234020f, -0.03875698f, 0.00498801f, -0.01238157f, 0.02634332f, 
    -0.05971716f, 0.00852342f, 0.01040952f, -0.03804559f, 0.06496321f, -0.04006015f, -0.04945206f, -0.02481514f, 
    -0.01801367f, 0.01503452f, 0.02745457f, -0.06333072f, -0.03847157f, -0.02271710f, 0.03571914f, 0.01456713f, 
    -0.02033251f, -0.06725011f, -0.02052943f, -0.02339202f, 0.02827027f, 0.03604574f, -0.00150049f, 0.00030902f, 
    -0.05864206f, -0.06782516f, -0.02730023f, 0.03896812f, -0.01010255f, -0.04350285f, -0.03166496f, -0.03518439f, 
    -0.00270958f, 0.00799879f, 0.00069330f, -0.03599458f, 0.06358887f, -0.05025099f, -0.01634711f, -0.01422179f, 
    -0.04641989f, 0.05077292f, 0.03392084f, -0.00237495f, 0.05259196f, 0.00574846f, -0.04595012f, 0.04037742f, 
    -0.05593728f, -0.03199149f, 0.04519465f, -0.02255868f, -0.06570236f, 0.00420772f, -0.04281637f, -0.07510141f, 
    0.02126152f, 0.04170012f, -0.07411505f, -0.01770139f, -0.03965274f, -0.04848391f, 0.03306112f, 0.05092178f, 
    -0.02745888f, -0.01994594f, -0.06841604f, 0.06070214f, 0.01420010f, -0.07285036f, -0.04452247f, -0.06546859f, 
    -0.03580527f, -0.00931374f, 0.00472303f, 0.03171614f, -0.02863890f, 0.06553721f, 0.03877075f, 0.03827531f, 
    0.04320414f, -0.00417371f, 0.06601744f, -0.00316132f, 0.03538907f, -0.04019910f, -0.02460557f, -0.03335543f, 
    -0.01823011f, -0.01716236f, -0.05722044f, 0.02680471f, -0.01379790f, 0.00291153f, 0.05759382f, -0.00116957f, 
    0.04758470f, 0.05183002f, 0.00067721f, 0.03970971f, -0.00121924f, -0.03907472f, -0.07348557f, -0.01222503f, 
    0.03801632f, 0.02115018f, 0.03948550f, -0.05887214f, 0.02936192f, -0.06700764f, -0.00604280f, 0.05834142f, 
    -0.00591763f, 0.02134511f, 0.06499551f, -0.03246033f, -0.02604047f, -0.07239838f, 0.03672789f, -0.01842423f, 
    -0.02832198f, 0.03481096f, -0.04186921f, 0.04523013f, 0.03530652f, -0.00287178f, -0.03354324f, 0.05809229f, 
    -0.01542791f, -0.01958225f, 0.03695090f, -0.05440094f, -0.05527234f, -0.00597619f, -0.07163376f, -0.03426383f, 
    -0.00718796f, -0.05136811f, -0.06549478f, -0.02201272f, 0.04173118f, -0.00343238f, -0.02254119f, -0.01933179f, 
    0.00124750f, -0.03014312f, -0.02133340f, 0.04211735f, 0.01403263f, -0.04613474f, 0.01548978f, -0.07300508f, 
    -0.04754194f, 0.00477623f, 0.01177609f, -0.01902116f, -0.06308796f, -0.05221485f, 0.04140465f, 0.03461253f, 
    -0.06257692f, -0.07180998f, -0.03957291f, -0.03344809f, 0.02111448f, -0.01344199f, 0.03104056f, -0.03666583f, 
    -0.01609758f, 0.05389180f, -0.03868256f, -0.00284214f, 0.02819944f, 0.00661188f, -0.00153740f, -0.07565468f, 
    0.04512782f, 0.02241362f, -0.05987446f, 0.02691109f, 0.03859216f, 0.05205316f, -0.03497392f, -0.07844170f, 
    -0.00776505f, -0.05669454f, 0.03429789f, 0.04730996f, -0.02167507f, -0.07468794f, 0.01078558f, -0.00999149f, 
    -0.06601983f, -0.05387038f, -0.06031589f, 0.00850514f, -0.05698914f, 0.02286503f, 0.06041508f, 0.01865230f, 
    -0.01867224f, 0.00860414f, -0.02478571f, -0.05923639f, -0.02299801f, 0.01448121f, 0.01657862f, -0.04318079f, 
    0.02529684f, -0.07012213f, -0.05866661f, -0.04243513f, 0.02803562f, -0.04884763f, -0.00422694f, -0.02340682f, 
    0.06863768f, -0.00613645f, -0.06336571f, 0.06416825f, 0.01512797f, 0.01762641f, 0.05228163f, -0.05218360f, 
    0.00426321f, -0.04888676f, 0.03533060f, 0.04599879f, -0.00002610f, -0.00024889f, 0.01501001f, -0.05253126f, 
    0.02623153f, -0.04958976f, 0.06250778f, 0.05012152f, 0.00870177f, 0.00444009f, -0.04325091f, -0.01056224f, 
    -0.01462974f, 0.01622770f, -0.06722366f, -0.02768922f, 0.02518790f, 0.02776320f, -0.03008546f, -0.03120226f, 
    0.03703346f, -0.07945043f, 0.04074836f, -0.04524853f, -0.01885799f, 0.04480060f, 0.06153584f, 0.05968518f, 
    -0.02489828f, 0.04421109f, 0.02930741f, 0.04664901f, -0.01761644f, 0.04430433f, 0.00902979f, -0.03122253f, 
    0.01179110f, -0.05850397f, 0.00514728f, 0.06389782f, -0.05567982f, 0.02492652f, -0.04523708f, -0.04902504f, 
    -0.01255549f, 0.04709537f, -0.01460259f, 0.02890861f, -0.03663066f, -0.04447022f, -0.05030805f, -0.01886171f, 
    0.04231483f, 0.04176461f, -0.05107208f, 0.00484081f, -0.08072236f, -0.03852393f, -0.03281077f, -0.05335606f, 
    -0.03684310f, 0.00202122f, -0.07776215f, 0.02968892f, 0.04235671f, 0.04955430f, 0.01708713f, -0.04848682f, 
    0.01201852f, -0.03384525f, -0.03502848f, -0.04982585f, 0.02526040f, -0.02959579f, -0.00183118f, -0.06314347f, 
    0.03072259f, -0.03765526f, -0.07324721f, -0.01657932f, 0.06790975f, 0.05078467f, -0.05130584f, 0.02087877f, 
    0.02535161f, 0.02032614f, -0.07102618f, 0.01154103f, -0.05981025f, -0.07532224f, -0.03506592f, 0.02757943f, 
    0.06470439f, -0.02327652f, 0.02150903f, -0.00274040f, -0.03680431f, -0.04620787f, -0.06412919f, -0.00568640f, 
    0.02437266f, -0.07876923f, -0.01339246f, -0.03453020f, 0.04004416f, -0.05493160f, -0.04520376f, -0.00583641f, 
    -0.20864202f, 0.06926568f, -0.16902700f, 0.26231834f, -0.05112224f, -0.05704173f, 0.08658611f, 0.00940461f, 
    -0.11984117f, -0.05303071f, 0.22593680f, 0.01406990f, 0.01907226f, -0.21148488f, -0.17630813f, -0.19126210f, 
    0.15583673f, 0.13431832f, 0.09837816f, 0.04761837f, 0.21409729f, -0.06378864f, 0.12513900f, -0.01120700f, 
    0.25190803f, -0.27344397f, 0.13951083f, -0.07890331f, 0.01808769f, 0.05710575f, 0.08354495f, -0.02988677f, 
    0.06084146f, 0.14223371f, 0.07631545f, 0.16680482f, -0.30064452f, -0.25195321f, -0.12871875f, -0.05040151f, 
    0.20413031f, -0.08320583f, 0.04548503f, -0.15132491f, 0.16765380f, 0.05257369f, 0.18539652f, 0.08467435f, 
    0.10863018f, 0.04268501f, -0.09191682f, 0.14056565f, -0.17457224f, -0.13284770f, -0.04776820f, 0.13804039f, 
    0.08417495f, 0.03636453f, 0.15690024f, 0.07345825f, -0.13466468f, 0.00582181f, 0.05630463f, -0.28934857f, 
    -0.18666774f, 0.01708072f, 0.05151065f, 0.29206422f, 0.00936101f, -0.13815658f, 0.05354402f, 0.00226703f, 
    0.24614434f, 0.00721566f, -0.06470054f, -0.09677854f, -0.02554827f, 0.07568128f, 0.06255663f, -0.10719483f, 
    0.15005973f, 0.11409890f, 0.04261522f, -0.01571254f, 0.03344615f, 0.04265684f, 0.04542955f, 0.07788749f, 
    0.04507868f, 0.02863289f, -0.01043829f, 0.06340466f, 0.02950190f, 0.26206389f, 0.10566872f, 0.23242503f, 
    -0.30348226f, 0.27201110f, -0.03191039f, 0.12538683f, 0.06101841f, -0.02171925f, 0.14792880f, 0.00917632f, 
    -0.09292346f, 0.09561764f, -0.01970490f, -0.06113466f, 0.09056403f, -0.02508728f, 0.01305739f, 0.11119062f, 
    0.19452415f, 0.00398368f, 0.16393143f, 0.12114601f, 0.08915349f, 0.08528343f, -0.02244585f, 0.09502481f, 
    0.05323840f, 0.03393747f, -0.09798279f, -0.20922171f, 0.24012393f, 0.13673006f, 0.03472541f, -0.00752488f, 
    0.08585792f, 0.08596087f, -0.04959947f, 0.01758255f, 0.36025867f, 0.06381456f, -0.18098250f, -0.06943616f, 
    -0.00655803f, 0.03878102f, 0.03164221f, -0.03400579f, 0.00845365f, 0.01040649f, -0.00542289f, 0.15357222f, 
    -0.04626192f, -0.00838613f, -0.01937175f, 0.15053363f, 0.15272027f, 0.06263153f, -0.08449523f, -0.17050648f, 
    0.02186273f, -0.03956912f, -0.00293967f, 0.10419082f, -0.39600781f, 0.03671221f, -0.02957654f, 0.06792458f, 
    0.00175178f, -0.00395963f, 0.08762435f, -0.03713430f, -0.09485446f, -0.06012894f, -0.00552710f, 0.03587583f, 
    -0.35203308f, -0.32264867f, -0.33758730f, -0.14067441f, 0.04580333f, -0.01633290f, 0.09075861f, 0.02542352f, 
    -0.13274835f, -0.11421007f, -0.04232020f, -0.13757516f, -0.17355298f, 0.31944525f, -0.16282600f, 0.29431069f, 
    -0.06084946f, -0.07483478f, 0.07069729f, 0.13737652f, 0.13808218f, 0.11295263f, 0.01187759f, 0.17215550f, 
    0.03180619f, -0.12353101f, 0.10817784f, -0.10266273f, 0.14618434f, 0.13561676f, -0.13613988f, -0.00010129f, 
    0.06874321f, 0.10518949f, 0.01715291f, 0.15685576f, 0.12731574f, 0.45364499f, 0.15049726f, 0.06991697f, 
    -0.12683022f, -0.09971028f, -0.07584545f, -0.05635132f, -0.07041162f, -0.07884363f, -0.06953418f, -0.04258205f, 
    0.19334701f, 0.20728342f, 0.01195667f, 0.03012685f, -0.10587493f, -0.05633830f, -0.09016842f, 0.02650771f, 
    -0.03033865f, -0.13059059f, -0.02990065f, -0.27837753f, 0.16598615f, 0.21779959f, -0.08878057f, -0.06019616f, 
    -0.01912349f, 0.12692840f, 0.10882964f, 0.07346091f, -0.05284130f, 0.02330161f, 0.07783871f, 0.21804479f, 
    -0.01962591f, 0.17968135f, 0.01478700f, 0.12884779f, 0.05634477f, 0.10335919f, -0.01314591f, 0.02439748f, 
    0.00284077f, 0.01464605f, -0.02619031f, 0.10945321f, -0.19916096f, -0.17567672f, 0.00178698f, 0.10360589f, 
    0.34455052f, 0.16465017f, -0.03683982f, -0.02419876f, 0.04277553f, 0.06701211f, -0.02794940f, 0.07838593f, 
    -0.27278864f, -0.04617899f, 0.00466805f, 0.21972808f, -0.02351692f, 0.05308999f, 0.00686495f, -0.02423199f, 
    -0.05270294f, 0.02125059f, -0.11400846f, -0.06325638f, 0.05581555f, -0.04259399f, 0.05025948f, 0.03523587f, 
    -0.10151029f, -0.08091237f, -0.01631422f, 0.06540929f, 0.02470034f, -0.16662034f, 0.16664067f, -0.00385986f, 
    0.05374080f, -0.19479874f, -0.15306786f, -0.01802925f, -0.06714132f, 0.10978543f, 0.04632540f, 0.02659750f, 
    0.09991129f, 0.05013254f, 0.09139967f, -0.05459063f, 0.13356985f, 0.26421928f, 0.05140153f, -0.17960100f, 
    -0.16615926f, 0.10716549f, 0.01176786f, -0.05372097f, -0.04101056f, -0.08603922f, -0.03047802f, 0.06158428f, 
    0.41258189f, 0.07596129f, -0.08789267f, 0.20233774f, -0.09553695f, -0.03963713f, 0.05398477f, 0.04686422f, 
    0.00860271f, 0.04694157f, -0.08086260f, -0.10339057f, -0.47892493f, 0.37439856f, 0.14416210f, 0.02945821f, 
    -0.04181515f, 0.06629734f, -0.12739532f, -0.08057611f, -0.13682528f, 0.12032439f, -0.11528632f, -0.13105895f, 
    0.07497849f, -0.00227530f, -0.08092131f, 0.08646874f, -0.03846608f, -0.04235272f, 0.05518207f, 0.15179598f, 
    -0.24806626f, -0.02770384f, 0.01386268f, 0.04121143f, 0.51084065f, 0.05278329f, 0.07635433f, 0.24351686f, 
    0.03543228f, 0.11378116f, 0.09114487f, -0.09111504f, 0.07412557f, 0.01991999f, 0.04044694f, 0.10269869f, 
    0.40874663f, 0.27639797f, 0.30338249f, 0.20304656f, 0.00506601f, 0.10965519f, -0.04667755f, -0.07193560f, 
    0.05494052f, 0.05107046f, 0.02561675f, 0.00802809f, 0.12022109f, -0.07930880f, 0.11211618f, -0.26462790f, 
    0.06776816f, -0.06511668f, -0.12462344f, 0.03752853f, -0.13106953f, 0.13552490f, 0.06170878f, -0.06800564f, 
    -0.13065122f, 0.11572971f, 0.02694171f, 0.02897427f, 0.03207170f, -0.01548693f, 0.07232707f, -0.01293695f, 
    -0.12855756f, -0.13818882f, 0.07367767f, 0.00595879f, -0.18667889f, 0.14557567f, 0.00140702f, 0.28552103f, 
    -0.04985231f, 0.01304168f, -0.04127786f, -0.02363030f, 0.08473042f, 0.03759444f, 0.08498503f, -0.01149438f, 
    0.09911512f, -0.15016739f, -0.23011029f, -0.04645301f, 0.06085244f, -0.03819331f, 0.03739228f, -0.08684690f, 
    -0.02532259f, 0.10559273f, 0.03987217f, -0.06047667f, 0.13927156f, 0.01101006f, -0.24577752f, 0.13246585f, 
    -0.16844672f, -0.17754133f, 0.06670687f, 0.11250232f, 0.05107985f, -0.04175804f, 0.22493824f, 0.14580519f, 
    -0.28811556f, 0.28777209f, -0.20960762f, -0.10499967f, -0.11206011f, -0.09956843f, -0.04955782f, 0.14332613f, 
    -0.02890481f, -0.13577826f, 0.03588723f, 0.02693062f, 0.49088374f, 0.00547946f, 0.05149584f, 0.01002425f, 
    -0.09527272f, -0.15255089f, 0.04418854f, 0.09480973f, -0.01780223f, 0.05651495f, 0.01041576f, 0.04884090f, 
    -0.02432767f, -0.04831391f, 0.01545585f, -0.08407354f, -0.07846781f, -0.02407228f, -0.00888556f, 0.01400777f, 
    0.10462178f, -0.14149293f, 0.02748521f, 0.00144652f, -0.10398652f, 0.05946651f, -0.01137183f, -0.12975450f, 
    -0.05837674f, -0.04065169f, -0.08223944f, -0.03307143f, 0.06906633f, 0.23054312f, -0.09714177f, 0.08643521f, 
    -0.66024852f, 0.23462783f, 0.12485219f, 0.14940068f, -0.04527353f, 0.00368549f, 0.14780045f, 0.09714644f, 
    0.06364402f, 0.04029696f, -0.02236062f, 0.02735871f, 0.20006812f, -0.14061387f, 0.00182948f, 0.23957500f, 
    -0.04921783f, -0.01518473f, 0.00608418f, 0.16716328f, 0.09176641f, 0.01890271f, -0.27774644f, 0.00946182f, 
    -0.13924521f, 0.19430964f, 0.07508220f, -0.01746678f, 0.05120475f, 0.18327618f, -0.20578921f, 0.08102238f, 
    -0.01245375f, -0.00331003f, -0.14286308f, -0.04963193f, 0.11706837f, -0.02390810f, 0.24756563f, 0.16552436f, 
    -0.06080182f, -0.03068418f, 0.00870121f, 0.03348295f, -0.10136693f, 0.07077753f, 0.02666916f, 0.14692633f, 
    -0.10530946f, 0.01792858f, 0.27378684f, -0.06653488f, 0.04782520f, 0.15732673f, 0.21586877f, -0.01820151f, 
    -0.01175189f, -0.07542548f, -0.11726960f, -0.08833848f, 0.30403459f, 0.07433314f, 0.14964586f, -0.13302360f, 
    0.00999724f, -0.00242325f, 0.00263199f, -0.02673674f, 0.07526314f, -0.07297523f, -0.01922589f, 0.06240903f, 
    0.05489656f, -0.22325455f, -0.02960146f, 0.13057582f, -0.02269588f, 0.06827290f, -0.07526203f, -0.05349580f, 
    0.00172287f, 0.06756181f, 0.14702889f, -0.25046107f, -0.26485077f, 0.42136624f, -0.01230686f, -0.07266323f, 
    -0.10417565f, 0.15038198f, 0.00674990f, -0.02911282f, -0.06417157f, 0.11798559f, 0.05554843f, 0.12552999f, 
    0.14311270f, 0.17135173f, 0.18905953f, 0.12981988f, -0.01747353f, 0.05629929f, -0.06422868f, 0.18073273f, 
    0.14132024f, -0.05028088f, 0.03995297f, 0.08076789f, -0.35327849f, 0.14274520f, 0.13568576f, 0.06984875f, 
    0.04968304f, -0.06201747f, 0.19013029f, -0.02366168f, -0.03330457f, -0.02995683f, 0.13290279f, 0.02748673f, 
    -0.40518394f, 0.02387957f, 0.07562460f, -0.04432517f, -0.05255428f, 0.16376208f, 0.06129504f, -0.05590758f, 
    -0.13957822f, -0.03918873f, -0.04375381f, -0.07529949f, -0.16367210f, 0.27510616f, -0.08291510f, -0.17649178f, 
    -0.00274594f, 0.03371015f, -0.09476297f, 0.09889989f, 0.08027805f, 0.08889994f, -0.12098447f, 0.02262919f, 
    -0.19345351f, 0.02641950f, -0.12901606f, 0.26079112f, 0.16625692f, 0.15595649f, 0.07874519f, 0.13358465f, 
    0.02393854f, -0.16900283f, 0.10641079f, -0.18124384f, 0.47923303f, 0.21102616f, 0.07241833f, 0.02191603f, 
    0.12267289f, -0.01741775f, -0.04978203f, 0.00498671f, 0.04275111f, 0.08713715f, 0.15234594f, -0.02371523f, 
    -0.15471783f, -0.09114980f, 0.20078774f, 0.12742613f, 0.01969739f, -0.12858315f, -0.06141552f, -0.00288081f, 
    -0.12792313f, -0.00612784f, -0.08465743f, -0.14632919f, 0.18508543f, -0.13562280f, 0.01055572f, 0.04491445f, 
    -0.08628771f, 0.12598807f, -0.07146961f, 0.09653429f, 0.06892708f, -0.05585759f, -0.05089899f, 0.02292131f, 
    0.64850014f, -0.18049696f, -0.12504910f, 0.08786239f, 0.13996674f, 0.14962241f, -0.19130898f, -0.03907359f, 
    0.12020498f, -0.00134120f, -0.06370248f, -0.09054779f, -0.01769951f, 0.36965498f, -0.06363676f, -0.07177140f, 
    -0.00049853f, 0.12531380f, -0.11899022f, -0.08775797f, -0.16545139f, -0.05900295f, -0.21941780f, -0.09453785f, 
    -0.43073156f, 0.03962630f, 0.12327112f, -0.05504843f, -0.07794741f, 0.01992374f, 0.03587706f, 0.15150905f, 
    -0.02279089f, 0.09572607f, 0.01219076f, -0.03122884f, -0.39950505f, 0.29524660f, 0.05909265f, -0.20836256f, 
    0.11319565f, -0.01492178f, -0.16374075f, 0.11378795f, -0.07378277f, 0.07249082f, -0.01532126f, 0.06275181f, 
    -0.04808834f, 0.09880514f, 0.28287035f, -0.17024772f, 0.09313145f, 0.03150493f, -0.10019398f, 0.10393765f, 
    -0.05682574f, 0.03228205f, -0.03326360f, 0.08305275f, 0.40028015f, 0.17758109f, -0.14750700f, 0.13195325f, 
    0.00984933f, 0.07710978f, 0.06726588f, -0.02468201f, 0.11650223f, -0.09155580f, -0.04847891f, 0.05019005f, 
    0.03848041f, 0.07976917f, 0.00459299f, 0.10991498f, -0.00335127f, 0.13812956f, 0.02624659f, 0.03027600f, 
    0.03375554f, 0.06686860f, 0.20262386f, -0.09322977f, 0.14240712f, -0.04712991f, 0.14680426f, -0.06624281f, 
    -0.16834320f, 0.03946359f, 0.12439977f, 0.02561595f, -0.13389014f, -0.08575660f, -0.03500848f, 0.07819357f, 
    -0.13036945f, -0.03096209f, 0.15685891f, 0.27785033f, 0.12835164f, 0.06175013f, 0.09050372f, 0.13705325f, 
    -0.11159889f, -0.11166813f, 0.16955882f, 0.05113162f, 0.07263710f, -0.23232388f, -0.14409606f, -0.13626498f, 
    0.03587607f, -0.12586482f, -0.10494673f, 0.05774380f, 0.17163302f, 0.07621188f, -0.00951944f, 0.20983450f, 
    -0.12447126f, -0.36855379f, 0.02630857f, -0.29241070f, 0.06714803f, -0.08067600f, -0.00846915f, -0.08901291f, 
    -0.04673124f, -0.04776407f, -0.05411674f, 0.11576030f, -0.32583383f, -0.10022112f, -0.10706568f, -0.20451605f, 
    0.15640897f, -0.15342271f, 0.00639382f, -0.09422222f, 0.14816557f, 0.06398960f, 0.16499621f, 0.06717364f, 
    0.32509756f, 0.20182127f, 0.11375897f, 0.26577118f, -0.16406834f, -0.14668857f, 0.18292509f, 0.22204444f, 
    0.05406039f, -0.09586849f, 0.11624137f, 0.00410470f, -0.25205171f, 0.37501794f, 0.17149894f, -0.03139198f, 
    0.10889587f, -0.03320682f, 0.09891499f, 0.32164425f, 0.12528773f, -0.11418943f, -0.06668784f, 0.03089215f, 
    0.54140025f, 0.12457759f, -0.02191855f, 0.01112353f, 0.07064579f, -0.01304051f, 0.22595884f, -0.05031954f, 
    -0.09882099f, 0.08914763f, -0.06133116f, -0.14910284f, 0.28105822f, -0.06623680f, 0.09330849f, 0.11188497f, 
    0.00322629f, 0.07139594f, -0.00622406f, -0.02373984f, -0.12314267f, 0.06321863f, -0.07307284f, 0.07906411f, 
    -0.13397840f, 0.31382754f, 0.10964119f, 0.15210883f, 0.04157475f, 0.07339387f, -0.01910258f, 0.04923701f, 
    -0.10113036f, -0.01299779f, 0.06918075f, -0.02155372f, 0.15063538f, -0.03914090f, -0.19483772f, 0.14496879f, 
    0.13712342f, 0.00098885f, 0.01476671f, 0.04061828f, 0.21969563f, -0.00883114f, -0.03870206f, -0.12186375f, 
    -0.02600466f, -0.11597831f, 0.06019871f, -0.04360455f, -0.01108936f, 0.13986327f, 0.00946797f, -0.05133156f, 
    0.01680473f, 0.09804664f, -0.04898930f, -0.12639599f, 0.13885851f, 0.08103567f, -0.34212250f, -0.05385957f, 
    -0.06162426f, 0.09320550f, -0.13689889f, 0.03742766f, -0.14909624f, 0.15632911f, 0.20366393f, 0.07887426f, 
    -0.18467456f, 0.15009770f, 0.30213645f, 0.18875186f, 0.01224590f, 0.12005661f, -0.11519399f, -0.10930775f, 
    0.11171731f, -0.13019751f, -0.05043037f, -0.00370989f, -0.23631370f, -0.03384613f, -0.16776571f, -0.08816064f, 
    0.01182227f, 0.01221399f, 0.07496902f, -0.06217461f, -0.03314414f, -0.05490346f, 0.09100650f, 0.01051664f, 
    -0.13519943f, -0.34019098f, -0.24093468f, -0.18701857f, -0.05857636f, 0.00576104f, -0.06779474f, 0.02083200f, 
    -0.06024825f, -0.05630580f, -0.15848048f, -0.05553788f, 0.12404017f, 0.06996483f, 0.11530454f, 0.20390683f, 
    0.00965796f, 0.05779581f, 0.08281606f, 0.14028819f, -0.07998184f, 0.06442331f, -0.01993637f, 0.08802988f, 
    0.15168063f, 0.25503379f, 0.04468185f, -0.00340221f, -0.14812668f, -0.04393952f, -0.11985963f, 0.00395560f, 
    0.11617925f, 0.03452937f, -0.05394303f, 0.03743359f, -0.02001054f, 0.00264957f, 0.02287970f, 0.08616960f, 
    0.09077381f, 0.13628682f, -0.02120024f, -0.12075023f, -0.05911880f, 0.08641227f, 0.06630176f, 0.08434768f, 
    0.15157537f, 0.31408775f, -0.01069842f, 0.25718230f, -0.06113848f, 0.21404447f, 0.11339616f, 0.03242628f, 
    -0.04510596f, 0.02645482f, 0.07923915f, 0.07124065f, 0.07165466f, -0.06786034f, 0.07724520f, 0.11811718f, 
    0.15222424f, 0.12875214f, -0.15142697f, 0.01411497f, 0.11334665f, 0.08284254f, -0.02235927f, -0.07728574f, 
    -0.22532243f, -0.35412222f, -0.06229328f, -0.04260274f, 0.18079339f, 0.14741877f, 0.01186098f, -0.07063714f, 
    0.10649142f, 0.11288445f, 0.09542166f, -0.00994591f, 0.12452891f, -0.10747889f, -0.07544988f, -0.13938659f, 
    -0.03000538f, 0.01308873f, 0.05215497f, -0.02431931f, 0.04631897f, 0.00011908f, 0.07348514f, 0.08347107f, 
    -0.14165339f, 0.13503344f, 0.10294554f, -0.26056924f, 0.03150419f, -0.02734244f, -0.02803800f, 0.11078020f, 
    -0.12952305f, 0.03798500f, 0.07689232f, 0.00950132f, -0.36727446f, 0.10959527f, 0.19045208f, 0.04037862f, 
    0.01803599f, 0.04731403f, -0.02897736f, 0.11550719f, 0.13869503f, -0.10778932f, -0.01942445f, 0.01234320f, 
    0.54812801f, -0.10167268f, -0.28621235f, 0.02380409f, 0.11812662f, 0.08213930f, 0.00974491f, -0.12216397f, 
    0.08065607f, -0.07157367f, 0.13278104f, 0.03991517f, -0.27491292f, 0.03311139f, 0.27532530f, -0.19513279f, 
    0.00236360f, -0.08172364f, -0.11775758f, -0.10930505f, -0.01497780f, 0.05362842f, 0.10242082f, 0.07388089f, 
    -0.11902092f, -0.11725453f, 0.06337592f, -0.35628951f, 0.08465002f, 0.06809949f, 0.00470393f, 0.03642451f, 
    0.03186783f, 0.04786414f, 0.03316936f, -0.03190022f, -0.02815629f, -0.11758538f, 0.13393721f, 0.12999481f, 
    0.20312721f, 0.05682886f, -0.08421215f, 0.00460997f, 0.14915875f, -0.14575052f, 0.05124458f, 0.01493313f, 
    0.06166597f, 0.00945296f, -0.29635829f, -0.19996379f, 0.02373154f, 0.03713540f, 0.00873274f, 0.01728304f, 
    0.01878441f, 0.21305224f, 0.01318022f, 0.10530826f, 0.03904231f, 0.04769512f, -0.04848010f, 0.16757134f, 
    -0.06086602f, -0.15500255f, -0.17483911f, 0.07588030f, 0.11648205f, -0.07713532f, -0.04469505f, 0.08691505f, 
    -0.11096927f, 0.23114918f, -0.09547522f, 0.04578595f, 0.12460656f, -0.11650747f, 0.03380330f, -0.00085852f, 
    -0.05012460f, -0.02189326f, 0.17190205f, 0.18350247f, -0.02366322f, -0.05300622f, -0.07259849f, 0.10278884f, 
    0.09129930f, 0.01868149f, 0.06379463f, 0.19328323f, 0.20292932f, 0.03807561f, -0.01606480f, 0.04609565f, 
    0.02582528f, -0.07234751f, -0.05950934f, -0.02984782f, 0.01824303f, 0.04688128f, 0.04045919f, -0.05584545f, 
    0.02720169f, -0.03122069f, 0.03674230f, 0.04619407f, -0.03546150f, -0.07348701f, -0.01316005f, -0.02760497f, 
    -0.02884538f, 0.00476067f, -0.06287624f, 0.01872892f, -0.01683938f, 0.02909443f, -0.01467495f, 0.01493778f, 
    -0.00989116f, 0.04114605f, -0.06784015f, 0.05834035f, -0.03383686f, 0.05659232f, 0.01561465f, 0.05880674f, 
    0.01931606f, 0.00539002f, -0.01722071f, -0.01338420f, -0.00226937f, 0.00755667f, -0.01064509f, -0.01959424f, 
    0.02347281f, -0.01016868f, 0.04680704f, 0.00796006f, 0.04996990f, -0.03596087f, 0.03219122f, 0.05802143f, 
    0.04906736f, -0.04329830f, -0.03870881f, -0.07856581f, -0.03476140f, -0.06647171f, -0.06642461f, 0.05390939f, 
    -0.07153352f, 0.04446742f, -0.02730337f, 0.05272961f, -0.07196571f, -0.01159987f, -0.02561529f, -0.01248921f, 
    0.06104750f, -0.02892543f, -0.00270165f, -0.04336372f, -0.05414404f, -0.07336211f, 0.00233120f, -0.02307727f, 
    -0.01720726f, 0.00880120f, 0.03664513f, -0.06753605f, -0.05506216f, 0.06140982f, -0.03361348f, -0.01226016f, 
    -0.05425686f, 0.03815527f, -0.05377721f, -0.04084311f, 0.05395981f, -0.01223525f, 0.03859786f, 0.00228701f, 
    -0.00514643f, 0.01606731f, -0.03732423f, 0.05567013f, -0.06933869f, 0.03185639f, 0.00174339f, 0.00403770f, 
    -0.04050887f, -0.03920281f, 0.03562878f, 0.04818463f, 0.01999045f, 0.01949001f, 0.05146533f, -0.06840281f, 
    -0.03750229f, -0.06858759f, 0.05158628f, -0.04281370f, -0.07794788f, -0.07123528f, -0.03818936f, 0.03568876f, 
    0.01744943f, -0.06509648f, 0.04764317f, -0.07375930f, 0.00808175f, -0.01988725f, -0.03320576f, -0.01595446f, 
    0.03164427f, 0.01237545f, 0.01865181f, 0.05363110f, -0.07424503f, 0.06289233f, 0.03008711f, -0.03938441f, 
    -0.05640873f, -0.02733727f, -0.05018687f, -0.06109830f, 0.01650436f, -0.08098299f, -0.06307257f, 0.03882249f, 
    -0.03062526f, -0.06303083f, 0.00561697f, 0.04446501f, -0.00505549f, -0.04960172f, -0.07392691f, 0.05420987f, 
    -0.02704769f, 0.05966189f, 0.04160417f, -0.06925562f, -0.01809053f, 0.01097018f, -0.05918842f, -0.04613951f, 
    0.05812642f, -0.01496179f, -0.08067758f, -0.03021381f, -0.07906023f, 0.00594707f, 0.03680572f, -0.02057360f, 
    -0.02794852f, 0.00865866f, -0.07596471f, -0.02662021f, 0.06203810f, 0.00477866f, -0.07472871f, -0.03721400f, 
    0.01249787f, -0.05168751f, -0.02563479f, 0.01001522f, -0.01794210f, -0.06053036f, -0.04040449f, -0.06884895f, 
    -0.07931983f, 0.00075752f, 0.02740167f, -0.00108086f, 0.04232888f, 0.05383145f, -0.03100490f, 0.03443625f, 
    -0.08038986f, -0.05716237f, -0.06735038f, -0.02352843f, 0.03184675f, -0.02415873f, -0.03650657f, -0.02314746f, 
    -0.01830362f, -0.03244065f, -0.02839163f, -0.02036387f, -0.00321410f, -0.06421787f, 0.03673681f, 0.02779929f, 
    -0.05602989f, 0.01677615f, 0.02311612f, 0.04591539f, -0.05353031f, 0.06333540f, 0.06190436f, 0.03210145f, 
    -0.03535466f, 0.05889585f, -0.02673337f, -0.07182730f, 0.03221590f, 0.03465308f, -0.04784213f, 0.01274052f, 
    -0.05893099f, -0.00820097f, 0.01863234f, 0.00214256f, -0.02050932f, -0.02752904f, -0.05350851f, -0.02483076f, 
    0.04248418f, -0.02396170f, -0.07736446f, 0.04093423f, -0.06941768f, 0.06089862f, 0.02807417f, -0.02454827f, 
    0.00684777f, 0.00177462f, -0.04747173f, 0.00385124f, -0.01254128f, -0.05699311f, 0.01016331f, -0.04419340f, 
    0.02294612f, -0.05014818f, 0.04525824f, 0.01608329f, -0.00303326f, -0.00309926f, 0.00184194f, -0.00297214f, 
    0.00535805f, -0.04378640f, -0.05870336f, -0.06265683f, 0.00549616f, 0.03454013f, 0.04052337f, 0.04149111f, 
    0.02018227f, 0.02465740f, -0.00202024f, -0.07760075f, -0.03192950f, 0.01319276f, -0.02425797f, -0.03266375f, 
    -0.06363925f, -0.00952591f, -0.02206036f, -0.03707596f, -0.01433805f, 0.03129240f, 0.04990913f, -0.03287900f, 
    -0.03948753f, -0.01457311f, -0.00219689f, 0.00067224f, -0.01905221f, -0.03103341f, -0.00478879f, 0.01441390f, 
    -0.03042340f, -0.05181533f, 0.00541790f, -0.06753616f, -0.07508501f, 0.03036546f, 0.05452907f, 0.05386937f, 
    0.03532158f, 0.05268467f, 0.01859976f, 0.06327762f, 0.06487162f, -0.07913996f, -0.07623589f, 0.03913205f, 
    0.01339182f, -0.02083084f, 0.06235848f, -0.07136375f, -0.04719353f, -0.02270600f, -0.04530266f, 0.01922477f, 
    0.03898890f, -0.06569376f, -0.05186382f, 0.05738223f, -0.03375626f, -0.07337464f, 0.06356496f, -0.06267576f, 
    -0.06736791f, 0.04361606f, 0.03724781f, 0.00360713f, -0.02007070f, 0.03963949f, -0.00291546f, 0.05142383f, 
    0.02491586f, 0.05195798f, -0.04463024f, -0.02891437f, 0.04969959f, -0.02540537f, 0.06171880f, 0.02548845f, 
    -0.04990550f, 0.05966683f, -0.04615729f, 0.01609183f, -0.02385580f, -0.03755365f, 0.02201402f, -0.01458279f, 
    -0.01395958f, 0.02099886f, -0.06267857f, -0.02070318f, -0.05223158f, -0.05699766f, -0.00315474f, -0.05172912f, 
    -0.07123823f, -0.01040060f, 0.05134384f, -0.01252737f, 0.05603495f, -0.03963661f, 0.01442344f, -0.03097845f, 
    -0.05192152f, 0.02590505f, -0.04360256f, -0.00431708f, 0.04972889f, 0.04096958f, 0.06044340f, -0.01525900f, 
    -0.04949610f, 0.01833116f, 0.01418929f, -0.00859621f, -0.05941126f, -0.06124671f, -0.05723041f, 0.04676456f, 
    -0.00784202f, -0.07822883f, 0.01645341f, -0.05059981f, -0.03016279f, -0.04474390f, 0.00956777f, 0.00204568f, 
    0.01710873f, -0.03218536f, 0.01950309f, 0.00839997f, 0.03141094f, -0.05991470f, -0.07482830f, -0.06689980f, 
    0.09737117f, 0.03239106f, 0.00336457f, -0.03501433f, 0.19823599f, -0.04231787f, 0.11539678f, 0.01510643f, 
    -0.03658970f, -0.04274805f, 0.06058327f, 0.04252497f, -0.01026736f, 0.19433749f, 0.15264164f, 0.05015832f, 
    -0.05962036f, -0.11580006f, -0.04612618f, 0.06038919f, 0.03776846f, 0.03620172f, 0.02895894f, 0.04341255f, 
    0.71074027f, 0.03683417f, 0.07870260f, -0.44787851f, 0.03187032f, -0.09755863f, -0.05185056f, 0.00955544f, 
    0.07508683f, -0.00193480f, -0.01353785f, 0.11450844f, -0.18759668f, 0.12631553f, -0.21951641f, -0.03140634f, 
    -0.05266363f, -0.00859307f, 0.06640381f, -0.10229787f, -0.08796395f, 0.09014191f, 0.03867206f, 0.06544646f, 
    -0.05550310f, 0.22500858f, -0.08790126f, 0.00508842f, 0.07858238f, 0.06519581f, -0.15486021f, 0.12554018f, 
    0.08909705f, 0.03629242f, 0.01209238f, -0.02619313f, 0.11240543f, -0.23441507f, 0.07303958f, -0.18300888f, 
    0.11060525f, 0.04975927f, -0.05199769f, 0.01557793f, -0.07361080f, -0.04597712f, 0.02428101f, -0.08734480f, 
    0.00371790f, -0.14738825f, 0.02759778f, 0.04789905f, 0.07719323f, 0.04443690f, 0.04701820f, 0.04756805f, 
    0.30814305f, 0.08747350f, 0.00885139f, 0.08393715f, -0.10118488f, 0.15281466f, 0.01875876f, -0.11133420f, 
    0.00503083f, 0.11527515f, 0.04645510f, 0.07068451f, 0.01509393f, 0.19425233f, 0.10313245f, 0.00800879f, 
    -0.48781639f, 0.17908686f, -0.24074449f, 0.11450122f, 0.09642499f, -0.01704154f, 0.10995583f, 0.04506905f, 
    -0.03823987f, 0.09234717f, 0.01699963f, -0.04687470f, 0.09289542f, -0.16175547f, -0.06567686f, 0.10430548f, 
    0.15831919f, -0.01608443f, -0.01803893f, 0.18254958f, 0.07563586f, 0.11345677f, -0.00247169f, 0.13658738f, 
    0.01353081f, 0.38133928f, 0.13057524f, -0.05024635f, -0.19588009f, -0.08425450f, -0.18064886f, -0.07316364f, 
    -0.01793391f, -0.05824946f, 0.05613232f, -0.01977842f, -0.29651588f, 0.17920093f, 0.17712601f, 0.10732312f, 
    -0.13712029f, 0.05944464f, 0.14381799f, 0.07132538f, -0.08423801f, 0.01092307f, -0.05860602f, -0.03244755f, 
    -0.00702431f, -0.05956991f, 0.21183640f, 0.02815963f, -0.06610637f, 0.05277053f, 0.01025813f, 0.08036541f, 
    -0.19328462f, -0.06885167f, 0.01289996f, 0.01807954f, -0.21769886f, 0.04049474f, -0.03094249f, 0.08890205f, 
    -0.03795559f, -0.07342125f, 0.01429838f, -0.15568931f, 0.01058313f, -0.01486321f, -0.10741989f, 0.11331841f, 
    0.09950477f, -0.19590825f, -0.21014644f, 0.12881078f, 0.04005602f, 0.10145883f, -0.00568224f, -0.04304102f, 
    0.11098170f, 0.09382212f, 0.10894334f, -0.14206246f, -0.28109860f, 0.27917063f, -0.07403000f, -0.06181927f, 
    0.01098870f, -0.04081842f, -0.03682829f, -0.02628664f, -0.07644643f, 0.12739345f, 0.08885634f, 0.10121764f, 
    0.06074863f, 0.01382300f, -0.02497830f, -0.05332341f, 0.06230428f, -0.06913798f, -0.02564155f, 0.00663789f, 
    -0.04717728f, -0.04910076f, -0.07044459f, 0.03757535f, 0.04173969f, 0.01911207f, 0.01985213f, -0.05064872f, 
    0.05255625f, -0.07606781f, -0.07468393f, 0.05464372f, -0.05478478f, -0.01619891f, -0.03772244f, -0.05424267f, 
    -0.00371804f, 0.05683213f, -0.04598315f, 0.00095451f, -0.00531004f, -0.00632215f, -0.01971736f, -0.00682941f, 
    0.05637304f, -0.07366703f, 0.01612561f, -0.06473209f, 0.00023868f, 0.02775294f, -0.06347331f, -0.06125824f, 
    -0.00284754f, -0.06562344f, 0.02882676f, -0.01732318f, -0.03474097f, -0.02982803f, -0.02446873f, -0.04652164f, 
    -0.02910723f, -0.04064790f, 0.05105960f, -0.02559663f, 0.00388915f, -0.05155282f, -0.07378115f, -0.05808223f, 
    -0.06126540f, -0.07989927f, 0.04639320f, 0.04151760f, -0.07040320f, -0.02683934f, 0.05111098f, -0.03747375f, 
    0.06103857f, 0.04194669f, -0.01346218f, 0.00842954f, 0.03858501f, 0.01153937f, -0.00945754f, -0.05521857f, 
    0.02252310f, 0.01316755f, 0.03509105f, -0.07343119f, 0.03051686f, -0.02666752f, -0.02454641f, -0.00608995f, 
    0.03500948f, 0.02775813f, -0.06576601f, 0.06170873f, -0.08215743f, 0.05724750f, 0.01645523f, -0.05327448f, 
    -0.00152715f, 0.00277196f, -0.03232202f, 0.04134049f, -0.04119046f, 0.00480813f, 0.00784796f, -0.07695950f, 
    0.02024873f, 0.03460030f, -0.04647741f, 0.05128059f, 0.02481353f, -0.05463904f, 0.01436275f, 0.02457583f, 
    -0.05649194f, -0.05291683f, -0.00200480f, 0.02469542f, 0.02399116f, 0.05756190f, 0.04255090f, -0.04923550f, 
    -0.05889352f, 0.02632393f, -0.02187150f, 0.04323497f, -0.00183374f, 0.00863572f, 0.03985335f, -0.01842940f, 
    0.01141452f, -0.03815849f, 0.01217960f, -0.06190260f, 0.06180731f, 0.04209435f, 0.02489313f, 0.01424132f, 
    -0.02276302f, -0.07315853f, 0.05171626f, -0.02460993f, -0.03347668f, -0.01978864f, -0.02015492f, -0.04396929f, 
    0.04178075f, -0.00251144f, -0.01155064f, -0.01507616f, -0.06491183f, 0.01589694f, -0.07495267f, -0.00810323f, 
    0.01729618f, -0.05390956f, -0.04623932f, 0.03465844f, 0.00766728f, -0.07497951f, -0.03406399f, -0.00488045f, 
    0.01959067f, 0.05048045f, -0.06234364f, 0.00777492f, -0.06766932f, -0.05306873f, -0.00504034f, -0.03498697f, 
    0.05585495f, 0.01375900f, -0.01363918f, -0.05582855f, -0.05102604f, 0.05986689f, 0.00634923f, -0.07852252f, 
    0.03328121f, -0.04304011f, -0.07741252f, 0.04726984f, 0.05224112f, -0.02701494f, -0.05860361f, -0.04373443f, 
    -0.03960768f, -0.05756158f, -0.00062677f, -0.08039143f, -0.04939646f, 0.05224432f, -0.02149960f, 0.06533993f, 
    0.06265667f, -0.02116825f, 0.00188706f, -0.01114291f, 0.03033090f, 0.06274384f, -0.01853608f, -0.04785121f, 
    -0.08442529f, -0.01725288f, -0.20337674f, -0.03232819f, -0.03933759f, -0.02338443f, -0.17416984f, -0.09458055f, 
    0.03115346f, 0.14270200f, -0.05970566f, 0.00374705f, 0.30230457f, 0.05837510f, -0.03557610f, -0.01659103f, 
    0.00551244f, 0.03970410f, -0.01560113f, 0.03117402f, -0.14690667f, -0.07560656f, -0.00740877f, -0.05776552f, 
    0.27925247f, 0.22076248f, -0.06106933f, 0.46620071f, -0.07899357f, 0.03502939f, 0.02886550f, 0.05355972f, 
    0.04716620f, -0.09424436f, 0.01495785f, -0.14391914f, 0.36548576f, -0.21492907f, 0.35329232f, 0.03555974f, 
    0.10713003f, 0.05192978f, -0.00259138f, 0.02976231f, 0.03468296f, 0.07984725f, 0.17997500f, -0.02279676f, 
    -0.05105591f, -0.11057333f, 0.07716710f, -0.16852474f, 0.07549433f, 0.02591310f, 0.08644326f, -0.18004104f, 
    0.04665790f, 0.16361816f, -0.05393973f, 0.22884238f, -0.19221669f, -0.30496249f, -0.11577873f, -0.03019131f, 
    -0.04780392f, 0.18155722f, 0.05985682f, 0.05866595f, -0.03475848f, 0.03870228f, -0.04721690f, 0.09322195f, 
    -0.19319090f, 0.12083963f, 0.02289599f, -0.01346133f, 0.09514962f, 0.07457981f, -0.11244908f, -0.03434685f, 
    -0.08152572f, -0.08465035f, -0.04082395f, 0.03721406f, -0.17350493f, 0.14201720f, 0.03756185f, 0.00329681f, 
    0.09919710f, -0.21267945f, 0.04375473f, -0.01892814f, 0.07622145f, 0.01666825f, 0.07278938f, 0.01840068f, 
    0.02491770f, 0.06879429f, 0.05734878f, -0.06587399f, -0.02020522f, -0.01002381f, -0.01143990f, 0.01686946f, 
    0.03360193f, -0.15574251f, 0.00546998f, 0.11481053f, -0.05952685f, -0.05439590f, 0.31852037f, -0.15828109f, 
    -0.04152884f, -0.03634285f, 0.08340800f, -0.04528394f, 0.03155521f, 0.07957532f, 0.13652855f, -0.01650382f, 
    0.31360894f, -0.17716521f, -0.26564470f, 0.08296648f, 0.16699913f, 0.05556149f, 0.15333883f, -0.01261355f, 
    0.01517092f, -0.05618652f, -0.02353026f, 0.05325709f, 0.32340705f, -0.30157617f, -0.03746581f, 0.04469026f, 
    0.17550974f, 0.07015309f, 0.07056860f, -0.11177241f, 0.13135904f, 0.03842663f, 0.02708232f, -0.01585283f, 
    0.04350467f, -0.03187695f, -0.42955205f, 0.14703435f, 0.02390411f, 0.04578954f, 0.11047839f, -0.04829271f, 
    0.03421615f, 0.12605211f, 0.16406241f, 0.07844444f, 0.11981339f, -0.10695497f, 0.17461856f, -0.03099109f, 
    -0.01071964f, -0.02122032f, -0.09176385f, 0.14867409f, 0.07344470f, 0.08785325f, 0.00643364f, -0.04985982f, 
    0.00411364f, 0.29724222f, 0.26009852f, 0.01060407f, 0.07609680f, -0.15328120f, 0.04025973f, -0.03946450f, 
    0.07164568f, -0.06019878f, -0.04861749f, 0.20524387f, 0.20219873f, -0.23886654f, -0.11910436f, 0.16861932f, 
    0.18021291f, 0.17791744f, -0.08119818f, 0.17855971f, 0.04131158f, 0.02758469f, 0.01112315f, 0.08821639f, 
    -0.37492129f, 0.01310814f, -0.34166417f, 0.11762786f, 0.14404869f, 0.09025870f, 0.11796161f, 0.01385478f, 
    0.02059291f, 0.01889295f, 0.15679710f, 0.01388184f, -0.54776716f, 0.13220084f, 0.09709141f, -0.03913455f, 
    -0.01431921f, 0.13558598f, 0.00514144f, 0.00421127f, -0.00508708f, -0.01503781f, 0.13527422f, -0.01136878f, 
    -0.07224709f, -0.24849297f, -0.07860652f, 0.12216327f, 0.05792885f, 0.03522856f, -0.03432412f, 0.07554314f, 
    0.11612272f, 0.04218580f, -0.06786574f, 0.03408644f, -0.23372777f, 0.04997448f, -0.10472865f, -0.13159099f, 
    -0.03960725f, -0.08884211f, 0.08161474f, 0.09577682f, -0.01593794f, 0.09669068f, 0.10291561f, 0.13988478f, 
    0.18037567f, 0.16638693f, -0.11775141f, 0.17518927f, -0.02165906f, -0.03715387f, 0.11587512f, 0.03037808f, 
    -0.06804894f, 0.06477703f, 0.12598948f, 0.04484066f, 0.05120908f, -0.09009450f, 0.00187905f, -0.02031309f, 
    -0.00640340f, 0.10458319f, -0.02778414f, 0.09214486f, -0.14752512f, -0.05616845f, 0.05812594f, 0.01513317f, 
    0.04295522f, -0.12217339f, 0.02392880f, 0.20767295f, 0.08717275f, 0.16066635f, 0.02382456f, -0.19282317f, 
    -0.04804822f, -0.15743351f, 0.08398001f, -0.04085137f, 0.33639553f, -0.03431855f, -0.08966833f, 0.40587080f, 
    0.03032332f, 0.05077445f, 0.00161808f, -0.04154945f, 0.02357672f, 0.33915603f, 0.07642677f, 0.19419996f, 
    -0.52393156f, 0.21020031f, 0.07631844f, 0.06964994f, 0.08588652f, -0.00009214f, 0.15980850f, 0.16242430f, 
    0.04195957f, 0.05022701f, -0.07288788f, 0.01828145f, 0.01009507f, 0.10088437f, -0.12011765f, -0.21536884f, 
    0.10573494f, 0.08920998f, 0.17306897f, 0.08343528f, -0.00484386f, -0.03034342f, -0.01818972f, 0.12488449f, 
    -0.09751262f, 0.28060037f, 0.11936899f, 0.32886112f, -0.00008268f, 0.06785599f, -0.03884071f, 0.02055392f, 
    0.04178360f, -0.10836762f, 0.02223475f, 0.09764774f, -0.10653313f, 0.11108217f, -0.08886254f, -0.18740612f, 
    -0.07005218f, 0.00308408f, 0.05519478f, 0.00540306f, 0.09133528f, -0.10567133f, 0.01794357f, 0.06694249f, 
    0.06401212f, -0.27035201f, 0.29373738f, 0.51171166f, 0.20321698f, 0.05964462f, 0.06956440f, -0.01571908f, 
    0.00807578f, -0.04232385f, 0.02359038f, 0.15034690f, 0.24551417f, 0.10267565f, 0.42790711f, -0.06700750f, 
    0.00197445f, 0.07216674f, 0.09766873f, 0.02587373f, 0.02053940f, -0.00856355f, 0.07817271f, 0.09376054f, 
    -0.42072767f, -0.17666356f, 0.05687071f, -0.35856217f, 0.10074671f, 0.00567447f, 0.13551503f, 0.02145972f, 
    0.12582931f, 0.01149136f, 0.01915095f, -0.17585042f, -0.39178929f, 0.34078088f, -0.14777589f, 0.34433010f, 
    -0.03908797f, 0.09330374f, -0.09063997f, -0.04871632f, 0.07811018f, 0.06780873f, -0.04559366f, 0.08089128f, 
    0.09976048f, 0.09082060f, -0.19396412f, -0.08104403f, -0.03728883f, -0.03462791f, -0.02535865f, 0.12122964f, 
    -0.07174766f, 0.04408530f, 0.02042615f, 0.06065690f, -0.39499673f, 0.32914671f, 0.00751290f, -0.14113429f, 
    0.09367409f, 0.19182985f, -0.02098161f, 0.16195665f, 0.04618603f, -0.08168375f, 0.17319563f, -0.01119300f, 
    -0.01375266f, 0.31667191f, -0.04229945f, 0.06715473f, 0.12734678f, 0.01436579f, -0.03547516f, 0.02070065f, 
    0.02107696f, 0.05275291f, 0.10585552f, 0.04744749f, 0.19811487f, -0.30971906f, 0.04673621f, -0.19040138f, 
    -0.12348875f, -0.08667641f, -0.08488190f, -0.00628244f, 0.20024109f, 0.01098694f, -0.00640030f, 0.02431178f, 
    0.05002847f, 0.17034182f, -0.08960136f, -0.08385344f, 0.07841358f, 0.13164650f, 0.07077050f, -0.17975605f, 
    -0.01011035f, 0.10573548f, 0.09537603f, -0.05993896f, 0.56245303f, 0.22724183f, -0.25269294f, 0.14814472f, 
    -0.06996800f, 0.18502477f, 0.13671383f, 0.01142442f, -0.10121615f, 0.07873043f, -0.03875363f, -0.08393013f, 
    -0.06969160f, 0.18519060f, 0.05833838f, -0.16867349f, 0.03123423f, -0.00537497f, -0.00555959f, -0.17775606f, 
    -0.04815467f, -0.20654118f, 0.09988867f, -0.00346219f, -0.19507498f, 0.35025194f, 0.02005732f, 0.21784389f, 
    0.08725764f, -0.04583809f, 0.01482655f, -0.02422308f, 0.10255932f, 0.21355060f, 0.07703527f, 0.02482598f, 
    0.29325446f, -0.08936553f, 0.10050896f, 0.11900950f, 0.06491685f, 0.09163955f, -0.03230876f, 0.07753224f, 
    0.05690372f, -0.17514446f, -0.07621317f, -0.04452532f, 0.05289670f, -0.02735071f, 0.14194965f, -0.33734038f, 
    0.04990928f, -0.00516429f, -0.02376354f, 0.12417659f, -0.07068615f, 0.07345755f, -0.07698087f, -0.05331236f, 
    -0.17534839f, 0.06716124f, -0.13126992f, 0.06669904f, -0.02153979f, -0.03918354f, -0.10497762f, -0.01036174f, 
    0.11267015f, 0.10484934f, -0.07300267f, 0.09564673f, -0.06251143f, -0.25024152f, 0.16898522f, -0.04335025f, 
    0.15124236f, 0.04366808f, 0.17221031f, 0.07036187f, 0.06618944f, -0.04513807f, 0.02941143f, 0.10115023f, 
    0.44087589f, 0.01201362f, -0.13858391f, 0.41426459f, -0.00982364f, 0.06176809f, 0.13059965f, -0.02529030f, 
    0.00394605f, 0.08131124f, 0.07720707f, 0.02633466f, 0.17827469f, -0.01065288f, 0.34049332f, 0.04807318f, 
    -0.02543331f, -0.00513341f, -0.00691829f, -0.14524946f, 0.00868150f, -0.08589080f, -0.01329689f, 0.02012643f, 
    -0.26545948f, 0.11448099f, 0.08816475f, -0.40524095f, 0.11167880f, -0.10905458f, -0.00102441f, 0.01485429f, 
    -0.04391369f, 0.01574190f, -0.01184669f, 0.00165255f, -0.21987563f, 0.11644054f, -0.19329084f, 0.13696554f, 
    -0.05563162f, 0.07263354f, 0.14509591f, -0.07620428f, 0.10633358f, -0.04912107f, -0.02767521f, 0.00819096f, 
    0.00894676f, -0.14189780f, 0.01996658f, -0.04866489f, 0.04978909f, 0.07966566f, 0.08233010f, -0.10429426f, 
    0.06925904f, 0.06376688f, -0.17306297f, -0.06810566f, 0.45456809f, -0.36581758f, -0.25407019f, 0.18285021f, 
    -0.07775372f, -0.24340603f, -0.09410615f, 0.01461303f, -0.17287043f, 0.09628882f, -0.11134872f, 0.01253336f, 
    -0.16271678f, -0.26698303f, -0.28553021f, -0.12389554f, 0.12144002f, -0.03251233f, 0.01117234f, 0.16836680f, 
    0.06116012f, -0.06616403f, 0.04475488f, 0.06418494f, 0.25691232f, 0.02983668f, 0.08449709f, 0.39960665f, 
    -0.17509679f, -0.08612967f, 0.11990757f, -0.04339430f, -0.19166465f, -0.07391931f, 0.03791778f, -0.13912550f, 
    0.09354588f, 0.06696826f, 0.31725922f, -0.18195184f, -0.02880340f, -0.07955278f, 0.03949873f, 0.05079176f, 
    0.04483561f, -0.04651227f, -0.07912692f, 0.03072079f, 0.01001264f, 0.27164868f, 0.25324780f, 0.25999877f, 
    -0.00893961f, -0.07757600f, -0.00494530f, -0.16096808f, 0.18477362f, 0.04543487f, -0.08894648f, 0.04867373f, 
    0.10706060f, 0.05376029f, 0.13344954f, 0.03837752f, -0.13269734f, -0.06156911f, 0.07293503f, 0.25521621f, 
    0.13724110f, 0.06941755f, 0.13052663f, 0.24828108f, 0.27461749f, 0.03227508f, -0.09593625f, -0.23083483f, 
    -0.01254828f, 0.01615326f, 0.17727420f, -0.01493730f, -0.02106127f, -0.23321892f, -0.04310287f, -0.07042028f, 
    -0.53119516f, -0.12174663f, 0.35143605f, -0.18787985f, -0.04524875f, 0.01234905f, -0.03937176f, -0.01048505f, 
    -0.06256250f, 0.07065222f, -0.03221992f, 0.19318436f, 0.21306893f, -0.18451725f, -0.17688243f, 0.44457048f, 
    -0.10383886f, -0.07370670f, -0.04878787f, 0.09281231f, 0.09491739f, 0.10909949f, 0.17200379f, 0.02740384f, 
    0.22263063f, -0.03438121f, 0.08250751f, 0.28598619f, -0.07571182f, -0.01997194f, -0.04384250f, 0.08421922f, 
    0.02675466f, -0.05144844f, 0.07152323f, 0.12211265f, 0.33889949f, -0.12045020f, 0.12262031f, 0.22956228f, 
    0.01560647f, -0.00903090f, 0.03846652f, 0.04310903f, 0.06349085f, 0.00556504f, 0.04592387f, 0.00529275f, 
    -0.02851786f, 0.17703566f, 0.15501332f, -0.15467402f, -0.10421712f, 0.02867117f, 0.07099072f, 0.07431334f, 
    0.11162772f, -0.09280914f, -0.03913929f, -0.10216911f, -0.13020173f, -0.11657649f, 0.08434239f, -0.03494928f, 
    0.14015247f, 0.05692504f, -0.04144711f, 0.16018701f, 0.14565980f, 0.14099282f, 0.08165343f, -0.11128079f, 
    0.33949804f, 0.07710237f, 0.11697438f, 0.25866470f, -0.18423574f, 0.08912871f, 0.02734272f, 0.03109534f, 
    0.05686413f, 0.08603213f, 0.02484636f, 0.27518100f, 0.28956887f, -0.18075436f, 0.16901442f, -0.29994607f, 
    -0.03115296f, 0.02170412f, -0.07373374f, -0.03822493f, -0.09888485f, -0.03368743f, 0.02069076f, -0.03955827f, 
    -0.10083137f, -0.13389893f, 0.01786681f, 0.14578436f, -0.03286168f, -0.03297820f, 0.13415876f, -0.00404008f, 
    -0.07325367f, -0.08991110f, -0.05047441f, 0.02391594f, 0.37718457f, -0.04938211f, -0.00463522f, 0.23856996f, 
    0.04056485f, -0.15754913f, 0.07370652f, 0.12134022f, -0.05387191f, 0.20448834f, -0.01274601f, -0.00349593f, 
    -0.17259602f, -0.10539670f, -0.08214087f, 0.07650686f, 0.01789598f, -0.01510705f, 0.00059850f, 0.05564409f, 
    0.13013192f, 0.15536055f, 0.05161413f, -0.00682591f, 0.52206063f, -0.00170309f, 0.10849703f, 0.04215877f, 
    0.02838020f, 0.04592310f, 0.05876933f, 0.22369736f, 0.09874389f, 0.08037937f, 0.02859868f, 0.01537657f, 
    -0.00436602f, -0.02272282f, 0.02500025f, -0.19786933f, 0.05204957f, -0.14228928f, 0.05464162f, 0.01019788f, 
    0.07803858f, -0.01160104f, -0.00774810f, 0.07353146f, 0.52376765f, 0.09667911f, 0.08490874f, 0.18513787f, 
    -0.18075830f, -0.13716619f, 0.16633172f, -0.00921145f, -0.12115940f, 0.14666596f, -0.04963130f, 0.02443419f, 
    0.10087099f, 0.19298227f, 0.10684569f, -0.26710743f, 0.06626062f, 0.13451606f, 0.08883875f, 0.12216271f, 
    0.07794391f, -0.07680439f, -0.03776477f, 0.06181415f, -0.26690218f, 0.01346462f, -0.13107282f, -0.26438853f, 
    0.00252300f, 0.05341751f, 0.13860545f, -0.05245052f, 0.00399255f, 0.16876492f, -0.08884414f, -0.06676218f, 
    0.05427281f, 0.13318437f, -0.06970791f, 0.01870147f, -0.02855248f, 0.04695582f, -0.06022059f, 0.01534414f, 
    0.01898684f, -0.11145796f, -0.05302916f, 0.10681616f, -0.13155280f, -0.28268582f, -0.02354073f, 0.24672997f, 
    0.05670997f, -0.03008183f, -0.09463817f, -0.03898024f, 0.13894834f, 0.08564775f, -0.11053938f, -0.11959872f, 
    -0.15732747f, -0.07913738f, 0.10655558f, -0.13930111f, -0.02048246f, 0.11688242f, -0.04758199f, -0.00010301f, 
    0.14588350f, 0.11785832f, 0.09043965f, 0.07979321f, 0.52241993f, -0.43292767f, 0.24433787f, 0.18206698f, 
    -0.04898938f, 0.04923004f, 0.02352361f, -0.00717127f, 0.01150229f, 0.01657313f, 0.01213970f, 0.15375358f, 
    -0.09089246f, -0.03990631f, -0.05775205f, -0.10424319f, -0.00573504f, 0.03394624f, 0.16088396f, 0.00993688f, 
    0.17528243f, 0.01669616f, -0.02644692f, -0.01280036f, 0.04661368f, -0.05246211f, -0.06088232f, -0.41202193f, 
    -0.06841188f, 0.03819926f, -0.11200788f, 0.04802678f, 0.01174145f, -0.10632846f, -0.02545788f, -0.08221824f, 
    0.16754961f, -0.04320418f, -0.10762251f, 0.24437158f, 0.08486462f, 0.00782619f, -0.06742739f, 0.11060314f, 
    -0.10126354f, 0.10248025f, 0.03139618f, -0.05327531f, 0.12273338f, -0.11202631f, 0.06042185f, -0.13385996f, 
    -0.00274874f, 0.03793725f, 0.11215814f, -0.19106285f, 0.12797765f, -0.18315096f, 0.02737077f, 0.00721575f, 
    -0.06213261f, -0.07061735f, 0.02989883f, -0.01844924f, 0.00859693f, 0.02138661f, -0.07542943f, -0.04628587f, 
    0.03260786f, -0.04870148f, -0.00095213f, -0.08056474f, -0.03541299f, -0.00886867f, -0.07351050f, -0.05547177f, 
    -0.05887540f, -0.01195297f, 0.04591132f, -0.04644630f, 0.01850507f, -0.06717721f, -0.05644708f, -0.04793723f, 
    0.03840799f, -0.02920503f, 0.03153159f, 0.00260730f, -0.07769064f, 0.03103654f, -0.01619414f, 0.01555552f, 
    0.03847726f, -0.05738457f, -0.05562171f, -0.00293400f, -0.00598560f, 0.02412572f, -0.05953154f, -0.07290629f, 
    0.00244657f, -0.03060673f, -0.05917165f, -0.03684781f, 0.03045500f, 0.01346496f, -0.01973581f, 0.04028067f, 
    0.00662159f, 0.05462625f, 0.06322612f, -0.00352525f, 0.03977692f, 0.00859982f, -0.03563471f, -0.02464656f, 
    0.04767648f, -0.01193400f, -0.05258476f, 0.02437056f, -0.01758691f, -0.01915537f, 0.05704201f, -0.05334071f, 
    -0.01589143f, -0.06189679f, 0.00461084f, -0.03908813f, -0.02936549f, -0.06403040f, -0.02358707f, -0.06557825f, 
    -0.02072341f, -0.04098817f, -0.02426234f, 0.05429452f, -0.03438818f, -0.01863598f, 0.06036588f, -0.05824335f, 
    -0.03997151f, 0.05192909f, 0.01365703f, 0.04398216f, 0.06237385f, -0.05340581f, -0.04125839f, -0.05298684f, 
    0.03143619f, 0.01177326f, 0.06239512f, 0.03975781f, -0.00484298f, 0.02161252f, -0.02256165f, 0.03915768f, 
    -0.00102270f, 0.00144188f, 0.04228562f, -0.05628434f, -0.02024368f, -0.02554912f, -0.07096630f, 0.04515969f, 
    0.01001504f, -0.07324442f, -0.01643553f, -0.06654985f, 0.03426406f, -0.05570613f, 0.02672928f, 0.04376254f, 
    -0.06851618f, -0.00867500f, -0.04663676f, -0.02180999f, 0.01253731f, 0.06155275f, 0.01624684f, -0.06734294f, 
    -0.05531706f, -0.04681258f, -0.06154487f, -0.06859457f, -0.01245091f, 0.00326830f, -0.02667193f, -0.03708801f, 
    0.03679969f, -0.03395246f, 0.03749589f, 0.03296934f, -0.02227410f, -0.01280644f, -0.07110489f, 0.06102116f, 
    0.02652348f, -0.01904883f, -0.04952583f, -0.04595138f, -0.01722576f, -0.04479952f, 0.03188333f, -0.05110568f, 
    0.01169731f, 0.04304080f, -0.05389237f, -0.07885009f, 0.00433882f, -0.05948639f, -0.07156102f, 0.04307267f, 
    -0.04305069f, -0.03710267f, -0.03495290f, -0.04557773f, 0.04277200f, 0.01424910f, 0.05949292f, 0.04210681f, 
    0.01837190f, -0.03153801f, 0.02220818f, -0.04339997f, 0.02069630f, 0.01073817f, -0.07493057f, 0.00297739f, 
    -0.00173527f, -0.07493442f, -0.04462339f, -0.07244594f, -0.00462779f, 0.05030842f, 0.00816052f, -0.02827227f, 
    0.00400988f, 0.05732690f, -0.03082524f, -0.06128163f, 0.02544261f, -0.03310261f, -0.00235727f, -0.05772290f, 
    -0.06924841f, 0.00804517f, 0.05233925f, 0.00898834f, -0.07580827f, -0.06655311f, -0.07147444f, -0.07789253f, 
    -0.00787470f, -0.04646241f, 0.03033123f, -0.29834324f, 0.09928084f, 0.12633143f, -0.15897968f, -0.09073494f, 
    0.03871996f, 0.12733141f, -0.06010828f, -0.02158109f, 0.21104643f, -0.18352856f, -0.18489443f, 0.03958873f, 
    -0.05694236f, -0.00393349f, -0.13401893f, -0.06050552f, -0.00551973f, -0.03284641f, -0.08537207f, 0.15333605f, 
    0.24872099f, 0.08848498f, -0.09895132f, 0.30593914f, -0.05033882f, 0.03602982f, 0.02637549f, -0.01334324f, 
    -0.11604238f, -0.06424282f, 0.00043420f, -0.15148966f, 0.26413780f, 0.14784850f, -0.04415178f, 0.38401905f, 
    -0.05436299f, 0.03629226f, 0.13410430f, -0.00274787f, -0.12752564f, -0.23065712f, 0.05352973f, 0.04772782f, 
    -0.17805398f, -0.13661627f, 0.34182945f, -0.09518237f, -0.11351223f, 0.05517940f, 0.09797392f, 0.01242979f, 
    0.05701409f, 0.11754996f, 0.00646027f, 0.16751221f, -0.49355373f, -0.18583454f, 0.03307285f, -0.14116070f, 
    0.00811222f, 0.00305992f, -0.05209238f, -0.01054856f, 0.16295823f, -0.01414506f, -0.01206757f, 0.16513041f, 
    -0.12492426f, 0.04285568f, 0.06030432f, 0.06307529f, -0.11884275f, 0.11171328f, -0.03527262f, 0.10259626f, 
    -0.06743823f, 0.14825083f, 0.06463789f, 0.12865923f, -0.13784905f, -0.13767497f, 0.26518103f, -0.18347876f, 
    -0.08814514f, -0.07626776f, -0.02025029f, 0.11895895f, 0.00068445f, -0.19903915f, 0.00262594f, -0.08746699f, 
    -0.22090942f, 0.00678858f, -0.02476093f, -0.07771901f, -0.08766806f, -0.00891679f, -0.02585806f, -0.09335239f, 
    0.04891538f, 0.08813368f, 0.11227577f, 0.14403650f, 0.17413786f, 0.04213872f, 0.18872979f, 0.19452234f, 
    -0.12888315f, -0.08687393f, 0.11261676f, -0.00135554f, 0.05905742f, 0.08723146f, 0.16167301f, 0.10153270f, 
    0.45929524f, -0.10082402f, -0.11368348f, 0.07328721f, 0.19134650f, -0.00673334f, -0.00477656f, 0.06734455f, 
    -0.10049576f, -0.04841230f, -0.01608848f, 0.01362056f, 0.04134121f, 0.11107338f, 0.04830737f, 0.19919042f, 
    -0.01887501f, -0.02694361f, -0.11725599f, 0.03798932f, 0.03625726f, 0.01804572f, 0.07207289f, -0.05571163f, 
    0.01061446f, 0.11682884f, -0.27044043f, -0.13911647f, -0.00137629f, 0.05330091f, 0.16016641f, 0.13348027f, 
    -0.06627181f, -0.05927271f, -0.08021328f, 0.09872472f, 0.10210901f, -0.13550527f, 0.00919928f, 0.32754821f, 
    0.06782274f, -0.02277569f, 0.04507701f, 0.16132525f, 0.00073241f, 0.24770755f, 0.03506133f, 0.10259815f, 
    0.21989517f, 0.23901637f, 0.11960090f, 0.24747346f, -0.12686554f, -0.02105096f, -0.12122963f, -0.04356558f, 
    0.01415091f, 0.03200530f, -0.00801568f, 0.24683586f, 0.11853898f, -0.31565323f, 0.17833136f, -0.22455041f, 
    0.23881200f, 0.08673123f, -0.15670736f, 0.13436405f, -0.02055226f, 0.10385108f, 0.02077947f, -0.00782800f, 
    0.27032056f, -0.24171615f, -0.00262974f, -0.24869063f, 0.04722788f, 0.07459022f, -0.03267949f, -0.21588011f, 
    -0.15427604f, 0.08677540f, -0.03526650f, -0.00265096f, 0.32555014f, -0.32035238f, -0.26672938f, 0.05329281f, 
    -0.05752032f, -0.10272120f, 0.01041533f, 0.17964192f, 0.01591203f, 0.07305137f, -0.08076409f, 0.08648549f, 
    0.14803599f, -0.16612279f, -0.02708311f, 0.06697715f, 0.04682174f, -0.16876502f, 0.02670259f, 0.08205476f, 
    0.15434034f, 0.08483469f, 0.00043761f, 0.11132054f, 0.03505383f, -0.24558914f, 0.03837201f, 0.31519166f, 
    -0.10657786f, 0.03947134f, 0.11120231f, -0.06165278f, 0.00710050f, -0.11821600f, -0.01962374f, -0.04309310f, 
    0.26513475f, 0.11754511f, 0.19549462f, -0.02915399f, -0.05361733f, -0.05522887f, 0.00987878f, 0.01783528f, 
    0.07741918f, 0.19977176f, 0.01681411f, 0.01933153f, -0.27679747f, -0.02995516f, -0.12470347f, -0.23270701f, 
    -0.14500898f, 0.06038108f, 0.10678290f, 0.00603535f, 0.08658892f, -0.04801518f, -0.10834721f, 0.01854134f, 
    0.14348438f, 0.04106124f, -0.13924803f, -0.01640516f, -0.10779402f, 0.03279936f, 0.03661910f, 0.00475918f, 
    0.11700357f, 0.16632308f, 0.14785661f, 0.00653026f, 0.08411343f, 0.14946449f, 0.19687200f, -0.22741167f, 
    -0.01903353f, -0.09288935f, 0.10692599f, 0.01382969f, 0.02176972f, 0.00105752f, 0.09990727f, 0.00403080f, 
    -0.30442557f, 0.29336953f, 0.19520198f, 0.01841379f, 0.01592720f, -0.00328509f, 0.05648975f, 0.00518158f, 
    -0.19119984f, 0.01498793f, -0.13079697f, 0.10358357f, 0.25808179f, -0.22198308f, -0.02665043f, 0.40875223f, 
    0.19779290f, -0.04588109f, 0.05369130f, 0.14878276f, 0.15465011f, 0.07453721f, 0.05830696f, -0.02351557f, 
    0.36652902f, -0.14159678f, -0.02866049f, 0.19016339f, 0.01277055f, 0.08720747f, -0.06501397f, 0.14807779f, 
    -0.01124966f, -0.04428199f, 0.04816430f, 0.09433866f, 0.40811288f, -0.21806681f, -0.06627994f, 0.33874923f, 
    -0.09162345f, 0.01449702f, -0.04634196f, -0.04182548f, -0.00802363f, 0.04417768f, -0.02061892f, 0.00056113f, 
    0.09394433f, 0.11499848f, -0.09355282f, -0.06837919f, -0.20982257f, 0.06002009f, 0.05238601f, 0.12527010f, 
    0.13601483f, 0.05742028f, 0.09330557f, -0.08128301f, -0.35287526f, -0.03688847f, 0.02559563f, 0.30042240f, 
    -0.06408898f, 0.02746091f, -0.08168670f, 0.18034148f, -0.06815188f, 0.13070916f, -0.00551412f, -0.02570355f, 
    -0.17321046f, 0.06640070f, -0.05605403f, -0.02049734f, -0.13740072f, 0.07985484f, 0.03628369f, 0.06384500f, 
    0.05249624f, -0.01936502f, -0.19184554f, 0.03101457f, 0.21356589f, -0.37166080f, 0.02274266f, -0.13186371f, 
    0.14373305f, 0.01152955f, -0.02210534f, 0.05758853f, -0.03369046f, 0.16118298f, -0.02284243f, 0.05110881f, 
    0.03452256f, -0.06210182f, -0.04449847f, -0.04895499f, 0.04207262f, -0.02256390f, 0.03166416f, -0.07447401f, 
    -0.05165444f, 0.03000049f, 0.06983823f, -0.05832959f, -0.05304020f, -0.00562819f, 0.03897760f, -0.03464017f, 
    -0.05651971f, 0.05711671f, 0.02952774f, 0.02291933f, 0.03195874f, -0.03809426f, -0.05219281f, 0.06510830f, 
    0.03396789f, -0.00468107f, 0.00397159f, -0.05152173f, -0.05645861f, -0.05769389f, 0.03023530f, -0.03690554f, 
    0.02319312f, 0.02912269f, -0.04648949f, 0.05732854f, -0.02216483f, 0.05937382f, 0.00603136f, -0.03887573f, 
    -0.05762940f, -0.01817502f, -0.03049932f, 0.00245511f, -0.04824322f, 0.00268853f, 0.07282674f, -0.03365846f, 
    0.04558671f, -0.06325512f, -0.04513397f, -0.08324356f, -0.02566530f, -0.06765708f, -0.06268664f, -0.00499876f, 
    0.06269468f, 0.05486656f, -0.04500554f, 0.04308947f, -0.04793958f, 0.04952040f, -0.02067109f, 0.04827972f, 
    0.04912557f, 0.04761476f, -0.01343784f, -0.03158610f, 0.01599406f, 0.01963581f, 0.02098989f, 0.02132277f, 
    -0.06304882f, -0.04003699f, 0.03869471f, -0.05184373f, -0.05640370f, -0.01443164f, 0.03390012f, 0.02301239f, 
    -0.03742813f, 0.02508363f, 0.00633231f, -0.00681426f, 0.01160393f, -0.04311250f, -0.02436471f, -0.07115192f, 
    0.02940048f, 0.03692806f, -0.04653075f, -0.07540718f, -0.06885318f, 0.03172121f, -0.01498921f, 0.03192894f, 
    -0.04228656f, -0.01154019f, -0.02782949f, -0.02775112f, -0.05726957f, -0.02924404f, 0.04195171f, 0.05433092f, 
    0.01129925f, 0.06541865f, -0.03539607f, -0.01620207f, 0.02569373f, 0.02649400f, 0.01705842f, -0.01112656f, 
    0.03037962f, -0.07278012f, 0.04874616f, -0.07464330f, -0.05751524f, -0.07415076f, -0.07461338f, -0.04310083f, 
    0.06243858f, -0.04008064f, -0.07639775f, 0.05609707f, -0.02882512f, 0.00479462f, 0.04462085f, 0.04214031f, 
    0.00861884f, 0.06035370f, 0.02640667f, -0.04450529f, -0.01615127f, -0.04846304f, -0.07169265f, -0.05360540f, 
    -0.01788695f, -0.04729994f, 0.05740092f, 0.01262682f, 0.03652735f, 0.03086016f, -0.02832481f, 0.05723870f, 
    -0.05266531f, 0.04376220f, 0.03168882f, 0.04538721f, -0.05281330f, 0.02026103f, 0.00610030f, -0.04338389f, 
    -0.07121813f, -0.01337122f, -0.05960965f, -0.00189009f, -0.05338660f, -0.06628573f, 0.00283091f, -0.04323214f, 
    -0.04444003f, -0.02919892f, -0.06263670f, 0.04271923f, 0.03326339f, -0.01446602f, 0.02294956f, -0.03465532f, 
    0.05625695f, 0.00296869f, -0.03575228f, -0.02367580f, 0.04241457f, 0.05401759f, 0.04496697f, 0.02360804f, 
    0.00778833f, 0.01672096f, -0.01191049f, 0.05462736f, 0.04147362f, -0.05524166f, -0.05093168f, -0.03769117f, 
    -0.02169728f, 0.01005257f, -0.00965221f, 0.04517588f, -0.04825609f, 0.03558405f, -0.07217404f, 0.00097355f, 
    0.11157589f, -0.00562180f, 0.19877884f, -0.17994936f, 0.02970790f, -0.06082899f, 0.03506099f, 0.14060088f, 
    0.01276933f, -0.02347914f, 0.00696947f, 0.18305106f, -0.40531051f, 0.37638727f, 0.19424723f, 0.22573961f, 
    -0.03313813f, 0.11596213f, -0.09754614f, -0.07814871f, 0.07159025f, 0.06270812f, 0.07674742f, 0.13565917f, 
    0.63867867f, 0.33901602f, 0.13447669f, 0.07494935f, 0.08720438f, 0.01493901f, 0.00085602f, -0.10106105f, 
    -0.15800604f, 0.04713433f, 0.06922844f, -0.02133997f, 0.21962580f, 0.24351601f, -0.25372756f, 0.11509766f, 
    0.12787963f, 0.04729623f, -0.04657402f, -0.10455140f, 0.16300310f, 0.05314253f, 0.03040717f, 0.16401364f, 
    -0.41833258f, -0.04836862f, -0.20659104f, -0.13017312f, 0.11980342f, 0.14887595f, -0.05232990f, 0.09798080f, 
    0.01411462f, 0.01967973f, 0.08408815f, -0.03027013f, -0.29534540f, -0.36503255f, -0.06356959f, -0.03664661f, 
    0.07914795f, -0.03079347f, 0.11596645f, -0.00637484f, -0.06322999f, 0.14145502f, 0.09650306f, 0.03690122f, 
    -0.19053701f, -0.00296152f, -0.04443080f, -0.23236799f, 0.05766321f, 0.06031014f, 0.04255528f, 0.06271729f, 
    -0.03289919f, 0.15205199f, 0.00500802f, 0.09985541f, -0.37784684f, -0.08047458f, 0.18796548f, 0.05107367f, 
    -0.01969083f, -0.01490198f, -0.03297833f, 0.06848280f, 0.05490467f, 0.09291745f, 0.07929722f, 0.01441336f, 
    -0.33688480f, 0.24120145f, -0.38630912f, 0.07206163f, -0.05616800f, 0.01185602f, 0.08734502f, 0.01585759f, 
    0.08399213f, 0.02115340f, 0.09208902f, 0.03908282f, -0.13709947f, 0.04864372f, 0.19992433f, -0.05152487f, 
    0.04311873f, 0.05035261f, 0.05397953f, 0.02567848f, -0.00422611f, 0.24227111f, 0.02101837f, 0.13076940f, 
    -0.11918895f, 0.08877050f, 0.19477470f, -0.17352842f, 0.15163237f, 0.03222128f, -0.13020238f, -0.12570265f, 
    0.07006963f, -0.01303964f, 0.12113303f, 0.13600232f, -0.48825330f, 0.28498676f, 0.18136553f, 0.25012767f, 
    -0.06193329f, -0.01006097f, 0.06769753f, -0.05121180f, 0.02956861f, 0.02043405f, -0.02273823f, -0.00526089f, 
    0.14525220f, -0.08345267f, -0.10211259f, 0.07129455f, -0.11925303f, 0.01469495f, 0.06136190f, 0.06460345f, 
    -0.09440532f, -0.00514785f, -0.02184642f, -0.00266530f, 0.36314431f, -0.09867417f, 0.09383044f, 0.09907547f, 
    0.07275157f, -0.25917760f, -0.10045931f, -0.20414324f, 0.03492773f, -0.11522637f, -0.10829169f, 0.02425754f, 
    0.11152786f, 0.09507955f, -0.10872059f, 0.13424240f, 0.13626325f, -0.02800820f, -0.01154654f, -0.05958777f, 
    -0.03777054f, 0.05566951f, -0.01411790f, 0.08033901f, -0.40307552f, 0.08481266f, -0.11995179f, 0.01891524f, 
    0.01100001f, 0.15194887f, 0.16469482f, -0.04360233f, -0.06268061f, 0.16290598f, 0.04132570f, 0.09954785f, 
    0.35741371f, 0.04807376f, 0.08281305f, 0.06817390f, -0.11806443f, -0.00798475f, 0.00170404f, 0.03584959f, 
    0.07420875f, 0.07764083f, 0.08205321f, 0.03141719f, 0.44924155f, 0.05909447f, -0.13110752f, -0.21932247f, 
    -0.10270254f, 0.01348416f, -0.02772327f, 0.00807576f, -0.08704149f, -0.09944043f, -0.07436531f, -0.11452379f, 
    0.41928500f, 0.12329590f, 0.20378934f, -0.44801375f, -0.12401671f, 0.01781712f, 0.11508357f, -0.07392927f, 
    -0.22759174f, -0.01758034f, 0.01711365f, -0.14776222f, -0.14057843f, 0.06740652f, -0.09739710f, 0.07352177f, 
    0.05321869f, -0.00944282f, 0.12708455f, -0.00265713f, 0.14733437f, 0.19557804f, 0.05532103f, -0.00364191f, 
    -0.06987682f, -0.05175416f, 0.03411819f, 0.20497647f, -0.12369546f, 0.08101749f, 0.02910326f, 0.10024055f, 
    -0.06538491f, 0.03503221f, 0.05000757f, -0.11827918f, 0.00174008f, 0.16765188f, -0.00544415f, -0.16861683f, 
    -0.02706281f, 0.02541293f, -0.03079415f, 0.09204587f, 0.15797029f, 0.06556357f, 0.02340379f, -0.01857780f, 
    -0.32784447f, -0.25143686f, 0.00974642f, 0.06951711f, -0.04272484f, -0.04144416f, -0.00700487f, -0.10476089f, 
    0.16686423f, 0.07136617f, -0.12884833f, -0.15756810f, 0.01692012f, 0.06163738f, 0.15704142f, 0.07782793f, 
    -0.05758188f, 0.05579520f, -0.09902346f, 0.03075738f, 0.03486898f, 0.08047742f, 0.17759296f, 0.12943989f, 
    0.27721429f, -0.21628290f, -0.11380821f, 0.18212548f, -0.03016676f, -0.03397797f, 0.07598138f, -0.03457839f, 
    -0.11830003f, 0.17658633f, 0.00296774f, -0.16629331f, 0.21422327f, 0.26737964f, -0.09826544f, 0.02383761f, 
    0.08139065f, 0.06662331f, -0.18140505f, 0.16816467f, -0.05602839f, 0.10504574f, -0.04924082f, -0.05190536f, 
    0.05101291f, 0.11125465f, -0.09295890f, -0.22247517f, 0.06697352f, -0.01787929f, 0.06661774f, 0.06672314f, 
    -0.11619184f, 0.11105227f, 0.00332064f, -0.22239387f, -0.01522602f, 0.29019666f, -0.04294820f, 0.13297547f, 
    0.06526800f, -0.01811136f, -0.09044228f, -0.12688407f, -0.16272587f, 0.14063768f, -0.17810272f, -0.16606879f, 
    -0.26567000f, 0.27842221f, 0.16898488f, -0.11924825f, -0.02217860f, -0.00891977f, -0.12994300f, 0.07760829f, 
    -0.03653984f, 0.08975033f, 0.11163335f, 0.18892300f, -0.22153999f, 0.15348828f, -0.35439074f, 0.30869561f, 
    -0.09461375f, 0.04637557f, 0.02399216f, -0.07578319f, -0.06127542f, 0.00521578f, 0.04271334f, 0.00448147f, 
    0.15883619f, -0.03047815f, -0.20432112f, -0.03477388f, -0.10081386f, 0.18622983f, -0.06770441f, -0.05791174f, 
    -0.13667308f, -0.19231927f, 0.03495027f, -0.19984736f, 0.15047660f, 0.04831292f, 0.05153609f, -0.05291708f, 
    -0.00747029f, -0.16441147f, 0.14275774f, 0.14383221f, -0.10529342f, 0.16762757f, -0.04595235f, 0.14845526f, 
    -0.16909854f, 0.00346175f, -0.12114216f, -0.15681636f, 0.30943978f, 0.12058626f, 0.14918044f, 0.07639469f, 
    0.05738333f, -0.07989717f, 0.10201693f, 0.02673552f, -0.15269645f, -0.35475990f, 0.16433360f, 0.11334488f, 
    -0.10575578f, -0.04721914f, 0.02483561f, -0.21082549f, 0.02890228f, 0.01529936f, 0.02334599f, -0.02729518f, 
    -0.19101878f, -0.33636135f, 0.03666317f, 0.14196038f, 0.08299480f, 0.11495268f, 0.01292203f, -0.00403307f, 
    0.08050703f, -0.15011160f, -0.01587026f, -0.06863982f, -0.18605803f, 0.26400039f, 0.03529511f, 0.07725684f, 
    0.04032350f, -0.05450765f, 0.07375931f, 0.11303268f, -0.08966333f, 0.09922490f, 0.08554940f, 0.03143818f, 
    -0.20006618f, -0.03810340f, -0.06842349f, 0.25133505f, 0.13768741f, -0.10677956f, -0.02811469f, 0.04576802f, 
    -0.01767574f, -0.11396725f, 0.04451048f, 0.07717001f, 0.42786714f, -0.05137147f, 0.10667127f, -0.22396030f, 
    0.13646445f, -0.02681575f, -0.18305279f, 0.04093330f, -0.12988301f, 0.00409002f, 0.09748949f, 0.04051417f, 
    -0.16122225f, -0.24018744f, 0.08297855f, 0.10392240f, 0.04854605f, -0.05585160f, -0.17955436f, 0.02032998f, 
    0.00912872f, -0.11809409f, 0.00956876f, 0.05422239f, 0.19583158f, -0.29286543f, -0.08275950f, -0.01149278f, 
    -0.11662473f, 0.15590750f, -0.08018725f, -0.07509830f, 0.03260715f, 0.07394134f, 0.03732919f, 0.09205899f, 
    -0.40550330f, 0.16555791f, 0.02634968f, 0.04856877f, 0.16404502f, -0.02861565f, 0.09066228f, 0.06186856f, 
    0.08456667f, 0.09632112f, -0.08586197f, -0.00213661f, 0.03776357f, -0.14115247f, -0.11751085f, 0.26092091f, 
    -0.01757244f, 0.07956974f, 0.12412796f, -0.01723447f, 0.15265104f, 0.01965374f, -0.03321774f, 0.03435003f, 
    -0.21652588f, 0.34100646f, 0.37314591f, 0.18065415f, -0.28072673f, -0.05408328f, -0.01582398f, -0.05497322f, 
    -0.00656188f, -0.04883444f, 0.11136770f, 0.08297680f, -0.05818455f, 0.05085823f, 0.09941021f, -0.40306163f, 
    0.05461373f, -0.08331770f, 0.07955164f, -0.05031231f, 0.05940845f, 0.03678999f, -0.01862267f, 0.04430000f, 
    -0.44083083f, -0.25162774f, 0.28056392f, -0.05419732f, 0.07171198f, -0.06732444f, -0.08498128f, -0.00973353f, 
    0.07928240f, 0.00735513f, 0.04345099f, 0.25835678f, 0.15273075f, 0.32391864f, -0.09422340f, 0.17055939f, 
    -0.04507988f, 0.09474028f, -0.06879002f, 0.15931469f, 0.01341406f, 0.04142004f, -0.04952041f, 0.17491357f, 
    0.09442057f, -0.08412442f, 0.05192969f, 0.11769425f, 0.09983519f, -0.09845173f, -0.08626689f, -0.06306546f, 
    0.14025430f, 0.13894470f, 0.08200067f, -0.02743485f, -0.04462219f, -0.05036909f, 0.13485885f, 0.05310397f, 
    -0.06624433f, 0.08552955f, -0.11265279f, -0.04422629f, -0.02843595f, -0.01298525f, 0.17031455f, 0.22855577f, 
    -0.17642032f, 0.18953918f, -0.17197683f, 0.00147221f, -0.00283937f, 0.01297860f, -0.03366099f, 0.09198768f, 
    0.01084864f, 0.07123747f, -0.08218225f, -0.06017251f, -0.46880889f, 0.15226354f, 0.10592847f, -0.04117194f, 
    0.20245770f, 0.15896949f, -0.08761863f, -0.00479378f, -0.17368028f, 0.00832084f, 0.03107887f, 0.01538487f, 
    -0.10896939f, 0.00045570f, -0.27765682f, 0.16898167f, 0.09821896f, 0.06363308f, 0.01601505f, -0.00749438f, 
    0.14934397f, -0.10184123f, 0.12402157f, 0.05908035f, 0.06395522f, 0.09319089f, 0.15422662f, -0.31920752f, 
    0.07556842f, -0.05024789f, -0.05898578f, -0.03682533f, 0.02771963f, 0.00875651f, -0.11643133f, -0.01493870f, 
    0.19153643f, 0.11077997f, 0.01141988f, 0.06545410f, 0.14180587f, 0.04665038f, 0.09018238f, -0.12617022f, 
    -0.06652633f, -0.02745875f, -0.08171503f, -0.02332270f, 0.09381807f, 0.02657584f, 0.04521691f, 0.31242645f, 
    0.02605713f, 0.13643749f, 0.01054777f, -0.13583988f, -0.09901891f, -0.10397265f, 0.00111341f, 0.05036023f, 
    0.02631211f, 0.27301049f, 0.09165195f, 0.06360631f, 0.03784572f, 0.02357630f, 0.01436430f, -0.08497119f, 
    -0.02126264f, -0.24719585f, 0.05432200f, 0.00451487f, 0.19072485f, -0.03252485f, -0.09304809f, 0.39482290f, 
    0.07347448f, 0.18322276f, 0.03438175f, -0.05879564f, -0.07203642f, 0.10328995f, 0.14154826f, 0.05195852f, 
    0.03945469f, -0.07483584f, 0.15962483f, -0.09789744f, -0.02630809f, 0.07595628f, -0.02302599f, -0.04806943f, 
    0.10868959f, -0.00812971f, 0.06878436f, 0.10297603f, -0.12325119f, 0.15022108f, 0.13383082f, -0.47080815f, 
    -0.11985346f, -0.01128961f, 0.04877702f, -0.11209824f, -0.06773839f, -0.05953277f, 0.17830572f, -0.07225761f, 
    -0.13982159f, 0.07467349f, -0.08068078f, 0.27378613f, -0.11717644f, -0.09721421f, 0.04785015f, -0.06782412f, 
    0.01018709f, 0.00343271f, -0.02105871f, 0.17480390f, -0.21632001f, -0.00199359f, -0.02763387f, -0.27416584f, 
    0.01949743f, 0.02209363f, 0.08739568f, 0.03798284f, 0.15858349f, -0.14841703f, 0.10118604f, -0.06034999f, 
    0.25351009f, -0.01486606f, 0.07038539f, 0.48817340f, 0.11044735f, -0.02875368f, 0.04761801f, -0.06977811f, 
    0.03966182f, 0.03758275f, -0.09994219f, 0.07795428f, 0.25425643f, -0.09823070f, 0.28038356f, -0.18283650f, 
    0.11240377f, -0.07507808f, 0.00355143f, -0.09616214f, 0.07564283f, 0.06279258f, 0.05998481f, -0.04333166f, 
    -0.16354331f, 0.03268159f, 0.19165634f, -0.17061083f, 0.18846662f, -0.18841060f, 0.08968851f, 0.03436438f, 
    0.05382312f, -0.04486788f, -0.11683077f, 0.10986044f, -0.06822953f, 0.23827431f, -0.08347712f, 0.19933611f, 
    -0.04052432f, 0.20311253f, 0.00945241f, -0.04489614f, 0.17016324f, 0.02516589f, -0.04758285f, 0.04571342f, 
    0.54450905f, -0.14893992f, -0.13878705f, -0.22851615f, 0.07433815f, -0.00965873f, -0.02923656f, -0.08161698f, 
    -0.04191872f, 0.09473711f, -0.11522564f, 0.00538470f, 0.30442947f, -0.20095882f, -0.14415374f, -0.14934520f, 
    -0.09153939f, -0.01129745f, 0.15426239f, 0.11300949f, -0.08173706f, 0.01470030f, -0.05690513f, -0.03438435f, 
    -0.01975904f, 0.19036049f, 0.13158374f, -0.05170817f, -0.05926996f, -0.08864623f, 0.11718971f, 0.12397778f, 
    0.04462200f, 0.11632106f, -0.01941757f, 0.15444355f, -0.05195901f, -0.27904114f, 0.19368389f, 0.05885045f, 
    -0.05642118f, 0.07053602f, -0.01664014f, -0.05815200f, 0.00261002f, -0.05251545f, -0.12926653f, -0.14174585f, 
    0.08611811f, -0.18037628f, 0.10180924f, 0.03917174f, 0.21721423f, 0.09248956f, 0.10417792f, -0.06389648f, 
    0.07854497f, 0.26486728f, -0.11416070f, -0.01797946f, 0.22834018f, 0.01757099f, -0.06458662f, -0.29317722f, 
    0.04983579f, 0.23961069f, -0.06275105f, -0.01948666f, 0.03231098f, -0.02092182f, -0.04305950f, -0.15252794f, 
    -0.04826653f, -0.12740378f, -0.19295119f, -0.05320268f, -0.05818875f, -0.02330518f, -0.09516990f, 0.05586031f, 
    0.15496314f, 0.13807991f, 0.01399460f, -0.04877940f, -0.09042141f, 0.25470462f, 0.16706823f, -0.06502637f, 
    0.14193937f, -0.09276364f, 0.09648235f, -0.11635626f, 0.11644676f, -0.02796665f, 0.06987114f, -0.05657295f, 
    0.37149134f, 0.00500147f, -0.04963103f, 0.00651880f, 0.08033501f, 0.03267551f, -0.03665754f, 0.02097191f, 
    -0.03016682f, 0.00628664f, 0.05229679f, 0.03275327f, 0.14078574f, -0.13593930f, -0.12451807f, 0.12509687f, 
    0.29895267f, 0.00030989f, -0.06113235f, 0.12489434f, -0.00404901f, 0.09496474f, 0.07234447f, 0.15890349f, 
    0.08543634f, 0.12145456f, 0.08645254f, 0.13756594f, -0.08274551f, -0.07373767f, -0.14882112f, 0.13292576f, 
    -0.16694841f, -0.08658700f, 0.07207771f, 0.09455820f, 0.23728625f, -0.13249527f, 0.10490345f, 0.01471204f, 
    0.06196544f, 0.03303182f, 0.11756086f, 0.01749490f, 0.17605297f, 0.05741879f, 0.00582705f, 0.05704251f, 
    -0.03093605f, 0.03901793f, -0.07169621f, -0.05055710f, -0.10012658f, 0.01994588f, -0.09274142f, -0.04638229f, 
    -0.03461174f, 0.12839523f, 0.09132056f, -0.05585628f, -0.48148003f, 0.18493839f, 0.02990973f, 0.23011149f, 
    -0.12680723f, 0.13744715f, -0.11641401f, 0.10537016f, 0.00323235f, 0.03969675f, 0.03418149f, -0.11879509f, 
    -0.16303232f, 0.14645222f, 0.00484505f, -0.16350751f, -0.03235000f, 0.04630969f, -0.02083241f, 0.06242204f, 
    0.18203233f, -0.05238738f, 0.04348087f, 0.23376091f, 0.26507610f, -0.62157297f, -0.17187269f, 0.02757825f, 
    0.21524367f, -0.13593496f, 0.25176281f, -0.00790148f, -0.00793138f, -0.07340091f, 0.02483237f, 0.13963135f, 
    -0.20785166f, 0.10155242f, -0.19904262f, 0.03691328f, 0.27927536f, 0.12322414f, 0.13332666f, 0.18213603f, 
    0.04250452f, -0.03276007f, -0.04907731f, 0.12483398f, -0.00757426f, -0.18702537f, -0.16339412f, 0.09734864f, 
    -0.17702952f, 0.00348456f, 0.05805348f, -0.08291312f, -0.19031821f, -0.05888239f, -0.02099774f, -0.07757048f, 
    -0.29156554f, -0.32662004f, -0.25787842f, -0.18561903f, -0.03523152f, -0.02936152f, 0.16283526f, -0.06639463f, 
    -0.06373143f, -0.18004566f, -0.10040925f, 0.05390290f, -0.12346205f, 0.29232037f, 0.13909154f, -0.04960342f, 
    0.07234373f, 0.07404270f, -0.06074755f, -0.17144912f, -0.18946579f, -0.02517295f, 0.00572861f, 0.02686362f, 
    -0.03818114f, 0.16614115f, -0.07900535f, 0.21762726f, 0.17990860f, 0.03075401f, 0.04587232f, 0.25595087f, 
    0.07572467f, -0.06392946f, 0.12505285f, 0.06852938f, 0.44245344f, 0.02743827f, 0.24063519f, 0.00220271f, 
    0.18836659f, 0.10658327f, 0.11522769f, -0.03598725f, -0.04454771f, 0.05841185f, 0.04167865f, 0.03818345f, 
    0.03729977f, -0.11967127f, 0.21301800f, 0.14713821f, -0.02255346f, 0.05778268f, -0.09702452f, 0.03466469f, 
    0.08949704f, 0.03228553f, 0.13092718f, -0.04684131f, 0.35348210f, -0.06260736f, -0.15539818f, -0.03386885f, 
    0.09454496f, 0.13425121f, 0.09075853f, -0.05139842f, 0.07640246f, 0.06073844f, 0.01579222f, -0.09926029f, 
    -0.26414955f, -0.16034968f, 0.18998943f, -0.11053117f, 0.08354885f, -0.08180938f, -0.14738311f, 0.04585228f, 
    0.09666498f, 0.07625687f, 0.01855048f, -0.03469034f, 0.29719335f, -0.13057297f, -0.26093563f, 0.07756164f, 
    -0.17853883f, 0.17055440f, 0.01918185f, -0.04911696f, 0.10032442f, -0.15048963f, -0.12107749f, -0.09280311f, 
    -0.11817060f, 0.31637231f, 0.18586542f, 0.33731779f, -0.18579733f, 0.05108436f, 0.08587535f, 0.15938228f, 
    -0.02295876f, 0.11027879f, 0.02939188f, -0.05157516f, -0.10776802f, 0.17936283f, -0.04627076f, -0.24568228f, 
    -0.00870245f, 0.10734678f, -0.08697056f, -0.27472395f, -0.01153246f, -0.03725946f, -0.15978386f, 0.05092620f, 
    -0.29793081f, -0.07008544f, 0.50039929f, -0.03887534f, 0.24303202f, 0.08392042f, -0.04659648f, 0.03131446f, 
    -0.03842506f, 0.16735747f, 0.00728242f, 0.01988786f, -0.00946521f, 0.19503739f, 0.19259818f, -0.01669528f, 
    0.23954344f, -0.02446852f, 0.08919991f, 0.04858624f, 0.02216700f, 0.03382425f, 0.00893392f, 0.05587307f, 
    0.23324315f, -0.12770987f, 0.06593172f, 0.08176658f, -0.09521386f, -0.06597207f, -0.17904529f, -0.20601776f, 
    0.11608779f, -0.06604263f, 0.02227331f, -0.07345473f, 0.02845544f, 0.08944139f, -0.05156230f, -0.02847161f, 
    -0.16960739f, -0.01628748f, 0.02935438f, 0.01141101f, -0.04400942f, -0.00893360f, -0.01180861f, 0.10636693f, 
    0.07508323f, -0.00204643f, 0.11000439f, -0.08194809f, 0.09953804f, -0.01538317f, -0.00009419f, -0.07887428f, 
    0.05369898f, 0.13647084f, -0.05189414f, 0.12172603f, 0.44688383f, -0.01282957f, 0.02747405f, 0.20694627f, 
    -0.04861918f, -0.17197779f, 0.01348266f, 0.01402222f, -0.16260707f, 0.02281941f, -0.13934161f, 0.02333522f, 
    0.19895953f, 0.33683795f, -0.02642892f, 0.24668303f, -0.15923157f, 0.10233089f, 0.04464823f, 0.07781561f, 
    -0.04752607f, -0.08270103f, 0.09313779f, -0.03493774f, 0.32192644f, 0.08113477f, 0.23396014f, 0.21066502f, 
    0.09363221f, 0.18739067f, -0.06136872f, 0.12848529f, -0.04197140f, 0.04848383f, 0.07108260f, -0.03512061f, 
    -0.24889879f, -0.23521002f, -0.02795972f, -0.09385762f, 0.16121426f, 0.09696831f, 0.08106297f, 0.01748029f, 
    0.08861075f, -0.00152852f, -0.02581248f, 0.22080746f, 0.05295306f, -0.29230788f, 0.10853849f, 0.01270418f, 
    0.07875330f, -0.00217830f, -0.00772352f, -0.09168496f, 0.00959016f, 0.07154164f, -0.03238725f, 0.11490677f, 
    -0.27654991f, -0.05227374f, 0.03688484f, 0.02605185f, 0.14252681f, 0.07337499f, -0.03725565f, 0.14498501f, 
    -0.07687572f, 0.11737689f, 0.00055054f, 0.09624100f, -0.22542050f, 0.05751022f, 0.05230923f, -0.30231526f, 
    0.02524305f, -0.02649616f, 0.01643130f, -0.02082905f, 0.10839377f, -0.22679916f, -0.05420695f, -0.06334107f, 
    -0.00253764f, -0.13470218f, -0.13678057f, -0.04090953f, 0.03808516f, 0.10249892f, -0.08376255f, -0.07100447f, 
    0.10355816f, -0.03087002f, 0.09252678f, 0.21118072f, -0.12060280f, -0.08499882f, 0.21436940f, 0.06747175f, 
    -0.05837410f, -0.12022732f, -0.15459619f, -0.02193971f, -0.00553692f, 0.13077588f, 0.21635114f, 0.00095727f, 
    0.22190601f, -0.01427073f, -0.01858835f, 0.08215079f, -0.07146511f, 0.05368644f, -0.05429525f, 0.13395490f, 
    0.03362841f, -0.03854384f, 0.03286860f, 0.00606002f, 0.17808940f, -0.10124233f, 0.18927360f, 0.10805815f, 
    0.04488749f, 0.06990569f, -0.03100216f, -0.02066178f, 0.13536647f, 0.00471253f, 0.01425674f, -0.12371723f, 
    -0.09752255f, -0.08785827f, -0.13789578f, -0.25215146f, -0.01003588f, -0.04948119f, 0.04148631f, 0.05178483f, 
    -0.00169735f, 0.07744953f, 0.03365778f, 0.00405190f, 0.10508024f, -0.02206798f, 0.07306948f, -0.01865924f, 
    0.09567212f, 0.02304853f, -0.13527082f, 0.15018593f, 0.15780669f, 0.17009510f, -0.12529199f, 0.05855151f, 
    0.40995982f, 0.25293413f, 0.14689597f, 0.33487102f, 0.05018402f, -0.01971723f, 0.03518631f, -0.05951709f, 
    0.07479841f, 0.07912035f, -0.00293326f, 0.14992557f, 0.18793344f, -0.36123297f, -0.03747073f, -0.12092655f, 
    0.05993958f, 0.08375747f, 0.00211752f, -0.00330117f, 0.08426479f, -0.05862708f, -0.01920237f, 0.01320768f, 
    0.01082089f, -0.05832900f, 0.03037193f, -0.06675710f, -0.00635270f, 0.03727877f, 0.03603428f, -0.06111602f, 
    -0.01915953f, -0.06429132f, -0.03348280f, 0.06265525f, -0.01394269f, 0.03433018f, 0.00694364f, -0.05015279f, 
    -0.03872459f, -0.04684816f, -0.02512807f, -0.04169293f, -0.04948439f, 0.04351215f, -0.06497838f, -0.04553134f, 
    0.03812626f, -0.05645386f, -0.05311513f, -0.01306522f, -0.00966266f, -0.00910694f, 0.01777362f, 0.01319091f, 
    -0.07266974f, -0.02412063f, 0.00460273f, -0.02501765f, 0.05113909f, 0.00852324f, -0.00928792f, 0.02595294f, 
    -0.04091120f, -0.06610968f, -0.02296330f, 0.02211319f, 0.03805568f, 0.02080814f, -0.01887571f, -0.07521813f, 
    -0.03717965f, 0.00082874f, 0.00416406f, -0.06245933f, 0.01841973f, -0.01180103f, -0.05074888f, -0.06813252f, 
    -0.04137230f, -0.05211712f, 0.03274726f, -0.00811078f, -0.07634731f, 0.03126727f, -0.03637437f, -0.05668795f, 
    0.04362002f, -0.05655399f, -0.04075453f, -0.00885116f, 0.04978978f, -0.00316738f, -0.05929559f, 0.02476008f, 
    -0.00893070f, -0.07436375f, 0.00803651f, 0.03685298f, 0.02455339f, -0.07658623f, 0.03487215f, -0.06739497f, 
    0.03499205f, 0.02433667f, -0.04135845f, -0.00913640f, -0.07217756f, -0.01926392f, 0.02284753f, 0.00609868f, 
    0.03663382f, -0.00112149f, 0.00278435f, -0.00274983f, -0.02087753f, -0.04378321f, 0.04653238f, 0.00839613f, 
    0.05664616f, 0.04176924f, 0.05544325f, -0.01838249f, 0.05759937f, -0.04809671f, -0.07660536f, -0.05194131f, 
    0.03596297f, 0.03451059f, -0.07071117f, 0.01826530f, 0.02427508f, -0.04678919f, 0.01362895f, -0.02092346f, 
    0.00646987f, 0.06091763f, 0.02634043f, -0.00011496f, -0.01256789f, 0.00673689f, 0.05888980f, -0.04595296f, 
    0.00091116f, 0.01360185f, 0.04819412f, -0.01781921f, 0.06679160f, -0.00118003f, -0.00026673f, 0.00230232f, 
    -0.05686286f, -0.01888988f, 0.04769711f, -0.04423848f, 0.06132985f, 0.05890209f, -0.04987592f, -0.05550212f, 
    -0.02467999f, 0.06165133f, 0.02587575f, -0.06151639f, 0.02927320f, 0.00438883f, -0.01744187f, -0.01569215f, 
    -0.03640659f, 0.03711572f, -0.04956479f, -0.07522933f, -0.02165095f, 0.04695472f, 0.01388370f, -0.04226875f, 
    -0.03083242f, 0.05516390f, -0.06046715f, -0.03469423f, 0.04871353f, 0.03709871f, -0.03162411f, -0.00200297f, 
    -0.05030704f, 0.02833340f, -0.05259557f, -0.05866412f, 0.06511100f, -0.07730202f, 0.04018039f, 0.04300141f, 
    -0.06194747f, 0.04661120f, 0.01964922f, 0.05571302f, 0.04634985f, 0.00525417f, -0.04348146f, -0.01002730f, 
    0.01441864f, -0.03743511f, 0.05074976f, 0.04454341f, -0.04926017f, -0.03037460f, 0.03996111f, -0.02967023f, 
    0.01081179f, -0.04262527f, 0.03232970f, 0.02434578f, 0.00320475f, 0.01519506f, -0.08300313f, -0.04713541f, 
    -0.36232963f, 0.06483844f, -0.12991208f, 0.18244298f, 0.16747023f, 0.03286164f, 0.03641208f, 0.03659027f, 
    0.03395176f, 0.05637864f, -0.07123050f, 0.10989070f, -0.08231842f, 0.32069430f, 0.20801039f, -0.14505747f, 
    0.06195849f, 0.21208964f, -0.09198944f, -0.05333098f, -0.01627302f, -0.02893062f, -0.03626986f, 0.00685260f, 
    0.46460882f, 0.00853667f, -0.05159316f, 0.09097941f, -0.01091879f, -0.05706291f, -0.11054280f, 0.02454959f, 
    0.13152856f, -0.06347477f, 0.14098799f, 0.08008365f, -0.00028960f, 0.03596400f, 0.06680443f, -0.36492160f, 
    0.14899562f, -0.05988118f, -0.08281399f, -0.09681623f, -0.02344417f, 0.14509173f, -0.00139141f, 0.07066512f, 
    0.17851971f, 0.17098734f, 0.06645062f, 0.19776677f, 0.05660729f, -0.03549257f, -0.00900917f, -0.07510425f, 
    -0.04943926f, 0.06416096f, -0.08182781f, 0.08836493f, -0.28400564f, -0.26810107f, -0.02603420f, 0.21599916f, 
    0.17285439f, 0.16936849f, -0.02419442f, 0.02393784f, 0.00413037f, -0.18456452f, -0.00562497f, 0.02660882f, 
    0.09738266f, 0.13052943f, -0.02534644f, 0.15701616f, 0.04235180f, -0.03197488f, 0.02588640f, -0.09306046f, 
    0.01933771f, -0.09332727f, -0.00405989f, 0.07966103f, 0.20142187f, 0.04594041f, -0.20773393f, 0.32198226f, 
    0.08490494f, 0.06679537f, -0.00933418f, -0.03008471f, -0.03959500f, 0.11940376f, 0.12643045f, 0.00752329f, 
    -0.25853211f, 0.15086953f, 0.03598023f, -0.12315360f, -0.00194004f, -0.00995513f, 0.09008896f, -0.04979160f, 
    0.01533206f, 0.05171564f, 0.07169256f, -0.02077412f, -0.10291924f, 0.04382107f, 0.17528430f, -0.42119369f, 
    -0.00490920f, -0.04913238f, 0.09742112f, 0.07027285f, -0.11778545f, -0.07698202f, 0.21811378f, -0.01112439f, 
    0.14457859f, 0.12092219f, -0.26446822f, 0.15446545f, -0.02950233f, -0.07649338f, 0.09134830f, -0.12746365f, 
    0.04666374f, -0.08553192f, -0.09165344f, 0.11997045f, -0.13668969f, 0.04724495f, -0.10818284f, -0.23900123f, 
    0.00600347f, 0.12866899f, 0.01457501f, -0.03020094f, 0.11314321f, -0.04766668f, -0.04416163f, 0.04165820f, 
    0.24865682f, -0.06829596f, -0.04402534f, 0.53452969f, 0.19498849f, 0.02463295f, 0.02708286f, -0.14423408f, 
    -0.05090977f, 0.07422403f, 0.02238959f, 0.12957220f, 0.02714388f, -0.12060238f, 0.19062032f, -0.04858373f, 
    0.13874368f, -0.12196086f, 0.04613328f, -0.02434686f, -0.02414056f, 0.07852390f, 0.06118200f, -0.00580652f, 
    -0.05359222f, -0.05181187f, 0.10139739f, -0.13933040f, 0.17135486f, -0.17778076f, -0.05296284f, 0.02096637f, 
    0.00836181f, -0.03981048f, -0.09276183f, 0.04149255f, -0.19798808f, 0.44870865f, -0.14079848f, 0.35538891f, 
    -0.02005820f, 0.10992558f, -0.19430774f, 0.04280571f, 0.07181093f, 0.05752095f, -0.09679146f, 0.09836520f, 
    -0.24525608f, -0.07729781f, -0.00582209f, 0.15303160f, 0.12699807f, 0.07953763f, -0.04510912f, 0.05160071f, 
    -0.07104105f, -0.00585344f, 0.21270253f, 0.02833588f, 0.18250801f, 0.06521938f, 0.03668213f, -0.04347358f, 
    -0.12562649f, -0.13080673f, 0.10671089f, 0.08504287f, 0.09862020f, -0.00522536f, 0.05318820f, -0.05026149f, 
    -0.34786943f, -0.31153363f, 0.09760024f, -0.17826396f, -0.07209206f, -0.04035892f, -0.09366276f, -0.04421067f, 
    -0.06811344f, 0.10001656f, -0.04488146f, -0.07765269f, -0.16282649f, -0.04447367f, -0.03306696f, -0.05470640f, 
    0.02698113f, -0.05291811f, 0.19286963f, 0.07797491f, -0.02334375f, 0.02502572f, 0.16021137f, 0.17474642f, 
    0.17418738f, 0.29543594f, 0.11034016f, 0.14969514f, -0.31723237f, -0.12818469f, -0.09630134f, 0.09501890f, 
    0.01721237f, -0.13818868f, 0.11968744f, 0.12559108f, 0.00791561f, 0.22064294f, 0.11482919f, -0.10995416f, 
    0.13914733f, -0.02831114f, -0.05259099f, 0.11002860f, 0.00394271f, 0.14796050f, 0.05777931f, -0.11150178f, 
    -0.04492725f, -0.08188244f, -0.04958622f, 0.12617709f, 0.06215418f, -0.07125917f, 0.05122496f, -0.05424029f, 
    0.08845232f, -0.05520149f, -0.09206343f, -0.08479588f, 0.35954168f, -0.13484640f, -0.13520397f, -0.11658937f, 
    -0.02522641f, -0.07931405f, -0.04685322f, -0.03391105f, -0.03197589f, 0.20709635f, 0.12776753f, 0.06513523f, 
    -0.19526105f, 0.12766057f, 0.16620962f, 0.05437104f, -0.02892399f, 0.00364969f, -0.00529147f, 0.14258662f, 
    -0.06709740f, 0.14105028f, -0.14343260f, -0.14242049f, 0.37747470f, 0.29743090f, -0.17939302f, 0.24498615f, 
    -0.08862299f, 0.16419761f, 0.11840568f, 0.12339762f, 0.09930044f, -0.09546646f, -0.24790786f, -0.07137967f, 
    0.21324721f, 0.01602703f, -0.08159756f, 0.24010603f, 0.01782309f, 0.01509857f, 0.13323866f, 0.14104354f, 
    -0.08325011f, 0.11908381f, -0.05840869f, -0.14239596f, 0.16160299f, 0.27555898f, -0.08405626f, -0.13428997f, 
    -0.10545988f, -0.06445753f, -0.07861988f, -0.06975030f, -0.25612253f, 0.22130463f, -0.01020939f, 0.07665700f, 
    -0.13649121f, -0.00339508f, 0.20659249f, -0.00175601f, 0.14862253f, -0.00345653f, -0.04144077f, 0.01606554f, 
    -0.08651552f, -0.06774363f, -0.03696338f, -0.04512721f, 0.19174625f, 0.17697614f, -0.10166150f, -0.05447912f, 
    -0.02245813f, 0.30538404f, 0.07650412f, -0.06665907f, -0.06249465f, -0.05791488f, 0.10812744f, 0.04922067f, 
    0.21949381f, -0.13982116f, 0.11431023f, -0.00035680f, -0.12576075f, 0.13703336f, -0.03637301f, 0.07411386f, 
    -0.00049030f, 0.02711636f, 0.05306327f, -0.21892998f, 0.11963553f, 0.09989098f, 0.28622270f, 0.01460377f, 
    -0.06125921f, -0.09925720f, 0.02344659f, 0.04706286f, -0.23771775f, 0.10684133f, 0.06168201f, -0.06137440f, 
    -0.02537239f, -0.49124783f, 0.07202300f, 0.05464883f, -0.03197012f, -0.16883278f, 0.04880398f, 0.10312667f, 
    0.00280266f, -0.04177736f, 0.00888350f, -0.01713222f, 0.22514966f, 0.19341384f, 0.12871341f, 0.03372804f, 
    -0.01973171f, -0.01329567f, 0.13778833f, 0.15450262f, -0.08918788f, 0.07614698f, 0.04927078f, 0.03809274f, 
    -0.35427019f, 0.00466415f, 0.21617620f, 0.05217779f, -0.00487977f, 0.00725291f, -0.06665154f, -0.04133760f, 
    0.09462492f, 0.06015502f, 0.08220569f, 0.12367027f, 0.50463712f, -0.12368932f, 0.25722548f, -0.28506619f, 
    0.00829714f, 0.06851774f, -0.05748522f, 0.05926828f, 0.04536349f, 0.09349480f, 0.07509691f, 0.04832516f, 
    0.13328014f, -0.08118441f, 0.13280495f, -0.18886128f, 0.03259939f, -0.04910550f, 0.02897558f, 0.06544867f, 
    0.13072196f, -0.01317607f, -0.02939410f, -0.02353398f, 0.17120348f, 0.12361862f, -0.15146901f, 0.18191496f, 
    -0.07194835f, -0.04648694f, 0.23172618f, 0.05814068f, -0.11574509f, 0.09934482f, -0.00538420f, -0.14178661f, 
    0.01779533f, 0.07887908f, -0.01329850f, -0.11516102f, 0.23673610f, 0.03790103f, 0.21503262f, 0.18657607f, 
    0.03915686f, -0.01152428f, -0.07749754f, -0.05358535f, -0.15623112f, 0.04486232f, -0.08941326f, 0.06083278f, 
    0.13411707f, 0.01355596f, 0.11291046f, 0.00263640f, 0.03833393f, -0.03673453f, -0.05291733f, -0.00254978f, 
    0.39159608f, -0.01321923f, -0.13728037f, 0.04135651f, 0.06361156f, 0.14787319f, 0.04632411f, 0.11527090f, 
    0.03638532f, 0.02023050f, -0.07714410f, -0.03149906f, -0.27945244f, -0.23767109f, 0.00411520f, -0.14395230f, 
    0.02386906f, 0.00416073f, -0.09686650f, 0.02022726f, 0.16926230f, 0.00681480f, 0.09320008f, 0.04576562f, 
    -0.17756417f, -0.25472617f, 0.22403748f, 0.06061041f, 0.08049323f, -0.10305256f, 0.08800792f, -0.04694535f, 
    0.13807613f, 0.11531869f, -0.04303169f, 0.10215008f, 0.31432316f, -0.48609528f, 0.00312922f, -0.07319578f, 
    0.04875980f, 0.06143450f, 0.04234838f, -0.04249923f, 0.00837730f, 0.02916608f, 0.15568785f, 0.10438547f, 
    0.08554281f, -0.14987265f, -0.08266916f, 0.12193938f, 0.01246963f, -0.09739354f, 0.09871221f, -0.01968989f, 
    0.14060834f, -0.03629897f, 0.08185273f, -0.19582881f, 0.01354335f, -0.14994048f, -0.11591173f, -0.33035812f, 
    -0.13873428f, 0.19313397f, -0.10896236f, 0.10079379f, 0.02505549f, -0.06711812f, 0.00401224f, -0.07916585f, 
    0.11149071f, 0.13789369f, -0.00174265f, -0.21809679f, -0.06182012f, 0.06854310f, -0.00564323f, 0.07451609f, 
    -0.07253073f, 0.09207422f, -0.04145397f, 0.06150851f, 0.12583739f, -0.38790533f, 0.02547812f, -0.06278459f, 
    0.06723627f, 0.02375157f, 0.18199460f, -0.03895417f, 0.05134718f, -0.20845558f, 0.01216355f, -0.14740632f, 
    -0.06203301f, 0.04877985f, 0.04706982f, 0.00973541f, -0.02205607f, -0.03622869f, -0.03938623f, -0.05813169f, 
    0.02238230f, -0.07431807f, 0.04957006f, 0.05360571f, 0.04432064f, -0.03971928f, -0.02614520f, 0.01648374f, 
    0.00709385f, -0.00338854f, 0.00042760f, 0.04685773f, 0.06285305f, -0.04762116f, -0.01043324f, -0.00909615f, 
    -0.06580690f, 0.03349072f, -0.04588347f, 0.04943769f, -0.00373509f, 0.05195541f, -0.04855129f, 0.03147614f, 
    0.01031598f, 0.05151864f, -0.01456175f, 0.03251978f, 0.05927079f, 0.01772511f, -0.06095274f, -0.01477046f, 
    -0.03679928f, 0.00062723f, -0.01070552f, -0.03861948f, -0.03885372f, -0.00052865f, 0.05007167f, -0.02747686f, 
    -0.05965877f, -0.02148085f, 0.03364963f, 0.01246642f, 0.01827973f, -0.00898147f, 0.03437474f, 0.05920438f, 
    -0.07916498f, -0.03896064f, 0.05192063f, -0.07027043f, 0.01336370f, 0.00028858f, -0.07491145f, -0.00681983f, 
    0.01118727f, -0.00348623f, -0.02430111f, 0.04003203f, 0.01409345f, -0.07807312f, -0.01779554f, -0.01385963f, 
    -0.06474248f, -0.03039159f, 0.05137392f, 0.04201656f, -0.04281806f, -0.06272367f, 0.01447002f, -0.02200370f, 
    -0.04276040f, -0.01129811f, 0.00357997f, 0.02177382f, 0.06268576f, 0.03642958f, 0.03013372f, -0.03009282f, 
    -0.01134234f, -0.07590501f, 0.05739725f, -0.07007009f, 0.02524854f, -0.01925302f, 0.00024669f, 0.00757442f, 
    0.00962668f, 0.04721684f, 0.03492349f, 0.04407981f, -0.01402669f, -0.03635782f, 0.06146324f, -0.06915864f, 
    -0.01326770f, 0.01970654f, 0.00701963f, -0.05323817f, -0.04983176f, 0.00047982f, 0.02272747f, -0.04118917f, 
    -0.06608835f, 0.02656471f, 0.02718730f, -0.06760509f, -0.01166973f, 0.04570011f, -0.06092499f, 0.00657736f, 
    0.02502264f, -0.00096441f, -0.03695698f, -0.06444674f, -0.00768262f, 0.06088554f, -0.05256080f, -0.06274868f, 
    0.04087423f, -0.02492588f, 0.00763011f, 0.01161256f, -0.04414011f, 0.01716461f, -0.02321055f, -0.07620301f, 
    -0.01308121f, -0.05971817f, -0.02077275f, 0.00292263f, 0.04203629f, 0.04613183f, -0.06507031f, -0.02106963f, 
    0.00930950f, 0.04933930f, -0.00055936f, -0.04680939f, 0.03150499f, -0.06450748f, 0.01678248f, 0.00943328f, 
    -0.07702997f, 0.00186378f, -0.03979252f, -0.07866732f, 0.02859567f, -0.05837464f, -0.06485416f, -0.07360594f, 
    -0.05316972f, -0.04504068f, -0.02220166f, -0.04359770f, -0.02927987f, -0.04911899f, -0.06720895f, 0.03033403f, 
    0.05238397f, -0.03913601f, 0.02148525f, -0.03917959f, -0.01443037f, -0.03795131f, 0.05434375f, -0.02905825f, 
    0.00507500f, -0.02486507f, -0.07076307f, -0.05485785f, 0.04530483f, -0.00247196f, -0.01239473f, -0.02237261f, 
    0.02863209f, -0.02528963f, -0.03236984f, -0.03873486f, 0.05040548f, 0.02155274f, 0.01621117f, 0.03668208f, 
    -0.10162691f, 0.13741043f, -0.01037687f, 0.28278789f, 0.02745965f, -0.09384504f, 0.11124377f, -0.04215458f, 
    0.00460069f, -0.14831199f, -0.12282053f, 0.05020339f, 0.57526636f, 0.18365896f, -0.12624367f, 0.17062053f, 
    0.02871597f, -0.14299841f, -0.00732596f, 0.03862097f, -0.09873502f, 0.07813823f, 0.01276251f, -0.09364153f, 
    0.21073294f, -0.01403385f, -0.27887520f, -0.48086327f, -0.06066243f, -0.12512892f, 0.07891994f, 0.12526944f, 
    0.05442354f, -0.07977939f, 0.06841150f, 0.09751309f, 0.16665061f, 0.10120948f, 0.13218732f, 0.10088076f, 
    0.03694504f, -0.13723016f, -0.01058752f, -0.08929093f, -0.05972168f, 0.18516695f, 0.01241335f, -0.10396970f, 
    0.07337373f, 0.32826388f, 0.03967095f, -0.04884503f, 0.05394920f, -0.01237840f, -0.06790342f, -0.01677263f, 
    -0.02929214f, -0.11639374f, -0.15684578f, 0.00791668f, 0.55086058f, 0.34875065f, 0.26646665f, 0.52506351f, 
    0.13151543f, 0.01798521f, 0.16101763f, 0.00291217f, -0.01516041f, -0.02058456f, -0.13413951f, -0.10762655f, 
    0.16391519f, 0.09693523f, 0.18567830f, -0.06528398f, 0.05771273f, -0.03538929f, -0.05443073f, 0.04487348f, 
    0.26635191f, -0.12443662f, 0.07352436f, 0.08317323f, 0.08978394f, 0.15011977f, -0.40812069f, -0.07534825f, 
    0.00306511f, 0.17960379f, 0.14439760f, -0.10723028f, 0.00358951f, 0.04818106f, 0.05315811f, 0.01192046f, 
    -0.10838465f, -0.14708760f, 0.19722642f, -0.16759793f, -0.02676754f, 0.00436054f, 0.01252584f, -0.15226994f, 
    -0.06140944f, 0.07274348f, -0.06661517f, 0.06160728f, 0.08107496f, -0.02710006f, -0.22298953f, 0.10454511f, 
    -0.12744875f, 0.06766845f, -0.09350494f, 0.05534803f, -0.01519825f, -0.04327270f, 0.05783407f, -0.11056478f, 
    -0.03336303f, 0.21612950f, -0.25201717f, 0.12632152f, -0.17391030f, 0.00519580f, -0.02292972f, -0.04444673f, 
    0.07419566f, 0.02143542f, -0.06137534f, 0.06049809f, 0.27004451f, -0.17017639f, 0.20841886f, 0.10759915f, 
    -0.05689372f, -0.05251687f, 0.00654977f, -0.00913191f, -0.00544191f, 0.02457522f, -0.01341038f, 0.05726422f, 
    -0.04311698f, 0.16701609f, 0.26126978f, 0.01943976f, 0.06302201f, -0.07161662f, 0.02724570f, -0.06232920f, 
    -0.16083130f, -0.13569824f, -0.04495301f, -0.04844046f, -0.01767421f, -0.11749931f, -0.02058132f, -0.38060147f, 
    0.15983404f, 0.07006239f, -0.02138411f, -0.08317677f, -0.03290213f, 0.00837865f, 0.03520967f, 0.03817015f, 
    0.50988287f, -0.16412625f, -0.00910838f, 0.27826512f, 0.01470319f, -0.00013878f, 0.05615993f, -0.00384688f, 
    0.06201705f, 0.12792921f, 0.05280852f, -0.10653353f, -0.02233353f, 0.37150744f, 0.10440257f, -0.12236533f, 
    -0.15689880f, -0.12611626f, -0.07400031f, -0.06822697f, 0.01699482f, 0.02103344f, 0.02653914f, 0.07187001f, 
    0.11822601f, 0.32023367f, 0.18109810f, -0.02698303f, 0.12172963f, 0.03722698f, -0.10858290f, 0.03778789f, 
    0.13334642f, -0.03306334f, 0.17498349f, 0.11270865f, -0.21932492f, 0.39301813f, 0.13165972f, -0.19082272f, 
    0.04027917f, 0.06710782f, 0.11373317f, -0.07930052f, -0.02335456f, -0.16142623f, 0.03707273f, 0.01945633f, 
    0.34825405f, 0.27410483f, 0.24109419f, -0.10348507f, -0.09839515f, 0.19619112f, 0.00357490f, -0.10189731f, 
    -0.14621077f, 0.00800641f, 0.09260296f, -0.05076208f, -0.19569671f, 0.07787969f, -0.07711490f, -0.00158876f, 
    0.14261323f, 0.02610013f, -0.07903885f, 0.02646398f, 0.01394618f, 0.13206194f, 0.06687806f, 0.13276431f, 
    -0.37304369f, -0.04083335f, -0.14531860f, 0.27156255f, -0.00153954f, 0.08156014f, -0.08152822f, -0.06738347f, 
    -0.09079795f, 0.11093086f, 0.15928975f, -0.03134701f, 0.02168502f, -0.20325290f, -0.04144045f, -0.11328318f, 
    0.28850067f, 0.05082870f, -0.04615752f, 0.10132284f, -0.01810160f, 0.01927261f, 0.13006604f, 0.02138408f, 
    -0.30058789f, -0.18267335f, 0.12091952f, 0.15386868f, -0.09157628f, -0.03602689f, -0.03818731f, -0.15444988f, 
    0.08411547f, -0.02296305f, -0.21251856f, -0.15735227f, -0.22479357f, 0.00489438f, 0.04851227f, 0.09358225f, 
    -0.05841598f, 0.05561453f, -0.13016297f, 0.09209131f, 0.11113158f, -0.00307064f, 0.06402392f, 0.10017522f, 
    0.37821391f, -0.25907746f, -0.29882231f, 0.14414750f, -0.00603423f, -0.03495827f, 0.02713304f, -0.01725160f, 
    0.08926570f, 0.06963569f, 0.02304902f, -0.15766515f, 0.04971915f, 0.49801168f, 0.11299199f, -0.12906179f, 
    -0.04507731f, 0.16665117f, -0.03280511f, -0.07113470f, -0.17950632f, -0.07788703f, -0.09110042f, 0.11954448f, 
    0.10269607f, 0.24967039f, -0.15524521f, -0.20111978f, -0.02520062f, -0.00091623f, -0.00796903f, 0.07371689f, 
    -0.06898082f, 0.06514146f, -0.01704929f, -0.14026298f, -0.55907160f, 0.50442350f, -0.02784119f, -0.05473005f, 
    0.09720731f, -0.00462432f, -0.05187788f, -0.12828505f, -0.14037976f, 0.02841779f, -0.14644396f, -0.05063997f, 
    -0.00455898f, 0.00070920f, 0.04935065f, -0.09044546f, 0.06231058f, 0.12773123f, -0.09117921f, 0.07912471f, 
    -0.19773522f, 0.01320209f, -0.00995163f, 0.14477269f, 0.32826963f, 0.12248504f, -0.16250564f, 0.38056862f, 
    0.01182780f, -0.07004913f, 0.02208216f, -0.13857895f, -0.08326503f, 0.06482332f, -0.06946750f, 0.05636344f, 
    0.12950997f, 0.05128394f, 0.00813870f, 0.01897321f, 0.08818148f, 0.08058430f, 0.08059979f, -0.09531742f, 
    -0.04356638f, -0.12475460f, 0.12611103f, -0.07059792f, -0.03813494f, 0.13355686f, -0.00308235f, 0.01973865f, 
    0.04091788f, -0.00527886f, 0.04999938f, 0.00972183f, -0.06339667f, 0.11043291f, -0.07222881f, 0.12652570f, 
    -0.04679345f, 0.00545592f, 0.03546558f, -0.01363398f, 0.01380663f, -0.01051290f, -0.06708497f, -0.07920978f, 
    0.01513002f, -0.04920634f, 0.01994821f, -0.03178008f, 0.04941293f, -0.02946801f, -0.00236065f, -0.05414236f, 
    0.05887148f, 0.01191392f, -0.05150940f, -0.04864672f, -0.05516556f, -0.08060063f, -0.05673467f, -0.03298500f, 
    -0.05378871f, 0.01983278f, 0.03032585f, 0.05036651f, -0.04452201f, 0.04796331f, 0.03109340f, 0.04000042f, 
    -0.06516606f, -0.06893130f, 0.00443383f, 0.02286711f, -0.02668567f, -0.02834909f, -0.04593733f, -0.02834418f, 
    0.01225931f, -0.00716630f, 0.00098690f, 0.05338285f, -0.05202846f, -0.06487196f, -0.00801289f, -0.04708346f, 
    -0.00436349f, -0.00807897f, 0.00157495f, -0.04585321f, 0.05372233f, -0.06205677f, 0.02820577f, -0.03182944f, 
    -0.03378078f, -0.02877896f, -0.05875122f, 0.03324325f, -0.05939924f, -0.07355609f, -0.06993204f, -0.03986230f, 
    -0.02697720f, 0.02731864f, -0.03104683f, 0.00044693f, -0.08176450f, 0.00721939f, -0.02967170f, -0.01491288f, 
    0.00618251f, -0.02297054f, 0.03546867f, -0.07190774f, -0.06659974f, -0.07242813f, 0.02712974f, 0.03746063f, 
    -0.01781681f, -0.02451162f, -0.03217535f, -0.01826203f, -0.07108211f, -0.02875094f, 0.03741241f, -0.07734937f, 
    -0.06967248f, -0.00396542f, 0.03197070f, -0.07054216f, -0.01565550f, 0.05033184f, -0.06263068f, 0.04566453f, 
    0.02720833f, 0.02037377f, -0.02536409f, -0.04956503f, 0.04243941f, 0.00258161f, -0.05726077f, 0.00720911f, 
    0.03352524f, 0.04656567f, 0.05275968f, -0.01544063f, 0.02643430f, -0.03437801f, -0.05309055f, -0.07076492f, 
    0.00897260f, 0.05473879f, 0.00036769f, -0.03482080f, -0.06553547f, -0.05709674f, -0.04752668f, 0.00998936f, 
    0.00423686f, -0.08083758f, -0.05580562f, 0.06842693f, -0.02403409f, -0.00879764f, -0.01053704f, -0.04442246f, 
    -0.06914306f, 0.05718382f, 0.02969843f, -0.03053616f, 0.04220764f, -0.04043129f, -0.07407404f, -0.06293720f, 
    -0.02399450f, -0.00496140f, -0.04834154f, -0.04685813f, 0.00850107f, -0.00635635f, -0.01202067f, 0.01307885f, 
    0.02748098f, 0.00605753f, 0.03425999f, -0.00817209f, 0.03794230f, 0.04819113f, -0.01910763f, 0.01898013f, 
    0.00263310f, 0.03980474f, -0.05407374f, -0.06096959f, 0.04350047f, 0.03725407f, -0.00076544f, -0.03964173f, 
    -0.03909167f, 0.00368667f, -0.06758368f, 0.03078992f, 0.02909333f, -0.03667347f, 0.04511214f, -0.06666961f, 
    0.04141190f, 0.00870163f, 0.00789088f, -0.02746998f, -0.06467542f, 0.02744880f, -0.00119601f, -0.01869877f, 
    0.02465220f, -0.07819130f, -0.06519852f, 0.02758481f, 0.03051356f, -0.05735418f, -0.05862276f, -0.04273667f, 
    -0.00878040f, -0.05382752f, -0.05540402f, -0.00390722f, 0.03920567f, -0.06385534f, -0.06570797f, -0.01954523f, 
    0.48852617f, -0.03613096f, 0.10512205f, -0.13946196f, 0.00180123f, 0.10549683f, -0.04338749f, -0.04059418f, 
    0.06854326f, 0.08723526f, -0.04481531f, 0.00591986f, -0.03144423f, 0.02096918f, -0.04998231f, -0.07505390f, 
    0.02296708f, 0.04490394f, -0.18562098f, -0.06627589f, 0.02566203f, -0.02906038f, -0.21184410f, 0.12778093f, 
    0.42146540f, 0.00952950f, 0.05816368f, -0.09267785f, 0.11923851f, 0.00460814f, -0.04085702f, 0.00207229f, 
    0.19730987f, 0.02120275f, 0.11385897f, 0.07731979f, -0.16532572f, -0.01440786f, 0.04055354f, -0.04222090f, 
    -0.04172656f, 0.00711022f, -0.03258728f, -0.05686858f, -0.08602778f, -0.09400252f, -0.17729031f, -0.12825342f, 
    0.45226198f, 0.08750089f, 0.25940242f, 0.05169920f, 0.05272057f, 0.08263932f, -0.02345936f, -0.07089054f, 
    -0.06651016f, 0.05868429f, -0.11770041f, -0.09248963f, -0.46996307f, 0.07611944f, 0.00946422f, 0.11218672f, 
    0.10115616f, 0.10177715f, -0.05154592f, -0.13821052f, -0.00447907f, -0.14141627f, -0.04846549f, -0.15482621f, 
    0.34451237f, 0.12280666f, -0.13372186f, 0.16500264f, 0.00750555f, -0.02443216f, 0.02527265f, 0.08704548f, 
    0.02274912f, 0.14988241f, -0.02720479f, 0.09900595f, 0.01210466f, 0.07234165f, 0.13714522f, 0.11038170f, 
    0.06415519f, 0.09348665f, 0.05381114f, -0.00143119f, -0.01061286f, -0.09574914f, 0.07615499f, -0.06860074f, 
    -0.03302756f, 0.20372301f, 0.02962762f, -0.12562750f, -0.01617882f, 0.04825202f, 0.05508922f, 0.09977512f, 
    -0.18582690f, 0.05583860f, 0.06394246f, 0.00515858f, -0.02448534f, -0.16662884f, 0.10773474f, -0.09593222f, 
    0.17860009f, -0.02218641f, -0.03832483f, 0.05623010f, -0.08975998f, 0.00087500f, 0.19722524f, 0.17887233f, 
    0.22334407f, -0.02927648f, -0.01743869f, 0.20525974f, -0.04860303f, -0.20073032f, 0.02006700f, -0.13861087f, 
    -0.06077327f, -0.09264220f, 0.12267264f, 0.12979792f, -0.19968271f, 0.03305926f, -0.03013563f, -0.06304885f, 
    0.04857354f, 0.07847032f, 0.12288864f, 0.11919965f, 0.05137217f, -0.06373866f, 0.03808246f, 0.00662872f, 
    0.30426109f, 0.06968334f, -0.15830354f, 0.16936997f, -0.09998383f, -0.00408541f, -0.08830099f, 0.05314943f, 
    0.02148028f, 0.00617586f, 0.05972794f, -0.02328506f, -0.38640022f, -0.11731232f, 0.08518493f, 0.10064413f, 
    -0.01072301f, -0.01946426f, -0.06293582f, -0.08846546f, -0.09777586f, 0.02981923f, -0.02234112f, -0.08983373f, 
    -0.17323332f, 0.05533464f, -0.05486979f, -0.25416201f, 0.01736252f, -0.02385218f, -0.04584625f, 0.03377460f, 
    0.19606635f, -0.12692560f, -0.12600717f, 0.17087695f, 0.29803041f, 0.00980671f, 0.06007874f, 0.02532007f, 
    0.12751202f, -0.01266131f, -0.04848474f, 0.01808146f, 0.09528031f, -0.00892333f, 0.11565902f, -0.07152785f, 
    -0.04641146f, -0.02227364f, -0.04284482f, -0.05016049f, -0.01393053f, 0.00787640f, -0.07556567f, -0.03603897f, 
    0.04388307f, 0.00382067f, -0.07517301f, -0.06924455f, 0.06311455f, 0.06297784f, -0.07661388f, -0.03840537f, 
    0.02126590f, 0.02985957f, 0.02940091f, 0.03258298f, -0.08023556f, 0.03307758f, -0.01648192f, -0.02215792f, 
    0.01863063f, -0.02650937f, -0.07184128f, -0.07500992f, -0.07483644f, -0.01847588f, 0.06107178f, -0.00485713f, 
    0.02225821f, -0.05707487f, -0.02034422f, 0.00255521f, 0.04057570f, -0.04255096f, -0.03577257f, -0.04143716f, 
    0.03216088f, -0.01621188f, -0.02991169f, 0.06669877f, 0.02813960f, 0.03248716f, -0.01810433f, 0.02777270f, 
    -0.04965719f, -0.06866830f, -0.08181261f, 0.01497078f, -0.07410353f, 0.02666054f, 0.04983541f, -0.04316826f, 
    0.06023509f, -0.07655516f, 0.02357828f, 0.02828254f, 0.01348494f, 0.04926670f, -0.05307454f, -0.07239689f, 
    0.01717491f, 0.03880370f, -0.07450885f, 0.01211192f, 0.04160602f, -0.07746257f, -0.03772054f, -0.02304612f, 
    0.04728848f, -0.04139724f, -0.06699526f, -0.02819739f, -0.01080234f, 0.05036163f, 0.05594719f, 0.05624818f, 
    -0.01735518f, 0.05063374f, 0.01715226f, -0.06224039f, -0.07212046f, 0.05825411f, -0.03032176f, 0.00594126f, 
    -0.00985288f, 0.04577545f, -0.05345018f, -0.06273568f, 0.03274991f, 0.00563479f, 0.06253043f, -0.06540593f, 
    -0.05449131f, -0.04155473f, -0.03580789f, 0.01522977f, 0.03565647f, -0.03539158f, -0.00982219f, 0.06679270f, 
    0.03546279f, -0.07387462f, 0.02503452f, 0.00403333f, -0.05860595f, 0.02248572f, 0.03669396f, -0.04483329f, 
    -0.07151087f, 0.00345470f, 0.05473577f, 0.01576402f, 0.03975608f, -0.00478975f, -0.02239463f, 0.01655163f, 
    -0.07584874f, -0.04443314f, 0.02057018f, -0.04803510f, -0.00120140f, -0.05455272f, 0.00218638f, 0.02089866f, 
    -0.08216035f, 0.05654524f, -0.00370011f, 0.03744875f, 0.03410638f, -0.02016522f, -0.04185102f, 0.02957000f, 
    -0.02738432f, -0.00849028f, -0.04454517f, -0.02937593f, 0.05593957f, -0.04978989f, -0.00509358f, -0.00384879f, 
    -0.06828956f, -0.05056987f, 0.05247824f, -0.00525370f, -0.07140689f, -0.01885826f, -0.03551865f, 0.01306768f, 
    -0.02239203f, 0.04972630f, 0.06104420f, 0.00005843f, 0.04039923f, -0.00259851f, -0.04421393f, 0.03343593f, 
    0.05353699f, 0.01565782f, -0.00427918f, -0.00447179f, 0.04322380f, -0.03731743f, -0.05535868f, -0.02351199f, 
    -0.05762879f, -0.05532076f, -0.03757865f, -0.07605202f, -0.00920348f, 0.04523752f, -0.06192647f, 0.05976714f, 
    0.05432293f, 0.01040622f, -0.05555948f, 0.03307479f, -0.05971611f, 0.05120152f, 0.03027611f, -0.01396378f, 
    0.02625008f, -0.01796006f, 0.02574367f, -0.04423770f, 0.03246092f, 0.00195222f, 0.05535452f, 0.05961253f, 
    0.00655867f, -0.01396142f, -0.03117085f, 0.02401434f, -0.03866077f, 0.00693901f, -0.03462145f, -0.03856686f, 
    0.06429220f, 0.01709810f, -0.03411462f, 0.00165636f, 0.06236161f, -0.05807342f, -0.06083709f, -0.03001669f, 
    0.05891202f, -0.03920285f, -0.04145278f, -0.05401493f, -0.05181757f, -0.07698506f, 0.02065061f, 0.06448243f, 
    -0.03523891f, 0.01237548f, 0.00319577f, -0.05728564f, 0.04685832f, 0.06522558f, -0.07344545f, -0.04173869f, 
    0.04770113f, -0.07600380f, -0.01131319f, 0.03013334f, 0.04450245f, 0.03424745f, 0.04330235f, 0.00299437f, 
    -0.01184689f, -0.03206396f, 0.01592931f, -0.06275921f, -0.02769528f, 0.00530768f, -0.01808048f, -0.07554871f, 
    -0.06012245f, 0.04284340f, -0.07431026f, -0.02867805f, -0.06405790f, 0.03740816f, -0.05671404f, 0.01746734f, 
    -0.05980131f, 0.01533433f, -0.00235495f, 0.01952118f, 0.03518073f, 0.03752308f, -0.04366878f, -0.06904293f, 
    0.03309431f, -0.00191445f, -0.06288962f, -0.02776633f, 0.05042800f, -0.05318304f, 0.04079259f, 0.02310259f, 
    -0.02238732f, -0.03903691f, -0.02887060f, 0.06374770f, -0.04625093f, 0.05116513f, -0.05518701f, 0.01346972f, 
    -0.04007199f, 0.05580240f, -0.04837421f, -0.04529976f, -0.06866597f, -0.03382372f, -0.05794935f, 0.01689285f, 
    -0.06035875f, 0.02880457f, -0.04495331f, -0.04847017f, -0.03060959f, -0.04310950f, -0.03476670f, 0.04471959f, 
    0.05267815f, 0.03411856f, -0.01791050f, -0.04428924f, -0.04536606f, 0.06073537f, -0.06390135f, 0.02299552f, 
    -0.04599167f, -0.05639736f, 0.00802237f, 0.01561998f, -0.07483903f, 0.02077672f, 0.04061361f, 0.02089499f, 
    -0.03714390f, -0.03543450f, -0.00141551f, -0.02509096f, -0.04523563f, 0.05993207f, -0.02087286f, 0.05555884f, 
    -0.00690770f, 0.06357320f, -0.04517579f, 0.00971440f, 0.06213484f, -0.01191053f, -0.03076985f, -0.03188911f, 
    0.05956744f, 0.02347166f, -0.06692246f, -0.03622016f, -0.07532518f, -0.04824679f, 0.02359048f, -0.07623085f, 
    -0.01298080f, 0.04785303f, 0.00479524f, -0.07559211f, 0.03729453f, -0.03485329f, 0.02593773f, 0.05032028f, 
    -0.03662144f, 0.00494340f, 0.00288164f, -0.03993411f, 0.01767834f, -0.06527127f, 0.05265953f, -0.04638977f, 
    0.01202644f, 0.05157303f, -0.03056376f, 0.02675778f, -0.05633552f, -0.03132905f, 0.00622967f, -0.01608249f, 
    0.05005260f, -0.02297106f, -0.07615933f, 0.04012189f, -0.07443140f, 0.00203746f, -0.06279196f, -0.04116950f, 
    -0.03138614f, 0.06323853f, 0.01368680f, -0.07365126f, -0.05584757f, 0.03409315f, -0.04139108f, 0.06282385f, 
    0.04725693f, 0.05306142f, 0.02007913f, 0.03554836f, 0.06210100f, -0.07268675f, -0.02671112f, -0.02774738f, 
    -0.07746620f, 0.02014781f, 0.02833770f, -0.04162546f, 0.01833705f, -0.01616180f, -0.01118345f, -0.03721596f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01378458f, 0.01004581f, 0.03825109f, -0.00382582f, 0.14621134f, -0.02513578f, 0.07184765f, -0.01224711f, 
    0.10269395f, 0.06346752f, -0.04734474f, 0.14020050f, -0.06371702f, 0.14638650f, 0.11614384f, -0.04789590f, 
    -0.04925773f, 0.02042317f, 0.08188522f, 0.08382099f, -0.01548144f, 0.11942684f, 0.00802881f, -0.04792150f, 
    -0.05740660f, -0.00746017f, -0.05320974f, 0.13935710f, -0.13896987f, -0.04583254f, -0.00859144f, 0.02780525f, 
    0.07037067f, -0.08102462f, -0.02191862f, 0.03292640f, -0.07079561f, 0.03228988f, 0.13606049f, -0.01300339f, 
    0.00991470f, 0.07531023f, 0.00385598f, -0.07283264f, 0.08301811f, 0.00502527f, 0.13440500f, -0.00429148f, 
    0.02157770f, 0.01897548f, 0.05947247f, -0.08234708f, 0.02811656f, -0.06688948f, 0.06901982f, -0.03525707f, 
    0.15079148f, -0.06030896f, -0.06318471f, -0.14016052f, -0.05001287f, -0.00098633f, -0.04950833f, 0.02885401f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.65050501f, -0.06785570f, 0.07444241f, 0.17123602f, -0.31009680f, 0.01225996f, 0.29702210f, -0.02885495f, 
    -0.32533282f, -0.22406484f, -0.03888280f, -0.42249355f, -0.05414329f, -0.25153437f, 0.02963494f, 0.08166406f, 
    -0.07813611f, -0.70028955f, 0.01220778f, 0.04321010f, -0.08663929f, -0.56852663f, 0.08369483f, 0.09302934f, 
    0.06286811f, 0.06755261f, -0.06787717f, -0.25051951f, 0.08493691f, 0.26600629f, 0.11728354f, -0.30107307f, 
    -0.06440783f, 0.04062548f, 0.03205058f, 0.33933422f, 0.09082617f, -0.25244975f, -0.09805281f, -0.02068795f, 
    0.22215520f, 0.10743947f, -0.02092190f, 0.03350129f, 0.13740803f, 0.06859185f, 0.04332380f, 0.12663017f, 
    0.23463981f, -0.47260755f, 0.29505944f, 0.24796095f, 0.10688438f, 0.06617026f, -0.52607906f, 0.07094034f, 
    -0.13289124f, -0.07651316f, 0.12703422f, 0.03196430f, -0.07037956f, -0.22346444f, 0.12395112f, 0.04384878f, 
    -0.19738109f, -0.23807283f, -0.02938619f, 0.11215397f, -0.49405456f, -0.08432885f, 0.04383441f, -0.10311135f, 
    -0.16194558f, 0.24337196f, -0.07203471f, -0.14121005f, 0.00478484f, 0.11279076f, 0.31548667f, -0.09507267f, 
    -0.31558934f, 0.07611357f, 0.20211561f, -0.40477112f, 0.16601007f, 0.35388735f, -0.30774865f, -0.10241315f, 
    -0.12014744f, 0.02353393f, 0.06716881f, -0.26268098f, 0.17592748f, -0.40310439f, -0.10278132f, 0.18139796f, 
    0.00595494f, -0.05451961f, -0.01193789f, -0.13129665f, 0.10646867f, 0.10515066f, -0.66284978f, -0.52736163f, 
    0.25631201f, 0.09562360f, -0.11209542f, 0.36528715f, 0.27019131f, 0.06926206f, 0.03410035f, 0.11296832f, 
    -0.20281734f, -0.43520984f, 0.16831142f, -0.45658755f, 0.21762723f, 0.10862793f, -0.23058315f, 0.03952925f, 
    0.20329548f, -0.00820665f, -0.11688014f, -0.11014523f, 0.10300306f, 0.19709700f, 0.11283182f, 0.03613285f, 
    0.28579614f, -0.09132217f, 0.07598882f, 0.00988538f, 0.17180660f, -0.10642544f, -0.81752771f, -0.09736100f, 
    0.03055529f, 0.15089281f, -0.05595679f, 0.36371997f, 0.04506455f, -0.51327813f, 0.08278493f, -0.11139940f, 
    0.24765414f, 0.20561229f, -0.27707660f, 0.01845855f, 0.38216150f, 0.20008390f, -0.60974109f, 0.05447984f, 
    -0.05372328f, 0.09529381f, 0.01415700f, -0.04590565f, -0.15418205f, -0.32061392f, 0.31371513f, -0.08251593f, 
    0.27542412f, -0.01554745f, -0.02919175f, -0.33967265f, -0.07105819f, 0.07623170f, -0.49450338f, 0.22357638f, 
    -0.21143892f, 0.28318408f, -0.11334565f, -0.41985795f, -0.41608143f, 0.00748279f, -0.35085902f, 0.35506073f, 
    -0.12044097f, -0.15100189f, 0.26591370f, 0.03902700f, 0.13827778f, 0.00429600f, -0.26228282f, -0.01538137f, 
    0.32334775f, -0.04706170f, 0.29050916f, 0.09811780f, 0.07204360f, -0.62269706f, -0.06109207f, 0.00133651f, 
    0.20164268f, -0.03012701f, -0.09237655f, 0.13914974f, -0.07627145f, 0.02803428f, 0.09062225f, 0.04364855f, 
    0.23445575f, -0.44775739f, 0.11831847f, 0.30433643f, 0.01638577f, -0.07450105f, -0.51415026f, 0.05395931f, 
    0.34809104f, 0.03399337f, 0.23903121f, -0.01550173f, 0.32784075f, -0.13940781f, 0.23042870f, 0.03955476f, 
    0.07118693f, 0.04026763f, 0.04643344f, 0.38096195f, -0.29637673f, -0.01910275f, -0.19899701f, 0.24782324f, 
    -0.17259388f, -0.02206595f, -0.03617425f, -0.42354503f, -0.00176569f, 0.06010797f, 0.21397750f, -0.19892377f, 
    0.19924119f, -0.14680886f, -0.01431798f, 0.19752304f, 0.34927770f, -0.08909974f, -0.94846988f, 0.04898432f, 
    -0.01496093f, -0.15021026f, 0.10950848f, -0.00158859f, -0.22883488f, 0.06954916f, -0.06408674f, 0.22327267f, 
    -0.47196704f, -0.11291276f, -0.23879802f, -0.23441939f, 0.01382254f, -0.09362930f, 0.09181209f, 0.05073395f, 
    -0.52135187f, 0.15487957f, -0.00043961f, 0.07997736f, 0.08700149f, -0.06032562f, 0.01578712f, -0.03301438f, 
    -0.21355379f, -0.04004627f, 0.09604600f, -0.25028798f, 0.07429726f, -0.27662399f, -0.05369722f, -0.02166888f, 
    0.18609403f, -0.02045981f, 0.00479474f, -0.74705911f, 0.16150092f, 0.63635612f, 0.23144768f, -0.09733968f, 
    0.02123970f, -0.09548523f, 0.05837468f, -0.04048051f, 0.04550129f, 0.22561674f, 0.01470076f, 0.13712174f, 
    -0.23499021f, 0.03273244f, -0.00424221f, 0.07994501f, 0.09878155f, -0.17937636f, 0.25403863f, -0.37319142f, 
    0.15520866f, 0.21149713f, -0.04262885f, -0.09211195f, -0.27919570f, -0.10606176f, -0.15373297f, -0.22600473f, 
    0.35018548f, -0.01524872f, -0.38468394f, 0.36503261f, -0.00192285f, -0.00240861f, 0.09598450f, 0.24852365f, 
    0.07818403f, -0.05713471f, 0.25889161f, -0.20018123f, 0.07807337f, -0.26732516f, 0.00665321f, -0.12487334f, 
    -0.11663778f, 0.15778176f, 0.04802456f, -0.01375807f, -0.45533216f, 0.04787251f, 0.23951152f, -0.32717222f, 
    0.26768479f, 0.02827889f, -0.09764677f, 0.01341468f, 0.01766991f, 0.16829702f, 0.06152996f, 0.00018864f, 
    -0.43080997f, -0.74425465f, -0.15992099f, 0.73693651f, -0.44214004f, 0.13147119f, 0.17849901f, 0.00928709f, 
    0.03103792f, 0.08562700f, -0.05172848f, -0.30883002f, 0.10131945f, -0.47134402f, -0.05921720f, -0.70482391f, 
    0.06225906f, -0.02757218f, -0.11800287f, -0.08512724f, -0.01284296f, 0.19640417f, 0.18053123f, 0.03870627f, 
    0.00099077f, -0.09894678f, 0.02385314f, 0.06903008f, -0.14010720f, -0.02875372f, -0.07873230f, -0.28497487f, 
    0.16811678f, 0.22491078f, 0.20889916f, 0.27627006f, 0.18812153f, 0.00935022f, 0.26888272f, -0.22674118f, 
    -0.04896391f, -0.11394483f, -0.13342118f, -0.06860901f, -0.07655421f, 0.22859308f, -0.06640693f, -0.01468582f, 
    -0.25109366f, 0.14998205f, -0.07146408f, -0.10657047f, 0.36747384f, 0.08285138f, -0.35858524f, 0.27795100f, 
    -0.84527314f, -0.38839296f, 0.00011467f, -0.50862318f, 0.08973147f, 0.07766058f, 0.01077716f, -0.02403214f, 
    -0.16991891f, 0.27431872f, 0.35495728f, -0.76245755f, -0.13348591f, -0.34874853f, -0.17921011f, -0.09815239f, 
    -0.10879223f, -0.09484333f, -0.10127225f, -0.22670452f, 0.20738068f, 0.07795651f, 0.10998267f, -0.40795845f, 
    0.13242969f, 0.01266852f, -0.05555319f, -0.30517069f, -0.04753819f, 0.26057318f, 0.20995879f, 0.45200318f, 
    -0.30665696f, 0.10645391f, -0.07324309f, 0.10803213f, -0.31639919f, -0.11331236f, 0.18783635f, -0.63328630f, 
    -0.08264367f, 0.15920891f, -0.16259588f, -0.40989199f, 0.10596056f, -0.07477378f, 0.07173646f, -0.04032377f, 
    0.28531438f, 0.04132798f, -0.42319134f, 0.12389298f, 0.06480008f, -0.30951896f, 0.05060604f, 0.06913019f, 
    0.25102910f, -0.23702812f, -0.05988934f, -0.04899326f, 0.02303187f, 0.01177061f, 0.11941624f, 0.14560874f, 
    0.29112849f, -0.22804677f, -0.05195136f, -0.19756316f, -0.07811054f, 0.11552301f, -0.26650828f, -0.13262925f, 
    -0.17561439f, 0.28350234f, -0.64515269f, -0.13648312f, -0.04697892f, -0.21787889f, 0.07090687f, 0.09186157f, 
    0.02825098f, 0.10026852f, -0.06652634f, -0.31838256f, 0.24778728f, -0.22413178f, 0.25366125f, 0.05134044f, 
    -0.32458261f, -0.01119058f, 0.04489414f, -0.29820940f, -0.00306753f, -0.43440127f, 0.00753395f, 0.19559999f, 
    0.16585435f, -0.28146395f, -0.13165563f, -0.19597800f, -0.24716477f, 0.06304848f, -0.28200474f, 0.13399827f, 
    -0.39156297f, 0.34523252f, -0.27438635f, 0.28317404f, -0.38243192f, -0.09459747f, 0.17879942f, 0.21359462f, 
    -0.21913838f, -0.05995937f, 0.33127931f, 0.06705806f, -0.02142619f, 0.16111198f, -0.00977454f, 0.07889786f, 
    -0.25054455f, -0.55444914f, 0.07156980f, 0.01898478f, -0.37104505f, -0.09603920f, -0.30196580f, -0.56570655f, 
    -0.15090835f, 0.15468854f, 0.01576039f, 0.32602414f, -0.03388140f, 0.09065510f, 0.02930360f, 0.09467491f, 
    0.38529357f, -0.30927995f, -0.41723990f, -0.31166720f, -0.32922512f, 0.05037249f, -0.07416983f, 0.02289326f, 
    0.09113432f, -0.07365232f, -0.05928221f, -0.01241076f, -0.14045157f, 0.33488357f, -0.33679345f, -0.27668339f, 
    0.25667083f, -0.01656991f, -0.01139318f, 0.09178399f, -0.10114026f, 0.16416834f, -0.32848060f, -0.04872939f, 
    0.31385052f, 0.21166262f, -0.08100471f, 0.30841494f, -0.05518146f, -0.08395244f, 0.39323109f, -0.32203865f, 
    -0.40317082f, 0.00219397f, -0.38721630f, 0.07752508f, 0.23300433f, 0.01746074f, 0.10889325f, -0.59324247f, 
    -0.52326274f, -0.09235951f, 0.37599668f, -0.13644114f, 0.01571928f, -0.11189173f, 0.03906400f, 0.10812200f, 
    -0.21317588f, 0.27158830f, -0.11515004f, 0.15513095f, -0.25202838f, 0.04410022f, -0.25783026f, -0.01507337f, 
    0.31444418f, 0.14462815f, 0.06246567f, -0.02249323f, 0.02241395f, -0.23990026f, 0.16434106f, 0.09808538f, 
    0.10617467f, 0.29641110f, -0.10595981f, 0.12836289f, -0.30664256f, -0.22061792f, -0.06169815f, 0.07682139f, 
    -0.01616481f, 0.09634483f, 0.03754756f, 0.18280177f, 0.19958815f, -0.10352545f, 0.19706051f, 0.02983160f, 
    0.09279701f, 0.05509793f, -0.04012715f, 0.31098002f, 0.08724905f, -0.22901842f, 0.16784576f, -0.24526897f, 
    -0.78536975f, -0.38676026f, -0.10077843f, -0.00332007f, -0.69932026f, -0.05917250f, 0.34210870f, 0.49241185f, 
    0.12144575f, -0.12517601f, -0.20587055f, -0.04881373f, -0.09474421f, -0.00111315f, 0.17068492f, 0.04851301f, 
    -0.50665444f, 0.09456107f, -0.45785132f, 0.50244099f, -0.06967479f, 0.02069149f, -0.04034792f, 0.04577344f, 
    -0.14945938f, -0.34282976f, -0.02906414f, 0.35422802f, 0.47477174f, 0.03547403f, 0.02043828f, 0.03654489f, 
    0.36322895f, 0.18443908f, -0.00413582f, 0.19348180f, 0.08669933f, 0.38899463f, 0.24051851f, 0.01924370f, 
    -0.14468750f, -0.11480732f, -0.33260617f, -0.01572256f, -0.19642834f, 0.21025851f, 0.26732284f, -0.12057238f, 
    -0.05356660f, -0.12650101f, -0.11355632f, 0.15423991f, -0.62995142f, -0.16176809f, 0.09748381f, 0.21025191f, 
    0.06769888f, 0.09787814f, 0.04316298f, -0.23530942f, -0.04521185f, -0.33490291f, 0.12000345f, 0.14545897f, 
    -0.10905292f, 0.15130009f, 0.06229145f, -0.41537851f, -0.04375141f, -0.10730489f, -0.09391043f, -0.57741910f, 
    -0.06309033f, 0.08297195f, 0.08729146f, -0.29385239f, -0.30227324f, 0.10622779f, -0.16621180f, -0.22899702f, 
    0.29906163f, 0.04169016f, -0.38510552f, -0.68232393f, 0.08963708f, 0.17695190f, -0.02661560f, 0.06166610f, 
    -0.34598336f, 0.04372888f, -0.12097892f, -0.75090367f, 0.05302958f, -0.05376079f, 0.17639062f, -0.12934344f, 
    -0.62560242f, 0.22041215f, -0.06987917f, 0.05975530f, -0.04629911f, -0.17718448f, 0.04978742f, -0.12251373f, 
    0.21617869f, 0.36419657f, -0.11372042f, -0.14313671f, 0.25977710f, -0.56207234f, -0.22674407f, 0.03165105f, 
    0.03423608f, 0.10559064f, -0.09386512f, 0.34180149f, -0.11835659f, 0.00853108f, -0.53166258f, 0.07968013f, 
    -0.15970300f, -0.05175527f, 0.01083435f, 0.37238005f, -0.02338183f, 0.07029668f, 0.18624847f, 0.29967725f, 
    -0.18839832f, 0.08389489f, 0.03317820f, -0.24944095f, 0.19601260f, 0.02423055f, 0.06141685f, -0.02911931f, 
    -0.39212501f, -0.02933986f, 0.14577983f, -0.49598429f, -0.19235247f, 0.04183855f, 0.35539207f, 0.00288662f, 
    0.20485722f, -0.01585148f, 0.14023390f, -0.22695369f, -0.00269963f, 0.21162042f, -0.12031991f, -0.06350010f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11333388f, 0.01850433f, -0.06712674f, -0.10147630f, 0.08595534f, -0.08269855f, 0.08631586f, -0.20374151f, 
    -0.15273330f, -0.02564039f, 0.09644607f, 0.00249034f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
