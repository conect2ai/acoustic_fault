#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.44509175f, -0.74623400f, -0.68744457f, 0.15079056f, -0.20615673f, -0.87449294f, 0.73834074f, -0.05631733f, 
    -0.17763944f, -0.30049977f, -0.29136288f, -0.42956546f, -0.22458628f, 0.46914744f, -0.09771866f, 0.69174343f, 
    -0.14982925f, 0.82814187f, 0.71460038f, 0.78655398f, -0.44033355f, -0.06379480f, 0.19619416f, -0.20268965f, 
    -0.27910918f, 1.02540982f, -0.64055955f, -0.39110035f, 0.18504728f, 0.15919630f, 1.07915950f, -0.31984448f, 
    -0.65098518f, -0.09959564f, 0.32938212f, -0.38808870f, 0.49967691f, 0.54832846f, 0.51591551f, 0.42961472f, 
    0.46732849f, 0.20422988f, 0.39498824f, -0.57232553f, -0.21238004f, -0.44428194f, -0.70964414f, -0.54915524f, 
    0.74735773f, 0.65592194f, 0.46424124f, -0.49509728f, 0.02681328f, -0.32209143f, -0.86422420f, -0.52155274f, 
    1.27210617f, 0.68692327f, -0.09278779f, -0.00500174f, -0.06317955f, -0.62522250f, -0.11209916f, -0.56260902f, 
    0.05816938f, 0.47296166f, -0.30184028f, -0.82549566f, -0.79488701f, 0.28724644f, 0.50196129f, 0.28487271f, 
    0.77139539f, -0.27471039f, 0.36898535f, -0.06191498f, 0.14339523f, -0.25103500f, 0.26741165f, 0.50187665f, 
    0.64765060f, 0.75256091f, 0.91135126f, 0.55911422f, -0.11097528f, 0.09740923f, 0.24519353f, -0.02166738f, 
    -0.47611794f, -0.39162335f, -0.30926239f, -0.07298645f, -0.43935207f, 0.47387737f, -0.43350565f, -0.76312274f, 
    0.06308144f, -0.56755942f, 0.57680827f, -0.97218645f, 0.95327812f, -0.11757217f, -0.67503506f, -0.07046989f, 
    0.91393512f, -0.18738070f, 0.10285177f, 0.19464476f, -0.34976447f, -0.51135451f, -0.18441172f, -0.79876214f, 
    -0.59716552f, -0.25376719f, 0.05299009f, -0.66903383f, -0.28863958f, -0.46451133f, -0.68275678f, -0.45658970f, 
    0.19604076f, -0.59578311f, 0.78908718f, 0.32668975f, -0.26530263f, -0.37924927f, 0.88441819f, -0.18735875f, 
    0.35591847f, -0.81898510f, 0.20272073f, 0.52960992f, 0.00025025f, -0.10975356f, -0.15394273f, 0.73478478f, 
    0.68645173f, 0.26386377f, 0.24689588f, -0.82419592f, -0.62232685f, -0.11648885f, 0.10696159f, 0.20064469f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.43363455f, 0.20532267f, 0.06543422f, -0.04750312f, 0.22268875f, -0.05898434f, 0.09459256f, 0.25710213f, 
    -0.00377402f, -0.34462753f, 0.47554454f, 0.23625264f, 0.42513832f, 0.16212474f, -0.19344315f, 0.50161362f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04559014f, -0.00493206f, 0.01815575f, -0.03823130f, -0.03807581f, 0.00950846f, -0.02146826f, 0.02149749f, 
    0.06512096f, 0.04246801f, 0.03015624f, -0.06145187f, 0.04994280f, -0.04038140f, 0.01893785f, -0.01359842f, 
    -0.07084854f, 0.05504999f, 0.05438649f, -0.02629298f, 0.02600859f, -0.02384793f, -0.00484293f, -0.04425750f, 
    -0.06086947f, -0.05191237f, -0.03447435f, 0.05998029f, -0.01118584f, -0.04395681f, 0.00719028f, -0.01185220f, 
    -0.06163418f, -0.02581200f, -0.06880897f, 0.03443668f, -0.07162731f, -0.00357058f, -0.00421942f, -0.07923094f, 
    -0.05911909f, -0.06957976f, -0.08901938f, -0.04651010f, -0.07420450f, -0.05220158f, -0.01514002f, 0.00752665f, 
    -0.01831094f, -0.02466276f, -0.03713940f, -0.01517939f, 0.06679785f, -0.07869633f, 0.07446749f, 0.00442198f, 
    0.01212644f, 0.05594422f, -0.05930295f, 0.06197719f, -0.00801246f, -0.06939387f, -0.08272813f, -0.00306752f, 
    0.00536233f, -0.01207250f, -0.01595823f, 0.04619370f, -0.02152833f, 0.05550824f, 0.01152993f, 0.00371231f, 
    0.00150747f, 0.05044522f, -0.02829131f, 0.02957585f, 0.01238912f, 0.02866992f, 0.06047368f, -0.06706478f, 
    -0.03480852f, 0.04305641f, -0.01216964f, -0.03056676f, -0.03875113f, -0.01378476f, -0.05213317f, 0.04995617f, 
    -0.01948157f, 0.03476404f, -0.00786503f, 0.03171343f, 0.04852457f, -0.02179313f, 0.04613578f, 0.02447579f, 
    -0.07745285f, 0.06279222f, -0.07853366f, -0.07607558f, -0.00599523f, 0.04891116f, -0.04517477f, 0.00443645f, 
    0.03576472f, -0.04341043f, -0.06296178f, -0.00091966f, -0.07060232f, 0.06015819f, -0.06208308f, 0.05757132f, 
    0.07514214f, -0.00214087f, -0.00601882f, -0.08835354f, -0.01070522f, -0.08101391f, 0.03706641f, -0.00469516f, 
    0.00701852f, -0.03197622f, -0.06543998f, 0.00755952f, 0.03227853f, -0.08561291f, -0.04255025f, -0.03772666f, 
    -0.05248993f, 0.04546364f, -0.05406290f, 0.05477152f, -0.01244725f, 0.05993906f, -0.01937896f, 0.06555893f, 
    -0.07374626f, -0.01319648f, -0.08904627f, 0.01672128f, -0.08730248f, -0.05971238f, -0.00331148f, -0.01028096f, 
    -0.10626648f, 0.16770397f, 0.73673522f, 0.09295625f, 0.09650577f, -0.21714772f, -0.03537232f, 0.08463387f, 
    0.03559193f, 0.01276293f, -0.07981026f, 0.11511544f, -0.01368410f, 0.23741361f, -0.13722858f, 0.04716130f, 
    -0.12730919f, -0.08757988f, 0.25160900f, 0.17048979f, -0.18471068f, -0.21892773f, -0.24216668f, 0.16282788f, 
    0.04614662f, -0.14387171f, 0.46407568f, 0.03882265f, 0.02893055f, 0.01852585f, 0.06929851f, 0.17126489f, 
    -0.11847114f, 0.42857391f, 0.20111971f, 0.45037311f, 0.09386715f, 0.05186465f, 0.00133529f, 0.11765809f, 
    -0.00692578f, 0.03606064f, 0.11148734f, 0.11652018f, 0.21959424f, -0.52199543f, 0.05534469f, 0.07378525f, 
    0.07308174f, -0.00723030f, 0.15144449f, 0.00821396f, 0.19251914f, 0.10458550f, 0.01402843f, 0.33905730f, 
    0.08726657f, 0.21251729f, -0.05225179f, -0.05853730f, 0.18985780f, 0.15257426f, 0.02723671f, 0.13114724f, 
    -0.22323021f, -0.03925939f, 0.10082605f, 0.01520779f, 0.10798621f, -0.03182824f, -0.14481123f, -0.27009091f, 
    -0.30149490f, -0.11476237f, -0.29128355f, -0.31882787f, -0.25580046f, -0.13148099f, -0.07295451f, -0.32848197f, 
    -0.32118496f, -0.06162616f, 0.11080455f, -0.10408349f, -0.13395132f, -0.10255251f, -0.04317227f, -0.05365257f, 
    0.06139522f, 0.10688902f, 0.11557405f, 0.19375540f, 0.29922166f, 0.18528885f, 0.10234962f, 0.11085475f, 
    0.00769804f, 0.02604949f, 0.02050008f, 0.58183455f, 0.03095602f, -0.26015601f, -0.20086291f, 0.10250050f, 
    -0.12030968f, -0.09495839f, 0.20196337f, 0.00908527f, 0.27799502f, 0.36654264f, 0.40013677f, 0.00400703f, 
    0.11750726f, 0.00437974f, 0.04054502f, 0.09656659f, 0.14018051f, -0.06070765f, 0.01895349f, 0.12485442f, 
    0.05373547f, 0.02629542f, 0.07380397f, 0.05395312f, 0.16481489f, 0.32516059f, -0.25085190f, 0.26372600f, 
    -0.11913768f, 0.18164645f, -0.22869533f, -0.14515629f, 0.11125858f, 0.04198331f, -0.04144543f, 0.49484554f, 
    0.37748718f, 0.25190443f, -0.04003555f, -0.03142072f, -0.13272516f, 0.06740944f, -0.12849799f, 0.01819866f, 
    -0.52246326f, -0.17940553f, 0.23069780f, -0.07230603f, -0.13658363f, 0.06737315f, -0.14099628f, 0.00190022f, 
    0.13284050f, 0.07537034f, 0.00241064f, 0.32985282f, 0.07818381f, -0.07452844f, 0.10266350f, 0.02344266f, 
    0.22848170f, 0.12224285f, 0.47233042f, -0.08739531f, 0.31986165f, -0.06857900f, 0.05155940f, 0.09422897f, 
    0.18110177f, 0.27574301f, 0.14618306f, -0.34418535f, 0.03652290f, -0.03420038f, 0.24950312f, 0.26603091f, 
    -0.28380692f, 0.20192049f, -0.01922377f, 0.02000873f, 0.11739456f, -0.03678270f, 0.12095149f, 0.06222050f, 
    -0.23103018f, -0.22188419f, 0.16672990f, 0.21978685f, -0.03177987f, -0.48109582f, 0.07210343f, 0.41195640f, 
    -0.07774959f, -0.08230838f, 0.09578779f, -0.39303038f, 0.04228422f, 0.06955818f, 0.28419223f, -0.04670236f, 
    0.10571580f, -0.01759705f, -0.17536369f, -0.06171015f, -0.06601077f, -0.10159481f, 0.05704497f, -0.03727789f, 
    -0.30910715f, -0.01528489f, 0.04589805f, 0.20271514f, -0.21196444f, 0.19868621f, 0.25980338f, 0.18353638f, 
    -0.06035915f, -0.42791525f, -0.16310431f, -0.03912786f, 0.10539403f, 0.11673313f, 0.06380893f, 0.09692851f, 
    0.22249986f, -0.02158272f, -0.05556084f, -0.22324513f, -0.04583887f, -0.28925863f, -0.30774552f, -0.28345904f, 
    -0.04287374f, -0.18248187f, -0.07035074f, 0.29197109f, 0.18984331f, 0.02982549f, -0.03056021f, 0.00496273f, 
    0.20657055f, -0.01097425f, 0.17986175f, 0.28932717f, 0.02547749f, -0.20497765f, -0.24743968f, -0.02916831f, 
    0.17311689f, 0.26581240f, 0.01461331f, 0.23411195f, -0.25022933f, -0.15773699f, 0.07699059f, 0.03577222f, 
    -0.08609378f, 0.10599695f, -0.02095718f, -0.08105233f, 0.07926265f, -0.29695117f, 0.03868602f, -0.04142163f, 
    -0.20062505f, -0.11680352f, 0.02114361f, -0.21768703f, -0.03562171f, 0.00301785f, 0.20962331f, -0.00709497f, 
    -0.36081997f, -0.10965450f, -0.02484131f, 0.02611282f, 0.01356893f, -0.06217156f, 0.04340365f, -0.14334929f, 
    -0.09231691f, 0.33921638f, -0.07647881f, 0.25229099f, -0.08794646f, 0.21942586f, 0.10150073f, 0.03976310f, 
    0.38165072f, 0.47675234f, 0.24508180f, 0.03339173f, -0.07501988f, -0.08371597f, -0.05823280f, 0.15327604f, 
    0.11743405f, -0.14075203f, -0.17403148f, -0.30738053f, 0.10434612f, -0.11738387f, -0.02295657f, 0.08919637f, 
    -0.22376266f, 0.03529731f, -0.02338065f, 0.07073157f, -0.16286297f, 0.16519703f, 0.02766421f, 0.14761323f, 
    -0.14894626f, 0.09421252f, -0.06110001f, -0.06061636f, 0.18185204f, -0.12582643f, -0.19192412f, -0.09435198f, 
    0.08440597f, -0.04739122f, -0.11451839f, 0.11076479f, -0.07964773f, -0.46468553f, -0.18097059f, 0.05476518f, 
    0.04543481f, -0.05322196f, -0.07553174f, -0.00338029f, -0.06727010f, 0.20617856f, 0.44460270f, 0.32433397f, 
    0.14011911f, -0.01303443f, 0.14318624f, -0.12246654f, 0.12912486f, 0.01005282f, 0.26028362f, -0.37122583f, 
    -0.10563653f, 0.15141043f, -0.09224024f, 0.24264252f, 0.14820714f, 0.01443267f, -0.02552730f, 0.35874102f, 
    0.21177360f, 0.28134662f, 0.10596213f, 0.11635859f, 0.04761750f, -0.09079237f, 0.02098736f, -0.16042422f, 
    -0.00044609f, 0.24144354f, -0.06746846f, -0.02503809f, -0.02378553f, 0.06727278f, -0.02992885f, -0.01771602f, 
    -0.02981916f, 0.24809702f, 0.32506111f, 0.04625684f, 0.00576342f, 0.18261583f, -0.04070071f, -0.05750529f, 
    0.05991215f, 0.22533703f, 0.19184984f, 0.21260008f, 0.09758451f, -0.01013597f, 0.00752821f, -0.09221145f, 
    0.03528975f, -0.04814105f, 0.01740143f, -0.18047731f, -0.27563009f, -0.38679841f, -0.00516303f, -0.03602684f, 
    0.11346194f, -0.09831591f, -0.06843921f, 0.10595446f, 0.16024743f, 0.21910153f, 0.10376367f, 0.05686151f, 
    -0.06407478f, -0.14731015f, -0.15830205f, -0.08595403f, -0.01784089f, 0.44079649f, 0.11049626f, 0.33601525f, 
    0.06470599f, 0.23442250f, -0.14195566f, -0.00413572f, 0.01475378f, -0.01639077f, -0.28252485f, 0.55998158f, 
    -0.33346683f, 0.29683939f, -0.10340907f, 0.06883113f, -0.11117640f, -0.08169013f, 0.10493417f, -0.08435902f, 
    -0.08988763f, -0.21448515f, -0.12477046f, -0.06942360f, -0.24529716f, 0.02064134f, 0.05968074f, -0.20585489f, 
    -0.18880357f, 0.17142999f, -0.26871735f, -0.01103138f, -0.29071781f, 0.20467705f, 0.11913768f, 0.18206327f, 
    0.01090392f, 0.00607024f, -0.08867057f, -0.03767790f, -0.11249854f, -0.05871544f, 0.11719958f, 0.00323080f, 
    0.29430860f, 0.32948884f, -0.17605180f, 0.04457879f, 0.01809542f, 0.30039561f, 0.07671495f, 0.10893778f, 
    -0.12804326f, 0.08088361f, 0.12795483f, 0.42503643f, -0.12927392f, 0.14984833f, 0.12567353f, 0.03744893f, 
    0.20879588f, -0.42926043f, -0.06219672f, -0.08394568f, 0.05550873f, -0.25688887f, -0.35220835f, 0.06914530f, 
    0.18815094f, 0.08298520f, -0.00512000f, -0.02234797f, -0.06542841f, 0.13693111f, -0.06552266f, -0.14871997f, 
    0.18559386f, 0.08845770f, -0.03524872f, -0.07323519f, -0.35971397f, -0.15411541f, 0.12086256f, -0.00164352f, 
    0.37799382f, 0.16475649f, 0.16306430f, 0.06406493f, -0.09409266f, -0.18026063f, -0.11757115f, 0.18943922f, 
    0.00361930f, -0.04067226f, -0.09407182f, -0.19718690f, 0.15008956f, 0.35914904f, 0.17793681f, 0.15668210f, 
    -0.02137426f, 0.05886686f, -0.17854550f, 0.06959317f, 0.06307673f, -0.12889883f, 0.27090922f, 0.04757588f, 
    0.38042322f, 0.09488776f, -0.08157145f, -0.14459608f, -0.01484324f, 0.11446442f, 0.17707533f, 0.06375255f, 
    -0.22916716f, -0.33255997f, -0.00723064f, 0.20687495f, -0.05216294f, 0.14687850f, 0.06741806f, 0.18400715f, 
    0.26553592f, -0.08637632f, 0.01509473f, 0.23765677f, 0.09977559f, 0.30157223f, 0.06846833f, -0.05265613f, 
    0.33993745f, -0.00802575f, -0.20467308f, 0.16224875f, -0.13657768f, 0.23659687f, -0.07566364f, 0.14425327f, 
    -0.00319264f, -0.04817859f, -0.17815872f, 0.05807756f, -0.07799359f, -0.01963661f, 0.28021246f, -0.13900608f, 
    0.01366600f, -0.12743247f, -0.16287015f, -0.24151346f, 0.05250243f, 0.11819858f, 0.00891390f, 0.04147913f, 
    -0.22572100f, 0.12926453f, 0.06889025f, -0.00469905f, 0.11537570f, -0.06458247f, -0.00899121f, -0.25563982f, 
    -0.10311749f, -0.35482895f, 0.27933842f, 0.09658118f, 0.08275680f, 0.00487383f, -0.12139399f, 0.02191244f, 
    0.31099075f, -0.33883512f, 0.37039220f, 0.06589443f, -0.12947100f, 0.08359608f, 0.01050629f, -0.02158261f, 
    0.09497786f, -0.21185583f, 0.15130417f, 0.33135217f, 0.18272416f, -0.01596717f, -0.05385533f, 0.03348095f, 
    0.10365155f, 0.08263879f, -0.47221813f, 0.46801892f, 0.19621977f, -0.02338377f, 0.09159604f, -0.18370479f, 
    0.01155646f, 0.26358810f, 0.02882817f, -0.21277638f, -0.32217371f, 0.40703672f, -0.19139209f, -0.05442867f, 
    -0.40080583f, 0.02471680f, 0.12458628f, 0.11600481f, -0.35682786f, -0.12724999f, 0.33853200f, -0.22456340f, 
    -0.08386858f, 0.02264363f, -0.05261656f, -0.20545660f, 0.12888461f, -0.01253017f, 0.28971609f, 0.13774027f, 
    -0.00444125f, -0.16076657f, 0.05439265f, 0.07164649f, -0.00632116f, -0.11124127f, -0.50953817f, -0.08259005f, 
    -0.56651825f, -0.42063987f, 0.19628423f, -0.26712850f, -0.05051003f, -0.02746344f, -0.06148677f, 0.35448343f, 
    0.21121268f, -0.00878389f, -0.05721858f, 0.15554236f, 0.28884876f, -0.03329211f, 0.03504862f, 0.03614534f, 
    0.02494848f, -0.02307947f, 0.00950864f, 0.12794717f, 0.21149898f, 0.14384745f, 0.19282706f, -0.25870487f, 
    -0.07294980f, -0.49737257f, -0.26673746f, -0.44128695f, -0.04748434f, -0.00526121f, 0.05268700f, 0.04402098f, 
    -0.03201382f, 0.04445761f, 0.14244276f, 0.20892073f, 0.18462239f, -0.20299329f, 0.12483533f, -0.08742286f, 
    0.23723590f, 0.13372964f, -0.07856651f, -0.88952589f, 0.20621988f, -0.44169998f, 0.02292372f, 0.12253507f, 
    -0.00221177f, 0.03283172f, 0.05247104f, 0.07922602f, 0.03405008f, -0.08046898f, 0.27402169f, 0.05942019f, 
    -0.00597464f, 0.10569653f, -0.02821488f, -0.00575252f, 0.11771373f, -0.06442182f, 0.17746539f, 0.34192082f, 
    0.08438261f, -0.16084383f, -0.15347312f, 0.19745146f, -0.06094379f, -0.03495443f, -0.64285427f, -0.68915147f, 
    -0.31357536f, 0.01147856f, -0.24337047f, 0.17419752f, 0.00372564f, 0.16694514f, -0.07530508f, -0.16142711f, 
    -0.09241055f, 0.09136790f, 0.13208970f, -0.02672261f, 0.01739198f, -0.10655247f, -0.06984279f, 0.02318644f, 
    -0.05875184f, 0.12287975f, -0.07364833f, -0.00906287f, -0.21474531f, 0.09200437f, -0.09609348f, 0.03202029f, 
    -0.19198589f, -0.35313126f, 0.22495964f, 0.04598828f, 0.08131499f, 0.06206110f, 0.00863806f, 0.16019444f, 
    0.05003465f, 0.05188030f, -0.05034653f, 0.17326128f, 0.69272894f, 0.19170593f, -0.26050574f, 0.00679730f, 
    0.03212763f, 0.04185244f, 0.08644948f, -0.33958611f, 0.31276965f, 0.50951010f, 0.24695486f, -0.07057670f, 
    -0.05542777f, 0.21260977f, 0.16106342f, 0.04727244f, 0.07773887f, 0.20018817f, 0.08791894f, -0.03121446f, 
    -0.18371350f, -0.25531757f, 0.15334861f, 0.12030389f, -0.01085025f, -0.04546921f, -0.57399857f, -0.20861605f, 
    0.13098450f, 0.15100613f, -0.15254948f, -0.18513751f, -0.05853560f, -0.19558057f, -0.15484761f, -0.10684244f, 
    -0.07690139f, 0.10813871f, 0.15191485f, 0.03358380f, -0.16019192f, 0.32209495f, 0.09675573f, -0.60512626f, 
    -0.40685543f, 0.09242822f, -0.07399253f, 0.09020685f, -0.05278531f, -0.06074636f, 0.04365407f, 0.08507576f, 
    0.17743240f, -0.00425611f, 0.10422287f, -0.07116240f, -0.06043290f, 0.23200741f, 0.09006950f, -0.03769091f, 
    0.01449747f, -0.03846173f, 0.13708927f, -0.42957234f, -0.13700278f, -0.33575800f, -0.17861280f, -0.05143988f, 
    0.01090247f, -0.10715711f, -0.26369160f, -0.12153155f, 0.14031217f, -0.02613401f, -0.06754384f, 0.11024787f, 
    0.22832064f, 0.00375550f, 0.06591561f, 0.08380400f, 0.52255499f, -0.37546647f, -0.04361295f, 0.13969825f, 
    0.33582020f, 0.06628460f, -0.00003866f, -0.02280592f, -0.30309102f, -0.37534878f, -0.53053600f, -0.17618804f, 
    0.14207667f, 0.07269389f, 0.04065828f, 0.15009142f, 0.09807158f, -0.15878126f, 0.04265880f, -0.34473005f, 
    -0.09790428f, -0.25690416f, 0.04910893f, -0.03712109f, 0.04351789f, -0.01585148f, 0.15397406f, -0.09440521f, 
    0.02663616f, -0.09862608f, -0.10137542f, 0.26594654f, -0.10900301f, 0.03423177f, 0.05000874f, 0.11003552f, 
    0.16368891f, -0.11152446f, 0.05765854f, -0.05648628f, 0.09223711f, 0.11579596f, 0.24583289f, 0.09235187f, 
    0.06753993f, -0.02696916f, -0.05346847f, 0.00256095f, -0.00756887f, -0.02384859f, -0.06570379f, 0.04752171f, 
    -0.01898814f, -0.03609763f, 0.03317760f, 0.02187866f, -0.03242434f, 0.00625421f, 0.03378250f, 0.04788635f, 
    -0.00084801f, -0.04566703f, 0.02164822f, 0.03904768f, 0.01354642f, -0.02974941f, 0.07622956f, 0.03848728f, 
    0.05347779f, -0.06259422f, -0.07012155f, 0.05371401f, -0.01600863f, -0.06799673f, 0.05837766f, -0.02946716f, 
    0.02356441f, 0.01082648f, -0.05092641f, -0.06228577f, 0.04324165f, -0.06573450f, 0.02424457f, -0.08840561f, 
    -0.04391208f, -0.02246721f, -0.02969237f, -0.02316005f, -0.07234550f, 0.07110484f, -0.04739333f, -0.00382816f, 
    -0.00136909f, 0.02328687f, -0.01312928f, -0.00595425f, 0.03034618f, 0.05411027f, -0.00758120f, 0.04283673f, 
    -0.05856436f, 0.06071496f, -0.06309268f, -0.06508596f, 0.01425453f, 0.02785194f, -0.06186564f, -0.04767470f, 
    -0.03503601f, -0.07019559f, 0.06998983f, -0.01979622f, 0.03555861f, -0.08649913f, 0.02326573f, -0.04891312f, 
    -0.02572634f, -0.01662560f, 0.03147508f, -0.03372415f, 0.03316632f, 0.04475026f, -0.05387074f, -0.01730515f, 
    0.00078095f, -0.03034476f, -0.07186434f, 0.02286565f, -0.08614186f, 0.07092138f, 0.03721533f, -0.04949044f, 
    -0.00463908f, -0.02524901f, -0.01954204f, 0.05078347f, -0.04343837f, 0.05456913f, 0.06536943f, -0.01088771f, 
    -0.05465596f, -0.03260814f, -0.08203830f, -0.03218269f, 0.02904670f, 0.00499896f, -0.08206658f, 0.01963645f, 
    0.03425215f, -0.03305221f, -0.04110484f, 0.01225105f, 0.01452654f, -0.07578788f, -0.00555503f, -0.04569351f, 
    -0.04094618f, -0.00310067f, 0.02355726f, -0.08818024f, -0.06458078f, -0.00447993f, -0.00597792f, 0.04425989f, 
    -0.03192700f, -0.01250013f, -0.00026773f, 0.05164930f, -0.01957479f, -0.01484600f, 0.05456488f, -0.06016435f, 
    -0.06550025f, 0.04278668f, 0.06274609f, -0.07719251f, -0.00657974f, -0.03833076f, 0.03817264f, -0.05862553f, 
    -0.05111647f, -0.01367520f, 0.03544278f, -0.00709008f, -0.06432080f, -0.02491030f, -0.06279691f, 0.04437824f, 
    -0.36259803f, -0.35355887f, 0.03729542f, 0.00828480f, -0.09726275f, -0.32042199f, -0.15253340f, 0.05766844f, 
    -0.02103059f, -0.11935096f, 0.20616549f, 0.37265587f, 0.23164529f, -0.09283188f, -0.14966033f, 0.17308436f, 
    -0.08312342f, -0.27202362f, -0.10544200f, -0.40291443f, -0.24318270f, -0.08502229f, -0.16618274f, 0.19079030f, 
    0.17955709f, -0.03652385f, 0.00926631f, -0.17428471f, -1.12660909f, -0.34722072f, -0.40005556f, 0.20704830f, 
    -0.01577969f, 0.01168594f, 0.09635116f, -0.05220058f, 0.20141232f, 0.15446815f, 0.14041990f, 0.07335777f, 
    0.15215853f, 0.05142039f, -0.02021860f, 0.16987622f, 0.10718977f, 0.13630724f, 0.25066096f, 0.39039332f, 
    -0.17096007f, -0.09252629f, -0.27541986f, -0.03729434f, 0.10556792f, 0.29513252f, -0.11053649f, 0.10881736f, 
    -0.28290641f, -0.23677039f, -0.02221136f, -0.06274790f, -0.01334091f, 0.02662092f, 0.13188311f, 0.18250351f, 
    0.03093227f, -0.33927384f, -0.06288409f, 0.00863335f, -0.11397507f, 0.24176896f, -0.24814925f, -0.08807779f, 
    0.10140897f, -0.10099488f, 0.01788930f, 0.09891319f, 0.08505169f, 0.08304404f, 0.25596470f, -0.08710287f, 
    -0.18326972f, -0.03405164f, 0.13566267f, -0.19056812f, 0.00900771f, 0.03099984f, 0.04270172f, 0.17771824f, 
    0.06193146f, 0.08983365f, -0.13124882f, -0.38450944f, 0.06014230f, -0.13680264f, 0.03285540f, -0.16098739f, 
    0.14529301f, -0.02330125f, 0.08766112f, -0.84800214f, -0.05548158f, -0.40825066f, -0.11622231f, -0.25819746f, 
    0.06502497f, 0.10110559f, -0.00010230f, 0.17721772f, -0.19987030f, -0.08876338f, -0.09203171f, 0.30586529f, 
    -0.03858801f, 0.04039358f, 0.04545327f, 0.06768499f, 0.01794133f, 0.02466340f, -0.17291303f, 0.36601207f, 
    -0.00062866f, 0.03929407f, -0.02008373f, 0.08629769f, 0.09989392f, 0.20342898f, -0.18099378f, -0.26096341f, 
    -0.78047401f, 0.06116243f, -0.12653269f, 0.00655624f, 0.17227890f, 0.03108811f, 0.13227454f, 0.29271707f, 
    0.15334637f, -0.17020726f, 0.11770127f, 0.09634548f, 0.28559962f, 0.08353337f, 0.08203363f, -0.07354557f, 
    0.31684726f, 0.24610260f, -0.00709196f, 0.01629938f, -0.05311340f, 0.13779004f, 0.17255907f, -0.01039862f, 
    -0.05918979f, -0.14547439f, 0.07389408f, -0.09278201f, -0.04795638f, -0.15766810f, 0.17000760f, -0.03727886f, 
    0.08376382f, 0.07440144f, 0.03359470f, -0.36955011f, -0.03293519f, 0.12347440f, 0.17145258f, -0.11184111f, 
    0.05267426f, -0.02182783f, 0.00535370f, -0.24164389f, 0.04510604f, 0.05813974f, -0.36341545f, -0.03339310f, 
    0.05040028f, 0.04078779f, 0.21106081f, 0.07443729f, -0.12628712f, -0.16693217f, 0.04817642f, 0.09949841f, 
    -0.03616620f, -0.15420198f, 0.18839324f, -0.22862241f, 0.07845046f, 0.27504173f, -0.27558732f, -0.39825639f, 
    0.12347001f, -0.06536971f, -0.04040474f, 0.13319561f, 0.11351084f, 0.08368576f, 0.16954207f, -0.13688619f, 
    -0.45708787f, -0.21206014f, -0.00806337f, 0.13761307f, 0.10632586f, 0.11561075f, -0.13384293f, -0.09940048f, 
    0.27988714f, 0.46148980f, -0.01839671f, 0.17240433f, -0.09127814f, -0.04603178f, 0.07808575f, 0.18572405f, 
    0.02575253f, 0.26960018f, -0.08420995f, 0.01993179f, -0.00707685f, 0.04725679f, 0.24449137f, -0.12776880f, 
    0.14011624f, 0.09725370f, -0.38932973f, -0.01090176f, 0.04787302f, 0.01779410f, -0.13351656f, -0.09172454f, 
    -0.03829601f, -0.02726287f, 0.19765379f, 0.29848185f, 0.08024363f, -0.20324159f, 0.07968527f, 0.08124485f, 
    0.20798744f, 0.01222366f, 0.22561643f, -1.37129378f, -0.59047329f, 0.08148931f, -0.12675701f, -0.05945027f, 
    -0.08679206f, 0.25514558f, 0.05616360f, 0.01158718f, 0.23712970f, 0.17839147f, 0.18532236f, 0.02434563f, 
    0.15118411f, 0.04601454f, 0.10206489f, -0.13726509f, 0.03581583f, 0.40878353f, -0.11931748f, 0.19233005f, 
    -0.20776768f, 0.12371013f, 0.07749502f, 0.03451840f, -0.07269844f, -0.07636500f, -0.07428712f, -0.59133142f, 
    -0.23308630f, -0.30807135f, -0.22179405f, 0.10350893f, -0.05023601f, -0.08330317f, -0.09278366f, -0.13994503f, 
    -0.37994081f, -0.28413033f, -0.21569256f, 0.18122454f, 0.01494865f, -0.01527773f, 0.00247333f, 0.13615908f, 
    0.20148386f, -0.01407344f, -0.06978620f, 0.08814307f, 0.15323770f, 0.07072062f, -0.12846991f, -0.12305638f, 
    -0.00595737f, 0.25389314f, 0.07489778f, 0.13962698f, 0.02616300f, 0.05177257f, -0.04981145f, -0.16241182f, 
    -0.08762220f, -0.06532432f, -0.39742595f, -0.46754736f, -0.31593332f, 0.03164212f, 0.27654877f, -0.01339242f, 
    0.00917900f, -0.41847762f, 0.22041662f, 0.32069272f, 0.42063379f, -0.17645222f, -0.20550124f, -0.11909204f, 
    -0.01591571f, 0.03367076f, 0.12171175f, 0.33341041f, -0.12553328f, -0.03949835f, 0.27629453f, 0.08165848f, 
    0.18747474f, -0.05901883f, 0.07140967f, 0.16940163f, 0.06859908f, 0.15212521f, 0.22469868f, 0.26693708f, 
    -0.14144188f, -0.03009344f, 0.12520075f, -0.07770735f, -0.08960433f, 0.06227890f, 0.61851829f, 0.54487640f, 
    -0.14071092f, -0.06419716f, 0.02459735f, 0.10731786f, 0.02284437f, -0.05605856f, 0.08044823f, 0.24419247f, 
    0.15990500f, -0.01884110f, 0.21912786f, -0.05451912f, -0.00864938f, -0.12240989f, -0.23098931f, -0.14636829f, 
    -0.15658520f, 0.02668017f, -0.07110281f, 0.03114784f, 0.04935893f, -0.18318439f, -0.11852411f, -0.13009802f, 
    0.00055861f, -0.31384680f, -0.38948542f, 0.21401761f, 0.02355494f, 0.20502079f, 0.04305363f, -0.04985932f, 
    0.04901429f, 0.00742911f, -0.04537212f, -0.14931317f, -0.03633820f, -0.02225026f, -0.07280963f, 0.02444310f, 
    0.02200116f, -0.22861615f, 0.22111960f, 0.27457651f, -0.03431289f, -0.19346470f, 0.24860226f, -0.12721029f, 
    -0.04557867f, 0.12347202f, -0.04018556f, -0.01182594f, -0.16586372f, -0.11455589f, -0.00666156f, -0.06601979f, 
    0.06457948f, 0.02445787f, -0.06404245f, -0.15257408f, 0.21802597f, 0.18953790f, -0.21488988f, 0.24342604f, 
    -0.04965810f, 0.16284339f, 0.27611849f, -0.01076405f, 0.21136494f, 0.24258241f, -0.45269710f, -0.45969489f, 
    0.13736090f, 0.18860240f, 0.07790900f, -0.11807219f, 0.06789004f, 0.15557081f, -0.08393122f, -0.33724684f, 
    -0.20925485f, 0.05871399f, 0.20693824f, 0.07279926f, -0.14249724f, -0.01640974f, 0.06351151f, -0.10163245f, 
    0.38976076f, -0.11453201f, -0.15331320f, 0.03730500f, -0.13004395f, 0.13688089f, 0.00781313f, -0.14959966f, 
    -0.00876633f, -0.05436629f, -0.05880426f, -0.24299575f, 0.20925319f, 0.06920296f, 0.11319198f, 0.18657137f, 
    -0.04667462f, 0.16015869f, -0.56129593f, -0.06358916f, 0.54201770f, -0.08263306f, -0.05790242f, -0.34185064f, 
    0.09033063f, -0.06987028f, 0.22689123f, 0.10227215f, -0.21806045f, -0.17780951f, -0.05949209f, 0.15977831f, 
    -0.14068723f, 0.10725596f, -0.12268651f, -0.11851148f, -0.32644138f, -0.00249231f, 0.17024630f, -0.10923517f, 
    -0.16432782f, -0.06451435f, 0.05616502f, -0.01734669f, 0.12933126f, 0.27909523f, -0.44629964f, -0.43328342f, 
    -0.11096823f, 0.02621808f, -0.05375784f, -0.00340580f, 0.04838971f, 0.04136721f, 0.30612621f, -0.36887953f, 
    -0.52741134f, -0.20841250f, 0.08650754f, -0.07247551f, 0.15466310f, -0.02426907f, 0.01587304f, 0.51152569f, 
    -0.08914833f, 0.10440969f, -0.09115377f, 0.05559529f, -0.03404958f, 0.02336057f, 0.11382323f, 0.12168290f, 
    0.26181865f, 0.04250534f, -0.15994927f, -0.14461239f, -0.07591213f, -0.29926041f, 0.29718155f, -0.07349958f, 
    -0.06416659f, -0.37677303f, 0.28461295f, 0.24222371f, -0.14205755f, 0.07531077f, -0.03362912f, -0.14026567f, 
    0.00998831f, -0.00622743f, 0.20400912f, -0.13288556f, -0.28527123f, -0.05945204f, -0.06671499f, -0.12326119f, 
    0.06776167f, 0.32327878f, 0.11715316f, 0.78607690f, -0.06516633f, -0.22144260f, -0.17605789f, 0.12738551f, 
    -0.06638457f, 0.03189780f, -0.13905641f, -0.03300006f, 0.20287411f, 0.37719581f, -0.21558298f, -0.11780186f, 
    -0.32294041f, -0.02709288f, 0.04293864f, 0.26401484f, 0.06864177f, -0.09830666f, -0.15894048f, -0.25127542f, 
    -0.02301789f, -0.03366854f, 0.22372960f, 0.05443078f, -0.00037655f, -0.18109781f, -0.42073813f, 0.07640046f, 
    0.08014339f, -0.24963591f, -0.18447669f, -0.05071902f, 0.15204984f, -0.13955487f, -0.00851816f, -0.40912122f, 
    0.09659429f, 0.42064759f, -0.11828998f, -0.05707229f, 0.19761290f, 0.06440236f, -0.04102858f, 0.05520786f, 
    -0.10078816f, 0.45206454f, -0.00068967f, -0.31003729f, 0.02073878f, 0.06550708f, -0.01324671f, -0.10922570f, 
    -0.11727522f, 0.00692593f, 0.09910576f, -0.12618472f, 0.01804373f, 0.21370265f, 0.23293968f, 0.00168228f, 
    0.09349146f, -0.06744038f, 0.31849331f, -0.26574057f, 0.22894019f, 0.00423073f, -0.06160399f, -0.08918549f, 
    0.14222619f, 0.00852575f, 0.18039440f, -0.27690756f, -0.47641897f, 0.02254546f, -0.16465554f, -0.01593178f, 
    -0.21244010f, 0.09292382f, 0.01339556f, 0.00487313f, 0.30490041f, 0.11431058f, 0.36587590f, -0.11826445f, 
    0.13721424f, -0.15370981f, -0.00907305f, -0.08247790f, -0.00103846f, -0.24573171f, -0.29022577f, -0.12582280f, 
    -0.20976667f, -0.24001510f, -0.27689180f, 0.09539370f, -0.24705681f, -0.09705398f, -0.15726815f, 0.10972202f, 
    0.17206791f, 0.02735082f, 0.07942520f, -0.05951837f, -0.01157923f, -0.00855520f, -0.03749006f, -0.43904293f, 
    0.00399900f, 0.28331518f, 0.19275726f, 0.13100147f, 0.14529558f, 0.05692834f, 0.03022127f, 0.18092427f, 
    0.05998316f, 0.10320901f, -0.13031071f, 0.02532690f, -0.02839310f, 0.18398526f, -0.06306217f, 0.00702564f, 
    0.29786369f, 0.20833638f, 0.12486929f, 0.13129735f, -0.05457299f, 0.15260950f, -0.16134451f, -0.13238038f, 
    -0.10412480f, -0.17103310f, -0.03409980f, 0.00857315f, -0.13684718f, -0.04757673f, 0.04829643f, 0.18542118f, 
    0.13709970f, 0.16941749f, -0.08229355f, -0.15795211f, -0.08415011f, -0.00030786f, 0.03991767f, 0.15502693f, 
    0.09052522f, 0.42340353f, 0.00853781f, 0.24596477f, -0.23678926f, 0.04616519f, -0.36383530f, -0.08158553f, 
    0.08585235f, -0.06776362f, 0.10360506f, 0.10512518f, -0.04670760f, -0.32978508f, 0.15716232f, -0.68625319f, 
    -0.22518088f, 0.07401291f, -0.02249552f, 0.08674515f, 0.03462780f, 0.03219018f, 0.47396371f, 0.03167108f, 
    -0.07171246f, -0.06230589f, 0.01946983f, -0.06058420f, 0.02787930f, -0.02684702f, 0.01397937f, -0.14484563f, 
    -0.23082596f, 0.28977650f, -0.01414160f, 0.03281727f, 0.24472085f, 0.17301695f, -0.09210792f, 0.20107891f, 
    0.08289842f, 0.27424246f, -0.08293220f, -0.16153638f, -0.24999914f, -0.02512808f, 0.10854978f, 0.09685583f, 
    -0.03341859f, -0.27162835f, -0.08207502f, 0.14846502f, 0.07029840f, -0.00866556f, -0.14610493f, 0.01923471f, 
    0.07457020f, 0.15843239f, -0.02182322f, -0.54913712f, 0.48063320f, 0.15201426f, -0.10810047f, -0.17717886f, 
    0.06706894f, 0.20820804f, -0.03961025f, -0.55371559f, -0.06110591f, 0.26117307f, 0.03614357f, -0.23622483f, 
    -0.30870673f, 0.02558718f, -0.07765091f, -0.10298093f, -0.19429557f, 0.19755292f, 0.12694973f, -0.12248814f, 
    -0.17172405f, -0.14490008f, -0.04174670f, 0.12724103f, -0.03622402f, -0.01770157f, -0.15810344f, -0.41811287f, 
    -0.05992951f, -0.16702145f, -0.15897171f, -0.09766323f, -0.05065210f, 0.05632992f, -1.05569172f, -0.74261093f, 
    0.17962603f, 0.00629910f, 0.25386542f, -0.12293912f, -0.13243765f, 0.00956776f, 0.14010511f, -0.19645023f, 
    0.07828249f, 0.22015969f, 0.00417237f, -0.03547410f, -0.10247983f, 0.01758165f, -0.07140471f, -0.10505641f, 
    0.21202911f, 0.15159644f, 0.11839857f, 0.03554510f, 0.12720056f, -0.08677211f, 0.23438677f, 0.18870066f, 
    -0.06362231f, 0.00251436f, 0.35960391f, 0.20496941f, -0.02562758f, -0.19883139f, -0.15290856f, 0.06100612f, 
    0.12675576f, 0.12017016f, 0.09236646f, 0.38882455f, 0.19945644f, -0.16529170f, -0.03559362f, -0.06755678f, 
    0.02293975f, 0.04182029f, -0.08410651f, -0.55668837f, 0.28106844f, -0.81249130f, 0.15617536f, -0.04078581f, 
    0.05271711f, 0.04411779f, -0.04501130f, 0.00398999f, 0.05879912f, 0.11942362f, 0.17489550f, 0.07744721f, 
    0.08274692f, 0.09502678f, 0.15143909f, 0.08951752f, -0.01030752f, -0.24551269f, 0.23998120f, -0.03743878f, 
    0.05962615f, 0.00648324f, 0.13113378f, 0.02722706f, 0.06710051f, -0.03830132f, 0.17201576f, 0.00380115f, 
    0.26204386f, 0.05632660f, -0.20722185f, 0.02688678f, -0.13311522f, -0.04858038f, -0.06238986f, 0.24934611f, 
    0.31371698f, -0.01721656f, 0.00486544f, -0.04606888f, 0.05468744f, 0.14472046f, 0.10904060f, 0.10541210f, 
    0.15762183f, 0.11972751f, 0.12525588f, -0.14300407f, 0.22101359f, 0.11839589f, 0.04041349f, 0.10112584f, 
    -0.10379212f, -0.07907107f, -0.04113261f, 0.15690681f, -0.01130550f, 0.22021998f, 0.30392203f, -0.19937029f, 
    0.31664062f, 0.21046101f, -0.33446655f, -0.07979440f, -0.15427643f, -0.20560342f, 0.08402085f, 0.08646707f, 
    -0.07336210f, -0.02446057f, 0.15515572f, 0.15539756f, 0.22608547f, 0.01524027f, -0.23083231f, 0.29333156f, 
    0.12964199f, -0.02515205f, 0.02987185f, 0.18824939f, 0.16540147f, -0.31022313f, -0.14084440f, -0.22074844f, 
    -0.03293323f, -0.16135094f, 0.13312577f, -0.14995931f, 0.15552248f, 0.06420510f, 0.15767412f, -0.10851770f, 
    0.12758560f, -0.02268139f, -0.11720262f, 0.09716315f, -0.00928066f, -0.21327995f, 0.02161227f, 0.16629785f, 
    0.06700082f, -0.19053037f, -0.03521616f, -0.25749737f, 0.15814047f, -0.10928981f, 0.12306423f, 0.04431878f, 
    0.07652085f, 0.29164046f, -0.00962206f, 0.00017009f, 0.11883055f, -0.05069675f, 0.03814042f, 0.32108703f, 
    0.02276396f, 0.04111004f, -0.05620348f, -0.02862931f, 0.18888649f, 0.10519151f, 0.10637797f, 0.03258323f, 
    0.23605910f, -0.45206243f, -0.38109094f, -0.32944599f, 0.22785869f, -0.26532570f, -0.01206846f, -0.06783753f, 
    -0.21568613f, -0.05560213f, 0.18671724f, 0.21093123f, 0.32149416f, 0.15863504f, 0.26595274f, -0.07229122f, 
    0.14140055f, -0.07038103f, -0.02003994f, -0.21161625f, 0.11989864f, -0.06109688f, -0.07765588f, 0.10173082f, 
    -0.31888446f, 0.00515756f, 0.18244185f, -0.15848850f, 0.08020132f, 0.25156298f, 0.14299184f, 0.21078333f, 
    0.09295923f, -0.00925485f, 0.12172600f, -0.16519406f, -0.28466141f, 0.12006332f, 0.10781057f, -0.14282548f, 
    -0.01832210f, 0.28884071f, 0.05081677f, 0.13825823f, 0.08830125f, -0.51884055f, -0.06160630f, -0.48060980f, 
    0.34149122f, 0.13413531f, -0.24007484f, -0.23612596f, -0.07508966f, 0.01844922f, -0.09867354f, -0.49568856f, 
    -0.23718330f, -0.26726815f, -0.18003662f, -0.02280127f, 0.09976565f, 0.19424850f, 0.15815444f, 0.31441018f, 
    0.17282479f, -0.30895883f, 0.31183031f, -0.06853485f, 0.01363621f, 0.08304831f, -0.08794064f, -0.07654509f, 
    -0.05418156f, 0.38660660f, -0.27006331f, 0.09557546f, 0.11553919f, -0.00133121f, -0.12346768f, 0.16068150f, 
    -0.01618197f, -0.43663374f, -0.07966129f, 0.40972888f, 0.17770076f, -0.08666978f, 0.18294141f, -0.22371519f, 
    -0.01468021f, -0.03960952f, 0.22352146f, 0.19395727f, 0.46100667f, -0.11379281f, -0.05247749f, -0.16569962f, 
    0.23053895f, 0.23720057f, 0.02861888f, -0.13704181f, -0.04279984f, 0.25638348f, 0.11977491f, 0.20187117f, 
    0.23995215f, -0.15207887f, 0.01804040f, -0.12526831f, 0.12001571f, -0.25494155f, -0.79025751f, -0.46792108f, 
    0.10004450f, -0.19038098f, 0.13777384f, -0.05315107f, 0.06404368f, 0.15642618f, -0.00577643f, -0.46197042f, 
    -0.30754736f, -0.02587944f, 0.04589132f, 0.20967780f, 0.20072590f, -0.12073041f, 0.10900057f, -0.23665832f, 
    -0.04229293f, 0.29132724f, -0.09414895f, 0.13392486f, 0.01892159f, 0.03029013f, -0.07413008f, 0.04372536f, 
    -0.13606380f, 0.16922873f, -0.18403834f, -0.08094985f, -0.05944997f, -0.09896618f, -0.03001388f, -0.14323385f, 
    -0.02230998f, 0.06846562f, 0.28935370f, 0.41784024f, -0.14263345f, -0.15932040f, -0.35704815f, 0.02675740f, 
    -0.11185878f, 0.16096230f, -0.32829395f, 0.18306082f, 0.00600495f, 0.12114918f, 0.04933658f, 0.02957281f, 
    0.00202099f, -0.02692994f, 0.07996448f, 0.54044086f, -0.03596935f, 0.19945674f, 0.07331633f, 0.32261574f, 
    -0.07195230f, 0.07956229f, -0.07048429f, -0.18366508f, -0.06616979f, -0.24724735f, 0.04465367f, 0.13008204f, 
    0.06219887f, 0.14716065f, 0.03568584f, -0.11104597f, 0.01619711f, -0.03883497f, -0.29391351f, -0.28237191f, 
    -0.17346618f, 0.11836959f, 0.05120757f, 0.12101436f, -0.02483439f, 0.16171658f, 0.42173204f, 0.03508810f, 
    0.13986354f, -0.07195458f, -0.01023295f, -0.11332662f, 0.09437967f, -0.15249610f, -0.03317655f, 0.31916195f, 
    0.51215166f, 0.12848632f, -0.20918809f, -0.15038352f, -0.22579621f, 0.02823861f, -0.04516950f, 0.11931304f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.01837883f, 0.31735101f, 0.47968212f, -0.23046114f, -0.09828210f, -0.04393550f, 0.14308777f, 0.00046187f, 
    0.26696688f, -0.01107919f, -0.00266642f, 0.10720634f, 0.36995187f, 0.14575142f, 0.28115395f, 0.07268187f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00956092f, -0.02522034f, -0.24688981f, -0.18467158f, -0.03551826f, 0.02572128f, 0.17220984f, -0.02068238f, 
    -0.05902925f, 0.03897228f, -0.02767308f, -0.03183309f, -0.10698581f, -0.16017644f, -0.08901544f, -0.16882814f, 
    -0.00733348f, -0.05045101f, -0.09535575f, -0.08978300f, 0.06880683f, 0.59835052f, 0.17166343f, 0.05974382f, 
    -0.22218490f, 0.07980385f, -0.03873613f, -0.35197830f, 0.17057969f, 0.10112961f, 0.50453335f, 0.11968676f, 
    -0.06192236f, 0.18812722f, 0.51570773f, -0.02694209f, 0.15443826f, -0.36283916f, -0.58207315f, -0.11280978f, 
    0.45717895f, -0.19568597f, 0.29430237f, 0.08320595f, -0.07887854f, -0.49871233f, -0.02495071f, -0.18827747f, 
    -0.21244706f, -0.02450995f, 0.33233944f, 0.29447022f, 0.03685515f, -0.13057694f, -0.37594071f, 0.06017050f, 
    0.03621775f, 0.28962857f, -0.20880675f, 0.51056552f, 0.31655720f, -0.37662154f, -0.01479835f, 0.08541432f, 
    -0.13947265f, -0.05887651f, -0.21007332f, -0.12940897f, -0.11665470f, 0.25311482f, -0.00974704f, 0.20656483f, 
    0.19112855f, -0.22609226f, 0.16186436f, -0.14733860f, 0.07970013f, -0.18727382f, -0.00673912f, -0.30258346f, 
    0.15181372f, -0.17552879f, 0.29668656f, 0.07698412f, 0.37150607f, 0.00200424f, 0.16371664f, 0.12735301f, 
    -0.79871118f, 0.14462611f, -0.40770248f, -0.36894348f, 0.03055531f, 0.61523706f, 0.35193515f, -0.05444304f, 
    -0.25544423f, 0.12964770f, -0.51362514f, 0.08650617f, -0.36525667f, 0.30982149f, 0.07697605f, 0.10763443f, 
    0.10308542f, 0.47034216f, 0.29151803f, 0.68184656f, -0.58682013f, 0.32241443f, -0.19873618f, 0.41012168f, 
    0.14860584f, 0.24042144f, 0.36853495f, 0.08101989f, -0.16962633f, -0.56360543f, -0.03420321f, -0.11191369f, 
    0.34066802f, 0.33969626f, -0.08592454f, 0.22377810f, 0.15191410f, -0.64166445f, -0.03377992f, 0.11644941f, 
    -0.18856442f, -0.15753987f, 0.04064466f, 0.14248963f, 0.04764795f, 0.02467086f, 0.06796675f, 0.20268017f, 
    0.17322326f, 0.13175967f, -0.20972052f, -0.13322523f, -0.22737926f, 0.04215103f, -0.18868832f, -0.17363717f, 
    0.09611982f, -0.30454290f, 0.00868973f, 0.37580332f, 0.16952610f, 0.31316200f, 0.45009345f, -0.04203147f, 
    -0.70081985f, 0.12113339f, -0.21352033f, 0.50890487f, 0.05947210f, 0.14866345f, 0.17840235f, 0.39580289f, 
    -0.11692689f, 0.33287689f, 0.23125020f, -0.08799420f, -0.05252010f, 0.17858669f, -0.08564350f, 0.13679557f, 
    0.11409729f, -0.52906996f, 0.41687709f, -0.01657346f, -0.41470933f, 0.08547812f, -0.22741774f, 0.15794782f, 
    -0.11561241f, 0.33437848f, -0.16910613f, 0.58148068f, -0.37311462f, -0.05488842f, -0.00905703f, 0.14907828f, 
    0.08715367f, 0.35456485f, 0.17806648f, -0.03999477f, -0.33420470f, -0.30621269f, -0.31447884f, 0.38760871f, 
    0.03484374f, -0.15776213f, -0.21991986f, 0.21030845f, 0.04199374f, -0.00906859f, 0.07148574f, 0.19440058f, 
    -0.01445164f, -0.19900677f, -0.19798146f, 0.01899389f, -0.03646155f, 0.19575477f, -0.18770377f, -0.27898806f, 
    0.19631308f, 0.48244363f, 0.18314892f, -0.20411545f, 0.00552948f, 0.02272587f, -0.11764635f, 0.23131280f, 
    0.18054363f, -0.14403202f, 0.04611918f, -0.68989253f, 0.04205238f, 0.99968719f, -0.06066347f, 0.13615160f, 
    -0.09560516f, 0.12772094f, -0.16894314f, 0.12283380f, -0.07803283f, 0.63232601f, -0.08454392f, 0.11660559f, 
    0.12271243f, -0.34784833f, -0.11368071f, -0.15947437f, 0.06355951f, -0.22283368f, 0.11374762f, 0.24427104f, 
    -0.06858677f, -0.02969864f, 0.29387236f, -0.08305424f, 0.41851977f, 0.39295879f, -0.21418631f, -0.09998679f, 
    -0.53771287f, 0.45483729f, 0.14956035f, 0.13836487f, -0.40445191f, -0.74507827f, 0.63310009f, -0.20078100f, 
    0.18899706f, -0.31204727f, -0.39089122f, 0.45770752f, 0.48692620f, 0.32012320f, -0.08843480f, -0.19792002f, 
    -0.10321707f, 0.53550255f, 0.10102163f, 0.34161794f, -0.36439115f, 0.27326342f, 0.40914387f, -0.30326805f, 
    0.01026770f, -0.12615216f, -0.26316258f, -0.17207047f, 0.11860181f, -0.20086174f, 0.02626464f, 0.07963815f, 
    -0.04408618f, -0.05601118f, 0.05477615f, -0.03806929f, -0.25887764f, 0.17287241f, 0.12005572f, -0.10838321f, 
    0.00401101f, 0.48332697f, 0.63032192f, -0.18875298f, -0.05652043f, -0.21125932f, -0.11791901f, 0.24735591f, 
    0.22363402f, -0.42454562f, 0.00903804f, -0.02533840f, -0.13030191f, -1.04696095f, 0.40353504f, -0.49135000f, 
    0.10588672f, 0.27967939f, 0.54916477f, -0.35943529f, -0.27788803f, -0.04148939f, 0.28494725f, 0.15703687f, 
    -0.38987461f, -0.02137638f, 0.17915595f, 0.09195964f, -0.42381561f, 0.37443137f, -0.00167608f, -0.33012241f, 
    0.10258767f, 0.43242407f, 0.17562933f, 0.01165078f, -0.13697703f, 0.06413321f, -0.54809731f, -0.05007359f, 
    0.13581292f, 0.03979164f, 0.23380364f, 0.41407704f, -0.76598316f, -0.71622908f, -0.12976815f, 0.14074941f, 
    0.07137075f, -0.16169259f, -0.00711934f, 0.10933848f, 0.19143951f, -0.03205355f, 0.30067787f, 0.06501853f, 
    -0.30334675f, 0.16152433f, -0.23430666f, 0.05336489f, 0.05862566f, 1.06033957f, 0.07323214f, 0.06358825f, 
    0.10211063f, 0.56098390f, 0.63356537f, -0.31012127f, -0.21582325f, 0.38372988f, 0.20253545f, -0.05752328f, 
    0.14306082f, -0.49838957f, 0.23257160f, 0.19533685f, -0.50022036f, -0.64773118f, -0.26686415f, -0.23847191f, 
    -0.24764362f, 0.07970570f, 0.01295281f, -0.63832378f, -0.32733846f, -0.05256020f, 0.15239009f, -0.04219460f, 
    0.17792554f, -0.30205467f, 0.00885912f, -0.56006598f, 0.09122284f, 0.06411347f, 0.34009084f, 0.30658805f, 
    -0.16241404f, 0.21823622f, 0.28583950f, -0.30763525f, 0.00421562f, 0.08865125f, -0.17989327f, -0.02302303f, 
    -0.83224386f, -0.09359021f, 0.12338752f, -0.78307891f, 0.22824056f, 0.64552134f, 0.47626910f, -0.24039494f, 
    -0.10784200f, 0.19175595f, -0.31784445f, -0.07453639f, 0.44612712f, 0.41255555f, -0.35585782f, -0.16330259f, 
    -0.00668612f, 0.43183827f, -0.22940154f, 0.37798059f, -0.35322148f, -0.25086081f, 0.43301809f, 0.02001783f, 
    0.22316787f, -0.21111420f, -0.00183980f, -0.05553323f, -0.27058679f, -0.17405465f, -0.24552074f, 0.20552364f, 
    -0.07111161f, -0.21122649f, -0.08226354f, 0.21966356f, 0.19923081f, -0.24395253f, -0.09370167f, -0.24420628f, 
    0.11936483f, -0.00928663f, -0.01455913f, -0.19985940f, -0.20384094f, -0.10403857f, 0.10015234f, 0.05008757f, 
    -0.06232429f, 0.20942375f, -0.21128961f, 0.18473101f, -0.20326798f, -0.14629230f, -0.21827671f, 0.12156444f, 
    -0.21241236f, 0.28749549f, -0.25102440f, -0.09245860f, -0.36853874f, -0.30593392f, 0.27721685f, 0.16537806f, 
    -0.47320583f, 0.05174680f, 0.54261380f, 0.71523792f, -0.44036886f, -0.75516647f, 0.05567917f, 0.16799884f, 
    -0.22337455f, -0.47823960f, 0.34342507f, -0.52089953f, -0.20391469f, 0.22084354f, -0.01057124f, -0.23699856f, 
    0.22377241f, -0.47330901f, -0.10600287f, 0.41957182f, 0.10994233f, 0.38678768f, 0.31230974f, -0.17433955f, 
    -0.19956490f, -0.00521647f, -0.30824280f, -0.10384963f, -0.08647872f, 0.59562552f, -0.08918911f, -0.13587847f, 
    0.19395395f, -0.06503905f, 0.12767485f, 0.15327697f, 0.26001269f, 0.02497833f, -0.17409217f, -0.15486594f, 
    -0.07041558f, 0.21394320f, -0.33038518f, 0.03661522f, -0.57380861f, 0.67300671f, 0.20464666f, -0.03777533f, 
    -0.16091120f, 0.19300306f, 0.20023778f, 0.12246145f, -0.40757450f, 0.26028636f, -0.16152604f, 0.54352307f, 
    -0.17686886f, 0.24393411f, 0.17970563f, -0.20633794f, 0.04482650f, 0.14723396f, -0.28839490f, 0.24152085f, 
    0.06867296f, 0.13494186f, -0.27040163f, -0.86167896f, 0.11491909f, -0.49729574f, 0.37114033f, -0.00092706f, 
    -0.11298370f, 0.12202323f, 0.03992919f, 0.26389346f, 0.05592738f, 0.12676516f, -0.14345305f, 0.12176597f, 
    -0.40496811f, -0.08047448f, 0.00732528f, -0.04821498f, 0.01024604f, -0.71336544f, 0.29454294f, -1.08768964f, 
    0.08541420f, 0.34850487f, -0.02404554f, 0.00929552f, 0.08230691f, -0.51636803f, 0.33984056f, 0.24357939f, 
    -0.30624780f, -0.28558049f, 0.23638630f, -0.37248453f, 0.09448794f, 0.58675396f, -0.34847379f, 0.23957105f, 
    0.01353411f, 0.47239515f, 0.70002764f, 0.09549870f, -0.36487517f, 0.18175480f, -0.10509945f, 0.05068842f, 
    0.55193037f, -0.41224942f, -0.25594318f, -0.24026480f, -0.24578434f, 0.58344227f, -0.17691846f, 0.19820194f, 
    -0.00696065f, 0.15291852f, 0.34709859f, 0.10424499f, 0.27519673f, 0.14221849f, 0.30291712f, 0.22399189f, 
    0.04966724f, 0.06695589f, -0.27863103f, -0.90675658f, -0.03415444f, 0.30540475f, -0.24098575f, -0.02976058f, 
    0.07249213f, 0.16273972f, 0.14986721f, 0.37698072f, -0.43432152f, 0.44962013f, -0.31400484f, -0.14154360f, 
    0.12407120f, 0.18352845f, 0.01948189f, -0.21994425f, -0.39882752f, 0.06720359f, -0.27922532f, 0.55370295f, 
    0.06505594f, 0.40089381f, -0.09225701f, 0.49043798f, -0.18260001f, -0.24888527f, 0.41383025f, 0.14418548f, 
    0.22989056f, -0.03578179f, 0.28887779f, -0.58936763f, -0.07146050f, 0.42020744f, -0.32143831f, 0.23351471f, 
    -0.16373402f, -0.23475932f, -0.03890774f, 0.00538006f, 0.17768131f, 0.19050844f, 0.33388346f, 0.14770466f, 
    -0.44003186f, 0.28279233f, 0.10722350f, 0.52615041f, 0.24898745f, -0.68484879f, 0.40302041f, 0.11139022f, 
    0.22104402f, -0.11703790f, -0.09098680f, -0.10544088f, -0.06723333f, 0.23040408f, 0.10691824f, 0.19935158f, 
    0.18107912f, 0.29206786f, 0.28367168f, -0.55196750f, 0.34638134f, -0.43011582f, 0.27291030f, 0.13339753f, 
    -0.05880724f, 0.31004578f, -0.00570539f, 0.10780434f, -0.23834351f, -0.54801357f, -0.06639049f, -0.11415238f, 
    0.01739581f, -0.07070874f, -0.11513071f, -0.04196196f, -0.00961834f, 0.42202294f, 0.45459977f, 0.19580331f, 
    -0.06100696f, -0.04037156f, 0.22552885f, 0.23851864f, 0.28744051f, 0.10136320f, -0.25966206f, 0.02345335f, 
    0.28886774f, -0.03672357f, -0.08305873f, 0.79083997f, -0.19492248f, 0.23166811f, -0.26658994f, 0.25123245f, 
    0.14602922f, -0.06391011f, -0.02002666f, 0.49185073f, -0.13867040f, -0.52796918f, -0.51141804f, -0.11688080f, 
    0.22527944f, 0.64788252f, 0.13294277f, -0.13085003f, 0.33608380f, -0.14128290f, 0.19965591f, 0.36516392f, 
    -0.08462378f, -0.06665647f, 0.27398807f, -0.31150135f, 0.04641910f, 0.03741962f, 0.23028700f, 0.02584073f, 
    -0.70854282f, 0.60091245f, 0.29800028f, -0.53666919f, -0.07544708f, 0.99171847f, 0.03053908f, -0.22607581f, 
    -0.15825532f, 0.14647362f, -0.31711420f, -0.13762388f, 0.22310567f, -0.32890767f, -0.46393454f, 0.20430747f, 
    0.18537657f, 0.05354503f, 0.33415172f, -0.35317186f, -0.21289304f, -0.31438556f, 0.59142804f, 0.09808294f, 
    0.08858141f, -0.11259805f, 0.17428163f, 0.17853038f, 0.21600978f, -0.60682559f, 0.05010106f, -0.04176152f, 
    -0.59781086f, 0.23994541f, 0.04450864f, 0.85564798f, 0.13290237f, 0.04869100f, 0.44260111f, 0.07064284f, 
    0.10391364f, 0.22954333f, 0.48523358f, 0.19029383f, 0.35651416f, -0.19373356f, 0.23502222f, -0.23310569f, 
    -0.74995488f, -0.24544173f, 0.09960654f, 0.33617914f, -0.28303936f, -0.52603394f, -0.03791101f, -0.29284438f, 
    -0.00988048f, -0.07715717f, -0.25373912f, 0.47891444f, -0.23828147f, 0.22987139f, -0.56370479f, -0.23983027f, 
    -0.06555110f, 0.37641209f, 0.14629431f, 0.33620185f, -0.24660945f, 0.06160750f, 0.30008900f, -0.41190633f, 
    -0.13639556f, -0.06830764f, 0.61816561f, -0.02318622f, 0.09135254f, 0.34009701f, -0.01740254f, -0.10286995f, 
    0.04756641f, -0.11627676f, -0.41508144f, 0.33130598f, 0.06139708f, -0.09279075f, 0.04846143f, 0.03043744f, 
    0.19649662f, 0.16020396f, -0.07244097f, -0.34817672f, 0.12620778f, -0.10380918f, 0.75396830f, 0.10068354f, 
    -0.30872360f, -0.38648596f, 0.13940023f, 0.58531547f, -0.10193898f, 0.24201991f, 0.10802054f, 0.03885648f, 
    0.22593869f, -0.01953762f, 0.21172197f, 0.44946229f, -0.04935985f, -0.40910229f, -0.20371343f, 0.05209550f, 
    -0.37028477f, 0.49201795f, -0.23997867f, 0.65942430f, 0.08275655f, 0.86604548f, 0.11913667f, 0.44852301f, 
    -0.19501278f, -0.06600360f, -0.18405865f, 0.31828764f, 0.12846804f, 0.12126986f, -0.25257471f, 0.00706234f, 
    -0.65492797f, 0.41105962f, 0.17952771f, -0.37299433f, 0.22434822f, -0.09247749f, 0.32255661f, -0.88265312f, 
    -0.23633221f, -0.29112321f, -0.31576666f, 0.49616432f, 0.43686906f, 0.21951221f, -0.28092718f, 0.21758148f, 
    -0.17242840f, 0.55128360f, 0.24616325f, 0.03601392f, 0.00487018f, -0.19488515f, 0.34263772f, -0.49159074f, 
    0.18814234f, 0.30060485f, -0.22967441f, -0.59158254f, -0.44919422f, 0.18038601f, 0.58857119f, 0.17359196f, 
    0.01449162f, 0.13935493f, -0.00259905f, -0.46920529f, 0.03066730f, 0.25243452f, -0.06078956f, 0.38380536f, 
    0.17191064f, -0.22883084f, 0.04913071f, 0.03800626f, -0.19726287f, 0.14546943f, 0.37969044f, 0.02184160f, 
    -0.39156857f, -0.06609394f, 0.22046393f, 0.36828849f, 0.32966113f, 0.25592041f, 0.31250688f, 0.13181156f, 
    -0.22725002f, 0.04110980f, -0.24551959f, 0.26161155f, -0.24005821f, 0.14352088f, -0.18393597f, 0.05565238f, 
    0.11023271f, 0.13552251f, 0.37331083f, 0.83011019f, -0.69442225f, 0.01689697f, 0.02883191f, 0.45171073f, 
    0.22707522f, -0.38987011f, 0.24996920f, -0.13162626f, 0.27049437f, 0.46808079f, 0.12452868f, -0.22214167f, 
    -0.02122128f, -0.19686384f, 0.12577419f, 0.90702957f, 0.03736563f, -0.15860394f, 0.24375854f, -0.16491935f, 
    -0.17679353f, 0.08595559f, 0.38681376f, -0.21320160f, 0.23472868f, -0.51475710f, -0.30593795f, 0.18567340f, 
    -0.21482569f, 0.14592010f, -0.20019427f, -0.23191927f, 0.11659272f, -0.09244525f, 0.33330020f, -0.32825848f, 
    -0.21694794f, -0.13037987f, 0.24708655f, 0.03036304f, 0.12360777f, -0.18529029f, 0.02896320f, -0.22156033f, 
    -0.44124681f, -0.41195291f, 0.36579543f, 0.77525276f, 0.28023306f, -0.13264883f, 0.30365953f, -0.07673391f, 
    -0.24382789f, 0.10054927f, 0.32880515f, -0.34089857f, -0.06507005f, 0.64942127f, -0.19028787f, 0.13277690f, 
    -0.16759613f, -0.36445671f, -0.00709443f, 0.41420966f, -0.01853932f, 0.53843910f, 0.21947341f, 0.19124758f, 
    -0.23179907f, 0.29479602f, 0.09665922f, 0.28312346f, 0.15782885f, -0.30087450f, 0.36802295f, 0.15887019f, 
    -0.17974500f, -0.12433067f, -0.40370056f, 0.33856189f, 0.19187126f, -0.44988742f, -0.16678511f, 0.06498700f, 
    -0.05437621f, 0.04450982f, -0.18287213f, 0.02642333f, 0.17497352f, 0.33415571f, -0.27409843f, 0.05026102f, 
    0.03466500f, 0.52800232f, 0.75499290f, -0.21926169f, -0.26292965f, 0.49203551f, 0.44724670f, -0.21825767f, 
    0.21121547f, 0.61082202f, 0.14361621f, 0.00521954f, -0.19793084f, 0.26709241f, -0.53539735f, 0.18241560f, 
    0.23626007f, 0.40227106f, -0.03115622f, -0.49870580f, -0.12611501f, 0.17243214f, -0.10513756f, -0.32048979f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.20608494f, -0.11865209f, 0.10931501f, 0.10011200f, -0.09700736f, 0.35864499f, -0.33558828f, 0.30559155f, 
    -0.21047544f, -0.45497268f, 0.23262481f, -0.52884293f, -0.01720198f, 0.15160513f, 0.12207260f, 0.26223949f, 
    0.03755349f, -0.30832151f, 0.46741170f, 0.36985070f, 0.25191584f, -0.07620847f, 0.53278303f, 0.66476089f, 
    0.36026952f, 0.29141015f, 0.04094562f, -0.14818104f, -0.37637249f, -0.20073089f, -0.25904977f, -0.26432803f, 
    0.32685357f, -0.09216882f, -0.23129396f, 0.59343016f, 0.07266060f, 0.08992115f, -0.20583443f, -0.11742151f, 
    0.22981781f, 0.29676607f, -0.45143968f, -0.13417742f, 0.37764174f, -0.09979538f, -0.34786686f, -0.02483372f, 
    -0.28787750f, 0.67914200f, -0.08108556f, -0.04893921f, 0.03210114f, -0.40704119f, 0.34090093f, 0.00695808f, 
    0.16888492f, -0.28477967f, 0.03382226f, -0.29773921f, -0.05941283f, 0.10719596f, -0.13826081f, 0.68094230f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.11279934f, -0.01600755f, -0.16786799f, 0.10534020f, 0.10615528f, -0.13949722f, 0.34192544f, 0.05789341f, 
    -0.01688572f, 0.21529904f, -0.72655845f, 0.18050781f, -0.00634279f, -0.49066076f, -0.13002886f, 0.10520141f, 
    0.34677497f, -0.14675173f, -0.77018338f, -0.65527070f, -0.01775148f, -0.06887059f, -0.77138329f, 0.22493260f, 
    -0.45954916f, 0.15794899f, 0.02786632f, -0.07440247f, 0.33283713f, 0.12751815f, 0.12126964f, 0.07683735f, 
    -0.15927815f, -0.08545402f, -0.21459977f, -0.90887517f, -0.25992310f, -0.11931738f, -0.27160782f, 0.21802026f, 
    0.20042787f, -0.36264998f, 0.12892590f, 0.27042884f, -0.05204255f, 0.07736071f, 0.18925722f, -0.03184124f, 
    0.24299745f, -0.29266086f, -0.32849157f, 0.15004905f, 0.24774303f, 0.35607857f, -0.32146239f, -0.04113720f, 
    0.08800260f, 0.02548382f, -0.24251460f, -0.07766297f, -0.51276541f, -0.28782070f, 0.15259285f, -0.04377406f, 
    -0.02295527f, 0.15001237f, -0.20741817f, -0.08763873f, 0.11306252f, 0.12486709f, -1.27757895f, 0.04277612f, 
    -0.02690186f, 0.11444335f, -0.47610945f, -0.47254345f, 0.00567469f, 0.02602331f, 0.00301358f, 0.05101199f, 
    0.32750940f, -0.04731551f, 0.06957693f, -0.42839384f, -0.53221130f, 0.10066607f, -0.55473179f, 0.42214605f, 
    0.20458046f, -0.04104042f, -0.02874866f, 0.09272899f, -0.70932692f, -0.20212263f, -0.09869508f, -0.89265507f, 
    0.14784366f, 0.48410770f, 0.05735490f, -0.10610091f, -0.00733527f, -0.75930417f, -0.02397588f, 0.17711313f, 
    0.04407342f, 0.27343532f, -0.27070561f, 0.02019275f, 0.10569984f, 0.12319241f, 0.22442599f, -0.09367323f, 
    0.21550532f, -0.05284656f, -0.00270062f, 0.19969010f, 0.46597946f, 0.59244823f, 0.63688254f, 0.25502843f, 
    -0.66771442f, -0.10789417f, 0.14159258f, 0.01060655f, -0.16357869f, 0.08190221f, 0.08145146f, -0.15138046f, 
    0.07588240f, -0.15503091f, 0.37793726f, 0.14744495f, -0.13485375f, -0.14227682f, -1.21653759f, 0.15534821f, 
    -0.04389647f, -1.15652370f, 0.17649044f, -0.14472708f, -0.06877913f, -0.08167917f, -0.06419801f, 0.23414379f, 
    -1.73691237f, 0.09669735f, 0.63891953f, 0.61854768f, 0.52454013f, -0.58050841f, 0.46460408f, 0.01394052f, 
    0.33941424f, 0.01837044f, -0.02375010f, 0.02235505f, 0.04646402f, 0.04516109f, 0.18325122f, -0.57229882f, 
    0.23036970f, 0.13173909f, -0.19376083f, 0.10921490f, -0.17297718f, 0.09617318f, -0.31688458f, -0.03115327f, 
    0.12970315f, -0.05093987f, -0.23858391f, 0.17110319f, -0.24534275f, 0.21637650f, -0.09892248f, 0.26411790f, 
    -0.43139327f, 0.09731068f, -0.32372484f, -0.38756123f, 0.03151701f, -1.31775177f, -0.39121613f, -0.07084963f, 
    -0.24019656f, -0.09577068f, 0.17168276f, -0.01272281f, -0.02680506f, -0.16622855f, -0.05862959f, 0.42444319f, 
    0.06955212f, 0.05055591f, 0.14813542f, -0.19306557f, -0.20397018f, -0.50702006f, -0.00341180f, -0.14828295f, 
    0.11540674f, -0.16110316f, 0.25357690f, 0.08734471f, -0.00083306f, -0.18815076f, 0.11537382f, 0.04021725f, 
    -0.10450197f, -0.13074361f, 0.15905397f, 0.26840007f, 0.22381507f, -0.66267461f, 0.26874781f, -0.25993669f, 
    -0.03349118f, 0.06470373f, 0.03011185f, -0.00407276f, 0.50912499f, -0.70879143f, -0.46955404f, 0.26693419f, 
    -0.08189677f, 0.58034259f, -0.02747656f, -0.23550551f, -0.74736029f, 0.04959572f, -0.07132607f, 0.05128425f, 
    -0.03199069f, -0.03440413f, -0.04910620f, -0.17759718f, -0.61554056f, 0.25817496f, -0.07669933f, 0.06049951f, 
    0.13169941f, -0.32392153f, 0.23247156f, -0.34849963f, -0.03096656f, -0.06639916f, -0.09381913f, 0.03800053f, 
    0.21145765f, 0.15653303f, -0.33703044f, 0.35551661f, 0.19225609f, -0.21758367f, 0.10179757f, -0.11176242f, 
    -0.11338935f, 0.05586423f, -0.23336186f, 0.14786212f, -0.33446240f, -0.22973435f, 0.13554025f, -0.15192913f, 
    0.08440402f, 0.12415664f, -0.06681889f, 0.16297147f, -0.03747535f, 0.02019312f, 0.12994047f, -0.14071909f, 
    0.14670572f, -0.09003662f, -0.46036261f, -0.15158349f, 0.03253430f, 0.12698965f, -0.25850353f, -0.12514773f, 
    -0.13291506f, 0.12433738f, -0.02945428f, -0.09297325f, -0.51856750f, -0.10273173f, -0.25014192f, 0.30256701f, 
    -0.03421408f, -0.67192400f, -0.14216949f, 0.16983899f, 0.11379035f, 0.36257166f, 0.12748583f, -0.19410117f, 
    0.12053867f, -0.06020819f, 0.29862046f, 0.14719951f, -0.20635994f, -0.09142336f, -0.37672454f, -0.55095160f, 
    0.25220257f, 0.00238576f, -0.54741383f, 0.15860757f, -0.01346399f, 0.02692289f, -0.38982350f, 0.05295480f, 
    0.20920995f, 0.04741101f, -0.64265800f, -0.07976631f, 0.07465140f, -0.02951992f, 0.15079951f, 0.05467902f, 
    -0.00459281f, -0.12297956f, 0.11643505f, 0.10857376f, 0.12657204f, 0.23712869f, -0.32947874f, 0.06371085f, 
    -0.04894665f, -0.12880656f, -0.13734983f, -0.14516366f, 0.05167533f, 0.14622509f, -0.15117629f, 0.12712692f, 
    0.00878821f, 0.02035199f, -0.18231753f, 0.08131421f, -0.04314660f, 0.00405776f, -0.35374478f, -0.49531266f, 
    0.31113771f, 0.13787201f, 0.03233832f, -0.05618457f, -0.59859145f, -0.41826290f, -0.11477337f, -0.45187950f, 
    0.09512498f, -0.36081699f, 0.24439289f, -0.06964915f, 0.01597614f, -0.12352841f, -0.02736180f, -0.09190299f, 
    -0.10463507f, 0.21630488f, 0.00877281f, 0.16872242f, 0.52916491f, 0.20913388f, 0.15351179f, 0.02005465f, 
    -0.24511847f, -0.11928505f, -0.06815723f, 0.34057459f, 0.10330174f, 0.05021414f, -0.67819721f, -0.18526554f, 
    -0.27172786f, -0.25559378f, 0.38629586f, 0.01746610f, 0.03155899f, 0.04786360f, 0.09743731f, -0.01060556f, 
    0.09627887f, -0.84945363f, 0.52665895f, 0.13397948f, -0.01805942f, -0.32591099f, -1.06672883f, 0.42985544f, 
    -0.08166679f, -0.48904365f, 0.19944392f, 0.10598161f, 0.10675363f, 0.09675123f, -0.09087330f, -1.47320175f, 
    -0.57829928f, 0.04044145f, 0.75099081f, 0.29319099f, 0.20812605f, -0.42099136f, 0.59649986f, -0.10261682f, 
    -0.51877880f, -0.68080086f, -0.11259775f, -0.07846236f, -1.55542016f, -0.45256421f, -0.03813299f, -0.84840745f, 
    0.00058716f, -1.19814265f, 0.09146065f, 0.34216502f, 0.25505754f, -0.22493748f, 0.30863667f, -0.59386218f, 
    -0.21170096f, -0.01020860f, 0.14950399f, -0.01586829f, -1.04952705f, -0.47212887f, -0.28596410f, 0.45205817f, 
    -0.19613400f, 0.11629102f, 0.01271067f, -0.22686675f, -0.38220280f, -0.61455083f, -0.05046616f, -0.71945822f, 
    -0.81043798f, -0.51653361f, 0.16154724f, -0.31479082f, -0.44312558f, 0.32357618f, -1.45351267f, 0.03987143f, 
    0.04408930f, -0.00761761f, -0.56283563f, 0.09426103f, 0.12352660f, 0.16751979f, 0.19079006f, 0.02129561f, 
    -0.08594403f, 0.39176181f, 0.02732593f, 0.78173947f, -0.06065488f, -0.00115628f, 0.06791861f, -0.80374843f, 
    -0.12100238f, -0.06789907f, -0.94089496f, -0.72546494f, -0.05131621f, 0.02634318f, -0.08884092f, -0.22069249f, 
    -0.05161188f, -1.21344781f, -0.04968996f, -0.08776328f, 0.55876821f, 0.01740291f, -0.02050614f, 0.64102560f, 
    -0.00015719f, 0.05829132f, 0.13678230f, -0.25868636f, 0.08071223f, 0.87491935f, 0.09005607f, 0.38216016f, 
    -0.05471531f, -0.11075671f, -0.11500119f, 0.18093131f, -0.14291511f, -0.83298773f, 0.36171579f, 0.16504905f, 
    -0.27814543f, -0.02428734f, 0.12584136f, 0.18177916f, -0.21818903f, -0.30130315f, -0.26373613f, 0.13702279f, 
    0.55414760f, 0.09071460f, -0.01876212f, 0.07966834f, -0.14606173f, 0.10854869f, -1.20692229f, -1.08468485f, 
    0.09676762f, -0.20195375f, -0.00346216f, 0.26977992f, -0.25188041f, 0.06660265f, -0.92644763f, 0.12099292f, 
    -0.01049944f, 0.34609053f, -0.11886352f, -0.73975003f, -0.09519695f, -0.09760292f, -0.00634306f, 0.26962382f, 
    0.01473252f, -0.16229895f, -0.04585886f, 0.00045559f, 0.16474010f, 0.08274432f, -0.07891306f, -0.06837621f, 
    -0.63867456f, 0.23018715f, -0.10508194f, -0.11600833f, -0.64682257f, 0.31996280f, 0.39954951f, -0.41037881f, 
    -0.29713836f, -0.35363254f, -0.04512587f, 0.18061490f, -0.25244087f, -0.53196561f, -0.46993709f, 0.14369197f, 
    -0.56068587f, -0.00894240f, 0.38997424f, -0.25564721f, -0.35656735f, -0.48819700f, 0.41823789f, 0.22661331f, 
    -0.57796621f, 0.25402328f, 0.17506057f, 0.42731899f, -0.97461140f, -0.71195346f, -0.28651756f, 0.19701047f, 
    0.26560727f, 0.38712028f, -0.10263819f, 0.20031708f, 0.36594680f, 0.11997236f, -0.43864295f, -1.46320903f, 
    0.00326175f, 0.03386142f, 0.00648886f, -0.10949717f, -0.24481788f, -0.42659017f, 0.02670093f, 0.05768271f, 
    -0.03240508f, -1.02872133f, 0.21644014f, 0.17898063f, 0.00771068f, 0.26274395f, 0.29840845f, -0.10122740f, 
    -0.25774363f, -0.09896011f, -0.09323256f, -0.31474522f, 0.25177419f, -0.15233260f, 0.09819444f, 0.26636967f, 
    -0.26175755f, 0.27521259f, 0.06376334f, -0.03067902f, -0.21546866f, 0.09372317f, -0.43594569f, 0.31217921f, 
    0.29854357f, -1.37458766f, 0.00706078f, 0.35061717f, 0.01895265f, 0.49974725f, 0.01984759f, -0.39771515f, 
    0.04223422f, 0.03264067f, 0.02175419f, -0.02557542f, -0.24774380f, 0.23113915f, -1.23456872f, -1.01449704f, 
    -0.58300996f, 0.09352060f, -0.22980171f, -0.03907266f, -0.52471018f, -0.46905035f, 0.27259535f, -0.56418860f, 
    0.48498353f, -0.11260326f, -0.44677529f, -0.85381353f, 0.22216733f, -0.13003458f, 0.03792393f, 0.43982038f, 
    0.08812709f, 0.33313259f, -0.23504612f, 0.03169860f, -0.09830594f, 0.33917588f, -0.20229296f, -0.34311271f, 
    -0.06530954f, 0.32794791f, -0.10498390f, -0.75494325f, 0.00151293f, -0.15233044f, 0.22588959f, 0.30786788f, 
    -0.14443018f, -0.03878995f, 0.10473604f, 0.06532298f, -0.18847334f, -0.06990321f, 0.44720691f, -0.21972071f, 
    0.30720782f, 0.24882171f, 0.09852217f, -0.11057596f, -1.01802146f, -0.94870573f, 0.35891405f, 0.28945646f, 
    0.18456289f, 0.38382626f, -0.15645306f, -0.07767299f, 0.23389269f, -0.10403853f, -0.59678358f, 0.36304376f, 
    0.20185888f, -0.57536834f, -0.06435803f, -1.45152092f, 0.29239607f, -0.43611050f, -0.52010047f, 0.28654087f, 
    -0.31664950f, 0.25629723f, 0.10683459f, -0.82508028f, 0.05328325f, -0.20563081f, 0.10737880f, 0.11179924f, 
    -0.71989727f, 0.36062515f, 0.08989102f, 0.12098964f, 0.35124061f, 0.02287104f, -0.04641007f, -0.08982023f, 
    -0.11951429f, -0.16795626f, -0.40948391f, -0.85722297f, 0.03690650f, 0.18564442f, -0.35760003f, -0.21112834f, 
    0.11649709f, 0.02141585f, 0.26092204f, -0.13146260f, -0.12579171f, 0.16800070f, -0.24593383f, -0.33314928f, 
    -0.05356038f, -0.10736940f, -0.64193892f, 0.72698176f, 0.06561445f, 0.19753630f, 0.16874839f, -0.12689368f, 
    0.28187937f, -0.45753521f, -0.08160181f, -0.07182528f, -0.76333749f, -0.53410745f, 0.67962599f, 0.34018019f, 
    -0.36630881f, -1.72882807f, 0.26710749f, 0.13029066f, 0.17230591f, -0.06114077f, 0.26432830f, -0.39283139f, 
    -0.47491959f, -0.05204710f, -0.07995386f, -0.72782022f, 0.93647218f, -0.16901717f, -0.26264852f, 0.25960127f, 
    -0.90506959f, -0.17217778f, 0.31493357f, -0.16848612f, -0.41128200f, -0.53199708f, 0.30582082f, -0.02177216f, 
    0.10536423f, -0.36695993f, -0.25016409f, -0.27072895f, 0.08392659f, -0.12889944f, 0.47546443f, 0.08246168f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.34450963f, 0.13686840f, 0.30604899f, -0.10815436f, -0.13914491f, -0.01883940f, 0.24294882f, -0.34167746f, 
    -0.00996918f, 0.09886207f, 0.26002485f, -0.14462984f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
