#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.90213197f, -0.17590153f, 0.21742216f, -0.37485743f, -0.37882587f, -0.00102251f, 0.45148507f, -0.25479153f, 
    -0.54650235f, -0.00964695f, 0.31129858f, -0.26809555f, -0.48551023f, -0.39720318f, -0.18869194f, 0.12769811f, 
    0.05092032f, -0.53919411f, -0.43832096f, -0.55956221f, -0.37992632f, -0.58063966f, -0.03849042f, 0.13503665f, 
    0.02911219f, -0.34391534f, -0.67721236f, -0.62073267f, 0.02499012f, -0.73543757f, 0.36250576f, 0.32273600f, 
    0.23371530f, 0.13863903f, 0.54986680f, 0.01940301f, 0.43946666f, -0.12168836f, 0.30447140f, -0.28167576f, 
    -0.30497429f, -0.12643701f, 0.06420691f, 0.25619555f, 0.03700211f, 0.15566136f, -0.07982622f, -0.04160790f, 
    -0.25663602f, 0.36928418f, -0.85753244f, -0.31958425f, -0.09143339f, 0.45101091f, 0.03865337f, -0.01467653f, 
    -0.30131260f, -0.43058482f, 0.19301388f, 0.39369914f, -0.62260848f, -0.15761608f, -0.46746841f, 0.39427751f, 
    -0.17313088f, 0.52225178f, 0.10736661f, -0.18592525f, 0.19280359f, -0.02666395f, -0.24789776f, -0.49693668f, 
    -0.33973679f, -0.27422783f, -0.25032702f, -0.82574093f, -1.18340838f, -0.45023167f, 0.40403223f, 0.95077121f, 
    0.27115673f, -0.13887788f, -0.23053111f, 0.39338470f, 0.77859890f, -0.09412915f, -0.13230765f, -0.02851766f, 
    -0.10343578f, 0.40525165f, -0.18503855f, 0.10719652f, -0.05003657f, 0.21496673f, 0.10059889f, 0.00135425f, 
    -0.39127570f, 0.00674301f, 0.14072977f, -0.29070720f, 0.19210179f, 0.43310761f, 0.36257994f, -0.24410766f, 
    0.21233179f, 0.14356683f, -0.00984390f, 0.11657045f, 0.39235047f, 0.27786660f, -0.37898895f, -0.30958009f, 
    -0.04286975f, 0.01663936f, 0.35646582f, 0.24564579f, 0.19212466f, -0.18998563f, -0.16699784f, -0.24572214f, 
    -0.24224697f, -0.39546111f, 0.08804850f, 0.28329420f, -0.13055333f, -0.72394657f, 0.13602649f, 0.69134563f, 
    1.01119256f, 0.43636447f, 0.47598180f, -0.52624702f, -0.76876873f, -0.45735556f, 0.03732439f, -0.33531225f, 
    0.23009785f, -0.39750770f, -0.02925773f, -0.14273804f, -0.10453165f, 0.21724539f, 0.14051257f, -0.01386052f, 
    -0.08817749f, 0.13061066f, -0.11375875f, -0.14716077f, 0.08851255f, -0.12025889f, -0.62769347f, -0.64226997f, 
    -0.41854599f, -0.48095831f, 0.06864988f, 0.10398466f, -0.63275182f, -0.42601758f, -0.71337700f, -0.00839992f, 
    -0.52589166f, -0.27718347f, -0.03045376f, 0.08775360f, -0.52539206f, -0.01194475f, -0.23229356f, -0.17841235f, 
    0.15799329f, -0.03851432f, 0.06897560f, 0.00351020f, -0.07688061f, -0.05540474f, 0.03957088f, -0.33461449f, 
    -0.83237863f, -0.19318737f, 0.35642642f, -0.07890340f, -0.39313361f, -0.87926996f, -0.61109138f, -0.39042538f, 
    -0.41442975f, 0.31382272f, 0.67942250f, 0.02450622f, 0.56848884f, 0.01529290f, 0.15123689f, 0.12653239f, 
    -0.01198873f, -0.45810825f, -0.40951416f, -0.04494680f, 0.50984389f, -0.20169175f, 0.09365506f, 0.21768101f, 
    0.66487682f, 0.21340013f, 0.25156784f, -0.51685131f, 0.32101420f, 0.11203855f, -0.11255500f, -0.24410035f, 
    -0.46579272f, 0.07457571f, -0.11968674f, -0.38684919f, 0.55251735f, -0.42981175f, -0.00833367f, -0.16185656f, 
    -0.14938597f, -0.20184058f, 0.23761453f, 0.43377590f, -0.14446495f, 0.17434008f, 0.10147589f, 0.12254815f, 
    0.47603217f, -0.62523079f, -0.18705837f, -0.17071530f, -0.61021173f, -0.57837832f, 0.85010296f, 0.07071386f, 
    0.03731175f, 0.30203584f, 0.73650974f, 0.11165708f, -0.24481878f, 0.04773153f, 0.00109259f, -0.02102452f, 
    0.14373814f, 0.21632537f, 0.04756192f, 0.01623090f, -0.11117941f, -0.18111522f, 0.13366507f, 0.02278773f, 
    -0.14541043f, -0.03917090f, 0.38194534f, -0.54437846f, -0.29469883f, -0.25244126f, -0.63953984f, -0.52694231f, 
    -0.49817869f, -0.55254251f, -0.53926301f, -0.51829904f, 0.07128384f, 0.31195882f, 0.11579242f, -0.15499292f, 
    -0.03157656f, -0.12919383f, 0.24477613f, 0.12550911f, 0.23012063f, 0.06914942f, -0.31174105f, -0.03887255f, 
    -0.17287663f, -0.23943207f, -0.21810892f, -0.58919221f, 0.07592244f, 0.25213072f, -0.93925989f, -0.72820294f, 
    1.02971065f, -0.58039093f, -0.23320363f, 0.33384964f, 0.28054133f, -0.27269477f, -0.04928588f, -0.38043538f, 
    -0.33202356f, -0.06909088f, 0.08770244f, -0.16809765f, 0.23749313f, 0.15867212f, 0.07851069f, -0.10945579f, 
    0.04270864f, 0.16942005f, -0.02396625f, -0.18314055f, 0.05577339f, -0.89881432f, -0.82187277f, -0.70670611f, 
    -0.50343865f, 0.27609098f, 0.13954408f, 0.01667810f, 0.03012551f, 0.04360199f, 0.29933575f, -0.01581853f, 
    -0.38400677f, -0.04079924f, 0.61811811f, -0.11511894f, -0.29092100f, -0.13415845f, -0.05428945f, -0.46612573f, 
    -0.21125856f, -0.11095037f, -0.12727542f, -0.14251693f, -0.07513560f, -0.68383968f, -0.14365998f, 0.12283670f, 
    -0.62527508f, -0.89626688f, 0.41481626f, 0.41460612f, -0.01294882f, 0.00219693f, 0.31783515f, 0.11593985f, 
    -0.05122533f, 0.15337163f, 0.07637369f, 0.14176439f, -0.23137921f, -0.03757408f, -0.38585111f, -0.40019438f, 
    0.17705481f, 0.30649164f, 0.17391209f, 0.39344579f, 0.20939603f, -0.00535852f, 0.95625728f, 0.29616556f, 
    -0.73324370f, -0.09997237f, -0.61825854f, -0.75588489f, -0.38270888f, 0.52399969f, 0.32116303f, 0.02001375f, 
    -0.25674656f, -0.19694133f, 1.02064157f, -0.27302611f, -0.28992108f, 0.22297156f, -0.04068459f, -0.03696907f, 
    -0.20424856f, -0.30884704f, -0.09630737f, -0.04583669f, 0.11201610f, -0.01719577f, 0.04068474f, 0.02618165f, 
    0.14610311f, 0.16953054f, 0.51265806f, 0.00333731f, 0.46260333f, -0.18767048f, 0.13675016f, 0.34129530f, 
    0.18560205f, 0.21606559f, 0.23334782f, -0.12275925f, -0.30494082f, 0.31992000f, -0.26804391f, -0.13710658f, 
    -0.09981352f, -0.05633685f, -0.14892402f, -0.01540500f, 0.55090362f, 0.13508067f, 0.01966195f, 0.03966018f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25655577f, 0.35287359f, 0.04343805f, 0.30070800f, 0.43561417f, 0.06912087f, -0.11835387f, 0.31309575f, 
    0.31602445f, 0.15271902f, -0.31515020f, 0.32637650f, 0.32736689f, 0.10828337f, 0.51757759f, 0.12015417f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02878570f, 0.17696346f, -0.08249175f, 0.04546412f, 0.10746584f, -0.04192116f, 0.04776155f, 0.06323146f, 
    0.23003885f, -0.07446059f, -0.10346416f, -0.02627376f, -0.01894763f, -0.26589581f, -0.02590274f, -0.03640570f, 
    -0.04327202f, 0.01872508f, 0.11809745f, 0.12311847f, -0.02117867f, -0.16028211f, -0.00867164f, 0.05449248f, 
    0.01224694f, -0.23336731f, 0.28378046f, 0.00113654f, 0.03388192f, -0.03198527f, 0.16324800f, -0.01655288f, 
    -0.07642525f, -0.08367725f, -0.08454999f, -0.20297685f, 0.16156009f, -0.12886821f, 0.03285987f, 0.10341083f, 
    -0.02354980f, 0.01365487f, 0.10535419f, 0.06560645f, 0.11269429f, -0.22939801f, 0.12992817f, 0.07957958f, 
    -0.18958829f, -0.12285093f, 0.02442342f, 0.03449161f, 0.08018754f, 0.01127703f, 0.00591544f, 0.01161331f, 
    0.17180677f, -0.07005954f, 0.09707740f, 0.17317416f, 0.26236933f, -0.16530083f, 0.13423078f, -0.26641569f, 
    -0.10261310f, -0.20286635f, -0.07824168f, 0.06992451f, 0.03447380f, -0.01254834f, -0.05291205f, -0.01088907f, 
    0.29807490f, 0.23484935f, 0.39082012f, -0.00973287f, -0.07637390f, 0.00980614f, 0.10138448f, -0.06496655f, 
    -0.04931775f, -0.10190462f, 0.07281791f, 0.04565164f, 0.45004106f, 0.12347292f, 0.23916791f, -0.04599059f, 
    -0.06741651f, 0.01546420f, 0.11731961f, -0.00650996f, 0.02097398f, -0.05900748f, 0.02134950f, -0.01725498f, 
    0.00478609f, -0.09322628f, -0.10418297f, -0.02753300f, -0.06584099f, -0.02926864f, -0.02128557f, 0.00758441f, 
    0.00038275f, 0.05968242f, -0.00285836f, 0.07665355f, -0.29832175f, -0.16537915f, -0.15932447f, -0.17273065f, 
    -0.01966473f, 0.02637402f, 0.02284578f, -0.06787989f, 0.08547634f, -0.17975423f, -0.10350969f, 0.07336910f, 
    0.34051996f, 0.26895669f, 0.32892346f, 0.07710636f, -0.05374948f, 0.10445508f, -0.11119621f, -0.03194916f, 
    -0.13321328f, -0.03992936f, 0.00320431f, -0.03940551f, -0.20711678f, 0.30443671f, -0.05685888f, -0.16974582f, 
    0.09654448f, 0.07275984f, 0.00384002f, -0.00400163f, -0.10237938f, -0.14155133f, 0.00920087f, -0.04132734f, 
    0.21154816f, -0.14803270f, 0.07796592f, -0.13431422f, 0.08625224f, 0.13420469f, 0.07754039f, -0.04766437f, 
    0.13358070f, -0.18923277f, -0.03676032f, -0.11563983f, -0.33378899f, -0.06781510f, -0.16140759f, 0.01110945f, 
    0.04556620f, 0.09115797f, 0.02029107f, -0.01253279f, 0.15889184f, 0.02465140f, 0.07433373f, -0.03490166f, 
    0.42872989f, 0.02021740f, 0.14407083f, 0.13501388f, 0.09222904f, 0.13807613f, -0.15039895f, 0.02371541f, 
    0.00654018f, 0.05350829f, -0.09552576f, -0.01426780f, -0.06338979f, -0.04532667f, 0.05837460f, -0.08189837f, 
    -0.04357016f, -0.05621788f, -0.03952536f, 0.02192576f, 0.14287515f, 0.14636391f, 0.15775502f, 0.24005802f, 
    0.54466224f, 0.19064237f, 0.17755546f, 0.15042035f, 0.11517259f, -0.11075839f, -0.10832805f, -0.02249850f, 
    0.07091119f, 0.05574139f, -0.07067523f, -0.04161790f, 0.11718571f, 0.05624714f, -0.09274074f, 0.04693611f, 
    0.02931257f, 0.25952014f, 0.06717693f, -0.03987087f, -0.14254101f, -0.07726870f, 0.16002654f, -0.18451025f, 
    -0.15326108f, 0.32957745f, 0.27198085f, -0.00446702f, 0.09769586f, -0.15618381f, -0.15580931f, 0.01767367f, 
    -0.02100027f, -0.11951648f, -0.05096851f, 0.01556651f, -0.28669637f, 0.18722145f, 0.00333155f, 0.07091715f, 
    -0.00630778f, 0.02949583f, 0.15773754f, 0.05023475f, -0.04911170f, -0.10911654f, -0.15594688f, -0.06763774f, 
    -0.39113972f, -0.37052172f, -0.18395154f, -0.04595739f, 0.02026250f, 0.02993380f, 0.05190026f, 0.01735735f, 
    0.11189593f, 0.08925030f, -0.14498734f, -0.09200536f, -0.26113439f, 0.32705602f, 0.03656936f, -0.08914724f, 
    -0.16175593f, -0.15427321f, -0.03126224f, 0.10897096f, 0.03671987f, 0.02526683f, -0.00297423f, -0.00756580f, 
    0.12175711f, 0.33261001f, 0.20582588f, 0.27560338f, 0.09832679f, 0.21094629f, 0.08034389f, 0.10888201f, 
    -0.01943689f, -0.01138537f, -0.04224908f, -0.08808313f, 0.23575127f, 0.31485355f, 0.07691749f, 0.24992192f, 
    0.07199948f, 0.18533067f, 0.23672399f, 0.26396641f, 0.06284237f, -0.05546797f, 0.01149685f, 0.09481593f, 
    -0.07621776f, -0.03032533f, -0.15212023f, -0.07835689f, -0.10829149f, -0.11135446f, -0.09440600f, 0.01813504f, 
    0.06778068f, 0.12136303f, 0.12317155f, 0.09234831f, -0.00741259f, -0.12326155f, -0.00883408f, 0.07378595f, 
    0.02242652f, 0.10470673f, 0.13878289f, 0.06838323f, -0.12319538f, -0.04196069f, -0.03799405f, 0.04649280f, 
    0.23699725f, 0.32806569f, 0.02876402f, 0.06214435f, 0.05554634f, 0.17063826f, 0.03824614f, 0.05642018f, 
    -0.02891559f, -0.05470993f, 0.07796690f, -0.03168691f, 0.38639799f, 0.52696884f, 0.22425579f, 0.18281947f, 
    -0.00899218f, -0.03998051f, 0.05445780f, 0.06314584f, -0.00587990f, 0.04974630f, 0.01663248f, -0.12809543f, 
    0.13814361f, 0.11095914f, 0.03281207f, 0.13297495f, 0.09534078f, 0.08893617f, -0.05667193f, -0.12146588f, 
    0.03356052f, -0.05030223f, -0.16765694f, -0.25751626f, 0.24679361f, -0.05225480f, 0.31736517f, 0.28558660f, 
    0.07603936f, 0.12309963f, -0.00158737f, -0.01446062f, 0.05382992f, 0.24968258f, 0.00457705f, -0.13658333f, 
    -0.03116821f, -0.08137400f, 0.45796677f, 0.28838488f, -0.20898214f, 0.23406777f, -0.06873810f, -0.16780776f, 
    -0.10705809f, -0.13852546f, -0.03428880f, -0.17461684f, -0.23996058f, -0.25266472f, -0.14236800f, -0.07370029f, 
    -0.09596693f, 0.02114373f, 0.01883470f, 0.06500550f, -0.00725313f, 0.11533113f, 0.06432594f, 0.15325312f, 
    -0.08585242f, 0.24289316f, 0.17097087f, -0.04643799f, -0.07767951f, 0.05815402f, 0.08446856f, 0.07407654f, 
    0.08652720f, -0.12485113f, 0.10599605f, 0.02479645f, -0.05450594f, 0.19784668f, 0.23244637f, 0.05969657f, 
    -0.08380926f, 0.04804508f, -0.07714010f, 0.14456861f, 0.02489513f, 0.03907470f, 0.09077442f, 0.05217396f, 
    -0.07127905f, 0.00270219f, 0.13509826f, 0.06103583f, 0.00924320f, 0.01876678f, -0.01478262f, 0.09837900f, 
    -0.17049994f, -0.03990194f, 0.13914400f, -0.05757369f, -0.22200176f, 0.09307366f, 0.30491298f, 0.29927707f, 
    0.14882390f, 0.00086562f, 0.05125486f, 0.08877926f, 0.13768803f, 0.10149928f, -0.00627383f, 0.06841458f, 
    -0.00677238f, -0.09084262f, 0.01022707f, 0.12552704f, -0.05120023f, 0.03664640f, -0.07585839f, 0.07579374f, 
    0.07892365f, 0.01835941f, -0.02519558f, 0.16827393f, -0.36293146f, -0.19684179f, 0.04898387f, 0.00839594f, 
    0.10059798f, 0.18727034f, -0.16613272f, -0.01891564f, -0.04920252f, -0.05015407f, 0.04957271f, -0.10932231f, 
    -0.00987315f, 0.11806663f, 0.03183028f, -0.12612046f, 0.26404569f, 0.10414742f, -0.01149766f, 0.19094577f, 
    -0.02809804f, -0.00926669f, -0.21164909f, -0.09403347f, -0.10031593f, 0.08112634f, 0.06288566f, -0.19264990f, 
    -0.00141968f, 0.17792465f, 0.02830451f, -0.32187557f, 0.15069608f, -0.26608843f, -0.06009334f, 0.02009585f, 
    -0.13702865f, -0.06149873f, 0.01122633f, -0.08104859f, -0.08104965f, 0.31854662f, 0.01189096f, -0.05615854f, 
    0.18349981f, 0.03493262f, 0.04961998f, 0.15976943f, -0.53479433f, 0.05103694f, -0.09634147f, 0.09210943f, 
    -0.08237430f, -0.18733674f, 0.02882996f, 0.11284131f, 0.10073687f, -0.03673836f, -0.02436679f, 0.04074673f, 
    -0.08620628f, -0.00079185f, -0.00278962f, -0.24591151f, 0.06194960f, -0.09570383f, -0.17545336f, -0.08801820f, 
    -0.19320624f, -0.11974714f, -0.02377870f, -0.25926754f, -0.18770573f, 0.09112258f, 0.07835493f, 0.08848552f, 
    0.19970077f, -0.00601882f, 0.06996400f, 0.10096037f, 0.11582922f, 0.05846446f, 0.01623609f, -0.06119703f, 
    0.06291405f, 0.25038901f, 0.06685210f, -0.11051197f, 0.00933602f, -0.17814997f, -0.04344067f, 0.20870470f, 
    -0.00793060f, -0.05288525f, -0.21295398f, 0.06468635f, -0.11636568f, -0.13106632f, -0.03738673f, -0.20523983f, 
    -0.07589287f, -0.18343003f, -0.06130603f, -0.04973567f, 0.05298650f, 0.19198291f, -0.18957359f, -0.18338040f, 
    0.53296429f, 0.26039103f, 0.13283031f, -0.02770728f, 0.08185373f, 0.14038338f, 0.03171550f, 0.23693076f, 
    0.13532744f, 0.03008061f, 0.09022998f, 0.17794549f, -0.27050075f, 0.02595170f, -0.24245849f, 0.18182595f, 
    -0.17780189f, -0.08556828f, 0.06195724f, -0.09000125f, 0.11616824f, 0.01712664f, 0.08724899f, 0.12708534f, 
    0.06256076f, -0.02553910f, 0.03594870f, 0.05826030f, 0.01725794f, 0.01769399f, -0.01511405f, 0.04596580f, 
    -0.06860424f, -0.01223039f, 0.05965848f, -0.01354990f, -0.00383052f, -0.01532421f, 0.05159241f, -0.07462462f, 
    0.01981121f, 0.01485657f, -0.05525240f, 0.03763485f, 0.04795599f, 0.00885220f, -0.07865047f, -0.00163430f, 
    -0.03557795f, -0.06234913f, 0.03985556f, 0.00190614f, 0.05320195f, 0.04482528f, -0.00485687f, 0.05082129f, 
    0.04913658f, 0.03471174f, -0.00790466f, 0.05010823f, 0.00094943f, 0.03025049f, -0.06968262f, 0.02637965f, 
    0.05474549f, -0.00199094f, -0.01782863f, 0.01201351f, 0.01244593f, -0.04210048f, -0.01154714f, -0.00491538f, 
    -0.03012995f, 0.06203064f, -0.06304523f, -0.03707925f, 0.00877654f, 0.05132762f, -0.07172653f, -0.07139905f, 
    0.05939203f, -0.07482342f, -0.00849867f, -0.07713614f, -0.06493066f, 0.05347887f, -0.07706431f, 0.03645374f, 
    -0.07294129f, 0.05206732f, -0.03771685f, 0.05809797f, -0.03617178f, -0.04069933f, 0.05885633f, 0.05036330f, 
    0.03009417f, -0.03357204f, -0.06006314f, -0.02620723f, 0.03616637f, -0.02711810f, -0.07969715f, 0.03561389f, 
    0.03007362f, -0.03803522f, -0.05571365f, -0.04334817f, -0.03079369f, -0.02357679f, -0.01207413f, 0.02432511f, 
    0.00329842f, 0.05554869f, 0.00168085f, -0.07028976f, -0.04182396f, 0.04151018f, -0.05550418f, -0.06173060f, 
    -0.06069938f, 0.02100686f, 0.03660639f, -0.05744291f, 0.00279781f, 0.01743746f, -0.06730006f, 0.00409153f, 
    -0.05560552f, 0.01388718f, 0.00311366f, -0.06620976f, -0.04307803f, 0.04807602f, -0.00601147f, -0.04606668f, 
    -0.01689693f, 0.02572160f, -0.03208457f, -0.05055761f, -0.07928137f, -0.06497892f, -0.03227431f, -0.04753800f, 
    -0.04602282f, -0.06444190f, 0.00541328f, -0.06989232f, -0.07654483f, 0.02694063f, -0.04796137f, -0.03846045f, 
    -0.05319709f, -0.03292901f, -0.04487528f, 0.06185559f, -0.03344887f, 0.01175515f, -0.04873777f, 0.00366465f, 
    0.02035508f, -0.01642615f, 0.01632065f, -0.00237034f, 0.04645430f, 0.05835479f, 0.00325923f, 0.01600237f, 
    0.01394063f, 0.04990856f, -0.03192111f, -0.04453479f, 0.03613057f, -0.07268539f, -0.06393156f, -0.01548065f, 
    -0.07134695f, -0.05851008f, -0.00132823f, -0.02429968f, 0.02742148f, 0.03608329f, 0.01971836f, -0.07207870f, 
    0.02837316f, 0.00863202f, 0.05708176f, -0.02749656f, -0.06931079f, -0.02743523f, -0.04153182f, 0.00100363f, 
    0.00568615f, 0.04159189f, 0.00379201f, -0.03139592f, -0.02979100f, 0.00660931f, 0.00261509f, -0.02853094f, 
    -0.00077795f, 0.02921672f, -0.07860170f, 0.00549328f, -0.00327730f, -0.03570465f, 0.04767066f, 0.02146922f, 
    -0.04912456f, -0.02005954f, 0.05142413f, 0.06113018f, -0.01990172f, -0.01743281f, 0.02084650f, 0.06301183f, 
    0.01813953f, -0.04179953f, 0.03520623f, 0.08513047f, 0.10917237f, 0.06155433f, 0.22860341f, 0.15294991f, 
    0.02603364f, -0.03040901f, 0.07413770f, -0.12061800f, -0.08143189f, 0.32385260f, 0.32481733f, 0.15564117f, 
    -0.00140788f, -0.03549040f, 0.01801836f, 0.07846536f, 0.03164628f, 0.05860333f, 0.09188770f, 0.00516786f, 
    0.07435750f, -0.01735180f, 0.00156226f, 0.06211545f, -0.18888150f, 0.16085380f, 0.00723773f, 0.21435750f, 
    -0.19685015f, 0.10343070f, -0.05985106f, -0.09247243f, -0.17745738f, 0.08014829f, -0.12195209f, -0.16035278f, 
    -0.11984372f, 0.05989390f, -0.10913593f, 0.08631703f, -0.02602760f, 0.02219923f, 0.01003537f, -0.08059973f, 
    -0.13637348f, 0.06895226f, -0.14564146f, -0.08801631f, -0.10916664f, -0.04395597f, -0.06621171f, -0.00125215f, 
    -0.02067104f, -0.00671187f, 0.06643062f, 0.12541617f, 0.12450312f, -0.25939924f, 0.19936182f, 0.27849638f, 
    -0.09284395f, 0.14004546f, -0.09849327f, -0.09241668f, -0.01817581f, -0.07925107f, -0.05477319f, -0.09561064f, 
    -0.32159370f, -0.16032414f, -0.24965566f, 0.03963662f, -0.09619198f, -0.02434188f, -0.08813398f, 0.14569575f, 
    0.08149780f, 0.02347227f, 0.02209797f, 0.09803755f, 0.09025650f, -0.01593661f, 0.03134356f, -0.00725157f, 
    0.08626720f, 0.10599459f, -0.05776280f, -0.12302180f, 0.00682706f, 0.18717454f, 0.10823703f, 0.07393004f, 
    -0.34569603f, -0.17542998f, -0.00510472f, 0.12515275f, 0.09610835f, 0.04753431f, 0.09362455f, 0.18434393f, 
    -0.01429512f, -0.05279808f, 0.12987070f, 0.00181208f, -0.08438974f, -0.01050010f, 0.09517383f, 0.10266458f, 
    0.02773535f, -0.14753318f, 0.05643534f, 0.16931343f, -0.02856248f, 0.00578386f, -0.04407606f, 0.07063656f, 
    -0.17137723f, -0.13002534f, 0.04636444f, 0.23900445f, 0.11433505f, 0.17841481f, 0.03482534f, -0.14315322f, 
    0.07741100f, 0.00950016f, -0.03212557f, -0.05771462f, 0.05962977f, -0.35700938f, -0.07359704f, 0.62817222f, 
    0.14797598f, -0.10729155f, 0.04859208f, 0.02686716f, 0.06606270f, 0.03331223f, -0.04145162f, 0.00367648f, 
    -0.11760309f, 0.31416070f, 0.02715367f, 0.35095733f, -0.04021661f, 0.01115124f, 0.25398675f, 0.21802288f, 
    0.05105698f, -0.03347530f, 0.01369727f, 0.06450326f, 0.44369790f, 0.22862662f, 0.14875329f, 0.15040660f, 
    -0.06766982f, 0.03400939f, -0.08202182f, 0.15446980f, -0.03212541f, 0.16404657f, 0.02461540f, 0.08675167f, 
    -0.22829764f, -0.00247673f, -0.48224765f, 0.27287361f, 0.01240002f, 0.09036991f, 0.19303359f, 0.11570558f, 
    0.05281677f, -0.11578572f, 0.05946101f, 0.15149438f, -0.14757898f, -0.19391465f, -0.15280068f, -0.40401626f, 
    -0.16845246f, -0.07346584f, -0.09682634f, -0.11296900f, -0.00610537f, -0.08091091f, 0.03823569f, 0.04109313f, 
    0.01443447f, -0.13176735f, 0.00132248f, 0.12824889f, 0.08707907f, -0.08433714f, 0.04373619f, 0.11288955f, 
    0.07783007f, 0.17675200f, 0.01641675f, -0.06565553f, 0.16731200f, 0.34815463f, 0.27355725f, 0.01394672f, 
    -0.04236008f, -0.08532371f, 0.01651786f, -0.14827462f, 0.18707699f, -0.08067624f, -0.11850649f, 0.11243322f, 
    -0.19955072f, -0.08668411f, -0.06168204f, 0.04023717f, -0.01621184f, 0.06443820f, -0.05663683f, 0.06465571f, 
    0.06642701f, 0.15648063f, -0.03728401f, 0.09131711f, 0.10052352f, -0.01047228f, 0.06429935f, 0.08972076f, 
    -0.21623373f, 0.10516304f, -0.17571101f, 0.10519724f, 0.03642886f, -0.01493987f, 0.09047303f, 0.05258605f, 
    0.10906629f, 0.18808562f, 0.02644323f, 0.07723911f, 0.04408298f, -0.01012160f, 0.00872973f, -0.22099020f, 
    0.04249495f, 0.04788588f, 0.09669190f, 0.13005304f, 0.06537600f, -0.69836587f, -0.04245263f, 0.15053812f, 
    -0.05384285f, 0.25232580f, -0.11854411f, -0.07128532f, -0.01807563f, 0.01334435f, 0.17027621f, 0.02395322f, 
    -0.23884200f, -0.06671519f, 0.16401041f, 0.25287905f, -0.10857099f, 0.02810171f, 0.04233595f, -0.05563196f, 
    -0.03782118f, 0.02922551f, 0.04784932f, -0.03107096f, -0.25321859f, 0.02567811f, 0.00725813f, 0.27662084f, 
    0.00533725f, 0.04768897f, -0.13508806f, 0.09157460f, -0.13570926f, 0.04525103f, -0.01264287f, -0.01715308f, 
    0.12807286f, -0.25825158f, 0.00734511f, -0.01741856f, 0.19027410f, -0.09920682f, 0.13115670f, 0.00752601f, 
    -0.21988457f, -0.27758166f, -0.12575373f, -0.10181064f, 0.16150603f, 0.24214146f, 0.00296257f, 0.00985912f, 
    0.02228639f, -0.10777654f, -0.04898999f, -0.16036201f, 0.07940017f, 0.07948736f, 0.09042055f, 0.00591518f, 
    -0.10523005f, 0.02925713f, 0.15159562f, 0.08179600f, -0.00039408f, 0.12372629f, 0.06248204f, 0.00197446f, 
    0.04687899f, -0.13458659f, 0.00048717f, -0.03554666f, -0.19901085f, -0.11317976f, -0.12538424f, -0.06959528f, 
    0.13534224f, -0.01672521f, 0.03615600f, -0.01313324f, 0.00358700f, -0.16047703f, 0.02905982f, 0.07261450f, 
    0.00950027f, 0.12847023f, 0.21316725f, -0.05610548f, -0.07867657f, 0.05651285f, 0.03913125f, 0.05764536f, 
    0.08496033f, 0.15183590f, 0.11216602f, 0.01143991f, 0.16965960f, 0.60101742f, 0.12984985f, -0.08787546f, 
    -0.08184353f, 0.01445588f, -0.10381655f, -0.01766155f, -0.10798106f, -0.14828824f, 0.26855144f, -0.00762706f, 
    -0.11741170f, 0.13873945f, -0.21033192f, -0.19240348f, 0.01751684f, 0.04269360f, 0.17952879f, 0.02182059f, 
    0.02743080f, -0.01607074f, -0.01951188f, -0.01302013f, 0.19709687f, 0.04011750f, 0.08069464f, -0.00411622f, 
    0.10608046f, -0.05660865f, 0.00182426f, -0.10979730f, 0.02723385f, -0.05608795f, -0.00625301f, 0.09475525f, 
    0.24273317f, -0.01039345f, -0.02021933f, 0.23916909f, 0.22812699f, -0.10271430f, -0.01904975f, 0.04166929f, 
    -0.12074784f, -0.03484857f, -0.08965894f, 0.11867937f, 0.25004366f, 0.38118860f, -0.15337561f, -0.11696843f, 
    0.04200092f, 0.10049117f, -0.02996988f, 0.01853844f, 0.06978968f, 0.08069021f, 0.24176134f, -0.18549691f, 
    -0.10728816f, 0.27045819f, -0.03813766f, -0.07171997f, -0.07036569f, 0.00869595f, -0.12013952f, -0.07102212f, 
    0.03795327f, 0.08819919f, -0.17755945f, 0.04341463f, -0.40442377f, 0.11655661f, -0.23006928f, -0.04881570f, 
    -0.10935461f, -0.01660252f, -0.08268692f, -0.20910959f, -0.10038510f, 0.07928810f, -0.09032648f, 0.05463200f, 
    -0.19812383f, -0.17395522f, -0.09906133f, -0.07574293f, -0.01037422f, -0.00361829f, 0.09800363f, -0.18855008f, 
    0.08461279f, 0.13267964f, 0.07939182f, -0.13788578f, -0.23994304f, 0.25885430f, 0.19121043f, 0.08849913f, 
    -0.08935628f, -0.11078089f, 0.26220447f, -0.02895428f, -0.10178061f, -0.10179268f, 0.03671240f, 0.05807437f, 
    -0.13376001f, 0.00097332f, 0.06644315f, 0.28931332f, -0.11556228f, 0.09700482f, -0.09783044f, 0.00969446f, 
    -0.01071880f, 0.03320814f, 0.08262353f, -0.06458851f, -0.00642143f, 0.18679270f, 0.19333482f, 0.30748999f, 
    -0.01019987f, 0.11556889f, 0.04865033f, 0.21272746f, -0.11348120f, 0.00985871f, -0.04772706f, 0.03961044f, 
    0.14539632f, -0.02748770f, 0.08438803f, 0.01212594f, -0.03678735f, -0.10558072f, -0.03267335f, 0.11441568f, 
    -0.08513013f, -0.04399197f, 0.07117756f, -0.32174060f, 0.26613426f, 0.14716113f, 0.11598200f, 0.16246252f, 
    0.00450136f, -0.02913511f, -0.01283802f, -0.03485951f, -0.09950001f, 0.02472670f, 0.21109498f, 0.11710706f, 
    -0.16576499f, -0.03748202f, 0.01870337f, 0.16747643f, -0.02474445f, -0.03228156f, -0.04997443f, 0.08789511f, 
    0.00873962f, -0.00089425f, -0.13416888f, -0.13047710f, 0.25911808f, 0.09612142f, 0.08441498f, 0.32647067f, 
    -0.07842977f, -0.09363522f, 0.01856293f, -0.00809892f, -0.08386172f, -0.04133879f, -0.07712681f, 0.01705652f, 
    0.00410385f, 0.05393087f, 0.15526900f, 0.17465280f, -0.09239265f, -0.03744499f, 0.06249307f, -0.01300184f, 
    0.05915763f, 0.18756847f, -0.08071621f, -0.02417860f, 0.35541454f, 0.41327479f, 0.30061328f, 0.21159653f, 
    0.15749685f, 0.09703901f, 0.13185278f, 0.09425598f, 0.00150893f, 0.00793151f, 0.00103981f, -0.04574910f, 
    -0.43424782f, -0.19665396f, 0.32881573f, 0.32290977f, -0.00628106f, -0.02582095f, 0.10876493f, -0.07634140f, 
    -0.18265735f, 0.07073479f, -0.04944686f, -0.15181793f, -0.15558703f, -0.17517669f, -0.01518706f, -0.08794642f, 
    0.04238370f, 0.12735052f, 0.04288897f, -0.02335426f, -0.16153841f, -0.04748612f, -0.07511025f, 0.07523081f, 
    -0.18385006f, 0.00641468f, -0.10967927f, -0.21365246f, -0.31716627f, 0.05621349f, 0.06053152f, -0.07544090f, 
    -0.40664279f, -0.17398289f, -0.12106735f, -0.03902125f, -0.05493572f, -0.07301755f, 0.01565935f, -0.07666141f, 
    0.11587573f, 0.10207938f, -0.06690805f, 0.14888148f, -0.00552897f, 0.08927087f, 0.25172600f, 0.17943935f, 
    -0.02929879f, 0.08284403f, 0.05988534f, -0.13596459f, -0.43829325f, -0.23646346f, 0.07018513f, 0.16051084f, 
    -0.61106086f, -0.04665613f, -0.19288582f, 0.11935923f, -0.00597891f, -0.07318595f, 0.09475864f, -0.02927383f, 
    -0.00297028f, -0.00947059f, 0.10815672f, 0.12497913f, -0.29693228f, -0.09392614f, -0.26609120f, -0.08948245f, 
    0.03179802f, 0.12888555f, 0.03768210f, 0.12873024f, 0.05124824f, 0.04984498f, 0.02395933f, 0.01494542f, 
    0.10720134f, -0.11919349f, -0.30589181f, -0.05840227f, 0.17041400f, -0.28017846f, -0.02514075f, 0.16266075f, 
    -0.01688317f, -0.01135466f, 0.05695800f, 0.05460143f, 0.10792669f, 0.02778172f, 0.05987708f, 0.10235284f, 
    -0.27478588f, -0.09504113f, 0.07228108f, -0.00303424f, -0.29131544f, -0.12902667f, -0.13497354f, -0.32723010f, 
    -0.03821491f, -0.07159210f, -0.10032829f, -0.00597146f, 0.20891196f, 0.21454808f, 0.28245685f, 0.00122348f, 
    0.02112657f, 0.02278231f, -0.02995382f, -0.27827165f, 0.08684683f, 0.00012952f, -0.07072894f, -0.05480997f, 
    0.04070391f, 0.01374215f, -0.03881543f, 0.11338979f, -0.07014447f, 0.06449411f, -0.01893070f, -0.01494286f, 
    0.12408034f, 0.01357810f, -0.01412631f, 0.05114885f, 0.07687080f, 0.10031970f, 0.13013884f, 0.09421013f, 
    0.17544486f, 0.02026995f, 0.09172986f, 0.04544726f, -0.04734851f, -0.05154869f, 0.12423904f, 0.08602354f, 
    0.11973277f, 0.07076701f, 0.26438808f, 0.12698968f, 0.08218659f, -0.02572597f, -0.09102464f, -0.24357559f, 
    -0.08297529f, -0.02056808f, 0.08417423f, -0.02297790f, 0.16342428f, -0.08976100f, 0.02247562f, -0.07975955f, 
    0.02879282f, -0.15000752f, 0.08875912f, -0.19965595f, 0.06558425f, -0.08577910f, 0.09440267f, 0.16452126f, 
    -0.06390095f, 0.05149949f, 0.15794747f, 0.23426965f, -0.04212363f, -0.09212644f, -0.01711943f, -0.00668960f, 
    -0.05103466f, 0.17880441f, -0.16690695f, 0.09126905f, 0.22973405f, 0.10155943f, 0.05945938f, -0.02285821f, 
    0.14074406f, -0.02796001f, -0.03813880f, -0.00619708f, 0.02824148f, 0.14499940f, 0.26664454f, 0.11439498f, 
    -0.15824653f, 0.03275187f, -0.26205453f, 0.06344562f, -0.06191215f, -0.21656011f, -0.27582023f, -0.22334361f, 
    0.29011205f, -0.04164987f, 0.06441748f, -0.21827123f, 0.15970500f, 0.14651573f, 0.11857236f, 0.06294040f, 
    0.18283461f, -0.00272293f, 0.09443560f, 0.03506054f, -0.02998503f, 0.02878730f, -0.12459099f, -0.09194303f, 
    -0.12986344f, 0.16711515f, -0.09962081f, -0.09041604f, -0.13322392f, -0.03379770f, 0.00755894f, 0.10731986f, 
    0.20050764f, -0.03151551f, 0.13778295f, 0.01072215f, -0.02648555f, 0.07167956f, 0.15226798f, -0.03408233f, 
    -0.00173580f, -0.08789774f, 0.02965027f, 0.14634825f, 0.03676141f, 0.05222940f, -0.06542543f, 0.11355594f, 
    -0.01904269f, -0.36795127f, 0.12959236f, -0.14758189f, 0.04596381f, -0.12540828f, 0.07336103f, 0.05646520f, 
    0.09400140f, 0.10114486f, 0.01669522f, -0.01558025f, 0.28440368f, -0.19382842f, 0.13353553f, 0.16953819f, 
    -0.02557400f, -0.08900510f, 0.07970148f, 0.03507485f, 0.16837555f, 0.03027381f, 0.20138566f, 0.15668091f, 
    -0.02610546f, 0.03022024f, -0.11817631f, 0.14198712f, 0.06421731f, -0.00518892f, -0.05027471f, 0.08504990f, 
    0.09853332f, 0.06598121f, 0.22614542f, 0.14600891f, 0.12621912f, -0.48759922f, 0.04823608f, -0.02418204f, 
    0.01620556f, 0.00405278f, -0.01062287f, 0.11998095f, -0.04140302f, 0.02385995f, -0.03619838f, -0.05255278f, 
    0.14538300f, 0.03034182f, 0.20266666f, -0.25352535f, -0.05889425f, -0.00667673f, -0.03470706f, 0.00740161f, 
    0.04135665f, 0.02688616f, 0.04804225f, 0.08801886f, 0.16191269f, 0.07759007f, 0.21024331f, -0.16780539f, 
    -0.02017054f, 0.04850607f, -0.05068386f, -0.17344846f, 0.08354955f, -0.04685519f, 0.08256575f, 0.04383086f, 
    -0.02067361f, -0.11310243f, 0.05547566f, -0.02896781f, 0.05107753f, 0.03530930f, 0.06744914f, -0.06802712f, 
    0.01892314f, -0.10135300f, -0.13551427f, 0.05506809f, -0.41725343f, 0.09365499f, -0.08046222f, -0.10809512f, 
    -0.03591648f, -0.01704798f, 0.01311603f, 0.07120582f, 0.10155337f, 0.00387386f, 0.06009679f, 0.00243661f, 
    0.31774381f, 0.14258501f, 0.11184683f, -0.26430377f, 0.08931805f, -0.10210823f, -0.02891807f, 0.11278456f, 
    0.01668477f, 0.00487278f, 0.02429309f, 0.01416487f, -0.28464448f, -0.00348417f, -0.20252649f, -0.21519478f, 
    0.05470395f, 0.08298102f, 0.09916098f, -0.05097413f, 0.06855898f, -0.03870926f, 0.10290473f, 0.03389958f, 
    0.23730516f, -0.13564543f, 0.07200455f, -0.23810585f, 0.02637635f, -0.06811682f, -0.05675592f, -0.04738089f, 
    0.15403573f, -0.12016556f, -0.04387500f, -0.02680296f, -0.45865729f, 0.17750381f, -0.23671831f, -0.10711242f, 
    0.05806054f, 0.08842336f, -0.10921983f, -0.21772246f, 0.08539141f, -0.12198338f, 0.06602114f, 0.00920507f, 
    0.33865473f, 0.16067080f, 0.25677395f, -0.21968786f, 0.30904713f, 0.00757879f, 0.08744988f, 0.21787494f, 
    0.10681190f, 0.10160097f, -0.11581849f, 0.01321613f, 0.10215740f, 0.08594240f, -0.02342373f, 0.06628022f, 
    0.05394682f, 0.00597434f, 0.01320414f, -0.02088103f, 0.05514995f, 0.02207276f, 0.05849587f, 0.08218095f, 
    0.20097685f, 0.07541130f, 0.10932838f, -0.00554933f, 0.18503687f, 0.02086282f, -0.03551687f, -0.05609171f, 
    0.10271993f, -0.04165288f, -0.11538220f, 0.12457068f, -0.07002472f, -0.38953760f, -0.13088982f, 0.01508056f, 
    -0.09336783f, 0.20621112f, -0.07459939f, 0.07392314f, 0.08272295f, -0.14827543f, 0.22488020f, 0.14387359f, 
    -0.08437823f, -0.09886967f, 0.13937706f, -0.12009342f, 0.04892569f, -0.01386035f, -0.04739663f, -0.04023543f, 
    -0.28447267f, -0.07272328f, -0.17271785f, -0.11431997f, 0.20647565f, -0.09569119f, 0.00440121f, -0.23727089f, 
    -0.06476105f, -0.05541242f, 0.10439378f, -0.03385149f, 0.10395574f, 0.01756897f, -0.04853304f, -0.01410538f, 
    -0.21017227f, -0.10012731f, 0.16212837f, 0.11215208f, -0.06470138f, -0.14829695f, -0.15532868f, -0.12683474f, 
    0.05573323f, -0.14676741f, -0.01905227f, 0.01450560f, 0.28386673f, 0.62105489f, 0.24309178f, -0.13503352f, 
    0.13639921f, -0.06342982f, 0.02827801f, 0.18478040f, -0.00845719f, -0.10118856f, -0.03287728f, 0.04194028f, 
    0.15856200f, 0.01353129f, 0.11607283f, -0.03513545f, 0.35615751f, 0.16403404f, 0.03941336f, 0.11068244f, 
    -0.04710949f, -0.06515887f, -0.01470968f, 0.09105621f, 0.35658592f, -0.12282389f, 0.03251882f, -0.15192074f, 
    0.24872205f, 0.22579384f, 0.28260422f, 0.04223170f, 0.02764113f, -0.01807415f, -0.02967326f, 0.07961003f, 
    -0.39660606f, -0.09326351f, -0.31395811f, 0.03091338f, 0.09959958f, -0.05447126f, -0.05796635f, -0.08348668f, 
    0.08712588f, 0.12888445f, 0.13410844f, 0.02656885f, -0.12306657f, -0.39664900f, -0.02899977f, -0.05948659f, 
    -0.08985942f, 0.00273287f, -0.17600791f, 0.00599531f, 0.10418391f, -0.04844007f, -0.06187933f, 0.21208596f, 
    -0.04162939f, -0.04087023f, -0.02761748f, 0.19271508f, 0.15404706f, 0.24933623f, -0.02024158f, -0.07660507f, 
    0.04941330f, -0.07931356f, 0.12566665f, 0.01843575f, 0.09755663f, 0.15305208f, 0.06522868f, 0.04458085f, 
    0.13755110f, -0.05691091f, -0.11484019f, 0.24986279f, -0.04795152f, 0.03833713f, 0.18639126f, 0.06577663f, 
    -0.02423480f, -0.08360474f, -0.10947669f, 0.06347898f, 0.14111121f, 0.26283258f, 0.02170541f, 0.03886584f, 
    0.16178149f, -0.13327062f, -0.22421114f, -0.06270031f, 0.17114165f, -0.38688225f, -0.01774991f, 0.30786565f, 
    0.07976768f, 0.22580394f, 0.10633226f, 0.10128795f, 0.06118361f, 0.24137329f, 0.13202758f, 0.06021692f, 
    -0.02598984f, -0.05017385f, -0.24934055f, 0.28362569f, -0.01227872f, 0.30408525f, -0.03391343f, -0.12131348f, 
    0.18005896f, 0.02417234f, 0.00538635f, 0.10388508f, -0.13793126f, -0.13392295f, 0.00815647f, -0.10111680f, 
    -0.17000049f, -0.15225537f, -0.19596285f, -0.09131313f, -0.01014504f, 0.08529251f, 0.01585861f, 0.24119905f, 
    0.01725249f, -0.03062671f, 0.00747189f, -0.07503381f, 0.06815749f, 0.14643233f, -0.00573523f, -0.10897439f, 
    0.10149503f, -0.15431850f, -0.09973010f, 0.14099494f, -0.07610812f, -0.25863972f, -0.17731124f, -0.03701419f, 
    -0.09375931f, -0.07581893f, -0.02249750f, 0.06775150f, 0.11140720f, 0.08488555f, 0.11473454f, -0.08010034f, 
    -0.02736166f, 0.15448774f, 0.05309216f, 0.10816073f, 0.11632826f, -0.05786031f, 0.30439633f, -0.12390064f, 
    -0.01739730f, -0.08370399f, 0.07944366f, -0.06385098f, -0.11233936f, 0.00704071f, -0.37015131f, -0.06410838f, 
    0.04059593f, -0.06281989f, -0.05179792f, -0.13295451f, 0.16128878f, 0.11493939f, 0.04717762f, 0.13437805f, 
    0.09214496f, 0.01061360f, 0.14782336f, 0.03636957f, -0.03957321f, -0.12014420f, -0.07621907f, -0.01103357f, 
    0.05684631f, 0.03215584f, -0.04972745f, 0.11764151f, 0.05182065f, 0.44644946f, 0.00151028f, -0.15093909f, 
    -0.12934372f, -0.22943728f, -0.05083929f, 0.14815590f, -0.00552521f, -0.03580142f, -0.14491971f, -0.04305748f, 
    0.25342497f, 0.18573523f, 0.29260996f, 0.00968639f, 0.06456338f, -0.06569830f, 0.18891369f, -0.11049669f, 
    -0.05133279f, -0.08823662f, -0.04306894f, 0.09050717f, 0.00436146f, 0.01515909f, -0.02901088f, 0.09373575f, 
    0.02614084f, 0.10881285f, 0.06148436f, 0.01174070f, 0.10164233f, -0.09038997f, -0.00518794f, 0.10792632f, 
    0.18123884f, 0.09707422f, 0.09504357f, -0.05197348f, -0.05999507f, 0.00846659f, -0.04048283f, -0.08646405f, 
    -0.00802434f, 0.07085264f, -0.01508720f, 0.12256423f, -0.30786768f, 0.02334836f, -0.32266062f, -0.18572180f, 
    -0.11796180f, -0.15540469f, -0.06161554f, 0.00547259f, -0.14974798f, 0.12734665f, 0.07016124f, -0.05611754f, 
    0.07509629f, -0.00903072f, -0.04762886f, -0.13540344f, -0.31352627f, -0.10557725f, -0.19475953f, -0.17562240f, 
    -0.08401211f, -0.17259018f, -0.09677821f, 0.01186104f, 0.04792624f, 0.30083138f, 0.15119933f, 0.03979526f, 
    0.13854234f, 0.10859597f, 0.11519691f, 0.13077177f, -0.17944752f, 0.15814777f, 0.19487123f, 0.01232261f, 
    -0.02420930f, -0.05138131f, -0.14505649f, -0.07761137f, 0.13019466f, 0.16367233f, -0.00491040f, 0.17572699f, 
    0.06944504f, -0.05581231f, -0.01912027f, 0.01412465f, -0.39220250f, -0.23843725f, -0.08877637f, -0.05095459f, 
    0.01633098f, -0.04806888f, 0.06803578f, 0.01442564f, 0.00158249f, 0.12772037f, 0.05405757f, -0.06692491f, 
    0.50704217f, -0.05734872f, 0.45990798f, -0.00937187f, 0.23218925f, 0.23109610f, 0.13002659f, 0.16958733f, 
    0.06675347f, 0.09670037f, 0.12026117f, 0.14754012f, -0.07052791f, 0.14624229f, 0.02495452f, 0.07728282f, 
    -0.01122917f, -0.13460407f, -0.05642438f, 0.02322579f, -0.03141959f, -0.03213891f, 0.00850129f, 0.17364863f, 
    0.49760693f, 0.16990094f, 0.06598710f, 0.25990826f, 0.13367946f, -0.00538290f, -0.15173821f, -0.29494658f, 
    -0.06109909f, 0.07453091f, -0.09184945f, 0.10279182f, 0.20454828f, 0.02282611f, -0.19236100f, -0.06827344f, 
    0.06919570f, 0.17096390f, 0.02846933f, 0.04966405f, 0.02222345f, -0.17141464f, 0.11425056f, -0.16349272f, 
    -0.18345886f, 0.31348878f, 0.24023254f, 0.08187317f, -0.05197036f, -0.11433687f, -0.04821200f, -0.08372252f, 
    -0.01501355f, -0.05389898f, -0.00763150f, 0.14603123f, -0.26065755f, 0.02920359f, 0.17502524f, 0.01988667f, 
    -0.07709620f, 0.05156287f, 0.01581672f, -0.02791017f, -0.01195062f, 0.01611695f, -0.11561450f, 0.06185833f, 
    -0.25625736f, -0.30315426f, -0.18242690f, -0.09565978f, 0.01557019f, 0.06143406f, -0.02483467f, -0.12376641f, 
    -0.06233314f, -0.01274343f, -0.11818015f, -0.06764615f, -0.37512249f, -0.03237538f, 0.16039774f, -0.06034304f, 
    -0.06663099f, -0.10975614f, 0.10125717f, -0.01504226f, -0.01309154f, 0.01661889f, 0.01751869f, 0.04547388f, 
    -0.11884508f, 0.19280136f, 0.41548476f, 0.20832482f, 0.00728645f, 0.19462845f, -0.03522867f, 0.05828866f, 
    0.13227347f, 0.02092268f, -0.00386187f, -0.02074145f, 0.25728238f, 0.32748023f, 0.32361108f, 0.42609411f, 
    0.06872033f, 0.07258565f, 0.21642262f, 0.24734184f, 0.01904850f, 0.05713360f, -0.05150019f, 0.05096827f, 
    -0.00683033f, -0.11567257f, -0.11056088f, -0.06565616f, 0.00180595f, 0.02366708f, -0.07991996f, 0.13104346f, 
    0.05275931f, -0.08664054f, 0.01927624f, -0.15686005f, 0.14611022f, 0.06450243f, 0.13177206f, -0.03904784f, 
    0.02533134f, 0.11084073f, 0.04120360f, 0.02884668f, 0.08790283f, -0.01599261f, 0.07588628f, 0.21198648f, 
    0.19497365f, 0.29166800f, 0.20209642f, 0.17506722f, -0.10909151f, 0.10453166f, -0.06154409f, 0.23470022f, 
    0.01602397f, 0.02755062f, -0.00491779f, -0.01516039f, 0.38266262f, 0.35064811f, 0.07279435f, -0.14713955f, 
    -0.01978046f, -0.09597555f, 0.03614977f, 0.16211088f, -0.00866664f, -0.05662041f, -0.01248982f, -0.01372122f, 
    0.06315653f, 0.07210324f, 0.17005511f, 0.06709795f, 0.15742145f, 0.09820776f, 0.00869668f, -0.11807167f, 
    0.08156550f, -0.00471051f, 0.00385588f, -0.08846489f, 0.38568178f, 0.31277430f, 0.15443376f, 0.08517168f, 
    0.08811127f, -0.05639954f, 0.03321492f, -0.05953039f, -0.07417483f, -0.07629107f, -0.03324712f, -0.04598696f, 
    0.01557703f, -0.08083859f, 0.50748235f, 0.00510563f, -0.06258883f, -0.07771141f, -0.12130295f, -0.16574027f, 
    0.02400248f, -0.02066628f, -0.06038708f, -0.03311064f, -0.34353834f, -0.35148403f, -0.21437424f, -0.06452890f, 
    0.01323710f, -0.01962817f, 0.03205300f, 0.01290638f, -0.09191675f, 0.02879693f, -0.15104152f, 0.03387292f, 
    0.31831235f, 0.14026870f, 0.20306861f, -0.04995566f, 0.01356130f, 0.04120287f, -0.05123480f, 0.12960482f, 
    -0.00326087f, 0.06232397f, -0.09018949f, 0.15390030f, 0.30434209f, 0.20034155f, 0.02885925f, -0.11508162f, 
    -0.03081770f, 0.02116937f, -0.05746075f, 0.01984289f, 0.02238100f, -0.11707488f, 0.01241387f, 0.05514048f, 
    -0.00995834f, -0.06236973f, 0.16096452f, 0.07897045f, 0.10144895f, -0.04233264f, 0.05907514f, -0.00099185f, 
    0.08360476f, 0.02600288f, -0.05204359f, 0.13204852f, 0.20730087f, -0.28575099f, 0.25626749f, 0.47977218f, 
    -0.26213217f, -0.07202996f, 0.10314946f, -0.03618485f, -0.13119085f, -0.03458987f, -0.01429325f, 0.02948328f, 
    -0.13097234f, -0.26557663f, -0.14823450f, 0.14865628f, 0.14471914f, -0.06653405f, 0.13182205f, -0.17942064f, 
    0.06286260f, 0.04985400f, 0.07631182f, -0.11589304f, -0.36403748f, -0.40026763f, -0.11552229f, -0.24827780f, 
    0.12593620f, -0.07710957f, -0.05412913f, 0.19429690f, -0.12365693f, -0.09286273f, -0.01391455f, 0.05429227f, 
    0.27621236f, 0.01244605f, 0.29520997f, 0.13722968f, -0.08075968f, 0.16222528f, 0.09654610f, -0.03775219f, 
    -0.07501529f, -0.19571200f, 0.06438664f, -0.13780883f, 0.00871447f, -0.00965282f, 0.01378371f, 0.11206134f, 
    -0.14486673f, -0.10837059f, 0.04149416f, 0.22168139f, 0.00404667f, -0.13085218f, -0.00567463f, 0.04354440f, 
    0.12283537f, -0.36866340f, -0.27315885f, -0.24763244f, 0.09441073f, 0.01126098f, 0.05795162f, -0.03419851f, 
    -0.16039863f, -0.07233392f, -0.12292792f, -0.18403196f, 0.34403017f, 0.18441096f, 0.29247737f, 0.08448386f, 
    -0.11071441f, 0.18811452f, -0.00393905f, -0.06347872f, 0.13442151f, 0.08885252f, -0.05642451f, -0.01444714f, 
    0.10319821f, 0.19004910f, 0.14456101f, -0.24367227f, -0.23469096f, 0.00696725f, -0.05112592f, 0.04245276f, 
    -0.03196824f, -0.00506943f, 0.10818871f, -0.00518282f, 0.07004966f, 0.60688370f, 0.22405331f, -0.31957927f, 
    -0.12027967f, -0.00455508f, -0.06182221f, 0.06983793f, -0.04575440f, -0.06904101f, 0.06350136f, 0.01821141f, 
    0.19097796f, -0.08734736f, 0.31639656f, -0.01518714f, -0.15061858f, 0.08357911f, -0.06663199f, 0.03987918f, 
    -0.07886830f, 0.17360857f, -0.05830871f, -0.05852177f, 0.13960010f, 0.28296205f, 0.09869014f, -0.06743500f, 
    0.05746416f, 0.14158989f, -0.01896490f, 0.12860489f, -0.12836887f, -0.29687726f, 0.06051297f, -0.03882945f, 
    -0.21314913f, 0.17491665f, 0.11578280f, -0.06320465f, -0.03289966f, 0.01202000f, 0.20333248f, -0.22847882f, 
    -0.00597772f, 0.06416580f, -0.13865636f, 0.05796650f, -0.08062332f, -0.32426527f, -0.03629200f, -0.03687663f, 
    0.13378854f, 0.14242533f, -0.06344179f, 0.10564124f, -0.08730024f, 0.16138248f, -0.07053661f, 0.07182320f, 
    -0.06747486f, -0.18165514f, 0.05862645f, -0.04541820f, -0.10296924f, -0.20520577f, -0.02722322f, 0.16410066f, 
    -0.17322597f, 0.09033948f, 0.31896624f, -0.08670545f, 0.32077992f, 0.41045609f, 0.35074317f, 0.15466368f, 
    -0.00821454f, -0.10275834f, 0.10974944f, 0.02489413f, -0.09034656f, 0.29388514f, -0.14994545f, -0.03091954f, 
    0.34413323f, -0.07633012f, -0.22836806f, 0.03013682f, -0.03787516f, 0.32014385f, 0.22180507f, 0.07722463f, 
    -0.02455184f, 0.01926266f, 0.26986092f, 0.20002589f, 0.44105783f, 0.08204153f, -0.03321159f, -0.00056335f, 
    0.09412211f, -0.01985529f, -0.06075552f, 0.04049066f, -0.10319628f, 0.08176699f, 0.37825525f, -0.04929842f, 
    0.04621132f, 0.06707451f, 0.05591622f, -0.01066657f, -0.03732445f, 0.02056449f, -0.06463947f, 0.07813814f, 
    0.04415108f, 0.05203024f, 0.41995525f, 0.06441516f, 0.40204126f, 0.35709172f, -0.19093105f, -0.22098285f, 
    0.07128386f, 0.22765598f, -0.26838747f, 0.13031191f, 0.04963873f, 0.13983107f, 0.01587731f, -0.07076752f, 
    0.12981917f, -0.23283203f, -0.25790021f, -0.10991981f, -0.26800472f, -0.19973831f, 0.08543129f, 0.08718292f, 
    -0.11255637f, 0.03024434f, -0.04566955f, -0.00048817f, -0.42807338f, -0.58028388f, -0.45196715f, -0.18321913f, 
    0.00358035f, -0.25988454f, -0.06595515f, 0.04546675f, -0.20767705f, -0.06737330f, -0.00757426f, -0.02915786f, 
    0.10970940f, 0.06498246f, 0.02798694f, -0.04856627f, 0.08473397f, -0.18232794f, 0.03969399f, 0.04342628f, 
    -0.08794408f, -0.06041908f, 0.04276967f, -0.04095645f, 0.06488302f, 0.30835122f, 0.11651607f, 0.04502210f, 
    0.02779550f, 0.08887801f, -0.05724527f, 0.06814598f, 0.09925979f, 0.27259803f, 0.01693233f, -0.12482377f, 
    -0.24868184f, -0.11930183f, -0.35843801f, -0.20728649f, -0.20355949f, 0.02661886f, 0.18853837f, -0.01745434f, 
    0.00804551f, -0.01908834f, -0.15071422f, 0.11434890f, -0.00824836f, 0.04093669f, 0.00709141f, 0.00224328f, 
    -0.09402004f, 0.22782604f, 0.03094924f, 0.19495764f, -0.00814894f, 0.04671795f, 0.02739128f, 0.11680519f, 
    -0.04330924f, 0.06554822f, -0.10221943f, -0.05954301f, -0.01414909f, 0.12582457f, -0.03828321f, 0.16065295f, 
    -0.09304120f, 0.08572106f, 0.39355531f, 0.18892474f, 0.22572805f, -0.09629403f, -0.04848843f, 0.30152446f, 
    -0.12919146f, 0.00461758f, 0.23914796f, 0.17392142f, -0.11257967f, -0.17247981f, 0.06461498f, 0.02127222f, 
    0.01342572f, 0.09610423f, -0.45298430f, -0.10721412f, -0.07573507f, 0.05261418f, 0.29390225f, 0.09256610f, 
    0.11131934f, 0.24402158f, -0.12358128f, 0.19434434f, -0.01801781f, 0.04783209f, -0.08424921f, -0.09643125f, 
    0.08965162f, -0.04539374f, -0.03859096f, 0.02208286f, -0.05281778f, 0.01561902f, 0.00857242f, -0.10372607f, 
    0.23239043f, -0.16646352f, -0.06719679f, -0.03396158f, -0.04587039f, -0.00655421f, 0.00815690f, 0.23666598f, 
    -0.15135136f, 0.07855131f, 0.17704375f, -0.01273720f, 0.02476508f, 0.30329904f, 0.02665527f, -0.16530314f, 
    0.09372805f, 0.02616901f, 0.15872775f, -0.07417297f, 0.02255830f, 0.15394081f, -0.01796556f, -0.07682230f, 
    0.20244363f, 0.33660895f, -0.15455015f, -0.09709063f, 0.14312707f, 0.15621577f, 0.09462077f, 0.21255663f, 
    0.27567551f, -0.08201382f, -0.05751300f, 0.02827816f, -0.16075000f, 0.41353804f, -0.33547431f, -0.04595563f, 
    0.03007799f, 0.16354160f, 0.10688651f, -0.04623971f, 0.02569407f, -0.06223594f, 0.14033438f, 0.04904333f, 
    0.10925145f, 0.10966826f, 0.02078681f, -0.08074771f, -0.01397478f, -0.07938410f, 0.02654860f, 0.04031885f, 
    -0.04144695f, 0.16741778f, 0.09882081f, -0.16643032f, 0.12727655f, 0.12801887f, -0.41986677f, 0.12007704f, 
    -0.09019583f, -0.06404224f, 0.06005665f, 0.02206468f, 0.01325025f, -0.15256518f, -0.06615081f, -0.12572233f, 
    0.23591456f, 0.14368239f, -0.32459557f, 0.20444375f, -0.13344631f, 0.10602011f, 0.10007734f, -0.00646255f, 
    -0.09216439f, -0.06408929f, 0.09159148f, -0.10525233f, -0.22770241f, 0.22612567f, -0.08694718f, 0.06545740f, 
    -0.19674243f, -0.06287857f, -0.26240593f, -0.06974751f, 0.00770422f, 0.07361358f, -0.00954965f, -0.07837585f, 
    0.28273353f, 0.10646453f, 0.18209158f, 0.05646280f, -0.10031285f, -0.09488874f, 0.07504365f, 0.26498568f, 
    -0.09266627f, -0.03389066f, 0.03893455f, -0.08500133f, 0.16448796f, 0.09328312f, 0.05862367f, 0.10709331f, 
    -0.05171135f, -0.05586406f, 0.01891963f, -0.06887081f, -0.03853878f, 0.36074620f, 0.08739030f, -0.15407084f, 
    0.01458075f, -0.00720408f, -0.21900737f, -0.27331308f, 0.02416468f, -0.11694051f, 0.02012505f, 0.02342350f, 
    0.04086110f, 0.05430372f, -0.21490008f, -0.07124414f, 0.11026571f, 0.13827492f, -0.08264049f, 0.35175648f, 
    -0.06887135f, 0.13262969f, 0.19202909f, 0.00972848f, -0.04519224f, -0.01032898f, -0.12661801f, 0.00294289f, 
    0.01232724f, 0.14221670f, -0.18097542f, -0.01007193f, 0.08098404f, -0.09339512f, 0.00529716f, -0.01935900f, 
    -0.02012817f, 0.06358512f, 0.18042694f, -0.03900283f, 0.08969249f, 0.02648565f, 0.10233369f, -0.25164112f, 
    0.01295638f, 0.06230924f, 0.02645303f, -0.06693377f, -0.12182229f, -0.15376121f, 0.05619644f, -0.08849248f, 
    -0.35889232f, -0.06950030f, 0.24146774f, 0.07831100f, 0.09216481f, 0.01769683f, 0.13667968f, 0.14843440f, 
    -0.30175689f, 0.04095889f, -0.09567987f, 0.21768598f, 0.09180554f, 0.15301979f, 0.07016292f, 0.03690458f, 
    -0.02457283f, 0.07665339f, 0.06421097f, -0.13432457f, -0.07308522f, 0.00374230f, -0.05526977f, 0.06867762f, 
    -0.04957614f, -0.03672012f, 0.12899606f, -0.01420343f, 0.08579806f, 0.13773297f, -0.00213551f, -0.12508218f, 
    -0.00489284f, 0.08298831f, 0.08450485f, 0.16599426f, -0.12813421f, -0.16127649f, -0.00286756f, 0.21053897f, 
    0.06360640f, 0.02521388f, 0.08190094f, 0.07261725f, 0.03134223f, 0.08833431f, 0.08333003f, -0.08433373f, 
    0.14500980f, 0.10101620f, -0.12836356f, 0.09809850f, 0.05164858f, 0.02483124f, 0.27959162f, -0.12441080f, 
    -0.03342814f, -0.03021487f, 0.23751582f, 0.08360789f, -0.26692054f, 0.06354112f, -0.41751701f, -0.02673858f, 
    0.26590031f, -0.03682652f, 0.05644123f, 0.03641123f, 0.09657095f, 0.06792163f, 0.09611952f, 0.19225073f, 
    0.19130805f, -0.14969845f, 0.06369609f, -0.23694646f, 0.03062395f, -0.05952079f, 0.00552390f, 0.16687715f, 
    0.04628187f, 0.13446511f, 0.13234702f, 0.07193018f, -0.07499348f, 0.80628139f, -0.17929158f, 0.02649967f, 
    0.05353909f, -0.21070287f, 0.02240050f, -0.12759931f, -0.01784527f, 0.03253895f, -0.16775389f, -0.02047142f, 
    -0.10154580f, -0.21667737f, -0.09457759f, 0.01402740f, -0.01371769f, -0.11480777f, 0.02628591f, -0.06435669f, 
    -0.13199140f, -0.04220748f, 0.03396504f, -0.07568743f, -0.07133155f, -0.24111544f, -0.24628204f, 0.05270778f, 
    0.01428435f, -0.09172154f, 0.00226345f, 0.05798313f, -0.01665354f, -0.03666648f, -0.10939272f, 0.01487493f, 
    0.04980584f, 0.21519347f, 0.20828405f, -0.16179042f, 0.05388574f, 0.00205058f, -0.13654746f, -0.00576436f, 
    0.04404664f, -0.00300358f, 0.08336428f, -0.05663545f, -0.03165332f, 0.04701959f, -0.01124269f, 0.02140863f, 
    0.05351827f, 0.09700499f, 0.10366332f, 0.07905508f, -0.00793878f, 0.06512718f, 0.02656769f, 0.04098068f, 
    -0.30521101f, -0.37255907f, -0.28630093f, 0.09712337f, -0.26576784f, 0.03647419f, -0.10387496f, -0.02257152f, 
    -0.11274645f, -0.00086901f, -0.18373536f, -0.14536220f, 0.32105657f, 0.04350152f, 0.23846406f, 0.36644599f, 
    0.12948239f, 0.02824906f, 0.04704629f, -0.00703187f, -0.06302842f, 0.02172413f, 0.02019423f, 0.12606327f, 
    -0.22221519f, 0.05641109f, 0.00522147f, 0.26001203f, -0.03950088f, 0.07711028f, 0.13296923f, 0.15248290f, 
    -0.08304657f, 0.06599458f, 0.17813577f, 0.08338574f, -0.12268551f, -0.19305451f, 0.12453215f, 0.33297348f, 
    0.05776346f, 0.05226240f, 0.27817860f, -0.00648252f, 0.02925887f, 0.07835039f, -0.17052497f, -0.00690742f, 
    -0.05695224f, -0.09090288f, 0.01242525f, 0.19515131f, -0.02812461f, 0.09931342f, 0.06212236f, -0.00302709f, 
    -0.04799452f, 0.22400470f, 0.09695352f, 0.06690044f, -0.10069387f, 0.16526532f, -0.16848169f, -0.11041171f, 
    0.06715582f, 0.08019286f, -0.03456509f, 0.08180583f, -0.02334137f, 0.04369831f, 0.03072278f, 0.17240389f, 
    0.22528851f, -0.08976240f, 0.08913298f, -0.02335740f, 0.04682486f, 0.02659708f, 0.00086612f, 0.13105588f, 
    -0.36084113f, -0.23893447f, -0.05678190f, -0.01733405f, -0.03164937f, 0.16882229f, 0.01374473f, 0.15485911f, 
    0.20081785f, 0.12369772f, 0.08870380f, 0.01834131f, -0.02123101f, 0.12017289f, 0.09008989f, -0.07990795f, 
    0.07067413f, 0.45138776f, -0.18696599f, 0.11524303f, -0.15494753f, 0.08248851f, -0.04459586f, 0.07202766f, 
    -0.00443839f, 0.08896844f, -0.04939319f, 0.04347134f, -0.12257358f, 0.42729267f, -0.12536633f, -0.01299581f, 
    0.11694098f, 0.18066472f, -0.02053801f, -0.10763434f, -0.05970856f, -0.03246308f, -0.19211324f, -0.00223208f, 
    -0.27319223f, -0.13136715f, -0.16708891f, -0.15473495f, -0.06181756f, -0.01321026f, 0.03584952f, 0.01849783f, 
    -0.00002283f, 0.06882753f, -0.05819883f, -0.06950618f, -0.11171774f, 0.46272409f, -0.16256475f, 0.19471994f, 
    0.00147341f, 0.08076208f, 0.27463043f, -0.06377307f, -0.07622643f, -0.12474345f, 0.04793919f, 0.02704404f, 
    0.11359981f, 0.06459794f, -0.27191785f, 0.15978879f, 0.03618795f, 0.11337185f, 0.09373636f, 0.06852949f, 
    -0.02093481f, -0.06354950f, 0.07973357f, -0.03795719f, 0.16659451f, 0.10905155f, -0.24689128f, -0.01919387f, 
    0.07143272f, -0.10173170f, 0.11111579f, 0.18288638f, -0.10457242f, 0.06001049f, -0.03813637f, 0.02322076f, 
    -0.05266961f, -0.00332099f, -0.14071661f, 0.04605328f, -0.07075384f, -0.05212522f, -0.07915758f, 0.07822126f, 
    -0.03289207f, 0.04140477f, 0.10247271f, -0.11058483f, 0.18744355f, 0.16105480f, 0.08918507f, 0.21951944f, 
    0.08950781f, 0.11155006f, 0.13955538f, -0.02226446f, -0.01176231f, 0.24058105f, 0.24875949f, 0.09967718f, 
    -0.05554602f, -0.04682946f, -0.14920475f, 0.10943475f, 0.17965002f, 0.19497350f, 0.09313598f, 0.07516818f, 
    0.06206855f, 0.13466236f, 0.03186205f, -0.01868530f, 0.43244958f, -0.04595361f, -0.00613759f, 0.37682894f, 
    -0.00202532f, 0.04264383f, 0.12784964f, 0.07562853f, 0.01123581f, 0.02719063f, -0.01092344f, 0.12230430f, 
    0.04414706f, 0.26679802f, 0.02521122f, 0.28709343f, 0.12125979f, 0.04259514f, 0.00113728f, 0.10067307f, 
    -0.20839965f, 0.05735899f, 0.02512201f, 0.10971626f, 0.25132656f, -0.01540548f, 0.29886734f, 0.21905476f, 
    0.04789205f, 0.04208887f, 0.06202983f, -0.06562375f, -0.12813124f, 0.04810140f, -0.06151439f, -0.07747351f, 
    -0.39360371f, -0.10600522f, -0.17782788f, 0.02053039f, -0.14977112f, -0.13308850f, -0.07665746f, -0.03944669f, 
    -0.10592458f, -0.17489168f, 0.10273284f, -0.04950336f, -0.23312560f, -0.11033521f, -0.13812692f, -0.12187209f, 
    -0.02505473f, -0.01939760f, -0.02544322f, -0.00327346f, -0.00456756f, 0.01347042f, 0.03411553f, -0.01723223f, 
    0.17382328f, -0.08193631f, 0.05351210f, -0.11101699f, 0.02919175f, -0.02617288f, -0.02049392f, -0.05692578f, 
    -0.17598844f, 0.04693555f, 0.04456396f, 0.12606356f, -0.00969602f, -0.10460074f, -0.01483329f, 0.13983208f, 
    0.00443121f, 0.00509404f, 0.03496986f, -0.09728921f, -0.04307394f, -0.09317791f, -0.04710862f, -0.09736064f, 
    0.20495597f, 0.03811697f, -0.07241470f, -0.02060508f, 0.05389002f, 0.14202861f, 0.32351118f, 0.00703834f, 
    0.14923748f, 0.02168148f, 0.17651881f, 0.18546760f, 0.20013468f, 0.00622566f, -0.20193084f, -0.15591611f, 
    -0.01242045f, -0.01741263f, 0.11561454f, 0.04339181f, 0.05900979f, -0.01144796f, 0.09627144f, 0.03026871f, 
    0.07270432f, -0.05203058f, 0.11197186f, -0.08698756f, -0.04375821f, -0.06672847f, 0.02263185f, 0.04248744f, 
    0.08645672f, 0.07315809f, 0.18834502f, -0.09804504f, 0.41282165f, 0.66280937f, -0.46163473f, -0.06388246f, 
    -0.09865747f, -0.19408464f, -0.01473245f, 0.13978228f, -0.05377142f, 0.09108973f, -0.10425009f, 0.09325698f, 
    0.36547476f, -0.06679231f, -0.03653120f, 0.04983192f, -0.06185873f, -0.03433697f, 0.08472347f, -0.14992476f, 
    -0.14167681f, -0.12752303f, -0.00984782f, -0.02672280f, -0.02387209f, -0.17613001f, -0.05646902f, 0.05721751f, 
    -0.05544352f, -0.12977578f, 0.09034133f, 0.15545945f, -0.08282255f, -0.09088500f, -0.09855708f, -0.00911806f, 
    0.18905203f, 0.10209141f, 0.02792244f, -0.01241992f, -0.08504848f, -0.13447808f, -0.06678838f, -0.08456994f, 
    -0.12654667f, -0.06069309f, 0.03183653f, -0.09484589f, 0.03178462f, 0.12402642f, 0.03065570f, 0.05981546f, 
    0.07026841f, 0.16955893f, -0.08635804f, 0.09585657f, -0.02264201f, 0.10026740f, -0.05399276f, -0.08433345f, 
    0.09169725f, 0.05127689f, -0.07911534f, 0.01412270f, -0.12371234f, 0.08795391f, 0.06352396f, -0.05766992f, 
    -0.00256276f, -0.02605539f, -0.04857256f, 0.14715591f, 0.23625223f, 0.28282684f, 0.12978548f, -0.10332450f, 
    -0.03011744f, 0.15472242f, 0.03407865f, 0.24403258f, -0.12091810f, 0.04310228f, 0.03757651f, 0.01377436f, 
    -0.03773281f, -0.03549466f, -0.00245821f, -0.00752113f, 0.03607576f, 0.18711065f, -0.12716562f, 0.06031364f, 
    0.00991721f, 0.08195826f, 0.25709149f, 0.11658522f, 0.03386008f, -0.21261990f, 0.19301876f, 0.19369124f, 
    -0.01876696f, 0.04630207f, 0.14823285f, 0.05335824f, -0.13036312f, -0.15691988f, 0.01228117f, 0.00280357f, 
    -0.08545449f, -0.13252074f, -0.19280022f, -0.13092454f, -0.06203616f, 0.07900528f, 0.00293083f, -0.03749638f, 
    -0.02080691f, 0.08824293f, 0.04077913f, -0.05094834f, 0.05955029f, 0.11785913f, -0.06387700f, -0.00784891f, 
    -0.01780401f, 0.05119047f, 0.02756385f, 0.08998800f, -0.12319168f, 0.05311072f, 0.04439773f, -0.06633136f, 
    0.02329192f, 0.06465204f, 0.16221280f, -0.02794063f, -0.08110573f, -0.00872981f, -0.12750742f, 0.15827852f, 
    -0.00663420f, -0.06717788f, 0.09047563f, 0.08188453f, -0.03722437f, -0.22668248f, 0.00709687f, 0.04426409f, 
    0.10602998f, 0.12954922f, 0.12393967f, 0.17046049f, -0.00480433f, 0.11161252f, 0.10666019f, -0.06277874f, 
    0.06819965f, 0.22415312f, 0.06699867f, -0.23668435f, 0.03515078f, -0.07084196f, 0.09648501f, 0.05438726f, 
    -0.09990130f, -0.07948093f, -0.00028011f, -0.14096542f, 0.10357144f, 0.20875138f, 0.01823154f, -0.12061868f, 
    0.16155773f, -0.03910443f, 0.07349417f, 0.02001539f, 0.08336833f, 0.05336787f, 0.05504091f, 0.10691261f, 
    -0.20869677f, -0.03262276f, -0.05615186f, 0.03446125f, -0.06159886f, 0.03868804f, -0.03941328f, 0.10033739f, 
    0.00947387f, 0.00816306f, 0.02542651f, 0.02361001f, 0.07114372f, 0.50373924f, 0.04613269f, -0.14548567f, 
    -0.00752844f, -0.16863179f, -0.02632104f, 0.03654404f, 0.04904295f, -0.08076274f, 0.00850210f, -0.02923241f, 
    0.35396707f, 0.21473992f, -0.14230509f, -0.13705838f, 0.19530429f, 0.02909785f, 0.10589802f, 0.16704826f, 
    -0.05013157f, -0.10525917f, -0.02590535f, -0.03807693f, 0.17883341f, 0.08229218f, -0.21991421f, -0.25739649f, 
    -0.02546105f, 0.01608799f, 0.05957988f, -0.04220290f, 0.06052485f, -0.00245805f, -0.06011582f, 0.00398191f, 
    -0.11749674f, -0.08303475f, -0.03129891f, -0.00300922f, -0.03929359f, 0.04834428f, -0.00240184f, 0.03103667f, 
    0.00529343f, 0.12611639f, 0.12688333f, 0.04099779f, -0.06365500f, -0.12715471f, -0.00079421f, 0.04047170f, 
    0.02836226f, 0.04110884f, 0.14341784f, 0.07111053f, 0.02253505f, 0.10861442f, -0.05696412f, 0.14759469f, 
    0.04933266f, 0.07072125f, -0.25267357f, -0.10562774f, 0.17434298f, -0.03214675f, 0.03101743f, 0.07061864f, 
    -0.04094036f, -0.03630879f, 0.01111880f, -0.13111266f, 0.10234182f, 0.13337339f, -0.00997244f, 0.11171217f, 
    0.11851858f, 0.18318474f, 0.02518844f, 0.08160626f, 0.03453071f, 0.07373183f, 0.03207404f, -0.06624904f, 
    0.09969037f, -0.07175028f, -0.06908356f, -0.02837986f, 0.11843867f, 0.07342532f, 0.06387670f, -0.04827429f, 
    -0.03201059f, -0.07645646f, -0.13194351f, -0.08729955f, -0.07223228f, -0.40138862f, -0.03980730f, 0.00385822f, 
    0.03004623f, 0.14540477f, 0.02693640f, -0.01095861f, 0.08142643f, 0.09445883f, -0.18650031f, -0.16463345f, 
    -0.01835601f, 0.03137083f, 0.03387538f, 0.10446328f, 0.13991162f, 0.12772855f, -0.08204488f, 0.19715101f, 
    -0.11831652f, -0.07133495f, 0.00141962f, 0.17542081f, -0.18757050f, -0.02397484f, -0.02693378f, -0.10254044f, 
    -0.08648355f, -0.00792426f, -0.00587185f, -0.08692972f, -0.02875351f, 0.17898284f, 0.15430440f, 0.17344293f, 
    0.14518528f, 0.06685681f, -0.00482627f, -0.04025067f, -0.03424314f, 0.13613063f, 0.09861536f, 0.18258344f, 
    0.09272391f, 0.02696811f, -0.10849106f, -0.04468982f, 0.15160792f, 0.10440022f, 0.20742778f, -0.20433515f, 
    -0.09060838f, 0.05461083f, -0.12084287f, 0.15566166f, 0.07647576f, 0.02307797f, 0.00578174f, 0.15586086f, 
    -0.00849830f, -0.07598041f, 0.15713117f, -0.16402756f, 0.25302875f, 0.02475489f, -0.08602954f, 0.15929124f, 
    0.16045246f, 0.05089406f, 0.00350443f, -0.07102772f, 0.37109694f, -0.01502127f, 0.44867736f, 0.24292053f, 
    -0.23513468f, 0.11396252f, -0.04415309f, -0.07863491f, 0.14977878f, -0.00999326f, 0.03345370f, 0.16226465f, 
    -0.01410353f, 0.32329985f, 0.01646255f, 0.20004228f, 0.12646890f, -0.23072700f, -0.06085562f, -0.25907648f, 
    0.06010132f, 0.01799144f, 0.07908211f, 0.10997780f, 0.14148775f, -0.56327939f, 0.08243581f, -0.12448399f, 
    -0.12002935f, 0.13237204f, 0.09537183f, 0.17645693f, 0.01739915f, -0.05806353f, 0.10791603f, -0.03979839f, 
    0.24152003f, 0.14955425f, -0.03044162f, -0.02555005f, 0.02514083f, 0.14064105f, -0.01486660f, 0.19122007f, 
    -0.07972687f, -0.10163115f, 0.08811780f, -0.08537469f, 0.01744498f, 0.11139941f, -0.01651032f, -0.22339235f, 
    -0.11775742f, 0.06885108f, 0.05888540f, 0.04525253f, -0.08739241f, -0.02427853f, 0.03491009f, -0.00697853f, 
    -0.00573635f, -0.28490359f, -0.38607278f, 0.08138379f, 0.04767762f, -0.10203777f, 0.26228017f, -0.07101024f, 
    -0.02815410f, 0.06080503f, -0.07824744f, 0.02656276f, 0.12086188f, 0.06644141f, -0.07659382f, 0.02377394f, 
    -0.13736069f, -0.08231965f, -0.15401730f, -0.11319641f, 0.13500389f, 0.25893673f, 0.04124019f, 0.08869331f, 
    0.16735542f, 0.15958956f, 0.10756925f, -0.28403255f, 0.10030061f, 0.01030849f, -0.00964611f, 0.16778071f, 
    -0.10264719f, -0.07381111f, 0.08630161f, -0.00000225f, -0.28062165f, 0.27689818f, -0.17930618f, -0.42581898f, 
    -0.06586826f, 0.03756466f, -0.05869271f, 0.03274056f, 0.05412964f, 0.04244828f, -0.05484684f, -0.09241319f, 
    0.34303185f, -0.11171316f, 0.12712185f, -0.21236892f, 0.04526403f, -0.00466277f, -0.12848307f, 0.00219853f, 
    -0.00910171f, 0.06860054f, -0.08433655f, 0.03784573f, 0.06144916f, 0.13931754f, -0.08658253f, -0.27412528f, 
    -0.21980582f, 0.02849699f, -0.01974185f, 0.07668608f, 0.05376001f, -0.14444345f, 0.12140347f, -0.11381317f, 
    -0.15782689f, 0.28330570f, -0.09357341f, -0.03673819f, 0.07283476f, -0.11784445f, -0.05196918f, -0.06815149f, 
    0.11739349f, -0.15947531f, -0.01969007f, 0.02113315f, 0.14582941f, -0.14541246f, 0.03046870f, 0.06024274f, 
    -0.03774313f, -0.05098953f, 0.02032543f, -0.13310060f, 0.16240953f, 0.11363558f, -0.06224248f, 0.20645995f, 
    -0.09083965f, 0.20142518f, 0.03992933f, 0.03590281f, -0.03186012f, 0.11612281f, -0.07501318f, 0.08096449f, 
    0.01417809f, -0.11883052f, 0.06065124f, -0.04860274f, -0.22290455f, -0.40378293f, 0.01661349f, 0.18326202f, 
    0.07271258f, -0.03683487f, -0.14921093f, -0.00537136f, -0.17131995f, -0.01872676f, -0.00381855f, 0.01768791f, 
    0.04030853f, 0.14736190f, 0.10793723f, 0.08120699f, 0.05809623f, -0.00013748f, 0.09932972f, 0.03603037f, 
    -0.21402596f, -0.18785037f, 0.07268339f, -0.10048662f, 0.19799778f, 0.09397498f, 0.39290175f, -0.11968525f, 
    0.22012962f, -0.00323846f, 0.05658766f, 0.09489264f, 0.08970823f, -0.05340406f, 0.04119715f, 0.06719944f, 
    -0.22265276f, -0.06354060f, -0.19648564f, -0.01310080f, -0.15834992f, -0.11358701f, -0.08778438f, 0.16413139f, 
    -0.01766386f, 0.03640183f, -0.04080181f, 0.03258669f, -0.16528937f, 0.03833518f, 0.27265576f, -0.09235764f, 
    -0.01207589f, 0.20559606f, -0.03171291f, 0.14925283f, 0.03062145f, -0.02438816f, -0.13413595f, -0.01462037f, 
    0.23814769f, 0.20078829f, 0.02647021f, -0.11800489f, 0.24556541f, 0.04015479f, 0.15508285f, 0.12942836f, 
    0.01412905f, -0.05485229f, -0.00555033f, -0.07581972f, 0.38713837f, 0.14463623f, 0.01653257f, -0.19369711f, 
    0.03860746f, 0.03829873f, 0.23561063f, 0.06133229f, 0.05588625f, 0.00609847f, -0.00259680f, -0.12314934f, 
    -0.31406549f, -0.05264346f, -0.38406441f, 0.03941091f, 0.22644866f, 0.10301348f, -0.03541438f, -0.17802805f, 
    0.16954152f, 0.09186159f, -0.05823777f, 0.22866842f, -0.02082986f, -0.57292283f, -0.19742694f, -0.27049029f, 
    0.00636421f, -0.04018902f, -0.04699446f, 0.07236782f, 0.07590307f, 0.01613153f, -0.04316978f, 0.08381741f, 
    0.16217323f, 0.06130429f, 0.07833945f, 0.03614886f, 0.17380002f, 0.04412701f, 0.22591530f, 0.18008952f, 
    -0.12167983f, -0.00003700f, 0.01458220f, 0.06629965f, 0.20980120f, -0.01071140f, 0.13206591f, -0.24032488f, 
    -0.00671495f, 0.10079620f, -0.02546019f, 0.11887544f, 0.02965546f, -0.04657330f, 0.04166046f, 0.06279534f, 
    0.16877696f, -0.04908526f, -0.00561387f, 0.10900651f, 0.07760470f, -0.01365186f, -0.09253349f, 0.00832073f, 
    -0.01001390f, -0.18808228f, 0.05502412f, -0.04563536f, -0.00641159f, -0.24537383f, -0.09197521f, -0.01419814f, 
    -0.05970100f, -0.01764061f, -0.06404369f, 0.02889000f, 0.17691791f, 0.20577876f, -0.12604082f, -0.06723812f, 
    0.37546304f, 0.24266036f, -0.04331397f, 0.11595459f, -0.03022908f, 0.00287586f, -0.17198567f, 0.03665048f, 
    0.07885262f, 0.00220910f, -0.02864680f, 0.10239770f, -0.06364695f, -0.46107352f, -0.02307540f, 0.10443522f, 
    -0.46237361f, 0.10210985f, -0.19651853f, 0.02035182f, 0.11974724f, 0.00934638f, 0.22465208f, -0.02180157f, 
    -0.09663162f, 0.15838568f, -0.08406142f, 0.09971979f, 0.00778212f, -0.00198139f, 0.10183599f, 0.02672942f, 
    0.01107494f, -0.03176828f, 0.16013797f, 0.06890483f, 0.11422255f, 0.30028585f, 0.03339941f, -0.02598907f, 
    0.12665091f, -0.01663136f, -0.08048600f, -0.16809383f, -0.10595676f, 0.02993427f, 0.07723619f, -0.01767682f, 
    0.07960404f, 0.03988868f, 0.11564052f, -0.11344510f, -0.13854149f, 0.01795522f, 0.11929458f, 0.01201750f, 
    0.02725517f, 0.09442871f, 0.05847130f, 0.26588187f, -0.20983166f, 0.15525424f, -0.12395474f, 0.08712435f, 
    0.01018534f, -0.03429116f, -0.00452877f, -0.33022615f, -0.06087570f, -0.03446947f, 0.07966414f, 0.23880605f, 
    -0.01962898f, -0.16093153f, -0.21000300f, -0.11784407f, -0.00900245f, -0.08040481f, -0.23598918f, -0.16738576f, 
    -0.03328510f, 0.01141301f, 0.11934743f, 0.16861862f, 0.29830426f, 0.08526498f, 0.43339387f, 0.45139140f, 
    0.18644805f, -0.10734988f, 0.11116064f, -0.23267470f, 0.06242641f, 0.03128048f, 0.00795909f, -0.05715062f, 
    0.09601431f, 0.08085127f, 0.13714790f, -0.07065793f, -0.07210135f, 0.04849790f, 0.02116001f, 0.06732184f, 
    -0.09167085f, -0.03304787f, 0.00986370f, 0.08650299f, 0.26261249f, 0.19564074f, 0.28363192f, -0.04409970f, 
    -0.02230574f, 0.04889626f, 0.04540378f, -0.00346020f, 0.02352917f, -0.06004144f, -0.06942861f, -0.15759400f, 
    -0.07875668f, 0.01734948f, 0.24111252f, -0.22932987f, -0.03886731f, -0.05998318f, -0.10699037f, -0.04660489f, 
    -0.28953111f, -0.34601066f, -0.65601707f, -0.43446285f, -0.62621063f, 0.13247578f, -0.24164097f, 0.10445923f, 
    0.06046603f, -0.04254609f, -0.11422163f, -0.14256093f, 0.08396324f, 0.07074023f, 0.15681225f, 0.10784215f, 
    0.31360808f, 0.18983936f, 0.29372796f, 0.06325410f, 0.21406275f, -0.03325582f, 0.01723301f, 0.29787001f, 
    0.04657301f, 0.13001020f, 0.05889915f, -0.10033189f, -0.16269737f, -0.08446978f, -0.19360705f, 0.13314813f, 
    0.07993467f, -0.07530760f, 0.11713311f, -0.11246704f, 0.00488005f, 0.06082993f, 0.02577987f, -0.00996773f, 
    0.02992673f, -0.09288175f, -0.02539925f, 0.06947582f, 0.06201157f, 0.04091676f, -0.00002292f, -0.02100614f, 
    0.11266674f, 0.04402496f, -0.05258766f, 0.23564374f, -0.22134529f, 0.12595159f, -0.18793960f, 0.06944364f, 
    0.03766365f, -0.06488248f, 0.04930965f, -0.20316394f, -0.01090633f, -0.10666232f, -0.12028045f, -0.23199351f, 
    0.10072081f, -0.14452009f, 0.37736133f, -0.15577184f, 0.17928416f, -0.04986274f, 0.00359491f, 0.18647271f, 
    -0.22889459f, -0.01673386f, -0.02347753f, -0.06084180f, 0.07083166f, 0.26176825f, -0.00522100f, 0.08307007f, 
    0.09070515f, 0.02136714f, -0.21108252f, -0.34989169f, 0.05591768f, -0.10191365f, -0.15175775f, -0.09879913f, 
    0.30500573f, -0.08001661f, -0.12737134f, -0.03445261f, -0.01822495f, 0.01598315f, 0.00084707f, 0.10928161f, 
    -0.08337907f, -0.03552826f, -0.06676012f, 0.00933040f, -0.08640932f, -0.04579901f, -0.20103346f, -0.31092563f, 
    0.00259530f, 0.00358140f, 0.09253732f, -0.09136590f, 0.17784931f, 0.16914847f, -0.04590634f, 0.01562521f, 
    -0.07461785f, 0.08066686f, 0.11299630f, -0.22184294f, 0.10305986f, 0.07507725f, 0.06252780f, 0.07994141f, 
    0.06345559f, -0.07697189f, -0.11652832f, -0.05028214f, -0.03937979f, 0.27664167f, -0.31799281f, -0.05180497f, 
    -0.14497536f, 0.10001846f, 0.01926619f, -0.07194292f, 0.06563138f, 0.14766817f, 0.12662667f, 0.07224913f, 
    0.22663894f, 0.14776833f, 0.30968386f, 0.09541822f, -0.08429675f, -0.12425147f, -0.11870889f, -0.15208156f, 
    0.01525584f, 0.11745709f, 0.08059100f, -0.02618793f, 0.08477767f, -0.03928038f, -0.10182003f, 0.06918130f, 
    -0.01354264f, -0.14721319f, -0.00918244f, 0.17342098f, 0.05894164f, -0.05999320f, 0.01550564f, 0.01735191f, 
    0.22060476f, 0.20832358f, 0.18850626f, 0.14334448f, 0.04146482f, -0.00002389f, 0.10014654f, -0.07521234f, 
    -0.09562653f, -0.11928495f, 0.01963031f, -0.02111770f, -0.15498981f, 0.13374662f, 0.23815292f, -0.01562206f, 
    -0.09840435f, 0.06228017f, 0.08515531f, -0.13379925f, 0.08636960f, 0.03966558f, -0.07402149f, -0.08256285f, 
    0.27181444f, 0.00042932f, 0.05766000f, 0.10058504f, -0.07166312f, -0.02294528f, 0.00899486f, -0.03861806f, 
    -0.04082203f, -0.02551019f, 0.06404571f, 0.07399321f, -0.18081760f, 0.06309035f, -0.19001599f, -0.07325086f, 
    0.00726987f, -0.16313562f, -0.23152794f, -0.15310504f, -0.12968792f, 0.19906431f, 0.07721001f, -0.01563373f, 
    0.22531711f, 0.17221378f, -0.01729806f, -0.24524136f, -0.15298450f, -0.01446513f, -0.16330695f, -0.04869247f, 
    -0.00883998f, -0.02461867f, -0.08212490f, 0.02674543f, -0.08846507f, 0.45002228f, -0.07454595f, 0.13810402f, 
    0.06814697f, 0.05724924f, 0.04125557f, 0.11142883f, -0.02654032f, 0.11304343f, -0.01791115f, 0.05305946f, 
    0.04876896f, 0.08468860f, -0.29399514f, -0.20612165f, 0.04537513f, 0.06881346f, -0.03367944f, 0.16928573f, 
    0.10587291f, 0.00247290f, -0.02946301f, -0.09599866f, -0.18574493f, -0.09925757f, 0.01479739f, -0.18123539f, 
    -0.08299711f, -0.02961581f, 0.02219705f, -0.00872297f, -0.10252798f, -0.09926768f, 0.10987113f, 0.00058520f, 
    0.28054982f, -0.22580354f, 0.33181071f, -0.06169382f, 0.18375468f, 0.22839518f, 0.21236198f, 0.11176840f, 
    0.15365176f, 0.05792399f, 0.03937446f, 0.20456226f, 0.15217584f, 0.17083475f, 0.10044935f, 0.11889198f, 
    -0.05836654f, -0.08001579f, -0.07039852f, -0.04679264f, -0.05315635f, 0.07022905f, -0.01842228f, 0.16046190f, 
    -0.24115419f, 0.04766645f, -0.05050412f, 0.32937512f, -0.07171011f, -0.08562206f, 0.10421405f, -0.02345243f, 
    0.04598009f, -0.00508929f, 0.24292490f, 0.10772981f, 0.01574836f, -0.30153850f, -0.37854639f, -0.03902073f, 
    0.26642039f, 0.00626699f, -0.11233936f, -0.07092690f, -0.05231439f, 0.14202772f, -0.03107855f, -0.04619211f, 
    0.22676432f, 0.20711184f, -0.05175645f, -0.18367682f, -0.07743901f, -0.03831609f, 0.09591334f, 0.05675934f, 
    0.04119574f, 0.04392704f, 0.13137853f, 0.23418993f, 0.25065362f, 0.06329177f, -0.10586772f, -0.54369205f, 
    0.37771779f, 0.05701200f, 0.06241781f, -0.12885150f, 0.01411142f, -0.06454355f, -0.02504566f, 0.08231565f, 
    0.01080383f, -0.13499230f, -0.14456786f, -0.18463872f, -0.15017836f, 0.07172836f, -0.05084541f, 0.03307888f, 
    -0.00439583f, 0.05863379f, 0.05901083f, 0.04993988f, 0.06828580f, 0.25606790f, 0.22974263f, 0.11876112f, 
    0.05099119f, 0.18808965f, 0.25397548f, 0.03181614f, -0.03046777f, 0.09097594f, -0.03396406f, 0.10843874f, 
    0.13756372f, 0.23371916f, 0.01912275f, -0.13122642f, 0.10320871f, -0.04310078f, -0.02856356f, 0.04091297f, 
    -0.06331915f, 0.00478181f, 0.02260236f, 0.04568363f, 0.26564026f, 0.33527029f, 0.38705981f, 0.23595302f, 
    0.03429305f, 0.17594041f, 0.13659842f, 0.06641570f, 0.01873727f, 0.04209372f, -0.06896619f, -0.21452275f, 
    -0.00944113f, 0.31923974f, 0.24038990f, -0.10576835f, 0.11248104f, -0.04622978f, -0.15860273f, -0.21181259f, 
    -0.01707026f, -0.14509910f, -0.21642566f, -0.16333880f, 0.15650073f, -0.38998058f, -0.22322239f, -0.43979660f, 
    -0.03871684f, 0.12953742f, 0.09596190f, 0.11180444f, 0.08343285f, 0.07426770f, 0.07165086f, -0.02422983f, 
    0.24522425f, 0.00783435f, 0.15829551f, 0.30986723f, 0.17107122f, -0.12918420f, 0.23970626f, 0.23000558f, 
    0.00102719f, 0.23645782f, -0.03742456f, 0.07012068f, 0.32457748f, -0.43067104f, 0.19519559f, -0.06715354f, 
    -0.22147018f, 0.19643116f, 0.01409451f, -0.00682809f, 0.09288207f, -0.06369066f, 0.11023670f, 0.15537110f, 
    -0.05965050f, -0.20811495f, -0.24700007f, 0.13270953f, 0.12525487f, -0.06030845f, 0.01406794f, -0.05243731f, 
    0.00437609f, -0.08861476f, 0.15151431f, 0.07905403f, 0.08915541f, -0.28749701f, -0.19443430f, 0.01053729f, 
    0.06277386f, 0.03814692f, -0.08355246f, -0.06600003f, -0.00240570f, 0.12065997f, -0.33807635f, -0.03877837f, 
    0.13385627f, -0.35124534f, 0.16299568f, 0.01401820f, -0.05064034f, -0.13811453f, -0.03408797f, 0.29798499f, 
    -0.07007766f, -0.04187319f, 0.13827051f, -0.04722636f, 0.21937975f, 0.02883736f, 0.16691054f, -0.17407085f, 
    -0.19520979f, 0.23736590f, 0.14989938f, -0.11670539f, -0.08169444f, -0.17490891f, 0.08065877f, -0.27944124f, 
    -0.17738627f, 0.28714034f, 0.02420493f, -0.01352020f, -0.01184434f, 0.00756766f, -0.00626226f, 0.11444671f, 
    0.16061579f, -0.08231847f, 0.04082211f, 0.01754362f, 0.26285160f, 0.07099909f, 0.09532294f, -0.08973306f, 
    -0.15049347f, 0.06812786f, 0.03516183f, 0.29909998f, 0.05548749f, -0.08557696f, 0.04233733f, 0.23039149f, 
    -0.03526970f, -0.34908944f, 0.23697409f, 0.01422045f, -0.09255991f, -0.00665362f, -0.01669002f, 0.04023683f, 
    -0.07113744f, 0.08628386f, -0.10889734f, -0.11567985f, 0.29779759f, -0.35391524f, 0.29478723f, 0.19211410f, 
    -0.16655949f, -0.10110041f, -0.08902716f, 0.09499433f, 0.07247287f, -0.06271294f, 0.09581832f, 0.07415248f, 
    -0.22702146f, -0.00750201f, -0.20915045f, 0.13367203f, 0.09441978f, 0.03948708f, -0.13868858f, 0.01547043f, 
    0.06486578f, -0.15312952f, 0.13915135f, 0.15025640f, 0.20239928f, -0.51231647f, 0.40179718f, -0.13333023f, 
    0.16258423f, 0.12128381f, -0.01019853f, 0.06636827f, 0.06411724f, 0.03718084f, -0.03826760f, -0.15132020f, 
    -0.10122420f, 0.01762845f, 0.14806129f, -0.25045025f, 0.07415039f, -0.04910808f, 0.02744223f, 0.19975325f, 
    0.10631513f, 0.05969366f, -0.04807370f, 0.09839452f, 0.23340599f, 0.09662728f, 0.32170743f, -0.11058965f, 
    -0.04016984f, 0.16054837f, 0.07652190f, -0.06920481f, 0.09838378f, -0.03346438f, -0.02559849f, 0.00761463f, 
    -0.12033971f, -0.21905760f, -0.04557788f, -0.09366235f, 0.14770557f, 0.06072771f, 0.10523687f, 0.00630721f, 
    -0.01002731f, -0.01342848f, -0.01472083f, 0.09575438f, -0.24899229f, -0.06960516f, -0.13872176f, -0.10750004f, 
    -0.09014391f, 0.03157180f, 0.10287286f, 0.07235467f, 0.25873703f, -0.08038320f, -0.10697220f, 0.02932785f, 
    0.22571364f, 0.16521332f, 0.27534029f, -0.16754939f, 0.09952449f, 0.00990570f, -0.01103888f, 0.09253637f, 
    0.04153652f, -0.03831404f, 0.08745367f, -0.06135149f, -0.23922844f, -0.14702891f, 0.01435769f, -0.15098539f, 
    0.06606042f, -0.05110191f, 0.03598019f, -0.08979744f, 0.03898003f, -0.00740835f, 0.05153697f, 0.04076368f, 
    0.15281807f, -0.25395140f, 0.07584810f, -0.05415679f, -0.05678237f, -0.07955206f, 0.05346644f, 0.09463251f, 
    0.11566627f, -0.00053348f, -0.16504441f, 0.00239928f, -0.19137360f, 0.08512369f, -0.35725915f, -0.01539173f, 
    -0.06161827f, 0.14469653f, -0.05213067f, -0.08194098f, 0.26704344f, -0.08713696f, -0.14234246f, -0.01445125f, 
    0.07123941f, 0.12795317f, 0.03164990f, 0.08451147f, 0.18673114f, 0.01494379f, 0.02429906f, 0.09447227f, 
    0.07517727f, -0.07145396f, 0.01522118f, -0.07696704f, -0.02150650f, -0.02130948f, -0.09440315f, -0.15134205f, 
    -0.03938156f, 0.04123618f, -0.03753716f, -0.03519805f, 0.11486614f, -0.01459183f, 0.14793484f, 0.19064973f, 
    -0.06367036f, -0.05902212f, 0.04305005f, 0.03005101f, 0.25684705f, 0.17139046f, 0.07647927f, -0.02823828f, 
    0.12262533f, 0.20381141f, 0.01521476f, 0.15197010f, 0.24030851f, 0.13730182f, 0.00596054f, 0.00040727f, 
    -0.02554867f, -0.00376472f, -0.01092362f, 0.09096756f, 0.07383842f, 0.01722562f, -0.02520632f, -0.09739986f, 
    -0.02626053f, -0.05686675f, 0.01451319f, 0.29874009f, 0.29878384f, 0.10887536f, 0.05286162f, -0.12210506f, 
    0.33187184f, -0.01451196f, 0.26086840f, 0.24234447f, 0.15056793f, -0.34415424f, -0.09535547f, 0.21808086f, 
    -0.03446790f, 0.03100584f, -0.06020546f, -0.04466018f, -0.04464927f, 0.07581336f, 0.02798856f, 0.10918329f, 
    0.38818285f, 0.01899502f, 0.09247960f, 0.01824179f, 0.06622247f, -0.04307433f, 0.04873016f, -0.07613794f, 
    0.03053298f, 0.10580678f, 0.17412454f, 0.00591999f, -0.04193443f, -0.16188706f, 0.02998885f, -0.15720522f, 
    -0.01672733f, 0.13527781f, 0.09690233f, -0.01206641f, -0.00824409f, -0.01957867f, -0.07589644f, 0.00884618f, 
    -0.26608306f, -0.15786022f, 0.19978476f, 0.14590847f, -0.24016044f, -0.05915717f, 0.04183157f, -0.14071332f, 
    -0.00035217f, 0.01432654f, 0.00904223f, -0.06096765f, -0.32105473f, -0.24560708f, -0.03908245f, 0.24861462f, 
    -0.03998795f, -0.11592340f, -0.08214408f, 0.16886576f, -0.15270181f, -0.01623002f, -0.04368112f, 0.01953505f, 
    0.32496503f, 0.10821424f, 0.10203231f, -0.23237230f, 0.11741308f, 0.12164178f, 0.07567794f, 0.04428948f, 
    -0.05473183f, 0.03393894f, 0.01987050f, -0.08219066f, 0.14452980f, 0.13962774f, 0.01258997f, 0.03650475f, 
    0.01745183f, 0.04554379f, 0.03259618f, -0.01133190f, 0.01306633f, 0.11264695f, 0.11701104f, -0.03982441f, 
    -0.16182719f, 0.00667745f, 0.08052289f, -0.05134700f, -0.29220733f, -0.03120902f, -0.08932521f, 0.02325891f, 
    -0.04706147f, -0.06100408f, -0.12827778f, -0.02728532f, -0.07082029f, 0.14199403f, 0.10960387f, -0.12651089f, 
    -0.10558324f, 0.00929394f, 0.05458784f, 0.01745738f, -0.05892366f, 0.05228255f, -0.08710687f, 0.01393264f, 
    -0.11865968f, -0.10107743f, 0.18179835f, -0.12639727f, -0.12914917f, -0.01984906f, 0.04738119f, 0.09152773f, 
    -0.08398271f, 0.33186120f, 0.27383637f, 0.17333303f, -0.08073329f, 0.28825787f, -0.06606673f, 0.02283626f, 
    -0.05782898f, -0.00167284f, 0.30294815f, 0.06987846f, 0.06819774f, -0.05651721f, -0.10491816f, 0.11001792f, 
    -0.04672030f, -0.00101227f, 0.40381753f, -0.17232531f, -0.01195207f, 0.01338444f, 0.15449727f, -0.07388429f, 
    0.16081826f, 0.11928394f, 0.01636886f, -0.17022736f, 0.16637294f, 0.15354691f, -0.13305455f, 0.16179870f, 
    0.05276952f, 0.00893616f, -0.04667305f, 0.00637324f, 0.01210018f, 0.03636939f, -0.05727898f, 0.04208927f, 
    -0.03790893f, -0.15745018f, -0.01688137f, 0.11622895f, -0.00697409f, 0.04078691f, -0.05855335f, 0.26562542f, 
    0.07576183f, 0.11357364f, 0.09756511f, 0.00830000f, 0.31492960f, -0.16984376f, -0.14301662f, -0.10680865f, 
    0.12594499f, -0.11007105f, -0.02452027f, 0.18164155f, -0.13072465f, 0.05746456f, 0.04283229f, -0.02663779f, 
    0.20453563f, 0.21762766f, -0.09114110f, -0.17909348f, 0.25354072f, -0.06224596f, 0.07548012f, 0.03877841f, 
    0.18358542f, -0.01966424f, 0.01061538f, 0.05702390f, 0.44397810f, 0.01878577f, 0.03672842f, -0.20229322f, 
    0.06747234f, 0.07514915f, 0.08710491f, -0.20295769f, 0.03385261f, -0.00263302f, 0.04137054f, 0.08814444f, 
    0.08205356f, 0.19247209f, 0.04471063f, 0.02380848f, 0.00584220f, 0.00883872f, 0.07443618f, -0.05984869f, 
    0.07644969f, 0.20252590f, 0.26176560f, -0.14330916f, 0.28652564f, 0.17023648f, -0.03109669f, -0.11475397f, 
    -0.00991668f, -0.08339781f, 0.11718828f, 0.07836791f, -0.00813427f, 0.04505369f, 0.00542188f, 0.00684016f, 
    0.30328411f, 0.10270885f, -0.10651596f, -0.08003601f, -0.04930131f, 0.02895067f, 0.13455519f, -0.06605978f, 
    -0.04940994f, -0.10490246f, 0.08200432f, -0.07088711f, 0.07439810f, 0.18077846f, -0.15431610f, -0.03397306f, 
    0.04173258f, -0.08010872f, 0.03047256f, 0.29761249f, -0.05317789f, 0.07885937f, -0.02861783f, -0.06664126f, 
    0.10062204f, 0.09299392f, 0.03712033f, 0.02945990f, -0.05397375f, -0.11167749f, 0.04109395f, -0.03092888f, 
    -0.00781128f, 0.01321408f, -0.04432686f, -0.01452839f, 0.22152387f, -0.01486040f, -0.08296034f, -0.20215741f, 
    -0.05591010f, 0.00625275f, 0.04921890f, 0.01553537f, 0.05190367f, 0.17894502f, 0.07652694f, -0.13403028f, 
    0.14954160f, 0.06160009f, -0.13435563f, -0.08546153f, 0.02838626f, -0.03841885f, 0.20447797f, 0.29350775f, 
    -0.04262019f, 0.01757083f, -0.01047090f, 0.01661894f, 0.08786546f, -0.06957985f, 0.01898371f, -0.26958069f, 
    -0.17035285f, 0.19333434f, 0.09876929f, 0.03226593f, 0.02883418f, -0.01085675f, 0.01127500f, 0.00723541f, 
    0.14074278f, -0.32187501f, -0.11079182f, 0.02404410f, 0.05507952f, -0.04208123f, -0.16254094f, -0.09456569f, 
    -0.10341383f, -0.04118411f, 0.09556378f, -0.00475111f, 0.15643971f, 0.11160863f, -0.14809105f, -0.09535445f, 
    -0.04088448f, 0.12443387f, 0.06830059f, 0.10772277f, -0.09412371f, -0.06099144f, -0.02427919f, 0.07397923f, 
    -0.22936185f, -0.01777997f, 0.24817871f, -0.08953195f, 0.03922292f, -0.12955649f, -0.04958010f, -0.03185894f, 
    -0.11729731f, 0.00380885f, 0.13427906f, -0.04813454f, 0.06283056f, 0.10668013f, 0.20556600f, -0.07476643f, 
    -0.01507830f, 0.03332733f, -0.01412814f, -0.04805377f, 0.11398314f, 0.13698485f, -0.00692293f, -0.04472861f, 
    0.02364099f, 0.09940616f, -0.10716635f, 0.04892590f, -0.08440153f, -0.04270383f, 0.05361659f, -0.12645109f, 
    -0.14906111f, -0.00186968f, 0.23275547f, 0.04838891f, -0.26094761f, -0.14811151f, -0.00917199f, 0.07727309f, 
    0.04387638f, 0.02015405f, 0.02529694f, -0.16194327f, -0.05424910f, 0.15958706f, -0.05096794f, 0.00883985f, 
    0.06282388f, 0.12684558f, 0.07907855f, -0.02160728f, -0.00647791f, -0.01279663f, 0.10285462f, 0.16434108f, 
    0.07660151f, -0.03307679f, 0.12002091f, 0.15850140f, 0.01894298f, 0.37052679f, -0.05962365f, -0.13834009f, 
    0.23302324f, 0.00013292f, 0.03421862f, -0.04177415f, 0.08296133f, 0.07370800f, -0.01687909f, 0.12818500f, 
    0.15333265f, 0.01260155f, -0.03602232f, 0.06364011f, -0.10685167f, -0.02163950f, -0.06471539f, 0.16503963f, 
    -0.12076658f, 0.05451473f, -0.20499812f, 0.02434450f, -0.16911376f, 0.17781614f, -0.24434340f, 0.19924606f, 
    0.00954438f, 0.19049957f, -0.04967018f, 0.07221445f, 0.08323682f, 0.09810137f, 0.01340879f, 0.17812000f, 
    0.25188786f, 0.29518244f, -0.11288894f, -0.06904191f, 0.08208424f, 0.06668700f, 0.00399747f, 0.01009424f, 
    -0.14684564f, -0.01748806f, -0.02212451f, 0.13440639f, 0.11621242f, 0.35772344f, 0.10553147f, -0.28540301f, 
    -0.09045581f, -0.09411005f, 0.20564941f, -0.09440349f, 0.11530697f, -0.09291433f, 0.04974311f, -0.02703908f, 
    -0.00058131f, 0.12820764f, -0.10640486f, 0.30294701f, 0.13163851f, 0.04073405f, -0.16230442f, -0.13744240f, 
    -0.05537518f, -0.15741669f, -0.17793977f, -0.04769526f, 0.00479422f, -0.15197180f, -0.08058403f, -0.28763494f, 
    0.00482786f, 0.10713857f, -0.06694862f, 0.15298192f, -0.12613045f, -0.01958750f, 0.09317029f, -0.02447877f, 
    0.39819133f, 0.15677458f, 0.06300279f, 0.02494446f, 0.07952502f, -0.11373742f, 0.19900726f, 0.07083578f, 
    -0.04882923f, 0.02859660f, -0.04832359f, 0.09639215f, 0.14548336f, -0.07161438f, -0.06153207f, -0.22972772f, 
    -0.02979221f, 0.12602238f, 0.05382350f, 0.13701451f, 0.03115047f, -0.07205589f, 0.03059182f, 0.06763522f, 
    0.20067665f, 0.07642057f, -0.18273546f, 0.03801371f, 0.15679321f, 0.08516716f, -0.10963972f, 0.00701297f, 
    0.13765751f, -0.05428571f, 0.17362154f, 0.15433441f, 0.00167479f, -0.21183722f, 0.10454699f, 0.04240284f, 
    0.02274159f, -0.15989904f, -0.06653424f, 0.11210965f, 0.02069471f, -0.05661806f, -0.09040190f, -0.00654172f, 
    0.65562218f, -0.00928287f, -0.14085589f, -0.15196949f, 0.08080298f, 0.00828107f, -0.09145238f, 0.16515735f, 
    0.07561030f, -0.10861740f, -0.05982192f, 0.10179999f, 0.05413636f, 0.16340651f, 0.11416497f, 0.30508709f, 
    0.00970737f, 0.07540120f, -0.02668790f, -0.04270297f, -0.04205146f, -0.08612594f, 0.16113622f, -0.20885158f, 
    0.11260773f, -0.16596685f, 0.21389194f, -0.02810740f, 0.15952680f, -0.05318255f, -0.02739707f, -0.27292323f, 
    -0.09752645f, 0.13216950f, -0.01028483f, 0.11262613f, 0.02334016f, 0.10159799f, 0.06211386f, -0.00852013f, 
    -0.02421303f, -0.01527862f, 0.03075060f, -0.19564258f, -0.00780403f, 0.00691360f, 0.03604024f, -0.09264863f, 
    -0.06416321f, -0.03135039f, -0.16295014f, 0.24787280f, 0.19521886f, 0.13782620f, -0.07101110f, -0.10768209f, 
    0.19665475f, -0.14080296f, 0.29076552f, 0.17072323f, -0.01543736f, -0.06705059f, 0.11015622f, 0.04958925f, 
    0.03983827f, 0.04506869f, 0.01816792f, 0.04868952f, -0.01153789f, 0.17343810f, 0.11532872f, -0.03931889f, 
    0.09956452f, 0.07070991f, 0.18089449f, 0.10310593f, -0.07052445f, -0.08374814f, 0.07161661f, -0.08577482f, 
    0.03728987f, 0.07085600f, 0.20900801f, -0.05678856f, -0.26853201f, 0.25798184f, -0.18023673f, -0.07115566f, 
    0.02029411f, 0.07506160f, -0.14622641f, 0.18957449f, 0.01118816f, 0.06227731f, -0.01562738f, 0.03827972f, 
    -0.04636472f, -0.13036689f, 0.08580234f, 0.14446092f, 0.02712723f, 0.04786770f, 0.13197318f, -0.10589104f, 
    -0.03959215f, -0.00082266f, -0.02446320f, -0.07241350f, -0.42520553f, -0.37204111f, -0.30386552f, 0.17168473f, 
    0.12184067f, -0.17161508f, 0.01692610f, 0.22802819f, -0.15399601f, -0.06380711f, -0.09553242f, 0.08387003f, 
    0.09482169f, 0.09736033f, -0.01811937f, -0.07789666f, 0.18118834f, -0.11035249f, 0.04705100f, 0.04294283f, 
    0.02204147f, -0.05487126f, 0.07032432f, -0.02241194f, 0.18767756f, 0.10308059f, 0.07576375f, -0.00511327f, 
    0.02042284f, 0.08005794f, -0.13106343f, 0.00608493f, -0.18587035f, 0.03022255f, -0.00473011f, 0.08121984f, 
    -0.39658386f, -0.18566951f, -0.17322536f, -0.00445535f, -0.20576993f, 0.05366820f, 0.07572556f, -0.12102855f, 
    0.06155765f, 0.00484596f, -0.07792842f, 0.08333471f, 0.14548817f, 0.24267004f, 0.15889744f, -0.15556930f, 
    0.02824890f, 0.09216810f, 0.07288134f, 0.18816356f, -0.01131301f, 0.16540843f, -0.07142524f, 0.06213024f, 
    -0.13416505f, 0.26576999f, 0.20879024f, -0.05570795f, -0.05902437f, 0.13346878f, -0.02699192f, -0.06857131f, 
    0.01690551f, 0.20945232f, 0.30885285f, -0.03003029f, 0.23133537f, -0.08506038f, 0.25002632f, 0.07196674f, 
    0.06187313f, -0.09890435f, 0.09232932f, 0.17886619f, -0.16702247f, 0.00962817f, -0.03790918f, -0.01687173f, 
    0.24669410f, 0.14944336f, -0.17975020f, -0.05319292f, -0.15945782f, 0.19612940f, 0.29644206f, -0.06529268f, 
    0.05803309f, 0.21108083f, 0.04317700f, -0.05225164f, -0.04806855f, -0.02449320f, -0.02607797f, 0.12515740f, 
    -0.08054794f, -0.01974882f, -0.06976392f, 0.11025449f, -0.09063362f, 0.01289248f, 0.05720163f, -0.01952382f, 
    -0.13987125f, -0.02782230f, 0.03424457f, 0.08943319f, 0.07764051f, 0.02851678f, -0.04823001f, -0.06700990f, 
    -0.04614690f, 0.13649580f, 0.25736615f, 0.17194505f, 0.00238395f, 0.09812789f, -0.06901080f, 0.07401629f, 
    0.07269466f, -0.08275265f, 0.21938203f, -0.00793323f, -0.08345380f, -0.03832110f, 0.00110274f, -0.02400373f, 
    0.20826542f, -0.11203133f, -0.14407793f, 0.15909079f, 0.01610474f, 0.00105820f, 0.16710928f, -0.06001494f, 
    0.21509983f, 0.16606984f, 0.26317281f, 0.34455585f, -0.11025489f, -0.24759671f, -0.20387006f, 0.22545199f, 
    0.16842599f, 0.03002428f, 0.00822509f, 0.09754927f, -0.04169523f, 0.22122502f, 0.16779375f, 0.05282183f, 
    0.17086686f, -0.16986363f, -0.10548411f, -0.20708801f, -0.01441992f, 0.08192192f, -0.00394926f, 0.13074800f, 
    0.10495702f, 0.22405437f, 0.12775832f, 0.00496050f, -0.08749455f, 0.69362462f, -0.21488518f, 0.11899761f, 
    0.07395466f, -0.22687450f, 0.13997644f, 0.05152598f, -0.05798060f, 0.15145230f, -0.09922026f, -0.08962703f, 
    -0.11888504f, -0.27339259f, 0.05412683f, -0.07966514f, -0.12139117f, -0.06894924f, -0.00612695f, -0.13025154f, 
    -0.13756719f, -0.03161622f, -0.03824847f, -0.03942045f, -0.18385239f, -0.27673373f, -0.11781769f, 0.15034719f, 
    0.04552844f, -0.20877114f, -0.18459632f, 0.12681086f, -0.13458972f, -0.21024472f, -0.07965104f, -0.16180830f, 
    0.23526318f, 0.35808519f, 0.32178646f, -0.25093886f, -0.06869967f, 0.05417947f, -0.21767709f, 0.03381174f, 
    -0.24586385f, -0.15040728f, -0.28822109f, -0.33934233f, 0.08287930f, 0.21163929f, 0.21958944f, 0.03519952f, 
    0.01106819f, 0.16138151f, 0.16878714f, 0.09917730f, 0.15848814f, -0.00893168f, 0.11379113f, 0.07088013f, 
    -0.21483281f, -0.07242329f, -0.08535543f, 0.01099890f, -0.10375336f, 0.00141721f, 0.17357481f, 0.11981183f, 
    0.03576982f, 0.15684511f, -0.10723502f, 0.14801277f, 0.18614565f, -0.07357088f, 0.18940464f, 0.13755776f, 
    -0.09473960f, 0.12545241f, 0.00275747f, 0.01268514f, -0.03599023f, -0.07745869f, -0.05611505f, 0.13787977f, 
    -0.24081799f, 0.01728640f, 0.24593070f, 0.21148919f, -0.14833060f, 0.00078420f, 0.12776913f, 0.05290359f, 
    -0.13320896f, 0.19800283f, 0.26865605f, 0.14496233f, -0.08909264f, 0.19378725f, 0.11323406f, 0.35872439f, 
    -0.04650152f, -0.11429032f, 0.09061573f, -0.19512798f, 0.00788906f, -0.25590557f, -0.37040976f, 0.05545908f, 
    -0.08659723f, 0.01213667f, 0.23906513f, -0.04015825f, -0.17493787f, 0.07059577f, 0.00908533f, -0.05266083f, 
    -0.03584972f, 0.25151303f, 0.13174279f, 0.03141318f, -0.03667658f, 0.23800272f, -0.05293111f, -0.02101580f, 
    0.16202441f, -0.01916927f, 0.03198620f, 0.15994096f, -0.10189753f, -0.19012542f, -0.04970116f, -0.21839832f, 
    -0.11731257f, -0.03037014f, -0.06675567f, 0.10662257f, -0.06926753f, 0.03479740f, 0.10709506f, -0.02178345f, 
    0.13945843f, 0.09266800f, 0.12687860f, 0.03983342f, -0.13624442f, 0.28203568f, -0.01771911f, -0.07291348f, 
    -0.00228052f, -0.06154835f, 0.03221046f, -0.11694988f, -0.00984485f, 0.14895803f, -0.17350107f, 0.09082597f, 
    -0.22714546f, -0.13515262f, 0.07927782f, 0.02798918f, 0.01854480f, -0.06693532f, 0.04460121f, 0.03160315f, 
    0.15810803f, 0.14010155f, 0.13903047f, 0.12770921f, -0.34443283f, 0.01166502f, 0.08722582f, 0.19873211f, 
    -0.12265694f, -0.01302213f, -0.00354904f, 0.07862851f, 0.07166378f, -0.00155590f, 0.17818779f, 0.07347942f, 
    0.19201070f, 0.01196384f, -0.00307247f, 0.10817065f, 0.04768242f, 0.03407151f, -0.04385544f, 0.05554242f, 
    0.07444458f, 0.19560963f, 0.03077968f, 0.09961842f, -0.12665869f, -0.58694935f, 0.04380089f, 0.31576476f, 
    -0.14375392f, 0.17679647f, 0.06179950f, -0.05461740f, -0.03877580f, -0.01409424f, 0.00795023f, -0.05324692f, 
    -0.17848481f, 0.14954948f, 0.17262062f, 0.06129482f, -0.16289987f, -0.00651227f, -0.03782864f, -0.17677370f, 
    0.03897842f, -0.02469833f, -0.00256452f, -0.00345556f, -0.04124036f, 0.25970918f, 0.27203381f, 0.16234376f, 
    -0.09644724f, 0.11694708f, -0.06958445f, -0.10670094f, 0.05042103f, -0.06750814f, 0.04148702f, 0.01855052f, 
    0.12189200f, -0.04334939f, 0.14824423f, 0.08035649f, 0.03535876f, 0.15518102f, 0.03232214f, -0.01115811f, 
    -0.10454739f, -0.09085305f, -0.12670432f, 0.00585829f, -0.11134444f, 0.07451913f, -0.12746209f, -0.13192737f, 
    -0.00750957f, -0.03025997f, -0.08735620f, -0.05345698f, -0.06872508f, 0.00264184f, 0.05621117f, -0.06598964f, 
    0.22228366f, 0.26139885f, 0.16549468f, -0.13958204f, -0.10118040f, -0.08753447f, -0.03439439f, 0.06185178f, 
    0.01999807f, 0.01512131f, 0.02447076f, -0.04898738f, -0.19378573f, -0.06259242f, -0.18104847f, -0.12016392f, 
    -0.07564996f, -0.06849222f, 0.07095532f, -0.13354863f, -0.07536815f, -0.01358925f, 0.08903137f, 0.06268290f, 
    0.07003210f, 0.06632098f, 0.06146063f, -0.16625927f, -0.01303745f, -0.07558953f, -0.02632497f, 0.10899220f, 
    0.19956577f, 0.01472272f, 0.11468214f, -0.01812366f, -0.29698122f, 0.42003864f, -0.04962740f, -0.15037879f, 
    0.04020001f, -0.11605461f, -0.07910232f, -0.14414097f, -0.02982947f, -0.11186305f, -0.04780151f, 0.03723986f, 
    0.51067865f, 0.08934414f, 0.33690476f, -0.19342491f, 0.17466974f, -0.04731875f, 0.10741198f, 0.20837963f, 
    0.06252582f, 0.09534403f, -0.09529508f, 0.05239290f, 0.15889396f, 0.13543496f, 0.09108945f, 0.25610685f, 
    0.07316899f, 0.03238104f, -0.07927369f, -0.05556529f, 0.11145940f, -0.09363353f, -0.02614796f, -0.10978168f, 
    -0.08796643f, 0.14097442f, -0.02058817f, -0.14827652f, 0.16503416f, 0.02789478f, 0.06493222f, -0.05741796f, 
    0.03293082f, 0.04972259f, 0.11354633f, 0.10491407f, 0.13766988f, 0.19690621f, 0.30500531f, 0.13923714f, 
    -0.01531057f, 0.00184030f, -0.03823632f, -0.04362005f, 0.02649855f, 0.00140145f, 0.01579100f, 0.13779305f, 
    -0.21065728f, -0.29694533f, 0.03859376f, 0.21064655f, -0.07698976f, -0.14879277f, -0.00387527f, -0.00384299f, 
    0.10890420f, 0.04667195f, 0.09183890f, 0.20075774f, -0.11504462f, -0.26595029f, 0.53189605f, 0.47238216f, 
    -0.05281980f, -0.11794163f, -0.09457987f, 0.10491724f, 0.06320541f, 0.08982280f, -0.01556415f, 0.09362363f, 
    0.04027013f, 0.00590190f, -0.02297591f, 0.10677162f, 0.05190552f, -0.05162973f, 0.01765868f, -0.10244038f, 
    0.11031272f, 0.07799511f, 0.08766750f, 0.15187864f, -0.14333819f, -0.31393382f, -0.01166236f, 0.29077739f, 
    0.15284061f, 0.21790971f, -0.02920075f, 0.11221308f, -0.04484569f, -0.02186424f, 0.00723300f, -0.02618026f, 
    -0.24160841f, -0.10941023f, 0.28265852f, 0.00707103f, -0.05101192f, 0.06834321f, 0.03806638f, -0.09505668f, 
    -0.07663769f, -0.04557435f, -0.07283574f, 0.00458045f, 0.18931298f, 0.01856679f, 0.02711287f, -0.02347202f, 
    0.10081591f, 0.09490512f, 0.15798718f, 0.01832465f, -0.00713285f, -0.08187032f, -0.04320757f, -0.00745114f, 
    -0.01587239f, -0.30425894f, -0.38749596f, 0.06178738f, 0.22022690f, 0.13857317f, 0.06363687f, -0.12437364f, 
    -0.09513265f, -0.10543333f, -0.38158670f, -0.07738582f, -0.03444159f, 0.20153093f, 0.04104764f, -0.05855899f, 
    0.06714296f, 0.02272703f, -0.00765056f, 0.04418137f, 0.17534323f, -0.08861979f, 0.06301673f, 0.21641116f, 
    0.19823042f, 0.26114815f, 0.41672131f, 0.07758943f, 0.04772216f, 0.11812520f, -0.06559412f, -0.06760012f, 
    0.02470833f, -0.06430585f, 0.04314505f, 0.10124022f, -0.26484266f, -0.00117794f, -0.16585863f, -0.40488937f, 
    0.02908574f, -0.07689597f, -0.05369881f, -0.04877265f, -0.04852054f, -0.11644524f, 0.00769188f, 0.04431790f, 
    0.27652720f, 0.07298236f, 0.31994611f, -0.06891512f, -0.01144096f, 0.08797010f, -0.02850446f, 0.12254032f, 
    0.09731845f, 0.08046702f, 0.02410954f, -0.00708887f, -0.11721356f, 0.37405205f, -0.00325870f, 0.01796385f, 
    0.00621986f, -0.20106143f, 0.04095266f, 0.13335857f, -0.02866029f, -0.07050615f, -0.06035113f, -0.09903409f, 
    0.57538480f, 0.37752727f, -0.02333618f, -0.33475116f, 0.08182354f, 0.02342105f, -0.10145175f, -0.08461129f, 
    0.13954061f, 0.09156689f, -0.01941498f, -0.02952332f, -0.12958452f, -0.02595885f, -0.06321597f, 0.29708686f, 
    0.12181763f, -0.11841293f, -0.21479000f, -0.04672192f, 0.16352308f, 0.03293344f, 0.12783116f, -0.00133514f, 
    -0.03621140f, -0.00249329f, 0.00623013f, -0.00146216f, -0.02797628f, 0.06505851f, -0.01852510f, -0.04091783f, 
    -0.00914997f, 0.03133372f, -0.02207227f, -0.06282992f, -0.04536277f, 0.03718750f, -0.05931284f, -0.06696931f, 
    -0.05145714f, -0.07301664f, -0.00496867f, -0.04441442f, 0.03074334f, 0.02853768f, 0.05602951f, 0.04872898f, 
    0.02329636f, 0.04073174f, 0.05157649f, 0.03748972f, 0.02255239f, 0.01538690f, -0.02502680f, 0.03282995f, 
    0.04483365f, -0.05284329f, 0.04284604f, -0.02073935f, -0.07518968f, -0.04334516f, -0.07780393f, -0.07487250f, 
    0.03278793f, -0.00890527f, 0.02641870f, 0.06368606f, -0.04881163f, -0.05032193f, -0.07047705f, -0.01343717f, 
    -0.02085577f, 0.05728978f, 0.02433232f, -0.02930639f, -0.07848502f, -0.05781015f, -0.07389692f, 0.01974503f, 
    -0.03222185f, -0.04044860f, -0.06086504f, 0.06042275f, -0.04333624f, 0.04870594f, 0.03013216f, -0.07601412f, 
    -0.02235674f, 0.04329975f, 0.01136600f, -0.05778233f, 0.02637201f, 0.01236156f, -0.05664734f, 0.05334832f, 
    0.01254587f, 0.00276551f, 0.03368081f, 0.03504592f, 0.02782956f, -0.06052755f, 0.00310422f, -0.05721106f, 
    0.05314782f, -0.03303503f, -0.06243160f, -0.03145036f, -0.07493383f, 0.00472115f, 0.00697461f, 0.01441517f, 
    -0.04268676f, 0.00119581f, 0.03562394f, -0.07069106f, -0.04301556f, 0.06277285f, 0.05091046f, 0.00100246f, 
    -0.06618715f, 0.01936251f, 0.03896982f, -0.05725754f, 0.05466922f, 0.04594797f, -0.01468165f, -0.07545352f, 
    0.02957105f, -0.04405229f, 0.04832165f, -0.06235884f, 0.06049152f, -0.02673098f, -0.02287247f, 0.02610547f, 
    -0.03265206f, -0.03974479f, -0.06113642f, -0.04630216f, -0.03241207f, -0.04359912f, 0.00945420f, -0.04045438f, 
    0.05167597f, 0.03828034f, -0.01133232f, 0.02239677f, 0.00639945f, 0.01470157f, -0.04399570f, 0.03277619f, 
    -0.02495755f, 0.03884511f, 0.01092566f, 0.01099709f, 0.03774237f, -0.06116030f, 0.02658642f, -0.01686444f, 
    -0.07366005f, -0.02193471f, 0.05927810f, -0.00036029f, -0.01297648f, -0.07296786f, -0.03793056f, -0.07343740f, 
    -0.03762493f, -0.02716929f, 0.04658863f, -0.07080523f, 0.05017792f, -0.01862577f, 0.02898803f, 0.02854969f, 
    0.01077130f, -0.04253643f, -0.06036295f, 0.02716650f, 0.01357139f, -0.00119981f, 0.01505911f, -0.02059893f, 
    0.01296442f, -0.07869685f, 0.06592313f, 0.04104269f, -0.07157769f, -0.05457119f, -0.02422908f, 0.00223018f, 
    -0.05976031f, -0.02160860f, -0.00764995f, 0.01888902f, -0.02853168f, -0.01029967f, -0.02646616f, 0.02442829f, 
    -0.05502805f, -0.03024031f, 0.00660635f, -0.06376263f, -0.04670974f, -0.04305165f, 0.00832852f, 0.00069503f, 
    0.04622788f, 0.01687674f, -0.04957452f, 0.04372615f, 0.05537315f, -0.03795683f, -0.05348338f, 0.02180587f, 
    0.13803715f, -0.07431807f, 0.10415315f, 0.11336847f, 0.19505352f, -0.06881551f, 0.04148697f, 0.09894437f, 
    0.05409883f, 0.16173020f, 0.13180652f, 0.01097137f, 0.19869068f, 0.24743870f, 0.22768404f, 0.10545261f, 
    -0.12218959f, -0.12168560f, 0.13402328f, -0.16541375f, 0.11835213f, -0.00530447f, 0.02360269f, 0.01167293f, 
    0.02833568f, -0.07034748f, -0.13820770f, 0.09256897f, 0.00964973f, 0.20024136f, -0.09744170f, 0.05077999f, 
    0.20770487f, 0.13751566f, 0.01728294f, 0.20058672f, -0.04386174f, 0.11804775f, -0.17404048f, -0.08774529f, 
    -0.17915671f, 0.06333895f, -0.00466387f, 0.02844062f, 0.17233427f, 0.05389227f, 0.14531983f, -0.01127159f, 
    -0.03987344f, -0.11275554f, -0.00513576f, -0.18476608f, -0.01223759f, -0.08873955f, 0.03469846f, -0.28329042f, 
    -0.06665357f, -0.00006537f, 0.23821439f, -0.04996620f, 0.31610700f, 0.19054841f, -0.15758008f, 0.21644998f, 
    0.13452621f, 0.12791577f, -0.01965096f, -0.04664273f, -0.18145740f, 0.06091238f, 0.02020621f, 0.07905127f, 
    -0.11000066f, -0.16823091f, -0.18974729f, 0.19591780f, -0.13647074f, 0.08866179f, -0.03001896f, 0.16330168f, 
    -0.07530116f, 0.03864861f, 0.09148569f, -0.09220351f, -0.05893685f, -0.13287450f, -0.12600900f, 0.12895687f, 
    -0.00121660f, -0.09572092f, -0.09225480f, 0.27611777f, -0.01866734f, 0.21700338f, 0.00296526f, -0.03288253f, 
    -0.22776246f, -0.16333179f, -0.17099965f, 0.05292844f, 0.11355343f, -0.22362085f, -0.01713583f, 0.15985432f, 
    -0.36884686f, -0.36616367f, -0.27619514f, -0.60920197f, 0.33914062f, 0.01536638f, 0.42202607f, 0.16059087f, 
    -0.01969045f, -0.03279047f, -0.06023816f, 0.00227001f, 0.26634264f, 0.09776060f, 0.13814776f, 0.13161887f, 
    -0.22128122f, -0.02652408f, -0.00208381f, 0.15153685f, 0.09294572f, 0.28737706f, 0.12345318f, 0.03285779f, 
    0.19311711f, 0.17132147f, 0.12276246f, 0.00469046f, -0.03123153f, -0.10431121f, -0.05916283f, 0.11732268f, 
    0.03220844f, 0.08519424f, -0.00856637f, 0.04339427f, 0.03893610f, -0.14346358f, -0.04875674f, 0.06252544f, 
    -0.06336173f, 0.17439251f, 0.08764071f, 0.29564166f, -0.15501122f, 0.03184429f, 0.11700176f, -0.11068827f, 
    0.10061472f, 0.14292541f, 0.20123343f, 0.10893477f, 0.30713820f, 0.21238245f, 0.17335132f, 0.16979998f, 
    -0.14519402f, 0.02759799f, -0.16466446f, -0.01927063f, -0.01075507f, -0.08603150f, 0.07445171f, 0.17661591f, 
    -0.38970760f, 0.07788646f, -0.27017266f, 0.07294922f, -0.05685632f, 0.10402331f, 0.00573741f, -0.08616770f, 
    -0.10825559f, -0.05138565f, -0.02397956f, 0.02339590f, -0.08785428f, -0.11752727f, 0.11277551f, -0.17914319f, 
    -0.02924973f, -0.24038106f, -0.27840909f, -0.35730994f, -0.15122502f, -0.18751894f, -0.12327254f, -0.15484801f, 
    0.19147179f, -0.19613273f, 0.09759627f, -0.01926666f, 0.21113336f, 0.13350402f, -0.05953583f, 0.07108093f, 
    0.15952437f, 0.15896422f, -0.08401575f, -0.00479388f, 0.04808358f, 0.02918171f, 0.01479160f, -0.13184977f, 
    -0.02685832f, 0.08152405f, -0.06560869f, 0.08360468f, 0.10804342f, -0.00360532f, 0.00669664f, -0.11825878f, 
    -0.14259622f, 0.36425871f, -0.10482129f, 0.05204379f, 0.13370915f, 0.04735136f, -0.06691191f, -0.07239408f, 
    0.01132224f, 0.04489948f, -0.06140567f, -0.08622098f, -0.24642190f, 0.00947557f, 0.01197152f, 0.09968324f, 
    -0.03294361f, -0.02953449f, 0.00637043f, -0.12095976f, -0.03979782f, -0.01403874f, -0.03449647f, 0.03461471f, 
    0.00323235f, 0.11202018f, 0.11272222f, 0.14268300f, -0.04611073f, -0.14900902f, -0.04461407f, -0.24376009f, 
    0.05881656f, 0.07953732f, 0.02887196f, -0.07391746f, -0.20899895f, 0.05180508f, -0.07017974f, 0.02811388f, 
    -0.03732896f, -0.09037177f, 0.13160108f, 0.09732106f, -0.07552511f, -0.15718085f, -0.16006786f, -0.12503651f, 
    -0.14184707f, -0.04230303f, -0.11727005f, 0.30387193f, -0.09569410f, 0.06823422f, 0.15075940f, -0.12695184f, 
    0.04631509f, -0.06438696f, 0.01608587f, 0.00093939f, -0.34648669f, -0.02552946f, -0.26396352f, 0.19846055f, 
    0.00032026f, -0.04083829f, -0.04641932f, 0.26801994f, -0.00908886f, 0.19700196f, -0.01146832f, -0.00429495f, 
    0.15857309f, -0.18007426f, -0.22276941f, 0.09794918f, -0.04595718f, -0.03296317f, 0.11155020f, 0.11841107f, 
    -0.07478180f, -0.04843958f, 0.12609793f, -0.04980125f, 0.27959022f, 0.05898130f, 0.00920705f, 0.03544863f, 
    0.02769209f, -0.06107738f, -0.06920376f, -0.16221651f, 0.02490429f, 0.11858632f, 0.06126844f, -0.03180967f, 
    -0.22784430f, 0.08341633f, -0.10598521f, 0.02215807f, -0.12720659f, 0.02838384f, -0.13588080f, 0.02615621f, 
    0.00662074f, -0.01813629f, -0.01517621f, -0.02094209f, 0.20902769f, 0.17628427f, 0.00951523f, 0.13743643f, 
    0.03985674f, -0.11370020f, 0.15865000f, 0.02926813f, -0.06152420f, -0.05969016f, 0.01153392f, -0.00961755f, 
    -0.06109907f, 0.19977643f, 0.20205560f, 0.21665218f, 0.09880805f, 0.14766406f, -0.00482128f, 0.08088509f, 
    -0.15598975f, 0.10102327f, -0.02699048f, -0.10700364f, -0.11424151f, 0.16819085f, 0.23928085f, -0.18126015f, 
    -0.02730927f, 0.05772265f, 0.15249953f, 0.02444820f, -0.02617434f, 0.07545029f, 0.10634208f, -0.06997517f, 
    -0.14179875f, 0.15222670f, 0.24946752f, 0.13585345f, 0.02459965f, 0.00749052f, 0.12244522f, -0.08705037f, 
    -0.01815173f, 0.03935078f, 0.11327935f, 0.04575424f, -0.06722993f, 0.00294240f, -0.04861303f, 0.15912148f, 
    -0.03808254f, -0.12310987f, -0.05038499f, -0.14021534f, -0.07516189f, 0.08743963f, -0.13573040f, 0.12587579f, 
    -0.28081602f, 0.20813847f, 0.09234487f, 0.13505602f, -0.06244391f, -0.10589422f, 0.13013181f, -0.04154558f, 
    0.08811416f, 0.09484763f, 0.29485175f, 0.04658352f, -0.00322222f, 0.14468358f, 0.22592929f, 0.38344577f, 
    0.08336797f, 0.04510544f, 0.02808513f, 0.10219051f, -0.12257639f, 0.02233066f, 0.09945492f, 0.11096892f, 
    -0.04196179f, -0.26737568f, 0.08196913f, 0.17106818f, -0.19238819f, -0.03652285f, 0.06728284f, 0.17732549f, 
    0.04501669f, 0.16858985f, 0.12132247f, 0.15823430f, 0.01828814f, -0.36007267f, 0.20825732f, 0.07656986f, 
    0.19805519f, -0.14032225f, 0.01291554f, 0.21709935f, 0.00629316f, 0.07491351f, 0.11745086f, 0.19793297f, 
    -0.10197611f, -0.23676674f, -0.24680316f, -0.09963152f, -0.06658227f, 0.15424599f, -0.02427663f, 0.29371375f, 
    0.03251906f, 0.07536288f, 0.15431695f, 0.18778737f, -0.04794405f, -0.07949758f, 0.35147196f, 0.31435075f, 
    -0.01121175f, 0.05100949f, -0.18374099f, -0.03382540f, -0.00162356f, 0.07504640f, -0.03686953f, -0.07184571f, 
    -0.38508815f, -0.17830409f, 0.13145950f, -0.23573230f, 0.11552457f, -0.10124899f, -0.14182624f, 0.22533992f, 
    -0.01238143f, 0.04331676f, -0.04649066f, 0.08644021f, 0.08687769f, -0.16251318f, 0.24824601f, 0.00999740f, 
    0.03780439f, -0.03692759f, -0.01561635f, -0.16388826f, 0.10585850f, -0.18653589f, -0.22480679f, -0.04882515f, 
    -0.39604586f, 0.06384268f, 0.28210080f, -0.24903774f, 0.25198314f, 0.22546850f, -0.22662745f, -0.15902847f, 
    -0.16666304f, -0.13216352f, -0.27509001f, -0.25342458f, -0.21957341f, -0.02604054f, 0.18896104f, 0.14276059f, 
    -0.05032816f, 0.08537912f, 0.22045279f, 0.34256920f, 0.10922133f, -0.09511580f, 0.05576608f, 0.10158165f, 
    -0.27092624f, -0.19238649f, -0.01459935f, 0.08385092f, 0.14319164f, -0.01503937f, 0.05877359f, -0.02014834f, 
    0.13494539f, -0.00257229f, -0.00945502f, -0.06267495f, -0.03825185f, -0.43953443f, 0.23336041f, 0.28354385f, 
    0.13972440f, 0.02081406f, -0.05866238f, -0.08355948f, -0.03920056f, -0.12604137f, 0.08572364f, 0.06020186f, 
    -0.10692246f, -0.01192458f, 0.26035011f, 0.15206385f, -0.03148285f, -0.10941434f, 0.12335558f, 0.13414194f, 
    0.12342844f, 0.06267437f, 0.09417772f, 0.22748278f, 0.12999307f, 0.09192198f, -0.03099351f, 0.27421755f, 
    0.00895975f, -0.03852231f, -0.07690506f, -0.09983844f, 0.05711574f, 0.05964686f, -0.32515067f, -0.07233445f, 
    0.07770505f, 0.18927692f, -0.09556812f, 0.07022772f, -0.04435435f, 0.04956381f, -0.03144796f, 0.10138987f, 
    0.08357752f, 0.17203981f, 0.13481025f, -0.07190134f, -0.08710890f, 0.01078594f, -0.08017065f, -0.26512718f, 
    -0.11425707f, 0.00998279f, -0.03204046f, 0.07715615f, 0.10143564f, -0.15047666f, 0.03074824f, -0.15863201f, 
    0.29104191f, 0.01101128f, 0.02144797f, -0.12377632f, 0.06406379f, -0.08607053f, -0.06613012f, 0.07509509f, 
    0.03416602f, 0.09257626f, -0.14240286f, 0.07610405f, 0.17085110f, 0.12430219f, -0.04179192f, -0.00416771f, 
    -0.10810541f, 0.21639697f, 0.04164485f, -0.02580160f, -0.06885792f, -0.12450103f, -0.07759316f, -0.01682059f, 
    -0.06210697f, -0.12886076f, 0.10949138f, -0.09569144f, 0.16086051f, 0.12173343f, -0.07918255f, -0.01234131f, 
    0.09699533f, -0.12014491f, -0.08500966f, -0.16884916f, 0.17703721f, 0.11026858f, 0.07040929f, -0.06883691f, 
    -0.18707377f, 0.13573977f, 0.05047588f, 0.12260741f, 0.11211704f, 0.00595012f, 0.03804389f, -0.05287792f, 
    -0.07735227f, -0.10326511f, 0.22930416f, 0.13412891f, 0.09760902f, -0.09123284f, 0.01280560f, -0.02570512f, 
    0.01321233f, 0.04686621f, 0.18412115f, -0.00763162f, 0.25644934f, 0.11475762f, 0.01936280f, -0.34925625f, 
    -0.00694876f, -0.24509479f, -0.27736357f, 0.31590959f, 0.11199281f, 0.01731569f, 0.03950891f, -0.04257543f, 
    0.25846627f, 0.14267311f, 0.04470314f, 0.03807875f, 0.17014691f, 0.13861933f, 0.15713531f, 0.12541211f, 
    0.06547744f, -0.08702164f, -0.08742537f, -0.00856299f, -0.04914369f, -0.05429549f, -0.07932710f, -0.14116521f, 
    0.01738654f, 0.04860498f, 0.02618357f, -0.10947423f, 0.04675853f, -0.12510546f, 0.01646181f, 0.10558985f, 
    -0.03534507f, -0.06397557f, -0.07645535f, 0.10512222f, -0.12349131f, -0.10244485f, 0.04279102f, -0.00664732f, 
    -0.05374356f, 0.13133894f, 0.04749507f, 0.07482940f, -0.11026575f, 0.04385725f, 0.04820901f, 0.02591033f, 
    0.02039111f, 0.07381298f, -0.11950685f, 0.14584622f, -0.11631650f, 0.09413332f, -0.07416788f, 0.00736700f, 
    0.12338987f, 0.22077365f, -0.11957662f, -0.21834300f, 0.04961475f, 0.15733024f, 0.00862415f, -0.04234144f, 
    -0.00412030f, -0.04468342f, 0.01525106f, -0.01155372f, -0.29234108f, 0.52995914f, -0.08629996f, -0.13207424f, 
    0.11227424f, 0.08995976f, 0.03964587f, 0.22234349f, -0.07098362f, 0.05380088f, -0.11248159f, -0.03423796f, 
    0.09220962f, 0.06253287f, -0.06843966f, -0.36113358f, 0.09626517f, 0.31278646f, -0.02342789f, -0.03727405f, 
    0.13420516f, -0.18177314f, -0.18190791f, -0.06158284f, 0.10253420f, -0.31584576f, 0.14579774f, -0.06852558f, 
    -0.05509220f, 0.19901851f, 0.03821015f, 0.03964574f, -0.18833350f, -0.12185396f, 0.03100101f, -0.13293245f, 
    -0.04098848f, 0.01534405f, -0.02030068f, 0.15375520f, 0.11867823f, 0.34766287f, 0.17264161f, -0.05815045f, 
    -0.06912673f, -0.09317183f, 0.03163713f, 0.14884859f, -0.11065466f, -0.09720639f, 0.00344951f, -0.12861566f, 
    -0.15983570f, -0.09968743f, 0.02975934f, 0.05148778f, -0.13435051f, 0.20449859f, 0.10023441f, 0.21242173f, 
    -0.06087722f, 0.02351351f, 0.13508546f, 0.03676405f, 0.03127416f, 0.10767471f, -0.09223806f, -0.08511742f, 
    0.29770815f, -0.09616557f, -0.02752058f, 0.10021555f, -0.01355727f, -0.45935899f, -0.08410282f, -0.00650685f, 
    -0.02974604f, 0.03902005f, -0.08685736f, 0.15564507f, -0.00709217f, -0.00601585f, 0.06822714f, 0.07676191f, 
    -0.03052044f, 0.00090520f, 0.02611062f, 0.07224326f, 0.11203249f, -0.12741153f, 0.01647775f, -0.00722887f, 
    -0.18910871f, -0.13744493f, -0.07700516f, -0.29510945f, 0.21757889f, -0.21608400f, 0.08553930f, -0.21938749f, 
    0.01102734f, -0.14397882f, -0.05371170f, 0.06267381f, 0.12750024f, 0.00704813f, 0.07771117f, -0.00789980f, 
    -0.16141686f, 0.03218561f, 0.11893427f, 0.12484448f, -0.11046524f, -0.06867699f, -0.08493581f, 0.02258847f, 
    0.02700872f, -0.10481318f, 0.10127225f, 0.07459206f, 0.07404502f, 0.23388509f, 0.21013640f, -0.23061368f, 
    0.09475356f, -0.06460063f, -0.09326340f, -0.00313638f, -0.02054796f, 0.00656702f, -0.15901446f, -0.01364605f, 
    0.04207345f, 0.01768819f, 0.05610608f, -0.07961941f, 0.24556068f, 0.06307869f, 0.10960878f, 0.14812666f, 
    0.10369947f, 0.01476708f, -0.02490924f, 0.04854229f, 0.12847120f, -0.01442371f, -0.06668681f, -0.08033030f, 
    0.14912686f, 0.16946402f, 0.13646321f, 0.02038575f, 0.00219272f, 0.04267965f, -0.01874555f, 0.00286748f, 
    -0.19551103f, -0.10217682f, -0.13375607f, -0.04292330f, 0.02941414f, -0.05087354f, -0.08684738f, -0.17226295f, 
    0.19066288f, 0.09532386f, 0.14601792f, 0.18871772f, -0.03813039f, -0.37527213f, -0.17888942f, -0.17866045f, 
    -0.04911130f, 0.02831628f, -0.07487472f, -0.01234632f, 0.03730397f, -0.04646089f, -0.14115325f, 0.10992989f, 
    -0.17777349f, -0.11550390f, 0.00192192f, 0.05104390f, -0.03896214f, 0.11888900f, 0.08478432f, -0.08584499f, 
    -0.05700660f, -0.03500137f, 0.05183216f, -0.02080633f, 0.02446116f, 0.03052168f, 0.12127138f, -0.01585747f, 
    0.16780387f, 0.13530754f, 0.03235104f, 0.15501879f, 0.04550912f, 0.04305156f, 0.12339539f, -0.00510185f, 
    -0.01932187f, -0.05464468f, -0.02643801f, 0.00664468f, 0.07054657f, 0.14534616f, 0.04772390f, 0.08933250f, 
    0.11280321f, -0.18855591f, -0.08371016f, -0.13619082f, -0.15267543f, -0.29264641f, -0.15333034f, 0.08309594f, 
    0.01057734f, 0.11621197f, 0.05374040f, 0.11681616f, 0.18689148f, 0.18525760f, 0.09897538f, -0.13260710f, 
    0.30552736f, 0.24973673f, -0.09898499f, 0.17313659f, 0.15806133f, 0.20330647f, 0.05743084f, 0.04014971f, 
    0.14560373f, 0.12370194f, 0.10804299f, 0.16402987f, -0.03958195f, -0.00766679f, 0.13949484f, -0.13161458f, 
    -0.09768213f, -0.10223702f, -0.11956526f, -0.07442590f, -0.00189782f, 0.19415097f, 0.16366781f, 0.27789283f, 
    0.04632427f, -0.13142397f, -0.02155974f, 0.14367895f, 0.18068895f, 0.12105229f, 0.01103908f, 0.02922774f, 
    0.10923457f, 0.04864343f, -0.01383267f, 0.02102226f, 0.13598721f, -0.50732547f, -0.20030540f, -0.02182679f, 
    -0.00174814f, 0.06268165f, 0.07126921f, 0.22215442f, 0.00742232f, -0.07070248f, 0.10169344f, -0.04554304f, 
    0.19834678f, 0.16778953f, -0.01679273f, 0.00522096f, 0.04684130f, 0.02921978f, 0.05476819f, -0.02221054f, 
    -0.03646208f, -0.03412092f, -0.02918153f, -0.03915975f, 0.23809211f, -0.08550297f, -0.32151070f, -0.49721080f, 
    0.15847300f, -0.13850619f, 0.04898001f, -0.17405109f, 0.07905125f, -0.04129104f, -0.01980475f, -0.09936994f, 
    0.01419926f, 0.07006859f, 0.00603024f, -0.07909290f, -0.06380399f, -0.05457629f, -0.05818839f, -0.02127545f, 
    0.02385399f, -0.04612403f, 0.01666689f, -0.06845366f, 0.23919635f, 0.59994996f, 0.15891610f, -0.19615966f, 
    -0.07243590f, -0.21122551f, -0.05929529f, -0.01265703f, -0.04829112f, -0.03755394f, -0.07000450f, 0.03488722f, 
    0.02379509f, -0.08206221f, -0.06940945f, 0.02594590f, 0.19954528f, -0.02633447f, 0.04228658f, -0.00984762f, 
    0.06091835f, -0.05193708f, 0.01959262f, 0.09609320f, 0.07865906f, -0.09512513f, -0.05896949f, 0.07325917f, 
    0.21441291f, 0.13964757f, 0.03790207f, 0.22271816f, 0.08029822f, 0.17427494f, -0.00814170f, 0.11949056f, 
    -0.14483821f, 0.12967457f, -0.03646322f, 0.01143958f, -0.05734448f, -0.13931566f, -0.09276808f, -0.02068276f, 
    0.10013688f, 0.07091380f, 0.20492214f, -0.01335048f, 0.10148204f, -0.25535807f, -0.07063284f, -0.08238609f, 
    -0.08310252f, 0.05975554f, 0.04463923f, 0.08836649f, 0.01066712f, -0.08715822f, -0.13014351f, -0.03863700f, 
    -0.12888113f, -0.14886932f, -0.11319938f, 0.27286175f, 0.03333388f, 0.02943687f, 0.12853712f, 0.02412822f, 
    -0.05318502f, -0.07294717f, -0.00245385f, -0.00773550f, 0.24527858f, -0.02640553f, 0.20809527f, 0.22976272f, 
    0.08142211f, 0.04899826f, 0.10397550f, 0.08736469f, -0.07004980f, -0.08346919f, 0.10703555f, 0.05132927f, 
    -0.20939554f, -0.11195105f, -0.10988829f, 0.22630729f, 0.12428852f, 0.05876490f, 0.09776929f, 0.12502523f, 
    -0.06623373f, -0.07193042f, 0.01836132f, 0.04543429f, 0.14489882f, -0.27185720f, -0.03331438f, 0.25864357f, 
    -0.00840205f, 0.11905568f, 0.23031440f, 0.19063096f, 0.08431157f, 0.22237583f, 0.07810768f, -0.02488770f, 
    -0.17292254f, -0.19487157f, -0.01177748f, 0.28833637f, -0.00676807f, 0.19387770f, -0.01845759f, 0.06384609f, 
    -0.05761752f, 0.00571337f, 0.12957892f, 0.06246184f, -0.02819623f, 0.10288372f, 0.12136579f, -0.25845057f, 
    -0.01777047f, -0.08960998f, 0.04196787f, 0.05377979f, -0.06619600f, 0.15907906f, 0.11744241f, 0.12333369f, 
    -0.04385268f, 0.12705919f, 0.01237239f, 0.01932562f, 0.07360371f, -0.03675250f, 0.00668264f, -0.00647575f, 
    0.18082246f, -0.01507876f, -0.01214817f, 0.12572725f, 0.10007878f, 0.08703519f, -0.03392665f, -0.12273312f, 
    -0.17692469f, 0.13985176f, 0.06868464f, 0.20499134f, 0.06736518f, -0.01531092f, -0.01881537f, 0.05113919f, 
    -0.13773458f, -0.19854699f, 0.29279977f, -0.09401710f, -0.02084386f, 0.03071675f, 0.05887337f, 0.06547909f, 
    -0.21279211f, -0.00238220f, -0.17609122f, -0.10133754f, -0.17925476f, -0.14128685f, -0.10822511f, -0.07831081f, 
    -0.13439523f, -0.13403991f, -0.03199046f, 0.13031955f, 0.08732655f, 0.12771726f, 0.01051492f, 0.04414670f, 
    -0.07320394f, -0.08007868f, 0.08723634f, 0.08434349f, -0.00006838f, 0.01354955f, -0.03924606f, -0.07904047f, 
    0.01093184f, -0.05404345f, -0.03065397f, 0.24983758f, 0.03150303f, 0.03878126f, 0.37703377f, -0.09297653f, 
    0.10056014f, -0.12217616f, 0.04620411f, -0.00407495f, 0.03653020f, -0.15751417f, -0.08048774f, -0.16784875f, 
    -0.18930809f, 0.09614079f, 0.16091917f, -0.05435877f, 0.06457659f, 0.02383351f, -0.05684988f, 0.07114500f, 
    0.04466308f, 0.03288546f, -0.04951842f, 0.10498339f, 0.15327573f, 0.09652417f, 0.34881514f, -0.00778703f, 
    0.02721608f, 0.23052682f, 0.05291666f, -0.18542433f, 0.13580136f, 0.03423927f, 0.07391416f, 0.10674588f, 
    -0.08883636f, -0.04150008f, 0.12296323f, -0.04142135f, -0.04194388f, 0.22608620f, -0.03490092f, 0.05698777f, 
    0.04274034f, 0.09347841f, 0.02679674f, -0.01107122f, -0.36133733f, -0.07348865f, -0.13647261f, -0.03112520f, 
    -0.08464024f, -0.06570257f, 0.01908840f, 0.04670875f, 0.04280376f, -0.14689380f, -0.00579277f, 0.03444639f, 
    -0.02114940f, -0.00007559f, 0.00946831f, 0.00090039f, 0.01622557f, -0.00794240f, -0.13509111f, -0.07618940f, 
    -0.00168302f, 0.06681832f, 0.01967139f, -0.10895991f, -0.17270912f, -0.03723544f, 0.08907271f, 0.32752270f, 
    0.19114773f, -0.10161287f, 0.00280120f, -0.05313624f, 0.01075900f, -0.04584824f, 0.07484104f, 0.01279538f, 
    -0.08519740f, 0.19935144f, -0.16070284f, -0.12043245f, -0.00006902f, -0.03750486f, 0.05096718f, 0.15963981f, 
    0.24473014f, -0.10355277f, -0.20762925f, 0.07181724f, -0.04920609f, -0.15173453f, -0.08469593f, 0.02814861f, 
    -0.01825536f, 0.12016758f, 0.06144697f, -0.05015663f, 0.11297609f, 0.08913089f, -0.10533187f, -0.04542892f, 
    0.20138444f, -0.19459917f, 0.22892243f, 0.25903603f, 0.10316942f, 0.12392100f, 0.13494793f, 0.20142084f, 
    0.10760619f, -0.06060158f, 0.09296709f, 0.02110127f, -0.11576770f, 0.03233060f, -0.05418273f, -0.03730318f, 
    -0.15224832f, -0.12714432f, 0.05773909f, -0.07280948f, -0.09220563f, -0.01020058f, 0.02863940f, 0.23783252f, 
    -0.02495358f, 0.07544643f, -0.02676094f, -0.16885272f, -0.10020009f, 0.08171780f, 0.19462146f, 0.19125937f, 
    -0.15490673f, -0.11440015f, 0.20899564f, -0.04254870f, -0.11317448f, 0.45956954f, 0.38459313f, 0.24866760f, 
    0.02204179f, -0.12219545f, 0.01491045f, -0.04615941f, -0.00226042f, 0.23524907f, -0.04596933f, 0.00694754f, 
    0.14544743f, 0.30419320f, -0.23646106f, 0.03552552f, -0.04337089f, 0.08849559f, 0.20501198f, 0.33671355f, 
    0.03723577f, 0.13800094f, 0.20019586f, 0.10748326f, -0.29470965f, 0.29803091f, 0.12121080f, 0.14124720f, 
    0.08647476f, 0.05313271f, 0.01305703f, -0.03844864f, 0.00324423f, -0.04964208f, 0.18075366f, 0.10602865f, 
    0.02031949f, 0.02869974f, -0.11510845f, 0.02028130f, -0.06754707f, -0.02217573f, -0.04001220f, 0.04928285f, 
    -0.06631518f, 0.09567764f, 0.12243336f, 0.17133284f, -0.16450642f, -0.15330778f, -0.12079265f, 0.54903841f, 
    -0.00212285f, 0.13078307f, -0.04251063f, -0.05613177f, -0.00761209f, -0.01694870f, -0.03685356f, -0.07604669f, 
    -0.03158016f, 0.06509733f, -0.43782553f, -0.00029928f, -0.07959321f, 0.06289523f, 0.02104769f, 0.03637197f, 
    -0.09490964f, 0.03489185f, -0.03076702f, 0.03104804f, 0.15609480f, 0.28772518f, -0.11757144f, -0.21244822f, 
    -0.17457247f, -0.11295874f, 0.03732753f, -0.26696277f, 0.01467906f, -0.03083149f, 0.07058019f, -0.09123710f, 
    -0.05214147f, -0.22161047f, -0.05506056f, 0.08102381f, -0.01818052f, -0.04509739f, 0.05418957f, 0.07038868f, 
    -0.12382223f, -0.10902373f, -0.02826810f, 0.00640192f, -0.09474666f, 0.10098754f, 0.01765149f, 0.04285212f, 
    0.01702697f, -0.09431791f, -0.00190667f, 0.01276375f, -0.00436053f, 0.14877197f, 0.11315735f, -0.01329721f, 
    0.21434942f, 0.05355525f, 0.06075983f, -0.01963983f, 0.24947721f, 0.00033791f, 0.02144161f, -0.00580834f, 
    0.06317674f, 0.04183326f, 0.11880400f, 0.10207722f, 0.04915182f, -0.29547924f, -0.31098953f, 0.29171276f, 
    0.10081059f, -0.00059448f, 0.03943164f, -0.17704819f, 0.00885808f, 0.09637598f, -0.04395995f, 0.13394395f, 
    0.02722089f, 0.37907726f, 0.13370387f, 0.15271109f, 0.02437416f, -0.08161111f, 0.06527604f, 0.16968015f, 
    0.14352709f, -0.02827068f, 0.07236553f, 0.05061167f, 0.05016062f, 0.30607364f, 0.16694073f, -0.09642609f, 
    -0.05991545f, -0.16132309f, -0.22856799f, 0.02522014f, -0.02098324f, -0.02019666f, -0.01922393f, -0.03959431f, 
    0.07171516f, 0.23296134f, -0.24565238f, -0.20081368f, 0.08090743f, -0.05495783f, 0.04950795f, 0.25550991f, 
    -0.05240062f, -0.03064463f, -0.05418289f, 0.19193739f, 0.01094051f, -0.08832408f, -0.00305646f, 0.07769265f, 
    -0.01082514f, 0.01956806f, -0.02546693f, -0.17195125f, -0.03413020f, -0.09866943f, 0.10324883f, -0.17405967f, 
    -0.00207303f, -0.00421772f, -0.00688778f, 0.00139724f, 0.06056900f, 0.00935977f, -0.02614017f, -0.02447910f, 
    -0.02395233f, -0.07037381f, -0.05280963f, -0.04113813f, -0.03427533f, 0.02026528f, -0.00866389f, -0.07132152f, 
    0.02043128f, -0.00267585f, 0.01930838f, -0.03618874f, -0.04360246f, -0.05494040f, -0.02444984f, -0.06316412f, 
    -0.00054265f, -0.05289174f, 0.01646978f, 0.05191503f, -0.04189948f, 0.02735218f, 0.02362943f, 0.03350216f, 
    0.02898761f, -0.03726007f, -0.05929095f, 0.01042522f, -0.05921626f, 0.02773510f, -0.00345975f, -0.00831169f, 
    -0.06295141f, -0.01244374f, 0.04117734f, 0.00256377f, -0.08430904f, 0.00900593f, 0.04701112f, 0.03920532f, 
    -0.04201576f, -0.02534927f, -0.05083730f, -0.00387382f, 0.01843801f, -0.05803438f, 0.04684456f, 0.04870980f, 
    -0.07117754f, -0.11429992f, -0.07726566f, 0.02307398f, -0.02076381f, -0.05707646f, 0.00350459f, -0.08878060f, 
    0.00028799f, 0.03921898f, -0.02242413f, -0.02011045f, 0.04293699f, -0.01302240f, 0.00907022f, -0.06637218f, 
    0.00149249f, -0.06173697f, -0.02709177f, -0.00121799f, 0.03851335f, 0.03107707f, -0.04085341f, 0.02042372f, 
    -0.04106653f, 0.06048275f, 0.05453772f, -0.04514620f, 0.02875792f, 0.05455822f, -0.05602701f, -0.08492985f, 
    -0.03492634f, -0.02828560f, 0.02552689f, -0.03217799f, 0.01805225f, -0.04677442f, 0.00992536f, -0.06131639f, 
    0.02206663f, -0.02733438f, 0.02938971f, 0.03690566f, 0.03748781f, -0.00301605f, -0.03944565f, -0.04651100f, 
    -0.03300149f, 0.04487537f, -0.06423234f, -0.04545406f, -0.02323467f, -0.06158725f, 0.04861388f, 0.03233353f, 
    0.04503062f, 0.03259197f, 0.00099029f, -0.04089618f, 0.00273200f, -0.08790031f, 0.00171663f, 0.01399910f, 
    -0.10173043f, -0.02343600f, -0.04295585f, 0.01912654f, -0.07934964f, -0.08043309f, -0.04136030f, -0.08209302f, 
    -0.06739049f, 0.01219979f, 0.06501902f, -0.03795332f, -0.07487218f, -0.07760764f, -0.02862071f, -0.00999402f, 
    0.05693589f, -0.03328387f, -0.05667322f, -0.05306012f, 0.03578122f, -0.01482113f, -0.04636797f, -0.03418907f, 
    -0.03424212f, -0.08143868f, -0.07546814f, -0.02815877f, -0.00272371f, 0.06335171f, -0.02646072f, -0.03847572f, 
    0.03663544f, -0.03360892f, -0.01840803f, 0.03221270f, -0.10502160f, -0.03952260f, -0.10073146f, -0.08775538f, 
    -0.00743516f, -0.04360530f, -0.02894549f, -0.09615530f, -0.00051205f, 0.00787963f, 0.05742835f, -0.06309360f, 
    -0.04701586f, 0.04157113f, 0.03138670f, -0.01356313f, -0.09867071f, 0.01217126f, -0.00043179f, -0.03429786f, 
    0.04194609f, -0.07100646f, -0.07431922f, -0.06501985f, -0.06233666f, 0.03663270f, -0.05214361f, -0.03173893f, 
    -0.06838439f, -0.02302280f, -0.04249382f, -0.00249997f, -0.04261290f, -0.09950363f, -0.11164951f, -0.09234373f, 
    0.07397390f, -0.00124798f, 0.24860211f, -0.02390415f, 0.23769820f, 0.12436254f, 0.06627536f, 0.13541318f, 
    0.25789714f, 0.06473780f, -0.04970759f, 0.00422132f, -0.05906941f, -0.05939757f, 0.11315699f, -0.10594881f, 
    0.01180526f, -0.00881047f, -0.13006064f, 0.11607455f, 0.11437192f, 0.03153249f, 0.12207977f, -0.01844921f, 
    -0.12173656f, 0.13834158f, -0.14056012f, 0.26300356f, 0.11085939f, -0.01520082f, -0.15145536f, 0.04407523f, 
    -0.08112177f, -0.04653203f, -0.03616522f, -0.17673239f, -0.24815874f, 0.06615975f, 0.15472004f, -0.15580058f, 
    0.02088886f, 0.01026119f, -0.20339929f, 0.02998852f, 0.05318686f, 0.06890216f, -0.03262640f, -0.08900621f, 
    -0.00073672f, 0.29642031f, 0.11113986f, 0.04218687f, -0.08010764f, -0.12280240f, 0.02171568f, -0.12929770f, 
    0.10121092f, 0.10600303f, -0.03399698f, -0.02022422f, -0.23685294f, -0.15469944f, -0.04476937f, -0.05907359f, 
    -0.12187434f, 0.09565949f, -0.13654055f, -0.02823256f, -0.08112531f, -0.20829032f, -0.07772595f, -0.12877929f, 
    -0.11229857f, -0.00306882f, -0.03792826f, 0.20445018f, 0.16805720f, 0.08243965f, 0.03391896f, 0.12131655f, 
    0.07705376f, 0.06837013f, -0.01980982f, -0.00116687f, -0.35406682f, -0.07049608f, -0.29773265f, 0.15086587f, 
    0.10279766f, 0.02441853f, 0.04641785f, 0.17315717f, -0.00687473f, 0.11843163f, 0.00347254f, 0.04562362f, 
    0.01841615f, -0.14105952f, -0.12763740f, -0.00087559f, 0.02509764f, 0.09457942f, 0.09101637f, 0.02203877f, 
    0.21099794f, -0.03406832f, 0.13681047f, 0.33174533f, 0.17595945f, -0.07151834f, -0.04155914f, -0.05267522f, 
    0.02732388f, -0.08440761f, -0.06573181f, -0.07272717f, -0.00091301f, -0.00236854f, 0.02190490f, 0.14677750f, 
    -0.33758596f, -0.21375105f, -0.23874047f, 0.01166943f, -0.15394981f, -0.00606589f, 0.02852926f, -0.06132311f, 
    -0.14616442f, -0.09847325f, -0.05272716f, -0.05713451f, 0.22663549f, 0.05653921f, 0.10895546f, 0.12061702f, 
    0.20505013f, -0.08236382f, 0.14361353f, 0.21481441f, -0.04309464f, 0.01730172f, 0.07793907f, 0.09866074f, 
    -0.00385601f, 0.18519139f, 0.13213280f, 0.12145498f, 0.09533633f, 0.08893998f, 0.04801960f, 0.06242948f, 
    0.01801305f, 0.03475513f, -0.02219576f, -0.18338054f, 0.10690952f, 0.07813849f, 0.17781019f, -0.18008433f, 
    0.11543206f, 0.05713649f, 0.00333353f, 0.06704854f, -0.00832199f, 0.17565493f, 0.12066092f, -0.14144723f, 
    0.07798197f, 0.41774032f, -0.02451895f, 0.17649730f, 0.01769504f, 0.09594799f, 0.33119112f, 0.10642744f, 
    0.09916255f, 0.14315012f, 0.00444693f, 0.15426713f, -0.10718279f, -0.16911164f, -0.04365113f, 0.09445278f, 
    -0.28164414f, -0.12230738f, -0.19602539f, -0.13805914f, 0.04699393f, 0.23620056f, 0.03985471f, 0.12724082f, 
    -0.31740475f, 0.01726178f, 0.08112320f, 0.19330737f, -0.04335454f, 0.03349596f, 0.02176059f, -0.11141150f, 
    0.10789300f, 0.06784911f, 0.15709287f, -0.03195284f, -0.09410857f, 0.09919443f, 0.27080581f, 0.41999224f, 
    0.02930393f, 0.05010647f, 0.03923460f, 0.10783280f, -0.11555736f, -0.03737711f, 0.00465057f, -0.07614350f, 
    -0.13327527f, -0.13278279f, -0.02071070f, 0.14827074f, -0.18838684f, 0.07972693f, 0.03884725f, 0.19903812f, 
    -0.12761553f, 0.00459228f, 0.07214653f, 0.07756136f, -0.06269295f, -0.08092862f, 0.10788480f, -0.26251888f, 
    0.22267763f, -0.01105769f, -0.04572434f, 0.30413485f, -0.06839963f, 0.01574520f, -0.03271781f, 0.16434491f, 
    -0.21836635f, -0.09288073f, -0.14397636f, -0.24852113f, -0.16180795f, 0.11776527f, -0.10051489f, 0.31726077f, 
    0.12796307f, -0.01374429f, 0.02360410f, 0.29811108f, -0.01016145f, -0.05861993f, 0.38513792f, 0.32975385f, 
    0.10982784f, 0.20085233f, -0.10291611f, -0.18809104f, -0.00037659f, 0.09812575f, -0.03800971f, 0.11083599f, 
    -0.32723197f, -0.14976282f, -0.04965705f, -0.09851234f, 0.06379338f, -0.07966699f, -0.06407700f, 0.02459317f, 
    0.00156652f, 0.06729276f, -0.12420536f, 0.01221153f, 0.16053471f, -0.12549233f, 0.19210957f, 0.17245492f, 
    0.19901554f, 0.03327179f, 0.03139113f, -0.02254682f, 0.05723619f, 0.00992786f, -0.15590598f, -0.19256911f, 
    -0.51266301f, -0.06742087f, 0.16150270f, 0.06959783f, 0.09996249f, 0.13077851f, -0.11031827f, -0.14513844f, 
    0.08470698f, -0.12898391f, -0.04629466f, 0.05280666f, -0.16433689f, 0.03020563f, 0.22817968f, 0.00437723f, 
    0.07660837f, -0.09180420f, 0.25769874f, 0.34747571f, 0.01961704f, -0.14550878f, -0.03013352f, 0.06622139f, 
    -0.23924351f, -0.10945307f, 0.07674362f, 0.33237016f, 0.05612598f, 0.02323325f, 0.19125620f, 0.02020087f, 
    -0.01857298f, -0.02644952f, -0.08152451f, -0.12889157f, 0.08530788f, -0.51665318f, 0.13536930f, 0.33790559f, 
    0.10422964f, -0.01227639f, 0.10009798f, -0.00269333f, 0.07733127f, -0.10409453f, 0.15719920f, 0.09409894f, 
    -0.15357442f, 0.09606025f, 0.09939653f, 0.25069264f, 0.07789078f, -0.10165294f, 0.17113952f, 0.16816522f, 
    0.01560242f, -0.05825868f, -0.00962923f, -0.02105295f, 0.12773886f, -0.01548010f, -0.02136746f, 0.30783990f, 
    0.03530743f, -0.05674266f, -0.07324886f, -0.08471221f, 0.07750890f, 0.17283970f, -0.03230875f, -0.14179103f, 
    0.21079502f, 0.22173573f, -0.33478549f, 0.14417891f, 0.00507237f, 0.00834418f, -0.00158944f, 0.19658969f, 
    -0.03527099f, 0.15020221f, 0.09325217f, -0.03583240f, -0.12683637f, -0.04298633f, -0.10148779f, -0.38000068f, 
    -0.37171131f, -0.02321762f, -0.17551775f, -0.05013583f, 0.08957072f, -0.11124033f, 0.14452535f, -0.06305652f, 
    -0.05426697f, 0.13460022f, 0.00687206f, -0.07105657f, -0.07986730f, 0.07778060f, 0.20857072f, 0.08311392f, 
    0.10762579f, -0.12735772f, 0.09491426f, 0.03134371f, -0.27967858f, 0.05858441f, 0.04552247f, -0.00090894f, 
    -0.09664196f, 0.14782716f, 0.16548444f, 0.02704244f, 0.16833112f, -0.00812077f, -0.03283753f, 0.08826227f, 
    -0.05942047f, -0.14904410f, 0.07416970f, -0.12122384f, -0.06359115f, -0.04211679f, 0.18569025f, 0.05620041f, 
    -0.05926728f, 0.05396540f, -0.02275742f, -0.13123220f, -0.19897500f, 0.09459617f, -0.13279009f, 0.19888265f, 
    -0.10376557f, 0.02841388f, 0.02599927f, 0.14788496f, 0.07656720f, -0.11485737f, 0.00190620f, 0.01904791f, 
    -0.08037134f, -0.09525619f, -0.05245967f, -0.02456792f, 0.05846808f, 0.01614350f, -0.08983953f, 0.06626126f, 
    0.05195092f, 0.07513550f, -0.01192705f, 0.13453729f, -0.06650849f, 0.20431501f, 0.08071757f, 0.11319195f, 
    -0.03077395f, 0.04190769f, 0.13011660f, -0.14872259f, -0.04899608f, -0.00519976f, 0.03060197f, -0.05755340f, 
    0.03092222f, 0.15039700f, -0.02847038f, -0.13962863f, 0.01680652f, -0.00246654f, 0.05041763f, 0.02517438f, 
    0.02351453f, 0.11493471f, 0.15036321f, 0.15701707f, 0.34178787f, 0.20778613f, 0.19404030f, -0.23013826f, 
    -0.03938770f, 0.13566427f, 0.04241068f, -0.25628069f, 0.13754986f, -0.06517342f, -0.03543464f, 0.03082581f, 
    -0.00601611f, 0.02707402f, 0.08544745f, 0.04758011f, -0.05139502f, 0.11426178f, -0.05172245f, -0.01482143f, 
    0.02890308f, -0.04022254f, -0.03807385f, 0.05073779f, -0.44814509f, -0.13943918f, -0.12662576f, 0.13014065f, 
    0.00682775f, 0.02214852f, 0.09579911f, 0.01866002f, -0.03504340f, -0.09676238f, -0.01235078f, 0.09943808f, 
    0.13502748f, -0.02462911f, 0.05086920f, -0.06855948f, 0.07995237f, -0.02327242f, -0.20002571f, -0.01990790f, 
    -0.03320152f, 0.02954251f, 0.01751738f, -0.02835238f, -0.18221147f, -0.03826454f, -0.14060000f, 0.34228277f, 
    0.15059029f, -0.01772936f, 0.03266991f, -0.08151986f, -0.08662847f, -0.00172244f, 0.15008365f, 0.09517229f, 
    0.00181008f, 0.07221638f, -0.09240382f, -0.04686217f, 0.07026460f, -0.10959446f, 0.17942615f, 0.04407270f, 
    0.15704200f, -0.07935122f, -0.21574880f, -0.05581516f, -0.50519681f, -0.15120481f, -0.18331851f, -0.05263877f, 
    0.05057740f, 0.00522332f, -0.06467029f, -0.13576786f, 0.15417084f, -0.04352597f, -0.18761161f, -0.01608465f, 
    0.18427326f, -0.10766230f, 0.19026077f, 0.00345825f, 0.15565129f, 0.09459837f, 0.07467766f, 0.14920722f, 
    -0.01849209f, -0.03373977f, -0.08673519f, 0.18405135f, -0.03469826f, 0.10124957f, -0.08414488f, 0.14891230f, 
    -0.06874771f, -0.02139791f, 0.07984375f, -0.06457397f, -0.06532834f, 0.04900083f, 0.13511635f, 0.19152187f, 
    -0.02020946f, 0.00339019f, 0.00492345f, -0.01723864f, 0.00665068f, -0.03596349f, -0.07020295f, 0.03946700f, 
    0.05226623f, 0.04882522f, 0.00144689f, -0.06811374f, -0.05596673f, -0.00428212f, 0.02689875f, -0.01810902f, 
    -0.06662327f, -0.00348993f, -0.01131818f, -0.05618475f, -0.00217329f, -0.06270655f, -0.02509081f, -0.06151608f, 
    0.06531677f, 0.03871301f, -0.04367793f, -0.01181606f, 0.06055582f, 0.05121769f, 0.04303047f, 0.03101066f, 
    -0.02988495f, 0.04184610f, -0.01580388f, 0.00855880f, 0.01448747f, -0.03315279f, -0.04776319f, -0.02723317f, 
    0.02472468f, -0.07122459f, -0.04859485f, -0.06918368f, 0.00256038f, 0.01779061f, -0.03456425f, 0.01490434f, 
    -0.00400091f, 0.03931297f, -0.00424202f, 0.01183937f, 0.02580283f, -0.01839100f, -0.02941801f, -0.07176586f, 
    0.00615751f, 0.02836304f, 0.01847996f, 0.04256397f, -0.07094439f, 0.04676476f, 0.00803414f, -0.07583274f, 
    0.00421286f, -0.00592342f, -0.03661047f, 0.05328703f, 0.03746141f, -0.04882566f, 0.05639024f, 0.04516258f, 
    -0.03026188f, -0.04584593f, 0.06471049f, -0.01506064f, -0.01543523f, -0.06674879f, 0.04117157f, -0.05605763f, 
    -0.03302336f, -0.07110812f, -0.04406394f, -0.03814374f, -0.02871810f, 0.00093382f, -0.04988351f, 0.02085827f, 
    0.05482106f, 0.05923941f, -0.03082346f, -0.05949295f, -0.04346016f, -0.04091728f, 0.04078480f, -0.03504337f, 
    0.00195490f, -0.00097777f, -0.00742895f, -0.00217018f, -0.05945868f, -0.00735863f, -0.07097672f, -0.04083127f, 
    -0.04816266f, -0.00550084f, 0.01233295f, -0.01573643f, 0.05730212f, -0.05680444f, 0.06538159f, -0.07639543f, 
    0.03039360f, -0.04260714f, -0.00203310f, -0.02477159f, -0.03838225f, -0.01605813f, 0.04386595f, 0.04611683f, 
    -0.07630789f, 0.03324750f, 0.02689571f, -0.06738935f, 0.04386222f, 0.05932195f, -0.06192103f, -0.00250366f, 
    0.01570641f, 0.03699294f, -0.04728442f, -0.04526981f, 0.00635159f, -0.02423826f, 0.00229358f, 0.00727342f, 
    0.01972154f, -0.07004283f, 0.02146230f, -0.05214810f, -0.05572693f, 0.05034057f, -0.01784001f, -0.07174394f, 
    0.00352409f, -0.01388129f, 0.02471172f, -0.00197556f, -0.02159050f, -0.03349503f, -0.05641440f, -0.07646444f, 
    0.06463432f, 0.01891373f, 0.04165473f, 0.01410192f, -0.05924032f, 0.03497027f, -0.00612229f, -0.04540711f, 
    -0.04004676f, 0.02174518f, -0.00443264f, 0.05797156f, -0.00991990f, 0.03617327f, -0.07480352f, -0.07128619f, 
    -0.02118085f, -0.00079623f, -0.03603036f, -0.00298484f, -0.05439299f, 0.01183107f, -0.03206433f, -0.02129435f, 
    0.00332719f, 0.06269176f, -0.00417856f, -0.06871773f, -0.04369707f, -0.03350982f, -0.07711910f, -0.07661892f, 
    -0.03056320f, 0.04529377f, -0.07622913f, 0.05170901f, -0.06834996f, -0.05002084f, 0.01421850f, 0.00670666f, 
    0.25544301f, 0.09201830f, 0.13392442f, -0.15028644f, 0.04731433f, 0.03845400f, 0.01220008f, -0.00333250f, 
    -0.07062242f, -0.07260858f, -0.11273631f, 0.02433605f, 0.06489419f, -0.02652832f, -0.28249210f, -0.02486719f, 
    -0.19898322f, 0.05272969f, 0.07955913f, 0.09971489f, 0.12932883f, -0.02522435f, 0.16226639f, -0.09293300f, 
    0.13196419f, 0.06683014f, 0.20391670f, -0.12737848f, 0.00527354f, -0.03127022f, 0.20644771f, -0.05941489f, 
    0.01179230f, -0.05263444f, -0.08793031f, -0.03906427f, -0.09254979f, 0.05098715f, -0.50903499f, -0.04769942f, 
    -0.07476164f, -0.28075233f, 0.10851330f, -0.07722912f, 0.04699038f, 0.06981141f, 0.11552617f, 0.08305168f, 
    0.04470430f, -0.12430163f, 0.13848452f, 0.01394612f, 0.05033797f, -0.06439671f, -0.13444866f, -0.01005853f, 
    0.03302809f, -0.05067792f, 0.03456701f, -0.02418995f, 0.21413751f, 0.90462577f, 0.07122583f, -0.10143097f, 
    0.05897595f, -0.34039962f, 0.02107446f, 0.00233848f, -0.00479663f, -0.09880741f, -0.20695639f, -0.04153501f, 
    0.20985602f, 0.09620965f, 0.03039282f, 0.00652342f, 0.12106842f, -0.01155504f, 0.12819768f, -0.03575390f, 
    -0.07279684f, -0.14502957f, -0.00051805f, -0.00544631f, 0.20044030f, -0.09740663f, 0.06045470f, -0.07005180f, 
    0.04710593f, 0.17258504f, -0.00534016f, -0.05240101f, 0.09660973f, 0.03846983f, -0.00781607f, 0.10636687f, 
    0.04655216f, 0.07480928f, 0.08415438f, -0.01570366f, -0.10219914f, 0.02569413f, 0.02809506f, 0.11166202f, 
    -0.00475486f, 0.13828392f, 0.18755899f, 0.02697343f, -0.25900972f, 0.09137303f, -0.05502453f, 0.21239427f, 
    -0.19306859f, -0.08683509f, -0.02480577f, -0.04565589f, 0.00890611f, 0.13638729f, 0.08912259f, 0.06796265f, 
    -0.12432556f, -0.12938955f, -0.31887010f, -0.18644851f, -0.15428187f, -0.00839968f, -0.28934902f, -0.04310407f, 
    -0.09812001f, -0.01845105f, -0.04170270f, -0.09772756f, 0.22818378f, 0.43955672f, 0.09608594f, 0.50062925f, 
    0.19530399f, -0.05965757f, 0.12855865f, 0.06668267f, -0.13905871f, 0.13295403f, 0.11073359f, -0.05156973f, 
    -0.03844114f, 0.07264689f, -0.21294671f, 0.02492552f, -0.02600202f, 0.06409720f, 0.11891109f, 0.04173224f, 
    0.00001359f, -0.05080070f, -0.02859545f, -0.05396109f, -0.14082813f, -0.37093639f, 0.02636163f, 0.08264308f, 
    -0.00698506f, 0.20163569f, 0.09378991f, 0.02112782f, 0.05508554f, 0.03702475f, -0.03049230f, 0.02006576f, 
    -0.07182118f, -0.18778263f, 0.54992425f, 0.32652614f, 0.14003375f, 0.33259892f, 0.10890647f, -0.03570729f, 
    -0.07775579f, 0.00784975f, -0.00376738f, 0.10734126f, -0.02570822f, 0.09236469f, -0.05428938f, -0.01832225f, 
    -0.08714034f, -0.07114082f, -0.02827544f, 0.00955496f, -0.15309328f, 0.06512371f, -0.01025882f, 0.25321430f, 
    -0.02128933f, -0.07175810f, 0.05987677f, 0.05451925f, -0.07249415f, 0.04288231f, -0.05977609f, -0.03407465f, 
    0.00357789f, -0.03436345f, 0.01464111f, -0.00350665f, -0.03156511f, 0.02912347f, 0.05669738f, -0.07941682f, 
    -0.01415468f, 0.05121509f, 0.05941068f, 0.00585671f, -0.01997985f, -0.01825854f, -0.05992261f, 0.00080664f, 
    -0.06021760f, -0.03680924f, -0.04141835f, -0.07298093f, -0.06529802f, 0.03883036f, -0.00558104f, 0.04442839f, 
    -0.00016138f, -0.06434105f, -0.08081544f, 0.05747698f, -0.04483018f, 0.01478326f, -0.05193956f, -0.00163586f, 
    -0.03797389f, -0.01751801f, -0.00439781f, 0.04735754f, -0.00114388f, 0.02352707f, -0.02910040f, 0.02132153f, 
    0.05088324f, -0.02522102f, -0.04280332f, 0.05555918f, -0.00254107f, -0.05154049f, 0.04258724f, 0.04328257f, 
    -0.02913104f, 0.00006705f, 0.01929785f, 0.04777768f, -0.06023333f, 0.05688212f, -0.04352918f, -0.00390104f, 
    -0.01068375f, -0.02167475f, -0.00927974f, 0.01187993f, 0.00835000f, 0.04883786f, -0.08008392f, -0.04292802f, 
    0.02686557f, 0.02752944f, -0.02343152f, -0.03225100f, -0.00752582f, -0.03092045f, -0.04949434f, -0.04222348f, 
    -0.04358230f, 0.00331531f, -0.06390402f, 0.02504291f, 0.05741570f, -0.03176178f, -0.00800469f, -0.01905112f, 
    0.00757446f, -0.03842285f, 0.03961525f, 0.02627905f, 0.02398838f, -0.01739499f, 0.03950823f, -0.01373862f, 
    0.03459818f, -0.06362747f, -0.01213504f, 0.02954460f, -0.06702521f, -0.03535132f, -0.03342806f, 0.03229662f, 
    -0.03506607f, -0.04546385f, -0.02499157f, -0.04756455f, 0.03667917f, 0.04151845f, -0.06864217f, -0.05184306f, 
    -0.03936204f, -0.05216129f, -0.03733263f, 0.02654923f, -0.00847163f, -0.01868182f, 0.00195544f, -0.04417083f, 
    -0.00077046f, -0.00893517f, 0.02119678f, -0.06652309f, -0.06405725f, 0.05200586f, 0.04125946f, 0.04409822f, 
    -0.03939348f, -0.02787776f, -0.04822098f, -0.03541287f, 0.00971846f, -0.03138096f, 0.03149839f, 0.06407065f, 
    -0.06725203f, 0.02168399f, 0.00486922f, 0.05195412f, -0.05256220f, -0.02764452f, -0.06540646f, -0.07356061f, 
    -0.05924628f, 0.03441574f, -0.07905555f, 0.05472590f, -0.05059636f, -0.00823351f, 0.01839310f, 0.05463196f, 
    0.05561369f, 0.03323393f, 0.04052552f, -0.04359870f, 0.05092818f, -0.06234816f, 0.02713032f, -0.06512716f, 
    0.00267027f, -0.07544716f, -0.07447813f, -0.06393538f, -0.03368914f, -0.03327722f, -0.01447016f, -0.03019332f, 
    -0.06165512f, 0.06151240f, -0.01798841f, 0.04221082f, -0.05580385f, 0.03214598f, -0.07610261f, -0.00207552f, 
    -0.07149631f, 0.03057079f, -0.07620595f, -0.02283727f, -0.01152638f, -0.07670666f, 0.04552283f, 0.04026587f, 
    -0.02982387f, -0.06443954f, -0.04218750f, 0.02201248f, -0.07905027f, -0.03925110f, 0.02820555f, -0.00139872f, 
    0.04804346f, -0.17280853f, 0.05668524f, 0.22075497f, 0.19047247f, 0.06090720f, -0.05550894f, -0.05253003f, 
    0.03652884f, 0.07395672f, -0.02429166f, -0.05744665f, 0.01193895f, 0.15296920f, -0.10150079f, -0.15413781f, 
    0.08103193f, -0.00588293f, 0.05959276f, -0.10570963f, 0.08063054f, 0.06128056f, -0.04797091f, -0.07435992f, 
    -0.18593386f, 0.29937279f, -0.14809453f, 0.10774533f, -0.03837292f, 0.06849550f, -0.12564644f, -0.00545123f, 
    -0.02597506f, -0.01413499f, 0.01674587f, 0.13481711f, -0.45438415f, 0.19694771f, -0.15835530f, -0.22245578f, 
    -0.00783734f, 0.04434874f, -0.02349233f, 0.02273402f, -0.03716893f, 0.10703155f, 0.01342977f, -0.04373424f, 
    0.09211756f, 0.19565934f, 0.12588783f, -0.02385326f, -0.11408796f, 0.00419852f, -0.01563159f, -0.18487968f, 
    0.11592352f, 0.21119918f, 0.06655238f, 0.06815062f, -0.19358273f, -0.07236364f, -0.10642430f, 0.42170826f, 
    -0.20379423f, 0.03010899f, -0.04218336f, -0.05196484f, -0.01098580f, -0.07234886f, 0.03116086f, 0.06293640f, 
    -0.14876096f, -0.09746727f, -0.01522110f, 0.26007110f, -0.12738536f, -0.01768435f, -0.01836164f, -0.00103078f, 
    -0.02421458f, 0.13917638f, -0.00981501f, -0.03940826f, -0.42709330f, -0.02354120f, -0.06265964f, 0.38570642f, 
    0.03253077f, -0.06142803f, -0.10356175f, 0.13520555f, -0.16721654f, 0.10028319f, -0.01367121f, 0.02404649f, 
    0.23150198f, 0.03709681f, 0.05786860f, 0.18833779f, 0.05478192f, -0.04693712f, -0.10294244f, 0.07679684f, 
    -0.04186788f, -0.11897451f, 0.03416238f, -0.10945585f, 0.44992781f, 0.03650364f, -0.00839201f, -0.09753332f, 
    0.20570064f, -0.04547488f, 0.04047980f, -0.11771616f, -0.19554996f, 0.06224554f, 0.19254629f, -0.06278956f, 
    -0.29908484f, -0.04651700f, -0.06530679f, 0.25205883f, -0.12540504f, 0.09798240f, 0.16216537f, -0.04226024f, 
    -0.00378140f, -0.06330424f, -0.15005414f, 0.01394329f, 0.15064700f, -0.13079153f, 0.05774254f, 0.14318852f, 
    0.02747479f, -0.05897604f, 0.06377278f, 0.06163400f, -0.08720776f, -0.05202882f, 0.02366534f, 0.07323717f, 
    -0.14954114f, 0.29858762f, -0.01660045f, 0.21951656f, -0.11597555f, 0.03148223f, 0.03405064f, 0.06309015f, 
    0.09264044f, 0.17409046f, 0.12966545f, -0.00072631f, 0.35986391f, 0.33865479f, 0.28185266f, 0.03945345f, 
    0.05253401f, -0.11997183f, -0.02920883f, 0.07086157f, -0.08207617f, 0.14159214f, 0.21390326f, 0.04121001f, 
    -0.08904519f, 0.04213247f, -0.10630453f, 0.15531158f, -0.04518499f, -0.12361348f, 0.09913934f, 0.03021023f, 
    -0.08134025f, 0.11378605f, -0.00738592f, 0.01263997f, 0.17879835f, 0.01224702f, 0.10179295f, 0.15110895f, 
    -0.01349647f, -0.06717043f, -0.10285390f, -0.01326302f, 0.04085277f, -0.07099316f, -0.08860121f, -0.01058797f, 
    0.07204215f, -0.02285510f, -0.10569009f, 0.12069204f, 0.12733258f, 0.03146410f, 0.13091965f, 0.14311229f, 
    0.16144332f, 0.05492290f, -0.01473109f, -0.00522627f, 0.28632775f, 0.06650978f, -0.34346491f, -0.32883358f, 
    -0.08377178f, 0.01483996f, -0.01588519f, 0.12953404f, 0.12377179f, -0.00924017f, 0.04048249f, -0.01954600f, 
    -0.15457939f, -0.00083589f, 0.06001688f, -0.08235072f, 0.04915383f, 0.04843712f, -0.13023922f, 0.02372671f, 
    -0.12618966f, -0.00119668f, -0.21357356f, -0.02328794f, 0.00867142f, -0.06397594f, -0.19370580f, -0.15508747f, 
    -0.20841335f, 0.03267653f, -0.12581246f, 0.00189406f, -0.09744332f, 0.03095032f, -0.01132420f, -0.02020240f, 
    0.20735489f, 0.25156999f, 0.24653767f, 0.16498676f, 0.10111745f, 0.09688403f, 0.02472804f, -0.14395645f, 
    0.12387123f, 0.04387569f, -0.01544558f, 0.12252466f, 0.23338419f, -0.54801983f, 0.40057021f, 0.08173780f, 
    -0.08263262f, 0.05020437f, 0.04884370f, 0.15350914f, 0.09227522f, -0.03303886f, 0.12885518f, 0.05285129f, 
    -0.03886063f, 0.09677209f, 0.20563601f, 0.25249085f, 0.00860656f, 0.06445615f, 0.10075106f, 0.16004705f, 
    -0.03712063f, -0.02076769f, -0.02413644f, -0.01716414f, -0.08015558f, 0.22166355f, 0.38103953f, 0.19694139f, 
    0.06935564f, 0.19003424f, 0.07174976f, 0.10671522f, -0.11168233f, 0.05839373f, 0.09476893f, 0.11682163f, 
    0.21026224f, 0.09932546f, 0.09191632f, 0.05825722f, -0.06214108f, 0.05618028f, 0.06871624f, 0.00229430f, 
    0.04315183f, 0.03491681f, -0.01993348f, 0.09576136f, 0.04832274f, -0.01553500f, -0.22743627f, -0.09589121f, 
    -0.07710113f, -0.18843323f, -0.16273460f, 0.05085245f, -0.10175478f, -0.12241641f, 0.03988849f, -0.08244606f, 
    0.01787337f, 0.05172594f, 0.13424374f, 0.08585493f, 0.00854429f, 0.03663486f, -0.09582998f, 0.07975955f, 
    -0.17825222f, -0.08333504f, -0.03250930f, -0.10346675f, -0.17204073f, 0.02920434f, -0.04919663f, 0.02291030f, 
    0.06486223f, -0.09901242f, 0.10819390f, 0.01346399f, -0.03263449f, -0.11290240f, -0.11921630f, -0.04319913f, 
    0.14282411f, -0.00408421f, -0.10176011f, -0.16225679f, -0.17958474f, -0.21814837f, -0.04896728f, 0.08152751f, 
    0.16919395f, -0.05209319f, -0.20747076f, -0.08829167f, 0.20020850f, 0.28305143f, -0.12785086f, -0.19427809f, 
    -0.06863483f, -0.00098664f, 0.08261430f, 0.08597879f, 0.00297511f, 0.03332555f, 0.20635040f, 0.04641571f, 
    -0.02323459f, -0.16003470f, 0.34044540f, 0.03663491f, 0.01649623f, 0.11020248f, 0.11081837f, 0.08473365f, 
    0.07258192f, -0.11568315f, 0.14562295f, -0.19884908f, 0.35524613f, 0.23332953f, 0.19829835f, 0.08755537f, 
    -0.01296639f, -0.01441993f, 0.07097550f, -0.05606846f, 0.06099376f, 0.05166701f, -0.02110831f, 0.14729743f, 
    0.06619264f, 0.07479931f, -0.09559442f, 0.11271726f, 0.17733598f, 0.00006244f, -0.02180677f, 0.16965142f, 
    -0.01557158f, 0.03860604f, -0.12201692f, -0.10782006f, 0.35219115f, 0.10402460f, -0.11785185f, -0.08513087f, 
    0.07018917f, 0.06406461f, 0.15762988f, 0.15850528f, 0.10228358f, -0.08291493f, 0.02381349f, -0.07046963f, 
    -0.03280897f, 0.08760069f, 0.08039545f, 0.08563814f, 0.01622232f, -0.14255986f, 0.09053662f, 0.00623500f, 
    0.07800304f, 0.04635403f, -0.04424144f, 0.05236497f, -0.01476378f, -0.10943130f, 0.23841317f, 0.24800406f, 
    -0.00696703f, 0.12568139f, -0.03779554f, -0.10884419f, -0.03736601f, -0.10851544f, -0.03855712f, 0.01539882f, 
    -0.23193295f, -0.13216406f, -0.40029344f, -0.13468482f, 0.12881008f, -0.06090231f, 0.07032666f, -0.30680570f, 
    0.07866161f, 0.10699811f, 0.09882668f, -0.06711609f, -0.08412850f, -0.62239653f, 0.25018707f, 0.15540415f, 
    0.07510224f, 0.06317222f, 0.20597187f, -0.05521597f, 0.04870753f, 0.04660536f, 0.08691370f, -0.06326058f, 
    -0.12151478f, -0.00911322f, 0.13173895f, 0.07493270f, -0.14900084f, 0.09464099f, -0.04291083f, 0.03887964f, 
    0.05186724f, -0.01668218f, 0.00712818f, 0.02611168f, 0.23238906f, 0.30519316f, 0.13447912f, 0.20410745f, 
    -0.03107984f, 0.09747471f, 0.13053255f, 0.25791290f, -0.01231789f, -0.02531108f, -0.03063728f, -0.01989772f, 
    0.07473896f, -0.25949425f, -0.13765053f, -0.15932323f, 0.01394809f, 0.00758699f, 0.16209191f, 0.01999723f, 
    -0.04305046f, -0.15384558f, -0.21378435f, -0.14050874f, 0.17351334f, 0.06597012f, -0.07645765f, 0.02343729f, 
    0.10178144f, 0.04831832f, 0.08796354f, -0.07418136f, 0.00888783f, 0.12299354f, 0.01395604f, 0.03753323f, 
    0.21932393f, 0.23518398f, 0.26841632f, 0.18372512f, -0.03613199f, -0.04693717f, -0.01540225f, 0.24239770f, 
    -0.00998975f, 0.07009355f, 0.06168351f, -0.01422012f, 0.04637781f, 0.02288516f, -0.10891504f, -0.15871230f, 
    -0.12228642f, -0.09948263f, 0.02309798f, -0.03825776f, -0.07509530f, -0.09588642f, 0.00179824f, 0.04015693f, 
    0.19525173f, -0.22846009f, 0.23885420f, 0.01627954f, 0.04702492f, 0.00519159f, 0.02281695f, 0.08017426f, 
    -0.08069947f, 0.00395728f, 0.04489722f, 0.02957547f, 0.06644609f, 0.48755333f, -0.03300383f, -0.00347553f, 
    -0.02277756f, 0.12105612f, 0.02102996f, -0.05428392f, -0.03696567f, -0.14229183f, 0.06362066f, 0.02800351f, 
    -0.22624767f, 0.04441196f, 0.46573922f, -0.08420540f, 0.05061817f, -0.17892785f, -0.02470553f, -0.02893033f, 
    -0.05232372f, 0.06060313f, -0.05104869f, -0.08076784f, -0.08045717f, -0.28691640f, -0.02138554f, -0.01517760f, 
    0.21789978f, 0.12298971f, -0.08992700f, -0.03439809f, -0.05061688f, -0.01286785f, -0.03935768f, 0.14019728f, 
    0.05578872f, -0.02153318f, -0.13514866f, 0.24446383f, 0.04433681f, 0.08896197f, -0.03182478f, 0.19387741f, 
    0.07276330f, 0.03038701f, -0.02083264f, 0.01848629f, 0.13848396f, -0.16133638f, -0.32048187f, -0.30573913f, 
    0.05532976f, 0.01459207f, -0.13952287f, 0.00186561f, 0.14717571f, -0.05360013f, -0.08866696f, 0.06264099f, 
    -0.09201230f, 0.01684514f, 0.08745786f, -0.03957993f, -0.01740222f, 0.01746620f, -0.02331217f, 0.01860230f, 
    0.07711392f, -0.02333108f, 0.03542732f, 0.15141599f, 0.29325518f, -0.03724454f, 0.25437772f, 0.07401422f, 
    -0.29275486f, 0.14661244f, -0.14091054f, -0.13311699f, 0.10771623f, -0.09255999f, -0.04074821f, -0.00774669f, 
    0.02806207f, 0.07197533f, -0.05828242f, 0.22425906f, -0.04234081f, -0.04873587f, 0.09206217f, -0.34368169f, 
    -0.01396752f, 0.02569777f, 0.00498370f, -0.08627348f, 0.21594578f, -0.53037590f, 0.38284528f, 0.02422134f, 
    0.04534443f, 0.27152205f, 0.21819143f, 0.09255722f, 0.01730077f, -0.04551943f, 0.13874775f, -0.02487871f, 
    0.17154795f, 0.16770832f, 0.13066536f, 0.01158076f, 0.12720673f, 0.24306904f, -0.02054225f, 0.14457965f, 
    0.03940543f, -0.00384008f, -0.02047878f, 0.09343865f, 0.21721663f, 0.34191966f, 0.25707287f, 0.05286987f, 
    0.04022297f, 0.22159776f, 0.15684330f, 0.23364134f, -0.11729831f, 0.02312144f, 0.07835469f, -0.06889879f, 
    0.10468566f, -0.06710720f, -0.24357094f, 0.08454426f, 0.04801670f, -0.09230294f, 0.04995388f, -0.23196755f, 
    -0.12610607f, -0.11654345f, -0.26168129f, -0.29353404f, 0.24187844f, -0.20234673f, -0.17389145f, -0.32112494f, 
    -0.12133160f, 0.05775413f, -0.18706097f, -0.31411347f, 0.18526535f, 0.11612984f, 0.07739171f, 0.04781904f, 
    0.50861835f, 0.39962733f, 0.35819456f, -0.05764680f, 0.27706450f, 0.00250672f, 0.22473127f, 0.34979713f, 
    -0.06520879f, 0.15274373f, 0.06709323f, 0.10157813f, -0.22265714f, -0.10380273f, -0.16688256f, -0.59178913f, 
    -0.29154652f, 0.10152785f, 0.03978621f, 0.08768580f, 0.07847320f, 0.01977125f, -0.05109762f, -0.00147586f, 
    0.29771698f, -0.34573624f, 0.02224808f, -0.06060244f, 0.05390738f, -0.01374770f, -0.01438543f, -0.19418989f, 
    0.05656856f, 0.08729975f, -0.07933856f, 0.16095220f, 0.11942841f, 0.15773502f, -0.24301523f, -0.31360874f, 
    -0.01803203f, -0.00132543f, -0.09460140f, 0.05382522f, 0.06384817f, -0.12789144f, 0.01570652f, -0.02431111f, 
    -0.21470991f, -0.04145163f, 0.24264087f, -0.03618732f, 0.21276627f, -0.15390153f, -0.06207953f, -0.01796388f, 
    0.09209782f, -0.06933141f, 0.04721497f, -0.01225148f, 0.27527931f, -0.02728508f, 0.21488534f, -0.03915695f, 
    0.02168163f, 0.02822918f, -0.19702165f, -0.16177221f, 0.05629808f, 0.01128781f, -0.02150443f, -0.01286717f, 
    0.44149643f, 0.05165858f, 0.15209129f, -0.00503908f, 0.09915479f, 0.05944119f, -0.17277545f, 0.05350415f, 
    -0.19887999f, -0.22505796f, -0.17659941f, -0.16537516f, -0.20432916f, -0.12424767f, -0.05345577f, -0.08597530f, 
    0.01528642f, 0.08096317f, 0.04486399f, 0.01668841f, 0.11312951f, 0.06065393f, -0.20394681f, -0.03970471f, 
    0.11441449f, 0.27606899f, 0.13148479f, 0.03225128f, 0.21289396f, 0.04544478f, -0.00596876f, -0.01585636f, 
    -0.02648578f, -0.28724390f, -0.13136844f, -0.24386552f, -0.09638620f, 0.29672155f, -0.10169626f, -0.12487041f, 
    0.06966732f, 0.04478370f, 0.13531525f, -0.06430998f, 0.08426981f, 0.18048331f, -0.13571538f, -0.15953852f, 
    -0.03991599f, -0.17892900f, -0.13182019f, -0.01582519f, -0.03050185f, -0.13729720f, -0.04928728f, -0.19350421f, 
    0.00350255f, -0.14668067f, -0.19499257f, -0.09912279f, -0.39694417f, 0.01453409f, -0.29244787f, -0.32951018f, 
    0.00906445f, -0.04095078f, 0.03340237f, 0.17810488f, 0.13102853f, -0.12108587f, 0.08055108f, -0.07772168f, 
    0.45356524f, 0.31767747f, 0.19641085f, 0.25124004f, 0.15298232f, 0.21387133f, -0.00195012f, 0.05672592f, 
    -0.11853319f, -0.15139900f, -0.03526615f, -0.19671431f, 0.06745423f, 0.39984307f, 0.06966963f, 0.08005589f, 
    -0.07928732f, -0.12681767f, 0.22705767f, 0.01429182f, -0.06019155f, 0.11013382f, 0.09414282f, -0.06499010f, 
    -0.02161910f, -0.22547929f, -0.37142491f, 0.06985710f, -0.10393156f, -0.10221133f, -0.20790637f, -0.09211577f, 
    0.07793677f, 0.13722630f, 0.10035957f, 0.19420601f, 0.36275405f, -0.20882954f, 0.07720225f, -0.15308408f, 
    0.02016441f, 0.03611281f, -0.00100755f, -0.03879203f, 0.08003555f, 0.08384758f, 0.05371292f, 0.04001243f, 
    0.27968270f, 0.09651959f, 0.07920543f, -0.03524242f, 0.10745864f, -0.02038764f, 0.09170631f, 0.07798727f, 
    -0.04860807f, 0.03116333f, -0.06350379f, 0.15870985f, 0.27581641f, 0.58245891f, 0.17961696f, -0.09923343f, 
    0.04217889f, 0.17893776f, 0.04061032f, 0.20723324f, -0.08855577f, -0.00706018f, -0.06535005f, -0.11618042f, 
    0.15071106f, 0.09246808f, -0.05872533f, 0.00433284f, 0.05410403f, 0.16053852f, -0.05084785f, -0.07412736f, 
    -0.02501432f, -0.16939372f, -0.05140311f, -0.09059421f, 0.20765735f, -0.01470657f, 0.29142222f, -0.03873340f, 
    0.08517316f, 0.04823999f, 0.08484661f, 0.11658682f, -0.00792196f, -0.14854249f, 0.06049272f, -0.06395698f, 
    0.22285016f, 0.04080951f, 0.05166241f, 0.16439742f, 0.13807619f, 0.04054002f, -0.04434546f, -0.01629424f, 
    0.06985146f, -0.01007634f, -0.21170928f, 0.15173385f, -0.06022882f, -0.43347174f, -0.12831779f, -0.09635423f, 
    0.01411337f, 0.09141020f, 0.09022845f, -0.16248989f, -0.22182901f, 0.12826531f, -0.10557892f, -0.04631236f, 
    -0.02778560f, 0.08643924f, -0.04044102f, 0.18100956f, -0.00257364f, -0.03446860f, 0.05673404f, 0.16006954f, 
    0.11029594f, 0.13384390f, 0.07339523f, 0.11026890f, 0.36526486f, 0.24228685f, 0.03652235f, 0.11275605f, 
    -0.01588537f, -0.00459944f, -0.00528087f, -0.08596238f, -0.05768055f, -0.10629573f, -0.00568633f, 0.04183370f, 
    0.09080552f, -0.26957428f, 0.06976472f, 0.03490263f, -0.02754292f, 0.15367469f, 0.04127562f, 0.07986213f, 
    0.23147553f, 0.19689533f, 0.11049073f, 0.30924219f, 0.36781824f, -0.30438179f, -0.01329047f, 0.06443999f, 
    -0.17455328f, 0.05873099f, -0.13229154f, -0.01228314f, 0.04577412f, 0.10767877f, 0.08601737f, 0.02689052f, 
    0.01984919f, -0.23007011f, -0.12286810f, -0.15097155f, -0.07732655f, 0.04859271f, -0.16616020f, -0.05301474f, 
    -0.02840042f, 0.13574675f, 0.33964452f, 0.12970020f, 0.42948729f, 0.26548675f, 0.39618710f, 0.13403445f, 
    0.17000113f, -0.14614768f, -0.01017906f, -0.12246569f, -0.09993767f, 0.18186171f, -0.08981016f, -0.00037156f, 
    -0.18602097f, -0.17944245f, -0.03400313f, -0.09813936f, -0.08647627f, 0.03679883f, -0.17791215f, 0.15941601f, 
    -0.11624660f, -0.03213782f, 0.03417879f, -0.09327927f, 0.08917984f, -0.17895825f, 0.22274821f, 0.17993413f, 
    0.04476324f, 0.01028225f, 0.02229999f, 0.21575207f, 0.02272137f, -0.12978539f, -0.22080238f, -0.09298495f, 
    -0.21957465f, 0.15339494f, 0.25170797f, -0.31304881f, 0.15630214f, -0.09000077f, -0.23557234f, -0.03953745f, 
    -0.38905570f, -0.31506693f, -0.52942055f, -0.84129620f, 0.18158866f, 0.01687615f, 0.17085980f, 0.18984775f, 
    -0.09981305f, 0.19564597f, 0.02082350f, -0.06994510f, 0.20425379f, 0.09766022f, 0.03363543f, 0.17057565f, 
    -0.04275973f, 0.05386030f, 0.14505623f, 0.17108476f, 0.17558844f, 0.07064548f, 0.10331442f, 0.18332306f, 
    0.20861861f, 0.19474025f, 0.06279183f, -0.05078977f, -0.00112216f, -0.19380401f, 0.01630170f, 0.02161727f, 
    -0.07746389f, 0.17080894f, 0.00574814f, -0.01226877f, -0.04433298f, -0.16727589f, -0.05667832f, 0.11222897f, 
    0.02285973f, -0.04822031f, 0.23410326f, 0.11695334f, -0.11076642f, -0.04262607f, 0.15786810f, -0.11227876f, 
    0.10489907f, 0.16010861f, 0.05527512f, 0.24078700f, 0.25352982f, 0.24294791f, -0.04625911f, 0.34366655f, 
    -0.10338349f, 0.11899046f, 0.00671610f, -0.03599720f, 0.00070287f, -0.05830259f, -0.24901398f, -0.02802703f, 
    -0.48900110f, -0.09866358f, 0.08521898f, 0.11058906f, 0.11871368f, 0.06383182f, 0.05234603f, -0.05030824f, 
    -0.19378000f, 0.12923269f, 0.03944568f, -0.04397376f, 0.16176906f, 0.08627871f, 0.01394555f, -0.47233412f, 
    -0.00331656f, 0.00934889f, -0.22192888f, -0.11420494f, -0.03551104f, -0.13973752f, -0.17950301f, -0.21877398f, 
    -0.06336374f, 0.26257965f, -0.00821432f, -0.07931500f, -0.02796734f, 0.01933891f, 0.11217609f, 0.11814550f, 
    -0.07494599f, 0.08756139f, 0.08911087f, 0.09770373f, 0.11549342f, 0.18764563f, 0.24684268f, -0.01140693f, 
    -0.01886628f, -0.02435965f, 0.05243546f, 0.05077275f, -0.10086892f, 0.08117988f, -0.12474370f, 0.11829098f, 
    0.17109561f, -0.20030007f, 0.21994291f, 0.05676423f, 0.00855570f, 0.02734726f, 0.00707267f, 0.14930211f, 
    0.09202591f, 0.04083063f, 0.14721526f, 0.12146036f, 0.38568205f, -0.21195085f, 0.36526841f, 0.39836389f, 
    -0.01951588f, 0.05921613f, -0.05492229f, 0.15811515f, -0.02964259f, 0.01797350f, 0.15242957f, -0.00054188f, 
    -0.11195998f, -0.13341169f, -0.21078284f, 0.01457411f, 0.00085997f, 0.10369489f, -0.00416448f, -0.04061050f, 
    0.10120554f, 0.13493849f, 0.21763176f, 0.21499223f, 0.19108778f, -0.16406643f, 0.26576000f, 0.05684946f, 
    0.03863350f, -0.12178722f, -0.06526678f, 0.08931958f, -0.04274638f, 0.05030234f, 0.05007623f, -0.28126675f, 
    0.14557192f, 0.08393848f, 0.07565023f, -0.18895669f, 0.00607288f, -0.02989215f, -0.06314881f, 0.14724967f, 
    -0.19013928f, -0.08394386f, -0.04217147f, -0.08453951f, 0.14329748f, -0.02998928f, 0.12133834f, -0.28549001f, 
    0.04038501f, -0.02217497f, 0.10731129f, -0.00133091f, -0.07213014f, -0.25522792f, -0.06986159f, -0.06764839f, 
    -0.18315528f, -0.03939125f, -0.01912686f, -0.35810819f, 0.12171260f, 0.04285207f, -0.16928409f, -0.10400560f, 
    -0.09988886f, -0.14031436f, -0.42883116f, -0.26292846f, -0.26694831f, 0.00132210f, -0.02183415f, 0.05669510f, 
    -0.12871830f, 0.16490780f, 0.02233341f, 0.20952682f, 0.11410500f, 0.04155612f, 0.04612387f, 0.13388111f, 
    0.15206535f, 0.17163785f, 0.17516190f, -0.23413324f, 0.20438589f, -0.05922796f, 0.16678576f, 0.17848895f, 
    0.00824286f, 0.13141783f, 0.18612838f, -0.09293858f, -0.12855329f, 0.12954602f, 0.04413232f, -0.21245214f, 
    -0.05792538f, 0.15653977f, 0.00631256f, -0.02276826f, 0.06654847f, 0.02300529f, -0.16514961f, 0.07983718f, 
    0.16898187f, -0.05804446f, 0.24814001f, -0.16032529f, -0.07519566f, -0.04955876f, 0.05532563f, 0.01052347f, 
    0.10701710f, 0.05393333f, -0.03197186f, 0.17399573f, 0.13935558f, 0.04715370f, -0.16711637f, -0.02845862f, 
    -0.18752331f, -0.09517372f, -0.02184073f, 0.05145221f, 0.21253864f, -0.23376614f, -0.25764850f, -0.03947165f, 
    0.13958620f, 0.22404952f, 0.13073575f, -0.13618541f, 0.02787372f, 0.13473244f, -0.01381829f, 0.00520453f, 
    0.05429737f, 0.02151723f, 0.01607491f, -0.02343391f, 0.10525221f, -0.01452713f, -0.15929547f, -0.19100012f, 
    -0.19977160f, 0.04782105f, -0.07741033f, 0.05639936f, 0.10958010f, -0.09284268f, 0.13156022f, -0.16156457f, 
    0.21745044f, -0.11660396f, 0.04597147f, -0.04032248f, 0.13107179f, -0.08256421f, 0.07317676f, -0.12863219f, 
    0.01990846f, 0.13970152f, -0.01436020f, 0.00323225f, -0.25637701f, 0.02013237f, 0.05866354f, 0.00801722f, 
    -0.14808944f, -0.04087893f, 0.09126633f, -0.17443010f, 0.14477690f, 0.02556875f, -0.04484814f, 0.01240624f, 
    -0.07546767f, -0.14398110f, -0.00875019f, 0.21685065f, 0.05773758f, 0.13401826f, 0.11835237f, -0.05817656f, 
    0.03403252f, 0.06887062f, 0.11646930f, 0.04848240f, -0.27091214f, -0.04610768f, -0.29266709f, 0.00534484f, 
    -0.07460894f, -0.11579223f, -0.05204945f, 0.16602771f, 0.16409267f, 0.24359827f, 0.17541510f, -0.00610874f, 
    0.10347372f, 0.05885193f, 0.14769478f, -0.05178772f, -0.11776350f, -0.04537281f, -0.00787033f, 0.00682874f, 
    -0.03813259f, -0.09815093f, -0.02121374f, 0.06689319f, 0.00393049f, 0.37091723f, -0.30359924f, 0.06884363f, 
    -0.02378556f, -0.11454385f, -0.23876320f, -0.05805751f, -0.00307546f, -0.07474959f, -0.00933789f, 0.00889149f, 
    -0.24446306f, -0.24440749f, 0.15636922f, 0.18970487f, 0.02681683f, -0.05558518f, 0.02361857f, -0.19225278f, 
    -0.06985037f, 0.06012181f, -0.01195357f, 0.00957195f, -0.39885044f, -0.45833266f, -0.08640218f, 0.13284466f, 
    -0.03701534f, 0.05270083f, 0.01216191f, -0.02392170f, -0.12950452f, 0.05426903f, -0.00503616f, 0.10238679f, 
    0.06971385f, 0.00957629f, -0.10446031f, 0.02065455f, 0.13017929f, -0.08095179f, -0.00827575f, 0.04989230f, 
    -0.06212885f, 0.03120090f, 0.00412005f, -0.01221506f, -0.08462533f, 0.00535753f, 0.10642520f, 0.03353403f, 
    0.04365486f, -0.04109693f, -0.03153531f, -0.12458253f, -0.06964765f, 0.02820505f, 0.04291123f, 0.13966821f, 
    -0.40429947f, -0.14573480f, -0.20655702f, 0.03457126f, -0.25301757f, 0.15871008f, -0.03838354f, -0.39360499f, 
    0.06125809f, -0.03907660f, 0.01273523f, 0.01100411f, -0.00525959f, 0.29563543f, 0.08789293f, 0.31894848f, 
    0.19966179f, -0.03031124f, 0.17217641f, 0.16106108f, -0.07278914f, 0.08431429f, 0.10256343f, 0.07241306f, 
    -0.22874807f, 0.50994241f, 0.05292017f, 0.08016271f, -0.01970707f, 0.21446304f, 0.06727590f, 0.22021098f, 
    0.13131493f, 0.17620212f, 0.07224901f, 0.02676707f, -0.12038223f, 0.00795637f, 0.23028840f, 0.14070547f, 
    -0.03768508f, 0.02821858f, 0.06678828f, -0.01209050f, 0.01996592f, 0.01597465f, 0.03981900f, 0.04676734f, 
    0.34037784f, 0.08475657f, -0.32340139f, -0.05246592f, -0.06836386f, 0.36328912f, 0.30413115f, -0.01037577f, 
    0.16847946f, 0.21206290f, 0.00489681f, 0.04860346f, -0.01638368f, 0.02843081f, -0.00316629f, 0.06409729f, 
    -0.07002607f, -0.17300975f, -0.14702471f, 0.01635340f, -0.01650672f, 0.06766461f, -0.03381864f, 0.01593470f, 
    -0.18798989f, 0.11412644f, 0.09612526f, 0.07142498f, 0.08688779f, 0.07150909f, 0.14640680f, -0.07084491f, 
    0.14366397f, 0.07884423f, 0.25729957f, 0.08031151f, 0.07267135f, 0.18040062f, 0.23704776f, 0.08530154f, 
    -0.01159796f, -0.11297283f, -0.08516118f, -0.02656915f, 0.07039191f, 0.06383109f, 0.08188829f, -0.02755151f, 
    -0.20390618f, -0.08577734f, -0.10353144f, 0.29521430f, -0.06866191f, -0.02216607f, -0.01926862f, 0.11669278f, 
    -0.03213258f, 0.01236924f, 0.22848605f, 0.07319757f, -0.47372606f, -0.05897696f, 0.14634484f, 0.19576663f, 
    0.12008503f, 0.07731549f, -0.02840519f, 0.09364620f, 0.04509421f, 0.21221949f, 0.08453662f, 0.08814386f, 
    0.12098938f, 0.07682896f, 0.01225840f, 0.01102357f, -0.04278478f, 0.03204274f, -0.04911392f, -0.03579424f, 
    0.15680723f, 0.14226937f, -0.06795993f, 0.28973883f, -0.45123488f, -0.40573356f, 0.12542151f, 0.26144862f, 
    0.02480627f, 0.20114274f, -0.09768732f, -0.13513623f, 0.05272514f, -0.00679342f, 0.01319225f, -0.05198573f, 
    -0.44484067f, -0.04390388f, 0.15822625f, -0.00259663f, 0.03051128f, -0.12987360f, 0.01757228f, -0.06099071f, 
    -0.07404252f, 0.10381547f, -0.16448535f, -0.06995048f, -0.21034694f, -0.11076120f, -0.01562446f, 0.21521755f, 
    0.10520042f, 0.04146279f, -0.01653602f, -0.00450899f, -0.12299335f, -0.19533701f, -0.09909672f, 0.04483028f, 
    0.09470113f, -0.06304210f, 0.13720882f, -0.13726647f, 0.13491936f, 0.18579407f, 0.01577348f, -0.09801506f, 
    -0.02899822f, -0.06491680f, -0.14271097f, 0.07766057f, -0.16142009f, 0.15099949f, -0.07600199f, 0.04382440f, 
    0.00145802f, -0.11927235f, 0.08194162f, 0.04473277f, 0.02186882f, -0.12556247f, 0.16263856f, 0.14585644f, 
    -0.25313622f, -0.17022607f, -0.01073011f, -0.01373895f, -0.17133513f, -0.03938510f, -0.06211346f, -0.02900337f, 
    -0.06512171f, -0.14371985f, -0.04632762f, -0.13111012f, 0.01190634f, -0.22000326f, 0.09225688f, 0.13290671f, 
    0.05626938f, 0.07830414f, 0.06476599f, -0.00035586f, 0.00548547f, -0.02869397f, 0.09733316f, 0.10126518f, 
    -0.08259847f, 0.30248424f, 0.29465705f, -0.01674445f, -0.13009521f, -0.24213333f, -0.01367474f, 0.16062650f, 
    0.06576936f, 0.02443119f, 0.01939266f, 0.04906897f, -0.16379949f, 0.44245198f, 0.10320462f, 0.04711774f, 
    0.18970364f, -0.21984726f, 0.00375391f, -0.11740311f, -0.05746851f, 0.17624825f, -0.12482169f, -0.07458633f, 
    0.71005875f, 0.31418455f, 0.24281757f, -0.05247593f, -0.04531785f, -0.09419297f, 0.13993177f, 0.21296091f, 
    0.02266842f, 0.18861157f, 0.15405285f, -0.07752576f, -0.02327631f, 0.04183754f, -0.15615584f, 0.22635871f, 
    -0.02373187f, -0.01531854f, -0.09088621f, -0.02974844f, 0.19963410f, 0.00698993f, 0.07779694f, -0.07992013f, 
    -0.09680612f, -0.15625037f, -0.09545211f, 0.12434659f, 0.16376264f, 0.18343195f, 0.00090414f, 0.14586397f, 
    0.23730671f, 0.14174989f, 0.01936048f, 0.02602094f, 0.17580229f, -0.30265686f, -0.20942937f, -0.19378176f, 
    0.02646929f, -0.08686113f, 0.03195820f, 0.16709575f, 0.05778668f, -0.01245655f, -0.08098676f, -0.03586784f, 
    -0.00715638f, 0.02437916f, -0.07234176f, -0.04721732f, 0.18451285f, 0.09009707f, 0.21966721f, -0.07103400f, 
    0.15851158f, -0.12116114f, -0.04684379f, -0.04887901f, 0.34196836f, -0.09217785f, -0.20860136f, -0.14274524f, 
    -0.04686309f, 0.00734336f, 0.02044482f, -0.16676107f, 0.02144760f, -0.18242611f, 0.21221364f, 0.07296473f, 
    0.04294238f, 0.16400385f, 0.06921521f, 0.00838523f, 0.01472966f, -0.01878662f, 0.04255312f, -0.12234166f, 
    0.06940340f, 0.01432204f, 0.13126805f, -0.04278151f, 0.30520886f, 0.05737795f, 0.16843493f, -0.22128217f, 
    -0.03331690f, -0.08834927f, 0.02543820f, 0.06351042f, -0.07124339f, -0.05350623f, -0.07783991f, -0.07688616f, 
    0.03424173f, -0.08619172f, -0.08914957f, 0.03316493f, -0.17845929f, -0.01307076f, 0.14622962f, -0.05918415f, 
    0.06681243f, -0.10435112f, 0.03368258f, -0.00228344f, -0.20495571f, -0.14022638f, -0.08948822f, 0.15831526f, 
    -0.03250100f, -0.00747039f, -0.03320466f, 0.33799791f, 0.00638163f, 0.18675157f, 0.09306175f, 0.07683514f, 
    0.10414464f, 0.01301286f, 0.13725729f, -0.00790223f, -0.05135115f, -0.14893605f, -0.01374116f, -0.04264494f, 
    -0.09936512f, 0.04650234f, -0.02250200f, 0.07117269f, 0.08954153f, 0.01295120f, -0.16231245f, -0.15642542f, 
    -0.13771001f, -0.05289563f, -0.07957979f, 0.01640352f, 0.09107196f, 0.01347953f, 0.00814294f, -0.09905575f, 
    -0.02272654f, -0.04892303f, -0.05696665f, 0.06862309f, -0.13574718f, -0.07842296f, -0.08032469f, 0.05547026f, 
    -0.11685926f, -0.16405471f, -0.06111750f, 0.00793890f, 0.09843431f, -0.04888546f, 0.05269948f, -0.03844735f, 
    -0.00011201f, 0.00041324f, 0.18651968f, 0.06886633f, -0.07384270f, 0.00898760f, 0.10764877f, 0.11804173f, 
    0.09205298f, -0.31523815f, -0.18498226f, 0.13039489f, 0.02414163f, 0.01665806f, 0.09730925f, 0.13016716f, 
    -0.13000104f, -0.02922411f, 0.03620638f, -0.02580630f, -0.18416567f, -0.01312916f, -0.28763723f, -0.14672783f, 
    -0.10701601f, -0.01515761f, 0.15056546f, 0.12078848f, -0.07152686f, 0.10870900f, 0.17457214f, 0.05501319f, 
    -0.09909290f, -0.04393601f, 0.36745012f, 0.09882593f, 0.07335830f, 0.13855788f, 0.09057810f, 0.22884223f, 
    0.02372119f, 0.18547134f, 0.14162394f, 0.19162412f, 0.07070798f, 0.07080218f, 0.07367101f, -0.02049973f, 
    0.02300958f, -0.08344742f, -0.07534085f, -0.01065650f, 0.06286762f, 0.04349882f, -0.01433578f, 0.06837168f, 
    -0.03376848f, -0.05857027f, -0.03275819f, -0.01810794f, 0.03606504f, -0.06098511f, 0.03474435f, -0.06410449f, 
    -0.06975476f, 0.05186809f, 0.04567937f, -0.01796746f, 0.02829273f, -0.06810916f, 0.01356949f, 0.04641525f, 
    -0.00986917f, -0.06835058f, 0.00102183f, 0.03548677f, -0.02912955f, -0.01480556f, -0.07181416f, 0.01573877f, 
    -0.02676968f, -0.05832169f, 0.00759103f, -0.04022301f, -0.01602760f, -0.02725200f, 0.05640891f, -0.01519956f, 
    -0.03620704f, 0.03332732f, 0.02691608f, 0.06108552f, 0.04218025f, 0.02219906f, 0.03137316f, -0.01890282f, 
    -0.01304166f, -0.04910684f, 0.03512831f, 0.01728966f, 0.03567145f, -0.01417115f, -0.03493009f, -0.07584871f, 
    0.03557966f, -0.04266786f, -0.07347740f, 0.02023210f, 0.04782545f, -0.02696680f, -0.05108181f, -0.01612879f, 
    0.03724997f, -0.05320127f, 0.01674925f, 0.01710901f, -0.06430317f, 0.00954807f, -0.04463563f, 0.03908288f, 
    -0.07611959f, 0.04435876f, -0.05780700f, -0.07033575f, -0.01018993f, -0.00135615f, 0.02385715f, -0.03833680f, 
    -0.07242139f, -0.04367058f, 0.02732772f, -0.05139295f, -0.02673495f, -0.05618633f, -0.00221575f, -0.06354707f, 
    0.05252641f, -0.02734560f, 0.04326845f, 0.01750622f, -0.06891893f, 0.05182837f, 0.05264096f, 0.01250496f, 
    0.03870019f, -0.02682445f, -0.03253746f, -0.03178894f, 0.06584758f, 0.02254896f, 0.04524315f, -0.07170906f, 
    0.01653170f, -0.05794445f, -0.07196345f, 0.06053669f, 0.02801543f, -0.03356019f, -0.00309335f, -0.03211683f, 
    -0.02483567f, -0.03793381f, -0.00941795f, -0.01277217f, -0.01071164f, 0.02070179f, 0.06355021f, -0.01038757f, 
    -0.05471946f, -0.02730062f, -0.05725553f, -0.01265486f, 0.06433550f, -0.05999271f, -0.00039404f, -0.02678181f, 
    -0.02280399f, 0.05261948f, 0.04693234f, -0.01909130f, -0.03139288f, -0.01148708f, 0.00678032f, 0.00592634f, 
    -0.06012266f, -0.07256417f, -0.03103085f, 0.05872093f, -0.00899922f, -0.07613747f, -0.02725567f, -0.06056461f, 
    0.00923194f, 0.03869484f, -0.04825629f, -0.01045787f, 0.03888863f, -0.02314452f, 0.00546817f, 0.02914487f, 
    -0.04597250f, -0.00105491f, -0.06470782f, -0.02374087f, -0.04090892f, -0.05614213f, -0.00979210f, -0.03427700f, 
    -0.03750189f, -0.06832661f, 0.00071670f, 0.02765432f, -0.00907424f, -0.00588395f, 0.02258542f, 0.03449168f, 
    -0.00417159f, 0.04378954f, -0.01317746f, 0.03218104f, 0.00669142f, 0.05598541f, -0.02985355f, -0.02484510f, 
    0.04047154f, -0.04128106f, -0.00428526f, -0.00154150f, -0.02886881f, -0.03767775f, -0.05825375f, 0.03712547f, 
    -0.01568089f, -0.06356366f, -0.02889472f, -0.00250798f, 0.01590895f, -0.05243909f, -0.04984168f, 0.06101665f, 
    0.01077744f, 0.03227403f, 0.01987258f, -0.00679693f, -0.00567437f, -0.06020166f, 0.05168064f, 0.00752753f, 
    0.22605354f, -0.17664054f, 0.01556359f, -0.02234729f, -0.02014337f, -0.07153062f, -0.08052094f, -0.01043539f, 
    -0.13128175f, 0.09066054f, 0.08847326f, 0.05899735f, 0.04389390f, 0.03803556f, -0.01494610f, 0.07968305f, 
    -0.00300812f, 0.02852842f, 0.18389010f, -0.15098681f, 0.02640541f, 0.07437334f, -0.05598675f, -0.14217882f, 
    0.24382371f, -0.04677272f, -0.01918066f, -0.10823379f, -0.06957181f, 0.20628045f, 0.10228207f, 0.07693183f, 
    0.11471202f, 0.04818648f, 0.15684111f, 0.35832331f, 0.18507464f, 0.11913014f, -0.42412701f, -0.41650540f, 
    -0.00971461f, 0.04066311f, 0.11363672f, 0.04696339f, 0.03539427f, 0.05385314f, 0.00229506f, 0.08840706f, 
    0.15634549f, -0.14781718f, 0.18209456f, -0.07377359f, -0.15011722f, 0.15948729f, -0.18705207f, 0.02501986f, 
    0.00075932f, 0.09709278f, 0.15758814f, -0.04686885f, 0.33123800f, 0.63160461f, -0.33308011f, 0.05566630f, 
    0.05712239f, -0.22744785f, -0.09995851f, 0.15329230f, -0.02475666f, -0.02794931f, -0.10741299f, 0.02306895f, 
    0.13490427f, -0.07477856f, -0.07809296f, 0.07299495f, -0.10210644f, 0.04592811f, 0.08617147f, 0.03981870f, 
    -0.11255857f, -0.11766782f, -0.08841318f, -0.07532167f, -0.01834652f, -0.03497488f, 0.03541160f, 0.16377281f, 
    -0.05764138f, -0.07223558f, -0.10360318f, 0.08187129f, 0.01761840f, -0.01798915f, -0.18295181f, -0.21743689f, 
    0.04049730f, 0.34708673f, 0.23965086f, 0.05043194f, 0.05724532f, -0.22105490f, -0.13303967f, 0.10914104f, 
    -0.29276448f, -0.21015787f, -0.04691204f, -0.39842677f, 0.37413937f, 0.01747473f, 0.37365949f, 0.08551471f, 
    0.00747152f, 0.23071708f, 0.02981805f, -0.02420069f, 0.00741697f, 0.01902375f, -0.01208507f, -0.07420403f, 
    -0.06912299f, -0.10813819f, -0.17461185f, 0.02525106f, 0.02522645f, 0.14729166f, 0.20077245f, -0.10383850f, 
    0.14786832f, 0.04671085f, -0.01391052f, 0.14232840f, 0.26091638f, 0.25706771f, 0.09764168f, 0.12343580f, 
    -0.08498250f, 0.20278546f, -0.03833888f, 0.20022206f, -0.07678768f, 0.00539086f, 0.10377817f, -0.06219618f, 
    -0.06460492f, 0.06325904f, -0.11252458f, 0.16798492f, 0.01106369f, 0.25530133f, 0.07398719f, -0.13735567f, 
    0.01944641f, 0.15379037f, 0.20802535f, 0.20680171f, 0.43968150f, -0.29268101f, 0.10261021f, 0.21369143f, 
    0.07146105f, -0.01374510f, -0.08925765f, -0.07113219f, -0.05409969f, -0.15224709f, 0.06049071f, 0.14942823f, 
    -0.24788529f, -0.28793606f, -0.40560383f, 0.13805903f, -0.11084492f, 0.22793736f, 0.04219034f, -0.12037849f, 
    0.00235363f, 0.14053570f, -0.12916827f, 0.12991367f, 0.12350880f, 0.13734177f, 0.01061952f, -0.33532640f, 
    0.08139437f, -0.03298440f, 0.11039962f, 0.07162997f, -0.20224862f, -0.09178972f, -0.12513340f, -0.22502679f, 
    0.32397258f, -0.52917093f, -0.31040642f, -0.07731136f, 0.18288948f, 0.11855419f, 0.12218758f, -0.01627846f, 
    0.08139260f, 0.11594090f, -0.08479515f, 0.01600991f, -0.25071943f, 0.00865693f, -0.23238279f, -0.24239399f, 
    -0.07239700f, 0.17228010f, 0.07701400f, -0.05941714f, -0.15258984f, 0.12608317f, -0.02595141f, -0.16176336f, 
    -0.80204856f, 0.05527491f, -0.22418407f, -0.16340706f, 0.11091787f, 0.18613620f, -0.38624126f, 0.04801830f, 
    0.03288567f, -0.09577472f, 0.03544921f, 0.13686995f, -0.11735190f, 0.28297555f, 0.11143949f, -0.19112043f, 
    -0.21523808f, 0.15740097f, 0.02890962f, 0.16933523f, 0.08109845f, -0.02039400f, 0.13975908f, -0.00871338f, 
    0.13180864f, 0.16079810f, 0.21453069f, 0.19224595f, -0.05686364f, -0.09159505f, 0.01491722f, 0.02953270f, 
    0.10741024f, 0.36128047f, 0.23479113f, 0.18381552f, 0.35732728f, 0.22405683f, 0.41728011f, 0.56201839f, 
    -0.14026530f, 0.19523574f, -0.02705032f, 0.18523289f, -0.03069446f, 0.08909675f, 0.00588543f, 0.04610993f, 
    -0.45246676f, -0.41931972f, -0.72454381f, -0.41467488f, 0.22133346f, 0.11970586f, -0.05984280f, 0.07013150f, 
    -0.14124972f, 0.02218336f, -0.01258386f, -0.03679824f, -0.21919522f, 0.09236943f, -0.49463522f, -0.40398395f, 
    0.39466223f, 0.21146220f, 0.12368117f, 0.12503260f, -0.16957659f, -0.08458702f, -0.05255773f, 0.03075572f, 
    0.14999381f, 0.12272817f, -0.02579818f, 0.19845520f, 0.04809282f, -0.14822261f, -0.05820811f, -0.00332440f, 
    -0.07366369f, -0.08596758f, 0.03166892f, -0.02903452f, 0.05539003f, -0.12339097f, -0.19838627f, -0.00141811f, 
    0.00660248f, 0.04585500f, -0.08323643f, 0.13329077f, -0.28651121f, -0.04813186f, 0.05333246f, 0.06041737f, 
    0.12753193f, 0.20114319f, 0.26255375f, -0.32357144f, 0.11156903f, 0.05129056f, -0.11896022f, 0.03042097f, 
    -0.01822017f, 0.02437204f, -0.01982221f, 0.10657862f, -0.49188909f, -0.06632341f, -0.82511312f, -0.50641716f, 
    0.00328813f, -0.17577413f, 0.09099336f, 0.30114606f, -0.06661408f, 0.00746383f, 0.00634235f, 0.02486053f, 
    -0.03193931f, 0.09135214f, -0.52212441f, -0.34580797f, -0.07889370f, 0.09394115f, -0.06248959f, 0.04582245f, 
    0.35310122f, -0.04783829f, -0.13032062f, -0.11240841f, -0.13273293f, -0.46470585f, -0.10236596f, -0.03489581f, 
    -0.12447012f, -0.18297462f, -0.08157948f, 0.02269236f, 0.02201570f, 0.11228298f, -0.10977232f, -0.09943350f, 
    0.32588440f, 0.12776816f, -0.33370560f, -0.02940454f, 0.03343827f, 0.14226265f, 0.13799143f, 0.08298066f, 
    0.21948993f, 0.17423959f, 0.12712927f, 0.13208684f, 0.11418675f, 0.13236015f, 0.14554247f, 0.22634630f, 
    0.01082578f, 0.00995932f, -0.02509213f, -0.02904158f, -0.00234070f, 0.00327392f, 0.03925764f, 0.00988613f, 
    -0.28370497f, 0.14839387f, 0.05575779f, 0.00144399f, 0.08806133f, 0.18726982f, 0.03491540f, -0.06283838f, 
    0.26158369f, -0.00611809f, 0.13386934f, 0.15043506f, 0.02160139f, -0.05760176f, 0.20734875f, 0.03234318f, 
    0.07705920f, -0.14614588f, -0.02987715f, 0.18342155f, 0.18049048f, 0.06843816f, 0.08135617f, 0.17879094f, 
    0.00726108f, -0.19732860f, -0.00259077f, 0.09497727f, 0.08352777f, 0.00639950f, 0.02629830f, 0.00483090f, 
    0.02075598f, -0.03616253f, 0.14772744f, -0.05095375f, 0.19921096f, -0.32031012f, 0.27024767f, 0.13386524f, 
    0.10419749f, -0.06008676f, -0.05201277f, -0.05422588f, 0.12140559f, 0.20658804f, 0.10990980f, 0.19972765f, 
    0.12255779f, 0.05684124f, -0.03687323f, 0.06755660f, -0.03883280f, 0.07434409f, -0.03907781f, -0.04320810f, 
    -0.01685547f, -0.11212272f, 0.08750942f, 0.14400907f, -0.32441878f, -0.02542866f, 0.15784904f, -0.01865217f, 
    0.20021696f, 0.33677253f, -0.02715494f, -0.07597043f, -0.02714730f, 0.04392755f, 0.01706992f, -0.12311251f, 
    -0.18233895f, -0.12447716f, -0.03160585f, -0.20377530f, 0.12417322f, -0.12304705f, 0.06853974f, 0.00937101f, 
    0.06396083f, 0.03302959f, 0.05445892f, 0.09081195f, -0.08909742f, -0.24495165f, -0.26323438f, -0.09043337f, 
    0.15521576f, 0.04780231f, -0.05266231f, 0.08307422f, 0.01091549f, 0.11002403f, -0.00268128f, 0.09358761f, 
    -0.15773357f, -0.15080507f, 0.05950877f, -0.24318963f, 0.26372221f, 0.08958547f, 0.10598846f, 0.03332564f, 
    0.15504175f, -0.01452469f, 0.03395955f, 0.00268666f, 0.02491267f, -0.01162616f, 0.00763168f, -0.13865207f, 
    -0.06147880f, -0.12250773f, 0.01059554f, -0.14933199f, 0.21913062f, -0.02611149f, -0.02742284f, 0.16948770f, 
    -0.41894567f, -0.27392173f, -0.14652127f, -0.05976538f, -0.04571247f, -0.06385417f, 0.09012715f, 0.10779015f, 
    -0.01579586f, -0.00521286f, 0.01644832f, 0.02062577f, -0.05678507f, -0.26178041f, 0.04701706f, -0.02911432f, 
    0.04704511f, 0.18642396f, 0.11051267f, 0.08983544f, 0.06864568f, 0.12941736f, 0.09164969f, 0.18476355f, 
    -0.08367497f, -0.14820400f, 0.22380130f, 0.08390115f, 0.00522824f, -0.08469445f, 0.13974413f, 0.06603846f, 
    0.00704286f, 0.07117946f, 0.13314013f, -0.00447833f, -0.23814130f, -0.02640955f, -0.16623080f, -0.04325661f, 
    0.03195661f, 0.04755402f, 0.07003143f, 0.05942487f, 0.29292896f, 0.07495812f, 0.06510235f, 0.00824680f, 
    0.20285298f, 0.33224958f, -0.05126835f, 0.19688219f, 0.11143689f, 0.00631470f, 0.28001654f, 0.23623528f, 
    0.08530924f, 0.22641161f, -0.12343571f, 0.22568727f, -0.08326577f, -0.07553492f, -0.04586310f, -0.03888385f, 
    -0.10795317f, -0.02119987f, -0.13029823f, -0.11743144f, 0.07026409f, -0.08567321f, 0.00489001f, 0.03310194f, 
    0.01053530f, 0.16660471f, 0.05817765f, 0.05056293f, -0.02315080f, 0.08129947f, -0.00710433f, 0.17811236f, 
    0.04234493f, 0.05823208f, 0.13053155f, 0.06044472f, 0.20902355f, 0.02440441f, 0.23235525f, 0.20402083f, 
    -0.02408927f, -0.04427310f, -0.19188169f, 0.12548055f, -0.11491258f, -0.02871381f, 0.13140847f, 0.08542911f, 
    0.10996397f, 0.09202500f, 0.00102531f, -0.04082655f, 0.03743872f, 0.02849275f, -0.11188211f, 0.03008935f, 
    0.03600266f, 0.04634336f, 0.11595777f, -0.01098035f, 0.23554625f, -0.05838770f, 0.68445629f, 0.05303097f, 
    0.06335671f, -0.08092044f, -0.15311128f, -0.13222544f, 0.19543548f, 0.13587557f, 0.08380600f, 0.04316993f, 
    -0.11139408f, -0.07475457f, -0.20069174f, 0.02378669f, -0.21668829f, -0.07345258f, -0.01299921f, -0.10420963f, 
    0.06411475f, 0.15860739f, 0.08842395f, 0.03530762f, -0.00333756f, 0.10261467f, 0.25565755f, 0.08365124f, 
    -0.07228918f, 0.24908835f, 0.02681654f, 0.10429551f, -0.09107216f, -0.02173656f, -0.04145977f, -0.13420694f, 
    0.08819985f, 0.00356413f, -0.29012474f, -0.27010152f, 0.08265909f, 0.03939959f, -0.04817981f, 0.20296009f, 
    -0.08846059f, -0.11662788f, -0.02452911f, -0.14738610f, 0.29144603f, -0.03359479f, -0.20462690f, -0.17484808f, 
    -0.03313224f, -0.02027714f, 0.09935347f, 0.25864854f, 0.02006608f, -0.02815451f, 0.01727751f, 0.05583572f, 
    -0.45567891f, -0.28218561f, -0.38646469f, -0.09210098f, 0.24244153f, -0.09602690f, -0.10198468f, -0.09179758f, 
    -0.07046329f, -0.01144012f, -0.26673079f, -0.33977962f, 0.33128956f, -0.25026906f, 0.19244003f, 0.02868462f, 
    -0.13918179f, -0.18402964f, -0.05794363f, -0.07989193f, 0.13527021f, 0.12941918f, 0.12120919f, 0.37706986f, 
    0.03181254f, -0.09277143f, -0.00691215f, 0.02745609f, 0.17309380f, 0.11280194f, 0.18967159f, 0.21776424f, 
    -0.01480857f, 0.13420795f, 0.08879515f, 0.10738239f, 0.18462135f, -0.15890603f, -0.07441338f, -0.31676331f, 
    -0.05943900f, 0.06154283f, -0.12817274f, 0.11596458f, 0.05800464f, -0.00250712f, -0.02805067f, 0.11294772f, 
    0.12196806f, -0.16527760f, 0.21556203f, 0.20270497f, -0.07685586f, -0.07390385f, -0.11244355f, -0.07590239f, 
    0.10015431f, 0.01423276f, 0.07003576f, 0.07825787f, 0.40241438f, 0.03710484f, -0.04489921f, 0.01281571f, 
    -0.22364290f, -0.04851646f, -0.08515806f, 0.21406737f, 0.23776720f, -0.02337002f, -0.12063492f, -0.08808194f, 
    -0.30493814f, 0.27262026f, -0.14071360f, 0.10265613f, -0.12017408f, -0.04335419f, -0.09006738f, 0.03627863f, 
    0.06804229f, 0.00750743f, -0.04832956f, 0.03882378f, 0.00683712f, -0.24126551f, 0.04980332f, -0.09387450f, 
    -0.27979156f, -0.07669119f, -0.35848573f, -0.22609615f, 0.09190471f, -0.08640891f, -0.02632514f, -0.20485722f, 
    0.25136206f, 0.17245959f, 0.17557856f, 0.00048474f, 0.18369654f, 0.07499718f, -0.03375994f, 0.02176327f, 
    -0.13514471f, 0.05338826f, 0.04001770f, 0.16769730f, 0.10628612f, 0.03745609f, -0.29730856f, -0.39217418f, 
    -0.09322323f, 0.04378065f, -0.18182418f, 0.04429065f, 0.03111626f, -0.05204028f, 0.04362679f, -0.04487510f, 
    -0.01640807f, 0.13322626f, 0.14614326f, 0.01735413f, 0.20342986f, 0.00871112f, -0.02814441f, -0.10423543f, 
    0.01446066f, -0.01065202f, 0.16394855f, 0.27892753f, -0.22357909f, 0.07464425f, -0.00573847f, 0.27070218f, 
    0.06665771f, -0.07268824f, -0.09315891f, -0.09088240f, 0.01418699f, 0.13791384f, -0.12287217f, 0.03583604f, 
    0.07299554f, -0.15482223f, 0.05172206f, -0.01312459f, 0.06656824f, 0.05909707f, -0.04593057f, -0.15290885f, 
    0.03901596f, 0.28019410f, -0.14416137f, -0.07766374f, -0.21867102f, 0.58556604f, 0.11905280f, -0.11908982f, 
    0.05861974f, -0.24851361f, 0.21946581f, 0.25160834f, 0.01647063f, -0.16238971f, 0.01915146f, -0.10365913f, 
    0.14935662f, 0.26490963f, 0.31881982f, 0.06809606f, 0.10649125f, 0.17706026f, 0.04443640f, -0.02637560f, 
    -0.10452868f, 0.01068793f, 0.06709227f, -0.10664015f, 0.08701207f, 0.32227993f, 0.22703080f, 0.08514442f, 
    0.10943352f, 0.10600294f, 0.20091645f, -0.10100996f, 0.03579399f, -0.13311169f, 0.04927795f, 0.01485056f, 
    0.20111912f, 0.36820960f, 0.04673058f, -0.24842754f, -0.14924535f, 0.04958799f, -0.08487475f, 0.04752368f, 
    0.01898910f, -0.00233564f, -0.16649346f, -0.18172987f, -0.03362204f, 0.19524416f, -0.03266488f, 0.00696321f, 
    -0.14703901f, 0.01019834f, -0.03609663f, -0.06244037f, 0.06831447f, 0.09986759f, 0.19363946f, 0.04808161f, 
    0.23600516f, 0.16743027f, 0.11988713f, -0.23295052f, 0.06338254f, 0.02218242f, -0.04641770f, 0.18928544f, 
    0.00496167f, 0.15199591f, 0.09469040f, 0.09440928f, 0.19263384f, 0.48475188f, 0.24403736f, -0.10911434f, 
    -0.16506131f, -0.00118181f, 0.00341371f, 0.05271281f, -0.06305761f, 0.02639120f, 0.05584408f, -0.02062985f, 
    0.10914990f, 0.03404045f, 0.02258078f, -0.18063372f, 0.05193689f, -0.03212096f, -0.04661473f, 0.05113701f, 
    -0.01142323f, 0.12948583f, -0.08458597f, 0.18176645f, 0.07224676f, -0.07246746f, 0.04714635f, -0.07855590f, 
    -0.02977563f, -0.25870401f, -0.01318517f, -0.10478850f, -0.03324133f, -0.08952805f, -0.33490637f, -0.12994240f, 
    0.19425674f, -0.13395248f, 0.71627861f, 0.10668831f, -0.01994261f, 0.10788465f, -0.08630991f, -0.10607993f, 
    -0.08351739f, -0.03144079f, -0.00036536f, 0.10799000f, -0.05441387f, 0.04982252f, -0.18584797f, 0.22927450f, 
    0.08116312f, -0.08482759f, 0.00832750f, 0.14137708f, -0.12778598f, -0.06374475f, -0.06474244f, -0.10379064f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07048097f, -0.04111852f, 0.21799830f, -0.02789912f, 0.05524633f, 0.08212389f, 0.04459708f, 0.02984187f, 
    0.04696647f, -0.00219160f, 0.24692631f, -0.03524573f, -0.06822452f, 0.13808645f, 0.00079141f, 0.10222334f, 
    -0.09245940f, 0.01331196f, 0.04623627f, 0.11467633f, 0.04880590f, -0.06316038f, 0.18063216f, -0.25033173f, 
    -0.01028425f, 0.20346291f, -0.05437297f, -0.05606912f, 0.16789548f, 0.00713428f, 0.14399272f, 0.08357923f, 
    0.01335997f, -0.05820539f, 0.15863119f, -0.01330248f, 0.03289952f, 0.08146287f, -0.03951295f, 0.13330130f, 
    0.09135104f, -0.09196552f, 0.18590432f, -0.00322216f, 0.05608011f, 0.00838580f, 0.14127934f, -0.00862681f, 
    0.06031061f, 0.19003455f, 0.03203944f, -0.11064075f, -0.05519955f, -0.05911896f, -0.02275821f, 0.15050629f, 
    0.15049104f, 0.17685923f, -0.05582151f, -0.07213664f, 0.36454397f, 0.24676442f, -0.04607558f, 0.08027656f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02495837f, 0.14747903f, -0.04235121f, -0.12092473f, -0.25596985f, -0.50101894f, -0.07311555f, 0.12721165f, 
    0.00121471f, 0.02617364f, -0.17400706f, 0.06664168f, 0.10505554f, -0.07366792f, 0.19053996f, -0.23643149f, 
    0.13340743f, 0.20838146f, 0.20323147f, 0.37988618f, 0.23802635f, 0.08085637f, 0.10510126f, 0.13605824f, 
    -0.17041238f, -0.35339558f, 0.18623868f, 0.27322417f, -0.18802036f, -0.16244482f, -0.14574070f, -0.02530805f, 
    0.02961254f, 0.04172077f, -0.16906941f, -0.28368357f, 0.17083775f, -0.21871039f, -0.21118358f, -0.20264018f, 
    0.16533078f, -0.08910872f, -0.39736256f, -0.48271179f, 0.05558457f, -0.07409392f, -0.03174351f, -0.11983895f, 
    -0.40577695f, -0.38278303f, -0.04162597f, 0.22169715f, 0.27169469f, -0.01347140f, 0.25748911f, -0.37988144f, 
    -0.40264946f, -0.50147706f, 0.02563353f, 0.21813086f, -0.12888871f, -0.43039787f, 0.27674216f, 0.17414817f, 
    0.11044125f, 0.17440324f, -0.18430555f, 0.03449885f, -0.32103962f, 0.18647741f, 0.11383650f, -0.03911939f, 
    -0.02899795f, 0.05109183f, 0.22763352f, 0.20037439f, 0.48022115f, -0.01898286f, 0.00812775f, -0.13492742f, 
    -0.07354480f, 0.18795818f, -0.12049359f, 0.23282672f, -0.19523144f, -0.72943437f, 0.30212012f, -0.33888286f, 
    -0.28065461f, 0.06681737f, -0.00007916f, 0.00909085f, 0.14312312f, -0.21720116f, 0.07079573f, 0.06799141f, 
    0.06180982f, -0.11701004f, 0.26440307f, -0.64007473f, 0.17177659f, 0.01623413f, -0.07236852f, -0.04676083f, 
    -0.17716247f, -0.01388092f, 0.11174215f, -0.81166410f, -0.05747267f, 0.03368143f, 0.01737921f, -0.11605376f, 
    0.22177030f, 0.14985853f, 0.08514512f, 0.16731831f, 0.36855990f, -0.61692238f, -0.32290819f, 0.19890198f, 
    -0.04317395f, 0.18685962f, 0.07209772f, 0.03881112f, 0.45276505f, -0.13034579f, -0.55018020f, 0.06435049f, 
    -0.40449363f, -0.00033914f, 0.20997812f, 0.11200671f, 0.00586501f, -0.11779427f, 0.19457178f, 0.05491748f, 
    -0.13700218f, 0.18171699f, -0.21545051f, 0.03443478f, 0.30681232f, 0.07782205f, -0.07289407f, 0.15388845f, 
    0.05905747f, 0.10081611f, 0.03004256f, -0.04609511f, -0.66227013f, -0.40647432f, -0.31136018f, -0.85210615f, 
    -0.07850531f, 0.08681430f, -0.32866272f, -0.45588356f, 0.13477555f, 0.25230747f, -0.21024291f, 0.02966302f, 
    0.06206939f, 0.21086931f, 0.14348605f, 0.19511062f, 0.00777837f, -0.04552920f, -0.07681070f, 0.04744161f, 
    -0.06719579f, 0.08837818f, 0.10466474f, -0.02808449f, -0.01439316f, 0.10673271f, 0.20319103f, 0.03029337f, 
    -0.03632636f, -0.29290482f, -0.14085735f, -0.53277677f, -0.38033295f, 0.34557059f, 0.22657186f, 0.19974996f, 
    0.05420937f, -0.21094182f, 0.11866076f, 0.25104332f, -0.21738446f, 0.04413598f, 0.12345597f, 0.23790078f, 
    -0.12778945f, 0.12839811f, -0.38275820f, -0.05203476f, 0.03947701f, -0.29734975f, 0.15599100f, 0.03186613f, 
    -0.71794355f, 0.16787381f, -0.17821507f, 0.18002142f, -0.23461837f, -0.01586632f, -0.19129838f, 0.23324136f, 
    0.17039995f, 0.20476933f, -0.01642477f, -0.64243269f, 0.15126206f, -0.08269585f, -0.29478708f, 0.25172171f, 
    -0.57209677f, -0.22841121f, 0.05118871f, 0.13626108f, 0.05271604f, 0.12110488f, -0.31292066f, -0.03588014f, 
    0.11313298f, 0.22095506f, 0.03080863f, 0.06043667f, -0.36147588f, 0.04618587f, 0.34092566f, -0.17519678f, 
    -0.01109143f, -0.04290926f, -0.05254814f, 0.27367455f, -0.14785370f, 0.10739899f, -0.06044754f, 0.04225810f, 
    0.23410702f, -0.30038574f, -0.02173934f, -0.00404685f, 0.09479452f, 0.10385820f, -0.24089354f, 0.02309223f, 
    -0.10205343f, 0.04199926f, -0.11937886f, 0.26868546f, -0.04268291f, -0.07364608f, 0.16650553f, 0.03635626f, 
    0.10542958f, 0.01894580f, -0.21364053f, 0.09530739f, 0.15431985f, 0.23188987f, 0.17768914f, 0.21292917f, 
    0.04224600f, -0.01056433f, -0.28153664f, 0.17172264f, 0.01231013f, -0.48802400f, -0.18855420f, -0.25875449f, 
    -0.00080198f, -0.01510067f, -0.30359516f, -0.07539371f, -0.28023982f, 0.30942684f, -0.09925850f, 0.00775744f, 
    0.26884961f, -0.01465500f, -0.14412998f, 0.00228142f, -0.33954382f, -0.07506657f, 0.19226612f, 0.18615372f, 
    -0.05977970f, 0.23155579f, -0.11809446f, 0.10076011f, -0.18288612f, -0.35367697f, -0.16190173f, 0.14167506f, 
    0.09000658f, -0.09049467f, -0.38609946f, 0.05420515f, 0.11299566f, 0.07411886f, -0.08003127f, -0.01257925f, 
    -0.05694374f, 0.27709463f, 0.27326262f, 0.18278895f, -0.09551392f, 0.29899815f, 0.05471639f, -0.08488631f, 
    -0.07270021f, -0.19657113f, 0.02721682f, 0.02879272f, 0.12970226f, -0.22202705f, -0.03143977f, 0.01174340f, 
    0.26308066f, 0.08423093f, 0.40616187f, 0.05146771f, -0.13417865f, -0.21504849f, -0.20856659f, 0.03201609f, 
    0.17544077f, 0.20457409f, 0.12786855f, 0.08276045f, -0.15462722f, -0.33410230f, -0.64839208f, -0.29651764f, 
    -0.24676135f, -0.22733197f, 0.06673191f, 0.09904983f, 0.37204704f, -0.04262305f, -0.01555369f, -0.01958786f, 
    0.41371167f, -0.24426641f, -0.24983959f, 0.11403968f, -0.17188197f, -0.57089567f, 0.12715636f, 0.20651463f, 
    0.09884704f, -0.53388268f, -0.12901917f, 0.12563618f, 0.05275461f, 0.29470247f, -0.10432463f, 0.28722486f, 
    -0.07169716f, 0.03588087f, 0.04351072f, 0.23495156f, 0.18469457f, 0.06578902f, -0.04054985f, 0.07167965f, 
    -0.31725299f, 0.03436627f, -0.10162446f, 0.05835556f, 0.06843469f, -0.39618760f, 0.09235438f, -0.06313321f, 
    0.17714678f, -0.09187669f, 0.04087259f, -0.67591524f, 0.05864381f, 0.10262801f, 0.08560410f, 0.02362636f, 
    -0.14987265f, -0.65195155f, 0.12556794f, 0.08835917f, 0.24698758f, 0.37355641f, -0.62189883f, -0.01214024f, 
    0.12974642f, -0.40496439f, -0.20263706f, -0.52835208f, -0.69925427f, 0.24393395f, 0.03757117f, 0.00191834f, 
    -0.11387770f, 0.09867481f, -0.34879941f, -0.15839303f, -0.41932759f, -0.32606491f, -0.08086854f, -0.26228562f, 
    -0.16442005f, -0.04041101f, -0.28988874f, 0.32064202f, 0.17863648f, 0.16346337f, 0.22951657f, 0.24270041f, 
    -0.01096901f, 0.16567877f, -0.07737425f, 0.28016523f, -0.09754840f, -0.20108913f, -0.46924475f, -0.25468341f, 
    0.30749783f, 0.10738388f, 0.09841751f, 0.44961101f, -0.07809801f, -0.01804318f, -0.53360212f, -0.09435442f, 
    0.25791222f, -0.33308890f, -0.66321182f, -0.67401052f, -0.23845622f, -0.09037998f, 0.03916332f, 0.36305219f, 
    0.28234905f, -0.17663509f, -0.11686312f, 0.34921205f, -0.08747879f, 0.18157607f, -0.21234325f, -0.70761675f, 
    -0.11370160f, -0.47367457f, -0.33279145f, -0.10383323f, 0.09833058f, 0.14872590f, -0.01259550f, 0.14535138f, 
    0.01096078f, 0.07961672f, -0.27187014f, -0.49759892f, -0.70214778f, 0.04664804f, -0.13319738f, -0.40685374f, 
    -0.51056933f, 0.02477745f, -0.19598220f, 0.20109054f, 0.24359711f, -0.28975964f, -0.07495946f, 0.55301106f, 
    0.26636752f, 0.05312004f, 0.23652117f, -0.25177887f, -0.07872814f, -0.17362806f, -0.19834605f, -0.62287360f, 
    0.00531111f, -0.05125273f, -0.48419014f, 0.18496135f, 0.07766242f, 0.10259932f, 0.19266111f, 0.09190434f, 
    -0.59243637f, 0.07223133f, -0.02412061f, 0.23618780f, -0.56181163f, -0.09556653f, -0.31089842f, -0.03574285f, 
    -0.01847676f, 0.35227048f, -0.38408998f, 0.49608004f, -0.21423964f, 0.47156003f, 0.24690180f, -0.19805062f, 
    -0.17737472f, 0.19613987f, -0.06522523f, 0.38780278f, -0.16379091f, 0.00549660f, 0.09588460f, -0.38241267f, 
    0.33141819f, -0.13401380f, -0.20853527f, -0.00744490f, 0.19100942f, -0.26050946f, -0.32992744f, -0.39128622f, 
    0.07267443f, 0.36341605f, 0.26131132f, -0.44831774f, -0.67259198f, 0.11300746f, 0.08066945f, 0.24557647f, 
    0.07032710f, 0.28406033f, 0.35149175f, 0.00822850f, -0.05230492f, -0.52876329f, 0.09446742f, -0.25687829f, 
    0.25032827f, -0.07333407f, 0.10875225f, -0.30661845f, -0.17944157f, -0.19736758f, -0.33898470f, -0.54350388f, 
    -0.01536560f, -0.01597576f, -0.00843848f, -0.07735801f, 0.17904991f, 0.35735461f, 0.35977715f, 0.14431369f, 
    -0.13056093f, 0.00518542f, 0.01758296f, 0.07476437f, 0.18704899f, -0.11217157f, 0.44851878f, -0.07936574f, 
    -0.47361848f, -0.13898891f, -0.36614239f, -0.64516330f, -0.62664938f, -0.03547237f, -0.30405465f, 0.12505691f, 
    -0.31858137f, 0.25923595f, -0.11391366f, 0.10870429f, -0.19711199f, 0.09263677f, -0.03837192f, -0.72437108f, 
    0.05649369f, -0.20564680f, -0.10379186f, -0.08026209f, -0.14729728f, 0.27934548f, -0.00760636f, -0.06481322f, 
    0.16734833f, -0.46736374f, -0.44164869f, -0.05752277f, 0.29165110f, -0.09638141f, -0.06609422f, -0.25612026f, 
    -0.10630412f, -0.24391232f, -0.22601141f, 0.47794852f, 0.07685586f, 0.03654566f, -0.50889736f, -0.16487478f, 
    0.33349648f, 0.16481477f, 0.30258456f, -0.22394767f, -0.05753175f, 0.08846049f, 0.16364610f, 0.23981296f, 
    -0.11854015f, 0.11836687f, 0.16495879f, 0.09539944f, -0.31216967f, -0.13189019f, -0.36605662f, -0.45099780f, 
    0.07898089f, -0.04202512f, 0.05551265f, -0.08256796f, -0.17439383f, -0.00635710f, -0.58710241f, -0.02222050f, 
    -0.01465640f, -0.05996270f, 0.39005351f, 0.33055583f, -0.50121444f, 0.26176137f, 0.25891921f, -0.31626052f, 
    0.14267540f, 0.14959705f, -0.10403704f, -0.58574677f, -0.17849793f, 0.21941955f, 0.37483609f, -0.23616713f, 
    -0.41477790f, 0.14352152f, 0.20620064f, 0.04223341f, 0.43668935f, 0.14724334f, 0.37560594f, -0.11233079f, 
    -0.49992949f, -0.19112541f, -0.08536592f, 0.04082651f, -0.58462596f, -0.31096220f, 0.68512434f, -0.08960028f, 
    0.24293306f, -0.48043117f, 0.11109598f, -0.09740010f, -0.35889068f, -0.20685403f, 0.19650815f, -0.06208493f, 
    -0.49682325f, -0.23012349f, -0.14786848f, -0.09145704f, -0.15229197f, -0.50661016f, 0.07879361f, -0.39425805f, 
    0.06487341f, 0.12637895f, 0.36110416f, -0.15927975f, -0.07421189f, -0.20870318f, -0.01163971f, 0.26815829f, 
    0.30404735f, -0.07855412f, 0.35810110f, 0.03502312f, 0.15593949f, -0.00186345f, 0.17727755f, 0.01795250f, 
    0.48939663f, 0.32008448f, -0.05482328f, -0.29804873f, 0.06928953f, -0.59874237f, -0.79015529f, 0.02963489f, 
    0.14771388f, -0.02815580f, 0.09786072f, -0.21877815f, -0.38377687f, -0.09550174f, -0.49472505f, -0.06151443f, 
    -0.04291838f, -0.20742890f, 0.08620214f, -0.05366123f, -0.42572048f, -0.29899234f, 0.08674602f, -0.30966699f, 
    0.13075961f, -0.52098137f, 0.36165982f, -0.08354913f, -0.28816846f, 0.04618488f, 0.20984530f, 0.33850604f, 
    -0.21495980f, 0.19428161f, -0.08670434f, -0.68161666f, -0.47298536f, 0.44710502f, 0.16317771f, 0.26689628f, 
    -0.09520718f, 0.28922483f, 0.07317212f, 0.07934651f, -0.00118589f, 0.45451871f, 0.24559027f, -0.15734778f, 
    -0.00136660f, -0.57826376f, -0.10691427f, 0.16979255f, -0.44179448f, -0.27166298f, -0.10362040f, 0.10300588f, 
    -0.06528220f, -0.09704885f, -0.19405042f, -0.14090665f, 0.17416528f, -0.06625760f, 0.25202373f, -0.04291907f, 
    -0.06419999f, -0.08348005f, -0.08831999f, -0.41655445f, -0.50500554f, 0.08981133f, 0.08819455f, 0.04377140f, 
    0.21597373f, 0.11502963f, 0.07145241f, 0.06149831f, -0.38419610f, 0.08148886f, -0.67780703f, 0.32651520f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18521544f, -0.04104833f, 0.16151515f, -0.04090656f, 0.00728116f, 0.09958414f, -0.01475423f, 0.03413880f, 
    0.10927361f, 0.09946191f, 0.16368788f, -0.11433677f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
