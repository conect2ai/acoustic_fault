#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.87497663f, -0.73081446f, -0.48795959f, 0.37067020f, 0.24897517f, 0.54384512f, 0.15510854f, 0.03902308f, 
    -0.10671575f, 0.54732823f, 0.32789046f, -0.03000398f, -0.25831568f, -0.14908576f, -0.06674581f, -0.71558475f, 
    -0.34114522f, -0.36092374f, 0.90439343f, 0.41812751f, 0.17165405f, 0.55417168f, 0.18571571f, -0.18491735f, 
    0.02359202f, 0.41258541f, -0.10573798f, -0.32788685f, -0.60165882f, -0.40737247f, 0.39573741f, 0.74349421f, 
    0.10951430f, -0.27442566f, -0.23536853f, -0.13805352f, 0.05976980f, -0.14749447f, -0.50488704f, -0.49820539f, 
    -0.58465576f, -0.69713128f, 0.33555484f, 0.29285604f, 0.02389762f, 0.01209922f, -0.65331882f, -0.40016183f, 
    -0.45548713f, -0.45422572f, -0.09801874f, -0.53257883f, -0.02954772f, -0.12248160f, -0.36130741f, 0.48231721f, 
    -0.27875420f, 0.36224329f, -0.22631213f, -0.34790099f, -0.16705170f, 0.24150181f, 0.67877692f, -0.11035993f, 
    -0.73866308f, -0.39223325f, -0.13482788f, -0.68814099f, -0.13560608f, -0.13624407f, 0.11010538f, 0.26181278f, 
    0.31980643f, 0.31930381f, 0.35642347f, 0.22700533f, 0.42985108f, 0.31295267f, -0.27107230f, -0.53352535f, 
    -0.45609382f, 0.25944981f, 0.63839054f, 0.73773843f, 0.20715499f, 0.09787061f, 0.41156712f, 0.00266945f, 
    0.22848353f, -0.07198209f, 0.54488719f, 0.52117497f, -0.64028645f, 0.47449777f, 0.36016449f, -0.27953359f, 
    0.51157606f, -0.19603029f, -0.00700794f, 0.31335181f, 0.32384408f, 0.63824958f, -0.54193735f, -0.06855802f, 
    -0.95664841f, -0.11405972f, -0.23249027f, 0.19129246f, 0.70500177f, -0.54729152f, -0.40048045f, -0.58046293f, 
    0.15926255f, -0.12598467f, -0.01255179f, 0.29022461f, 0.13125472f, -0.79233235f, 0.29612011f, 0.08578247f, 
    0.31368530f, 0.17865317f, -0.80365741f, -0.05722835f, 0.08277849f, -0.06212560f, 0.19159453f, -0.45159805f, 
    0.39266253f, 0.78040594f, -0.63447076f, 0.19313082f, 0.25798130f, -0.37133583f, -0.20734362f, 0.74676704f, 
    0.77537787f, 0.38787881f, -0.48395231f, -0.50150663f, 0.10249916f, 0.25891507f, 0.08101834f, 0.10978690f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08446243f, 0.28804806f, -0.21564507f, 0.15450804f, 0.31024098f, -0.29571530f, -0.16324195f, 0.43555215f, 
    0.31284368f, 0.55987316f, -0.30676973f, 0.11572023f, -0.12210798f, 0.21057531f, -0.01256925f, 0.02893033f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.23958723f, 0.54419696f, 0.17840102f, -0.08362139f, 0.02262896f, -0.15296134f, -0.03832167f, 0.08883934f, 
    0.07098337f, 0.00795004f, 0.00743715f, -0.13571016f, 0.11063697f, -0.01092204f, 0.06406058f, -0.05726073f, 
    -0.03028409f, -0.08867057f, -0.15661344f, 0.08877312f, 0.32321689f, 0.09668680f, 0.00031378f, -0.20811683f, 
    -0.06806755f, 0.04457428f, 0.06414673f, 0.32427946f, 0.14148091f, -0.04227263f, -0.23782510f, 0.12962675f, 
    -0.04785417f, 0.05591577f, 0.16570848f, -0.22204258f, 0.21002766f, -0.11914834f, -0.27147114f, -0.10070450f, 
    0.05563063f, 0.12322887f, 0.28496429f, -0.08480172f, 0.09128598f, 0.12105975f, -0.03632957f, 0.10849647f, 
    0.15823954f, -0.00324580f, 0.08808669f, -0.16534409f, -0.09521593f, 0.05302209f, -0.33109051f, -0.06873455f, 
    -0.09097580f, 0.12834498f, -0.22702220f, -0.05073203f, 0.01888070f, 0.11322992f, 0.08603633f, -0.41780013f, 
    0.38679492f, -0.10807590f, 0.01960560f, -0.01466763f, 0.04597635f, 0.06584788f, 0.02903924f, -0.16190536f, 
    0.28743836f, -0.02016140f, 0.02875629f, 0.10369436f, -0.09096105f, 0.06519260f, 0.00852637f, 0.22773339f, 
    0.08055948f, 0.12949169f, 0.05958534f, 0.06987870f, 0.00485810f, 0.06683768f, 0.02409986f, 0.14643973f, 
    -0.18699403f, 0.17991199f, 0.34280056f, -0.37096322f, -0.19720446f, -0.14875394f, -0.05929733f, -0.03608887f, 
    -0.02277205f, -0.00932775f, 0.15794042f, -0.08590438f, -0.46249118f, -0.15200056f, 0.19290681f, -0.00104021f, 
    0.06749129f, -0.00677447f, -0.06940945f, -0.11067193f, 0.76095855f, -0.09093914f, -0.28812525f, 0.19343500f, 
    0.00030204f, 0.00989491f, -0.01658925f, -0.19425558f, -0.16178809f, -0.76718074f, -0.45287991f, -0.17111333f, 
    -0.11942714f, 0.15828659f, -0.11334265f, -0.09808200f, 0.08536752f, 0.06002018f, 0.01867938f, 0.13632703f, 
    0.24630199f, 0.04005395f, 0.07135479f, -0.09436976f, -0.04716575f, 0.06045594f, 0.00459946f, 0.01345219f, 
    -0.07292719f, 0.20784174f, 0.24444979f, -0.23203905f, 0.19448273f, 0.10169122f, -0.13911831f, 0.16110189f, 
    -0.14526451f, -0.09845988f, -0.13881457f, -0.11531505f, 0.07168477f, 0.07720169f, -0.10777726f, 0.18321262f, 
    -0.31135619f, 0.11315347f, 0.21364054f, -0.04764749f, 0.28191510f, -0.11056966f, 0.17995092f, 0.02055944f, 
    -0.18411900f, 0.19740061f, -0.24221259f, -0.08683387f, -0.13530798f, 0.20896980f, -0.11167309f, 0.11079085f, 
    0.05693749f, -0.04463977f, 0.02014833f, -0.05028018f, -0.46794605f, 0.10951923f, -0.03181013f, -0.08141001f, 
    0.09215927f, -0.30497673f, -0.16465923f, 0.00856105f, 0.13646828f, 0.16366951f, -0.18256117f, 0.31872863f, 
    -0.12724967f, -0.01833091f, 0.10566839f, 0.01249736f, 0.02258366f, 0.20898078f, 0.10361521f, -0.02201116f, 
    -0.22410716f, -0.16547878f, 0.17053054f, 0.05271653f, -0.08669866f, 0.20978385f, 0.25275877f, 0.03852882f, 
    -0.00322992f, -0.10955584f, -0.00250389f, -0.09559511f, 0.26204178f, 0.10530360f, -0.21762234f, 0.37696671f, 
    0.08987433f, -0.19177605f, 0.08475221f, 0.03585476f, -0.03501843f, 0.29563016f, -0.14791425f, 0.13220000f, 
    0.07334121f, 0.23012091f, 0.01465146f, 0.05591989f, 0.24699937f, 0.03632035f, -0.11847687f, -0.04793268f, 
    0.05821302f, 0.26971561f, 0.20483859f, 0.28603664f, 0.17329316f, 0.15330712f, 0.12021533f, 0.17822497f, 
    -0.06852804f, 0.07676745f, 0.05263638f, -0.61163479f, 0.06047748f, 0.31089658f, 0.10638864f, -0.11800291f, 
    -0.17663378f, 0.01561426f, 0.07679462f, 0.55943209f, 0.41616786f, 0.14039612f, 0.00008436f, -0.08073305f, 
    -0.02288388f, 0.03670490f, -0.08494667f, -0.06259838f, 0.12118188f, 0.09196511f, -0.23379914f, 0.01401398f, 
    -0.31529695f, -0.13552541f, -0.06744495f, 0.04258842f, -0.13580820f, 0.02253169f, -0.02223012f, -0.07480020f, 
    -0.15837750f, 0.02178592f, -0.11692830f, -0.00032723f, -0.13653691f, 0.21193834f, -0.50233263f, -0.21571031f, 
    -0.21491478f, 0.12626225f, 0.11139962f, 0.37089369f, -0.00074671f, -0.13139081f, -0.27189207f, 0.18766172f, 
    0.33133823f, 0.02189164f, 0.25283140f, -0.05670588f, 0.02731595f, 0.01686872f, -0.00908891f, 0.04476094f, 
    0.02163058f, 0.05197319f, 0.00154693f, -0.03592826f, -0.08558697f, 0.06781718f, -0.08351407f, 0.02911842f, 
    -0.05293063f, 0.07134687f, 0.05502860f, -0.08242480f, 0.04286444f, 0.02769995f, -0.00073636f, -0.00436089f, 
    0.00020983f, -0.07361390f, 0.05492363f, -0.05987751f, 0.05136080f, 0.06936350f, -0.05230477f, -0.02086926f, 
    0.01603421f, 0.05237183f, 0.03709727f, -0.02637082f, -0.04007430f, -0.09015472f, -0.05259337f, -0.00472208f, 
    -0.08232370f, -0.04865804f, -0.04017505f, 0.01498922f, 0.04664480f, -0.04265233f, 0.00519347f, -0.02569631f, 
    -0.04422498f, 0.00515425f, -0.07077867f, -0.03313344f, 0.06182211f, -0.06783487f, 0.07417200f, -0.05158458f, 
    0.02384555f, 0.01716502f, 0.01354098f, 0.05414206f, -0.01067833f, 0.02843679f, -0.00132108f, -0.01808394f, 
    0.07545289f, 0.04977116f, -0.01912589f, 0.03559069f, 0.05028050f, 0.05899791f, 0.02551029f, -0.08655636f, 
    0.02753450f, -0.05483550f, -0.07991050f, 0.05924836f, -0.06655184f, -0.05175449f, 0.02569093f, -0.06561405f, 
    -0.00088729f, 0.00828865f, -0.05952055f, -0.04983184f, -0.01356260f, -0.08681527f, 0.01235207f, 0.03817123f, 
    -0.07492164f, -0.06774428f, -0.04559368f, -0.03826282f, -0.03851695f, -0.03651078f, -0.02881793f, 0.06875252f, 
    -0.06187002f, 0.04919021f, 0.07315208f, 0.05905823f, -0.04995755f, -0.02286459f, -0.04319227f, -0.00467751f, 
    -0.01402011f, -0.08573219f, -0.08792564f, -0.06759034f, -0.00939990f, -0.08684867f, -0.08274905f, 0.01910242f, 
    -0.01388358f, 0.06716722f, -0.08748931f, -0.01048497f, 0.02949579f, 0.03826138f, 0.00634073f, 0.00030171f, 
    0.08114016f, 0.00828257f, -0.07450584f, 0.07408804f, -0.08513995f, 0.03185045f, 0.01362472f, -0.06366018f, 
    -0.08704731f, -0.00307488f, -0.02020748f, -0.01170129f, -0.06111290f, -0.05041005f, 0.03292007f, 0.00258960f, 
    -0.05172629f, -0.08387282f, -0.04967776f, -0.01970169f, -0.05804604f, -0.06243452f, -0.03679385f, -0.06646400f, 
    -0.08983003f, 0.04588075f, -0.07249784f, -0.01865196f, -0.03065429f, -0.04245974f, 0.07029468f, 0.00007578f, 
    0.03437119f, 0.24746464f, -0.54906702f, 0.05567566f, 0.16236509f, -0.05602961f, 0.13341793f, -0.01959011f, 
    -0.17294978f, -0.07167279f, 0.00873896f, -0.03824516f, 0.14747009f, -0.12623857f, 0.05800537f, 0.19466832f, 
    0.07652291f, 0.09589756f, 0.03788223f, -0.33327821f, 0.00299960f, -0.04843868f, -0.03931380f, -0.07220770f, 
    -0.15805788f, 0.10883260f, -0.21883409f, 0.27248499f, -0.04449605f, -0.39092585f, 0.11097602f, 0.14625593f, 
    0.05548123f, -0.06875073f, -0.02057067f, -0.08873791f, -0.13130137f, -0.08661781f, 0.19373135f, 0.05398048f, 
    0.00104954f, -0.01024090f, 0.03242682f, -0.02862692f, 0.12808827f, -0.11206412f, -0.29613918f, 0.05917087f, 
    0.13933687f, 0.07309012f, -0.02191558f, 0.01375645f, -0.26554394f, 0.00069954f, -0.15274480f, -0.27433577f, 
    -0.30676714f, -0.02560854f, 0.14586164f, 0.01002401f, 0.02746151f, -0.18192790f, 0.20797326f, -0.33372700f, 
    -0.14807712f, -0.02697365f, -0.06661814f, 0.00560585f, 0.04897798f, -0.10321082f, 0.18311511f, 0.07597519f, 
    0.03167671f, 0.15973338f, 0.04710534f, -0.09858365f, 0.09322713f, -0.02132096f, 0.06200800f, 0.18234581f, 
    0.08087102f, 0.05406403f, 0.19249378f, 0.23425098f, 0.19397140f, 0.20093217f, 0.04875934f, -0.02717215f, 
    -0.01859670f, -0.17554085f, -0.07324028f, -0.19909093f, -0.09403735f, -0.02598504f, 0.00973493f, -0.22460045f, 
    0.05987965f, 0.03345013f, -0.09617189f, 0.28039807f, 0.06731676f, -0.05830966f, 0.01470188f, 0.00386457f, 
    0.09287743f, 0.06804845f, -0.03419458f, 0.15029007f, -0.42367885f, -0.31411076f, -0.25348011f, -0.15403986f, 
    -0.01988508f, -0.17240380f, 0.03166130f, -0.20059383f, -0.10015343f, 0.01799339f, -0.25891420f, 0.12301140f, 
    0.17078157f, -0.04223103f, -0.08305940f, 0.17241128f, 0.08923157f, 0.12795883f, -0.13684228f, -0.13788930f, 
    0.10841806f, 0.14188655f, 0.18002948f, 0.12664860f, 0.01616648f, 0.04830058f, -0.20899861f, -0.20503114f, 
    0.07208880f, 0.10089211f, 0.01956166f, -0.26960829f, 0.04129812f, -0.05905168f, 0.03800653f, 0.14461270f, 
    -0.15498124f, 0.03474879f, -0.11759777f, 0.06086241f, 0.29636863f, -0.02027496f, 0.00354704f, -0.05989359f, 
    -0.06006090f, 0.14677347f, 0.10037877f, -0.10199269f, 0.12990811f, 0.08636413f, -0.10949296f, 0.16332127f, 
    -0.06133945f, -0.14905386f, -0.07654152f, -0.31052184f, -0.19480518f, 0.08846238f, 0.00685618f, 0.08946276f, 
    0.10600159f, -0.06548065f, 0.12060549f, -0.15411326f, -0.19573222f, 0.11747622f, 0.02258396f, -0.14578131f, 
    0.12221605f, 0.05418688f, 0.08892424f, 0.10157338f, -0.05190203f, -0.06508505f, 0.23266324f, -0.13821527f, 
    0.13031015f, 0.04554813f, -0.16943659f, 0.24566425f, -0.14337878f, 0.06096825f, -0.17490372f, -0.01981503f, 
    -0.00395713f, -0.14652397f, -0.29679748f, 0.14062737f, 0.08894911f, 0.02628454f, 0.05019860f, -0.27655011f, 
    0.20701450f, -0.03094283f, 0.02820391f, 0.04984095f, -0.17436369f, -0.21968302f, -0.21254086f, 0.13210088f, 
    -0.27072954f, 0.10682688f, -0.17403220f, 0.12885408f, 0.05341743f, 0.18133003f, -0.00002160f, 0.11159930f, 
    -0.26529285f, 0.10333534f, -0.00787227f, 0.08244535f, -0.12737653f, 0.24097475f, 0.21173742f, -0.04716646f, 
    0.13523048f, -0.25393426f, -0.10633437f, -0.05682089f, -0.10719016f, 0.15223044f, 0.21635716f, 0.03373520f, 
    0.04918721f, -0.12584710f, -0.04379753f, 0.05267639f, 0.11350080f, 0.19482411f, -0.06564380f, -0.04103703f, 
    -0.10013662f, 0.14714307f, -0.09711272f, 0.10962722f, -0.00939497f, 0.36757633f, -0.10688000f, -0.39088333f, 
    0.00058103f, 0.07488808f, 0.30851528f, 0.15016869f, -0.05163211f, -0.27845651f, 0.05943318f, -0.10321971f, 
    -0.22772287f, -0.12778856f, 0.21519287f, 0.05758827f, 0.05160832f, 0.14807604f, 0.09347497f, 0.09804665f, 
    -0.29579496f, -0.17146032f, -0.07822727f, -0.07973837f, 0.01360870f, 0.09465540f, 0.09092899f, -0.20198599f, 
    -0.23212945f, -0.05849244f, 0.14129238f, 0.21321876f, 0.04418299f, 0.01764002f, -0.04383087f, -0.13698955f, 
    -0.13675191f, -0.09959408f, 0.13866867f, -0.01661050f, 0.11783695f, 0.28079653f, -0.11508013f, 0.05542792f, 
    -0.29137298f, -0.13760945f, 0.01760756f, -0.02640472f, 0.16020826f, 0.07284802f, 0.20706874f, 0.04346932f, 
    0.01516796f, 0.09473344f, 0.05279464f, 0.28250045f, -0.15495877f, -0.12837230f, -0.04058694f, -0.02600947f, 
    0.21124904f, -0.05466281f, -0.18651414f, 0.25550762f, -0.19013694f, -0.05690334f, 0.02132613f, -0.05888627f, 
    0.02706754f, 0.06310470f, 0.00582042f, -0.16408797f, -0.06341638f, 0.00314106f, 0.13463639f, 0.08480594f, 
    -0.04217024f, -0.21139982f, -0.27196604f, -0.01830083f, 0.17653657f, 0.15205730f, 0.01900610f, 0.15248457f, 
    0.08470225f, -0.06437918f, 0.27872530f, -0.05127824f, 0.14325750f, 0.17777194f, -0.02788243f, 0.16274756f, 
    0.08851784f, 0.17126131f, -0.03416009f, -0.05666657f, -0.06588728f, -0.07542463f, -0.13701642f, 0.01658284f, 
    0.05286252f, 0.09731166f, -0.09469532f, 0.08867039f, -0.26002210f, 0.02008976f, 0.05475434f, -0.07667259f, 
    -0.29809120f, 0.14711529f, 0.10412190f, 0.04738229f, -0.28092393f, -0.13302609f, -0.14126356f, -0.07148950f, 
    0.35904679f, -0.08935700f, 0.08026738f, -0.01163758f, -0.13625947f, -0.16653615f, 0.33390179f, -0.11231654f, 
    -0.02497320f, -0.17827563f, 0.00025718f, 0.00695041f, 0.15647602f, -0.00538944f, 0.04589158f, 0.01753555f, 
    0.02616840f, -0.11627325f, -0.14973278f, -0.07389922f, -0.03313489f, -0.18127356f, -0.05466207f, -0.05165996f, 
    -0.12717026f, -0.07352374f, -0.00717704f, 0.09971706f, 0.06318092f, 0.25168833f, -0.14310023f, 0.20089610f, 
    0.01546883f, -0.01095226f, -0.14959748f, 0.22656094f, 0.12950771f, -0.11762353f, -0.14229561f, -0.18754713f, 
    -0.06532735f, -0.00226552f, -0.04885252f, 0.08958415f, 0.07439210f, -0.20935185f, -0.09762401f, -0.07182278f, 
    0.15780020f, 0.04241157f, -0.10596851f, 0.15286213f, 0.12994628f, 0.03594140f, 0.15183948f, -0.19029424f, 
    -0.53177017f, -0.06440411f, 0.11547817f, 0.20936505f, -0.04263423f, -0.07477272f, 0.03961317f, -0.25158039f, 
    0.27981770f, 0.23927674f, -0.23297331f, -0.19670919f, -0.05774768f, 0.02117576f, -0.05101192f, -0.07741801f, 
    -0.23817205f, -0.25836724f, 0.10984815f, -0.11070623f, -0.02935378f, -0.01287792f, -0.02468174f, -0.06420738f, 
    0.10325055f, -0.00879669f, -0.02458468f, -0.16015281f, 0.11858642f, 0.14713743f, 0.11903679f, -0.01815243f, 
    0.07430962f, -0.11271322f, 0.16493909f, 0.22156584f, -0.00445574f, -0.24235788f, -0.05151454f, -0.06486597f, 
    -0.18892358f, 0.05807674f, -0.00701065f, -0.26668152f, -0.30809119f, -0.28744158f, -0.13108236f, -0.16612375f, 
    -0.00274426f, -0.02697268f, -0.08035561f, -0.07662690f, -0.16391940f, 0.10188645f, -0.11715088f, 0.12986189f, 
    0.03532193f, 0.17118612f, 0.04652059f, 0.05758206f, -0.05593253f, -0.09599783f, 0.27254814f, -0.18984273f, 
    0.09958845f, 0.23574652f, 0.21477628f, -0.12365833f, 0.18121082f, -0.19017477f, -0.15858115f, 0.09985146f, 
    -0.13479581f, 0.03435395f, 0.00712178f, 0.04724033f, -0.15885442f, -0.01026076f, 0.02727458f, -0.31811130f, 
    0.06084968f, -0.12352337f, 0.08396781f, 0.02128699f, -0.12775369f, -0.14070158f, 0.04769994f, 0.00497222f, 
    0.18713515f, 0.00976000f, -0.08468331f, 0.06191165f, -0.11918026f, -0.32255659f, 0.14356424f, 0.12518486f, 
    -0.13396856f, 0.36425385f, 0.16522138f, 0.07104389f, 0.01524161f, 0.01572350f, -0.05866079f, 0.03888840f, 
    0.03639882f, -0.04205091f, -0.43454480f, 0.03143254f, 0.01856381f, -0.01028542f, 0.07684648f, -0.13940150f, 
    -0.04662696f, -0.02660740f, 0.16616833f, 0.24949306f, -0.10509288f, 0.01340839f, 0.15791249f, -0.04462556f, 
    0.11490870f, 0.10779306f, 0.07116735f, 0.14565137f, -0.17707682f, -0.31903541f, 0.06296843f, -0.01168475f, 
    0.01244563f, -0.05734479f, 0.00007643f, -0.16262381f, -0.01592939f, -0.16475941f, -0.14049284f, 0.12459611f, 
    0.25925031f, -0.09478529f, 0.07777195f, -0.01880130f, -0.07237412f, 0.10707542f, 0.19176517f, -0.07466637f, 
    0.03171840f, 0.09326269f, -0.18902384f, 0.08815321f, 0.02882373f, -0.02274915f, 0.09022795f, 0.32100764f, 
    0.14219193f, 0.10242161f, -0.08808354f, 0.08799481f, 0.03646847f, 0.08360109f, 0.11554410f, 0.12119067f, 
    -0.05248277f, 0.14724851f, 0.02372442f, -0.12664424f, -0.09695294f, 0.13159393f, -0.13453960f, 0.09750518f, 
    0.12525734f, 0.07485431f, -0.14183557f, -0.10479909f, 0.22438774f, 0.07233309f, -0.04091067f, -0.00580446f, 
    -0.16868818f, -0.08345205f, -0.17374389f, -0.27602914f, -0.06558824f, 0.02145932f, 0.01178632f, -0.05751142f, 
    0.01312331f, 0.01971558f, 0.18098152f, 0.03839141f, 0.24364671f, 0.11478116f, -0.33625385f, -0.04713022f, 
    -0.24248531f, -0.05166697f, 0.16885860f, -0.08852988f, 0.45076275f, 0.13119100f, -0.19035660f, -0.10075751f, 
    -0.12822723f, -0.12631319f, 0.02704301f, -0.05098526f, 0.08370692f, 0.03013965f, 0.20476158f, -0.08778096f, 
    -0.29403424f, 0.18393736f, -0.02712477f, 0.00586968f, 0.08347148f, -0.05033487f, 0.21858583f, -0.11133198f, 
    -0.00889606f, -0.17042714f, -0.05179007f, 0.16819985f, -0.04830192f, -0.03789329f, -0.02739769f, 0.31601605f, 
    -0.00461789f, -0.23865907f, 0.06841453f, -0.22283192f, -0.06025749f, 0.00248827f, -0.01404748f, -0.04589985f, 
    -0.01996753f, -0.40877214f, -0.10088205f, 0.04753965f, 0.21721689f, 0.06080364f, -0.03565818f, 0.11334713f, 
    0.07086252f, 0.04814551f, -0.23807693f, -0.11633386f, 0.12085429f, 0.16194735f, -0.04282975f, 0.02882138f, 
    -0.06467380f, -0.04470110f, 0.08896371f, -0.01722191f, -0.10868520f, 0.07733154f, -0.08072647f, -0.04618147f, 
    -0.14582755f, 0.11040352f, -0.09263031f, -0.08193111f, 0.03743202f, 0.16244534f, 0.14974307f, 0.00367202f, 
    0.20219095f, -0.03323441f, -0.11636325f, 0.05055640f, -0.10755512f, 0.31372195f, -0.09088940f, -0.18514681f, 
    -0.21911205f, -0.04148258f, 0.26014552f, 0.06668646f, -0.04979351f, 0.12914571f, -0.29991180f, -0.03796427f, 
    -0.07019020f, -0.06059986f, -0.03163638f, -0.01258235f, 0.05761905f, -0.04775544f, -0.06468845f, -0.06429202f, 
    -0.03283104f, 0.04658233f, 0.08625545f, -0.07926971f, 0.00108625f, 0.05239607f, 0.24419869f, 0.33801287f, 
    -0.19956808f, -0.03856368f, 0.11920769f, 0.04353827f, 0.07137966f, 0.07664154f, -0.03540790f, -0.08178266f, 
    0.14515889f, -0.08426592f, 0.11870362f, 0.07893473f, -0.11379185f, 0.15165716f, 0.07783271f, 0.05090886f, 
    0.10414977f, -0.04867527f, -0.05577046f, -0.03138982f, 0.00670138f, 0.05113065f, -0.28320760f, -0.03113451f, 
    -0.00248692f, 0.06539524f, -0.13581946f, 0.22549732f, -0.02510307f, -0.11178171f, -0.05843516f, -0.00290948f, 
    -0.09726914f, 0.03213520f, -0.18607825f, 0.02634166f, -0.02651468f, 0.32001662f, 0.03460973f, 0.05027509f, 
    0.26872471f, -0.03949492f, -0.05794879f, 0.08453611f, 0.02031119f, -0.01075946f, -0.12370884f, -0.04967453f, 
    0.01218961f, -0.10104375f, 0.07679210f, -0.15948005f, -0.00844711f, 0.49658245f, 0.17163728f, 0.51226336f, 
    0.01278375f, 0.17715842f, 0.03570291f, 0.03437843f, -0.05623098f, -0.01223686f, 0.07373223f, 0.06929988f, 
    0.08172664f, -0.18883085f, -0.01701098f, -0.02213019f, 0.11115750f, 0.07081970f, -0.12597534f, 0.17731650f, 
    -0.04315743f, 0.26034185f, -0.01744275f, 0.02437592f, -0.15262859f, -0.05369706f, -0.07612139f, -0.00983167f, 
    0.18120712f, -0.06208766f, 0.07695763f, -0.05008567f, 0.09104650f, 0.08510852f, 0.17204101f, -0.06692459f, 
    -0.20471239f, 0.16788019f, -0.08493701f, 0.22760813f, 0.01597906f, -0.01201456f, 0.02062363f, 0.04796460f, 
    -0.05092953f, -0.36673924f, -0.13026442f, 0.25453696f, 0.04352240f, -0.21822444f, -0.11028533f, 0.00654075f, 
    -0.03697222f, 0.04364919f, -0.05903734f, 0.25404090f, -0.11488265f, -0.08991820f, 0.02438631f, 0.02819726f, 
    0.00021466f, -0.03591038f, 0.02092988f, 0.11337866f, 0.28774846f, 0.11921459f, 0.14227644f, -0.19813226f, 
    -0.06839077f, 0.12280463f, -0.08509369f, -0.03861156f, -0.09957006f, 0.20468962f, 0.03843740f, -0.05925195f, 
    0.25129607f, -0.10087751f, -0.03363854f, 0.03650697f, -0.02632058f, 0.11840747f, 0.20704044f, -0.01258755f, 
    -0.31589645f, -0.09805039f, -0.24954017f, -0.07204340f, -0.12053881f, -0.14900535f, -0.11946800f, -0.46529225f, 
    -0.36640689f, -0.11922643f, 0.08034018f, 0.05839443f, -0.38958770f, -0.14395362f, 0.07352891f, -0.10307161f, 
    0.02469907f, -0.08493418f, -0.04311114f, 0.06658944f, -0.06298751f, -0.04577362f, -0.04887190f, -0.03511882f, 
    -0.07990959f, -0.00225160f, -0.05374815f, -0.03898956f, -0.02835654f, -0.03451161f, 0.05253468f, -0.03614562f, 
    -0.00443846f, -0.02707374f, -0.07282645f, 0.06332574f, 0.06485233f, 0.04818633f, -0.02417909f, 0.02436604f, 
    0.05838657f, -0.00310895f, 0.00077520f, -0.06875701f, 0.05562760f, -0.03172249f, -0.03751934f, 0.04530339f, 
    -0.02487394f, 0.02269782f, 0.06661777f, -0.05206559f, -0.03831292f, 0.07769101f, 0.00570895f, 0.04631150f, 
    0.05346242f, 0.04380848f, 0.07196479f, -0.06062729f, -0.09110388f, -0.05320070f, -0.02604158f, -0.00120890f, 
    0.03309977f, 0.07122334f, 0.04300883f, 0.00413024f, -0.04619952f, 0.05763985f, -0.05846462f, 0.03967882f, 
    -0.06096178f, -0.01970998f, 0.02521795f, -0.03897063f, 0.03147083f, 0.03001990f, -0.03186989f, 0.02093627f, 
    -0.04284561f, -0.02793656f, -0.00914488f, -0.01493132f, -0.02624396f, -0.02012390f, -0.03831211f, -0.03556142f, 
    -0.08921368f, -0.06867565f, -0.01991928f, -0.03251494f, -0.04292637f, 0.06640475f, -0.06805032f, 0.03777609f, 
    -0.01691344f, 0.04621985f, -0.00567132f, 0.01657896f, -0.00812037f, 0.01935128f, -0.03342211f, -0.07695406f, 
    0.02734634f, 0.05481135f, -0.04369763f, -0.01566852f, -0.01773382f, 0.02162285f, 0.00648702f, -0.00597789f, 
    -0.04784109f, 0.03835069f, 0.03601122f, -0.08113582f, -0.08796629f, -0.06307034f, 0.02277942f, 0.02084274f, 
    -0.00244566f, 0.00689757f, -0.00601771f, -0.10049988f, -0.04936907f, 0.01179404f, 0.07438198f, -0.01411165f, 
    0.00374628f, 0.00786593f, -0.05470768f, -0.03489352f, 0.01792041f, -0.05731523f, -0.06285811f, -0.06441426f, 
    0.03979502f, 0.07060621f, -0.05659502f, -0.05885344f, 0.01142264f, -0.01768681f, -0.07811570f, -0.03673688f, 
    0.04176519f, 0.06768795f, -0.09276758f, 0.02491850f, -0.03954752f, -0.03477950f, -0.07811195f, -0.06704196f, 
    0.00070413f, -0.04398413f, -0.01496322f, 0.03213385f, -0.07967430f, -0.02504470f, -0.03294758f, -0.05560048f, 
    -0.15934934f, -0.43487510f, 0.21393244f, 0.01399094f, -0.09102570f, 0.20250788f, -0.20939498f, 0.09584093f, 
    0.10394050f, 0.08324585f, -0.17546420f, 0.13566375f, -0.03516739f, 0.20642528f, 0.13497570f, 0.16938344f, 
    0.19092610f, 0.08731423f, 0.67624688f, 0.04484654f, -0.24017294f, -0.14669605f, 0.02345180f, 0.04311604f, 
    0.00533481f, -0.14534636f, 0.04026282f, 0.18296142f, -0.18736735f, 0.60812670f, -0.21669850f, -0.09668151f, 
    0.12201922f, 0.04621359f, 0.02587793f, 0.27568421f, -0.11552103f, -0.00340581f, -0.04434491f, 0.24482782f, 
    0.09878142f, -0.04707834f, -0.01488034f, 0.09242976f, -0.03647426f, -0.04001542f, -0.12865631f, -0.01621655f, 
    0.09677719f, -0.37342885f, 0.09708838f, -0.16618533f, 0.11476319f, 0.02854787f, -0.07679251f, 0.11043922f, 
    -0.23094779f, 0.12893037f, -0.04773914f, -0.02101167f, -0.01625438f, -0.24581240f, -0.08950541f, -0.23249407f, 
    0.05059012f, 0.09222862f, 0.20278263f, 0.05966712f, 0.02252200f, 0.18331844f, -0.03838244f, -0.13137849f, 
    0.12278792f, -0.06852888f, 0.04951225f, 0.09536435f, -0.19745956f, -0.04571008f, 0.00606603f, 0.16823776f, 
    0.24165946f, -0.04883733f, 0.49941868f, -0.06270919f, 0.21489944f, -0.05488596f, 0.09521054f, 0.00544546f, 
    0.01685325f, 0.02673416f, 0.25096950f, 0.42736381f, -0.08329853f, -0.24447122f, -0.09914170f, -0.08413228f, 
    -0.03974228f, 0.23026089f, -0.01401776f, -0.20267788f, 0.09092145f, -0.76960963f, 0.20687118f, 0.05056647f, 
    -0.00126519f, 0.10730991f, 0.03268712f, 0.11848558f, 0.16697563f, -0.16458742f, 0.10159975f, -0.07571786f, 
    0.05138092f, -0.10509131f, -0.13663588f, -0.19549753f, -0.08463131f, -0.40678534f, -0.12585615f, -0.27843010f, 
    -0.02454428f, -0.19400547f, 0.12660579f, 0.05708476f, 0.20659409f, 0.19544463f, 0.05873323f, -0.00612413f, 
    -0.20242901f, -0.06064151f, 0.11186670f, 0.04579489f, -0.06821671f, -0.02699316f, 0.12161972f, -0.06443045f, 
    0.42402706f, -0.21696152f, -0.00654702f, -0.09388785f, -0.18273547f, -0.02238940f, -0.08574353f, -0.22172217f, 
    0.01799376f, 0.01032407f, -0.05604530f, -0.04447095f, -0.05749367f, -0.08922701f, 0.02947818f, 0.02845793f, 
    0.00848229f, 0.01785783f, -0.03474378f, -0.06212014f, -0.02449199f, 0.02790830f, 0.02926621f, -0.08516418f, 
    -0.04375286f, 0.04949734f, -0.07926153f, -0.03629259f, 0.05378811f, 0.06371965f, -0.01618744f, -0.06714041f, 
    0.01650353f, 0.05615277f, 0.02719117f, -0.04601964f, -0.08058374f, 0.00097049f, -0.06237985f, 0.04189742f, 
    -0.04653722f, 0.01906736f, -0.00148121f, -0.06906393f, -0.06704991f, -0.00042527f, 0.00184082f, -0.05544949f, 
    -0.01924592f, -0.02886919f, -0.03447311f, 0.04985695f, -0.01669479f, -0.06253291f, 0.05373812f, 0.01742834f, 
    0.06643178f, -0.02059431f, 0.02452504f, 0.00809063f, 0.07446479f, 0.00657764f, 0.04125443f, -0.08205500f, 
    -0.07349464f, 0.04849517f, 0.05972742f, -0.06637968f, 0.00707559f, 0.00681146f, -0.01309684f, -0.00359842f, 
    0.01914785f, -0.01858991f, 0.07108392f, 0.07721246f, -0.08288912f, -0.08514574f, -0.08710264f, 0.04947997f, 
    -0.01559898f, -0.04419563f, -0.00680295f, -0.02359481f, -0.03662583f, -0.04960306f, -0.03527789f, -0.00940016f, 
    -0.03505155f, -0.05824262f, 0.03615868f, -0.08659495f, 0.06316672f, -0.08402577f, -0.08540165f, -0.05267847f, 
    0.04245687f, 0.02969532f, -0.00750985f, -0.06958690f, -0.03957476f, 0.02228286f, 0.03773690f, -0.05950894f, 
    0.01583626f, -0.01954368f, 0.01143734f, -0.06297758f, 0.00810234f, -0.04812704f, -0.06863420f, 0.00106234f, 
    0.04539556f, -0.00063577f, 0.01505235f, -0.00118698f, 0.05527518f, 0.04324909f, -0.04280156f, -0.07038065f, 
    0.02812403f, 0.03803219f, -0.05778501f, 0.01408658f, -0.05126175f, -0.06797118f, -0.02321791f, 0.00619025f, 
    -0.06169327f, -0.02322102f, 0.00887136f, 0.07093637f, 0.01617574f, 0.04253060f, -0.06923526f, 0.03846126f, 
    0.00460578f, 0.06369373f, -0.04016294f, 0.06285518f, -0.03132620f, 0.03249004f, 0.06731483f, -0.07913965f, 
    0.01729728f, -0.00484065f, -0.05900405f, -0.01387092f, -0.05090798f, -0.08221313f, 0.05352264f, 0.02105031f, 
    0.31658897f, 0.14633487f, 0.26240197f, 0.10629581f, 0.17446867f, -0.14576904f, -0.04669176f, 0.03996675f, 
    0.08387896f, -0.40820965f, -0.18110071f, 0.51218450f, -0.04879837f, -0.04546327f, -0.00875257f, 0.03171352f, 
    -0.01583609f, -0.16507702f, -0.39589104f, -0.41336268f, -0.31623995f, -0.13198720f, 0.05112195f, 0.04199927f, 
    0.04234791f, -0.06352635f, 0.20175107f, 0.21941563f, 0.14317662f, -0.22354825f, 0.04228288f, -0.02688481f, 
    -0.03500818f, 0.25829238f, -0.02777408f, -0.01541123f, 0.16878767f, 0.04202200f, 0.00989958f, 0.15594392f, 
    -0.04853326f, 0.13256560f, -0.20893532f, 0.06570046f, -0.01093301f, -0.01458281f, -0.04177919f, 0.22835684f, 
    0.31675631f, -0.11583219f, 0.02036006f, -0.07456870f, 0.04704979f, -0.14891516f, 0.25283265f, -0.11176359f, 
    -0.19928090f, -0.00742249f, 0.00157090f, -0.15023094f, 0.12018487f, 0.05810296f, -0.02009968f, 0.22894159f, 
    0.17780113f, 0.09529406f, 0.10655382f, -0.06425782f, 0.07293648f, -0.17862530f, 0.18910997f, 0.03917769f, 
    -0.19774607f, -0.09951575f, -0.01874097f, 0.02098784f, 0.31848773f, -0.00804209f, -0.22771174f, 0.00842855f, 
    -0.18016231f, -0.51236361f, 0.10177930f, -0.09221435f, -0.01060372f, 0.08041119f, -0.11801174f, 0.15766682f, 
    0.04043246f, 0.15806556f, -0.38950190f, -0.23796213f, -0.12627284f, 0.08732984f, 0.02158522f, 0.14281511f, 
    0.00711188f, 0.06295598f, -0.04894683f, -0.32758453f, 0.27781406f, 0.22287349f, 0.16795769f, 0.13947125f, 
    0.13972203f, -0.10611999f, -0.05544008f, -0.13065058f, -0.27586874f, -0.28275168f, 0.10257243f, -0.03388361f, 
    0.01318266f, -0.09669620f, 0.03814085f, 0.10293970f, 0.08269204f, 0.04595415f, 0.04325228f, -0.30947506f, 
    0.01964606f, -0.00071240f, 0.13552465f, 0.09415089f, 0.01373618f, 0.19879942f, -0.24188425f, -0.19499090f, 
    0.00177564f, 0.13574849f, -0.02673266f, -0.05308876f, -0.19808432f, 0.19033970f, 0.21443370f, -0.44290745f, 
    -0.30434799f, -0.31496158f, 0.10081878f, -0.08657376f, -0.02987375f, -0.11668722f, -0.09911331f, 0.00260499f, 
    0.44966927f, 0.33446571f, 0.03355293f, -0.03881495f, 0.06816025f, 0.23264563f, 0.09721683f, 0.07153647f, 
    0.05866642f, 0.00754501f, -0.02810928f, 0.03349411f, -0.06469256f, -0.17000870f, 0.02049587f, 0.25871661f, 
    -0.06793063f, -0.09891772f, -0.05750332f, 0.19761384f, -0.08227862f, -0.05583740f, -0.13005406f, 0.08939803f, 
    0.29193011f, 0.07626851f, 0.19951473f, 0.57108307f, 0.07242823f, 0.07478593f, 0.12166963f, -0.08273247f, 
    -0.07454661f, 0.17018662f, 0.11084922f, -0.01412564f, -0.58566755f, -0.33879754f, 0.17753695f, -0.09018102f, 
    0.04252683f, 0.01274379f, -0.08688568f, 0.04775991f, -0.16825336f, -0.02000636f, 0.20144425f, 0.11407778f, 
    0.04929812f, -0.25968081f, -0.05137400f, -0.09787969f, -0.01150423f, 0.04449579f, -0.03849258f, -0.13234761f, 
    0.12880625f, -0.05921767f, 0.00884697f, -0.17643024f, 0.06186142f, -0.01194228f, 0.04746906f, 0.00675594f, 
    0.21346146f, 0.02040782f, -0.04906066f, -0.00956965f, -0.06054005f, -0.02962059f, 0.01144094f, 0.03883381f, 
    0.24910115f, 0.09946916f, 0.12683533f, -0.10326236f, 0.08241145f, -0.13299198f, -0.07957335f, 0.03435583f, 
    0.22171129f, 0.02282187f, -0.04249428f, 0.20854604f, -0.14064153f, 0.22101086f, -0.08437020f, -0.08404867f, 
    0.09710375f, 0.06674609f, -0.27283201f, 0.18649939f, 0.00896624f, 0.09544545f, 0.09747341f, -0.10713470f, 
    0.01514338f, -0.08850911f, 0.19534099f, -0.28339770f, -0.16785496f, -0.00013010f, -0.05241320f, -0.13483052f, 
    0.02070518f, -0.09725935f, -0.13387276f, -0.05447150f, -0.48265642f, 0.03274213f, 0.17755157f, 0.06167969f, 
    0.00894718f, -0.11144304f, -0.01823980f, -0.02410806f, 0.08555965f, -0.13702717f, 0.14236569f, 0.04063532f, 
    -0.00502388f, 0.04203466f, 0.05334724f, 0.02127531f, -0.03274104f, -0.08527438f, -0.00727116f, -0.01373912f, 
    -0.02732007f, 0.07559146f, 0.12602636f, -0.20431453f, 0.06674024f, -0.04887692f, 0.10027393f, -0.27357888f, 
    -0.02699078f, 0.03342411f, -0.31090775f, -0.08383287f, -0.06471346f, -0.06969945f, 0.03168708f, -0.07918561f, 
    -0.03373673f, -0.08572651f, 0.07095170f, -0.06666087f, 0.01519523f, 0.00774169f, -0.05006630f, 0.05274441f, 
    -0.06274436f, -0.01309559f, 0.03847788f, 0.05564152f, -0.07444760f, 0.00154157f, 0.03456070f, 0.06660048f, 
    -0.06331268f, 0.05120572f, 0.02091763f, -0.05621655f, 0.05010392f, -0.04713156f, 0.04406516f, -0.06694101f, 
    -0.01676950f, -0.06061356f, 0.00862360f, 0.01382595f, -0.04360230f, -0.02005292f, -0.01405940f, -0.06628059f, 
    -0.09847085f, -0.06104145f, -0.01014814f, -0.01959118f, -0.01189735f, -0.03577639f, 0.01479473f, -0.09000511f, 
    -0.02716783f, 0.01450640f, 0.05468376f, -0.07771870f, -0.07141845f, -0.00946936f, 0.04410936f, 0.08231662f, 
    -0.06548188f, 0.05951578f, 0.01217625f, 0.00735186f, 0.04090525f, 0.05496245f, 0.00003894f, -0.07647766f, 
    0.02858381f, -0.04792024f, 0.06534295f, -0.01713580f, 0.05087877f, -0.06290636f, -0.04503381f, 0.02355436f, 
    -0.07830664f, 0.03817793f, -0.06192604f, 0.02366478f, -0.06961519f, -0.03895265f, -0.09477487f, -0.08446866f, 
    -0.00220670f, 0.02218256f, 0.01358461f, 0.00120183f, 0.02642074f, -0.03566028f, -0.00772510f, 0.01427632f, 
    -0.07804086f, 0.00158332f, -0.01089724f, -0.03304834f, -0.01933827f, 0.03147962f, 0.05335115f, -0.04980698f, 
    -0.02027001f, -0.08198851f, 0.06661250f, -0.06160089f, -0.06267364f, -0.07382037f, -0.02428337f, -0.07261354f, 
    0.04671781f, 0.01667684f, 0.06101704f, -0.03349587f, -0.06582810f, -0.04083654f, 0.04606657f, -0.03305015f, 
    0.02541949f, 0.02065744f, -0.09683660f, -0.07396112f, 0.00603323f, -0.03706709f, 0.04042893f, -0.08102864f, 
    0.05314879f, -0.05802050f, 0.03275168f, 0.07292555f, -0.00689190f, -0.07380869f, 0.00564731f, 0.06176769f, 
    0.04651887f, 0.04656013f, -0.09561603f, 0.02577840f, 0.06024625f, 0.03733058f, 0.01458110f, 0.04624360f, 
    -0.01001498f, -0.07536544f, 0.02666296f, -0.02747741f, 0.00510898f, 0.03525921f, 0.00788724f, 0.06631178f, 
    -0.05505260f, -0.03790719f, -0.07583247f, -0.03298127f, -0.01584132f, -0.02187516f, 0.01459010f, -0.01535386f, 
    -0.03789238f, -0.06326061f, 0.04363910f, 0.04356758f, 0.01556446f, 0.02786773f, -0.00694817f, -0.05161059f, 
    -0.11273590f, -0.02883643f, -0.09515191f, -0.02023938f, -0.00906249f, 0.04176842f, 0.03286663f, -0.10843178f, 
    -0.02371659f, -0.08646761f, -0.01566519f, -0.04337463f, -0.02032584f, -0.04693544f, -0.10941178f, 0.00075618f, 
    -0.05915290f, 0.01671791f, -0.03282787f, -0.02291204f, -0.04112452f, -0.09361448f, 0.06023724f, 0.05873289f, 
    0.01767258f, 0.05726463f, -0.03845833f, -0.07330965f, -0.02579866f, -0.00427999f, -0.11760824f, -0.01030187f, 
    0.01146541f, -0.09086763f, -0.08933322f, -0.07644071f, -0.05972401f, -0.00968223f, -0.01066001f, -0.01018222f, 
    0.07683075f, 0.00919461f, -0.05304799f, -0.00859009f, 0.02475038f, -0.06270920f, 0.02620561f, -0.01368148f, 
    -0.11036326f, 0.04110022f, -0.03987065f, -0.10481524f, 0.03332183f, -0.09541452f, -0.04714800f, -0.03822856f, 
    0.03248255f, -0.09001316f, 0.04023549f, -0.10417175f, -0.05004588f, 0.02561028f, -0.10341313f, -0.01336708f, 
    0.02491203f, -0.02666182f, -0.00344272f, -0.08631296f, -0.03918573f, 0.03292309f, -0.06729224f, -0.05161493f, 
    -0.07146306f, -0.02104378f, 0.05278021f, -0.03405576f, -0.06975023f, -0.07480013f, 0.06443421f, -0.03847417f, 
    -0.07694871f, -0.09139271f, -0.05830271f, -0.08439454f, 0.03941096f, -0.02057698f, 0.05135484f, -0.05498137f, 
    0.01118270f, -0.08654921f, -0.07804640f, 0.02186177f, 0.01181089f, -0.00860333f, -0.02314198f, -0.08258561f, 
    -0.09805661f, -0.08827058f, -0.00731456f, -0.04749014f, -0.00041568f, -0.07895727f, -0.05992438f, -0.00578732f, 
    -0.00816992f, 0.07506453f, 0.03600761f, -0.05664359f, -0.06380213f, -0.00046012f, -0.01825216f, -0.00397470f, 
    0.05504683f, 0.01959659f, -0.10420819f, -0.02431607f, -0.07420367f, -0.01061831f, 0.07417615f, 0.05961690f, 
    -0.06160882f, 0.05100781f, 0.00147769f, 0.04367318f, 0.05443761f, -0.10244460f, 0.03508066f, -0.02439227f, 
    -0.06474490f, 0.03209563f, -0.08253914f, 0.03752280f, 0.00591027f, 0.01653465f, 0.04696988f, -0.01525091f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.07358698f, 0.29043975f, 0.07118025f, 0.32151264f, 0.19849017f, -0.03579415f, 0.09552618f, 0.11654276f, 
    -0.02607836f, -0.07868451f, 0.23728850f, -0.07274205f, 0.18908477f, -0.12843339f, -0.09007000f, 0.02800030f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.42394209f, 0.24663156f, -0.21423207f, 0.27172285f, -0.41822955f, -0.02807462f, 0.35948315f, -0.20758547f, 
    -0.05398205f, -0.14646304f, -0.11984126f, -0.11351886f, -0.05097315f, 0.36557043f, -0.18659090f, 0.03839199f, 
    -0.38724437f, 0.22578320f, 0.04505293f, 0.24481466f, 0.35284051f, 0.43151984f, 0.29745346f, -0.54923153f, 
    -0.34266716f, -0.03872826f, 0.44061282f, -0.19723815f, 0.18677117f, 0.08198776f, 0.10854596f, -0.23755947f, 
    0.37057829f, 0.24879523f, 0.09969017f, -0.26470095f, 0.13320524f, -0.75832117f, 0.37349218f, 0.46031669f, 
    0.36410564f, -0.16769834f, -0.29460913f, 0.18710029f, 0.25178131f, 0.00326876f, 0.02981625f, 0.17814311f, 
    -0.10767764f, -0.12429754f, 0.21882227f, -0.17706810f, -0.16035198f, 0.12531385f, -0.01425443f, -0.17472661f, 
    -0.08898529f, 0.12948115f, -0.05883742f, -0.18017372f, -0.11625630f, 0.18200380f, 0.19795559f, -0.14572045f, 
    -0.17191502f, -0.21650574f, 0.18135072f, -0.09400012f, 0.03706523f, -0.20969453f, -0.07902786f, -0.12003382f, 
    0.07126817f, 0.04455584f, -0.29353490f, 0.21164042f, -0.09362906f, 0.08863448f, -0.07878222f, -0.15237555f, 
    -0.16737811f, -0.23700057f, 0.24100591f, 0.21780176f, -0.00838268f, 0.31281623f, -0.24442154f, 0.26853997f, 
    0.50434285f, -0.11759067f, -0.15744965f, 0.22060220f, 0.56085211f, 0.85497612f, 0.10985705f, -0.03856679f, 
    0.30676085f, -0.08145265f, -0.10503846f, 0.32950082f, -0.15865916f, -0.29512435f, 0.12208367f, -0.43325034f, 
    0.10498495f, 0.06725473f, 0.50163901f, -0.08691257f, -0.26399425f, 0.18305299f, -0.08207529f, 0.11205152f, 
    -0.26118684f, -0.14774683f, 0.20206715f, -0.26798740f, -0.08784228f, 0.15731765f, 0.17217985f, -0.13522714f, 
    -0.03985086f, -0.04587815f, 0.00660191f, 0.10942668f, -0.05627071f, -0.14776224f, -0.17630692f, 0.21030454f, 
    -0.30459571f, 0.36657742f, -0.23002815f, -0.28344393f, 0.47337502f, -0.18365698f, -0.19994678f, 0.43642062f, 
    0.23376523f, 0.07413953f, 0.21289206f, 0.08073777f, -0.16125171f, -0.72329217f, 0.15044604f, 0.02056475f, 
    -0.31919953f, 0.43589866f, -0.13491221f, -0.55252010f, 0.00027219f, 0.02732641f, -0.15017454f, 0.20151322f, 
    0.60397357f, -0.10999922f, -0.00841414f, -0.06695104f, 0.34486589f, 0.12050685f, 0.23065905f, 0.07122431f, 
    -0.13030206f, -0.07742613f, 0.18849148f, 0.41789761f, 0.15176645f, 0.71486789f, -0.33717152f, -0.33674422f, 
    0.46459946f, -0.17509241f, 0.38674259f, -0.07504053f, -0.22870101f, 0.41070771f, 0.12804228f, 0.01845667f, 
    0.36930093f, 0.11330147f, -0.01248503f, -0.28706551f, 0.14558356f, 0.06626174f, 0.06932317f, 0.23503865f, 
    -0.26956812f, 0.23923238f, 0.10441819f, -0.23812783f, 0.01104107f, -0.39392495f, -0.00711839f, 0.21327221f, 
    0.25444418f, -0.04105196f, 0.23816493f, -0.24016266f, 0.06038665f, 0.45347005f, 0.50202191f, 0.15105754f, 
    -0.39825678f, -0.08279531f, 0.42233989f, 0.24873602f, -0.64392078f, -0.26404262f, -0.24769968f, 0.04955669f, 
    0.18158130f, 0.27469838f, 0.25211889f, 0.32638729f, 0.41408873f, -0.19491215f, -0.27064973f, 0.23937261f, 
    0.28153405f, 0.10418981f, -0.25017452f, -0.14191151f, 0.76538515f, -0.04199361f, -0.12848961f, 0.06239707f, 
    0.00110480f, -0.02382589f, -0.16815883f, -0.22962740f, -0.46552956f, -0.39169487f, 0.18129969f, 0.34388232f, 
    -0.42588168f, -0.17084917f, 0.12392737f, -0.13596393f, 0.56267029f, -0.03247821f, 0.19039205f, 0.18966989f, 
    0.43854237f, -0.02069319f, 0.22743073f, -0.33539650f, -0.05538142f, -0.06039658f, -0.29627100f, 0.23418212f, 
    -0.51271790f, -0.23325743f, -0.02689054f, 0.08271813f, 0.58885646f, -0.25264207f, 0.01402361f, 0.20856217f, 
    0.41522437f, -0.04049776f, -0.06792341f, 0.05312772f, -0.29024431f, 0.11303142f, 0.45704126f, -0.43084952f, 
    -0.11293613f, -0.16743575f, 0.36465114f, 0.18940015f, 0.38510329f, 0.27372152f, 0.16430834f, 0.17084509f, 
    -0.27851257f, 0.39101619f, 0.00241945f, 0.42482969f, 0.09114549f, 0.09900296f, 0.40958497f, -0.04569503f, 
    -0.45402223f, -0.07377445f, -0.21827884f, -0.20312612f, 0.05759551f, 0.12741520f, -0.07996362f, 0.05979292f, 
    0.34500775f, 0.50966913f, -0.24309200f, 0.05595974f, -0.00326993f, 0.31808910f, -0.35134840f, -0.08844928f, 
    -0.30290782f, -0.10948381f, -0.01757064f, 0.03843680f, -0.34726477f, -0.39288536f, -0.22732583f, 0.18222827f, 
    -0.01252912f, -0.08544506f, -0.21863683f, 0.28700104f, 0.49180591f, -0.37581289f, -0.35528970f, 0.38367900f, 
    0.51106298f, -0.08742251f, 0.10855246f, -0.11955375f, 0.28691629f, 0.17583507f, -0.01477198f, -0.03903943f, 
    -0.25417021f, 0.12438887f, 0.11630774f, -0.56275254f, -0.15307888f, -0.09690494f, -0.05608106f, 0.39978492f, 
    -0.05907165f, -0.22827788f, 0.60576904f, -0.23848133f, 0.21623187f, -0.35027814f, 0.20870607f, 0.05351396f, 
    -0.28094357f, -0.18680893f, 0.19895595f, 0.42937961f, 0.30699182f, 0.28871545f, 0.76556557f, -0.05888645f, 
    0.00849131f, 0.09428932f, -0.10997032f, 0.08137362f, -0.11144509f, -0.37122601f, 0.22078741f, -0.05651693f, 
    -0.03133222f, 0.22615284f, -0.22302681f, -0.29638407f, 0.00007057f, -0.12161988f, -0.31634495f, 0.33673429f, 
    0.37447110f, -0.17812611f, 0.21661474f, 0.09916079f, -0.06630008f, -0.27927056f, 0.16102505f, 0.20339207f, 
    0.34792119f, -0.12273393f, 0.06281130f, -0.30790824f, -0.49693361f, 0.46082872f, 0.23686245f, 0.24566877f, 
    0.13915718f, 0.23135802f, 0.24845085f, -0.19741820f, -0.30925933f, -0.02375706f, 0.23081535f, -0.08157444f, 
    0.06107257f, -0.16701579f, -0.15902340f, -0.00294027f, -0.11912713f, -0.00711148f, -0.16750808f, 0.17185785f, 
    -0.19548392f, -0.07921015f, -0.01539472f, -0.06963313f, 0.10634145f, -0.23729861f, -0.02395585f, 0.18652225f, 
    -0.15679742f, 0.08467636f, 0.16684358f, 0.42459553f, 0.27146035f, -0.71204102f, -0.06647059f, 0.31657568f, 
    0.56028390f, 0.16270919f, 0.03556907f, 0.20452824f, -0.36709544f, 0.28409395f, 0.07962126f, 0.13502246f, 
    0.29743579f, 0.28705174f, 0.02159637f, 0.07557217f, 0.35979304f, -0.22973180f, -0.25308535f, 0.38599125f, 
    -0.12578490f, 0.06347886f, -0.13962688f, 0.19497485f, -0.35910663f, -0.27889261f, 0.08999266f, 0.02956654f, 
    -0.08788918f, -0.01454683f, -0.20264620f, -0.03951839f, 0.47916707f, -0.09106655f, -0.22517133f, 0.36469635f, 
    0.26725647f, -0.17201784f, 0.42177781f, -0.18490043f, -0.29877907f, 0.13796422f, 0.09765176f, -0.08870020f, 
    0.53051013f, -0.02895278f, 0.02096299f, 0.17222881f, -0.02058076f, -0.06681742f, 0.52712494f, -0.26658499f, 
    0.19875117f, -0.19732976f, -0.01500488f, 0.13546830f, 0.07918642f, -0.39560011f, 0.10357470f, 0.21696573f, 
    0.11967459f, -0.06238968f, -0.13718775f, -0.45185184f, -0.02144465f, 0.53604198f, -0.57951462f, -0.10502876f, 
    0.58897322f, -0.05810544f, 0.12559009f, 0.20884576f, 0.10442637f, 0.20041078f, 0.18385054f, -0.14865331f, 
    -0.34285519f, 0.30311832f, 0.00067553f, 0.35326642f, -0.20979092f, 0.66569352f, 0.23158300f, -0.07549871f, 
    -0.24236891f, 0.04561714f, 0.12119846f, 0.22181329f, -0.38018098f, 0.14682941f, -0.04117069f, 0.14015290f, 
    -0.21495666f, 0.39895692f, 0.01537443f, 0.23683092f, 0.11855505f, 0.16523802f, 0.05433584f, -0.28436059f, 
    0.27011248f, -0.15059406f, -0.35209978f, 0.05488057f, -0.17784017f, -0.09034982f, 0.15918861f, 0.17023112f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12012216f, 0.57724315f, -0.18423218f, 0.05085104f, 0.07044853f, -0.15934023f, 0.37432641f, 0.01583226f, 
    0.24586393f, 0.24229114f, 0.07470017f, 0.32690975f, 0.02209401f, -0.19124384f, 0.46789002f, 0.22429857f, 
    0.24340026f, 0.69366276f, 0.08696118f, -0.08898413f, 0.44875273f, -0.08631366f, 0.13421273f, -0.22488597f, 
    -0.26102155f, 0.14086960f, -0.15426634f, -0.06657434f, 0.49875137f, -0.58156806f, 0.38001028f, 0.33188128f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05569390f, -0.16299924f, 0.51976824f, -0.00987544f, 0.05210391f, -0.52280682f, 0.04518502f, -0.17580046f, 
    0.52445960f, 0.60792637f, -0.22379199f, 0.20200437f, -0.18304592f, 0.30475995f, -0.62089181f, -0.04727791f, 
    -0.28570133f, 0.17613709f, 0.20628037f, 0.21822590f, 0.06580324f, -0.11093838f, 0.52617508f, -0.57059610f, 
    -0.08259934f, 0.23277004f, 0.31323281f, 0.08289877f, 0.25478846f, -0.29082879f, -0.16024677f, 0.48789239f, 
    0.26557744f, -0.75134128f, 0.33389297f, 0.05873299f, -0.05517762f, 0.24222404f, 0.40300861f, -0.16318311f, 
    -0.44442457f, 0.37640294f, 0.13273972f, -0.71454179f, -0.25068215f, -0.00924643f, -0.16163616f, -0.28760150f, 
    0.00758847f, -0.65455210f, -0.23316471f, 0.09785593f, -0.11860599f, -0.08737735f, 0.32161000f, 0.91482121f, 
    -0.12153617f, 0.15957196f, -0.01387321f, -0.07759117f, -0.48050117f, 1.00667751f, -0.22464158f, -0.14312318f, 
    0.70828342f, 0.35337213f, -0.00008387f, -0.05940413f, 0.08816490f, 0.06625475f, 0.66036624f, 0.01646024f, 
    -0.42660695f, -0.25721234f, 0.23610529f, 0.33802888f, 0.20844176f, -0.00387789f, -0.16126683f, 0.21326298f, 
    0.45746559f, 0.34332830f, 0.77103364f, -0.21452366f, -0.16757961f, 0.67084199f, -0.10071261f, 0.23275036f, 
    -0.01038207f, -0.18289757f, 0.31430817f, -0.12946634f, -0.03845548f, 0.16776901f, 0.29400238f, 0.12265403f, 
    0.34396499f, -0.06164679f, -0.05354016f, -0.11496421f, -0.15930681f, -0.36687124f, 0.50327164f, 0.18165079f, 
    -0.56168085f, -0.55322927f, 0.11830869f, 0.09661244f, 0.40154621f, -0.15730745f, 0.55476427f, -0.01634157f, 
    0.35021982f, -0.06897457f, 0.15710300f, 0.05244434f, -0.26727501f, 0.24021284f, -0.27091992f, 0.75434047f, 
    -0.04765482f, 0.12808135f, 0.18085630f, -0.07402325f, 0.69395626f, 0.45808962f, 0.10805987f, -0.13966776f, 
    0.12118740f, 0.07575347f, 0.01529557f, 0.02729249f, -0.00726932f, -0.05886628f, -0.22849800f, -0.02865107f, 
    -0.06429402f, -0.11084776f, -0.03802188f, 0.02979668f, -0.01375834f, -0.10426279f, -0.08334156f, -0.01569345f, 
    -0.12885433f, -0.09549060f, -0.19169565f, 0.11736477f, 0.11020983f, 0.14076859f, -0.16809040f, 0.05884513f, 
    -0.15940940f, -0.11295471f, 0.02784556f, 0.12517728f, -0.12244209f, -0.19260038f, -0.02841805f, 0.10088442f, 
    -0.16068865f, 0.56526709f, -0.18225875f, -0.11149096f, -0.07427688f, 0.37461507f, 0.08031827f, 0.00171488f, 
    0.12320743f, 0.16671447f, 0.45363361f, -0.21678303f, 0.13690816f, -0.16406383f, 0.43347710f, -0.19151838f, 
    0.12751022f, 0.24144818f, 0.04035233f, -0.22438547f, 0.36186212f, -0.00561840f, -0.24614824f, -0.21361595f, 
    0.15570810f, -0.22686559f, -0.19095990f, 0.14097041f, -0.18187027f, -0.11299283f, 0.43028155f, -0.00940573f, 
    0.03989241f, 0.25675476f, 0.05286878f, -0.06571958f, -0.14463066f, -0.16879073f, -0.06845492f, -0.10753731f, 
    0.06949492f, 0.05992891f, 0.20396809f, 0.47805682f, -0.16698663f, 0.22863716f, 0.36747822f, 0.69606119f, 
    0.40081733f, -0.16102883f, 0.18769634f, -0.17847748f, -0.18643159f, 0.53676116f, -0.02066953f, 0.11580148f, 
    -0.07632647f, -0.33531412f, -0.18369669f, -0.38179582f, 0.63163233f, -0.06221022f, -0.16140194f, -0.02072056f, 
    0.05167950f, 0.36825666f, 0.01529741f, 0.02202697f, 0.10911719f, 0.81037205f, 0.29280934f, -0.10723159f, 
    -0.41470557f, -0.13249429f, 0.07009953f, -0.27014127f, 0.07113929f, 0.25637376f, 0.70059431f, 0.41552842f, 
    0.34405813f, 0.32782796f, -0.42397332f, 0.37887859f, -0.03515209f, 0.49731028f, -0.40586978f, -0.08185416f, 
    0.13333882f, 0.00287655f, -0.25257689f, -0.20062289f, 0.26634702f, 0.22184171f, -0.06166559f, -0.05537370f, 
    -0.35361314f, 0.28226063f, -0.34208369f, 0.15470675f, 0.12390764f, -0.05577958f, -0.00322810f, 0.11332910f, 
    0.11364217f, 0.18360855f, 0.18857011f, -0.14517193f, -0.16484518f, -0.01080375f, -0.06777792f, -0.18431589f, 
    0.11399201f, -0.18425158f, 0.10541695f, -0.06155543f, 0.32945767f, -0.40695766f, -0.00544600f, -0.27346727f, 
    -0.17045888f, -0.38343608f, -0.26182362f, 0.25488967f, -0.00297712f, 0.49869931f, 0.05232969f, -0.15676329f, 
    -0.13962135f, 0.14669099f, -0.10318289f, 0.03734313f, -0.02655699f, -0.19324748f, -0.19593926f, 0.18027936f, 
    0.70260906f, 0.38988182f, -0.01929829f, 0.41531929f, 0.32258171f, -0.18771806f, 0.18074687f, -0.05248591f, 
    0.08514013f, 0.20687003f, 0.35901898f, -0.59372956f, 0.98340237f, -0.11376389f, 0.55727273f, 0.42551506f, 
    -0.01962849f, -0.41382992f, 0.03183098f, -0.12050603f, -0.10726489f, -0.69922000f, 0.34703809f, 0.02288019f, 
    -0.12636536f, -0.05455894f, -0.16013712f, -0.14994189f, -0.10868067f, 0.31701556f, -0.45826066f, 0.08967166f, 
    -0.00258893f, 0.14775270f, 0.22060885f, 0.04635630f, -0.84302312f, 0.39145470f, -0.48550901f, -0.11167159f, 
    -0.12473042f, -0.04149094f, 0.29658103f, 0.26413065f, -0.02583864f, -0.12981111f, 0.36878890f, -0.54214138f, 
    0.14920592f, -0.21513550f, 0.25645563f, -0.08901068f, -0.34843230f, 0.61485749f, 0.03082866f, 0.18383621f, 
    0.12302863f, -0.29432377f, 0.15719624f, 0.07546748f, 0.04529319f, 0.12597311f, -0.28173104f, 0.08501623f, 
    -0.27530944f, 0.20521159f, 0.10230938f, -0.09310488f, -0.53683406f, -0.06640047f, 0.04796072f, 0.25533375f, 
    -0.08549871f, -0.23145837f, -0.20528327f, 0.14405659f, -0.15651616f, -0.18384992f, 0.14793393f, -0.01696404f, 
    -0.06430051f, -0.03520020f, -0.34046468f, -0.20013091f, -0.04990279f, 0.35555285f, -0.23612751f, -0.13009103f, 
    -0.18041730f, 0.08615024f, -0.13961068f, 0.00314264f, -0.08053859f, -0.03765523f, 0.05231450f, -0.11795416f, 
    0.05947351f, 0.06689597f, -0.12186343f, -0.11748769f, -0.01740326f, -0.15527192f, 0.16138814f, -0.03596193f, 
    -0.15700063f, 0.13739094f, -0.21630722f, 0.08383852f, -0.14394218f, -0.15907885f, -0.02215158f, 0.15033899f, 
    0.04670632f, -0.03387983f, -0.15842108f, -0.12951763f, -0.17713293f, -0.11127119f, -0.08926553f, 0.09296349f, 
    -0.48631215f, 0.08910758f, 0.19275536f, -0.03899915f, -0.18004981f, -0.30281124f, -0.31927010f, 0.07969199f, 
    0.64308918f, 0.20235536f, 0.19963492f, 0.02354173f, -0.24404426f, 0.31537718f, -0.08199127f, -0.39544612f, 
    -0.16769394f, -0.08190284f, 0.12970544f, 0.55907780f, 0.45416611f, -0.60367900f, 0.24811079f, -0.69635218f, 
    0.08295429f, 0.31112257f, 0.12750636f, 0.45410118f, -0.27862537f, -0.29200959f, 0.01129068f, 0.29318756f, 
    0.02441544f, 0.33842888f, 0.03547040f, 0.10225624f, 0.10453196f, 0.41213527f, 0.00756798f, 0.12217120f, 
    0.56754643f, 0.24112478f, 0.15735474f, -0.28187659f, -0.05358622f, 0.03643174f, -0.18952721f, -0.22859171f, 
    -0.08899626f, 0.47712928f, -0.06201977f, 0.13928056f, -0.14900652f, 0.01685953f, 0.07014449f, -0.73460621f, 
    0.00747509f, 0.43963185f, 0.04230563f, 0.18407652f, -0.01927081f, -0.76596451f, 0.29659170f, 0.50772601f, 
    -0.08900470f, 0.12914197f, -0.20218833f, 0.02343113f, 0.08164588f, -0.04962095f, 0.31095055f, -0.13772933f, 
    0.26357597f, -0.17946982f, -0.10010949f, 0.44518474f, 0.45769411f, -0.33236885f, 0.27624840f, -0.38243940f, 
    0.16584827f, -0.07163396f, 0.11183345f, 0.08527617f, 0.78952342f, -0.26659155f, 0.30376744f, 0.46916509f, 
    0.20110407f, 0.03062989f, 0.25913659f, 0.44099027f, -0.07801475f, 0.07387962f, -0.10425836f, -0.51278633f, 
    -0.06879144f, -0.18726631f, 0.30818304f, -0.12474749f, -0.13108411f, 0.06049793f, 0.02497647f, 0.07124563f, 
    0.17893144f, 0.17767107f, 0.01872922f, 0.14209221f, 0.13838275f, 0.26135144f, 0.54585135f, 0.29166582f, 
    0.26127028f, -0.26732007f, -0.17699911f, 0.38029906f, 0.56756580f, -0.90788352f, 0.46330413f, 0.69280195f, 
    -0.17896377f, -0.04983306f, -0.19495074f, 0.29554066f, 0.25708535f, -0.16903773f, -0.15363768f, -0.27468330f, 
    -0.21407261f, -0.12949058f, -0.11070882f, 0.18066081f, -0.03872228f, -0.05854789f, 0.00780679f, -0.14979105f, 
    -0.24077953f, -0.14299123f, -0.06658503f, 0.02380495f, -0.12628277f, 0.03474551f, -0.22048283f, -0.15569282f, 
    -0.08350322f, 0.13342810f, 0.09211583f, -0.15293579f, 0.04677192f, 0.14175774f, -0.01654220f, -0.05903018f, 
    0.09011856f, -0.09051410f, -0.13437960f, 0.05992730f, -0.04499732f, 0.04240778f, 0.08631993f, 0.08903507f, 
    0.12733492f, 0.46728855f, -0.49198243f, 0.04020371f, -0.07948732f, -0.25184715f, 0.25817370f, -0.15953673f, 
    0.34999800f, -0.01897581f, 0.60735327f, -0.00410953f, -0.04006336f, -0.20185503f, -0.53679407f, -0.34094685f, 
    0.08598004f, 0.21806464f, 0.28077120f, -0.12013048f, -0.21669754f, 0.66750866f, 0.15212505f, -0.31495562f, 
    0.10123149f, 0.11536920f, 0.11516129f, 0.38435438f, 0.15627412f, 0.05872713f, 0.45876089f, 0.27878281f, 
    0.18340161f, 0.09027035f, 0.54825819f, -0.10585620f, -0.16280203f, -0.51674068f, -0.09345669f, -0.02947518f, 
    -0.03070211f, 0.31330508f, -0.58434707f, 0.47610083f, 0.16032732f, 0.31080583f, 0.48751104f, 0.82577175f, 
    0.27886122f, 0.36832190f, 0.08077165f, -0.17636384f, 0.30082247f, 0.51647633f, 0.18639840f, 0.02041773f, 
    0.07177843f, -0.28386331f, 0.03641158f, -0.40945944f, 0.16849917f, -0.72065568f, -0.14800322f, 0.22210640f, 
    0.16481847f, 0.45917523f, -0.26425716f, 0.12872145f, 0.09772740f, 0.58693302f, 0.20061824f, 0.03658457f, 
    -0.27063838f, 0.15134810f, 0.21686286f, -0.40954396f, 0.06434273f, -0.06665896f, -0.10339951f, -0.42367125f, 
    0.26942125f, 0.19075024f, -0.07985099f, -0.36728531f, -0.11999326f, 0.42733723f, -0.11868732f, -0.25236607f, 
    0.12236208f, 0.08422018f, -0.41184595f, -0.29436633f, -0.18119770f, 0.63322699f, 0.48522142f, 0.39607406f, 
    0.01080530f, -0.18646409f, -0.16966167f, 0.10585807f, -0.00866638f, -0.08704533f, -0.02533884f, 0.09359991f, 
    0.10466696f, 0.12868512f, 0.12166982f, -0.11319473f, -0.06163158f, -0.17370586f, -0.05844537f, -0.11236813f, 
    0.01430428f, 0.11936751f, -0.06420151f, -0.08578589f, -0.14910907f, -0.17488065f, -0.00481764f, 0.14042751f, 
    -0.12959334f, -0.09233331f, 0.12516217f, 0.08623677f, 0.10095660f, -0.01152931f, -0.10415456f, -0.13706832f, 
    0.01458279f, -0.19217515f, -0.10547053f, 0.09688704f, 0.04368147f, -0.14265908f, -0.19857208f, 0.12822789f, 
    0.07687743f, 0.07984920f, 0.07153503f, -0.05327800f, -0.07762781f, -0.14868920f, 0.12210053f, -0.07756849f, 
    0.06728731f, 0.03888431f, 0.09396756f, 0.12990798f, -0.18445036f, -0.01062187f, 0.07762818f, 0.01048707f, 
    0.15976466f, 0.03968066f, -0.08377155f, -0.15056059f, 0.12543394f, 0.08197618f, 0.05330716f, -0.11228929f, 
    -0.22137502f, 0.11159042f, 0.33944336f, -0.15356314f, -0.06508321f, -0.08194003f, 0.12134124f, 0.04452972f, 
    0.00919627f, -0.66180450f, -0.03480307f, 0.35674742f, 0.28172833f, -0.09335463f, -0.29483667f, 0.23445927f, 
    -0.06059914f, -0.18640649f, 0.06631008f, 0.18613435f, -0.09718663f, 0.49666008f, -0.07031551f, 0.19548161f, 
    0.08761253f, 0.16561934f, 0.33562440f, 0.39763135f, 0.08507753f, -0.33602530f, -0.31542107f, -0.37886080f, 
    -0.22293425f, 0.18343811f, -0.14890197f, -0.06601019f, -0.12068186f, 0.18036696f, 0.45527098f, -0.14140986f, 
    0.04313683f, 0.33934140f, 0.37652627f, 0.03017964f, 0.08178784f, -0.17188866f, 0.22309236f, -0.54942667f, 
    0.19073056f, -0.30053666f, -0.30805480f, 0.06325344f, 0.54900992f, -0.87648582f, 0.31766155f, 0.61338103f, 
    0.00296367f, 0.02445634f, -0.65833819f, 0.46617025f, -0.29178703f, 0.24342091f, 0.00922206f, -0.25601119f, 
    0.03637112f, -0.08917756f, -0.09299749f, -0.07396051f, 0.01696564f, -0.09725848f, 0.08279959f, -0.07203563f, 
    0.00269834f, 0.05811091f, -0.16527514f, -0.04928869f, 0.06735859f, 0.03037480f, -0.09691276f, 0.09566595f, 
    -0.20695294f, -0.04721071f, -0.07603025f, -0.00156253f, -0.07120764f, 0.06257743f, 0.10021596f, -0.12228536f, 
    -0.03576217f, -0.18615702f, 0.05096667f, 0.07591116f, -0.18418317f, 0.10441025f, -0.15370235f, 0.14735961f, 
    0.10049766f, 0.07358956f, -0.14709148f, 0.14067023f, 0.13773261f, -0.15710752f, -0.00249137f, -0.08325198f, 
    -0.11540649f, 0.00064089f, -0.12505789f, -0.01019057f, -0.09496570f, -0.10180037f, 0.10429276f, -0.15720943f, 
    -0.09710529f, -0.06842924f, -0.14522935f, -0.09560414f, 0.09293146f, -0.12708323f, 0.07619508f, -0.03304503f, 
    -0.15236856f, -0.04681603f, -0.08224994f, 0.01236881f, -0.16994357f, 0.04457925f, -0.00921963f, 0.09390707f, 
    -0.22163248f, 0.10533875f, 0.22640963f, 0.13604741f, -0.11197091f, 0.48407802f, -0.04899558f, 0.03294561f, 
    0.06855283f, 0.13342303f, 0.26779336f, -0.08312792f, -0.10495920f, 0.36181203f, 0.21071465f, -0.08814710f, 
    -0.06978104f, -0.04393306f, -0.40551350f, 0.77364409f, 0.15404402f, -0.43597001f, 0.29074824f, -0.11374073f, 
    0.09693572f, 0.31800106f, 0.13958442f, 0.47257993f, -0.55869883f, 0.24082538f, -0.19129822f, -0.16181526f, 
    0.07575735f, -0.17563026f, -0.10255130f, -0.09660679f, -0.11103302f, -0.14714700f, -0.00471240f, 0.15022305f, 
    -0.03397202f, -0.13339224f, -0.09335053f, -0.08758398f, 0.10345219f, 0.07538588f, -0.02642601f, -0.06603663f, 
    0.01518768f, -0.08937369f, -0.10543339f, 0.01134196f, 0.11630736f, -0.06435407f, 0.02503293f, 0.05144578f, 
    0.03445473f, -0.08956737f, -0.06484422f, -0.01709106f, -0.02624294f, 0.04188101f, 0.09212372f, -0.09277917f, 
    0.05143417f, 0.11662973f, -0.00297794f, 0.10809701f, 0.02536136f, -0.22305860f, -0.11014227f, 0.07039960f, 
    0.01817903f, -0.07205746f, -0.07961112f, -0.05159800f, -0.05427854f, -0.11196069f, 0.04491255f, -0.14864908f, 
    0.06595659f, 0.03991836f, -0.06975741f, 0.00022332f, -0.02681624f, -0.13120794f, -0.02129208f, 0.07007642f, 
    0.14114483f, -0.22526802f, -0.15589266f, -0.00432536f, -0.12846032f, 0.12476829f, 0.01984879f, -0.08428773f, 
    0.38890272f, -0.24210605f, 0.21428162f, 0.07127313f, -0.02216091f, 0.03685595f, 0.32697406f, -0.09682145f, 
    -0.66976279f, -0.27839988f, 0.15694575f, 0.01344618f, -0.10835613f, -0.03525193f, 0.34236160f, -0.10045759f, 
    0.31511989f, -0.14180790f, -0.16154064f, 0.08117080f, -0.31334758f, 0.02394900f, -0.03737299f, 0.50809705f, 
    -0.11722600f, 0.06326441f, -0.19228935f, -0.20104711f, 0.14120758f, 0.12485967f, -0.22007380f, -0.22042322f, 
    -0.04467960f, 0.04299031f, -0.12070434f, -0.11346210f, 0.03819808f, 0.11792286f, -0.02766631f, -0.04499901f, 
    -0.09531035f, 0.02145445f, -0.01480291f, 0.06096923f, -0.07082544f, -0.12225891f, -0.06511681f, 0.07099443f, 
    -0.12947199f, 0.01797430f, -0.13001537f, 0.03188414f, -0.06551143f, -0.06337988f, -0.10149542f, -0.16509448f, 
    -0.01523092f, -0.15130553f, -0.15819821f, -0.04466188f, -0.14206001f, -0.05241648f, -0.10764445f, 0.14666323f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00595541f, -0.66323912f, 0.25509676f, 0.04839406f, -0.16750923f, 0.40145791f, 0.36685982f, 0.08095887f, 
    -0.17579210f, 0.18535472f, -0.18077941f, -0.23250799f, -0.01695111f, -0.06170816f, 0.64726210f, 0.02325506f, 
    0.14367890f, -0.02574988f, 0.27139607f, 0.30455214f, 0.09274648f, 0.04507196f, -0.09897130f, -0.30586126f, 
    0.35553399f, -0.14412957f, -0.05492296f, -0.00845004f, -0.16903090f, -0.10919945f, -0.09365062f, 0.06250627f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.25238726f, -0.76393372f, 0.10764308f, -0.03471024f, 0.08855105f, 0.18233126f, -0.04361918f, 0.34398243f, 
    -0.52856719f, -0.61415255f, -0.82801569f, -0.45804673f, -0.13985068f, -0.25247717f, 0.26906991f, -0.44628552f, 
    -0.02836064f, 0.02062656f, 0.02296788f, -0.60547316f, 0.16590406f, 0.07796390f, 0.09553207f, 0.01442985f, 
    0.31528631f, 0.05502208f, -0.11390948f, 0.36493835f, -0.04430087f, 0.03845673f, -0.17973265f, 0.08071699f, 
    -0.52255762f, 0.69341576f, 0.26831871f, 0.50210303f, 0.08178234f, -0.05857940f, 0.19914818f, 0.36036396f, 
    -0.05874925f, -0.44132107f, -0.21101625f, 0.38246110f, 0.01383736f, -0.01658644f, -0.23954746f, -0.44919047f, 
    -0.27975470f, -0.22371468f, 0.25689197f, 0.09920733f, 0.12418790f, -0.09774365f, -0.12632781f, -0.62015003f, 
    -0.90414011f, -0.02252736f, -0.04791342f, 0.02251258f, -0.01930319f, -0.12797040f, 0.24983695f, -0.11142809f, 
    -0.09443303f, -0.56613314f, 0.18211000f, -0.00165153f, -0.04000657f, 0.09009701f, 0.00664397f, -0.56663984f, 
    -0.30413231f, 0.33006671f, -0.29829538f, -0.48297548f, -0.00971397f, -0.20259316f, -0.19298306f, 0.10170030f, 
    0.14653769f, 0.07919136f, 0.02325155f, 0.25174430f, -0.08592696f, -0.18305944f, -0.13757281f, -0.69608605f, 
    0.24842376f, -0.09062896f, -0.10601401f, -0.65588129f, -0.03825136f, -0.03066224f, 0.38991293f, 0.07830273f, 
    0.28178552f, -0.51961571f, -1.02160394f, -0.10051659f, -0.01448707f, -0.40730295f, -0.32245383f, -0.21178763f, 
    0.09057707f, -0.11267195f, 0.24744108f, -0.60999304f, 0.14117728f, 0.47007090f, 0.13418701f, -0.29340631f, 
    0.31102881f, -0.06090460f, -0.70984274f, 0.06039046f, -0.34748951f, 0.12684287f, -0.09890089f, 0.50846493f, 
    0.09973900f, 0.12601943f, 0.04157748f, 0.26263890f, 0.09468715f, 0.09423574f, -0.00375169f, 0.09813958f, 
    -0.09917672f, -0.71877092f, 0.00926938f, -0.05805396f, 0.04409048f, 0.20272234f, 0.04510505f, -0.11710790f, 
    0.41428387f, -0.10976052f, 0.34328908f, -0.68621576f, -0.14857635f, 0.03669821f, 0.01639250f, 0.05927417f, 
    -0.02419848f, -0.07432277f, 0.24656628f, -0.43890932f, 0.18055677f, 0.14538291f, -0.05088626f, 0.40722767f, 
    0.15903293f, -0.10809233f, 0.17195532f, 0.00779098f, -0.08586302f, -0.21815132f, 0.54064208f, -0.13993141f, 
    -0.16876696f, 0.63505697f, 0.28143072f, -0.01300973f, -0.13651833f, 0.06037234f, -0.07279980f, 0.31626093f, 
    -0.52230299f, -0.23761359f, 0.47272646f, 0.23602989f, 0.15438144f, -0.80703682f, 0.31493273f, 0.33382496f, 
    -0.68050218f, 0.04839163f, -0.05946857f, -0.06854819f, 0.38441864f, 0.13004752f, -0.00026558f, 0.60495812f, 
    -0.97798222f, 0.15652435f, 0.07300907f, -0.08936404f, -0.11095814f, -0.19576937f, -0.43809935f, -0.14125428f, 
    0.18106143f, -0.35623345f, 0.16183321f, -0.58187526f, 0.11164980f, 0.17393799f, 0.28197375f, -0.18006006f, 
    -0.31770307f, 0.16356564f, -0.82327968f, -0.47614944f, -0.01580766f, -0.41330528f, 0.26149437f, -0.51287639f, 
    -0.34754917f, -0.09337257f, 0.20010181f, 0.15070690f, 0.20483896f, -0.06005263f, -0.16655941f, -0.16483462f, 
    -0.44130665f, 0.05320461f, 0.14363712f, -0.21671052f, -0.16240311f, 0.06591462f, -0.22574559f, 0.07071197f, 
    0.07978356f, 0.85031188f, 0.07485622f, 0.14226650f, -0.03465749f, -0.30719733f, -0.68151170f, -0.00810221f, 
    0.05138692f, -0.78986543f, 0.08476849f, 0.00421916f, 0.16341957f, 0.10893977f, -0.32566261f, 0.53605819f, 
    0.19550797f, 0.02828879f, -0.39842412f, -0.47108462f, 0.18757124f, -0.05270221f, -0.19837017f, -0.80930638f, 
    0.29945400f, 0.09479882f, -0.03686850f, 0.23023145f, -0.06366375f, -0.21711071f, -0.37058100f, 0.17267786f, 
    -0.32361051f, 0.23812857f, 0.31935462f, 0.35108110f, 0.10004520f, -0.72842389f, 0.26418561f, 0.04727471f, 
    0.16276048f, 0.03951215f, -0.55005741f, -0.17775108f, 0.04179057f, -0.70160961f, -0.89490157f, 0.47632006f, 
    0.41810966f, -0.11145909f, -0.22714017f, -0.00481960f, -0.73750418f, -0.17711462f, -0.10511461f, 0.36706346f, 
    -0.00574306f, 0.06404964f, 0.06980632f, -0.16984633f, 0.12531126f, -0.15058486f, 0.13384740f, -0.08625741f, 
    -0.54950041f, 0.13245280f, 0.05304736f, -0.29419726f, -0.13050638f, 0.36027560f, -0.13682765f, 0.09577621f, 
    0.19240636f, 0.17627206f, -0.00496401f, -0.91575533f, 0.03438072f, -0.13369322f, -0.04905711f, 0.48725116f, 
    -0.18392195f, -0.00908587f, 0.20970193f, -0.49776688f, 0.13676184f, 0.01177731f, 0.07038821f, 0.36554292f, 
    0.16927271f, 0.02836811f, -0.11775595f, 0.11920831f, -0.00216281f, -0.00795564f, -0.53103220f, -0.15630804f, 
    -0.12054387f, -0.61569178f, -0.43508625f, -0.12279848f, 0.05881262f, 0.00934806f, 0.23631294f, 0.35734877f, 
    -0.70206004f, -0.05527375f, -0.13649422f, -0.34925762f, 0.13705432f, -0.22352250f, -0.25983617f, -0.20886643f, 
    0.32137075f, 0.08953426f, -1.18837702f, 0.58779103f, -0.23754157f, 0.01743919f, -0.13066684f, 0.09335776f, 
    0.04380893f, -0.03106883f, -0.06782949f, 0.07189514f, -0.04322820f, 0.08799553f, -0.80194992f, 0.13973324f, 
    0.35636070f, 0.22465570f, 0.10593035f, -0.65023816f, -0.12658603f, -0.35166436f, -0.17853297f, -0.81176704f, 
    -0.47092769f, -0.01975600f, 0.26058805f, 0.02736660f, -0.07791826f, 0.29396185f, 0.07408719f, -0.21318629f, 
    -0.02379817f, 0.02307267f, -0.00330033f, 0.22699462f, -0.46130893f, -0.04835349f, -0.03874114f, -0.02572444f, 
    -0.18443228f, 0.09577206f, -0.03828127f, 0.08347813f, 0.06496266f, -0.24382964f, 0.18895343f, 0.02669790f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.35482717f, -0.27626970f, 0.28948876f, 0.15156023f, 0.16411026f, 0.33665362f, -0.09410036f, -0.84073907f, 
    -0.34408045f, -0.37657708f, 0.22554231f, 0.13741183f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
