#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.20840785f, -0.77188396f, 0.08143333f, -1.10631740f, 1.17182767f, 0.46010241f, 0.21024145f, 0.50917798f, 
    -0.35159233f, 1.21297145f, 0.74740463f, 0.87999892f, -0.53254688f, -0.73005694f, 0.18085638f, 0.01256387f, 
    -0.27174485f, -0.02125450f, -1.47305238f, 0.19654045f, 0.09526426f, 0.84881169f, 1.14915216f, 0.00329781f, 
    -0.06404725f, -0.32491872f, 0.30623302f, 1.01570404f, 1.19390309f, 0.39553681f, 0.77218056f, -0.86245221f, 
    -0.34147066f, 0.20109029f, 0.03527609f, 0.31565142f, 1.29126155f, -1.20207489f, 0.53303617f, -0.22607991f, 
    -0.76740861f, -0.35346457f, -0.16285832f, -0.16423234f, 0.07838637f, 0.68179256f, -0.51557308f, -1.02291512f, 
    0.66783667f, 0.01211554f, -0.23800536f, -0.45441872f, -0.67191845f, 0.85671049f, -0.20007734f, 1.58661699f, 
    -0.96561772f, -0.42734408f, 0.57858032f, -0.81740320f, -0.03422089f, 0.03923212f, -0.04439390f, 1.04932046f, 
    0.67451847f, -0.05061529f, 0.50611192f, 0.46262342f, -0.16911604f, 0.49517214f, 0.36685637f, 0.12121341f, 
    -0.10043969f, 0.38676786f, -0.60088104f, 0.86365712f, 0.87033266f, -1.19568729f, 0.45031801f, -0.50034344f, 
    -0.69965601f, -0.67452139f, -0.78158975f, -0.34687507f, -0.49227220f, 0.80466861f, 0.99639714f, 0.18284854f, 
    0.44955149f, 0.64006907f, -0.10818161f, -0.69412851f, 0.98308998f, -1.20004237f, -0.64795280f, 0.17440648f, 
    -0.02035086f, -0.47985724f, 0.31664729f, -1.05904782f, -0.98324120f, -1.12908912f, -0.84523737f, 0.56328154f, 
    0.35059258f, 0.11069641f, -0.29686731f, 0.30343112f, -0.37600839f, -1.15840483f, -0.61143303f, -0.80156827f, 
    0.08020170f, -0.97380763f, 0.41049883f, 0.37823859f, 0.10537377f, 0.85281527f, 1.28831255f, -1.20168793f, 
    0.63702744f, 0.16567655f, 0.47487819f, -0.07926310f, -0.38450998f, -0.01131398f, 0.60177130f, 0.59542936f, 
    0.81350178f, 0.80435014f, -0.08597491f, 0.80597544f, -0.25598511f, 0.41135392f, -0.76349777f, -0.37601307f, 
    0.55270231f, 1.12623441f, 0.71859044f, -0.21050322f, 0.67067695f, -0.44708103f, -0.54209441f, 0.26296738f, 
    1.27938688f, -0.94441497f, -0.99968255f, 0.15951510f, 0.09467130f, -0.43308517f, -0.03376724f, -0.07985523f, 
    0.35308686f, 0.35188970f, 1.21139467f, 0.95529914f, -1.18049669f, 0.94761884f, -0.33309945f, 0.33271343f, 
    0.10946346f, -0.24229023f, 0.07774934f, 0.09565943f, -0.37377971f, -0.91889840f, -1.03425622f, -0.86154616f, 
    -0.11935708f, -0.16280465f, -0.50430298f, 0.83804166f, 0.45137849f, 0.19979696f, -0.02437508f, 0.23230529f, 
    1.00478458f, -0.45726907f, -0.42938876f, -0.37388244f, 0.90594029f, 0.38715568f, 0.45549300f, -1.13683164f, 
    -0.71036303f, -0.81709570f, 0.71136332f, 0.27048644f, 0.40855682f, -0.63471526f, -1.83928204f, 0.28589880f, 
    0.72187001f, 0.75819945f, 0.50149161f, -0.17794913f, -0.24457936f, -0.20121449f, -0.21322893f, -0.52521229f, 
    0.81699401f, -0.67624360f, -0.70419812f, -0.17352165f, -0.39409953f, -0.48052248f, -0.57779026f, 0.00907519f, 
    -0.52520311f, 0.14830795f, -0.06700174f, -1.24573910f, 0.69818664f, 0.18945719f, -0.65016276f, -0.76775396f, 
    0.10330284f, 0.15894084f, -1.20101166f, -0.46517423f, -0.95164347f, 0.56429505f, 0.82282382f, -0.19561036f, 
    -0.09078842f, -0.08333115f, 1.25651968f, 0.75361782f, 0.24729253f, -0.66467720f, 0.06774271f, -0.65246761f, 
    -0.38213605f, -0.30841744f, -0.48371309f, -1.14776874f, -0.92880350f, 0.38246819f, 0.78616518f, 0.68040890f, 
    -0.67228085f, -0.09942327f, -0.57407200f, 0.74508750f, 0.95503616f, 0.60964173f, -0.55921030f, 0.40626022f, 
    0.11522190f, -0.38299870f, 0.30729184f, -0.41455099f, 0.57567292f, -0.30923361f, 1.20609796f, -0.68760383f, 
    0.36427599f, -0.79808569f, 0.55765736f, 0.64668381f, -0.36757007f, 1.03538632f, -1.07528532f, 0.80266315f, 
    1.00223958f, -0.19489263f, -0.03273546f, 0.05678689f, 0.27378619f, -0.67352569f, -0.28724033f, -0.96537483f, 
    0.24575473f, -0.73320770f, -0.57136452f, 0.10101840f, 0.85848033f, 0.68067366f, -0.70985579f, 0.87872708f, 
    -1.06375897f, 0.51474923f, 0.27137852f, 0.22416869f, 0.57189226f, 0.46930298f, -0.09308803f, -0.07337251f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04660602f, 0.24962197f, -0.13613398f, -0.05402622f, 0.17040010f, 0.16582890f, 0.00211827f, 0.33389592f, 
    0.20782314f, -0.00253126f, 0.26557991f, 0.24768241f, 0.49372458f, -0.03062501f, 0.09047771f, 0.26377070f, 
    0.48965767f, 0.23781921f, 0.32350251f, 0.20680350f, 0.01282088f, 0.21441908f, 0.09088721f, -0.06777244f, 
    0.10489362f, 0.23498929f, -0.05916574f, 0.24171107f, -0.08666489f, 0.20271948f, 0.00056223f, 0.25962675f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.36609960f, -0.10557336f, -0.04366701f, -0.00728990f, -0.14448902f, -0.19885844f, 0.04721383f, -0.05864659f, 
    -0.13097903f, 0.06008010f, 0.04222847f, -0.03946382f, 0.08170889f, 0.07467249f, 0.05606428f, -0.05244134f, 
    -0.12708296f, -0.02447019f, -0.19882181f, -0.03217180f, 0.13188761f, 0.08650941f, -0.01416490f, -0.25109074f, 
    0.09645912f, -0.16457398f, -0.23320906f, -0.12754232f, 0.05697780f, -0.00828685f, -0.01126406f, 0.00000607f, 
    0.03973814f, -0.00792512f, -0.02069894f, 0.13434790f, 0.00612964f, 0.00775347f, 0.06769134f, 0.06404457f, 
    0.90096670f, 0.08220777f, 0.45072192f, -0.06397228f, -0.10878128f, 0.03076210f, 0.08186208f, 0.01589456f, 
    0.01513212f, -0.04470252f, 0.02478727f, -0.04766244f, -0.03115388f, 0.01864155f, 0.09513103f, 0.13057043f, 
    0.01989502f, 0.10656537f, 0.07495761f, 0.08978090f, 0.24943599f, -0.14724194f, 0.06683702f, -0.21403779f, 
    0.07102443f, -0.20775628f, -0.07303557f, 0.02618170f, 0.07620113f, -0.01325692f, 0.02966211f, -0.06657803f, 
    -0.02968042f, 0.06479071f, -0.05552683f, 0.11653826f, 0.03910680f, 0.09876424f, -0.04154117f, 0.02699274f, 
    0.32650805f, -0.47925943f, 0.29103839f, 0.07798667f, -0.39854410f, 0.05478258f, 0.00212306f, 0.01302195f, 
    0.03853424f, -0.01576619f, -0.23700066f, 0.10042394f, -0.01508135f, 0.02102319f, 0.13942973f, 0.02984719f, 
    -0.11892326f, 0.08853995f, 0.11201923f, -0.00225443f, -0.04411325f, -0.13616765f, 0.09355067f, 0.06789574f, 
    0.10424399f, -0.07415079f, 0.14154929f, 0.09697043f, 0.01818073f, -0.04541004f, -0.10238059f, 0.08134422f, 
    0.02373321f, -0.09394336f, 0.01432342f, 0.09559533f, -0.02768493f, -0.02164671f, -0.27984786f, 0.01099195f, 
    0.16689011f, 0.02226464f, 0.15580432f, -0.21933180f, 0.41627324f, -0.01787414f, 0.01944510f, 0.10126052f, 
    -0.20036063f, 0.07133269f, 0.03466336f, 0.14112370f, -0.06931025f, -0.14196700f, 0.10568487f, -0.22587411f, 
    0.04577916f, 0.16705148f, -0.07727443f, -0.14730920f, 0.01894077f, -0.03816528f, -0.07810173f, -0.11465261f, 
    0.27839631f, -0.07773864f, -0.00813456f, 0.01771427f, 0.10240989f, -0.02091385f, 0.04480095f, 0.01612673f, 
    0.02684324f, 0.08705989f, -0.03215713f, -0.00400505f, -0.15366757f, 0.03688607f, 0.02914452f, -0.02654375f, 
    0.33021745f, 0.02341566f, 0.19973199f, -0.11144520f, 0.09496137f, -0.11182096f, 0.00530689f, 0.10540572f, 
    -0.00184845f, -0.08896390f, 0.10866322f, 0.15182711f, 0.04240896f, 0.07719437f, -0.02188871f, 0.10074824f, 
    0.00386333f, -0.00683398f, 0.01725494f, -0.04840096f, -0.35609052f, 0.22130769f, -0.17538409f, -0.10014141f, 
    -0.20277475f, 0.02436992f, -0.09094743f, -0.04959525f, 0.13398904f, -0.12167814f, 0.08989447f, -0.03019344f, 
    -0.00863612f, 0.06976983f, 0.10379000f, 0.06444896f, -0.13288102f, -0.03594201f, -0.00864980f, -0.01350141f, 
    0.11232497f, -0.09833988f, -0.18546976f, 0.21148762f, -0.18600887f, -0.05441796f, -0.01074096f, 0.00159079f, 
    -0.00190933f, -0.09521800f, -0.06756818f, 0.00050050f, -0.08308069f, -0.09596284f, -0.00940040f, -0.02377088f, 
    0.01509069f, 0.01150851f, 0.08092442f, -0.03592070f, -0.25680345f, 0.38828701f, -0.22337818f, -0.14297798f, 
    -0.33276689f, 0.08658241f, -0.05082626f, 0.01725286f, 0.06802692f, -0.09413444f, 0.08864069f, 0.02421629f, 
    -0.06082900f, 0.14469092f, -0.02806233f, -0.02509836f, -0.16799846f, 0.02241513f, -0.02417117f, 0.04294906f, 
    -0.25527912f, -0.51994872f, -0.16853124f, 0.11864842f, -0.26946464f, -0.03676963f, -0.19217198f, 0.07106377f, 
    0.02415819f, 0.01757983f, 0.04032113f, 0.03055348f, -0.18686908f, -0.12814216f, 0.09914187f, 0.02302738f, 
    -0.00367663f, -0.01788689f, 0.03443253f, 0.02689689f, 0.06017762f, 0.02076825f, 0.15350030f, -0.17839290f, 
    0.45787665f, -0.29874915f, 0.06727888f, 0.09363540f, 0.10320408f, -0.04717474f, 0.00255608f, -0.01711974f, 
    -0.05911465f, 0.01907442f, -0.04356464f, -0.00398318f, 0.00989395f, 0.01874750f, -0.22248495f, 0.03452241f, 
    0.09960686f, -0.02450684f, 0.06311236f, 0.06948508f, 0.07739148f, -0.15938577f, -0.08623129f, 0.08368772f, 
    -0.01127042f, 0.03040919f, -0.01660751f, -0.00235442f, 0.03839146f, -0.05815027f, -0.09133465f, 0.05737946f, 
    -0.05840542f, -0.14156483f, -0.00275849f, 0.04776247f, -0.23728947f, -0.03533080f, 0.19245413f, 0.22838077f, 
    0.00847060f, -0.10877406f, -0.08400622f, -0.01231231f, -0.02303002f, 0.01913966f, 0.00514881f, -0.06711429f, 
    -0.01865223f, -0.12083635f, 0.01218970f, 0.04198724f, -0.00463060f, -0.01383821f, -0.01920437f, -0.00582410f, 
    -0.05285330f, -0.33812615f, 0.16118309f, 0.14677578f, 0.09850445f, -0.03888712f, 0.02452798f, 0.13953343f, 
    -0.01321770f, -0.01960949f, -0.07766165f, 0.08911107f, 0.02960335f, -0.09298979f, -0.03058167f, 0.03250661f, 
    0.03044204f, 0.03985611f, -0.04192522f, -0.00930207f, 0.07588078f, 0.05298622f, 0.01367974f, -0.16085480f, 
    0.16206419f, -0.11895596f, -0.08995952f, -0.04727391f, -0.01923076f, 0.04519182f, -0.06258570f, 0.00887352f, 
    -0.02213452f, -0.10768702f, 0.09312316f, -0.09569213f, -0.01420136f, 0.02870054f, 0.01170419f, -0.08967246f, 
    -0.07996823f, -0.26043707f, 0.28096715f, 0.21085910f, 0.06304226f, 0.04264869f, -0.05761102f, 0.01767545f, 
    -0.07351639f, 0.00242882f, 0.03430378f, -0.09786818f, -0.02651940f, -0.00907754f, -0.00858506f, 0.08089417f, 
    0.06142958f, -0.02799418f, -0.07234322f, -0.09750362f, 0.16029070f, -0.01758193f, -0.06316663f, -0.02602879f, 
    0.14975606f, -0.16646555f, 0.04270310f, -0.15073046f, 0.00872257f, -0.08217032f, -0.04233893f, -0.01248479f, 
    0.07459342f, -0.07132327f, -0.01251218f, 0.15608968f, 0.13977389f, -0.04162726f, -0.02547455f, 0.06816899f, 
    0.06775053f, -0.00564144f, 0.05380943f, 0.07912814f, 0.06342672f, -0.05647306f, 0.00135121f, -0.23375267f, 
    0.08907386f, -0.02704494f, 0.05572948f, -0.06743836f, 0.06896942f, -0.06037952f, -0.10884488f, -0.09025697f, 
    -0.03094472f, 0.01551467f, 0.17920977f, -0.02614080f, -0.25553721f, 0.21808435f, 0.23848718f, -0.05030820f, 
    -0.53387755f, 0.09085714f, 0.04748463f, 0.11731359f, 0.09223174f, -0.02989803f, 0.01540778f, -0.02957186f, 
    -0.06966369f, -0.07971408f, -0.06089575f, -0.07415959f, 0.09317236f, -0.03746756f, -0.05823153f, -0.00573543f, 
    0.02786302f, -0.02374041f, -0.33042458f, 0.21171038f, -0.06799423f, -0.13030866f, -0.07245140f, 0.01636202f, 
    0.14504041f, 0.03408759f, 0.01754530f, 0.07703879f, -0.06475308f, -0.04417406f, 0.02899238f, 0.09977140f, 
    -0.09930194f, 0.09710746f, 0.12415040f, 0.07305964f, 0.03800936f, -0.09095595f, 0.14009397f, 0.11600504f, 
    -0.14050791f, -0.08889829f, 0.07747545f, -0.12789750f, -0.06138568f, 0.05633200f, -0.07475246f, -0.04899034f, 
    0.25548753f, -0.01598349f, 0.01821104f, -0.03801465f, -0.09303959f, -0.07093082f, 0.06633591f, -0.00884895f, 
    -0.03030177f, -0.37579367f, 0.13147098f, 0.07724112f, -0.03016827f, -0.11219722f, -0.12798022f, -0.12153832f, 
    0.07659841f, -0.04701631f, -0.05397855f, -0.11471602f, -0.08380516f, -0.03006152f, 0.05867815f, -0.07520467f, 
    -0.18190946f, 0.03919728f, -0.06758726f, -0.15154579f, -0.15226509f, 0.17411552f, 0.11558761f, 0.08681703f, 
    0.24465796f, -0.04367632f, -0.20143433f, 0.01269704f, -0.04311999f, 0.02455897f, 0.04491600f, -0.01831335f, 
    -0.14957605f, 0.06542692f, 0.03616272f, 0.07301594f, 0.10539383f, -0.03848533f, -0.05431169f, 0.08397420f, 
    -0.04477150f, 0.12369026f, -0.07617556f, -0.23285805f, -0.36338699f, 0.03533250f, 0.05861966f, 0.03167150f, 
    -0.00592616f, 0.00259495f, 0.05575546f, -0.09364966f, 0.08378790f, 0.04579935f, -0.05966036f, 0.07376051f, 
    0.06562410f, 0.04017484f, -0.12443823f, 0.08836473f, 0.14984611f, 0.11055126f, -0.04617971f, -0.17716692f, 
    0.37780344f, -0.13942286f, -0.15957466f, -0.12085926f, 0.08029906f, 0.00693503f, -0.05382475f, 0.01405480f, 
    0.02511904f, -0.00221388f, 0.03969286f, -0.02403415f, 0.05466345f, -0.04568584f, 0.07315454f, 0.00800938f, 
    0.18398127f, -0.17589515f, -0.08800731f, 0.20546883f, -0.34712437f, -0.10534495f, -0.16706921f, -0.04585518f, 
    0.02761285f, -0.08144940f, 0.04700620f, 0.16044010f, 0.04359297f, 0.03550916f, -0.10824285f, -0.03382841f, 
    -0.14280885f, 0.07410917f, -0.04038486f, 0.04681945f, 0.26852086f, -0.25707600f, 0.09674874f, 0.01125835f, 
    -0.35565412f, 0.00945585f, -0.13482825f, 0.04589702f, 0.03193148f, -0.10232460f, -0.14297968f, 0.10866513f, 
    0.02484019f, 0.05284116f, -0.03943972f, -0.05615489f, -0.04956253f, 0.07331917f, -0.01180399f, -0.03144991f, 
    -0.21786362f, -0.55009490f, -0.26925066f, 0.19635007f, -0.25834453f, -0.10564502f, -0.02708726f, 0.07595963f, 
    -0.01735362f, -0.01977466f, 0.04599584f, -0.02488434f, 0.08101399f, -0.03347979f, -0.13177390f, -0.00116388f, 
    -0.02174885f, -0.08961422f, -0.02721408f, 0.05318522f, 0.09827079f, 0.00950217f, -0.13628612f, -0.02895929f, 
    -0.19777183f, 0.10467447f, 0.00479240f, 0.00662804f, -0.03697151f, -0.01593275f, -0.07579958f, -0.00998024f, 
    -0.19682170f, 0.00502305f, 0.04310204f, -0.16106085f, -0.03041881f, 0.01034595f, 0.06358107f, -0.02118649f, 
    0.05097967f, -0.15455763f, -0.06209176f, 0.11973957f, 0.18315770f, -0.07871135f, -0.05455818f, 0.01709403f, 
    0.01326748f, -0.08271565f, 0.04200542f, -0.05151372f, -0.09825670f, -0.00781844f, -0.19179943f, 0.07253740f, 
    -0.20648280f, 0.02620989f, -0.01406199f, 0.10393200f, 0.15508330f, 0.07064024f, 0.05290535f, 0.18456846f, 
    -0.03859720f, -0.02652527f, -0.08383059f, 0.09388853f, 0.00918458f, -0.01298466f, -0.03788826f, -0.02014049f, 
    -0.07278719f, 0.11199985f, 0.03342680f, 0.06897072f, -0.05273185f, 0.02686913f, -0.11481727f, -0.03939224f, 
    -0.81441754f, 0.11020581f, -0.11230796f, -0.02795862f, -0.04285810f, 0.05877926f, 0.08334999f, -0.12360049f, 
    -0.06639968f, -0.02593907f, -0.00821167f, 0.12545630f, -0.03952019f, -0.10989914f, -0.02669656f, 0.13666700f, 
    -0.07637708f, -0.06690113f, 0.04456786f, -0.08941830f, 0.04340555f, 0.00078495f, 0.23890083f, 0.02611480f, 
    0.39110523f, -0.08037276f, -0.15355101f, 0.05504423f, -0.01316720f, -0.02497423f, -0.07280783f, 0.00844904f, 
    0.10611682f, 0.12238995f, -0.10489066f, 0.00951999f, -0.03795693f, -0.09944919f, 0.03454506f, -0.01707356f, 
    0.03733098f, -0.09063057f, 0.07057850f, -0.15096964f, -0.03748048f, -0.01079821f, 0.04631713f, 0.05818462f, 
    -0.08270232f, -0.05347127f, 0.13431150f, 0.04061896f, 0.13863544f, -0.07825850f, -0.05279132f, -0.01911527f, 
    -0.02497528f, -0.18758433f, -0.10204413f, -0.07932764f, 0.04879700f, -0.37396881f, 0.03219075f, -0.14103539f, 
    -0.19480669f, 0.05868677f, -0.06922647f, -0.03826122f, 0.01852180f, 0.01909123f, 0.00236075f, 0.03139773f, 
    -0.10732588f, -0.06963097f, -0.07115515f, -0.08084574f, 0.11382458f, -0.12806013f, 0.18908575f, -0.09598894f, 
    0.05354766f, -0.08688720f, -0.49380630f, -0.61364716f, 0.05020300f, -0.01263261f, 0.01390339f, -0.03695882f, 
    -0.03372917f, 0.10586493f, 0.15349524f, -0.06805920f, 0.18294615f, 0.05612166f, 0.21593924f, -0.00175884f, 
    -0.01250741f, -0.05778427f, -0.12142200f, 0.06602104f, 0.24762268f, 0.01086407f, 0.29219913f, -0.05074728f, 
    -0.07805152f, -0.12779777f, -0.11373118f, 0.00051908f, -0.04101055f, -0.06316448f, -0.05605794f, 0.03350533f, 
    -0.02028250f, 0.04627924f, 0.02365970f, -0.00604710f, 0.02754514f, -0.06456236f, 0.00178276f, 0.03011486f, 
    -0.23000699f, -0.32845154f, -0.18024670f, 0.00145659f, 0.04929093f, 0.03236386f, -0.05540062f, -0.04225912f, 
    -0.06741948f, 0.08080630f, -0.07266027f, -0.03234207f, -0.06187125f, -0.11487275f, 0.05453612f, -0.00048943f, 
    -0.04183771f, -0.08634382f, 0.01569220f, -0.08350687f, 0.10806698f, 0.13531587f, -0.08015790f, 0.03879079f, 
    -0.02826497f, -0.01895267f, -0.00242902f, 0.08985455f, 0.05202708f, 0.07863070f, -0.03692595f, -0.11931138f, 
    0.02227271f, -0.11727375f, 0.02531545f, 0.11855480f, -0.02502213f, 0.01988805f, -0.12397377f, 0.06693271f, 
    -0.63948959f, -0.04691537f, -0.04731832f, -0.14464639f, -0.36045966f, 0.07338843f, 0.06879558f, -0.08627219f, 
    0.05171059f, -0.01092691f, -0.03733186f, 0.03232344f, -0.02451319f, 0.07812420f, -0.05931637f, -0.02049983f, 
    -0.03609970f, -0.11222334f, 0.03821930f, -0.14556836f, 0.38774729f, -0.06424710f, -0.01965220f, 0.02792838f, 
    -0.08512434f, -0.02019805f, 0.02175823f, -0.06505221f, 0.14930643f, 0.18907325f, 0.00629269f, -0.04728805f, 
    0.04351815f, -0.00543802f, 0.12482680f, 0.03198456f, 0.04411463f, 0.02906445f, -0.24377452f, -0.07447445f, 
    0.19808848f, -0.17468442f, -0.13707520f, 0.08436727f, -0.09302693f, 0.06995976f, 0.00528055f, 0.03398509f, 
    0.07956652f, 0.13234463f, -0.02230811f, -0.09620889f, 0.11839121f, 0.08687426f, -0.03031905f, 0.18412238f, 
    0.05717389f, -0.09150577f, -0.17639786f, -0.07945291f, 0.04342156f, -0.52174038f, 0.16802263f, -0.09200981f, 
    0.19800042f, -0.15506935f, -0.02694629f, -0.09836037f, -0.02787020f, -0.06669866f, -0.02220773f, 0.02793370f, 
    -0.13355851f, 0.00491026f, -0.04840514f, -0.13301961f, -0.00466827f, -0.00207587f, 0.08654927f, -0.10290204f, 
    0.16350763f, 0.15725119f, 0.12984000f, 0.12349779f, 0.18102476f, -0.02543829f, -0.02916285f, 0.00864227f, 
    -0.04446432f, 0.15152858f, -0.04341256f, -0.01088913f, -0.02943788f, 0.05089420f, -0.07160497f, -0.07116815f, 
    0.00791238f, 0.07759429f, 0.10139020f, 0.04581917f, 0.21640606f, 0.20758869f, -0.09583852f, -0.01269207f, 
    0.11592050f, -0.02264490f, 0.03887415f, 0.12255001f, -0.13875246f, 0.13314043f, -0.02816676f, 0.06705394f, 
    0.10090724f, -0.00276319f, 0.05208929f, 0.08933561f, -0.05058643f, 0.06709107f, 0.02210021f, 0.11523121f, 
    0.17204800f, -0.64157677f, 0.03076687f, -0.17540067f, -0.03519540f, 0.02828803f, -0.04677930f, -0.08744178f, 
    -0.02957816f, 0.01968706f, 0.07865813f, 0.08401307f, -0.02631638f, 0.02401288f, -0.09597034f, 0.07155190f, 
    0.00927478f, -0.07691920f, 0.03802699f, -0.06013428f, 0.09647114f, 0.25162503f, -0.07436109f, 0.04138366f, 
    0.24112725f, -0.01482740f, 0.02502339f, 0.06551516f, 0.00371589f, -0.00728882f, 0.12709723f, -0.02919861f, 
    0.05606943f, 0.08419858f, -0.13772927f, -0.03558645f, 0.05649507f, 0.08529280f, -0.09241157f, 0.07746638f, 
    0.03302799f, -0.04895252f, -0.27501962f, -0.28303561f, -0.07890595f, 0.09099216f, -0.05246135f, 0.02418372f, 
    0.05105574f, 0.02569495f, -0.11931792f, -0.04132025f, -0.03287837f, 0.11674186f, -0.13355486f, -0.20248438f, 
    -0.08810193f, -0.08946398f, 0.00750707f, -0.02940246f, 0.15098800f, 0.13440423f, 0.10540596f, 0.15881376f, 
    0.19621536f, 0.01307200f, -0.04870204f, -0.02624986f, 0.06944769f, 0.00914635f, 0.00783225f, 0.16761494f, 
    -0.09433316f, -0.01058945f, -0.15961380f, -0.07907896f, -0.05774408f, 0.09441987f, 0.12575659f, -0.07920644f, 
    0.08288906f, -0.27934968f, -0.10221704f, -0.01299163f, -0.21866107f, 0.07601761f, -0.04880665f, 0.12239438f, 
    -0.02554133f, -0.04309433f, 0.01876846f, 0.08549689f, -0.00043196f, 0.12343224f, 0.07100086f, 0.01509765f, 
    -0.08096948f, -0.21235330f, -0.11766098f, 0.03648085f, 0.24688776f, 0.06266459f, -0.18669473f, 0.07624178f, 
    -0.39745671f, 0.00646240f, 0.06499916f, -0.05774483f, -0.04036828f, 0.17534329f, 0.05651113f, -0.01013688f, 
    -0.15116769f, 0.07859115f, 0.00801668f, 0.02864203f, 0.14054520f, 0.05701844f, 0.01649594f, -0.05123189f, 
    -0.29904419f, 0.18048792f, -0.14297970f, -0.06538257f, -0.38179404f, -0.07166723f, -0.02515410f, 0.00932936f, 
    -0.01269589f, -0.03390284f, -0.11701775f, -0.04510982f, -0.07912775f, -0.05892306f, -0.07503254f, 0.02818665f, 
    -0.06734547f, -0.10023427f, -0.09534216f, -0.00650616f, -0.51966071f, 0.29960039f, 0.07262119f, 0.06050920f, 
    0.06691802f, -0.02961254f, -0.09010207f, 0.08362896f, 0.08666078f, 0.08982890f, 0.04113498f, -0.00885904f, 
    -0.02828307f, 0.01860519f, -0.05545455f, -0.01404728f, 0.00058158f, -0.00686819f, 0.03264203f, -0.01838063f, 
    0.02664116f, -0.08005489f, -0.03730614f, -0.04829013f, 0.04470693f, 0.05098889f, -0.08297087f, 0.02545921f, 
    0.05868225f, 0.05883016f, 0.11543601f, 0.01650503f, 0.07057985f, 0.00289595f, -0.06964295f, -0.05456152f, 
    -0.03970490f, -0.11579647f, 0.05047062f, 0.14197746f, 0.25057563f, 0.02562804f, -0.06827527f, -0.09992948f, 
    0.19058342f, -0.06377565f, 0.04395042f, 0.10731973f, -0.07840704f, 0.08951264f, -0.09677345f, -0.15834147f, 
    0.01808602f, -0.04456640f, 0.06233558f, -0.01021188f, -0.06188194f, 0.00411595f, -0.03803118f, -0.06743941f, 
    0.28817308f, -0.19050694f, -0.05763725f, -0.03222127f, -0.25580776f, -0.01062933f, -0.00793735f, -0.14180532f, 
    0.00203481f, 0.05536919f, 0.13134743f, 0.07800602f, -0.05462087f, -0.01120610f, -0.05203671f, -0.03680060f, 
    0.04855889f, -0.08248384f, -0.01404304f, 0.04990086f, 0.21910353f, 0.37071452f, 0.02812075f, 0.16736020f, 
    0.15443777f, -0.01161629f, 0.02348781f, 0.14396027f, 0.01748833f, 0.02685419f, 0.02229430f, 0.02923752f, 
    -0.08043089f, 0.08295967f, -0.09975656f, 0.05350395f, 0.01736458f, 0.02227087f, -0.05023479f, 0.01480103f, 
    -0.35126054f, -0.05767403f, 0.04690068f, 0.04456428f, 0.00670019f, -0.02799256f, -0.00446161f, -0.01948683f, 
    -0.04791111f, -0.03043979f, 0.17912394f, -0.08466268f, -0.08594649f, -0.08154532f, -0.05210396f, -0.13109800f, 
    0.10976857f, -0.04263156f, -0.00185937f, 0.04511904f, 0.44594643f, -0.06230785f, 0.10995030f, -0.14496021f, 
    -0.11928143f, -0.16295725f, 0.08349752f, 0.03876403f, -0.00267466f, 0.06421246f, 0.03296371f, -0.12969598f, 
    0.09820884f, -0.07252346f, 0.03157759f, 0.06561776f, 0.08907682f, -0.06315081f, 0.09825722f, 0.17724754f, 
    -0.34892398f, -0.00244695f, -0.12245708f, 0.04861302f, -0.24363109f, 0.05271914f, -0.10107037f, -0.06712298f, 
    0.23310149f, -0.07200085f, -0.21533206f, -0.22042960f, 0.04864947f, 0.07005831f, -0.12485822f, 0.03148016f, 
    0.09618114f, 0.00913607f, -0.17337094f, -0.03522530f, 0.08895288f, -0.15948769f, 0.05448298f, 0.01052426f, 
    -0.01723533f, -0.05629873f, -0.05492150f, -0.00535929f, 0.04050698f, 0.05825897f, 0.13156416f, 0.02413182f, 
    0.08863264f, -0.04568610f, -0.10723021f, 0.10778929f, -0.03814794f, 0.08236117f, 0.06416483f, 0.02499142f, 
    0.54008657f, 0.21593906f, 0.08781280f, -0.07428663f, -0.06994022f, 0.02078127f, 0.00864372f, 0.12265114f, 
    -0.02716980f, -0.03216130f, -0.06937572f, 0.01730377f, 0.05249758f, 0.02117855f, -0.13400778f, 0.16753991f, 
    -0.12010911f, -0.08578945f, 0.04743743f, -0.04914086f, -0.38093367f, 0.24639912f, -0.12077975f, -0.09892383f, 
    0.18972799f, 0.01294987f, 0.05012976f, 0.08192727f, -0.00739443f, -0.08468084f, -0.02763625f, 0.05661827f, 
    0.04836316f, -0.06484728f, -0.06311942f, -0.09946731f, 0.06775595f, -0.02024447f, -0.06203416f, 0.03776097f, 
    0.66833901f, 0.07687944f, 0.20928790f, -0.01497699f, 0.29772592f, 0.10619225f, -0.22380571f, -0.16058762f, 
    0.02566627f, 0.13268550f, 0.04662385f, 0.05663957f, 0.03662911f, 0.01686892f, -0.02338564f, -0.01472654f, 
    -0.14494005f, 0.00324090f, -0.02995993f, -0.06304272f, 0.01712201f, 0.03640968f, 0.08436643f, -0.13120918f, 
    0.00534289f, 0.10069798f, -0.01130460f, 0.17347404f, 0.00583847f, -0.04446102f, -0.17355324f, 0.10887229f, 
    -0.03502279f, -0.07851082f, -0.07066032f, 0.07052418f, -0.01173890f, -0.04158325f, -0.18278286f, 0.02001278f, 
    -0.57034874f, 0.11819410f, -0.26177630f, -0.32394961f, -0.14827989f, 0.09130669f, 0.08532753f, -0.03175098f, 
    0.07945921f, 0.02569567f, -0.03096577f, -0.06149026f, -0.06824060f, -0.06587500f, -0.06500054f, -0.04225937f, 
    0.07747765f, 0.02051258f, 0.11144101f, 0.08578143f, -0.23943071f, -0.09598786f, 0.15580121f, 0.04394561f, 
    0.04238282f, -0.01645891f, -0.20632480f, -0.05895256f, 0.00493473f, -0.00667198f, -0.07939075f, -0.02881227f, 
    0.03168703f, 0.15127786f, -0.05388219f, -0.13194904f, -0.07690895f, -0.05022472f, -0.01939012f, 0.00834102f, 
    0.27032182f, -0.16486293f, -0.23759079f, -0.40162441f, -0.17495246f, 0.06274685f, -0.04116594f, 0.09028130f, 
    -0.22752284f, 0.06494051f, -0.06453028f, -0.01111748f, 0.04510434f, -0.04625388f, 0.00035741f, -0.00770336f, 
    -0.09042877f, 0.15183319f, 0.03917240f, -0.07322140f, 0.14146058f, 0.01076326f, 0.10228933f, -0.05041674f, 
    0.10710556f, -0.07374119f, -0.04999340f, 0.10058081f, -0.05010223f, -0.03212994f, -0.01416999f, -0.02222154f, 
    0.07212105f, -0.01717998f, -0.02712555f, 0.00171116f, -0.08461217f, 0.01901350f, -0.01759720f, 0.01567449f, 
    0.26207218f, -0.25962836f, 0.10652116f, -0.15308219f, 0.01162621f, 0.05953106f, -0.10432494f, 0.00709736f, 
    -0.06185957f, 0.08728296f, -0.04951615f, -0.04345969f, -0.00309577f, 0.06907794f, -0.06578287f, 0.01410673f, 
    -0.21594808f, -0.00929152f, 0.02119304f, -0.09681268f, 0.41359508f, 0.01846290f, 0.07679350f, 0.14406726f, 
    0.03175989f, -0.05964057f, -0.01148327f, -0.01681232f, -0.04860837f, 0.05972976f, 0.04070692f, -0.06830166f, 
    -0.02974016f, -0.10364565f, -0.07849696f, 0.02860068f, -0.01013497f, 0.01150129f, 0.18526271f, -0.07005740f, 
    0.12977834f, -0.04774359f, -0.28469217f, -0.03590339f, -0.19021627f, -0.03078385f, 0.02066533f, -0.01284069f, 
    -0.10262582f, -0.01810498f, 0.05825574f, -0.01392768f, 0.01076583f, -0.03395585f, -0.00665064f, 0.05970452f, 
    -0.00056457f, -0.02922102f, 0.06466991f, -0.09311727f, 0.53407407f, -0.22851555f, -0.25996530f, 0.18789934f, 
    0.07050410f, -0.14365192f, 0.07894460f, -0.12547871f, -0.03211751f, 0.07352761f, 0.06964002f, 0.02333275f, 
    0.07241095f, 0.00933219f, -0.01261255f, -0.07218362f, -0.09057636f, 0.00219063f, 0.04822635f, -0.01125438f, 
    0.46585771f, -0.43837634f, -0.00021703f, -0.20281082f, -0.26376227f, -0.12468331f, 0.07333022f, -0.09537199f, 
    0.01062924f, 0.04049531f, 0.02841823f, -0.04793640f, -0.00748516f, -0.07731564f, -0.03463314f, 0.02734788f, 
    0.05033282f, 0.12430262f, 0.04990446f, -0.01989404f, 0.39490911f, -0.21736771f, -0.21580252f, -0.08475250f, 
    -0.24239829f, 0.02333192f, -0.19616936f, 0.15029375f, 0.01899508f, 0.03295371f, 0.04989501f, -0.06293894f, 
    0.11149307f, 0.02601916f, -0.01990833f, 0.05054001f, -0.05657304f, 0.10511182f, -0.05922884f, -0.12056736f, 
    -0.06574005f, 0.06956948f, 0.01678767f, -0.11545929f, 0.04078364f, 0.02806150f, 0.00582149f, -0.04050661f, 
    0.08469073f, 0.06940133f, 0.00242878f, 0.00125292f, 0.12332387f, -0.04440947f, 0.01924023f, -0.02961788f, 
    -0.04585128f, -0.13129044f, -0.08852147f, 0.04229007f, -0.00368634f, 0.05444073f, -0.03366716f, 0.01232605f, 
    0.05889678f, -0.05504207f, 0.07230937f, -0.02029412f, 0.00492458f, -0.06147284f, -0.00512653f, 0.04330095f, 
    0.04596270f, 0.05529331f, 0.06177649f, -0.10840224f, 0.03175396f, -0.08651772f, -0.01842807f, -0.02925839f, 
    -0.01502000f, -0.27610123f, -0.01651020f, -0.21007599f, -0.33536562f, -0.12480442f, -0.08745634f, -0.00631677f, 
    0.07109402f, 0.02679798f, -0.05163291f, -0.10105900f, -0.06883382f, -0.08245644f, -0.02147006f, 0.01300652f, 
    -0.04820223f, 0.07088860f, 0.05913053f, 0.00242637f, 0.14845811f, 0.20536563f, -0.04998724f, -0.09138575f, 
    0.05902860f, 0.00309189f, 0.09094337f, -0.00823660f, -0.03032157f, -0.14519434f, -0.08401714f, -0.06323345f, 
    -0.06430881f, -0.01047896f, 0.03740553f, 0.00571701f, 0.01077912f, -0.09330273f, -0.03380994f, -0.01200779f, 
    -0.46527031f, -0.35316759f, -0.10226925f, -0.21531150f, -0.29417664f, 0.03908543f, 0.03182061f, -0.11162391f, 
    -0.06737074f, -0.02936646f, -0.03238344f, 0.12433498f, 0.05192765f, -0.05220640f, -0.06093542f, 0.11075168f, 
    -0.06493896f, 0.05823441f, -0.03586054f, -0.09753180f, -0.21479258f, 0.13050573f, -0.10918874f, 0.05958794f, 
    -0.05750774f, 0.03069613f, -0.12015192f, 0.05300356f, 0.09802993f, 0.07470270f, -0.13420048f, -0.03727326f, 
    0.03399519f, 0.00863523f, -0.04137919f, -0.23581803f, -0.05346078f, -0.03017240f, -0.04023679f, 0.00268841f, 
    -0.00871502f, 0.24442208f, -0.06714004f, -0.09941680f, -0.07515689f, 0.03069835f, 0.10800157f, 0.07466926f, 
    -0.14572823f, 0.00333542f, -0.08879254f, 0.06799487f, -0.05889718f, -0.20323548f, -0.06162100f, 0.08532032f, 
    0.01178856f, 0.04899822f, -0.00546126f, -0.04622720f, 0.09393512f, -0.13222568f, 0.17683490f, 0.00262327f, 
    0.26259449f, -0.22437556f, -0.00449471f, -0.08866398f, 0.03543636f, 0.01403148f, 0.12075398f, -0.05302364f, 
    -0.00164938f, -0.09234574f, 0.11221733f, -0.00919591f, -0.09468612f, -0.13878921f, 0.01475805f, 0.09076529f, 
    -0.08887334f, -0.10151977f, -0.33942488f, -0.01394601f, -0.12698407f, 0.01594634f, 0.09403499f, -0.02487222f, 
    -0.01386017f, -0.17161684f, 0.00862687f, 0.04037268f, 0.06693430f, 0.01385709f, 0.03534079f, -0.04044380f, 
    -0.03152277f, 0.04713674f, -0.02709026f, -0.07198016f, -0.46187830f, 0.08310691f, 0.04675570f, -0.02213156f, 
    -0.00344356f, -0.06426788f, 0.01523888f, -0.09766231f, 0.08360131f, -0.05559226f, 0.09597655f, -0.03353863f, 
    0.08399529f, -0.02239587f, 0.07350569f, 0.05889086f, -0.05141968f, -0.12475768f, -0.17286199f, -0.04700664f, 
    -0.19070826f, -0.15047571f, 0.05374360f, 0.15074311f, -0.31417981f, -0.04399037f, -0.08432489f, 0.13049765f, 
    -0.07835621f, 0.11148281f, -0.02894959f, 0.06468856f, 0.03930875f, -0.05423440f, 0.03428060f, 0.06648540f, 
    -0.09005468f, 0.10129172f, -0.01431009f, -0.08483402f, 0.01561009f, 0.01434225f, -0.13074191f, 0.04023781f, 
    -0.05819944f, 0.06608058f, 0.14328341f, 0.05361498f, 0.00104688f, -0.05400714f, 0.03167890f, 0.06310722f, 
    -0.00279006f, -0.02451756f, -0.10941487f, -0.10738134f, 0.04770945f, -0.00654296f, -0.06974167f, 0.05513692f, 
    0.26140338f, -0.05143626f, -0.00394398f, 0.26385087f, 0.24883211f, -0.11359080f, -0.12100540f, -0.03597114f, 
    0.08106940f, 0.12114647f, 0.12169162f, -0.04113856f, -0.05782684f, 0.10859617f, 0.05355489f, -0.07651552f, 
    -0.05863664f, -0.04735670f, -0.16940267f, -0.02405245f, -0.04362244f, 0.08458505f, -0.16356707f, -0.12168247f, 
    0.09689398f, 0.01865598f, 0.05023142f, 0.06164328f, -0.04907054f, -0.08066088f, -0.07386637f, 0.06863324f, 
    0.03647342f, 0.01161832f, -0.02004009f, -0.01352476f, 0.04237677f, 0.00184249f, -0.11849779f, 0.00323783f, 
    0.07797278f, 0.24731550f, -0.03315336f, 0.01772605f, 0.02762624f, 0.00628466f, 0.15733045f, 0.02808674f, 
    0.00447854f, -0.08441068f, 0.09273826f, -0.10341547f, 0.02230879f, 0.09540760f, -0.08782614f, 0.02695471f, 
    0.10518755f, -0.04895509f, 0.11478960f, -0.09288503f, -0.63257819f, 0.09726227f, 0.08910702f, -0.09796346f, 
    0.07675104f, 0.11096743f, 0.05947564f, -0.00732421f, 0.03915617f, 0.01907510f, 0.02595067f, -0.08701254f, 
    0.03290950f, -0.07770462f, 0.06951096f, 0.04034876f, 0.02752837f, -0.15344448f, -0.02137381f, 0.06079434f, 
    0.07053615f, -0.21034576f, 0.11006286f, 0.05331868f, -0.09101933f, -0.09232997f, 0.14156514f, 0.07775932f, 
    -0.07407080f, -0.06358597f, 0.03041813f, -0.02854933f, 0.12085156f, 0.00841477f, -0.04448435f, 0.11315447f, 
    -0.14829437f, -0.09855728f, 0.05554654f, -0.05602511f, -0.13766505f, 0.19369213f, 0.08473396f, -0.03295216f, 
    -0.02667655f, -0.01169818f, -0.13515441f, -0.03655276f, 0.09102689f, -0.02469748f, -0.02132117f, -0.02517775f, 
    -0.01453406f, 0.04117150f, 0.06775350f, -0.01694705f, 0.04776649f, -0.04313399f, 0.06047330f, 0.10427094f, 
    -0.21946554f, 0.25910711f, 0.10378182f, 0.07222316f, 0.04366516f, 0.13101362f, -0.02509478f, -0.12333467f, 
    0.03397867f, -0.16089290f, 0.00902077f, 0.04966389f, -0.13832699f, 0.13244428f, 0.08156943f, 0.08752345f, 
    0.07193123f, -0.20719498f, 0.07665490f, 0.03890927f, -0.03018702f, -0.67823786f, -0.37629789f, 0.11049232f, 
    0.19288741f, 0.06588966f, 0.06013710f, 0.06475987f, -0.05539053f, -0.10751679f, -0.01275163f, 0.08924098f, 
    0.01710112f, -0.04608344f, 0.02304111f, -0.04887857f, 0.02366315f, 0.01802359f, -0.01139440f, -0.04346940f, 
    -0.48162740f, 0.19503120f, -0.14358126f, -0.06983294f, -0.15244879f, 0.03467515f, -0.22260572f, -0.06198777f, 
    0.09921371f, -0.09697913f, 0.07160761f, -0.09461686f, -0.09356000f, -0.03558857f, -0.00723269f, -0.04411431f, 
    0.04188263f, -0.06429264f, -0.00572689f, 0.03320236f, 0.18786250f, -0.33382913f, -0.42156684f, 0.22277646f, 
    -0.09450670f, -0.00500991f, 0.03772603f, -0.04196686f, 0.05485712f, -0.08001436f, -0.00964733f, -0.00839725f, 
    -0.09892109f, -0.04539701f, -0.12167982f, -0.01186080f, 0.00439602f, 0.15424766f, -0.03394979f, -0.02704887f, 
    0.11600346f, 0.22506505f, 0.06034273f, 0.16238564f, 0.13752560f, 0.03827321f, 0.20936891f, -0.02562902f, 
    0.08019661f, 0.07046714f, 0.02352587f, -0.02360479f, -0.18770789f, 0.04150128f, -0.07193954f, 0.01017048f, 
    -0.01100917f, 0.09750824f, 0.11748007f, 0.00426773f, 0.09304208f, 0.07649117f, -0.13184091f, 0.01215173f, 
    -0.22771798f, 0.08187636f, 0.14519307f, -0.00021810f, -0.02859054f, -0.10592544f, -0.12517591f, 0.04068084f, 
    -0.08419399f, -0.05706333f, 0.06730480f, 0.00557270f, 0.01166747f, 0.01913310f, -0.25560340f, 0.05098399f, 
    0.63063812f, 0.30826887f, 0.00339417f, -0.16629364f, 0.17389131f, -0.00885649f, 0.04172001f, 0.06073039f, 
    0.08940246f, 0.04132082f, -0.16289710f, -0.02806454f, -0.04526877f, 0.06773987f, -0.07513038f, -0.01084860f, 
    -0.00722670f, 0.03175391f, 0.12636170f, 0.12336431f, -0.26370889f, -0.43057439f, -0.21740952f, 0.09891099f, 
    -0.10260577f, -0.18458463f, -0.17765692f, -0.04514647f, 0.09037019f, -0.00343701f, -0.07137025f, -0.02408479f, 
    -0.01601290f, 0.00195556f, -0.00509640f, -0.06119355f, 0.00441566f, -0.03376955f, -0.10761455f, -0.06687640f, 
    0.30475298f, 0.05737684f, -0.12204749f, 0.12173885f, 0.05725967f, 0.02539504f, -0.05486104f, -0.02905185f, 
    -0.03383980f, -0.04963550f, -0.01218239f, -0.10854906f, 0.04746073f, 0.05829320f, 0.07980162f, -0.08193921f, 
    0.07957012f, -0.00236366f, -0.03627016f, -0.02891677f, 0.00831929f, -0.16317374f, 0.02250416f, -0.08581341f, 
    -0.27748150f, -0.10706405f, -0.18061370f, -0.14790042f, -0.18654041f, -0.05698410f, -0.03897355f, 0.07511724f, 
    -0.01769867f, 0.07826523f, 0.06520774f, 0.04780645f, 0.09294825f, -0.00833511f, 0.11221556f, -0.06764672f, 
    0.03403332f, 0.30161521f, 0.16818391f, 0.22588091f, 0.16898754f, -0.00147413f, 0.06587438f, 0.07223627f, 
    -0.04519269f, -0.04452764f, -0.13144818f, 0.06132687f, -0.01476680f, -0.00343251f, -0.00475864f, 0.02577112f, 
    0.11704918f, 0.05498162f, 0.00225687f, -0.03536842f, -0.01259871f, 0.02876359f, -0.02351191f, 0.05333700f, 
    -0.00593204f, -0.06437483f, -0.16035953f, 0.10444630f, -0.08449656f, -0.01747505f, -0.09846536f, -0.00828655f, 
    -0.10992755f, -0.01782192f, 0.08596694f, 0.05229808f, 0.05161618f, 0.07239887f, 0.16517828f, -0.01876596f, 
    0.00139639f, 0.20111601f, 0.02313771f, 0.01981094f, 0.07399707f, -0.09793064f, -0.09758365f, -0.07812868f, 
    -0.05837870f, 0.00676745f, -0.03912282f, -0.04091989f, -0.06906316f, -0.09771294f, 0.01924939f, -0.03843058f, 
    0.00225676f, 0.12858327f, -0.05501084f, -0.01828626f, 0.06438723f, 0.06978998f, -0.12854041f, 0.02716051f, 
    -0.14069226f, -0.18057977f, 0.06049828f, 0.11515297f, 0.08308876f, 0.13505197f, 0.08848728f, -0.13556382f, 
    0.00268681f, 0.04483931f, -0.00802936f, -0.08983032f, -0.06008789f, -0.03510804f, 0.02746357f, 0.04101486f, 
    -0.59832007f, -0.56988931f, -0.26154673f, -0.01355722f, -0.13971721f, -0.19592929f, -0.13211440f, -0.05019632f, 
    0.06040481f, -0.07234403f, -0.03103962f, -0.05461307f, -0.01091578f, -0.02201688f, 0.08123494f, 0.03083223f, 
    -0.12661354f, -0.02007942f, -0.03630409f, -0.02668354f, -0.28906131f, -0.44075131f, -0.04631486f, 0.03267229f, 
    -0.03427803f, 0.02789613f, -0.06026711f, 0.01172432f, 0.02127898f, -0.10306442f, 0.04849969f, -0.00504448f, 
    0.05437926f, 0.03402610f, -0.01355806f, 0.04770801f, 0.08003487f, 0.00171186f, 0.02754242f, -0.00349270f, 
    0.19047073f, 0.16450690f, 0.00464615f, 0.09779971f, -0.14541481f, -0.08481409f, 0.05296389f, -0.00871734f, 
    0.00481925f, 0.06929362f, -0.00847547f, -0.03201564f, 0.03156926f, -0.01297762f, -0.06478470f, -0.04793030f, 
    -0.00934014f, -0.00729222f, -0.00046277f, 0.03057187f, -0.62974918f, 0.19542587f, -0.13703609f, 0.00457649f, 
    0.22808443f, -0.09544435f, 0.05385542f, -0.04023780f, 0.06784442f, -0.00585283f, -0.06489106f, -0.03466808f, 
    0.08216467f, -0.10405593f, -0.01383452f, -0.05970286f, 0.05048564f, -0.15835690f, 0.05533304f, 0.06546916f, 
    0.22324842f, 0.26760733f, 0.12678979f, 0.11619598f, 0.19485410f, 0.11769267f, 0.07240818f, 0.00361718f, 
    -0.09052177f, 0.06412460f, -0.04725882f, -0.10158622f, 0.01188511f, -0.17556570f, -0.00127756f, 0.05751869f, 
    -0.02526648f, 0.17351115f, 0.12482965f, 0.04188417f, -0.16337335f, -0.49688649f, -0.07148093f, -0.11736621f, 
    -0.08801676f, -0.08183191f, -0.00450273f, 0.02671019f, 0.00363321f, -0.01625639f, -0.05395762f, 0.00882709f, 
    0.12677895f, 0.01718566f, 0.05750411f, -0.00962208f, -0.08789434f, -0.01439360f, -0.03038728f, 0.11890367f, 
    -0.06122239f, -0.12422387f, -0.07349473f, 0.25328130f, 0.30668995f, 0.04932766f, 0.12359717f, 0.07735088f, 
    -0.00322523f, -0.03820790f, -0.03420175f, -0.01513694f, -0.02393157f, -0.35125846f, -0.05286691f, 0.13804035f, 
    -0.01624030f, 0.17306302f, -0.03613231f, -0.14099650f, 0.32448700f, -0.17363107f, 0.09448905f, -0.09987518f, 
    -0.14358188f, -0.09386523f, -0.12202802f, -0.05492121f, -0.05759126f, -0.00677040f, -0.02289094f, -0.06402916f, 
    0.07338036f, -0.08937837f, 0.04155168f, 0.02920607f, -0.02421057f, -0.02311254f, 0.04745059f, 0.07918537f, 
    -0.04310026f, 0.00906222f, 0.12052200f, 0.21615887f, 0.06784768f, 0.02768095f, -0.02403557f, 0.06384489f, 
    -0.02495659f, 0.04307601f, -0.08044551f, 0.05426173f, 0.06335515f, 0.06143646f, 0.01626294f, -0.05092971f, 
    0.12767519f, 0.06364894f, 0.10083768f, -0.01629923f, 0.16327637f, -0.09198184f, 0.11915592f, 0.25690389f, 
    0.19727178f, 0.04792962f, 0.20123367f, -0.01909796f, -0.08209048f, -0.00684460f, -0.16250689f, 0.01119749f, 
    -0.01860443f, 0.04254040f, 0.08132676f, -0.07821245f, 0.10732155f, 0.00869466f, 0.07664123f, -0.06889550f, 
    0.38393027f, 0.11581865f, -0.16065353f, 0.08506176f, -0.01072950f, -0.02813730f, 0.08742232f, 0.05096335f, 
    -0.13880284f, -0.08280031f, 0.04525772f, -0.06983847f, -0.12475118f, -0.05926435f, 0.09502784f, -0.13246876f, 
    -0.01283350f, -0.04489355f, -0.01903425f, -0.05429490f, -0.01126349f, -0.41486266f, -0.29283488f, 0.06320561f, 
    0.15123408f, 0.04506063f, 0.04597223f, 0.02936401f, 0.04345011f, 0.09254581f, -0.00037083f, 0.06702727f, 
    0.00451419f, 0.11558920f, -0.07962455f, -0.00259926f, 0.05288417f, -0.02242741f, 0.12221062f, 0.03417687f, 
    0.00117404f, -0.19309916f, -0.15998226f, -0.12342776f, -0.27365890f, -0.11188707f, -0.12599136f, 0.16801514f, 
    -0.02901101f, 0.02250544f, -0.13079686f, -0.02846903f, 0.13724688f, -0.05991615f, -0.00881442f, 0.02708724f, 
    -0.01067092f, 0.07355417f, 0.00385005f, 0.11173612f, -0.45295244f, -0.11573914f, -0.22453417f, -0.12289435f, 
    0.01274014f, -0.06018757f, 0.06015523f, -0.06095913f, 0.02679586f, -0.02937678f, -0.03423531f, -0.04729338f, 
    0.01420938f, 0.05391404f, -0.03669965f, -0.05982215f, -0.05964835f, -0.08782791f, 0.00200443f, 0.04356799f, 
    -0.53168631f, 0.34023520f, -0.14354655f, 0.24527337f, 0.09740331f, -0.04222022f, 0.10727341f, -0.01654752f, 
    0.10789952f, 0.07585812f, 0.08250674f, -0.07822576f, -0.03648238f, -0.11770399f, 0.00655027f, -0.05234999f, 
    -0.02247794f, 0.04320220f, 0.06317002f, -0.10372894f, -0.11235581f, -0.12167860f, -0.49663228f, 0.08499831f, 
    -0.12506188f, -0.02983731f, 0.07068615f, -0.07578345f, -0.08658705f, -0.00117421f, 0.01785376f, -0.01135650f, 
    -0.07022149f, 0.02779643f, 0.01356846f, 0.04757425f, -0.03756608f, 0.12072391f, -0.00914001f, -0.07025170f, 
    -0.00381896f, 0.07163858f, 0.11080877f, 0.18443000f, 0.05477621f, -0.03543568f, 0.07233024f, -0.06867432f, 
    -0.09124246f, -0.01192359f, -0.12433541f, 0.01628851f, 0.01246093f, -0.05485803f, 0.05571735f, -0.07730936f, 
    0.07389906f, -0.05293887f, 0.17589287f, -0.20310742f, 0.03140287f, -0.04101979f, -0.16281873f, -0.01994630f, 
    -0.06455119f, -0.13009556f, 0.09989627f, -0.08391167f, 0.05002892f, -0.10454516f, -0.03627581f, 0.07149424f, 
    -0.01491080f, 0.04873183f, 0.03111317f, -0.01763189f, 0.00362902f, -0.02898339f, -0.04442735f, -0.02403412f, 
    -0.75382495f, 0.12344982f, 0.13597488f, -0.07902790f, 0.01006638f, -0.04411227f, 0.01952875f, 0.00836148f, 
    -0.09772571f, -0.03168264f, -0.03615673f, 0.08298898f, 0.06066595f, 0.07664953f, -0.07710513f, -0.16702373f, 
    0.24824679f, 0.05174473f, 0.04455324f, -0.24583861f, 0.00768859f, -0.26463851f, 0.21119015f, 0.07243993f, 
    0.01294782f, -0.02137803f, 0.05264685f, -0.02160640f, -0.01200928f, -0.01043954f, 0.08312375f, 0.12113602f, 
    0.02339546f, -0.10077135f, -0.02351686f, -0.05716251f, 0.03745834f, -0.02435925f, 0.08488954f, 0.06981067f, 
    -0.13709831f, 0.29975840f, -0.38035801f, -0.03246171f, 0.00651405f, 0.17115325f, -0.01338210f, 0.18208870f, 
    -0.08488277f, 0.00338247f, 0.04363614f, -0.00901398f, 0.00529360f, -0.03211652f, -0.05567251f, 0.02312780f, 
    0.10562344f, 0.10256656f, 0.13162920f, 0.06518347f, -0.33341894f, -0.14611261f, 0.10383882f, 0.00197481f, 
    0.05405477f, -0.07802372f, -0.02784522f, -0.13613719f, 0.03794128f, 0.12374791f, 0.04698528f, -0.02279607f, 
    0.07479040f, -0.00462690f, -0.02915057f, -0.10905994f, -0.05228327f, -0.04841325f, 0.01086978f, 0.06852602f, 
    -0.17217810f, 0.13408495f, 0.09574417f, 0.06774867f, -0.18194862f, -0.00804758f, -0.03389311f, -0.02558427f, 
    -0.03810042f, -0.01918585f, 0.08916565f, 0.00172076f, -0.06148005f, -0.04504625f, -0.09260790f, -0.06826632f, 
    0.03197268f, 0.19151780f, 0.03378901f, 0.15462011f, 0.18714307f, 0.12627891f, -0.14106897f, 0.12383410f, 
    -0.02760673f, -0.00444535f, -0.08173065f, -0.00735117f, -0.07270559f, -0.04419173f, 0.01157671f, 0.04872088f, 
    0.02498866f, 0.07997032f, 0.00319754f, -0.07936063f, -0.12014134f, 0.06087966f, 0.05995416f, 0.08243664f, 
    -0.08734015f, 0.11167139f, 0.09096533f, -0.02738118f, -0.24183506f, 0.04403367f, -0.11499482f, 0.07807054f, 
    -0.03231697f, -0.19288130f, -0.00196285f, 0.00805190f, -0.16012511f, -0.01618958f, 0.03029232f, 0.00761686f, 
    0.14580308f, -0.02192087f, -0.00856152f, 0.02096912f, -0.03333494f, -0.11211961f, -0.08061324f, -0.12176689f, 
    -0.05219123f, -0.00506095f, 0.01016485f, -0.14066364f, 0.13776298f, 0.12839928f, 0.09503075f, -0.11306040f, 
    -0.05135296f, 0.01011789f, 0.08090272f, 0.02529019f, 0.06297728f, -0.02799822f, -0.05140138f, -0.03196947f, 
    -0.21155328f, 0.00814636f, 0.08374228f, -0.10398841f, -0.11057318f, -0.02563989f, 0.02343933f, -0.00907216f, 
    -0.06788000f, -0.03990305f, -0.09409711f, 0.00442795f, 0.05907112f, 0.08416010f, 0.01220077f, -0.22921053f, 
    0.11228006f, -0.01728997f, -0.01666568f, 0.07991023f, -0.28888845f, 0.16426593f, -0.01629997f, 0.04809014f, 
    0.18569483f, -0.01949920f, 0.02562595f, 0.01201862f, 0.00263039f, 0.13308775f, -0.18509756f, 0.06955709f, 
    -0.13049886f, 0.04379786f, -0.05468826f, 0.01311651f, 0.05787221f, -0.02774495f, -0.02893086f, -0.20411685f, 
    0.01277039f, -0.14749251f, 0.09013920f, 0.07913119f, 0.12383176f, -0.05655696f, -0.05891383f, 0.01704977f, 
    -0.11293038f, 0.01023455f, 0.08349492f, -0.01031202f, -0.10741140f, 0.00518839f, 0.04596950f, -0.14193387f, 
    0.01471111f, 0.01657607f, 0.11603414f, -0.04060626f, -0.21567412f, -0.05051083f, -0.05170972f, 0.11987073f, 
    0.15208541f, 0.03527915f, -0.06213103f, 0.05067236f, -0.02023281f, 0.13568653f, 0.07656903f, -0.05407983f, 
    0.00136439f, -0.01189254f, 0.00641968f, -0.05045398f, 0.03261188f, 0.05520973f, 0.18870105f, -0.11755709f, 
    -0.18452266f, 0.07487814f, -0.03278004f, 0.08941784f, 0.03806854f, 0.12325555f, 0.06168653f, 0.01316049f, 
    0.13473843f, -0.08023861f, -0.00361954f, 0.06559882f, -0.00258723f, -0.00896238f, 0.05789921f, -0.03658368f, 
    -0.08934394f, 0.01798594f, 0.04570965f, 0.01414484f, 0.28197014f, -0.35230964f, -0.34655660f, 0.24830571f, 
    -0.33983934f, 0.11478082f, -0.05067700f, 0.08103795f, -0.02769010f, 0.05887330f, -0.12104093f, -0.03722898f, 
    0.09379627f, -0.03830861f, -0.07832374f, 0.05677967f, -0.03659886f, -0.07118992f, -0.02000394f, 0.01679959f, 
    0.06990325f, -0.04228063f, -0.05820165f, -0.16969901f, 0.19126391f, 0.11046099f, 0.04275123f, 0.04527842f, 
    0.04966648f, -0.02197081f, 0.14388797f, -0.06132766f, 0.14178947f, 0.06411908f, -0.15965995f, 0.19338991f, 
    -0.07684287f, -0.08092017f, 0.00099626f, -0.00240561f, 0.40326238f, 0.28527218f, -0.16194858f, -0.16726238f, 
    0.13324837f, 0.07566854f, -0.09072267f, -0.10183398f, 0.17019096f, -0.06076346f, -0.07974124f, 0.14113934f, 
    0.00752301f, 0.07298804f, 0.08570524f, -0.10778996f, -0.02832005f, -0.09899635f, -0.05067087f, -0.00613294f, 
    0.14725490f, 0.37035912f, -0.15623125f, -0.01859622f, -0.29593420f, -0.07847270f, 0.02166527f, 0.09880505f, 
    -0.05688410f, -0.20357609f, -0.10282025f, -0.09681501f, -0.02046814f, 0.04852803f, -0.00255140f, -0.06889553f, 
    -0.06694907f, 0.12498806f, 0.01419372f, -0.02162418f, -0.64769399f, 0.03489641f, 0.18345477f, 0.10614982f, 
    0.06367640f, -0.09240760f, -0.06313517f, 0.10280291f, -0.07184647f, -0.05829983f, 0.09925482f, 0.02006687f, 
    -0.12333734f, -0.08202542f, -0.04369644f, 0.04956545f, 0.10859398f, -0.15603739f, 0.02616384f, -0.03314242f, 
    -0.00047461f, -0.01160320f, -0.03526011f, 0.20644277f, -0.13006458f, -0.09476451f, 0.14430791f, 0.06722361f, 
    -0.01231660f, 0.01453433f, 0.08885211f, -0.00568768f, 0.00596919f, 0.00907110f, 0.23533809f, 0.12715282f, 
    -0.02705469f, 0.05948120f, 0.06745035f, 0.18618609f, 0.26764941f, -0.14261062f, 0.24960312f, -0.00057519f, 
    -0.13811673f, -0.01899359f, -0.00714276f, 0.05403844f, -0.02475985f, 0.10386912f, 0.03782651f, -0.06819737f, 
    0.04630714f, 0.07752720f, 0.06114222f, -0.10877461f, 0.13730772f, -0.00275343f, -0.01440229f, -0.11921415f, 
    -0.25819805f, -0.54533166f, 0.14583972f, 0.30542225f, -0.08414112f, -0.14862773f, -0.02423159f, -0.09736359f, 
    -0.21782325f, -0.06818868f, 0.02455973f, 0.03790853f, -0.04154394f, -0.06251032f, 0.11781596f, -0.18099593f, 
    -0.13454166f, 0.00549028f, -0.01209469f, 0.02134185f, -0.64157593f, 0.01495057f, -0.08941322f, 0.02751686f, 
    0.25268421f, -0.01866074f, 0.02247390f, -0.03505405f, 0.13117237f, -0.01459459f, 0.02981535f, -0.00732694f, 
    -0.04775796f, 0.12604871f, 0.11790919f, -0.00092400f, -0.00088972f, 0.06779147f, 0.05082143f, 0.04980966f, 
    0.06241357f, -0.02146907f, 0.16630983f, 0.08881117f, 0.09064950f, 0.08402040f, 0.13553919f, 0.03788636f, 
    -0.10430702f, 0.00018360f, 0.14565541f, 0.04322363f, -0.14356013f, 0.12466048f, 0.02639912f, -0.00459349f, 
    0.06307080f, 0.06794740f, -0.00598971f, 0.09681240f, 0.17163756f, -0.26315621f, -0.04666584f, -0.05860076f, 
    0.09982590f, 0.01198301f, -0.03789527f, 0.02379822f, -0.01593438f, -0.09858685f, 0.02150168f, 0.02035069f, 
    -0.20701601f, -0.03359704f, -0.06816547f, -0.08569953f, 0.11470241f, -0.10530082f, -0.08432845f, -0.06424819f, 
    0.11062113f, 0.06373285f, -0.41307312f, 0.03272396f, -0.11125513f, 0.00488415f, -0.10556430f, 0.04749181f, 
    -0.06911906f, -0.16808501f, -0.14097966f, -0.03642181f, 0.09093925f, -0.01558635f, -0.00469086f, -0.09832803f, 
    -0.04671133f, 0.19563363f, -0.17376654f, 0.00191078f, 0.23398884f, 0.10588846f, 0.02560493f, -0.05012202f, 
    0.01577684f, -0.12534861f, -0.03085564f, 0.05814806f, 0.06896817f, -0.07020739f, -0.01976974f, 0.04943475f, 
    0.05596543f, 0.06839021f, -0.06918747f, -0.01339754f, 0.01054994f, 0.12550327f, 0.04489207f, 0.12726164f, 
    -0.82928014f, -0.04866355f, 0.07252195f, 0.23123716f, 0.32389373f, 0.16768628f, -0.05264809f, 0.13985831f, 
    -0.00128197f, 0.17326058f, -0.04064848f, -0.02022120f, 0.10139342f, 0.09981509f, 0.06370836f, 0.05347989f, 
    -0.01998218f, 0.05326325f, 0.16720515f, -0.05701771f, 0.02228881f, 0.02538030f, 0.32517558f, -0.04760502f, 
    -0.04288960f, -0.05257010f, -0.05312968f, 0.07663741f, -0.00279978f, 0.02222338f, 0.15937035f, -0.02960774f, 
    -0.01718523f, -0.15163523f, -0.05067898f, 0.16273971f, 0.02522655f, 0.01396057f, -0.06155025f, -0.05055008f, 
    -0.39197978f, -0.16123360f, 0.18552583f, -0.12596631f, -0.02213940f, -0.00055365f, -0.04308908f, -0.00601334f, 
    0.02834345f, 0.10776851f, -0.10329738f, 0.00515864f, -0.04531941f, -0.15783313f, 0.06464378f, 0.16946146f, 
    -0.14468727f, -0.03626950f, 0.00480195f, 0.00015054f, -0.25626874f, 0.34330267f, 0.19866879f, -0.21016930f, 
    -0.14849328f, 0.17133085f, -0.02940349f, -0.00851165f, -0.07928779f, -0.06204554f, 0.08969996f, -0.09323211f, 
    -0.14633480f, -0.02621331f, -0.07294364f, 0.01579977f, -0.12366107f, -0.13388687f, -0.17467409f, -0.05424242f, 
    -0.10455449f, -0.10720258f, 0.04451567f, -0.00252576f, 0.13874573f, 0.00430253f, 0.05712753f, -0.01163590f, 
    -0.08271886f, 0.05221882f, 0.12525378f, 0.21428971f, -0.03192095f, -0.13669795f, -0.05922198f, -0.00519902f, 
    -0.11564654f, 0.03017275f, -0.05438546f, -0.01115034f, -0.28247920f, 0.15186277f, 0.07779610f, -0.30840260f, 
    -0.16041082f, -0.01704681f, 0.08018439f, -0.10172500f, -0.06870677f, 0.07893517f, -0.03837549f, -0.10983349f, 
    0.07788054f, 0.04494823f, 0.04415321f, 0.02287358f, -0.03488220f, -0.14365731f, -0.15552078f, -0.09185840f, 
    -0.07233227f, -0.13455331f, 0.00957546f, -0.13689655f, -0.22325604f, 0.02967767f, -0.11243388f, 0.01649592f, 
    0.14320683f, -0.08458090f, 0.04880453f, -0.03107306f, -0.12749650f, -0.14045215f, -0.05480583f, 0.02523259f, 
    -0.09382730f, 0.00438518f, 0.04173070f, 0.10075141f, 0.13351671f, 0.06152182f, 0.00153302f, 0.18572061f, 
    0.13360326f, -0.06931365f, 0.03460814f, -0.05224933f, 0.03588062f, 0.04633296f, -0.03884244f, -0.13373251f, 
    0.02153496f, 0.14933287f, 0.01022879f, -0.00339734f, -0.06289207f, 0.08377977f, 0.00729125f, 0.02169465f, 
    -0.76531374f, 0.01829846f, 0.06270091f, -0.09450123f, -0.16579908f, -0.01884948f, 0.01756639f, 0.19075923f, 
    -0.05287217f, -0.12096875f, 0.10742900f, -0.07233332f, 0.10245889f, -0.11320551f, -0.00940402f, -0.08963943f, 
    0.02910573f, -0.11605456f, 0.06220935f, 0.00833803f, 0.02106689f, -0.05429672f, -0.00851269f, 0.12727821f, 
    -0.05706663f, 0.04467112f, -0.05503494f, 0.06563827f, -0.02326098f, 0.06892002f, -0.00493761f, -0.01819883f, 
    -0.12317695f, 0.01966910f, 0.10773367f, -0.01822208f, -0.02381858f, -0.01832253f, 0.17624125f, -0.01258748f, 
    0.00792926f, -0.18637413f, -0.11818393f, 0.16270472f, 0.28794175f, -0.07698087f, -0.19182165f, -0.01326416f, 
    0.07861027f, 0.07592080f, -0.06184843f, -0.09053802f, 0.03068807f, 0.08628438f, -0.00232229f, 0.05637190f, 
    -0.16949710f, -0.05151583f, -0.14736807f, -0.17491184f, -0.00864961f, 0.00192391f, -0.22598810f, -0.20331511f, 
    0.04379993f, -0.02552709f, 0.11249067f, -0.11260150f, 0.10713114f, -0.01277863f, 0.17814814f, -0.02902215f, 
    0.09449692f, -0.09320217f, 0.00173481f, 0.08292127f, -0.04023989f, -0.03492066f, 0.13568594f, 0.10784024f, 
    -0.09186275f, -0.26583067f, 0.24055994f, 0.23051727f, -0.09372219f, -0.18219350f, -0.00218363f, -0.03256570f, 
    0.05346178f, 0.17136331f, 0.07785749f, -0.07123727f, -0.01485855f, 0.07026201f, -0.17659497f, -0.06290509f, 
    -0.04095878f, -0.17866059f, 0.12493896f, 0.01078158f, 0.01441449f, 0.02709367f, 0.03214395f, 0.13837676f, 
    0.17934860f, 0.24885075f, 0.05244768f, 0.12197903f, -0.02005265f, 0.01239215f, -0.03959439f, -0.13055240f, 
    0.00225370f, -0.06878456f, 0.00842684f, 0.05724379f, 0.11135985f, -0.07605895f, 0.08771009f, 0.02946645f, 
    0.07895123f, 0.09748427f, 0.00956291f, -0.02911705f, 0.02428517f, -0.01632773f, 0.02443828f, 0.06199549f, 
    0.08531345f, -0.10382002f, 0.00395787f, -0.09385539f, 0.00027501f, -0.11703212f, -0.09536148f, -0.06840350f, 
    -0.01032505f, -0.05942962f, 0.07338741f, 0.18570378f, -0.47327521f, -0.22747856f, -0.18771985f, -0.15382314f, 
    -0.22973688f, 0.10678980f, -0.03605425f, -0.02485521f, 0.05420398f, -0.28272542f, 0.09794927f, 0.10413195f, 
    0.06999559f, -0.00522653f, -0.06749254f, 0.04051896f, 0.00609795f, -0.01136320f, 0.06728467f, 0.07104773f, 
    0.15122235f, 0.11712849f, 0.04604232f, -0.00994680f, -0.02043500f, 0.00547477f, -0.05079635f, -0.02000955f, 
    -0.00381923f, 0.06360928f, 0.03182891f, -0.02841584f, 0.14713384f, 0.14882818f, -0.01678260f, 0.07190073f, 
    -0.18201074f, 0.02528892f, -0.29081583f, 0.15127283f, -0.79774064f, -0.23395139f, -0.34510764f, -0.33811045f, 
    0.01346181f, 0.13369513f, 0.12837042f, 0.00943583f, 0.10318285f, -0.12311125f, 0.03441068f, 0.00881351f, 
    -0.04665490f, 0.01376350f, -0.16429460f, -0.03094060f, 0.00089614f, -0.11019776f, -0.28922310f, 0.07627467f, 
    -0.34064144f, -0.21490954f, -0.03377653f, 0.01559022f, 0.18726090f, 0.15364738f, -0.03659737f, -0.05676210f, 
    -0.04272092f, 0.01861800f, -0.01523686f, 0.08056591f, 0.14335509f, 0.13925642f, 0.02219224f, -0.07382587f, 
    0.07545428f, -0.11843307f, -0.26021835f, -0.02427038f, 0.09540744f, 0.44323260f, 0.00128390f, -0.12372944f, 
    -0.10039786f, 0.03292862f, -0.11512160f, -0.15230834f, -0.18943837f, 0.13588691f, -0.03055730f, -0.03023052f, 
    -0.14707547f, 0.01627279f, -0.07567885f, 0.07351425f, -0.01602560f, -0.02970482f, 0.12704593f, 0.00995452f, 
    0.07934091f, 0.08193629f, 0.18928291f, 0.14076732f, -0.18091831f, 0.03127436f, 0.02907892f, -0.00647953f, 
    0.00668948f, -0.09996068f, 0.04686538f, 0.10090705f, -0.02764389f, -0.01692466f, 0.08395399f, 0.02326377f, 
    0.01354892f, 0.22280230f, -0.07703125f, -0.12279912f, -0.15595870f, 0.01664535f, 0.16509816f, 0.19039474f, 
    -0.21895529f, 0.13546582f, 0.00043084f, 0.04307633f, 0.02932340f, -0.03081997f, 0.02751828f, -0.06141915f, 
    -0.09052038f, -0.04680135f, -0.09488026f, 0.00108882f, 0.06501520f, 0.12626286f, 0.06391421f, 0.09202236f, 
    -0.10376535f, -0.22503076f, -0.06898120f, 0.05500877f, 0.18736859f, 0.05825609f, -0.04845347f, -0.07203198f, 
    0.05698979f, 0.08536631f, 0.04799563f, 0.04435770f, 0.09793063f, 0.00368671f, -0.01297424f, -0.13632670f, 
    0.03377815f, -0.17917357f, -0.07969306f, -0.08130758f, 0.08602511f, -0.15594462f, -0.06358123f, 0.08849011f, 
    -0.30482063f, -0.19286829f, 0.04191998f, -0.01999950f, 0.03262154f, -0.01016198f, -0.08194181f, -0.01888075f, 
    0.12533002f, 0.07590814f, 0.13532171f, -0.10019222f, -0.04617448f, 0.14093474f, 0.05470110f, 0.06309187f, 
    0.03317532f, -0.01668482f, -0.02685262f, 0.10528368f, 0.16424571f, 0.04954070f, -0.06079538f, 0.02336902f, 
    0.02445215f, -0.02914328f, -0.06470048f, 0.02525896f, 0.09766362f, 0.18984407f, 0.17903112f, -0.07164430f, 
    0.02763888f, 0.00982168f, -0.11519843f, -0.14045528f, 0.26496655f, 0.17665869f, 0.12842314f, -0.15048158f, 
    0.15200481f, -0.04465888f, 0.09688426f, -0.00776102f, -0.16226591f, 0.11291140f, 0.01262810f, -0.04571255f, 
    -0.04532282f, 0.02202430f, -0.06017923f, 0.08985579f, -0.11535520f, 0.12262101f, -0.02098072f, 0.05676802f, 
    0.13410506f, 0.15784584f, 0.10210572f, 0.03535232f, 0.19179550f, -0.23414166f, -0.14348699f, 0.10541528f, 
    0.11057270f, 0.12158317f, -0.10722237f, -0.26885009f, 0.04121812f, 0.12734704f, 0.14126469f, 0.09052376f, 
    0.13332067f, -0.10254113f, -0.15790857f, 0.05194731f, -0.52255601f, 0.23423764f, -0.30801037f, -0.07008278f, 
    -0.19953495f, 0.04575001f, -0.01505334f, 0.10128289f, -0.07595699f, -0.13960199f, -0.02981353f, 0.02991702f, 
    0.06018354f, -0.15187413f, -0.06325863f, 0.06340742f, -0.02153012f, 0.01844985f, 0.08512115f, -0.07836822f, 
    0.07221712f, 0.22364530f, -0.05234431f, 0.04726290f, 0.09187169f, 0.04581299f, -0.01610089f, 0.00312367f, 
    0.10701115f, 0.05071515f, -0.02477374f, -0.00166493f, 0.15888128f, -0.10511429f, 0.10353982f, -0.14822279f, 
    0.07755873f, -0.12265950f, -0.07872387f, -0.15916972f, -0.01129016f, -0.09843054f, -0.18410815f, 0.04699228f, 
    0.03728563f, 0.11984691f, 0.03965927f, 0.00566696f, 0.02174200f, 0.16163525f, 0.06892660f, 0.04846182f, 
    0.17845674f, 0.01778522f, -0.13599166f, -0.07509837f, -0.12857927f, 0.06700301f, -0.12511972f, -0.03760500f, 
    -0.33260810f, -0.08889620f, 0.14313725f, -0.05824634f, 0.09292235f, -0.00857496f, 0.05141855f, -0.22186637f, 
    -0.01972959f, 0.07581664f, -0.00297051f, 0.05448831f, -0.20241213f, 0.07422726f, -0.02611103f, 0.12717785f, 
    0.17285198f, -0.07604861f, -0.13381463f, 0.06473177f, -0.05900035f, -0.05702944f, 0.14565632f, 0.15433402f, 
    -0.33950526f, -0.04500575f, -0.13960941f, -0.05981325f, 0.01799319f, -0.01843261f, 0.00967142f, 0.06203039f, 
    0.09057095f, -0.12145977f, 0.13402648f, -0.00568861f, 0.01378893f, 0.08763859f, 0.19002655f, -0.14794259f, 
    -0.06447200f, 0.40602690f, -0.28647512f, -0.19841950f, -0.01460142f, 0.06545538f, 0.19055201f, 0.04615923f, 
    -0.10603268f, -0.15259133f, 0.05226932f, 0.03249080f, -0.19574666f, -0.14606167f, -0.02711804f, 0.02723967f, 
    0.02882942f, 0.03832284f, 0.00931522f, -0.08424955f, 0.09361502f, -0.01475425f, -0.01338164f, 0.04240058f, 
    -0.01296213f, -0.09344815f, 0.20264582f, -0.09135423f, 0.02300611f, 0.00099360f, -0.01273664f, 0.05580990f, 
    0.12234268f, 0.04428925f, 0.10665012f, -0.06778530f, -0.12786831f, 0.08918400f, 0.08562829f, -0.01918954f, 
    -0.02324078f, -0.06723079f, -0.08741382f, -0.05975208f, 0.12098213f, -0.05356815f, -0.01106208f, 0.12772685f, 
    0.03481718f, 0.07073613f, -0.05782148f, -0.03025478f, -0.06165639f, -0.09566807f, 0.18847825f, -0.06043595f, 
    0.06328298f, -0.01104411f, -0.12627098f, -0.10721413f, -0.42159995f, 0.04333654f, 0.11709936f, 0.35297033f, 
    0.07022522f, -0.06307989f, -0.04848311f, 0.02601402f, -0.05837622f, 0.10256211f, 0.12559319f, 0.13146165f, 
    0.06161749f, -0.00900896f, 0.03076177f, -0.04506809f, 0.08407374f, -0.08611234f, 0.02798439f, -0.23196846f, 
    -0.09006482f, -0.09871548f, 0.03154388f, -0.07371230f, 0.20095085f, -0.10126514f, -0.08802986f, -0.03195860f, 
    0.09676763f, 0.15414874f, 0.06976314f, -0.00336370f, -0.00555873f, 0.08623216f, 0.17229185f, -0.00681483f, 
    -0.00792235f, 0.00810860f, -0.35779792f, 0.04245487f, -0.34336656f, 0.01329208f, 0.09837344f, 0.08639639f, 
    -0.09500052f, -0.07052905f, 0.05983441f, -0.02242510f, -0.04213201f, -0.09639020f, 0.05660806f, -0.01196209f, 
    -0.05601088f, 0.00882268f, 0.04250356f, 0.08382500f, 0.01114325f, 0.00719937f, -0.02331099f, 0.03517033f, 
    0.59147453f, -0.20365921f, 0.06504130f, -0.01253017f, 0.15659028f, 0.09431285f, 0.03854437f, 0.04237599f, 
    0.05245988f, -0.07066213f, -0.13517794f, -0.07795540f, 0.21563497f, 0.00903856f, 0.05365013f, -0.04027146f, 
    0.10845818f, 0.02556296f, 0.02759194f, -0.01195581f, -0.18608250f, 0.24342203f, 0.05671126f, -0.03908445f, 
    -0.27318999f, 0.05189437f, -0.03312940f, 0.02723320f, 0.06688011f, -0.04395990f, -0.04941535f, 0.06101035f, 
    -0.01956512f, -0.08121115f, -0.04033889f, 0.02947005f, -0.01731341f, -0.10470700f, 0.08216966f, 0.00560647f, 
    0.34389988f, -0.67224032f, -0.15968974f, 0.08315570f, 0.00382286f, -0.11355976f, 0.10857434f, -0.09187176f, 
    0.02339166f, 0.03685379f, -0.09435057f, 0.01506680f, -0.04955506f, 0.09988134f, 0.06415191f, -0.04419380f, 
    -0.07513730f, 0.08644624f, -0.15952814f, 0.11217504f, -0.10491087f, 0.35458729f, -0.15061603f, 0.25288832f, 
    -0.35519919f, -0.12354533f, 0.13288237f, -0.02116724f, 0.05847639f, -0.02761327f, 0.01637484f, 0.15869193f, 
    -0.02848296f, -0.03990781f, -0.00991322f, -0.11236178f, -0.08385709f, 0.10227239f, -0.11604249f, -0.04481546f, 
    0.09256238f, 0.07054125f, -0.09259706f, -0.03454199f, 0.20919454f, -0.15687992f, 0.03886994f, 0.05761141f, 
    -0.05292798f, 0.07935619f, -0.12518591f, 0.05069023f, -0.01230874f, -0.03411461f, 0.10962162f, 0.09234044f, 
    -0.09597973f, 0.05216515f, 0.11806462f, 0.10725292f, -0.05930356f, -0.22096157f, -0.11735489f, -0.14946881f, 
    0.26587814f, -0.16368085f, 0.08618468f, 0.04217203f, -0.17562009f, -0.12765045f, 0.04079350f, 0.00575902f, 
    -0.04178009f, 0.00617941f, -0.22763647f, 0.01839591f, 0.04582758f, 0.10633234f, 0.04452011f, -0.08503120f, 
    -0.43159062f, 0.04372530f, -0.04627760f, 0.39373156f, -0.00931335f, 0.19939287f, 0.05201415f, 0.06944954f, 
    0.05517473f, -0.08001785f, -0.14586379f, 0.06882674f, -0.00196361f, 0.10497495f, -0.10574146f, 0.13470845f, 
    -0.16949564f, 0.12859817f, 0.00143110f, -0.01508872f, -0.28041232f, 0.20686352f, -0.17479765f, 0.16407676f, 
    -0.11547428f, -0.18211365f, 0.00729427f, -0.09387113f, 0.05904598f, 0.01645004f, 0.05876998f, 0.04800400f, 
    0.01628384f, -0.00724384f, -0.11181053f, -0.14701676f, -0.09386861f, -0.04155456f, -0.12876371f, -0.14401671f, 
    0.14233114f, -0.13923724f, -0.10569441f, 0.08539914f, -0.04086306f, -0.06460786f, 0.09508473f, -0.09530694f, 
    0.11986545f, -0.02064626f, -0.02393808f, 0.03067008f, 0.05116442f, -0.05684862f, 0.13802527f, -0.00140864f, 
    0.03935146f, 0.12749679f, -0.20351997f, 0.04821170f, -0.10864533f, -0.41990513f, 0.02479817f, -0.06900354f, 
    0.06554054f, -0.05042160f, 0.02454499f, 0.09387762f, -0.13510354f, 0.09370330f, 0.12855645f, -0.08448525f, 
    0.09667391f, 0.10970077f, 0.02582389f, -0.11308128f, -0.08072306f, -0.04485999f, -0.03389597f, -0.18730387f, 
    0.02388622f, -0.01239443f, 0.01276451f, -0.19710958f, -0.12323105f, 0.00524417f, 0.02186287f, 0.09667042f, 
    -0.01861766f, 0.06729435f, 0.06248607f, -0.09487130f, -0.10875645f, -0.08437045f, 0.09256937f, -0.06861704f, 
    -0.01144060f, -0.01742467f, 0.13438642f, -0.04917477f, -0.33037931f, 0.06067247f, 0.03252140f, -0.38522488f, 
    0.14299960f, -0.01063767f, -0.07709506f, 0.11486645f, -0.19302696f, 0.00656294f, -0.03839022f, -0.11477408f, 
    0.09760135f, 0.01811590f, 0.04498507f, -0.01683502f, -0.01617418f, -0.00964180f, 0.11888974f, 0.17113779f, 
    0.01706782f, 0.16516477f, -0.13041827f, -0.28304955f, 0.07968795f, -0.05457563f, 0.06918710f, 0.00556941f, 
    -0.07479017f, -0.06780843f, -0.02174039f, -0.14110853f, -0.03089181f, -0.12820745f, -0.04274323f, -0.11791021f, 
    -0.02324506f, 0.11430066f, 0.17739221f, 0.10323497f, -0.18622097f, 0.19226477f, -0.28471461f, 0.29163855f, 
    -0.19552463f, -0.09938238f, 0.01333823f, 0.01654643f, 0.03830563f, 0.06954926f, 0.07899944f, -0.01566872f, 
    0.06193520f, -0.01270069f, -0.07935251f, -0.00004237f, 0.01998411f, 0.01153085f, -0.15375872f, -0.04965783f, 
    -0.39960903f, 0.18875340f, -0.11067140f, 0.30782056f, -0.02296867f, -0.15422523f, -0.07957193f, -0.00414157f, 
    0.16590221f, 0.01143539f, -0.09724445f, -0.01898013f, 0.00387869f, 0.13256675f, 0.13406052f, -0.07736946f, 
    0.05062343f, -0.21612734f, -0.07853466f, -0.14368166f, 0.04713216f, 0.00422574f, -0.05888329f, 0.07523600f, 
    -0.14870444f, -0.06114968f, 0.11560090f, 0.04699906f, 0.05897962f, 0.14246988f, -0.02209720f, 0.08465163f, 
    -0.00086783f, -0.05594048f, 0.08557451f, 0.11034682f, 0.01105500f, -0.19296829f, 0.10281032f, -0.12555651f, 
    -0.11657368f, -0.11891307f, -0.16165535f, -0.19066800f, 0.28711706f, -0.04576942f, -0.02414683f, 0.03524830f, 
    -0.09626357f, -0.05690258f, 0.02333264f, -0.11367615f, -0.00829951f, -0.00794732f, -0.13515060f, 0.10011337f, 
    0.05069836f, 0.10736539f, 0.00574548f, 0.07411513f, -0.04122419f, 0.24517158f, 0.25299200f, 0.03262765f, 
    -0.24842773f, 0.19920845f, -0.05354868f, 0.05495270f, 0.04594092f, -0.04300456f, -0.05445458f, 0.06514101f, 
    -0.07940789f, 0.07207842f, -0.06642859f, 0.03272385f, -0.06838816f, 0.00617599f, 0.02806357f, -0.12421057f, 
    -0.07076123f, 0.08487366f, -0.32633862f, -0.14375933f, -0.03579385f, -0.02442781f, 0.05623954f, -0.09127742f, 
    -0.01122172f, 0.06846965f, -0.05003725f, -0.05087893f, -0.16170870f, -0.10602075f, -0.08137271f, -0.04284226f, 
    -0.02716965f, 0.12760901f, 0.04034225f, 0.12549052f, -0.43394291f, 0.00928128f, 0.03398796f, 0.13790613f, 
    0.08513701f, 0.11730898f, -0.08440512f, -0.00324234f, -0.00811891f, -0.11522111f, -0.10407057f, -0.02832059f, 
    -0.02079028f, 0.10518075f, 0.01354149f, 0.17098421f, 0.02695185f, -0.37952191f, 0.03216265f, -0.14694175f, 
    -0.09408382f, 0.25552064f, 0.09711856f, -0.01211042f, -0.19927558f, 0.09026513f, 0.12316298f, 0.03221078f, 
    -0.03522739f, 0.04543542f, 0.01562448f, 0.09814008f, -0.13595305f, 0.09055617f, -0.26866254f, 0.04848943f, 
    -0.05876368f, 0.09989111f, 0.05935834f, -0.18934660f, 0.23965363f, -0.61212122f, -0.00742141f, -0.18923840f, 
    0.05237550f, -0.02326190f, 0.09921058f, -0.10112354f, 0.02383434f, 0.02267024f, -0.05439660f, 0.01695772f, 
    0.06786869f, 0.13856830f, 0.01100622f, 0.05858636f, -0.02335720f, -0.07293614f, -0.11048390f, 0.10471579f, 
    -0.04647313f, 0.04751242f, -0.02390066f, -0.44052920f, -0.18014148f, 0.00857937f, 0.10770439f, 0.07377990f, 
    -0.06998979f, 0.06971703f, -0.05535741f, -0.05253292f, -0.11848850f, -0.05360666f, 0.19168665f, -0.00181658f, 
    -0.13762422f, -0.02786221f, 0.18322599f, 0.08604030f, -0.29077858f, -0.21255191f, 0.02749837f, -0.43765059f, 
    -0.13029777f, 0.06458022f, 0.09431450f, 0.10334484f, -0.10371788f, -0.15626232f, -0.03414765f, -0.22054492f, 
    -0.12561718f, 0.05304410f, -0.00087130f, 0.23769256f, -0.01397123f, 0.11448850f, 0.18977159f, 0.05735579f, 
    -0.06730071f, -0.09714862f, -0.09343988f, -0.01253111f, 0.03758904f, 0.05994118f, 0.08325689f, 0.08959372f, 
    -0.14884272f, -0.00576814f, 0.04193699f, -0.07615083f, 0.06641749f, -0.00140416f, -0.08975530f, 0.01071956f, 
    -0.07909345f, -0.12160954f, 0.12058053f, 0.04166184f, -0.09746194f, 0.35265917f, -0.06476052f, -0.08640246f, 
    -0.11418448f, 0.05949278f, -0.08979017f, 0.05798048f, 0.03259972f, 0.09669793f, 0.06293861f, 0.06177143f, 
    0.01136063f, -0.09328905f, -0.05156726f, -0.00589263f, -0.12948574f, -0.02629830f, 0.01047808f, 0.06051967f, 
    -0.15092021f, -0.43128619f, -0.07108517f, -0.40580434f, 0.06352773f, -0.02665933f, -0.00069116f, -0.01153327f, 
    0.01707669f, -0.10814928f, -0.04962602f, 0.00646061f, 0.05466372f, 0.11323569f, 0.03741623f, 0.06343401f, 
    -0.01227843f, -0.07382357f, -0.11094857f, 0.09665023f, -0.34137964f, 0.21890631f, 0.04860966f, 0.07890923f, 
    -0.38750103f, 0.03800329f, -0.20312124f, 0.10552584f, 0.01496499f, 0.04207643f, -0.04859671f, -0.01508265f, 
    0.06156662f, 0.12316182f, -0.08099727f, 0.00312406f, 0.05759660f, -0.05591236f, 0.03712590f, -0.05661333f, 
    0.10111012f, 0.15098685f, 0.14071345f, -0.02129244f, -0.01752472f, 0.06676977f, 0.00389318f, -0.04386543f, 
    -0.09372488f, 0.00675827f, -0.09251363f, 0.11971038f, 0.11166922f, 0.08166648f, -0.07718895f, 0.10624248f, 
    -0.10315706f, -0.01764130f, -0.02654433f, 0.03039434f, 0.06518672f, -0.07043316f, -0.18098336f, -0.06579727f, 
    0.49955210f, -0.06564527f, -0.07272010f, -0.05525146f, 0.00080471f, -0.10052309f, -0.08370041f, 0.01148212f, 
    -0.01774691f, 0.01781250f, 0.02107865f, -0.03607148f, -0.12695478f, 0.06887034f, -0.07350979f, 0.20117745f, 
    0.19318780f, 0.25181237f, -0.03435851f, -0.11227845f, -0.05187140f, 0.09377805f, -0.05908611f, 0.03868285f, 
    -0.13586873f, -0.05429074f, 0.02435268f, 0.02609916f, 0.00689785f, -0.03389286f, 0.03066472f, -0.08897755f, 
    0.04920228f, 0.24490000f, 0.16377857f, 0.06240586f, 0.39875773f, -0.18765722f, 0.06911620f, 0.13976593f, 
    0.42396787f, 0.03769889f, -0.02800159f, 0.02434570f, 0.04611417f, 0.00188335f, -0.02469305f, 0.01969009f, 
    0.01139706f, 0.04274649f, 0.05083652f, -0.06202183f, -0.03479199f, 0.03057424f, -0.03871671f, -0.03268263f, 
    0.33410054f, -0.26861575f, 0.13842833f, -0.15745816f, -0.00266892f, -0.06685853f, 0.14299506f, 0.01561881f, 
    -0.02020101f, 0.04991950f, -0.02984019f, 0.05517626f, 0.00755550f, 0.06952246f, -0.09305857f, 0.01761699f, 
    0.04752919f, 0.04560646f, -0.07110862f, -0.12758262f, -0.18936995f, -0.18173966f, -0.27833003f, -0.13987128f, 
    -0.07848614f, -0.02482143f, -0.07383338f, -0.06101337f, -0.00166910f, -0.10264368f, -0.04896426f, 0.00789637f, 
    0.08901139f, -0.08788805f, -0.06055877f, -0.00480883f, -0.03657674f, -0.03574082f, -0.01820418f, 0.07365831f, 
    -0.02368344f, 0.17657533f, 0.19535960f, 0.04094354f, 0.04155358f, 0.06939196f, -0.03183845f, -0.02506143f, 
    0.13295920f, -0.05091984f, -0.03112024f, 0.05252703f, 0.05608005f, -0.00535924f, -0.05102272f, 0.03945939f, 
    0.07757265f, 0.03999865f, 0.01097837f, -0.02456021f, -0.35734463f, 0.11386251f, -0.18539706f, -0.23332557f, 
    -0.15083836f, 0.03034336f, -0.05995422f, -0.06188851f, 0.04190534f, -0.09488267f, -0.18357751f, 0.04287966f, 
    0.05190272f, 0.01286003f, 0.00641470f, 0.01217087f, -0.01740293f, 0.07723463f, 0.01964290f, 0.01557204f, 
    0.05493624f, 0.23703307f, -0.21014333f, 0.13740222f, 0.28083149f, -0.10569537f, -0.06422452f, -0.06664367f, 
    0.05406630f, -0.01442356f, -0.20110206f, -0.00763158f, -0.03279226f, -0.05091390f, -0.04485757f, 0.02765909f, 
    0.01221255f, -0.01105365f, -0.08669100f, -0.02808086f, 0.09073057f, 0.24503575f, 0.04818626f, 0.05186893f, 
    0.13992745f, -0.07341033f, 0.09777185f, 0.00066478f, -0.06721579f, 0.02625576f, -0.10978898f, -0.07823360f, 
    -0.08249851f, -0.04929054f, -0.01197412f, -0.05098268f, 0.01667129f, 0.02434090f, 0.00319885f, 0.00265742f, 
    -0.37273833f, 0.10976372f, 0.20917404f, 0.17943731f, 0.10994963f, 0.04928754f, -0.10513572f, -0.08119214f, 
    0.07719395f, 0.02328590f, 0.06400154f, 0.02652462f, -0.04967531f, -0.00833533f, -0.13240652f, 0.00589451f, 
    -0.11474641f, 0.02123514f, -0.05643878f, -0.06538134f, -0.39737144f, 0.06543755f, -0.00753215f, -0.11779489f, 
    -0.17614430f, -0.09882081f, -0.01103519f, -0.03585371f, -0.05500076f, -0.06977804f, -0.03828807f, -0.01369325f, 
    -0.06587262f, -0.03557201f, -0.07165954f, -0.07446029f, -0.00438771f, 0.07088444f, -0.03925216f, -0.02798519f, 
    -0.30930522f, 0.24598417f, 0.04708635f, 0.07351200f, -0.00084690f, -0.08267491f, 0.01373083f, -0.07922109f, 
    0.04050624f, -0.08426257f, 0.03427564f, -0.02037775f, -0.00982997f, 0.00415058f, -0.09701793f, 0.11222440f, 
    -0.04886286f, 0.05678000f, -0.00581238f, -0.06903981f, 0.25771311f, -0.24522944f, 0.23969260f, 0.01037320f, 
    -0.04984614f, -0.02949172f, 0.06611703f, -0.05965259f, -0.14712590f, -0.04848894f, 0.02706871f, 0.13214573f, 
    -0.02629928f, 0.08610588f, -0.09799688f, -0.12059261f, -0.08445850f, 0.00557078f, 0.04853598f, -0.03520513f, 
    0.27658814f, -0.00459571f, 0.03810469f, 0.00002969f, 0.24742930f, -0.02461875f, -0.12494296f, 0.02005196f, 
    0.00135528f, -0.05175621f, -0.08408451f, 0.02019296f, -0.04222228f, -0.00900366f, -0.01665809f, -0.04628881f, 
    0.06459365f, -0.02959185f, -0.04386484f, -0.01765609f, 0.19384998f, 0.05007298f, 0.31322396f, 0.02896152f, 
    0.09868349f, 0.13949434f, 0.07534061f, -0.00338461f, -0.01202091f, 0.01267529f, -0.07994631f, 0.05852987f, 
    0.00168971f, -0.04004211f, -0.08824469f, -0.02365457f, -0.00670636f, -0.01874190f, 0.10914428f, 0.00961112f, 
    0.23060462f, 0.10224160f, 0.30424565f, -0.00079731f, 0.18977462f, -0.09231206f, 0.09780253f, -0.01810626f, 
    -0.01570519f, 0.02602660f, -0.01398869f, -0.02363120f, -0.05408146f, 0.00178938f, -0.06257378f, -0.06328734f, 
    -0.09711178f, -0.00678739f, 0.08949141f, -0.06865718f, -0.19844562f, 0.22986372f, 0.10920208f, -0.07344139f, 
    -0.15148719f, 0.00191722f, -0.00148810f, -0.06873316f, 0.05212070f, -0.03173982f, 0.01164245f, 0.02220289f, 
    -0.05576809f, 0.00561319f, -0.13531271f, 0.13051990f, -0.00141521f, -0.01924509f, -0.01248339f, -0.01135825f, 
    0.12065102f, -0.12025161f, -0.20113839f, -0.20664775f, -0.20025301f, -0.01496124f, -0.02593653f, 0.03431373f, 
    -0.05197302f, -0.10458112f, 0.00328620f, -0.03996493f, -0.08411989f, -0.07208746f, -0.17466368f, 0.03540815f, 
    -0.06658611f, -0.05473106f, -0.07987060f, 0.01961656f, 0.13581128f, -0.04606913f, -0.09645582f, -0.02733103f, 
    -0.06823941f, -0.00922613f, -0.08604228f, -0.06009535f, -0.04990257f, -0.00358695f, -0.02747609f, 0.03845255f, 
    -0.01455052f, 0.00648389f, -0.00843714f, 0.06004874f, -0.07790145f, -0.05457812f, -0.03306014f, 0.00018921f, 
    0.03987586f, 0.27879164f, 0.05797601f, -0.04520533f, 0.16700016f, -0.13792695f, 0.08479706f, -0.11744452f, 
    -0.04837269f, -0.04233813f, -0.11973528f, 0.04846726f, -0.14229290f, -0.02998603f, -0.01991571f, -0.01102530f, 
    0.00785820f, 0.06030077f, -0.04725917f, -0.06574481f, 0.08065142f, -0.51437938f, 0.03280702f, -0.07249897f, 
    -0.25083983f, -0.03136946f, 0.02767430f, 0.04024431f, 0.00098952f, -0.03576469f, -0.07057825f, -0.04758467f, 
    -0.11071153f, -0.02842083f, -0.02673416f, -0.04931466f, -0.01187530f, 0.04554894f, -0.01717399f, -0.05229583f, 
    -0.01681974f, 0.07819781f, -0.04643012f, 0.09325939f, 0.25634962f, 0.07820045f, -0.07799523f, -0.13225392f, 
    0.00051730f, -0.06816969f, 0.02941152f, 0.02450106f, -0.04142522f, -0.02798541f, -0.10397146f, 0.02935601f, 
    -0.07203255f, -0.04611955f, 0.00959149f, -0.03163790f, -0.06130973f, -0.27311045f, -0.08466629f, -0.20322652f, 
    -0.28751647f, -0.07080490f, -0.00473773f, 0.07039494f, -0.04678155f, -0.00627710f, 0.05538107f, -0.05896990f, 
    -0.00832110f, -0.05475592f, -0.01228596f, -0.00110888f, -0.06011122f, -0.00199024f, -0.03217928f, 0.04709807f, 
    -0.09468813f, -0.12857591f, -0.20070833f, -0.01794833f, 0.11628098f, -0.11916365f, -0.15698014f, -0.15380180f, 
    0.03862086f, -0.05303213f, -0.08278179f, -0.02314206f, 0.03923919f, -0.04849672f, -0.09855036f, -0.09235720f, 
    0.01789968f, 0.02962268f, 0.02358713f, 0.10435811f, -0.04766268f, 0.10322656f, 0.28846034f, 0.13143432f, 
    0.25112459f, 0.04353061f, 0.13633835f, 0.02058221f, 0.03650035f, -0.04345639f, 0.02572366f, 0.05162624f, 
    0.04387338f, -0.04578277f, -0.05124393f, -0.04920733f, -0.01622340f, -0.03469986f, -0.03978859f, -0.00842349f, 
    0.17162798f, 0.00698636f, 0.03197832f, 0.17068850f, 0.22137451f, 0.00785559f, -0.04521269f, -0.03933612f, 
    -0.07061016f, 0.01595941f, -0.03015663f, 0.09776603f, -0.06495007f, 0.03057654f, -0.03171502f, -0.03729801f, 
    0.02390233f, -0.02017324f, -0.00779107f, -0.00835203f, 0.16292103f, 0.19710304f, -0.16055304f, 0.25857863f, 
    0.07735755f, 0.02724200f, 0.06656617f, -0.12054034f, -0.02075314f, -0.04773691f, 0.01157279f, 0.11700268f, 
    -0.03410446f, -0.07518819f, -0.07830869f, 0.02575806f, -0.12837934f, -0.10646851f, 0.02516435f, -0.06497106f, 
    -0.02213955f, 0.24407001f, -0.02336747f, -0.00093224f, 0.10011774f, 0.07492071f, 0.03053209f, -0.06081527f, 
    0.03668873f, 0.01103290f, 0.01502871f, -0.00734295f, 0.00611248f, -0.12008807f, -0.00627357f, 0.03212161f, 
    -0.10653850f, 0.03016467f, 0.06324741f, -0.10520835f, 0.03702165f, 0.01315066f, -0.07066852f, -0.03225870f, 
    -0.05918521f, 0.00977118f, -0.06690730f, -0.04987942f, -0.02924545f, -0.08112331f, -0.04366229f, -0.00411261f, 
    -0.05091797f, 0.03218065f, -0.12206405f, 0.00489281f, -0.00192215f, -0.07018261f, -0.03956914f, -0.01734220f, 
    0.11332953f, 0.07914564f, 0.32519087f, 0.14237063f, 0.13515350f, 0.00520180f, 0.15643501f, 0.07538142f, 
    0.05374616f, -0.01932469f, 0.02138139f, 0.02140967f, 0.00466744f, 0.00674452f, -0.08349496f, -0.08477590f, 
    0.02434399f, 0.06247919f, 0.01856795f, -0.03440687f, -0.02060998f, -0.48820937f, -0.09528837f, -0.10748316f, 
    -0.20707181f, -0.03620803f, -0.10885116f, -0.02236947f, -0.05758365f, -0.11227684f, -0.02004851f, -0.06997147f, 
    -0.08925064f, -0.05919510f, -0.00925371f, -0.02510698f, 0.00509538f, -0.03031893f, -0.03954616f, -0.00080907f, 
    0.18207990f, -0.23599474f, -0.13239180f, 0.15097283f, 0.21648820f, -0.06300493f, 0.00557902f, 0.04499130f, 
    -0.00175725f, 0.00471178f, -0.06875506f, -0.02545049f, -0.04850396f, 0.07766651f, 0.04245289f, -0.00202638f, 
    0.02518456f, 0.02000214f, -0.03131107f, 0.00241783f, -0.20242535f, -0.05298883f, -0.23568565f, 0.01640818f, 
    0.02258107f, -0.09409892f, -0.02573956f, -0.11988539f, 0.04188743f, -0.08842048f, -0.03094980f, 0.10127433f, 
    -0.11488573f, -0.08499297f, -0.06866193f, -0.02512743f, -0.14378047f, 0.00033640f, -0.11939368f, 0.00619167f, 
    0.21851793f, 0.13396296f, 0.01349182f, 0.07622741f, 0.22282614f, -0.05640967f, 0.03951607f, -0.00600012f, 
    -0.02126212f, 0.00757396f, -0.03982100f, 0.15313756f, -0.02073638f, 0.00519876f, -0.00447163f, -0.10089885f, 
    -0.01572876f, 0.04743990f, 0.06392892f, -0.01439951f, -0.13219601f, 0.07159396f, -0.13361564f, -0.04883728f, 
    0.01261493f, -0.09115360f, -0.06368139f, -0.11822171f, -0.02567616f, -0.01393904f, 0.03849484f, 0.01843444f, 
    -0.08265594f, -0.00643992f, -0.02792938f, 0.03131083f, -0.10927428f, -0.01477704f, -0.01036818f, -0.03168957f, 
    0.02577559f, 0.09050336f, -0.12187090f, 0.00062544f, 0.07984039f, 0.07584873f, -0.01175564f, 0.00507046f, 
    -0.09272677f, 0.07757142f, 0.10332347f, 0.06841324f, -0.03028492f, 0.09853975f, 0.07567983f, 0.01419209f, 
    -0.00634941f, -0.03078588f, -0.03145515f, 0.05254862f, -0.08988757f, -0.13295674f, -0.01705141f, 0.05253908f, 
    0.18545341f, 0.10414007f, 0.08042105f, -0.12349329f, -0.05612170f, -0.04480755f, 0.00913002f, 0.01261448f, 
    0.03554289f, -0.01854994f, -0.06580907f, -0.06955877f, 0.03814764f, 0.12472872f, 0.00486770f, -0.06572363f, 
    0.08393248f, -0.08362827f, 0.00536199f, 0.03601697f, 0.12600888f, -0.15537107f, -0.11803670f, -0.08921796f, 
    -0.04787396f, 0.11049324f, -0.05624127f, -0.14761370f, 0.02438750f, -0.15922995f, 0.05383720f, -0.00302586f, 
    0.04779458f, -0.08084370f, 0.11929755f, 0.00682272f, 0.03642820f, 0.11178766f, -0.17696975f, 0.06976103f, 
    0.13254946f, 0.11398887f, 0.06231284f, -0.12675899f, -0.01947968f, -0.02056427f, 0.11676314f, 0.02553152f, 
    0.08061797f, 0.00270903f, 0.08413728f, -0.05654717f, 0.01550121f, -0.00229726f, 0.12309463f, 0.00415768f, 
    -0.20394592f, 0.04811716f, 0.05198881f, -0.16814096f, -0.14103946f, -0.07851584f, -0.04332042f, -0.12350743f, 
    -0.09384101f, -0.20407967f, 0.07508257f, 0.02460007f, 0.02625150f, 0.03163334f, -0.05635884f, -0.02918605f, 
    0.16288835f, -0.03522309f, 0.01406932f, -0.05054563f, -0.05253991f, 0.11839286f, 0.05569872f, -0.05820675f, 
    -0.21785770f, -0.04442233f, -0.06553506f, 0.13429363f, -0.06444175f, 0.06817536f, 0.06253639f, 0.01019822f, 
    0.00690654f, -0.08774284f, 0.02863972f, -0.02015567f, -0.03295552f, -0.18309036f, 0.06882758f, -0.08212961f, 
    -0.05515858f, 0.17187148f, -0.52530921f, 0.08426701f, -0.11441267f, 0.02747518f, -0.08508737f, -0.25469276f, 
    -0.15265095f, -0.06519859f, 0.01994112f, 0.07719975f, 0.09262393f, -0.06315597f, -0.00949956f, 0.04489240f, 
    -0.15914465f, -0.16376461f, 0.10422052f, 0.00330220f, 0.11350740f, 0.16119741f, -0.18105400f, 0.04734234f, 
    0.12801428f, 0.09814098f, 0.05226992f, 0.02014961f, -0.03552560f, -0.00931585f, -0.08069024f, 0.04875989f, 
    0.00183793f, 0.06182571f, -0.02847421f, -0.05245076f, 0.06057525f, 0.06420419f, 0.06238756f, 0.03297605f, 
    0.10089733f, 0.00792509f, -0.18235812f, 0.11921053f, -0.02635564f, -0.02775218f, -0.06910270f, -0.06515343f, 
    -0.04455942f, -0.00846018f, 0.04546505f, -0.00821324f, 0.01702292f, 0.06479794f, 0.07842784f, 0.08101682f, 
    0.02059737f, -0.13044617f, 0.11342239f, -0.06320302f, 0.06603823f, -0.06773368f, 0.19214702f, 0.03784280f, 
    0.12447052f, -0.07753415f, 0.02824263f, 0.02767268f, 0.05021039f, -0.03730127f, 0.03759804f, -0.05998833f, 
    0.07172149f, 0.05854442f, 0.00610275f, 0.10555883f, -0.06988118f, -0.00870500f, 0.00899313f, 0.06673904f, 
    -0.22771563f, -0.19881850f, 0.07886261f, -0.21199727f, -0.04251512f, -0.02253437f, 0.01247483f, -0.06952363f, 
    -0.04198206f, -0.08000386f, 0.07547123f, 0.06500056f, 0.03264877f, 0.02774561f, 0.01606721f, 0.00631136f, 
    0.08854888f, 0.03137116f, -0.22412665f, 0.00566302f, -0.30308980f, -0.09932545f, 0.26542827f, -0.12124661f, 
    -0.01362143f, -0.00306097f, -0.00893999f, 0.00109970f, -0.10506452f, -0.06316976f, 0.05816056f, -0.04650797f, 
    0.03400227f, -0.05389313f, -0.00289223f, -0.03582033f, -0.09814005f, -0.02291630f, -0.17581043f, -0.01087319f, 
    -0.14912279f, 0.12990026f, 0.14494136f, -0.18370385f, -0.26901373f, -0.07835633f, 0.01204204f, -0.10824341f, 
    -0.07729921f, -0.09715435f, 0.03652641f, 0.00932627f, 0.05337075f, 0.06587264f, -0.02506833f, -0.01407695f, 
    -0.01838660f, -0.02396147f, -0.22396940f, -0.07411674f, 0.04828938f, 0.18249711f, -0.12427003f, 0.08056589f, 
    -0.02358671f, -0.01964342f, 0.01777850f, -0.20015703f, -0.01940137f, -0.06930219f, -0.02523475f, 0.00562972f, 
    0.06881976f, -0.12744108f, 0.02810898f, -0.05505566f, 0.01415992f, -0.05896407f, 0.19033000f, -0.11148810f, 
    0.21632759f, 0.22787452f, -0.06586489f, 0.07323531f, 0.18809336f, 0.05292416f, 0.02307095f, -0.07027239f, 
    -0.08128168f, -0.00607184f, 0.02876235f, 0.00547910f, -0.10803004f, 0.01405476f, -0.01124509f, -0.15005088f, 
    -0.00183879f, 0.06800448f, 0.05477550f, -0.05172363f, 0.11700157f, 0.08105536f, 0.08461007f, -0.05026768f, 
    0.18807170f, -0.01782353f, 0.02756751f, -0.07869667f, 0.01598086f, -0.05872624f, 0.06160330f, -0.04640079f, 
    0.02516167f, -0.04254548f, 0.02787626f, -0.05008747f, -0.00947317f, 0.05040416f, -0.00053908f, 0.02832381f, 
    -0.17239287f, 0.25170690f, 0.12327188f, -0.05845184f, -0.29519179f, -0.15784433f, -0.05632788f, -0.04367729f, 
    -0.03880929f, -0.00307590f, 0.11317803f, 0.05312311f, 0.02528688f, 0.00722576f, -0.00359551f, -0.04249659f, 
    0.02670568f, -0.08045460f, 0.07327149f, 0.05522152f, 0.07481921f, -0.15187322f, -0.33694714f, 0.08028506f, 
    0.12774564f, 0.15796736f, 0.00949798f, 0.01451874f, -0.06176604f, -0.05149562f, -0.05088144f, 0.00224166f, 
    0.01560114f, 0.00420622f, -0.03738461f, 0.05974282f, 0.01640294f, 0.01811835f, 0.08900378f, 0.02172795f, 
    -0.23142451f, -0.17437346f, -0.14200017f, -0.41802427f, -0.18288428f, 0.02284049f, -0.01385371f, -0.07745443f, 
    0.11068907f, -0.02572466f, 0.09230199f, 0.06948274f, 0.02438009f, -0.05197001f, 0.02500228f, -0.12304187f, 
    -0.05173395f, -0.00874494f, -0.14624907f, -0.05854125f, 0.19591670f, 0.14813161f, -0.13064045f, 0.04066923f, 
    0.13558942f, 0.03935811f, 0.05273452f, -0.19012675f, -0.00915690f, -0.05235104f, 0.05802020f, 0.05311828f, 
    -0.08898345f, -0.10746998f, -0.00464077f, -0.14589670f, -0.08139271f, 0.12058837f, 0.02502091f, -0.02932396f, 
    -0.02453580f, -0.05469085f, -0.28524306f, -0.23776430f, -0.02880012f, 0.08719376f, 0.04118914f, 0.01783613f, 
    0.01714901f, -0.17148799f, 0.05999436f, 0.11153651f, 0.02893794f, 0.06289841f, -0.02067657f, 0.12847348f, 
    0.11225113f, 0.02360506f, -0.03192388f, 0.00656002f, -0.09152789f, -0.13526531f, 0.22339021f, 0.06132872f, 
    0.14557239f, -0.08698451f, -0.10271659f, 0.01045032f, -0.06688387f, -0.00034693f, 0.04839631f, -0.03719697f, 
    -0.02594905f, -0.17054629f, 0.05749981f, 0.00473603f, -0.02915001f, 0.03740698f, 0.09798671f, 0.06020635f, 
    -0.10466558f, -0.26051816f, 0.04064932f, -0.18381532f, -0.01766711f, 0.02359001f, 0.05085967f, -0.07157321f, 
    -0.01179548f, -0.02398358f, 0.09339622f, 0.08928670f, 0.09083095f, 0.01652830f, -0.04831566f, -0.05745997f, 
    0.05618169f, 0.14232351f, -0.16766307f, -0.08936841f, -0.20202155f, -0.08915480f, -0.02009169f, -0.28218558f, 
    -0.09983933f, 0.01512648f, -0.00165734f, -0.12016524f, 0.03057045f, 0.00229430f, -0.03500536f, 0.06528957f, 
    -0.09720017f, 0.02758501f, 0.00609651f, -0.13899066f, -0.09798779f, 0.12531498f, -0.15353210f, -0.17071787f, 
    -0.29854777f, 0.19832285f, -0.01097417f, -0.15536778f, -0.22440977f, 0.06391793f, 0.00408427f, -0.02060980f, 
    0.15704739f, 0.00851050f, -0.02827382f, 0.02605622f, -0.07547031f, 0.15230420f, 0.04807153f, -0.04000937f, 
    -0.10441604f, -0.04549886f, 0.01124007f, -0.02125687f, -0.11237250f, -0.09297316f, 0.10759334f, -0.01290029f, 
    0.14533597f, 0.08961493f, 0.00052158f, -0.12362164f, 0.03122988f, -0.05527558f, 0.07649515f, 0.07102849f, 
    0.07456990f, -0.00942670f, 0.04188829f, -0.02687633f, 0.03024072f, 0.04051739f, -0.02128288f, -0.00684227f, 
    -0.08325553f, 0.05417385f, 0.14863037f, -0.01647692f, 0.14677052f, -0.03282597f, -0.10240834f, 0.07470207f, 
    0.00912843f, -0.02616321f, -0.04289300f, -0.04283012f, -0.26767826f, -0.12746546f, 0.07126213f, -0.01657584f, 
    0.00200038f, 0.03829575f, 0.06628391f, 0.00648759f, 0.10908376f, -0.20318840f, -0.13995031f, 0.17851865f, 
    0.12789065f, 0.10794466f, 0.05173724f, -0.10658406f, -0.02962087f, -0.01346754f, -0.08949271f, 0.04548496f, 
    -0.09397375f, -0.04856700f, -0.03033176f, -0.07814015f, -0.05548218f, 0.03346838f, 0.04324285f, -0.02444932f, 
    0.17706294f, -0.10366432f, -0.31133240f, -0.08173838f, -0.01080087f, 0.09119008f, 0.03278824f, -0.01145798f, 
    -0.03572840f, -0.02387152f, -0.01778772f, 0.07558861f, -0.01552543f, 0.08034263f, -0.04332940f, 0.02570482f, 
    0.01433572f, -0.00331610f, -0.04697863f, -0.01355092f, 0.09569425f, 0.14371537f, 0.15065829f, -0.00742062f, 
    0.03464283f, -0.15507865f, -0.03987867f, -0.02230867f, -0.14899315f, -0.08651996f, 0.04927503f, 0.00152199f, 
    -0.00833566f, 0.00727897f, -0.05809789f, -0.14240600f, 0.03155943f, -0.09857091f, 0.09126538f, -0.10227165f, 
    -0.27566394f, -0.18864520f, 0.05483815f, -0.20850000f, -0.11237034f, 0.12261140f, -0.01694972f, -0.01819664f, 
    -0.06670354f, 0.03967401f, 0.05574249f, 0.01332198f, -0.00044266f, 0.12821555f, -0.11725612f, 0.02735923f, 
    0.03294933f, -0.01725606f, -0.30353656f, 0.03034465f, 0.03724425f, 0.18116696f, -0.03864854f, 0.07108368f, 
    0.05724426f, 0.09556184f, -0.07951144f, -0.06144954f, -0.10386304f, -0.08385798f, 0.17892452f, -0.04808521f, 
    -0.03009426f, -0.03481062f, -0.03256663f, -0.06002935f, 0.08714920f, 0.08198105f, -0.00664689f, -0.00358956f, 
    -0.38160029f, -0.19372542f, 0.05350858f, 0.11513199f, -0.35462064f, 0.08653504f, 0.01730219f, -0.10612271f, 
    0.04047953f, 0.07778889f, 0.00187273f, -0.07014158f, 0.04599969f, 0.03758037f, 0.20952536f, 0.01792368f, 
    0.01274672f, -0.06529904f, 0.06501763f, 0.09036675f, 0.02375764f, -0.21898465f, 0.15136625f, 0.01036878f, 
    -0.32111999f, -0.00615737f, 0.06391767f, 0.07687490f, -0.04173154f, -0.00459581f, -0.09418507f, -0.12187908f, 
    -0.05505260f, -0.09497573f, -0.06239797f, -0.05319336f, -0.04039969f, -0.05015885f, -0.08067638f, -0.09206800f, 
    0.18035856f, -0.43932223f, -0.00273901f, -0.05321284f, 0.22151165f, 0.08460543f, -0.02624941f, -0.00637416f, 
    0.07206680f, 0.13980484f, -0.10375559f, 0.06069658f, 0.08329925f, 0.22220394f, -0.03392252f, -0.09103405f, 
    -0.06345654f, -0.02161342f, -0.19877054f, -0.06637479f, -0.10305026f, 0.21275094f, 0.18045357f, -0.34109509f, 
    -0.34532061f, -0.00167744f, 0.11496258f, -0.01785931f, -0.09666247f, 0.03022484f, 0.02331303f, -0.10738782f, 
    0.05752737f, -0.24386406f, 0.11314321f, 0.03343576f, 0.10515191f, -0.04269124f, -0.24184838f, -0.02981963f, 
    0.20732763f, -0.16300192f, -0.33397251f, -0.10884359f, -0.31052691f, 0.02646297f, 0.06567811f, 0.00768482f, 
    0.07446378f, -0.10520594f, -0.10332169f, -0.12505130f, -0.04258393f, 0.05545625f, 0.08113810f, -0.01149758f, 
    0.09212849f, -0.00530002f, 0.05516474f, 0.11464734f, -0.58657217f, 0.19382532f, 0.23289140f, 0.04602153f, 
    -0.03378369f, 0.28611195f, -0.01883961f, -0.11338528f, 0.08600406f, 0.15288892f, -0.09170096f, 0.00524917f, 
    -0.09607922f, 0.11719053f, 0.09409700f, 0.08194162f, -0.07588036f, 0.12932347f, -0.27672160f, 0.10646622f, 
    -0.04306577f, -0.18669464f, 0.31900963f, -0.12006690f, 0.13053980f, -0.10038847f, 0.07754469f, 0.03673925f, 
    0.10602089f, -0.19277698f, -0.10218968f, -0.09530620f, -0.10060769f, 0.03263595f, -0.17897087f, 0.00041101f, 
    0.03143165f, 0.12358453f, -0.09569991f, 0.11164833f, -0.06834368f, 0.18331717f, 0.08924492f, 0.00287008f, 
    -0.19117360f, 0.05697568f, 0.04705943f, -0.01873309f, -0.05888143f, -0.03174575f, -0.08726829f, 0.04993534f, 
    -0.04821300f, 0.01524910f, 0.01824975f, 0.06767499f, -0.07725418f, 0.14722739f, -0.03954671f, 0.02002913f, 
    -0.65624821f, 0.15172817f, 0.00707074f, 0.03555084f, 0.21828654f, 0.11675975f, 0.04577750f, -0.10996154f, 
    -0.00331971f, 0.11101735f, 0.08221784f, -0.08054191f, -0.05954697f, 0.01403743f, -0.02059568f, 0.09083007f, 
    -0.02736212f, 0.04461066f, -0.02981849f, 0.05647209f, 0.10444711f, -0.20604491f, -0.10126697f, 0.11749324f, 
    -0.04374494f, 0.07109677f, -0.03422928f, -0.16329896f, -0.02238148f, 0.05055215f, -0.02752608f, 0.08472890f, 
    -0.11113050f, -0.17463614f, 0.05829222f, -0.07194471f, -0.00332816f, -0.03545585f, -0.03051131f, 0.13497835f, 
    0.09762067f, -0.08606128f, -0.10190555f, -0.02727047f, -0.09801130f, 0.00703744f, -0.02245354f, 0.06865809f, 
    -0.02636237f, 0.02778334f, -0.07351462f, 0.06790262f, 0.12047580f, -0.02777203f, -0.04371352f, 0.17794995f, 
    0.06886172f, 0.08145379f, -0.02387933f, 0.13830373f, 0.13112693f, -0.37594819f, -0.05510478f, 0.22443041f, 
    0.06086830f, -0.12502515f, -0.02990628f, -0.13472369f, 0.07802621f, 0.05816180f, -0.14020781f, 0.14425929f, 
    -0.05366463f, -0.06548616f, 0.01063092f, 0.00025277f, 0.08611172f, 0.03155182f, 0.13706218f, 0.02758313f, 
    -0.39852670f, -0.25374874f, -0.11426547f, 0.12848879f, 0.13740583f, -0.08967272f, 0.07741764f, -0.04524539f, 
    -0.18253560f, 0.03345885f, 0.04175817f, 0.10624838f, -0.13856111f, 0.02014232f, 0.02781049f, -0.10111235f, 
    -0.00547637f, -0.02471663f, 0.15971407f, 0.07831402f, -0.36670277f, -0.03387836f, 0.49078462f, -0.32142454f, 
    0.16368659f, 0.04898128f, 0.03725075f, 0.08522573f, 0.04871616f, -0.08932461f, 0.03095597f, 0.02325789f, 
    0.10409739f, -0.00484457f, 0.22625378f, -0.02674177f, 0.01930789f, 0.08319259f, -0.30498698f, 0.07217538f, 
    0.23710452f, 0.05605460f, 0.02236971f, -0.03116051f, -0.10558635f, 0.05096420f, 0.09486984f, -0.00708231f, 
    0.07858967f, -0.17017914f, -0.04820863f, 0.05429853f, -0.01712760f, -0.05289994f, 0.04266548f, -0.00531575f, 
    0.08086268f, -0.08173463f, 0.06246352f, 0.00259623f, -0.01909022f, -0.09160950f, 0.04411691f, -0.16381320f, 
    -0.03752654f, 0.02608289f, -0.03488782f, -0.11876784f, -0.03613614f, -0.09676246f, -0.00903017f, -0.06710894f, 
    -0.00195836f, 0.18610610f, -0.08580504f, 0.02805101f, 0.05978885f, -0.07621437f, -0.13016969f, -0.22711259f, 
    -0.33441672f, 0.22977532f, -0.08916699f, 0.22827996f, -0.16170318f, 0.15110244f, 0.09112917f, -0.09065492f, 
    0.02338138f, 0.02833345f, -0.13738376f, -0.07128630f, 0.01359388f, -0.02232623f, 0.21131867f, 0.08059356f, 
    -0.01642291f, -0.01757898f, -0.10020250f, -0.04075115f, 0.05224227f, -0.33990401f, 0.21614905f, -0.13006662f, 
    -0.13805702f, 0.00742487f, -0.00238643f, -0.12216068f, -0.04967036f, 0.04411065f, -0.00395585f, -0.04498238f, 
    0.00491180f, -0.02092541f, -0.07929341f, 0.01609509f, -0.08209101f, 0.03096675f, -0.00492403f, 0.07954770f, 
    -0.06506801f, -0.01417446f, 0.21829727f, -0.16545075f, -0.14584731f, -0.24357149f, -0.03785961f, -0.08410745f, 
    0.02228887f, 0.12090883f, 0.04971584f, 0.10937922f, 0.06858229f, -0.02567911f, 0.02553503f, -0.00918058f, 
    0.11400954f, -0.05878911f, 0.05653943f, -0.09253658f, 0.06505524f, -0.01684226f, -0.16881023f, 0.21420094f, 
    -0.14461944f, 0.02304802f, 0.04333745f, 0.14459109f, 0.09225808f, -0.21077216f, 0.14407822f, -0.03265693f, 
    -0.01490363f, -0.07764681f, -0.04798971f, 0.03123560f, -0.03710792f, 0.01086950f, -0.03066026f, 0.02540633f, 
    -0.19819558f, 0.11136233f, 0.00663711f, -0.41700530f, -0.33315656f, -0.11458866f, 0.06422259f, 0.01999156f, 
    0.08380228f, 0.05669288f, -0.05627973f, 0.05648055f, -0.06019375f, -0.12960093f, -0.02843657f, -0.05247196f, 
    -0.07625330f, -0.01243094f, 0.14375682f, -0.00996274f, 0.48304111f, -0.11707716f, -0.13002177f, -0.06141045f, 
    0.19675978f, 0.15517740f, -0.14383253f, -0.02472990f, -0.07999474f, 0.19133085f, -0.03395395f, -0.01739545f, 
    0.04401926f, 0.05936169f, -0.08251026f, -0.03257093f, -0.03998349f, -0.14504363f, 0.02320155f, -0.10036642f, 
    0.25131011f, -0.24270514f, 0.04525929f, -0.12448319f, 0.03374942f, -0.04783889f, -0.08590224f, -0.06310724f, 
    0.06913624f, -0.05296255f, -0.05817272f, -0.08977953f, 0.12814717f, -0.07705083f, -0.17070396f, 0.02667845f, 
    0.05623547f, 0.13684069f, -0.08141618f, 0.03179258f, 0.49949458f, 0.11734906f, -0.01403471f, -0.13660958f, 
    -0.15322517f, -0.23053753f, -0.15049770f, 0.10417759f, 0.14073578f, 0.03541312f, -0.04072340f, 0.04520731f, 
    0.13919953f, -0.12507811f, 0.19435436f, 0.15071259f, -0.01405547f, 0.14597216f, 0.03272831f, 0.15873231f, 
    -0.01843212f, -0.12519152f, 0.24743187f, -0.09354645f, -0.19319412f, -0.18857752f, 0.01533339f, 0.15613545f, 
    0.13391812f, -0.01437353f, 0.00760490f, 0.00464985f, 0.11568274f, 0.12858273f, 0.05168742f, 0.02843683f, 
    0.07115938f, -0.02924153f, 0.09813110f, -0.15905438f, -0.01553562f, -0.39866993f, 0.07181692f, -0.12504894f, 
    -0.12087802f, 0.00875561f, 0.11405388f, -0.17021815f, -0.00826380f, 0.04159754f, -0.04340103f, 0.01383033f, 
    0.03596629f, 0.08253877f, -0.08943678f, 0.00249697f, 0.10333149f, -0.19909075f, -0.17889218f, -0.10104822f, 
    -0.05825790f, 0.01914913f, -0.10376178f, 0.12037876f, -0.03257253f, 0.00531583f, 0.05111244f, -0.07129623f, 
    -0.02163532f, 0.07030417f, -0.04281618f, -0.12871248f, 0.14001782f, 0.04438217f, 0.11367775f, -0.00478701f, 
    -0.14549877f, -0.00800827f, 0.00789214f, 0.02526719f, 0.10215644f, -0.28007600f, 0.24727781f, 0.06269431f, 
    -0.12949318f, 0.14022188f, 0.06503674f, -0.05281303f, -0.10887296f, -0.05048755f, -0.08990628f, 0.03848540f, 
    -0.05432227f, -0.02540948f, 0.03636156f, -0.03784908f, 0.00610352f, -0.04664047f, -0.01161385f, -0.02077888f, 
    0.08591773f, -0.05021336f, 0.13928461f, -0.34618890f, -0.21482484f, 0.05596954f, -0.00261813f, -0.02028823f, 
    -0.03865239f, -0.02255308f, -0.04010572f, -0.07560971f, 0.06881668f, 0.13760521f, 0.05100572f, -0.14865480f, 
    0.08814273f, 0.11079743f, 0.12899357f, -0.00882164f, 0.41484126f, 0.11420435f, -0.27004164f, -0.02674127f, 
    -0.18671092f, 0.03934802f, 0.11785197f, 0.08450158f, 0.14409463f, 0.00881149f, -0.11006910f, 0.05101763f, 
    -0.03687181f, 0.13279630f, -0.02605806f, 0.15924156f, 0.06752740f, 0.07470921f, 0.01354547f, -0.01462700f, 
    0.28552553f, -0.13117698f, -0.09864719f, -0.02052706f, 0.00305312f, -0.01293771f, 0.08205646f, 0.12688729f, 
    -0.15672049f, -0.17703821f, 0.10858631f, -0.02075065f, -0.08830266f, -0.09843421f, 0.05559602f, -0.02794995f, 
    -0.09136727f, -0.17828153f, 0.35132745f, 0.05090369f, 0.43488565f, -0.05738024f, -0.20897210f, 0.15253647f, 
    -0.05719705f, 0.09968567f, 0.06072437f, 0.18236318f, 0.02253017f, -0.12611824f, -0.06401298f, -0.00216942f, 
    0.08575028f, 0.09378093f, -0.03735409f, -0.03409099f, 0.05198485f, -0.13017982f, 0.01577809f, 0.06046244f, 
    0.03216479f, -0.01788586f, -0.19229725f, 0.07555642f, 0.19043100f, 0.00265968f, -0.02074435f, 0.01482014f, 
    0.01415228f, 0.01236053f, 0.04815202f, -0.01244909f, -0.08342181f, -0.07149411f, 0.01748014f, -0.00605428f, 
    0.03462338f, 0.10556373f, -0.02403561f, 0.15546046f, -0.63141525f, -0.08480971f, 0.05624989f, -0.12070481f, 
    -0.23417012f, 0.15142930f, -0.03644902f, -0.01856217f, -0.07285025f, 0.03675338f, 0.02087949f, 0.02265301f, 
    -0.02868412f, 0.22035849f, 0.07530278f, 0.05761666f, -0.06660514f, 0.04535828f, -0.05722963f, -0.04130075f, 
    0.22112249f, 0.19130372f, -0.38554537f, 0.12039717f, -0.05790832f, -0.14999233f, -0.18277203f, -0.02175318f, 
    -0.08095270f, -0.08695485f, 0.01967517f, -0.01389454f, -0.00290123f, -0.21074559f, 0.03278954f, -0.12357847f, 
    -0.03055774f, 0.09788391f, -0.01163784f, -0.08876701f, -0.80191308f, -0.57194149f, -0.21874911f, -0.20817652f, 
    -0.03398607f, 0.06652062f, -0.03063119f, -0.02387981f, -0.07169136f, -0.03991465f, 0.05474855f, -0.02138613f, 
    0.03037190f, 0.07571654f, 0.02987745f, 0.05759001f, -0.08499929f, -0.03166033f, 0.01681742f, -0.02908553f, 
    -0.29318801f, -0.16546054f, 0.18475384f, 0.00260808f, -0.21978995f, 0.10823021f, -0.10971785f, 0.09042718f, 
    -0.09423412f, 0.11325743f, 0.02495900f, 0.07806228f, 0.04286694f, -0.02724329f, 0.06778286f, -0.05300127f, 
    -0.09872320f, -0.19526920f, -0.15056224f, -0.06286602f, -0.04033197f, 0.09609158f, -0.01981879f, 0.13095824f, 
    -0.04248467f, 0.05550794f, -0.00282988f, 0.13255699f, -0.02506267f, 0.01925713f, 0.04491952f, -0.02680170f, 
    -0.02507753f, -0.06677608f, 0.07733986f, 0.11973488f, -0.02746215f, 0.03874259f, 0.16950938f, -0.10384776f, 
    -0.34157515f, -0.25663885f, -0.07539179f, 0.25994679f, 0.08675147f, -0.00152075f, 0.06990398f, -0.13537462f, 
    0.05328377f, 0.02146937f, 0.04595526f, 0.08851665f, 0.06531596f, -0.04617590f, 0.27240559f, -0.01578765f, 
    -0.10202910f, -0.11654913f, -0.03594724f, -0.12722647f, -0.38761067f, -0.44593838f, -0.17677338f, -0.13444154f, 
    -0.02096196f, 0.12914544f, -0.01307658f, -0.03740581f, -0.01157192f, 0.00232004f, 0.14657077f, 0.00084473f, 
    0.03415505f, 0.04900313f, -0.01383371f, 0.07760273f, 0.04007922f, 0.11084217f, 0.13879724f, 0.10282469f, 
    -0.02734547f, 0.01887341f, -0.14599162f, 0.01846179f, -0.19985566f, 0.06283960f, 0.04800445f, 0.06360024f, 
    0.05483912f, 0.04771784f, 0.10718688f, 0.02477576f, 0.00807204f, 0.00926396f, -0.01610621f, -0.00632705f, 
    -0.02359565f, -0.06083535f, 0.10477931f, 0.02718615f, 0.06768707f, 0.09544040f, -0.15461700f, -0.13823117f, 
    -0.00155335f, -0.08318463f, 0.10354996f, 0.07213853f, 0.05012800f, 0.00992144f, -0.07055970f, -0.01580568f, 
    -0.04172652f, -0.09737074f, 0.00804327f, -0.00921442f, 0.14027219f, 0.04986954f, -0.01740275f, 0.19428642f, 
    -0.04173814f, 0.21916968f, 0.06909182f, -0.01806296f, -0.09630450f, 0.03428122f, 0.02161425f, 0.03821611f, 
    0.01411268f, 0.00262339f, -0.04027545f, 0.08820228f, 0.03139877f, 0.04692603f, 0.02358252f, 0.07347440f, 
    0.09691046f, -0.08154691f, -0.13464549f, 0.09144669f, 0.15960452f, -0.03652352f, -0.03620807f, 0.08965153f, 
    -0.01058906f, 0.00730392f, 0.07100219f, -0.01266791f, 0.06796347f, -0.00812865f, 0.03259826f, 0.12234484f, 
    -0.02922916f, 0.02786538f, -0.03564674f, -0.00332921f, 0.09722760f, -0.09693936f, -0.28923953f, -0.01593957f, 
    0.20528033f, 0.09074771f, -0.07292721f, 0.03682414f, -0.22259240f, 0.08716431f, 0.05199065f, 0.04376670f, 
    0.07025233f, 0.02864509f, -0.04046233f, -0.03732565f, 0.02340938f, 0.07732318f, -0.03103260f, 0.10336148f, 
    0.07635042f, -0.25511864f, -0.09461681f, 0.05569577f, -0.61541241f, -0.34710899f, -0.21442215f, -0.12062856f, 
    0.14171645f, 0.01375743f, -0.06424972f, -0.05030705f, -0.11343431f, -0.13237007f, 0.08137453f, 0.05078546f, 
    -0.09740673f, -0.00269834f, 0.09505131f, -0.04545847f, 0.00323218f, 0.09478874f, 0.10787117f, 0.04526094f, 
    -0.48663157f, -0.37578952f, -0.10956907f, -0.25706387f, -0.26865724f, 0.03751343f, 0.08529531f, -0.04952713f, 
    -0.04568922f, 0.09792078f, -0.02504621f, 0.04151048f, -0.06820007f, 0.04899972f, 0.07700812f, -0.05722841f, 
    0.03691812f, 0.11060563f, 0.12563740f, 0.04259120f, -0.54075783f, -0.04118357f, -0.01901677f, -0.16476548f, 
    -0.02214699f, 0.04841235f, 0.04820131f, -0.04608965f, -0.02349349f, 0.08014434f, 0.05221143f, -0.05706845f, 
    0.00526786f, -0.09289475f, 0.05798462f, -0.06937692f, -0.06777805f, 0.15711719f, 0.01627448f, 0.11021649f, 
    -0.16296211f, -0.12784834f, 0.07240310f, 0.05204699f, 0.12255554f, 0.03716070f, 0.04457973f, 0.08158514f, 
    0.06567289f, 0.04020850f, 0.12590942f, -0.06069510f, 0.06083466f, 0.04019075f, 0.03366637f, 0.02552205f, 
    0.02261514f, -0.06037533f, 0.11841865f, -0.02701033f, -0.46057874f, -0.09775656f, -0.19363970f, -0.10373269f, 
    -0.10422588f, 0.05671479f, 0.04508754f, -0.02690309f, -0.05010056f, 0.14024055f, -0.02797830f, 0.02262386f, 
    -0.04812942f, 0.11566847f, 0.06218619f, 0.12677661f, -0.08092357f, 0.16155748f, -0.07574198f, 0.09762796f, 
    0.28038710f, 0.15552686f, 0.24488664f, 0.20854196f, -0.00672654f, 0.10051092f, -0.04852178f, 0.09644369f, 
    0.02016017f, -0.00168596f, -0.02848919f, 0.00283765f, 0.00279944f, -0.04355628f, -0.18229692f, 0.00069977f, 
    -0.04573736f, -0.32670233f, -0.05900976f, -0.08917338f, -0.27768943f, -0.29885924f, -0.05445804f, -0.17725474f, 
    0.03975602f, 0.04737492f, 0.04294910f, -0.10801728f, -0.02293148f, -0.05631798f, 0.01896315f, -0.09673503f, 
    -0.07366370f, -0.02952167f, 0.06936192f, -0.08467304f, 0.05201812f, 0.06147184f, 0.05881498f, 0.06619991f, 
    0.06510860f, 0.09119784f, 0.26718774f, -0.01470884f, -0.03456564f, 0.15872343f, 0.03701934f, -0.06939948f, 
    0.03276422f, -0.03359199f, -0.03912024f, 0.07395491f, 0.07762881f, 0.15981269f, 0.04533736f, 0.07043192f, 
    0.11480936f, -0.04325018f, -0.08232930f, -0.01149025f, 0.28931150f, 0.16775888f, -0.11296070f, 0.07723901f, 
    -0.00476803f, -0.11553568f, -0.17669907f, 0.02437389f, 0.01275152f, -0.05803062f, -0.00289576f, -0.04443166f, 
    -0.02849681f, -0.07072034f, -0.10025349f, 0.00690344f, -0.05604030f, 0.11334004f, -0.11198089f, -0.00128533f, 
    -0.13233915f, 0.23293173f, 0.03358541f, 0.02508334f, -0.11000939f, 0.04029702f, -0.00463607f, -0.04388405f, 
    -0.02678200f, 0.02524918f, -0.05967783f, 0.02853396f, -0.02886160f, -0.03864510f, -0.01825663f, 0.04481145f, 
    -0.11840016f, -0.27817163f, -0.15071666f, -0.03860077f, -0.34285235f, 0.15513948f, 0.12083659f, 0.05675691f, 
    0.17624435f, 0.08215603f, -0.15938678f, -0.03510736f, -0.04060540f, -0.00107202f, -0.16033605f, 0.10248338f, 
    -0.05632756f, -0.02359298f, -0.08097037f, -0.02294182f, 0.00906640f, -0.17387082f, -0.13608110f, 0.10677119f, 
    0.09700800f, -0.08868256f, 0.05597169f, -0.11303346f, 0.25376102f, 0.11943934f, 0.05828640f, 0.03807881f, 
    0.05007261f, -0.11184969f, 0.01054131f, -0.02061660f, -0.01140561f, 0.05607273f, -0.00693487f, 0.00458999f, 
    0.18099013f, 0.01599753f, 0.00515572f, 0.12326044f, -0.61273420f, 0.04866937f, -0.05920346f, -0.08152568f, 
    -0.08659928f, 0.16475624f, 0.01014202f, -0.03237329f, -0.06241868f, 0.03397889f, 0.04571149f, -0.04947094f, 
    -0.05535873f, -0.09778000f, 0.11426575f, -0.04828077f, -0.09552259f, -0.01706140f, -0.06978817f, -0.01250982f, 
    0.33985293f, -0.03535659f, 0.01117528f, -0.01690049f, -0.04685076f, -0.29894644f, -0.10410817f, -0.10094194f, 
    0.05959029f, -0.06946807f, 0.00581763f, 0.00184470f, -0.11148325f, -0.17446302f, -0.12305050f, -0.09701917f, 
    0.02748960f, -0.03281981f, -0.05788693f, -0.03144990f, -0.68452549f, -0.29780793f, -0.21178196f, -0.10495241f, 
    -0.32909214f, 0.00550260f, 0.05654926f, -0.06530322f, -0.02156975f, 0.02217034f, 0.01290520f, -0.03022211f, 
    -0.08618101f, 0.01939157f, -0.04824587f, 0.07103350f, 0.03655376f, 0.03207841f, -0.00875983f, 0.08526436f, 
    -0.08391466f, 0.04934947f, 0.01208020f, -0.07427248f, -0.25564453f, -0.02973573f, -0.01938524f, 0.00855514f, 
    0.01732354f, 0.08599094f, 0.00103522f, 0.10137906f, 0.03208506f, -0.01822475f, 0.04673804f, 0.11641330f, 
    0.00668471f, 0.06669486f, -0.03265520f, 0.05666214f, -0.36196336f, -0.13362300f, 0.20714746f, 0.04596836f, 
    -0.14695394f, 0.07192388f, 0.08072756f, 0.05279293f, -0.01748960f, 0.09849046f, 0.02916524f, 0.00007386f, 
    0.06067263f, -0.01198844f, 0.06916501f, -0.00322819f, 0.01709383f, 0.09761899f, 0.18726537f, 0.06944929f, 
    0.21286283f, 0.23803091f, 0.17124353f, -0.21348575f, -0.13256720f, 0.25796255f, 0.00763867f, -0.00313184f, 
    0.06003421f, -0.11628257f, -0.10660343f, -0.06113153f, 0.04700833f, 0.04524509f, -0.00786276f, 0.09114730f, 
    0.12038132f, 0.14819883f, -0.09410967f, 0.12163350f, -0.07311817f, -0.10629866f, 0.07426729f, 0.09685543f, 
    0.11512785f, 0.02950852f, -0.08090026f, 0.07393483f, -0.06078816f, -0.02037313f, -0.02287037f, 0.01634005f, 
    0.05252581f, -0.06957308f, 0.04148341f, 0.00023008f, 0.13825639f, 0.16109473f, 0.11671158f, 0.07678318f, 
    -0.36031935f, 0.41768080f, -0.15031792f, 0.02587347f, 0.01611528f, 0.02645946f, -0.05872736f, 0.14395209f, 
    0.12505086f, 0.20500369f, 0.04913070f, 0.01517869f, 0.02422527f, -0.08088175f, 0.02684926f, 0.02061390f, 
    -0.00211797f, -0.07134002f, -0.07475697f, -0.31268394f, 0.49630311f, 0.25753501f, -0.28086993f, -0.24868128f, 
    -0.03012141f, -0.04809579f, -0.02720786f, -0.01623741f, 0.08517416f, 0.02633207f, 0.09822480f, -0.00026272f, 
    0.01801530f, -0.06157265f, 0.05187840f, -0.05749540f, 0.01487321f, 0.04129564f, -0.00114383f, 0.05705363f, 
    -0.20682892f, -0.34204122f, 0.09215451f, -0.04370544f, 0.03896008f, -0.08960610f, 0.16521522f, -0.04480977f, 
    0.08176164f, -0.01762097f, -0.18455325f, 0.00812924f, 0.19128212f, 0.16501851f, -0.05275342f, -0.07411926f, 
    0.01338041f, -0.03259835f, -0.32094693f, 0.03908388f, 0.46209797f, -0.08768550f, -0.27795455f, -0.02442940f, 
    -0.07025054f, 0.15488173f, -0.03988132f, -0.15764424f, 0.02115764f, -0.05922622f, 0.05361518f, 0.03445256f, 
    -0.02378199f, 0.05557172f, 0.03208520f, 0.03479614f, -0.02259691f, -0.09947212f, -0.00813929f, 0.02533014f, 
    -0.14217365f, 0.13563053f, -0.04671574f, -0.20008178f, 0.42202017f, 0.12839510f, -0.20931168f, -0.01598319f, 
    0.09788519f, 0.09987330f, 0.06145065f, 0.01201955f, 0.06824008f, 0.02263231f, 0.05877178f, 0.08566024f, 
    0.09000014f, 0.03633565f, -0.05363642f, 0.00939158f, 0.22356173f, -0.18050183f, 0.05161981f, 0.14316247f, 
    -0.13690630f, 0.03797609f, -0.10227370f, 0.09806494f, 0.06593609f, 0.02091585f, 0.04821838f, -0.05629056f, 
    0.06519810f, 0.08804787f, -0.00299635f, -0.07709357f, 0.07810242f, -0.02613682f, -0.11970975f, -0.11906096f, 
    0.10327306f, 0.16983065f, -0.18950422f, 0.11990548f, -0.38325250f, -0.17162441f, -0.00048308f, 0.02159518f, 
    0.01407965f, -0.06536849f, -0.05906859f, 0.00232304f, 0.07941627f, -0.00648286f, -0.07080726f, 0.15421504f, 
    0.16509095f, 0.01114966f, -0.09212643f, -0.11579173f, 0.27449065f, -0.17317586f, -0.02170668f, 0.00002653f, 
    -0.06076106f, 0.05546258f, 0.03882188f, 0.01023584f, -0.06375449f, 0.05592106f, 0.06038362f, 0.08928390f, 
    -0.00354048f, 0.01055834f, -0.00622547f, -0.02294360f, -0.07827871f, -0.08081523f, -0.05821311f, 0.07146917f, 
    0.17390130f, -0.27515441f, -0.04606634f, 0.04925513f, -0.15246940f, -0.10096072f, 0.02791917f, 0.06979144f, 
    -0.04405535f, 0.03305253f, -0.10736669f, 0.04318027f, -0.04803755f, -0.03164307f, -0.25821871f, -0.07269768f, 
    -0.01085489f, -0.04373829f, -0.11925156f, -0.12602171f, -0.38656834f, 0.27516517f, -0.02603086f, 0.05446866f, 
    0.09509782f, 0.01602446f, -0.02640384f, 0.02521265f, -0.12098666f, 0.14856458f, -0.03673623f, -0.02677004f, 
    0.07579944f, -0.15397288f, -0.01949266f, -0.02878974f, 0.05380947f, 0.03344157f, -0.04088884f, -0.10110217f, 
    -0.32985187f, 0.14593789f, -0.02273964f, -0.11374832f, 0.42156184f, -0.08330805f, -0.14324625f, 0.00829083f, 
    0.08435279f, -0.02344709f, 0.09198408f, 0.00564079f, 0.08259574f, 0.04495651f, -0.07356092f, -0.02019826f, 
    0.03928065f, 0.04180012f, 0.02352243f, 0.03814527f, -0.03162869f, 0.26393169f, 0.04391429f, -0.07037429f, 
    -0.11655524f, -0.06786347f, -0.09522693f, -0.10226270f, -0.15380503f, -0.26834825f, -0.00510502f, 0.00119977f, 
    0.08290669f, -0.15839693f, 0.02535069f, 0.05347232f, 0.07962573f, -0.03183560f, 0.07796256f, 0.00765477f, 
    -0.00525690f, 0.20363556f, -0.11879628f, -0.23746032f, 0.10041061f, -0.01853450f, -0.17783427f, 0.00254970f, 
    -0.09769934f, -0.14949492f, 0.02379292f, -0.09421284f, 0.01507428f, -0.04809936f, -0.06847249f, 0.03404315f, 
    0.00133717f, 0.03046246f, 0.11522987f, -0.03249662f, -0.15381098f, -0.08073834f, -0.03711987f, 0.15936691f, 
    -0.12240053f, 0.33048287f, 0.11514559f, 0.02842781f, 0.03439574f, 0.01896271f, -0.02246190f, -0.03987667f, 
    0.07001293f, 0.02452241f, 0.01275474f, -0.02218333f, 0.02429628f, -0.17378815f, -0.13188405f, 0.04993014f, 
    -0.09579687f, -0.51932371f, -0.08222441f, -0.28348169f, -0.29486513f, 0.12465192f, -0.00535688f, 0.07352825f, 
    -0.08468833f, 0.08721421f, 0.00916799f, 0.04184229f, 0.00915724f, -0.13693738f, -0.09690096f, -0.02133345f, 
    0.02603842f, 0.01221823f, -0.01097991f, -0.04523668f, -0.33266947f, -0.29846680f, 0.08601811f, -0.03579213f, 
    0.07864648f, -0.15902747f, 0.07138216f, -0.03441900f, 0.03484765f, 0.03126276f, 0.05492630f, -0.02675444f, 
    -0.03224020f, -0.08432757f, -0.05458727f, -0.13695547f, 0.04269508f, -0.08550234f, -0.01986624f, -0.03647485f, 
    -0.03487774f, 0.03001894f, 0.05262428f, 0.03616380f, 0.10454223f, 0.16195434f, -0.15572187f, -0.01909842f, 
    0.00578262f, 0.00477206f, 0.03309176f, 0.11779127f, -0.05913737f, 0.00393427f, -0.02138199f, -0.05283673f, 
    0.02323031f, 0.00400632f, -0.09255455f, 0.01186218f, 0.56412035f, 0.03916563f, -0.29367343f, 0.00963018f, 
    -0.10547811f, -0.03620446f, -0.04658020f, 0.01773228f, -0.01371139f, 0.03561728f, 0.06892304f, 0.07738001f, 
    0.01799246f, 0.04922092f, 0.04933227f, 0.05534959f, 0.01805745f, -0.01107870f, -0.02450430f, -0.02256574f, 
    0.14977217f, -0.01576180f, -0.16938980f, -0.10609372f, 0.02948568f, 0.02534870f, -0.06210837f, 0.08300734f, 
    0.05878707f, -0.18134084f, 0.10118494f, 0.03710932f, -0.07000151f, 0.05053288f, -0.11878277f, 0.12892807f, 
    -0.02356538f, 0.05473765f, 0.07652774f, 0.03003371f, -0.62792361f, 0.02313025f, -0.19874831f, -0.05311375f, 
    -0.46749279f, 0.07602797f, -0.02919578f, 0.08280710f, 0.01334275f, 0.06338529f, -0.04049814f, -0.09011251f, 
    -0.02827090f, -0.04644908f, 0.13494997f, -0.04348157f, -0.00800007f, -0.02258759f, -0.02162747f, 0.00796557f, 
    0.28699577f, 0.16302496f, -0.26793307f, -0.11042839f, 0.26651597f, 0.11161829f, -0.03996260f, -0.06904219f, 
    0.09199296f, -0.01772857f, 0.08456277f, 0.17008238f, 0.02392913f, -0.00918755f, -0.02029384f, -0.03616238f, 
    -0.01448627f, 0.17996173f, 0.02074818f, 0.12291552f, -0.33364064f, 0.06833951f, 0.00759711f, -0.01439783f, 
    0.08282460f, -0.11045836f, 0.08016272f, 0.03201769f, 0.06480823f, -0.11747814f, -0.01252751f, -0.08392587f, 
    0.03386233f, -0.03225087f, -0.02275682f, -0.11749833f, -0.16392404f, 0.02270166f, -0.20530230f, 0.06171612f, 
    -0.03582136f, -0.14062965f, 0.07073228f, -0.13672039f, 0.33136278f, -0.04877947f, -0.10300481f, -0.04986882f, 
    0.03047167f, -0.02646804f, 0.09971698f, -0.12442514f, -0.03496800f, 0.05220805f, -0.00138827f, 0.00675260f, 
    -0.03673415f, -0.15229324f, 0.03714423f, 0.06427244f, 0.15938951f, -0.04258638f, 0.08550768f, -0.23887898f, 
    -0.04553701f, 0.03720362f, 0.05849473f, 0.06528769f, 0.07754898f, 0.08139803f, -0.09047123f, -0.14663474f, 
    -0.18020102f, 0.05554979f, 0.07416378f, 0.01060607f, 0.00092337f, 0.08918230f, 0.05569430f, 0.08055259f, 
    0.06032454f, 0.17763355f, -0.03573330f, 0.09426858f, 0.21757117f, 0.14820910f, 0.15452854f, 0.04529425f, 
    -0.15761383f, 0.03157939f, 0.04820028f, 0.14138120f, -0.02764615f, -0.11234803f, -0.02180809f, 0.04898422f, 
    0.04770762f, -0.16640262f, 0.13764966f, 0.12257668f, 0.11945482f, -0.09106542f, -0.00129218f, -0.04855270f, 
    -0.13127951f, -0.00448664f, 0.10411836f, -0.13101056f, 0.00965151f, -0.01589998f, 0.09805630f, -0.14290620f, 
    -0.02083115f, 0.06800122f, 0.00254934f, -0.01591000f, 0.03710638f, -0.12286083f, 0.01835907f, 0.08706849f, 
    -0.01264863f, -0.05559495f, 0.02219630f, 0.00031153f, -0.22422749f, -0.04795490f, -0.02507654f, 0.00892527f, 
    -0.05723911f, -0.13320790f, -0.07575668f, -0.08412585f, 0.04987189f, -0.04991077f, -0.07994495f, -0.03093985f, 
    -0.02669274f, -0.14737958f, 0.05168589f, 0.01393053f, 0.40637821f, 0.07461228f, -0.23740512f, -0.16126481f, 
    -0.35028595f, -0.03102527f, -0.10253775f, 0.01387597f, 0.01886785f, 0.03077189f, 0.12179041f, -0.00232833f, 
    -0.04015714f, -0.14611711f, 0.05964391f, -0.05062957f, -0.02231323f, -0.04780349f, -0.03482447f, 0.06831492f, 
    0.48961115f, 0.04958729f, -0.14726657f, 0.14092846f, 0.27550271f, 0.08796642f, -0.02362810f, -0.05575150f, 
    0.01823645f, -0.00412069f, 0.05665363f, -0.02666510f, 0.03794774f, 0.07845996f, -0.01640028f, 0.07317998f, 
    0.01974281f, -0.01335079f, 0.05829558f, -0.06854089f, -0.09308095f, -0.58691013f, -0.04236551f, -0.00600196f, 
    0.11844837f, -0.02102657f, -0.06062272f, 0.03930893f, 0.03907934f, 0.12414113f, -0.08306096f, -0.00744642f, 
    -0.09247921f, 0.01769144f, -0.02043856f, 0.05265248f, 0.11031930f, 0.11747120f, -0.01953018f, -0.18362020f, 
    -0.16946904f, 0.23393162f, -0.08070105f, -0.21504360f, 0.10174662f, -0.11157985f, 0.03921070f, 0.13176732f, 
    0.02983289f, 0.11970318f, -0.08321116f, -0.01276096f, -0.04187425f, -0.09841049f, 0.20541172f, 0.05578826f, 
    -0.09783561f, -0.14331789f, 0.07750664f, -0.14166114f, -0.47650245f, 0.06713059f, 0.02817323f, -0.01389009f, 
    -0.00913648f, 0.11896987f, -0.00975326f, 0.00655392f, 0.03524035f, 0.15156186f, -0.05114938f, 0.08533599f, 
    0.01929561f, -0.07666179f, -0.11225945f, -0.04753889f, -0.01619075f, -0.08547455f, -0.15866300f, -0.15968867f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04225887f, 0.06558444f, -0.02621888f, -0.01883666f, 0.02760340f, -0.00198735f, -0.00181372f, -0.05875301f, 
    -0.02354489f, 0.00952594f, 0.10878486f, 0.01478015f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
