#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.00315797f, -0.54152238f, 0.18984121f, 0.80785817f, 0.31490591f, -0.22164248f, -0.71070641f, -0.11958617f, 
    -0.28536037f, 0.44251293f, 0.39854237f, -0.19375460f, 0.37313494f, 0.23803207f, 0.06656905f, -0.28092900f, 
    -0.13874955f, 0.19510539f, -0.22509666f, 0.27947152f, -0.03111237f, -0.14222699f, 0.20794252f, 0.07076696f, 
    -0.02374109f, -0.89936781f, 0.63879853f, 0.35726261f, -0.66865462f, 0.14544138f, -0.44561824f, 0.13624060f, 
    0.38630295f, 0.05538801f, 0.14571825f, -0.59807378f, -0.40618122f, 0.12754698f, -0.06390974f, 0.27247933f, 
    0.18366130f, 0.11462831f, 0.19393905f, 0.04984752f, -0.20999435f, -0.21386686f, -0.29454038f, 0.03045062f, 
    -0.32727537f, -0.67962849f, -0.41960457f, 0.09339125f, 0.06492566f, -0.02051410f, -0.33856967f, 0.27239010f, 
    -0.06959333f, 0.00492784f, 0.52661109f, -0.50904948f, -0.18654066f, -0.08189122f, 0.45185006f, -0.02714282f, 
    -0.14368741f, -0.13384739f, -0.22581494f, 0.25039002f, 0.15744880f, 0.21133654f, -0.09930366f, 0.10341691f, 
    -0.28096956f, 0.21010131f, 0.08146099f, 0.76468158f, 0.42174256f, 0.08224051f, -0.34912807f, -0.32137659f, 
    0.23841161f, 0.08868925f, -0.18060589f, -0.30085117f, 0.05411642f, 0.24803045f, 0.09184583f, 0.00329078f, 
    -0.17847520f, -0.24508326f, -0.10276184f, -0.04060932f, 0.02637246f, 0.14655973f, -0.22631101f, 0.20982639f, 
    -0.21503370f, -0.11512396f, -0.19238245f, 0.16952325f, -0.82276154f, -0.88059276f, -0.13138269f, 0.78737003f, 
    0.20281132f, 0.72578955f, 0.53397024f, -0.79725218f, -0.82848233f, -0.18336318f, 0.14977212f, -0.03398438f, 
    -0.23938246f, -0.25094557f, -0.42229554f, -0.08717021f, -0.02577196f, -0.13269061f, -0.04108988f, 0.18241334f, 
    0.21065961f, -0.31275466f, -0.16273049f, 0.14670673f, -0.20607276f, -0.44490179f, -0.31104460f, -0.13829540f, 
    -0.06617684f, -0.32273397f, -0.16989659f, -0.40265164f, -0.39270350f, 0.19788086f, -0.18804578f, 0.24279426f, 
    0.06376632f, -0.05455299f, 0.00953388f, -0.04484507f, 0.09624914f, -0.11557432f, 0.05333591f, -0.09532526f, 
    -0.19631363f, 0.12468262f, 0.17182937f, 0.18362863f, 0.34876397f, 0.29022947f, -1.12120497f, 0.12678550f, 
    -0.26549321f, -0.06676730f, 0.55124867f, 0.33847389f, -0.00673991f, 0.12301773f, 0.27953321f, -0.19799006f, 
    0.25056258f, 0.05059288f, 0.38847774f, -0.52338952f, -0.09313774f, 0.05789539f, 0.01628865f, -0.29492548f, 
    -0.19557771f, 0.10218932f, 0.22154720f, 0.03746588f, 0.00463295f, -0.15037756f, 0.09699143f, 0.46102643f, 
    -0.38510746f, -0.07258555f, 0.22032234f, 0.14890808f, 0.32204112f, 0.35722259f, -0.08729315f, -0.17178118f, 
    0.08789328f, -0.19833207f, 0.35417345f, -0.02282287f, -0.27479655f, 0.14636114f, -0.24002169f, 0.04251822f, 
    -0.04457023f, -0.16824268f, -0.21298049f, 0.22022775f, -0.09107561f, 0.11426067f, 0.10833114f, 0.19990729f, 
    -0.25223666f, 0.25567368f, -0.00767588f, -0.14819190f, 0.49116933f, -0.27106068f, -0.15519381f, -0.12785836f, 
    -0.61048138f, -0.57480222f, -0.45535699f, 0.35887155f, -0.30756813f, -0.12752339f, -0.06005739f, 0.38576931f, 
    -0.27231035f, -0.09847839f, -0.08321893f, 0.10231075f, -0.05894221f, 0.30526298f, 0.05282624f, 0.07891724f, 
    0.15445399f, 0.88571233f, -0.17447281f, 0.20166899f, -0.05007336f, -0.43679747f, 0.01997344f, 0.04257524f, 
    0.01580260f, 0.00085995f, -0.18034759f, 0.01087035f, -0.34533849f, 0.16764104f, -0.26751032f, 0.02823612f, 
    -0.14231220f, 0.12819442f, 0.18723677f, -0.17433390f, -0.33084509f, -0.07334712f, -0.21353903f, -0.20949604f, 
    -0.42031661f, -0.55704975f, 0.48535234f, -0.72285444f, 0.17615215f, 0.45525545f, -0.09155121f, 0.29718015f, 
    0.42694971f, -0.10285820f, -0.67170930f, -0.06282103f, 0.00505479f, -0.08036556f, -0.09814550f, -0.29195073f, 
    -0.10052487f, 0.11294776f, 0.18270536f, 0.13902566f, 0.10717795f, -0.13286552f, -0.03865710f, 0.21333583f, 
    -0.31492352f, -0.19511503f, 0.22644380f, 0.45960161f, 0.26446733f, 0.10270496f, -0.09515744f, -0.20030132f, 
    -0.12215065f, -0.23002326f, 0.20339029f, -0.19216302f, -0.06675455f, -0.19332519f, 0.01163612f, 0.26068103f, 
    0.08185801f, -0.34358856f, -0.03741746f, 0.09100061f, -0.08664635f, -0.00894281f, 0.15935741f, 0.12085584f, 
    -0.22223721f, -0.29498544f, 0.20347860f, 0.02380854f, -0.71380442f, -0.41691315f, -0.21581623f, -0.35530329f, 
    -0.25042784f, 0.47425717f, 0.45136583f, 0.31929767f, -0.33103612f, -0.00616703f, 0.33104289f, 0.07187115f, 
    -0.12170465f, 0.28474528f, 0.04487111f, -0.45189300f, -0.28048089f, -0.44775772f, -0.22220166f, 0.40970555f, 
    0.29611969f, -0.05053074f, 0.13763142f, 0.16834883f, 0.05719544f, -0.70232767f, -0.19328716f, -0.33269683f, 
    -0.47758311f, -0.10231882f, -0.28862405f, 0.06320054f, 0.56071049f, 0.48026213f, 0.22246635f, 0.03933136f, 
    0.08575398f, 0.13592404f, 0.06436288f, -0.47887170f, -0.42860663f, -0.18034779f, 0.16105406f, 0.08974239f, 
    0.17512864f, 0.10793753f, 0.24769071f, -0.05903694f, 0.03391676f, 0.07895464f, -0.20027515f, -0.29422432f, 
    0.25638187f, -0.03519444f, -0.64318299f, -0.30030435f, 0.62779927f, 0.28214213f, -0.06381372f, -0.51674730f, 
    -0.15866388f, -0.00144437f, -0.09145646f, 0.01004630f, -0.09208419f, -0.01065969f, -0.05046207f, 0.11115246f, 
    0.24070254f, 0.21064638f, -0.24489357f, 0.04275869f, -0.13575445f, -0.28672108f, 0.05698859f, 0.17351279f, 
    0.46112850f, 0.38511136f, -0.22155727f, -0.37852588f, -0.58535546f, -0.33507839f, 0.34666815f, 0.24005072f, 
    -0.06499338f, 0.07420320f, 0.15764405f, 0.00814160f, -0.49307573f, 0.39917603f, 0.22376877f, 0.07598785f, 
    -0.03188051f, -0.18584955f, -0.12028623f, 0.07751961f, -0.14217080f, -0.26368171f, 0.15962547f, 0.16381888f, 
    -0.21395785f, -0.65277857f, -0.36998349f, -0.24712721f, -0.45439476f, 0.40086347f, 0.26555490f, -0.02836196f, 
    -0.00780122f, 0.18247576f, 0.13690907f, 0.08267539f, 0.19120543f, -0.06275998f, -0.11953313f, -0.18300243f, 
    0.05493856f, -0.06019286f, -0.14936818f, -0.04363858f, -0.40285328f, 0.09197065f, -0.12755843f, -0.40828520f, 
    -0.22809462f, 0.62572289f, 0.80812782f, 0.55453610f, -0.21040724f, -0.65544152f, -0.59814614f, -0.21557783f, 
    -0.08750602f, -0.31117311f, -0.33837828f, 0.22671215f, 0.06859152f, -0.17721303f, 0.10974975f, 0.16494362f, 
    -0.11757844f, -0.05731092f, 0.23881516f, 0.17580885f, 0.05443373f, 0.08169615f, 0.10448137f, -0.30128929f, 
    -0.32168475f, 0.06318557f, 0.19414391f, -0.31134415f, -0.28990078f, -0.30704704f, -0.48172599f, 0.30068105f, 
    -0.30764464f, -0.25362152f, -0.08063938f, -0.43897185f, -0.22769538f, -0.06427661f, -0.06881372f, -0.23329918f, 
    -0.19273078f, -0.21323857f, 0.04339986f, -0.05924206f, 0.14065936f, 0.11187083f, -0.21027263f, 0.29589126f, 
    0.22375436f, 0.01730185f, 0.40592748f, -0.35963249f, -0.25349745f, 0.17685206f, 0.03935021f, 0.30594566f, 
    0.16563375f, 0.37447822f, -0.01203268f, 0.20251787f, 0.47357339f, 0.13531746f, -0.08173639f, 0.00597826f, 
    -0.13550289f, 0.09886970f, -0.25620115f, -0.00433275f, -0.15611389f, 0.09451222f, -0.16233450f, 0.27185243f, 
    0.28208643f, -0.05616639f, -0.24610321f, 0.16336924f, -0.09037633f, -0.20963477f, -0.57441235f, -0.07086369f, 
    0.34226513f, -0.45161623f, -0.41098684f, -0.64573467f, -0.31465501f, -0.46740454f, 0.08870149f, 0.53503519f, 
    0.40305686f, 0.21128511f, -0.17702092f, -0.12617466f, 0.12368985f, -0.29345116f, -0.05476969f, -0.09483072f, 
    0.21360745f, -0.28268233f, -0.14998502f, 0.10115570f, -0.09339724f, 0.69194466f, -0.19713746f, -0.24891438f, 
    0.42909554f, 0.11577128f, -0.01850765f, 0.09318351f, 0.10667673f, -0.54819018f, -0.34162757f, -0.10232942f, 
    0.27967739f, -0.09492823f, 0.28802201f, -0.21203659f, 0.01592601f, -0.10428029f, -0.22442642f, 0.11265500f, 
    0.28955492f, -0.20936857f, 0.01820656f, -0.07591005f, 0.27070257f, -0.41249236f, -0.15314730f, -0.08280845f, 
    -0.55453748f, -0.94522792f, -0.90971339f, 0.49827254f, 0.05807574f, 0.11431380f, 0.19672725f, -0.00859195f, 
    0.08909815f, -0.52154636f, -0.27703908f, -0.35042971f, -0.17174678f, 0.06323384f, -0.11948429f, -0.00789311f, 
    0.20205073f, -0.26387087f, -0.03508046f, -0.05211490f, 0.15198652f, -0.12060706f, -0.15175104f, 0.66634709f, 
    -0.03641302f, -0.40482485f, -0.36156133f, -0.32395086f, -0.14877130f, 0.12735744f, 0.08740663f, 0.18073894f, 
    0.20220757f, -0.04790633f, 0.07764860f, -0.34422258f, 0.02232407f, 0.34959927f, -0.02554950f, 0.04336578f, 
    -0.31608549f, 0.19399647f, 0.09636736f, 0.01262373f, -0.13787830f, 0.05850597f, -0.02951610f, 0.27919054f, 
    0.33258775f, -0.17963333f, -0.26101828f, -0.30839926f, -0.57335436f, -0.27699250f, -0.32769510f, -0.47430307f, 
    -0.42427176f, -0.42456353f, 0.14153358f, 0.08771507f, 0.01882233f, -0.21361078f, 0.11692318f, -0.09235230f, 
    0.32041040f, -0.04675747f, -0.19402666f, -0.26378596f, -0.25923079f, -0.02430560f, -0.11757305f, -0.28910843f, 
    -0.51422620f, -0.75608718f, -0.30791342f, -0.25629419f, -0.47273880f, -0.06938965f, 0.00745610f, -0.15292104f, 
    -0.33878639f, -0.39389130f, 0.09242371f, -0.31293398f, -0.25950313f, -0.19248477f, -0.41919822f, -0.26489323f, 
    0.10225389f, 0.01694889f, -0.23921040f, -0.11636687f, -0.18754432f, -0.03212195f, 0.02304285f, -0.06508029f, 
    -0.08046617f, -0.10329830f, -0.09077291f, -0.57956117f, -0.23697469f, 0.51355779f, 0.39726818f, -0.33061382f, 
    -0.50123245f, -0.44407275f, 0.94808674f, -0.09854120f, 0.32422066f, -0.11330239f, -0.17348865f, -0.04756406f, 
    0.30534211f, 0.02037196f, 0.20312451f, -0.16920863f, -0.11006704f, -0.09329754f, -0.17581417f, 0.00867726f, 
    -0.18181002f, 0.36370134f, 0.21229307f, -0.84210211f, -0.63663954f, -0.60773665f, -0.29692134f, -0.52797341f, 
    0.69326508f, 0.46598071f, 0.13270192f, -0.00257589f, 0.67635888f, 0.21805784f, 0.06108209f, -0.01027176f, 
    -0.11745540f, 0.21170415f, -0.13320218f, 0.26562715f, -0.05722141f, -0.01170343f, -0.19584116f, -0.11752851f, 
    -0.27129847f, 0.12307254f, -0.02501244f, 0.01210930f, 0.58833027f, 0.18015081f, -0.12078509f, 0.05255944f, 
    -0.22682321f, 0.23612802f, -0.23346888f, 0.02332480f, 0.23038062f, 0.33946761f, 0.11181006f, -0.14708318f, 
    -0.10410064f, 0.04127264f, 0.08883768f, -0.07800479f, -0.01987291f, -0.17254184f, -0.02893617f, -0.10391632f, 
    0.14109266f, 0.29685390f, 0.28320289f, -0.36001739f, -0.41072169f, 0.52978230f, 0.20998093f, 0.31267145f, 
    0.10218859f, 0.06390429f, -0.28929299f, 0.01018583f, 0.04212458f, -0.14075029f, 0.04480926f, 0.24064206f, 
    -0.10841193f, -0.09865284f, 0.27640963f, -0.28596309f, 0.16776511f, 0.07689331f, 0.10442597f, -0.22165231f, 
    -0.08111310f, -0.23631078f, 0.28798091f, 0.06737330f, -0.06159092f, 0.10993776f, -0.44110224f, 0.82378721f, 
    -0.15452093f, -0.60175276f, -0.10528202f, -0.02235207f, 0.82160234f, -0.34939161f, -0.03911958f, -0.10740057f, 
    -0.06719727f, 0.02872536f, -0.05283262f, 0.31299028f, -0.27949238f, 0.11167130f, -0.10091764f, -0.11662988f, 
    0.12029119f, -0.15862989f, -0.08958784f, 0.15587603f, 0.01078077f, 0.17365021f, -0.01607636f, 0.01203232f, 
    0.04552767f, 0.52431446f, -0.23342529f, -0.55931538f, -0.38250616f, -0.36331558f, -0.24032354f, -0.48839307f, 
    -0.78254038f, 0.51206154f, -0.13682559f, -0.00888446f, -0.12955837f, 0.23471592f, 0.15689623f, 0.11418456f, 
    -0.10582943f, -0.20400628f, -0.32809892f, -0.33804530f, 0.20689315f, 0.37343094f, 0.12800236f, -0.06473215f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24973349f, -0.06142995f, 0.28123772f, 0.38087857f, 0.27127355f, -0.17151399f, 0.21277714f, 0.01088582f, 
    -0.06522925f, 0.10555541f, 0.12244164f, 0.25208515f, 0.24812275f, 0.28061748f, 0.33836478f, 0.04626259f, 
    -0.20103674f, 0.22652784f, -0.07200785f, -0.03992142f, 0.15375885f, -0.04809133f, -0.13822980f, 0.33134115f, 
    -0.22251530f, -0.10053053f, 0.19473818f, 0.10660664f, 0.26542962f, -0.17199130f, 0.08355771f, 0.26717943f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05033361f, -0.04143518f, -0.03149345f, -0.04718408f, 0.03387113f, -0.03922795f, 0.00559323f, 0.00173106f, 
    -0.02725565f, -0.05239673f, 0.01064525f, 0.04273690f, -0.04186720f, 0.02241549f, -0.05174461f, -0.00424155f, 
    0.03762938f, 0.03272439f, -0.00796941f, -0.05131593f, 0.01326360f, 0.00381082f, 0.00510596f, 0.01557718f, 
    0.01251026f, -0.03718591f, -0.02212219f, -0.05242322f, -0.03589759f, -0.00112269f, -0.04829233f, 0.01127215f, 
    -0.03908417f, -0.04698056f, -0.00625853f, -0.03118265f, 0.03525869f, -0.03517153f, 0.03737199f, 0.02330532f, 
    -0.00660193f, 0.02563672f, 0.00539898f, 0.02003298f, 0.04380970f, -0.04220189f, -0.00930876f, 0.00969621f, 
    0.04475488f, -0.00515794f, -0.00354729f, 0.01780036f, -0.01771911f, 0.01577754f, 0.00963265f, -0.02859255f, 
    0.04344930f, 0.03603608f, 0.00665384f, -0.03073560f, 0.02963006f, 0.04258498f, -0.04472936f, -0.02616313f, 
    -0.00902196f, 0.02852300f, -0.00071352f, -0.01658051f, -0.03254338f, 0.04439839f, -0.05043872f, 0.04403195f, 
    0.03152951f, 0.03249040f, -0.00202616f, -0.00432901f, -0.02136675f, -0.03007427f, -0.02341277f, -0.02965615f, 
    0.01108569f, -0.01459354f, -0.01705225f, 0.00238330f, -0.04222706f, -0.05312848f, -0.00249226f, 0.03335547f, 
    0.02223132f, -0.03021730f, -0.04270285f, -0.00158023f, 0.03597059f, 0.02927304f, 0.03698120f, 0.01857080f, 
    -0.01730715f, -0.05038219f, -0.05294075f, -0.05214909f, -0.02181477f, -0.03244127f, 0.02885736f, -0.05532403f, 
    -0.02712503f, -0.00825069f, 0.04131429f, 0.01257352f, -0.02895793f, 0.03191737f, -0.04428938f, -0.05260392f, 
    0.01586435f, 0.02816584f, 0.01038037f, 0.02704182f, -0.04377684f, -0.00887098f, -0.00901317f, 0.03297943f, 
    0.02679702f, -0.03091309f, 0.04092876f, 0.03756625f, -0.03796095f, 0.01104089f, 0.00433494f, -0.03779001f, 
    -0.05672515f, 0.02692050f, 0.04400242f, -0.00799899f, 0.00183123f, 0.02997467f, -0.02971800f, 0.00219943f, 
    0.00211804f, -0.04767653f, -0.03504341f, -0.02498016f, -0.04743405f, 0.01631079f, -0.05331290f, -0.00565759f, 
    0.02420881f, 0.01462764f, 0.02816939f, -0.00898436f, -0.02174563f, 0.03420918f, -0.03520258f, 0.00173504f, 
    0.01563051f, -0.01037537f, -0.01760067f, -0.00241827f, -0.04660705f, 0.00185589f, 0.03560273f, 0.00928711f, 
    -0.04936535f, 0.02033602f, -0.01714981f, -0.02188485f, 0.00192568f, 0.03799341f, -0.05207716f, 0.01344951f, 
    -0.01373259f, 0.00389801f, 0.04063155f, 0.03244837f, 0.01078208f, 0.04270346f, -0.05272236f, -0.03584027f, 
    0.00122434f, 0.00004389f, -0.02059642f, -0.05276465f, -0.03189884f, -0.01375179f, -0.04980201f, -0.04796444f, 
    -0.02272575f, 0.04297746f, -0.00749684f, 0.02018318f, 0.02384057f, -0.03555826f, 0.02000289f, -0.02089327f, 
    -0.02978274f, 0.03293170f, 0.01977498f, 0.04044382f, -0.03338476f, -0.04564575f, 0.01355518f, -0.03865921f, 
    0.04406252f, -0.03162259f, -0.00050238f, -0.00727756f, -0.03651448f, -0.05343387f, 0.02022437f, -0.05224575f, 
    -0.02281436f, -0.02909986f, -0.04346626f, -0.02620124f, -0.01308988f, 0.00809348f, -0.02905143f, -0.05303610f, 
    -0.03268570f, -0.02929973f, 0.02872218f, -0.00924552f, -0.02970611f, 0.04440069f, 0.04124477f, 0.01540328f, 
    -0.01795794f, 0.04348487f, 0.04521011f, 0.02357395f, -0.04097942f, -0.00646081f, -0.01710844f, 0.02013968f, 
    0.00709224f, -0.04746859f, -0.02647491f, 0.02651706f, -0.03923776f, -0.03123196f, -0.01060327f, -0.04417028f, 
    0.01618893f, -0.05161691f, -0.02463372f, 0.03257349f, -0.03838549f, 0.02293850f, 0.03831961f, -0.05356242f, 
    0.01215817f, 0.02977816f, -0.04447957f, 0.01943862f, -0.04209987f, -0.02711278f, 0.00642585f, 0.02809378f, 
    0.02215695f, 0.04041646f, -0.01925276f, 0.03026946f, -0.00153844f, -0.01905213f, -0.04206313f, 0.01914796f, 
    -0.00327552f, -0.03009215f, -0.01184660f, 0.02210119f, -0.03876733f, 0.02504487f, 0.03522683f, -0.02642146f, 
    0.02700961f, -0.00388810f, 0.00992504f, 0.01389259f, 0.04104357f, -0.01244979f, 0.00250864f, 0.01654778f, 
    0.02453773f, 0.02869959f, -0.03150873f, -0.03728564f, -0.05513343f, -0.03755257f, -0.04006664f, -0.01012543f, 
    -0.00096716f, -0.00141650f, 0.03672918f, -0.00120456f, -0.04878401f, -0.01046759f, 0.03161810f, -0.00406507f, 
    -0.03006605f, -0.01525632f, 0.01396871f, 0.01608482f, -0.00993440f, -0.03240624f, 0.00989384f, -0.00897779f, 
    -0.04586381f, -0.01640124f, -0.00583340f, 0.01705519f, 0.00420185f, 0.03306061f, -0.03502166f, -0.00730054f, 
    -0.01071580f, 0.02845019f, 0.00807863f, 0.02896420f, 0.00139850f, 0.03808136f, -0.01917574f, 0.02365727f, 
    0.04379807f, 0.02162023f, 0.02470100f, -0.03621092f, 0.02480788f, 0.02847784f, -0.04945607f, -0.03048181f, 
    0.02203136f, -0.03182869f, -0.02426599f, -0.05255909f, 0.03054067f, 0.00663366f, 0.04004780f, 0.02386919f, 
    -0.04939065f, -0.00962034f, -0.04054749f, -0.00390379f, -0.02153350f, -0.04399986f, 0.00849012f, -0.03159170f, 
    -0.01337040f, -0.03925411f, -0.00799522f, 0.02289426f, 0.03257523f, 0.00434198f, 0.04662390f, -0.02609561f, 
    0.01266035f, 0.01563284f, -0.01111662f, -0.04855473f, 0.02410101f, -0.04932525f, -0.01631746f, -0.02469881f, 
    0.03988349f, -0.03212083f, 0.02426694f, -0.01208700f, 0.02275256f, -0.03557063f, 0.02421640f, -0.00742454f, 
    -0.01769867f, -0.05382016f, -0.03658424f, 0.02847039f, -0.05741688f, -0.02264922f, 0.02055626f, 0.00156047f, 
    0.04524484f, 0.00586567f, -0.00261037f, 0.04528645f, -0.01012907f, -0.02351548f, -0.04053283f, -0.03765641f, 
    0.00929581f, 0.15767905f, 0.26414877f, -0.08611222f, 0.10083085f, 0.16858642f, 0.12554097f, 0.18436670f, 
    0.20903760f, -0.02163407f, -0.03357919f, 0.03118563f, -0.16764820f, 0.04331059f, 0.14783315f, -0.09279429f, 
    -0.04446789f, -0.06436402f, -0.05909272f, 0.14277528f, 0.03820189f, -0.07766773f, -0.09491315f, -0.29876524f, 
    0.04989986f, -0.05553081f, 0.07518704f, 0.03204715f, 0.02716377f, 0.07750148f, -0.16083713f, 0.05917321f, 
    0.05749495f, 0.06365784f, 0.08546338f, -0.00776451f, -0.06237140f, -0.02482441f, -0.26059332f, 0.29655680f, 
    -0.09082739f, -0.04708232f, -0.00228336f, -0.06163831f, -0.00516952f, 0.00925564f, 0.02187865f, -0.00156821f, 
    -0.10891563f, 0.48541525f, -0.05725461f, 0.07381563f, 0.10464803f, 0.11989975f, 0.10703548f, 0.02240209f, 
    0.02065359f, -0.04848635f, -0.08391633f, -0.03585279f, 0.15330800f, 0.22318509f, 0.18433249f, -0.03785961f, 
    0.18964754f, 0.15058611f, 0.11726460f, 0.02664972f, 0.03537326f, 0.03579006f, -0.00446259f, -0.02382708f, 
    -0.27222922f, 0.07706852f, 0.08971173f, -0.13428433f, 0.02063742f, 0.06850353f, 0.03375227f, 0.02383444f, 
    -0.12384731f, -0.03780165f, 0.14092249f, 0.15614653f, -0.10142875f, 0.00018380f, -0.14767846f, -0.05643665f, 
    -0.08483721f, -0.03525502f, -0.04657933f, 0.00429625f, 0.03279132f, -0.05428222f, 0.18680786f, -0.02617357f, 
    0.14849389f, 0.31454432f, 0.22893517f, -0.10632800f, 0.08478556f, 0.11599888f, 0.14408147f, 0.01598481f, 
    0.01074392f, -0.04033850f, 0.04769818f, 0.03634727f, -0.09561931f, -0.17232238f, -0.06009741f, -0.05070785f, 
    -0.02148271f, 0.02856675f, -0.07399667f, 0.02353878f, -0.12291116f, -0.11888156f, -0.08934003f, -0.35114568f, 
    -0.10912446f, 0.04641963f, -0.08878810f, -0.00424208f, -0.04947434f, -0.11701122f, 0.15300709f, -0.01257933f, 
    -0.05189065f, 0.10403887f, -0.00069771f, -0.02381700f, 0.07793547f, -0.18300217f, -0.12719049f, 0.11835153f, 
    0.01815735f, -0.02661440f, -0.09129631f, -0.04739165f, -0.01164011f, -0.04947097f, 0.08039091f, -0.04771983f, 
    -0.10195711f, -0.09739171f, -0.24356377f, 0.01415364f, 0.03813940f, 0.07401031f, -0.03028845f, 0.19082589f, 
    0.17876294f, 0.34809095f, 0.06411786f, -0.07242475f, 0.08820018f, -0.29522693f, 0.06867961f, -0.01895483f, 
    -0.03723430f, 0.08524608f, 0.04320213f, -0.01486514f, -0.08513407f, 0.01639234f, 0.20499332f, -0.06421973f, 
    0.42196548f, 0.05765153f, 0.04008205f, 0.07560698f, 0.13239689f, 0.10100788f, 0.05116019f, 0.18173033f, 
    -0.08955782f, 0.02829980f, 0.03372386f, 0.14188343f, -0.09240628f, -0.13176985f, 0.09269473f, 0.07704696f, 
    0.21110666f, -0.09252039f, -0.21600381f, 0.06631261f, -0.10582117f, 0.00206335f, 0.13504228f, 0.12148374f, 
    0.08945603f, -0.06737857f, -0.13178000f, -0.03537157f, 0.12656966f, 0.09520608f, 0.02286897f, 0.02700228f, 
    -0.01542851f, 0.01104732f, -0.00500654f, -0.11112615f, 0.02506538f, -0.15551820f, 0.01723010f, 0.07750157f, 
    0.08471677f, -0.13041201f, 0.04680313f, -0.03345099f, -0.13213648f, 0.06293579f, 0.05366133f, -0.01623171f, 
    0.29507622f, 0.19646055f, -0.04997109f, 0.07810511f, 0.04862710f, 0.13873996f, 0.06519086f, -0.00346261f, 
    0.03207976f, 0.01249876f, 0.06058768f, 0.07472301f, -0.29089445f, -0.09637479f, -0.03906301f, 0.04504998f, 
    -0.00682553f, -0.05781594f, -0.04472994f, -0.08106026f, 0.00774607f, -0.08423943f, 0.08511165f, 0.00613080f, 
    0.16251101f, 0.23766375f, -0.00128583f, -0.05806657f, 0.09765569f, 0.08299018f, 0.21422279f, 0.05040219f, 
    -0.09773594f, -0.04408696f, -0.02531527f, -0.01732913f, 0.09443495f, -0.10801306f, -0.21237901f, 0.17724407f, 
    -0.14085200f, 0.11495651f, -0.09349717f, -0.09084776f, 0.07866982f, 0.03478052f, 0.03620585f, -0.15132028f, 
    0.34911099f, -0.00640952f, -0.06897740f, -0.01505525f, -0.08411966f, 0.02080975f, 0.06181116f, 0.12128139f, 
    0.00287665f, 0.05964103f, -0.01282050f, -0.08240499f, -0.14408267f, -0.18772644f, -0.00398562f, 0.00830115f, 
    -0.07739299f, -0.03039848f, -0.00845520f, -0.00021479f, 0.14451616f, 0.01320648f, -0.04713720f, 0.02916971f, 
    0.12166715f, 0.08117894f, 0.00660770f, -0.05569288f, -0.01412329f, -0.03121685f, 0.06481500f, 0.13839564f, 
    -0.11437321f, -0.08840539f, -0.11372633f, -0.10224761f, 0.19370463f, 0.18675521f, 0.11564817f, 0.00992720f, 
    0.15993221f, 0.05203123f, 0.12310316f, 0.12525901f, -0.00304362f, -0.04101153f, -0.09943210f, -0.06343199f, 
    -0.00174906f, 0.12877879f, 0.11039498f, -0.03302658f, -0.18540384f, 0.02386307f, 0.19989283f, -0.13774993f, 
    0.02584638f, -0.08759429f, -0.00497529f, 0.05343645f, -0.24184199f, 0.22195138f, -0.38733646f, -0.09429000f, 
    0.20663239f, 0.06278803f, -0.04489597f, -0.05163058f, 0.05880751f, -0.03095452f, -0.02221543f, -0.09770993f, 
    -0.10161339f, -0.15665345f, -0.10089210f, 0.01865342f, -0.02109360f, 0.00926393f, -0.01085893f, 0.01981011f, 
    -0.05403034f, 0.08770162f, -0.06147262f, -0.24279116f, -0.05697433f, -0.06214133f, -0.10480870f, 0.05549349f, 
    -0.03339003f, -0.01425510f, -0.04162098f, -0.02122615f, 0.04894155f, 0.01671812f, 0.00448377f, 0.06403303f, 
    -0.11531350f, 0.16950919f, 0.08046022f, -0.03121707f, 0.03516519f, 0.12481977f, 0.08832353f, -0.09995908f, 
    0.13422860f, 0.23047645f, 0.05294498f, -0.04107134f, 0.31135592f, 0.03497366f, 0.06644411f, 0.03650818f, 
    0.07645518f, -0.00148127f, 0.13723478f, 0.08972219f, -0.01939344f, 0.03332400f, 0.00601929f, 0.08580075f, 
    -0.14940979f, -0.02507854f, -0.10275859f, -0.09316958f, 0.02980191f, 0.06065921f, -0.06255287f, -0.01011462f, 
    0.05750749f, -0.11241601f, 0.02529880f, 0.04206805f, 0.01854276f, 0.05023063f, 0.01947836f, 0.00754447f, 
    0.03183936f, -0.05800393f, -0.00227365f, -0.01157296f, -0.18600690f, -0.61662650f, -0.46574244f, -0.08093751f, 
    0.01015757f, -0.06146342f, -0.02585706f, -0.03808723f, 0.06825165f, -0.03584025f, -0.05831765f, 0.11145986f, 
    0.04080743f, -0.02895734f, 0.01208456f, 0.00724902f, 0.12998292f, 0.11043271f, -0.04674472f, -0.08910736f, 
    -0.03306774f, 0.03692708f, 0.04166978f, -0.01296583f, 0.08133230f, 0.08289391f, 0.04581784f, -0.02646914f, 
    0.02535658f, -0.11864899f, 0.11389060f, -0.20543216f, -0.10292423f, -0.15844131f, -0.06777482f, -0.11235722f, 
    -0.21889998f, -0.14137602f, -0.17734893f, -0.00479717f, 0.14052421f, 0.09329800f, 0.10151979f, 0.06266771f, 
    0.00487174f, 0.19192265f, 0.02679626f, -0.12754588f, 0.00680214f, -0.05418656f, -0.01952878f, 0.04220428f, 
    0.01511156f, 0.01280182f, -0.12599792f, -0.06466551f, 0.01126109f, 0.15606931f, 0.01680836f, 0.03746444f, 
    -0.13664524f, 0.01660784f, -0.09547469f, 0.11870250f, 0.10259187f, 0.10972305f, 0.10935909f, 0.06564233f, 
    0.08979946f, 0.05712333f, 0.03310975f, -0.02514197f, -0.02312246f, 0.04203222f, -0.00434085f, 0.00572148f, 
    0.18099423f, -0.02149198f, 0.15507089f, 0.16712645f, -0.17004131f, -0.40650707f, -0.05774391f, 0.13767375f, 
    0.04686262f, -0.00876404f, -0.03182390f, 0.03043553f, -0.14222845f, -0.04428348f, -0.07765406f, -0.20583750f, 
    0.03265612f, -0.07839934f, -0.01219585f, -0.06952787f, -0.05900871f, -0.11390966f, -0.01905001f, 0.01148772f, 
    0.04713891f, 0.05400157f, 0.06475192f, 0.16629368f, -0.11369404f, 0.05457951f, 0.02592200f, 0.14658305f, 
    0.02457620f, 0.03278003f, 0.00729411f, 0.06131829f, -0.00985401f, 0.07845367f, 0.17047223f, 0.03019905f, 
    -0.02984805f, 0.00183169f, -0.01784968f, -0.06482586f, 0.06207689f, 0.07435554f, 0.04349094f, 0.05407557f, 
    0.20388736f, 0.15478100f, -0.09208687f, -0.04854694f, 0.01875073f, -0.01675122f, 0.06868915f, -0.03888543f, 
    0.04715551f, 0.21900673f, 0.35287103f, 0.19226433f, 0.07515380f, 0.08565114f, -0.20993938f, -0.13660443f, 
    0.09952012f, -0.00925826f, -0.00998771f, 0.14497936f, 0.15210654f, 0.07742964f, 0.14969422f, 0.09287573f, 
    -0.05571721f, -0.00287448f, 0.12977193f, 0.08745541f, -0.11865281f, -0.04252838f, -0.18470223f, -0.27933571f, 
    -0.07037588f, -0.08058742f, -0.01596626f, -0.06119068f, -0.01158156f, 0.06579937f, -0.01904941f, 0.00604409f, 
    -0.05014281f, -0.06099159f, -0.08286002f, -0.00425281f, 0.15915169f, 0.05499367f, -0.06975105f, 0.13956150f, 
    -0.11783176f, -0.11146098f, 0.03871432f, 0.01714328f, 0.04215720f, -0.04740479f, -0.05279025f, -0.01401889f, 
    -0.23786968f, -0.20023939f, -0.15596376f, -0.35888067f, 0.06705233f, 0.03260847f, 0.03522616f, 0.00751300f, 
    -0.04258685f, 0.12159607f, 0.02994978f, -0.17025928f, 0.11697001f, 0.19696090f, 0.07040013f, -0.01749743f, 
    0.18581635f, 0.15130365f, 0.08991588f, 0.01825251f, -0.12858297f, -0.20437340f, -0.24785130f, -0.12225000f, 
    0.02977080f, 0.02160473f, -0.03624432f, 0.05661843f, 0.10250717f, 0.09387205f, -0.01171210f, -0.06892429f, 
    0.04232252f, 0.08438578f, -0.01334171f, -0.01355668f, -0.22605348f, -0.07814473f, -0.11785018f, -0.04940059f, 
    -0.11985543f, 0.06990152f, 0.09211653f, 0.07595768f, 0.16323593f, -0.10216779f, 0.03458239f, 0.06049216f, 
    -0.08479710f, -0.09091943f, 0.00912447f, -0.04721279f, 0.03986430f, -0.03901945f, 0.17086866f, -0.03823936f, 
    0.03634371f, -0.07578513f, -0.08327649f, 0.07756789f, -0.00591859f, 0.15928762f, -0.00376970f, 0.08456096f, 
    0.09048853f, 0.18733539f, -0.05440808f, -0.28577948f, 0.10619822f, 0.04747123f, 0.22827700f, -0.03437154f, 
    -0.10258643f, -0.03623167f, -0.01021175f, -0.01813087f, -0.01156888f, -0.02204630f, -0.02304213f, 0.04994573f, 
    -0.02054697f, -0.05776982f, -0.01518073f, 0.02639954f, -0.00306660f, 0.07787278f, -0.01030716f, -0.08069919f, 
    0.10631163f, 0.07561111f, 0.25360069f, 0.09254441f, 0.18482099f, 0.17874385f, 0.10982060f, -0.11140553f, 
    -0.19373974f, 0.02577821f, 0.00143285f, 0.00807313f, -0.04456552f, -0.08228296f, -0.05909632f, 0.03056176f, 
    -0.05886970f, -0.07427609f, -0.02164239f, -0.07517178f, -0.04405335f, -0.12629075f, -0.06159219f, 0.04577701f, 
    -0.08916263f, 0.03775624f, -0.17583738f, 0.04619031f, -0.12096915f, 0.03664539f, -0.11037190f, 0.03357131f, 
    0.00083817f, -0.01968528f, -0.17804623f, 0.17031583f, 0.08507321f, -0.12778756f, 0.10960461f, -0.03664881f, 
    0.05179333f, 0.01756507f, -0.00444735f, 0.01237451f, -0.19954132f, 0.04879685f, 0.14404711f, -0.15331116f, 
    0.18079512f, 0.18372630f, 0.10054813f, -0.00809053f, 0.06035075f, -0.01981080f, 0.03013826f, 0.02510408f, 
    0.02849681f, 0.04435698f, 0.00708240f, -0.23986009f, 0.07577901f, 0.04994935f, -0.02490328f, 0.09238376f, 
    0.03143637f, -0.06936994f, 0.01463682f, -0.00220261f, 0.04752509f, 0.06644753f, -0.03269815f, 0.07962997f, 
    0.31940845f, -0.10818181f, -0.25794467f, -0.00962801f, 0.23103391f, -0.18178703f, -0.00908223f, -0.27958196f, 
    -0.02021745f, -0.18536893f, 0.08745562f, 0.05723320f, 0.02420423f, -0.04549154f, 0.24861765f, -0.02071425f, 
    -0.05389887f, -0.05094703f, -0.20937718f, -0.41837469f, -0.01822278f, -0.06251789f, -0.02506667f, -0.01843370f, 
    -0.08321535f, -0.25356239f, 0.19401853f, 0.15938187f, 0.05308761f, -0.13720196f, 0.05940031f, -0.05732364f, 
    0.07964006f, -0.04849568f, -0.04760185f, 0.09439795f, -0.30555040f, 0.09148857f, 0.07553125f, 0.10096262f, 
    0.02751803f, 0.00925972f, 0.04077018f, 0.06585857f, 0.23696248f, 0.04929947f, 0.08704581f, 0.00722249f, 
    -0.02943854f, -0.14017071f, 0.07321592f, -0.09151495f, 0.15871017f, 0.09969009f, -0.15454786f, -0.00840876f, 
    0.08493380f, -0.03455554f, -0.04813205f, 0.05262990f, 0.30999810f, -0.10548683f, -0.18985297f, -0.03200461f, 
    -0.02578705f, 0.09858491f, 0.07330418f, -0.00378347f, -0.06151493f, 0.07511734f, 0.06023810f, 0.05507983f, 
    -0.01805095f, -0.17884544f, 0.09838168f, 0.06371061f, -0.18070249f, 0.05090392f, -0.07752728f, 0.08723204f, 
    0.09283345f, -0.05787036f, 0.02585975f, 0.02927933f, 0.19940768f, 0.35028625f, 0.25641260f, 0.07209500f, 
    -0.00206142f, -0.00631297f, 0.05529653f, 0.00628719f, 0.02760673f, -0.11115674f, -0.03487707f, -0.08509082f, 
    -0.38851798f, 0.24465217f, 0.19043733f, 0.07467443f, -0.05554628f, 0.09971776f, -0.15364821f, -0.03106559f, 
    -0.02935264f, -0.08226110f, 0.05094142f, -0.01016351f, 0.14098458f, 0.05354653f, -0.05234100f, -0.00324719f, 
    0.08933714f, 0.02896140f, -0.03011647f, -0.01372875f, -0.03654898f, -0.08415684f, 0.01706099f, -0.17734493f, 
    -0.09534683f, 0.23129247f, 0.03111685f, 0.11602120f, 0.09811656f, 0.04173733f, 0.06214746f, -0.04730847f, 
    0.02842471f, -0.11396062f, -0.04031513f, -0.02711869f, 0.18829288f, -0.25754830f, -0.05577181f, -0.11541017f, 
    0.04646496f, -0.04150433f, 0.08863311f, -0.00029279f, 0.04061364f, -0.12140554f, 0.01329748f, 0.13934185f, 
    0.07213658f, -0.41470534f, -0.12110741f, -0.21290362f, -0.09538355f, 0.00166049f, 0.13589162f, 0.15553543f, 
    0.01605684f, 0.06586944f, -0.00695932f, -0.07864963f, 0.25614876f, -0.05179868f, -0.14937723f, 0.01090247f, 
    0.09504855f, 0.03989500f, -0.00055137f, 0.08633158f, -0.05156315f, 0.00020634f, 0.03689072f, -0.06349069f, 
    0.00601057f, 0.20546065f, -0.14239490f, -0.07425954f, 0.01394432f, -0.03456197f, -0.20660684f, -0.05692373f, 
    0.01119144f, -0.05809016f, -0.04229999f, 0.20831028f, -0.11706451f, -0.16188583f, 0.29861638f, -0.20904267f, 
    0.13531992f, -0.17076740f, 0.03044082f, -0.03228133f, -0.03812160f, 0.00673150f, 0.04679265f, 0.06487127f, 
    0.03659983f, 0.12834372f, -0.01885402f, -0.11891963f, -0.07010421f, -0.12612365f, 0.02650390f, 0.15839666f, 
    0.01710589f, 0.09106226f, 0.00750443f, 0.15284190f, -0.17259797f, 0.11893579f, -0.17880417f, 0.04540620f, 
    0.08280221f, 0.03580417f, 0.00011988f, 0.06338114f, -0.03047534f, 0.01588926f, 0.02010790f, -0.00543585f, 
    0.17400540f, 0.05333412f, -0.10613330f, -0.19938470f, -0.00847988f, 0.01953405f, 0.02759534f, -0.05621708f, 
    0.18667157f, 0.05348086f, 0.17467195f, 0.12599187f, 0.17450227f, 0.27430749f, -0.32903653f, 0.13063502f, 
    -0.00740484f, -0.00611319f, 0.25290143f, 0.08236831f, -0.01841403f, 0.11256655f, -0.05655699f, 0.00120780f, 
    0.22691892f, 0.20084207f, 0.14539596f, -0.23469917f, 0.02538785f, 0.05691747f, -0.01980586f, 0.02362704f, 
    0.00502380f, -0.08697585f, -0.02143239f, -0.08168767f, -0.06373470f, 0.05676893f, -0.04356444f, 0.04084769f, 
    0.00420786f, 0.01154378f, -0.05325020f, -0.06360080f, -0.00374786f, -0.00954192f, -0.12393350f, -0.09808636f, 
    0.17563392f, 0.24394877f, 0.25542325f, -0.07813240f, -0.06084845f, -0.13502315f, -0.10193738f, -0.00734060f, 
    0.06193401f, -0.00733163f, -0.00352053f, -0.03295070f, 0.42431960f, -0.12578078f, -0.02000238f, -0.20228748f, 
    -0.06101728f, 0.29405370f, -0.09894376f, 0.11901465f, 0.12269528f, 0.05049294f, -0.03579608f, -0.13511395f, 
    -0.05572531f, 0.11347402f, -0.05104799f, -0.42823586f, -0.10280099f, -0.03365756f, 0.10981950f, 0.05705587f, 
    0.00962056f, 0.00393326f, -0.00072359f, 0.00383507f, 0.04616963f, -0.24480575f, -0.00041629f, -0.09847872f, 
    0.02873494f, -0.08763764f, -0.04939158f, 0.13147485f, -0.13015211f, -0.07566013f, -0.11750983f, -0.02690828f, 
    0.25772399f, 0.29414597f, 0.08152806f, -0.03832575f, -0.01057801f, -0.08532399f, 0.06432646f, 0.10067261f, 
    0.06614269f, 0.02789808f, 0.17549975f, -0.01391492f, -0.12763418f, 0.15806313f, 0.15449578f, -0.11048477f, 
    0.03098246f, 0.01027646f, -0.00770014f, 0.00534499f, 0.02415106f, 0.02602943f, 0.04861650f, -0.00662069f, 
    0.02900042f, -0.02007750f, 0.41746846f, 0.24960732f, -0.05349389f, 0.11663260f, -0.02263978f, -0.01818221f, 
    -0.05436252f, -0.28036043f, -0.02467861f, -0.00758546f, -0.03930716f, 0.21618153f, -0.18073685f, -0.19534335f, 
    -0.04439828f, -0.06536834f, -0.10179445f, 0.07648385f, 0.01135169f, -0.07078554f, 0.00638735f, 0.02825147f, 
    0.28793341f, -0.35114375f, -0.05408031f, -0.13729401f, 0.07158444f, 0.02919347f, 0.11429720f, -0.04836239f, 
    0.12541018f, 0.00251092f, 0.06634291f, -0.17248404f, 0.18760246f, -0.04753708f, -0.00190215f, 0.02242951f, 
    0.06393397f, 0.12998231f, 0.03581790f, 0.05547575f, 0.02161514f, -0.02637647f, -0.04311357f, -0.02502121f, 
    -0.68411130f, 0.30544969f, -0.14185475f, 0.05073290f, 0.05688955f, 0.06544606f, -0.03860506f, -0.02434699f, 
    -0.03140039f, 0.10887076f, -0.13397110f, 0.01146109f, 0.08431685f, 0.36439231f, -0.06382575f, 0.06760767f, 
    -0.07292929f, 0.01743376f, 0.07236434f, -0.04681835f, 0.03193764f, -0.07412005f, -0.01991765f, -0.14038032f, 
    -0.14537852f, -0.18151370f, -0.04514389f, 0.18552080f, -0.14031617f, -0.00719095f, -0.07206692f, -0.02846189f, 
    -0.14763466f, 0.02113645f, -0.01868717f, 0.01869009f, -0.02973436f, -0.05668245f, -0.21538509f, 0.09519809f, 
    0.04051058f, -0.06631123f, 0.08192127f, -0.09207925f, 0.22164299f, 0.17490043f, 0.16539772f, 0.38479856f, 
    -0.14852004f, 0.04009848f, -0.13677432f, -0.13569665f, -0.02911250f, -0.09166978f, 0.14408630f, -0.07625614f, 
    -0.00825283f, -0.01591321f, -0.08702780f, 0.02575444f, 0.30120137f, 0.00504008f, 0.11502834f, -0.27548262f, 
    0.11781774f, 0.02390717f, 0.04968611f, -0.01576020f, 0.02991660f, 0.10636363f, 0.04265951f, 0.04365116f, 
    -0.00769847f, -0.41855669f, 0.29014561f, 0.00966737f, -0.08505356f, -0.08260047f, 0.00401018f, 0.02735617f, 
    -0.00668524f, 0.10826734f, 0.02975505f, 0.04777747f, -0.05426988f, 0.06209759f, -0.00501372f, 0.06463923f, 
    -0.12478083f, -0.05379704f, -0.00291253f, 0.06367105f, -0.04973816f, -0.09413806f, -0.07255747f, -0.12709564f, 
    0.08163367f, 0.01514485f, 0.06895676f, 0.23527132f, -0.01018411f, -0.09138096f, -0.04602881f, -0.08656245f, 
    0.17107628f, 0.11601967f, -0.12483020f, 0.05420931f, 0.18228139f, -0.03265719f, 0.14560401f, -0.03106249f, 
    0.07660346f, 0.02237113f, -0.05678466f, -0.03040276f, -0.02375092f, 0.03389716f, -0.15510027f, -0.07906078f, 
    -0.14964879f, -0.03138544f, -0.15078612f, 0.23502152f, 0.19206479f, -0.03451012f, 0.13638939f, 0.05327474f, 
    -0.05154508f, -0.05741612f, -0.10558246f, -0.08776591f, 0.13084978f, 0.17050833f, -0.01204892f, -0.10530832f, 
    0.05292105f, -0.05426491f, 0.06460338f, -0.08484249f, 0.17696273f, 0.15132183f, 0.21807861f, 0.40105763f, 
    0.21506858f, -0.35864228f, 0.07278926f, -0.14705424f, 0.15012099f, 0.20395213f, -0.17899673f, 0.04395816f, 
    0.11051852f, -0.00126610f, -0.00060741f, -0.07535708f, -0.08427884f, 0.11068042f, -0.14372982f, -0.08618202f, 
    0.13604440f, 0.10697412f, 0.03845366f, -0.01731287f, -0.03184749f, -0.05026055f, -0.01912055f, -0.03464155f, 
    0.25412133f, 0.33313856f, 0.31927332f, 0.07353617f, -0.06971191f, -0.08468571f, -0.05278467f, -0.10535385f, 
    -0.06371168f, -0.12382501f, 0.03955937f, 0.14912230f, -0.10768197f, 0.30648509f, 0.11602673f, 0.07775507f, 
    0.00677477f, -0.14987093f, -0.00027534f, -0.07130979f, 0.06103512f, -0.06154469f, -0.18575703f, 0.08366644f, 
    -0.36252937f, 0.04349655f, -0.06330977f, -0.14453833f, -0.10352226f, -0.02077756f, -0.00823395f, -0.04193771f, 
    0.11956802f, 0.03590994f, -0.05267218f, -0.05395855f, -0.07674035f, 0.04658177f, -0.19428788f, -0.00157910f, 
    -0.18317451f, 0.06253879f, 0.16726184f, -0.03707406f, 0.07432808f, 0.11581156f, -0.05471687f, -0.02704989f, 
    0.07485325f, 0.07430137f, 0.25557306f, 0.06481284f, -0.08999876f, -0.06048255f, -0.08974727f, -0.07517448f, 
    0.18338706f, -0.06036545f, 0.06810798f, 0.27031067f, 0.04308221f, 0.26078197f, -0.30675912f, -0.08104040f, 
    0.09309079f, 0.17346896f, 0.15966931f, -0.04078474f, 0.16496946f, 0.03889387f, -0.10183793f, 0.00336463f, 
    -0.21855173f, -0.06342068f, 0.19134048f, -0.11875817f, 0.06446148f, 0.05489273f, 0.01928152f, 0.03484715f, 
    -0.05282025f, -0.11561228f, -0.00584644f, -0.12031616f, 0.18767801f, 0.04661164f, 0.04300601f, 0.08176295f, 
    0.02309554f, 0.02509687f, -0.03269210f, 0.01132053f, 0.09347974f, -0.03243677f, -0.12127613f, -0.01727045f, 
    -0.09344676f, -0.06131016f, 0.06940978f, -0.01428790f, -0.03193461f, 0.01191860f, -0.07614455f, 0.05841348f, 
    0.07787140f, 0.04868758f, 0.02635018f, -0.05063298f, -0.09262355f, -0.05379303f, 0.00312565f, -0.23425288f, 
    0.21220368f, 0.07042342f, 0.00798767f, -0.00827819f, -0.03424395f, -0.03714400f, 0.00249798f, 0.07501348f, 
    -0.29768518f, 0.17355964f, 0.20884255f, -0.09804817f, 0.03208032f, -0.03219163f, -0.03076417f, -0.04854555f, 
    0.00647185f, -0.02810187f, 0.00439618f, -0.03461786f, 0.12040161f, 0.02935564f, 0.00534262f, -0.10086547f, 
    0.09041249f, 0.01203195f, -0.00375189f, 0.02565310f, -0.07990143f, 0.02151582f, 0.06972469f, 0.00168498f, 
    0.00478322f, 0.15911035f, 0.05937805f, 0.03066223f, 0.11618081f, 0.10591886f, 0.00790512f, -0.02188314f, 
    0.12522492f, 0.02972755f, 0.14469226f, 0.01693682f, -0.25684842f, -0.11291965f, 0.04316884f, 0.09744754f, 
    -0.04285991f, -0.06046175f, -0.04408828f, 0.00174061f, 0.02556338f, -0.07857110f, 0.05064865f, -0.02726377f, 
    -0.05179205f, -0.13806190f, -0.05933774f, 0.19545683f, 0.12324324f, 0.06136272f, -0.05650209f, -0.01408487f, 
    -0.13864373f, -0.10490500f, 0.00031650f, -0.04373271f, 0.20794460f, 0.14309855f, 0.46261686f, 0.15177956f, 
    -0.18298717f, -0.13465604f, -0.00998610f, -0.01949625f, 0.06844159f, 0.04969636f, 0.10135818f, 0.19362375f, 
    0.09357753f, 0.05364366f, 0.00776556f, -0.14381510f, 0.00996178f, -0.02419333f, -0.03369513f, -0.05701553f, 
    0.15629299f, -0.11248855f, 0.07141321f, 0.13055716f, 0.02006289f, -0.18693154f, -0.09191103f, 0.02446927f, 
    -0.00224349f, 0.10347387f, 0.11502639f, -0.01833778f, 0.01383160f, -0.17626257f, -0.13864720f, -0.11138620f, 
    -0.04518066f, 0.00023338f, -0.12318140f, -0.14419393f, 0.06887963f, -0.26535112f, -0.06928314f, 0.08645112f, 
    0.01549959f, -0.09864616f, 0.05278094f, 0.03342049f, -0.09309392f, 0.18716845f, -0.08101160f, 0.03586001f, 
    0.01398398f, 0.11591452f, 0.06353351f, 0.03693623f, -0.00824702f, -0.09244858f, -0.00313036f, -0.09631248f, 
    0.02276513f, -0.00285815f, -0.04401144f, 0.03144602f, -0.02907589f, 0.00081138f, 0.00535144f, 0.01315373f, 
    -0.05275004f, -0.03115530f, 0.01678355f, 0.01059217f, 0.00039890f, -0.05669027f, 0.01878279f, -0.04754860f, 
    0.00724072f, -0.02971344f, 0.02314925f, -0.04053366f, -0.04953248f, 0.00526323f, -0.01421805f, -0.01169452f, 
    -0.02384734f, -0.05818000f, -0.05245857f, -0.01548314f, -0.02216718f, -0.00856772f, 0.02500269f, -0.00935247f, 
    0.01067153f, -0.04685826f, -0.03925171f, 0.01013617f, -0.01608825f, 0.02959087f, 0.04470058f, -0.02637581f, 
    -0.03971372f, -0.01121292f, -0.04695789f, 0.01447512f, 0.02392903f, -0.01004468f, -0.00110575f, -0.02613712f, 
    0.00397212f, 0.04306832f, -0.03178309f, 0.00876569f, -0.01344123f, -0.02951089f, 0.01024982f, -0.05539409f, 
    0.00756528f, 0.03868204f, -0.03198761f, 0.03229051f, 0.00642119f, -0.04239978f, -0.03281084f, -0.04885646f, 
    0.03559391f, -0.00232267f, -0.02620328f, 0.00444185f, 0.04871770f, 0.02192780f, -0.02483693f, 0.03260302f, 
    -0.00108092f, 0.02573276f, -0.01294087f, -0.01796818f, -0.03730559f, -0.03372106f, 0.00920145f, -0.01651923f, 
    0.00801241f, 0.00548076f, -0.05315788f, -0.01282515f, -0.04866687f, 0.00782263f, -0.04033267f, -0.01930718f, 
    0.03356877f, 0.00832358f, -0.05461652f, 0.02287077f, -0.03226168f, 0.01742814f, 0.01672517f, 0.03782998f, 
    -0.02434992f, -0.01942507f, -0.04266474f, 0.02879171f, 0.02357165f, 0.03033625f, -0.04650318f, 0.01565042f, 
    -0.01086480f, -0.00898065f, -0.04095178f, -0.02133542f, 0.02843965f, -0.04979016f, -0.04821262f, 0.00866865f, 
    0.03037734f, 0.00401268f, -0.02121988f, -0.02627189f, 0.02049847f, -0.03519037f, -0.01413329f, 0.01629350f, 
    -0.00171592f, -0.03395313f, -0.00903489f, -0.03548878f, -0.02014968f, 0.00623625f, -0.00359733f, 0.00074787f, 
    -0.02646729f, 0.03564940f, 0.01684341f, 0.02639554f, -0.00167344f, -0.02667406f, -0.01616369f, 0.00695776f, 
    -0.03669140f, 0.00450216f, 0.03922719f, -0.02320202f, 0.00813005f, -0.02921177f, -0.01473059f, -0.00531443f, 
    -0.02223447f, 0.04090925f, -0.00129251f, 0.01539570f, -0.02851013f, 0.00417759f, -0.00859207f, 0.03343659f, 
    -0.03807474f, 0.01871866f, -0.01496912f, 0.03861015f, 0.00194516f, -0.03414059f, 0.01618031f, -0.02294734f, 
    0.01384793f, -0.03358970f, 0.02850422f, 0.03389795f, -0.02203063f, 0.02333315f, 0.00768678f, 0.02623598f, 
    -0.05375478f, -0.00072819f, 0.03468110f, 0.01150757f, 0.03944492f, 0.03894430f, -0.02370753f, -0.02908442f, 
    0.01682181f, -0.02437267f, -0.05232177f, -0.03335997f, -0.01402670f, -0.03988379f, 0.02351149f, -0.01876363f, 
    -0.04706135f, -0.04455523f, -0.04429759f, -0.00511036f, -0.02052361f, 0.03142912f, 0.04342371f, -0.05635185f, 
    0.02454039f, -0.00220262f, 0.03300936f, 0.02903812f, -0.02030726f, -0.04628706f, -0.05800822f, -0.03798852f, 
    -0.01322893f, 0.02229306f, -0.00546261f, 0.03821782f, 0.00662759f, -0.02036791f, -0.03704827f, 0.04141669f, 
    -0.03057457f, 0.04179299f, -0.03774757f, -0.02277033f, 0.01947052f, -0.04735537f, -0.03936962f, -0.05083338f, 
    0.03739470f, -0.05554193f, 0.02093535f, -0.01601029f, -0.04569846f, -0.05405965f, 0.00604437f, -0.02536303f, 
    -0.02517118f, -0.03862805f, 0.00622615f, 0.03029252f, 0.01123144f, -0.03678865f, -0.03753518f, 0.01941566f, 
    0.04568682f, -0.00373561f, 0.02760542f, -0.00226285f, -0.04037223f, 0.01789406f, 0.01531051f, 0.03657581f, 
    -0.02315874f, -0.00744277f, 0.01925871f, -0.01141605f, 0.02450575f, 0.00394097f, -0.00287640f, 0.03580925f, 
    -0.02630943f, -0.05335243f, 0.02988091f, 0.03645567f, -0.02941276f, -0.04478064f, 0.05139772f, -0.02750685f, 
    -0.04555180f, 0.01840341f, -0.03295280f, 0.01551111f, 0.01081215f, 0.03729064f, -0.00880790f, 0.00526182f, 
    -0.00848620f, 0.00482216f, -0.01165079f, -0.03717424f, -0.01352468f, 0.01978515f, -0.02681467f, 0.04184513f, 
    -0.00805106f, 0.04488673f, -0.05697315f, -0.01019667f, 0.00651968f, 0.01463567f, 0.01944583f, -0.01634000f, 
    0.02878882f, -0.04412957f, -0.05779352f, -0.02861834f, -0.02031093f, -0.01824255f, 0.01370972f, -0.05391299f, 
    0.00553863f, 0.03980646f, -0.02539570f, 0.02017152f, -0.00601169f, 0.00286885f, 0.02968767f, -0.01205662f, 
    -0.04283442f, 0.04475477f, 0.00814521f, 0.03466381f, -0.04983664f, 0.00558322f, 0.03372292f, 0.01731794f, 
    -0.03452667f, -0.01984032f, -0.04003151f, -0.05937626f, -0.05766570f, -0.05545770f, 0.02444458f, -0.02757441f, 
    0.00242248f, 0.00448198f, -0.04850808f, -0.00584997f, -0.04923008f, 0.02029009f, -0.03610317f, 0.02709585f, 
    -0.04377866f, 0.02955945f, -0.01083778f, -0.01664445f, 0.02177899f, 0.02136397f, 0.02373242f, 0.02851671f, 
    -0.03049855f, -0.00412327f, 0.02197666f, 0.03792917f, -0.02832671f, 0.01616892f, -0.00415470f, -0.01137259f, 
    -0.04500911f, 0.01593449f, -0.02629443f, 0.01926492f, 0.00783904f, -0.00250635f, -0.01065748f, 0.03311322f, 
    0.00222013f, 0.01725464f, -0.05565328f, -0.04644851f, -0.01578888f, 0.02919574f, -0.02659024f, -0.02008625f, 
    -0.05898297f, 0.02231443f, 0.01623772f, 0.02451798f, -0.00689196f, -0.01829435f, 0.00046051f, -0.03071376f, 
    -0.04131395f, 0.00301993f, -0.03108642f, -0.02604279f, -0.02430676f, 0.00827025f, 0.02167538f, 0.01900991f, 
    -0.02613511f, -0.01320464f, -0.05695717f, -0.01674839f, -0.04545619f, -0.03852943f, -0.04762960f, -0.03201259f, 
    -0.03800927f, 0.02891820f, 0.02845903f, -0.04350314f, -0.00506872f, -0.03292951f, -0.00524073f, -0.05812394f, 
    -0.04453563f, 0.00475794f, -0.02258927f, 0.02348926f, -0.04586504f, -0.04710889f, -0.00427074f, 0.04094495f, 
    0.00906619f, -0.00415936f, -0.00640324f, 0.03059902f, -0.01399117f, 0.04446894f, 0.03202079f, -0.00781173f, 
    -0.00808895f, -0.01241705f, 0.04524034f, -0.02953845f, -0.02302585f, 0.00333346f, -0.03777844f, -0.01694790f, 
    0.03596532f, -0.04726480f, -0.02178927f, -0.03996775f, 0.03868916f, -0.05342264f, -0.02344377f, 0.01698070f, 
    -0.05094505f, 0.03792325f, -0.05208488f, 0.00209519f, 0.02501755f, -0.05586956f, 0.00805373f, -0.04424438f, 
    -0.03119084f, 0.02202434f, -0.01745285f, 0.03717499f, 0.00155675f, 0.02003809f, 0.04066683f, -0.01859543f, 
    -0.03033379f, -0.04611425f, -0.04321910f, -0.00807145f, -0.01405707f, 0.03152631f, 0.01630217f, 0.02843987f, 
    0.02084007f, 0.03896751f, -0.05774827f, 0.00511929f, 0.01956914f, -0.05651871f, 0.04057971f, 0.00397250f, 
    0.01064125f, -0.01798292f, 0.01022136f, -0.02033508f, 0.00812786f, -0.03124584f, 0.01076517f, 0.02210861f, 
    -0.03958589f, 0.03140035f, 0.00941142f, -0.00741533f, 0.03466579f, 0.03142367f, -0.05328854f, 0.01729907f, 
    0.01549875f, -0.02873529f, -0.05556997f, -0.01437454f, -0.04558205f, -0.02085679f, 0.01890605f, -0.01855877f, 
    -0.02885008f, 0.03616637f, -0.01273132f, -0.02663546f, 0.02714783f, 0.04364073f, 0.00382320f, -0.01988026f, 
    0.00249996f, -0.03772976f, -0.03024823f, 0.01232477f, -0.03366659f, 0.00512159f, -0.01899237f, -0.00728772f, 
    0.02152648f, 0.00546785f, -0.02841114f, 0.02021336f, 0.00855873f, -0.03656259f, -0.01994665f, 0.01988858f, 
    0.02358270f, 0.00498733f, 0.03406758f, -0.05423840f, -0.02292080f, -0.00727976f, 0.03103121f, 0.02715808f, 
    -0.01668810f, 0.03363010f, -0.03147166f, 0.02161194f, -0.01300161f, -0.05163553f, -0.05291092f, -0.04079966f, 
    -0.03337935f, 0.00777702f, 0.00523175f, 0.01326373f, 0.00961773f, -0.02088553f, 0.00930596f, -0.03142044f, 
    -0.03638147f, -0.05676624f, -0.04192365f, -0.04340076f, 0.03574782f, 0.02862503f, 0.03504506f, 0.00487172f, 
    0.00026481f, 0.00763653f, 0.03844618f, -0.02949636f, 0.02130911f, -0.01477468f, -0.05817992f, -0.02219130f, 
    -0.01484416f, 0.02175871f, -0.04638271f, -0.05050562f, -0.02805984f, -0.05008017f, 0.03222356f, 0.01195984f, 
    0.04412356f, 0.00722221f, 0.01100063f, -0.02188643f, -0.03558924f, -0.02390767f, -0.01321124f, -0.04075648f, 
    0.03342490f, 0.00296364f, -0.03849199f, -0.02964886f, 0.00609014f, 0.01068389f, -0.04506133f, 0.01358134f, 
    -0.00737448f, -0.04040909f, -0.01468929f, -0.01131267f, 0.02023684f, -0.02670025f, 0.04271175f, -0.05248272f, 
    0.00007720f, -0.02849896f, -0.00072856f, 0.00172097f, 0.04087934f, -0.00008836f, 0.03053001f, 0.02025349f, 
    0.03379366f, 0.03423784f, -0.00488017f, -0.02595022f, 0.04331093f, 0.05407687f, 0.02597794f, -0.00987536f, 
    0.00521961f, 0.04205035f, 0.03482710f, 0.02655428f, -0.02974109f, -0.04856254f, -0.00753800f, -0.04108706f, 
    0.00507750f, 0.01489457f, -0.00999049f, -0.01777880f, -0.02935810f, 0.03234676f, -0.03870392f, 0.04182105f, 
    -0.01408023f, -0.01731073f, 0.02851574f, 0.02194878f, 0.02287783f, -0.00593017f, -0.02021499f, -0.03807047f, 
    -0.03331534f, -0.03442010f, 0.01479926f, -0.04052919f, -0.00011100f, 0.01603897f, -0.02343514f, -0.03866012f, 
    0.00815213f, -0.02598972f, 0.04111161f, -0.03882061f, -0.02802564f, 0.03866132f, 0.03752301f, -0.04421962f, 
    -0.01755013f, -0.04044657f, -0.04273193f, -0.05558531f, 0.01855337f, -0.03427481f, -0.01498205f, -0.02623498f, 
    -0.02314383f, -0.05495828f, 0.00716618f, -0.04685793f, -0.05141051f, 0.03957768f, -0.01424525f, 0.02136583f, 
    -0.03176860f, -0.03436121f, -0.04853642f, 0.03205296f, -0.04045423f, -0.01749060f, -0.03431610f, 0.02784281f, 
    0.03278314f, -0.00665915f, 0.02476064f, -0.00410593f, -0.04004440f, -0.04903637f, -0.03156292f, 0.04153978f, 
    -0.03413920f, -0.05404540f, 0.04062464f, -0.04626472f, 0.03626895f, 0.01592510f, 0.01193598f, -0.00750365f, 
    0.03402599f, 0.01971238f, -0.02443109f, -0.00127539f, -0.02974368f, 0.01400687f, -0.03295767f, -0.01752060f, 
    0.01958380f, -0.03395342f, 0.01791865f, 0.03788778f, -0.05400415f, 0.02137574f, -0.02416824f, -0.00492187f, 
    -0.02316559f, -0.04226535f, 0.01934349f, -0.01403202f, -0.00795742f, -0.04796578f, -0.03140723f, -0.03152291f, 
    0.00973367f, 0.03219222f, 0.00242709f, 0.02827989f, -0.05275553f, -0.00689020f, -0.02450598f, -0.01067920f, 
    -0.05650422f, -0.03334918f, 0.00529338f, -0.03646591f, 0.01602628f, -0.02108711f, -0.00504605f, -0.03025358f, 
    0.01009252f, -0.03439131f, 0.03775633f, -0.01950347f, -0.00633270f, 0.00304682f, -0.03204558f, 0.04444011f, 
    -0.00721948f, -0.02925312f, 0.02513794f, 0.01608289f, 0.00224759f, -0.03632177f, -0.05660854f, 0.03279950f, 
    0.04604455f, -0.02350161f, 0.00669810f, 0.01124130f, -0.05312445f, 0.00096729f, 0.01435157f, -0.00973017f, 
    -0.03649612f, -0.04104326f, -0.02398366f, -0.01325861f, -0.02802551f, -0.04094371f, 0.00374471f, -0.04252590f, 
    0.00041497f, -0.05436018f, -0.02420242f, -0.01630474f, -0.03983219f, 0.02962365f, 0.00619017f, -0.03683708f, 
    -0.03894785f, 0.02115131f, 0.01999851f, -0.04588031f, 0.02572830f, 0.02689018f, 0.01487078f, 0.02538554f, 
    -0.02209787f, -0.05457272f, -0.05642445f, -0.05155573f, -0.05541817f, 0.01005223f, -0.02405111f, -0.00376916f, 
    -0.02068669f, 0.03760659f, -0.04755136f, -0.00807901f, 0.00266485f, -0.03162122f, -0.02390287f, 0.01749977f, 
    -0.02536167f, -0.07751948f, -0.04301417f, 0.06562720f, 0.06896899f, 0.15081088f, 0.00521400f, 0.24288511f, 
    0.05460296f, -0.02058628f, -0.02019489f, 0.00335508f, -0.02598920f, 0.00449708f, -0.06032459f, -0.06419130f, 
    0.05678520f, -0.23801370f, -0.17111719f, -0.18268493f, -0.00130284f, -0.12782328f, -0.19148798f, -0.31328842f, 
    -0.09454212f, 0.02551797f, -0.19105014f, 0.05591780f, 0.02128465f, 0.17563030f, 0.18296964f, 0.08160776f, 
    -0.02294734f, 0.15606897f, 0.11746547f, 0.06708592f, 0.16627038f, 0.25060502f, 0.13620788f, 0.10066547f, 
    -0.09847915f, -0.04631143f, -0.08934323f, 0.10326878f, 0.24623090f, 0.02082816f, -0.06983891f, 0.06384131f, 
    -0.33719125f, 0.17424844f, 0.14573173f, -0.01928633f, 0.13096189f, 0.09130429f, -0.22177018f, 0.17963469f, 
    0.16783920f, -0.01795301f, -0.15761319f, -0.04573220f, -0.14976333f, -0.10528074f, -0.06604112f, 0.03176257f, 
    0.10775482f, 0.14880382f, 0.15297076f, 0.14036378f, -0.05338517f, -0.02774468f, -0.06558765f, 0.02144063f, 
    -0.09043336f, 0.02211826f, 0.11654690f, 0.26294693f, 0.07580552f, -0.11453240f, -0.04399661f, -0.05057234f, 
    0.09633811f, -0.05320887f, -0.02405186f, 0.31416997f, 0.01507066f, -0.18714912f, 0.11512206f, -0.13336389f, 
    -0.11126781f, -0.10442308f, -0.20216505f, -0.12083181f, 0.23870382f, 0.13298734f, 0.24846303f, 0.09003489f, 
    0.00190041f, -0.13176104f, 0.07654130f, -0.03981839f, 0.05227279f, -0.13801731f, 0.17306232f, 0.25267127f, 
    0.06767233f, -0.05667234f, 0.00364994f, 0.08771078f, 0.06653835f, 0.15198669f, -0.01034688f, 0.05586547f, 
    -0.06102140f, 0.07325848f, -0.09290867f, -0.04458231f, -0.03080702f, -0.19799048f, -0.07244124f, -0.47552785f, 
    0.06219308f, 0.02902079f, 0.13658920f, 0.17742071f, -0.01951160f, -0.00432474f, -0.18349576f, 0.05177749f, 
    0.07665654f, -0.04270231f, -0.00800050f, 0.01271376f, -0.01171210f, 0.09239831f, -0.09545889f, 0.17164405f, 
    0.03484938f, -0.08183203f, 0.21816210f, 0.05261764f, 0.15283678f, -0.08374668f, -0.01051188f, -0.00809601f, 
    0.05797748f, -0.00040597f, 0.12747349f, -0.01666781f, -0.03530018f, -0.02136919f, -0.00042419f, 0.03016717f, 
    0.20481715f, 0.29103699f, 0.16700880f, -0.03385027f, -0.10984766f, 0.02399944f, -0.16821338f, 0.12550455f, 
    0.04123467f, -0.01493205f, 0.12866619f, -0.05135792f, 0.02133389f, -0.08022250f, 0.11874815f, 0.06847942f, 
    0.06091010f, 0.05892202f, -0.04897721f, 0.12710288f, 0.13997641f, 0.21732661f, -0.04016268f, 0.12116763f, 
    -0.01308117f, 0.05320710f, 0.06753400f, -0.04794656f, -0.24155580f, -0.09667790f, -0.12407551f, 0.02046197f, 
    0.03845597f, -0.22800325f, -0.10554757f, 0.03735302f, 0.01355466f, 0.01422797f, -0.03873942f, 0.12577446f, 
    -0.04805442f, 0.00779712f, 0.11268108f, -0.03464116f, 0.01793830f, -0.04324959f, -0.12880725f, 0.03176919f, 
    -0.12503493f, -0.16187021f, -0.07296710f, -0.29275480f, -0.18832718f, -0.07673145f, -0.16729316f, -0.01104567f, 
    0.07817283f, 0.09648772f, 0.01410139f, 0.04355868f, -0.06998569f, 0.02389329f, -0.11794467f, -0.00275845f, 
    0.09697855f, 0.05019440f, 0.11672688f, 0.11161833f, 0.09689442f, -0.01628327f, 0.17111959f, 0.08734863f, 
    -0.04504995f, 0.02965152f, 0.13293977f, 0.06418493f, -0.01427046f, -0.02560721f, 0.08799955f, 0.00019311f, 
    -0.09717278f, -0.20396648f, -0.18340804f, -0.12315244f, 0.07280490f, -0.00988034f, 0.22012569f, 0.17019930f, 
    -0.12144231f, 0.03359653f, 0.09914009f, 0.09577369f, 0.12049039f, 0.06604958f, 0.15084690f, 0.03368946f, 
    -0.11738830f, -0.11238739f, -0.03633074f, 0.03474951f, -0.11758133f, -0.12336509f, -0.08384462f, 0.18123770f, 
    0.31792897f, 0.02274187f, -0.13898171f, -0.25297627f, 0.02378348f, -0.12913854f, 0.04309179f, -0.15143318f, 
    0.24667399f, 0.04964670f, 0.11277308f, 0.04439544f, -0.02332289f, -0.13591324f, 0.05753028f, 0.04783726f, 
    -0.01667036f, -0.03424130f, -0.08707690f, -0.10716991f, 0.09629242f, 0.21039078f, 0.10143837f, -0.20112324f, 
    -0.04873880f, -0.00200394f, -0.00615925f, -0.08701032f, 0.25713658f, 0.13804251f, 0.17138328f, 0.10718362f, 
    -0.08071905f, -0.00929385f, 0.05160137f, -0.03686133f, -0.05833720f, 0.06181654f, 0.02442827f, 0.11539656f, 
    -0.12295403f, -0.11100004f, -0.21212023f, -0.19318604f, -0.09120161f, 0.02316286f, 0.16951099f, 0.18960026f, 
    0.02940142f, -0.02880376f, 0.03349663f, 0.05510955f, 0.10205775f, -0.02729419f, -0.04413236f, 0.06758878f, 
    -0.13543293f, 0.00318645f, -0.36157840f, 0.17978005f, 0.05310247f, -0.11148535f, 0.15259768f, 0.03045122f, 
    0.03114804f, 0.12148207f, 0.10043558f, 0.14281555f, 0.03409750f, -0.11400943f, 0.18115146f, -0.05421526f, 
    0.01077095f, -0.06607615f, -0.13179964f, 0.05086450f, 0.02448159f, -0.06117851f, -0.02014730f, -0.07902876f, 
    0.07028013f, 0.30834335f, -0.02291667f, -0.06279344f, -0.02987469f, 0.01053049f, -0.10513124f, -0.13351223f, 
    0.08867231f, 0.22647457f, 0.06689525f, -0.05847334f, -0.25887933f, -0.17725596f, -0.18619476f, -0.08635665f, 
    0.00125352f, -0.12872346f, -0.10202443f, -0.11346693f, 0.04763937f, 0.10900239f, 0.07963364f, 0.03373765f, 
    0.14883490f, 0.18573800f, 0.21554790f, -0.45804402f, 0.09124494f, -0.08157649f, 0.08166262f, 0.02103780f, 
    0.10866629f, -0.01312841f, 0.12363160f, 0.18325987f, 0.09921937f, 0.01944515f, 0.02807783f, 0.12506832f, 
    0.11863069f, 0.01082873f, 0.18609995f, 0.26304480f, 0.00124402f, 0.03241377f, -0.07578658f, 0.08305156f, 
    -0.03354574f, -0.00842824f, -0.05839068f, -0.25584832f, 0.05314417f, -0.07375044f, -0.03378451f, -0.07017757f, 
    -0.08256629f, 0.01436686f, -0.03583730f, -0.12471543f, 0.10025298f, -0.05424001f, -0.05946430f, 0.19882679f, 
    0.06352392f, 0.09904705f, 0.04025319f, -0.09943161f, 0.15331519f, 0.22392961f, 0.10867219f, 0.35996410f, 
    -0.01977290f, -0.15790007f, -0.10238201f, -0.23049036f, 0.07158607f, 0.06555417f, -0.07671136f, 0.04460690f, 
    0.15277132f, -0.22525351f, -0.15624735f, -0.01728364f, 0.05104444f, 0.03940760f, 0.28009439f, 0.15209502f, 
    -0.17964701f, -0.02094100f, 0.11177482f, -0.09853735f, -0.19650939f, 0.10370744f, 0.02991216f, 0.14620915f, 
    0.23394142f, -0.03798282f, -0.21715842f, -0.01709279f, 0.03148438f, 0.02833289f, 0.18017618f, 0.14198028f, 
    -0.14978860f, -0.00861973f, 0.16013013f, 0.13950773f, 0.28337225f, 0.18014200f, 0.13243034f, 0.05851910f, 
    -0.05999761f, 0.03861871f, -0.06715056f, 0.13101794f, -0.07331998f, -0.10109413f, 0.17373076f, -0.20472647f, 
    0.10406716f, 0.07098980f, -0.15199162f, 0.00649004f, -0.02140005f, 0.13481046f, -0.20014553f, -0.11573095f, 
    -0.12257761f, 0.10186235f, -0.02462239f, -0.17986980f, 0.38989586f, 0.08923907f, 0.12319797f, 0.12718517f, 
    0.04825957f, -0.01385198f, 0.05931058f, -0.16821945f, -0.26614499f, -0.02239393f, -0.17358895f, -0.03993854f, 
    -0.04876700f, 0.05938223f, -0.00553032f, 0.02280497f, -0.08194678f, 0.12128707f, -0.01742746f, -0.07845111f, 
    -0.12516733f, -0.08030587f, -0.02844875f, -0.21395104f, -0.07234717f, -0.07549892f, 0.23455684f, -0.02560486f, 
    -0.26123735f, -0.00021503f, 0.08877178f, -0.12215108f, -0.01619680f, 0.14769852f, 0.09400935f, 0.37050658f, 
    0.04186965f, -0.17453124f, -0.02850628f, -0.03887092f, 0.08663557f, 0.09206115f, 0.16046914f, 0.06518854f, 
    -0.01293390f, 0.00276814f, 0.08600257f, 0.04047846f, 0.07309322f, 0.08741089f, 0.12238251f, 0.02368484f, 
    0.19353643f, -0.10610490f, 0.09725683f, -0.15993677f, -0.07169086f, -0.03903347f, 0.10843219f, 0.18216746f, 
    0.07815596f, 0.08270142f, -0.19133243f, -0.09022277f, 0.11554383f, -0.03217601f, 0.03065173f, -0.10480137f, 
    -0.29397029f, -0.19656329f, 0.02347404f, 0.02442020f, 0.20736319f, -0.00866070f, 0.10733007f, -0.19836010f, 
    0.11844146f, -0.07123204f, 0.00514962f, -0.03654036f, 0.07085998f, 0.00505583f, -0.08264823f, 0.10947493f, 
    -0.19035499f, -0.07584579f, -0.00965123f, -0.12090039f, 0.08133920f, -0.15218091f, 0.01672700f, -0.07549367f, 
    0.06548630f, -0.12458491f, 0.01814007f, 0.04967379f, 0.03697916f, 0.20650610f, 0.18323520f, -0.08378907f, 
    -0.21458587f, 0.17725898f, 0.33155435f, -0.13626443f, 0.00761024f, -0.01695812f, -0.01657276f, -0.11332025f, 
    0.09002842f, -0.03685428f, -0.08389571f, 0.06555791f, 0.01184476f, 0.03223729f, -0.04587059f, -0.09975505f, 
    0.04291208f, 0.10217546f, 0.05451047f, 0.18394685f, 0.20410918f, 0.22491439f, 0.05685455f, -0.15097056f, 
    -0.18857634f, 0.12521794f, 0.11272155f, -0.00769334f, -0.03828257f, -0.12117498f, -0.10396669f, -0.01526831f, 
    0.09394453f, -0.05489361f, -0.10589263f, -0.02408172f, -0.11447574f, 0.08779352f, -0.05311343f, 0.25522932f, 
    -0.16328534f, -0.05509713f, -0.19480015f, -0.09811290f, 0.24268901f, 0.25339648f, 0.06100044f, 0.19125319f, 
    -0.02323353f, 0.16909935f, -0.06708571f, -0.18549111f, -0.00754298f, -0.04085257f, -0.12853122f, -0.10436320f, 
    -0.05507685f, 0.17515342f, -0.06118475f, 0.12354603f, -0.00149111f, -0.02685353f, 0.13634233f, 0.18935588f, 
    0.13899539f, 0.02923392f, -0.02595529f, -0.12567686f, 0.44687513f, 0.03125669f, 0.07602162f, -0.04415352f, 
    0.12736484f, 0.03739766f, 0.04874770f, 0.29275462f, -0.04222446f, -0.16789213f, -0.06055771f, 0.20009294f, 
    0.09682233f, -0.03937146f, 0.04842508f, -0.20724644f, -0.04366883f, 0.19057496f, 0.07944707f, 0.01356075f, 
    0.08793630f, 0.07536557f, 0.07668822f, 0.23613632f, 0.01507998f, -0.32234386f, -0.05206944f, -0.13374317f, 
    -0.01507145f, 0.05433093f, 0.05682525f, -0.04471857f, -0.19769777f, -0.03931180f, 0.05414689f, -0.10643329f, 
    0.12567499f, 0.05055872f, -0.05985578f, 0.01824663f, 0.03146002f, 0.02338745f, 0.18835247f, 0.32209474f, 
    0.05340159f, 0.22063863f, -0.03102318f, 0.08725572f, 0.37587142f, 0.09563403f, -0.17289098f, 0.03622691f, 
    0.06902776f, 0.09229438f, -0.02059090f, 0.06962702f, -0.08080710f, 0.02433410f, 0.10095594f, -0.02079592f, 
    -0.05197546f, 0.35135847f, 0.16838332f, 0.05757878f, 0.17162986f, -0.06291428f, -0.14894183f, -0.03946524f, 
    -0.13460536f, -0.10287645f, -0.01048495f, -0.21200606f, 0.76632464f, -0.05788657f, -0.11125813f, -0.05186960f, 
    0.14652066f, -0.02932834f, -0.05448046f, -0.15840660f, 0.03596108f, 0.07086009f, 0.13322194f, 0.08345417f, 
    0.12004720f, -0.09517660f, 0.14924671f, 0.04917637f, -0.10844097f, 0.02900140f, 0.05765823f, -0.07075726f, 
    -0.15121366f, -0.04933419f, -0.01596405f, -0.04873629f, 0.26414227f, 0.04000310f, 0.08224853f, 0.08692626f, 
    -0.05096614f, 0.11296530f, 0.02236153f, -0.02172177f, -0.12300163f, 0.01421889f, -0.05756236f, -0.16075680f, 
    -0.09970591f, -0.21894251f, -0.12785071f, 0.16941032f, -0.11626203f, -0.00989813f, 0.07567047f, -0.10890363f, 
    0.11540669f, -0.13868003f, -0.19648629f, -0.00860589f, 0.18486486f, 0.06688531f, -0.07984138f, -0.04801023f, 
    -0.02360484f, 0.01438710f, -0.01292266f, 0.29140836f, -0.14690520f, 0.10373050f, 0.02946251f, -0.10991212f, 
    0.04308804f, -0.00455048f, -0.05012472f, 0.00424165f, -0.04250610f, -0.01347539f, -0.01116542f, -0.00464469f, 
    -0.00802784f, -0.00231254f, 0.03465338f, 0.01546738f, -0.01348025f, -0.03247437f, -0.00945590f, -0.02736974f, 
    -0.00249968f, -0.01760906f, -0.01531766f, -0.05609113f, -0.01760283f, 0.01149257f, 0.04277794f, -0.00270450f, 
    0.02882738f, 0.00344628f, 0.03752293f, 0.01333264f, 0.01581399f, -0.03964140f, -0.01412729f, 0.01269427f, 
    -0.02004067f, -0.03322027f, 0.02360955f, -0.00974645f, 0.03333447f, -0.01997201f, 0.02040046f, -0.05214681f, 
    0.03367611f, 0.00497718f, 0.02245506f, 0.02941904f, 0.04578720f, 0.04077787f, 0.00958982f, 0.03775901f, 
    -0.01629051f, 0.00431577f, 0.03050082f, -0.00749340f, -0.01991199f, 0.02104412f, -0.02008633f, -0.01430981f, 
    -0.00514129f, -0.01952144f, -0.02468980f, 0.03127862f, -0.04293951f, 0.02030508f, 0.00213026f, -0.00740598f, 
    0.04014980f, -0.03137713f, -0.02221991f, -0.04240072f, -0.00759993f, -0.05193521f, -0.02313538f, 0.02269698f, 
    0.00443010f, 0.02811633f, 0.00934045f, 0.00611729f, -0.04877578f, -0.04727774f, 0.02376355f, 0.02936721f, 
    0.00318397f, 0.00739810f, 0.02644692f, -0.04645720f, 0.03933804f, 0.01570721f, -0.02082692f, -0.03796198f, 
    0.04221576f, -0.03954671f, 0.01510483f, 0.03779829f, 0.01239437f, -0.03647481f, 0.02440634f, -0.05281352f, 
    0.04333572f, -0.05447684f, 0.00473140f, 0.04208761f, -0.03969941f, -0.03800005f, -0.01368719f, 0.00079768f, 
    -0.03215987f, -0.02812482f, -0.00866543f, 0.01617773f, -0.04744298f, 0.00995855f, 0.01258578f, -0.02487624f, 
    0.02966845f, -0.00095728f, 0.04541033f, -0.01380563f, -0.02576591f, -0.04741841f, -0.00564314f, 0.00510905f, 
    -0.02620157f, -0.01328989f, -0.01390364f, -0.02555969f, -0.00218867f, -0.05139881f, 0.03147542f, -0.02153703f, 
    -0.03340293f, 0.03270007f, -0.04778587f, -0.01446871f, 0.03376676f, 0.02740798f, 0.02516145f, 0.00546589f, 
    -0.00253440f, 0.00788940f, 0.00705103f, -0.00372532f, 0.00304056f, 0.03873727f, -0.01767261f, 0.01325581f, 
    -0.04553787f, -0.01075541f, 0.00585557f, 0.03200834f, -0.02077662f, -0.01323566f, -0.03327204f, -0.03708433f, 
    0.02172281f, 0.02782316f, -0.04399896f, -0.03390992f, 0.00715418f, 0.03410764f, -0.03740414f, 0.00028237f, 
    0.01429373f, -0.02596038f, -0.05229571f, -0.02710016f, 0.02082505f, 0.00743939f, 0.02755129f, 0.01440144f, 
    0.03159677f, 0.03295440f, -0.04090741f, 0.03077646f, 0.00526090f, -0.00734640f, 0.00197459f, -0.00671095f, 
    -0.02528724f, -0.01332593f, -0.05152103f, -0.00359207f, 0.03455129f, -0.04496679f, -0.03851717f, 0.03502772f, 
    -0.04083972f, -0.01844965f, -0.01667904f, 0.00387863f, 0.02223247f, -0.05721633f, -0.04409677f, -0.02265397f, 
    -0.03452008f, 0.04534335f, -0.02061722f, -0.00100631f, 0.03926203f, -0.02613331f, -0.05148820f, 0.04333629f, 
    0.02840730f, 0.02316997f, -0.03539015f, -0.01142273f, 0.03621071f, -0.02186368f, -0.05684234f, 0.01098987f, 
    -0.03060197f, -0.05388702f, -0.03099667f, 0.00552121f, 0.01987145f, 0.00751342f, -0.02449588f, -0.00977513f, 
    0.04591163f, 0.02123097f, -0.00701806f, 0.01171481f, -0.00018465f, -0.03206921f, -0.01410472f, -0.01764348f, 
    -0.00126351f, -0.05360598f, -0.02615501f, 0.04787520f, -0.04037620f, -0.00294675f, 0.01086611f, -0.01899147f, 
    -0.02437901f, -0.01285634f, -0.03320405f, 0.00011677f, -0.02900406f, 0.03094016f, 0.03438911f, 0.01693677f, 
    -0.00577829f, 0.04615664f, -0.04412574f, -0.01961438f, -0.01709989f, 0.00320650f, -0.03695832f, 0.01422777f, 
    -0.00910182f, -0.04905945f, -0.02363024f, 0.04723288f, -0.05462618f, -0.02746172f, 0.01781262f, 0.02937778f, 
    0.00884291f, 0.00171070f, -0.04496896f, -0.02888151f, 0.04360024f, -0.03473313f, 0.03830292f, 0.00953303f, 
    0.03260523f, -0.03928347f, -0.03600234f, 0.02043724f, 0.00529166f, 0.00833038f, -0.00016201f, 0.01729579f, 
    -0.03438370f, -0.04219878f, -0.00962247f, 0.01552034f, 0.02756269f, 0.01494179f, -0.05095865f, -0.03025464f, 
    -0.02352343f, -0.04861826f, -0.04456459f, -0.01349686f, -0.04987534f, -0.03601186f, 0.02333152f, -0.04724832f, 
    -0.01564075f, -0.04602914f, 0.03651236f, -0.00148921f, -0.00153198f, -0.04829287f, 0.02537162f, 0.01024298f, 
    0.00778960f, -0.02921418f, -0.02533664f, 0.01456179f, -0.03490001f, -0.01449226f, -0.00836765f, -0.03363884f, 
    0.05229668f, -0.03574195f, 0.03832851f, -0.04440075f, -0.00095846f, -0.03742950f, 0.02883962f, -0.04144445f, 
    -0.05069485f, 0.00233803f, -0.05076129f, 0.00425785f, -0.02674655f, 0.03860209f, -0.01647824f, 0.01639411f, 
    -0.01290516f, -0.00101521f, 0.04553414f, 0.04361902f, -0.03176204f, 0.04326307f, 0.04850936f, 0.00631856f, 
    0.00729025f, -0.02418903f, 0.03296007f, 0.02321031f, 0.05688275f, -0.00932657f, -0.03375327f, 0.04027600f, 
    0.00536359f, 0.02016769f, 0.03831402f, -0.05628938f, 0.00536470f, 0.01976831f, -0.02271045f, 0.00625093f, 
    -0.00567678f, -0.03341352f, -0.05118352f, -0.02549201f, 0.00003239f, 0.00510049f, 0.01381822f, -0.04030860f, 
    0.03036456f, -0.05220046f, -0.02204387f, 0.04154752f, -0.04289016f, 0.03946983f, 0.02561510f, 0.04263584f, 
    0.02735891f, 0.03084237f, -0.01732581f, -0.02754167f, -0.02298486f, 0.04320123f, 0.04123401f, 0.00682597f, 
    -0.02643888f, -0.03628897f, 0.04199815f, -0.04004584f, 0.04773322f, -0.03823748f, 0.01908798f, -0.04767338f, 
    0.00718771f, 0.04261132f, 0.01011302f, 0.05093668f, 0.00406812f, -0.03513790f, -0.05365271f, -0.01193216f, 
    0.72008663f, -0.04942200f, 0.01029587f, -0.03507002f, 0.15403292f, -0.19544367f, -0.02097364f, -0.04401681f, 
    0.16586997f, 0.02701687f, 0.15860365f, -0.02988306f, -0.42725617f, 0.05144931f, 0.01940130f, 0.17133169f, 
    0.08755645f, 0.08190025f, -0.07532434f, 0.06225888f, 0.11997582f, 0.14076012f, 0.04670390f, -0.27057329f, 
    0.02516165f, 0.11270409f, -0.06658850f, 0.00515187f, 0.07941739f, 0.01672265f, 0.00172292f, 0.06091569f, 
    0.05909428f, -0.00472882f, 0.03548806f, 0.00313372f, 0.03313944f, 0.03046132f, 0.17571209f, -0.00409626f, 
    -0.05232675f, 0.08116448f, -0.02796935f, 0.11231352f, 0.04662631f, -0.06382728f, 0.01946338f, 0.01800202f, 
    0.44279420f, 0.01736927f, 0.05219312f, -0.24969724f, -0.06114842f, -0.04797236f, 0.16132303f, 0.22587049f, 
    0.26237893f, -0.09667645f, 0.09238821f, -0.01822660f, 0.04221141f, 0.02886499f, 0.02833763f, -0.04830549f, 
    0.15087521f, 0.09256642f, -0.07300552f, 0.11813267f, 0.02228615f, -0.06216581f, 0.04377097f, 0.01163525f, 
    -0.26691481f, 0.14175195f, -0.23249784f, 0.15771173f, -0.00043418f, -0.03792695f, 0.06598451f, 0.05305507f, 
    0.00406520f, 0.07454543f, -0.01827202f, 0.06923643f, 0.04406609f, -0.15933515f, 0.03099727f, 0.05071415f, 
    -0.16966416f, 0.06300536f, -0.00381157f, -0.00835946f, 0.08729848f, -0.00846249f, 0.05154477f, -0.01526432f, 
    -0.00995260f, 0.32894549f, -0.15177231f, -0.31508318f, -0.07177046f, -0.08766688f, -0.00720578f, -0.19312447f, 
    0.00745721f, 0.04205576f, -0.03696920f, -0.02151706f, 0.03779212f, -0.25164425f, 0.05623252f, -0.01885356f, 
    0.04292675f, 0.04935432f, -0.03289501f, -0.14182122f, 0.03727075f, -0.11288398f, 0.01088307f, -0.14787780f, 
    0.20600101f, -0.09471558f, 0.02183724f, -0.14277796f, -0.01531001f, -0.01550816f, -0.04124675f, -0.01709234f, 
    0.03452493f, 0.13680224f, -0.06285228f, 0.00593485f, -0.03960037f, 0.10751340f, -0.00048176f, 0.12169596f, 
    0.12567304f, -0.04723203f, 0.08518978f, 0.04279037f, -0.02947501f, -0.10853192f, 0.01450232f, 0.01557714f, 
    -0.05927275f, -0.26672617f, -0.38046217f, -0.06297647f, 0.01703211f, 0.03428852f, 0.01965360f, 0.01553901f, 
    0.11195092f, -0.01310063f, -0.02592752f, -0.02998131f, -0.22372605f, -0.11764843f, -0.03953042f, -0.00401006f, 
    0.13603856f, -0.03479255f, 0.02644336f, -0.06850107f, -0.05487871f, -0.07860894f, 0.17272884f, -0.00905262f, 
    0.22696358f, -0.00030063f, -0.15441358f, -0.02795486f, 0.06597409f, 0.07594480f, 0.08834146f, 0.23046303f, 
    -0.00183277f, 0.10109222f, 0.07665969f, 0.16868626f, -0.35672277f, 0.12801354f, 0.08408129f, 0.16663329f, 
    0.18811712f, 0.11151543f, -0.03395400f, -0.07683650f, 0.04028565f, -0.10448258f, 0.05503498f, 0.01746331f, 
    0.27304295f, -0.11940142f, -0.18507400f, -0.04652146f, 0.03527802f, 0.09014859f, 0.07529616f, -0.01732109f, 
    0.04176591f, 0.00126880f, 0.14143901f, -0.14147374f, -0.26663566f, 0.26220298f, -0.06031496f, 0.00366586f, 
    -0.05579989f, 0.02808692f, 0.01362435f, -0.03559883f, -0.16943306f, 0.00258445f, -0.05295908f, 0.02613521f, 
    0.14551836f, 0.13163835f, -0.09776136f, -0.25031823f, 0.01698857f, 0.16089298f, 0.03777330f, 0.07735907f, 
    0.01040175f, 0.00884525f, 0.06720485f, 0.01909867f, -0.05041368f, 0.02275530f, -0.07406021f, 0.18770725f, 
    -0.03093125f, -0.02995313f, -0.12373003f, 0.03286777f, 0.08875601f, 0.03185149f, -0.00901371f, 0.04846500f, 
    0.22234577f, 0.19391488f, -0.17048275f, -0.22936916f, -0.02825601f, -0.09511556f, 0.11142568f, 0.10878092f, 
    0.04039981f, -0.03749697f, 0.09480920f, -0.02613319f, 0.26681063f, 0.03837226f, -0.29810894f, -0.06741232f, 
    -0.05438388f, -0.06892607f, 0.06954230f, 0.02286089f, -0.00453856f, 0.04090445f, -0.05593619f, -0.09472283f, 
    0.03841501f, 0.39548579f, 0.03452372f, -0.39703345f, -0.11389562f, 0.12251439f, 0.05956379f, 0.03828186f, 
    -0.11582680f, -0.07575289f, -0.00582676f, -0.09762460f, -0.11026245f, -0.11986437f, 0.24154198f, -0.01724283f, 
    0.04464873f, 0.12892683f, -0.02201305f, 0.01243825f, 0.00436773f, 0.16771479f, -0.10175225f, 0.07143434f, 
    0.07965201f, 0.03067952f, -0.04912303f, -0.27734727f, 0.01165942f, 0.00641218f, 0.00788004f, 0.08289408f, 
    -0.06879018f, 0.07580702f, 0.01127385f, -0.13882999f, 0.09738027f, 0.38271311f, 0.22644871f, -0.09423228f, 
    0.04962195f, 0.01704769f, 0.11916202f, 0.00344189f, 0.06821674f, 0.02299509f, -0.04633413f, -0.00538421f, 
    0.31873965f, -0.20138130f, 0.25678319f, 0.08025882f, 0.18786390f, 0.04386302f, 0.20158151f, -0.15860222f, 
    0.23505540f, 0.06377696f, 0.07673830f, 0.10859951f, 0.13652574f, -0.06090951f, -0.17268303f, -0.09232792f, 
    -0.08476464f, 0.09159527f, -0.00778952f, 0.12346908f, 0.16778351f, -0.10610811f, -0.08644606f, -0.07895163f, 
    -0.03420698f, -0.12359413f, 0.10702203f, 0.00497855f, 0.11134955f, 0.05642789f, 0.02395234f, 0.05535641f, 
    0.01191129f, 0.15615386f, 0.03026215f, 0.04912320f, -0.07428613f, 0.05043829f, 0.09248635f, 0.07852063f, 
    0.07246026f, 0.01919289f, -0.06867641f, -0.04275952f, -0.01785265f, -0.00926913f, 0.05771422f, 0.00918885f, 
    -0.67492628f, -0.15499949f, -0.12929592f, -0.08169622f, -0.02832768f, 0.11257895f, 0.06287089f, 0.07293425f, 
    0.10890891f, 0.07111350f, 0.00513045f, 0.04465765f, -0.01073527f, 0.24368134f, -0.08180044f, -0.10415561f, 
    0.05253857f, 0.05587803f, -0.02253826f, 0.12657480f, -0.00633046f, 0.07791258f, -0.01552579f, 0.05402938f, 
    -0.18812294f, -0.18244740f, 0.01296627f, 0.04703172f, 0.07858806f, 0.12937276f, 0.07699276f, 0.06456127f, 
    0.11181156f, 0.06859426f, 0.12008627f, -0.00728851f, -0.05293234f, 0.06132923f, -0.08958487f, -0.07073926f, 
    0.01728066f, 0.07307987f, -0.09211943f, 0.04415870f, 0.13606915f, 0.02329929f, -0.09439335f, -0.21346676f, 
    -0.09986801f, 0.09471989f, -0.00594986f, 0.02198283f, 0.21769436f, 0.21426688f, 0.15218768f, 0.01530075f, 
    0.04586313f, 0.08275176f, -0.05564096f, 0.08847309f, 0.30296829f, 0.25092295f, 0.54546785f, 0.14409688f, 
    -0.03787911f, -0.04446207f, -0.01249821f, -0.03811681f, 0.07359337f, 0.03710829f, -0.00142524f, 0.11444438f, 
    -0.17680398f, 0.06576373f, -0.00665941f, 0.04205126f, 0.01066893f, 0.06779800f, 0.00021967f, 0.16543871f, 
    0.18934187f, 0.02150995f, 0.07373799f, -0.01163122f, -0.24446535f, -0.19615574f, -0.14135715f, -0.05404428f, 
    0.08783758f, -0.05309165f, -0.03220314f, 0.11279037f, -0.10015490f, -0.04740718f, 0.02147219f, -0.06844348f, 
    -0.21461442f, 0.12108498f, 0.26370052f, 0.03293625f, -0.03846381f, -0.07756083f, -0.04827917f, -0.07705011f, 
    -0.03724898f, 0.08532569f, 0.06222054f, 0.07945607f, 0.12251325f, -0.00773206f, 0.03770216f, 0.01288364f, 
    -0.06300028f, -0.00098869f, -0.05521354f, -0.06294274f, 0.01316323f, -0.02017337f, -0.05219573f, 0.12244210f, 
    -0.12432291f, -0.21222816f, -0.03070641f, -0.13843063f, -0.16092522f, -0.09687898f, 0.04101919f, -0.10771247f, 
    -0.08900061f, -0.04326663f, 0.01327252f, -0.02964922f, 0.18000148f, -0.04780840f, 0.09039354f, -0.04133939f, 
    -0.03203438f, 0.06594536f, 0.01001186f, 0.05923949f, -0.07780082f, 0.00345611f, -0.06963334f, -0.29361549f, 
    0.09241194f, 0.05001097f, -0.04909334f, 0.12609436f, -0.01206771f, 0.04600555f, -0.04553670f, -0.16432285f, 
    0.08399411f, 0.01702852f, -0.03184885f, 0.03824858f, 0.13659972f, 0.08967786f, 0.06974264f, -0.02517829f, 
    0.10559323f, -0.06207980f, 0.21408218f, -0.08127640f, -0.05138406f, -0.02260210f, 0.02076964f, 0.03042828f, 
    -0.26704869f, -0.08173149f, -0.08492272f, -0.13965739f, -0.11678396f, -0.05292006f, -0.00424075f, 0.07038436f, 
    0.10720088f, 0.09819113f, 0.17617483f, 0.00428450f, -0.06914611f, -0.04493342f, -0.07107934f, -0.05682259f, 
    -0.00264765f, -0.00152013f, 0.13481674f, 0.03092274f, -0.18131277f, 0.18010978f, 0.01331045f, 0.02464803f, 
    -0.00237565f, -0.07487389f, -0.09484071f, 0.07317560f, 0.12802514f, 0.19409102f, 0.08646578f, 0.00932336f, 
    0.05277899f, -0.05016205f, 0.02432945f, 0.04336230f, 0.04549014f, 0.01004422f, 0.01368901f, 0.01122762f, 
    0.07270798f, 0.03861187f, 0.20563948f, -0.01350755f, -0.05161059f, 0.00242745f, 0.03772604f, 0.01602207f, 
    0.03286536f, 0.02393051f, -0.10996903f, -0.18653202f, -0.04732108f, -0.03643494f, -0.04633398f, 0.05286630f, 
    -0.05506456f, -0.08615962f, -0.04516983f, -0.15714259f, 0.17869718f, 0.02203263f, -0.13841283f, -0.06530485f, 
    0.10057501f, 0.02294437f, 0.19264616f, 0.04952037f, -0.11812235f, -0.15012071f, 0.01775306f, 0.04098590f, 
    0.00584423f, -0.00985220f, -0.02749784f, -0.09576006f, 0.02415110f, 0.02032014f, 0.09416787f, 0.06206089f, 
    -0.05943692f, -0.00411990f, -0.02327318f, 0.03973984f, -0.06380832f, 0.01517664f, 0.01193641f, 0.01858512f, 
    -0.07025710f, -0.05324577f, -0.05103959f, -0.10858988f, 0.16491738f, 0.03826668f, 0.15057483f, 0.21279179f, 
    -0.30454472f, -0.03900132f, -0.17967412f, 0.06434080f, -0.05055171f, 0.06392027f, 0.11753086f, -0.04087899f, 
    -0.02109121f, -0.01418886f, -0.01422349f, 0.10524797f, 0.07908095f, 0.03789332f, -0.17968071f, -0.09448620f, 
    0.17242531f, 0.07134090f, 0.00946276f, 0.00249476f, -0.01012129f, -0.07840813f, -0.02621046f, -0.00529670f, 
    0.27545413f, -0.04380094f, -0.09138580f, -0.17148553f, -0.12332175f, -0.03413008f, 0.19459960f, 0.11446913f, 
    0.00055503f, 0.05452458f, -0.06747206f, -0.11788945f, 0.20672363f, -0.02841754f, -0.03474334f, -0.03463393f, 
    0.03588190f, 0.11546855f, 0.19025363f, -0.02799048f, 0.21821029f, 0.05158240f, 0.20520024f, -0.14397568f, 
    -0.16091627f, -0.16698633f, -0.08184869f, -0.08744667f, -0.16401508f, -0.01872647f, 0.07256594f, 0.16901608f, 
    0.03112279f, -0.08969676f, -0.07906271f, -0.12179639f, 0.16142763f, 0.04206529f, 0.03881004f, -0.02018982f, 
    0.03448794f, -0.05525009f, -0.00187488f, 0.05866757f, 0.00739012f, 0.00270593f, -0.03778934f, -0.03708293f, 
    -0.12603216f, 0.11765244f, -0.18288833f, 0.22185589f, 0.25896019f, 0.08609921f, 0.13531350f, 0.06540044f, 
    -0.00217987f, 0.08731657f, 0.23682249f, -0.09384472f, 0.09978715f, 0.01069769f, -0.20521754f, -0.18147580f, 
    -0.12732194f, -0.05153489f, -0.12842180f, 0.07297374f, -0.02643387f, 0.00812679f, 0.10028414f, -0.21859488f, 
    0.34729275f, 0.10802837f, 0.06567788f, 0.10913744f, -0.02751260f, -0.03636446f, -0.05922681f, 0.00416891f, 
    -0.05985638f, 0.10059381f, 0.22279702f, -0.00771985f, -0.02027682f, 0.03964173f, -0.00824355f, -0.06692252f, 
    0.01672658f, -0.05694465f, -0.00957870f, -0.01757695f, -0.07884803f, 0.05054663f, -0.02482633f, -0.02516414f, 
    -0.28923652f, 0.12248950f, 0.26654422f, -0.18969409f, -0.02410149f, 0.01945412f, 0.40810212f, 0.15268889f, 
    0.10874965f, 0.09791459f, -0.03726076f, 0.13058662f, -0.02555169f, -0.22576608f, -0.09255970f, -0.15085582f, 
    0.04494096f, -0.05583455f, 0.02767112f, 0.22275449f, -0.04714401f, 0.09569222f, 0.02889224f, 0.01144997f, 
    -0.01762046f, -0.04629807f, 0.00891766f, 0.02888646f, -0.04182504f, -0.00262418f, 0.01092058f, 0.01593560f, 
    0.03007954f, -0.04723073f, -0.03938705f, -0.05505560f, -0.03541780f, -0.01331459f, 0.01326074f, 0.02968546f, 
    -0.04895629f, 0.00004445f, 0.01676812f, -0.05153626f, -0.03984135f, 0.03382236f, -0.02213398f, 0.04551665f, 
    -0.05288296f, -0.03728489f, -0.01031828f, 0.00310307f, -0.03478305f, 0.03096638f, -0.03127930f, 0.00189072f, 
    -0.03916997f, -0.03400430f, -0.00344476f, -0.05142792f, 0.02227349f, -0.04180040f, 0.03497674f, 0.02510377f, 
    0.02879444f, -0.05206691f, 0.01133136f, 0.02899457f, -0.02998546f, -0.05634118f, -0.00222443f, 0.00968220f, 
    0.00975693f, 0.02339580f, -0.02458031f, 0.00362517f, -0.02259479f, -0.03096498f, 0.01570036f, -0.00007708f, 
    -0.00721575f, 0.00899372f, 0.02775246f, -0.00228473f, 0.02885928f, -0.02065724f, 0.03001967f, -0.01090517f, 
    -0.04777113f, -0.02041068f, -0.02018042f, -0.00116318f, -0.05172475f, 0.00605849f, -0.04646351f, -0.02619308f, 
    0.03225886f, 0.02349636f, -0.05090312f, -0.01237578f, 0.04441233f, 0.03454326f, 0.02584135f, -0.01573691f, 
    0.02379837f, -0.01260377f, -0.03696119f, -0.02768961f, -0.00101003f, -0.04250953f, -0.04894808f, 0.03472668f, 
    -0.05414228f, 0.03336458f, 0.04467294f, -0.02449063f, 0.00782329f, 0.04205604f, 0.03027709f, -0.01541048f, 
    0.04158009f, 0.03969471f, -0.03977088f, 0.04277704f, -0.00009893f, -0.04115961f, -0.04171540f, -0.00637398f, 
    -0.02965813f, -0.02718306f, -0.00153385f, -0.02723483f, 0.01766330f, 0.03269335f, -0.02222977f, -0.03753539f, 
    0.03595874f, 0.01927254f, -0.01045750f, -0.01671549f, -0.04384315f, -0.00927607f, 0.00053205f, -0.02772424f, 
    -0.03764794f, -0.01793263f, 0.00403653f, -0.05470065f, 0.03746944f, -0.00263998f, -0.00782680f, -0.00307966f, 
    -0.02768526f, 0.00039110f, 0.04065740f, 0.02742087f, -0.04291710f, 0.04332078f, -0.04869873f, 0.01554781f, 
    -0.00715364f, -0.05618105f, -0.03121753f, 0.00392858f, -0.02367466f, -0.04139327f, -0.03574929f, 0.00444325f, 
    0.03974895f, -0.04582696f, 0.04084154f, 0.01333171f, 0.02783960f, -0.02997275f, -0.03622685f, -0.00836020f, 
    -0.04272039f, -0.00172816f, 0.03110556f, -0.02123144f, -0.00926179f, -0.04809763f, -0.01465548f, -0.04715143f, 
    -0.02101052f, 0.01975483f, -0.05218426f, -0.03187288f, -0.00602274f, -0.02533614f, 0.02934713f, -0.03894162f, 
    -0.05531455f, -0.01048416f, 0.03956256f, -0.01925823f, -0.04162699f, 0.01302779f, -0.04043848f, 0.02362262f, 
    0.01067248f, -0.05080830f, 0.00059470f, -0.00327360f, 0.00850203f, 0.01387536f, -0.00295444f, 0.00644622f, 
    -0.04190699f, -0.01937351f, -0.04235300f, 0.00286975f, -0.04779316f, -0.02449351f, 0.00701813f, -0.01681668f, 
    0.00423798f, 0.02799417f, 0.02636670f, 0.02437866f, -0.01051327f, -0.05084669f, 0.00594949f, -0.01871214f, 
    -0.02559135f, -0.01538183f, -0.04298801f, -0.02669023f, -0.03106172f, -0.01703482f, 0.00254623f, -0.01989958f, 
    -0.01509608f, -0.00571444f, 0.04215808f, -0.04193790f, -0.00075684f, 0.02298190f, 0.03904369f, 0.02578883f, 
    -0.01654250f, 0.02047294f, 0.02383749f, 0.04901323f, -0.00338355f, -0.04409042f, -0.02860801f, 0.01800810f, 
    -0.02307076f, -0.04387309f, 0.01911186f, -0.04595309f, -0.00876133f, -0.01193838f, -0.01652198f, -0.01570217f, 
    0.02176014f, 0.01991639f, 0.03864257f, 0.03917363f, 0.02613028f, -0.00155553f, -0.00309238f, -0.03636434f, 
    -0.02924423f, -0.01927027f, 0.03139774f, -0.03649577f, 0.02741649f, -0.03243205f, -0.00914894f, -0.01112790f, 
    -0.00318954f, -0.04968435f, -0.00571113f, 0.02726906f, 0.03274839f, -0.05024643f, 0.00202871f, 0.00749035f, 
    0.02701224f, 0.03497317f, -0.03057871f, -0.02977029f, 0.00868180f, 0.01066716f, 0.02004008f, -0.01165903f, 
    -0.00210095f, 0.02743878f, 0.02394981f, -0.03575722f, -0.02860462f, 0.00095637f, -0.00014417f, 0.01739392f, 
    0.00386784f, -0.02215485f, -0.02143699f, -0.01128687f, -0.04618800f, -0.03380243f, 0.03220114f, -0.03753615f, 
    -0.01978614f, 0.00074546f, -0.05117413f, 0.00785425f, 0.00951259f, 0.03108128f, 0.02026937f, -0.05414799f, 
    0.02248672f, -0.03968180f, 0.03598192f, -0.02078943f, -0.01308178f, -0.03307029f, -0.03200749f, 0.01523838f, 
    -0.04074780f, -0.01835532f, 0.03953774f, 0.01015583f, 0.01887695f, -0.03383806f, -0.04115340f, 0.02925790f, 
    -0.04790927f, 0.05034108f, 0.00751840f, -0.02038407f, -0.01295792f, 0.00586749f, 0.00363453f, 0.03324972f, 
    0.04226894f, 0.03046347f, 0.02963791f, 0.03016952f, 0.00172503f, -0.03727180f, -0.03839786f, -0.04205935f, 
    -0.02564459f, 0.02810854f, -0.02839254f, 0.00696928f, 0.02836882f, -0.01234190f, 0.04608592f, -0.00573583f, 
    0.01512628f, -0.00788277f, -0.04351926f, -0.03791330f, 0.02642697f, 0.00088253f, 0.01826451f, 0.02138892f, 
    0.02234601f, -0.00770823f, -0.04513198f, 0.00209316f, 0.02435628f, 0.02306096f, -0.00620636f, -0.00458809f, 
    -0.05235650f, -0.01133526f, 0.04005524f, 0.03545409f, -0.01568385f, -0.00770358f, -0.02608946f, 0.03915339f, 
    0.02978690f, -0.04329241f, 0.02637493f, 0.01142306f, 0.01901038f, 0.03089772f, -0.02516826f, -0.04181365f, 
    -0.05293769f, -0.04626432f, -0.03445988f, -0.05280821f, 0.00509192f, -0.05702009f, -0.01875420f, -0.03907153f, 
    -0.03145652f, -0.04056990f, 0.03655495f, 0.01484267f, -0.00723644f, -0.00533735f, 0.00691208f, -0.02858363f, 
    0.03724067f, -0.04159765f, 0.02697868f, -0.04361489f, -0.01094048f, 0.00659318f, 0.02628708f, 0.00815087f, 
    0.43206835f, -0.24155129f, 0.11202808f, 0.29975948f, 0.13004464f, 0.09203603f, -0.01983234f, -0.09673735f, 
    0.15998265f, 0.10962982f, -0.05537428f, 0.02480843f, 0.15939753f, -0.01278420f, 0.01107478f, -0.08664520f, 
    -0.08465254f, -0.02420836f, -0.00050419f, 0.08716163f, 0.10034551f, 0.01217876f, 0.24654001f, 0.11084644f, 
    0.16055468f, 0.03667453f, 0.13041776f, 0.08738504f, -0.02914093f, 0.20607570f, 0.05834408f, 0.08502085f, 
    0.01744258f, -0.01599893f, -0.10502996f, 0.08923339f, -0.29902020f, -0.07128165f, -0.18541187f, 0.16232833f, 
    0.01367434f, 0.03595899f, 0.04841327f, 0.02180447f, -0.06872295f, 0.02442384f, -0.00171457f, -0.08031777f, 
    -0.42488244f, 0.17991281f, -0.03846404f, 0.20908342f, -0.02054174f, 0.11871909f, 0.03019550f, -0.03966140f, 
    -0.13951421f, 0.01319506f, 0.09890481f, -0.06746007f, -0.11424118f, -0.20055276f, -0.07494898f, -0.02637446f, 
    -0.06003977f, -0.17190717f, 0.03639512f, -0.19321269f, 0.00467636f, 0.06140095f, -0.02640052f, 0.02042074f, 
    0.08756902f, 0.01308886f, 0.31998277f, -0.13695353f, -0.00773591f, -0.05495255f, 0.03321972f, -0.01223593f, 
    0.19036479f, -0.02285741f, 0.16802040f, -0.07715155f, -0.23788135f, -0.03141209f, -0.06815345f, -0.12952191f, 
    0.01512705f, -0.04277271f, -0.04504110f, -0.00771131f, 0.00452275f, -0.08347301f, 0.17703687f, 0.01151931f, 
    0.01534164f, 0.08697661f, 0.32901272f, 0.04776737f, 0.24504296f, 0.10316279f, -0.17368835f, 0.08047806f, 
    0.05671252f, -0.07952201f, 0.02347065f, -0.04599601f, -0.12130664f, 0.01744545f, -0.08715518f, 0.14324135f, 
    0.06900182f, -0.07549186f, 0.09240827f, 0.11575480f, 0.18544401f, 0.13810830f, 0.08740915f, -0.14579630f, 
    -0.32088181f, 0.08554614f, 0.22147492f, 0.06862029f, -0.02714408f, -0.13454659f, 0.13696451f, 0.00497621f, 
    -0.17575814f, -0.00637720f, -0.04043320f, -0.03439033f, -0.06117180f, -0.11828159f, -0.03783913f, 0.03642262f, 
    -0.05981519f, 0.07080437f, -0.01709156f, 0.13260956f, -0.04786532f, 0.07374249f, -0.10567714f, -0.10013226f, 
    -0.19524886f, 0.04820211f, 0.10067562f, 0.34995851f, 0.00446263f, 0.03408640f, -0.10505886f, -0.03819255f, 
    0.20602603f, -0.02740013f, -0.12776136f, 0.07367419f, 0.43486518f, -0.27387694f, 0.07188480f, 0.13759845f, 
    0.11163262f, 0.04120284f, 0.04288037f, 0.13465625f, 0.00153031f, 0.09627427f, 0.01202892f, -0.01007214f, 
    0.17153926f, 0.07954136f, -0.01409526f, 0.15411317f, 0.16731983f, 0.06914889f, 0.24481764f, 0.31989700f, 
    -0.08387917f, 0.01593643f, -0.09032506f, 0.05415547f, -0.01442713f, -0.04718428f, -0.21227421f, 0.02327432f, 
    0.13991699f, -0.07579322f, -0.16108459f, 0.21933562f, -0.06430533f, 0.00369225f, 0.08754645f, -0.00313037f, 
    -0.24168457f, 0.02377786f, -0.04275373f, -0.07153029f, -0.01977841f, -0.09696692f, -0.06502531f, 0.12870127f, 
    0.08833502f, 0.12054246f, 0.13607146f, 0.05811734f, -0.01302474f, 0.01039897f, -0.00584017f, 0.20654055f, 
    0.19723454f, -0.03509340f, 0.15164398f, 0.16532305f, -0.00324419f, -0.08848780f, -0.00176429f, 0.02513041f, 
    -0.17755404f, -0.16357711f, 0.06108132f, 0.09747731f, 0.08077047f, -0.10911264f, -0.00079097f, -0.12748191f, 
    0.03031793f, -0.03925677f, -0.00342118f, 0.03487327f, -0.15854745f, -0.06207727f, -0.10550799f, -0.13046309f, 
    0.01651939f, -0.03635564f, 0.08128268f, -0.06996093f, 0.11326211f, 0.01276918f, 0.13127321f, 0.05965268f, 
    0.17992623f, -0.07592148f, 0.27437025f, -0.06710407f, 0.05083545f, 0.04236067f, 0.03055270f, 0.06754893f, 
    -0.06109117f, 0.07395533f, -0.04176762f, -0.12784465f, -0.07747228f, -0.06195175f, 0.13701150f, 0.15159194f, 
    -0.03181408f, 0.32469061f, 0.06232285f, 0.07064303f, 0.15377590f, -0.07637998f, -0.08539198f, -0.04407150f, 
    -0.16293637f, -0.33190438f, -0.11988826f, 0.24837472f, 0.10007478f, 0.03174119f, 0.09491970f, -0.01479963f, 
    0.02200644f, -0.05583168f, 0.17024426f, 0.05090524f, -0.04285258f, -0.11252306f, -0.03949166f, 0.02558298f, 
    -0.01584555f, -0.08861209f, -0.04112834f, -0.00470499f, -0.01777636f, -0.12648499f, -0.03634559f, 0.25187492f, 
    -0.09360146f, -0.01327381f, 0.01341462f, 0.08494697f, 0.06890352f, -0.00162598f, 0.07952576f, 0.02064835f, 
    0.00602262f, -0.04603883f, 0.12272909f, -0.13063158f, -0.32840151f, -0.17981315f, -0.02821058f, -0.15935892f, 
    -0.12982406f, -0.12604153f, 0.14904118f, 0.04271127f, 0.00091560f, -0.05397415f, 0.03957615f, 0.04004383f, 
    0.73135060f, -0.28683740f, 0.21251205f, 0.03953935f, -0.03783527f, 0.04919083f, -0.12777123f, 0.20408356f, 
    0.00188785f, -0.03279816f, 0.08063311f, -0.08716410f, -0.63225311f, -0.02878029f, -0.17995411f, -0.05761559f, 
    -0.02773418f, -0.05869275f, 0.11487398f, 0.16828558f, -0.02944181f, -0.01613100f, -0.03186400f, 0.13209073f, 
    -0.19574545f, -0.12384464f, -0.06988318f, -0.02467762f, 0.02971879f, 0.06742737f, 0.08580040f, -0.04513768f, 
    -0.02418273f, 0.05845298f, 0.03694248f, 0.06572904f, -0.03606356f, 0.03625621f, -0.01044650f, -0.06452060f, 
    0.01652773f, -0.00037935f, 0.02168572f, 0.06675627f, 0.04898629f, -0.05873289f, -0.00170238f, -0.01316538f, 
    -0.21290280f, 0.36208004f, 0.11263987f, 0.17201914f, -0.07094726f, 0.29228938f, -0.05969227f, 0.11296996f, 
    0.01908633f, 0.19057800f, -0.10646088f, -0.04767761f, 0.14797179f, 0.09028012f, 0.08605589f, 0.29093069f, 
    0.03881227f, 0.10509832f, 0.06800134f, -0.07895435f, 0.12868884f, -0.03503810f, -0.00425789f, -0.01529900f, 
    -0.68026662f, 0.08274636f, 0.05683068f, 0.17237937f, 0.00618988f, 0.04522081f, 0.12828040f, 0.10977709f, 
    -0.01387648f, 0.01983211f, 0.08494548f, 0.06072545f, 0.00881286f, 0.00548409f, 0.00118247f, -0.08978923f, 
    0.02525407f, 0.07731089f, -0.05158008f, 0.09872325f, -0.02220020f, 0.06530615f, -0.11659575f, -0.03317472f, 
    -0.10134385f, 0.09453519f, 0.19992121f, 0.06329280f, 0.21471816f, 0.06394857f, 0.12574336f, -0.04126310f, 
    0.00212442f, 0.08087365f, -0.02489290f, 0.01096133f, 0.32268035f, 0.07460563f, 0.40846708f, 0.08472767f, 
    -0.11887988f, -0.01396110f, 0.03712332f, 0.00333614f, 0.01058593f, 0.01742304f, 0.04828826f, 0.06663185f, 
    -0.04377020f, -0.13351682f, 0.01109689f, 0.29844096f, 0.07232396f, 0.17571019f, -0.05263127f, 0.06439438f, 
    0.17006901f, -0.04932436f, 0.06247611f, -0.04966231f, -0.06415953f, 0.09040003f, -0.06039364f, -0.07195576f, 
    -0.04817799f, -0.13564889f, -0.03895993f, 0.10086802f, -0.13948232f, 0.00753254f, -0.01772089f, 0.01481039f, 
    -0.17185742f, 0.03978242f, 0.24689339f, 0.05459715f, -0.07033762f, 0.03690466f, 0.00669316f, 0.03373415f, 
    -0.01036029f, -0.05783839f, 0.08528055f, -0.03881933f, 0.06000608f, 0.13340406f, -0.03383681f, 0.11727098f, 
    -0.07387245f, -0.02989332f, -0.05616860f, 0.01033126f, -0.05107491f, 0.06512655f, -0.05785390f, 0.07997219f, 
    -0.09168749f, -0.31706920f, -0.01247249f, 0.10260079f, -0.36659941f, 0.01929377f, 0.05248627f, 0.03774930f, 
    -0.08626530f, -0.01475279f, 0.00101518f, 0.00821023f, 0.20046158f, 0.13836499f, 0.13812974f, -0.06101630f, 
    -0.02131767f, -0.05319401f, 0.02274100f, 0.17517051f, -0.12341984f, 0.04884264f, 0.05429562f, 0.09429339f, 
    -0.08125367f, 0.00896127f, -0.04749674f, 0.08835927f, -0.02637474f, 0.10216052f, 0.04627905f, -0.04052025f, 
    0.08379948f, -0.07214045f, 0.05256109f, 0.02790545f, 0.18759242f, 0.03039754f, 0.19707839f, -0.07334565f, 
    0.05496635f, -0.10090908f, 0.07390186f, -0.06936939f, 0.01344949f, 0.07761665f, 0.09068300f, 0.04283476f, 
    -0.07956433f, 0.13050210f, 0.26055735f, -0.10109448f, -0.07437090f, -0.09550197f, 0.06004750f, 0.10212409f, 
    -0.01279955f, 0.03876026f, 0.10543393f, -0.01750800f, -0.12592337f, 0.21926366f, 0.16412811f, -0.21715492f, 
    -0.06405678f, 0.00882110f, 0.10749079f, 0.08440781f, -0.09824593f, 0.09165478f, 0.05111474f, -0.05026465f, 
    0.02253277f, 0.01973573f, 0.17067786f, 0.01560342f, 0.10833631f, 0.05085766f, 0.04450930f, -0.11782961f, 
    -0.03988308f, 0.01795913f, 0.05088965f, -0.04338687f, 0.15257254f, -0.09010299f, 0.13621815f, -0.17705896f, 
    -0.01460359f, 0.05137793f, 0.28638613f, -0.03466288f, -0.04417808f, -0.01341052f, -0.03746703f, -0.03403497f, 
    -0.00482268f, 0.13911013f, 0.05192423f, -0.08948001f, -0.08634223f, -0.00814352f, 0.02327521f, -0.01914353f, 
    -0.10994803f, 0.05380029f, -0.02300094f, -0.14406043f, 0.21062253f, -0.07251447f, 0.06727841f, -0.11475068f, 
    0.07487694f, -0.02930450f, 0.09431239f, -0.03052310f, -0.09562927f, -0.12940659f, 0.00868375f, 0.06840237f, 
    0.12113858f, 0.08378675f, -0.08431339f, 0.14836484f, -0.08227087f, 0.13373400f, 0.10901390f, 0.14267236f, 
    -0.00658248f, 0.07658716f, -0.05529404f, 0.01026626f, -0.03787083f, 0.02409459f, 0.07504602f, 0.09074496f, 
    -0.09322276f, -0.00791349f, -0.01105107f, 0.00334278f, 0.09597915f, 0.03872940f, 0.04376114f, 0.05239876f, 
    -0.37226599f, -0.10849755f, -0.14870052f, 0.16406356f, -0.00454317f, 0.11228344f, -0.02081147f, -0.01323955f, 
    0.07240427f, -0.03583583f, -0.02842531f, 0.10107551f, 0.09415150f, 0.06859244f, 0.00840217f, -0.10099397f, 
    0.09463419f, 0.09430440f, 0.02386160f, 0.15986633f, -0.08561684f, 0.01039332f, 0.01389312f, 0.00886729f, 
    0.21781273f, 0.06340192f, 0.15168442f, -0.06522816f, -0.02781411f, 0.01806635f, 0.16800167f, 0.13885351f, 
    0.00175873f, 0.10467414f, -0.16765468f, -0.06751931f, 0.28440082f, 0.11004903f, -0.00328079f, -0.02729135f, 
    -0.06101339f, 0.09760723f, 0.17669250f, -0.01346104f, 0.13662583f, 0.00637039f, 0.15661003f, -0.20016564f, 
    -0.07119361f, -0.03732662f, -0.04688420f, -0.05259840f, -0.15593547f, -0.18902045f, 0.19796680f, 0.14073759f, 
    0.02115370f, 0.06115741f, -0.15907674f, 0.01744002f, 0.27460417f, 0.01022137f, 0.01900990f, 0.20676234f, 
    0.07904420f, 0.11883888f, 0.03452927f, 0.14348009f, 0.01230727f, 0.03824074f, 0.03090615f, -0.08834644f, 
    -0.52998430f, 0.39924783f, -0.26168078f, 0.36689216f, 0.10118759f, 0.05715877f, 0.06690267f, 0.02666048f, 
    -0.06460588f, 0.03284957f, 0.08041698f, -0.06742854f, 0.27933928f, 0.31958190f, 0.00281458f, -0.09738407f, 
    0.00314719f, -0.05478090f, -0.18372363f, -0.02870696f, -0.04533785f, 0.20188579f, 0.15696307f, -0.23967390f, 
    0.34994501f, 0.13742901f, 0.01386197f, 0.21983397f, -0.04017346f, -0.10753655f, -0.00422900f, 0.07274293f, 
    -0.11299182f, -0.01639381f, 0.08331081f, 0.01036553f, 0.10643794f, -0.04872377f, 0.01661510f, -0.06864357f, 
    -0.00904582f, 0.00845649f, -0.03893418f, 0.02076009f, -0.14420046f, -0.00063522f, -0.02728895f, -0.02498490f, 
    0.21487826f, 0.01662815f, 0.41688678f, -0.04339124f, 0.00158774f, -0.08450047f, 0.34288439f, 0.12906903f, 
    0.03814921f, 0.07414623f, -0.05559120f, 0.04531476f, -0.03457068f, -0.10178123f, -0.04719004f, -0.12729880f, 
    -0.12105268f, -0.18859147f, 0.01997277f, 0.06533906f, -0.12032170f, 0.01910342f, 0.02166571f, 0.09114629f, 
    -0.01158805f, 0.03299714f, -0.01404187f, -0.02952401f, 0.02986903f, 0.02945077f, 0.02114205f, 0.03478836f, 
    -0.02335235f, 0.03286694f, -0.03236639f, -0.01430510f, 0.01203465f, 0.03356643f, 0.01356884f, -0.01682762f, 
    0.02532664f, -0.01809806f, 0.02844667f, -0.02949312f, 0.03610168f, 0.00414390f, 0.04122164f, -0.04405061f, 
    -0.05231213f, -0.02344412f, -0.03003522f, -0.02506660f, -0.04259000f, -0.02085718f, -0.05398372f, 0.04445981f, 
    0.03417058f, -0.01934884f, -0.05592018f, -0.01751360f, 0.02123836f, -0.03079559f, 0.01107089f, -0.01083104f, 
    -0.00348259f, -0.02604249f, -0.02129971f, 0.00265498f, -0.01136961f, 0.00741325f, -0.02004639f, -0.05456845f, 
    -0.00106935f, -0.02619866f, -0.00321170f, 0.00320602f, -0.04907890f, 0.03597172f, 0.03010762f, -0.00820686f, 
    0.00715447f, -0.01095319f, -0.02115426f, 0.04224377f, 0.02927603f, -0.03319083f, -0.00762340f, -0.05547385f, 
    0.01077747f, -0.00556962f, 0.00393657f, -0.04617712f, -0.04039483f, 0.01256601f, -0.03784203f, -0.04535964f, 
    -0.02780354f, -0.04702127f, 0.02046310f, 0.00508025f, -0.03805772f, -0.01852822f, 0.04274520f, 0.03653833f, 
    -0.02088692f, 0.00285844f, 0.03600688f, 0.01993063f, -0.04128970f, -0.01543581f, -0.04457742f, -0.01234766f, 
    0.03590503f, -0.03733892f, -0.04847140f, 0.02604643f, -0.03171340f, -0.02379219f, -0.05189372f, 0.00911189f, 
    0.00711069f, -0.02942356f, 0.03340959f, 0.03105589f, -0.00665562f, -0.04222183f, 0.02432110f, -0.02219424f, 
    -0.04312536f, 0.01791630f, -0.02103723f, -0.00466387f, -0.02268651f, 0.04427490f, -0.02401788f, 0.03810599f, 
    -0.03286502f, -0.00599741f, -0.02472953f, -0.00690076f, -0.05139761f, -0.03965916f, 0.00992183f, -0.04222113f, 
    0.02631004f, -0.04799781f, 0.03460559f, 0.04463322f, 0.01745616f, -0.03759098f, 0.02171342f, 0.03125931f, 
    -0.02597949f, 0.03108032f, -0.03682011f, -0.03600763f, -0.00747546f, -0.04408810f, -0.02296455f, 0.00446940f, 
    -0.00813330f, 0.00769635f, 0.01174845f, -0.00015638f, -0.02112790f, 0.02668390f, -0.03777565f, -0.04463722f, 
    -0.03037804f, 0.03476416f, -0.02749924f, 0.01316736f, 0.03697855f, -0.01989782f, 0.00327566f, 0.02986171f, 
    -0.04253317f, -0.05596637f, -0.00750655f, 0.00066067f, -0.01136850f, -0.04042891f, 0.03974167f, -0.01502229f, 
    0.01513914f, -0.01670102f, 0.01464858f, -0.05129214f, -0.03365447f, -0.05489263f, -0.01144108f, -0.03944447f, 
    -0.05236528f, 0.02843252f, -0.00834572f, 0.03142434f, -0.00375081f, -0.04173093f, -0.05072071f, 0.04348758f, 
    -0.00075963f, 0.03607185f, -0.03922171f, 0.03824696f, -0.03258843f, -0.01744055f, 0.02499899f, -0.01915652f, 
    0.02156007f, 0.00885960f, -0.02752938f, -0.01200264f, -0.04248387f, -0.05189463f, 0.04380125f, -0.05647530f, 
    -0.02537150f, -0.02958455f, 0.02665393f, 0.00172836f, 0.02785506f, 0.02661072f, 0.03543607f, -0.02169725f, 
    -0.02724050f, -0.00110949f, 0.03367488f, -0.05060669f, 0.00118276f, -0.03314000f, -0.01808296f, -0.02124778f, 
    -0.04829108f, -0.00194487f, 0.03139209f, -0.05289041f, -0.02631442f, -0.03732540f, -0.03765955f, -0.03257428f, 
    -0.02584329f, -0.03112303f, -0.01606312f, -0.01759093f, -0.00601244f, -0.05642089f, 0.03690947f, -0.04226559f, 
    -0.00161482f, 0.00812389f, 0.01761363f, 0.03708814f, 0.01538916f, 0.04188509f, -0.05404262f, -0.05226953f, 
    0.02617494f, -0.05638083f, -0.00396099f, -0.01726442f, -0.03790584f, -0.04729045f, -0.00644676f, -0.05152350f, 
    0.00515298f, -0.02529431f, -0.00207756f, -0.00006646f, 0.03708395f, 0.01131226f, 0.01363445f, 0.03669232f, 
    -0.01306580f, -0.02076755f, -0.02699278f, -0.03958243f, 0.03714697f, -0.01390961f, 0.04841204f, 0.02202071f, 
    -0.02459848f, -0.03121080f, 0.03333970f, 0.04463935f, -0.01008060f, -0.00671486f, -0.05267890f, 0.03868380f, 
    -0.04189117f, -0.00971805f, 0.01597888f, -0.05262844f, -0.00717429f, -0.00821752f, 0.03425035f, -0.05040854f, 
    -0.00389109f, -0.02151546f, 0.02827029f, -0.00892183f, -0.00124525f, -0.01382730f, 0.00845698f, -0.02844273f, 
    0.00237737f, 0.03503067f, 0.04390910f, -0.01005185f, 0.03031355f, 0.03225172f, 0.01447216f, 0.03637287f, 
    -0.04083662f, -0.02048906f, 0.01835845f, -0.01170767f, -0.04626086f, -0.00075480f, 0.02038215f, 0.03595791f, 
    -0.04955512f, 0.01565478f, -0.04231361f, 0.01502556f, -0.03781253f, -0.01862074f, -0.03686201f, 0.00506648f, 
    0.03033729f, -0.01704838f, 0.02469860f, -0.02713111f, 0.03395745f, -0.02108018f, -0.01804320f, -0.03028017f, 
    -0.01710646f, 0.03322230f, 0.04337835f, -0.05652482f, -0.01624696f, -0.01204519f, 0.00650368f, 0.04141802f, 
    -0.00222048f, 0.00311268f, -0.01734427f, -0.01383168f, 0.04244142f, 0.00160410f, 0.02268153f, 0.04269272f, 
    0.04000013f, 0.03105690f, -0.01131900f, -0.03368307f, 0.01571554f, 0.01264383f, -0.02244878f, 0.00685846f, 
    0.01752443f, -0.00900847f, 0.01968060f, -0.03433931f, -0.02982612f, 0.04216336f, -0.02831482f, 0.02632840f, 
    0.00618455f, -0.03502520f, -0.01905694f, -0.03366830f, -0.01460222f, -0.01690108f, 0.00018218f, 0.01934349f, 
    0.02742245f, 0.00566076f, 0.01093283f, 0.03183087f, -0.03428891f, -0.01935334f, 0.02411895f, 0.01789709f, 
    -0.03625278f, -0.04229032f, -0.03999421f, -0.01261870f, -0.04835967f, -0.00801748f, -0.04149384f, -0.00774548f, 
    -0.02067165f, -0.03207912f, -0.01827135f, -0.03132394f, -0.01023450f, -0.02857265f, 0.02413932f, 0.01794858f, 
    0.00026062f, -0.04321920f, 0.03329321f, 0.02994954f, -0.02217794f, -0.03157976f, -0.04758359f, -0.04427036f, 
    0.02173701f, -0.07149030f, -0.11888924f, 0.09326740f, -0.00576951f, -0.08409699f, 0.04084231f, 0.00968320f, 
    0.04936308f, -0.08214733f, 0.13525748f, 0.00858994f, 0.15836807f, 0.06979289f, -0.02714547f, -0.12530261f, 
    0.05446077f, -0.01088463f, 0.06614398f, 0.13853335f, 0.03199891f, 0.09980201f, 0.09658275f, -0.04831786f, 
    -0.04589068f, -0.05074150f, -0.03903449f, 0.01890572f, 0.15870404f, 0.01499767f, 0.04825927f, 0.08864314f, 
    -0.03322004f, 0.18604241f, -0.08918472f, 0.10984910f, -0.00933252f, -0.03531876f, 0.26838624f, -0.02074490f, 
    -0.03896242f, -0.00546700f, 0.00123098f, -0.04314526f, 0.01289655f, -0.01761668f, 0.02828055f, 0.07616467f, 
    -0.29402617f, 0.25065237f, -0.03793136f, 0.09924370f, 0.02695788f, -0.00240879f, 0.15527576f, -0.03032691f, 
    0.08124985f, 0.07014767f, 0.14013524f, 0.05157462f, -0.17365722f, -0.30409241f, -0.10121502f, -0.05687382f, 
    0.17932381f, -0.01778904f, 0.02548753f, -0.00766661f, -0.02390192f, -0.02047450f, 0.01885862f, -0.08009717f, 
    -0.37172866f, -0.15736113f, -0.03830005f, 0.03923119f, 0.07667997f, -0.07141637f, 0.01833679f, 0.01462118f, 
    0.13255218f, 0.23788598f, 0.08083294f, -0.04366668f, -0.09725000f, -0.04665567f, -0.06305601f, 0.05925457f, 
    -0.05600898f, 0.02660643f, -0.02721742f, 0.00227948f, 0.01972491f, -0.01592945f, 0.01662529f, 0.14319156f, 
    0.00914702f, -0.11653421f, 0.07969527f, -0.24746208f, -0.03852121f, 0.02177827f, -0.18724480f, -0.09199480f, 
    -0.05906716f, -0.01262020f, -0.02235952f, 0.06461889f, 0.04034216f, 0.04657044f, -0.02716735f, 0.10107452f, 
    0.02125193f, 0.06834223f, 0.03355709f, -0.02495891f, 0.07968050f, 0.11147376f, 0.03577136f, -0.24469903f, 
    -0.21313995f, 0.46887112f, -0.08391372f, 0.13129927f, 0.03675228f, -0.06900468f, -0.05092882f, -0.03760687f, 
    0.07107089f, 0.11179449f, -0.09495023f, -0.07420816f, 0.03829711f, 0.01455317f, 0.30684522f, -0.11235091f, 
    0.02266613f, 0.00287025f, 0.14335363f, -0.05867651f, 0.03039968f, -0.04140879f, -0.09849663f, -0.00405010f, 
    -0.45725495f, -0.14785440f, 0.06572196f, 0.17678195f, 0.02659295f, 0.02471433f, 0.02748674f, 0.00192969f, 
    0.20407322f, -0.03556075f, -0.02851364f, -0.02349706f, -0.05741473f, -0.08626193f, -0.09583154f, 0.25678274f, 
    0.04702139f, 0.14203633f, 0.02079101f, 0.10185686f, -0.11189628f, 0.14028841f, 0.01264771f, 0.06130091f, 
    0.15401982f, -0.00745968f, -0.09242847f, -0.00977211f, 0.08325525f, 0.18940626f, 0.08488589f, 0.01940216f, 
    0.01423368f, -0.03514610f, 0.06028732f, 0.06756788f, 0.23901907f, 0.01626289f, 0.06048187f, -0.00070234f, 
    0.09695002f, -0.06658822f, 0.03902541f, 0.03276771f, -0.05805857f, 0.01442830f, 0.01506208f, -0.06631485f, 
    -0.16300887f, 0.16540086f, 0.01694713f, -0.03001592f, -0.03833212f, 0.02675587f, 0.05031157f, 0.04687992f, 
    -0.05502854f, -0.00546021f, 0.03747514f, -0.04699391f, 0.10183689f, -0.12158575f, 0.27097046f, -0.02645625f, 
    0.15850888f, 0.11979800f, -0.03046677f, -0.00003946f, -0.08615277f, -0.21537347f, -0.05980146f, 0.01549033f, 
    -0.10377236f, -0.01622612f, -0.04271676f, 0.09853954f, 0.06008412f, -0.07045811f, -0.04597240f, -0.15664051f, 
    -0.03435121f, 0.08720713f, 0.08770308f, 0.07111656f, -0.24914326f, 0.01454459f, -0.01230277f, 0.08806358f, 
    -0.03426048f, 0.01329639f, 0.00727933f, 0.03663291f, 0.11174186f, -0.00436901f, 0.27480495f, 0.22781278f, 
    0.07940685f, -0.12852152f, -0.11970790f, -0.03628855f, -0.00953575f, -0.01685331f, 0.19698536f, -0.04566769f, 
    -0.04096817f, 0.09287876f, 0.01795440f, 0.09083036f, -0.06553681f, 0.02900940f, -0.07807010f, 0.17908920f, 
    0.10325891f, -0.18316528f, 0.02908471f, -0.03756048f, 0.00297868f, -0.10812369f, -0.07129660f, 0.10789786f, 
    0.11001625f, 0.11862741f, 0.11327946f, 0.09772015f, -0.02796524f, 0.01891707f, 0.03672165f, -0.05249362f, 
    -0.03782781f, 0.06356850f, 0.12326428f, 0.04066518f, 0.10594155f, 0.02366718f, 0.02159746f, 0.12972906f, 
    -0.00717883f, 0.11976374f, -0.07351437f, -0.00102373f, 0.21965446f, -0.10015857f, 0.07537935f, 0.09325913f, 
    -0.20261148f, -0.20463207f, -0.05072425f, -0.06274226f, -0.14385170f, 0.00281139f, 0.00144885f, -0.02756313f, 
    0.11747038f, 0.00164511f, -0.06781964f, 0.03581089f, 0.04431652f, -0.04015158f, 0.05668698f, -0.00580049f, 
    -0.07448008f, -0.06039304f, 0.05653258f, -0.09946712f, 0.01479572f, 0.00644992f, 0.00869606f, 0.03431145f, 
    0.16928411f, -0.26818395f, -0.07086898f, 0.20312876f, 0.04581408f, -0.16005069f, -0.00614382f, 0.15565282f, 
    0.05168800f, 0.05481417f, 0.16936213f, 0.02376832f, -0.38056734f, -0.14689854f, -0.01136207f, -0.00260633f, 
    -0.02980708f, 0.07128090f, 0.14212522f, -0.00121242f, -0.04657926f, -0.07495270f, 0.02536423f, 0.05600856f, 
    -0.00120412f, 0.12189495f, -0.02508372f, 0.17779736f, -0.05183703f, 0.07387616f, -0.07608993f, 0.02411734f, 
    -0.07667629f, 0.07633617f, 0.10402308f, 0.13031320f, -0.06404062f, 0.06407573f, 0.04110596f, 0.03361986f, 
    0.11079268f, 0.02478323f, -0.03725376f, -0.02484540f, -0.08074182f, -0.03631129f, 0.06155907f, -0.02969071f, 
    0.02806499f, -0.24711119f, -0.23388408f, -0.12435447f, 0.07303989f, 0.01243208f, -0.07895918f, 0.06254816f, 
    0.10677627f, -0.00007839f, 0.02773881f, -0.03522813f, -0.01565389f, -0.15062258f, 0.08875076f, -0.17692977f, 
    0.10379024f, -0.01310703f, 0.07634231f, -0.02168898f, 0.01161037f, -0.00174641f, 0.08566482f, -0.01788179f, 
    0.12801291f, -0.06553771f, 0.04803011f, -0.11790508f, 0.05221981f, 0.05495273f, 0.12347646f, 0.17673826f, 
    0.00827314f, 0.01760579f, 0.13907728f, -0.04078300f, -0.10164766f, 0.05827547f, -0.00471663f, 0.08728870f, 
    -0.02368007f, 0.00927560f, -0.10521583f, -0.02596216f, 0.02653796f, -0.07545055f, -0.14593154f, -0.41280082f, 
    -0.07181843f, 0.07563423f, -0.25487339f, -0.08306062f, -0.08130807f, 0.04543138f, -0.02327384f, 0.01478717f, 
    -0.05946094f, 0.06975169f, 0.16746496f, -0.02433202f, 0.31867939f, 0.16672191f, -0.02640530f, 0.20147702f, 
    0.00208477f, -0.03593172f, -0.06009816f, 0.04035810f, 0.14818223f, -0.08951207f, 0.02095210f, 0.05161718f, 
    0.44813552f, 0.10518189f, 0.12741077f, -0.28170142f, -0.09730290f, -0.08504353f, 0.10525850f, 0.19969648f, 
    0.08183257f, -0.08381669f, 0.03483674f, 0.07802024f, 0.08098039f, 0.18999469f, 0.23483495f, 0.12005885f, 
    0.10335571f, 0.32638270f, 0.03612117f, 0.06938625f, -0.02435554f, 0.02953823f, 0.01191581f, 0.04394234f, 
    0.26157892f, 0.18820921f, -0.26851353f, -0.04300406f, 0.03106170f, -0.06072953f, 0.05363632f, 0.01089135f, 
    -0.14724705f, -0.09413820f, -0.03379316f, 0.15202905f, 0.24110709f, 0.09930227f, 0.19472906f, 0.06836128f, 
    -0.08413581f, -0.01075054f, 0.04171852f, 0.03007736f, 0.09175906f, 0.02111146f, -0.03024247f, -0.04542546f, 
    -0.00629589f, 0.41335797f, -0.13126031f, 0.02226957f, 0.09405291f, -0.14314644f, 0.23037581f, -0.06657237f, 
    -0.01363405f, 0.04822400f, 0.01452716f, 0.04535684f, 0.14907485f, -0.18256465f, -0.00597288f, 0.01877040f, 
    0.00433948f, 0.04819418f, -0.02775334f, -0.02765840f, -0.03795406f, -0.24363618f, -0.10576578f, -0.25756305f, 
    0.33809975f, -0.00274484f, -0.02609872f, -0.01157759f, -0.02053153f, -0.04221077f, -0.00594840f, -0.13469402f, 
    0.01123413f, -0.01812512f, -0.00085887f, 0.08613735f, 0.15428087f, 0.09007709f, -0.12188680f, 0.10025829f, 
    -0.03555253f, -0.12064794f, -0.06092219f, -0.10438559f, 0.04106646f, 0.00661828f, 0.03979803f, 0.09891833f, 
    0.13262120f, -0.26381797f, -0.54282552f, -0.25105509f, -0.00931689f, 0.00532350f, -0.03320784f, 0.02260385f, 
    0.06785696f, 0.27543408f, 0.00728194f, -0.08340234f, -0.16771650f, -0.15359169f, -0.30879629f, -0.21358104f, 
    -0.13601527f, 0.05692247f, 0.06083474f, -0.14299585f, -0.13074778f, 0.01966097f, 0.13142301f, -0.05622659f, 
    -0.00256346f, -0.04011916f, -0.18852498f, 0.08771387f, -0.02846855f, -0.07948200f, -0.10532069f, -0.05882336f, 
    0.00413648f, -0.00741566f, 0.01869110f, 0.03812410f, 0.03875620f, -0.00063453f, 0.07824551f, 0.13174738f, 
    0.17343415f, 0.08993808f, -0.10000172f, -0.05431595f, -0.04373186f, 0.09948463f, 0.08640466f, 0.06663593f, 
    0.08860692f, -0.32211232f, -0.24842796f, -0.20360062f, 0.01237144f, 0.08486790f, 0.07715319f, 0.08409205f, 
    0.05323710f, -0.08933154f, -0.00643531f, -0.13797699f, -0.06833793f, -0.00066707f, -0.13949865f, 0.05054263f, 
    0.00279411f, -0.04780627f, -0.01442464f, 0.08766722f, -0.05980356f, 0.06676933f, 0.03009317f, -0.01556856f, 
    0.28449252f, 0.25251716f, 0.16485304f, -0.00864425f, 0.13354234f, 0.06374418f, 0.22098783f, 0.05077565f, 
    -0.02588849f, 0.00910651f, -0.00264223f, 0.02357657f, 0.20145629f, 0.09867276f, 0.01512114f, -0.05018477f, 
    -0.05320127f, -0.03301270f, -0.07418889f, -0.01125461f, -0.01227711f, -0.01896326f, -0.12681127f, 0.05114388f, 
    0.08153988f, 0.19323720f, 0.11392632f, 0.06738871f, 0.08836449f, 0.02305081f, 0.12297656f, 0.09797972f, 
    0.04836113f, -0.07916279f, 0.00694192f, 0.08846423f, 0.07981578f, 0.16522932f, -0.15640490f, 0.15211797f, 
    -0.00398911f, 0.02916312f, 0.18763928f, -0.21178421f, -0.02400355f, 0.02893812f, 0.05953193f, -0.08408473f, 
    0.10018124f, 0.19098420f, -0.18271373f, -0.15987289f, -0.03010984f, -0.04778251f, 0.05376309f, 0.18775253f, 
    -0.04389231f, -0.07751618f, -0.08328951f, 0.03640856f, 0.06456199f, -0.08131858f, -0.01235477f, 0.01543044f, 
    -0.04895862f, 0.02951959f, 0.14596020f, -0.08723356f, 0.13788584f, 0.12550516f, -0.14323430f, -0.09033503f, 
    0.20476888f, 0.07332679f, 0.16995472f, 0.03306087f, 0.11437389f, 0.07142682f, -0.00552649f, 0.08166566f, 
    -0.07861800f, -0.20371296f, -0.02345089f, -0.04870291f, 0.25965381f, 0.38167328f, 0.18146335f, 0.11462858f, 
    0.26870304f, 0.04624796f, 0.00862960f, 0.08168968f, -0.03255491f, -0.06299053f, -0.08480989f, 0.08173253f, 
    -0.19701996f, -0.01377266f, 0.16576038f, -0.10563082f, 0.03399602f, 0.22971496f, 0.14782907f, -0.24906863f, 
    0.04626193f, 0.08603717f, -0.02692720f, 0.01395281f, 0.16794422f, -0.20101051f, -0.46052599f, -0.31967601f, 
    -0.06939937f, 0.03674048f, -0.05067276f, 0.10714104f, 0.15169260f, -0.14330108f, -0.05490595f, -0.16207825f, 
    0.19430573f, 0.03278147f, 0.08079262f, 0.01393177f, 0.06328803f, -0.00872339f, -0.13222978f, 0.02921354f, 
    0.09773798f, 0.05753075f, -0.00241857f, -0.22655734f, 0.09250936f, 0.06062729f, 0.13471745f, 0.07210077f, 
    -0.01286772f, -0.03458643f, -0.02222314f, -0.05452294f, 0.02169229f, 0.04233493f, 0.04840673f, 0.06672767f, 
    -0.08926267f, 0.14268440f, -0.14896402f, 0.04765712f, 0.11734370f, 0.12070704f, 0.23104773f, -0.04169340f, 
    0.04968145f, 0.07456006f, -0.02444782f, 0.14706713f, -0.04233115f, 0.16278954f, 0.01543611f, 0.06537157f, 
    0.07817458f, 0.10519918f, 0.01893755f, 0.13328926f, -0.08635019f, 0.01346759f, -0.03470264f, 0.02698448f, 
    -0.31026751f, -0.04739163f, -0.33236697f, 0.29925382f, -0.08476359f, -0.10240773f, 0.01148275f, -0.00666967f, 
    -0.05801441f, 0.05804880f, 0.04723108f, 0.01427564f, 0.23767830f, -0.08526511f, -0.24796465f, -0.06799379f, 
    0.08652721f, 0.00732383f, 0.02808211f, -0.11078218f, 0.04223153f, -0.00275815f, 0.03827055f, 0.17838438f, 
    -0.05428981f, 0.01586593f, -0.01032199f, -0.02922850f, 0.16671100f, 0.01890107f, 0.29274213f, 0.05116620f, 
    -0.02210873f, 0.14996535f, 0.05155415f, 0.04398312f, 0.24854539f, 0.13240328f, 0.53522432f, -0.24027057f, 
    0.09584367f, 0.01420899f, 0.01232879f, -0.00652721f, 0.03298479f, 0.03194292f, 0.09889674f, 0.02565731f, 
    -0.13677393f, -0.22463624f, 0.20411043f, 0.12319668f, -0.02306256f, -0.02220823f, 0.07505780f, 0.01469589f, 
    0.01614320f, 0.02731794f, 0.06445453f, 0.05976484f, -0.20155843f, -0.17198129f, -0.09962590f, 0.15827763f, 
    -0.08026431f, -0.14968453f, 0.02837447f, 0.12799133f, -0.07740018f, 0.01608448f, -0.05218098f, -0.01115405f, 
    0.01008461f, -0.24573785f, -0.16264673f, 0.08965980f, 0.02820168f, 0.01936944f, 0.04478887f, 0.04164574f, 
    0.16249822f, 0.26505759f, -0.10168039f, 0.11741740f, 0.09294787f, 0.03700054f, -0.09279969f, 0.03562832f, 
    0.01079288f, 0.02492589f, 0.02457535f, 0.01314643f, -0.04558698f, 0.06522827f, -0.14046064f, 0.03813609f, 
    -0.03116519f, -0.22919059f, 0.07078818f, 0.15018183f, -0.09452270f, -0.03983688f, -0.08894100f, -0.00873638f, 
    -0.06498343f, -0.03073459f, -0.00920967f, 0.01995954f, 0.18335335f, 0.29410335f, 0.06073592f, -0.05744356f, 
    -0.01223754f, -0.03352499f, 0.07162336f, -0.11760028f, 0.18890965f, 0.13336159f, 0.11429650f, 0.14732441f, 
    0.05205758f, 0.23986411f, 0.06328425f, 0.05182835f, 0.12981310f, 0.14379279f, -0.19231787f, -0.06475157f, 
    0.08348700f, -0.06995986f, -0.01377574f, -0.05217540f, 0.11202504f, 0.13219933f, 0.31632149f, -0.20495105f, 
    0.07959911f, 0.07363677f, 0.03166841f, -0.00354989f, 0.05755886f, 0.01418660f, 0.00469549f, 0.00293688f, 
    0.03808776f, 0.08569556f, 0.34639806f, 0.06010673f, -0.07197677f, -0.04712346f, 0.08884183f, -0.12050387f, 
    -0.00601720f, -0.04736954f, 0.09131745f, 0.13820167f, -0.05435964f, 0.09599982f, -0.03677236f, 0.08468670f, 
    0.01520450f, 0.04821955f, 0.02330593f, 0.07857419f, 0.06835655f, 0.06559516f, -0.11797386f, 0.07776880f, 
    -0.22967142f, 0.10606136f, -0.02755675f, -0.01506402f, -0.06008679f, -0.00462408f, -0.00367102f, -0.12703785f, 
    0.08946542f, -0.05020269f, -0.01272176f, -0.08759528f, 0.23254336f, 0.12400721f, 0.07942466f, -0.13058066f, 
    -0.00154276f, 0.03644703f, 0.13605356f, 0.01225932f, 0.14914800f, 0.24589892f, -0.03229509f, 0.04774593f, 
    -0.08665875f, 0.08254706f, 0.18167768f, 0.10774812f, -0.10081161f, -0.08663496f, -0.03344223f, -0.01796087f, 
    0.06974274f, -0.05518810f, -0.04151275f, 0.11386305f, 0.16478410f, 0.15555282f, 0.13844711f, -0.05618888f, 
    0.15791711f, 0.10921885f, -0.04472243f, -0.01345294f, 0.20182504f, -0.09770257f, -0.02980335f, 0.06474774f, 
    -0.17266859f, -0.06766257f, 0.20666926f, 0.08686059f, -0.00398268f, 0.05648813f, -0.00524745f, -0.07221338f, 
    -0.05585169f, -0.02584551f, -0.01498736f, -0.06938297f, 0.05346854f, -0.02712077f, -0.00026795f, -0.03387079f, 
    0.07615231f, 0.06610546f, -0.04793500f, -0.02700782f, 0.12936644f, 0.04022525f, 0.09169271f, 0.05913955f, 
    -0.14609942f, -0.26621044f, 0.02272096f, 0.12643851f, 0.00957501f, 0.08938860f, -0.06653556f, -0.00987600f, 
    -0.01245820f, 0.09475463f, -0.02164412f, 0.06306026f, -0.04995051f, 0.15698680f, 0.12637337f, -0.08909316f, 
    0.10392432f, -0.03345420f, 0.07036066f, 0.07969798f, -0.10447454f, -0.08367258f, 0.04161416f, 0.14813270f, 
    -0.19321117f, 0.15240841f, 0.16368254f, 0.11344524f, 0.09537618f, -0.00618734f, -0.02526582f, -0.14804986f, 
    -0.00912579f, -0.00855422f, 0.02847037f, -0.04015126f, 0.22344767f, 0.15960270f, -0.07253434f, 0.09008642f, 
    0.10450764f, 0.12149303f, -0.00234402f, 0.08943283f, 0.14432769f, 0.04273149f, 0.09774532f, 0.09101591f, 
    -0.11175932f, -0.06310598f, 0.08431908f, 0.03111259f, -0.03191441f, 0.09028881f, -0.01677637f, -0.04004275f, 
    0.15777826f, 0.05592488f, 0.05303492f, 0.05892574f, -0.24925750f, -0.19341542f, 0.02048663f, 0.10587693f, 
    -0.11832791f, -0.11319369f, -0.01094777f, -0.06008448f, -0.03314263f, -0.02314372f, 0.01522395f, 0.04002817f, 
    -0.05718357f, -0.16706192f, -0.10934621f, 0.31410494f, 0.15748881f, 0.03524114f, -0.03197328f, 0.19778407f, 
    -0.04546030f, 0.05543912f, -0.03433438f, 0.03307601f, 0.02676237f, -0.02939303f, 0.26557127f, 0.13597342f, 
    -0.14907217f, -0.08503233f, 0.04595495f, -0.08305442f, -0.03194391f, -0.00011829f, 0.04501680f, 0.06149565f, 
    0.18849970f, 0.33883989f, 0.08671053f, 0.07253618f, -0.00964448f, -0.00365022f, -0.08708021f, 0.01250247f, 
    0.13692513f, -0.01983009f, 0.08726428f, 0.18879424f, 0.05909875f, 0.02001177f, 0.08364180f, -0.04721779f, 
    -0.00113043f, 0.06175667f, 0.01764309f, 0.01919443f, 0.03474079f, -0.10709381f, 0.01846883f, -0.07247834f, 
    0.30045542f, -0.27546689f, -0.12606254f, 0.06367595f, 0.16550626f, -0.19933772f, 0.01582361f, 0.14784504f, 
    -0.03421887f, -0.16674416f, 0.06519699f, 0.08268890f, -0.25238869f, -0.01900385f, 0.00921860f, 0.11007388f, 
    -0.07163672f, -0.00291935f, 0.13259478f, -0.00226568f, 0.03260799f, -0.02892222f, -0.02664320f, -0.06957054f, 
    -0.26624116f, 0.03369329f, -0.20447561f, 0.04481352f, -0.03666945f, -0.09515060f, 0.06509458f, -0.11042431f, 
    -0.13579375f, 0.02890734f, -0.03884818f, -0.00405621f, -0.14115459f, -0.11730403f, -0.09995849f, -0.02353729f, 
    0.07708295f, -0.04132701f, -0.01309967f, -0.15247962f, 0.12107041f, -0.00690991f, -0.00932723f, 0.12032607f, 
    -0.02256004f, -0.07752314f, 0.08980891f, 0.00350984f, 0.01267270f, -0.02396867f, 0.06640280f, 0.05548927f, 
    -0.05321439f, -0.08418101f, -0.02393222f, -0.01138804f, 0.26666716f, 0.07762524f, 0.15722173f, -0.02061801f, 
    -0.10125088f, -0.06059445f, -0.03561639f, 0.09337688f, -0.10313746f, 0.05861950f, 0.10638802f, 0.05720935f, 
    0.16210259f, -0.35663885f, 0.10674529f, 0.06706934f, -0.03319671f, 0.03914192f, -0.01947374f, 0.08993240f, 
    -0.02440399f, -0.02145141f, 0.01814678f, 0.06468859f, 0.09334237f, 0.25635663f, 0.08089812f, 0.17971051f, 
    -0.11437010f, -0.00350763f, -0.00414701f, 0.15126392f, -0.08920061f, -0.00005210f, 0.02606845f, 0.03443398f, 
    0.19236416f, -0.08372760f, -0.18737738f, 0.12504415f, -0.06503881f, 0.09031747f, -0.06990937f, 0.00799310f, 
    0.01000559f, -0.01011118f, -0.11317412f, 0.00155604f, 0.25772342f, 0.14985776f, -0.03230124f, -0.01949692f, 
    0.05202685f, 0.06112695f, 0.01592725f, 0.05786012f, -0.14813793f, -0.02838772f, -0.11438090f, -0.07271232f, 
    0.00848746f, -0.03175552f, -0.04369402f, 0.18624134f, -0.13908756f, 0.06418188f, 0.00978219f, 0.01269765f, 
    -0.03184206f, -0.08684123f, -0.14933859f, -0.05793451f, 0.08870450f, 0.08352903f, 0.09816854f, -0.12267333f, 
    -0.05295131f, -0.09511833f, 0.01048781f, -0.05247715f, -0.00540506f, -0.11224653f, 0.06389779f, 0.33262321f, 
    0.07678960f, -0.22438954f, 0.06565811f, -0.10035320f, 0.01869428f, 0.19588576f, -0.08853127f, 0.09141923f, 
    0.00937293f, -0.07434379f, 0.09553984f, -0.01375137f, 0.14241782f, 0.04676291f, 0.02329069f, -0.00617098f, 
    0.08213785f, 0.05710270f, -0.07394441f, 0.06480163f, -0.06560165f, -0.02165278f, 0.04863991f, 0.00366811f, 
    0.35744467f, 0.12105919f, 0.04314723f, -0.07615545f, -0.05667034f, -0.14521956f, 0.08489797f, -0.09995796f, 
    -0.11282080f, -0.08936194f, -0.08634293f, 0.11555733f, -0.00707772f, 0.09823694f, 0.15597689f, -0.23543489f, 
    0.05916702f, -0.07052892f, 0.00351333f, 0.05821780f, 0.04680213f, -0.05668942f, -0.13567938f, -0.03906136f, 
    -0.20339809f, 0.10180346f, 0.08856503f, -0.09318013f, -0.05852472f, -0.16966522f, -0.02508988f, 0.03350361f, 
    0.00239817f, 0.01126955f, -0.02320273f, -0.07042091f, -0.18671332f, 0.18054073f, 0.12291336f, -0.06975147f, 
    -0.09473087f, 0.09364574f, 0.12095050f, -0.07224230f, 0.13083914f, 0.09036921f, 0.03619085f, 0.02450175f, 
    0.16955686f, -0.01166567f, 0.06441583f, 0.03388841f, -0.10707332f, -0.16871437f, -0.04468950f, -0.14100590f, 
    0.02375235f, -0.02153726f, 0.04870336f, 0.08031172f, 0.09104101f, 0.38500541f, 0.04405409f, 0.06480281f, 
    -0.04531078f, -0.02541065f, 0.01847442f, 0.04000409f, 0.03965840f, 0.07179148f, -0.07923191f, -0.05609436f, 
    0.03321905f, 0.05484712f, 0.15083049f, 0.02413589f, -0.07745742f, 0.16385472f, -0.05865312f, 0.18919937f, 
    0.00528550f, -0.11356372f, -0.03662460f, -0.14174825f, 0.10762680f, -0.00172572f, -0.00427569f, 0.01652292f, 
    0.00285355f, 0.05487635f, -0.01283613f, -0.05709077f, -0.00907069f, 0.01986014f, -0.21886079f, -0.17755926f, 
    -0.07250092f, 0.02612235f, 0.14298962f, 0.08781023f, -0.04077401f, 0.02950258f, -0.11339494f, 0.04601570f, 
    0.16087823f, 0.09025302f, -0.05443691f, -0.05966853f, 0.32335907f, 0.07656553f, 0.19129264f, -0.27587488f, 
    0.00976474f, 0.12981582f, -0.05698011f, 0.22130919f, -0.08631209f, -0.04761270f, 0.01142333f, 0.10192845f, 
    -0.07644635f, 0.18393710f, 0.14549182f, -0.09204835f, -0.00219914f, -0.02301414f, 0.08007032f, -0.04790572f, 
    0.01632419f, -0.03303642f, -0.08373436f, -0.02406371f, -0.04507792f, -0.10458568f, 0.13040970f, -0.09656213f, 
    0.03404566f, -0.01877444f, -0.02082307f, 0.02649174f, -0.10338667f, 0.08008838f, -0.07489595f, -0.05350098f, 
    0.07216539f, 0.15927687f, 0.17691754f, 0.00238710f, 0.07621925f, -0.13755853f, 0.07998501f, 0.14761209f, 
    0.16488703f, 0.14455427f, 0.07162258f, 0.00884948f, -0.09862670f, -0.00539430f, 0.10350139f, 0.10306723f, 
    0.02357820f, -0.00385600f, -0.02100953f, -0.00342247f, 0.01673623f, -0.06587072f, 0.03769790f, 0.02326094f, 
    -0.11480677f, 0.15848394f, 0.12632024f, 0.22096005f, 0.06366606f, -0.00149932f, -0.08294108f, -0.07733545f, 
    -0.13696367f, -0.14828415f, -0.20280138f, 0.11264552f, 0.45767483f, 0.14075409f, 0.04854736f, 0.04539356f, 
    -0.12955137f, -0.16531217f, -0.11148755f, -0.11431796f, 0.03503770f, 0.03725270f, -0.04412152f, -0.00102880f, 
    0.11795531f, -0.05346660f, 0.14057238f, -0.02154134f, 0.00570947f, -0.11387440f, 0.10992273f, 0.04134992f, 
    0.07519306f, -0.04810711f, -0.01254256f, 0.07735963f, 0.25053960f, 0.07402544f, 0.15117285f, 0.08996814f, 
    -0.05846293f, 0.10223929f, 0.02380180f, 0.05834441f, 0.01379603f, -0.07108092f, -0.04021600f, -0.01902349f, 
    0.16416867f, -0.08461986f, 0.03067005f, 0.21154621f, 0.02893329f, -0.12916552f, 0.05580905f, 0.00011745f, 
    -0.01544074f, -0.16660254f, 0.01452178f, -0.03953106f, -0.07735569f, 0.23655353f, 0.04811478f, 0.19531597f, 
    -0.04763615f, -0.02164917f, 0.08627351f, 0.09702181f, -0.07296168f, -0.07083447f, 0.02124761f, -0.08799129f, 
    -0.09224626f, 0.07485992f, -0.05568743f, 0.15115000f, 0.07964734f, -0.09398295f, -0.02178214f, -0.13741948f, 
    -0.08142874f, 0.00133225f, 0.02598195f, -0.08572792f, -0.12546806f, -0.11002986f, -0.10961509f, 0.04797014f, 
    0.12583899f, 0.01406748f, 0.06187284f, -0.12024840f, -0.01866009f, 0.16654509f, 0.11635061f, 0.20403561f, 
    -0.13915215f, -0.19285244f, -0.16913094f, -0.17245950f, 0.22303911f, -0.07701322f, 0.08119100f, 0.11786557f, 
    -0.01203260f, -0.01156773f, -0.01673426f, -0.07929406f, 0.08509227f, -0.15043236f, -0.16406643f, -0.27785364f, 
    -0.06364144f, 0.00435856f, -0.04645716f, -0.03298889f, 0.10343662f, 0.00319469f, 0.06639609f, -0.06685122f, 
    0.11927881f, -0.07719538f, 0.24703196f, 0.09868653f, 0.00612356f, -0.11314411f, -0.05379554f, 0.02251815f, 
    0.07850448f, 0.03042003f, -0.09308974f, 0.12141952f, 0.24885115f, 0.36974105f, 0.33775499f, 0.18869925f, 
    0.08170409f, 0.07494131f, 0.06049824f, 0.19455479f, 0.01104257f, -0.11719216f, -0.06438780f, -0.14226902f, 
    -0.43768433f, -0.05801461f, -0.22569314f, 0.28167766f, 0.09000943f, 0.03355717f, -0.07648056f, -0.00209289f, 
    0.06112474f, 0.21255405f, -0.06490371f, 0.11360190f, -0.00943982f, -0.20365371f, -0.26647055f, 0.02093321f, 
    0.09615894f, 0.09028288f, 0.04665671f, -0.02141596f, -0.02710288f, -0.10213840f, -0.16004640f, -0.12425814f, 
    0.13082483f, 0.04856654f, -0.02570875f, 0.16091391f, 0.07928327f, 0.04122799f, 0.01044391f, 0.02019258f, 
    -0.06466293f, -0.05045941f, -0.14923419f, -0.09652882f, 0.06873348f, -0.09735271f, -0.11930750f, -0.14823689f, 
    -0.01829199f, -0.07367396f, -0.04354276f, -0.09922282f, 0.12267499f, 0.03933473f, 0.09334388f, 0.48946843f, 
    0.04524205f, 0.01486603f, -0.22116473f, -0.09444088f, -0.04500546f, 0.08379859f, -0.05175853f, 0.10935558f, 
    0.27416846f, -0.03632189f, -0.12922786f, -0.01354452f, 0.09965167f, -0.04233142f, -0.10081296f, -0.22604628f, 
    -0.02847600f, 0.10209757f, -0.02369063f, -0.08007722f, 0.08002771f, -0.04364581f, 0.02829939f, -0.00885607f, 
    0.16942886f, 0.29695222f, 0.07571952f, 0.11811471f, 0.08110336f, 0.03404440f, 0.01832233f, -0.03394889f, 
    -0.15656626f, -0.05350162f, -0.00036174f, 0.00030813f, -0.01399890f, 0.20991258f, 0.10529966f, 0.13677214f, 
    0.17463273f, 0.12656844f, -0.00158589f, 0.03966150f, 0.04512944f, 0.02072819f, -0.10094655f, -0.02588473f, 
    -0.03672945f, 0.18965895f, -0.04929734f, -0.10717611f, -0.08370676f, -0.12621607f, -0.11471378f, -0.08787378f, 
    0.05385506f, -0.08491025f, 0.04680887f, 0.06572668f, 0.01403178f, 0.01417330f, -0.05552963f, -0.12977484f, 
    -0.02432338f, 0.15409297f, 0.03204960f, -0.13542204f, 0.17491539f, 0.16154969f, 0.00113737f, -0.01021440f, 
    0.15150842f, 0.12964910f, 0.20907226f, 0.23281822f, 0.00360142f, -0.05346580f, 0.04116080f, -0.06587341f, 
    0.09730985f, -0.08754686f, 0.08482732f, 0.19924280f, 0.14601138f, 0.21854161f, -0.00228867f, -0.12904845f, 
    0.01552253f, 0.16620876f, 0.02536147f, 0.12711486f, 0.12076096f, 0.01051619f, 0.00578688f, -0.07803296f, 
    0.08909678f, 0.32795194f, 0.19130437f, -0.00801038f, -0.02025750f, 0.01307691f, -0.08932603f, 0.02430119f, 
    -0.00446300f, -0.09534629f, -0.04218490f, -0.19861433f, -0.07072681f, -0.12644559f, -0.16022842f, 0.17040208f, 
    0.10455465f, 0.09443228f, -0.07902591f, 0.02817325f, -0.00070895f, 0.10612049f, -0.06198914f, 0.02567092f, 
    0.23984370f, 0.11535039f, 0.20701395f, 0.15241221f, -0.00169891f, -0.05347169f, -0.00587772f, 0.04321270f, 
    0.08965885f, -0.01159644f, 0.00336009f, 0.06812234f, 0.13242665f, -0.14685893f, -0.20484708f, -0.21095328f, 
    -0.06088312f, -0.06365545f, 0.01143640f, 0.05957177f, 0.00755290f, 0.05175663f, -0.02958330f, 0.21829745f, 
    -0.04676924f, 0.40208140f, 0.21561225f, -0.15523238f, 0.02410203f, 0.04012839f, -0.06872442f, 0.01128336f, 
    -0.04504182f, 0.02282391f, 0.02354185f, 0.09879111f, 0.09096815f, -0.14117065f, -0.20064078f, -0.13493344f, 
    0.08013032f, 0.11331630f, -0.07683553f, 0.07880048f, -0.00279762f, 0.01481811f, -0.12206025f, 0.08461536f, 
    0.19501895f, 0.21853469f, 0.25242054f, 0.10701682f, -0.05513239f, -0.04532329f, -0.13095081f, 0.01398181f, 
    0.03197217f, 0.08296923f, 0.16034910f, 0.16596422f, -0.02982791f, 0.07835799f, 0.24021238f, 0.25656426f, 
    -0.01589733f, -0.05452941f, -0.10243436f, -0.09292109f, 0.01205391f, 0.00618190f, 0.07305123f, -0.00976003f, 
    -0.18026206f, -0.15010163f, 0.02346705f, 0.15262364f, 0.03821015f, 0.06085397f, -0.06887212f, -0.07218672f, 
    -0.15853550f, -0.13047856f, -0.10669841f, 0.11035296f, 0.18778089f, 0.28074932f, 0.32917449f, 0.19910282f, 
    0.07704779f, 0.02765639f, 0.13573581f, -0.12865175f, -0.02799496f, -0.03163081f, 0.10546121f, 0.13212118f, 
    0.10311926f, -0.25797039f, -0.11714970f, -0.19671695f, -0.03424264f, 0.02257579f, 0.01030993f, 0.05256894f, 
    0.12640136f, -0.08344409f, -0.04795051f, 0.10451233f, -0.07733539f, -0.25402853f, -0.10217294f, 0.14612429f, 
    0.10900298f, 0.02867438f, 0.05238771f, 0.08793935f, 0.04729647f, -0.05174671f, -0.10712715f, -0.09256747f, 
    0.10418671f, -0.31231463f, -0.56139570f, 0.03790005f, 0.19490993f, -0.14390257f, -0.20542802f, -0.01754365f, 
    -0.06404819f, -0.24523140f, 0.05451959f, -0.07072149f, 0.08690812f, 0.32949853f, 0.13341376f, 0.04504447f, 
    0.01626855f, -0.07765351f, 0.11577453f, 0.05210316f, -0.13658170f, -0.08923986f, 0.02331656f, -0.06066070f, 
    -0.03471008f, -0.01076588f, -0.03158647f, -0.05776219f, 0.03097359f, -0.05904822f, -0.01044165f, -0.03879714f, 
    -0.04257479f, -0.00158661f, 0.01285069f, 0.02237312f, 0.01707721f, -0.03269014f, -0.06038170f, -0.04424895f, 
    0.00937274f, 0.02932602f, -0.05376324f, 0.02418261f, -0.01029402f, 0.02372574f, 0.01092916f, 0.01951421f, 
    0.02481197f, -0.02666331f, -0.04210981f, -0.02524495f, -0.01681881f, -0.02990136f, 0.01343516f, -0.00634511f, 
    0.00482214f, -0.00974528f, -0.06405500f, -0.06054271f, 0.01567828f, -0.01668911f, -0.02338260f, -0.03506516f, 
    -0.03503337f, -0.05099653f, 0.02464546f, -0.04326314f, 0.00283903f, 0.01676722f, -0.06259187f, -0.04979950f, 
    0.02059405f, 0.01784297f, -0.02575081f, -0.04372985f, -0.02780189f, 0.01044519f, -0.01457848f, -0.02285767f, 
    -0.01283403f, 0.00158123f, 0.02340546f, -0.01479736f, -0.03454579f, 0.02537961f, 0.02874909f, -0.03477875f, 
    -0.00484865f, -0.02163498f, -0.05470239f, 0.01953552f, 0.00992083f, -0.01548110f, -0.02189019f, -0.02334734f, 
    -0.00604366f, -0.00513797f, -0.04237743f, 0.00449954f, -0.05823010f, 0.00320872f, -0.04514537f, -0.02587153f, 
    -0.03652556f, -0.06100699f, -0.06440372f, -0.01038533f, -0.03606535f, -0.04686064f, 0.01996942f, -0.03804111f, 
    0.04361957f, -0.00257298f, -0.02800375f, -0.03570516f, -0.02753321f, -0.04606726f, -0.06471701f, -0.03152440f, 
    0.00344006f, -0.04816322f, 0.03098606f, 0.00290528f, -0.00027558f, -0.04310215f, 0.02871799f, -0.00563563f, 
    -0.01936050f, -0.03839298f, 0.00765547f, -0.03712089f, 0.00022345f, 0.01846228f, -0.02002914f, -0.06135853f, 
    -0.01805208f, 0.01484328f, -0.00506167f, 0.01176578f, -0.04396008f, -0.01190921f, 0.00552889f, -0.02551785f, 
    -0.06018293f, -0.00249739f, 0.02325669f, -0.03914937f, 0.03056482f, 0.01304126f, -0.01509129f, 0.00712313f, 
    -0.00802992f, -0.00452581f, -0.01384784f, -0.00921386f, -0.02525382f, -0.02304740f, -0.03631776f, -0.02857200f, 
    -0.05342337f, -0.00509731f, -0.04637624f, 0.00888920f, -0.01382637f, -0.04706486f, 0.01986017f, -0.05065844f, 
    0.01629619f, 0.00022123f, 0.01427503f, 0.02479014f, -0.01223005f, 0.03110227f, -0.00146274f, -0.01503272f, 
    0.01693631f, -0.04037516f, -0.01046044f, 0.02882443f, -0.05477726f, 0.03568905f, -0.00978129f, 0.01829022f, 
    -0.00715825f, -0.06101240f, 0.00933561f, -0.06215321f, 0.01191656f, 0.03248691f, -0.04098046f, 0.02509088f, 
    0.01100359f, -0.04787313f, 0.01197469f, 0.00147388f, -0.03763700f, -0.03159523f, 0.01902062f, -0.04044179f, 
    0.01103117f, -0.04793998f, -0.02753720f, -0.00351517f, 0.02307803f, -0.04681686f, -0.01453850f, 0.00270248f, 
    -0.00524328f, -0.05356017f, 0.03064352f, 0.01795759f, -0.05432895f, -0.01396514f, -0.05972840f, -0.04605187f, 
    -0.03519775f, 0.00309083f, -0.06451439f, -0.00789594f, -0.05269014f, 0.01723904f, -0.04343834f, -0.03740754f, 
    -0.00192357f, -0.05900676f, -0.02911280f, -0.03251352f, -0.00536139f, 0.00219528f, -0.01382768f, -0.01154661f, 
    -0.03311476f, -0.05919683f, -0.02626672f, 0.02565194f, -0.00922754f, 0.00567069f, -0.01074467f, 0.01537102f, 
    0.01360044f, -0.00306267f, -0.02319959f, -0.05985534f, -0.05361419f, -0.00892275f, -0.00774321f, 0.00494497f, 
    -0.05604506f, 0.03187871f, -0.02508467f, 0.01311107f, -0.04606650f, -0.01710422f, -0.03258542f, 0.00284019f, 
    0.01987744f, 0.00397611f, 0.03020825f, 0.00598493f, -0.04862272f, -0.01120679f, 0.03650510f, 0.00133668f, 
    -0.00965243f, 0.03200245f, -0.03106889f, 0.02005073f, 0.03610578f, -0.00500370f, -0.04375423f, -0.00516250f, 
    -0.02848220f, -0.03418890f, 0.01320132f, -0.03941936f, -0.05881190f, -0.02370072f, -0.04495185f, 0.00524068f, 
    -0.03417197f, -0.05126601f, -0.01927283f, 0.02316493f, 0.00628938f, -0.03453701f, 0.01183242f, -0.01123155f, 
    -0.03938403f, -0.03053021f, -0.00972272f, -0.02123330f, 0.01561485f, -0.04617262f, -0.03327734f, -0.01332808f, 
    -0.02249373f, 0.00430619f, 0.00227845f, -0.04233333f, -0.06250803f, -0.02769169f, 0.02352742f, -0.04256018f, 
    -0.05428879f, -0.05898674f, -0.05744974f, -0.04942924f, -0.00671470f, -0.01849998f, -0.04411859f, -0.01615126f, 
    -0.02495588f, -0.04399718f, -0.02820831f, 0.02430656f, -0.03619290f, -0.02301744f, -0.04983343f, -0.01395371f, 
    -0.03543363f, -0.02634498f, -0.05513446f, -0.02362692f, -0.04665370f, 0.02333218f, -0.06397846f, 0.02885390f, 
    -0.04305448f, 0.02472165f, -0.04538220f, -0.03635136f, -0.02140069f, -0.06042113f, -0.04382333f, -0.05418469f, 
    0.01524721f, 0.02789705f, -0.05314282f, -0.04595060f, -0.04266347f, 0.02071450f, 0.01187505f, -0.06260355f, 
    -0.04051488f, 0.00930675f, -0.02172698f, -0.01105681f, -0.01677933f, 0.01046714f, -0.00939543f, 0.00633275f, 
    0.01174271f, -0.02403077f, 0.01345792f, -0.00919706f, -0.06051999f, -0.01534619f, 0.00703246f, 0.03182499f, 
    0.02494654f, -0.01640191f, -0.03536718f, -0.03306872f, -0.00655053f, -0.02307321f, -0.04662951f, 0.01103305f, 
    -0.02567192f, -0.01810776f, -0.03675148f, -0.00931600f, -0.02542740f, 0.02231850f, 0.03014568f, -0.03853953f, 
    0.02961117f, 0.02301173f, -0.01701879f, 0.00468670f, 0.00141671f, -0.03152982f, -0.04454806f, 0.03438216f, 
    -0.04191019f, -0.06461774f, -0.02454082f, -0.02197786f, -0.00976897f, -0.04195744f, -0.06011039f, -0.05018739f, 
    -0.03588807f, -0.00425112f, -0.02013279f, -0.02770068f, -0.01270427f, -0.00162630f, -0.04419272f, -0.01509525f, 
    -0.03112788f, -0.01114933f, -0.04837632f, -0.02466859f, 0.01434172f, -0.03415672f, -0.03492492f, 0.01545521f, 
    -0.03706206f, -0.01627070f, -0.03518603f, -0.02179018f, -0.01560577f, 0.00416352f, -0.01851654f, -0.02732226f, 
    0.01438501f, 0.02779211f, 0.01114725f, -0.00378828f, 0.04460272f, -0.04678912f, -0.02918783f, 0.01053572f, 
    0.03818243f, -0.02458626f, -0.00929698f, 0.02439410f, -0.03632428f, -0.03286429f, -0.02426730f, -0.00872347f, 
    -0.06466847f, -0.02190854f, 0.03129989f, -0.04364208f, -0.01034382f, -0.01802152f, 0.03486189f, -0.03078372f, 
    0.03518516f, 0.01648451f, -0.05793535f, 0.01261824f, -0.02776650f, 0.02214491f, 0.02118326f, -0.03629375f, 
    0.01098695f, 0.01800026f, 0.00410270f, 0.02815706f, 0.01033951f, 0.03749022f, -0.00152071f, 0.01221186f, 
    -0.02519867f, -0.03606935f, -0.02124453f, 0.03431555f, -0.05236930f, -0.02455636f, -0.02092605f, -0.04118921f, 
    0.04033715f, -0.00487395f, -0.00475517f, 0.04707024f, 0.03471821f, -0.04469355f, 0.03180202f, -0.04129779f, 
    -0.00311752f, 0.01247368f, 0.02656563f, -0.04827394f, 0.00168695f, -0.02303746f, -0.01060711f, -0.04409095f, 
    0.03581443f, 0.03422471f, 0.04179380f, 0.00277620f, -0.05016806f, 0.04044139f, -0.02344054f, -0.01025530f, 
    0.00692852f, 0.01859891f, -0.05986395f, -0.04647044f, 0.02300753f, -0.02179011f, -0.04097253f, -0.02671016f, 
    -0.00093999f, 0.01909821f, 0.03436611f, -0.00947110f, -0.03949156f, -0.05646873f, -0.01807092f, -0.02679660f, 
    0.00011819f, 0.02703937f, 0.01360488f, 0.01604166f, -0.01839119f, 0.01994772f, 0.04001529f, 0.00380755f, 
    0.01333981f, -0.03884219f, -0.00328332f, 0.00081042f, -0.00803907f, 0.02043512f, 0.02597955f, -0.01371814f, 
    -0.02398412f, -0.05168549f, -0.00998532f, -0.04744989f, -0.02400383f, 0.04140329f, -0.03872186f, -0.03800495f, 
    -0.01579166f, -0.01138594f, -0.02707878f, -0.05080628f, 0.03338847f, -0.03200353f, 0.00839257f, -0.02630012f, 
    -0.05004473f, -0.05871264f, -0.01771695f, -0.06202903f, 0.02602536f, 0.02554267f, 0.01599875f, 0.02845513f, 
    -0.04211799f, -0.01459387f, -0.01808349f, -0.03047980f, -0.03603171f, -0.01824627f, 0.04193951f, -0.00200171f, 
    0.01370086f, -0.03515653f, -0.00937456f, -0.00082156f, -0.04558045f, -0.00328748f, 0.01308568f, 0.03099183f, 
    -0.05096599f, -0.04249202f, 0.02555695f, -0.02402502f, -0.05360721f, 0.00195171f, 0.04103651f, 0.02025974f, 
    -0.00493999f, 0.03757035f, -0.04207265f, -0.00485896f, 0.00929505f, -0.05901420f, -0.00106008f, 0.03788754f, 
    -0.01921774f, 0.00789826f, -0.00003445f, 0.03064972f, 0.03447347f, -0.04304642f, -0.00610565f, 0.03329047f, 
    0.03570652f, -0.04186508f, 0.01991694f, 0.04254113f, -0.00567445f, -0.04245587f, 0.02438497f, 0.03925866f, 
    -0.05372564f, 0.00813394f, -0.00728910f, 0.01489080f, -0.00090645f, -0.03987444f, -0.03873821f, 0.01599219f, 
    -0.03806927f, 0.03410794f, 0.04336024f, -0.03168179f, -0.04226797f, -0.03985991f, -0.03910887f, -0.04622148f, 
    0.00810585f, -0.00690441f, -0.02933722f, 0.00391693f, 0.01975089f, -0.03231437f, 0.03081799f, 0.02958038f, 
    -0.05479601f, -0.02550090f, -0.01088641f, -0.02524052f, -0.01076027f, 0.00857676f, 0.02477466f, -0.01916085f, 
    0.02690249f, 0.01961732f, 0.00721439f, -0.01515878f, -0.01190599f, 0.04895163f, -0.01268437f, -0.00069512f, 
    0.02594891f, -0.02180878f, 0.03800347f, 0.03612131f, 0.04493414f, 0.03617911f, -0.03651989f, -0.03264690f, 
    -0.04114403f, 0.02732419f, -0.05949215f, 0.01167791f, -0.02604619f, -0.03842694f, 0.03155460f, 0.00025029f, 
    -0.01975166f, 0.03205669f, -0.02150446f, 0.00250260f, 0.00458299f, -0.01303156f, -0.03375719f, -0.04504213f, 
    0.02798295f, -0.05006033f, -0.00985579f, 0.04445883f, -0.05066084f, -0.04609507f, -0.03044216f, -0.03474411f, 
    0.01710630f, 0.01090280f, -0.02561126f, -0.00179324f, 0.04527825f, -0.01081872f, -0.02844400f, -0.02831935f, 
    -0.03774420f, 0.04139002f, -0.00040566f, -0.01606152f, -0.04700812f, 0.01735191f, -0.01370097f, 0.03506093f, 
    -0.04605357f, -0.01915737f, -0.00964920f, -0.04995915f, 0.04327790f, -0.03891531f, -0.03066684f, -0.01598827f, 
    -0.01272874f, 0.02241193f, -0.03925595f, 0.03204615f, -0.01641155f, -0.01486005f, -0.00194995f, 0.04361939f, 
    -0.01178717f, -0.00989873f, 0.01608144f, -0.02635065f, 0.03692854f, 0.01341166f, -0.04180337f, 0.03781541f, 
    0.01145882f, -0.03886469f, -0.03853001f, 0.04432634f, -0.04926001f, 0.00342810f, -0.06142826f, -0.00498964f, 
    0.03978179f, -0.04644857f, -0.03403163f, -0.01215583f, -0.02869060f, 0.03322550f, -0.05299162f, -0.04407934f, 
    -0.01175068f, -0.06485695f, -0.04319023f, -0.03065027f, -0.00334666f, 0.04118842f, 0.02907762f, -0.02318767f, 
    -0.02972380f, 0.02513484f, -0.02025019f, -0.05644684f, -0.06081892f, -0.01075898f, -0.02817360f, 0.02986843f, 
    0.02170952f, -0.01382665f, -0.03615304f, -0.00139826f, 0.00860727f, 0.03195376f, -0.01372281f, 0.01006901f, 
    0.01396369f, 0.01327853f, -0.03518851f, 0.01637111f, 0.00433654f, 0.03433508f, -0.02864399f, -0.03785627f, 
    0.02030871f, 0.02639166f, 0.00099002f, 0.03281542f, -0.02866307f, -0.05015928f, -0.02283481f, -0.03824409f, 
    0.00103354f, -0.02155757f, -0.00901850f, 0.00329869f, 0.00671683f, -0.03953733f, 0.00954223f, 0.00407445f, 
    0.02466394f, -0.00507480f, -0.03896454f, -0.04892809f, 0.03367268f, 0.03628367f, -0.05408786f, -0.02350752f, 
    -0.03327870f, -0.01523958f, 0.03310470f, 0.03494413f, -0.06219681f, 0.03838515f, -0.02721214f, -0.00294258f, 
    -0.01983814f, 0.01073701f, -0.02978753f, 0.02043828f, 0.00667062f, -0.03218421f, -0.01153257f, -0.01340574f, 
    0.00529182f, -0.04839057f, 0.03897405f, 0.04031171f, 0.01583946f, 0.01704186f, -0.03997684f, 0.04563182f, 
    -0.04757034f, -0.04002642f, 0.03190476f, -0.00008981f, 0.02157202f, -0.03771657f, -0.04284596f, -0.04973802f, 
    -0.04969496f, -0.02690222f, 0.04005591f, -0.03856951f, -0.01377984f, 0.02646283f, -0.05003234f, -0.04193947f, 
    -0.04123797f, 0.01032020f, -0.04396194f, -0.00148137f, -0.03252774f, 0.03239042f, -0.04179081f, 0.04652340f, 
    -0.03188315f, 0.00680919f, -0.02672295f, 0.04241906f, -0.01063701f, -0.05173118f, 0.01379637f, 0.01684512f, 
    0.02196843f, -0.02171609f, 0.02482695f, -0.03688484f, -0.01609022f, -0.02025658f, 0.02738670f, 0.01036283f, 
    0.03939811f, 0.01102085f, 0.03289564f, -0.04722360f, -0.02161396f, -0.03735073f, -0.03309428f, 0.00503960f, 
    0.02130814f, 0.01237640f, 0.02549378f, 0.02799736f, -0.02731548f, -0.01806418f, -0.03449726f, -0.04268076f, 
    -0.04974369f, -0.05368192f, 0.01147566f, 0.01580441f, -0.01010571f, -0.00746983f, 0.03679408f, 0.03412103f, 
    -0.04592050f, -0.00355681f, -0.04599904f, 0.04026567f, -0.03479270f, -0.01995193f, -0.00120378f, 0.04286126f, 
    -0.03292016f, -0.01579553f, -0.05484170f, 0.02211695f, -0.00226349f, 0.04691768f, 0.00441799f, -0.01945564f, 
    0.01029812f, 0.04588076f, 0.04125922f, -0.01518232f, 0.01159331f, -0.02771040f, -0.04338094f, -0.02763894f, 
    0.00830866f, 0.00906890f, -0.05648186f, 0.02433508f, -0.03368128f, -0.00449276f, -0.00020557f, 0.02780931f, 
    0.01855109f, 0.00853749f, -0.03638662f, -0.02525134f, 0.02034887f, 0.00973354f, -0.04699692f, -0.05697259f, 
    -0.02580325f, 0.02974292f, 0.04220179f, -0.01242595f, -0.03432123f, -0.01384690f, -0.01260174f, 0.01594936f, 
    -0.04754723f, -0.01691956f, 0.03342960f, -0.01055590f, 0.01692761f, -0.01898184f, 0.03886096f, -0.01828031f, 
    -0.03633708f, -0.02920017f, -0.05358184f, -0.04622165f, 0.03763017f, 0.00248302f, 0.00128468f, 0.00789410f, 
    -0.00624831f, -0.02290664f, 0.00462517f, -0.01456088f, -0.02113440f, -0.03797591f, 0.02884635f, -0.03314017f, 
    0.02739041f, 0.00469545f, -0.00172347f, -0.01582477f, -0.02507432f, 0.02890901f, -0.00556677f, 0.00334545f, 
    -0.05286138f, -0.05887705f, 0.00685570f, -0.04112988f, -0.04946878f, 0.00130004f, 0.00516758f, 0.02578092f, 
    0.03743117f, -0.02583550f, 0.03748362f, -0.00900550f, -0.01548290f, 0.02498404f, -0.00301639f, 0.01710582f, 
    -0.04282304f, -0.03796805f, -0.01774344f, -0.05303636f, -0.01802170f, -0.01370237f, -0.05313454f, -0.04667773f, 
    0.03954086f, 0.00628310f, -0.04379976f, 0.03196980f, -0.00963647f, 0.01091498f, -0.03241351f, -0.02277030f, 
    0.03438044f, -0.05428088f, -0.02644175f, -0.00983087f, 0.02013058f, 0.02034021f, -0.03991072f, -0.00285355f, 
    -0.04088543f, -0.02564023f, 0.00381769f, 0.04371980f, -0.02944905f, -0.00789166f, 0.02340997f, -0.01233460f, 
    -0.02259968f, 0.03122200f, -0.01479414f, -0.02520586f, 0.03543870f, -0.00419751f, 0.02857009f, 0.00329097f, 
    -0.04848694f, -0.03776318f, 0.03098544f, -0.02487177f, -0.00614991f, 0.03706592f, -0.00747785f, -0.05184812f, 
    -0.01513371f, -0.01966910f, -0.04212328f, -0.01341531f, 0.03165543f, 0.00439071f, 0.02898133f, -0.03352651f, 
    0.02511900f, -0.00336590f, 0.03721181f, 0.01594675f, 0.02341975f, -0.02473364f, -0.01683020f, 0.04369284f, 
    -0.02932114f, 0.03481761f, -0.02264095f, -0.01835571f, -0.01513178f, 0.00930640f, -0.03467271f, -0.03916077f, 
    0.03709289f, 0.01385077f, -0.03718579f, 0.03802466f, 0.02074988f, -0.03982228f, -0.04309314f, 0.02844469f, 
    -0.04390589f, 0.03571303f, 0.03223260f, 0.00729382f, 0.01345962f, 0.01008302f, -0.00846848f, -0.02232553f, 
    0.00569769f, 0.01130568f, 0.00989293f, 0.02208889f, 0.01058066f, -0.00615973f, -0.01111546f, -0.00808220f, 
    -0.01388766f, -0.01644559f, -0.01133657f, 0.03508181f, -0.04727336f, -0.00971938f, 0.03047843f, -0.04671695f, 
    -0.01408025f, -0.04154569f, -0.02499356f, 0.00002469f, 0.03724527f, -0.00491883f, -0.00954598f, -0.03875855f, 
    0.02903254f, -0.04705856f, -0.03404311f, -0.01769942f, 0.03495272f, -0.00912650f, -0.04671342f, -0.04664958f, 
    -0.03495853f, 0.02977917f, 0.02830040f, 0.04610904f, -0.02773699f, -0.00000257f, -0.00591452f, 0.00727201f, 
    -0.00122459f, -0.01800437f, 0.02137650f, 0.04214492f, -0.01631474f, -0.04399119f, 0.03537562f, 0.02227200f, 
    -0.05585862f, -0.01714441f, 0.04224415f, -0.01139975f, -0.03155297f, -0.01139054f, -0.05038202f, 0.03617996f, 
    0.02868115f, -0.03970677f, 0.02813719f, 0.04001836f, -0.01039053f, -0.03906880f, -0.03273195f, 0.03215135f, 
    0.02219187f, -0.01791339f, -0.02527741f, 0.04243758f, -0.02004123f, -0.05735650f, 0.02570804f, 0.03132207f, 
    0.00672985f, 0.00976491f, -0.02314163f, -0.01798121f, -0.02633128f, -0.03119255f, 0.03410059f, 0.02534462f, 
    0.02596440f, 0.04290524f, 0.00974076f, 0.03392707f, -0.03799274f, 0.03018306f, -0.01930504f, -0.03484594f, 
    0.03306299f, -0.01581147f, 0.03627973f, -0.01491370f, -0.04685082f, 0.02194204f, -0.00113028f, -0.02020856f, 
    0.03209731f, -0.04670380f, -0.05522708f, -0.00208402f, 0.03445701f, -0.02360646f, -0.02567859f, -0.04649052f, 
    -0.03768499f, -0.01027527f, -0.00217019f, -0.03805695f, -0.01430983f, -0.03349333f, 0.03891773f, 0.03108573f, 
    -0.00219497f, 0.02876800f, -0.05080873f, 0.03797415f, 0.00889841f, -0.01263894f, 0.03971126f, 0.02510623f, 
    -0.04838011f, 0.02536697f, -0.02357681f, 0.04082779f, -0.03123606f, -0.02432286f, 0.00027325f, -0.01011120f, 
    0.03561719f, -0.00872649f, -0.03691534f, -0.03587403f, -0.00346827f, 0.01948075f, -0.00719130f, 0.02900347f, 
    -0.02723517f, -0.01045663f, -0.03551500f, 0.03227682f, 0.02397251f, -0.04871915f, -0.00983434f, -0.00674460f, 
    -0.00135053f, 0.00288341f, -0.01986605f, 0.04436456f, -0.04321048f, 0.03465583f, -0.03430907f, -0.00250384f, 
    -0.03551041f, -0.04250080f, 0.01144199f, -0.04797674f, 0.04150854f, -0.03853904f, -0.03139386f, 0.03244330f, 
    0.04045789f, -0.00829524f, -0.02601132f, -0.00545277f, 0.02110602f, -0.01993843f, -0.04941744f, 0.02660465f, 
    -0.05328381f, 0.00267369f, -0.02046002f, -0.03093766f, -0.03330134f, -0.01397841f, 0.04437697f, 0.02673488f, 
    0.04994441f, 0.02213077f, 0.04175229f, 0.02093323f, -0.00459568f, 0.04918644f, 0.01832129f, -0.01322699f, 
    0.03231451f, -0.03945335f, -0.02721572f, -0.03150278f, 0.02313123f, 0.02324001f, -0.02262085f, -0.04298008f, 
    0.04972320f, -0.04011158f, -0.00792873f, -0.04615772f, -0.00219821f, -0.00164496f, 0.01814792f, -0.01957200f, 
    -0.03370084f, 0.00292099f, 0.03498722f, -0.05618268f, -0.05259977f, -0.02109376f, 0.02113493f, -0.01264952f, 
    -0.01796682f, 0.05085489f, 0.01010760f, 0.04458803f, -0.00287642f, -0.02240537f, -0.03319788f, 0.00835977f, 
    -0.02624834f, 0.00849779f, -0.01547887f, -0.01434804f, -0.02015530f, -0.03013461f, 0.00005920f, -0.01179613f, 
    -0.00985937f, 0.03014946f, -0.00747850f, -0.02975980f, 0.00837397f, 0.00930172f, 0.03359419f, 0.02287360f, 
    -0.05396089f, 0.00585120f, 0.00953569f, -0.05557394f, -0.04874508f, -0.01776553f, -0.04801935f, -0.03711772f, 
    -0.03969784f, 0.02015114f, -0.05250444f, -0.03581790f, 0.01157128f, 0.00747506f, 0.01198331f, 0.02496053f, 
    0.04218810f, -0.03760001f, 0.01479549f, -0.04917048f, -0.01332293f, -0.04881044f, -0.04629312f, -0.00730391f, 
    -0.03397650f, -0.04580040f, -0.01046424f, -0.02579750f, -0.01588780f, -0.01784404f, -0.04907610f, -0.00143591f, 
    0.00934221f, 0.02223137f, 0.00248592f, 0.03379829f, 0.03695536f, -0.05472727f, 0.02217040f, 0.00474870f, 
    0.02396217f, 0.02240724f, -0.03461393f, 0.00938972f, -0.01721663f, -0.04485159f, -0.00412446f, 0.03563557f, 
    0.02526472f, 0.04984662f, -0.03726770f, -0.03175756f, -0.00776941f, -0.03832654f, -0.03140198f, -0.00899233f, 
    -0.03585966f, -0.00171114f, -0.03374758f, 0.00167957f, -0.04532777f, -0.04999172f, -0.03877413f, 0.03453255f, 
    -0.02798143f, -0.02022574f, 0.02296299f, -0.04803300f, -0.01539876f, 0.03572117f, -0.04920073f, -0.03776841f, 
    0.00193409f, 0.00270496f, 0.01727069f, -0.03826675f, 0.01346734f, -0.00245670f, -0.02636018f, -0.01871653f, 
    0.00137629f, 0.00959572f, 0.03105284f, -0.01723582f, 0.01013298f, -0.05204181f, -0.01053482f, -0.02007079f, 
    0.03899224f, -0.00777233f, -0.02735548f, 0.00458500f, 0.00526104f, -0.02688124f, -0.04456063f, -0.05147922f, 
    -0.03742251f, -0.00182746f, 0.01464982f, 0.00003387f, -0.03821443f, -0.01939512f, 0.00365000f, -0.01603553f, 
    0.01303973f, -0.00144654f, -0.03326736f, -0.00764244f, 0.02777436f, 0.01826338f, 0.03822262f, -0.05595452f, 
    0.03228228f, -0.01334050f, -0.00980612f, 0.00052451f, 0.03635831f, -0.01596731f, 0.03557308f, -0.03425469f, 
    0.04039599f, 0.00191453f, -0.04416223f, 0.00194390f, -0.02333103f, 0.04118390f, 0.00498888f, 0.02487518f, 
    -0.02218537f, -0.01986168f, -0.00416047f, 0.01515516f, -0.00206035f, -0.01743045f, -0.04418174f, 0.01599656f, 
    0.00195222f, -0.04284254f, 0.03349206f, 0.04377604f, 0.03737895f, -0.01901337f, 0.01072647f, -0.00938333f, 
    -0.01016677f, -0.03054448f, -0.02264582f, -0.05175613f, 0.04175973f, -0.03522791f, 0.04042557f, -0.03954966f, 
    0.03263862f, -0.05131094f, 0.03997174f, 0.03908243f, 0.02580190f, -0.02190850f, -0.05615609f, -0.04752335f, 
    -0.00288019f, 0.02783743f, -0.04745132f, -0.03472456f, 0.00668466f, 0.01572846f, -0.01039709f, -0.00651891f, 
    0.04375850f, -0.05546089f, -0.04667505f, 0.01080605f, -0.00806250f, 0.02391787f, 0.04377970f, -0.04285912f, 
    -0.05007672f, -0.05014552f, 0.00408516f, -0.05379790f, -0.04972396f, 0.00922832f, 0.03281045f, 0.00312720f, 
    -0.04164926f, -0.04854342f, -0.01903236f, -0.02195973f, -0.03045792f, -0.04439045f, -0.04782604f, -0.02686256f, 
    0.01472104f, 0.03096344f, -0.02483381f, 0.02368571f, -0.04157984f, 0.00724159f, -0.01993459f, -0.04311147f, 
    0.04897819f, 0.00394759f, -0.00785198f, -0.00317628f, 0.00018547f, 0.02096935f, 0.00130401f, 0.01018165f, 
    0.02755629f, 0.01762708f, 0.01744869f, -0.00136599f, 0.03928460f, -0.01735581f, -0.02073190f, 0.01201874f, 
    -0.04364200f, 0.01695944f, -0.00915585f, 0.01869532f, -0.03186856f, -0.03485119f, -0.02711607f, 0.01594999f, 
    -0.04144900f, -0.00781097f, 0.03807451f, 0.02399014f, -0.04502769f, -0.04166998f, -0.03872766f, 0.02982317f, 
    0.03662870f, -0.03579228f, -0.02651975f, 0.03481722f, 0.03045988f, -0.00613199f, -0.03855777f, 0.00881578f, 
    0.00851691f, 0.01618396f, 0.03499644f, -0.01751369f, 0.03262140f, 0.03505022f, 0.01506095f, 0.03545793f, 
    -0.01786313f, 0.03844024f, 0.02547449f, -0.02367707f, -0.04134439f, -0.00983199f, 0.03148144f, -0.00907167f, 
    -0.01266883f, 0.01906942f, -0.03690022f, -0.01310766f, 0.00883103f, -0.00749222f, -0.04097505f, 0.01911412f, 
    -0.04584102f, -0.00609484f, 0.00396986f, -0.04945789f, 0.04670274f, -0.01499050f, -0.01257388f, 0.00382667f, 
    -0.03893152f, -0.04035337f, -0.04285016f, -0.03670312f, -0.01832547f, 0.01543841f, 0.01321801f, -0.05157253f, 
    -0.20109759f, 0.01021063f, -0.17280908f, 0.24432229f, -0.02641873f, 0.08419643f, 0.00193038f, -0.00287322f, 
    -0.10741689f, 0.04856021f, 0.12999068f, 0.00247644f, 0.26829717f, -0.06644180f, -0.13572949f, -0.11246980f, 
    0.01520445f, 0.04943307f, -0.04350358f, -0.02728755f, -0.07335566f, 0.02484825f, -0.03580438f, 0.15346466f, 
    -0.05440676f, 0.16208313f, -0.01503570f, -0.01454121f, 0.07926107f, -0.02448284f, 0.32794666f, 0.02097276f, 
    0.00682021f, 0.05410548f, 0.08417097f, 0.06766250f, 0.07701457f, 0.23003830f, 0.59674597f, -0.22494575f, 
    -0.00519996f, -0.02671859f, 0.00020176f, 0.04649099f, 0.04706432f, 0.02628186f, 0.08551380f, 0.10278604f, 
    0.00108222f, -0.25714850f, 0.10876817f, 0.10382175f, 0.04016934f, -0.00551724f, -0.00046592f, -0.01194424f, 
    0.01888550f, 0.02324060f, 0.03236393f, 0.00430518f, -0.27339691f, -0.17770259f, -0.26404333f, 0.02204776f, 
    -0.17551187f, -0.13802743f, -0.09854587f, 0.06333994f, -0.11573144f, 0.01593141f, -0.02508189f, 0.03007476f, 
    0.22502857f, -0.07947741f, 0.11741059f, 0.14042556f, 0.02266189f, -0.06241446f, 0.01081584f, -0.00610025f, 
    0.09647545f, 0.14369769f, -0.06522431f, 0.04172882f, -0.03461516f, -0.00872271f, 0.01200453f, -0.01504593f, 
    -0.04556517f, 0.01958150f, -0.06579935f, -0.02882432f, -0.08053799f, 0.07583192f, -0.09479345f, 0.11636904f, 
    -0.07683755f, -0.36555085f, -0.14956866f, 0.12749746f, -0.20155577f, -0.12473586f, -0.08545970f, -0.00511096f, 
    -0.10649112f, 0.00620663f, -0.00873604f, 0.01193995f, 0.07797882f, 0.23052995f, 0.11734104f, 0.01404878f, 
    0.02331945f, -0.08363838f, -0.03744777f, 0.02447259f, 0.07151491f, 0.24521707f, 0.07863305f, 0.28647497f, 
    -0.01826189f, 0.05996536f, 0.12725040f, 0.18031004f, 0.05457191f, 0.07957860f, -0.04834845f, 0.00855207f, 
    0.03787019f, -0.01998784f, -0.00977552f, 0.01501094f, -0.02328216f, 0.12922838f, 0.17204432f, -0.14972511f, 
    0.03596747f, -0.01249543f, 0.04906857f, 0.06509817f, 0.01476157f, 0.01333762f, 0.03272855f, -0.00083771f, 
    0.20589104f, 0.09678441f, 0.37168202f, -0.01762068f, -0.07097639f, -0.05266671f, 0.12489349f, -0.01695679f, 
    -0.09203831f, -0.12380330f, 0.14737466f, 0.12719631f, 0.15761249f, 0.44332221f, -0.01616514f, 0.10461304f, 
    0.01694765f, -0.02098664f, 0.09370872f, 0.12601298f, 0.08018290f, 0.02675407f, -0.07654467f, 0.02842131f, 
    -0.23161291f, 0.03430535f, 0.14805467f, 0.08780822f, -0.00503174f, 0.14866421f, 0.04677645f, -0.12124362f, 
    0.12133172f, -0.03822877f, 0.05118979f, -0.11486197f, 0.21123683f, -0.02517410f, 0.07808053f, -0.21189858f, 
    -0.12165719f, 0.10633919f, 0.23023413f, -0.04954812f, 0.10113584f, 0.06631430f, -0.00254747f, -0.03631500f, 
    -0.03202159f, 0.12880014f, 0.18472332f, 0.06681262f, -0.08538088f, -0.02866120f, -0.07491259f, 0.01486392f, 
    -0.05062741f, -0.02722763f, -0.10094228f, -0.00944055f, 0.09902070f, -0.04632101f, 0.11415784f, -0.30000573f, 
    -0.03370472f, 0.01944096f, -0.03228464f, 0.05342667f, 0.08069332f, -0.01685973f, 0.07923003f, 0.10415860f, 
    -0.21609570f, -0.10631435f, -0.05686560f, -0.01646429f, -0.03882656f, -0.04240647f, 0.07832527f, 0.03994600f, 
    -0.06520354f, 0.01304205f, -0.08297153f, -0.03422761f, 0.03322912f, -0.00408638f, -0.03201584f, -0.01991012f, 
    -0.00586973f, -0.02085409f, -0.02599713f, 0.00752975f, 0.12448819f, 0.13907439f, 0.08857435f, 0.12051716f, 
    -0.39677307f, -0.34933588f, -0.15935129f, 0.15457019f, 0.01636304f, 0.09485632f, -0.03466860f, 0.01852985f, 
    0.05926974f, -0.02336175f, -0.02675551f, 0.05386395f, -0.14345032f, 0.04006835f, 0.03826563f, -0.17688669f, 
    0.22231066f, -0.07039209f, 0.20185451f, 0.16911805f, -0.07057511f, -0.00658828f, 0.00171439f, 0.14901260f, 
    -0.02991774f, 0.08124105f, 0.20566075f, 0.18717249f, 0.11848629f, 0.03429288f, 0.06202363f, -0.04838458f, 
    0.09249353f, 0.01555790f, -0.04538732f, -0.11471795f, 0.13403882f, 0.17063205f, -0.03699680f, 0.04674334f, 
    0.07398386f, 0.18170522f, 0.13118562f, 0.03335271f, 0.10808598f, 0.16568218f, 0.23004901f, -0.14223780f, 
    -0.23626031f, -0.19228186f, -0.17969705f, -0.07756598f, -0.12522215f, 0.06311728f, 0.10557953f, -0.08750999f, 
    0.12768888f, 0.04062653f, -0.10769906f, 0.09895489f, -0.08660945f, -0.20793824f, -0.05458568f, 0.07703796f, 
    -0.11754080f, -0.04186281f, -0.07065699f, 0.01317433f, 0.03798711f, 0.00488477f, -0.04804268f, -0.08129562f, 
    -0.19265787f, 0.19998659f, -0.28032935f, 0.28057453f, 0.32383987f, 0.06085708f, -0.07832412f, 0.14388168f, 
    -0.03724302f, 0.15644692f, 0.09061168f, -0.06899718f, 0.35227585f, 0.03733189f, 0.43132284f, 0.24367182f, 
    -0.13572673f, -0.11223362f, -0.04350647f, -0.03727505f, 0.00964313f, 0.20977907f, 0.13428965f, 0.05080199f, 
    0.05951370f, 0.23678303f, 0.04803722f, 0.12026995f, -0.07537853f, -0.03639726f, -0.01030892f, -0.02374544f, 
    0.03226070f, -0.00106291f, 0.11287936f, 0.31486470f, 0.01673921f, -0.01991827f, 0.00941673f, -0.13551274f, 
    -0.07652981f, -0.00601149f, 0.01667269f, -0.01746479f, -0.10082023f, -0.04727583f, 0.02360390f, -0.05732561f, 
    0.40678236f, -0.29645410f, 0.31421843f, 0.01278725f, -0.01156775f, -0.08264137f, 0.45738494f, 0.24613285f, 
    -0.01564739f, -0.14208189f, 0.02503280f, 0.12253519f, -0.36105323f, -0.23076358f, -0.08467201f, -0.06681348f, 
    -0.13675545f, -0.03848985f, 0.01420423f, -0.02822585f, -0.01785574f, -0.02307124f, -0.05959414f, 0.04242746f, 
    -0.01645021f, 0.02862243f, 0.02513861f, -0.04862385f, -0.02760332f, -0.02618485f, -0.02986005f, -0.01799003f, 
    -0.00222241f, -0.01613987f, -0.02303991f, 0.03233304f, -0.04781841f, -0.03883333f, -0.04821814f, -0.01920139f, 
    0.00075282f, -0.04249831f, 0.02365246f, -0.03233712f, 0.00176515f, 0.00139319f, -0.00972466f, 0.00111390f, 
    0.00231810f, -0.05177194f, -0.02336170f, -0.03170754f, -0.03178792f, -0.00726306f, -0.05510912f, -0.01683742f, 
    -0.04239586f, -0.01108556f, 0.00106623f, 0.01807418f, -0.00778605f, -0.02872532f, -0.01756948f, 0.01175189f, 
    -0.00291727f, -0.02120883f, -0.02953387f, -0.00774277f, 0.00742085f, 0.01879935f, -0.03453916f, 0.01632643f, 
    0.01313328f, 0.02083160f, 0.03338374f, 0.02600050f, -0.03069763f, 0.01050720f, 0.00622947f, -0.01758477f, 
    0.02448861f, -0.02843335f, 0.00623947f, 0.00481877f, -0.04756437f, 0.01263351f, 0.01545416f, 0.03244881f, 
    0.03321715f, 0.01102087f, 0.00410238f, -0.03747575f, -0.02691801f, 0.01856655f, 0.00227273f, -0.01277477f, 
    0.01317243f, 0.04389630f, -0.04051422f, 0.01685699f, 0.02472118f, 0.03648323f, -0.02883188f, -0.01576325f, 
    -0.00090605f, -0.03556529f, -0.01034354f, -0.04617796f, -0.02256677f, 0.00890534f, -0.03419130f, 0.03084821f, 
    -0.00898971f, 0.02279767f, -0.04105170f, 0.04323252f, -0.01839937f, -0.02715096f, -0.03282276f, -0.04126189f, 
    -0.04237070f, -0.01106452f, -0.01289667f, -0.01875907f, -0.03340346f, -0.00540309f, -0.03273684f, -0.05403591f, 
    0.02183138f, -0.00394150f, -0.04015926f, -0.05607209f, -0.01284832f, 0.01906807f, 0.03792520f, -0.01504304f, 
    0.00648667f, -0.02289679f, -0.02581773f, 0.02428604f, -0.02801596f, 0.03677106f, -0.04996156f, -0.00679261f, 
    -0.02459641f, -0.01423425f, 0.01770184f, 0.04064727f, -0.01103359f, -0.00518223f, 0.03903251f, -0.00301046f, 
    -0.01262232f, -0.04613928f, -0.00726792f, -0.03369618f, -0.00327372f, 0.04104273f, 0.03491538f, 0.04421157f, 
    -0.05327083f, -0.03582545f, 0.02776477f, -0.04083654f, 0.02999850f, 0.02167017f, -0.00858114f, -0.01152511f, 
    -0.03573588f, -0.03802123f, -0.04045935f, -0.05346751f, 0.01746250f, 0.02944773f, -0.03310831f, 0.03774806f, 
    -0.02478939f, -0.05374048f, 0.03243854f, 0.03402801f, -0.04493717f, -0.00454293f, -0.04794351f, 0.00185849f, 
    -0.01293368f, 0.00377231f, -0.03156998f, -0.05673924f, -0.00355331f, -0.00580545f, -0.03488133f, -0.02230047f, 
    0.03279050f, -0.05686887f, 0.00606738f, -0.04148965f, -0.01156420f, -0.04140273f, 0.03361579f, -0.00606642f, 
    0.02149330f, -0.00089195f, -0.04926639f, 0.00931128f, -0.05690278f, 0.00724028f, -0.00158927f, 0.04011013f, 
    0.04263144f, 0.01939025f, -0.01137276f, -0.00238927f, -0.04659222f, -0.00013908f, 0.04369138f, -0.02347012f, 
    0.01245005f, 0.00863214f, 0.03857057f, 0.00119827f, -0.02919528f, -0.03678066f, 0.01519779f, -0.02838730f, 
    0.02581499f, -0.02666831f, -0.01535049f, 0.02468455f, 0.02371009f, 0.04004658f, -0.03547508f, -0.04687039f, 
    -0.01435624f, -0.01728671f, -0.03916173f, -0.04504115f, 0.00062328f, 0.01758126f, -0.03066614f, 0.02471613f, 
    0.02252507f, 0.03022053f, 0.02130998f, -0.00725670f, -0.05268580f, -0.01012968f, -0.01223804f, -0.01544070f, 
    -0.00459430f, -0.03508635f, -0.03706428f, -0.04544904f, 0.01415737f, -0.04951899f, -0.01311731f, -0.03252380f, 
    0.00534729f, -0.01540964f, 0.00416156f, -0.05032720f, 0.00918326f, 0.02436109f, -0.04038610f, 0.04374970f, 
    0.04285598f, 0.00116469f, -0.00165159f, 0.03180826f, -0.00285985f, 0.00466870f, -0.03096288f, -0.00472315f, 
    -0.02442810f, 0.00672584f, -0.02829633f, -0.02432372f, 0.02368913f, -0.04120873f, -0.04353036f, -0.05338483f, 
    -0.02143774f, -0.00574043f, 0.02163639f, -0.03793878f, 0.00757428f, 0.02621208f, 0.04120843f, 0.03502094f, 
    -0.01030546f, -0.01131254f, -0.02639909f, 0.03400297f, -0.04908204f, -0.03681775f, -0.01558684f, 0.03579482f, 
    -0.01270527f, -0.05106733f, -0.04708724f, 0.04234655f, 0.01396344f, -0.02889957f, -0.02916849f, -0.05526331f, 
    -0.02464210f, -0.04845732f, 0.00383410f, -0.05626763f, -0.04167703f, -0.05641775f, -0.02127864f, 0.03721031f, 
    -0.00066035f, 0.00833716f, -0.04725909f, -0.01777791f, -0.02616594f, 0.01713818f, 0.04433835f, -0.05479941f, 
    0.00368425f, -0.01841692f, -0.03934042f, 0.01188852f, 0.01990398f, 0.02346478f, -0.03412998f, -0.00673442f, 
    0.01575685f, -0.01099528f, 0.04055616f, -0.00831137f, -0.03029528f, -0.02423644f, -0.05298321f, -0.00162698f, 
    0.02018364f, 0.03805313f, -0.02586015f, 0.00768254f, 0.00468373f, -0.04927971f, -0.02955925f, -0.01313651f, 
    0.04181973f, -0.00621932f, 0.00940582f, 0.00395380f, -0.01038464f, -0.02086547f, 0.03435624f, -0.02651351f, 
    0.01587191f, -0.02403290f, -0.02003800f, -0.00837264f, -0.00919212f, 0.01225194f, 0.00222565f, 0.04208371f, 
    -0.04624857f, -0.00418873f, -0.00145623f, -0.00680138f, -0.04027334f, -0.04073424f, -0.04656768f, -0.00335383f, 
    -0.05240606f, -0.03015211f, -0.04994536f, 0.00217580f, -0.04590704f, -0.04490074f, -0.04466437f, 0.01210086f, 
    -0.00364828f, 0.00641101f, -0.02908461f, 0.03521698f, 0.04050150f, -0.03676957f, 0.03018556f, 0.03502053f, 
    0.00868441f, -0.03122877f, -0.03587464f, 0.03829103f, -0.02921779f, 0.02059441f, 0.01656166f, -0.01084615f, 
    -0.04263502f, -0.03355780f, -0.04299545f, -0.00103839f, 0.03554115f, 0.02579881f, 0.02110264f, 0.01975930f, 
    -0.02872179f, 0.01017531f, 0.01334263f, 0.02307797f, -0.04064609f, -0.01076302f, -0.02585757f, 0.00201161f, 
    0.00354638f, -0.02657903f, -0.03299225f, -0.00086589f, 0.03359139f, -0.00609038f, -0.04285003f, 0.00558869f, 
    -0.05290861f, 0.02354193f, -0.00222961f, -0.01654235f, 0.00245921f, 0.00522982f, -0.01420425f, -0.02667659f, 
    -0.04601471f, -0.04088810f, -0.01398296f, 0.02658553f, -0.04969669f, -0.06668131f, -0.00515588f, 0.00372089f, 
    -0.05048953f, -0.06537290f, 0.01049659f, -0.05177748f, 0.02179972f, -0.03352582f, 0.02082941f, -0.05348411f, 
    -0.05657372f, -0.02784709f, 0.01795675f, -0.03326380f, -0.06435286f, 0.02979549f, -0.05315626f, -0.05704316f, 
    0.00504848f, 0.01269519f, -0.05256033f, -0.04394907f, 0.00790631f, -0.00573161f, 0.00459207f, -0.04622111f, 
    -0.01142400f, -0.02333937f, 0.00434169f, 0.00549200f, -0.03955318f, -0.03797831f, -0.02525864f, -0.01374916f, 
    0.01301472f, -0.05202758f, -0.00241315f, -0.00852751f, 0.03457361f, -0.03739077f, -0.00555645f, 0.02808725f, 
    0.00380912f, 0.01519510f, 0.02586327f, 0.01489384f, 0.01131139f, -0.01932546f, 0.00368687f, -0.00633756f, 
    -0.01820493f, 0.00212882f, -0.03386669f, -0.05910793f, -0.00016398f, -0.05306084f, -0.02172976f, -0.03287072f, 
    -0.05222613f, -0.04626489f, -0.03150317f, 0.01114721f, -0.00540788f, -0.03101726f, -0.00278341f, 0.00644679f, 
    -0.06791995f, 0.03247434f, -0.04364654f, 0.00198045f, 0.00237835f, -0.03055464f, -0.01494990f, -0.06672316f, 
    0.00581255f, 0.02120599f, 0.02819705f, 0.00799140f, 0.02711452f, -0.03321313f, -0.00955807f, 0.02782013f, 
    0.01162354f, -0.01431446f, -0.03193523f, 0.00328850f, -0.04272271f, -0.01305694f, -0.06332521f, -0.03437858f, 
    0.01168392f, -0.02368242f, -0.02553461f, -0.04582452f, -0.02491001f, -0.01900873f, 0.02637040f, -0.00562230f, 
    -0.04733209f, -0.03972149f, -0.05026342f, -0.01881426f, -0.01077788f, -0.01936637f, -0.01376247f, -0.01585023f, 
    0.00816309f, -0.01118495f, -0.04121107f, 0.03054909f, -0.03290939f, -0.04401616f, 0.00203923f, -0.01145058f, 
    0.01875005f, -0.01476722f, -0.05274665f, 0.00802574f, -0.00466423f, 0.00321064f, -0.05133357f, -0.04246928f, 
    -0.06697594f, -0.01493023f, -0.04860539f, -0.05858947f, -0.00784751f, -0.02240167f, 0.01663769f, -0.02367643f, 
    -0.06101216f, 0.00583795f, 0.02357659f, -0.05533464f, -0.04593604f, -0.06467073f, -0.01530700f, 0.03594009f, 
    -0.01776414f, -0.02154315f, 0.02489039f, 0.00183762f, 0.02514791f, -0.02066684f, -0.03833105f, -0.04956066f, 
    -0.03714737f, -0.01524298f, -0.01945091f, 0.04045029f, -0.00116091f, -0.00784556f, -0.05584503f, -0.00868213f, 
    0.00085367f, -0.00401134f, -0.02620791f, -0.03191521f, -0.02423023f, -0.06501048f, -0.02001803f, -0.02765533f, 
    -0.02057583f, -0.02120727f, -0.03098446f, -0.02215065f, -0.05917030f, -0.00518668f, 0.02405001f, -0.02856624f, 
    0.00089845f, -0.00910326f, -0.01190759f, 0.00323777f, 0.01777735f, -0.06149499f, 0.00382463f, -0.05184522f, 
    -0.02688378f, -0.06815282f, -0.05428718f, -0.04719105f, 0.01354418f, -0.04237504f, -0.04313327f, -0.02059638f, 
    -0.03534737f, 0.02916459f, -0.04416765f, 0.01638716f, -0.02647068f, -0.02475941f, 0.02370159f, -0.05249563f, 
    -0.01306884f, -0.04507402f, -0.04437423f, -0.00956051f, -0.06273120f, 0.01764767f, -0.03095540f, -0.00070936f, 
    -0.01221259f, -0.02885775f, 0.01741733f, 0.03654420f, -0.03271832f, 0.01771426f, 0.02295041f, 0.01701852f, 
    -0.05070506f, 0.01983682f, -0.03328424f, -0.00534670f, -0.02027166f, -0.05244539f, -0.04998935f, -0.03340502f, 
    -0.04903606f, -0.04085302f, 0.03379119f, -0.02245169f, -0.01210966f, 0.01002015f, -0.04953209f, -0.04024370f, 
    -0.04972603f, -0.03129000f, -0.06372259f, -0.02162518f, -0.06771931f, -0.05606780f, -0.04390341f, -0.03964464f, 
    -0.03715451f, -0.01505836f, 0.00371827f, -0.05855832f, -0.02560639f, 0.03159267f, -0.04971659f, -0.02032809f, 
    -0.00088755f, -0.03306751f, -0.04933251f, 0.00522492f, 0.02281185f, 0.02463415f, -0.01253777f, -0.00306805f, 
    -0.04616507f, -0.03233396f, -0.03758509f, -0.00988237f, -0.04435779f, -0.01892426f, 0.00555559f, -0.00070150f, 
    -0.03860614f, -0.06760582f, 0.00219222f, 0.00255808f, -0.03703780f, 0.01167340f, 0.02504480f, -0.04817043f, 
    -0.00039826f, -0.02049254f, 0.03622492f, 0.00849656f, 0.03098286f, -0.03459840f, -0.00386157f, -0.00118295f, 
    -0.04031984f, -0.04536353f, 0.01155287f, 0.01568704f, -0.01359689f, -0.03824674f, -0.03662708f, 0.00191337f, 
    0.01210538f, -0.05049984f, -0.02792484f, 0.00339122f, 0.03161934f, -0.00874955f, -0.05659127f, -0.00769871f, 
    -0.05715697f, 0.01521809f, -0.00811752f, 0.01094784f, -0.01394283f, 0.02025093f, -0.05253387f, -0.00317222f, 
    -0.01926032f, -0.03881957f, -0.02056774f, -0.03474312f, -0.04011409f, 0.01175234f, -0.01094511f, 0.01659179f, 
    0.02369424f, 0.01780653f, 0.02389190f, -0.04005979f, -0.00206781f, -0.06658465f, 0.01029423f, -0.03571574f, 
    -0.02027164f, -0.01623999f, -0.03280878f, 0.00848977f, 0.01199758f, 0.01498097f, 0.00629272f, 0.00484665f, 
    -0.06423202f, -0.03216449f, 0.01154360f, 0.00529049f, 0.01183337f, -0.02606843f, 0.01341221f, -0.04456913f, 
    -0.04834863f, 0.00289490f, -0.06352036f, -0.06475725f, -0.01274173f, -0.01933042f, -0.04935696f, 0.02575493f, 
    -0.06106926f, 0.01431325f, -0.01535378f, -0.01104949f, -0.05085032f, -0.03451643f, -0.00519461f, -0.06799353f, 
    -0.01283654f, 0.01525668f, 0.02432674f, -0.02604255f, -0.03393261f, -0.04823356f, -0.01958796f, -0.04770423f, 
    0.01164325f, -0.01975794f, -0.02765687f, -0.03572125f, 0.00304646f, 0.04421967f, -0.02405982f, -0.04761951f, 
    -0.14318991f, 0.03319571f, 0.21358001f, -0.06651579f, 0.11996519f, -0.10142734f, 0.06812643f, 0.09076318f, 
    0.15523571f, -0.03850782f, 0.05569306f, 0.03908382f, -0.32581952f, 0.02820611f, 0.07718803f, -0.01094538f, 
    -0.01868599f, -0.01535256f, -0.04934041f, 0.05822081f, 0.19449145f, -0.08206657f, -0.16105796f, -0.36432949f, 
    -0.12450996f, 0.03151608f, 0.02597688f, 0.01397160f, 0.12302912f, 0.05219875f, -0.00592699f, -0.02392557f, 
    0.04101242f, -0.00206543f, -0.00557160f, 0.05213496f, 0.37737337f, -0.09778559f, -0.07075968f, 0.22575141f, 
    -0.10343362f, -0.03409308f, 0.04133764f, 0.04405915f, -0.00788233f, -0.07086297f, -0.04964826f, 0.09687620f, 
    0.32509464f, -0.00955824f, 0.09310871f, -0.05228459f, 0.01874776f, 0.09443031f, 0.03462144f, 0.18061773f, 
    0.11522410f, -0.06498215f, 0.02253146f, -0.13484921f, 0.08094315f, 0.27724332f, 0.11589521f, -0.07157910f, 
    0.16496272f, 0.10550219f, 0.04946519f, 0.07271228f, -0.00175978f, -0.09175300f, 0.02710265f, -0.01157162f, 
    -0.28304240f, 0.14526924f, 0.08352242f, 0.08184922f, -0.10041355f, 0.01972958f, -0.02351199f, 0.02504492f, 
    0.01455077f, -0.05795069f, 0.09438180f, 0.07915105f, 0.15068987f, 0.02401977f, -0.01461118f, 0.09828781f, 
    -0.10752115f, -0.04557962f, -0.02799016f, 0.00065662f, 0.07538664f, 0.05539956f, 0.07393888f, 0.03443119f, 
    -0.13121188f, 0.06813999f, -0.02848596f, -0.03585226f, -0.16230692f, 0.05618346f, 0.17152981f, -0.02638416f, 
    -0.01364186f, -0.00541350f, -0.00262095f, 0.05341225f, 0.24440220f, -0.17682761f, -0.00795429f, -0.09768089f, 
    -0.03181228f, 0.02356206f, 0.02170813f, 0.08239429f, -0.13856764f, -0.34006575f, -0.11077128f, -0.24670035f, 
    0.15908125f, -0.18602617f, -0.00333350f, -0.03082899f, -0.06921596f, 0.02561696f, 0.02225012f, 0.06974959f, 
    0.00298029f, 0.05703098f, -0.04536866f, -0.02476454f, 0.13615759f, -0.04765447f, -0.11822513f, 0.17899387f, 
    -0.02199390f, -0.01708114f, 0.05788170f, 0.00659113f, -0.04477227f, -0.05346636f, -0.02779535f, 0.02101596f, 
    -0.07069571f, -0.12194278f, -0.14456432f, -0.15330532f, -0.10085455f, -0.04564146f, -0.00775236f, 0.01969655f, 
    0.13311292f, 0.06428207f, -0.01490075f, -0.00850479f, -0.40877056f, 0.01000271f, 0.09405981f, -0.12264273f, 
    -0.05981508f, -0.06222180f, 0.14554144f, -0.04985793f, -0.10220823f, -0.01396277f, 0.05935915f, -0.01182963f, 
    0.08457917f, 0.06076720f, -0.04164859f, -0.08376484f, 0.10223759f, 0.08139195f, -0.00170191f, 0.13905822f, 
    -0.03119624f, 0.11763125f, -0.01969871f, 0.10366893f, -0.16057605f, 0.09547955f, 0.03937818f, 0.10326989f, 
    0.09513064f, 0.10530479f, 0.03206173f, -0.02829295f, -0.05933414f, -0.11923629f, 0.10317904f, 0.02388846f, 
    0.12875439f, -0.06383950f, -0.17989805f, -0.15168850f, -0.04167810f, -0.00141133f, 0.05560342f, 0.00188203f, 
    -0.01526386f, -0.08286361f, 0.01723960f, -0.17051925f, 0.07085107f, 0.01982588f, -0.17192379f, 0.06318746f, 
    -0.03779825f, -0.05129970f, 0.06819774f, -0.05006124f, -0.16706081f, 0.03066621f, -0.01826164f, -0.01828725f, 
    0.37049469f, 0.21610829f, 0.05722016f, 0.01144600f, 0.06248032f, 0.09089831f, 0.15696876f, 0.17257179f, 
    -0.06449459f, 0.06232227f, 0.01133543f, 0.09405872f, -0.06528627f, 0.01921394f, 0.03133419f, 0.14324804f, 
    -0.11869051f, -0.10091592f, 0.00370035f, -0.05750357f, 0.09890033f, 0.02460865f, -0.09788319f, -0.02262381f, 
    0.08930466f, 0.31698084f, 0.03831566f, -0.02739521f, 0.00747605f, -0.09158535f, -0.03228066f, -0.04385834f, 
    -0.00818428f, -0.07682686f, 0.02309338f, 0.03340518f, 0.16025266f, 0.00435613f, -0.01007405f, -0.05295537f, 
    0.00515602f, 0.07777912f, -0.01724194f, -0.08134577f, -0.08136598f, 0.01566805f, -0.06381095f, -0.16087918f, 
    0.18084791f, 0.15472583f, -0.03804250f, -0.26673892f, -0.02710718f, -0.00644575f, 0.08130684f, 0.16274075f, 
    -0.11817425f, -0.02274110f, -0.19575289f, -0.07874190f, 0.12495402f, -0.11787798f, 0.12295958f, -0.11048216f, 
    -0.07965303f, -0.05757675f, 0.07190693f, 0.12010989f, 0.18160838f, 0.08496459f, -0.00560823f, -0.06213437f, 
    0.23838352f, 0.17038232f, 0.15832937f, -0.08635867f, 0.03038295f, 0.00903748f, 0.07980080f, 0.11299665f, 
    -0.16631714f, -0.09701729f, -0.04067516f, -0.15116562f, 0.21998881f, 0.36966425f, 0.25216314f, 0.07073411f, 
    0.21403918f, 0.10471216f, 0.05528863f, 0.14333373f, 0.06057548f, -0.02049926f, -0.01485587f, -0.02201453f, 
    -0.28871530f, 0.18075188f, 0.09040423f, 0.04151433f, 0.04125321f, 0.11706025f, 0.17661487f, -0.07163308f, 
    0.03255126f, -0.06528936f, 0.02184319f, 0.06513251f, 0.01917356f, 0.16622081f, -0.25689170f, -0.25303721f, 
    -0.00158060f, 0.02354855f, -0.12948488f, 0.12399809f, 0.02183067f, -0.06698906f, -0.01316256f, -0.25715491f, 
    0.24264784f, -0.03829611f, 0.00690929f, 0.07138274f, 0.03350825f, -0.09007765f, 0.02091693f, 0.01891966f, 
    -0.03085974f, 0.12516120f, 0.06953317f, -0.11945700f, 0.04035397f, 0.01987049f, 0.06536998f, 0.09119304f, 
    0.06991223f, 0.01417469f, -0.03054426f, -0.01321090f, -0.06164008f, 0.06565561f, -0.07965817f, 0.01857777f, 
    -0.40943077f, 0.14070289f, 0.13013761f, -0.09596487f, -0.07501749f, -0.02609017f, 0.14276531f, 0.09729578f, 
    0.14175020f, 0.11809802f, -0.01153263f, 0.08759660f, 0.07136429f, 0.20271523f, 0.02912102f, -0.09829976f, 
    0.01384747f, -0.04036805f, 0.05647352f, 0.21484780f, -0.02975643f, -0.00108203f, -0.00917588f, 0.06876722f, 
    -0.03449352f, 0.01530979f, -0.02630060f, -0.03014960f, -0.04833304f, 0.00437980f, 0.01721982f, -0.05191096f, 
    0.02783771f, 0.00266241f, -0.03967767f, -0.02272183f, 0.01336397f, -0.01056240f, -0.02947192f, 0.01169772f, 
    -0.00941532f, -0.03843207f, 0.01359561f, -0.04404910f, -0.01714619f, 0.00354521f, 0.03083158f, -0.03910987f, 
    0.00924163f, 0.04482739f, 0.03998376f, 0.02432371f, -0.02753511f, -0.04617508f, -0.03402711f, -0.03220623f, 
    -0.02179427f, 0.00148001f, 0.02845048f, -0.04228229f, -0.05322521f, -0.01660222f, 0.03572134f, -0.04024106f, 
    -0.01967945f, -0.04847870f, 0.01706787f, -0.01258975f, 0.00463029f, 0.02527733f, -0.02224357f, 0.02406162f, 
    -0.03760581f, -0.00397898f, -0.01652618f, -0.04683045f, -0.00755512f, 0.01798372f, -0.03225613f, 0.01240803f, 
    -0.02067595f, 0.03581196f, -0.04502011f, 0.00065071f, -0.02154171f, -0.04314649f, 0.01242278f, -0.00486195f, 
    0.00224149f, 0.02693578f, -0.03341867f, -0.03957379f, -0.03134281f, 0.03093396f, 0.04277889f, 0.01317221f, 
    0.02053699f, -0.04994044f, 0.00603875f, 0.01114284f, -0.04706244f, 0.03974675f, -0.00554656f, -0.05695822f, 
    -0.02219421f, 0.00063906f, -0.05109936f, -0.02898201f, -0.01826485f, 0.01077673f, 0.03172885f, 0.00056891f, 
    0.04139293f, 0.00526113f, -0.02239482f, 0.01544925f, 0.03297338f, -0.02298406f, 0.02681380f, -0.01841854f, 
    0.02330918f, 0.00570736f, 0.04402703f, -0.04599416f, -0.05204403f, -0.02527577f, 0.01518390f, -0.04396335f, 
    0.02036101f, -0.05375688f, -0.01106629f, 0.03501885f, 0.02891245f, 0.01397396f, -0.03847384f, -0.03951709f, 
    -0.02757028f, -0.02846676f, 0.02205455f, 0.02399594f, -0.04937423f, -0.04590968f, 0.01258342f, 0.03192236f, 
    0.01924048f, -0.03697691f, 0.02207647f, 0.03485174f, -0.05167281f, 0.03633406f, -0.05574584f, 0.00583755f, 
    -0.04023193f, 0.00602100f, -0.00464564f, -0.04184832f, 0.03811475f, -0.00030131f, -0.02165154f, -0.01658257f, 
    0.01271326f, 0.01185308f, -0.05597420f, 0.00525232f, 0.00406289f, -0.00891807f, 0.01016413f, 0.02055193f, 
    0.00549199f, -0.04431963f, -0.02396566f, 0.04302736f, 0.02125509f, -0.01046847f, 0.00986718f, -0.00564208f, 
    0.04030942f, -0.04448980f, -0.01842277f, -0.00466597f, -0.02021082f, -0.04340315f, 0.02583151f, 0.02154074f, 
    0.03817714f, -0.01016879f, -0.01188769f, -0.00869526f, -0.05485993f, -0.02745654f, 0.00296637f, -0.01607131f, 
    0.02152981f, 0.02996782f, 0.01632637f, 0.00732613f, 0.00202034f, 0.00449982f, 0.01063514f, -0.03092044f, 
    0.02064934f, -0.02365213f, -0.01862003f, -0.05428910f, -0.02249137f, 0.03291092f, 0.01903665f, -0.00709601f, 
    0.00542260f, -0.02719801f, 0.03098303f, -0.00044016f, 0.02889803f, -0.04669921f, -0.04955003f, -0.00543431f, 
    0.03731673f, 0.02827724f, -0.03617599f, -0.01255642f, -0.05658729f, -0.04509278f, 0.01269971f, -0.03384664f, 
    0.02633513f, 0.01890494f, -0.04779642f, -0.03968815f, -0.05343056f, 0.02538933f, 0.01537805f, 0.04284311f, 
    -0.01861258f, -0.03575807f, -0.05462547f, -0.03631059f, -0.00421832f, -0.02454135f, 0.00224311f, 0.04476454f, 
    0.01918679f, 0.04010453f, 0.03813922f, 0.03454926f, -0.00098240f, -0.00025522f, 0.00357403f, -0.04073749f, 
    -0.05581930f, -0.05337566f, -0.03640602f, -0.01456567f, -0.03253745f, -0.02922618f, -0.05385948f, -0.01164107f, 
    -0.02540831f, 0.01459091f, 0.02735266f, 0.01768702f, -0.02561679f, -0.01245424f, -0.03537722f, -0.02789768f, 
    -0.00099047f, 0.01787312f, 0.03831786f, -0.03364516f, -0.02633063f, -0.01023922f, 0.04038686f, 0.01179992f, 
    -0.05169254f, 0.00879917f, -0.01569303f, -0.02065385f, 0.01511502f, 0.04228770f, -0.05260832f, -0.03448876f, 
    -0.00300269f, 0.02651426f, -0.04880037f, 0.03751267f, -0.03657638f, -0.00225827f, -0.04956086f, -0.00036319f, 
    0.01052213f, -0.00218547f, -0.00528846f, -0.05135049f, 0.01069489f, -0.02943829f, -0.04871685f, -0.01028317f, 
    -0.02880771f, -0.00101762f, 0.03726183f, 0.02171961f, -0.03707011f, -0.00610273f, 0.02060318f, 0.00472788f, 
    0.01343011f, -0.04060500f, 0.01418253f, 0.00479965f, 0.04491545f, -0.02085892f, -0.00755633f, 0.00460635f, 
    0.03803593f, 0.01143507f, -0.05586024f, 0.00537105f, -0.04686428f, -0.01455885f, 0.00966439f, 0.03671783f, 
    -0.00221883f, 0.01982056f, -0.01578115f, 0.04026932f, -0.05669476f, 0.04261909f, -0.02510798f, 0.02323137f, 
    -0.03494811f, -0.01350257f, -0.03578123f, -0.00238276f, 0.03325319f, 0.00659796f, 0.03203708f, -0.00604095f, 
    -0.02602433f, -0.05189602f, 0.04181618f, -0.04069556f, -0.00413860f, 0.00822510f, -0.02889154f, -0.05408499f, 
    0.03445030f, -0.02646608f, -0.04176643f, -0.03628099f, -0.01107591f, 0.00967565f, 0.01677697f, -0.02993402f, 
    -0.04972950f, 0.02206916f, 0.01401455f, 0.03720075f, 0.04362068f, -0.01671434f, -0.00208262f, -0.00466545f, 
    0.01423489f, 0.04224489f, -0.00364810f, 0.00147293f, -0.04913229f, 0.03791678f, 0.01632858f, -0.05376066f, 
    -0.04931852f, 0.01596062f, 0.02306418f, -0.03861882f, -0.03839358f, -0.04786425f, -0.01336255f, -0.00291401f, 
    -0.05538305f, 0.04244345f, 0.00756884f, 0.01292510f, -0.04558540f, -0.04627757f, -0.02819201f, 0.02309792f, 
    -0.04618368f, -0.04532261f, -0.02617096f, -0.03386388f, -0.04717261f, -0.01023921f, 0.03399287f, 0.01746645f, 
    -0.02250632f, 0.04373200f, 0.03275309f, 0.02296045f, -0.05354718f, 0.02268595f, -0.04256692f, 0.04275733f, 
    -0.05543350f, -0.04087153f, -0.05415026f, -0.02336627f, -0.05287413f, 0.01701248f, 0.01891170f, -0.05296255f, 
    0.01578167f, 0.46323082f, 0.03211542f, -0.25469410f, -0.11368910f, 0.05185558f, 0.04793055f, 0.20845604f, 
    -0.04510390f, -0.02496915f, 0.02449518f, -0.03649443f, -0.09244527f, -0.11960076f, 0.04818292f, -0.01339490f, 
    -0.02278911f, -0.05061037f, -0.05943360f, 0.00929386f, -0.08383324f, 0.14785300f, -0.04880982f, -0.05990623f, 
    -0.09348565f, 0.16056009f, -0.04519923f, 0.09000490f, -0.01012660f, -0.08031385f, 0.11498771f, 0.04110277f, 
    0.07581637f, 0.06437410f, 0.05674297f, 0.03228190f, -0.22449027f, -0.07039282f, 0.14605296f, -0.00282886f, 
    -0.01082768f, -0.03375079f, -0.02834468f, 0.04232626f, -0.04477635f, -0.08586340f, -0.02540930f, 0.10468771f, 
    0.51156682f, 0.26922452f, -0.12396234f, -0.13724354f, 0.21448587f, -0.01871319f, 0.09259379f, -0.04903607f, 
    -0.05425147f, 0.01330174f, 0.05266472f, -0.05591398f, -0.00949643f, 0.02394389f, -0.15161878f, -0.18730989f, 
    0.25677013f, 0.18850870f, -0.00699873f, 0.10075013f, -0.05945748f, -0.00856726f, 0.09275687f, 0.13623157f, 
    -0.00017560f, 0.00543890f, -0.02885034f, 0.11937020f, 0.03277878f, -0.08302867f, 0.12528063f, -0.00316106f, 
    -0.09559342f, 0.15586621f, 0.08153164f, 0.04869764f, -0.16030607f, -0.21411528f, 0.01600834f, -0.07238771f, 
    -0.15288723f, -0.09110829f, -0.04057431f, -0.02803520f, 0.08002216f, 0.04996682f, 0.13717437f, 0.11855485f, 
    0.06365489f, -0.08091655f, -0.31047514f, -0.04952341f, -0.02581284f, 0.10369671f, 0.12223811f, 0.08274432f, 
    -0.09784490f, 0.10855006f, 0.04557020f, 0.10377876f, -0.15954159f, -0.05593420f, 0.07279839f, 0.06516868f, 
    -0.05494948f, 0.02043234f, -0.13887201f, 0.01253053f, -0.08769511f, 0.00685566f, -0.00041841f, 0.04435072f, 
    0.10145766f, 0.09567130f, -0.11942001f, 0.07392604f, 0.05969185f, -0.05040290f, -0.09351875f, 0.02264553f, 
    0.00785263f, 0.00977886f, 0.09386677f, 0.06673470f, -0.24258620f, -0.09094543f, 0.05035404f, -0.02272953f, 
    0.00273290f, -0.02465352f, -0.04030720f, -0.18286109f, 0.01410276f, -0.08244795f, 0.05800962f, 0.08141054f, 
    0.08423284f, -0.05883087f, 0.23867446f, 0.00878161f, 0.10828459f, 0.08149152f, 0.14091495f, 0.02102312f, 
    0.01799386f, 0.10602017f, 0.07341184f, -0.14918643f, -0.18800652f, 0.36480168f, -0.07728302f, 0.18267334f, 
    -0.13155177f, 0.26219380f, 0.05064527f, 0.10261416f, 0.10857236f, -0.02457562f, 0.01807431f, 0.03800014f, 
    0.07934720f, -0.07811321f, 0.09148884f, -0.13263153f, 0.03938105f, 0.21886101f, 0.08600742f, -0.03497127f, 
    0.03641002f, 0.07782682f, 0.07347229f, 0.00222253f, -0.01368883f, -0.24850073f, 0.18178324f, -0.17911960f, 
    -0.10447923f, -0.06419288f, -0.02138530f, -0.12389719f, -0.03671211f, -0.09700062f, 0.02689854f, 0.01806788f, 
    0.11126716f, 0.03900949f, 0.02620148f, 0.08625134f, 0.00431854f, 0.09060106f, 0.06951077f, -0.03845605f, 
    -0.08639428f, 0.06164680f, -0.03793238f, 0.04125567f, -0.22908354f, -0.45632774f, 0.10528912f, -0.32116559f, 
    0.11457172f, -0.07024936f, -0.06890647f, -0.14888491f, 0.02632677f, -0.00108308f, 0.02788011f, 0.03551140f, 
    0.04294546f, 0.06785418f, -0.22847952f, 0.10799783f, 0.12920821f, 0.12276599f, 0.10435241f, 0.00005517f, 
    0.02803247f, 0.08361842f, 0.06812683f, 0.07200697f, -0.11434607f, -0.10284834f, 0.04281653f, 0.01532278f, 
    -0.13322476f, -0.06430458f, -0.07180349f, -0.01725731f, -0.09333264f, 0.01357524f, 0.18995783f, 0.04114220f, 
    0.06041314f, -0.00317229f, -0.41419300f, -0.09095158f, 0.13838114f, 0.06817310f, 0.16219211f, 0.10677603f, 
    0.04687456f, 0.01300875f, 0.05337687f, 0.02429271f, -0.34350073f, -0.12287059f, -0.11493696f, 0.02539305f, 
    0.01078554f, -0.24407262f, -0.06101373f, -0.23272142f, -0.08070265f, -0.01944046f, 0.04171130f, 0.06758416f, 
    0.15352912f, 0.08055695f, 0.04887177f, 0.25268117f, 0.06846417f, 0.17869580f, 0.02667417f, 0.12114469f, 
    -0.04520249f, -0.05059614f, -0.02772022f, 0.04353114f, -0.03962386f, 0.23897634f, 0.01498854f, 0.07194985f, 
    -0.00736650f, 0.07096960f, -0.02398013f, -0.08328599f, 0.22125232f, 0.02274775f, 0.03966498f, -0.05232337f, 
    -0.08355743f, -0.15507282f, -0.11571717f, -0.19664825f, 0.03334867f, 0.14429259f, -0.05271118f, -0.00850413f, 
    -0.08045512f, -0.04057602f, -0.18189594f, 0.03101300f, 0.34016067f, 0.16535334f, -0.11349180f, 0.03656754f, 
    0.14717674f, 0.20603700f, 0.03610408f, 0.10694061f, -0.08962377f, -0.05776880f, -0.13212708f, -0.00314755f, 
    -0.22854626f, 0.34425187f, -0.31704029f, -0.25167829f, -0.04393807f, -0.08260498f, 0.13099538f, -0.03104255f, 
    0.11779646f, 0.16213904f, 0.04481562f, 0.09609917f, 0.30995980f, 0.03340670f, 0.20172179f, 0.22534215f, 
    0.15387614f, 0.21181236f, 0.09233309f, -0.02659568f, 0.02412258f, 0.22172861f, 0.03372744f, 0.10351331f, 
    -0.28602540f, 0.16211529f, -0.02089368f, 0.12642454f, -0.06157745f, -0.08765437f, -0.03431427f, -0.03073988f, 
    -0.08020869f, 0.09345786f, -0.01577950f, -0.00341378f, -0.22351874f, -0.11968906f, -0.18509828f, -0.08069287f, 
    -0.02019907f, -0.13978039f, -0.06199643f, -0.12031586f, -0.13829367f, 0.03046993f, 0.07272461f, 0.06912108f, 
    0.46108881f, -0.38771585f, 0.26813945f, -0.11348117f, 0.00326853f, -0.09688432f, 0.10342583f, -0.04571460f, 
    0.04167065f, 0.01197591f, 0.24286555f, 0.03234313f, -0.03108923f, -0.27209228f, -0.03794925f, -0.27735382f, 
    0.21879032f, -0.01323261f, -0.09794503f, 0.08328214f, -0.03094479f, 0.06119552f, 0.08843403f, 0.12913115f, 
    0.23888789f, 0.09142946f, 0.18346654f, -0.21021712f, -0.01610431f, -0.06600774f, 0.03893942f, 0.10649665f, 
    0.14921589f, -0.00038285f, 0.00965835f, 0.02965319f, -0.46397883f, 0.01482202f, 0.08912095f, 0.18732671f, 
    0.06192728f, -0.00614260f, -0.11339589f, 0.12332561f, 0.13411303f, 0.19179189f, 0.06837983f, -0.06027978f, 
    -0.07656838f, -0.12422020f, -0.12776564f, -0.01876892f, 0.13569766f, 0.01422650f, -0.08949438f, 0.03600985f, 
    0.04407495f, -0.04180265f, 0.01561029f, 0.03573332f, 0.04361879f, -0.11407261f, -0.11790287f, 0.08118071f, 
    -0.05129450f, 0.01350159f, 0.00349568f, -0.02120034f, -0.05018603f, -0.00394911f, 0.00164859f, 0.06324990f, 
    0.34212685f, 0.11228033f, -0.08874445f, -0.15471902f, 0.05301229f, -0.05112097f, 0.04781352f, 0.04092267f, 
    0.14031757f, -0.08198372f, -0.01327688f, 0.09420881f, 0.20731097f, 0.17731419f, 0.13830243f, -0.09431847f, 
    0.19754635f, 0.08459058f, 0.02444854f, 0.13385642f, 0.04339414f, -0.07258493f, -0.01215554f, -0.05591376f, 
    -0.45799842f, 0.19945486f, 0.05336940f, 0.14626792f, 0.00317255f, -0.00378968f, -0.03687018f, -0.08950162f, 
    -0.00989224f, 0.10574961f, 0.05845653f, 0.20443581f, 0.08743198f, -0.18355896f, 0.11263672f, 0.07168987f, 
    -0.04976640f, -0.00092147f, -0.04800672f, -0.05712868f, 0.01598630f, -0.04673411f, 0.07472063f, 0.04157666f, 
    -0.02868660f, 0.22291064f, -0.28896880f, -0.23404320f, -0.00486262f, 0.00240317f, 0.08732840f, -0.04361768f, 
    0.00050859f, -0.00786899f, -0.00872592f, -0.00271298f, 0.06159045f, -0.31533226f, 0.03851517f, -0.10851659f, 
    -0.00150344f, 0.06121787f, -0.01606897f, -0.05970673f, -0.03803211f, -0.09934290f, 0.00878269f, 0.08182453f, 
    0.23074006f, -0.33301470f, -0.15635872f, -0.18135476f, -0.03746001f, -0.07638593f, 0.02239679f, 0.06333157f, 
    0.10696089f, 0.12070737f, 0.03821285f, -0.04389941f, -0.03104235f, -0.09148528f, -0.21943153f, 0.15205811f, 
    0.16616823f, 0.01830083f, 0.08052501f, -0.08084992f, -0.02594613f, -0.10334376f, -0.00191120f, 0.11167076f, 
    -0.13790396f, 0.00218851f, -0.29930058f, -0.02984112f, 0.08133235f, 0.06335008f, -0.06492528f, 0.05890318f, 
    0.02955698f, -0.02444248f, 0.12906866f, -0.03915823f, -0.31004447f, 0.03934685f, 0.07441443f, 0.05641992f, 
    0.09326742f, 0.00356548f, 0.00062257f, -0.03620980f, -0.08651928f, -0.17537652f, 0.21037930f, 0.05119173f, 
    0.16672996f, -0.05956091f, -0.11684789f, -0.09604296f, 0.05234686f, 0.04621958f, -0.00787352f, 0.09701408f, 
    0.00675941f, -0.00396023f, 0.06735452f, 0.15775810f, -0.31619444f, -0.01436192f, -0.00259853f, 0.17340642f, 
    0.14279565f, 0.00629861f, -0.08850186f, -0.12709621f, 0.01674526f, -0.04224045f, 0.01289772f, 0.06266971f, 
    0.20330317f, -0.00565799f, -0.07239902f, 0.01583111f, 0.05357459f, 0.10162292f, 0.05511103f, -0.05177280f, 
    0.07303897f, 0.02014005f, 0.11079046f, 0.07610033f, -0.02418854f, -0.01404649f, -0.22290662f, -0.17114639f, 
    0.02720687f, 0.07282913f, 0.04651482f, -0.04681145f, -0.12507249f, 0.05053283f, -0.06072376f, -0.06430593f, 
    0.19141933f, 0.12095741f, -0.09076429f, -0.13861553f, 0.07204996f, 0.13607882f, 0.00618412f, 0.08036817f, 
    -0.04148984f, 0.00533004f, 0.05493243f, 0.06385131f, -0.07751667f, 0.03048478f, 0.08022337f, 0.24635063f, 
    -0.10016801f, -0.01909646f, -0.11154946f, -0.01726417f, 0.06103746f, 0.04398292f, -0.08451942f, 0.07834313f, 
    0.27981442f, 0.32232267f, -0.24806581f, -0.18055771f, -0.04885000f, -0.20464700f, 0.14715050f, 0.13042697f, 
    0.05386696f, 0.03759569f, 0.04716143f, 0.07428953f, 0.15279067f, -0.18520077f, -0.33075112f, -0.10448640f, 
    -0.03294934f, -0.10083029f, -0.04217808f, -0.10226244f, 0.05828257f, 0.03868915f, 0.02024341f, -0.11467206f, 
    0.15528372f, 0.21733496f, -0.08597928f, -0.39179188f, -0.11863810f, 0.05136236f, 0.05742021f, 0.09297823f, 
    -0.00851480f, 0.02209485f, 0.01566138f, -0.03918936f, 0.02189978f, -0.14847690f, 0.12925571f, -0.02198422f, 
    -0.00621692f, -0.01640791f, -0.06539096f, -0.01717136f, 0.01839120f, 0.07246698f, 0.03415784f, 0.04769497f, 
    0.10349474f, 0.05002723f, -0.02271618f, -0.17266291f, 0.07142644f, 0.04535988f, -0.03004310f, 0.10591333f, 
    -0.00129885f, -0.02291622f, 0.01402715f, -0.01835856f, 0.26527572f, 0.32506788f, 0.12388729f, -0.01302325f, 
    0.13442315f, 0.10788238f, 0.01434835f, 0.04224333f, 0.03072616f, 0.03620636f, 0.02094640f, 0.00192252f, 
    -0.00959974f, 0.01937126f, 0.21627147f, -0.18153863f, 0.06711806f, -0.03820778f, 0.21773484f, -0.17214178f, 
    0.23226918f, -0.16784620f, -0.00031796f, 0.10236499f, 0.19111376f, 0.13232099f, -0.06199354f, -0.05665397f, 
    0.05160344f, 0.12775841f, -0.06583034f, -0.08873947f, 0.12669547f, -0.03994414f, -0.00123524f, 0.05780564f, 
    -0.00821937f, -0.12271847f, -0.03763394f, -0.02585568f, 0.05232627f, -0.02156023f, -0.02361821f, 0.00319909f, 
    0.04548843f, 0.11884394f, -0.01446565f, -0.20832910f, -0.09669942f, -0.13756369f, -0.08517412f, 0.15457468f, 
    0.08519833f, 0.01162765f, -0.02927601f, -0.05510074f, 0.03139970f, -0.02580190f, -0.01472055f, 0.01822899f, 
    -0.68361712f, -0.05062346f, -0.20853202f, -0.22252001f, 0.02128463f, 0.03712401f, -0.16154672f, -0.10607342f, 
    0.07898467f, 0.07097041f, 0.03309990f, -0.08648784f, 0.14932610f, 0.01153797f, -0.10553217f, -0.37763804f, 
    0.06705906f, 0.07553918f, 0.01656325f, 0.14194694f, -0.01315808f, 0.04644733f, 0.07230978f, -0.07013492f, 
    -0.00452234f, -0.01194333f, 0.01553996f, -0.04683832f, 0.01883131f, -0.00486316f, -0.02716321f, 0.04147079f, 
    -0.05058759f, -0.02897525f, -0.04214880f, 0.03588098f, -0.04310581f, -0.01324121f, 0.01747852f, 0.03199085f, 
    -0.04376868f, -0.01365216f, -0.03843486f, -0.01852389f, 0.00434757f, -0.02605196f, -0.04465938f, 0.02864005f, 
    -0.01316856f, -0.02582093f, -0.04117129f, -0.00267734f, -0.04950595f, 0.03334218f, -0.04091035f, -0.04639696f, 
    -0.04092288f, -0.03603731f, -0.04996980f, 0.01548051f, -0.01355984f, -0.03353401f, 0.03819831f, -0.01881158f, 
    -0.02893749f, 0.02415265f, 0.03711244f, 0.01737295f, -0.03259010f, -0.00191862f, -0.04307598f, 0.00712791f, 
    -0.02490613f, 0.00279345f, 0.00690305f, -0.01332454f, 0.04449598f, 0.01910459f, -0.01901256f, 0.02931100f, 
    0.02250816f, -0.02074536f, 0.03528016f, -0.03581751f, -0.02159828f, 0.00714808f, 0.01058514f, -0.04154116f, 
    0.04070506f, -0.01076314f, -0.03851688f, -0.04000587f, -0.05206086f, 0.01341529f, -0.00292869f, 0.01641750f, 
    -0.01479646f, 0.03103127f, -0.04199311f, -0.04635885f, 0.01971400f, -0.01973380f, 0.02496507f, -0.05786073f, 
    -0.01892154f, 0.03703699f, 0.02029737f, -0.04830739f, -0.03469048f, -0.04270411f, -0.03557282f, -0.05782716f, 
    0.02202506f, -0.03057314f, 0.03824939f, -0.03633401f, 0.02139237f, -0.01437924f, 0.01106389f, 0.03321102f, 
    -0.02269606f, -0.01318977f, -0.03565419f, -0.03762081f, 0.00784054f, 0.02670416f, -0.03527994f, -0.01856968f, 
    0.01044677f, -0.04621050f, -0.05204125f, 0.03952320f, -0.02471467f, 0.04227703f, -0.03889898f, 0.02098149f, 
    0.01322955f, 0.02734121f, 0.03754290f, 0.00634500f, 0.02243771f, 0.03757742f, -0.00837117f, -0.02329888f, 
    0.02919253f, 0.02684292f, -0.02502671f, -0.00170388f, 0.01473861f, -0.01552705f, -0.00629246f, -0.03301994f, 
    0.03782942f, 0.03653092f, -0.00408693f, -0.02519614f, 0.02443567f, 0.02908671f, -0.04456539f, 0.00751086f, 
    -0.02051422f, 0.01381600f, -0.02834807f, 0.00580562f, 0.04522029f, -0.01865174f, 0.03398414f, -0.01684168f, 
    -0.03643105f, 0.02329552f, -0.02210642f, 0.04128282f, -0.03808324f, 0.02042845f, 0.00967470f, -0.02545980f, 
    0.03685457f, -0.04742983f, 0.01913278f, -0.03285205f, -0.00048066f, -0.02789233f, 0.03036257f, 0.02939480f, 
    0.01624181f, 0.02011749f, -0.00922058f, -0.05267507f, 0.01233901f, 0.00215646f, -0.04393427f, 0.03675768f, 
    -0.02166200f, -0.04730669f, -0.03438078f, 0.01036619f, 0.00318866f, -0.04350293f, 0.02296272f, -0.00597966f, 
    -0.00424817f, -0.04873013f, 0.00018764f, -0.01478137f, -0.00257839f, -0.05687240f, -0.00459398f, -0.02320381f, 
    -0.00193053f, -0.01107065f, -0.01544107f, -0.05841701f, 0.04093664f, -0.00836439f, 0.04772712f, 0.04971573f, 
    0.02678075f, -0.02248143f, -0.01037318f, -0.00748155f, 0.01410049f, -0.02255255f, -0.00402517f, -0.03416642f, 
    -0.03105912f, -0.04718236f, 0.02552881f, -0.03906021f, 0.03906817f, 0.02516336f, -0.04657351f, -0.03254883f, 
    0.03938047f, -0.03067996f, 0.03000935f, -0.02926088f, -0.04164206f, -0.02301547f, 0.00172964f, 0.03812777f, 
    0.03983963f, 0.01961661f, 0.01584551f, -0.04430820f, -0.03872985f, -0.01161738f, 0.00658338f, 0.02223481f, 
    0.03884514f, 0.03387358f, 0.02038696f, -0.01511859f, -0.00153362f, -0.02651664f, 0.00383606f, -0.02088108f, 
    0.03786970f, -0.04689670f, 0.03998185f, -0.04201978f, -0.03448762f, 0.00290629f, 0.01696541f, -0.00021339f, 
    0.01249948f, 0.03345317f, -0.02223580f, 0.02345113f, 0.01935161f, -0.01290604f, -0.02185526f, -0.04502026f, 
    -0.01929484f, 0.04292570f, 0.02074435f, -0.04413413f, -0.05127706f, -0.02633625f, 0.03964680f, 0.02905122f, 
    -0.01136024f, -0.03214455f, -0.01649638f, 0.01966544f, -0.02586778f, -0.03683027f, -0.03236818f, 0.03681269f, 
    0.02552546f, -0.03710723f, -0.02694866f, 0.02016021f, 0.02868559f, 0.00338198f, 0.01889388f, 0.02999193f, 
    0.03758324f, 0.00695369f, -0.01324560f, -0.00588751f, -0.01330827f, 0.03254240f, -0.02660686f, -0.04127267f, 
    -0.03640725f, -0.04394336f, -0.03741078f, -0.02888733f, 0.02098769f, 0.03386012f, 0.04501743f, 0.02586730f, 
    -0.05122035f, -0.00672845f, -0.03165244f, -0.02610832f, -0.01699685f, 0.02279083f, -0.01255672f, 0.02954443f, 
    -0.04571760f, 0.01321294f, -0.03993390f, -0.01322271f, 0.02020451f, -0.03810881f, -0.04424155f, -0.04470373f, 
    -0.04240946f, -0.00268309f, -0.00508166f, -0.02896997f, -0.00994578f, -0.01510205f, -0.01024749f, 0.01229297f, 
    0.02638346f, -0.03101036f, 0.03654459f, -0.01138805f, -0.05171784f, 0.03240501f, 0.03585089f, 0.02161764f, 
    0.04311855f, -0.02770917f, -0.04463663f, 0.02886054f, -0.03635179f, -0.04949021f, 0.01888318f, -0.02553658f, 
    0.00530226f, -0.00840597f, -0.00881263f, -0.03422601f, 0.03038687f, -0.04695721f, -0.00353878f, 0.02142221f, 
    -0.02802422f, 0.00011710f, -0.02441446f, -0.04729582f, 0.02115300f, -0.00359325f, -0.02038507f, 0.04306072f, 
    0.00652392f, 0.04330288f, 0.02336360f, 0.02300846f, 0.00173683f, -0.02837585f, -0.00973144f, -0.03441588f, 
    -0.05749700f, -0.04784969f, -0.04174326f, 0.00279354f, 0.04665981f, -0.02885913f, 0.02313441f, 0.04938138f, 
    -0.01385087f, -0.03349791f, 0.03549468f, 0.00155207f, -0.04729521f, -0.00353471f, 0.03601653f, 0.04454978f, 
    0.01727622f, 0.00995912f, -0.04428439f, -0.02313208f, -0.03026180f, -0.01617448f, 0.03445544f, 0.04004230f, 
    0.01718688f, -0.03283340f, 0.01854099f, -0.00218610f, -0.04890705f, -0.03903412f, -0.04855666f, 0.00439569f, 
    0.43016532f, -0.16335340f, -0.03491356f, 0.26055905f, 0.07377907f, 0.08138321f, 0.09268615f, 0.15754746f, 
    0.10066533f, 0.05279696f, 0.00108510f, -0.04000371f, 0.41537315f, 0.10961699f, -0.04886802f, -0.09589089f, 
    -0.10976201f, -0.05801657f, 0.15614477f, -0.03867876f, 0.02491986f, -0.08490676f, 0.15197767f, 0.09650681f, 
    0.23576726f, 0.10570729f, 0.16386950f, 0.15930292f, 0.00728188f, 0.04939678f, -0.05093287f, 0.09660096f, 
    -0.13877234f, 0.03764545f, -0.07917091f, -0.01049243f, -0.15018819f, 0.24511342f, 0.07932787f, 0.00738369f, 
    0.12983644f, -0.03558704f, -0.07594820f, -0.07336728f, 0.01405680f, 0.08510109f, 0.08002209f, -0.04679244f, 
    -0.47664827f, 0.23467366f, 0.15237194f, 0.14048181f, -0.04550439f, 0.05797708f, -0.05229036f, 0.23284897f, 
    -0.10386685f, 0.16761999f, -0.00226212f, 0.02522294f, -0.12955438f, -0.24396628f, 0.00470842f, 0.11838479f, 
    -0.08892725f, -0.03838928f, 0.03543073f, -0.10726138f, -0.05086051f, 0.04881723f, -0.09872921f, -0.08610094f, 
    0.33255503f, -0.01139546f, 0.02707703f, -0.29647130f, -0.02149233f, 0.05475337f, -0.00554228f, 0.07302210f, 
    0.03815024f, -0.05950010f, 0.11443160f, 0.00813343f, -0.24023022f, 0.03167491f, -0.31782135f, -0.21645783f, 
    0.03240047f, -0.20724453f, -0.04124739f, 0.03523288f, -0.16250262f, 0.02591607f, 0.03630903f, -0.09899413f, 
    0.09389272f, 0.23092552f, 0.36986214f, -0.06185259f, 0.31897441f, -0.04179621f, -0.09029888f, 0.16934596f, 
    0.04327311f, -0.24965928f, -0.08760372f, 0.04398454f, -0.16546910f, 0.12670821f, -0.08144373f, 0.14872688f, 
    0.05766377f, 0.10990393f, 0.13771346f, 0.07885069f, 0.08602115f, 0.17336439f, 0.17385605f, -0.16138291f, 
    -0.28034255f, 0.35416350f, 0.13024776f, 0.09682459f, -0.04875355f, -0.21957895f, 0.05103352f, 0.02552823f, 
    -0.11794697f, 0.03937913f, -0.10037769f, -0.09709936f, -0.13568866f, 0.01564575f, 0.08341530f, -0.08109441f, 
    -0.04250846f, -0.00550255f, -0.04312249f, 0.13478760f, 0.02347493f, 0.10853922f, -0.04546143f, -0.15404978f, 
    0.02678380f, 0.00167009f, 0.02167061f, 0.19965428f, -0.14301096f, -0.13223003f, -0.03339779f, -0.03326477f, 
    0.14110535f, 0.07214439f, -0.10257254f, -0.07012831f, 0.43971407f, 0.01510859f, -0.13467380f, 0.06900629f, 
    0.02390940f, 0.02986700f, 0.05580061f, 0.04065486f, -0.08153311f, 0.13353421f, 0.09212612f, -0.09702183f, 
    0.14432010f, 0.20678872f, 0.07741146f, 0.13081475f, 0.15665863f, 0.05363363f, 0.12170449f, 0.19955958f, 
    -0.12538870f, -0.04634305f, -0.03218102f, 0.09497090f, -0.21374151f, 0.08921373f, -0.41750848f, 0.05523538f, 
    0.03271500f, -0.07483798f, -0.32916707f, 0.18336782f, -0.17479753f, 0.03100778f, -0.00708006f, 0.08790747f, 
    -0.13506764f, -0.04155607f, 0.13932316f, 0.05454857f, 0.01113461f, -0.05636103f, 0.02106088f, 0.14587130f, 
    0.03362599f, -0.05142634f, -0.07436433f, 0.06875855f, -0.27308759f, 0.34323478f, 0.11941320f, 0.34632203f, 
    0.12799281f, 0.13596649f, -0.05342152f, 0.02626395f, -0.06546774f, -0.15439382f, -0.08390916f, -0.00556129f, 
    -0.29167464f, -0.17535479f, 0.14850742f, -0.07267345f, -0.03129393f, -0.01668145f, 0.04142961f, 0.01986359f, 
    -0.01234473f, -0.00557649f, 0.04713255f, -0.00003348f, -0.16835199f, -0.18015398f, -0.24485058f, -0.28995717f, 
    0.06440020f, -0.02418479f, 0.05095449f, -0.07187956f, 0.02185762f, -0.14051269f, 0.16433866f, 0.01313209f, 
    0.00597058f, -0.18669425f, 0.37029546f, -0.01391856f, 0.19641642f, 0.06374414f, 0.06729712f, 0.14008747f, 
    -0.05366195f, 0.07026236f, -0.02485537f, -0.07122252f, -0.05273912f, 0.04293822f, -0.00532212f, 0.18955284f, 
    0.06886885f, -0.00029357f, 0.11184917f, 0.09591959f, 0.13422023f, 0.01470113f, -0.05244339f, 0.03345970f, 
    -0.13599662f, -0.15658113f, 0.07008831f, 0.18800239f, -0.04790169f, -0.05782958f, 0.18000779f, -0.00960377f, 
    0.00997855f, -0.06363217f, 0.25648633f, 0.12011567f, -0.28854552f, -0.03213512f, -0.07635375f, -0.01921775f, 
    -0.00687012f, -0.11344627f, -0.03694589f, -0.14892538f, -0.13271199f, -0.06641088f, 0.02123782f, 0.26365951f, 
    -0.16367076f, -0.04698080f, 0.06010558f, 0.10216717f, 0.11897504f, 0.03969473f, 0.05255297f, -0.09380274f, 
    0.00765208f, -0.02847937f, 0.05790582f, -0.00245201f, -0.32968262f, -0.19164738f, -0.03337272f, -0.08308101f, 
    -0.09300775f, -0.11690422f, 0.01966132f, -0.01446332f, 0.07261745f, -0.02920348f, 0.05227553f, 0.04190309f, 
    0.49301887f, -0.21365802f, 0.22347572f, 0.21695957f, -0.14601512f, 0.00158723f, -0.02916784f, 0.15087289f, 
    -0.18181014f, 0.02807597f, -0.06466113f, -0.09584373f, -0.25324982f, -0.05900273f, 0.11879610f, 0.06654116f, 
    -0.01547952f, -0.00842821f, 0.12794393f, 0.25047821f, -0.03934494f, -0.00775113f, -0.03461276f, 0.05541117f, 
    -0.21055365f, -0.10160181f, -0.01675428f, -0.13653301f, -0.04507555f, 0.11767188f, -0.13085146f, -0.20597664f, 
    0.14488356f, -0.01920269f, 0.00158256f, 0.23653148f, -0.26541311f, -0.06869078f, 0.05385243f, -0.25474948f, 
    -0.07587909f, -0.15735812f, -0.30780029f, -0.03615372f, 0.01673872f, -0.21245953f, 0.18865760f, -0.13307030f, 
    0.43425924f, 0.34845546f, 0.07355066f, 0.15011442f, 0.16358957f, 0.20889147f, -0.07712687f, 0.02591536f, 
    -0.02786973f, -0.00095850f, -0.00342814f, -0.01419367f, -0.01167379f, 0.03767735f, 0.06373157f, 0.34577894f, 
    0.03863923f, 0.06665694f, 0.07474948f, -0.12905653f, 0.08317515f, -0.17211713f, -0.10800175f, -0.10557085f, 
    0.18835361f, 0.01356981f, 0.22266158f, -0.24740858f, 0.23190004f, 0.07020174f, -0.13777107f, 0.20821528f, 
    0.10895164f, 0.04563086f, -0.06366915f, -0.11746445f, 0.09123747f, 0.09309899f, 0.03857359f, 0.21566629f, 
    -0.06039109f, -0.06633220f, -0.03742566f, -0.15763845f, -0.08707971f, 0.09027983f, 0.10119176f, 0.16270131f, 
    0.14306600f, 0.02774571f, -0.14316446f, -0.04131462f, 0.00667681f, 0.06146907f, -0.04915744f, 0.09214151f, 
    0.05102268f, -0.10318561f, -0.02201607f, -0.12829535f, -0.32576758f, 0.14877756f, -0.03759617f, 0.12816310f, 
    -0.04483521f, -0.04440952f, 0.05934289f, 0.00490549f, 0.16138259f, -0.01498027f, -0.03556903f, -0.04031999f, 
    -0.10581312f, 0.42034712f, -0.14049335f, -0.08618234f, 0.20685644f, 0.05472632f, -0.20923738f, 0.16726905f, 
    -0.18760771f, 0.04548304f, -0.02537161f, 0.02836023f, 0.11133236f, 0.02954730f, 0.02273122f, -0.16794327f, 
    0.11704548f, 0.13641879f, 0.12354111f, 0.02031525f, 0.03972814f, -0.11327586f, 0.05551060f, 0.06675692f, 
    -0.08224346f, 0.13060144f, 0.14725457f, 0.16931874f, 0.10547047f, -0.04433792f, -0.14776708f, 0.05585296f, 
    -0.12941580f, -0.05004835f, 0.09856413f, 0.17580010f, -0.09141053f, -0.13839754f, 0.05993550f, -0.04420780f, 
    -0.09521970f, -0.17303383f, -0.24545458f, -0.09202610f, 0.04262118f, -0.01706704f, 0.04223620f, -0.12522520f, 
    0.14056373f, 0.09165686f, 0.09817381f, -0.23223057f, 0.09284873f, 0.06383744f, 0.01635108f, 0.21598275f, 
    0.10094193f, -0.08209320f, -0.04216132f, -0.05499190f, -0.22326785f, 0.04567378f, -0.06194989f, 0.04838654f, 
    0.00891623f, 0.17649387f, -0.01578966f, -0.07864565f, 0.01720248f, 0.02149015f, 0.04487888f, 0.03095202f, 
    -0.18889764f, -0.03065431f, 0.09559985f, 0.00444703f, -0.12944010f, -0.13030422f, 0.04018983f, 0.24937440f, 
    0.00223506f, 0.01702271f, -0.08735291f, 0.02896789f, -0.25814018f, 0.09405600f, -0.07133889f, 0.17572723f, 
    0.02478350f, -0.16968082f, 0.07170991f, 0.03569850f, 0.17715539f, -0.04673734f, 0.03382454f, -0.02307810f, 
    0.15764682f, 0.10162558f, -0.05093323f, 0.17366090f, -0.03065806f, -0.17475852f, -0.05103853f, 0.25077870f, 
    0.00253885f, 0.09062429f, -0.10864595f, -0.24166802f, 0.18415368f, 0.21762860f, 0.03959461f, 0.14687322f, 
    0.02283561f, 0.01297894f, 0.01832100f, 0.01047082f, 0.03603499f, -0.09472870f, 0.12750567f, -0.13736537f, 
    0.19299281f, 0.08150057f, 0.02072083f, -0.11408080f, 0.08652248f, 0.00554828f, 0.03558370f, 0.15770471f, 
    -0.00260035f, 0.04342358f, 0.07373052f, 0.07247378f, -0.44779909f, -0.07544217f, -0.15919580f, 0.05429695f, 
    -0.08977931f, -0.08823384f, -0.13875897f, -0.10151014f, -0.01531462f, -0.07817137f, -0.00158168f, -0.06214334f, 
    0.03451338f, 0.09176745f, 0.10796194f, 0.14805877f, 0.03180425f, -0.03687724f, -0.18822774f, 0.00084458f, 
    -0.06031193f, 0.06954877f, -0.02263115f, 0.09420584f, -0.40118966f, 0.04769606f, 0.02806577f, 0.10938542f, 
    -0.07212608f, 0.11769537f, -0.03359614f, -0.10100891f, 0.09279620f, 0.06663349f, -0.07166221f, 0.02886552f, 
    -0.14723244f, 0.05444738f, -0.07302635f, -0.09292822f, -0.07012577f, 0.04497897f, -0.01260030f, 0.19893923f, 
    -0.06802795f, 0.07268424f, 0.02956349f, -0.03151560f, 0.06114610f, -0.12571564f, 0.11150219f, 0.32488886f, 
    0.01185953f, -0.12624374f, -0.24219750f, -0.03609785f, -0.03890850f, -0.02242195f, 0.07690600f, -0.03797048f, 
    0.09569318f, 0.17960237f, 0.02614164f, -0.11207770f, 0.14550532f, -0.10999626f, 0.17029364f, 0.18837954f, 
    -0.04146478f, 0.01866913f, -0.03328283f, -0.03987438f, 0.08849850f, -0.17160210f, -0.22101560f, 0.26721406f, 
    0.13991433f, -0.27480870f, -0.00827921f, 0.13449398f, 0.14190614f, -0.03181520f, -0.22874622f, -0.00758311f, 
    0.24430121f, -0.04616687f, 0.09459145f, -0.04115059f, -0.04656642f, -0.03922073f, 0.02368708f, 0.11340036f, 
    -0.03715313f, -0.05180927f, 0.08974506f, 0.09416893f, -0.27239782f, 0.14255695f, 0.15678212f, -0.27383575f, 
    -0.13258958f, -0.16765204f, -0.14965804f, -0.18453750f, -0.00362738f, -0.00027518f, -0.02941576f, 0.14950129f, 
    0.06050816f, -0.00960314f, -0.09155539f, -0.02666169f, 0.04326687f, -0.05719870f, -0.04958104f, 0.15343694f, 
    -0.04028514f, 0.08939161f, -0.07902902f, 0.02625062f, 0.05776951f, 0.01852509f, 0.02286915f, 0.02948651f, 
    0.17477202f, 0.10613239f, 0.01678045f, 0.09375688f, 0.02110589f, 0.07280254f, -0.03677275f, -0.01242985f, 
    -0.11240298f, 0.20251431f, -0.02405836f, -0.00277389f, -0.02195904f, -0.07486882f, -0.01151849f, -0.02183883f, 
    -0.08385418f, -0.05872461f, 0.00878110f, -0.05664445f, 0.17254543f, -0.06217861f, 0.25369006f, 0.07334603f, 
    0.14785628f, 0.02869275f, -0.28002891f, -0.02020164f, -0.03612054f, 0.11855311f, 0.07012742f, 0.03996633f, 
    -0.21645658f, -0.05063909f, -0.07168706f, 0.02213869f, -0.04391617f, 0.00334758f, -0.02719248f, -0.12463120f, 
    0.04094034f, -0.03628941f, -0.06366494f, 0.09207143f, -0.38397855f, -0.31619719f, -0.18639202f, 0.28241482f, 
    -0.01729323f, -0.19698566f, -0.07733969f, -0.00548637f, -0.07112333f, 0.10204834f, 0.07837085f, -0.02641457f, 
    0.30301541f, 0.07782473f, -0.05009005f, -0.31681585f, -0.05400736f, 0.00826778f, -0.00076932f, -0.15239602f, 
    -0.02632559f, -0.04480998f, -0.04237512f, 0.01027989f, 0.28419122f, -0.12564638f, -0.02780173f, -0.04173357f, 
    0.18219098f, 0.00050362f, 0.09910379f, 0.09279538f, 0.00622598f, 0.05653192f, -0.03217635f, -0.03466192f, 
    -0.00025054f, -0.16246516f, -0.07107764f, 0.26456693f, 0.04057649f, -0.04190909f, 0.10864781f, 0.19669773f, 
    0.14377184f, 0.11537408f, 0.17127903f, 0.02476030f, -0.13485627f, -0.16676924f, -0.19976267f, -0.07499617f, 
    -0.01321634f, 0.05048197f, 0.00145874f, 0.08741496f, 0.04499333f, -0.01424943f, -0.17157905f, -0.44292167f, 
    -0.04820470f, 0.23993963f, -0.06955231f, 0.09753821f, -0.01538040f, 0.04961914f, 0.26398364f, -0.05629112f, 
    -0.02999906f, 0.14667301f, 0.08737919f, 0.12372722f, 0.34743440f, 0.21583997f, 0.16800931f, -0.00514739f, 
    0.01002993f, -0.07933694f, -0.10398682f, 0.02133952f, 0.01863209f, -0.15722862f, -0.05025252f, 0.05871012f, 
    0.06033001f, -0.14059481f, 0.34975445f, 0.01501937f, -0.00450811f, 0.02085129f, 0.17239785f, 0.07986397f, 
    0.14188460f, 0.12287974f, 0.05226308f, -0.21274501f, -0.44657499f, -0.26955959f, -0.20390350f, -0.08936550f, 
    -0.03860993f, -0.01578072f, -0.03232142f, -0.02982986f, -0.07520216f, 0.03803829f, -0.09172503f, -0.03140949f, 
    0.10987020f, 0.03192181f, 0.04039294f, 0.04899359f, -0.05435496f, -0.09928997f, 0.10346638f, 0.02611588f, 
    0.12021840f, -0.01536958f, 0.06216547f, 0.11469866f, -0.02652299f, -0.01715555f, 0.04362677f, -0.03357013f, 
    -0.18384886f, -0.05980186f, -0.12176318f, -0.02778443f, 0.08491854f, -0.00168138f, 0.07178476f, 0.03867660f, 
    -0.10842321f, -0.06692305f, -0.16059214f, 0.01635765f, 0.04056558f, -0.22242787f, 0.16717544f, -0.02909121f, 
    -0.00515476f, 0.01741721f, 0.00596608f, -0.00090359f, 0.22973458f, 0.06645709f, -0.02315022f, 0.09127657f, 
    -0.03051403f, -0.00153673f, -0.06944947f, 0.05530190f, 0.00169441f, -0.13510814f, -0.04457790f, -0.23134233f, 
    0.17287262f, 0.05652561f, 0.15855311f, 0.12629108f, 0.10085858f, 0.01013965f, -0.04570093f, -0.14601985f, 
    0.01145373f, -0.01037489f, -0.02992984f, -0.00426822f, 0.13145991f, 0.04266355f, -0.03767467f, 0.07042854f, 
    -0.03855257f, -0.01618232f, 0.08018973f, 0.03166707f, 0.01117926f, -0.02068013f, 0.04386757f, -0.02075634f, 
    -0.09710540f, -0.15195543f, 0.19046360f, -0.12675162f, -0.12176505f, 0.02042522f, 0.05059119f, 0.01711049f, 
    0.27706185f, 0.16039687f, 0.05849465f, 0.02342001f, -0.27384457f, 0.19033539f, -0.14804611f, 0.16141933f, 
    -0.12260493f, 0.02742838f, 0.01856970f, 0.05751541f, -0.03895644f, 0.11870757f, -0.01171156f, 0.03832470f, 
    -0.03925916f, 0.07355240f, -0.06655654f, 0.03865568f, 0.03219366f, 0.31346199f, 0.13062049f, -0.01260125f, 
    -0.02552887f, 0.03718074f, 0.00895709f, 0.02434154f, 0.14751874f, -0.08006860f, 0.02282297f, 0.05456460f, 
    0.04517893f, 0.11071662f, 0.04831930f, 0.03241719f, -0.07545620f, 0.06948227f, 0.18273082f, -0.00739952f, 
    -0.01961158f, -0.02914863f, -0.09428475f, -0.20412353f, -0.10493293f, 0.01531716f, 0.04885923f, 0.04986151f, 
    -0.03308615f, -0.13735415f, -0.04971313f, -0.20050378f, -0.02744536f, -0.16230856f, -0.12862091f, -0.13554232f, 
    0.14271630f, -0.12469791f, 0.01748771f, 0.07026252f, -0.04016265f, -0.04682935f, 0.00272309f, 0.02734238f, 
    -0.02475298f, -0.01077002f, 0.07383983f, 0.00561423f, 0.20209493f, 0.06048852f, 0.19974296f, -0.14715500f, 
    -0.02155080f, 0.00051318f, 0.04010336f, 0.06014524f, -0.01304825f, -0.02025646f, -0.03233675f, -0.12369930f, 
    -0.14737295f, -0.11964120f, -0.08101568f, -0.01673330f, 0.07139349f, 0.08277285f, 0.15804604f, 0.23641902f, 
    -0.13390058f, -0.15424797f, -0.08900046f, -0.02895815f, -0.00536057f, 0.20146015f, -0.06101622f, -0.08260272f, 
    0.01706632f, -0.10207126f, -0.01098774f, 0.03810682f, -0.25957268f, 0.13136452f, -0.02683559f, -0.07131553f, 
    0.08053547f, 0.08353079f, 0.22281328f, -0.14983192f, -0.10269899f, -0.00606819f, -0.04532295f, -0.08213410f, 
    -0.14316323f, 0.16676900f, 0.03076313f, 0.12694114f, 0.06286713f, 0.02692618f, -0.00525695f, 0.08046528f, 
    -0.04520850f, -0.02829750f, -0.18248484f, -0.19644545f, 0.20033699f, 0.08734353f, 0.03827105f, 0.06671495f, 
    0.03021332f, 0.09506534f, 0.18920165f, 0.08112336f, 0.22563413f, 0.06019634f, 0.05158138f, 0.00074108f, 
    -0.14144821f, -0.04871264f, -0.04200174f, -0.17549644f, -0.02124167f, 0.18758966f, -0.04757314f, -0.11260073f, 
    -0.09258611f, -0.27325571f, -0.01689949f, -0.11575047f, -0.10311797f, 0.04027594f, 0.22320405f, 0.03293405f, 
    -0.08729398f, 0.00660756f, 0.09642291f, 0.04030445f, -0.04537790f, -0.01607387f, -0.02169407f, -0.06077085f, 
    -0.15303423f, 0.00845427f, -0.12224278f, 0.14004935f, 0.11313849f, 0.07409687f, 0.15764524f, -0.00130440f, 
    0.14407322f, 0.18103009f, 0.25453281f, 0.09796105f, -0.31495911f, -0.05592036f, 0.11503829f, -0.08106951f, 
    -0.15408760f, -0.03576041f, 0.05872026f, 0.22910418f, 0.01464505f, -0.03280773f, -0.08382044f, -0.14679989f, 
    0.14184777f, 0.26629072f, 0.10538655f, 0.12085580f, -0.10437608f, -0.10795080f, -0.05446945f, 0.00329763f, 
    -0.03569386f, 0.14454423f, 0.06180846f, 0.02298209f, -0.04153110f, 0.04860629f, -0.06304175f, -0.11993248f, 
    -0.03636348f, -0.10693347f, -0.11865810f, -0.08310330f, -0.07421403f, -0.08116169f, -0.05981564f, 0.05967388f, 
    -0.05848023f, 0.16355033f, 0.39235455f, -0.07556896f, -0.00878488f, 0.02312796f, 0.19778031f, 0.34420058f, 
    0.05876642f, 0.16651981f, 0.07346062f, 0.20644996f, -0.27670297f, 0.01928880f, 0.09202053f, 0.03659105f, 
    0.08199137f, 0.05964512f, 0.05795489f, 0.02241249f, 0.05557988f, 0.07372276f, -0.02275682f, 0.12104942f, 
    0.05780379f, 0.03808716f, -0.08107932f, -0.04511887f, 0.20485084f, 0.05544801f, 0.13767157f, -0.02313660f, 
    0.19019853f, 0.01259762f, 0.16043998f, -0.05259855f, 0.17214815f, 0.10150011f, 0.15386243f, -0.04457997f, 
    0.05843339f, 0.05312527f, 0.03709103f, 0.10384902f, -0.03477854f, 0.01393930f, 0.07979525f, -0.25364420f, 
    0.15589827f, -0.15233639f, 0.03287699f, -0.00872675f, 0.05775049f, 0.15129773f, -0.08672816f, 0.06621212f, 
    -0.03213836f, 0.04959356f, 0.05611733f, 0.03036657f, 0.07117551f, 0.11497180f, 0.09441406f, 0.33889297f, 
    -0.03669788f, 0.00001936f, -0.06960492f, 0.02994973f, 0.05303619f, -0.06891184f, 0.15292601f, 0.00643080f, 
    -0.12397549f, 0.38929233f, -0.14667633f, 0.13265720f, 0.07364223f, 0.04849674f, 0.19473840f, 0.10877049f, 
    0.02505090f, -0.02018767f, 0.04252034f, 0.02742443f, 0.04247040f, 0.02843373f, 0.20813014f, 0.15251441f, 
    0.16237855f, 0.21613079f, 0.13354883f, 0.08411048f, -0.01933762f, 0.02601719f, -0.00029136f, -0.07141419f, 
    0.03155024f, -0.08182161f, -0.23692520f, -0.29734889f, 0.08326148f, 0.04348426f, 0.04373806f, -0.02692464f, 
    -0.04349784f, 0.00841949f, 0.13210885f, 0.00883866f, 0.09652655f, 0.12223879f, -0.12551661f, 0.03912713f, 
    -0.02333429f, -0.07285175f, 0.05178222f, -0.00713380f, 0.04517238f, -0.07715774f, -0.05390702f, 0.01736807f, 
    0.22901738f, 0.28616747f, 0.22977962f, -0.18019314f, 0.03428031f, 0.03486663f, -0.11171342f, -0.11881600f, 
    -0.06349123f, 0.01132026f, -0.02872940f, -0.02525293f, 0.13796076f, -0.11184965f, 0.03925689f, 0.15766181f, 
    -0.07585018f, 0.07485148f, -0.02094712f, 0.09378131f, -0.01987068f, -0.02606811f, -0.09466664f, -0.29669482f, 
    -0.00178850f, 0.48519990f, -0.14725074f, 0.25162929f, -0.04078496f, -0.17450625f, 0.21325380f, -0.11585940f, 
    -0.03755123f, 0.07270885f, -0.03765014f, -0.01330530f, 0.31196365f, 0.05015700f, 0.29270458f, 0.10553452f, 
    -0.09503204f, -0.07556301f, -0.04576832f, 0.00587565f, 0.02616664f, 0.04883661f, 0.00990782f, -0.02675892f, 
    -0.28907052f, -0.32336450f, -0.45529288f, 0.00376157f, 0.02901207f, 0.06058098f, 0.02670878f, 0.08460135f, 
    0.12685826f, 0.21544224f, -0.08290488f, 0.01796245f, 0.20343414f, -0.46561494f, -0.22292210f, -0.14577512f, 
    0.00539946f, 0.11526985f, 0.07797462f, 0.02844909f, -0.19131577f, 0.27416551f, 0.09052211f, -0.02810670f, 
    0.33778077f, -0.01637524f, -0.11803572f, 0.07991079f, 0.13137604f, -0.04362829f, 0.07466503f, 0.01503567f, 
    -0.12511095f, -0.02017517f, -0.02827005f, 0.18691702f, 0.14797568f, 0.08108978f, 0.12106963f, 0.09528402f, 
    0.27941969f, -0.04014099f, -0.15695517f, 0.07631696f, -0.18664035f, 0.12432214f, 0.00321526f, 0.01758691f, 
    -0.10436732f, -0.13995992f, -0.34114265f, -0.10606656f, 0.04944582f, 0.05218531f, 0.05289878f, 0.16942438f, 
    -0.01097711f, -0.04677628f, 0.00016571f, -0.05764586f, 0.00277020f, -0.02667307f, 0.29564172f, 0.17033340f, 
    0.09929939f, -0.08242269f, -0.09577335f, 0.22018218f, -0.18273145f, -0.09315627f, 0.02464965f, 0.04908011f, 
    0.16201536f, 0.13905975f, 0.09512478f, 0.16839187f, 0.09110464f, 0.06363575f, 0.13559483f, 0.01279206f, 
    -0.05218722f, -0.00363796f, 0.02877459f, 0.01455174f, -0.10283358f, -0.02590158f, -0.18250003f, -0.08326332f, 
    -0.01355810f, 0.02475276f, -0.08163057f, -0.03845923f, 0.10298810f, -0.00290546f, 0.04767681f, -0.04344217f, 
    0.07450529f, 0.00426295f, 0.11101963f, 0.09352192f, 0.09572307f, 0.08757411f, 0.09123134f, 0.10151302f, 
    0.00278267f, -0.01910822f, 0.02946081f, 0.12489312f, 0.20498456f, 0.21806298f, -0.05623169f, 0.36132485f, 
    -0.16728771f, 0.04371117f, 0.06420156f, 0.00330589f, 0.06824864f, 0.05885377f, 0.04110378f, 0.02688596f, 
    0.14962617f, 0.04826714f, -0.14208253f, -0.00065449f, -0.01013394f, 0.01908016f, 0.08406691f, 0.03262245f, 
    0.00285234f, 0.06054456f, 0.09013881f, 0.13203864f, 0.05276747f, -0.20885551f, -0.17467026f, 0.20148358f, 
    0.05733803f, 0.03337188f, -0.00381569f, 0.05371087f, 0.06227680f, -0.06459592f, -0.03839079f, 0.06313299f, 
    -0.04610901f, -0.13619222f, 0.07857744f, 0.12628575f, -0.04459884f, -0.06716026f, 0.03551414f, 0.07007435f, 
    -0.00767629f, -0.02143708f, -0.02048939f, 0.01074069f, 0.15183470f, 0.14539902f, 0.15748313f, -0.05573009f, 
    0.09950283f, -0.08259366f, 0.08317920f, 0.03692227f, 0.01512483f, -0.01010808f, -0.02413387f, 0.07914437f, 
    0.22786613f, -0.14952002f, 0.29166189f, 0.02671350f, -0.05354280f, 0.15371540f, 0.07659538f, -0.03247631f, 
    0.07362354f, 0.01591186f, 0.01555932f, 0.00287714f, -0.29944474f, -0.18440579f, -0.53957587f, -0.27487159f, 
    0.08678751f, 0.06514385f, 0.05280543f, 0.05704036f, 0.03873524f, -0.14014986f, -0.02817024f, -0.03501732f, 
    0.05849865f, -0.11157649f, 0.16569808f, 0.13020739f, 0.00969631f, 0.06936052f, -0.07941893f, 0.05407575f, 
    0.01117719f, 0.06151927f, -0.01712809f, -0.13654886f, 0.11871581f, 0.14447847f, 0.19358918f, 0.06816524f, 
    -0.10039099f, -0.07833491f, -0.13442850f, -0.11897666f, -0.07817148f, -0.08204128f, -0.02619589f, -0.04762110f, 
    -0.05913929f, -0.01755422f, -0.33201271f, 0.30759081f, -0.05008952f, 0.26339489f, 0.02922240f, 0.08109526f, 
    0.02933929f, 0.23015550f, 0.03363667f, 0.00983295f, 0.08251711f, -0.01223959f, 0.13169129f, 0.19944833f, 
    0.05611670f, 0.00711664f, 0.09065410f, 0.00951209f, -0.02212073f, -0.04895978f, 0.01012858f, -0.01131696f, 
    0.17812866f, -0.04758085f, 0.26106909f, -0.12319265f, 0.12270705f, -0.01499128f, -0.01357467f, 0.06989603f, 
    0.08227077f, 0.04071625f, -0.12977497f, -0.06992612f, -0.42981118f, 0.00755228f, -0.05908670f, 0.27116197f, 
    0.00121790f, -0.03086056f, 0.05163037f, -0.23271999f, 0.17644194f, 0.04615419f, 0.03302060f, -0.04405675f, 
    -0.12969853f, -0.02672526f, -0.33784714f, -0.06956200f, -0.09201477f, -0.01213503f, -0.12501456f, 0.00564396f, 
    -0.05304932f, -0.01194033f, 0.04678062f, -0.13613401f, 0.18595254f, 0.10449806f, -0.21401028f, 0.11077662f, 
    -0.05003146f, -0.11976755f, 0.01098706f, 0.09186752f, 0.01496224f, -0.07886153f, -0.03837311f, -0.05054314f, 
    0.21548666f, -0.06777271f, 0.13544959f, -0.21849789f, 0.02786795f, 0.00567124f, -0.13205549f, 0.27475995f, 
    0.10928362f, 0.02440416f, -0.04360355f, 0.06850921f, -0.00050299f, 0.25149301f, 0.15941827f, 0.12341139f, 
    0.05721878f, 0.22165844f, 0.11896771f, 0.06687626f, 0.02830935f, -0.09635589f, 0.01423202f, 0.08672874f, 
    0.13657071f, 0.23365970f, -0.11134438f, 0.19881257f, -0.07653802f, 0.02969347f, -0.15649782f, -0.05350192f, 
    0.03308672f, -0.11911463f, -0.04872350f, 0.20143524f, 0.23002534f, -0.10096250f, 0.27003446f, -0.03657950f, 
    -0.05389547f, -0.07207622f, -0.10071704f, -0.06967066f, 0.02987929f, -0.05653385f, 0.12166466f, -0.12635930f, 
    -0.13738990f, 0.31498215f, -0.14405961f, -0.00399368f, 0.13608889f, 0.01676702f, 0.31476986f, 0.13943322f, 
    0.06979351f, -0.05762207f, -0.04756705f, -0.11571735f, 0.09156040f, -0.07379236f, 0.04246754f, -0.04452839f, 
    0.06834629f, 0.03269976f, 0.04667275f, -0.01741618f, -0.04003312f, -0.19802649f, 0.01758842f, 0.03820308f, 
    0.21990259f, -0.49370039f, 0.02191758f, -0.21582493f, 0.00131318f, 0.05166097f, -0.11167720f, 0.18701801f, 
    -0.00182406f, 0.11235370f, -0.02079702f, -0.09556837f, -0.00950681f, 0.03905722f, -0.31516337f, 0.22239584f, 
    0.06711762f, -0.07338880f, 0.07434166f, 0.13603717f, -0.02774774f, -0.13140036f, -0.04455877f, -0.06131387f, 
    0.40363419f, 0.14180465f, -0.28940889f, -0.06341342f, 0.02638063f, -0.11614957f, -0.09493168f, 0.04550493f, 
    0.05536011f, 0.08836074f, -0.13089080f, -0.05125908f, -0.19423766f, 0.09849865f, -0.02111740f, -0.15482888f, 
    -0.01108436f, -0.06231690f, -0.05638174f, -0.16476969f, 0.00418664f, -0.13038865f, -0.00127586f, -0.00261585f, 
    -0.04074858f, 0.06026903f, -0.15977785f, -0.20530479f, -0.00090060f, -0.05944239f, 0.01425817f, 0.21230355f, 
    0.03360930f, 0.15964447f, 0.03683747f, 0.06836709f, -0.56876361f, 0.05471861f, -0.08971944f, 0.19063777f, 
    0.05889896f, 0.11358169f, -0.05431794f, -0.13527657f, 0.06407588f, -0.00791894f, 0.02440811f, 0.12669207f, 
    0.24973540f, -0.19322357f, 0.04389986f, -0.10299690f, 0.01512788f, -0.00909308f, 0.00226863f, 0.00555706f, 
    0.10352534f, 0.03930024f, 0.04997170f, 0.05914498f, -0.23954746f, 0.31252560f, -0.39302868f, 0.17302248f, 
    0.04031707f, 0.05857944f, 0.14634684f, 0.04300383f, -0.00813116f, 0.17061079f, -0.07515340f, -0.04976059f, 
    0.05767355f, 0.22563052f, 0.19060592f, -0.10681167f, -0.03573151f, 0.14461143f, 0.13278836f, 0.23384361f, 
    0.02444317f, -0.00771767f, 0.04909342f, 0.04013032f, 0.32108587f, 0.03532071f, 0.12269110f, 0.11788349f, 
    -0.13262649f, -0.11447541f, -0.12455723f, -0.01930909f, 0.10977494f, -0.00618278f, -0.12214460f, -0.02638869f, 
    0.23632731f, 0.26815847f, 0.29395381f, -0.07521843f, 0.08610891f, -0.01378060f, 0.03547569f, 0.14841931f, 
    0.05389098f, -0.06088008f, 0.06576156f, 0.00290309f, 0.12477306f, -0.05684305f, -0.04313096f, -0.12269098f, 
    0.10919477f, -0.01597341f, 0.03700631f, 0.04314578f, 0.00136379f, 0.07472079f, -0.12174794f, -0.16678900f, 
    -0.03342935f, 0.17349178f, 0.01578048f, -0.33298966f, -0.16106910f, -0.07410929f, 0.00352435f, -0.02054307f, 
    -0.04065808f, -0.07075386f, -0.04674399f, 0.05360691f, -0.25243074f, -0.12109874f, 0.11153124f, -0.48318297f, 
    -0.06670441f, -0.14608477f, -0.06615487f, -0.10762429f, -0.02271869f, 0.07251589f, -0.12468340f, 0.04072657f, 
    0.27578217f, 0.24527396f, 0.18177490f, 0.01977643f, 0.20311315f, -0.00957576f, 0.01103988f, 0.10881231f, 
    -0.01430140f, 0.05215692f, 0.15339708f, 0.01205472f, -0.06305029f, 0.23866190f, 0.21186098f, 0.02821854f, 
    0.15868905f, 0.06133729f, 0.05154414f, 0.10126086f, 0.10428795f, -0.00474105f, 0.04903961f, 0.07452134f, 
    -0.13282868f, -0.03575071f, 0.24248230f, 0.05632944f, -0.03536127f, 0.08612493f, 0.05906094f, -0.26348439f, 
    -0.14999318f, -0.12412577f, 0.00580934f, 0.14498137f, 0.35634091f, -0.10228047f, -0.08030243f, -0.15538470f, 
    -0.13369507f, -0.14074178f, -0.18805638f, 0.08159302f, 0.18711847f, -0.00310133f, 0.01054092f, 0.02617540f, 
    0.04523218f, -0.16631183f, 0.01908547f, -0.06868241f, 0.00892898f, -0.18148230f, -0.00520351f, -0.05897130f, 
    0.05139551f, -0.03214803f, -0.02284272f, -0.08353780f, -0.01506535f, -0.25735164f, -0.03233378f, 0.28658921f, 
    0.06175952f, 0.04080168f, -0.00774830f, 0.03851205f, 0.11931837f, -0.05242347f, -0.09312887f, 0.07789573f, 
    -0.33102110f, 0.19551466f, -0.01758764f, -0.25138289f, 0.05770195f, -0.07977760f, -0.04383167f, -0.03577866f, 
    -0.03431435f, -0.07899614f, -0.03981420f, -0.02420153f, 0.10662694f, 0.33132085f, -0.09649216f, 0.22033697f, 
    0.10440976f, 0.15594153f, 0.09657827f, 0.17460199f, -0.03069784f, 0.02073138f, -0.03058290f, -0.05403061f, 
    0.22592592f, -0.04751042f, 0.10314848f, -0.19989368f, -0.01925801f, -0.00799556f, -0.08665071f, -0.06080218f, 
    0.12960514f, -0.08750523f, -0.05316179f, -0.15826862f, -0.79720306f, -0.01887135f, -0.06741963f, 0.08205999f, 
    -0.22850996f, 0.05377628f, -0.04284982f, 0.01438325f, 0.10137288f, 0.15778829f, 0.04796118f, -0.07153212f, 
    -0.05345822f, 0.18899709f, 0.11338892f, 0.05446229f, 0.11112464f, 0.09693656f, 0.12482163f, -0.09767976f, 
    0.13513331f, -0.05962721f, -0.16373992f, -0.05056880f, -0.00472202f, -0.10114397f, -0.07295469f, 0.05023820f, 
    -0.24826775f, -0.24371177f, 0.04354094f, 0.03025381f, -0.13367797f, -0.08507594f, -0.00395554f, 0.05710700f, 
    0.24676767f, -0.11225864f, -0.11042868f, -0.01340798f, 0.02416929f, -0.01354777f, 0.02357377f, 0.10860395f, 
    -0.05545478f, -0.06564348f, 0.00991544f, 0.01282655f, 0.19072349f, 0.13122112f, 0.07365891f, 0.01541005f, 
    0.11138200f, -0.10709239f, 0.01631734f, -0.05071621f, -0.10519914f, -0.28328601f, -0.03288254f, -0.14162593f, 
    -0.13584498f, 0.25035247f, 0.03165327f, 0.20681709f, -0.01404772f, 0.07008889f, 0.00637929f, -0.02862791f, 
    0.04538679f, 0.07167680f, 0.11217420f, -0.00613732f, 0.07097796f, 0.00691584f, 0.00398696f, 0.02189758f, 
    0.00110969f, 0.04020867f, 0.02388442f, -0.01176586f, 0.02997502f, 0.09750291f, 0.05935585f, 0.05567634f, 
    -0.01940187f, 0.08132223f, -0.04257599f, -0.02666050f, -0.11679019f, 0.06058297f, -0.00810447f, -0.09896608f, 
    -0.10447064f, -0.10132637f, -0.07600577f, -0.10474092f, 0.02358436f, -0.20402998f, 0.06810184f, 0.03100819f, 
    -0.03924650f, -0.17401022f, -0.19200626f, 0.15867920f, -0.02020520f, -0.09055088f, -0.03729745f, 0.14389211f, 
    0.09912203f, -0.54052192f, -0.03798686f, -0.23459955f, -0.05086908f, -0.01457716f, 0.12265821f, 0.17738087f, 
    -0.06059506f, 0.07372836f, -0.17346478f, 0.07122331f, -0.03140559f, -0.04326043f, -0.05332068f, 0.08044139f, 
    0.06539071f, -0.15035701f, -0.00420061f, 0.10576963f, 0.00178089f, -0.10034699f, 0.08993895f, 0.01902772f, 
    0.09086930f, 0.04102152f, 0.00178483f, 0.13520493f, -0.02413098f, 0.08337802f, 0.01096562f, -0.03479676f, 
    0.04778446f, -0.21285558f, -0.06264668f, -0.01488671f, -0.03622198f, 0.08718001f, 0.21211846f, -0.09927852f, 
    -0.03924148f, 0.05984088f, 0.19814171f, 0.10049184f, -0.15067658f, 0.01471691f, 0.03412142f, -0.00400439f, 
    0.04623523f, 0.00824471f, 0.13764927f, -0.07504562f, 0.05617286f, 0.00904438f, 0.13301627f, 0.20263568f, 
    -0.15305501f, 0.06882140f, -0.05151853f, 0.29340738f, -0.29117236f, 0.06159643f, 0.10363286f, 0.22008945f, 
    0.27292556f, 0.12574594f, 0.12241422f, -0.06639598f, -0.00075995f, -0.04704580f, 0.16354133f, 0.06961549f, 
    0.13304086f, 0.07942774f, -0.09227768f, 0.03580598f, -0.07919414f, -0.18234104f, -0.00074407f, -0.10342249f, 
    -0.13117939f, -0.07795577f, 0.04088748f, 0.05420850f, 0.09104768f, 0.35941470f, -0.01266055f, 0.19617888f, 
    0.07469070f, -0.00182445f, 0.14936227f, -0.00638477f, -0.11647946f, -0.04547348f, 0.02883185f, -0.02529594f, 
    0.23494598f, 0.01761743f, 0.06273994f, -0.10429189f, 0.01504014f, 0.01546753f, -0.07632124f, 0.16617841f, 
    -0.12385008f, -0.08324222f, 0.03765305f, 0.04737784f, -0.08576082f, 0.02585874f, 0.00960868f, 0.14310686f, 
    -0.11880030f, -0.02689182f, -0.01792776f, 0.07205085f, 0.19148619f, 0.19166577f, 0.00611447f, 0.06351358f, 
    0.22419177f, 0.24019022f, 0.02600135f, -0.13461256f, -0.08107936f, -0.19717409f, -0.03335793f, -0.01439543f, 
    0.06891996f, 0.04608221f, -0.07201697f, -0.03515761f, 0.26240948f, -0.01194154f, 0.01149300f, -0.28563455f, 
    -0.08226545f, 0.01829788f, -0.17296892f, 0.11327305f, -0.01067426f, -0.01696961f, -0.17763585f, 0.00670155f, 
    0.00671777f, 0.05121128f, -0.03801112f, -0.12299333f, 0.01624950f, 0.05668918f, 0.17385100f, 0.03466216f, 
    -0.23515940f, -0.10481416f, -0.14627786f, 0.04426055f, -0.05272420f, -0.21955286f, 0.23902026f, -0.26075369f, 
    0.00266764f, -0.10675431f, -0.02136162f, 0.04486172f, -0.00168187f, 0.02016549f, -0.05211775f, 0.00663643f, 
    0.24002871f, 0.21418987f, 0.09972253f, 0.09088210f, 0.11997081f, -0.02337597f, -0.09012476f, 0.09572222f, 
    -0.07966971f, 0.02661006f, 0.08071065f, 0.05753406f, 0.08249252f, 0.27343446f, 0.00214815f, 0.01906538f, 
    0.02766382f, 0.13758767f, -0.05082319f, -0.01852909f, -0.11407597f, -0.02861611f, -0.06201588f, 0.11271670f, 
    0.08134350f, 0.21230540f, 0.18345693f, -0.00207552f, 0.15403013f, 0.22432417f, -0.08066911f, -0.11669633f, 
    0.14771597f, -0.08663471f, 0.09784327f, -0.21863203f, -0.07189365f, 0.12898147f, -0.15536989f, 0.02808254f, 
    -0.14421889f, -0.12801518f, -0.09431027f, 0.04756627f, -0.02166201f, -0.10143872f, 0.00857661f, -0.03227169f, 
    -0.01259990f, -0.10146461f, -0.13406342f, 0.04210511f, 0.01281505f, 0.00035175f, 0.19334771f, 0.13797492f, 
    0.00123069f, -0.00137155f, 0.07152610f, 0.05059336f, 0.00031567f, 0.07160738f, -0.00794321f, 0.00120430f, 
    0.05042402f, 0.07854504f, 0.10690402f, 0.10583723f, 0.08675709f, -0.02391026f, -0.01295041f, 0.02245914f, 
    -0.56972474f, 0.01970315f, -0.02014337f, -0.00092336f, 0.01122712f, 0.00182616f, 0.19226280f, 0.01339718f, 
    0.06948829f, 0.19818325f, -0.15565987f, 0.07928377f, 0.05870177f, 0.17797174f, 0.04261991f, 0.07002716f, 
    0.00820083f, -0.06050850f, 0.08549279f, 0.03924363f, -0.23497094f, -0.01513824f, -0.02922285f, 0.16709471f, 
    -0.03773348f, -0.01126968f, 0.00078844f, -0.01794748f, 0.00366187f, -0.01975548f, -0.01802551f, 0.01600702f, 
    -0.04814280f, -0.04342766f, 0.01853314f, -0.05423061f, 0.02839130f, -0.02531259f, 0.01771756f, 0.01812635f, 
    -0.01108992f, 0.01433141f, -0.00350262f, -0.04603253f, -0.06624819f, 0.01576627f, -0.06491560f, 0.00056672f, 
    0.00850629f, -0.02525514f, 0.03267162f, 0.01244417f, -0.03644864f, -0.00178374f, -0.02321757f, -0.05901973f, 
    -0.06940714f, -0.02441193f, 0.01107097f, -0.06151417f, -0.01613981f, -0.04037000f, -0.03426279f, -0.03228677f, 
    0.03115539f, -0.00152037f, -0.04216657f, -0.03432048f, 0.00371161f, -0.07375427f, -0.07518224f, 0.00321562f, 
    0.03269489f, -0.06736342f, 0.00308604f, -0.04073801f, -0.05058572f, -0.03669104f, -0.00998261f, -0.06337761f, 
    -0.01309705f, 0.02217217f, 0.01142299f, 0.02048850f, -0.03105222f, -0.07065231f, -0.03699864f, -0.01385150f, 
    0.00691215f, -0.00470124f, 0.01698294f, -0.04786764f, 0.02248923f, -0.01185738f, 0.02537107f, 0.01518406f, 
    0.01081842f, 0.02359334f, 0.02485851f, -0.03947930f, 0.03931638f, 0.00224614f, 0.02088509f, 0.05194342f, 
    0.00452006f, -0.02918407f, 0.03586839f, -0.03381688f, 0.02726898f, 0.00664593f, -0.01132822f, -0.02314527f, 
    -0.03457354f, 0.05153000f, 0.05838078f, -0.04071567f, -0.02023947f, 0.02799842f, 0.01489921f, -0.03656615f, 
    -0.05700321f, -0.06801701f, -0.00605009f, -0.04189677f, -0.01909172f, -0.01485931f, 0.02968342f, 0.00032842f, 
    -0.02185570f, -0.02564007f, 0.05933754f, 0.02683152f, -0.01171639f, -0.02556420f, -0.03861300f, -0.01265214f, 
    0.03377101f, -0.00934517f, -0.06930909f, 0.00581799f, -0.06381807f, -0.07244187f, 0.00986190f, -0.02427676f, 
    0.01565488f, 0.01417956f, -0.06764599f, -0.00971015f, -0.04218566f, -0.04173890f, -0.06746864f, -0.03126052f, 
    -0.02016881f, -0.01812474f, 0.00084402f, -0.03847606f, 0.00561789f, -0.06357356f, 0.02717746f, -0.02942579f, 
    -0.02742180f, -0.04862474f, -0.03685943f, -0.00042925f, 0.03917763f, -0.05399907f, 0.03823300f, -0.04299017f, 
    -0.03822064f, -0.07037717f, -0.02015031f, 0.01266812f, 0.00874441f, -0.04108211f, -0.03495634f, 0.00912430f, 
    0.00218461f, -0.00104030f, -0.02818839f, -0.04507908f, -0.05235418f, 0.03005688f, -0.03270316f, 0.00181598f, 
    -0.04523890f, -0.02135685f, -0.00620695f, -0.00234620f, -0.01067370f, -0.06651760f, -0.01717911f, -0.06500882f, 
    -0.06230548f, -0.07365639f, -0.01129957f, -0.01616325f, 0.00170136f, 0.01865634f, -0.03963922f, -0.06958551f, 
    -0.00326804f, -0.06061178f, -0.06651332f, -0.02984878f, -0.03559286f, -0.04203757f, -0.02316112f, -0.03343854f, 
    -0.04638838f, 0.01571533f, -0.01088578f, -0.06611274f, -0.02833093f, -0.03282259f, 0.02603433f, -0.02736134f, 
    0.00163421f, 0.01168223f, -0.05341527f, -0.05874035f, 0.03995873f, -0.05959529f, -0.01819843f, 0.03296716f, 
    -0.06789274f, -0.07679427f, -0.07425250f, -0.03182314f, -0.00686411f, -0.02589793f, -0.04767798f, 0.00963333f, 
    -0.03731431f, -0.02285425f, -0.02353086f, -0.02851870f, 0.00937691f, -0.04211561f, -0.04594157f, 0.03274073f, 
    -0.00086351f, 0.00604265f, 0.02213752f, -0.02685281f, 0.02056078f, 0.01722058f, -0.00255578f, -0.04686396f, 
    0.04021996f, 0.00532124f, 0.00660708f, 0.04040797f, -0.05651904f, -0.05263114f, 0.02299147f, -0.02151395f, 
    0.01076359f, 0.00169922f, 0.04768711f, 0.01657546f, -0.05621352f, -0.05153066f, 0.02235326f, -0.06346095f, 
    -0.04068523f, -0.05565062f, -0.02237858f, -0.01931126f, 0.01704293f, -0.07776958f, 0.00078074f, -0.02982302f, 
    -0.00664634f, -0.00232671f, 0.01555655f, -0.04165779f, 0.00899395f, 0.03817872f, -0.03262030f, 0.00659918f, 
    -0.00707174f, -0.07897320f, -0.01433071f, 0.00713608f, 0.02777358f, -0.04800747f, 0.00202527f, -0.04106382f, 
    -0.01510862f, -0.05287059f, 0.00933329f, -0.02176584f, 0.02437809f, 0.00404233f, -0.06860556f, -0.03495763f, 
    0.03845904f, -0.01363505f, -0.01395660f, -0.00404434f, -0.01475882f, 0.02951539f, 0.02224151f, -0.04403813f, 
    0.02782785f, -0.01722547f, -0.04018655f, -0.02498775f, 0.02364655f, -0.01926387f, -0.06402472f, -0.06108495f, 
    -0.05288145f, -0.01857722f, 0.00122332f, -0.02196345f, -0.05799337f, -0.06255068f, -0.04937559f, -0.03310543f, 
    0.04887791f, -0.00018603f, -0.05352645f, 0.03359660f, 0.00700836f, -0.07472411f, 0.00289643f, -0.04207749f, 
    -0.05368124f, -0.03197226f, -0.02562561f, -0.02052408f, 0.08629652f, -0.00598593f, 0.04921251f, 0.04956131f, 
    -0.08155817f, 0.03068671f, -0.02263266f, 0.00408714f, -0.00786396f, 0.04535485f, -0.03440517f, -0.01488290f, 
    0.02459987f, -0.01417547f, -0.04410399f, -0.03778392f, -0.04796849f, -0.02616940f, -0.00608552f, -0.00814291f, 
    -0.03562229f, -0.02671068f, -0.03996434f, 0.01247887f, -0.02848005f, -0.01373951f, -0.01862337f, -0.04735949f, 
    0.04437910f, -0.02219945f, -0.02483472f, -0.02726511f, 0.02847938f, 0.00319735f, 0.00933322f, 0.04794125f, 
    0.02206958f, -0.02507234f, 0.01084984f, 0.01254982f, -0.00101459f, -0.02935791f, -0.05190627f, 0.01950156f, 
    -0.05531684f, -0.01141283f, 0.04008138f, 0.05159475f, -0.01492717f, 0.00212330f, -0.01302664f, 0.04453322f, 
    -0.02071771f, -0.06266075f, -0.02505246f, -0.04965400f, -0.06715900f, -0.04356850f, -0.05936385f, -0.05970409f, 
    0.01472288f, -0.05657142f, -0.07861759f, -0.01009055f, -0.03919383f, -0.07080638f, -0.04795368f, -0.06288362f, 
    0.01681703f, -0.05768368f, 0.00856587f, 0.01722860f, 0.05440423f, -0.02554801f, 0.05295285f, 0.03089227f, 
    0.03746077f, -0.02391500f, -0.01084775f, -0.05176406f, -0.05063457f, 0.02723209f, -0.03022451f, -0.03291185f, 
    0.02036834f, 0.00552422f, 0.03017385f, -0.03115438f, 0.03608438f, 0.01644861f, -0.04966859f, -0.03806999f, 
    0.05132463f, 0.03079905f, -0.03567025f, -0.04648598f, 0.03253017f, -0.02076972f, -0.04239241f, -0.00441261f, 
    -0.01681077f, -0.05640064f, 0.04311123f, -0.03791518f, -0.01551682f, -0.02194726f, 0.00156114f, 0.03091385f, 
    0.02381322f, -0.02050393f, 0.02490684f, 0.02685028f, -0.03777464f, -0.01786790f, -0.02272100f, -0.01593171f, 
    0.02761499f, 0.00982953f, 0.01101859f, 0.00732853f, -0.02929683f, -0.05819643f, 0.00043836f, -0.01425388f, 
    -0.02449365f, -0.00653366f, -0.03193014f, -0.02649435f, -0.01067644f, -0.01413212f, -0.04466284f, -0.01497548f, 
    0.01172884f, 0.01599162f, -0.04527416f, -0.03273772f, -0.02890505f, 0.02903263f, 0.04549547f, 0.03241625f, 
    0.04552828f, -0.03598753f, -0.04154921f, -0.04857548f, 0.00449823f, -0.01877569f, 0.01172091f, -0.04131277f, 
    0.04062385f, -0.02772671f, -0.00974073f, 0.02903790f, -0.02442845f, -0.01222154f, -0.00330110f, -0.04864998f, 
    0.03921349f, 0.04550111f, 0.03727960f, 0.03014082f, 0.03670947f, -0.01619660f, 0.01337818f, 0.01862927f, 
    -0.02144601f, 0.00555056f, 0.00046220f, 0.01153584f, 0.03815189f, 0.01367540f, -0.05126688f, -0.00477825f, 
    -0.05301458f, 0.04392371f, -0.00701628f, -0.03433206f, 0.04758581f, 0.02910281f, 0.04506823f, 0.00061003f, 
    -0.04130942f, 0.03894789f, -0.03146552f, -0.00635431f, 0.03265394f, -0.03900010f, -0.03946541f, 0.00545828f, 
    0.04480601f, 0.01364554f, 0.01585211f, -0.05556332f, 0.04541325f, -0.04248726f, 0.00109629f, -0.04704595f, 
    -0.04043431f, -0.05810609f, 0.04240191f, 0.00935707f, -0.03352273f, 0.02964893f, 0.04027103f, -0.00702136f, 
    -0.01110592f, -0.04998571f, -0.01795724f, -0.03295694f, -0.01567207f, -0.00512135f, -0.05538823f, -0.00378631f, 
    -0.04335983f, -0.02310559f, -0.03240630f, -0.00097258f, -0.04063145f, -0.02177153f, -0.00532780f, 0.03845302f, 
    0.03972227f, 0.01056073f, 0.02867923f, 0.03457233f, 0.03692263f, 0.00376898f, 0.00397129f, -0.02759056f, 
    -0.05305418f, 0.02696065f, 0.02260889f, 0.05331547f, 0.02599232f, -0.02730425f, 0.02308408f, 0.04135589f, 
    0.00869264f, -0.04433445f, 0.02526686f, -0.02466082f, 0.03369651f, 0.00349241f, 0.00200709f, -0.00161561f, 
    0.02961997f, -0.01223978f, 0.03860085f, -0.03930929f, 0.01757788f, -0.05031604f, 0.01815183f, -0.02724838f, 
    -0.00703978f, 0.03679609f, -0.02625016f, -0.05207914f, 0.01368923f, 0.03418317f, 0.03148444f, 0.03843151f, 
    0.01189729f, -0.03886886f, -0.04810912f, 0.00426789f, 0.02192487f, -0.01566078f, -0.03185080f, -0.05693808f, 
    0.02408519f, -0.02637288f, -0.04634163f, 0.04389261f, -0.04279659f, -0.02183225f, -0.04294330f, -0.02641042f, 
    -0.04419686f, -0.00908470f, -0.05185533f, 0.03841219f, 0.03934477f, -0.03522300f, 0.00757780f, -0.00922718f, 
    -0.00972726f, -0.04526665f, 0.01240043f, -0.04246436f, 0.01438365f, -0.03858095f, -0.01663086f, -0.03086899f, 
    0.00067277f, -0.04047735f, 0.04741567f, -0.03924841f, -0.00258689f, -0.05070460f, -0.01915698f, -0.02204502f, 
    -0.05290237f, -0.02721935f, -0.05126305f, -0.03676105f, -0.04409696f, 0.00198559f, -0.02287599f, 0.01774403f, 
    -0.05177696f, -0.04701847f, -0.05391895f, 0.00136284f, -0.04346368f, 0.03521373f, 0.03499294f, -0.02939048f, 
    -0.02943007f, 0.02547577f, -0.01352805f, -0.02069697f, -0.03474650f, 0.03479554f, -0.01496765f, -0.00865013f, 
    -0.00828711f, 0.04198297f, -0.00946389f, 0.02724337f, -0.03366407f, -0.05592428f, 0.03580998f, -0.03314962f, 
    0.00888226f, 0.02511760f, -0.03528519f, 0.04631018f, 0.01165376f, -0.05751385f, -0.03854889f, 0.03569576f, 
    0.01169759f, 0.03605146f, 0.01698652f, -0.03053301f, 0.01343329f, -0.04847410f, -0.00398762f, -0.00010267f, 
    -0.01780392f, 0.01260813f, -0.00537740f, -0.01705450f, 0.00186438f, -0.00353709f, -0.02818497f, -0.01012267f, 
    0.01904215f, 0.03066540f, -0.00582868f, 0.03434350f, 0.01357683f, 0.00454844f, 0.01628101f, -0.02893323f, 
    -0.00847473f, -0.01546300f, -0.02224142f, -0.04420788f, -0.01770381f, 0.01826590f, -0.03007679f, -0.03230834f, 
    -0.02096379f, -0.01426305f, -0.04715356f, 0.00904664f, -0.05055652f, 0.03237534f, -0.01076334f, 0.01879847f, 
    -0.05076481f, -0.04983927f, -0.03876095f, 0.00809721f, 0.00660193f, 0.00232604f, -0.02221123f, 0.00564806f, 
    0.00474218f, 0.01853558f, -0.01455268f, -0.01969040f, -0.01446165f, 0.00293874f, 0.02491906f, -0.02857525f, 
    -0.01624558f, -0.05149816f, 0.01959310f, 0.01723027f, 0.03434272f, 0.00960127f, -0.01416100f, 0.03417367f, 
    0.04003446f, -0.05106520f, 0.01256478f, -0.00686476f, -0.03811559f, 0.04055558f, 0.02916766f, -0.04172695f, 
    -0.01594546f, -0.02694756f, 0.01149455f, -0.00594024f, 0.01174835f, -0.00518324f, 0.02351511f, -0.01361860f, 
    -0.05412457f, -0.04100043f, -0.04839775f, -0.04820319f, -0.02214253f, -0.02976978f, -0.00440298f, 0.03281087f, 
    0.01896689f, -0.04051834f, -0.01718825f, -0.03427148f, 0.04199497f, 0.01873968f, -0.03713132f, -0.01479255f, 
    0.00930517f, -0.01484450f, -0.01632708f, 0.00007487f, -0.01708659f, -0.05472200f, 0.02481116f, -0.00756262f, 
    0.03939859f, -0.03193732f, 0.01528419f, -0.00950660f, 0.02194269f, 0.00598382f, 0.04028150f, 0.02247827f, 
    -0.00668528f, 0.04876402f, -0.03986155f, -0.02895026f, -0.02869973f, -0.05654086f, -0.03322088f, -0.03735474f, 
    0.27193379f, -0.05063618f, -0.13982630f, -0.09219909f, 0.05848743f, 0.26756337f, -0.00953553f, -0.11427258f, 
    -0.05789121f, -0.08405714f, 0.01031314f, -0.00278893f, 0.05496293f, 0.09282128f, 0.08312401f, 0.06096080f, 
    0.02265501f, -0.05997684f, -0.03045264f, -0.09230772f, -0.17035876f, -0.12932861f, -0.16321664f, 0.06987265f, 
    0.13645153f, -0.05849461f, -0.02236239f, -0.00237901f, -0.08022880f, 0.01986256f, -0.05666578f, 0.06324968f, 
    0.09745701f, -0.01194660f, 0.05676055f, -0.02273206f, -0.32083723f, 0.00249148f, -0.22782226f, -0.09753747f, 
    -0.00363967f, 0.02863874f, -0.03715437f, -0.03681172f, 0.00537142f, 0.02020929f, -0.00668711f, -0.14779286f, 
    0.00831517f, -0.05330689f, 0.03387412f, -0.16105546f, -0.09078739f, -0.14304961f, -0.21093474f, -0.15773524f, 
    -0.15975615f, -0.24926038f, -0.19398037f, 0.11483938f, 0.30070826f, 0.13172424f, 0.08908109f, 0.04015944f, 
    0.12067386f, 0.23421481f, -0.16291845f, -0.11301208f, 0.08217452f, 0.06709372f, 0.04601924f, 0.10213365f, 
    0.01964087f, -0.08374241f, -0.15039676f, -0.02173016f, 0.10421656f, 0.12437829f, -0.02157083f, 0.02376525f, 
    -0.27250835f, 0.14622559f, -0.12971084f, 0.14631271f, -0.04758111f, -0.06753143f, 0.09999916f, 0.00220800f, 
    0.04355882f, 0.03708950f, 0.00795976f, 0.03758912f, -0.00387623f, -0.01178468f, 0.04587011f, -0.05224779f, 
    0.11823723f, 0.08998266f, 0.06567644f, 0.13480169f, 0.02165034f, -0.14910604f, -0.02256732f, 0.14036566f, 
    0.11451169f, 0.08416924f, 0.07518106f, -0.00603494f, -0.27331570f, 0.02854047f, -0.04130531f, -0.12147348f, 
    0.05142320f, -0.07935335f, -0.02485638f, -0.02109784f, -0.05536094f, -0.03954010f, -0.07172158f, 0.03522012f, 
    -0.01875184f, -0.04459525f, 0.06246012f, 0.15653867f, -0.01574607f, 0.03944739f, -0.02031578f, 0.07973235f, 
    0.00903975f, -0.00683453f, 0.05074956f, 0.00375465f, -0.03927214f, 0.02768973f, -0.02849020f, -0.01866002f, 
    -0.07456029f, -0.01234090f, -0.07419988f, -0.04398176f, 0.07107676f, 0.08649719f, -0.04108113f, 0.09595617f, 
    0.29610726f, 0.17663516f, -0.12809548f, 0.08041823f, 0.07437904f, 0.02039121f, -0.01369270f, -0.00834596f, 
    -0.20258479f, 0.16342433f, 0.24032180f, 0.17630993f, 0.23544608f, -0.13744827f, -0.16971460f, 0.00875610f, 
    0.25648066f, -0.00958518f, 0.05093307f, 0.13539253f, 0.22060548f, -0.08700158f, 0.13226053f, 0.11687793f, 
    0.03620595f, -0.01158150f, 0.17217557f, 0.19350277f, -0.23155901f, -0.00403450f, -0.21571378f, -0.12467607f, 
    0.03383058f, -0.05454276f, -0.00437640f, -0.08111824f, -0.07803246f, -0.04120103f, -0.10476584f, -0.08536835f, 
    -0.06892061f, -0.06568006f, -0.13397610f, 0.04751441f, 0.05762351f, 0.02720218f, -0.06038780f, 0.10433460f, 
    -0.09307573f, -0.10006641f, 0.06463078f, -0.00217559f, 0.05749903f, 0.05553141f, 0.00839803f, 0.02443450f, 
    -0.21258028f, -0.01330203f, -0.23310512f, -0.10648911f, -0.01227876f, 0.05198526f, -0.02787589f, -0.04042165f, 
    -0.32638422f, -0.02628850f, -0.02114151f, 0.09927420f, 0.12783349f, 0.18528767f, 0.03744477f, 0.04946313f, 
    0.09007477f, 0.04992832f, 0.05370368f, 0.09857846f, -0.23483469f, -0.45312214f, -0.17173401f, -0.31886557f, 
    0.05395281f, 0.05437451f, 0.01616840f, -0.00733479f, 0.09230019f, 0.04266495f, -0.00761413f, -0.11789349f, 
    0.03898541f, 0.02271840f, 0.09745205f, 0.01479729f, -0.29985002f, -0.03909015f, -0.15397391f, -0.07372564f, 
    -0.01643773f, -0.02162237f, 0.00909494f, -0.01523634f, 0.30393931f, 0.04622348f, 0.09227192f, 0.08518891f, 
    -0.15500896f, -0.04946757f, 0.01085911f, -0.02731130f, -0.02853111f, -0.18449816f, 0.09973181f, 0.00439076f, 
    -0.13032007f, -0.08197265f, -0.17218430f, 0.11956530f, 0.16145642f, 0.07426290f, 0.00191569f, 0.06157992f, 
    -0.06807248f, -0.07385202f, -0.09853509f, -0.12454140f, 0.16420560f, 0.01128022f, 0.09636240f, 0.07502011f, 
    0.00317486f, -0.01498750f, 0.04112028f, 0.03719356f, -0.10640932f, -0.05694683f, -0.06742286f, 0.02772100f, 
    0.04096908f, 0.00879951f, -0.08567051f, 0.04303363f, -0.11170743f, 0.01194401f, -0.09990761f, 0.03053078f, 
    0.00570600f, -0.00900278f, 0.16112575f, 0.11837042f, 0.20407653f, 0.12439743f, -0.08282729f, -0.14372917f, 
    -0.27208939f, -0.07540642f, 0.02312304f, -0.08777856f, -0.14021079f, -0.15463422f, -0.09949101f, -0.00448744f, 
    -0.16017114f, -0.06470519f, -0.19943868f, -0.20179021f, -0.09052049f, -0.08081070f, -0.05987182f, 0.11119182f, 
    0.15800601f, -0.13281423f, -0.11839222f, -0.23612420f, 0.15224287f, 0.00017385f, -0.11757737f, 0.00482933f, 
    0.03749295f, 0.05329275f, -0.06756052f, 0.16321418f, 0.16944893f, -0.20956312f, 0.05694216f, 0.04391991f, 
    0.08872852f, 0.03824097f, 0.04264709f, 0.06028130f, -0.14623162f, -0.10354600f, -0.00817270f, 0.01914761f, 
    -0.06145472f, -0.01680534f, 0.01763678f, -0.18671054f, 0.06614551f, 0.00733549f, 0.07611999f, -0.01454323f, 
    0.07592231f, -0.05062202f, -0.10293513f, -0.21931617f, 0.01164118f, -0.04573590f, 0.00807890f, 0.03952283f, 
    -0.06020487f, 0.02680737f, 0.06711330f, 0.02086452f, 0.08217589f, 0.09530909f, 0.04038662f, 0.02635124f, 
    0.15594311f, -0.11448511f, -0.21134762f, -0.01814033f, 0.03978166f, 0.02697976f, -0.08968677f, -0.16801077f, 
    -0.02290493f, -0.06154740f, 0.07604245f, 0.02200659f, -0.00683692f, -0.03157042f, -0.01562798f, 0.02362074f, 
    0.21950591f, 0.17584917f, -0.22921790f, -0.02519356f, 0.00235788f, -0.04788576f, -0.02248154f, -0.09407863f, 
    0.03594590f, -0.04710454f, -0.00835968f, 0.04311429f, 0.00288712f, -0.05200196f, 0.04209793f, -0.00618798f, 
    -0.03486003f, 0.03165266f, 0.01398868f, 0.02545593f, 0.02526909f, -0.03120478f, -0.04167372f, -0.03618953f, 
    -0.04916865f, -0.03193020f, 0.03912324f, -0.00354104f, -0.02333699f, -0.03046854f, -0.04573521f, 0.03874560f, 
    -0.03476037f, -0.04129029f, 0.04093378f, -0.04810228f, 0.03742157f, 0.02265784f, -0.02447892f, 0.00283136f, 
    -0.05095926f, 0.03574647f, -0.03021543f, 0.03643527f, -0.05496745f, 0.00330590f, 0.03200065f, -0.04853790f, 
    0.01919886f, 0.01712381f, -0.01660106f, 0.03386137f, -0.04195307f, 0.02943099f, 0.00641270f, -0.05382136f, 
    -0.00063511f, 0.00061477f, 0.03885499f, 0.01871267f, 0.00630156f, -0.04976379f, -0.03113527f, -0.01465146f, 
    -0.05179070f, 0.01319594f, 0.00414673f, 0.02209914f, 0.04144125f, -0.03466092f, 0.01980343f, 0.01327462f, 
    -0.02718432f, -0.00490898f, -0.03676197f, 0.03416870f, -0.01637873f, -0.03240115f, -0.02695872f, -0.04173319f, 
    -0.03332800f, -0.02401191f, -0.04599790f, 0.03515249f, -0.00861496f, -0.05336250f, 0.04060061f, -0.02838077f, 
    -0.03295535f, 0.01967638f, -0.04754929f, 0.02129763f, 0.00569510f, -0.03368190f, 0.02958391f, 0.02855971f, 
    -0.03678902f, 0.01900755f, -0.04259923f, -0.04660450f, -0.03190526f, -0.01763833f, 0.01446548f, -0.01332686f, 
    -0.00466231f, -0.05479329f, 0.00251688f, -0.01907744f, 0.02039853f, -0.05554347f, -0.01733802f, -0.01480729f, 
    0.01708947f, -0.03437834f, -0.04186329f, 0.00713196f, -0.04958810f, -0.01163649f, 0.00380516f, -0.02808726f, 
    -0.03363729f, -0.02182622f, -0.04054641f, -0.03788268f, 0.01055150f, -0.00196019f, 0.00960676f, -0.01009067f, 
    -0.00816921f, 0.03416918f, -0.03300451f, 0.04371247f, -0.04276640f, 0.00129412f, 0.02639620f, -0.03890784f, 
    -0.02664902f, -0.04055055f, 0.03805510f, -0.00141924f, -0.01377466f, 0.04229165f, 0.00157444f, 0.01063417f, 
    -0.05599985f, 0.01744131f, 0.01774012f, -0.03012458f, -0.04002401f, 0.02820984f, -0.02811605f, 0.00755460f, 
    -0.04366964f, -0.03231302f, -0.03829823f, 0.03996582f, -0.04550945f, -0.03443984f, -0.04681583f, 0.01432989f, 
    -0.00679416f, 0.03144439f, 0.04073922f, 0.03987481f, 0.02324023f, 0.00556758f, 0.01069093f, -0.00235084f, 
    -0.02355253f, -0.02374198f, 0.01794486f, 0.03007684f, 0.01225853f, -0.04198572f, -0.01778751f, 0.01392862f, 
    -0.04532499f, -0.00536169f, 0.01301428f, -0.05210519f, -0.04566274f, 0.00298938f, -0.01100016f, -0.05109575f, 
    0.03711494f, -0.00169548f, 0.02923901f, 0.00294551f, 0.02184950f, 0.00941376f, -0.04068651f, -0.00415251f, 
    -0.02765838f, -0.04579931f, -0.05364176f, -0.05664520f, -0.04394483f, 0.00955070f, -0.02894599f, 0.01624889f, 
    -0.03172774f, 0.03302249f, -0.02238234f, -0.02705000f, -0.04972059f, 0.04465253f, 0.02847709f, 0.01149042f, 
    -0.00139428f, 0.00727258f, -0.00256043f, -0.05177064f, -0.04121384f, -0.04885778f, 0.01660053f, -0.00719229f, 
    -0.03146179f, -0.01190580f, -0.04223631f, 0.01856730f, 0.02272361f, 0.00096250f, -0.04941967f, -0.05193743f, 
    0.04347910f, -0.05604208f, 0.03532620f, 0.02735966f, -0.03026845f, -0.03474891f, -0.00664487f, -0.03630380f, 
    0.03607253f, 0.03254888f, -0.02157594f, 0.02092141f, -0.03819841f, 0.02303075f, -0.00723706f, 0.00585589f, 
    0.01278551f, 0.01499507f, -0.03779208f, -0.02795263f, -0.03668810f, 0.03179252f, -0.03922012f, -0.04526141f, 
    -0.01636392f, 0.03856833f, -0.01960857f, -0.02961869f, 0.02176976f, -0.05188310f, -0.04092887f, 0.02775534f, 
    0.03173098f, 0.00584531f, 0.01649082f, 0.04339733f, 0.01424399f, 0.00791718f, 0.01013835f, 0.00396259f, 
    -0.03453143f, 0.00442348f, -0.02411065f, 0.02149638f, -0.00217002f, 0.02840918f, -0.04326497f, -0.01803011f, 
    0.02152549f, -0.02752973f, 0.02562068f, 0.04308295f, -0.03802133f, 0.02752056f, -0.03746909f, -0.02322440f, 
    0.01058401f, -0.00422050f, -0.01349704f, 0.00319555f, 0.01457662f, 0.01544690f, -0.00541202f, 0.00896893f, 
    -0.00559120f, -0.05007583f, 0.03250988f, 0.04219578f, 0.01179895f, 0.00469904f, 0.03423871f, 0.00877872f, 
    0.01705603f, 0.02104647f, 0.01325022f, -0.03622041f, 0.01192355f, 0.02214223f, 0.02705105f, -0.03925089f, 
    -0.04800766f, 0.01855640f, 0.01726764f, -0.03472929f, -0.00015640f, 0.00235005f, 0.01845366f, -0.02673618f, 
    0.03691259f, 0.01307087f, 0.01551586f, -0.05254070f, 0.00891976f, 0.03144026f, -0.04612568f, 0.02848126f, 
    -0.02417025f, 0.01106858f, 0.01313545f, -0.03635414f, -0.05714894f, -0.02623153f, -0.01172376f, -0.03848364f, 
    -0.03446735f, 0.01752443f, -0.05402656f, -0.00108809f, -0.04303227f, -0.00758235f, -0.03808641f, -0.02829633f, 
    -0.01639461f, -0.01595424f, 0.02796723f, -0.04301978f, -0.01383030f, -0.04974426f, -0.03686006f, -0.00663076f, 
    -0.00851491f, -0.04617135f, -0.00323053f, 0.00871466f, -0.00871209f, -0.04435842f, 0.00257071f, 0.03297614f, 
    0.01319758f, 0.00409028f, -0.04862740f, -0.00828666f, -0.03825816f, -0.02972907f, 0.00669349f, -0.03143157f, 
    -0.02692259f, -0.01315972f, -0.02161007f, -0.04993885f, -0.00579143f, -0.03466258f, -0.00608280f, 0.02381475f, 
    -0.04559733f, -0.01316154f, 0.02576775f, 0.03220125f, 0.00256575f, 0.03234445f, 0.00892833f, 0.00670592f, 
    -0.00685699f, 0.03523012f, -0.02386543f, 0.03121420f, 0.01104287f, 0.00635663f, 0.02646104f, 0.04488974f, 
    0.03079610f, -0.05294697f, -0.00590841f, -0.03416226f, 0.03167993f, -0.04199358f, 0.01998146f, 0.03045443f, 
    0.02311650f, 0.01900183f, -0.02054181f, 0.02482233f, 0.00899112f, 0.01958692f, -0.02986261f, -0.05431238f, 
    -0.01836081f, 0.02296298f, -0.05720659f, 0.02854665f, -0.04621932f, -0.05373451f, 0.01695024f, 0.01641802f, 
    0.02997110f, 0.00053546f, -0.04076093f, -0.02290102f, 0.02643599f, -0.05848583f, -0.05364304f, -0.05476543f, 
    0.00960035f, 0.01082248f, 0.01214358f, 0.00785709f, 0.03279049f, 0.00227154f, -0.00645874f, -0.03964610f, 
    -0.04724306f, -0.01000895f, 0.01274356f, 0.00182119f, -0.04395298f, 0.04177562f, 0.02570901f, 0.00715104f, 
    0.01674401f, -0.05400703f, 0.02435523f, 0.02547619f, 0.00634452f, 0.00977192f, 0.01013040f, -0.05062827f, 
    0.01390326f, -0.00493942f, 0.03483731f, 0.02853470f, -0.02197950f, -0.05647716f, -0.01530923f, -0.04688428f, 
    0.03555496f, -0.00152529f, -0.02637609f, -0.02612962f, -0.00797064f, -0.01238239f, -0.04180169f, -0.02470986f, 
    0.02089661f, 0.03203600f, -0.03878679f, 0.00699210f, 0.03121226f, 0.00536793f, -0.01629836f, 0.03615993f, 
    0.01254783f, -0.03113832f, -0.00586858f, -0.05254090f, 0.02527424f, 0.03146568f, 0.02019510f, -0.03639423f, 
    -0.01032672f, 0.00247706f, -0.04560944f, 0.01235413f, -0.03219633f, -0.05693991f, 0.00551949f, -0.00803675f, 
    -0.04116215f, 0.01918530f, 0.01239252f, -0.04153404f, -0.00903588f, -0.02961409f, 0.01885080f, 0.01863566f, 
    -0.04606332f, 0.02304940f, -0.02366379f, -0.02246623f, -0.02405934f, -0.01803266f, 0.02297226f, 0.01421047f, 
    -0.00437512f, 0.01807269f, -0.05462372f, 0.01878459f, -0.05488905f, 0.00721386f, 0.03254235f, -0.02307867f, 
    -0.05329161f, -0.02749308f, 0.01873587f, 0.00336377f, -0.00932927f, -0.05428110f, -0.00837006f, -0.05937609f, 
    -0.01820497f, -0.03987762f, 0.01502713f, 0.01099502f, 0.01987727f, 0.02633411f, 0.03529731f, -0.00211554f, 
    -0.05095047f, -0.01267625f, -0.04415550f, 0.02778976f, 0.01255662f, 0.01096319f, 0.01650441f, 0.03713938f, 
    -0.00890085f, 0.01804651f, -0.04286554f, 0.03423227f, -0.03592014f, 0.03538436f, -0.02669402f, 0.02324468f, 
    -0.05769883f, 0.00560452f, -0.04075484f, 0.02333567f, 0.03537033f, 0.03671622f, 0.01705161f, 0.00517003f, 
    -0.00093272f, 0.00421803f, -0.03819752f, -0.03152488f, -0.01295253f, -0.03438069f, 0.03030122f, -0.01250266f, 
    0.03495530f, -0.00557971f, -0.02407555f, -0.03909763f, -0.04403490f, -0.01027525f, 0.00927862f, -0.05171210f, 
    -0.05438790f, 0.01481973f, -0.04705911f, 0.01744175f, 0.00537995f, -0.05322041f, 0.02474038f, -0.00325754f, 
    0.02265823f, -0.01256785f, -0.04629814f, 0.00925785f, 0.03435646f, -0.04179477f, 0.03885138f, 0.00919337f, 
    -0.01437945f, 0.01365407f, 0.00913790f, -0.01064364f, -0.00794838f, 0.03913780f, 0.01910132f, -0.03867792f, 
    -0.02056579f, 0.03229933f, -0.05029599f, -0.00533630f, 0.02754851f, -0.03324102f, 0.03990338f, -0.01237623f, 
    -0.02515204f, -0.05208151f, -0.05387406f, 0.02064202f, -0.00359648f, -0.04266898f, 0.04285615f, -0.00625555f, 
    0.03640723f, -0.01855087f, -0.01303294f, -0.01346159f, -0.00293044f, -0.02585525f, -0.02641525f, -0.01866638f, 
    -0.02672064f, -0.00782797f, 0.03384998f, 0.02341345f, -0.02395097f, -0.03549155f, -0.05577901f, -0.04903899f, 
    -0.05370373f, -0.01554020f, -0.00582988f, 0.02067148f, -0.03685013f, -0.02820667f, 0.00803247f, -0.01487617f, 
    -0.05525423f, -0.03617400f, 0.03933261f, -0.02660188f, 0.03675064f, 0.02808665f, -0.05782341f, 0.01699138f, 
    -0.04378543f, 0.01025396f, 0.00800568f, 0.04216155f, 0.03169499f, -0.03133668f, 0.03507347f, -0.02219811f, 
    0.01372521f, 0.01907299f, -0.04250387f, -0.00395852f, -0.04982471f, -0.00431934f, -0.01655929f, -0.02510426f, 
    -0.03604375f, -0.03058744f, -0.05764599f, -0.04455366f, -0.03431778f, -0.00492467f, -0.02404879f, -0.04062817f, 
    -0.05594350f, -0.05413417f, 0.01218677f, -0.05614459f, -0.03390689f, 0.01551238f, -0.04097646f, -0.05259242f, 
    0.00776151f, 0.03304168f, 0.01710308f, -0.05427682f, -0.04772005f, 0.03946261f, 0.04346713f, -0.04054869f, 
    -0.01540274f, 0.02293528f, -0.02722381f, -0.03498915f, -0.03868870f, 0.01692415f, 0.03343295f, -0.04760009f, 
    0.03772767f, -0.04000568f, 0.04009240f, -0.03837878f, -0.03792951f, -0.05508244f, 0.00974201f, 0.00528622f, 
    0.03419850f, 0.00775097f, -0.03714813f, -0.03180972f, -0.00018810f, -0.02421432f, -0.00301746f, -0.00078762f, 
    0.01447949f, 0.01650816f, 0.03365522f, 0.03228163f, -0.03555842f, -0.04611261f, -0.02758283f, 0.03760452f, 
    -0.02833360f, -0.03375886f, 0.04299552f, 0.00811083f, -0.05444871f, -0.01489436f, 0.03713845f, -0.03737031f, 
    -0.03865784f, 0.02589759f, 0.04245280f, -0.02288574f, 0.04354446f, 0.01344254f, -0.04771271f, -0.04449851f, 
    0.02525177f, -0.04825858f, 0.01722223f, -0.02416104f, 0.02865587f, -0.01964332f, -0.00374046f, 0.00193985f, 
    -0.04679028f, -0.02752754f, 0.04002417f, 0.00545352f, 0.01901432f, -0.03460192f, -0.02834306f, 0.01199637f, 
    -0.03514150f, 0.02546953f, 0.03955018f, -0.04658476f, 0.01465821f, 0.01012987f, 0.03854866f, -0.04004208f, 
    -0.01045407f, -0.01905722f, -0.02017404f, -0.02883909f, -0.01835554f, 0.00744073f, -0.02832397f, -0.04914838f, 
    0.01722579f, -0.00450422f, 0.00528155f, 0.03643412f, -0.01269270f, 0.00878414f, 0.01635180f, 0.03943562f, 
    -0.03179346f, -0.03291396f, -0.01538754f, 0.02095546f, -0.05338920f, 0.02742083f, -0.03072837f, 0.01929958f, 
    -0.03688517f, -0.05300056f, -0.02029449f, -0.03406100f, 0.02535113f, -0.05083585f, -0.02873381f, -0.04336982f, 
    0.38169008f, 0.24886969f, -0.24889633f, -0.41242436f, 0.08866466f, 0.10186818f, -0.04677362f, -0.18561104f, 
    -0.02224160f, -0.00896018f, 0.05706261f, -0.09406851f, 0.07610976f, 0.07170671f, 0.10687979f, -0.02926284f, 
    0.05043973f, 0.04043849f, -0.08363356f, 0.01858637f, -0.16020700f, 0.16181739f, 0.03166820f, 0.25753120f, 
    0.11012635f, -0.06481975f, 0.05226605f, 0.02219185f, -0.06749711f, -0.04360711f, 0.07964342f, 0.08177435f, 
    0.00115878f, -0.15174790f, 0.06761397f, -0.07466840f, -0.50158978f, 0.01887976f, 0.11625104f, 0.36386698f, 
    -0.10171449f, -0.08038387f, -0.10408208f, -0.03454610f, -0.08633860f, 0.00507171f, -0.00115426f, -0.00362289f, 
    0.26563799f, 0.23794118f, -0.36144042f, -0.10250912f, 0.19874468f, 0.03410934f, 0.15893199f, -0.09033438f, 
    -0.09239584f, -0.18121541f, 0.07056552f, 0.16489185f, 0.26739424f, 0.07838797f, 0.01779713f, 0.18316881f, 
    0.14668120f, 0.10433679f, 0.05167406f, 0.06177779f, -0.04006003f, -0.03895788f, 0.00008497f, -0.00122524f, 
    0.33456013f, -0.25570405f, -0.34142372f, -0.33947068f, 0.00444981f, 0.07345550f, 0.03585640f, -0.08759000f, 
    -0.02519665f, 0.21022366f, 0.02963856f, -0.20075957f, 0.05049585f, 0.05209875f, 0.05873913f, -0.06362639f, 
    -0.04898948f, -0.01850037f, 0.07815677f, -0.05043501f, -0.04749459f, -0.01462225f, -0.10278707f, 0.04800529f, 
    0.23057868f, 0.11893094f, 0.12974267f, 0.00875339f, -0.15347178f, 0.12940039f, -0.11050531f, -0.06149662f, 
    -0.07825734f, 0.01472470f, -0.01490833f, -0.00125294f, -0.36691880f, -0.03528364f, 0.14670512f, 0.16619733f, 
    -0.06012473f, 0.02661146f, -0.02357225f, -0.07212777f, -0.03395145f, 0.15372741f, -0.17975795f, 0.03701881f, 
    -0.02294496f, 0.22416580f, 0.08629134f, 0.15516312f, -0.15761246f, -0.05346895f, 0.06136735f, -0.16506332f, 
    -0.04906420f, -0.04153693f, 0.02056843f, -0.01254862f, -0.11255103f, -0.03919863f, 0.25881994f, 0.02811373f, 
    -0.04316631f, -0.08919686f, -0.06340579f, -0.16096014f, -0.04163758f, 0.01726498f, -0.02825935f, 0.00496393f, 
    0.01903861f, -0.24418937f, -0.28070980f, 0.07575107f, 0.00952786f, 0.11802905f, 0.09920464f, 0.15273556f, 
    -0.04501907f, 0.06711926f, 0.03877322f, -0.06912526f, 0.37806976f, -0.29185507f, -0.10647916f, -0.18231110f, 
    0.02133787f, 0.08822039f, 0.09282893f, 0.09838175f, 0.01941298f, 0.05185831f, 0.06896393f, -0.03581000f, 
    0.21033444f, -0.19558923f, 0.13033204f, 0.21074307f, 0.03398173f, 0.05658006f, 0.00857566f, 0.12995186f, 
    -0.07026938f, -0.04830528f, -0.05646934f, -0.05780814f, -0.01358238f, -0.05620134f, 0.23610829f, 0.08906539f, 
    -0.01454552f, -0.10948899f, -0.19457465f, -0.04540916f, 0.02133047f, -0.10684757f, 0.00876331f, -0.01883989f, 
    0.02799929f, -0.16610251f, -0.14234938f, 0.21943802f, 0.07578076f, 0.04269827f, 0.04846334f, 0.03695049f, 
    -0.09430253f, 0.06853420f, -0.10924537f, -0.01811019f, -0.20186600f, -0.04426676f, 0.33016208f, 0.08030566f, 
    -0.02572221f, 0.01193142f, -0.13645279f, 0.03537143f, -0.09241665f, -0.06368358f, 0.06251335f, -0.08336140f, 
    0.20852314f, -0.04393603f, -0.02070578f, 0.30981237f, -0.02587141f, -0.07139884f, -0.12880749f, 0.16274689f, 
    -0.02024645f, -0.03343599f, -0.06776544f, 0.00612614f, -0.02339141f, 0.06442577f, -0.12690136f, -0.17511214f, 
    -0.02047202f, 0.03218710f, -0.03158426f, -0.03478139f, 0.03451665f, 0.08176807f, -0.03446906f, 0.03101487f, 
    0.25229475f, 0.09447724f, -0.17773771f, 0.13776672f, 0.06663250f, 0.19667614f, 0.16054796f, 0.08701394f, 
    0.04975100f, 0.13759500f, 0.00341883f, 0.03411122f, 0.02185735f, 0.10775238f, 0.01619673f, 0.27044636f, 
    -0.20961462f, -0.12051279f, -0.09574362f, -0.12710078f, -0.00523438f, -0.05311549f, 0.08532169f, 0.01911059f, 
    0.16205494f, -0.15555358f, -0.08544391f, 0.30857477f, 0.19545655f, 0.23640673f, -0.06453645f, -0.02884839f, 
    -0.07310518f, 0.00358136f, 0.03542595f, 0.12324830f, -0.27902964f, -0.11989482f, -0.05355328f, 0.05553258f, 
    -0.02466568f, -0.04454425f, -0.08452372f, -0.09043534f, -0.02125842f, -0.02303743f, 0.04668399f, 0.05918752f, 
    0.01139983f, -0.11914015f, -0.02248326f, 0.15720929f, 0.03202515f, 0.05552387f, 0.04235828f, 0.14084414f, 
    0.00694641f, 0.09846108f, -0.14672402f, 0.06217860f, 0.41229388f, 0.01656185f, -0.21326415f, 0.00428867f, 
    0.02084168f, 0.03087930f, -0.01872886f, -0.08576453f, -0.03579955f, -0.00522936f, -0.07305820f, 0.01895085f, 
    0.46884319f, -0.02472408f, 0.03450516f, -0.46975005f, 0.12479963f, -0.09478229f, 0.01474860f, -0.13911076f, 
    0.13168710f, 0.05488122f, -0.02872895f, -0.09125491f, 0.28996658f, -0.28931147f, -0.45404258f, 0.15477376f, 
    0.10144585f, 0.04659175f, 0.11292260f, -0.03225008f, 0.03572184f, -0.00153933f, 0.00168347f, 0.12871641f, 
    -0.44977719f, 0.05738401f, 0.14499052f, -0.01596156f, -0.04772888f, 0.02941212f, -0.03547440f, -0.00805858f, 
    0.00152325f, -0.00139249f, -0.00245930f, 0.04900173f, -0.09534814f, 0.20660134f, 0.10250523f, -0.01185509f, 
    -0.14565192f, -0.08445197f, -0.01390256f, -0.04947587f, -0.06979965f, 0.12104844f, 0.04612250f, -0.02418549f, 
    0.24662024f, -0.23347703f, -0.27347398f, 0.25777790f, -0.15492706f, 0.30803242f, -0.02009692f, -0.01289594f, 
    0.01622436f, 0.02743297f, -0.00774666f, 0.00234070f, 0.14557569f, -0.07223743f, 0.04562047f, 0.08669021f, 
    0.04509976f, 0.04985163f, -0.08458570f, 0.24062838f, -0.04410042f, 0.03371369f, 0.02796225f, -0.03050558f, 
    0.14268778f, -0.12715296f, -0.16742119f, 0.01659194f, 0.01000960f, 0.05962499f, 0.01664577f, -0.08200708f, 
    -0.13451321f, 0.17372516f, 0.02460913f, 0.11874735f, -0.00527892f, -0.07954881f, -0.09170797f, -0.00387763f, 
    -0.05147205f, -0.04525312f, -0.06913421f, -0.17116444f, 0.01930002f, -0.21490088f, -0.13166143f, -0.05948202f, 
    0.04836870f, 0.11216250f, -0.14723012f, 0.02951655f, -0.19765431f, 0.10848369f, 0.26051468f, 0.06749707f, 
    -0.01928769f, 0.00342227f, 0.09974840f, 0.02704147f, 0.07562191f, 0.26742187f, -0.06584839f, 0.16930497f, 
    0.01633295f, -0.05956175f, -0.04131627f, 0.04035898f, 0.06565443f, 0.03159633f, -0.03705396f, -0.02434775f, 
    -0.09033017f, -0.22771563f, 0.22278945f, -0.09816614f, -0.05852538f, 0.06966730f, -0.06622776f, 0.15444344f, 
    0.00034491f, -0.13549317f, -0.06715633f, 0.06625917f, -0.18944077f, -0.03473777f, -0.02612736f, 0.16737221f, 
    -0.03520054f, 0.01182865f, 0.03007055f, 0.09365236f, 0.00712572f, 0.01218700f, 0.08578671f, 0.10552144f, 
    0.62920320f, -0.05869675f, -0.07466993f, -0.11156316f, -0.08685336f, -0.05434261f, 0.06263947f, -0.01510410f, 
    0.04312779f, -0.10423179f, -0.26498413f, 0.06192216f, 0.13756815f, 0.02672799f, 0.17463778f, -0.09469843f, 
    0.07282162f, 0.05426797f, -0.03930751f, 0.02135987f, 0.09009016f, 0.07155718f, 0.12272289f, 0.05048298f, 
    -0.07678007f, 0.00229178f, 0.24556617f, 0.34454694f, -0.05047483f, -0.16142154f, 0.07176460f, 0.13483566f, 
    0.03087938f, 0.04104175f, -0.06255259f, 0.03711795f, 0.03389762f, 0.13194048f, 0.02844090f, 0.06173554f, 
    -0.02137726f, -0.14112827f, -0.06760243f, 0.00088437f, -0.06097075f, -0.28618026f, -0.09361240f, -0.13760531f, 
    0.15877633f, -0.12777855f, 0.37434423f, 0.04258129f, 0.00331638f, 0.09438934f, -0.13173632f, -0.08873562f, 
    -0.06170136f, -0.15089688f, -0.09215345f, 0.04300405f, -0.00629289f, 0.11830854f, -0.18440121f, 0.17835750f, 
    -0.10410386f, 0.02248403f, -0.13378517f, 0.11354642f, 0.11557734f, -0.05406481f, -0.02354859f, -0.03442417f, 
    0.38007849f, -0.04083699f, -0.02965035f, -0.13148090f, -0.03935207f, 0.05290190f, 0.07936191f, 0.04527205f, 
    0.14486614f, 0.19078153f, 0.08897103f, 0.00705196f, 0.22641316f, -0.04840670f, -0.10530837f, -0.19405170f, 
    -0.04367449f, -0.05276361f, 0.14715317f, -0.05203144f, 0.13413571f, -0.12774910f, -0.08480998f, -0.00283717f, 
    -0.17873950f, 0.09177737f, -0.01930497f, 0.18081179f, 0.04495449f, -0.04051856f, -0.08845036f, 0.20849381f, 
    -0.00224304f, 0.00114226f, -0.13405593f, -0.14515468f, -0.18399449f, 0.09230447f, 0.03077871f, 0.15399070f, 
    0.06245049f, -0.01359203f, -0.12036628f, 0.04070149f, 0.05868383f, -0.02206659f, 0.15797263f, 0.04301406f, 
    -0.08353777f, -0.28807446f, -0.08041418f, -0.14916444f, -0.05679430f, -0.00388365f, -0.09211892f, 0.13955334f, 
    -0.03463907f, -0.09108174f, -0.07756571f, -0.18511756f, -0.22914542f, 0.25846079f, -0.13349771f, 0.17520979f, 
    -0.07245968f, -0.03990704f, 0.04851073f, 0.15000613f, -0.06151082f, 0.13647705f, 0.07745539f, -0.06165258f, 
    -0.07238746f, -0.12146509f, 0.24455729f, 0.28910288f, 0.06492083f, -0.05902357f, 0.13183613f, 0.12423974f, 
    0.04669375f, 0.01881055f, 0.09746864f, 0.08964642f, 0.23587158f, 0.02171661f, 0.05628708f, -0.22518235f, 
    -0.05176880f, -0.01930348f, 0.02965662f, -0.01963658f, -0.02956808f, 0.06644968f, 0.02336920f, 0.02675807f, 
    -0.02495337f, 0.09425306f, 0.30109286f, 0.15784256f, -0.03418156f, 0.21225139f, 0.04798090f, 0.00159830f, 
    -0.05918787f, 0.10905505f, 0.07054248f, -0.08251790f, -0.01014650f, 0.03594654f, 0.25200367f, 0.01764359f, 
    -0.02064789f, 0.27696615f, 0.04255214f, -0.15636583f, 0.01902417f, -0.01360220f, -0.01077305f, -0.05532388f, 
    -0.07946285f, -0.21508154f, -0.07048449f, 0.22888269f, 0.08478469f, -0.03940627f, -0.05666043f, -0.06707193f, 
    -0.08023730f, -0.10201693f, -0.16343404f, 0.00629214f, -0.10763364f, 0.02415867f, 0.06993087f, -0.24684265f, 
    0.04113448f, -0.00510006f, 0.08226680f, -0.07025445f, -0.01702454f, 0.12716453f, 0.03541762f, 0.00342507f, 
    0.03868728f, 0.18493593f, 0.16610143f, 0.18653691f, 0.20498997f, 0.15361790f, 0.09482478f, 0.06837929f, 
    -0.04340130f, -0.08837020f, 0.08581995f, -0.10656665f, -0.20065109f, -0.16910903f, -0.00297039f, 0.02686250f, 
    -0.00410419f, 0.03053085f, 0.04352044f, 0.10362053f, 0.08092495f, -0.03565945f, 0.01877540f, 0.15372492f, 
    0.26252502f, -0.04822523f, 0.04320809f, -0.18809409f, 0.19597939f, -0.00769852f, 0.03324720f, -0.13101405f, 
    -0.09604022f, 0.09632023f, 0.00040962f, 0.17052154f, 0.05451932f, -0.27636823f, -0.29719195f, -0.09381527f, 
    -0.09078193f, -0.12072826f, -0.12118019f, 0.12116005f, -0.04991994f, -0.11497336f, -0.11701124f, -0.16224223f, 
    -0.10017171f, 0.18563882f, 0.13442171f, -0.06759424f, -0.01585543f, -0.00416010f, -0.02843546f, -0.04165182f, 
    0.11949170f, 0.12328953f, -0.03737924f, 0.01836871f, -0.01808525f, 0.09841520f, 0.06796955f, 0.05298607f, 
    -0.01779477f, -0.04087764f, 0.02127188f, -0.05696727f, 0.09798856f, 0.15275948f, 0.04828562f, 0.08508433f, 
    0.01127673f, 0.32647476f, 0.20474955f, -0.04833292f, -0.10240812f, 0.02555041f, 0.23141155f, 0.07992168f, 
    -0.06082965f, 0.08527111f, -0.03911838f, 0.17222956f, -0.09805632f, 0.28906465f, 0.03105909f, 0.43492976f, 
    0.10131018f, 0.00818172f, 0.08436485f, 0.31246090f, -0.05077578f, 0.07534487f, -0.05849955f, 0.01306527f, 
    -0.37767094f, 0.36170352f, -0.05341786f, -0.07647416f, 0.12276636f, -0.12889221f, 0.13807480f, 0.02079813f, 
    0.02933572f, -0.12384484f, 0.15400836f, -0.05293660f, -0.11134689f, -0.11480781f, 0.02353827f, -0.06037549f, 
    0.03267460f, 0.06244366f, -0.06647708f, 0.10168611f, -0.05651026f, 0.10294028f, -0.07979537f, -0.20258091f, 
    -0.16969691f, 0.07876520f, 0.14149803f, 0.11869198f, 0.13569796f, -0.20880534f, 0.06592686f, 0.04764429f, 
    0.00226610f, 0.03151201f, 0.09702271f, -0.09800062f, 0.18594690f, -0.02229870f, 0.26255748f, -0.09808256f, 
    -0.10907882f, 0.00452820f, -0.09405880f, 0.09526957f, -0.05201124f, -0.10950447f, 0.08850243f, 0.05671849f, 
    0.48280802f, -0.05851984f, -0.00558903f, 0.03254546f, 0.04728299f, -0.12612373f, 0.28282920f, -0.09210101f, 
    0.09030183f, 0.00987267f, 0.00791245f, -0.04732633f, 0.10882425f, 0.17770775f, 0.02006914f, -0.08652261f, 
    0.10100319f, 0.04973239f, -0.01434014f, 0.08293623f, -0.14437084f, -0.02380478f, -0.00794625f, -0.02303420f, 
    -0.04588083f, -0.08644058f, -0.26066658f, 0.06905330f, -0.07284015f, -0.00305718f, 0.06326431f, 0.07702758f, 
    0.00140453f, 0.04819151f, -0.02678363f, -0.09562884f, 0.15919814f, 0.12013466f, -0.17630118f, 0.18003196f, 
    -0.06349454f, 0.05906766f, 0.01250538f, 0.10618523f, -0.06602077f, -0.01047727f, -0.07041123f, -0.00429693f, 
    0.06108612f, -0.04829139f, -0.30368394f, -0.07407368f, -0.26317638f, 0.00745709f, 0.02008231f, -0.11118232f, 
    -0.10799988f, 0.06404257f, -0.08075383f, -0.00606246f, 0.02864949f, -0.02438614f, 0.04708063f, -0.13429150f, 
    -0.01698972f, 0.01272047f, -0.09207848f, 0.05079370f, -0.03080105f, 0.03609829f, 0.05426203f, 0.08335920f, 
    -0.00098351f, 0.15748504f, -0.24423754f, 0.06801699f, -0.07666963f, 0.07981239f, -0.07996549f, -0.07417981f, 
    0.09706366f, -0.01740754f, 0.00198631f, 0.03463114f, 0.04911076f, -0.08077385f, 0.28749844f, -0.09949902f, 
    -0.05456308f, -0.10221926f, -0.02986782f, 0.01390049f, -0.02148537f, 0.02188050f, 0.10582443f, -0.01007078f, 
    0.05379753f, -0.20380652f, 0.06769775f, -0.07669638f, -0.04296143f, -0.05537687f, 0.21307169f, -0.00425265f, 
    -0.00960839f, 0.04496117f, -0.06219827f, -0.08858000f, -0.23926546f, 0.25989205f, 0.02744834f, -0.07283577f, 
    -0.08998340f, 0.15395789f, -0.01484356f, 0.12246218f, -0.05431866f, -0.00774478f, 0.05502466f, -0.11693298f, 
    0.10250523f, -0.00452215f, 0.18056160f, -0.15587068f, -0.05360094f, 0.15044281f, -0.01114780f, -0.06807370f, 
    -0.00114753f, 0.01023919f, 0.02851200f, 0.00306024f, 0.22373988f, 0.04729291f, 0.37969440f, -0.07049967f, 
    0.03806322f, 0.09378576f, 0.18610968f, -0.14738931f, -0.02207561f, 0.02294710f, 0.01382278f, 0.06334391f, 
    0.10007504f, 0.01855501f, -0.21087442f, 0.04094911f, 0.01766716f, -0.06461307f, 0.08967286f, -0.07082099f, 
    -0.07349907f, 0.02376200f, -0.05420767f, -0.04738756f, 0.06087032f, -0.21648319f, 0.37270898f, -0.11839823f, 
    0.05731135f, -0.03616106f, -0.15968220f, -0.10585629f, 0.01081072f, -0.05117289f, 0.07305755f, 0.02332659f, 
    0.19865564f, 0.16215916f, -0.20122045f, 0.06174872f, -0.01376356f, 0.20045525f, -0.02176676f, 0.04722412f, 
    -0.09970491f, -0.02867115f, -0.09492395f, -0.02487544f, -0.02900178f, 0.00760887f, -0.04461035f, 0.05890625f, 
    -0.11339719f, 0.05733662f, 0.00277034f, 0.10395802f, 0.06955271f, 0.03377628f, -0.04531334f, -0.04079008f, 
    -0.12821560f, -0.11542884f, -0.26293841f, 0.03613367f, 0.03959331f, 0.04332302f, -0.08344657f, -0.01760997f, 
    0.11496521f, -0.14430365f, -0.03259611f, 0.06339984f, 0.02651561f, 0.29517722f, -0.11551514f, -0.14835894f, 
    -0.11979950f, -0.16110964f, 0.07913491f, 0.00625478f, -0.22516076f, 0.10468773f, 0.05226152f, 0.07188205f, 
    0.08421388f, 0.33624837f, 0.16456650f, -0.05652518f, 0.02560703f, 0.13375169f, -0.02684567f, -0.02096812f, 
    -0.06378163f, -0.03391494f, -0.12917230f, -0.07025803f, 0.13272768f, 0.10741782f, 0.04782817f, 0.19879057f, 
    0.01928949f, 0.14499789f, 0.09171934f, 0.04166956f, 0.12644465f, 0.12934236f, 0.03017041f, -0.11714357f, 
    -0.04218521f, -0.06682607f, -0.18477157f, -0.12181981f, -0.08661134f, -0.11863919f, -0.11370713f, -0.05519814f, 
    0.03044584f, 0.07615382f, -0.12580884f, 0.00561426f, 0.34937373f, 0.14326057f, 0.06600991f, 0.11309879f, 
    0.06956915f, 0.12272128f, 0.03583227f, -0.04570449f, -0.00727968f, -0.01742794f, -0.04083066f, -0.15955193f, 
    -0.41042861f, 0.38851663f, -0.10776453f, 0.18681529f, 0.05991630f, 0.18522991f, 0.08434679f, -0.08349691f, 
    0.08198062f, 0.01991659f, -0.08205532f, -0.04265399f, 0.17087345f, 0.21051867f, -0.02038930f, 0.03216176f, 
    0.00965878f, 0.06023582f, 0.07395143f, -0.03435487f, -0.00783091f, 0.05677735f, -0.09620666f, -0.17591682f, 
    0.09885141f, 0.10792856f, 0.09292361f, 0.25271073f, -0.06880729f, -0.02636380f, -0.01568160f, 0.06490579f, 
    -0.06714520f, -0.07230641f, -0.01076100f, 0.09979122f, 0.15119250f, 0.12866835f, 0.07320215f, 0.04503202f, 
    -0.09605789f, -0.08264001f, -0.05832893f, -0.03498288f, -0.09293076f, 0.02844417f, 0.06174862f, 0.05148041f, 
    0.34419271f, -0.46369654f, 0.04857903f, 0.23361118f, 0.00484603f, -0.13200584f, 0.06340806f, 0.12099551f, 
    -0.00728190f, -0.00432172f, 0.01253893f, 0.03831485f, -0.15691330f, -0.04886283f, 0.09028549f, -0.20129752f, 
    -0.05293064f, -0.05502447f, -0.07223700f, -0.01495639f, -0.11088441f, 0.05184537f, 0.01773772f, 0.14739643f, 
    0.28056544f, -0.26565957f, 0.23991580f, -0.05208499f, -0.08635854f, -0.05910285f, -0.03090641f, 0.04732612f, 
    0.05824744f, 0.10526986f, -0.09430502f, 0.11248305f, -0.24625118f, 0.02193838f, -0.02715657f, 0.14467171f, 
    -0.03738755f, -0.07340536f, -0.07264146f, -0.02812278f, 0.11587952f, -0.03415854f, 0.01668609f, 0.02224919f, 
    0.04464258f, -0.04949020f, -0.14913076f, 0.03152379f, -0.12087357f, 0.07843541f, 0.01263307f, -0.02418007f, 
    -0.00162913f, 0.01215316f, -0.01965440f, 0.08714137f, 0.04051798f, -0.02223869f, -0.39448392f, 0.17401998f, 
    0.01645829f, 0.04136217f, 0.15507716f, -0.01360220f, 0.01989716f, 0.04015127f, -0.14113413f, -0.02980725f, 
    -0.07269479f, -0.16261387f, 0.02986852f, -0.07261686f, -0.04008326f, 0.09268785f, -0.17699733f, 0.00926167f, 
    0.09243078f, -0.01028809f, -0.03435217f, 0.00733840f, -0.04329533f, 0.02885913f, -0.02685810f, -0.05896660f, 
    -0.04331304f, -0.01472251f, 0.05714568f, -0.10604078f, 0.10271215f, -0.03958799f, -0.01314147f, 0.02113959f, 
    0.03206112f, 0.20413457f, 0.34847739f, 0.05877217f, -0.06641807f, -0.02301386f, -0.07612396f, -0.10932286f, 
    0.09910680f, -0.03802915f, -0.00851055f, 0.06914201f, -0.02401409f, -0.10726843f, 0.25729257f, -0.12532827f, 
    0.10877300f, 0.02006454f, -0.02618274f, -0.06288828f, 0.08393269f, 0.01848208f, 0.22405358f, -0.01030220f, 
    -0.16478150f, 0.06142666f, 0.11906506f, 0.17181946f, 0.17204824f, -0.03586850f, 0.16179265f, 0.12321792f, 
    0.05604574f, -0.06508156f, 0.08957446f, -0.05413353f, 0.10522430f, -0.01848328f, -0.06397813f, 0.04258595f, 
    0.10107177f, 0.02938702f, 0.09127737f, 0.01893002f, -0.05260568f, -0.22991699f, -0.12244160f, -0.12756240f, 
    0.21005508f, -0.41615084f, 0.27329850f, -0.14867154f, 0.03668740f, 0.04719971f, 0.02720954f, 0.00640086f, 
    -0.11028164f, 0.00208279f, 0.04185620f, -0.00041814f, -0.07809365f, -0.01461954f, -0.43263373f, 0.26619089f, 
    0.08525749f, 0.07223687f, -0.00917235f, 0.13681145f, 0.00709104f, -0.11162941f, -0.09241917f, -0.05943262f, 
    0.07367039f, 0.07086833f, 0.05341786f, 0.05810959f, 0.04313131f, 0.09975797f, -0.12429047f, -0.02143683f, 
    0.18905653f, -0.05142695f, 0.12902237f, 0.11150073f, -0.13608861f, -0.02312475f, 0.16719410f, 0.00766013f, 
    -0.05377439f, -0.17621300f, 0.06416216f, -0.01441354f, 0.07200438f, -0.14042389f, -0.02928800f, 0.12942582f, 
    -0.05599129f, 0.06250561f, -0.14022361f, 0.08625679f, 0.06332555f, 0.01292845f, 0.01107125f, 0.23292498f, 
    0.00774076f, 0.06310491f, -0.04400290f, 0.05967083f, -0.25984320f, 0.05119312f, -0.33100379f, 0.19591881f, 
    0.06414341f, -0.05833682f, -0.10331547f, 0.05444556f, 0.03856554f, -0.09299783f, 0.11260516f, -0.01568224f, 
    0.12605312f, 0.02037389f, 0.16451456f, -0.13794118f, 0.06058205f, 0.01862506f, -0.07447172f, 0.05880830f, 
    0.08273140f, 0.01293637f, 0.01527554f, -0.04577928f, -0.12862046f, 0.13094294f, -0.46872091f, 0.22116019f, 
    0.03026102f, 0.10229098f, 0.29073590f, -0.02466507f, -0.01428675f, 0.13262932f, 0.00976094f, -0.10181189f, 
    0.06061824f, -0.03909303f, 0.09210617f, -0.05662071f, 0.08119100f, -0.08133907f, -0.01464364f, 0.00713140f, 
    0.00060596f, -0.03768915f, 0.09113244f, 0.12777679f, 0.08542334f, -0.01502471f, 0.16768025f, 0.00768304f, 
    -0.02837445f, -0.05622598f, 0.00461170f, -0.04948905f, 0.01179761f, 0.02405174f, -0.00314697f, 0.05607680f, 
    0.27474999f, 0.28705296f, 0.20733418f, -0.05988677f, -0.10986146f, -0.07457701f, 0.01555387f, -0.00931300f, 
    0.00660369f, 0.12285209f, 0.00965313f, -0.09743098f, -0.00910619f, -0.26432121f, 0.13733706f, 0.04465697f, 
    0.02820275f, 0.27490038f, -0.06141904f, -0.16180886f, 0.14201261f, -0.05279579f, -0.00805516f, -0.18892980f, 
    -0.12359703f, -0.29521874f, -0.19275321f, -0.05910335f, -0.01102708f, -0.11199316f, -0.05792029f, 0.02826217f, 
    -0.04243075f, -0.12274311f, -0.03461613f, -0.08696140f, -0.07552838f, -0.06186938f, 0.12839694f, -0.23180611f, 
    -0.02193962f, -0.17523831f, -0.05607913f, 0.07119920f, -0.01176995f, -0.06523241f, 0.08495460f, 0.12775455f, 
    0.26281688f, 0.26530239f, 0.15948607f, -0.00538111f, 0.12338217f, 0.09173132f, 0.00276285f, 0.03467022f, 
    -0.04906704f, -0.06099751f, 0.16845214f, -0.12500685f, -0.24777849f, 0.03975652f, -0.01959956f, -0.08896974f, 
    -0.00011562f, 0.01712514f, 0.01656710f, 0.07499739f, 0.08416525f, 0.05398503f, 0.07969739f, 0.13977429f, 
    0.32100317f, -0.01156191f, 0.14252391f, -0.27717578f, -0.00607749f, -0.11203795f, 0.09853269f, 0.03317228f, 
    0.06966293f, -0.13547485f, 0.04003855f, 0.09488738f, -0.15518431f, -0.01855364f, -0.01913529f, -0.06575720f, 
    -0.08271568f, 0.02218483f, -0.03359477f, 0.09072378f, 0.01478554f, -0.13776584f, 0.01852556f, -0.06976767f, 
    -0.03350455f, 0.05636948f, -0.11511651f, -0.11598275f, 0.03176621f, 0.02928293f, 0.09436183f, -0.08916818f, 
    0.14265995f, 0.16449350f, -0.00611217f, -0.03422907f, -0.07174222f, -0.07014949f, -0.09123304f, 0.05492710f, 
    0.06644054f, 0.10514504f, -0.00125996f, -0.02142391f, 0.10502806f, 0.07628562f, -0.01417644f, 0.09386164f, 
    -0.59981722f, 0.61817098f, 0.21655571f, -0.20526198f, -0.04478709f, 0.11100960f, -0.13020226f, 0.07454871f, 
    0.00147310f, 0.13323990f, -0.05540335f, -0.00078982f, 0.11200830f, 0.26749852f, -0.01274466f, 0.11003603f, 
    0.08813915f, 0.05211616f, 0.08089532f, 0.12687057f, 0.13039789f, 0.08838942f, 0.09125986f, -0.04003868f, 
    -0.07165677f, 0.17348272f, 0.05177312f, 0.06210082f, 0.16645654f, 0.05610857f, -0.05538139f, 0.16294219f, 
    -0.02187764f, 0.11877555f, -0.08421209f, -0.03581557f, -0.00649841f, -0.03194341f, -0.03680039f, 0.01243149f, 
    0.05095523f, -0.13686413f, 0.04262016f, -0.27660912f, -0.05357900f, 0.07856844f, 0.11005229f, 0.05403508f, 
    0.04231442f, -0.03980077f, -0.23715597f, -0.00205629f, -0.06343430f, -0.00503864f, 0.01512353f, 0.09705464f, 
    -0.14745528f, 0.11690256f, 0.12937438f, -0.22168374f, -0.08988034f, 0.15939698f, -0.17038018f, -0.10558482f, 
    0.09064076f, -0.04553730f, -0.12730205f, 0.00896426f, 0.18066581f, 0.04726350f, 0.00859370f, -0.09034995f, 
    -0.31461465f, 0.36909169f, 0.28814358f, 0.00731538f, 0.07839116f, 0.00435245f, -0.04446871f, 0.21158585f, 
    -0.06635250f, 0.12543803f, -0.08052582f, 0.06443924f, 0.07309966f, 0.10476013f, 0.17654411f, 0.12674797f, 
    0.04767193f, 0.16138308f, 0.16867401f, 0.00818626f, -0.02659997f, -0.09002226f, -0.05561026f, 0.01487890f, 
    -0.17921990f, -0.00859214f, -0.18895951f, 0.23012246f, 0.12758762f, -0.02727071f, -0.18452103f, 0.07757482f, 
    0.16991213f, 0.02048463f, -0.10232531f, 0.34401524f, -0.04632856f, -0.17800401f, -0.22011764f, -0.08162872f, 
    -0.05421001f, -0.06009885f, -0.12370945f, 0.01410621f, 0.06372239f, 0.01727402f, -0.01856364f, -0.15492894f, 
    0.19136664f, 0.21591718f, 0.12084296f, -0.09831920f, 0.15861055f, 0.02685615f, 0.05659351f, 0.32433295f, 
    0.16062254f, -0.12778579f, -0.15015940f, -0.07961220f, -0.08315920f, 0.12533405f, -0.18424331f, -0.08679359f, 
    0.05998463f, 0.09154793f, -0.09979659f, -0.10508273f, 0.08718583f, -0.03417714f, 0.08009544f, 0.05333464f, 
    -0.14483334f, 0.06737407f, -0.12373389f, -0.11653241f, -0.04143301f, -0.03487915f, -0.19064410f, 0.18204568f, 
    0.07961930f, 0.03047810f, -0.02853731f, 0.04816055f, -0.14814317f, 0.11231986f, -0.16184485f, 0.02530748f, 
    -0.02237976f, 0.02271479f, -0.10080554f, 0.15406792f, 0.06224895f, 0.00911179f, -0.04497757f, -0.12540978f, 
    0.20787098f, 0.18446700f, 0.03459650f, 0.13090362f, -0.04315594f, -0.17952448f, 0.01782946f, 0.12230621f, 
    0.05430414f, 0.18004665f, -0.18582076f, -0.17324357f, 0.05317015f, 0.25153854f, -0.02006451f, 0.14779094f, 
    -0.02968897f, 0.05347589f, -0.02951503f, -0.00358392f, -0.04698998f, -0.02550564f, 0.03594607f, -0.08570531f, 
    0.12229391f, 0.24347205f, -0.03986777f, -0.08010504f, 0.10856298f, 0.04145509f, -0.00950921f, 0.04134150f, 
    -0.06666126f, 0.10555435f, 0.05577125f, 0.04351334f, -0.35804126f, 0.05810087f, -0.21650991f, 0.08130360f, 
    -0.01291992f, 0.02936973f, -0.18130645f, -0.10945065f, 0.01105164f, 0.17374758f, 0.03432583f, 0.11875618f, 
    0.03796528f, 0.01282302f, 0.27212524f, 0.25848255f, -0.00077819f, -0.10292792f, -0.15203558f, -0.06788793f, 
    -0.03971760f, -0.04868421f, 0.01025167f, 0.14921093f, -0.36859643f, 0.26783413f, 0.09219732f, 0.23534966f, 
    0.09201248f, 0.07738558f, -0.20129982f, 0.00542927f, 0.05328888f, 0.10689355f, -0.08441343f, -0.07051639f, 
    -0.23814008f, 0.18361883f, 0.14831622f, 0.02268299f, -0.04782457f, 0.03249850f, 0.10465818f, 0.16454540f, 
    -0.02619135f, 0.05952941f, 0.02960351f, -0.14313395f, -0.16299699f, -0.28206608f, -0.06360286f, 0.15470484f, 
    0.08647056f, -0.04381525f, -0.17856719f, -0.02496089f, 0.03896626f, -0.05364745f, 0.06637460f, 0.00176694f, 
    0.17152306f, 0.00977775f, 0.35868886f, -0.01244537f, 0.16064444f, -0.00238625f, 0.02806247f, 0.22125265f, 
    -0.09264287f, -0.01937208f, 0.03612852f, 0.10675297f, -0.06008806f, -0.12301461f, -0.24491374f, 0.14795035f, 
    0.01036415f, -0.21587394f, 0.01680819f, 0.07887811f, 0.04703830f, -0.03000419f, -0.05449488f, 0.02210976f, 
    0.09689878f, 0.33963630f, 0.28829375f, 0.10430815f, -0.01630669f, -0.24424891f, 0.00098181f, 0.04783195f, 
    -0.01991835f, -0.04416505f, 0.07207578f, 0.08127126f, -0.23830254f, 0.10542639f, -0.08466292f, -0.21623744f, 
    -0.03820150f, -0.03894357f, -0.23231527f, -0.19463013f, 0.00909103f, 0.04280641f, -0.07061797f, 0.22366951f, 
    -0.03332900f, 0.14068608f, 0.22719653f, 0.05942642f, 0.03161937f, 0.05081366f, -0.09385569f, 0.03897472f, 
    -0.03410420f, 0.03789937f, 0.03659724f, 0.04556404f, -0.27740315f, -0.07456191f, 0.25435764f, 0.19087741f, 
    0.06213536f, -0.01270087f, -0.00725740f, 0.06046492f, 0.12239701f, -0.03952897f, -0.03098042f, 0.05983799f, 
    -0.13128872f, -0.14894335f, -0.01424956f, 0.17019261f, -0.22527316f, -0.01861282f, 0.06633897f, -0.14459462f, 
    -0.20171112f, -0.13897057f, -0.10245810f, 0.20269436f, 0.07875469f, 0.08992115f, 0.39004600f, 0.17348535f, 
    0.03712884f, -0.06129540f, -0.13227464f, -0.04013797f, -0.04372076f, -0.04791832f, -0.02968521f, 0.06612796f, 
    -0.22266230f, -0.13163032f, -0.11740594f, -0.11033732f, -0.01425564f, -0.08903342f, -0.20720866f, -0.06370533f, 
    0.19397578f, 0.02504244f, -0.01287800f, 0.14028735f, -0.44775307f, -0.41218686f, -0.13230473f, 0.29069942f, 
    0.03453909f, -0.17505187f, -0.02758264f, 0.05621265f, 0.08726907f, -0.11025280f, 0.03810237f, -0.06464667f, 
    0.55487764f, -0.05022335f, -0.26892608f, -0.26145053f, 0.22984600f, -0.13486743f, -0.15520255f, 0.08764309f, 
    -0.07954555f, -0.10131740f, 0.11327309f, -0.11016305f, 0.10042214f, 0.20534168f, 0.16832721f, 0.23973085f, 
    0.15396249f, 0.05321833f, 0.27413127f, 0.10431285f, 0.02887075f, -0.06238944f, 0.02951222f, 0.00650326f, 
    -0.62000340f, 0.14541198f, -0.16790606f, 0.02964821f, 0.03501774f, -0.03985353f, 0.03636324f, -0.02836061f, 
    -0.00467709f, -0.07936618f, -0.02520178f, 0.00105909f, 0.14374667f, -0.03464209f, 0.09593888f, -0.16009170f, 
    0.00442855f, -0.02055729f, 0.06431358f, 0.08822522f, 0.08412428f, 0.15059084f, 0.14218338f, 0.28764734f, 
    -0.04486817f, -0.12324657f, 0.21932784f, -0.05069745f, 0.14112669f, -0.06167192f, -0.04522608f, 0.06404153f, 
    -0.04663985f, 0.05356563f, -0.14793749f, -0.01991522f, 0.15556642f, -0.16000606f, 0.10061215f, -0.03243230f, 
    -0.05827538f, 0.01107388f, -0.03416117f, -0.04294708f, -0.10149736f, 0.09662582f, 0.08785743f, -0.01331886f, 
    -0.00993698f, -0.01709807f, -0.11674651f, 0.31391394f, 0.14806990f, 0.05233007f, 0.18767634f, -0.16510496f, 
    -0.11738843f, 0.09280127f, 0.08818974f, 0.06181255f, 0.19344322f, 0.20506318f, 0.10046893f, -0.01255991f, 
    0.05641258f, -0.15389442f, 0.02361551f, 0.03620934f, -0.08477331f, -0.02467106f, -0.06662803f, -0.22365473f, 
    -0.31456661f, -0.15351936f, 0.04425706f, -0.01347878f, 0.01681016f, 0.02855069f, -0.03771519f, 0.05920122f, 
    0.01771148f, 0.20558614f, 0.08255214f, -0.10984187f, 0.08540238f, 0.08384500f, -0.12125012f, 0.12158955f, 
    0.00473555f, 0.01196860f, 0.04054510f, 0.04612512f, -0.18152955f, -0.09139130f, -0.16065696f, -0.04812297f, 
    0.19634473f, -0.22384034f, 0.00586760f, 0.07531729f, -0.03465178f, 0.27074027f, -0.07579353f, -0.03446877f, 
    -0.06953627f, -0.05376543f, -0.11376276f, -0.08423257f, 0.04287644f, -0.00130555f, 0.08775013f, -0.12117422f, 
    -0.04340096f, -0.02268881f, -0.03768856f, 0.08662759f, 0.06581860f, 0.21297953f, 0.15227172f, 0.34262109f, 
    -0.16808747f, 0.29024342f, -0.15650044f, 0.07043192f, -0.06808758f, 0.01792161f, 0.04736621f, 0.04226561f, 
    0.02537835f, 0.00353289f, 0.01345444f, -0.12534100f, 0.18342935f, -0.09748948f, 0.36284930f, -0.08082092f, 
    -0.06739209f, 0.04974509f, -0.05107489f, -0.07883101f, -0.02895626f, 0.06942017f, -0.06510080f, -0.04422633f, 
    -0.20877558f, 0.04720996f, 0.18126795f, 0.09954027f, -0.07829148f, -0.09098657f, 0.03411946f, -0.00703147f, 
    -0.10091340f, -0.10905583f, -0.03244159f, 0.10722584f, -0.04235521f, -0.01057468f, 0.20389885f, -0.09765003f, 
    0.01036830f, 0.13398102f, -0.05846308f, 0.13338241f, -0.01229241f, 0.09887082f, -0.03460364f, -0.04334216f, 
    -0.01100778f, -0.07190104f, 0.17393090f, -0.11290326f, -0.12012978f, -0.01855582f, 0.02659682f, -0.16117108f, 
    -0.01082405f, -0.02982748f, 0.00937264f, 0.03278080f, 0.30348253f, 0.05713653f, 0.13489437f, -0.14390217f, 
    0.01893891f, -0.00860058f, 0.13320693f, 0.03027602f, 0.01593163f, 0.09765071f, -0.04415345f, -0.03008892f, 
    -0.01983186f, 0.22611851f, -0.03177235f, 0.16421935f, -0.10066330f, -0.14627634f, -0.01795804f, -0.09869402f, 
    -0.03076490f, 0.07150252f, 0.06871207f, 0.26264483f, 0.30344403f, -0.19512682f, 0.26893434f, -0.03503910f, 
    0.15175715f, 0.11616226f, 0.02385919f, -0.02324446f, 0.06630722f, -0.15556742f, -0.06945881f, 0.00373670f, 
    0.03553638f, 0.10938214f, -0.03736015f, 0.11804868f, -0.01014478f, 0.16510479f, -0.08692288f, -0.02868012f, 
    -0.04199008f, -0.13631271f, -0.10216063f, -0.14336599f, -0.10648661f, 0.02873614f, -0.03781873f, 0.09360012f, 
    -0.03366128f, -0.01456840f, -0.00156710f, -0.00203773f, 0.06263067f, 0.01648252f, 0.01612687f, 0.03177008f, 
    -0.11528651f, -0.20125698f, -0.12837721f, 0.12541112f, 0.00879413f, 0.06824905f, -0.11770983f, 0.01318430f, 
    0.10994505f, 0.02220469f, -0.09944507f, 0.07950345f, 0.08951600f, 0.07557815f, 0.11252682f, 0.09157699f, 
    -0.09773949f, -0.00652111f, -0.07219986f, 0.07785474f, -0.08058763f, -0.09992778f, 0.07677870f, 0.18722609f, 
    0.08112918f, 0.14404650f, 0.11140653f, 0.06536639f, 0.14658935f, 0.09925751f, -0.06310675f, 0.00126177f, 
    -0.07145606f, 0.06824256f, 0.09169311f, 0.03189535f, 0.14891858f, 0.03037529f, -0.18921161f, 0.16815884f, 
    0.03581151f, 0.06156486f, 0.02600154f, 0.15868944f, 0.02825321f, -0.12842797f, 0.01362078f, 0.00927862f, 
    -0.03983278f, -0.03977996f, -0.08296068f, 0.08472818f, -0.13459863f, -0.16599962f, -0.01286576f, 0.00177326f, 
    0.16930087f, 0.11703405f, 0.02952466f, 0.14215928f, 0.12589115f, 0.01426171f, -0.02299104f, 0.03562582f, 
    -0.00775771f, 0.03431561f, -0.01119829f, -0.07498267f, -0.09854245f, 0.02226845f, 0.07699232f, -0.06515649f, 
    -0.23530088f, 0.16124928f, -0.01249477f, 0.18911038f, 0.01272613f, -0.04832458f, -0.10927183f, 0.15106209f, 
    -0.01962834f, -0.14777970f, -0.10057352f, -0.05376107f, -0.08291769f, 0.45504254f, -0.01747711f, 0.06892933f, 
    0.05057724f, -0.06568551f, 0.13842313f, -0.20849636f, -0.05732575f, 0.06861628f, 0.09767820f, 0.14280938f, 
    0.19547844f, 0.08819542f, -0.04513169f, 0.21944629f, -0.08739714f, -0.00698841f, -0.01983202f, 0.04870445f, 
    -0.07685605f, -0.06338695f, 0.04351174f, 0.01340699f, 0.22062479f, 0.07666814f, 0.09930104f, 0.03645350f, 
    -0.06348676f, -0.02190137f, -0.01473735f, 0.05430756f, -0.16679823f, -0.03649744f, -0.04301645f, -0.09921034f, 
    0.34596473f, -0.30726033f, -0.28928092f, 0.36983916f, 0.12038638f, -0.04307353f, -0.19519876f, 0.05567199f, 
    0.02155800f, -0.11446925f, 0.00959604f, -0.03550214f, 0.00396289f, -0.15829520f, 0.14139815f, -0.18321986f, 
    -0.13860691f, -0.06298277f, -0.00905107f, -0.08678474f, -0.09523749f, -0.08081219f, 0.02356586f, -0.06484648f, 
    0.01417565f, 0.02270992f, 0.03036617f, 0.02072569f, -0.01348386f, -0.04444632f, -0.02006300f, -0.03617514f, 
    0.02980077f, 0.03646296f, 0.00658681f, 0.00452237f, -0.01988855f, 0.03333225f, 0.01734428f, 0.00496629f, 
    0.03722399f, -0.05096041f, 0.02535153f, 0.00895507f, -0.05238678f, 0.03624437f, -0.05137064f, 0.02430939f, 
    0.01501891f, -0.04205670f, -0.00049861f, -0.04516000f, -0.04697039f, -0.01222117f, -0.03868208f, -0.01034866f, 
    0.03537785f, -0.00818723f, 0.02463317f, -0.02022449f, -0.00965691f, 0.01670184f, -0.05622404f, -0.03233075f, 
    0.00405999f, 0.01376820f, -0.02948568f, 0.03623882f, 0.00933249f, 0.03511731f, -0.03317350f, -0.03735263f, 
    -0.02070928f, -0.00573734f, -0.02516395f, -0.03744602f, -0.01755836f, -0.01758632f, 0.02332948f, -0.04334525f, 
    0.00129750f, -0.04216154f, 0.03497165f, -0.03781223f, -0.02416871f, -0.01284209f, -0.04081503f, -0.02337122f, 
    0.01938325f, -0.01455915f, 0.01561365f, -0.03793338f, 0.01606520f, -0.04026677f, -0.03264156f, -0.00263676f, 
    0.04170975f, 0.03594388f, 0.01623219f, -0.05153978f, -0.05477409f, -0.03363369f, -0.00190033f, -0.03623420f, 
    0.02503010f, 0.03848517f, 0.01742120f, -0.00239698f, 0.00697839f, -0.00712871f, 0.03037119f, -0.05261349f, 
    -0.04332107f, -0.03702664f, 0.04136502f, -0.05003045f, -0.01765208f, 0.02804513f, -0.04032060f, 0.04327869f, 
    -0.00182873f, -0.03763538f, 0.02938590f, 0.02995881f, 0.02313359f, 0.03596647f, -0.02006596f, 0.03502740f, 
    -0.01605096f, 0.02817672f, -0.02243659f, 0.00104494f, 0.03340498f, 0.01287600f, 0.00890157f, 0.01194507f, 
    0.01468468f, -0.04134519f, -0.05646871f, 0.01572283f, 0.03162197f, 0.00683538f, -0.03405303f, -0.03391404f, 
    0.02883741f, -0.00584897f, -0.02386488f, -0.00963903f, 0.03399385f, 0.00218784f, -0.02903270f, -0.00758485f, 
    -0.03889256f, -0.04580010f, -0.02258403f, -0.03922915f, 0.01682121f, -0.01783666f, 0.02021553f, -0.03560293f, 
    0.00115326f, -0.04114931f, -0.05188397f, -0.03645147f, 0.03600570f, 0.00031174f, -0.00522843f, -0.03819028f, 
    -0.01454367f, -0.01437942f, -0.03591704f, 0.02595721f, -0.05664971f, -0.02799933f, 0.04353363f, -0.01072383f, 
    0.00263922f, 0.00550110f, -0.02848035f, -0.04624503f, 0.02207976f, 0.01796610f, -0.02200125f, 0.04331774f, 
    -0.02917171f, -0.03575760f, 0.02398854f, -0.04273310f, 0.03870122f, 0.03367649f, -0.02652021f, 0.01430060f, 
    -0.04265837f, -0.04580190f, 0.00956992f, -0.01797144f, -0.05035327f, -0.01728025f, -0.01711119f, -0.02562336f, 
    0.04428367f, 0.03889413f, 0.03381033f, -0.02579037f, -0.00233181f, 0.02057591f, 0.00421757f, 0.00040693f, 
    -0.00252877f, -0.00199196f, 0.03907309f, -0.04308193f, 0.02979667f, 0.00377381f, -0.00933097f, 0.00014647f, 
    0.01302862f, 0.01744452f, -0.00345279f, -0.00150145f, 0.01688702f, -0.04797515f, 0.04295029f, 0.02581719f, 
    -0.00177090f, 0.00772028f, -0.03746912f, -0.02648972f, 0.03334124f, -0.02015409f, -0.04372699f, 0.01533026f, 
    0.01889311f, 0.03615876f, 0.01577688f, -0.00085186f, -0.05420095f, -0.01142800f, 0.00070728f, 0.00792859f, 
    -0.02979529f, -0.02271072f, 0.00801865f, -0.00374495f, -0.00632972f, -0.01069541f, -0.05341244f, -0.04500898f, 
    0.03589798f, 0.03297538f, 0.00507205f, -0.05215437f, 0.02202049f, -0.00605548f, -0.01028168f, -0.05183208f, 
    -0.00626393f, -0.04728889f, -0.02537310f, 0.01515314f, 0.02765964f, -0.03855747f, -0.04380756f, 0.04116089f, 
    -0.01021257f, -0.00167309f, 0.01035722f, -0.03317339f, -0.05635399f, -0.02372427f, 0.01201254f, 0.03368648f, 
    0.00679540f, -0.02095246f, -0.05077678f, -0.02174701f, 0.00585385f, 0.03267508f, -0.05109277f, 0.01259692f, 
    -0.01243404f, 0.01755221f, 0.02147491f, 0.01972486f, 0.03482366f, 0.01297146f, -0.02840145f, -0.03904900f, 
    0.00823998f, -0.04919397f, -0.02990850f, 0.01378582f, 0.02556006f, 0.04178106f, 0.04140604f, -0.05314985f, 
    -0.03930302f, -0.00035540f, 0.01284942f, -0.00646922f, -0.00094631f, 0.00038503f, 0.01908869f, -0.01683065f, 
    0.00932064f, 0.02250913f, 0.00111298f, 0.00120860f, -0.03562588f, -0.04517088f, -0.03512011f, 0.01885257f, 
    -0.04739454f, 0.01075227f, 0.02206855f, 0.02519077f, 0.03427075f, -0.04750910f, -0.01945250f, -0.03575438f, 
    -0.03466635f, -0.02257752f, -0.03640403f, -0.00305568f, -0.00937989f, 0.00548992f, 0.00855793f, 0.00655712f, 
    -0.05127817f, 0.02025108f, -0.00219089f, 0.00071511f, 0.00771906f, 0.01440376f, 0.00028526f, 0.04459991f, 
    -0.04979322f, 0.00046090f, -0.03929909f, 0.00032423f, 0.03060376f, 0.00607349f, -0.00402346f, -0.01885260f, 
    -0.00453942f, 0.03600803f, -0.00989966f, 0.01598207f, -0.01530179f, 0.04103616f, 0.02772275f, 0.02998739f, 
    0.00177691f, -0.05161744f, 0.03566798f, -0.02922639f, -0.00696919f, -0.03410932f, 0.00795225f, -0.00946662f, 
    -0.04312780f, 0.03069948f, 0.00190829f, 0.02760068f, -0.02202736f, -0.04810603f, 0.01817380f, -0.05372310f, 
    0.00281132f, -0.01434118f, -0.03942848f, -0.00117744f, 0.00245143f, -0.04077422f, 0.00563384f, 0.00973190f, 
    -0.04364206f, -0.05298460f, -0.04711559f, -0.00286329f, -0.03247271f, 0.01866315f, -0.04265387f, -0.01782437f, 
    0.04463328f, -0.00033491f, -0.01702426f, 0.01198417f, 0.02702761f, -0.01322049f, -0.03899140f, -0.03677139f, 
    0.02390370f, -0.02805387f, 0.01623654f, 0.03322168f, -0.04928786f, -0.03937827f, 0.01702275f, 0.02508270f, 
    -0.04952779f, 0.03510207f, -0.01829718f, -0.05447394f, 0.00859782f, -0.02287940f, 0.01572578f, -0.03885128f, 
    -0.05151945f, -0.05776443f, 0.03399824f, -0.00659914f, 0.00238243f, 0.00565822f, -0.06185146f, -0.04199258f, 
    0.01365713f, -0.02544951f, 0.02155641f, -0.01596567f, -0.04075003f, 0.03428813f, 0.02672865f, -0.01755791f, 
    -0.01158225f, 0.00210149f, 0.02829310f, -0.01061524f, -0.00243149f, 0.02259938f, -0.02886091f, 0.02271185f, 
    -0.03899618f, 0.02845672f, 0.02268202f, 0.01180238f, 0.03875903f, 0.02224900f, -0.05508967f, -0.01887632f, 
    0.03486260f, -0.05262698f, 0.00433481f, 0.01096874f, -0.01590462f, -0.02740087f, 0.00232214f, -0.01407414f, 
    -0.02882168f, -0.02438963f, 0.02728350f, -0.05137387f, -0.05165191f, 0.02850799f, 0.02066718f, 0.02464373f, 
    -0.03899641f, 0.02325528f, -0.02523877f, -0.00299035f, 0.01902726f, -0.06063456f, 0.03905548f, -0.02171572f, 
    -0.04450237f, 0.01799490f, -0.02433153f, 0.03136153f, -0.02454632f, -0.04184302f, 0.00470583f, -0.02634220f, 
    0.04003711f, 0.00991807f, -0.00492303f, -0.01045879f, -0.03495618f, -0.02822000f, 0.02329394f, 0.00120465f, 
    -0.04939296f, -0.01240693f, -0.03909881f, -0.00119692f, -0.05842449f, 0.02575314f, 0.00545754f, -0.01596357f, 
    0.02461314f, 0.02746584f, 0.00543037f, -0.00848447f, -0.05798414f, -0.00945736f, -0.02189391f, 0.02555305f, 
    -0.03479546f, 0.02682724f, 0.03771496f, -0.04066242f, -0.05198227f, -0.01976268f, -0.03422321f, 0.02296691f, 
    -0.04504180f, -0.05309077f, -0.01966516f, -0.00857878f, 0.04295976f, -0.02309830f, 0.01189789f, 0.00672401f, 
    -0.01193606f, 0.01283068f, -0.01188695f, 0.03001263f, -0.02791028f, -0.05670569f, -0.00773019f, -0.01259544f, 
    -0.05036099f, -0.02599772f, -0.03523153f, -0.04721407f, 0.01149405f, -0.00175543f, 0.02508059f, 0.02949992f, 
    0.01169748f, 0.03983691f, -0.06054993f, 0.02638775f, 0.04079660f, -0.02358781f, 0.01237513f, 0.02947028f, 
    -0.02418975f, 0.01084211f, 0.00772019f, -0.00262012f, -0.04417929f, -0.02132788f, 0.02133812f, 0.01996252f, 
    -0.02169064f, 0.03178053f, -0.04124383f, -0.04566025f, -0.01477397f, 0.00767696f, -0.02411501f, -0.01572587f, 
    0.03236345f, -0.02909780f, -0.04215652f, -0.05172303f, 0.00522077f, -0.03964691f, 0.00136016f, 0.01375930f, 
    -0.04958775f, 0.03173708f, 0.01753771f, 0.00780897f, 0.00018486f, 0.01567500f, 0.03912885f, 0.03879620f, 
    0.00418476f, 0.01554895f, -0.04910114f, -0.00196755f, 0.02466401f, -0.04530422f, -0.05891994f, 0.02022822f, 
    -0.04241358f, 0.02853130f, 0.02145687f, -0.05860965f, 0.03810097f, 0.00021692f, -0.00416941f, 0.03581382f, 
    -0.02472761f, -0.02067626f, -0.02564855f, -0.00107968f, 0.00830541f, 0.01189968f, -0.03160017f, 0.01983350f, 
    -0.01941000f, -0.01034133f, -0.00916201f, 0.03884413f, 0.03288483f, 0.00333250f, -0.02645401f, 0.03231131f, 
    -0.04252864f, -0.02477485f, -0.01823990f, -0.04990588f, -0.00639418f, -0.02802063f, 0.02170985f, 0.03275502f, 
    0.01853777f, -0.01612322f, -0.04572247f, -0.06839607f, -0.04646610f, -0.05920127f, -0.03244795f, -0.05416003f, 
    -0.04348367f, 0.03244002f, -0.06338332f, -0.00260513f, 0.00561382f, -0.00858015f, 0.00489302f, -0.01414326f, 
    0.01886381f, -0.02834480f, -0.02794914f, -0.02551448f, 0.02280168f, 0.03388032f, 0.00426164f, -0.03639799f, 
    -0.03381119f, -0.05404568f, 0.01809764f, -0.03716426f, 0.00645759f, -0.04755189f, -0.00929281f, -0.03364757f, 
    0.03257869f, -0.04711169f, -0.00214055f, 0.00128276f, -0.02859567f, -0.03505686f, 0.00628864f, -0.00824281f, 
    0.00985925f, -0.03448952f, -0.02869923f, 0.02086678f, -0.00646848f, -0.03823631f, 0.03095629f, -0.04914068f, 
    0.02767563f, -0.02309379f, -0.06007678f, -0.05367184f, 0.03517380f, -0.03750136f, 0.00078519f, -0.05015023f, 
    0.02349684f, -0.03462225f, 0.02741983f, 0.00007023f, 0.02550231f, -0.05304188f, -0.06210480f, -0.02503551f, 
    -0.03104107f, -0.04873602f, -0.03234065f, -0.05506737f, -0.03753446f, 0.00633321f, 0.02137335f, -0.04335458f, 
    0.01969117f, -0.05731493f, -0.04530822f, -0.05259562f, -0.05523707f, -0.04809426f, -0.02460271f, 0.01166033f, 
    -0.03901451f, -0.03662587f, 0.03579977f, -0.01934936f, -0.03025336f, 0.02673753f, -0.03435519f, 0.03973401f, 
    0.02657826f, 0.02130219f, 0.00839780f, -0.04243281f, -0.03589144f, -0.00007705f, 0.00947543f, -0.01226960f, 
    -0.01895729f, 0.00318515f, -0.01393281f, -0.01306582f, -0.00426652f, 0.02540889f, 0.03266106f, 0.04666426f, 
    0.01947953f, 0.03667165f, 0.01703612f, 0.00789011f, 0.01474828f, -0.03478855f, -0.03005054f, -0.05469092f, 
    0.00721349f, -0.04483426f, -0.04691954f, -0.02885505f, 0.00374086f, -0.03851264f, -0.01006421f, -0.04498004f, 
    -0.02229125f, -0.03361050f, 0.00963661f, -0.00570259f, -0.01899175f, -0.00894184f, -0.03625882f, 0.03646983f, 
    -0.06085589f, -0.02906052f, 0.00912187f, -0.03321747f, 0.00986657f, -0.01583320f, 0.01866453f, 0.00700445f, 
    0.00447782f, 0.01885675f, 0.00005368f, 0.01630230f, -0.03153081f, 0.03110772f, 0.01313774f, -0.02488849f, 
    -0.01829479f, 0.03781336f, -0.04573916f, 0.00771308f, 0.03061463f, 0.01626927f, 0.03356146f, 0.03011672f, 
    0.02822173f, -0.03593233f, 0.02775871f, -0.01801796f, -0.04527768f, 0.00569874f, 0.02588794f, -0.00884648f, 
    -0.00261881f, 0.01633289f, 0.02582680f, 0.02134629f, -0.03081577f, 0.03274744f, 0.02743193f, -0.04500155f, 
    -0.00244321f, -0.03579628f, 0.00140500f, -0.05475703f, 0.03247083f, 0.02892334f, -0.00396390f, -0.01232598f, 
    0.03096082f, 0.04560789f, -0.05999924f, -0.03817050f, -0.04540551f, -0.05029710f, 0.03217028f, -0.04173549f, 
    -0.36155245f, 0.22962107f, -0.29555443f, 0.04298665f, -0.10121302f, -0.15280928f, 0.14505894f, -0.14187808f, 
    -0.05395531f, -0.05440291f, 0.12051918f, -0.09052794f, 0.23922710f, -0.06787587f, -0.09108236f, 0.06528051f, 
    0.11935654f, -0.05548145f, -0.04214254f, -0.10366379f, 0.12941982f, 0.07331185f, -0.06738079f, 0.15481514f, 
    -0.02790569f, -0.16315058f, -0.11125294f, -0.09602945f, 0.04760727f, 0.08019908f, 0.05768573f, 0.02174838f, 
    -0.09819981f, -0.05220828f, 0.05881923f, -0.08646135f, -0.07346956f, -0.00830780f, 0.28703615f, -0.51077843f, 
    -0.03934084f, -0.01284764f, -0.16765858f, 0.00185259f, -0.11332923f, -0.07474804f, 0.18545102f, 0.00224360f, 
    0.07906696f, 0.05748750f, 0.21406956f, 0.07676714f, -0.09035123f, -0.18331283f, 0.09315477f, 0.05490408f, 
    -0.02253493f, 0.00927846f, -0.01893910f, 0.16283736f, 0.08282312f, 0.13251245f, 0.12890220f, 0.28510273f, 
    -0.00154660f, 0.04596667f, 0.05553336f, 0.16399099f, -0.07839168f, 0.03269091f, 0.03793763f, 0.00133668f, 
    -0.13226911f, -0.31177917f, -0.34997839f, 0.08033021f, -0.02190031f, 0.03398611f, -0.06565038f, 0.04952467f, 
    -0.04686977f, 0.17495929f, -0.18222989f, 0.02990314f, 0.05081776f, -0.04713000f, -0.25083402f, -0.03789823f, 
    0.03588640f, 0.02438382f, 0.02574025f, -0.00123423f, -0.15497598f, -0.02291827f, -0.22668870f, -0.06525984f, 
    0.17475922f, -0.11473954f, 0.04537904f, 0.06791148f, -0.14498468f, -0.10240646f, -0.10235646f, -0.02934684f, 
    -0.04016589f, 0.07264590f, -0.06142006f, -0.03159310f, 0.03737381f, 0.13219419f, 0.02943245f, -0.06881769f, 
    -0.03108562f, 0.04077874f, -0.03436486f, -0.05859733f, -0.11807473f, -0.02572216f, 0.14060873f, 0.19548127f, 
    -0.05947635f, 0.17746104f, -0.11147854f, -0.08295608f, -0.02733274f, 0.09808900f, -0.19365928f, -0.14997764f, 
    0.06929356f, -0.09976789f, 0.03446140f, 0.04896286f, 0.06748601f, 0.07606909f, 0.02674836f, -0.35803854f, 
    0.00568233f, -0.06219962f, -0.03793731f, -0.11981010f, -0.02281702f, 0.04688698f, 0.06411197f, -0.02087277f, 
    0.08664083f, 0.12429157f, 0.22575195f, 0.10285522f, 0.05074858f, 0.05057173f, 0.14422093f, -0.05669022f, 
    -0.23467208f, -0.01904667f, 0.07490514f, 0.05608892f, 0.10683412f, 0.14551090f, -0.04486056f, 0.10317137f, 
    0.08437784f, 0.10900683f, 0.02557248f, 0.15324149f, 0.06111612f, 0.00249761f, -0.09154954f, -0.01749002f, 
    -0.11426508f, 0.17740715f, 0.05291086f, 0.12113793f, -0.06773444f, 0.00808237f, -0.22907457f, -0.22753590f, 
    -0.01760335f, -0.09195319f, 0.03802890f, -0.05478568f, 0.04294440f, 0.07661596f, 0.14217365f, -0.15784332f, 
    0.01068764f, -0.01679996f, -0.00822946f, -0.05503749f, 0.11204740f, 0.07713807f, -0.08519667f, -0.04424540f, 
    0.05283071f, 0.10675876f, 0.10535435f, 0.31043014f, -0.03807937f, 0.00011844f, 0.02433047f, 0.05954622f, 
    -0.03511203f, -0.15427859f, -0.09050020f, -0.00861207f, -0.06155274f, 0.06506343f, 0.23616481f, -0.24980670f, 
    -0.01756318f, 0.06361146f, -0.26068446f, 0.06768512f, 0.03844009f, -0.09309179f, -0.03462202f, 0.03323120f, 
    0.03181535f, 0.18841331f, 0.21815625f, 0.19806363f, -0.04069579f, 0.15309763f, -0.00365898f, 0.03422117f, 
    -0.04507397f, -0.05713455f, 0.00192174f, -0.06994398f, -0.10187421f, -0.26986209f, -0.22423171f, 0.01158688f, 
    0.03770091f, 0.07584468f, -0.09886664f, -0.03963234f, 0.17229396f, 0.07918862f, -0.10028125f, -0.07287557f, 
    0.01332539f, -0.06338304f, 0.04386968f, 0.28797880f, -0.19053297f, 0.05081729f, 0.00906701f, -0.01859402f, 
    0.11460149f, 0.00285655f, 0.05477662f, 0.04470405f, 0.05791577f, 0.02272111f, -0.21798126f, -0.13006017f, 
    0.00291244f, -0.11588186f, -0.05388493f, -0.01626058f, -0.12903368f, 0.01304996f, 0.01169856f, 0.18508229f, 
    0.20556459f, 0.40058729f, 0.33971104f, 0.20396204f, -0.01769094f, -0.00232197f, 0.04726053f, -0.08382441f, 
    -0.01072340f, 0.04440042f, -0.03246894f, 0.12071703f, -0.02244093f, 0.04031504f, -0.08422468f, 0.04053527f, 
    0.04015269f, 0.14419679f, -0.03939759f, -0.05310249f, -0.02138979f, 0.00099393f, 0.01447714f, -0.07221886f, 
    0.01138579f, -0.01809849f, 0.07855844f, 0.15750322f, -0.20356329f, 0.01632178f, -0.05474359f, 0.08084472f, 
    0.06611585f, 0.18148531f, -0.00918431f, 0.22959292f, 0.15161107f, 0.08537341f, 0.10890428f, 0.33638528f, 
    -0.08676790f, -0.11836670f, -0.08346264f, -0.03925507f, 0.09137282f, 0.04323863f, -0.00058556f, 0.05593901f, 
    -0.16157915f, -0.12196326f, -0.26630813f, 0.22082500f, -0.00832591f, -0.17382078f, -0.00688737f, -0.07452358f, 
    -0.09622309f, 0.04605525f, -0.06945049f, -0.00345151f, 0.49800923f, 0.01901250f, 0.33174622f, 0.31130007f, 
    0.11332460f, -0.02332464f, 0.02131298f, -0.20034108f, 0.01312897f, 0.01317741f, -0.05383867f, -0.01843455f, 
    -0.31181562f, -0.07664605f, 0.09374472f, -0.18232094f, -0.06165240f, 0.00032485f, -0.06722538f, 0.03187783f, 
    0.02583044f, -0.08220061f, -0.02299413f, -0.00499740f, -0.11613475f, -0.02898829f, -0.01313692f, -0.10351720f, 
    -0.08219376f, 0.00555014f, -0.09079205f, -0.06678944f, -0.04623835f, 0.02218857f, 0.03228220f, -0.06895983f, 
    0.42919314f, -0.35651395f, -0.33133391f, 0.03844653f, 0.15509582f, -0.10065870f, -0.20817497f, -0.10073222f, 
    -0.08185648f, -0.37350518f, 0.15129989f, -0.00429195f, 0.01424238f, 0.12590253f, 0.16736299f, 0.05379542f, 
    -0.04715530f, -0.02084590f, -0.03827050f, 0.10048019f, -0.08249287f, -0.00425492f, -0.00106776f, 0.02775987f, 
    0.12212551f, 0.25674921f, -0.26034400f, 0.16863549f, 0.17420357f, -0.10782228f, 0.05611150f, -0.12308447f, 
    0.07846580f, -0.01515665f, 0.06838310f, -0.07753510f, 0.09626371f, -0.14949608f, 0.06418842f, -0.11348528f, 
    0.03087547f, -0.05915571f, 0.03998414f, -0.06273694f, 0.04775482f, 0.11211700f, 0.03822411f, -0.21619329f, 
    0.10582270f, -0.00212839f, 0.19224794f, 0.17445749f, 0.07621972f, -0.05328378f, -0.01675771f, 0.07628074f, 
    -0.01494765f, 0.10177030f, 0.00729533f, -0.09488574f, -0.15457259f, 0.05063713f, 0.23589437f, -0.03286051f, 
    -0.06502054f, -0.05942249f, -0.01092170f, 0.02384050f, -0.02020035f, -0.10042419f, 0.10067741f, -0.04781888f, 
    -0.05817051f, 0.15470438f, 0.04245701f, 0.14742634f, -0.00286500f, -0.07548873f, 0.20707327f, 0.14066067f, 
    -0.03510646f, 0.00819208f, 0.06322210f, -0.04802214f, 0.01335029f, -0.12321743f, 0.00196277f, 0.08705519f, 
    0.10201051f, 0.10703749f, 0.00601475f, 0.01380805f, -0.16585198f, -0.01504671f, -0.05590406f, -0.00667183f, 
    -0.02487188f, -0.27652708f, -0.30173495f, -0.04663936f, -0.04467573f, 0.06317010f, 0.01728184f, 0.07072710f, 
    0.17002848f, 0.05340217f, 0.09657484f, -0.01005792f, -0.13086289f, 0.04695795f, -0.30293185f, 0.02883300f, 
    -0.12053071f, 0.01099361f, 0.03317564f, 0.04455829f, -0.02891842f, -0.04984068f, -0.02920823f, -0.10611896f, 
    0.33047041f, 0.13978487f, 0.19774044f, -0.29727498f, 0.03906654f, 0.09525828f, -0.12249893f, -0.01312368f, 
    0.01914698f, -0.10160121f, -0.11735904f, 0.02044300f, -0.06930548f, 0.02448537f, 0.01977955f, 0.04342404f, 
    -0.03415416f, -0.01404997f, -0.04923677f, -0.04959641f, 0.11279356f, 0.06111836f, 0.12337449f, -0.01949318f, 
    -0.28952473f, 0.31132981f, -0.08480277f, 0.02640623f, -0.06962562f, -0.04602369f, 0.03104214f, 0.05389562f, 
    -0.08113225f, -0.04978915f, 0.03693404f, -0.08212901f, 0.10431693f, -0.01419600f, 0.40203020f, -0.03070800f, 
    -0.01415808f, 0.10515589f, -0.03849578f, 0.17338440f, -0.09527921f, 0.01786093f, -0.02149353f, -0.06637762f, 
    -0.03763388f, -0.16988049f, -0.04631577f, 0.22771890f, -0.05876915f, -0.02438328f, 0.23228841f, -0.07579479f, 
    0.11588743f, 0.13918200f, -0.34237322f, -0.12829718f, 0.13138619f, -0.09821069f, -0.14648023f, 0.04529723f, 
    0.06931424f, 0.15158568f, -0.02161462f, 0.07163113f, -0.04580291f, -0.00953774f, 0.09806775f, -0.10360298f, 
    0.37631240f, 0.19093323f, 0.03284810f, -0.13740918f, 0.12261397f, 0.06973347f, 0.09901346f, 0.11820638f, 
    -0.03774936f, 0.08561981f, 0.00899292f, 0.10753608f, 0.03224807f, 0.06551810f, 0.25632307f, -0.00928566f, 
    0.18025205f, -0.00933717f, -0.14467785f, 0.01620363f, 0.02632251f, 0.07106625f, 0.04422111f, -0.01096742f, 
    -0.06828696f, -0.11919983f, -0.11161190f, 0.13979787f, -0.04746754f, -0.12358495f, 0.02145461f, 0.01092572f, 
    -0.09257432f, -0.03332462f, 0.01534705f, -0.02238962f, -0.19184238f, 0.10048621f, 0.45217296f, 0.10484830f, 
    0.09305131f, -0.04027224f, -0.24638489f, 0.12260512f, -0.00842673f, -0.12346750f, 0.02466912f, -0.02884631f, 
    -0.17766760f, 0.04881823f, 0.04510135f, 0.13783041f, -0.03149516f, 0.26733518f, 0.06268157f, 0.03005577f, 
    -0.01440924f, -0.06070265f, -0.07831576f, -0.07146337f, -0.24811132f, -0.02181314f, -0.20439090f, -0.02831379f, 
    -0.05154634f, 0.01690709f, 0.08065616f, -0.00774675f, 0.14002897f, 0.06206853f, 0.12381197f, -0.00249813f, 
    0.20867351f, -0.33815870f, 0.11424804f, -0.09659819f, 0.15559794f, 0.13759589f, 0.05249889f, 0.08578568f, 
    0.00896996f, 0.00143493f, -0.05046399f, -0.02707450f, 0.13755791f, 0.30599144f, 0.01286750f, -0.04813140f, 
    -0.22623155f, 0.06961078f, 0.00398178f, 0.13417378f, -0.07330714f, -0.02459621f, -0.12571828f, 0.04103965f, 
    -0.19163878f, 0.48569143f, 0.15664549f, 0.10887581f, -0.04110783f, 0.14130241f, -0.02254460f, -0.09458629f, 
    -0.07416815f, -0.04665972f, 0.01994082f, 0.10914979f, -0.16279379f, -0.08398626f, 0.03108281f, 0.12975432f, 
    -0.01882743f, 0.10662509f, -0.12885483f, 0.02160805f, 0.03027907f, -0.00131283f, -0.20146984f, 0.27232698f, 
    -0.26776317f, -0.15455408f, -0.10323136f, -0.31365937f, -0.02719413f, -0.17504224f, -0.22445442f, -0.13274673f, 
    0.04423511f, 0.05711076f, 0.02357786f, 0.01686322f, -0.25243890f, -0.03829566f, 0.17918846f, -0.10277485f, 
    -0.13605203f, -0.18345839f, 0.00708334f, -0.10898765f, -0.04838610f, -0.06388670f, -0.01386847f, 0.04181970f, 
    0.24111424f, -0.20958088f, 0.26358783f, 0.28331366f, -0.08959885f, 0.19495170f, -0.09876298f, 0.09653067f, 
    0.08099102f, -0.04100082f, 0.00642488f, 0.07092998f, -0.30668858f, 0.07828833f, -0.11249272f, 0.00800454f, 
    -0.05872140f, -0.01170724f, 0.10222698f, -0.00501799f, 0.07816160f, -0.03725046f, -0.07095009f, 0.04336569f, 
    -0.15870960f, -0.03885809f, 0.13282645f, 0.15608530f, -0.02569423f, 0.02359978f, -0.05637829f, -0.00414013f, 
    -0.00877857f, -0.08277261f, -0.01769384f, 0.17577250f, -0.03320161f, 0.20262401f, 0.21917596f, 0.09386548f, 
    0.02295731f, -0.06638381f, -0.01705889f, 0.06521431f, -0.08456775f, -0.17174298f, 0.07275662f, -0.12749779f, 
    0.38781568f, -0.31914607f, -0.27556384f, 0.40193307f, 0.06254449f, 0.04826125f, -0.12760761f, 0.15170863f, 
    0.03319259f, -0.02215068f, 0.09804415f, 0.07552605f, -0.24486773f, 0.24038428f, 0.24234253f, 0.28178853f, 
    0.01331354f, 0.11776292f, 0.08791830f, -0.01921385f, 0.03748684f, -0.02512904f, 0.03964670f, 0.05320023f, 
    -0.36107165f, -0.38179821f, 0.10752740f, 0.38942364f, -0.02996462f, 0.01319906f, -0.02429434f, 0.07357473f, 
    -0.03009437f, 0.05850328f, -0.09263638f, 0.16571239f, 0.09671314f, 0.07794057f, -0.09390976f, -0.00604032f, 
    -0.02070256f, 0.01605855f, 0.06592726f, -0.02492581f, 0.32618159f, 0.00752455f, 0.09741306f, 0.22280844f, 
    -0.06171801f, -0.07299101f, -0.09311969f, -0.05701964f, 0.11252725f, 0.09438856f, -0.01468143f, -0.03689570f, 
    -0.04100029f, 0.05240726f, -0.17389441f, 0.17894159f, 0.37806144f, -0.00715348f, -0.16416095f, -0.26292509f, 
    0.15474087f, 0.08352505f, 0.14149010f, -0.02790919f, 0.07393681f, 0.16593984f, -0.01814166f, 0.05698856f, 
    -0.58758903f, -0.21620609f, 0.28152820f, 0.21278834f, -0.03774280f, 0.05994827f, -0.13366979f, 0.00993284f, 
    0.05276242f, 0.19017930f, 0.00700214f, -0.02300307f, -0.25748488f, -0.13963087f, -0.02510717f, -0.05521986f, 
    -0.19182232f, -0.15132417f, 0.08654484f, -0.06590396f, 0.07908828f, 0.00374148f, -0.07539836f, -0.06319186f, 
    -0.26582527f, 0.03504957f, 0.46015599f, 0.09109052f, 0.02075715f, -0.03975178f, -0.14143577f, -0.06476309f, 
    0.13782617f, -0.03340342f, 0.02467972f, 0.08957600f, -0.06692415f, -0.01122493f, -0.00407942f, -0.01854399f, 
    0.09910385f, -0.01067620f, -0.06024424f, 0.05889034f, -0.02105229f, -0.05209247f, -0.00603015f, -0.14930952f, 
    -0.20829250f, -0.25535017f, 0.23871419f, 0.16610846f, 0.37337703f, 0.05748359f, 0.03912574f, 0.08444692f, 
    0.10093845f, -0.04014877f, 0.06749001f, -0.05550972f, 0.32714114f, 0.17926864f, -0.11839718f, -0.10297136f, 
    0.01924593f, 0.04589566f, 0.18567471f, 0.10283999f, 0.13423739f, 0.05408913f, 0.16984305f, 0.08301266f, 
    -0.11189896f, -0.11506156f, -0.01181434f, -0.11129401f, 0.06712149f, 0.07246464f, 0.03554769f, 0.16891053f, 
    0.06652932f, -0.00100206f, 0.00474060f, -0.02433934f, 0.19140953f, 0.02986984f, -0.17669503f, -0.06387091f, 
    0.10663819f, 0.11319542f, 0.14675741f, 0.05743765f, 0.02627548f, 0.05434955f, -0.02855504f, 0.00980343f, 
    -0.14071831f, 0.39311099f, 0.30970743f, 0.09521645f, -0.02382311f, -0.12304866f, -0.14667404f, -0.13077541f, 
    0.02304766f, -0.08320650f, 0.06153592f, 0.20536040f, -0.07353805f, -0.01376416f, 0.21325210f, 0.12955070f, 
    0.02863655f, -0.06197283f, -0.09595461f, -0.07459705f, 0.02258155f, 0.17756203f, -0.16023867f, 0.12809496f, 
    -0.19618079f, 0.10974163f, -0.13610028f, -0.05920016f, 0.02424371f, -0.06945345f, -0.04589924f, -0.03595750f, 
    0.09185652f, 0.05333278f, -0.05226539f, 0.04384892f, 0.09497194f, 0.03976351f, -0.33191469f, -0.11779121f, 
    0.00685547f, -0.06591593f, 0.14126441f, 0.18000054f, 0.00538693f, 0.12421675f, -0.07251015f, -0.05413735f, 
    -0.05663677f, 0.18249768f, 0.25980514f, -0.15653938f, -0.04965360f, -0.03430865f, -0.05784988f, 0.07358706f, 
    0.16198114f, 0.01950335f, 0.13108632f, 0.27182445f, 0.31394565f, 0.17047240f, -0.30774015f, -0.01157021f, 
    0.14411907f, 0.08807770f, 0.30731389f, 0.02106094f, 0.06757010f, -0.09871546f, -0.11639221f, -0.00646628f, 
    -0.15475695f, -0.11688842f, 0.18447532f, -0.18873398f, 0.06130808f, -0.06659625f, 0.04151541f, -0.16689545f, 
    0.05355601f, -0.03912029f, 0.01089250f, -0.00854829f, -0.02975367f, -0.05296484f, 0.05393829f, 0.00069879f, 
    0.10782786f, -0.04432227f, -0.00034594f, -0.10073978f, 0.03063986f, 0.06037048f, 0.10485819f, 0.05133056f, 
    -0.21344604f, -0.12841864f, 0.24349508f, 0.08075368f, -0.08728749f, -0.12671092f, -0.16438639f, -0.10150338f, 
    -0.04931784f, 0.10047884f, 0.00666061f, -0.00721434f, 0.08345982f, -0.25950015f, 0.16988271f, -0.05958810f, 
    0.13381873f, 0.23129344f, -0.00385518f, 0.18608832f, 0.11296304f, -0.04870327f, -0.02649205f, 0.00284810f, 
    -0.13833682f, -0.07785583f, 0.03579735f, -0.09121412f, -0.01279848f, -0.17599742f, 0.09760815f, -0.03671425f, 
    0.12247749f, 0.09388875f, 0.14169827f, 0.01254401f, 0.25584862f, -0.04058436f, -0.08762369f, -0.06599959f, 
    0.02181837f, -0.06824482f, 0.04949617f, 0.13786000f, 0.02177224f, -0.10433053f, 0.12078250f, 0.10400689f, 
    -0.02092889f, 0.11898240f, 0.15222211f, 0.08339839f, -0.00617537f, 0.05758511f, 0.10536487f, -0.01563395f, 
    0.14839174f, 0.06264836f, 0.21133865f, 0.01198946f, -0.49425542f, -0.21800700f, 0.10592793f, -0.01311229f, 
    -0.01923728f, -0.06292108f, 0.03349029f, 0.05183256f, 0.03497653f, 0.04295089f, 0.07897439f, 0.00885502f, 
    -0.15743558f, -0.27041602f, -0.03673499f, 0.34106651f, -0.12738802f, -0.04441988f, -0.15659092f, 0.29018420f, 
    -0.16185890f, -0.09271792f, 0.01515422f, -0.06653861f, -0.38965663f, 0.17389412f, 0.32477131f, -0.03407661f, 
    -0.05118307f, -0.16654921f, -0.00066051f, 0.02341393f, -0.06316209f, 0.11914801f, 0.13198364f, 0.06394002f, 
    0.44335681f, -0.09359102f, -0.16140620f, -0.05179610f, -0.06963404f, 0.03120459f, 0.07946854f, -0.04461022f, 
    0.11174645f, -0.06764235f, 0.09421403f, 0.05033197f, 0.14304347f, -0.18584372f, -0.13966550f, -0.11507902f, 
    0.07489830f, 0.13740385f, 0.05025237f, 0.04961585f, 0.06059687f, -0.11232183f, -0.08094905f, -0.07090768f, 
    -0.26952454f, 0.44156602f, 0.03152065f, -0.12676920f, 0.17044191f, -0.23773521f, -0.10449088f, 0.00786093f, 
    0.02770564f, -0.01933372f, -0.05364398f, 0.05425441f, 0.02758529f, 0.03572027f, 0.06042599f, 0.12625669f, 
    -0.04340157f, -0.01930122f, 0.13185713f, -0.14290242f, 0.10776096f, -0.11902805f, 0.00483128f, -0.04666617f, 
    0.51179212f, 0.19121481f, 0.23494563f, -0.21028954f, 0.09178634f, 0.07953715f, -0.08322190f, 0.09110321f, 
    0.01758872f, 0.07837410f, -0.07570904f, -0.06037007f, 0.23895954f, 0.13617952f, -0.06036160f, 0.21514601f, 
    -0.22573651f, 0.08717696f, 0.16173469f, -0.15256490f, -0.15908524f, 0.00675675f, 0.31152502f, 0.36994272f, 
    0.09698909f, 0.20908841f, -0.14765990f, -0.15442672f, -0.07057400f, -0.06551705f, -0.18553419f, -0.00655844f, 
    -0.07684561f, -0.03961999f, -0.06336980f, -0.16262664f, -0.27642336f, 0.04386465f, -0.14551872f, 0.13039644f, 
    0.19256261f, -0.04954446f, 0.02465861f, -0.15722591f, -0.00341012f, -0.09677474f, 0.03699761f, -0.10516139f, 
    0.04524490f, 0.22797103f, 0.03259937f, -0.00625962f, 0.06945461f, -0.02901821f, 0.10767619f, 0.07304247f, 
    0.03319926f, 0.15442193f, -0.04053979f, 0.04722970f, 0.09514238f, -0.01497863f, 0.09205999f, 0.19251905f, 
    0.02935218f, 0.06591692f, 0.09699064f, -0.02964925f, -0.16878264f, -0.11027883f, -0.19567208f, -0.07736365f, 
    0.56861627f, 0.22563617f, -0.05435344f, -0.35694745f, -0.28489491f, -0.14114270f, -0.03726971f, 0.03344706f, 
    0.08826265f, 0.00178334f, 0.18175252f, -0.07148059f, -0.08611586f, -0.00950135f, -0.06887306f, -0.04479137f, 
    0.09287879f, -0.14865200f, 0.07354711f, -0.09969607f, -0.18636557f, -0.10124908f, -0.21455209f, -0.24569930f, 
    0.06988936f, 0.38705349f, 0.13854256f, 0.04758941f, 0.42170608f, -0.00181296f, -0.05374012f, 0.09990338f, 
    -0.24738431f, -0.20678656f, -0.22719646f, -0.35499108f, -0.14868535f, 0.02140837f, -0.09632970f, 0.20578846f, 
    -0.00856291f, -0.12344590f, 0.12696102f, -0.03823591f, 0.18248439f, 0.14587240f, 0.11835709f, 0.30146953f, 
    -0.01358105f, 0.18881646f, 0.08300896f, -0.09485533f, 0.12631914f, -0.20560291f, 0.06968494f, 0.11749531f, 
    -0.21942201f, 0.06562747f, -0.18308489f, -0.03838701f, -0.36850077f, -0.01730982f, -0.10300039f, 0.01203068f, 
    -0.04497846f, 0.01246661f, -0.11875344f, -0.02303479f, -0.05521042f, -0.01645294f, -0.23954102f, -0.17159815f, 
    0.22850309f, 0.13102032f, -0.07522370f, 0.22625135f, -0.04382886f, -0.21266337f, -0.09835579f, 0.14107597f, 
    0.02734175f, -0.03247697f, -0.11863960f, -0.25160465f, 0.18178941f, 0.07677492f, 0.03651226f, 0.15521774f, 
    -0.10752074f, 0.04789948f, -0.07878572f, -0.02629277f, -0.08912273f, 0.09149535f, -0.11844242f, -0.19892824f, 
    -0.02770781f, -0.08071263f, 0.02702836f, -0.02233589f, 0.12794347f, -0.08016150f, 0.07457004f, 0.04519447f, 
    -0.10611470f, -0.04461756f, 0.07225893f, 0.15743166f, -0.04727984f, 0.06080217f, -0.18063790f, 0.16744991f, 
    -0.11241096f, -0.08191327f, -0.06586285f, 0.15919811f, 0.05129385f, 0.09204330f, -0.05226839f, -0.03657155f, 
    0.05895745f, -0.03821317f, 0.04581292f, 0.22556347f, 0.04664907f, -0.00266215f, -0.00871849f, -0.00500763f, 
    0.14984949f, 0.11904114f, -0.04570046f, 0.30785164f, -0.27140015f, 0.16024441f, 0.10994286f, 0.35857612f, 
    0.13231903f, 0.28383860f, -0.00537436f, 0.08134552f, 0.19712052f, -0.09228507f, -0.01442142f, -0.07620300f, 
    -0.17791158f, -0.05559656f, 0.05755782f, -0.13309063f, 0.04330031f, -0.01522617f, 0.00307105f, 0.01999165f, 
    -0.05883020f, -0.24280716f, -0.05903842f, -0.12152106f, 0.13572080f, -0.00797328f, 0.05318645f, -0.33026975f, 
    -0.15072866f, 0.01293976f, -0.04443587f, 0.07436633f, 0.10708416f, 0.02796178f, 0.05020956f, -0.04811580f, 
    0.24076217f, 0.03986786f, 0.19760470f, -0.07148687f, 0.04276332f, -0.03781019f, 0.04399405f, 0.20621988f, 
    -0.00816858f, 0.12976088f, 0.02116945f, -0.06558269f, -0.33076772f, 0.13510072f, 0.06578723f, 0.33819005f, 
    0.05223642f, -0.23067288f, 0.25246823f, -0.02544097f, 0.10863963f, 0.16368571f, -0.08220579f, 0.09985611f, 
    -0.08723256f, -0.17750557f, -0.15168095f, 0.39719164f, 0.13252358f, 0.13062245f, 0.06412364f, 0.03479065f, 
    0.12107288f, -0.08921151f, 0.17354512f, 0.21315859f, -0.37299210f, 0.03702982f, -0.17386715f, 0.06909548f, 
    -0.01668684f, -0.19994627f, -0.09809130f, -0.16172771f, -0.10108304f, -0.04162145f, -0.06111915f, 0.06730911f, 
    0.06616019f, 0.02337947f, 0.05498244f, 0.23994114f, 0.15533547f, 0.14777648f, 0.04211952f, -0.03315867f, 
    0.22349313f, 0.03228627f, 0.14771041f, 0.21942940f, -0.02620254f, -0.00112700f, -0.13797146f, -0.16702425f, 
    0.12381685f, 0.00269632f, -0.00296581f, 0.05940803f, 0.09990538f, 0.03502993f, -0.12340485f, 0.07680308f, 
    0.38000131f, -0.04992964f, 0.33932009f, -0.32490355f, -0.11773423f, 0.14912868f, -0.03758286f, -0.08223678f, 
    -0.17195502f, 0.05951416f, -0.17904145f, -0.16089804f, 0.13474590f, -0.13344331f, 0.07766183f, 0.25020781f, 
    -0.00667206f, 0.09415277f, 0.02359901f, 0.00766884f, 0.10784337f, 0.11454631f, -0.02269005f, 0.20515995f, 
    -0.21888757f, -0.16862912f, 0.04537794f, -0.04449643f, -0.05291840f, -0.03656996f, -0.12712842f, -0.10771483f, 
    0.18043940f, -0.27039880f, -0.03704670f, 0.18582995f, -0.26085201f, -0.07011446f, -0.00481017f, 0.04631416f, 
    0.08389132f, -0.08921523f, -0.16180573f, -0.05063768f, -0.17763247f, -0.32946318f, 0.00258876f, -0.14599682f, 
    0.33942258f, 0.22282949f, -0.16304813f, 0.30486506f, -0.03313055f, 0.25376946f, -0.07268686f, -0.03404073f, 
    -0.05729864f, -0.12011197f, 0.09519179f, -0.26533738f, 0.09178299f, 0.11318558f, 0.06338487f, 0.29070690f, 
    0.12413090f, 0.17220989f, -0.00386862f, -0.09700892f, -0.02935032f, -0.11037645f, -0.01344184f, -0.16633689f, 
    -0.14039935f, 0.33622083f, 0.23119131f, -0.15086119f, 0.07975747f, 0.21439897f, -0.04851664f, 0.02192153f, 
    -0.07399201f, 0.07856258f, -0.16244562f, 0.09156846f, 0.03271659f, 0.02845862f, 0.21283427f, -0.09665123f, 
    -0.10452225f, 0.04363463f, 0.01490149f, -0.16327760f, -0.06617669f, -0.07384182f, -0.01028313f, 0.06490985f, 
    0.12474968f, -0.04154249f, -0.00059159f, -0.06355786f, -0.07859333f, 0.12775120f, -0.17936715f, 0.03250218f, 
    -0.07886107f, -0.05825660f, -0.09622598f, -0.05730099f, -0.19485205f, -0.18299663f, -0.68795991f, 0.39455894f, 
    -0.06930465f, -0.08146120f, 0.00978092f, -0.09423633f, -0.02069760f, -0.12985772f, -0.09183826f, -0.06959459f, 
    -0.08354020f, 0.34305635f, -0.11246052f, 0.01089338f, 0.20995252f, 0.00061371f, -0.05355411f, -0.09054736f, 
    -0.11667576f, 0.04115349f, -0.00168721f, 0.00936998f, 0.37534502f, 0.37410432f, 0.42120960f, 0.25575364f, 
    0.01979176f, 0.06688997f, 0.12120851f, -0.02428906f, 0.04989934f, 0.11504500f, -0.06411652f, 0.06066916f, 
    0.33792534f, -0.03093103f, 0.15031675f, -0.24671519f, 0.03052289f, 0.02910632f, -0.00529370f, -0.03062004f, 
    0.00117606f, -0.05306762f, -0.00240767f, -0.02759995f, -0.18815294f, 0.11582131f, -0.05552430f, -0.05777266f, 
    0.09282789f, -0.08726878f, 0.04476683f, 0.00170800f, -0.02911931f, -0.00556375f, 0.12504527f, 0.00797831f, 
    0.17287998f, 0.20362912f, 0.31488439f, 0.25495994f, 0.15479407f, 0.16069786f, 0.17488940f, 0.38183603f, 
    0.07721400f, -0.01712780f, 0.01938331f, -0.11035568f, -0.09147152f, -0.20694038f, -0.07333013f, 0.02501656f, 
    -0.03887341f, -0.09606376f, -0.09631535f, 0.07217517f, -0.10103036f, -0.17395844f, -0.13978100f, -0.17473327f, 
    -0.08709143f, -0.00937306f, -0.05365398f, 0.08235661f, 0.05264729f, -0.16380405f, 0.12992245f, 0.02884232f, 
    -0.14243792f, -0.00431012f, -0.13108864f, 0.00781688f, -0.01058785f, -0.20573170f, -0.26551241f, 0.01897015f, 
    -0.21257266f, -0.01701342f, -0.14512852f, 0.03041357f, 0.11167693f, -0.01349683f, -0.05785246f, -0.02466052f, 
    0.19666289f, 0.10181702f, -0.13924606f, 0.11870084f, -0.00313210f, -0.02497879f, -0.01208851f, 0.06924091f, 
    0.00205307f, 0.12221667f, -0.05088125f, -0.05274545f, 0.23230480f, -0.11292766f, 0.06906773f, 0.01815035f, 
    -0.03160974f, 0.16718216f, -0.07391747f, -0.08615269f, -0.01919064f, 0.09151334f, -0.04912762f, -0.06459714f, 
    0.20492819f, 0.01905025f, 0.18941920f, 0.19574544f, 0.07126722f, -0.09567554f, -0.06670044f, -0.02268368f, 
    -0.04917818f, -0.01158905f, -0.01973775f, -0.07935399f, -0.11283020f, -0.28700861f, 0.00273423f, -0.07026614f, 
    -0.11024152f, -0.07613346f, -0.10878087f, 0.14780170f, -0.02209955f, -0.03709331f, 0.00596183f, -0.07354861f, 
    0.06735098f, -0.05289296f, 0.02218237f, 0.09754652f, 0.21051496f, 0.00355290f, -0.01192285f, -0.08209668f, 
    -0.08167327f, 0.04441016f, -0.16093966f, -0.01567185f, 0.00772282f, -0.25067446f, -0.03700138f, 0.18683752f, 
    0.01332749f, 0.00708790f, 0.02289350f, 0.18044183f, 0.05831064f, 0.07714136f, -0.03180892f, -0.11129724f, 
    0.24841057f, 0.15971862f, 0.20718026f, 0.46452394f, 0.03850939f, 0.00112618f, -0.07008775f, 0.02328544f, 
    0.03088609f, 0.01714881f, 0.01851368f, 0.08077916f, -0.04604906f, -0.04405005f, 0.07353235f, -0.14629051f, 
    0.06954183f, -0.05079425f, 0.05852755f, -0.02664989f, -0.04505617f, 0.05161407f, -0.02431542f, -0.10826144f, 
    0.27352896f, 0.42195576f, 0.32152930f, 0.21636471f, 0.05813253f, 0.07479697f, 0.06940562f, 0.08689193f, 
    -0.10328267f, -0.04125210f, -0.07008205f, -0.07268269f, -0.09021638f, -0.21971266f, 0.24840030f, 0.27984104f, 
    -0.00852671f, 0.07190397f, 0.02599807f, -0.01391214f, -0.00228744f, 0.02369126f, 0.03024977f, -0.09339186f, 
    0.16067502f, -0.35289103f, -0.22962946f, 0.37326396f, 0.11159199f, -0.12678820f, -0.11947715f, 0.10506831f, 
    -0.00871257f, -0.03941421f, -0.01913294f, 0.14233612f, -0.09688475f, -0.16176835f, -0.26607054f, 0.00916771f, 
    -0.07394760f, -0.14017504f, -0.02698047f, -0.01071676f, -0.00113566f, -0.09652191f, 0.02865321f, 0.03050966f, 
    0.38326067f, 0.21395858f, 0.18791786f, 0.36856321f, 0.16903187f, -0.01253787f, 0.09836745f, 0.13481085f, 
    -0.08820967f, -0.09944735f, -0.02104986f, 0.02880983f, 0.09107072f, 0.04514432f, -0.14238797f, -0.08924010f, 
    0.23769195f, 0.12870811f, -0.00185812f, 0.02602821f, -0.06776491f, -0.06684239f, -0.05566238f, 0.01689544f, 
    -0.03678206f, 0.17875746f, 0.07191273f, -0.32443091f, -0.12218027f, 0.08646072f, -0.04726560f, 0.06627961f, 
    -0.12485067f, 0.02211749f, -0.02207736f, 0.03940829f, 0.05911933f, 0.14704908f, -0.26794773f, -0.02848636f, 
    0.21902704f, 0.00496767f, 0.10136362f, 0.05147043f, -0.05617222f, 0.03573320f, 0.03623452f, -0.06413885f, 
    -0.15486258f, -0.29586211f, -0.25434870f, -0.06169086f, -0.07121738f, -0.07167840f, -0.03403997f, -0.06117147f, 
    -0.05057483f, -0.09854670f, -0.14221016f, -0.09615663f, -0.14473073f, -0.23439124f, -0.17288876f, -0.01402842f, 
    -0.03621439f, -0.00861819f, 0.01481416f, 0.01466832f, 0.05231220f, 0.14372110f, -0.00920960f, -0.03152239f, 
    0.23345628f, 0.40631929f, -0.04169332f, 0.29612079f, -0.04669156f, 0.16529803f, -0.00427240f, -0.05926305f, 
    -0.01242768f, 0.05411729f, -0.07278249f, -0.09167830f, 0.41075754f, 0.12112255f, 0.30770925f, 0.36144394f, 
    0.03369303f, 0.04092338f, 0.03968011f, 0.18051533f, 0.02082225f, 0.00865829f, -0.02607013f, -0.07838538f, 
    0.49435130f, -0.28830147f, 0.29338387f, 0.06287318f, 0.14533706f, 0.15031263f, -0.15773274f, 0.12508798f, 
    0.20917125f, -0.02846785f, -0.02227286f, -0.04902365f, 0.17177862f, 0.17923847f, -0.22006723f, 0.05325302f, 
    -0.14187662f, -0.00035010f, 0.22426039f, -0.06776597f, 0.03616952f, 0.11477603f, 0.31318772f, 0.30563045f, 
    0.02584831f, 0.07149535f, -0.10123114f, -0.11483054f, 0.01700695f, 0.01073526f, -0.12739971f, 0.03054684f, 
    -0.00480081f, -0.07344008f, -0.11699072f, 0.03140238f, -0.16166915f, 0.08831324f, -0.08964358f, -0.00631379f, 
    0.11402492f, 0.06041620f, 0.09422524f, -0.07006732f, 0.04929462f, 0.14185736f, -0.01900229f, 0.05995762f, 
    -0.25239825f, 0.27897409f, 0.14735775f, 0.03939378f, 0.04264974f, 0.09263524f, -0.09789149f, 0.10092659f, 
    0.04396422f, 0.10990413f, 0.12033124f, 0.11614998f, -0.02402278f, -0.17621617f, -0.09808288f, -0.08941105f, 
    -0.01230572f, 0.00712988f, 0.07743667f, -0.04853460f, -0.02198393f, -0.19856347f, -0.27058777f, -0.23064923f, 
    0.03045376f, 0.26853022f, 0.33686358f, 0.02387398f, 0.06156885f, -0.13394180f, -0.05131030f, 0.00131825f, 
    -0.01044374f, -0.02724379f, 0.20351781f, 0.06570276f, -0.24509481f, -0.18303858f, 0.04791171f, -0.22092220f, 
    0.10297390f, -0.10873597f, -0.14509529f, -0.14804704f, -0.06585243f, -0.11823802f, 0.02005336f, -0.14122373f, 
    -0.06172990f, 0.22213545f, 0.09444954f, -0.02146308f, 0.46043390f, 0.03562284f, -0.06627733f, 0.00606727f, 
    -0.12858514f, -0.22234295f, -0.03795094f, -0.17021643f, -0.13072634f, -0.01335550f, -0.18869816f, 0.02941995f, 
    -0.01909339f, 0.06720594f, 0.26964566f, 0.06527654f, 0.13997634f, 0.28010726f, 0.10460992f, 0.13780151f, 
    -0.18280143f, 0.07094706f, 0.02185166f, 0.09600049f, -0.11489499f, -0.14496797f, 0.10713406f, 0.11641593f, 
    0.02907484f, 0.12637527f, -0.11000597f, -0.01194311f, -0.27621824f, -0.04587218f, -0.19841062f, -0.03736983f, 
    0.06356625f, -0.03850315f, 0.15279667f, 0.08613545f, 0.03190725f, 0.09000479f, -0.07140873f, -0.02437547f, 
    -0.01517668f, 0.26292849f, 0.06978175f, 0.10541888f, -0.01338231f, -0.15188898f, -0.19979882f, 0.16472125f, 
    0.05223940f, -0.00807465f, 0.08288304f, -0.15388387f, 0.18805727f, 0.15071683f, 0.14322451f, 0.22033796f, 
    0.09948064f, -0.01955510f, 0.03202492f, -0.02632511f, -0.14768806f, 0.12647377f, 0.00831930f, -0.08092798f, 
    0.01169761f, -0.03456150f, -0.11091169f, 0.13366474f, 0.07379435f, 0.04652583f, 0.12074593f, 0.05834965f, 
    0.03025514f, -0.07897343f, 0.03060315f, 0.14033899f, -0.13671651f, -0.07998691f, -0.63376993f, -0.09088606f, 
    -0.14756730f, -0.04775051f, -0.04889599f, 0.18574183f, 0.00957959f, 0.10660205f, -0.00359077f, -0.13430068f, 
    -0.01262385f, 0.13174343f, 0.16236174f, -0.04874960f, -0.00004836f, -0.00502130f, -0.04563822f, 0.11780182f, 
    0.18040638f, 0.12216749f, 0.02932598f, 0.26743343f, 0.00245956f, 0.06645302f, -0.35873312f, 0.12314144f, 
    -0.00608621f, 0.18284930f, 0.11975569f, 0.05333500f, 0.01735386f, -0.03206123f, -0.00530701f, 0.03886367f, 
    -0.16784659f, -0.09345477f, 0.04508981f, -0.25827020f, 0.06244737f, -0.08803187f, -0.01586678f, -0.02203525f, 
    -0.09322060f, -0.19043463f, -0.11329072f, -0.09241547f, 0.02073784f, -0.10635532f, 0.13002096f, -0.10857573f, 
    0.01167135f, 0.05310973f, -0.03854705f, 0.00640691f, 0.00235822f, -0.02567033f, 0.07152420f, 0.06810834f, 
    0.01479662f, 0.03762143f, 0.16724384f, -0.05193413f, 0.09273192f, -0.09000734f, 0.08142083f, 0.08327769f, 
    -0.09923613f, 0.09228637f, 0.06408668f, -0.08777041f, -0.24941099f, -0.30458006f, -0.15430658f, 0.15713996f, 
    0.25421014f, -0.14309533f, 0.22018148f, -0.03037694f, 0.20445040f, 0.10427041f, -0.16428657f, 0.00830312f, 
    0.02307896f, -0.17086454f, -0.08803743f, 0.04149654f, 0.00473046f, -0.03466993f, 0.15361775f, 0.15120377f, 
    0.08669792f, -0.02314291f, 0.26659957f, 0.09989242f, -0.01878101f, 0.10052874f, -0.05102305f, 0.01729377f, 
    0.02433398f, -0.22295608f, 0.00252214f, -0.10113925f, -0.00852259f, 0.04864969f, 0.00814684f, 0.04946312f, 
    -0.03385511f, -0.07333366f, -0.01970561f, 0.05837816f, 0.03798844f, 0.11977734f, 0.13787735f, 0.06326647f, 
    0.10065569f, 0.00255398f, 0.07518302f, 0.11853518f, -0.16268314f, -0.12015007f, -0.10122807f, -0.10336881f, 
    0.09630354f, 0.01686028f, 0.03526353f, 0.10552444f, -0.00498219f, -0.03739590f, 0.03457328f, 0.06546491f, 
    0.26382643f, -0.25929031f, 0.06952779f, -0.05437623f, 0.01203320f, 0.04896396f, -0.14338833f, 0.05346566f, 
    -0.03871037f, -0.01700730f, 0.01986783f, -0.17604908f, 0.06778067f, -0.04624838f, 0.37793344f, 0.01630466f, 
    0.03394629f, 0.06203485f, 0.00711234f, 0.25433299f, -0.00137109f, 0.12283739f, 0.12079927f, 0.17753397f, 
    0.07371748f, -0.14235669f, -0.13998562f, -0.17738646f, -0.05711003f, 0.01840024f, 0.15575388f, -0.11077298f, 
    0.13838930f, -0.00753754f, 0.03145585f, 0.12159882f, -0.28001383f, -0.35553560f, -0.19392125f, -0.13855074f, 
    0.13223770f, -0.01576135f, 0.05592784f, -0.05344227f, -0.17541941f, -0.20647171f, -0.02914334f, -0.10333082f, 
    -0.09451378f, 0.43627605f, -0.01844212f, -0.18999808f, -0.07530952f, 0.13877490f, -0.03642024f, -0.09133308f, 
    -0.05353438f, -0.03545613f, -0.03704607f, -0.10289882f, 0.16413127f, -0.03121294f, -0.08062075f, 0.01462368f, 
    0.17014687f, 0.11047994f, -0.00649959f, -0.08063515f, 0.01555509f, -0.13204585f, -0.08114679f, -0.13587312f, 
    0.18432774f, -0.05894004f, -0.17877135f, 0.05524825f, 0.13468604f, 0.10958524f, -0.00019384f, -0.00532509f, 
    0.13313659f, -0.03632243f, 0.20535651f, -0.12882712f, 0.38471854f, 0.04078741f, -0.02924918f, -0.05593951f, 
    0.00488619f, -0.02349440f, -0.00886085f, -0.02940492f, -0.04690318f, 0.10031454f, 0.02219435f, -0.12526940f, 
    -0.00269216f, -0.01761297f, -0.05318748f, -0.03486292f, 0.06314681f, 0.18453938f, 0.08480135f, 0.04984325f, 
    0.05705865f, 0.07010674f, 0.08747485f, 0.02322462f, -0.14502499f, 0.27496710f, 0.56941056f, -0.01192003f, 
    -0.06255534f, 0.03439083f, -0.12672178f, -0.03913198f, 0.05849978f, -0.02771164f, 0.09642861f, 0.05248860f, 
    -0.17457634f, 0.27049717f, -0.00760669f, -0.00921205f, 0.06997219f, -0.00348555f, 0.14624536f, 0.10029982f, 
    0.05279192f, 0.01553837f, 0.08162515f, 0.07335020f, -0.09181122f, -0.24007972f, -0.09902401f, -0.05335275f, 
    0.14661612f, 0.08640032f, -0.06519572f, 0.10809296f, -0.03651432f, -0.00221817f, 0.02741774f, -0.09196164f, 
    -0.03235007f, -0.05513499f, -0.16926429f, -0.08946732f, 0.10984932f, -0.02794466f, 0.05721616f, -0.04379846f, 
    -0.00376871f, 0.09520236f, 0.09329113f, 0.00684825f, -0.10278591f, -0.07963947f, -0.04735523f, 0.00627280f, 
    -0.05826267f, -0.14254074f, -0.06240949f, -0.05733966f, -0.02968804f, -0.04797709f, -0.06347875f, 0.02689530f, 
    0.08715661f, 0.04433856f, -0.01367012f, -0.26174819f, -0.02878264f, -0.03774272f, -0.14964744f, -0.02205020f, 
    -0.01334523f, 0.02367870f, -0.02683796f, 0.04231004f, -0.05316241f, 0.12349629f, 0.09498981f, 0.14436972f, 
    -0.01503718f, 0.08047632f, -0.04737392f, -0.02574936f, 0.08330970f, 0.20657912f, 0.00520639f, -0.15936454f, 
    -0.06415855f, 0.48201156f, -0.05000216f, 0.28078666f, 0.03414433f, -0.09471131f, 0.00601830f, -0.09575108f, 
    -0.03387341f, 0.01100797f, 0.00856496f, 0.01234210f, 0.00222034f, 0.07357644f, 0.25654700f, -0.08200136f, 
    0.00028218f, -0.04758890f, 0.13596191f, -0.09784683f, -0.04388637f, 0.02712330f, 0.00707109f, 0.03265661f, 
    -0.26243019f, -0.09303080f, -0.06946510f, 0.06195271f, 0.06780121f, 0.03774699f, 0.05787296f, -0.00806058f, 
    0.12137880f, 0.13252763f, 0.06550661f, 0.00469257f, 0.17373164f, -0.12214171f, -0.26221541f, 0.10059150f, 
    0.10437389f, 0.09097736f, 0.05187149f, 0.11063630f, -0.09109514f, 0.16567163f, 0.06871983f, 0.00782440f, 
    0.11909111f, -0.05010895f, -0.06971934f, 0.10448234f, 0.08643474f, 0.19317798f, 0.00336536f, -0.06904121f, 
    0.03588368f, -0.08396351f, 0.04934145f, 0.02103420f, 0.22102205f, -0.02134000f, 0.03170991f, -0.04234115f, 
    0.05231215f, -0.07095923f, -0.07220686f, -0.01353582f, -0.02985027f, 0.09855555f, -0.05431504f, -0.07184939f, 
    -0.09375327f, 0.02981361f, -0.10793527f, -0.02414977f, -0.04512480f, 0.03977814f, 0.02975558f, 0.07010765f, 
    0.04389815f, -0.02248748f, -0.00743967f, -0.03582128f, -0.03196164f, -0.16704091f, 0.25365147f, -0.14366193f, 
    0.02064826f, -0.00855774f, -0.11042865f, 0.15538299f, -0.05062043f, -0.08445453f, -0.00166007f, 0.08509202f, 
    -0.13078609f, -0.09712303f, 0.03381197f, -0.00553364f, -0.00436993f, 0.03858553f, 0.05899464f, -0.01695136f, 
    -0.04606087f, 0.03661216f, -0.01348782f, -0.00075022f, -0.11479200f, -0.08531506f, -0.18714084f, -0.04195788f, 
    -0.04822697f, 0.06002037f, -0.09383347f, -0.06561770f, 0.04199818f, -0.04489255f, 0.24244849f, 0.14288223f, 
    -0.11496118f, -0.27017328f, -0.15664221f, 0.12807697f, 0.12894069f, 0.04984831f, 0.24107046f, 0.02547568f, 
    -0.02623161f, -0.04965215f, -0.05230571f, 0.07545100f, -0.09449445f, 0.07432500f, -0.20977424f, 0.19066232f, 
    0.03395920f, -0.26346707f, 0.09307935f, 0.04900065f, 0.00901612f, -0.09009578f, -0.00987535f, 0.11128139f, 
    0.09026485f, 0.04852023f, 0.09026307f, 0.09475721f, -0.03504310f, 0.10475814f, 0.14355050f, 0.08686414f, 
    0.02516383f, 0.09675014f, 0.16013813f, 0.07965944f, 0.08795366f, 0.02668461f, -0.05415852f, 0.10628539f, 
    -0.02781872f, 0.17297798f, 0.00128094f, -0.05188377f, 0.14713766f, 0.10127987f, 0.05982061f, -0.00539135f, 
    -0.26148716f, -0.23931013f, -0.12092278f, -0.03166920f, -0.06768353f, 0.09694830f, 0.03892559f, 0.02857518f, 
    0.07882927f, -0.01363820f, -0.10385119f, 0.06586704f, 0.00702784f, -0.08683446f, 0.02534805f, -0.01448783f, 
    -0.00453514f, -0.10372633f, 0.04773561f, 0.02435479f, -0.05193130f, 0.04937903f, -0.04666723f, -0.02767493f, 
    0.21557081f, -0.23331179f, -0.09601696f, 0.11356550f, 0.01639883f, 0.00750832f, -0.01208178f, 0.05009000f, 
    0.07711660f, 0.18536119f, 0.13350289f, 0.00282052f, -0.00946569f, -0.28862768f, 0.01955370f, 0.00120701f, 
    0.04129987f, 0.04031195f, 0.05632871f, -0.01286688f, 0.02501497f, 0.01719018f, 0.00402313f, 0.03282527f, 
    0.01710487f, 0.20284751f, 0.11096191f, -0.01626047f, -0.00207937f, -0.00953615f, -0.14752823f, -0.03686041f, 
    -0.01673668f, 0.10196939f, 0.04429792f, 0.09191689f, -0.10306904f, -0.01612091f, 0.01566325f, -0.06690806f, 
    -0.06514531f, -0.14518771f, -0.14991787f, -0.05749245f, -0.06932172f, -0.11357640f, -0.01016392f, -0.05868072f, 
    0.28951627f, -0.28001189f, -0.06591059f, 0.04132832f, 0.02984464f, 0.08602118f, 0.11442764f, 0.02918906f, 
    0.05967411f, -0.09184653f, 0.08677982f, 0.05749710f, -0.10782738f, -0.18763894f, -0.00633085f, -0.02485116f, 
    0.08623032f, 0.01063856f, -0.05019910f, -0.01253029f, 0.07567599f, 0.01021113f, -0.00369950f, 0.05074613f, 
    -0.49195307f, 0.33682793f, 0.06681617f, 0.04243896f, -0.05156330f, 0.07253068f, -0.00276676f, 0.04483557f, 
    -0.09151740f, 0.09007846f, -0.08836927f, 0.04374664f, 0.06730684f, -0.18039578f, 0.13145716f, -0.10564422f, 
    -0.13223757f, -0.00575812f, 0.10181411f, 0.00141767f, -0.13242304f, 0.00955417f, -0.05240914f, 0.21726872f, 
    0.01112650f, 0.04332054f, 0.22549786f, 0.14752950f, -0.04377773f, -0.12136804f, 0.04274533f, 0.01659442f, 
    0.01894547f, -0.01350249f, -0.07332665f, -0.14790009f, -0.01616165f, -0.09221276f, -0.28791177f, 0.08354190f, 
    -0.01910680f, -0.03438347f, -0.02615884f, 0.00080185f, -0.11260682f, 0.00317856f, -0.04674718f, -0.02137681f, 
    0.21247882f, -0.10836735f, 0.01985956f, 0.10014826f, 0.20455384f, 0.06569734f, -0.00082772f, -0.18542548f, 
    -0.10611737f, 0.10693806f, 0.05639553f, 0.04418163f, 0.13385355f, 0.25261128f, 0.14210148f, 0.07313833f, 
    -0.14043204f, -0.03571133f, 0.07598282f, -0.07800531f, -0.00092809f, 0.07156523f, -0.04520700f, 0.03708949f, 
    0.23480982f, -0.22129524f, 0.02864981f, -0.10280275f, -0.00205732f, 0.07291371f, 0.02666445f, 0.03894463f, 
    -0.01562450f, -0.05869902f, 0.04248440f, -0.14338663f, -0.07672298f, 0.12674262f, -0.16384177f, -0.04338616f, 
    0.00876485f, 0.00255302f, -0.02149773f, 0.09612569f, -0.04541321f, 0.04208134f, 0.02078245f, -0.02399138f, 
    0.18685381f, -0.11927455f, 0.11949607f, 0.39965513f, -0.07998695f, 0.13964766f, 0.07489070f, 0.18764295f, 
    -0.04699903f, -0.01450058f, 0.05393631f, -0.02280274f, -0.09153847f, 0.15430307f, -0.06515586f, -0.06336215f, 
    -0.08162566f, -0.05546478f, -0.03013005f, 0.16509461f, -0.05373519f, -0.02357006f, 0.02782531f, 0.25143889f, 
    -0.05701569f, -0.03907400f, 0.04609847f, 0.01182553f, -0.02901211f, 0.05643932f, 0.03904501f, 0.06843684f, 
    -0.08435521f, -0.08580615f, 0.04151205f, -0.05183097f, 0.02524747f, -0.14729765f, 0.07998414f, -0.08298770f, 
    -0.19667934f, 0.03125889f, -0.22998533f, 0.08980888f, 0.04261078f, 0.01983100f, -0.02310214f, -0.07125026f, 
    0.31953868f, 0.13147037f, 0.33466691f, 0.06120564f, -0.01102544f, 0.03384016f, 0.10383949f, 0.01897122f, 
    -0.13713217f, 0.02553863f, -0.20346236f, -0.11083452f, 0.11190210f, 0.22845721f, 0.15259570f, 0.03305285f, 
    -0.08386514f, 0.08724189f, -0.08045376f, 0.08151892f, 0.12721017f, -0.06763776f, -0.10198977f, -0.13810660f, 
    0.01358873f, 0.04974780f, 0.28362358f, -0.07013933f, -0.00217575f, -0.01089270f, 0.05865513f, -0.05490055f, 
    -0.06852865f, 0.01897401f, -0.05405864f, -0.12002593f, 0.07360191f, -0.15438583f, 0.12176582f, -0.11328440f, 
    -0.22098599f, -0.02547499f, -0.04089778f, -0.03091039f, 0.04780390f, 0.02906127f, 0.12051778f, -0.01191848f, 
    0.01624273f, 0.11665945f, 0.12834859f, 0.14257653f, 0.12321404f, 0.01134353f, 0.01540772f, -0.06033833f, 
    -0.03404880f, 0.12518935f, -0.08945615f, 0.02383969f, -0.00301354f, -0.21360546f, 0.09535313f, 0.02838973f, 
    0.09230877f, -0.05093346f, -0.01843570f, -0.03715679f, 0.12845261f, 0.00407698f, 0.00706852f, -0.11015839f, 
    0.05678976f, 0.09909306f, 0.04950144f, 0.19243667f, -0.03577587f, 0.02159005f, -0.01283407f, 0.00172028f, 
    0.03663811f, 0.02799806f, -0.09070432f, -0.01812681f, -0.04304133f, -0.09030971f, -0.03773801f, -0.11854223f, 
    -0.00065080f, 0.00553271f, 0.10536630f, -0.03483039f, -0.11223758f, 0.02731112f, 0.01790443f, -0.05345057f, 
    0.09797137f, 0.02338445f, 0.09728916f, 0.02939752f, 0.05518813f, 0.20153281f, -0.24557237f, 0.05793086f, 
    0.15124464f, 0.05534117f, 0.01241973f, -0.10742193f, -0.11575242f, 0.02802812f, 0.35847610f, -0.10743270f, 
    -0.16369446f, 0.14311546f, -0.04774630f, -0.08878289f, -0.11431599f, -0.00598341f, 0.02768459f, 0.05071572f, 
    -0.11440547f, -0.09481898f, -0.01680310f, 0.30674481f, 0.16364373f, 0.01979166f, -0.19311301f, -0.09843089f, 
    0.02113134f, -0.06015336f, -0.06311413f, 0.02936329f, -0.09149564f, 0.09426530f, -0.03205024f, 0.11919513f, 
    -0.07358463f, -0.06427432f, -0.04674419f, 0.05075155f, -0.07883269f, -0.15534537f, -0.05141240f, -0.03973300f, 
    0.13557050f, 0.18442577f, 0.01827912f, 0.06544232f, 0.13521469f, -0.10885800f, 0.01362212f, -0.02091281f, 
    -0.00330190f, 0.01139005f, 0.03784277f, 0.14399293f, -0.03101101f, -0.05357075f, -0.15163331f, 0.00742208f, 
    -0.03687157f, 0.11725176f, 0.02601612f, -0.03410827f, -0.12025443f, -0.03404352f, 0.05250849f, 0.05285218f, 
    -0.28068507f, 0.32429487f, -0.10744274f, -0.06978223f, -0.08117328f, 0.04211953f, -0.08104839f, 0.13163865f, 
    -0.13504753f, -0.13291848f, -0.13916223f, -0.00260748f, 0.01278616f, 0.28185382f, 0.09137849f, 0.16144803f, 
    0.12269849f, 0.04896407f, 0.06758928f, 0.04786490f, -0.08721651f, 0.12902021f, 0.03752322f, -0.08598410f, 
    -0.21887484f, 0.00674257f, -0.22032543f, 0.15353349f, -0.03645575f, -0.03562455f, 0.01829101f, -0.00939489f, 
    -0.12507249f, -0.13680995f, -0.09602375f, 0.09633120f, 0.08074962f, -0.07308837f, -0.09241430f, -0.01773390f, 
    -0.08128820f, -0.01099786f, -0.04850793f, -0.03013954f, -0.09681064f, 0.03068317f, -0.07845017f, -0.03258605f, 
    0.61984503f, 0.02103156f, 0.22075634f, 0.30433178f, -0.00704163f, -0.00991076f, -0.03959657f, 0.06946406f, 
    -0.09689727f, 0.04202162f, -0.01733097f, -0.10678263f, 0.00859560f, 0.01609104f, 0.13041049f, 0.15134503f, 
    -0.05881102f, 0.00923339f, 0.04961155f, -0.05382438f, -0.02992765f, 0.02902327f, -0.05522359f, 0.06882591f, 
    0.01760656f, 0.03600055f, 0.00423991f, 0.00546941f, -0.02812826f, -0.04278804f, -0.03285100f, -0.05085196f, 
    -0.03896809f, 0.03818029f, 0.00577697f, -0.04314800f, -0.04349962f, -0.03309983f, 0.03365148f, 0.04057122f, 
    0.02719090f, -0.01078240f, -0.03739938f, -0.04435182f, -0.03301273f, -0.00110951f, -0.04573079f, 0.01143622f, 
    0.03174020f, -0.05176500f, 0.01190246f, 0.01698919f, -0.00209378f, -0.01123820f, -0.03983511f, 0.04034583f, 
    -0.00156786f, -0.00979439f, -0.00915538f, 0.04181933f, -0.01049678f, 0.00859986f, 0.04470464f, 0.02185230f, 
    -0.05775262f, -0.02759116f, 0.03159742f, -0.04115493f, 0.01396437f, -0.01428095f, 0.00400291f, -0.01873977f, 
    -0.01880583f, -0.02029357f, -0.00193063f, -0.02570755f, -0.03726897f, -0.04666530f, 0.01363123f, 0.00483943f, 
    0.03061666f, 0.00921647f, -0.02057967f, -0.01257780f, -0.00138716f, -0.01087294f, 0.03114670f, -0.00944942f, 
    0.03331652f, -0.00116399f, -0.01009081f, -0.01786148f, -0.05766896f, 0.03109312f, -0.03154624f, 0.01463885f, 
    -0.01523349f, -0.01034878f, 0.01757317f, 0.01633753f, -0.02042741f, 0.00567476f, -0.05555459f, 0.03406515f, 
    -0.01114429f, -0.02207421f, -0.01625829f, -0.05196799f, -0.02711589f, 0.01449656f, 0.03213663f, -0.03366641f, 
    -0.03732030f, 0.02946891f, 0.04018509f, 0.00480356f, 0.02933803f, 0.00178050f, -0.04677358f, 0.03892881f, 
    0.02940653f, -0.02134738f, 0.02342769f, -0.05266565f, 0.00941319f, 0.02307526f, -0.00940073f, -0.00009553f, 
    0.03621778f, -0.02572223f, -0.02539034f, 0.02393028f, -0.04681386f, 0.02750995f, -0.04443192f, -0.03506342f, 
    -0.01540406f, -0.01351791f, 0.04359286f, -0.02290873f, -0.00145094f, -0.05356670f, 0.03507603f, -0.02255564f, 
    0.02153797f, 0.01944602f, 0.03191550f, 0.02421909f, 0.01892011f, -0.04626095f, 0.01058619f, -0.03393889f, 
    0.02807453f, 0.01856357f, -0.05095958f, -0.01008541f, -0.05279294f, -0.02349405f, -0.02481976f, -0.01446476f, 
    0.01023272f, 0.03223487f, -0.03300025f, -0.05662229f, -0.04131453f, 0.00329485f, -0.05443443f, -0.00071375f, 
    0.01356623f, -0.02245798f, -0.03314662f, -0.00186854f, -0.03690198f, -0.03291865f, -0.04128508f, 0.00680412f, 
    0.00496385f, -0.03471800f, 0.00528963f, 0.00436096f, 0.02883020f, -0.04746279f, -0.02618848f, 0.00659738f, 
    -0.00588706f, 0.00556258f, -0.04181179f, -0.01605033f, -0.05326276f, 0.00198829f, 0.01745657f, 0.02639042f, 
    -0.00624759f, 0.04102197f, -0.03619984f, -0.04930424f, -0.01274717f, -0.00345614f, -0.03717162f, -0.01073214f, 
    0.00131575f, 0.03984510f, -0.01480201f, -0.00693068f, -0.00890248f, -0.00167165f, -0.01757319f, 0.03128694f, 
    -0.03537820f, 0.01883264f, -0.00174712f, -0.01108461f, 0.01876914f, -0.03096250f, 0.01505307f, -0.03475004f, 
    0.02600636f, -0.01870323f, 0.00640647f, -0.05002800f, 0.00876966f, 0.03363445f, -0.00749558f, 0.02169108f, 
    0.02810231f, -0.04942841f, 0.03013298f, -0.02163396f, -0.05649655f, 0.01488231f, -0.02074487f, -0.02505117f, 
    -0.01351535f, -0.02161385f, -0.00771413f, -0.04633370f, -0.04253480f, 0.01804359f, -0.02310713f, 0.01605638f, 
    0.01505114f, 0.04325062f, 0.02695615f, 0.00298163f, 0.01209523f, -0.04344977f, 0.03690912f, 0.04312931f, 
    0.00036801f, 0.02982823f, -0.02075374f, -0.03557639f, 0.03487165f, -0.05412365f, 0.02056095f, 0.01235697f, 
    0.00864127f, 0.01769074f, -0.00816734f, -0.00536257f, 0.04285044f, -0.04339671f, 0.03176216f, 0.02765690f, 
    0.04044112f, -0.01719156f, 0.00858951f, -0.05294927f, -0.00942544f, 0.04104732f, 0.00214838f, 0.00077979f, 
    0.00911451f, -0.04209417f, -0.00591908f, 0.02860561f, -0.01697398f, -0.02490205f, 0.02528854f, -0.03772918f, 
    0.00599845f, 0.01095740f, 0.04159565f, 0.03430228f, -0.01028992f, -0.00097782f, -0.00914517f, 0.01036660f, 
    0.00074096f, -0.01727534f, -0.01870700f, -0.02047804f, -0.03478150f, 0.04409776f, -0.02914999f, -0.03049153f, 
    0.03332261f, -0.02347017f, -0.00843672f, 0.02434518f, 0.04145769f, 0.00386982f, -0.02016812f, -0.01947875f, 
    -0.01667117f, 0.02553570f, 0.02994218f, -0.01498722f, 0.03030940f, -0.02484382f, -0.05318176f, 0.01338499f, 
    0.03957394f, -0.04448827f, -0.00161340f, -0.01225198f, 0.04029420f, -0.01857787f, 0.02454012f, -0.03837290f, 
    0.02537951f, -0.03872138f, 0.03168820f, 0.03314206f, 0.00302445f, -0.01701109f, 0.04130842f, -0.01387790f, 
    -0.02168550f, -0.04029630f, 0.00450523f, 0.04245761f, -0.03035546f, -0.05327953f, -0.04746016f, 0.03775417f, 
    0.03177034f, 0.03463332f, -0.04229896f, 0.02956928f, -0.00694615f, 0.04109574f, -0.01651067f, 0.04463331f, 
    -0.04613944f, -0.05309325f, -0.05008460f, 0.01244668f, 0.01036336f, 0.01287171f, -0.05385481f, 0.00579705f, 
    -0.03221823f, -0.04198388f, -0.02826622f, -0.02348609f, 0.01171042f, 0.02215495f, 0.01587368f, 0.02428798f, 
    0.03850598f, -0.03045444f, -0.02961379f, -0.04541602f, -0.02910341f, -0.00492659f, 0.00670192f, 0.02162074f, 
    -0.04616998f, 0.01381075f, -0.04247094f, 0.00256613f, 0.01293772f, -0.02997032f, 0.01902168f, -0.01323555f, 
    -0.00474340f, -0.00532070f, -0.03625973f, -0.00121735f, 0.03489678f, -0.01627071f, -0.02840053f, -0.02775639f, 
    0.00472722f, -0.00338041f, -0.05297092f, -0.04192504f, -0.03151003f, -0.05281395f, 0.01209695f, -0.05011859f, 
    0.02632505f, 0.01995581f, -0.03826235f, 0.03774000f, -0.05072133f, 0.04700948f, -0.05319262f, -0.02354523f, 
    0.03015873f, 0.01816292f, -0.03661881f, -0.02394227f, -0.04531073f, 0.01346676f, 0.00670675f, -0.01780130f, 
    -0.12139354f, 0.07080513f, 0.26733318f, 0.04323431f, -0.15532340f, -0.11241694f, 0.10672824f, 0.19894457f, 
    0.10066339f, -0.05515175f, -0.13976271f, 0.12700638f, -0.33975729f, -0.11157655f, 0.04900770f, 0.05732449f, 
    -0.05877590f, 0.02176949f, 0.05222904f, 0.09875579f, 0.05431399f, -0.03648857f, -0.07524202f, -0.09113460f, 
    -0.12868924f, 0.05518151f, 0.07741942f, 0.16665867f, -0.03665045f, -0.08542711f, 0.05904811f, -0.02867382f, 
    -0.02457933f, 0.03303019f, -0.09416495f, 0.09571110f, 0.28836426f, -0.22473593f, -0.48281583f, 0.02584005f, 
    0.09525118f, 0.04864334f, 0.10945168f, 0.04214725f, 0.04217353f, 0.04552138f, -0.09851047f, 0.01077305f, 
    0.15774474f, -0.12120782f, 0.13617235f, -0.00131894f, 0.04471819f, -0.00347650f, -0.01452039f, -0.11712793f, 
    -0.02388178f, 0.14886372f, -0.02233241f, -0.11488584f, -0.06439284f, 0.03968756f, -0.03906545f, -0.11901973f, 
    -0.04613261f, -0.00945279f, 0.03415505f, -0.15254091f, 0.03766051f, 0.00209193f, -0.08085226f, 0.03414431f, 
    -0.20208579f, 0.11564041f, 0.26387939f, 0.11769844f, -0.05206728f, -0.08504198f, 0.10241836f, 0.06228687f, 
    0.18537359f, -0.06007821f, 0.09644386f, 0.03191380f, -0.05076302f, -0.02868928f, 0.00091446f, 0.05851502f, 
    0.00502310f, -0.00769062f, -0.00580886f, 0.01429100f, 0.10784681f, 0.02103816f, 0.19791138f, -0.07048993f, 
    -0.07443555f, -0.07148182f, -0.10063814f, 0.15088154f, 0.18298697f, 0.06029835f, 0.18111625f, 0.10830676f, 
    0.01721960f, -0.05966164f, 0.01797201f, 0.07023280f, 0.19529973f, -0.05666540f, -0.19185747f, -0.05701810f, 
    0.05750956f, 0.03467695f, -0.03525059f, 0.09214009f, -0.01308393f, -0.11171138f, 0.05918984f, 0.06309438f, 
    0.15524520f, -0.34068939f, 0.02554221f, -0.10044833f, 0.03470323f, -0.00032116f, 0.01486389f, 0.11680652f, 
    -0.04685152f, 0.06676295f, 0.02273211f, -0.05913074f, -0.01523118f, -0.10136516f, -0.25211182f, 0.13812104f, 
    -0.07298809f, 0.14431348f, -0.01821191f, 0.04694510f, 0.01932675f, -0.00580144f, -0.01600979f, -0.05286612f, 
    0.02032448f, 0.10458665f, 0.25100023f, 0.01046463f, 0.00220811f, 0.05197551f, -0.08000126f, -0.03087892f, 
    0.16705339f, 0.03742599f, 0.02309518f, -0.00580624f, -0.40948829f, 0.19376530f, 0.15017909f, 0.06136497f, 
    -0.11538843f, 0.00393101f, -0.02694835f, -0.05755576f, 0.11476537f, -0.07513230f, -0.10276094f, 0.01637251f, 
    0.02162995f, 0.07502779f, 0.06583362f, -0.19231345f, -0.06281698f, 0.13046917f, 0.05444664f, 0.08954807f, 
    -0.00922731f, 0.09092236f, -0.08879215f, 0.02955268f, -0.09426162f, -0.04896985f, -0.16813888f, 0.05165476f, 
    0.00316964f, -0.04969300f, 0.02747536f, 0.09653768f, -0.06002587f, -0.03704791f, 0.13969982f, -0.00043113f, 
    0.04694255f, 0.14122814f, 0.08473778f, -0.01846681f, 0.02065808f, 0.09805679f, 0.11331116f, -0.05711364f, 
    0.08169149f, -0.00018265f, 0.10194134f, 0.04922751f, 0.10465429f, -0.21855778f, -0.32661593f, 0.06021197f, 
    0.15795557f, -0.05883076f, 0.20043737f, -0.11719672f, 0.06244633f, 0.05405201f, -0.01052764f, -0.02636368f, 
    0.08772530f, 0.06236856f, -0.03248444f, -0.05259467f, 0.07599983f, 0.02045341f, 0.04504173f, -0.09755860f, 
    0.01409611f, -0.03186766f, 0.02928910f, 0.13492236f, -0.09223051f, 0.00723866f, 0.14205998f, -0.01846862f, 
    -0.03681041f, -0.09826044f, 0.07541058f, 0.08286280f, -0.06677699f, 0.05469899f, -0.01671142f, 0.01601247f, 
    0.22171880f, 0.16766849f, 0.07823326f, -0.15991634f, -0.08878993f, -0.00699593f, -0.14574343f, -0.09804925f, 
    0.03089890f, 0.13600299f, -0.01359151f, -0.03158829f, -0.15564622f, -0.07154713f, 0.16948134f, -0.08960035f, 
    -0.00518425f, 0.17137003f, -0.05317354f, -0.24476387f, -0.05084603f, -0.02655891f, 0.07112389f, -0.13545300f, 
    -0.16066951f, 0.00814309f, -0.03341909f, 0.05042160f, 0.00130547f, 0.01028732f, -0.11811768f, -0.00290751f, 
    -0.09249838f, -0.07405850f, -0.02975030f, -0.05657199f, 0.04563970f, 0.07484737f, 0.11702543f, 0.00446291f, 
    0.03315623f, -0.15848374f, -0.03404105f, 0.14034228f, 0.17121486f, -0.10422839f, 0.03948313f, 0.04891592f, 
    0.24181195f, 0.23007847f, 0.08374825f, -0.02206364f, 0.10652999f, 0.03872674f, -0.05853615f, -0.08465816f, 
    -0.05564920f, -0.14438264f, 0.17384289f, -0.01036229f, -0.15895121f, 0.04827345f, 0.10270368f, -0.05370411f, 
    -0.01894224f, 0.03967202f, 0.06937751f, 0.01112357f, -0.01861946f, 0.00519167f, 0.06097007f, 0.10344522f, 
    -0.15857108f, 0.11519651f, 0.06896019f, -0.10798366f, -0.16251746f, -0.08576076f, 0.12584870f, 0.10190109f, 
    0.06149066f, -0.18701276f, 0.04981235f, 0.14150773f, -0.33445969f, 0.30160829f, 0.20081085f, 0.03032993f, 
    -0.05629552f, 0.09898609f, 0.16533995f, 0.16816546f, -0.04936271f, -0.03534263f, -0.00685575f, -0.05692859f, 
    0.11444388f, 0.02565665f, -0.15466300f, 0.10119756f, -0.00464597f, -0.00335232f, 0.10305394f, 0.04109716f, 
    0.02837847f, -0.00792550f, -0.03015753f, -0.02366418f, 0.06622452f, -0.04391686f, -0.13918371f, -0.02789702f, 
    0.12304973f, 0.09414279f, -0.02662126f, 0.02775316f, 0.04478175f, -0.02157945f, -0.12704349f, 0.06510419f, 
    -0.27326646f, 0.22435138f, 0.23329073f, -0.14851590f, 0.03088640f, -0.10093022f, -0.25037831f, 0.10007753f, 
    -0.01939088f, 0.17427090f, 0.01735974f, -0.04383978f, 0.02860643f, 0.14613664f, -0.01981046f, -0.12553695f, 
    0.06658743f, 0.03010420f, 0.00278875f, -0.04405189f, 0.06778464f, -0.04321474f, 0.05278816f, 0.03511823f, 
    0.03193736f, 0.25810039f, -0.32771209f, -0.32616651f, 0.03295302f, 0.15605022f, -0.01401065f, -0.11231535f, 
    -0.08898500f, 0.04964185f, 0.05875272f, 0.02784207f, 0.21449792f, 0.05660171f, 0.08665443f, -0.09612590f, 
    0.07784913f, -0.03205309f, -0.00127732f, -0.07122298f, -0.16436526f, -0.01286712f, -0.01530417f, 0.24552803f, 
    0.10115146f, -0.08210404f, 0.13106939f, -0.03429789f, 0.02034073f, 0.07591579f, 0.14215747f, 0.23660290f, 
    0.00592906f, -0.07144003f, 0.04513023f, -0.11755833f, -0.40024599f, 0.06583372f, 0.24850632f, 0.30155006f, 
    -0.12027363f, -0.09148501f, 0.05313789f, -0.06794193f, -0.02821373f, 0.04303066f, -0.02517930f, -0.04482077f, 
    -0.14439671f, 0.11406832f, -0.25003549f, 0.01460514f, 0.19974399f, 0.09198641f, -0.18098520f, 0.00614514f, 
    0.01127337f, -0.11410888f, 0.04429338f, 0.14121024f, 0.18729797f, 0.05810444f, -0.05116151f, 0.13796885f, 
    0.01657893f, 0.00571495f, 0.06581397f, 0.14188504f, -0.07595722f, 0.04550255f, 0.04296678f, 0.03688738f, 
    0.15428691f, -0.26945311f, -0.05573001f, -0.15411815f, -0.04376582f, 0.02108013f, -0.10769664f, -0.07323556f, 
    -0.07394945f, 0.03589324f, -0.03048208f, 0.02028192f, -0.01868197f, -0.05271818f, -0.04098773f, -0.17753869f, 
    0.00967750f, 0.00674658f, -0.06526744f, -0.08295423f, -0.07859288f, 0.03703189f, -0.01881290f, 0.19621643f, 
    0.19289950f, -0.21526645f, 0.16981006f, 0.08143467f, -0.14601783f, 0.10827922f, -0.03895447f, 0.18981342f, 
    -0.00417942f, -0.01485180f, -0.03089537f, 0.00353506f, -0.27890474f, 0.14967664f, 0.20152536f, 0.15321708f, 
    0.03207924f, 0.00956353f, 0.00188360f, -0.06240232f, -0.02880251f, 0.04468447f, -0.07700266f, 0.01797198f, 
    -0.23653379f, 0.05113890f, 0.14310604f, 0.14575072f, -0.17188060f, 0.05660421f, -0.12239935f, -0.01011986f, 
    0.03130275f, 0.00687930f, -0.01769166f, -0.00213942f, -0.26469448f, 0.07447121f, 0.10341588f, 0.04467753f, 
    0.11458171f, -0.02845353f, 0.08611200f, -0.06290862f, 0.06979393f, -0.00590801f, -0.04889800f, -0.01544668f, 
    0.12721324f, -0.03190945f, 0.13821694f, 0.10594007f, -0.02267400f, -0.00615043f, 0.18583247f, 0.06052332f, 
    -0.11869818f, 0.06761850f, 0.14612144f, 0.00891350f, 0.40298092f, 0.00033334f, 0.03604544f, -0.03144279f, 
    0.07017511f, 0.04389863f, 0.13719496f, 0.07825178f, 0.08176241f, -0.12312701f, 0.01575569f, 0.01040148f, 
    0.00603774f, -0.07775347f, 0.25361544f, 0.08020297f, 0.12075251f, 0.02920596f, -0.01558512f, 0.11300925f, 
    0.08009709f, -0.10235394f, 0.08346092f, -0.21782345f, -0.22710931f, -0.04573708f, 0.08361559f, -0.10254369f, 
    -0.07813906f, -0.10018042f, 0.04137202f, -0.13590197f, 0.11835749f, -0.22418834f, 0.02020387f, 0.01426257f, 
    0.00721555f, 0.03600272f, 0.11654896f, 0.24094391f, 0.08085504f, -0.01807533f, -0.03948694f, 0.10181984f, 
    -0.20098761f, 0.00471644f, -0.20385945f, -0.19472134f, -0.32691556f, 0.12968619f, 0.36482054f, 0.13884141f, 
    0.04753991f, 0.15464519f, 0.01573571f, -0.07530069f, -0.06044110f, -0.09649527f, -0.05423258f, -0.03760163f, 
    -0.00652619f, -0.20139053f, -0.07470815f, 0.35048842f, -0.14565143f, -0.03111390f, -0.15901299f, 0.21086314f, 
    -0.00982126f, 0.07482098f, 0.06360246f, 0.03255675f, -0.09233419f, -0.07271248f, -0.08661252f, -0.04600699f, 
    -0.03881047f, 0.03208255f, -0.00434384f, -0.15932985f, -0.01721698f, 0.00975913f, 0.11992645f, 0.03485032f, 
    0.03686643f, 0.05024510f, 0.04131951f, 0.08456203f, 0.01938282f, 0.11791747f, 0.18006560f, 0.03093785f, 
    -0.00646404f, 0.14600338f, 0.02482597f, -0.03257496f, -0.01788910f, -0.07346667f, 0.16903114f, 0.10781841f, 
    0.12097882f, 0.08982241f, -0.19945009f, 0.04165166f, -0.03550573f, -0.12969449f, 0.03531409f, 0.01528518f, 
    0.29486856f, -0.30939877f, 0.03139582f, 0.33664697f, 0.07721495f, -0.01895593f, 0.00775874f, -0.08785786f, 
    0.07119364f, 0.10673613f, -0.03721437f, 0.08560486f, -0.35716185f, 0.07105300f, 0.09020936f, -0.16385157f, 
    -0.03348622f, 0.04939489f, -0.14585909f, -0.15482746f, -0.11969198f, 0.01801824f, 0.16057111f, 0.09516636f, 
    -0.06443784f, -0.07464910f, -0.02593696f, 0.10931435f, 0.06252182f, -0.05339587f, 0.06895676f, 0.17727864f, 
    -0.00907212f, 0.15503967f, -0.10210501f, 0.03815950f, 0.16850549f, -0.14161320f, -0.21340682f, 0.08460585f, 
    -0.03613291f, 0.09225933f, 0.01764357f, -0.05960912f, 0.09953207f, 0.09265341f, 0.04609927f, -0.00692178f, 
    0.29756466f, 0.29262307f, -0.30880538f, -0.09074570f, 0.12989578f, -0.09816577f, -0.01670202f, 0.07342911f, 
    -0.03532469f, 0.08222296f, -0.05007273f, 0.08951958f, 0.38357928f, -0.07899430f, -0.10972393f, 0.24993011f, 
    0.19726600f, 0.01782910f, -0.00879892f, -0.09386643f, -0.04969706f, 0.03721346f, 0.03652209f, 0.05746759f, 
    -0.38245204f, 0.13891718f, -0.02576721f, -0.04051690f, -0.01964725f, -0.06974693f, -0.04313935f, -0.17214017f, 
    0.06300978f, 0.04858235f, -0.00723965f, 0.15910971f, -0.26329306f, 0.04441336f, -0.06174877f, -0.11347353f, 
    -0.17643276f, -0.12806931f, -0.09650981f, -0.10055944f, -0.06033885f, 0.18146843f, 0.02660886f, 0.00616499f, 
    0.34036303f, -0.08745195f, 0.11092627f, 0.00037884f, -0.01766849f, 0.05737759f, 0.13530160f, -0.00024335f, 
    0.02105539f, -0.07282486f, 0.14736286f, -0.11216783f, 0.15119034f, -0.06105423f, -0.00494253f, 0.20905215f, 
    0.01506799f, -0.11260736f, -0.01375268f, 0.28784713f, 0.00977177f, 0.11971629f, -0.01438445f, 0.03438895f, 
    0.02506592f, 0.01312917f, -0.00906865f, -0.06866459f, 0.01685251f, -0.00957908f, -0.07438748f, 0.01888185f, 
    -0.00285644f, 0.01188373f, -0.05911355f, 0.04169331f, -0.04145866f, -0.06190189f, -0.04487342f, -0.00495573f, 
    -0.01169101f, -0.01288728f, 0.00460156f, -0.04257707f, -0.06894545f, -0.01917461f, -0.06467149f, 0.01465732f, 
    -0.00964615f, -0.00322346f, -0.03603846f, -0.02769824f, -0.01660200f, 0.02879574f, 0.02625743f, -0.00754797f, 
    -0.02131637f, -0.05462540f, -0.04849293f, -0.04798974f, -0.01625476f, 0.00802185f, -0.01053307f, -0.04433829f, 
    -0.04981940f, -0.01751231f, -0.03987459f, -0.06620849f, -0.05254518f, -0.01408443f, -0.00534578f, 0.01878989f, 
    0.01393575f, -0.04951723f, 0.01206508f, -0.04689946f, -0.03562112f, -0.04336707f, 0.04584447f, -0.00610664f, 
    -0.00882195f, 0.01257731f, 0.03131399f, 0.01208767f, 0.05236783f, 0.01080144f, 0.04182232f, -0.06103162f, 
    0.02020805f, 0.00740902f, -0.00126529f, 0.01561972f, -0.00246964f, -0.00445680f, -0.06466466f, -0.04813079f, 
    -0.05284760f, -0.01053329f, -0.05837100f, -0.00344829f, 0.00052086f, -0.05987072f, -0.05585174f, -0.01495660f, 
    -0.00977889f, -0.06180121f, -0.03440229f, -0.01202105f, 0.04259995f, -0.00951963f, -0.01874424f, -0.03133341f, 
    -0.00195307f, -0.04607348f, 0.02317018f, 0.02445863f, 0.03649564f, 0.00755792f, 0.03890287f, 0.01831714f, 
    0.02137358f, -0.04721611f, -0.00181338f, -0.03557662f, -0.05627190f, -0.00338733f, 0.00755270f, -0.04428661f, 
    -0.05637208f, -0.06724423f, -0.04630272f, -0.07490186f, -0.03394637f, -0.02594400f, -0.04520850f, 0.00662242f, 
    -0.07089757f, -0.06337247f, -0.03411239f, -0.08612569f, 0.00025346f, 0.01817934f, -0.04490197f, -0.05724607f, 
    -0.06293486f, 0.00476558f, 0.02010063f, 0.01375063f, 0.00637167f, 0.00170690f, -0.02683047f, -0.07371287f, 
    -0.02498251f, -0.03393036f, -0.00198482f, -0.04867198f, -0.01708269f, 0.00187624f, -0.01251823f, -0.00765310f, 
    -0.03824748f, -0.00509984f, 0.01581605f, -0.02454459f, -0.03336484f, 0.00077377f, 0.00630647f, -0.05428162f, 
    0.04342707f, -0.00941852f, -0.03089819f, 0.03474192f, -0.02245350f, -0.05150329f, -0.06324296f, -0.01333301f, 
    -0.05484067f, -0.02397332f, 0.00527032f, 0.01556104f, -0.06526171f, 0.04818118f, 0.04630044f, -0.00546865f, 
    0.00246727f, -0.06915503f, 0.02090840f, -0.04147929f, -0.01870284f, 0.02018184f, 0.01960423f, -0.03040618f, 
    -0.01933407f, -0.06289726f, 0.03066359f, -0.03582074f, 0.03787332f, -0.03821782f, 0.00883324f, -0.07289185f, 
    -0.04999188f, 0.01127936f, 0.00652738f, 0.02701473f, -0.01732134f, -0.00030834f, 0.01811647f, -0.04050750f, 
    -0.03741284f, 0.00622217f, 0.02141845f, 0.01100819f, 0.02655674f, -0.00426842f, 0.02281084f, -0.05065577f, 
    0.02735834f, 0.00458145f, 0.03187783f, 0.01419445f, 0.00399345f, -0.06160063f, -0.07097975f, -0.05318513f, 
    -0.07433181f, 0.00499063f, -0.01030018f, -0.02928090f, -0.00106358f, -0.01785718f, 0.02622841f, -0.04036715f, 
    -0.00488482f, -0.06366398f, -0.00062246f, 0.01186704f, 0.03186455f, -0.04510256f, 0.00560246f, -0.06747452f, 
    -0.01083051f, 0.00874509f, 0.03168363f, 0.02144329f, 0.01166514f, 0.01477177f, -0.04947498f, -0.01607915f, 
    -0.04240981f, 0.00705533f, -0.03511750f, 0.02046123f, -0.03682121f, -0.01124037f, 0.06874737f, -0.01209218f, 
    0.04800669f, 0.03818232f, 0.00331696f, 0.02523465f, 0.03281886f, 0.04104889f, 0.01432454f, 0.00888686f, 
    -0.05720828f, 0.00660079f, -0.05469126f, -0.06365832f, 0.01320294f, 0.00391025f, 0.01003988f, -0.00787714f, 
    -0.04125058f, -0.02861657f, -0.05079868f, 0.03414408f, -0.05283621f, 0.03109427f, -0.04905196f, -0.04643176f, 
    0.00119731f, -0.04151629f, 0.00595940f, 0.01545437f, 0.01124111f, -0.01630556f, -0.07583075f, 0.00453621f, 
    -0.00671723f, -0.05902089f, 0.04230866f, -0.02483124f, 0.01266490f, -0.01232425f, -0.00253818f, 0.00981096f, 
    0.00193539f, 0.03556547f, 0.03017051f, -0.04588105f, -0.06159433f, -0.03259728f, 0.04247120f, -0.01777659f, 
    0.02207897f, 0.01805060f, -0.05937267f, -0.01696666f, -0.00868838f, -0.04687101f, -0.03632823f, -0.04050244f, 
    -0.02162008f, -0.02968196f, 0.01293372f, 0.04398780f, -0.05454336f, 0.00469604f, 0.01373367f, -0.00189207f, 
    -0.00454301f, -0.05057999f, -0.00363671f, -0.03063177f, 0.00792118f, 0.01822687f, -0.00373017f, -0.04931068f, 
    -0.05204121f, -0.00548603f, 0.03749362f, 0.03605042f, 0.00587221f, -0.00515390f, -0.02594342f, 0.00640085f, 
    -0.02839073f, -0.00788531f, 0.00047557f, -0.02723690f, 0.02222561f, -0.07546860f, -0.05350845f, -0.01974641f, 
    -0.01173233f, -0.06187761f, -0.03939737f, -0.05482264f, -0.00056365f, -0.04498187f, 0.04304174f, 0.03821666f, 
    0.02833849f, -0.02123378f, 0.00903054f, 0.02065432f, 0.00800018f, -0.06225627f, -0.06213649f, -0.03718353f, 
    0.00859558f, 0.01671416f, -0.00038545f, -0.01081938f, 0.01188739f, 0.02892257f, -0.05746306f, -0.01450209f, 
    -0.03055383f, 0.01133381f, -0.03542764f, -0.03165107f, 0.00876758f, 0.05315432f, 0.01335147f, -0.04277549f, 
    -0.01429288f, -0.04186462f, 0.00698983f, 0.02142719f, 0.02489789f, -0.01410253f, -0.02891617f, 0.03762500f, 
    -0.00473008f, 0.05456955f, -0.02513934f, -0.00256298f, -0.06459662f, 0.03750251f, -0.01137500f, -0.03545805f, 
    -0.04139306f, -0.04159484f, -0.00273547f, 0.01456408f, 0.02031832f, -0.05765764f, -0.01758175f, -0.06195419f, 
    -0.06979617f, 0.01962023f, -0.05137801f, 0.01170319f, -0.01905973f, -0.05848945f, 0.01405838f, -0.05589391f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03831843f, 0.03315825f, -0.03683893f, -0.02411381f, 0.00178212f, 0.00869364f, -0.04440266f, 0.26629010f, 
    -0.09842201f, 0.00214699f, 0.11665844f, 0.21867447f, 0.02649518f, -0.00640179f, 0.14611535f, 0.00246601f, 
    0.12003987f, 0.05036132f, 0.12907337f, -0.01222552f, -0.03503621f, -0.04679898f, -0.00169793f, -0.01630856f, 
    0.03443508f, 0.06830859f, -0.01394095f, 0.00021505f, 0.10730806f, -0.01406167f, 0.10747681f, 0.01409822f, 
    0.01421918f, 0.04845347f, 0.08560304f, 0.25596213f, 0.04858836f, 0.04726304f, 0.11131898f, -0.05527503f, 
    -0.00597203f, -0.10868583f, -0.05417135f, 0.02941860f, -0.12340299f, 0.05876836f, 0.08587915f, 0.00085576f, 
    0.08711243f, 0.03176843f, -0.04825427f, 0.00079517f, -0.05113322f, 0.00572528f, 0.02986498f, -0.15364416f, 
    -0.13867375f, 0.03057148f, 0.06480964f, -0.02832414f, 0.02700467f, 0.09536700f, 0.01603403f, -0.02809874f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.07088333f, 0.10723922f, 0.13090807f, 0.09906970f, -0.27119651f, -0.02726570f, 0.11740880f, -0.40094712f, 
    0.32696152f, -0.12423273f, 0.23011813f, -0.27336445f, -0.05735093f, -0.19925709f, -0.19191346f, -0.07093158f, 
    -0.14547785f, 0.03998241f, -0.47327369f, -0.08753372f, 0.05771011f, -0.07120882f, -0.09266928f, -0.10843403f, 
    -0.11460393f, -0.26762959f, 0.07332339f, 0.04518329f, 0.11336812f, 0.00707612f, 0.22334759f, 0.27793723f, 
    -0.05922044f, -0.52341765f, 0.18488498f, -0.25084013f, -0.04287639f, 0.17135850f, 0.10619012f, 0.05000802f, 
    -0.02662168f, 0.16468576f, 0.07658733f, 0.11667676f, 0.15328842f, -0.28760630f, 0.13512675f, 0.04618414f, 
    -0.07081602f, 0.02405054f, 0.10848494f, -0.06149800f, -0.12543413f, -0.03039842f, -0.42686605f, 0.21436970f, 
    0.13410299f, 0.01447668f, -0.28792787f, 0.07960587f, -0.01879570f, 0.13603687f, -0.03007468f, -0.01110870f, 
    -0.07144579f, -0.01473855f, 0.02437669f, 0.00241754f, -0.00329326f, -0.03940219f, -0.07983319f, 0.14820385f, 
    0.38063678f, -0.02695921f, 0.16455097f, 0.11317872f, -0.06348751f, -0.48960805f, 0.14540617f, 0.01476022f, 
    0.03950810f, 0.22993642f, 0.12812175f, 0.16277745f, 0.13098426f, -0.10053574f, -0.03522268f, 0.04030966f, 
    -0.10692042f, 0.02867866f, -0.08179930f, 0.04774813f, 0.25140908f, 0.09177714f, 0.09926634f, 0.04494665f, 
    0.00208037f, -0.74438030f, -0.23321347f, 0.10953642f, 0.09283898f, 0.10740412f, -0.04649338f, 0.00232185f, 
    -0.11320990f, -0.06625012f, 0.08665010f, 0.01576454f, -0.04272432f, -0.02526988f, 0.23198980f, -0.12159399f, 
    -0.05332995f, 0.07933196f, -0.02970047f, -0.06931520f, 0.36711064f, 0.02559132f, -0.12755166f, -0.65945435f, 
    -0.08417794f, -0.62022173f, 0.06705011f, -0.08437520f, -0.03878397f, -0.03153070f, -0.04840138f, 0.01910171f, 
    -0.09961048f, -0.23730019f, 0.03798496f, -0.25342643f, 0.19999559f, 0.04803437f, -0.07074137f, 0.09853736f, 
    -0.42562759f, 0.12338147f, 0.10704329f, -0.11951189f, -0.06584454f, -0.18116014f, -0.08086088f, -0.04642332f, 
    0.14003271f, -0.26958862f, 0.26345849f, 0.04614201f, 0.06824505f, 0.08259457f, -0.00266361f, -0.04138421f, 
    0.05387416f, 0.13678214f, -0.07701126f, -0.02958724f, -0.32859004f, -0.01515857f, 0.18197384f, -0.13696158f, 
    -0.05625118f, 0.24363378f, 0.31709051f, 0.07612503f, -0.24688466f, -0.07582629f, -0.25505275f, 0.03790436f, 
    0.01657801f, 0.08205762f, 0.03045963f, 0.11415598f, -0.15797123f, -0.26422703f, 0.10749593f, -0.15845825f, 
    0.40838155f, 0.01042607f, 0.01042789f, 0.10006505f, 0.20523155f, 0.22289760f, -0.08763707f, 0.08865973f, 
    -0.74965906f, 0.05894717f, 0.11599889f, 0.02644500f, -0.08541270f, 0.01796413f, -0.01355306f, -0.08774620f, 
    -0.11891167f, 0.04965927f, 0.09357285f, -0.40008053f, -0.35122135f, -0.00132976f, 0.01976146f, 0.07786344f, 
    0.09953140f, -0.05547324f, -0.41007236f, -0.07880231f, -0.08669930f, 0.11251079f, -0.19034201f, -0.11652051f, 
    0.19720054f, -0.09751064f, -0.03714197f, -0.28839287f, 0.00376887f, -0.08380578f, 0.00992049f, 0.02863065f, 
    -0.07303271f, -0.13310121f, -0.07795127f, -0.01126298f, -0.42955247f, 0.02471260f, 0.05622894f, -0.28165847f, 
    -0.11500922f, 0.15368611f, 0.20460345f, -0.37266695f, 0.25709635f, -0.20016944f, -0.46553484f, -0.05486768f, 
    -0.10340735f, 0.27174252f, -0.03808067f, 0.11956470f, 0.25590917f, -0.06739978f, -0.19963931f, -0.25611663f, 
    0.15783466f, 0.08138363f, -0.06622332f, -0.09337646f, 0.18788272f, 0.03261435f, -0.13534734f, 0.22565578f, 
    0.19531932f, 0.16122763f, 0.27423254f, -0.00359880f, -0.09165484f, -0.34189934f, 0.27266201f, 0.11335087f, 
    -0.04885514f, -0.14126748f, 0.12027450f, 0.13437103f, 0.32432899f, 0.01007286f, 0.07381992f, -0.17989686f, 
    -0.00141255f, 0.04683599f, -0.08895508f, -0.31695101f, -0.07446526f, 0.08888490f, -0.25307789f, 0.03188764f, 
    -0.13859026f, -0.04593961f, 0.16430804f, 0.28889516f, 0.20074767f, -0.03493270f, 0.09970666f, -0.02161514f, 
    0.01768470f, -0.17498374f, -0.01188662f, 0.09140847f, -0.12664954f, 0.10835364f, -0.19713010f, -0.20402507f, 
    0.09956158f, -0.02721355f, -0.10184865f, -0.11778846f, -0.04140912f, 0.14769970f, -0.07378713f, -0.09504648f, 
    0.04590413f, 0.15115441f, -0.02613618f, 0.04407758f, -0.03027935f, 0.14299852f, -0.11646674f, 0.17851454f, 
    0.14710654f, 0.06154574f, -0.01049787f, -0.12037355f, 0.15275508f, 0.08964118f, 0.11768380f, 0.23464072f, 
    0.13867941f, -0.08134510f, -0.38439858f, 0.13377646f, -0.03147938f, 0.12957194f, 0.03970878f, 0.06774936f, 
    -0.05799875f, 0.20701185f, -0.13311066f, 0.20859496f, -0.24952994f, -0.04306047f, 0.02581226f, 0.24065539f, 
    -0.58854932f, -0.01270092f, 0.20993629f, 0.02574435f, 0.06981066f, 0.20762715f, -0.17741379f, -0.06952778f, 
    0.07362439f, 0.15805629f, -0.21111205f, -0.31430793f, -0.00669884f, 0.06571327f, -0.04960010f, -0.10006943f, 
    0.01296921f, -0.32023767f, -0.05071769f, -0.08817730f, 0.23022985f, 0.00932147f, -0.10478085f, 0.09728831f, 
    0.06045295f, -0.01256077f, 0.05590589f, 0.13725843f, 0.19322681f, 0.23465015f, 0.00572528f, -0.07290437f, 
    -0.09351861f, -0.05469637f, 0.02234800f, -0.00127470f, -0.21943064f, -0.02579736f, -0.20833905f, 0.25880468f, 
    0.12247925f, -0.21056551f, -0.11492772f, 0.10402380f, -0.30319077f, 0.00810432f, 0.11065047f, -0.10218973f, 
    0.07275873f, 0.08181475f, -0.04004074f, -0.16443643f, 0.01850467f, 0.17841460f, -0.23226386f, -0.08818370f, 
    -0.00980846f, -0.52302837f, -0.00814340f, -0.01234643f, 0.29307052f, -0.02779663f, 0.10982192f, -0.09746222f, 
    -0.13291064f, -0.00984698f, -0.31707251f, 0.13171895f, -0.10651661f, 0.17142065f, 0.12771882f, 0.06197714f, 
    0.15937021f, -0.35819110f, 0.23440418f, -0.22187245f, -0.07224732f, 0.03527062f, 0.06893224f, 0.04198687f, 
    0.09676056f, 0.20364808f, 0.02100789f, -0.02718084f, -0.31520042f, 0.07255143f, 0.02721916f, -0.25952420f, 
    -0.00613256f, -0.12504819f, -0.55765921f, 0.18527663f, -0.29066193f, -0.68160844f, -0.40492296f, 0.00689286f, 
    -0.13164680f, -0.03888036f, 0.06307343f, 0.10563603f, -0.35029376f, -0.32316136f, -0.15879735f, 0.05361198f, 
    -0.59964037f, 0.24201517f, -0.00317118f, 0.10647518f, -0.43075690f, -0.42119956f, 0.33077112f, -0.02061878f, 
    -0.37115481f, 0.35675690f, 0.05610180f, -0.02858167f, 0.00985241f, 0.20646058f, -0.30484971f, 0.01374625f, 
    0.07952639f, -0.39707503f, 0.02336661f, 0.05126759f, 0.08544036f, -0.06907998f, 0.10127088f, -0.15984149f, 
    0.13236040f, 0.08028690f, 0.08059427f, 0.00901455f, -0.02177229f, 0.01337651f, -0.16452155f, -0.00154100f, 
    -0.30336502f, 0.25699979f, 0.03961082f, 0.15433542f, -0.45435259f, 0.11720908f, 0.00991302f, -0.02920984f, 
    0.09241676f, 0.07121250f, 0.00155945f, 0.05955089f, -0.17155659f, -0.12022436f, -0.47511300f, -0.38848814f, 
    -0.10891296f, 0.34003395f, -0.43170369f, 0.08098579f, 0.09639592f, 0.29453740f, -0.21461605f, 0.04339944f, 
    -0.11066991f, 0.14144322f, -0.10216159f, 0.02591233f, 0.02018056f, 0.27091166f, -0.23708504f, 0.02504600f, 
    -0.33180210f, -0.52577305f, -0.05473704f, 0.11187562f, -0.23519826f, -0.10659528f, -0.11940250f, 0.46759388f, 
    -0.02344153f, 0.27173531f, 0.08403802f, -0.22399253f, -0.01041661f, -0.26051092f, -0.15625426f, 0.00018246f, 
    0.01823322f, -0.02535244f, -0.31199369f, -0.40323180f, -0.41120458f, -0.05619717f, 0.02830810f, 0.13746937f, 
    -0.28629392f, -0.10995793f, 0.28527921f, 0.09292455f, -0.10701929f, 0.27004549f, -0.17146333f, 0.05642594f, 
    0.25920230f, -0.10407467f, 0.00179535f, -0.50300878f, -0.60410243f, -0.11802214f, -0.07977372f, 0.01623479f, 
    -0.08580298f, -0.01056286f, -0.08046859f, 0.05034029f, -0.08216955f, 0.07301691f, 0.21715184f, -0.04181698f, 
    0.05716693f, 0.05954270f, -0.13142359f, 0.17792231f, 0.12311704f, -0.45436782f, 0.06701598f, -0.07615376f, 
    -0.04736699f, -0.14402860f, -0.06519638f, -0.07351305f, 0.35097331f, 0.20521741f, -0.04144655f, 0.14702389f, 
    -0.56442714f, -0.31409502f, 0.01663104f, 0.04064045f, -0.09724289f, 0.16018808f, -0.42424574f, -0.01615895f, 
    -0.29029337f, -0.20055857f, 0.16350567f, -0.21001129f, 0.07991654f, -0.07202540f, 0.32364520f, 0.08716691f, 
    -0.05857693f, -0.20541824f, -0.02982813f, 0.35730058f, 0.30521294f, -0.03280172f, -0.04847354f, 0.13767539f, 
    0.40726203f, -0.07742807f, 0.15751749f, 0.13151696f, -0.03502854f, -0.08942381f, 0.04433006f, 0.02895642f, 
    -0.06251281f, -0.38438511f, 0.00327957f, 0.23126660f, 0.07504404f, -0.12788188f, -0.10305157f, 0.03180695f, 
    0.01948814f, -0.01129203f, -0.12752405f, -0.06315038f, 0.08352751f, -0.03148153f, -0.25273106f, 0.17135985f, 
    -0.02597085f, -0.13271394f, 0.19061604f, -0.23992078f, -0.63213438f, 0.24189831f, 0.35677099f, -0.09602120f, 
    0.09603933f, 0.09792570f, 0.11812244f, 0.06525263f, -0.33832908f, -0.04201199f, -0.51497817f, 0.35229632f, 
    -0.00922256f, -0.20916060f, -0.05377697f, -0.00363491f, -0.07136671f, -0.57618731f, 0.24283367f, -0.18812273f, 
    -0.47835773f, 0.28162777f, -0.17136419f, -0.35016274f, 0.10674585f, -0.04304072f, 0.05611630f, -0.01268345f, 
    -0.08880454f, 0.17574155f, -0.05048217f, -0.34919944f, -0.27180123f, -0.02642350f, 0.10895108f, 0.31164217f, 
    -0.24356407f, 0.05712013f, -0.45188040f, 0.09197726f, -0.07763705f, 0.07465790f, 0.38775063f, -0.09410668f, 
    -0.22555511f, -0.18493244f, -0.05844544f, 0.03990939f, -0.38335866f, 0.03238347f, -0.13041484f, 0.09405328f, 
    0.06810547f, 0.14327021f, 0.00965231f, 0.08096176f, 0.16404626f, -0.01374716f, 0.19688427f, -0.62154752f, 
    -0.08265230f, 0.00080851f, 0.09591051f, 0.21191619f, -0.22945884f, -0.08770723f, -0.11757342f, 0.07767322f, 
    -0.09433306f, -0.21541978f, -0.11455127f, 0.03159011f, -0.07067114f, 0.27385226f, 0.09564742f, 0.12031605f, 
    -0.06840768f, -0.08870956f, -0.02439353f, 0.04427856f, -0.26336765f, -0.08384056f, -0.00755270f, -0.41724530f, 
    0.23791428f, -0.34289423f, -0.18540709f, 0.35997954f, 0.07341409f, 0.20567042f, 0.32575175f, -0.05428582f, 
    -0.09409644f, 0.05921232f, -0.38561198f, 0.21877436f, -0.27521884f, 0.05357753f, -0.07968409f, -0.40696537f, 
    0.12334359f, -0.10728739f, 0.03525786f, 0.06834707f, -0.11085837f, 0.33376247f, 0.15348659f, -0.00355450f, 
    0.27153113f, -0.37156454f, 0.12637499f, 0.10388018f, 0.07770683f, -0.02009796f, 0.07896028f, -0.04879586f, 
    0.01895143f, -0.00389702f, 0.07062746f, -0.03765451f, -0.05480261f, -0.09562440f, -0.61654913f, -0.41190603f, 
    -0.04321375f, 0.20477760f, -0.43529552f, -0.08111459f, 0.37882343f, -0.60485709f, 0.09463979f, 0.07399159f, 
    0.11559820f, -0.28540966f, -0.00662850f, -0.05173618f, -0.00336173f, -0.33114600f, 0.14144792f, -0.42182451f, 
    -0.32474074f, 0.42256352f, -0.06385881f, -0.09551664f, 0.01022738f, 0.52034694f, 0.08967154f, -0.19797610f, 
    -0.31527945f, -0.23679458f, 0.14212129f, -0.05251309f, -0.02601832f, -0.22128835f, -0.01464017f, -0.03349758f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05595454f, 0.00828163f, 0.12011504f, -0.16856721f, -0.15710834f, 0.07693255f, -0.00783398f, -0.10063945f, 
    0.10158174f, 0.09403371f, 0.13974045f, -0.12211630f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
