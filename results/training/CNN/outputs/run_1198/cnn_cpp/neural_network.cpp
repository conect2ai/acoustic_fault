#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.74594301f, -0.76877689f, 0.72142595f, -0.90434092f, -0.49395382f, -0.02080259f, -0.05067965f, 0.48407012f, 
    -0.30099231f, -0.97016871f, -0.32722399f, -0.27382597f, 0.23730129f, -0.03942132f, -0.36060959f, -0.49042958f, 
    -0.14678741f, -0.28673416f, -0.52281767f, -0.00202673f, 0.67053002f, -0.22699614f, 0.12147886f, 0.23954073f, 
    0.46437192f, -0.52217889f, -0.05138661f, -0.49439281f, 0.09024052f, 0.68972492f, -0.28585961f, -0.20704585f, 
    0.30218828f, 0.13291338f, 0.29957005f, 0.53766388f, 0.42467165f, -0.62607634f, 0.60477298f, 0.68782622f, 
    -0.37578553f, -0.41126901f, 0.08406104f, 0.39609933f, 0.00306890f, 0.30260119f, 0.52737755f, 0.21670242f, 
    -0.11375004f, 0.33227512f, 0.46087548f, 0.40742260f, -0.10996785f, -0.37137979f, -0.07132717f, 0.56866592f, 
    -0.52333915f, 0.29820189f, 0.73950976f, -0.65672636f, -0.12912209f, -0.39541247f, -0.19417801f, -0.12074951f, 
    -0.60161662f, -0.76621342f, 0.27310538f, 0.19401386f, 0.03799083f, 0.18918718f, 0.65095782f, 0.63041663f, 
    1.06376076f, 0.63804436f, -0.12683395f, -0.25437886f, -0.14271578f, -0.48949972f, -0.16015549f, 0.16638705f, 
    0.17170107f, 0.02475466f, -0.88744837f, -0.55613124f, 0.70205855f, -0.34731808f, 0.23978783f, 0.36249661f, 
    -0.08518762f, -0.71356326f, 0.18664229f, 0.34045234f, 0.03495618f, -0.12877506f, 0.30193207f, 0.45209554f, 
    -0.48115554f, -0.58486968f, -0.31337938f, -1.12444115f, 1.20644653f, -0.81639999f, -0.23240042f, 0.37157783f, 
    -0.17554305f, 0.05109586f, -0.02643445f, -0.00751491f, -1.00847399f, -0.43432680f, -0.39285153f, 0.87161762f, 
    0.15579273f, -0.35729694f, -0.10482607f, -0.23955692f, 0.36292830f, -0.25246263f, -0.29159188f, -0.32897568f, 
    -0.74267250f, -0.75316238f, -0.72893810f, 0.27517936f, 0.53123856f, 0.36334860f, -0.11379170f, 0.07765771f, 
    -0.65536106f, -0.69332027f, -0.51807910f, -0.46365884f, -0.33115205f, -0.34578151f, -0.22749166f, 0.49317840f, 
    -0.34099600f, 0.84860432f, -0.69294524f, -0.02813461f, 0.13600689f, 0.14236806f, 0.10010289f, 0.37807935f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07317027f, -0.04120351f, 0.46638957f, 0.16013117f, -0.15462410f, 0.27376550f, -0.04356095f, 0.30543953f, 
    0.34193137f, 0.36938584f, 0.04571858f, 0.01398228f, 0.28665349f, -0.14776637f, -0.28263065f, 0.06907422f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.10858312f, -0.05960987f, 0.24190581f, 0.11741167f, 0.01446312f, -0.24179003f, 0.12545502f, 0.00219012f, 
    -0.14633211f, -0.23440537f, 0.33752075f, -0.29948348f, 0.13964100f, -0.02399815f, 0.13324501f, -0.11205307f, 
    0.00720488f, 0.01382289f, 0.30215853f, 0.35332167f, -0.19740388f, -0.03312362f, 0.03487152f, -0.03198771f, 
    0.11866204f, 0.02994222f, -0.03943037f, 0.11285317f, -0.32727316f, -0.10469712f, 0.04078093f, 0.04939391f, 
    -0.04951419f, -0.05781315f, -0.06703899f, -0.10585948f, 0.07981983f, 0.24911307f, -0.45095724f, 0.18518837f, 
    0.04298740f, -0.21020168f, 0.24002425f, 0.06338283f, -0.04561610f, 0.02319554f, 0.30979106f, 0.08324861f, 
    0.11160519f, -0.05738525f, -0.17962988f, 0.01625482f, -0.00914902f, 0.17391853f, 0.00008174f, 0.17285080f, 
    -0.57029772f, -0.14316630f, 0.02278398f, 0.19903187f, 0.03463902f, -0.16724759f, -0.16532061f, -0.28023675f, 
    0.04699498f, -0.15640984f, 0.00403318f, 0.06653687f, 0.01658640f, -0.17303850f, 0.04116361f, 0.06385037f, 
    0.18617058f, 0.10876884f, 0.15067904f, -0.07364663f, -0.10187315f, 0.02316815f, 0.07429266f, -0.06808262f, 
    0.05623980f, -0.26294938f, 0.32546127f, -0.17879830f, -0.00896223f, 0.20897631f, 0.12429491f, 0.04344758f, 
    0.05594776f, 0.22943161f, 0.02250461f, -0.14841405f, 0.11762656f, 0.06497441f, 0.13324028f, -0.08984336f, 
    0.16237946f, 0.16597345f, 0.22584961f, -0.02857739f, 0.14545986f, -0.35594529f, -0.13812385f, 0.10654493f, 
    -0.12935267f, -0.17651616f, 0.11306683f, -0.08774377f, -0.50548512f, 0.13825390f, -0.58060366f, 0.09728672f, 
    -0.23422928f, -0.00962614f, -0.04980128f, -0.02020944f, -0.04139204f, 0.25660110f, 0.15989742f, 0.16376069f, 
    -0.01724999f, -0.02162911f, -0.09400593f, 0.01595624f, 0.10704399f, -0.11114010f, 0.44719836f, -0.01150722f, 
    0.22934693f, -0.09663089f, 0.10899810f, 0.30319053f, 0.12956831f, -0.09274542f, -0.09676329f, -0.04961593f, 
    -0.42021587f, -0.10983191f, 0.00654842f, 0.17389277f, -0.00659129f, -0.00456280f, -0.07295971f, -0.02219550f, 
    0.28925419f, 0.08578647f, 0.20308253f, 0.24414474f, 0.16298039f, 0.11055142f, -0.11979765f, 0.05837897f, 
    0.11930632f, -0.24666762f, -0.14573146f, 0.17219742f, -0.02118168f, -0.08949551f, -0.03011195f, 0.06896330f, 
    -0.26857439f, -0.05903643f, 0.18865842f, -0.06198742f, 0.09327862f, 0.03527925f, -0.02087008f, 0.11952551f, 
    -0.00436014f, -0.00367421f, -0.11850692f, -0.07237040f, -0.02830024f, 0.09832060f, 0.10716614f, -0.06729947f, 
    0.07275143f, 0.06564520f, 0.02273795f, 0.26220268f, -0.18868558f, 0.10146552f, -0.10984588f, 0.02656863f, 
    -0.01338534f, -0.02175794f, 0.04834483f, -0.04758978f, 0.17846261f, 0.03773774f, -0.02818541f, 0.10006794f, 
    -0.03214987f, -0.04218229f, -0.01298763f, -0.12962653f, 0.05287359f, -0.13277963f, -0.34187365f, 0.13348819f, 
    -0.01963618f, 0.14971983f, -0.07628915f, 0.14204818f, 0.01863022f, -0.05272373f, -0.34778586f, 0.02329581f, 
    0.01349223f, 0.05804029f, 0.13006023f, -0.10908453f, -0.14008099f, -0.02031535f, 0.07447104f, 0.13295497f, 
    -0.00847712f, -0.14050065f, -0.12887125f, 0.03994753f, 0.16484517f, 0.13226882f, 0.05361323f, 0.00981394f, 
    0.10280937f, -0.21596463f, 0.12626950f, -0.14485596f, 0.02079224f, -0.00607960f, -0.24722776f, -0.18282594f, 
    -0.14097778f, -0.27493930f, -0.11005087f, -0.27462974f, -0.17199045f, -0.02965944f, -0.06746347f, 0.17582068f, 
    -0.02118890f, -0.25906301f, -0.26066154f, -0.29208812f, 0.64680731f, 0.21169052f, 0.10066897f, -0.32556948f, 
    0.29677773f, 0.05276280f, 0.25911835f, 0.17875573f, -0.21465880f, 0.20676377f, 0.14496061f, 0.11119689f, 
    -0.03276930f, 0.05312900f, 0.10165244f, 0.00425473f, 0.00698141f, -0.20721616f, 0.04370952f, -0.15883173f, 
    -0.09036629f, 0.13547565f, 0.01114007f, 0.26440066f, 0.06070644f, 0.18712100f, -0.17239980f, 0.04849063f, 
    -0.12144712f, 0.12744719f, -0.00284234f, -0.00683974f, -0.05341825f, 0.01082758f, -0.18067065f, -0.14990924f, 
    -0.07337219f, -0.06430860f, -0.03967188f, 0.15107858f, 0.05625662f, -0.18815710f, 0.05237446f, 0.16552636f, 
    -0.79654270f, 0.13760096f, 0.15791549f, -0.11618957f, 0.16923137f, 0.19321606f, 0.14647856f, 0.16832410f, 
    -0.13527589f, 0.35881844f, 0.05562209f, -0.27614307f, 0.01974046f, -0.09450518f, -0.05063353f, -0.00008510f, 
    0.08941080f, -0.08023702f, 0.08781295f, 0.29381120f, -0.01461865f, -0.14294079f, 0.20501977f, -0.10433929f, 
    -0.08064109f, 0.16227365f, 0.17198358f, 0.15040804f, 0.14373082f, 0.12520459f, 0.06063433f, 0.20835480f, 
    -0.06012578f, -0.14995119f, 0.00428075f, -0.03008253f, 0.01669368f, 0.07984604f, 0.27738699f, -0.16540651f, 
    0.09142461f, 0.04887486f, -0.03399364f, 0.01630853f, -0.03639608f, 0.03887348f, 0.25291646f, 0.15146834f, 
    0.01529238f, -0.05887943f, 0.10748918f, -0.24187489f, 0.08806949f, -0.03515911f, 0.10279347f, 0.18751997f, 
    0.06939650f, -0.06816299f, 0.12275425f, -0.11808588f, -0.33816865f, 0.12819211f, -0.01519548f, 0.18870655f, 
    -0.08674571f, -0.05418289f, 0.03331176f, 0.04593671f, 0.10946958f, -0.02448061f, 0.03944939f, -0.03238895f, 
    0.06106312f, -0.03637107f, -0.05636762f, 0.03679532f, -0.06082771f, 0.15611912f, -0.14853159f, -0.06236894f, 
    0.09379952f, 0.08080290f, -0.29842579f, -0.05991920f, -0.03394705f, 0.06872113f, -0.05854179f, 0.09751964f, 
    -0.07454123f, -0.19171067f, 0.11331304f, 0.17060898f, 0.15032841f, -0.03052031f, -0.00647911f, -0.02336481f, 
    0.11505187f, -0.04729173f, 0.16003305f, -0.06578959f, 0.04615802f, 0.07835197f, -0.15145947f, 0.28034991f, 
    -0.05950143f, 0.10939001f, -0.04860970f, -0.10365096f, 0.51153642f, -0.06752847f, -0.07947920f, -0.10464409f, 
    -0.17958468f, -0.14638563f, 0.07886866f, 0.18384472f, 0.01698704f, 0.14933121f, -0.20042524f, 0.08298320f, 
    -0.19076286f, -0.06738066f, 0.06762389f, -0.11444371f, -0.19294778f, 0.13851324f, -0.12316341f, -0.25707030f, 
    0.01443746f, 0.03549951f, -0.01782625f, -0.12647206f, -0.21029459f, 0.14781991f, 0.15301321f, -0.10266665f, 
    0.17701195f, 0.00398125f, 0.01932511f, 0.13451007f, -0.11140125f, -0.08395170f, 0.16878574f, 0.11965220f, 
    0.13265592f, -0.11867468f, 0.27920589f, 0.08214798f, 0.06937612f, 0.15415378f, 0.00498175f, -0.07292413f, 
    -0.08383183f, -0.16689974f, -0.13686360f, -0.25769407f, -0.13928308f, 0.20193793f, -0.07282653f, 0.07955837f, 
    -0.10665868f, 0.03160799f, -0.11409020f, 0.37245885f, 0.29107177f, -0.04201262f, 0.15564699f, 0.22015838f, 
    -0.03548888f, 0.07336620f, -0.00811380f, -0.04300300f, 0.14725623f, 0.01281768f, 0.03636968f, 0.13510132f, 
    -0.02668644f, 0.02371613f, 0.00286001f, -0.05369533f, -0.10584670f, -0.15158072f, -0.10006426f, -0.06431513f, 
    0.08755564f, -0.12900220f, 0.12889607f, -0.10699280f, -0.07650271f, 0.12724870f, 0.12582543f, 0.17258258f, 
    -0.07244147f, -0.06630567f, 0.10871180f, 0.17384714f, 0.10883813f, -0.14074917f, -0.03747728f, -0.02042723f, 
    -0.42764482f, -0.18161966f, -0.01729397f, 0.03193182f, 0.10628956f, 0.16233096f, -0.14229062f, -0.11362764f, 
    -0.17133369f, 0.01798837f, 0.12115975f, 0.06199239f, 0.15863657f, 0.16931760f, 0.11404417f, -0.07227097f, 
    0.37000313f, 0.06987180f, 0.44526213f, -0.06744173f, 0.14598630f, -0.15748748f, -0.13264024f, 0.36699530f, 
    0.03788858f, 0.15900651f, -0.19518970f, 0.17392763f, 0.06577403f, -0.00239800f, 0.05465930f, -0.18554139f, 
    -0.07816004f, 0.18659426f, 0.12516311f, -0.03710971f, -0.03572530f, -0.09598763f, -0.27083221f, -0.07625395f, 
    -0.08303677f, -0.10107845f, -0.01116353f, -0.27716902f, 0.35968909f, 0.06432637f, 0.16031808f, -0.04197638f, 
    0.07510856f, -0.08249014f, 0.20352522f, 0.04285799f, -0.33809435f, -0.08481999f, -0.34797439f, 0.22181834f, 
    -0.08461666f, 0.08243375f, 0.04487776f, -0.02233158f, 0.05413716f, -0.11454342f, 0.01737768f, -0.29147625f, 
    -0.09653997f, -0.22998045f, -0.24653347f, 0.21195084f, -0.04376836f, 0.11810241f, -0.01763801f, -0.00941062f, 
    -0.04602307f, -0.10743273f, -0.06907110f, 0.08491635f, 0.13557653f, 0.03608017f, 0.02224997f, 0.08456449f, 
    0.31671739f, 0.04925949f, 0.03753505f, -0.19438812f, 0.01876223f, 0.01723771f, -0.02272533f, -0.02114309f, 
    -0.07594100f, 0.15568382f, 0.39199135f, -0.09412063f, 0.19254905f, 0.27259991f, 0.05714927f, 0.08258557f, 
    -0.04111086f, -0.01021582f, -0.05991161f, -0.16479541f, 0.00945409f, -0.04072501f, -0.03722434f, 0.00373114f, 
    -0.15549929f, -0.00893060f, -0.11864383f, 0.06828117f, 0.03049049f, -0.07273173f, -0.07065511f, 0.10662780f, 
    -0.05914276f, -0.03671220f, -0.30760083f, 0.03261904f, 0.15108822f, -0.05805564f, -0.10733899f, 0.14172457f, 
    -0.20664720f, 0.09537617f, 0.18759583f, -0.02373965f, -0.09472234f, -0.03034564f, 0.05640491f, -0.01500273f, 
    0.04969753f, -0.05758859f, 0.08847359f, 0.14406067f, -0.04122550f, -0.17081049f, -0.20071989f, -0.04578945f, 
    -0.03735417f, -0.14080057f, 0.14627676f, 0.02917576f, 0.17328985f, -0.19205175f, 0.09475040f, 0.02185926f, 
    -0.04197267f, 0.08447973f, -0.08269364f, 0.23929347f, -0.43399048f, -0.04829939f, -0.03883042f, 0.03945443f, 
    0.13993083f, 0.01957086f, 0.06452866f, -0.10306951f, -0.26202470f, 0.15751916f, 0.05939758f, 0.31146178f, 
    -0.43190491f, -0.31841680f, 0.02901097f, 0.05404184f, 0.18534921f, 0.08352247f, 0.03006147f, 0.06073595f, 
    0.04040707f, 0.06412983f, -0.09123854f, -0.02746405f, -0.08533993f, -0.07342190f, -0.05323993f, -0.17135058f, 
    -0.09518410f, 0.02153631f, 0.00321099f, -0.07050775f, -0.03777577f, 0.16936420f, -0.05149493f, 0.01635775f, 
    -0.40066007f, -0.19124041f, -0.15864810f, 0.32349265f, 0.66604310f, 0.59715760f, -0.18074563f, 0.05782220f, 
    0.11556315f, -0.16567567f, 0.15858562f, 0.03903197f, 0.08736561f, -0.10234078f, -0.04775841f, 0.27130142f, 
    0.00088225f, 0.04333182f, 0.09435245f, -0.15383619f, 0.12584960f, 0.27905089f, 0.14278297f, 0.27147764f, 
    0.04554668f, 0.04999366f, -0.07755651f, 0.06617884f, -0.06134207f, 0.15612292f, 0.16302796f, -0.02626096f, 
    0.24598999f, 0.03381926f, 0.03796863f, 0.21786587f, -0.05064928f, -0.10026886f, -0.02432709f, -0.37057731f, 
    0.00859021f, 0.07331290f, 0.01315089f, 0.14044882f, 0.08688612f, -0.09278247f, 0.21864732f, 0.02948583f, 
    -0.28351325f, -0.49362868f, -0.74115592f, -0.11098774f, 0.14669110f, -0.15361984f, 0.04386188f, -0.01231134f, 
    0.05690621f, 0.04863631f, 0.12079845f, 0.37765175f, 0.03874535f, -0.05454588f, -0.23695378f, 0.01232881f, 
    -0.05353419f, -0.15725394f, 0.32303342f, 0.06056464f, -0.15875612f, 0.06847399f, -0.13138534f, 0.14287563f, 
    0.01811321f, 0.12719163f, 0.19090302f, 0.13744055f, -0.20455912f, -0.03637726f, -0.09528479f, -0.16985849f, 
    0.09406525f, -0.04337626f, 0.07193507f, 0.12837966f, -0.14714798f, -0.10240838f, 0.02785641f, -0.13965654f, 
    -0.03088544f, -0.08205316f, 0.03149169f, 0.13748406f, 0.11489776f, 0.14028855f, 0.09650129f, 0.05071532f, 
    -0.01877915f, -0.29175138f, -0.03157277f, 0.01738432f, -0.08470212f, 0.03478900f, -0.07994038f, -0.17131619f, 
    0.31803638f, -0.00020143f, -0.04923581f, 0.03816275f, 0.00171967f, 0.03341983f, -0.03585606f, -0.09891437f, 
    0.11209713f, -0.31853765f, -0.07090700f, -0.00763417f, 0.03654190f, -0.01766896f, -0.02376679f, 0.13930526f, 
    -0.28611124f, 0.01879430f, 0.13115826f, 0.00866897f, 0.00337473f, -0.01911984f, 0.07056677f, 0.07649679f, 
    0.15617673f, 0.00656035f, -0.10438701f, 0.03081029f, 0.05661428f, -0.02045982f, 0.11317579f, 0.22479720f, 
    -0.00284113f, -0.01241764f, 0.04546374f, 0.06182935f, 0.01965393f, 0.04055953f, -0.06843405f, -0.02304922f, 
    0.04865246f, -0.01944313f, -0.10938340f, 0.97426677f, -0.45616966f, -0.45192268f, 0.02978400f, -0.00670175f, 
    0.14802362f, -0.06726128f, 0.00230511f, -0.10197848f, 0.18417451f, 0.29591995f, 0.45605952f, 0.12674837f, 
    0.08613847f, -0.01976816f, 0.14763872f, 0.12420120f, 0.08611111f, -0.60735947f, -0.58047795f, -0.11351296f, 
    0.10341971f, -0.05175887f, -0.22771300f, 0.05557168f, -0.03368263f, -0.00833432f, -0.22680067f, -0.22065270f, 
    -0.33981091f, -0.14204451f, -0.11778075f, -0.15294531f, 0.00947294f, -0.12074313f, 0.06963920f, 0.04965222f, 
    -0.34568277f, -0.16162714f, -0.10314623f, -0.00341665f, -0.00715471f, -0.02823233f, 0.03150793f, 0.05629227f, 
    0.25969741f, -0.61174119f, -0.03100858f, 0.03934949f, -0.08032812f, 0.13950136f, 0.00814141f, -0.13703384f, 
    0.06843761f, -0.37100133f, 0.09761933f, 0.37527230f, 0.09095376f, -0.06893763f, -0.09959872f, 0.03123962f, 
    0.26051930f, 0.10890703f, 0.08215785f, 0.12657130f, 0.09388875f, 0.00477811f, 0.25493288f, 0.03022373f, 
    0.12428778f, 0.10289013f, 0.29825786f, -0.20343536f, -0.25344366f, -0.19810458f, 0.23210214f, 0.13723823f, 
    -0.05936193f, 0.05036535f, 0.25956050f, 0.00588072f, -0.10830016f, -0.29899916f, 0.01030922f, -0.40240505f, 
    0.10513568f, -0.01304957f, 0.22108696f, -0.01249368f, 0.23803082f, -0.23979761f, -0.06987549f, 0.07241040f, 
    -0.16935793f, -0.18578713f, -0.13095094f, 0.00759205f, 0.07337743f, 0.19516425f, -0.21414502f, -0.24954273f, 
    0.21100715f, 0.04648188f, -0.12695965f, -0.00359123f, 0.14539798f, -0.16555433f, -0.03126559f, -0.29300779f, 
    -0.19526030f, 0.09573028f, -0.20986500f, 0.16570398f, 0.16804448f, 0.03871283f, 0.06992982f, -0.03881628f, 
    0.41759339f, 0.05641606f, -0.16438586f, -0.00631517f, -0.00699826f, -0.03890577f, 0.07832579f, 0.12180833f, 
    0.13427125f, 0.01227067f, 0.32961750f, -0.06371718f, 0.09357091f, 0.13392149f, 0.29034674f, -0.09771339f, 
    0.20446821f, 0.07038321f, 0.02113375f, -0.20273335f, -0.06950529f, -0.26150918f, -0.12455101f, -0.17152001f, 
    0.05221826f, -0.10314242f, -0.05626386f, -0.44116193f, -0.04534923f, -0.09883339f, -0.12759992f, -0.13088071f, 
    0.47260681f, 0.07006485f, -0.17442562f, -0.01323443f, -0.28079352f, 0.21973282f, 0.48670700f, -0.08062228f, 
    0.05811169f, -0.11541979f, 0.11457037f, 0.05394539f, 0.16371810f, -0.27188677f, -0.09362609f, -0.03449371f, 
    -0.11621994f, -0.11994409f, -0.41218472f, -0.04611126f, 0.11681466f, 0.05422005f, 0.02428082f, -0.05702208f, 
    0.02671941f, -0.10961243f, -0.17087910f, -0.00644829f, 0.04211367f, 0.16773154f, 0.01870224f, -0.15120429f, 
    -0.14834881f, -0.11799425f, 0.04547593f, -0.13471010f, -0.18850212f, 0.08401068f, 0.14400186f, -0.07890791f, 
    -0.06337627f, -0.06652287f, 0.06029401f, 0.04462609f, 0.01811140f, -0.04894297f, 0.03650467f, 0.00740125f, 
    0.00999359f, -0.00475295f, 0.00363107f, -0.03115926f, -0.05193829f, 0.07237322f, 0.03222657f, 0.04214311f, 
    -0.00104445f, -0.08297279f, -0.04792966f, 0.06407735f, -0.07908283f, -0.00911890f, 0.05128209f, 0.04282986f, 
    -0.02331600f, -0.03411676f, -0.05427743f, 0.05964429f, -0.08504227f, 0.04141674f, -0.01206381f, -0.07306266f, 
    -0.06483350f, -0.05056940f, 0.06874451f, 0.04430677f, 0.00180492f, -0.07929929f, -0.03886434f, 0.07046070f, 
    -0.03718020f, -0.02212101f, -0.02613615f, 0.00754688f, -0.02152635f, -0.03274513f, -0.07209951f, -0.05548056f, 
    0.05058708f, -0.07067641f, -0.01213063f, 0.07333936f, -0.06547319f, 0.00101625f, 0.04132687f, -0.03151842f, 
    -0.03526634f, -0.05559704f, 0.05450473f, 0.01444159f, 0.04273065f, 0.03710749f, -0.00858898f, 0.04359647f, 
    -0.04427320f, -0.06494640f, 0.01457100f, -0.04546978f, -0.08110970f, 0.03651546f, -0.07709204f, -0.04219785f, 
    0.03514482f, -0.03836529f, -0.00423904f, 0.01619023f, -0.07526919f, -0.04721934f, 0.03371729f, -0.02860087f, 
    -0.07109875f, 0.07265214f, 0.06305759f, 0.03378226f, -0.03140367f, -0.05547103f, -0.07522694f, 0.02340104f, 
    0.04448259f, 0.00007471f, 0.00145636f, 0.03995019f, 0.05649401f, -0.07363609f, -0.08144625f, 0.02784478f, 
    -0.00908743f, -0.04310103f, -0.07894410f, -0.02445336f, 0.07457408f, -0.00995137f, -0.06044170f, 0.02337781f, 
    -0.07521053f, 0.01826935f, 0.05092282f, -0.06291413f, -0.06882458f, -0.09037770f, 0.02030095f, -0.05138771f, 
    -0.08977188f, 0.00349319f, -0.01933330f, -0.03539337f, -0.06931291f, 0.00631637f, 0.00180923f, -0.05228531f, 
    0.06310624f, -0.02415846f, 0.00399561f, -0.09124801f, 0.03783390f, -0.00784805f, 0.04923829f, -0.02668806f, 
    -0.07579955f, -0.06399438f, -0.01836634f, -0.05821747f, -0.04444093f, 0.01946148f, -0.01054955f, -0.02222033f, 
    -0.04898695f, 0.02531600f, -0.07711365f, -0.08697336f, 0.05186027f, 0.06404796f, 0.06661876f, -0.08190660f, 
    0.35051641f, 0.29312602f, 0.16125333f, 0.14162251f, -0.04884067f, 0.24385136f, 0.11493456f, -0.00927071f, 
    0.01045812f, 0.11024718f, -0.07558001f, -0.09475016f, -0.01690958f, -0.01058785f, 0.12174590f, 0.02757486f, 
    0.02552355f, 0.19455200f, 0.16371864f, 0.09751272f, -0.31914937f, -0.03768704f, 0.23555516f, 0.10305866f, 
    0.04044247f, -0.10765143f, -0.06449990f, -0.04124462f, -0.03062653f, -0.11271623f, -0.17639667f, 0.08134020f, 
    -0.04884745f, 0.11826190f, -0.22889929f, -0.40361986f, -0.07934070f, 0.06507923f, -0.02978313f, 0.16607513f, 
    0.02808595f, 0.00938295f, -0.02558480f, -0.03101031f, -0.28442931f, -0.01090215f, 0.19899900f, -0.06703579f, 
    0.13913582f, 0.09831517f, 0.08270386f, 0.11388091f, -0.06432136f, -0.25486323f, -0.01932203f, -0.07903672f, 
    0.02067769f, 0.19613329f, 0.12975897f, 0.08445746f, 0.08416914f, 0.36146411f, 0.22964248f, -0.15475443f, 
    0.10266940f, 0.28643590f, 0.11217223f, -0.01484952f, -0.17960495f, -0.25831571f, -0.35417545f, -0.32830057f, 
    0.10874261f, 0.29862365f, 0.06291123f, 0.02105907f, 0.01594038f, 0.11272917f, 0.04993505f, 0.03464385f, 
    -0.05979548f, -0.20750062f, -0.01346839f, 0.15471119f, 0.06957362f, 0.13912046f, 0.16965906f, -0.00437358f, 
    0.09247544f, 0.34608766f, -0.17548735f, 0.00046947f, -0.04408516f, 0.12892647f, 0.14422615f, 0.09946829f, 
    0.12885991f, 0.13809541f, -0.01422429f, 0.27646062f, -0.15273766f, -0.18343163f, -0.33342987f, 0.03026094f, 
    0.03354449f, -0.06443441f, -0.18907197f, 0.24909721f, 0.16586603f, -0.21419153f, -0.08809609f, -0.09332529f, 
    -0.05036075f, 0.12733956f, 0.12908834f, 0.09243247f, 0.09510137f, -0.13093589f, -0.11541855f, -0.15063781f, 
    0.25232357f, 0.15672708f, -0.04791467f, -0.12922339f, -0.14215058f, -0.16199620f, 0.18250145f, -0.11067253f, 
    0.23212066f, -0.02331389f, 0.20508166f, 0.11647142f, -0.05764966f, 0.04181860f, 0.25449824f, 0.15649223f, 
    0.03237252f, -0.02430254f, -0.10776452f, 0.17953856f, -0.00079474f, -0.00406224f, -0.01302876f, -0.22401874f, 
    0.49822131f, -0.40471673f, -0.13986738f, -0.10255177f, -0.07230154f, 0.04770379f, -0.09093677f, 0.10092220f, 
    0.01585920f, 0.48770964f, 0.41376337f, -0.02043683f, 0.11084895f, -0.06841219f, 0.12658684f, 0.10943127f, 
    0.05981513f, -0.08185354f, 0.32413790f, 0.05673080f, -0.05868896f, 0.08397415f, 0.09458216f, 0.01813752f, 
    0.16233587f, 0.18232562f, -0.12829167f, 0.30689895f, -0.06550951f, -0.04100460f, 0.07503311f, -0.01995257f, 
    -0.03428472f, 0.27191153f, -0.08852685f, -0.04851190f, -0.05278848f, -0.10816316f, -0.51185519f, -0.43420500f, 
    0.05928582f, -0.02643584f, 0.14187071f, 0.09949429f, -0.17991668f, -0.15770909f, 0.20165062f, 0.31219357f, 
    -0.11125305f, 0.07793416f, -0.16681384f, 0.00618612f, -0.04671171f, 0.03169017f, -0.14653365f, -0.21875980f, 
    -0.24418825f, -0.15026078f, 0.04648038f, 0.03832573f, 0.09588443f, -0.01651560f, -0.08306056f, -0.18216249f, 
    -0.33952191f, -0.08869507f, 0.02019426f, -0.15928546f, 0.07498910f, 0.19420451f, -0.04334415f, -0.00995745f, 
    -0.45511016f, 0.01356848f, 0.22484602f, -0.15868038f, -0.15852095f, 0.02537433f, 0.26176220f, -0.00062037f, 
    0.15588002f, 0.07906456f, -0.09090647f, -0.13607606f, -0.04879929f, 0.20483221f, 0.09598836f, -0.05016519f, 
    0.08249303f, 0.19337626f, -0.09345216f, 0.28121519f, 0.30807939f, -0.28098446f, -0.03633257f, -0.16747962f, 
    -0.03028647f, -0.02255145f, 0.04361055f, 0.19549483f, -0.70124000f, -0.84135818f, -0.03555238f, 0.19197212f, 
    0.06755988f, 0.15756170f, -0.19432563f, 0.14824593f, 0.24207784f, -0.04627456f, -0.28491873f, -0.10861275f, 
    0.10107096f, 0.08384199f, 0.03385713f, -0.05290632f, 0.08193492f, 0.29450902f, -0.01554815f, 0.03096536f, 
    -0.13333532f, -0.15568884f, -0.07013436f, -0.08745100f, -0.01782478f, 0.05558916f, 0.35776502f, -0.07734682f, 
    -0.27386382f, -0.07834414f, -0.12779815f, -0.24490577f, -0.04522495f, -0.06753977f, 0.13129725f, 0.30650631f, 
    0.30247003f, -0.14186046f, 0.04439481f, 0.05187720f, 0.07862846f, -0.04292840f, 0.16233504f, 0.10536858f, 
    -0.30315888f, 0.00077457f, 0.45098913f, -0.14179778f, 0.11014047f, 0.02070690f, 0.05783173f, -0.25763956f, 
    0.01730639f, -0.01025114f, -0.04758892f, 0.39508334f, 0.01891977f, 0.11205981f, -0.07004567f, 0.14770956f, 
    0.08080713f, -0.10457744f, -0.08574385f, -0.01993340f, -0.00177795f, 0.16031700f, -0.10123315f, 0.04101690f, 
    0.12085839f, 0.26763064f, 0.12415583f, 0.05442707f, -0.18862069f, -0.40423319f, 0.16855671f, 0.08553819f, 
    -0.00315621f, -0.34363174f, -0.05686521f, -0.21217482f, -0.38014284f, -0.31825849f, -0.08189932f, -0.10149404f, 
    -0.13833846f, -0.35057288f, -0.11264265f, -0.12568924f, 0.22014433f, -0.23489797f, -0.13272436f, -0.03954861f, 
    -0.00167867f, -0.04701756f, 0.18278144f, 0.17027530f, 0.12159980f, 0.10397451f, -0.38859180f, -0.01945556f, 
    0.19287330f, 0.23004970f, 0.03241639f, -0.01314257f, 0.21548992f, 0.11850473f, -0.15073428f, -0.13396828f, 
    -0.16312562f, 0.32630581f, 0.07968279f, 0.01690767f, 0.00498460f, 0.17378083f, 0.09086243f, 0.10795864f, 
    -0.49147022f, 0.14403272f, -0.11367241f, -0.01520726f, -0.02938586f, 0.06954996f, -0.03093659f, -0.01828408f, 
    -0.06138058f, -0.18215327f, 0.17999813f, 0.33144382f, 0.21880703f, -0.14585960f, 0.02841322f, 0.18364511f, 
    -0.13451567f, 0.19921716f, -0.16837354f, -0.08283587f, -0.18283567f, 0.12232108f, 0.08587634f, 0.00715160f, 
    0.01416441f, 0.01367146f, 0.11572567f, -0.06663364f, -0.27238759f, 0.09454293f, 0.07537077f, 0.21702947f, 
    0.12037886f, 0.01521982f, 0.03361296f, -0.16680917f, -0.14187340f, -0.10885566f, 0.46566331f, 0.06527192f, 
    0.07921934f, -0.19321480f, 0.18532221f, 0.06222735f, 0.05789512f, -0.09098045f, -0.04318421f, 0.58084661f, 
    0.20576677f, 0.13070533f, -0.02431480f, -0.05668223f, -0.00811734f, -0.09987150f, -0.10245170f, -0.08037952f, 
    0.24642515f, -0.06797747f, -0.00866019f, 0.06349902f, -0.02124682f, 0.06055142f, -0.08569568f, -0.29873392f, 
    -0.10724138f, -0.15812089f, -0.08815350f, -0.10798875f, -0.04801668f, -0.04702306f, -0.10578995f, -0.05856247f, 
    0.08814178f, -0.47679847f, -0.20915882f, -0.01309485f, -0.07544651f, -0.16613674f, -0.01352451f, 0.05228315f, 
    -0.22781378f, 0.17094742f, 0.24899799f, 0.03993390f, 0.00309977f, 0.06479079f, 0.02010024f, 0.10062515f, 
    0.02260925f, 0.05900110f, 0.07126612f, -0.01299680f, -0.16156904f, 0.19130202f, 0.12033127f, -0.18529172f, 
    -0.01789159f, 0.19433047f, -0.09511949f, -0.02436883f, -0.17272894f, -0.08105858f, -0.16825575f, 0.08027992f, 
    -0.17678447f, 0.19459780f, 0.21270959f, -0.00958556f, -0.00747820f, -0.22303401f, -0.41856030f, 0.03833307f, 
    0.01050253f, 0.05803778f, 0.15000868f, 0.12190896f, 0.04844674f, -0.19459307f, -0.11507984f, 0.28999618f, 
    0.10842794f, -0.02712295f, -0.06089902f, 0.00623878f, 0.05329589f, 0.04001964f, -0.15642790f, -0.28528273f, 
    0.18014941f, -0.22342668f, 0.07954397f, -0.02052924f, 0.19248261f, -0.21017520f, -0.05979423f, -0.12507513f, 
    -0.18533482f, -0.15796641f, 0.17234229f, 0.11716470f, 0.07513961f, 0.12979656f, 0.08388068f, 0.20139889f, 
    -0.43459290f, -0.27343306f, -0.17573848f, -0.02304239f, 0.03255705f, -0.00045266f, -0.04094769f, -0.12689626f, 
    0.05887418f, 0.34125736f, 0.06684113f, -0.00718036f, -0.14356640f, -0.07601625f, 0.11633568f, -0.03777045f, 
    0.07890459f, -0.03207978f, -0.05160986f, -0.09275151f, 0.15628546f, -0.06798556f, -0.07393356f, -0.03710557f, 
    0.03207362f, 0.15385075f, -0.26077741f, -0.09591311f, 0.40578482f, 0.33013555f, 0.18925744f, -0.01827903f, 
    0.01207562f, -0.12226796f, 0.03710238f, 0.02219810f, 0.03601876f, 0.24496619f, -0.03053063f, 0.15542449f, 
    -0.04698411f, -0.02271795f, 0.07034084f, 0.02487800f, 0.18358342f, -0.06986997f, -0.13469647f, 0.16834363f, 
    0.01049033f, 0.13727780f, 0.09817705f, 0.14728181f, -0.13049546f, -0.18527909f, 0.00872183f, -0.06687555f, 
    -0.00128536f, -0.00498100f, -0.04683099f, 0.13260473f, 0.00464587f, 0.36203235f, -0.05689557f, 0.08127061f, 
    -0.22458878f, -0.33539739f, 0.03176038f, -0.12312862f, -0.21914224f, -0.10452438f, 0.21593368f, -0.00247863f, 
    0.07636383f, -0.52248073f, -1.12842274f, 0.20511343f, -0.10382968f, -0.02545460f, 0.02244300f, -0.02440605f, 
    0.01831789f, -0.02324292f, 0.17555326f, -0.01093717f, 0.01217184f, 0.06600143f, -0.01111197f, 0.05066604f, 
    -0.01163593f, -0.01769010f, -0.13498875f, 0.06449203f, 0.02605980f, -0.07454269f, -0.06953580f, 0.03388273f, 
    0.10152386f, 0.13616614f, 0.29861808f, 0.01809045f, -0.08738536f, -0.19016600f, -0.12677929f, -0.09417614f, 
    0.08291510f, 0.19796559f, -0.07890118f, 0.13683645f, 0.06418502f, -0.56295377f, -0.15771951f, -0.01866653f, 
    0.18643868f, 0.03071107f, 0.09261249f, 0.04019536f, -0.00606025f, -0.00016633f, -0.08926851f, -0.10946326f, 
    -0.14491798f, 0.07214077f, 0.07856918f, -0.04712608f, 0.11402372f, 0.10140692f, -0.11468550f, -0.88399953f, 
    0.27822465f, -0.31568000f, -0.04071846f, 0.02379004f, 0.05926786f, 0.11828993f, -0.05543010f, -0.13848530f, 
    0.34257981f, 0.27116337f, -0.05036341f, 0.03137058f, -0.23594160f, -0.13341059f, 0.10691788f, 0.07361847f, 
    0.24804856f, -0.06817352f, -0.15081824f, 0.24931103f, 0.15659113f, 0.11812335f, -0.01316860f, 0.00855462f, 
    -0.05257312f, 0.31467202f, 0.13094833f, 0.36574712f, 0.04945515f, -0.00320231f, -0.04522812f, 0.17883168f, 
    0.09764942f, 0.09948562f, -0.00297109f, -0.06341159f, -0.13919607f, -0.11813844f, -0.02893397f, -0.04122378f, 
    0.03499607f, 0.07305863f, 0.15294349f, -0.92294562f, -0.26228625f, -0.60658723f, 0.20831487f, 0.09497143f, 
    -0.09149590f, 0.03864321f, -0.25317770f, -0.02760119f, -0.33137482f, 0.13781431f, 0.23205806f, -0.21474850f, 
    0.01899559f, -0.11945379f, 0.15024276f, 0.13788655f, 0.14847970f, -0.20773813f, 0.12261926f, -0.06452566f, 
    -0.00460589f, -0.11757360f, -0.00882499f, -0.07490315f, -0.05564768f, -0.03691271f, -0.12652636f, 0.27640140f, 
    -0.33414119f, -0.17340748f, -0.08750048f, -0.14353374f, 0.07653956f, -0.03794648f, 0.12884271f, 0.46272206f, 
    -0.31050518f, -0.22765398f, 0.12769337f, -0.13933602f, 0.17192204f, -0.00416149f, 0.03393472f, 0.04130621f, 
    0.40199077f, -0.43588871f, -0.57535744f, -0.15566118f, -0.05302622f, 0.18479545f, -0.03694705f, -0.11779378f, 
    -0.00061779f, 0.23541808f, -0.38153335f, -0.43280694f, -0.16491012f, -0.03392161f, -0.13433363f, 0.05179802f, 
    0.06743698f, 0.15482116f, 0.32032502f, 0.24946059f, 0.17492941f, -0.09646844f, 0.14217411f, 0.06693140f, 
    0.10072396f, 0.01639613f, 0.28887758f, 0.00402708f, -0.09661905f, 0.15571123f, -0.02657822f, 0.09192484f, 
    0.01583033f, 0.10280046f, -0.00675782f, -0.20830496f, -0.06122817f, 0.05122063f, -0.17152135f, -0.05176761f, 
    0.08815694f, 0.17512830f, 0.21141493f, -0.04198061f, -0.19803183f, 0.23878436f, 0.22883604f, 0.14949059f, 
    -0.01283720f, -0.20903772f, 0.05577303f, -0.08853378f, 0.02905938f, 0.24158134f, -0.39198816f, -0.40210491f, 
    -0.11123758f, 0.00303053f, 0.01513995f, 0.00103241f, -0.01381196f, -0.14834844f, 0.28280622f, -0.55294079f, 
    0.21447343f, -0.09730126f, 0.02547691f, -0.00988721f, 0.11084755f, 0.07952793f, -0.05543204f, -0.11004447f, 
    0.61612803f, 0.00812186f, -0.01263602f, 0.09385321f, -0.07695675f, 0.03419378f, -0.01288489f, 0.03084045f, 
    -0.10140269f, -0.29418650f, -0.25151810f, -0.26561496f, -0.05320425f, 0.17597955f, 0.12247043f, 0.09466634f, 
    -0.02934954f, 0.30653620f, -0.07283689f, 0.15758990f, 0.09893175f, -0.07261687f, 0.01990621f, 0.08320865f, 
    -0.02455693f, 0.06887089f, 0.19085740f, -0.68366492f, -0.43856829f, -0.60602152f, 0.04671321f, 0.13364279f, 
    -0.00877496f, 0.20490725f, 0.13361062f, -0.15775087f, -0.29149157f, -0.23314948f, 0.37321234f, 0.00350225f, 
    -0.03148798f, 0.06635897f, 0.03939745f, 0.03780386f, -0.06889427f, -0.58756554f, -0.16053535f, -0.28164628f, 
    -0.07718867f, 0.04967054f, -0.19807312f, -0.02027342f, -0.00287675f, 0.00788378f, -0.15183078f, 0.30124202f, 
    -0.23746322f, -0.16058162f, -0.14003626f, -0.05342888f, 0.14251624f, 0.12705480f, 0.06381606f, 0.57567543f, 
    -0.02307304f, -0.24147731f, -0.06633209f, -0.11320972f, 0.01744351f, -0.25824538f, 0.07215053f, -0.18019858f, 
    -0.19083479f, 0.03111194f, -0.01964153f, -0.00866178f, -0.06358010f, 0.00263285f, 0.02699311f, -0.00191450f, 
    -0.02747246f, 0.26733389f, 0.20007500f, 0.21014273f, -0.00870945f, 0.01728296f, 0.16955134f, 0.04005317f, 
    -0.02723625f, -0.00168446f, -0.52923268f, -0.26869708f, 0.28610823f, -0.03575896f, -0.16128685f, 0.05343241f, 
    -0.05294665f, -0.09037942f, 0.02209769f, -0.21717215f, -0.15545197f, -0.03358706f, 0.03303429f, 0.25421906f, 
    0.09893618f, 0.06566508f, 0.14719494f, 0.13661040f, -0.42799601f, 0.11836584f, -0.00166218f, -0.18315303f, 
    0.17723070f, -0.03240824f, 0.17127663f, 0.05616157f, 0.00167957f, -0.22559316f, -0.08661112f, -0.26427540f, 
    -0.02257781f, -0.05695942f, -0.01753136f, -0.06876586f, -0.08128469f, 0.04421961f, -0.03112014f, 0.24564838f, 
    0.12544708f, -0.15539157f, -0.22938862f, -0.17508942f, 0.16186260f, -0.04959733f, 0.10352056f, 0.10607062f, 
    0.00190082f, -0.18571499f, 0.11584275f, -0.06348694f, -0.07103153f, 0.08144162f, 0.13143429f, 0.17428268f, 
    0.07558558f, -0.55126256f, -0.48047563f, -0.01800692f, -0.10543704f, -0.18348584f, -0.04011970f, 0.10326598f, 
    0.12900595f, 0.50504106f, -0.34043810f, -0.12051601f, 0.01570676f, 0.07767902f, -0.01517896f, 0.11978546f, 
    0.04298547f, -0.17371948f, -0.10502834f, -0.00351547f, 0.24494357f, -0.11905590f, -0.10916810f, -0.16405794f, 
    0.18681499f, -0.07886150f, 0.00350577f, -0.54253024f, -0.07975359f, -0.13323285f, -0.18739764f, -0.17386746f, 
    0.15912528f, 0.16479078f, 0.08178739f, 0.02707747f, 0.31287739f, 0.20491874f, -0.07089788f, -0.14817163f, 
    -0.09590227f, -0.07143216f, 0.04232363f, 0.11984438f, 0.00445586f, 0.24721351f, 0.46963069f, 0.43092191f, 
    -0.07954272f, 0.05214161f, -0.16550164f, 0.11883695f, 0.11902273f, 0.14355856f, 0.02732739f, 0.33605558f, 
    0.32458866f, -0.14179681f, 0.14877671f, 0.02203765f, 0.11437601f, -0.14998358f, -0.08394529f, -0.23933221f, 
    -0.06911582f, 0.07470642f, -0.06378429f, -0.04328874f, -0.16140959f, -0.02243962f, -0.16406950f, -0.03366290f, 
    0.22227250f, -0.18546946f, -0.09538077f, 0.04817604f, -0.07109289f, -0.18499465f, -0.03541913f, -0.02693312f, 
    0.14331464f, -0.04373500f, -0.08121044f, 0.03950390f, 0.04241792f, 0.08861466f, 0.09592016f, -0.05139704f, 
    -0.02880168f, -0.08685785f, -0.18810296f, -0.13873245f, -0.01024018f, 0.34855771f, -0.08583272f, -0.06908464f, 
    0.09273481f, 0.19795230f, 0.15876055f, -0.03090476f, -0.08042831f, -0.07264856f, 0.13521031f, -0.02409039f, 
    0.05688875f, -0.10707373f, 0.11895659f, 0.20314579f, -0.27242970f, -0.19509621f, -0.38703460f, -0.18849406f, 
    -0.00787622f, 0.03035187f, -0.00278363f, -0.19605723f, 0.18677586f, -0.00623766f, -0.34955323f, -0.03394008f, 
    0.03353972f, -0.23599479f, -0.27402031f, 0.15437321f, 0.08666014f, 0.14221190f, 0.19496098f, 0.12883715f, 
    -0.20727356f, -0.07251458f, -0.08686283f, 0.16682522f, 0.03574554f, -0.19215024f, -0.03107821f, 0.04500794f, 
    0.10101350f, -0.07057765f, 0.02918796f, 0.09572314f, 0.19904102f, -0.06236526f, -0.04314875f, 0.00616786f, 
    0.40504581f, -0.30407012f, -0.22448727f, -0.10099062f, 0.08326109f, -0.03690528f, 0.17498820f, -0.06184927f, 
    0.07024889f, 0.06586245f, -0.00402838f, -0.07795399f, 0.08413917f, 0.20838825f, -0.13126987f, 0.28243458f, 
    0.17547226f, 0.12116878f, 0.20193787f, -0.09296763f, -0.12846312f, 0.24186315f, 0.00056353f, -0.17532697f, 
    -0.07509537f, 0.05723880f, 0.01754175f, -0.21457200f, 0.38039085f, -0.38861105f, -0.01048629f, -0.47022304f, 
    0.15982902f, 0.10790828f, -0.04410182f, 0.01317716f, -0.18402590f, -0.17928974f, -0.08071952f, -0.02110886f, 
    -0.01145480f, 0.12124401f, -0.01119831f, 0.18038720f, 0.03355444f, 0.38169584f, 0.33137286f, 0.40901640f, 
    -0.05810677f, -0.05143632f, -0.04044250f, -0.04152865f, -0.19503267f, -0.12911960f, 0.20195104f, 0.03710100f, 
    0.13383088f, 0.07157505f, -0.05727014f, 0.04527002f, 0.04787811f, 0.03548937f, -0.05377992f, -0.05998908f, 
    -0.32571352f, -0.50089878f, 0.19449104f, -0.19823620f, -0.13693716f, -0.13140681f, -0.07625327f, 0.14053477f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.23556755f, 0.18935646f, -0.17426996f, 0.24221535f, -0.10465893f, 0.19334175f, 0.29213077f, 0.02984244f, 
    -0.08165073f, 0.21850827f, 0.20413347f, 0.15828387f, 0.24065332f, 0.23394038f, -0.12445742f, 0.03511490f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06819142f, -0.48480457f, -0.20776169f, -0.23280673f, 0.21592554f, -0.94796246f, -0.22530302f, 0.15284410f, 
    0.03743074f, 0.09962653f, -0.27600130f, 0.20247619f, -0.43911833f, 0.10255586f, 0.61083740f, 0.29431659f, 
    0.19835922f, 0.06588469f, -0.12039027f, 0.12070749f, -0.03713210f, -0.08881257f, -0.17779313f, -0.06480287f, 
    0.05087676f, 0.17983139f, -0.21469909f, 0.00558158f, 0.53482014f, 0.02799075f, -0.14854909f, 0.29018855f, 
    0.39443216f, -0.20441286f, 0.29475263f, -0.33927768f, -0.18153687f, 0.01901223f, 0.31379694f, 0.23369944f, 
    0.16475500f, 0.24599835f, 0.27056003f, -0.19940694f, 0.17640184f, 0.09523650f, -0.40922210f, -0.15013562f, 
    0.70788771f, -0.32865146f, -0.19253615f, -0.36376590f, -0.53765559f, 0.64526618f, 0.18812566f, -0.11894896f, 
    0.35376787f, 0.37794098f, 0.36027062f, 0.00224749f, -0.51646185f, -0.22817239f, 0.04020752f, -0.28572375f, 
    0.41119906f, 0.05802817f, 0.15928757f, 0.09123490f, -0.08656462f, 0.42063370f, 0.41730717f, 0.18483800f, 
    0.08131793f, -0.24578933f, 0.27147177f, -0.01857982f, -0.29111370f, -0.37674534f, -0.41473970f, -0.14995842f, 
    0.14123973f, -0.34087268f, 0.29011637f, -0.50445193f, 0.01852457f, 0.35697109f, -0.24163379f, 0.17183258f, 
    0.05161922f, 0.80250835f, 0.43412733f, -0.18787889f, -0.15596414f, 0.33231828f, 0.36387655f, 0.01720445f, 
    -0.13116537f, -0.27524090f, 0.17006175f, 0.09584600f, 0.19208337f, 0.47334751f, -0.09194320f, -0.00965695f, 
    0.12231489f, -0.41877732f, 0.27683452f, 0.23152675f, 0.03300434f, -0.21239063f, -0.45076579f, 0.23476499f, 
    0.09042866f, -0.12474209f, -0.53146535f, -0.09887267f, -0.06108487f, 0.60544032f, 0.25425708f, 0.18088502f, 
    -0.19453385f, 0.58187282f, 0.05674493f, 0.43146226f, -0.14306170f, -0.31940258f, -0.24814865f, 0.35559842f, 
    0.10720655f, 0.19130678f, -0.29114839f, 0.07969829f, -0.23876844f, 0.24056669f, -0.11302983f, 0.10558408f, 
    0.16306731f, -0.08387685f, -0.06748713f, 0.02876273f, 0.59392339f, 0.30662531f, 0.65217310f, -0.02548329f, 
    -0.00002748f, 0.01953644f, -0.36824661f, -0.04961593f, 0.32627153f, 0.15980498f, 0.25351816f, 0.21664642f, 
    0.21772115f, -0.30509597f, -0.16881561f, -0.17092942f, 0.28811949f, -0.09433726f, -0.26027662f, 0.36873409f, 
    0.06433927f, -0.15867610f, -0.13592517f, -0.11425667f, -0.24280319f, -0.01698308f, 0.18773544f, 0.01645470f, 
    0.31595838f, -0.43073717f, -0.06326000f, -0.09043934f, 0.23493993f, 0.15583171f, 0.19687475f, 0.16226941f, 
    0.05598742f, -0.26071706f, 0.25030378f, 0.04216191f, 0.01226569f, -0.28018528f, -0.34319946f, 0.04381958f, 
    -0.04155270f, -0.39696437f, -0.33957210f, -0.60361403f, 0.32744783f, 0.20474824f, -0.27092957f, -0.88814104f, 
    0.13214889f, -0.00614265f, 0.28548843f, 0.35413712f, 0.27976635f, -0.27804533f, -0.03435428f, 0.13776383f, 
    -0.16590805f, 0.04080438f, 0.08584615f, -0.03271820f, -0.39871192f, -0.10430244f, -0.02939781f, 0.42102671f, 
    -0.84606481f, 0.23143290f, 0.21808872f, -0.33162326f, 0.08053030f, 0.25132734f, 0.22091943f, 0.08305270f, 
    -0.05159789f, 0.32420194f, 0.17448923f, -0.00077554f, 0.05374312f, -0.33347645f, -0.12238117f, -0.30097789f, 
    -0.20963770f, -0.28676274f, 0.06058946f, -0.20093317f, 0.01041052f, 0.28341448f, -0.05542589f, -0.12000453f, 
    0.32574713f, -0.36134225f, 0.26979938f, 0.36389253f, 0.27601922f, -0.20354633f, -0.00204989f, -0.23890869f, 
    -0.19850048f, -0.21036616f, 0.34882960f, -0.08639957f, 0.25795993f, 0.35941753f, 0.30136865f, 0.22659744f, 
    0.03980904f, -0.28016013f, 0.14333846f, -0.26998776f, -0.36424693f, 0.27066615f, 0.03458609f, 0.23808911f, 
    -0.11170515f, -0.10521707f, -0.07841465f, 0.00012085f, -0.11553985f, 0.17156407f, 0.02064520f, -0.07594740f, 
    -0.22303075f, 0.03857437f, -0.08273152f, -0.20538259f, -0.07279176f, -0.05789214f, -0.05745709f, -0.12924671f, 
    0.17935336f, -0.05019258f, -0.07216528f, 0.23138411f, 0.31747681f, -0.39960295f, 0.19516301f, 0.00061422f, 
    0.01756689f, -0.00122543f, 0.49052978f, 0.06177367f, -0.16847216f, -0.68571281f, -0.25049046f, -0.06192221f, 
    0.19806050f, 0.26255015f, 0.07983895f, -0.22504501f, -0.16657692f, -0.21537025f, -0.04001208f, 0.04928309f, 
    0.03259674f, 0.06195225f, -0.03826862f, 0.53331268f, 0.36303759f, -0.22013076f, -0.07412757f, 0.25344774f, 
    -0.59190530f, 0.15171388f, 0.14980328f, 0.06943983f, 0.11746532f, 0.16373774f, -0.05658919f, -0.08675084f, 
    -0.21109703f, -0.53548300f, 0.27469030f, 0.34890732f, -0.11186492f, -0.66548556f, 0.38895893f, 0.17541666f, 
    0.26186696f, -0.02574576f, -0.17226958f, 0.03041278f, -0.22368290f, 0.08711774f, -0.06671555f, -0.02559652f, 
    -0.22552878f, -0.17746666f, 0.37589279f, 0.09310601f, 0.08150098f, 0.40708795f, -0.05754270f, 0.67047942f, 
    -0.63019168f, 0.30183950f, -0.19596238f, -0.18499959f, -0.01493028f, 0.16444413f, 0.51564807f, -0.15956375f, 
    0.19314706f, 0.23530369f, 0.27324450f, 0.19021888f, 0.22440618f, 0.08336114f, -0.04992522f, -0.04741021f, 
    -0.13913514f, -0.00002304f, 0.28566906f, 0.13099630f, -0.21706712f, -0.18709722f, -0.73448223f, -0.03962368f, 
    0.11819797f, -0.23962435f, -0.45256466f, -0.32570156f, -0.20463489f, -0.09750634f, -0.25351575f, -0.18144876f, 
    0.04983969f, -0.09259065f, 0.24533455f, -0.31944126f, 0.32763046f, -0.36380470f, -0.22723190f, -0.04274633f, 
    0.09377585f, 0.58192211f, -0.12011509f, 0.20838451f, -0.14858614f, -0.08891256f, 0.42784178f, 0.26892239f, 
    0.08525752f, -0.59095871f, 0.18116660f, -0.44325295f, -0.22311637f, 0.01423203f, -0.14961557f, -0.16186698f, 
    0.41059071f, 0.26498011f, 0.42303127f, 0.02823883f, 0.47345564f, 0.06560260f, 0.33086267f, 0.00942136f, 
    0.00388737f, 0.26686338f, 0.05098631f, 0.07452094f, 0.15784793f, -0.14605238f, 0.21985841f, 0.02684776f, 
    -0.28937513f, 0.34204474f, 0.17918953f, 0.14707208f, -0.50195765f, 0.24383800f, 0.38289884f, -0.15609582f, 
    -0.14800443f, -0.11420255f, 0.01076220f, -0.01398271f, 0.15133515f, -0.03646624f, 0.50562429f, -0.06335381f, 
    0.16152814f, 0.04811271f, 0.20811218f, -0.19502006f, -0.12550497f, 0.31957987f, -0.27109364f, -0.07670757f, 
    0.27672815f, 0.01729472f, 0.18679796f, -0.00915392f, -0.07137666f, -0.46684343f, -0.02917639f, 0.08408865f, 
    0.17785409f, 0.03819335f, -0.19727725f, 0.14322422f, 0.39192393f, -0.70965642f, 0.49656904f, 0.29456005f, 
    0.16520204f, -0.16823530f, 0.32472387f, -0.65850329f, 0.30120066f, -0.08142550f, -0.09285355f, 0.06311236f, 
    -0.11588576f, 0.33577031f, -0.06385615f, 0.16271053f, -0.11589102f, -0.94868660f, 0.11602098f, 0.52464014f, 
    0.06224031f, 0.02289705f, 0.07951755f, -0.19616145f, -0.02269180f, 0.50147444f, 0.34901518f, -0.04590717f, 
    -0.09025707f, 0.46021736f, 0.47088417f, 0.29329398f, -0.83563596f, 0.07063945f, -0.50225383f, 0.04320485f, 
    0.37697372f, 0.17051043f, -0.01341169f, 0.00891647f, -0.05511418f, 0.22181693f, -0.68634999f, 0.23115230f, 
    -0.02354659f, 0.27120179f, 0.13736685f, 0.16880772f, -0.29387823f, 0.16105342f, 0.50570834f, 0.55672067f, 
    0.05666167f, -0.18737838f, -0.16077223f, -0.07477280f, -0.17752123f, -0.17324567f, -0.22226769f, -0.23150277f, 
    -0.04873279f, 0.10757485f, 0.01861829f, -0.01341677f, -0.17034489f, -0.09272608f, -0.24086079f, 0.22314239f, 
    0.15832806f, 0.29439226f, -0.19755106f, -0.07413743f, 0.27436376f, 0.37399602f, 0.14220458f, 0.23225522f, 
    -0.08932808f, -0.66555130f, 0.44930789f, 0.08171556f, -0.07536244f, -0.43435046f, -0.28209916f, 0.51396620f, 
    0.36968020f, 0.36621311f, 0.13317500f, -0.10765773f, 0.11143205f, 0.12859568f, -0.17545034f, -0.20064172f, 
    -0.21149917f, 0.41585869f, -0.20261529f, 0.36837885f, -0.41667396f, 0.04545080f, 0.00774706f, 0.23295176f, 
    -0.30984581f, 0.23376599f, -0.01296518f, 0.38779002f, 0.08170861f, -0.36796439f, 0.47173411f, 0.01672491f, 
    -0.21866865f, -0.38014746f, -0.02966991f, 0.24827479f, -0.31281510f, 0.18269973f, 0.49593276f, -0.05094583f, 
    -0.08674068f, -0.15365165f, 0.29043055f, 0.06569280f, 0.26786092f, -0.47194678f, 0.12031397f, -0.19373497f, 
    0.16216767f, 0.13238198f, 0.09314064f, -0.11377756f, -0.04699142f, -0.33120593f, -0.28418615f, -0.08568388f, 
    -0.11547763f, 0.00736509f, -0.00560690f, 0.16290027f, -0.08055160f, 0.37997976f, -0.32348701f, 0.08147705f, 
    -0.15812998f, 0.48743147f, -0.21711189f, 0.51084989f, -0.22135389f, -0.11437024f, -0.59961790f, 0.06858957f, 
    -0.10401977f, -0.25313580f, 0.12397284f, 0.04064681f, -0.15156002f, 0.30081430f, 0.19137612f, 0.22227705f, 
    0.15546981f, 0.27625528f, 0.21102911f, 0.28302199f, 0.15161648f, 0.21069111f, -0.22835656f, -0.46361575f, 
    -0.07003342f, 0.29353487f, -0.12557541f, 0.06499543f, 0.18277000f, 0.44677240f, 0.43002254f, -0.12563115f, 
    -0.08980952f, 0.49473369f, -0.02776458f, 0.22694002f, -0.15171160f, 0.36266151f, -0.51174313f, 0.07257847f, 
    0.33540511f, -0.07689109f, 0.24560888f, 0.16866209f, -0.27905944f, -0.25450140f, 0.50133044f, -0.08090913f, 
    0.20369159f, -0.08017426f, -0.13323657f, -0.66451120f, 0.07260545f, 0.37298620f, 0.06680857f, 0.13362642f, 
    0.44760850f, -0.32387245f, -0.21269110f, -0.05189401f, 0.07967446f, -0.26474071f, 0.53042507f, 0.11116476f, 
    0.24273270f, -0.16761960f, 0.39889094f, -0.01705433f, 0.01063925f, -0.87890500f, -0.40428528f, 0.36130205f, 
    0.08688886f, 0.01580701f, -0.11517247f, 0.30317226f, 0.22495669f, -0.47532177f, 0.18515036f, -0.21137574f, 
    0.00203286f, 0.45834169f, -0.00911386f, 0.16024601f, -0.08064310f, -0.44513705f, 0.47863254f, -0.18719868f, 
    -0.19794193f, -0.03870519f, 0.29644796f, 0.17313777f, -0.14796713f, -0.20277812f, -0.60721827f, 0.09393400f, 
    0.20305438f, -0.15953842f, -0.01552810f, 0.06645444f, 0.04531706f, -0.09552494f, 0.34117591f, -0.07236016f, 
    -0.12295987f, -0.12573053f, 0.07923717f, -0.19796754f, -0.06332884f, -0.01338306f, 0.10724556f, 0.19477406f, 
    0.10781127f, 0.11315842f, -0.19512585f, -0.26297078f, -0.21513198f, -0.18570527f, 0.17991321f, -0.05132412f, 
    -0.38629881f, -0.12229504f, -0.20099750f, -0.02862434f, 0.05060646f, 0.24836521f, 0.16004083f, -0.14990380f, 
    0.17080273f, -0.22333676f, 0.01316586f, -0.01916828f, 0.52917534f, 0.34220135f, 0.23920861f, -0.12344535f, 
    -0.02258627f, 0.08638322f, -0.11605946f, -0.21726623f, -0.20965612f, 0.14714991f, -0.26635498f, -0.19697735f, 
    0.00446090f, 0.10837783f, -0.26991135f, 0.16405796f, -0.09873258f, -0.03578602f, -0.18446335f, 0.02384430f, 
    -0.19295743f, -0.19976014f, -0.14507410f, -0.20350504f, 0.17793027f, 0.07377425f, -0.12487307f, -0.17989218f, 
    -0.20043868f, -0.19450611f, -0.12431237f, 0.12602079f, -0.18557408f, -0.16555831f, -0.04553780f, -0.13363051f, 
    -0.34760171f, -0.22449727f, 0.31190041f, 0.32251874f, 0.37767354f, 0.29832995f, -0.12056150f, 0.14216106f, 
    -0.25554478f, 0.33529505f, 0.32027200f, -0.25855982f, -0.15937257f, -0.28011271f, 0.25919625f, -0.27748758f, 
    0.23004143f, 0.17600717f, -0.16587397f, 0.20918751f, -0.12204431f, -0.32619226f, 0.29358745f, 0.02529770f, 
    0.26451531f, 0.46617216f, -0.16293140f, -0.47961563f, -0.12878120f, 0.30264106f, -0.37248906f, -0.24126311f, 
    -0.23203233f, 0.14798254f, -0.16733879f, -0.07011814f, -0.10050857f, 0.06129065f, 0.11605236f, 0.14959148f, 
    -0.09479156f, 0.13075940f, -0.12571006f, -0.05033837f, -0.24959603f, -0.09151121f, 0.02801106f, -0.23888758f, 
    0.19841157f, 0.08828128f, 0.00145866f, -0.05831309f, -0.18293199f, -0.07986316f, 0.06285416f, -0.16285107f, 
    0.29332453f, 0.28804711f, -0.01703812f, 0.18116169f, 0.33838227f, -0.42763159f, -0.46882755f, -0.16286680f, 
    0.60259318f, -0.16616885f, 0.41407341f, -0.10123292f, -0.28207368f, -0.06702405f, -0.05720951f, -0.03161199f, 
    0.08800235f, -0.07381190f, 0.50534379f, 0.29141343f, -0.14605020f, -0.45201841f, -0.46592286f, 0.17875390f, 
    -0.31596872f, -0.48026484f, 0.13482529f, 0.16520293f, -0.20267612f, 0.11589947f, 0.36251852f, 0.20236017f, 
    0.34398049f, -0.02845852f, -0.03414458f, -0.50978029f, 0.16601601f, -0.27640343f, 0.40040094f, 0.21693060f, 
    -0.23739210f, -0.13432880f, 0.01530754f, 0.32202208f, -0.02463961f, -0.37499931f, 0.62810081f, 0.00585040f, 
    -0.29933724f, 0.17518297f, 0.14802302f, 0.32574981f, -0.68084180f, 0.22745618f, -0.29767630f, 0.38650715f, 
    0.24816628f, 0.04686740f, 0.15384918f, 0.21564426f, 0.15503842f, 0.01296234f, -0.26514384f, 0.06797648f, 
    -0.21269315f, 0.54334784f, -0.30685994f, 0.33884150f, -0.20623593f, -0.22051544f, 0.43138909f, 0.04693004f, 
    0.25746390f, 0.13042307f, 0.15170377f, -0.12520322f, -0.28511366f, -0.00508407f, -0.28764603f, -0.24419782f, 
    0.04273963f, 0.13711746f, -0.15652561f, 0.13691986f, 0.43791515f, -0.04684898f, 0.39468378f, 0.34140974f, 
    0.08843117f, 0.05283888f, 0.33546051f, -0.24385220f, -0.29412401f, 0.26372623f, 0.24380258f, 0.16587444f, 
    -0.16342048f, 0.59167314f, 0.19181193f, -0.09958144f, 0.35355768f, 0.19342993f, 0.12865993f, -0.08816111f, 
    -0.19067430f, -0.15102008f, 0.25684050f, -0.05534729f, -0.23831882f, -0.06065848f, -0.28150946f, 0.01104313f, 
    0.17906126f, -0.17016061f, -0.21412051f, -0.34034520f, -0.11207829f, -0.00203513f, -0.27299809f, -0.14990123f, 
    -0.18754150f, -0.22202037f, -0.00636798f, -0.30499297f, 0.03641586f, 0.16252021f, -0.10288203f, -0.24504188f, 
    0.11187005f, 0.10484617f, -0.20921592f, 0.21112151f, 0.04177451f, -0.48036507f, 0.51198488f, 0.64748371f, 
    0.47029382f, -0.08219020f, 0.13985296f, -0.12815367f, 0.05195504f, 0.71442318f, -0.15999922f, -0.21566179f, 
    -0.12287713f, 0.08780370f, -0.00069770f, -0.16480806f, -0.00882692f, 0.29141235f, -0.59795731f, 0.02062666f, 
    0.40919420f, -0.13802095f, 0.12752222f, 0.26344967f, -0.28771251f, 0.07874622f, 0.33499318f, -0.13647750f, 
    0.21484509f, 0.12576973f, -0.22269578f, -0.24649636f, 0.49948511f, -0.15163395f, -0.47148108f, 0.12940282f, 
    0.06747625f, 0.11707233f, -0.31554285f, -0.09764507f, 0.02863423f, -0.11138147f, 0.05141479f, -0.18008816f, 
    0.36478430f, 0.82914454f, -0.28912467f, 0.02967598f, -0.29277399f, -0.01009555f, 0.17830747f, -0.26277909f, 
    -0.12030946f, 0.37009177f, 0.20105261f, -0.09728857f, 0.20619734f, 0.34761566f, -0.08840083f, 0.15358672f, 
    -0.02619757f, 0.09515592f, -0.24108839f, -0.18537852f, 0.16796939f, -0.14328259f, -0.17430839f, -0.11104337f, 
    -0.05333635f, -0.08307430f, -0.05585822f, -0.15798406f, -0.17731750f, -0.09945052f, -0.13584229f, 0.24660262f, 
    0.05075453f, -0.01055564f, -0.13499926f, 0.00666234f, 0.22631004f, -0.08930156f, -0.16165149f, -0.03947958f, 
    -0.34937045f, 0.25139257f, 0.19449262f, 0.11195902f, -0.00823798f, -0.02481343f, -0.68713856f, 0.09224761f, 
    0.11750314f, -0.43829525f, -0.55754977f, -0.26680547f, 0.29787457f, -0.07219616f, -0.09057833f, -0.55022103f, 
    -0.01306515f, 0.34670383f, 0.13033791f, 0.28355247f, -0.16442166f, -0.19635385f, 0.37772238f, -0.04863869f, 
    -0.24723166f, 0.06811523f, 0.01990798f, 0.18297683f, -0.30135038f, -0.05055444f, 0.50810796f, -0.22468045f, 
    0.09517532f, 0.08163745f, 0.16352747f, 0.19420925f, -0.21457060f, -0.20048997f, -0.26008624f, -0.11716003f, 
    -0.27015588f, 0.08123261f, 0.03464319f, 0.41202623f, 0.23411070f, -0.09307738f, 0.04284362f, 0.06530343f, 
    -0.10513790f, 0.35228220f, -0.51888442f, -0.20226510f, -0.03385254f, 0.76048750f, 0.33615759f, 0.00669104f, 
    -0.32396173f, -0.20801614f, 0.13694240f, 0.25315604f, 0.17813800f, -0.61370337f, -0.11564901f, 0.30691591f, 
    0.57397532f, -0.18835029f, 0.08292589f, 0.18753730f, -0.21415965f, -0.16677237f, 0.30500534f, -0.18455066f, 
    0.16516602f, -0.35163927f, 0.13925105f, 0.31772310f, 0.50562865f, 0.12199213f, -0.41685039f, 0.00261489f, 
    -0.17964529f, -0.06685202f, 0.23642382f, -0.38576862f, -0.09879334f, -0.47469342f, -0.27851006f, -0.12809858f, 
    0.17850564f, 0.36996600f, -0.05658422f, 0.34295011f, -0.29396057f, -0.31205547f, 0.47392765f, 0.18652426f, 
    -0.08745176f, -0.21825232f, 0.04358164f, -0.18475366f, 0.10570188f, -0.15692544f, -0.23634572f, -0.00912407f, 
    0.07188608f, 0.06698450f, -0.02229074f, -0.27650547f, 0.16873108f, -0.05146283f, 0.14103508f, -0.23146158f, 
    0.35679597f, -0.13195023f, 0.08286889f, -0.01353144f, 0.22134121f, 0.08603092f, -0.31934905f, -0.22701576f, 
    -0.17092447f, 0.74757862f, -0.18607561f, -0.10212344f, -0.04993625f, 0.32157710f, 0.03627416f, 0.14294270f, 
    -0.25461870f, -0.06518785f, 0.38424605f, -0.21393751f, 0.20507459f, 0.32983744f, -0.13691843f, 0.13594897f, 
    0.24021041f, -0.06669146f, 0.17087115f, -0.13258949f, -0.13329744f, -0.23162997f, 0.13162988f, -0.14413059f, 
    -0.20359704f, -0.06315600f, -0.22054747f, 0.02193419f, -0.23073076f, 0.11055818f, -0.15273163f, 0.03232303f, 
    -0.22333582f, 0.01649166f, -0.22038318f, -0.15193969f, 0.18661879f, 0.16241108f, -0.02703600f, 0.07419697f, 
    -0.25059029f, 0.23337774f, 0.20740695f, 0.04148167f, -0.13827506f, -0.34096327f, 0.22673915f, -0.06834641f, 
    -0.25763455f, 0.46120441f, 0.06421332f, 0.27476072f, 0.03448348f, 0.09656036f, 0.20732300f, -0.22716007f, 
    0.45650524f, -0.18922779f, -0.00095815f, 0.21039009f, -0.03932203f, -0.07788166f, 0.59665656f, -0.00126725f, 
    -0.09515647f, 0.59475720f, 0.03597474f, -0.60395354f, -0.38280028f, 0.33781987f, -0.64217597f, -0.00025539f, 
    -0.03848656f, 0.01018014f, -0.37116745f, 0.00223747f, 0.17433430f, 0.01627010f, 0.49522659f, -0.23463315f, 
    -0.16574526f, 0.03920994f, -0.33240566f, 0.02152589f, 0.25975481f, 0.55185992f, 0.42111805f, 0.07052162f, 
    0.28444520f, 0.30525842f, 0.15878160f, 0.09818129f, 0.29157379f, 0.43207893f, 0.32915863f, -0.10837436f, 
    -0.15738505f, 0.36995664f, -0.24275661f, -0.21368811f, -0.58600903f, 0.03443724f, 0.30816266f, -0.05618234f, 
    -0.33639601f, 0.13797775f, -0.19680257f, -0.16908085f, 0.12333441f, 0.07909720f, 0.55228573f, 0.08691031f, 
    0.10413358f, 0.25036165f, 0.18679546f, 0.30155557f, -0.20579824f, -0.08309960f, -0.31564635f, -0.26952997f, 
    -0.26462755f, 0.00145009f, -0.07470044f, 0.21485116f, -0.18193726f, 0.18120883f, 0.57424128f, -0.02801007f, 
    0.14364474f, -0.43604043f, 0.05556836f, 0.01191053f, 0.50532740f, 0.07389528f, 0.47225511f, -0.15280232f, 
    -0.42166317f, 0.15138558f, -0.11858045f, 0.29557240f, 0.21922959f, -0.22393061f, 0.33616227f, -0.07652913f, 
    -0.19363385f, -0.24017586f, 0.28873461f, -0.26543206f, -0.04853871f, 0.38076034f, 0.00417233f, 0.13580970f, 
    -0.23272175f, -0.21236326f, -0.01119932f, 0.16124338f, -0.02238578f, -0.03866325f, 0.04002072f, 0.01637697f, 
    -0.11148081f, -0.27950335f, -0.20153449f, 0.15753159f, -0.09113512f, -0.15201567f, 0.09610521f, -0.03561481f, 
    0.57239622f, -0.25255254f, -0.01182601f, 0.14094710f, 0.15978834f, 0.20038708f, 0.13766813f, -0.21551687f, 
    0.13895090f, 0.01673684f, -0.09628548f, -0.43745601f, -0.13348566f, 0.52235419f, -0.44368616f, 0.05926035f, 
    0.52534699f, 0.01934114f, 0.38904202f, -0.13778192f, -0.16377719f, -0.07346427f, -0.67422605f, -0.14181495f, 
    0.26993543f, 0.25512862f, -0.26361772f, -0.35984111f, -0.34047428f, -0.05856312f, 0.09609503f, -0.03117122f, 
    -0.04208677f, 0.44766569f, -0.42632708f, -0.19604689f, -0.13554187f, 0.60869712f, 0.53525454f, 0.17090255f, 
    -0.28475031f, 0.39786175f, -0.02593520f, 0.33062205f, 0.24848378f, 0.06385238f, -0.13031450f, -0.09294382f, 
    -0.22653553f, 0.23715262f, -0.10620859f, -0.22164127f, 0.32161972f, 0.15230492f, -0.22508310f, -0.10782849f, 
    0.08177682f, 0.18051930f, -0.05292797f, 0.47968531f, 0.09931295f, -0.10798841f, 0.43287933f, 0.16566998f, 
    -0.40318537f, 0.26058239f, -0.08523095f, 0.06420631f, -0.10911673f, 0.42010155f, -0.15843810f, 0.06836426f, 
    0.12452137f, -0.43508804f, 0.06676038f, 0.26806813f, 0.18195549f, -0.47038046f, 0.34886029f, 0.16451241f, 
    -0.13187033f, -0.20328797f, -0.19860494f, 0.06399610f, -0.21435130f, -0.12279489f, 0.15121056f, 0.24823597f, 
    0.05650368f, -0.18276539f, -0.22057687f, 0.11610132f, 0.02352663f, 0.03086178f, -0.12167217f, -0.06723680f, 
    -0.18653898f, 0.14943561f, -0.28239316f, -0.07850077f, -0.07711361f, -0.00357180f, -0.28165808f, 0.17511392f, 
    -0.00471700f, -0.10051633f, 0.17160220f, -0.11485945f, 0.03533822f, -0.03445955f, -0.19294791f, -0.11667307f, 
    -0.18552795f, 0.38718650f, 0.06580921f, 0.18822776f, 0.08503191f, -0.14434648f, 0.17630872f, -0.10996556f, 
    -0.16953905f, -0.10791593f, 0.00479968f, -0.11607993f, 0.15203089f, -0.18787666f, -0.22194554f, -0.12379589f, 
    0.79052645f, -0.24365556f, -0.15830110f, -0.20989378f, 0.15911828f, 0.10893013f, 0.24099806f, -0.23204386f, 
    0.22182931f, 0.32285202f, 0.17277341f, -0.08597947f, -0.51007181f, -0.62657815f, -0.41138011f, 0.28262734f, 
    0.10853624f, -0.31217802f, 0.19436705f, -0.28945178f, -0.00468561f, 0.21078020f, 0.25989437f, -0.21158396f, 
    0.25998345f, 0.16647536f, 0.14879863f, 0.08734634f, 0.23067977f, 0.28682667f, -0.46881998f, -0.04846806f, 
    0.23392408f, 0.12030416f, 0.12004774f, -0.24034329f, -0.12966350f, -0.47137129f, 0.09730576f, 0.17853822f, 
    0.07746103f, -0.18123914f, 0.18023264f, 0.26854688f, -0.06980602f, 0.09718905f, -0.26308861f, 0.35450321f, 
    0.17943560f, 0.25241211f, -0.30703396f, -0.30793646f, 0.19683002f, 0.77509004f, 0.28803051f, -0.11236846f, 
    -0.15057054f, 0.75545114f, 0.22199354f, 0.08000170f, -0.57360268f, 0.25517455f, -0.60310405f, 0.09830540f, 
    -0.38199139f, -0.19656144f, 0.18692167f, 0.15961203f, 0.06678648f, -0.31768084f, -0.10234601f, -0.13053399f, 
    0.31857321f, -0.02664679f, -0.45833588f, -0.34609860f, -0.16714741f, 0.13721152f, -0.29044333f, 0.39283675f, 
    0.44947577f, -0.35794100f, 0.38144389f, -0.16755262f, 0.11917126f, 0.21495181f, -0.19448473f, 0.17959663f, 
    0.23497111f, -0.16138558f, 0.32119066f, 0.09320149f, 0.20141697f, -0.23479001f, -0.40613776f, -0.04026829f, 
    0.06096827f, -0.05189600f, -0.08687443f, 0.19564722f, -0.23203388f, -0.60759568f, 0.28645414f, 0.09674347f, 
    -0.37986124f, 0.03349696f, 0.24051435f, 0.29990435f, 0.09025000f, 0.48671722f, -0.11816216f, 0.34103543f, 
    -0.10058255f, -0.26482269f, 0.20756970f, 0.27036157f, 0.28128254f, -0.53978646f, -0.04729896f, 0.03766678f, 
    -0.09575348f, 0.49264124f, 0.34107506f, 0.14439470f, -0.18926890f, -0.19353876f, 0.31932792f, -0.05550118f, 
    -0.47086504f, 0.45347431f, -0.07530759f, -0.63178337f, -0.09146350f, -0.48309579f, 0.27633950f, -0.17324844f, 
    -0.11557862f, 0.23236777f, -0.24392235f, 0.20213944f, 0.37029409f, -1.13845134f, 0.34935468f, 0.18813597f, 
    0.12274525f, -0.02240325f, -0.04011930f, 0.17999576f, 0.29191664f, -0.07987957f, 0.08155182f, 0.10094213f, 
    0.00903007f, 0.10978375f, -0.20005909f, -0.21165150f, -0.39715275f, 0.18128805f, 0.50572813f, 0.29677549f, 
    0.16063666f, -0.23552917f, 0.20256735f, 0.06781245f, 0.12565058f, -0.32805195f, 0.26077262f, -0.23404136f, 
    0.17577243f, -0.39921317f, -0.27412459f, -0.27936962f, 0.00776349f, 0.19711483f, 0.30844972f, 0.36845908f, 
    0.42330346f, -0.29124051f, 0.09095021f, -0.15866537f, 0.24675655f, -0.08444403f, -0.20915148f, 0.04994758f, 
    0.20051706f, 0.23205532f, -0.13807486f, 0.09755459f, 0.09729314f, -0.07005394f, -0.35837895f, 0.30210611f, 
    -0.30909365f, -0.21616988f, 0.21431382f, -0.29271272f, -0.09691080f, -0.14958949f, -0.23687729f, 0.16462772f, 
    0.28477043f, -0.04162541f, 0.45392731f, -0.02194804f, 0.23812741f, 0.21853597f, 0.05475336f, 0.30206060f, 
    0.23300493f, -0.43509546f, -0.51508152f, 0.10897000f, -0.06748119f, 0.04093251f, 0.46535859f, 0.11072770f, 
    0.61833996f, -0.34978756f, 0.35099989f, -0.23765123f, 0.07483605f, 0.08136397f, -0.15507177f, 0.11009500f, 
    0.04883916f, 0.14057915f, -0.41574088f, 0.33337900f, 0.16389388f, 0.21151987f, 0.10899389f, 0.07253120f, 
    0.02270260f, -0.06155416f, 0.17326252f, 0.02558547f, 0.19348736f, 0.08224401f, 0.01014973f, -0.35834458f, 
    0.18836784f, 0.07729931f, 0.14003557f, 0.18721573f, 0.07593302f, -0.15026674f, -0.06961972f, 0.03748128f, 
    -0.05267848f, 0.47031528f, -0.28906304f, -0.16580075f, -0.31913003f, 0.33626172f, -0.15777811f, 0.15858169f, 
    -0.19120352f, -0.06225063f, 0.09902304f, -0.49087307f, 0.18105045f, -0.01077211f, -0.19271061f, -0.07210040f, 
    0.27031663f, 0.38704109f, -0.15155300f, -0.12188160f, -0.20983616f, -0.64898801f, 0.42657048f, 0.47718337f, 
    -0.18751271f, -0.16098735f, -0.02900629f, -0.15427645f, -0.16878071f, -0.11130429f, 0.18121018f, 0.05697012f, 
    0.16285709f, 0.08145475f, -0.17631920f, 0.15930587f, 0.07346798f, -0.09239624f, 0.17231822f, -0.19904281f, 
    -0.16062908f, 0.06581238f, -0.40783322f, 0.20535772f, 0.11265543f, -0.45044068f, 0.24676937f, 0.05568397f, 
    0.22978973f, -0.03179688f, -0.00917120f, -0.09333443f, -0.02476537f, 0.27876669f, 0.02892546f, -0.02032934f, 
    0.07978036f, 0.48017463f, -0.40230298f, -0.34866428f, 0.09411116f, -0.10433638f, 0.55707550f, -0.21617208f, 
    -0.37160987f, 0.36925244f, -0.14853010f, 0.45274270f, 0.12535636f, 0.00437771f, -0.08176211f, -0.16700689f, 
    0.31236231f, -0.30365843f, -0.17398943f, 0.03872705f, -0.22433110f, 0.14530087f, 0.24851042f, -0.07619214f, 
    0.52090526f, 0.22284462f, 0.15039934f, -0.14900151f, 0.11326344f, 0.16470426f, -0.43834597f, -0.30829144f, 
    0.77637756f, -0.14135697f, 0.10457153f, 0.04143208f, 0.32003087f, 0.35808712f, 0.11442717f, -0.01566806f, 
    -0.11071480f, -0.19318675f, -0.05924094f, -0.00228624f, -0.53865629f, -0.32103375f, 0.05911388f, 0.23764285f, 
    0.29182267f, -0.22552748f, 0.19083752f, -0.00256574f, 0.10694814f, -0.09800985f, 0.01974764f, 0.17836262f, 
    0.31705979f, -0.28091681f, 0.38340023f, 0.05809929f, -0.04150795f, 0.01022847f, -0.26096952f, -0.24573055f, 
    0.21455629f, 0.11901137f, -0.04596635f, -0.03982048f, 0.18426622f, -0.32297239f, 0.00673333f, 0.20875099f, 
    0.19864744f, 0.03257616f, -0.30255073f, -0.31575927f, 0.23731090f, -0.10114380f, 0.15338331f, 0.42425737f, 
    -0.03343640f, 0.26041114f, -0.04907741f, 0.18271567f, -0.13726307f, 0.06430417f, 0.40176952f, 0.08204862f, 
    -0.27489439f, -0.46641141f, 0.16556960f, -0.02745166f, 0.36694276f, 0.12260079f, -0.11123034f, 0.42800727f, 
    -0.19473907f, -0.10013056f, -0.16648148f, 0.23688945f, 0.05838266f, -0.22676092f, 0.35242897f, -0.14807865f, 
    0.19608097f, -0.09632052f, 0.53266186f, 0.00502695f, 0.42214844f, 0.22020516f, -0.38476419f, -0.06050406f, 
    -0.47376901f, -0.04524539f, 0.37583032f, -0.00144820f, 0.11715680f, -0.06150919f, 0.00471624f, 0.20948678f, 
    -0.13660064f, -0.14069730f, 0.31442735f, -0.14929998f, 0.16380195f, -0.37069181f, -0.04802625f, -0.08292489f, 
    0.24048866f, -0.34061021f, 0.23048352f, 0.16334340f, -0.26966062f, 0.04749441f, -0.20890190f, 0.13442136f, 
    0.38651374f, -0.37864920f, 0.29188618f, -0.21408704f, 0.20150116f, -0.13183419f, 0.25093034f, 0.03644448f, 
    0.42017397f, -0.22112507f, 0.18703584f, 0.29219115f, -0.04359737f, 0.06284317f, -0.05641204f, 0.14445323f, 
    0.11547568f, -0.15733859f, -0.02736121f, 0.18470542f, -0.08769686f, -0.53187865f, 0.24958594f, 0.45452714f, 
    -0.06534250f, 0.15213662f, -0.09436671f, 0.12768751f, 0.30957046f, -0.24440129f, 0.31862786f, -0.10588461f, 
    -0.27859727f, -0.13644856f, 0.41413391f, 0.29230073f, 0.01972752f, -0.54305834f, 0.11253285f, 0.51070011f, 
    -0.00156322f, -0.04173265f, -0.00711195f, -0.24340974f, -0.23391046f, 0.07185491f, -0.18405606f, 0.15487728f, 
    -0.04795786f, 0.00102405f, 0.02016388f, -0.15886989f, 0.23422582f, -0.02768019f, -0.12090951f, 0.04439551f, 
    0.63607115f, 0.27943051f, 0.11698529f, -0.25752136f, -0.28667706f, 0.17900589f, -0.12223570f, -0.22763275f, 
    -0.22889860f, 0.38416603f, 0.01834754f, 0.22269788f, 0.16814914f, 0.04366726f, -0.14341119f, 0.28570715f, 
    0.17077000f, -0.04786941f, 0.02692865f, 0.29049450f, -0.45343179f, -0.68863177f, 0.15594092f, 0.18317559f, 
    -0.21232970f, 0.21715629f, -0.05163762f, 0.11251111f, -0.21434301f, 0.27407011f, -0.09375332f, 0.32477477f, 
    0.32817954f, 0.12883464f, 0.07968678f, 0.30404550f, -0.10398321f, 0.15472576f, -0.19085291f, -0.03703490f, 
    -0.18678451f, -0.06603181f, 0.22019202f, -0.07922339f, 0.50362730f, -0.27912593f, 0.05245027f, -0.59800810f, 
    0.30830559f, -0.04545986f, 0.25673214f, -0.16248141f, 0.25002953f, -0.11023960f, -0.30993524f, -0.22856575f, 
    -0.20821019f, -0.07635062f, 0.18228446f, 0.08406653f, -0.38904619f, 0.17515555f, 0.35195109f, 0.54663581f, 
    -0.22561389f, -0.02850253f, 0.07270934f, 0.33507729f, -0.08048394f, 0.36074403f, 0.51995152f, 0.01382413f, 
    -0.31123635f, -0.03371654f, 0.31830692f, -0.20213470f, -0.56319141f, 0.08031945f, 0.00091326f, 0.04863424f, 
    0.44720221f, 0.03853222f, -0.09422400f, -0.26078925f, 0.11140741f, 0.44519866f, 0.40318298f, -0.23639587f, 
    0.08968565f, 0.26066220f, -0.07332415f, 0.32528618f, -0.15566638f, -0.09847081f, -0.41536862f, -0.13783827f, 
    0.45340359f, 0.15118566f, -0.52832162f, 0.47030517f, 0.09464908f, -0.09555637f, 0.13834974f, 0.16053380f, 
    -0.09930751f, 0.06277034f, -0.00931299f, 0.15793270f, 0.34177586f, -0.38551131f, -0.02322927f, -0.22178185f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.42361623f, 0.32970071f, 0.35920173f, 0.13488597f, -0.22367221f, -0.21174930f, -0.11779089f, 0.07700428f, 
    0.04803161f, 0.27232072f, -0.00471329f, -0.33552927f, 0.09865910f, 0.19585693f, -0.15521206f, 0.08824243f, 
    0.00489306f, 0.47876775f, 0.15519126f, 0.25330129f, 0.29737425f, 0.34463724f, -0.19124444f, 0.10473391f, 
    -0.17546220f, -0.21496819f, 0.06988646f, 0.17843933f, 0.05283397f, -0.12104673f, -0.26707879f, -0.21645349f, 
    0.01276349f, -0.16229185f, -0.06704223f, 0.21958038f, 0.11592622f, 0.22512059f, 0.17537068f, -0.02987877f, 
    0.34364909f, 0.28690922f, 0.01678898f, -0.27348891f, 0.32188368f, -0.04426138f, -0.10638881f, -0.24832077f, 
    0.05319633f, -0.06633838f, 0.52015764f, 0.33925611f, -0.12554197f, 0.27549592f, 0.09966095f, 0.06970532f, 
    -0.18323030f, -0.03622622f, 0.05745777f, 0.10499889f, 0.14272161f, 0.02775317f, -0.28899035f, 0.01737300f, 
    -0.45693928f, -0.06653093f, 0.49146155f, 0.37064660f, 0.33982822f, 0.06358254f, -0.23634002f, 0.03513744f, 
    0.29303902f, 0.01719093f, -0.11034155f, 0.04303456f, 0.09424065f, -0.25282478f, 0.29594436f, 0.27291813f, 
    0.29803762f, 0.17351882f, 0.14760487f, 0.40057555f, 0.53713036f, 0.01147089f, 0.24404536f, -0.15473734f, 
    -0.04209836f, -0.36592025f, 0.11595296f, 0.32036290f, -0.12623626f, 0.28183657f, -0.36544594f, -0.26150602f, 
    0.68436384f, 0.37309352f, -0.04545651f, -0.08451875f, 0.01459102f, -0.18065834f, -0.12231160f, 0.02232150f, 
    0.05257272f, -0.19386354f, 0.04065406f, -0.24991505f, -0.20340323f, 0.50442564f, 0.45391455f, -0.16972914f, 
    0.07651170f, -0.36977732f, 0.37704366f, 0.46795055f, 0.32287258f, 0.10695320f, -0.00157156f, 0.24955314f, 
    0.04927056f, -0.19104342f, 0.37874067f, 0.28151467f, 0.26059905f, 0.03771532f, 0.06771118f, 0.23133586f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.57426500f, 0.00321594f, -0.11775453f, -0.12492573f, 0.03139441f, 0.21953271f, -0.17115764f, -0.11385108f, 
    0.15448798f, -0.55159330f, -0.13258375f, -0.01176544f, -0.02347525f, 0.11944915f, -0.07996430f, 0.01234778f, 
    0.04594314f, -0.31221381f, 0.06848851f, 0.08008296f, -0.22194158f, -0.24389984f, 0.07603461f, 0.24448565f, 
    0.20361657f, 0.08921020f, -0.29874668f, 0.23851898f, 0.13676271f, -0.81075341f, 0.18442178f, 0.02684436f, 
    -0.26100224f, 0.08859123f, 0.03166164f, 0.05438762f, -0.30513656f, -0.27848375f, -0.33036646f, -0.04944358f, 
    -0.20310374f, 0.13235898f, 0.00738301f, -0.07306966f, -0.06896798f, -0.02878623f, 0.06007289f, 0.16676633f, 
    -0.07711990f, -0.04239963f, 0.02876252f, -0.23688594f, 0.24596825f, -0.21875542f, 0.24890450f, 0.25480935f, 
    0.01126464f, -0.08340958f, 0.29494050f, -0.09652338f, -0.03538061f, 0.28807214f, 0.08299398f, -0.09053626f, 
    0.11764679f, 0.08502601f, -0.07908144f, -0.26041013f, -0.37513739f, 0.31725079f, -0.02115697f, 0.09131829f, 
    0.06942353f, -0.06280711f, 0.01899102f, -0.66902882f, 0.17843892f, 0.16623308f, -0.49717984f, 0.03583923f, 
    -0.25360158f, -0.05701157f, -0.38562620f, 0.05297939f, -0.47238174f, 0.07899433f, 0.13198420f, -0.07314936f, 
    -0.02269514f, 0.18123449f, -0.16791186f, -0.43341479f, -0.19246510f, -0.66698909f, -0.06725111f, -0.15621851f, 
    -0.49714693f, 0.08160717f, 0.24688978f, 0.17688045f, 0.14767730f, -0.10344851f, 0.00717252f, -0.54977494f, 
    -0.25588065f, -0.10132121f, 0.24174741f, 0.05147306f, -0.08788265f, -0.50476664f, 0.01538287f, 0.05108016f, 
    -0.30005285f, 0.14223312f, -0.31908879f, -0.95580566f, 0.00267083f, 0.03777414f, 0.14286676f, -0.05009635f, 
    0.06586992f, -0.16871554f, -0.41859460f, -0.01474692f, 0.08190711f, -0.29233024f, -0.48262957f, -0.32956067f, 
    -1.53497887f, -0.00644220f, 0.11280702f, -0.41509253f, -0.20866555f, 0.04504273f, -0.07754897f, -0.13084161f, 
    -0.02382351f, -0.27984899f, -0.21856910f, -0.12049610f, 0.01460937f, 0.34929246f, 0.02431121f, 0.08693182f, 
    -0.02980258f, -0.16425304f, 0.20774160f, 0.24628474f, 0.32348505f, 0.24356809f, 0.05002685f, 0.01918674f, 
    -0.16123931f, 0.10554577f, -0.06926674f, -0.05233961f, 0.07528479f, 0.13144915f, 0.06640165f, 0.05546495f, 
    0.05606717f, 0.11138833f, -0.00852018f, -0.05474288f, -0.35582140f, 0.01121328f, 0.07720063f, 0.07825886f, 
    -0.31947151f, -0.10678117f, -0.11392044f, -0.01045271f, -0.05640924f, -0.01903322f, -0.02877118f, -0.12199192f, 
    0.04495590f, -0.00391992f, -0.23973192f, 0.03341765f, -0.24521947f, 0.23940541f, 0.00555069f, 0.03451226f, 
    0.15454134f, -0.07739696f, 0.04806834f, 0.17176101f, -0.04880825f, -0.24667725f, -0.10625593f, -0.00159247f, 
    -0.15152995f, 0.00508365f, 0.07787134f, 0.24611089f, -0.05074504f, 0.22684394f, -0.01991105f, 0.03476543f, 
    -0.04995526f, 0.00542360f, 0.09328610f, 0.39390907f, 0.20356676f, 0.01136162f, -0.02899642f, -0.00586087f, 
    -0.01480022f, -0.00902520f, 0.23705229f, 0.12556520f, 0.18182436f, 0.09204330f, 0.08979484f, -0.02229235f, 
    -0.05750109f, -0.18153907f, -0.51311636f, -0.02389206f, 0.07311071f, 0.03063983f, -0.05716164f, -0.21668258f, 
    0.44686362f, -0.07058419f, 0.71575397f, -0.07740784f, -0.03034927f, -0.10754569f, 0.10008860f, -0.69468039f, 
    -0.14494018f, 0.11456973f, 0.11844729f, -0.22804393f, -0.26464692f, 0.17639984f, -0.04333241f, -0.33164397f, 
    -0.19827127f, -0.12272622f, 0.11966088f, -0.13158129f, -0.03407333f, -0.16964258f, -0.16261894f, 0.13022289f, 
    -0.04977615f, 0.07123156f, 0.31157318f, -0.12136789f, 0.12870678f, 0.06865885f, -0.21256645f, -0.24245307f, 
    -0.47557807f, -0.01048383f, -0.02896317f, 0.73159021f, 0.16362455f, -0.36285448f, 0.10358200f, 0.55007190f, 
    -0.13098784f, 0.06794517f, -0.09033979f, 0.37970728f, -0.32308429f, 0.14551812f, 0.20144512f, 0.10588170f, 
    -0.03655865f, -0.05670532f, 0.06856540f, -0.51800895f, 0.09025304f, 0.17394607f, 0.25082442f, -0.67969155f, 
    -0.11299363f, -0.22000685f, -0.06041543f, -0.47859740f, -0.52842289f, 0.39054194f, -0.26218370f, -0.06326129f, 
    0.11582579f, -0.16407749f, -0.12928523f, -0.12524012f, -0.01817348f, 0.07717910f, 0.01759076f, -0.16118656f, 
    0.37039447f, -0.35657105f, 0.23808566f, -0.08653926f, 0.03374020f, -0.08297301f, -0.01922001f, -0.04236162f, 
    -0.35535207f, -0.03074100f, 0.12853430f, 0.12216353f, 0.25681442f, -0.06463039f, -0.25453910f, -0.04641121f, 
    0.11185577f, 0.03886772f, -0.26210424f, 0.01187908f, -0.03425739f, -0.13775438f, 0.10956860f, -0.08194598f, 
    0.29861343f, -0.05971621f, 0.00841172f, 0.52582520f, 0.03772850f, -0.61157000f, 0.03241913f, -0.27393883f, 
    -0.00115691f, -0.03383689f, -0.06315991f, -0.50638443f, -0.48598009f, -0.15060072f, 0.23509206f, 0.08645489f, 
    -0.09813011f, 0.01436341f, -0.41938874f, -0.01692455f, 0.26619256f, -0.10201555f, 0.19551083f, -0.07530911f, 
    0.01806588f, 0.13746057f, 0.34205610f, 0.12095305f, -0.01238531f, 0.23529914f, 0.11996774f, 0.05003975f, 
    -0.30050123f, -0.59651589f, -0.52522349f, -0.54886436f, -0.16312416f, -0.10899497f, -0.05260223f, 0.22332412f, 
    0.02079270f, 0.01287112f, -0.29150027f, 0.01837987f, -0.19700776f, -0.02950792f, 0.08958707f, -0.53470939f, 
    0.02317753f, -0.24040331f, -0.00460711f, 0.05795270f, 0.04617352f, 0.05289165f, -0.09914441f, -0.02424674f, 
    0.05290942f, 0.11595294f, 0.14630572f, 0.06726015f, -0.26518369f, 0.22630753f, 0.19311686f, -0.06931619f, 
    -0.26807296f, -0.11466048f, 0.33456150f, 0.16215707f, 0.04639397f, 0.28116220f, 0.12814796f, 0.07759384f, 
    -0.78334069f, -0.03462061f, -0.09742047f, -0.16990718f, 0.07483599f, 0.23629181f, 0.00077495f, 0.10183246f, 
    -0.01396391f, 0.15046886f, 0.01502215f, -0.12169871f, 0.01160414f, -0.17219469f, -0.32667881f, 0.17089853f, 
    0.19077404f, -0.08053734f, -0.01867719f, -0.13339216f, 0.22891060f, 0.39205888f, 0.02769146f, 0.04659027f, 
    0.02459248f, 0.12100573f, -0.52200496f, 0.38239613f, 0.00594502f, 0.03490327f, 0.06169773f, -0.93770248f, 
    0.17430156f, -0.02530227f, -0.92075235f, 0.04085972f, -0.53501362f, 0.02053379f, -0.00761736f, 0.12396411f, 
    -0.44016072f, -0.02936308f, 0.33352810f, 0.29626700f, -0.09694114f, 0.01947316f, 0.00166425f, -0.13393515f, 
    0.01008487f, -0.06401263f, 0.09468306f, -0.22268365f, -0.70070523f, 0.11633554f, 0.46674806f, -0.02728487f, 
    -0.13423155f, -0.32520267f, -0.11939148f, -0.26301217f, -0.09483970f, 0.07962027f, 0.06686026f, 0.29727274f, 
    0.17392428f, 0.05100336f, -0.16205771f, -0.96104723f, -0.68924165f, 0.01862871f, -0.11794454f, -0.75204301f, 
    -0.32430977f, 0.06806870f, -0.65585393f, -1.85481119f, -0.23885944f, -0.04504878f, -0.21136969f, -0.00461529f, 
    -0.09626597f, 0.49243107f, 0.36352131f, 0.27289709f, 0.11906791f, 0.30824491f, -0.29672021f, 0.48108760f, 
    -0.28822428f, 0.12894604f, -0.50402462f, -0.12486999f, -0.11783553f, 0.37018341f, 0.15875734f, -0.03565769f, 
    -0.29534569f, -0.05167466f, 0.13815951f, -0.05369916f, -0.24918705f, -0.27328098f, 0.18797567f, 0.11960651f, 
    0.21784845f, -0.01679036f, -0.48257813f, -0.11735469f, 0.15876712f, -0.01625904f, 0.04249428f, -0.03361099f, 
    0.00967188f, 0.11463436f, -0.05015467f, -0.07652619f, 0.09645119f, -0.16839057f, 0.15317132f, -0.30822480f, 
    -0.21387029f, 0.04529703f, -0.55801654f, -0.06274491f, -0.45155039f, -0.00196402f, 0.03804133f, -0.11026812f, 
    0.00314707f, 0.07111486f, 0.36788747f, -0.02148283f, 0.15557748f, -0.36481348f, 0.18089682f, 0.13548662f, 
    -0.07638413f, 0.15587039f, -0.05529042f, 0.16378310f, 0.10560935f, -0.09472407f, -0.06345246f, 0.11051061f, 
    0.16075127f, 0.10122377f, -0.09583241f, -0.00433039f, -0.06767511f, -0.29162851f, 0.16604415f, -0.05799282f, 
    0.19903287f, -0.07359143f, 0.05775641f, -0.00047061f, 0.55585176f, -0.11987336f, -0.15708549f, -0.04741902f, 
    0.08220617f, 0.04917583f, 0.01083728f, 0.06047532f, -0.04320261f, -0.02716704f, -0.04082851f, 0.09939886f, 
    0.00331134f, 0.02590636f, -0.56280923f, -0.02356847f, 0.16201103f, -0.01545910f, -0.06400192f, -0.06742828f, 
    -0.27685782f, -0.24779652f, 0.12245527f, -0.13695085f, -0.07762338f, -0.11204898f, -0.01963007f, -0.04317822f, 
    -0.15637052f, -0.04106901f, -0.03486763f, -0.10229533f, -0.11929534f, 0.00225649f, -0.00724764f, -0.05527304f, 
    0.04251942f, -0.06353981f, -0.09043854f, 0.00764094f, -0.18570924f, -0.09848469f, -0.27719602f, -0.03215858f, 
    0.14545622f, 0.06287701f, -0.20961265f, -0.04693909f, -0.74405509f, 0.01590582f, 0.10775977f, 0.07051518f, 
    -0.01589401f, 0.00164605f, -0.09450387f, -0.21071011f, 0.09606120f, -0.34961784f, -0.01774773f, -0.07435291f, 
    -0.05312356f, 0.12241437f, -0.71844292f, 0.20119195f, 0.14395268f, 0.00229350f, 0.25503248f, 0.23594978f, 
    -0.04244420f, 0.08065391f, 0.05266677f, -0.03263244f, 0.19435465f, -0.92715031f, -0.57786965f, 0.00676868f, 
    0.10677416f, 0.05670113f, -0.07256683f, 0.09107255f, 0.07279508f, 0.22318560f, 0.07437550f, 0.17729773f, 
    -0.05427179f, -0.47789934f, -0.45353255f, -0.03078848f, 0.15406768f, 0.12711635f, -0.47969210f, -0.09656738f, 
    0.32610315f, 0.11489961f, -0.29461208f, -0.42794883f, 0.01423792f, -0.66109830f, -0.01297469f, 0.23077473f, 
    -0.09678681f, 0.43145576f, -0.38194549f, 0.02766707f, 0.14206620f, -0.55769277f, -0.78685337f, -0.04008489f, 
    -0.01778004f, 0.06674020f, 0.07677941f, 0.01401761f, 0.17924021f, -0.10762136f, 0.06971248f, -0.07411291f, 
    -0.62974197f, 0.03201693f, -0.09586042f, 0.05447118f, 0.02582853f, -0.07679696f, 0.04729078f, -0.01431776f, 
    0.18147479f, 0.11397520f, 0.09757046f, -0.01243134f, 0.05560138f, -0.28170124f, 0.06228308f, -0.05125194f, 
    0.17870629f, 0.05351412f, 0.07772297f, -0.03851116f, -0.08337497f, -0.07554477f, -0.04254657f, -0.26262650f, 
    0.02728236f, -0.06079882f, -0.12452928f, 0.04325510f, -0.24948449f, 0.31272423f, 0.04288478f, -0.03465997f, 
    -0.41594410f, -0.36063021f, 0.05892989f, -0.11141682f, -0.01958674f, -0.06725856f, -0.05953202f, -0.08004531f, 
    0.02923319f, -0.03157710f, 0.00934817f, 0.35790837f, 0.01609096f, -0.19680279f, -0.10267733f, -0.04376926f, 
    -0.27653855f, 0.06297638f, -0.15609093f, -0.26357138f, 0.27008462f, 0.08540490f, -0.08701070f, -0.11579373f, 
    0.03723569f, -0.00887883f, 0.06429102f, 0.12369899f, 0.14094639f, -0.02010866f, 0.06854705f, 0.02802914f, 
    -0.00258968f, 0.00860052f, 0.24114230f, -0.21623880f, 0.06313791f, -0.01616671f, 0.28572559f, -0.24961069f, 
    0.20348224f, -0.11667971f, -0.07223975f, 0.13292140f, 0.14406113f, 0.10564438f, -0.32155469f, -0.21802346f, 
    -0.00780603f, 0.11605886f, -0.06845292f, -0.12769918f, 0.24138466f, 0.31004381f, -0.32919735f, 0.32379696f, 
    -0.15459085f, 0.17032437f, 0.13092682f, -0.08612850f, -0.24282296f, -0.24839060f, 0.23634700f, 0.20794149f, 
    0.00550911f, 0.03382268f, 0.19910902f, -0.25057131f, 0.07027946f, -0.01354939f, 0.04580774f, 0.36434397f, 
    -0.04284525f, 0.14032206f, 0.20467672f, -0.27953029f, -0.07985880f, 0.00782948f, 0.06627236f, -0.26872912f, 
    0.28775376f, 0.38134408f, 0.22571155f, 0.09088702f, -0.54471916f, 0.04444155f, 0.04552012f, 0.10020740f, 
    0.03196476f, -1.01826441f, -0.19764969f, -0.35120445f, 0.22561498f, 0.14390263f, 0.07602093f, -0.37698850f, 
    0.29012415f, -0.56072420f, 0.12889159f, -1.60006988f, -0.20172139f, -0.59360987f, -0.19215049f, -0.00533136f, 
    -0.63292605f, -0.32992336f, -0.26985458f, -0.12454025f, -0.32591459f, 0.16776943f, 0.12315549f, 0.02230743f, 
    -0.82356554f, -1.23258138f, -0.21018244f, -0.07509846f, 0.40505314f, 0.06014784f, 0.00728730f, -0.16892374f, 
    0.02437801f, -0.08982748f, 0.02343253f, -0.69923979f, 0.15641646f, -1.16046345f, -0.45577499f, 0.07861807f, 
    0.08983768f, 0.03417907f, -0.17400512f, 0.20325552f, 0.08415641f, -0.33778679f, -0.07196271f, -0.02329439f, 
    -0.08248804f, -0.49867201f, -0.28149500f, -0.42596179f, 0.09074336f, -0.23897333f, -0.01814370f, -0.04864587f, 
    0.09140231f, -0.07650984f, -0.27939603f, -0.26273346f, 0.23654906f, -0.15828288f, -0.02024649f, 0.24449417f, 
    0.10536253f, -0.10741817f, 0.19516172f, -0.29038748f, 0.26664948f, -0.11608183f, 0.01184897f, 0.05770883f, 
    0.02482978f, -0.20189497f, -0.58655500f, 0.24182422f, -0.06840353f, -0.14388119f, -0.19576953f, 0.15610678f, 
    -0.03810871f, -0.95019299f, -0.21013761f, -0.24580027f, 0.11115693f, 0.03620443f, 0.21401051f, 0.30688500f, 
    0.18380994f, -0.29999459f, -0.09767178f, 0.06364242f, 0.06687571f, 0.10439315f, 0.19928688f, -0.24535856f, 
    0.11419836f, 0.04595634f, 0.16035838f, 0.19933997f, -0.14039743f, 0.17266940f, -0.50696969f, -1.09815991f, 
    -0.00160980f, -0.05649189f, -0.06241922f, 0.10865632f, -0.11544853f, -0.30620345f, 0.01273294f, 0.05091259f, 
    -0.17963882f, -0.04829554f, 0.09796099f, 0.89378029f, 0.17036502f, 0.35305727f, -0.08738098f, -0.78752857f, 
    -0.06782193f, -0.55171299f, 0.24493022f, -0.18809517f, 0.00737648f, -0.53361154f, 0.12178350f, 0.06496388f, 
    0.08122201f, -0.34810564f, -0.09754656f, -0.57205415f, -0.40072376f, -0.73530018f, -0.21296966f, -0.06884359f, 
    0.42039874f, 0.17573887f, -0.09161511f, -0.88671297f, -0.18321048f, 0.41599602f, 0.27438146f, -0.06065605f, 
    0.08119845f, 0.20148374f, -0.11522540f, -0.14120360f, 0.32460892f, 0.03759558f, 0.08373141f, -0.04030782f, 
    0.11178471f, -0.33719182f, -0.13857771f, -0.07240522f, -0.22795215f, 0.00784512f, 0.00657187f, 0.02054834f, 
    -0.06329983f, -0.06040060f, -0.19614509f, 0.28231817f, 0.01243331f, -0.65752244f, 0.10764428f, 0.01446176f, 
    0.10811125f, 0.02813793f, -0.62571031f, 0.24438331f, -0.05654735f, -0.27171952f, 0.08748130f, 0.07276734f, 
    0.01943247f, 0.09930778f, 0.00954114f, -0.32939363f, 0.05683625f, -0.54583478f, 0.06486191f, 0.14304419f, 
    -0.05091250f, 0.03842460f, 0.08771683f, 0.00929384f, -0.26453397f, 0.16726704f, -0.12671392f, -0.11891109f, 
    -0.10126652f, -0.01825451f, 0.17485476f, -0.10963047f, -0.34681216f, -0.44382390f, -0.40022060f, -0.06683652f, 
    0.03613827f, 0.10807095f, 0.57071418f, -0.03848758f, 0.10805558f, 0.07783572f, -0.14002693f, 0.09934211f, 
    -0.70862192f, -0.27823341f, -0.23607151f, -0.01644104f, 0.00440986f, -0.01742858f, -0.17718090f, 0.00824397f, 
    0.04783548f, 0.06166783f, -0.51320302f, 0.01717014f, -0.26620239f, -0.17454861f, -0.11914120f, 0.43610325f, 
    0.10451499f, -0.15579338f, -0.05199860f, -0.37191552f, -0.18522760f, 0.06879748f, -0.03337320f, -0.67795110f, 
    -0.09383588f, 0.24782868f, -0.68193263f, 0.13405861f, 0.06503645f, 0.09223045f, 0.18360084f, -0.22467346f, 
    -0.21879539f, 0.08854457f, -0.14259394f, 0.14285947f, -0.25097775f, 0.38158524f, -0.34773469f, 0.26534373f, 
    0.07183108f, -0.17758921f, 0.02679594f, 0.37377053f, -0.18424670f, 0.00869101f, 0.01688274f, -0.50018126f, 
    0.01540891f, -0.07832415f, 0.01822217f, -0.97213596f, -0.26358026f, 0.18685116f, -0.03646111f, 0.11315820f, 
    -0.35130244f, 0.26205456f, -0.01902014f, -0.81995523f, -0.97111022f, 0.29656020f, 0.01547422f, 0.02932953f, 
    -0.73152399f, 0.24444093f, -0.04012487f, -0.22378716f, 0.20140141f, 0.11971843f, 0.21936159f, -0.20912492f, 
    -0.71049374f, 0.19319806f, 0.06524644f, -0.08009299f, -0.00188750f, -0.04687279f, -0.04141909f, 0.00024464f, 
    0.19553837f, -0.04436976f, 0.03681630f, -1.05822027f, -0.77143079f, -0.05943572f, 0.18228011f, -0.05695555f, 
    0.16682036f, -0.11933197f, -1.07037544f, 0.07218093f, -0.17341706f, 0.87975025f, -0.05817648f, -0.07019001f, 
    0.17268944f, 0.08445040f, 0.02556897f, -0.29755187f, -0.14054818f, -0.35851350f, 0.05905788f, 0.24513958f, 
    -0.32755899f, -0.07849729f, 0.16637848f, 0.10973421f, 0.06597164f, 0.15666777f, 0.28016844f, -0.14937332f, 
    0.02417430f, -0.07126942f, -0.18999156f, -0.34222072f, 0.25428808f, 0.31237215f, -0.04606116f, -0.09123078f, 
    0.03559164f, -0.03576351f, -0.07912762f, -0.16584426f, -0.15771927f, 0.59073228f, -0.23193285f, -0.69755799f, 
    -0.10808370f, -0.04928954f, -0.61288339f, -0.04048350f, -0.56677753f, -0.05459389f, -0.46265417f, -0.24819271f, 
    0.23821700f, 0.06463327f, -0.66685873f, -0.02339723f, 0.15146215f, 0.34543622f, 0.03115200f, -0.30236536f, 
    -0.32998776f, -0.10284771f, -0.13680220f, -0.02954183f, -0.22889905f, -0.56742865f, -0.91816580f, -0.10481004f, 
    -0.05926505f, 0.12806499f, -0.07020334f, 0.05102263f, -0.17703120f, -0.04164954f, 0.27460372f, 0.19891119f, 
    -1.10506380f, 0.23056908f, 0.16406174f, 0.03037995f, -0.19080028f, -0.25486413f, -0.07121479f, -0.42802447f, 
    0.08822455f, -0.03676338f, 0.01447931f, -0.68512994f, -0.26742250f, -0.12121431f, 0.23916340f, -0.57643968f, 
    -0.02266982f, 0.00071830f, 0.31570810f, -0.04772935f, -0.19404697f, -0.06130769f, -0.31721008f, -0.12658229f, 
    0.40855104f, -0.45792124f, -0.14491968f, 0.51536894f, -0.70192665f, -0.84912485f, -0.13509770f, -0.01586059f, 
    -0.10504442f, -0.21190734f, -0.15810053f, 0.17433672f, 0.02851718f, 0.12751761f, -0.18062192f, -0.02004371f, 
    0.21901636f, 0.16142626f, -0.05222530f, 0.02954641f, 0.09769139f, -0.00408019f, -0.06801950f, -0.42445233f, 
    0.02769700f, 0.02758752f, 0.46541205f, 0.30800840f, 0.09219664f, -0.53776842f, 0.08609015f, 0.24770889f, 
    0.02762390f, -0.46424317f, -0.31966928f, -0.25467208f, 0.18583061f, -0.01935156f, -0.45047072f, -0.04821463f, 
    -0.46594265f, -0.10822058f, 0.38692969f, -0.13299529f, 0.26413986f, -0.37918100f, -0.06945276f, -0.13121724f, 
    -0.11450767f, -0.01898493f, 0.02266487f, -0.31955132f, -0.39792791f, -0.55096650f, -0.04272020f, 0.07276344f, 
    -0.24080345f, -0.04983382f, -0.19667181f, 0.05214632f, -0.11535004f, 0.06691375f, 0.14079984f, 0.02847293f, 
    0.06389946f, -0.14909957f, -0.30303198f, 0.05186353f, 0.07243487f, -0.69864708f, -0.26519063f, 0.16211362f, 
    0.08611944f, 0.09616681f, 0.03355658f, -0.60965395f, -0.00207300f, 0.11439969f, 0.11419748f, 0.14258835f, 
    -0.01278753f, -0.25010160f, -0.66456085f, 0.06343938f, -0.00097165f, 0.08916727f, 0.18776348f, -1.09972548f, 
    0.12894671f, 0.00423745f, 0.04811255f, 0.26290601f, -0.00683485f, 0.26199901f, 0.16096447f, 0.03988741f, 
    0.05872682f, 0.10622291f, 0.46048614f, 0.41481650f, -0.19618385f, -0.62826991f, -0.08675392f, 0.29096523f, 
    -1.27108371f, -0.31357011f, -0.22649637f, -0.50254852f, 0.12573318f, -0.52022851f, 0.15245116f, -0.31507173f, 
    -0.38653079f, 0.02554929f, -0.50665575f, -0.22041653f, 0.19394657f, 0.20284149f, 0.00092877f, 0.12434360f, 
    -0.05335680f, 0.41172984f, -0.12279942f, 0.33551833f, -0.55277348f, 0.00193139f, -0.28681403f, -0.27429625f, 
    -0.65832543f, 0.21857780f, -0.06317722f, -0.28869227f, -0.52802151f, -0.01759205f, -0.40754038f, 0.00781563f, 
    0.12443463f, -0.05712943f, 0.25579157f, 0.30723041f, -0.44804716f, 0.06855575f, 0.06306010f, -0.57024807f, 
    -0.12205695f, 0.30962491f, -0.17092675f, 0.00342819f, -0.03173549f, -0.05121181f, -0.04771681f, 0.50877213f, 
    -0.89919800f, 0.06143637f, -0.15577309f, -0.06308382f, -0.24772163f, 0.11158782f, 0.18251602f, -0.58966452f, 
    -0.39376035f, -0.10019965f, -0.92632431f, -0.24612507f, -0.58851635f, -0.53391421f, -0.04493669f, 0.05866539f, 
    -0.42252901f, 0.21018644f, 0.02689664f, -0.00053150f, -0.04743789f, -0.59523803f, 0.00138716f, -0.52822286f, 
    0.27439702f, 0.03130923f, 0.01513750f, -1.02377665f, -0.19952695f, 0.19077824f, 0.13811657f, 0.15460370f, 
    0.21478763f, 0.01719372f, -0.60883063f, -0.41730472f, 0.07196326f, -0.01209668f, 0.25969622f, -0.05439265f, 
    -0.03117266f, 0.05881956f, -0.33870608f, -0.19915667f, -0.34716472f, -0.02382456f, -0.35465410f, 0.04784041f, 
    -0.41851488f, 0.31201184f, -0.77290398f, -0.05748372f, -0.30265039f, -0.24316759f, -0.45379594f, -0.60484201f, 
    0.22915554f, -0.78904897f, -0.47217414f, -0.05989491f, -0.12984224f, -0.02384450f, -0.29876754f, 0.06093252f, 
    0.15489754f, -0.33655706f, 0.10331372f, 0.12939169f, 0.35657918f, -0.10496739f, 0.08520054f, 0.31886673f, 
    -0.00460310f, -0.67503101f, -0.19464512f, 0.45076093f, 0.02362311f, 0.28434506f, -0.06813375f, 0.15568465f, 
    -0.16817518f, -0.10229854f, 0.23750107f, -0.15838242f, 0.08200807f, -0.43876526f, -0.23066138f, -0.44781214f, 
    -0.22882715f, -0.01816819f, -0.11687876f, -0.12797265f, -0.03688408f, 0.26260871f, -1.03117323f, 0.28516439f, 
    -0.06329774f, 0.12513600f, -0.66289151f, -0.91242683f, -0.43701202f, 0.12533256f, -0.86752880f, -0.22243527f, 
    -0.55308539f, 0.07138202f, 0.30202955f, -0.19954681f, -0.65696526f, -0.03745613f, -1.05200672f, 0.03492415f, 
    -0.55320853f, -0.57479858f, 0.18859649f, 0.32369271f, -0.91404700f, 0.17278717f, 0.10875756f, 0.18216659f, 
    0.36243257f, -0.08305826f, -0.10141622f, -0.02112980f, 0.15177631f, 0.01277614f, 0.00404062f, 0.02350579f, 
    0.23335314f, 0.08305997f, -0.09533575f, -0.35823414f, 0.28305158f, 0.37386945f, -0.35284460f, -0.37445790f, 
    0.05394715f, -0.52099389f, -0.49346247f, -0.21988609f, -0.01810030f, 0.17004877f, -0.22580184f, -0.01373890f, 
    -0.29398000f, 0.05386822f, -0.25665572f, -1.06108427f, 0.05617698f, -0.46102068f, 0.03747092f, -0.10071710f, 
    0.00574075f, -0.02124573f, 0.12408670f, 0.31380177f, 0.12253854f, 0.04322444f, 0.19582061f, 0.20435533f, 
    0.25840834f, -0.04370777f, 0.04534937f, -0.62024373f, -0.18381406f, -0.85753870f, -0.63522786f, 0.00963475f, 
    -0.08391528f, -0.07334286f, 0.23768586f, 0.10136947f, -0.06046655f, -0.12172922f, 0.13685046f, -0.26117674f, 
    0.00935890f, 0.01858720f, -0.04517747f, 0.01324540f, 0.24663962f, -0.08957311f, -0.02322364f, 0.20952410f, 
    -0.04001883f, -0.03753914f, -0.26176682f, -0.17900053f, 0.29621345f, -0.02543499f, 0.10395417f, -0.27355364f, 
    0.07983670f, -0.06451203f, -0.00954684f, 0.27584478f, 0.12075973f, -0.06085078f, -0.36177349f, -0.17277049f, 
    -0.03561479f, -0.53315634f, -0.05667060f, -0.35593894f, -0.42549005f, 0.24299356f, -0.04617146f, -0.30286264f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17793395f, 0.10333131f, -0.01640693f, -0.12731726f, -0.12999788f, 0.03014497f, -0.01346225f, -0.12889315f, 
    -0.01382732f, 0.22201332f, 0.17205930f, 0.01341619f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
