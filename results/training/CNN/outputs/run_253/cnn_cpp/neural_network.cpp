#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.38182855f, -0.47718179f, -0.78001362f, 0.44950444f, 0.92307687f, 0.39609513f, -0.13343871f, -0.58884239f, 
    -0.74520969f, -0.30217290f, 0.82989997f, 0.69459009f, 0.81195581f, 0.03073513f, -1.50695038f, -0.35984704f, 
    0.25067830f, 0.06124401f, -1.29353273f, 1.15781355f, -0.07208897f, -0.48359931f, -0.57229614f, -0.92428720f, 
    0.27986717f, -0.25730368f, 0.24223261f, -0.10164734f, 1.35298741f, -1.10951269f, 1.12359107f, -0.59174037f, 
    -0.14948328f, -0.07762912f, 0.05781724f, -0.06493173f, -0.22611149f, 0.28788778f, 0.00348252f, -0.81407177f, 
    -0.94792527f, -1.03717124f, -0.98650146f, 0.23441106f, -0.14003456f, 0.87714493f, 0.35781923f, -0.94036359f, 
    -1.23633862f, 0.16422965f, -0.76273119f, 0.50981629f, 0.54700428f, 0.50385135f, 1.42506957f, 0.26518336f, 
    0.76077265f, 1.03259242f, 0.69096977f, -0.30534017f, -0.00117563f, -0.05381205f, -0.44841656f, 0.37668061f, 
    1.18790936f, 1.08209622f, -0.22029929f, 0.83977598f, -0.59985119f, -0.16311322f, 0.20743865f, 0.44998732f, 
    -0.87798196f, -0.85442954f, -0.64381552f, -0.72677475f, -1.10804379f, 0.75472605f, 0.25711524f, 0.09127315f, 
    -0.24341437f, -0.63056338f, -1.21372283f, 0.04301927f, -1.37969017f, 0.11194093f, 0.47312459f, 0.41498545f, 
    0.11110241f, 0.58796173f, -1.08442569f, -0.69764048f, -1.15282953f, -0.23798610f, 0.66861784f, 0.95497710f, 
    0.77684915f, -0.07702918f, 0.34645438f, 1.63428962f, -0.80858070f, -1.01422024f, -0.26662073f, -0.26861012f, 
    -0.28014380f, 0.16977234f, 0.17618722f, -0.15616284f, -0.81336522f, -1.06554174f, -0.74621451f, 0.49134490f, 
    0.38458145f, -0.34202805f, 0.45176089f, 0.36179778f, 0.33045959f, 1.14690554f, 0.67872125f, 0.61164671f, 
    0.39135242f, 0.15627439f, 0.33160105f, -0.58276987f, 0.36383519f, 0.32462066f, -0.40723255f, 0.92936581f, 
    -0.39731997f, -0.84959531f, -0.86882120f, -0.64287817f, 0.28220764f, 0.51310331f, -0.38465914f, -0.88981277f, 
    0.26409483f, -0.79585862f, -1.08898711f, 0.55015051f, 1.20993555f, -0.11066342f, 0.29997388f, 0.44839305f, 
    -0.25988549f, 0.46112430f, 0.21620481f, 0.95636493f, -1.06703460f, 0.64674991f, 0.61547834f, 0.06392478f, 
    0.35639355f, 1.20614946f, 1.17256916f, 0.55699688f, -0.58853984f, -1.12250829f, 0.30234489f, -0.36109024f, 
    0.30424282f, -0.05341886f, 0.98862416f, -0.41173920f, -0.78185052f, -0.77486384f, -0.89120734f, -0.76650858f, 
    -0.02756321f, -0.22035024f, 0.71189308f, 0.71878397f, -1.45497537f, 0.95941532f, 0.94461286f, -0.02951504f, 
    0.78636456f, -0.27071714f, -0.60120851f, -0.09456158f, -0.21156810f, -0.76887411f, -1.14921558f, -0.54082930f, 
    0.00323144f, 0.42726794f, -0.83847606f, 0.08990996f, -0.86898625f, 0.88566208f, 1.28540897f, 0.36467841f, 
    -0.57488590f, -0.84507668f, -0.82346344f, 0.20422865f, -0.72308373f, -0.64643049f, 0.34231627f, 0.30190909f, 
    0.03176665f, 0.86616880f, 1.21329010f, 0.36499196f, -0.58694702f, 0.33631805f, 0.08279685f, -0.87289321f, 
    -1.06704640f, -0.03013855f, -0.03315773f, 0.30741113f, -1.09761930f, 0.50429702f, 0.04201308f, -0.47517294f, 
    0.97819382f, -0.09020121f, -0.96584034f, 0.09795196f, 0.89246881f, 0.77760530f, 0.09501448f, -0.05069217f, 
    0.63956028f, -0.83868414f, 0.43725637f, 0.86770183f, 1.09078777f, -0.83415771f, -0.69443178f, -0.52699518f, 
    -0.55454314f, -0.46639210f, -0.22525197f, 0.87222564f, 0.81576538f, 0.04591112f, 0.81978130f, 0.47733817f, 
    -0.29609033f, 0.48056018f, -0.13110858f, -1.10815299f, -0.97596079f, -1.12633073f, 0.05754612f, -0.40042135f, 
    -0.00991896f, -0.30541277f, -0.04504018f, 0.16357656f, 1.00669134f, 0.86067790f, 0.89357269f, 0.41629291f, 
    -0.13690884f, 0.44937834f, 1.02871490f, -0.14856380f, 0.46471366f, -0.14114529f, -1.31785679f, -0.56562477f, 
    1.01916695f, 0.78334540f, 0.16084130f, -0.42518425f, -0.17897581f, 0.03553181f, -1.08190405f, -0.09276564f, 
    0.65370131f, 0.93400604f, 0.96179569f, 0.01434488f, -0.18164937f, 0.63734353f, -0.36098829f, 0.76015592f, 
    0.86616904f, 1.01836658f, -1.28605902f, 0.68851298f, -0.47394952f, 0.07683973f, -0.17860965f, 0.63321400f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06017278f, 0.10393475f, 0.29369298f, -0.26672903f, -0.06984406f, 0.16126291f, -0.03430049f, -0.08356882f, 
    0.21814767f, 0.19354798f, 0.02430478f, 0.00360460f, 0.37891254f, 0.73161268f, 0.14410019f, 0.15291403f, 
    -0.09811777f, -0.02676348f, 0.40489343f, 0.42054632f, -0.27274475f, 0.06203383f, 0.00014057f, -0.36178738f, 
    -0.07662155f, -0.13862863f, 0.58073992f, 0.24561875f, -0.12834333f, -0.18447006f, -0.18285215f, 0.40597501f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.10266025f, -0.37190878f, -0.43330541f, 0.16758475f, 0.15576047f, -0.04080363f, -0.10209814f, -0.02289588f, 
    0.09959427f, -0.07593086f, 0.17631873f, 0.19103695f, 0.11830768f, 0.10060292f, 0.08077230f, 0.09046900f, 
    0.04980561f, 0.15956788f, -0.08522265f, 0.03946083f, 0.15551199f, -0.12206914f, 0.21465726f, 0.00985004f, 
    0.15245293f, 0.13686810f, -0.03257623f, -0.13294767f, -0.29942989f, -0.37740493f, 0.03678919f, -0.00923047f, 
    0.03081519f, 0.03808502f, -0.25869206f, -0.17773920f, 0.20175225f, 0.18171038f, 0.26162863f, -0.02789763f, 
    0.00241839f, 0.01197112f, -0.03112561f, 0.08872947f, 0.02815815f, -0.07891704f, -0.22588222f, -0.25635007f, 
    -0.02695457f, 0.03728154f, 0.11248504f, 0.08157337f, 0.03159213f, -0.13282032f, -0.28628936f, 0.09353974f, 
    0.28884363f, -0.04131720f, 0.19275983f, -0.13610335f, -0.07223308f, -0.16841137f, -0.04748009f, -0.52935731f, 
    0.39191240f, 0.21755974f, -0.15558931f, 0.16450299f, 0.18453635f, 0.11491335f, -0.13239753f, 0.01873848f, 
    0.00426434f, -0.17732622f, -0.27394944f, 0.10074674f, -0.06132125f, 0.10709829f, 0.07731071f, -0.09719905f, 
    0.06347117f, -0.30343577f, -0.03883270f, 0.12959382f, 0.11722904f, 0.01484966f, 0.10907593f, 0.12743425f, 
    0.17485620f, 0.12443310f, 0.08714107f, 0.01781492f, -0.15781936f, 0.09298892f, 0.09685834f, 0.02149793f, 
    0.13945502f, -0.07799044f, 0.14853399f, -0.25313249f, -0.30976427f, -0.55590463f, -0.26777333f, 0.03757668f, 
    -0.06328458f, -0.08618459f, -0.05897425f, 0.02603721f, 0.05300090f, 0.26433036f, -0.25689712f, -0.11533151f, 
    0.05592553f, 0.00936490f, 0.00549243f, 0.02879117f, -0.06860972f, 0.24470966f, 0.11273614f, 0.18333057f, 
    0.20611157f, 0.15015942f, 0.05294230f, 0.00864140f, 0.18328533f, 0.18566941f, 0.23883080f, -0.07595563f, 
    -0.05698508f, -0.13860787f, -0.04918196f, 0.14961822f, -0.17350069f, -0.07515129f, -0.00945515f, -0.25891325f, 
    0.05972716f, -0.10604911f, -0.09225404f, 0.21470493f, 0.00592998f, -0.06704712f, -0.23781283f, 0.03800560f, 
    0.12055334f, -0.09975704f, 0.01825635f, 0.10754536f, -0.00968907f, -0.04034152f, -0.07049056f, -0.01078785f, 
    -0.05335513f, -0.25551388f, -0.23172589f, 0.33250132f, -0.13499969f, -0.03237521f, -0.17339742f, -0.05020834f, 
    -0.08498897f, -0.03439643f, 0.14285707f, -0.29300869f, -0.19908230f, -0.06490261f, 0.02412840f, 0.02060732f, 
    0.19748038f, -0.00973964f, 0.07575940f, -0.77715337f, -0.02324817f, -0.22178003f, 0.35170531f, 0.26177675f, 
    -0.09644800f, 0.12578994f, 0.01558988f, 0.04979435f, -0.25527173f, -0.34313297f, 0.06221894f, 0.17137504f, 
    -0.01429086f, 0.10015314f, -0.27543092f, -0.07192922f, 0.05359435f, -0.22856630f, -0.05221884f, 0.27246165f, 
    -0.06111759f, 0.01939641f, -0.09469426f, -0.04630017f, -0.05828745f, 0.14471154f, -0.34696633f, 0.26194218f, 
    0.33261245f, 0.19272691f, 0.06054521f, -0.23558454f, 0.11541653f, 0.00794925f, -0.13136978f, -0.11483411f, 
    0.15395650f, 0.06841326f, -0.25224394f, -0.10933732f, -0.12103693f, 0.11230247f, -0.04018216f, -0.07545988f, 
    0.41830590f, -0.17254068f, -0.33866522f, 0.08467957f, -0.12555304f, 0.04552675f, 0.16611043f, -0.01903204f, 
    -0.02404251f, 0.50601304f, 0.14321105f, 0.18175997f, -0.07692262f, -0.08537540f, -0.18924145f, 0.24329740f, 
    -0.07694554f, 0.27906212f, 0.15784419f, 0.26800656f, 0.08672486f, 0.07266036f, 0.29907957f, 0.10359021f, 
    0.03810237f, 0.17544968f, 0.09342392f, -0.02735311f, 0.00320148f, 0.07133348f, 0.03708909f, 0.07885309f, 
    -0.07495376f, 0.13431714f, -0.04479733f, -0.00619891f, -0.09176894f, -0.14420722f, 0.24963905f, 0.20100439f, 
    0.16982393f, -0.15385836f, 0.08321869f, -0.03876214f, -0.06972060f, -0.28790995f, -0.33889207f, -0.19134301f, 
    0.02951214f, -0.03900580f, -0.22133802f, 0.13934860f, -0.04932893f, -0.13281785f, -0.08045866f, -0.03803011f, 
    -0.13158715f, -0.10018203f, 0.00432980f, 0.02196513f, 0.03304633f, 0.05073110f, -0.23742498f, -0.20873018f, 
    0.32317370f, 0.28073061f, -0.15582331f, 0.04386663f, 0.06339105f, 0.16202356f, -0.12169308f, 0.09465867f, 
    -0.04740798f, 0.03888949f, 0.02197170f, -0.03202452f, -0.06943208f, -0.02560192f, -0.05463994f, -0.00525404f, 
    0.02699687f, -0.03054946f, 0.01975031f, -0.01144952f, -0.01007090f, -0.03591005f, -0.05134374f, -0.06346858f, 
    -0.03143614f, 0.04373038f, -0.01521030f, -0.02609854f, 0.00820222f, 0.04491063f, 0.03610829f, -0.04146577f, 
    0.00532771f, 0.00474356f, 0.01897893f, -0.05919715f, 0.00241485f, -0.00939917f, 0.04562907f, 0.01534141f, 
    -0.00524200f, 0.04710527f, -0.02207039f, -0.01130992f, 0.00809184f, -0.02772950f, -0.03580274f, 0.04577660f, 
    0.00211431f, 0.03071826f, -0.05776954f, -0.00269056f, -0.06112266f, -0.00454162f, -0.06172870f, -0.03268658f, 
    0.04532334f, -0.00779019f, 0.00009644f, 0.03441714f, 0.03095412f, 0.02467153f, 0.01248855f, -0.05205771f, 
    -0.00202641f, 0.00424035f, -0.00112095f, -0.03900270f, 0.01154818f, -0.05497145f, -0.02448605f, -0.05481066f, 
    0.00765805f, 0.01568911f, 0.02342544f, -0.05633950f, 0.00580901f, 0.03207427f, 0.03934095f, -0.03743162f, 
    -0.02616959f, -0.01785209f, -0.03679981f, 0.01600852f, -0.06569234f, 0.01192910f, -0.01150113f, 0.02656030f, 
    0.02073859f, 0.00230760f, 0.05345780f, 0.02572114f, -0.03373941f, -0.01537132f, -0.03920262f, -0.00565951f, 
    0.01880480f, -0.05269484f, 0.01369014f, -0.01355052f, -0.00699411f, -0.00238920f, -0.00009786f, -0.00804582f, 
    0.04492823f, 0.04756302f, -0.02839199f, -0.04198122f, -0.04906598f, 0.02021308f, -0.06764125f, -0.02045208f, 
    -0.03267664f, 0.03474731f, -0.03654370f, 0.02814939f, 0.05222874f, -0.01714995f, -0.03785547f, 0.02355579f, 
    -0.02576075f, -0.00879405f, -0.05859395f, 0.03359451f, 0.01066799f, -0.02295288f, -0.02591524f, 0.00003331f, 
    -0.00442481f, 0.04589240f, -0.01480104f, -0.00571975f, -0.01489414f, -0.00563539f, -0.01834038f, 0.02815679f, 
    0.04136011f, -0.00412619f, 0.03449017f, -0.06041154f, 0.02754776f, -0.01866896f, 0.03683803f, 0.04766399f, 
    -0.01047331f, -0.00421020f, 0.03025790f, 0.01246524f, 0.01441175f, -0.05376040f, -0.02654882f, 0.01623006f, 
    -0.02161544f, -0.03726863f, 0.03227428f, 0.03859290f, 0.01902607f, 0.04302890f, 0.03507410f, -0.02176007f, 
    -0.03250019f, -0.06342699f, 0.02242132f, -0.01408358f, -0.02794404f, -0.06529629f, -0.02662719f, -0.01216026f, 
    -0.01019585f, -0.03786577f, -0.03503748f, -0.04809746f, -0.04883650f, -0.00956070f, 0.01653953f, -0.06702553f, 
    -0.02422521f, -0.00243456f, 0.01861099f, 0.02818666f, -0.06273929f, -0.04604865f, 0.02166089f, 0.00818723f, 
    0.02146906f, -0.01869173f, -0.02245149f, 0.02086890f, 0.04841641f, 0.04028612f, -0.01553873f, -0.06165107f, 
    0.02866610f, 0.03710604f, -0.03781872f, 0.03798190f, 0.00966650f, 0.02204448f, -0.04196880f, 0.04494524f, 
    0.04199974f, -0.03339217f, 0.01477503f, 0.01326007f, -0.04430531f, -0.01073180f, -0.02161267f, 0.00455022f, 
    -0.03081297f, 0.00774542f, 0.03979268f, -0.03179561f, 0.02156817f, 0.04021078f, -0.01550922f, -0.00174777f, 
    -0.01886986f, -0.02153110f, 0.02820771f, 0.00853341f, -0.06775051f, 0.00489281f, 0.02387824f, -0.00129389f, 
    0.00257970f, 0.00106459f, -0.06649644f, -0.01318144f, -0.04516271f, 0.03757073f, 0.00985331f, -0.00420502f, 
    -0.02125400f, -0.04421192f, 0.01294609f, -0.01664908f, -0.02624973f, -0.01338584f, 0.02776342f, 0.04308243f, 
    -0.03163135f, 0.03793319f, -0.01191473f, 0.03534006f, 0.02390609f, -0.02859277f, 0.03955671f, 0.01420100f, 
    0.02492764f, 0.01695540f, 0.00640877f, -0.01007011f, 0.02904598f, 0.01521673f, 0.01988100f, -0.06800927f, 
    -0.03596193f, -0.02056113f, 0.00438613f, -0.04847452f, 0.00358265f, -0.03793230f, -0.05294894f, 0.01986802f, 
    0.03165149f, 0.02504256f, 0.02748564f, -0.05771906f, 0.00251765f, 0.05008732f, -0.04465060f, -0.05989759f, 
    -0.04691029f, -0.05823381f, -0.02776105f, 0.04898846f, -0.03224203f, -0.03681068f, -0.04439518f, -0.05414394f, 
    -0.02106752f, 0.02067099f, 0.03729017f, 0.01870409f, 0.03345550f, 0.05002278f, -0.03163668f, 0.04084877f, 
    -0.04329146f, -0.04017733f, -0.01836720f, 0.02923719f, -0.05182284f, -0.02136576f, -0.06842861f, -0.04350996f, 
    -0.05572988f, 0.04184205f, -0.04855066f, -0.02484235f, -0.01603177f, -0.00436438f, -0.00136908f, -0.02236776f, 
    -0.02094358f, -0.00211434f, 0.01338770f, 0.02839268f, -0.00373073f, 0.00765764f, -0.02927274f, 0.00120439f, 
    -0.05416960f, 0.04460308f, -0.00050093f, 0.03270062f, -0.02035313f, 0.03338798f, -0.01403376f, -0.01891616f, 
    -0.03318429f, 0.02383337f, 0.02610926f, 0.01602776f, 0.00614446f, -0.02849869f, 0.04547250f, -0.03373491f, 
    0.00107400f, 0.03887227f, -0.04904309f, -0.04747902f, 0.00637227f, -0.01990912f, -0.01238163f, -0.04859903f, 
    -0.05244733f, -0.01082997f, 0.01788319f, -0.04764888f, -0.04186595f, 0.02569041f, -0.05509761f, -0.02953272f, 
    0.00788667f, -0.04117401f, 0.02356794f, 0.05448939f, -0.02482834f, -0.02019115f, -0.02191073f, -0.01472237f, 
    -0.00521055f, -0.02290940f, 0.04578869f, -0.05434519f, 0.01640015f, -0.00591003f, 0.03590163f, 0.00128603f, 
    -0.01552566f, -0.00086946f, 0.04749622f, -0.04100769f, -0.05045788f, -0.04816956f, 0.00903794f, 0.01376746f, 
    0.04477991f, -0.00620434f, -0.03437670f, -0.01611303f, 0.03210653f, -0.03016658f, 0.01133856f, 0.04113010f, 
    -0.04846969f, 0.00753454f, 0.01635438f, 0.03936820f, 0.04963513f, -0.01502619f, 0.02036090f, 0.04973465f, 
    -0.03059543f, 0.03016062f, 0.03517020f, 0.03115649f, -0.02013116f, 0.04935738f, -0.02063175f, -0.00615838f, 
    0.02397873f, -0.01027122f, -0.02004726f, -0.04155111f, 0.01221128f, 0.05810769f, 0.00054742f, 0.01206742f, 
    -0.04024054f, -0.01973523f, 0.00192350f, -0.04327202f, 0.00380918f, -0.05621790f, 0.02545892f, -0.05441349f, 
    -0.00725543f, 0.03912706f, -0.05589625f, -0.01803805f, -0.03708353f, -0.00539122f, 0.01550767f, -0.00504000f, 
    -0.03447846f, 0.04154162f, -0.03329987f, -0.03422137f, 0.02312811f, 0.01446323f, 0.01023582f, -0.02096886f, 
    0.00160818f, 0.00908122f, 0.00846932f, -0.01743104f, -0.02489240f, 0.05825327f, 0.00985945f, 0.01160545f, 
    -0.02465006f, -0.05072996f, -0.02410737f, 0.03911222f, -0.03725665f, -0.00008058f, 0.05275487f, -0.04607045f, 
    -0.04840514f, -0.05398456f, 0.00180063f, 0.02701070f, 0.00636802f, -0.03746344f, 0.04348047f, 0.00536565f, 
    -0.02510251f, -0.05060767f, -0.01693979f, 0.04281162f, -0.04700058f, 0.04634820f, 0.01791981f, -0.01398421f, 
    -0.00528476f, -0.05492998f, -0.04312465f, 0.04603793f, -0.05599079f, 0.02054801f, -0.02647711f, -0.03375688f, 
    0.00532908f, -0.01137302f, -0.03618299f, -0.04333200f, -0.02089455f, -0.01865684f, -0.03100928f, -0.01806541f, 
    -0.02697244f, -0.02214846f, 0.01341435f, 0.01481727f, 0.00878179f, -0.03883218f, -0.02932623f, -0.05521051f, 
    0.03694000f, -0.02360405f, -0.04802549f, 0.01505893f, -0.02388090f, 0.04581025f, -0.05454583f, -0.00345920f, 
    0.03802467f, 0.05886015f, 0.04915757f, -0.01046541f, 0.01828724f, -0.02610383f, 0.02891532f, -0.04463537f, 
    0.03757235f, -0.01375102f, -0.05611360f, -0.02475709f, 0.02394087f, 0.04374897f, -0.05452840f, -0.00325496f, 
    -0.03635472f, 0.02068590f, 0.01608061f, 0.00805692f, -0.00894103f, -0.03995474f, 0.04250212f, 0.00029694f, 
    -0.03646547f, 0.00054013f, -0.03500557f, -0.01700211f, 0.00946332f, 0.00176603f, -0.01239718f, -0.02897422f, 
    0.04730321f, 0.02234698f, 0.00601892f, 0.02318517f, 0.01823815f, 0.00929122f, 0.01374327f, 0.05660440f, 
    0.00322024f, -0.05358580f, -0.00572134f, -0.03689435f, 0.02265976f, -0.00414982f, -0.03306666f, 0.02967359f, 
    -0.02169660f, 0.04698185f, -0.05303361f, -0.02043956f, -0.01950919f, -0.03378817f, -0.00850972f, -0.05657550f, 
    0.01675376f, 0.03419753f, -0.05313690f, 0.05587597f, 0.02457168f, 0.01737271f, 0.00373835f, -0.03939785f, 
    0.05448008f, -0.01245824f, -0.05818507f, -0.01030998f, -0.04973303f, -0.04136136f, 0.01209206f, -0.04273188f, 
    0.00048590f, 0.02655996f, -0.04954166f, 0.02694220f, -0.00391168f, -0.05294010f, -0.04289209f, 0.01077443f, 
    -0.05434388f, -0.01234340f, -0.01589026f, 0.03725314f, 0.00997397f, -0.04899142f, 0.03354885f, -0.01260255f, 
    -0.00791356f, -0.03980576f, 0.01548659f, -0.00281831f, 0.04778954f, 0.05408023f, -0.02416030f, 0.02883151f, 
    0.27359259f, 0.03997529f, -0.18760018f, 0.17808081f, 0.12351535f, 0.36077508f, 0.28400531f, -0.23386458f, 
    -0.01910521f, 0.11255811f, 0.15404174f, -0.13357218f, 0.02076149f, 0.08975532f, 0.01133450f, 0.00682926f, 
    0.08227871f, 0.17593317f, 0.15696406f, 0.14026172f, 0.07030223f, -0.08048858f, 0.04679987f, -0.22357346f, 
    0.07265124f, 0.19424856f, 0.19030137f, 0.03581189f, -0.25058907f, 0.27663133f, -0.27084762f, -0.07528459f, 
    -0.17100380f, 0.18175898f, -0.04959674f, 0.20318399f, 0.16359845f, 0.00424414f, 0.35967246f, -0.00778755f, 
    0.27212834f, -0.16804370f, -0.14203216f, 0.21945138f, 0.15944663f, 0.08714133f, 0.14513232f, 0.10876811f, 
    -0.01748665f, -0.11773130f, -0.05049203f, -0.19649942f, 0.19249292f, -0.01193833f, -0.24663164f, 0.28332302f, 
    0.18382333f, -0.13619033f, 0.10903495f, 0.00037589f, 0.05587376f, 0.08355068f, 0.02225882f, -0.24759805f, 
    0.19717087f, 0.12507793f, 0.30637547f, 0.10895599f, -0.05293602f, -0.14425041f, -0.04806998f, -0.04317542f, 
    -0.46363717f, -0.18527469f, -0.42453465f, 0.30298182f, 0.22519895f, -0.09161668f, 0.10163079f, -0.07458933f, 
    -0.08107173f, -0.29462457f, -0.06563449f, -0.22414085f, 0.26434347f, -0.00861198f, 0.20569402f, 0.10024241f, 
    0.09463595f, -0.01000391f, -0.67799604f, 0.03317145f, -0.18146382f, 0.10121636f, 0.06435888f, 0.24665791f, 
    -0.05412379f, -0.03731301f, -0.02057088f, -0.09559904f, -0.11583375f, -0.38452122f, -0.18333904f, -0.22400434f, 
    -0.12672424f, -0.03700570f, 0.14248395f, 0.09015300f, -0.53112274f, 0.09601661f, 0.02306498f, 0.07876971f, 
    0.07755181f, 0.02231646f, 0.17051464f, -0.01729801f, 0.07184207f, -0.01407136f, 0.27506858f, 0.13755855f, 
    0.19937839f, 0.13643689f, 0.08954457f, 0.03193263f, -0.24410881f, 0.02063495f, -0.16794769f, 0.09058659f, 
    0.07373004f, -0.12868004f, -0.12925760f, -0.18620424f, -0.22091246f, 0.01219974f, 0.25616252f, -0.69595796f, 
    -0.11794852f, 0.02373628f, 0.05171137f, -0.02027149f, 0.18652739f, 0.07436676f, 0.03896464f, 0.04953620f, 
    -0.31523800f, -0.43576691f, -0.21217126f, -0.22469538f, -0.05702713f, 0.00565787f, -0.01786260f, 0.03851162f, 
    -0.18728088f, -0.01649100f, 0.27687797f, 0.09499908f, -0.13188805f, 0.03072694f, -0.13250923f, -0.02333966f, 
    0.11323370f, -0.03816574f, 0.14939041f, -0.28825712f, -0.03395092f, -0.12652475f, 0.08007639f, 0.10538211f, 
    0.04110249f, -0.00580158f, 0.13917243f, 0.22314273f, 0.06388969f, -0.09948938f, -0.02310343f, 0.05140088f, 
    0.03006785f, -0.08079825f, -0.10131714f, 0.15639099f, 0.09959804f, -0.14903401f, 0.03711528f, 0.01937431f, 
    -0.07804739f, -0.02597939f, 0.05055366f, -0.13370849f, 0.02200645f, -0.13993794f, 0.25447151f, 0.28529546f, 
    -0.09663036f, 0.10114066f, -0.12918939f, 0.12381033f, -0.03782591f, 0.08002803f, -0.16380274f, -0.08345252f, 
    0.15281554f, 0.13118169f, 0.03700039f, 0.19653811f, -0.02271502f, -0.12204947f, -0.08010330f, -0.33588073f, 
    0.21734677f, -0.33916953f, 0.30494329f, 0.08708060f, 0.14277346f, 0.03746427f, 0.14551757f, -0.02511955f, 
    -0.03402055f, 0.03821215f, 0.00394057f, 0.11679326f, 0.23105589f, -0.11844567f, -0.08709893f, -0.33468887f, 
    -0.08802510f, 0.34567404f, 0.03758390f, 0.04509830f, -0.09478404f, -0.00952143f, 0.02502114f, 0.24107575f, 
    -0.12574115f, -0.00033634f, -0.04642200f, 0.03274475f, 0.18028072f, 0.04564511f, 0.17728870f, 0.11341865f, 
    -0.05449687f, -0.09750658f, -0.04953046f, -0.48504981f, 0.04534403f, 0.04786967f, 0.14676657f, 0.17232506f, 
    -0.08724178f, 0.07162219f, 0.12594856f, -0.02502012f, -0.18110007f, 0.21923518f, 0.09624431f, -0.06676674f, 
    0.08222973f, -0.03206242f, 0.23022330f, -0.10425277f, -0.05106398f, -0.40471604f, 0.12448273f, -0.36621383f, 
    0.10336483f, -0.03706171f, 0.12503926f, -0.03924610f, 0.04047161f, -0.18817861f, 0.03144620f, -0.36843929f, 
    0.05123304f, 0.00160017f, -0.03617460f, 0.27923131f, -0.13887335f, -0.15308841f, -0.04885638f, 0.00504272f, 
    0.31474560f, 0.14948872f, -0.15873316f, 0.03266722f, 0.11054350f, 0.05464445f, -0.05777441f, -0.06819205f, 
    0.00682220f, -0.03013315f, -0.05771405f, 0.03455250f, 0.03905958f, -0.03414892f, 0.04077321f, -0.01740265f, 
    -0.04650640f, 0.02536947f, -0.05924875f, -0.03573463f, -0.04600691f, -0.03933867f, 0.01855767f, -0.03678457f, 
    0.03045174f, 0.01834263f, -0.03805318f, -0.05977563f, -0.05052990f, -0.03894507f, 0.01533594f, 0.04116026f, 
    0.01662111f, -0.01301622f, 0.02403503f, 0.03911551f, 0.04060639f, -0.05906477f, 0.02409575f, -0.05571298f, 
    -0.00671657f, -0.05460928f, -0.06136376f, -0.01096002f, -0.02122370f, 0.04833394f, 0.02314330f, -0.05834865f, 
    -0.03717146f, -0.00613543f, 0.01814500f, -0.03137141f, 0.02976138f, -0.00775992f, -0.01208686f, 0.03019974f, 
    -0.05272973f, 0.03894972f, -0.01573777f, -0.04583395f, 0.02331485f, -0.02561863f, -0.01787372f, 0.04443759f, 
    0.05136099f, -0.05436752f, -0.03070089f, -0.01365279f, 0.01620886f, -0.02670511f, -0.04094280f, -0.00304185f, 
    -0.01728423f, -0.01738176f, -0.04866665f, -0.03636542f, 0.02655245f, -0.03877162f, 0.01411653f, -0.01284952f, 
    -0.03372451f, 0.00428948f, 0.03565273f, 0.02170823f, 0.02894323f, 0.03236727f, -0.06208294f, -0.00077128f, 
    -0.03848861f, -0.02949994f, 0.04340471f, 0.01888900f, -0.02385667f, -0.02266346f, -0.02195283f, -0.04733806f, 
    -0.04074058f, -0.00142500f, -0.05519446f, -0.06068787f, -0.05240566f, -0.01504986f, 0.02447091f, 0.02325170f, 
    0.00371379f, -0.02672638f, -0.05070937f, 0.03608806f, 0.02086195f, 0.01612790f, 0.00795402f, -0.02838774f, 
    0.02146409f, 0.02376320f, -0.05928322f, -0.05734938f, 0.02607439f, -0.02455361f, -0.05813643f, 0.03500609f, 
    -0.06262252f, 0.00152882f, 0.00555072f, 0.03530063f, -0.02900055f, -0.00583992f, -0.00126928f, 0.01395634f, 
    0.00199373f, -0.03719125f, 0.00275403f, -0.00192707f, -0.01930909f, -0.03290611f, 0.00299844f, -0.06598874f, 
    0.00274204f, 0.04381944f, -0.05144986f, 0.01583259f, -0.03656293f, -0.00019707f, -0.01477241f, -0.02961201f, 
    -0.06416775f, 0.05094195f, 0.02223496f, 0.03463990f, 0.04163783f, -0.03241115f, 0.02409884f, 0.00935377f, 
    0.01212376f, -0.05503881f, 0.03252961f, -0.03074358f, 0.00831556f, -0.00730875f, -0.04321943f, -0.00924316f, 
    0.03477032f, 0.02434989f, 0.01149223f, -0.01671992f, -0.06474084f, 0.01374388f, -0.01963674f, 0.04322631f, 
    0.04535554f, -0.04106335f, 0.02113394f, -0.06523245f, -0.02997394f, -0.01995582f, 0.03932582f, 0.01986651f, 
    -0.00435418f, 0.01568731f, -0.00445959f, 0.04219669f, -0.03786292f, 0.05025196f, 0.03536749f, -0.04051327f, 
    -0.05625046f, 0.02229342f, -0.04794072f, 0.04072558f, -0.01119388f, -0.01245180f, 0.04355903f, -0.03215823f, 
    0.04010178f, -0.03269392f, -0.05349229f, -0.02360171f, 0.02227681f, 0.04820788f, 0.00565655f, 0.04314799f, 
    -0.01846701f, -0.03762697f, 0.01403531f, -0.00537465f, -0.04319218f, 0.03078210f, 0.00743519f, 0.03528438f, 
    0.00889940f, -0.02089210f, 0.01977863f, 0.05189819f, -0.01805462f, -0.05343915f, 0.00151693f, 0.01693823f, 
    -0.02979895f, 0.01510826f, -0.06615441f, 0.02237181f, -0.02573280f, -0.06262762f, -0.04985659f, -0.04034560f, 
    0.02375449f, -0.05772422f, -0.01172575f, 0.01870392f, 0.01641825f, 0.04548138f, 0.03718195f, 0.00724728f, 
    -0.02133964f, 0.00712112f, -0.01231511f, -0.04392310f, -0.01454000f, 0.00206928f, -0.05621422f, -0.04135845f, 
    -0.00360572f, -0.01662083f, 0.01706763f, 0.01668810f, -0.00265575f, -0.03580192f, 0.03610035f, 0.02317224f, 
    -0.06496734f, -0.02087706f, -0.05971299f, -0.05413233f, 0.03398926f, -0.03446329f, -0.04595095f, -0.01290563f, 
    -0.04037583f, 0.02864264f, 0.01758309f, -0.02100980f, -0.01248040f, 0.01272845f, -0.03336194f, -0.03557127f, 
    0.01477397f, 0.04465041f, -0.04334372f, 0.03043550f, 0.01944548f, -0.05577547f, -0.05810648f, -0.04754308f, 
    -0.04199695f, 0.02832075f, -0.03768325f, 0.00832722f, -0.04143994f, -0.03568464f, 0.00580170f, -0.05096602f, 
    0.04575287f, -0.00628432f, -0.03442430f, -0.01924152f, -0.00075180f, -0.00828711f, 0.01359340f, 0.02678863f, 
    0.00215864f, 0.00804834f, 0.04165117f, 0.04174242f, -0.03268817f, 0.04792524f, -0.03429148f, -0.04127968f, 
    0.42048880f, -0.09318884f, -0.20552140f, 0.16345726f, 0.29321557f, 0.16199364f, 0.04910475f, -0.08808371f, 
    0.03889092f, -0.10287188f, 0.25476164f, 0.06722255f, -0.08934148f, -0.27273434f, -0.02879795f, 0.00624700f, 
    0.23434286f, 0.19425599f, -0.26989850f, -0.03569825f, -0.00192724f, -0.03029555f, 0.01036422f, 0.11803791f, 
    -0.13062002f, -0.05390352f, 0.05393358f, -0.23194611f, 0.05551253f, -0.28590220f, -0.01585585f, 0.19808267f, 
    0.06152277f, -0.25814593f, -0.01868438f, 0.18149371f, -0.14963111f, 0.21656550f, -0.02385713f, 0.08987366f, 
    0.20949398f, 0.04521674f, -0.02263191f, -0.05508978f, -0.04402950f, -0.45296186f, 0.20480159f, 0.04468659f, 
    0.00329574f, -0.02808234f, -0.01372907f, -0.27090684f, -0.07128604f, 0.15992056f, 0.08227985f, 0.16817017f, 
    0.07839351f, 0.05832952f, -0.23926234f, 0.24437587f, 0.28698739f, 0.11021582f, 0.17161860f, 0.11382105f, 
    0.04843546f, 0.04916057f, 0.01143068f, -0.02409437f, 0.04415550f, 0.03638580f, 0.11027670f, -0.09824502f, 
    0.07680698f, -0.24193230f, -0.10268784f, 0.19153687f, 0.24235967f, -0.07612457f, -0.05934451f, 0.09217441f, 
    -0.08621678f, -0.29323980f, -0.41938290f, -0.12747963f, 0.11861035f, 0.16009697f, -0.00368652f, -0.16760755f, 
    -0.05465389f, -0.04677412f, 0.34272963f, 0.03980271f, -0.21062130f, 0.08386822f, 0.09985755f, -0.11830210f, 
    -0.00112711f, -0.18810368f, 0.02340097f, 0.01883161f, -0.04506483f, -0.12230834f, -0.25425538f, 0.08143164f, 
    -0.01502864f, -0.14304779f, -0.02744203f, 0.20583147f, 0.15809917f, -0.13056251f, -0.00376866f, 0.15718459f, 
    0.13662584f, -0.02997712f, 0.12295821f, 0.07744512f, -0.01858138f, 0.37821168f, 0.11824530f, 0.17868769f, 
    0.02307579f, 0.09618948f, 0.00314527f, 0.12319907f, 0.03292162f, -0.00207374f, -0.30934098f, -0.14678173f, 
    0.13330606f, -0.08821511f, 0.08380363f, 0.19384803f, -0.05502346f, 0.08519625f, 0.08375157f, 0.34962994f, 
    -0.23118760f, -0.41615334f, -0.03483361f, 0.09904319f, -0.18468246f, -0.19648242f, -0.08844224f, -0.01646518f, 
    -0.27402782f, -0.22001587f, -0.32575870f, 0.31032988f, 0.15842882f, 0.02034763f, -0.23647088f, -0.18350931f, 
    -0.12302388f, 0.09579545f, 0.15374996f, 0.19741897f, -0.59604812f, 0.10001270f, -0.03503842f, -0.30209517f, 
    0.16394214f, -0.12027233f, -0.28596580f, 0.16908148f, 0.07705967f, -0.07169718f, 0.14364998f, -0.08232147f, 
    -0.24536040f, 0.11179144f, 0.24820583f, 0.26894015f, 0.06346288f, -0.13874090f, 0.13228031f, 0.06615297f, 
    0.12929036f, 0.06497521f, 0.09605497f, -0.17209621f, 0.03634780f, -0.08178818f, 0.01514908f, -0.00817510f, 
    0.10317001f, -0.01629218f, -0.26718244f, 0.02402274f, 0.20978734f, 0.15985189f, 0.06336655f, 0.16820818f, 
    -0.33918491f, -0.20332994f, -0.10562026f, 0.07422430f, 0.08686247f, 0.04913398f, 0.05020900f, 0.21296851f, 
    -0.16827068f, 0.13911085f, -0.14593011f, 0.14929970f, 0.21463926f, 0.28227717f, -0.08177110f, -0.49080268f, 
    -0.17235139f, 0.03629904f, 0.13463630f, 0.13691108f, 0.02260674f, 0.08646539f, 0.00189203f, -0.15438215f, 
    0.11967913f, -0.12401243f, -0.38442993f, 0.14509724f, 0.08083960f, 0.07628515f, -0.03272951f, 0.12097382f, 
    -0.17359956f, -0.31337550f, 0.31290194f, 0.16762128f, -0.01086688f, -0.18368848f, -0.12132400f, 0.07627765f, 
    -0.01660475f, 0.16189444f, 0.28830957f, 0.09366798f, 0.11941668f, -0.02078103f, 0.13598712f, -0.04265727f, 
    0.11581685f, 0.11761661f, -0.14486019f, 0.20409642f, 0.00725459f, 0.02669122f, 0.25234899f, 0.11946493f, 
    -0.06955485f, 0.23025505f, -0.07043414f, 0.00489785f, -0.03881325f, -0.13889451f, -0.18529788f, -0.11528198f, 
    0.04896105f, 0.02061751f, -0.05279230f, -0.19036829f, -0.23341155f, 0.09284561f, -0.23905598f, -0.25911081f, 
    0.23845443f, -0.05513322f, 0.11635762f, -0.05024713f, 0.01528728f, 0.09255276f, 0.17244118f, 0.54636115f, 
    -0.08427414f, 0.11655364f, -0.00178959f, -0.01835189f, -0.04797489f, -0.05973630f, 0.00079253f, 0.06301332f, 
    -0.10792788f, 0.22211576f, -0.16261047f, 0.02507517f, 0.01093673f, -0.00143635f, -0.13054205f, -0.10852294f, 
    0.08189121f, 0.16874863f, 0.17371480f, 0.11442897f, 0.37958899f, -0.19319831f, 0.02790553f, 0.15188937f, 
    0.00030664f, 0.08054847f, 0.02489315f, -0.32467550f, -0.07769784f, 0.03943321f, 0.13414429f, 0.00786782f, 
    -0.04227633f, 0.22627941f, -0.27216741f, -0.16781184f, 0.10207084f, 0.12748858f, -0.13906188f, -0.00392292f, 
    -0.10592511f, 0.00470190f, -0.01045343f, -0.35180101f, 0.33422202f, 0.17771029f, 0.13059413f, 0.09618267f, 
    -0.14185360f, 0.00285543f, 0.03877554f, -0.04344263f, -0.06151535f, -0.02721234f, -0.05613573f, -0.03319000f, 
    -0.13018522f, -0.02100213f, -0.08965155f, -0.05668248f, -0.16661520f, 0.09556395f, -0.14218320f, 0.12669677f, 
    0.09342302f, -0.18670380f, 0.09850528f, -0.09329209f, -0.09399759f, -0.13807645f, 0.05911262f, -0.34143358f, 
    -0.13300230f, 0.09976263f, 0.06166271f, -0.05504813f, 0.05999032f, -0.11124625f, 0.11984000f, -0.11105134f, 
    -0.18369885f, -0.38454786f, -0.05356877f, -0.17773034f, 0.07561104f, 0.13640454f, -0.20568445f, 0.21724790f, 
    0.11876005f, 0.12105349f, 0.02944380f, -0.00706093f, -0.03311165f, -0.16832733f, 0.05023238f, -0.10102981f, 
    0.15045704f, -0.17337944f, 0.08352754f, -0.04828482f, 0.04669453f, 0.00128659f, -0.31419399f, -0.11954843f, 
    0.04503822f, 0.13344888f, 0.18556122f, 0.14508586f, 0.11473715f, 0.06090976f, 0.10907592f, -0.36431023f, 
    0.04889670f, 0.16470757f, -0.08713840f, 0.30275607f, -0.13121609f, 0.24954550f, 0.20444833f, -0.26898932f, 
    0.09814040f, -0.19410552f, -0.12649804f, -0.14153779f, 0.27796492f, 0.21917687f, 0.23665060f, -0.03568551f, 
    0.02593921f, -0.08924428f, -0.03374533f, -0.06053017f, 0.03773016f, -0.00831919f, -0.01429266f, -0.02117478f, 
    0.06325623f, 0.07813752f, -0.10055088f, -0.09350169f, -0.14864404f, 0.15993576f, 0.03723507f, -0.27867654f, 
    -0.06005119f, 0.14550574f, 0.07296075f, -0.00490406f, -0.28688839f, 0.19223510f, -0.10641769f, -0.00556291f, 
    -0.07567751f, 0.09682710f, 0.01267724f, 0.11800148f, -0.21869420f, -0.15190701f, 0.02519500f, 0.01491769f, 
    -0.26021218f, -0.35434538f, -0.15299414f, 0.27967143f, 0.15359952f, 0.17756091f, -0.17879543f, -0.04316070f, 
    -0.09931872f, 0.22943296f, 0.37584433f, -0.15014178f, -0.11003823f, -0.14869122f, 0.03473363f, -0.23898882f, 
    0.13887765f, 0.07452608f, 0.16952464f, -0.01332067f, -0.01796050f, 0.12037756f, -0.09266740f, -0.02672196f, 
    -0.27796531f, -0.18627812f, -0.04067140f, -0.26852813f, -0.07815656f, -0.10934085f, 0.01275959f, 0.14972517f, 
    0.11109906f, -0.12032513f, -0.01686462f, 0.25773892f, -0.00793048f, 0.23197627f, 0.28416181f, 0.00033760f, 
    0.11287170f, -0.16177139f, -0.02915266f, 0.00490877f, 0.14544703f, 0.18677211f, 0.00552527f, -0.09152549f, 
    -0.16926323f, -0.25549316f, 0.05510928f, -0.22902815f, 0.08558770f, -0.11305274f, 0.13257827f, 0.04636766f, 
    -0.09536695f, 0.02889119f, 0.05025459f, -0.16617031f, 0.19646499f, -0.03347223f, 0.09625117f, 0.14669678f, 
    0.32296935f, -0.12381559f, -0.03909038f, -0.04553759f, 0.08967996f, -0.03999409f, -0.05591103f, -0.04669640f, 
    0.10187315f, -0.00235932f, 0.14036527f, 0.10815178f, 0.12019606f, 0.01291112f, -0.25564662f, 0.09532663f, 
    0.06001925f, 0.07013560f, -0.22652274f, 0.01221035f, 0.20430967f, -0.15830705f, 0.20734510f, -0.12016702f, 
    0.00870269f, -0.05024004f, -0.10882214f, 0.09091804f, -0.10156445f, 0.07566340f, -0.05410327f, 0.01856068f, 
    -0.02030480f, 0.08875920f, 0.07896882f, 0.26088792f, 0.20583344f, 0.38263783f, -0.04685561f, 0.11372194f, 
    -0.08421726f, 0.07519283f, 0.15987498f, 0.10684753f, -0.01860818f, -0.18486696f, -0.04900686f, -0.08195189f, 
    -0.07781339f, 0.07682628f, -0.17766502f, -0.05509578f, 0.04180228f, 0.25533724f, 0.14103071f, 0.06171165f, 
    0.09735657f, 0.17070803f, -0.20300667f, 0.07153424f, 0.08834791f, 0.01419107f, 0.15649605f, 0.14588083f, 
    -0.37111384f, 0.15843999f, 0.17834023f, 0.04429198f, 0.05347877f, 0.12247250f, -0.04371670f, -0.10273900f, 
    0.04974257f, -0.19067156f, 0.04901027f, -0.02482959f, 0.07898677f, -0.04366769f, -0.15785389f, -0.08455037f, 
    -0.13693193f, -0.10432985f, 0.32391146f, 0.27537000f, -0.03412727f, -0.05752601f, 0.01681753f, 0.11773180f, 
    0.22576590f, 0.02884062f, -0.16979225f, -0.43582344f, -0.06740140f, -0.20625132f, 0.10126147f, 0.00800603f, 
    0.01665039f, -0.08511535f, -0.06137682f, -0.05821738f, -0.39337003f, 0.16626126f, -0.00679207f, -0.03204482f, 
    -0.03378372f, -0.02643589f, 0.18365195f, -0.20811640f, 0.18977983f, -0.15050593f, -0.25237402f, 0.26220107f, 
    -0.10451376f, -0.10829075f, 0.09875070f, 0.10754797f, -0.00654785f, 0.16221540f, -0.24331500f, 0.16018566f, 
    -0.11021228f, -0.16104501f, -0.07808232f, 0.09342217f, 0.03052798f, 0.07934056f, 0.13169959f, -0.38682041f, 
    0.17681244f, -0.03008054f, -0.13926463f, -0.08518130f, -0.02627125f, 0.10764404f, 0.20015536f, 0.19706331f, 
    -0.03311910f, -0.10371752f, -0.02538021f, 0.07498451f, -0.13210636f, 0.15899698f, 0.21942420f, -0.11339908f, 
    -0.10249831f, -0.26778704f, 0.06773655f, -0.00473662f, -0.01481908f, 0.00068693f, -0.07150553f, 0.02543504f, 
    -0.28987163f, -0.00901172f, 0.21646960f, 0.02546949f, 0.01838250f, 0.19973159f, -0.03613287f, 0.07939050f, 
    -0.06530637f, 0.11196660f, -0.32503992f, 0.29651824f, -0.12276695f, 0.00738806f, -0.19866352f, -0.04737227f, 
    -0.08105405f, 0.03185057f, 0.09008164f, -0.11982653f, 0.37351000f, -0.03568367f, 0.18196966f, 0.08899739f, 
    -0.17624228f, 0.12670068f, 0.16927873f, 0.35374290f, 0.40519887f, 0.17568254f, -0.25372204f, -0.06038523f, 
    -0.25403571f, -0.01656833f, -0.01414169f, 0.11348547f, -0.13720442f, -0.02854398f, 0.32275489f, 0.02675159f, 
    -0.05586194f, 0.00063298f, -0.09941045f, 0.16361332f, 0.11159079f, 0.02084691f, 0.06182123f, -0.06004996f, 
    -0.09948441f, 0.10218933f, -0.05826155f, -0.06574327f, 0.13884175f, 0.01883461f, -0.48944047f, 0.14978209f, 
    -0.72615236f, 0.06290516f, 0.09731773f, -0.23821726f, 0.00278946f, 0.03611064f, -0.18818398f, 0.09900365f, 
    -0.25430122f, 0.05248354f, 0.05818688f, -0.06996375f, -0.02173001f, -0.20378244f, 0.13583313f, 0.10614795f, 
    -0.05268669f, 0.21637531f, -0.10093571f, 0.06299479f, 0.07353638f, 0.13040794f, -0.02594195f, -0.08222133f, 
    -0.15728797f, -0.26464167f, 0.02531323f, 0.04656424f, 0.12855525f, 0.04091791f, -0.15448192f, -0.01863941f, 
    -0.05799405f, -0.20013085f, 0.24204579f, 0.34369692f, -0.15250781f, -0.14548266f, 0.03633894f, -0.17479436f, 
    -0.06184593f, -0.07263295f, 0.13066247f, 0.26796836f, 0.00430648f, -0.05648438f, -0.02748073f, 0.02810359f, 
    0.04308040f, 0.05666821f, 0.05033999f, 0.04529718f, 0.14359784f, -0.10899720f, 0.46802029f, -0.01923977f, 
    0.06413405f, 0.02997814f, 0.03335179f, 0.08978465f, -0.01286024f, -0.43437877f, 0.08356346f, 0.05436407f, 
    0.15527806f, 0.01709519f, -0.12589495f, -0.16051282f, 0.10715210f, -0.14183836f, 0.06578962f, 0.05652191f, 
    0.00216803f, 0.14184436f, -0.10389987f, 0.13099912f, -0.04096586f, 0.03958765f, -0.05081141f, -0.09619003f, 
    0.06288330f, 0.38130367f, 0.28977278f, -0.05102289f, -0.04991577f, -0.02553950f, -0.10036101f, -0.11215992f, 
    0.13839604f, 0.01897121f, 0.06377833f, -0.13077460f, -0.00360738f, -0.10377805f, 0.02615465f, 0.09065144f, 
    -0.15880269f, 0.05801954f, -0.17939736f, -0.29808486f, -0.13338940f, -0.11246715f, 0.02952505f, 0.14029463f, 
    0.12906276f, 0.12975405f, -0.01801836f, 0.18061048f, 0.27855816f, -0.00299562f, -0.17323199f, 0.00988328f, 
    0.03038446f, -0.02506687f, -0.19892646f, -0.38139758f, -0.03445625f, 0.43778688f, 0.18665206f, 0.12743264f, 
    -0.06226748f, -0.01815241f, -0.08244999f, 0.18908168f, -0.01857908f, 0.34279469f, 0.21809877f, 0.20637473f, 
    -0.04796857f, -0.13174613f, -0.01779258f, -0.04696330f, 0.11325025f, 0.07856726f, 0.18326747f, 0.54979533f, 
    0.10529088f, -0.08371475f, -0.06872895f, -0.04030079f, 0.01749281f, 0.17953852f, -0.00134504f, -0.21519211f, 
    0.04659349f, 0.10887540f, -0.10443897f, 0.11189062f, -0.00696241f, -0.10339834f, 0.00999906f, -0.18439440f, 
    -0.16196477f, -0.36884350f, -0.19540556f, 0.01903278f, 0.00884940f, 0.14763503f, -0.10944014f, -0.03289568f, 
    0.28063682f, -0.02597132f, -0.25251123f, -0.02119864f, 0.12586725f, -0.00523232f, 0.10177824f, 0.11044674f, 
    -0.06850966f, -0.07815084f, -0.35555786f, 0.06160170f, -0.09992355f, -0.00797555f, -0.03971958f, 0.16613862f, 
    -0.02572291f, -0.03456580f, 0.23223487f, 0.23230295f, -0.55402547f, 0.25499982f, 0.18075947f, 0.17287794f, 
    -0.01247920f, 0.09787919f, -0.01685279f, 0.06356826f, -0.37592405f, 0.02135373f, 0.12039157f, 0.17093873f, 
    -0.10045634f, -0.05383121f, 0.16801488f, 0.20384005f, 0.01357280f, 0.11476554f, -0.22814715f, 0.11562813f, 
    0.07778621f, 0.09207093f, -0.22266419f, 0.07369716f, -0.01413307f, 0.21342352f, -0.12975621f, -0.08049256f, 
    -0.01660934f, -0.08383401f, 0.01041500f, -0.04090188f, -0.22670998f, -0.11820431f, -0.32690153f, -0.59208691f, 
    0.04713554f, -0.17489286f, -0.08908267f, 0.10544495f, -0.16331908f, 0.09109563f, -0.05782058f, -0.06282710f, 
    0.15416534f, -0.03575243f, -0.09955398f, 0.08705755f, -0.00142945f, -0.08501638f, 0.01684837f, 0.12065710f, 
    0.09957924f, -0.43296534f, -0.00699421f, -0.00779014f, 0.00077795f, 0.17347811f, 0.04317361f, 0.00496788f, 
    0.25571510f, 0.12696368f, -0.06838445f, 0.00199190f, -0.19294935f, 0.16237961f, -0.17655413f, 0.05309492f, 
    -0.11793034f, -0.08769338f, 0.69931698f, 0.05125026f, 0.01849913f, -0.09618126f, 0.10030866f, -0.19123937f, 
    -0.02309923f, -0.09913839f, 0.20369534f, -0.46311784f, -0.01911432f, 0.09274456f, -0.05699644f, 0.17217019f, 
    0.11379518f, -0.09365977f, 0.01729678f, 0.10979600f, 0.25939527f, -0.27261585f, 0.05991418f, -0.05783974f, 
    -0.00584529f, -0.09138668f, -0.05450699f, 0.09097957f, 0.07235674f, -0.24154146f, 0.04043938f, -0.01046913f, 
    -0.16896300f, -0.01358194f, -0.00853543f, 0.03961474f, -0.06646936f, 0.11917906f, -0.16950220f, 0.14288297f, 
    -0.06829832f, 0.28020427f, 0.16278292f, -0.00464799f, -0.09850854f, 0.05778182f, -0.02754374f, 0.39547521f, 
    0.11758473f, -0.22835015f, -0.13132541f, -0.08770107f, -0.07815487f, -0.12121412f, -0.11395079f, 0.08829705f, 
    0.19604483f, 0.22853722f, -0.07508527f, 0.10691599f, 0.04384397f, -0.01090009f, 0.15701886f, -0.06309364f, 
    -0.07032485f, -0.45298800f, -0.17051496f, -0.07715190f, 0.08058336f, -0.05369680f, 0.10227738f, 0.02766029f, 
    -0.28422910f, -0.01078053f, -0.11336891f, -0.14766045f, -0.02086433f, 0.11213058f, 0.14824128f, -0.00135568f, 
    -0.02179345f, -0.08194270f, 0.01495855f, -0.22055614f, 0.15609948f, 0.15589765f, 0.25182822f, 0.25119972f, 
    0.01867082f, 0.11718327f, -0.03482584f, -0.04711670f, -0.15109921f, -0.57868969f, 0.16271551f, 0.06950297f, 
    0.24293238f, 0.19857119f, 0.23651119f, 0.14195286f, 0.35926998f, 0.04980129f, -0.07116458f, 0.01170908f, 
    0.00880818f, 0.12275890f, 0.04549950f, -0.00842698f, 0.13100982f, 0.04341908f, 0.11772520f, 0.28320661f, 
    0.22109886f, -0.08077943f, -0.04440992f, -0.11995939f, 0.03193490f, 0.01066690f, 0.00174998f, -0.05834247f, 
    -0.48644707f, -0.03820164f, 0.19728677f, -0.13034673f, -0.19820601f, -0.09963635f, 0.08394241f, 0.03137134f, 
    0.13521431f, -0.35663748f, 0.12660915f, -0.05493880f, -0.26516664f, -0.02340188f, 0.00743956f, 0.00935738f, 
    -0.01967665f, -0.13318183f, -0.15590258f, -0.00427007f, -0.19502549f, 0.23523779f, -0.06739352f, -0.00247290f, 
    -0.00079007f, -0.39507592f, -0.09317794f, 0.23233773f, -0.10920084f, -0.01060216f, 0.08086298f, 0.16587824f, 
    -0.10218783f, -0.12867962f, -0.03658339f, 0.08432164f, -0.30793068f, 0.21940133f, -0.06688845f, 0.03169106f, 
    -0.03330719f, 0.06318698f, -0.02396406f, 0.18766531f, -0.14525947f, -0.03171014f, 0.24512590f, -0.27675053f, 
    0.07199057f, -0.06943996f, -0.14167359f, -0.06242318f, 0.03006663f, 0.25380501f, -0.20769729f, 0.21541832f, 
    -0.11559669f, 0.00138657f, -0.15527269f, 0.10138409f, 0.09553286f, 0.15886404f, 0.14712131f, 0.02761836f, 
    -0.02213264f, -0.08751971f, -0.00114441f, -0.12482045f, 0.07866888f, 0.04966225f, -0.00802036f, 0.11556993f, 
    0.21707003f, -0.16509938f, 0.08009133f, 0.01149484f, 0.05482462f, -0.10331593f, 0.07267436f, -0.10434229f, 
    0.17389230f, 0.32505080f, 0.04148317f, -0.00059056f, 0.03070568f, -0.14126261f, 0.20342535f, 0.00006943f, 
    -0.13092606f, -0.36960462f, -0.07687032f, 0.30026197f, -0.35090825f, 0.07436483f, -0.13848412f, -0.20228176f, 
    0.04067990f, 0.10703605f, -0.20436886f, -0.25828016f, -0.52017325f, 0.05438929f, 0.03517879f, 0.19997460f, 
    -0.03183275f, -0.17833661f, -0.09781559f, -0.05912405f, -0.81666309f, -0.21712016f, 0.03803707f, -0.03217600f, 
    -0.14601181f, 0.11819752f, 0.16087778f, -0.13631365f, -0.33957404f, -0.31774029f, -0.15998484f, 0.22463357f, 
    0.12513041f, -0.18423207f, -0.04326142f, 0.07157662f, 0.07644138f, 0.31425411f, -0.40886846f, -0.10710921f, 
    -0.02047642f, 0.03444730f, -0.05979190f, 0.03188400f, -0.19415441f, 0.03355094f, 0.29273397f, -0.17981075f, 
    0.11985756f, 0.12475608f, -0.10726386f, 0.01119107f, -0.21869543f, 0.05312420f, -0.15276212f, -0.05779562f, 
    0.18002768f, -0.08022006f, -0.31196859f, -0.07902643f, -0.07211570f, -0.15604445f, 0.17476374f, -0.04204480f, 
    -0.29160923f, 0.29946360f, -0.16873963f, 0.00359744f, 0.07409507f, 0.04869431f, 0.04630870f, 0.05145642f, 
    0.22730394f, -0.21072374f, 0.19714187f, 0.12757242f, 0.06604554f, 0.10788129f, 0.08223015f, 0.06583367f, 
    0.04738046f, -0.09287380f, 0.41699648f, 0.41690302f, 0.00612435f, 0.09407551f, 0.02602256f, 0.04211234f, 
    -0.06030053f, 0.09318991f, -0.04004128f, 0.26767319f, -0.38717419f, 0.20911579f, -0.04611496f, -0.04402423f, 
    -0.10801434f, -0.08526433f, -0.10277236f, -0.00586776f, 0.15270273f, 0.22909240f, -0.04327529f, 0.10457349f, 
    0.09303670f, 0.04647039f, 0.07643811f, -0.03833653f, -0.04642173f, 0.32642898f, 0.17034461f, 0.02187531f, 
    0.12962392f, -0.14686751f, -0.01390513f, 0.09320790f, 0.05338812f, 0.02366146f, -0.33695963f, -0.16299523f, 
    -0.26295453f, 0.07984877f, 0.01815423f, -0.07393096f, 0.15511790f, 0.10812355f, 0.10357728f, 0.16224490f, 
    0.24893096f, -0.25046611f, 0.09929024f, -0.05431360f, -0.04380309f, -0.09832445f, 0.03766693f, 0.19688952f, 
    -0.03182815f, -0.04597081f, -0.01362796f, 0.10598196f, 0.10335949f, 0.11724590f, -0.09115847f, 0.06781248f, 
    -0.04774316f, 0.21042950f, 0.15794536f, 0.01569771f, 0.26883921f, -0.38152471f, 0.10201903f, 0.00031448f, 
    -0.15268257f, 0.16656338f, 0.18096989f, -0.26530826f, -0.11292657f, 0.04673466f, 0.08514251f, -0.06256652f, 
    -0.01773692f, 0.03001093f, -0.06910447f, 0.15939176f, 0.16363050f, -0.07569194f, -0.06600168f, -0.00832156f, 
    0.00296151f, -0.02389344f, 0.12660486f, -0.04367903f, -0.18041825f, -0.02044879f, 0.14999282f, 0.24081795f, 
    -0.25358695f, -0.09384368f, 0.23404884f, 0.06319082f, 0.12461314f, 0.24750003f, 0.07027755f, 0.11894799f, 
    -0.06608342f, -0.01822828f, 0.03422563f, -0.07657413f, 0.11094993f, 0.02461931f, 0.16686197f, 0.39666069f, 
    -0.01481279f, 0.04273341f, -0.19649120f, -0.07850821f, -0.15942226f, 0.09883841f, 0.01420150f, -0.50382698f, 
    0.05911719f, -0.17334090f, 0.11605924f, 0.13672999f, 0.23652217f, 0.02132476f, -0.17275511f, -0.29015198f, 
    0.05838303f, -0.23713510f, -0.08124618f, -0.01595196f, -0.02184884f, -0.13253348f, 0.04038895f, -0.06803422f, 
    0.18329464f, -0.28685543f, -0.19286031f, 0.02998919f, -0.25118971f, 0.16837090f, -0.11755209f, -0.00318488f, 
    0.20710774f, 0.11655571f, 0.10517143f, 0.27772760f, -0.02558163f, -0.10750308f, 0.03689247f, -0.19359529f, 
    -0.07557207f, 0.06330036f, -0.04272569f, 0.00926563f, 0.39709979f, -0.06649728f, 0.02103784f, -0.05272701f, 
    0.10283586f, 0.10738996f, -0.14281797f, -0.02184322f, 0.05859777f, -0.08471284f, 0.12363195f, -0.01059847f, 
    -0.12401056f, 0.09465367f, -0.16659056f, 0.08744743f, 0.01105857f, -0.02422589f, 0.19232182f, -0.12384046f, 
    -0.00668881f, 0.07664268f, -0.06706157f, 0.17839904f, -0.06347352f, 0.06803042f, 0.15380651f, 0.26451892f, 
    0.28092706f, -0.20136584f, 0.06532502f, -0.14993437f, 0.04227789f, -0.07564994f, 0.04040071f, 0.29373464f, 
    -0.12042802f, -0.44482368f, -0.07763615f, -0.14373276f, 0.01990787f, 0.10003556f, 0.19802268f, -0.04273408f, 
    0.17437711f, -0.01202992f, 0.21186247f, 0.06533362f, -0.00943315f, 0.19924228f, -0.07625406f, 0.11677421f, 
    0.26824814f, 0.20938280f, -0.26174924f, -0.00271675f, 0.03640645f, -0.04101450f, 0.20400020f, -0.19693212f, 
    0.03108913f, 0.01922839f, 0.33129445f, 0.03850437f, -0.08707812f, 0.18384336f, -0.14766908f, -0.20512162f, 
    -0.01053349f, -0.01355312f, 0.10222122f, 0.34790498f, 0.27293235f, 0.13833192f, -0.06457826f, 0.16533744f, 
    0.23907758f, -0.08337897f, 0.24481530f, 0.06602719f, 0.44544336f, -0.06711333f, 0.13716094f, 0.01959614f, 
    -0.01641353f, -0.15847488f, 0.17606264f, -0.08329146f, 0.15364213f, -0.32513043f, -0.07908294f, 0.12560953f, 
    -0.03845087f, -0.03907984f, -0.15924788f, 0.01000186f, -0.03190843f, 0.24950144f, 0.02910966f, 0.14964043f, 
    -0.11749000f, 0.16641685f, -0.10844295f, 0.09802467f, 0.10857634f, 0.00922839f, -0.07968778f, -0.29009551f, 
    -0.06533363f, 0.28912261f, 0.19091853f, -0.04171903f, 0.15422146f, 0.16023017f, 0.00839840f, 0.13462324f, 
    0.17553836f, 0.01026538f, 0.09699018f, 0.16912214f, -0.02589539f, -0.06809889f, 0.06576663f, 0.14828737f, 
    0.02311454f, -0.16672175f, 0.10475835f, 0.03010285f, 0.00820142f, -0.07825708f, -0.02129444f, 0.04139599f, 
    -0.02802971f, -0.04485374f, 0.10966052f, 0.08652143f, 0.15431793f, 0.08261858f, 0.03299939f, 0.10664720f, 
    -0.00763037f, 0.05631327f, 0.03052593f, 0.01993906f, 0.27264115f, -0.05839666f, -0.24395019f, 0.02402377f, 
    -0.27832642f, -0.10230411f, 0.00849960f, 0.13989711f, -0.03616592f, 0.04954490f, 0.29402101f, 0.05529588f, 
    -0.03529773f, 0.05565776f, -0.09493711f, 0.14008817f, 0.06231728f, -0.30494758f, -0.21540563f, -0.08809060f, 
    0.09986874f, 0.00803458f, 0.11007121f, -0.14701508f, -0.04453237f, -0.21677887f, 0.19875027f, -0.00861492f, 
    0.03454082f, -0.17770976f, -0.04074658f, -0.14748737f, 0.01095506f, 0.04560001f, -0.12609388f, 0.14092058f, 
    -0.07852194f, -0.03720925f, 0.09747308f, 0.00427584f, -0.00601373f, 0.10546476f, 0.00313870f, 0.06674358f, 
    -0.29113251f, -0.10687838f, 0.03518947f, -0.14245757f, -0.03710382f, -0.10506234f, 0.07117919f, 0.15698376f, 
    -0.10585395f, -0.40331668f, -0.49189290f, 0.04316141f, -0.01436357f, 0.05463386f, -0.11686041f, 0.02416569f, 
    -0.07848368f, -0.25806719f, 0.20235106f, 0.15692183f, -0.10361400f, -0.14120746f, 0.09359452f, -0.12272713f, 
    0.08473018f, -0.17500709f, 0.14401442f, 0.32927248f, 0.05018148f, -0.19750698f, -0.12820098f, -0.05480102f, 
    -0.00600270f, 0.22381547f, 0.07081825f, -0.09425621f, 0.15106557f, -0.10045186f, 0.47294161f, 0.09774388f, 
    -0.01129586f, 0.10854972f, 0.09015685f, -0.25293180f, -0.02382914f, -0.46048710f, -0.15488011f, -0.05867191f, 
    0.06772700f, -0.07905568f, -0.10254426f, -0.04328259f, -0.12406193f, -0.01388987f, -0.20407514f, 0.04938592f, 
    -0.16290285f, 0.24423815f, -0.03141171f, 0.07611965f, 0.14950575f, 0.14794938f, -0.14949022f, 0.04312547f, 
    0.14931168f, 0.29116890f, 0.29315314f, -0.02139605f, -0.02930256f, -0.14338662f, -0.02811167f, 0.09887191f, 
    -0.06367271f, 0.08296755f, -0.22950803f, 0.04753097f, 0.00062368f, -0.06993081f, -0.03371857f, 0.01999648f, 
    -0.23354889f, 0.26510125f, -0.03723456f, 0.03984153f, 0.01801981f, -0.17230956f, -0.02208899f, -0.01059764f, 
    0.00002758f, -0.05536746f, -0.15336809f, 0.14037982f, 0.05668827f, 0.02198569f, 0.00240484f, 0.12209670f, 
    0.08293049f, -0.10469713f, -0.26830238f, 0.15567338f, -0.05239991f, 0.21274869f, 0.12684143f, 0.04423485f, 
    -0.17063308f, -0.06856684f, -0.05375654f, 0.06845772f, -0.21650535f, -0.27529317f, 0.14163005f, 0.03579033f, 
    -0.07599210f, 0.12807985f, -0.20937289f, -0.11662854f, 0.12389044f, 0.12230248f, -0.05734286f, 0.19485402f, 
    -0.09378938f, 0.23090081f, -0.09677643f, 0.09484398f, 0.11090682f, -0.06199793f, 0.10553373f, 0.26052663f, 
    -0.09992420f, 0.10855632f, 0.00520408f, 0.24109638f, 0.02941081f, -0.09505812f, -0.21405567f, -0.40421674f, 
    -0.22385134f, 0.01219275f, -0.11606988f, 0.13688183f, -0.01931966f, 0.04320556f, 0.01783348f, 0.08595679f, 
    -0.22428264f, 0.46173850f, 0.26428032f, 0.16077955f, 0.04130802f, 0.01608702f, -0.06639405f, 0.21797317f, 
    0.20272574f, -0.21584530f, -0.06152464f, -0.04412205f, 0.07448126f, -0.03253689f, 0.01269908f, 0.00205701f, 
    0.15123717f, 0.04100547f, -0.03012209f, -0.00441134f, 0.10362186f, 0.12247182f, -0.08933224f, 0.09764666f, 
    -0.16498472f, -0.06101637f, 0.02756768f, 0.52445596f, 0.40229845f, -0.22578929f, -0.09778155f, 0.03642205f, 
    -0.12466099f, -0.04928686f, -0.03365349f, -0.13473873f, 0.31748480f, 0.03294250f, -0.06997050f, -0.11626388f, 
    -0.13507326f, 0.22737192f, -0.13128208f, 0.03114794f, 0.24210614f, 0.24229008f, 0.09814110f, 0.06432422f, 
    -0.28474870f, -0.12723050f, -0.09216126f, -0.12371698f, 0.08691572f, -0.19246162f, -0.37879682f, -0.01571083f, 
    0.23829365f, -0.19240572f, -0.07487288f, -0.17845838f, 0.01254192f, 0.03415806f, 0.06186953f, -0.43003923f, 
    -0.12267403f, 0.12490767f, 0.03102719f, 0.23793258f, -0.07088904f, 0.02048100f, 0.05288528f, 0.07753135f, 
    -0.09231649f, -0.14537261f, 0.06002108f, 0.04764838f, 0.05252622f, -0.08190031f, 0.08183125f, 0.16011670f, 
    -0.21734795f, -0.03891533f, -0.05420676f, 0.05481323f, 0.14687252f, 0.05406411f, 0.14446887f, 0.12100536f, 
    0.02101164f, -0.18573500f, -0.20477083f, -0.32396245f, -0.18376434f, 0.14051785f, 0.09978952f, -0.16420884f, 
    -0.10871683f, 0.06569345f, 0.11578193f, 0.46376950f, 0.28434563f, -0.17681295f, 0.03002156f, -0.08280121f, 
    -0.32127529f, -0.14600433f, 0.12103121f, -0.06612828f, -0.48573440f, -0.06080682f, 0.01830622f, 0.03201545f, 
    0.04513066f, 0.03833497f, -0.00145564f, -0.02554477f, -0.40087438f, -0.23003072f, 0.08040401f, 0.03718453f, 
    0.11603823f, 0.05397135f, -0.21124047f, -0.14393891f, -0.04553992f, -0.01652467f, -0.10615542f, 0.06903668f, 
    0.04774870f, -0.17673789f, 0.00466022f, -0.01126857f, -0.17863674f, 0.08847077f, -0.07392998f, -0.03594803f, 
    -0.15771851f, 0.04865484f, 0.13546574f, 0.03287216f, -0.04784446f, 0.14791429f, -0.05647592f, 0.09331605f, 
    0.00987823f, -0.10331527f, 0.05807699f, 0.10340019f, -0.10543258f, 0.14666966f, 0.07730149f, -0.01665197f, 
    -0.02254181f, 0.07060643f, 0.04051989f, -0.07017750f, 0.04765086f, -0.05872060f, 0.22418924f, -0.11057416f, 
    -0.01056120f, 0.06496397f, 0.28361902f, 0.14964496f, -0.01462695f, -0.23788869f, -0.19073583f, 0.04412117f, 
    0.00027970f, -0.07053573f, -0.12017307f, 0.14137521f, 0.02598136f, -0.23038931f, -0.24353820f, -0.04454088f, 
    -0.13585001f, 0.29448664f, -0.20183820f, 0.15345286f, 0.25405487f, 0.17127152f, 0.16068041f, 0.00139159f, 
    0.08960813f, -0.20628886f, 0.11095291f, 0.10088938f, 0.04570143f, -0.11246770f, -0.11042905f, -0.06191558f, 
    0.01291879f, 0.00078755f, 0.14703757f, -0.38542446f, -0.03585137f, 0.00835028f, -0.04373007f, 0.03065727f, 
    0.03386451f, -0.07333968f, 0.11228775f, -0.17652988f, 0.06842168f, 0.02668738f, -0.06525899f, -0.04043304f, 
    0.04757220f, 0.31337008f, 0.25986892f, 0.23826019f, 0.14019971f, -0.02354605f, 0.03624443f, -0.14355186f, 
    0.03849187f, 0.01729322f, -0.29077044f, -0.12503897f, -0.03202102f, -0.21544650f, 0.12352379f, 0.04089589f, 
    -0.09166849f, 0.13458335f, 0.07364000f, 0.19875348f, 0.07577261f, -0.11667042f, 0.03459722f, 0.05153249f, 
    0.13445780f, -0.16624133f, -0.20816596f, -0.13595599f, 0.16415451f, -0.20628537f, -0.01811113f, -0.24392956f, 
    -0.07128569f, -0.06172367f, 0.01496610f, -0.22937295f, 0.02467417f, 0.07191712f, 0.14898542f, 0.04089839f, 
    -0.01583423f, 0.04956957f, 0.07041243f, -0.03300546f, -0.15644754f, -0.10166697f, 0.20535386f, 0.04682263f, 
    0.19365060f, -0.08636500f, 0.15192820f, -0.12054858f, 0.13957880f, -0.02308296f, 0.24435225f, -0.19412395f, 
    0.05618384f, 0.06556498f, -0.23239933f, 0.01018280f, 0.11046599f, -0.06622555f, -0.16786760f, -0.13552840f, 
    0.32638299f, 0.02086540f, -0.20794776f, 0.03692881f, 0.02029185f, -0.12217118f, 0.06782149f, -0.00351175f, 
    0.04832798f, 0.09264369f, -0.20819932f, 0.22893162f, 0.13536009f, 0.01355554f, 0.00574486f, -0.00567358f, 
    0.26131296f, 0.21825659f, 0.01087137f, 0.08704254f, -0.00011875f, -0.00084852f, -0.03011807f, -0.12281141f, 
    -0.02445014f, -0.19077370f, -0.00978286f, -0.15573478f, -0.14641820f, -0.19807547f, 0.04573259f, 0.21435061f, 
    0.11660811f, -0.02880161f, -0.04607550f, 0.18137483f, 0.02406605f, -0.10668400f, 0.03930462f, 0.16124785f, 
    0.04034819f, 0.19151507f, 0.10800382f, -0.23054528f, 0.12336610f, -0.07380613f, 0.03983042f, 0.11087156f, 
    0.09147026f, -0.00719305f, -0.08404644f, -0.03992400f, -0.07038486f, 0.12555566f, 0.11939401f, 0.13342720f, 
    -0.07198424f, 0.06069837f, 0.01494098f, -0.05316833f, 0.01447057f, -0.52235764f, -0.09847458f, 0.42045435f, 
    -0.06131469f, 0.04921963f, 0.02199664f, -0.11592787f, 0.03967864f, -0.06354271f, 0.10120039f, 0.00971643f, 
    -0.15037711f, -0.09915390f, -0.07706974f, 0.07839502f, 0.05705827f, 0.04680577f, 0.14964904f, -0.25848553f, 
    0.11628067f, -0.07944834f, 0.04968047f, 0.02252049f, 0.05664942f, 0.01960024f, 0.11081053f, 0.03591214f, 
    -0.14195244f, -0.26923060f, -0.10839089f, 0.14757963f, -0.04748629f, -0.01677902f, 0.06048913f, 0.11138511f, 
    -0.11267546f, -0.34447694f, -0.34643674f, 0.05076322f, 0.16140187f, -0.12022879f, 0.01890938f, -0.02505757f, 
    0.15580638f, 0.07338984f, 0.01068031f, 0.05302779f, -0.01098259f, -0.01774768f, 0.05686512f, -0.01862162f, 
    0.20428602f, -0.13369948f, 0.04285732f, -0.50858349f, -0.36466208f, 0.39367342f, 0.04125668f, 0.15110712f, 
    -0.02048137f, 0.07829653f, -0.19762978f, 0.04496959f, -0.07677829f, -0.01419184f, 0.27131861f, 0.00380642f, 
    0.08760370f, 0.04279980f, 0.14723414f, 0.15980776f, -0.02515162f, 0.03344381f, -0.02172108f, -0.04567993f, 
    0.07727131f, 0.09942988f, 0.09663159f, 0.12856194f, -0.06812082f, 0.05574651f, 0.12012214f, 0.00001949f, 
    0.20598070f, -0.22556880f, -0.07979152f, 0.09959677f, -0.09826422f, -0.02190507f, 0.19587351f, 0.02546397f, 
    0.07823727f, -0.32113442f, 0.04596654f, -0.05225713f, 0.06287716f, 0.04902460f, 0.12210806f, 0.16782081f, 
    -0.17439261f, -0.12539208f, -0.15912347f, 0.01005055f, 0.09895173f, 0.11366365f, -0.08604567f, -0.09054687f, 
    -0.10207275f, -0.03528150f, 0.09175795f, 0.04919415f, 0.01992152f, -0.03963389f, -0.11608361f, -0.04146130f, 
    -0.09571524f, 0.11235331f, -0.35996407f, 0.02754783f, 0.40388525f, 0.02078034f, -0.00000625f, 0.20545180f, 
    0.00470106f, 0.15931037f, 0.07096540f, 0.40712768f, 0.00279601f, -0.09915497f, 0.03319602f, 0.15832581f, 
    -0.20668332f, 0.10135642f, 0.01992452f, -0.08554056f, 0.16067567f, -0.06180166f, -0.04168119f, 0.04688103f, 
    -0.21542342f, -0.13592705f, -0.07255720f, -0.14186013f, -0.06102215f, -0.00331268f, 0.23813327f, 0.40077186f, 
    -0.27263746f, -0.12830581f, -0.04261461f, -0.12035432f, -0.09560193f, 0.07473376f, 0.18224914f, 0.23001722f, 
    -0.09513642f, -0.02582778f, -0.04686497f, -0.14298318f, 0.09517352f, 0.07847457f, 0.23233303f, -0.38301018f, 
    -0.39434436f, 0.20120163f, -0.03234317f, -0.03757316f, 0.03224714f, -0.04176563f, 0.17059226f, -0.12942272f, 
    0.05045044f, 0.01230793f, -0.22773749f, -0.25219652f, 0.11948777f, -0.00791645f, 0.17055601f, 0.08806505f, 
    0.14285794f, -0.25219616f, -0.09918959f, -0.06816867f, -0.05866467f, -0.16173862f, -0.10747924f, -0.14667343f, 
    -0.04212823f, -0.06312206f, -0.18587260f, 0.18376932f, 0.02564435f, 0.21840835f, 0.08854511f, -0.20924507f, 
    0.23691119f, 0.07789377f, 0.11359034f, 0.13589534f, 0.00366141f, 0.24078088f, 0.15496163f, 0.03875188f, 
    -0.04529409f, 0.17644437f, 0.14658999f, 0.06263539f, 0.03253135f, 0.03958493f, -0.51105440f, -0.13978232f, 
    -0.20382617f, -0.08177593f, -0.13344973f, -0.09122910f, 0.02548209f, 0.37642786f, -0.08353920f, -0.29841191f, 
    -0.25144586f, -0.02390528f, 0.01024794f, -0.09525709f, 0.05905074f, 0.13620469f, 0.14591843f, 0.33909860f, 
    -0.01902128f, 0.03656172f, -0.13737607f, -0.09156005f, 0.07687564f, -0.07771225f, -0.01789681f, -0.07659175f, 
    0.22967465f, -0.22637215f, -0.06492165f, -0.11121403f, 0.11606616f, -0.14269122f, 0.04809420f, 0.09825397f, 
    0.33001766f, -0.05483232f, -0.06649783f, -0.06398866f, -0.00173549f, 0.06650759f, 0.04617719f, 0.08443677f, 
    -0.00516446f, 0.40464243f, -0.18272422f, -0.30370244f, -0.04085592f, -0.03392621f, 0.02085788f, -0.14556351f, 
    0.18824857f, 0.06641708f, 0.73870581f, 0.28352213f, -0.19140251f, 0.04955907f, 0.08341611f, -0.19366731f, 
    -0.08603509f, -0.17350189f, 0.18797846f, 0.27036017f, 0.21015781f, -0.17895828f, -0.18878233f, 0.18213975f, 
    -0.25093773f, 0.13183621f, 0.11452068f, 0.03700645f, 0.24645878f, 0.33174840f, 0.05402106f, 0.03579411f, 
    -0.07142565f, -0.17199653f, -0.03099365f, 0.03857728f, 0.01749250f, 0.31651172f, 0.06839170f, -0.19069786f, 
    -0.08667778f, 0.18525764f, -0.02298923f, -0.11965901f, -0.11500355f, -0.00400612f, -0.47999790f, -0.17143463f, 
    0.12993498f, 0.06030197f, -0.21281685f, -0.17762148f, -0.02436354f, 0.11330000f, -0.03471467f, 0.08827202f, 
    0.40079388f, 0.24462348f, 0.14871956f, 0.04305183f, 0.03079766f, 0.10902296f, -0.02288481f, -0.18087435f, 
    -0.27885240f, -0.29988429f, 0.33724606f, -0.13654955f, -0.04426346f, -0.03332100f, -0.13663641f, 0.01310083f, 
    -0.02683402f, 0.23286392f, -0.15818830f, 0.09189660f, -0.15071334f, -0.27439797f, -0.07401428f, -0.07487347f, 
    -0.07884546f, 0.09207829f, 0.13643305f, 0.27674499f, 0.02046555f, -0.02455593f, -0.20178363f, 0.12071667f, 
    0.26753065f, 0.07688960f, 0.05554708f, -0.03794782f, -0.08824620f, -0.09130841f, -0.13540731f, 0.00379463f, 
    0.01898043f, -0.08450408f, -0.19293685f, 0.17927231f, -0.02381194f, 0.08966136f, 0.21570168f, -0.06661475f, 
    0.07219857f, 0.02050310f, 0.06435715f, -0.02217938f, 0.07728941f, -0.19682388f, -0.02334193f, -0.11790287f, 
    -0.13888465f, -0.01116905f, 0.19555873f, -0.15584169f, 0.07742243f, -0.03525842f, -0.20902915f, -0.09093364f, 
    0.19956766f, 0.00754415f, 0.05825709f, -0.18056878f, -0.09888919f, -0.02773628f, -0.02487364f, 0.12165534f, 
    0.04447019f, -0.27875048f, -0.02054683f, 0.04998094f, 0.03815853f, 0.01792515f, 0.01686940f, 0.14328966f, 
    0.27965429f, 0.30813888f, -0.18063828f, -0.08108580f, 0.23741034f, -0.00043931f, -0.08466572f, -0.22739734f, 
    0.03152220f, -0.26857251f, 0.10386646f, 0.10577155f, -0.19097857f, 0.10991079f, 0.07133143f, -0.23268631f, 
    0.01100167f, 0.01299202f, 0.24175508f, -0.07534892f, -0.15799758f, -0.04923979f, 0.17629980f, -0.17183383f, 
    -0.03509384f, 0.02790795f, -0.06336237f, -0.24675234f, 0.06649765f, -0.18740255f, 0.17146145f, 0.01167144f, 
    -0.18628988f, -0.15418768f, -0.04942538f, 0.01691873f, 0.03779066f, -0.08984613f, 0.16292557f, -0.06639450f, 
    -0.14066176f, 0.27340412f, -0.17219211f, 0.20086817f, 0.06091493f, -0.12729703f, 0.20060782f, 0.18877076f, 
    0.15554950f, 0.00733326f, -0.08490998f, -0.06173635f, 0.02841249f, -0.06306053f, -0.03601420f, -0.08687023f, 
    0.13623486f, -0.03279060f, 0.00037354f, -0.03602301f, 0.02600330f, 0.01591579f, 0.16875602f, -0.23006919f, 
    0.07269628f, 0.24393198f, -0.17876986f, 0.06548809f, -0.14834309f, -0.01620279f, -0.04659319f, -0.12278048f, 
    0.11386731f, -0.21345556f, -0.12200496f, 0.31432694f, -0.07245570f, -0.17203163f, -0.10565584f, -0.02488087f, 
    0.07794935f, 0.67180127f, -0.01455733f, 0.07348805f, -0.00001977f, 0.00499984f, -0.26968136f, -0.00400755f, 
    0.23626833f, 0.07300729f, 0.09090638f, 0.01876321f, -0.05529239f, -0.14307229f, 0.04923354f, 0.00697703f, 
    -0.00743250f, 0.03282434f, 0.01030628f, -0.14245445f, 0.02684905f, -0.01069341f, -0.21701400f, -0.15924540f, 
    0.03697396f, -0.06119351f, 0.00951072f, -0.14425482f, -0.03337782f, 0.17602256f, 0.11602288f, -0.18309486f, 
    0.22898100f, 0.18385236f, -0.19029701f, -0.08597303f, -0.07373414f, -0.00989754f, -0.01612444f, 0.20420422f, 
    0.08934675f, 0.06620373f, -0.02533690f, 0.00296523f, -0.01384979f, 0.09781837f, 0.34314021f, -0.03067381f, 
    -0.11837801f, -0.23766670f, -0.04224194f, -0.12781680f, -0.11606357f, 0.25251344f, -0.01601549f, 0.13924959f, 
    0.25508687f, 0.08916998f, -0.07531531f, 0.21106331f, -0.15098682f, -0.06913838f, -0.08650219f, -0.09003420f, 
    -0.00960085f, -0.06553555f, -0.03769935f, 0.02038225f, -0.02088639f, -0.06767523f, 0.00289703f, -0.01587996f, 
    -0.05636672f, -0.04925226f, 0.01072498f, 0.01400798f, -0.01574599f, -0.04100824f, -0.05328901f, 0.02146727f, 
    -0.05801152f, -0.02755716f, 0.04090614f, -0.04371269f, 0.04054575f, 0.03280463f, 0.02758036f, -0.02244039f, 
    -0.02502969f, 0.04633547f, -0.01235877f, -0.05624973f, 0.03303361f, 0.03379326f, 0.02986823f, 0.03358178f, 
    0.02779100f, -0.03414820f, -0.02435295f, 0.03188233f, 0.01603031f, 0.04099926f, -0.01138447f, 0.00883807f, 
    -0.05468582f, 0.05043205f, -0.01790680f, 0.03893459f, -0.05682402f, -0.05456067f, -0.04888872f, -0.05080921f, 
    -0.06497769f, 0.00813521f, 0.03130059f, 0.01203174f, -0.02762900f, -0.01883554f, -0.03759647f, -0.04220673f, 
    0.03539097f, 0.00866069f, 0.05062537f, -0.01837930f, -0.02123585f, -0.01746514f, -0.03484603f, -0.06297545f, 
    -0.05975495f, -0.02318366f, -0.02884840f, 0.03491282f, -0.04340158f, 0.04196238f, 0.00664305f, 0.02121230f, 
    0.00772731f, -0.03843474f, 0.00887215f, -0.05725088f, -0.00997234f, -0.01353376f, -0.02998419f, 0.01740387f, 
    -0.00320011f, -0.00548210f, -0.00188207f, 0.00643004f, 0.01448237f, 0.03360924f, 0.03688275f, -0.05648291f, 
    0.02134018f, -0.03750839f, -0.05581601f, 0.03828677f, 0.04116669f, -0.06224339f, 0.02677879f, -0.03022286f, 
    0.06375218f, 0.03158972f, 0.04932838f, 0.00944833f, 0.01630325f, 0.04483600f, -0.02660015f, 0.04102292f, 
    -0.02580212f, 0.00975158f, 0.04095655f, 0.05522256f, -0.00948797f, -0.04973242f, 0.01488925f, -0.03818895f, 
    -0.05649795f, -0.02786123f, 0.02186259f, 0.04136199f, 0.02114656f, 0.04211401f, -0.00216532f, -0.05390831f, 
    0.02345465f, -0.00888280f, -0.03329374f, -0.04230506f, 0.01228902f, -0.04457413f, -0.03306644f, 0.04620423f, 
    0.04109798f, -0.02123394f, -0.00460899f, 0.04034954f, -0.01889538f, -0.06052208f, 0.03796913f, 0.00708497f, 
    -0.03479662f, -0.02273163f, -0.01321614f, 0.03779041f, 0.04577607f, -0.02440464f, 0.00702853f, 0.01680036f, 
    -0.03945638f, 0.03096114f, 0.05214782f, 0.04294852f, 0.01729089f, 0.05496789f, 0.03711104f, -0.01002518f, 
    -0.04105963f, 0.04829824f, -0.04686290f, 0.04398708f, 0.04611468f, -0.01532939f, -0.04220846f, -0.01675530f, 
    0.01462238f, 0.04660240f, 0.03090374f, -0.02501261f, 0.04254016f, -0.05327798f, -0.05420244f, -0.01029889f, 
    -0.03795929f, -0.04738163f, -0.01480088f, -0.02854631f, 0.03077972f, 0.03895024f, -0.02268144f, 0.00831467f, 
    -0.03995653f, 0.00471099f, 0.01515606f, 0.04427999f, -0.06499745f, 0.01652057f, -0.04221268f, 0.04767892f, 
    -0.05929793f, -0.07011006f, -0.05711482f, -0.04936385f, 0.03184770f, -0.04248526f, -0.06508909f, -0.02957530f, 
    -0.00191104f, -0.04451382f, 0.03825716f, 0.01574075f, -0.04155752f, -0.01874506f, -0.01848426f, 0.00599640f, 
    -0.04296247f, 0.01839694f, 0.03457684f, 0.04245261f, -0.03081959f, 0.03947274f, -0.02165356f, -0.01960251f, 
    0.04374117f, -0.03285605f, -0.03122985f, 0.04516959f, -0.01076338f, 0.03061852f, -0.05018749f, 0.00395477f, 
    -0.01488074f, -0.00636424f, 0.02913482f, -0.01376181f, 0.01907628f, -0.05619738f, -0.04863143f, -0.06043234f, 
    -0.01198361f, 0.02030486f, 0.02007408f, 0.04406682f, 0.00990319f, 0.00871395f, -0.05987630f, 0.04977045f, 
    -0.06045755f, 0.04576614f, -0.04569896f, 0.00493841f, 0.04319838f, -0.03604101f, -0.02393971f, -0.02615981f, 
    -0.00055021f, 0.01981456f, -0.03173210f, 0.02084045f, 0.04479907f, -0.06197333f, -0.00940759f, 0.03775432f, 
    0.03832486f, -0.00452440f, 0.03065843f, 0.01993985f, -0.04247310f, -0.05917611f, 0.05357606f, 0.01986146f, 
    -0.04388142f, 0.03928802f, -0.04136666f, 0.02080074f, -0.04028141f, 0.03091399f, 0.00505531f, 0.02070461f, 
    0.02484469f, -0.05536098f, 0.00920464f, 0.05785311f, 0.00044633f, 0.00963101f, 0.01129605f, -0.04843682f, 
    -0.02823381f, -0.04245700f, 0.01335256f, 0.00874100f, -0.03486434f, 0.02663584f, 0.03518153f, -0.05457918f, 
    0.01469881f, -0.04420474f, 0.00952705f, -0.05001080f, 0.00235486f, 0.03377439f, -0.05979909f, 0.00108863f, 
    0.01150806f, -0.03440500f, 0.01093943f, -0.01088815f, 0.04740442f, -0.03066428f, -0.00788202f, -0.01342002f, 
    -0.01333485f, -0.02289911f, 0.04158597f, -0.02073833f, -0.02749676f, -0.00328365f, -0.01756652f, -0.05842153f, 
    -0.03124081f, 0.00827958f, -0.05751555f, -0.02914360f, 0.00093564f, -0.06532022f, 0.01719110f, -0.04632691f, 
    -0.05335568f, -0.04413456f, -0.05701189f, -0.01389949f, -0.04315044f, 0.03664717f, -0.03434921f, -0.03968922f, 
    -0.01079718f, 0.00591491f, 0.02064645f, -0.02942390f, -0.02570746f, 0.03854279f, 0.04445537f, 0.05109100f, 
    0.00405140f, -0.00487460f, 0.02310929f, -0.05026503f, 0.00532381f, 0.02038440f, -0.01696543f, 0.03637284f, 
    0.03433056f, -0.04356407f, -0.03732551f, -0.01630390f, 0.01927236f, -0.04344118f, -0.04343772f, 0.02976586f, 
    -0.06679872f, -0.00341534f, 0.03003420f, -0.05575921f, -0.05999446f, 0.04800118f, 0.03736819f, -0.02047226f, 
    0.01386638f, 0.03845656f, 0.00268368f, -0.02188284f, -0.05784703f, 0.03175557f, -0.04451005f, -0.02538810f, 
    0.03444345f, -0.00280233f, 0.04009772f, -0.06454297f, -0.04756456f, 0.01998366f, 0.04031963f, -0.02419713f, 
    0.03198395f, 0.00834819f, 0.04056405f, 0.02585846f, -0.00622012f, -0.03783023f, -0.02925192f, -0.02446739f, 
    -0.03089081f, -0.05698280f, 0.02552544f, -0.04481413f, -0.03510554f, -0.06437366f, 0.04674071f, 0.01263788f, 
    0.04576758f, -0.05219620f, -0.06664126f, -0.06022621f, -0.03277040f, -0.05134011f, -0.02602424f, 0.00739340f, 
    0.00450593f, 0.03862120f, -0.06134189f, -0.01708642f, 0.01594629f, -0.00566092f, -0.00118878f, -0.02865812f, 
    -0.00313265f, -0.06194745f, -0.03220093f, -0.03295390f, -0.06380876f, 0.01077028f, -0.04728945f, 0.03490395f, 
    0.02076094f, -0.05165989f, 0.04563293f, 0.04077556f, -0.01671980f, 0.06013336f, 0.03536304f, -0.04407521f, 
    0.00954324f, -0.04883100f, 0.04394058f, -0.06111872f, -0.00953152f, 0.01021077f, -0.05658875f, -0.03075276f, 
    -0.00180629f, 0.00742287f, 0.02193085f, -0.01933503f, 0.02976307f, 0.03038050f, -0.05439720f, 0.04538310f, 
    -0.04590136f, -0.04571551f, -0.00844805f, 0.00609709f, 0.02131843f, 0.04146900f, 0.02848979f, 0.00502492f, 
    -0.05792684f, 0.02862570f, 0.02476587f, -0.00162787f, 0.03859746f, 0.02419359f, -0.04255965f, -0.01379091f, 
    0.01241225f, 0.00301621f, 0.01595554f, -0.03689120f, 0.00880274f, -0.02503606f, 0.01319754f, 0.00051980f, 
    -0.00432234f, 0.03178891f, 0.01499949f, -0.00621922f, -0.03477042f, 0.00875514f, -0.02895238f, 0.01423166f, 
    -0.02821318f, 0.02144161f, -0.03668813f, -0.03719275f, 0.00694249f, 0.03692237f, -0.02563871f, -0.02940956f, 
    -0.02871754f, 0.03780069f, -0.04315648f, 0.03673932f, -0.01862941f, 0.01089011f, 0.02759819f, 0.00151988f, 
    -0.01076423f, -0.02375187f, 0.04533238f, -0.02376602f, 0.01705717f, -0.02849782f, -0.02381681f, -0.03454141f, 
    0.00447200f, -0.03392519f, -0.05283595f, -0.03239496f, 0.04299512f, 0.00994720f, -0.05357205f, -0.03426634f, 
    -0.02273054f, 0.03695899f, 0.03114097f, -0.02773478f, -0.04505515f, -0.01336272f, -0.04045795f, -0.00748788f, 
    0.00162605f, 0.02868426f, 0.01458594f, -0.05617594f, -0.05918516f, -0.04885436f, 0.00412531f, 0.01097950f, 
    -0.02001617f, -0.03947085f, -0.03429820f, 0.00923851f, -0.04836860f, -0.00375792f, 0.00153308f, -0.03376706f, 
    -0.03148662f, -0.05955867f, -0.05143404f, -0.06600440f, -0.04074633f, -0.01694421f, -0.04359607f, 0.01409722f, 
    -0.01259694f, -0.06239107f, 0.05480326f, 0.03756137f, -0.05721166f, -0.05144858f, -0.05029546f, 0.00483329f, 
    0.02593128f, -0.04423214f, -0.03488992f, 0.03627674f, 0.00864167f, 0.00414306f, -0.02027848f, -0.00797939f, 
    -0.03771143f, -0.03207034f, -0.01197309f, 0.00685823f, 0.04376281f, -0.04639030f, 0.04510455f, -0.04861520f, 
    0.01347427f, 0.04705114f, 0.05013251f, 0.04805831f, -0.04383340f, 0.04082147f, 0.03497808f, 0.01871393f, 
    -0.02718560f, -0.02269230f, -0.05245587f, -0.05052454f, -0.05669646f, 0.01190879f, -0.03490403f, 0.03953111f, 
    -0.00405811f, -0.05983169f, 0.01396344f, 0.04854268f, -0.02713566f, -0.03659300f, 0.04430997f, -0.05996403f, 
    0.01318369f, 0.20580612f, -0.23987517f, 0.27103180f, -0.06549165f, -0.20763789f, -0.01025744f, -0.08670662f, 
    -0.17600386f, -0.02899917f, 0.00175320f, -0.11472328f, -0.11570319f, 0.13242950f, 0.10653305f, -0.03699788f, 
    -0.16113961f, 0.08629710f, 0.05426107f, -0.02843259f, -0.28198132f, 0.08038627f, -0.01885479f, 0.03111512f, 
    0.12818418f, 0.02727848f, -0.11470088f, -0.03705064f, -0.30940443f, -0.17866637f, 0.22081374f, 0.08917385f, 
    -0.18121606f, -0.08018118f, 0.04353648f, -0.08685859f, 0.05003485f, -0.02662707f, -0.54731959f, 0.11262833f, 
    0.00036767f, 0.25205347f, -0.19349617f, 0.04318267f, 0.02212765f, 0.13827807f, -0.06956588f, -0.02325902f, 
    0.14969318f, -0.07168904f, 0.03656549f, 0.04768545f, -0.05217432f, -0.05620772f, -0.12277675f, -0.17979483f, 
    0.15491052f, -0.21205281f, 0.24742371f, -0.18277349f, 0.08033991f, 0.18482225f, 0.07119406f, 0.35807413f, 
    0.05164191f, 0.04345365f, -0.07216520f, -0.04611609f, 0.19920097f, -0.06950933f, 0.00371584f, 0.23650496f, 
    -0.19337800f, 0.29936573f, -0.31878763f, 0.10340833f, 0.02569642f, 0.14674081f, -0.22975677f, 0.17238358f, 
    0.09075879f, -0.17562562f, 0.36596745f, -0.20845953f, -0.04362134f, 0.04914298f, 0.01693867f, 0.01928817f, 
    0.17885540f, 0.03292250f, -0.09155117f, 0.13634291f, -0.32512388f, -0.01201357f, -0.06644585f, 0.00811368f, 
    0.03307400f, 0.16501975f, 0.00145252f, -0.31578040f, -0.05292508f, -0.16223125f, 0.18422344f, -0.07069322f, 
    -0.14412953f, 0.01350793f, -0.04218155f, -0.16619880f, -0.03397221f, -0.00060091f, -0.31305963f, -0.12181047f, 
    0.13718152f, 0.10362516f, 0.21959856f, 0.06618691f, -0.03078542f, 0.07694874f, 0.07072832f, 0.04537451f, 
    0.16084956f, 0.05647558f, -0.04810768f, -0.00688959f, 0.20221065f, 0.17349248f, 0.21680516f, 0.03475453f, 
    -0.25717962f, 0.05180698f, 0.00100965f, 0.04570760f, -0.02151681f, -0.09547513f, -0.20930347f, -0.50210416f, 
    -0.05761084f, -0.32167169f, 0.12961352f, -0.11092667f, 0.09486725f, -0.04838589f, 0.15792467f, 0.07070619f, 
    0.01916047f, -0.00805900f, 0.06031721f, 0.02781005f, 0.23819777f, 0.00259766f, 0.19566706f, 0.16735429f, 
    0.12502237f, 0.49354652f, 0.41591066f, -0.26234397f, 0.09317413f, -0.32447842f, 0.24748102f, -0.16448607f, 
    -0.05268596f, 0.28952494f, -0.01935998f, 0.11734768f, -0.17068498f, 0.37178153f, -0.11761155f, 0.11615275f, 
    -0.23136196f, -0.12188629f, -0.09642849f, -0.08092141f, 0.02718374f, 0.22004564f, 0.10359523f, 0.15744621f, 
    -0.03562068f, 0.08427091f, 0.29399574f, 0.02025047f, 0.21042052f, -0.13882980f, -0.07745542f, 0.00960032f, 
    -0.10469397f, 0.02571842f, 0.07098150f, 0.11960009f, -0.13712880f, 0.39722794f, 0.24274924f, -0.23048681f, 
    0.12833957f, 0.04681849f, 0.24261887f, -0.23167060f, -0.06839713f, -0.12414551f, 0.11951768f, -0.06670074f, 
    0.02124939f, -0.18997774f, 0.25649515f, -0.15652415f, 0.00479703f, 0.02570059f, 0.13829803f, 0.07369996f, 
    0.06513411f, -0.09795137f, -0.26099142f, 0.07542625f, 0.38619745f, 0.05671665f, 0.26635361f, -0.09048946f, 
    -0.30268466f, -0.22079423f, 0.02408390f, 0.07924699f, -0.04303823f, -0.06138658f, 0.07014191f, 0.08350837f, 
    0.02948559f, -0.53606814f, -0.06157928f, 0.01100612f, 0.30693251f, 0.28120729f, 0.01799467f, 0.00511689f, 
    -0.19899113f, 0.11556963f, -0.05022019f, 0.14035253f, -0.08420354f, 0.14154486f, -0.07412045f, -0.21108902f, 
    0.17545117f, 0.08595104f, 0.13844742f, 0.16264489f, 0.34241402f, -0.22870417f, -0.13266358f, -0.06351099f, 
    0.26427111f, 0.01868814f, 0.10085151f, -0.15516248f, 0.37300003f, 0.02543487f, 0.17203748f, 0.11063410f, 
    0.06858594f, -0.01750524f, 0.14327209f, 0.30589783f, 0.15019470f, 0.05199226f, -0.39144093f, -0.41599727f, 
    0.02559369f, 0.23571587f, 0.08866654f, 0.08182164f, -0.14738706f, 0.06998678f, -0.36762214f, -0.03884942f, 
    0.04642569f, -0.11011275f, 0.03790320f, -0.17734680f, 0.10974201f, -0.19518736f, 0.16763340f, 0.43913323f, 
    0.06720567f, -0.06956907f, 0.04982058f, -0.09737697f, 0.12264760f, 0.03262087f, 0.03412810f, 0.19284658f, 
    -0.09180545f, 0.16993292f, 0.19498636f, -0.23132287f, 0.04496623f, -0.01771128f, 0.04232094f, -0.14232844f, 
    0.00821314f, 0.25226748f, -0.46546379f, -0.10995622f, -0.11353852f, -0.07262003f, 0.00472388f, -0.09155202f, 
    0.12641187f, -0.09184171f, 0.20798886f, 0.18676946f, 0.04548341f, -0.02267750f, -0.13112439f, 0.03693433f, 
    -0.08299813f, -0.13319448f, 0.02806764f, 0.48470557f, -0.50772470f, 0.02400712f, -0.01334852f, 0.05112551f, 
    -0.02320817f, 0.08621994f, -0.08866737f, 0.06620701f, 0.12817000f, 0.25242165f, 0.13124642f, 0.17882915f, 
    0.11367301f, -0.13480733f, 0.17513199f, -0.08059725f, -0.03475473f, 0.17358658f, 0.00298203f, -0.16226438f, 
    0.05890804f, -0.00989208f, -0.06965032f, 0.10918415f, -0.02464033f, 0.03397513f, -0.66336244f, -0.25904110f, 
    -0.19718744f, 0.14403766f, 0.21595801f, -0.01229084f, 0.01028915f, 0.12854667f, 0.16610722f, -0.03428214f, 
    -0.49023652f, 0.17638302f, 0.13118930f, -0.02582078f, 0.20236571f, -0.05118741f, -0.07965285f, 0.05165713f, 
    -0.12445726f, 0.17486738f, -0.29561052f, 0.01895001f, -0.17037816f, -0.04682066f, -0.06244231f, 0.13890377f, 
    0.10513972f, -0.19660017f, 0.19636329f, -0.02600489f, -0.13701041f, -0.16214631f, -0.19186363f, 0.07025457f, 
    0.16177988f, 0.13966176f, 0.15453041f, 0.18492785f, 0.07140142f, -0.13398537f, -0.10810348f, 0.02453243f, 
    0.22028276f, 0.02587302f, 0.25316933f, 0.24358292f, 0.50026381f, -0.46647093f, -0.14999974f, -0.02462042f, 
    -0.19155304f, 0.14900000f, 0.06241082f, -0.05604607f, -0.07680061f, 0.16417022f, -0.03585611f, -0.18731409f, 
    0.01824668f, -0.00063680f, -0.02038469f, 0.14938465f, 0.02995562f, -0.47922242f, -0.28491846f, 0.01781824f, 
    0.08798102f, 0.02623919f, 0.02681138f, -0.09713562f, -0.00065192f, -0.15674911f, 0.32283410f, 0.14121988f, 
    0.00047982f, -0.05547842f, 0.15036143f, 0.03337061f, 0.17777821f, -0.13501441f, -0.11131286f, 0.04269351f, 
    0.12064596f, 0.02024959f, -0.25066435f, -0.10922501f, -0.19212516f, 0.06902097f, 0.07087575f, 0.19741340f, 
    0.15747547f, -0.20680010f, -0.14250849f, 0.07497027f, 0.10184100f, 0.07902681f, -0.02057126f, -0.08723845f, 
    0.19814220f, -0.12136857f, -0.78777170f, 0.07364453f, 0.18812516f, 0.05676243f, 0.04753168f, 0.17807655f, 
    -0.10795119f, -0.17571013f, 0.46732756f, 0.35189837f, -0.21794881f, 0.06296007f, 0.03492551f, 0.04738250f, 
    0.12169708f, -0.01550881f, 0.04974985f, -0.03685143f, 0.18670681f, -0.07828254f, -0.06309026f, 0.01208952f, 
    -0.05393656f, 0.15752845f, 0.15684539f, 0.15503696f, 0.06662606f, -0.01675889f, -0.05191250f, -0.06180544f, 
    -0.20024353f, -0.17740953f, -0.23354541f, 0.01289414f, -0.04029447f, 0.52339149f, -0.16680449f, -0.01855502f, 
    0.22513656f, 0.17222731f, 0.03271633f, -0.08845590f, 0.10055473f, 0.01851562f, -0.14245319f, -0.00918310f, 
    -0.00887052f, -0.10340254f, 0.01706157f, -0.20502239f, -0.12965983f, 0.14208563f, 0.08207466f, -0.79622287f, 
    0.17304681f, 0.05315871f, 0.06815815f, 0.03285097f, -0.08157998f, -0.16890155f, 0.04013022f, 0.08992189f, 
    0.21611646f, -0.13666260f, 0.05942469f, 0.12437673f, -0.10767653f, -0.12316150f, 0.03805284f, 0.11771718f, 
    0.03588359f, -0.16267587f, -0.39294222f, -0.16568257f, -0.03810742f, -0.02339428f, 0.04516485f, 0.06967384f, 
    -0.26585054f, 0.15124416f, 0.16375816f, -0.01635478f, 0.20691779f, 0.10319481f, -0.08957859f, 0.06369187f, 
    0.15512624f, -0.11349251f, -0.05060599f, -0.11080313f, 0.12576714f, -0.26563868f, -0.15149817f, -0.15198594f, 
    0.03768191f, -0.06640456f, 0.05655025f, -0.03520123f, -0.03852286f, -0.40947786f, 0.13975182f, 0.15173709f, 
    0.09764405f, 0.22614180f, -0.21214823f, -0.09211867f, -0.05197222f, 0.37340909f, 0.14474449f, -0.02499526f, 
    -0.40444189f, 0.04915266f, 0.00196711f, -0.13507043f, 0.27113023f, -0.08406202f, -0.12400555f, 0.29497927f, 
    0.13268846f, -0.20169374f, -0.13281839f, 0.23536216f, -0.04091557f, 0.04286534f, 0.13937539f, -0.15855548f, 
    -0.52155608f, 0.02512028f, 0.18620627f, -0.00831535f, 0.02599888f, -0.06647342f, 0.00809902f, 0.09687764f, 
    0.02804782f, -0.01706222f, 0.02229104f, -0.04102651f, -0.01786685f, -0.00728572f, -0.03156326f, 0.02349566f, 
    0.04483756f, -0.03540312f, 0.00929712f, 0.05128442f, 0.03479522f, -0.04024482f, -0.01435359f, 0.02346050f, 
    -0.00137960f, 0.00882960f, 0.02649336f, 0.04813132f, -0.03534891f, 0.00523495f, -0.05055292f, -0.06151275f, 
    0.04454779f, -0.01865729f, -0.06012395f, 0.00653441f, 0.05188026f, -0.02399972f, 0.01648505f, -0.03236336f, 
    -0.02413721f, 0.05556338f, 0.04016371f, -0.04114880f, -0.01946539f, -0.05404178f, 0.01382597f, -0.01459895f, 
    -0.04521367f, -0.04032803f, 0.05049753f, 0.03267191f, 0.03649382f, -0.03277292f, -0.00963254f, 0.03782997f, 
    0.01814566f, -0.06249396f, -0.05798553f, -0.03464970f, -0.02520703f, 0.03056923f, 0.03804867f, 0.04191271f, 
    -0.04210360f, -0.05025792f, -0.03402402f, -0.01016081f, 0.02670803f, 0.03071830f, 0.05467356f, 0.02768015f, 
    -0.06294065f, -0.01069674f, 0.02418384f, -0.06023325f, 0.03126623f, 0.03863269f, -0.05704820f, -0.04981507f, 
    -0.04599100f, -0.02686882f, -0.05742395f, -0.05795648f, -0.05190854f, -0.00791201f, -0.05417932f, -0.05483052f, 
    -0.05146083f, 0.04030343f, -0.05347506f, -0.01165226f, -0.04450607f, -0.02162797f, -0.02564649f, -0.03845127f, 
    -0.04882114f, -0.02543809f, -0.02574178f, -0.01471104f, 0.05443351f, 0.01447193f, 0.01131759f, -0.05218324f, 
    0.01644492f, 0.04500578f, 0.00055877f, -0.03298825f, 0.02997984f, 0.02452584f, 0.01101256f, 0.04843796f, 
    0.04830799f, -0.01751137f, -0.04706853f, -0.01919864f, -0.03840738f, -0.03592304f, -0.00312966f, 0.01616790f, 
    0.05096480f, 0.00174312f, -0.05519379f, -0.03448804f, 0.04527180f, 0.00613868f, 0.00511932f, 0.02143643f, 
    -0.04604019f, -0.02544214f, -0.01725735f, -0.01345631f, -0.02657423f, -0.03624655f, 0.04592406f, -0.04063264f, 
    0.01337802f, -0.04838047f, 0.01044004f, 0.03583677f, 0.00120919f, -0.02439524f, -0.03401759f, 0.03335205f, 
    0.02468904f, -0.02625086f, 0.00147422f, -0.04692409f, -0.05286419f, -0.05267671f, -0.06603564f, 0.02532242f, 
    0.02391394f, 0.00281196f, 0.03832530f, -0.03611173f, 0.03445692f, -0.02358115f, 0.05218763f, 0.00532305f, 
    0.04657806f, 0.03655082f, 0.03848599f, 0.03906817f, -0.04248011f, 0.01159501f, -0.00959061f, 0.00371299f, 
    -0.02638514f, -0.02271200f, -0.05124172f, -0.03456462f, -0.05486672f, -0.00181730f, 0.01015123f, -0.05572330f, 
    -0.00586723f, 0.00163346f, -0.04167821f, 0.01792172f, -0.03154717f, -0.00328517f, 0.01092439f, -0.02581887f, 
    0.04351623f, 0.04256814f, -0.02613119f, -0.00081820f, -0.02075176f, -0.03411812f, 0.01750616f, 0.02263008f, 
    -0.04857210f, 0.04986235f, 0.00030368f, 0.00739691f, -0.01366176f, -0.05124385f, -0.00769702f, -0.02370233f, 
    0.00547289f, -0.00271970f, -0.01800524f, -0.02426807f, -0.01072138f, 0.03883211f, 0.03283131f, 0.00879350f, 
    0.00425194f, -0.01856001f, -0.05422119f, -0.00446917f, -0.03885668f, 0.04378726f, 0.01535556f, -0.01919717f, 
    -0.03571352f, 0.01457457f, -0.00198423f, -0.03521760f, -0.05474776f, -0.06595904f, 0.04422868f, 0.04275631f, 
    0.03873858f, 0.00050443f, -0.03367345f, -0.02891472f, 0.01872360f, -0.04801635f, -0.02665853f, -0.02026037f, 
    -0.00131522f, -0.02105621f, 0.00023352f, -0.04494962f, 0.02143327f, 0.00395950f, -0.06183143f, 0.02754359f, 
    0.00988658f, 0.04025054f, -0.05803274f, 0.03958213f, -0.01393144f, -0.06748798f, -0.06361085f, -0.03128198f, 
    -0.06084204f, 0.04570406f, -0.04208848f, -0.06190788f, -0.00701825f, -0.00802537f, -0.06450074f, -0.00007665f, 
    0.01533171f, 0.00825607f, 0.02664947f, 0.03356187f, -0.02588910f, 0.03867981f, -0.02143063f, -0.01845120f, 
    -0.05989087f, -0.04977347f, 0.01331500f, -0.01258935f, -0.04595868f, -0.06257886f, 0.00185515f, 0.01730947f, 
    -0.05689064f, 0.05548455f, 0.03785067f, 0.01438270f, 0.02846652f, -0.03067494f, 0.04283611f, -0.06280310f, 
    -0.04567428f, -0.00832037f, -0.00267174f, -0.04941696f, 0.04084000f, 0.01862891f, 0.04134329f, 0.04286126f, 
    -0.06725339f, 0.04553291f, 0.01519293f, -0.00535932f, -0.05768639f, 0.01449298f, -0.03032166f, 0.01656143f, 
    -0.20776440f, -0.21446665f, 0.06159355f, -0.19859114f, -0.06889915f, -0.31090322f, 0.08555882f, 0.04354880f, 
    -0.09449818f, 0.10627600f, -0.00187379f, 0.05304817f, 0.25575736f, -0.07212349f, 0.27202284f, 0.09312858f, 
    0.18644619f, 0.18384795f, 0.11489193f, -0.27605933f, -0.05651852f, 0.02704927f, 0.08917670f, 0.16466545f, 
    0.12368230f, -0.01801145f, -0.07867958f, -0.43225652f, -0.19505380f, 0.05620919f, 0.01045552f, 0.20526233f, 
    0.05623755f, -0.37466705f, 0.13619381f, 0.03972026f, 0.00601300f, -0.15325645f, -0.18134363f, -0.04632294f, 
    0.26759693f, 0.28449908f, -0.11200788f, 0.37151712f, -0.18688394f, 0.13448681f, 0.02241911f, 0.20404772f, 
    -0.08606905f, -0.16257390f, 0.07740851f, 0.09610497f, -0.03878176f, 0.25264043f, 0.09452328f, 0.45798141f, 
    -0.04486797f, -0.12288697f, -0.01615962f, -0.30573350f, -0.21896641f, 0.05922163f, 0.00402399f, 0.32196826f, 
    0.17287654f, 0.00191943f, 0.02058666f, -0.12612116f, -0.13511108f, -0.11329519f, 0.29842120f, -0.16123033f, 
    -0.30893353f, -0.02365460f, -0.10507686f, 0.11815426f, 0.16553017f, 0.15012397f, 0.06673978f, -0.11773052f, 
    -0.18170407f, -0.07320049f, -0.04797253f, 0.18245271f, 0.15304182f, 0.14484012f, 0.13626589f, 0.15881427f, 
    0.12332425f, 0.00641504f, -0.31365710f, -0.14305444f, 0.10862352f, -0.03461276f, 0.07553391f, 0.01549927f, 
    -0.22471017f, 0.04495215f, -0.23882732f, -0.23450185f, -0.07752962f, -0.26003024f, 0.09418514f, 0.01916149f, 
    -0.09332938f, -0.08208612f, -0.14275859f, -0.02419242f, -0.48767316f, -0.01605591f, -0.00829449f, 0.12857296f, 
    0.15433630f, 0.08661371f, 0.02529262f, 0.04749262f, 0.09956651f, 0.03050272f, 0.23643206f, 0.12856972f, 
    -0.01923095f, -0.02413959f, 0.06697562f, -0.05150086f, 0.38599536f, -0.02792198f, -0.02976637f, -0.23706703f, 
    -0.11350394f, 0.00591914f, 0.15014358f, 0.15477662f, -0.07794693f, -0.16228467f, -0.06370434f, -0.12214696f, 
    -0.49996540f, 0.00670146f, 0.19131844f, 0.22599640f, 0.06304725f, 0.03977743f, 0.03713790f, -0.03391444f, 
    0.00050038f, -0.00658243f, -0.03852834f, -0.10892417f, 0.05008756f, 0.02616593f, 0.08908711f, 0.13288368f, 
    0.16752850f, -0.13058968f, 0.10152753f, 0.10824932f, 0.03866466f, -0.10453606f, 0.06318846f, 0.06915520f, 
    0.08339734f, -0.03352673f, -0.34478837f, -0.03498077f, -0.22817761f, -0.05480080f, 0.00877985f, 0.10307569f, 
    0.10567742f, -0.23284592f, -0.06519184f, 0.39437574f, -0.12402217f, -0.00666495f, -0.06084181f, -0.24605814f, 
    -0.13372828f, 0.07706895f, -0.00891319f, 0.31454512f, -0.42983609f, 0.22456415f, -0.35034230f, -0.01551445f, 
    -0.10706649f, 0.08060545f, 0.06498951f, 0.13260621f, -0.28340143f, -0.15788013f, -0.00548014f, 0.06946298f, 
    0.09887153f, 0.04620445f, 0.04758717f, -0.04630512f, -0.21451628f, -0.12027330f, 0.00299476f, 0.04223951f, 
    -0.05840109f, -0.10948138f, -0.14628153f, 0.01289003f, 0.32016549f, -0.05098331f, -0.04521314f, 0.11292917f, 
    -0.09975088f, -0.27316639f, 0.18141340f, 0.16593182f, 0.03933733f, -0.05699334f, -0.00763553f, 0.04015237f, 
    -0.16114217f, -0.12197749f, 0.09021250f, 0.03216874f, 0.02659232f, -0.11125755f, -0.00539907f, 0.09602153f, 
    -0.01574149f, 0.14921030f, -0.12750080f, 0.01965209f, -0.04241622f, -0.12823439f, 0.11772770f, 0.30735022f, 
    -0.03136433f, 0.27427876f, 0.36858726f, -0.17283736f, -0.01332570f, -0.04115375f, 0.03438225f, -0.05431079f, 
    0.07405308f, 0.04190624f, -0.16051891f, -0.30512604f, 0.28978643f, -0.01915436f, -0.05386986f, 0.05271588f, 
    -0.13594423f, -0.03770440f, 0.21608824f, -0.13727728f, 0.04745698f, 0.34659094f, 0.08229364f, -0.21660897f, 
    -0.26870531f, -0.17352751f, 0.09796616f, 0.07655073f, 0.04835106f, -0.35387108f, -0.25933102f, -0.12238839f, 
    -0.06403864f, -0.02978146f, -0.07296847f, 0.05857678f, -0.10141535f, -0.17726271f, -0.21026658f, -0.52381134f, 
    -0.13301653f, 0.00922498f, -0.19896211f, -0.10131843f, 0.04026804f, -0.10007474f, 0.01761577f, 0.24963111f, 
    0.30862731f, 0.25612187f, -0.17319866f, -0.16586339f, -0.06247571f, 0.04373978f, 0.15071125f, 0.02337275f, 
    0.01306652f, 0.02770333f, -0.00654314f, 0.01107841f, -0.01190635f, -0.03070385f, -0.06813538f, 0.05113642f, 
    -0.01366551f, 0.01079324f, -0.05228888f, 0.01265688f, -0.00889842f, -0.02064823f, -0.02705031f, -0.02838777f, 
    -0.03180245f, 0.03996882f, 0.03018623f, -0.04713804f, 0.01370261f, 0.04336033f, -0.04963403f, -0.01257115f, 
    0.00729188f, 0.04856761f, 0.02646938f, 0.05005707f, 0.02453908f, -0.04897476f, 0.01119760f, -0.03163708f, 
    0.00411829f, 0.01479469f, -0.03097481f, -0.05243385f, -0.03866495f, 0.01681704f, -0.05618374f, 0.03738366f, 
    0.00704684f, 0.04132469f, 0.02676938f, 0.01626743f, 0.05918719f, -0.03622045f, 0.03357527f, 0.02550888f, 
    -0.01396980f, -0.03391570f, -0.01664866f, -0.06444871f, 0.00676154f, 0.04267652f, 0.03638813f, 0.03901527f, 
    -0.04570707f, -0.04278971f, -0.02216259f, -0.01362061f, 0.01205677f, 0.03357662f, 0.00108614f, 0.04473620f, 
    0.04254202f, 0.04373690f, -0.02172222f, 0.00032463f, -0.00447847f, -0.01651581f, -0.05019248f, -0.07693262f, 
    -0.00293409f, 0.01717689f, -0.00428296f, -0.02502487f, 0.02399316f, 0.00869534f, -0.05853094f, -0.02307235f, 
    -0.01932904f, -0.02534991f, 0.02143471f, -0.01113097f, 0.02895451f, 0.01831195f, -0.04626106f, 0.04331300f, 
    -0.03453474f, 0.00602102f, 0.03555717f, 0.03088531f, 0.02327988f, -0.03719620f, -0.01257075f, -0.04159606f, 
    0.03054837f, 0.00009563f, -0.06512859f, -0.04850166f, 0.00929375f, -0.01420699f, 0.00344985f, 0.03968424f, 
    0.01230821f, 0.00308643f, 0.02466942f, -0.00140714f, 0.02924362f, -0.00118653f, -0.00598621f, -0.04132770f, 
    -0.02014858f, -0.01329174f, -0.03353758f, -0.01583969f, -0.05410308f, -0.06944454f, -0.06782755f, -0.03111900f, 
    -0.01875380f, 0.04206815f, -0.02730999f, 0.03280817f, -0.01399894f, 0.00690803f, 0.02190397f, -0.06778833f, 
    -0.05197530f, -0.02196776f, 0.05261958f, -0.04338556f, -0.00453113f, 0.00073380f, 0.02451781f, 0.04280785f, 
    0.04024641f, 0.01680148f, -0.01505661f, 0.02598097f, 0.03038148f, 0.01034784f, 0.03252143f, 0.02663933f, 
    0.00246087f, -0.04522539f, -0.05387659f, -0.00194956f, -0.03664173f, -0.01056966f, 0.03050778f, -0.05945590f, 
    -0.05370802f, 0.00349051f, -0.06324644f, -0.06225985f, 0.00123646f, 0.03472123f, -0.03929003f, 0.02031592f, 
    -0.03031689f, 0.04459008f, 0.03338164f, 0.00626564f, 0.04681370f, -0.01731171f, -0.00640057f, -0.02677042f, 
    -0.01182767f, 0.01261506f, 0.04494635f, -0.02436421f, -0.06407207f, -0.01620782f, -0.02090849f, -0.05167069f, 
    0.04494618f, 0.04218695f, 0.01443706f, 0.03740572f, 0.02138150f, 0.01402994f, 0.02618634f, -0.05661313f, 
    -0.03059989f, -0.04575158f, 0.02190511f, -0.00736315f, 0.02689897f, -0.04336747f, -0.04671327f, -0.03127930f, 
    -0.03470663f, -0.03218502f, -0.00031199f, -0.00973280f, -0.04898215f, -0.00579281f, -0.04051089f, -0.02715673f, 
    0.03974810f, 0.00580944f, 0.03081710f, -0.02455719f, 0.01872992f, 0.03273546f, -0.05467689f, -0.05398826f, 
    -0.04581495f, -0.02611893f, 0.00203818f, 0.00998643f, 0.02152101f, 0.04474351f, -0.03970680f, -0.04061829f, 
    0.04420264f, 0.03116611f, -0.05058333f, -0.05425863f, -0.06225910f, 0.02085444f, 0.04750329f, 0.04253579f, 
    0.03097435f, -0.05349037f, -0.05963366f, 0.03443980f, -0.01010351f, 0.02522650f, 0.02845771f, 0.01769410f, 
    0.01757412f, 0.02699409f, -0.03067459f, -0.04582506f, -0.01707125f, -0.01764841f, 0.04811583f, -0.00875147f, 
    -0.01093376f, 0.03230855f, -0.04533541f, 0.00526052f, -0.04705152f, -0.00565493f, -0.04382397f, -0.05703500f, 
    -0.03375574f, -0.02189285f, 0.01075413f, 0.01716615f, 0.03302877f, -0.07145737f, -0.04845719f, 0.01850650f, 
    0.03365704f, -0.01431602f, 0.03793756f, 0.04121646f, -0.05200842f, -0.05068763f, -0.01895658f, -0.05443054f, 
    -0.01250520f, -0.02501177f, -0.02927073f, -0.01767544f, -0.04339961f, -0.06653026f, 0.01689438f, 0.00811207f, 
    -0.06896508f, -0.04008098f, 0.02084969f, 0.01015844f, -0.04281074f, -0.02756894f, 0.02803843f, -0.00967433f, 
    0.00344258f, -0.03797015f, 0.00861729f, -0.04969548f, -0.05052602f, 0.04081151f, -0.04999036f, 0.03478907f, 
    -0.03741773f, 0.03419978f, -0.56130064f, 0.02114404f, 0.01422246f, -0.04832041f, -0.00507557f, -0.18623969f, 
    -0.19952019f, 0.11763664f, -0.01370813f, 0.23906162f, 0.05105390f, 0.02599051f, -0.07750160f, 0.14090668f, 
    0.00572770f, 0.17217723f, 0.44812581f, -0.26422778f, 0.01265390f, -0.22501060f, -0.09697555f, 0.12340905f, 
    0.17070986f, 0.01013471f, 0.14962229f, -0.38371131f, -0.31748015f, 0.42084551f, 0.13485642f, 0.06859651f, 
    -0.17083822f, 0.04666087f, 0.02131931f, -0.02268733f, -0.01509265f, 0.10207293f, -0.18247382f, -0.20684974f, 
    0.06600092f, 0.05290239f, 0.07377929f, 0.25978383f, 0.18469448f, 0.15538919f, 0.24923845f, 0.07137998f, 
    -0.09524019f, 0.01521728f, 0.01569260f, -0.17086133f, 0.08045075f, -0.00004550f, -0.12503034f, 0.15897794f, 
    0.22897762f, 0.14366499f, 0.10984755f, 0.33622542f, -0.05903475f, 0.00444838f, -0.14526261f, 0.43774295f, 
    0.02047842f, 0.15531343f, 0.11463377f, 0.18501954f, -0.10355372f, -0.28463733f, -0.01176422f, 0.02017979f, 
    -0.10107542f, -0.13832723f, -0.17158000f, -0.03513320f, 0.19277228f, 0.03005872f, 0.12734573f, -0.05097699f, 
    0.02680963f, 0.11373567f, -0.17740834f, -0.11101504f, 0.05624781f, 0.11673328f, -0.08821607f, 0.18208887f, 
    -0.10356457f, 0.01347737f, -0.25028357f, -0.34099808f, -0.14056951f, 0.02690848f, -0.03147228f, -0.22102304f, 
    -0.10528518f, -0.25416532f, -0.21635465f, -0.25755677f, -0.01093296f, -0.18231566f, 0.01232300f, -0.09703146f, 
    -0.41012502f, 0.10374881f, 0.24111848f, 0.11793857f, -0.25103113f, -0.22170825f, -0.26849818f, -0.00810394f, 
    0.07860129f, -0.00984880f, 0.23263456f, -0.04079799f, 0.01654474f, -0.22346507f, 0.15440966f, 0.21628141f, 
    0.07311135f, 0.13957131f, -0.03215958f, 0.09583838f, -0.03922573f, 0.16561969f, 0.12258830f, -0.09377698f, 
    0.01031460f, -0.01502885f, 0.12315800f, 0.02829230f, 0.07652138f, 0.09347876f, 0.13855761f, 0.16024226f, 
    -0.27131599f, -0.14021355f, -0.02945915f, 0.08480841f, -0.10529245f, 0.11935366f, 0.03287778f, 0.00904459f, 
    -0.03285361f, -0.12503771f, 0.08251279f, -0.03452569f, 0.20491195f, 0.09982214f, 0.15789807f, 0.11476189f, 
    -0.22452880f, 0.08693495f, 0.49373236f, 0.08495905f, -0.16665772f, 0.05180042f, -0.06928699f, -0.13742849f, 
    -0.00254838f, 0.16154632f, -0.22596723f, 0.12065798f, -0.18296140f, 0.09498379f, -0.06882118f, 0.03620988f, 
    0.01417092f, 0.03614791f, 0.02680641f, 0.58750182f, 0.01676263f, -0.05757715f, 0.06420883f, 0.17243050f, 
    0.28861716f, 0.12340546f, -0.07349873f, -0.19438767f, -0.19357574f, -0.14831999f, -0.24360585f, -0.17395774f, 
    -0.03449016f, -0.12305558f, -0.08174260f, 0.18640414f, 0.01368970f, 0.22298338f, 0.21933635f, -0.02011877f, 
    0.27543423f, -0.08767378f, -0.05237041f, -0.03863125f, 0.01192647f, 0.16208722f, 0.07591444f, 0.10098661f, 
    0.26096013f, 0.31201214f, 0.32389116f, 0.04742857f, -0.04348439f, -0.19464397f, -0.15228400f, -0.15253802f, 
    -0.09513123f, -0.36220601f, 0.04969947f, 0.12289266f, 0.09307852f, 0.18099451f, 0.10940465f, -0.01318296f, 
    -0.57944643f, 0.21574193f, 0.49252602f, -0.12506448f, 0.03867378f, 0.05200002f, -0.12030149f, -0.00723547f, 
    -0.14396115f, -0.21450585f, -0.13631682f, 0.12255087f, -0.05955464f, 0.02318925f, -0.21336356f, 0.09769725f, 
    0.05359785f, -0.02930163f, 0.28406256f, -0.07854021f, 0.19308189f, -0.02022736f, 0.14610651f, -0.13767685f, 
    -0.08933566f, 0.15910031f, -0.09001239f, -0.41618770f, -0.02904666f, -0.24394487f, -0.03056955f, 0.00820478f, 
    0.20334685f, -0.14838445f, 0.00289012f, 0.03120114f, -0.09225791f, 0.19003186f, 0.22245011f, 0.17173049f, 
    0.06186416f, 0.20966260f, 0.36263156f, 0.03189337f, -0.08683456f, 0.04392619f, -0.32920092f, -0.73526216f, 
    0.18106095f, 0.04421454f, -0.19443686f, -0.09707294f, -0.24243985f, -0.10149974f, -0.16922083f, -0.46887341f, 
    0.15948109f, 0.10425227f, -0.11415987f, -0.05482414f, 0.05918239f, -0.09882055f, -0.22110672f, 0.34920642f, 
    0.23006709f, 0.13368206f, -0.07287592f, 0.03069621f, 0.03280244f, -0.05377529f, -0.02548486f, -0.03759021f, 
    0.35519835f, 0.00321177f, -0.14683174f, -0.13017339f, -0.28228867f, -0.06560756f, -0.03236413f, -0.16582537f, 
    0.12757087f, 0.09112788f, -0.09968546f, -0.39650062f, -0.04824724f, 0.07519853f, 0.07670210f, 0.03665605f, 
    0.15131527f, 0.03182544f, -0.00715998f, -0.07665668f, -0.27384213f, 0.05560300f, 0.10526210f, -0.02821245f, 
    0.04469430f, 0.06009107f, -0.04845341f, 0.30094722f, -0.20563811f, 0.04668314f, -0.20602825f, 0.04325756f, 
    0.00652044f, -0.26639479f, 0.04903306f, 0.09307164f, -0.49950805f, -0.06940140f, -0.47241533f, -0.00322387f, 
    0.04737999f, -0.07417045f, -0.12691702f, 0.14075971f, 0.18208371f, 0.32540235f, 0.25708300f, -0.03188497f, 
    0.31298953f, 0.14465915f, 0.00037819f, -0.22269511f, -0.09572406f, 0.03857523f, -0.09242632f, 0.12651248f, 
    0.09187550f, 0.15500791f, 0.07017832f, 0.06386293f, 0.01653657f, 0.16975036f, -0.02276421f, 0.06384268f, 
    0.00686235f, -0.06537598f, 0.07083254f, 0.12552340f, -0.01957249f, -0.00627176f, -0.02033756f, 0.02823141f, 
    0.20521756f, 0.02152469f, -0.11977116f, -0.22741772f, 0.23845433f, 0.10152370f, 0.06831183f, 0.00738280f, 
    0.05548940f, 0.83299595f, 0.09965046f, -0.15889473f, -0.07325127f, 0.06362532f, 0.15725328f, -0.17632724f, 
    0.17938937f, -0.05226351f, 0.16007894f, 0.19876601f, 0.13329190f, -0.17250019f, -0.02075553f, 0.07000418f, 
    -0.14540090f, 0.03156886f, 0.03906970f, 0.28569812f, -0.10588725f, -0.11308272f, -0.00879788f, -0.03849086f, 
    0.25661835f, -0.03210895f, 0.06443851f, -0.07714909f, 0.35541424f, -0.00517669f, 0.01770047f, -0.25089732f, 
    -0.09896637f, -0.21518342f, 0.09787046f, -0.16744488f, 0.01022987f, -0.20005488f, -0.04248186f, 0.14398843f, 
    0.23260096f, -0.03058118f, 0.11795096f, -0.06769916f, 0.20079827f, 0.05448296f, 0.20795730f, 0.04217360f, 
    -0.21341000f, 0.03248768f, 0.09133431f, -0.18886350f, -0.10012245f, -0.14535645f, -0.03448134f, 0.32734567f, 
    0.20807162f, -0.06346165f, -0.22745803f, 0.28772548f, -0.01248203f, -0.04842017f, 0.11477199f, -0.12851098f, 
    -0.36537227f, 0.30528370f, -0.01351857f, 0.05119833f, 0.06385975f, 0.08077056f, 0.16404471f, 0.04215739f, 
    0.00839376f, -0.23746394f, 0.22077262f, -0.11075388f, 0.23975694f, 0.06003813f, 0.07521083f, 0.01097322f, 
    0.24597701f, -0.00032882f, -0.13018866f, 0.09126326f, -0.07927323f, 0.12212393f, 0.05622302f, 0.02123957f, 
    -0.03331063f, 0.12368273f, -0.06425712f, -0.27544299f, 0.32450595f, 0.15174028f, -0.16419986f, -0.06955272f, 
    0.04082610f, 0.01128563f, -0.00915716f, -0.00146867f, 0.30364466f, -0.19744654f, -0.37855932f, -0.03010935f, 
    -0.16516370f, 0.15735278f, -0.06033915f, -0.04056885f, -0.00352657f, 0.09522533f, -0.01353428f, 0.16820933f, 
    0.15104599f, 0.23504233f, -0.07823436f, -0.01149588f, 0.01460481f, 0.08744221f, 0.18373980f, 0.00791736f, 
    0.17474505f, -0.05929595f, -0.14271697f, 0.19775037f, -0.08525176f, 0.10028888f, 0.03660127f, 0.57140219f, 
    -0.44593614f, -0.23530687f, 0.02015074f, 0.05389692f, -0.26737657f, 0.31536919f, -0.23114665f, 0.19986232f, 
    0.38222638f, 0.15373357f, -0.07703621f, -0.23316497f, -0.17192899f, 0.04226384f, 0.12752827f, -0.11502226f, 
    -0.16058740f, -0.07855801f, -0.17478715f, -0.23928162f, -0.07342412f, 0.05608232f, 0.10161549f, 0.07766996f, 
    -0.03163471f, -0.23265886f, 0.34943411f, -0.02528165f, -0.02695489f, -0.02240040f, -0.10585359f, 0.24931479f, 
    -0.00660596f, 0.11682271f, 0.05886256f, -0.06229741f, 0.15153122f, 0.00261168f, 0.01416202f, 0.11304214f, 
    -0.21027347f, 0.16984388f, -0.09263261f, 0.21770455f, 0.10258068f, 0.04569997f, -0.09080280f, 0.20799387f, 
    0.01858950f, -0.22039773f, 0.01488910f, 0.00736614f, -0.01089210f, 0.10936753f, 0.19192152f, 0.23049526f, 
    -0.36540627f, -0.21761002f, -0.06556866f, 0.03572969f, -0.18483607f, 0.09908209f, 0.76568520f, -0.01702410f, 
    -0.05335743f, -0.36176950f, -0.01956276f, 0.10315172f, -0.04873539f, 0.15707105f, -0.31037012f, 0.05699480f, 
    0.23902163f, 0.06643536f, 0.19975944f, 0.11608577f, 0.11994953f, 0.05800387f, 0.01548435f, -0.17648816f, 
    0.02722593f, 0.03694927f, -0.06081222f, 0.01465521f, 0.03802680f, -0.02118964f, -0.02131361f, -0.03492602f, 
    0.04308249f, 0.03202290f, -0.04916111f, -0.04900713f, 0.01970953f, 0.00597719f, 0.02095800f, -0.02130918f, 
    -0.03080149f, -0.02957440f, 0.03261596f, -0.01743891f, 0.03108831f, 0.03626307f, -0.01299959f, -0.03342236f, 
    -0.03268003f, -0.06453274f, 0.04045038f, -0.00766488f, 0.03441237f, 0.04419069f, -0.06460587f, 0.02189881f, 
    0.04239298f, 0.03060678f, 0.03449275f, 0.00293414f, 0.00355505f, 0.03300118f, -0.01523881f, 0.01249075f, 
    0.01328158f, -0.03860138f, 0.03161557f, -0.01845525f, 0.00042023f, -0.04167314f, -0.03542018f, 0.00051216f, 
    -0.06801128f, -0.03518958f, 0.02251225f, 0.03378679f, 0.01379720f, -0.04320886f, -0.07607920f, -0.00428058f, 
    -0.03600768f, 0.03162770f, -0.08111314f, -0.05084846f, -0.00488188f, 0.02817220f, -0.02716908f, 0.00748237f, 
    0.00144368f, 0.02970965f, -0.01680565f, 0.01191264f, 0.01738647f, -0.05729915f, 0.04050409f, 0.00028721f, 
    0.02437422f, -0.07321455f, -0.05003276f, -0.01508389f, -0.02435917f, 0.03592491f, 0.00057569f, -0.04532908f, 
    0.01079419f, 0.03107299f, 0.00298748f, -0.01665277f, -0.05904866f, -0.05484447f, -0.00366272f, 0.00597110f, 
    -0.05825192f, -0.03736562f, -0.07442765f, 0.01805978f, -0.03342030f, -0.00527259f, 0.04571792f, 0.01974369f, 
    -0.02373076f, -0.02716863f, -0.01912123f, -0.01592985f, -0.03726354f, -0.06697470f, -0.03902240f, 0.04773954f, 
    -0.06695658f, -0.00077751f, 0.04256291f, 0.02516049f, -0.04401970f, -0.05775394f, 0.02599814f, -0.06159880f, 
    0.03434515f, 0.01835613f, -0.04898926f, -0.05630367f, 0.03170468f, -0.02123191f, 0.00348777f, -0.03164779f, 
    0.03174170f, 0.01973871f, 0.00586698f, -0.06000411f, 0.01168864f, -0.01797675f, -0.04663358f, -0.02288575f, 
    -0.00867866f, -0.03111730f, -0.00919760f, 0.01880254f, 0.01714679f, 0.02366934f, -0.02213088f, 0.01359039f, 
    0.03304680f, -0.01044825f, 0.02787423f, 0.05217155f, -0.06108075f, -0.03635296f, -0.05955681f, 0.01963093f, 
    -0.02528762f, 0.02704627f, -0.02731766f, 0.00996460f, -0.02644680f, 0.03780896f, -0.04568627f, 0.00409194f, 
    -0.05771542f, -0.04728036f, -0.05864991f, -0.03542600f, -0.04270983f, 0.04928441f, -0.02659123f, -0.06286702f, 
    -0.07144224f, -0.02338777f, -0.03257956f, 0.03255798f, -0.00556816f, -0.05008142f, 0.00919403f, -0.03677108f, 
    -0.01170364f, 0.01177403f, 0.04855581f, -0.05586739f, -0.04296893f, 0.02369391f, -0.03849559f, -0.01218813f, 
    0.03538548f, -0.03188836f, -0.01362226f, -0.05119675f, -0.07353694f, -0.04030652f, 0.02013804f, -0.07099222f, 
    0.03327623f, -0.04445507f, 0.03206937f, -0.01257622f, 0.04386375f, -0.06304748f, -0.04801419f, 0.01201384f, 
    -0.06330613f, 0.01783999f, -0.07390998f, 0.04429987f, -0.02412591f, 0.04486395f, 0.02939047f, 0.02815671f, 
    0.01096696f, 0.02292961f, -0.07428086f, -0.05589149f, -0.06266964f, -0.07336569f, -0.02488963f, -0.06070799f, 
    -0.06809592f, -0.02808307f, -0.04260274f, -0.03254160f, -0.02228298f, 0.02439679f, -0.00506335f, 0.01639564f, 
    0.03165223f, 0.04250181f, 0.00706942f, 0.01948607f, 0.00092088f, 0.03030707f, 0.01042555f, 0.03339648f, 
    -0.04370425f, 0.00216873f, 0.01493009f, -0.00756715f, -0.03785158f, -0.05407679f, -0.00158147f, 0.01004204f, 
    -0.02265027f, -0.02824961f, -0.03581185f, -0.05039142f, -0.06588453f, 0.02096366f, 0.02799946f, 0.00143723f, 
    0.00297620f, 0.02157833f, -0.01054102f, -0.05958037f, 0.02623015f, -0.03919186f, -0.02113999f, -0.05588083f, 
    0.04762319f, 0.00108548f, -0.05623707f, 0.04434045f, -0.02249302f, -0.03240653f, -0.04570173f, -0.00096647f, 
    -0.04235717f, 0.03255664f, 0.02177143f, -0.00999454f, 0.02042888f, -0.02644976f, 0.00544674f, 0.00166410f, 
    -0.02086092f, 0.03471259f, -0.03289996f, 0.01147319f, 0.03156308f, 0.00184760f, 0.01846242f, -0.03389106f, 
    0.00212871f, 0.04134146f, 0.00490773f, 0.01512648f, -0.04162567f, -0.04117446f, -0.07916820f, 0.01306469f, 
    -0.01969789f, 0.03385100f, 0.03416485f, -0.06728785f, 0.03411675f, -0.03995672f, 0.00117816f, -0.06137309f, 
    0.03820863f, 0.00250253f, -0.03376633f, -0.01521253f, -0.04497338f, -0.06002387f, -0.02842858f, -0.00877605f, 
    0.02637049f, -0.00540484f, -0.03918797f, -0.05981701f, 0.01440378f, -0.06880745f, -0.02260666f, 0.01791101f, 
    -0.02727355f, -0.03171540f, -0.00097048f, -0.05145965f, -0.00518664f, -0.00775616f, -0.02798907f, 0.03074602f, 
    -0.00126243f, -0.02143912f, -0.03231015f, 0.03460067f, -0.02112522f, -0.01757286f, 0.00659187f, -0.00557895f, 
    -0.02859867f, -0.03094449f, -0.03466818f, -0.01873023f, 0.02562444f, 0.03210248f, -0.04119377f, -0.03086853f, 
    0.02964945f, -0.03837252f, -0.05453750f, -0.01962415f, -0.02496185f, -0.06461702f, -0.03726281f, -0.10129565f, 
    0.00522617f, 0.00336303f, -0.06711067f, -0.05490441f, -0.05348062f, -0.03616979f, 0.07494180f, 0.02758315f, 
    -0.00232112f, 0.02034671f, 0.07149833f, -0.02896433f, 0.03306257f, 0.07657882f, -0.01980150f, 0.04370181f, 
    -0.00587872f, 0.01952112f, -0.04729427f, -0.01555246f, -0.00518369f, -0.00433874f, -0.01257129f, -0.06316798f, 
    -0.07939425f, -0.04658836f, -0.02207134f, -0.06698093f, -0.00807822f, -0.05876201f, -0.00344456f, 0.00761300f, 
    -0.02612153f, -0.01230775f, -0.10575591f, -0.01406105f, 0.01751748f, -0.05224130f, 0.04055932f, 0.00480340f, 
    -0.03009100f, -0.08884916f, 0.02250427f, 0.02293476f, -0.08657226f, -0.04819050f, -0.01082970f, -0.06810252f, 
    -0.06751478f, -0.04753783f, -0.08194503f, -0.06362353f, -0.01296646f, -0.03552255f, 0.03387043f, -0.02836528f, 
    -0.03701995f, 0.00531374f, -0.04277737f, -0.00966949f, -0.02405762f, -0.07865170f, 0.04663969f, -0.02154606f, 
    -0.03198398f, 0.03411997f, -0.01906417f, -0.03490484f, 0.02047017f, 0.01988706f, -0.02596338f, 0.02159412f, 
    -0.01214673f, -0.04477330f, -0.02806943f, 0.04153898f, -0.07858583f, 0.00294870f, 0.04941596f, 0.01920089f, 
    -0.02391761f, -0.05198756f, -0.03377332f, -0.00521009f, -0.05724102f, -0.01920750f, 0.01624307f, 0.01692297f, 
    0.00705127f, -0.08056713f, 0.00926913f, -0.04112933f, 0.04182977f, 0.01729229f, -0.04315054f, -0.08474845f, 
    0.06827348f, 0.03600817f, -0.07216887f, -0.01269851f, 0.02182448f, -0.03872405f, -0.03339998f, 0.02811355f, 
    -0.07278332f, 0.06167099f, -0.03137166f, -0.05427566f, 0.00463068f, -0.08569846f, 0.03390387f, -0.04863284f, 
    -0.09605459f, -0.00426516f, -0.04494592f, 0.03005859f, 0.03066774f, 0.01845062f, -0.02435751f, 0.01498865f, 
    -0.06844354f, -0.04876375f, -0.06930167f, 0.05993837f, -0.01102267f, 0.03344566f, 0.02644954f, -0.01614184f, 
    -0.00192250f, -0.06824157f, 0.03438887f, 0.03604258f, 0.00584441f, -0.04241541f, 0.03084034f, -0.04130524f, 
    -0.02300568f, -0.02248318f, -0.08305330f, -0.03390322f, -0.02618943f, 0.00358673f, 0.01454461f, -0.05053805f, 
    0.00708248f, -0.04037526f, -0.00535041f, -0.07869579f, -0.00943731f, -0.02221605f, -0.01885850f, 0.09379514f, 
    0.03370163f, -0.04526400f, -0.01601822f, -0.07466459f, 0.05957330f, -0.07375132f, -0.06482799f, -0.06215921f, 
    -0.07063023f, 0.01359988f, -0.08657482f, 0.02117101f, 0.05569227f, 0.01041138f, 0.06038858f, -0.00215199f, 
    0.03511434f, 0.05624639f, -0.06469073f, 0.00985933f, -0.06469373f, 0.01112303f, 0.02989633f, -0.00881454f, 
    -0.08995406f, 0.05072726f, -0.00852842f, -0.07547950f, 0.01484430f, 0.05048179f, 0.05378345f, -0.02024221f, 
    -0.12724167f, 0.04916693f, 0.04770936f, -0.02293476f, 0.00701342f, 0.04483188f, -0.05405574f, -0.05639273f, 
    0.07031028f, -0.08623539f, 0.03271531f, -0.03065331f, -0.08160434f, -0.00401625f, 0.05160911f, -0.02796603f, 
    0.00530501f, -0.06511003f, 0.02712377f, -0.03928890f, -0.00023457f, 0.00596990f, 0.01842217f, -0.00381578f, 
    -0.02514403f, -0.05336386f, -0.04788130f, 0.03760322f, 0.00713271f, 0.03563451f, -0.01065877f, 0.01423314f, 
    -0.04353235f, 0.00792362f, -0.08698805f, -0.02569850f, -0.02517961f, -0.05477151f, -0.02876255f, 0.06894549f, 
    0.00775654f, -0.04326340f, -0.07778584f, -0.07410841f, 0.03912532f, -0.03855971f, -0.00947890f, 0.04951922f, 
    -0.04657545f, -0.00505483f, -0.00731722f, -0.06473154f, -0.07928752f, 0.01709796f, 0.01957584f, -0.06703050f, 
    0.07608631f, 0.43514913f, 0.33536386f, -0.03786246f, 0.00971059f, 0.03773412f, -0.22275266f, 0.10407639f, 
    0.36714068f, 0.26245230f, -0.38879171f, 0.33910626f, 0.04985536f, -0.04694720f, 0.06842209f, -0.07625027f, 
    -0.20353302f, -0.13602078f, -0.17084105f, -0.03380866f, 0.18513541f, -0.06370333f, 0.06385818f, 0.03571368f, 
    0.01591345f, -0.05230839f, -0.17658411f, 0.68149030f, 0.05198160f, 0.24839967f, 0.03769153f, -0.11263567f, 
    -0.05282291f, -0.21583399f, -0.07733627f, 0.22601043f, -0.26155755f, -0.07018200f, 0.03604718f, 0.21549113f, 
    0.03636489f, 0.05045803f, 0.18231255f, 0.00289093f, 0.04993538f, 0.05963392f, 0.04190028f, -0.27453241f, 
    0.01760836f, 0.10036681f, -0.06666220f, -0.01305581f, -0.02482566f, -0.24975891f, -0.32662013f, -0.11282242f, 
    -0.04459646f, 0.04994695f, 0.00942699f, 0.16717069f, 0.15241194f, 0.21937120f, -0.14880793f, 0.45009699f, 
    0.10853396f, 0.38739216f, -0.09471884f, 0.18408144f, 0.07996146f, -0.01237094f, 0.03309665f, -0.07225005f, 
    0.02850607f, 0.08474150f, -0.16551046f, -0.07246955f, 0.08972216f, -0.25504237f, -0.04559819f, 0.13744631f, 
    0.10377368f, -0.33272839f, 0.10245939f, -0.07052910f, 0.01207474f, 0.17708793f, -0.06308872f, -0.04270883f, 
    -0.14504917f, -0.08682249f, -0.13044189f, 0.14822267f, -0.01866018f, -0.00757891f, 0.18273781f, -0.09311259f, 
    -0.04978576f, -0.10658053f, 0.12625484f, 0.16162983f, -0.03423484f, -0.07092443f, -0.04890323f, -0.10989279f, 
    -0.17723952f, -0.09583779f, 0.02704824f, 0.02755352f, -0.00372328f, 0.22988638f, 0.02931939f, 0.10189217f, 
    0.24554381f, 0.05958057f, -0.03048869f, 0.09231254f, 0.13496892f, -0.09622522f, 0.07489138f, -0.05727887f, 
    -0.05659530f, 0.04315068f, 0.12877777f, 0.01427903f, 0.04582683f, -0.09841985f, -0.00585410f, 0.01131118f, 
    0.08318494f, -0.08075669f, -0.10088855f, -0.01985392f, -0.01395000f, -0.08134714f, -0.07314955f, -0.34428141f, 
    0.09938648f, -0.04630813f, -0.12632416f, -0.04417909f, 0.01705448f, -0.00354391f, -0.02519058f, -0.17373958f, 
    0.08699603f, 0.15082361f, -0.06307099f, 0.00977758f, 0.16918094f, 0.15662843f, -0.28016293f, -0.12790628f, 
    -0.21895280f, 0.23525615f, -0.13533221f, -0.25710952f, -0.05748375f, 0.09699214f, 0.13911140f, 0.23857248f, 
    0.03873394f, 0.31708932f, 0.28419980f, 0.00806344f, -0.19496855f, 0.10163318f, -0.24059077f, -0.31057170f, 
    -0.03814480f, -0.04385513f, 0.09135530f, -0.33343673f, -0.33506718f, -0.14077614f, -0.09259606f, -0.00115647f, 
    -0.09726365f, -0.03902767f, -0.10535371f, -0.14870141f, 0.10924530f, 0.42030090f, 0.10816827f, -0.18438305f, 
    -0.10526541f, -0.05137110f, -0.23415467f, -0.00114259f, 0.21758297f, 0.21951719f, -0.31917045f, -0.20778385f, 
    0.16717130f, 0.06285094f, 0.08777800f, 0.18824112f, 0.23403589f, 0.22437465f, -0.48812070f, -0.04586049f, 
    0.07746331f, 0.25672084f, -0.14339522f, 0.05216115f, -0.14107871f, -0.03054674f, -0.36429086f, -0.15354888f, 
    0.31550929f, -0.01495981f, -0.08212296f, 0.39354292f, 0.07384431f, 0.00668473f, 0.17144071f, 0.21798803f, 
    -0.49113628f, 0.11772929f, 0.03681283f, 0.08863351f, 0.09561420f, 0.06372023f, -0.06554888f, 0.11175061f, 
    -0.05330476f, -0.10469425f, -0.03677460f, -0.01633725f, -0.04796373f, -0.16658399f, 0.08135244f, 0.07634073f, 
    0.00094445f, 0.20664893f, -0.02121965f, -0.04410468f, 0.08175884f, -0.05182609f, 0.02803125f, -0.03639682f, 
    -0.13499692f, -0.15324739f, -0.03361307f, 0.18870562f, 0.18937601f, -0.14827874f, -0.09811904f, -0.01430003f, 
    -0.03266735f, 0.11642888f, 0.04738743f, 0.05914546f, 0.02620826f, 0.08595387f, -0.08097192f, 0.05092670f, 
    0.00736318f, 0.22154920f, 0.02296653f, 0.20203282f, -0.01423952f, -0.10636553f, 0.06366389f, 0.04221027f, 
    0.22375160f, 0.28987247f, 0.15775245f, -0.22810383f, -0.03700750f, 0.08146591f, -0.18593778f, 0.17259407f, 
    0.11786924f, 0.10509306f, 0.09603959f, 0.17398193f, -0.18605715f, 0.07894950f, 0.15138897f, 0.25560072f, 
    0.11015873f, 0.05392354f, -0.19450536f, 0.04119958f, -0.01591589f, 0.05739992f, 0.06923080f, -0.08448730f, 
    -0.17505710f, -0.09834501f, 0.19166681f, -0.04395382f, -0.11833701f, -0.10905488f, -0.06785471f, 0.05143252f, 
    -0.04493901f, 0.01437258f, -0.09605344f, -0.35029200f, 0.04725296f, -0.03021067f, 0.08213720f, 0.00868712f, 
    0.07138132f, 0.24313885f, -0.54849982f, -0.08597173f, -0.29849988f, 0.22938789f, 0.09973313f, -0.12772414f, 
    -0.05241286f, 0.11087652f, -0.05781766f, -0.50336945f, 0.07699134f, -0.60621458f, -0.01536084f, 0.16241635f, 
    -0.16903876f, -0.05849656f, -0.11107012f, 0.18577698f, -0.44128549f, -0.33031565f, -0.46837294f, 0.11214534f, 
    -0.00264811f, -0.00256166f, -0.11014091f, 0.19472407f, 0.14335243f, 0.06763679f, 0.14669676f, -0.42876396f, 
    0.03968768f, 0.02352642f, 0.04976352f, -0.02564595f, -0.06254135f, -0.07810339f, 0.07689568f, 0.10473268f, 
    0.03176718f, 0.13304101f, 0.07437787f, -0.00626029f, 0.30992475f, -0.07024358f, 0.25118455f, -0.16321348f, 
    0.03225206f, -0.20378688f, 0.13450944f, 0.06444290f, -0.02552312f, -0.05436598f, -0.04388381f, 0.00815576f, 
    -0.25304750f, -0.00017039f, 0.00973864f, 0.02227195f, 0.07033148f, -0.20208757f, -0.02577861f, 0.10748402f, 
    0.08534069f, -0.24752399f, -0.20583478f, -0.17265604f, 0.18413259f, 0.09390543f, 0.08845087f, 0.04563390f, 
    -0.12106390f, 0.32754448f, -0.19102429f, -0.02551265f, 0.16478203f, -0.17737873f, 0.02768736f, 0.06570642f, 
    -0.15476499f, 0.02630080f, 0.09849062f, 0.11729342f, -0.01918828f, 0.23365802f, 0.17360155f, 0.15793128f, 
    0.07482429f, -0.00497965f, -0.03639749f, -0.28307781f, -0.26120141f, -0.14589919f, 0.17956653f, -0.02615683f, 
    -0.07334185f, 0.20528108f, -0.09090194f, 0.00196542f, 0.09018904f, 0.17673010f, 0.07492255f, 0.13449275f, 
    0.20305578f, 0.00323935f, -0.09031624f, 0.14846727f, -0.03524601f, 0.02998460f, -0.40018988f, -0.13028495f, 
    -0.30647668f, -0.06700163f, 0.22256629f, -0.04451148f, 0.04091843f, 0.06851113f, -0.17358640f, -0.01652338f, 
    0.03603364f, 0.10321418f, -0.11775769f, 0.19575988f, 0.06766673f, -0.07355085f, -0.00565374f, -0.00055677f, 
    -0.05494836f, 0.22071402f, -0.26315635f, 0.14381969f, 0.22213686f, 0.03523134f, 0.16124839f, -0.08095016f, 
    -0.00225491f, -0.18634810f, -0.01171961f, 0.11294127f, 0.24001853f, 0.17375682f, -0.08884902f, 0.06742159f, 
    0.06480993f, -0.02563375f, -0.11181189f, 0.03818179f, -0.24759261f, 0.06158079f, -0.05545183f, -0.01726921f, 
    0.05989666f, -0.04041931f, -0.10761584f, 0.07590867f, 0.00469510f, -0.06774220f, -0.08636864f, -0.07923418f, 
    0.21943326f, 0.07804523f, 0.05339727f, 0.10009100f, 0.18850128f, 0.18557870f, 0.13592491f, 0.09958587f, 
    -0.07675831f, -0.32888883f, 0.14730559f, -0.01008435f, -0.06972776f, -0.35713857f, 0.14561130f, -0.05439989f, 
    0.07410662f, 0.19959430f, 0.02836759f, -0.10375558f, 0.25562096f, -0.00925915f, 0.26281956f, 0.06923074f, 
    -0.13398249f, 0.09494005f, -0.26706412f, 0.01824393f, 0.11466753f, 0.15426478f, 0.06568313f, -0.20604695f, 
    -0.41393316f, 0.21428925f, -0.05799533f, -0.00615851f, -0.08630992f, 0.10107075f, 0.02038759f, 0.25096932f, 
    0.16041835f, 0.04684185f, 0.07081717f, -0.09727037f, -0.01987098f, -0.09269135f, -0.00023122f, 0.05885252f, 
    0.03747385f, -0.51942527f, -0.24203889f, -0.27076423f, 0.03565288f, -0.14045154f, -0.20309564f, 0.21882060f, 
    0.01936905f, 0.10158022f, -0.03737476f, 0.19986576f, -0.05603482f, 0.11512828f, 0.02338407f, 0.02927860f, 
    0.07934213f, 0.07199928f, 0.04574419f, -0.02215214f, -0.06348842f, 0.28214332f, 0.12885223f, -0.04332100f, 
    -0.16425405f, -0.00630915f, 0.10262207f, -0.12231164f, 0.21449901f, 0.45872816f, 0.27054748f, 0.01569401f, 
    -0.19226567f, -0.17434314f, 0.00748957f, -0.25234783f, 0.02013583f, 0.25590083f, 0.02485224f, 0.25699496f, 
    -0.03755238f, -0.03598926f, 0.02615390f, -0.07030309f, -0.08278555f, -0.00256163f, 0.14249046f, -0.10286769f, 
    -0.22016637f, -0.13224985f, 0.13745530f, 0.09621792f, 0.08784419f, -0.01735117f, -0.12754093f, -0.06991172f, 
    0.10531131f, -0.15258855f, 0.27625647f, 0.07881609f, 0.14807202f, -0.04681043f, -0.09109145f, -0.04373093f, 
    -0.02360966f, 0.04304092f, -0.02794770f, 0.01706817f, 0.03653964f, -0.06585736f, 0.03023005f, -0.00212969f, 
    0.03086226f, 0.01442435f, 0.04421931f, -0.05432672f, -0.04983243f, 0.00116987f, 0.02808075f, 0.01747129f, 
    0.04952273f, -0.00198108f, 0.03244924f, 0.03536847f, -0.05495546f, -0.01596413f, -0.04062524f, -0.06885773f, 
    -0.01734109f, 0.04493431f, 0.00697428f, 0.04936328f, -0.02556862f, 0.03421319f, 0.03028391f, -0.04097941f, 
    0.04022264f, -0.00812033f, -0.03984357f, -0.03413681f, -0.03312673f, -0.00410672f, 0.04488061f, 0.03017795f, 
    -0.00660099f, 0.00140486f, 0.03527897f, 0.06091434f, -0.04190349f, -0.00694744f, -0.01072411f, -0.02756601f, 
    -0.05793228f, -0.00134175f, -0.04033395f, 0.04489657f, 0.01973514f, -0.04094480f, 0.05430995f, 0.02799686f, 
    0.02031985f, 0.03710002f, 0.05118701f, -0.03216135f, -0.04708654f, 0.03096756f, -0.01413257f, 0.03146832f, 
    -0.04441813f, 0.05282634f, 0.04225886f, -0.04877886f, 0.04455738f, -0.01555766f, 0.00657431f, -0.04394624f, 
    -0.01832346f, 0.01626736f, 0.02672552f, 0.04600958f, 0.05228124f, 0.04634672f, -0.04020441f, 0.05201844f, 
    -0.06042745f, -0.05934721f, 0.01620591f, 0.03595464f, -0.03019616f, 0.00931786f, 0.01006164f, -0.05029508f, 
    -0.04809510f, -0.01935628f, -0.05065262f, 0.04153768f, -0.00360253f, -0.04079175f, 0.04228888f, -0.03851314f, 
    0.03970528f, 0.00662856f, -0.03978598f, -0.03458773f, -0.01300902f, 0.01900929f, 0.01028090f, 0.02632400f, 
    0.03381042f, -0.02035116f, -0.01262292f, -0.02399437f, -0.00267967f, 0.00789962f, -0.04496173f, 0.02473235f, 
    0.01311693f, 0.03520233f, 0.02303068f, -0.04529591f, -0.00856979f, -0.03570619f, -0.00689654f, -0.05335038f, 
    0.02680248f, -0.00630039f, -0.00381058f, 0.01370749f, -0.06528107f, -0.02209196f, -0.04972503f, 0.00567092f, 
    0.00314799f, -0.05799358f, 0.00426527f, 0.01748865f, 0.05410738f, 0.03393714f, -0.04015087f, -0.03771736f, 
    0.00191958f, 0.04317595f, 0.02110143f, -0.05253860f, -0.03371086f, 0.00992639f, -0.03480880f, 0.01259871f, 
    -0.04679776f, -0.04860757f, 0.04577086f, -0.03932549f, -0.06666020f, 0.02992677f, -0.03368038f, -0.05111484f, 
    0.02912303f, -0.02074008f, -0.03847590f, -0.01674670f, 0.00904279f, -0.01381176f, -0.03010045f, -0.04437641f, 
    0.00748993f, 0.04864993f, 0.04009428f, -0.02587393f, -0.02075311f, -0.05124567f, -0.05099867f, -0.02544298f, 
    -0.06040212f, 0.03946291f, 0.05235584f, -0.00241397f, -0.02848450f, -0.01703127f, -0.04197102f, -0.01196612f, 
    -0.03169924f, -0.00492278f, -0.00029242f, -0.04944405f, -0.03975502f, -0.03590037f, -0.01203488f, -0.05141264f, 
    -0.04817900f, 0.04828660f, -0.02427747f, -0.01186625f, -0.05616563f, -0.05718334f, -0.04424260f, -0.04922967f, 
    0.03553470f, -0.02448189f, -0.03444773f, -0.02448090f, 0.03456338f, -0.05148789f, -0.04991947f, 0.01571414f, 
    0.03106771f, -0.03735285f, -0.05683291f, 0.03359858f, -0.04225503f, -0.03721505f, 0.03987299f, -0.01052459f, 
    -0.05287233f, 0.03764679f, -0.03386607f, -0.03174423f, 0.04166111f, -0.03616160f, -0.04467737f, -0.05982668f, 
    -0.02984559f, 0.02520660f, -0.06041498f, -0.00101730f, -0.03766473f, 0.00603446f, -0.02562755f, -0.02983495f, 
    0.04527667f, -0.04306940f, -0.02134483f, -0.03706487f, 0.02027924f, -0.02828933f, 0.03485491f, -0.04250071f, 
    -0.01332637f, 0.01945517f, 0.03393771f, -0.02653504f, 0.00763460f, -0.00882435f, 0.05124918f, -0.05189848f, 
    0.04584314f, 0.00519055f, 0.05300798f, 0.02236719f, -0.05707932f, -0.04120498f, -0.04447803f, -0.02187202f, 
    -0.04672501f, -0.05102040f, -0.01415118f, -0.03318890f, -0.04074658f, 0.04722911f, -0.00483704f, 0.06105864f, 
    -0.06271703f, -0.01737158f, 0.02060270f, -0.03375530f, -0.05047097f, 0.01161557f, -0.06554218f, 0.02416782f, 
    0.01238976f, -0.06137647f, -0.01572649f, 0.01930781f, 0.04023561f, 0.01501426f, -0.00543893f, -0.03872223f, 
    -0.03264666f, -0.03949853f, 0.03561169f, -0.02831752f, -0.00695492f, -0.05733629f, 0.01559945f, 0.05028630f, 
    0.00029643f, 0.02375229f, -0.03507083f, -0.03634005f, 0.02511309f, 0.00403312f, -0.04127391f, 0.01458255f, 
    -0.58547240f, -0.48255390f, 0.30270073f, -0.05657647f, -0.05369542f, 0.10484567f, -0.20164062f, 0.29933631f, 
    0.26415229f, 0.25159305f, 0.11364606f, -0.82225871f, -0.20369358f, -0.13296397f, 0.20984022f, -0.02002144f, 
    -0.03372619f, 0.02808833f, -0.15857600f, 0.30123666f, -0.23023109f, 0.06834140f, 0.03851514f, 0.13990042f, 
    0.00459996f, -0.11389036f, 0.05118536f, -0.24414398f, 0.03919844f, 0.01507450f, 0.22899404f, 0.08491316f, 
    -0.04715658f, -0.04358161f, -0.11099039f, 0.12759623f, -0.23625374f, 0.12622634f, -0.06517372f, -0.12232639f, 
    -0.07461274f, 0.09367689f, 0.08245514f, 0.04116090f, 0.03876639f, 0.14574271f, -0.10317564f, -0.09805520f, 
    0.06769567f, -0.04663258f, 0.01091078f, -0.04351143f, 0.13651991f, -0.04316348f, 0.40349662f, 0.05145996f, 
    0.04933968f, 0.12527984f, 0.09712700f, 0.15394506f, -0.04017416f, -0.01743633f, 0.06764839f, 0.04891361f, 
    0.17816874f, -0.30775705f, 0.09477279f, -0.18352787f, -0.00190237f, 0.03584439f, -0.12709472f, 0.17495118f, 
    -0.01968236f, -0.18505941f, -0.16387992f, 0.06347489f, 0.05384997f, 0.18700565f, -0.06818534f, -0.01179808f, 
    -0.00348031f, -0.06130783f, 0.03617282f, -0.14511903f, 0.00433872f, 0.00049571f, 0.19643530f, 0.15220937f, 
    0.05942577f, -0.08273386f, -0.19436759f, -0.23938417f, 0.25787297f, -0.08251965f, 0.04167395f, 0.07048701f, 
    -0.22700654f, 0.15109715f, -0.17223005f, 0.26027006f, 0.08130243f, 0.29211441f, 0.10491709f, -0.14495821f, 
    -0.02181321f, -0.03938427f, 0.22738397f, -0.05852282f, 0.05967512f, -0.13138993f, 0.32744679f, -0.04425083f, 
    -0.10688865f, 0.00131834f, -0.00340057f, 0.01194432f, -0.16355883f, 0.28077120f, 0.09899096f, 0.12810646f, 
    0.07586597f, 0.05303982f, -0.01680610f, 0.20187852f, -0.04773936f, -0.08329975f, 0.12818548f, 0.14131312f, 
    -0.17700347f, 0.01550524f, -0.15383321f, -0.10074277f, 0.01576945f, 0.25492567f, -0.09769747f, -0.49732107f, 
    0.16588956f, 0.13819645f, -0.02911787f, 0.09042202f, 0.01259504f, -0.00097234f, 0.12732719f, -0.17493892f, 
    -0.18827787f, -0.47702494f, -0.38877633f, -0.06610893f, 0.13124126f, 0.18253659f, 0.09288502f, 0.31998062f, 
    -0.13536635f, 0.17813714f, 0.12115052f, 0.02397494f, 0.19944462f, 0.06670973f, -0.22840163f, 0.08786333f, 
    -0.08777794f, -0.13440743f, 0.23899280f, -0.02534749f, -0.17108554f, 0.07507540f, -0.06801450f, 0.02162572f, 
    0.16213731f, -0.11652841f, -0.03372833f, 0.04620178f, -0.06239400f, -0.10825752f, 0.05628085f, 0.23019762f, 
    0.12527855f, -0.07550322f, 0.00985541f, 0.02573795f, -0.07866381f, -0.17922480f, 0.31540674f, -0.16736852f, 
    -0.24592158f, 0.12512824f, 0.11687623f, -0.06148630f, 0.36153120f, 0.48080888f, 0.47146374f, -0.12428073f, 
    0.05557920f, 0.08694798f, -0.08982369f, -0.15165275f, 0.05384266f, -0.11922780f, -0.23065545f, -0.27969429f, 
    -0.07442432f, -0.04206925f, 0.10651015f, 0.21539754f, -0.15556704f, -0.12493262f, -0.02779418f, -0.13842614f, 
    -0.27778730f, -0.08572655f, 0.17010804f, -0.23204052f, 0.04960836f, -0.05069425f, 0.00446814f, 0.01792009f, 
    0.08432143f, -0.03078891f, 0.24805897f, -0.03327257f, 0.05495238f, 0.14154081f, -0.01288211f, -0.08089275f, 
    -0.05479273f, 0.04222437f, -0.51472050f, -0.56096977f, -0.45503294f, -0.11949758f, 0.04718074f, -0.15661533f, 
    -0.03687542f, 0.03023970f, -0.06233857f, 0.25206527f, 0.01961335f, 0.03099238f, -0.07079049f, 0.03632161f, 
    -0.08475549f, 0.06449044f, 0.00030352f, 0.23213406f, -0.06924929f, 0.30325195f, 0.04780655f, 0.13683225f, 
    -0.01296940f, 0.12094159f, 0.13811046f, 0.15496090f, 0.13107991f, -0.08909532f, 0.10466526f, 0.24304724f, 
    0.04893805f, -0.07060922f, 0.12045965f, 0.11945146f, -0.15992066f, 0.01834136f, -0.16748507f, 0.38952544f, 
    -0.04300340f, 0.09452313f, 0.19008006f, -0.30273363f, 0.18463594f, 0.03623164f, -0.16141582f, -0.34679887f, 
    -0.15969610f, -0.22003649f, 0.15218367f, -0.00590903f, 0.17480202f, -0.00391551f, -0.05872293f, 0.13079040f, 
    0.32991651f, -0.07284073f, 0.29562685f, -0.15232466f, 0.01885096f, 0.10513156f, -0.06518281f, -0.11751108f, 
    0.29480863f, 0.06410632f, 0.05598199f, -0.16804589f, 0.13234043f, -0.02936406f, -0.03514125f, 0.04547039f, 
    -0.01045228f, 0.02162698f, -0.00891837f, -0.11842678f, 0.08186274f, 0.01639297f, -0.02465109f, -0.07947535f, 
    0.04043464f, 0.07085118f, 0.53361183f, 0.27736619f, 0.22405146f, -0.07198808f, -0.07016640f, 0.01795553f, 
    0.10191151f, -0.04398227f, 0.12181942f, 0.29249147f, 0.05533051f, -0.08801923f, 0.23042256f, -0.07843503f, 
    -0.06325644f, -0.10135379f, -0.11054839f, -0.28468630f, 0.35057387f, 0.26080707f, 0.33662450f, 0.17236885f, 
    0.05321420f, 0.16724670f, -0.07369829f, 0.13388176f, -0.05962896f, -0.02871692f, 0.16772392f, 0.14802927f, 
    -0.02170071f, -0.06744648f, -0.16464539f, -0.11562649f, 0.27441099f, 0.13324174f, -0.77992857f, -0.45386484f, 
    -0.48442677f, 0.26213691f, 0.20049535f, 0.06991320f, 0.28287375f, 0.02934901f, 0.03408042f, -0.23908831f, 
    -0.06165060f, -0.08774478f, 0.07346407f, 0.11169532f, 0.02820538f, 0.01159651f, -0.12035841f, 0.04027474f, 
    -0.05986845f, 0.09694143f, -0.22443786f, 0.02301622f, -0.09475907f, -0.07433774f, 0.01275669f, 0.11405538f, 
    0.00238770f, 0.00955524f, 0.15326247f, -0.00486302f, 0.05125400f, -0.18015468f, -0.10984524f, 0.27962512f, 
    0.21026602f, -0.05185598f, 0.33035329f, 0.17150435f, 0.06754823f, 0.01971901f, 0.07852977f, -0.15427276f, 
    -0.12600386f, 0.17020816f, -0.05183544f, -0.03705507f, -0.18369821f, -0.12166648f, -0.19419537f, 0.03823401f, 
    0.13793921f, 0.06372669f, 0.05198914f, -0.04018992f, 0.04917421f, 0.12678912f, -0.16005708f, -0.19933891f, 
    -0.12361673f, -0.05457552f, -0.01278635f, 0.12587962f, -0.07755541f, -0.77757221f, -0.40965018f, -0.14870039f, 
    0.12584600f, 0.20525043f, 0.01643883f, 0.10925931f, -0.01052314f, 0.00830725f, 0.47130185f, 0.13252610f, 
    0.28831169f, -0.08541048f, -0.09658355f, 0.00334559f, -0.19657132f, 0.03637896f, 0.03829818f, 0.05206923f, 
    0.20505391f, 0.01508771f, -0.08030380f, 0.19065899f, -0.10705099f, 0.11883305f, 0.14696114f, -0.09622075f, 
    -0.32332218f, -0.01627983f, 0.00501948f, 0.34131002f, -0.02549514f, 0.04258769f, -0.23305811f, 0.12136245f, 
    0.05891941f, -0.13857533f, -0.06810551f, 0.14699662f, 0.17903101f, 0.15278241f, -0.06258690f, -0.02940639f, 
    0.14657097f, 0.19234076f, 0.32454503f, 0.14883806f, 0.07434647f, -0.01551568f, -0.00539527f, 0.03308186f, 
    0.10464051f, 0.10693362f, 0.03185509f, -0.11925466f, -0.17792466f, 0.12885539f, 0.01533167f, 0.13670155f, 
    0.09190047f, -0.02668116f, 0.04925372f, -0.21382037f, 0.07015318f, 0.00692613f, -0.03898852f, -0.38652369f, 
    0.09795368f, -0.11008889f, 0.16406551f, 0.06973089f, -0.26933986f, 0.29097396f, 0.32894477f, 0.03142118f, 
    0.35995510f, 0.08074681f, -0.02346242f, 0.01196488f, 0.03272989f, -0.10032950f, -0.04825351f, -0.05791321f, 
    -0.23636904f, 0.09576006f, -0.02467287f, 0.05668842f, -0.03724448f, 0.00700480f, -0.06847853f, -0.05783181f, 
    -0.08800702f, -0.19281220f, -0.18600248f, -0.09325735f, 0.17841350f, 0.04066873f, 0.12143157f, 0.08226412f, 
    0.17177320f, -0.14704478f, -0.10632605f, -0.01901731f, -0.05708728f, 0.05965091f, -0.07135309f, 0.16960762f, 
    0.03302005f, -0.24350193f, -0.13210030f, 0.07359821f, 0.01318630f, 0.02325046f, 0.10272911f, -0.05986050f, 
    -0.23361923f, 0.05621116f, -0.34778088f, -0.29097930f, -0.21125907f, 0.17942151f, 0.05069482f, 0.06840431f, 
    0.12010063f, -0.11702401f, 0.00909260f, 0.06970248f, -0.00322521f, -0.12682453f, -0.15270464f, -0.07496540f, 
    -0.03205345f, 0.23512229f, 0.11874321f, 0.04932054f, -0.79140764f, -0.48579019f, -0.06609678f, 0.28113776f, 
    0.12675886f, 0.16893382f, -0.07189181f, -0.06815390f, -0.03979212f, 0.42266437f, 0.07879513f, -0.19079311f, 
    -0.05385201f, 0.03405885f, -0.02076869f, -0.06897536f, 0.16040811f, -0.03817443f, -0.11251686f, -0.10012035f, 
    -0.20704046f, 0.05239206f, 0.01121791f, 0.02997165f, -0.03780339f, -0.01111769f, 0.05276044f, 0.05198387f, 
    0.16801611f, 0.31361452f, 0.02199693f, 0.20485941f, 0.04560477f, 0.06401969f, -0.00079349f, 0.03561887f, 
    0.40339476f, 0.24912040f, 0.28992429f, 0.14000624f, 0.05118354f, -0.07999156f, 0.11385832f, 0.06559210f, 
    -0.09679998f, -0.34184054f, -0.18475485f, -0.34492677f, 0.09933300f, 0.12449758f, 0.05908669f, -0.00178722f, 
    0.10636369f, 0.27385297f, 0.32038775f, -0.14582868f, -0.32725969f, -0.01127484f, -0.18693681f, 0.09439956f, 
    -0.22134764f, -0.08644407f, -0.28161713f, 0.18347679f, -0.04997159f, -0.21094398f, -0.12898843f, 0.05574175f, 
    -0.20523898f, 0.06707528f, 0.01258115f, -0.24825567f, 0.14220880f, -0.27707544f, -0.11226547f, -0.17038479f, 
    0.00666181f, 0.07663639f, -0.47290766f, -0.00901476f, -0.09987444f, 0.16947126f, -0.26301774f, -0.12323524f, 
    -0.17416568f, -0.00202922f, 0.23763682f, -0.23657681f, 0.08056872f, 0.01273272f, -0.25147688f, -0.27224514f, 
    -0.02804041f, 0.10172968f, 0.08638524f, -0.13603275f, -0.02475659f, -0.32075340f, 0.13227203f, -0.36418504f, 
    -0.25742149f, -0.11888447f, 0.08399682f, -0.07970574f, 0.20256267f, 0.14733791f, -0.14121825f, 0.29599401f, 
    -0.04545965f, -0.06472288f, 0.11852793f, -0.04062800f, 0.01777908f, 0.02107365f, -0.01712877f, -0.04798061f, 
    -0.06461976f, 0.07131617f, -0.06210281f, -0.00584009f, 0.16459815f, -0.14082491f, 0.02915521f, -0.04498481f, 
    0.16504763f, 0.07415498f, 0.41815972f, 0.20112734f, 0.19875208f, 0.05519268f, 0.10450429f, 0.04307324f, 
    0.06821656f, -0.01954759f, 0.07319535f, -0.40798357f, -0.10862473f, 0.07656641f, 0.02985959f, -0.13135070f, 
    0.07504860f, 0.08067483f, -0.06216344f, -0.08654425f, 0.08945043f, 0.19720663f, 0.23965687f, -0.14960498f, 
    -0.05767813f, 0.02831316f, 0.02736284f, 0.04524080f, -0.00687225f, -0.21567006f, -0.23089761f, 0.08341566f, 
    0.03804685f, 0.02706138f, -0.01261256f, -0.00953964f, 0.00423566f, 0.22514881f, 0.14134575f, -0.24461815f, 
    -0.27661282f, -0.01593315f, -0.13143656f, 0.09413308f, -0.05586206f, 0.27319294f, -0.12347931f, 0.10654135f, 
    0.05656377f, 0.11063215f, 0.02156650f, -0.19035427f, 0.02864019f, 0.13510992f, 0.02174229f, 0.08254565f, 
    -0.29816899f, 0.13800180f, -0.21506213f, 0.10168266f, -0.09483559f, 0.11990433f, 0.15581669f, 0.18524969f, 
    -0.09524805f, -0.44715732f, -0.28921261f, 0.03651393f, 0.16841891f, -0.03807285f, 0.05895372f, 0.00915167f, 
    0.07134281f, 0.04478155f, 0.04714055f, -0.14248343f, -0.04627252f, -0.03521907f, 0.20717353f, 0.20636129f, 
    -0.13393389f, -0.16398200f, -0.19638444f, -0.22636914f, 0.22925095f, 0.03691333f, 0.17212029f, 0.02461105f, 
    -0.27170950f, 0.12392212f, -0.00923575f, 0.11886800f, 0.09570275f, 0.24326889f, 0.11686694f, 0.23968734f, 
    -0.02727368f, -0.16479389f, -0.02285471f, 0.25085393f, -0.23567809f, -0.34418026f, -0.29104859f, 0.13157508f, 
    0.11364907f, 0.01901429f, 0.23397328f, -0.23883738f, 0.07452716f, -0.18362023f, 0.23173982f, 0.17123112f, 
    0.08354712f, -0.04097369f, -0.10821560f, -0.06969534f, 0.07733585f, 0.01813436f, 0.22097448f, -0.04940255f, 
    0.18313208f, 0.03602526f, -0.12587957f, -0.09024901f, 0.12874955f, -0.05273503f, 0.03745738f, 0.06281906f, 
    0.27054220f, 0.10112549f, 0.09221528f, -0.09119037f, 0.05391002f, -0.19250369f, 0.06131823f, 0.13116035f, 
    0.12742883f, -0.00534327f, -0.03149241f, -0.12471136f, 0.00114993f, 0.03299708f, 0.10856587f, -0.22315897f, 
    0.10937104f, -0.05175779f, -0.03802051f, 0.06693824f, -0.10071713f, 0.01589185f, 0.04805455f, 0.02388472f, 
    0.07343671f, -0.08757798f, 0.19003467f, 0.19617341f, 0.25086692f, 0.12415724f, 0.10074189f, 0.10575465f, 
    0.08330698f, -0.04136613f, 0.15382634f, -0.09050096f, -0.35259402f, -0.01513179f, 0.06967910f, 0.13707516f, 
    -0.09298190f, 0.12376320f, 0.06368185f, 0.15089011f, 0.38036245f, 0.17073968f, 0.46810770f, 0.14680158f, 
    -0.11273167f, 0.03301612f, -0.03608244f, 0.20521697f, 0.23711918f, 0.00256559f, 0.17151472f, 0.00744634f, 
    -0.12621643f, -0.16670477f, 0.08999363f, -0.04900865f, 0.19075501f, 0.14329986f, 0.03037691f, -0.21390732f, 
    -0.16312140f, 0.10388766f, 0.10094857f, 0.15635820f, 0.07500155f, -0.02331648f, -0.14108069f, -0.05677938f, 
    0.03253468f, 0.03003927f, 0.00182495f, 0.01301725f, 0.04201612f, -0.01342786f, -0.05618782f, -0.02443762f, 
    -0.05008131f, 0.01484229f, 0.02176727f, -0.05628530f, 0.01759702f, -0.01135587f, 0.02946527f, -0.05374881f, 
    -0.03801694f, -0.05921138f, -0.01592607f, 0.04017616f, -0.00592454f, 0.02793404f, 0.03945488f, -0.02983245f, 
    -0.03393724f, 0.01593111f, -0.06638458f, -0.03004970f, 0.02473296f, -0.05128751f, 0.02037154f, -0.02442744f, 
    -0.04684296f, -0.03055415f, -0.01426444f, 0.04415550f, -0.02193653f, 0.00790535f, -0.02022500f, -0.01936274f, 
    -0.01634694f, -0.06176199f, 0.04716515f, 0.01152143f, -0.06281247f, 0.01718749f, -0.04626611f, 0.03784090f, 
    -0.02447477f, -0.06667405f, -0.01671339f, 0.02917766f, -0.01594371f, -0.00858661f, 0.02971082f, -0.05308560f, 
    0.01969153f, -0.05775594f, 0.02160538f, -0.05355104f, 0.04344399f, 0.03119033f, 0.02381885f, 0.04985723f, 
    -0.04988129f, -0.06429693f, -0.02365086f, -0.00324552f, -0.03529245f, -0.00121313f, 0.03645977f, 0.00392011f, 
    -0.05130330f, -0.06386319f, 0.02594781f, 0.02391728f, -0.01360660f, -0.01079772f, 0.02292421f, 0.03914829f, 
    0.01513130f, -0.00743813f, -0.05032059f, 0.02252063f, 0.03979065f, 0.03859631f, -0.03521189f, 0.00759525f, 
    0.02742779f, 0.00029644f, -0.01656380f, 0.00172994f, 0.00052676f, -0.02240678f, -0.05500083f, 0.01275405f, 
    0.04373328f, 0.04156962f, 0.01743018f, 0.00273966f, 0.00551042f, 0.00053317f, 0.03531430f, -0.05427521f, 
    0.01414139f, 0.02196157f, -0.04614269f, -0.02629682f, 0.04103231f, -0.04037537f, 0.04376873f, -0.04288005f, 
    0.04873240f, -0.04723114f, 0.01109244f, -0.03117632f, 0.01071565f, -0.01492424f, -0.05226401f, -0.04763094f, 
    -0.03481091f, 0.00660341f, -0.06869508f, -0.05186358f, -0.05367557f, -0.00848076f, -0.05430007f, -0.05529556f, 
    0.04286546f, -0.03993932f, -0.02900147f, -0.04016865f, -0.01925010f, 0.01507027f, 0.03154396f, -0.05768435f, 
    0.02646190f, -0.00846480f, -0.02789401f, 0.00770326f, -0.00500529f, 0.02346573f, -0.06317294f, -0.00996991f, 
    0.02741055f, -0.01476190f, 0.01995739f, -0.05687269f, -0.00436931f, 0.00203943f, 0.01431986f, 0.01745398f, 
    0.01137153f, -0.00514173f, 0.00994887f, -0.04671909f, -0.03165700f, 0.02093574f, -0.02293293f, -0.02154304f, 
    -0.00279507f, 0.02083447f, -0.02982189f, 0.02976119f, -0.00584901f, -0.05101283f, -0.05026310f, -0.01301153f, 
    -0.03518052f, -0.03771319f, -0.01401970f, -0.05475662f, 0.00851156f, -0.04529935f, 0.03424422f, 0.03495064f, 
    -0.00386989f, 0.04521162f, 0.01487043f, 0.04721767f, -0.00064033f, -0.00212201f, -0.00429875f, -0.05125953f, 
    -0.06278457f, 0.02693685f, -0.03598500f, -0.04790476f, -0.01383512f, 0.02282673f, 0.03171410f, -0.03621110f, 
    -0.01245873f, 0.03749404f, -0.06815385f, 0.00097112f, -0.02812691f, 0.03398276f, -0.03361017f, -0.01990340f, 
    -0.01825891f, 0.03655777f, 0.04757564f, 0.04459413f, -0.06189841f, -0.06675446f, -0.06247798f, 0.02300189f, 
    0.03062943f, 0.01987653f, 0.01762471f, 0.03701491f, -0.02435830f, 0.02506381f, -0.00659151f, 0.02992784f, 
    0.02747888f, -0.02615448f, 0.04105996f, -0.00677220f, 0.00498280f, -0.01918004f, 0.01696196f, -0.05650048f, 
    0.02839102f, -0.06393488f, -0.03251894f, -0.06508111f, -0.00707777f, 0.03402475f, -0.02594423f, 0.01439956f, 
    -0.03586368f, -0.05203629f, -0.04974497f, 0.04843619f, -0.01393539f, -0.00432899f, -0.06751508f, 0.04847462f, 
    -0.03965369f, -0.02067288f, -0.05071900f, -0.01147771f, -0.03608637f, 0.00660969f, -0.02663433f, -0.00796715f, 
    -0.00179121f, -0.05326598f, -0.05570553f, 0.01461290f, 0.01410286f, -0.01126768f, -0.02557480f, -0.00484286f, 
    -0.02643473f, -0.03453107f, 0.02971512f, -0.03323693f, 0.04125845f, -0.02827398f, -0.01152269f, -0.05810115f, 
    -0.00691300f, -0.05907919f, 0.02701842f, -0.02476577f, -0.02299153f, 0.04398333f, -0.03316922f, -0.04391639f, 
    0.03961090f, 0.04433826f, 0.04221253f, -0.00218421f, 0.01331538f, -0.05458128f, -0.05211807f, -0.03656384f, 
    -0.04776359f, 0.04846089f, 0.04626260f, 0.02937914f, -0.02714317f, -0.05605180f, 0.02931243f, -0.02313681f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.27635053f, -0.00924689f, -0.02565078f, 0.10643439f, -0.02576835f, 0.12148762f, 0.03751244f, -0.05264885f, 
    0.01039421f, -0.08541761f, -0.02102239f, -0.07064981f, 0.12554975f, -0.07954526f, -0.04894519f, -0.01338714f, 
    -0.00452512f, 0.05454741f, -0.04778036f, 0.18606900f, -0.01596371f, 0.15673442f, 0.06500819f, 0.04361784f, 
    -0.04660879f, -0.04637259f, 0.14510898f, 0.04040576f, 0.13063106f, 0.15808582f, 0.04098579f, 0.00025135f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.34542862f, -0.12620950f, -0.08664741f, 0.26830196f, 0.02050924f, 0.56652170f, -0.58779228f, -0.06335483f, 
    0.06729575f, 0.59869701f, 0.33190033f, -0.53415453f, 0.68961930f, 0.07669838f, -0.02172175f, -0.04323535f, 
    -0.01878545f, 0.04815143f, 0.17649561f, -0.57158870f, 0.14350303f, -0.19421893f, -0.22912198f, 0.11786404f, 
    0.01869098f, 0.13647874f, -0.30603582f, -0.00665010f, -0.55507553f, -0.23020026f, -0.23629244f, 0.11059581f, 
    0.36397976f, 0.02571835f, -0.09067407f, -0.44001314f, -0.02868453f, 0.27305511f, 0.47169951f, -0.16798979f, 
    0.75279725f, 0.65207082f, -0.34803385f, -0.15254097f, -0.25360751f, -0.06839976f, 0.13240147f, 0.00407663f, 
    0.10004827f, -0.34053302f, -0.15323873f, 0.32333648f, -0.06445596f, 0.08308225f, -0.26292583f, -0.11726242f, 
    -0.12405480f, -0.37070641f, 0.03342516f, 0.12737353f, -0.28494832f, -0.19060369f, 0.25843105f, 0.08620971f, 
    -0.73337948f, -0.04170182f, -0.10235619f, -0.00599854f, 0.13996345f, 0.00059397f, -0.38224459f, 0.20008452f, 
    0.35843238f, -0.26721022f, -0.72220969f, -0.42407539f, -0.31438074f, 0.63029039f, -0.05177876f, 0.02918763f, 
    -0.21580672f, -0.29929355f, 0.10340453f, 0.23548207f, 0.03566793f, -0.20127201f, 0.67341870f, 0.08151416f, 
    -0.16013500f, -0.02129917f, 0.05946114f, 0.02322218f, -0.18318295f, -0.06034477f, -0.08439421f, 0.09009273f, 
    0.11424545f, 0.10801659f, 0.14419989f, -0.34878117f, -0.04515211f, -0.58531636f, -0.26430076f, -0.15166633f, 
    0.20860235f, -0.39922738f, 0.28023043f, -0.06111337f, -0.08631966f, 0.49419016f, 0.09482596f, 0.03718631f, 
    -0.13281429f, 0.83689380f, 0.03649039f, -0.52953589f, 0.12100959f, -0.08441865f, -0.48484290f, 0.02130472f, 
    -0.07551039f, 0.36038586f, -0.45757189f, -0.12153450f, 0.10951826f, 0.28571364f, 0.05654861f, -0.01502977f, 
    0.86899316f, -0.02472979f, 0.02331020f, 0.22542275f, 0.04840092f, 0.27031511f, -0.21254627f, 0.11628230f, 
    0.04966488f, -0.42395365f, 0.26956213f, 0.06428710f, 0.13152409f, 0.04951996f, -0.06854288f, -0.09359667f, 
    -0.56999189f, -0.30888170f, -0.02221172f, -0.19111413f, -0.02737458f, -0.61834759f, 0.07170571f, 0.02421616f, 
    -0.06228241f, -0.04284095f, -0.00068401f, -0.12214379f, 0.37237528f, 0.07870506f, -0.19908461f, 0.05695719f, 
    0.11105965f, 0.08529340f, 0.04490962f, 0.35998371f, 0.01601484f, 0.17095941f, 0.17013873f, -0.86676776f, 
    -0.54815000f, -0.23918639f, -0.41739818f, 0.86388189f, 0.29975420f, -0.36968595f, 0.14456080f, 0.10266213f, 
    0.20411718f, -0.33993724f, -0.02031893f, 0.26274323f, -0.04501532f, 0.41334900f, -0.27267087f, 0.14834672f, 
    -0.17828359f, 0.03267668f, 0.09495889f, 0.10915844f, -0.63523197f, -0.00739136f, 0.15003084f, 0.15320632f, 
    0.25483161f, -0.13545111f, 0.00235148f, 0.55997819f, -0.04897243f, -0.31585759f, -0.49264017f, -0.12942302f, 
    -0.21895033f, -0.28280878f, -0.15605274f, -0.28601176f, -0.54906267f, 0.17122076f, -0.08209442f, 0.09333004f, 
    0.19552907f, -0.15578306f, 0.14572257f, 0.33424044f, -0.03550890f, 0.31502077f, 0.01566548f, 0.02421894f, 
    -0.05262277f, 0.27125642f, -1.11001623f, 0.07019491f, 0.13965759f, 0.14520507f, -0.61770356f, -0.01349480f, 
    -0.17735937f, 0.10126441f, 0.11934420f, -0.05720158f, -0.12457737f, -0.07793206f, 0.39048883f, 0.88173592f, 
    -0.30108273f, -0.05316855f, 0.37300926f, 0.47530186f, -0.57573897f, 0.24760412f, -0.02313849f, -0.04450120f, 
    -0.50239748f, -0.20280319f, 0.05664134f, -0.19096285f, -0.11270620f, -0.23018996f, -0.24549796f, -0.09769358f, 
    -0.13486874f, 0.30323276f, 0.30656791f, 0.01940143f, -0.61608309f, -0.15315831f, 0.30603161f, 0.03497254f, 
    -0.07324278f, 0.05053615f, -0.09606206f, -0.17627765f, 0.17414182f, -0.24150647f, -0.24748358f, 0.56671131f, 
    -0.41200793f, 0.43067902f, -0.25844479f, 0.34999174f, -0.20547861f, -0.42511129f, 0.03249556f, -0.01687115f, 
    0.22995439f, 0.47929516f, 0.06590989f, 0.33475220f, -0.05744476f, -0.42213973f, 0.03417207f, -0.00836309f, 
    0.08730319f, -0.11671817f, 0.59832710f, 0.14468002f, -0.23233339f, -0.44805247f, 0.29236463f, -0.13271461f, 
    -0.63177395f, -0.04868108f, -0.14736737f, 0.07667492f, -0.17476933f, 0.36719421f, 0.07444286f, 0.30561334f, 
    -0.37377155f, -0.50651556f, 0.08446496f, 0.48234627f, 0.25090957f, -0.70897102f, -0.15394434f, -0.11396735f, 
    -0.23532946f, -0.16064461f, -0.12466767f, 0.04119439f, -0.01542423f, 0.35650849f, -0.05973614f, 0.05575945f, 
    -0.15392503f, -0.12314805f, 0.38797024f, 0.11118971f, 0.51659662f, -0.00600397f, -0.46688327f, -0.00084138f, 
    -0.12665580f, 0.14608090f, 0.09305268f, -0.63869441f, 0.00047137f, -0.70867872f, 0.12728511f, -0.39385027f, 
    0.28063858f, -0.43019855f, -0.05597880f, -0.53635305f, 0.25712588f, -0.39655688f, 0.01152566f, -0.11974813f, 
    0.20156139f, 0.11975638f, 0.15374112f, 0.12575574f, -0.15358841f, -0.32964709f, 0.10869275f, -0.04750431f, 
    -0.04734702f, -0.63480812f, -0.04472593f, 0.09889065f, 0.05935410f, 0.53745317f, 0.76870650f, 0.13300362f, 
    -0.14016816f, -0.07540224f, -0.00601886f, -0.38766757f, -0.11973288f, -0.07265443f, 0.23236610f, -0.69045997f, 
    -0.13321692f, 0.06899629f, -0.28823379f, -0.30888563f, -0.61312157f, -0.43928844f, 0.05612528f, 0.08017823f, 
    0.37637955f, 0.29366279f, 0.14818326f, -0.70406157f, 0.03775781f, 0.00595038f, 0.06779512f, -0.05480195f, 
    0.02795468f, 0.49014735f, -0.19845164f, 0.04633558f, 0.51366198f, 0.24502604f, -0.34507808f, 0.06177284f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12398423f, -0.06100421f, -0.07060439f, -0.03669699f, 0.05903526f, 0.13537417f, 0.06697513f, -0.32107848f, 
    -0.10155459f, -0.22626676f, -0.03009873f, 0.15289120f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
