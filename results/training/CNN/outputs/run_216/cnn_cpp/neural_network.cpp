#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.14544749f, 0.95974272f, 0.55913264f, -0.19691274f, 0.25275970f, -0.01879318f, -0.41855228f, 0.59884334f, 
    -0.15648355f, -1.10021007f, -0.48426834f, 0.05533157f, -0.19180328f, 1.37247300f, -0.36136636f, 0.21409786f, 
    0.03787635f, -0.34737876f, 0.89509678f, -0.09248796f, 0.32094681f, -1.14615560f, -1.07000208f, -0.59472096f, 
    -0.41365150f, 0.53148675f, 0.00582373f, -1.19528902f, 1.04092467f, -0.22583514f, 0.25175878f, 0.61456758f, 
    0.26397714f, -0.41801208f, -0.39306581f, -0.62082124f, 1.19175291f, 0.83892030f, 1.04574215f, 0.32238367f, 
    0.06836468f, 0.17120814f, 0.69251204f, -0.12174072f, 0.49261051f, 1.12533307f, 0.85046297f, 0.53303915f, 
    -0.77490652f, 1.01706314f, -0.51920003f, 0.46879897f, 0.07953389f, -0.13148995f, -1.06860816f, 1.09830415f, 
    -0.75411677f, 0.46271998f, -0.71335101f, -0.97931439f, -0.09862383f, 0.19621807f, -0.13707979f, -0.56422073f, 
    -0.08125751f, 1.11457348f, 1.07941329f, 1.24616134f, 0.08553968f, -0.47288996f, -0.17765303f, 0.06707788f, 
    0.88156372f, -0.67836994f, -0.61292475f, 1.27332854f, 0.24073085f, 0.09283067f, -0.47698212f, -0.17758289f, 
    0.44545686f, -1.00589752f, -1.02931321f, 0.08677423f, -0.56507999f, -1.16191351f, -0.03972379f, 0.13182792f, 
    0.36821035f, 0.10737792f, 0.20843673f, -0.12882900f, 0.61454332f, 0.80172026f, -1.20982504f, 0.75293773f, 
    0.74009657f, -0.10027169f, 0.20993415f, -1.12852454f, -0.64767641f, -0.50688148f, 0.99625891f, 0.95819783f, 
    0.71276569f, 0.28271690f, 0.01451933f, 0.14032036f, 0.68199682f, 1.28966010f, 0.21154110f, -0.72163850f, 
    -1.26755643f, -1.26474631f, 0.03472720f, -0.21936525f, 0.31155366f, -0.46147874f, -0.71788901f, -1.01023507f, 
    -0.38371402f, 1.05524945f, 0.01120626f, -0.48123217f, -0.07169142f, 0.26920956f, 0.77373564f, 0.01256869f, 
    -0.23547651f, -1.12357950f, 0.56647325f, 0.37558493f, 0.36931598f, 0.75911194f, 0.85981292f, -0.94623834f, 
    -1.44913375f, -1.41555440f, -0.16138478f, -0.41093311f, 0.33095372f, 0.12140533f, -0.00930913f, -0.12174441f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.51552916f, -0.01905892f, 0.29531321f, 0.22507945f, 0.25150046f, 0.01438579f, 0.31103233f, -0.11392789f, 
    0.13953954f, -0.16210936f, 0.18087758f, 0.11613198f, 0.55545944f, 0.05002967f, 0.11171270f, -0.29250392f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05916966f, -0.09339227f, -0.12897600f, 0.04654628f, 0.05272330f, 0.11220711f, 0.06073451f, 0.16696565f, 
    0.16302824f, -0.02897531f, -0.69580495f, -0.36851087f, 0.08830775f, 0.07173440f, 0.07624853f, 0.13758382f, 
    -0.19546831f, -0.12802646f, 0.08251504f, 0.18670593f, -0.25431868f, 0.04524279f, 0.31382060f, 0.31354111f, 
    0.05412373f, 0.20407893f, 0.00523051f, -0.45854443f, -0.01492914f, 0.01366798f, 0.07762171f, -0.19387202f, 
    -0.41227224f, 0.08295017f, 0.05628765f, 0.21934788f, 0.06431706f, 0.20809366f, 0.11925824f, 0.03142569f, 
    0.01647763f, -0.27963495f, 0.03714041f, 0.02023341f, 0.22272347f, 0.27190739f, -0.00479254f, -0.10037390f, 
    0.03397761f, -0.08110404f, 0.04988832f, -0.14874040f, 0.07788382f, 0.15501951f, -0.51841444f, -0.34059504f, 
    0.06264424f, 0.14445634f, 0.13591631f, 0.00926248f, 0.19366702f, 0.01705526f, -0.09531458f, -0.22952646f, 
    -0.12415883f, 0.06649902f, -0.01822347f, -0.13119477f, -0.02656977f, -0.10040170f, 0.05280728f, 0.00709226f, 
    -0.23261683f, 0.09620575f, 0.21467933f, 0.21274258f, -0.13279396f, -0.07909349f, -0.00490692f, 0.08380112f, 
    0.08473021f, -0.15843579f, -0.24617454f, 0.15750931f, 0.13519111f, -0.06177795f, 0.33518854f, -0.05053886f, 
    0.06382729f, -0.07132176f, 0.11330452f, 0.32024485f, 0.45110235f, 0.13115731f, -0.09234964f, -0.04878360f, 
    0.24702367f, 0.18692482f, 0.20635216f, -0.30040020f, -0.12667082f, 0.06117193f, -0.23153855f, -0.21475805f, 
    -0.28381678f, -0.05082086f, -0.10145847f, 0.02978182f, 0.57521319f, 0.09653795f, -0.17222907f, 0.24771537f, 
    -0.09795120f, 0.16489781f, -0.06066206f, -0.07985024f, -0.08933097f, -0.49398097f, -0.03697513f, -0.73771304f, 
    0.23780835f, 0.06834938f, 0.21760400f, -0.23805991f, -0.35434037f, -0.41005117f, 0.22663602f, 0.17041123f, 
    0.16794063f, -0.06157828f, -0.16161129f, -0.16433878f, 0.08655389f, 0.06585910f, 0.17708461f, -0.30336365f, 
    0.23332749f, -0.01561096f, -0.08170792f, 0.05827289f, 0.00531856f, 0.05106468f, 0.06029788f, -0.01867884f, 
    -0.02568746f, 0.17925236f, 0.14526108f, 0.25923717f, 0.36337024f, 0.24199748f, 0.09640818f, -0.00263964f, 
    0.04319726f, -0.53654295f, -0.12326062f, -0.17789380f, -0.04497104f, -0.31498915f, 0.08414741f, -0.21926028f, 
    0.24024615f, 0.13541763f, 0.24727722f, 0.23028859f, -0.16932070f, -0.12956126f, -0.05662257f, -0.14708532f, 
    0.00728773f, 0.24531473f, -0.07809786f, 0.09685199f, 0.21245700f, 0.16657852f, -0.16934456f, -0.04324072f, 
    -0.05922621f, -0.17302631f, -0.10499694f, 0.09385447f, 0.32789662f, -0.38768137f, 0.15871499f, 0.31030548f, 
    0.09808879f, 0.17355104f, 0.23521823f, -0.10487124f, -0.02061589f, 0.44133070f, 0.29425633f, -0.24084233f, 
    0.22042353f, 0.07259502f, -0.11485410f, -0.12384780f, 0.05704860f, 0.05679842f, -0.17107734f, -0.01189849f, 
    0.32421497f, -0.20185487f, -0.01228648f, -0.05739401f, -0.03009649f, -0.00102488f, -0.03801778f, -0.32857439f, 
    -0.53661370f, -0.22233011f, 0.18057147f, 0.19486462f, 0.04227394f, 0.03616742f, 0.00259369f, 0.07457653f, 
    0.17026271f, -0.20331633f, 0.23645391f, 0.12863727f, -0.02794505f, -0.04813191f, 0.00842519f, -0.10965646f, 
    -0.13656488f, 0.18174933f, -0.09630404f, -0.53762984f, 0.24851573f, 0.29168463f, 0.11150333f, -0.08462587f, 
    0.08423315f, 0.24984115f, -0.44090587f, -0.66070360f, -0.24201904f, 0.35356730f, 0.19187181f, 0.42562529f, 
    -0.11052494f, -0.09801703f, -0.21861655f, -0.17057632f, -0.02210774f, 0.18679926f, 0.14841825f, 0.15796870f, 
    0.21821380f, -0.33303976f, 0.02940333f, 0.03152464f, 0.70436090f, 0.67084968f, -0.23129223f, 0.21537101f, 
    -0.08477779f, -0.16595449f, 0.11916707f, 0.05265585f, 0.02090725f, -0.20339969f, -0.22440201f, 0.18747827f, 
    -0.15624548f, -0.00006040f, 0.04841862f, 0.00035254f, -0.18717670f, -0.03314181f, -0.46829337f, 0.21040915f, 
    0.14483221f, 0.16210209f, -0.07812741f, -0.03535291f, 0.40205246f, 0.10171496f, -0.33083346f, -0.25115541f, 
    0.18713430f, -0.17304677f, -0.31592840f, -0.05143836f, -0.02334944f, 0.24812692f, 0.02426404f, 0.11561805f, 
    0.00015668f, 0.03725648f, -0.06931199f, -0.00878684f, -0.08359730f, -0.06357441f, 0.06723946f, 0.03141434f, 
    -0.07796557f, -0.03413943f, 0.01755424f, -0.02867122f, 0.01530041f, -0.04278437f, 0.05093435f, -0.03432208f, 
    -0.01992176f, -0.03386679f, -0.06999239f, -0.04741647f, -0.00828243f, -0.05981082f, -0.05852430f, -0.06739886f, 
    -0.04781162f, -0.01671547f, -0.08757474f, 0.00723595f, -0.00649340f, 0.06747001f, 0.01619228f, -0.05864293f, 
    0.06675415f, -0.07939367f, -0.05616763f, -0.08304890f, 0.00915426f, 0.00959113f, 0.06742173f, 0.06776410f, 
    -0.07008139f, -0.01143030f, -0.09015961f, 0.01832486f, 0.05188547f, 0.01525725f, -0.08895180f, 0.06637672f, 
    -0.04884978f, -0.02605972f, -0.07446062f, 0.05354470f, -0.04722228f, -0.08139241f, -0.00930317f, -0.01272645f, 
    -0.00740368f, 0.01835735f, -0.08265476f, 0.00937879f, 0.05326727f, -0.06208325f, 0.02104236f, 0.00504699f, 
    -0.04134854f, -0.05153174f, -0.03668908f, -0.01664143f, -0.00842702f, -0.06605402f, -0.04914371f, 0.06032366f, 
    -0.01938309f, 0.03592839f, -0.01431482f, 0.00587535f, 0.07014889f, -0.03951883f, -0.04920225f, -0.01214096f, 
    0.02998516f, -0.03298732f, 0.01944703f, -0.08614612f, -0.01675964f, 0.02420892f, 0.01529571f, -0.08056597f, 
    -0.04777557f, -0.06055332f, 0.03454306f, 0.02230922f, 0.01744518f, -0.07138173f, -0.03595209f, -0.07081579f, 
    -0.06361629f, 0.01330826f, -0.01864836f, -0.04309358f, 0.04053235f, 0.00164620f, 0.01590974f, 0.07298122f, 
    -0.00096670f, 0.00396718f, -0.07767655f, -0.07785569f, -0.05597844f, -0.03083646f, 0.00478869f, 0.02324892f, 
    -0.03555650f, -0.02544072f, -0.03104270f, 0.03874585f, 0.05717322f, 0.05659123f, 0.07009018f, -0.06038861f, 
    -0.06045115f, 0.01965261f, 0.07215779f, 0.06527726f, -0.06214833f, -0.04510590f, 0.01967744f, -0.00268135f, 
    0.03470222f, -0.05401685f, -0.00384950f, -0.02516759f, 0.01670844f, -0.05093859f, 0.00860808f, 0.04880213f, 
    0.04659792f, 0.03242997f, -0.06152414f, 0.06176495f, -0.09377660f, -0.02555370f, -0.02796300f, 0.05301196f, 
    -0.03836449f, -0.01461033f, -0.00421056f, -0.08126777f, -0.03011210f, 0.00885751f, -0.05415456f, -0.02237926f, 
    -0.08382329f, 0.01897270f, -0.07438691f, 0.02351363f, -0.08924370f, -0.03548347f, -0.08315513f, 0.03446447f, 
    -0.08576575f, -0.06857201f, -0.02857650f, -0.09372394f, -0.03048907f, 0.04316141f, 0.02459154f, 0.04779914f, 
    -0.02520540f, -0.05187013f, 0.06126343f, -0.08059863f, -0.05156830f, -0.06464321f, -0.02275577f, 0.06554624f, 
    0.02488651f, 0.01332357f, -0.00621119f, -0.03705591f, -0.00347766f, -0.00455331f, -0.03442386f, 0.00180249f, 
    0.04190621f, -0.02756862f, -0.03034125f, -0.04533055f, -0.07594763f, -0.03120472f, 0.07136310f, 0.02110476f, 
    0.05908899f, -0.04087012f, -0.01940419f, 0.01227913f, -0.05805852f, 0.06298483f, -0.05475743f, 0.05599042f, 
    -0.04985879f, -0.01318008f, 0.05056377f, -0.05245883f, -0.05772400f, 0.02190871f, -0.05980398f, -0.02840915f, 
    -0.03447152f, -0.07885849f, 0.00650746f, 0.06217810f, 0.04817506f, 0.02030473f, -0.05685536f, 0.05386402f, 
    0.03791260f, 0.01709492f, 0.06611000f, -0.03008770f, -0.04293384f, -0.07387480f, -0.06092346f, -0.05903950f, 
    -0.06651098f, -0.08195405f, 0.04340148f, -0.01135985f, 0.02952123f, -0.05251108f, -0.06165491f, 0.05543763f, 
    0.06320360f, -0.00234055f, 0.06530244f, 0.00006603f, -0.05704612f, -0.01927792f, 0.06582952f, -0.00810553f, 
    -0.03333580f, -0.05919532f, 0.04721690f, 0.05940565f, -0.06699040f, 0.02456629f, -0.08201183f, -0.03930678f, 
    0.03974369f, -0.02806363f, 0.02704581f, 0.00916080f, -0.05774440f, 0.04907047f, -0.04664645f, 0.00895260f, 
    0.01006694f, -0.02795923f, -0.07491535f, 0.02833507f, 0.05309833f, -0.07827679f, -0.08097170f, -0.06867912f, 
    0.01709363f, -0.06694284f, -0.01378703f, -0.08767035f, -0.04149853f, 0.06954395f, -0.04464265f, -0.00904003f, 
    0.06170181f, 0.04852753f, -0.06388097f, 0.02004653f, 0.06050907f, -0.01260901f, 0.02596533f, -0.05818426f, 
    -0.05452788f, 0.04092074f, 0.01820143f, 0.02247644f, 0.07327414f, -0.03834654f, -0.07599016f, -0.03182583f, 
    -1.03582585f, -0.05979103f, -0.06394339f, -0.00548316f, 0.08017322f, 0.27779138f, 0.29529804f, -0.03060068f, 
    -0.09135792f, 0.30965719f, 0.71467274f, -0.02665941f, -0.22079387f, -0.39151794f, -0.09840681f, 0.07591120f, 
    0.22573230f, 0.22154315f, 0.51366705f, 0.36606526f, 0.39119902f, 0.09066153f, 0.41450357f, -0.20895092f, 
    -0.01754076f, -0.09901632f, 0.10044266f, 0.47105014f, 0.21734519f, -0.40279064f, -0.06814554f, 0.06432886f, 
    0.18960649f, 0.12441625f, 0.14798138f, 0.08673293f, -1.27602923f, -0.10456000f, 0.24931844f, -0.06738453f, 
    0.23116787f, 0.39008293f, -0.29613590f, 0.00872688f, -0.01192115f, -0.47924751f, 0.27905560f, 0.22038496f, 
    0.02972843f, -0.10348829f, 0.09921233f, -0.06656505f, -0.12226439f, -0.12954372f, 0.69045812f, -0.04577866f, 
    0.12973717f, -0.16104028f, -0.08332100f, -0.06834511f, 0.09247645f, 0.20485142f, 0.17157544f, 0.04139964f, 
    -0.35949120f, -0.01837871f, -0.25609919f, -0.04778235f, 0.16273665f, 0.03449770f, -0.00122128f, -0.38735029f, 
    0.25445914f, -0.14577714f, -0.18599457f, 0.01134420f, 0.16386490f, -0.09095716f, -0.14260617f, 0.11697187f, 
    -0.02199839f, 0.16047083f, -0.04146538f, 0.34233397f, -0.21780898f, -0.21109952f, -0.02400177f, -0.01204443f, 
    -0.07010924f, 0.28314203f, 0.02051559f, -0.32006216f, -0.32873443f, 0.01505920f, 0.39026576f, 0.13908657f, 
    -0.20097734f, 0.00997534f, -0.32872123f, 0.42510647f, -0.16618602f, -0.13746761f, 0.05445857f, 0.27453420f, 
    -0.04186307f, 0.19508588f, 0.31548402f, 0.05192015f, -0.14949176f, 0.06873845f, 0.01569574f, 0.23427217f, 
    -0.01708153f, -0.12925486f, -0.26195961f, 0.05913070f, -0.01012335f, 0.22822733f, 0.14198300f, 0.18919486f, 
    -0.23179880f, -0.27828011f, 0.12649065f, 0.28364569f, -0.03380857f, 0.13677448f, 0.11859112f, 0.10516058f, 
    -0.18370387f, -0.13163346f, 0.00917920f, -0.18311238f, 0.07549957f, 0.15973760f, 0.02846925f, 0.04987851f, 
    -0.36606583f, 0.33172336f, -0.27383918f, 0.00535097f, 0.11353312f, -0.21023259f, 0.14024146f, -0.01729677f, 
    -0.03320961f, 0.06154055f, -0.00965970f, -0.05009969f, 0.06724353f, -0.05859321f, -0.02976353f, -0.01234970f, 
    -0.04163627f, 0.03265867f, 0.02183434f, -0.07182121f, -0.05326060f, -0.03739821f, -0.04113583f, -0.04175363f, 
    -0.00371089f, 0.07675639f, 0.00435561f, 0.01879616f, 0.01848565f, 0.02435469f, 0.05828224f, 0.04791886f, 
    -0.01321572f, -0.04123591f, 0.01754947f, -0.00031920f, 0.03411957f, 0.04280052f, -0.06804936f, -0.02481480f, 
    0.03600067f, -0.06260522f, 0.07488077f, -0.03169079f, -0.06641440f, 0.05762915f, -0.05688664f, 0.04915043f, 
    0.07326113f, 0.01975858f, -0.00814167f, -0.04178271f, 0.04348904f, -0.01925258f, -0.05690917f, -0.00787289f, 
    -0.08750375f, 0.01528669f, -0.03074300f, -0.00461904f, 0.02542071f, -0.07162400f, -0.06906052f, 0.00943291f, 
    -0.07233994f, -0.01772669f, -0.00925311f, -0.04156366f, -0.05400016f, -0.04022165f, -0.07459273f, 0.02834541f, 
    -0.05115975f, 0.00651095f, -0.01325007f, -0.04662439f, -0.03883799f, -0.02009333f, 0.02672534f, -0.04400015f, 
    0.01027966f, -0.05485449f, 0.05919546f, -0.00257803f, -0.00636256f, 0.03229547f, -0.06087507f, -0.00548730f, 
    -0.03521893f, -0.08292605f, -0.08481650f, 0.06106184f, -0.02503105f, 0.05392317f, 0.05613691f, -0.00006492f, 
    0.06664421f, 0.07352088f, 0.06723364f, -0.07559544f, -0.08218723f, 0.01891976f, 0.03118128f, -0.03828920f, 
    0.00873479f, 0.00400899f, -0.08279734f, 0.04786409f, -0.06429887f, 0.01189972f, -0.05578551f, 0.01857105f, 
    0.03571373f, -0.05159073f, -0.08465128f, 0.05303502f, 0.00973856f, -0.04117871f, -0.07133288f, -0.01625976f, 
    -0.02215087f, 0.05306012f, -0.02116784f, -0.08157083f, 0.05348121f, -0.07209142f, 0.04994755f, -0.00018598f, 
    -0.03694461f, 0.03867192f, -0.04220798f, -0.06676602f, -0.01347629f, -0.01319176f, 0.01546992f, -0.00115369f, 
    -0.02703838f, 0.06748976f, 0.02291832f, -0.07895087f, -0.03215145f, -0.06416698f, -0.04990446f, 0.05639214f, 
    -0.05390896f, -0.06317323f, -0.03838847f, 0.02378510f, 0.06192591f, 0.00489992f, -0.05045391f, -0.07598109f, 
    -0.06223409f, -0.01957483f, -0.01334195f, -0.08516185f, -0.00715023f, -0.05952007f, 0.00170780f, -0.02051864f, 
    0.03340555f, -0.03753854f, -0.07090613f, -0.08251922f, -0.02134735f, -0.01458264f, -0.02049150f, 0.01699768f, 
    -0.03564949f, -0.05723384f, -0.00694477f, 0.05893073f, 0.02204313f, -0.03964398f, 0.05613120f, -0.01471369f, 
    -0.09214842f, 0.02824345f, -0.03253805f, -0.03705195f, 0.02260495f, -0.04852013f, 0.01537411f, 0.02952858f, 
    -0.01898406f, -0.05023245f, 0.04834505f, -0.05420362f, -0.04712498f, -0.01218828f, 0.00341885f, 0.04523312f, 
    0.07217711f, -0.04025132f, -0.00228545f, 0.06190443f, -0.04563942f, 0.03702190f, -0.02610064f, -0.01933189f, 
    0.06269846f, -0.03498846f, -0.04987428f, -0.04514881f, 0.00112315f, -0.00874342f, -0.03515876f, -0.04586564f, 
    -0.07396606f, -0.04727588f, 0.01765376f, 0.01636394f, -0.02227319f, -0.08157083f, -0.08535751f, 0.04439124f, 
    0.03239982f, 0.03080104f, 0.00913121f, -0.00080938f, -0.00069894f, 0.05880703f, -0.07190994f, -0.02198590f, 
    -0.08902025f, -0.00933738f, 0.05169416f, -0.07754993f, 0.02575834f, 0.04517918f, 0.01939640f, -0.06662348f, 
    -0.06050321f, 0.05395726f, 0.05133010f, -0.05742998f, 0.05116456f, -0.01033220f, -0.05998976f, -0.01410398f, 
    -0.08278910f, -0.04095175f, 0.06726201f, 0.00303763f, 0.02788179f, -0.06330458f, -0.03543663f, -0.01855044f, 
    0.03910803f, -0.05817062f, -0.03212586f, 0.01810730f, 0.05922850f, -0.02614242f, 0.03587728f, -0.08972109f, 
    -0.03371961f, 0.01669179f, -0.07743574f, -0.00036368f, -0.06184394f, -0.08572657f, -0.01868037f, 0.01614263f, 
    -0.07402176f, -0.05587616f, -0.08702031f, -0.03666456f, 0.02689368f, 0.06877975f, 0.06873846f, -0.02081474f, 
    -0.05169016f, 0.05784643f, 0.06169813f, 0.00193654f, 0.05890433f, -0.06752315f, -0.03910163f, 0.05656324f, 
    0.03964424f, -0.06614619f, -0.02709593f, 0.02687157f, 0.05243862f, 0.04264478f, 0.04807353f, 0.06772915f, 
    -0.06731105f, -0.04358901f, -0.03127221f, 0.00878592f, 0.05161332f, 0.01028835f, 0.00694291f, 0.00842357f, 
    -0.10810288f, 0.15341821f, 0.21977200f, -0.08638420f, 0.02257365f, 0.04750655f, -0.14141342f, 0.14895391f, 
    0.09046223f, -0.19483422f, -0.30757046f, -0.22899567f, 0.02852549f, 0.08483662f, 0.17911260f, 0.03366355f, 
    -0.13760620f, -0.08208510f, -0.42814535f, 0.34500635f, -0.40767628f, 0.09902856f, -0.00215504f, 0.01706599f, 
    -0.20170218f, -0.09995558f, -0.15782960f, 0.17784749f, -0.12649082f, -0.43333960f, 0.00608219f, -0.15608214f, 
    0.14860745f, 0.16471913f, 0.11654513f, -0.11299197f, -0.07679845f, 0.20926231f, 0.29228121f, 0.03809067f, 
    -0.07651994f, -0.10700312f, 0.04874743f, 0.10326058f, 0.06246461f, 0.20534453f, -0.02841390f, -0.43206486f, 
    -0.00058517f, -0.09085576f, 0.14983159f, 0.13052022f, -0.08049704f, -0.05315366f, -0.41494712f, -0.63030154f, 
    -0.68922955f, 0.10150749f, -0.08046287f, 0.04749776f, 0.01680208f, -0.04843755f, 0.08609844f, 0.32796952f, 
    -0.07314606f, 0.28101596f, -0.10944159f, -0.12839511f, -0.37330681f, 0.05522308f, 0.13130622f, 0.18108779f, 
    -0.39237326f, 0.14766701f, 0.09474897f, -0.13729851f, -0.06584907f, -0.17893095f, 0.03032817f, -0.08473166f, 
    0.13855682f, -0.23533908f, -0.30823055f, -0.09025948f, 0.00447488f, -0.16932589f, 0.04699538f, 0.10797907f, 
    0.09647703f, 0.19968264f, -0.06075567f, 0.38202175f, -0.15436600f, 0.06901114f, -0.10213402f, -0.01502014f, 
    -0.04442303f, -0.06159072f, -0.08121596f, 0.54956990f, 0.27704507f, 0.18759651f, 0.11241465f, -0.01337121f, 
    0.16104063f, 0.01907364f, -0.06099829f, -0.03829584f, -0.51131451f, -0.08973622f, -0.27406636f, 0.12137261f, 
    0.15970396f, -0.15228893f, 0.00952873f, 0.12122612f, -0.06674240f, 0.00903991f, 0.18099876f, 0.14630783f, 
    -0.19291726f, -0.10144957f, 0.17873043f, 0.01855935f, -0.07559624f, 0.07197639f, 0.61304033f, 0.45071426f, 
    -0.23694833f, 0.04448584f, 0.05079583f, 0.00303163f, -0.11859968f, 0.05667721f, 0.02228583f, 0.54624861f, 
    0.61686462f, 0.80419141f, 0.25101584f, 0.06951043f, -0.08811393f, 0.01677059f, 0.18739662f, 0.07682892f, 
    0.51868606f, 0.12182157f, 0.04291885f, -0.35508108f, -0.26795489f, -0.04380387f, 0.07557990f, 0.15274115f, 
    0.16350518f, -0.04728818f, -0.29975727f, 0.02839217f, -0.08731849f, -0.01455854f, 0.09567049f, -0.12135175f, 
    0.15967208f, 0.05542792f, 0.18939710f, 0.26963320f, 0.03578910f, 0.19582164f, -0.16711339f, -0.06317426f, 
    0.13428436f, -0.05913274f, 0.03489314f, -0.12558222f, -0.03771491f, -0.09628831f, -0.25232837f, -0.07141440f, 
    -0.21853194f, -0.05225120f, -0.01910315f, -0.05548438f, 0.18027499f, 0.12062477f, 0.10654754f, -0.08696952f, 
    -0.18514979f, 0.21839266f, -0.02575235f, 0.29187423f, -0.25368595f, 0.69859129f, 0.16632962f, -0.10160334f, 
    -0.13190129f, -0.03777139f, -0.05452061f, -0.00538803f, -0.00260950f, 0.08289481f, 0.09967384f, -0.51044047f, 
    -0.11115872f, -0.13810636f, -0.06604062f, 0.00410450f, 0.21955046f, -0.09827494f, -0.01500930f, -0.49161243f, 
    0.05921748f, 0.41035423f, -0.03557392f, -0.01551294f, 0.02378920f, -0.02634128f, 0.11759692f, 0.04368646f, 
    0.02705962f, -0.39982691f, -0.20454781f, 0.02411060f, 0.17129526f, -0.00576051f, -0.11432339f, -0.05120222f, 
    -0.06807288f, -0.41384038f, 0.19892476f, -0.30658543f, -0.09246451f, 0.04623396f, -0.07258414f, -0.28528789f, 
    0.00063454f, 0.13418527f, -0.37508997f, 0.22971085f, 0.30551401f, 0.08524610f, 0.07716034f, 0.02801690f, 
    -0.12406790f, 0.01693183f, -0.10142140f, -0.10783930f, 0.17826550f, -0.07444789f, 0.10449238f, 0.00771106f, 
    0.27186683f, -0.00695023f, -0.10727008f, -0.10074501f, 0.46238524f, -0.09287684f, -0.24061090f, 0.40618515f, 
    0.09193522f, 0.07182591f, 0.00577389f, -0.02194668f, 0.06021848f, 0.12476100f, 0.25774434f, -0.52212000f, 
    -0.05062366f, 0.16200070f, -0.10865185f, -0.09775680f, 0.02545052f, 0.13888392f, 0.23221968f, -0.23515710f, 
    0.08593094f, 0.06034988f, -0.05007889f, -0.10013773f, 0.10744326f, -0.01789400f, -0.07641100f, 0.20940614f, 
    0.08608512f, -0.16278829f, -0.35032451f, -0.03969606f, 0.02195527f, 0.17466258f, 0.03831518f, 0.23275772f, 
    -0.01312917f, -0.04301438f, -0.08316098f, 0.02196742f, -0.08773139f, 0.05422167f, -0.05545853f, -0.03525578f, 
    0.03481439f, -0.01932741f, -0.01714201f, 0.03959361f, -0.00555429f, 0.02196438f, 0.01199753f, 0.05891360f, 
    0.05529806f, -0.07723448f, -0.03857779f, -0.08634628f, -0.02956140f, 0.04505079f, 0.07291485f, -0.05857078f, 
    -0.07960515f, -0.08838295f, -0.01060174f, -0.01479484f, -0.06060081f, 0.00866983f, 0.05848596f, -0.07648033f, 
    -0.06239028f, -0.06007612f, -0.02493235f, -0.08512459f, -0.02388407f, -0.08546687f, -0.04126764f, 0.02091039f, 
    0.03926431f, -0.00704644f, -0.07355809f, 0.00886198f, 0.06250645f, 0.07158015f, 0.04698398f, 0.00721260f, 
    0.03091118f, 0.02645966f, -0.08620238f, -0.04892267f, -0.01298652f, 0.07320178f, -0.00828911f, -0.06652509f, 
    0.06055024f, -0.04334798f, -0.09053963f, -0.06998190f, 0.03743005f, 0.04654562f, 0.05965283f, 0.01989701f, 
    -0.01823191f, 0.04929289f, -0.00985772f, 0.01533279f, -0.08807638f, -0.06769545f, 0.01823047f, 0.00376158f, 
    0.00045950f, -0.04548157f, 0.05343855f, -0.00557942f, 0.04641192f, -0.03946723f, 0.02109735f, -0.08313446f, 
    -0.04228538f, -0.01397008f, 0.00980482f, -0.08242817f, -0.05235963f, -0.06469062f, -0.02395085f, 0.01454092f, 
    0.01186575f, -0.01697456f, 0.06366812f, -0.01760303f, -0.03288901f, -0.09579051f, -0.00845419f, 0.03119219f, 
    -0.07987633f, 0.04696599f, 0.03737247f, 0.04242254f, 0.04996813f, -0.05544911f, 0.03333378f, 0.04019390f, 
    0.02564165f, -0.04331386f, -0.06992584f, 0.06430204f, -0.02519718f, -0.00203443f, 0.01192699f, 0.00540557f, 
    -0.04461789f, 0.00955975f, 0.03821128f, -0.07681809f, -0.02817719f, -0.08297028f, -0.03443483f, -0.03018863f, 
    0.02360672f, -0.08290772f, 0.01254915f, -0.04568237f, -0.02713854f, 0.04765144f, -0.01807312f, 0.04822349f, 
    -0.03609626f, -0.03781760f, 0.05007610f, -0.09199143f, -0.08721778f, -0.08314619f, -0.01975903f, 0.01474024f, 
    -0.01186738f, -0.01909519f, -0.04718545f, -0.02800813f, 0.03953489f, -0.01090433f, -0.04687877f, -0.04277514f, 
    -0.06630924f, 0.45668161f, 0.69355303f, 0.05786873f, -0.12659650f, -0.14407361f, -0.04115115f, 0.25279748f, 
    0.04126913f, -0.72330445f, -0.37252179f, -0.65612811f, 0.01108270f, 0.37384677f, -0.17740129f, -0.21919507f, 
    0.01062611f, 0.03673190f, 0.14355606f, 0.48305598f, -0.12847923f, -0.04445467f, 0.27741271f, -0.19729699f, 
    0.02820664f, 0.09406684f, 0.00112288f, 0.52858353f, -0.32482681f, -0.06498898f, -0.15254509f, -0.01231261f, 
    -0.04045942f, -0.07320645f, -0.08072793f, 0.29517084f, -0.03497861f, 0.02747043f, 0.38639361f, 0.20219219f, 
    -0.14024642f, -0.03961516f, 0.10584204f, 0.07942468f, -0.32969943f, 0.01602137f, 0.34659162f, 0.49521887f, 
    -0.09076016f, -0.16286074f, -0.16012609f, 0.07837527f, 0.08823796f, -0.04333885f, -0.21123044f, 0.23681961f, 
    0.08903138f, -0.15684064f, -0.01754703f, -0.05614400f, 0.10506754f, 0.14249264f, 0.33886844f, 0.33890334f, 
    -0.86962855f, -0.26376528f, 0.03043237f, 0.16766433f, 0.09709514f, 0.11392412f, 0.11056361f, -0.19690137f, 
    -0.27472812f, -0.48946783f, 0.33182564f, 0.04300094f, -0.08897343f, 0.16797505f, -0.09446277f, -0.31461838f, 
    0.00638169f, -0.15423550f, -0.47740716f, -0.26918834f, 0.31146416f, 0.03864332f, 0.03338429f, 0.20724855f, 
    0.19540025f, -0.17131193f, 0.02996749f, -0.01658690f, -0.21945739f, -0.10986363f, 0.02102067f, 0.14801836f, 
    -0.16820607f, 0.03146732f, 0.19079150f, -0.07745398f, -0.47777882f, 0.01800784f, -0.00082959f, -0.20276144f, 
    0.07357702f, 0.16876473f, -0.16851160f, 0.05691611f, -0.07625360f, 0.32807821f, -0.03310199f, -0.25570941f, 
    0.16973799f, 0.05419735f, 0.03798364f, 0.00290325f, 0.00374622f, 0.08302704f, -0.31456521f, 0.01664086f, 
    0.09359454f, 0.05343497f, 0.30115497f, 0.00545842f, -0.17898561f, -0.07060850f, 0.05922395f, -0.14653446f, 
    0.04632157f, -0.01573910f, 0.00081972f, -0.11536506f, 0.00248059f, -0.00061762f, -0.05400980f, -0.11242895f, 
    0.06326537f, -0.36567113f, 0.13988170f, 0.04855818f, 0.15412182f, -0.07677212f, -0.07617728f, -0.01901847f, 
    -0.65948719f, -0.39724538f, 0.04418232f, 0.00171101f, -0.22754419f, -0.09739079f, 0.13429770f, -0.16403826f, 
    -0.00786813f, 0.24634010f, 0.32004154f, 0.03224121f, -0.00156849f, 0.12002069f, -0.12474140f, 0.14242592f, 
    -0.17662267f, -0.15510222f, 0.14294800f, -0.66081536f, 0.13569976f, -0.09973670f, 0.03621990f, 0.29052657f, 
    -0.13407248f, -0.14645551f, 0.09351426f, -0.25042376f, -0.24079360f, 0.10758886f, 0.23114277f, -0.07833637f, 
    -0.12334359f, -0.09467862f, -0.08117095f, 0.03891766f, -0.31106499f, -0.19726761f, -0.00534705f, 0.43513560f, 
    -0.04180513f, -0.03372754f, -0.18391494f, 0.06700522f, -0.03914987f, -0.82164198f, -0.47492605f, -0.09736338f, 
    0.21015601f, 0.10108418f, -0.04905195f, -0.05446974f, -0.13545041f, 0.13551866f, -0.18752661f, -0.39628527f, 
    -0.10084723f, -0.09387057f, 0.25460073f, -0.09926689f, 0.00569272f, 0.03645142f, -0.03632010f, 0.21433811f, 
    0.18176273f, -0.59481394f, -0.00822829f, -0.12870587f, -0.18344352f, -0.05488346f, 0.10729723f, -0.06420946f, 
    0.44101632f, -0.05801886f, -0.14920934f, 0.12746325f, -0.02036574f, -0.03710093f, 0.34373140f, 0.08611055f, 
    0.10458578f, 0.06142253f, 0.65213597f, -0.07735907f, -0.04404102f, -0.10290468f, -0.02397932f, -0.13016690f, 
    0.04740974f, 0.01399564f, -0.31783116f, -0.15994662f, 0.25496054f, 0.04432163f, 0.12943470f, 0.22168010f, 
    -0.14288698f, 0.03678871f, 0.24455395f, 0.27003554f, 0.52202058f, 0.50109655f, -0.04840681f, 0.25399873f, 
    -0.02498083f, 0.07279034f, 0.17002816f, 0.19143324f, 0.44068721f, -0.26437643f, 0.24741569f, 0.09198859f, 
    -0.02180915f, 0.20946020f, -0.10203913f, 0.06279483f, 0.03694602f, 0.46147749f, 0.11393385f, 0.08943141f, 
    -0.07828271f, -0.05688705f, 0.07262332f, 0.01915795f, 0.21448615f, -0.36683646f, -0.68317586f, -0.34490135f, 
    -0.09744329f, -0.13551646f, -0.00304183f, 0.00526610f, 0.21303217f, 0.18066822f, 0.39250425f, -0.18975212f, 
    0.54397017f, -0.14355454f, 0.38072768f, -0.03526811f, -0.14134638f, 0.19779213f, 0.12582570f, 0.07300976f, 
    -0.05784914f, 0.06989136f, 0.02869337f, -0.03243921f, -0.00550027f, 0.00123115f, 0.01384443f, -0.02243128f, 
    -0.06015727f, 0.03783853f, -0.01268381f, -0.03906573f, -0.01858204f, -0.00189785f, -0.03293991f, -0.01859866f, 
    -0.03055240f, 0.00526687f, 0.02748711f, -0.07589207f, -0.08107442f, -0.01465592f, 0.00737685f, -0.02002566f, 
    -0.04317263f, 0.00764911f, 0.05138598f, -0.02340374f, -0.07947274f, 0.01472810f, -0.07044743f, -0.04544501f, 
    -0.01236487f, 0.01176951f, 0.03564170f, 0.02932695f, -0.07074286f, -0.05316856f, -0.03571175f, 0.05603907f, 
    0.06782497f, -0.06576695f, -0.06853983f, -0.05586371f, -0.01000553f, 0.06547200f, -0.00414251f, -0.05639334f, 
    0.07536459f, 0.03992610f, 0.04579241f, -0.01995858f, -0.01051420f, 0.00870990f, -0.06203105f, -0.01784068f, 
    -0.08911020f, -0.05125625f, 0.06882166f, 0.06391687f, -0.04607201f, 0.06238523f, 0.02387192f, -0.07786291f, 
    -0.00620095f, -0.08286754f, 0.07594036f, 0.01768462f, -0.03999158f, -0.02130968f, -0.01695339f, -0.03236887f, 
    0.00050357f, 0.04611959f, -0.01546893f, -0.05952014f, -0.00752932f, -0.00203687f, -0.00097519f, -0.07802515f, 
    -0.00268528f, 0.02566351f, 0.06199509f, -0.01163087f, 0.03299683f, 0.02563637f, 0.00180622f, -0.06547830f, 
    -0.03539188f, 0.05282865f, -0.09353945f, -0.04983743f, -0.01297855f, -0.06053660f, -0.00741703f, 0.03587678f, 
    -0.06341381f, -0.01750552f, -0.08867428f, -0.00092096f, -0.09304953f, -0.06188291f, -0.02497880f, -0.08239305f, 
    -0.04490391f, -0.04852327f, 0.01183182f, -0.08613586f, -0.09727228f, -0.04210210f, -0.06597228f, -0.03281040f, 
    0.05181871f, -0.00891879f, 0.00304571f, -0.00636246f, 0.03742886f, 0.03787433f, 0.00100130f, -0.00637558f, 
    -0.03109732f, 0.04388937f, -0.06868859f, 0.03087667f, -0.04970729f, 0.03080767f, 0.06135229f, 0.05560007f, 
    0.02725322f, 0.01029940f, -0.01810142f, 0.03475660f, -0.07198202f, -0.06937109f, -0.01205319f, 0.00862676f, 
    -0.01676909f, -0.06041715f, -0.00749556f, 0.06312315f, -0.04089906f, 0.03166596f, -0.04955027f, 0.05994576f, 
    0.05770857f, 0.14962630f, 0.01095326f, 0.31283554f, -0.00566740f, -0.07851371f, 0.17640838f, 0.15328966f, 
    -0.13546172f, -0.49200490f, -0.07000109f, 0.01014433f, -0.01841391f, -0.07496945f, -0.13454519f, 0.10780835f, 
    0.05755378f, -0.07490041f, 0.01653838f, 0.40062428f, -0.27666429f, 0.14959151f, -0.03113030f, -0.04863828f, 
    0.17749570f, -0.04824840f, -0.14186165f, -0.54105300f, 0.35309884f, -0.11408435f, 0.09413231f, 0.00536272f, 
    -0.13785197f, -0.15681866f, 0.06139980f, 0.04998484f, 0.01984623f, -0.05657872f, -0.22815889f, 0.03572633f, 
    0.22249043f, 0.08571412f, -0.14205976f, -0.02302292f, -0.12272073f, -0.11794002f, 0.06958769f, -0.19099844f, 
    0.25763795f, -0.16749758f, 0.06792804f, -0.21624745f, 0.13267826f, 0.02323870f, -0.39657238f, -0.04534612f, 
    -0.37005723f, -0.15927833f, 0.01131152f, 0.12915100f, -0.04419901f, 0.03791708f, 0.04639486f, -0.02501920f, 
    0.06156478f, -0.26473552f, -0.06830281f, -0.25694731f, 0.16412798f, 0.12446262f, -0.10454122f, 0.12661980f, 
    0.60678053f, 0.08658681f, 0.55925912f, -0.20932725f, 0.12957099f, 0.15637168f, 0.13489348f, 0.07694232f, 
    -0.04368748f, 0.01992721f, -0.30735648f, 0.10977814f, 0.07356133f, -0.16046867f, -0.22950473f, 0.00982994f, 
    0.11613587f, 0.02113854f, 0.05846556f, -0.16518719f, -0.45358405f, 0.02012203f, 0.08972927f, 0.28415960f, 
    -0.05475565f, -0.04591399f, -0.21697895f, 0.21670730f, -0.28224754f, 0.66638047f, -0.20180106f, 0.03793193f, 
    0.11805032f, -0.19024037f, 0.02360703f, 0.10840254f, -0.00999919f, 0.40470371f, -0.56142056f, 0.13810740f, 
    0.06828043f, -0.12675321f, 0.12544952f, 0.09852709f, -0.04005302f, 0.12316687f, 0.10507624f, 0.51783729f, 
    -0.20575692f, -0.25706810f, 0.08206835f, 0.24865155f, 0.00670102f, 0.18543524f, -0.04938643f, -0.14740674f, 
    -0.09363887f, 0.08161297f, -0.00957224f, 0.10733910f, -0.06789527f, -0.22124042f, -0.01003371f, -0.56193143f, 
    -0.46874124f, 0.57730144f, 0.19854018f, -0.03535382f, 0.10973328f, -0.17221810f, -0.01864027f, 0.08422415f, 
    0.06029064f, 0.00646687f, -0.00958591f, -0.06163967f, -0.04997744f, 0.00568187f, 0.02958411f, -0.07652590f, 
    -0.06631254f, 0.02646095f, -0.01760862f, 0.07598335f, -0.05944803f, 0.05414006f, 0.00164398f, -0.02751227f, 
    -0.07484376f, 0.03850669f, -0.08373335f, 0.06203545f, -0.04928641f, -0.06955853f, 0.00345418f, 0.03375235f, 
    0.02317778f, -0.06998089f, -0.07457639f, 0.05587851f, -0.00154865f, 0.03912584f, -0.01659143f, 0.01562898f, 
    -0.05483527f, -0.04848072f, -0.08951391f, 0.06077166f, 0.05993740f, -0.00451798f, -0.02541537f, -0.01541377f, 
    -0.06028851f, -0.00424025f, 0.03911330f, 0.05899969f, 0.04037445f, 0.03887318f, 0.04750567f, 0.07194986f, 
    0.03887005f, 0.04279224f, -0.05084294f, -0.07880686f, -0.01146505f, -0.03349214f, 0.00981163f, -0.05971575f, 
    -0.01198857f, -0.08951820f, -0.02964831f, -0.06409068f, -0.08735019f, -0.03056098f, 0.03545482f, -0.08946355f, 
    0.00925411f, -0.05773646f, -0.05260738f, 0.03252820f, -0.09100013f, 0.02506866f, -0.02811456f, -0.00052004f, 
    0.05364879f, -0.00505927f, -0.05533408f, 0.04857381f, 0.02075707f, -0.05195625f, 0.03324007f, -0.03723095f, 
    0.00896030f, -0.01555978f, -0.03395595f, -0.03739682f, 0.05932790f, -0.03057971f, 0.01293347f, -0.06866307f, 
    0.08199893f, 0.00020854f, -0.07934246f, 0.01701820f, -0.07804975f, -0.01015370f, 0.05674232f, -0.04619437f, 
    -0.08298314f, -0.07593777f, 0.04893212f, -0.05801905f, -0.00307119f, -0.00749686f, 0.06725482f, -0.06718045f, 
    -0.05358822f, -0.02592115f, -0.03736142f, -0.07416511f, 0.05250192f, -0.05284611f, -0.03018116f, -0.07745446f, 
    0.03641458f, -0.02994609f, -0.02228664f, -0.00426459f, -0.05831271f, 0.02205980f, -0.06826635f, -0.03377416f, 
    -0.00049397f, -0.07899565f, 0.05662213f, -0.07579333f, -0.03063581f, -0.02514262f, 0.01002854f, -0.02754864f, 
    0.04023738f, 0.07089642f, -0.07228520f, -0.06169568f, 0.03444820f, 0.03300953f, 0.00673419f, 0.02093365f, 
    -0.01851328f, -0.00412639f, -0.01940707f, 0.06847723f, -0.04622542f, 0.05585373f, 0.00527322f, -0.01138085f, 
    0.14370629f, 0.18488762f, 0.17696299f, -0.21978785f, 0.13811293f, 0.03997853f, -0.01145269f, 0.15371133f, 
    0.07258880f, 0.08844372f, 0.34657717f, 0.33279473f, 0.26502466f, 0.21625414f, 0.17480898f, 0.07049248f, 
    -0.43831778f, -0.19500114f, 0.39261994f, -0.50226992f, 0.28317535f, -0.46132469f, -0.15974383f, -0.05138087f, 
    0.00338088f, 0.08357026f, 0.25499746f, 0.46379054f, 0.43591601f, 0.20109493f, 0.03714148f, 0.06763063f, 
    0.02519203f, 0.28866556f, 0.07534900f, 0.09199350f, -0.14333935f, 0.18106988f, 0.15226841f, -0.21236540f, 
    0.04763155f, 0.02160248f, 0.30514279f, -0.25231406f, 0.02536322f, -0.19835193f, -0.05781857f, 0.13942705f, 
    -0.38012516f, -0.03401393f, 0.36647752f, -0.02716185f, 0.06728461f, 0.05380521f, -0.06969498f, -0.40833250f, 
    -0.18370534f, 0.17874257f, 0.17485844f, 0.03310219f, 0.11867250f, 0.01311303f, -0.03556665f, 0.02669318f, 
    0.54705894f, 0.53153276f, -0.02915968f, -0.20001405f, -0.35367122f, 0.06415094f, 0.23956910f, 0.06125953f, 
    0.39488947f, -0.54200327f, -0.65102333f, -0.26446962f, 0.00249508f, -0.09029730f, 0.02976104f, 0.15070209f, 
    0.19906184f, -0.63154888f, -0.52597958f, 0.35441712f, 0.25627413f, 0.15687618f, -0.10968642f, 0.15859109f, 
    0.11476545f, 0.21107744f, -0.28062102f, -0.09709729f, -0.31569883f, 0.00490076f, 0.05116380f, -0.08064830f, 
    -0.07438976f, -0.01959899f, 0.04928716f, 0.71124256f, 0.40832940f, -0.42060000f, 0.50127131f, 0.29107925f, 
    0.23309782f, 0.13676779f, 0.05785043f, -0.10034102f, -0.00052504f, 0.02094709f, 0.19185863f, -0.47473720f, 
    -0.16611053f, 0.24316113f, -0.25467733f, 0.08594445f, 0.15891589f, -0.32656488f, -0.08756164f, -0.38791326f, 
    0.21487412f, 0.09361347f, 0.17847911f, -0.23200981f, 0.08209372f, 0.05803383f, -0.44641998f, 0.03508835f, 
    -0.60559493f, -0.27499360f, -0.11845929f, 0.11529661f, -0.20299497f, -0.08870003f, -0.04767124f, -0.33568972f, 
    0.10803866f, 0.11361377f, 0.26876903f, 0.14104930f, -0.12390008f, 0.49553412f, 0.12251259f, 0.17131364f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.18553607f, 0.20543084f, -0.04993124f, -0.08605236f, -0.14024191f, -0.08330983f, 0.06312134f, -0.08502326f, 
    -0.17283306f, -0.02308859f, 0.54901826f, 0.13418984f, 0.00796519f, 0.15829347f, -0.07566691f, 0.20897473f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.41312870f, -0.36804429f, 0.03353368f, 0.01657369f, -0.23116483f, -0.11360149f, 0.13386844f, -0.18674278f, 
    0.18697742f, -0.18476725f, -0.31594574f, -0.08154269f, 0.04955178f, -0.09118417f, -0.24517295f, 0.70164800f, 
    0.50201553f, -0.50421983f, -0.22011526f, 0.04980922f, -0.28969985f, -0.12852462f, 0.21580307f, 0.48599732f, 
    0.43301547f, -0.13585511f, 0.08059581f, -0.15888128f, -0.19529182f, -0.77538002f, -0.18993391f, 0.21903792f, 
    -0.39885321f, -0.28151798f, -0.12858418f, -0.06104257f, 0.19662122f, -0.18191624f, 0.04643731f, 0.90340662f, 
    0.43673912f, 0.10384637f, 0.37938887f, -1.21303892f, -0.02304851f, -0.10603638f, -0.20078948f, -0.33936924f, 
    -0.52613217f, -0.13599634f, 0.02856914f, -0.00563923f, 0.59457898f, -0.13217339f, -0.04429648f, -0.74077988f, 
    0.18551968f, 0.08273894f, -0.46664578f, 0.27264023f, 0.13175988f, 0.21152747f, 0.20382003f, -0.46913069f, 
    -0.84434903f, 0.24901593f, 0.12695239f, -0.17083728f, 0.07892258f, -0.18532486f, -0.04636933f, -0.09393890f, 
    -0.79798043f, -0.04239659f, 0.44165757f, -0.36898327f, 0.08604135f, 0.24228367f, -0.09855895f, 0.13086666f, 
    0.45185596f, 0.22461051f, 0.11866679f, -0.01121234f, -0.59589565f, -0.23154698f, -0.23945984f, -0.24500293f, 
    -0.37117839f, 0.20882945f, 0.00631256f, 0.14041285f, 0.08541401f, -0.65039760f, -0.10149343f, 0.49161911f, 
    0.03141405f, 0.26385334f, -0.07727174f, -0.05122815f, -0.14326294f, -0.01516654f, -0.25489259f, -0.53470886f, 
    0.38696802f, -0.08315839f, 0.73476976f, -0.36537224f, -0.04807265f, -0.56199300f, 0.22134247f, -0.15741302f, 
    -0.89836222f, -0.63837045f, -0.03666059f, 0.05586655f, 0.20455261f, 0.06541681f, -0.23606913f, 0.49847990f, 
    -0.82997429f, -0.11936063f, -0.71031469f, 0.62827104f, 0.06254128f, 0.08821748f, -0.23641463f, 0.06474814f, 
    0.60755903f, -0.34748685f, -0.22392672f, 0.05452749f, -0.86156392f, 0.11603045f, -0.19904122f, 0.47080854f, 
    0.19865295f, -0.19994622f, -0.08623608f, 0.66406918f, 0.22206177f, 0.22646642f, -0.00446489f, -0.20864829f, 
    -0.11741098f, 0.28394747f, -0.11075570f, 0.05753764f, -0.30689365f, -0.00115939f, -0.06473992f, -0.54477578f, 
    -0.62868732f, 0.03549111f, 0.43821996f, -0.17589881f, 0.10453574f, 0.73281801f, -0.00088026f, 0.02837656f, 
    0.39789119f, 0.16856714f, -0.09188550f, 0.08269212f, 0.10523343f, -0.02296059f, -0.19357936f, -0.30193967f, 
    -0.21465661f, 0.00346601f, -0.41899335f, 0.74539953f, -0.11602587f, -0.17442925f, -0.03213661f, -0.67805558f, 
    -0.14006820f, 0.90027893f, 0.22405952f, 0.10765985f, -0.23922519f, 0.01088812f, 0.08348815f, -0.55344176f, 
    0.49473417f, 0.18544799f, -0.61696601f, 0.14277808f, 0.18256463f, -0.41206372f, -0.20771872f, -0.31447688f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.30145153f, 0.21022587f, -0.28134385f, 0.21297552f, 0.75331813f, 0.01331343f, -0.52026290f, -0.85318822f, 
    -0.39638877f, 0.11384832f, 0.40477836f, 0.15055132f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
