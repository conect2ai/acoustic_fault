#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.40674838f, 1.15899098f, 0.93972301f, 0.64801264f, 0.92402375f, -0.37543043f, -0.35754633f, -0.16088180f, 
    -0.73309994f, -0.80374289f, 0.49181810f, -0.00434010f, -0.05505814f, 0.01304989f, -0.07908375f, -0.01855997f, 
    0.39962277f, 0.51777297f, -0.06228268f, 0.72863424f, -0.27746060f, 0.16410188f, 0.02156718f, 0.42656311f, 
    0.70304102f, 0.95480204f, -1.20680356f, -1.48088431f, 0.58892256f, 0.47286940f, -0.90467262f, 1.02814233f, 
    0.82884532f, -0.17529306f, 0.52462929f, 0.41332993f, -0.05271342f, -0.41177776f, -0.38688585f, -0.07927155f, 
    -0.04333321f, -0.03256686f, -0.40049601f, -0.34345624f, -0.16573979f, -0.11742622f, -0.16971140f, -0.04916371f, 
    0.30083692f, -0.05983225f, -0.89198458f, 0.03695510f, 0.02034012f, 0.10133021f, -0.06030976f, -0.95986706f, 
    -0.60080570f, -0.60843623f, -0.71681023f, -0.69902688f, -0.73449445f, 0.39718744f, 0.35505149f, 0.74228364f, 
    0.07252739f, 0.04774975f, -0.52326399f, 0.35611379f, 0.42749423f, 0.07722082f, 0.57401013f, 0.15261513f, 
    -0.38552377f, 0.10099079f, 0.35744834f, 0.69310713f, 0.17749956f, -0.15999141f, 0.63672870f, 0.34306276f, 
    -0.61055332f, -0.80391455f, -1.34086597f, -0.95048857f, -0.32891670f, -0.62444443f, -0.35368690f, -0.19458228f, 
    -0.38215458f, -0.48771521f, -0.78106946f, -0.41629738f, -0.01757472f, -0.28200680f, -0.37351051f, -0.60900587f, 
    0.54003298f, -0.10026297f, -0.18374382f, 0.29971841f, 0.59999412f, 0.15832403f, 0.54585385f, 1.36373127f, 
    0.59593338f, -0.64399737f, 0.17341557f, 1.06054556f, 0.81565642f, -0.41692814f, -0.21097678f, -0.11649957f, 
    -0.15748285f, 0.06641225f, -0.39386764f, -0.04454553f, -0.02095756f, 0.54117179f, 0.03412987f, -0.05947878f, 
    0.78775060f, 0.36950085f, 0.08347811f, -0.19926171f, -0.48039451f, 1.84748578f, 1.07280743f, 1.15540659f, 
    0.22854608f, 0.36803615f, 0.21479715f, -0.05114535f, -0.09173974f, 0.82102209f, 0.48618335f, -0.20276666f, 
    -0.04242524f, -0.08777082f, -0.29082227f, 0.04853894f, -0.13381083f, 0.34327158f, -0.25179157f, -0.47840974f, 
    -0.40239710f, 0.20238352f, -0.21922190f, 0.31506047f, 0.06483174f, 0.07977436f, -0.82541645f, -1.01948142f, 
    -0.76497245f, -0.56741768f, -0.88012564f, 0.61207092f, 1.28714132f, 0.13177480f, 0.32053345f, 1.02334321f, 
    -0.07742496f, -0.49320400f, -0.19264722f, -0.55111992f, -0.04598724f, -0.06722219f, 0.27554038f, -0.14021148f, 
    0.07523292f, -0.17360440f, -0.20557162f, -0.31210729f, -0.21258703f, -0.38707805f, -0.07493455f, 0.93037558f, 
    0.74452400f, 0.85303277f, 0.09447069f, -1.41921651f, -1.30918062f, 0.68797719f, -0.75448561f, -0.06364553f, 
    -0.24153794f, 0.38591385f, -0.00031072f, -0.63761991f, -0.60791898f, 0.25031546f, -0.05915128f, 0.30808723f, 
    0.12515864f, 0.19477755f, -0.04113492f, -0.43402383f, -0.04298625f, -0.14397277f, -0.09189437f, -0.10282993f, 
    -0.18041432f, 0.35004082f, -0.88588041f, -0.71269971f, -0.65404475f, 1.20139062f, 1.23965549f, -1.16148210f, 
    -0.26367211f, 0.38306242f, 0.31345513f, 0.00888519f, 0.58493966f, 0.57220674f, 0.28039953f, 0.00475896f, 
    -0.10834899f, 0.19948678f, -0.03018387f, -0.07565168f, 0.17942308f, -0.24052310f, -0.09509551f, -0.11084972f, 
    0.23148274f, -1.03599966f, 0.30277899f, 0.92600870f, -0.03493531f, 0.86670578f, 0.01311354f, -0.22585389f, 
    -0.94488251f, -1.10721099f, -0.21400538f, 0.18056594f, 0.54810518f, 0.30007172f, 0.24248667f, 0.01933074f, 
    -0.10725924f, -0.63647121f, -0.08393974f, -0.70983076f, 0.34607819f, -0.14087215f, -0.46912864f, -0.47606549f, 
    -0.35560185f, -0.23638900f, 1.55712748f, 1.19730473f, 0.47873741f, -1.36064899f, -1.44511080f, 0.31287944f, 
    -0.63061708f, -0.04294859f, -0.69884831f, -0.01616396f, 0.55585176f, 0.54429901f, 0.24463721f, 0.40077105f, 
    -0.22981896f, -0.08943217f, -0.00294772f, 0.04378824f, 0.17397264f, 0.15524018f, 0.18046860f, 0.43464279f, 
    0.19301447f, -0.09360897f, 0.21104652f, -1.27325523f, -0.28134415f, 0.66819590f, 0.63358945f, 0.93876493f, 
    0.41918713f, 1.89092767f, 0.90909350f, -0.47889578f, 0.67594665f, -0.59415066f, 0.28658906f, 0.68906879f, 
    -0.25157198f, -0.37729669f, -0.33959037f, -0.41644120f, 0.07476649f, -0.29786980f, -0.42651981f, 0.24716659f, 
    -0.27144572f, -0.04869878f, 0.24620232f, -0.55022657f, -1.32367468f, -0.16137724f, -1.40479422f, -1.03526926f, 
    -0.93432087f, -0.05341370f, -0.41072842f, -0.09345509f, 0.18723285f, -0.39336246f, -0.47055200f, 0.22898561f, 
    0.10251428f, 0.27197456f, 0.08309890f, 0.28070465f, 0.16977453f, 0.08383808f, -0.01123629f, -0.14351983f, 
    -0.07670647f, 0.05924852f, 0.16719815f, -0.16639316f, 0.02500698f, 1.66206157f, -0.10129284f, -1.18292212f, 
    1.42362821f, 0.36653864f, -0.00963829f, 0.92183024f, -0.72470725f, 0.63082397f, 0.34293371f, 0.01912015f, 
    0.42045611f, 0.17819354f, 0.27471223f, 0.31569204f, -0.38854542f, -0.22991717f, 0.05482393f, 0.00389929f, 
    -0.31898159f, 0.17374529f, 0.36294234f, 0.19876117f, 0.00658077f, 0.18769491f, 1.26408947f, 1.16672707f, 
    0.38587821f, 0.99478382f, 1.39749384f, 0.24401878f, -0.29496047f, 0.59451753f, -0.49392077f, 0.50774074f, 
    -0.66692674f, 0.20431460f, 0.54462099f, 0.74407411f, 0.47929198f, 0.34793732f, -0.45701137f, 0.16111375f, 
    0.22999312f, 0.27671161f, 0.17867021f, -0.35049251f, 0.15389512f, -0.15375768f, -0.11552839f, 0.04249813f, 
    0.27529588f, -0.74108720f, -1.17663431f, 0.08509476f, 1.47236061f, 0.50155324f, 0.68640268f, 0.22367129f, 
    -0.00214477f, -0.34642768f, -0.67220920f, -0.49168560f, -0.03758730f, 0.00661885f, -0.09084949f, -0.32205603f, 
    -0.26088944f, -0.01135129f, 0.26871589f, 0.36459586f, 0.19969243f, 0.24337848f, 0.44125989f, 0.35003006f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31273019f, 0.10651731f, 0.51702529f, 0.32145911f, 0.09152663f, 0.54549825f, 0.00821316f, 0.28073952f, 
    0.26878235f, 0.10310899f, 0.52114731f, 0.26490432f, 0.25464642f, 0.36419216f, 0.22228248f, 0.08722857f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09497329f, 0.21819636f, -0.03931040f, -0.16687056f, -0.19433050f, -0.19759868f, -0.01949255f, 0.34163958f, 
    0.00190894f, -0.00258157f, -0.18675651f, 0.02467767f, -0.61142826f, 0.34842977f, 0.08986614f, 0.28910476f, 
    -0.03668091f, 0.22566421f, -0.23943394f, -0.08839142f, -0.11618088f, 0.04449444f, 0.04458452f, 0.09299258f, 
    -0.50558746f, 0.14066431f, -0.02409203f, 0.05743656f, -0.27353078f, 0.06061807f, 0.08537666f, 0.10218127f, 
    -0.04365214f, 0.11032960f, -0.23315765f, -0.05795790f, 0.43251187f, -0.13999692f, 0.14039654f, 0.34085089f, 
    -0.14565963f, 0.06214058f, -0.15617186f, 0.09991015f, -0.26830038f, -0.04816085f, -0.02410495f, 0.06250937f, 
    0.24924156f, 0.36213252f, 0.01660576f, 0.50944531f, -0.06445844f, 0.29186371f, -0.00690354f, -0.23577069f, 
    0.03669097f, 0.01146967f, 0.08171922f, -0.08260348f, 0.17490308f, -0.08781874f, -0.25783759f, -0.03222961f, 
    -0.16990045f, -0.43527773f, 0.10727167f, 0.13347116f, -0.08378985f, -0.00445338f, 0.10381937f, -0.18463983f, 
    0.62093890f, 0.15090872f, 0.40358388f, -0.62031657f, 0.21405333f, 0.11598406f, -0.15914272f, 0.13066591f, 
    0.07284838f, -0.08757991f, -0.02161277f, 0.12117732f, -0.11701578f, 0.34651583f, -0.14639528f, 0.23749039f, 
    -0.19516039f, 0.02878738f, -0.25531796f, -0.04939296f, 0.03829254f, 0.03220232f, -0.08085405f, -0.44229439f, 
    0.38766134f, -0.24757698f, 0.04363193f, -0.37031427f, -0.31721261f, -0.03479319f, 0.00674334f, 0.07962003f, 
    0.09520911f, 0.07568591f, -0.08089332f, 0.23734038f, -0.90866733f, -0.22640149f, 0.12708794f, -0.08950284f, 
    -0.12775609f, -0.04275650f, 0.16595064f, -0.07624004f, 0.23091540f, -0.17304918f, 0.14566438f, 0.08542056f, 
    -0.73059499f, 0.39711800f, 0.25553000f, -0.61751622f, -0.05439407f, -0.02484646f, 0.16216467f, -0.01496286f, 
    -0.25576279f, -0.21588428f, -0.11225186f, 0.06028379f, -0.43902537f, 0.31175986f, 0.11287965f, 0.06600093f, 
    0.05169753f, 0.04024757f, -0.04330517f, -0.03389031f, 0.00462262f, 0.01272505f, -0.03763083f, -0.07765759f, 
    0.10608706f, -0.47101784f, -0.08636070f, -0.39351758f, 0.03993312f, -0.24381188f, 0.03326868f, -0.10728657f, 
    0.01820645f, -0.04007388f, -0.16038984f, -0.15963894f, -0.05187099f, -0.06203651f, -0.35631153f, 0.49834627f, 
    -0.30606273f, -0.19558012f, -0.10669448f, 0.03204175f, -0.04454138f, 0.26968625f, -0.17754178f, 0.00346358f, 
    0.45782638f, -0.19179837f, 0.01999967f, -0.14730683f, -0.05037238f, 0.08473563f, -0.04009256f, 0.16422279f, 
    -0.03624206f, 0.10687570f, -0.12801160f, -0.02012221f, 0.26416039f, -0.13343717f, 0.17104425f, -0.33487025f, 
    0.20771758f, 0.06511778f, 0.26847056f, -0.06139752f, 0.12182380f, 0.22566700f, -0.02652748f, 0.14415202f, 
    0.22385912f, 0.28054386f, 0.19329153f, 0.28493345f, -0.10472365f, 0.19031566f, 0.12293375f, -0.10814320f, 
    -0.10746169f, 0.17939277f, 0.12451327f, 0.24558723f, 0.60620320f, -0.80375874f, 0.07363354f, -0.04106788f, 
    -0.41057444f, 0.10687664f, -0.16319956f, 0.04911758f, 0.17180711f, -0.11151730f, -0.30180070f, 0.17367347f, 
    -0.24393222f, -0.08108721f, -0.13197099f, -0.12046560f, -0.05631160f, 0.11753575f, -0.14597730f, 0.13278499f, 
    -0.09359439f, 0.26982474f, 0.21301031f, 0.03061324f, 0.19347510f, -0.40500700f, -0.23196466f, -0.27008682f, 
    0.02748989f, -0.05608862f, 0.07304966f, 0.10970905f, 0.02113435f, -0.22168159f, -0.00852168f, -0.47134545f, 
    0.07176188f, -0.14892244f, -0.08211275f, 0.38065687f, -0.02794252f, -0.20270309f, 0.02974424f, -0.04513624f, 
    0.06097154f, -0.13136826f, -0.17844658f, 0.03939838f, 0.37948555f, 0.09693389f, 0.23846798f, 0.27108103f, 
    -0.13059804f, -0.11500342f, 0.11221481f, 0.17164190f, 0.00549770f, -0.23026657f, -0.08496363f, 0.02912011f, 
    0.06280821f, -0.08723204f, -0.10435042f, -0.17416893f, 0.20819932f, -0.22846329f, 0.05979757f, 0.03009756f, 
    0.10941442f, 0.09026176f, -0.04010854f, -0.01233244f, 0.35343647f, -0.16559726f, -0.75999707f, -0.14223126f, 
    -0.02241412f, -0.22699858f, -0.01416373f, -0.03057906f, 0.16846977f, 0.06338837f, -0.12506764f, 0.33167800f, 
    -0.13997304f, -0.47755229f, 0.04636554f, -0.25915322f, -0.11877600f, -0.03718013f, 0.07695545f, -0.06799220f, 
    -0.12794170f, -0.00662900f, -0.10488887f, -0.12530108f, 0.07520537f, 0.07922546f, -0.30723685f, -0.35198942f, 
    -0.19306181f, -0.12494025f, -0.07553486f, -0.32860684f, -0.16403481f, -0.19031337f, 0.01678174f, -0.11886021f, 
    0.30937499f, -0.24426612f, -0.05879726f, -0.34488481f, 0.00567681f, 0.03682749f, 0.16672702f, -0.00077820f, 
    -0.03130712f, 0.14570887f, 0.30307582f, 0.02199468f, -0.02903504f, 0.43205500f, -0.02289983f, 0.07004604f, 
    -0.02368852f, 0.22659254f, -0.05980007f, 0.02017999f, -0.11678597f, -0.03009959f, 0.13269696f, -0.21589218f, 
    -0.24206690f, 0.27596253f, 0.23561589f, -0.34261188f, 0.00647447f, 0.09176937f, 0.25460222f, 0.25055605f, 
    0.03807047f, -0.06971847f, 0.17196728f, -0.05761490f, 0.53078574f, -0.53261524f, -0.06081343f, 0.21342324f, 
    0.01894876f, -0.00692396f, -0.23114651f, 0.22651620f, -0.13574199f, -0.05601068f, -0.13619967f, 0.08902327f, 
    0.52048635f, 0.16657731f, 0.04950282f, 0.26565456f, -0.08443707f, -0.19529502f, -0.03873325f, -0.04161648f, 
    0.18896015f, 0.03509698f, -0.20858195f, 0.04365445f, -0.34413341f, -0.60952103f, 0.18417539f, -0.04696927f, 
    -0.11069263f, 0.07231542f, -0.22891358f, -0.11244890f, 0.07766929f, 0.03590776f, -0.08464701f, -0.08874634f, 
    0.02721985f, 0.31299245f, -0.33926424f, 0.29357556f, 0.15551406f, -0.10023396f, -0.15065867f, -0.13378111f, 
    -0.29738545f, -0.17287681f, 0.10956147f, -0.12021829f, 0.91981542f, -0.15318032f, -0.14269081f, 0.13925344f, 
    0.15837768f, -0.02213288f, 0.11141091f, -0.01050644f, -0.15360662f, -0.10213169f, 0.03747790f, -0.13153404f, 
    -0.03926524f, 0.16749766f, -0.33362037f, -0.47088054f, 0.00563598f, -0.07317943f, -0.07095394f, -0.02590654f, 
    -0.20969129f, -0.08233448f, -0.25444683f, -0.01011337f, -0.69392216f, 0.15878917f, -0.01261911f, -0.43682674f, 
    0.01986447f, 0.08093914f, 0.05551865f, -0.12543662f, 0.04202697f, 0.45846897f, -0.03976376f, -0.07871831f, 
    -0.44843462f, 0.12105216f, -0.11709356f, 0.01002990f, -0.00006929f, 0.01336247f, -0.11642215f, 0.18413147f, 
    0.09698688f, 0.08569261f, -0.04632344f, 0.03714001f, 0.04447104f, 0.12509362f, -0.09232742f, 0.00838484f, 
    0.16653913f, 0.04779923f, 0.12562183f, 0.13211629f, -0.06584072f, 0.09809404f, 0.08114981f, -0.17790905f, 
    0.60464454f, -0.22593154f, 0.57545131f, 0.40491876f, -0.01907831f, -0.28922847f, 0.13254265f, 0.27527276f, 
    -0.12541635f, 0.07686254f, 0.07181202f, -0.25611231f, -0.25253198f, 0.31968689f, -0.09305778f, -0.47262937f, 
    -0.10423633f, 0.01823677f, 0.14315288f, 0.31874266f, -0.00072147f, 0.08162821f, -0.10001841f, -0.17231487f, 
    0.50004894f, 0.01755851f, 0.15891077f, -0.38005459f, 0.22741769f, -0.42345113f, -0.22146155f, -0.04475403f, 
    0.09150837f, -0.11958108f, 0.12823611f, -0.18037905f, 0.69248325f, 0.01875536f, -0.46839795f, 0.08896101f, 
    0.17886423f, -0.08910745f, 0.15840964f, -0.17363249f, -0.19903174f, -0.07128806f, 0.02509268f, -0.35022432f, 
    -1.21768177f, 0.09345576f, 0.08757348f, -0.66640985f, 0.02394082f, 0.14147744f, 0.26778436f, -0.17278637f, 
    -0.14172593f, 0.01834196f, -0.13572210f, -0.08760683f, 0.59700811f, -0.41960293f, 0.05464768f, 0.06354472f, 
    0.00166951f, -0.21134432f, -0.13102986f, 0.15849385f, 0.00074815f, 0.05619059f, 0.02005709f, 0.14039873f, 
    -0.45826823f, 0.27987468f, -0.48047951f, 0.00553969f, -0.32148698f, -0.51384914f, -0.16666339f, -0.21172844f, 
    -0.22840092f, -0.05307503f, -0.09084579f, -0.03537900f, 0.44392455f, 0.01012075f, 0.09572360f, -0.38575336f, 
    0.12539805f, -0.01607583f, 0.08572364f, -0.13119483f, -0.08518866f, 0.04540725f, -0.15170038f, -0.05927940f, 
    -0.36594760f, 0.02060783f, 0.12151409f, -0.09506914f, 0.14013153f, 0.09447573f, -0.01839990f, -0.16003039f, 
    -0.07353280f, -0.05118237f, -0.06948645f, 0.08496279f, 0.03127378f, 0.40502915f, 0.11581970f, 0.57345915f, 
    -0.05038205f, -0.21907066f, -0.07163342f, 0.10208561f, -0.01428554f, -0.12242407f, 0.15371488f, 0.08515280f, 
    -0.48820779f, -0.43129519f, 0.12080628f, 0.24441317f, 0.07682107f, -0.12683187f, -0.17076759f, 0.02541823f, 
    -0.07619567f, 0.01837265f, 0.08845752f, -0.32896164f, 0.16710824f, 0.08144692f, 0.13932580f, 0.37983349f, 
    -0.03766533f, 0.11106002f, 0.03844280f, -0.00875832f, -0.25955877f, 0.18315317f, -0.00651165f, 0.10481612f, 
    0.23800066f, 0.47839385f, 0.44877249f, 0.15072611f, 0.02584598f, -0.06445454f, 0.15801756f, 0.00902414f, 
    -0.11257961f, -0.24616908f, 0.09468509f, 0.03551835f, 0.62283504f, -0.10627561f, 0.20836388f, 0.25079381f, 
    0.04013369f, 0.13988180f, -0.19800343f, 0.09485595f, 0.23177110f, 0.01822556f, -0.01168070f, 0.06014843f, 
    -0.31314641f, -0.71003699f, 0.16155918f, -0.15107173f, -0.05805494f, 0.12001441f, 0.04551309f, -0.09900280f, 
    -0.00583487f, 0.14965388f, -0.05075121f, -0.12905683f, -0.73279667f, -1.06637740f, -0.82570428f, -0.19734623f, 
    -0.08213255f, -0.07354992f, 0.06956160f, -0.17197534f, -0.01340278f, 0.11240676f, -0.12085924f, 0.11019249f, 
    -0.11567068f, -0.03093299f, -0.21538539f, -0.40683433f, -0.26934260f, -0.14759083f, -0.04631052f, 0.10052430f, 
    0.01971504f, -0.15217325f, 0.03923130f, -0.11271854f, -0.74957287f, 0.70952129f, -0.19260277f, -0.10237050f, 
    -0.03330338f, 0.32609618f, -0.02808782f, 0.03143551f, -0.05902905f, 0.04322174f, 0.19546829f, 0.10238338f, 
    0.08331361f, 0.38828635f, -0.08662164f, 0.17757265f, -0.02839435f, -0.16933222f, -0.13645636f, 0.09033538f, 
    -0.19587944f, -0.06152623f, -0.16367665f, 0.24667695f, 0.18354225f, 0.10349491f, 0.34081343f, 0.38527429f, 
    0.23839691f, 0.27464110f, 0.05790891f, 0.03398139f, 0.07073513f, 0.08883779f, -0.12110860f, 0.00007739f, 
    0.09865152f, -0.83597356f, -0.24271874f, 0.24255821f, -0.17919931f, -0.05554649f, -0.12049612f, 0.34703490f, 
    0.02503362f, 0.19533576f, -0.18113545f, 0.03833994f, -0.61994213f, 0.15322194f, 0.20619197f, -0.09968059f, 
    0.12580462f, -0.06351358f, 0.09802070f, 0.09855939f, 0.07945585f, 0.16715266f, -0.13703255f, 0.05381555f, 
    -0.05655507f, -0.04231320f, -0.09150413f, -0.10589208f, -0.45260537f, -0.00614755f, 0.18419960f, 0.12099898f, 
    -0.21236682f, 0.10446747f, 0.00107431f, 0.16849238f, 0.40916932f, -0.28747967f, -0.30393061f, -0.16077723f, 
    0.08745951f, 0.05081068f, -0.01999507f, -0.00313729f, 0.17161985f, 0.09385113f, 0.17594802f, -0.29300573f, 
    -0.32761097f, -0.72509772f, -0.07458428f, 0.33048734f, -0.18000016f, 0.00686028f, 0.01083259f, -0.13379310f, 
    0.07070318f, -0.10157353f, 0.02241940f, 0.14079683f, -0.44033855f, 0.11798111f, -0.05827831f, -0.04082705f, 
    0.01062493f, 0.01325798f, 0.22733186f, -0.06635398f, -0.25658324f, -0.17664807f, 0.01235940f, -0.23362336f, 
    -0.13857785f, 0.03820413f, 0.26138982f, 0.01300070f, -0.07107019f, -0.08621065f, 0.07676300f, -0.00020743f, 
    0.11845458f, -0.05016117f, -0.16776782f, -0.33764634f, -0.25501326f, 0.34934005f, -0.22143662f, -0.07223982f, 
    0.01407978f, 0.01006960f, -0.07651353f, -0.11527933f, -0.07759791f, -0.10367864f, 0.12985064f, -0.07959232f, 
    -0.13774481f, 0.11394326f, 0.25039428f, 0.23697381f, 0.13601205f, -0.11711425f, 0.02732495f, 0.07037055f, 
    0.11491703f, -0.24059516f, -0.00722755f, 0.26520002f, -0.08171987f, -0.03133179f, 0.37405497f, 0.20696563f, 
    -0.03987690f, 0.01861485f, -0.16702217f, 0.06045501f, 0.09426758f, -0.19481291f, 0.06707028f, 0.16570029f, 
    0.43758675f, -0.14570339f, -0.08198433f, 0.19413804f, 0.02824739f, 0.27452299f, 0.20574242f, -0.04552937f, 
    -0.04504993f, 0.00523958f, -0.10145603f, -0.01157823f, -0.06941961f, -0.08430336f, 0.10267672f, -0.13673988f, 
    -0.11240773f, 0.08913110f, -0.13105543f, 0.14728145f, -0.03120306f, 0.19415022f, -0.07220940f, 0.21735731f, 
    -1.09560537f, -0.34171289f, 0.10713799f, 0.42404062f, -0.09000710f, 0.09608433f, 0.08754167f, 0.10722771f, 
    -0.08416130f, 0.13626793f, 0.11710864f, -0.00680898f, -0.38144341f, -0.30222499f, 0.33978480f, -0.28085211f, 
    -0.08859653f, 0.14789702f, 0.22831257f, -0.12453642f, -0.03853483f, -0.01540805f, 0.02121848f, 0.07603398f, 
    -0.68921465f, -0.16699415f, 0.18217255f, 0.07501944f, 0.29560268f, 0.02136882f, 0.01678363f, -0.00164897f, 
    0.06515501f, -0.04550083f, -0.14400834f, 0.02063623f, -0.61810899f, 0.17380705f, 0.18391015f, -0.10639191f, 
    -0.00304716f, 0.09286578f, -0.26327905f, 0.05646105f, -0.00052782f, 0.19793935f, -0.16057524f, 0.17947178f, 
    -0.06749444f, -0.41910261f, 0.33470529f, -0.11719565f, -0.18833382f, 0.19348232f, -0.07581285f, -0.20088263f, 
    -0.06086689f, -0.04274786f, 0.10358898f, -0.09460425f, -0.56294376f, 0.34642386f, -0.27169886f, 0.00849469f, 
    -0.15423164f, -0.07967915f, 0.14774947f, 0.09112921f, -0.05935882f, 0.12073063f, -0.14435312f, -0.09284831f, 
    0.61540657f, 0.00018155f, 0.03719327f, -0.00976217f, 0.27682215f, -0.24362707f, 0.12385613f, 0.30504915f, 
    0.14562131f, -0.06422104f, 0.01963682f, 0.02357359f, 0.25246739f, 0.05491803f, 0.28825158f, -0.04826258f, 
    -0.21020779f, 0.12479837f, -0.05449037f, -0.10807484f, -0.24331526f, -0.11966752f, -0.08160067f, 0.13043343f, 
    0.20469092f, -0.17667021f, -0.30329874f, 0.39074019f, -0.08992793f, -0.10585694f, 0.06594872f, -0.01016317f, 
    -0.14538388f, 0.00451128f, 0.16582406f, -0.04838118f, 0.20301050f, -0.10929092f, -0.58318496f, 0.18124941f, 
    0.26695982f, -0.22645713f, -0.02677855f, -0.24177937f, -0.04101082f, -0.22144192f, 0.06702917f, 0.08330470f, 
    0.03289768f, -0.27391165f, 0.02142109f, 0.00992899f, -0.15316892f, 0.17509219f, 0.11062602f, 0.00863524f, 
    -0.03965502f, -0.00823224f, 0.13930990f, 0.40284976f, -0.46622720f, 0.18819733f, -0.08377379f, -0.26086509f, 
    -0.08614306f, -0.03384482f, -0.14656800f, -0.15717039f, 0.03039568f, -0.07272862f, -0.28552720f, -0.03353201f, 
    0.24222240f, -0.08128237f, -0.06198679f, 0.07008413f, 0.02268277f, 0.04114012f, -0.09444737f, -0.01453403f, 
    -0.22410515f, 0.08842376f, 0.46626601f, 0.04193227f, 0.06087200f, -0.01926882f, 0.03588270f, 0.27746475f, 
    0.03028370f, -0.14821200f, -0.02466221f, 0.00927842f, -0.17901261f, -0.07883739f, 0.12688948f, -0.11466771f, 
    -0.13765332f, 0.20672335f, 0.14884990f, -0.28646231f, 0.13875860f, -0.48764780f, -0.02302646f, 0.10381836f, 
    0.09277046f, 0.05281807f, 0.08629657f, 0.04486441f, 0.36984786f, 0.02869296f, 0.10994340f, 0.26465106f, 
    0.13610362f, -0.02354294f, -0.05231392f, -0.11853684f, 0.01073894f, -0.16769783f, -0.00911321f, -0.09031454f, 
    -0.21509729f, 0.26494914f, -0.53972107f, -0.05620525f, 0.17495251f, -0.00439917f, -0.27836040f, -0.36134702f, 
    0.02956850f, -0.22963595f, -0.08776062f, -0.04188548f, -0.08273596f, -0.02757014f, 0.06417326f, 0.09098196f, 
    -0.09925795f, -0.03906862f, -0.02914289f, 0.10439610f, -0.33822301f, 0.09153558f, 0.11992119f, -0.00114298f, 
    -0.41163516f, -0.16700503f, -0.26608407f, -0.03032400f, -0.11981699f, -0.01365705f, 0.10636549f, -0.02338128f, 
    -0.05410789f, -0.04214333f, 0.26961899f, -0.17814820f, -0.10847487f, -0.41010088f, 0.01008309f, 0.21620969f, 
    0.00336268f, -0.04835665f, -0.03612574f, 0.02607834f, -0.29813644f, -0.04760199f, 0.03753906f, 0.21543859f, 
    -0.11262444f, 0.25658932f, -0.14433101f, 0.26373416f, -0.09274003f, -0.07882846f, 0.05530851f, 0.13859180f, 
    0.16253245f, -0.11427359f, 0.06418139f, 0.02266550f, -0.32238278f, -0.05672683f, 0.35518065f, -0.39865777f, 
    0.25147128f, -0.10299515f, 0.03417352f, -0.20242292f, -0.00679983f, -0.18076754f, 0.15576473f, -0.28232545f, 
    -0.66722816f, -0.34412566f, -0.04435852f, -0.04557387f, 0.17384051f, 0.46804905f, -0.04687890f, -0.06794069f, 
    0.23166730f, 0.08214489f, 0.10079665f, 0.15582807f, -0.02203725f, -0.18414953f, 0.22078110f, -0.20265488f, 
    0.10103457f, -0.16816425f, -0.03837021f, 0.03675899f, 0.17956711f, -0.17771772f, 0.15059030f, -0.05344458f, 
    -0.18338169f, 0.20168941f, 0.42584312f, -0.46454349f, 0.00936243f, 0.18594591f, 0.19139294f, 0.04046994f, 
    -0.15005259f, -0.00445602f, 0.09520015f, 0.25573978f, 0.52580082f, -0.00913586f, 0.06514093f, -0.19285798f, 
    0.02721594f, 0.13163626f, 0.11564953f, 0.19130559f, 0.40436548f, 0.17834584f, -0.16217656f, -0.22911596f, 
    0.23753399f, 0.27995852f, 0.10335412f, -0.59698939f, -0.00870954f, -0.16712476f, 0.04637497f, -0.06322305f, 
    0.25402832f, -0.17564459f, -0.29428354f, -0.33276966f, 0.46126932f, -0.30327740f, 0.22380565f, -0.10428838f, 
    0.04418686f, -0.06178308f, 0.14608110f, 0.13152649f, -0.03505746f, 0.11730141f, 0.17535618f, -0.10459884f, 
    -0.10115603f, 0.07018172f, -0.09293202f, -0.14480323f, 0.06603157f, 0.06731950f, 0.19706754f, -0.20170757f, 
    -0.19200967f, -0.08302477f, -0.13263471f, -0.04577488f, -0.23068233f, 0.23617698f, -0.45408106f, -0.47415370f, 
    0.04811741f, 0.03638261f, 0.18554258f, 0.10880312f, -0.06110670f, -0.01045349f, -0.07589461f, 0.19589695f, 
    0.25571433f, 0.13024564f, 0.26134929f, -0.43656740f, 0.20701359f, 0.16748098f, 0.19147666f, -0.09958100f, 
    -0.22632918f, 0.11360906f, -0.01827459f, 0.00649414f, -0.93576282f, 0.56240904f, 0.21611938f, 0.17910582f, 
    -0.04593437f, -0.00363063f, 0.04838663f, -0.05257116f, 0.02947099f, 0.14811881f, 0.24178723f, 0.05147958f, 
    -0.15735573f, -0.66781420f, -0.38370976f, -0.21746063f, -0.19439125f, 0.14327438f, 0.02604803f, 0.12783436f, 
    0.04794564f, 0.10900016f, 0.12051411f, 0.18016216f, 0.10077976f, -0.07257778f, 0.16806352f, 0.19656076f, 
    0.30930868f, -0.17630927f, 0.00641701f, -0.07454933f, 0.01817970f, -0.02148591f, -0.01885264f, -0.30651411f, 
    0.10905015f, -0.21310137f, -0.45234165f, 0.18277141f, 0.04908659f, 0.05125542f, 0.03889359f, -0.05372745f, 
    -0.08085791f, 0.13481911f, -0.17778856f, -0.01542386f, 0.22985239f, 0.12353426f, -0.04582509f, 0.05704537f, 
    -0.12559485f, 0.08229361f, -0.01939881f, 0.13615514f, 0.23895684f, 0.01825428f, -0.04364494f, 0.06305664f, 
    -0.18973890f, -0.16033906f, -0.54880548f, 0.50738275f, 0.06791929f, 0.17470062f, -0.14989246f, 0.05609376f, 
    -0.15039183f, -0.09798542f, -0.24195293f, -0.11959450f, 0.34829491f, -1.07719064f, -0.09589586f, 0.29763797f, 
    -0.03306568f, 0.07836920f, -0.02788856f, 0.06330607f, 0.12949139f, 0.19475368f, -0.08834514f, 0.50529110f, 
    -0.02375376f, -0.15531868f, -0.17805934f, 0.07782717f, -0.30294803f, -0.11516112f, -0.12397726f, -0.21073630f, 
    -0.26434988f, 0.01251661f, 0.10278205f, 0.15999585f, -0.12993468f, 0.04424639f, 0.11353762f, 0.05675159f, 
    -0.17228936f, 0.12678173f, 0.12611224f, 0.07593642f, -0.09853996f, 0.14184715f, 0.08743039f, -0.07021991f, 
    -0.05238111f, 0.36674374f, 0.42044005f, -0.51665586f, -0.26202762f, -0.05421983f, -0.07426915f, 0.09519213f, 
    0.09836614f, -0.24921903f, 0.04416686f, -0.15599161f, -0.21754950f, 0.09574612f, -0.20541795f, 0.18653104f, 
    -0.05960754f, 0.07541491f, -0.13002524f, -0.14068219f, -0.12568574f, -0.11694643f, -0.03079244f, 0.11236231f, 
    -0.68408686f, -0.48631740f, -0.24023792f, -0.06518313f, -0.05987680f, -0.09705409f, -0.11820558f, -0.08273013f, 
    0.01875045f, 0.06246960f, 0.07524485f, -0.02329374f, 0.26937512f, 0.17215349f, 0.15427363f, -0.36864105f, 
    -0.27647784f, -0.04953988f, -0.18449552f, -0.15351032f, -0.03190533f, 0.09303044f, -0.09422722f, -0.10970987f, 
    0.27559909f, -0.07103895f, 0.08464011f, 0.18491457f, 0.12511405f, -0.32418773f, -0.14163406f, -0.13611189f, 
    0.09688827f, 0.12942146f, -0.22672555f, 0.05800074f, -0.04626084f, 0.01674326f, 0.03539743f, 0.42467317f, 
    -0.10368933f, -0.20083514f, -0.16407330f, -0.05277524f, -0.33384171f, 0.17245340f, -0.05610057f, 0.19048546f, 
    0.46416312f, 0.06566209f, -0.06644946f, -0.36908209f, -0.06473340f, 0.16121905f, -0.00069806f, -0.34770459f, 
    0.01245428f, -0.05814788f, 0.05502182f, -0.16198593f, -0.63742912f, -0.02008819f, -0.27811179f, -0.37743381f, 
    0.17210634f, 0.21487424f, -0.03877565f, -0.27458072f, -0.15441990f, 0.07047750f, 0.08235725f, 0.08559596f, 
    -0.10921561f, 0.62640512f, 0.32922336f, 0.34775224f, 0.29136702f, 0.13315272f, 0.13821794f, 0.05867475f, 
    -0.06167459f, 0.12778458f, 0.12243574f, -0.18646409f, 0.14728686f, -0.17300111f, -0.04358413f, 0.13496859f, 
    -0.03182752f, -0.20858523f, -0.00537641f, 0.00330183f, -0.11291631f, 0.00549670f, -0.25899708f, -0.07657203f, 
    -0.21089506f, 0.66407382f, 0.13525762f, 0.11217365f, -0.02904563f, -0.00165447f, -0.12567575f, 0.23343880f, 
    0.14239414f, 0.03029693f, -0.06708734f, -0.15044266f, 0.22740559f, -0.56652397f, 0.23099522f, 0.24995735f, 
    -0.00506755f, -0.26309779f, 0.05652652f, 0.01704553f, -0.09715614f, 0.07106926f, -0.20147343f, -0.29671603f, 
    -0.38562974f, -0.04483493f, -0.16835898f, 0.14665839f, -0.01731974f, -0.13072334f, -0.11508477f, 0.04530962f, 
    -0.01787121f, -0.03681624f, 0.07382648f, -0.17535889f, 0.06941680f, -0.41125771f, 0.15461956f, -0.17505421f, 
    0.14947538f, -0.06820676f, -0.16779645f, -0.08672177f, 0.01627188f, 0.05027339f, -0.08688039f, 0.13192604f, 
    0.26346484f, 0.32998055f, 0.12013226f, 0.55429864f, 0.35508472f, 0.19741665f, 0.00290361f, -0.06374967f, 
    -0.08567580f, -0.01918616f, -0.28478366f, -0.10293581f, -0.43846065f, 0.66964000f, -0.21733144f, -0.10171194f, 
    -0.17922699f, -0.01143716f, 0.07137384f, -0.09106735f, -0.23903348f, -0.15694696f, 0.11328586f, -0.15274937f, 
    -0.67467928f, 0.24854714f, -0.22966485f, -0.26796883f, -0.01215616f, 0.01687305f, 0.11757232f, -0.07043466f, 
    -0.15853195f, -0.05550249f, 0.09297092f, -0.07918189f, 0.01283705f, 0.37049016f, -0.23516059f, 0.00977914f, 
    -0.07836733f, 0.06453916f, 0.16927472f, 0.01904689f, 0.17158596f, -0.04874118f, 0.01774256f, 0.06513356f, 
    -0.05335195f, -0.25170562f, 0.09581036f, 0.36102286f, 0.22979480f, 0.15982652f, -0.03211335f, -0.04549158f, 
    -0.06940214f, 0.10865235f, 0.30364773f, 0.25729346f, -0.30077097f, 0.41811275f, 0.00937925f, 0.03363458f, 
    -0.07267928f, -0.21036084f, -0.02397513f, -0.05311412f, 0.15297103f, 0.00118432f, -0.12486471f, 0.01702118f, 
    -0.29892340f, -0.48298207f, -0.39312151f, -0.75392848f, -0.12956011f, -0.18901697f, -0.20602731f, -0.11766561f, 
    0.23809151f, 0.18433681f, 0.22263487f, -0.16914020f, -0.26536474f, -0.34753257f, -0.29507768f, 0.13885005f, 
    0.04395175f, 0.16643322f, -0.07989851f, -0.12364369f, 0.20575523f, -0.12645867f, 0.12996683f, -0.14778672f, 
    0.20451385f, -0.47872674f, 0.01407838f, 0.19447912f, 0.00023886f, -0.18753631f, -0.04593316f, 0.32111314f, 
    0.13783193f, -0.17523059f, 0.04301540f, -0.05314448f, 0.13880403f, -0.25223836f, 0.23485558f, 0.17318295f, 
    0.20765334f, -0.07203238f, -0.05407625f, -0.11273493f, -0.13149200f, -0.12136994f, -0.07412405f, 0.01356703f, 
    -0.23864432f, -0.12988465f, 0.21807295f, 0.24799876f, -0.28876975f, 0.08829604f, -0.28043056f, -0.04390815f, 
    0.13372096f, -0.07434761f, -0.35293493f, -0.14779320f, 0.28738859f, -0.14593320f, -0.45824611f, -0.35180241f, 
    0.08315992f, 0.07398583f, -0.05208206f, -0.19546801f, -0.05058477f, 0.09461671f, -0.08659024f, -0.06225922f, 
    0.01193843f, 0.32147595f, -0.09105785f, 0.05285499f, 0.03189924f, 0.05684742f, -0.06981912f, -0.11753169f, 
    -0.07886324f, 0.10712919f, 0.42553264f, 0.23373511f, 0.10759900f, -0.15966348f, -0.32610917f, -0.15545873f, 
    -0.08579629f, -0.01420324f, -0.06429780f, 0.00639797f, -0.05011008f, 0.26822332f, -0.13052769f, -0.10669366f, 
    0.45376000f, 0.51201773f, -0.82779247f, -0.21312240f, -0.03548913f, -0.19221891f, -0.12762000f, -0.05794878f, 
    0.14621879f, 0.08104329f, 0.04968018f, 0.20809780f, 0.51936972f, -0.19229467f, 0.20455903f, 0.17634137f, 
    -0.25554854f, 0.05946106f, -0.00315234f, -0.41435820f, -0.07472858f, -0.15421039f, -0.01989351f, -0.41350704f, 
    -0.53252083f, -0.08451556f, -0.15599257f, -0.27903420f, 0.25318208f, -0.03700745f, -0.12983488f, -0.14344895f, 
    0.07071441f, 0.05890707f, 0.10049438f, -0.18240467f, 0.35902518f, 0.06788366f, -0.05973307f, 0.07186717f, 
    0.00217014f, -0.05425562f, -0.10148057f, -0.10424078f, 0.17087102f, -0.14248863f, 0.23043744f, -0.08792124f, 
    0.11050661f, -0.29177865f, -0.23061532f, 0.25487000f, 0.05024715f, -0.00882422f, -0.12691540f, -0.10910729f, 
    -0.08856854f, 0.32348439f, 0.27976960f, -0.47007260f, 0.08793170f, 0.52822715f, 0.08097827f, 0.01626371f, 
    -0.17031433f, 0.12897459f, 0.19283649f, 0.03230502f, -0.04544979f, -0.09107158f, -0.25171965f, -0.23323025f, 
    -0.01734986f, 0.04487592f, -0.25475103f, -0.47726399f, 0.05432221f, 0.04332326f, -0.19156024f, 0.09503827f, 
    -0.05483463f, -0.16452882f, -0.26261458f, -0.36459926f, -0.67784709f, 0.01829200f, -0.10054611f, 0.14835054f, 
    0.17837860f, 0.05905716f, -0.01869367f, 0.10336855f, -0.25357619f, 0.21492720f, 0.22588940f, 0.11946042f, 
    0.12341445f, -0.25115243f, -0.15016730f, -0.04637301f, 0.02301861f, -0.00134369f, 0.16054136f, -0.02861886f, 
    0.02276214f, 0.08093862f, -0.48988682f, 0.09941047f, -0.56579494f, 0.16619301f, -0.11930092f, -0.68242007f, 
    0.06127208f, -0.10567197f, 0.00339242f, -0.13320142f, -0.12636197f, 0.10998401f, 0.06001249f, 0.09782381f, 
    -0.17208177f, -0.03329881f, 0.00432186f, 0.44245404f, -0.11878112f, -0.03832893f, -0.13994953f, -0.27529699f, 
    0.00464725f, 0.05870086f, -0.08390874f, 0.00564936f, 0.01982561f, 0.10727804f, 0.28986228f, -0.18276773f, 
    0.00850281f, 0.26477605f, -0.31580874f, -0.11225727f, -0.13046537f, -0.11505792f, -0.16279364f, -0.28386846f, 
    -0.17616259f, -0.40985733f, -0.16128758f, -0.21949112f, 0.15393519f, 0.02164019f, 0.09952153f, 0.05260057f, 
    0.00901124f, 0.34336114f, 0.04746052f, 0.18809958f, 0.06905390f, 0.15747011f, 0.24958305f, 0.31138349f, 
    -0.12260044f, 0.06802452f, -0.10058150f, 0.09040930f, 0.20995083f, -0.07720453f, 0.20865731f, 0.03784569f, 
    -0.42268020f, 0.14725192f, 0.72836179f, 0.01737376f, -0.00744775f, -0.04865758f, -0.06443744f, 0.05777305f, 
    0.09074064f, 0.05328916f, -0.13676390f, -0.12814498f, -0.02131506f, 0.11904797f, 0.03269884f, -0.30323875f, 
    0.13271838f, -0.05962022f, -0.05486060f, 0.10873561f, 0.17032525f, -0.11640926f, 0.15274850f, -0.12648110f, 
    0.45029098f, 0.02123928f, 0.57224965f, 0.04211285f, 0.01433239f, 0.08985655f, 0.04646373f, -0.07124560f, 
    -0.01507927f, 0.09752953f, -0.09325244f, -0.10478139f, 0.58474851f, -0.20043907f, -0.24039942f, 0.05832371f, 
    0.16531172f, 0.13208181f, -0.12498069f, -0.01626272f, -0.08991945f, 0.07091622f, -0.11387165f, 0.16344766f, 
    -0.20560411f, -0.70184815f, 0.09754927f, 0.40646663f, 0.03323932f, -0.06958075f, -0.07735272f, 0.28621420f, 
    -0.00194435f, -0.17356013f, -0.13400422f, 0.10565744f, -1.18644893f, 0.77529210f, -0.28723893f, -0.32336482f, 
    0.07520851f, -0.02455768f, 0.30530241f, -0.20277494f, 0.14824240f, 0.03504104f, 0.20695454f, 0.08225267f, 
    -0.48613214f, 0.21790862f, -0.59689510f, -0.08319642f, 0.01386973f, 0.25668928f, 0.20883445f, -0.00314147f, 
    0.09805778f, -0.13151069f, -0.14472063f, -0.05177163f, -0.40973735f, 0.32512364f, 0.28995568f, 0.18449171f, 
    0.01868287f, -0.03021853f, -0.34645823f, 0.18289685f, -0.20667452f, -0.09815522f, 0.12998642f, 0.06359354f, 
    -0.56648159f, -0.17533137f, -0.22256334f, -0.50217158f, -0.02753033f, 0.16180693f, 0.05292205f, 0.16070868f, 
    0.18858215f, 0.23076653f, 0.16121580f, 0.30181789f, 0.12669760f, -0.16312563f, -0.35136396f, -0.11054754f, 
    0.06642103f, 0.02587626f, 0.09325658f, 0.03344895f, 0.05191318f, -0.18725663f, -0.26114634f, -0.03359145f, 
    0.63998902f, 0.11913440f, -0.06600154f, -0.06668733f, 0.16957150f, 0.37850943f, -0.15879060f, 0.05856440f, 
    0.07933401f, 0.23858678f, 0.26429197f, -0.00296986f, -0.03159930f, 0.13020065f, 0.34455431f, -0.30483118f, 
    0.10904655f, 0.04755709f, 0.11367108f, 0.15582550f, 0.11489195f, -0.03164022f, -0.22388026f, -0.21460752f, 
    -0.65779197f, -0.49518764f, -0.33687595f, -0.46295646f, 0.26375547f, -0.08809411f, -0.10804086f, 0.13595571f, 
    -0.06926160f, 0.08277050f, 0.22834328f, 0.19007795f, -1.12542617f, -0.62964797f, -0.02128114f, -0.14859940f, 
    0.17488670f, 0.05559362f, 0.16227362f, 0.01281580f, 0.07825556f, -0.07789519f, 0.11940016f, 0.18868694f, 
    0.48830605f, 0.22272271f, -0.01382465f, -0.01757671f, -0.41123009f, -0.28316429f, -0.06264648f, -0.16873395f, 
    0.00751186f, -0.15974498f, -0.18289979f, -0.02279876f, -1.22214794f, -0.33109909f, 0.37495202f, 0.19789393f, 
    0.29225987f, -0.07030443f, 0.02853286f, -0.24651192f, 0.00848050f, 0.03934838f, -0.11264267f, 0.35396242f, 
    0.17819165f, 0.04508968f, -0.40902752f, 0.02445875f, -0.06678999f, -0.03816387f, 0.26854095f, -0.04768091f, 
    0.13563477f, -0.01106801f, 0.29621583f, -0.00692245f, 0.19664538f, 0.38656184f, 0.02573596f, -0.04569657f, 
    0.00762586f, -0.23695861f, -0.12253053f, 0.17560287f, 0.21410592f, -0.12412494f, 0.11573049f, 0.07105886f, 
    -0.80399686f, 0.03935360f, 0.21737088f, 0.08529349f, 0.35542342f, -0.00008440f, -0.02444369f, -0.09780701f, 
    0.00997717f, 0.21552567f, 0.08161107f, 0.06915759f, 0.27448297f, 0.25511348f, -0.28505519f, 0.07918757f, 
    0.04197228f, -0.08619203f, -0.09146358f, 0.01319478f, -0.01784049f, -0.16303512f, -0.11439409f, -0.24247898f, 
    0.21846080f, 0.04271175f, -0.03939350f, -0.30314445f, -0.15050983f, 0.15546080f, 0.06567734f, -0.06260648f, 
    -0.12641841f, 0.16836326f, 0.11854643f, -0.23465970f, -0.82899433f, -0.91334534f, -0.16003698f, 0.33288527f, 
    0.19689164f, 0.07540852f, -0.00103876f, 0.25513187f, 0.15872985f, 0.05108304f, 0.05117286f, 0.25884578f, 
    -1.24060869f, -0.73159492f, -0.18418574f, -0.41330862f, 0.34124368f, -0.18340683f, -0.16078642f, -0.04940159f, 
    0.06330117f, 0.29055795f, 0.15713347f, 0.09656241f, 0.08063117f, -0.21802303f, -0.10435306f, -0.17403190f, 
    -0.32342911f, 0.13652830f, 0.12450423f, 0.08021187f, 0.14265697f, 0.24551730f, -0.16998647f, 0.14199297f, 
    0.20365672f, -0.05827398f, -0.25748086f, 0.27841246f, 0.23598893f, -0.08129269f, -0.20935214f, 0.01656393f, 
    -0.08504239f, -0.01647772f, 0.09140193f, -0.05387611f, -0.32436794f, 0.16184603f, -0.03097698f, 0.10976834f, 
    0.25020939f, -0.17079785f, 0.32707694f, 0.03434926f, 0.10832859f, -0.10235007f, -0.00421695f, -0.16026905f, 
    -0.02371161f, 0.05213988f, -0.02230768f, 0.08889457f, -0.30756468f, -0.07990539f, 0.19599442f, 0.07340053f, 
    0.23063330f, -0.31640857f, -0.14652136f, -0.18082686f, 0.16233891f, -0.03601288f, -0.55463254f, 0.06639271f, 
    0.21369293f, -0.07600427f, 0.09571780f, -0.27474603f, 0.17725174f, 0.07345407f, -0.00272795f, 0.10308619f, 
    -0.49256271f, 0.00617307f, -0.20815600f, -0.81136191f, -0.04689627f, 0.24236237f, -0.09028673f, -0.01136082f, 
    0.15043315f, -0.06084310f, 0.04853479f, -0.03018033f, 0.55258739f, 0.00937107f, -0.38020924f, -0.25766400f, 
    -0.11825095f, 0.01695494f, 0.04165728f, -0.02002415f, 0.07340419f, 0.05249115f, 0.00745285f, -0.03483231f, 
    0.20948967f, -0.18608762f, 0.04334876f, 0.10670838f, -0.17579870f, -0.09184285f, 0.23013406f, 0.05780811f, 
    -0.15940025f, -0.07656826f, -0.09975574f, -0.21505411f, 0.81706470f, 0.11458994f, 0.03222728f, -0.04825522f, 
    0.10905867f, -0.22938251f, 0.03176228f, -0.01574616f, 0.04594145f, -0.07758494f, 0.11067254f, 0.18618049f, 
    0.53238630f, -0.50475973f, -0.49020937f, 0.22747378f, 0.02800393f, 0.30043659f, -0.11411753f, -0.02799955f, 
    0.04428075f, -0.04128802f, -0.22344673f, 0.08319921f, 0.41014409f, -0.04933629f, -0.18143775f, 0.25798270f, 
    0.01941843f, 0.02173436f, 0.25942743f, -0.02588382f, -0.03691720f, -0.00979027f, 0.23553704f, 0.26693138f, 
    0.63294792f, 0.04650230f, -0.16097656f, 0.09974934f, 0.04441653f, -0.31197187f, -0.24800996f, -0.11172256f, 
    0.31627610f, 0.23988765f, 0.06817571f, 0.09656350f, -0.92429882f, 0.04601436f, -0.40771037f, -0.25731027f, 
    0.09052370f, -0.16395430f, 0.19540301f, -0.05503953f, -0.00957256f, 0.05362670f, 0.21403199f, 0.20014806f, 
    0.32287440f, 0.20925950f, -0.41661310f, -0.03167683f, -0.29901755f, -0.14416113f, -0.39148363f, -0.28396887f, 
    -0.24294442f, -0.14338678f, 0.07180507f, -0.17216228f, -0.21572231f, -0.12763850f, 0.23240712f, -0.20222685f, 
    0.35001275f, 0.05846366f, -0.03561835f, 0.00641221f, 0.14484355f, 0.12017784f, -0.09888063f, -0.03924171f, 
    -0.13179398f, -0.01509770f, -0.23034270f, 0.08273685f, 0.05228590f, -0.28255212f, 0.04185307f, 0.11169203f, 
    0.01428054f, -0.05141393f, -0.20072432f, 0.06831440f, -0.28513122f, -0.38835692f, 0.26245111f, 0.14168216f, 
    -0.04990384f, -0.15282758f, -0.13063245f, -0.21018000f, -0.23837051f, -0.01319124f, 0.04702371f, -0.04171044f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17654572f, 0.06054336f, -0.19277385f, 0.00610646f, 0.01128686f, 0.00855229f, -0.02600647f, -0.07293758f, 
    -0.11491333f, 0.07406031f, 0.24475212f, -0.00992301f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
