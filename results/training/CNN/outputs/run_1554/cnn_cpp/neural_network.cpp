#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.03255672f, 0.07851012f, -0.91192859f, -0.50949192f, -0.10322183f, 0.09600958f, -0.31957731f, -0.40632951f, 
    -0.24876165f, 0.12874477f, 0.54864395f, 0.45454308f, 0.18355195f, 0.29194751f, 0.20300864f, -0.00379716f, 
    -0.67124003f, 0.33157110f, -0.51934671f, -0.22477984f, -0.16035265f, -0.44271609f, -0.59616494f, -0.14408761f, 
    -0.11817804f, 0.86854899f, -0.07425357f, -0.17932406f, -0.72816598f, -0.84859270f, 0.41310874f, 0.59004825f, 
    0.45732260f, -0.41415358f, -0.34023437f, -0.68828815f, -0.56294072f, -0.05585346f, 0.52758110f, -0.35095707f, 
    -0.76948446f, -0.88176495f, 0.45061320f, 0.71537399f, -0.14980970f, -0.00407724f, 0.33206403f, 0.62793082f, 
    0.78640944f, -0.65837061f, -0.47793356f, -0.30224124f, -0.14917760f, -0.33420148f, 0.96748894f, -1.16584790f, 
    0.24639185f, -0.37490344f, -0.80479211f, -0.83766973f, 0.22433950f, -0.37965736f, -0.50863498f, 0.53812248f, 
    -0.45727819f, -0.29967886f, 0.18422265f, -0.63127822f, -0.83097565f, 0.15222746f, 0.30413738f, 0.90575343f, 
    -0.36094823f, 0.41838840f, -1.03579009f, -0.36050460f, 0.68127996f, -0.38475633f, -0.08391290f, -0.23982292f, 
    -0.08162566f, -0.71476829f, -0.25428966f, -0.42853826f, -0.19215325f, -0.73122048f, -0.39603710f, -0.01125971f, 
    -0.45889941f, 0.54186106f, -1.16319489f, 0.83086514f, 0.22907814f, -0.91655856f, 0.77866054f, 0.26819879f, 
    0.14598964f, -0.28840548f, 0.14850262f, 0.58376062f, 0.52306527f, 0.56704932f, 0.01817019f, -0.29535967f, 
    -0.61958265f, 0.56277329f, 0.31437236f, -0.26871398f, -0.71266907f, -0.29727545f, -0.00867783f, 0.07782184f, 
    -0.23316929f, -0.68845630f, -0.34275180f, -0.02272379f, -0.60762376f, -0.07322273f, 0.15770221f, -0.27918687f, 
    -0.63783729f, -0.40855271f, 0.07467036f, 0.29865193f, 0.58408052f, 0.68060160f, -0.42142910f, -0.45846087f, 
    0.93091494f, 0.42430219f, 0.40092653f, 0.20094393f, 0.13429613f, -0.54238021f, 0.08303171f, 0.52435470f, 
    -0.52290189f, 0.53681481f, 0.13018499f, -0.08131646f, 0.45754012f, -0.28823343f, 0.41115201f, 0.34563664f, 
    1.39281023f, -1.14291942f, -0.89261365f, -0.19127993f, -0.18788974f, 0.33887795f, 0.10388503f, 0.25051728f, 
    -0.15177736f, -0.08286624f, 0.57512659f, -0.45659241f, 0.21466637f, 0.69603187f, -0.28634930f, 0.23842654f, 
    -0.50363111f, 0.04363493f, 0.97547191f, 0.07634365f, 0.82594472f, -0.47198409f, -0.55484456f, -0.26186174f, 
    -0.07791235f, 0.26411393f, 0.17972623f, -0.89692283f, 0.27625078f, -0.52227801f, -0.15060031f, 0.74881583f, 
    0.41459170f, -0.04290293f, 0.42257237f, 0.33712801f, -0.76546186f, -0.31666613f, -0.52978677f, 0.90021491f, 
    -0.33534932f, 0.73155379f, 0.03961069f, 0.44797564f, 0.38066560f, -0.87244344f, 0.68210167f, 0.23294108f, 
    0.70678174f, 0.61214966f, 0.05762238f, -0.08793296f, 0.35304555f, 0.22623527f, 0.60356742f, 0.16190137f, 
    0.34709960f, -0.18936177f, -0.19448410f, 0.58210880f, -0.15858218f, -0.14252073f, 0.23225316f, 0.06111197f, 
    0.26005325f, 0.22897893f, 0.65131396f, 0.31410059f, 0.28085911f, -0.01087309f, 0.32244310f, -0.43444258f, 
    -1.02103353f, 0.07078020f, 0.20288850f, -0.55561614f, -0.58493978f, 0.19079475f, -0.07689983f, -0.36027965f, 
    -0.35520703f, -0.52182859f, -0.43423715f, -0.58704311f, 0.48801714f, 0.51537037f, -0.58191633f, -0.52445298f, 
    -0.49903896f, 0.22416350f, -0.59878784f, 1.18637025f, -0.76089346f, 0.00377719f, -0.14209740f, -0.24530621f, 
    0.33826825f, 0.48015338f, 0.14104269f, 0.97999752f, -0.09194005f, -0.77118701f, -0.15106291f, -0.23011307f, 
    0.28752679f, 0.51459545f, -0.00047381f, 0.42608899f, -0.76391870f, -0.54706603f, -0.34387815f, -0.00094036f, 
    -0.17281553f, -0.13965948f, -0.02869053f, -0.23222128f, -0.20438768f, -0.05007754f, -0.15467082f, -0.12897758f, 
    0.57349741f, -0.05969831f, -0.13825026f, 0.42093635f, 0.36591986f, 0.13306002f, -0.65401351f, -0.80838513f, 
    -0.66045296f, 0.33713078f, -0.04058705f, 0.40013370f, 0.34924677f, 0.20418714f, -0.07358740f, 0.37964910f, 
    -0.26273042f, -0.22719802f, -0.20899932f, 0.81966263f, 1.02705514f, -0.58985502f, -0.07324915f, 0.22122192f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30005124f, 0.37453225f, -0.09387320f, 0.30636698f, 0.39276376f, 0.08701648f, 0.22299992f, -0.02008382f, 
    0.05321383f, -0.45815554f, 0.05150443f, 0.18326621f, -0.44805726f, 0.45436731f, 0.25378761f, 0.02855340f, 
    0.09848535f, 0.13265733f, 0.23758061f, 0.27401403f, -0.10351203f, -0.27514830f, 0.31886402f, 0.13755558f, 
    -0.48481879f, -0.27707601f, 0.03402101f, -0.13506913f, -0.39828455f, 0.02898481f, -0.03323605f, -0.25552323f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01551406f, 0.04041682f, -0.08280223f, 0.15867075f, -0.05405248f, 0.06757280f, -0.03752938f, 0.04409983f, 
    0.05199652f, 0.06442248f, 0.05746817f, 0.06288932f, 0.03800075f, -0.09752212f, 0.02548632f, 0.08757650f, 
    0.17423047f, 0.08574033f, 0.21078382f, 0.11893509f, -0.21648704f, 0.01362014f, -0.03066805f, -0.06340794f, 
    -0.09613418f, 0.04625170f, -0.11790582f, -0.00577203f, -0.24948509f, -0.00000799f, 0.01609419f, -0.02519662f, 
    -0.19949093f, 0.19099107f, 0.04308131f, -0.06536213f, 0.44543236f, 0.31367791f, -0.20803012f, 0.14221908f, 
    -0.08923621f, 0.00223830f, -0.00091551f, 0.01102185f, 0.10474492f, 0.08025177f, -0.05086315f, -0.08373107f, 
    -0.08851127f, -0.01882843f, 0.12634322f, -0.06632892f, 0.07297266f, -0.04532875f, 0.19651525f, 0.17229776f, 
    -0.44640103f, -0.01693083f, -0.05664187f, -0.08115883f, -0.11999398f, -0.11409435f, -0.13669017f, 0.36689311f, 
    -0.09485032f, -0.06432777f, -0.23019016f, 0.09082236f, 0.12121490f, 0.14930044f, -0.09951119f, 0.09878910f, 
    -0.17895381f, 0.04990748f, -0.13807768f, 0.08150082f, 0.02643186f, 0.02848795f, 0.03184418f, -0.25060043f, 
    -0.14029305f, 0.18760577f, 0.03673149f, -0.12093857f, -0.12086641f, -0.10872498f, -0.15367655f, 0.08917038f, 
    -0.05182747f, -0.03417631f, -0.19636087f, 0.37506011f, -0.09730185f, -0.19770357f, 0.04155871f, -0.09233552f, 
    0.00769958f, 0.24518754f, -0.25237858f, -0.20403053f, 0.11355602f, 0.11547041f, 0.01402649f, 0.06933971f, 
    0.13649090f, 0.14232615f, -0.03502538f, 0.06519112f, 0.56889611f, -0.19453143f, -0.12460341f, -0.07031008f, 
    -0.13222751f, -0.03934979f, 0.08076747f, -0.10189532f, 0.11680967f, -0.09221306f, -0.05580174f, -0.02076705f, 
    0.05796292f, -0.00535744f, -0.05064953f, 0.04587832f, 0.04013339f, 0.12234623f, 0.13374364f, 0.03653523f, 
    0.01367918f, -0.32438856f, 0.11711951f, -0.18624786f, -0.18746962f, -0.03915937f, -0.17591920f, -0.02504320f, 
    -0.01381835f, 0.02350899f, 0.25441480f, -0.17071468f, -0.28376159f, 0.14584115f, 0.10047401f, -0.00178617f, 
    0.04054926f, -0.40407914f, 0.06954872f, -0.13463677f, 0.21618688f, 0.11374592f, 0.02196829f, -0.01441079f, 
    -0.15029542f, -0.14240554f, -0.00004981f, 0.36041522f, -0.07988124f, -0.20032330f, -0.07721813f, 0.09068744f, 
    -0.02581586f, -0.36587957f, -0.35169771f, 0.06934930f, -0.07228716f, 0.03554305f, -0.01584340f, 0.10261565f, 
    0.10759510f, -0.06138503f, 0.25258684f, 0.06736297f, 0.00253160f, 0.13060135f, -0.13306203f, -0.07055005f, 
    -0.24194749f, 0.12410338f, -0.01542036f, -0.00401132f, 0.21533285f, 0.03087002f, 0.16601865f, -0.10454621f, 
    0.11429947f, -0.09527189f, 0.08775304f, 0.02909498f, 0.06225115f, 0.27219257f, 0.07786860f, 0.05633301f, 
    -0.58127403f, -0.09219103f, -0.43168530f, -0.00572306f, 0.10247339f, -0.03805507f, -0.25614944f, 0.09701531f, 
    0.07953101f, 0.05749303f, -0.14735164f, -0.00435193f, 0.08174131f, 0.10451305f, 0.20511796f, 0.18149525f, 
    0.12919372f, 0.17686553f, -0.16342410f, 0.02854799f, -0.13583863f, 0.10218589f, 0.11206321f, -0.04536623f, 
    0.76322174f, 0.46041530f, -0.55154049f, 0.11649390f, -0.20917726f, -0.15299758f, 0.01550630f, 0.12255638f, 
    0.11276887f, 0.04897781f, -0.09121642f, 0.02115604f, -0.06421868f, 0.07806332f, -0.29730976f, 0.04002687f, 
    0.10943436f, 0.08299422f, 0.21471126f, 0.21680222f, 0.19699293f, 0.00321205f, 0.27709669f, 0.27824929f, 
    0.01582290f, 0.01247914f, -0.00404375f, -0.12215815f, 0.03734429f, 0.18381636f, -0.13055488f, -0.20717755f, 
    0.02901405f, 0.17569651f, 0.06056640f, -0.09018184f, 0.42291987f, -0.02191284f, -0.31253240f, -0.00170776f, 
    -0.12803520f, -0.11897116f, 0.09329337f, -0.05932054f, -0.05776905f, 0.10238465f, -0.08731537f, 0.05534182f, 
    -0.09105336f, -0.19429456f, -0.14369263f, 0.18490790f, 0.05392461f, 0.08984536f, 0.40458974f, -0.20829655f, 
    0.13023387f, -0.10914222f, -0.14258894f, 0.01769982f, 0.06480159f, 0.02048134f, -0.03216115f, 0.15077038f, 
    0.02299552f, 0.01744520f, -0.03587473f, -0.48084691f, -0.28535542f, 0.11016079f, 0.02457602f, 0.06363810f, 
    -0.00929772f, -0.06202161f, 0.02528031f, -0.00696737f, -0.06346752f, 0.03074378f, -0.05375595f, -0.03838763f, 
    -0.06216959f, -0.03140362f, -0.01034475f, 0.00888066f, 0.04063013f, -0.06108251f, -0.04964242f, 0.00787323f, 
    -0.00881099f, -0.05192476f, -0.00684474f, 0.02412987f, -0.05439721f, 0.04667728f, -0.00932731f, 0.02800288f, 
    -0.01711437f, -0.05244263f, -0.04510302f, -0.01383450f, 0.00733697f, -0.06335095f, -0.00892014f, 0.00709354f, 
    0.00811923f, -0.06248116f, -0.04983273f, -0.00977148f, -0.03991690f, -0.05772305f, 0.00905651f, 0.00778069f, 
    -0.01572669f, 0.03526478f, -0.05572796f, -0.05241077f, -0.03881350f, -0.00544869f, 0.00052420f, 0.02741480f, 
    -0.02468766f, -0.04996987f, -0.03322508f, -0.02330393f, -0.04619878f, 0.02861936f, 0.00344090f, 0.04574995f, 
    0.00439728f, -0.06203412f, -0.03201840f, -0.04504945f, 0.03438888f, -0.03371793f, 0.01025631f, 0.02576038f, 
    0.00133405f, 0.04514500f, 0.04769588f, -0.03298105f, 0.04168697f, -0.04080025f, -0.03509461f, -0.00804385f, 
    0.02174853f, 0.02486021f, 0.05167414f, -0.00329546f, -0.02900750f, 0.00732674f, -0.04345540f, 0.00903389f, 
    0.00071743f, -0.04461482f, 0.00489407f, 0.01012562f, -0.04381792f, 0.03127598f, -0.00181127f, -0.01212802f, 
    0.02714101f, -0.03981736f, 0.02444333f, 0.01444856f, 0.02516773f, -0.06330037f, 0.03140134f, 0.00713670f, 
    0.00398429f, -0.05437921f, -0.00117641f, 0.01909680f, 0.02535117f, -0.01793997f, 0.01046153f, 0.03726517f, 
    -0.04766543f, 0.03225723f, -0.05720293f, -0.00194164f, -0.02411711f, -0.00854175f, -0.04677166f, 0.00856168f, 
    -0.03461923f, -0.02299754f, -0.05962962f, -0.04599624f, -0.03890971f, 0.03303218f, -0.00451165f, 0.02149549f, 
    -0.05241308f, -0.03659865f, 0.00118029f, 0.00836515f, -0.05109622f, 0.04456425f, 0.04060765f, -0.04765711f, 
    -0.01147512f, 0.00903648f, 0.02303514f, -0.03666420f, -0.04811763f, 0.00778661f, -0.02278969f, 0.00669664f, 
    -0.06388474f, 0.00009772f, -0.02332812f, -0.00476465f, 0.03344182f, 0.00945904f, -0.00008576f, -0.06249016f, 
    -0.04468730f, -0.02845574f, -0.01420647f, 0.03561661f, -0.02455597f, 0.02662837f, 0.03790019f, -0.05372453f, 
    0.03428853f, -0.02469548f, -0.00342549f, 0.00549125f, -0.04697948f, -0.05044442f, 0.03288536f, -0.06265374f, 
    -0.03146376f, 0.03819153f, 0.01105660f, -0.02434666f, 0.00628976f, -0.01355361f, -0.00467174f, 0.02966995f, 
    -0.04817232f, -0.05045361f, -0.04484169f, 0.03667023f, 0.02057534f, -0.00323051f, -0.02936039f, 0.01342006f, 
    -0.01934985f, -0.01175799f, -0.00137294f, -0.04793987f, 0.01008226f, 0.01798076f, -0.05065250f, -0.02357989f, 
    -0.03659679f, 0.01589430f, -0.00805442f, -0.00166248f, 0.02313142f, -0.03722179f, 0.04804236f, 0.04957291f, 
    -0.05171558f, 0.00363287f, -0.01089501f, 0.04673466f, -0.05666638f, -0.02825435f, -0.04819308f, -0.01441220f, 
    -0.00707537f, -0.01464792f, -0.05357515f, -0.01848480f, 0.01146729f, 0.02486832f, 0.03337108f, 0.02739005f, 
    0.01580911f, 0.04424923f, -0.02795801f, 0.04082664f, -0.02813683f, -0.03358854f, 0.01558397f, 0.02778758f, 
    0.01903121f, 0.04951958f, 0.04863152f, 0.03770809f, 0.02642688f, 0.00234472f, -0.06027303f, -0.05121389f, 
    0.00395019f, 0.01042103f, -0.00199013f, -0.01904302f, 0.02629465f, -0.00446009f, -0.01028010f, 0.01507465f, 
    0.02893666f, -0.05823176f, 0.02717038f, -0.02751364f, 0.01040101f, -0.05775530f, 0.03628670f, 0.01660662f, 
    0.02671968f, -0.02972540f, -0.02357529f, -0.02996124f, 0.00409922f, -0.05364718f, -0.00870395f, -0.03472176f, 
    -0.04369429f, -0.03766201f, -0.05589846f, 0.01453459f, 0.03107891f, 0.02553381f, 0.04631808f, -0.03206713f, 
    -0.01236603f, -0.02982587f, 0.00358446f, -0.02995822f, -0.06087238f, 0.02257096f, -0.06040735f, 0.03377043f, 
    0.00270500f, -0.06096419f, 0.04539643f, -0.02045009f, 0.00100996f, -0.04226444f, -0.00046354f, 0.01498241f, 
    0.00388673f, -0.00348154f, 0.04563848f, 0.03062468f, -0.04554880f, 0.01012770f, -0.01296454f, -0.06249624f, 
    0.01144977f, 0.01589928f, -0.06183333f, 0.03772265f, -0.00086242f, 0.02740205f, -0.02427067f, 0.03611777f, 
    0.13420217f, 0.00998537f, -0.08884614f, -0.03680930f, 0.06376376f, 0.02170434f, -0.05913907f, 0.01174428f, 
    -0.09171090f, -0.21109113f, 0.15677792f, 0.03191048f, -0.09337428f, -0.05496754f, 0.10208232f, -0.17869462f, 
    -0.21856052f, -0.08362466f, -0.03373785f, 0.30415308f, -0.08694161f, -0.09866161f, -0.08009870f, -0.04944063f, 
    0.02320402f, 0.09771418f, 0.17948413f, -0.01017322f, -0.27033675f, -0.14682925f, -0.06785442f, 0.14889687f, 
    0.00198553f, -0.06213748f, -0.22109017f, -0.26754060f, 0.25814810f, 0.20331374f, 0.07583687f, 0.00527283f, 
    0.09954304f, 0.00694931f, 0.05531950f, 0.12352556f, 0.07366592f, -0.16133668f, -0.16735868f, 0.01116391f, 
    -0.07544125f, 0.02267530f, -0.10766463f, 0.04668517f, -0.11429287f, -0.25871083f, 0.21544971f, 0.03912719f, 
    0.11889327f, 0.01061593f, 0.15984505f, 0.08274891f, 0.04855620f, 0.13508837f, -0.15754628f, 0.06080821f, 
    0.39763078f, 0.18209276f, 0.00617034f, 0.05388715f, 0.09292617f, 0.21004294f, 0.06509635f, 0.10062811f, 
    0.16514446f, 0.07581795f, -0.05524159f, -0.01167206f, 0.07665113f, -0.00047334f, -0.04236513f, -0.05101976f, 
    -0.06973860f, 0.15523541f, 0.10730417f, -0.23288196f, -0.00440968f, -0.14121154f, -0.01868288f, -0.05860004f, 
    0.06224804f, 0.22726665f, 0.18801290f, 0.43672821f, 0.40840289f, -0.00073472f, -0.05176128f, 0.08173625f, 
    0.06700207f, 0.03632932f, -0.07485318f, -0.01785157f, -0.09696791f, 0.10439818f, -0.12876529f, 0.10847453f, 
    -0.02697902f, 0.08094558f, 0.14722773f, -0.01524713f, 0.15461877f, -0.01115716f, -0.37276632f, -0.00677098f, 
    -0.03056780f, 0.07953711f, 0.02253040f, -0.02708904f, -0.03925646f, -0.04446293f, 0.04078602f, 0.05848957f, 
    -0.01631579f, 0.09238244f, 0.05878852f, 0.16621582f, 0.15294231f, 0.20354433f, -0.07568841f, 0.11340613f, 
    -0.07857485f, -0.00812887f, 0.06521736f, -0.02758187f, -0.10908050f, -0.28250882f, -0.32114074f, -0.17376986f, 
    -0.04840440f, -0.08538434f, 0.10764761f, -0.19898488f, -0.28447321f, -0.14632943f, 0.08875470f, -0.00921406f, 
    0.03441060f, -0.49798593f, 0.09316405f, -0.05176852f, -0.00937457f, 0.20315301f, 0.12850447f, -0.04078139f, 
    0.04011600f, -0.19095713f, 0.24748534f, -0.03612906f, 0.22945677f, 0.07876053f, 0.02951749f, 0.03082628f, 
    -0.01409808f, -0.15084572f, 0.22322027f, -0.10782723f, -0.19384354f, 0.02083013f, 0.02533375f, -0.00653649f, 
    0.03833309f, 0.02184139f, 0.08135957f, 0.01649253f, -0.04953862f, -0.19316895f, 0.01691369f, 0.10713947f, 
    -0.03922120f, 0.11709548f, 0.17816985f, 0.09024379f, -0.02762540f, 0.03901763f, -0.26681852f, 0.04058649f, 
    -0.00083435f, -0.12881583f, 0.03402630f, 0.13800001f, 0.14663051f, -0.09752452f, 0.04595188f, -0.00251470f, 
    -0.01171723f, -0.06357214f, -0.03008659f, -0.08458377f, 0.15396549f, -0.03500357f, -0.11492191f, 0.09056094f, 
    -0.05234910f, 0.05492298f, -0.06255154f, 0.10367264f, -0.14206757f, -0.08513440f, -0.03274141f, -0.18783969f, 
    0.07337643f, 0.09857042f, 0.00165060f, 0.02691536f, -0.18346702f, -0.18363847f, -0.26087147f, -0.15870360f, 
    0.18778992f, 0.26587871f, 0.03489707f, 0.15007150f, -0.03144107f, 0.10965849f, 0.07470565f, 0.03463582f, 
    -0.12209488f, 0.29602706f, -0.02227194f, -0.35080007f, -0.10431147f, -0.05453895f, -0.08905299f, 0.11195467f, 
    -0.01816220f, 0.06957151f, -0.04399103f, 0.06357522f, 0.12996054f, 0.02680161f, 0.20754895f, 0.13848443f, 
    0.08546539f, 0.25816154f, 0.11697495f, -0.13541143f, -0.20103167f, -0.08366253f, 0.00114711f, -0.09678631f, 
    -0.03726811f, 0.08817610f, -0.05925028f, 0.01553595f, 0.13692966f, -0.05558956f, -0.36047164f, -0.02006678f, 
    -0.05671055f, 0.02534479f, 0.01890906f, -0.01968785f, 0.00088665f, -0.13769661f, -0.01523344f, -0.02366073f, 
    0.20471005f, 0.02444177f, -0.14554600f, -0.01925780f, 0.21720710f, 0.20788541f, 0.29433802f, 0.07324915f, 
    -0.11051478f, -0.11374789f, -0.10230529f, -0.23535034f, 0.02138025f, 0.01528970f, 0.13611761f, -0.18435539f, 
    0.01357999f, 0.07577629f, 0.11354031f, 0.01461463f, -0.05747669f, -0.07903840f, -0.06596386f, -0.08045268f, 
    -0.13236032f, 0.17961454f, 0.29512805f, 0.07441267f, 0.03301965f, 0.22234964f, -0.02239395f, -0.01828049f, 
    -0.02612003f, -0.05625004f, 0.30745879f, -0.24693727f, 0.25492549f, 0.02410802f, -0.04576781f, -0.02446812f, 
    -0.03435441f, 0.02973703f, -0.18339533f, -0.06231215f, 0.16485693f, 0.01463189f, -0.00051587f, -0.11217890f, 
    0.07541637f, -0.06408577f, 0.00539622f, 0.30381182f, 0.00944977f, 0.33100972f, 0.03693254f, 0.15205954f, 
    0.25185940f, 0.27376121f, 0.10652925f, 0.06996456f, 0.05221981f, -0.04066128f, 0.15677813f, -0.13872328f, 
    -0.10202073f, -0.12993577f, -0.02601908f, 0.06054250f, -0.20419590f, 0.13052808f, 0.21934308f, -0.21555482f, 
    -0.06342054f, -0.02887013f, 0.05646921f, 0.01389006f, -0.02424915f, -0.18128584f, -0.35910180f, 0.25532290f, 
    0.01341178f, 0.11284366f, -0.03305145f, -0.22991002f, 0.03775167f, -0.00008836f, 0.16532573f, 0.15267679f, 
    0.28285700f, -0.07480252f, 0.02151349f, -0.04744977f, -0.00272767f, 0.19112568f, 0.07431860f, 0.08427076f, 
    -0.07094736f, -0.04981260f, 0.04396372f, 0.05208669f, -0.14735849f, 0.08374922f, 0.18394689f, 0.12317762f, 
    0.06327530f, 0.03182819f, 0.35271528f, 0.17458926f, 0.01051077f, -0.02673042f, -0.02776029f, -0.01811112f, 
    -0.03421230f, 0.09924714f, -0.29379681f, -0.42307109f, -0.33207798f, 0.08692611f, 0.06233319f, -0.03158218f, 
    0.23256800f, 0.00464669f, -0.00076472f, 0.27731073f, 0.02269796f, 0.09189180f, -0.09738363f, -0.19457234f, 
    -0.07185219f, -0.03905096f, -0.06277839f, -0.11268137f, 0.34249979f, -0.05263012f, 0.17733082f, 0.25197586f, 
    0.05907194f, 0.12460388f, 0.01449885f, -0.11496042f, 0.15758575f, 0.02027642f, -0.03765369f, -0.04731872f, 
    -0.03997894f, -0.09558558f, -0.14138763f, -0.01430235f, -0.18267530f, -0.15245372f, 0.27490541f, -0.45684823f, 
    0.18135321f, -0.18412858f, 0.02518490f, 0.05478727f, 0.20893019f, 0.30286932f, 0.07072746f, 0.17555602f, 
    0.12329509f, -0.33642730f, 0.05347621f, 0.00046355f, 0.06393598f, -0.01606822f, 0.05697609f, -0.26000229f, 
    0.12732226f, 0.65825051f, -0.03828205f, -0.03741656f, -0.01593797f, -0.03493458f, 0.06801391f, 0.23016885f, 
    -0.03863216f, -0.28799358f, -0.10393221f, -0.36094627f, 0.12968144f, -0.01417910f, -0.09008548f, 0.02438426f, 
    0.17477791f, -0.04548565f, 0.04017526f, 0.13900030f, -0.34040734f, 0.02859541f, -0.07109595f, -0.37958753f, 
    0.02924687f, -0.06439037f, -0.03332705f, -0.37723568f, -0.31537053f, -0.32227144f, 0.07778365f, 0.05289390f, 
    0.07461993f, -0.16659275f, -0.14242034f, -0.07306955f, -0.22149402f, -0.36776656f, -0.27458915f, 0.06407963f, 
    0.06924618f, 0.08425129f, -0.31843147f, 0.02386113f, 0.02847374f, -0.07080240f, -0.12651992f, -0.42080429f, 
    0.09432741f, -0.09697810f, 0.00330741f, -0.24292098f, -0.15262932f, -0.04828882f, 0.02334406f, 0.10638703f, 
    -0.07867952f, 0.19369999f, 0.03900800f, -0.07027508f, 0.13863945f, -0.10038584f, -0.04972550f, 0.50607580f, 
    0.10542327f, -0.21872252f, -0.08533059f, -0.17972955f, 0.05907136f, -0.04370893f, -0.00640417f, -0.03108751f, 
    0.01390764f, 0.20145904f, 0.31393266f, 0.17279391f, 0.17198698f, -0.07291862f, -0.10104287f, -0.21582212f, 
    0.01036196f, 0.75901997f, -0.04123553f, 0.34975511f, 0.06794858f, 0.07622407f, -0.01705142f, 0.04584735f, 
    -0.01625477f, -0.01934823f, 0.31184882f, -0.13793185f, -0.43038353f, 0.15713413f, -0.18098944f, -0.29667935f, 
    0.00848709f, -0.03393437f, 0.04689658f, -0.02441615f, 0.20146343f, -0.16400330f, -0.03838917f, 0.01685472f, 
    0.01428074f, 0.07970753f, 0.18339632f, 0.22855876f, 0.46385455f, 0.06723090f, 0.46624756f, 0.20770817f, 
    -0.03243138f, 0.06929713f, -0.01970321f, -0.20525107f, 0.09945612f, 0.19651093f, -0.31252801f, -0.21494095f, 
    -0.02831531f, -0.04816365f, 0.17254291f, -0.25454143f, -0.10662524f, -0.15520293f, 0.27170700f, -0.25899306f, 
    0.21856722f, -0.05173366f, 0.06262296f, 0.21976306f, 0.00294169f, -0.11121166f, -0.02876644f, -0.03904944f, 
    0.11186289f, -0.15591228f, 0.24294822f, 0.00800218f, 0.33322331f, 0.15315022f, 0.08469930f, -0.12959412f, 
    0.01315552f, 0.01152741f, 0.16456529f, -0.10150664f, 0.16258693f, 0.16067003f, -0.02209949f, 0.00762649f, 
    0.05614245f, -0.02795079f, -0.08480852f, 0.11094540f, 0.19721259f, 0.01931193f, -0.25969616f, 0.13316992f, 
    -0.10789842f, -0.06560617f, 0.12702958f, 0.33833513f, 0.36039802f, 0.05237881f, -0.06341134f, -0.03047688f, 
    -0.07905713f, 0.03177339f, -0.00877246f, 0.04626600f, -0.39878926f, -0.20277518f, -0.01773038f, -0.05372188f, 
    0.02602950f, -0.03467320f, 0.03391590f, 0.07055648f, 0.19941553f, 0.30045563f, 0.39944953f, -0.23154248f, 
    0.09609216f, -0.14237273f, -0.12357135f, 0.00796635f, -0.00453071f, -0.28415141f, -0.20471658f, -0.06034628f, 
    -0.12370121f, 0.05161083f, -0.22165783f, 0.17299879f, 0.02715420f, -0.14428724f, 0.40805799f, 0.00373490f, 
    0.08469954f, 0.06642283f, 0.04486383f, 0.13027520f, -0.02632841f, -0.08834661f, 0.03419288f, 0.17486864f, 
    0.39855784f, -0.13463610f, 0.09385520f, -0.10252401f, -0.09292012f, 0.04146283f, 0.07015979f, 0.03667342f, 
    -0.14812970f, -0.06737952f, -0.01552449f, -0.17918849f, -0.00294212f, 0.15726537f, 0.08602230f, 0.03992458f, 
    0.19754323f, 0.25187275f, 0.35332456f, 0.25336990f, -0.12758923f, -0.22715814f, -0.08786928f, 0.11284356f, 
    -0.12535524f, 0.06469811f, -0.89127368f, -0.18666308f, 0.31839290f, -0.42656010f, -0.02203011f, 0.01857237f, 
    0.11560218f, -0.04849584f, 0.23750710f, -0.16713580f, -0.57031441f, 0.04637989f, -0.02727770f, 0.05219815f, 
    -0.03052224f, -0.01152449f, 0.14275128f, 0.24791440f, 0.11609299f, 0.14130177f, 0.09420942f, -0.04900456f, 
    -0.03343880f, -0.01930770f, 0.17793769f, -0.04580293f, 0.12176666f, 0.18859936f, 0.26691604f, 0.10477655f, 
    -0.15005395f, -0.09594904f, -0.26409706f, -0.03566897f, 0.00137525f, -0.03134314f, 0.14970994f, -0.13458575f, 
    -0.08383279f, -0.26931182f, -0.29475620f, 0.17596610f, 0.05776037f, -0.06325622f, -0.10363966f, -0.07217392f, 
    -0.04811140f, 0.01545251f, -0.11089686f, -0.21096317f, 0.16020773f, 0.24334772f, -0.08188356f, 0.01889025f, 
    -0.00600374f, -0.30539325f, -0.52016139f, 0.06441145f, -0.14831227f, 0.16673766f, 0.11865348f, -0.02662780f, 
    -0.13530110f, -0.19054864f, -0.18647376f, -0.09408160f, -0.04552205f, -0.40517819f, -0.01908429f, 0.11697683f, 
    -0.10290726f, 0.07383999f, -0.21877639f, -0.58643055f, -0.09071540f, -0.11058895f, 0.02584480f, -0.00549032f, 
    -0.07501988f, 0.01996712f, -0.05286414f, 0.08900178f, -0.02224247f, -0.05835290f, -0.10480672f, -0.05968576f, 
    -0.03273541f, 0.00747851f, 0.09153068f, 0.06466711f, 0.14100449f, 0.08748288f, 0.09221613f, -0.11461546f, 
    -0.12816669f, -0.02588885f, 0.04480062f, 0.03186507f, 0.01523069f, 0.08286054f, -0.02856769f, -0.02578220f, 
    -0.18960737f, -0.37809986f, 0.12925214f, 0.07286564f, 0.14273517f, 0.07392932f, -0.18450683f, -0.32908615f, 
    -0.08295406f, 0.03647269f, -0.18547490f, -0.10664407f, 0.01788311f, -0.10139503f, -0.05847566f, 0.01610233f, 
    0.06648145f, -0.03400847f, 0.10096162f, -0.35157111f, -0.23388714f, 0.06450568f, 0.06444406f, 0.06733787f, 
    0.07095956f, 0.18663555f, 0.27006799f, -0.11913502f, 0.14474900f, -0.13082856f, 0.20377125f, -0.01116948f, 
    0.10850094f, 0.12714830f, -0.06971041f, -0.03750871f, -0.18663980f, -0.07402883f, 0.10843734f, -0.14789331f, 
    0.04786893f, 0.15477525f, 0.27677190f, -0.02053371f, -0.43595898f, -0.30309260f, 0.14834923f, -0.05539570f, 
    0.02397167f, 0.07253125f, 0.15274496f, -0.08636995f, -0.02871344f, -0.20323670f, -0.12641771f, -0.06650197f, 
    -0.02754746f, -0.00868428f, 0.10593302f, -0.07153305f, 0.15626639f, 0.16218227f, 0.09064924f, -0.05703076f, 
    -0.02719536f, 0.01587559f, 0.05956797f, -0.09946024f, 0.08220336f, 0.08510658f, 0.04146801f, -0.11187406f, 
    0.14524351f, -0.09489860f, -0.06178571f, 0.12674488f, -0.04052851f, 0.07190171f, 0.55338550f, 0.08428406f, 
    0.25303915f, -0.07501576f, 0.01615690f, 0.17184691f, 0.01735472f, 0.02441837f, -0.07629651f, 0.01414357f, 
    0.03054686f, -0.06383748f, 0.23407848f, -0.26154104f, -0.34092197f, 0.24784575f, -0.00944531f, 0.25976983f, 
    0.10693049f, 0.02594864f, -0.06448852f, -0.01551786f, 0.05522870f, -0.13031802f, 0.03110559f, -0.09932724f, 
    0.13622408f, 0.03152174f, 0.20970412f, 0.16931212f, 0.01252106f, 0.03456277f, -0.15790921f, 0.02599292f, 
    0.09504495f, -0.04113787f, -0.09767073f, 0.18026155f, 0.10052070f, 0.03155924f, -0.13085780f, -0.04311246f, 
    -0.06732152f, 0.01576719f, -0.17500705f, -0.23377232f, 0.06186122f, 0.01033352f, 0.17127904f, -0.05720741f, 
    -0.24504106f, -0.04871657f, 0.04765195f, 0.03935301f, -0.23871122f, 0.06891081f, 0.12088163f, 0.06349090f, 
    0.04996089f, 0.06733690f, -0.13053541f, -0.01077436f, -0.00128776f, 0.09292010f, 0.14608626f, 0.39082527f, 
    0.06108905f, 0.12943237f, -0.05900880f, 0.13026567f, 0.37832224f, 0.10609445f, -0.05037591f, -0.04106491f, 
    -0.23458330f, -0.02250282f, 0.03070149f, 0.21442951f, 0.04989351f, 0.00076399f, 0.05094086f, -0.41775915f, 
    0.04940377f, -0.55887896f, -0.05135322f, 0.08578447f, 0.12165229f, -0.11008335f, -0.08077406f, -0.16219592f, 
    -0.06520601f, -0.14077641f, 0.05599489f, -0.12674558f, -0.04991744f, 0.03059603f, 0.05017168f, -0.23333400f, 
    0.02908286f, -0.07032792f, 0.19957128f, 0.00356759f, 0.01744715f, -0.11038495f, -0.10285407f, 0.10887633f, 
    0.16598333f, -0.32789156f, -0.31275120f, -0.25388691f, 0.26376921f, 0.06274275f, 0.13541153f, 0.18911646f, 
    0.10005518f, 0.01022732f, 0.22320539f, 0.16617931f, 0.18510266f, 0.30149859f, -0.05079724f, -0.13423306f, 
    -0.03089731f, 0.00750573f, -0.06849380f, 0.10420066f, -0.40190053f, 0.02489518f, 0.23295423f, 0.09210230f, 
    -0.07903391f, -0.14248224f, -0.04357935f, -0.03800771f, -0.16912113f, 0.09062577f, 0.03351346f, -0.03015831f, 
    0.27063072f, 0.07240049f, 0.09006032f, 0.01569864f, -0.03209832f, -0.10246421f, -0.15514334f, 0.15544827f, 
    0.08368899f, 0.18552285f, 0.23970298f, -0.28010046f, -0.07086135f, 0.21026295f, 0.01442753f, 0.01086981f, 
    0.14897792f, 0.08937424f, -0.15297493f, 0.01101652f, 0.25758287f, -0.06113647f, 0.15315305f, 0.01226458f, 
    0.36589167f, 0.14547496f, 0.28422907f, -0.08282711f, 0.15041979f, -0.02422927f, -0.30909118f, -0.08736347f, 
    0.29795051f, -0.01166960f, 0.05779142f, 0.00595001f, -0.04250886f, 0.21120887f, 0.19528627f, -0.01032357f, 
    -0.09760202f, 0.04360791f, 0.27057964f, 0.35887849f, 0.17479900f, -0.00855577f, -0.02305463f, 0.04271955f, 
    0.11494424f, -0.05601573f, 0.01200780f, -0.25429571f, 0.04175620f, 0.04947582f, -0.01861170f, 0.09198505f, 
    -0.00753713f, 0.00684671f, 0.05345030f, 0.02172807f, -0.27458975f, 0.04838670f, -0.16478784f, -0.10450204f, 
    -0.17751433f, -0.01112466f, 0.01368755f, -0.00563560f, -0.06024187f, -0.14008181f, 0.05485373f, -0.05459566f, 
    -0.05553411f, 0.00389181f, -0.16392092f, -0.08883303f, 0.00059123f, 0.20949590f, 0.12188464f, 0.26659739f, 
    0.20549062f, -0.07280828f, 0.00535906f, 0.00934126f, 0.06001034f, 0.17376937f, -0.01648234f, -0.01162572f, 
    -0.01622615f, 0.01264781f, 0.12329642f, 0.05622754f, -0.01588253f, -0.02746470f, 0.07553364f, 0.04604365f, 
    -0.68948603f, -0.25622037f, 0.12328949f, 0.01692431f, 0.02389246f, -0.31527629f, -0.08106714f, 0.19981948f, 
    -0.02475021f, -0.36396837f, 0.14615707f, 0.35584465f, 0.00468018f, -0.13427189f, -0.19514407f, -0.04961143f, 
    -0.05558139f, -0.09274002f, -0.01811795f, -0.31976092f, -0.27819636f, 0.25086227f, -0.15574300f, 0.20906921f, 
    -0.09991253f, -0.11700276f, 0.00659002f, 0.00410786f, 0.06448558f, -0.01619612f, -0.00828068f, 0.21894728f, 
    -0.00612963f, -0.27938548f, 0.08560158f, 0.01523348f, -0.40323627f, 0.07360668f, 0.26744872f, -0.03882178f, 
    -0.01213811f, -0.14271978f, 0.06631589f, 0.05448482f, -0.30707741f, -0.05210671f, -0.06503711f, 0.07503930f, 
    -0.06695510f, 0.01648518f, 0.14726843f, -0.03828207f, -0.01955323f, 0.07737890f, -0.33143896f, 0.27983931f, 
    0.17178050f, 0.11622558f, -0.10568927f, -0.10069986f, 0.00073889f, 0.06712729f, -0.09722993f, -0.05111443f, 
    -0.00877823f, 0.10369414f, -0.23759501f, -0.03673004f, -0.17351641f, -0.21914418f, 0.00334816f, 0.12706001f, 
    0.01158631f, -0.03796751f, 0.02586352f, -0.03196854f, 0.00303045f, -0.06508800f, -0.00375445f, -0.02298816f, 
    0.01611098f, -0.00547295f, 0.02003173f, -0.02607614f, 0.02574863f, 0.00370394f, -0.06217049f, -0.00960229f, 
    0.01891097f, -0.03232110f, 0.02061622f, -0.02434116f, -0.01156443f, 0.02239833f, -0.04009346f, 0.01674929f, 
    0.00630559f, 0.02391958f, -0.06151830f, -0.00200594f, -0.01390461f, 0.02887703f, 0.02430012f, 0.03014104f, 
    -0.03464673f, -0.03896811f, -0.04659345f, -0.03466929f, -0.01729230f, -0.01785679f, -0.04834604f, 0.01491768f, 
    0.04451590f, -0.03366760f, -0.04660280f, 0.01934326f, -0.03904995f, 0.01198372f, 0.03532256f, -0.03043992f, 
    -0.03724489f, -0.01646285f, -0.05464108f, 0.02296829f, -0.01123357f, -0.02403288f, -0.02405409f, -0.00736346f, 
    -0.02478641f, -0.02881701f, -0.03220570f, 0.03233813f, -0.03558469f, 0.04883183f, 0.05151084f, -0.05710739f, 
    0.03799221f, -0.04830380f, 0.03457436f, -0.05960551f, -0.06335577f, 0.03144262f, 0.01833302f, 0.01757607f, 
    0.01055960f, -0.01790412f, -0.04076262f, 0.03892723f, 0.03812752f, -0.02630394f, -0.00742987f, 0.04345760f, 
    0.04010185f, -0.02105032f, -0.03165694f, 0.00825251f, 0.02852424f, -0.01935888f, 0.04258067f, 0.01756578f, 
    -0.04296569f, -0.00273144f, -0.05343447f, -0.05593027f, -0.01991063f, -0.01369639f, 0.02586500f, 0.00364414f, 
    -0.02438265f, 0.02865157f, 0.01384910f, -0.05131641f, 0.00630218f, 0.01548255f, 0.02100625f, 0.02854613f, 
    0.01083060f, -0.01155169f, 0.03687691f, -0.00634318f, 0.01094976f, 0.02563091f, -0.04277636f, 0.03465448f, 
    -0.03723567f, -0.01995877f, 0.04253145f, 0.01847210f, -0.01683051f, -0.03407867f, 0.02738401f, -0.06611693f, 
    0.04325680f, -0.03035771f, 0.05018723f, -0.00060123f, -0.03715783f, -0.05417704f, -0.00443591f, -0.02574264f, 
    0.00548434f, -0.02968479f, -0.06059414f, -0.00883660f, 0.00858509f, -0.02530888f, -0.05753283f, -0.01597662f, 
    0.04149230f, -0.04012227f, -0.02345816f, 0.04968606f, -0.05106078f, -0.00245291f, -0.01665250f, -0.01933139f, 
    -0.05187368f, 0.05013962f, -0.04202255f, -0.05919220f, -0.03122850f, -0.00994793f, 0.03299264f, -0.00653035f, 
    -0.05243232f, -0.00924291f, -0.00505118f, -0.04809732f, 0.05093976f, 0.03043608f, -0.01277728f, -0.03605683f, 
    0.04609811f, 0.03188847f, -0.02960068f, -0.00604668f, -0.03791920f, 0.01438441f, 0.04770192f, -0.01421383f, 
    -0.06515123f, -0.04633173f, -0.05989412f, 0.04742957f, -0.05948034f, -0.01209527f, 0.02990076f, 0.04317725f, 
    -0.06274781f, 0.00302993f, -0.05314131f, 0.00130185f, -0.03279227f, -0.02547081f, -0.03013147f, 0.03788509f, 
    -0.01341032f, -0.00019836f, -0.03022268f, 0.01730562f, -0.04087663f, -0.01766335f, 0.03635130f, -0.04424964f, 
    0.00466863f, 0.01531772f, -0.02342791f, 0.02181611f, 0.01047407f, 0.03585858f, -0.02718413f, 0.01139201f, 
    -0.01559055f, 0.00577070f, 0.01122119f, 0.00502324f, -0.01493140f, -0.02007549f, -0.06105741f, -0.05677922f, 
    0.02338570f, -0.04718509f, -0.06484351f, -0.05478416f, -0.00948477f, -0.02710383f, -0.03698264f, 0.01954249f, 
    -0.04466200f, 0.01384106f, 0.05274658f, 0.01975153f, 0.03912273f, 0.00200226f, 0.02882525f, -0.01305320f, 
    -0.03966244f, -0.00286018f, 0.01553037f, 0.03620411f, 0.04758679f, -0.06169805f, 0.04669113f, 0.02689612f, 
    -0.02323190f, 0.00657543f, 0.00023809f, -0.01415444f, 0.01760546f, 0.00147801f, -0.01053385f, -0.01645783f, 
    -0.00851786f, 0.04851115f, -0.03427254f, -0.04549652f, 0.00713859f, -0.00769179f, -0.03184674f, 0.01305181f, 
    -0.06172916f, -0.04923942f, -0.01060735f, -0.05204557f, 0.03678511f, -0.00275108f, -0.05262003f, 0.01030676f, 
    -0.00222982f, -0.00351817f, 0.00562966f, -0.00770387f, 0.03233522f, 0.03841861f, -0.02113082f, 0.00828341f, 
    -0.00465659f, 0.03684206f, -0.00531117f, -0.02080694f, 0.01875296f, -0.02601450f, 0.02333795f, -0.05473782f, 
    0.03802908f, -0.04198334f, -0.00851038f, -0.01608036f, -0.06415288f, -0.06247886f, 0.03873227f, -0.02824044f, 
    -0.02024671f, 0.04593138f, -0.06246026f, -0.00203987f, 0.02867178f, -0.00971959f, 0.03025536f, 0.00927390f, 
    -0.15068762f, -0.10280495f, 0.06936960f, -0.07088508f, 0.14879093f, 0.07351646f, -0.02517339f, 0.12089051f, 
    0.30194849f, 0.12951030f, 0.00211504f, -0.17238833f, 0.05617622f, 0.13854966f, 0.03306155f, 0.08812056f, 
    0.01088142f, -0.16093253f, 0.09464363f, -0.20013444f, 0.05145395f, 0.22416295f, 0.18077298f, 0.05769977f, 
    0.09530845f, -0.04710416f, 0.00200032f, -0.14295620f, -0.02335093f, 0.09911309f, -0.02626042f, 0.18986194f, 
    0.29255384f, 0.20160888f, 0.30738452f, 0.51446378f, 0.11434390f, -0.15421900f, -0.22743537f, 0.23013400f, 
    -0.00662825f, 0.04054434f, -0.19113404f, -0.07907251f, -0.05851528f, 0.28414890f, 0.21757184f, 0.13674298f, 
    0.02886723f, 0.07945938f, 0.01253503f, 0.19207308f, 0.15294720f, 0.07100885f, -0.12301601f, 0.36793160f, 
    0.07263148f, 0.29238719f, -0.00631404f, -0.13066433f, 0.01792438f, 0.17750823f, 0.19764958f, 0.09849519f, 
    0.21374287f, -0.04391753f, -0.03182313f, 0.14771500f, -0.02294437f, -0.06175514f, -0.25876918f, -0.36274463f, 
    0.16510965f, -0.03893285f, 0.05043128f, -0.04923338f, -0.01588791f, 0.19373088f, 0.05167774f, 0.12892658f, 
    0.46680987f, -0.01344983f, -0.32835793f, 0.08801193f, 0.24564733f, -0.02442604f, 0.06757254f, -0.08089849f, 
    -0.10156172f, -0.13795102f, 0.22344282f, 0.23780152f, 0.11086155f, 0.26092228f, 0.24717152f, 0.35429159f, 
    0.02314651f, 0.09595913f, 0.13855264f, 0.09413554f, 0.18954836f, 0.05165772f, -0.00691125f, -0.04762002f, 
    0.13283390f, -0.03129414f, 0.01136993f, -0.12235478f, 0.07581466f, 0.01310725f, -0.07361303f, 0.03028822f, 
    -0.10612971f, -0.03725158f, -0.05322688f, 0.03816763f, 0.17423408f, 0.05839552f, -0.03065773f, 0.03793746f, 
    0.21782270f, -0.05807152f, -0.29020491f, -0.43779460f, -0.58113319f, -0.61414611f, 0.16208519f, 0.00477631f, 
    -0.41130719f, 0.08244060f, 0.17092232f, 0.21358730f, 0.21667445f, -0.13313207f, -0.14722079f, 0.05146348f, 
    0.03638103f, -0.09206823f, -0.06712958f, 0.00969806f, -0.00725338f, -0.01523617f, -0.35585928f, -0.42030206f, 
    -0.42704248f, 0.13055046f, 0.24036664f, -0.23123628f, 0.10719357f, -0.00949369f, 0.06660435f, 0.31612095f, 
    -0.02326345f, -0.02184296f, -0.19445060f, -0.40045708f, 0.13758419f, 0.12668276f, 0.11983369f, 0.05908304f, 
    0.12124878f, 0.23174627f, 0.14834568f, 0.22140108f, -0.08309720f, -0.07624426f, 0.03004788f, -0.04094059f, 
    0.14779070f, 0.02336206f, -0.00563684f, 0.09821153f, -0.00305240f, 0.05200140f, 0.07869697f, 0.07733678f, 
    0.11900233f, -0.12456530f, -0.08117850f, 0.00918406f, 0.19738549f, -0.06612647f, -0.00453004f, 0.19383192f, 
    -0.09284437f, 0.10680304f, 0.17030114f, -0.06672697f, 0.05317178f, -0.02465130f, 0.02216500f, -0.08432330f, 
    0.17529637f, -0.04165546f, 0.20207958f, -0.21528350f, -0.32957572f, -0.12442932f, 0.08666687f, 0.05916770f, 
    -0.09440508f, 0.04558442f, -0.00246086f, -0.01214683f, 0.29269195f, 0.06122168f, -0.08761518f, 0.04026749f, 
    0.04606145f, 0.06932843f, 0.08066597f, 0.17097965f, 0.14108400f, -0.04326670f, -0.07790218f, -0.08995046f, 
    0.22143809f, 0.25274119f, -0.04532517f, 0.09150284f, 0.12253588f, 0.19636142f, -0.06130044f, -0.09427031f, 
    0.16103256f, -0.01669756f, -0.18185362f, -0.14233153f, 0.18422361f, -0.18810987f, 0.10162495f, 0.07104869f, 
    0.15626687f, 0.18674944f, 0.13328828f, -0.06737742f, -0.14569609f, 0.28104970f, -0.14724265f, -0.02634809f, 
    -0.24316658f, -0.36336151f, -0.34502310f, -0.08482196f, -0.14979266f, -0.07289561f, 0.12393878f, 0.11246091f, 
    -0.10280255f, 0.20450187f, -0.01217451f, -0.56240290f, 0.03464808f, -0.10506846f, -0.07839435f, 0.08936383f, 
    -0.01853602f, 0.18893945f, -0.02094090f, -0.08470934f, 0.05219107f, -0.00933830f, -0.11590659f, -0.03760643f, 
    0.09748188f, 0.06460682f, 0.09811417f, -0.03457918f, -0.39200205f, -0.64150971f, 0.42652205f, -0.25553048f, 
    0.01619779f, 0.23620968f, -0.00018513f, 0.09683989f, 0.40977868f, 0.18553525f, 0.15495537f, -0.05389151f, 
    -0.11343876f, -0.04847381f, 0.15704478f, 0.12317125f, 0.15547194f, 0.11816087f, 0.06010601f, -0.25933650f, 
    0.02042276f, -0.20175324f, -0.48300573f, 0.05551237f, 0.02486449f, 0.19347802f, 0.03118370f, -0.01802506f, 
    0.05963077f, 0.02985878f, 0.22199056f, 0.35406554f, 0.04284808f, -0.00428067f, -0.08095787f, -0.08751304f, 
    0.03055577f, 0.12098322f, 0.21906160f, -0.35357675f, 0.29036337f, -0.02631529f, 0.03475755f, -0.15336844f, 
    -0.11154693f, -0.19585279f, 0.09127890f, 0.03291339f, -0.46230957f, -0.28879425f, -0.16245539f, 0.06143437f, 
    0.26027665f, 0.01675198f, 0.08030473f, 0.08189702f, -0.02311647f, 0.08317164f, -0.08307283f, -0.12614943f, 
    0.08868229f, -0.01268677f, 0.08867248f, 0.04267960f, 0.13332663f, -0.21413457f, 0.40290833f, 0.24003005f, 
    -0.00365840f, -0.18817979f, -0.01776643f, -0.11129678f, 0.03926127f, -0.02190298f, 0.48267829f, -0.25529689f, 
    -0.04877754f, -0.14400604f, -0.00401444f, 0.14503421f, -0.07263845f, 0.06005384f, -0.07076027f, -0.13977100f, 
    -0.39751026f, 0.29201883f, -0.13838580f, -0.03802797f, -0.18276730f, 0.20767775f, -0.10999137f, 0.05890501f, 
    -0.18880893f, -0.17647800f, -0.38713393f, -0.05264746f, 0.19190997f, 0.14445345f, 0.03603625f, 0.06091811f, 
    -0.03006374f, -0.10867557f, 0.30410373f, -0.00025905f, -0.05139803f, -0.32725677f, -0.08659267f, 0.01164106f, 
    -0.08314318f, 0.10116742f, 0.44533575f, -0.31524581f, -0.19298813f, -0.00305459f, 0.06378387f, -0.07326364f, 
    -0.09771958f, 0.24536566f, -0.20160702f, 0.14837761f, 0.42269808f, 0.09985155f, -0.11422966f, 0.03388902f, 
    0.08306684f, 0.07560253f, 0.25028151f, -0.06746227f, 0.25833189f, 0.13815831f, -0.52447110f, -0.08375327f, 
    -0.13147296f, 0.22088118f, 0.05050007f, 0.11856567f, 0.14741598f, 0.16607106f, -0.16149883f, 0.03335257f, 
    0.09492085f, 0.09308405f, 0.11071119f, 0.22803180f, 0.19133396f, 0.05346202f, -0.35786545f, -0.12367950f, 
    -0.23715483f, -0.04552767f, -0.01920603f, 0.05687549f, -0.00612054f, -0.03587494f, 0.24901794f, 0.15153152f, 
    0.07257619f, 0.00562864f, -0.11944947f, 0.05116072f, -0.02666531f, 0.21420310f, -0.03938670f, -0.05144182f, 
    0.00918559f, -0.79002601f, -0.09332103f, -0.15622561f, 0.13411555f, 0.05386663f, 0.02495861f, -0.18918931f, 
    -0.12437782f, -0.46200615f, 0.19932799f, -0.04630699f, -0.19114919f, 0.09298965f, -0.19678178f, 0.10856423f, 
    0.22521996f, 0.12424098f, 0.66316199f, 0.46454835f, 0.41522589f, -0.02922324f, 0.04623850f, 0.06665794f, 
    0.08297911f, 0.17025122f, 0.14509232f, 0.08425558f, -0.39214829f, -0.09101902f, 0.05909785f, 0.13050775f, 
    0.08930863f, 0.17356913f, -0.06073737f, -0.05943172f, -0.16241030f, -0.47571266f, -0.14301883f, -0.14207685f, 
    -0.06781980f, 0.01527802f, 0.03111844f, -0.15404423f, -0.18395439f, -0.21446438f, -0.15147899f, -0.25766054f, 
    -0.21169701f, -0.09030661f, 0.00172786f, 0.15949622f, 0.02511288f, 0.03138670f, 0.14201036f, 0.19152518f, 
    0.48043278f, 0.06633114f, 0.05513017f, -0.02099576f, 0.00824850f, 0.02860830f, 0.04730581f, -0.27931839f, 
    0.13734052f, 0.09080496f, -0.06048274f, 0.02049782f, -0.02034523f, 0.00933172f, -0.08067659f, 0.11030032f, 
    0.51991332f, -0.27172107f, -0.19461603f, -0.24984266f, -0.18005715f, 0.14906445f, 0.01609099f, 0.08368601f, 
    0.09658203f, 0.07509117f, 0.07155018f, -0.77734321f, -0.07051576f, 0.05653145f, 0.12429605f, -0.11628784f, 
    -0.03206621f, 0.06565752f, -0.08975311f, -0.05686389f, -0.07563590f, 0.04621137f, 0.05460015f, -0.20502304f, 
    0.24730714f, 0.23334934f, -0.33821622f, -0.10891474f, -0.09494659f, 0.13206366f, -0.08678021f, 0.05152752f, 
    0.04457593f, -0.02573243f, -0.09517933f, 0.08728238f, 0.18307528f, 0.14564659f, -0.47083265f, -0.13821843f, 
    -0.10283788f, 0.19060132f, -0.00190677f, 0.01415073f, -0.02268478f, -0.15587854f, -0.05246317f, -0.10375802f, 
    -0.06036412f, 0.10713123f, 0.06915530f, 0.15334702f, 0.01314519f, -0.21216738f, -0.03712044f, -0.40752369f, 
    -0.26552740f, -0.21350834f, -0.00426662f, 0.15013179f, -0.11087807f, -0.15590923f, -0.23392534f, -0.25595787f, 
    -0.60919875f, 0.10161509f, -0.11083762f, 0.09856082f, 0.03548003f, -0.02081805f, -0.12974679f, 0.09316260f, 
    -0.04674497f, 0.04131168f, 0.10583137f, -0.03781021f, 0.06388077f, 0.20305616f, 0.13418247f, 0.16315396f, 
    0.13425285f, 0.00529638f, 0.14202207f, -0.05475202f, 0.01051797f, -0.10735939f, -0.03296818f, 0.04060951f, 
    0.10601429f, 0.00019599f, -0.14617674f, 0.11671111f, -0.31025574f, -0.12663326f, -0.01724399f, -0.03226284f, 
    -0.09205282f, -0.07950159f, 0.00204963f, -0.02203259f, -0.14814502f, 0.34618047f, 0.00039585f, 0.21647613f, 
    0.12271089f, 0.05688065f, 0.20566389f, 0.14184839f, -0.13159236f, -0.25019670f, -0.22581494f, 0.01650131f, 
    0.32088464f, -0.10373243f, 0.11800289f, 0.08849383f, 0.13262276f, -0.28595716f, -0.07745808f, 0.09628838f, 
    -0.00680147f, 0.08724416f, -0.25952274f, 0.28252459f, -0.00925233f, 0.01558849f, -0.20992087f, -0.04784826f, 
    0.12794428f, -0.07085861f, 0.06757684f, 0.03230793f, -0.02399871f, -0.00637545f, 0.05683417f, -0.31711924f, 
    -0.06777182f, 0.11305235f, -0.27160162f, -0.05245040f, -0.20262918f, 0.06450090f, -0.03545094f, 0.15731515f, 
    0.04676345f, -0.01837770f, 0.31093904f, -0.03935898f, 0.00290156f, 0.22645222f, 0.12810014f, 0.13054229f, 
    0.14556310f, -0.09404645f, -0.10385812f, -0.26407933f, -0.04413873f, 0.01268698f, 0.02709985f, 0.04708021f, 
    -0.13907498f, 0.08607737f, 0.23699497f, -0.06855541f, -0.33715561f, 0.00789992f, -0.06793305f, -0.15456450f, 
    -0.06109036f, 0.16316393f, 0.08444990f, -0.10625723f, -0.17869285f, -0.15482624f, 0.00571737f, 0.11615717f, 
    -0.17923748f, -0.04504837f, 0.08347154f, 0.13117808f, -0.07771780f, -0.37121844f, 0.04753759f, -0.10303452f, 
    0.09953684f, -0.04731413f, -0.15618061f, 0.12277105f, 0.01037619f, 0.09979977f, -0.11393126f, -0.27288228f, 
    0.05467665f, 0.08715998f, -0.05025474f, 0.06910574f, 0.15328923f, 0.14416084f, 0.26549140f, 0.20220783f, 
    -0.09175321f, 0.03553638f, 0.04286559f, -0.12483373f, -0.04018953f, 0.04956472f, 0.18155207f, 0.09589867f, 
    0.14519435f, -0.05604077f, -0.14703619f, 0.08490642f, 0.11173449f, 0.10555958f, -0.00649179f, -0.03828270f, 
    0.22520097f, 0.46657044f, 0.34178352f, -0.15823650f, 0.05327169f, 0.01643777f, -0.10264979f, 0.10051173f, 
    -0.07304668f, 0.20800577f, -0.00584636f, 0.03684378f, 0.10070973f, 0.00388674f, 0.24056053f, -0.09330045f, 
    0.08940463f, 0.06020883f, -0.06919872f, -0.22045925f, 0.03950007f, -0.09028839f, 0.16238549f, 0.05178877f, 
    -0.05497062f, 0.20901932f, 0.14891917f, 0.14058629f, 0.07383204f, 0.18580768f, -0.08190013f, -0.12886906f, 
    -0.09238330f, 0.03935075f, 0.06202989f, 0.11747766f, -0.19304468f, 0.09236480f, -0.08064415f, 0.01754187f, 
    -0.22246368f, 0.02877578f, -0.04431926f, -0.05170111f, 0.01787334f, 0.05441713f, 0.03251170f, -0.24395229f, 
    -0.11149685f, -0.11737181f, -0.18190782f, -0.09994271f, 0.03910447f, -0.03566860f, 0.06399552f, 0.06810487f, 
    0.01890037f, -0.01602369f, 0.09125230f, -0.02736411f, 0.04552048f, -0.00749695f, -0.14359723f, 0.01979471f, 
    -0.03014372f, -0.04933567f, -0.09941925f, -0.07614907f, -0.14722157f, 0.09271040f, 0.14057286f, -0.10369042f, 
    -0.34040537f, 0.01118919f, -0.39488775f, -0.08633614f, -0.02544833f, -0.03907823f, 0.00638841f, -0.09199523f, 
    0.09119114f, -0.13140033f, -0.22644077f, 0.17367697f, -0.05778479f, 0.08675939f, -0.03344506f, -0.06437767f, 
    0.02556055f, 0.21594894f, 0.52845091f, -0.27225769f, -0.12708323f, 0.17984180f, 0.03818216f, -0.14446120f, 
    0.07400140f, 0.01345594f, -0.12681486f, 0.05995465f, 0.15952262f, -0.07956471f, -0.15165439f, 0.01418832f, 
    -0.00797211f, -0.01289374f, 0.01152719f, 0.07210654f, -0.08497868f, -0.22173686f, -0.02089327f, -0.02242605f, 
    0.05074001f, 0.00744670f, -0.27970806f, -0.06111008f, 0.14847824f, -0.09486806f, 0.06006156f, -0.05387976f, 
    -0.15492742f, -0.18491410f, -0.10626603f, -0.01590380f, 0.11179005f, 0.07762353f, -0.05805447f, 0.07257272f, 
    0.12693118f, -0.07188591f, 0.29427838f, 0.00943050f, -0.08746893f, 0.01402048f, -0.00064457f, 0.03618573f, 
    -0.11444045f, -0.30836147f, -0.44214424f, 0.04829814f, -0.09865355f, 0.14264993f, -0.19464304f, -0.03767321f, 
    -0.09971055f, -0.29530701f, -0.42182970f, -0.01409310f, 0.13250108f, -0.20265570f, -0.15929390f, -0.10274708f, 
    0.14509553f, 0.06888594f, 0.01881416f, 0.16006319f, -0.06861589f, 0.12672946f, 0.02191322f, -0.04505065f, 
    0.05308448f, 0.07670670f, -0.98618037f, -0.22652730f, 0.00395655f, 0.12356608f, 0.06315216f, -0.09960371f, 
    0.01655597f, -0.00950725f, 0.02176470f, -0.29861465f, -0.16609317f, -0.27548140f, 0.02219288f, 0.18048629f, 
    -0.13248947f, -0.00468059f, 0.05284785f, 0.05053759f, -0.84206975f, -0.40843204f, -0.16533592f, 0.02328428f, 
    0.06599836f, -0.03026879f, 0.03519952f, -0.03583564f, 0.07176243f, 0.04300636f, -0.13828467f, -0.00239952f, 
    0.10175569f, 0.19218452f, -0.04371841f, 0.19746062f, 0.11648522f, 0.23969768f, -0.50470191f, -0.33032641f, 
    -0.49831760f, 0.17231485f, 0.10153005f, 0.10160826f, 0.04098646f, -0.22526096f, -0.04991868f, -0.49360853f, 
    0.54805118f, -0.28849241f, -0.00754102f, -0.03464818f, -0.00389196f, 0.03490802f, -0.09245707f, 0.02143042f, 
    -0.59203166f, -0.56114316f, -0.32770717f, -0.04209008f, 0.17489672f, -0.12816080f, 0.04321629f, -0.05686657f, 
    0.04901166f, -0.41978502f, 0.17968179f, 0.23450850f, 0.05965162f, -0.09205478f, -0.09151486f, -0.16004825f, 
    0.10112148f, -0.07931159f, -0.27515608f, -0.09075619f, -0.09553317f, -0.38921264f, -0.03723856f, -0.09132545f, 
    0.33611521f, 0.19765250f, 0.22561258f, 0.45308045f, -0.32980424f, -0.12319482f, 0.05754930f, 0.14587754f, 
    0.11453383f, -0.01708052f, -0.28171626f, 0.15640828f, 0.13961719f, 0.03297278f, -0.35597217f, -0.03254510f, 
    0.08999144f, -0.02153956f, -0.09581817f, 0.09383143f, 0.03794038f, -0.28291753f, 0.18427248f, 0.01188954f, 
    0.00325733f, 0.09093241f, 0.14752510f, 0.05157543f, -0.11025228f, -0.12425013f, 0.06562158f, 0.15222520f, 
    -0.11500694f, 0.01725538f, 0.11589222f, -0.01881683f, 0.03543401f, 0.09007068f, 0.08246499f, 0.17219490f, 
    0.19515133f, 0.00003192f, -0.12396754f, 0.16662891f, 0.24103031f, -0.10352050f, 0.22797391f, -0.06447689f, 
    0.49921998f, 0.46040428f, -0.62289888f, 0.01072888f, 0.12109545f, -0.00481208f, 0.24426100f, 0.03846396f, 
    -0.05991212f, -0.12941600f, -0.11337507f, 0.07995228f, 0.08044276f, 0.06644782f, 0.10166690f, 0.02679103f, 
    0.05563625f, 0.21154447f, 0.42033985f, -0.44522893f, -0.36576667f, -0.07512711f, 0.11373708f, 0.17577590f, 
    0.17065369f, -0.12161546f, -0.05487737f, -0.29337418f, 0.01286565f, -0.00322145f, -0.16155116f, 0.13875617f, 
    -0.04778813f, 0.06066914f, 0.14610544f, -0.06716745f, -0.28786147f, 0.04597506f, -0.06585906f, -0.20933539f, 
    -0.06053474f, -0.10531685f, -0.06964699f, -0.04696274f, -0.02183031f, 0.03875287f, 0.08162987f, -0.03607076f, 
    -0.08225642f, -0.02022465f, -0.07618388f, 0.11270163f, -0.03529978f, 0.02889578f, 0.19644137f, 0.15069816f, 
    0.20546238f, -0.13471554f, 0.01261530f, 0.22314219f, -0.05400876f, 0.20271692f, 0.11813961f, 0.03963067f, 
    0.11786979f, 0.13018765f, 0.04677897f, 0.00802965f, -0.08218267f, -0.05934802f, -0.10829866f, 0.09719673f, 
    -0.03195408f, -0.29734778f, -0.33262977f, -0.06523720f, -0.10651406f, -0.29452345f, -0.13748170f, -0.04632768f, 
    0.05581260f, 0.03501783f, -0.19999810f, -0.39037433f, 0.05635489f, -0.00319061f, 0.07075045f, -0.02486631f, 
    0.05550886f, -0.05487054f, -0.27225831f, -0.06147335f, 0.20856409f, 0.02106413f, 0.11081970f, 0.16090634f, 
    -0.05540836f, 0.06722426f, 0.05654002f, 0.36427036f, 0.22109242f, -0.04806274f, 0.04349802f, -0.33433527f, 
    0.00374407f, 0.05839979f, 0.19397438f, 0.01100784f, -0.01609003f, 0.46305057f, -0.52992964f, -0.02164201f, 
    -0.00823079f, -0.14564449f, -0.08935601f, 0.05036188f, -0.12047902f, -0.06040427f, 0.08891166f, 0.13679963f, 
    -0.16080341f, -0.01008407f, 0.12073478f, 0.03794799f, -0.06154755f, 0.16708079f, -0.50273800f, -0.11121320f, 
    0.08240602f, -0.27498424f, 0.13318817f, -0.04716842f, 0.07013819f, 0.03672357f, -0.03597265f, -0.08138097f, 
    0.09613023f, 0.00896150f, -0.20198154f, 0.06806465f, -0.25933158f, 0.04061083f, 0.08578475f, -0.19635403f, 
    0.11738827f, 0.19910765f, 0.17874731f, 0.02256238f, 0.00196117f, -0.13569720f, -0.07403352f, -0.22822414f, 
    -0.09212374f, 0.03607670f, 0.03447634f, 0.05191542f, -0.02077455f, -0.05924365f, 0.15410902f, -0.01198389f, 
    -0.15099677f, -0.30370426f, 0.36520222f, -0.17432708f, -0.30758840f, 0.12324495f, 0.07990535f, 0.03318712f, 
    0.00814075f, -0.01742497f, 0.07264925f, 0.02754771f, -0.08440758f, -0.06727771f, -0.15389010f, -0.07778414f, 
    -0.22386090f, -0.26325446f, -0.46868128f, -0.41554487f, -0.05654152f, -0.00333092f, -0.24426125f, -0.03227862f, 
    0.02242556f, -0.03663981f, 0.09361124f, 0.17408493f, -0.02914947f, -0.19449794f, -0.10695618f, -0.01722058f, 
    0.15664697f, -0.06548423f, 0.18085729f, -0.28363642f, -0.34173381f, -0.21964864f, -0.33494928f, 0.19914848f, 
    -0.08465217f, 0.02950841f, -0.03163925f, -0.01090444f, 0.01094482f, 0.00784512f, -0.00717954f, -0.13489589f, 
    -0.30379853f, -0.18985000f, 0.28847316f, -0.16683494f, 0.11368334f, 0.17187683f, 0.11812647f, 0.20703213f, 
    0.32364050f, 0.47156924f, 0.46236700f, -0.04762585f, 0.02863031f, -0.11922100f, -0.07429589f, -0.12800202f, 
    -0.03045560f, 0.37314066f, -0.09059368f, -0.02433941f, 0.13770097f, -0.03070856f, 0.04504903f, 0.14404117f, 
    0.07008918f, 0.04276790f, 0.30839133f, -0.03158639f, 0.65802395f, 0.05404854f, -0.08076315f, 0.14682765f, 
    0.03411828f, 0.13762222f, -0.02465275f, -0.23633023f, 0.00795359f, -0.07487252f, 0.06270119f, -0.00212101f, 
    0.16207102f, 0.03330822f, 0.06229150f, -0.00485518f, 0.02541296f, 0.03099513f, -0.21136875f, 0.07736146f, 
    -0.02839085f, 0.06315295f, 0.07609554f, -0.11518888f, -0.18198620f, 0.02841437f, -0.15180776f, 0.03448240f, 
    -0.09055965f, -0.04350701f, -0.02520712f, 0.20348638f, 0.15686263f, 0.20083824f, 0.14340329f, 0.00763442f, 
    0.11663762f, 0.27584031f, 0.01217301f, 0.16724226f, -0.17066799f, -0.12874834f, -0.17146392f, 0.20390005f, 
    0.00625956f, 0.19368778f, 0.26831990f, -0.09193191f, 0.06476153f, -0.17315200f, -0.01028779f, 0.11351515f, 
    0.14837611f, -0.21284732f, 0.25254285f, 0.15080589f, 0.03171777f, -0.01917839f, -0.05091200f, 0.15128814f, 
    0.24745141f, 0.12894885f, 0.20576629f, 0.06966553f, -0.09221486f, -0.04300554f, 0.12289343f, -0.12159219f, 
    -0.18742613f, -0.16841049f, -0.32839924f, -0.21870235f, 0.13233142f, 0.07313602f, 0.10599783f, 0.07353275f, 
    0.05549339f, 0.04470386f, 0.27959418f, 0.21705045f, -0.03569471f, 0.19830903f, -0.10498226f, -0.01064370f, 
    -0.08840740f, 0.09900349f, 0.04436484f, 0.08272190f, 0.03557253f, 0.05482804f, 0.02751998f, -0.07892028f, 
    0.06130029f, -0.11816183f, -0.03552768f, 0.07965972f, 0.21005371f, 0.16550578f, 0.06153237f, 0.05842460f, 
    0.23311828f, 0.06810689f, -0.03231188f, 0.03278098f, 0.00796017f, 0.12245935f, 0.01754957f, 0.06058264f, 
    0.05352661f, 0.16692121f, 0.04715674f, -0.03104415f, -0.30455303f, -0.06512830f, -0.06914760f, -0.00188782f, 
    0.03704328f, 0.05161126f, 0.25349328f, 0.06032869f, 0.12430949f, -0.21162209f, -0.22920261f, -0.14782955f, 
    0.07373602f, -0.01486750f, -0.01317162f, 0.13642699f, 0.03640462f, 0.05169550f, 0.08942492f, 0.03493238f, 
    -0.19956711f, 0.27869192f, 0.12865283f, 0.07752340f, -0.07976387f, -0.10975990f, -0.00648513f, 0.13149521f, 
    -0.14950790f, -0.04211272f, 0.04897318f, 0.23926389f, 0.16735491f, -0.24828763f, -0.05419062f, 0.06796422f, 
    0.08018332f, 0.28383902f, 0.17538404f, 0.13120498f, 0.03439313f, 0.06966753f, 0.03759250f, 0.14365329f, 
    0.19757369f, -0.18169288f, 0.25000331f, 0.03610231f, 0.10727350f, -0.09635288f, -0.15872718f, 0.10670566f, 
    0.03379425f, -0.00920406f, 0.05851443f, -0.04497784f, -0.00861245f, 0.16150387f, 0.09324852f, -0.02573532f, 
    0.04426741f, 0.04836259f, -0.02738768f, -0.02473346f, 0.08037253f, 0.15991718f, 0.14725183f, 0.00328559f, 
    -0.07873468f, -0.32944277f, -0.13292164f, -0.18849798f, -0.02285869f, 0.04329201f, 0.12295050f, 0.18982625f, 
    -0.09833150f, 0.22950256f, 0.02456259f, 0.31617066f, 0.15315707f, -0.12533385f, -0.28275153f, -0.11262760f, 
    0.11787020f, 0.09807662f, 0.09184501f, 0.14680873f, 0.04578546f, 0.06768371f, 0.18258318f, 0.14884435f, 
    -0.07742246f, 0.07441381f, -0.13201912f, 0.09233157f, -0.27010146f, -0.13412906f, -0.16511020f, 0.25722116f, 
    0.16039607f, -0.11422175f, -0.17799172f, -0.01529189f, 0.14575268f, -0.12727728f, 0.03633751f, -0.14660339f, 
    -0.05397581f, 0.01213603f, 0.01062739f, -0.04691018f, 0.44579569f, 0.26597208f, 0.24235968f, 0.08188996f, 
    0.02421177f, 0.23376620f, 0.19287243f, -0.02578958f, -0.11384191f, -0.20856583f, 0.15024523f, 0.01437798f, 
    0.09957767f, 0.02843267f, -0.20521352f, 0.06946671f, 0.22878823f, -0.05363960f, -0.41069323f, 0.07446499f, 
    -0.03101473f, -0.08648817f, -0.01238246f, 0.29253715f, 0.15015602f, -0.03120902f, 0.24702658f, 0.27671766f, 
    -0.20239498f, -0.11203057f, -0.05104616f, -0.08201300f, 0.05552891f, -0.01054696f, 0.14141829f, -0.47209904f, 
    -0.08580568f, -0.05490453f, -0.22613819f, 0.01222863f, -0.19817156f, 0.03863652f, -0.14199264f, 0.10586058f, 
    -0.06098406f, -0.01011629f, 0.23382346f, 0.15224729f, -0.10833193f, 0.05222739f, 0.16430125f, 0.00227786f, 
    0.11421882f, -0.23115447f, 0.03726783f, 0.24918589f, -0.03186043f, -0.04558374f, 0.10105029f, -0.03892082f, 
    -0.00953892f, -0.05177471f, -0.09803919f, -0.71532089f, -0.20168456f, -0.01862862f, 0.09848601f, -0.03404826f, 
    0.31681979f, 0.05416026f, 0.22513947f, -0.11601986f, -0.40588719f, 0.02747380f, -0.13512646f, -0.09844658f, 
    0.02129482f, 0.05376402f, 0.04979867f, 0.16699150f, -0.00860803f, 0.17806385f, 0.40798548f, 0.07088812f, 
    -0.07283057f, 0.00728546f, -0.00993460f, -0.02925814f, -0.16143134f, -0.01658756f, -0.31474367f, 0.06034156f, 
    0.05431329f, 0.17654753f, -0.05829090f, -0.02993392f, -0.19901939f, 0.03366283f, 0.12446611f, -0.09823432f, 
    -0.09892939f, -0.12108737f, 0.10969794f, -0.21509556f, 0.02442555f, 0.03376726f, 0.10572675f, 0.00635641f, 
    -0.14051045f, -0.02397319f, -0.06740781f, 0.11575498f, 0.01468208f, 0.02680735f, 0.23305985f, 0.08751916f, 
    0.57912016f, 0.48471761f, 0.21467495f, -0.08894321f, 0.04840216f, -0.02144510f, -0.13946097f, 0.02954249f, 
    0.05898891f, -0.15529867f, -0.28097740f, 0.18481889f, -0.03619403f, -0.03948013f, 0.23141330f, 0.01226643f, 
    0.03522039f, 0.07149886f, -0.32205704f, -0.20806152f, -0.32506388f, -0.02439128f, -0.21055268f, 0.01121802f, 
    -0.11618724f, 0.01361281f, 0.04575467f, -0.12678939f, 0.17473517f, 0.40197158f, 0.04478669f, 0.15415113f, 
    -0.03577543f, 0.17442547f, 0.06599965f, 0.00886674f, -0.32889116f, 0.20388977f, 0.11446932f, 0.07647740f, 
    -0.06424785f, 0.19807376f, 0.00826659f, -0.00040463f, 0.03299702f, 0.15160130f, -0.05576228f, -0.27107069f, 
    -0.39493030f, -0.06607769f, -0.17800911f, 0.05016939f, 0.07822990f, -0.12542105f, 0.02708374f, -0.08153171f, 
    0.05140148f, -0.03942489f, 0.05948637f, -0.02135686f, -0.10871737f, 0.11748754f, -0.04131041f, -0.02913272f, 
    -0.17322344f, 0.21870595f, -0.36691722f, 0.02157927f, -0.28013504f, 0.13330877f, 0.11767789f, 0.02308361f, 
    -0.23674449f, 0.01435089f, -0.16002917f, -0.09026995f, -0.22405910f, -0.22007385f, -0.02081756f, 0.17689133f, 
    -0.09450109f, -0.22602366f, 0.30780753f, 0.35568869f, 0.14861529f, 0.04957205f, -0.05725047f, 0.28446877f, 
    0.04515070f, 0.16123386f, 0.46277770f, -0.46980655f, 0.29610687f, -0.06376485f, -0.14597696f, 0.22890183f, 
    -0.14670920f, -0.28341994f, -0.08314319f, -0.07689878f, 0.12283026f, 0.10709700f, 0.05114817f, -0.06718646f, 
    0.07778242f, -0.03017371f, -0.24590254f, 0.07368103f, -0.00665280f, 0.19331829f, 0.15700398f, 0.08106198f, 
    -0.14121550f, -0.11753786f, 0.02879803f, 0.15956612f, -0.06898386f, -0.12002796f, 0.12783581f, -0.16059317f, 
    -0.24029833f, -0.06420443f, 0.04979987f, 0.14127170f, -0.02695430f, -0.12758066f, -0.25573561f, 0.46496561f, 
    0.06213765f, 0.01152590f, -0.00211424f, 0.02589255f, 0.15234013f, 0.12793887f, -0.18565318f, 0.24818225f, 
    -0.29612604f, 0.02482334f, -0.32775566f, -0.15177503f, -0.06304847f, 0.10493529f, 0.16733359f, -0.09276303f, 
    -0.02167437f, 0.22816882f, 0.00305617f, 0.11487024f, 0.04949417f, -0.08821908f, -0.00724939f, -0.01270347f, 
    0.11752308f, -0.10762337f, -0.09465800f, -0.01827175f, 0.07864901f, -0.04293185f, -0.04655014f, 0.15112017f, 
    -0.04337205f, 0.13021676f, -0.11793990f, 0.09873019f, 0.39322293f, 0.00478994f, -0.04957017f, 0.03922964f, 
    0.00720273f, 0.13086070f, 0.03229417f, 0.24602251f, 0.13147354f, 0.22174419f, 0.09017585f, 0.07593828f, 
    -0.01363536f, 0.10732529f, -0.06168726f, 0.07521643f, 0.26222149f, 0.12263193f, 0.15533675f, -0.18528192f, 
    0.03836091f, 0.10207887f, -0.08846232f, -0.14583567f, 0.28741375f, -0.53142214f, -0.35974133f, -0.02953625f, 
    -0.17761244f, 0.07762962f, 0.03876288f, 0.17766164f, 0.04531049f, -0.18595974f, -0.03600278f, -0.09557105f, 
    -0.37915781f, -0.09841481f, 0.07228977f, 0.08655298f, -0.01200652f, 0.04463875f, -0.08657967f, -0.04109563f, 
    -0.01634154f, 0.22770628f, -0.07105915f, 0.08047310f, 0.02691037f, -0.02086364f, -0.09044234f, 0.18220887f, 
    -0.25446123f, 0.01275908f, -0.08137974f, -0.04466197f, -0.05314594f, -0.24689895f, 0.02591115f, 0.08491287f, 
    -0.17170721f, 0.03562686f, 0.22339095f, 0.41643000f, -0.10633495f, 0.13627936f, -0.37424114f, 0.13447589f, 
    0.20557922f, -0.03909735f, -1.01315141f, -0.36422810f, -0.12964113f, 0.13192576f, 0.12320298f, -0.10829821f, 
    0.18497510f, 0.19261841f, 0.11000403f, -0.18988232f, -0.13160682f, 0.09530437f, -0.07788122f, 0.05192132f, 
    -0.01669502f, 0.11866979f, -0.24295977f, 0.07340854f, 0.22070540f, 0.02304691f, 0.08730145f, -0.06981631f, 
    0.03654207f, -0.13469231f, 0.16134666f, -0.12353741f, 0.16033435f, 0.05858127f, 0.01166851f, 0.11334381f, 
    0.24536406f, -0.09168357f, 0.02921495f, 0.00579127f, -0.02853307f, 0.06264093f, 0.02362856f, -0.06082140f, 
    0.14994682f, -0.06610101f, 0.04844531f, -0.03851550f, 0.04115985f, 0.10400397f, -0.03027619f, -0.06767032f, 
    -0.02974984f, -0.23443089f, -0.09725197f, -0.16834082f, 0.03431093f, 0.15341294f, 0.13182880f, -0.00621745f, 
    -0.08447187f, 0.23962484f, -0.20542803f, 0.11856047f, -0.17011496f, -0.17508397f, 0.02258107f, 0.01436904f, 
    -0.12680639f, -0.13164268f, -0.00354470f, 0.26962888f, 0.08002095f, -0.04791585f, -0.12986989f, 0.10874195f, 
    0.12560262f, -0.02739440f, -0.46023479f, -0.39307186f, -0.33309311f, -0.07745647f, -0.06780234f, 0.23750328f, 
    -0.08882058f, -0.02061066f, -0.04807504f, -0.20244028f, -0.15809679f, -0.09889273f, -0.02336563f, 0.04480323f, 
    0.05232994f, 0.01130066f, 0.20213504f, 0.01324794f, 0.16638385f, -0.15027058f, 0.14323048f, 0.10261892f, 
    0.01779940f, 0.03771975f, 0.08449327f, -0.01086052f, 0.12298196f, 0.13516301f, -0.07684245f, -0.07507855f, 
    -0.24808027f, 0.08088353f, -0.02717043f, 0.02367761f, -0.08187742f, 0.13989109f, -0.56024247f, -0.03285137f, 
    -0.25442111f, 0.02965245f, -0.15964320f, 0.10672859f, 0.20220847f, 0.08646870f, -0.00358496f, 0.21571356f, 
    0.08316406f, 0.10255371f, -0.02417607f, -0.02394410f, -0.07660472f, 0.04045255f, -0.05748654f, 0.12723263f, 
    0.04145683f, -0.07681067f, -0.16356464f, 0.02177075f, 0.11944752f, -0.11645147f, 0.05281152f, -0.00763106f, 
    0.11594385f, 0.25955266f, 0.23725270f, 0.27533427f, -0.04121419f, 0.18134509f, -0.10517590f, -0.11230170f, 
    -0.02353543f, -0.13024464f, 0.05362920f, 0.12137395f, -0.01679417f, 0.10580144f, 0.21797684f, 0.08421864f, 
    0.06567517f, 0.05232326f, -0.06078309f, -0.37875250f, 0.21261163f, 0.18035749f, 0.07480879f, -0.19286405f, 
    0.01510277f, 0.09360919f, -0.05420287f, -0.00031849f, 0.33173910f, 0.13439812f, 0.26056525f, -0.07373975f, 
    -0.04679652f, -0.36453134f, 0.03497091f, -0.03768001f, 0.17568241f, 0.02240748f, -0.21248253f, -0.01691333f, 
    -0.07383933f, 0.05683301f, 0.05359585f, 0.18874982f, -0.11806322f, 0.21225221f, 0.32144517f, -0.00191139f, 
    0.34090450f, 0.10304535f, 0.10887261f, 0.02252866f, 0.02078932f, -0.05277244f, 0.12622648f, -0.05169315f, 
    -0.03259984f, 0.13000819f, 0.08592680f, -0.21154575f, 0.00609853f, 0.03005691f, 0.07080870f, -0.00129108f, 
    -0.48061258f, -0.42227605f, -0.53757477f, 0.08545005f, -0.01160800f, -0.06807329f, -0.03672932f, -0.00662044f, 
    -0.10786365f, 0.06510302f, 0.20278378f, 0.09999431f, -0.09034923f, 0.03326739f, -0.11464122f, 0.03075819f, 
    -0.05638776f, -0.01006263f, 0.37151402f, -0.56933486f, -0.70497322f, 0.10829075f, -0.08127262f, -0.02307621f, 
    -0.05520447f, -0.07494950f, -0.12238692f, -0.06616461f, -0.20343527f, -0.31667149f, -0.13283391f, 0.05253360f, 
    0.04259136f, -0.00468193f, 0.09469006f, -0.04377914f, -0.16069911f, -0.58347678f, 0.14998636f, 0.13652286f, 
    0.05472223f, 0.09811704f, -0.03869998f, -0.01153956f, -0.00180820f, 0.07857091f, 0.11793941f, 0.12009342f, 
    0.04730333f, 0.07901797f, 0.00651852f, 0.03161361f, 0.07729483f, 0.29134655f, -0.12143497f, -0.53163666f, 
    0.20932420f, -0.08336496f, -0.07379694f, 0.24387446f, 0.05454359f, 0.11276842f, -0.01679797f, -0.76488394f, 
    -0.22140077f, 0.59712833f, -0.05189861f, 0.06237291f, 0.03294022f, -0.04625541f, -0.00462547f, 0.26207951f, 
    -0.12273422f, -0.64371341f, -0.58294684f, -0.07457709f, -0.13614246f, 0.18406729f, -0.07946921f, 0.02906355f, 
    0.00072033f, 0.53762734f, -0.39530295f, 0.81781965f, -0.13895296f, -0.05028803f, -0.11270783f, 0.04046793f, 
    0.10005224f, -0.12964560f, 0.77062070f, 0.52012688f, -0.10472804f, -0.03754876f, 0.02690335f, 0.18996221f, 
    0.05462500f, -0.03386182f, 0.20163748f, 0.01713949f, -0.02788222f, 0.15026301f, -0.06243685f, -0.02486880f, 
    0.18741263f, 0.07607108f, -0.03179414f, 0.10880695f, 0.02080414f, 0.10191891f, 0.40364528f, -0.09988350f, 
    -0.05904273f, 0.03276009f, 0.08958320f, 0.08831246f, -0.12812223f, -0.21477506f, -0.25977126f, -0.14974159f, 
    0.21378267f, 0.06555766f, 0.08259143f, -0.10242472f, -0.09451728f, 0.15224646f, 0.11659483f, 0.17504674f, 
    0.01886429f, -0.26941225f, -0.00394352f, -0.19141078f, -0.08935591f, -0.02130184f, -0.18426108f, 0.10162677f, 
    0.19526769f, 0.05932586f, 0.00545571f, -0.01813264f, -0.22629324f, -0.08635902f, 0.03887131f, -0.06407357f, 
    0.12731628f, -0.19963317f, -0.03002361f, 0.09668961f, -0.00867349f, 0.27049720f, 0.07344270f, 0.06951116f, 
    0.02717847f, 0.02062789f, 0.16601820f, 0.09613457f, -0.06224949f, -0.02214806f, 0.00779298f, 0.07359163f, 
    -0.12042939f, -0.11955610f, -0.10892569f, -0.16641860f, -0.01800517f, 0.01534217f, -0.01087970f, 0.02378498f, 
    0.11578716f, 0.32609472f, 0.07517721f, 0.37134182f, 0.07483532f, -0.36592901f, 0.02745435f, -0.12124950f, 
    -0.04190345f, 0.04034676f, -0.08689238f, -0.07378460f, 0.25415850f, -0.23884632f, -0.35429657f, 0.04865467f, 
    0.05205412f, -0.20559341f, 0.07982444f, 0.04376713f, -0.03221807f, 0.39309028f, 0.16324160f, 0.06541961f, 
    -0.20711948f, -0.00630906f, -0.14478494f, -0.04026506f, -0.15279782f, -0.00818169f, -0.03538061f, 0.02949576f, 
    -0.00722283f, 0.00473811f, 0.01369259f, 0.09056468f, 0.03899388f, 0.14640108f, 0.02574996f, 0.10424390f, 
    0.16171919f, 0.24947630f, -0.09769260f, -0.04093745f, -0.03401498f, -0.02019407f, -0.28173959f, -0.10501564f, 
    0.42916989f, -0.71244192f, -0.00259928f, 0.02897391f, -0.07765117f, -0.28238493f, 0.01140505f, 0.38107395f, 
    -0.12499405f, 0.41625023f, -0.26129138f, 0.45819733f, -0.15786646f, -0.06520731f, 0.03767281f, 0.00278142f, 
    -0.06136702f, 0.05708616f, 0.78616494f, 0.02423905f, 0.08890986f, -0.08360587f, 0.17822355f, 0.23691303f, 
    -0.03582567f, -0.08663755f, 0.24807738f, -0.16769718f, 0.14423947f, 0.11602481f, 0.08470898f, -0.07786591f, 
    -0.07249586f, -0.08846588f, 0.05404508f, 0.05107571f, 0.50640851f, 0.04301091f, 0.70029700f, -0.14755772f, 
    -0.09316535f, -0.13732979f, 0.10439961f, 0.14160296f, -0.07616026f, 0.05850050f, -0.02211349f, 0.11708474f, 
    -0.04353064f, 0.07763227f, 0.03662625f, 0.10179728f, -0.11279372f, 0.02239694f, 0.42951897f, -0.39250004f, 
    -0.43568379f, -0.08362024f, 0.02632542f, -0.01727106f, 0.02273714f, -0.04293269f, -0.09978457f, 0.02451343f, 
    0.20665903f, -0.12175924f, -0.08567864f, -0.26933473f, -0.07835747f, -0.29212102f, -0.15769240f, -0.06685624f, 
    0.20881864f, 0.08399515f, 0.09693314f, 0.06267910f, 0.09984171f, 0.16603933f, -0.07839478f, 0.04806046f, 
    0.02229193f, -0.20370571f, -0.36712182f, -0.19980085f, 0.06940918f, 0.11043702f, 0.07849502f, 0.03046684f, 
    -0.09643594f, 0.01100031f, 0.17457364f, 0.20020577f, -0.03414267f, 0.39707875f, -0.05904845f, -0.13298169f, 
    0.04771181f, -0.06317534f, -0.16086788f, 0.22971217f, 0.10938410f, -0.27655640f, -0.14075606f, -0.19158675f, 
    0.30992904f, 0.04220021f, 0.01939350f, 0.01615744f, 0.24938154f, 0.24536449f, 0.19452751f, 0.37242252f, 
    0.10921615f, 0.14398590f, 0.04987811f, -0.01783413f, -0.30562109f, -0.43098521f, -0.12895536f, 0.07015442f, 
    0.04970520f, 0.02350152f, 0.11320080f, 0.02840795f, -0.13748504f, -0.13585916f, -0.04647173f, 0.46301821f, 
    0.08192784f, 0.05715497f, 0.13176195f, 0.08727437f, -0.11516357f, 0.00503201f, -0.00451233f, 0.26067227f, 
    0.30638802f, 0.09347104f, 0.14949620f, -0.15140852f, -0.06488378f, 0.25649288f, -0.18076350f, 0.25313988f, 
    0.43611363f, 0.23949982f, 0.13215575f, -0.04026906f, 0.03085966f, 0.30854616f, 0.05666730f, 0.02786188f, 
    -0.01369739f, 0.25831363f, -0.00731943f, 0.10967680f, 0.17175187f, -0.19121583f, 0.05524591f, -0.05380342f, 
    -0.19764911f, 0.00795096f, 0.28410500f, 0.14362407f, 0.50964475f, -0.00158391f, 0.04868107f, 0.28341070f, 
    -0.05265126f, 0.21781741f, 0.19789578f, -0.24172537f, -0.10432503f, -0.23178597f, 0.06146951f, 0.00206468f, 
    0.01548812f, 0.18932556f, 0.03891652f, -0.12825811f, 0.01215460f, 0.19469793f, -0.22556968f, -0.04717461f, 
    0.09691333f, -0.02623371f, 0.02786043f, -0.02591888f, -0.13187198f, 0.13011694f, 0.23067716f, 0.23566100f, 
    0.08277499f, -0.10803346f, -0.13111342f, 0.17668939f, 0.06234723f, -0.09111856f, -0.19052020f, 0.19622101f, 
    -0.12717998f, 0.18829352f, -0.13828643f, 0.13440837f, 0.02956374f, -0.17410634f, -0.01783941f, 0.03019808f, 
    -0.21449274f, -0.07908376f, 0.09970296f, 0.03295041f, -0.09459945f, 0.10283730f, -0.15580185f, 0.04077097f, 
    0.23185293f, 0.14584847f, -0.01163474f, 0.02763007f, 0.23190799f, -0.05944883f, 0.01836513f, 0.09321525f, 
    0.13915019f, 0.11655352f, -0.07930682f, -0.19437492f, 0.07961001f, 0.01186212f, 0.02548112f, 0.13717845f, 
    -0.08447519f, 0.05823387f, -0.15348269f, -0.22206461f, 0.03565724f, -0.02970501f, 0.07069162f, -0.00392382f, 
    0.20983051f, 0.12106592f, -0.08671798f, 0.08555805f, 0.05588639f, 0.17302854f, 0.11525512f, 0.14241150f, 
    0.07438699f, 0.11216217f, 0.07589360f, -0.04583865f, 0.09516333f, 0.12738585f, -0.03053144f, 0.15554228f, 
    0.24335389f, 0.02198306f, -0.06099226f, -0.08512924f, -0.00437362f, 0.02268993f, 0.08359517f, -0.10929985f, 
    0.05227897f, 0.13688160f, 0.08812631f, 0.04813530f, 0.04488963f, -0.11374041f, -0.05425686f, -0.37761936f, 
    -0.16081156f, 0.08412194f, 0.06150945f, -0.10937581f, -0.03784433f, 0.12176751f, 0.04555871f, -0.19822012f, 
    -0.21404871f, -0.43530676f, 0.08294285f, 0.08129642f, 0.02424490f, 0.01091438f, 0.04239788f, -0.12470769f, 
    0.08133164f, 0.35234204f, 0.27524024f, 0.00541550f, 0.08433173f, 0.15483455f, -0.11079096f, -0.05240580f, 
    -0.10035059f, 0.10744296f, 0.01555439f, -0.46474355f, -0.12083484f, -0.06733777f, 0.00485506f, -0.09347016f, 
    0.06847363f, 0.06736901f, -0.08812797f, 0.13725512f, 0.08290131f, -0.12988167f, 0.13834876f, -0.25120762f, 
    -0.03799940f, 0.40739703f, -0.36187270f, 0.04158117f, 0.07930597f, -0.15709938f, -0.02698462f, -0.05619956f, 
    -0.04969976f, 0.09980337f, 0.35481745f, 0.08283716f, -0.08029357f, -0.05677022f, -0.14007455f, 0.13010110f, 
    -0.09511387f, 0.01126073f, -0.00373149f, -0.02955365f, -0.03990294f, -0.00560334f, 0.12981869f, -0.18706848f, 
    0.08630907f, 0.06055547f, -0.08018620f, 0.15495554f, -0.03637371f, -0.01209357f, 0.07260882f, 0.11432149f, 
    -0.03028514f, 0.02783104f, 0.19154173f, 0.16542989f, 0.12850831f, -0.12016917f, -0.03039721f, 0.12724178f, 
    -0.51653117f, -0.23987898f, 0.08453359f, 0.04299164f, 0.12008470f, 0.01410110f, 0.00940984f, 0.03672006f, 
    0.01857536f, -0.01697831f, -0.04968564f, -0.06471676f, -0.00326244f, 0.03051339f, -0.02394058f, -0.06275254f, 
    -0.05454685f, -0.04653595f, 0.04001247f, -0.02364817f, 0.03779771f, 0.04441739f, -0.03888624f, -0.03394761f, 
    -0.05939108f, -0.02827295f, -0.04115428f, 0.02509405f, -0.05613719f, -0.07181903f, 0.00747180f, -0.04199111f, 
    -0.05936094f, 0.04252278f, 0.00573696f, -0.01819186f, 0.01383510f, 0.02161781f, -0.05860730f, 0.00810352f, 
    0.01516445f, -0.05732515f, -0.07056092f, -0.06334996f, -0.02202412f, 0.04662157f, 0.02572282f, -0.06161540f, 
    0.01540632f, 0.04292712f, -0.06630779f, -0.00799976f, -0.01527912f, -0.03205293f, -0.05803369f, 0.00493181f, 
    0.03981626f, 0.01367669f, -0.07267987f, -0.01194235f, -0.05839185f, -0.05053719f, 0.02205550f, 0.01954587f, 
    0.04215299f, -0.03101429f, 0.00349784f, 0.03478175f, 0.02023468f, -0.03848887f, -0.04422827f, 0.00084997f, 
    -0.00964495f, -0.04346023f, -0.03408715f, 0.02926100f, -0.01603706f, 0.01570268f, 0.03837540f, 0.03238129f, 
    -0.05149795f, 0.00411623f, -0.05339361f, 0.00535117f, -0.05857970f, 0.03462823f, 0.03474196f, -0.05253169f, 
    -0.02371093f, -0.05018836f, -0.04392167f, -0.05791702f, -0.03103559f, -0.03708280f, 0.03675956f, 0.03436803f, 
    0.01991221f, 0.00399301f, -0.00586292f, -0.02583283f, 0.01811872f, -0.01911636f, -0.02212215f, -0.01188544f, 
    -0.05975779f, -0.07082501f, 0.01140113f, -0.04479665f, 0.03398022f, -0.03736527f, -0.00126146f, -0.04901993f, 
    0.03714723f, -0.05371521f, 0.02078497f, -0.03256747f, -0.03884446f, -0.00696983f, 0.02354620f, -0.04672014f, 
    0.03804605f, 0.04220548f, -0.00845006f, 0.03421238f, -0.02571577f, 0.00436381f, -0.04214134f, -0.03841649f, 
    -0.06031407f, -0.04565677f, 0.01379958f, 0.03912168f, 0.01597715f, -0.01372974f, -0.07132573f, -0.00206053f, 
    0.04173345f, -0.05062240f, 0.05123306f, -0.01572450f, -0.01153111f, -0.02109168f, -0.05294970f, -0.03806083f, 
    0.04201288f, -0.03322232f, 0.03435432f, 0.05128214f, -0.00507675f, -0.03576848f, 0.00018027f, 0.03978431f, 
    0.00910702f, -0.01228397f, 0.04300073f, 0.03232677f, -0.03645864f, -0.03935545f, 0.03662932f, -0.05081142f, 
    -0.05345782f, 0.02735718f, -0.01745518f, 0.02043302f, -0.01762316f, 0.02211194f, 0.00190531f, -0.04233006f, 
    0.01845901f, 0.02165609f, 0.02748528f, 0.02031245f, 0.04479812f, 0.03463499f, -0.04442625f, 0.02449977f, 
    0.03230354f, 0.00738828f, -0.01413342f, 0.00088512f, -0.04271916f, -0.03409682f, 0.05101831f, 0.00158371f, 
    -0.06704919f, -0.02123975f, -0.04792445f, -0.06599669f, 0.03320171f, -0.03253663f, 0.01834523f, -0.02880543f, 
    -0.03955824f, -0.03164010f, -0.04567832f, 0.03102100f, 0.03010215f, -0.06522957f, -0.06821596f, 0.02226949f, 
    -0.04056374f, -0.01043465f, 0.01854897f, -0.05283735f, -0.00955441f, 0.02625804f, 0.03213288f, 0.03355817f, 
    0.04489607f, -0.06896523f, -0.05386658f, -0.04794921f, -0.01491147f, -0.01057927f, -0.03623566f, 0.04053921f, 
    -0.05164587f, -0.02390769f, -0.05049878f, -0.04714749f, -0.04614738f, -0.01048589f, 0.00793731f, -0.04237331f, 
    0.06345729f, 0.05146039f, -0.02015853f, -0.03551798f, -0.05498840f, 0.01019724f, -0.03594846f, -0.02594839f, 
    0.01298498f, 0.02190738f, 0.02922067f, -0.00456074f, 0.00548930f, 0.00550923f, 0.02896762f, 0.03159487f, 
    -0.01494910f, 0.00113343f, 0.02368431f, 0.00906275f, 0.01970654f, -0.02348555f, 0.02227359f, -0.02991925f, 
    0.00416665f, -0.05715099f, 0.02403896f, -0.00597055f, 0.00184616f, 0.05102331f, 0.02549586f, -0.04722937f, 
    0.03244184f, -0.04882588f, -0.03482733f, 0.01303309f, -0.01745295f, 0.02371874f, 0.00971479f, 0.04363125f, 
    -0.01905056f, -0.01367599f, 0.00533670f, -0.03564391f, -0.02819851f, -0.01318791f, -0.05049438f, 0.04588175f, 
    0.03508049f, 0.01380380f, 0.03257955f, -0.02744814f, -0.06761404f, -0.04461464f, -0.03545252f, -0.05647421f, 
    -0.01711266f, -0.00896899f, 0.00982068f, -0.02816915f, 0.03132199f, 0.00389313f, -0.05651017f, 0.02217825f, 
    -0.03582192f, -0.06027458f, -0.01868676f, 0.03573852f, -0.02468741f, -0.01420397f, -0.07009751f, 0.01409297f, 
    -0.00940801f, 0.03514896f, -0.30128959f, 0.14490995f, -0.00895348f, -0.00361373f, -0.16738105f, 0.00423231f, 
    -0.09087190f, -0.02297295f, 0.00471319f, -0.09075700f, -0.11091345f, 0.02627163f, -0.02547058f, 0.14427556f, 
    0.13811262f, 0.02583717f, -0.06938474f, -0.14439996f, 0.11922689f, 0.11081465f, -0.11070471f, -0.15815274f, 
    0.06050772f, 0.00347875f, 0.08609234f, -0.08396690f, 0.13979690f, 0.21918589f, -0.00302365f, 0.13876767f, 
    0.14745922f, 0.02838727f, 0.16411121f, -0.11231259f, -0.34328377f, -0.15370737f, 0.33824807f, -0.08247800f, 
    -0.01112529f, -0.09424193f, 0.03293908f, 0.08216838f, 0.15713067f, -0.29943681f, 0.10403526f, 0.01028515f, 
    0.02884996f, -0.05553641f, -0.26827171f, -0.00984757f, 0.10986947f, 0.17500550f, -0.79631704f, -0.66435039f, 
    -0.31785518f, 0.09920317f, 0.12196674f, 0.23754211f, 0.03133789f, -0.08307336f, -0.04864747f, -0.22661410f, 
    -0.40102056f, -0.06336489f, -0.13634214f, -0.09571982f, -0.00875273f, -0.07992372f, -0.13169384f, 0.06237562f, 
    -0.22173603f, -0.15631568f, -0.53873682f, 0.15509810f, 0.05393707f, 0.18030293f, -0.04648008f, -0.06656404f, 
    -0.01834951f, 0.18832490f, 0.17683974f, -0.10637898f, -0.06765939f, -0.03716562f, -0.12584853f, 0.09071995f, 
    -0.03216429f, 0.02133743f, 0.23966718f, 0.05678509f, -0.03397134f, -0.32514629f, 0.12439170f, 0.11381939f, 
    -0.10628800f, 0.01549116f, -0.11904649f, -0.32736301f, -0.36943057f, 0.24923883f, -0.01191452f, -0.00931061f, 
    0.16000940f, -0.01026413f, -0.11253998f, 0.02444124f, 0.11770429f, 0.10175555f, 0.26173788f, -0.00296928f, 
    -0.07387697f, -0.10670274f, 0.08512012f, 0.01124906f, -0.15241039f, 0.02407562f, -0.26557711f, -0.15172726f, 
    0.14366145f, 0.00771101f, 0.12450529f, 0.02704893f, -0.14719775f, 0.00149535f, 0.15148646f, 0.09855390f, 
    -0.03154637f, -0.09958789f, -0.03164218f, 0.06745512f, 0.04198118f, 0.13318174f, -0.00144553f, -0.00529514f, 
    0.08458836f, -0.15824392f, -0.02623384f, 0.15622231f, 0.05424395f, 0.09925555f, 0.11600588f, 0.04195691f, 
    0.51662487f, -0.30950427f, -0.55868942f, -0.05006424f, 0.18086541f, 0.25804129f, -0.07125709f, 0.01106173f, 
    -0.07137825f, -0.32088915f, -0.04050674f, 0.10806134f, -0.02850017f, 0.35541493f, 0.15033291f, 0.31022906f, 
    0.21183839f, 0.13186671f, -0.28814501f, -0.43111986f, 0.08834495f, 0.01411247f, 0.10433187f, 0.11236536f, 
    0.07838262f, -0.06853179f, 0.08645107f, 0.26176426f, 0.20437686f, -0.12061275f, 0.01628750f, 0.10305156f, 
    0.03970823f, 0.05359250f, -0.05864314f, -0.00179890f, 0.40242022f, 0.16294199f, -0.38427788f, -0.16171503f, 
    -0.00962677f, 0.09061642f, -0.03308679f, -0.00977396f, 0.01185392f, 0.00362072f, 0.14863586f, -0.15018901f, 
    -0.07399007f, -0.06002208f, 0.09941167f, 0.11586401f, -0.11338037f, -0.06486970f, -0.08376013f, 0.02801917f, 
    0.01476661f, 0.04232224f, 0.09540475f, 0.13677660f, 0.12889276f, 0.07967114f, 0.19728974f, -0.05784612f, 
    0.04947665f, 0.03933028f, -0.05672772f, -0.02078916f, 0.02576304f, 0.14911187f, 0.05389042f, 0.02777769f, 
    0.29226276f, 0.14673577f, 0.03302742f, 0.09155443f, -0.02499982f, -0.16412717f, -0.09850426f, 0.12566040f, 
    -0.04669455f, 0.30813456f, 0.03693174f, 0.05186629f, -0.04454841f, 0.10951431f, -0.24379383f, 0.10477360f, 
    -0.12016296f, 0.23984960f, 0.02961170f, -0.34323192f, -0.12170114f, -0.09406832f, 0.06815002f, 0.27571374f, 
    0.05727163f, -0.04972923f, -0.06753211f, 0.07661965f, -0.25195268f, -0.20836112f, 0.04222362f, 0.01775780f, 
    0.18281364f, -0.08162229f, 0.00664050f, -0.12584762f, 0.45949498f, 0.44794315f, 0.23824367f, -0.07801108f, 
    -0.03315895f, -0.13017800f, -0.01117714f, -0.07447961f, -0.26276806f, -0.05101644f, 0.04734205f, 0.03159901f, 
    0.03683263f, -0.00503810f, 0.06073125f, -0.00503531f, 0.07199998f, 0.07146225f, 0.51426160f, 0.41399789f, 
    -0.29557940f, -0.09151661f, 0.11875723f, 0.12182082f, 0.02427504f, 0.02709943f, -0.23225901f, -0.15250382f, 
    -0.08610747f, -0.16946633f, -0.01106005f, 0.11734882f, -0.06248197f, 0.12289565f, -0.12168963f, 0.02222968f, 
    -0.17275593f, -0.22077468f, -0.03592391f, 0.18265687f, -0.23753853f, 0.06750537f, 0.14726490f, -0.09461399f, 
    -0.05448590f, -0.25009525f, 0.02129482f, -0.05959865f, 0.02819002f, -0.04011323f, -0.02829850f, 0.01030873f, 
    -0.04622212f, 0.06598096f, 0.21879527f, 0.50780094f, 0.38691869f, -0.13917148f, -0.04477246f, 0.02102686f, 
    0.02826029f, 0.09350915f, -0.06516254f, -0.07607346f, -0.15550481f, -0.08503007f, 0.20144466f, -0.27309763f, 
    0.05886969f, -0.09746224f, -0.07381553f, -0.16651627f, 0.31206957f, 0.19808993f, 0.14660431f, -0.11727696f, 
    0.05482272f, 0.03067679f, 0.05187182f, 0.06033693f, -0.06895436f, -0.23954475f, -0.19407538f, 0.29891369f, 
    -0.16422087f, 0.08336022f, -0.24610180f, 0.05417635f, -0.17617205f, 0.11972817f, 0.32333210f, -0.04548118f, 
    0.40595970f, -0.14295906f, -0.04933551f, 0.17784661f, 0.01691628f, -0.00552229f, -0.06050926f, 0.11863124f, 
    0.29615760f, 0.22882855f, 0.00504432f, 0.04381225f, 0.02942898f, 0.18601927f, -0.02343472f, 0.03832381f, 
    -0.17719363f, 0.02702620f, 0.30657801f, 0.06145139f, -0.09461532f, -0.07065604f, 0.02180498f, -0.11625804f, 
    -0.05749452f, -0.01670279f, 0.24687365f, 0.18913066f, -0.02811427f, -0.06126175f, -0.05463434f, 0.09077922f, 
    -0.04799707f, -0.05545416f, -0.61454886f, 0.44763932f, 0.07605384f, -0.14471373f, 0.01737650f, -0.17704014f, 
    -0.14447115f, -0.01068267f, -0.10638150f, 0.04865203f, 0.05795580f, -0.08217904f, -0.06548414f, 0.11313067f, 
    -0.05293584f, 0.00806053f, -0.06096429f, -0.02557022f, -0.16716179f, 0.05239603f, 0.19606359f, 0.01507500f, 
    0.11096392f, -0.13667713f, 0.05672554f, 0.01402513f, 0.00690121f, -0.02198327f, 0.23705408f, 0.04323022f, 
    0.05287744f, -0.06986993f, -0.13450535f, 0.05788152f, 0.07345682f, -0.04432777f, -0.42147219f, 0.06438862f, 
    -0.43746352f, -0.12628256f, 0.15209901f, -0.10945335f, -0.19499689f, 0.05074545f, 0.11201071f, -0.21051389f, 
    -0.16554792f, 0.04184012f, 0.02033807f, 0.03108389f, 0.21122594f, 0.01903025f, -0.09259110f, -0.00937518f, 
    -0.25153506f, -0.13471498f, 0.02187751f, -0.00239011f, -0.30854362f, 0.37975538f, -0.19292934f, -0.10854908f, 
    0.03390765f, -0.24962129f, 0.11830007f, 0.34552357f, -0.09716042f, -0.01040588f, -0.12836753f, -0.35713625f, 
    -0.26316485f, -0.04766310f, -0.15669505f, 0.09487144f, -0.00816258f, -0.06668935f, 0.19456647f, -0.01096855f, 
    0.02048051f, -0.04804071f, -0.01133382f, -0.05079523f, 0.18242820f, 0.07584947f, -0.04109606f, -0.08251216f, 
    0.07168811f, 0.07963654f, 0.06725337f, 0.04620516f, -0.10139741f, 0.16408558f, 0.36236542f, -0.06417020f, 
    -0.11425482f, -0.12393639f, 0.12639454f, 0.15336603f, -0.07710306f, -0.05333203f, -0.07606499f, 0.03831012f, 
    -0.09099084f, 0.05151413f, 0.17103727f, -0.02765597f, -0.07327310f, 0.06617170f, -0.32837304f, -0.06100345f, 
    -0.35706961f, -0.03954836f, -0.04707552f, 0.11336612f, -0.02499946f, -0.05598444f, 0.06207034f, -0.23587482f, 
    -0.02846974f, 0.16034158f, 0.05319055f, 0.05199158f, -0.00084208f, -0.07450406f, 0.02098672f, -0.04551792f, 
    -0.15094160f, -0.13149092f, 0.28111172f, 0.15526833f, -0.03014289f, -0.04233970f, 0.18074903f, -0.00743928f, 
    0.17523488f, -0.26566389f, 0.12572102f, 0.05643136f, -0.12474336f, 0.06687949f, -0.17950384f, -0.03127645f, 
    0.11947180f, -0.02457439f, 0.04237594f, 0.00647004f, -0.08666294f, 0.01860836f, 0.45741823f, 0.00016123f, 
    0.01393070f, 0.17000534f, -0.10583157f, -0.13031910f, -0.07480674f, 0.26403764f, 0.13508530f, -0.16645844f, 
    0.14103934f, 0.02217008f, -0.12325318f, -0.03982001f, -0.26843217f, -0.37928921f, 0.19527182f, 0.11023549f, 
    0.16619967f, 0.06428839f, 0.17865594f, -0.07739262f, 0.12414603f, 0.11673299f, -0.02799855f, 0.16044654f, 
    0.03293126f, -0.09415008f, -0.01607911f, 0.22836453f, 0.15433720f, -0.10464591f, -0.03119945f, 0.24163005f, 
    0.15356015f, -0.08945344f, -0.08921678f, -0.19306166f, 0.17231904f, -0.08088885f, 0.01480278f, -0.06363714f, 
    0.02277099f, -0.17029774f, 0.06290906f, -0.25412348f, 0.10849294f, -0.18874890f, -0.07267968f, 0.04024933f, 
    -0.13177420f, -0.15759695f, -0.26947507f, 0.13909188f, -0.00325542f, 0.19930777f, 0.06549744f, 0.04643095f, 
    0.02400752f, 0.28811279f, 0.31928921f, 0.27978775f, -0.02274068f, -0.07488243f, 0.01343088f, -0.03723958f, 
    0.30750558f, 0.00171403f, 0.07237305f, -0.01472791f, 0.11478764f, 0.12580849f, -0.04336601f, -0.08058375f, 
    -0.05443171f, 0.04936319f, 0.04245080f, -0.35212326f, -0.10328746f, 0.04781667f, -0.08389202f, 0.01358357f, 
    0.03791157f, -0.13737337f, -0.10612752f, 0.04404148f, 0.07299956f, -0.12963738f, 0.33758917f, 0.23005949f, 
    0.02244912f, -0.15484846f, 0.03011895f, 0.03402018f, 0.14682484f, -0.05393222f, 0.30439469f, 0.38242379f, 
    -0.03451787f, -0.06328760f, 0.08211801f, 0.05164865f, -0.08279042f, 0.00124032f, -0.02719181f, 0.15178503f, 
    -0.21032143f, 0.00825965f, 0.26520330f, 0.11161533f, 0.10581055f, -0.10303079f, 0.03864616f, -0.14473592f, 
    -0.06121870f, 0.20509040f, -0.29025435f, 0.04156008f, -0.13678426f, 0.08119310f, 0.12813058f, -0.01383294f, 
    -0.24042036f, -0.36389822f, -0.09660085f, 0.16854592f, 0.02877147f, 0.25482413f, 0.04672279f, -0.01556826f, 
    0.00270197f, 0.23647614f, 0.00815244f, 0.22692104f, -0.06421045f, -0.01251344f, -0.23035762f, 0.15038121f, 
    -0.04636202f, 0.06244221f, 0.14157803f, -0.38515249f, 0.10988779f, 0.20144650f, -0.38314387f, 0.07791254f, 
    0.08456647f, 0.16310062f, -0.18130861f, 0.08564592f, 0.21868180f, 0.32514030f, 0.03727452f, -0.10511541f, 
    -0.30919927f, -0.02247402f, 0.05417152f, 0.26022041f, -0.24717973f, -0.17727254f, 0.15036148f, -0.12561607f, 
    -0.20480876f, -0.34705377f, 0.14559087f, 0.05678861f, -0.01093974f, 0.11665593f, -0.05124364f, 0.13194600f, 
    0.11473864f, 0.10756817f, 0.15345836f, 0.05162831f, 0.28214610f, 0.20652604f, -0.12538780f, -0.25751078f, 
    0.02118813f, 0.14447716f, 0.06368528f, 0.12547988f, -0.06412823f, 0.19377391f, 0.01972293f, 0.17111129f, 
    0.13238735f, -0.07677986f, 0.00802220f, 0.04340383f, -0.12597105f, -0.04599576f, 0.09127896f, -0.13648404f, 
    -0.04861201f, -0.49845919f, -0.51807433f, -0.06306951f, 0.13839240f, 0.28720632f, -0.08195490f, 0.16702215f, 
    -0.01947854f, 0.01631112f, 0.04771429f, -0.05910625f, 0.00382424f, 0.03940989f, 0.16328917f, -0.08332179f, 
    -0.01614597f, 0.21649979f, 0.54823041f, 0.28284100f, 0.09760431f, 0.29018372f, -0.01792776f, -0.10282055f, 
    0.08045792f, 0.03518400f, 0.01093732f, -0.10700519f, -0.33888343f, -0.21663052f, 0.13984987f, 0.13042411f, 
    0.07569525f, 0.13249092f, -0.10811595f, -0.05587256f, -0.17551683f, -0.09564023f, -0.38840088f, -0.07276142f, 
    0.12628791f, -0.07229112f, -0.01954007f, -0.17874396f, 0.03028855f, -0.14023623f, -0.11662178f, -0.18999545f, 
    0.01250208f, 0.08186774f, -0.00348459f, -0.07944585f, -0.06700561f, -0.21823645f, 0.34473991f, 0.31545842f, 
    0.21361442f, 0.01177951f, 0.05962211f, 0.00035056f, -0.01587798f, 0.09672957f, -0.08063352f, -0.09027208f, 
    0.00762484f, 0.12888883f, 0.03636876f, -0.04175670f, 0.04878474f, -0.23606883f, 0.01688277f, -0.07173689f, 
    -0.36364141f, -0.27155340f, 0.16831890f, -0.13061044f, -0.13647453f, -0.22938523f, 0.11780374f, 0.15497032f, 
    -0.06082888f, -0.22141665f, -0.16621988f, -0.19982891f, -0.03866274f, -0.06177368f, -0.08525385f, 0.09255477f, 
    -0.15285245f, 0.01254598f, -0.27668756f, -0.22074118f, -0.08594575f, -0.01909526f, -0.23085314f, 0.12094986f, 
    -0.04208874f, 0.38769516f, -0.07820687f, -0.08973903f, -0.10073098f, -0.18169145f, -0.11080219f, 0.06465917f, 
    0.16090880f, -0.26486272f, 0.22475970f, 0.03693827f, -0.32805592f, -0.09913986f, -0.03402188f, -0.04415160f, 
    -0.07317100f, -0.21585155f, 0.07023247f, 0.04994912f, 0.01935169f, -0.11139341f, -0.02204378f, -0.02257844f, 
    -0.13585332f, 0.16416097f, -0.00171972f, 0.06770673f, 0.11478625f, 0.17469777f, -0.34062752f, -0.05788867f, 
    -0.28300977f, -0.10536472f, 0.09103479f, 0.16035409f, 0.03280506f, -0.03817108f, 0.05484571f, 0.05594606f, 
    -0.09679113f, -0.04983232f, 0.02278395f, 0.00082225f, -0.01944374f, -0.08796025f, 0.02926093f, 0.11091588f, 
    -0.22523025f, 0.15948434f, 0.24129024f, 0.14550151f, 0.03155105f, 0.16393244f, -0.21092856f, 0.07151148f, 
    0.11210942f, 0.07277639f, -0.06926098f, -0.05488478f, 0.00165175f, -0.13572924f, -0.03795137f, 0.09287008f, 
    0.05186629f, -0.19126840f, 0.13354363f, -0.11183012f, -0.24989377f, -0.03779465f, -0.05657931f, 0.05018388f, 
    -0.02078162f, 0.17209399f, -0.02680927f, -0.23183474f, 0.09636541f, 0.23242517f, 0.08036419f, 0.07692397f, 
    0.04144327f, -0.30108482f, -0.04791255f, -0.10619228f, -0.01378594f, 0.04324219f, -0.16579318f, 0.15562479f, 
    0.00784923f, 0.07418083f, 0.14416148f, 0.09428549f, 0.20194840f, -0.02405921f, -0.04992711f, 0.00756546f, 
    0.02670402f, -0.06017674f, 0.02583680f, 0.16553850f, -0.00360364f, -0.29038307f, -0.15005587f, 0.06191173f, 
    0.08413506f, 0.09315862f, 0.04711632f, -0.11184839f, 0.05859085f, 0.20088013f, -0.03922816f, -0.34313762f, 
    -0.13102497f, -0.23860271f, -0.29059410f, -0.15113895f, -0.15522748f, 0.16501223f, 0.11668676f, 0.23850995f, 
    -0.01632727f, 0.12630199f, 0.46782526f, 0.08380114f, -0.05353535f, 0.19233255f, -0.13569643f, -0.08533268f, 
    0.23006517f, -0.24074449f, -0.24343482f, -0.04989329f, -0.07201447f, -0.00100992f, 0.04404884f, 0.11008935f, 
    0.01363444f, 0.12579903f, 0.07565612f, -0.32209891f, 0.03121746f, 0.23306526f, 0.05496195f, 0.10205378f, 
    -0.04840562f, 0.00589154f, 0.05895953f, -0.11339829f, -0.12688693f, -0.12703730f, -0.04787282f, -0.00693325f, 
    -0.12329485f, 0.19034764f, 0.24540792f, 0.15854292f, -0.34866413f, -0.12221434f, 0.05677616f, -0.02676085f, 
    0.00969925f, -0.00174030f, -0.08586790f, 0.15239471f, -0.09545028f, 0.01313431f, -0.04323674f, -0.04931858f, 
    0.09895658f, -0.04782064f, -0.01244150f, 0.17297591f, 0.19533207f, -0.01121405f, 0.08376983f, -0.15832220f, 
    -0.05963096f, 0.18075517f, 0.03699410f, 0.05300840f, -0.04015562f, -0.11097361f, -0.09654891f, 0.00299684f, 
    0.02876575f, -0.02223882f, 0.06166463f, 0.05831955f, 0.09929656f, 0.07387085f, 0.08782071f, 0.00584837f, 
    0.17766432f, 0.02386549f, 0.11542694f, 0.27706200f, 0.03426525f, 0.18691491f, -0.11467479f, 0.09811731f, 
    -0.03093961f, 0.25705284f, -0.10557421f, 0.04535592f, 0.15161367f, 0.15940593f, 0.02220351f, 0.13788758f, 
    -0.11644129f, 0.06816643f, -0.17963675f, 0.12395638f, -0.15017885f, -0.08593960f, 0.02772996f, -0.14535552f, 
    -0.01908120f, 0.09260429f, 0.04162357f, 0.13597554f, 0.10321938f, 0.06641436f, 0.05961935f, -0.08281404f, 
    0.10153332f, 0.02337375f, 0.07983965f, 0.18780357f, 0.00394443f, 0.26009044f, -0.04488194f, -0.04944669f, 
    0.00888502f, -0.20171043f, -0.00841079f, 0.07473230f, 0.07512579f, -0.02232977f, -0.06383677f, -0.12457918f, 
    0.13134064f, 0.04790314f, -0.09692974f, 0.11774079f, 0.16588140f, 0.03119460f, 0.06825041f, 0.01499015f, 
    -0.13716166f, -0.02931153f, -0.00593047f, 0.00972884f, -0.00233615f, -0.01334337f, 0.02187782f, -0.04194798f, 
    -0.18219252f, -0.26042113f, 0.06602679f, 0.08424832f, -0.00274116f, 0.13223898f, 0.16342947f, -0.14762273f, 
    -0.67343915f, -0.22862819f, -0.12494679f, 0.09448621f, 0.12161925f, 0.08414026f, -0.26487872f, 0.09341910f, 
    0.07357297f, -0.18119292f, -0.11215507f, 0.19660099f, -0.19766814f, 0.05549606f, -0.05622228f, -0.11138467f, 
    -0.18422867f, 0.11234798f, -0.02189960f, -0.08291487f, -0.22935227f, 0.05195761f, -0.20929322f, -0.20311578f, 
    0.19112612f, 0.17043370f, 0.03054117f, 0.06480670f, 0.00608917f, -0.09439017f, 0.10184251f, -0.07414295f, 
    0.09834444f, 0.15259507f, 0.08928653f, 0.03354300f, -0.44491741f, -0.16520809f, -0.15048772f, -0.09052001f, 
    0.02155431f, -0.01296041f, 0.04047228f, 0.12552279f, -0.02078564f, 0.00385509f, 0.13837692f, -0.13638692f, 
    0.08208584f, 0.19981368f, -0.05176600f, 0.10794014f, 0.21650440f, 0.14026839f, -0.13154104f, 0.28146496f, 
    0.02991803f, -0.04845453f, 0.10466044f, 0.10915481f, -0.03776750f, -0.01862751f, -0.11200844f, -0.01663994f, 
    -0.15075473f, -0.22849505f, 0.18467987f, -0.14864700f, 0.34058577f, 0.05919204f, -0.10626860f, 0.09296156f, 
    -0.01012863f, -0.01474035f, -0.05725181f, -0.05295793f, -0.02404120f, -0.06152424f, 0.03354362f, -0.02826994f, 
    -0.00679214f, -0.04614476f, -0.01042465f, 0.00279977f, -0.00784494f, 0.00038997f, 0.04349676f, -0.04657836f, 
    -0.05897122f, 0.00630665f, -0.03099202f, -0.01604078f, 0.01763248f, -0.04110898f, 0.00617080f, 0.02488831f, 
    -0.00473779f, 0.04252492f, 0.03435431f, -0.05464849f, -0.04094870f, 0.00268264f, 0.03225087f, -0.03730302f, 
    0.03474751f, -0.04184699f, -0.01423108f, -0.06614619f, -0.05377921f, 0.00275667f, 0.00598644f, 0.00261439f, 
    0.00459189f, -0.04894863f, 0.02555118f, -0.02454995f, 0.04189899f, -0.05694832f, -0.03164069f, -0.04803739f, 
    0.01202714f, 0.02390563f, 0.04221066f, 0.02770881f, -0.02975432f, 0.01535938f, 0.03961418f, -0.00633486f, 
    -0.03792235f, 0.01607718f, -0.04087719f, 0.02147640f, -0.01953205f, 0.00504302f, -0.05452684f, -0.04483030f, 
    0.00162045f, -0.05412806f, -0.02680042f, -0.05214993f, 0.00799614f, 0.03053451f, 0.00597056f, -0.06481834f, 
    0.01120355f, 0.00189073f, -0.01719832f, 0.02465620f, -0.02100233f, -0.03332644f, -0.01154512f, -0.02192220f, 
    -0.01246931f, -0.01853229f, 0.03444556f, -0.06410562f, 0.00110085f, 0.02789474f, -0.04930579f, -0.06067036f, 
    -0.05659384f, 0.00397769f, -0.06044999f, 0.04165189f, 0.03691163f, 0.02736724f, 0.02595067f, -0.01043082f, 
    0.00067650f, 0.02797385f, -0.03812591f, 0.00971758f, -0.01872996f, -0.04519532f, 0.01957749f, 0.00474505f, 
    -0.01494937f, -0.04978670f, 0.04208058f, -0.03637710f, 0.04561464f, 0.00737501f, -0.04850361f, -0.02283412f, 
    -0.03439499f, 0.00717958f, -0.04974367f, -0.02665346f, 0.02952170f, -0.01157533f, -0.05358192f, -0.00203997f, 
    -0.02282813f, 0.01966344f, -0.02077534f, 0.03891101f, -0.02868075f, -0.01283944f, -0.04395378f, -0.02194426f, 
    -0.02716793f, 0.00340035f, -0.05176785f, 0.02816671f, -0.03019376f, 0.03136721f, 0.04556377f, -0.04649748f, 
    0.02990246f, 0.03194009f, 0.00343894f, 0.04635301f, 0.04779790f, -0.00804708f, 0.04651315f, 0.04407409f, 
    0.05495027f, 0.01290261f, -0.06239597f, 0.04644272f, -0.00324895f, -0.04829280f, 0.03162766f, -0.02610583f, 
    0.00380132f, -0.04043416f, -0.01644262f, -0.02925680f, 0.01773416f, 0.02125731f, -0.01350846f, -0.06426729f, 
    -0.03151181f, 0.03938077f, 0.04680132f, -0.03235510f, -0.05840351f, 0.01232322f, 0.02878563f, 0.04779962f, 
    0.00508363f, -0.04385643f, 0.00246313f, -0.00663618f, 0.00219211f, -0.03454664f, -0.03397365f, -0.03190077f, 
    -0.01727916f, 0.01130068f, -0.06270634f, -0.00010138f, -0.06352611f, 0.03452493f, -0.06655868f, 0.00678107f, 
    -0.04174364f, -0.01174204f, -0.02218088f, -0.04666577f, 0.03616761f, 0.03386139f, -0.03841496f, -0.00351013f, 
    -0.03426790f, -0.03842364f, 0.00527698f, 0.01205418f, -0.00545195f, 0.00041717f, 0.01629453f, -0.04852697f, 
    -0.04202775f, -0.00166174f, -0.02502532f, -0.02417826f, -0.02571448f, -0.02000898f, -0.00813943f, -0.03936659f, 
    -0.02387972f, -0.01112999f, -0.00899390f, -0.03430798f, -0.00088049f, -0.03628409f, 0.04464455f, -0.05828597f, 
    -0.00266023f, -0.01638767f, 0.04674730f, 0.00667579f, -0.06009055f, -0.05172670f, 0.00023138f, 0.04605357f, 
    0.02742587f, 0.02006785f, -0.02397697f, -0.01291700f, 0.01407476f, -0.05387325f, -0.02035361f, 0.00152048f, 
    -0.00674396f, -0.01475247f, 0.01690004f, -0.02740829f, -0.00231844f, 0.01408937f, 0.02808783f, -0.04989046f, 
    -0.04605951f, -0.04296503f, -0.00334913f, -0.06087311f, -0.00099681f, 0.01672510f, 0.00501799f, -0.06362095f, 
    0.04872170f, 0.03940513f, 0.04034849f, 0.01968558f, -0.06361581f, 0.01747691f, -0.02381977f, 0.02453248f, 
    -0.02349683f, -0.00025441f, 0.00876335f, 0.03181792f, 0.00907616f, 0.03215613f, 0.01656510f, -0.02281291f, 
    0.00876005f, -0.05512835f, -0.00947701f, 0.01068878f, 0.02718409f, 0.03646226f, 0.03638965f, 0.00977148f, 
    -0.05795107f, -0.04468934f, 0.02933229f, 0.00961430f, -0.04110315f, 0.00032986f, -0.05945620f, -0.05505127f, 
    0.01155730f, 0.03331763f, -0.02419884f, -0.05121741f, -0.05577163f, 0.03083092f, -0.01907977f, 0.00465545f, 
    -0.18714856f, -0.20838417f, -0.42366442f, -0.13445035f, 0.04247858f, -0.00655575f, 0.04018599f, 0.06753854f, 
    0.07642646f, 0.08946614f, 0.06579122f, 0.03589888f, 0.03399707f, 0.08404282f, -0.22878689f, 0.11594947f, 
    0.09345925f, 0.04446559f, -0.14398712f, 0.07238366f, -0.18215773f, -0.18143037f, -0.06627511f, -0.12806498f, 
    0.01203241f, 0.10001580f, -0.08839440f, -0.19115384f, -0.03072051f, 0.04919168f, -0.17463356f, 0.07736233f, 
    0.26527470f, 0.06535099f, 0.10153189f, 0.17210169f, -0.28411505f, -0.03091151f, 0.45448962f, 0.03925737f, 
    0.02610745f, -0.09924140f, 0.05085772f, 0.10570595f, 0.06607322f, -0.09644850f, 0.05152352f, 0.07112817f, 
    0.02393912f, -0.03015101f, -0.11995449f, 0.13654740f, -0.06824043f, 0.10039623f, -0.77439100f, -0.41075811f, 
    -0.21648952f, -0.05037122f, 0.21984342f, 0.04556993f, 0.03959325f, 0.06306759f, -0.08183085f, 0.25737676f, 
    0.43345335f, 0.06480949f, 0.11750958f, 0.03971461f, -0.06528377f, -0.08079644f, -0.03890512f, -0.06086197f, 
    -0.32480481f, -0.24780695f, -0.81188047f, -0.07219224f, 0.01187612f, -0.10321357f, -0.07811943f, 0.01853278f, 
    -0.06746998f, 0.11107596f, 0.26055786f, 0.24289617f, -0.12042189f, -0.18347779f, -0.15558174f, -0.04976260f, 
    0.06446721f, 0.05336590f, 0.01921976f, 0.01404842f, 0.12233351f, -0.12121337f, 0.05956474f, 0.01297589f, 
    -0.10633855f, -0.08650735f, 0.00026727f, -0.10488316f, -0.01404191f, 0.14618526f, 0.19263907f, -0.01939905f, 
    -0.01672829f, 0.03346338f, -0.21302845f, 0.10440717f, -0.08215016f, -0.04305138f, 0.19153085f, -0.03084921f, 
    -0.19794275f, -0.15996000f, -0.02844172f, 0.08330347f, 0.13716894f, 0.28039533f, -0.05439129f, -0.07640603f, 
    -0.10722581f, -0.02262368f, -0.01797565f, 0.10514247f, 0.03224622f, -0.01388439f, 0.18165536f, 0.22767803f, 
    0.07423309f, -0.14471520f, -0.19766343f, -0.07728771f, -0.05111116f, 0.05057913f, -0.02737017f, 0.11295697f, 
    -0.08842931f, -0.13877203f, -0.05395637f, -0.05309597f, -0.18262313f, 0.11157391f, 0.09291606f, 0.02859818f, 
    0.18343820f, 0.38212717f, -0.74387014f, -0.30080208f, 0.22662622f, 0.14269154f, 0.18742575f, 0.03811257f, 
    -0.31019998f, 0.01348029f, 0.21530178f, -0.12149961f, -0.21202213f, 0.17065468f, -0.13408925f, 0.15524195f, 
    0.04378532f, -0.06453198f, -0.17656273f, -0.44863248f, 0.10637172f, 0.03521153f, 0.10061651f, -0.06613734f, 
    0.06226737f, -0.22422203f, 0.01393717f, 0.12691094f, 0.03548510f, -0.02764146f, 0.12070289f, -0.01963806f, 
    -0.05948930f, 0.15269428f, 0.01174572f, 0.00355203f, 0.18125825f, 0.03764986f, -0.17904399f, -0.05469143f, 
    0.11564890f, 0.11589816f, 0.03003152f, 0.01114417f, -0.03298239f, 0.21090861f, 0.02430018f, -0.03708680f, 
    -0.26290867f, -0.24509297f, -0.07641154f, 0.14483762f, -0.05267878f, -0.07910904f, -0.04441047f, -0.19562477f, 
    0.06211314f, 0.12030751f, 0.09939435f, -0.09939902f, -0.02750892f, 0.05418189f, -0.01677396f, 0.22858106f, 
    0.08963542f, -0.04412378f, -0.10453878f, -0.07056268f, -0.10323750f, 0.00757452f, -0.12346601f, -0.03697728f, 
    0.02723891f, 0.00477905f, 0.27882090f, -0.02948156f, -0.09126077f, -0.25416800f, -0.17284365f, 0.17549790f, 
    0.14999120f, 0.18126802f, -0.05502465f, -0.50566936f, -0.03162444f, -0.08720776f, -0.11210307f, -0.00141221f, 
    -0.00500445f, 0.05993884f, 0.24263318f, -0.07635412f, -0.11375414f, 0.00137573f, 0.09118728f, 0.03506713f, 
    0.18496595f, 0.08500775f, 0.13746160f, 0.19968663f, 0.12525612f, -0.26958445f, -0.26496258f, -0.10712791f, 
    -0.13451713f, 0.20978639f, 0.19031437f, -0.01414909f, 0.20014702f, 0.71334988f, 0.40801707f, -0.09777809f, 
    -0.15791087f, -0.32102546f, -0.05782452f, -0.02618070f, 0.06253735f, 0.11389393f, 0.14241225f, -0.06420073f, 
    -0.01962017f, -0.31457475f, 0.06272186f, 0.13670011f, 0.14784731f, 0.17071612f, 0.20556027f, 0.46650535f, 
    0.38893518f, -0.06902546f, -0.16175817f, -0.06061644f, -0.00594610f, 0.07046928f, -0.08322415f, 0.04910974f, 
    -0.05599726f, -0.06944974f, -0.14595330f, 0.08526527f, -0.21327575f, 0.13838799f, -0.12360194f, 0.04504079f, 
    0.04170731f, -0.04038760f, -0.04636336f, -0.02958014f, 0.02943314f, 0.00455135f, 0.04065756f, 0.04850670f, 
    -0.04592828f, -0.04101634f, 0.02482902f, 0.02945999f, -0.03211436f, -0.00669414f, -0.00867273f, -0.00425710f, 
    -0.05521418f, 0.04714715f, -0.00016475f, 0.03428662f, 0.03870660f, -0.04620575f, 0.03256854f, 0.00307121f, 
    0.03997428f, 0.00204099f, -0.03524397f, -0.05257957f, -0.03930642f, 0.04617105f, -0.00563051f, -0.05832076f, 
    -0.01548282f, -0.01297536f, 0.03768118f, 0.00840200f, 0.03802793f, -0.02053873f, -0.00952181f, -0.04100284f, 
    -0.06015669f, 0.02546296f, -0.06747169f, -0.03857861f, -0.02208575f, 0.04445869f, -0.06076463f, 0.02850264f, 
    0.00216120f, 0.01465630f, -0.06154178f, 0.02581659f, 0.00780238f, 0.01455463f, 0.02959331f, -0.00067697f, 
    -0.06149784f, 0.03203355f, 0.01955944f, -0.03822725f, -0.02244246f, 0.01934027f, 0.03302938f, 0.01026085f, 
    0.01009910f, 0.04750310f, 0.04928148f, 0.01473103f, 0.01823778f, -0.05693658f, -0.00475016f, 0.03507139f, 
    -0.06041416f, -0.02864551f, -0.00593311f, 0.01773299f, 0.01323743f, -0.04403232f, 0.01836023f, -0.03243854f, 
    -0.03291490f, 0.02922508f, 0.05651046f, -0.04575054f, -0.00545926f, -0.00616809f, 0.00843435f, -0.03243619f, 
    0.02782483f, -0.01858963f, -0.03173406f, -0.05317677f, -0.06157880f, -0.06756052f, -0.01624981f, -0.04670814f, 
    0.00926616f, -0.04545423f, 0.04205287f, 0.02769293f, -0.04499061f, 0.02928189f, 0.00509915f, 0.05075479f, 
    -0.06706195f, -0.04159956f, 0.03613638f, -0.00653498f, 0.01529849f, 0.05545956f, 0.00877284f, -0.03642565f, 
    -0.05445965f, -0.04375345f, 0.03427019f, 0.01011970f, 0.04788194f, -0.02781520f, 0.04050582f, 0.00225404f, 
    -0.00837812f, -0.02600681f, -0.05913511f, -0.05096231f, 0.01960802f, -0.03903653f, 0.02101406f, 0.01716756f, 
    0.00100031f, 0.01861867f, 0.03387301f, -0.03500696f, -0.04420907f, -0.01491518f, 0.04593020f, -0.00772180f, 
    0.04216075f, 0.04051422f, 0.03154989f, 0.01918783f, -0.01555671f, -0.05869584f, -0.01534953f, -0.02932741f, 
    -0.03813864f, -0.02271396f, -0.01985609f, 0.01759377f, -0.04491994f, -0.06014455f, 0.00188837f, 0.00699597f, 
    0.02766004f, -0.05625494f, 0.04070093f, -0.06263563f, -0.00785161f, -0.00866472f, -0.06233108f, 0.04365355f, 
    -0.03518699f, -0.03076934f, -0.03685100f, 0.01186440f, -0.01790248f, -0.00213428f, -0.02407154f, -0.01497233f, 
    0.00632341f, -0.03505279f, -0.05047477f, 0.00768529f, 0.02693178f, 0.01078442f, -0.01982840f, -0.03285703f, 
    0.01630030f, 0.00265390f, 0.01762830f, 0.02037722f, -0.02053203f, -0.01126732f, 0.01503715f, -0.04708914f, 
    0.00526219f, -0.04620348f, -0.01830943f, 0.03941301f, -0.05633700f, 0.04899995f, 0.03326089f, 0.03353915f, 
    -0.06004343f, -0.05445129f, -0.06469988f, -0.05289707f, 0.00855773f, -0.02482229f, 0.04571661f, -0.06614576f, 
    -0.01999489f, 0.02349345f, 0.00314245f, -0.05052605f, -0.01717841f, 0.01046529f, -0.01907172f, 0.00290576f, 
    0.00190556f, -0.05054547f, 0.03385398f, 0.00562165f, -0.01460496f, -0.02026357f, 0.00402813f, -0.00352035f, 
    0.04293465f, 0.00374133f, -0.01031393f, -0.01288436f, 0.04313483f, 0.01423424f, 0.03967796f, -0.06565142f, 
    -0.03705977f, -0.04717693f, 0.02345237f, -0.02823815f, 0.00377733f, 0.02662881f, -0.03646505f, 0.00081170f, 
    0.04880626f, -0.05134527f, -0.05889493f, -0.04710635f, -0.05541351f, 0.04659960f, -0.00289821f, 0.03992386f, 
    0.04839709f, -0.03528429f, 0.00805773f, 0.04096634f, -0.05881635f, -0.02343491f, 0.01352266f, 0.03179788f, 
    0.00680937f, -0.01529675f, -0.00791837f, 0.04116729f, -0.02682710f, 0.03546834f, -0.00680908f, 0.00689135f, 
    -0.04081772f, 0.00776477f, 0.00538210f, -0.02994016f, -0.03568503f, -0.00024448f, 0.00019459f, -0.04600486f, 
    -0.01410470f, 0.00327870f, -0.05026868f, -0.00172926f, 0.03652145f, 0.02291986f, -0.04099464f, 0.03583480f, 
    -0.01343324f, -0.03864536f, -0.03927423f, 0.01072616f, 0.00196375f, 0.00150851f, 0.04621379f, 0.02593693f, 
    -0.01034416f, 0.02694589f, -0.01852562f, -0.04728545f, -0.06133626f, 0.05210039f, 0.02924768f, -0.00695772f, 
    -0.06753425f, -0.48630351f, -0.02640757f, 0.05238783f, 0.02324133f, -0.14977254f, 0.06322820f, 0.11458994f, 
    0.14331895f, 0.01917989f, 0.11940631f, 0.12169453f, 0.08265159f, 0.03244656f, 0.06898174f, 0.07529911f, 
    0.20379552f, 0.00789763f, -0.35679680f, 0.09244977f, 0.03123259f, -0.21889278f, -0.37019235f, -0.20292349f, 
    0.12338521f, 0.00535357f, 0.15309981f, 0.12328961f, -0.02281998f, 0.14643794f, 0.08548097f, -0.07130951f, 
    0.00825270f, 0.05921197f, 0.07611581f, 0.26293990f, -0.47294563f, -0.10011799f, -0.21608284f, 0.09759951f, 
    -0.22223544f, -0.09599431f, -0.15709744f, -0.11225020f, 0.02754799f, -0.11375195f, -0.22599293f, 0.16034986f, 
    0.04846489f, 0.07571436f, 0.03912808f, 0.13888240f, 0.16578293f, 0.13169242f, -0.05574332f, -0.67852122f, 
    -0.43685219f, -0.04035778f, -0.09912582f, -0.02592078f, 0.08751462f, 0.01570229f, -0.05689967f, 0.23077144f, 
    -0.02000745f, -0.37685543f, 0.03520264f, -0.33123839f, 0.08727571f, -0.25841588f, -0.14318612f, -0.24303736f, 
    -0.22029182f, -0.44848219f, 0.09878334f, 0.06813575f, 0.12381732f, -0.15255791f, 0.01532053f, 0.05743925f, 
    0.11044125f, -0.12955070f, -0.09310126f, 0.00389795f, -0.17037569f, -0.14797358f, -0.21455467f, 0.03985644f, 
    0.01442498f, -0.04609754f, -0.62539196f, -0.02568052f, 0.46792650f, -0.05008875f, -0.05644598f, -0.00877828f, 
    0.08179867f, 0.26593468f, -0.03344328f, 0.35182032f, -0.09693193f, -0.08315499f, 0.15929271f, 0.08052774f, 
    -0.12219774f, 0.05683148f, -0.14068130f, 0.02179197f, -0.15855013f, -0.13356042f, -0.40676227f, 0.13449278f, 
    0.13556598f, -0.24497719f, -0.00998355f, 0.07787407f, 0.10747751f, 0.08414260f, 0.14509006f, 0.02956421f, 
    0.09146937f, -0.10111962f, -0.05963117f, -0.11764466f, 0.00231968f, -0.21172199f, -0.01730730f, 0.27972636f, 
    0.21321355f, 0.03341996f, 0.20032330f, -0.19829251f, -0.16543972f, 0.14897971f, 0.23788010f, 0.06945745f, 
    0.21956955f, 0.13040242f, 0.13341153f, 0.18672165f, 0.17741545f, -0.03555311f, 0.12354700f, -0.40426794f, 
    0.01846399f, -0.17190564f, 0.52120835f, -0.03915822f, 0.05696157f, 0.28268012f, -0.04848200f, 0.07716288f, 
    0.13777843f, 0.10057416f, 0.07818608f, 0.43151718f, 0.06104127f, 0.02965629f, 0.18349484f, 0.05701908f, 
    0.08615445f, 0.14443277f, 0.37464970f, -0.19677323f, -0.01395996f, 0.20020242f, 0.15848346f, 0.08078139f, 
    0.15519653f, -0.06485844f, -0.12632938f, 0.01804280f, 0.16915123f, 0.16677232f, 0.06099550f, -0.12053490f, 
    -0.08497805f, 0.10897082f, 0.11022452f, -0.02746393f, 0.03782322f, 0.35706788f, -0.00139771f, -0.13580741f, 
    -0.29925787f, -0.12393418f, -0.22492830f, -0.17198987f, -0.16066362f, -0.26708686f, 0.12838155f, 0.05390619f, 
    0.04653895f, -0.03100757f, -0.05190353f, 0.13993466f, -0.03587612f, -0.04502531f, 0.20398146f, 0.08466022f, 
    -0.04462058f, 0.08223066f, 0.08622102f, 0.11989584f, 0.13757296f, 0.11819795f, -0.11083446f, 0.02291375f, 
    0.25056753f, 0.14663041f, 0.08916587f, 0.08053377f, -0.12725791f, 0.04796381f, 0.16515391f, 0.07927346f, 
    -0.82899153f, 0.10109337f, -0.16919535f, -0.12963550f, 0.23683535f, -0.04251188f, -0.11207780f, 0.03886348f, 
    0.07174756f, 0.18388869f, -0.11972728f, -0.27003330f, -0.14859352f, 0.01000073f, -0.14524402f, -0.01416999f, 
    0.05130290f, 0.16452286f, -0.30730549f, 0.00401660f, 0.02308763f, 0.12936032f, 0.11793223f, -0.15915860f, 
    0.02081911f, -0.25136545f, -0.20755219f, 0.34627143f, 0.15567878f, -0.00531839f, 0.19491933f, 0.13859302f, 
    0.08753852f, -0.03101921f, 0.03685570f, -0.23118275f, -0.14938186f, -0.05471466f, -0.00199981f, 0.26330295f, 
    0.29251093f, -0.17591117f, 0.04451185f, 0.05022987f, 0.20058094f, 0.06894185f, 0.10702696f, 0.17288576f, 
    0.09418628f, -0.00216620f, 0.10355166f, -0.18773982f, -0.05053285f, -0.17161360f, -0.04593338f, 0.31932446f, 
    0.35698819f, 0.15468739f, -0.15906291f, -0.19015148f, -0.08210305f, 0.04393514f, 0.14364356f, 0.14025062f, 
    0.23335616f, 0.01224899f, 0.00020605f, 0.01097536f, -0.04806339f, -0.00029192f, 0.06590929f, -0.21492286f, 
    -0.16614664f, 0.21489994f, 0.01104024f, 0.05555974f, 0.01017160f, 0.07827961f, 0.19045144f, 0.14984560f, 
    -0.10048507f, 0.03789255f, -0.20455946f, 0.03577263f, -0.15521291f, 0.07162659f, -0.06391849f, -0.00145028f, 
    -0.06310768f, -0.03091509f, 0.05395998f, 0.24665745f, 0.42723089f, -0.21411726f, 0.05660307f, -0.06149482f, 
    -0.13317640f, 0.16264355f, 0.01185467f, -0.25650990f, -0.15304768f, 0.06137379f, 0.00105266f, 0.01135374f, 
    -0.05872152f, 0.23377401f, 0.04684700f, -0.16174680f, 0.05442883f, 0.11673068f, 0.31639072f, -0.05836378f, 
    -0.02843390f, -0.01537072f, 0.01890008f, 0.04587037f, 0.03835477f, -0.15490539f, -0.74683225f, -0.30482870f, 
    -0.01064154f, -0.20316383f, -0.04068343f, -0.01379950f, -0.02500733f, -0.03728491f, 0.50511444f, 0.02546602f, 
    -0.25497699f, 0.13135619f, 0.19292851f, -0.10318567f, 0.04491920f, -0.05722521f, -0.01702891f, 0.31068444f, 
    -0.07360245f, -0.09420893f, 0.14497800f, 0.20900795f, -0.26823488f, 0.12224153f, -0.29347846f, 0.19872499f, 
    -0.30079037f, -0.02590791f, 0.04710736f, 0.09001467f, -0.04061116f, 0.17829935f, 0.15857463f, 0.11872000f, 
    -0.10964734f, 0.03069918f, 0.32447913f, 0.36096561f, -0.18314001f, 0.02948439f, -0.20280951f, 0.01265700f, 
    0.01062354f, -0.00138211f, -0.89746463f, -0.48684749f, 0.18762264f, 0.07326446f, -0.03684866f, 0.13250443f, 
    0.13811955f, 0.12853187f, -0.00268938f, 0.04599501f, -0.33700496f, -0.17085610f, 0.09484326f, -0.01446947f, 
    -0.04616109f, 0.12707016f, -0.05252618f, 0.20145287f, -0.07300553f, 0.08214466f, 0.26193285f, -0.02065104f, 
    -0.03962853f, -0.06667375f, 0.05133214f, 0.14994587f, -0.03629279f, 0.09314953f, 0.06558897f, 0.10389567f, 
    0.16999723f, 0.06928601f, 0.02516030f, 0.14880078f, -0.01244146f, 0.13013633f, -0.15223815f, -0.15877776f, 
    0.06415898f, -0.33839130f, -0.30453017f, 0.07502583f, 0.01587230f, -0.13924219f, -0.01896908f, -0.11342418f, 
    -0.07618733f, -0.16428530f, 0.00430441f, -0.05969955f, -0.04730994f, 0.24624538f, 0.00374839f, 0.02313835f, 
    0.48079911f, -0.10372811f, -0.26805967f, 0.01978102f, -0.10170551f, -0.13009030f, 0.06245913f, -0.16913994f, 
    -0.03276150f, 0.17294224f, -0.14865607f, 0.18895315f, -0.17978695f, -0.11892796f, -0.02462798f, 0.24309640f, 
    -0.17765389f, -0.08649482f, 0.16999544f, -0.67479473f, -0.68987972f, 0.02266824f, 0.09041622f, -0.08185085f, 
    -0.04811182f, -0.04310989f, 0.25402471f, -0.20782772f, -0.18628246f, -0.01487503f, -0.14250392f, -0.03849887f, 
    0.01866101f, 0.07515283f, 0.09486824f, 0.26229632f, -0.00858938f, -0.29453841f, -0.17455882f, -0.20714344f, 
    0.08747014f, -0.05976768f, 0.06325594f, 0.05371227f, -0.02375960f, 0.04565448f, 0.06517819f, 0.01777414f, 
    -0.17092545f, -0.03443765f, -0.14903337f, 0.02471184f, 0.14287147f, 0.15768170f, -0.03974384f, -0.28668413f, 
    0.04341320f, -0.10003588f, 0.04974550f, -0.01363154f, -0.08303253f, 0.03762384f, 0.14645407f, 0.00386918f, 
    0.07537525f, 0.12251750f, -0.14802016f, -0.08683598f, -0.14616050f, 0.21221815f, 0.03019998f, -0.00102566f, 
    -0.43603149f, 0.01933034f, 0.23450665f, 0.02522310f, 0.03228150f, -0.02811979f, 0.13422787f, 0.07488830f, 
    0.05732652f, -0.12849452f, -0.08272774f, 0.26823065f, -0.17617348f, 0.03232311f, 0.03450597f, 0.11812735f, 
    -0.00943291f, 0.07973405f, 0.09106276f, 0.01917252f, -0.22278939f, -0.01465472f, 0.16252379f, 0.30673641f, 
    -0.00356182f, 0.38505059f, 0.00241776f, -0.20945784f, 0.00135097f, 0.07085403f, -0.13476059f, 0.05267631f, 
    0.24674153f, -0.04446520f, -0.00969852f, 0.17237610f, 0.01963847f, 0.13560419f, 0.16247971f, -0.08128957f, 
    -0.04598093f, -0.03443345f, -0.02412067f, 0.00959542f, -0.03057127f, -0.03706239f, -0.04979759f, -0.04468286f, 
    -0.14646646f, -0.10560676f, 0.10993139f, 0.06920284f, 0.13410179f, 0.10608722f, 0.16565645f, -0.23403718f, 
    0.08678226f, -0.24368420f, -0.01159849f, 0.08922510f, -0.01836564f, -0.02185060f, -0.04505888f, 0.15170981f, 
    -0.10789058f, 0.07654709f, 0.07303786f, -0.04280557f, -0.39436552f, -0.01993717f, 0.08442649f, 0.08768125f, 
    -0.04331460f, 0.07999746f, 0.02692912f, 0.02744025f, -0.13409598f, 0.06768874f, 0.04723932f, 0.15292312f, 
    -0.24676184f, -0.09958228f, -0.00480683f, -0.06966028f, 0.02828781f, 0.05235756f, -0.07352233f, 0.03434277f, 
    0.24185781f, 0.01430016f, 0.26224446f, 0.10451538f, 0.25899163f, 0.16196951f, 0.06923378f, 0.05861190f, 
    0.05330567f, -0.10763732f, 0.12131202f, -0.05841605f, 0.02606680f, 0.09485122f, -0.06113180f, -0.20287752f, 
    0.15164144f, -0.20070378f, 0.01159793f, -0.40599123f, 0.22466274f, 0.17953764f, 0.35997042f, 0.05649860f, 
    0.00581195f, 0.00882598f, -0.02175772f, 0.16538666f, -0.02547511f, -0.05272220f, 0.13847347f, -0.03205863f, 
    0.03957680f, 0.13059489f, -0.04876874f, 0.00489608f, -0.38958564f, 0.14265899f, 0.03546549f, -0.07797328f, 
    0.68541557f, 0.08358660f, 0.02570921f, 0.10096896f, 0.04010354f, -0.28036743f, -0.12126222f, -0.06306167f, 
    0.00623190f, 0.25068042f, -0.29380572f, 0.24463588f, 0.06867938f, 0.14925255f, -0.30344415f, 0.13932711f, 
    -0.01682355f, 0.34154695f, -0.07080572f, -0.00501413f, -0.26040405f, 0.00681559f, -0.08627327f, 0.17604566f, 
    -0.20700322f, 0.04199126f, 0.10184441f, 0.36613712f, 0.13619418f, -0.02871025f, -0.17404483f, 0.00664474f, 
    -0.17123318f, -0.07951149f, 0.53950441f, 0.04811378f, -0.43515939f, 0.13536403f, -0.15126115f, -0.15034018f, 
    -0.16253224f, 0.06546250f, -0.13045844f, -0.42128924f, 0.02823833f, -0.27492249f, 0.23409122f, 0.06403252f, 
    -0.14112191f, -0.08364762f, 0.05558299f, -0.11743902f, 0.02851255f, 0.06906249f, 0.48192769f, 0.08362600f, 
    -0.07373999f, -0.06754489f, 0.13064851f, 0.00519460f, 0.02791520f, 0.28905660f, 0.15305337f, 0.16323143f, 
    -0.03742290f, 0.00384463f, 0.05272966f, 0.19311759f, 0.13598119f, 0.14763391f, -0.03233771f, -0.07685262f, 
    -0.08263590f, -0.00020695f, -0.04417888f, -0.18885753f, -0.07475700f, 0.15023682f, -0.19354039f, -0.05589636f, 
    -0.11418251f, -0.05200927f, 0.01304669f, -0.11595677f, -0.08910950f, 0.16483752f, 0.06651052f, 0.23331916f, 
    -0.23566547f, 0.00922396f, 0.74301529f, 0.06728742f, 0.08077386f, 0.03928776f, 0.00030542f, -0.08415047f, 
    0.08976454f, -0.00771684f, 0.19503123f, -0.33081293f, -0.15157264f, -0.13161129f, 0.04105347f, 0.08461863f, 
    0.19950129f, -0.51540738f, -0.48856294f, 0.16239838f, 0.29718545f, 0.06136508f, 0.04245220f, -0.07071245f, 
    0.11271056f, 0.18219192f, 0.06031538f, 0.02230319f, -0.02802315f, 0.13463318f, 0.00843217f, -0.15665855f, 
    -0.05875212f, -0.11261468f, 0.05280041f, 0.22297753f, -0.12535557f, -0.04741707f, 0.08535560f, 0.30084831f, 
    -0.02118777f, -0.12706895f, -0.02113520f, -0.05890395f, 0.23881891f, -0.05678434f, -0.04216178f, -0.05331030f, 
    -0.02802124f, -0.12463511f, -0.21903996f, 0.09404542f, -0.00513925f, 0.16460942f, -0.24760467f, -0.29850602f, 
    -0.00395589f, 0.00522213f, 0.01670904f, 0.08914585f, 0.00490015f, 0.20920707f, 0.08799689f, -0.11043157f, 
    -0.03380409f, -0.01389054f, 0.09613150f, 0.07874338f, -0.06826317f, -0.06957132f, -0.04927373f, 0.15797019f, 
    0.14705971f, -0.05801223f, 0.42219040f, 0.10694445f, 0.02671047f, -0.07466708f, 0.21651143f, 0.12867613f, 
    0.11141109f, -0.27503690f, -0.10349712f, 0.13120955f, 0.07005454f, -0.08186969f, -0.14126962f, 0.09758487f, 
    -0.03051222f, -0.10971242f, 0.21055317f, 0.53901553f, -0.07755474f, 0.16538623f, -0.03591648f, -0.15240976f, 
    0.07669646f, 0.32908332f, -0.01221140f, -0.13975695f, -0.05263999f, 0.04762970f, 0.05143579f, 0.10039045f, 
    -0.02615040f, 0.02304164f, 0.23587066f, 0.21317898f, -0.20001835f, -0.04373524f, 0.32397395f, 0.15969114f, 
    -0.07209596f, -0.02840866f, 0.09470981f, -0.06025817f, -0.08517669f, -0.01282382f, 0.02476108f, -0.16096954f, 
    0.15916385f, 0.03146594f, -0.04652597f, -0.02139507f, 0.04537998f, 0.21727179f, -0.34522825f, -0.16164224f, 
    0.13591263f, 0.26478750f, -0.02857304f, -0.02425088f, -0.11332242f, -0.00403649f, 0.12294330f, -0.08820839f, 
    -0.29128319f, 0.00026921f, -0.08624043f, -0.09286790f, 0.08510230f, -0.08832957f, 0.09142179f, -0.02326501f, 
    -0.04073834f, -0.04413398f, -0.05607953f, -0.03995112f, -0.05308738f, -0.02600320f, 0.02709671f, -0.04633464f, 
    0.02884913f, 0.01487884f, 0.02845031f, -0.00020275f, -0.04770828f, 0.01959258f, -0.02734688f, -0.06215766f, 
    -0.04780358f, -0.02482799f, 0.00472686f, -0.02181147f, -0.02254512f, 0.03403885f, 0.04180857f, 0.02382670f, 
    0.01911373f, 0.03229796f, 0.01546098f, -0.04880982f, 0.01069802f, -0.04228279f, 0.01026362f, -0.05263368f, 
    -0.02951300f, 0.01015787f, -0.02323739f, -0.00143474f, 0.04303079f, 0.00463604f, 0.01229406f, -0.03715936f, 
    0.04127951f, 0.01930751f, -0.00224145f, 0.04196186f, 0.04325017f, -0.00154678f, -0.03940754f, -0.00328133f, 
    0.02849844f, 0.05253412f, 0.02299130f, -0.02104585f, -0.05074481f, 0.04225021f, 0.03329780f, -0.04436638f, 
    -0.03490207f, 0.00490804f, -0.05299753f, 0.04948653f, 0.00891831f, 0.00198649f, -0.01356296f, 0.04679633f, 
    0.01301732f, 0.02264628f, -0.05092651f, -0.03045344f, 0.03504780f, -0.00991915f, -0.05372544f, -0.05995697f, 
    -0.03542526f, 0.02275387f, 0.04590472f, -0.05451757f, 0.02902757f, 0.04265644f, -0.04919489f, -0.03558286f, 
    -0.04043825f, -0.05239818f, -0.05142458f, 0.04022227f, 0.01072340f, -0.04438721f, -0.04305302f, -0.00040773f, 
    -0.05438972f, 0.04809728f, -0.04271577f, -0.01597318f, 0.02482187f, -0.05943520f, -0.03406526f, -0.05606543f, 
    -0.03529294f, -0.03246374f, 0.00410401f, 0.02337853f, 0.03695306f, -0.01136835f, -0.02556667f, -0.01265869f, 
    0.00443149f, -0.05150942f, -0.01775091f, -0.02139174f, 0.00019966f, -0.00557899f, 0.02538612f, -0.04377658f, 
    -0.06377745f, 0.00647395f, -0.03458597f, 0.00276609f, 0.02223249f, 0.00694371f, 0.02851868f, 0.01394034f, 
    -0.03261917f, 0.02763039f, 0.02860183f, 0.01955521f, -0.06304345f, -0.01000941f, -0.04728975f, 0.00507734f, 
    0.00561059f, -0.05265995f, 0.01113794f, -0.02263522f, 0.04074155f, -0.03746945f, -0.01911494f, -0.04456776f, 
    0.02391454f, -0.05518224f, 0.04504674f, 0.00953312f, -0.02735845f, 0.04112418f, 0.01853142f, 0.02208080f, 
    -0.03332051f, 0.00077909f, 0.00299327f, -0.06111106f, 0.03358806f, -0.06101859f, -0.05005514f, -0.01973481f, 
    -0.03044354f, 0.02878730f, -0.01368303f, 0.02912443f, -0.06130803f, -0.04411221f, 0.04713732f, -0.03767847f, 
    -0.01145130f, -0.02746301f, -0.06353926f, -0.04919490f, -0.02937442f, -0.02744275f, 0.00307964f, 0.05192045f, 
    -0.04171830f, -0.00863914f, 0.00312015f, -0.01278390f, -0.01270470f, -0.06038237f, -0.03230818f, -0.00075912f, 
    -0.00717461f, 0.01180166f, 0.00996701f, 0.00127061f, -0.03422600f, -0.02646032f, -0.01734477f, -0.06239412f, 
    -0.01840799f, -0.05222961f, -0.03624720f, 0.03878972f, -0.03506020f, -0.04790183f, 0.03034106f, 0.01335014f, 
    0.02812140f, -0.06269642f, -0.05221459f, 0.04474031f, 0.03588976f, -0.00235916f, -0.02988164f, 0.03672753f, 
    -0.05084002f, -0.04590559f, -0.00756650f, 0.03666163f, 0.02204392f, -0.04392055f, 0.00235895f, 0.00424280f, 
    0.01839954f, -0.03407665f, -0.03386249f, -0.01059231f, -0.04565164f, -0.04001186f, 0.00691038f, 0.03892542f, 
    0.02449781f, 0.00159802f, 0.03782275f, -0.04028984f, -0.01826432f, -0.00200099f, 0.04828881f, -0.04207772f, 
    -0.05874657f, -0.03202279f, 0.00857411f, 0.04753188f, -0.03924847f, -0.00362407f, -0.00215827f, -0.03496368f, 
    0.04876916f, 0.00883953f, -0.06064245f, 0.03845352f, 0.00714619f, 0.01259142f, -0.05936008f, -0.03419623f, 
    -0.03484821f, -0.00088280f, -0.01459058f, 0.04235468f, 0.03821318f, -0.05215951f, -0.03000726f, 0.01664698f, 
    0.03118585f, -0.02614021f, 0.05675668f, -0.01893320f, 0.00077423f, -0.00659645f, 0.04860838f, -0.04151649f, 
    -0.05632319f, 0.00439241f, -0.01625058f, -0.00583252f, 0.02103095f, 0.03866832f, -0.03540732f, -0.02393354f, 
    -0.04045452f, -0.04197612f, -0.04250742f, -0.04781526f, -0.03971176f, -0.03814549f, -0.03530158f, -0.00953708f, 
    -0.02626776f, 0.03985850f, 0.04103715f, 0.02098062f, -0.05281768f, 0.03846168f, 0.04287961f, 0.02968689f, 
    -0.01274394f, -0.02540466f, 0.00041162f, -0.04564043f, -0.01498985f, -0.00661248f, -0.04270139f, -0.04266989f, 
    0.03524431f, -0.07045146f, 0.03107873f, 0.04244683f, -0.02788103f, -0.02719486f, -0.00126567f, -0.00805934f, 
    -0.06468901f, 0.00527837f, -0.02516229f, -0.04401432f, -0.01636204f, 0.03624463f, 0.00261216f, -0.03655826f, 
    0.02188253f, -0.01977242f, -0.03270141f, -0.01785052f, -0.06223280f, -0.01982026f, -0.06395335f, 0.04607356f, 
    0.04442903f, 0.00012819f, -0.03054441f, 0.02973497f, -0.01583720f, 0.02539538f, 0.00411834f, 0.01858698f, 
    -0.00353239f, -0.03744456f, -0.02282851f, -0.01481195f, 0.02689281f, -0.05767255f, -0.04072313f, 0.02726404f, 
    -0.00745683f, -0.02996421f, -0.02606184f, 0.01013513f, 0.02069709f, -0.02516525f, 0.00677834f, -0.06130091f, 
    0.03338474f, 0.00651592f, 0.03489618f, -0.03277093f, -0.01244449f, 0.03037714f, 0.04751315f, 0.00760292f, 
    -0.06274702f, 0.03096041f, -0.01114552f, 0.02088866f, -0.00655992f, -0.04641796f, -0.00428427f, -0.00460748f, 
    -0.00557625f, 0.01847138f, 0.04188379f, -0.03071570f, -0.00055429f, 0.04584471f, 0.04212403f, 0.01404384f, 
    0.02182647f, -0.01261369f, -0.04617308f, 0.03037812f, 0.01627623f, -0.04475166f, 0.00478336f, 0.00020077f, 
    -0.01545337f, 0.01255574f, -0.00999910f, 0.04405243f, 0.03813446f, 0.03789163f, -0.06519195f, -0.02745575f, 
    -0.04596966f, -0.02740256f, 0.00841020f, -0.05512633f, 0.04291176f, -0.01029711f, -0.05652015f, -0.00370199f, 
    0.04962673f, 0.01342948f, -0.04475576f, -0.03087424f, 0.02276946f, -0.03011714f, -0.04483997f, -0.03824899f, 
    -0.00896316f, 0.04849858f, -0.01603093f, -0.00310592f, -0.00064820f, -0.00188562f, -0.04265270f, 0.02691172f, 
    -0.05942368f, -0.02150947f, -0.03393911f, -0.03512707f, -0.04368340f, -0.02260167f, -0.05379368f, -0.00684162f, 
    0.02546937f, -0.01848976f, -0.00415276f, -0.03087993f, -0.03775745f, 0.01653207f, 0.04454285f, 0.03672652f, 
    0.02850558f, -0.00245697f, -0.06080506f, 0.02347067f, 0.03934928f, -0.02284411f, -0.01490077f, -0.00432341f, 
    -0.04092193f, -0.00367141f, 0.03932071f, -0.00091400f, -0.02160615f, 0.01900030f, 0.04217201f, -0.06458914f, 
    -0.03627646f, 0.04275564f, -0.01596425f, 0.03601104f, -0.01504417f, -0.04837711f, -0.05358534f, -0.03900269f, 
    -0.04443666f, 0.02641034f, 0.03812055f, -0.00536817f, 0.04439681f, -0.02304077f, -0.04034477f, -0.05953428f, 
    -0.03503665f, 0.01787872f, -0.01674218f, -0.01020978f, 0.02706497f, 0.01158673f, 0.03747270f, 0.00565428f, 
    -0.04939746f, -0.03883144f, -0.01875794f, -0.03360694f, -0.00842452f, -0.01507805f, -0.02910333f, 0.00842391f, 
    -0.00588738f, -0.01344116f, -0.05994101f, -0.01042946f, 0.01935811f, -0.02755069f, 0.01311656f, 0.04726687f, 
    -0.05676353f, -0.02941276f, -0.00846215f, -0.03289780f, -0.03340326f, 0.00057152f, 0.02393885f, 0.05201247f, 
    0.01420634f, -0.05240550f, -0.01361283f, 0.00394095f, -0.02431924f, -0.05578811f, -0.05352062f, -0.03711348f, 
    0.00480032f, -0.06472763f, -0.04380291f, -0.01978800f, 0.00430423f, -0.02925631f, 0.02285869f, -0.06065783f, 
    -0.04664369f, -0.04043956f, -0.03884027f, -0.04572723f, 0.02813641f, -0.04942473f, 0.03986897f, -0.04432375f, 
    -0.06545062f, -0.00513470f, 0.04749281f, -0.03110320f, -0.01535586f, -0.04087587f, 0.02018943f, -0.06267175f, 
    0.00517946f, -0.00927963f, -0.06546755f, -0.02386682f, -0.00901380f, 0.04378724f, 0.01410297f, 0.02135821f, 
    -0.00158567f, 0.04308686f, -0.06627943f, -0.00958888f, 0.00232717f, -0.06402653f, -0.01183435f, -0.03565913f, 
    0.00713513f, -0.01226296f, 0.05301299f, -0.05724174f, -0.00181663f, -0.05272064f, -0.00723716f, 0.05426214f, 
    0.03074802f, 0.05515866f, -0.04036757f, -0.04198333f, -0.00177766f, -0.04842734f, 0.04919728f, 0.02132026f, 
    0.03299364f, 0.04727740f, 0.02237966f, 0.03383508f, 0.02475954f, 0.03775638f, -0.06115096f, 0.00619734f, 
    0.02337550f, 0.01051316f, 0.02958142f, 0.02516168f, 0.03767295f, 0.00202180f, -0.02055617f, -0.04798425f, 
    0.01791616f, 0.04789888f, 0.02301878f, -0.05030258f, -0.02154553f, 0.01071561f, 0.03759552f, -0.06181422f, 
    -0.00274732f, -0.03830315f, 0.01570007f, 0.00374252f, 0.04052835f, -0.04626061f, 0.04794035f, 0.03114462f, 
    0.38816005f, 0.26405296f, 0.19801517f, 0.05932521f, 0.16409835f, 0.20430322f, -0.00091733f, 0.03456129f, 
    -0.10780670f, -0.23724757f, -0.34615022f, -0.11498021f, 0.12899813f, 0.03271504f, -0.03604805f, -0.15656912f, 
    0.12745671f, 0.11972935f, 0.05230829f, -0.02926144f, 0.07430441f, 0.01562645f, -0.08635667f, -0.21503852f, 
    0.07597527f, 0.09788127f, 0.09793133f, 0.32705379f, 0.03064341f, -0.16903062f, 0.08669076f, 0.04423817f, 
    -0.02724368f, 0.13323978f, -0.01042184f, -0.08774099f, 0.25325790f, 0.11406517f, 0.18648942f, -0.03593273f, 
    0.02398904f, -0.15875988f, -0.10824106f, -0.04670490f, 0.14298907f, -0.63966668f, -0.11653867f, -0.25563896f, 
    -0.12133125f, -0.02817463f, -0.01156602f, 0.01146472f, 0.10822044f, 0.09354766f, -0.11117045f, 0.03668961f, 
    -0.03651148f, -0.05652054f, 0.23728846f, -0.03347211f, -0.03390776f, -0.10612928f, 0.02960131f, -0.01608676f, 
    0.39474589f, -0.13049611f, -0.12622380f, 0.01684698f, 0.03294992f, 0.08371248f, -0.25412315f, 0.20868467f, 
    0.16348954f, 0.09960039f, -0.00587255f, -0.11839013f, 0.16057698f, 0.27550805f, 0.06784432f, -0.07323340f, 
    -0.20130682f, -0.01047581f, 0.10665449f, 0.03756572f, 0.12504418f, -0.00444950f, -0.00218796f, 0.08079897f, 
    -0.03249061f, 0.15453215f, -0.36390597f, -0.26426995f, 0.22762841f, -0.01845921f, -0.32493213f, 0.05318683f, 
    -0.09414196f, 0.14007434f, 0.02738455f, -0.24747236f, -0.35264361f, 0.05765497f, 0.00194484f, -0.12655097f, 
    0.01409152f, -0.05599529f, 0.11134055f, 0.24429235f, 0.12473761f, 0.21786301f, -0.05972720f, 0.08026497f, 
    0.14561751f, 0.14086176f, 0.10507007f, -0.06811808f, 0.04562237f, 0.26210815f, 0.13775638f, 0.20565967f, 
    -0.14299254f, 0.02463871f, 0.17392974f, -0.08857830f, 0.00274020f, 0.09720550f, -0.19557311f, 0.22246751f, 
    -0.17117637f, 0.17846251f, -0.22593012f, -0.22718012f, 0.03780564f, 0.14914858f, 0.11828370f, 0.03387883f, 
    -0.09331249f, -0.38146493f, 0.02097248f, 0.20888337f, -0.10371318f, 0.11795030f, 0.06573572f, 0.00907384f, 
    0.49170321f, 0.23828042f, -0.37824526f, -0.17492943f, -0.15970890f, 0.14231913f, -0.05215368f, 0.05896628f, 
    -0.22696634f, -0.34776568f, -0.24673988f, -0.34135845f, -0.02040726f, -0.03759260f, -0.04624517f, 0.11250935f, 
    -0.04580135f, -0.04683289f, -0.24618621f, -0.35834673f, -0.08667833f, 0.07243434f, -0.01072249f, -0.34308138f, 
    0.10075522f, 0.05451170f, 0.21921074f, -0.37068242f, -0.64761603f, -0.45732775f, 0.07762574f, 0.09438903f, 
    0.13920589f, 0.23508207f, -0.02524865f, -0.10223889f, -0.48026156f, -0.14219578f, -0.49226823f, 0.29405060f, 
    0.18028028f, 0.15811056f, 0.21560526f, 0.04809795f, 0.15809231f, -0.17976157f, -0.25112277f, -0.38122785f, 
    0.00027036f, 0.03911392f, 0.10278287f, -0.08418806f, 0.00764294f, 0.06638189f, -0.05591225f, -0.35230330f, 
    -0.31672996f, 0.19361871f, 0.00772085f, -0.03945812f, 0.12605493f, 0.09332059f, 0.02409275f, -0.27686185f, 
    -0.13422163f, -0.11529183f, 0.12250461f, -0.00932911f, -0.02618939f, -0.00590320f, -0.06985220f, 0.17975456f, 
    0.27959710f, 0.20562932f, 0.24305326f, 0.09255665f, -0.00228373f, -0.15782601f, 0.06296014f, 0.03324657f, 
    -0.12390372f, 0.09053046f, 0.11766046f, -0.20701383f, 0.06762057f, 0.08733356f, 0.02472138f, 0.10573233f, 
    0.03822101f, -0.08439663f, 0.16155903f, 0.06180790f, -0.09653210f, -0.20779282f, -0.13176365f, 0.19809884f, 
    0.05160335f, 0.09538414f, -0.17514785f, 0.40150729f, 0.15902281f, -0.40502641f, -0.00320381f, 0.04275066f, 
    0.21515580f, -0.11638588f, 0.07982638f, 0.20905025f, 0.18468250f, 0.12129712f, 0.05162580f, 0.06113221f, 
    -0.00220460f, 0.07942581f, 0.16569404f, -0.07020608f, 0.01586895f, 0.08511230f, -0.02763202f, -0.28545803f, 
    0.14879791f, 0.11003304f, 0.18587583f, 0.11979539f, 0.00796207f, -0.00917849f, -0.02487353f, -0.28885132f, 
    -0.29679582f, 0.19866227f, 0.23370077f, 0.31331214f, 0.22809076f, -0.03841902f, 0.06599343f, 0.11549066f, 
    -0.36548057f, -0.32795244f, 0.00397846f, 0.09486286f, -0.03466139f, 0.19815226f, 0.09998750f, -0.01642286f, 
    0.05645758f, 0.00443159f, -0.00632773f, 0.08341318f, 0.05143008f, 0.07817549f, 0.01875462f, 0.01147043f, 
    0.12765986f, -0.07436762f, -0.01083949f, -0.02101514f, -0.05685389f, 0.08028913f, 0.03550384f, 0.19347292f, 
    0.25245070f, 0.02957131f, 0.08553547f, 0.00977679f, 0.09710322f, 0.26260546f, 0.13780811f, 0.07915315f, 
    0.06780840f, -0.06257473f, 0.06546508f, 0.01331528f, 0.00216095f, 0.13517991f, 0.18007775f, 0.05092115f, 
    0.16325760f, 0.02014441f, -0.05447053f, 0.14019842f, -0.00730888f, 0.07373799f, -0.00977691f, 0.15213357f, 
    0.29160264f, 0.17777312f, 0.03231109f, 0.02133380f, 0.11050434f, 0.20697939f, 0.46076936f, 0.15114422f, 
    0.01580851f, 0.03465164f, -0.24644911f, 0.00315498f, -0.08690397f, 0.24552956f, 0.02311586f, 0.10237231f, 
    0.60810924f, 0.13702320f, 0.10001178f, -0.01898444f, -0.02369104f, -0.04907066f, 0.06456308f, 0.01766072f, 
    -0.07656778f, 0.21414720f, 0.18895063f, 0.30037636f, 0.03525640f, -0.11833688f, -0.35514882f, 0.17049123f, 
    0.13897954f, 0.06338564f, 0.18226913f, 0.03063506f, -0.00743571f, -0.24758625f, 0.17244916f, 0.11130733f, 
    0.32109147f, 0.10878364f, -0.06695522f, 0.19866672f, 0.17018606f, 0.00612926f, -0.01397576f, -0.00244331f, 
    -0.09665681f, -0.15403150f, 0.94551730f, 0.24396421f, -0.22762917f, -0.11321099f, 0.18353309f, 0.07395175f, 
    0.23698226f, 0.27938342f, -0.00787185f, -0.13565861f, 0.21065097f, -0.18420793f, 0.11646298f, 0.05694905f, 
    -0.00568045f, -0.05910718f, -0.04284430f, 0.04148204f, 0.02837339f, 0.01383211f, 0.05183782f, 0.02720369f, 
    0.05152873f, 0.15017232f, -0.02972917f, -0.15165471f, -0.08553695f, -0.00994076f, -0.12560268f, 0.05205524f, 
    0.26110274f, 0.08910657f, 0.05259897f, 0.07186271f, 0.03674308f, -0.15601072f, 0.10406432f, -0.17276810f, 
    -0.12666534f, 0.23120840f, 0.08565458f, 0.17642188f, 0.05334242f, -0.03775077f, 0.00853899f, -0.06023422f, 
    -0.05510820f, 0.06480595f, -0.08513011f, -0.10519777f, -0.04464003f, 0.12592320f, 0.12839994f, 0.21068892f, 
    0.03189516f, -0.06137177f, 0.80861944f, -0.06031066f, 0.16342762f, -0.08869879f, 0.12945630f, -0.16580456f, 
    0.15393323f, 0.09772686f, 0.01416943f, -0.04956654f, 0.06365076f, 0.19179744f, 0.13888730f, 0.20333801f, 
    0.11748059f, 0.02028031f, -0.15764949f, 0.50395983f, 0.18338270f, -0.01034718f, 0.02094730f, -0.04257917f, 
    -0.05719687f, -0.09984504f, 0.07421635f, -0.03737907f, -0.05968404f, 0.26825455f, -0.02012281f, 0.18615977f, 
    0.09521470f, -0.12195455f, 0.00518463f, 0.26956528f, -0.16826770f, -0.27329725f, 0.19157830f, 0.12152907f, 
    0.08704545f, 0.08896956f, -0.13774820f, -0.13541548f, 0.13761383f, -0.00214472f, -0.06476180f, 0.05305385f, 
    -0.12793952f, 0.03434316f, 0.14766294f, 0.11634272f, -0.01188063f, -0.07191683f, -0.03956812f, -0.01474102f, 
    0.06437014f, -0.05555189f, -0.07371782f, 0.05313773f, -0.00675568f, 0.24867658f, 0.03729613f, -0.07116487f, 
    -0.06646135f, -0.08451694f, 0.07619655f, -0.02418928f, 0.11124983f, -0.03679811f, 0.08381400f, -0.00995012f, 
    0.19091228f, 0.03657003f, 0.08126140f, -0.00462405f, 0.04584357f, 0.25010890f, -0.05241304f, -0.10161609f, 
    -0.00822969f, -0.13972890f, -0.12065511f, 0.00393206f, 0.10082365f, -0.01120965f, -0.07849983f, 0.15408319f, 
    0.04195843f, -0.12627950f, 0.04674143f, 0.23455104f, 0.01695119f, 0.16876057f, 0.04121753f, -0.14178860f, 
    -0.01551391f, 0.01789164f, -0.03512211f, -0.06076523f, -0.18988034f, 0.02894848f, -0.07281611f, -0.14905871f, 
    -0.14945281f, 0.25974813f, 0.18059653f, 0.07237474f, -0.08040775f, -0.00138114f, -0.01939566f, 0.08620230f, 
    -0.04402389f, 0.07859030f, -0.06439403f, -0.09597500f, -0.09675360f, -0.16393809f, -0.15560247f, -0.05523505f, 
    -0.14800508f, -0.01305863f, 0.05482521f, -0.01988854f, 0.01748087f, 0.10717680f, -0.19671653f, -0.22778201f, 
    0.09882832f, 0.16148792f, -0.00229996f, 0.08512706f, -0.13533695f, 0.03122174f, 0.14060798f, -0.23843168f, 
    -0.23821037f, 0.07922589f, 0.19599129f, 0.04024362f, -0.01936007f, 0.00255398f, -0.10735809f, 0.09768219f, 
    -0.13863245f, -0.08239619f, -0.11106184f, 0.15693632f, 0.04317803f, 0.02036269f, -0.11094841f, 0.17358212f, 
    0.03374915f, 0.12282286f, 0.04392309f, 0.06624581f, -0.10314402f, -0.02126238f, -0.16756700f, 0.09669317f, 
    -0.13185351f, 0.05578920f, -0.39495412f, -0.28439438f, 0.03501690f, 0.10702442f, 0.01519440f, -0.04500033f, 
    0.08291740f, -0.01025836f, 0.02639194f, -0.08096147f, 0.30469206f, 0.17859834f, 0.07301714f, -0.00665662f, 
    -0.13562587f, 0.07861981f, 0.05527624f, 0.11876096f, -0.73796499f, 0.00492120f, 0.27287313f, 0.03756227f, 
    0.06815608f, -0.00494284f, 0.06231640f, 0.03098758f, 0.10374023f, -0.07404346f, 0.09491037f, -0.23464096f, 
    0.03123944f, 0.14542635f, -0.05628612f, 0.07156073f, -0.14541805f, -0.09315180f, -0.36390904f, 0.15375665f, 
    -0.32397485f, 0.04635095f, 0.20539097f, 0.03204007f, 0.01287120f, 0.13282982f, 0.01532119f, -0.08122817f, 
    0.50244033f, -0.25416854f, 0.13224493f, -0.08888334f, -0.03435079f, 0.02044516f, -0.18943000f, 0.09141970f, 
    -0.37144729f, -0.07076086f, -0.26568520f, 0.07948895f, 0.21573402f, -0.01846500f, -0.16769256f, 0.03976805f, 
    -0.05832331f, -0.25268856f, 0.04394342f, -0.42837760f, -0.03613722f, 0.04744724f, 0.06160579f, -0.01846406f, 
    0.02735146f, -0.03421433f, -0.11226608f, -0.36787611f, -0.34419584f, 0.03242402f, 0.05186122f, 0.26081696f, 
    0.25389415f, -0.13854197f, 0.17947707f, 0.09336320f, 0.00102935f, -0.02553865f, -0.08184712f, -0.08608859f, 
    -0.03878785f, -0.05699820f, 0.04147719f, 0.22524184f, -0.01797760f, -0.07903163f, -0.20211509f, -0.10062905f, 
    -0.03145289f, 0.11838774f, 0.04695200f, -0.12689441f, -0.12120736f, -0.21490087f, -0.11986868f, 0.18746778f, 
    0.18196790f, 0.10594025f, 0.11474634f, 0.01816707f, -0.00835226f, 0.10709941f, 0.04746426f, 0.11754769f, 
    -0.02833978f, -0.00966326f, -0.17149708f, -0.00781556f, 0.04328679f, 0.14192043f, 0.12832403f, 0.09786188f, 
    0.02142589f, -0.08425451f, -0.03040599f, 0.09016570f, 0.37215722f, 0.09466534f, 0.03084455f, -0.03918212f, 
    0.34594160f, 0.00614098f, -0.60496873f, 0.15662619f, 0.42469928f, -0.16417527f, -0.02719674f, 0.12117376f, 
    0.07801413f, -0.13871339f, 0.15867703f, 0.16389291f, -0.17692496f, 0.45919931f, -0.03249583f, -0.05902001f, 
    -0.13074160f, 0.07279138f, 0.18167822f, -0.17649204f, 0.03644669f, -0.06167824f, -0.03662024f, 0.00673751f, 
    0.19468434f, -0.13658042f, 0.08301451f, -0.15683937f, -0.12274003f, -0.16920739f, 0.09104483f, 0.21682568f, 
    0.01940222f, 0.18564610f, -0.08415132f, 0.02468878f, -0.18177611f, -0.02777331f, -0.18840848f, 0.01372226f, 
    0.12144866f, 0.05358085f, 0.13853265f, -0.10182759f, -0.00940333f, -0.10248950f, -0.16669807f, -0.11230163f, 
    -0.04153183f, -0.05063987f, -0.04662911f, 0.19865242f, -0.08666106f, 0.03515697f, 0.24915782f, 0.22005822f, 
    0.10759599f, 0.01165502f, 0.03335759f, 0.11377010f, 0.05055292f, 0.02005167f, -0.03972253f, 0.06583837f, 
    0.17229955f, 0.11260869f, -0.02297706f, -0.17804459f, -0.11759440f, -0.03962325f, -0.20956120f, 0.02617029f, 
    -0.53174371f, -0.39582086f, 0.02577345f, -0.12633678f, -0.15665255f, 0.02028294f, -0.00420929f, -0.03102528f, 
    -0.11171316f, -0.09202664f, 0.14093903f, -0.12856971f, -0.01094800f, 0.16555512f, -0.11530213f, -0.03001806f, 
    -0.25750732f, 0.03575533f, -0.36383384f, -0.35882813f, 0.31630415f, -0.02742615f, -0.02833473f, 0.10710061f, 
    0.20256741f, 0.11111761f, 0.08189551f, -0.09816373f, -0.07890416f, -0.13814655f, 0.13364281f, -0.08350658f, 
    -0.03003348f, -0.04471967f, -0.01852746f, 0.11734320f, -0.05060853f, 0.17434035f, -0.21608448f, -0.06181866f, 
    -0.02415761f, 0.00993116f, 0.01194703f, -0.02691906f, -0.01589568f, -0.09994029f, -0.00222418f, -0.05623345f, 
    0.04540997f, -0.08220664f, 0.20516917f, 0.00593997f, 0.03808018f, 0.08293922f, -0.14103837f, 0.26859871f, 
    0.01690598f, 0.08327889f, 0.28723329f, 0.04726075f, 0.04515175f, -0.08527691f, -0.06860318f, -0.02161356f, 
    -0.08182244f, -0.03612350f, -0.19295816f, -0.19340676f, 0.06308559f, -0.04328388f, -0.12883426f, 0.13706154f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01459059f, -0.06672473f, 0.05246311f, -0.05433787f, -0.03010748f, 0.36394295f, -0.06278800f, -0.15968709f, 
    0.19684930f, 0.32480070f, 0.11295114f, -0.09981095f, 0.24612707f, 0.09803687f, 0.00267771f, 0.00109782f, 
    0.01968084f, 0.10578447f, -0.03048003f, 0.25796315f, 0.21507637f, -0.02181832f, 0.07820898f, 0.03106895f, 
    0.17409419f, 0.15662122f, 0.22493298f, -0.03894411f, -0.00247504f, -0.00657417f, 0.23318930f, 0.20197555f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15529668f, 0.06911314f, 0.20256063f, 0.69958568f, -0.11589977f, -0.12480480f, 0.00112003f, 0.12244679f, 
    0.06506509f, -0.21404655f, 0.15563673f, -0.06231213f, -0.20167726f, 0.16086046f, 0.27970734f, -0.00225706f, 
    -0.13600793f, 0.48701304f, -0.29693779f, 0.10097516f, -0.08766716f, 0.01553285f, 0.34619752f, 0.05613815f, 
    -0.13142315f, -0.07916924f, -0.06280142f, -0.07021309f, 0.14347772f, 0.29199207f, -0.10223940f, 0.18554009f, 
    0.08528801f, -0.01260909f, -0.05532877f, -0.13427393f, 0.03198735f, -0.00437203f, -0.12553337f, -0.09356258f, 
    -0.04674094f, -0.00421471f, 0.03035231f, 0.01890757f, -0.02135967f, 0.05811853f, -0.06861218f, 0.15208460f, 
    -0.12510674f, -0.15679371f, -0.03647304f, -0.11073337f, -0.08182804f, -0.16564865f, 0.09464711f, 0.01177625f, 
    -0.02749487f, -0.21351589f, -0.02358303f, 0.06883575f, -0.14778499f, 0.02266024f, -0.13977312f, 0.04484430f, 
    -0.28824672f, -0.09711310f, 0.02961389f, -0.03192312f, -0.35997453f, 0.13789076f, -0.05552173f, 0.27868536f, 
    0.05280082f, 0.22167592f, -0.24290091f, -0.15525037f, -0.02288589f, -0.09560949f, -0.49181899f, 0.19852559f, 
    0.00169490f, -0.14374693f, -0.10796341f, 0.40876162f, 0.36211121f, -0.16528861f, -0.27661553f, -0.12091189f, 
    0.12310535f, -0.24643198f, 0.24024242f, 0.07278719f, -0.08244457f, 0.06844328f, 0.19451872f, -0.15564281f, 
    -0.15283597f, -0.17117295f, -0.01289614f, 0.11753148f, -0.01307011f, -0.14537708f, -0.02750328f, -0.11295500f, 
    0.03752936f, 0.02872165f, 0.00530867f, -0.04042054f, -0.05079599f, -0.03095928f, 0.13416530f, -0.07970170f, 
    -0.08415626f, -0.06830503f, 0.00223560f, -0.13241728f, -0.13828799f, -0.12059088f, -0.14550184f, -0.07522756f, 
    0.15917628f, -0.03622841f, 0.10965165f, -0.15034063f, -0.07150818f, 0.11487474f, -0.04694463f, -0.15192738f, 
    -0.10910218f, 0.06197251f, 0.07423154f, -0.22854891f, 0.00683356f, -0.02369913f, -0.05718208f, 0.07998969f, 
    0.07162908f, -0.12839651f, -0.20096824f, -0.18933456f, -0.12993228f, -0.04041139f, 0.13044807f, 0.06642830f, 
    -0.11773548f, -0.07670271f, -0.17949258f, -0.12618849f, -0.10074520f, -0.05789841f, -0.15760618f, -0.14819254f, 
    0.13623409f, -0.19093077f, -0.07452422f, 0.10598639f, 0.02528004f, -0.17620148f, -0.02012313f, 0.11519534f, 
    0.04084016f, 0.14882089f, 0.04343261f, -0.16883378f, -0.16608576f, -0.08413019f, 0.14424552f, 0.08197430f, 
    -0.10227875f, -0.05616647f, -0.18972388f, 0.06906526f, 0.00531985f, -0.01511627f, 0.14095284f, -0.13665089f, 
    0.04475698f, -0.03661882f, -0.08806254f, 0.09112459f, -0.06207689f, -0.15625483f, -0.11752473f, 0.14531089f, 
    -0.09106085f, -0.05650922f, -0.10249680f, 0.04361501f, -0.08146393f, -0.01052990f, -0.19637905f, -0.08440614f, 
    0.22274154f, -0.14730167f, -0.13634998f, -0.33794600f, -0.61915433f, 0.04111972f, -0.14155757f, -0.06488960f, 
    -0.10026880f, 0.36148283f, -1.34057367f, 0.06205993f, 0.57406902f, -0.17456891f, -0.16149428f, 0.17241482f, 
    0.09293199f, -0.19052540f, -0.09595308f, 0.01524134f, 0.29857287f, -0.14708872f, -0.53416455f, -0.08368797f, 
    -0.62078798f, -0.17039742f, 0.42264882f, -0.04957330f, -0.09997328f, 0.34320614f, 0.31331986f, -0.16097003f, 
    0.08328028f, 0.08820179f, 0.45011482f, 0.35207504f, 0.55945235f, -0.29816929f, -0.02969040f, 0.06513646f, 
    0.53084189f, -0.34878451f, -0.41035122f, -0.07852398f, -0.38669729f, 0.13580510f, 0.15090288f, 0.15914202f, 
    0.14907531f, -0.22687349f, 0.40132117f, 0.13992858f, -0.15349360f, -0.07405755f, 0.26768136f, -0.16856772f, 
    -0.16260411f, 0.10647681f, 0.41743404f, 0.12925965f, 0.11970603f, 0.30341426f, -0.00931379f, -0.34588116f, 
    -0.16737475f, -0.00995737f, -0.25172907f, 0.27932334f, -0.47695252f, 0.18299878f, 0.02910678f, -0.13380317f, 
    0.10933167f, 0.24853852f, 0.25895923f, -0.31394315f, 0.47444302f, 0.54218137f, 0.28349143f, -0.23469746f, 
    -0.04041059f, 0.34041780f, 0.05894567f, -0.22849970f, -0.21185486f, 0.02783449f, -0.03202634f, 0.05078230f, 
    0.16282202f, 0.40982813f, 0.05241713f, -0.14159839f, 0.14773214f, -0.24807380f, 0.19241819f, 0.29270163f, 
    -0.08674610f, -0.03933220f, -0.28905967f, -0.22262651f, -0.01586226f, 0.11613045f, 0.02669392f, 0.23302829f, 
    -0.14293817f, 0.20654351f, -0.02788047f, 0.08794270f, 0.20578176f, -0.28419611f, -0.61334348f, 0.19966041f, 
    -0.03304842f, 0.04564223f, 0.30576092f, -0.17909759f, 0.13473634f, 0.17652385f, -0.27993497f, -0.06614543f, 
    0.28344795f, -0.33993846f, 0.21224377f, -0.06495588f, 0.14200482f, -0.38266242f, 0.39068565f, -0.08628884f, 
    -0.06254937f, -0.16271521f, 0.02596037f, -0.01703386f, 0.07714264f, 0.00497251f, 0.16563804f, -0.10306453f, 
    -0.14390199f, 0.09626435f, -0.04584740f, -0.16725622f, -0.10731173f, 0.06195247f, -0.01443544f, 0.14928284f, 
    0.08914047f, -0.16686355f, -0.12289749f, -0.08755032f, 0.09277122f, 0.06050829f, -0.08586790f, 0.11290978f, 
    0.09665463f, -0.00769085f, -0.06461392f, 0.07206666f, -0.06921330f, -0.02030290f, -0.16583684f, 0.00432521f, 
    -0.16000427f, 0.04363151f, -0.07189225f, 0.22626372f, 0.44673648f, 0.35243240f, 0.08547417f, 0.32786766f, 
    -0.27409422f, -0.06649014f, -0.13507108f, -0.48623997f, -0.16886301f, 0.02914136f, -0.79282677f, -0.04104461f, 
    -0.08343278f, -0.24274608f, 0.03526111f, 0.16069284f, 0.02796858f, 0.08564664f, 0.41328070f, 0.03640611f, 
    0.34012243f, 0.18820646f, 0.11646742f, 0.05460990f, 0.15443692f, 0.28396881f, 0.17853455f, -0.36665222f, 
    -0.09198646f, 0.13388570f, -0.03913354f, -0.14085832f, 0.05998135f, 0.01836770f, -0.01108740f, -0.12346552f, 
    0.01046461f, 0.04634606f, 0.07141936f, -0.01585331f, -0.08122852f, 0.02025361f, -0.14493908f, 0.12510332f, 
    -0.08766970f, -0.07143828f, -0.12016690f, -0.05100225f, -0.16333288f, -0.06691400f, -0.02121621f, 0.04000745f, 
    0.09636004f, -0.04905254f, -0.00839398f, -0.12266222f, -0.06194988f, -0.12395519f, -0.05105616f, -0.05408063f, 
    0.02977900f, -0.00743910f, 0.16359685f, 0.11052857f, -0.11660046f, 0.08543452f, -0.10935714f, -0.37881213f, 
    -0.37639996f, -0.10400110f, -0.14602426f, 0.23941803f, 0.25680500f, 0.21137312f, -0.27883351f, -0.09982877f, 
    -0.09822751f, 0.46481305f, -0.50120074f, 0.03393222f, 0.13675724f, -0.03221077f, 0.13059215f, -0.08836970f, 
    -0.15641326f, 0.09403087f, 0.15240330f, -0.15726046f, 0.04158795f, 0.54441684f, -0.23277417f, 0.00081102f, 
    0.29425132f, -0.01073442f, 0.05274128f, 0.10292419f, 0.66007823f, 0.01252466f, 0.14940605f, 0.10879912f, 
    0.40767175f, -0.37786955f, -0.23178279f, -0.14871745f, -0.24544394f, 0.20757492f, -0.09083461f, 0.04571243f, 
    -0.11327033f, -0.31285694f, 0.17648417f, -0.67310596f, -0.02932657f, 0.14887020f, 0.07040986f, -0.14134143f, 
    0.35614559f, 0.37697506f, -0.26698741f, -0.08105966f, -0.07804492f, 0.12285418f, -0.18533131f, -0.33938247f, 
    -0.21443467f, 0.02490360f, -0.16476528f, -0.12185048f, 0.48918670f, 0.30560574f, 0.07923108f, -0.11620965f, 
    -0.20781405f, 0.16029790f, 0.28952169f, 0.18895572f, 0.23590356f, 0.31699932f, 0.27696618f, -0.15059960f, 
    -0.02541697f, -0.51975983f, 0.07409766f, 0.36956391f, 0.02515545f, -0.10881993f, 0.06046006f, -0.01957136f, 
    0.16401097f, 0.65619588f, -0.00178783f, -0.08751359f, 0.12659694f, 0.16965105f, -0.23548023f, 0.26526862f, 
    0.10319702f, 0.08808476f, 0.08705416f, -0.13497342f, -0.08416228f, 0.05252670f, 0.10024575f, -0.10545615f, 
    -0.10337385f, -0.03480851f, 0.06842874f, -0.18506874f, 0.09376591f, -0.17546146f, 0.08249482f, -0.12691963f, 
    -0.02583697f, -0.15896155f, -0.13285956f, -0.01488080f, -0.05277164f, -0.16980822f, -0.04900413f, -0.04255483f, 
    -0.09235708f, 0.03555972f, -0.17690572f, -0.10250539f, -0.15862973f, -0.17420046f, 0.00211471f, -0.01688028f, 
    -0.11696061f, -0.15335889f, 0.06460215f, 0.13078474f, 0.08154123f, -0.07024109f, 0.16556868f, -0.07073303f, 
    0.06658820f, -0.09125531f, 0.04231694f, -0.11092550f, -0.11769085f, -0.05612598f, 0.03130063f, 0.08525103f, 
    0.00563219f, -0.13405606f, 0.05262526f, 0.01056191f, 0.01412309f, -0.06929430f, 0.03977629f, 0.15908565f, 
    -0.14331202f, 0.08342920f, 0.13048655f, -0.16031213f, -0.09163130f, -0.19211386f, -0.20255004f, 0.00530009f, 
    0.19163777f, -0.16357693f, 0.15919562f, 0.16236660f, 0.50717294f, 0.05682838f, 0.08813222f, -0.04963959f, 
    -0.13362175f, -0.09333625f, -0.24424519f, 0.08704039f, -0.38176945f, 0.26057845f, -0.28691563f, 0.29916877f, 
    0.05655535f, -0.12859045f, 0.17724589f, 0.03397641f, 0.01559571f, -0.13762537f, 0.24189712f, 0.07240775f, 
    -0.09484821f, 0.53522599f, -0.21968229f, -0.10125141f, -0.04783762f, 0.19288719f, -0.03782102f, 0.04642831f, 
    0.00778694f, 0.11169370f, 0.09130035f, 0.16091593f, -0.15731496f, -0.13478155f, -0.14913629f, 0.02425171f, 
    -0.17673005f, -0.08038870f, 0.09096988f, -0.08749430f, -0.14442809f, 0.01216828f, -0.13653722f, -0.18911767f, 
    -0.13115609f, 0.08096968f, 0.02235205f, 0.03062624f, 0.03580546f, -0.00002489f, -0.02107469f, -0.14519943f, 
    -0.05530827f, 0.06395490f, 0.13422561f, 0.04323382f, -0.11084781f, -0.05545602f, -0.06895141f, -0.11460777f, 
    0.35290623f, -0.10444657f, 0.46417141f, 0.14067006f, 0.32596737f, -0.07127422f, -0.07396029f, -0.18971393f, 
    0.24766143f, -0.11291685f, -0.18390460f, -0.02055772f, -0.47169647f, 0.33752552f, 0.17686500f, -0.03199807f, 
    0.04896839f, 0.14634013f, 0.01135604f, 0.01344514f, -0.09366543f, -0.10592112f, 0.43297490f, -0.09238182f, 
    0.06140189f, 0.88928515f, 0.13430585f, -0.16968267f, 0.09776451f, -0.04313032f, -0.08218432f, 0.21826313f, 
    -0.14952043f, -0.01608335f, 0.26473194f, 0.37646332f, 0.07803097f, 0.35346955f, 0.06433475f, 0.05882647f, 
    0.11544110f, 0.17730607f, 0.17288586f, -0.05551409f, 0.21292171f, -0.25119147f, -0.12284241f, 0.24284858f, 
    -0.07889590f, 0.42778194f, -0.36998412f, 0.18829994f, 0.06008098f, -0.04188006f, -0.09242879f, -0.03593366f, 
    0.03129280f, -0.11040122f, -0.43640652f, -0.10077855f, 0.04126994f, 0.17879058f, -0.02701846f, 0.41267395f, 
    -0.05697984f, -0.13948166f, -0.03424773f, 0.03270733f, -0.00929855f, -0.03075179f, 0.13381650f, -0.12830588f, 
    -0.09761770f, -0.15963842f, -0.18155992f, 0.17059720f, -0.15806702f, 0.14991686f, -0.06365006f, -0.02669826f, 
    -0.00061322f, -0.00320837f, -0.06367341f, 0.11156746f, -0.17432556f, 0.03705082f, -0.11146148f, 0.13142116f, 
    -0.11593755f, -0.01728838f, -0.07096545f, -0.00345760f, 0.01067040f, -0.07266620f, -0.17757723f, 0.05100507f, 
    0.39929515f, -0.07565454f, -0.37250644f, -0.01033413f, -0.27267295f, 0.12053064f, 0.10911077f, 0.05779694f, 
    -0.78823972f, -0.04947203f, -0.04913837f, -0.04793064f, 0.57076371f, 0.36468729f, 0.42635959f, 0.17852844f, 
    0.13289075f, -0.07608157f, -0.29581112f, -0.30898571f, 0.04174472f, 0.13299769f, 0.25950789f, 0.00355897f, 
    -0.32512617f, -0.00898277f, 0.15357479f, -0.12591189f, -0.04146406f, 0.52247679f, 0.08047952f, 0.01153487f, 
    -0.16426797f, 0.13441494f, 0.08191131f, 0.34466863f, 0.44497141f, -0.00525114f, 0.10293135f, 0.30859476f, 
    0.37175781f, -0.24755132f, -0.56957227f, -0.11405230f, -0.20547739f, -0.06573028f, 0.68380922f, 0.24947768f, 
    -0.11714448f, 0.14580657f, 0.08292563f, -0.18111190f, -0.27146113f, 0.14509863f, -0.00951011f, 0.16552304f, 
    -0.29836673f, -0.11859988f, 0.06232473f, -0.00454587f, -0.15753376f, 0.01612732f, 0.04439254f, -0.42119497f, 
    0.30005822f, -0.11921046f, 0.37175071f, -0.21928024f, 0.15671401f, -0.25933403f, 0.13406064f, -0.06419338f, 
    0.29656187f, 0.08549210f, -0.21796493f, 0.40932870f, -0.05359679f, 0.01745643f, 0.09124666f, 0.30718568f, 
    -0.06295363f, -0.09844514f, 0.20205081f, -0.12691866f, -0.15796329f, 0.12906149f, -0.19855498f, 0.05016600f, 
    -0.30758080f, -0.21160321f, 0.22244439f, 0.03473115f, 0.15429217f, 0.45879889f, -0.13707861f, -0.21979162f, 
    -0.08982571f, -0.07787813f, 0.27693322f, -0.53783381f, -0.02065480f, -0.18675800f, -0.15257244f, -0.35885635f, 
    0.44674376f, 0.05732488f, -0.25604153f, 0.33271074f, 0.06992321f, -0.24770460f, -0.05134368f, 0.23176050f, 
    -0.15289573f, -0.39197502f, 0.44572607f, 0.40007359f, 0.30037200f, -0.11001072f, -0.40180188f, 0.06782743f, 
    -0.22238277f, 0.41623428f, 0.36614063f, -0.00289450f, 0.11716415f, -0.11940777f, 0.21380773f, 0.09479104f, 
    0.23486289f, 0.10896097f, -0.28537914f, -0.08690707f, 0.28657988f, 0.16147624f, -0.02201789f, 0.28408095f, 
    0.02936832f, 0.16725157f, -0.31417087f, -0.02779355f, -0.10762822f, 0.26521188f, -0.20753613f, -0.01334001f, 
    0.11423630f, -0.39764714f, 0.57695431f, -0.14059405f, -0.18147810f, 0.15428740f, -0.08484689f, -0.06922317f, 
    0.19791187f, -0.42745134f, 0.22798884f, -0.07742144f, 0.02368867f, -0.15042265f, 0.29999220f, -0.45533979f, 
    0.17757608f, -0.02115485f, -0.15234983f, 0.26079452f, -0.13412093f, -0.18630327f, -0.12077281f, 0.24728104f, 
    -0.37165248f, 0.11518025f, -0.07187382f, -0.28904378f, 0.18736674f, 0.37605718f, 0.18067098f, -0.26880604f, 
    0.01891362f, 0.41934451f, 0.19530848f, -0.31653768f, -0.14648780f, 0.08609050f, 0.38451511f, -0.09933747f, 
    0.21368150f, 0.07592703f, 0.15404265f, 0.13340014f, 0.09516682f, -0.28294715f, 0.23782668f, 0.31312174f, 
    -0.16774887f, -0.14847228f, 0.00430733f, -0.11299311f, 0.05401837f, -0.13957365f, -0.15688132f, -0.13500842f, 
    -0.16889824f, -0.16247669f, 0.04452085f, -0.02543017f, -0.08085169f, -0.05437301f, 0.08650587f, -0.09109590f, 
    -0.09007333f, 0.00268242f, -0.12286910f, -0.07008567f, 0.11444624f, -0.12376462f, -0.07380920f, 0.02820417f, 
    0.10355615f, -0.04549480f, -0.03682391f, 0.09291812f, -0.11984073f, -0.02679326f, -0.00731066f, 0.01781227f, 
    0.01996503f, -0.13773081f, -0.00303863f, 0.20888966f, -0.12818550f, 0.20454200f, 0.02897698f, -0.33967867f, 
    0.49951944f, -0.19974688f, 0.05978521f, 0.22098058f, 0.05427387f, 0.28888810f, 0.08972583f, -0.10861871f, 
    -0.10406537f, 0.02571504f, 0.05618673f, 0.14212714f, -0.11175184f, 0.02093386f, -0.32490921f, -0.15968765f, 
    0.04423137f, -0.08028803f, 0.01716949f, 0.02744843f, 0.14575422f, 0.49909669f, 0.08391476f, -0.02157800f, 
    -0.70945948f, 0.03795888f, -0.21119177f, 0.05475897f, -0.19861622f, 0.38626432f, -0.10277554f, -0.04655718f, 
    0.42609704f, 0.18971917f, -0.14687628f, -0.07197335f, 0.28624916f, 0.10041235f, 0.22610021f, 0.12968421f, 
    0.10893559f, -0.64729756f, 0.17868651f, 0.43640506f, 0.28812191f, 0.14200068f, -0.46437058f, 0.01716296f, 
    0.17216094f, 0.26256454f, 0.17070656f, -0.11300705f, 0.02551358f, 0.20646222f, -0.07548763f, 0.19149379f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11742856f, -0.15423307f, 0.40716317f, 0.13225882f, -0.11508185f, -0.12030061f, 0.50150675f, 0.05994482f, 
    0.09346400f, 0.30793568f, -0.14195371f, 0.35468355f, -0.09276260f, 0.19559087f, -0.29855630f, 0.13670848f, 
    -0.08220039f, -0.12193289f, 0.00763272f, -0.11870287f, 0.08242974f, 0.14181350f, 0.16848554f, 0.26196563f, 
    -0.42079177f, -0.22025193f, 0.00689322f, 0.01619766f, -0.11960575f, -0.16841015f, 0.17872263f, 0.16866791f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14832827f, 0.00247881f, -0.60760307f, -0.13727796f, -0.01698043f, -0.19108462f, -0.53671992f, 0.18773897f, 
    -0.57990438f, -0.30360103f, -0.13697828f, 0.06678610f, -0.03092708f, -0.08588360f, 0.54697710f, 0.01483531f, 
    0.16692512f, -0.04959871f, 0.35320044f, -0.04032966f, 0.25033793f, 0.16080609f, 0.09626484f, 0.16618484f, 
    0.27410266f, 0.17192359f, -0.54805148f, -0.00102558f, -0.18868315f, -0.10620949f, -0.03746768f, -0.71491522f, 
    0.08504007f, 0.06593288f, -0.12215786f, -0.02469650f, -0.13892794f, -0.08652488f, -0.24598084f, -0.01612904f, 
    0.35290787f, -0.27812302f, 0.15858933f, -0.26833498f, -0.02323875f, 0.69505203f, -1.19588053f, 0.26791233f, 
    -0.00161072f, 0.01580138f, 0.05140883f, 0.07202964f, 0.09362190f, 0.13013735f, -0.00199305f, 0.29743189f, 
    -0.49527255f, -0.06672530f, -0.23655820f, -0.37883431f, -0.08524040f, -0.12593386f, 0.34837699f, 0.18739748f, 
    -0.11637911f, 0.02910566f, -0.00314315f, 0.07350962f, -0.19058284f, -0.06728638f, 0.55897576f, -1.09023023f, 
    0.00968719f, 0.18246917f, 0.13818499f, 0.04321113f, 0.07722204f, -0.36292464f, -0.71769309f, 0.11777192f, 
    0.15242080f, 0.10231392f, -0.14349756f, 0.00614809f, -0.11421991f, 0.07919338f, 0.08779786f, 0.58680713f, 
    -0.76115537f, -0.40526462f, -0.28763014f, 0.11486921f, 0.11176382f, 0.01351175f, -0.29786143f, -0.05401243f, 
    0.23908059f, 0.04153922f, 0.04148754f, 0.09182034f, 0.00990279f, 0.03532172f, 0.26736856f, 0.33145535f, 
    -0.41719890f, 0.02255799f, 0.17282523f, 0.04423290f, 0.09401717f, -0.11665703f, -0.61443996f, -1.13092279f, 
    -0.03659385f, -0.15599483f, -0.26264942f, -0.08490151f, -0.22671199f, -0.23864777f, 0.11746261f, 0.26241297f, 
    0.26025110f, 0.28728309f, -0.39600423f, 0.16044046f, 0.04861635f, -0.09286834f, 0.15411726f, -0.37077159f, 
    -0.00832669f, 0.07977300f, -0.26950112f, -0.01643780f, -0.05288506f, 0.05296751f, -0.35838982f, 0.21680516f, 
    -0.07582281f, -0.01465751f, 0.03239872f, 0.23911831f, 0.15134336f, -0.92086476f, 0.06423806f, 0.31946191f, 
    -0.05828732f, 0.12856698f, 0.15315816f, -0.16089734f, 0.14850706f, -0.22926845f, 0.07335902f, 0.06778330f, 
    0.13187687f, -0.15009917f, -0.16202602f, 0.10825391f, 0.18285634f, -0.11196492f, -0.13015783f, 0.04692609f, 
    -0.12328923f, -0.02038196f, 0.16695474f, -0.08311088f, 0.05946871f, 0.01528730f, 0.14979164f, 0.13930872f, 
    -0.59530705f, -0.12974255f, -0.12024552f, 0.11371626f, 0.15964285f, 0.34000170f, -0.13172694f, 0.33942971f, 
    0.05570944f, 0.00521986f, 0.08886589f, -0.04556205f, 0.00533123f, 0.00443712f, -0.12658481f, 0.05824865f, 
    -0.17499945f, 0.05059329f, 0.15287451f, -0.29907998f, -0.50412619f, -0.00004692f, -0.03256308f, 0.18053165f, 
    0.13641506f, -0.14350061f, 0.21026991f, -0.04082949f, -0.15739107f, -0.04747951f, -0.85677999f, -1.20683742f, 
    0.30780646f, 0.40213716f, 0.13471019f, 0.25783119f, 0.06947286f, 0.08700874f, -0.04046327f, -0.33751291f, 
    -0.04053060f, 0.12896129f, -0.67527127f, 0.10072447f, -0.20979135f, 0.43162331f, -0.03435621f, -0.21078318f, 
    -1.00711453f, -0.39650345f, -0.48595217f, -0.44967246f, 0.34012374f, -0.11633249f, -0.55229253f, -0.06078545f, 
    0.36399806f, -0.13445282f, -0.33622789f, -0.07979544f, -0.00578765f, -0.11822071f, -0.22814934f, 0.34978715f, 
    0.35647136f, -0.54172027f, -0.04067476f, -1.12868142f, -0.14694381f, -0.20653413f, -0.28109938f, 0.09745275f, 
    -0.01954119f, -0.05448036f, -0.51234138f, 0.09301987f, 0.17343836f, 0.07037436f, -0.07415919f, 0.12802996f, 
    0.81346399f, -0.39958736f, -0.08768999f, -0.63341421f, 0.33234251f, 0.02324847f, -0.07049257f, -0.13131668f, 
    -0.02251834f, -0.17938526f, 0.17533562f, -0.12553853f, -0.25166574f, -0.13784529f, 0.11963154f, 0.34062845f, 
    -0.11784895f, -0.08569804f, -0.06801515f, -1.27944863f, -0.15547310f, -0.33712137f, -0.46919754f, -0.33789426f, 
    0.12076534f, -0.07984781f, 0.07870265f, -0.04663439f, 0.23129529f, 0.16552114f, -0.16550004f, -0.86796254f, 
    -0.07773563f, 0.31467199f, 0.45636347f, -0.53018570f, -0.62581956f, -0.08853164f, 0.03092038f, 0.24995518f, 
    0.05126192f, 0.10499451f, 0.16179988f, 0.11172133f, 0.06473780f, 0.11291519f, -0.34043565f, 0.27391127f, 
    0.22924954f, -0.01254153f, -0.13935468f, 0.51439762f, -0.15094124f, -0.34464604f, -1.66245604f, -0.05488753f, 
    -0.12912193f, 0.12013161f, 0.24114169f, 0.10717993f, 0.43692744f, -0.24475297f, 0.15133835f, -0.30210820f, 
    -0.25243691f, -1.23492038f, -0.46666783f, 0.31510440f, 0.27215359f, 0.16286796f, -0.39955291f, -0.08079670f, 
    -0.90910506f, 0.00773163f, -0.21938840f, 0.07281642f, -0.04873870f, -0.14713670f, 0.35132891f, -0.14618321f, 
    0.21463580f, 0.25843042f, -0.00457896f, -0.52252239f, -0.09556080f, -0.23656090f, -0.15780631f, -0.14649947f, 
    0.01323019f, 0.00400316f, -0.12919244f, 0.07269425f, 0.18502693f, -0.57704926f, 0.09960134f, -0.01279536f, 
    -0.77502275f, 0.23484679f, 0.58478719f, 0.25638476f, 0.15051813f, 0.10986339f, 0.02588701f, -0.13002412f, 
    -0.50815308f, 0.01278919f, 0.35299474f, -0.13762268f, -0.03877611f, 0.09325199f, -0.04264533f, -0.02677169f, 
    -0.02602503f, 0.33990756f, -0.10664514f, -0.16866294f, -0.14471173f, -0.48309448f, -0.03693346f, 0.01746994f, 
    0.03616086f, 0.01269156f, -0.41863430f, -0.00479388f, -0.89211988f, 0.11866821f, -0.04093217f, -0.94719779f, 
    0.04064627f, -0.34385994f, -0.03122223f, 0.38129598f, -0.44456434f, 0.14255427f, 0.11512836f, 0.46656293f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16468212f, 0.00594493f, 0.17386119f, -0.19479167f, -0.35222673f, -0.19930944f, 0.46422154f, -0.33193219f, 
    0.15048482f, 0.03821112f, 0.04712044f, -0.08941650f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
