#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.18761951f, -0.38852218f, 0.93837357f, -1.35744977f, -0.10540546f, -0.62536055f, 0.54511440f, -0.10227693f, 
    -0.71500945f, -0.40100068f, -1.29003263f, -0.75267041f, 0.81175470f, -0.07939195f, 0.77538204f, -0.69801044f, 
    0.28523234f, -0.70868051f, -0.63120389f, -0.95516944f, -0.71727377f, 0.69117182f, 1.05528128f, -0.38193023f, 
    -0.31187347f, -0.61877799f, -0.76525289f, -1.41238952f, -0.09999789f, -0.29218996f, -0.14752354f, 0.28066331f, 
    0.03982922f, -0.04499023f, 0.09308995f, 1.23166823f, -0.90192425f, 1.61306751f, -0.11912828f, 0.56206900f, 
    0.03959691f, -0.85580713f, -0.07823756f, -0.43687874f, -0.07562979f, -1.10198784f, 0.38538602f, 0.37696868f, 
    -0.91307139f, -0.71302319f, 0.54141116f, 0.11247737f, 0.49364659f, 0.44932160f, 1.74159503f, -1.32622433f, 
    -0.41739881f, 0.45580170f, -0.98894566f, -0.12613350f, -0.12540509f, -0.27416492f, 0.59224653f, -1.08854592f, 
    -0.29924926f, -1.01142120f, -0.22613356f, -0.97016233f, 0.05489713f, -0.72240090f, -0.49859300f, -0.76826608f, 
    1.34750521f, 0.48032951f, 0.63511986f, 0.85364664f, 0.95116144f, -0.12117922f, 0.09219485f, -0.15968592f, 
    -0.03663918f, -0.99366778f, -0.77382213f, -0.95814848f, 0.11307685f, 0.86258405f, 0.77620488f, 0.34545189f, 
    -0.10879365f, 0.36940411f, -1.19609475f, -0.04702852f, -0.10473982f, -0.09381287f, 1.04705656f, 0.95208097f, 
    -0.01795801f, -0.68019640f, -0.22915934f, 1.08490586f, 1.03873909f, 0.91570705f, -0.58384633f, -0.81307185f, 
    -0.08825254f, -0.22824611f, -0.40603659f, -0.50249749f, 0.08790535f, -0.26280546f, 1.29350019f, 0.65327889f, 
    -0.85674125f, -0.60341197f, -0.51258069f, -0.68916148f, 0.24770655f, 1.32640684f, -0.05916565f, 0.89179200f, 
    0.58919650f, -0.50204569f, 0.36123890f, 0.56395888f, 0.57942963f, -0.33033779f, 1.12221062f, 0.37325171f, 
    0.41797474f, -1.40404582f, 1.08982694f, -0.65703559f, -0.14848058f, -0.10260442f, 0.12270819f, 0.49963564f, 
    0.83016580f, -0.91654032f, 1.20317793f, 0.88700718f, -0.71088153f, 0.37152347f, 0.50203228f, -0.13084906f, 
    -1.70833921f, 1.17431605f, -1.14769411f, 0.10076269f, 0.66673571f, -0.50694650f, 0.06834234f, 0.05427125f, 
    0.04634614f, -0.50612229f, 0.87794781f, 0.03946954f, 0.82225370f, 1.09377241f, 0.26832896f, 0.09080903f, 
    -0.15427938f, -0.05243745f, 0.15817612f, -1.09707165f, -0.90413260f, -0.44110614f, -0.97983646f, -0.40627402f, 
    -0.76336187f, 0.39145276f, 0.02490275f, -0.16879952f, -0.12621161f, 0.66142774f, 1.21991456f, -0.00297046f, 
    1.10334969f, 0.69155014f, -0.09734108f, 0.68854374f, -1.20073009f, -0.77883434f, -1.25920475f, -0.41551164f, 
    -0.13151865f, -0.18516031f, 0.25889808f, 0.06229602f, -0.06409392f, -0.44509047f, -1.41066504f, 0.00063388f, 
    -1.29048860f, -0.48845661f, -0.04652325f, 0.02574713f, 0.49034303f, 0.06675044f, 0.96957195f, 0.61436719f, 
    0.39161712f, -1.06707215f, -0.77049428f, -0.42595610f, 0.69091088f, 0.35349426f, 0.09243353f, 0.17515539f, 
    0.95023477f, 1.15761459f, 0.54121649f, 0.71990287f, -0.48225600f, -0.13695757f, 0.04160861f, -0.07213524f, 
    0.33992204f, 0.65265077f, -0.17529336f, 0.39328435f, 0.77987492f, 0.91531527f, 0.17869969f, -1.05063784f, 
    -0.87504524f, -1.11909878f, -1.28097677f, -0.60629946f, 0.99242514f, 0.45529237f, -0.11225554f, 0.11146326f, 
    -0.17923465f, 0.29519144f, 1.21236086f, 0.86713898f, 1.11120868f, -0.10541607f, 0.46660054f, -0.06962834f, 
    0.17157577f, 0.54649621f, 0.30782080f, -0.56480151f, -0.34441879f, 0.99549729f, 0.23946019f, -0.84984434f, 
    -0.83924603f, 0.58579832f, 0.81126404f, -0.14305887f, 0.55715632f, 0.93026114f, -0.55734009f, -0.21594818f, 
    -1.53092003f, -0.70756441f, 0.22208475f, 0.10159925f, 0.58452606f, 0.44741064f, -0.62452024f, -0.69895482f, 
    -0.97991282f, -0.63894027f, -1.37380540f, 0.27553123f, 0.34327573f, -0.25825757f, -1.40317905f, 0.36472437f, 
    -0.30686766f, 0.43878940f, -1.26727617f, 0.44616684f, 0.30172348f, -0.60820222f, 0.07726787f, -1.22297251f, 
    -0.02562553f, 1.04922485f, 1.03469491f, 1.17508185f, -0.23213644f, -0.46197191f, 0.20989960f, 0.38988668f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28792021f, -0.02693032f, -0.09679690f, -0.24879469f, 0.05471573f, 0.42278168f, -0.26832741f, 0.24869254f, 
    0.09988975f, 0.03229826f, -0.21057822f, 0.16407588f, 0.37940693f, 0.17132042f, -0.16790381f, 0.07729934f, 
    0.39372006f, -0.48370132f, -0.24895702f, -0.16107021f, -0.01251676f, 0.41753989f, 0.03839094f, 0.18798545f, 
    0.53866643f, 0.17661759f, 0.18464352f, 0.12057972f, -0.27729586f, -0.01012804f, 0.24741767f, -0.22590166f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.18443307f, -0.00074269f, -0.44335529f, 0.26643518f, 0.05961250f, -0.22828484f, -0.04812348f, 0.28715724f, 
    0.09760585f, -0.15315510f, -0.22150946f, 0.32313138f, 0.00030012f, 0.12413740f, 0.04877943f, -0.18618377f, 
    -0.18000916f, 0.12509945f, -0.16544594f, -0.44979471f, 0.41323164f, -0.03501333f, 0.06271751f, 0.05356510f, 
    -0.26670921f, 0.20255612f, 0.22091947f, 0.24877502f, 0.32613418f, 0.00345870f, -0.10022727f, 0.01090630f, 
    -0.00067263f, -0.27235916f, -0.21932510f, -0.05638515f, -0.29884923f, -0.10512105f, -0.38352680f, 0.07448251f, 
    -0.03111000f, -0.03542555f, 0.07331491f, 0.03305121f, 0.14462249f, -0.25846294f, 0.19598418f, -0.26591635f, 
    0.10047349f, -0.01465441f, 0.10419114f, 0.30464664f, -0.07165003f, -0.21284184f, 0.72149485f, 0.18822363f, 
    0.33613482f, -0.23866396f, -0.23406540f, -0.12638223f, 0.02271157f, 0.16251169f, -0.09543193f, -0.15892546f, 
    -0.12266471f, 0.18308267f, 0.15534820f, 0.00120398f, 0.05682265f, 0.13308130f, 0.07756971f, 0.16250136f, 
    0.56025922f, -0.10673273f, 0.06166647f, 0.10958207f, 0.25048897f, -0.07634393f, -0.00933528f, -0.03235424f, 
    0.05973287f, 0.00466959f, -0.34592071f, 0.62696326f, 0.04249385f, 0.01885384f, 0.02245207f, -0.08654954f, 
    -0.01107837f, 0.09350471f, -0.46594253f, -0.53445262f, -0.10996310f, 0.03396546f, 0.13553783f, -0.02538146f, 
    -0.42802942f, 0.19839512f, 0.11979479f, 0.13206382f, 0.55481321f, -0.01591577f, 0.02286776f, -0.24229339f, 
    -0.16062810f, 0.18862785f, 0.07327332f, -0.03582638f, 0.33343542f, 0.18174444f, -0.74026096f, -0.39277509f, 
    -0.03022163f, -0.08322706f, 0.16299646f, 0.08423553f, 0.04175742f, 0.14484227f, -0.11176394f, -0.06926684f, 
    0.22084798f, 0.24360912f, -0.02089616f, -0.09479669f, 0.10093736f, -0.34274817f, 0.47098216f, -0.21676378f, 
    -0.11867112f, 0.13035570f, -0.20464921f, -0.02596442f, 0.25701979f, -0.10486754f, -0.19763999f, 0.18354641f, 
    0.14963725f, -0.20097815f, -0.01992775f, 0.02836229f, -0.04577578f, 0.05687293f, -0.08610318f, 0.01474150f, 
    -0.67752367f, -0.07947116f, -0.02209789f, -0.00839017f, 0.08811238f, 0.13144282f, 0.02591285f, 0.07573938f, 
    -0.03574637f, -0.13187380f, -0.10054611f, 0.38205665f, 0.26183048f, 0.08553368f, 0.28494179f, -0.23761980f, 
    0.13013023f, -0.02316398f, 0.37310499f, 0.21592537f, 0.21089569f, 0.22796421f, -0.21679497f, -0.03975479f, 
    0.21074578f, 0.09633058f, 0.07716868f, 0.30372295f, -0.22353280f, -0.03819587f, 0.11768407f, 0.22026438f, 
    0.02178578f, -0.18126817f, -0.28425714f, -0.06224475f, 0.28704530f, -0.13211089f, 0.53955525f, 0.20334055f, 
    0.03793892f, -0.07580475f, -0.10657833f, 0.19454397f, -0.05609871f, -0.12794231f, 0.03876467f, 0.10825288f, 
    0.08679973f, 0.05703855f, 0.04393378f, -0.13840605f, -0.24559386f, -0.06559614f, 0.09165935f, 0.32290536f, 
    -0.43552554f, 0.06423611f, -0.07805815f, -0.07026152f, 0.09670686f, 0.19153738f, -0.27649218f, 0.44633120f, 
    0.12019791f, -0.54729497f, 0.01441282f, -0.14775571f, 0.12597810f, -0.03308792f, 0.00942887f, 0.13214403f, 
    -0.25062165f, -0.17426248f, 0.34056547f, 0.05076275f, 0.16132796f, 0.17541842f, -0.02521426f, 0.09254643f, 
    0.25306895f, 0.26814103f, -0.54877907f, 0.68774390f, 0.02590925f, 0.16798154f, 0.01982566f, -0.06971014f, 
    -0.04987803f, 0.12458933f, 0.37825710f, -0.00064400f, -0.01452851f, 0.16592899f, -0.14289676f, 0.06278743f, 
    0.20825860f, -0.05775081f, -0.07874972f, 0.01550865f, -0.06649635f, -0.44418436f, -0.21694186f, -0.03175095f, 
    -0.27620757f, 0.02639023f, -0.03638000f, -0.12713283f, -0.12842868f, 0.09002090f, -0.39691198f, 0.10641246f, 
    -0.24196365f, -0.15979680f, 0.01425228f, 0.17931673f, 0.03522527f, 0.35928461f, -0.35792536f, -0.47680959f, 
    0.50829965f, -0.10432471f, -0.00354690f, -0.07390925f, -0.12429690f, -0.09249966f, 0.18360075f, -0.41161841f, 
    0.15868790f, 0.03800439f, 0.04077984f, 0.09098917f, -0.25690156f, -0.00708686f, -0.00208960f, 0.17822814f, 
    -0.10831399f, -0.18475808f, 0.09830479f, -0.01411664f, -0.03968638f, 0.00015970f, 0.25066605f, -0.01149834f, 
    0.29303002f, 0.32627532f, -0.17841151f, 0.22057581f, 0.03188328f, 0.02237904f, -0.16246332f, 0.13890728f, 
    -0.14323907f, 0.38913390f, 0.08926427f, 0.12222504f, 0.01333141f, -0.08466731f, -0.24067706f, 0.06014713f, 
    0.14508770f, 0.18837415f, 0.47490054f, -0.01411325f, -0.05743094f, -0.08252944f, 0.06285859f, 0.00509243f, 
    -0.23136707f, 0.00380741f, 0.00960622f, -0.05982491f, -0.16588452f, -0.25153214f, 0.13853385f, -0.21139430f, 
    -0.10347350f, -0.02940328f, 0.09104655f, -0.07815761f, -0.30194435f, -0.37702572f, -0.02574119f, 0.16513780f, 
    -0.03785326f, -0.00050982f, -0.13637809f, -0.18157573f, 0.00437113f, -0.24510360f, -0.07626072f, -0.06938583f, 
    -0.14665984f, 0.15556008f, 0.15532750f, -0.08819033f, -0.03426540f, 0.15370311f, -0.03692419f, -0.35434228f, 
    0.11054539f, -0.24758659f, -0.09327166f, 0.12538439f, 0.22473677f, -0.11343376f, 0.12566586f, 0.36759633f, 
    0.18450972f, -0.01758300f, 0.33312750f, 0.10001320f, -0.11881977f, -0.00073681f, 0.13761966f, -0.16887142f, 
    -0.09156919f, -0.04167784f, -0.16459964f, 0.09572674f, 0.19155359f, -0.25739619f, 0.29815742f, 0.00567819f, 
    0.03135205f, 0.06807663f, 0.19671102f, 0.13863543f, -0.03281690f, -0.14033630f, -0.09081776f, 0.07626092f, 
    0.21511804f, 0.03186481f, -0.05818883f, -0.03821669f, -0.06804162f, 0.09973738f, -0.02141804f, -0.06413416f, 
    0.27650005f, 0.09146462f, -0.06365360f, 0.09169914f, -0.18636209f, -0.17148055f, 0.16556533f, 0.04421384f, 
    0.15639932f, 0.01505943f, -0.03820885f, 0.01206142f, -0.55936527f, 0.02447120f, 0.14172480f, 0.09629998f, 
    0.10518333f, 0.00800327f, 0.14902821f, -0.14633429f, 0.00223391f, -0.03167422f, -0.39730978f, -0.00356391f, 
    0.01439609f, -0.11472470f, -0.01474006f, 0.25968140f, -0.00887219f, 0.06397590f, -0.76908064f, -0.20001101f, 
    0.18417150f, 0.09967613f, -0.10901113f, 0.41802135f, -0.03202748f, -0.06857248f, 0.04824338f, 0.06311927f, 
    0.35897645f, -0.21882990f, -0.08753239f, -0.09461919f, 0.26798627f, 0.00932316f, 0.24765785f, 0.07884105f, 
    -0.31304133f, -0.12527329f, 0.09527014f, 0.09823933f, 0.06261136f, 0.07627353f, -0.10024300f, -0.12110808f, 
    -0.11261209f, -0.12096337f, 0.03064962f, -0.07152338f, 0.22952548f, 0.09317201f, -0.02599128f, 0.01483552f, 
    0.07263755f, 0.01580991f, 0.56448454f, 0.15080996f, -0.05529235f, -0.06819672f, -0.03047294f, 0.10947058f, 
    -0.24005963f, 0.31543496f, -0.31528077f, -0.13528754f, -0.06548626f, 0.11751588f, 0.45828164f, 0.22162393f, 
    0.18753485f, 0.01442264f, 0.08666462f, -0.13743712f, -0.10716109f, 0.23991045f, 0.06471740f, 0.09510142f, 
    -0.06937530f, 0.01736326f, 0.11490324f, 0.10939376f, -0.15894946f, 0.22519936f, 0.33996645f, -0.31365681f, 
    0.11246456f, 0.04122486f, 0.06331135f, 0.07109127f, 0.13247095f, -0.18970934f, 0.12091140f, -0.18042345f, 
    -0.02022972f, -0.20039248f, -0.08609157f, -0.12830399f, -0.13201812f, 0.07564256f, 0.04081587f, -0.23224698f, 
    0.04135943f, -0.45910159f, 0.12985440f, 0.01865734f, -0.01997932f, -0.01445086f, 0.03359178f, 0.08216123f, 
    -0.27351230f, -0.17672637f, -0.31283483f, 0.23513325f, 0.09103964f, -0.06478352f, -0.10824531f, -0.08101188f, 
    0.13719782f, 0.17552844f, 0.25008756f, -0.22218148f, -0.22918206f, 0.11239690f, -0.05691700f, -0.01819060f, 
    0.12998956f, 0.16577184f, -0.28536645f, -0.32679966f, 0.04000980f, 0.16492315f, 0.09039403f, 0.02532320f, 
    0.07268886f, 0.08662552f, 0.15734005f, -0.04786761f, -0.00486089f, 0.00563773f, 0.22503823f, -0.09776648f, 
    -0.02074255f, -0.06608690f, 0.05495872f, -0.00982290f, 0.38521421f, 0.02105845f, 0.11749232f, 0.17585111f, 
    -0.10526417f, 0.04855425f, 0.04346308f, 0.05866244f, 0.02082797f, 0.15652941f, -0.17511065f, 0.13195382f, 
    -0.16604930f, -0.00797403f, 0.01888800f, -0.12956712f, -0.15512677f, -0.05211196f, -0.21858718f, -0.14128262f, 
    0.02034384f, -0.14214031f, 0.12752783f, 0.16059896f, 0.03360639f, 0.30788919f, -0.08363053f, -0.26880178f, 
    0.03842628f, -0.41146645f, -0.04264257f, -0.06377536f, -0.15328382f, 0.11361725f, 0.11792851f, 0.11348286f, 
    0.28339240f, 0.29142910f, 0.07745022f, 0.14900969f, 0.02172296f, 0.05023808f, 0.02397943f, -0.04950712f, 
    0.21433952f, 0.09705906f, 0.39607054f, 0.16310242f, 0.10317001f, -0.16987184f, 0.12242382f, -0.38802633f, 
    0.20265971f, -0.00763988f, -0.18140562f, -0.07332516f, 0.44984314f, -0.22327860f, -0.14050005f, 0.07959094f, 
    -0.20632732f, 0.19760464f, 0.09207741f, 0.09732907f, 0.25454164f, 0.04620852f, -0.51326573f, -0.13780783f, 
    0.13455372f, 0.25183892f, 0.06296757f, -0.28493014f, 0.32179171f, -0.28259137f, -0.33348829f, -0.20891097f, 
    -0.06860304f, 0.06801823f, 0.00074166f, 0.12342657f, -0.14992918f, -0.18812540f, 0.19734883f, -0.07434117f, 
    -0.14069787f, -0.02867780f, 0.09712517f, 0.15103692f, -0.08589131f, -0.17591614f, 0.03348203f, 0.23465759f, 
    -0.18795861f, -0.04717817f, -0.21503147f, 0.01209632f, -0.07623054f, 0.16580530f, -0.09787905f, -0.50281447f, 
    -0.12535587f, 0.12149985f, -0.26787812f, 0.27137303f, 0.07053982f, -0.07788865f, -0.15360501f, 0.15968710f, 
    -0.60818434f, 0.06235985f, 0.00073662f, 0.17698357f, 0.09024508f, 0.20579323f, 0.08910598f, 0.15064284f, 
    -0.02107549f, 0.25540966f, 0.25150326f, 0.10541043f, -0.35164559f, -0.01430875f, 0.02073793f, -0.07561880f, 
    0.20182265f, -0.04355449f, 0.03014936f, 0.15570575f, 0.08887826f, -0.45208469f, 0.11596356f, 0.27331030f, 
    0.03370065f, 0.07657363f, -0.14311332f, 0.44128379f, 0.34128177f, -0.01734538f, 0.10587534f, -0.08546586f, 
    0.06450038f, 0.43041965f, -0.09478565f, 0.17503792f, -0.31904089f, -0.10799333f, 0.09535817f, -0.12952597f, 
    0.21921054f, 0.13416483f, -0.17081675f, 0.02399517f, 0.04897310f, -0.35923514f, -0.46215415f, -0.28467786f, 
    0.32052317f, -0.03170642f, 0.08366484f, -0.12727270f, 0.16930626f, 0.09796546f, -0.04657191f, 0.38558018f, 
    -0.10681114f, 0.27855989f, 0.20686489f, 0.02545558f, 0.15629065f, -0.14681676f, 0.09634332f, 0.16082063f, 
    -0.05199188f, -0.02779200f, -0.28236410f, -0.12353598f, -0.08652742f, -0.01203526f, -0.04066800f, -0.07880752f, 
    0.19723986f, -0.21170221f, -0.27291059f, -0.51685333f, -0.10136495f, 0.07486556f, 0.18015841f, 0.04493776f, 
    -0.24766292f, 0.28314808f, 0.27579758f, 0.06338006f, -0.48826995f, 0.10831759f, 0.38898072f, -0.18725626f, 
    0.08663111f, -0.00496704f, 0.29633811f, -0.16034229f, -0.16549075f, 0.00691881f, 0.30788323f, 0.00195848f, 
    0.28125313f, 0.19144407f, 0.09390630f, -0.22110143f, -0.16805239f, -0.01827583f, 0.19645688f, 0.04888946f, 
    0.05229517f, -0.38770959f, -0.22689590f, -0.01361862f, 0.09901979f, -0.07946100f, -0.16585232f, -0.11630992f, 
    -0.08154976f, 0.00987996f, 0.05336072f, 0.21489485f, 0.00035574f, 0.38939273f, 0.11216976f, -0.22029820f, 
    -0.02929320f, 0.13138835f, -0.00250123f, 0.09255467f, -0.03497140f, -0.06501508f, 0.59482807f, 0.20103326f, 
    -0.06744408f, 0.01390149f, -0.02782054f, -0.10855906f, 0.10385914f, 0.15097688f, 0.03612485f, 0.37011695f, 
    -0.20568044f, -0.03971414f, -0.05474535f, 0.20645162f, 0.03749800f, -0.26420775f, -0.11881393f, -0.04138082f, 
    -0.08445416f, 0.06376014f, -0.11948820f, -0.04348921f, 0.13331531f, 0.07942929f, 0.11532112f, -0.07436306f, 
    -0.27551770f, 0.36291063f, 0.15896219f, 0.18713413f, -0.19074343f, -0.50531596f, -0.04152624f, -0.09138436f, 
    0.00225991f, -0.11339267f, 0.08342021f, -0.06440822f, -0.07621647f, -0.06177280f, 0.15002954f, 0.21288146f, 
    0.16974603f, -0.05164514f, -0.14242661f, 0.38035485f, -0.11480572f, 0.17009854f, 0.15525386f, -0.04478833f, 
    0.10006578f, -0.10168464f, 0.08257610f, -0.27018011f, 0.61830223f, 0.21385276f, -0.04798676f, 0.08565385f, 
    -0.08510421f, 0.03037542f, 0.20162609f, 0.34193403f, -0.12704293f, 0.29051724f, -0.05514462f, -0.10456853f, 
    0.00946431f, 0.02076613f, -0.31984720f, -0.16463225f, -0.30185196f, 0.03030611f, -0.60996550f, -0.05093387f, 
    -0.12716696f, -0.04899008f, 0.17756924f, 0.07629371f, -0.06351591f, -0.06335567f, -0.07702077f, 0.21523027f, 
    0.16376008f, 0.14088069f, -0.20936623f, 0.26446941f, -0.00929806f, 0.23820385f, 0.11048944f, -0.00257869f, 
    0.01413481f, -0.00243406f, 0.00789546f, -0.06382813f, -0.02177558f, -0.02087291f, 0.01101215f, 0.02728536f, 
    -0.01353405f, 0.02019007f, -0.01657099f, -0.06013116f, -0.05558401f, -0.06194085f, 0.03143076f, 0.01371049f, 
    0.05142548f, -0.01895495f, -0.03300893f, -0.00087595f, -0.05097720f, 0.01233069f, 0.05029520f, -0.00117891f, 
    0.04450360f, 0.02790853f, 0.04213979f, -0.00510068f, 0.04014019f, 0.03666567f, -0.00000449f, 0.00795496f, 
    0.02041821f, 0.01797333f, 0.02321658f, -0.03076514f, -0.05773934f, -0.03799439f, -0.00276209f, 0.04920216f, 
    -0.00284037f, -0.04276313f, 0.04908315f, -0.05408796f, -0.01854303f, 0.00851953f, 0.04261727f, -0.05919547f, 
    -0.05888932f, -0.06364378f, 0.02776126f, -0.04990992f, 0.00854179f, 0.00532350f, -0.04597745f, -0.03872817f, 
    0.01314890f, 0.03362995f, 0.05108201f, 0.02237280f, 0.01713766f, -0.02168390f, -0.01590684f, -0.05015903f, 
    0.01542014f, 0.04045320f, -0.00265886f, -0.02686613f, -0.01975448f, -0.00621777f, -0.06282271f, -0.05220040f, 
    0.00872406f, 0.05090499f, 0.02193418f, -0.03709776f, 0.01744094f, 0.04554529f, -0.03866573f, -0.04146204f, 
    -0.05039025f, -0.02630218f, -0.06036739f, -0.04287842f, 0.01811428f, 0.02509646f, -0.00654659f, 0.01552844f, 
    -0.05902745f, -0.04229747f, -0.06097484f, -0.00896046f, 0.00702378f, -0.00230372f, 0.01918750f, 0.01548896f, 
    -0.04039665f, -0.01963555f, -0.02470598f, -0.01421844f, -0.00308063f, 0.02029015f, -0.06040404f, 0.01094417f, 
    0.01618670f, -0.03816224f, -0.00705906f, 0.01265302f, -0.02539970f, -0.03169072f, -0.01805372f, -0.03121739f, 
    -0.00218713f, 0.01273793f, 0.04011383f, -0.05587512f, -0.02682465f, 0.04326059f, 0.05084181f, 0.00648549f, 
    -0.00808372f, -0.04738003f, -0.04113377f, 0.05028961f, -0.03299334f, -0.06162245f, -0.04381300f, -0.02235217f, 
    0.04593442f, -0.02735590f, 0.00809836f, 0.01824459f, 0.00098330f, 0.01795572f, 0.03237109f, 0.02892443f, 
    0.02895022f, -0.02764693f, 0.03855691f, -0.00225479f, 0.02773518f, 0.01996096f, -0.06319612f, 0.01405602f, 
    0.03917349f, -0.05566639f, -0.03191483f, -0.03832485f, -0.03250434f, -0.03608424f, -0.00585539f, -0.00450074f, 
    0.04441063f, -0.05029887f, 0.04512238f, -0.04734937f, -0.05876507f, -0.03409891f, -0.06399648f, -0.03084010f, 
    -0.00572590f, -0.00391562f, -0.05822315f, 0.02139766f, -0.04142325f, 0.04579820f, 0.03136447f, -0.06397986f, 
    -0.03968610f, -0.04978301f, 0.04598121f, 0.00337723f, -0.03959116f, -0.01626491f, 0.03985776f, -0.02285967f, 
    0.01667936f, 0.03203590f, 0.03284148f, 0.02226972f, -0.05947413f, 0.02068645f, -0.04549309f, -0.01924431f, 
    0.04373481f, 0.04459571f, -0.04669790f, -0.04823574f, 0.05054997f, -0.04057021f, -0.02264898f, -0.00643379f, 
    -0.01933360f, 0.04333317f, -0.04462218f, -0.04796265f, 0.00842318f, -0.00987985f, -0.03894548f, 0.00005168f, 
    0.00189684f, -0.04963767f, -0.03517925f, -0.05450623f, 0.03098479f, -0.00425134f, 0.02071611f, -0.05326070f, 
    0.04806060f, -0.04849734f, 0.02239287f, 0.02323458f, -0.04565378f, -0.05583126f, 0.02543881f, -0.00716289f, 
    0.05002820f, 0.00097538f, 0.00346454f, 0.01305444f, 0.00715874f, -0.00557810f, 0.03815601f, 0.00536525f, 
    0.00786997f, 0.00942141f, 0.01956190f, -0.02417795f, -0.05922485f, -0.04939792f, -0.05648265f, -0.02752483f, 
    0.03890521f, 0.01707197f, -0.04900102f, -0.04936058f, 0.04217618f, 0.04676479f, -0.06393831f, -0.03465110f, 
    -0.01416024f, 0.03626632f, 0.02002369f, -0.05467388f, -0.00674568f, 0.03376894f, 0.01288120f, -0.05668455f, 
    0.00009793f, -0.03987337f, 0.04088871f, 0.03144635f, -0.00983988f, 0.01630416f, -0.05299895f, -0.03704360f, 
    -0.04852124f, -0.00925923f, -0.01868677f, -0.03902446f, -0.01703005f, -0.00481051f, -0.06001484f, -0.00214118f, 
    -0.06128377f, -0.05146442f, -0.01465184f, -0.04944163f, -0.03314066f, 0.00233885f, 0.02307600f, 0.01926198f, 
    -0.00217762f, -0.00999112f, -0.03291547f, -0.06116755f, 0.02515501f, -0.00102697f, 0.03376721f, 0.02032911f, 
    0.01365083f, 0.01378769f, 0.03548701f, -0.04265005f, -0.02626546f, 0.01399988f, 0.02419390f, 0.00771957f, 
    0.01327129f, -0.05489314f, -0.03038222f, 0.02235360f, 0.00983943f, -0.06388013f, -0.03813773f, -0.03196173f, 
    -0.04906840f, 0.02278227f, 0.05338781f, -0.05997127f, -0.03208292f, -0.04072773f, -0.00791103f, -0.02840360f, 
    -0.01277301f, -0.00153223f, -0.04751832f, 0.01053905f, -0.02451269f, 0.02090988f, -0.05480104f, 0.04533083f, 
    0.03916277f, -0.05886216f, -0.03403110f, -0.01903245f, -0.03912883f, -0.06073846f, 0.05523581f, -0.04165729f, 
    0.00126309f, -0.03344833f, -0.00502946f, -0.04986181f, -0.04593319f, -0.01607595f, -0.01271519f, -0.01876906f, 
    0.04252123f, 0.01513882f, -0.02530093f, 0.00077419f, -0.03214369f, -0.05611329f, -0.00855732f, -0.05124236f, 
    0.04458684f, 0.00311501f, -0.04341803f, -0.05586424f, 0.05170651f, -0.04284114f, 0.02391856f, 0.03213916f, 
    -0.03715068f, -0.00201154f, 0.01856763f, -0.02383113f, -0.06535064f, 0.01648034f, -0.00306354f, 0.03068194f, 
    -0.01208688f, -0.02448065f, -0.00531848f, -0.01523367f, 0.01938799f, 0.02196385f, 0.00328326f, -0.00766970f, 
    0.01099019f, -0.04316739f, 0.00735077f, -0.02320997f, 0.01649297f, 0.00962054f, 0.01448439f, 0.06221227f, 
    -0.04912763f, 0.01895037f, -0.02630972f, 0.04153712f, -0.04228446f, -0.01942252f, -0.01501736f, -0.04547962f, 
    0.02019810f, 0.02112878f, 0.05470732f, 0.00040557f, -0.01378625f, 0.00244835f, 0.03454615f, 0.03557760f, 
    0.02665221f, 0.03707135f, 0.04020498f, -0.02291064f, 0.03321051f, 0.02804591f, 0.00021310f, -0.02618141f, 
    -0.02236324f, -0.04759106f, 0.00464809f, -0.01795690f, 0.01900715f, -0.03500571f, -0.03466661f, 0.01585579f, 
    0.02279769f, -0.04288838f, 0.02568724f, 0.00718537f, 0.04345490f, 0.01113639f, -0.00140382f, 0.01391224f, 
    0.00889349f, 0.04872451f, -0.03751980f, -0.04502330f, 0.04857683f, -0.05621460f, 0.01234738f, -0.01637225f, 
    0.02650756f, -0.05189643f, 0.00690302f, -0.04265911f, -0.00550935f, 0.04420536f, 0.02573885f, -0.04475983f, 
    0.00756374f, -0.00283685f, 0.05194769f, -0.05394776f, 0.00309039f, 0.01096469f, -0.04150918f, 0.02959810f, 
    -0.03617950f, 0.01257577f, -0.05590970f, -0.02149528f, 0.00867653f, -0.06466427f, -0.05558366f, -0.00399722f, 
    0.04409393f, 0.04171253f, -0.00575954f, -0.04160603f, -0.00844327f, 0.03510889f, -0.01341213f, -0.04245517f, 
    0.02252115f, -0.04785966f, 0.05477352f, -0.04020022f, -0.00916279f, 0.03900721f, 0.03398312f, -0.02513531f, 
    0.00373838f, -0.00862392f, 0.02942979f, 0.01421781f, 0.05246684f, -0.03318036f, -0.04169187f, 0.04480605f, 
    0.03046871f, -0.01419749f, 0.03512892f, 0.03833933f, -0.02242814f, 0.02277141f, -0.02302764f, -0.05596532f, 
    -0.02991281f, -0.02681305f, -0.05680894f, 0.03153288f, -0.06123650f, -0.05294254f, 0.03215238f, -0.03371666f, 
    0.00807568f, -0.02139370f, 0.00592451f, -0.04802516f, 0.02948531f, 0.00149565f, -0.03347995f, 0.03802856f, 
    -0.05077693f, -0.04999031f, -0.02978700f, 0.04871140f, -0.00357411f, 0.02530879f, -0.05419279f, -0.01603768f, 
    -0.05072043f, -0.01439678f, -0.03845644f, 0.01484179f, -0.05378179f, 0.02636569f, 0.03877188f, 0.01116988f, 
    0.01686018f, 0.01493785f, -0.00601186f, -0.03297682f, -0.02725366f, 0.00825033f, -0.04966246f, 0.05524944f, 
    0.00141301f, 0.01761964f, -0.01776521f, 0.00752782f, -0.03682037f, -0.02872137f, -0.01577917f, 0.04593652f, 
    -0.05135831f, -0.04511097f, -0.01777893f, -0.05127787f, -0.02219366f, -0.02971535f, -0.05878668f, 0.00412504f, 
    -0.04849205f, 0.04684419f, -0.04453252f, -0.00843489f, -0.04608288f, 0.00774414f, 0.01894741f, 0.02969158f, 
    0.01042509f, -0.00175008f, -0.02424010f, 0.03552602f, 0.03701347f, 0.01118514f, 0.02056269f, 0.01976403f, 
    -0.01077347f, -0.04871902f, -0.04680736f, 0.05061409f, 0.02991189f, 0.02996639f, 0.05856347f, -0.05595301f, 
    0.03786734f, -0.02298241f, -0.02058159f, 0.03534957f, -0.01803690f, 0.02710556f, -0.02812468f, -0.04926083f, 
    -0.01949455f, -0.06355403f, -0.02623704f, 0.01552488f, -0.03700172f, 0.03774339f, -0.06269140f, 0.03323997f, 
    -0.05130136f, -0.04466141f, 0.04679807f, -0.00972407f, -0.02169469f, 0.05382115f, -0.04546633f, -0.01198912f, 
    -0.05496759f, -0.03529894f, -0.02812240f, 0.00512015f, 0.04302859f, -0.01261250f, -0.01335563f, -0.04049842f, 
    0.02925196f, -0.06085879f, 0.01564015f, 0.00939099f, 0.00405890f, 0.04022545f, 0.01456217f, -0.01166365f, 
    0.04393222f, -0.04665831f, 0.01967396f, -0.02600917f, 0.04014770f, -0.06510223f, 0.00584970f, -0.06755066f, 
    0.03705973f, -0.01239863f, 0.04340122f, -0.03192120f, 0.03642714f, -0.03028804f, -0.04953375f, -0.06896657f, 
    0.02356070f, -0.00939986f, 0.02688341f, -0.04742891f, -0.01090400f, 0.00982181f, -0.03808448f, 0.00170742f, 
    -0.02978099f, 0.01725917f, -0.06122742f, -0.03027392f, -0.05321870f, -0.07178303f, -0.03531390f, -0.07221398f, 
    -0.03969466f, -0.02897464f, -0.01383393f, -0.00786033f, -0.00933817f, -0.00746998f, 0.04020542f, -0.03011619f, 
    -0.02234127f, 0.04725775f, 0.03707444f, -0.06068015f, -0.05523830f, -0.05150924f, 0.04235322f, -0.03200351f, 
    -0.06098310f, 0.05090848f, -0.03855518f, 0.02759551f, -0.04394538f, -0.05840289f, -0.01748264f, 0.02027521f, 
    0.00420173f, -0.05324977f, -0.02263040f, 0.02685651f, 0.03482702f, -0.04644785f, -0.01354801f, -0.00968892f, 
    0.03458050f, 0.01496650f, -0.05414328f, -0.01937916f, -0.02123966f, 0.03907859f, -0.06121136f, 0.03774787f, 
    -0.00665808f, -0.05589315f, 0.02648952f, -0.01300170f, -0.01180937f, 0.00434144f, -0.03375782f, -0.02192660f, 
    -0.03059505f, 0.03844419f, 0.01179379f, 0.02038006f, -0.05290481f, 0.00460470f, 0.03087310f, -0.03900896f, 
    -0.06843606f, -0.01751136f, -0.02908697f, 0.04268080f, 0.00420643f, -0.04527771f, 0.04200183f, 0.04159685f, 
    -0.01312986f, 0.02250297f, -0.03818493f, -0.04384699f, 0.00083565f, -0.04186921f, 0.04056492f, -0.01129064f, 
    -0.02939782f, 0.03554381f, -0.01189580f, 0.02901693f, -0.05022160f, 0.02677219f, 0.02887701f, -0.06454869f, 
    0.03579335f, 0.04423830f, -0.00817894f, 0.02124919f, -0.00131348f, 0.01472180f, -0.02179812f, -0.05956924f, 
    0.04624541f, -0.06649932f, 0.04096009f, 0.00614595f, -0.03120685f, 0.02073744f, 0.01541654f, -0.00729231f, 
    0.04357005f, -0.05430866f, -0.00154563f, 0.03084210f, 0.01782691f, 0.01830724f, -0.01369403f, 0.03291512f, 
    0.02688024f, -0.03982696f, -0.04811699f, 0.01327331f, 0.02865918f, -0.00156314f, 0.02009064f, 0.02013020f, 
    -0.01252246f, 0.01064972f, 0.02855715f, -0.01110704f, 0.06602253f, 0.03460584f, 0.01350879f, -0.03809040f, 
    -0.06272727f, -0.01875853f, -0.06214280f, -0.04398686f, 0.00980036f, -0.00068447f, 0.02518005f, 0.03948381f, 
    0.02795414f, -0.00493023f, 0.04115408f, 0.01722714f, -0.00708442f, -0.05317850f, 0.02680390f, 0.01492578f, 
    -0.01830477f, 0.05269952f, -0.06655540f, 0.01179350f, -0.02165659f, 0.00976372f, -0.05326146f, 0.00367305f, 
    -0.05024955f, 0.04940637f, -0.02619393f, -0.04975233f, -0.03319398f, -0.04903747f, -0.01907520f, 0.00483680f, 
    -0.02518794f, -0.04742011f, 0.04479852f, -0.05022697f, -0.01150231f, -0.04034365f, -0.00726563f, 0.00534285f, 
    0.01681780f, -0.05617155f, -0.04399860f, -0.04972658f, -0.02184366f, -0.01742383f, 0.02389211f, 0.04168860f, 
    -0.00221818f, 0.02656167f, -0.04584429f, 0.01823918f, 0.02225703f, 0.00710996f, -0.02553812f, 0.01789947f, 
    0.04057608f, 0.04538709f, -0.00163927f, 0.03446935f, -0.03318668f, -0.03198650f, -0.01021351f, -0.01101982f, 
    -0.03996075f, 0.01139438f, -0.06508686f, -0.06714372f, -0.06505346f, -0.04865970f, 0.04030104f, -0.06618810f, 
    0.00384545f, -0.02835809f, -0.01973550f, -0.00011765f, -0.07141346f, 0.01145008f, -0.01146289f, 0.00182156f, 
    0.02608722f, -0.04983578f, -0.05495350f, 0.02474471f, 0.02585175f, -0.03738765f, 0.00279429f, -0.04385423f, 
    0.02016465f, -0.01895740f, 0.01039269f, 0.02465592f, 0.01981208f, -0.04894356f, 0.02026476f, -0.06808245f, 
    0.04657291f, -0.04322797f, -0.01255476f, 0.04388577f, 0.04217354f, -0.06957192f, -0.01103207f, -0.01093029f, 
    -0.00829564f, -0.00378550f, -0.04138293f, -0.04577037f, 0.03187391f, -0.00272479f, -0.00923712f, -0.04392317f, 
    -0.06325438f, 0.02368369f, 0.01602810f, -0.01041365f, 0.03372385f, -0.00150253f, -0.06345890f, 0.03884372f, 
    0.03460057f, 0.05090425f, 0.02094011f, -0.01958867f, -0.00299102f, -0.01016209f, -0.05187809f, 0.04569811f, 
    -0.01420714f, 0.03131810f, -0.02383638f, 0.01216642f, -0.04445681f, -0.04953469f, 0.03475175f, -0.00297464f, 
    -0.06151174f, -0.02819328f, -0.04990027f, -0.06202038f, 0.04480408f, -0.05659560f, -0.01411766f, -0.05846686f, 
    0.02544372f, -0.03301262f, 0.04771808f, 0.02429279f, 0.01564959f, -0.02934643f, -0.04629685f, -0.06387989f, 
    -0.05915724f, -0.03340818f, -0.02443555f, -0.02292683f, -0.05388451f, 0.01291012f, -0.04143487f, 0.02486611f, 
    -0.03194549f, -0.04436103f, 0.00625975f, -0.03817671f, -0.02950517f, 0.02324339f, 0.02420905f, 0.01305860f, 
    -0.02407889f, 0.04397668f, -0.05315577f, -0.00079770f, 0.00969727f, 0.04228075f, -0.04476707f, -0.04525585f, 
    0.03726587f, -0.01225796f, 0.02380126f, -0.05872193f, 0.02359415f, -0.02020029f, -0.03774897f, 0.05002584f, 
    0.05173732f, -0.03703357f, -0.06177259f, 0.05160268f, -0.01693807f, -0.01873777f, -0.00421297f, 0.04718871f, 
    -0.03087021f, -0.02841530f, -0.02462870f, 0.02767030f, 0.01995631f, 0.01765095f, -0.02851730f, -0.03415444f, 
    -0.03426807f, -0.05694822f, 0.04586607f, 0.03232455f, 0.03289346f, -0.06321896f, -0.05987801f, 0.04751739f, 
    0.04394075f, 0.01516850f, 0.01941987f, -0.01572764f, -0.01098925f, -0.01165144f, 0.01877280f, 0.02416025f, 
    -0.00332829f, -0.03108148f, -0.03533290f, -0.00095872f, -0.05665012f, -0.00162535f, -0.03245698f, -0.00478995f, 
    0.00231047f, 0.00005793f, -0.04208514f, -0.02304597f, 0.02864597f, 0.03432322f, -0.03117329f, -0.01588654f, 
    -0.05293424f, -0.04191378f, -0.05049612f, -0.03515001f, -0.00374891f, 0.04275035f, -0.02464654f, -0.03795613f, 
    -0.06103826f, -0.06241107f, -0.06125858f, -0.00329467f, -0.05342436f, 0.04494054f, 0.00988742f, -0.01890323f, 
    0.01110154f, -0.01504744f, 0.03097551f, -0.04857408f, -0.02756306f, -0.04927570f, -0.00844357f, 0.04608264f, 
    0.04597647f, -0.04319728f, 0.04001921f, 0.03302223f, 0.01363939f, 0.00121510f, 0.02949471f, 0.05252305f, 
    -0.01904388f, 0.00703235f, 0.04920728f, 0.05055141f, 0.00938841f, -0.04135948f, 0.04594269f, 0.00011385f, 
    0.01054586f, 0.04195295f, 0.03951609f, -0.03551276f, -0.05054638f, -0.05008612f, 0.00553707f, -0.03668697f, 
    -0.00583869f, -0.05651295f, -0.01360198f, -0.03357251f, -0.04844509f, -0.00952605f, -0.02948312f, -0.02550723f, 
    -0.06469826f, -0.01275329f, -0.03170932f, -0.03379058f, -0.04684535f, -0.04576975f, 0.01899317f, 0.03546692f, 
    -0.03193147f, 0.01107949f, 0.00041458f, 0.00108041f, 0.01806937f, -0.02703561f, -0.00404949f, -0.02193173f, 
    -0.01340292f, 0.03935673f, -0.04138375f, 0.02634247f, 0.02024506f, -0.02505795f, 0.01818863f, 0.03389342f, 
    -0.05364931f, -0.03978022f, -0.04740589f, -0.03161571f, 0.03732594f, 0.03643899f, -0.00518530f, -0.02726169f, 
    -0.05141103f, -0.03675858f, -0.04612430f, -0.01408127f, -0.02066002f, 0.00825541f, -0.05900957f, -0.02706640f, 
    0.04149463f, -0.04642003f, 0.01184706f, -0.05760995f, -0.02793244f, -0.02387979f, 0.03751431f, -0.05752236f, 
    -0.01177722f, -0.02088381f, -0.00565331f, 0.01799913f, 0.02551384f, -0.00793609f, 0.03652758f, -0.02395678f, 
    0.03756099f, -0.06050025f, 0.04449313f, -0.05247467f, -0.01679417f, -0.04127788f, -0.02159904f, 0.03592070f, 
    -0.05725561f, -0.04447820f, -0.06035540f, -0.06291727f, 0.00416147f, -0.02034722f, -0.05565198f, -0.01599569f, 
    0.04918313f, -0.00356908f, -0.02082951f, -0.02979218f, -0.00428767f, 0.02777140f, -0.05150709f, -0.00514374f, 
    -0.06384151f, -0.03842072f, -0.03427473f, 0.02546777f, 0.04190828f, 0.03033451f, -0.04435612f, -0.01942688f, 
    -0.02350870f, -0.04233798f, -0.02627468f, -0.00505750f, -0.04581496f, 0.03408860f, -0.02294734f, -0.03105464f, 
    0.00172321f, 0.05239665f, -0.01636180f, -0.00501674f, -0.00157257f, -0.02693232f, 0.03804790f, -0.03046329f, 
    0.04789512f, -0.03995449f, 0.00760560f, 0.01350519f, 0.01246314f, 0.02186679f, -0.00845159f, 0.01206236f, 
    -0.01249730f, -0.02989546f, 0.02222926f, 0.04604762f, 0.01835913f, -0.02342715f, 0.05009571f, 0.02532607f, 
    0.10027673f, -0.17466441f, -0.38690805f, 0.06049767f, 0.08731749f, 0.02861217f, 0.14968194f, 0.12428794f, 
    0.02502718f, 0.15011276f, -0.14884983f, -0.26451918f, 0.16999646f, -0.07427747f, 0.23176487f, 0.06306921f, 
    -0.05916964f, 0.01336455f, 0.03016851f, 0.08334334f, -0.38100711f, 0.32994759f, 0.26158750f, 0.13465481f, 
    -0.04865996f, -0.19017404f, -0.12804456f, 0.22823468f, -0.04814642f, -0.09666423f, 0.03967531f, -0.13777676f, 
    -0.04789050f, 0.06825420f, -0.10547116f, 0.09288263f, 0.21975836f, -0.13460922f, -0.10691794f, -0.41106814f, 
    -0.04611219f, -0.10902183f, -0.13034903f, 0.00646816f, 0.05072700f, -0.73636037f, -0.22335425f, -0.27052000f, 
    -0.09779011f, 0.00023597f, 0.06592848f, -0.17028277f, -0.00204513f, 0.24120747f, 0.00741306f, -0.90449721f, 
    0.18283901f, 0.29335341f, 0.09505509f, 0.09463049f, -0.34418473f, 0.14702567f, -0.14833580f, -0.12069635f, 
    0.08654615f, 0.02560355f, 0.07541876f, -0.13080280f, 0.13389425f, 0.30493149f, 0.19596954f, -0.07865295f, 
    0.22448589f, 0.05386586f, 0.03590894f, -0.51332724f, 0.02165157f, -0.02729027f, 0.35433802f, 0.13053603f, 
    0.10332293f, 0.09507268f, 0.11088645f, 0.03919575f, 0.23095267f, 0.09585736f, 0.18513288f, 0.13006911f, 
    0.03375753f, -0.24294631f, 0.37275863f, 0.53315407f, 0.38972747f, -0.02606353f, 0.24792558f, -0.13627571f, 
    -0.07260059f, 0.04702575f, -0.38959089f, 0.42117676f, 0.13826126f, 0.02758277f, -0.41406810f, -0.27245528f, 
    -0.14305574f, -0.11770497f, 0.27932495f, 0.10370822f, -0.24750367f, -0.00806177f, 0.13043605f, -0.12207163f, 
    0.14758265f, -0.29702598f, 0.06392634f, 0.25819483f, -0.04559197f, 0.04952656f, 0.42549875f, -0.09254663f, 
    -0.13860166f, -0.06619961f, 0.03736743f, 0.13098729f, 0.24156801f, -0.11313222f, 0.21796380f, -0.12486742f, 
    -0.28186625f, -0.01771526f, -0.08973906f, -0.24736333f, -0.13987470f, 0.08590063f, 0.11323233f, 0.09446620f, 
    -0.46993804f, -0.17060368f, -0.19986807f, 0.10623825f, -0.12206645f, 0.15106086f, 0.13816166f, 0.18800741f, 
    0.80544055f, -0.35416323f, 0.07706155f, 0.02286541f, -0.12927568f, -0.22734614f, -0.07707337f, -0.28947696f, 
    -0.22324716f, 0.59974921f, -0.06261874f, -0.02243171f, -0.16835086f, -0.06273090f, 0.05094709f, -0.19984752f, 
    -0.21249765f, -0.03114018f, -0.36999983f, -0.35201737f, -0.01675151f, 0.01485999f, 0.04676049f, 0.11604385f, 
    0.02457987f, -0.04183569f, -0.02953179f, -0.53127813f, -0.05840164f, -0.31451118f, 0.29730427f, 0.56512600f, 
    -0.03408000f, -0.22684848f, -0.10476160f, -0.04488388f, -0.24568404f, 0.10238852f, -0.11346197f, -0.02536479f, 
    0.07346695f, 0.08401221f, 0.40003940f, -0.00634017f, -0.04782322f, -0.25643498f, -0.00899008f, 0.11256144f, 
    0.24368136f, 0.11335151f, 0.12485829f, -0.02132120f, -0.05301123f, -0.02278900f, 0.69340086f, 0.44328058f, 
    0.10261521f, -0.10948514f, -0.07778575f, 0.14409229f, -0.34494308f, 0.11935719f, 0.12316242f, -0.20442849f, 
    0.23323317f, 0.32105356f, -0.27680749f, -0.10985271f, 0.18504043f, 0.03836510f, 0.15722221f, 0.11963397f, 
    0.02065819f, 0.13797386f, -0.11877828f, -0.15464859f, -0.09543943f, 0.12392321f, 0.22491677f, 0.10689171f, 
    -0.08240876f, 0.08347920f, 0.11431726f, -0.36182576f, 0.20110187f, 0.17546126f, 0.10222735f, -0.00356521f, 
    0.01107492f, -0.09447611f, 0.47017014f, 0.27438596f, -0.01837119f, -0.18072180f, -0.08719574f, -0.20872375f, 
    0.13079041f, 0.03995776f, -0.16324449f, -0.60633880f, 0.07610989f, -0.19600071f, -0.07111010f, 0.13251947f, 
    0.03925854f, -0.07796393f, 0.17499904f, 0.25805101f, 0.17558962f, 0.29614094f, 0.19865572f, -0.07946569f, 
    0.08401013f, 0.04592549f, -0.32102028f, 0.10395721f, -0.01310309f, 0.10250357f, -0.28664955f, 0.02225390f, 
    0.16362423f, 0.09913637f, -0.08891076f, 0.40562356f, -0.10182525f, 0.11419661f, -0.26229921f, -0.01125300f, 
    0.13240683f, -0.03446615f, 0.05984171f, -0.04763602f, -0.14456378f, 0.03673332f, 0.20519347f, 0.22759141f, 
    -0.03766256f, 0.74902499f, 0.04398082f, -0.04767162f, -0.21731296f, -0.27440381f, -0.11431389f, 0.12123934f, 
    -0.31196630f, -0.05383777f, 0.12108005f, -0.07939809f, -0.22863035f, 0.16283107f, -0.15619507f, -0.14825797f, 
    0.24795029f, 0.10127266f, -0.05168791f, -0.21274078f, 0.01787601f, 0.05022778f, -0.14576979f, -0.19481775f, 
    0.01613934f, 0.16219360f, -0.04449754f, 0.16706213f, 0.09037095f, -0.01534621f, 0.35551941f, -0.00116675f, 
    -0.09324097f, 0.03863457f, -0.20780703f, -0.42506227f, 0.48213050f, -0.05283209f, -0.18716031f, 0.16144952f, 
    -0.21845216f, -0.22744693f, 0.07655693f, -0.05828900f, 0.33620501f, -0.17225718f, -0.09712404f, 0.17435342f, 
    -0.18137658f, 0.15357798f, -0.06778210f, -0.02318078f, 0.14791204f, -0.29459921f, 0.06731179f, -0.21844330f, 
    -0.13378139f, -0.04627125f, 0.14652324f, -0.03122153f, -0.02206907f, 0.16036643f, 0.65186507f, 0.12116688f, 
    -0.21416825f, -0.02003315f, 0.03289762f, 0.13169056f, 0.16656885f, -0.02397916f, 0.02039290f, -0.17913523f, 
    0.44898441f, -0.02569854f, 0.11036977f, -0.09120899f, 0.15992464f, -0.09641116f, -0.21583413f, 0.09363037f, 
    -0.15429911f, 0.16473266f, 0.08521872f, -0.13625017f, -0.05101761f, -0.10290442f, -0.02825571f, 0.16747093f, 
    0.11529902f, 0.25843054f, 0.42845476f, 0.11778791f, 0.01531958f, 0.14335693f, -0.04000952f, 0.16767487f, 
    0.29603857f, 0.21019669f, -0.11751719f, 0.37042069f, 0.15224589f, -0.21576597f, 0.05533968f, -0.07773920f, 
    0.03423173f, 0.07593927f, -0.00779182f, -0.25030261f, -0.55565929f, 0.02374216f, 0.33850080f, 0.00275287f, 
    -0.18227299f, 0.06370259f, -0.15302017f, 0.30807287f, -0.25201836f, -0.18135445f, 0.47217280f, 0.07124394f, 
    0.18760484f, -0.11558799f, 0.14534466f, -0.17554317f, -0.07407556f, -0.16987656f, -0.33721957f, 0.12260567f, 
    0.12739807f, -0.10786646f, 0.09857385f, 0.01515691f, 0.00883164f, 0.05892681f, -0.06017143f, -0.42683145f, 
    0.05500072f, 0.14732836f, 0.19105724f, 0.17307776f, -0.17399342f, -0.18214157f, 0.09169155f, 0.33661839f, 
    -0.26435566f, -0.01624444f, -0.32543567f, -0.21500330f, -0.11845668f, -0.05814475f, 0.16840194f, 0.14156599f, 
    0.14644141f, 0.02979042f, 0.02975492f, -0.13262175f, -0.15824598f, -0.02543134f, -0.10009526f, -0.05761367f, 
    -0.17838950f, -0.20694064f, -0.24516796f, 0.11084920f, -0.09644097f, -0.02074408f, 0.12062873f, 0.04735463f, 
    0.03354077f, -0.08110441f, 0.17810899f, 0.20388922f, -0.11559969f, 0.07078621f, -0.16587371f, -0.12107444f, 
    0.01419381f, -0.10091960f, -0.06170241f, 0.10656653f, 0.12684235f, 0.01834303f, 0.03401798f, 0.17139284f, 
    0.04151356f, 0.09235482f, -0.01955535f, -0.08208141f, 0.13591418f, 0.47472554f, -0.00818638f, -0.16496848f, 
    -0.03409771f, 0.04484026f, 0.34790021f, 0.11460815f, 0.12707734f, -0.07482779f, 0.19487604f, 0.16103862f, 
    -0.05480453f, -0.44298431f, -0.02473845f, -0.08617949f, 0.08810911f, 0.01330804f, 0.24007262f, -0.64457381f, 
    -0.02363568f, 0.14644176f, 0.06423743f, 0.12845409f, 0.34140837f, -0.34352842f, -0.02345204f, 0.20286252f, 
    -0.10483058f, -0.01932273f, -0.20027666f, -0.18016346f, 0.12703858f, 0.06421772f, -0.00574513f, 0.03660299f, 
    0.17135933f, -0.21141249f, 0.21094871f, -0.09233706f, -0.04023860f, -0.20288126f, -0.02293481f, -0.02765662f, 
    0.37257081f, -0.19761601f, 0.24444570f, 0.08129112f, 0.02039059f, 0.18170105f, 0.00652911f, 0.09989396f, 
    0.32909825f, -0.09966098f, -0.29869539f, 0.01048197f, 0.07780192f, -0.04197574f, -0.01018705f, -0.03375209f, 
    0.02576946f, 0.05256474f, -0.11558722f, -0.47907937f, 0.18352827f, -0.17067733f, -0.08005688f, -0.02802378f, 
    -0.14971212f, -0.07849476f, 0.09930132f, 0.12571584f, 0.49017859f, -0.67934525f, -0.02887992f, 0.02661807f, 
    0.17600775f, -0.11138114f, 0.17514563f, 0.13427924f, -0.19977166f, 0.27518615f, 0.25723976f, -0.14287251f, 
    -0.08532175f, 0.01265377f, -0.29784143f, -0.03525371f, -0.08684809f, 0.02348788f, -0.18607400f, 0.42645714f, 
    -0.27151474f, -0.00787818f, -0.09025104f, -0.09891015f, 0.00203390f, -0.25260195f, 0.08710908f, -0.47971496f, 
    0.10440447f, 0.12149113f, -0.21334876f, -0.08223729f, 0.02455134f, -0.05091243f, -0.08718547f, -0.10790192f, 
    -0.19856298f, -0.15646878f, -0.09777573f, 0.43203166f, 0.20010923f, 0.11072975f, 0.04718377f, 0.08844106f, 
    -0.08718140f, 0.18473262f, 0.17571375f, -0.39638242f, 0.04716813f, -0.22188333f, 0.03591178f, 0.03185997f, 
    -0.12829594f, -0.12082305f, 0.00911537f, -0.41827679f, -0.10353851f, 0.02252435f, 0.07098468f, -0.29822573f, 
    0.17212321f, -0.02427883f, -0.01100180f, -0.65359211f, -0.21648353f, 0.00585192f, 0.04517298f, 0.07222548f, 
    0.22787875f, 0.04103183f, -0.03711032f, 0.16587138f, -0.62106782f, -0.14806744f, -0.28524542f, 0.23202336f, 
    -0.11216765f, 0.07465073f, 0.08006775f, -0.24336357f, 0.08772049f, -0.42041287f, -0.04723968f, -0.00488422f, 
    0.24286531f, -0.05286851f, 0.23167667f, 0.36363235f, 0.14703032f, 0.25730735f, 0.12520877f, -0.37092501f, 
    0.35818860f, 0.07342038f, -0.14282055f, -0.19275476f, 0.11259148f, -0.09259358f, -0.09440872f, -0.15043221f, 
    0.27445483f, 0.23569553f, 0.08830225f, -0.13507834f, -0.17725001f, 0.16099057f, -0.06480996f, 0.21346839f, 
    0.22976613f, -0.09669843f, 0.07193287f, -0.10298094f, 0.14800268f, -0.12402719f, 0.10438683f, -0.04694357f, 
    0.06245060f, -0.32033467f, -0.15602623f, 0.09812459f, -0.10732064f, 0.07491969f, -0.04539815f, -0.10701708f, 
    -0.25707540f, 0.00840998f, -0.22146721f, 0.01957359f, 0.03087415f, -0.03004758f, -0.07086162f, -0.30102530f, 
    0.07699339f, -0.00204746f, 0.05592129f, -0.07689268f, 0.06863744f, 0.06910895f, 0.26347125f, 0.01382866f, 
    0.06931186f, -0.01483434f, -0.03423389f, -0.00120315f, -0.10703892f, -0.03662162f, -0.15328357f, -0.27357504f, 
    0.15272707f, -0.02262125f, 0.08144340f, 0.17742752f, 0.21595399f, 0.37335670f, 0.05408035f, 0.30452427f, 
    0.09793726f, 0.07390972f, -0.10173521f, -0.04049137f, 0.08237028f, -0.00618098f, -0.06549544f, 0.01759815f, 
    -0.17998256f, 0.08607129f, -0.01562424f, 0.13432600f, 0.01893994f, 0.01545207f, 0.12287221f, 0.26243514f, 
    0.27900535f, -0.10838218f, 0.09008878f, -0.20661891f, 0.11753365f, -0.07502954f, 0.05149438f, -0.04712139f, 
    -1.36214316f, -0.23504746f, 0.24363084f, 0.04206319f, 0.15832017f, 0.02660892f, -0.13119847f, -0.00642497f, 
    0.08975685f, -0.39890608f, -0.00737724f, -0.17828228f, -0.03916657f, -0.15738674f, -0.14297767f, -0.07682317f, 
    -0.07237338f, -0.07369156f, 0.12542966f, -0.21097545f, -0.40358442f, 0.05933173f, -0.00780837f, 0.15022497f, 
    0.10000303f, -0.12767948f, -0.07369087f, 0.20413040f, 0.10418901f, -0.00329076f, -0.18207373f, 0.24143916f, 
    -0.02826003f, -0.01206601f, 0.04238394f, 0.00173422f, -0.88470334f, 0.14641356f, 0.44672802f, 0.11343969f, 
    0.23802142f, 0.07493537f, 0.01256466f, -0.19765596f, 0.25618285f, -0.05465075f, 0.13901174f, 0.03690091f, 
    0.17227750f, -0.00311303f, 0.12880966f, -0.03879553f, -0.12272023f, 0.06199475f, 0.35555673f, 0.07237361f, 
    0.06333981f, 0.12554345f, -0.01518956f, -0.00278977f, -0.09006374f, 0.02781917f, -0.07145600f, -0.41226485f, 
    0.11641740f, -0.21065235f, 0.10898448f, 0.01246100f, -0.09405451f, -0.03401274f, 0.04470266f, 0.22975080f, 
    0.22029369f, 0.16135889f, -0.08412224f, 0.07021752f, 0.14092112f, -0.10640554f, 0.21300101f, 0.04224170f, 
    0.14951466f, -0.27648011f, -0.30445936f, 0.14105135f, -0.21294801f, 0.16197258f, 0.12934415f, -0.05629587f, 
    0.02013292f, 0.03910297f, 0.13889739f, 0.20599094f, 0.05212725f, 0.04851636f, 0.06754130f, -0.12505537f, 
    0.14436249f, -0.05359902f, 0.14151244f, 0.14203241f, 0.01446159f, -0.22850238f, -0.03952551f, -0.12348275f, 
    0.09855489f, -0.01669045f, -0.10848550f, 0.12889801f, -0.00680589f, 0.31820792f, -0.42208356f, 0.06980903f, 
    0.02791602f, 0.10479046f, 0.04884877f, 0.03200018f, 0.01366410f, 0.38845241f, -0.23114407f, -0.41217038f, 
    0.19211714f, 0.10405856f, 0.04638746f, -0.06783053f, -0.01885240f, 0.04710539f, -0.59196883f, -0.11860031f, 
    -0.05172357f, -0.01301634f, -0.07334930f, 0.16375464f, 0.13574287f, 0.27999017f, 0.25242338f, -0.43164799f, 
    0.22694053f, 0.06115732f, -0.08701340f, -0.08250745f, -0.23435427f, -0.02603145f, -0.07899883f, -0.02338931f, 
    0.06197232f, 0.13332239f, -0.20283705f, 0.12994862f, -0.08512830f, 0.02986917f, -0.10534787f, -0.01292918f, 
    -0.01637615f, 0.43495154f, 0.31649956f, 0.04566960f, 0.17610566f, -0.03127418f, 0.17249222f, 0.08058999f, 
    -0.01368512f, 0.00490874f, 0.37946722f, 0.27403927f, 0.34818402f, 0.17266929f, -0.14496465f, -0.06786981f, 
    0.13797709f, 0.07822979f, -0.00869941f, 0.17748620f, -0.42348292f, 0.15649679f, -0.10057769f, 0.03643886f, 
    0.28896487f, -0.06795641f, -0.09124367f, 0.10523836f, -0.40633279f, 0.28038567f, -0.07641028f, -0.14030609f, 
    0.10643660f, 0.10936776f, -0.07027119f, 0.06635394f, 0.06001902f, -0.23254095f, -0.20042723f, -0.10768943f, 
    -0.10114109f, -0.33480799f, -0.21951458f, 0.10542165f, 0.17481120f, -0.05532478f, 0.09999400f, 0.33145347f, 
    -0.25698754f, 0.18897860f, 0.10590119f, -0.11367685f, -0.25008619f, -0.20381941f, -0.01874322f, 0.34667796f, 
    0.12279885f, 0.12565333f, 0.04044721f, -0.02671184f, -0.17846406f, 0.03173028f, -0.30630040f, 0.05351257f, 
    0.28720886f, -0.24270484f, -0.02881100f, -0.19465104f, 0.02511757f, -0.05845302f, 0.19721627f, -0.16749945f, 
    0.23881494f, 0.41755122f, 0.11871498f, 0.17343555f, 0.04636703f, 0.07166938f, 0.14679144f, -0.02231457f, 
    -0.06973059f, 0.21129212f, 0.11544323f, 0.21191126f, 0.24780071f, 0.31530079f, 0.11530371f, -0.30214137f, 
    -0.02353661f, -0.17145278f, -0.07682521f, -0.41582578f, 0.04810579f, -0.19592786f, -0.18962370f, -0.09411047f, 
    0.13207044f, -0.16594660f, -0.10047368f, 0.00438768f, -0.09947091f, -0.04176773f, -0.37548515f, -0.22588271f, 
    -0.25238526f, -0.11445758f, -0.00337690f, 0.11145677f, -0.09524742f, 0.06415792f, 0.18330747f, 0.03977069f, 
    -0.11773854f, -0.18370968f, -0.16920748f, -0.07739329f, -0.03830765f, -0.05572880f, -0.44330695f, -0.28739649f, 
    -0.05323038f, 0.05779722f, -0.06904797f, -0.02736992f, -0.10508502f, -0.08604012f, -0.02283459f, -0.32096666f, 
    0.21034741f, -0.04889750f, -0.00251924f, -0.24556701f, -0.03151401f, 0.23162624f, 0.05990381f, -0.03557245f, 
    0.00436413f, -0.09712227f, 0.20402063f, 0.23280178f, 0.23321402f, 0.06205667f, -0.21477100f, 0.14007150f, 
    -0.19336461f, 0.07398405f, 0.13201797f, 0.04123971f, 0.05624630f, 0.15532002f, -0.13535836f, -0.01550069f, 
    -0.03769943f, 0.32562411f, 0.18008024f, 0.31075355f, 0.16802180f, -0.30817583f, -0.16876903f, -0.18725245f, 
    -0.13286920f, 0.15736677f, -0.00425971f, -0.04074964f, -0.17396404f, 0.00446024f, -0.01030342f, 0.07116413f, 
    -0.05267517f, 0.13454841f, -0.16997549f, -0.02133000f, 0.54858613f, 0.08922399f, 0.41353449f, -0.07048260f, 
    0.02244965f, 0.00623390f, 0.05999724f, 0.02977762f, 0.16928604f, 0.01770361f, -0.18792799f, 0.03837460f, 
    0.01363579f, -0.04231642f, -0.26658055f, 0.05716489f, 0.07065807f, 0.03151598f, -0.57473892f, 0.04657545f, 
    -0.32077774f, 0.04751751f, -0.14442024f, -0.02882022f, -0.32279742f, 0.05891205f, -0.01830122f, -0.02926523f, 
    0.12603915f, -0.35214940f, 0.02382690f, -0.03379859f, -0.12645669f, -0.12426519f, 0.10612756f, 0.06650108f, 
    -0.25670677f, -0.11512391f, 0.12585016f, -0.02277302f, 0.15294270f, 0.02715781f, -0.01492946f, -0.31763405f, 
    0.21941662f, 0.36154929f, 0.20226666f, 0.36762217f, -0.00624861f, 0.02080923f, 0.11725464f, 0.16550957f, 
    0.03336190f, 0.11024198f, -0.09135915f, 0.07194719f, 0.29617232f, -0.05900916f, -0.13333258f, -0.20484757f, 
    -0.06233415f, 0.06295890f, 0.22588368f, -0.00572500f, 0.00485439f, -0.22670086f, 0.13369782f, -0.01461327f, 
    -0.14450334f, -0.01710673f, 0.01961209f, -0.02153636f, -0.32801554f, 0.28055409f, -0.01846727f, -0.20515516f, 
    -0.17517053f, 0.19516478f, -0.05830606f, 0.03045818f, -0.02943450f, -0.25515038f, -0.14614215f, 0.07399335f, 
    -0.12747067f, 0.17445965f, -0.00133581f, -0.29773206f, 0.03002838f, -0.07163414f, -0.02679601f, -0.05744414f, 
    0.02307263f, 0.03015587f, -0.14315680f, 0.07530590f, 0.03448909f, -0.08416966f, -0.04425862f, 0.24739514f, 
    0.23152083f, -0.02176059f, 0.15499371f, 0.25745964f, -0.12837340f, 0.22210746f, 0.03336020f, -0.04312308f, 
    0.25746614f, 0.29991370f, -0.21455887f, 0.02659382f, 0.20616756f, 0.15123060f, 0.06669565f, -0.07211514f, 
    -0.17614670f, 0.02967851f, -0.33290294f, -0.23947743f, 0.12262899f, 0.07233078f, 0.13553791f, -0.24450395f, 
    -0.04317535f, -0.22684881f, -0.10401519f, -0.45351693f, -0.71018106f, -0.01300448f, -0.08421867f, 0.07177809f, 
    -0.11071937f, -0.10400353f, -0.02470359f, -0.09674809f, -0.20999062f, -0.18127587f, -0.07915542f, -0.14252341f, 
    -0.44063067f, 0.42269525f, -0.13429655f, 0.13856265f, -0.22095747f, 0.27415273f, -0.11004374f, 0.07626963f, 
    0.02278908f, -0.02473766f, 0.02787270f, 0.06809510f, 0.13881303f, 0.15538381f, -0.29965866f, 0.00447507f, 
    -0.13749546f, 0.03086786f, 0.00808083f, 0.15903182f, 0.16235274f, 0.21005702f, -0.53798276f, -0.40417707f, 
    -0.82493085f, 0.05460919f, 0.13695182f, -0.35876173f, 0.16584769f, -0.10703586f, 0.21057110f, 0.14310680f, 
    0.19047999f, -0.00671004f, 0.01886639f, 0.05042218f, -0.06103927f, 0.12392554f, -0.00952364f, -0.09013666f, 
    0.03076839f, 0.06885884f, 0.29788679f, 0.00118870f, 0.06341467f, 0.00016158f, 0.17315125f, 0.15794511f, 
    -0.07537801f, -0.05485187f, -0.19290800f, -0.10954748f, 0.10424770f, 0.10686181f, 0.00923088f, -0.00204257f, 
    -0.14053385f, -0.06873804f, -0.26584992f, -0.32809561f, -0.49223208f, -0.08588734f, 0.18548322f, 0.12665950f, 
    -0.20818657f, -0.13042970f, 0.11760518f, 0.35561818f, 0.40995526f, 0.31728557f, 0.12811051f, -0.15147121f, 
    -0.01983980f, 0.15536353f, -0.02077505f, 0.11676630f, 0.03804157f, 0.03534690f, 0.12647516f, 0.09603507f, 
    0.26607370f, 0.08694106f, 0.24549085f, -0.15448762f, 0.15293829f, 0.23242790f, 0.27755049f, 0.10524742f, 
    -0.19157526f, -0.02649377f, 0.20503296f, 0.39061260f, 0.18080460f, -0.23690838f, 0.30058080f, 0.18727790f, 
    -0.00002303f, 0.08506470f, 0.43012685f, 0.23549043f, -0.26573610f, -0.05359928f, -0.00646286f, -0.29174441f, 
    -0.25993961f, 0.36550203f, -0.02407315f, 0.08988088f, -0.08721804f, 0.18151854f, -0.12419806f, -0.10799835f, 
    -0.08785502f, 0.36404914f, 0.03958315f, -0.11785684f, -0.03110135f, -0.00826068f, 0.09480833f, 0.05047533f, 
    -0.14462896f, -0.33098271f, -0.19946967f, 0.16873844f, 0.07977508f, 0.23586619f, 0.01863606f, -0.02266504f, 
    0.05462911f, -0.28019589f, -0.36380354f, 0.17808250f, -0.40611884f, -0.07749841f, -0.09387469f, 0.03084907f, 
    -0.16431762f, 0.06732113f, 0.16434661f, -0.63046175f, -0.26068786f, 0.57225198f, 0.29473314f, 0.06453282f, 
    0.21768071f, -0.10976108f, -0.33177653f, -0.38487875f, -0.13627931f, 0.40752006f, -0.08751529f, 0.10193630f, 
    -0.02227383f, 0.14091539f, 0.10896763f, -0.00109269f, -0.14022575f, -0.11402749f, 0.10828035f, -0.18517841f, 
    0.11505790f, 0.03334290f, 0.03335543f, 0.12845528f, 0.13099100f, 0.17691003f, 0.41295075f, 0.38409352f, 
    0.12547685f, -0.17768286f, -0.14227927f, -0.16041483f, 0.27403143f, -0.02793771f, 0.08242429f, 0.29408643f, 
    0.30253679f, 0.18727982f, 0.05337645f, 0.06664736f, 0.11363081f, 0.18831930f, 0.01525635f, -0.04953593f, 
    0.05335639f, 0.01756694f, 0.34396946f, 0.21240197f, 0.10112211f, 0.36371985f, -0.07907025f, 0.12520321f, 
    0.28960824f, -0.27457199f, -0.27914408f, -0.32555667f, 0.04407039f, -0.00351006f, 0.01295917f, 0.10853191f, 
    -0.00954143f, 0.02827793f, 0.30270797f, 0.26858276f, 0.20413674f, 0.26362392f, 0.10452635f, 0.11088166f, 
    0.06529968f, -0.04567610f, 0.08514626f, -0.16769114f, -0.48297095f, -0.13095240f, 0.13947743f, -0.05783240f, 
    0.12480319f, 0.13017459f, -0.00638126f, -0.08637951f, 0.14814600f, -0.00004421f, 0.04963820f, -0.23328698f, 
    -0.19663374f, -0.10741184f, -0.07983758f, -0.12527162f, 0.31646711f, -0.04268805f, -0.17295177f, -0.31982011f, 
    -0.09913013f, -0.15629622f, 0.14980057f, 0.11857390f, 0.04710997f, -0.16039337f, -0.18161817f, -0.11809254f, 
    0.06909496f, -0.12984435f, -0.01299874f, 0.04593946f, 0.08458950f, -0.16259867f, -0.06699008f, -0.51575696f, 
    -0.35851377f, -0.03715782f, 0.05906170f, -0.10905094f, 0.20445427f, 0.09448582f, -0.11339184f, 0.06759465f, 
    0.12601027f, 0.31504199f, 0.45242822f, 0.08939106f, -0.01479308f, -0.12624119f, 0.12488221f, -0.06715743f, 
    0.09517331f, 0.21358623f, 0.07103134f, 0.17284988f, -0.03214271f, 0.19222736f, -0.05631457f, -0.08352812f, 
    0.04429829f, 0.02999694f, 0.16834924f, -0.37508309f, -0.09707747f, -0.13273409f, -0.28472322f, 0.09978942f, 
    -0.08636378f, 0.11876962f, -0.12153735f, -0.20271552f, 0.09904598f, 0.17345932f, -0.19161914f, -0.24472952f, 
    -0.45903167f, 0.15067683f, -0.03635984f, 0.08078592f, 0.60207951f, 0.04676178f, -0.21811041f, 0.18027747f, 
    -0.02766532f, 0.01247131f, -0.00560396f, -0.16476560f, -0.02708264f, 0.18267055f, -0.01108525f, 0.04182856f, 
    0.07661535f, 0.23701575f, 0.01205251f, 0.02353642f, 0.11668532f, 0.14365044f, -0.05682771f, 0.20104042f, 
    0.04800736f, -0.03812971f, 0.04761444f, -0.31956396f, -0.02965640f, 0.06054975f, -0.01395079f, -0.37278676f, 
    -0.37960857f, -0.05535000f, -0.22654326f, 0.04596512f, 0.37848020f, 0.15206192f, -0.12685893f, -0.04601033f, 
    -1.02686179f, -0.31249455f, -0.08633326f, -0.16956966f, 0.02183538f, 0.09932525f, 0.09541149f, 0.04817818f, 
    0.21089469f, 0.22937469f, 0.14053719f, -0.04945165f, -0.11625991f, 0.03628169f, -0.05626322f, -0.18023281f, 
    -0.00630544f, 0.07014852f, 0.27494708f, -0.34118882f, -0.42382425f, -0.22131328f, -0.12114529f, -0.18726549f, 
    0.00912032f, 0.21297215f, 0.07965004f, -0.75181866f, 0.13393621f, 0.16680482f, 0.20835584f, 0.20499656f, 
    0.06571528f, -0.08471026f, -0.19332975f, -0.12198838f, -0.19661239f, 0.05692499f, -0.05432179f, 0.07369944f, 
    0.03070117f, -0.00755744f, -0.00091810f, 0.03120472f, -0.06743014f, -0.53946871f, -0.38159791f, -0.06964395f, 
    0.01266916f, 0.19358332f, -0.04522453f, -0.17894438f, 0.01865724f, 0.20342441f, -0.95240444f, 0.34169826f, 
    0.04149364f, 0.08872946f, 0.27583823f, 0.04141101f, 0.00453480f, -0.03051585f, 0.12940644f, -0.00365403f, 
    -0.11134624f, -0.17075785f, -0.10673336f, -0.05420946f, -0.19837394f, -0.02556373f, -0.11254969f, 0.20694299f, 
    -0.00806548f, 0.17919230f, -0.13895379f, 0.15541247f, 0.32392535f, 0.01137478f, 0.14060755f, 0.02879846f, 
    0.05339370f, -0.07962979f, 0.01550544f, 0.02826531f, 0.14485320f, -0.06256636f, -0.11127849f, 0.08363452f, 
    -0.05153068f, 0.12687990f, -0.05475300f, -0.17353253f, 0.51318443f, 0.16295189f, -0.33490729f, 0.12115881f, 
    0.12162922f, -0.17226744f, 0.16322003f, 0.37112156f, 0.03248229f, -0.12878785f, 0.18453489f, 0.13548462f, 
    0.19366510f, 0.14523475f, 0.21669829f, 0.01291511f, -0.43454713f, -0.14799494f, 0.11252382f, 0.10179164f, 
    -0.01269030f, 0.21782437f, -0.14340909f, -0.19103003f, 0.23138815f, 0.20720540f, 0.17766932f, 0.15666792f, 
    0.02371066f, -0.24892221f, 0.06676432f, 0.04471051f, 0.11687506f, 0.06551287f, -0.08831504f, 0.16895574f, 
    -0.01358971f, 0.23260316f, 0.06573049f, -0.19250815f, 0.00151411f, 0.00433575f, -0.09140521f, -0.44337183f, 
    0.26956943f, 0.19787914f, 0.18169692f, -0.03852388f, 0.09247020f, 0.04767743f, -0.05879616f, 0.16804793f, 
    -0.25924996f, -0.10097808f, -0.06043697f, 0.01665274f, -0.18826738f, 0.16397695f, -0.03566546f, -0.01153015f, 
    -0.07621673f, 0.04771456f, 0.02484703f, -0.04084825f, -0.23795052f, -0.02877374f, 0.20246848f, 0.02841345f, 
    0.24221115f, -0.08467080f, -1.42070305f, -0.10037390f, -0.11472307f, 0.12124568f, 0.01573624f, 0.13184288f, 
    0.08074850f, -0.10278435f, -0.09608731f, 0.24071006f, -0.05152274f, 0.01110825f, 0.36905590f, -0.19977009f, 
    -0.12275247f, -0.23227982f, 0.13308910f, 0.44034886f, 0.16585241f, 0.34320346f, -0.47364700f, 0.11912580f, 
    -0.07287398f, -0.12036483f, -0.15092379f, 0.08793186f, -0.01706614f, 0.34751844f, 0.39697459f, 0.26997620f, 
    0.29451805f, -0.01986890f, 0.11882178f, 0.02782187f, 0.18374164f, 0.15728699f, 0.16556461f, 0.02672468f, 
    -0.27885839f, -0.31815097f, 0.25404355f, 0.19772762f, 0.00228696f, -0.17231637f, 0.01251715f, -0.24332096f, 
    -0.09667804f, -0.26960471f, 0.00520883f, -0.04490929f, 0.03688408f, 0.40237200f, 0.04999207f, 0.01179582f, 
    0.28925329f, -0.15786298f, -0.37301046f, 0.25206524f, 0.17684424f, 0.14860281f, 0.16911843f, -0.00043903f, 
    -0.03147265f, 0.01037730f, 0.25124034f, 0.14878151f, 0.06722645f, -0.12673280f, -0.18664338f, -0.21020018f, 
    -0.28263324f, -0.41669297f, 0.03689498f, -0.09118507f, 0.00882288f, 0.00060283f, -0.23606838f, -0.05072933f, 
    0.10696644f, -0.00166750f, -0.03027402f, -0.05927281f, -0.25539964f, 0.10548385f, -0.09119534f, -0.21741356f, 
    -0.03342040f, 0.01472581f, 0.10182938f, 0.22606148f, 0.23164374f, -0.29066780f, -0.26408258f, -0.08956731f, 
    0.08066950f, 0.04940792f, -0.20209271f, -0.07637545f, 0.05720280f, 0.15628946f, 0.23608860f, -0.37343234f, 
    0.01056805f, 0.04618584f, -0.04829010f, -0.00061839f, -0.15172169f, -0.07207020f, -0.94942003f, 0.16979560f, 
    0.14584845f, 0.08695830f, 0.05349791f, -0.12273903f, 0.10174681f, -0.11974408f, -0.04660349f, -0.14888163f, 
    -0.33667833f, 0.11777750f, -0.05780656f, 0.10182347f, 0.01549859f, -0.14025830f, 0.11336128f, 0.13690124f, 
    0.07082146f, -0.22135875f, 0.07799705f, 0.29392588f, 0.06661835f, -0.13272336f, 0.01983737f, 0.17647299f, 
    0.19314301f, 0.16087127f, 0.28813314f, 0.34866342f, -0.24103855f, -0.23789462f, 0.02462896f, -0.08020989f, 
    -0.02581040f, 0.13139774f, 0.25536203f, 0.13696252f, 0.25502634f, 0.18344036f, -0.11580927f, 0.05929041f, 
    0.18175997f, -0.08143390f, 0.04996848f, -0.34924769f, -0.15573598f, -0.11499123f, 0.10081007f, 0.20342745f, 
    -0.01510203f, 0.00195984f, 0.21161203f, -0.05942435f, -0.29662701f, -0.18850380f, 0.18471169f, 0.00872048f, 
    0.19825037f, -0.16313535f, 0.13808018f, -0.17122659f, -0.00188213f, -0.57972378f, 0.14287932f, 0.07665664f, 
    -0.03114583f, 0.21878308f, -0.23285231f, 0.14290455f, -0.00072745f, 0.14571287f, -0.32827026f, 0.06796345f, 
    -0.26318100f, 0.38810900f, 0.29164383f, 0.22052811f, -0.19285655f, 0.00153213f, 0.13062418f, 0.28090584f, 
    -0.27360222f, 0.01670506f, -0.18570952f, -0.06709447f, 0.05227129f, 0.10272419f, -0.01091880f, 0.16566609f, 
    -0.28013974f, 0.06044402f, -0.42250547f, 0.06375500f, -0.05939360f, 0.00214163f, -0.02766502f, -0.09445322f, 
    -0.05414644f, 0.58381432f, 0.10582624f, -0.09698300f, -0.19864507f, -0.29241863f, 0.22612771f, 0.07787349f, 
    0.07917809f, 0.12919243f, -0.45921171f, -0.02534994f, -0.37816590f, 0.25805891f, 0.20666644f, 0.09264091f, 
    0.00741800f, 0.13498330f, 0.11188897f, 0.14354084f, 0.30159757f, 0.09128983f, 0.06313676f, 0.07551239f, 
    0.05383512f, 0.18207633f, -0.09301673f, 0.10381803f, -0.16316749f, 0.02166858f, 0.04729111f, 0.21160868f, 
    0.05448058f, 0.06803030f, -0.14824148f, 0.10177884f, -0.04009309f, 0.45253736f, -0.16527221f, -0.26991194f, 
    -0.00410872f, -0.07474026f, 0.06941960f, -0.06962693f, -0.09849970f, -0.08477356f, 0.19091198f, 0.19797832f, 
    -0.14810649f, 0.05663096f, 0.09679152f, -0.00711078f, 0.16027221f, -0.01802528f, -0.14412768f, -0.00688750f, 
    -0.32061267f, -0.23448795f, 0.11770622f, 0.10078909f, -0.07601280f, -0.04575666f, 0.16855876f, -0.01746559f, 
    0.12574573f, 0.00999795f, -0.35906196f, -0.15226118f, -0.03569825f, -0.23449188f, 0.17996895f, 0.06394435f, 
    0.22120465f, 0.00222303f, 0.23644619f, 0.38014868f, -0.15426356f, -0.14910986f, -0.21165381f, 0.03708060f, 
    -0.04949244f, -0.09506419f, -0.09439410f, 0.02290848f, 0.16135623f, 0.17261910f, 0.24614431f, -0.12749419f, 
    -0.21870682f, 0.03975307f, 0.20943357f, 0.28173774f, -0.25485110f, -0.18597278f, -0.35290286f, 0.05741210f, 
    0.10963010f, -0.11368927f, -0.11598637f, 0.07555528f, -0.22050218f, -0.21536358f, -0.22654407f, 0.03154416f, 
    0.02535314f, -0.09125508f, 0.01083622f, 0.08650495f, -0.10586841f, 0.26686788f, 0.35615480f, -0.21507661f, 
    0.11587046f, -0.07312345f, 0.08747865f, 0.04400239f, 0.04896098f, -0.04475625f, -0.28798702f, 0.13692783f, 
    0.03448541f, -0.00059320f, -0.11298231f, 0.10278497f, 0.09601806f, 0.24576406f, -0.04481643f, 0.42828494f, 
    0.05708306f, -0.02986305f, -0.19364320f, -0.12574442f, 0.09095551f, 0.14137243f, 0.08667979f, 0.19986650f, 
    -0.38810217f, -0.20783946f, -0.26689667f, 0.13827112f, -0.01256325f, 0.14919807f, -0.07192469f, 0.11365438f, 
    -0.20741312f, 0.29273495f, -0.18491054f, 0.29269007f, 0.08438890f, 0.12501210f, -0.05936556f, 0.19148937f, 
    0.16374686f, 0.00144595f, 0.19367960f, -0.39803630f, -0.01229692f, 0.11972960f, 0.05124841f, -0.26087031f, 
    0.12577738f, 0.19364734f, -0.34858721f, -0.47923520f, 0.23781490f, -0.34944966f, 0.19934388f, -0.10120454f, 
    0.17295970f, -0.02053201f, -0.13443196f, -0.33808693f, 0.07298668f, -0.60513604f, -0.36629048f, -0.13385986f, 
    0.08983748f, -0.02251817f, 0.17260614f, 0.10793423f, -0.09201848f, -0.19381884f, -0.14499693f, -0.61367404f, 
    0.08175860f, -0.12920697f, 0.05030121f, -0.01419322f, -0.10697284f, 0.15777457f, -0.36283126f, -0.58581316f, 
    0.05666363f, 0.17449751f, 0.27033076f, -0.28175461f, 0.10245083f, -0.09373258f, 0.10433444f, -0.15820847f, 
    -0.14479961f, -0.49937928f, 0.19192684f, 0.24104637f, 0.17234434f, 0.04179739f, 0.07312256f, 0.00452765f, 
    -0.15621343f, 0.01883229f, 0.17939134f, 0.03503869f, 0.14520910f, -0.02774940f, -0.03473940f, 0.00486141f, 
    0.24378775f, 0.59794331f, 0.23174265f, -0.14961942f, 0.02619784f, -0.01687237f, 0.13758568f, 0.06918340f, 
    0.11028522f, 0.12444612f, 0.52361155f, 0.64660358f, -0.35905954f, 0.07410030f, -0.06363636f, -0.18008256f, 
    0.18309897f, -0.12788327f, -0.00077774f, -0.04380697f, -0.08220336f, -0.20445858f, 0.28690478f, -0.19235316f, 
    0.09491558f, 0.03018169f, 0.02823164f, -0.07368930f, -0.08652333f, 0.01648526f, 0.14157307f, -0.03729743f, 
    0.21158899f, 0.16944222f, -0.11259195f, -0.04746952f, 0.20486626f, -0.28135204f, -0.08999543f, 0.19404307f, 
    0.01224357f, 0.04500726f, -0.08440310f, -0.24656275f, -0.10569894f, 0.05312999f, 0.28556427f, -0.06536574f, 
    -0.36368203f, -0.13694331f, -0.16605283f, 0.08680213f, -0.01504424f, 0.01698001f, -0.01523142f, 0.18693745f, 
    -1.00658119f, -0.10611919f, -0.04656933f, 0.01250639f, -0.16542679f, -0.05860561f, 0.26405281f, 0.12086704f, 
    0.15592477f, -0.06764974f, -0.89080352f, 0.33706486f, 0.15695958f, 0.08787139f, 0.10070350f, -0.00312779f, 
    -0.04421581f, 0.15058145f, -0.00442497f, 0.26576567f, -0.06633892f, -0.05858313f, -0.45631689f, 0.02299588f, 
    0.04638724f, 0.08147679f, -0.82166153f, -0.11142386f, 0.20541202f, 0.03121150f, 0.04081009f, 0.15653993f, 
    -0.23330727f, 0.08205118f, 0.02478263f, -0.30033258f, 0.16778731f, -0.00494276f, -0.11194913f, 0.21903385f, 
    -0.00295579f, 0.12854689f, -0.10988445f, 0.08304743f, 0.50274086f, 0.11728029f, 0.30727351f, -0.06820481f, 
    -0.18763205f, 0.06849242f, 0.34894785f, -0.21352066f, 0.14972726f, -0.57644570f, -0.56058216f, 0.22172761f, 
    -0.01250652f, 0.02621441f, 0.17001991f, 0.06068850f, 0.15907058f, 0.03002415f, -0.20755145f, -0.24804090f, 
    0.01977137f, -0.08716426f, -0.09126474f, 0.06370456f, -0.03762759f, -0.19724329f, 0.12578481f, -0.16822822f, 
    0.10843593f, 0.26520035f, 0.07189862f, 0.16919732f, -0.02476130f, -0.00307096f, 0.18897781f, -0.17835610f, 
    0.32087237f, 0.28151727f, 0.02688203f, 0.10130295f, 0.06989760f, -0.07807022f, 0.01156338f, 0.23317051f, 
    -0.02770204f, -0.05857076f, 0.31260198f, -0.16145964f, 0.23598903f, 0.07725525f, -0.03042657f, 0.15150146f, 
    -0.02350993f, 0.14213523f, 0.00473787f, 0.23224801f, 0.13680705f, -0.02270241f, -0.05274903f, -0.03260282f, 
    -0.01372455f, 0.03111848f, 0.16871637f, -0.28276512f, -0.18819731f, -0.14295167f, -0.09075889f, -0.08828323f, 
    -0.11918680f, 0.04093593f, 0.07490002f, -0.00152764f, -0.43368667f, -0.35401440f, -0.06843843f, -0.15040292f, 
    -0.07583632f, -0.04542005f, -0.07323493f, -0.27488074f, 0.18186750f, -0.46413401f, -0.13651857f, 0.36788565f, 
    0.03624739f, 0.16891772f, 0.10938374f, -0.15862533f, 0.21292263f, 0.00289359f, 0.29158160f, 0.63542992f, 
    -0.57294571f, 0.10875949f, 0.05942475f, -0.05766685f, 0.07450617f, 0.07864109f, -0.13457660f, -0.76679617f, 
    0.07115737f, 0.24147557f, 0.03433238f, 0.16416837f, -0.08176871f, 0.19234447f, 0.08967806f, 0.25673029f, 
    -0.02107153f, 0.01766950f, 0.05080664f, 0.02765291f, -0.15337458f, 0.06003379f, 0.08286922f, 0.30241397f, 
    -0.03961343f, 0.43188095f, -0.11544247f, -0.09088787f, 0.10791898f, -0.11799208f, -0.12628108f, 0.06118601f, 
    -0.23243274f, 0.17753790f, -0.01732963f, 0.24206878f, -0.01043982f, -0.02433083f, -0.03197832f, 0.17585535f, 
    0.04304564f, -0.08066721f, -0.03517062f, 0.05484517f, 0.12757005f, -0.10887852f, -0.04055501f, 0.15860315f, 
    0.07895859f, -0.32734936f, -0.09799695f, -0.12226353f, 0.27975988f, 0.11748333f, 0.16080488f, -0.28772587f, 
    -0.11421616f, 0.01126454f, 0.30501685f, 0.01333915f, 0.07608651f, -0.15342087f, -0.06957642f, -0.21404535f, 
    -0.01231814f, 0.12602083f, 0.22333911f, -0.20591564f, 0.01086015f, -0.18537331f, 0.13588542f, 0.04429660f, 
    -0.04817049f, 0.04867071f, 0.03073078f, -0.02459364f, -0.11370376f, -0.14822151f, 0.16071481f, 0.21664990f, 
    -0.20348865f, 0.16940939f, -0.08320175f, -0.00297709f, -0.15900365f, 0.14209941f, 0.27238595f, 0.13381267f, 
    -0.05490572f, 0.28246436f, -0.07715236f, -0.01962445f, -0.01516673f, 0.08677996f, 0.10230015f, 0.07027197f, 
    0.09405357f, -0.06577207f, -0.16548000f, 0.13709028f, 0.16161935f, -0.09463309f, 0.00873410f, -0.25464609f, 
    -0.00554085f, 0.18936017f, -0.03890032f, 0.32889709f, -0.26773119f, -0.00640094f, -0.23382531f, -0.02727527f, 
    -0.11766015f, 0.07522672f, 0.28257686f, -0.08685820f, -0.11484794f, 0.02649673f, 0.08209915f, 0.07808727f, 
    0.01584220f, 0.17620263f, 0.13795114f, 0.01850872f, -0.03126819f, 0.06724861f, -0.35612667f, 0.09720325f, 
    -0.17853503f, 0.06157154f, 0.14572935f, 0.03185617f, 0.09603038f, 0.12086100f, 0.01720862f, -0.14826989f, 
    0.28870967f, 0.13003801f, -0.07142520f, 0.06107763f, -0.11333860f, 0.08987651f, -0.36937198f, -0.11711141f, 
    0.02724447f, -0.29602712f, 0.04681627f, 0.00522724f, 0.01383042f, 0.02008831f, 0.00087344f, 0.00504902f, 
    -0.03633029f, 0.10079377f, 0.08299722f, -0.01674833f, -0.11952192f, 0.20653753f, 0.03128066f, 0.10217218f, 
    0.32400879f, 0.14865839f, 0.13182847f, -0.12755272f, -0.06865177f, -0.03771302f, 0.09309938f, -0.02997621f, 
    0.10300912f, -0.02123607f, 0.09020802f, -0.00205944f, 0.04170703f, -0.18353087f, 0.11786669f, 0.21581769f, 
    -0.09385967f, 0.19737220f, 0.05385299f, -0.12053708f, 0.03483769f, 0.03171920f, -0.21786244f, 0.20436868f, 
    0.06679738f, 0.14003052f, 0.05399187f, 0.18505511f, 0.15726918f, -0.49459535f, 0.26606402f, 0.00691548f, 
    0.14002115f, -0.08189089f, 0.01634293f, -0.03499046f, -0.18702167f, -0.60534370f, 0.18096021f, 0.17996688f, 
    0.08668815f, -0.11345725f, -0.08227836f, 0.12621783f, -0.05448879f, -0.03155284f, -0.22060536f, 0.01308158f, 
    0.06034107f, -0.02631313f, -0.10290531f, -0.13970844f, -0.21831265f, 0.04408333f, -0.08496585f, -0.07769956f, 
    0.08790258f, -0.22238208f, 0.12987196f, -0.09015873f, -0.11042040f, -0.02738103f, -0.03107769f, -0.35670364f, 
    0.05410844f, 0.05395263f, -0.02708060f, -0.10675072f, 0.01803714f, 0.22798775f, 0.20699961f, 0.06099280f, 
    -0.08177284f, 0.02091771f, -0.25631368f, -0.05155307f, -0.00584446f, 0.03200152f, 0.05325205f, 0.06500499f, 
    0.08506884f, -0.25218317f, -0.20187862f, 0.08121517f, 0.14336962f, -0.07640669f, -0.22148283f, 0.07478049f, 
    -0.15172522f, -0.18013705f, -0.07249393f, 0.04935945f, 0.10506956f, 0.06936946f, 0.03841377f, 0.08421283f, 
    -0.06659795f, -0.11319017f, -0.03901612f, 0.07532964f, -0.10913983f, -0.07158443f, 0.09333682f, -0.09815999f, 
    -0.00754115f, 0.04311915f, -0.12404858f, 0.05376346f, -0.01061665f, 0.08922791f, 0.00430294f, -0.43470091f, 
    0.12267099f, 0.19058970f, -0.00463675f, 0.00030942f, -0.06782103f, -0.23339389f, 0.25601143f, -0.03290162f, 
    0.02801717f, 0.14156044f, 0.11326090f, -0.00948389f, 0.01549132f, 0.14352070f, -0.26814660f, -0.10935587f, 
    -0.14454897f, -0.00450175f, 0.02777812f, 0.17370144f, 0.12376379f, 0.11171392f, -0.31046841f, 0.09465466f, 
    0.43597144f, 0.08460135f, -0.11303414f, -0.18422580f, -0.20640536f, 0.11856617f, -0.00689495f, 0.14706096f, 
    0.01147565f, 0.02861912f, -0.03075561f, 0.00423280f, -0.05971004f, -0.02057716f, -0.04247124f, -0.04705001f, 
    0.00488578f, -0.06983405f, 0.03455317f, -0.04243426f, -0.03622365f, -0.00953254f, -0.06130862f, -0.04425272f, 
    0.01859403f, -0.03837033f, 0.01321224f, 0.04359179f, -0.03360805f, -0.03450852f, -0.02080391f, 0.01204053f, 
    -0.01472932f, -0.05448841f, 0.01421637f, 0.02852397f, -0.03084445f, -0.04782223f, -0.06379482f, -0.02363091f, 
    -0.05269136f, -0.02083802f, 0.01886657f, 0.04270925f, -0.02007517f, -0.00960791f, -0.02695277f, 0.01970609f, 
    -0.04122965f, -0.02572535f, -0.03289522f, 0.03575177f, 0.00496286f, -0.02569451f, -0.02544578f, -0.05811541f, 
    -0.02633006f, 0.04490354f, 0.00532155f, -0.04020693f, 0.03774812f, 0.02216898f, -0.02744771f, 0.04925698f, 
    -0.00427283f, 0.04351151f, 0.01617788f, -0.04548092f, -0.04795432f, -0.00214646f, -0.01928154f, 0.03624919f, 
    -0.05927870f, 0.04677743f, -0.05866966f, 0.01202628f, 0.02657206f, 0.03780792f, -0.03959623f, -0.03134703f, 
    -0.00644243f, -0.02320303f, -0.02034155f, -0.04328239f, -0.02685369f, -0.04878403f, -0.03684428f, 0.03387284f, 
    0.00605501f, -0.03574950f, 0.00439642f, 0.02498742f, 0.00507409f, -0.05254094f, -0.04380719f, -0.05636732f, 
    -0.05290921f, -0.05703042f, 0.04669931f, 0.01014600f, -0.04269051f, 0.04260483f, -0.01842527f, -0.06058028f, 
    0.04352788f, 0.04436320f, -0.02524797f, 0.02550733f, -0.02184765f, -0.01844218f, -0.01051940f, -0.00235982f, 
    0.04902192f, 0.04338803f, -0.02197256f, 0.04043185f, 0.03659004f, -0.04505261f, -0.04343516f, -0.06420688f, 
    0.02004235f, -0.05027376f, 0.04469462f, -0.01189294f, -0.00650512f, -0.02414469f, -0.03623939f, -0.01864992f, 
    -0.00777962f, 0.00279918f, 0.02869730f, -0.04916910f, 0.04659469f, -0.01818118f, 0.04778712f, 0.03425476f, 
    -0.05326046f, -0.04473065f, 0.01843423f, -0.00291032f, -0.00106581f, -0.06315888f, 0.03353785f, 0.06657094f, 
    0.03334063f, 0.03616253f, -0.05261574f, -0.00678536f, 0.01022820f, 0.04207418f, 0.02150727f, -0.05947005f, 
    0.00656398f, 0.04758149f, 0.03083064f, 0.03676800f, 0.02207627f, -0.02238248f, -0.00270509f, 0.01266456f, 
    0.04909964f, -0.00125765f, 0.00747918f, 0.04866450f, -0.05832756f, 0.02728378f, -0.05745369f, -0.03113556f, 
    0.03946761f, -0.02910120f, -0.04214929f, 0.02213795f, 0.04972112f, -0.04604315f, 0.03888206f, -0.01317111f, 
    0.02277218f, -0.03799823f, 0.04451114f, -0.02834982f, 0.00961649f, -0.00477185f, 0.00992142f, -0.04156130f, 
    0.03165547f, 0.02497054f, 0.03770752f, 0.05297441f, -0.05132154f, -0.01284986f, 0.00424999f, -0.00832043f, 
    0.00241600f, 0.00629597f, 0.02395799f, -0.01996341f, -0.01959727f, -0.03231778f, -0.01328038f, -0.04214817f, 
    -0.06284974f, 0.00790560f, 0.02058387f, -0.01702258f, 0.04351217f, 0.04009309f, -0.02736286f, 0.00253086f, 
    -0.03342611f, -0.00454903f, -0.05548551f, 0.02547946f, 0.04271273f, 0.00501950f, -0.00625667f, 0.03641280f, 
    -0.00665314f, -0.00789115f, -0.00881047f, 0.01427121f, 0.05020725f, -0.02952960f, 0.02780266f, -0.00466088f, 
    0.03291763f, -0.02444907f, 0.03639771f, -0.04838904f, 0.01509716f, -0.01132124f, 0.02369765f, -0.03002092f, 
    -0.00218925f, -0.01594792f, 0.02160469f, -0.02495521f, -0.02026819f, -0.06331419f, 0.03463834f, -0.05628798f, 
    0.02853565f, 0.01236385f, -0.02639369f, -0.06093231f, -0.04491041f, -0.02182620f, 0.03965851f, 0.01693953f, 
    0.01905813f, -0.00020274f, 0.02367766f, 0.01860745f, -0.03066573f, -0.06298868f, -0.01769936f, 0.01451281f, 
    0.01898958f, -0.05572727f, 0.00773078f, 0.04527728f, 0.01655407f, 0.02284583f, -0.06269853f, -0.03595536f, 
    0.02098902f, -0.01053174f, 0.00526808f, -0.05763386f, -0.04702455f, 0.02777906f, 0.01732724f, 0.01952428f, 
    -0.01998703f, -0.06141416f, -0.00721240f, -0.00218869f, 0.00029758f, 0.02306531f, 0.01278810f, -0.03619021f, 
    -0.06183930f, 0.02746902f, -0.06807102f, -0.03870249f, -0.03759018f, -0.01614571f, -0.00195237f, -0.04628100f, 
    0.02097263f, -0.01021639f, -0.02613903f, -0.01079404f, 0.00913549f, -0.01270698f, -0.00507466f, -0.00467064f, 
    -0.05636931f, -0.03443543f, -0.04374656f, -0.01145891f, 0.00560189f, -0.00669388f, -0.02855856f, 0.03175394f, 
    -0.06079962f, -0.01521489f, 0.00073956f, -0.01335205f, -0.02347744f, 0.01147134f, -0.06145639f, -0.04008630f, 
    0.00454938f, -0.01112866f, 0.06090496f, -0.04943571f, -0.03938131f, 0.05486108f, -0.01585914f, -0.03049071f, 
    -0.01779737f, 0.00326250f, -0.03117697f, 0.02799418f, -0.02346916f, 0.03387283f, -0.02104773f, 0.00582473f, 
    0.03088231f, 0.02951437f, 0.00031089f, 0.00890763f, -0.02969212f, -0.01625354f, 0.03771763f, -0.04265247f, 
    -0.06132330f, -0.04409591f, 0.04937144f, -0.05622641f, -0.03033834f, -0.00815259f, -0.04076750f, -0.04706116f, 
    -0.02657376f, 0.01940687f, -0.05974512f, -0.06192203f, 0.01200515f, -0.00170942f, -0.03040259f, 0.00461390f, 
    0.01684375f, 0.00238141f, 0.05046398f, -0.05497716f, 0.02939434f, -0.05391213f, -0.00464847f, 0.03289789f, 
    -0.00990630f, -0.05500038f, -0.06076622f, 0.01139074f, -0.00686743f, 0.03153880f, -0.01923349f, -0.00487657f, 
    -0.01044884f, -0.03210331f, -0.04552038f, 0.02760230f, 0.01538283f, -0.02722740f, -0.04082488f, 0.02502458f, 
    0.02953562f, 0.04305182f, -0.01907365f, 0.01849246f, -0.01815372f, -0.02573265f, 0.00202518f, -0.04043103f, 
    -0.01666188f, -0.04127504f, 0.00347438f, -0.03147262f, 0.02952128f, 0.02698671f, 0.04869756f, 0.03197432f, 
    0.02880529f, -0.00438894f, -0.04262993f, 0.00850673f, 0.03728305f, 0.04291875f, -0.03939785f, 0.02353983f, 
    0.01251320f, -0.03021654f, 0.02918147f, 0.04079833f, -0.04190120f, 0.00326123f, -0.00264585f, -0.00523879f, 
    0.03278375f, -0.00214877f, 0.02823355f, 0.00013293f, 0.01248913f, -0.00379714f, -0.00847858f, 0.03333699f, 
    -0.02966345f, 0.02539502f, -0.00027283f, -0.00047578f, 0.01295247f, 0.00096071f, 0.00025062f, -0.00246421f, 
    0.01970274f, 0.00033521f, -0.05452039f, 0.04016643f, -0.00749089f, -0.04661201f, -0.06406066f, -0.00386813f, 
    0.00115198f, -0.05157733f, 0.05156947f, 0.03925186f, -0.01280610f, -0.04529428f, 0.04297994f, 0.04236216f, 
    0.01471466f, -0.02763182f, 0.04900278f, 0.02026652f, 0.03465483f, 0.04392704f, -0.00728351f, -0.05519209f, 
    -0.01125759f, 0.02978404f, -0.04906346f, -0.02448910f, -0.02201867f, -0.01960604f, -0.05337190f, 0.00782575f, 
    -0.02273286f, 0.00251861f, -0.01387052f, 0.04330919f, -0.02508735f, -0.02156365f, 0.02312239f, -0.06171241f, 
    -0.05019109f, -0.05256111f, -0.00040349f, 0.05364807f, -0.01040197f, 0.05039424f, -0.03286667f, 0.04548701f, 
    -0.04448096f, -0.06133512f, -0.03979867f, -0.04647163f, -0.04203934f, 0.04209030f, -0.02249307f, -0.05551079f, 
    0.01234395f, 0.03023577f, -0.04167603f, -0.02544912f, 0.05477080f, 0.00358633f, 0.03866542f, -0.00759736f, 
    -0.06043115f, 0.00713119f, 0.02362408f, -0.04687293f, 0.04473300f, -0.04355732f, -0.05083311f, 0.04902862f, 
    -0.05677261f, -0.04957224f, -0.01965032f, -0.05068701f, 0.01583340f, -0.01844511f, -0.03502325f, 0.01613726f, 
    -0.01735483f, -0.04203306f, -0.04303506f, -0.06422667f, 0.00005077f, 0.03415232f, 0.03344610f, -0.00880521f, 
    -0.03868804f, -0.01503887f, 0.00602820f, -0.03516626f, 0.04245780f, 0.05294274f, 0.00569214f, 0.00509944f, 
    -0.05893276f, 0.01061244f, -0.02628988f, 0.00707626f, -0.03407435f, 0.01861244f, -0.00896394f, -0.00185719f, 
    0.04650681f, 0.01248097f, -0.05518213f, -0.00738390f, 0.02705908f, -0.03675316f, 0.01152818f, -0.04791432f, 
    -0.03615427f, -0.02641939f, -0.01101903f, -0.03700516f, 0.03144928f, -0.00941404f, -0.00946086f, -0.01580716f, 
    -0.00018390f, 0.02134404f, -0.04860068f, -0.01148234f, -0.03588445f, -0.03376464f, 0.02049746f, -0.01793110f, 
    0.00415964f, -0.04850198f, 0.00901470f, -0.03666655f, 0.04650548f, -0.02213895f, -0.00643215f, 0.01359664f, 
    0.03945600f, 0.00345241f, 0.01615618f, -0.00645686f, 0.01194513f, 0.01824057f, 0.01783445f, 0.02066670f, 
    0.02716199f, 0.04403646f, -0.04777651f, -0.01452613f, 0.00662649f, 0.04627410f, -0.05886971f, -0.04680109f, 
    0.03738593f, -0.01934242f, 0.05003700f, 0.01300664f, 0.00729212f, -0.00369779f, -0.05644873f, 0.01367874f, 
    -0.02209447f, 0.03738168f, -0.05783492f, -0.02626976f, -0.05489198f, -0.01009941f, -0.04881551f, 0.00028409f, 
    0.00783490f, 0.02266852f, -0.02739266f, 0.02854839f, 0.05002825f, 0.02325742f, 0.01276745f, -0.04938021f, 
    -0.04161497f, 0.00344568f, -0.00450985f, -0.04564946f, 0.00594404f, -0.02519031f, -0.03838477f, -0.02398100f, 
    -0.00177643f, -0.04009925f, 0.00715176f, -0.04612062f, 0.03627163f, -0.00761061f, 0.03367151f, 0.04896770f, 
    0.01174803f, -0.04643264f, -0.05861441f, -0.01392726f, -0.05341115f, 0.02649574f, -0.02270655f, 0.01882336f, 
    0.01732326f, 0.01541658f, -0.06323186f, 0.02034328f, 0.04140235f, 0.02748118f, 0.02469624f, 0.04165162f, 
    -0.02815588f, -0.04114891f, -0.02145321f, 0.02757632f, -0.00303042f, -0.00757104f, 0.02250187f, -0.01297309f, 
    -0.03329696f, -0.03641529f, -0.05832284f, -0.00261243f, -0.00663032f, -0.02775284f, -0.05925090f, -0.05035549f, 
    -0.03520165f, 0.02329152f, 0.02697630f, -0.02268106f, -0.01985141f, -0.02948269f, 0.04795079f, 0.04514902f, 
    0.03377111f, -0.01642543f, 0.00313825f, 0.03591215f, -0.05287629f, -0.00558720f, 0.00088284f, 0.02267215f, 
    0.00162998f, -0.01539407f, 0.02204146f, -0.04692663f, -0.04908796f, 0.02015506f, -0.03952358f, 0.04073589f, 
    -0.03138761f, 0.02392094f, 0.04875209f, -0.03082111f, 0.05560875f, -0.03356130f, -0.02878472f, -0.05288839f, 
    -0.01807304f, 0.01443938f, -0.03306074f, -0.04461641f, 0.04076439f, -0.02102624f, 0.01568134f, -0.01945436f, 
    -0.05700345f, -0.03127836f, -0.04533007f, -0.01250707f, 0.03376504f, 0.01799355f, 0.04594372f, -0.04613209f, 
    0.04542316f, 0.01999111f, -0.05042673f, 0.04588189f, 0.01347759f, -0.03143765f, 0.02396325f, -0.02510648f, 
    -0.02418457f, 0.00295110f, -0.06081717f, 0.01503325f, -0.03505586f, -0.02694374f, 0.02601639f, 0.02407072f, 
    -0.02157162f, 0.04747340f, -0.00895488f, -0.04374237f, 0.04036656f, 0.01493561f, 0.02963966f, -0.00744391f, 
    -0.02968953f, 0.04035494f, -0.02636963f, 0.02714185f, -0.02769710f, -0.04342898f, 0.01637584f, -0.05681571f, 
    0.02549767f, 0.04561699f, -0.01241821f, -0.03151167f, 0.01205703f, -0.02777249f, -0.01297032f, 0.01968386f, 
    -0.02348995f, 0.00704289f, 0.02181147f, -0.03785828f, 0.01553964f, 0.03498856f, -0.05017322f, -0.00417184f, 
    0.00161485f, -0.04237587f, -0.05350462f, -0.01123689f, -0.00783523f, -0.02909881f, 0.03837508f, 0.04047942f, 
    -0.03623357f, -0.00044041f, -0.03250256f, -0.03070203f, 0.00880831f, 0.02908636f, -0.04636768f, 0.02610035f, 
    -0.05398797f, 0.00965136f, 0.00469094f, 0.01739686f, -0.04040034f, -0.05927026f, -0.00057603f, -0.03760356f, 
    -0.06459803f, 0.05168529f, -0.01258617f, -0.00871819f, -0.06018576f, -0.05778579f, -0.05099755f, 0.02637071f, 
    0.01681341f, 0.02825101f, -0.05106108f, -0.05106928f, -0.00129811f, 0.03339389f, -0.00501577f, -0.00441799f, 
    -0.05704040f, 0.03958856f, 0.01866698f, -0.01262974f, -0.04536006f, -0.02781652f, -0.05431913f, 0.00745697f, 
    -0.04561651f, -0.01930771f, -0.03369539f, 0.04850620f, -0.04291143f, -0.01046254f, -0.04976231f, -0.05739392f, 
    0.00632542f, -0.00521471f, -0.04647706f, -0.03199662f, -0.03316754f, -0.00382670f, 0.04741702f, -0.02568083f, 
    -0.03221160f, 0.01561087f, 0.04347360f, 0.03810337f, -0.02058511f, -0.01092882f, -0.04899001f, 0.01787810f, 
    0.00186306f, 0.04118596f, 0.03873834f, 0.00693219f, -0.02132676f, -0.04715181f, -0.01210781f, -0.03959035f, 
    -0.01808151f, -0.03186714f, 0.02747395f, -0.04610373f, -0.02736370f, 0.02822975f, 0.03461425f, -0.05094092f, 
    0.02126450f, 0.00920834f, -0.04292994f, -0.05131103f, -0.01203073f, -0.03075893f, 0.00982471f, -0.01115877f, 
    -0.00896941f, 0.03884274f, 0.03585167f, -0.06360929f, -0.01965428f, -0.04177624f, -0.03379260f, -0.02385216f, 
    0.00800360f, 0.03154520f, -0.04749658f, 0.00047438f, -0.04665159f, -0.02942393f, -0.01087508f, 0.04706243f, 
    -0.05236358f, -0.05752064f, 0.02827210f, -0.01311790f, -0.00079551f, -0.03363591f, -0.00800782f, -0.01455136f, 
    -0.00900504f, -0.02158145f, 0.04392121f, 0.01323111f, 0.04644065f, 0.02477820f, 0.03281463f, -0.05168549f, 
    0.01820068f, -0.03149930f, 0.00370578f, -0.04595084f, 0.00268950f, 0.02050996f, 0.02285867f, 0.01804926f, 
    -0.02062908f, -0.01209974f, -0.00465699f, -0.01017062f, -0.04791815f, -0.05394356f, 0.05133809f, 0.02550505f, 
    0.02732669f, -0.01759072f, 0.03420274f, -0.01341737f, -0.04471330f, -0.03455875f, -0.02199539f, -0.03719209f, 
    -0.01093280f, 0.00246983f, -0.05142187f, 0.00647491f, -0.03471516f, -0.01474650f, -0.01973785f, -0.00499211f, 
    0.01806776f, -0.04579885f, -0.03109673f, -0.04801671f, 0.04521402f, -0.03194715f, -0.01904113f, -0.01251347f, 
    0.04721300f, -0.06562414f, 0.00017627f, 0.04530473f, -0.02649999f, -0.04331366f, -0.01095676f, -0.03596042f, 
    0.04433744f, 0.04463474f, -0.00700333f, -0.02620515f, -0.04997511f, 0.04246652f, 0.03230899f, -0.05256594f, 
    -0.01689887f, -0.00996242f, -0.06559551f, -0.03081845f, -0.02655490f, 0.00399759f, -0.00606101f, 0.02186748f, 
    -0.02346507f, -0.04730780f, 0.03756663f, 0.01010556f, -0.03479946f, -0.00620469f, 0.00351401f, -0.01993685f, 
    0.02597247f, -0.04320928f, -0.02137959f, -0.01379915f, 0.00030430f, -0.00558289f, -0.05396944f, -0.01705451f, 
    0.03489743f, 0.04721531f, -0.04865355f, -0.04146333f, 0.05181345f, 0.05509758f, -0.05919486f, -0.02380732f, 
    -0.01942602f, -0.01680277f, -0.05402708f, -0.05394863f, -0.06030822f, -0.06370953f, -0.03094019f, 0.01007406f, 
    -0.04221284f, 0.00501046f, -0.00994235f, -0.04791665f, 0.00321014f, 0.00237827f, -0.06116460f, -0.03041790f, 
    -0.06227796f, -0.01695621f, 0.00761069f, -0.02151818f, 0.01974082f, -0.00487092f, 0.02599006f, 0.03569666f, 
    0.02509287f, 0.02043782f, -0.04143143f, -0.05532406f, 0.00975395f, 0.03602371f, 0.04789022f, -0.01082898f, 
    -0.01722116f, -0.06021762f, 0.03459826f, -0.01487591f, -0.05058003f, -0.04990156f, -0.03766479f, -0.04128380f, 
    -0.04566427f, -0.04376230f, 0.01180106f, -0.04852830f, 0.02192710f, 0.03622480f, -0.04620169f, 0.01920707f, 
    0.04833022f, -0.02509180f, -0.05529065f, -0.02064226f, -0.03087769f, -0.03071948f, -0.06458130f, -0.00932855f, 
    -0.05365054f, 0.03307339f, -0.01683103f, 0.04400033f, 0.01594624f, -0.04142136f, -0.01069550f, -0.00173158f, 
    -0.00900372f, -0.00792593f, 0.03133179f, 0.03164212f, -0.04031212f, 0.03624875f, -0.00031256f, 0.02010319f, 
    0.02056702f, 0.03156079f, -0.05681018f, -0.02386993f, -0.00581088f, -0.02020911f, 0.02303980f, 0.01587975f, 
    0.03317614f, -0.03803005f, -0.00213826f, 0.03475696f, 0.02315378f, -0.04311864f, -0.00357643f, -0.03895115f, 
    -0.05866076f, 0.01033484f, -0.01924959f, -0.04368174f, 0.01384879f, 0.02613023f, -0.05131385f, 0.03195673f, 
    0.00798042f, -0.06137896f, 0.01377429f, 0.01489208f, 0.00930806f, 0.01015041f, -0.03235639f, -0.06014518f, 
    0.00513023f, 0.03327178f, -0.00360259f, -0.00349069f, 0.04718084f, -0.05813777f, 0.00403232f, -0.02984738f, 
    -0.06262124f, 0.05010382f, 0.00870129f, 0.03102575f, 0.01297470f, -0.01226674f, -0.04884138f, -0.00079036f, 
    0.04509607f, -0.03224982f, -0.04987497f, -0.05465418f, 0.01019697f, 0.01605408f, 0.00055610f, 0.04811751f, 
    -0.00823207f, 0.02609451f, -0.03703439f, -0.06632648f, -0.01745619f, -0.00628949f, 0.01584734f, -0.05374575f, 
    -0.02356692f, -0.00821369f, -0.00480742f, -0.01605955f, -0.01485732f, -0.04571513f, -0.05752971f, -0.02787719f, 
    -0.00549121f, -0.02567963f, 0.03531733f, -0.06650440f, 0.04818742f, 0.03795081f, -0.00053577f, -0.02092157f, 
    0.03567201f, -0.05204581f, 0.00641016f, -0.00908460f, 0.01195896f, 0.01920999f, -0.00187763f, -0.04265619f, 
    -0.03705404f, 0.03139084f, -0.04581311f, 0.04118708f, -0.01960636f, -0.00913021f, -0.02363729f, -0.03017351f, 
    -0.01959427f, 0.05173862f, 0.03877386f, -0.04929409f, -0.00793779f, 0.03111596f, -0.02113468f, -0.03473793f, 
    -0.05760501f, -0.02834303f, 0.05157797f, -0.02297591f, 0.04871491f, 0.01198864f, 0.02154369f, -0.04298285f, 
    0.02123665f, 0.03617064f, 0.00534790f, -0.01596627f, -0.02010078f, 0.00370259f, -0.02798585f, -0.02514227f, 
    -0.03055841f, -0.03832999f, -0.06076778f, -0.06116883f, -0.05591856f, 0.04998191f, -0.04831856f, 0.03114929f, 
    0.02102949f, 0.04612226f, 0.01121486f, -0.00558447f, -0.03550409f, -0.02005722f, -0.05318049f, 0.04264458f, 
    -0.01388510f, -0.06716863f, -0.02839260f, 0.02995488f, -0.04827021f, -0.03432764f, -0.03123096f, -0.03042274f, 
    -0.05694522f, -0.01355413f, 0.00366519f, -0.01027919f, 0.02188567f, -0.01007279f, -0.04451657f, -0.01686166f, 
    -0.01503664f, 0.03307370f, 0.00358088f, 0.00736419f, -0.03682987f, -0.04742861f, -0.02816890f, 0.03535280f, 
    0.04244890f, -0.01682238f, 0.01104340f, -0.02497005f, -0.04501154f, -0.01181965f, -0.04202577f, -0.05981689f, 
    0.03645565f, 0.02734360f, -0.01782121f, 0.02566747f, -0.00703560f, 0.00246668f, 0.04064906f, -0.06860420f, 
    -0.04931892f, 0.04162292f, -0.03392914f, 0.01982425f, 0.03243688f, -0.05123878f, 0.02951764f, -0.00758651f, 
    -0.04417558f, -0.02459993f, 0.00099231f, -0.06730676f, -0.00961967f, 0.03822298f, -0.02173750f, 0.03535359f, 
    -0.03553317f, 0.04323620f, 0.04224857f, 0.00786232f, -0.00129165f, 0.00629968f, -0.01233094f, -0.05651532f, 
    -0.04568297f, -0.00262091f, 0.04138439f, -0.05158711f, -0.05266108f, -0.05098619f, -0.01637807f, -0.05617209f, 
    0.01720193f, -0.02594357f, -0.04861298f, 0.04726145f, 0.04512395f, 0.04672319f, -0.04141166f, -0.02451216f, 
    -0.00195524f, -0.02594563f, -0.06767234f, -0.01776395f, -0.02951128f, 0.03546150f, -0.05575179f, -0.04518445f, 
    0.02411215f, -0.00125310f, -0.06289411f, 0.04337423f, -0.05325365f, 0.05010130f, -0.00453375f, 0.01999707f, 
    -0.04918731f, -0.05392596f, 0.04678435f, -0.00155827f, -0.04364608f, -0.04027585f, -0.05890590f, 0.00189502f, 
    0.02991091f, 0.03759983f, 0.03210634f, 0.03990813f, -0.02099311f, 0.04708152f, -0.02104432f, -0.05334250f, 
    -0.04354316f, 0.04003324f, -0.01782977f, -0.04056501f, -0.06629699f, 0.04541883f, -0.06068614f, -0.06348894f, 
    -0.05843014f, 0.04346820f, -0.00157641f, 0.03646094f, -0.06548346f, -0.00529946f, 0.04551960f, 0.01278852f, 
    -0.00917193f, -0.04190662f, -0.00520582f, -0.04365132f, 0.01360971f, -0.06301869f, -0.03038821f, -0.05157875f, 
    0.00393127f, 0.03672617f, -0.05338153f, -0.04799164f, 0.02216874f, -0.05927240f, -0.01196602f, 0.01657535f, 
    0.01099293f, -0.03103962f, -0.05847378f, -0.02378075f, 0.01472081f, -0.04911187f, -0.05476021f, 0.03923230f, 
    0.01869447f, 0.03891481f, 0.01335186f, -0.01239897f, 0.01966824f, -0.02373291f, 0.04870716f, -0.02423274f, 
    -0.06384008f, -0.01215555f, -0.01914126f, 0.02892992f, -0.05595003f, 0.02079595f, -0.01940549f, 0.02068164f, 
    -0.06704839f, -0.04153792f, -0.05691705f, 0.03918519f, 0.00971474f, -0.00790503f, -0.02559082f, -0.06373246f, 
    -0.05683041f, -0.02986022f, -0.01676924f, 0.05248082f, -0.00774341f, -0.03337919f, -0.02154031f, -0.01487136f, 
    -0.03952783f, 0.00070538f, 0.02159113f, -0.04228586f, 0.00768172f, 0.03643398f, 0.03012741f, -0.00350257f, 
    0.02062621f, -0.06191604f, 0.03352842f, -0.04967743f, 0.00571587f, -0.06752994f, 0.01457974f, -0.00039298f, 
    0.03843547f, 0.00224333f, 0.03295007f, 0.02178547f, 0.00655676f, -0.01759244f, 0.00613040f, -0.05136042f, 
    -0.02365755f, -0.01713243f, 0.02103742f, 0.01393045f, -0.00111943f, 0.04590867f, -0.05655680f, 0.04059658f, 
    -0.00749110f, -0.03220006f, 0.02321783f, -0.03089287f, -0.04502809f, -0.01880495f, 0.00954131f, 0.00475401f, 
    0.04696165f, -0.05685376f, -0.04564520f, 0.01888471f, 0.03953626f, -0.00582660f, 0.00368914f, -0.00216650f, 
    -0.00220944f, -0.03131179f, 0.03869002f, 0.02322347f, 0.03616299f, 0.00185747f, 0.02340090f, 0.02049191f, 
    -0.00883857f, 0.03099856f, -0.06480363f, 0.01897995f, 0.02817060f, -0.05302771f, -0.05072525f, -0.00526330f, 
    -0.05093159f, -0.02237689f, -0.02877076f, 0.00311388f, -0.06351193f, -0.05349451f, 0.04641986f, 0.04192235f, 
    -0.05172097f, -0.00651068f, -0.00362384f, -0.02400296f, -0.06398053f, 0.03225822f, 0.01778366f, -0.05375683f, 
    -0.04488473f, 0.02468768f, -0.06374636f, 0.03012270f, -0.03289868f, 0.00902956f, -0.04448254f, 0.03344866f, 
    -0.05461749f, -0.01501046f, 0.03371832f, 0.03019353f, 0.04312988f, 0.00798230f, 0.01793895f, 0.00950888f, 
    0.05270645f, -0.02656848f, -0.05855615f, -0.06401113f, 0.01877593f, 0.02903428f, -0.00539642f, -0.05535585f, 
    0.01347602f, -0.05021420f, -0.06241896f, -0.06399796f, 0.01233909f, -0.05142789f, -0.04318713f, 0.00148585f, 
    -0.04400496f, -0.05762923f, -0.03807791f, -0.02270383f, -0.04175471f, -0.00834753f, -0.01239389f, -0.03356064f, 
    -0.00665636f, 0.02965165f, 0.02592617f, 0.00815644f, -0.05724789f, 0.01635208f, -0.01867919f, -0.01622795f, 
    0.04036676f, -0.03183308f, 0.03086152f, 0.01678543f, 0.01247809f, 0.04964152f, -0.00523582f, -0.05628410f, 
    -0.01858598f, 0.02078873f, -0.01590526f, 0.03598065f, -0.00281081f, -0.03944779f, -0.06401239f, -0.01036387f, 
    0.01829983f, -0.04728866f, 0.04366124f, -0.01683028f, 0.04201673f, -0.05256189f, 0.04668155f, -0.01586056f, 
    -0.04379391f, -0.04418134f, 0.00138964f, 0.00123261f, -0.02123809f, -0.01294724f, -0.04226098f, 0.03390500f, 
    0.01476011f, -0.00787174f, 0.03195177f, 0.05273336f, 0.00637471f, -0.05639753f, -0.02952188f, -0.06092157f, 
    0.05117110f, 0.00931230f, -0.00156539f, 0.04216523f, -0.01636795f, 0.04935148f, -0.05987007f, 0.04461003f, 
    0.02043951f, -0.04483778f, -0.05793498f, 0.02462331f, 0.04974442f, 0.04445063f, 0.00652217f, 0.03125120f, 
    -0.02000751f, 0.01019240f, 0.05115994f, 0.00353545f, -0.03446089f, 0.00459882f, -0.00005385f, -0.02090990f, 
    -0.04287372f, -0.04130162f, -0.03752541f, 0.03469342f, -0.03831428f, 0.03106557f, -0.04609858f, -0.04448174f, 
    -0.01138880f, -0.05867017f, -0.04855646f, -0.02709623f, 0.01814620f, 0.00346106f, 0.00257696f, -0.04332998f, 
    -0.01332909f, -0.00392550f, 0.05083562f, 0.03765173f, -0.06321944f, -0.05429602f, 0.01292462f, -0.03959798f, 
    0.02708947f, -0.01039052f, -0.06478268f, -0.03929234f, -0.02921100f, 0.00719809f, 0.04334697f, -0.00202011f, 
    -0.05289901f, -0.04291136f, -0.04142242f, 0.01257499f, 0.02989532f, -0.02264993f, -0.00335735f, 0.05272068f, 
    0.00480095f, -0.04982875f, 0.01378976f, -0.04895092f, 0.04506617f, -0.05963650f, -0.06326593f, -0.01093394f, 
    -0.03502231f, -0.03228439f, -0.01126845f, -0.04883578f, -0.02868802f, -0.05547478f, -0.04603474f, -0.04852754f, 
    0.00348588f, 0.03829120f, -0.02879016f, 0.03914518f, -0.02603390f, 0.05241988f, -0.05337215f, 0.05085345f, 
    -0.00837984f, 0.05215142f, -0.05572280f, -0.03365671f, -0.03708241f, 0.04697168f, 0.00226633f, -0.06050685f, 
    0.04993850f, 0.02074508f, 0.02857299f, -0.03537221f, 0.03439534f, -0.03050360f, 0.02515575f, -0.05676327f, 
    0.00571002f, 0.02402417f, 0.01063616f, -0.00251783f, -0.00108780f, 0.03748931f, -0.05629392f, 0.01046290f, 
    -0.02793094f, 0.00838071f, 0.00547430f, -0.01111510f, 0.00154945f, -0.01906798f, 0.00402201f, -0.02357500f, 
    -0.02043867f, 0.01057296f, -0.01015552f, -0.01102802f, -0.01290753f, 0.02080268f, 0.04760766f, -0.02528058f, 
    -0.01362690f, -0.00008492f, -0.04882609f, -0.05382391f, 0.02753270f, -0.04454453f, -0.06097827f, -0.03097877f, 
    0.04949932f, 0.03100794f, -0.05414946f, 0.01065678f, -0.01228942f, -0.04575795f, -0.04405201f, -0.00057851f, 
    -0.02602643f, 0.05213323f, 0.04898451f, -0.00898169f, 0.01493263f, 0.00860272f, 0.00287013f, -0.02017853f, 
    -0.01669008f, 0.05034190f, 0.01375975f, 0.01233971f, -0.02410435f, -0.01062685f, -0.06003717f, -0.02998924f, 
    -0.02385046f, -0.03427298f, -0.03005189f, 0.00806441f, -0.03803625f, -0.04529888f, -0.02211428f, -0.04522208f, 
    0.04983835f, -0.05357593f, 0.04976726f, -0.02234586f, 0.02734102f, -0.03340667f, 0.03455459f, 0.01247627f, 
    0.04466163f, 0.02681986f, 0.02026142f, -0.06141127f, -0.04508840f, 0.01791582f, -0.04104650f, 0.03161115f, 
    -0.00141468f, 0.00146281f, -0.04295949f, -0.05282203f, -0.05517956f, -0.02146397f, -0.04996260f, -0.02967150f, 
    -0.04022212f, 0.04038533f, -0.00851033f, -0.02681874f, -0.03973352f, 0.03377150f, 0.00970764f, 0.04763304f, 
    -0.03002507f, -0.00003568f, 0.02018517f, 0.03836831f, 0.04888314f, -0.04577206f, 0.04970011f, 0.02887448f, 
    0.02796366f, 0.01659739f, 0.00360229f, -0.05080060f, 0.02583214f, 0.00430481f, 0.00130842f, -0.01551028f, 
    -0.13767575f, 0.27206004f, 0.10814281f, -0.01653329f, -0.02588000f, -0.00181779f, 0.04575076f, -0.08233105f, 
    -0.14239050f, -0.42913631f, 0.06381480f, 0.26459101f, 0.08079384f, -0.14510125f, 0.03527972f, -0.16792424f, 
    -0.12117113f, -0.14054060f, -0.22165562f, 0.11877609f, 0.22610088f, 0.06261544f, -0.00916566f, 0.00440018f, 
    0.19648597f, 0.26755032f, -0.03355469f, -0.39403495f, -0.36031908f, -0.09003984f, 0.04031845f, 0.10717355f, 
    -0.09422035f, 0.09357238f, 0.06343244f, -0.13450564f, 0.41541466f, 0.42530599f, 0.24489926f, 0.36424765f, 
    0.11325641f, 0.11087953f, -0.02823532f, -0.26293984f, -0.12795036f, 0.42817003f, -0.22147830f, -0.10376666f, 
    0.11109433f, 0.03771710f, -0.06711282f, 0.01870106f, 0.11913062f, -0.07344232f, 0.07833955f, -0.45290157f, 
    -0.31682834f, -0.06083701f, -0.24293822f, 0.09953349f, -0.14895071f, -0.06267956f, 0.23009422f, -0.12777372f, 
    -0.24589753f, -0.02813102f, 0.10158101f, 0.22900082f, -0.18125482f, 0.20175113f, -0.01657645f, 0.05824926f, 
    0.24418145f, -0.00351840f, 0.14471826f, -0.07509620f, -0.26721388f, -0.22210090f, 0.02858097f, -0.03961392f, 
    0.18081914f, -0.52838629f, 0.19784126f, 0.14890641f, 0.29539973f, 0.21450828f, 0.03447389f, -0.01127071f, 
    0.08897325f, -0.05618051f, -0.33793879f, -0.00029373f, -0.09167481f, -0.17486003f, 0.21298708f, 0.20979923f, 
    -0.02487559f, -0.24196993f, 0.10734262f, -0.25302622f, -0.13241705f, 0.43583378f, -0.14906941f, 0.23239000f, 
    0.04103684f, 0.19736254f, 0.09176993f, 0.16516800f, 0.11066340f, -0.09468403f, -0.12214817f, 0.05585606f, 
    0.06065952f, -0.16218230f, 0.02733950f, 0.13104600f, 0.18702042f, -0.23953304f, 0.19382642f, 0.08780259f, 
    0.20084070f, 0.07791388f, -0.14077030f, 0.17357966f, -0.03368595f, -0.09385979f, -0.16369350f, 0.18366857f, 
    0.38474807f, -0.09428281f, -0.01969081f, -0.06889842f, -0.17812443f, 0.21281087f, -0.26865155f, -0.33518642f, 
    -0.43528047f, -0.04944929f, -0.07899748f, 0.05569403f, -0.05498202f, 0.12246513f, 0.01721463f, -0.01168415f, 
    -0.23888291f, 0.01073774f, 0.05524095f, 0.16834506f, 0.00629591f, 0.27466446f, -0.01543195f, 0.08020395f, 
    0.03801242f, 0.03438376f, -0.26032376f, 0.12435379f, 0.03702129f, 0.09313019f, 0.13168339f, 0.05850668f, 
    -0.22483924f, -0.11516915f, -0.14295997f, -0.07805996f, 0.13480076f, 0.15269016f, 0.10732663f, 0.04590590f, 
    -0.21283177f, 0.27047163f, -0.05772837f, 0.03715533f, 0.19075060f, -0.02512929f, 0.07776421f, -0.00548460f, 
    0.05526764f, -0.24884501f, -0.32517606f, -0.17185645f, -0.60836583f, -0.10106572f, 0.14791419f, 0.24591444f, 
    0.18384726f, -0.01308395f, 0.06156218f, -0.09684251f, -0.10819731f, -0.34857380f, 0.00273401f, -0.33314496f, 
    0.21920219f, 0.00515242f, 0.11213765f, 0.21312028f, 0.07128402f, -0.11921964f, -0.09922284f, -0.11265027f, 
    0.17241859f, -0.20628263f, -0.13908930f, -0.06144102f, 0.08704282f, 0.13726149f, -0.03718075f, 0.16926573f, 
    0.16273482f, 0.11089225f, 0.07231365f, 0.21071327f, -0.16961138f, 0.19727124f, -0.01377301f, 0.14087562f, 
    0.14698283f, 0.11444368f, 0.14371446f, -0.13525708f, -0.00053564f, 0.00154987f, 0.00814422f, 0.16216798f, 
    0.40614018f, -0.80239332f, -0.07889598f, 0.13057585f, 0.18993664f, 0.19925492f, 0.00854781f, 0.20085591f, 
    0.06433319f, -0.15033601f, -0.25152606f, -0.05560979f, 0.37719777f, 0.27836516f, 0.01099530f, 0.00745740f, 
    -0.08750906f, -0.02514229f, -0.05909218f, -0.00235092f, -0.08840624f, 0.06537103f, 0.08272559f, 0.02856086f, 
    -0.23734821f, -0.08762912f, -0.05176526f, 0.12889479f, -0.24686852f, -0.09026946f, 0.02303385f, -0.16092901f, 
    0.05826470f, -0.02745931f, -0.15467004f, -0.10102528f, 0.07081879f, 0.30437902f, 0.17582291f, -0.06143694f, 
    0.07269526f, 0.01248889f, 0.15955791f, -0.01053308f, 0.08484592f, 0.12238176f, -0.03369749f, -0.28262079f, 
    -0.43344346f, 0.05170954f, -0.13792580f, 0.01906803f, 0.32602325f, -0.01480956f, 0.05709629f, -0.09796567f, 
    -0.28476086f, -0.33239859f, -0.06145206f, -0.06035708f, -0.05225805f, 0.13969107f, -0.03253999f, 0.06350540f, 
    0.09593590f, -0.04727427f, 0.03753535f, 0.11891615f, -0.09271281f, 0.01025472f, 0.10647253f, 0.11228255f, 
    0.16376996f, -0.03026773f, -0.09991544f, 0.20198876f, -0.09043133f, 0.11740421f, 0.16784066f, -0.27842554f, 
    -0.14838883f, 0.04978884f, -0.32908881f, 0.42225912f, 0.25834984f, 0.08022095f, 0.14936088f, 0.32565519f, 
    -0.08821472f, -0.09867962f, 0.35525912f, 0.07376422f, 0.13065165f, 0.19787407f, 0.14494058f, 0.00636508f, 
    -0.07427661f, 0.32104090f, 0.06465735f, -0.17034520f, 0.23056178f, 0.20853442f, 0.37875396f, -0.05965847f, 
    0.07132104f, 0.00806204f, -0.35661763f, -0.10372135f, -0.10247433f, -0.33172247f, -0.02920163f, 0.24789083f, 
    0.00375580f, -0.15042961f, -0.07173049f, 0.13604303f, 0.15899830f, -0.22278865f, 0.23264228f, -0.11824045f, 
    -0.10272798f, -0.31045732f, -0.24837479f, 0.05252340f, -0.26684484f, 0.16094147f, -0.22056116f, 0.15644640f, 
    0.18358697f, 0.18285212f, 0.04789249f, -0.14068803f, 0.00248465f, -0.03299180f, 0.01047662f, 0.22229329f, 
    -0.45263392f, -0.35520649f, -0.20206648f, 0.39580157f, 0.07896367f, 0.12998655f, -0.02084048f, 0.12947576f, 
    -0.23040999f, -0.14196132f, -0.10619564f, 0.12008918f, 0.25030604f, 0.13136958f, 0.08368890f, -0.21839251f, 
    0.17929648f, -0.04745023f, -0.15242128f, 0.08505505f, 0.09662385f, -0.01151063f, 0.07298388f, 0.02865277f, 
    -0.02326517f, -0.01316846f, 0.14217438f, 0.04760591f, -0.34493271f, -0.24049415f, -0.02666833f, 0.18311451f, 
    -0.09295852f, 0.28035992f, 0.02855035f, 0.08442246f, 0.25687182f, -0.18429413f, -0.23727845f, 0.21547517f, 
    0.00177430f, 0.02708155f, 0.04587572f, 0.01017243f, -0.14110109f, -0.13991900f, -0.25105974f, -0.40890270f, 
    0.05704204f, 0.25543249f, -0.08125730f, 0.17643310f, -0.01700377f, 0.04688539f, 0.04012369f, 0.09582391f, 
    0.00621024f, -0.46474540f, -0.13789873f, 0.05365241f, -0.01592377f, 0.06006577f, 0.17848273f, 0.10587198f, 
    0.28428319f, 0.07950033f, 0.09212455f, -0.22407277f, -0.06060803f, -0.18272704f, 0.15526360f, -0.13853352f, 
    -0.03778022f, 0.43283141f, 0.05155581f, -0.14652078f, -0.14531206f, 0.07163296f, -0.01841811f, -0.12245966f, 
    0.12018656f, -0.29586253f, 0.04920070f, 0.18167609f, 0.07992122f, -0.11930498f, 0.26347050f, 0.12223075f, 
    0.19135351f, -0.35817751f, 0.30698985f, -0.06745683f, 0.11976086f, 0.26299083f, 0.03848959f, -0.17936651f, 
    0.22236882f, 0.21571098f, 0.09837101f, -0.20960993f, -0.31889066f, -0.19056016f, 0.13221192f, 0.15876935f, 
    -0.07850385f, -0.11209051f, -0.09644543f, -0.32497182f, -0.14180680f, -0.10336203f, 0.17495261f, 0.04852925f, 
    0.25468513f, -0.09896878f, 0.08575272f, 0.16879377f, 0.18833353f, 0.03465174f, -0.35716107f, 0.02652734f, 
    0.14500879f, 0.06016905f, -0.06772905f, 0.32657695f, -0.05003574f, 0.05315527f, 0.02400292f, 0.13258828f, 
    -0.23066211f, -0.17472346f, -0.01261604f, -0.52613056f, 0.08947662f, 0.06826933f, 0.02626009f, 0.03767025f, 
    -0.11438372f, 0.14947475f, 0.16666509f, -0.00844512f, 0.17082459f, -0.12203006f, 0.23962145f, -0.07958046f, 
    -0.36280617f, -0.17667983f, 0.01992866f, -0.02730243f, 0.12999949f, 0.12547179f, 0.34105363f, -0.17651138f, 
    -0.20348240f, -0.42768329f, -0.05132153f, 0.01774386f, 0.19564527f, 0.25214466f, 0.07047064f, -0.10356501f, 
    0.02747292f, 0.07311509f, -0.28757304f, -0.17599867f, 0.15265645f, -0.11837211f, 0.06443104f, 0.23259716f, 
    -0.09571531f, -0.02237776f, -0.07116302f, 0.08357955f, -0.19941108f, -0.07957012f, 0.21208718f, -0.11001529f, 
    -0.15313169f, -0.00944206f, -0.41172212f, 0.02194022f, 0.38970727f, 0.09559162f, 0.21157181f, 0.06075368f, 
    -0.20535561f, -0.32548937f, 0.09033142f, -0.24049532f, -0.02075989f, 0.08285567f, 0.13943365f, -0.23860382f, 
    -0.25230461f, -0.04719336f, -0.28789535f, 0.10775118f, -0.04215740f, 0.23031807f, -0.10295220f, 0.09793333f, 
    0.09943719f, -0.11404160f, 0.03892695f, 0.09607598f, 0.19850658f, 0.00157902f, -0.18581489f, -0.23937693f, 
    0.21623817f, 0.12457166f, 0.26743138f, 0.04027762f, 0.18575172f, -0.04486041f, -0.01693372f, -0.23023537f, 
    -0.05333771f, -0.04288227f, -0.05598110f, 0.03546602f, 0.03540111f, -0.02867029f, -0.02419546f, 0.02690648f, 
    -0.05591235f, 0.02957173f, -0.05374310f, 0.04496893f, -0.05479188f, -0.04467938f, -0.00041047f, -0.04038320f, 
    -0.05424869f, -0.01863892f, 0.02282737f, 0.00009523f, -0.03604388f, 0.04347470f, 0.02522722f, 0.03243851f, 
    -0.04074992f, 0.03243404f, -0.03299038f, 0.05216461f, -0.03619155f, -0.04978397f, -0.02545078f, -0.01590073f, 
    -0.02813312f, 0.01172333f, 0.01419205f, 0.01004332f, -0.03869210f, -0.01228472f, 0.04881037f, -0.02430660f, 
    0.02775883f, -0.03203307f, -0.03531764f, -0.00234479f, -0.06464141f, -0.03311307f, 0.00324503f, -0.00260754f, 
    0.02627843f, -0.03029106f, -0.06642041f, 0.05221916f, 0.00661470f, -0.01093750f, -0.03382628f, 0.04738665f, 
    0.04904584f, -0.00093383f, -0.02841930f, 0.04407030f, 0.01472455f, -0.05512989f, -0.03077093f, -0.05331534f, 
    0.04750629f, 0.01727475f, -0.01162268f, -0.00534843f, -0.05425343f, 0.03600392f, 0.02796289f, 0.03150555f, 
    0.01983227f, 0.01506164f, -0.01456986f, 0.05435425f, -0.00130770f, 0.01528708f, 0.00516264f, 0.00021141f, 
    0.04629303f, -0.05076188f, -0.03512223f, -0.02837453f, -0.00596370f, -0.03714989f, -0.01007467f, -0.03003625f, 
    0.05100835f, -0.04698917f, -0.02260374f, -0.03381250f, -0.02571558f, -0.02123723f, -0.04538455f, 0.02653995f, 
    -0.05868481f, -0.00364593f, -0.02969738f, -0.02715057f, -0.01836208f, -0.04924528f, 0.00757440f, 0.02564823f, 
    -0.03932087f, -0.00055100f, 0.00399136f, -0.04905815f, 0.00566211f, -0.03164668f, -0.05569635f, 0.04625519f, 
    -0.00624932f, 0.03367114f, -0.01942413f, 0.04485970f, -0.00135407f, -0.01770371f, -0.02217773f, -0.01768000f, 
    0.05204008f, -0.00667375f, -0.03051895f, -0.02849842f, 0.00182829f, -0.02527007f, -0.05258242f, -0.03407909f, 
    0.04677890f, -0.02027130f, -0.05714491f, -0.02068582f, -0.03363192f, 0.03081608f, -0.05717943f, -0.03096781f, 
    0.01701293f, 0.04978541f, 0.00374862f, 0.04116751f, -0.04415264f, -0.02833463f, -0.01193232f, -0.02736432f, 
    -0.00721310f, -0.05866957f, -0.01055897f, -0.02829062f, -0.01427546f, -0.02063759f, 0.04161965f, 0.02693447f, 
    -0.02578407f, -0.00511669f, -0.03475636f, -0.01397190f, -0.05269516f, -0.05230103f, 0.04232506f, 0.01651960f, 
    0.04454836f, -0.04967124f, 0.02181975f, -0.00813776f, 0.01935219f, 0.00017565f, -0.05822346f, -0.04863990f, 
    0.01689111f, -0.04960119f, 0.04774504f, 0.00181112f, -0.02219011f, -0.01518462f, 0.03145802f, 0.02207483f, 
    0.03024857f, 0.01066845f, -0.06504628f, -0.05666354f, -0.02717683f, -0.04196136f, 0.04667779f, -0.01773902f, 
    0.00334442f, 0.02240156f, 0.04977325f, -0.04434554f, -0.01272200f, 0.00758232f, -0.06179516f, 0.00466062f, 
    0.00577845f, 0.03389965f, 0.04557647f, -0.04399306f, -0.00503119f, -0.04612384f, -0.01615917f, 0.01714123f, 
    0.04168516f, 0.00097040f, 0.02487295f, 0.04471064f, 0.01254758f, -0.05209614f, 0.03416261f, -0.04279090f, 
    -0.00791570f, -0.04939399f, 0.00676310f, -0.03699832f, -0.00909662f, -0.04279017f, 0.01576010f, -0.03216852f, 
    0.03180048f, -0.03013203f, -0.02321794f, 0.05182731f, 0.02480810f, 0.01394411f, -0.05674028f, 0.04600517f, 
    0.03890707f, -0.04003882f, -0.03298828f, 0.00578226f, -0.01483758f, 0.04020172f, -0.05947110f, 0.03914877f, 
    -0.05106321f, 0.04021870f, -0.00610775f, 0.04807317f, 0.01214124f, 0.01688948f, 0.02405467f, -0.02773045f, 
    -0.06192192f, -0.03442920f, -0.03462903f, 0.00763294f, 0.03990760f, -0.06078998f, -0.03628779f, -0.01955357f, 
    0.03441589f, -0.04921968f, 0.01480988f, 0.04020337f, 0.01618830f, -0.04081384f, -0.02169191f, 0.01736117f, 
    -0.00940657f, 0.04085828f, 0.03614844f, -0.03135442f, 0.04168440f, 0.04571598f, 0.02891742f, 0.03229570f, 
    -0.04475297f, -0.02014775f, 0.02019639f, 0.00292975f, 0.04530307f, -0.01888317f, 0.02959094f, -0.03364371f, 
    0.01578631f, -0.01416044f, -0.05452597f, 0.01029309f, 0.00602828f, 0.01895450f, 0.02312872f, 0.00869755f, 
    0.04988045f, -0.04955969f, -0.04275825f, 0.03342845f, 0.05233004f, -0.02063338f, -0.03669548f, -0.04358294f, 
    -0.06108314f, -0.01413695f, -0.00583516f, 0.01839684f, -0.05447936f, -0.00552188f, -0.01996896f, -0.03516108f, 
    0.00250364f, -0.04780245f, -0.03493898f, -0.01311271f, -0.05630102f, 0.00089476f, -0.01412431f, 0.03370025f, 
    0.02456434f, 0.01644002f, -0.02905317f, 0.01315957f, 0.01207280f, -0.01108986f, -0.03667672f, -0.04622089f, 
    0.02236098f, -0.03504196f, -0.04249719f, 0.03523808f, -0.01472878f, -0.05021202f, 0.00861354f, -0.04219619f, 
    0.00649574f, 0.06584017f, -0.01564114f, 0.03441755f, -0.06218249f, 0.05048893f, -0.02971066f, -0.04829965f, 
    0.03101469f, -0.03569425f, -0.02723067f, -0.06323805f, 0.04302576f, -0.01860987f, -0.04752868f, 0.01146163f, 
    -0.02077770f, -0.05959529f, 0.03329832f, -0.03995889f, 0.04051684f, -0.06156236f, -0.02044421f, -0.05500742f, 
    -0.04462820f, -0.04369876f, 0.04884682f, -0.06538276f, -0.01882242f, -0.00061120f, -0.05607962f, 0.00151219f, 
    0.01823842f, -0.05947181f, -0.04049464f, 0.03444618f, -0.06601825f, 0.03537420f, 0.01862889f, -0.04729235f, 
    0.04058082f, -0.03510262f, -0.02055809f, -0.03755803f, 0.00595828f, 0.00125846f, -0.01727998f, -0.02707197f, 
    0.03240715f, -0.04387842f, 0.00316008f, -0.02029644f, -0.03897133f, -0.00445025f, -0.05366791f, -0.02240799f, 
    0.01756315f, -0.02198646f, 0.05527829f, 0.04592256f, -0.01756076f, -0.04742125f, 0.06086296f, -0.04741596f, 
    -0.01693760f, -0.03324369f, -0.04740018f, 0.04205326f, -0.00641981f, -0.02221012f, 0.00891420f, -0.04418759f, 
    0.00923689f, -0.02986628f, 0.02138258f, -0.03468874f, 0.02223287f, 0.03863293f, -0.06818418f, 0.04911868f, 
    -0.03110330f, 0.02090768f, 0.04121774f, 0.01896985f, 0.01782441f, 0.03827258f, -0.02920940f, 0.03871730f, 
    -0.00780765f, 0.03182224f, 0.05600636f, 0.01205408f, 0.04297901f, 0.04783387f, -0.00606050f, -0.04800432f, 
    -0.02845302f, 0.04302547f, 0.04344507f, -0.01403434f, -0.03039046f, 0.02530605f, 0.04633915f, -0.06143632f, 
    0.00666467f, 0.04072410f, 0.01364894f, -0.04673791f, -0.02612658f, 0.01992007f, 0.05543550f, -0.05124062f, 
    -0.03899863f, -0.02284573f, 0.00899289f, -0.05294620f, 0.01533838f, 0.01672158f, -0.01351065f, 0.02512913f, 
    -0.02296185f, 0.03907403f, -0.01153251f, -0.02876264f, -0.03026949f, 0.01732638f, -0.05745956f, -0.05023566f, 
    -0.03330521f, 0.00894152f, 0.00374696f, 0.02852248f, -0.06053606f, -0.00581277f, 0.00337329f, -0.06070261f, 
    -0.00889916f, 0.04358844f, -0.00126204f, 0.01800671f, -0.03721692f, -0.04882201f, 0.02125926f, -0.00074213f, 
    0.05718978f, 0.03716377f, 0.03090831f, 0.04015685f, 0.01912398f, 0.02294406f, 0.00286238f, -0.01374478f, 
    -0.03945662f, 0.00374850f, -0.00727290f, -0.01998612f, 0.02916951f, -0.04805645f, -0.03910273f, 0.01324337f, 
    -0.03662166f, 0.01303263f, 0.00044816f, 0.02249137f, 0.00813337f, 0.04480881f, -0.04993306f, -0.01093014f, 
    -0.02842019f, 0.04540839f, -0.00441373f, 0.03395659f, -0.05713546f, 0.00451396f, -0.04439703f, -0.03745237f, 
    -0.01156303f, -0.05169072f, -0.03338266f, -0.02278292f, 0.00424232f, 0.01783326f, -0.01096683f, 0.02051393f, 
    -0.04001444f, -0.04021610f, -0.03892129f, -0.06893726f, -0.01201403f, -0.04127614f, -0.05215856f, 0.01147319f, 
    0.00019414f, -0.02169120f, 0.04329597f, 0.01383459f, -0.02220919f, 0.01342235f, -0.03066395f, -0.01372839f, 
    -0.03235171f, 0.04746500f, -0.02282012f, 0.03322707f, 0.03109051f, -0.01104563f, 0.02284991f, 0.03953525f, 
    0.02504141f, -0.01291777f, 0.04219887f, 0.02157271f, 0.02983351f, -0.05981006f, -0.03818803f, -0.02908941f, 
    0.02893931f, 0.01511635f, -0.05127176f, 0.01280906f, -0.01744394f, -0.00714514f, -0.03576876f, 0.03671189f, 
    0.04804458f, -0.06294433f, 0.02819845f, 0.04545897f, 0.00742441f, 0.01262479f, 0.03648142f, 0.03041477f, 
    -0.02652675f, -0.00526981f, -0.02548476f, 0.02729371f, -0.02102870f, 0.02389112f, -0.02806232f, -0.06949746f, 
    -0.05797568f, 0.04422270f, -0.04791578f, 0.01150704f, -0.03669571f, 0.03099402f, 0.00911480f, -0.01348888f, 
    -0.03123628f, 0.03273241f, -0.03508500f, 0.00316113f, 0.00749303f, -0.02375202f, 0.02973203f, 0.04745623f, 
    0.00838270f, -0.06506275f, -0.03081955f, -0.04328258f, 0.03261396f, -0.00317473f, -0.05717831f, 0.03853301f, 
    0.03595415f, -0.03588343f, -0.03185372f, 0.02836967f, -0.02694771f, -0.02407256f, -0.06514192f, 0.01181675f, 
    0.04189248f, -0.04677381f, -0.01217979f, 0.02558268f, -0.00435315f, 0.03871134f, 0.01581745f, 0.03806399f, 
    0.03424795f, 0.00755957f, 0.01739348f, 0.00170852f, -0.03487426f, -0.02188198f, -0.03377967f, 0.00346629f, 
    -0.03583510f, -0.01349106f, 0.00639193f, -0.01484922f, -0.06106253f, 0.02609379f, -0.04595809f, 0.04002409f, 
    -0.04628696f, -0.00208380f, 0.00392991f, -0.01972819f, 0.03509999f, -0.02337272f, -0.01777567f, -0.01964027f, 
    -0.06258314f, -0.03363111f, 0.03669274f, 0.04309214f, -0.03615669f, -0.05634575f, -0.02581425f, -0.03205961f, 
    0.01580687f, -0.00602636f, 0.03159108f, 0.03214172f, -0.05336260f, 0.03988500f, -0.00596910f, -0.00559873f, 
    0.04461071f, -0.03488081f, -0.01376656f, -0.06808695f, 0.01421464f, -0.02645162f, 0.03819046f, -0.06417798f, 
    0.00445316f, 0.04877348f, 0.02206039f, -0.01253919f, 0.02146572f, 0.04008203f, -0.01844572f, -0.02963562f, 
    0.02904483f, -0.01670288f, -0.02785887f, -0.03689174f, 0.01721662f, 0.04535803f, 0.04032503f, 0.02064924f, 
    -0.01153122f, -0.04977857f, 0.04434005f, 0.00480094f, 0.03029482f, -0.05629818f, 0.01234470f, 0.00907751f, 
    -0.02562069f, -0.01754452f, -0.06545730f, -0.06727564f, 0.01890591f, -0.03137916f, 0.00516812f, -0.01884726f, 
    0.01953115f, -0.04700239f, -0.06789455f, -0.00428936f, -0.06343471f, 0.03325994f, -0.06442130f, -0.05194907f, 
    -0.01981068f, -0.04296713f, -0.04720920f, -0.06252379f, -0.06166387f, -0.04195875f, -0.01080432f, -0.00360706f, 
    -0.00048607f, -0.00363199f, 0.00733933f, -0.06280150f, 0.03205407f, -0.04245438f, -0.00983824f, -0.05994929f, 
    0.00448628f, 0.03732645f, 0.03782964f, 0.01195169f, 0.03063466f, -0.02055999f, -0.00432379f, 0.03594163f, 
    -0.02277345f, -0.06360869f, 0.03701646f, -0.04896888f, -0.01493563f, -0.02971704f, -0.07871501f, -0.04410616f, 
    0.01588957f, 0.02659212f, 0.02495531f, -0.01904428f, 0.03844808f, -0.00186991f, 0.03818080f, -0.05235876f, 
    -0.04183917f, -0.02224629f, -0.04097851f, 0.01531923f, -0.05730993f, 0.01230860f, -0.06070761f, 0.04448593f, 
    0.00961588f, -0.02493830f, 0.00186206f, -0.04444863f, -0.06097776f, 0.04289272f, 0.04016038f, 0.01600240f, 
    0.00493352f, -0.02165146f, 0.01435565f, -0.01690007f, -0.04159026f, 0.01792910f, 0.02984680f, -0.01333937f, 
    0.02178274f, -0.00462119f, 0.00542534f, -0.02464868f, 0.02665569f, -0.00430007f, -0.06032004f, 0.04512509f, 
    0.03897622f, 0.02078282f, 0.03944562f, -0.06519394f, 0.01202607f, -0.04297890f, -0.00831764f, -0.03296091f, 
    0.03791362f, 0.02380924f, 0.00663139f, -0.03077258f, -0.02504299f, 0.03081498f, -0.00654056f, -0.02902751f, 
    -0.04697266f, -0.02348854f, -0.04866482f, -0.04967713f, -0.00540314f, -0.04916273f, 0.04531351f, -0.04760833f, 
    -0.05236128f, 0.03206398f, 0.01480909f, 0.00056847f, -0.05372155f, 0.04529200f, 0.03574672f, -0.05945412f, 
    0.03567510f, 0.02187202f, -0.00173363f, -0.04988629f, -0.06806976f, 0.04206698f, -0.03858085f, 0.04018636f, 
    0.00770635f, -0.03419483f, -0.04099880f, -0.06245058f, -0.02138325f, -0.07195722f, -0.00256991f, -0.06475098f, 
    -0.03586113f, -0.00713361f, 0.03975895f, -0.01168143f, 0.04635028f, 0.04067923f, 0.04612491f, -0.03937570f, 
    -0.00661282f, -0.04942900f, -0.02624446f, -0.03357976f, 0.01621290f, -0.04473441f, -0.03144482f, -0.00288933f, 
    -0.04699843f, 0.01172703f, 0.00431791f, -0.01043860f, 0.00978265f, -0.07197133f, 0.00436699f, -0.01755353f, 
    0.02259055f, 0.04080543f, 0.01411745f, -0.06525826f, -0.02866933f, -0.04649793f, 0.02698368f, 0.01646622f, 
    0.04161895f, -0.03449237f, -0.04431428f, -0.05542586f, -0.05106944f, -0.06898545f, -0.03973533f, -0.02441189f, 
    -0.05019424f, -0.03281078f, -0.02934755f, 0.04317168f, -0.03171311f, 0.03806532f, -0.03511528f, -0.05106920f, 
    -0.02350390f, 0.02416223f, 0.01524989f, -0.06430187f, 0.04524383f, -0.00956389f, -0.02047907f, -0.00101988f, 
    -0.02006120f, 0.04575785f, -0.03193673f, 0.01355281f, -0.01620113f, -0.02254310f, 0.01246306f, -0.05327253f, 
    0.01606523f, -0.04335458f, 0.03099103f, -0.06765247f, -0.06546414f, 0.04688815f, -0.01611791f, -0.05901060f, 
    0.00242466f, -0.03364876f, -0.04151646f, -0.06206511f, 0.00766079f, 0.04297624f, -0.00247041f, -0.06248467f, 
    -0.01685128f, 0.02426856f, 0.03600691f, -0.05004396f, 0.02238019f, -0.02619761f, 0.02768597f, -0.03662671f, 
    -0.05631510f, 0.02771139f, 0.02757304f, -0.04126415f, -0.04913250f, -0.01554810f, -0.01052146f, 0.03435984f, 
    0.02635664f, -0.04080031f, 0.01423343f, -0.06342079f, 0.01772056f, -0.03148639f, 0.03198184f, 0.01894288f, 
    0.02881053f, -0.01363793f, -0.03353575f, 0.03580657f, -0.00500206f, 0.02095911f, -0.05641237f, 0.03517754f, 
    -0.01725654f, 0.00025347f, -0.01331387f, -0.03310528f, -0.00987296f, -0.04012301f, 0.00252548f, -0.02743288f, 
    -0.06050154f, -0.04378738f, 0.04558343f, 0.03599724f, -0.03220324f, 0.00141564f, -0.01128580f, 0.01828750f, 
    0.02023935f, 0.03039157f, -0.02671904f, -0.03403853f, -0.02541050f, -0.02980641f, -0.06332986f, 0.05959534f, 
    0.02042606f, -0.05453324f, -0.04279786f, -0.03934255f, 0.02879601f, 0.03690044f, -0.01084919f, 0.03206851f, 
    -0.00760311f, -0.05185010f, 0.02113650f, -0.01626596f, -0.03002140f, 0.02731921f, 0.02389107f, 0.01374864f, 
    -0.01943872f, -0.05739805f, 0.04651991f, 0.01295268f, -0.04899767f, 0.02157264f, -0.01812927f, 0.04168658f, 
    0.03245863f, 0.01094405f, -0.03664590f, -0.04097028f, -0.06196814f, -0.03562680f, 0.02686603f, -0.06161204f, 
    -0.03998826f, -0.01655669f, -0.01068231f, 0.04628282f, -0.00776031f, -0.02490483f, -0.02311674f, 0.01796829f, 
    -0.06423818f, 0.04917503f, 0.04417060f, 0.03391002f, -0.04863893f, 0.03175760f, -0.03731987f, -0.02809972f, 
    -0.02652591f, -0.03963435f, -0.02019991f, 0.01346560f, -0.03644136f, -0.04411967f, -0.06270953f, -0.05227358f, 
    -0.05799395f, -0.04496369f, 0.03633377f, -0.05426582f, 0.04467772f, -0.06910279f, -0.04167826f, 0.01458820f, 
    0.00874978f, 0.01431252f, -0.01951969f, -0.03744671f, 0.03715414f, -0.05968855f, 0.04545262f, -0.02574095f, 
    -0.05849775f, -0.01007396f, -0.06814449f, 0.02630835f, 0.03616866f, 0.03533047f, -0.06636434f, -0.05927849f, 
    -0.05747218f, -0.05936916f, 0.04547165f, 0.03773807f, 0.02926118f, -0.00802156f, -0.05448323f, -0.00479878f, 
    -0.00555787f, 0.04189402f, -0.04224958f, -0.01057202f, 0.01045375f, -0.02254577f, 0.02514092f, -0.04298820f, 
    0.04148738f, 0.04775063f, -0.03513589f, 0.00390607f, 0.04340671f, -0.06358300f, -0.05905320f, 0.00432441f, 
    0.03857312f, -0.06112971f, 0.00019329f, 0.01520275f, 0.02666339f, -0.03951849f, -0.00711299f, 0.02301440f, 
    -0.02103620f, -0.06325422f, -0.04896129f, 0.02696732f, -0.02758371f, 0.03507673f, -0.00457331f, -0.00389023f, 
    -0.06770664f, -0.01700273f, 0.04774249f, -0.03961837f, -0.00286440f, -0.05584095f, 0.04079404f, -0.04633565f, 
    0.01103147f, 0.01282365f, 0.04510932f, -0.04093517f, -0.01326683f, -0.02723997f, 0.04155212f, -0.06436124f, 
    -0.01941902f, 0.00100575f, -0.02786219f, 0.02596068f, 0.01579542f, -0.02029291f, 0.00881789f, 0.04713265f, 
    -0.06784623f, -0.04243293f, -0.03725317f, 0.03826392f, 0.04588053f, -0.06318431f, -0.00277954f, -0.03405472f, 
    -0.01830837f, -0.03908939f, -0.06697907f, -0.04548120f, -0.03025903f, -0.03860155f, 0.01148107f, -0.02445613f, 
    0.00897501f, 0.02884041f, 0.02177476f, -0.00919712f, -0.04520221f, -0.00999862f, 0.03730378f, -0.04746708f, 
    0.03380344f, -0.02305193f, -0.05219989f, 0.02698018f, -0.00687985f, 0.04759819f, 0.03432015f, -0.02459306f, 
    0.03284610f, 0.04808057f, 0.03927904f, -0.01534587f, -0.04139509f, -0.05671645f, 0.04400682f, 0.00395699f, 
    0.03137023f, -0.01997441f, 0.00763353f, 0.04515693f, -0.02142814f, -0.03312203f, 0.03537431f, -0.02397139f, 
    0.04068712f, 0.04038571f, 0.01879714f, -0.05662872f, -0.04534428f, -0.05743117f, -0.01955740f, 0.01228346f, 
    -0.03204241f, -0.03583740f, -0.05544211f, 0.02540381f, -0.03445040f, -0.01947722f, -0.00177751f, -0.06225226f, 
    -0.07288361f, 0.01681436f, -0.03458293f, -0.02281859f, 0.02940290f, -0.01151296f, 0.01699261f, -0.04666515f, 
    -0.01670070f, 0.01898457f, -0.05531622f, -0.01144676f, -0.02772988f, -0.04567139f, 0.00570835f, -0.06435915f, 
    0.04186188f, 0.00000913f, 0.00461256f, -0.05607844f, -0.06940311f, 0.02772085f, 0.01495771f, 0.02561131f, 
    0.04171485f, -0.02545941f, 0.01098782f, -0.03856417f, -0.02599395f, -0.00208048f, -0.01914368f, -0.01074093f, 
    0.04166184f, -0.02175104f, -0.06496844f, -0.00104101f, -0.00141037f, -0.03481643f, -0.03124686f, 0.02164610f, 
    0.02172040f, -0.03099750f, 0.03552867f, 0.02005208f, -0.05644105f, -0.07226303f, -0.01460354f, 0.02523671f, 
    0.01920732f, 0.01127876f, 0.04068445f, 0.00232091f, 0.03920872f, -0.02995148f, -0.03303753f, 0.04371150f, 
    -0.06497888f, -0.02310517f, -0.03495973f, 0.03447361f, -0.04744777f, -0.05477645f, 0.00245432f, -0.03570186f, 
    -0.04492631f, -0.07285310f, 0.04102435f, -0.02094376f, -0.02118552f, -0.06081878f, 0.02366351f, -0.04780110f, 
    -0.03768766f, -0.05511062f, -0.06975728f, -0.01094211f, -0.06329767f, -0.03424596f, -0.00068304f, -0.04624538f, 
    -0.02267229f, 0.02474285f, -0.00840776f, -0.01361977f, 0.01165073f, -0.05070923f, 0.04142339f, 0.03008939f, 
    0.02938160f, -0.05296714f, -0.06620494f, -0.01796132f, -0.01378125f, -0.00575284f, -0.00736918f, 0.04284662f, 
    0.02023571f, -0.01402340f, -0.05819561f, 0.01433484f, -0.05307322f, 0.02870038f, 0.02767655f, -0.01275186f, 
    0.02349380f, 0.02578772f, -0.03435926f, 0.03174321f, 0.03092460f, 0.03880221f, 0.02642743f, 0.00215851f, 
    0.02125211f, -0.05951731f, -0.04560453f, -0.01750797f, -0.06718151f, -0.04777610f, 0.04000833f, 0.00286148f, 
    0.04127591f, -0.06959859f, -0.01131540f, -0.01764006f, -0.06248983f, -0.02188760f, 0.01155010f, 0.03701704f, 
    0.02955172f, -0.05736744f, 0.03225384f, -0.00961188f, -0.01702067f, 0.00690348f, 0.00172214f, -0.04890294f, 
    -0.03149539f, -0.02268558f, -0.07081980f, -0.05474640f, 0.02931069f, 0.03225458f, 0.03797464f, -0.01049893f, 
    -0.07395940f, 0.00448440f, -0.02851276f, -0.00476450f, 0.03211766f, -0.00818932f, 0.02450033f, -0.06236349f, 
    -0.01510397f, 0.03938328f, 0.01252660f, -0.02431337f, 0.02549667f, 0.00527665f, -0.05171579f, -0.04257542f, 
    0.01645282f, -0.02526642f, 0.03563030f, -0.00114420f, -0.02285135f, -0.01064788f, -0.06425591f, -0.00355849f, 
    -0.04751170f, 0.03175167f, 0.00416072f, -0.02053036f, -0.04620505f, -0.02547144f, -0.05708541f, -0.02260370f, 
    -0.01205519f, 0.04118842f, -0.00771705f, 0.04232661f, -0.01049685f, 0.00579752f, 0.01289602f, 0.04493748f, 
    -0.07119648f, 0.03063091f, 0.00649969f, 0.00522481f, 0.01607301f, -0.06703760f, -0.05936047f, 0.01430542f, 
    0.01715099f, 0.03811177f, -0.04048771f, 0.00378435f, -0.03680682f, 0.00870353f, -0.00768299f, 0.02434836f, 
    -0.01335814f, 0.03008961f, 0.01348161f, -0.05479572f, -0.01917791f, -0.02781979f, 0.03712219f, -0.06635862f, 
    -0.06633969f, -0.00917816f, -0.05893696f, 0.01956590f, 0.01412399f, 0.03047589f, -0.05224008f, -0.03586625f, 
    -0.06688220f, -0.05431639f, 0.03284048f, -0.01868599f, 0.00326687f, 0.04040864f, -0.06280661f, 0.00953023f, 
    -0.02028006f, -0.05303675f, -0.02023299f, -0.04137231f, -0.01611288f, 0.03147254f, -0.01020477f, -0.03118347f, 
    -0.00912692f, 0.03682331f, 0.02520425f, 0.03577556f, -0.07001049f, 0.02161627f, -0.03870613f, -0.01117335f, 
    0.03197058f, -0.07266821f, 0.04344807f, -0.02804759f, 0.04089800f, -0.00866646f, -0.06914398f, -0.04599195f, 
    0.02215947f, -0.06220854f, -0.01853413f, -0.00800746f, 0.03061963f, 0.02068707f, 0.03940586f, -0.03600509f, 
    -0.05569915f, 0.03799798f, -0.01846023f, -0.03143480f, -0.03679652f, -0.05826311f, 0.02537996f, 0.01854327f, 
    0.03331058f, -0.03429176f, 0.00963856f, -0.02499353f, 0.01014364f, 0.02508626f, 0.02881666f, -0.05949787f, 
    0.03316840f, 0.04115213f, 0.00217635f, 0.03822972f, 0.02380048f, -0.05493955f, 0.03313075f, 0.00638246f, 
    -0.07370777f, 0.01132313f, -0.03018579f, -0.00999050f, -0.05620310f, -0.07031462f, 0.02455954f, -0.03962298f, 
    0.03911122f, -0.04341527f, -0.02103895f, -0.00477375f, 0.00252438f, 0.01906650f, -0.03986250f, 0.04646058f, 
    0.01141019f, -0.01091704f, -0.05730330f, 0.00139864f, -0.03899281f, -0.05274239f, 0.01656188f, 0.01017594f, 
    -0.04381102f, -0.01995401f, -0.06088999f, 0.01853331f, -0.00288147f, -0.05557678f, -0.01888152f, -0.05893939f, 
    -0.03731361f, -0.06239460f, -0.00205541f, -0.03155243f, -0.01334187f, 0.03414487f, 0.00745241f, -0.05575572f, 
    -0.05184057f, -0.04470574f, -0.00185854f, -0.02048229f, 0.04002228f, -0.06180678f, -0.04954688f, -0.02611804f, 
    -0.04461127f, -0.01672570f, -0.01332179f, 0.01391935f, 0.03015857f, 0.01563472f, -0.03934070f, -0.01721129f, 
    -0.01200950f, -0.03343605f, -0.03213942f, -0.06347283f, 0.05316887f, 0.00799761f, -0.00240281f, -0.02014260f, 
    0.01378411f, -0.01980266f, 0.00705668f, 0.00702158f, -0.00311559f, 0.04365792f, 0.01518257f, 0.02465369f, 
    -0.03223570f, 0.01860578f, -0.04032028f, -0.05460133f, -0.05669900f, 0.05087047f, -0.00980047f, 0.04156274f, 
    0.03961193f, -0.02077710f, 0.04070213f, -0.02492459f, -0.00722730f, 0.02061059f, -0.01519929f, -0.04892981f, 
    -0.02091710f, -0.02435226f, -0.04548221f, -0.05374115f, -0.01227390f, -0.03120780f, -0.03346046f, -0.04997279f, 
    0.05063308f, 0.04988587f, 0.04729249f, -0.01235137f, -0.03803648f, -0.00185231f, 0.03012236f, -0.00879624f, 
    -0.01394222f, -0.01546124f, -0.05424128f, -0.00220812f, 0.01289476f, 0.01326082f, -0.01125174f, 0.00745434f, 
    -0.00215469f, -0.00760225f, 0.03438529f, -0.05011551f, -0.05675560f, -0.00040313f, -0.01187769f, -0.00559052f, 
    -0.06011964f, -0.04187302f, 0.01428612f, 0.00244917f, -0.03143208f, 0.01942731f, 0.00221827f, 0.00049757f, 
    0.00863764f, 0.01083191f, -0.03834909f, -0.06170687f, 0.00611345f, -0.02627135f, -0.03650134f, -0.03129439f, 
    -0.02827506f, -0.00914317f, 0.03874863f, -0.05393568f, -0.05429745f, 0.05333975f, 0.04080558f, 0.02232712f, 
    -0.04480556f, 0.00046090f, -0.06165370f, 0.00496761f, -0.01294625f, 0.03814442f, -0.06007317f, 0.01800829f, 
    0.01273044f, -0.03641041f, 0.05291859f, 0.01321343f, -0.05705377f, -0.01021625f, -0.06189043f, 0.02575839f, 
    -0.01141966f, -0.04561526f, 0.00958457f, 0.04130580f, -0.04615788f, -0.05940155f, 0.04918369f, -0.05808457f, 
    -0.03798516f, 0.05066400f, 0.05590731f, -0.02798451f, 0.03638199f, 0.03081692f, 0.00797734f, 0.02965710f, 
    -0.00041180f, -0.03407666f, -0.05238124f, 0.04821049f, -0.01911403f, 0.02372251f, 0.02280063f, -0.05757472f, 
    -0.02903485f, -0.01887569f, 0.00278159f, -0.01147522f, 0.05275257f, -0.04627144f, 0.04851454f, 0.02284762f, 
    -0.05036622f, 0.00031171f, -0.01334869f, 0.03529606f, -0.00781269f, 0.02514208f, -0.01173135f, 0.02050581f, 
    -0.00029346f, 0.04380843f, -0.01935973f, -0.06038796f, 0.04698017f, 0.01659878f, -0.06241780f, 0.01797417f, 
    -0.01123881f, 0.04971317f, 0.01375291f, -0.01580220f, -0.00168595f, -0.05337559f, -0.02207206f, -0.00221488f, 
    0.01206927f, -0.04863131f, 0.00604331f, -0.00990014f, -0.02483916f, 0.03258262f, 0.01411493f, 0.00976987f, 
    -0.04356673f, 0.02357991f, -0.02044928f, 0.02463502f, -0.02053911f, -0.05979836f, -0.06121652f, 0.02482839f, 
    -0.03834602f, 0.01461704f, 0.01435208f, 0.04378190f, -0.00056458f, -0.00012084f, 0.03449519f, -0.02836689f, 
    0.01006237f, -0.04121367f, -0.00487018f, 0.04354351f, -0.02508775f, -0.04686279f, 0.00592391f, -0.03150899f, 
    -0.03695882f, 0.00470104f, -0.02306730f, -0.05915364f, -0.05878537f, 0.04700419f, 0.00282268f, -0.04763433f, 
    0.01884353f, -0.00864509f, 0.02277355f, -0.01812851f, 0.01880830f, -0.04572604f, -0.01524537f, -0.00911167f, 
    -0.04769835f, 0.05256404f, 0.02771909f, 0.05234936f, -0.04569365f, -0.06306142f, 0.04913241f, -0.02481546f, 
    0.02049998f, 0.03453786f, -0.02296892f, 0.00694895f, 0.05204417f, -0.03340284f, 0.04411462f, 0.02945334f, 
    -0.01166708f, 0.02882733f, -0.05266941f, 0.00322054f, -0.01546211f, 0.03985681f, -0.02191234f, -0.05501519f, 
    0.02413573f, 0.01133179f, -0.00082108f, -0.05285984f, 0.00808663f, -0.05344583f, 0.01957580f, 0.04087694f, 
    -0.04938078f, -0.05142114f, -0.06194133f, -0.06261297f, -0.04823865f, -0.00050396f, 0.03988525f, -0.01435074f, 
    0.02278201f, -0.05766897f, -0.04494741f, 0.03915462f, 0.00306539f, -0.05185472f, 0.02545040f, -0.01831095f, 
    0.04942109f, 0.00057971f, -0.02071917f, 0.01434880f, 0.00132999f, -0.06546293f, -0.05817510f, -0.05361661f, 
    -0.06072350f, -0.02330820f, -0.04030152f, -0.00955908f, 0.00041545f, -0.00886707f, -0.02710962f, 0.02532934f, 
    -0.03483858f, 0.00578426f, -0.05251719f, -0.06458161f, -0.03498207f, -0.05144276f, 0.00904224f, -0.03357670f, 
    -0.01609574f, -0.05697305f, 0.04820826f, 0.03463543f, 0.02091341f, 0.01096441f, 0.01614778f, 0.03185559f, 
    -0.02367026f, 0.00962967f, 0.02084008f, 0.03340499f, -0.03789154f, 0.03089105f, -0.03566715f, 0.00131361f, 
    0.02361462f, 0.01394743f, -0.03434889f, -0.02171189f, -0.02021896f, -0.00313900f, -0.01088154f, 0.02132181f, 
    -0.03786511f, 0.00692592f, -0.01580748f, 0.01338608f, -0.04002858f, 0.00683614f, -0.01371693f, 0.02758301f, 
    0.03836099f, -0.02855318f, 0.04189708f, 0.05085552f, -0.02681007f, -0.03951837f, 0.03736377f, -0.02571973f, 
    -0.04203946f, 0.03087586f, 0.01448416f, 0.03281645f, 0.01357878f, -0.02884765f, 0.01016853f, -0.04714701f, 
    -0.01352292f, 0.03234309f, -0.04007510f, -0.03703194f, 0.03609539f, -0.02159594f, -0.00155394f, 0.00209865f, 
    -0.03422638f, -0.03530297f, -0.04672528f, -0.01017094f, -0.04569848f, -0.01268821f, 0.01208656f, -0.02682856f, 
    -0.05951470f, 0.03832031f, -0.04581076f, 0.02171717f, -0.03308529f, 0.03581121f, 0.01539188f, 0.02441062f, 
    -0.04069179f, 0.03981363f, -0.01976389f, 0.02890932f, 0.01961431f, -0.03370576f, 0.01221064f, -0.01112933f, 
    -0.04676513f, -0.05736658f, -0.01815591f, -0.05221515f, -0.04451058f, -0.00769986f, 0.03768252f, -0.04366755f, 
    -0.00747015f, -0.02201739f, -0.04971438f, -0.03351651f, 0.01586402f, -0.00229903f, -0.04228420f, 0.01437287f, 
    -0.00896979f, -0.03678414f, -0.01694647f, 0.04842734f, -0.03589934f, -0.00962639f, -0.03484445f, 0.02850915f, 
    0.01334434f, 0.03886185f, -0.02185375f, -0.06844574f, -0.05488075f, 0.03501205f, 0.03664676f, 0.04385671f, 
    -0.03586616f, 0.02227209f, -0.02465336f, 0.00015754f, -0.00421202f, 0.04430392f, -0.05957490f, 0.01721468f, 
    -0.03801918f, -0.01637278f, -0.02636636f, 0.03469471f, 0.00050409f, 0.05258216f, -0.02151739f, -0.02724141f, 
    -0.02037361f, 0.01786282f, -0.02194656f, -0.00710654f, 0.02213948f, 0.03436063f, -0.02998802f, 0.00931036f, 
    -0.02189066f, 0.00828101f, -0.02281911f, -0.02723225f, -0.06016809f, 0.06124919f, 0.03523232f, -0.01431077f, 
    -0.03420315f, 0.04525215f, 0.03065469f, -0.02561083f, -0.02517763f, 0.02714983f, -0.01365306f, -0.00791405f, 
    -0.02624536f, -0.05060642f, -0.00487591f, 0.03179775f, 0.04405852f, -0.01535790f, 0.03663427f, 0.01641085f, 
    0.00097461f, 0.04103437f, 0.00890468f, -0.04645109f, -0.05403312f, -0.02524077f, 0.01534141f, -0.00547588f, 
    -0.01510010f, 0.03009504f, -0.02085814f, -0.06621639f, -0.03466620f, 0.03113276f, -0.05603424f, -0.06185263f, 
    -0.04731367f, 0.01938769f, 0.02756210f, -0.04721931f, 0.01504799f, 0.03933508f, -0.05134513f, 0.01754461f, 
    -0.04980933f, -0.04082531f, 0.02200053f, 0.05533539f, -0.05992487f, -0.02821278f, -0.06630833f, -0.04156987f, 
    -0.04245788f, -0.01413075f, 0.01579128f, 0.03531650f, 0.03980831f, 0.00572915f, -0.03608710f, 0.02281665f, 
    0.04309504f, -0.00034285f, -0.02777827f, -0.05336979f, 0.01517459f, -0.02088220f, 0.04900737f, 0.01181300f, 
    -0.00796170f, 0.01964841f, -0.05541398f, -0.04177359f, -0.02741051f, 0.00588355f, -0.05669964f, 0.01208495f, 
    -0.01688107f, -0.04273562f, 0.04714774f, 0.00970724f, -0.02651624f, -0.04408740f, -0.04292052f, -0.03035409f, 
    -0.04323013f, -0.05369170f, 0.05233531f, 0.00713489f, -0.02200151f, -0.06019688f, -0.06177378f, -0.02475837f, 
    -0.00986135f, -0.00398320f, -0.03989384f, 0.01983033f, -0.02306187f, -0.05118784f, -0.02723633f, -0.00591184f, 
    0.03880933f, 0.02199424f, -0.04386159f, 0.01927925f, -0.05586750f, -0.03074843f, -0.03469693f, 0.00780349f, 
    0.03470946f, -0.03957889f, -0.04248203f, -0.01618654f, 0.01563159f, -0.01359383f, -0.00364269f, 0.01557521f, 
    -0.02043406f, -0.06045274f, -0.00724333f, -0.00329555f, -0.06613264f, -0.00244224f, 0.00816847f, 0.01623964f, 
    0.02993112f, -0.05734047f, -0.03001117f, -0.00659411f, -0.05784891f, 0.01265736f, -0.05217191f, -0.01346113f, 
    0.01005374f, -0.02078878f, 0.01517690f, -0.00243837f, 0.00470790f, 0.04014500f, -0.00172583f, 0.02639633f, 
    -0.04999882f, -0.02425914f, 0.05411679f, -0.01555529f, -0.01490803f, -0.05253664f, 0.02892531f, -0.05945525f, 
    0.02424496f, -0.03340445f, -0.02078792f, -0.01377385f, 0.01127195f, -0.02030450f, 0.03058385f, -0.02769622f, 
    -0.01450837f, -0.06391820f, -0.06248555f, -0.02598685f, -0.01109742f, -0.05243826f, -0.01377165f, 0.01321613f, 
    0.02153234f, -0.01227657f, -0.06055323f, -0.05799183f, 0.04360193f, -0.03587855f, 0.05406995f, 0.02498262f, 
    0.04317262f, -0.01142421f, 0.03577061f, -0.04063856f, 0.03379038f, 0.03271828f, 0.00351983f, 0.01152710f, 
    0.03040211f, -0.01040401f, -0.05922454f, -0.01286029f, 0.01654547f, 0.01406000f, -0.04325023f, -0.00002520f, 
    0.03709231f, -0.05706281f, -0.03975787f, -0.03432968f, -0.01442989f, -0.02421527f, 0.02100681f, 0.03230827f, 
    -0.03297980f, 0.03376862f, -0.06756308f, 0.01126098f, -0.00690349f, -0.03004221f, 0.04763255f, -0.06510568f, 
    -0.02915226f, -0.04300867f, 0.00803252f, 0.05232467f, -0.00732185f, -0.04273997f, -0.00963145f, 0.00874275f, 
    0.02498912f, -0.02993761f, 0.02394026f, -0.03354288f, 0.01800544f, -0.00474550f, 0.01958282f, 0.00265186f, 
    0.03032530f, 0.00680253f, 0.00628138f, 0.00145390f, 0.00026563f, 0.00399950f, 0.02666261f, -0.03179344f, 
    0.03567886f, -0.04800544f, -0.02999463f, -0.03804328f, -0.00935006f, -0.04039716f, -0.00091514f, -0.05793555f, 
    0.04447049f, -0.06202295f, -0.03134791f, 0.00626849f, 0.01381605f, -0.05856534f, 0.01660834f, 0.03217897f, 
    0.02396901f, 0.05517398f, -0.00774954f, 0.00020357f, 0.04060317f, 0.04542084f, -0.03147912f, -0.05574192f, 
    -0.05676362f, -0.04546444f, -0.00026624f, -0.00554420f, -0.06323954f, -0.00092732f, -0.01892082f, 0.01273538f, 
    -0.02082027f, 0.03027862f, -0.06543249f, 0.03099712f, -0.05444431f, 0.03568877f, -0.05986220f, -0.05054382f, 
    0.03389397f, -0.05400094f, 0.02248924f, -0.04859395f, -0.02205192f, -0.05388990f, -0.06070821f, -0.05954266f, 
    0.00166196f, 0.03083430f, 0.01786415f, -0.00351903f, -0.05740558f, -0.01249679f, 0.04846530f, 0.00391460f, 
    -0.03320972f, 0.00454142f, 0.04626875f, 0.04315985f, -0.03795294f, 0.01074627f, -0.02243945f, 0.02216273f, 
    0.02616056f, -0.00713693f, -0.02166686f, 0.04116416f, 0.00430525f, -0.00359365f, 0.04367375f, -0.04719624f, 
    -0.00168986f, -0.04325117f, 0.00758120f, -0.03532844f, -0.03082270f, -0.02124081f, 0.03904868f, -0.05093873f, 
    0.04979249f, -0.03935263f, 0.03756038f, -0.01041333f, -0.05500994f, -0.06311280f, -0.03964472f, -0.06079799f, 
    0.03758752f, 0.02336630f, -0.04647395f, -0.05612523f, -0.00120297f, -0.02237849f, 0.03129026f, 0.01821671f, 
    0.01023621f, 0.02940217f, 0.03946241f, 0.03024453f, -0.01333116f, -0.06643878f, 0.05026581f, -0.03193469f, 
    0.04073486f, -0.02630323f, -0.05001190f, -0.03688535f, 0.03667634f, 0.00692962f, 0.01913016f, -0.06007056f, 
    -0.02413313f, -0.06177266f, -0.02347660f, 0.03329424f, -0.06350953f, 0.01366203f, -0.01531230f, 0.02266345f, 
    0.04340212f, -0.02686362f, 0.02466248f, 0.04497731f, 0.02113581f, -0.02482956f, 0.03028431f, 0.02762325f, 
    -0.04227579f, -0.00674876f, -0.01270989f, -0.02210074f, -0.01281612f, -0.05489844f, -0.02921103f, 0.03615808f, 
    0.01881694f, -0.05963692f, -0.04107193f, 0.00789885f, 0.05312978f, -0.03969591f, -0.05114614f, 0.02240949f, 
    -0.04237309f, -0.01294057f, -0.05809023f, -0.01801062f, 0.02581031f, 0.00073383f, -0.06201825f, -0.05708200f, 
    0.03196299f, 0.04041453f, -0.04716443f, -0.04261215f, -0.04083993f, 0.03233709f, 0.03663832f, 0.00631547f, 
    -0.02406617f, -0.03707897f, 0.04612064f, -0.00979327f, -0.04699824f, -0.05501683f, -0.06142853f, -0.01875256f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07657529f, 0.17009926f, -0.08833750f, -0.06146633f, -0.05829368f, -0.03001017f, 0.05143368f, -0.06238270f, 
    -0.08204166f, 0.26165006f, -0.02422391f, 0.23649150f, 0.18618357f, -0.01120278f, 0.16623662f, 0.08424714f, 
    -0.06969515f, 0.05162299f, -0.04140821f, 0.00968776f, -0.04590405f, -0.01207386f, 0.25407153f, -0.17238261f, 
    -0.00935082f, -0.06364843f, 0.00014913f, 0.02334078f, 0.01943855f, -0.02927247f, -0.04026005f, -0.03688345f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.39762658f, -0.12158576f, -0.05432760f, -0.00160992f, 0.02707847f, 0.14509514f, 0.10253108f, 0.69900519f, 
    -0.26505452f, -0.78792483f, -0.05480403f, -0.23686063f, -0.08732279f, -0.31491816f, 0.35812846f, 0.42970544f, 
    -0.14517882f, 0.03531533f, 0.14156565f, -0.03615320f, 0.08742630f, 0.11877930f, -0.15164097f, 0.07957599f, 
    -0.03241902f, -0.17604452f, 0.01639547f, -0.05830019f, 0.08845978f, 0.09084768f, -0.05642077f, 0.00645116f, 
    0.02134949f, -0.12254625f, -0.40120065f, -0.07918258f, 0.01140432f, 0.13954365f, -0.16246262f, 0.08163796f, 
    0.18122147f, -0.02156233f, 0.43893805f, 0.16229586f, -0.01857731f, -0.23136304f, 1.10979688f, -0.30339643f, 
    0.06102043f, 0.05780633f, -0.09343775f, 0.02399295f, -0.03244854f, -0.15796588f, -0.25677624f, -0.76368231f, 
    -0.10538472f, 0.04326042f, 0.13320698f, 0.10556912f, 0.06009474f, 0.12503791f, 0.10760505f, -0.13529120f, 
    -0.00511229f, -1.13183320f, 0.50083631f, 0.08871895f, -0.04210481f, -0.02678674f, 0.02438276f, 0.07293624f, 
    -0.76910949f, -0.41343811f, -0.99924278f, -0.28864333f, 0.07039095f, 0.95846832f, -0.10127705f, -0.12517452f, 
    -0.07019717f, 0.12787063f, 0.01432072f, -0.07699981f, 0.13207783f, 0.00040619f, 0.16892131f, -0.16267377f, 
    0.03962781f, 0.15905453f, -0.10643101f, -0.14990905f, 0.11855809f, -0.04781681f, -0.07861082f, -0.03958387f, 
    -0.41353172f, -0.13826478f, 0.29215083f, 0.05036873f, -0.13724528f, 0.15077762f, -0.15163806f, -0.38217837f, 
    0.72725081f, -0.65771526f, -0.73199433f, -0.20902970f, 0.56561482f, -0.24435872f, -0.51379198f, 0.13386455f, 
    0.08223461f, 0.01492431f, -0.04770930f, -0.14506404f, 0.14174344f, -0.12589633f, -0.17004827f, 0.16386338f, 
    -0.04158319f, -0.09293654f, -0.10604567f, -0.08165661f, 0.13501428f, -0.11795061f, -0.06985798f, 0.12436239f, 
    0.29991481f, -0.15511890f, -0.16643378f, 0.03099539f, -0.15297709f, -0.12059820f, -0.11698194f, -0.45999268f, 
    -0.27874553f, -0.63747311f, -0.01713183f, -0.12623401f, 0.11915439f, -0.26076409f, -0.14212056f, 0.31294262f, 
    0.05036566f, -0.04849579f, -0.11581716f, -0.09593359f, 0.15078180f, 0.10682002f, 0.86324430f, 0.16379334f, 
    0.12661737f, -0.14397039f, -0.13143837f, 0.04904215f, -0.02419615f, 0.06737807f, 0.09204374f, -0.13221799f, 
    -0.61356920f, 0.37330607f, -0.59227222f, 0.15648863f, 0.15243176f, 0.16137923f, 0.05826163f, 0.07307646f, 
    -0.26705426f, 0.18900481f, 0.44949466f, 0.51706660f, -0.51091033f, -0.03630961f, -0.03091929f, 0.04157677f, 
    -0.13800649f, 0.06515580f, 0.16104402f, -0.13151358f, -0.15520528f, -0.18246843f, 0.24681844f, 0.00850803f, 
    -0.02491064f, 0.10712315f, -0.03331223f, 0.14172874f, -0.08921885f, 0.06303503f, -0.05001679f, 0.01039746f, 
    -0.20987482f, -0.47237197f, -0.19625361f, 0.14804496f, 0.05030165f, -0.12508400f, 0.05759294f, 0.11732675f, 
    -0.04329623f, 0.05006062f, -0.81212324f, 0.80363119f, 0.24111170f, -0.55246758f, -0.86527544f, -0.50395930f, 
    -0.13450813f, -0.06514333f, 0.14529426f, 0.15888652f, 0.09180487f, -0.14260758f, 0.19604072f, 0.23603790f, 
    -0.13384792f, 0.13735260f, 0.02069044f, -0.00445263f, 0.03746505f, 0.03220723f, -0.17511389f, 0.07685652f, 
    0.00501033f, 0.24852195f, -0.00231504f, 0.01669208f, 0.02971455f, 0.07823058f, 0.15462855f, -0.40504503f, 
    -0.06369340f, -0.32800794f, 0.68660998f, -0.37607759f, -0.23361337f, -0.22888264f, -0.08056738f, 0.27821892f, 
    -0.14029466f, 0.01367394f, -0.06343727f, -0.02317710f, 0.16155618f, 0.13538201f, -0.02950948f, 0.25971341f, 
    0.01074219f, 0.09102030f, 0.12661844f, 0.03589857f, 0.12525089f, 0.10421828f, 0.10981635f, 0.16079918f, 
    -0.05225053f, 0.05527722f, -0.35755372f, 0.12795791f, -0.14428540f, -0.10380851f, -0.08558576f, -0.03118593f, 
    0.94690776f, 0.42746854f, -0.20978250f, -0.42647654f, -0.97972649f, 0.88293403f, -0.10259498f, -0.10581083f, 
    0.02648159f, -0.14169967f, -0.08606718f, -0.03452144f, -0.02105986f, -0.18267754f, 0.06692390f, -0.59252423f, 
    -0.01640764f, 0.14360064f, 0.11354612f, -0.01298377f, 0.10920412f, -0.10774862f, 0.06220295f, 0.13244686f, 
    0.46356121f, -0.19615954f, -0.32188857f, 0.09899510f, -0.13042019f, -0.00310784f, -0.14589906f, -0.01274911f, 
    -0.56251466f, 0.87637144f, 0.31424269f, -0.05726175f, -0.15402964f, -0.43856403f, -1.00426698f, 0.46190676f, 
    -0.06129597f, 0.02598509f, -0.05617899f, -0.06492097f, -0.13712099f, -0.07627311f, -0.10912682f, 0.13981563f, 
    0.02093095f, -0.05923077f, 0.11015888f, -0.16009954f, -0.02123442f, 0.05066583f, 0.04340552f, 0.16089007f, 
    -0.32636467f, 0.69817525f, 0.29095301f, -0.05576201f, 0.00013433f, 0.03127613f, -0.17125568f, -0.54211950f, 
    -0.30164987f, 0.14466196f, 0.06035969f, -0.42154539f, 0.74024576f, 0.46862790f, -0.05301892f, -0.55450505f, 
    -0.02813660f, -0.07041761f, 0.10117987f, -0.05233281f, -0.12972783f, -0.03228909f, -0.32481784f, -0.58036667f, 
    -0.04636198f, 0.10716555f, -0.05375769f, -0.06719393f, -0.01120253f, 0.03243800f, -0.02822125f, -0.03216165f, 
    0.28042960f, 0.26352677f, 0.70568526f, 0.10038059f, 0.00623903f, -0.06154858f, 0.15702645f, -0.12707348f, 
    -0.05852079f, -0.34632781f, -0.88691086f, 0.09773915f, -0.47376814f, -0.29775739f, -0.40281758f, -0.14696188f, 
    -0.08015834f, 0.05323244f, 0.01833073f, -0.01624151f, -0.01996947f, 0.11960980f, -0.63502944f, 0.31097677f, 
    0.05452221f, -0.16422698f, -0.09473690f, -0.09423864f, -0.03160407f, -0.09379952f, -0.00036153f, 0.05286339f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14479159f, -0.03800212f, 0.00765644f, -0.06540138f, 0.37461749f, 0.27448308f, -0.35771948f, -0.55426842f, 
    -0.14956255f, 0.02402833f, 0.21994545f, -0.12197235f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
