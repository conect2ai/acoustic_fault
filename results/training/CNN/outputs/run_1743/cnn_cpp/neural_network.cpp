#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.33559999f, 0.13938229f, -0.04476551f, -0.22715198f, -0.45928401f, -0.44280785f, -0.47689864f, -0.10387762f, 
    -0.25644895f, -0.25268188f, 0.08507895f, -0.44920844f, 0.00828932f, -0.59446967f, -0.39310503f, -0.17808519f, 
    -0.32458314f, -0.02986163f, -0.45256722f, -0.48924181f, -0.16885655f, 0.70529181f, 0.16434011f, -0.42148447f, 
    -0.40024409f, -0.23349112f, -0.17185730f, -0.76261091f, -0.57861477f, 0.08625274f, -0.08933226f, -0.05526861f, 
    0.15954347f, 0.12952843f, -0.02494672f, -0.40224704f, 0.06011643f, 0.14204310f, 0.55157679f, -0.17312695f, 
    -0.19476727f, 0.51992989f, -0.00840107f, -0.40659311f, -0.45722598f, 0.39155516f, 0.00400420f, -0.14588732f, 
    0.50058758f, 0.14973095f, 0.42829880f, -0.18034992f, 0.74156910f, -0.61451411f, -0.29223922f, -0.16649322f, 
    -0.10584071f, -0.23856275f, -0.12103398f, -0.55760658f, 0.44361702f, -0.00936666f, 0.58968371f, -0.39887860f, 
    0.03514856f, 0.20314543f, -0.20116617f, -0.59794104f, -0.69825566f, -0.11876824f, 0.67978054f, -0.03372560f, 
    -0.37380251f, -0.06638165f, -0.64696139f, -0.30813399f, 0.96305799f, -0.19915189f, -0.05725758f, 0.04067539f, 
    -0.17033747f, -0.74496561f, -0.16865413f, 0.50622088f, -0.07036741f, 0.51053256f, 0.89943928f, -0.23779005f, 
    0.27212647f, 0.13558000f, 0.68093801f, 0.62202644f, -0.49921432f, -0.37331703f, -0.32192308f, 0.13853048f, 
    -0.19481440f, 0.31528816f, 0.11349418f, 0.01525108f, -0.36612135f, 0.80137366f, -0.14931767f, -0.37568301f, 
    0.22629312f, 0.18704188f, 0.14370498f, 0.15346517f, 0.08512782f, -0.05747307f, -0.07792153f, -0.76016086f, 
    0.39390939f, 0.23715752f, -0.25389892f, -0.36513004f, 0.70499617f, 0.03275366f, -0.36101311f, -0.50599629f, 
    -0.02272547f, 0.15981568f, -0.03449169f, 0.69737577f, 0.20652708f, 0.10219909f, 0.92291540f, -0.51052558f, 
    -0.29691219f, 0.50836486f, -0.19131450f, -0.12729993f, -0.16252860f, 0.09114733f, -0.07271603f, -0.94606256f, 
    -0.30310902f, 0.33288515f, -0.26255429f, 0.07020734f, -0.39323032f, -0.44727173f, 0.13939740f, -0.16870788f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12095618f, -0.39145160f, -0.23351538f, -0.36657363f, 0.08463605f, -0.00800362f, -0.05618812f, 0.13901119f, 
    0.21688907f, -0.29728806f, 0.04730745f, -0.03238335f, -0.06579947f, -0.04254291f, -0.06949956f, 0.14800499f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.17967583f, 0.01886298f, -0.11108852f, 0.09318242f, 0.04305518f, -0.01715061f, -0.05913021f, -0.05553672f, 
    0.01207796f, 0.11167370f, 0.16201645f, 0.24271478f, -0.27489054f, 0.10788614f, -0.04126953f, 0.11592389f, 
    -0.05041088f, 0.20187984f, -0.04938051f, -0.04685837f, -0.05115203f, -0.24913539f, -0.02062161f, -0.31981358f, 
    0.12022167f, 0.01023075f, 0.01971661f, 0.02656200f, -0.11218074f, 0.17123312f, -0.35970235f, -0.08395941f, 
    0.09117356f, -0.00378617f, -0.18102109f, 0.00388775f, -0.19861162f, 0.01767784f, -0.48174414f, -0.07104273f, 
    -0.21140066f, -0.03231745f, 0.09234916f, 0.00793317f, -0.05235961f, 0.15542592f, -0.24652876f, -0.07675693f, 
    -0.11289570f, -0.07571087f, -0.11173439f, 0.14569178f, -0.03227168f, -0.02922719f, 0.02001595f, 0.15877080f, 
    0.25225884f, -0.14648503f, 0.02942926f, -0.03134920f, 0.09162983f, -0.03805938f, 0.16561835f, 0.08442456f, 
    0.07330912f, 0.33823928f, -0.05239465f, 0.01885323f, -0.11454770f, -0.01161028f, 0.06612220f, 0.13112989f, 
    -0.23629186f, -0.14742133f, 0.18289225f, 0.09250731f, 0.01893779f, 0.07957648f, 0.20976952f, 0.07510632f, 
    -0.06618213f, -0.13297051f, -0.07348147f, -0.14978209f, -0.05951355f, 0.04765080f, -0.16038457f, 0.08125849f, 
    0.09898814f, 0.10379773f, 0.03069418f, -0.28484884f, -0.77335602f, 0.02329922f, -0.04431173f, 0.08047224f, 
    0.06966580f, -0.00603218f, 0.01976924f, -0.09896554f, 0.07843445f, -0.48589173f, 0.04536674f, 0.01976490f, 
    0.08623932f, -0.12521532f, 0.24031691f, -0.02421576f, -0.41066813f, -0.10548071f, 0.05245606f, 0.13401337f, 
    0.04890567f, -0.16601895f, 0.07328189f, 0.08486581f, 0.18234323f, -0.00053186f, -0.14813538f, 0.02901271f, 
    0.02739286f, -0.09978752f, 0.11133555f, 0.08136009f, 0.11115900f, -0.06487256f, 0.42638129f, -0.46183562f, 
    -0.69986016f, -0.10582469f, -0.02172981f, -0.07512442f, 0.00657879f, -0.06048074f, -0.13357320f, -0.28285599f, 
    -0.07635155f, 0.31766599f, -0.07494319f, 0.03006017f, 0.26272053f, 0.07840588f, 0.02588760f, 0.11659528f, 
    -0.24838427f, -0.12596679f, -0.42577413f, -0.04898750f, 0.09185847f, -0.05015384f, -0.03869603f, -0.03636809f, 
    0.14670308f, -0.35915998f, -0.40270185f, -0.51605904f, -0.06134295f, -0.00806041f, -0.08823732f, -0.03834318f, 
    0.12859975f, 0.16279903f, -0.05740738f, -0.24851960f, -0.22995061f, 0.00323101f, -0.04931596f, -0.08736949f, 
    -0.09081137f, 0.02050295f, 0.08477367f, -0.15378456f, 0.18371493f, -0.74276489f, 0.01315299f, 0.13784041f, 
    0.03938146f, 0.03252944f, -0.09311964f, -0.05833568f, 0.01951845f, 0.33119559f, 0.04635230f, -0.01839145f, 
    0.05289897f, 0.00216512f, 0.03167362f, -0.04863115f, 0.18624723f, 0.18543269f, 0.07970674f, 0.20765691f, 
    0.01419184f, -0.16425404f, 0.15786958f, -0.15909040f, -0.10517107f, -0.08712279f, -0.36049563f, 0.27853850f, 
    0.00251362f, 0.04621847f, 0.07195362f, 0.05758736f, 0.10370598f, -0.07296962f, -0.11596586f, -1.06506240f, 
    -0.57366973f, -0.02946293f, 0.05204260f, -0.02471024f, -0.05961579f, -0.03328026f, -0.07776184f, 0.19381745f, 
    -0.33012950f, -0.43654555f, -0.01108608f, 0.03928934f, 0.10737722f, -0.13515835f, -0.11978307f, -0.07214428f, 
    0.00011388f, -0.04964553f, -0.02573459f, -0.02117099f, -0.33694986f, -0.03218680f, 0.04040242f, -0.01781426f, 
    0.07797032f, 0.06070154f, 0.62683839f, -0.12478673f, -0.27362019f, -0.13132852f, -0.07187827f, 0.34367967f, 
    0.03023461f, 0.08739199f, -0.07517145f, 0.08895789f, -0.02253211f, 0.16462378f, 0.06956609f, 0.10609675f, 
    0.17737778f, -0.12239225f, -0.03625083f, 0.07230218f, -0.09584434f, 0.42755574f, 0.10720462f, 0.12808499f, 
    -0.02434367f, -0.14772168f, 0.11454469f, 0.36655486f, -0.09109308f, -0.20417151f, -0.07013324f, -0.29508713f, 
    -0.10218155f, 0.03369245f, -0.05219115f, 0.15868104f, 0.01247149f, 0.04461781f, 0.38246870f, 0.13345295f, 
    0.20609300f, 0.02662703f, -0.00596011f, 0.22831473f, 0.18493180f, -0.08905465f, -0.02757810f, 0.20790453f, 
    -0.55143976f, -0.13404231f, -0.04046996f, 0.09643929f, 0.17122944f, -0.05843973f, 0.03999843f, -0.11243333f, 
    -0.14843695f, 0.05284373f, -0.05963730f, -0.02475782f, -0.05419489f, -0.00342575f, 0.04108912f, -0.14698409f, 
    -0.00912235f, 0.04168665f, 0.23728760f, 0.24635881f, -0.01289827f, 0.05184194f, -0.05257754f, 0.05083302f, 
    -0.10242356f, -0.17905988f, 0.37752360f, 0.26531830f, 0.08623297f, -0.08733778f, 0.10969153f, 0.02911265f, 
    -0.08491033f, -0.04908410f, -0.06687082f, 0.17160095f, -0.11669341f, -0.10920967f, -0.01398088f, 0.01043739f, 
    0.20983128f, 0.05740987f, 0.02052766f, -0.17804003f, -0.43075880f, 0.09517606f, 0.09109412f, 0.02995450f, 
    -0.04246113f, -0.23739821f, 0.04644312f, -0.01796180f, -0.03818523f, -0.00415154f, -0.12907162f, -0.28943649f, 
    -0.08583776f, 0.13243860f, 0.12209979f, 0.07688364f, 0.10927496f, -0.14928897f, 0.14110450f, 0.18567953f, 
    0.29687694f, -0.10465608f, 0.00567254f, 0.02684268f, 0.02384224f, 0.10368689f, 0.16678862f, 0.01221615f, 
    0.18411250f, 0.06632795f, -0.31014660f, 0.01707690f, -0.11663906f, 0.12850636f, 0.07810461f, 0.25888458f, 
    0.02519625f, 0.10171249f, 0.02788793f, 0.09764662f, 0.06062360f, 0.13362633f, -0.00556061f, 0.23803535f, 
    0.11913721f, -0.29364100f, -0.25325358f, -0.14057754f, -0.01787111f, -0.26872459f, -0.07551490f, -0.14963284f, 
    -0.05502971f, -0.14283566f, -0.07029269f, -0.32400307f, -0.18865885f, -0.00111333f, 0.07240443f, 0.13104948f, 
    0.07480383f, 0.03491315f, 0.35454226f, -0.23312609f, -0.22706765f, -0.33080396f, -0.16452794f, 0.33697397f, 
    -0.11158420f, 0.13662881f, 0.14652494f, -0.01828622f, 0.02482289f, 0.50354892f, 0.46058154f, 0.01403788f, 
    0.10191419f, 0.00507913f, 0.03926057f, 0.26155546f, 0.14143226f, 0.10752765f, -0.10909383f, -0.01739718f, 
    -0.18669935f, 0.11968885f, 0.15704955f, 0.01364815f, 0.04364042f, -0.02391070f, 0.15543014f, -0.47290483f, 
    -0.05099403f, -0.05507824f, 0.15603867f, -0.06731128f, 0.10637998f, 0.03177326f, 0.01857548f, 0.19751672f, 
    0.18301648f, 0.23811169f, -0.05702358f, -0.00525984f, 0.27494481f, 0.11479004f, -0.00787271f, -0.12916645f, 
    0.14288895f, 0.07820052f, 0.16420491f, 0.25250959f, -0.14247756f, -0.02483758f, -0.04637801f, -0.00511293f, 
    0.07239694f, 0.07136483f, 0.08186470f, 0.31381905f, -0.13300700f, -0.11051958f, 0.12957539f, 0.25815940f, 
    -0.17516354f, 0.05089497f, -0.09704180f, -0.07023557f, -0.13696317f, -0.13781217f, -0.01465119f, 0.15579604f, 
    0.14587444f, -0.05856349f, 0.07321001f, -0.26013246f, -0.12790777f, -0.16337624f, 0.13470843f, -0.06980317f, 
    -0.03763854f, 0.00294461f, -0.02185844f, 0.15320350f, 0.16827935f, 0.20622995f, 0.21520922f, -0.16954692f, 
    -0.21871135f, -0.12933247f, -0.00192037f, -0.07093053f, -0.06096949f, 0.10121894f, -0.23952712f, 0.25252864f, 
    0.18140036f, 0.15284008f, -0.02143053f, 0.16977379f, -0.07509498f, -0.03770155f, -0.05451472f, -0.21320470f, 
    0.05344270f, -0.13023804f, 0.03140347f, -0.24482273f, 0.06752670f, -0.14980127f, -0.26886219f, -0.23204994f, 
    0.04845896f, 0.15965486f, -0.00984850f, -0.03714503f, -0.12920207f, -0.09541174f, -0.05209529f, 0.06233809f, 
    0.00739572f, -0.18029228f, 0.01941672f, -0.02306137f, -0.12234902f, -0.09063205f, -0.07297334f, 0.16700920f, 
    0.17872632f, 0.00342894f, 0.19383469f, -0.06625377f, 0.08156603f, -0.03268557f, -0.00900574f, -0.10775503f, 
    -0.01446191f, -0.19542201f, 0.16941284f, 0.19844809f, 0.34386560f, 0.05692304f, 0.02808099f, -0.06114796f, 
    0.05330008f, 0.04050265f, -0.06634293f, 0.02990350f, 0.05860726f, 0.15918660f, 0.11228625f, 0.21784215f, 
    0.07766397f, -0.17254294f, -0.15506335f, -0.13139202f, 0.14533003f, -0.05264900f, 0.27237380f, 0.19830482f, 
    -0.05455920f, 0.03685913f, 0.16333918f, 0.04880628f, -0.00695682f, -0.01389775f, -0.27197984f, -0.04037624f, 
    0.05341399f, 0.10470129f, -0.07913909f, -0.08709455f, 0.02889446f, -0.06266359f, 0.21502137f, -0.20235477f, 
    0.61008579f, -0.20516793f, -0.16103803f, 0.37903675f, -0.09680789f, -0.12112629f, -0.06935591f, -0.33686531f, 
    0.01331924f, 0.10982407f, -0.04983304f, 0.17795482f, -0.14554094f, 0.07472074f, -0.00504184f, 0.18881108f, 
    0.17223395f, 0.20255743f, 0.50672239f, -0.05810359f, -0.13691469f, -0.06281538f, -0.11457814f, 0.12797612f, 
    0.16418366f, 0.27998608f, 0.23813023f, 0.14461656f, 0.14584106f, -0.11379763f, 0.08411602f, 0.14830758f, 
    -0.07058437f, 0.20406359f, -0.45098361f, -0.21604329f, -0.16122855f, 0.01786003f, -0.32565811f, -0.08715676f, 
    -0.08636382f, -0.06031009f, 0.01418965f, 0.06822937f, -0.01485143f, 0.03473762f, 0.20479427f, -0.02994652f, 
    0.17084020f, 0.07933430f, -0.10670588f, 0.28317511f, 0.03625430f, -0.05534539f, -0.09365058f, 0.01079361f, 
    -0.09746502f, -0.11528511f, -0.09410644f, -0.00781650f, 0.08071355f, -0.27998224f, -0.07476936f, -0.20484889f, 
    -0.10139301f, 0.02137619f, -0.07965767f, 0.22815417f, 0.01687552f, 0.07582871f, 0.12399291f, 0.03206832f, 
    0.02537712f, 0.12457377f, -0.01523031f, -0.14285232f, 0.24552962f, -0.02731035f, -0.15673049f, 0.14852308f, 
    0.22405630f, 0.20550975f, 0.14136532f, 0.08844988f, 0.03458482f, -0.03439795f, -0.00809440f, -0.09318818f, 
    -0.00308915f, 0.13122876f, -0.01313789f, -0.00202967f, 0.06620724f, 0.24459580f, 0.01610825f, -0.04620365f, 
    0.18131429f, 0.18950443f, 0.06215307f, -0.50645781f, 0.12192854f, 0.00649507f, 0.06261068f, -0.08707738f, 
    0.05522098f, 0.04154664f, 0.27095735f, 0.20352879f, -0.06285653f, 0.03798786f, 0.04959292f, -0.04053815f, 
    -0.00734767f, 0.09936376f, -0.01971368f, 0.13064761f, -0.16145955f, -0.22470237f, 0.02820489f, 0.01514791f, 
    -0.03155109f, 0.03954070f, -0.01721592f, -0.23178542f, -0.09074850f, -0.00390628f, -0.14304690f, 0.19240576f, 
    -0.04801368f, 0.13181341f, 0.05470333f, -0.00311986f, -0.23161076f, 0.23244914f, -0.01231705f, 0.12378745f, 
    0.11989080f, 0.08217625f, -0.21021138f, 0.11474840f, -0.04074996f, -0.05152052f, -0.55973160f, 0.52141196f, 
    -0.27159494f, -0.07766016f, 0.09232875f, -0.06640989f, 0.04479757f, -0.09022861f, -0.15971865f, -0.07925744f, 
    0.14259617f, 0.11888584f, 0.07414715f, -0.31479490f, -0.01515265f, -0.00244682f, 0.00639398f, 0.03806628f, 
    -0.24719448f, -0.06765390f, -0.08669391f, -0.07853134f, 0.08458140f, -0.18232413f, 0.07338157f, -0.01767411f, 
    -0.01836303f, -0.46636960f, -0.27595010f, -0.21790315f, -0.28372294f, -0.17717993f, -0.19912788f, 0.04953402f, 
    0.10593789f, -0.00761724f, 0.09026260f, -0.16035546f, -0.20136611f, -0.15716542f, -0.07441160f, -0.10633804f, 
    0.05914527f, -0.01083496f, 0.16585380f, -0.11574439f, 0.20018876f, 0.84098899f, -0.20430756f, 0.10668087f, 
    0.09874435f, -0.10572889f, -0.02607389f, 0.19628651f, -0.14437246f, -0.15223333f, -0.05086159f, 0.04500499f, 
    0.21926942f, -0.01305576f, 0.01555824f, 0.17259200f, 0.31354016f, 0.31843588f, 0.16603866f, -0.02395498f, 
    -0.02792874f, -0.00870075f, -0.09907413f, 0.02064312f, 0.11115891f, 0.04169841f, 0.00461668f, 0.21564823f, 
    0.01681938f, -0.06534800f, 0.01671778f, -0.13968408f, 0.06810530f, 0.01903312f, -0.14444302f, -0.33603600f, 
    -0.28708315f, -0.23962633f, 0.04658439f, 0.08095919f, -0.04187570f, -0.07664844f, -0.02325013f, -0.02063135f, 
    -0.28200501f, 0.04356437f, 0.14140451f, 0.16321287f, 0.04746712f, 0.14375485f, 0.10739105f, -0.00433232f, 
    0.22096737f, -0.12240028f, 0.15616989f, 0.07138311f, -0.34732801f, -0.11003476f, -0.08788466f, -0.07905807f, 
    0.14816059f, -0.16842172f, 0.27267674f, -0.02698658f, -0.60312581f, -0.04604363f, 0.04520251f, 0.18301988f, 
    0.14288691f, -0.02399251f, -0.06590053f, 0.14969057f, -0.25667107f, -0.19093709f, -0.02776990f, 0.03695013f, 
    0.15553558f, -0.02743653f, -0.06430922f, -0.23059140f, -0.15767297f, -0.19838037f, -0.25343484f, 0.10025834f, 
    0.01855626f, -0.03784087f, 0.18091533f, 0.11734589f, 0.02221277f, 0.03604501f, 0.57926142f, 0.03415513f, 
    -0.02958184f, 0.12326708f, -0.05477891f, 0.07639261f, -0.03839460f, -0.05307674f, 0.00844116f, 0.15442996f, 
    -0.12804095f, -0.02927253f, -0.09892580f, 0.09774584f, -0.15088853f, 0.00948801f, -0.15236178f, -0.01406661f, 
    -0.42594972f, -0.06059708f, 0.03915901f, 0.10910616f, 0.03689202f, -0.05664511f, 0.07859758f, 0.00521996f, 
    -0.06699604f, 0.09968165f, 0.35111976f, -0.19770548f, -0.07662363f, -0.01714313f, 0.04834161f, 0.04872163f, 
    0.11295801f, -0.12962763f, -0.24671653f, -0.03457440f, -0.07664210f, -0.26811603f, -0.04224136f, 0.14558749f, 
    0.00422180f, 0.12694018f, -0.24655236f, -0.17971289f, 0.16880946f, 0.01041341f, 0.05092967f, -0.16392994f, 
    -0.17113233f, 0.05912689f, 0.03504152f, -0.00536661f, -0.16140363f, -0.16456202f, -0.27262723f, -0.19035129f, 
    -0.02706603f, -0.08852838f, 0.19458774f, 0.06868988f, -0.10596053f, 0.18233338f, 0.07945678f, -0.00737495f, 
    -0.04507040f, -0.04828053f, -0.06961196f, 0.03766752f, 0.09035849f, -0.17321754f, -0.04409092f, 0.26971492f, 
    0.17861103f, -0.01489862f, 0.04978247f, 0.04679435f, 0.02090631f, 0.10070491f, -0.50805914f, -0.11592457f, 
    0.15309811f, -0.05769489f, -0.05242033f, -0.15796797f, 0.04961406f, -0.01910198f, 0.06197116f, -0.43347460f, 
    -0.17756858f, -0.03808426f, 0.14685617f, 0.07916390f, -0.25189865f, 0.10957428f, 0.00208295f, 0.08129752f, 
    -0.00283844f, 0.02215930f, 0.46406594f, 0.02144582f, 0.10670374f, -0.09789477f, -0.02209461f, 0.03512490f, 
    0.08388693f, -0.00721408f, -0.02174995f, -0.37769219f, 0.10475557f, 0.00568271f, -0.09156684f, 0.01645104f, 
    -0.12213567f, 0.16194488f, 0.50430697f, -0.10209820f, 0.22977974f, 0.14018863f, 0.01267132f, -0.05864221f, 
    0.08717288f, 0.11699229f, 0.08593784f, -0.04797958f, -0.18323937f, -0.00575549f, -0.15555790f, 0.04449829f, 
    -0.05589206f, -0.03556128f, 0.11446221f, 0.02300931f, -0.08444820f, 0.23188062f, -0.03884442f, 0.02806338f, 
    0.04208692f, -0.00300914f, 0.21509007f, 0.10384196f, -0.00199351f, -0.32428217f, -0.01286050f, -0.06560113f, 
    -0.18448895f, 0.20104952f, -0.12141304f, 0.16644841f, 0.04838358f, -0.20022984f, 0.00772058f, 0.10255045f, 
    0.10221706f, -0.42989472f, 0.01624958f, 0.32932249f, 0.04489880f, 0.02486670f, 0.09474428f, 0.04832876f, 
    0.10548522f, 0.08918599f, 0.02551487f, 0.08429471f, -0.12196617f, -0.00797975f, 0.03309911f, 0.00561409f, 
    -0.23386763f, 0.07679912f, 0.16920127f, -0.03413826f, 0.01153619f, -0.06987491f, -0.10379112f, -0.11306142f, 
    -0.14339973f, 0.16975309f, 0.29771665f, 0.19616733f, -0.09966663f, 0.16263190f, 0.07147113f, 0.10590819f, 
    0.10284162f, 0.01615411f, 0.39614758f, 0.06085605f, -0.07919528f, -0.05850824f, -0.02524934f, 0.02365484f, 
    -0.12741198f, 0.14221859f, 0.04163231f, 0.45901743f, -0.00082432f, 0.32476598f, 0.25099412f, 0.10385000f, 
    0.01200309f, -0.21585515f, 0.00359600f, 0.10510661f, -0.09498882f, 0.00057593f, -0.09247066f, 0.01155546f, 
    -0.11636901f, 0.00125432f, -0.02077197f, 0.00738687f, 0.04491245f, 0.09837559f, 0.10270996f, 0.07368263f, 
    -0.09453985f, -0.15061314f, -0.04906191f, 0.09504148f, -0.08488481f, -0.01025947f, 0.21339367f, 0.35129097f, 
    0.13803297f, -0.02329901f, -0.20405518f, 0.05283482f, -0.06111535f, -0.00189338f, -0.02818996f, 0.16058102f, 
    0.13646717f, 0.10320388f, -0.12768663f, 0.03288453f, -0.04007449f, 0.01703281f, 0.03482277f, 0.09503808f, 
    0.16271307f, -0.30535710f, -0.22975978f, -0.19212924f, -0.06496129f, 0.18518749f, 0.08302123f, 0.04942079f, 
    0.04528038f, 0.09171356f, 0.14470492f, -0.05381056f, -0.10365655f, 0.07234832f, 0.06564993f, 0.05637347f, 
    0.00392282f, -0.06291502f, -0.34934041f, -0.02507033f, -0.61662543f, 0.04119815f, -0.00473249f, 0.01835034f, 
    0.05767827f, 0.10613744f, -0.13700388f, 0.07539607f, -0.04818451f, 0.15207538f, 0.11844568f, 0.07216289f, 
    0.00026143f, 0.25005084f, 0.07934232f, 0.13939950f, -0.52043134f, 0.04092639f, 0.15490407f, 0.04489725f, 
    -0.20812856f, -0.04508133f, -0.13889928f, -0.01601718f, -0.09749482f, -0.00196562f, 0.11618881f, -0.15892516f, 
    0.11802761f, 0.06994566f, 0.29642498f, 0.00014703f, 0.20697337f, -0.07956245f, -0.09216535f, 0.15324813f, 
    0.00001798f, -0.05297079f, -0.00543876f, -0.08576601f, 0.14354518f, 0.00568023f, 0.08330833f, 0.18824582f, 
    0.08525439f, -0.00858994f, -0.01651569f, -0.02090914f, -0.09317052f, 0.00453749f, -0.13876957f, -0.17003466f, 
    0.07579526f, -0.10977263f, 0.08222977f, -0.11036177f, -0.00419132f, 0.01956614f, -0.20419326f, -0.00648535f, 
    0.01718630f, 0.14520259f, -0.02069123f, 0.05277128f, 0.03244001f, 0.05076746f, -0.13303225f, 0.07146598f, 
    0.11495020f, -0.07619452f, 0.34228945f, -0.16854209f, -0.42375404f, -0.05597569f, 0.05960152f, -0.18106914f, 
    -0.01988185f, 0.05066013f, 0.03944976f, 0.07684524f, 0.13788398f, -0.33511755f, 0.23307124f, -0.19709435f, 
    -0.01359879f, 0.20608404f, -0.08366807f, 0.10843793f, -0.27222908f, 0.10008641f, -0.10517302f, -0.05161009f, 
    -0.16903926f, -0.09132927f, -0.11667813f, 0.05962798f, 0.21388610f, -0.09443461f, 0.34110308f, 0.23442085f, 
    0.02476243f, -0.13310692f, -0.32867002f, -0.07751371f, 0.14793955f, 0.03458105f, 0.07119192f, 0.13098060f, 
    0.11327670f, 0.01522013f, 0.03984394f, -0.17297830f, 0.11601435f, 0.10055188f, 0.12684502f, 0.23822613f, 
    0.26767251f, 0.16197710f, -0.36636749f, 0.06608113f, -0.03532297f, 0.09805283f, 0.00924275f, 0.07211131f, 
    0.05744929f, 0.14079604f, -0.14320323f, 0.03619054f, -0.16027769f, -0.10579734f, -0.06694759f, 0.03526869f, 
    -0.02203044f, 0.17363155f, 0.48777333f, -0.39122725f, 0.09506802f, -0.24564892f, -0.18457080f, 0.01582615f, 
    -0.03682861f, -0.08631274f, -0.25434482f, -0.07667720f, -0.20823598f, 0.13297497f, -0.05847538f, 0.07767208f, 
    -0.08444714f, 0.04444357f, 0.09513243f, -0.05426045f, 0.10750230f, -0.24204150f, 0.15452695f, 0.18122256f, 
    0.03632830f, 0.10340903f, 0.11938220f, -0.04143876f, -0.06480521f, 0.36765972f, -0.01039823f, 0.12722406f, 
    -0.13953991f, -0.00050980f, -0.08247939f, -0.06615691f, 0.15587007f, 0.10471474f, -0.18140465f, 0.24211340f, 
    -0.19501969f, -0.19419268f, 0.15886049f, 0.05727212f, 0.06135842f, 0.05640005f, -0.01019351f, -0.26940310f, 
    0.27299926f, 0.01967603f, -0.13301721f, 0.23077717f, 0.20648880f, -0.04854399f, -0.09139757f, 0.07270329f, 
    0.00780718f, -0.13942356f, 0.02423929f, -0.02087766f, -0.03447582f, 0.02979086f, 0.08964428f, 0.04239913f, 
    0.19205646f, -0.06014442f, 0.34700125f, 0.09117097f, 0.02729453f, 0.00058739f, 0.07979858f, 0.05181705f, 
    0.16290769f, 0.07659374f, -0.04264773f, 0.23284015f, 0.13978812f, 0.00537634f, -0.06730376f, -0.18549174f, 
    -0.08936840f, -0.00958959f, -0.12316933f, -0.02498417f, 0.08872659f, -0.01485351f, 0.02358207f, 0.05317603f, 
    -0.01598188f, 0.02048895f, 0.24867320f, 0.15223868f, -0.05167510f, -0.04847723f, -0.13873257f, -0.07736893f, 
    0.22208610f, 0.02583152f, 0.00808504f, 0.18885712f, 0.02570105f, 0.23529328f, -0.14596777f, -0.16293952f, 
    0.11190128f, 0.09625906f, 0.13373175f, 0.01072485f, 0.01451792f, -0.01124692f, 0.03342974f, -0.03039525f, 
    0.11385573f, 0.15144330f, 0.31369033f, 0.07611482f, -0.01864520f, 0.03099581f, -0.06151804f, -0.24098670f, 
    0.00644404f, 0.01075794f, 0.14871933f, -0.02066553f, -0.05979852f, 0.05224574f, -0.31330678f, -0.08534547f, 
    -0.02723396f, 0.00494445f, 0.16550069f, 0.04911954f, 0.09946077f, 0.10550943f, -0.07752572f, -0.05210554f, 
    -0.14128412f, -0.00378458f, 0.05085417f, 0.05125603f, 0.18542090f, 0.11939307f, 0.15758798f, 0.06269639f, 
    0.24628210f, -0.22111161f, 0.07582626f, 0.00497114f, 0.13026246f, 0.10508527f, 0.10105725f, -0.19818091f, 
    -0.26166400f, -0.05241739f, 0.24688338f, 0.11917203f, 0.18696719f, -0.03168884f, 0.10419928f, 0.01255283f, 
    0.09376260f, 0.05133461f, -0.09000865f, 0.23321435f, -0.04178416f, 0.05594913f, -0.09589202f, 0.00366164f, 
    0.05007927f, -0.07759970f, 0.14356084f, -0.14968723f, -0.25900155f, 0.18232599f, 0.01801214f, -0.01228947f, 
    0.17478316f, -0.10984385f, 0.09644447f, -0.05464057f, 0.01735518f, -0.05022009f, -0.17301139f, 0.12488139f, 
    -0.09268761f, 0.11818409f, -0.12970164f, 0.14248639f, -0.14659476f, -0.19727325f, -0.14934681f, 0.22232169f, 
    0.09984250f, 0.13987672f, 0.06399963f, 0.21895778f, 0.08866214f, 0.27536756f, -0.07515492f, 0.03644305f, 
    0.08848282f, -0.09600224f, -0.13759001f, -0.14508767f, 0.06520604f, 0.03464369f, 0.07063993f, 0.10071573f, 
    0.00132534f, -0.11440368f, 0.02477949f, -0.03596826f, 0.12305610f, -0.06424465f, 0.06096084f, 0.05575810f, 
    -0.29500243f, -0.09194143f, -0.09146264f, -0.07751418f, 0.10847370f, 0.01842505f, -0.06036570f, -0.01090911f, 
    -0.05030704f, -0.08919498f, -0.28167489f, 0.25412962f, 0.25592873f, -0.05265084f, -0.05458314f, -0.16925579f, 
    0.13980092f, -0.03542578f, -0.00940080f, -0.20676032f, 0.09838717f, -0.02191481f, -0.04687081f, -0.08379195f, 
    -0.06265066f, -0.10061412f, 0.09260210f, 0.04711793f, -0.01567061f, -0.09966959f, -0.19200638f, -0.19007000f, 
    -0.10264836f, 0.00228240f, -0.20465159f, -0.20976722f, -0.23230825f, -0.08164042f, -0.08920926f, 0.06610441f, 
    -0.00408784f, -0.03882626f, -0.09242822f, 0.06812444f, 0.06917524f, 0.09324016f, -0.09835700f, 0.21063882f, 
    0.09664647f, 0.04128072f, 0.03502567f, 0.13150725f, -0.11294759f, -0.04648577f, -0.10358886f, -0.41106480f, 
    -0.23516364f, 0.00979356f, 0.11672115f, -0.07172313f, 0.03047178f, -0.02381508f, -0.00874642f, 0.02262570f, 
    -0.19110125f, 0.34067833f, 0.48757216f, 0.04931287f, 0.08406477f, -0.07052013f, 0.07017288f, -0.28157920f, 
    0.16946647f, -0.06507827f, -0.17648165f, 0.01508637f, 0.08378576f, 0.02587595f, -0.03724635f, 0.08273652f, 
    0.20631564f, -0.01415204f, 0.12172758f, 0.03647839f, -0.07309760f, -0.04466435f, 0.22792444f, 0.10311225f, 
    -0.02609140f, 0.08126020f, 0.25129607f, -0.10065988f, -0.11951447f, -0.06499159f, -0.01981999f, 0.12792483f, 
    0.09003603f, 0.12326910f, 0.05696405f, -0.02866940f, -0.08016659f, -0.24232751f, 0.10093112f, -0.08371571f, 
    0.22443837f, -0.07737139f, 0.10241431f, -0.12093794f, 0.23155113f, -0.26948959f, 0.03057486f, 0.03868816f, 
    -0.13287829f, 0.08734502f, 0.08120576f, 0.18122233f, 0.14118148f, -0.22445670f, 0.29843792f, 0.19555663f, 
    -0.10130289f, 0.05954158f, -0.08642051f, 0.00489124f, 0.06574177f, 0.16177423f, 0.01466191f, -0.05081408f, 
    0.24100226f, 0.28746754f, 0.09510715f, 0.04235250f, 0.02621843f, 0.01922502f, -0.13281488f, -0.08085191f, 
    0.08793287f, 0.12029083f, 0.33339095f, 0.12033474f, 0.04303571f, -0.04771690f, -0.09684241f, -0.05509875f, 
    -0.33226040f, 0.07793290f, 0.19357571f, 0.03596363f, -0.08567923f, -0.10878541f, -0.05187336f, 0.05848629f, 
    -0.11496001f, -0.16223237f, -0.04231511f, -0.10110389f, 0.18574531f, -0.04505474f, 0.05023675f, -0.07785828f, 
    0.18225533f, 0.02026504f, -0.09488969f, -0.27944100f, -0.33090627f, 0.10997322f, 0.09436420f, -0.03823604f, 
    -0.05147734f, 0.13229513f, 0.01921375f, 0.17013898f, 0.02184292f, -0.05154080f, -0.01389507f, 0.09401130f, 
    -0.06544335f, -0.01275459f, 0.01678813f, 0.03303409f, -0.27394220f, -0.08317731f, -0.03071509f, 0.26900193f, 
    -0.41204166f, 0.00677470f, 0.01281560f, -0.10413853f, 0.15948330f, -0.04413600f, 0.27510679f, 0.03658153f, 
    0.38659161f, 0.03132951f, 0.17379585f, -0.01957683f, -0.06423087f, -0.03615659f, -0.03137965f, 0.13951854f, 
    0.13536999f, 0.28191963f, 0.04243071f, 0.12065621f, 0.00825473f, -0.08813053f, -0.26285443f, 0.08682836f, 
    -0.02660109f, 0.11027244f, 0.26811451f, 0.02365961f, -0.18399629f, -0.15391934f, -0.08069582f, 0.12376236f, 
    -0.09347612f, 0.03302521f, 0.14570372f, -0.09191544f, -0.11583290f, -0.12233347f, -0.04857725f, 0.11460501f, 
    -0.06142741f, 0.09588869f, -0.30056584f, -0.10686135f, 0.00274719f, 0.01185205f, 0.05094584f, 0.16757005f, 
    -0.05567263f, 0.17481723f, -0.07123093f, -0.04086837f, 0.26089096f, 0.00637997f, -0.06530567f, -0.16074468f, 
    0.14062619f, 0.18557175f, 0.05137346f, -0.11954331f, -0.19439775f, -0.09156834f, 0.08417159f, -0.28950226f, 
    0.23700930f, -0.07204209f, -0.00993182f, -0.01092889f, 0.07543179f, 0.02488119f, 0.10692403f, 0.25667742f, 
    -0.11557347f, -0.08233760f, 0.00708374f, 0.14457890f, -0.10914242f, 0.02389285f, -0.21296714f, -0.05302611f, 
    0.23994040f, 0.20905228f, -0.23568854f, -0.35784465f, -0.02733915f, -0.05930589f, 0.01043800f, -0.01450026f, 
    -0.08529171f, 0.16032107f, 0.11879884f, 0.10896040f, -0.07191256f, -0.02926630f, -0.10833102f, -0.12316284f, 
    -0.23416802f, 0.39497679f, -0.25752965f, 0.04595431f, -0.01784779f, -0.27130499f, 0.14968705f, -0.00780887f, 
    0.14945652f, -0.37446594f, -0.01001304f, -0.46522003f, -0.31670794f, -0.06055296f, -0.01446037f, 0.12486764f, 
    0.03560757f, -0.00701710f, 0.22357714f, -0.02428341f, -0.78479415f, -0.12545741f, -0.13509975f, 0.23177445f, 
    0.10766248f, -0.14206567f, -0.15883200f, -0.03976845f, -0.53602064f, -0.68721384f, -0.21495853f, -0.04585897f, 
    0.16641641f, -0.01649933f, -0.23024030f, -0.06946216f, 0.19294742f, 0.36415610f, 0.11123294f, 0.02899593f, 
    -0.03362281f, -0.04071970f, 0.02124529f, 0.04269708f, 0.16719633f, -0.33047539f, 0.39868951f, 0.06073463f, 
    -0.01092127f, 0.18810108f, -0.24514320f, 0.00949697f, 0.14327388f, 0.01589789f, -0.17621876f, -0.30398905f, 
    -0.28014290f, 0.01308820f, 0.05050205f, -0.05470067f, 0.10268184f, 0.16170563f, -0.06556991f, -0.27155370f, 
    0.48604795f, 0.13827528f, -0.07984193f, -0.08057648f, -0.07441887f, 0.16564965f, 0.22103152f, 0.04121552f, 
    -0.27884907f, -0.31742468f, -0.35770768f, -0.05837599f, 0.17367721f, 0.16342872f, 0.04843450f, 0.04218865f, 
    0.05333924f, 0.34003183f, -0.34172207f, -0.23639435f, -0.17807765f, 0.09589746f, 0.05024701f, 0.01202336f, 
    -0.17167735f, 0.03327757f, -0.13172333f, -0.17271559f, 0.05924454f, -0.04231729f, 0.14957696f, -0.11407427f, 
    0.12447920f, 0.09760625f, 0.02553657f, 0.21049300f, -0.10250356f, -0.00290164f, 0.09911164f, -0.09716053f, 
    -0.09756625f, 0.05668956f, 0.19603404f, 0.07680442f, -0.39998820f, -0.19111057f, -0.05409615f, 0.16392443f, 
    0.15797764f, -0.16560347f, 0.02818136f, -0.07358396f, -0.01776338f, -0.41525367f, -0.25770074f, 0.00052601f, 
    0.00152003f, 0.03352555f, 0.12414248f, 0.12452839f, 0.00310051f, -0.05586023f, -0.41141501f, 0.18770838f, 
    -0.08138647f, -0.11286853f, 0.22172047f, 0.08564903f, -0.10991268f, 0.22781949f, -0.23115484f, -0.02157335f, 
    0.11277074f, -0.27035764f, -0.03645144f, -0.02551290f, 0.06844912f, 0.00721859f, -0.02765313f, -0.14850526f, 
    -0.18037325f, 0.03668526f, 0.03912178f, 0.06484321f, -0.06436808f, -0.02010879f, 0.05388376f, -0.00739995f, 
    0.16787116f, 0.11650654f, 0.09904645f, -0.10840405f, 0.00454670f, -0.14141814f, 0.02007878f, 0.01683253f, 
    0.15188664f, -0.31920201f, 0.19167939f, 0.26874167f, 0.07618847f, 0.11155552f, 0.08497486f, -0.01808481f, 
    0.04194497f, 0.06222675f, -0.11734686f, 0.16235960f, 0.18935536f, 0.04411636f, 0.18144378f, -0.01576164f, 
    0.00589110f, 0.09317989f, -0.27164614f, 0.03707140f, -0.19874394f, 0.08661539f, -0.13909881f, 0.09976460f, 
    -0.08390141f, 0.04614668f, -0.32469389f, 0.14428692f, 0.08225656f, 0.03105094f, 0.06178918f, 0.18238506f, 
    -0.09659170f, -0.09509260f, -0.22577828f, 0.19890030f, -0.12531689f, 0.11689148f, -0.08595297f, -0.15072906f, 
    -0.06080972f, -0.05784476f, -0.13304055f, 0.14337979f, 0.02797311f, 0.17284603f, 0.15214552f, 0.16323225f, 
    -0.31063861f, -0.05721933f, -0.04057648f, -0.24260585f, -0.07833055f, 0.09680759f, 0.03198557f, 0.14361987f, 
    0.09056742f, 0.08634811f, -0.04885869f, 0.13019472f, 0.04257173f, 0.09582258f, 0.15173453f, -0.15242085f, 
    -0.07350980f, 0.07988510f, 0.07436039f, 0.01265106f, -0.09786575f, -0.07163724f, -0.15196386f, 0.01991277f, 
    0.04356496f, 0.12037017f, -0.52801764f, 0.03004069f, 0.03805327f, -0.17345354f, 0.08817356f, -0.25540343f, 
    0.05160056f, 0.03882460f, -0.02384733f, 0.34692341f, -0.21048236f, -0.36386004f, -0.00204309f, -0.09033519f, 
    -0.09265042f, 0.29625601f, 0.32158038f, 0.03017864f, 0.02199080f, -0.40434447f, -0.23079917f, 0.10882488f, 
    0.07708381f, -0.04397866f, 0.01530374f, 0.17993121f, -0.19391480f, 0.11339165f, 0.21607655f, 0.06493572f, 
    -0.05677262f, -0.06214265f, 0.06956239f, -0.01358529f, 0.16717114f, -0.06464589f, 0.53570783f, -0.07363123f, 
    -0.29473495f, 0.28904074f, 0.02674443f, -0.43231273f, 0.23790811f, 0.05462644f, 0.06226334f, 0.21067062f, 
    0.13537952f, -0.11118250f, 0.00776550f, -0.00024827f, 0.01723739f, 0.07958523f, 0.04030335f, 0.00004367f, 
    0.00104683f, -0.03932650f, 0.10574017f, -0.25252569f, -0.08448959f, -0.00575629f, 0.01520405f, 0.01703979f, 
    -0.00233012f, -0.43260357f, -0.00635440f, 0.07086455f, 0.08689862f, 0.04766455f, 0.08725336f, 0.10774315f, 
    0.17715867f, -0.01337227f, -0.13577770f, -0.10684539f, -0.03802864f, 0.10406717f, -0.16585259f, -0.04226024f, 
    -0.01418684f, 0.05155431f, -0.03392968f, 0.40410370f, -0.04265409f, -0.22588181f, -0.00159816f, -0.16891961f, 
    0.10222293f, 0.07272986f, -0.08281560f, -0.16480845f, 0.04249003f, -0.04921027f, 0.36879981f, 0.03669278f, 
    0.10866784f, -0.01773918f, -0.00226840f, -0.00626399f, 0.17127253f, 0.51791769f, 0.09634937f, 0.08703458f, 
    0.01933389f, -0.00703328f, -0.02022661f, -0.10148753f, -0.00505701f, -0.08318307f, 0.02913594f, -0.10601878f, 
    0.14095783f, 0.08149368f, -0.06982142f, 0.16796331f, 0.06484038f, 0.00604613f, 0.06459635f, -0.10884520f, 
    0.22676115f, 0.22508346f, 0.00594016f, -0.04010492f, -0.02359495f, -0.08697486f, 0.02670076f, 0.16583644f, 
    0.19577777f, -0.51205832f, -0.23103942f, -0.17541267f, -0.08038776f, -0.08722185f, -0.08841491f, 0.03666329f, 
    -0.10595340f, 0.12653446f, 0.05294775f, 0.30361855f, -0.16315368f, -0.15918615f, -0.14954622f, -0.14064877f, 
    -0.05428931f, -0.01738734f, -0.06751164f, 0.19887559f, -0.01179493f, 0.04175799f, 0.17726102f, -0.09323886f, 
    -0.00709787f, 0.03130203f, -0.08214652f, 0.04971190f, 0.05533493f, 0.24745242f, -0.07115265f, -0.10065676f, 
    0.01883509f, 0.16992448f, 0.05387662f, -0.05135965f, -0.21648647f, -0.01809049f, 0.19517028f, -0.05476286f, 
    0.04087738f, -0.18300895f, 0.15307975f, 0.20702389f, -0.12644294f, -0.17514369f, -0.12830627f, -0.35564047f, 
    0.04968546f, -0.12953416f, 0.17951243f, 0.19050364f, -0.01126496f, 0.01512797f, 0.34734988f, 0.03831286f, 
    -0.04563220f, -0.01321829f, 0.18201512f, 0.12337914f, 0.12813477f, 0.20927224f, -0.04722010f, -0.22553369f, 
    -0.30384186f, -0.35777003f, 0.01072053f, 0.05566743f, -0.07026008f, 0.02866827f, -0.09260514f, -0.04715907f, 
    0.26392359f, -0.24400420f, -0.33328497f, 0.05674917f, 0.10477877f, 0.08784586f, -0.14111333f, -0.00074484f, 
    -0.03192220f, -0.05629737f, -0.11203826f, -0.33381259f, 0.02700852f, 0.08112092f, -0.04306984f, 0.08341718f, 
    0.09372560f, -0.09336142f, -0.25056154f, -0.04789434f, -0.03548317f, -0.03281080f, -0.08467432f, 0.00065512f, 
    -0.04726513f, -0.32042050f, -0.23371802f, -0.17401347f, -0.16314831f, 0.14160459f, 0.13090488f, 0.03798801f, 
    0.06491740f, -0.18181731f, 0.07649929f, 0.02937426f, 0.00803517f, -0.07522225f, 0.15963247f, -0.20126294f, 
    -0.01646356f, 0.00704825f, -0.43522394f, -0.16292925f, -0.24300589f, 0.02127629f, 0.01524059f, 0.00215434f, 
    0.17110498f, 0.33279738f, -0.00198041f, -0.14783446f, -0.03656535f, -0.08113656f, 0.07088148f, 0.05285526f, 
    0.13919480f, 0.00597409f, 0.03486786f, 0.10031915f, 0.05159811f, 0.14312363f, 0.18364121f, 0.18296228f, 
    0.00190981f, 0.04341800f, -0.09287002f, 0.11931778f, 0.00444423f, 0.28909627f, 0.00609782f, 0.03235141f, 
    0.04224734f, -0.05776838f, 0.25460920f, 0.06764395f, -0.08851674f, 0.12847935f, -0.05965144f, -0.18460144f, 
    -0.08335036f, -0.02082610f, -0.03281328f, 0.17706320f, 0.19695312f, 0.07736563f, 0.02792256f, -0.01472010f, 
    -0.14156570f, 0.01885381f, 0.25746849f, -0.17960887f, 0.12359535f, 0.17500222f, 0.11536548f, 0.01506073f, 
    0.01290681f, 0.08638968f, 0.06894203f, -0.13983007f, 0.22039939f, 0.21879695f, 0.09761709f, -0.14813451f, 
    0.04138517f, -0.02243080f, 0.20594583f, 0.19563605f, 0.15857303f, 0.12676543f, 0.24341792f, -0.10498980f, 
    0.03539755f, 0.04908540f, -0.03217448f, 0.01465172f, -0.00702009f, 0.15242191f, 0.05720382f, 0.07784101f, 
    0.01558758f, -0.10135958f, 0.17460631f, 0.04704116f, 0.32624975f, 0.03129470f, -0.02503226f, -0.01891920f, 
    0.12121908f, 0.05654063f, -0.06995387f, 0.17864487f, 0.02802944f, -0.08681256f, 0.01335102f, -0.11718757f, 
    -0.17318849f, 0.25254181f, -0.04085551f, 0.10496888f, -0.00611369f, 0.08604608f, -0.09814338f, -0.10191828f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.12103148f, 0.00345528f, 0.16417839f, 0.13830318f, -0.08429775f, 0.32814270f, 0.25745654f, -0.19127390f, 
    -0.16377896f, 0.21922293f, 0.25798365f, -0.03810433f, 0.26415190f, -0.05933913f, -0.00534480f, 0.11137327f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.30863547f, 0.02692978f, 0.18920557f, -0.18964337f, 0.05796928f, -0.04939378f, 0.03302405f, 0.54131234f, 
    0.34600034f, 0.12482288f, -0.38343760f, -0.07354391f, -0.09836787f, 0.06772085f, -0.15403239f, -0.46492389f, 
    0.04647220f, -0.76746911f, 0.13445559f, -0.44412613f, 0.22088440f, -0.34880754f, 0.03942704f, -0.42780319f, 
    0.13280115f, 0.09621122f, 0.27559742f, 0.32649940f, 0.05475069f, 0.06833296f, -0.03801078f, 0.23458816f, 
    -0.50721109f, -0.47774801f, 0.14259049f, -0.44630086f, 0.12987442f, -0.48150456f, 0.18228516f, 0.03725712f, 
    0.38190037f, -0.16055104f, -0.08755793f, 0.22944778f, 0.29156959f, 0.10904174f, 0.15917410f, 0.21988656f, 
    -1.07083166f, 0.39345193f, 0.22988126f, 0.42349109f, 0.24919407f, -0.05852882f, 0.35539645f, -0.05389924f, 
    -0.36775267f, -0.19812831f, -0.04207041f, -0.21045505f, 0.21626118f, -0.29029337f, 0.07008148f, 0.18892510f, 
    0.27266309f, 0.08896530f, -0.07822368f, 0.57411385f, 0.08856174f, 0.38220203f, -0.27681947f, 0.00066054f, 
    0.45163462f, 0.13255416f, -0.41046181f, 0.32736939f, -0.09199343f, -0.05775318f, -0.09261620f, -0.17963436f, 
    0.05037840f, 0.17883694f, -0.21915607f, -0.02069129f, -0.24208809f, -0.24958108f, -0.00782581f, 0.19310759f, 
    -0.03094416f, -0.20850326f, 0.07604694f, 0.16210379f, -0.24920088f, -0.13287573f, 0.09695701f, -0.18385620f, 
    0.04502578f, 0.06931882f, -0.21612276f, -0.08904099f, 0.41045278f, -0.28816375f, -0.13276044f, 0.17367972f, 
    -0.08098073f, -0.00134536f, 0.17384753f, -0.32906246f, -0.17239693f, 0.07310363f, -0.01980558f, 0.06281275f, 
    0.39625174f, 0.02817452f, -0.02193267f, 0.05053677f, 0.40959880f, 0.22055714f, -0.19098829f, -0.04289807f, 
    0.39984339f, 0.00783913f, 0.04057660f, 0.23310456f, 0.34366134f, -0.21621040f, 0.37545866f, -0.23075840f, 
    0.26243186f, -0.21473768f, 0.27554646f, 0.20988983f, 0.00801849f, -0.55095088f, 0.39017603f, -0.54620773f, 
    0.09756573f, -0.01892547f, 0.26438528f, 0.26985827f, -0.09071793f, -0.15193063f, 0.06968335f, 0.15214463f, 
    -0.31648198f, -0.19431983f, 0.03942486f, 0.17289236f, 0.01117391f, 0.25396940f, 0.49324983f, -0.56352282f, 
    0.17755295f, -0.06439403f, 0.31337562f, -0.09543505f, 0.04285990f, 0.01550009f, -0.45711166f, 0.11069021f, 
    0.04311469f, -0.12825702f, 0.21459097f, 0.20130548f, -0.21261662f, -0.35544437f, -0.04859473f, 0.29049763f, 
    0.36448240f, -0.08918467f, -0.14559785f, -0.02301494f, 0.34670496f, 0.02281131f, 0.19256523f, 0.21593818f, 
    0.25858912f, -0.67596519f, 0.12392186f, 0.16893087f, 0.06597877f, -0.26161703f, -0.02689863f, 0.31388959f, 
    0.41130459f, 0.04455455f, -0.07930154f, 0.32743952f, -0.41761881f, -0.27397028f, 0.31717765f, 0.18078418f, 
    0.04000061f, -0.10183211f, -0.24511279f, -0.01314452f, 0.14398870f, -0.17733595f, 0.13412847f, -0.13318875f, 
    -0.26619285f, -0.12738693f, -0.04220499f, -0.20558384f, -0.20148033f, 0.08184315f, -0.00583611f, 0.10948820f, 
    0.29194385f, 0.30432338f, 0.33380726f, 0.12839678f, -0.19898362f, 0.32152763f, 0.08689357f, -0.35422799f, 
    -0.11622949f, -0.17373073f, 0.29588202f, -0.24403565f, -0.30401048f, -0.19380954f, 0.30694517f, -0.16472955f, 
    -0.40282422f, -0.16461806f, -0.02027388f, -0.23359659f, -0.05487917f, 0.19823547f, -0.20461205f, 0.15403281f, 
    0.36538514f, 0.02744116f, -0.19797207f, -0.05028735f, 0.41774550f, 0.09201963f, 0.21715336f, 0.33828279f, 
    -0.03960486f, -0.12008122f, -0.18106163f, -0.05561456f, -0.11851757f, 0.11471615f, 0.09216899f, 0.00759729f, 
    -0.05502864f, -0.23281875f, 0.09975583f, -0.08529230f, -0.13069476f, -0.04247629f, 0.14552951f, -0.16870204f, 
    -0.12055323f, 0.42628282f, 0.10355131f, -0.21117039f, 0.09698011f, 0.12207556f, 0.09982474f, 0.02923123f, 
    -0.42170408f, 0.10132879f, 0.42805919f, -0.35645103f, 0.20070240f, 0.12895261f, -0.10241027f, -0.23467584f, 
    0.49679935f, 0.27653426f, 0.29523507f, 0.32315180f, -0.22995882f, 0.07714296f, -0.32509524f, 0.25958291f, 
    0.12728693f, -0.06281662f, 0.08496154f, -0.43097284f, 0.29606757f, -0.16788466f, 0.11779858f, -0.00851682f, 
    0.38459802f, 0.01736684f, 0.20459443f, 0.16268776f, 0.24160387f, 0.04311088f, -0.34674212f, 0.14165279f, 
    0.36647466f, 0.08941695f, -0.17588173f, -0.11019478f, 0.31645152f, -0.34711921f, 0.20831008f, -0.02906611f, 
    0.70824766f, 0.01579179f, -0.02749854f, 0.02959049f, 0.41410464f, 0.02034981f, 0.01124003f, 0.07969011f, 
    -0.29401985f, -0.12160961f, 0.11442392f, -0.41513053f, 0.34590340f, 0.14736104f, 0.23754065f, 0.09222545f, 
    0.02634835f, -0.60920060f, -0.11971238f, -0.46093330f, 0.30563277f, -0.09499189f, -0.07236111f, 0.18840785f, 
    0.09582590f, 0.26233795f, -0.29685220f, 0.23281233f, -0.08606893f, 0.15953983f, 0.18383487f, 0.25897816f, 
    -0.23736575f, 0.04350138f, 0.16762644f, -0.09144931f, -0.40324694f, 0.24918392f, 0.21914083f, -0.45594844f, 
    0.34335545f, -0.26596233f, 0.26196107f, 0.24258669f, -0.13687792f, -0.05788217f, -0.00537890f, 0.08817494f, 
    -0.32572889f, -0.27538189f, -0.04167349f, -0.05612032f, 0.09469970f, -0.08644392f, 0.62777233f, -0.33363125f, 
    -0.13335672f, 0.35963875f, 0.08695332f, -0.10959583f, -0.21988901f, -0.13278013f, -0.66892177f, -0.22585298f, 
    -0.31116393f, -0.02268452f, -0.02450195f, -0.02418994f, 0.31058556f, 0.36947379f, -0.36428109f, 0.25701091f, 
    -0.09358526f, 0.43925440f, -0.12775503f, -0.27018678f, 0.23748752f, 0.33967119f, -0.27064532f, -0.16366936f, 
    0.33744198f, -0.80800414f, 0.23270729f, 0.04370955f, 0.20608030f, -0.08851258f, -0.11365663f, 0.11845738f, 
    0.06047799f, 0.06602556f, 0.00618122f, 0.30670294f, -0.51042581f, -0.02076804f, 0.38033015f, 0.07637828f, 
    -0.08862506f, 0.09882281f, -0.21942300f, 0.23647659f, 0.11963846f, -0.17418838f, 0.25585514f, -0.31572333f, 
    -0.26037234f, 0.22279169f, 0.17292298f, -0.35654375f, -0.16550539f, 0.26266176f, -0.22596657f, -0.01253839f, 
    -0.55967885f, -0.24568132f, 0.22142242f, -0.41747189f, 0.16311161f, 0.12199901f, 0.30763263f, -0.24853426f, 
    0.00811545f, -0.03553426f, 0.18775833f, -0.17928396f, 0.23573664f, 0.31880376f, -0.52557397f, -0.01105112f, 
    -0.40613934f, -0.33728179f, -0.06471919f, 0.36406234f, 0.14497122f, 0.07986669f, 0.50461596f, -0.13610888f, 
    0.17114143f, 0.25608334f, -0.05506008f, -0.33900130f, -0.13732265f, -0.15684614f, -0.39087725f, 0.03634059f, 
    0.25298023f, -0.18585810f, 0.40907034f, -0.24361770f, 0.20703062f, -0.21784191f, -0.10182811f, 0.11582097f, 
    0.26082635f, -0.16429120f, 0.18447797f, 0.05774388f, -0.55850148f, 0.19338547f, 0.36270586f, -0.01265882f, 
    -0.07183515f, -0.16013673f, -0.05010403f, 0.13845932f, -0.07893042f, -0.04282019f, -0.17074071f, 0.06878491f, 
    -0.13919248f, 0.15546881f, -0.18604344f, 0.12867011f, -0.07045638f, -0.20551769f, 0.09784512f, -0.30046859f, 
    0.11598267f, 0.17823258f, 0.05094426f, -0.15216970f, -0.19305171f, 0.37645012f, 0.14258631f, -0.37458423f, 
    -0.29890507f, 0.13858834f, 0.32923296f, -0.22244854f, -0.18959369f, 0.14656697f, -0.46092111f, 0.17638828f, 
    0.62290949f, 0.23778892f, 0.22388123f, 0.35912248f, -0.35911196f, -0.26096287f, 0.37679061f, 0.12228077f, 
    0.06042186f, -0.15832749f, 0.25443721f, -0.04192965f, 0.52537167f, -0.32774931f, -0.37925416f, 0.23825447f, 
    -0.55548000f, -0.35909790f, 0.04249901f, 0.21084960f, -0.20661804f, -0.05373131f, -0.27543488f, -0.44102725f, 
    0.18399502f, 0.15696862f, -0.28018862f, -0.10499082f, -0.00323110f, 0.12336261f, 0.01219727f, 0.30518803f, 
    0.77065861f, 0.13541862f, 0.27936089f, 0.20536532f, 0.41826394f, -0.11142249f, 0.07336578f, 0.17316751f, 
    -0.01845470f, -0.23794988f, -0.03074665f, 0.34261987f, 0.25273487f, -0.13090402f, 0.32383993f, -0.16701892f, 
    -0.08245889f, 0.10307838f, -0.29070264f, 0.57388133f, 0.34391299f, -0.30491957f, 0.35197234f, 0.37418211f, 
    0.22894117f, 0.15435520f, -0.10989431f, -0.23416346f, -0.21816166f, -0.15509534f, -0.13399078f, 0.17650512f, 
    0.29681236f, -0.15652542f, -0.04845325f, -0.38413167f, 0.15342578f, -0.31402287f, -0.29743475f, 0.06121792f, 
    -0.04417012f, 0.35555530f, 0.25548172f, 0.32917416f, -0.06557857f, 0.28918487f, 0.42630103f, -0.27626675f, 
    0.14191063f, -0.31241646f, 0.21132426f, 0.42062268f, 0.18040746f, 0.34430882f, 0.12171537f, -0.50057310f, 
    -0.02066647f, 0.45999944f, -0.38165537f, -0.23806570f, 0.38488731f, -0.14119019f, -0.46801680f, -0.39918777f, 
    -0.17770183f, -0.01636043f, -0.23065747f, 0.04194704f, 0.33673146f, 0.22666590f, 0.33513871f, -0.15960971f, 
    0.12162670f, 0.22522050f, 0.16422489f, 0.21464312f, 0.17601414f, -0.12519085f, -0.03430552f, -0.28625470f, 
    -0.14868622f, -0.13580057f, -0.05774535f, 0.51244313f, 0.03672847f, -0.00840696f, 0.47289795f, -0.28895846f, 
    0.19201908f, 0.25311938f, -0.18176743f, 0.02105492f, -0.19616373f, -0.14383955f, -0.26979572f, 0.07636450f, 
    -0.49794552f, 0.16477609f, 0.26168856f, 0.29904416f, 0.15083511f, -0.59437644f, 0.39824590f, 0.04107084f, 
    0.29712594f, -0.13843803f, 0.09993904f, -0.00587076f, 0.54899013f, -0.41080400f, -0.30905011f, -0.12641217f, 
    -0.09708601f, -0.10089797f, 0.08905969f, 0.06005684f, -0.07567377f, -0.42100000f, 0.14210436f, -0.32286283f, 
    -0.33898041f, 0.15817484f, 0.43445766f, 0.13587873f, -0.29465577f, -0.04245114f, 0.00666374f, 0.18517864f, 
    -0.42312166f, 0.16871798f, 0.28638542f, -0.04099740f, 0.34690589f, -0.19254564f, -0.12027014f, 0.43917987f, 
    0.08723462f, 0.00376122f, -0.23679209f, -0.12008273f, -0.17743002f, 0.00519998f, -0.34143797f, -0.54140782f, 
    -0.10204630f, 0.47842768f, -0.10853215f, -0.36157688f, -0.40633479f, 0.23723242f, 0.02364404f, -0.11704457f, 
    -0.24420823f, 0.28642118f, 0.21336593f, 0.21146856f, -0.24946789f, 0.49239442f, 0.12565382f, 0.02359380f, 
    0.12838402f, -0.38072392f, 0.00223314f, 0.05649513f, 0.29120579f, -0.08735675f, 0.15630156f, -0.39484844f, 
    -0.22109199f, 0.03849569f, 0.17765209f, -0.24773468f, -0.03012661f, 0.20677005f, 0.31793869f, 0.14844663f, 
    -0.08982361f, 0.13280448f, -0.17033738f, 0.43307248f, 0.00072881f, 0.17524943f, 0.27274412f, 0.04337323f, 
    -0.07705761f, 0.33796918f, 0.25709015f, 0.38913918f, -0.69917142f, -0.33132082f, -0.18548080f, -0.38681191f, 
    -0.52992392f, -0.24676873f, 0.15510298f, -0.43403780f, -0.20985630f, -0.35103357f, -0.20387243f, 0.20337372f, 
    0.38457093f, -0.08365774f, 0.25068331f, -0.14282045f, 0.45665121f, 0.18802911f, -0.09005191f, 0.26488355f, 
    0.35484535f, 0.03870473f, 0.28453639f, 0.17861778f, -0.18311974f, -0.52167451f, 0.36206806f, 0.25165746f, 
    0.13898778f, -0.34959003f, 0.13949797f, 0.29232478f, 0.09702378f, -0.14776918f, 0.29125166f, 0.06889127f, 
    -0.43194491f, -0.18300885f, 0.16257802f, 0.09976216f, 0.22516033f, -0.73501819f, -0.50616866f, 0.20481722f, 
    0.43279308f, 0.02893082f, -0.13592039f, 0.42863467f, 0.32445225f, 0.04538603f, -0.20906065f, -0.64744228f, 
    0.32173440f, -0.31469333f, -0.09800382f, 0.04764891f, 0.27282897f, 0.30918866f, -0.13169345f, 0.26428565f, 
    0.27065492f, 0.13750015f, -0.17049621f, 0.11913867f, 0.01259749f, 0.00506656f, 0.03931451f, -0.24900381f, 
    -0.30030149f, 0.01918468f, 0.29055655f, -0.07049867f, -0.24145305f, 0.50881839f, 0.11430603f, -0.40003997f, 
    0.28702557f, -0.15465637f, 0.18844916f, -0.15472853f, 0.21733937f, 0.19366500f, -0.43687686f, 0.27609259f, 
    0.03680724f, -0.11103828f, -0.17243166f, 0.23993473f, -0.01332089f, -0.19284797f, -0.05637708f, -0.05278687f, 
    -0.13268773f, 0.01589684f, -0.07862592f, -0.10837507f, -0.17178696f, -0.22986543f, -0.18446650f, 0.02174977f, 
    -0.26573873f, 0.20964725f, 0.21955742f, 0.28168055f, 0.33013326f, -0.01905124f, 0.07615082f, 0.08308773f, 
    -0.11954870f, -0.09904513f, -0.32923153f, -0.37075269f, 0.14210249f, -0.22132152f, -0.01523552f, 0.18599306f, 
    0.18225695f, 0.12179974f, 0.07460614f, 0.13886765f, 0.30321285f, 0.29042464f, -0.24643086f, 0.48186362f, 
    -0.09552971f, 0.28216806f, -0.17442948f, -0.29680434f, 0.38620561f, 0.10520768f, -0.29349226f, -0.13031882f, 
    -0.31654310f, -0.04580534f, 0.39437896f, -0.27494758f, -0.29017186f, -0.32154977f, 0.09282899f, 0.17817882f, 
    0.12203893f, -0.30400452f, -0.03730011f, -0.30028659f, 0.18534751f, 0.30074328f, -0.49501699f, 0.32054612f, 
    -0.21737380f, -0.16095540f, 0.30908900f, -0.07637128f, -0.03516746f, -0.57858199f, 0.27986497f, -0.53677672f, 
    0.14942420f, -0.05373497f, 0.12362949f, 0.31458202f, 0.55800784f, -0.13301311f, -0.09466356f, 0.18482848f, 
    -0.20073946f, 0.27318236f, 0.19411278f, -0.01519721f, 0.15243761f, -0.36521530f, 0.32581705f, -0.08841614f, 
    -0.28754967f, -0.18926619f, 0.00263943f, -0.12328663f, 0.57468134f, 0.28178707f, -0.21546167f, 0.16829579f, 
    0.09132507f, 0.07623885f, 0.29701528f, -0.40810061f, 0.31045604f, -0.24843608f, -0.13404088f, 0.26477873f, 
    -0.01261718f, -0.36605689f, 0.22371967f, -0.27559784f, 0.16399418f, 0.03601180f, 0.01493104f, 0.16885065f, 
    0.37529346f, -0.36790165f, -0.25381801f, 0.12974353f, 0.24195811f, 0.31766620f, -0.13836773f, -0.17339957f, 
    -0.42523462f, 0.39811864f, 0.13971008f, 0.10839790f, -0.14129138f, 0.14427197f, -0.10468644f, -0.09625211f, 
    -0.06245355f, 0.03256931f, -0.14269094f, 0.10570996f, -0.27889147f, 0.51030076f, -0.03692504f, -0.14590485f, 
    -0.17181440f, 0.31130499f, 0.06872029f, -0.11152749f, -0.33352587f, -0.09723111f, 0.21287693f, 0.02911673f, 
    -0.33539557f, 0.43567014f, -0.03917745f, -0.15775946f, 0.16312410f, 0.18278731f, -0.17428653f, -0.41682252f, 
    -0.21360946f, -0.00556880f, 0.12688601f, -0.20269713f, 0.02046968f, -0.13529037f, 0.36228278f, 0.15784428f, 
    0.44630927f, -0.07439209f, 0.34742096f, 0.01637754f, 0.15837862f, -0.32873717f, 0.25790998f, -0.33413506f, 
    -0.01097665f, -0.02240240f, 0.20371044f, 0.35009477f, -0.58850104f, -0.14265321f, 0.31969929f, -0.07426298f, 
    0.19144265f, 0.22986722f, -0.14969824f, -0.06901329f, -0.44307819f, 0.07171617f, 0.06412850f, -0.34719360f, 
    -0.14615282f, 0.26872963f, 0.41566333f, 0.49746650f, -0.58848369f, 0.21458727f, -0.13919902f, -0.04315958f, 
    -0.00578278f, -0.18621048f, -0.17225003f, 0.19135828f, -0.34602967f, 0.02837483f, -0.14900291f, 0.01370511f, 
    0.21923752f, 0.24822719f, 0.39587337f, 0.35079926f, -0.27333814f, -0.22029833f, 0.10052410f, -0.04502677f, 
    0.89045173f, -0.47703528f, 0.45045012f, -0.08678291f, 0.08199063f, -0.35772237f, -0.12289791f, 0.17688829f, 
    -0.35293576f, -0.26533893f, 0.34818935f, 0.02731471f, -0.16629092f, 0.39107639f, -0.01427207f, 0.38344014f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01069704f, 0.37523225f, 0.04572681f, -0.21501502f, 0.14364472f, -0.06493133f, -0.19969486f, -0.31945089f, 
    0.02807502f, 0.47742632f, -0.08260650f, 0.23366438f, -0.21014327f, 0.52750498f, -0.55980891f, 0.05601383f, 
    -0.01133612f, -0.08226436f, -0.20130357f, 0.61637551f, 0.03997668f, 0.31720591f, 0.61282247f, 0.30615541f, 
    0.04842874f, 0.22540356f, 0.42463467f, 0.36665925f, 0.15125096f, -0.20253980f, 0.39917368f, 0.28105190f, 
    0.05882554f, -0.12829433f, -0.08857783f, 0.27964869f, 0.36853632f, 0.43042469f, 0.02860227f, 0.04378909f, 
    0.58946735f, -0.17082486f, -0.46200258f, 0.53931093f, 0.38023710f, 0.20631459f, -0.04841077f, 0.08309115f, 
    -0.35191131f, 0.20777868f, -0.10540815f, 0.10380464f, -0.05264533f, 0.33432245f, 0.40148959f, 0.05197014f, 
    0.09256802f, 0.58590961f, 0.36912274f, 0.12370562f, -0.02475069f, 0.05884438f, 0.48587784f, 0.42125723f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10632253f, -0.10113114f, -0.13200973f, 0.00773847f, -0.05985498f, 0.07176751f, -0.06671986f, -0.12653139f, 
    0.05095881f, -0.11684116f, 0.03510217f, -0.12300162f, 0.02115767f, 0.09143042f, 0.06259391f, 0.09738855f, 
    -0.14164072f, -0.05556970f, -0.19089693f, -0.13416438f, 0.04337273f, -0.12287673f, 0.08051406f, -0.12679996f, 
    -0.04185857f, -0.05187343f, 0.12457526f, 0.00850412f, -0.17775697f, -0.11574084f, -0.12174195f, 0.01060765f, 
    -0.02676261f, -0.05939867f, 0.05665617f, -0.04676893f, 0.10455200f, -0.09386141f, -0.14241305f, 0.04459342f, 
    -0.10329107f, 0.04281962f, -0.13402012f, 0.04194513f, 0.06576543f, -0.04241018f, 0.03769191f, 0.05156226f, 
    -0.13131875f, -0.12838788f, 0.11595371f, -0.13555902f, -0.04655826f, 0.06557585f, -0.15146984f, 0.06359787f, 
    0.06777466f, 0.05475393f, -0.03856153f, -0.10990575f, -0.10601159f, -0.01365879f, -0.11645239f, -0.04276829f, 
    -0.44861084f, 0.01082170f, -0.17728576f, 0.05318411f, -0.59404409f, -0.00642953f, -0.21242900f, -0.15493838f, 
    0.22166800f, 0.14397459f, -0.21298526f, -0.09697890f, -0.05695200f, 0.28670830f, -0.62626088f, 0.03202982f, 
    0.37192455f, -0.10639016f, -0.18026091f, 0.08741818f, -0.14400463f, 0.27554309f, 0.36984688f, -0.03214473f, 
    0.02713515f, 0.03392647f, 0.08979689f, -0.11642392f, 0.12478888f, 0.06473213f, -0.03725858f, 0.17250504f, 
    -0.14407983f, 0.13662040f, -0.31271029f, 0.16447903f, 0.03902432f, 0.06918612f, -0.18487933f, 0.28839383f, 
    0.36790106f, -0.40225706f, 0.05387336f, 0.26060468f, 0.22195259f, -0.07547005f, 0.19884148f, -0.36497211f, 
    -0.29331058f, -0.10009027f, -0.03226750f, -0.06586034f, -0.01585509f, 0.12029090f, 0.14143157f, 0.40162051f, 
    0.14426292f, 0.08920720f, -0.10738731f, -0.02645507f, 0.23450156f, 0.32667443f, -0.12386479f, 0.23814367f, 
    0.53546935f, 0.06661635f, 0.22844623f, -0.05672588f, 0.05632173f, -0.07487090f, 0.03562292f, -0.01417178f, 
    0.23806454f, 0.14837703f, 0.26503107f, 0.55976492f, 0.09718352f, -0.15329768f, -0.00508144f, 0.03613519f, 
    -0.30580243f, 0.02894294f, 0.10440120f, 0.13953054f, 0.28858459f, -0.01832367f, -0.03013017f, -0.12785007f, 
    0.43312967f, -0.09456256f, -0.29825336f, 0.32456616f, 0.22247691f, -0.05255182f, -0.08179069f, 0.13518424f, 
    0.14747515f, 0.13843939f, 0.21542579f, 0.13034192f, -0.04870569f, -0.15299205f, 0.12416039f, 0.08442464f, 
    -0.13228762f, 0.20712316f, -0.23621707f, -0.01002120f, -0.03922438f, -0.25437009f, 0.39907610f, 0.34732673f, 
    0.10610757f, -0.01770563f, -0.09298672f, 0.13254657f, -0.17121252f, 0.03831087f, 0.27929774f, -0.07384481f, 
    0.22896641f, -0.08406208f, -0.06395704f, -0.10763870f, 0.21020606f, -0.29131159f, -0.03218866f, 0.25865299f, 
    0.02838859f, -0.13959886f, -0.07958641f, -0.07665396f, 0.09043182f, 0.08604585f, -0.06482461f, -0.01216620f, 
    0.02487732f, -0.08500314f, 0.08958890f, -0.05159936f, 0.09704615f, -0.07054181f, -0.13301638f, 0.05167936f, 
    -0.00929448f, -0.06860678f, -0.04656280f, -0.03399979f, 0.05926946f, -0.04031342f, -0.04112385f, -0.09141719f, 
    -0.11958951f, 0.03919173f, 0.12243588f, 0.06490251f, -0.03156906f, 0.11838892f, -0.12963891f, -0.13552566f, 
    0.09166160f, 0.08605351f, -0.01088555f, -0.13356316f, -0.11947106f, 0.00164444f, -0.02475365f, -0.01082470f, 
    -0.07984364f, 0.08714630f, -0.10586218f, 0.08653134f, -0.03543397f, -0.00100077f, 0.02658709f, -0.12490432f, 
    -0.01731371f, -0.05425799f, 0.03540461f, 0.06522033f, -0.10604308f, 0.05963674f, -0.09454587f, -0.12265542f, 
    -0.03322914f, -0.00948774f, -0.07323980f, 0.03858888f, -0.06703123f, -0.07539831f, -0.11682695f, 0.07103540f, 
    -0.21732293f, 0.15704647f, -0.15419401f, -0.20622879f, 0.03205127f, 0.04695274f, -0.32541618f, 0.05653302f, 
    0.27191395f, 0.07089299f, 0.27307546f, 0.15006249f, 0.06826035f, 0.14396575f, -0.24165806f, -0.08458095f, 
    -0.25815597f, 0.33831486f, 0.12446381f, 0.00009329f, -0.12700379f, 0.29253834f, -0.47158220f, -0.17005022f, 
    0.03783406f, -0.25253966f, -0.24919462f, -0.28012651f, 0.22921085f, -0.03562455f, 0.14697836f, 0.43685219f, 
    -0.27485719f, 0.18369231f, -0.13206328f, -0.08380213f, -0.21101640f, -0.22563332f, -0.10755543f, -0.16776882f, 
    0.07776850f, -0.14763789f, -0.13026540f, -0.00125098f, -0.30355760f, -0.22279589f, 0.23394570f, -0.50107706f, 
    0.10879423f, 0.18447179f, 0.12262574f, -0.26954091f, -0.06113295f, 0.25786245f, 0.20686589f, -0.27467641f, 
    0.04155688f, -0.14784931f, 0.05182093f, -0.11746112f, 0.18253754f, 0.51533014f, 0.10843515f, 0.34788403f, 
    0.09110268f, -0.03586068f, 0.06301867f, 0.12089442f, 0.27130133f, -0.00979759f, 0.20539403f, 0.11985164f, 
    0.14993247f, 0.21309409f, 0.13593936f, 0.11758410f, -0.08995304f, -0.41509253f, -0.17503226f, 0.04616411f, 
    -0.14763431f, 0.26603878f, 0.13850491f, 0.01326370f, -0.31318605f, 0.48943523f, -0.15454513f, -0.12477465f, 
    0.03308909f, -0.21099679f, -0.07865998f, 0.14924486f, -0.17742698f, 0.04248076f, 0.13596901f, 0.23270534f, 
    -0.25068381f, -0.07582142f, 0.17075959f, -0.23965532f, 0.20765366f, 0.16663492f, 0.26130697f, 0.32579529f, 
    0.05623572f, -0.33771548f, -0.21790388f, -0.24625358f, 0.20722875f, -0.05229245f, 0.26470384f, -0.19175927f, 
    -0.03911571f, 0.12667079f, 0.06631160f, 0.02714748f, -0.03268484f, 0.12185973f, 0.06325076f, -0.19824760f, 
    -0.10623120f, -0.11917458f, -0.16503301f, -0.21866344f, -0.20259742f, 0.06514131f, 0.22320022f, -0.14125587f, 
    0.28623682f, -0.05997763f, 0.15530595f, 0.04933941f, -0.02301038f, 0.13304672f, -0.27444139f, 0.26970398f, 
    0.06587467f, -0.11148494f, 0.36450917f, 0.13425255f, 0.02297202f, -0.09911609f, 0.20138396f, -0.05287900f, 
    -0.02352333f, 0.34441790f, 0.35238075f, 0.18565533f, 0.11914615f, 0.00578958f, -0.91605037f, 0.00283961f, 
    -0.04705298f, 0.02773922f, -0.07721321f, -0.13527496f, 0.05969192f, -0.05851672f, 0.05846936f, 0.25168622f, 
    -0.06228944f, 0.28504506f, -0.22514039f, -0.00291621f, 0.05697498f, -0.15378247f, -0.15735886f, 0.14979364f, 
    -0.06192384f, 0.19322158f, -0.10325488f, 0.09161001f, -0.78856069f, 0.45876613f, 0.08804572f, -0.01495363f, 
    0.08527388f, 0.24638267f, 0.01806968f, 0.19988517f, 0.22404648f, 0.12784189f, 0.37782261f, 0.06498826f, 
    0.14077896f, -0.07579710f, -0.10712482f, 0.11868054f, 0.06022783f, -0.19478524f, -0.28493491f, 0.25790790f, 
    -0.02987554f, -0.08096987f, 0.14550608f, 0.17675298f, 0.17205773f, 0.13398089f, 0.15179439f, 0.11344741f, 
    0.26915130f, 0.05505205f, 0.18191127f, 0.09958485f, -0.02922426f, -0.51796234f, -0.19233562f, 0.06806427f, 
    -0.10767306f, 0.09728691f, 0.24898899f, -0.15542787f, -0.22943342f, 0.46753815f, 0.13581292f, -0.21470855f, 
    -0.11839215f, -0.27842921f, -0.12848641f, 0.08716957f, -0.07025745f, 0.01104938f, 0.00345278f, 0.32616669f, 
    -0.43875679f, 0.30770496f, 0.12398754f, -0.16260219f, 0.05783803f, -0.00180492f, 0.24994707f, 0.76048803f, 
    -0.02650298f, -0.24480681f, -0.16997282f, -0.44188818f, 0.32855347f, -0.22590709f, 0.34600255f, 0.20436959f, 
    0.11190940f, 0.07196165f, 0.01015916f, 0.11791542f, -0.04019053f, -0.06374488f, 0.15739614f, -0.07853635f, 
    -0.08087606f, -0.27120474f, -0.19323030f, -0.11578323f, 0.07164169f, 0.24935107f, 0.02409709f, -0.04700405f, 
    -0.25789958f, 0.27887252f, -0.10610860f, -0.09870165f, -0.11626760f, -0.02175985f, 0.06951568f, 0.00344790f, 
    -0.01053923f, -0.02987452f, -0.30312473f, -0.13130997f, 0.03022690f, 0.56713891f, -0.09025004f, 0.11082987f, 
    0.19297077f, -0.07918993f, -0.03805585f, 0.22492184f, -0.02095354f, -0.18163347f, 0.33645117f, 0.30249146f, 
    0.00748701f, 0.37297419f, 0.34108329f, 0.31589207f, 0.01619959f, 0.07677911f, 0.25067112f, -0.21286908f, 
    0.04772038f, -0.01887023f, 0.00465746f, 0.11902737f, 0.20943858f, 0.05184804f, 0.02343575f, -0.61647105f, 
    0.35226589f, -0.05517524f, -0.00906990f, 0.25163406f, 0.24596474f, -0.00100193f, -0.25314674f, -0.24614429f, 
    -0.05341491f, 0.04662526f, 0.07974645f, 0.06848073f, 0.05747249f, 0.07020175f, -0.02018816f, -0.03419675f, 
    0.03067796f, 0.52633625f, 0.13415813f, 0.11957890f, 0.13499673f, -0.02608308f, 0.08392438f, 0.16600172f, 
    -0.60050970f, -0.37101498f, -0.15977466f, 0.13719507f, 0.16582367f, -0.00025058f, 0.12050966f, 0.22906691f, 
    0.11787163f, -0.30432937f, -0.00881110f, -0.04836164f, -0.00540215f, 0.13593516f, 0.11793614f, -0.05061652f, 
    0.10948879f, 0.12167810f, 0.21132000f, 0.07435510f, -0.04898876f, -0.18077081f, -0.27406034f, -0.07653024f, 
    -0.51012367f, 0.11671519f, -0.66415894f, -0.18713881f, -0.08928727f, 0.05747028f, -0.05448813f, -0.05869146f, 
    0.11670712f, 0.38536903f, 0.23133281f, 0.10113011f, -0.39191297f, 0.17659816f, 0.16796181f, 0.13232201f, 
    0.13647661f, -0.20717868f, 0.05667111f, 0.08873212f, 0.14331798f, -0.16238509f, 0.08602078f, 0.66352743f, 
    -0.09247958f, -0.33905089f, -0.09885174f, 0.02614688f, 0.00733982f, -0.14080186f, 0.25613058f, 0.21964283f, 
    -0.39845321f, -0.11748961f, -0.10481256f, 0.22707109f, 0.34802809f, 0.05095898f, -0.17445846f, -0.42310378f, 
    -0.30105442f, -0.09273826f, 0.04257184f, 0.08783782f, -0.32360205f, 0.01365699f, -0.07889374f, 0.07862299f, 
    0.06075051f, -0.10711340f, 0.02073431f, -0.20544748f, -0.09792853f, -0.12912324f, -0.16097625f, 0.02652080f, 
    0.15372194f, 0.20659681f, 0.15979744f, 0.29073557f, -0.02682423f, -0.22666512f, -0.35963875f, 0.19330513f, 
    -0.02087549f, 0.08410012f, -0.02614042f, -0.25597250f, -0.10143208f, 0.07450669f, 0.12647079f, 0.11939284f, 
    -0.12897103f, 0.18849097f, -0.10193130f, 0.10496219f, -0.06669835f, 0.06116540f, -0.10916974f, -0.01267661f, 
    0.08927204f, -0.07518350f, -0.23791991f, 0.13984838f, -0.69601566f, 0.25763634f, 0.13715638f, -0.70561546f, 
    -0.04304164f, 0.02748032f, 0.08340983f, 0.13484055f, 0.30494198f, 0.30572328f, 0.07306276f, 0.40592679f, 
    0.19300617f, 0.15543373f, -0.20247449f, -0.08081067f, -0.04973247f, 0.08990426f, -0.26533461f, 0.28163138f, 
    -0.04033309f, 0.04718303f, -0.13314164f, -0.23236433f, 0.12290934f, -0.01073592f, -0.11133385f, 0.16098090f, 
    0.06340079f, 0.04279095f, -0.04827587f, 0.13879724f, 0.00688782f, 0.83423853f, -0.06697030f, 0.02206403f, 
    0.07975072f, 0.09887192f, 0.00204558f, -0.00290492f, -0.11673433f, 0.09542326f, 0.17207842f, -0.05272213f, 
    0.19902751f, -0.11453422f, -0.04062971f, -0.11871412f, 0.18938348f, -0.08237655f, 0.02657553f, -0.13145061f, 
    0.10201852f, 0.06236392f, -0.22625299f, 0.18562008f, -0.07270733f, 0.05366752f, -0.13586241f, -0.42497775f, 
    0.14481393f, -0.21064921f, 0.12367590f, 0.17380129f, 0.05357881f, -0.28049168f, -0.05640895f, -0.35157806f, 
    -0.03639306f, 0.06347460f, -0.06209250f, -0.04679726f, -0.17211747f, 0.02808625f, 0.08181951f, -0.20737836f, 
    0.05230280f, 0.19482085f, 0.24315532f, 0.06890102f, 0.19551016f, 0.08679751f, 0.18195331f, 0.24813062f, 
    0.02299980f, -0.07031458f, -0.08865226f, 0.07205237f, -0.07100383f, -0.04923005f, 0.10436827f, 0.03500500f, 
    -0.12058180f, 0.03485034f, 0.00283372f, -0.01211711f, 0.10697351f, -0.11406969f, -0.06505647f, -0.11332773f, 
    0.05413682f, -0.04644502f, -0.05454729f, -0.14686921f, 0.03232006f, -0.10738055f, -0.04080094f, 0.03801825f, 
    0.05312505f, 0.01314003f, 0.00697560f, -0.09807108f, -0.12318802f, 0.08683184f, -0.07335873f, 0.03362700f, 
    0.02685401f, -0.08077892f, -0.06967814f, -0.04196130f, -0.02331347f, -0.14673342f, 0.01230422f, 0.05150021f, 
    0.03506574f, 0.10206633f, 0.02770702f, -0.04047189f, -0.11110385f, -0.10954129f, -0.08024027f, 0.09150214f, 
    0.03351214f, 0.02322023f, 0.08091353f, -0.08625024f, -0.09646215f, -0.12389904f, 0.06911999f, 0.02704626f, 
    0.01098142f, -0.02983140f, -0.11432217f, 0.05934422f, 0.09660694f, -0.08177495f, -0.08660738f, -0.12517551f, 
    -0.01417593f, 0.34521165f, 0.21360302f, -0.20329376f, 0.17513938f, -0.05201400f, -0.06192237f, 0.01192208f, 
    0.06767713f, -0.23053981f, 0.12802692f, 0.33981153f, 0.09335092f, -0.16444552f, -0.04629176f, -0.07357868f, 
    -0.39923432f, -0.18544503f, 0.02906005f, -0.07921787f, 0.30129132f, -0.50135332f, 0.08432809f, 0.05144586f, 
    0.14721681f, -0.26708212f, -0.15274988f, 0.03990635f, 0.13682927f, -0.09893469f, -0.12273375f, -0.02376727f, 
    -0.06968305f, -0.09493737f, -0.03208549f, 0.11714353f, 0.23921745f, 0.15981530f, 0.14448702f, -0.30897731f, 
    0.10862590f, -0.08746105f, -0.19706754f, 0.20713663f, 0.19882679f, -0.07134124f, 0.03027128f, 0.25248271f, 
    0.17451487f, -0.11014038f, -0.04452248f, -0.22474551f, -0.12378488f, -0.13373122f, 0.17708786f, -0.24254461f, 
    -0.11747533f, 0.19337815f, -0.13137552f, -0.40239471f, 0.17853048f, -0.36465406f, 0.33975792f, 0.12960555f, 
    -0.19779104f, 0.01094235f, 0.07690313f, 0.27175528f, 0.05458152f, -0.12568751f, -0.03451787f, -0.00963936f, 
    0.25865608f, 0.01506086f, 0.11964078f, 0.01277503f, -0.12445560f, 0.23165618f, 0.09211562f, 0.08780114f, 
    -0.25481394f, -0.06979027f, 0.10636601f, -0.08078220f, 0.08850994f, 0.11986066f, -0.35167778f, -0.30047566f, 
    0.15217432f, 0.07443251f, -0.21873486f, -0.03270892f, 0.05518532f, 0.04234042f, 0.06607112f, 0.15889589f, 
    0.19433573f, 0.19632269f, 0.05117108f, -0.26313549f, -0.44293770f, 0.06571244f, 0.11507203f, 0.06566697f, 
    0.03090471f, -0.36133546f, -0.02183330f, 0.15324065f, -0.19305675f, -0.64112467f, 0.29655626f, -0.31532413f, 
    -0.05598101f, 0.07172731f, 0.07960390f, 0.06425110f, -0.09881698f, 0.00854823f, 0.06701314f, 0.07062671f, 
    0.21028118f, -0.02045176f, 0.06423861f, 0.04846268f, 0.39693904f, -0.00692119f, -0.07436082f, 0.17647065f, 
    0.04653013f, -0.14479913f, -0.14325523f, -0.04396453f, -0.11579923f, -0.06225966f, 0.07722534f, 0.03461143f, 
    -0.00420286f, 0.03093630f, -0.10318709f, -0.02967629f, 0.07207426f, 0.00756864f, -0.08649144f, -0.00453316f, 
    0.05276413f, -0.13517359f, -0.11545415f, -0.14637469f, 0.07942019f, -0.12109497f, 0.07821693f, 0.08054740f, 
    -0.07526024f, -0.08074717f, 0.07855139f, 0.10354482f, 0.08221424f, 0.12309524f, -0.01920190f, -0.13162792f, 
    -0.01537642f, -0.08320163f, -0.02373687f, -0.11610875f, -0.09698854f, -0.12549505f, 0.07016592f, -0.13399601f, 
    -0.10516222f, -0.00492270f, 0.01854733f, -0.02342548f, -0.08252527f, -0.03057656f, 0.06399585f, -0.05111108f, 
    0.01859787f, -0.07916139f, 0.09875198f, -0.00065077f, -0.04368765f, 0.04427895f, 0.07324682f, 0.07926316f, 
    0.05437500f, -0.01414794f, -0.01463699f, -0.08299044f, 0.07995271f, -0.08177838f, -0.13309549f, 0.03284163f, 
    0.73594588f, 0.12395006f, 0.33676729f, 0.12896445f, 0.24129333f, 0.03544875f, 0.33092928f, 0.12886262f, 
    0.09674276f, -0.02583709f, 0.00673880f, 0.24439323f, 0.06447119f, -0.78860074f, -0.05698818f, 0.02246268f, 
    -0.34809789f, -0.01828205f, 0.17458528f, 0.06267870f, 0.25509259f, -0.60168159f, 0.42940766f, 0.06173327f, 
    0.15266751f, 0.08073539f, -0.23368172f, 0.30601165f, 0.28464770f, 0.13299003f, -0.21754643f, -0.16498323f, 
    -0.13690415f, 0.24364802f, 0.27304572f, 0.10327180f, 0.12169972f, -0.20070486f, 0.03933835f, 0.61040789f, 
    -0.18303385f, 0.47821629f, -0.35203290f, -0.05201726f, 0.00994487f, -0.28039426f, 0.18527405f, 0.80263293f, 
    0.27527526f, -0.22664154f, -0.06472323f, 0.17456242f, 0.06844894f, -0.03160796f, 0.07080589f, 0.04024547f, 
    0.11614209f, -0.27554035f, -0.43694943f, -0.03889235f, 0.25371304f, -0.41190481f, -0.35822076f, 0.05721318f, 
    0.06213493f, -0.27872166f, 0.01583531f, 0.26151550f, -0.15379053f, -0.20694870f, 0.13311675f, -0.00255747f, 
    -0.00371735f, -0.11177924f, -0.01276695f, -0.15005487f, 0.04053258f, 0.09917521f, -0.09498905f, 0.11692502f, 
    0.05390719f, 0.02349517f, -0.18572268f, 0.01967582f, -0.22610469f, -0.16558793f, 0.45189151f, -0.16477562f, 
    -0.42898199f, 0.20236914f, 0.06392160f, 0.18971051f, -0.41260421f, 0.11618080f, 0.14290364f, 0.23895758f, 
    -0.09772943f, -0.01359343f, 0.22617459f, -0.17268470f, -0.13339028f, 0.06096809f, 0.22007947f, 0.37382591f, 
    0.07788249f, 0.30777681f, 0.18359601f, 0.00611599f, 0.29131120f, -0.21432628f, 0.27970907f, 0.04879311f, 
    -0.10978640f, -0.04717287f, -0.12209517f, 0.07682769f, -0.01781764f, 0.19339871f, -0.13410273f, 0.07635450f, 
    -0.51210737f, -0.07056519f, 0.02543834f, 0.05726788f, 0.15595818f, 0.05132762f, -0.06476094f, -0.47138107f, 
    0.81104147f, -0.11695363f, -0.33546820f, 0.08407596f, -0.00891811f, 0.08116171f, 0.25049308f, -0.16246244f, 
    -0.11583860f, 0.19982149f, -0.31804237f, -0.14119741f, -0.04978181f, 0.39534739f, -0.31130639f, 0.07689466f, 
    0.04976671f, 0.15560806f, -0.10134570f, 0.06250137f, -0.14589252f, 0.06517293f, 0.76183653f, 0.05050709f, 
    -0.01919249f, 0.26899111f, 0.21843094f, 0.35235518f, -0.14902078f, -0.09571841f, 0.11428158f, 0.16068020f, 
    -0.63419551f, -0.03766000f, 0.14488679f, -0.09044256f, 0.07471736f, 0.17850070f, -0.01133716f, 0.11321928f, 
    0.08482492f, 0.43522432f, -0.03858525f, 0.04612057f, 0.80209953f, -0.43880183f, -0.18576549f, -0.56356680f, 
    -0.03144543f, -0.01145268f, 0.10298671f, 0.02198161f, 0.14152758f, -0.18735142f, -0.24027239f, -0.13152376f, 
    -0.54586369f, 0.25355706f, 0.03145876f, -0.10434195f, -0.02927337f, 0.20341568f, 0.17631090f, -0.19990526f, 
    -0.22744922f, 0.00469678f, -0.24074413f, -0.31294540f, 0.14034605f, 0.03458756f, 0.27059472f, 0.02105640f, 
    0.05731101f, 0.40527105f, -0.58192021f, 0.01072466f, -0.05879292f, 0.20270108f, -0.52122569f, 0.06038254f, 
    0.11739345f, -0.10173874f, 0.00653757f, 0.13040914f, 0.12572972f, -0.25480410f, 0.94406128f, 0.09676521f, 
    0.13907173f, 0.29617757f, 0.10338470f, 0.43543598f, -0.12084147f, 0.08346894f, 0.09422735f, 0.00033176f, 
    -0.05356932f, 0.11879944f, 0.02065400f, 0.12741819f, 0.68359113f, 0.18421566f, 0.19426472f, -0.34555396f, 
    0.20711571f, 0.20597397f, -0.37616411f, 0.16713583f, 0.75611538f, -0.62575573f, -0.20020875f, 0.08042727f, 
    0.13177812f, -0.24089049f, 0.00885659f, -0.10566023f, 0.17898476f, -0.32220784f, 0.01919451f, -0.58593160f, 
    0.17284508f, 0.56536186f, 0.28026456f, -0.42172360f, 0.20489161f, 0.11644207f, 0.13080339f, 0.07226793f, 
    -0.31473947f, -0.07077816f, -0.26866975f, 0.27025035f, -0.19080831f, 0.10652705f, 0.17788127f, -0.14582789f, 
    -0.10312739f, 0.19382466f, -0.15087211f, -0.11051278f, 0.10640241f, 0.31134599f, -0.24794096f, 0.05221212f, 
    0.21419521f, 0.27714747f, 0.04284392f, 0.30784842f, -0.11027884f, -0.14939275f, 0.05131258f, 0.14772554f, 
    -0.08271110f, 0.35843313f, 0.28050846f, 0.19524381f, -0.01626020f, 0.14519164f, 0.22593838f, 0.20935901f, 
    0.07402962f, -0.02826939f, 0.20035157f, 0.04300577f, -0.09604371f, 0.04948318f, 0.11994267f, -0.42128208f, 
    0.05770607f, -0.25982440f, -0.18818003f, 0.24303953f, -0.16110033f, -0.21180758f, 0.02408135f, -0.87914836f, 
    -0.13002266f, -0.07669108f, -0.08073916f, 0.28894389f, 0.17617001f, 0.35472706f, -0.10979023f, 0.08476499f, 
    0.16651715f, 0.24284258f, 0.32736689f, 0.03493007f, -0.05397944f, -0.24376231f, -0.08027659f, 0.23824440f, 
    0.27077872f, -0.14091922f, -0.14902993f, 0.06616922f, 0.24766001f, -0.03871011f, -0.09422214f, 0.00586668f, 
    -0.04287518f, -0.21839789f, -0.10982487f, 0.03970957f, 0.01580433f, -0.28512126f, 0.09124304f, -0.08767106f, 
    0.07252633f, 0.14337958f, 0.14060548f, -0.00461063f, 0.01478631f, -0.18859625f, 0.23496518f, 0.23846677f, 
    -0.05530679f, -0.17041844f, -0.40250614f, 0.13107914f, -0.05962903f, -0.09859396f, -0.11711327f, 0.14180587f, 
    -0.52491134f, 0.23546018f, 0.21864481f, 0.01773340f, 0.36793649f, 0.00347178f, 0.11629299f, 0.10189312f, 
    0.02171500f, -0.00949736f, 0.07921261f, -0.28072897f, 0.51080853f, -0.16961940f, 0.02120974f, 0.13707516f, 
    0.11517461f, -0.13759671f, 0.01793517f, 0.09534419f, 0.33257309f, -0.27485380f, -0.04516726f, -0.20485035f, 
    -0.30643645f, 0.15290575f, 0.09913713f, -0.18263389f, -0.10254820f, 0.17861520f, -0.01176723f, -0.14152381f, 
    0.03840809f, -0.03470783f, -0.04594226f, -0.14319661f, 0.00545048f, -0.09399791f, -0.06830554f, -0.00577548f, 
    -0.07204089f, 0.09318404f, 0.02687946f, 0.04703169f, 0.10309407f, -0.02364520f, 0.00519909f, -0.08688073f, 
    0.01695791f, 0.02226116f, -0.02195422f, 0.01669682f, -0.08283731f, 0.00740594f, -0.05123077f, -0.04976314f, 
    -0.02736305f, -0.01603272f, -0.05015084f, 0.09135028f, -0.08354141f, -0.06938429f, 0.02978054f, -0.03300432f, 
    0.08500047f, -0.02691405f, 0.01810348f, -0.11699025f, -0.05016004f, 0.03904873f, 0.05601507f, -0.08963441f, 
    0.06814859f, -0.03175001f, -0.05339432f, -0.05714991f, -0.07834508f, 0.02430774f, -0.04126456f, -0.03026666f, 
    0.02440978f, -0.02120558f, 0.06618771f, -0.13163532f, -0.07233440f, -0.13708825f, 0.02643373f, -0.02295429f, 
    -0.12393025f, -0.13470684f, -0.00984749f, 0.07598733f, 0.08447204f, 0.08122911f, -0.13845818f, -0.12646689f, 
    -0.07841279f, -0.18007515f, -0.21335754f, 0.22692831f, 0.45250463f, -0.04105488f, -0.14220148f, 0.04479392f, 
    0.01392926f, -0.22750770f, 0.12445258f, 0.29513010f, -0.10756980f, -0.03757926f, 0.03901273f, -0.07212768f, 
    -0.20340756f, 0.32060632f, 0.11952113f, 0.13022044f, -0.04613152f, -0.09597919f, -0.42700881f, 0.02988224f, 
    0.10137827f, -0.26496714f, -0.39399946f, 0.17724487f, -0.00182613f, 0.07334381f, 0.07116346f, 0.14121890f, 
    0.07078347f, 0.25495812f, 0.21902446f, -0.16769059f, 0.00675682f, -0.00187458f, 0.15196314f, -0.18489720f, 
    -0.11168214f, -0.25221550f, -0.34223843f, 0.02205822f, 0.13180283f, -0.39239118f, -0.04957977f, -0.26428044f, 
    0.00009039f, 0.04334357f, 0.09120653f, 0.29343364f, 0.18482685f, -0.09571449f, -0.13294591f, -0.14086038f, 
    -0.22300027f, 0.14454800f, 0.09478743f, -0.09368922f, -0.05065900f, -0.22870980f, 0.07177375f, 0.15327759f, 
    -0.02726418f, 0.06750846f, 0.06533374f, 0.10009398f, 0.00254230f, 0.05693193f, 0.02198741f, 0.04360912f, 
    0.05255736f, -0.06242316f, 0.04178951f, -0.06774843f, 0.07024053f, -0.04121476f, -0.15119244f, 0.12362142f, 
    0.05213179f, -0.05226290f, 0.00374597f, -0.08250823f, -0.12487455f, 0.08127443f, 0.10190507f, -0.14846496f, 
    -0.13268492f, 0.04881289f, 0.03879721f, -0.08233631f, -0.07509045f, 0.03971083f, -0.05930228f, -0.10752994f, 
    0.05547866f, -0.00091384f, -0.05202896f, 0.03697316f, -0.06398823f, -0.03243734f, -0.02299986f, -0.07880115f, 
    -0.07990102f, -0.07863642f, -0.08314435f, 0.03841031f, 0.03491401f, 0.10022900f, -0.13947488f, -0.00122349f, 
    -0.09563676f, -0.11804797f, 0.11427703f, -0.03531384f, -0.01795902f, -0.10811978f, 0.06910120f, 0.02319492f, 
    -0.07396152f, -0.05951416f, -0.03014006f, 0.02797602f, -0.00982382f, 0.00916480f, -0.03524503f, -0.04091591f, 
    0.03503756f, 0.23139279f, 0.36819056f, -0.00201838f, -0.02410929f, 0.00904592f, 0.38010365f, 0.08489949f, 
    0.12973990f, 0.47269437f, 0.02382229f, 0.06735851f, 0.05007830f, -0.57019192f, 0.00645066f, -0.05602305f, 
    0.00950710f, -0.20401877f, 0.05722940f, -0.18205896f, 0.01572905f, -0.25325519f, 0.87855673f, 0.07508428f, 
    -0.07433131f, 0.22231701f, 0.29083991f, 0.53342927f, -0.24126068f, 0.07502127f, -0.15820269f, 0.02349566f, 
    0.07683160f, -0.00884101f, 0.18634009f, 0.03690125f, 0.65200704f, 0.28821647f, 0.32112455f, 0.58377343f, 
    0.03597151f, 0.00151359f, -0.48907191f, 0.17672244f, 0.26058084f, 0.17538576f, -0.17929512f, 0.38546008f, 
    0.04837786f, 0.04531549f, 0.00387086f, 0.02729925f, 0.03803508f, -0.04717230f, 0.33423707f, 0.19415344f, 
    -0.06480462f, -0.00168552f, -0.51869398f, -0.26088279f, -0.14507316f, -0.40583578f, 0.04164023f, -0.14574941f, 
    0.03600081f, -0.19839542f, -0.15992375f, -0.09644239f, -0.04081412f, -0.11048417f, 0.11331066f, 0.12752686f, 
    -0.21139427f, 0.01351345f, -0.07717990f, 0.15097493f, -0.11632277f, 0.18106869f, -0.03172047f, -0.12264672f, 
    -0.05249434f, 0.05188607f, 0.10719682f, -0.11209773f, 0.16015323f, -0.15886445f, 0.03375940f, 0.03497235f, 
    -0.26365528f, -0.24088944f, -0.04503302f, -0.14622119f, 0.25883788f, -0.11300839f, 0.00859946f, -0.40818396f, 
    0.16149914f, -0.24964334f, -0.14339417f, 0.14127100f, -0.04029130f, -0.24299207f, -0.30525535f, 0.10508373f, 
    0.21803027f, 0.05441722f, 0.17098032f, -0.21673092f, 0.51342195f, 0.08855173f, -0.03533303f, 0.00840934f, 
    -0.20682459f, -0.30783418f, -0.03774635f, -0.02539486f, -0.40760550f, 0.09181000f, -0.22875351f, -0.30712602f, 
    0.01433889f, -0.15472586f, 0.18256941f, 0.07102234f, 0.14028214f, 0.05134113f, 0.13432220f, -0.29439548f, 
    -0.30536181f, 0.23187593f, 0.16300187f, 0.17408384f, -0.61466563f, 0.05435048f, -0.06151728f, -0.20259528f, 
    0.30062300f, 0.44194442f, -0.10100187f, 0.01487873f, 0.09631255f, 0.11207465f, -0.32452038f, -0.03502496f, 
    0.12214840f, -0.13998343f, -0.07442908f, 0.12509291f, -0.21499899f, 0.50604171f, 0.29126096f, -0.34432787f, 
    -0.10369410f, 0.18312140f, 0.30303976f, 0.05053972f, -0.03883425f, 0.02161925f, 0.14253335f, 0.34501800f, 
    0.20336670f, 0.04027241f, -0.17761390f, -0.09076043f, -0.14021079f, -0.06211735f, 0.09161101f, 0.45678246f, 
    0.24835055f, -0.29635677f, -0.21412376f, 0.31769285f, 0.01939698f, 0.20880398f, 0.32333151f, -0.47659063f, 
    -0.24941655f, -0.01455260f, -0.06014937f, -0.00821085f, -0.15516828f, 0.39372316f, 0.47568220f, 0.35753146f, 
    0.33570111f, -0.06394675f, 0.06108649f, -0.25373450f, 0.23457663f, -0.12921113f, 0.09600358f, 0.18810239f, 
    0.08165653f, 0.29220173f, 0.15376993f, -0.42994249f, 0.11224511f, -0.11836600f, -0.19164111f, 0.03009192f, 
    0.06858882f, -0.07582118f, -0.04948378f, 0.39752173f, -0.10111200f, -0.18891209f, -0.26957500f, 0.02555330f, 
    -0.34075555f, -0.15407117f, 0.10430479f, -0.13289019f, 0.29131365f, -0.12044860f, -0.05378072f, 0.09666053f, 
    0.46232626f, -0.03574080f, -0.23473535f, 0.06881035f, 0.28396678f, 0.09922113f, -0.18046108f, -0.07735651f, 
    -0.18272839f, 0.16500787f, -0.10496401f, 0.20023824f, 0.17208050f, -0.16560654f, 0.01749942f, -0.31392840f, 
    0.11490808f, -0.05440335f, -0.29354900f, 0.16967072f, 0.23377202f, -0.21994027f, 0.14513780f, 0.21817204f, 
    0.19051443f, 0.00522731f, -0.09433361f, -0.18148635f, 0.01460158f, -0.01527238f, -0.05860908f, -0.59387004f, 
    0.05554006f, 0.16774307f, 0.04015072f, -0.32118148f, 0.35053587f, -0.06533882f, 0.43776867f, 0.30232814f, 
    -0.05172694f, -0.09983902f, 0.10076102f, 0.05641551f, -0.06962875f, 0.04658379f, 0.11724406f, 0.06879309f, 
    -0.12476998f, -0.11021945f, -0.02913517f, -0.03154774f, -0.09464876f, -0.06292784f, -0.07827453f, 0.07487820f, 
    0.09588310f, 0.09493648f, -0.03170659f, -0.13823064f, -0.03850203f, 0.03094521f, 0.09183613f, 0.08332000f, 
    -0.06459741f, 0.00466187f, -0.00492484f, -0.05632069f, -0.04298370f, -0.04966114f, -0.06055812f, -0.09137683f, 
    -0.12341993f, 0.04210263f, 0.08060188f, -0.09762815f, 0.08177483f, 0.00552656f, 0.06022249f, -0.09523547f, 
    0.08758646f, -0.05986771f, 0.05027445f, -0.02506959f, -0.14475983f, -0.03251320f, 0.05301130f, 0.00884226f, 
    -0.00951708f, -0.06749717f, -0.12336595f, -0.07140119f, 0.02877120f, -0.01809315f, -0.11089669f, -0.09856628f, 
    -0.01098034f, -0.06783944f, -0.13334386f, -0.11239006f, -0.10545962f, -0.03507590f, -0.05682392f, 0.07654383f, 
    0.50705856f, 0.23058529f, 0.36224604f, 0.18694265f, -0.17877223f, 0.00028200f, -0.42127967f, -0.05730635f, 
    0.20293771f, 0.04033979f, 0.17261750f, 0.34402671f, -0.04213569f, 0.11768702f, 0.13925254f, 0.08491489f, 
    -0.10322583f, -0.04046425f, 0.00944993f, -0.28746378f, 0.21440420f, 0.30253655f, -0.20080531f, -0.02156863f, 
    0.09165869f, -0.13542877f, 0.15586527f, 0.08458517f, 0.11497006f, -0.09231196f, -0.12250990f, 0.12129568f, 
    0.13362999f, -0.15969223f, 0.05953173f, -0.14734937f, -0.15314583f, -0.03162392f, 0.03596834f, 0.39739713f, 
    0.01594369f, 0.30925882f, -0.10334887f, 0.02704307f, -0.26018924f, 0.35341001f, 0.16977900f, 0.40489373f, 
    -0.08649788f, 0.16886955f, 0.00331150f, 0.04857401f, -0.28243950f, 0.28514096f, 0.37205231f, -0.14008802f, 
    0.13906632f, -0.36970627f, -0.01582601f, -0.14688855f, 0.07194867f, -0.04991985f, 0.04467997f, -0.01175842f, 
    -0.48350790f, 0.09354804f, -0.07444767f, 0.15550506f, -0.62299967f, -0.07820334f, 0.01410734f, -0.27085692f, 
    0.11748677f, 0.04843759f, -0.04283103f, -0.03024818f, -0.12224407f, 0.54594231f, -0.24035950f, -0.06391380f, 
    0.17090681f, 0.15196362f, -0.10068360f, 0.20964231f, -0.12938283f, -0.02328140f, -0.32407087f, -0.12891217f, 
    -0.07237549f, 0.10311765f, 0.47762421f, -0.11566411f, 0.11587796f, 0.05564003f, 0.18205884f, 0.14375971f, 
    0.31452450f, 0.14210300f, -0.09310713f, 0.08780010f, -0.31187129f, -0.19520447f, -0.07414475f, -0.17207980f, 
    0.32159758f, -0.27338478f, -0.20148933f, 0.55478370f, -0.58979613f, 0.08707090f, -0.00852337f, -0.77870488f, 
    -0.15351388f, 0.13179611f, 0.09898034f, 0.02207904f, -0.05645968f, 0.24375679f, -0.03900315f, 0.40113443f, 
    0.29850146f, 0.04015182f, -0.05438071f, 0.05958938f, 0.01489751f, -0.47559565f, -0.21303403f, 0.31585822f, 
    -0.33313119f, -0.26221749f, -0.78687656f, 0.20207742f, 0.02622014f, -0.06561780f, -0.00477549f, -0.09225173f, 
    0.05909560f, -0.15428467f, -0.00926980f, -0.05280434f, 0.02324607f, 0.58994168f, -0.20530103f, -0.09609966f, 
    0.09368341f, 0.21106249f, 0.04320814f, 0.08660904f, -0.62952828f, 0.03859005f, -0.14658141f, -0.18151909f, 
    -0.32260075f, 0.22245549f, -0.44619119f, 0.15986255f, 0.06596689f, 0.00033535f, -0.00676670f, 0.03533634f, 
    0.02725078f, -0.01651524f, 0.14986758f, -0.17904228f, -0.36972600f, 0.06057725f, 0.00159010f, 0.13598292f, 
    0.16542174f, -0.01828115f, -0.00444303f, 0.16920830f, 0.45404956f, -0.37121657f, -0.01938424f, 0.15128642f, 
    -0.38728592f, -0.18503188f, -0.07950562f, 0.13173866f, 0.03116997f, -0.54239833f, -0.05884282f, 0.06791017f, 
    -0.37020460f, -0.06862666f, 0.13945930f, 0.14381631f, 0.22508146f, -0.21415472f, 0.06080128f, -0.14152005f, 
    0.00042378f, -0.00350202f, 0.00076031f, 0.13231134f, 0.11348133f, 0.03609371f, 0.07465046f, 0.31075019f, 
    0.19461438f, 0.03124256f, 0.17691922f, -0.04327426f, 0.15194170f, -0.73622978f, 0.06800256f, 0.05608945f, 
    0.09867302f, 0.21160364f, 0.14139439f, 0.10871361f, -0.17743699f, 0.03198533f, -0.19266319f, 0.09796141f, 
    0.01243304f, -0.12658265f, -0.32123256f, 0.12264404f, -0.24205668f, 0.07338955f, -0.06694653f, 0.21868810f, 
    0.02723519f, 0.37967876f, 0.07091355f, 0.02576579f, 0.22715975f, 0.24743839f, 0.09551912f, 0.33285353f, 
    -0.18208852f, -0.12704158f, -0.07285620f, 0.08005504f, -0.40938255f, -0.09977939f, 0.10131718f, -0.10190027f, 
    0.04860691f, 0.12800902f, 0.10930341f, 0.03445619f, 0.32288864f, -0.06625596f, 0.10107979f, 0.11433748f, 
    -0.08891612f, 0.07220636f, -0.20810972f, -0.02909602f, -0.14841241f, -0.08187494f, -0.24959289f, -0.07292773f, 
    -0.02218936f, 0.07532243f, 0.00352195f, 0.03819554f, 0.18390498f, -0.03541855f, 0.26295945f, -0.12594569f, 
    0.19460216f, 0.71399450f, -0.06821276f, 0.03513727f, -0.05332882f, -0.04705267f, 0.01627167f, 0.07652086f, 
    -0.02797399f, -0.35288739f, -0.20733732f, -0.06560636f, 0.09407561f, 0.38916582f, 0.84939957f, -0.09227467f, 
    0.02105667f, 0.18030819f, 0.55553550f, 0.62700182f, -0.17426784f, 0.00749946f, 0.23062976f, 0.06477846f, 
    0.09748492f, -0.30945596f, 0.06017252f, -0.32189682f, 0.39862874f, 0.22723714f, 0.45105565f, 0.09839384f, 
    0.10721625f, -0.67191648f, 0.02330595f, 0.36453867f, 0.42632300f, 0.07816593f, -0.25772151f, -0.03062439f, 
    0.03951870f, 0.42924836f, -0.04995114f, 0.01941658f, -0.20767425f, 0.22949201f, 0.16999812f, 0.00714923f, 
    -0.07141706f, 0.22870487f, 0.16149302f, -0.20279621f, -0.00244530f, 0.02335833f, 0.05826793f, -0.05292286f, 
    -0.26230839f, 0.18871871f, -0.03304614f, -0.25171503f, 0.32795513f, 0.10723129f, 0.20101911f, 0.03307918f, 
    0.13406186f, 0.53846616f, -0.26342249f, 0.08811070f, 0.13681196f, 0.72695863f, -0.28827801f, -0.10063130f, 
    -0.16300932f, 0.01511366f, -0.00634263f, 0.20577256f, -0.02181794f, 0.34684837f, -0.49402624f, -0.06964860f, 
    -0.02253929f, -0.20048432f, 0.18645293f, -0.15053482f, 0.09437855f, 0.07282071f, 0.35899791f, 0.15433758f, 
    0.52960122f, -0.01849063f, -0.17891219f, 0.03476575f, 0.29586318f, 0.11857916f, 0.14796126f, -0.43146178f, 
    0.31713843f, -0.28875867f, -0.20070550f, 0.38923779f, 0.02898257f, -0.27477312f, -0.06756688f, -0.16009605f, 
    -0.08244822f, 0.28213513f, 0.00408982f, -0.14064418f, -0.10447741f, -0.14810340f, 0.15557800f, -0.31137568f, 
    0.00624783f, 0.33574226f, 0.30037168f, 0.06761301f, 0.18242724f, -0.10983025f, 0.16484830f, 0.20831881f, 
    0.31975403f, -0.35876849f, -0.27211350f, 0.20433144f, 0.17478023f, 0.13659538f, -0.07999855f, -0.07468481f, 
    -0.04694752f, -0.41446736f, -0.06125572f, 0.08921865f, -0.02555437f, 0.55805212f, -0.03308368f, 0.06613706f, 
    -0.04983598f, 0.30094346f, 0.10198125f, 0.04007488f, -0.37551150f, -0.09618305f, -0.22339047f, -0.21824880f, 
    -0.17128378f, -0.00454322f, -0.17118691f, -0.05262627f, 0.26110795f, 0.03557939f, -0.22588147f, -0.09703249f, 
    0.17894502f, -0.04922330f, 0.08460431f, -0.24905179f, -0.24969685f, 0.06250252f, 0.10379983f, 0.30026683f, 
    -0.07246314f, 0.47538522f, -0.10552081f, -0.02969304f, 0.15003277f, -0.24384850f, -0.14225639f, 0.18379794f, 
    -0.06026670f, -0.33081040f, 0.10846905f, 0.20323884f, -0.17833078f, -0.11082374f, -0.06918884f, -0.26791874f, 
    0.20507485f, -0.19082789f, 0.12427322f, 0.19069447f, 0.13145265f, -0.28593993f, 0.04341368f, -0.30994064f, 
    -0.09529892f, -0.09558145f, -0.05754225f, -0.07790998f, -0.05572005f, 0.08333760f, -0.05589750f, 0.01146968f, 
    -0.13251260f, 0.07578443f, 0.07757887f, -0.01888103f, 0.09385084f, -0.08706260f, 0.06773233f, -0.02486280f, 
    0.00440122f, -0.10012399f, -0.00832113f, -0.12424899f, -0.11515686f, -0.10723856f, -0.07583994f, -0.13281369f, 
    0.03710098f, -0.03093650f, 0.04191780f, 0.04888689f, 0.01808453f, 0.08417568f, 0.08373480f, -0.09555680f, 
    -0.10802221f, -0.13261352f, -0.10172023f, -0.05250447f, 0.05175712f, 0.08106396f, -0.11853413f, -0.11724612f, 
    -0.10775368f, -0.10427713f, -0.01559030f, 0.09047153f, -0.10889985f, 0.10165519f, -0.05394495f, -0.09218514f, 
    -0.13221948f, -0.17762932f, -0.04186228f, -0.02337288f, -0.18177475f, -0.08416160f, -0.07779959f, 0.01730661f, 
    0.07919212f, -0.02257405f, -0.10103864f, 0.05135085f, 0.00771989f, -0.07106640f, -0.02295808f, -0.13880128f, 
    -0.01457061f, 0.01527695f, -0.10162475f, -0.06594361f, -0.15151399f, -0.01742198f, 0.02149385f, -0.12934032f, 
    -0.06721780f, -0.13067107f, -0.12347466f, -0.09451830f, -0.08992262f, -0.13423887f, -0.08174736f, 0.04952441f, 
    -0.15248418f, -0.03307612f, -0.13327467f, -0.06032052f, -0.00946184f, -0.05833454f, -0.02192848f, -0.12041456f, 
    -0.05540008f, 0.06076688f, -0.08396893f, -0.10472227f, 0.01304672f, 0.04962611f, -0.05161006f, 0.03127411f, 
    0.11762730f, -0.06958227f, 0.02668392f, -0.04327431f, -0.01321755f, -0.11246204f, -0.07269594f, -0.04586149f, 
    0.03942154f, 0.03468749f, 0.01911462f, -0.12228652f, -0.12449513f, -0.06312528f, -0.12821715f, -0.08247051f, 
    0.06162090f, -0.10489205f, 0.05187388f, 0.03902283f, -0.07438277f, -0.08420473f, -0.03141119f, 0.06569218f, 
    0.05685201f, -0.00385414f, -0.04795551f, 0.01932987f, -0.04579653f, 0.02568265f, 0.03580408f, -0.16184397f, 
    0.00584649f, -0.11699025f, -0.23923980f, 0.13167442f, 0.36837888f, -0.04502703f, -0.05977537f, 0.45642671f, 
    -0.16314566f, 0.03021390f, -0.15899952f, -0.05752445f, 0.03552588f, 0.48827940f, -0.09261902f, 0.06956439f, 
    0.05746647f, 0.28315011f, 0.39391145f, -0.03993116f, -0.32239527f, 0.27779752f, -0.18572719f, 0.16914460f, 
    -0.18222165f, -0.00569670f, -0.05782176f, 0.21206209f, -0.04680130f, 0.17221110f, 0.01971777f, 0.02917136f, 
    -0.08092419f, 0.23497553f, 0.05484215f, 0.00688088f, 0.11584257f, 0.19301991f, -0.05448398f, -0.01449279f, 
    -0.17958830f, -0.46020100f, -0.26381320f, 0.04535461f, 0.28921473f, -0.47761750f, -0.32577518f, 0.12500156f, 
    0.23489755f, 0.29447296f, -0.01462430f, 0.09813327f, 0.25177765f, -0.06693199f, -0.06916133f, -0.25887510f, 
    -0.65746611f, 0.10787757f, 0.10865186f, 0.03000843f, 0.04540020f, -0.18013403f, -0.08559403f, -0.50210953f, 
    -0.32718658f, 0.12298372f, 0.01297227f, -0.02862952f, -0.14042337f, 0.08489647f, -0.17857012f, -0.17207545f, 
    0.12420224f, 0.43102551f, 0.09764273f, -0.16166425f, 0.03243783f, 0.64769220f, 0.00172194f, -0.10553403f, 
    0.13393724f, 0.27173844f, 0.06790269f, 0.14611396f, -0.30784857f, 0.49482498f, -0.24224503f, -0.03500276f, 
    -0.07808398f, -0.17406036f, 0.56771523f, -0.17754163f, 0.08527543f, -0.09283184f, 0.29886508f, 0.22807881f, 
    0.06983192f, -0.01378707f, -0.20281126f, 0.07198310f, -0.33538476f, -0.06982370f, -0.08329695f, 0.01216153f, 
    0.15124014f, -0.30310103f, -0.05166073f, 0.07331391f, -0.19953333f, 0.45160797f, 0.19459552f, -0.87909132f, 
    -0.22615926f, 0.48231098f, -0.02558237f, -0.16270937f, -0.13929525f, 0.44499180f, 0.22082755f, -0.03920621f, 
    0.12626702f, -0.08595581f, 0.09439391f, -0.08787543f, 0.06492055f, 0.24903086f, 0.07796280f, 0.15945232f, 
    -0.24552347f, 0.11171559f, -0.02323123f, 0.49339801f, -0.02405987f, 0.15986598f, 0.40637133f, 0.06389286f, 
    0.27713770f, 0.09873381f, 0.15407817f, -0.05194457f, 0.15261936f, -0.52574778f, -0.03740247f, 0.04025576f, 
    0.03114781f, -0.00262016f, 0.14050417f, 0.22498545f, -0.25104144f, -0.18449141f, -0.05401009f, -0.05492075f, 
    -0.10146829f, 0.03116515f, -0.26226357f, 0.06072451f, 0.10233662f, 0.04719106f, -0.05972522f, 0.13726686f, 
    0.09093679f, 0.34292540f, 0.29837757f, -0.04778025f, -0.10443618f, 0.04893544f, 0.08737969f, 0.59961069f, 
    0.04910632f, -0.19002099f, -0.22979560f, 0.18674304f, -0.01991312f, -0.36117792f, 0.16964599f, 0.00957906f, 
    -0.08350337f, -0.16077645f, 0.01790958f, 0.30094129f, -0.02195352f, -0.15456043f, 0.19580398f, 0.30137503f, 
    -0.00096051f, -0.21507588f, -0.13642389f, -0.02533126f, 0.12102132f, -0.10895997f, -0.31842130f, -0.03969035f, 
    -0.00418193f, 0.16502267f, 0.04305607f, -0.08462468f, 0.21037570f, -0.03998048f, -0.10651608f, 0.33008939f, 
    0.04090157f, -0.35934323f, 0.04999081f, 0.21606266f, 0.04376877f, -0.29317829f, 0.09215980f, 0.02221766f, 
    -0.05303045f, -0.02842679f, 0.32419100f, 0.31506801f, 0.12625489f, -0.13838072f, -0.30621094f, 0.21548928f, 
    0.33272532f, -0.32856062f, -0.26401472f, -0.22040863f, 0.20425475f, 0.09817290f, -0.16225459f, 0.10520431f, 
    0.12522592f, 0.36786568f, -0.13617729f, 0.41165826f, 0.25324512f, 0.21273208f, -0.05081746f, -0.04139048f, 
    -0.01391929f, 0.12899306f, -0.11080526f, 0.16806217f, -0.10248373f, 0.00901360f, 0.13064972f, 0.35756487f, 
    0.14187466f, -0.16046087f, 0.07333250f, -0.08090115f, 0.20693932f, -0.26012310f, 0.20587978f, 0.01118494f, 
    0.09830018f, 0.14560641f, -0.09015298f, 0.03148356f, 0.00919520f, 0.05108454f, 0.08998276f, 0.15854825f, 
    0.27217063f, -0.27346596f, -0.20101772f, 0.27905273f, 0.38470870f, 0.11544416f, 0.06597510f, -0.03660904f, 
    -0.10636318f, -0.05155420f, -0.14653751f, -0.18352544f, -0.01033148f, 0.35011339f, -0.02850581f, 0.00601928f, 
    0.20075847f, -0.06920563f, -0.06472524f, -0.06623163f, -0.04314808f, 0.23382388f, 0.18904749f, 0.28913042f, 
    -0.19393849f, 0.19847727f, 0.08693721f, 0.10654455f, 0.00072319f, 0.14121160f, 0.21048447f, -0.22374360f, 
    -0.11513298f, -0.04252459f, 0.24015772f, -0.11410011f, -0.18890689f, 0.21807528f, 0.23349875f, -0.10035811f, 
    -0.13543017f, 0.08464661f, -0.00911588f, 0.04755806f, 0.51586324f, -0.33119810f, -0.30121589f, 0.03527847f, 
    0.10209010f, 0.22199616f, 0.01498964f, 0.06803554f, 0.29475519f, 0.02467475f, -0.16103640f, -0.11884867f, 
    -0.45097134f, 0.09438946f, 0.30627972f, 0.12624605f, 0.09036854f, -0.01551421f, -0.01325175f, -0.46681327f, 
    -0.18355781f, 0.30336851f, -0.11766005f, -0.19955446f, -0.07488267f, -0.01056453f, 0.07353221f, 0.00833554f, 
    0.26005170f, 0.29074931f, -0.04496110f, 0.29811820f, -0.08435202f, -0.07417776f, -0.25003979f, -0.03122939f, 
    -0.25989085f, -0.14545089f, 0.04242442f, 0.12278906f, 0.02568892f, 0.19888529f, 0.17206490f, -0.31763029f, 
    0.21647874f, -0.09348345f, -0.06914037f, 0.06918620f, 0.11371763f, -0.04486421f, -0.05388872f, 0.13319069f, 
    0.18394253f, 0.06790921f, -0.10264479f, 0.19973472f, 0.14511076f, 0.01060241f, 0.14736924f, -0.02610873f, 
    0.29764012f, -0.45416802f, -0.30459327f, 0.16502520f, 0.08134172f, -0.44436675f, 0.26132414f, -0.18586589f, 
    0.05349309f, 0.01008260f, 0.10625742f, -0.17505422f, -0.37221798f, -0.09237903f, 0.31832126f, -0.24928369f, 
    0.02103016f, 0.14938509f, 0.02610442f, -0.32255661f, 0.37007412f, 0.09368661f, 0.21120319f, 0.08576480f, 
    0.15250112f, -0.08063059f, 0.17128885f, 0.09714231f, 0.06241747f, 0.07965138f, 0.04248072f, -0.14016692f, 
    -0.20358875f, 0.18695645f, 0.00253662f, -0.38128367f, -0.14539485f, -0.06174815f, 0.02608248f, -0.04026738f, 
    0.22162391f, 0.07844854f, 0.00081896f, 0.15365878f, -0.02966909f, 0.11494631f, 0.11581898f, 0.22506672f, 
    -0.40703449f, 0.30127546f, 0.29598624f, 0.30329725f, -0.08206308f, -0.08765648f, 0.22474715f, -0.08626395f, 
    0.23658559f, -0.35419479f, 0.08529031f, 0.14479676f, -0.17869061f, 0.12536216f, 0.15439527f, 0.25837135f, 
    -0.09022486f, 0.31418163f, 0.06074457f, 0.02739558f, -0.15615202f, 0.33377889f, -0.15211089f, -0.44912326f, 
    0.05687905f, 0.13719811f, -0.04446086f, 0.00767594f, 0.16650558f, 0.14721671f, 0.06238144f, 0.27951419f, 
    -0.28713825f, 0.21321464f, 0.13016212f, -0.06736066f, -0.31555542f, 0.01484386f, -0.17909738f, -0.11795156f, 
    -0.04822379f, -0.08624598f, -0.24455018f, 0.43251804f, 0.18439172f, 0.08415992f, 0.05218981f, 0.14118673f, 
    -0.05563710f, -0.10312398f, -0.04189865f, -0.09528747f, -0.02726038f, -0.09878741f, -0.02863216f, -0.07625496f, 
    -0.05752998f, 0.24245307f, 0.00889667f, 0.24368297f, -0.22403991f, 0.07858525f, -0.52387118f, 0.06952550f, 
    0.01014179f, -0.01701404f, -0.39378151f, -0.10666133f, -0.00754701f, 0.11578382f, 0.01204718f, 0.31402802f, 
    -0.01384725f, 0.31879428f, 0.28189814f, -0.22046345f, -0.06912047f, 0.04057141f, 0.24036048f, 0.11651938f, 
    0.02608286f, -0.24678697f, 0.01802529f, 0.01829259f, -0.06918728f, -0.39053398f, 0.23025964f, -0.34091854f, 
    0.07667945f, 0.27087575f, 0.05052953f, 0.24182798f, 0.10605403f, 0.13705049f, 0.01252794f, 0.13371716f, 
    0.18969664f, -0.01889442f, 0.01502786f, -0.07294438f, 0.18325809f, -0.02968102f, -0.05843053f, 0.08469792f, 
    -0.25847462f, 0.07097378f, -0.04983379f, 0.13169351f, 0.14139819f, -0.04638906f, 0.25277007f, 0.01392128f, 
    0.02980227f, -0.15467942f, -0.13725217f, 0.09125651f, 0.04156971f, -0.48863709f, -0.00373584f, -0.00734234f, 
    -0.05706554f, 0.02366504f, -0.06736112f, 0.09587973f, 0.03216506f, -0.38058987f, 0.05013554f, 0.13641725f, 
    -0.02985816f, -0.01382615f, -0.20817849f, -0.07219900f, -0.06633619f, -0.06352074f, 0.11016162f, 0.09220834f, 
    0.07954664f, 0.14301437f, 0.17701709f, 0.10221082f, 0.38960028f, 0.23372504f, 0.25935501f, -0.33044985f, 
    0.32639998f, -0.25387883f, -0.10520073f, 0.30854449f, 0.27560827f, -0.41977373f, 0.04431894f, -0.04166994f, 
    0.10317158f, -0.23399609f, -0.09195805f, 0.00693319f, -0.06042552f, -0.24641472f, 0.01077487f, 0.06402516f, 
    -0.14093080f, 0.40228122f, -0.04387145f, 0.02701410f, 0.08553906f, -0.21285069f, 0.09688423f, 0.15268524f, 
    0.21654478f, 0.01512532f, -0.11233801f, -0.24237475f, 0.11394911f, -0.16440214f, 0.26501238f, 0.20557527f, 
    -0.19428997f, 0.02823377f, -0.05512130f, -0.16340151f, 0.15321995f, -0.03189496f, -0.05210357f, 0.04595575f, 
    0.17139238f, 0.14377402f, 0.18035150f, 0.30229256f, 0.20309693f, -0.31103584f, 0.26325530f, 0.37751472f, 
    0.18213278f, 0.20313025f, -0.08494573f, -0.06127504f, 0.05083885f, -0.16051152f, 0.12270638f, -0.08215766f, 
    0.05629161f, 0.02490140f, -0.01042135f, 0.25602061f, 0.45744073f, 0.06005592f, -0.06765886f, -0.61197829f, 
    -0.20102985f, 0.38129315f, 0.01747206f, 0.16294153f, 0.22713448f, -0.07678731f, -0.27665010f, 0.27786723f, 
    0.29592970f, 0.01768890f, -0.02927778f, -0.03505926f, 0.36206439f, -0.13963257f, -0.21928054f, -0.12019503f, 
    -0.03246707f, 0.38961622f, 0.02136821f, -0.00498908f, -0.12808490f, -0.00950676f, -0.15637602f, 0.20411578f, 
    0.46067455f, 0.07506059f, 0.21226379f, 0.01809605f, -0.04192152f, -0.01562851f, 0.03495100f, -0.00951509f, 
    0.04607987f, 0.39596063f, 0.04517258f, 0.09184626f, 0.13154384f, 0.30496040f, 0.24768542f, 0.10751383f, 
    -0.10606892f, -0.20757121f, 0.08269403f, -0.00161201f, 0.36275455f, -0.16411632f, 0.49073726f, 0.18581261f, 
    0.21907882f, 0.24859358f, 0.35555014f, 0.45980546f, 0.26219922f, -0.04347597f, -0.10220407f, -0.28902102f, 
    0.34158412f, -0.16953532f, 0.00225524f, 0.00247526f, 0.03521628f, 0.00431213f, 0.02820245f, -0.36043823f, 
    0.01721699f, 0.52014273f, -0.03036586f, 0.19829345f, -0.07852872f, 0.08684461f, -0.12468795f, 0.47565037f, 
    0.08196773f, 0.09597771f, -0.01277464f, 0.03981847f, 0.08335149f, 0.13568051f, -0.20487480f, -0.08090197f, 
    0.16282150f, 0.17322095f, 0.13122399f, 0.05524473f, 0.08982369f, -0.23145969f, -0.14791536f, 0.16696091f, 
    0.39806700f, -0.23073219f, -0.03293761f, 0.31859392f, 0.06809278f, 0.04616429f, -0.25092953f, -0.14074165f, 
    -0.09349488f, 0.09862003f, 0.10081553f, -0.28635386f, -0.02510406f, 0.40359306f, -0.00264680f, -0.02719212f, 
    0.21491429f, 0.46842730f, 0.27417091f, 0.19319603f, -0.34887591f, 0.02037513f, -0.05682626f, 0.16982250f, 
    -0.28504276f, 0.12305859f, 0.07944792f, 0.12321972f, -0.17614828f, 0.15258600f, -0.01875513f, 0.18248744f, 
    -0.00461525f, 0.05867685f, 0.19472501f, -0.36957794f, 0.13780612f, 0.09760194f, 0.10778134f, 0.38392159f, 
    -0.10635200f, 0.32877526f, -0.36911595f, -0.04422442f, 0.03460942f, 0.17130275f, -0.09171930f, 0.09005621f, 
    0.01405011f, 0.06906946f, 0.05547811f, 0.45922235f, 0.46973023f, 0.30342039f, 0.05757616f, 0.22444728f, 
    -0.09267877f, -0.08576503f, 0.02093987f, 0.13645111f, -0.30728248f, -0.63259208f, -0.11921676f, -0.20148155f, 
    -0.02900884f, -0.03729771f, 0.01298319f, -0.14896618f, 0.04050712f, -0.05919378f, 0.12589842f, -0.03567344f, 
    -0.16419521f, -0.16805476f, 0.07044138f, -0.00284452f, 0.05908868f, -0.18728453f, 0.15090348f, 0.11460066f, 
    -0.02393393f, -0.10533562f, -0.03124923f, -0.07748967f, 0.14094996f, -0.20421213f, -0.11673587f, -0.08466374f, 
    -0.04784849f, 0.00687303f, -0.02559180f, 0.04321217f, 0.00660424f, -0.01093043f, -0.02876924f, -0.17206365f, 
    0.06872723f, -0.10945144f, -0.07142456f, 0.03426680f, -0.19599934f, -0.16746192f, 0.06969755f, -0.15875171f, 
    -0.05305294f, -0.14709368f, 0.04468000f, 0.07506480f, -0.15652807f, 0.05707169f, -0.13181397f, -0.07987393f, 
    0.00300481f, -0.16286170f, 0.04243045f, 0.01607913f, 0.02713371f, 0.02114632f, -0.01628112f, 0.07488015f, 
    -0.09430474f, -0.13501044f, -0.04804131f, -0.12283731f, 0.04177685f, 0.06513944f, -0.06149510f, 0.06697565f, 
    0.03164850f, 0.10082582f, -0.06554360f, -0.00246156f, -0.13078120f, -0.08228107f, 0.12244023f, -0.05578731f, 
    -0.07563473f, -0.01202468f, -0.12140262f, -0.12674588f, -0.09359400f, -0.08746854f, 0.00071065f, 0.05869633f, 
    0.02224082f, -0.11919669f, 0.00742310f, -0.05653914f, -0.02786936f, 0.10101194f, 0.00661812f, -0.11639050f, 
    -0.04751607f, 0.08300730f, -0.05581092f, 0.01053845f, -0.01468872f, 0.02808316f, 0.06159792f, 0.05225122f, 
    0.08677168f, 0.05812891f, 0.01368446f, -0.12914427f, -0.01418068f, -0.03171894f, 0.08582425f, -0.04455636f, 
    -0.02540001f, 0.03464723f, -0.08697566f, -0.13381553f, -0.08906718f, -0.00802509f, -0.00048517f, 0.06346186f, 
    -0.01982048f, -0.07038134f, 0.06463143f, 0.02950773f, -0.11621344f, 0.05369682f, -0.01908436f, 0.01365818f, 
    0.03726599f, 0.06327134f, -0.00637200f, -0.04422835f, -0.09206239f, 0.02629833f, 0.00233316f, -0.12702106f, 
    0.06668161f, 0.06251096f, 0.04331066f, 0.06215890f, -0.10913961f, -0.15952547f, -0.15093048f, -0.24358003f, 
    0.00052498f, -0.18384318f, 0.24370176f, 0.29415968f, 0.00397932f, -0.22680849f, -0.08691462f, 0.01244734f, 
    0.00840495f, 0.32338700f, 0.18001404f, 0.22144163f, 0.23349790f, -0.42490807f, -0.62239391f, -0.03903259f, 
    0.32141939f, -0.07069542f, -0.20148998f, -0.60161519f, 0.31774482f, -0.07737241f, 0.01812225f, 0.33773515f, 
    -0.47117385f, 0.32835650f, -0.12372888f, 0.16171029f, -0.22407408f, -0.48613918f, -0.26909065f, -0.43257371f, 
    -0.06963845f, 0.15505210f, -0.21821246f, 0.11601485f, -0.51291668f, -0.08390453f, 0.29283309f, -0.23821455f, 
    0.01911532f, -0.04975724f, -0.03069459f, -0.04317788f, 0.10301033f, 0.34036848f, 0.08557006f, 0.18870170f, 
    0.22483611f, -0.11166094f, -0.31771007f, -0.17999204f, 0.20094989f, -0.17854153f, -0.25757658f, 0.47899282f, 
    0.46040341f, 0.11262292f, 0.18900125f, -0.24668755f, -0.19088097f, -0.14802951f, 0.25348595f, 0.09308648f, 
    0.15170431f, 0.07504950f, -0.05252244f, 0.33969960f, 0.13036005f, 0.24521945f, -0.00527946f, -0.05098113f, 
    -0.22303556f, -0.17080289f, 0.07977814f, 0.02320926f, 0.19085144f, -0.05560910f, 0.22573811f, -0.13973641f, 
    0.21671441f, -0.00913373f, -0.12643468f, 0.01856331f, 0.35627002f, -0.09248778f, -0.16170081f, -0.11232245f, 
    0.12252629f, 0.11270034f, -0.09328377f, 0.18225783f, -0.06704488f, 0.12771069f, 0.00346146f, 0.02035572f, 
    0.10506889f, 0.40446648f, -0.17685947f, 0.24270873f, 0.10427254f, -0.19085214f, 0.12351065f, 0.45971310f, 
    0.02312316f, -0.19322374f, 0.11703538f, -0.06590046f, -0.16112530f, 0.06266701f, 0.23140348f, -0.26783967f, 
    0.25886506f, 0.09509095f, 0.09499163f, -0.00538272f, 0.36409050f, -0.32547420f, -0.09243656f, 0.19273983f, 
    -0.12807211f, 0.18159957f, 0.30826887f, 0.14689013f, -0.34624416f, -0.03235079f, 0.02169511f, -0.12208896f, 
    0.14948921f, 0.30045664f, -0.13528785f, -0.05208499f, 0.03601158f, 0.19775708f, -0.01275135f, 0.07598058f, 
    0.19092529f, -0.21703456f, -0.11474877f, -0.05746073f, -0.00194397f, 0.34137008f, 0.58753055f, -0.21684629f, 
    0.07522450f, 0.24027866f, 0.51841205f, 0.16958572f, 0.01357498f, -0.00033386f, 0.21478230f, 0.16467799f, 
    0.01513082f, 0.08312754f, -0.05661280f, 0.05402301f, -0.05700893f, 0.17071244f, 0.15109129f, 0.38508138f, 
    0.39992017f, -0.22644544f, -0.04606805f, 0.10524999f, 0.31330919f, 0.30494153f, 0.14074698f, 0.10516292f, 
    -0.17510490f, 0.02009319f, -0.09175729f, -0.01281552f, -0.30221662f, 0.04083764f, 0.42069617f, 0.13885167f, 
    0.00304564f, 0.12173405f, -0.04769334f, -0.16406338f, 0.13962534f, -0.01835792f, 0.24469949f, 0.07177863f, 
    -0.15551768f, -0.03476032f, 0.03676309f, 0.00981517f, -0.08487451f, -0.07960120f, 0.06477000f, 0.10161745f, 
    -0.13444601f, -0.09124712f, 0.01705996f, -0.14999507f, -0.06253526f, 0.00446005f, 0.02952839f, 0.07836057f, 
    0.01267499f, -0.09358733f, -0.10350605f, -0.13389337f, -0.03695303f, -0.03160741f, 0.00140878f, -0.04575081f, 
    -0.05417747f, 0.06622265f, -0.05717320f, -0.06895471f, -0.04372616f, 0.08320168f, -0.10268354f, -0.04514836f, 
    -0.22811489f, -0.11091197f, -0.12602173f, 0.04806238f, -0.01052288f, -0.08538832f, -0.12545799f, -0.08525170f, 
    -0.02352604f, 0.06789439f, 0.04800376f, -0.01126689f, -0.14684168f, -0.04265752f, -0.10002852f, -0.06776173f, 
    -0.00618449f, -0.17951433f, 0.05217561f, -0.22490367f, -0.11861446f, -0.12932304f, -0.07836901f, 0.01477167f, 
    0.01842193f, -0.09826093f, 0.09482096f, -0.02978785f, 0.14141667f, -0.07114494f, 0.05240380f, 0.02936862f, 
    -0.54118443f, 0.08610249f, -0.10565817f, 0.33346328f, 0.03590599f, 0.02328774f, -0.08544441f, 0.10914207f, 
    0.21431813f, -0.17137404f, 0.02916427f, 0.08594869f, -0.11329339f, 0.07668531f, -0.04333869f, -0.03833976f, 
    0.02013827f, 0.04714643f, 0.05876839f, 0.22431286f, -0.12434053f, -0.02287460f, -0.71576494f, -0.17010219f, 
    0.01025857f, -0.08276623f, -0.41219661f, -0.28199220f, 0.04006911f, 0.02636677f, 0.03223882f, 0.35660285f, 
    0.12380961f, 0.28938261f, 0.14088511f, -0.12361778f, -0.07932852f, -0.06890728f, -0.01309344f, 0.24118811f, 
    0.21108146f, -0.54247051f, 0.07757682f, 0.17129320f, -0.10320680f, -0.58074194f, 0.24182704f, -0.38938025f, 
    -0.06766766f, -0.06249992f, -0.04382557f, 0.12466097f, -0.05939830f, -0.12609529f, 0.12914495f, 0.25725046f, 
    0.01178116f, 0.01567579f, 0.06018636f, 0.03936056f, 0.16656308f, -0.14910665f, -0.06656720f, 0.24073106f, 
    -0.10019028f, -0.11842004f, -0.00931991f, -0.08096378f, 0.01281951f, 0.07214761f, -0.09356622f, -0.12318040f, 
    0.08118682f, 0.02793029f, 0.04472950f, 0.05600765f, 0.10534240f, 0.11150129f, -0.08728078f, -0.08949435f, 
    0.04866752f, -0.16258363f, -0.03429157f, 0.06656524f, -0.16211212f, -0.08965695f, 0.07254590f, -0.10218965f, 
    -0.11453784f, -0.06136489f, -0.00390802f, 0.02235316f, -0.05303381f, -0.09247273f, -0.14080384f, -0.12822579f, 
    -0.08718431f, 0.04117285f, 0.06375466f, 0.07961074f, -0.05352852f, -0.08462106f, -0.00810924f, 0.05212089f, 
    -0.02725832f, 0.10369141f, 0.06054849f, -0.13844447f, 0.05303575f, 0.06370704f, -0.15772912f, -0.08969866f, 
    -0.12953258f, -0.04958520f, 0.06428356f, -0.10971713f, -0.01404311f, 0.01221600f, -0.09097313f, -0.00450550f, 
    0.05984379f, -0.07755847f, -0.04745389f, 0.04463428f, -0.04860877f, -0.06928188f, -0.15285842f, 0.11047667f, 
    0.21653250f, 0.10865104f, 0.25748742f, 0.07208543f, -0.50368732f, 0.04306149f, -0.13351940f, -0.39210612f, 
    0.02777543f, 0.33906934f, 0.18405406f, 0.03706734f, 0.05588135f, -0.41970378f, -0.08387842f, -0.06159316f, 
    0.26749372f, 0.05791184f, -0.09189064f, -0.00453992f, 0.04837324f, 0.02108204f, -0.14922351f, -0.02323610f, 
    0.05708906f, 0.15007444f, 0.56240636f, 0.04414969f, 0.17097823f, -0.09588929f, -0.00353787f, 0.09626704f, 
    0.24364837f, -0.06572923f, -0.07743742f, -0.16139656f, -0.45833561f, -0.21998432f, -0.02275267f, 0.36188418f, 
    0.12652558f, 0.20565304f, -0.13349546f, 0.12031454f, -0.59824002f, 0.80818826f, 0.09584266f, -0.17060904f, 
    -0.22393808f, 0.21893720f, 0.09311866f, 0.26551944f, 0.07436157f, 0.56964594f, 0.12618062f, 0.25009796f, 
    0.29218265f, -0.09634966f, -0.21090095f, -0.06878719f, -0.04342218f, -0.26158020f, -0.31781563f, 0.25027516f, 
    0.16268723f, 0.29940376f, 0.32333282f, 0.11854077f, -0.43080086f, -0.11722493f, 0.03793020f, -0.34670046f, 
    0.14394465f, 0.36804211f, -0.00639849f, -0.03144444f, 0.00323482f, 0.20208834f, -0.19697207f, 0.12241355f, 
    0.15026130f, -0.22884770f, -0.10024609f, -0.14634345f, -0.09775988f, 0.45837781f, 0.82640845f, 0.04197579f, 
    0.00644161f, 0.33301735f, 0.72076607f, 0.14353719f, 0.01948998f, 0.02207778f, -0.02836116f, -0.08018103f, 
    0.16605875f, -0.17183505f, -0.05366882f, 0.05333082f, 0.10052131f, 0.06518667f, 0.07108753f, 0.33919686f, 
    0.32069835f, 0.13439481f, 0.00514226f, 0.11046989f, 0.30974144f, 0.49385113f, -0.03271453f, 0.00323021f, 
    -0.15672685f, -0.02920711f, 0.04345991f, -0.03468313f, -0.09808765f, 0.30313405f, 0.30841964f, 0.08342731f, 
    0.19498058f, -0.08664420f, -0.16537020f, -0.22409201f, 0.18063654f, 0.00372336f, 0.11814760f, -0.06408031f, 
    -0.32543081f, 0.20573196f, -0.03164333f, -0.19858007f, 0.18884939f, 0.06704038f, 0.34012640f, 0.06089798f, 
    0.04735290f, -0.02957747f, -0.18263437f, -0.00905924f, 0.03926439f, -0.37094826f, -0.06084359f, 0.04146980f, 
    -0.10458297f, -0.25264880f, -0.00890708f, 0.28055352f, 0.21551658f, -0.55463648f, 0.30504784f, 0.22657058f, 
    0.15633449f, 0.16776843f, 0.02151403f, 0.19306581f, 0.06014470f, -0.07507919f, -0.03780485f, -0.15193494f, 
    0.43131641f, 0.02657190f, 0.22425251f, 0.03000006f, 0.59102690f, 0.23076673f, 0.04573005f, -0.51257670f, 
    0.27054632f, -0.21194692f, -0.28993157f, 0.48478195f, 0.34686014f, -0.16751128f, -0.13275263f, -0.01103143f, 
    0.13890818f, -0.30575508f, 0.07051031f, -0.04994698f, 0.01857670f, -0.28984764f, -0.08175156f, -0.16837837f, 
    0.04069440f, 0.49877277f, -0.12650134f, -0.18218283f, -0.03178127f, -0.44324130f, -0.00127628f, 0.11887550f, 
    -0.57317656f, 0.21378338f, 0.31402525f, -0.00238690f, -0.12379430f, 0.12115120f, 0.38882488f, 0.05290100f, 
    -0.00558200f, 0.37683085f, -0.09743472f, -0.34878239f, -0.01683687f, -0.82485259f, -0.01606507f, -0.09575070f, 
    0.20574412f, -0.12134030f, -0.06403669f, 0.06618348f, 0.06966302f, -0.24145168f, 0.15260944f, 0.15273857f, 
    -0.17444891f, 0.25868466f, 0.58466136f, 0.34285447f, -0.23601370f, 0.08443500f, 0.03662047f, 0.08585960f, 
    0.37370384f, -0.10201460f, 0.00888165f, -0.12649453f, 0.48295990f, 0.04689492f, -0.00038835f, 0.52394772f, 
    0.12580243f, -0.44311154f, -0.11700072f, 0.24959378f, -0.35885116f, 0.28694963f, -0.06943958f, 0.01482792f, 
    -0.02061901f, 0.16302915f, 0.03859631f, 0.14815338f, 0.14484416f, 0.25934601f, 0.42512956f, 0.25590906f, 
    -0.01682470f, 0.05967244f, -0.36061919f, -0.01851420f, -0.28095105f, -0.28570342f, -0.44540164f, -0.05993667f, 
    -0.23722719f, 0.28458577f, 0.14072171f, -0.18755506f, 0.06728502f, -0.06930124f, -0.11573827f, -0.07208278f, 
    -0.00158983f, 0.21657982f, -0.04715414f, -0.01081873f, -0.00037435f, 0.24628417f, 0.04895713f, 0.01315877f, 
    0.09311701f, -0.15005316f, -0.09983409f, -0.05008420f, 0.14605466f, 0.23862430f, 0.15191309f, 0.26110303f, 
    0.05565614f, 0.08716647f, 0.57454067f, 0.12412301f, -0.09500492f, -0.08467936f, 0.21672378f, 0.04168727f, 
    0.09930982f, -0.20564584f, -0.12676141f, 0.13410671f, 0.35207269f, 0.14948985f, 0.01864559f, -0.00448481f, 
    0.13955280f, 0.00682957f, -0.07661037f, 0.06289933f, 0.21395604f, 0.65270144f, -0.16478670f, 0.01887435f, 
    -0.06274439f, 0.29234180f, 0.10125223f, -0.07356600f, 0.07655057f, 0.08137815f, 0.29900435f, 0.03458046f, 
    -0.18049924f, 0.05446321f, 0.01519038f, -0.01331226f, -0.14211363f, 0.01945196f, 0.29590762f, -0.07167450f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16429999f, 0.21693033f, 0.00353647f, -0.12515171f, 0.17720944f, 0.15537694f, 0.19142790f, -0.27965549f, 
    0.42956617f, -0.39394557f, 0.20476097f, 0.26155359f, 0.03444386f, 0.19332035f, -0.08270371f, -0.00540737f, 
    -0.18443957f, -0.20286579f, 0.14723483f, 0.24332368f, 0.27780649f, -0.09129626f, -0.04372782f, 0.33199042f, 
    0.05627088f, -0.01618080f, -0.10227603f, 0.18816821f, 0.12084616f, 0.03442923f, -0.01444867f, 0.30955240f, 
    0.38142803f, -0.16534162f, 0.14951949f, 0.30743217f, 0.16734780f, 0.00245958f, 0.03778257f, 0.11060375f, 
    0.27675599f, -0.33089951f, 0.29692557f, 0.07470200f, 0.27449018f, 0.05053756f, -0.16760562f, 0.30628094f, 
    0.05617053f, 0.10612932f, 0.40371466f, -0.15788604f, 0.03430266f, -0.06100874f, 0.21455139f, 0.17558797f, 
    -0.15133889f, 0.07975560f, -0.05874487f, 0.01563598f, 0.17002565f, 0.30984807f, -0.12119023f, 0.40060312f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.09040383f, -0.71644098f, 0.19254951f, -0.03239371f, 0.12215825f, 0.00659563f, 0.20235677f, -0.03565932f, 
    -0.46676788f, -0.03364547f, 0.04542379f, -0.06058203f, -0.02177954f, -0.04085828f, -0.02969228f, -0.02235984f, 
    0.29941425f, -0.19925161f, 0.19442229f, -0.41302466f, 0.13646734f, 0.13851884f, 0.02666210f, -0.06301557f, 
    0.06450395f, -0.32230335f, 0.10194407f, -0.30322254f, 0.00539872f, 0.06677066f, 0.19271085f, -0.50533742f, 
    -0.10638608f, -0.03843509f, -0.53989881f, -0.67312706f, -0.11783561f, -0.07929441f, -0.16538188f, -0.27064243f, 
    -0.33407670f, -0.02399026f, 0.07405709f, -0.15624322f, -0.15083383f, -0.07185835f, 0.06802227f, -0.45165351f, 
    0.08375637f, 0.23063946f, 0.57874769f, 0.07343134f, -0.05236563f, 0.25829983f, 0.15707409f, -0.62408131f, 
    -0.01581363f, -0.33504838f, -0.05410737f, 0.35382798f, -0.31405392f, -0.51051408f, -0.25964347f, -0.37134764f, 
    -0.04190930f, 0.34777868f, 0.01395356f, -0.11666436f, 0.35755089f, -0.13938268f, 0.06507800f, -0.26396343f, 
    0.08700967f, 0.11299776f, 0.27805948f, 0.05281286f, -0.04622952f, -0.10383078f, 0.15662912f, 0.00245344f, 
    -0.33027789f, 0.03906677f, 0.05693296f, -0.59551233f, 0.11244166f, -0.06943510f, -0.07597689f, 0.06652304f, 
    -0.10307954f, -0.89568758f, 0.01927978f, 0.23483704f, -0.12977535f, -0.10293095f, 0.09204035f, 0.29602182f, 
    0.37395576f, -0.13509589f, -0.48132256f, 0.02299243f, 0.40072742f, 0.10174845f, -0.06221404f, 0.28988895f, 
    0.25981876f, 0.00484205f, -0.05166437f, 0.20564006f, 0.07464051f, -0.03705927f, 0.12230910f, -0.03031711f, 
    -0.24892341f, -0.17174244f, 0.29547450f, -0.00805527f, -0.08556765f, 0.22922376f, -0.09715705f, 0.03296221f, 
    -0.10096786f, 0.24324283f, 0.03073507f, 0.20748283f, -0.01945503f, -0.32212454f, -0.62970197f, -0.03738867f, 
    -0.05075102f, 0.39052495f, -0.30774185f, -0.11862749f, -0.58466047f, -0.13863619f, -0.11916929f, -0.54953265f, 
    0.18143114f, 0.19442131f, 0.15440322f, 0.17327665f, 0.05568957f, -0.10499898f, -0.38391328f, -0.00921598f, 
    -0.89649570f, -0.26697496f, 0.10665315f, 0.40292647f, 0.09121815f, -0.11474947f, -0.01984185f, -0.77278382f, 
    -0.04549158f, -0.00176282f, 0.11513690f, 0.01514306f, -0.14108761f, 0.09047350f, -0.28397834f, 0.12217440f, 
    -0.48761493f, -0.35967043f, 0.01904067f, 0.04272720f, 0.09646165f, 0.12311328f, 0.09410043f, -0.43086544f, 
    0.11054647f, -0.60671902f, -0.03067428f, -0.30350319f, -0.01076759f, -0.07938570f, -0.30832049f, 0.05193361f, 
    0.18837517f, 0.08402700f, -0.58326972f, -0.10635649f, -0.05413595f, -1.00115967f, -0.06890915f, 0.17963099f, 
    -0.02796223f, -0.25403810f, -0.09188064f, -0.13235191f, 0.23359440f, 0.22387704f, -0.05138671f, 0.14050172f, 
    0.05165828f, -0.28374428f, 0.13145140f, 0.03174508f, -0.23548862f, -0.31227589f, -0.10253417f, -0.35889488f, 
    0.09477904f, -0.84171367f, -0.11846621f, -0.08153539f, 0.01780263f, 0.27804196f, -0.24222809f, -0.06255654f, 
    0.19420683f, -0.45578232f, -0.33581731f, 0.10332359f, -0.25580910f, -0.02283406f, -0.01959587f, -0.61504287f, 
    -0.03456209f, 0.28593311f, -0.37547973f, -0.26074493f, 0.07287868f, 0.05471157f, 0.20789295f, -0.23637253f, 
    -0.16584353f, -0.22220120f, -0.19535704f, -0.26569965f, -0.02160914f, 0.01115489f, 0.03807905f, -0.97125745f, 
    -0.52975821f, -0.12498152f, 0.17360102f, -1.10685754f, -0.00874954f, -0.80953956f, -0.67502868f, -0.00267554f, 
    0.02042628f, 0.24997158f, -0.24768640f, 0.01237567f, 0.05348983f, -0.05485437f, 0.21933630f, 0.06721562f, 
    -0.20568717f, -0.82653368f, 0.06658708f, -0.02111744f, 0.18603458f, 0.21286653f, 0.00900772f, 0.17864658f, 
    -0.05454247f, 0.05892735f, 0.05225348f, 0.03985479f, 0.11009531f, -0.17663650f, 0.02587827f, 0.07799479f, 
    -0.11059185f, -0.12583049f, -0.10607658f, 0.02536205f, -0.12850522f, 0.23590913f, 0.13572003f, 0.04398472f, 
    0.09375837f, 0.09943448f, -0.17675719f, 0.03382885f, -0.50418174f, 0.27167794f, -0.00833666f, 0.27296168f, 
    -0.01791879f, -0.07927559f, -0.57115310f, -0.23959202f, 0.11769528f, -0.07830207f, -0.05785936f, -0.56761336f, 
    -0.55070513f, 0.09560291f, -0.54915518f, 0.05708447f, -0.40979782f, -0.03396472f, 0.01563033f, -0.74084610f, 
    -0.65843451f, -0.01953072f, 0.21005125f, -0.14160734f, 0.16984233f, 0.00287535f, 0.19117434f, 0.25772917f, 
    0.09815575f, -0.07140105f, -0.80310398f, 0.03503928f, 0.01614253f, 0.12426873f, -0.02330408f, -0.17190698f, 
    -0.13977465f, 0.31495476f, -0.00981128f, -0.83974260f, -0.61762941f, 0.22213793f, -0.31133607f, -0.20159733f, 
    0.02835689f, 0.03061274f, 0.06284641f, -0.04754695f, 0.07743579f, -0.23361593f, 0.00956978f, -0.31359729f, 
    0.06814782f, -0.02903637f, 0.17494823f, -0.04820970f, 0.09183554f, -0.08579555f, 0.15822349f, 0.00030508f, 
    -0.02464489f, -0.11543822f, -0.97707230f, -0.00317367f, 0.13597347f, -0.24430260f, -0.11607776f, 0.10576921f, 
    -0.01149414f, -0.07163406f, -0.49730247f, 0.10795301f, -0.12877865f, 0.09118593f, -0.12207720f, 0.21995844f, 
    -0.66632897f, 0.11339664f, 0.14329529f, 0.11882459f, -0.78287077f, 0.02970806f, -0.06656655f, 0.09926235f, 
    -0.16814595f, 0.25809526f, -0.00118277f, 0.25943244f, 0.11691477f, -0.06335974f, 0.20044830f, 0.11552131f, 
    0.03439697f, 0.03495786f, -0.48282439f, -0.00728856f, -0.05244002f, 0.17902328f, 0.08879431f, -0.09537989f, 
    -0.22428529f, 0.21420714f, 0.08792902f, 0.01823940f, -0.27687463f, 0.24230339f, 0.21323080f, -0.26266146f, 
    -0.18954928f, -0.22521523f, -0.89568645f, 0.10821917f, -0.07801639f, -0.07793120f, -0.54260975f, -0.00206724f, 
    0.29935384f, -0.25498226f, -0.41977876f, -0.17522514f, -0.05586933f, -1.05006802f, -0.29123047f, -0.07530770f, 
    -0.63265097f, 0.20035914f, 0.21995097f, 0.29961890f, 0.16936328f, 0.09349903f, -0.12273169f, -0.42789358f, 
    -0.04168530f, -0.04704580f, -0.19397545f, -0.38561481f, -1.04671454f, -0.06638537f, -0.20509851f, -0.10903532f, 
    0.07327453f, -0.20431462f, 0.14524266f, 0.05191055f, 0.47572839f, 0.06239197f, -0.09575521f, 0.30591777f, 
    0.19666876f, -0.19809067f, -0.55802840f, 0.32100132f, -1.02875531f, 0.20979954f, -0.01007058f, -0.01859285f, 
    0.23542701f, -0.00965161f, 0.26809755f, 0.05094871f, -0.09407830f, -0.09709250f, -0.84047031f, 0.14678535f, 
    -0.12772594f, -0.64331043f, 0.02522824f, -0.87194663f, 0.15018588f, 0.02701874f, -0.04606979f, 0.16349165f, 
    -0.10567299f, -0.21837473f, -0.14165959f, -0.02663197f, 0.16456632f, 0.12069771f, 0.24444640f, 0.31496581f, 
    -0.28319567f, 0.06911307f, 0.33471924f, -0.25375143f, -0.10321740f, -0.23431765f, -0.18827410f, 0.09057817f, 
    0.37552226f, 0.01305171f, -0.17980929f, -0.30058461f, -0.21448670f, 0.12504405f, 0.10506979f, -0.16213091f, 
    -0.13041857f, 0.37337169f, -0.11839794f, -0.22945164f, -0.36320058f, -0.10693514f, -0.06579361f, -0.38490522f, 
    -0.50747097f, 0.46049452f, -0.33741575f, -0.90054768f, -0.28576347f, 0.00258195f, 0.14163943f, 0.10997179f, 
    0.00590352f, 0.19068114f, 0.21100089f, -0.15712051f, -0.66231245f, 0.04085803f, 0.15181622f, -0.01179962f, 
    -0.05439079f, -0.67074978f, 0.02108912f, -0.00153069f, 0.06122631f, -0.34626168f, -0.38404220f, -0.02523264f, 
    -0.00455101f, 0.15152138f, 0.03829048f, 0.09498391f, -0.26739040f, -0.19638431f, 0.37016708f, -0.05633969f, 
    0.03965081f, -0.11452158f, -0.15077916f, -0.12035210f, -0.30706885f, 0.19514486f, 0.20227705f, -0.00319447f, 
    -0.08457488f, -0.29389256f, 0.05630014f, -0.54576528f, -0.12058114f, -0.24477015f, -0.09511629f, -0.13483122f, 
    -0.39006540f, -0.22200537f, -0.22666210f, -1.02963305f, 0.06536059f, -0.23605154f, -0.08846292f, 0.05797781f, 
    0.08835579f, 0.21105479f, -0.14546633f, 0.21782082f, -0.69458091f, 0.08414467f, 0.23708569f, 0.25898719f, 
    0.10805862f, 0.06675327f, 0.11809021f, 0.09518155f, 0.29868707f, -0.12273060f, -0.11226577f, -0.15685979f, 
    0.22458340f, 0.05266852f, -0.20143473f, -0.21958625f, -0.26729348f, 0.16766775f, -0.03901853f, -0.00081396f, 
    -0.12887460f, 0.04084084f, 0.27956423f, 0.08272790f, -0.09976926f, -0.45379558f, -0.32911909f, 0.15136369f, 
    -0.05993040f, -0.01730352f, -0.08833047f, 0.29033014f, 0.11958491f, -0.15776496f, 0.37936133f, 0.25342286f, 
    -0.13862909f, -0.62468857f, -0.03476297f, 0.04178874f, 0.44198421f, 0.22656302f, -0.23262314f, -0.23600954f, 
    0.24214037f, -0.40082791f, -0.03629233f, 0.04786678f, -0.00654807f, 0.16593115f, -0.36963549f, -0.12982053f, 
    -0.28422108f, -0.30673379f, 0.10080747f, 0.19910517f, 0.17379071f, 0.18206829f, 0.09457466f, 0.38778064f, 
    0.12193280f, -0.05027794f, -0.14189360f, -0.90411210f, 0.18851361f, -0.00510844f, -0.33839366f, -0.33437890f, 
    0.08800808f, -0.17611501f, 0.05416565f, 0.22179887f, -0.05805001f, -0.01389554f, 0.01141505f, 0.16783509f, 
    0.05215381f, -0.53814083f, -0.01675204f, 0.04170305f, -0.07974593f, -0.08601574f, -0.05887496f, 0.16975531f, 
    0.17945546f, -0.01129065f, 0.12701288f, -0.15955652f, 0.08990675f, -0.42211449f, -0.16989219f, -0.15619171f, 
    -0.01444665f, -0.20256491f, 0.01893538f, -0.99483061f, -0.27808586f, 0.23507589f, -0.25755844f, 0.14699768f, 
    -0.15577585f, 0.08643138f, 0.20766465f, -0.08466225f, 0.18833192f, 0.21916656f, -0.10484175f, 0.43710199f, 
    -0.41803923f, -0.76409531f, -0.63390982f, 0.04435416f, 0.03525776f, -0.00505151f, 0.24825612f, 0.05397642f, 
    -0.05385950f, -0.39530197f, -0.06620221f, -0.36054137f, -0.38291806f, -0.14116649f, -0.01425442f, -0.28312257f, 
    -0.12436686f, 0.11213472f, -0.29058078f, 0.25584280f, -0.01307917f, -0.00769483f, 0.31316027f, -0.09176899f, 
    -0.43556598f, -0.31680760f, 0.16006519f, 0.14173876f, -0.36428046f, 0.06629932f, 0.07646524f, 0.23369874f, 
    0.18597035f, -0.14490120f, -0.21131089f, -0.16710262f, 0.28284475f, -0.71105045f, -0.18895774f, -0.18725942f, 
    -0.66587883f, -0.08877844f, -0.24638522f, 0.04386635f, 0.06844579f, -0.28426099f, 0.14150314f, 0.24236399f, 
    0.02306977f, -0.13043153f, -0.07942794f, -0.15136498f, 0.15036811f, -0.68972653f, -0.61430484f, 0.00461879f, 
    -0.09209032f, 0.36960116f, -0.04371947f, -0.10991891f, -0.89031637f, 0.20250216f, -0.61477637f, 0.27881098f, 
    -0.03422832f, 0.23115699f, -0.32841748f, -0.56000584f, 0.08997963f, -0.18073033f, -0.01031833f, -0.04549897f, 
    0.14192443f, 0.32685944f, 0.23256172f, -0.04084121f, 0.12686886f, 0.00932896f, 0.08109659f, -0.15258381f, 
    -0.07698856f, 0.24807677f, -0.15080266f, 0.31992045f, -0.39846122f, 0.10541617f, 0.00408500f, -0.05901781f, 
    0.30286640f, -0.15077229f, 0.14203478f, -0.21630800f, -0.18704422f, -0.04487580f, -0.10163469f, -0.27607197f, 
    -0.17303514f, 0.18379506f, -0.57482249f, 0.05569306f, -0.11967556f, -0.10124317f, 0.10967224f, 0.15927343f, 
    -0.35927156f, -0.20353884f, -0.04738971f, -0.02992636f, -0.06108002f, -0.38399890f, -0.35489604f, 0.20873772f, 
    -0.03032092f, 0.18144263f, -0.11027838f, -0.22557302f, 0.27771601f, -0.02942477f, 0.07068702f, -0.15539198f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.38039929f, 0.19560918f, 0.18938921f, 0.10632078f, -0.10242324f, -0.24206786f, -0.18075545f, 0.09311496f, 
    -0.03326175f, 0.33187449f, -0.16665782f, -0.19846003f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
