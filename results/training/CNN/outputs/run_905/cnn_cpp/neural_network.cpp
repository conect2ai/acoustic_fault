#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.37553951f, 0.75148767f, -0.57406938f, 0.47370413f, -1.19546342f, -1.42791724f, 0.27028149f, 0.11186701f, 
    0.65660709f, -1.11911762f, 1.21566999f, 0.01965971f, 0.12541625f, -0.66493696f, -1.41339087f, -0.49864832f, 
    0.18902092f, 0.21310069f, 1.30048466f, -0.58389986f, 1.09350145f, -0.88334179f, 0.50767875f, -0.31000274f, 
    0.10212144f, -0.33976948f, -0.09390129f, 0.53011030f, 0.99409968f, 0.01390584f, 0.27118340f, -0.98842871f, 
    0.69014168f, 0.61401123f, 0.50408083f, 0.43334198f, -0.75200182f, -0.82387346f, -0.56651598f, -1.15583396f, 
    -0.38699102f, 1.07956803f, -0.59257501f, -0.19233161f, -0.03912128f, -1.48489094f, -0.22614191f, 0.98790431f, 
    0.14391908f, -0.33231103f, -0.03308095f, 0.56603158f, 0.48147100f, 0.61475146f, 0.34045374f, 1.34743488f, 
    0.26132241f, -0.89675730f, -0.47656935f, -0.45157418f, -0.32323056f, -0.57401294f, 0.23735178f, -1.18049598f, 
    -1.11150312f, -0.35050875f, -0.45114785f, -0.80405480f, -0.29235083f, 0.17300913f, 0.21020932f, -0.06855368f, 
    -0.72350788f, -1.22653699f, -1.12755609f, 0.25612390f, -0.29032004f, 0.08880652f, -0.02280002f, -0.15808991f, 
    -0.72673035f, -0.93567973f, -0.98817778f, -0.67890692f, 0.38710609f, 1.16991615f, 0.19616121f, 0.19477330f, 
    -0.59122032f, -0.34630582f, -1.79459679f, 1.34357166f, -0.72481358f, -0.65780759f, 0.47138628f, 0.15830351f, 
    0.21564485f, -0.16146226f, 0.19393344f, 1.33636403f, 0.89121485f, 0.68348974f, 0.54301095f, -0.56939167f, 
    0.32427832f, -0.94646895f, -0.08748331f, 0.14083314f, -0.57369721f, 0.04233595f, -0.16905348f, 1.21811366f, 
    1.11630511f, 1.35164833f, -0.73060912f, 0.08478180f, -0.42175135f, -0.40803272f, 1.44000459f, -1.11951876f, 
    0.46833172f, 0.29625478f, -0.54464924f, 0.66182107f, -0.48953864f, -0.37265900f, 0.76758510f, 0.92431277f, 
    0.54390150f, -0.64211690f, 0.24596822f, 0.96946812f, -0.31476229f, -0.54036129f, -0.71232671f, 0.93361449f, 
    0.19154064f, 0.85464561f, -0.43811795f, -1.25830042f, 0.53930324f, 0.36603543f, 0.79539698f, -0.21987772f, 
    1.27775896f, 0.38546225f, -0.55393070f, 0.64790505f, 0.19422531f, -0.15462083f, 0.74884748f, 0.72152084f, 
    -0.74351770f, -1.14007795f, -0.72201276f, -0.18958734f, 0.86925912f, 1.28495133f, 0.13380283f, -0.16602761f, 
    -0.22141072f, -0.11499176f, -0.80945480f, 0.05683162f, -0.55946654f, 0.19595054f, 0.78223008f, 1.08608449f, 
    0.21638514f, 0.08189335f, 0.72021693f, -0.84614313f, 0.48604244f, 0.30959526f, 1.39045405f, -0.55761111f, 
    0.93474102f, 0.25557879f, -0.90347284f, -0.01564042f, -0.05031829f, 0.77098364f, 1.20823848f, 0.88331288f, 
    0.81773472f, -0.27947995f, -0.12792544f, 0.17412655f, 0.02226588f, 1.44455957f, -1.43294573f, -0.53121179f, 
    -1.00178540f, -0.52890539f, -0.33909401f, -0.33149293f, 0.29498178f, 0.04026979f, -0.59281486f, -0.05952562f, 
    -0.75939363f, -0.36268067f, -0.69121695f, 0.58460248f, -1.01465571f, 1.02445793f, 0.09509805f, 1.42836535f, 
    1.13833654f, 0.99590081f, -0.66735125f, -0.14858192f, -0.83135939f, 0.07015161f, -0.23404042f, -0.05733993f, 
    -0.15728734f, -0.80937201f, -0.63095009f, -1.06635094f, 0.81323087f, -0.81411326f, 0.44691405f, 0.78460038f, 
    -0.60292226f, -0.35165086f, 0.44646180f, 0.57745183f, -1.46870959f, -0.49097845f, -0.63320398f, 0.18590315f, 
    0.69849783f, -0.08670633f, -0.92941725f, -0.46161947f, -0.87590915f, 0.46697626f, 0.75381088f, -0.76007569f, 
    -0.58708757f, 0.60961860f, 0.50101751f, -0.67548102f, -1.09770131f, -0.79458982f, 0.23212902f, -0.38458040f, 
    0.85989416f, 0.39223287f, -0.01902008f, 0.37974152f, 0.59471625f, 0.66298741f, 0.47065875f, -1.04215026f, 
    0.32130566f, -0.89148223f, 0.65129465f, 0.72756326f, 0.61241156f, 0.68660951f, -0.29022211f, 0.81707489f, 
    1.12091446f, 0.38353795f, -0.53124619f, 0.27303928f, 0.81927735f, -0.48210472f, 1.17974842f, 0.13923611f, 
    1.16220903f, 1.03734612f, 0.81742150f, 0.42788342f, 0.44989288f, 0.56673735f, 0.08423545f, -1.04091799f, 
    -0.04627196f, 0.16916579f, 0.87511718f, -0.23412097f, -0.67197967f, -0.24253550f, -0.09737885f, -1.12414503f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22789627f, 0.19416288f, -0.20163803f, -0.29585063f, -0.17015466f, 0.03473564f, -0.02721812f, -0.01846961f, 
    -0.21250959f, -0.16256428f, 0.49412173f, 0.53687578f, 0.22832657f, 0.21966451f, 0.52666450f, 0.13071775f, 
    0.10023542f, 0.12987751f, 0.05075307f, -0.25863257f, 0.32549894f, 0.18791550f, -0.21292755f, -0.21359941f, 
    0.10921755f, 0.21110110f, 0.22694243f, 0.06174903f, -0.02057986f, 0.10759749f, 0.48668724f, -0.03990884f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01734648f, -0.05771330f, -0.05108421f, -0.03357311f, -0.01303980f, -0.03414220f, -0.05004633f, 0.02214050f, 
    -0.03793057f, 0.04072008f, 0.00059928f, -0.00051191f, 0.01536412f, -0.01205837f, 0.03082045f, -0.01719591f, 
    0.02173523f, -0.05563463f, -0.06278571f, -0.04937725f, -0.00079029f, 0.00175652f, -0.05123451f, 0.03962355f, 
    -0.06698792f, -0.05664981f, -0.01569295f, -0.02651628f, -0.01902836f, -0.05359936f, 0.03424919f, 0.01578758f, 
    0.01946707f, 0.00780786f, -0.02573931f, 0.05261650f, 0.01012104f, -0.05124981f, 0.02285269f, -0.01560678f, 
    0.00274759f, 0.05089498f, -0.06077480f, 0.04596567f, 0.04226022f, 0.03859539f, -0.03088957f, 0.00069498f, 
    -0.01631839f, 0.02639385f, -0.04534070f, -0.04313288f, -0.00286779f, -0.01331635f, -0.02019285f, -0.04832804f, 
    -0.05361412f, 0.02408643f, -0.06024730f, -0.00536723f, -0.05311109f, 0.01161684f, 0.01517639f, -0.00409023f, 
    0.04225175f, 0.03164700f, -0.03295775f, -0.02421224f, -0.00899779f, 0.01668679f, 0.01662352f, -0.00610060f, 
    -0.00154935f, -0.02523228f, -0.00723000f, 0.04088365f, -0.06542818f, -0.05112231f, -0.04139311f, -0.01539992f, 
    0.02439847f, -0.02580266f, -0.06132785f, -0.06480544f, 0.02427716f, 0.02245226f, -0.04431952f, -0.05835744f, 
    0.04631430f, 0.01693727f, -0.04837549f, -0.05625223f, 0.05045893f, 0.03531040f, 0.04367527f, -0.01662543f, 
    -0.03174344f, 0.00805160f, 0.02040140f, 0.01550978f, -0.02153672f, -0.04807342f, -0.01993939f, 0.00456052f, 
    0.03581828f, -0.05831995f, -0.04503138f, 0.03031481f, -0.00659567f, 0.04710795f, -0.02922866f, -0.04945824f, 
    -0.00468201f, -0.03186225f, -0.03607985f, 0.03413021f, -0.01459106f, 0.04402529f, 0.03982527f, 0.04536453f, 
    0.03753302f, -0.01563417f, -0.02599019f, 0.02177305f, -0.02141816f, -0.04108206f, -0.06006734f, -0.01475450f, 
    0.03749165f, -0.03770605f, -0.04093030f, -0.06323817f, 0.02748770f, 0.02032998f, -0.02252698f, -0.04889380f, 
    -0.00382802f, -0.04311316f, 0.04395011f, -0.04994975f, -0.06386365f, 0.03324002f, 0.03303116f, -0.01979072f, 
    -0.04723121f, 0.00013104f, 0.01735945f, 0.01413895f, 0.01418455f, -0.06001488f, 0.04998230f, 0.00025667f, 
    0.02605181f, 0.00070328f, 0.01113084f, 0.04708009f, -0.01328417f, 0.04585725f, -0.04125149f, -0.02758120f, 
    0.03642206f, -0.01070005f, -0.02069252f, 0.02184205f, 0.03065659f, -0.05234021f, 0.04307261f, -0.02097396f, 
    0.03419821f, -0.04493707f, -0.01215161f, 0.03774451f, -0.02839957f, -0.02215705f, -0.00366416f, 0.02758529f, 
    0.00366472f, 0.00655511f, -0.05294085f, 0.03510613f, -0.02546641f, -0.01104113f, -0.03681701f, -0.06682536f, 
    -0.06561902f, -0.04665337f, -0.06103396f, 0.00858498f, -0.01715684f, -0.02054792f, -0.01727345f, -0.00373693f, 
    -0.06792782f, 0.03616902f, 0.02000795f, 0.01287821f, 0.00764832f, -0.06118625f, -0.06482358f, 0.01738419f, 
    -0.05480260f, -0.04325089f, -0.05580486f, -0.02654981f, 0.03623220f, -0.01713369f, -0.04022792f, 0.04546356f, 
    0.02805961f, -0.01087671f, 0.04260733f, -0.05709077f, -0.03039210f, -0.02441795f, -0.06176159f, 0.03979444f, 
    -0.05916253f, 0.04094348f, 0.03545776f, 0.03476320f, 0.00211911f, -0.03407326f, -0.02710248f, -0.03354134f, 
    0.04984901f, 0.04490437f, -0.04588795f, 0.02232757f, 0.04481144f, -0.01818703f, -0.02751980f, -0.05297553f, 
    -0.03751163f, -0.00515198f, -0.01189513f, 0.02905143f, -0.04398884f, -0.05674203f, 0.01954512f, 0.03110647f, 
    -0.02550600f, -0.03936351f, 0.04951750f, -0.02329096f, -0.06028606f, -0.02916012f, 0.01075269f, -0.00620869f, 
    0.02446325f, 0.00261977f, -0.05292398f, -0.03251757f, 0.00657039f, -0.04361690f, -0.02698115f, -0.05742451f, 
    -0.01086988f, 0.01464362f, -0.01831288f, 0.00573075f, 0.01077716f, 0.01973124f, 0.00871153f, -0.02799857f, 
    -0.03703611f, -0.06357845f, -0.01216242f, -0.03289236f, -0.05965682f, 0.01825704f, -0.04319865f, 0.02347121f, 
    0.00427125f, -0.03533026f, -0.02622964f, -0.05242127f, 0.01832425f, -0.02605895f, 0.00373757f, 0.02001703f, 
    0.02892991f, -0.02963635f, 0.01304433f, -0.02774606f, 0.02452368f, -0.06194199f, -0.02007137f, -0.05170541f, 
    -0.06215982f, 0.17541935f, -0.08986095f, -0.04160012f, 0.15886673f, -0.17072567f, 0.03509329f, 0.11113124f, 
    0.11500496f, 0.01417567f, 0.14888947f, 0.01464269f, 0.16575375f, 0.13947468f, -0.02721464f, -0.08568173f, 
    0.32950878f, 0.25974134f, 0.00533489f, 0.33635312f, 0.00238860f, -0.28170666f, 0.13880195f, 0.14262740f, 
    -0.20063828f, 0.13508262f, -0.07162887f, -0.25272819f, -0.10385673f, -0.04674381f, -0.07302386f, 0.06104124f, 
    0.07935976f, -0.12943380f, -0.15987527f, -0.18550685f, -0.27168190f, -0.18895963f, -0.33239934f, 0.06649009f, 
    0.25078568f, 0.01207906f, 0.10188860f, -0.12508395f, 0.03268992f, -0.19085352f, -0.34131345f, -0.24841662f, 
    0.17080799f, -0.23087505f, 0.02213604f, -0.05511811f, -0.06585128f, 0.17432895f, -0.23952127f, 0.16681845f, 
    0.10681024f, -0.18018144f, -0.08301647f, 0.23508398f, 0.01834124f, 0.07965677f, -0.07721930f, -0.26794943f, 
    -0.04024348f, -0.07995638f, 0.43266711f, 0.01815797f, 0.07870010f, 0.15688123f, 0.04314329f, -0.06017047f, 
    -0.12251778f, 0.40017766f, -0.27317059f, 0.27951717f, 0.01867263f, -0.08934360f, 0.13182595f, 0.05369076f, 
    -0.02090831f, -0.51536268f, -0.14477484f, -0.40414122f, 0.16597642f, 0.03383322f, 0.18352205f, 0.03203770f, 
    -0.01369469f, 0.06416818f, -0.62483197f, -0.19324870f, 0.00293775f, -0.08912607f, -0.01956762f, -0.11281181f, 
    0.18006542f, -0.16006674f, 0.04462070f, 0.07827279f, 0.39810556f, 0.28328881f, 0.36979446f, 0.21289891f, 
    0.25476506f, -0.02888980f, 0.09437776f, 0.14970416f, 0.11739483f, -0.01568939f, 0.15546845f, 0.12149870f, 
    0.12624204f, 0.09816243f, -0.03287549f, -0.06341661f, -0.12970845f, -0.42608884f, 0.03090256f, 0.11595325f, 
    -0.01868687f, 0.16878556f, -0.05867659f, -0.00976298f, -0.02806415f, 0.07902532f, -0.07177252f, 0.27050588f, 
    0.25238365f, -0.08917035f, -0.05538075f, 0.12807560f, 0.03740565f, 0.15968183f, -0.02985211f, -0.24496730f, 
    0.09833433f, 0.12114162f, -0.01582890f, 0.00159193f, 0.08338954f, 0.09797072f, 0.05214991f, -0.07287923f, 
    -0.10320276f, 0.07341579f, -0.02445382f, -0.27973065f, -0.03822116f, -0.10066879f, 0.03828374f, 0.23338522f, 
    0.01748293f, -0.30983296f, -0.12689847f, -0.30439746f, 0.15699133f, 0.07420063f, 0.15039513f, 0.09354486f, 
    -0.14827260f, 0.03996688f, -0.38878441f, -0.02990275f, 0.01384690f, 0.27114141f, -0.10299605f, 0.06442965f, 
    0.05272120f, -0.17635061f, 0.07398219f, 0.11151937f, -0.11449368f, 0.07885366f, -0.10451067f, -0.15516977f, 
    0.32331550f, 0.11189480f, -0.23864794f, -0.31196067f, 0.06934728f, 0.01397710f, 0.05041606f, 0.23695728f, 
    0.02072748f, 0.03515919f, 0.14213508f, 0.03576575f, 0.02648681f, 0.19558913f, -0.01554948f, -0.51228380f, 
    -0.30983284f, -0.08020463f, -0.15239991f, 0.11609576f, 0.14138371f, -0.10737409f, -0.03189123f, -0.04332617f, 
    -0.26196939f, 0.09490319f, 0.28106055f, 0.02027382f, -0.20987317f, 0.23174010f, 0.28377649f, -0.08527660f, 
    0.33692610f, 0.38969529f, 0.07154959f, 0.23736283f, -0.01038380f, -0.05923583f, -0.09540205f, 0.04111705f, 
    -0.07992884f, 0.21512187f, -0.21913882f, -0.03238440f, 0.04086515f, -0.04464734f, 0.04511630f, -0.09182332f, 
    -0.17596254f, 0.22958429f, 0.15008968f, -0.04849759f, -0.01150741f, 0.13917914f, 0.19467442f, 0.07277354f, 
    0.02780348f, 0.22310966f, -0.55482227f, -0.41399175f, -0.00342078f, 0.07923949f, 0.08529182f, 0.12221959f, 
    -0.10532544f, 0.11288220f, -0.08995416f, -0.71061862f, -0.23037362f, -0.21720995f, 0.14265938f, -0.00633605f, 
    -0.03419707f, 0.01301000f, -0.19130674f, 0.01869814f, 0.17955656f, 0.36752483f, 0.25690746f, -0.28752691f, 
    -0.02019573f, 0.29754028f, 0.12636976f, -0.11647576f, 0.16361910f, -0.28899878f, -0.16830538f, 0.20847110f, 
    0.00386725f, -0.13526608f, -0.03831998f, -0.05169252f, 0.06648775f, -0.04369702f, -0.26713744f, 0.12801538f, 
    0.29465863f, 0.22565800f, 0.00179880f, -0.07744604f, -0.04628581f, -0.13895187f, -0.03160128f, 0.10185619f, 
    0.05906184f, -0.15992816f, 0.01291798f, 0.02786973f, -0.01068005f, 0.33145010f, 0.09890850f, 0.01217057f, 
    0.16315997f, 0.16142258f, -0.03933566f, 0.00222257f, -0.11841399f, -0.02727041f, -0.14398444f, 0.21650299f, 
    0.13171425f, 0.39921889f, 0.11785281f, 0.17285025f, -0.15879261f, 0.05801380f, -0.06803551f, 0.07007727f, 
    0.08602356f, 0.00665086f, -0.04208608f, 0.15067758f, 0.07012505f, -0.32295635f, 0.02788525f, 0.02577800f, 
    0.19364648f, 0.02539060f, 0.09111143f, -0.14118582f, -0.18421753f, -0.07285293f, -0.17818925f, 0.09087649f, 
    -0.00186370f, -0.09480254f, 0.19766270f, -0.12978269f, -0.15252197f, 0.14489792f, 0.15949538f, -0.05480602f, 
    -0.08146638f, 0.20989133f, 0.31779611f, 0.01438982f, -0.06188598f, 0.18181193f, -0.28770134f, -0.01338083f, 
    0.11470024f, -0.19286102f, 0.14425227f, -0.09769893f, 0.10962050f, -0.07690059f, -0.31874752f, 0.25867540f, 
    0.15496030f, 0.13080038f, 0.16016948f, -0.25231829f, 0.02471284f, 0.12987487f, 0.09195607f, -0.03440832f, 
    0.00792602f, 0.10092750f, 0.05833545f, 0.10516214f, -0.17816730f, -0.12572983f, -0.14099623f, -0.10848619f, 
    -0.05080220f, -0.08241371f, -0.10383090f, -0.09336471f, 0.21834202f, 0.08872936f, -0.25030178f, -0.07773950f, 
    -0.07574255f, 0.05968050f, -0.07267815f, -0.06009933f, -0.00503531f, 0.08359919f, 0.12960052f, 0.17114136f, 
    0.10658596f, 0.19005278f, -0.17010307f, -0.09454405f, 0.30462310f, -0.09896477f, -0.05715396f, -0.03084687f, 
    0.07210679f, 0.06034157f, -0.10192598f, -0.34743211f, 0.09290960f, -0.08896593f, 0.02972212f, -0.03475283f, 
    0.08243194f, 0.11949694f, -0.10242343f, -0.16777651f, 0.17894450f, -0.28075382f, -0.07155880f, -0.08778858f, 
    0.06768530f, 0.16642268f, 0.22152026f, -0.07218856f, -0.04514094f, -0.01002770f, -0.00038683f, 0.20313513f, 
    -0.01211652f, 0.12159041f, -0.00977252f, 0.06766432f, -0.05864441f, 0.08011235f, -0.16309179f, 0.04802696f, 
    0.03963762f, 0.06842665f, 0.05195217f, 0.04595556f, 0.24657719f, 0.00853264f, -0.42298654f, -0.15889046f, 
    0.00364921f, -0.20506532f, 0.09220815f, 0.13123247f, 0.08103539f, -0.12230466f, 0.09429355f, -0.05865258f, 
    0.05975191f, 0.03759493f, -0.17262162f, -0.00823874f, 0.11665231f, 0.08937873f, -0.09120743f, 0.02466334f, 
    0.12268902f, 0.16252817f, 0.00154609f, -0.11695217f, 0.09458730f, -0.08330597f, 0.11930513f, 0.33822453f, 
    0.02437110f, -0.06216495f, -0.10850763f, -0.09436834f, 0.05279311f, 0.06684320f, -0.14430560f, -0.07109028f, 
    0.07876382f, -0.16411556f, -0.18964893f, 0.04491715f, -0.06479103f, -0.09744774f, -0.48173007f, 0.05206424f, 
    0.05038324f, 0.00090031f, 0.11918049f, -0.21275826f, -0.20816664f, 0.05143562f, 0.00434486f, 0.00848985f, 
    -0.06350925f, 0.11214705f, 0.03644120f, 0.04150082f, -0.20787247f, -0.06699620f, 0.11438147f, 0.12101448f, 
    -0.05504701f, 0.09689876f, -0.14712818f, 0.02444595f, 0.17353058f, -0.06861356f, -0.06977909f, 0.20388554f, 
    -0.04296302f, 0.06410067f, -0.09141840f, 0.10662609f, -0.16966805f, -0.04616275f, 0.39666331f, -0.50901824f, 
    0.11895192f, 0.29565901f, 0.13914675f, 0.13411950f, -0.00015966f, 0.09997961f, -0.22720915f, 0.16026409f, 
    -0.00700494f, 0.19274315f, 0.11367647f, -0.07928179f, -0.04568044f, -0.04424139f, -0.01781075f, 0.02274071f, 
    0.04742486f, -0.22688168f, 0.09991352f, -0.02756235f, 0.13211904f, 0.13919841f, -0.17907144f, 0.02931382f, 
    -0.09532376f, -0.01492855f, -0.21071737f, 0.27926788f, 0.10749811f, 0.01208680f, -0.14106977f, -0.07150228f, 
    -0.17556730f, 0.10091151f, -0.01372999f, 0.00242192f, 0.10102995f, 0.01192157f, 0.10915893f, -0.00216747f, 
    -0.05286643f, -0.12478571f, -0.18993412f, -0.05709942f, -0.37926233f, 0.03012631f, 0.15967663f, -0.04898241f, 
    -0.11150671f, -0.16003563f, -0.10161112f, -0.09296535f, 0.03028090f, -0.00563848f, -0.07083935f, -0.29192239f, 
    0.07292975f, 0.15354778f, 0.01811036f, 0.05993754f, 0.08481444f, 0.06605234f, -0.12579954f, -0.07937339f, 
    -0.17152525f, 0.09361736f, 0.03614901f, 0.11305394f, 0.13162221f, 0.11203533f, -0.05095257f, 0.22200915f, 
    0.05494078f, -0.14906009f, -0.15407695f, 0.12051180f, 0.00925106f, 0.27539936f, -0.12990239f, -0.01898076f, 
    0.05244070f, -0.31298339f, -0.09859274f, 0.19642779f, -0.11584096f, -0.01192124f, 0.12113324f, 0.03217815f, 
    0.08179785f, -0.35329461f, -0.45672747f, -0.23090902f, -0.02284599f, -0.02981834f, 0.02745250f, -0.00856236f, 
    -0.05875200f, 0.11018617f, 0.02264619f, -0.03601918f, -0.10345871f, 0.10203753f, -0.10221890f, 0.07973653f, 
    0.01503241f, 0.12699148f, -0.19570744f, 0.14432862f, -0.00508243f, 0.25244212f, 0.20890963f, -0.12132973f, 
    -0.05840098f, 0.19311054f, -0.05156123f, 0.11922026f, -0.27763543f, 0.29143408f, -0.02972859f, 0.16841820f, 
    -0.21556793f, -0.03162550f, 0.03040786f, 0.07286848f, 0.21358526f, -0.27764371f, 0.04072975f, -0.16120028f, 
    -0.16434906f, 0.10029738f, -0.04837236f, 0.03630715f, -0.10093349f, 0.01914017f, 0.36449528f, 0.03839684f, 
    -0.24105999f, -0.08502772f, 0.21662518f, 0.07548866f, 0.06889602f, -0.12064636f, -0.06111155f, -0.17898969f, 
    0.29775742f, -0.32741222f, -0.03559588f, -0.02919573f, 0.00138672f, -0.19741796f, 0.04402760f, -0.05445439f, 
    0.43304327f, 0.22933879f, -0.24411803f, -0.08131824f, 0.07230348f, -0.19483849f, 0.12439797f, 0.13644060f, 
    0.02911885f, 0.12375087f, 0.28740859f, -0.05098667f, 0.05809268f, 0.18314445f, -0.02438034f, -0.08937217f, 
    0.23083778f, -0.08908134f, -0.37909374f, -0.00377020f, -0.41248202f, -0.09462883f, 0.09795769f, -0.13875465f, 
    0.00025745f, -0.00588266f, -0.14222349f, 0.02032478f, 0.15076903f, 0.09118340f, 0.15302132f, -0.03243371f, 
    0.09262326f, 0.05885309f, -0.09838120f, 0.12140384f, -0.28820360f, -0.03744863f, 0.04350610f, -0.04317098f, 
    0.10492046f, -0.05590694f, -0.10800440f, -0.00224129f, -0.17768312f, -0.04855673f, -0.24889281f, -0.18303156f, 
    -0.14832520f, 0.01135481f, -0.09057662f, 0.04564852f, 0.18792655f, -0.04961249f, 0.25784096f, -0.00909370f, 
    -0.13038224f, 0.15436473f, -0.12837239f, 0.00552670f, 0.11558482f, 0.17165749f, -0.12579256f, -0.09312388f, 
    0.16597030f, 0.16293123f, 0.15078600f, -0.14749222f, -0.07876597f, 0.07755136f, 0.06494668f, 0.12108057f, 
    0.29518446f, -0.31156904f, 0.00645696f, 0.06604027f, -0.07979763f, 0.15170762f, 0.06959230f, 0.17870697f, 
    0.17843108f, -0.18724541f, 0.05779096f, -0.07253157f, -0.01463744f, 0.11485702f, 0.12526800f, -0.12889004f, 
    0.16304694f, -0.03016036f, -0.05236191f, 0.25423703f, -0.05679775f, 0.07809975f, 0.23528990f, -0.08729864f, 
    -0.10117605f, 0.01733917f, 0.08437779f, -0.47563085f, 0.11430424f, -0.15788068f, 0.12614416f, 0.11211899f, 
    0.08325258f, 0.05830761f, 0.19875386f, -0.04661108f, 0.03920641f, 0.10701012f, 0.04870446f, -0.15309797f, 
    -0.00344818f, -0.13500173f, 0.04764149f, -0.03514226f, 0.15196224f, -0.08001414f, 0.03440725f, -0.27194855f, 
    0.21291821f, -0.13252991f, 0.07371637f, 0.14203358f, 0.08710621f, -0.06639770f, -0.22763139f, -0.04309886f, 
    0.08910023f, -0.02559195f, -0.17640598f, 0.10454774f, 0.12423553f, -0.04322771f, 0.15172555f, 0.53927159f, 
    0.04559069f, -0.06885384f, 0.12457147f, -0.04606046f, 0.07524209f, -0.04314112f, -0.11912230f, 0.03917384f, 
    0.02246081f, 0.18562411f, -0.43419623f, 0.14624031f, -0.04260901f, 0.12721421f, -0.03538492f, 0.03712922f, 
    -0.07297236f, 0.12138642f, -0.13030003f, -0.15154746f, 0.05823117f, -0.07275325f, 0.13905273f, -0.00735487f, 
    -0.13575488f, -0.23553933f, 0.05793944f, -0.04924002f, -0.30619964f, -0.05462361f, 0.01045188f, 0.06920560f, 
    0.05716868f, 0.07620292f, 0.01193360f, 0.11769719f, 0.50083739f, 0.11336613f, 0.02817700f, 0.13830830f, 
    -0.07602677f, 0.16768984f, 0.12809783f, 0.19525762f, 0.60149705f, -0.09214639f, -0.10550854f, -0.01424644f, 
    0.00969361f, 0.30448180f, 0.03761144f, -0.15193991f, -0.07036439f, 0.16537638f, -0.32610759f, -0.09198326f, 
    0.04085646f, 0.08164685f, 0.02229152f, 0.09369283f, -0.14648418f, -0.01693487f, 0.10824571f, -0.30533126f, 
    0.09878231f, -0.13083261f, -0.06203774f, -0.19810550f, 0.12532248f, 0.09619126f, -0.04338878f, -0.30790189f, 
    -0.02118492f, -0.04961730f, -0.21016744f, 0.06491061f, 0.03450099f, -0.13417177f, 0.09326279f, -0.03419550f, 
    0.24756970f, 0.03501645f, 0.22874728f, 0.15780646f, 0.12703332f, -0.20370391f, 0.09392297f, -0.02415374f, 
    0.02001191f, 0.24809016f, 0.00899712f, -0.13016962f, 0.10860737f, -0.14068235f, 0.10093747f, 0.20266908f, 
    -0.02322664f, -0.11504411f, -0.38381961f, 0.14148255f, -0.29782060f, 0.25711247f, 0.18058260f, 0.17726699f, 
    -0.07963973f, 0.11394134f, 0.11526618f, -0.24361415f, -0.25037220f, -0.07964042f, -0.05958406f, 0.06136261f, 
    0.23995665f, 0.09302901f, -0.16213909f, -0.10355962f, 0.19538826f, -0.11545765f, -0.02404014f, -0.15267529f, 
    0.21459603f, -0.09563196f, -0.05372988f, 0.17097682f, 0.15000054f, 0.40616891f, 0.36607659f, -0.32826594f, 
    -0.41581509f, 0.21074797f, 0.03782971f, -0.04780796f, 0.00172390f, 0.29052579f, -0.05341871f, 0.10892861f, 
    0.05407816f, 0.21836503f, 0.27745852f, -0.07267430f, 0.10873019f, -0.08200077f, -0.08578991f, 0.19986716f, 
    -0.14417429f, -0.19145148f, -0.24922329f, 0.03348716f, 0.02886321f, -0.00731846f, -0.04618494f, 0.26808497f, 
    -0.02806524f, -0.22591446f, 0.20016582f, 0.00779159f, 0.13981307f, -0.05848514f, -0.02787811f, -0.15291111f, 
    0.08415250f, 0.23885272f, -0.11346846f, -0.10499599f, -0.15885818f, -0.00699965f, -0.23815820f, 0.04875176f, 
    -0.24000776f, 0.02617054f, -0.15419389f, -0.15784894f, -0.19371121f, -0.19830886f, 0.26326621f, -0.02476862f, 
    -0.04045230f, 0.01161880f, 0.00458712f, -0.04777339f, -0.11768151f, -0.08929485f, 0.08087233f, -0.16640486f, 
    0.21297543f, -0.09580778f, 0.03292548f, -0.00916729f, 0.50489962f, 0.38939062f, 0.11623523f, -0.02463679f, 
    -0.04936848f, -0.00613372f, 0.07902189f, -0.10611926f, 0.32657263f, 0.16955712f, -0.26226455f, -0.02000045f, 
    0.10220981f, -0.06751039f, -0.16036852f, -0.06691930f, 0.05355200f, 0.03193142f, -0.27706680f, -0.20231588f, 
    -0.37674570f, 0.07573993f, 0.10352886f, 0.27963722f, -0.29320052f, 0.16383921f, 0.15821707f, -0.32146871f, 
    0.01233100f, 0.11745039f, 0.10113628f, 0.05005709f, 0.13173704f, 0.11997014f, -0.02545501f, -0.04809834f, 
    0.32289127f, 0.10832192f, 0.02310690f, -0.03589263f, 0.07670873f, -0.07292251f, 0.11235203f, 0.05148028f, 
    0.00405575f, 0.35504696f, 0.10992378f, -0.07511234f, -0.05566861f, -0.26814640f, -0.23050484f, 0.09477470f, 
    -0.26565924f, 0.21014696f, 0.14281040f, 0.26065117f, 0.16200775f, 0.01489929f, 0.04802672f, -0.06403381f, 
    -0.02661879f, 0.03790161f, 0.30521414f, -0.14938626f, -0.09919351f, -0.21581522f, 0.08365281f, -0.09041338f, 
    0.25559685f, 0.00423434f, -0.06060383f, 0.10735918f, 0.02861208f, -0.08761625f, -0.67934644f, 0.25497144f, 
    -0.04540416f, 0.15505652f, 0.19832520f, 0.12191080f, 0.13300315f, 0.38208508f, 0.03666438f, -0.02489890f, 
    0.02010138f, 0.10508758f, 0.19539590f, 0.19760454f, 0.04644417f, 0.08347879f, 0.07693398f, -0.25884682f, 
    0.00942366f, -0.09365435f, -0.17990023f, -0.00296217f, 0.10220131f, 0.07015369f, -0.08413376f, -0.26551929f, 
    0.19573963f, -0.07875814f, 0.17734869f, 0.15944807f, 0.05184114f, -0.04442635f, -0.06308898f, -0.03384297f, 
    0.26401705f, -0.05811888f, -0.27617326f, 0.01244904f, -0.04130043f, -0.06327603f, 0.04155612f, 0.25544882f, 
    0.06730965f, 0.38884035f, 0.39750886f, -0.03626265f, -0.03653595f, 0.15220588f, 0.06265381f, -0.08896432f, 
    0.03591207f, -0.02295139f, -0.09559535f, -0.10517887f, 0.04733735f, 0.13479659f, -0.15828705f, -0.10068182f, 
    0.04616510f, -0.07549545f, 0.07097661f, 0.25076190f, -0.01571733f, 0.27118322f, -0.04834941f, -0.10824178f, 
    -0.05852406f, -0.17800914f, 0.04407169f, -0.05429090f, 0.09575412f, 0.21906915f, -0.03608630f, 0.21311487f, 
    0.23838805f, -0.10824961f, -0.08632127f, -0.03728660f, 0.00519260f, -0.18650047f, 0.11087789f, -0.26254401f, 
    0.21222745f, 0.19671755f, 0.00061864f, 0.21217722f, 0.06930487f, 0.00398676f, -0.09895109f, -0.16595681f, 
    -0.09996998f, 0.20770031f, -0.01775611f, 0.18936214f, -0.10381481f, -0.06947083f, 0.26388007f, -0.17619376f, 
    -0.19071633f, -0.11068089f, 0.13067378f, -0.19989745f, -0.15914968f, 0.03813807f, 0.02144985f, -0.00101159f, 
    -0.01225131f, -0.03081791f, -0.03451217f, -0.06261597f, 0.03522897f, -0.00998282f, 0.03182926f, -0.02995000f, 
    0.00970732f, 0.04130469f, -0.01550282f, 0.04155985f, 0.01648773f, 0.03928072f, -0.05209063f, 0.01978745f, 
    -0.05165126f, 0.01936266f, -0.06004566f, -0.04667066f, -0.01182488f, -0.04044291f, 0.02839203f, 0.02048905f, 
    0.04293967f, 0.00797674f, 0.03805154f, -0.02197451f, 0.00109613f, -0.03151371f, -0.03569725f, -0.05910475f, 
    -0.05929040f, -0.02485679f, 0.02718134f, -0.00822625f, 0.00320578f, 0.01413817f, 0.01071001f, -0.06267526f, 
    -0.05482844f, -0.01014442f, -0.03803337f, -0.00049199f, -0.00866906f, 0.04680103f, -0.04953767f, -0.03623649f, 
    -0.00911986f, 0.01344422f, -0.05634306f, 0.04802687f, 0.02434416f, -0.05959919f, 0.00284234f, 0.02561181f, 
    0.02086100f, 0.02989499f, -0.01595966f, 0.02112102f, 0.05153960f, -0.03237267f, -0.00330248f, 0.00304290f, 
    0.05134755f, 0.03848139f, -0.05476321f, -0.04613603f, -0.00106641f, -0.01879245f, -0.03496072f, -0.02842425f, 
    0.01107325f, 0.01861861f, 0.01856015f, -0.00547142f, 0.02743537f, 0.00423230f, -0.05547021f, -0.02683692f, 
    0.03583672f, -0.05639841f, -0.04016912f, 0.00401774f, -0.03919594f, 0.03896331f, -0.03814750f, 0.01161725f, 
    0.02946909f, -0.06411429f, 0.04544955f, -0.02001094f, 0.01939219f, -0.06272678f, 0.02548095f, -0.05466666f, 
    -0.00510194f, 0.03343401f, -0.04291269f, 0.02376340f, -0.02574888f, 0.04145988f, 0.03688250f, -0.02196216f, 
    -0.00825861f, -0.05137293f, -0.03573491f, -0.02971549f, -0.04598195f, -0.03542473f, 0.02687705f, -0.05061891f, 
    0.02840958f, 0.00694596f, 0.05259214f, 0.00459833f, 0.04600644f, 0.01787837f, -0.03790917f, -0.06209455f, 
    -0.04582435f, 0.01568496f, 0.00205510f, -0.06239758f, -0.04520893f, 0.04829059f, 0.03784551f, 0.01187283f, 
    0.02900672f, 0.02054390f, 0.04324573f, -0.04872214f, 0.02169763f, -0.01007155f, 0.00336090f, -0.00016400f, 
    0.04502477f, -0.05787417f, -0.02625816f, -0.05847568f, 0.04150898f, 0.04360786f, 0.00673500f, -0.00974393f, 
    -0.06011325f, -0.03643179f, -0.05655094f, -0.03491669f, -0.00148328f, 0.02822127f, -0.06541760f, -0.02134397f, 
    -0.02435027f, 0.04105652f, 0.01028751f, -0.02550131f, -0.00579923f, -0.03455355f, 0.03118595f, -0.02009220f, 
    -0.01759067f, 0.03667041f, 0.02989389f, -0.02031787f, 0.01674264f, 0.03858382f, -0.01145816f, -0.00123385f, 
    0.03568947f, -0.04741458f, -0.02912628f, 0.01272466f, -0.01170678f, 0.00850166f, -0.03024804f, 0.01745526f, 
    -0.03471648f, -0.02077124f, -0.03218385f, 0.04901966f, -0.01958714f, 0.03683277f, -0.00282251f, 0.04820041f, 
    0.02609072f, 0.04784736f, 0.01647042f, 0.01252583f, -0.03014197f, 0.02527480f, -0.00370331f, 0.01975940f, 
    -0.05719964f, -0.01933596f, -0.02149586f, -0.03420522f, -0.02477347f, 0.04655667f, 0.04254241f, 0.03601497f, 
    -0.01434633f, 0.01966504f, -0.05109624f, 0.03304188f, 0.01048496f, 0.02886426f, -0.02429062f, 0.00365078f, 
    -0.03288236f, 0.02731451f, 0.00314343f, -0.04835547f, 0.01822519f, -0.05764313f, -0.03621947f, -0.00292601f, 
    -0.06588046f, -0.01946707f, 0.00996521f, 0.01732893f, -0.04313865f, -0.02242234f, -0.01771489f, -0.04019532f, 
    0.02325550f, 0.04481225f, -0.06187012f, -0.05195262f, 0.04962436f, -0.03260627f, -0.03667228f, -0.06396516f, 
    -0.02711679f, -0.01381835f, 0.04441665f, -0.06109710f, -0.04142826f, -0.04641952f, 0.02968665f, -0.02118474f, 
    -0.02437026f, 0.04552345f, 0.03071848f, 0.03514858f, -0.04739406f, -0.03920143f, -0.02801878f, 0.03768114f, 
    -0.03143061f, 0.05022300f, -0.02778526f, -0.01538044f, 0.00124881f, 0.04757252f, 0.01503155f, 0.01033252f, 
    0.03089633f, 0.04065940f, -0.03943142f, -0.05506972f, 0.01855131f, -0.01608642f, 0.01162974f, 0.02073275f, 
    -0.06589232f, 0.03915919f, 0.01153419f, -0.05635907f, 0.01563330f, -0.05913398f, -0.02649603f, -0.05816269f, 
    -0.02542053f, -0.00058025f, 0.01599665f, -0.05082535f, -0.03486745f, -0.00842898f, 0.00585062f, -0.00478765f, 
    -0.01853822f, -0.02809141f, -0.01577490f, -0.03526996f, -0.03771972f, -0.02198362f, -0.05752911f, -0.05997488f, 
    -0.05187730f, -0.01402419f, 0.03109406f, -0.05325354f, -0.05437230f, -0.03632993f, 0.04541866f, 0.01552254f, 
    0.00040808f, -0.00482298f, -0.06249834f, 0.02862828f, 0.03656052f, -0.02771723f, -0.03475162f, -0.01569721f, 
    -0.00507255f, -0.04644345f, -0.03519854f, 0.04177982f, -0.04587885f, 0.04967217f, 0.04435148f, -0.06575201f, 
    -0.04598081f, 0.01029456f, 0.04245486f, -0.00274683f, 0.00576451f, -0.00264952f, 0.03140027f, 0.06073132f, 
    -0.01868493f, 0.04680546f, -0.01193656f, -0.05728890f, -0.00642480f, 0.02030549f, 0.05555454f, -0.01742295f, 
    -0.01314162f, -0.01356495f, 0.05304369f, -0.04995040f, 0.04913355f, 0.00858743f, -0.06245986f, -0.00902484f, 
    -0.04240854f, -0.05531066f, 0.00073895f, -0.03610689f, -0.01131967f, 0.01384392f, 0.03738061f, 0.00824052f, 
    -0.00880050f, -0.01156008f, -0.04434210f, -0.03395976f, -0.04110691f, -0.05560412f, -0.00820672f, 0.03277718f, 
    -0.00109154f, 0.03550167f, 0.01453505f, 0.01917483f, 0.06095489f, -0.01314797f, 0.00551078f, -0.05685960f, 
    -0.02706345f, 0.04132569f, -0.04820634f, -0.04557437f, 0.00114776f, 0.02781194f, 0.05069114f, 0.05202784f, 
    0.00802015f, 0.00174758f, -0.02432681f, 0.01133821f, 0.04675335f, 0.04702364f, -0.02048113f, -0.06507789f, 
    -0.02698400f, -0.03542895f, 0.01801437f, 0.03769353f, 0.01780245f, 0.00025860f, -0.06300118f, -0.06529376f, 
    0.03367808f, -0.00268501f, 0.03378623f, 0.04102523f, -0.06236916f, 0.00489111f, -0.03447169f, 0.04009715f, 
    0.02614912f, 0.01357980f, 0.03920348f, -0.04793707f, -0.02478334f, -0.04317024f, -0.05752838f, -0.02769462f, 
    0.00755329f, 0.03513039f, 0.04063031f, -0.05158278f, -0.00388758f, 0.02239994f, -0.05680775f, -0.02306556f, 
    -0.00480968f, -0.06635179f, -0.00205129f, -0.01052028f, -0.02104305f, 0.04552553f, -0.05873437f, -0.01124966f, 
    -0.04707332f, 0.03790018f, -0.01515339f, -0.05761514f, -0.05059031f, 0.02050529f, -0.01691041f, -0.03641087f, 
    -0.03100224f, 0.05006186f, -0.01739651f, -0.01571721f, -0.03825834f, -0.00478621f, -0.04798573f, 0.00665780f, 
    -0.00150313f, -0.02328784f, 0.03703779f, -0.02026364f, 0.00769831f, 0.05270238f, 0.03841125f, -0.01730478f, 
    -0.03046905f, 0.00424155f, -0.04238710f, -0.02464085f, 0.01811538f, 0.00947814f, 0.01533803f, -0.00930559f, 
    -0.05245176f, -0.06095809f, -0.03827963f, -0.02561515f, -0.03770522f, 0.00823554f, -0.02268493f, -0.04256661f, 
    0.05036679f, -0.00255956f, 0.01146266f, -0.06066846f, -0.00719920f, 0.04061114f, -0.02781080f, -0.01322980f, 
    -0.01140060f, -0.00334278f, -0.02407168f, 0.01597579f, 0.00336085f, -0.01328389f, -0.05613297f, -0.03035649f, 
    -0.06049774f, -0.00013657f, -0.00650812f, 0.00764672f, -0.02842610f, -0.00880345f, -0.03930023f, 0.01347057f, 
    -0.01729112f, 0.01766260f, -0.05351294f, 0.01670531f, -0.00072113f, -0.00293636f, -0.00006384f, -0.00926134f, 
    -0.00320476f, -0.03693537f, -0.04103892f, -0.04456296f, -0.04663671f, 0.01496590f, -0.02409377f, 0.03539748f, 
    -0.03904036f, 0.02283817f, 0.04708475f, -0.02357312f, 0.05691626f, -0.02803741f, 0.04834136f, -0.05303285f, 
    0.00367390f, -0.02335432f, -0.00201315f, -0.02196465f, 0.01277042f, -0.06522840f, 0.03647332f, -0.03402545f, 
    -0.02710115f, -0.02260047f, 0.02421038f, 0.00114806f, 0.04105160f, -0.04559823f, -0.05538652f, 0.02616316f, 
    -0.05348522f, -0.02783897f, 0.04941690f, 0.02760866f, -0.01538978f, 0.05804475f, -0.06386358f, -0.01824771f, 
    -0.03222197f, -0.03572385f, -0.00673153f, -0.04785064f, -0.03671989f, -0.03642717f, 0.01380186f, 0.05067561f, 
    0.02999174f, -0.02631925f, -0.02011810f, -0.03686652f, 0.01603591f, 0.05313681f, -0.02612130f, -0.05323468f, 
    -0.03761779f, -0.04642649f, -0.00496634f, 0.04044412f, -0.04699975f, -0.06244856f, -0.01990395f, 0.00913525f, 
    0.04240857f, 0.04905448f, 0.03505677f, -0.03221738f, -0.03406347f, 0.04927611f, 0.02585323f, 0.04048061f, 
    0.02518305f, -0.04184854f, 0.05081644f, 0.03644408f, 0.01138797f, -0.02925428f, 0.01506819f, -0.04852783f, 
    -0.00103749f, 0.03238710f, -0.05118813f, 0.01008394f, 0.04334175f, -0.06506354f, 0.01101404f, -0.00943173f, 
    -0.02680234f, 0.04843117f, -0.00798152f, 0.03110779f, -0.02609299f, -0.02922361f, -0.03045251f, 0.01629006f, 
    -0.00325215f, -0.06828598f, -0.03108905f, -0.02607111f, 0.02539618f, -0.06133733f, -0.02896164f, 0.04999420f, 
    0.02966509f, -0.05958084f, -0.02957079f, -0.01428130f, 0.04009899f, -0.00297559f, 0.01345343f, -0.03290109f, 
    0.04629713f, -0.04289003f, -0.02123525f, 0.03608855f, -0.05609761f, -0.02515090f, 0.00560233f, -0.05424857f, 
    0.04327758f, 0.01561235f, 0.02797781f, -0.05579368f, -0.04701879f, 0.01587574f, -0.00299444f, -0.04715680f, 
    -0.02924800f, 0.04120583f, -0.03679363f, 0.04019726f, 0.01119635f, -0.02242489f, -0.03966779f, 0.01065396f, 
    -0.06039420f, 0.00851236f, -0.00410523f, -0.04958270f, 0.02945259f, -0.04976811f, -0.03386091f, 0.00030109f, 
    0.00331019f, -0.01895283f, 0.01968304f, -0.04712545f, -0.01248703f, -0.03899108f, -0.05532181f, -0.05104884f, 
    -0.03487027f, -0.04181825f, -0.00208885f, -0.01596996f, -0.04016453f, -0.04433075f, -0.06453477f, 0.01646383f, 
    0.04522343f, 0.03082469f, 0.04596346f, 0.04668465f, 0.03388030f, 0.03632547f, -0.02805737f, -0.06323804f, 
    -0.01677774f, 0.02074433f, 0.02831599f, -0.01626470f, -0.00385843f, 0.03519177f, 0.01029978f, -0.00568739f, 
    0.04399409f, -0.06002700f, -0.06578124f, 0.00996312f, -0.02592474f, 0.01726483f, 0.01599876f, -0.05558991f, 
    -0.04155677f, 0.00140568f, 0.03494182f, -0.04345503f, -0.04966874f, 0.02330050f, -0.03210192f, 0.02619519f, 
    -0.00780931f, 0.02214850f, -0.03829244f, 0.02177150f, 0.02359713f, -0.02349449f, 0.02271896f, -0.06669511f, 
    0.03156060f, 0.03706084f, 0.02910727f, -0.05037299f, 0.03174954f, -0.05372665f, -0.04846691f, -0.01661992f, 
    -0.03731083f, 0.04560092f, 0.03272120f, -0.00665852f, 0.04964541f, 0.02952138f, 0.04455764f, 0.00898075f, 
    -0.01518561f, 0.03923026f, 0.00690590f, 0.02417114f, -0.02515946f, -0.05583571f, 0.01370898f, -0.06046864f, 
    0.01172625f, 0.02534634f, 0.01088736f, -0.05626901f, 0.04161260f, 0.02072246f, -0.02610289f, 0.04722358f, 
    0.03383382f, -0.05962006f, -0.02750487f, 0.00993087f, -0.04314819f, -0.00501185f, 0.01978173f, 0.01894076f, 
    -0.02448962f, 0.02765055f, 0.03017725f, -0.00908441f, -0.03125458f, 0.01519825f, -0.01621637f, -0.04897241f, 
    -0.01673270f, 0.02759668f, 0.02581507f, 0.02612659f, 0.00995386f, 0.03817987f, -0.06220604f, 0.04400035f, 
    -0.01555386f, -0.02224462f, -0.04683384f, -0.02298613f, -0.04869080f, -0.03892479f, 0.03595340f, 0.02573137f, 
    0.01037890f, 0.04963548f, 0.00413238f, -0.01365040f, 0.04337002f, 0.01299110f, -0.04871029f, 0.01249157f, 
    0.05134450f, -0.00044182f, -0.06578516f, -0.02933816f, -0.01107570f, -0.04499317f, 0.03639131f, -0.04095589f, 
    -0.04225929f, -0.02285652f, 0.01286973f, -0.04489392f, 0.00864450f, -0.01820226f, -0.06791722f, 0.04325080f, 
    -0.01991344f, 0.00484548f, 0.02240042f, 0.05222011f, -0.03757617f, -0.02970466f, -0.06645475f, -0.01333789f, 
    -0.03091273f, -0.02982998f, 0.03243150f, 0.05343000f, 0.04865809f, -0.05103302f, -0.01436769f, 0.01271709f, 
    0.03830805f, 0.04098633f, -0.03600096f, -0.03819439f, -0.00119528f, -0.02104007f, -0.02860679f, 0.01710634f, 
    -0.00211928f, -0.04651250f, -0.05597550f, -0.03573389f, 0.01492256f, 0.00603494f, -0.06700650f, -0.01980241f, 
    -0.01920922f, 0.00837836f, 0.02342730f, -0.01662844f, -0.05110133f, 0.00017987f, -0.02453176f, -0.05816486f, 
    0.00926884f, -0.05263500f, -0.05694039f, 0.05282253f, 0.00915232f, -0.03245434f, -0.06293938f, 0.03356144f, 
    0.04050281f, -0.00045117f, 0.01208882f, 0.01394688f, -0.04085966f, 0.01088764f, 0.04811760f, -0.00945350f, 
    -0.00600675f, 0.03084780f, -0.01635407f, 0.00369818f, 0.05401416f, -0.05122211f, 0.02279558f, 0.03986229f, 
    -0.01218223f, -0.05391661f, -0.05884694f, -0.01135942f, 0.02179798f, -0.05603500f, -0.04717905f, 0.01382357f, 
    -0.01763752f, -0.01001388f, -0.03095644f, -0.00672620f, 0.04717935f, 0.02889013f, -0.01415418f, 0.04119711f, 
    -0.06349161f, -0.01886478f, -0.02350182f, -0.02968947f, -0.02652725f, -0.04112787f, -0.00438351f, -0.01158660f, 
    0.26132175f, -0.10138619f, 0.04292687f, -0.03465671f, 0.04819946f, -0.04007552f, 0.08265518f, -0.01971150f, 
    0.12315434f, 0.02987140f, -0.07912216f, 0.17478159f, -0.10632081f, 0.08120801f, -0.18831301f, -0.11751916f, 
    -0.14458372f, 0.07674377f, -0.03963248f, 0.10004845f, 0.05509302f, -0.13438664f, -0.14623496f, 0.17777307f, 
    0.18088602f, 0.18900232f, 0.02941889f, 0.31708223f, 0.16611481f, -0.04365274f, -0.04764612f, -0.01755638f, 
    0.28375533f, -0.20554772f, -0.08556841f, -0.10269972f, 0.15230377f, 0.38629538f, -0.25777179f, -0.09561292f, 
    0.08183748f, -0.14691128f, -0.13225614f, 0.13427515f, 0.18793152f, -0.33458960f, -0.27090305f, 0.06740305f, 
    0.05781309f, 0.19007823f, -0.27539301f, 0.04001486f, -0.05167383f, 0.15932006f, -0.30326185f, 0.05023174f, 
    0.22317497f, -0.07032154f, -0.10095266f, 0.02650786f, 0.18956892f, 0.24342662f, 0.14498341f, -0.47667465f, 
    -0.11014827f, 0.03544796f, 0.20415066f, 0.17790973f, -0.11371861f, -0.13634849f, -0.04526352f, 0.11905471f, 
    0.09223742f, 0.09533258f, -0.15801293f, 0.27050245f, 0.22271466f, -0.13639846f, 0.09060154f, -0.08782919f, 
    0.14610672f, 0.11275131f, 0.36212760f, 0.12803751f, -0.02209247f, 0.14334773f, -0.07212253f, 0.07226666f, 
    -0.17387620f, 0.13472930f, 0.21234943f, -0.10640537f, -0.05079975f, 0.03991016f, -0.19205591f, 0.05854103f, 
    -0.29200542f, -0.07715704f, -0.06793946f, 0.01195300f, 0.05621529f, 0.00808274f, -0.29158095f, 0.01089188f, 
    -0.04345197f, 0.05579492f, 0.04991993f, -0.25468647f, -0.06062556f, 0.15439130f, 0.11423323f, 0.07058897f, 
    -0.05835582f, -0.07572319f, -0.07588601f, -0.02993187f, -0.02379512f, 0.48838300f, 0.06136269f, 0.27644739f, 
    -0.36395237f, -0.04187508f, 0.05345142f, 0.08132279f, -0.06783426f, 0.06926967f, -0.13670710f, -0.05636589f, 
    -0.23601720f, -0.18507105f, 0.17919868f, -0.02417472f, 0.15114485f, 0.22549030f, -0.13458548f, 0.03851840f, 
    0.07707265f, 0.01621355f, -0.24939859f, 0.03247527f, -0.03846241f, -0.06926923f, 0.06923337f, -0.14586760f, 
    0.19734877f, -0.06391618f, -0.04645123f, 0.00876160f, 0.05312772f, 0.01772010f, -0.08048610f, -0.08519262f, 
    -0.06440519f, 0.07397588f, 0.27002811f, 0.10173919f, 0.09044941f, 0.01275627f, 0.11984896f, -0.20620707f, 
    -0.20885529f, 0.08282157f, -0.27927014f, 0.10197850f, -0.09513430f, 0.04146264f, -0.13521543f, -0.07484083f, 
    -0.10678054f, 0.14430368f, -0.00747715f, -0.11786633f, -0.02921185f, 0.12730680f, -0.16309491f, -0.03394619f, 
    0.13245957f, -0.06163688f, 0.27747014f, 0.20635718f, -0.26774308f, 0.14062457f, 0.28451067f, 0.16265726f, 
    -0.11549428f, 0.02823369f, -0.06397428f, -0.05381927f, -0.14553368f, 0.24586990f, -0.23801436f, 0.13270849f, 
    -0.13763855f, -0.02940406f, -0.21874364f, -0.14998858f, 0.08776431f, 0.15441464f, 0.09279335f, 0.02870614f, 
    0.05593168f, 0.01048020f, 0.01895319f, -0.10142799f, 0.37854412f, 0.16426049f, 0.25565132f, -0.18450344f, 
    0.17495903f, 0.08766301f, -0.00426991f, -0.02408382f, 0.05180383f, -0.02287203f, 0.07403204f, 0.06580315f, 
    -0.13766043f, -0.05270092f, -0.11776949f, 0.05634352f, 0.02831667f, 0.11880106f, 0.10206717f, 0.06392460f, 
    -0.23944439f, 0.01942062f, 0.08120354f, -0.08701579f, -0.00029280f, 0.03575349f, -0.05619156f, -0.08673203f, 
    0.00122394f, 0.00109097f, 0.12631544f, 0.05425096f, -0.01819272f, 0.27589011f, 0.12706722f, -0.08488742f, 
    -0.30225343f, 0.04022183f, -0.04300069f, -0.23572493f, -0.03859649f, -0.12432723f, 0.16878937f, 0.09675309f, 
    0.11227816f, -0.26894841f, 0.21177672f, 0.03059690f, 0.05948663f, 0.20770012f, 0.05049578f, -0.00543972f, 
    0.11876225f, -0.15927789f, -0.19770056f, -0.05688521f, 0.05150363f, -0.24711552f, -0.19482023f, 0.18864174f, 
    0.21773061f, 0.08491176f, -0.08492763f, 0.07225443f, 0.02260012f, -0.35145521f, 0.01205175f, 0.04548252f, 
    0.03423646f, 0.21181844f, -0.07646503f, -0.11229380f, -0.04054638f, -0.04153815f, -0.13676031f, -0.15502766f, 
    -0.00347837f, 0.32285374f, 0.06262558f, -0.16145036f, 0.03336602f, 0.34473708f, 0.02055198f, -0.06956212f, 
    -0.44622657f, 0.16372521f, -0.03308008f, -0.25864345f, -0.18260555f, 0.25842297f, -0.05768582f, 0.03952954f, 
    0.02990249f, -0.38735056f, -0.16911130f, 0.04705464f, 0.05871414f, 0.01811787f, -0.07479340f, -0.20705339f, 
    0.29649845f, 0.04504983f, 0.10450260f, -0.07748513f, 0.07424707f, -0.06739891f, -0.10256624f, 0.02273847f, 
    0.17267825f, -0.13678548f, -0.29847708f, -0.17457761f, 0.16820431f, 0.07834156f, 0.27751184f, -0.11935755f, 
    -0.30088601f, -0.00578979f, 0.15877324f, -0.06592858f, 0.43110278f, 0.11807563f, 0.19665557f, 0.07315453f, 
    -0.04686464f, -0.27763778f, -0.03014917f, 0.08285306f, 0.05376236f, 0.01769847f, 0.02824021f, -0.20905134f, 
    0.03302170f, 0.10481007f, -0.16890407f, -0.01928359f, -0.11570153f, 0.19489518f, -0.15807046f, 0.19489060f, 
    0.32861573f, -0.23189759f, -0.23383804f, 0.22755116f, -0.04994807f, -0.04611493f, -0.04408740f, 0.13854326f, 
    0.22944406f, 0.16058269f, 0.09052393f, 0.18183669f, 0.24012057f, 0.05266238f, 0.08695247f, 0.25819740f, 
    0.14831971f, 0.36729714f, 0.30358464f, 0.26454374f, -0.06413371f, -0.01263816f, 0.31957108f, 0.12615025f, 
    -0.00852926f, 0.14102873f, 0.27230495f, 0.09820221f, 0.03909373f, 0.04263244f, 0.01080947f, 0.18023218f, 
    0.02010524f, -0.05850494f, -0.19856226f, -0.20493135f, 0.33216017f, 0.06729372f, 0.07252743f, -0.00090435f, 
    0.02429905f, 0.07689637f, -0.18717448f, 0.02897684f, 0.12466900f, -0.07653238f, 0.00275115f, 0.07484558f, 
    -0.05507397f, -0.08454259f, 0.21472783f, 0.16792138f, 0.19580355f, 0.08079559f, -0.07897744f, 0.20288908f, 
    0.12416553f, -0.13185357f, 0.13990515f, 0.07882982f, 0.13835853f, -0.39578542f, -0.04526760f, 0.24995764f, 
    0.12871420f, -0.02026079f, -0.04560331f, 0.27828783f, -0.05314844f, -0.01323029f, 0.05424343f, -0.14914629f, 
    -0.19087590f, -0.11192960f, -0.38046589f, -0.11393643f, 0.08184254f, 0.02197481f, 0.16654436f, -0.31846234f, 
    0.16929416f, -0.20125917f, 0.14429943f, -0.16091359f, -0.23007993f, -0.05336844f, 0.23523867f, 0.04387666f, 
    -0.33203000f, -0.06179299f, 0.00162009f, 0.06713083f, 0.03270136f, -0.00345228f, 0.23162232f, 0.04977791f, 
    -0.08067564f, 0.18964832f, 0.28587654f, 0.05382324f, 0.05122462f, 0.12716454f, 0.13467619f, 0.04957325f, 
    0.05878009f, 0.09582643f, 0.11288720f, -0.15176807f, -0.00423925f, 0.19073515f, 0.22313605f, -0.03238125f, 
    0.17426920f, -0.01552815f, 0.09817722f, 0.04406004f, -0.04115559f, -0.32883582f, 0.15966320f, 0.14585704f, 
    0.00583468f, 0.11610362f, -0.13512740f, 0.07601379f, 0.08666093f, -0.11356282f, -0.48913506f, 0.15024939f, 
    0.09666315f, -0.24500734f, 0.04070525f, 0.19514443f, 0.08309244f, 0.05219345f, -0.02658882f, -0.03839999f, 
    -0.25112328f, 0.03893507f, -0.10643245f, -0.10755617f, -0.01775953f, -0.13744648f, 0.50562650f, 0.11071517f, 
    0.36755750f, -0.19837014f, 0.33292574f, -0.07726855f, -0.14169934f, 0.20113313f, -0.17720670f, 0.01242566f, 
    0.15860614f, -0.12661621f, -0.16545843f, -0.08428790f, 0.18194592f, 0.06773607f, -0.00405650f, -0.02462698f, 
    -0.02846785f, -0.33818591f, 0.38859352f, -0.12482107f, 0.13393365f, 0.05470736f, -0.03617210f, -0.11426679f, 
    -0.10222778f, -0.21334654f, -0.30037895f, 0.08002190f, -0.20198107f, -0.18917142f, 0.00972898f, -0.13374415f, 
    0.02026761f, 0.18853223f, -0.08097421f, -0.07888146f, 0.13921088f, 0.04270079f, 0.20943226f, 0.10538905f, 
    -0.10466738f, 0.10647353f, -0.08911559f, 0.10111015f, 0.05122865f, -0.04250764f, 0.00472980f, 0.06777011f, 
    0.07726270f, 0.32908621f, 0.12067473f, -0.16951281f, -0.33085659f, -0.25823149f, 0.31789583f, -0.18249270f, 
    -0.05417523f, 0.19991198f, -0.08628119f, -0.00986658f, 0.11152784f, -0.08843373f, 0.01538905f, 0.07716115f, 
    0.11281732f, 0.07232943f, 0.00752994f, 0.14527835f, -0.00293804f, -0.04237032f, -0.17974752f, 0.09145498f, 
    -0.07745990f, 0.17170520f, -0.00427380f, -0.00313881f, 0.24927966f, -0.10575466f, 0.19679086f, 0.05542195f, 
    0.35749182f, 0.03317041f, -0.08591533f, 0.13745435f, -0.13084699f, -0.12287836f, 0.11888102f, -0.05533561f, 
    0.30330303f, 0.06543415f, -0.07757944f, -0.01502869f, 0.01577449f, 0.02849140f, -0.34865329f, 0.19912453f, 
    0.08043614f, 0.45187816f, -0.48030350f, -0.07429779f, -0.05873752f, 0.03042442f, -0.02111850f, -0.12132328f, 
    0.15724027f, 0.01395967f, -0.27455595f, 0.09221731f, 0.05660280f, 0.16179553f, 0.30440784f, 0.25670019f, 
    -0.02295156f, 0.02911945f, -0.29906261f, -0.25639221f, -0.28617254f, -0.10537870f, 0.10729568f, 0.06741194f, 
    0.18424584f, -0.19505607f, -0.00571306f, -0.00494536f, -0.01130908f, -0.26905575f, 0.02764602f, -0.03357030f, 
    -0.00131323f, -0.02685774f, -0.06448798f, -0.13729717f, -0.06230317f, 0.17488170f, 0.20776984f, 0.06632356f, 
    -0.16471085f, 0.03533137f, 0.05080696f, 0.05647826f, 0.13454954f, 0.02472580f, 0.08310202f, 0.07298721f, 
    0.12637295f, 0.07074807f, 0.09423231f, 0.24579136f, -0.20999917f, 0.19999094f, -0.06583519f, -0.06598400f, 
    -0.08457975f, 0.18552807f, -0.19101037f, -0.05628006f, -0.19793326f, -0.11095983f, -0.00085487f, -0.11894891f, 
    -0.48810577f, -0.06184815f, 0.09592143f, 0.04203178f, -0.11325685f, -0.11910109f, -0.13539653f, 0.07008384f, 
    0.06437340f, 0.28442252f, 0.17171539f, 0.03644788f, -0.02025231f, 0.04056602f, 0.03202359f, -0.00866533f, 
    0.17957444f, -0.01958159f, -0.22624236f, -0.04957591f, -0.53294653f, 0.03808960f, 0.07249118f, 0.10320139f, 
    0.20337322f, -0.12843487f, -0.01578549f, -0.66530931f, -0.10986988f, -0.01605695f, -0.02954200f, 0.16004369f, 
    0.07824928f, -0.12309653f, 0.06277212f, 0.09462500f, 0.30741340f, 0.10254160f, -0.01835948f, 0.01440882f, 
    -0.16150746f, -0.09936528f, -0.11970007f, 0.13073921f, 0.00170709f, 0.30753723f, -0.14838581f, -0.02361265f, 
    -0.02238815f, -0.08008577f, -0.07952611f, 0.04273033f, -0.01565490f, 0.09097049f, -0.49413592f, 0.10624374f, 
    -0.26425019f, 0.11988413f, -0.00288896f, 0.16578285f, -0.14081232f, -0.15640888f, 0.19276243f, -0.58549047f, 
    -0.00218205f, 0.01304484f, -0.14020997f, 0.18875146f, 0.02373057f, 0.11300728f, 0.24639109f, 0.06513732f, 
    -0.09081391f, -0.35206503f, -0.28461066f, -0.18505181f, -0.12524530f, 0.20276660f, 0.14832231f, 0.25837225f, 
    -0.17273119f, 0.60005778f, 0.10660310f, 0.01280143f, -0.13112292f, -0.18437326f, -0.09431615f, 0.08047839f, 
    0.16443846f, -0.09593971f, 0.18597643f, 0.23939118f, -0.15112567f, 0.01386367f, 0.07271354f, 0.05090893f, 
    0.27488190f, -0.03866467f, 0.11409931f, 0.35071227f, -0.04733563f, -0.21511310f, -0.07280963f, 0.16576473f, 
    0.23097819f, -0.24944319f, -0.09123477f, 0.19986552f, 0.12680900f, -0.17088166f, -0.16748786f, 0.00998043f, 
    0.16359417f, -0.13199992f, -0.05531448f, -0.02701603f, 0.02424176f, 0.46704856f, 0.30240890f, 0.01043880f, 
    0.07463081f, 0.04357453f, 0.19814853f, 0.01648063f, 0.01862070f, -0.17022853f, -0.06273128f, -0.09122327f, 
    0.04117266f, -0.23579925f, 0.10863535f, 0.02478628f, 0.10651480f, 0.30925667f, -0.04164188f, -0.40045649f, 
    0.24563007f, 0.18441641f, 0.24394615f, 0.16270439f, 0.17607124f, 0.00240028f, -0.08782953f, -0.11391790f, 
    0.27884319f, -0.05688236f, -0.04777868f, 0.07683429f, 0.14293703f, 0.03686287f, -0.17612571f, -0.09722316f, 
    -0.11137106f, 0.57643878f, 0.15773407f, 0.07041393f, 0.11319610f, -0.15351343f, -0.02640774f, -0.08363233f, 
    0.00551675f, 0.00581457f, 0.06328413f, 0.03826821f, 0.04888875f, -0.32040244f, -0.11134019f, -0.14093548f, 
    0.17212304f, 0.04883776f, 0.11072607f, 0.14288773f, 0.12072708f, -0.03988155f, -0.06768917f, 0.06387936f, 
    0.01162247f, -0.00446457f, 0.18267818f, -0.01154444f, 0.20434748f, 0.35243163f, 0.05740926f, 0.13541108f, 
    -0.12997569f, 0.07774697f, -0.28613514f, -0.11323632f, 0.12494754f, -0.47313070f, -0.34723741f, -0.21834067f, 
    0.08317789f, 0.08902701f, -0.12957329f, 0.24574171f, 0.15837471f, 0.06248437f, -0.60472405f, -0.27938345f, 
    0.01250019f, -0.03000936f, 0.01079268f, -0.08353806f, 0.01153923f, 0.02163454f, 0.14997876f, 0.30880129f, 
    -0.17123327f, 0.09072966f, -0.14869474f, -0.03006205f, 0.04891666f, 0.12894535f, -0.08247124f, 0.05138706f, 
    -0.29624557f, -0.26663715f, 0.02165802f, 0.08319724f, 0.26148549f, -0.00114626f, 0.26153111f, -0.12667172f, 
    0.04915664f, -0.10586835f, -0.32088533f, -0.22198357f, -0.04171466f, 0.10876073f, -0.02473817f, 0.03857200f, 
    -0.04612214f, -0.17473395f, -0.43426043f, -0.14172506f, -0.06603730f, 0.08952467f, -0.17053211f, 0.03597764f, 
    -0.15705620f, -0.06770020f, -0.03573475f, 0.18803196f, 0.02561720f, -0.03598700f, 0.03828562f, -0.27136895f, 
    0.04958856f, 0.06924628f, -0.12894565f, 0.40113577f, 0.21646351f, -0.15535003f, -0.10945414f, 0.24582195f, 
    0.10079712f, -0.11864166f, -0.12123099f, -0.00376103f, 0.02913610f, -0.04946026f, 0.07602837f, -0.23512083f, 
    -0.14088345f, 0.17895070f, 0.11471249f, 0.21251650f, 0.19250524f, 0.17166509f, -0.09925030f, -0.27860534f, 
    0.11296706f, -0.01486000f, -0.05217618f, 0.12303696f, -0.30464476f, 0.08648799f, -0.23769565f, 0.07692213f, 
    0.19758572f, -0.02066157f, 0.14566420f, 0.08179190f, 0.10958459f, 0.05491664f, -0.00973478f, -0.12254196f, 
    0.03785628f, 0.32596615f, 0.03606252f, 0.05705924f, -0.06544969f, -0.04242773f, 0.13004366f, 0.17126389f, 
    -0.38735124f, 0.23796782f, 0.19511507f, 0.06611945f, -0.10053602f, -0.15840116f, -0.14569634f, 0.07262436f, 
    -0.01083333f, -0.23504594f, -0.04869481f, 0.15991259f, -0.21880175f, 0.08687630f, -0.05169324f, 0.00421080f, 
    -0.04139468f, -0.17905645f, 0.15569843f, 0.11461794f, -0.09914887f, -0.06101653f, 0.13468587f, -0.10289825f, 
    0.05860492f, -0.00725840f, 0.09353913f, 0.22297542f, 0.29212135f, 0.06615090f, 0.40744248f, -0.05148806f, 
    0.01897451f, -0.27118698f, 0.05640701f, -0.01165005f, -0.06192779f, 0.04847761f, -0.13744999f, -0.29590788f, 
    0.01080770f, -0.04102085f, 0.04858351f, 0.10898879f, 0.14724922f, 0.07236867f, 0.05502796f, 0.09336225f, 
    -0.14666118f, 0.16456954f, -0.14888901f, -0.14647962f, 0.03985505f, -0.07873011f, 0.10285120f, -0.08502051f, 
    0.02834610f, -0.12006433f, 0.09379091f, -0.20875750f, 0.14969102f, 0.05673665f, -0.09466167f, 0.18176325f, 
    -0.31634393f, -0.24029014f, -0.04123820f, 0.09350955f, 0.02827236f, -0.10780819f, 0.10453985f, -0.13040479f, 
    0.06975052f, 0.11065359f, 0.16083905f, 0.03852504f, -0.15834013f, 0.00671335f, -0.16839978f, 0.02197805f, 
    -0.00714259f, -0.08837091f, 0.29267916f, 0.35670859f, 0.23706755f, -0.17748789f, -0.03057715f, 0.02586460f, 
    0.07264159f, 0.06400001f, 0.17371741f, 0.24358679f, 0.31862044f, 0.00427885f, 0.24751061f, -0.06694935f, 
    -0.13906115f, -0.10597128f, 0.11166368f, -0.01125536f, 0.07891452f, -0.02033065f, 0.08029924f, 0.11526076f, 
    0.05219558f, -0.18516839f, 0.07361843f, 0.09765296f, 0.23593540f, -0.44136393f, -0.10759301f, -0.01256703f, 
    0.21379164f, 0.09994269f, -0.05694886f, -0.15104535f, -0.14339466f, -0.22013134f, 0.16120189f, -0.08112486f, 
    -0.13341948f, 0.17754357f, -0.05505019f, 0.08591044f, -0.05154572f, -0.10170537f, -0.04455299f, -0.29173005f, 
    -0.20165528f, 0.02638445f, 0.19934537f, -0.05816734f, -0.03877333f, -0.29712379f, 0.16872057f, 0.11443350f, 
    0.15764141f, -0.17282599f, 0.13636144f, 0.05765873f, 0.08366971f, 0.19970801f, 0.02199714f, -0.31451818f, 
    -0.36843163f, 0.06846579f, -0.29471028f, -0.44426402f, 0.04778173f, 0.08574254f, 0.15325035f, 0.09065541f, 
    -0.03123677f, 0.04212551f, -0.25289670f, 0.05562123f, -0.18391608f, -0.03101390f, 0.11545118f, 0.07836358f, 
    0.00691579f, 0.14692801f, -0.11718358f, -0.06680176f, 0.25518063f, 0.10229236f, -0.23223816f, 0.06094844f, 
    0.06320674f, 0.15185775f, 0.15074743f, -0.01596848f, 0.07747756f, -0.17306109f, -0.11724932f, 0.03638265f, 
    0.10324495f, 0.21225187f, 0.09138543f, -0.00709762f, 0.18969797f, -0.06920755f, 0.04055400f, 0.27011463f, 
    -0.09595283f, 0.09848277f, -0.09780563f, -0.05647131f, -0.08934320f, 0.08735513f, 0.10116169f, 0.19823296f, 
    0.36901587f, 0.01016247f, -0.15816604f, -0.39385459f, 0.13165863f, 0.00536411f, 0.25259787f, -0.02249852f, 
    -0.11237395f, -0.15918046f, -0.05017161f, -0.02991864f, 0.15168110f, -0.12394231f, -0.02672191f, 0.01815329f, 
    0.17587027f, -0.03489851f, -0.22122227f, -0.19463888f, 0.14611013f, -0.19705959f, 0.26306498f, 0.05812903f, 
    0.04403672f, -0.20306963f, 0.06904991f, -0.56045121f, 0.08522245f, -0.14033101f, -0.17343488f, 0.13771388f, 
    -0.11610045f, -0.04001764f, 0.23948209f, 0.10397485f, -0.01646884f, -0.08184194f, 0.05509427f, -0.05632582f, 
    -0.15872690f, 0.13400875f, 0.03215453f, 0.07034940f, -0.06609183f, -0.19032447f, 0.15859345f, 0.09378969f, 
    0.17287333f, -0.01476893f, -0.22827114f, 0.00613277f, -0.37767380f, 0.16979235f, -0.14605863f, -0.18686341f, 
    -0.01299445f, -0.11358365f, 0.26890448f, 0.18026142f, 0.05725061f, -0.06225463f, -0.10790062f, 0.28039742f, 
    0.06533969f, -0.05635557f, -0.01214302f, -0.14029828f, -0.07763701f, -0.15249665f, -0.09846191f, 0.04177943f, 
    -0.15474132f, 0.26324007f, 0.07514890f, -0.23202866f, 0.20420134f, 0.05289921f, 0.03359716f, -0.44596100f, 
    -0.42639080f, -0.17845771f, -0.14496498f, -0.17208512f, -0.25897035f, 0.07806592f, 0.06008970f, -0.26781553f, 
    -0.20556459f, -0.05647038f, 0.30140439f, 0.05553784f, -0.11005112f, -0.13625133f, 0.22658423f, 0.11633436f, 
    0.07974626f, 0.10909378f, 0.32429728f, 0.36630437f, -0.08937021f, 0.22742222f, 0.15016119f, 0.07834891f, 
    0.08577222f, 0.23455289f, 0.43369746f, 0.01318989f, -0.02238850f, -0.09010783f, -0.14661232f, -0.29894987f, 
    -0.09901841f, 0.15520200f, -0.11674953f, 0.06616505f, 0.00226217f, -0.05750294f, 0.02261429f, 0.00062782f, 
    0.09098849f, 0.03722805f, 0.07720507f, 0.15986924f, 0.37938187f, 0.30691239f, 0.32134676f, -0.27708837f, 
    -0.10474084f, 0.28585625f, -0.03995127f, 0.12366686f, -0.11535500f, 0.41826159f, -0.13757728f, -0.00218096f, 
    -0.15735546f, 0.23177765f, -0.35851094f, -0.08026531f, -0.01330293f, -0.02365382f, -0.17642567f, 0.02837523f, 
    -0.26748797f, 0.00373932f, 0.04165975f, -0.10446063f, 0.07313313f, -0.08821120f, 0.09230368f, -0.00970322f, 
    -0.10579231f, -0.19498043f, -0.03929384f, 0.02189546f, -0.04530323f, 0.07505851f, 0.20220038f, -0.30048212f, 
    0.05784603f, 0.11537568f, 0.01514369f, 0.01260595f, 0.01328205f, 0.18031399f, 0.02382689f, -0.06049922f, 
    -0.09725582f, 0.35375753f, 0.38188365f, 0.33620015f, -0.37302667f, 0.04630819f, 0.21695679f, 0.00389743f, 
    0.02751738f, 0.18289359f, 0.15844169f, 0.18351553f, 0.46850508f, -0.08258272f, -0.19232188f, -0.07591107f, 
    -0.10958385f, 0.05255254f, 0.19904025f, 0.25570768f, 0.14951231f, 0.14016333f, -0.12596366f, 0.21776608f, 
    0.02379456f, -0.14996682f, -0.14934002f, 0.04334918f, -0.00518925f, 0.00042316f, 0.23339929f, -0.16797070f, 
    0.12771994f, 0.05728700f, 0.07293213f, 0.03122969f, -0.05305111f, 0.15282796f, 0.02427283f, 0.09378652f, 
    -0.19578496f, 0.27408409f, -0.06088161f, -0.03866972f, -0.02070546f, -0.09147538f, -0.05877613f, -0.16611913f, 
    -0.20354426f, 0.03150329f, -0.07067164f, 0.19006808f, -0.08164664f, 0.15247202f, 0.14703697f, 0.21379499f, 
    0.06722086f, -0.08027083f, 0.03102867f, 0.07737247f, 0.02534277f, 0.27145669f, -0.00806363f, 0.20000175f, 
    -0.38082623f, 0.26686072f, -0.01772159f, -0.06790019f, 0.13713314f, -0.42682356f, 0.03820217f, -0.14869213f, 
    -0.35927662f, -0.11789420f, -0.06696926f, -0.28611085f, 0.09375576f, 0.02466702f, -0.13209738f, -0.18436733f, 
    -0.04756765f, -0.19751476f, 0.19797939f, 0.00632397f, 0.07152794f, -0.00839408f, -0.21142468f, 0.17881925f, 
    -0.14964686f, -0.01204466f, -0.16235588f, 0.16369025f, 0.13813399f, -0.04000993f, -0.00245870f, 0.14084491f, 
    -0.20667680f, -0.07506237f, -0.06678215f, -0.01989860f, 0.05415716f, -0.00962006f, -0.06724427f, 0.18382552f, 
    -0.02549380f, -0.10014302f, -0.24102256f, 0.01497050f, -0.16860159f, -0.20237668f, 0.02207221f, 0.13033858f, 
    0.05408752f, -0.10758890f, 0.04452195f, -0.03656238f, 0.22686696f, -0.14852206f, 0.10572919f, 0.03588459f, 
    -0.12841623f, -0.02664335f, -0.09522854f, 0.00247159f, -0.13560225f, 0.08650766f, -0.25880551f, -0.15834466f, 
    0.05441350f, 0.09540304f, -0.21881782f, -0.01248199f, 0.11390064f, 0.00095060f, 0.16435720f, 0.00136031f, 
    0.33021784f, -0.02236829f, 0.12407237f, -0.01758569f, -0.06166440f, -0.13035050f, 0.06030821f, 0.17641991f, 
    -0.22034593f, 0.51218683f, -0.17486595f, 0.22188942f, -0.12915711f, -0.00154258f, 0.09640630f, -0.05314687f, 
    -0.35141182f, -0.18929887f, 0.18128838f, 0.14323629f, 0.20931207f, 0.17590204f, 0.07172511f, 0.07720520f, 
    -0.07628389f, -0.05878115f, 0.22575839f, 0.23078084f, -0.40148219f, -0.05603902f, 0.02212570f, -0.03169101f, 
    0.09938113f, 0.21613938f, -0.05438584f, -0.20486948f, 0.07039659f, 0.09159984f, -0.00353369f, -0.08735195f, 
    -0.26268208f, -0.07096045f, -0.18708858f, 0.15153575f, 0.02540647f, -0.33320412f, 0.08593425f, 0.13285035f, 
    0.05677548f, -0.10413004f, -0.06187772f, -0.08149622f, 0.10683808f, 0.06478236f, -0.06237211f, -0.45895121f, 
    -0.07909262f, 0.01360312f, 0.01215023f, 0.06862458f, -0.14301442f, -0.13259077f, -0.07303950f, -0.15378501f, 
    0.29871586f, 0.20136605f, -0.02693467f, -0.18449040f, 0.10344010f, -0.00731157f, 0.06254734f, 0.12544021f, 
    0.31448552f, 0.24989238f, -0.16297108f, 0.04490247f, 0.04684455f, -0.06088852f, 0.16562054f, 0.13989387f, 
    0.10654410f, 0.28822577f, 0.39212948f, 0.05974485f, 0.06681468f, 0.12155043f, -0.19515075f, 0.08139397f, 
    0.15555584f, -0.02331921f, -0.09916199f, 0.05929158f, -0.00015488f, 0.05619830f, -0.16968745f, 0.09121349f, 
    -0.05492112f, -0.14334084f, -0.05306232f, -0.07340676f, -0.48203412f, -0.07134253f, -0.08836435f, 0.08305773f, 
    0.21557684f, -0.06301340f, -0.03524354f, 0.21848258f, -0.25662878f, -0.10863271f, -0.09334879f, 0.21994294f, 
    0.13818152f, -0.09946394f, 0.07945853f, 0.16689172f, 0.20887312f, 0.38877401f, 0.05429866f, -0.03764979f, 
    -0.13212086f, 0.02590149f, 0.06961647f, -0.10975350f, 0.20702334f, -0.23045328f, 0.05338837f, -0.46749151f, 
    -0.05504679f, 0.05230672f, 0.13264348f, -0.00071483f, -0.12556775f, 0.14819361f, 0.15328419f, -0.11857724f, 
    -0.54239565f, -0.03823581f, 0.06630854f, -0.10756004f, 0.02650681f, 0.02428949f, -0.23136008f, 0.03561779f, 
    0.10313553f, -0.25088191f, -0.28120402f, -0.21452853f, -0.08856768f, -0.03359527f, 0.00322194f, -0.13521856f, 
    -0.00454316f, -0.01093293f, 0.32334778f, 0.13263346f, 0.02082742f, 0.05094119f, -0.25515842f, 0.02911961f, 
    0.05713660f, 0.17510742f, 0.00063633f, 0.20346698f, 0.00127285f, 0.05404098f, -0.07012111f, -0.16728929f, 
    0.17703588f, 0.12250450f, 0.10459627f, -0.13934520f, 0.03164381f, -0.03632169f, 0.20879738f, -0.00560730f, 
    0.16138701f, -0.01746316f, 0.03075379f, 0.28041613f, 0.04821873f, -0.02374815f, 0.04847969f, 0.02576802f, 
    -0.14348154f, -0.01613792f, -0.00106003f, 0.19473279f, 0.12886739f, 0.15598139f, 0.52174318f, 0.03553089f, 
    -0.02215114f, -0.12555036f, -0.12729420f, -0.04413676f, -0.21769185f, -0.03588685f, -0.06867521f, -0.01470210f, 
    0.22883028f, -0.26445827f, -0.09309484f, 0.05618351f, 0.15901196f, 0.10755515f, -0.18468103f, 0.21360789f, 
    -0.60502988f, 0.18181689f, -0.07660541f, 0.00410748f, 0.16995449f, -0.01654057f, -0.16949259f, 0.28756854f, 
    -0.10148735f, 0.28951618f, -0.05165869f, 0.15654185f, -0.01964389f, 0.10842273f, -0.14548980f, -0.21295097f, 
    -0.35162634f, -0.23342659f, -0.10532531f, 0.13888161f, -0.07534522f, -0.02721621f, 0.14159885f, 0.01479196f, 
    -0.02722385f, 0.09723634f, 0.07284150f, 0.30586064f, -0.01830126f, -0.11320530f, 0.22036631f, 0.23257530f, 
    0.15733649f, 0.01158835f, -0.22535205f, 0.35935870f, 0.16816644f, -0.23710118f, 0.15020199f, 0.14497162f, 
    0.12872371f, 0.21577524f, 0.26010972f, 0.05943694f, 0.02699812f, -0.34823000f, 0.13391450f, 0.09026418f, 
    0.09887744f, 0.34955215f, -0.09613585f, -0.06632423f, -0.04222320f, -0.23863709f, -0.27666178f, -0.35619047f, 
    -0.04883792f, -0.05890556f, -0.01784570f, 0.07691795f, -0.06336477f, -0.08999136f, -0.30201977f, -0.19432098f, 
    -0.00620597f, 0.08834685f, -0.05851602f, 0.21040025f, 0.14008978f, 0.12175490f, 0.15799066f, 0.26806670f, 
    0.14971045f, 0.01732592f, -0.15631850f, 0.15353435f, -0.13613488f, 0.01232968f, -0.28539521f, 0.21895441f, 
    -0.00087799f, -0.45419297f, 0.30872029f, -0.23331495f, -0.03389390f, -0.09863569f, 0.03504439f, 0.07757247f, 
    -0.06112858f, 0.11719683f, -0.25893143f, 0.08735210f, 0.02931186f, 0.08263204f, -0.22898997f, 0.15080261f, 
    0.11599763f, 0.25639281f, 0.48791865f, -0.29199931f, -0.08891574f, 0.05848844f, 0.04731172f, -0.03114661f, 
    -0.19234779f, -0.13468838f, 0.15675180f, -0.35731149f, -0.01918682f, 0.02227030f, 0.02475194f, -0.05020476f, 
    0.09353223f, -0.26719716f, -0.05891268f, -0.06084720f, -0.96872360f, -0.00488912f, -0.35443115f, 0.16157101f, 
    -0.06345448f, 0.07493765f, -0.09406874f, 0.01779643f, 0.16082752f, -0.76696277f, -0.19545516f, 0.11816777f, 
    -0.03289624f, -0.06303049f, -0.11040396f, -0.12294296f, 0.17329428f, -0.00315314f, 0.06498467f, 0.19669981f, 
    0.12362263f, -0.17145340f, -0.09739039f, -0.09164847f, -0.09512571f, 0.01012526f, 0.07956422f, -1.05426514f, 
    -0.10612137f, 0.28155500f, -0.10344666f, -0.02107243f, -0.06618791f, 0.02483443f, 0.14988780f, 0.08337080f, 
    0.12157991f, -0.07732591f, -0.20758580f, 0.02263093f, -0.03741050f, 0.06666474f, 0.26112807f, 0.03639975f, 
    -0.02927315f, 0.45774540f, 0.05792014f, -0.34485421f, 0.02397389f, 0.19112979f, 0.17468533f, 0.00005313f, 
    -0.04683647f, -0.07236933f, 0.66405755f, -0.13204733f, -0.34948257f, 0.05014548f, 0.10661138f, -0.11625705f, 
    -0.17790744f, 0.01445723f, -0.01401821f, 0.17074206f, 0.14027163f, 0.24083470f, -0.16646188f, 0.24984805f, 
    -0.11114828f, 0.35851943f, 0.11964605f, -0.03379577f, 0.11770039f, -0.11547726f, -0.25410974f, 0.32331321f, 
    0.01227639f, 0.10487421f, 0.07719546f, -0.12507293f, 0.10803683f, 0.33594874f, -0.07548878f, -0.13297492f, 
    -0.23694801f, -0.01917098f, -0.07541829f, 0.01609596f, -0.00169209f, -0.05110578f, -0.17984991f, 0.23700693f, 
    0.03426544f, 0.02934598f, 0.01384987f, -0.03157916f, 0.04648587f, 0.13620672f, 0.07079644f, 0.09337387f, 
    0.31422329f, 0.07350980f, 0.01360112f, -0.20472452f, -0.02009700f, -0.09976473f, 0.06403577f, 0.08237545f, 
    0.12472373f, -0.27265844f, -0.10693827f, -0.31656894f, -0.14326207f, -0.04075224f, -0.09811282f, 0.17089796f, 
    0.00167291f, 0.54794258f, 0.01309412f, -0.19969673f, 0.06874541f, 0.00855787f, 0.16222070f, -0.02901930f, 
    0.04503620f, 0.03716993f, 0.05188275f, 0.03369524f, -0.42936832f, 0.25159988f, 0.11408508f, -0.03129356f, 
    0.02740313f, -0.16405919f, -0.11469627f, -0.00014285f, -0.04863273f, -0.03277179f, 0.22526136f, 0.26879117f, 
    0.34387013f, 0.03936213f, 0.11060125f, -0.15784754f, 0.03960218f, 0.20452712f, 0.45908821f, -0.14847696f, 
    0.02539859f, 0.06498989f, 0.00157566f, 0.13890265f, 0.08830728f, 0.06674105f, -0.46339840f, 0.04055937f, 
    -0.40218636f, 0.00378770f, 0.07019319f, 0.14393517f, -0.04175641f, -0.01274021f, -0.61598587f, -0.35573635f, 
    0.19625466f, 0.14968280f, 0.02777251f, -0.09497921f, 0.11747522f, -0.11943015f, 0.28282958f, 0.05192675f, 
    0.28518304f, 0.23572461f, -0.01992349f, -0.17917009f, 0.02837278f, -0.16688514f, -0.01284417f, 0.15822220f, 
    0.14036265f, -0.47875583f, -0.13935484f, 0.21352217f, 0.24434797f, 0.07557177f, -0.07126478f, -0.08240817f, 
    -0.12789403f, -0.27914429f, 0.13113199f, -0.08952516f, 0.14475292f, 0.01702772f, -0.15919974f, 0.19402710f, 
    0.09109775f, 0.09861478f, 0.14076065f, -0.15471961f, -0.22102310f, 0.04086839f, -0.00865011f, 0.11027399f, 
    0.09723616f, 0.01647603f, -0.02838106f, -0.03216876f, -0.04357870f, -0.59309775f, 0.09541817f, 0.20773911f, 
    0.14781706f, 0.14590351f, -0.01219012f, -0.01568699f, 0.12675683f, 0.16533250f, -0.08852503f, 0.07099702f, 
    -0.04370075f, -0.18203582f, -0.13047859f, -0.20382836f, 0.01327114f, -0.07787623f, -0.12579206f, 0.16108947f, 
    -0.32492942f, 0.11842724f, -0.08490228f, 0.09066512f, 0.13385490f, 0.11849791f, -0.00989695f, -0.01291009f, 
    0.16447572f, 0.12623213f, 0.21037005f, -0.05648506f, 0.12472320f, 0.18905661f, 0.06238320f, 0.05566189f, 
    -0.03985851f, -0.28816855f, 0.06039660f, -0.02750218f, -0.16509111f, 0.12781347f, -0.01754589f, -0.10955828f, 
    -0.02779188f, 0.02007897f, 0.04732575f, -0.02207249f, 0.02967275f, -0.03786190f, -0.02946882f, -0.04617116f, 
    -0.05657200f, 0.03239311f, 0.01306189f, -0.02498592f, -0.02708682f, -0.02700061f, -0.00105034f, 0.04794162f, 
    -0.04734278f, 0.04212006f, -0.04130146f, 0.01054153f, -0.04198162f, -0.03909268f, 0.00383224f, 0.02568658f, 
    -0.06151453f, 0.04586445f, -0.00788758f, 0.01568067f, 0.02099239f, -0.00686982f, -0.06149999f, 0.02173147f, 
    0.03028029f, -0.04057175f, 0.01866276f, 0.03231620f, -0.03090427f, -0.01165749f, 0.01087265f, 0.03672609f, 
    -0.02682677f, 0.03977751f, 0.03332250f, 0.01962923f, 0.03782045f, -0.00436981f, -0.03720740f, 0.01716411f, 
    -0.02286076f, -0.06709858f, 0.00409598f, 0.03972290f, -0.00256512f, 0.03125294f, -0.00852634f, -0.02964730f, 
    -0.05452454f, -0.05456057f, 0.02397900f, -0.05234335f, 0.05107468f, -0.03498931f, -0.00512819f, -0.05151572f, 
    0.04382208f, 0.00685684f, 0.04333013f, -0.05111950f, 0.02305508f, -0.00292832f, 0.03841939f, -0.02686661f, 
    -0.02862071f, 0.04855870f, -0.05267073f, -0.04569631f, -0.05114440f, 0.04518589f, 0.01646664f, 0.01053120f, 
    0.02183216f, 0.03574190f, 0.02837613f, 0.02889737f, -0.03687087f, 0.03086739f, 0.00919255f, 0.03604537f, 
    -0.06484696f, 0.00155787f, -0.04143110f, 0.03877007f, 0.02498922f, -0.01964730f, -0.00380636f, -0.01708798f, 
    0.04344795f, 0.00673408f, -0.05944666f, 0.02956676f, 0.00388423f, -0.05733130f, 0.01877580f, -0.05526518f, 
    -0.05968224f, 0.03783009f, -0.01187291f, -0.04664583f, 0.00307114f, -0.04968736f, -0.01793701f, -0.06726380f, 
    -0.03609820f, 0.03803622f, -0.00569264f, 0.02216081f, -0.05653827f, -0.01163914f, -0.05062747f, 0.04784486f, 
    -0.00959557f, 0.04809937f, 0.00106521f, 0.01208831f, -0.01284796f, 0.04911164f, 0.01452436f, -0.04374973f, 
    0.02349154f, -0.05516959f, -0.05398882f, -0.01310760f, 0.03456395f, -0.05555931f, -0.01600420f, -0.00596374f, 
    0.01833401f, 0.02524016f, -0.04595844f, -0.00565297f, -0.00599496f, -0.06518511f, -0.05650436f, -0.06718107f, 
    -0.01130147f, -0.02569870f, -0.04322746f, 0.04830508f, 0.01988620f, -0.05303995f, 0.04913256f, -0.01851713f, 
    -0.02619090f, 0.01118537f, -0.01607309f, 0.04104164f, -0.01867698f, 0.02143951f, 0.04351184f, 0.01101887f, 
    -0.05714184f, 0.03378185f, 0.05384746f, -0.04424441f, -0.02694054f, -0.04679227f, -0.03140948f, -0.02448341f, 
    0.01522753f, -0.04457609f, 0.03717793f, -0.04344834f, 0.02618446f, -0.04977689f, -0.05532236f, 0.02715228f, 
    -0.01997239f, 0.02347423f, 0.00788162f, 0.01705072f, 0.01020150f, -0.03856209f, -0.01525951f, 0.03331399f, 
    -0.03754914f, -0.03503989f, 0.00273334f, 0.01084129f, -0.02484290f, -0.06246250f, -0.01489544f, 0.04021617f, 
    0.01299313f, 0.02724192f, -0.04241311f, 0.01200670f, 0.02522753f, -0.02407774f, -0.05801059f, -0.06147293f, 
    0.01647556f, 0.02012488f, -0.03207618f, 0.05605623f, -0.01728579f, 0.00045861f, 0.00634163f, -0.01696250f, 
    0.01160433f, -0.05180984f, 0.01102985f, -0.02713082f, 0.04473569f, -0.01843911f, -0.03349768f, -0.02282241f, 
    -0.03704489f, 0.00592722f, -0.01484204f, -0.06564628f, -0.01665263f, -0.03221702f, -0.04484092f, 0.01487536f, 
    0.03989363f, 0.00533906f, -0.05275067f, -0.04766439f, -0.05704219f, -0.05727605f, 0.01358606f, -0.05253044f, 
    0.04997701f, 0.00831578f, 0.01520629f, 0.00138610f, 0.00449617f, 0.02121349f, -0.04616257f, 0.04523404f, 
    -0.02861073f, 0.03653832f, 0.01873389f, 0.05431193f, -0.00088457f, 0.00087446f, -0.01544402f, -0.04475388f, 
    0.01417312f, -0.05368105f, 0.04811213f, 0.04547236f, -0.05550338f, 0.01344342f, -0.01568746f, -0.03035912f, 
    -0.04512192f, 0.05379739f, -0.05180259f, -0.04243191f, -0.00163537f, 0.04658607f, 0.03542901f, -0.02662125f, 
    -0.02387540f, 0.01956962f, 0.03067574f, -0.04637532f, 0.03985538f, -0.04569691f, -0.01906982f, 0.03308264f, 
    0.02706534f, -0.02468235f, -0.04629523f, 0.02507141f, -0.04178698f, -0.02185610f, 0.03407173f, -0.03513785f, 
    -0.04959558f, 0.03907508f, -0.01453988f, -0.01965399f, 0.00294055f, 0.03517769f, -0.00577334f, -0.06413447f, 
    -0.05286395f, -0.03159163f, -0.02058542f, 0.04255055f, -0.03032689f, -0.05409657f, 0.01185367f, -0.00776925f, 
    -0.00861100f, -0.04145917f, 0.02449805f, -0.03598496f, 0.01868521f, 0.03992762f, 0.02915691f, -0.00732334f, 
    0.01613292f, 0.02967129f, -0.00085177f, -0.01731259f, -0.05730115f, 0.05696166f, 0.03679845f, -0.04544885f, 
    -0.02094703f, 0.01037309f, -0.00713224f, 0.00799529f, 0.04312298f, -0.03549548f, -0.03264596f, 0.00000832f, 
    -0.03880138f, 0.04022035f, -0.01689680f, -0.04493277f, -0.05719081f, -0.01802334f, -0.03289546f, -0.02219121f, 
    -0.05001474f, -0.04460663f, -0.04339045f, 0.01894187f, -0.02965516f, -0.01405669f, -0.04284748f, 0.00295531f, 
    0.01411087f, 0.00246975f, -0.03321574f, -0.01377415f, -0.05143068f, -0.02063628f, -0.05012470f, -0.02712171f, 
    -0.04340549f, -0.01111964f, -0.00701340f, -0.00321850f, -0.05662736f, -0.05324820f, 0.03253533f, 0.02293152f, 
    -0.05571274f, 0.03385033f, -0.01248339f, 0.04292553f, -0.04303903f, -0.05522837f, -0.02650988f, 0.02087370f, 
    0.01753139f, -0.04969763f, -0.03434668f, 0.00935436f, -0.00315037f, -0.07093626f, -0.04093864f, -0.03342712f, 
    -0.06305609f, 0.01776276f, -0.05551284f, -0.03279206f, 0.03432698f, 0.04050737f, -0.04034159f, -0.03509558f, 
    0.00721218f, -0.06062243f, -0.01073560f, 0.00660185f, -0.03837030f, 0.03778152f, -0.06205640f, 0.00898389f, 
    0.04352985f, -0.03946745f, -0.00141318f, -0.04041192f, 0.01825850f, -0.06510802f, -0.01538827f, -0.03627631f, 
    -0.03474685f, 0.04594445f, 0.00415978f, 0.04430442f, 0.01904039f, -0.04825108f, -0.06028761f, -0.05893782f, 
    0.04521054f, -0.04743631f, 0.04837047f, -0.05773561f, 0.04841785f, 0.05209682f, -0.00670982f, 0.04296746f, 
    -0.03527956f, -0.05955182f, 0.00490238f, -0.04812443f, -0.02779611f, -0.05306134f, -0.05433702f, -0.03456354f, 
    -0.02346236f, 0.01190930f, 0.01289363f, 0.00018701f, -0.04435005f, 0.04218385f, 0.00192471f, 0.00309196f, 
    0.04769693f, -0.03568823f, -0.05410741f, -0.05219701f, -0.05579732f, 0.03067895f, -0.03117917f, 0.00777640f, 
    -0.04036961f, 0.04588380f, 0.03663005f, 0.04524131f, -0.00277666f, -0.02703527f, 0.00498155f, 0.00431417f, 
    -0.01768871f, 0.03970545f, -0.06009738f, 0.00268712f, -0.04211172f, -0.03197669f, -0.01410427f, 0.03957175f, 
    -0.03882369f, -0.06110295f, 0.01090023f, 0.03060684f, -0.00432437f, -0.05123705f, 0.03029009f, 0.04081999f, 
    -0.02253125f, -0.04741079f, -0.03335902f, -0.05713844f, 0.04013432f, -0.04551249f, -0.02766612f, 0.03723447f, 
    0.00575165f, 0.04992805f, -0.01725254f, -0.00772292f, 0.03731108f, 0.04769493f, -0.04943429f, -0.05488982f, 
    0.00036142f, -0.04335475f, 0.04417801f, -0.04133333f, -0.03049971f, -0.04122232f, 0.01631384f, -0.03491579f, 
    -0.06623461f, 0.03739725f, 0.04201966f, 0.00352053f, 0.02907600f, 0.02905781f, -0.00169865f, -0.01867930f, 
    -0.05189804f, 0.02220964f, 0.00094441f, 0.04723848f, -0.03789297f, -0.01284977f, 0.00190227f, -0.05840842f, 
    -0.04714155f, -0.05415668f, -0.02925265f, -0.04119592f, -0.01429790f, -0.00824192f, -0.00448902f, -0.01941046f, 
    0.03726529f, -0.01293120f, 0.02440198f, 0.01390374f, -0.02915334f, 0.03262636f, -0.00577378f, 0.02780738f, 
    0.02305583f, -0.00810321f, 0.02979627f, 0.04888118f, 0.00722795f, 0.02936769f, -0.00994074f, -0.05266267f, 
    0.04572645f, -0.03422492f, 0.00126528f, -0.06476803f, 0.02599139f, -0.06106936f, -0.02673355f, 0.02344250f, 
    -0.05228094f, 0.00836651f, -0.01953032f, -0.03210621f, 0.00614408f, -0.00285922f, 0.04476664f, 0.01626484f, 
    -0.02730595f, 0.02520892f, 0.03093143f, -0.04141944f, -0.03616497f, -0.02754390f, -0.02871235f, -0.05066721f, 
    0.04100614f, -0.01832582f, 0.02609920f, -0.01760607f, -0.05694271f, 0.00406945f, -0.02594533f, 0.02137105f, 
    0.02169968f, -0.03629259f, -0.01728375f, -0.01600210f, -0.03833479f, -0.05719519f, 0.01423056f, 0.03233447f, 
    -0.01082858f, -0.00273638f, -0.00919685f, 0.04692529f, -0.02375099f, -0.02011313f, -0.04178846f, -0.06021796f, 
    -0.03768665f, -0.05114225f, -0.05302789f, -0.04692999f, 0.03053883f, -0.03229154f, -0.06449408f, 0.03173532f, 
    -0.11705618f, -0.07460896f, -0.24868745f, 0.00222479f, -0.11474092f, -0.20450374f, 0.02498751f, -0.07466691f, 
    0.01933859f, -0.23981301f, 0.03155195f, -0.19692829f, 0.11399573f, -0.11041572f, 0.15047224f, 0.00491293f, 
    -0.07214966f, 0.04115496f, 0.43937647f, -0.05648322f, -0.17661346f, -0.15103450f, -0.33183461f, 0.05883484f, 
    0.03612217f, -0.08408797f, 0.14516509f, -0.33297822f, 0.12195938f, 0.25125033f, -0.02890759f, 0.12342088f, 
    0.05605609f, 0.05535705f, -0.00959240f, -0.06117817f, 0.21183765f, -0.10251211f, 0.18673822f, 0.17033462f, 
    0.12075416f, 0.03677221f, -0.07525609f, -0.02140656f, 0.00749980f, 0.45523012f, 0.05878492f, -0.09591682f, 
    -0.02024691f, -0.06806802f, -0.24380191f, -0.13457511f, 0.03343857f, -0.04949505f, -0.22932467f, 0.01408610f, 
    0.17657731f, -0.09480410f, -0.09191827f, -0.22768869f, 0.06228373f, 0.17449659f, 0.10000587f, -0.01715289f, 
    0.01763735f, 0.24592412f, 0.11857419f, -0.11102736f, -0.10457852f, 0.04441798f, 0.07975606f, -0.14347713f, 
    -0.38883621f, -0.05026658f, 0.43164867f, 0.19573121f, 0.06343510f, 0.04282133f, -0.05771384f, 0.10336879f, 
    0.09983020f, -0.32577509f, 0.02233476f, 0.43691936f, 0.18281272f, 0.05084665f, 0.00538921f, -0.18049189f, 
    0.15478420f, 0.20927793f, -0.40152711f, -0.07161796f, 0.07576595f, 0.19008766f, -0.07805581f, 0.08064736f, 
    -0.08031000f, 0.15446301f, 0.13216925f, 0.52678818f, 0.31343627f, 0.05208639f, -0.20795013f, 0.00564020f, 
    -0.08386204f, -0.11413001f, -0.10953826f, -0.14855355f, 0.01387542f, -0.20124289f, 0.24981585f, -0.03076445f, 
    0.12032659f, 0.22953956f, -0.10435303f, 0.05210083f, -0.08413189f, -0.56524372f, -0.05032703f, -0.02011957f, 
    0.13270378f, 0.01971547f, 0.04480970f, 0.07067046f, -0.07080969f, 0.14105064f, 0.13614185f, 0.06626612f, 
    0.06866342f, -0.27151397f, -0.20360012f, -0.00362223f, 0.09482726f, 0.02576952f, -0.14702645f, -0.12168251f, 
    0.16603450f, -0.43003771f, -0.05310810f, 0.13573286f, 0.07236817f, 0.02426577f, 0.03444700f, -0.24390130f, 
    0.00052227f, 0.16147138f, 0.12488718f, 0.04143241f, -0.04937930f, 0.00012657f, 0.14865659f, 0.09090320f, 
    0.14664829f, -0.09786002f, 0.08334848f, 0.40298134f, 0.22876868f, 0.06733434f, -0.02461467f, -0.09730077f, 
    0.00000661f, 0.16974093f, 0.00307704f, -0.13301632f, 0.11662085f, 0.09818555f, 0.09004643f, 0.07506903f, 
    0.03977124f, 0.16190580f, -0.00872856f, 0.27156428f, 0.12095847f, -0.16127835f, 0.15223932f, 0.04211958f, 
    0.16726987f, -0.15166810f, -0.22556247f, -0.02422353f, 0.22363615f, -0.05508569f, -0.25397804f, 0.05907019f, 
    -0.14019123f, 0.24816902f, -0.07182505f, 0.05880074f, -0.12534656f, 0.71050930f, -0.01352604f, -0.18658189f, 
    -0.06038564f, 0.02965196f, -0.11688151f, -0.08455361f, 0.05857037f, -0.04291242f, 0.08785652f, 0.06062775f, 
    0.28099120f, -0.21935906f, -0.08859763f, 0.13364294f, 0.11863640f, -0.22319959f, 0.03127057f, -0.21030194f, 
    -0.10074105f, -0.20330791f, -0.13925329f, -0.03201983f, -0.14926976f, -0.06979684f, -0.04449673f, 0.05760785f, 
    0.42774481f, -0.08297780f, 0.31485420f, 0.17382634f, 0.07906637f, 0.14016688f, -0.20749871f, -0.07112728f, 
    0.00834331f, -0.08263806f, 0.02335981f, -0.30245957f, 0.03969549f, -0.03867341f, -0.08421297f, 0.02483862f, 
    0.06032257f, -0.13062508f, -0.38031402f, -0.11630318f, 0.36594445f, -0.00572344f, 0.10159057f, -0.06095279f, 
    0.20729545f, -0.03251150f, 0.01100971f, 0.09730215f, -0.26825210f, 0.24320494f, 0.13272190f, 0.13113935f, 
    -0.07215535f, 0.03259490f, -0.10130800f, -0.00366370f, 0.14771219f, -0.01551373f, -0.13140111f, -0.08230741f, 
    0.03949144f, -0.09117004f, 0.00526322f, 0.05498021f, 0.10550281f, 0.21159779f, -0.20690474f, -0.49994758f, 
    -0.17112117f, 0.06532288f, 0.02239841f, -0.07709369f, -0.19462478f, -0.27349904f, 0.07363200f, 0.09755735f, 
    0.02604043f, -0.11772835f, -0.02879472f, 0.12988225f, -0.05815796f, -0.07383310f, -0.02807892f, -0.00762984f, 
    0.11197571f, -0.03599120f, 0.02346089f, 0.13322809f, -0.11426227f, -0.02745141f, -0.08586644f, -0.11652704f, 
    -0.00590552f, 0.04604556f, 0.03831841f, 0.00028977f, 0.02156351f, 0.04924050f, -0.06273539f, -0.03572471f, 
    0.01176644f, -0.03275308f, 0.02093023f, 0.01172421f, 0.00751248f, 0.04693430f, 0.01735827f, -0.01640817f, 
    -0.03353095f, -0.03297302f, 0.01118530f, -0.02365682f, 0.03599194f, -0.02080278f, -0.02265357f, 0.02880679f, 
    -0.06194713f, 0.00198056f, -0.03501766f, 0.02869439f, -0.05141336f, -0.01563916f, -0.01831889f, 0.00667742f, 
    -0.04022935f, 0.00272392f, 0.00169028f, -0.06022999f, 0.01541316f, -0.05250097f, -0.01832073f, -0.01487713f, 
    -0.05309755f, -0.03726641f, 0.00269138f, -0.05811247f, 0.00167018f, 0.05127046f, 0.03296110f, -0.02698584f, 
    0.02961338f, -0.06660110f, -0.04539935f, -0.00581540f, -0.06128762f, -0.04068290f, 0.04436798f, -0.06342250f, 
    -0.00386583f, 0.04845013f, 0.03835737f, 0.02253368f, -0.03434024f, 0.00296233f, -0.06162144f, 0.02080265f, 
    0.03125327f, -0.00445664f, 0.02131687f, -0.04808388f, -0.04114651f, 0.04591276f, 0.04796921f, 0.04341926f, 
    0.01104316f, -0.04076654f, -0.05083904f, 0.01552008f, 0.01643976f, 0.04231804f, -0.03039608f, -0.03388943f, 
    0.02866640f, -0.04344862f, -0.05089227f, -0.02448115f, -0.01131779f, 0.02751113f, -0.02685402f, -0.00135095f, 
    -0.02119143f, -0.02770616f, 0.02562250f, 0.01941006f, 0.00804252f, -0.04367109f, -0.04065491f, 0.05020777f, 
    -0.01179530f, -0.06486826f, 0.01733690f, -0.02415072f, -0.06410963f, -0.04421599f, 0.00680531f, -0.01247781f, 
    -0.05244647f, -0.05664454f, -0.01120255f, 0.01526100f, 0.02151182f, -0.00630793f, -0.02614895f, 0.04980062f, 
    -0.01373072f, 0.00434942f, -0.03248654f, 0.01692354f, -0.01889672f, -0.04861422f, -0.01548980f, -0.06380381f, 
    0.04266306f, -0.04508989f, -0.00637965f, -0.03929006f, 0.03499092f, 0.02432819f, 0.03539789f, -0.01499521f, 
    -0.03429536f, -0.03458466f, -0.02392449f, -0.01554850f, 0.03933593f, 0.00651016f, -0.01979762f, 0.03963653f, 
    -0.02645670f, -0.03344690f, 0.03158434f, 0.00358201f, 0.02878875f, -0.01131486f, -0.04959587f, -0.01530291f, 
    -0.01601268f, 0.01227546f, 0.04867155f, -0.05031558f, 0.05692367f, 0.03429288f, -0.05065236f, -0.03480927f, 
    0.04687577f, 0.01645688f, -0.03985934f, 0.03913127f, -0.04688564f, -0.03883893f, 0.04222637f, -0.05492544f, 
    -0.02808343f, 0.04146232f, 0.04193082f, 0.04878895f, -0.03442894f, -0.01035471f, -0.04254640f, -0.01909597f, 
    0.01863156f, -0.03078410f, 0.03703834f, 0.04890847f, 0.01275362f, 0.04917450f, 0.00050796f, -0.01878651f, 
    0.00753422f, -0.06625238f, -0.03587012f, -0.02770733f, 0.02184327f, -0.03643274f, -0.02844476f, 0.03469214f, 
    -0.04624911f, -0.03543143f, 0.03110448f, 0.00504162f, -0.05937241f, -0.00373376f, -0.04282076f, 0.04209544f, 
    0.04325076f, 0.03453737f, 0.02686700f, 0.03346327f, -0.01732619f, -0.00890962f, 0.02610903f, 0.02611480f, 
    0.02952377f, 0.00816167f, 0.03168801f, 0.03041461f, 0.00083287f, -0.00268534f, -0.05509061f, -0.03871940f, 
    0.03929134f, -0.02386391f, 0.02066868f, -0.04972167f, -0.06328298f, -0.05085254f, 0.03515051f, 0.02501772f, 
    -0.00701940f, -0.01002657f, -0.06313144f, -0.03192393f, 0.01678592f, -0.06059341f, 0.00686283f, 0.00629889f, 
    -0.05247040f, 0.04617687f, -0.02818476f, -0.03089624f, 0.02674677f, 0.04778617f, -0.00562093f, -0.05881713f, 
    -0.04164888f, -0.02515548f, 0.03602303f, -0.05786527f, -0.00066295f, 0.02228147f, -0.00076961f, -0.03778226f, 
    0.03133472f, 0.03628995f, 0.03410042f, -0.00798420f, 0.03958726f, 0.00421242f, -0.05210449f, 0.04707359f, 
    -0.05341380f, -0.01323034f, 0.02731710f, 0.03311798f, -0.01685300f, 0.01131729f, -0.01503827f, -0.02993536f, 
    0.02041180f, 0.00533962f, -0.00579616f, 0.02021627f, 0.02532060f, -0.01553214f, -0.04664169f, -0.06364820f, 
    -0.05836854f, -0.01243406f, 0.03964029f, 0.01255575f, -0.00478436f, -0.05846156f, 0.02723963f, -0.00984953f, 
    -0.01921332f, 0.04649028f, 0.00248026f, -0.00602152f, -0.05024550f, -0.01480069f, -0.06340558f, 0.01120664f, 
    -0.01759720f, -0.00076216f, -0.05991120f, 0.02198420f, 0.02328702f, 0.01945539f, -0.01358004f, -0.03316026f, 
    -0.06180264f, 0.00361830f, -0.03437966f, 0.03770528f, -0.04746723f, -0.03627390f, -0.05322285f, 0.04617207f, 
    0.04510842f, 0.01605703f, 0.03271025f, -0.04351874f, 0.01598338f, -0.02552520f, 0.03234755f, -0.03866951f, 
    -0.03797134f, 0.02263469f, 0.00739567f, -0.05867251f, -0.02862084f, 0.02156454f, 0.03341165f, 0.05179960f, 
    0.03888011f, 0.04023393f, 0.02084397f, -0.04203297f, 0.03663500f, -0.00490730f, -0.01719078f, 0.00284886f, 
    -0.02068349f, 0.02094666f, 0.01724764f, -0.01409006f, 0.01304538f, -0.03376068f, -0.00197600f, -0.00085018f, 
    0.00748147f, -0.01967686f, 0.04672902f, -0.03878002f, 0.04169254f, -0.00955153f, 0.03174801f, -0.03337366f, 
    0.05034924f, 0.02801981f, 0.05038508f, 0.01074234f, -0.02328978f, 0.05017850f, -0.01052105f, 0.01480638f, 
    -0.04087223f, 0.00008536f, 0.01634100f, 0.05090913f, -0.01890382f, -0.05862041f, -0.00563224f, -0.05895148f, 
    -0.01481771f, -0.02389097f, 0.01550452f, 0.02327956f, -0.04350516f, 0.01434773f, -0.01675298f, -0.02930545f, 
    -0.02467390f, -0.03287778f, -0.05311973f, 0.01439062f, -0.06407452f, 0.03432009f, -0.03604313f, 0.00962985f, 
    0.02262911f, 0.01178333f, 0.01927819f, -0.01388714f, 0.04316480f, -0.01391995f, -0.02035411f, 0.02286981f, 
    -0.05720414f, -0.05157441f, -0.06043962f, -0.05714430f, -0.02984636f, 0.02781202f, 0.03222148f, -0.05715431f, 
    0.04162050f, -0.01118316f, 0.04968277f, 0.00014389f, 0.03921928f, -0.01591546f, -0.04189162f, -0.05401782f, 
    0.01784434f, -0.03558486f, 0.00141390f, -0.03946141f, -0.02825583f, 0.02531735f, -0.04873239f, 0.02207155f, 
    0.00552800f, -0.04653297f, 0.01712805f, 0.02005622f, -0.03212591f, -0.04587151f, 0.05221923f, 0.01027029f, 
    -0.03011354f, -0.00134597f, 0.03184140f, 0.02166720f, -0.02277103f, -0.04640831f, -0.05914387f, 0.01740627f, 
    0.03607768f, -0.03637714f, 0.02855985f, 0.01895715f, -0.05908039f, -0.03916632f, -0.05749528f, -0.06372546f, 
    0.00189306f, -0.03365251f, 0.04922971f, -0.04559655f, -0.05731709f, -0.00448178f, -0.03345327f, -0.01689719f, 
    0.03058115f, 0.03367518f, -0.05741446f, 0.01548727f, 0.02549650f, -0.04720146f, -0.03112724f, -0.00852478f, 
    -0.02240357f, -0.02074385f, 0.01484042f, -0.00600382f, -0.06112142f, 0.00472871f, -0.01461614f, -0.02282189f, 
    0.04706550f, -0.02562421f, -0.00524469f, -0.02274556f, -0.04572115f, -0.03882062f, 0.04589191f, -0.04990813f, 
    -0.01867154f, -0.00174432f, 0.01840484f, -0.04146305f, 0.01371027f, -0.00840172f, 0.00598663f, 0.04786998f, 
    -0.00693122f, -0.05591536f, -0.00352465f, -0.05515032f, 0.00081929f, -0.03779310f, -0.03958102f, 0.01321341f, 
    0.02849955f, 0.01216319f, -0.02297793f, 0.03303376f, 0.03653245f, -0.05930087f, -0.05853101f, -0.05983328f, 
    0.04886538f, -0.03269798f, -0.06136967f, -0.05276305f, 0.00040500f, -0.00084890f, 0.04383708f, 0.04675433f, 
    -0.04479294f, -0.02344331f, -0.05955666f, 0.03830834f, -0.01887898f, -0.06235506f, -0.01945953f, 0.03567959f, 
    -0.02363038f, -0.05924040f, 0.02564923f, -0.05458371f, -0.00232758f, 0.01889386f, 0.02059487f, -0.01872425f, 
    0.00066870f, 0.01818989f, -0.03778097f, 0.02540097f, -0.03749260f, 0.05159038f, -0.03785618f, 0.01390777f, 
    -0.02612389f, -0.06035334f, 0.01809773f, 0.03474174f, 0.02827803f, -0.01579972f, -0.06260545f, 0.00445968f, 
    -0.03639893f, -0.06091268f, -0.00997119f, -0.04160044f, 0.01295626f, -0.03758487f, 0.04449697f, 0.03023307f, 
    -0.04238777f, -0.01264241f, 0.03652177f, -0.05175507f, -0.01760468f, -0.03906773f, 0.00340355f, 0.04861142f, 
    0.04598139f, -0.03996037f, -0.02283066f, -0.00755342f, 0.00362038f, -0.04645615f, -0.04037616f, -0.00107240f, 
    -0.02086665f, -0.02172780f, -0.02306060f, -0.03736972f, -0.01119882f, -0.02278143f, -0.02068960f, -0.00178339f, 
    -0.04990897f, 0.00162818f, -0.06214609f, 0.02275290f, -0.00870818f, 0.02512295f, 0.02093283f, -0.00614520f, 
    0.00858114f, -0.00990810f, -0.01089544f, 0.03006852f, 0.02507458f, 0.00029102f, 0.02952820f, -0.06041860f, 
    -0.03904437f, -0.03573043f, -0.04345358f, -0.00671153f, -0.01525739f, -0.05592072f, -0.03575712f, -0.01370420f, 
    0.02444359f, 0.28106210f, -0.54945886f, -0.08768188f, -0.10728447f, 0.06991977f, 0.02296085f, 0.17280939f, 
    0.13023873f, -0.47260216f, -0.38038829f, -0.51579458f, 0.28183901f, 0.00334908f, -0.04681842f, 0.00743774f, 
    0.04484831f, 0.02120106f, -0.64497530f, -0.01135800f, -0.15491775f, 0.07392654f, 0.14377128f, 0.16955848f, 
    0.07209588f, -0.03533351f, 0.26894683f, 0.04658420f, 0.51252943f, -0.26180661f, -0.09341245f, -0.03993694f, 
    0.00707438f, 0.03900520f, 0.02440888f, -0.08375246f, -0.11830942f, -0.05765921f, 0.25561377f, 0.06708724f, 
    0.02696659f, -0.18630958f, -0.09496219f, -0.08495757f, 0.18093039f, 0.22292766f, -0.13514033f, 0.16932411f, 
    -0.15605009f, 0.05105758f, 0.06274860f, -0.24627222f, -0.14086011f, 0.15975040f, -0.35660306f, -0.02307905f, 
    -0.46751210f, 0.21004978f, -0.22657070f, 0.04989027f, -0.02845555f, 0.04666511f, -0.19763495f, -0.06242606f, 
    -0.05470223f, 0.60299057f, -0.05081737f, 0.03768378f, -0.33283597f, -0.05118804f, -0.01028776f, 0.10080440f, 
    0.13483146f, 0.10456558f, 0.44396347f, 0.08569339f, 0.13004683f, -0.15088843f, 0.04311869f, 0.15739596f, 
    0.11148322f, 0.02444150f, -0.20607735f, 0.58531976f, -0.06373329f, -0.18293521f, -0.01045266f, 0.03259829f, 
    -0.01511880f, 0.03959261f, -0.89407724f, -0.06461699f, -0.02761565f, -0.08055776f, 0.12634332f, 0.09648779f, 
    -0.06003902f, 0.05562654f, 0.03490982f, 0.14627640f, 0.14722690f, 0.22197184f, -0.14530729f, 0.07744671f, 
    -0.11372994f, 0.12982747f, 0.16611670f, 0.06008745f, 0.10742211f, -0.21377736f, 0.06016645f, 0.26605192f, 
    0.01184334f, -0.04360854f, -0.14079769f, 0.20035392f, -0.17019691f, -0.28808162f, 0.39193836f, -0.32540336f, 
    0.08085296f, -0.09193580f, -0.18200907f, -0.03998730f, 0.05996799f, 0.11693189f, -0.17179640f, 0.08863644f, 
    0.10720591f, 0.10406967f, 0.10914535f, -0.06375089f, 0.13948143f, 0.07094581f, -0.04501600f, 0.07730698f, 
    0.25210965f, 0.05148364f, 0.09383754f, 0.10526267f, 0.14876276f, -0.00045581f, 0.01607580f, -0.33106917f, 
    0.40807417f, 0.18603496f, 0.30240119f, -0.14900382f, -0.14420271f, -0.29024810f, 0.01896559f, 0.12696357f, 
    -0.14227223f, 0.02709241f, -0.27729952f, 0.24761535f, -0.09306902f, -0.16559933f, 0.00739379f, -0.11286422f, 
    -0.07731568f, 0.00115820f, 0.21963899f, -0.17008920f, 0.43865982f, -0.18659279f, 0.10373771f, 0.18977347f, 
    -0.18481471f, 0.03153989f, 0.36920780f, -0.20274058f, 0.06757244f, -0.26037431f, 0.13594642f, -0.04086763f, 
    0.00638963f, 0.16616084f, -0.04518326f, 0.05266142f, 0.04829042f, 0.19681880f, -0.50496835f, -0.08940817f, 
    -0.03661926f, -0.06367070f, 0.14321634f, -0.11304711f, 0.29354119f, -0.02728966f, 0.05653752f, 0.08308374f, 
    0.25897324f, -0.10029114f, 0.04263501f, -0.01764449f, -0.05525724f, -0.05346563f, -0.43898427f, -0.41858912f, 
    0.05425980f, 0.02135763f, 0.01398782f, -0.29704010f, 0.42768490f, -0.29387161f, -0.46853274f, -0.30296570f, 
    -0.01045369f, -0.11058573f, 0.05724283f, -0.14410402f, 0.06872238f, -0.27446103f, -0.23852609f, 0.00014368f, 
    -0.26156020f, 0.23561448f, -0.28355318f, 0.19063798f, 0.03380807f, -0.04640250f, 0.01853282f, 0.00083093f, 
    -0.09674869f, -0.10541850f, 0.37332767f, -0.29334944f, 0.05797249f, -0.02740838f, 0.10693088f, 0.06869060f, 
    0.00371653f, -0.13902727f, -0.02519072f, -0.02589224f, 0.11240853f, 0.04115881f, -0.14892118f, 0.24339558f, 
    -0.08956984f, -0.11005276f, 0.15664548f, -0.16621943f, 0.19662073f, 0.23211226f, -0.23399651f, 0.14859286f, 
    0.02432104f, -0.00761848f, 0.12916186f, 0.29998684f, 0.34652951f, 0.09348281f, -0.69986683f, 0.01149758f, 
    0.10032696f, 0.14705838f, 0.12912944f, -0.05713048f, -0.04004229f, 0.40410328f, -0.18901564f, -0.21585758f, 
    -0.00564410f, -0.03709435f, 0.05349243f, -0.05975857f, -0.05743946f, -0.07555824f, 0.16182418f, 0.32124555f, 
    0.14255874f, 0.00416608f, 0.10916597f, -0.09407640f, 0.11286811f, 0.21986340f, 0.04348130f, -0.06751295f, 
    -0.28073955f, -0.02727873f, -0.29331023f, 0.01164034f, -0.06373543f, 0.23832311f, 0.13476324f, 0.03354667f, 
    0.01837402f, -0.03726731f, -0.05497956f, -0.05212398f, 0.01603725f, 0.03676051f, 0.00920908f, 0.00317895f, 
    -0.03669066f, -0.06213459f, 0.03618964f, -0.00480030f, 0.02265679f, -0.00415536f, 0.01853446f, -0.02208090f, 
    -0.06494049f, -0.05787594f, 0.00225697f, -0.04850848f, 0.00500574f, 0.03494439f, 0.03731048f, -0.00309656f, 
    0.02666881f, -0.03590329f, 0.02604321f, -0.04541596f, 0.01126292f, -0.03978902f, -0.00670571f, -0.00218669f, 
    0.01748147f, -0.05668642f, -0.01647202f, 0.01828557f, 0.03361458f, 0.04083811f, 0.03846271f, 0.03761097f, 
    0.02198337f, -0.05017387f, -0.05614338f, 0.02988311f, 0.02952572f, -0.03379693f, -0.00131634f, -0.06374747f, 
    -0.01128661f, 0.01915739f, -0.05488687f, 0.02614937f, 0.04367730f, -0.04064391f, 0.01601943f, 0.01315644f, 
    -0.00839467f, -0.01257717f, -0.04872328f, 0.01439934f, 0.02663212f, -0.00968391f, 0.02395552f, -0.04637881f, 
    0.02926918f, -0.00270088f, -0.00711609f, 0.03019146f, 0.03191388f, 0.03817176f, -0.02269400f, 0.01172951f, 
    -0.05848546f, 0.04829476f, -0.02085445f, 0.01068269f, 0.04140453f, 0.04141008f, 0.01178114f, -0.01514704f, 
    -0.05026710f, 0.01107840f, -0.03702545f, -0.02537072f, -0.04304700f, -0.05395362f, 0.00071768f, -0.05234265f, 
    0.01734144f, -0.06455512f, 0.00657647f, 0.05039143f, -0.03765203f, -0.02996605f, -0.05360515f, -0.00024688f, 
    -0.03769787f, 0.00291249f, 0.03213450f, 0.04657302f, 0.03440145f, -0.01617873f, -0.01141488f, 0.03263073f, 
    -0.05565495f, 0.00818099f, 0.05593691f, -0.05103643f, 0.00806656f, -0.05663498f, 0.00918087f, -0.00297172f, 
    -0.03939318f, -0.03234120f, 0.03476785f, 0.03132726f, -0.05423674f, -0.03940348f, 0.05453387f, 0.00816112f, 
    -0.03535220f, -0.00571355f, -0.05032533f, -0.04401274f, -0.00941351f, 0.02290962f, 0.04408235f, 0.02917721f, 
    -0.04493503f, 0.04137096f, -0.02033491f, -0.04754524f, -0.02463077f, 0.05544916f, -0.00380614f, 0.03810192f, 
    -0.01887607f, -0.05476151f, -0.03588404f, 0.04042065f, -0.04490088f, -0.02644194f, 0.01223966f, -0.00276116f, 
    -0.02516869f, 0.01397450f, -0.02010310f, 0.00515109f, 0.02706409f, 0.04622709f, 0.01123453f, -0.00552781f, 
    0.02875843f, -0.06222476f, 0.02831082f, -0.06511397f, -0.02437834f, 0.01226085f, -0.00731982f, 0.04143017f, 
    -0.00131525f, -0.04448806f, -0.04772580f, 0.04098509f, 0.02127992f, 0.03921995f, -0.01142206f, -0.03802042f, 
    -0.04012747f, -0.02332146f, -0.04816945f, 0.03662125f, -0.01118785f, 0.05029295f, 0.01862299f, -0.03382516f, 
    -0.03681219f, -0.02255703f, -0.01621483f, -0.02608564f, -0.03681096f, -0.03115357f, -0.01018101f, 0.02244503f, 
    -0.05485724f, 0.01108010f, -0.02623356f, -0.04283583f, 0.02669277f, -0.00019930f, 0.00516027f, -0.05361101f, 
    -0.02998137f, -0.00243217f, 0.05033723f, 0.00431726f, 0.03686889f, 0.05146559f, 0.03942236f, -0.02093585f, 
    -0.03418605f, 0.03792566f, 0.00632421f, 0.04859028f, -0.05911124f, 0.00669892f, 0.00399213f, -0.02188179f, 
    0.04349831f, -0.04725724f, -0.01998035f, -0.01593242f, -0.02852325f, -0.05000753f, -0.05475300f, 0.03486341f, 
    0.01332304f, -0.03388970f, 0.00732865f, -0.01926909f, -0.02819645f, -0.02322948f, -0.03441180f, 0.03885066f, 
    0.03914512f, -0.03437273f, 0.04781511f, 0.04177552f, -0.05540497f, -0.00045182f, -0.05866578f, -0.01498334f, 
    -0.05931714f, -0.04558585f, 0.02125916f, -0.03174636f, 0.01788015f, 0.03162597f, -0.05605743f, 0.04599321f, 
    -0.04928233f, 0.02616591f, 0.02062346f, -0.04541151f, -0.01183262f, -0.04383820f, 0.04649388f, -0.06101311f, 
    0.03903191f, -0.06610616f, 0.02756205f, 0.01674297f, -0.02591558f, -0.02810855f, 0.00867367f, -0.01176244f, 
    -0.01260772f, -0.05459537f, 0.00005054f, -0.01498865f, 0.01705375f, 0.05248917f, -0.02038615f, 0.03719178f, 
    -0.04899630f, 0.04182344f, -0.06069489f, 0.04094371f, -0.04191660f, -0.05240962f, -0.01705861f, -0.02787022f, 
    -0.01308356f, 0.00729469f, -0.04668216f, 0.02104859f, -0.03742644f, -0.01045770f, 0.04187082f, 0.05167931f, 
    0.01477533f, 0.00043598f, 0.01214486f, -0.05803354f, 0.01050119f, -0.00255472f, -0.03388738f, 0.04169802f, 
    -0.02087311f, 0.03174570f, -0.04038220f, 0.04706835f, 0.04906107f, -0.04407384f, -0.04916338f, -0.01353400f, 
    -0.05550349f, -0.04025698f, -0.05344493f, -0.03434853f, -0.01743333f, -0.02397669f, -0.00124276f, -0.03703555f, 
    -0.02447444f, -0.02190091f, -0.04298502f, -0.04297288f, -0.04207174f, 0.04859283f, -0.04504443f, 0.02461207f, 
    -0.01134613f, -0.03492625f, 0.01678209f, 0.04022563f, -0.03063696f, -0.03906256f, -0.02457650f, -0.04181258f, 
    -0.03211967f, -0.03057612f, -0.04406181f, -0.03380135f, -0.01347419f, 0.04316167f, -0.05930439f, 0.03106346f, 
    0.00140442f, -0.00433353f, -0.05956585f, 0.03717000f, -0.00883009f, -0.04874707f, -0.05801531f, -0.03027634f, 
    0.04703169f, 0.02610551f, 0.00645960f, 0.03347925f, 0.02959323f, 0.00897718f, 0.00246768f, 0.01777255f, 
    -0.01192271f, -0.05991709f, -0.02393470f, -0.01787242f, -0.01656888f, -0.04744386f, -0.03235739f, -0.04824998f, 
    0.03379439f, -0.02985604f, -0.06100428f, -0.03577904f, -0.00163986f, -0.04528675f, -0.00980973f, -0.04422449f, 
    0.01091742f, -0.00288003f, 0.01894210f, 0.00947110f, 0.03324190f, 0.01521614f, 0.04023191f, -0.00570380f, 
    -0.01253686f, -0.02545534f, 0.01422859f, 0.04101957f, 0.01851352f, -0.06421767f, 0.04645311f, -0.01535443f, 
    0.04146278f, -0.01928258f, 0.01149689f, 0.00507880f, -0.01271554f, 0.04438419f, -0.05977151f, -0.02085248f, 
    0.01929873f, -0.04932665f, 0.00395920f, -0.02477414f, -0.00694072f, -0.00126318f, -0.01169273f, -0.04260067f, 
    0.00639313f, 0.00119433f, -0.06389271f, 0.00632218f, 0.01228929f, -0.02176578f, -0.03668171f, 0.02960168f, 
    0.02326059f, 0.02502894f, 0.01400870f, 0.02398996f, 0.02367818f, -0.05013002f, -0.00058259f, -0.00828447f, 
    -0.05391364f, -0.01086544f, -0.06498144f, 0.02235853f, 0.03115554f, 0.00597922f, -0.02432576f, 0.03477092f, 
    -0.01286078f, -0.00201908f, -0.02140121f, 0.05060697f, -0.00910839f, -0.00852153f, -0.03665821f, -0.03586365f, 
    -0.02733841f, -0.06260496f, 0.04906495f, -0.03238909f, -0.01793738f, 0.02190413f, -0.00188852f, -0.03988022f, 
    -0.01146383f, 0.03322374f, 0.01578930f, 0.01265209f, -0.03941483f, -0.02426079f, -0.03713373f, 0.01458786f, 
    0.01965729f, -0.05681724f, -0.04044468f, -0.02242549f, -0.04265430f, -0.01599173f, -0.02822762f, -0.04319569f, 
    0.02953018f, -0.00500493f, 0.03363179f, -0.00130694f, -0.02760271f, 0.01659978f, 0.02021642f, -0.04245606f, 
    -0.02686631f, 0.01741839f, -0.00201152f, -0.02935794f, 0.03621056f, -0.05312931f, -0.04548863f, -0.02206742f, 
    -0.02993884f, -0.02559123f, -0.06702931f, -0.04469226f, 0.03039188f, -0.06447817f, -0.02619661f, -0.03426231f, 
    0.01919085f, 0.04289224f, 0.02633128f, -0.02323453f, -0.06513430f, 0.00878105f, -0.03771080f, -0.06559524f, 
    0.02676078f, -0.00436950f, 0.03239215f, 0.00648715f, -0.02647932f, -0.03645970f, 0.00134106f, 0.04992326f, 
    -0.03776657f, -0.06182363f, -0.06330946f, 0.03361630f, -0.04459774f, -0.02668097f, 0.05046315f, 0.02679529f, 
    -0.00617742f, 0.01760088f, 0.03718816f, -0.02552942f, 0.04266828f, 0.04790125f, -0.02645771f, 0.03965255f, 
    0.01054482f, -0.03775105f, -0.03101942f, -0.03135833f, 0.01693918f, 0.00185711f, -0.01996461f, -0.05245060f, 
    -0.05084845f, -0.02193967f, 0.02870210f, -0.06058257f, 0.00625907f, -0.02288762f, -0.01855267f, 0.04014972f, 
    -0.00110898f, -0.05043553f, 0.01860595f, 0.04129311f, -0.02500785f, 0.00677767f, 0.01431867f, 0.03126659f, 
    -0.04916085f, -0.00030621f, 0.05026263f, -0.00920076f, 0.04689299f, 0.00629234f, 0.00560155f, -0.01747457f, 
    0.05205195f, 0.00065896f, 0.04250579f, -0.05887877f, -0.03031091f, -0.00932109f, 0.01589066f, -0.02670779f, 
    0.00905180f, 0.02688574f, 0.04666337f, 0.04035398f, -0.02620278f, 0.02872122f, 0.04621094f, -0.03462815f, 
    0.04186439f, 0.00898995f, -0.02254359f, -0.00894568f, -0.03099127f, -0.01112484f, 0.00399301f, 0.00282106f, 
    0.00404613f, 0.04742993f, -0.04618301f, 0.03886428f, -0.03178900f, -0.02646016f, 0.04719862f, 0.03997114f, 
    0.03694146f, -0.01476683f, 0.01541033f, 0.00183505f, -0.06502749f, 0.00089925f, 0.02735742f, 0.03525544f, 
    0.04271997f, -0.04473603f, 0.00701080f, -0.01841670f, -0.00214403f, 0.03728712f, 0.02612358f, -0.03753730f, 
    0.04559939f, 0.03149049f, 0.03372644f, 0.01789562f, 0.02839193f, -0.00469891f, -0.02353879f, 0.02615868f, 
    -0.00695808f, 0.03660365f, 0.00362981f, -0.04999593f, 0.00004759f, -0.05592665f, 0.01043813f, -0.03453299f, 
    -0.05006433f, 0.02285605f, -0.05369456f, 0.00566463f, 0.05155439f, 0.03137742f, 0.00699064f, 0.03709689f, 
    -0.04453397f, 0.04927392f, -0.05753156f, 0.02862494f, 0.03670975f, -0.05316495f, -0.04361521f, -0.04973482f, 
    0.00336216f, -0.03610526f, -0.06349190f, 0.01508673f, -0.00876129f, 0.00177403f, -0.01903871f, -0.04505433f, 
    -0.03423566f, -0.05551689f, 0.02810231f, 0.03071189f, -0.01395524f, -0.05109234f, 0.02164339f, -0.02852974f, 
    -0.00585699f, -0.04629705f, -0.00215957f, -0.03917409f, 0.02355537f, -0.01215058f, -0.03995664f, 0.02376657f, 
    -0.03043462f, 0.03607694f, -0.04248150f, 0.00340891f, 0.03187960f, -0.04656919f, -0.00829218f, 0.02366891f, 
    -0.01986349f, -0.02995497f, -0.05228843f, 0.05000610f, 0.03041789f, -0.03550253f, -0.04383272f, -0.05121126f, 
    0.01549995f, 0.00071413f, 0.02442104f, 0.02653697f, 0.02646941f, -0.06388435f, -0.05874768f, 0.04102269f, 
    -0.00733278f, -0.03587294f, -0.04859323f, -0.03694027f, 0.03794709f, -0.01248300f, -0.01953524f, 0.00129261f, 
    0.00763267f, -0.02319993f, 0.04091036f, 0.00640095f, 0.03667966f, 0.04181098f, -0.02297766f, -0.03818366f, 
    -0.01842114f, 0.02536185f, 0.02323104f, -0.05796070f, -0.00524451f, -0.01625382f, -0.03414271f, 0.03249959f, 
    0.01724947f, -0.03662381f, -0.05046999f, -0.04491013f, -0.04823880f, 0.03210894f, -0.02590526f, -0.02657251f, 
    -0.04796672f, -0.01352582f, -0.05497619f, 0.02115129f, -0.04976209f, 0.01624314f, -0.03065519f, 0.00233174f, 
    -0.03595348f, -0.02153939f, -0.00148352f, 0.04638951f, 0.00153634f, 0.01811436f, -0.05136625f, -0.04561660f, 
    0.00178610f, 0.02841762f, -0.02541918f, -0.04468881f, -0.02394879f, 0.04031662f, -0.06462859f, -0.04960520f, 
    -0.05712426f, 0.01981962f, -0.05083444f, -0.03197430f, -0.05675412f, 0.00167785f, -0.02618953f, 0.02988735f, 
    0.04458696f, -0.04416238f, 0.02894844f, 0.02410897f, -0.05644158f, -0.04553955f, -0.05551583f, -0.05388656f, 
    0.02758547f, 0.01491526f, 0.00831974f, 0.00509335f, 0.02297810f, -0.01913503f, -0.04426370f, -0.04115799f, 
    -0.02230790f, 0.00872227f, -0.06485666f, 0.04629930f, 0.00223749f, 0.05173484f, -0.02267309f, 0.03163065f, 
    0.02396753f, -0.06470007f, 0.00316686f, 0.02056513f, 0.03102195f, 0.03507451f, 0.03892044f, -0.00332574f, 
    -0.00521118f, 0.02808820f, -0.03230279f, -0.06117432f, 0.04063807f, -0.03291580f, 0.02167304f, -0.02043747f, 
    0.01827286f, 0.00252486f, -0.06072028f, -0.04388109f, -0.04948943f, 0.03972661f, 0.03554577f, -0.04473995f, 
    -0.04780389f, -0.04088284f, -0.01559136f, -0.00474945f, -0.06011279f, 0.05257401f, 0.04633301f, 0.00448773f, 
    0.00521384f, 0.01028834f, 0.04889989f, -0.01717741f, -0.02246162f, -0.01299395f, 0.03727535f, 0.00023288f, 
    -0.04847460f, -0.06187915f, -0.02745245f, -0.00622248f, -0.05100175f, -0.03084022f, -0.00964175f, -0.01465574f, 
    0.00669809f, -0.03324740f, 0.04665024f, 0.00096432f, -0.03981396f, 0.00954756f, -0.03372087f, 0.01379616f, 
    0.04134385f, -0.04693555f, 0.01504139f, -0.02824855f, 0.02865115f, 0.02737847f, -0.02118000f, -0.02165157f, 
    0.05054754f, 0.01727672f, -0.03303201f, -0.04013557f, -0.00133688f, 0.02229389f, -0.06246623f, 0.03975588f, 
    0.03213473f, -0.02812127f, 0.01524613f, -0.01900990f, -0.01335877f, -0.00931562f, -0.03909620f, 0.03813868f, 
    0.00385657f, -0.04114313f, -0.00920175f, -0.05918907f, -0.02886236f, -0.01533109f, -0.05560505f, 0.04130317f, 
    -0.04303738f, -0.03309916f, -0.02095660f, 0.00492191f, -0.01766784f, 0.01458764f, -0.06239937f, 0.04316975f, 
    -0.05204713f, 0.00561704f, -0.04426925f, 0.00171606f, 0.00898894f, -0.05772333f, -0.05018054f, 0.05154949f, 
    -0.04992346f, 0.00307591f, -0.02798901f, -0.03443845f, 0.04616795f, 0.03924453f, -0.03668118f, -0.04719055f, 
    -0.14602710f, -0.03582923f, -0.36676261f, 0.41786912f, -0.07132797f, -0.02555106f, 0.00014899f, 0.05217952f, 
    -0.05193920f, -0.12940148f, -0.13975453f, -0.08271711f, -0.06536239f, 0.06405746f, 0.21755295f, -0.08667962f, 
    0.02820481f, -0.28759474f, 0.23960419f, -0.03976054f, 0.20895763f, -0.15950432f, 0.01671141f, -0.14126369f, 
    0.04967757f, -0.04677304f, 0.14930828f, 0.53342324f, 0.17081743f, 0.19373190f, -0.05680832f, -0.11652506f, 
    0.09932058f, 0.12314097f, 0.08288033f, 0.21144859f, -0.03033767f, 0.20444262f, -0.32496831f, -0.08463949f, 
    0.02098699f, 0.11428859f, -0.04392403f, 0.07596085f, -0.26226178f, -0.17075568f, 0.02572188f, 0.20097515f, 
    -0.08502382f, -0.08695988f, 0.09331785f, 0.03315144f, 0.01445537f, 0.18193696f, 0.59200668f, 0.09086490f, 
    -0.29133147f, 0.10843095f, 0.05568511f, -0.01294829f, -0.03841991f, 0.04535717f, -0.08745912f, 0.08983565f, 
    0.10157945f, -0.18381146f, -0.05019395f, 0.21128166f, 0.19665138f, -0.00699721f, 0.04274630f, -0.03689235f, 
    0.20603627f, 0.08324751f, -0.56776112f, -0.06888255f, 0.04647253f, 0.00620504f, 0.24141985f, -0.18632960f, 
    0.02068257f, 0.12947723f, -0.14395781f, -0.44005829f, 0.07031288f, 0.11215474f, -0.05477386f, -0.01619540f, 
    -0.03893443f, -0.35671028f, -0.35102612f, -0.42577976f, 0.15666090f, -0.34117892f, 0.09227715f, -0.16538538f, 
    0.05294299f, 0.04578124f, 0.09129281f, 0.18591714f, 0.29492545f, 0.05788956f, 0.17015323f, -0.22026457f, 
    -0.04312922f, -0.13103352f, 0.24079053f, 0.02876000f, -0.26166293f, -0.17840929f, -0.02485502f, 0.14062248f, 
    0.05586332f, -0.13307993f, -0.03085874f, -0.23452474f, -0.27604690f, -0.17799111f, -0.44159883f, 0.10705144f, 
    0.05900365f, -0.00152082f, 0.00015910f, 0.00516429f, 0.15638573f, -0.04259441f, 0.28274629f, 0.17042190f, 
    0.18223645f, 0.06603988f, -0.10889848f, 0.03809000f, 0.00711997f, 0.11819789f, 0.01941934f, 0.55430132f, 
    0.25350103f, 0.34482029f, -0.05401158f, -0.07505333f, 0.30072102f, 0.38497049f, 0.14576614f, 0.17622034f, 
    0.40715891f, 0.12432282f, 0.07974275f, 0.09868356f, 0.08812819f, -0.01681266f, -0.04247210f, 0.19344673f, 
    0.29634422f, -0.11470632f, -0.41620585f, -0.32227299f, 0.01176638f, 0.06310188f, 0.06279134f, 0.02792699f, 
    -0.02141903f, -0.27120060f, -0.29290724f, -0.16346833f, 0.19682129f, 0.05246585f, -0.00534289f, -0.11158849f, 
    -0.07703561f, -0.00060944f, -0.08624395f, -0.53887987f, -0.11749085f, 0.25811353f, 0.22800289f, 0.22894184f, 
    0.28806153f, 0.10424885f, -0.17345959f, 0.22669311f, 0.07589771f, -0.01420898f, 0.04575071f, -0.20742047f, 
    0.05255517f, -0.00778616f, -0.01981834f, -0.03289519f, -0.20696297f, -0.02227175f, 0.09971625f, -0.31441829f, 
    0.15710208f, 0.06223417f, 0.09284450f, -0.08454320f, 0.10204621f, 0.00694726f, -0.15434113f, 0.10943326f, 
    -0.16114034f, -0.06329786f, -0.10818493f, -0.01366284f, -0.03630356f, 0.13609251f, -0.22511874f, 0.58761597f, 
    0.49906081f, -0.15446517f, 0.04001245f, -0.15235828f, 0.14146173f, -0.09632687f, -0.03788022f, -0.08224166f, 
    -0.14221339f, -0.12423445f, -0.24913955f, 0.09127770f, 0.29358125f, 0.17734043f, 0.01710386f, -0.13993976f, 
    -0.02483803f, 0.01586111f, 0.08249089f, -0.11982926f, 0.31606230f, 0.23063932f, 0.18545420f, 0.15640804f, 
    0.00060637f, -0.13212126f, 0.00949291f, -0.15025157f, 0.02512072f, -0.06695541f, 0.00768998f, -0.07780667f, 
    -0.06141875f, -0.02410181f, -0.00555636f, -0.20879468f, 0.10808102f, 0.11147735f, -0.11377786f, 0.06797080f, 
    0.10091691f, -0.08502252f, 0.12763530f, -0.15819322f, 0.38557020f, 0.09807732f, -0.20971452f, 0.10138568f, 
    -0.06023310f, 0.02859638f, 0.02178960f, -0.24119447f, 0.13208538f, 0.09622469f, 0.08954556f, -0.10477769f, 
    0.02281167f, 0.09704905f, 0.11071048f, -0.06880439f, 0.14425473f, -0.03396660f, 0.24853691f, -0.02810447f, 
    0.32758090f, -0.08007898f, 0.20865102f, -0.11385272f, 0.06931809f, 0.10186970f, -0.00481805f, -0.32118154f, 
    -0.17489396f, 0.06020310f, 0.23453431f, -0.02229518f, -0.01290207f, 0.09409265f, -0.06622284f, -0.15667917f, 
    0.28097159f, 0.11443618f, -0.23959488f, -0.06841999f, 0.12645248f, 0.08046374f, 0.03057359f, 0.29054636f, 
    -0.00293260f, 0.56264651f, -0.21272822f, -0.19626381f, 0.07638638f, -0.14369123f, -0.10581540f, -0.08371996f, 
    0.03775539f, 0.06374608f, -0.74257225f, -0.20275453f, 0.26553598f, 0.02904142f, 0.12907816f, 0.04608735f, 
    0.05353655f, -0.02951735f, -0.04329923f, 0.02260360f, -0.35428128f, -0.13435864f, 0.19588275f, 0.04166999f, 
    -0.06394235f, -0.09608582f, -0.03434666f, -0.07814002f, 0.07999617f, -0.10598056f, 0.22982422f, 0.15408181f, 
    -0.02957258f, -0.14530721f, 0.24996531f, 0.12038695f, -0.16324113f, -0.15596007f, -0.07559901f, -0.12771870f, 
    0.04832499f, -0.21355145f, -0.16691655f, 0.03800141f, -0.01866144f, 0.14387557f, -0.20479223f, 0.24978541f, 
    -0.06209101f, 0.17548509f, -0.08648077f, -0.01206549f, -0.12084626f, 0.10765713f, -0.28387204f, 0.20837665f, 
    0.07099864f, 0.10071061f, -0.02698481f, -0.08198687f, -0.08833030f, -0.20501745f, -0.03010345f, -0.01960036f, 
    0.09873035f, 0.06835903f, 0.10530368f, -0.04048800f, 0.01795955f, 0.12397959f, -0.06528817f, -0.00641424f, 
    0.02030350f, 0.07204589f, 0.31097114f, 0.11203679f, -0.03963526f, 0.00024487f, 0.11464835f, -0.00625189f, 
    0.18129572f, 0.02982643f, -0.37252551f, -0.12562209f, 0.02909379f, 0.00815427f, 0.09097204f, -0.01181214f, 
    0.05157948f, 0.19322073f, -0.07272904f, -0.50893199f, -0.18935399f, 0.05240786f, 0.19951889f, -0.15433693f, 
    0.02450818f, 0.01988087f, -0.04407443f, -0.09915028f, 0.18158983f, 0.18642151f, 0.05899612f, 0.21995030f, 
    0.13790837f, -0.02709846f, 0.16359878f, 0.18238163f, -0.05499053f, -0.22712229f, 0.18058026f, -0.06506460f, 
    0.08877911f, 0.03759777f, 0.00368467f, 0.19237468f, 0.11184919f, 0.04125693f, -0.24115434f, -0.07812051f, 
    -0.08262323f, -0.05982452f, 0.04237392f, -0.12931803f, 0.15855852f, -0.06797533f, 0.06576073f, 0.14123559f, 
    -0.24186772f, -0.17445184f, 0.00844510f, -0.07294811f, -0.13592304f, -0.06309127f, 0.31979817f, -0.08141378f, 
    -0.43215898f, -0.34873354f, -0.18128237f, -0.05458675f, -0.08768719f, 0.02823025f, 0.00412287f, -0.04293714f, 
    -0.22230886f, 0.06400260f, 0.26634800f, -0.06141184f, 0.03970820f, 0.06804034f, -0.00790617f, 0.07679567f, 
    0.28459731f, -0.01315090f, 0.06844530f, -0.08417497f, 0.00233448f, 0.06079973f, -0.07489903f, -0.13766146f, 
    0.07412131f, 0.14267433f, 0.13200049f, 0.02161150f, -0.09948244f, -0.07669793f, -0.07764487f, 0.23362461f, 
    0.31173694f, -0.12288579f, -0.02257574f, -0.17661627f, -0.62517983f, 0.20818645f, -0.25611082f, 0.12856497f, 
    -0.00818314f, -0.00181847f, -0.00055737f, -0.00189082f, 0.14578557f, 0.13952696f, -0.14904808f, 0.29774904f, 
    -0.22800799f, 0.06169520f, -0.10072120f, -0.06566384f, 0.03515089f, 0.04287683f, 0.44042140f, -0.05032263f, 
    0.17396069f, 0.03054473f, 0.05585913f, -0.01978155f, 0.13176735f, 0.14540787f, 0.10223664f, -0.86267591f, 
    -0.40889791f, 0.20675364f, 0.06103150f, -0.04467673f, 0.06620083f, -0.09776319f, -0.20160799f, -0.05001586f, 
    0.00336560f, 0.15655889f, 0.12103297f, 0.09712925f, -0.02348141f, 0.06743386f, 0.06625811f, -0.14222139f, 
    -0.24963947f, 0.15116547f, 0.24493723f, -0.31186363f, -0.01718802f, -0.10561811f, -0.02743947f, -0.04922375f, 
    0.04252551f, -0.02362869f, -0.09168062f, 0.07341379f, -0.01375009f, -0.04782373f, -0.00774307f, 0.20252898f, 
    0.03917845f, 0.17302912f, 0.05306874f, 0.23825833f, 0.17048720f, 0.06386323f, 0.01389000f, 0.06608804f, 
    -0.03556067f, -0.12687485f, 0.27395698f, 0.10245232f, -0.25494874f, -0.13172777f, -0.00886048f, -0.01128952f, 
    0.00294855f, 0.06455232f, -0.23999803f, 0.04109854f, -0.14604524f, -0.40605319f, -0.13613521f, -0.11361870f, 
    0.12615621f, -0.03819389f, 0.12715070f, 0.11292695f, 0.16335306f, -0.07904784f, -0.27055377f, -0.09189260f, 
    -0.04785181f, 0.20287189f, -0.04362259f, 0.00762978f, 0.15537201f, 0.01234369f, 0.06047227f, 0.02211385f, 
    -0.18226939f, 0.05470724f, -0.03522435f, 0.01823154f, 0.13418543f, -0.06268976f, -0.00223135f, -0.00227995f, 
    0.24377911f, 0.02366863f, -0.10557504f, 0.05267502f, -0.13092996f, -0.18302369f, 0.13968804f, 0.05551984f, 
    -0.06490427f, 0.04396886f, 0.27647108f, -0.04759182f, 0.16645998f, 0.04371771f, 0.01504034f, 0.03963514f, 
    -0.03839559f, 0.05190301f, 0.43984497f, 0.08088074f, -0.01042721f, -0.05418006f, -0.03885441f, 0.08951838f, 
    0.29529700f, 0.01296767f, 0.13598472f, -0.11886985f, -0.39550167f, -0.06790270f, 0.09322155f, 0.05830932f, 
    0.01504294f, -0.00775477f, -0.03075735f, -0.22039746f, -0.37988332f, 0.01277162f, -0.14385143f, 0.04520070f, 
    -0.14982498f, -0.15113154f, 0.20121707f, 0.07255922f, 0.06757199f, 0.04047940f, 0.30346632f, -0.15259588f, 
    0.10359972f, 0.12876935f, 0.18223685f, -0.05139851f, -0.01098816f, -0.32143560f, 0.52546120f, 0.14582698f, 
    0.13256873f, 0.11154416f, 0.01886278f, -0.26241779f, -0.01668447f, 0.07741702f, 0.13780668f, 0.03282264f, 
    -0.01468034f, -0.04319619f, -0.03348435f, -0.14576001f, -0.15174513f, 0.09492067f, -0.08944725f, 0.03500802f, 
    -0.19806087f, -0.10076679f, 0.12372759f, -0.37666574f, -0.14976154f, 0.10124372f, -0.15539519f, -0.04473469f, 
    0.19859962f, -0.42655313f, -0.18106721f, 0.21111149f, 0.00173100f, -0.15425785f, 0.06630345f, -0.25004905f, 
    0.25899991f, 0.31906304f, -0.13360786f, 0.15313837f, 0.23590100f, -0.46666732f, 0.04810271f, 0.16663112f, 
    -0.24554196f, 0.09105239f, -0.09540796f, 0.20796849f, 0.20570613f, -0.03987716f, 0.12289918f, 0.13200454f, 
    0.18909110f, 0.04423706f, -0.01701368f, 0.10898361f, -0.33751285f, -0.10143339f, 0.07355981f, 0.25573650f, 
    0.11309457f, 0.36679667f, -0.18214725f, -0.23845215f, 0.13996726f, 0.21638143f, -0.23922001f, 0.11266350f, 
    -0.05738574f, 0.05270559f, -0.08846954f, -0.29416451f, 0.00375551f, 0.10274188f, -0.01660344f, 0.08468431f, 
    -0.03581705f, 0.25585729f, 0.36493590f, 0.24317200f, 0.14183979f, -0.13416024f, -0.12412419f, -0.01372461f, 
    -0.30973655f, -0.24318093f, 0.32108724f, -0.04598156f, -0.13098463f, 0.05221444f, 0.15626414f, -0.03220854f, 
    0.08462104f, -0.17860985f, -0.00593484f, 0.21626732f, 0.21379259f, 0.02122115f, -0.02983444f, 0.05164675f, 
    0.02270772f, -0.30903241f, -0.14908218f, 0.23009129f, 0.16417873f, -0.04665717f, 0.20800804f, -0.16833036f, 
    0.13287298f, 0.29447031f, -0.29938650f, 0.16589835f, 0.02441197f, 0.22415884f, 0.18961561f, 0.03898964f, 
    -0.27752981f, -0.08445469f, -0.21007445f, -0.22529273f, -0.53267366f, -0.14699398f, 0.02429050f, 0.19687667f, 
    0.16662289f, -0.07770482f, 0.03283316f, -0.15400758f, 0.02754552f, -0.36065486f, -0.05226041f, 0.21205765f, 
    0.20499013f, 0.16683184f, 0.07715616f, 0.02691097f, -0.00708975f, -0.12430012f, 0.11218812f, -0.17864802f, 
    -0.11627381f, -0.32850733f, -0.05122919f, 0.25488219f, 0.39563748f, 0.11553936f, -0.08093345f, -0.03308345f, 
    0.15532596f, 0.06670956f, 0.11259282f, -0.17830548f, 0.04335656f, -0.14742941f, 0.19799456f, 0.52743846f, 
    0.29919234f, 0.11702976f, -0.06782403f, -0.13325886f, -0.16381095f, 0.15842955f, 0.12168841f, -0.02019681f, 
    -0.08194029f, 0.19341633f, -0.03143993f, 0.01401699f, -0.12106550f, -0.02437496f, -0.20072605f, 0.16562752f, 
    0.14831306f, 0.05344263f, 0.10350196f, -0.13584797f, 0.04337300f, 0.12941983f, -0.39800540f, -0.01325862f, 
    0.03908740f, -0.01287165f, -0.05245925f, 0.08630536f, 0.20709687f, 0.18432383f, -0.05281176f, -0.07929043f, 
    -0.00948917f, -0.03272576f, -0.05331519f, 0.04222518f, 0.13308288f, -0.26527178f, 0.08980764f, 0.09419452f, 
    -0.09940720f, 0.02773366f, -0.11376060f, -0.20735328f, 0.23210089f, 0.21538091f, -0.03255518f, 0.01774160f, 
    -0.08861220f, -0.31835562f, 0.02310942f, 0.10685532f, -0.00534026f, -0.02099959f, -0.12515415f, -0.14677264f, 
    0.09116723f, 0.08881101f, 0.00984204f, 0.08897928f, -0.01617852f, -0.26012912f, -0.20443746f, -0.45104334f, 
    -0.13831718f, 0.28538990f, 0.20305400f, 0.16325992f, 0.13512611f, 0.13687803f, -0.33157924f, 0.07236262f, 
    -0.04404496f, -0.02973855f, -0.10702322f, 0.31593499f, 0.22148009f, -0.04490437f, -0.11540791f, -0.02320277f, 
    -0.31157255f, 0.05766991f, 0.00628189f, -0.18823729f, 0.18063714f, -0.01664895f, -0.11855308f, -0.13797332f, 
    0.18080975f, -0.13387972f, 0.16862988f, -0.26490158f, 0.07606148f, 0.14834642f, 0.12898651f, 0.14813609f, 
    -0.08337945f, 0.13668285f, -0.08422052f, 0.00530287f, -0.08744863f, -0.03775895f, 0.02408237f, 0.05773595f, 
    -0.00373015f, 0.10295961f, -0.17868559f, -0.17170684f, -0.09764370f, 0.18085836f, 0.01888566f, -0.13466801f, 
    -0.05641606f, -0.02260333f, -0.11027823f, 0.02917112f, 0.12484942f, -0.43187457f, 0.30699518f, -0.08580152f, 
    -0.23923182f, 0.03118699f, -0.03975675f, -0.03512488f, 0.07026944f, 0.08960223f, 0.31385955f, -0.30937293f, 
    -0.06569467f, -0.14384472f, -0.17641282f, 0.12805702f, -0.03156651f, -0.12248507f, 0.01748966f, -0.09150263f, 
    -0.07195427f, 0.03977194f, 0.15532887f, 0.07184604f, -0.19557959f, -0.01663919f, -0.11369831f, -0.15159425f, 
    -0.43545887f, 0.13481288f, -0.03523865f, -0.05766964f, 0.05821440f, -0.18461579f, 0.00057998f, 0.02825194f, 
    -0.02599910f, -0.28384522f, 0.48066780f, 0.15327962f, 0.11062035f, -0.07698005f, 0.03355202f, -0.10831255f, 
    0.08051772f, 0.19586779f, -0.15899330f, 0.01254574f, 0.03015209f, 0.07025977f, 0.03215268f, 0.02395446f, 
    0.11846386f, -0.01968500f, 0.43892545f, 0.38183385f, -0.47167411f, 0.10468084f, 0.23836567f, 0.20609812f, 
    -0.02906712f, -0.00932125f, 0.00799131f, -0.09138588f, -0.07102347f, 0.25007096f, -0.06410111f, 0.10323971f, 
    0.07648369f, 0.05830342f, -0.13749535f, 0.09816051f, 0.07877339f, -0.05961920f, 0.09961563f, -0.07965370f, 
    0.07275351f, 0.03863920f, -0.05136173f, -0.11142803f, 0.17061648f, 0.38969880f, -0.44824126f, -0.16268754f, 
    0.05204315f, 0.16429891f, -0.25954849f, -0.02026017f, 0.16496217f, 0.05408597f, -0.18242610f, 0.13772056f, 
    -0.09955897f, -0.02790688f, -0.00610259f, 0.06885691f, -0.07376330f, 0.00029341f, -0.09120508f, -0.47375718f, 
    0.12709822f, 0.18230739f, 0.05961360f, 0.05618655f, -0.07430433f, -0.08935154f, 0.02577177f, -0.18994559f, 
    -0.01884265f, -0.30354428f, 0.10042355f, -0.07412702f, 0.15047207f, -0.05770593f, -0.01450403f, -0.12314998f, 
    0.06434691f, 0.04752404f, -0.07870858f, -0.05312493f, 0.06195039f, -0.16629946f, 0.07439711f, 0.08258355f, 
    0.10649631f, 0.02853377f, 0.40003294f, 0.25865731f, -0.27938348f, 0.06285138f, -0.24528019f, -0.04103970f, 
    -0.06562637f, -0.08769757f, 0.03641024f, 0.30844301f, 0.46592450f, -0.06575207f, 0.00986703f, 0.15144943f, 
    -0.01404465f, -0.03026724f, -0.00509959f, -0.07493068f, 0.03901266f, -0.02301116f, 0.12027412f, -0.06115168f, 
    0.13357948f, -0.08146620f, 0.02225525f, 0.12023483f, -0.14472422f, -0.36282757f, -0.21999525f, 0.26339507f, 
    0.01801379f, 0.26991472f, -0.03306686f, 0.09837233f, 0.15542854f, 0.11349010f, -0.50330609f, 0.01549601f, 
    -0.02324043f, -0.16947633f, 0.17043014f, 0.24864128f, 0.10601546f, 0.04413265f, 0.18586135f, 0.23981395f, 
    -0.10013150f, 0.20516181f, -0.15262170f, -0.05386745f, 0.13908975f, 0.03462316f, 0.08440447f, -0.07396480f, 
    0.21379235f, -0.38881597f, 0.00012478f, -0.04471032f, 0.05179987f, 0.13443512f, -0.01075168f, -0.12151869f, 
    0.18847056f, -0.30825728f, 0.12225006f, -0.06558166f, 0.07756934f, 0.10045675f, 0.01580348f, -0.05554746f, 
    0.24501102f, -0.00325644f, -0.03882437f, -0.27540943f, 0.05606999f, 0.01186727f, -0.07261174f, -0.03507700f, 
    0.26705846f, 0.23431398f, 0.13369161f, 0.29727343f, 0.10934313f, 0.37953678f, 0.01246468f, 0.10115828f, 
    -0.27037650f, -0.00693557f, -0.01067336f, 0.05706709f, -0.11370791f, 0.02449549f, 0.00783584f, 0.02584286f, 
    0.17194614f, -0.02238712f, -0.12384073f, 0.01729997f, -0.20342150f, 0.04250662f, -0.58235234f, 0.16375542f, 
    0.03908290f, 0.10401399f, 0.06401322f, -0.06241126f, -0.13893336f, -0.26898518f, -0.42463550f, -0.14920600f, 
    0.26197714f, -0.26126444f, 0.03550277f, -0.00028318f, -0.09182107f, 0.03594384f, 0.00477639f, 0.25729960f, 
    -0.64312470f, -0.28548139f, -0.19430210f, 0.00609793f, -0.07837013f, 0.13484357f, 0.06459695f, -0.20405744f, 
    0.18545412f, 0.04078961f, 0.13107745f, 0.07252213f, -0.14305890f, 0.06456025f, 0.06249537f, 0.18920274f, 
    0.15077302f, 0.08794577f, 0.06716499f, 0.03262226f, 0.06021890f, 0.07810581f, 0.12351409f, 0.06621160f, 
    0.01652959f, -0.03378518f, -0.40538254f, 0.13666829f, 0.28784034f, 0.27641732f, 0.03346830f, -0.43850625f, 
    0.04927474f, 0.00367053f, -0.16768993f, -0.04833291f, -0.70659983f, -0.26510897f, 0.03834498f, 0.01819026f, 
    0.03943583f, 0.05044774f, 0.11245424f, 0.08502677f, -0.12140724f, -0.11818536f, -0.32185623f, -0.12779039f, 
    0.09076855f, 0.15468416f, 0.08503036f, 0.01023105f, -0.08171562f, 0.25233969f, -0.02456696f, -0.54625237f, 
    -0.04731769f, -0.05127965f, 0.00100294f, 0.06568753f, 0.00837921f, -0.09401101f, -0.27989131f, -0.04368474f, 
    0.33217734f, 0.24113353f, -0.10040496f, -0.14657630f, 0.16263258f, 0.00888996f, 0.02680785f, 0.06759744f, 
    0.03600179f, 0.07441846f, 0.16567199f, -0.01196760f, 0.13228001f, 0.19448470f, 0.23860633f, 0.05820964f, 
    -0.29370546f, -0.04991451f, 0.28983626f, 0.27772877f, -0.07374753f, 0.00336039f, -0.00245401f, 0.01888541f, 
    0.08098682f, -0.37360853f, 0.12485962f, 0.09998783f, -0.07880606f, -0.02070185f, 0.05019083f, -0.25154757f, 
    -0.02613241f, 0.01763553f, -0.06399285f, -0.31327820f, -0.00514598f, 0.05167753f, 0.21548779f, 0.04980484f, 
    0.07406048f, -0.10820247f, -0.09986942f, 0.32489824f, 0.17064284f, 0.47625798f, 0.11201046f, 0.03905046f, 
    0.11245458f, -0.00077213f, 0.30884668f, 0.04905159f, -0.00138768f, 0.27574947f, 0.02754269f, 0.07065478f, 
    -0.13272282f, 0.11585869f, 0.01565039f, 0.11427390f, -0.16005795f, 0.05253159f, -0.38840410f, -0.08908869f, 
    0.16604774f, 0.13334738f, 0.10216890f, -0.06052654f, -0.03745769f, 0.23159245f, 0.31366923f, 0.10295930f, 
    0.30249417f, 0.15193903f, -0.03476396f, -0.18894945f, 0.14079018f, -0.12217499f, 0.12669532f, -0.17486487f, 
    -0.30540299f, 0.24484180f, 0.04359632f, -0.06613033f, -0.32739156f, 0.03453127f, 0.10175911f, 0.06940135f, 
    -0.03521606f, -0.39210504f, -0.21812752f, 0.01304163f, -0.08631837f, -0.04578952f, -0.05857609f, -0.10711561f, 
    0.02463279f, -0.40747094f, 0.22865684f, 0.01611052f, -0.05727494f, -0.15749675f, 0.09588465f, -0.11148920f, 
    0.03033173f, -0.05258104f, -0.15746209f, 0.35815871f, 0.05666303f, 0.06427615f, 0.04388664f, -0.00827512f, 
    0.04168413f, 0.19991490f, 0.05528075f, 0.27668941f, -0.12695195f, 0.08800712f, -0.08800164f, 0.07783522f, 
    -0.04049404f, -0.14002848f, 0.15520453f, -0.08416730f, 0.10785291f, -0.08045725f, 0.22819513f, 0.00347553f, 
    -0.19400576f, -0.09730828f, 0.24368085f, 0.03152991f, 0.16030622f, -0.24943599f, -0.28222838f, -0.03497753f, 
    -0.11501725f, 0.04862009f, -0.00821962f, 0.04031957f, 0.20259076f, 0.01844595f, -0.08563928f, 0.13565421f, 
    -0.02415416f, 0.18250470f, -0.10445984f, 0.03743474f, 0.02663820f, -0.06333256f, -0.16507117f, -0.42331976f, 
    0.18246420f, 0.46661106f, 0.09620291f, -0.09334550f, -0.30024838f, -0.03163122f, 0.05110803f, 0.17410199f, 
    0.26993299f, 0.04958774f, -0.02273291f, 0.15119056f, 0.03402880f, 0.14143407f, -0.15434274f, -0.00093609f, 
    -0.01994263f, -0.07345505f, -0.04863989f, 0.23887312f, 0.08927572f, -0.10653851f, 0.08050004f, -0.11881442f, 
    0.13283412f, -0.04789640f, -0.20975995f, -0.02964725f, 0.08741827f, 0.14585638f, -0.19685833f, -0.00601866f, 
    -0.00442826f, 0.21007393f, -0.06800535f, 0.00625958f, 0.11091971f, -0.18840796f, 0.11247052f, 0.03836772f, 
    0.09888341f, -0.11171656f, 0.30974090f, 0.07609088f, -0.39312792f, -0.15993795f, 0.19212218f, 0.18712831f, 
    -0.07510410f, 0.04206329f, 0.09091223f, 0.01047321f, 0.01452516f, -0.23324765f, -0.09239168f, 0.12972473f, 
    -0.03025781f, 0.04251370f, -0.06202894f, -0.00705745f, -0.14750208f, 0.16196673f, -0.11756051f, -0.22990598f, 
    0.22454090f, 0.15952781f, -0.03067430f, -0.02912767f, 0.16814494f, 0.06856455f, 0.10679962f, -0.01280065f, 
    0.10725030f, -0.37365508f, -0.08466596f, 0.19424824f, -0.00273144f, -0.04322149f, -0.15348735f, 0.17330351f, 
    -0.04705560f, -0.04882958f, 0.01439931f, -0.02486271f, -0.04686467f, 0.02015948f, -0.02185752f, 0.03006627f, 
    0.01198252f, 0.01316716f, -0.01950004f, 0.02937661f, -0.04263357f, -0.00423545f, 0.00786908f, 0.04734748f, 
    -0.04274536f, -0.03693281f, 0.04083383f, 0.05311954f, -0.03769403f, 0.00836728f, -0.04515258f, -0.01138998f, 
    -0.03111332f, -0.05708421f, -0.04583622f, -0.01697135f, -0.01887854f, -0.04766176f, -0.02455236f, -0.02012763f, 
    -0.01075222f, 0.01410457f, -0.01935851f, -0.05677770f, -0.01321360f, -0.05594799f, -0.00596744f, -0.03731900f, 
    -0.06372427f, -0.02736263f, 0.04567849f, -0.05604756f, 0.04664753f, -0.00678461f, -0.01107769f, -0.05415024f, 
    -0.05219788f, 0.04486383f, -0.00190355f, -0.00232840f, 0.01371476f, -0.06487364f, 0.02230122f, -0.05125109f, 
    -0.04888794f, 0.00293315f, 0.04270227f, -0.03660982f, -0.02880085f, 0.02657068f, -0.05258587f, -0.06504518f, 
    -0.00648885f, 0.02555019f, -0.02865410f, -0.01650263f, 0.04071545f, 0.00907144f, -0.02573919f, -0.01078233f, 
    -0.00047631f, 0.04436421f, 0.04408919f, -0.00186440f, 0.03147654f, -0.03702385f, -0.03288353f, -0.05605671f, 
    -0.01952104f, 0.01814927f, -0.00961222f, 0.03608727f, -0.04149508f, -0.05754507f, -0.01050150f, -0.02332931f, 
    0.03488711f, -0.00999018f, -0.06560770f, 0.03373728f, -0.00913877f, -0.06175282f, -0.04416067f, 0.02422925f, 
    -0.06122505f, -0.02790738f, -0.00460621f, -0.04130046f, 0.01247136f, -0.00834222f, -0.04040305f, -0.04392241f, 
    -0.01588028f, 0.01467989f, -0.05792348f, -0.04419887f, -0.02337081f, -0.00503754f, -0.00010237f, -0.02516417f, 
    0.04941368f, 0.01883164f, -0.02984686f, 0.03063514f, 0.01285516f, -0.01996579f, 0.00050537f, 0.00958603f, 
    -0.04924316f, -0.02146782f, -0.04377867f, -0.01224567f, 0.03343447f, 0.01490967f, -0.06248702f, -0.03943320f, 
    -0.00428562f, 0.03427819f, -0.00160649f, 0.01804437f, 0.02050186f, 0.00373913f, 0.01157975f, 0.02880036f, 
    -0.03580511f, -0.05255732f, -0.05333222f, -0.01562664f, -0.02153789f, 0.01923700f, 0.01396149f, -0.04010509f, 
    0.00860394f, 0.00655955f, -0.03779301f, -0.01200703f, 0.01612456f, -0.00450174f, 0.05651368f, 0.02245193f, 
    -0.00474459f, 0.00498776f, -0.01063089f, 0.01250820f, 0.00790970f, -0.00103122f, -0.01611475f, 0.03795477f, 
    -0.03985375f, 0.03082402f, 0.00080824f, -0.02306361f, -0.02206022f, -0.05672457f, 0.03578775f, -0.02846777f, 
    0.03351821f, -0.03018463f, 0.01960936f, -0.01062994f, -0.06131665f, -0.05874883f, -0.06773874f, -0.04964189f, 
    -0.03179980f, 0.04848800f, 0.02929886f, 0.04697084f, 0.01174387f, -0.00023524f, -0.00728599f, 0.05065951f, 
    -0.05912251f, -0.04625961f, 0.04550437f, 0.03111115f, -0.02995335f, -0.02283577f, -0.03953043f, -0.01454498f, 
    -0.06031524f, -0.00100647f, -0.00488954f, 0.04506141f, 0.04920856f, 0.04927607f, -0.02239708f, 0.02352759f, 
    0.03335996f, -0.00574577f, -0.06536329f, 0.01504470f, -0.01115007f, -0.05799552f, 0.03686164f, 0.04143510f, 
    -0.04856034f, -0.05493931f, -0.02352407f, -0.00238415f, -0.05200515f, 0.01531112f, -0.03118218f, 0.03497211f, 
    0.04881834f, 0.03441902f, -0.00032744f, 0.01513952f, -0.05536433f, 0.04813635f, 0.03869439f, 0.03779344f, 
    -0.02432034f, 0.02796624f, -0.03784531f, -0.03239696f, -0.05336421f, -0.01804312f, -0.00428232f, 0.00545145f, 
    -0.06298368f, 0.03214987f, 0.02055068f, 0.02611833f, -0.06737873f, -0.01844558f, -0.00288633f, -0.01977103f, 
    0.02853974f, -0.06368578f, -0.05486592f, 0.03203529f, -0.04343324f, 0.04866948f, 0.03248528f, 0.01267508f, 
    0.01009624f, -0.00585224f, -0.00807638f, -0.04277888f, -0.02371731f, 0.02596475f, 0.02090241f, 0.03650457f, 
    0.04484778f, 0.01648805f, -0.02269972f, 0.01886491f, -0.04981335f, 0.02591353f, -0.04221879f, -0.04906490f, 
    0.02318379f, 0.02147599f, 0.01125409f, -0.00810251f, 0.02590564f, -0.02339004f, 0.03276761f, 0.00529436f, 
    -0.00011399f, 0.02796023f, 0.03548162f, -0.02535226f, -0.00249576f, -0.02460327f, 0.02350929f, -0.02790235f, 
    0.04261866f, -0.03066409f, 0.02048667f, -0.04251666f, -0.03951257f, -0.02828329f, 0.01812677f, 0.04499884f, 
    -0.44846219f, 0.00044852f, -0.17388336f, 0.02986114f, -0.08901447f, -0.13740394f, -0.06322176f, 0.11959622f, 
    -0.01559002f, -0.24464789f, -0.34836149f, -0.33113551f, 0.07440916f, 0.11518220f, -0.05903243f, -0.04924269f, 
    0.23419993f, -0.01153448f, 0.27315560f, -0.28021616f, -0.19370817f, 0.15245399f, 0.02788678f, 0.26637331f, 
    0.14917549f, -0.15714842f, 0.13706592f, -0.18590106f, -0.00688685f, 0.30260164f, -0.12846701f, 0.02915392f, 
    -0.01689914f, 0.00779202f, 0.00644004f, 0.13601463f, -0.10996022f, 0.19568479f, -0.19067357f, 0.06871462f, 
    0.14273719f, -0.19364761f, 0.20111001f, 0.00951330f, 0.12249073f, 0.00129456f, -0.11482756f, -0.02814126f, 
    -0.17676964f, -0.11618797f, -0.15557890f, 0.08191323f, 0.01531693f, -0.15690428f, -0.17744498f, 0.06730354f, 
    -0.08557451f, -0.35885888f, 0.06469642f, 0.01324670f, -0.05182760f, 0.06759462f, 0.04649154f, -0.30345434f, 
    -0.20998658f, 0.23138371f, -0.29817852f, 0.03028058f, 0.01903046f, -0.19823039f, 0.07275055f, 0.08292147f, 
    0.40468955f, 0.43598875f, -0.18930520f, 0.02192709f, 0.05761820f, 0.15945448f, 0.22406808f, 0.07292352f, 
    0.12009402f, 0.23610705f, 0.22651358f, 0.17040265f, -0.05848771f, 0.10553067f, -0.07693380f, 0.09334654f, 
    0.05731706f, -0.01607891f, 0.11792127f, -0.34029144f, -0.22997923f, 0.38286877f, 0.07724887f, 0.15582758f, 
    0.01896621f, -0.15514766f, -0.06903157f, 0.03635194f, -0.03585637f, 0.01526096f, -0.15690552f, 0.01983186f, 
    -0.02354329f, -0.08991451f, 0.04423867f, -0.23057087f, 0.24769825f, 0.22925080f, -0.17998043f, -0.06971900f, 
    -0.02875376f, -0.09895648f, 0.08349671f, -0.01888884f, 0.16409792f, 0.00212991f, -0.16525567f, -0.05047773f, 
    -0.11278667f, 0.08935781f, -0.13195093f, 0.09492330f, -0.10704772f, 0.05840401f, 0.23529086f, 0.01083388f, 
    0.11879772f, -0.49521533f, 0.04329161f, -0.00326171f, 0.21626268f, 0.09767842f, 0.11956991f, 0.12883982f, 
    0.25828671f, 0.19787885f, -0.07611206f, 0.07385798f, -0.03654906f, -0.09993580f, 0.15775727f, 0.03468191f, 
    0.48344627f, 0.10199886f, 0.04826134f, -0.23402752f, 0.04743773f, -0.05100545f, 0.09654675f, 0.25898793f, 
    0.21214232f, 0.38722512f, 0.22483145f, 0.09614858f, 0.01953754f, 0.01222868f, -0.20871864f, -0.06478479f, 
    -0.05198335f, -0.02634892f, 0.41286987f, 0.03680919f, -0.21081689f, 0.06280353f, -0.18340978f, 0.05496263f, 
    -0.01068332f, -0.01504717f, -0.02285925f, -0.09594306f, 0.02118346f, -0.35438412f, 0.06535611f, 0.02725699f, 
    -0.07508928f, -0.22758223f, 0.19369105f, 0.12409971f, -0.23270907f, 0.28646207f, 0.13827170f, 0.11091002f, 
    -0.11910003f, -0.15751797f, -0.05123965f, 0.13450259f, 0.09875411f, 0.18280229f, -0.63111258f, 0.15185915f, 
    0.24567705f, 0.26984289f, 0.04204575f, -0.14993012f, 0.19407585f, -0.11095939f, -0.32558516f, -0.22676162f, 
    -0.13426517f, 0.23471314f, -0.09335794f, -0.18625784f, 0.06738611f, -0.13937256f, 0.02159755f, 0.00662005f, 
    0.11474306f, -0.30540359f, -0.37995294f, -0.00391351f, 0.07932741f, -0.13123673f, -0.01677002f, -0.03188985f, 
    -0.42557329f, -0.40403941f, -0.02000967f, 0.12315856f, 0.07204932f, 0.10252414f, -0.06722501f, 0.00271401f, 
    -0.06712142f, -0.27724552f, 0.03821450f, -0.22718631f, -0.02135606f, -0.00762769f, -0.07313164f, 0.08381952f, 
    0.03993827f, -0.01963770f, 0.14750926f, -0.23430097f, 0.28249544f, -0.07443042f, -0.02244801f, 0.10226663f, 
    0.02875653f, 0.00456420f, 0.06123603f, 0.14405662f, 0.31843206f, 0.25011820f, -0.05377008f, 0.09562916f, 
    0.23254132f, 0.15028329f, -0.13799274f, -0.07484162f, -0.24912427f, 0.14209604f, -0.19977286f, -0.06998299f, 
    -0.00673692f, -0.10902487f, 0.01298593f, -0.01285112f, -0.05190939f, 0.13216482f, 0.14411399f, -0.22027238f, 
    -0.20443298f, -0.10758075f, 0.00842980f, 0.02555179f, 0.26911095f, 0.01286454f, 0.06939702f, 0.21499567f, 
    -0.17697774f, -0.12906796f, 0.12058894f, 0.12958966f, -0.00055578f, 0.18412127f, 0.02056061f, -0.23256274f, 
    -0.10042976f, 0.06595750f, -0.08878794f, -0.05318406f, -0.05427028f, -0.04457532f, 0.12663560f, 0.17841201f, 
    0.00662926f, 0.00388641f, 0.04785822f, -0.02917797f, -0.01517992f, -0.04007798f, -0.01792390f, -0.03533235f, 
    -0.04545137f, 0.02330530f, -0.03273776f, 0.02074959f, 0.00906733f, -0.04419545f, -0.02013026f, 0.04226674f, 
    -0.05491602f, 0.03513037f, -0.06609290f, 0.02480500f, -0.04966892f, 0.01174760f, 0.03764473f, -0.01927371f, 
    -0.04243596f, -0.05340392f, 0.02456956f, -0.04473268f, -0.01039690f, 0.02297583f, 0.02573736f, 0.02248570f, 
    -0.03107942f, -0.03980372f, -0.01593603f, 0.01029867f, -0.00382512f, 0.04626212f, -0.00994969f, 0.01434020f, 
    0.00572096f, 0.04506981f, -0.04441911f, -0.01151601f, 0.02953051f, -0.02776650f, 0.04022621f, -0.05854186f, 
    0.02021544f, -0.02026111f, 0.00778472f, 0.01175117f, 0.05711295f, -0.01580746f, 0.03263316f, -0.06444073f, 
    -0.02309286f, -0.04734949f, -0.03151929f, -0.05269711f, -0.03848461f, -0.03242645f, 0.01612925f, -0.06485222f, 
    -0.01155417f, -0.04302638f, 0.01663220f, -0.04181873f, 0.01752227f, 0.02167835f, -0.00916181f, -0.06197409f, 
    -0.00856191f, 0.00670196f, 0.05239157f, -0.05480599f, -0.06198079f, -0.02177901f, 0.00683171f, -0.05727589f, 
    0.01289469f, -0.00596067f, 0.03784027f, 0.00777882f, -0.00322659f, -0.06102946f, -0.01335104f, -0.03587975f, 
    -0.06586056f, 0.04745854f, 0.04426707f, 0.03950414f, -0.00108955f, 0.00794436f, -0.04960092f, -0.04306993f, 
    -0.04055657f, -0.04171514f, 0.00247649f, -0.04446506f, -0.03245101f, 0.03298225f, 0.01891429f, -0.05498974f, 
    -0.06056698f, 0.03789253f, 0.04547732f, -0.03737128f, 0.01864276f, -0.03460758f, 0.05758762f, -0.03310707f, 
    -0.03201222f, 0.02439624f, 0.03701368f, -0.02419739f, -0.03795570f, 0.04835232f, -0.04328721f, 0.03611040f, 
    -0.02338281f, 0.02025334f, -0.01228569f, 0.01258263f, 0.00265597f, -0.06336177f, -0.01029855f, 0.00104174f, 
    0.01391377f, 0.04954302f, -0.00362516f, 0.04242759f, -0.05122582f, 0.02881386f, -0.01221196f, -0.01536333f, 
    -0.02792660f, -0.05765568f, 0.03642832f, -0.01324630f, 0.03995283f, 0.04659168f, 0.00986996f, -0.03392325f, 
    0.01096904f, 0.01854563f, 0.03249408f, -0.03621519f, 0.04391728f, -0.00815167f, -0.05038162f, 0.02517322f, 
    -0.01660636f, 0.03246097f, -0.02131004f, 0.01486836f, -0.04581119f, -0.01576091f, -0.02540311f, -0.05390536f, 
    -0.01762720f, -0.02439704f, -0.01888383f, 0.01122661f, -0.02534755f, -0.05602411f, -0.03508283f, 0.01856741f, 
    0.04806640f, -0.01799817f, -0.03378217f, 0.04268433f, -0.00612961f, 0.02532325f, -0.01039667f, 0.02023442f, 
    -0.00892321f, -0.06045289f, -0.04663007f, 0.01730464f, -0.06417946f, 0.05257495f, -0.05772987f, 0.01307423f, 
    0.00069115f, 0.02060940f, 0.03993025f, -0.03671195f, 0.01813323f, -0.04060144f, -0.06332437f, -0.04028650f, 
    0.00502127f, 0.04480106f, 0.02901850f, -0.06230606f, -0.02122390f, -0.03478980f, -0.04558984f, 0.05550272f, 
    -0.03862521f, -0.06031182f, -0.05317942f, 0.05000528f, 0.00033441f, 0.01600146f, -0.05968522f, 0.00790989f, 
    -0.06703535f, -0.06521168f, 0.01134272f, -0.01089983f, 0.03001289f, 0.00131111f, -0.01195562f, 0.01885528f, 
    0.04640428f, -0.00304023f, 0.03157622f, -0.05403737f, -0.04869989f, -0.04642305f, -0.03387037f, 0.04396902f, 
    0.05436790f, 0.03093264f, 0.04759711f, 0.02236368f, 0.04381107f, 0.01101798f, 0.01387535f, -0.03240468f, 
    -0.00534808f, 0.03572616f, -0.02126891f, -0.01600608f, -0.03963215f, 0.00056598f, -0.05814326f, 0.01206272f, 
    0.04197234f, 0.03624491f, -0.03507902f, -0.01902798f, -0.00054549f, 0.05397110f, -0.04847148f, -0.01951044f, 
    0.03111435f, -0.05084596f, -0.04413512f, 0.02012770f, -0.02768319f, -0.00067495f, -0.04249351f, -0.02002312f, 
    -0.04317112f, -0.03036686f, -0.01793095f, 0.02237105f, 0.06641752f, 0.01697780f, -0.04248018f, -0.00321334f, 
    -0.05905559f, -0.03430405f, -0.00076982f, 0.01605389f, 0.04869297f, -0.01912021f, 0.00031467f, -0.05002757f, 
    -0.03073012f, 0.00656390f, -0.00335295f, 0.04497555f, -0.05662464f, -0.06198237f, -0.03664890f, 0.00846810f, 
    0.00834121f, -0.03543158f, 0.02536399f, 0.04805176f, 0.04142993f, -0.02126833f, -0.02780312f, 0.03153026f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01906616f, 0.19452649f, 0.03482918f, -0.01670912f, 0.13624024f, -0.04269276f, -0.01148808f, 0.02626747f, 
    -0.19629921f, 0.14158033f, 0.00569448f, 0.03859096f, -0.12074021f, -0.08725617f, -0.02043010f, 0.00003646f, 
    0.01206144f, -0.18892838f, 0.04547793f, 0.02287043f, 0.09370610f, -0.05633360f, -0.03103241f, -0.01946063f, 
    -0.04443223f, 0.09038224f, 0.08737694f, 0.05507208f, 0.23202759f, 0.00492193f, 0.03997558f, 0.02621556f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11293320f, -0.51545638f, 0.38436344f, -0.46853682f, -0.26055354f, -0.09027340f, -0.08564906f, -0.15672334f, 
    0.52281040f, 0.15140286f, -0.33782727f, -0.19402480f, 0.50183803f, -0.03669225f, 0.75672787f, 0.07699826f, 
    0.14108981f, -0.31843135f, -0.15009010f, 0.05649531f, -0.55571848f, -0.13158993f, 0.15243877f, -0.00782248f, 
    -0.20880829f, 0.23203851f, -0.26149803f, -0.11536262f, 0.05151157f, 0.12748714f, 0.38168028f, 0.04156350f, 
    0.03592137f, -0.17247421f, -0.36319828f, 0.52644330f, -0.21286668f, 0.13238570f, -0.09221835f, 0.15812162f, 
    -0.26644614f, 0.12961006f, -0.20732255f, 0.40754420f, -0.39866540f, 0.11493122f, 0.27255371f, 0.10785015f, 
    0.09273084f, -0.25153491f, -0.13799185f, 0.12686905f, -0.23299298f, -0.07020462f, 0.15548164f, -0.05293931f, 
    0.05649439f, -0.16023327f, -0.40561876f, 0.89772481f, -0.13791573f, -0.15082079f, 0.43173727f, 0.09883625f, 
    0.04949433f, -0.12571834f, -0.05265221f, -0.14203750f, 0.40768117f, 0.01163508f, -0.05473053f, 0.08260943f, 
    -0.02175741f, -0.47970942f, 0.70564115f, 0.00968538f, 0.40868261f, -0.71945894f, -0.60781223f, 0.09965567f, 
    0.00104909f, 0.27020425f, -0.09619670f, 0.03110499f, -0.21571650f, -0.08098984f, 0.04649621f, -0.13306895f, 
    -0.02669758f, -1.26469374f, 0.06879865f, 0.46823752f, -0.30709368f, -0.09116795f, 0.39442551f, -0.13891877f, 
    -0.14530042f, -0.52125716f, 0.28677887f, 0.02120965f, 0.08183381f, -0.03408239f, 0.04541137f, -0.10295976f, 
    0.36269245f, -0.73631340f, 0.41322681f, -0.40649417f, -0.32360834f, 0.73462218f, -0.30913201f, -0.14627528f, 
    -0.03461396f, -0.35118017f, 0.08398591f, 0.00772019f, -0.07445350f, 0.13028036f, 0.01599458f, 0.14092582f, 
    -0.51554441f, 0.39139330f, 0.09951307f, 0.31379873f, 0.07843296f, 0.15854418f, -0.21868667f, 0.04748920f, 
    -0.08261155f, 0.26937976f, 0.22288045f, -0.68924159f, 0.15297510f, 0.09239066f, -0.15047561f, -0.15204889f, 
    -0.49992010f, 0.12684591f, -0.21340863f, -0.17059144f, 0.22647329f, -0.35311079f, -0.28911510f, 0.01225246f, 
    -0.03448034f, 0.14885163f, 0.14232942f, -0.00267541f, -0.27888331f, 0.10260082f, -0.07939927f, -0.03251004f, 
    -0.63786447f, 0.14707379f, 0.32143316f, 0.21168859f, 0.49252960f, -0.16381501f, -0.34356204f, -0.12336383f, 
    0.04602653f, 0.65936714f, -0.49002051f, -0.12326194f, -0.03689119f, -0.09297743f, 0.15642869f, 0.12432858f, 
    0.28662235f, 0.54395461f, -0.38804373f, 0.35455537f, -0.50818139f, 0.09025409f, 0.08879269f, -0.12393798f, 
    -0.07417734f, -0.78851181f, 0.06392748f, 0.07139262f, -0.44535112f, -0.14241961f, -0.06149414f, -0.05717922f, 
    -0.03516304f, -0.28070906f, -0.34708196f, -0.67486948f, 0.04023213f, -0.15245311f, -0.05409528f, 0.02114625f, 
    0.00687776f, 0.41594756f, 0.45970261f, 0.02608707f, -0.34496427f, -0.11262527f, 0.02750130f, -0.00871053f, 
    -0.00066851f, -0.30760708f, 0.12894775f, -0.68056065f, -0.27259037f, -0.39454558f, 0.44855073f, -0.15673041f, 
    0.15228662f, -0.05334991f, -0.05470563f, 0.15782088f, -0.80649024f, 0.00091969f, -0.08368639f, 0.06525959f, 
    0.49268359f, -0.47195911f, 0.25862572f, -0.29094917f, 0.11112575f, 0.05131361f, -0.71710330f, 0.06288488f, 
    -0.07628483f, -0.17300506f, 0.11505228f, -0.20492056f, -0.54271942f, -0.11421578f, 0.16706349f, -0.14959337f, 
    0.15987462f, 0.50903845f, 0.18758556f, 0.18230549f, 0.22813651f, 0.19266874f, -0.31020933f, 0.07256934f, 
    0.06940666f, 0.98956972f, -0.11826273f, -0.10854884f, 0.10709118f, -0.11166864f, -0.09171204f, 0.03068877f, 
    -0.58204842f, 0.32075262f, -0.53495073f, -0.22531393f, -0.48709503f, -0.09612224f, -0.02784682f, 0.08579539f, 
    0.04276270f, -0.27680111f, -0.49023062f, 0.48664972f, -0.13428380f, -0.15741931f, -0.10929327f, 0.03550218f, 
    0.21465629f, -0.25477919f, -0.33818090f, 0.52063906f, 0.10894987f, 0.13213861f, -0.15374547f, 0.09315220f, 
    0.05229968f, -0.18483253f, -0.05365168f, 0.09467512f, 1.00752461f, -0.13793209f, 0.08448729f, 0.16673653f, 
    0.03645780f, -0.22782326f, -0.46572465f, -0.59098166f, 0.25374502f, 0.03188324f, -0.29927543f, 0.09555238f, 
    0.11442239f, 0.14486128f, 0.16669548f, -0.54487097f, 0.23446837f, -0.03444241f, -0.17414157f, -0.09090657f, 
    0.19522730f, -0.09845911f, -0.57316166f, -0.77393901f, -0.58961368f, -0.26563942f, -0.05079486f, -0.15464056f, 
    0.07889925f, 0.54762030f, -0.06257248f, -0.11294408f, 0.73983109f, 0.13496196f, 0.13200612f, 0.07106199f, 
    0.06317915f, -0.01798410f, 0.01848957f, -0.60697061f, -0.07033630f, -0.07448264f, 0.68939757f, -0.08281809f, 
    0.00793772f, -0.39793816f, 0.11828910f, -0.12529907f, 0.41418928f, 0.06657037f, -0.01593157f, -0.01309652f, 
    -0.77431685f, 0.26614341f, 0.56551135f, 0.56944758f, -0.27184239f, -0.29284397f, -0.73872852f, 0.13547185f, 
    0.06003608f, -0.72440743f, 0.06622846f, -0.17581841f, -0.10315000f, -0.07511868f, 0.03165501f, -0.04254665f, 
    -0.04000292f, 0.69467509f, -0.32765898f, -0.31594694f, 0.06156730f, 0.06739998f, -0.23387831f, 0.07968159f, 
    -0.05794925f, -0.40573716f, -0.50594157f, 0.91733909f, 0.02316560f, -0.09474401f, -0.16563357f, 0.15756138f, 
    -0.01918483f, 0.08492332f, -0.11901310f, -0.15139231f, 0.20290239f, 0.21634218f, -0.40207547f, 0.12156373f, 
    -0.12978105f, -0.20751575f, -0.15243535f, -0.01944530f, -0.64663875f, -0.00725688f, -0.00620781f, -0.13715971f, 
    0.17158826f, -0.32735851f, 0.51442486f, -0.08633548f, -0.09689292f, -0.00817922f, -0.73953784f, 0.01622078f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.17039424f, -0.05492961f, -0.17986189f, 0.04501558f, -0.06954793f, 0.11177367f, -0.04890068f, -0.42001861f, 
    -0.16232216f, 0.08086549f, -0.02712947f, 0.00800165f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
